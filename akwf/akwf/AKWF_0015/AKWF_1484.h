#define DATA_LENGTH 512
#define DATA AKWF_1484

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 8, 12, 17, 23, 30, 37, 45,
53, 61, 69, 77, 84, 92, 98, 104, 108, 112, 115, 118, 119, 120, 119, 117, 117,
116, 113, 109, 107, 103, 100, 96, 93, 89, 86, 82, 79, 75, 71, 68, 65, 62, 59,
56, 54, 52, 49, 47, 45, 42, 41, 40, 38, 37, 35, 34, 33, 32, 31, 32, 29, 29, 28,
29, 28, 28, 27, 27, 27, 27, 26, 27, 26, 26, 26, 26, 26, 26, 26, 26, 25, 26, 26,
25, 25, 26, 26, 26, 25, 26, 26, 26, 26, 25, 25, 25, 25, 26, 24, 25, 25, 25, 24,
24, 24, 25, 24, 24, 23, 24, 23, 23, 23, 23, 22, 22, 22, 21, 23, 21, 21, 22, 21,
21, 20, 21, 21, 20, 20, 19, 20, 19, 18, 19, 19, 18, 18, 18, 18, 18, 17, 17, 18,
16, 17, 17, 16, 16, 16, 16, 16, 16, 15, 15, 15, 15, 15, 14, 15, 14, 13, 14, 14,
13, 14, 14, 13, 12, 13, 13, 13, 12, 12, 12, 11, 12, 11, 11, 12, 11, 11, 11, 10,
10, 11, 10, 11, 10, 10, 10, 10, 9, 9, 8, 9, 9, 9, 9, 8, 9, 9, 8, 8, 8, 8, 7, 7,
7, 7, 7, 6, 7, 6, 6, 6, 6, 6, 5, 6, 6, 5, 5, 6, 5, 5, 5, 5, 5, 5, 5, 5, 5, 4, 5,
4, 4, 4, 4, 3, 4, 4, 3, 3, 3, 3, 3, 2, 3, 3, 2, 2, 2, 2, 2, 2, 1, 1, 1, -1, -3,
-7, -10, -16, -20, -26, -32, -39, -46, -53, -61, -68, -74, -80, -84, -90, -94,
-98, -100, -103, -104, -104, -105, -104, -103, -102, -101, -99, -96, -95, -91,
-89, -86, -84, -79, -77, -75, -71, -68, -66, -64, -61, -59, -57, -55, -53, -50,
-49, -48, -46, -44, -43, -42, -41, -39, -38, -38, -37, -36, -35, -35, -34, -33,
-33, -32, -32, -31, -32, -31, -31, -31, -31, -31, -32, -31, -30, -30, -30, -30,
-31, -30, -29, -30, -30, -30, -29, -30, -30, -30, -29, -29, -29, -29, -29, -28,
-28, -28, -29, -29, -28, -28, -27, -28, -27, -27, -27, -27, -27, -26, -26, -26,
-26, -25, -25, -25, -25, -24, -25, -24, -23, -24, -23, -23, -23, -23, -23, -22,
-22, -21, -22, -21, -22, -21, -21, -20, -20, -21, -20, -20, -20, -19, -18, -19,
-19, -19, -18, -18, -18, -17, -17, -17, -17, -17, -17, -15, -17, -16, -15, -16,
-16, -15, -15, -15, -14, -14, -14, -14, -14, -13, -14, -14, -13, -14, -13, -13,
-12, -12, -13, -12, -12, -12, -12, -11, -11, -11, -10, -10, -10, -10, -10, -10,
-10, -9, -9, -9, -10, -9, -9, -8, -9, -8, -8, -9, -8, -7, -8, -8, -8, -8, -6,
-7, -7, -6, -6, -6, -6, -6, -5, -6, -6, -5, -4, -5, -6, -5, -5, -4, -5, -5, -5,
-4, -4, -4, -3, -4, -4, -4, -3, -4, -3, -3, -3, -2, -3, -2, -2, -3, -2, -1, -1,
-1, };