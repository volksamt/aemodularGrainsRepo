#define DATA_LENGTH 512
#define DATA AKWF_1447

const PROGMEM int8_t DATA[DATA_LENGTH] = {18, 79, 120, 118, 119, 119, 120, 119,
120, 119, 119, 119, 119, 118, 119, 120, 118, 120, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 120, 119,
120, 119, 119, 120, 119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 120, 118, 119, 118, 119, 120, 119, 119, 119, 119, 119, 119, 120, 120,
119, 120, 119, 119, 119, 119, 120, 119, 119, 120, 118, 118, 119, 119, 119, 119,
119, 119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 118, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 120, 118, 119, 119, 119, 120, 119, 120, 118, 120,
119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 119,
119, 120, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 120, 119, 120, 119, 120, 119, 119, 118, 119, 118, 119, 118, 119,
119, 119, 120, 119, 119, 119, 119, 118, 120, 119, 118, 119, 119, 119, 119, 118,
119, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 119, 118, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 118, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 118,
121, 110, 66, -11, -87, -119, -120, -119, -120, -119, -119, -120, -120, -119,
-119, -118, -119, -119, -118, -119, -120, -119, -118, -120, -119, -120, -119,
-119, -119, -119, -120, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-118, -120, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -120, -119, -119, -120, -119, -119, -119,
-120, -119, -119, -119, -120, -119, -119, -119, -120, -118, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -118, -119, -119, -119, -120, -119, -120,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -118, -120, -118, -120, -119, -118, -119, -119, -119, -119, -119,
-119, -118, -120, -120, -119, -119, -119, -119, -119, -120, -120, -119, -118,
-119, -119, -119, -119, -118, -118, -119, -119, -119, -119, -119, -118, -118,
-119, -119, -119, -119, -119, -119, -120, -119, -120, -119, -119, -119, -118,
-118, -119, -118, -119, -120, -118, -119, -119, -119, -119, -119, -120, -120,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -118, -118, -119, -119, -119, -119, -119, -119, -118, -119,
-118, -119, -118, -120, -119, -118, -119, -119, -118, -119, -119, -119, -119,
-118, -118, -119, -118, -118, -120, -119, -117, -62, -5, };