#define DATA_LENGTH 512
#define DATA AKWF_1498

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 9, 11, 14, 15, 18, 21, 23,
25, 27, 30, 32, 34, 36, 38, 40, 43, 45, 47, 49, 50, 53, 55, 57, 58, 60, 62, 63,
65, 66, 67, 68, 69, 70, 72, 72, 73, 74, 75, 76, 76, 77, 77, 78, 79, 79, 79, 80,
80, 80, 82, 81, 82, 82, 82, 83, 83, 83, 82, 82, 82, 81, 81, 81, 80, 79, 79, 78,
78, 76, 76, 75, 75, 73, 72, 72, 71, 71, 70, 70, 69, 68, 68, 67, 67, 66, 67, 66,
66, 65, 64, 65, 64, 64, 64, 63, 62, 63, 62, 62, 62, 63, 63, 62, 62, 62, 62, 63,
62, 63, 63, 63, 63, 64, 65, 64, 64, 66, 66, 66, 67, 67, 68, 68, 68, 68, 69, 69,
69, 70, 69, 70, 69, 69, 69, 68, 67, 67, 67, 66, 65, 64, 64, 63, 62, 60, 59, 58,
57, 56, 54, 53, 52, 51, 49, 47, 45, 43, 41, 39, 37, 35, 34, 32, 29, 27, 24, 22,
21, 18, 16, 14, 11, 9, 6, 4, 2, -2, -3, -5, -8, -10, -13, -15, -17, -19, -21,
-22, -25, -27, -27, -30, -30, -32, -34, -35, -37, -37, -38, -39, -41, -42, -42,
-42, -44, -44, -46, -46, -47, -47, -47, -49, -50, -50, -50, -51, -51, -52, -51,
-51, -51, -51, -51, -51, -51, -51, -50, -51, -50, -49, -49, -47, -47, -47, -46,
-45, -45, -44, -43, -42, -41, -41, -40, -39, -38, -37, -37, -36, -35, -34, -32,
-31, -29, -28, -27, -25, -24, -22, -20, -20, -17, -16, -14, -12, -10, -9, -7,
-5, -3, -1, 1, 3, 5, 7, 10, 11, 13, 14, 16, 18, 19, 21, 22, 24, 25, 26, 28, 30,
30, 31, 32, 33, 34, 35, 36, 36, 36, 37, 38, 39, 39, 39, 40, 41, 41, 41, 42, 43,
43, 44, 44, 45, 45, 45, 46, 46, 46, 48, 47, 48, 49, 49, 49, 48, 49, 49, 48, 47,
48, 47, 46, 47, 46, 45, 45, 44, 43, 42, 41, 40, 39, 38, 38, 36, 35, 32, 32, 31,
29, 27, 25, 25, 23, 21, 20, 18, 17, 15, 13, 13, 11, 10, 7, 7, 5, 3, 3, 1, -1,
-2, -4, -6, -7, -8, -11, -13, -15, -16, -18, -20, -22, -25, -26, -28, -30, -32,
-35, -37, -38, -41, -44, -46, -48, -50, -52, -54, -57, -59, -62, -64, -65, -67,
-69, -71, -73, -76, -77, -79, -81, -81, -84, -86, -86, -88, -89, -90, -92, -92,
-94, -94, -95, -98, -99, -99, -100, -101, -102, -103, -104, -105, -107, -107,
-108, -109, -110, -111, -112, -113, -114, -115, -115, -115, -116, -117, -117,
-118, -118, -119, -119, -120, -119, -119, -119, -118, -118, -118, -117, -116,
-116, -114, -114, -113, -111, -111, -109, -107, -106, -104, -103, -101, -100,
-97, -96, -94, -93, -90, -88, -86, -84, -81, -79, -77, -75, -72, -70, -68, -64,
-62, -60, -57, -54, -51, -48, -45, -42, -39, -37, -33, -31, -28, -24, -21, -19,
-16, -13, -11, -8, -5, -2, -1, };