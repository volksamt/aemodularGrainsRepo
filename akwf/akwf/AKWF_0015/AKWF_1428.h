#define DATA_LENGTH 512
#define DATA AKWF_1428

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 11, 18, 24, 29, 32, 35, 40, 42, 46,
49, 51, 54, 56, 59, 60, 61, 62, 65, 67, 69, 69, 71, 72, 72, 74, 76, 76, 77, 78,
78, 78, 78, 78, 78, 78, 77, 75, 76, 75, 74, 73, 72, 71, 70, 70, 70, 69, 69, 68,
69, 70, 71, 70, 72, 73, 74, 74, 76, 77, 79, 79, 81, 82, 84, 85, 86, 86, 87, 87,
88, 89, 88, 89, 89, 89, 88, 89, 88, 89, 88, 88, 87, 88, 87, 87, 86, 85, 86, 85,
86, 85, 85, 85, 85, 85, 86, 86, 85, 85, 87, 86, 86, 88, 87, 86, 82, 74, 71, 70,
67, 62, 55, 51, 48, 46, 43, 42, 41, 38, 36, 34, 32, 31, 28, 25, 22, 16, 12, 7,
3, -1, -3, -5, -7, -9, -11, -14, -15, -17, -17, -18, -19, -19, -20, -21, -22,
-23, -23, -23, -25, -25, -26, -26, -26, -26, -27, -27, -28, -27, -27, -27, -27,
-27, -27, -26, -26, -25, -24, -24, -24, -23, -23, -23, -22, -23, -23, -24, -23,
-23, -24, -25, -25, -26, -27, -28, -28, -29, -30, -31, -31, -31, -33, -33, -33,
-34, -35, -34, -34, -34, -34, -35, -36, -35, -35, -34, -34, -34, -35, -34, -33,
-33, -34, -33, -33, -34, -32, -33, -33, -33, -33, -33, -33, -33, -33, -33, -34,
-33, -34, -34, -34, -34, -34, -35, -34, -30, -26, -25, -23, -21, -17, -15, -12,
-9, -8, -7, -7, -6, -4, -3, -2, -2, 0, 1, 4, 7, 10, 12, 15, 18, 19, 21, 22, 23,
25, 25, 27, 28, 29, 29, 30, 30, 30, 31, 30, 31, 32, 31, 33, 32, 33, 32, 33, 33,
34, 34, 34, 34, 33, 33, 33, 33, 32, 33, 32, 32, 32, 31, 24, 16, 14, 12, 8, 3,
-3, -8, -10, -13, -14, -16, -17, -19, -20, -23, -23, -25, -28, -30, -33, -37,
-41, -45, -49, -52, -54, -57, -58, -61, -62, -64, -65, -67, -67, -68, -69, -70,
-70, -71, -71, -74, -74, -74, -75, -75, -75, -76, -77, -77, -77, -77, -78, -77,
-77, -78, -77, -76, -76, -75, -74, -73, -73, -73, -71, -61, -52, -50, -46, -41,
-34, -28, -21, -18, -15, -14, -11, -10, -9, -7, -5, -4, -2, 0, 5, 10, 14, 19,
25, 29, 31, 34, 37, 40, 42, 44, 46, 49, 50, 51, 52, 55, 54, 56, 56, 58, 59, 60,
61, 61, 62, 62, 64, 64, 65, 65, 65, 65, 64, 64, 63, 63, 62, 62, 61, 60, 59, 59,
46, 34, 30, 26, 20, 11, 2, -7, -12, -16, -18, -20, -22, -25, -27, -30, -32, -34,
-37, -42, -48, -54, -60, -66, -71, -77, -80, -84, -87, -90, -93, -95, -97, -100,
-101, -103, -104, -106, -107, -108, -109, -111, -113, -113, -114, -115, -116,
-116, -117, -118, -118, -119, -119, -118, -118, -119, -117, -116, -116, -115,
-113, -112, -112, -110, -108, -93, -83, -79, -74, -68, -58, -49, -41, -36, -33,
-31, -28, -26, -24, -21, -19, -18, -15, -11, -7, -1, };