#define DATA_LENGTH 512
#define DATA AKWF_1480

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 7, 10, 12, 15, 17, 20, 21, 22,
24, 25, 26, 28, 27, 29, 29, 29, 30, 29, 30, 29, 29, 30, 29, 28, 28, 27, 28, 27,
27, 26, 26, 26, 26, 26, 26, 25, 25, 25, 26, 25, 25, 25, 26, 26, 26, 25, 26, 27,
28, 28, 29, 29, 30, 31, 31, 33, 33, 34, 35, 35, 37, 37, 39, 40, 40, 40, 41, 42,
42, 43, 44, 43, 44, 44, 45, 45, 46, 46, 46, 46, 46, 46, 46, 46, 46, 46, 45, 45,
45, 45, 44, 44, 43, 43, 42, 43, 41, 41, 40, 40, 39, 38, 37, 38, 37, 36, 35, 34,
33, 32, 32, 32, 31, 30, 29, 28, 28, 26, 27, 26, 24, 24, 23, 23, 22, 21, 21, 20,
20, 19, 19, 18, 17, 17, 16, 17, 16, 15, 15, 14, 13, 13, 13, 11, 11, 11, 11, 10,
10, 9, 8, 8, 7, 7, 7, 6, 6, 5, 5, 4, 3, 3, 3, 2, 2, 2, 0, 0, 0, 0, -1, -1, -1,
-3, -2, -4, -3, -4, -5, -5, -5, -6, -6, -6, -7, -7, -7, -7, -7, -8, -9, -9, -9,
-10, -9, -9, -10, -10, -10, -11, -10, -12, -10, -11, -11, -11, -12, -11, -11,
-12, -12, -11, -11, -11, -13, -11, -12, -11, -12, -11, -12, -12, -12, -12, -11,
-12, -11, -11, -11, -12, -11, -11, -11, -11, -10, -11, -11, -10, -10, -10, -10,
-10, -9, -10, -10, -9, -9, -9, -9, -8, -8, -8, -8, -7, -7, -8, -8, -7, -6, -6,
-6, -6, -6, -6, -6, -5, -5, -4, -5, -5, -4, -4, -4, -3, -3, -3, -3, -3, -3, -3,
-3, -2, -2, -2, -2, -2, -1, -1, 0, 0, -1, 0, 0, 1, 0, 1, 0, 1, 1, 1, 2, 2, 2, 2,
3, 2, 2, 3, 2, 3, 3, 4, 3, 3, 3, 5, 5, 4, 4, 4, 4, 5, 5, 5, 5, 5, 5, 6, 5, 5, 5,
5, 6, 6, 6, 6, 5, 6, 6, 6, 7, 6, 6, 6, 7, 6, 6, 6, 6, 6, 6, 7, 7, 6, 5, 6, 6, 6,
6, 5, 6, 6, 6, 6, 6, 6, 6, 7, 6, 6, 5, 6, 6, 6, 5, 5, 5, 6, 5, 5, 4, 5, 5, 5, 5,
5, 5, 5, 4, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 3, 3, 3, 3, 3, 3, 2, 2, 3, 2,
2, 2, 2, 2, 2, 2, 1, 1, 1, 1, 2, 2, 1, 1, 1, 0, 1, 0, 1, 0, 1, 1, 0, -1, 0, -1,
0, -1, -1, 0, -1, -1, 0, -1, -1, -2, -3, -5, -7, -10, -13, -17, -22, -26, -32,
-37, -43, -50, -55, -61, -67, -73, -78, -83, -90, -94, -98, -102, -106, -110,
-112, -115, -117, -117, -119, -119, -119, -118, -118, -116, -114, -112, -109,
-107, -104, -101, -97, -93, -88, -85, -79, -74, -69, -65, -60, -54, -51, -46,
-40, -35, -31, -27, -22, -18, -13, -9, -6, -2, };