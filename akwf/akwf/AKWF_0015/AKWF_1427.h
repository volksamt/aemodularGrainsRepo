#define DATA_LENGTH 512
#define DATA AKWF_1427

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 5, 8, 10, 12, 13, 16, 17, 19,
21, 23, 24, 27, 29, 30, 32, 34, 35, 35, 37, 39, 39, 39, 40, 41, 41, 41, 41, 42,
42, 43, 42, 43, 42, 44, 44, 44, 44, 45, 46, 47, 48, 48, 49, 50, 53, 53, 54, 56,
57, 59, 60, 61, 61, 63, 65, 65, 65, 67, 67, 68, 68, 69, 69, 70, 70, 70, 71, 72,
72, 72, 72, 72, 73, 74, 74, 74, 74, 75, 75, 75, 77, 77, 77, 78, 78, 79, 79, 80,
80, 80, 81, 81, 82, 83, 84, 83, 84, 84, 85, 86, 86, 86, 87, 87, 88, 88, 88, 89,
89, 89, 90, 91, 90, 91, 91, 91, 92, 92, 92, 92, 92, 93, 93, 93, 93, 94, 94, 94,
94, 95, 95, 95, 96, 96, 96, 96, 97, 97, 97, 97, 98, 97, 98, 98, 99, 100, 99,
100, 100, 101, 100, 100, 101, 101, 100, 101, 101, 101, 102, 102, 102, 101, 103,
102, 102, 103, 103, 103, 103, 103, 103, 103, 104, 103, 103, 103, 104, 104, 104,
103, 105, 104, 104, 104, 105, 104, 104, 105, 105, 105, 105, 106, 104, 105, 105,
105, 106, 106, 106, 106, 106, 106, 106, 105, 106, 106, 105, 106, 105, 106, 106,
107, 102, 90, 84, 81, 77, 71, 64, 57, 50, 46, 44, 42, 39, 36, 34, 30, 29, 26,
23, 19, 15, 9, 2, -5, -11, -15, -18, -21, -26, -28, -31, -33, -35, -37, -39,
-40, -42, -43, -44, -44, -46, -47, -47, -49, -49, -50, -51, -51, -53, -53, -53,
-55, -54, -55, -55, -55, -54, -54, -54, -53, -52, -53, -51, -51, -51, -51, -50,
-50, -50, -50, -50, -50, -50, -50, -52, -53, -53, -55, -55, -56, -57, -58, -60,
-61, -61, -63, -64, -64, -64, -65, -66, -67, -67, -68, -68, -68, -68, -67, -67,
-69, -68, -67, -68, -68, -68, -68, -67, -67, -66, -67, -67, -68, -66, -67, -67,
-67, -68, -68, -69, -69, -69, -69, -69, -70, -71, -71, -72, -72, -72, -72, -72,
-72, -73, -74, -74, -74, -74, -74, -74, -74, -74, -75, -75, -75, -75, -75, -75,
-76, -76, -75, -75, -76, -76, -76, -75, -76, -76, -76, -76, -76, -77, -77, -76,
-76, -77, -77, -78, -78, -77, -78, -77, -78, -78, -78, -78, -78, -79, -79, -79,
-80, -78, -80, -79, -79, -80, -79, -80, -80, -80, -80, -80, -80, -80, -80, -81,
-81, -80, -80, -81, -81, -81, -80, -81, -81, -80, -81, -81, -81, -80, -81, -81,
-82, -82, -82, -81, -81, -81, -82, -82, -82, -81, -82, -82, -81, -82, -82, -82,
-82, -82, -82, -81, -82, -82, -81, -82, -82, -82, -82, -83, -82, -83, -82, -83,
-82, -82, -82, -82, -82, -82, -82, -82, -82, -83, -82, -83, -82, -100, -118,
-100, -94, -97, -102, -105, -103, -98, -89, -84, -80, -78, -75, -73, -70, -68,
-66, -66, -67, -68, -69, -69, -67, -62, -58, -51, -47, -43, -38, -35, -32, -28,
-24, -20, -16, -13, -10, -8, -5, -3, -2, };