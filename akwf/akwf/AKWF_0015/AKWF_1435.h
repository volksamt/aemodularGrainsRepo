#define DATA_LENGTH 512
#define DATA AKWF_1435

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 3, 4, 5, 7, 8, 9, 10, 11, 11,
12, 14, 15, 16, 18, 20, 20, 21, 22, 23, 24, 27, 27, 29, 30, 31, 33, 35, 36, 37,
38, 40, 41, 43, 43, 45, 46, 48, 49, 50, 52, 53, 55, 56, 57, 59, 61, 61, 63, 64,
65, 67, 69, 69, 71, 72, 74, 76, 77, 79, 80, 81, 82, 84, 85, 86, 87, 88, 90, 91,
93, 93, 94, 96, 96, 98, 99, 99, 101, 103, 103, 104, 106, 106, 107, 108, 108,
110, 111, 110, 111, 113, 113, 114, 115, 115, 115, 117, 117, 117, 117, 118, 117,
118, 119, 119, 119, 119, 119, 119, 118, 119, 120, 119, 119, 118, 119, 119, 118,
118, 117, 117, 116, 116, 116, 114, 113, 114, 112, 113, 112, 111, 110, 110, 108,
107, 107, 106, 105, 104, 103, 102, 101, 98, 98, 97, 95, 94, 92, 91, 90, 89, 87,
86, 85, 84, 82, 80, 79, 78, 76, 73, 72, 71, 69, 67, 65, 64, 61, 60, 58, 56, 54,
53, 52, 50, 48, 46, 45, 43, 40, 39, 38, 36, 33, 32, 30, 29, 28, 26, 23, 22, 21,
19, 17, 15, 14, 13, 11, 10, 7, 7, 4, 4, 3, 2, 0, -2, -2, -4, -5, -6, -8, -8, -9,
-11, -10, -12, -12, -14, -14, -15, -16, -17, -17, -17, -17, -17, -16, -18, -22,
-26, -26, -26, -27, -26, -27, -28, -28, -28, -29, -31, -30, -31, -32, -31, -33,
-35, -32, -19, -7, -11, -20, -23, -24, -23, -22, -21, -21, -22, -20, -20, -20,
-20, -20, -20, -19, -19, -19, -19, -19, -19, -19, -19, -19, -20, -20, -19, -20,
-22, -22, -22, -22, -23, -24, -24, -24, -25, -25, -26, -28, -29, -28, -30, -31,
-32, -32, -34, -36, -36, -37, -39, -40, -42, -43, -44, -46, -47, -48, -50, -52,
-54, -56, -57, -58, -61, -62, -64, -65, -68, -70, -72, -73, -75, -78, -81, -82,
-84, -87, -89, -90, -92, -99, -96, -75, -52, -52, -71, -83, -84, -83, -84, -83,
-83, -83, -83, -83, -84, -85, -85, -84, -85, -85, -85, -86, -85, -84, -84, -84,
-85, -86, -86, -87, -87, -88, -87, -89, -89, -89, -90, -90, -90, -92, -91, -93,
-93, -93, -95, -94, -94, -95, -95, -95, -95, -95, -95, -96, -95, -95, -95, -94,
-95, -95, -94, -94, -94, -93, -93, -93, -93, -92, -92, -90, -90, -89, -88, -88,
-86, -86, -85, -84, -83, -82, -81, -79, -78, -77, -76, -74, -72, -71, -69, -68,
-66, -64, -63, -61, -58, -56, -54, -53, -50, -48, -45, -44, -41, -38, -37, -32,
-28, -33, -48, -58, -56, -46, -43, -41, -40, -39, -39, -38, -38, -37, -37, -36,
-36, -36, -36, -36, -34, -34, -33, -33, -33, -32, -32, -32, -31, -30, -30, -29,
-29, -29, -28, -27, -26, -26, -25, -25, -25, -24, -23, -22, -21, -21, -21, -20,
-19, -17, -17, -17, -16, -15, -15, -14, -13, -12, -11, -10, -9, -9, -8, -7, -6,
-5, -4, -4, -2, -2, -1, };