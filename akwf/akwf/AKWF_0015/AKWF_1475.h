#define DATA_LENGTH 512
#define DATA AKWF_1475

const PROGMEM int8_t DATA[DATA_LENGTH] = {36, 67, 64, 66, 64, 65, 64, 64, 63,
63, 63, 63, 61, 62, 62, 61, 61, 60, 61, 60, 60, 60, 60, 60, 59, 58, 59, 58, 57,
57, 56, 57, 56, 55, 56, 56, 56, 55, 55, 55, 53, 55, 54, 54, 53, 54, 53, 52, 52,
52, 52, 52, 51, 51, 51, 51, 51, 50, 49, 50, 50, 49, 49, 48, 48, 48, 47, 47, 47,
47, 47, 46, 46, 46, 46, 46, 45, 45, 45, 45, 44, 45, 44, 43, 43, 43, 43, 43, 42,
43, 42, 42, 41, 41, 41, 41, 40, 41, 41, 40, 39, 39, 39, 39, 39, 40, 39, 39, 39,
38, 41, 59, 85, 94, 94, 92, 92, 92, 91, 91, 90, 90, 89, 88, 88, 88, 87, 87, 86,
85, 85, 85, 84, 83, 84, 83, 82, 82, 81, 81, 80, 79, 80, 79, 78, 78, 77, 77, 76,
76, 76, 75, 76, 74, 73, 73, 73, 73, 72, 72, 71, 71, 70, 69, 70, 69, 69, 68, 68,
67, 67, 66, 66, 66, 65, 64, 64, 64, 64, 64, 62, 63, 62, 61, 60, 61, 60, 59, 59,
59, 59, 57, 58, 57, 57, 57, 57, 56, 56, 55, 55, 54, 55, 55, 53, 53, 52, 52, 52,
51, 52, 51, 52, 51, 50, 50, 50, 50, 49, 49, 49, 48, 47, 47, 47, 46, 47, 46, 45,
44, 45, 45, 44, 43, 44, 44, 43, 43, 42, 41, 43, 41, 41, 41, 40, 41, 40, 40, 40,
39, 39, 38, 39, 38, 37, 37, 37, 37, 37, 36, 36, 36, 36, 35, 34, 35, 35, 34, 33,
34, 34, 33, 32, 32, 32, 31, 31, 31, 30, 30, 30, 30, 30, 30, 30, 29, 29, 29, 28,
28, 29, 29, 28, 28, 27, 27, 27, 27, 26, 26, 26, 26, 20, -17, -68, -88, -86, -86,
-86, -85, -85, -84, -85, -84, -83, -83, -82, -83, -81, -80, -81, -81, -79, -80,
-78, -78, -78, -77, -78, -76, -76, -76, -76, -75, -74, -75, -75, -74, -73, -73,
-73, -72, -72, -72, -72, -71, -70, -70, -69, -69, -68, -69, -69, -68, -67, -66,
-67, -66, -66, -66, -66, -65, -64, -64, -63, -63, -67, -86, -110, -120, -118,
-117, -117, -116, -116, -114, -113, -114, -113, -113, -111, -112, -110, -110,
-108, -107, -108, -107, -107, -106, -105, -104, -104, -103, -103, -101, -102,
-100, -99, -99, -99, -98, -98, -97, -97, -96, -95, -95, -94, -93, -93, -93, -91,
-92, -91, -90, -89, -90, -89, -88, -87, -88, -86, -86, -86, -85, -84, -83, -83,
-82, -82, -82, -81, -81, -80, -79, -79, -79, -78, -77, -77, -76, -77, -77, -75,
-75, -74, -74, -73, -74, -72, -72, -72, -71, -70, -70, -69, -69, -69, -68, -68,
-67, -67, -66, -65, -65, -66, -64, -64, -63, -62, -63, -62, -62, -62, -61, -61,
-60, -60, -60, -60, -58, -58, -58, -57, -56, -56, -56, -56, -56, -55, -54, -55,
-54, -53, -53, -53, -52, -52, -52, -51, -51, -50, -51, -50, -49, -48, -49, -47,
-49, -39, -5, };