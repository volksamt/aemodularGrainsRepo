#define DATA_LENGTH 512
#define DATA AKWF_1489

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 2, 2, 3, 4, 5, 6, 6, 8, 9,
10, 12, 13, 14, 17, 17, 19, 21, 21, 23, 23, 25, 25, 27, 27, 28, 29, 30, 31, 31,
32, 33, 33, 34, 34, 35, 36, 36, 36, 37, 36, 37, 37, 38, 38, 39, 38, 39, 38, 39,
39, 40, 41, 40, 40, 41, 41, 42, 40, 41, 42, 41, 42, 42, 43, 43, 45, 45, 46, 46,
46, 47, 48, 49, 50, 52, 52, 53, 55, 55, 56, 56, 58, 59, 60, 62, 63, 64, 66, 66,
67, 69, 71, 71, 73, 74, 75, 76, 77, 77, 78, 79, 80, 80, 80, 81, 81, 82, 82, 83,
82, 83, 84, 84, 84, 85, 86, 87, 88, 88, 89, 90, 91, 92, 94, 96, 97, 97, 99, 101,
102, 104, 106, 108, 108, 109, 110, 112, 112, 114, 115, 116, 116, 116, 117, 117,
118, 117, 119, 119, 119, 119, 118, 119, 119, 118, 119, 120, 119, 119, 118, 118,
118, 118, 118, 117, 117, 116, 115, 115, 114, 114, 114, 112, 112, 111, 110, 110,
109, 108, 107, 107, 107, 107, 106, 106, 105, 105, 106, 105, 105, 105, 106, 105,
104, 104, 103, 104, 103, 103, 103, 103, 102, 102, 101, 101, 101, 100, 99, 98,
98, 97, 96, 96, 96, 94, 94, 92, 92, 91, 89, 88, 86, 85, 83, 83, 81, 79, 77, 75,
74, 71, 70, 68, 65, 63, 60, 58, 55, 52, 49, 46, 41, 38, 34, 31, 27, 24, 20, 17,
13, 8, 5, 1, -1, -6, -10, -13, -17, -20, -24, -28, -31, -35, -39, -42, -47, -50,
-52, -55, -58, -60, -63, -65, -67, -69, -71, -73, -76, -77, -79, -81, -83, -84,
-86, -87, -88, -89, -91, -92, -93, -94, -94, -95, -97, -97, -97, -98, -99, -100,
-100, -101, -101, -101, -102, -102, -102, -102, -104, -103, -104, -105, -104,
-105, -104, -105, -105, -105, -105, -105, -105, -105, -106, -107, -107, -106,
-107, -108, -109, -109, -110, -110, -111, -112, -112, -113, -114, -115, -116,
-116, -116, -116, -117, -118, -117, -118, -118, -119, -119, -118, -119, -118,
-119, -119, -119, -120, -119, -119, -118, -119, -118, -118, -118, -118, -117,
-116, -115, -114, -113, -113, -112, -111, -110, -109, -107, -106, -104, -103,
-101, -99, -97, -97, -95, -93, -93, -91, -90, -89, -88, -87, -86, -86, -86, -85,
-85, -84, -83, -83, -83, -82, -82, -81, -81, -80, -80, -80, -78, -78, -78, -77,
-76, -75, -74, -73, -71, -71, -69, -68, -66, -65, -64, -63, -61, -60, -59, -58,
-57, -55, -55, -53, -52, -52, -52, -51, -50, -48, -47, -47, -47, -45, -45, -44,
-43, -43, -42, -42, -42, -41, -41, -40, -40, -41, -41, -41, -40, -40, -40, -39,
-39, -38, -39, -38, -38, -37, -38, -37, -37, -36, -37, -36, -35, -36, -35, -35,
-34, -33, -32, -32, -32, -31, -30, -29, -28, -27, -27, -25, -24, -24, -22, -22,
-20, -19, -18, -17, -15, -13, -12, -11, -9, -8, -7, -6, -5, -5, -4, -2, -2, -1,
-1, -1, };