#define DATA_LENGTH 512
#define DATA AKWF_1438

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 2, 2, 3, 4, 4, 5, 5, 6, 6, 7,
7, 7, 9, 9, 10, 11, 11, 12, 13, 12, 13, 14, 13, 9, 7, 12, 16, 17, 18, 19, 18,
20, 20, 21, 21, 22, 24, 23, 25, 25, 26, 26, 27, 28, 28, 29, 29, 30, 31, 31, 32,
33, 33, 34, 35, 36, 36, 36, 37, 38, 38, 39, 39, 40, 41, 41, 43, 43, 44, 45, 44,
45, 46, 47, 47, 48, 48, 50, 50, 50, 51, 52, 52, 53, 54, 55, 54, 55, 56, 58, 57,
58, 59, 60, 60, 61, 61, 63, 63, 63, 63, 65, 66, 66, 66, 67, 68, 69, 69, 70, 70,
71, 72, 71, 71, 71, 71, 71, 71, 72, 71, 70, 71, 70, 71, 70, 71, 71, 71, 71, 70,
71, 71, 71, 71, 71, 71, 70, 71, 71, 71, 71, 71, 71, 71, 71, 71, 71, 71, 70, 70,
71, 71, 71, 71, 70, 71, 71, 69, 71, 70, 70, 70, 70, 71, 71, 70, 72, 70, 70, 71,
71, 69, 70, 70, 70, 71, 69, 69, 71, 68, 70, 71, 68, 71, 71, 67, 72, 69, 66, 75,
68, 66, 83, 50, -18, -32, -15, -22, -25, -18, -23, -22, -20, -24, -22, -20, -23,
-22, -21, -23, -22, -22, -23, -21, -22, -23, -21, -22, -22, -22, -22, -22, -22,
-22, -21, -22, -23, -21, -22, -22, -21, -22, -22, -22, -21, -22, -22, -22, -22,
-22, -22, -22, -21, -22, -21, -22, -21, -22, -22, -22, -22, -21, -22, -22, -22,
-22, -22, -22, -22, -22, -22, -22, -22, -22, -22, -22, -22, -21, -22, -22, -21,
-22, -22, -22, -22, -23, -22, -22, -22, -22, -21, -22, -21, -21, -22, -22, -21,
-22, -22, -22, -22, -23, -22, -22, -23, -23, -22, -23, -22, -23, -23, -22, -22,
-23, -22, -22, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -24, -24,
-24, -24, -24, -24, -24, -24, -23, -23, -23, -25, -24, -24, -24, -24, -23, -25,
-24, -23, -25, -24, -25, -25, -24, -25, -24, -23, -24, -25, -24, -26, -24, -24,
-25, -25, -24, -26, -24, -25, -27, -22, -26, -30, -16, -34, -96, -120, -96, -80,
-81, -78, -79, -79, -77, -77, -78, -75, -76, -74, -74, -75, -73, -72, -73, -71,
-71, -71, -69, -70, -69, -67, -67, -67, -67, -66, -65, -64, -64, -63, -62, -62,
-61, -61, -60, -59, -59, -59, -58, -58, -57, -56, -56, -56, -55, -54, -53, -53,
-53, -52, -52, -50, -50, -50, -49, -48, -48, -47, -47, -46, -45, -45, -44, -43,
-43, -42, -42, -41, -41, -40, -40, -39, -38, -38, -38, -36, -36, -36, -35, -34,
-34, -33, -32, -33, -32, -31, -31, -31, -30, -29, -28, -28, -28, -27, -26, -26,
-26, -24, -23, -23, -22, -23, -22, -22, -20, -20, -20, -19, -18, -17, -16, -16,
-16, -15, -15, -14, -14, -13, -12, -12, -12, -10, -10, -10, -9, -9, -8, -8, -7,
-7, -6, -5, -5, -4, -4, -3, -3, -2, -2, -1, 0, };