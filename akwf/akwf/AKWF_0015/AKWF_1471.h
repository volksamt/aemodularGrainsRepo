#define DATA_LENGTH 512
#define DATA AKWF_1471

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 2, 3, 2, 3, 3, 3, 3, 4, 4, 4,
5, 5, 5, 6, 7, 6, 6, 7, 8, 8, 8, 8, 9, 8, 9, 9, 10, 10, 10, 11, 11, 11, 11, 11,
12, 13, 12, 12, 13, 12, 13, 14, 13, 14, 15, 15, 15, 15, 15, 15, 15, 16, 16, 16,
16, 16, 16, 17, 17, 17, 17, 17, 17, 17, 17, 19, 18, 17, 18, 18, 19, 19, 19, 19,
20, 18, 19, 19, 19, 19, 21, 20, 20, 21, 21, 21, 21, 20, 21, 21, 21, 21, 20, 21,
21, 21, 21, 22, 21, 22, 22, 22, 22, 22, 22, 23, 23, 22, 22, 22, 22, 22, 22, 22,
22, 23, 23, 22, 22, 23, 23, 23, 23, 23, 23, 22, 23, 22, 23, 23, 23, 23, 23, 24,
23, 23, 23, 23, 24, 23, 23, 23, 23, 24, 24, 24, 23, 24, 23, 23, 23, 23, 23, 24,
24, 23, 23, 23, 24, 24, 23, 24, 24, 23, 23, 23, 23, 23, 23, 24, 23, 23, 23, 23,
23, 23, 23, 23, 23, 23, 23, 23, 23, 22, 24, 23, 23, 23, 22, 23, 23, 24, 23, 23,
22, 23, 22, 23, 22, 22, 23, 22, 22, 23, 22, 22, 22, 22, 22, 23, 22, 21, 22, 21,
22, 22, 22, 22, 22, 21, 21, 21, 22, 21, 21, 21, 21, 21, 22, 21, 21, 21, 21, 21,
22, 21, 21, 21, 21, 20, 20, 21, 20, 20, 20, 20, 20, 20, 19, 20, 20, 19, 19, 20,
20, 20, 19, 19, 19, 19, 20, 20, 18, 18, 18, 19, 19, 19, 19, 18, 19, 18, 18, 18,
18, 18, 18, 18, 18, 18, 18, 18, 17, 17, 17, 17, 17, 18, 18, 17, 17, 17, 17, 17,
17, 17, 17, 17, 17, 17, 16, 16, 16, 16, 16, 16, 16, 16, 15, 15, 15, 16, 15, 15,
16, 15, 14, 14, 15, 14, 15, 15, 14, 14, 14, 14, 14, 14, 15, 15, 14, 14, 14, 14,
14, 14, 14, 13, 14, 13, 14, 14, 13, 14, 13, 13, 12, 14, 12, 13, 12, 12, 12, 12,
12, 13, 13, 13, 12, 12, 11, 12, 12, 12, 11, 11, 13, 11, 11, 11, 12, 9, 13, 7,
18, -17, -62, -50, -72, -86, -96, -104, -109, -114, -116, -118, -118, -119,
-119, -118, -117, -117, -115, -114, -111, -111, -108, -107, -104, -102, -101,
-98, -97, -96, -94, -92, -90, -88, -87, -85, -84, -82, -80, -79, -77, -75, -75,
-72, -71, -70, -68, -67, -66, -65, -63, -62, -61, -59, -58, -57, -56, -55, -54,
-53, -51, -51, -49, -47, -46, -46, -44, -44, -43, -41, -41, -40, -39, -38, -38,
-37, -35, -35, -34, -33, -32, -30, -30, -30, -29, -28, -27, -26, -27, -25, -24,
-24, -23, -23, -21, -20, -19, -20, -19, -18, -18, -17, -16, -15, -15, -15, -14,
-13, -12, -12, -11, -10, -10, -10, -10, -9, -8, -8, -7, -7, -6, -6, -6, -5, -5,
-4, -4, -2, -3, -2, -2, -1, -1, 0, 0, };