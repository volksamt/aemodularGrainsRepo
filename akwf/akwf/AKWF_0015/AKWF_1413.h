#define DATA_LENGTH 512
#define DATA AKWF_1413

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 3, 5, 5, 8, 8, 10, 10, 12,
12, 14, 16, 17, 18, 19, 20, 22, 22, 24, 25, 26, 28, 29, 30, 31, 32, 34, 35, 35,
37, 37, 39, 41, 42, 43, 44, 45, 47, 47, 48, 50, 51, 51, 53, 54, 55, 56, 58, 59,
60, 61, 61, 62, 64, 65, 67, 68, 69, 70, 71, 72, 73, 74, 75, 76, 77, 78, 80, 80,
81, 83, 84, 85, 86, 86, 87, 88, 90, 91, 91, 92, 93, 94, 95, 96, 97, 98, 99, 101,
101, 102, 103, 104, 105, 106, 107, 108, 108, 109, 110, 110, 112, 112, 114, 114,
115, 117, 117, 117, 119, 119, 116, 112, 105, 97, 90, 84, 76, 70, 63, 56, 50, 45,
39, 35, 30, 26, 21, 17, 13, 10, 7, 5, 1, 0, -2, -4, -6, -7, -8, -9, -10, -10,
-12, -12, -12, -12, -13, -13, -12, -12, -12, -12, -11, -11, -10, -10, -9, -8,
-8, -8, -6, -5, -4, -3, -2, -2, -1, 1, 1, 2, 4, 5, 6, 6, 9, 10, 11, 11, 13, 14,
15, 16, 18, 19, 20, 21, 22, 24, 25, 25, 27, 28, 29, 31, 31, 32, 34, 35, 37, 37,
39, 40, 40, 42, 44, 45, 45, 46, 48, 49, 50, 50, 53, 54, 54, 55, 57, 58, 60, 60,
61, 62, 63, 64, 66, 67, 69, 70, 70, 71, 72, 73, 75, 75, 77, 77, 79, 79, 77, 72,
65, 59, 51, 43, 36, 28, 21, 14, 9, 3, -2, -8, -12, -18, -21, -26, -29, -33, -36,
-40, -42, -44, -47, -48, -50, -53, -54, -55, -56, -57, -58, -59, -60, -60, -60,
-60, -60, -60, -60, -60, -59, -59, -59, -58, -58, -58, -56, -56, -55, -55, -54,
-53, -53, -51, -50, -50, -49, -47, -47, -46, -44, -42, -42, -42, -40, -38, -38,
-36, -35, -34, -34, -32, -31, -30, -28, -27, -26, -25, -23, -22, -22, -20, -19,
-18, -17, -15, -14, -14, -12, -10, -9, -9, -7, -7, -5, -4, -2, -1, -1, 1, 2, 4,
5, 6, 7, 9, 10, 11, 11, 14, 14, 15, 17, 18, 19, 20, 21, 23, 24, 25, 26, 26, 28,
29, 31, 31, 29, 24, 18, 12, 4, -2, -10, -17, -23, -29, -35, -39, -44, -49, -53,
-56, -61, -65, -68, -72, -75, -78, -81, -83, -86, -88, -90, -92, -93, -95, -95,
-96, -98, -98, -99, -101, -101, -100, -101, -100, -102, -102, -101, -101, -100,
-100, -100, -99, -99, -99, -98, -98, -97, -97, -96, -95, -95, -93, -93, -92,
-91, -89, -88, -88, -86, -87, -86, -84, -84, -82, -82, -80, -80, -78, -78, -76,
-76, -75, -73, -72, -71, -71, -70, -69, -67, -66, -65, -64, -63, -62, -61, -60,
-58, -58, -57, -55, -55, -53, -52, -50, -50, -49, -47, -47, -45, -44, -43, -42,
-40, -39, -38, -37, -36, -35, -34, -33, -32, -31, -29, -28, -27, -26, -25, -24,
-23, -21, -20, -19, -17, -17, -15, -14, -13, -11, -10, -9, -8, -7, -6, -4, -3,
-2, -1, };