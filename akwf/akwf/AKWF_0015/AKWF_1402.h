#define DATA_LENGTH 512
#define DATA AKWF_1402

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 6, 7, 9, 10, 11, 12, 14,
14, 15, 16, 17, 18, 19, 21, 22, 23, 23, 25, 25, 27, 28, 28, 29, 29, 31, 30, 32,
33, 33, 33, 34, 35, 35, 36, 36, 37, 37, 39, 38, 39, 40, 39, 40, 40, 40, 40, 41,
41, 41, 41, 41, 42, 42, 42, 41, 41, 42, 41, 41, 42, 42, 41, 41, 42, 41, 42, 42,
41, 42, 42, 42, 41, 42, 42, 42, 42, 42, 41, 42, 42, 42, 42, 41, 42, 42, 42, 42,
41, 42, 41, 42, 42, 42, 42, 42, 42, 42, 42, 42, 42, 42, 42, 42, 41, 42, 42, 42,
41, 42, 42, 42, 41, 42, 42, 43, 42, 42, 43, 42, 42, 42, 42, 42, 42, 42, 42, 42,
43, 42, 42, 42, 43, 42, 42, 42, 42, 42, 43, 43, 42, 42, 43, 41, 42, 42, 42, 41,
42, 42, 42, 42, 42, 42, 42, 42, 42, 43, 43, 42, 43, 43, 42, 42, 43, 43, 42, 43,
42, 42, 42, 43, 43, 42, 42, 43, 42, 42, 42, 42, 43, 42, 41, 43, 42, 42, 42, 42,
42, 42, 42, 42, 42, 42, 42, 41, 43, 42, 43, 43, 43, 42, 41, 42, 42, 42, 42, 42,
42, 43, 42, 42, 43, 42, 42, 42, 43, 42, 42, 43, 42, 42, 43, 42, 42, 43, 43, 42,
42, 42, 43, 42, 43, 41, 42, 41, 42, 42, 42, 42, 42, 43, 42, 42, 42, 43, 42, 42,
42, 42, 42, 42, 42, 42, 42, 42, 43, 42, 42, 42, 42, 43, 42, 42, 41, 42, 42, 42,
43, 41, 43, 40, 37, 35, 33, 33, 30, 28, 27, 26, 24, 22, 21, 20, 19, 18, 16, 15,
13, 12, 11, 10, 9, 7, 7, 6, 4, 3, 2, 1, 0, -1, -1, -2, -2, -4, -4, -6, -7, -8,
-9, -9, -10, -11, -12, -12, -14, -14, -15, -16, -16, -17, -18, -19, -19, -20,
-21, -22, -22, -22, -22, -24, -25, -25, -25, -27, -28, -27, -28, -29, -29, -30,
-31, -30, -32, -32, -32, -32, -33, -33, -34, -34, -34, -36, -36, -36, -37, -38,
-37, -39, -38, -39, -38, -40, -39, -40, -40, -42, -41, -41, -42, -42, -42, -42,
-43, -43, -43, -44, -44, -43, -44, -44, -44, -45, -45, -44, -46, -46, -46, -45,
-47, -45, -46, -45, -48, -46, -47, -46, -47, -46, -47, -45, -46, -111, -122,
-115, -121, -116, -119, -116, -118, -115, -116, -114, -116, -114, -115, -113,
-113, -112, -111, -110, -109, -109, -107, -106, -105, -104, -103, -102, -100,
-99, -97, -96, -94, -92, -90, -89, -88, -87, -86, -84, -82, -81, -80, -77, -77,
-75, -74, -74, -72, -71, -70, -68, -69, -67, -65, -65, -64, -63, -63, -62, -62,
-60, -60, -59, -58, -57, -58, -57, -57, -56, -56, -55, -55, -55, -54, -54, -54,
-54, -54, -54, -54, -53, -50, -45, -43, -39, -37, -34, -32, -31, -28, -26, -25,
-22, -20, -19, -18, -15, -14, -12, -10, -8, -7, -5, -4, -2, -1, };