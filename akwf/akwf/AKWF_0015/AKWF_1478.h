#define DATA_LENGTH 512
#define DATA AKWF_1478

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 5, 7, 9, 11, 13, 14, 15, 17,
19, 20, 23, 23, 25, 27, 28, 30, 31, 32, 34, 35, 36, 38, 38, 40, 41, 42, 43, 44,
46, 47, 48, 48, 50, 50, 51, 51, 53, 54, 54, 55, 55, 56, 57, 57, 59, 59, 59, 60,
60, 61, 61, 62, 62, 62, 64, 63, 63, 63, 63, 64, 64, 64, 64, 64, 64, 65, 64, 64,
63, 64, 64, 64, 64, 63, 63, 62, 62, 62, 61, 62, 61, 60, 61, 59, 60, 59, 58, 57,
57, 57, 56, 56, 55, 54, 54, 54, 52, 51, 51, 50, 49, 49, 49, 47, 47, 47, 46, 45,
44, 44, 43, 42, 41, 40, 40, 39, 39, 37, 36, 35, 35, 34, 33, 31, 32, 30, 30, 29,
28, 27, 26, 26, 25, 24, 23, 22, 21, 21, 19, 19, 18, 18, 17, 17, 15, 14, 14, 13,
13, 12, 11, 10, 10, 9, 9, 8, 7, 7, 5, 5, 4, 4, 4, 2, 3, 1, 1, 0, 0, 0, -2, -1,
-1, -2, -3, -3, -4, -4, -4, -5, -5, -6, -6, -7, -7, -7, -8, -8, -8, -8, -9, -9,
-9, -10, -10, -10, -10, -10, -11, -10, -11, -11, -11, -11, -11, -11, -11, -10,
-11, -11, -11, -11, -11, -10, -11, -11, -11, -12, -11, -12, -12, -12, -11, -11,
-10, -11, -11, -10, -10, -11, -11, -9, -10, -9, -10, -9, -9, -9, -10, -9, -9,
-8, -8, -8, -8, -7, -8, -8, -7, -7, -6, -6, -5, -5, -6, -5, -5, -5, -5, -4, -3,
-4, -3, -3, -3, -3, -2, -2, -1, -2, -2, -1, -1, 0, 0, -1, 0, -1, 0, 0, 1, 2, 1,
2, 1, 2, 3, 2, 3, 2, 3, 3, 3, 5, 4, 5, 4, 4, 5, 5, 5, 5, 5, 6, 6, 6, 6, 6, 6, 7,
7, 8, 7, 7, 7, 7, 8, 7, 8, 7, 8, 8, 8, 8, 9, 9, 9, 9, 8, 9, 9, 9, 9, 9, 9, 9, 8,
9, 8, 9, 9, 9, 9, 10, 9, 9, 9, 9, 9, 8, 9, 9, 9, 8, 8, 9, 9, 9, 8, 8, 8, 9, 8,
8, 8, 7, 8, 7, 7, 7, 8, 7, 7, 7, 7, 7, 7, 6, 7, 6, 6, 5, 6, 6, 5, 6, 6, 6, 5, 6,
5, 5, 4, 4, 5, 5, 4, 4, 4, 4, 4, 4, 3, 4, 3, 0, -8, -19, -26, -34, -40, -45,
-48, -51, -54, -58, -59, -63, -67, -71, -75, -79, -83, -87, -90, -95, -98, -100,
-104, -109, -111, -115, -119, -119, -114, -108, -103, -99, -97, -96, -96, -96,
-96, -97, -97, -97, -97, -95, -94, -94, -92, -91, -90, -89, -89, -87, -87, -87,
-85, -83, -82, -81, -81, -79, -77, -75, -75, -74, -71, -69, -68, -67, -66, -64,
-62, -61, -59, -57, -55, -53, -51, -50, -48, -46, -45, -43, -40, -40, -37, -36,
-33, -32, -30, -29, -26, -25, -23, -21, -18, -17, -16, -13, -11, -10, -8, -7,
-4, -2, -1, };