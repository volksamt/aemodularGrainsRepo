#define DATA_LENGTH 512
#define DATA AKWF_1449

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 39, 43, 33, 28, 31, 34, 36, 37, 38,
39, 40, 55, 90, 115, 112, 103, 101, 105, 106, 106, 106, 106, 94, 58, 34, 41, 43,
41, 44, 44, 46, 46, 44, 44, 47, 46, 46, 46, 44, 44, 43, 42, 40, 40, 38, 37, 36,
33, 33, 32, 33, 33, 34, 34, 35, 36, 37, 37, 38, 38, 39, 40, 40, 41, 42, 42, 47,
74, 108, 118, 110, 101, 103, 107, 107, 109, 109, 111, 110, 111, 111, 111, 112,
112, 112, 113, 112, 113, 114, 113, 113, 114, 114, 115, 115, 114, 115, 114, 114,
114, 113, 115, 115, 115, 115, 115, 114, 113, 113, 112, 111, 110, 109, 107, 104,
101, 98, 97, 98, 99, 98, 99, 99, 100, 100, 100, 100, 100, 102, 101, 101, 102,
102, 102, 101, 101, 101, 101, 100, 101, 100, 99, 99, 99, 98, 98, 97, 96, 95, 94,
94, 93, 92, 91, 90, 89, 88, 88, 86, 85, 84, 84, 82, 82, 80, 79, 80, 79, 79, 80,
81, 83, 83, 85, 86, 87, 88, 90, 90, 90, 90, 87, 82, 77, 72, 70, 71, 70, 70, 72,
71, 71, 71, 70, 67, 67, 66, 65, 64, 63, 61, 59, 58, 56, 55, 53, 51, 49, 47, 45,
43, 41, 38, 37, 35, 32, 31, 28, 26, 24, 21, 19, 17, 15, 13, 10, 9, 7, 4, 3, 0,
-1, -3, -4, -6, -7, -8, -8, -4, -1, 0, 1, 2, 4, 7, 9, 10, 11, 10, 8, -1, -12,
-19, -24, -23, -22, -21, -19, -17, -15, -14, -14, -17, -18, -16, -16, -16, -16,
-16, -17, -17, -18, -18, -19, -21, -21, -22, -23, -24, -25, -26, -28, -29, -30,
-32, -32, -33, -35, -36, -36, -37, -38, -39, -39, -41, -42, -42, -44, -45, -46,
-48, -49, -50, -51, -51, -50, -45, -42, -40, -41, -39, -38, -36, -34, -34, -33,
-33, -35, -42, -47, -52, -58, -60, -58, -56, -54, -52, -48, -46, -47, -53, -58,
-56, -54, -54, -54, -54, -53, -54, -56, -57, -58, -58, -60, -60, -61, -62, -64,
-64, -66, -67, -68, -69, -71, -73, -74, -75, -74, -75, -77, -77, -78, -79, -80,
-82, -83, -85, -86, -89, -91, -94, -96, -99, -99, -94, -87, -85, -87, -90, -90,
-91, -90, -90, -91, -90, -92, -88, -72, -57, -55, -59, -61, -60, -57, -57, -56,
-55, -57, -72, -87, -86, -83, -85, -83, -84, -83, -82, -84, -83, -84, -83, -83,
-83, -83, -83, -84, -84, -84, -84, -84, -84, -84, -84, -84, -84, -83, -83, -83,
-82, -81, -81, -82, -82, -83, -84, -86, -88, -91, -94, -98, -101, -101, -94,
-76, -68, -71, -77, -77, -74, -74, -74, -73, -74, -73, -68, -43, -8, 3, -6, -12,
-11, -6, -6, -7, -6, -9, -33, -68, -74, -66, -67, -65, -62, -61, -58, -57, -57,
-56, -54, -52, -50, -49, -48, -46, -45, -44, -43, -41, -41, -40, -38, -37, -36,
-33, -32, -30, -28, -25, -24, -22, -21, -21, -21, -21, -22, -25, -25, -28, -29,
-31, -17, };