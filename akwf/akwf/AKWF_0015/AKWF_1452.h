#define DATA_LENGTH 512
#define DATA AKWF_1452

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 12, 16, 24, 28, 34, 40, 46, 51, 55,
61, 65, 68, 73, 77, 80, 85, 90, 93, 96, 100, 103, 106, 109, 110, 113, 115, 116,
118, 117, 118, 119, 118, 119, 119, 118, 118, 116, 115, 114, 113, 110, 108, 107,
105, 103, 101, 99, 96, 95, 94, 91, 90, 87, 87, 86, 84, 84, 83, 81, 81, 79, 79,
77, 75, 74, 72, 71, 70, 67, 64, 61, 59, 56, 52, 49, 46, 42, 38, 34, 31, 28, 25,
23, 20, 17, 14, 11, 8, 3, -3, -7, -10, -14, -15, -17, -19, -20, -21, -21, -22,
-21, -21, -20, -19, -19, -17, -16, -14, -11, -9, -7, -4, 1, 4, 5, 5, 6, 6, 5, 4,
1, -2, -5, -7, -10, -13, -17, -21, -24, -27, -31, -35, -38, -41, -44, -46, -49,
-51, -54, -57, -59, -62, -64, -66, -69, -70, -73, -76, -77, -78, -80, -81, -83,
-84, -85, -87, -87, -89, -91, -91, -92, -93, -94, -94, -95, -96, -95, -96, -95,
-95, -95, -95, -94, -94, -96, -95, -95, -96, -96, -97, -98, -98, -98, -98, -96,
-97, -96, -96, -95, -94, -93, -92, -91, -90, -88, -87, -85, -84, -82, -79, -77,
-75, -71, -67, -64, -60, -58, -53, -48, -43, -40, -35, -31, -26, -22, -17, -12,
-6, 5, 11, 15, 19, 22, 26, 29, 32, 35, 39, 41, 43, 45, 47, 48, 50, 51, 53, 55,
55, 58, 59, 59, 59, 60, 60, 61, 62, 61, 64, 63, 65, 66, 68, 70, 73, 74, 75, 78,
80, 83, 84, 86, 88, 90, 92, 93, 94, 95, 95, 96, 96, 96, 95, 95, 95, 95, 95, 95,
95, 94, 95, 94, 95, 94, 94, 95, 95, 96, 96, 95, 96, 96, 96, 96, 96, 96, 96, 96,
95, 94, 93, 93, 91, 90, 88, 88, 85, 84, 83, 81, 80, 78, 77, 76, 74, 74, 72, 72,
71, 71, 70, 68, 68, 67, 65, 65, 63, 63, 60, 60, 57, 55, 53, 51, 48, 46, 44, 40,
37, 34, 31, 29, 25, 22, 18, 15, 11, 7, 2, -5, -8, -11, -15, -19, -22, -24, -27,
-29, -32, -34, -37, -39, -42, -45, -47, -50, -51, -53, -54, -56, -58, -58, -61,
-62, -63, -64, -66, -67, -69, -71, -73, -73, -75, -77, -79, -80, -83, -84, -86,
-88, -88, -88, -89, -91, -91, -91, -90, -90, -88, -88, -87, -86, -86, -85, -84,
-84, -83, -83, -83, -82, -83, -83, -84, -83, -84, -84, -83, -82, -80, -80, -78,
-78, -77, -75, -74, -73, -72, -70, -71, -70, -69, -68, -67, -66, -66, -67, -66,
-65, -66, -65, -66, -66, -66, -67, -68, -67, -66, -66, -64, -62, -59, -58, -56,
-54, -51, -49, -47, -43, -41, -38, -37, -35, -35, -34, -33, -33, -34, -36, -37,
-38, -41, -43, -46, -47, -49, -50, -50, -51, -51, -51, -51, -51, -50, -48, -49,
-49, -48, -47, -46, -47, -47, -47, -47, -47, -46, -46, -46, -45, -44, -44, -43,
-41, -40, -38, -35, -33, -30, -26, -22, -17, -12, -3, };