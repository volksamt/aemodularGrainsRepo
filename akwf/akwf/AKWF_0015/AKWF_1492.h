#define DATA_LENGTH 512
#define DATA AKWF_1492

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 4, 4, 5, 5, 7, 6, 6, 7, 8,
8, 8, 8, 8, 8, 9, 10, 10, 11, 12, 12, 13, 14, 14, 16, 16, 18, 19, 20, 21, 22,
24, 25, 26, 27, 29, 31, 33, 34, 36, 38, 40, 41, 43, 46, 47, 49, 52, 54, 56, 58,
60, 63, 65, 66, 69, 70, 72, 74, 76, 79, 80, 81, 83, 85, 85, 87, 88, 89, 91, 91,
92, 93, 94, 94, 95, 94, 95, 96, 96, 97, 97, 97, 98, 98, 98, 99, 100, 100, 100,
100, 101, 101, 102, 103, 103, 103, 104, 104, 105, 106, 107, 107, 107, 108, 108,
109, 109, 109, 109, 110, 109, 110, 110, 110, 110, 110, 110, 111, 111, 111, 111,
112, 111, 112, 112, 113, 114, 114, 114, 114, 114, 115, 116, 115, 116, 116, 116,
117, 117, 118, 116, 117, 117, 117, 117, 118, 117, 116, 117, 116, 116, 117, 116,
116, 116, 116, 116, 116, 116, 117, 116, 116, 117, 117, 117, 117, 117, 116, 117,
115, 115, 115, 115, 114, 114, 112, 111, 110, 109, 109, 107, 105, 104, 103, 100,
99, 97, 96, 94, 91, 89, 87, 86, 83, 81, 80, 78, 76, 74, 73, 70, 69, 67, 66, 65,
63, 62, 61, 59, 58, 57, 54, 54, 52, 52, 51, 49, 50, 48, 46, 47, 45, 45, 44, 44,
44, 44, 43, 43, 43, 42, 42, 41, 41, 41, 40, 39, 38, 38, 38, 37, 36, 35, 34, 33,
31, 30, 30, 27, 27, 25, 23, 21, 19, 18, 16, 13, 11, 10, 8, 5, 2, 0, -3, -6, -7,
-10, -13, -15, -18, -20, -23, -26, -28, -30, -33, -36, -38, -40, -42, -44, -46,
-47, -49, -50, -52, -53, -54, -55, -57, -58, -59, -59, -60, -61, -60, -61, -62,
-63, -63, -63, -63, -63, -64, -64, -65, -66, -66, -67, -67, -68, -67, -69, -69,
-69, -71, -71, -72, -73, -74, -75, -75, -77, -77, -79, -80, -80, -80, -81, -82,
-84, -84, -85, -86, -88, -88, -90, -90, -91, -93, -94, -95, -96, -98, -99, -100,
-101, -102, -104, -105, -107, -107, -109, -109, -111, -111, -112, -113, -114,
-113, -115, -114, -115, -115, -115, -116, -116, -116, -117, -117, -116, -116,
-117, -116, -116, -117, -116, -117, -117, -117, -118, -117, -118, -119, -118,
-119, -120, -120, -119, -119, -118, -119, -118, -119, -119, -118, -118, -117,
-116, -117, -116, -115, -113, -113, -112, -111, -109, -109, -108, -107, -106,
-105, -105, -103, -101, -101, -100, -99, -98, -98, -97, -97, -96, -94, -94, -93,
-93, -93, -92, -91, -90, -90, -89, -89, -89, -88, -87, -87, -87, -86, -85, -85,
-84, -85, -84, -84, -83, -84, -84, -84, -83, -84, -83, -83, -83, -82, -83, -83,
-83, -81, -81, -80, -79, -79, -79, -78, -77, -76, -74, -73, -71, -69, -68, -66,
-65, -63, -61, -59, -58, -55, -53, -50, -48, -45, -43, -41, -39, -36, -34, -32,
-30, -27, -25, -23, -21, -19, -17, -15, -13, -11, -10, -8, -8, -6, -5, -3, -2,
-1, };