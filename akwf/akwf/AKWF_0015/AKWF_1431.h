#define DATA_LENGTH 512
#define DATA AKWF_1431

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 1, 1, 1, 2, 2, 2, 3, 3, 3, 3,
4, 3, 4, 5, 6, 6, 7, 7, 8, 8, 8, 9, 9, 10, 11, 11, 12, 12, 12, 13, 15, 15, 16,
16, 16, 17, 18, 19, 20, 20, 21, 22, 22, 24, 25, 26, 25, 27, 28, 28, 31, 31, 31,
31, 34, 34, 35, 36, 38, 38, 39, 40, 40, 39, 40, 41, 38, 40, 41, 38, 38, 41, 39,
35, 40, 43, 27, 2, -7, 0, 1, -3, -3, 0, -1, -3, -1, 0, -3, -1, -1, -2, -2, -1,
-1, -2, -3, -1, -2, -1, -1, -1, -2, -2, -2, -2, -2, -2, -3, -2, -2, -2, -2, -3,
-2, -3, -2, -2, -2, -2, -2, -2, -2, -1, -2, -3, -2, -2, -2, -3, -2, -2, -2, -2,
-2, -2, -2, -2, -2, -1, -2, -3, -2, -2, -1, -2, -2, -1, -2, -1, -2, -2, -1, -2,
-2, -2, -1, -2, -2, -1, -1, -1, -2, -1, -1, -1, -1, -1, -2, -2, -2, -2, -2, -1,
-1, -2, -1, -1, -1, -2, -2, -1, -1, -2, -2, -2, -2, -1, -1, -1, -2, -2, -2, -2,
-2, -2, -2, -2, -4, -7, -8, -10, -12, -14, -16, -18, -20, -22, -23, -26, -27,
-29, -30, -33, -35, -37, -38, -39, -42, -43, -45, -47, -49, -50, -52, -53, -55,
-56, -58, -60, -61, -62, -65, -66, -68, -69, -70, -72, -74, -75, -76, -78, -79,
-80, -82, -83, -86, -86, -88, -90, -89, -91, -93, -93, -95, -97, -98, -98, -99,
-102, -102, -103, -105, -106, -107, -108, -110, -110, -111, -113, -113, -114,
-117, -118, -116, -118, -118, -113, -110, -113, -109, -103, -106, -108, -96,
-95, -108, -95, -39, 7, 5, -8, -3, 4, -3, -3, 0, 1, -4, 0, 1, -3, -3, 0, -1, -3,
0, 0, -2, -1, -1, -1, -3, 0, -2, -2, -2, -1, -1, -2, -1, -1, -1, -1, -1, -1, -2,
-1, -2, -2, -1, -1, -1, -1, -1, -1, -2, 0, -1, -1, -1, -1, -1, -2, -1, -1, -2,
-2, -1, -2, 0, -2, -1, -1, -1, -1, -1, -2, -1, -1, -1, -1, -1, -2, -1, 0, -1,
-1, -2, -1, -1, -2, -1, -2, -1, -1, -1, -1, -1, -1, -1, -2, -1, -1, -2, -2, -2,
-2, -2, -2, -2, -1, -2, -2, -2, -2, -1, -2, -2, -1, 0, -1, -1, -1, -1, -1, -1,
-2, -1, -2, -1, -1, -1, -1, -1, -2, -1, -1, -2, -1, -2, -1, 0, -2, -1, -1, -1,
-2, -1, 0, -2, -1, -1, -2, -1, -1, -1, -2, -1, -1, -1, -2, -1, -1, -1, -2, -1,
-1, -1, -2, -2, -1, -2, -1, -1, -2, -1, -1, -2, -2, -1, -1, -2, -1, -2, -2, -1,
-1, -2, -1, -2, -2, -2, -2, -1, -1, -1, -2, -1, -1, -1, -1, -1, -1, -2, -1, -2,
-2, -1, -2, -1, -2, -2, -1, -1, -2, -2, -1, -1, -2, -1, -1, -1, -2, 0, 0, -1,
-1, 1, };