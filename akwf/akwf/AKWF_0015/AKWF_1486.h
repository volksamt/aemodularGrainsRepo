#define DATA_LENGTH 512
#define DATA AKWF_1486

const PROGMEM int8_t DATA[DATA_LENGTH] = {-6, -18, -33, -46, -56, -61, -64, -65,
-65, -67, -69, -70, -75, -76, -79, -82, -86, -89, -92, -95, -98, -101, -103,
-105, -107, -111, -113, -114, -117, -119, -119, -114, -105, -92, -79, -70, -66,
-65, -66, -67, -68, -67, -66, -65, -64, -63, -62, -59, -57, -55, -53, -51, -49,
-47, -46, -45, -43, -42, -41, -39, -37, -36, -35, -33, -31, -31, -28, -27, -26,
-24, -22, -21, -20, -18, -16, -16, -14, -13, -11, -10, -8, -7, -6, -5, -4, -2,
-1, -1, 2, 2, 4, 4, 6, 6, 7, 9, 10, 10, 12, 13, 14, 14, 15, 15, 17, 17, 18, 19,
20, 21, 22, 21, 22, 23, 24, 25, 25, 25, 25, 26, 26, 27, 28, 29, 29, 29, 29, 30,
30, 31, 30, 31, 31, 32, 32, 32, 32, 31, 32, 32, 33, 32, 33, 33, 33, 33, 33, 33,
33, 32, 33, 33, 32, 32, 33, 32, 32, 33, 33, 32, 32, 32, 32, 32, 32, 31, 31, 31,
31, 31, 30, 30, 29, 30, 29, 28, 29, 28, 28, 29, 29, 28, 27, 26, 27, 26, 26, 26,
25, 25, 25, 25, 24, 24, 24, 24, 22, 22, 23, 21, 22, 21, 21, 20, 21, 20, 19, 19,
19, 19, 19, 19, 18, 17, 17, 17, 17, 16, 16, 16, 16, 16, 15, 14, 14, 14, 14, 13,
13, 12, 12, 11, 13, 11, 11, 12, 11, 11, 10, 10, 10, 10, 9, 9, 9, 9, 8, 8, 9, 8,
8, 7, 8, 8, 7, 8, 7, 6, 6, 6, 6, 5, 6, 6, 5, 5, 4, 5, 5, 5, 4, 4, 4, 4, 4, 4, 4,
4, 3, 3, 3, 3, 3, 4, 3, 3, 3, 3, 3, 3, 2, 3, 3, 2, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3,
3, 2, 1, 2, 3, 2, 3, 2, 3, 2, 2, 3, 3, 2, 2, 3, 2, 3, 3, 3, 3, 3, 2, 3, 2, 3, 2,
3, 3, 3, 3, 2, 3, 3, 3, 2, 3, 3, 4, 4, 4, 3, 4, 3, 4, 4, 4, 3, 3, 4, 3, 4, 5, 4,
4, 4, 4, 5, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 5, 4, 5, 4, 5, 4, 5, 4, 5, 5, 6, 5, 5,
5, 6, 6, 5, 5, 5, 5, 6, 6, 5, 5, 5, 6, 5, 6, 5, 6, 6, 5, 6, 6, 5, 6, 5, 6, 6, 6,
6, 6, 6, 5, 5, 6, 6, 6, 7, 5, 6, 6, 6, 6, 6, 7, 6, 6, 5, 7, 5, 6, 6, 6, 6, 7, 6,
7, 5, 6, 6, 6, 6, 6, 6, 7, 6, 7, 7, 6, 7, 7, 6, 6, 6, 7, 6, 7, 6, 7, 6, 7, 7, 6,
6, 6, 7, 6, 7, 6, 6, 6, 6, 6, 6, 6, 7, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 5, 6, 6, 6,
6, 6, 5, 5, 7, 6, 7, 6, 6, 5, 6, 6, 6, 6, 5, 6, 6, 4, 0, };