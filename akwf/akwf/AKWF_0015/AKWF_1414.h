#define DATA_LENGTH 512
#define DATA AKWF_1414

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 7, 10, 12, 15, 18, 21, 24, 27,
29, 33, 36, 40, 42, 45, 49, 52, 55, 59, 62, 65, 68, 71, 74, 77, 81, 83, 85, 89,
92, 94, 97, 98, 101, 103, 104, 107, 109, 110, 111, 112, 114, 114, 115, 115, 117,
117, 117, 118, 118, 119, 118, 119, 118, 118, 118, 118, 118, 118, 118, 118, 117,
118, 116, 116, 117, 117, 117, 117, 116, 117, 115, 115, 115, 116, 116, 116, 116,
116, 116, 116, 116, 116, 116, 116, 116, 116, 117, 116, 116, 116, 116, 117, 118,
116, 117, 117, 118, 118, 118, 118, 118, 118, 117, 118, 119, 119, 118, 119, 119,
119, 119, 119, 119, 120, 119, 118, 119, 119, 120, 118, 119, 118, 118, 119, 118,
118, 117, 118, 118, 116, 116, 115, 116, 114, 114, 114, 113, 113, 112, 111, 111,
110, 109, 108, 107, 105, 105, 103, 103, 101, 100, 99, 97, 96, 94, 93, 91, 89,
87, 85, 84, 82, 80, 77, 75, 73, 71, 68, 65, 64, 61, 59, 55, 54, 51, 48, 46, 44,
41, 38, 36, 33, 30, 27, 25, 23, 20, 18, 16, 14, 11, 9, 8, 6, 4, 3, 1, -1, -2,
-5, -6, -9, -10, -12, -15, -16, -18, -20, -22, -24, -26, -28, -30, -32, -34,
-36, -37, -40, -41, -43, -45, -47, -48, -50, -52, -53, -55, -56, -57, -59, -60,
-62, -63, -65, -66, -67, -69, -69, -70, -72, -72, -74, -74, -76, -76, -77, -78,
-78, -79, -80, -81, -81, -81, -82, -84, -83, -84, -84, -85, -86, -86, -86, -87,
-87, -87, -88, -87, -87, -88, -89, -89, -89, -89, -90, -90, -89, -91, -89, -90,
-90, -90, -90, -91, -90, -90, -90, -91, -90, -90, -90, -90, -90, -91, -90, -90,
-91, -90, -90, -90, -90, -89, -89, -89, -89, -90, -88, -88, -89, -89, -88, -87,
-87, -87, -87, -86, -87, -86, -86, -86, -85, -86, -85, -84, -84, -83, -83, -82,
-83, -81, -82, -81, -80, -80, -81, -79, -78, -79, -78, -77, -77, -76, -75, -75,
-75, -74, -74, -73, -72, -72, -71, -71, -71, -70, -70, -69, -69, -68, -68, -67,
-66, -66, -66, -66, -66, -64, -64, -64, -63, -64, -64, -63, -63, -62, -62, -63,
-63, -62, -62, -63, -63, -62, -63, -64, -64, -65, -65, -67, -67, -68, -69, -71,
-72, -73, -74, -76, -78, -79, -82, -83, -84, -87, -89, -90, -92, -94, -95, -97,
-98, -100, -101, -102, -104, -104, -105, -106, -108, -108, -109, -109, -110,
-111, -111, -111, -112, -113, -113, -113, -113, -114, -113, -114, -114, -113,
-113, -114, -114, -113, -114, -113, -113, -112, -112, -112, -112, -112, -111,
-111, -110, -110, -110, -109, -108, -107, -107, -105, -105, -104, -103, -103,
-102, -101, -100, -98, -98, -97, -96, -94, -92, -92, -90, -88, -87, -86, -84,
-82, -81, -78, -77, -75, -73, -70, -70, -66, -64, -62, -60, -58, -55, -52, -50,
-47, -45, -43, -40, -37, -34, -32, -29, -26, -24, -21, -19, -16, -14, -11, -9,
-7, -4, -3, 0, };