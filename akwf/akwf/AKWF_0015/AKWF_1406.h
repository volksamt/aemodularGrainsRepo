#define DATA_LENGTH 512
#define DATA AKWF_1406

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 9, 17, 21, 26, 30, 35, 38, 40, 45,
47, 49, 52, 54, 56, 59, 61, 62, 65, 66, 67, 68, 71, 71, 73, 74, 75, 77, 79, 80,
81, 82, 83, 83, 85, 86, 86, 88, 88, 89, 90, 90, 91, 93, 92, 93, 94, 94, 95, 95,
95, 96, 96, 96, 97, 97, 97, 98, 98, 98, 99, 98, 99, 99, 99, 100, 100, 100, 101,
99, 84, 79, 77, 74, 73, 71, 69, 68, 67, 66, 65, 64, 63, 62, 61, 61, 60, 59, 58,
58, 57, 56, 56, 55, 55, 54, 53, 52, 52, 53, 52, 51, 51, 51, 50, 49, 49, 49, 48,
48, 47, 47, 48, 47, 47, 46, 46, 46, 46, 46, 45, 45, 44, 44, 44, 44, 43, 43, 43,
44, 43, 43, 43, 42, 43, 42, 43, 42, 41, 42, 41, 41, 41, 40, 42, 41, 41, 41, 42,
40, 40, 41, 41, 40, 41, 40, 40, 40, 41, 41, 40, 41, 15, 1, -2, -8, -9, -13, -15,
-18, -19, -23, -22, -25, -26, -27, -30, -31, -32, -33, -34, -35, -36, -37, -39,
-40, -40, -41, -41, -43, -43, -44, -45, -45, -46, -46, -48, -48, -49, -49, -50,
-51, -51, -52, -53, -53, -52, -54, -54, -55, -56, -55, -55, -56, -56, -56, -58,
-57, -58, -59, -59, -59, -59, -59, -59, -61, -61, -60, -60, -61, -60, -62, -61,
-61, -62, -62, -62, -62, -62, -63, -63, -63, -63, -62, -63, -63, -62, -62, -63,
-62, -63, -61, -59, -59, -59, -58, -58, -58, -57, -57, -58, -57, -57, -56, -57,
-56, -57, -56, -57, -56, -55, -56, -56, -56, -56, -56, -56, -55, -55, -55, -55,
-55, -54, -55, -55, -55, -54, -54, -55, -54, -54, -54, -54, -53, -54, -54, -54,
-53, -54, -54, -54, -53, -54, -54, -54, -53, -54, -53, -53, -54, -53, -53, -53,
-53, -53, -54, -53, -54, -52, -54, -52, -54, -52, -54, -52, -53, -53, -53, -52,
-53, -52, -53, -52, -53, -52, -52, -54, -51, -54, -51, -55, -50, -56, -49, -57,
-47, -60, -43, -68, -15, 123, 85, 90, 82, 81, 78, 74, 74, 70, 71, 67, 69, 64,
66, 61, 64, 59, 62, 59, 60, 57, 58, 56, 56, 55, 53, 53, 53, 52, 51, 50, 50, 50,
49, 49, 48, 48, 47, 48, 47, 46, 45, 46, 44, 45, 44, 45, 45, 43, 44, 43, 42, 43,
43, 41, 42, 42, 42, 41, 42, 41, 41, 42, 41, 41, 41, 41, 40, 41, 39, 44, 25, 2,
1, -7, -7, -11, -13, -17, -18, -21, -23, -24, -25, -27, -28, -30, -31, -33, -34,
-34, -35, -37, -38, -39, -39, -40, -41, -42, -43, -42, -44, -45, -45, -47, -47,
-48, -48, -50, -49, -49, -50, -52, -51, -52, -52, -53, -53, -54, -54, -54, -55,
-56, -55, -56, -56, -57, -57, -58, -58, -59, -59, -59, -58, -59, -59, -60, -60,
-61, -61, -61, -61, -61, -61, -61, -62, -61, -62, -62, -63, -61, -63, -61, -62,
-62, -63, -61, -64, -62, -63, -61, -11, };