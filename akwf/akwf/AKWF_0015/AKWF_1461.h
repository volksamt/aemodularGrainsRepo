#define DATA_LENGTH 512
#define DATA AKWF_1461

const PROGMEM int8_t DATA[DATA_LENGTH] = {82, 97, 90, 96, 91, 94, 92, 95, 92,
94, 91, 94, 92, 94, 92, 94, 93, 94, 93, 93, 93, 94, 94, 93, 93, 93, 93, 93, 93,
93, 94, 93, 94, 94, 94, 94, 94, 94, 93, 94, 94, 93, 94, 93, 92, 93, 93, 92, 94,
92, 94, 92, 93, 93, 92, 93, 92, 93, 93, 93, 93, 93, 93, 92, 93, 93, 93, 92, 93,
93, 93, 94, 93, 92, 93, 93, 93, 92, 93, 92, 93, 92, 92, 93, 92, 92, 93, 92, 92,
92, 92, 92, 93, 92, 93, 92, 92, 92, 93, 93, 93, 92, 93, 93, 93, 92, 92, 92, 92,
92, 92, 93, 92, 92, 92, 93, 91, 93, 92, 93, 93, 93, 91, 92, 92, 92, 92, 92, 92,
92, 92, 92, 92, 92, 91, 93, 92, 92, 91, 92, 92, 92, 93, 92, 91, 92, 91, 92, 92,
92, 92, 92, 92, 92, 92, 91, 91, 92, 91, 92, 92, 92, 91, 92, 93, 92, 91, 92, 92,
91, 92, 92, 92, 91, 91, 91, 92, 91, 91, 91, 91, 91, 91, 92, 92, 92, 92, 92, 92,
92, 92, 92, 91, 91, 91, 91, 91, 91, 91, 92, 91, 91, 92, 91, 92, 91, 91, 92, 91,
91, 91, 91, 92, 91, 91, 91, 92, 91, 91, 91, 91, 91, 91, 91, 90, 91, 91, 91, 91,
91, 91, 90, 90, 91, 91, 91, 91, 91, 91, 91, 91, 91, 91, 90, 91, 90, 91, 90, 92,
90, 91, 91, 91, 90, 90, 90, 91, 91, 90, 90, 90, 91, 90, 90, 89, 91, 90, 91, 90,
92, 89, 92, 90, 91, 90, 91, 91, 89, 92, 89, 92, 86, 95, 85, 100, 77, 115, -9,
-128, -105, -127, -113, -123, -116, -121, -118, -120, -119, -119, -120, -119,
-120, -118, -120, -117, -120, -118, -119, -118, -120, -118, -120, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -118, -119, -118, -119, -118, -119,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -119, -119, -119, -118, -118, -118, -119, -118, -118, -118,
-118, -119, -119, -118, -119, -119, -119, -118, -119, -119, -118, -119, -118,
-118, -118, -118, -118, -119, -118, -118, -118, -118, -118, -117, -118, -119,
-118, -118, -118, -119, -118, -118, -118, -118, -119, -118, -118, -118, -118,
-117, -118, -117, -118, -118, -117, -118, -117, -118, -118, -118, -118, -118,
-117, -118, -117, -118, -117, -118, -118, -117, -118, -118, -118, -117, -117,
-117, -118, -117, -117, -118, -117, -117, -117, -117, -117, -118, -118, -117,
-117, -117, -117, -118, -117, -117, -117, -117, -117, -117, -117, -117, -116,
-117, -117, -116, -117, -117, -117, -117, -117, -117, -117, -117, -117, -117,
-117, -116, -117, -117, -117, -117, -117, -117, -117, -116, -117, -116, -117,
-116, -116, -117, -117, -116, -117, -116, -117, -116, -117, -116, -117, -116,
-116, -115, -116, -115, -117, -116, -116, -117, -116, -116, -116, -117, -116,
-117, -115, -118, -116, -117, -115, -118, -114, -118, -114, -119, -113, -120,
-111, -124, -98, };