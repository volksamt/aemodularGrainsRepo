#define DATA_LENGTH 512
#define DATA AKWF_1454

const PROGMEM int8_t DATA[DATA_LENGTH] = {103, 125, 115, 122, 116, 122, 117,
121, 117, 120, 117, 121, 118, 120, 118, 119, 118, 119, 118, 119, 119, 118, 119,
119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 118, 119, 120, 119, 118, 119,
118, 119, 120, 119, 119, 118, 118, 119, 119, 119, 118, 120, 118, 119, 118, 119,
119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 118, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119,
119, 118, 119, 120, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 119,
120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 120, 118, 120,
119, 119, 118, 119, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 118, 120,
119, 119, 119, 120, 118, 119, 119, 119, 120, 118, 119, 119, 119, 119, 120, 119,
119, 119, 120, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 118, 119,
120, 119, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 120, 119, 119,
119, 120, 118, 120, 119, 120, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119,
120, 118, 120, 118, 121, 117, 121, 117, 122, 117, 123, 116, 122, 116, 122, 116,
122, 116, 122, 112, -101, -127, -113, -124, -115, -124, -115, -123, -115, -123,
-116, -121, -116, -121, -117, -120, -118, -119, -118, -119, -120, -119, -120,
-118, -120, -119, -119, -119, -120, -118, -119, -118, -119, -119, -120, -118,
-119, -118, -119, -118, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-120, -119, -119, -119, -120, -119, -119, -119, -120, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -118, -119, -119, -119,
-119, -119, -118, -119, -119, -120, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -120, -119, -119, -119,
-119, -118, -119, -120, -119, -119, -120, -119, -119, -119, -120, -119, -118,
-120, -119, -118, -119, -119, -118, -118, -118, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -118, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -118, -119, -120, -119, -119, -118, -119, -119, -119, -119, -119,
-118, -119, -119, -119, -119, -120, -119, -119, -119, -119, -120, -120, -119,
-118, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -118,
-120, -118, -120, -119, -119, -118, -119, -119, -119, -118, -119, -119, -118,
-120, -119, -120, -118, -120, -118, -120, -118, -121, -116, -122, -116, -122,
-80, };