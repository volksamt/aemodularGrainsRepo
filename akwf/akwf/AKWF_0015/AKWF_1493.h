#define DATA_LENGTH 512
#define DATA AKWF_1493

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 10, 13, 15, 17, 20, 22, 25,
26, 29, 32, 34, 37, 42, 45, 47, 51, 53, 56, 59, 62, 65, 67, 68, 71, 73, 74, 75,
77, 78, 79, 80, 81, 82, 84, 84, 86, 87, 89, 90, 91, 92, 94, 95, 98, 99, 100,
102, 104, 106, 108, 109, 111, 112, 113, 113, 114, 116, 116, 116, 117, 117, 115,
115, 113, 114, 113, 113, 112, 111, 111, 111, 111, 109, 110, 111, 111, 110, 111,
109, 109, 109, 108, 107, 106, 105, 102, 101, 99, 97, 95, 93, 91, 89, 87, 85, 83,
82, 80, 78, 75, 74, 73, 72, 71, 70, 69, 68, 67, 67, 65, 66, 64, 65, 63, 63, 62,
61, 60, 60, 58, 57, 55, 54, 51, 50, 47, 45, 43, 40, 38, 36, 34, 32, 31, 29, 27,
26, 25, 24, 22, 21, 19, 18, 16, 14, 12, 9, 7, 4, 1, 0, -3, -5, -8, -9, -12, -12,
-15, -15, -16, -17, -18, -18, -19, -19, -19, -19, -19, -18, -17, -17, -16, -15,
-14, -13, -11, -9, -7, -5, -4, -2, 2, 4, 6, 9, 12, 15, 18, 21, 23, 24, 27, 28,
29, 32, 32, 34, 34, 37, 37, 38, 39, 42, 43, 46, 46, 49, 50, 53, 56, 57, 60, 62,
64, 65, 66, 68, 69, 69, 71, 71, 71, 71, 71, 71, 71, 70, 69, 69, 68, 66, 65, 64,
63, 61, 58, 56, 54, 52, 50, 46, 43, 40, 37, 33, 31, 26, 24, 19, 15, 11, 8, 6, 2,
-1, -4, -7, -9, -12, -15, -18, -18, -22, -24, -28, -30, -33, -36, -40, -43, -45,
-49, -53, -56, -59, -61, -63, -66, -68, -70, -72, -73, -74, -76, -78, -79, -79,
-80, -82, -83, -85, -86, -87, -88, -91, -92, -93, -95, -96, -99, -101, -102,
-104, -107, -107, -110, -111, -113, -114, -115, -117, -118, -119, -119, -119,
-119, -119, -118, -118, -117, -116, -115, -116, -114, -115, -115, -114, -114,
-115, -115, -114, -115, -115, -114, -114, -114, -114, -114, -112, -111, -110,
-107, -106, -104, -102, -100, -98, -96, -94, -92, -90, -88, -86, -84, -83, -81,
-80, -79, -78, -76, -75, -74, -73, -73, -72, -72, -71, -70, -70, -69, -68, -68,
-67, -66, -64, -63, -61, -60, -58, -55, -54, -51, -49, -46, -44, -41, -39, -37,
-36, -34, -32, -31, -30, -28, -27, -26, -24, -23, -21, -18, -16, -13, -11, -8,
-6, -4, -1, 1, 4, 6, 9, 11, 12, 14, 15, 16, 17, 18, 19, 19, 20, 20, 20, 20, 20,
20, 18, 18, 16, 16, 14, 13, 12, 9, 7, 6, 4, 3, -1, -3, -6, -8, -10, -13, -15,
-18, -21, -23, -24, -25, -26, -28, -29, -31, -31, -32, -34, -35, -36, -38, -40,
-41, -43, -46, -47, -50, -51, -54, -56, -58, -59, -60, -62, -63, -63, -65, -65,
-65, -66, -66, -66, -64, -64, -63, -63, -61, -60, -59, -58, -56, -56, -53, -51,
-49, -46, -44, -41, -39, -37, -32, -29, -26, -22, -19, -15, -11, -8, -5, -1, };