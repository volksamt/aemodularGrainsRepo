#define DATA_LENGTH 512
#define DATA AKWF_1407

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 14, 18, 22, 26, 31, 34, 37,
40, 44, 47, 50, 54, 57, 59, 62, 65, 67, 69, 73, 75, 77, 79, 81, 82, 85, 86, 87,
89, 91, 92, 93, 95, 96, 97, 98, 99, 100, 101, 102, 103, 103, 105, 105, 106, 106,
107, 107, 107, 109, 109, 110, 110, 110, 110, 111, 111, 112, 112, 112, 112, 114,
114, 114, 114, 114, 114, 115, 115, 115, 115, 115, 115, 115, 117, 116, 117, 117,
117, 117, 116, 117, 117, 118, 117, 117, 118, 117, 118, 117, 118, 118, 118, 118,
118, 118, 118, 118, 118, 118, 119, 119, 118, 118, 119, 119, 119, 119, 119, 118,
119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119,
119, 118, 119, 119, 120, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119,
119, 119, 119, 119, 118, 118, 119, 118, 118, 119, 119, 118, 119, 117, 118, 118,
118, 118, 117, 118, 117, 118, 117, 118, 117, 117, 117, 117, 117, 117, 116, 117,
116, 116, 116, 116, 115, 115, 116, 116, 115, 114, 114, 114, 113, 113, 114, 113,
113, 113, 112, 112, 111, 111, 110, 111, 109, 110, 109, 108, 108, 107, 107, 106,
106, 105, 104, 103, 103, 102, 101, 100, 100, 98, 97, 96, 96, 94, 92, 92, 90, 89,
87, 86, 83, 82, 80, 78, 76, 74, 72, 69, 67, 64, 61, 59, 56, 53, 50, 48, 44, 40,
37, 33, 28, 25, 22, 18, 14, 9, 6, 1, -3, -7, -11, -15, -19, -23, -26, -30, -34,
-38, -41, -44, -47, -51, -55, -58, -60, -63, -66, -67, -70, -73, -75, -76, -78,
-81, -83, -84, -86, -88, -89, -91, -93, -93, -94, -95, -96, -98, -99, -99, -102,
-102, -103, -104, -104, -106, -105, -107, -107, -107, -108, -108, -109, -109,
-110, -111, -111, -111, -112, -111, -113, -113, -113, -113, -113, -114, -113,
-114, -115, -114, -115, -115, -115, -115, -116, -116, -116, -116, -117, -116,
-117, -117, -117, -116, -117, -117, -117, -117, -118, -117, -118, -117, -118,
-117, -118, -118, -118, -118, -117, -118, -119, -118, -119, -118, -118, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -120, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -118, -118, -118, -118, -118, -118, -118, -118, -119,
-118, -118, -118, -118, -117, -117, -117, -117, -118, -117, -117, -117, -116,
-117, -116, -117, -116, -116, -115, -117, -116, -116, -116, -116, -115, -114,
-115, -114, -114, -114, -114, -114, -113, -113, -112, -112, -113, -112, -111,
-111, -111, -110, -109, -109, -108, -109, -107, -107, -107, -106, -105, -105,
-104, -104, -103, -102, -102, -101, -100, -98, -97, -96, -95, -94, -92, -91,
-90, -89, -86, -86, -84, -82, -80, -78, -76, -74, -71, -69, -67, -64, -61, -59,
-56, -53, -49, -45, -43, -40, -36, -32, -28, -24, -20, -17, -13, -9, -5, -1, };