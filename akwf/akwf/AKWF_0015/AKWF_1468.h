#define DATA_LENGTH 512
#define DATA AKWF_1468

const PROGMEM int8_t DATA[DATA_LENGTH] = {42, 73, 66, 72, 70, 73, 71, 73, 73,
75, 75, 76, 77, 77, 79, 80, 80, 81, 82, 83, 84, 85, 85, 87, 88, 87, 88, 89, 91,
91, 93, 93, 93, 95, 95, 96, 96, 97, 98, 98, 99, 100, 101, 101, 101, 102, 104,
104, 105, 106, 106, 106, 106, 108, 107, 108, 109, 110, 110, 111, 111, 112, 112,
113, 114, 113, 114, 114, 114, 114, 115, 115, 116, 116, 116, 117, 117, 117, 118,
117, 118, 118, 118, 118, 118, 119, 119, 119, 119, 119, 118, 119, 118, 119, 119,
119, 119, 120, 119, 120, 119, 119, 118, 120, 119, 119, 119, 118, 118, 118, 118,
118, 117, 117, 117, 117, 117, 118, 117, 116, 116, 116, 117, 116, 117, 115, 115,
115, 114, 114, 114, 114, 113, 113, 113, 112, 112, 111, 111, 111, 111, 111, 110,
110, 109, 108, 109, 108, 108, 107, 107, 106, 105, 105, 105, 103, 104, 102, 102,
102, 102, 101, 99, 100, 99, 98, 97, 97, 97, 96, 95, 95, 94, 93, 93, 91, 92, 90,
89, 88, 88, 87, 85, 86, 85, 83, 83, 81, 81, 80, 79, 78, 77, 77, 75, 74, 72, 72,
71, 70, 70, 68, 67, 66, 64, 64, 62, 61, 59, 58, 58, 56, 55, 53, 53, 52, 50, 48,
46, 46, 46, 43, 43, 42, 39, 39, 38, 36, 34, 32, 32, 30, 28, 28, 27, 25, 23, 22,
21, 20, 18, 17, 16, 15, 13, 12, 10, 9, 7, 6, 4, 4, 2, 0, -1, -2, -3, -5, -6, -8,
-10, -10, -12, -14, -15, -17, -18, -18, -21, -22, -23, -24, -26, -28, -29, -29,
-31, -32, -34, -36, -36, -38, -38, -40, -42, -43, -44, -46, -47, -48, -49, -51,
-52, -52, -54, -56, -57, -57, -59, -60, -62, -63, -65, -65, -66, -67, -69, -70,
-70, -72, -73, -75, -76, -76, -76, -79, -80, -81, -82, -82, -82, -85, -86, -85,
-86, -87, -88, -89, -89, -90, -92, -92, -92, -93, -94, -95, -96, -97, -96, -97,
-98, -99, -100, -100, -101, -102, -102, -103, -103, -104, -104, -105, -105,
-105, -107, -106, -107, -107, -108, -108, -108, -109, -110, -109, -110, -111,
-111, -111, -112, -112, -112, -113, -114, -113, -114, -114, -114, -115, -115,
-114, -115, -115, -115, -116, -115, -116, -116, -116, -117, -117, -117, -118,
-117, -118, -118, -118, -118, -118, -118, -119, -119, -118, -118, -118, -118,
-118, -119, -119, -118, -118, -118, -119, -118, -118, -118, -118, -117, -118,
-117, -118, -117, -117, -116, -117, -116, -116, -117, -116, -116, -115, -115,
-115, -114, -114, -115, -113, -113, -112, -113, -112, -112, -111, -111, -111,
-109, -110, -109, -109, -108, -108, -107, -107, -106, -105, -105, -104, -103,
-103, -102, -101, -101, -100, -99, -99, -98, -97, -97, -95, -94, -95, -92, -92,
-92, -91, -89, -89, -88, -87, -87, -86, -84, -85, -83, -82, -82, -80, -79, -79,
-78, -77, -75, -74, -75, -73, -71, -72, -69, -70, -68, -67, -67, -66, -65, -63,
-63, -61, -61, -59, -61, -56, -62, -33, };