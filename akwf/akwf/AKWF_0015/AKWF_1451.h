#define DATA_LENGTH 512
#define DATA AKWF_1451

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 9, 12, 15, 20, 23, 27, 30, 35, 38,
40, 43, 46, 49, 52, 54, 56, 59, 61, 62, 64, 67, 68, 69, 72, 73, 76, 77, 78, 80,
82, 83, 85, 86, 88, 89, 92, 93, 94, 96, 99, 100, 101, 102, 104, 105, 108, 109,
110, 111, 113, 114, 116, 116, 118, 118, 119, 119, 119, 120, 118, 119, 117, 117,
116, 115, 114, 112, 110, 107, 105, 102, 100, 97, 94, 90, 86, 83, 79, 75, 71, 67,
63, 58, 54, 49, 46, 41, 36, 31, 27, 24, 19, 14, 10, 6, 1, -3, -8, -11, -16, -20,
-24, -28, -32, -36, -40, -44, -48, -52, -56, -60, -64, -67, -71, -73, -77, -81,
-84, -87, -90, -93, -96, -98, -100, -102, -104, -105, -106, -108, -109, -110,
-111, -111, -110, -110, -111, -110, -110, -109, -107, -106, -105, -104, -102,
-101, -100, -98, -96, -94, -93, -91, -89, -87, -86, -84, -82, -81, -79, -77,
-76, -74, -72, -70, -69, -67, -66, -64, -62, -62, -59, -58, -57, -55, -52, -51,
-48, -47, -45, -43, -40, -38, -35, -33, -30, -27, -25, -22, -19, -17, -13, -11,
-7, -5, -2, 1, 3, 6, 9, 10, 14, 16, 19, 21, 23, 26, 27, 30, 30, 32, 35, 37, 38,
39, 40, 41, 42, 44, 44, 45, 46, 47, 47, 47, 48, 48, 49, 49, 49, 50, 49, 48, 49,
48, 48, 48, 48, 47, 47, 46, 46, 45, 45, 45, 44, 44, 43, 42, 42, 42, 42, 41, 40,
40, 40, 39, 39, 39, 39, 39, 38, 37, 36, 36, 35, 34, 33, 33, 31, 30, 30, 29, 28,
27, 26, 26, 24, 24, 23, 22, 22, 21, 20, 20, 19, 19, 19, 19, 19, 18, 17, 17, 17,
17, 17, 17, 16, 17, 17, 18, 17, 17, 17, 18, 18, 19, 18, 19, 18, 19, 19, 18, 18,
19, 18, 18, 18, 18, 17, 17, 17, 17, 17, 16, 16, 16, 15, 15, 15, 14, 14, 14, 13,
13, 14, 13, 13, 13, 13, 12, 12, 12, 11, 10, 11, 9, 9, 9, 9, 8, 8, 7, 7, 6, 5, 5,
5, 4, 4, 4, 3, 3, 2, 2, 1, 1, 1, 1, 0, 0, 0, 0, -1, -1, -1, 0, -2, 0, -1, -1,
-1, -2, -2, -1, -1, -1, -2, -1, -1, -1, -1, -1, -2, -2, -1, -2, -2, -3, -3, -4,
-4, -4, -5, -5, -5, -6, -6, -6, -7, -8, -8, -8, -9, -10, -10, -10, -11, -11,
-13, -14, -15, -16, -17, -18, -18, -20, -21, -23, -24, -26, -28, -28, -30, -32,
-34, -36, -37, -40, -41, -43, -46, -47, -49, -51, -52, -53, -56, -56, -58, -59,
-60, -61, -62, -63, -64, -64, -66, -67, -67, -68, -68, -70, -70, -71, -71, -72,
-73, -73, -73, -74, -73, -74, -74, -74, -74, -74, -73, -72, -72, -72, -71, -71,
-70, -69, -68, -67, -66, -64, -64, -63, -62, -60, -58, -57, -54, -52, -50, -49,
-46, -44, -40, -37, -33, -30, -27, -23, -20, -17, -12, -8, -4, 0, };