#define DATA_LENGTH 512
#define DATA AKWF_1434

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 2, 4, 5, 7, 8, 10, 11, 12, 14, 15,
16, 19, 20, 22, 23, 23, 26, 27, 28, 29, 32, 33, 34, 35, 38, 39, 41, 43, 45, 47,
50, 51, 53, 54, 55, 56, 57, 60, 61, 62, 63, 65, 66, 68, 69, 71, 72, 73, 76, 77,
78, 79, 80, 81, 83, 84, 85, 86, 88, 88, 90, 90, 91, 93, 94, 94, 95, 97, 97, 98,
99, 100, 101, 101, 103, 104, 104, 105, 106, 107, 107, 109, 109, 110, 110, 111,
111, 112, 113, 113, 115, 115, 115, 115, 116, 117, 117, 118, 118, 119, 119, 119,
119, 119, 120, 119, 120, 119, 119, 118, 118, 118, 118, 118, 118, 117, 117, 117,
117, 117, 116, 116, 115, 115, 114, 114, 113, 113, 113, 111, 111, 111, 110, 110,
110, 109, 108, 108, 107, 107, 106, 105, 104, 104, 103, 103, 101, 100, 99, 99,
99, 99, 98, 97, 95, 96, 95, 94, 92, 92, 91, 89, 88, 88, 86, 85, 83, 82, 81, 80,
78, 77, 75, 71, 68, 67, 66, 66, 65, 64, 63, 62, 62, 60, 59, 58, 56, 56, 55, 53,
52, 51, 51, 49, 49, 48, 47, 47, 47, 45, 44, 44, 43, 43, 42, 40, 40, 40, 40, 39,
38, 38, 38, 36, 36, 35, 35, 34, 34, 33, 32, 32, 31, 31, 30, 29, 29, 28, 28, 27,
26, 25, 24, 22, 21, 21, 21, 20, 19, 16, 16, 16, 14, 14, 12, 12, 11, 9, 8, 7, 6,
5, 3, 2, -1, -3, -6, -8, -9, -9, -10, -11, -13, -14, -15, -17, -17, -19, -21,
-22, -24, -25, -27, -28, -29, -30, -31, -34, -35, -36, -37, -39, -39, -41, -42,
-43, -44, -45, -47, -48, -49, -50, -51, -53, -54, -55, -55, -57, -58, -60, -60,
-61, -62, -63, -63, -65, -65, -67, -68, -68, -69, -70, -71, -72, -72, -73, -74,
-74, -75, -75, -77, -77, -77, -79, -79, -80, -79, -80, -80, -82, -82, -82, -83,
-83, -84, -83, -83, -83, -85, -85, -85, -86, -85, -86, -85, -86, -86, -86, -87,
-88, -87, -87, -88, -87, -87, -89, -89, -88, -89, -89, -89, -88, -87, -88, -87,
-87, -88, -89, -88, -89, -89, -90, -88, -89, -90, -90, -90, -90, -90, -90, -91,
-91, -91, -91, -91, -91, -92, -92, -93, -93, -93, -93, -93, -94, -93, -95, -95,
-94, -95, -94, -95, -96, -95, -97, -96, -97, -97, -97, -98, -98, -98, -98, -98,
-99, -99, -99, -99, -100, -100, -99, -100, -100, -100, -101, -101, -101, -102,
-101, -101, -101, -101, -101, -101, -101, -101, -101, -101, -101, -101, -100,
-100, -100, -99, -99, -98, -97, -96, -95, -94, -94, -92, -92, -90, -89, -89,
-88, -86, -83, -81, -78, -77, -76, -76, -74, -73, -72, -70, -70, -68, -66, -65,
-63, -62, -60, -59, -58, -56, -54, -53, -51, -49, -47, -46, -44, -43, -40, -37,
-34, -32, -31, -31, -29, -28, -26, -25, -22, -22, -19, -18, -17, -15, -14, -13,
-11, -9, -8, -6, -5, -3, -3, 0, };