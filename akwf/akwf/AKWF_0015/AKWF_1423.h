#define DATA_LENGTH 512
#define DATA AKWF_1423

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 1, 2, 3, 4, 5, 6, 5, 6, 6, 7,
8, 8, 8, 8, 10, 10, 10, 12, 11, 12, 12, 12, 12, 14, 15, 16, 15, 16, 15, 15, 16,
16, 16, 18, 18, 19, 19, 18, 18, 18, 18, 20, 20, 19, 20, 21, 22, 22, 22, 21, 20,
20, 20, 22, 22, 23, 23, 23, 22, 23, 22, 23, 23, 24, 24, 24, 25, 25, 26, 26, 26,
27, 27, 28, 28, 30, 30, 31, 30, 31, 32, 33, 35, 36, 36, 38, 39, 38, 40, 40, 42,
44, 46, 48, 48, 48, 49, 49, 50, 52, 54, 57, 57, 59, 59, 59, 60, 60, 61, 64, 65,
66, 68, 68, 69, 69, 69, 69, 70, 71, 72, 72, 72, 72, 73, 73, 73, 73, 71, 71, 70,
71, 72, 70, 69, 67, 64, 62, 63, 63, 64, 63, 61, 57, 55, 54, 54, 56, 55, 49, 41,
33, 27, 25, 26, 27, 27, 20, 12, 4, -2, -4, -3, -4, -9, -15, -25, -32, -36, -40,
-42, -46, -53, -60, -67, -71, -73, -74, -77, -82, -88, -95, -100, -104, -105,
-105, -105, -108, -111, -114, -116, -119, -119, -118, -118, -118, -119, -120,
-118, -118, -116, -113, -112, -109, -107, -106, -103, -101, -98, -95, -90, -86,
-81, -77, -73, -70, -68, -65, -62, -57, -50, -44, -39, -36, -33, -31, -28, -24,
-20, -16, -12, -9, -6, -4, -1, 0, 3, 5, 6, 8, 10, 11, 13, 13, 13, 14, 14, 14,
14, 14, 13, 13, 13, 11, 10, 9, 8, 7, 5, 5, 3, 1, -1, -2, -4, -5, -8, -9, -12,
-13, -13, -16, -17, -20, -23, -24, -25, -25, -26, -27, -28, -30, -31, -32, -33,
-32, -32, -32, -32, -33, -34, -33, -33, -32, -31, -31, -30, -30, -28, -26, -25,
-23, -23, -21, -19, -17, -16, -14, -12, -11, -9, -7, -5, -3, -1, 1, 3, 4, 5, 9,
10, 13, 14, 15, 15, 17, 19, 19, 21, 22, 23, 23, 24, 24, 24, 25, 26, 27, 26, 27,
25, 26, 25, 25, 26, 25, 24, 23, 22, 22, 21, 20, 19, 18, 17, 16, 15, 14, 12, 12,
10, 8, 6, 5, 5, 5, 5, 4, 3, 0, -1, -2, -4, -3, -4, -3, -5, -7, -7, -8, -8, -9,
-10, -9, -10, -11, -10, -10, -9, -10, -10, -11, -11, -10, -10, -10, -9, -8, -9,
-9, -8, -8, -7, -6, -5, -5, -4, -4, -3, -3, -1, -1, 0, 1, 1, 1, 1, 2, 3, 3, 4,
4, 3, 4, 4, 4, 6, 5, 6, 5, 5, 5, 4, 4, 5, 5, 5, 5, 4, 4, 3, 2, 1, 1, 1, 0, 1, 1,
0, -1, -2, -4, -4, -3, -4, -5, -6, -7, -6, -7, -7, -8, -9, -10, -11, -11, -11,
-10, -11, -11, -12, -13, -14, -13, -14, -13, -12, -12, -13, -14, -14, -13, -11,
-11, -11, -10, -11, -11, -11, -11, -9, -8, -8, -7, -7, -8, -8, -7, -5, -5, -5,
-5, -4, -4, -2, -1, -1, 0, 0, };