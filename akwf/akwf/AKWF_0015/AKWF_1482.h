#define DATA_LENGTH 512
#define DATA AKWF_1482

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 5, 9, 13, 16, 20, 24, 29, 32, 36,
40, 44, 48, 52, 55, 59, 62, 66, 68, 71, 75, 78, 81, 83, 86, 88, 92, 94, 96, 98,
100, 102, 103, 105, 107, 109, 111, 111, 113, 112, 114, 114, 115, 116, 117, 118,
118, 118, 118, 118, 118, 119, 119, 118, 118, 118, 118, 117, 117, 118, 117, 116,
115, 115, 114, 113, 112, 111, 111, 110, 109, 108, 108, 107, 105, 104, 103, 102,
102, 99, 99, 97, 96, 95, 94, 93, 91, 91, 89, 88, 86, 85, 84, 82, 82, 80, 78, 76,
76, 74, 73, 71, 71, 68, 68, 66, 65, 63, 62, 61, 60, 59, 57, 57, 54, 54, 51, 51,
49, 49, 47, 46, 45, 44, 43, 41, 40, 39, 38, 36, 35, 34, 33, 33, 32, 30, 29, 28,
28, 26, 26, 24, 23, 22, 22, 20, 20, 20, 18, 17, 16, 15, 15, 15, 13, 12, 11, 11,
9, 9, 9, 9, 7, 6, 6, 6, 5, 4, 3, 3, 2, 1, 2, 1, 0, -1, -1, -1, -2, -2, -3, -4,
-4, -4, -4, -5, -5, -6, -7, -7, -7, -8, -8, -8, -8, -9, -9, -9, -9, -10, -9,
-10, -10, -11, -11, -12, -11, -11, -12, -11, -12, -13, -13, -12, -13, -14, -13,
-13, -13, -13, -14, -14, -14, -13, -14, -15, -14, -14, -15, -14, -15, -15, -15,
-15, -14, -15, -15, -15, -15, -16, -15, -15, -15, -14, -16, -15, -15, -15, -15,
-15, -15, -15, -15, -15, -15, -15, -15, -14, -15, -15, -16, -15, -15, -15, -14,
-14, -15, -15, -14, -15, -14, -15, -14, -15, -14, -14, -14, -14, -14, -14, -14,
-15, -15, -14, -14, -14, -14, -14, -13, -14, -14, -13, -14, -14, -13, -14, -13,
-13, -13, -13, -13, -13, -12, -13, -13, -13, -13, -12, -13, -13, -13, -12, -12,
-12, -12, -12, -12, -13, -12, -12, -11, -12, -12, -12, -12, -12, -11, -12, -11,
-11, -12, -11, -11, -11, -11, -12, -11, -11, -11, -11, -11, -11, -10, -12, -10,
-11, -10, -11, -11, -11, -10, -11, -10, -11, -10, -10, -11, -11, -10, -10, -10,
-11, -11, -10, -10, -11, -13, -13, -16, -17, -18, -21, -23, -25, -27, -29, -32,
-34, -37, -40, -42, -45, -48, -50, -53, -55, -58, -61, -63, -65, -68, -70, -72,
-74, -76, -77, -79, -80, -83, -84, -86, -88, -88, -89, -90, -92, -92, -94, -94,
-95, -96, -96, -97, -98, -97, -98, -98, -98, -99, -99, -98, -99, -98, -98, -98,
-98, -98, -98, -98, -97, -96, -96, -95, -95, -94, -93, -93, -92, -92, -90, -90,
-89, -87, -87, -86, -85, -84, -83, -83, -81, -80, -79, -77, -77, -75, -74, -74,
-72, -72, -69, -68, -68, -66, -65, -64, -63, -62, -60, -59, -57, -56, -55, -55,
-53, -52, -50, -50, -48, -47, -46, -45, -43, -43, -41, -39, -39, -37, -37, -35,
-33, -32, -31, -30, -30, -29, -27, -27, -25, -24, -23, -22, -21, -20, -18, -17,
-15, -14, -12, -9, -7, -4, 0, };