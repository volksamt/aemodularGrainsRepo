#define DATA_LENGTH 512
#define DATA AKWF_1419

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 4, 6, 9, 11, 14, 16, 18, 21, 24,
27, 29, 31, 35, 37, 39, 42, 44, 48, 50, 53, 56, 57, 61, 63, 66, 68, 71, 73, 76,
78, 80, 83, 84, 86, 89, 90, 91, 93, 94, 97, 98, 100, 102, 103, 105, 107, 109,
109, 112, 113, 116, 116, 117, 119, 119, 119, 119, 118, 118, 116, 114, 110, 107,
103, 97, 90, 84, 77, 70, 63, 56, 52, 47, 43, 40, 38, 37, 34, 33, 30, 27, 25, 21,
18, 15, 11, 9, 7, 2, -1, -4, -7, -10, -13, -16, -19, -22, -24, -27, -30, -33,
-36, -39, -42, -46, -48, -50, -52, -55, -56, -57, -59, -61, -63, -67, -68, -71,
-74, -78, -80, -83, -85, -87, -89, -88, -89, -88, -89, -88, -87, -85, -84, -82,
-81, -79, -78, -77, -76, -74, -72, -71, -69, -68, -66, -66, -65, -63, -62, -63,
-62, -61, -60, -60, -59, -56, -53, -51, -48, -44, -41, -37, -34, -30, -26, -23,
-20, -16, -13, -10, -7, -3, 0, 3, 5, 9, 12, 15, 19, 21, 24, 27, 29, 31, 33, 34,
36, 37, 38, 41, 42, 44, 46, 49, 51, 54, 56, 58, 59, 61, 63, 64, 65, 67, 67, 68,
69, 70, 70, 71, 72, 73, 72, 73, 74, 74, 75, 74, 73, 72, 71, 71, 69, 68, 68, 65,
64, 63, 63, 61, 60, 57, 55, 54, 53, 50, 48, 46, 44, 41, 39, 37, 34, 32, 30, 28,
24, 23, 21, 19, 16, 15, 13, 11, 8, 6, 4, 2, 0, -3, -6, -9, -11, -14, -17, -20,
-22, -24, -26, -29, -32, -34, -37, -39, -41, -44, -47, -49, -52, -54, -56, -58,
-60, -60, -62, -62, -63, -64, -64, -65, -65, -67, -66, -67, -67, -67, -67, -68,
-67, -67, -67, -67, -67, -66, -66, -66, -64, -63, -62, -62, -61, -59, -59, -57,
-56, -54, -54, -51, -50, -47, -47, -44, -42, -41, -39, -37, -36, -33, -32, -30,
-29, -27, -25, -22, -20, -18, -17, -14, -12, -9, -7, -5, -3, -1, 1, 4, 6, 8, 10,
13, 15, 17, 20, 21, 24, 26, 27, 30, 31, 33, 34, 36, 37, 38, 40, 40, 42, 43, 44,
45, 46, 47, 48, 48, 49, 49, 51, 50, 50, 50, 51, 50, 50, 50, 50, 50, 49, 49, 48,
47, 45, 44, 43, 40, 39, 37, 36, 34, 32, 30, 28, 27, 25, 22, 20, 18, 16, 15, 12,
10, 9, 6, 4, 1, -1, -4, -5, -8, -10, -12, -15, -17, -19, -22, -25, -27, -29,
-32, -34, -37, -39, -40, -42, -44, -46, -47, -49, -50, -52, -54, -55, -57, -59,
-59, -61, -62, -62, -64, -64, -65, -66, -67, -68, -68, -69, -69, -69, -70, -70,
-70, -69, -68, -69, -67, -66, -65, -66, -65, -63, -63, -62, -60, -59, -58, -57,
-56, -55, -53, -51, -50, -49, -47, -45, -44, -43, -40, -40, -37, -36, -34, -33,
-31, -30, -27, -25, -24, -21, -19, -18, -15, -14, -13, -11, -9, -8, -7, -5, -5,
-3, -1, 0, };