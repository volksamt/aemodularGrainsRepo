#define DATA_LENGTH 512
#define DATA AKWF_1408

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 12, 16, 20, 25, 28, 33, 37, 42,
45, 49, 53, 55, 59, 63, 65, 69, 70, 74, 76, 78, 81, 83, 84, 87, 88, 90, 92, 93,
95, 96, 97, 99, 99, 101, 101, 102, 104, 104, 105, 105, 107, 106, 107, 108, 109,
110, 110, 111, 110, 111, 112, 112, 112, 112, 113, 113, 114, 114, 115, 114, 114,
115, 116, 115, 115, 116, 117, 116, 117, 116, 116, 116, 117, 117, 118, 117, 117,
117, 117, 118, 117, 118, 118, 118, 118, 118, 118, 118, 118, 118, 119, 119, 118,
118, 118, 118, 118, 119, 119, 119, 119, 118, 118, 118, 119, 119, 119, 119, 119,
118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 118, 119,
119, 119, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119, 119, 119,
118, 119, 120, 119, 119, 119, 118, 119, 118, 119, 118, 119, 119, 119, 118, 119,
118, 118, 117, 118, 119, 118, 117, 117, 117, 118, 117, 117, 118, 117, 118, 117,
117, 117, 117, 116, 117, 116, 116, 115, 115, 116, 115, 115, 114, 115, 115, 114,
114, 114, 113, 113, 113, 113, 113, 112, 112, 111, 111, 111, 110, 110, 109, 109,
109, 107, 107, 107, 106, 105, 105, 104, 103, 102, 101, 100, 99, 98, 97, 97, 95,
93, 93, 91, 90, 87, 85, 84, 82, 80, 79, 76, 73, 71, 68, 65, 63, 60, 57, 54, 50,
47, 43, 40, 36, 32, 27, 23, 19, 14, 10, 6, 1, -3, -7, -12, -17, -21, -25, -30,
-34, -37, -41, -46, -49, -53, -56, -60, -62, -65, -69, -71, -74, -76, -79, -82,
-83, -85, -87, -89, -90, -92, -93, -95, -97, -98, -99, -100, -101, -102, -103,
-103, -105, -106, -106, -107, -107, -108, -108, -109, -110, -110, -110, -111,
-111, -112, -113, -113, -112, -112, -113, -114, -113, -114, -114, -115, -115,
-115, -115, -115, -116, -116, -116, -116, -116, -116, -116, -116, -116, -117,
-117, -117, -117, -118, -117, -118, -117, -118, -118, -118, -119, -118, -119,
-118, -118, -119, -118, -119, -119, -118, -118, -118, -118, -119, -118, -119,
-118, -119, -119, -119, -119, -118, -119, -119, -118, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -120, -119, -119, -118, -120, -119, -119, -119, -119, -119,
-118, -118, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-118, -119, -118, -118, -118, -119, -118, -118, -117, -118, -118, -118, -118,
-117, -118, -117, -117, -118, -117, -116, -117, -117, -117, -116, -116, -116,
-116, -116, -116, -116, -115, -115, -115, -115, -115, -114, -114, -113, -114,
-113, -112, -113, -112, -112, -111, -111, -111, -110, -109, -110, -110, -109,
-108, -108, -108, -107, -107, -105, -105, -103, -102, -102, -101, -101, -99,
-98, -97, -96, -95, -94, -92, -91, -90, -87, -85, -84, -82, -80, -78, -75, -74,
-70, -68, -65, -63, -60, -57, -53, -49, -46, -43, -39, -35, -30, -27, -23, -19,
-14, -10, -5, -1, };