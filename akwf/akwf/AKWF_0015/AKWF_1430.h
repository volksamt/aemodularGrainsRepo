#define DATA_LENGTH 512
#define DATA AKWF_1430

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 21, 34, 49, 60, 69, 72, 73, 71, 69,
66, 62, 58, 54, 50, 46, 45, 45, 48, 50, 52, 53, 51, 48, 44, 37, 31, 25, 20, 13,
5, -2, -9, -16, -22, -29, -33, -38, -41, -44, -46, -49, -48, -50, -49, -48, -47,
-45, -44, -42, -41, -38, -36, -35, -33, -31, -28, -26, -24, -21, -19, -16, -13,
-10, -7, -3, -1, 3, 7, 11, 14, 17, 21, 24, 27, 29, 31, 33, 33, 33, 35, 33, 32,
30, 27, 25, 21, 17, 13, 7, 2, -3, -9, -13, -19, -24, -30, -34, -38, -43, -47,
-51, -54, -57, -59, -61, -63, -64, -64, -65, -64, -63, -62, -61, -59, -57, -56,
-54, -50, -48, -45, -43, -40, -37, -34, -31, -28, -24, -22, -19, -17, -14, -11,
-9, -6, -4, -2, 1, 2, 5, 6, 8, 10, 12, 14, 15, 17, 18, 20, 21, 21, 23, 24, 25,
27, 27, 27, 27, 28, 29, 30, 31, 30, 30, 30, 30, 29, 30, 28, 28, 27, 27, 26, 25,
23, 23, 21, 21, 20, 18, 16, 15, 14, 12, 10, 8, 7, 6, 4, 3, 1, 0, -2, -3, -4, -5,
-7, -7, -8, -10, -10, -10, -12, -13, -13, -13, -13, -14, -13, -14, -14, -14,
-14, -13, -13, -13, -13, -12, -11, -11, -10, -10, -9, -8, -7, -5, -5, -4, -3,
-1, -1, 0, 2, 3, 4, 5, 6, 7, 9, 10, 10, 11, 13, 14, 16, 17, 18, 18, 19, 21, 22,
22, 23, 24, 24, 25, 26, 27, 26, 28, 28, 28, 28, 29, 29, 28, 29, 29, 29, 29, 28,
28, 29, 28, 27, 26, 26, 25, 25, 24, 23, 23, 21, 21, 19, 19, 17, 16, 15, 14, 13,
12, 10, 9, 8, 7, 5, 4, 3, 1, 0, -2, -2, -4, -5, -6, -8, -10, -10, -11, -12, -13,
-15, -15, -17, -18, -19, -21, -22, -22, -23, -25, -24, -26, -27, -27, -28, -28,
-29, -29, -31, -31, -32, -32, -31, -33, -33, -33, -33, -34, -33, -33, -33, -34,
-33, -33, -32, -33, -33, -32, -32, -32, -31, -31, -31, -29, -28, -29, -28, -28,
-26, -26, -26, -25, -24, -23, -22, -22, -20, -20, -20, -18, -17, -16, -15, -15,
-13, -13, -11, -10, -10, -9, -7, -7, -5, -4, -3, -2, -2, 0, 0, 1, 1, 3, 3, 4, 5,
6, 7, 7, 8, 9, 9, 9, 10, 10, 11, 12, 11, 11, 12, 12, 11, 12, 11, 10, 10, 10, 9,
9, 8, 8, 7, 6, 6, 4, 3, 3, 1, -1, -3, -4, -6, -7, -9, -11, -13, -15, -17, -19,
-21, -24, -26, -28, -32, -33, -36, -39, -42, -45, -47, -50, -54, -56, -59, -63,
-65, -68, -71, -73, -77, -80, -82, -85, -88, -91, -93, -96, -99, -101, -103,
-104, -107, -108, -110, -113, -114, -115, -116, -116, -118, -118, -118, -119,
-120, -119, -119, -119, -117, -116, -115, -113, -112, -110, -108, -106, -102,
-100, -97, -93, -90, -86, -82, -78, -73, -69, -64, -60, -51, -30, -10, 0, };