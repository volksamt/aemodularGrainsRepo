#define DATA_LENGTH 512
#define DATA AKWF_1497

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 2, 3, 4, 4, 5, 6, 5, 6, 6, 7,
7, 8, 8, 8, 8, 8, 9, 9, 9, 8, 9, 10, 9, 9, 9, 9, 10, 10, 10, 9, 10, 10, 9, 9, 9,
10, 10, 10, 10, 10, 10, 9, 10, 9, 10, 9, 10, 10, 9, 10, 9, 9, 9, 10, 10, 11, 10,
10, 11, 11, 12, 12, 12, 13, 13, 14, 14, 14, 15, 16, 16, 16, 17, 17, 18, 19, 19,
20, 21, 21, 22, 22, 23, 23, 25, 25, 25, 27, 27, 28, 29, 29, 30, 31, 31, 33, 33,
34, 36, 35, 36, 37, 38, 39, 39, 41, 41, 42, 43, 44, 45, 46, 47, 47, 49, 49, 50,
50, 52, 53, 55, 54, 55, 57, 57, 58, 60, 60, 61, 62, 62, 64, 64, 66, 67, 67, 68,
68, 69, 71, 71, 73, 73, 74, 75, 76, 77, 78, 79, 79, 79, 81, 82, 83, 84, 85, 84,
85, 86, 88, 89, 88, 89, 90, 91, 92, 92, 92, 94, 94, 94, 95, 95, 96, 97, 98, 99,
98, 100, 99, 100, 101, 101, 101, 102, 102, 102, 104, 103, 104, 104, 104, 105,
105, 106, 106, 106, 107, 107, 107, 107, 108, 107, 108, 108, 108, 109, 110, 109,
108, 110, 109, 109, 109, 110, 110, 110, 110, 109, 110, 109, 109, 109, 109, 108,
108, 109, 108, 107, 107, 106, 106, 105, 104, 104, 103, 102, 101, 101, 100, 100,
98, 97, 96, 96, 94, 93, 91, 90, 89, 87, 86, 85, 83, 82, 81, 79, 78, 75, 74, 72,
70, 69, 66, 64, 63, 61, 58, 57, 55, 52, 51, 48, 46, 43, 42, 40, 37, 35, 33, 30,
28, 25, 23, 21, 18, 16, 13, 11, 9, 7, 3, 1, -2, -4, -7, -8, -11, -14, -16, -19,
-21, -24, -26, -28, -30, -33, -35, -38, -40, -42, -45, -47, -49, -51, -54, -55,
-58, -60, -62, -64, -65, -68, -70, -72, -73, -75, -76, -79, -80, -82, -83, -85,
-87, -89, -90, -91, -93, -94, -95, -96, -98, -98, -100, -100, -102, -103, -104,
-105, -107, -107, -107, -108, -109, -110, -111, -111, -111, -112, -112, -114,
-113, -115, -114, -116, -115, -116, -116, -116, -116, -117, -117, -117, -118,
-118, -119, -118, -119, -119, -119, -119, -119, -119, -119, -118, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -118, -119, -119, -119,
-118, -118, -117, -118, -117, -117, -116, -117, -115, -115, -115, -115, -113,
-114, -114, -112, -111, -111, -110, -110, -109, -108, -109, -107, -107, -106,
-104, -103, -102, -101, -101, -99, -98, -97, -97, -95, -94, -93, -92, -90, -89,
-89, -87, -85, -84, -83, -81, -80, -78, -77, -75, -74, -72, -71, -69, -67, -66,
-64, -63, -61, -59, -59, -57, -55, -53, -52, -51, -49, -47, -45, -44, -43, -41,
-40, -38, -37, -35, -34, -32, -31, -29, -28, -27, -26, -24, -22, -22, -20, -19,
-18, -16, -15, -14, -13, -12, -11, -9, -8, -8, -6, -6, -5, -4, -4, -2, -2, -1,
0, 0, };