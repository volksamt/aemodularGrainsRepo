#define DATA_LENGTH 512
#define DATA AKWF_1473

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 3, 4, 5, 5, 6, 7, 8, 9, 10, 12,
13, 13, 15, 14, 16, 17, 18, 19, 20, 21, 22, 22, 23, 25, 25, 26, 27, 28, 29, 30,
30, 32, 32, 34, 34, 36, 36, 36, 39, 39, 40, 42, 42, 43, 44, 44, 46, 46, 46, 47,
48, 49, 49, 51, 52, 52, 53, 53, 55, 56, 57, 57, 58, 59, 59, 60, 60, 61, 63, 62,
63, 64, 64, 65, 66, 66, 67, 67, 69, 69, 69, 70, 70, 71, 72, 73, 73, 74, 74, 74,
74, 75, 76, 75, 77, 76, 78, 78, 78, 78, 79, 80, 80, 81, 80, 80, 81, 82, 82, 83,
82, 83, 82, 83, 83, 84, 85, 84, 84, 84, 85, 85, 85, 85, 85, 85, 86, 86, 86, 86,
87, 87, 87, 86, 87, 87, 87, 86, 86, 86, 86, 86, 86, 87, 87, 86, 87, 87, 86, 85,
85, 85, 85, 85, 85, 86, 84, 85, 84, 84, 83, 84, 83, 82, 83, 82, 81, 82, 81, 81,
80, 80, 80, 80, 78, 79, 78, 78, 77, 77, 77, 76, 76, 75, 74, 74, 74, 74, 73, 71,
72, 70, 70, 70, 70, 68, 68, 67, 67, 65, 66, 64, 64, 62, 62, 62, 61, 60, 60, 58,
57, 56, 56, 55, 54, 53, 52, 51, 51, 50, 48, 48, 47, 46, 46, 44, 43, 43, 41, 41,
40, 39, 37, 37, 36, 34, 34, 33, 32, 31, 30, 29, 28, 28, 27, 26, 25, 25, 24, 23,
22, 21, 20, 20, 19, 18, 17, 18, 17, 16, 16, 15, 14, 14, 12, 13, 12, 12, 12, 11,
10, 11, 10, 9, 9, 8, 9, 8, 8, 7, 7, 7, 8, 7, 7, 6, 6, 6, 5, 6, 7, 5, 6, 5, 6, 5,
6, 5, 6, 6, 7, 8, 7, 9, -33, -61, -61, -64, -63, -66, -65, -68, -69, -71, -73,
-75, -78, -81, -84, -87, -90, -95, -97, -101, -104, -106, -108, -111, -113,
-115, -116, -117, -118, -118, -119, -119, -119, -119, -119, -118, -118, -118,
-118, -118, -118, -116, -117, -117, -117, -117, -116, -116, -115, -115, -115,
-116, -116, -116, -114, -115, -115, -114, -114, -114, -113, -112, -112, -112,
-111, -111, -111, -110, -110, -110, -109, -109, -109, -108, -107, -107, -107,
-106, -105, -104, -104, -104, -102, -103, -102, -101, -101, -100, -99, -99, -98,
-97, -98, -97, -96, -95, -96, -94, -94, -93, -92, -92, -90, -90, -90, -89, -87,
-87, -87, -86, -86, -85, -83, -84, -82, -82, -81, -80, -79, -78, -78, -77, -76,
-75, -74, -73, -73, -72, -70, -71, -70, -69, -68, -68, -67, -65, -65, -64, -63,
-62, -61, -61, -60, -58, -58, -57, -56, -55, -54, -53, -52, -51, -50, -50, -49,
-48, -46, -46, -45, -44, -43, -43, -42, -40, -39, -39, -38, -37, -36, -35, -34,
-33, -32, -31, -30, -29, -28, -27, -27, -25, -25, -24, -22, -21, -21, -20, -18,
-17, -16, -15, -15, -13, -12, -11, -11, -9, -8, -8, -7, -7, -5, -4, -3, -2, 0,
0, };