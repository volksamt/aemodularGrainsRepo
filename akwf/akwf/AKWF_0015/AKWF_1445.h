#define DATA_LENGTH 512
#define DATA AKWF_1445

const PROGMEM int8_t DATA[DATA_LENGTH] = {14, 34, 52, 70, 88, 107, 118, 118,
119, 120, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
120, 119, 119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 120, 119, 119, 119, 119,
119, 118, 119, 120, 120, 120, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119,
119, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 119,
119, 119, 119, 119, 119, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 118, 119, 120, 118, 119, 119, 119, 120, 119, 119, 119, 120, 119,
119, 118, 120, 119, 119, 119, 119, 119, 118, 120, 118, 119, 118, 120, 119, 119,
120, 119, 120, 119, 119, 118, 120, 119, 119, 118, 119, 120, 119, 119, 119, 119,
119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 118, 119, 119, 118,
119, 119, 119, 110, 94, 78, 62, 46, 29, 14, -2, -18, -34, -49, -65, -81, -97,
-113, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -120, -120, -119, -119, -118,
-119, -119, -120, -119, -118, -118, -119, -119, -119, -119, -118, -119, -119,
-119, -118, -119, -119, -118, -120, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -118, -119, -119, -119, -118, -119, -119,
-119, -118, -120, -119, -120, -119, -119, -119, -119, -119, -118, -120, -119,
-119, -119, -119, -118, -119, -119, -120, -118, -119, -119, -119, -120, -119,
-120, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -120, -120, -119, -120, -119, -119, -119, -118, -120, -119, -119, -120,
-119, -119, -119, -120, -119, -120, -120, -119, -120, -119, -118, -120, -119,
-119, -120, -119, -119, -119, -119, -119, -118, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -120, -119, -119, -118, -120, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-118, -120, -119, -119, -118, -119, -120, -120, -119, -119, -119, -119, -118,
-120, -119, -119, -118, -119, -119, -119, -119, -119, -118, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -118, -119, -118, -120, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -120, -119, -118, -120, -119, -120, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -120, -119,
-118, -120, -117, -112, -107, -101, -96, -90, -85, -79, -75, -70, -65, -60, -56,
-50, -45, -40, -36, -30, -27, -21, -17, -12, -1, };