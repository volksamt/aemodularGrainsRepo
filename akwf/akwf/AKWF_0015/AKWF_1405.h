#define DATA_LENGTH 512
#define DATA AKWF_1405

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 5, 6, 8, 9, 10, 12, 12, 14, 15,
15, 17, 17, 19, 19, 19, 20, 21, 21, 21, 23, 23, 23, 24, 25, 26, 26, 27, 27, 27,
28, 28, 29, 29, 29, 29, 30, 31, 30, 31, 31, 31, 31, 32, 32, 31, 31, 33, 33, 33,
33, 32, 32, 33, 32, 33, 33, 30, 29, 29, 29, 29, 28, 29, 29, 28, 29, 28, 28, 28,
28, 28, 27, 28, 28, 27, 27, 28, 27, 27, 27, 27, 27, 27, 27, 27, 26, 27, 27, 26,
27, 26, 26, 27, 26, 26, 26, 26, 26, 26, 26, 26, 26, 25, 26, 26, 26, 26, 26, 26,
25, 25, 25, 25, 25, 25, 26, 26, 26, 26, 26, 25, 26, 25, 25, 25, 25, 26, 25, 26,
26, 26, 24, 26, 25, 26, 25, 24, 52, 63, 66, 71, 74, 77, 79, 82, 83, 86, 87, 89,
90, 91, 93, 94, 95, 97, 98, 99, 99, 100, 101, 103, 103, 103, 104, 105, 106, 107,
107, 108, 108, 109, 109, 110, 111, 111, 111, 112, 112, 113, 114, 114, 114, 115,
115, 116, 116, 115, 117, 117, 117, 117, 118, 117, 118, 119, 117, 118, 118, 119,
118, 120, 119, 119, 119, 120, 118, 121, 117, 124, 105, 69, 66, 57, 54, 49, 46,
43, 40, 37, 34, 31, 29, 27, 25, 23, 20, 20, 18, 17, 15, 13, 12, 11, 8, 8, 6, 5,
3, 2, 1, 0, -1, -2, -4, -5, -6, -7, -8, -9, -11, -11, -13, -14, -14, -15, -17,
-17, -18, -19, -20, -20, -21, -22, -23, -24, -25, -27, -26, -27, -28, -29, -30,
-31, -32, -32, -33, -34, -34, -35, -36, -36, -37, -38, -39, -39, -40, -40, -41,
-42, -42, -43, -43, -44, -45, -45, -46, -47, -47, -48, -48, -49, -50, -51, -51,
-51, -52, -53, -53, -54, -54, -55, -55, -55, -56, -56, -57, -57, -58, -58, -58,
-59, -58, -59, -59, -60, -61, -60, -61, -61, -62, -62, -62, -62, -63, -62, -63,
-63, -64, -64, -64, -64, -64, -65, -65, -65, -66, -66, -66, -66, -67, -67, -67,
-67, -68, -67, -68, -68, -69, -70, -69, -70, -70, -69, -70, -71, -70, -71, -71,
-71, -71, -71, -71, -72, -72, -72, -73, -73, -73, -72, -73, -73, -73, -73, -73,
-73, -74, -74, -74, -74, -73, -74, -74, -74, -75, -75, -75, -75, -75, -75, -75,
-76, -75, -76, -76, -76, -75, -77, -76, -76, -76, -76, -76, -76, -77, -76, -76,
-76, -76, -76, -76, -76, -77, -77, -77, -75, -78, -75, -79, -74, -82, -53, -11,
-8, 4, 6, 13, 16, 19, 22, 25, 26, 27, 29, 29, 31, 28, 16, 12, 11, 8, 7, 6, 5, 5,
5, 4, 5, 10, 12, 12, 14, 14, 16, 15, 16, 15, 17, 15, 18, 10, -16, -19, -26, -28,
-31, -34, -36, -38, -39, -42, -43, -45, -46, -47, -46, -48, -49, -50, -51, -51,
-52, -53, -52, -53, -54, -54, -55, -54, -55, -53, -57, -37, -19, -17, -11, -10,
-5, -5, -2, 0, };