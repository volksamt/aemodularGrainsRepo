#define DATA_LENGTH 512
#define DATA AKWF_1433

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 8, 10, 13, 15, 17, 19, 21,
24, 26, 29, 31, 33, 37, 39, 42, 44, 47, 50, 53, 55, 58, 62, 66, 69, 71, 74, 77,
80, 83, 86, 88, 90, 93, 95, 96, 97, 99, 101, 103, 103, 104, 104, 105, 107, 108,
109, 110, 110, 111, 114, 117, 119, 118, 117, 115, 113, 110, 109, 108, 106, 104,
102, 100, 98, 96, 94, 91, 90, 88, 86, 83, 81, 79, 76, 75, 73, 71, 68, 66, 63,
61, 59, 56, 54, 52, 50, 47, 45, 44, 42, 40, 38, 36, 36, 33, 31, 31, 29, 28, 27,
26, 23, 23, 22, 21, 20, 16, 14, 13, 12, 14, 13, 13, 13, 13, 13, 13, 14, 13, 14,
15, 14, 14, 15, 14, 15, 16, 15, 15, 15, 16, 15, 15, 16, 16, 16, 16, 16, 16, 16,
17, 16, 17, 16, 17, 17, 17, 17, 18, 17, 17, 18, 18, 18, 19, 19, 20, 19, 20, 20,
19, 21, 21, 20, 21, 22, 21, 22, 22, 22, 22, 22, 25, 31, 30, 18, 13, 17, 18, 17,
20, 20, 22, 22, 23, 23, 24, 24, 24, 24, 24, 23, 24, 25, 25, 24, 24, 24, 24, 24,
23, 23, 23, 23, 23, 23, 22, 23, 22, 22, 23, 22, 22, 23, 22, 22, 23, 21, 21, 22,
20, 21, 23, 18, 23, 25, -5, -31, -26, -22, -26, -22, -20, -22, -19, -19, -20,
-18, -17, -18, -17, -18, -18, -15, -16, -15, -14, -16, -14, -13, -15, -14, -13,
-14, -12, -13, -14, -12, -13, -13, -11, -13, -12, -11, -13, -12, -10, -14, -11,
-9, -16, -9, -7, -36, -40, -8, -1, -13, -8, -9, -15, -12, -13, -16, -15, -18,
-20, -19, -21, -23, -22, -25, -27, -27, -27, -28, -29, -34, -37, -38, -37, -35,
-36, -40, -44, -46, -48, -48, -50, -51, -53, -53, -55, -56, -58, -59, -59, -61,
-61, -62, -63, -64, -66, -67, -68, -68, -69, -71, -73, -75, -76, -78, -79, -79,
-80, -80, -81, -83, -83, -83, -84, -84, -85, -85, -85, -85, -86, -87, -86, -86,
-86, -86, -86, -87, -87, -87, -87, -87, -87, -89, -89, -90, -90, -87, -86, -86,
-84, -83, -82, -82, -80, -79, -77, -76, -76, -74, -73, -72, -71, -69, -67, -66,
-65, -63, -62, -61, -60, -57, -57, -55, -53, -52, -50, -48, -47, -45, -44, -42,
-39, -38, -37, -35, -35, -33, -30, -30, -27, -25, -26, -23, -22, -22, -19, -19,
-20, -13, -18, -37, -28, -8, -10, -12, -7, -6, -7, -4, -6, -7, -4, -7, -5, -5,
-6, -6, -5, -7, -6, -6, -7, -7, -6, -7, -7, -7, -7, -6, -7, -7, -7, -7, -7, -7,
-8, -7, -7, -8, -8, -9, -8, -8, -8, -9, -9, -9, -9, -9, -10, -10, -10, -11, -11,
-11, -11, -12, -13, -13, -13, -13, -14, -14, -15, -15, -15, -15, -15, -16, -15,
-15, -15, -14, -14, -13, -13, -13, -12, -10, -10, -10, -10, -9, -7, -7, -6, -6,
-6, -6, -5, -4, -1, };