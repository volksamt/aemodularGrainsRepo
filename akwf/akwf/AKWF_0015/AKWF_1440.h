#define DATA_LENGTH 512
#define DATA AKWF_1440

const PROGMEM int8_t DATA[DATA_LENGTH] = {17, 24, 8, 20, 27, 18, 19, 19, 13, 15,
14, 13, 16, 14, 14, 17, 17, 18, 21, 21, 22, 24, 25, 27, 29, 29, 32, 33, 34, 36,
38, 38, 41, 42, 44, 46, 47, 48, 51, 52, 54, 55, 55, 57, 59, 59, 61, 63, 63, 66,
66, 68, 69, 70, 71, 73, 74, 75, 77, 77, 79, 81, 80, 83, 84, 84, 86, 86, 86, 90,
89, 90, 94, 92, 94, 98, 95, 98, 101, 96, 103, 105, 96, 113, 111, 58, 34, 57, 52,
40, 50, 53, 52, 62, 61, 63, 69, 67, 69, 72, 71, 72, 74, 71, 72, 72, 70, 72, 72,
71, 71, 70, 69, 69, 68, 67, 67, 66, 65, 65, 64, 64, 64, 62, 62, 62, 60, 60, 60,
60, 59, 58, 57, 57, 56, 56, 57, 55, 55, 55, 54, 54, 53, 53, 53, 53, 53, 51, 52,
51, 51, 51, 50, 51, 50, 50, 49, 49, 49, 48, 49, 48, 48, 48, 48, 47, 48, 46, 46,
46, 47, 46, 46, 46, 47, 46, 45, 45, 45, 45, 46, 44, 44, 44, 44, 44, 45, 43, 44,
43, 43, 42, 44, 42, 42, 43, 43, 42, 43, 42, 42, 42, 41, 41, 41, 41, 41, 41, 41,
40, 40, 40, 39, 40, 39, 39, 40, 39, 38, 38, 38, 37, 38, 37, 36, 37, 37, 36, 36,
36, 36, 35, 35, 34, 35, 34, 33, 33, 33, 33, 33, 32, 32, 32, 32, 31, 31, 30, 31,
31, 30, 29, 28, 29, 28, 28, 27, 28, 27, 27, 27, 26, 27, 26, 25, 26, 24, 24, 25,
24, 25, 24, 24, 23, 23, 22, 23, 23, 21, 22, 22, 21, 22, 20, 19, 21, 19, 18, 20,
17, 18, 20, 16, 18, 20, 14, 18, 18, 11, 21, 21, -23, -45, -29, -31, -42, -35,
-34, -35, -29, -29, -29, -26, -27, -27, -26, -27, -28, -28, -31, -30, -30, -33,
-33, -33, -35, -36, -38, -39, -39, -41, -43, -43, -45, -46, -47, -49, -50, -50,
-52, -53, -54, -55, -57, -57, -59, -59, -60, -60, -62, -64, -64, -64, -65, -67,
-67, -68, -69, -69, -70, -71, -73, -73, -74, -75, -75, -77, -76, -78, -77, -79,
-80, -80, -81, -82, -83, -83, -84, -84, -86, -85, -86, -86, -88, -88, -89, -90,
-90, -91, -90, -91, -91, -91, -91, -91, -92, -91, -91, -92, -91, -92, -92, -93,
-92, -92, -92, -92, -91, -92, -92, -91, -92, -92, -91, -90, -91, -91, -90, -90,
-91, -90, -90, -89, -88, -89, -88, -89, -88, -87, -88, -87, -86, -86, -85, -85,
-85, -84, -83, -83, -83, -83, -82, -82, -82, -80, -80, -81, -79, -79, -79, -78,
-77, -77, -76, -75, -75, -75, -73, -73, -72, -72, -72, -71, -70, -70, -69, -68,
-68, -67, -66, -66, -65, -65, -64, -63, -63, -63, -61, -61, -60, -59, -59, -58,
-57, -57, -55, -54, -54, -53, -53, -53, -50, -51, -50, -48, -49, -48, -45, -47,
-45, -43, -45, -43, -40, -44, -38, -38, -43, -33, -36, -48, -16, };