#define DATA_LENGTH 512
#define DATA AKWF_1465

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 5, 6, 8, 9, 10, 12, 13, 14,
15, 16, 18, 20, 21, 22, 24, 25, 26, 27, 29, 30, 31, 32, 35, 35, 37, 38, 39, 40,
42, 43, 44, 46, 47, 48, 50, 50, 52, 53, 55, 55, 57, 58, 59, 59, 61, 62, 64, 65,
66, 67, 67, 69, 70, 71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 81, 81, 83, 84, 84,
85, 86, 87, 87, 88, 88, 90, 91, 92, 92, 93, 93, 94, 95, 95, 95, 97, 98, 98, 99,
100, 100, 100, 102, 102, 103, 102, 103, 104, 104, 105, 105, 105, 106, 106, 107,
107, 108, 108, 109, 110, 110, 110, 109, 110, 110, 111, 112, 112, 112, 113, 113,
113, 114, 114, 114, 114, 115, 114, 115, 115, 116, 116, 115, 116, 117, 117, 116,
117, 118, 118, 118, 118, 118, 118, 118, 118, 119, 118, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 120, 119, 119, 119, 119,
118, 119, 118, 118, 118, 118, 117, 118, 117, 117, 117, 116, 116, 117, 116, 115,
114, 114, 115, 114, 113, 113, 113, 113, 112, 112, 111, 110, 110, 110, 109, 109,
109, 107, 107, 106, 105, 105, 104, 104, 103, 102, 101, 102, 100, 100, 99, 99,
97, 97, 97, 95, 95, 94, 94, 93, 91, 91, 90, 90, 89, 89, 88, 86, 86, 86, 85, 83,
82, 82, 81, 80, 81, 79, 66, 44, 24, 8, -3, -11, -17, -22, -27, -30, -33, -37,
-39, -40, -44, -47, -48, -50, -52, -54, -56, -57, -59, -61, -62, -64, -65, -67,
-69, -70, -72, -73, -74, -75, -78, -79, -80, -80, -83, -84, -84, -86, -87, -88,
-89, -90, -91, -92, -93, -94, -95, -96, -96, -97, -98, -99, -100, -100, -102,
-103, -103, -105, -105, -105, -107, -107, -107, -107, -109, -109, -109, -111,
-111, -111, -112, -113, -112, -113, -113, -114, -115, -114, -115, -116, -116,
-115, -116, -116, -117, -117, -117, -117, -118, -118, -118, -119, -118, -118,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -117,
-118, -118, -117, -117, -117, -117, -117, -117, -117, -116, -115, -115, -115,
-115, -115, -115, -114, -113, -114, -114, -113, -112, -113, -112, -111, -111,
-111, -111, -110, -110, -110, -109, -109, -108, -107, -107, -107, -107, -106,
-105, -105, -104, -104, -103, -104, -103, -102, -101, -101, -100, -100, -99,
-97, -97, -97, -97, -95, -95, -94, -94, -93, -93, -91, -91, -89, -90, -88, -88,
-87, -86, -86, -85, -83, -83, -82, -82, -80, -80, -79, -78, -77, -76, -75, -73,
-72, -73, -70, -69, -68, -67, -66, -65, -64, -63, -62, -60, -59, -58, -57, -56,
-55, -54, -52, -50, -49, -49, -47, -45, -45, -43, -43, -41, -39, -38, -38, -36,
-34, -33, -32, -31, -29, -28, -27, -25, -24, -22, -22, -20, -19, -18, -17, -15,
-13, -12, -11, -9, -8, -7, -5, -4, -3, -1, 0, };