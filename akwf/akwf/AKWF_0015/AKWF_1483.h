#define DATA_LENGTH 512
#define DATA AKWF_1483

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 10, 14, 18, 22, 26, 29, 33, 35,
38, 41, 44, 45, 46, 49, 51, 52, 51, 52, 54, 55, 54, 55, 56, 55, 56, 54, 55, 55,
54, 54, 52, 52, 53, 52, 50, 50, 49, 49, 47, 47, 46, 47, 45, 45, 43, 43, 43, 41,
41, 40, 40, 40, 39, 38, 37, 37, 36, 36, 35, 34, 34, 33, 33, 33, 31, 31, 31, 30,
29, 29, 28, 29, 28, 28, 27, 26, 27, 26, 25, 25, 24, 23, 23, 23, 22, 22, 21, 21,
20, 20, 19, 19, 17, 17, 17, 17, 16, 15, 15, 14, 14, 14, 13, 13, 12, 12, 11, 11,
10, 10, 10, 9, 8, 8, 7, 7, 7, 6, 5, 5, 5, 5, 4, 4, 3, 2, 2, 2, 2, 1, 1, 0, 0, 0,
0, 0, 0, 0, -1, -2, -2, -2, -2, -3, -3, -3, -3, -3, -5, -4, -5, -5, -4, -5, -5,
-5, -6, -5, -6, -6, -6, -6, -6, -7, -6, -7, -7, -7, -7, -7, -7, -7, -7, -8, -7,
-8, -8, -7, -7, -7, -7, -7, -7, -8, -8, -8, -8, -7, -7, -8, -8, -7, -8, -8, -8,
-8, -8, -7, -7, -8, -7, -7, -7, -7, -7, -7, -7, -7, -7, -6, -6, -7, -6, -7, -6,
-6, -6, -6, -6, -5, -6, -6, -6, -5, -5, -5, -6, -5, -5, -5, -5, -5, -4, -5, -4,
-4, -4, -4, -4, -4, -4, -4, -4, -5, -4, -4, -3, -3, -3, -4, -4, -3, -2, -3, -3,
-3, -2, -2, -3, -3, -2, -2, -2, -1, -3, -2, -2, -2, -2, -1, -1, -1, -1, -2, -1,
-1, -1, 0, -1, -1, -1, -1, -1, 0, -1, -1, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 2, 0, 0, 1,
2, 2, 0, 1, 1, 0, 1, 0, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2,
1, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 0, 0, 1, 1, 0, 2, 1, 1, 0, 1, 0, 1, 1, 1,
1, 0, 0, 1, 1, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, -1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, -1, -1, 1, 0, 0, 0, -1, -1, -1,
-1, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, -1, -1, 0, 0, 0, 0, 0, -1, -1, 0, 0,
-1, 0, 0, 0, -1, 0, 0, -1, -3, -3, -6, -6, -10, -14, -18, -23, -29, -35, -43,
-50, -58, -67, -74, -81, -88, -95, -101, -106, -111, -113, -117, -117, -119,
-120, -118, -117, -114, -111, -107, -103, -100, -94, -88, -83, -77, -70, -64,
-58, -52, -45, -40, -33, -26, -21, -15, -10, -3, };