#define DATA_LENGTH 512
#define DATA AKWF_1455

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 125, 115, 122, 116, 122, 117,
122, 117, 120, 118, 121, 118, 120, 118, 120, 119, 120, 119, 119, 119, 118, 119,
119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119, 118, 118, 119,
119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 118, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 120, 120, 119, 119, 118, 118, 119, 119, 119, 119, 120, 118,
120, 119, 119, 118, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119,
119, 120, 119, 120, 119, 120, 119, 119, 119, 119, 118, 120, 119, 119, 118, 119,
119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 120, 119, 121, 118,
119, 117, 121, 117, 121, 116, 121, 116, 121, 116, 121, 117, 122, 117, 121, 115,
-84, -127, -112, -124, -115, -123, -115, -122, -116, -122, -116, -121, -118,
-121, -117, -120, -118, -120, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -118, -120, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -118, -119, -119, -118, -118, -119, -119, -119, -119, -118,
-119, -119, -118, -119, -119, -119, -119, -119, -119, -120, -119, -119, -118,
-119, -119, -120, -118, -119, -119, -119, -119, -119, -118, -120, -118, -120,
-118, -120, -118, -119, -119, -119, -118, -119, -120, -119, -119, -118, -120,
-118, -120, -117, -122, -117, -122, -115, -123, -115, -124, -112, -128, -109,
-128, -71, 127, 114, 121, 119, 119, 121, 117, 121, 117, 121, 117, 121, 117, 122,
117, 120, 117, 120, 117, 120, 118, 120, 118, 120, 119, 120, 119, 118, 119, 118,
119, 118, 119, 118, 119, 118, 120, 119, 120, 119, 119, 118, 119, 119, 119, 118,
118, 119, 119, 118, 120, 119, 119, 118, 119, 118, 119, 119, 120, 120, 119, 119,
118, 119, 119, 119, 118, 120, 118, 120, 119, 120, 119, 120, 119, 120, 118, 119,
119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 120, 117, 121, 117, 121, 116,
121, 115, 122, 115, 123, 113, 125, 111, 127, 77, -122, -117, -119, -120, -118,
-121, -117, -121, -116, -120, -117, -121, -117, -120, -117, -121, -118, -120,
-118, -120, -118, -119, -118, -119, -119, -119, -119, -120, -119, -119, -120,
-118, -119, -119, -120, -119, -119, -119, -119, -118, -120, -119, -119, -118,
-119, -119, -119, -118, -119, -119, -119, -120, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -118,
-119, -120, -118, -120, -119, -118, -119, -120, -119, -118, -120, -120, -120,
-119, -119, -119, -120, -118, -120, -119, -119, -118, -119, -119, -118, -119,
-119, -120, -119, -119, -119, -120, -119, -119, -119, -119, -118, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-120, -118, -120, -118, -121, -118, -121, -116, -121, -116, -122, -117, -123,
-114, -126, -101, };