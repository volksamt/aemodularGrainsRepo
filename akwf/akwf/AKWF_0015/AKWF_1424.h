#define DATA_LENGTH 512
#define DATA AKWF_1424

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 8, 9, 12, 15, 17, 19, 21, 24,
27, 30, 34, 36, 39, 39, 42, 43, 46, 48, 50, 52, 54, 55, 58, 57, 60, 61, 61, 63,
64, 65, 65, 66, 68, 69, 70, 71, 72, 73, 74, 74, 75, 75, 75, 77, 76, 77, 78, 78,
79, 79, 79, 80, 82, 81, 81, 81, 82, 81, 82, 82, 82, 82, 82, 82, 82, 82, 82, 82,
81, 82, 81, 81, 81, 80, 80, 81, 80, 82, 82, 82, 82, 83, 83, 82, 82, 83, 82, 82,
83, 83, 84, 84, 84, 85, 84, 84, 84, 84, 84, 84, 84, 84, 84, 84, 84, 82, 82, 81,
81, 81, 82, 81, 82, 81, 81, 80, 80, 80, 80, 80, 79, 80, 81, 81, 80, 80, 79, 78,
78, 79, 78, 77, 77, 76, 76, 75, 75, 75, 72, 72, 70, 69, 68, 67, 67, 66, 65, 64,
63, 62, 61, 59, 57, 55, 54, 53, 51, 51, 50, 49, 46, 45, 44, 41, 40, 39, 37, 35,
34, 32, 31, 30, 29, 27, 27, 25, 25, 24, 22, 21, 19, 17, 16, 14, 14, 12, 12, 10,
8, 6, 5, 4, 2, 1, 1, 0, -1, -3, -3, -5, -5, -5, -5, -6, -7, -6, -7, -8, -9, -8,
-8, -7, -8, -7, -7, -7, -7, -8, -7, -8, -8, -9, -8, -8, -8, -9, -9, -7, -7, -5,
-5, -5, -5, -4, -4, -2, -2, -1, 0, 0, 2, 3, 4, 4, 5, 6, 7, 7, 7, 8, 8, 9, 9, 10,
11, 11, 11, 12, 13, 13, 13, 13, 12, 11, 11, 12, 12, 13, 14, 13, 13, 13, 12, 13,
12, 13, 12, 11, 12, 12, 13, 11, 11, 9, 9, 9, 8, 8, 7, 6, 6, 6, 5, 4, 4, 1, -1,
-2, -4, -4, -5, -7, -7, -9, -11, -14, -16, -16, -17, -19, -21, -22, -23, -24,
-26, -27, -30, -31, -33, -34, -35, -35, -38, -39, -40, -41, -43, -44, -47, -48,
-49, -49, -50, -51, -52, -52, -54, -55, -56, -58, -58, -59, -60, -62, -63, -64,
-65, -65, -67, -67, -67, -68, -69, -70, -70, -70, -72, -73, -73, -74, -74, -75,
-75, -76, -78, -79, -80, -80, -80, -80, -80, -81, -82, -82, -82, -83, -84, -85,
-86, -88, -88, -88, -89, -89, -90, -90, -90, -91, -92, -92, -93, -94, -94, -95,
-95, -95, -96, -95, -96, -96, -96, -96, -97, -98, -100, -100, -102, -103, -103,
-104, -105, -105, -106, -107, -108, -109, -109, -110, -112, -112, -112, -114,
-113, -115, -114, -115, -116, -116, -117, -117, -118, -118, -117, -119, -118,
-118, -118, -119, -118, -118, -117, -117, -117, -118, -119, -118, -118, -118,
-119, -118, -117, -117, -117, -116, -114, -114, -113, -113, -112, -111, -110,
-108, -106, -106, -105, -104, -102, -100, -98, -97, -96, -94, -93, -91, -88,
-86, -85, -84, -81, -78, -76, -71, -68, -66, -65, -62, -60, -57, -54, -50, -48,
-46, -43, -40, -37, -35, -32, -30, -28, -26, -24, -20, -17, -15, -13, -11, -9,
-6, -2, };