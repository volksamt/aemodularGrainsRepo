#define DATA_LENGTH 512
#define DATA AKWF_1436

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 3, 3, 5, 6, 7, 7, 8, 9,
10, 10, 12, 12, 13, 14, 15, 16, 17, 16, 18, 18, 19, 21, 21, 22, 23, 24, 24, 25,
26, 26, 28, 29, 30, 30, 31, 31, 32, 34, 35, 35, 35, 37, 37, 38, 40, 40, 41, 42,
42, 44, 44, 45, 46, 47, 48, 48, 50, 50, 52, 52, 53, 54, 54, 55, 56, 57, 58, 59,
60, 61, 62, 63, 63, 65, 65, 66, 67, 68, 68, 69, 71, 71, 72, 74, 74, 76, 76, 76,
78, 78, 79, 81, 82, 82, 83, 85, 84, 86, 86, 88, 88, 89, 90, 91, 91, 92, 94, 94,
96, 96, 97, 99, 99, 100, 101, 103, 103, 104, 104, 107, 106, 108, 108, 109, 110,
111, 112, 113, 114, 115, 117, 117, 118, 119, 119, 119, 118, 118, 117, 115, 114,
113, 111, 110, 109, 108, 105, 104, 103, 102, 99, 99, 97, 95, 94, 92, 91, 90, 88,
87, 85, 84, 82, 80, 79, 78, 76, 75, 74, 72, 71, 69, 68, 67, 65, 64, 61, 61, 59,
58, 57, 56, 55, 52, 50, 50, 48, 46, 44, 44, 42, 40, 38, 37, 36, 35, 33, 33, 31,
30, 28, 27, 25, 24, 22, 22, 20, 19, 17, 16, 15, 14, 13, 12, 10, 8, 8, 6, 5, 4,
2, 2, 1, 0, -2, -3, -4, -5, -5, -7, -8, -10, -10, -10, -12, -13, -14, -14, -16,
-16, -18, -18, -19, -20, -21, -22, -23, -24, -24, -25, -27, -28, -28, -28, -30,
-31, -31, -32, -32, -33, -34, -35, -36, -36, -37, -38, -38, -39, -41, -40, -41,
-42, -43, -43, -44, -44, -45, -46, -46, -47, -48, -47, -49, -49, -50, -50, -52,
-51, -52, -53, -53, -54, -54, -54, -56, -55, -57, -56, -57, -58, -58, -59, -59,
-59, -59, -60, -61, -61, -62, -61, -62, -63, -64, -63, -64, -65, -65, -65, -65,
-66, -66, -66, -67, -67, -67, -68, -68, -68, -69, -69, -69, -69, -69, -69, -70,
-70, -70, -71, -71, -71, -71, -72, -73, -72, -72, -73, -72, -73, -74, -73, -74,
-74, -75, -74, -74, -75, -75, -74, -74, -74, -74, -74, -74, -74, -74, -74, -73,
-73, -73, -73, -73, -72, -73, -72, -72, -71, -72, -71, -72, -71, -71, -71, -70,
-70, -70, -69, -69, -68, -68, -68, -68, -68, -68, -67, -66, -66, -66, -65, -66,
-65, -65, -63, -63, -63, -63, -63, -62, -61, -61, -61, -60, -60, -59, -59, -58,
-59, -58, -57, -58, -57, -56, -55, -55, -54, -54, -53, -53, -52, -52, -51, -51,
-50, -50, -49, -48, -49, -48, -47, -46, -46, -46, -45, -45, -44, -43, -43, -41,
-41, -42, -41, -40, -39, -38, -39, -38, -36, -36, -36, -35, -34, -34, -32, -32,
-31, -31, -30, -30, -29, -28, -27, -27, -26, -26, -25, -24, -23, -23, -23, -21,
-21, -20, -19, -19, -18, -17, -17, -16, -15, -14, -13, -13, -13, -12, -12, -10,
-10, -9, -8, -7, -7, -5, -5, -4, -4, -2, -2, -1, -1, };