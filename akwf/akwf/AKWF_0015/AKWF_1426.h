#define DATA_LENGTH 512
#define DATA AKWF_1426

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 1, 2, 2, 1, 2, 2, 1, 2, 1, 3,
2, 2, 2, 2, 2, 3, 1, 2, 2, 2, 1, 2, 2, 2, 2, 1, 2, 2, 2, 2, 1, 1, 1, 1, 1, 1, 2,
2, 1, 2, 2, 2, 1, 1, 2, 2, 2, 3, 2, 2, 2, 2, 3, 3, 2, 3, 3, 2, 2, 3, 3, 3, 3, 3,
3, 4, 3, 3, 3, 3, 4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 2, 3, 3, 3, 2, 4, 3,
3, 3, 3, 3, 4, 3, 3, 3, 3, 4, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 3, 3, 4, 4, 3, 2,
3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 2, 3, 3, 3, 3, 3, 3, 2, 3, 4, 3, 2, 3, 3, 3, 3,
3, 4, 3, 2, 3, 2, 3, 3, 2, 3, 3, 3, 2, 3, 2, 2, 3, 3, 3, 3, 3, 3, 2, 3, 3, 2, 3,
2, 2, 2, 3, 3, 3, 3, 2, 3, 3, 3, 2, 2, 2, 2, 2, 1, 2, 1, 2, 2, 1, 2, 2, 1, 2, 2,
1, 2, 2, 2, 1, 2, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 1, 0, 0, 0, 0,
0, 0, 0, 0, 1, 0, 0, -1, 0, 1, 0, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 0, 0, -1, 0,
1, 11, 27, 30, 31, 36, 44, 52, 59, 63, 64, 64, 64, 65, 66, 66, 67, 67, 68, 70,
71, 76, 82, 87, 92, 94, 97, 97, 97, 97, 95, 96, 95, 94, 93, 90, 89, 86, 84, 81,
79, 77, 75, 73, 71, 69, 66, 65, 62, 60, 58, 55, 53, 51, 48, 45, 42, 39, 37, 33,
30, 26, 23, 20, 17, 14, 12, 8, 6, 4, 3, 0, -1, -3, -4, -6, -8, -9, -9, -10, -11,
-14, -14, -15, -17, -18, -19, -21, -23, -24, -26, -28, -30, -32, -35, -36, -38,
-42, -44, -46, -49, -51, -54, -56, -59, -61, -64, -66, -69, -70, -73, -75, -78,
-79, -81, -84, -85, -88, -89, -92, -93, -95, -96, -98, -100, -102, -104, -105,
-107, -109, -111, -112, -112, -114, -115, -116, -117, -116, -117, -118, -118,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -118, -118, -117, -116,
-115, -114, -114, -112, -111, -111, -108, -107, -105, -105, -103, -102, -100,
-99, -98, -95, -95, -93, -92, -91, -89, -87, -86, -84, -83, -81, -80, -79, -77,
-76, -75, -73, -72, -71, -69, -68, -67, -66, -65, -64, -63, -62, -61, -60, -59,
-58, -57, -56, -54, -53, -53, -51, -51, -50, -48, -48, -47, -45, -44, -42, -41,
-40, -39, -38, -36, -34, -32, -31, -30, -29, -29, -26, -25, -24, -23, -22, -21,
-18, -18, -16, -16, -14, -13, -13, -10, -10, -9, -8, -7, -7, -6, -5, -5, -5, -3,
-4, -3, -2, -2, -2, -1, 0, 1, };