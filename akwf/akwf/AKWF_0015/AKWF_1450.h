#define DATA_LENGTH 512
#define DATA AKWF_1450

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 16, 22, 29, 36, 43, 48, 53, 58,
62, 65, 69, 70, 72, 74, 74, 75, 75, 76, 76, 75, 75, 74, 75, 73, 73, 72, 72, 71,
70, 69, 69, 68, 68, 67, 67, 68, 67, 67, 68, 69, 69, 69, 70, 71, 71, 74, 74, 76,
77, 79, 79, 80, 82, 84, 85, 86, 87, 88, 90, 92, 94, 94, 97, 98, 99, 100, 100,
101, 101, 100, 99, 99, 96, 93, 89, 85, 80, 74, 69, 61, 54, 47, 40, 32, 23, 16,
9, 1, -6, -14, -20, -26, -32, -37, -42, -46, -49, -53, -56, -57, -59, -60, -59,
-59, -58, -57, -56, -53, -50, -48, -43, -38, -34, -30, -25, -21, -15, -10, -4,
0, 6, 11, 15, 20, 23, 27, 30, 33, 34, 37, 37, 38, 38, 38, 37, 35, 33, 31, 28,
24, 21, 17, 12, 8, 3, -2, -9, -15, -20, -27, -33, -40, -45, -52, -58, -64, -70,
-76, -81, -86, -91, -96, -100, -104, -107, -110, -113, -115, -117, -118, -118,
-119, -119, -118, -116, -115, -113, -109, -106, -101, -97, -92, -87, -82, -75,
-70, -63, -58, -51, -45, -38, -33, -27, -23, -18, -14, -10, -7, -5, -2, 0, 0, 0,
1, 1, 0, 0, -1, -3, -6, -7, -10, -12, -16, -19, -23, -27, -30, -34, -38, -42,
-46, -50, -53, -58, -61, -64, -68, -70, -73, -75, -76, -78, -79, -80, -80, -80,
-79, -79, -77, -76, -74, -70, -67, -63, -60, -54, -50, -43, -37, -30, -23, -15,
-8, -1, 6, 14, 21, 28, 35, 41, 47, 51, 57, 61, 64, 67, 69, 71, 73, 73, 75, 76,
76, 76, 76, 76, 75, 75, 76, 75, 74, 74, 73, 72, 72, 71, 71, 69, 70, 69, 70, 70,
70, 70, 70, 71, 72, 73, 74, 75, 77, 77, 78, 80, 82, 83, 84, 86, 87, 88, 89, 91,
92, 94, 95, 97, 99, 99, 101, 102, 103, 103, 104, 103, 104, 103, 100, 98, 95, 91,
87, 81, 76, 69, 63, 56, 48, 41, 34, 26, 18, 11, 2, -4, -11, -18, -24, -29, -35,
-39, -43, -48, -50, -52, -55, -55, -57, -57, -57, -55, -55, -53, -50, -47, -44,
-40, -36, -32, -28, -21, -17, -12, -6, -1, 4, 9, 14, 19, 23, 27, 31, 34, 37, 38,
41, 42, 42, 42, 42, 42, 40, 38, 35, 33, 30, 26, 22, 18, 13, 9, 2, -3, -8, -14,
-20, -26, -33, -40, -45, -51, -57, -63, -69, -74, -80, -84, -89, -93, -97, -101,
-104, -107, -108, -111, -112, -113, -113, -113, -113, -111, -110, -108, -105,
-101, -98, -94, -88, -83, -78, -72, -66, -60, -53, -48, -43, -36, -29, -25, -20,
-16, -12, -8, -5, -2, 0, 1, 2, 3, 5, 4, 4, 3, 2, 0, -2, -4, -6, -9, -12, -16,
-19, -22, -26, -30, -34, -37, -42, -45, -49, -53, -56, -60, -63, -65, -68, -70,
-71, -72, -73, -75, -75, -75, -75, -74, -72, -71, -70, -66, -64, -59, -55, -52,
-45, -39, -33, -27, -19, -13, -4, };