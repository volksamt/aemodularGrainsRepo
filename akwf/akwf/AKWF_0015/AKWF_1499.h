#define DATA_LENGTH 512
#define DATA AKWF_1499

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 6, 10, 13, 16, 19, 22, 26, 28,
32, 34, 37, 40, 43, 47, 50, 52, 55, 57, 61, 63, 65, 68, 70, 72, 74, 77, 78, 79,
82, 83, 84, 84, 86, 86, 88, 88, 88, 88, 89, 88, 88, 88, 87, 86, 85, 83, 83, 81,
79, 78, 76, 74, 71, 69, 67, 64, 62, 58, 55, 53, 49, 46, 42, 39, 35, 30, 27, 23,
18, 15, 10, 5, 0, -4, -9, -14, -19, -25, -28, -33, -39, -45, -50, -55, -60, -65,
-70, -76, -81, -85, -91, -95, -98, -102, -106, -110, -112, -114, -115, -117,
-118, -120, -119, -119, -118, -117, -116, -114, -111, -110, -107, -105, -101,
-97, -94, -91, -86, -83, -78, -74, -69, -65, -60, -56, -50, -47, -42, -37, -32,
-27, -23, -18, -14, -10, -5, -2, 2, 5, 9, 12, 15, 18, 21, 23, 24, 27, 28, 30,
31, 32, 33, 32, 33, 33, 32, 31, 30, 29, 27, 25, 23, 22, 21, 18, 16, 16, 13, 12,
11, 9, 9, 7, 7, 7, 6, 5, 5, 6, 5, 5, 6, 7, 7, 9, 10, 9, 12, 12, 14, 14, 17, 17,
18, 20, 22, 22, 23, 26, 26, 29, 30, 31, 33, 33, 35, 36, 36, 37, 38, 39, 40, 41,
41, 42, 41, 42, 42, 43, 43, 43, 43, 42, 41, 41, 41, 40, 39, 38, 38, 37, 36, 35,
33, 32, 31, 30, 29, 27, 25, 24, 22, 21, 18, 17, 15, 13, 12, 10, 8, 6, 5, 3, 2,
-1, -3, -4, -5, -7, -9, -10, -11, -13, -15, -16, -17, -18, -20, -20, -22, -22,
-23, -24, -25, -25, -26, -26, -26, -26, -26, -25, -25, -25, -24, -23, -23, -22,
-21, -20, -19, -17, -14, -14, -11, -9, -7, -4, -1, 0, 3, 6, 8, 12, 15, 18, 21,
25, 28, 31, 34, 36, 40, 43, 45, 48, 49, 50, 52, 52, 52, 53, 53, 53, 52, 51, 50,
49, 48, 45, 43, 41, 39, 36, 33, 30, 28, 24, 22, 17, 15, 11, 8, 5, 2, -1, -5, -8,
-10, -13, -16, -18, -21, -23, -26, -27, -28, -30, -31, -33, -34, -35, -35, -35,
-35, -34, -35, -33, -33, -31, -31, -29, -28, -28, -26, -26, -25, -24, -24, -23,
-22, -24, -23, -23, -23, -25, -25, -26, -26, -27, -28, -29, -29, -31, -31, -32,
-33, -34, -34, -35, -35, -37, -37, -37, -36, -37, -37, -36, -37, -36, -35, -34,
-34, -32, -32, -29, -27, -25, -24, -22, -20, -17, -15, -12, -9, -5, -3, 1, 4, 7,
10, 11, 14, 16, 19, 19, 21, 23, 23, 23, 25, 25, 24, 24, 23, 22, 22, 21, 19, 18,
16, 15, 13, 10, 8, 6, 4, 1, -1, -3, -5, -6, -9, -12, -14, -16, -19, -20, -22,
-25, -27, -29, -30, -32, -34, -35, -36, -37, -39, -39, -40, -41, -41, -42, -42,
-42, -42, -43, -42, -41, -41, -41, -40, -40, -38, -37, -35, -35, -32, -30, -28,
-27, -25, -23, -20, -18, -15, -13, -9, -7, -4, -2, };