#define DATA_LENGTH 512
#define DATA AKWF_1491

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 5, 8, 10, 12, 14, 16, 17, 20,
22, 24, 26, 27, 29, 30, 33, 35, 37, 38, 39, 41, 43, 44, 46, 47, 49, 51, 52, 53,
54, 56, 57, 57, 59, 60, 61, 62, 64, 64, 66, 65, 66, 67, 68, 69, 69, 70, 70, 70,
72, 71, 72, 72, 72, 73, 72, 73, 73, 73, 73, 73, 73, 72, 73, 72, 72, 72, 71, 71,
71, 70, 69, 69, 68, 68, 66, 65, 65, 64, 63, 62, 61, 60, 59, 58, 57, 56, 55, 53,
52, 51, 50, 49, 48, 46, 45, 43, 41, 40, 39, 38, 36, 35, 33, 31, 30, 29, 27, 26,
25, 23, 21, 19, 19, 16, 15, 14, 13, 10, 9, 7, 6, 5, 3, 2, 1, -1, -3, -3, -5, -6,
-8, -9, -10, -11, -12, -13, -15, -15, -17, -18, -19, -19, -20, -21, -22, -23,
-23, -24, -24, -25, -25, -26, -26, -27, -26, -27, -27, -26, -26, -26, -26, -26,
-26, -26, -24, -24, -24, -22, -23, -21, -20, -19, -17, -15, -15, -14, -12, -11,
-9, -7, -5, -4, -1, 0, 2, 5, 8, 10, 12, 14, 16, 19, 22, 24, 27, 29, 33, 34, 37,
39, 41, 45, 47, 48, 51, 52, 54, 56, 58, 59, 61, 62, 63, 66, 67, 67, 68, 69, 69,
70, 70, 71, 71, 71, 71, 73, 72, 71, 71, 71, 70, 71, 70, 69, 68, 68, 67, 67, 66,
65, 64, 63, 63, 61, 60, 59, 58, 57, 56, 53, 53, 52, 51, 49, 48, 46, 45, 45, 43,
42, 41, 39, 38, 37, 35, 35, 33, 32, 31, 29, 28, 28, 27, 26, 26, 25, 23, 22, 23,
21, 21, 20, 20, 20, 19, 19, 18, 19, 18, 18, 18, 19, 19, 19, 19, 20, 20, 21, 22,
23, 23, 25, 25, 25, 27, 27, 29, 31, 30, 32, 33, 33, 34, 34, 36, 37, 37, 39, 39,
39, 39, 39, 40, 39, 40, 40, 40, 38, 39, 38, 37, 37, 36, 36, 34, 33, 32, 32, 31,
29, 28, 27, 25, 23, 22, 21, 18, 17, 14, 13, 11, 9, 6, 5, 3, 1, -1, -3, -5, -8,
-9, -12, -15, -17, -19, -22, -24, -25, -28, -30, -33, -35, -37, -40, -42, -44,
-47, -48, -51, -53, -56, -58, -60, -62, -65, -67, -68, -70, -72, -75, -76, -78,
-79, -82, -83, -86, -88, -88, -91, -92, -94, -96, -97, -98, -99, -101, -103,
-104, -106, -107, -107, -108, -110, -111, -111, -112, -114, -113, -114, -115,
-116, -117, -117, -117, -118, -119, -118, -118, -119, -119, -120, -119, -119,
-119, -119, -118, -118, -118, -118, -117, -116, -116, -116, -115, -115, -113,
-113, -112, -111, -111, -109, -109, -107, -106, -106, -104, -102, -101, -100,
-99, -98, -96, -95, -93, -91, -89, -89, -86, -84, -83, -82, -80, -78, -76, -74,
-72, -70, -68, -66, -65, -62, -60, -58, -56, -55, -51, -50, -48, -46, -43, -41,
-40, -37, -36, -33, -31, -28, -26, -24, -22, -19, -18, -15, -13, -10, -9, -6,
-4, -2, -1, };