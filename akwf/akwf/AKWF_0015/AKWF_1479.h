#define DATA_LENGTH 512
#define DATA AKWF_1479

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 1, 1, 1, 2, 4, 3, 5, 6, 6, 6, 7,
8, 9, 9, 9, 10, 11, 12, 12, 13, 14, 15, 15, 15, 17, 17, 18, 19, 20, 20, 21, 21,
22, 23, 23, 25, 25, 26, 26, 27, 27, 28, 29, 29, 30, 31, 31, 31, 31, 32, 33, 33,
33, 33, 34, 34, 35, 36, 35, 35, 36, 36, 36, 37, 37, 37, 37, 37, 37, 37, 37, 37,
37, 37, 37, 37, 37, 36, 37, 37, 36, 36, 37, 35, 35, 35, 36, 35, 34, 33, 34, 33,
34, 33, 33, 33, 32, 32, 31, 31, 31, 31, 29, 29, 29, 28, 28, 27, 27, 27, 26, 27,
25, 25, 25, 24, 24, 23, 22, 23, 22, 22, 21, 21, 20, 20, 19, 18, 18, 17, 16, 17,
16, 15, 15, 14, 14, 13, 13, 13, 12, 12, 11, 11, 10, 11, 10, 8, 8, 8, 8, 7, 7, 6,
6, 6, 5, 4, 4, 4, 3, 3, 3, 2, 2, 1, 1, 1, 0, 0, 0, 0, -1, -2, -2, -1, -3, -2,
-3, -3, -4, -4, -4, -4, -4, -5, -5, -4, -5, -5, -5, -6, -6, -6, -6, -6, -6, -7,
-7, -7, -7, -7, -7, -8, -7, -8, -7, -8, -8, -8, -7, -8, -8, -8, -8, -9, -8, -7,
-7, -7, -8, -8, -8, -8, -7, -7, -8, -7, -7, -7, -8, -7, -8, -7, -8, -6, -7, -8,
-8, -7, -7, -6, -7, -7, -6, -6, -6, -6, -6, -6, -5, -5, -5, -5, -5, -6, -5, -5,
-4, -5, -3, -4, -4, -4, -4, -4, -3, -2, -3, -2, -2, -2, -2, -2, -1, -2, -1, -1,
0, -2, -1, 0, -1, 0, 1, 0, 0, 0, 1, 0, 0, 1, 2, 1, 1, 1, 1, 1, 2, 1, 2, 2, 2, 2,
2, 3, 3, 4, 3, 3, 3, 3, 4, 3, 4, 3, 3, 3, 4, 4, 4, 4, 4, 5, 4, 5, 4, 4, 4, 5, 4,
5, 5, 5, 4, 5, 5, 5, 5, 5, 6, 5, 5, 5, 5, 5, 5, 5, 5, 6, 5, 6, 6, 5, 5, 5, 4, 5,
5, 5, 5, 5, 5, 5, 5, 6, 5, 4, 5, 5, 4, 4, 5, 4, 4, 5, 4, 4, 5, 4, 4, 5, 3, 4, 4,
4, 4, 4, 4, 3, 4, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 2, 2, 2, 3, 3, 2, 2, 3, 2, 2, 1,
2, 2, 1, 1, 2, 2, 1, 1, 1, 1, 1, 0, 1, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, -1, 0, 0,
0, 0, -1, -1, -2, -9, -21, -34, -46, -58, -68, -79, -87, -96, -103, -111, -118,
-119, -115, -110, -107, -104, -100, -98, -96, -94, -93, -92, -90, -88, -84, -82,
-78, -75, -71, -69, -65, -62, -59, -57, -53, -51, -48, -45, -43, -40, -37, -35,
-33, -30, -27, -26, -24, -22, -21, -20, -17, -16, -14, -13, -11, -10, -10, -9,
-7, -6, -5, -5, -4, -3, -2, -2, -1, };