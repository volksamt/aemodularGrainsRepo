#define DATA_LENGTH 512
#define DATA AKWF_1453

const PROGMEM int8_t DATA[DATA_LENGTH] = {54, 117, 117, 120, 119, 120, 119, 119,
118, 120, 119, 119, 119, 118, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119,
119, 120, 119, 119, 119, 118, 119, 119, 120, 119, 119, 120, 119, 118, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119,
120, 119, 120, 119, 118, 119, 119, 118, 119, 118, 119, 119, 119, 120, 119, 119,
119, 119, 120, 119, 119, 118, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119,
119, 119, 119, 118, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 119,
119, 120, 119, 118, 120, 120, 119, 119, 119, 120, 118, 119, 120, 120, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 120, 118, 118, 119, 119, 120,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 118,
118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
119, 119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 118, 120, 120, 119, 118,
119, 119, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119, 120, 119,
119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 120, 119, 120, 119, 119, 119, 119, 119, 120, 118, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 118, 119, 118, 120, 118, 120, 117, 121, 118, 120,
118, 120, 116, 121, 117, 121, 117, 120, 118, 119, 119, 119, 121, 111, 123, -66,
-128, -108, -128, -113, -124, -115, -122, -116, -122, -117, -121, -117, -121,
-118, -119, -120, -120, -119, -120, -119, -118, -120, -119, -119, -118, -119,
-118, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -120, -120, -119, -118,
-119, -119, -120, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -120, -119, -119, -118, -119, -118,
-119, -119, -119, -118, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -118,
-119, -120, -119, -119, -118, -119, -118, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -118, -120, -119, -118, -119, -118,
-119, -119, -120, -119, -119, -119, -120, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -118, -120, -119, -119, -119, -120, -120, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -118, -119, -119, -119, -118, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -118, -120, -118, -120, -117,
-120, -114, -120, -116, -123, -114, -122, -94, };