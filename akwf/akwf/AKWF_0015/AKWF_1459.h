#define DATA_LENGTH 512
#define DATA AKWF_1459

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 115, 122, 116, 122, 116,
121, 117, 121, 117, 121, 118, 120, 117, 120, 118, 120, 118, 120, 118, 118, 119,
119, 120, 118, 120, 118, 121, 117, 121, 116, 123, 113, 126, 110, 127, 61, -45,
-20, -34, -25, -30, -26, -29, -27, -28, -28, -28, -29, -27, -29, -28, -30, -27,
-29, -27, -29, -28, -29, -28, -29, -28, -29, -29, -29, -28, -29, -29, -28, -29,
-29, -28, -29, -28, -28, -29, -29, -29, -28, -29, -28, -28, -29, -29, -28, -28,
-28, -28, -28, -28, -28, -29, -28, -28, -29, -28, -28, -29, -28, -28, -27, -29,
-28, -29, -28, -30, -28, -28, -28, -29, -28, -29, -28, -29, -28, -29, -29, -28,
-29, -28, -29, -26, -31, -26, -31, -24, -35, -18, -45, 34, 127, 110, 124, 116,
121, 117, 120, 119, 119, 119, 118, 119, 118, 120, 117, 120, 118, 119, 117, 120,
118, 119, 118, 119, 118, 119, 119, 119, 118, 118, 119, 118, 119, 119, 118, 118,
119, 119, 119, 119, 118, 119, 118, 119, 118, 119, 118, 120, 117, 119, 117, 119,
117, 120, 116, 121, 116, 120, 116, 122, 98, -26, -31, -27, -31, -27, -30, -27,
-31, -27, -30, -28, -30, -28, -30, -28, -30, -28, -30, -28, -30, -30, -29, -29,
-29, -30, -28, -29, -29, -29, -29, -29, -28, -29, -29, -29, -29, -30, -28, -29,
-28, -29, -29, -29, -29, -29, -30, -29, -29, -30, -29, -29, -29, -28, -29, -29,
-28, -29, -29, -29, -29, -28, -29, -29, -29, -29, -30, -29, -29, -30, -28, -28,
-29, -29, -28, -29, -29, -29, -29, -29, -29, -29, -29, -28, -29, -29, -28, -29,
-28, -28, -29, -29, -28, -29, -28, -28, -29, -29, -29, -29, -29, -29, -28, -29,
-28, -29, -29, -29, -28, -29, -28, -29, -29, -28, -29, -29, -29, -29, -28, -28,
-29, -28, -28, -29, -29, -29, -28, -28, -28, -29, -28, -28, -28, -29, -29, -29,
-29, -28, -29, -29, -29, -28, -28, -29, -29, -29, -29, -28, -29, -29, -28, -29,
-29, -29, -28, -28, -28, -29, -28, -29, -29, -28, -29, -29, -28, -29, -28, -29,
-29, -29, -29, -29, -29, -29, -28, -28, -28, -28, -29, -28, -28, -29, -29, -28,
-28, -28, -28, -29, -29, -28, -29, -28, -29, -29, -29, -28, -29, -28, -28, -28,
-29, -28, -28, -29, -28, -29, -28, -28, -28, -28, -28, -28, -28, -28, -29, -28,
-28, -29, -29, -29, -29, -28, -28, -28, -28, -28, -28, -28, -28, -28, -29, -29,
-28, -28, -28, -29, -28, -29, -28, -29, -28, -29, -29, -28, -29, -28, -28, -29,
-29, -28, -28, -28, -28, -28, -29, -29, -28, -28, -28, -28, -28, -29, -27, -28,
-28, -28, -28, -28, -28, -28, -28, -28, -28, -27, -29, -28, -27, -28, -29, -28,
-28, -28, -28, -28, -28, -29, -28, -28, -28, -28, -28, -28, -28, -28, -28, -28,
-28, -27, -27, -28, -28, -28, -28, -28, -28, -28, -28, -28, -27, -28, -28, -28,
-27, -29, -27, -29, -28, -29, -27, -29, -23, };