#define DATA_LENGTH 512
#define DATA AKWF_1500

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 9, 11, 14, 17, 19, 22, 27,
30, 33, 36, 39, 41, 45, 48, 51, 54, 57, 60, 62, 65, 68, 71, 74, 76, 78, 81, 84,
87, 89, 92, 93, 93, 91, 92, 95, 96, 96, 98, 99, 100, 100, 100, 101, 102, 102,
102, 102, 103, 104, 103, 104, 103, 104, 103, 104, 104, 104, 103, 103, 104, 104,
102, 103, 102, 102, 102, 101, 101, 101, 100, 100, 100, 99, 99, 99, 97, 98, 96,
95, 93, 93, 94, 94, 94, 94, 96, 96, 97, 98, 98, 98, 98, 98, 100, 100, 101, 102,
103, 103, 103, 104, 104, 106, 107, 106, 107, 108, 108, 109, 110, 111, 111, 111,
111, 113, 113, 114, 114, 114, 115, 115, 116, 116, 116, 117, 117, 116, 117, 118,
117, 118, 118, 118, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119,
118, 118, 118, 118, 118, 118, 117, 116, 117, 116, 117, 114, 114, 114, 114, 113,
112, 112, 111, 110, 110, 108, 108, 108, 106, 105, 104, 102, 101, 100, 98, 97,
97, 96, 95, 93, 92, 90, 89, 88, 87, 85, 83, 81, 80, 78, 76, 76, 74, 74, 72, 71,
70, 68, 67, 67, 65, 64, 62, 61, 60, 58, 57, 55, 55, 53, 52, 51, 50, 48, 48, 46,
45, 44, 43, 41, 40, 38, 38, 36, 35, 34, 33, 32, 30, 29, 28, 27, 25, 24, 23, 23,
20, 19, 18, 17, 15, 13, 12, 11, 10, 9, 7, 6, 4, 3, 2, 0, 0, -2, -4, -4, -7, -7,
-9, -10, -12, -13, -14, -16, -17, -19, -19, -21, -21, -24, -25, -26, -27, -28,
-29, -31, -32, -33, -34, -35, -37, -37, -38, -40, -41, -42, -43, -45, -47, -47,
-49, -49, -51, -53, -53, -55, -56, -57, -58, -61, -61, -63, -64, -64, -65, -67,
-68, -69, -71, -72, -73, -74, -76, -77, -78, -79, -81, -83, -85, -86, -88, -89,
-91, -93, -93, -94, -96, -96, -97, -98, -99, -101, -102, -104, -106, -107, -109,
-109, -109, -109, -110, -112, -112, -113, -113, -114, -114, -115, -115, -115,
-116, -116, -117, -116, -118, -118, -119, -118, -119, -119, -118, -119, -119,
-119, -120, -119, -118, -119, -119, -119, -119, -119, -119, -119, -118, -118,
-118, -118, -117, -116, -116, -116, -116, -116, -115, -114, -115, -114, -114,
-114, -113, -112, -111, -111, -110, -109, -110, -109, -109, -108, -106, -106,
-105, -105, -105, -104, -102, -102, -102, -102, -100, -99, -98, -98, -98, -97,
-97, -96, -95, -95, -94, -95, -94, -95, -94, -93, -96, -98, -98, -98, -98, -98,
-99, -100, -100, -100, -101, -101, -101, -101, -102, -103, -103, -103, -103,
-103, -104, -103, -104, -104, -103, -103, -104, -104, -104, -104, -104, -103,
-103, -101, -102, -102, -101, -101, -100, -99, -99, -97, -97, -95, -94, -93,
-91, -94, -93, -91, -88, -86, -83, -81, -78, -76, -74, -71, -67, -65, -62, -60,
-57, -53, -51, -48, -45, -42, -39, -36, -33, -30, -27, -22, -20, -17, -14, -12,
-10, -6, -3, -1, };