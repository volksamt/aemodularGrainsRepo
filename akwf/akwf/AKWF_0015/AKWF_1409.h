#define DATA_LENGTH 512
#define DATA AKWF_1409

const PROGMEM int8_t DATA[DATA_LENGTH] = {19, 43, 57, 71, 77, 82, 82, 82, 81,
81, 82, 84, 87, 90, 95, 98, 103, 105, 109, 112, 114, 116, 117, 117, 119, 118,
118, 119, 118, 118, 119, 119, 119, 119, 118, 119, 119, 120, 119, 120, 119, 119,
119, 119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 119, 119, 119, 118, 119,
119, 119, 118, 119, 118, 118, 118, 118, 118, 118, 119, 119, 118, 119, 118, 119,
119, 118, 119, 119, 118, 119, 119, 119, 119, 118, 118, 119, 118, 118, 119, 119,
119, 118, 118, 118, 118, 119, 118, 119, 119, 119, 118, 119, 119, 118, 118, 119,
119, 119, 119, 119, 119, 119, 119, 118, 118, 118, 119, 119, 118, 119, 119, 119,
119, 118, 119, 119, 119, 119, 119, 118, 119, 118, 118, 119, 118, 119, 118, 119,
119, 119, 119, 118, 119, 119, 118, 118, 118, 119, 118, 119, 119, 119, 118, 118,
119, 119, 118, 119, 119, 119, 118, 118, 119, 119, 119, 118, 118, 119, 119, 119,
119, 119, 118, 118, 119, 119, 119, 118, 118, 118, 119, 119, 119, 118, 119, 119,
119, 118, 119, 119, 119, 119, 119, 119, 118, 118, 119, 118, 119, 119, 118, 118,
119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119,
119, 119, 118, 119, 120, 119, 119, 118, 119, 118, 119, 118, 118, 119, 118, 119,
119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
119, 117, 99, 69, 33, 2, -23, -44, -60, -71, -79, -81, -82, -82, -82, -82, -83,
-84, -87, -91, -95, -99, -103, -106, -110, -112, -114, -115, -116, -117, -118,
-118, -119, -119, -119, -119, -118, -118, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -118,
-119, -119, -118, -118, -119, -118, -118, -119, -119, -119, -118, -119, -118,
-119, -118, -118, -118, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-118, -119, -119, -119, -119, -119, -119, -118, -118, -118, -119, -119, -118,
-118, -119, -118, -119, -118, -118, -119, -118, -118, -118, -118, -118, -118,
-118, -118, -118, -118, -119, -119, -118, -118, -118, -119, -118, -119, -119,
-119, -119, -118, -119, -118, -119, -119, -118, -118, -119, -119, -118, -119,
-119, -119, -119, -118, -119, -119, -119, -118, -118, -119, -118, -118, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -118, -118, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -118, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -118, -118, -118, -119, -119, -119, -118, -119, -119, -118, -119, -119,
-119, -118, -119, -119, -118, -118, -119, -118, -118, -119, -118, -118, -119,
-119, -119, -119, -119, -119, -119, -118, -118, -119, -118, -119, -118, -118,
-118, -118, -118, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -118, -119, -118, -118, -118, -118, -118, -119, -118, -119, -119, -118,
-118, -119, -118, -119, -119, -116, -96, -64, -29, -1, };