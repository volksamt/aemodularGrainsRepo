#define DATA_LENGTH 512
#define DATA AKWF_1458

const PROGMEM int8_t DATA[DATA_LENGTH] = {44, 52, 50, 52, 50, 52, 50, 51, 49,
51, 49, 52, 49, 51, 51, 52, 51, 51, 50, 51, 51, 50, 51, 51, 51, 50, 51, 50, 51,
51, 51, 51, 51, 51, 51, 51, 50, 51, 51, 50, 51, 50, 51, 51, 51, 51, 51, 51, 51,
52, 50, 50, 51, 52, 50, 51, 50, 51, 51, 51, 50, 51, 51, 51, 50, 51, 51, 51, 51,
51, 51, 50, 51, 50, 51, 51, 51, 51, 51, 51, 50, 51, 51, 50, 51, 50, 50, 51, 50,
50, 51, 51, 51, 50, 51, 51, 50, 51, 51, 50, 51, 50, 51, 51, 51, 50, 51, 51, 51,
50, 50, 50, 51, 50, 50, 50, 50, 50, 50, 50, 50, 51, 50, 51, 50, 51, 51, 51, 50,
50, 50, 50, 50, 50, 50, 50, 50, 50, 51, 50, 51, 51, 50, 50, 51, 49, 50, 49, 51,
50, 50, 49, 51, 50, 51, 49, 51, 50, 51, 50, 50, 50, 50, 51, 49, 51, 49, 52, 47,
53, 47, 53, 46, 54, 45, 57, 44, 58, 41, 61, 29, -117, -122, -114, -124, -112,
38, 57, 44, 56, 45, 55, 45, 55, 45, 53, 47, 52, 48, 51, 50, 50, 50, 48, 53, 45,
55, 44, 58, 39, 69, -16, -128, -110, -124, -113, -123, -115, -123, -113, -125,
-109, -128, -44, 72, 38, 58, 44, 53, 47, 51, 49, 50, 49, 50, 49, 49, 50, 49, 51,
49, 51, 49, 51, 49, 51, 49, 50, 49, 51, 49, 51, 50, 51, 49, 50, 50, 49, 51, 50,
50, 50, 51, 49, 51, 49, 50, 49, 50, 50, 50, 49, 49, 50, 49, 51, 49, 52, 48, 51,
48, 52, 47, 52, 46, 53, 46, 53, 45, 57, 35, -119, -120, -118, -121, -117, -122,
-117, -121, -117, -121, -118, -120, -117, -120, -117, -121, -118, -120, -118,
-119, -118, -119, -118, -119, -118, -119, -119, -119, -119, -119, -119, -118,
-118, -119, -119, -118, -119, -119, -119, -118, -120, -118, -120, -118, -120,
-117, -120, -117, -120, -117, -120, -117, -121, -117, -121, -117, -118, -119,
-118, -120, -114, -128, 17, 63, 42, 56, 45, 54, 46, 54, 48, 53, 48, 51, 49, 51,
49, 51, 50, 50, 50, 50, 51, 50, 50, 50, 51, 50, 51, 50, 51, 50, 51, 49, 51, 49,
50, 49, 50, 49, 51, 50, 51, 49, 50, 49, 50, 49, 50, 50, 50, 51, 50, 51, 49, 50,
50, 51, 50, 51, 50, 51, 50, 51, 49, 50, 49, 52, 49, 51, 49, 51, 49, 50, 50, 50,
50, 50, 51, 48, 52, 47, 53, 46, 57, 39, 71, -35, -128, -108, -125, -114, -122,
-116, -120, -117, -119, -118, -119, -118, -118, -119, -118, -120, -118, -119,
-118, -120, -117, -120, -118, -120, -117, -120, -118, -119, -118, -119, -119,
-119, -118, -119, -118, -118, -118, -118, -118, -118, -120, -117, -118, -118,
-119, -118, -119, -118, -119, -117, -118, -117, -119, -118, -118, -118, -118,
-119, -118, -119, -117, -120, -117, -119, -115, -121, -116, -120, -115, -122,
-114, -125, -101, };