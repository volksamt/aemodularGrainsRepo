#define DATA_LENGTH 512
#define DATA AKWF_1462

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 115, 122, 117, 122, 117,
121, 117, 121, 118, 121, 117, 120, 118, 120, 118, 119, 119, 119, 119, 119, 119,
118, 119, 119, 120, 119, 119, 118, 119, 118, 119, 119, 118, 119, 119, 119, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 118, 119, 119, 119, 119,
119, 118, 119, 119, 119, 119, 119, 118, 119, 119, 118, 118, 119, 119, 118, 118,
118, 118, 118, 119, 119, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118,
118, 119, 118, 119, 118, 118, 119, 117, 118, 118, 119, 119, 118, 117, 118, 118,
117, 118, 118, 118, 118, 118, 118, 118, 117, 118, 117, 117, 118, 118, 117, 118,
117, 118, 118, 118, 118, 118, 117, 118, 117, 118, 118, 118, 117, 117, 118, 117,
117, 117, 118, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117,
117, 116, 118, 117, 117, 117, 117, 117, 118, 117, 117, 117, 116, 117, 118, 117,
117, 117, 116, 117, 118, 117, 117, 117, 117, 117, 117, 116, 116, 116, 117, 117,
117, 116, 117, 116, 116, 117, 116, 117, 117, 116, 116, 116, 116, 117, 116, 116,
116, 117, 116, 117, 116, 117, 116, 117, 116, 117, 117, 116, 115, 116, 116, 117,
116, 117, 115, 116, 117, 115, 115, 116, 116, 116, 117, 116, 117, 115, 117, 115,
117, 115, 117, 114, 118, 114, 117, 114, 117, 115, 117, 115, 116, 116, 115, 117,
114, 119, 110, 124, 103, 127, -23, -128, -102, -127, -109, -123, -112, -120,
-114, -119, -115, -118, -117, -118, -117, -117, -117, -116, -118, -116, -118,
-116, -118, -115, -118, -116, -118, -116, -117, -117, -117, -116, -117, -116,
-117, -116, -116, -116, -117, -116, -116, -116, -117, -117, -116, -116, -116,
-117, -117, -117, -116, -117, -117, -116, -117, -117, -117, -117, -117, -117,
-116, -117, -116, -117, -116, -116, -116, -116, -116, -116, -116, -116, -116,
-116, -117, -116, -117, -117, -117, -117, -117, -117, -115, -116, -116, -115,
-115, -117, -116, -116, -115, -116, -116, -117, -116, -116, -117, -117, -116,
-116, -116, -116, -116, -116, -116, -115, -116, -116, -115, -117, -116, -115,
-115, -116, -115, -116, -115, -116, -115, -115, -115, -116, -115, -116, -116,
-116, -115, -116, -115, -116, -116, -115, -115, -115, -115, -116, -115, -115,
-115, -115, -115, -116, -116, -116, -115, -115, -116, -115, -115, -115, -115,
-115, -115, -116, -115, -115, -114, -114, -115, -114, -115, -115, -115, -115,
-116, -115, -115, -115, -115, -115, -115, -114, -115, -115, -115, -114, -115,
-115, -114, -115, -115, -115, -115, -115, -115, -114, -115, -115, -114, -115,
-114, -115, -114, -114, -114, -114, -114, -114, -115, -115, -114, -114, -114,
-114, -114, -114, -114, -115, -115, -114, -114, -115, -114, -114, -115, -114,
-114, -114, -114, -114, -114, -115, -115, -113, -114, -114, -114, -114, -114,
-113, -114, -114, -114, -113, -114, -114, -114, -114, -113, -114, -114, -114,
-113, -114, -113, -115, -112, -115, -113, -115, -112, -116, -112, -116, -110,
-117, -109, -120, -97, };