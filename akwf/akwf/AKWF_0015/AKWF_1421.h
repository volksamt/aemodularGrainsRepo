#define DATA_LENGTH 512
#define DATA AKWF_1421

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 5, 6, 8, 9, 12, 14, 15, 16,
17, 19, 20, 22, 23, 24, 25, 26, 28, 29, 30, 30, 31, 31, 32, 31, 32, 32, 33, 33,
33, 34, 34, 34, 34, 33, 32, 33, 32, 31, 30, 30, 29, 28, 27, 27, 26, 25, 24, 24,
23, 22, 22, 20, 20, 19, 18, 17, 17, 15, 14, 13, 13, 12, 11, 12, 11, 11, 10, 10,
10, 9, 8, 7, 8, 7, 8, 7, 7, 8, 7, 8, 9, 9, 9, 10, 10, 11, 11, 12, 12, 12, 14,
14, 14, 16, 16, 17, 18, 19, 20, 21, 22, 23, 23, 23, 24, 25, 26, 26, 27, 28, 29,
30, 30, 31, 32, 32, 32, 33, 33, 34, 35, 36, 36, 37, 38, 38, 39, 40, 39, 40, 41,
41, 41, 42, 42, 42, 42, 42, 43, 43, 44, 43, 44, 43, 45, 44, 45, 45, 44, 45, 44,
45, 45, 44, 45, 44, 45, 45, 45, 45, 46, 46, 45, 45, 45, 47, 46, 47, 47, 46, 47,
46, 47, 47, 47, 47, 48, 48, 47, 48, 47, 46, 45, 45, 45, 45, 45, 44, 44, 44, 45,
44, 43, 42, 42, 43, 45, 45, 43, 42, 41, 39, 35, 30, 25, 21, 18, 13, 9, 6, 3, -1,
-4, -9, -13, -17, -22, -27, -30, -36, -40, -45, -50, -54, -60, -64, -69, -73,
-78, -80, -84, -86, -90, -93, -96, -99, -102, -105, -109, -110, -113, -114,
-117, -119, -118, -119, -118, -119, -118, -117, -117, -116, -115, -115, -113,
-111, -110, -107, -105, -101, -98, -95, -91, -87, -82, -78, -73, -69, -65, -59,
-56, -51, -47, -42, -38, -35, -31, -26, -22, -19, -14, -9, -6, -2, 2, 5, 8, 11,
12, 15, 17, 19, 22, 24, 27, 29, 31, 33, 35, 36, 38, 39, 41, 41, 42, 42, 41, 40,
40, 40, 40, 39, 38, 36, 34, 32, 32, 29, 25, 24, 20, 17, 14, 11, 8, 5, 1, -2, -5,
-8, -11, -14, -17, -18, -23, -24, -28, -31, -34, -36, -39, -42, -44, -46, -48,
-50, -52, -53, -54, -55, -57, -59, -59, -60, -61, -62, -63, -63, -63, -63, -63,
-63, -62, -62, -61, -60, -58, -56, -55, -52, -51, -49, -47, -45, -42, -41, -38,
-35, -33, -29, -26, -24, -19, -17, -15, -12, -8, -7, -5, -2, 2, 5, 6, 9, 12, 14,
16, 18, 20, 23, 26, 29, 30, 33, 34, 35, 36, 38, 38, 39, 41, 41, 42, 43, 45, 44,
45, 44, 44, 44, 44, 44, 44, 44, 42, 41, 40, 39, 37, 36, 33, 33, 32, 30, 29, 28,
26, 25, 22, 20, 19, 16, 14, 12, 10, 7, 6, 4, 2, 0, -1, -2, -5, -5, -7, -10, -11,
-13, -15, -19, -19, -21, -23, -24, -24, -26, -28, -29, -29, -30, -30, -31, -32,
-32, -33, -33, -34, -34, -35, -35, -35, -34, -34, -34, -32, -32, -31, -29, -29,
-28, -27, -27, -25, -23, -23, -22, -20, -19, -18, -17, -15, -13, -11, -11, -8,
-7, -5, -3, -1, };