#define DATA_LENGTH 512
#define DATA AKWF_1477

const PROGMEM int8_t DATA[DATA_LENGTH] = {88, 105, 96, 104, 99, 102, 99, 102,
99, 102, 100, 102, 99, 102, 100, 101, 100, 101, 100, 101, 101, 100, 101, 100,
101, 99, 100, 100, 101, 100, 100, 100, 100, 100, 100, 100, 101, 100, 100, 101,
101, 100, 100, 100, 100, 101, 100, 100, 100, 100, 100, 101, 100, 100, 101, 100,
100, 99, 100, 100, 100, 101, 100, 99, 100, 100, 100, 99, 100, 99, 100, 100, 100,
100, 100, 99, 100, 100, 99, 100, 100, 100, 99, 99, 100, 100, 100, 100, 99, 99,
100, 99, 99, 99, 99, 100, 99, 99, 100, 100, 99, 99, 99, 99, 99, 100, 99, 99, 99,
99, 99, 99, 98, 99, 98, 100, 100, 99, 99, 99, 99, 100, 99, 99, 99, 99, 99, 99,
100, 99, 99, 99, 99, 99, 98, 99, 99, 99, 99, 99, 99, 99, 100, 100, 100, 99, 98,
98, 99, 98, 98, 99, 98, 99, 99, 99, 98, 99, 99, 98, 98, 99, 98, 98, 99, 99, 98,
99, 98, 100, 98, 99, 98, 99, 98, 99, 98, 99, 98, 99, 97, 99, 97, 99, 99, 98, 98,
98, 99, 97, 99, 97, 100, 95, 101, 94, 103, 92, 110, 62, -24, -6, -16, -10, -12,
-11, -12, -11, -12, -12, -12, -13, -11, -13, -12, -12, -12, -13, -12, -13, -12,
-12, -12, -12, -11, -12, -12, -12, -11, -13, -11, -13, -12, -12, -12, -12, -12,
-13, -11, -12, -12, -13, -11, -13, -12, -13, -12, -13, -12, -11, -13, -10, -16,
-3, -92, -128, -113, -124, -116, -122, -117, -121, -117, -120, -118, -120, -118,
-120, -118, -120, -120, -119, -120, -119, -119, -119, -120, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -118, -119, -119, -118, -119, -119, -119, -118, -118, -118,
-118, -119, -118, -118, -118, -119, -118, -118, -118, -118, -119, -118, -118,
-119, -118, -118, -119, -118, -119, -118, -118, -119, -118, -118, -118, -118,
-118, -118, -118, -118, -119, -119, -117, -118, -118, -118, -118, -117, -118,
-117, -118, -118, -118, -118, -118, -117, -118, -117, -117, -119, -117, -118,
-118, -117, -117, -117, -117, -118, -118, -117, -118, -118, -118, -117, -117,
-118, -117, -117, -118, -117, -117, -118, -118, -117, -117, -117, -117, -117,
-118, -117, -118, -116, -118, -117, -118, -117, -117, -117, -117, -116, -117,
-116, -118, -117, -118, -117, -116, -117, -116, -118, -115, -120, -111, -128,
-46, 5, -14, -2, -11, -4, -9, -4, -9, -5, -8, -6, -8, -7, -6, -7, -7, -8, -7,
-7, -7, -8, -6, -7, -6, -7, -6, -8, -7, -8, -6, -7, -7, -6, -8, -7, -7, -7, -6,
-7, -7, -7, -7, -7, -7, -7, -7, -7, -6, -6, -7, -7, -7, -7, -6, -6, -6, -7, -7,
-6, -6, -7, -7, -6, -6, -7, -7, -7, -8, -6, -6, -6, -7, -6, -7, -7, -6, -7, -7,
-7, -6, -7, -7, -7, -6, -7, -6, -7, -8, -6, -7, -7, -7, -6, -7, -7, -7, -6, -7,
-6, -7, -5, };