#define DATA_LENGTH 512
#define DATA AKWF_1448

const PROGMEM int8_t DATA[DATA_LENGTH] = {54, 122, 117, 120, 118, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119,
120, 118, 119, 119, 120, 119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 120, 119, 118, 119, 118, 119, 120, 120, 119, 119, 119, 119, 119, 119,
119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 120, 118, 119, 120, 119, 120,
119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119,
120, 120, 119, 120, 119, 118, 120, 119, 120, 119, 119, 119, 119, 119, 120, 118,
119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 118, 119, 120, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 118, 119, 119,
120, 119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 120, 119, 119, 119,
119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 119, 119, 120, 120, 120, 119, 119, 119, 119, 119, 119, 119, 118, 119,
119, 118, 119, 119, 119, 119, 119, 120, 119, 120, 120, 118, 119, 118, 119, 119,
119, 119, 119, 119, 119, 119, 120, 119, 118, 119, 118, 120, 118, 120, 119, 119,
119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119,
119, 119, 120, 119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 120, 118, 120,
117, 120, 117, 123, 115, 127, 56, -84, -117, -120, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -118, -119, -118, -119, -118, -120, -119,
-120, -119, -119, -119, -119, -120, -119, -118, -118, -118, -119, -119, -119,
-120, -119, -120, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -120, -120, -119, -119, -119, -119, -119, -120, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -118, -119, -119, -120,
-118, -119, -119, -119, -120, -118, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -118,
-120, -120, -119, -120, -119, -119, -118, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -118, -119, -119, -118,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -120, -120, -119, -120, -119, -119, -120, -120, -119, -119, -119, -120,
-119, -119, -118, -119, -119, -120, -119, -119, -119, -119, -120, -119, -119,
-120, -119, -119, -120, -119, -119, -120, -119, -119, -119, -120, -119, -120,
-118, -119, -119, -118, -119, -118, -118, -120, -118, -119, -119, -119, -119,
-118, -119, -119, -119, -120, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -120, -120, -118, -119, -120, -119, -119, -119, -119, -120, -119, -120,
-118, -119, -118, -120, -118, -120, -118, -119, -119, -120, -118, -35, };