#define DATA_LENGTH 512
#define DATA AKWF_1422

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 9, 9, 9, 9, 9, 11, 12, 14,
16, 18, 20, 19, 18, 16, 14, 14, 16, 17, 21, 23, 25, 24, 24, 22, 21, 20, 19, 19,
21, 23, 26, 26, 27, 26, 24, 23, 21, 22, 24, 27, 29, 29, 28, 27, 27, 28, 30, 31,
32, 34, 35, 35, 37, 40, 41, 44, 44, 42, 41, 41, 43, 46, 49, 52, 52, 52, 50, 50,
52, 56, 59, 61, 60, 60, 60, 60, 64, 67, 71, 72, 72, 70, 70, 71, 72, 75, 75, 74,
73, 73, 75, 76, 78, 79, 78, 76, 75, 74, 75, 78, 79, 79, 77, 75, 74, 75, 77, 78,
79, 78, 76, 74, 75, 76, 78, 78, 78, 75, 72, 70, 70, 71, 73, 75, 76, 76, 74, 70,
65, 59, 53, 47, 45, 46, 51, 54, 57, 57, 54, 53, 56, 62, 63, 59, 42, 14, -18,
-45, -62, -65, -56, -49, -45, -51, -62, -74, -81, -84, -83, -83, -87, -95, -102,
-108, -110, -109, -110, -113, -117, -119, -117, -109, -99, -88, -82, -80, -82,
-84, -85, -83, -78, -74, -70, -68, -68, -66, -64, -63, -59, -60, -60, -59, -58,
-56, -51, -47, -48, -53, -61, -70, -78, -82, -83, -82, -80, -78, -77, -77, -75,
-71, -68, -67, -64, -65, -62, -59, -53, -49, -46, -45, -48, -51, -54, -55, -52,
-49, -46, -44, -43, -43, -42, -41, -39, -36, -35, -35, -33, -31, -30, -27, -27,
-27, -29, -31, -32, -32, -30, -27, -25, -23, -21, -21, -21, -20, -18, -16, -15,
-13, -11, -11, -11, -13, -15, -17, -21, -23, -25, -25, -23, -19, -15, -13, -12,
-14, -16, -18, -19, -16, -15, -13, -12, -12, -12, -13, -13, -14, -15, -16, -15,
-13, -8, -3, 2, 5, 4, 5, 4, 3, 4, 5, 7, 7, 9, 9, 8, 7, 5, 1, 0, -2, 0, 3, 4, 6,
7, 7, 5, 3, 1, 1, 2, 4, 5, 6, 6, 5, 4, 3, 1, 0, 0, 0, 1, 3, 8, 12, 14, 14, 12,
11, 8, 9, 11, 13, 16, 15, 12, 9, 7, 4, 4, 6, 10, 11, 13, 13, 12, 10, 8, 6, 5, 6,
6, 8, 6, 6, 3, 2, 1, 1, 3, 5, 6, 8, 8, 8, 6, 3, 2, 1, 2, 3, 6, 7, 9, 8, 8, 7, 5,
5, 4, 5, 7, 9, 10, 8, 6, 3, 0, -3, -3, -1, 1, 2, 3, 2, 1, -2, -4, -4, -5, -5,
-5, -4, -3, -3, -2, -2, -4, -5, -8, -9, -8, -4, -2, 0, 0, -1, -4, -5, -6, -8,
-6, -5, -4, -2, -3, -3, -4, -7, -8, -8, -7, -6, -4, -3, -3, -3, -6, -8, -12,
-15, -17, -16, -12, -9, -6, -5, -6, -9, -11, -11, -12, -10, -10, -8, -6, -5, -4,
-4, -4, -7, -10, -12, -11, -9, -5, -2, -2, -1, -1, -4, -5, -7, -9, -9, -7, -7,
-5, -3, -3, -4, -6, -8, -9, -10, -10, -7, -5, -3, -3, -2, -2, -3, -4, -4, -4,
-3, -1, };