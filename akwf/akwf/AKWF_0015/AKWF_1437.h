#define DATA_LENGTH 512
#define DATA AKWF_1437

const PROGMEM int8_t DATA[DATA_LENGTH] = {14, 65, 69, 57, 67, 65, 62, 67, 66,
64, 68, 65, 65, 68, 66, 67, 70, 68, 69, 70, 69, 71, 71, 70, 71, 72, 72, 73, 72,
72, 74, 73, 73, 74, 73, 76, 76, 74, 76, 76, 76, 77, 78, 77, 78, 78, 78, 79, 79,
79, 80, 80, 80, 81, 81, 81, 83, 82, 83, 83, 83, 83, 83, 83, 85, 84, 84, 87, 85,
85, 87, 85, 88, 90, 84, 91, 93, 59, 29, 36, 40, 34, 38, 38, 36, 39, 38, 37, 38,
38, 37, 38, 38, 38, 39, 37, 38, 38, 38, 39, 40, 39, 38, 39, 39, 40, 39, 39, 40,
40, 39, 40, 39, 39, 41, 40, 40, 40, 39, 41, 40, 41, 41, 41, 41, 41, 41, 41, 42,
41, 41, 42, 42, 41, 43, 42, 42, 43, 42, 43, 42, 43, 43, 42, 43, 43, 43, 43, 43,
43, 42, 43, 44, 43, 43, 44, 44, 44, 44, 44, 44, 45, 44, 44, 44, 45, 45, 45, 45,
45, 46, 45, 45, 46, 45, 46, 46, 45, 46, 46, 46, 47, 46, 46, 46, 47, 47, 47, 47,
46, 46, 47, 47, 47, 48, 47, 47, 47, 47, 48, 48, 48, 48, 48, 49, 47, 49, 48, 48,
49, 49, 49, 49, 49, 49, 48, 49, 49, 49, 49, 49, 48, 49, 49, 48, 48, 48, 49, 48,
48, 49, 49, 48, 48, 48, 49, 48, 48, 47, 48, 48, 49, 49, 48, 48, 48, 48, 48, 49,
48, 48, 48, 48, 49, 49, 47, 49, 48, 48, 48, 47, 48, 49, 48, 48, 49, 47, 49, 48,
47, 49, 48, 47, 49, 47, 47, 50, 47, 48, 50, 46, 48, 50, 45, 50, 49, 44, 51, 48,
43, 55, 45, 40, 67, 18, -94, -118, -90, -101, -106, -94, -102, -103, -97, -103,
-100, -98, -103, -100, -99, -103, -100, -100, -102, -99, -100, -101, -100, -100,
-100, -99, -102, -101, -99, -101, -100, -100, -101, -100, -100, -101, -100,
-101, -101, -99, -100, -101, -99, -100, -100, -100, -100, -100, -99, -100, -99,
-100, -100, -99, -100, -100, -100, -99, -99, -99, -100, -100, -99, -99, -100,
-100, -100, -99, -99, -100, -99, -99, -99, -99, -100, -100, -99, -100, -99, -99,
-100, -99, -99, -99, -98, -99, -98, -97, -97, -96, -96, -95, -95, -94, -93, -92,
-91, -91, -91, -89, -88, -88, -87, -87, -86, -85, -84, -83, -83, -82, -82, -80,
-80, -79, -79, -78, -77, -77, -76, -75, -74, -73, -73, -72, -72, -71, -71, -70,
-69, -68, -68, -66, -65, -65, -64, -65, -64, -62, -62, -61, -60, -60, -59, -59,
-57, -56, -56, -55, -56, -54, -53, -52, -52, -52, -50, -50, -50, -49, -48, -47,
-46, -45, -44, -44, -43, -43, -42, -42, -41, -41, -39, -39, -37, -37, -36, -35,
-36, -33, -34, -33, -32, -31, -31, -30, -30, -29, -28, -28, -27, -27, -26, -24,
-24, -24, -22, -22, -22, -20, -20, -20, -18, -19, -17, -16, -17, -15, -13, -16,
-11, -12, -14, -8, -10, -14, -2, -14, -18, };