#define DATA_LENGTH 512
#define DATA AKWF_1439

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 7, 9, 10, 12, 13, 16, 18, 20,
21, 23, 26, 27, 28, 31, 33, 34, 37, 39, 40, 42, 44, 46, 48, 50, 52, 53, 56, 58,
58, 60, 63, 65, 66, 68, 70, 70, 73, 74, 76, 78, 80, 81, 83, 85, 86, 88, 88, 91,
92, 93, 95, 97, 97, 99, 100, 101, 102, 103, 105, 106, 107, 108, 108, 110, 110,
111, 112, 114, 114, 116, 116, 117, 117, 118, 118, 118, 119, 119, 119, 119, 120,
119, 118, 119, 119, 119, 118, 118, 118, 117, 117, 117, 117, 116, 116, 115, 114,
114, 113, 113, 112, 112, 111, 110, 109, 109, 108, 107, 107, 106, 105, 105, 104,
103, 102, 102, 100, 100, 99, 97, 96, 96, 95, 94, 92, 92, 91, 89, 88, 87, 86, 85,
84, 83, 83, 81, 80, 79, 78, 77, 77, 76, 74, 73, 72, 71, 70, 69, 67, 66, 66, 65,
62, 63, 62, 59, 59, 58, 57, 55, 55, 54, 52, 52, 51, 50, 49, 48, 47, 45, 44, 44,
43, 41, 41, 41, 40, 38, 36, 36, 36, 34, 34, 33, 31, 30, 30, 29, 29, 27, 27, 25,
24, 23, 23, 23, 22, 21, 19, 18, 18, 17, 17, 16, 16, 14, 13, 12, 11, 11, 10, 9,
9, 8, 7, 6, 5, 4, 3, 3, 1, 2, 0, 0, -2, -2, -3, -4, -5, -5, -5, -6, -7, -8, -9,
-10, -11, -12, -12, -13, -13, -14, -15, -17, -17, -18, -18, -19, -20, -21, -22,
-23, -24, -24, -25, -26, -26, -27, -28, -29, -29, -30, -31, -32, -32, -33, -34,
-34, -35, -37, -37, -38, -39, -40, -40, -40, -42, -42, -44, -44, -44, -44, -45,
-46, -47, -48, -49, -49, -50, -50, -51, -51, -52, -53, -54, -54, -55, -55, -56,
-57, -58, -58, -57, -58, -58, -59, -60, -60, -61, -61, -62, -62, -63, -63, -64,
-64, -64, -64, -65, -65, -65, -67, -66, -67, -67, -67, -67, -68, -68, -68, -69,
-68, -69, -68, -70, -69, -69, -69, -70, -70, -70, -70, -70, -70, -71, -70, -70,
-71, -71, -71, -70, -71, -71, -70, -71, -72, -71, -72, -71, -71, -70, -71, -70,
-71, -71, -72, -71, -71, -71, -71, -71, -71, -71, -71, -71, -71, -71, -71, -71,
-71, -71, -71, -72, -71, -71, -71, -71, -71, -71, -71, -72, -71, -72, -70, -72,
-72, -71, -72, -71, -72, -72, -72, -72, -72, -72, -73, -72, -73, -73, -72, -73,
-73, -73, -74, -74, -74, -74, -74, -74, -74, -74, -74, -74, -73, -73, -74, -73,
-73, -74, -72, -73, -72, -72, -72, -72, -72, -72, -71, -71, -71, -70, -70, -69,
-69, -69, -69, -68, -68, -68, -67, -67, -66, -66, -65, -64, -63, -64, -63, -61,
-61, -60, -60, -59, -59, -58, -57, -56, -56, -54, -53, -52, -51, -51, -49, -48,
-47, -46, -45, -44, -43, -42, -40, -40, -38, -37, -36, -34, -34, -32, -31, -29,
-27, -25, -24, -23, -22, -20, -18, -16, -15, -14, -11, -10, -8, -7, -5, -3, -2,
1, };