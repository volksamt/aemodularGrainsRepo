#define DATA_LENGTH 512
#define DATA AKWF_1466

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 4, 6, 6, 8, 9, 11, 11, 14, 14,
16, 17, 18, 19, 21, 22, 24, 25, 26, 28, 29, 30, 31, 33, 35, 36, 37, 38, 40, 41,
42, 43, 45, 45, 47, 48, 49, 51, 52, 52, 54, 55, 57, 58, 59, 60, 62, 62, 63, 65,
65, 67, 68, 69, 70, 72, 72, 73, 74, 76, 76, 77, 78, 79, 80, 80, 82, 82, 83, 85,
85, 86, 87, 87, 89, 89, 89, 91, 92, 91, 93, 93, 93, 94, 96, 95, 96, 97, 97, 98,
99, 99, 100, 100, 101, 101, 102, 103, 103, 104, 104, 104, 105, 105, 106, 107,
107, 107, 107, 109, 109, 109, 110, 109, 110, 110, 111, 112, 111, 112, 112, 113,
114, 114, 114, 114, 114, 114, 114, 115, 115, 116, 115, 116, 117, 117, 116, 117,
117, 117, 117, 117, 117, 117, 117, 117, 118, 119, 119, 119, 118, 118, 119, 119,
118, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 118, 119, 119, 118, 118, 117, 118, 117, 118, 116, 116, 117, 117, 116, 116,
116, 116, 114, 114, 113, 114, 113, 114, 113, 113, 112, 113, 111, 111, 110, 109,
109, 108, 108, 107, 107, 105, 107, 104, 106, 102, 106, 98, 109, 84, 47, 60, 46,
47, 41, 40, 36, 35, 33, 29, 28, 26, 24, 21, 19, 17, 16, 13, 12, 9, 8, 5, 4, 2,
0, -2, -4, -6, -7, -9, -11, -12, -14, -17, -18, -19, -21, -23, -25, -26, -28,
-29, -31, -32, -34, -35, -37, -38, -40, -41, -43, -44, -46, -48, -48, -49, -51,
-53, -54, -55, -56, -57, -59, -60, -61, -62, -64, -65, -66, -68, -69, -70, -71,
-72, -74, -75, -74, -76, -77, -79, -80, -81, -81, -82, -83, -84, -86, -87, -87,
-88, -89, -89, -91, -92, -93, -93, -95, -95, -95, -97, -97, -98, -98, -99, -100,
-100, -101, -102, -102, -102, -102, -103, -104, -104, -105, -105, -105, -105,
-106, -106, -107, -107, -107, -107, -108, -109, -108, -109, -109, -109, -109,
-110, -110, -110, -110, -110, -111, -110, -110, -111, -111, -111, -111, -111,
-111, -110, -111, -112, -111, -111, -112, -111, -111, -111, -111, -111, -111,
-111, -111, -109, -111, -111, -110, -110, -109, -110, -109, -109, -109, -109,
-108, -108, -108, -107, -108, -107, -107, -108, -107, -107, -106, -106, -104,
-105, -104, -105, -104, -104, -103, -103, -102, -102, -102, -101, -101, -101,
-100, -99, -99, -99, -97, -97, -97, -96, -96, -95, -94, -94, -94, -93, -92, -91,
-91, -90, -89, -89, -88, -88, -86, -86, -85, -85, -84, -84, -82, -81, -81, -79,
-79, -78, -77, -77, -75, -74, -74, -73, -72, -71, -70, -68, -68, -66, -65, -65,
-63, -62, -61, -60, -58, -57, -56, -56, -54, -54, -52, -50, -50, -47, -47, -45,
-44, -44, -43, -41, -39, -38, -37, -36, -35, -33, -32, -31, -29, -28, -26, -25,
-24, -22, -22, -20, -19, -17, -17, -15, -13, -12, -11, -10, -9, -7, -5, -4, -2,
-2, 1, };