#define DATA_LENGTH 512
#define DATA AKWF_1481

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 8, 10, 13, 16, 18, 22, 24, 26,
28, 30, 32, 34, 36, 36, 38, 39, 40, 40, 41, 42, 42, 43, 43, 44, 44, 44, 44, 43,
44, 44, 44, 43, 44, 43, 43, 43, 43, 42, 41, 42, 41, 40, 39, 39, 39, 39, 38, 38,
37, 37, 36, 37, 36, 35, 35, 35, 33, 33, 33, 32, 32, 32, 31, 31, 31, 31, 30, 30,
29, 28, 28, 27, 27, 28, 26, 26, 26, 25, 25, 25, 24, 24, 24, 23, 23, 22, 23, 22,
22, 21, 21, 20, 20, 20, 19, 19, 19, 18, 17, 17, 17, 17, 17, 16, 16, 16, 15, 14,
15, 14, 14, 14, 13, 14, 12, 12, 12, 12, 12, 11, 12, 11, 11, 10, 10, 9, 10, 10,
9, 9, 8, 9, 8, 8, 9, 8, 7, 8, 8, 7, 7, 7, 6, 6, 5, 5, 6, 5, 5, 5, 5, 6, 4, 5, 4,
4, 3, 4, 4, 4, 4, 4, 4, 3, 4, 3, 3, 4, 2, 2, 3, 2, 2, 3, 1, 2, 1, 2, 2, 2, 2, 2,
2, 2, 1, 1, 1, 1, 2, 1, 1, 0, 1, 2, 1, 1, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 0, 0,
0, 0, 1, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0,
0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 1, 1, 0, 0, 0, 1,
0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0,
1, -1, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, -1, 0, 0, 0, 0, -1, 0, 1, 0,
0, 0, 0, 0, -1, 1, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0,
1, -1, 0, -1, 0, -1, 0, 0, -1, 0, 0, 0, 0, 1, 1, 1, -1, 0, 0, -1, 0, 0, 0, 0,
-1, -1, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1,
-1, 0, -1, 0, -1, 0, -1, -1, 0, 0, -1, -1, -1, -2, -5, -7, -10, -14, -19, -24,
-30, -37, -44, -52, -59, -66, -74, -80, -87, -93, -98, -104, -106, -111, -113,
-116, -117, -119, -119, -119, -119, -116, -115, -113, -111, -109, -105, -101,
-97, -94, -89, -86, -80, -76, -70, -66, -62, -56, -51, -47, -42, -38, -32, -28,
-24, -19, -15, -11, -6, -3, };