#define DATA_LENGTH 512
#define DATA AKWF_1464

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 13, 18, 24, 27, 30, 33, 35, 36,
38, 39, 40, 41, 43, 44, 45, 47, 48, 50, 52, 54, 55, 57, 58, 60, 61, 63, 64, 66,
66, 68, 68, 70, 71, 72, 74, 75, 76, 78, 79, 79, 81, 82, 84, 84, 86, 87, 87, 88,
89, 91, 91, 93, 94, 94, 94, 96, 97, 98, 99, 99, 100, 101, 101, 102, 103, 103,
104, 105, 105, 106, 107, 107, 108, 109, 108, 110, 110, 110, 111, 112, 112, 112,
113, 114, 114, 114, 114, 116, 115, 116, 115, 116, 117, 117, 117, 118, 118, 119,
119, 118, 118, 119, 119, 119, 119, 119, 120, 120, 119, 119, 120, 119, 119, 119,
119, 119, 119, 118, 118, 118, 118, 117, 118, 117, 116, 116, 116, 115, 115, 115,
113, 113, 112, 112, 111, 111, 110, 110, 108, 108, 107, 107, 106, 105, 105, 103,
102, 102, 101, 100, 99, 97, 97, 95, 94, 94, 93, 91, 90, 89, 87, 86, 84, 84, 82,
81, 80, 79, 77, 75, 74, 73, 72, 70, 69, 68, 67, 65, 64, 63, 61, 60, 59, 57, 56,
55, 53, 53, 51, 50, 48, 46, 46, 45, 44, 42, 41, 40, 38, 38, 37, 35, 35, 33, 31,
30, 30, 28, 28, 27, 25, 25, 23, 23, 22, 21, 20, 19, 18, 18, 17, 16, 15, 15, 13,
12, 12, 10, 11, 10, 9, 9, 8, 7, 6, 6, 5, 4, 4, 2, 3, 2, 1, 0, -1, -1, -2, -4,
-5, -5, -6, -7, -7, -8, -8, -10, -11, -12, -13, -13, -13, -16, -16, -17, -18,
-19, -20, -20, -22, -24, -25, -25, -26, -28, -29, -29, -30, -32, -32, -34, -35,
-37, -38, -39, -41, -42, -43, -45, -46, -48, -49, -50, -52, -53, -55, -55, -58,
-58, -60, -61, -62, -63, -65, -66, -67, -69, -70, -72, -73, -73, -76, -76, -77,
-79, -80, -82, -83, -84, -84, -86, -87, -88, -89, -90, -91, -91, -93, -93, -95,
-95, -96, -97, -98, -99, -100, -101, -101, -102, -103, -103, -104, -105, -105,
-106, -106, -107, -108, -108, -108, -108, -109, -109, -110, -111, -110, -111,
-112, -111, -112, -112, -112, -112, -113, -112, -113, -112, -113, -114, -114,
-113, -113, -113, -113, -113, -113, -113, -113, -113, -112, -112, -112, -112,
-112, -112, -111, -111, -111, -110, -111, -110, -109, -110, -109, -108, -109,
-109, -108, -108, -107, -107, -107, -107, -106, -106, -105, -105, -105, -104,
-104, -103, -103, -103, -102, -102, -102, -101, -101, -100, -100, -100, -98,
-98, -99, -98, -97, -97, -97, -95, -95, -94, -94, -94, -93, -92, -92, -91, -91,
-90, -90, -89, -89, -88, -87, -87, -86, -85, -84, -83, -83, -82, -81, -81, -80,
-79, -77, -77, -77, -75, -74, -73, -73, -71, -71, -70, -68, -68, -66, -64, -63,
-62, -61, -60, -59, -57, -56, -55, -53, -52, -51, -49, -48, -48, -46, -44, -43,
-42, -40, -39, -37, -35, -34, -32, -31, -28, -27, -25, -24, -22, -20, -18, -17,
-16, -15, -14, -13, -11, -10, -6, -3, -1, };