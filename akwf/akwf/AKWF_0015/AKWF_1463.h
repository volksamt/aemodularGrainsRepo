#define DATA_LENGTH 512
#define DATA AKWF_1463

const PROGMEM int8_t DATA[DATA_LENGTH] = {105, 125, 114, 121, 116, 122, 117,
121, 117, 121, 118, 120, 118, 120, 118, 120, 118, 120, 119, 120, 118, 119, 119,
118, 119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 118, 118, 119, 119,
119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 118,
119, 118, 119, 119, 119, 118, 119, 118, 118, 118, 119, 119, 119, 118, 119, 118,
119, 118, 119, 119, 118, 118, 118, 119, 118, 118, 118, 118, 118, 118, 118, 118,
118, 119, 118, 117, 118, 118, 119, 118, 118, 118, 117, 118, 118, 118, 118, 117,
117, 118, 118, 118, 117, 118, 119, 117, 117, 118, 118, 118, 117, 118, 118, 118,
117, 118, 118, 117, 118, 118, 117, 118, 117, 117, 117, 117, 117, 117, 117, 117,
117, 118, 117, 118, 117, 117, 117, 117, 118, 117, 117, 117, 118, 117, 118, 117,
117, 116, 117, 117, 117, 116, 117, 116, 117, 118, 117, 116, 116, 117, 118, 117,
117, 117, 117, 116, 116, 117, 116, 117, 117, 117, 117, 117, 117, 117, 116, 116,
117, 117, 117, 117, 116, 117, 116, 116, 117, 116, 116, 116, 116, 116, 116, 116,
117, 116, 116, 116, 116, 117, 116, 117, 116, 117, 115, 117, 116, 117, 116, 117,
116, 117, 116, 117, 115, 117, 115, 116, 115, 116, 116, 116, 116, 115, 118, 114,
118, 114, 120, 111, 121, 109, 126, 101, 127, 31, -127, -94, -114, -100, -108,
-104, -107, -106, -105, -107, -105, -107, -105, -108, -104, -107, -105, -107,
-104, -107, -104, -106, -105, -107, -106, -106, -105, -106, -106, -106, -106,
-105, -105, -106, -106, -105, -106, -105, -106, -105, -106, -106, -106, -106,
-106, -106, -105, -105, -106, -106, -105, -105, -105, -106, -106, -106, -105,
-106, -106, -105, -105, -105, -105, -105, -105, -105, -105, -105, -105, -105,
-105, -105, -105, -105, -104, -105, -106, -104, -105, -105, -105, -105, -105,
-106, -105, -104, -105, -105, -104, -105, -105, -106, -105, -105, -105, -104,
-104, -106, -105, -105, -105, -105, -105, -104, -105, -105, -105, -105, -104,
-105, -105, -105, -105, -104, -105, -105, -105, -104, -104, -105, -105, -104,
-105, -104, -104, -105, -105, -104, -104, -105, -105, -105, -104, -104, -105,
-105, -104, -104, -104, -105, -104, -105, -105, -104, -104, -104, -104, -104,
-104, -104, -104, -104, -105, -104, -104, -104, -104, -104, -104, -104, -104,
-104, -103, -104, -105, -104, -104, -104, -104, -104, -104, -104, -104, -104,
-103, -104, -104, -103, -103, -104, -103, -104, -104, -103, -104, -103, -103,
-103, -103, -104, -104, -103, -104, -103, -103, -103, -103, -103, -103, -104,
-103, -103, -103, -103, -103, -103, -104, -103, -103, -103, -103, -103, -104,
-103, -103, -102, -103, -104, -104, -103, -104, -103, -102, -104, -103, -103,
-102, -103, -103, -102, -104, -102, -103, -103, -104, -103, -103, -103, -103,
-103, -103, -103, -103, -102, -103, -103, -103, -102, -103, -103, -103, -102,
-103, -103, -102, -103, -102, -104, -101, -104, -101, -104, -101, -105, -101,
-105, -100, -105, -98, -109, -88, };