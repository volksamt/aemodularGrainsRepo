#define DATA_LENGTH 512
#define DATA AKWF_1456

const PROGMEM int8_t DATA[DATA_LENGTH] = {-3, 30, 125, 116, 121, 118, 119, 119,
119, 120, 119, 120, 117, 121, 118, 120, 118, 120, 118, 119, 118, 119, 119, 119,
118, 119, 119, 119, 118, 118, 120, 119, 120, 119, 119, 119, 120, 120, 120, 118,
119, 119, 120, 119, 119, 118, 118, 119, 119, 118, 118, 119, 119, 118, 120, 119,
119, 118, 119, 120, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 120, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 118, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 118, 119, 119, 119, 118, 120, 118, 120, 117,
122, 117, 121, 117, 121, 116, 121, 117, 121, 118, 119, 120, 116, 118, -78, -128,
-109, -126, -113, -124, -115, -123, -115, -121, -116, -121, -118, -121, -118,
-119, -119, -120, -119, -119, -119, -119, -120, -119, -120, -119, -120, -118,
-120, -119, -120, -120, -119, -118, -120, -118, -120, -119, -119, -119, -119,
-119, -119, -118, -119, -120, -119, -119, -119, -120, -119, -119, -119, -119,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -120,
-120, -119, -120, -118, -119, -119, -119, -119, -120, -118, -120, -118, -120,
-118, -120, -119, -120, -118, -119, -119, -119, -119, -118, -120, -118, -120,
25, 127, 115, 122, 116, 121, 118, 121, 118, 120, 118, 120, 118, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119,
120, 119, 119, 119, 120, 119, 118, 119, 118, 120, 120, 119, 120, 119, 119, 119,
119, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 120,
119, 120, 118, 120, 118, 119, 118, 120, 118, 120, 117, 120, 118, 120, 118, 120,
119, 119, 119, 118, 121, 117, 123, 114, 127, 108, 127, -2, -128, -107, -127,
-114, -124, -116, -121, -117, -121, -118, -120, -119, -118, -120, -118, -120,
-118, -119, -118, -120, -118, -120, -118, -120, -119, -119, -119, -120, -118,
-119, -119, -119, -118, -119, -119, -119, -119, -118, -118, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -120, -119, -118,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -120, -118,
-119, -119, -119, -118, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -118, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -120, -119, -119, -120,
-118, -120, -118, -120, -118, -121, -117, -121, -116, -122, -116, -123, -114,
-126, -98, };