#define DATA_LENGTH 512
#define DATA AKWF_1460

const PROGMEM int8_t DATA[DATA_LENGTH] = {24, 31, 28, 30, 29, 30, 29, 30, 29,
30, 29, 30, 30, 29, 29, 29, 29, 30, 30, 30, 30, 29, 30, 30, 29, 29, 29, 29, 29,
30, 29, 29, 30, 30, 29, 30, 30, 30, 30, 30, 30, 29, 29, 29, 30, 30, 30, 30, 30,
29, 30, 30, 30, 30, 29, 29, 29, 29, 30, 29, 30, 30, 30, 29, 30, 29, 29, 30, 29,
29, 30, 30, 30, 29, 30, 29, 29, 29, 29, 29, 29, 29, 29, 30, 30, 29, 30, 29, 30,
30, 29, 29, 29, 30, 29, 30, 29, 29, 29, 29, 29, 29, 29, 30, 29, 29, 30, 29, 29,
29, 29, 29, 29, 29, 30, 29, 30, 29, 30, 28, 29, 29, 28, 30, 29, 29, 29, 30, 29,
29, 29, 28, 30, 29, 29, 29, 29, 29, 29, 29, 30, 29, 30, 29, 29, 29, 29, 28, 29,
30, 29, 29, 28, 30, 30, 29, 30, 29, 28, 29, 29, 29, 29, 28, 29, 28, 28, 29, 28,
29, 29, 28, 28, 29, 29, 29, 29, 29, 29, 29, 29, 28, 29, 29, 29, 28, 29, 29, 30,
29, 29, 29, 29, 29, 30, 28, 28, 29, 28, 29, 28, 30, 29, 28, 28, 29, 29, 29, 29,
28, 29, 29, 29, 29, 28, 28, 29, 29, 29, 29, 28, 28, 28, 29, 28, 30, 28, 29, 29,
29, 28, 29, 29, 29, 29, 28, 29, 29, 29, 29, 29, 29, 28, 28, 28, 28, 29, 29, 29,
29, 29, 29, 29, 30, 29, 30, 28, 29, 29, 29, 29, 29, 29, 28, 29, 29, 29, 28, 28,
29, 29, 29, 29, 28, 28, 28, 29, 28, 29, 28, 29, 29, 29, 28, 29, 29, 28, 29, 28,
30, 28, 29, 27, 30, 26, 31, 25, 32, 25, 33, 22, 37, 8, -124, -117, -119, -120,
-119, -121, -117, -120, -117, -121, -116, -121, -117, -120, -117, -121, -117,
-120, -118, -120, -118, -121, -118, -119, -119, -119, -124, -1, 45, 12, 52, -59,
-128, -112, -123, -116, -120, -118, -120, -118, -119, -118, -119, -118, -120,
-118, -120, -117, -121, -117, -121, -116, -122, -116, -123, -113, -126, -98, 34,
28, 29, 29, 27, 30, 27, 31, 28, 31, 28, 30, 27, 31, 28, 31, 28, 30, 29, 29, 29,
30, 29, 29, 28, 28, 29, 29, 30, 29, 29, 29, 30, 29, 29, 28, 30, 28, 29, 28, 29,
29, 29, 29, 29, 29, 29, 28, 29, 29, 29, 28, 29, 29, 29, 29, 29, 29, 29, 28, 29,
30, 28, 29, 30, 29, 28, 29, 29, 30, 29, 29, 29, 30, 29, 30, 29, 29, 28, 29, 29,
29, 29, 29, 29, 29, 29, 29, 29, 28, 30, 28, 31, 28, 31, 27, 31, 26, 32, 26, 33,
24, 34, 17, -118, -119, -116, -120, -117, -120, -116, -120, -117, -120, -118,
-121, -117, -120, -118, -119, -118, -119, -118, -118, -118, -119, -118, -118,
-118, -118, -118, -118, -119, -119, -118, -119, -118, -119, -118, -119, -117,
-120, -117, -121, -116, -121, -115, -122, -113, -126, -101, };