#define DATA_LENGTH 512
#define DATA AKWF_1442

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 120, 120, 118, 121, 118, 121, 118,
120, 118, 121, 118, 120, 117, 120, 118, 120, 118, 120, 119, 120, 119, 119, 119,
120, 119, 119, 119, 119, 119, 119, 119, 120, 119, 118, 120, 120, 119, 119, 119,
119, 120, 119, 118, 119, 119, 119, 119, 120, 119, 120, 119, 119, 118, 119, 120,
119, 119, 118, 119, 119, 118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 118, 119, 118, 119, 119, 119, 119, 120, 119, 120, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119,
119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 119, 119, 119, 111, 98, 86, 74, 62, 49, 37, 25, 14, 1, -10, -23, -35,
-46, -59, -69, -81, -93, -104, -117, -120, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -118, -120, -118, -118, -118, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -120, -120, -120,
-119, -118, -119, -119, -120, -119, -119, -118, -120, -119, -119, -120, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -118, -119, -119, -119, -119, -119, -119, -120, -119, -119, -120,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -120, -119, -119, -119, -119, -119, -118,
-119, -120, -119, -118, -119, -119, -120, -120, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -120, -119, -119, -118, -120, -119, -119,
-119, -119, -118, -119, -119, -118, -119, -118, -119, -120, -118, -119, -119,
-119, -119, -118, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -120, -119, -119, -119, -119, -120,
-120, -119, -120, -119, -118, -119, -120, -119, -119, -119, -119, -120, -118,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -118, -119, -119, -119, -119, -118, -119,
-119, -118, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -118, -119, -119, -118, -119, -120, -119, -119, -119, -120,
-118, -119, -119, -118, -119, -119, -119, -118, -119, -120, -119, -119, -119,
-119, -119, -119, -120, -119, -118, -120, -119, -119, -120, -119, -120, -119,
-119, -120, -118, -119, -119, -120, -120, -120, -119, -119, -119, -119, -118,
-119, -120, -119, -119, -119, -118, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -120, -119, -119, -119, -112, -104, -95, -87, -79, -70, -61, -53,
-45, -36, -27, -19, -9, };