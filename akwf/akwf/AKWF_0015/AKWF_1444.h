#define DATA_LENGTH 512
#define DATA AKWF_1444

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 87, 119, 117, 121, 118, 120, 118,
120, 119, 120, 119, 120, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 120, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 120, 119, 119,
119, 118, 119, 119, 119, 118, 119, 119, 119, 118, 120, 119, 120, 119, 120, 119,
119, 120, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 120,
119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119,
119, 119, 119, 119, 120, 118, 119, 118, 119, 119, 119, 119, 119, 120, 119, 119,
119, 119, 120, 119, 119, 119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 120,
119, 119, 119, 120, 119, 120, 119, 119, 119, 118, 119, 119, 120, 118, 120, 119,
119, 118, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 120, 119, 120,
119, 120, 120, 119, 118, 118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 113, 101, 89, 76, 64, 52, 39, 27, 14, 1, -10, -23, -36,
-47, -60, -73, -85, -97, -110, -119, -120, -119, -120, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -120, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -120, -120, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -118, -119, -119, -119, -118, -119,
-120, -120, -120, -120, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -120, -118, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -118, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -118,
-120, -120, -119, -120, -119, -119, -119, -119, -119, -118, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -118, -120, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -120, -119, -120, -120, -120, -119, -119, -119,
-120, -119, -120, -119, -119, -119, -119, -119, -118, -119, -118, -119, -120,
-120, -119, -119, -118, -120, -120, -120, -117, -106, -94, -81, -71, -58, -47,
-34, -23, -10, };