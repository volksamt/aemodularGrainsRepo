#define DATA_LENGTH 512
#define DATA AKWF_1416

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 11, 16, 23, 31, 37, 44, 50, 56, 62,
67, 72, 76, 82, 86, 91, 95, 99, 101, 105, 108, 110, 112, 114, 117, 118, 119,
119, 119, 118, 117, 115, 113, 111, 109, 105, 102, 99, 96, 90, 87, 83, 78, 74,
69, 66, 61, 57, 53, 49, 45, 41, 38, 36, 33, 30, 27, 25, 23, 22, 21, 21, 22, 22,
22, 22, 22, 23, 24, 23, 24, 23, 22, 19, 18, 16, 14, 11, 9, 7, 4, 1, -1, -6, -8,
-12, -14, -19, -21, -24, -26, -30, -32, -34, -36, -38, -42, -44, -47, -50, -53,
-57, -61, -65, -70, -73, -76, -80, -83, -85, -87, -88, -90, -91, -92, -91, -91,
-89, -88, -85, -84, -82, -80, -79, -77, -76, -74, -73, -72, -71, -71, -71, -71,
-71, -73, -72, -73, -74, -73, -75, -75, -77, -76, -77, -78, -78, -78, -77, -77,
-77, -75, -74, -72, -69, -67, -63, -59, -56, -52, -47, -45, -40, -37, -34, -29,
-26, -22, -19, -16, -11, -8, -6, -1, 1, 3, 4, 6, 6, 7, 6, 7, 5, 4, 3, 2, 0, -1,
-3, -4, -5, -6, -6, -8, -9, -10, -10, -10, -10, -11, -9, -8, -7, -5, -4, -2, -1,
2, 5, 5, 8, 9, 11, 14, 16, 17, 20, 22, 24, 27, 29, 32, 34, 36, 38, 41, 42, 44,
46, 48, 49, 50, 51, 52, 52, 52, 50, 51, 50, 49, 48, 48, 48, 47, 48, 47, 49, 50,
52, 54, 56, 58, 61, 64, 66, 70, 73, 75, 78, 80, 82, 85, 86, 88, 89, 91, 91, 91,
92, 91, 92, 91, 91, 89, 87, 86, 85, 83, 81, 81, 79, 78, 76, 76, 74, 73, 72, 71,
70, 70, 68, 67, 66, 65, 64, 62, 61, 60, 59, 57, 55, 53, 52, 50, 48, 46, 43, 40,
39, 36, 34, 31, 30, 28, 27, 26, 24, 23, 21, 19, 18, 16, 14, 13, 9, 7, 4, 2, -2,
-5, -8, -12, -15, -19, -22, -27, -30, -34, -39, -43, -47, -50, -54, -56, -60,
-63, -66, -68, -71, -74, -74, -77, -78, -79, -81, -82, -84, -84, -84, -85, -85,
-83, -83, -83, -82, -82, -82, -82, -81, -81, -81, -80, -80, -79, -77, -77, -76,
-75, -74, -73, -73, -71, -71, -70, -68, -67, -66, -65, -63, -61, -59, -57, -56,
-54, -53, -52, -50, -48, -47, -47, -45, -44, -44, -43, -41, -41, -40, -38, -38,
-36, -35, -34, -33, -31, -31, -30, -29, -27, -26, -25, -23, -22, -20, -19, -18,
-16, -14, -14, -14, -12, -11, -12, -11, -12, -10, -9, -9, -8, -7, -6, -3, -1, 2,
4, 4, 7, 7, 7, 7, 7, 5, 3, 1, -2, -3, -7, -9, -14, -16, -20, -23, -25, -27, -28,
-28, -27, -26, -25, -22, -20, -17, -14, -11, -7, -4, 1, 4, 6, 9, 10, 11, 13, 13,
14, 15, 15, 14, 15, 14, 13, 12, 11, 9, 9, 5, 4, 2, -1, -2, -5, -6, -8, -10, -12,
-15, -16, -16, -15, -14, -13, -9, -5, -1, };