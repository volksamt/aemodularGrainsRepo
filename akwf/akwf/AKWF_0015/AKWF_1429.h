#define DATA_LENGTH 512
#define DATA AKWF_1429

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 0, 0, 0, 3, 8, 10, 11, 13,
15, 19, 23, 25, 27, 28, 29, 31, 32, 35, 36, 38, 39, 41, 44, 48, 51, 55, 58, 62,
64, 67, 70, 72, 75, 78, 80, 82, 85, 87, 88, 91, 92, 94, 96, 98, 100, 103, 104,
106, 109, 110, 113, 115, 116, 115, 110, 101, 92, 91, 87, 80, 73, 65, 61, 58, 55,
55, 54, 52, 51, 49, 48, 46, 43, 40, 35, 28, 22, 15, 11, 6, 3, 1, -1, -2, -3, -5,
-6, -7, -6, -7, -7, -6, -6, -5, -6, -7, -7, -6, -7, -6, -6, -7, -8, -8, -8, -8,
-7, -7, -7, -6, -5, -4, -3, -2, -1, 0, 2, 3, 4, 4, 6, 7, 7, 7, 8, 8, 8, 8, 7, 6,
6, 5, 3, 2, 2, 2, 0, 0, -1, -2, -4, -3, -4, -4, -3, -4, -4, -5, -5, -4, -3, -4,
-3, -3, -2, -2, -2, -1, -1, 0, 1, 1, 1, 2, 1, 2, 3, 2, 2, 1, 2, 2, 2, 2, -4, -8,
-9, -10, -12, -16, -20, -23, -26, -26, -27, -30, -31, -33, -34, -37, -37, -39,
-41, -44, -47, -50, -54, -57, -60, -62, -64, -67, -68, -70, -72, -74, -76, -78,
-80, -82, -83, -85, -87, -87, -89, -91, -94, -94, -96, -98, -100, -102, -103,
-105, -106, -108, -109, -110, -112, -113, -115, -116, -117, -119, -120, -117,
-111, -105, -95, -90, -86, -81, -73, -65, -59, -57, -54, -54, -53, -52, -51,
-49, -48, -47, -45, -41, -36, -30, -25, -18, -13, -8, -5, -3, -3, 0, 2, 3, 5, 5,
6, 6, 7, 6, 6, 7, 7, 8, 8, 9, 8, 8, 8, 9, 9, 9, 8, 8, 8, 8, 6, 6, 5, 4, 3, 3, 0,
-1, -2, -3, -4, -6, -6, -6, -8, -8, -8, -8, -8, -8, -7, -6, -6, -6, -4, -4, -3,
-1, 0, 0, 1, 2, 2, 3, 4, 4, 4, 5, 5, 4, 4, 5, 4, 3, 4, 2, 2, 1, 1, 1, 0, -1, -1,
-2, -1, -1, -1, -2, -2, -2, -2, -2, -2, -2, -2, -3, -1, -1, -1, -1, -1, 0, 0, 0,
0, 0, 0, 1, 0, 1, 2, 1, 1, 1, 1, 1, 0, 1, 1, 0, 1, 0, 0, 0, 0, 1, 1, 1, 0, 0,
-1, 0, 0, -1, -1, -1, 0, 0, -1, 0, -1, -1, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1,
0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0,
1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, -1, 0, -1, 1, 0, 0, 0, 1, 0, 0, 0, -1,
1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0,
-1, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, };