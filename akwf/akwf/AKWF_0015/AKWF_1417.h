#define DATA_LENGTH 512
#define DATA AKWF_1417

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 14, 19, 23, 29, 34, 39, 44, 48,
53, 57, 61, 66, 70, 73, 77, 82, 84, 88, 91, 95, 98, 99, 101, 104, 106, 108, 109,
111, 112, 113, 113, 114, 115, 115, 115, 114, 114, 113, 112, 111, 110, 108, 106,
105, 103, 101, 98, 95, 92, 89, 86, 83, 79, 75, 71, 67, 64, 59, 54, 50, 45, 40,
36, 31, 25, 20, 15, 10, 4, -1, -6, -12, -16, -22, -27, -31, -37, -42, -47, -52,
-55, -60, -65, -68, -72, -76, -79, -82, -85, -88, -91, -93, -97, -98, -101,
-103, -105, -106, -108, -109, -111, -113, -113, -115, -116, -117, -117, -118,
-119, -119, -119, -119, -119, -120, -119, -118, -118, -117, -116, -116, -115,
-114, -112, -111, -110, -108, -106, -105, -102, -101, -98, -96, -93, -91, -89,
-86, -84, -82, -78, -76, -74, -71, -67, -65, -63, -60, -57, -54, -52, -50, -47,
-45, -42, -40, -39, -36, -34, -31, -30, -28, -26, -23, -22, -20, -18, -17, -15,
-13, -10, -9, -7, -6, -3, -2, 0, 2, 4, 6, 8, 10, 11, 13, 15, 17, 18, 20, 22, 24,
26, 27, 30, 31, 33, 35, 36, 37, 39, 41, 42, 43, 44, 46, 47, 48, 48, 49, 51, 51,
52, 53, 54, 55, 55, 56, 57, 56, 57, 59, 59, 60, 60, 60, 61, 62, 61, 62, 62, 63,
61, 62, 62, 62, 62, 62, 61, 60, 60, 60, 58, 58, 57, 56, 55, 54, 53, 51, 50, 49,
47, 45, 44, 42, 40, 39, 37, 34, 33, 31, 29, 27, 24, 23, 20, 19, 16, 14, 12, 9,
7, 5, 3, 0, -2, -4, -7, -9, -11, -13, -15, -16, -20, -22, -23, -25, -28, -28,
-30, -32, -33, -35, -36, -37, -38, -40, -40, -41, -42, -43, -42, -44, -44, -44,
-43, -44, -44, -43, -44, -43, -43, -43, -42, -42, -39, -39, -38, -37, -36, -35,
-33, -31, -29, -28, -27, -24, -21, -20, -17, -16, -13, -12, -9, -6, -5, -3, -1,
3, 4, 6, 9, 10, 13, 15, 18, 20, 22, 24, 27, 30, 31, 34, 35, 38, 40, 43, 46, 49,
51, 52, 55, 57, 60, 62, 65, 68, 70, 72, 73, 76, 78, 79, 81, 82, 85, 86, 86, 87,
89, 90, 91, 91, 91, 91, 91, 91, 91, 91, 91, 90, 90, 89, 88, 88, 87, 87, 85, 84,
83, 82, 81, 80, 79, 78, 76, 75, 73, 72, 70, 69, 66, 65, 63, 60, 58, 56, 53, 50,
49, 46, 43, 39, 36, 33, 30, 26, 23, 19, 15, 11, 9, 4, 1, -3, -8, -11, -15, -18,
-22, -26, -30, -33, -36, -40, -43, -47, -50, -53, -56, -60, -63, -65, -68, -70,
-74, -76, -79, -81, -83, -86, -88, -91, -93, -94, -97, -98, -100, -102, -103,
-105, -105, -106, -107, -108, -108, -108, -108, -108, -108, -107, -106, -106,
-105, -103, -101, -99, -97, -96, -93, -90, -88, -85, -81, -78, -75, -70, -68,
-64, -60, -55, -51, -47, -42, -38, -34, -29, -24, -19, -15, -10, -5, 0, };