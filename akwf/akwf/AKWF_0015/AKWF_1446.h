#define DATA_LENGTH 512
#define DATA AKWF_1446

const PROGMEM int8_t DATA[DATA_LENGTH] = {20, 120, 119, 118, 120, 118, 120, 117,
120, 117, 121, 117, 120, 118, 120, 118, 120, 119, 120, 119, 120, 119, 120, 118,
120, 119, 118, 120, 119, 119, 118, 120, 119, 118, 119, 119, 119, 119, 119, 119,
118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119,
118, 119, 118, 119, 118, 119, 119, 118, 120, 120, 119, 119, 119, 119, 119, 119,
119, 118, 119, 120, 119, 119, 120, 119, 120, 119, 118, 120, 118, 119, 120, 119,
119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 120, 118, 119, 119, 119, 119, 120, 119, 119,
119, 120, 119, 119, 119, 120, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 118, 119, 119,
119, 119, 119, 120, 119, 119, 119, 119, 120, 118, 120, 118, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 118, 120, 118, 120, 117, 122, 116, 124, 107, 25,
-59, -119, -118, -120, -118, -119, -119, -119, -120, -118, -119, -118, -120,
-118, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -120, -118, -119,
-119, -119, -119, -119, -119, -118, -120, -118, -119, -119, -119, -119, -118,
-120, -119, -118, -119, -118, -118, -119, -120, -119, -119, -119, -119, -119,
-120, -120, -119, -119, -120, -120, -120, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -120, -120, -119, -119, -119, -120, -120, -119, -119, -119,
-119, -118, -120, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -120, -118, -119, -120, -120, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -120, -118, -119, -119, -119, -118, -119, -119, -120,
-120, -120, -119, -119, -118, -120, -120, -119, -119, -119, -119, -119, -118,
-119, -118, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -120, -119, -119, -119, -119, -119, -118, -120, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -120, -120, -118, -120, -119,
-118, -119, -119, -120, -120, -120, -119, -119, -119, -119, -118, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -120, -119, -118, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -118, -119, -119, -120,
-119, -119, -119, -118, -120, -119, -119, -118, -119, -119, -120, -119, -119,
-118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -120,
-117, -119, -118, -121, -117, -121, -117, -122, -116, -123, -113, -126, -101, };