#define DATA_LENGTH 512
#define DATA AKWF_1457

const PROGMEM int8_t DATA[DATA_LENGTH] = {89, 122, 116, 121, 117, 121, 117, 121,
117, 120, 117, 120, 118, 120, 119, 120, 118, 120, 120, 118, 119, 119, 118, 119,
119, 118, 119, 119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119,
119, 119, 118, 120, 119, 119, 120, 119, 119, 118, 119, 119, 119, 119, 119, 119,
119, 119, 119, 118, 119, 118, 118, 119, 119, 119, 119, 120, 120, 119, 119, 119,
118, 119, 118, 119, 120, 119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 118,
120, 119, 119, 120, 119, 120, 119, 119, 120, 119, 119, 119, 118, 120, 120, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 119, 119,
119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 120,
120, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 120,
119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 118, 119, 119, 119, 119, 120,
119, 119, 119, 119, 118, 119, 119, 119, 120, 120, 118, 119, 119, 118, 119, 118,
119, 119, 119, 120, 119, 119, 119, 119, 119, 118, 119, 120, 119, 118, 119, 119,
119, 120, 120, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 119,
119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 120, 118,
120, 118, 120, 118, 120, 118, 120, 117, 120, 117, 120, 117, 120, 118, 119, 119,
119, 120, 117, 123, 112, 127, -50, -127, -108, -127, -113, -125, -115, -122,
-116, -121, -117, -121, -117, -120, -119, -120, -119, -119, -119, -119, -120,
-119, -120, -119, -120, -119, -119, -119, -120, -119, -120, -119, -119, -120,
-119, -119, -119, -119, -119, -120, -118, -119, -119, -120, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -120, -119, -118, -119, -120, -118, -119, -119, -119, -119, -119,
-119, -120, -119, -118, -120, -119, -120, -119, -119, -119, -118, -119, -119,
-119, -119, -118, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -120, -119, -119, -120, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -120, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -120, -118, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -120, -118, -119, -119, -119, -119, -119, -120, -118, -120,
-119, -119, -118, -119, -120, -119, -119, -119, -118, -119, -120, -119, -119,
-119, -119, -119, -120, -118, -118, -120, -119, -119, -119, -119, -118, -119,
-119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -118, -119, -118, -120, -119, -119, -118, -120, -119, -118, -120, -119,
-120, -119, -120, -118, -120, -118, -121, -117, -122, -117, -121, -116, -123,
-114, -126, -95, };