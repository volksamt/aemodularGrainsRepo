#define DATA_LENGTH 512
#define DATA AKWF_1487

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 13, 22, 30, 37, 46, 53, 61, 68, 73,
77, 85, 91, 97, 102, 106, 112, 115, 117, 118, 119, 119, 118, 118, 116, 114, 112,
110, 107, 104, 101, 97, 94, 90, 88, 84, 81, 76, 73, 67, 63, 57, 52, 47, 40, 35,
28, 23, 18, 13, 8, 7, 3, -3, -6, -10, -14, -16, -20, -23, -25, -26, -28, -29,
-30, -31, -32, -32, -31, -32, -32, -30, -30, -29, -28, -26, -25, -24, -23, -22,
-19, -18, -16, -15, -13, -12, -10, -9, -8, -7, -5, -5, -3, -3, -2, -1, -1, -1,
0, 1, 0, -1, 0, -1, -1, -2, -2, -2, -3, -4, -4, -4, -4, -5, -5, -5, -7, -7, -8,
-7, -8, -8, -8, -10, -10, -10, -10, -10, -11, -10, -11, -11, -11, -12, -10, -12,
-11, -11, -11, -11, -10, -11, -10, -10, -11, -10, -9, -9, -9, -8, -8, -7, -6,
-6, -5, -3, -3, -2, -1, 0, 1, 2, 3, 4, 6, 7, 9, 10, 11, 12, 13, 15, 17, 18, 20,
20, 22, 23, 25, 25, 27, 27, 29, 30, 31, 31, 32, 31, 32, 32, 31, 31, 31, 29, 27,
26, 23, 21, 19, 17, 14, 11, 8, 7, 4, 1, -3, -7, -11, -17, -21, -26, -30, -34,
-38, -43, -47, -49, -52, -56, -57, -60, -62, -64, -66, -68, -70, -70, -73, -73,
-76, -76, -77, -78, -79, -79, -80, -80, -80, -77, -76, -73, -71, -67, -63, -58,
-53, -48, -42, -36, -32, -25, -19, -16, -10, -4, 3, 10, 15, 20, 25, 31, 37, 44,
48, 53, 58, 63, 66, 70, 74, 76, 78, 79, 79, 79, 79, 79, 78, 77, 75, 75, 74, 73,
70, 69, 67, 66, 64, 62, 60, 57, 55, 53, 50, 46, 42, 38, 34, 30, 26, 21, 16, 11,
7, 2, 0, -4, -7, -8, -11, -15, -17, -19, -22, -24, -25, -27, -29, -29, -30, -31,
-31, -32, -32, -32, -31, -30, -30, -29, -28, -27, -26, -25, -23, -22, -21, -19,
-18, -17, -15, -13, -12, -11, -9, -8, -7, -6, -4, -3, -3, -1, -1, 1, 2, 3, 4, 4,
5, 6, 6, 7, 8, 8, 9, 9, 10, 9, 10, 10, 10, 12, 11, 11, 11, 11, 11, 11, 12, 11,
10, 11, 11, 11, 9, 10, 9, 9, 9, 8, 8, 8, 8, 7, 6, 7, 6, 6, 5, 5, 4, 3, 3, 3, 2,
2, 2, 2, 1, 1, 0, 0, 0, 0, 0, 1, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 12, 13, 15, 17,
18, 20, 22, 23, 24, 26, 26, 28, 30, 30, 30, 31, 32, 32, 32, 31, 31, 30, 30, 27,
26, 25, 22, 19, 17, 13, 10, 7, 3, -3, -6, -9, -14, -17, -24, -29, -35, -41, -46,
-53, -58, -63, -68, -72, -77, -81, -85, -88, -92, -95, -97, -101, -104, -107,
-109, -112, -114, -116, -118, -118, -119, -118, -117, -117, -113, -111, -106,
-102, -97, -91, -84, -76, -73, -68, -60, -53, -45, -37, -28, -20, -12, -4, };