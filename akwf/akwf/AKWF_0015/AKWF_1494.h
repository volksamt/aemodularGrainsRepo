#define DATA_LENGTH 512
#define DATA AKWF_1494

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 4, 5, 7, 8, 10, 11, 13, 14, 15,
15, 16, 17, 18, 18, 19, 20, 21, 21, 22, 23, 22, 24, 24, 25, 25, 25, 26, 27, 26,
27, 27, 29, 28, 29, 30, 30, 31, 32, 33, 33, 34, 36, 36, 38, 39, 40, 41, 43, 44,
45, 47, 48, 51, 53, 54, 56, 57, 60, 62, 63, 65, 67, 69, 71, 73, 75, 75, 78, 80,
80, 82, 83, 85, 86, 87, 86, 88, 87, 88, 87, 87, 87, 87, 86, 84, 83, 82, 79, 77,
76, 74, 71, 68, 66, 62, 59, 57, 54, 51, 47, 44, 41, 38, 34, 32, 30, 27, 24, 22,
19, 17, 14, 12, 10, 10, 9, 8, 6, 5, 5, 5, 4, 4, 5, 4, 4, 6, 7, 7, 9, 9, 11, 13,
14, 17, 17, 20, 22, 23, 25, 28, 29, 31, 33, 36, 37, 38, 41, 43, 46, 48, 49, 52,
54, 56, 58, 59, 61, 64, 65, 67, 69, 72, 73, 75, 76, 78, 80, 82, 84, 85, 86, 88,
91, 92, 93, 95, 96, 98, 99, 101, 102, 104, 105, 106, 107, 109, 110, 111, 113,
113, 114, 115, 116, 116, 117, 117, 118, 118, 118, 118, 118, 118, 118, 117, 118,
118, 116, 115, 114, 113, 112, 110, 109, 107, 105, 103, 101, 98, 97, 94, 92, 89,
87, 84, 81, 78, 74, 72, 69, 65, 62, 59, 56, 52, 50, 47, 43, 40, 38, 34, 31, 29,
25, 22, 20, 18, 15, 12, 10, 7, 5, 3, 2, -1, -2, -4, -6, -8, -8, -10, -12, -13,
-15, -15, -16, -17, -18, -19, -19, -19, -21, -21, -21, -22, -23, -23, -24, -25,
-24, -25, -25, -26, -26, -27, -28, -28, -28, -30, -30, -31, -32, -32, -33, -33,
-35, -35, -37, -37, -40, -40, -41, -44, -44, -45, -48, -49, -50, -52, -54, -56,
-57, -60, -62, -63, -66, -67, -69, -71, -73, -75, -76, -78, -79, -81, -82, -83,
-83, -86, -86, -87, -87, -88, -88, -87, -87, -87, -86, -85, -84, -83, -82, -80,
-79, -77, -75, -72, -69, -67, -64, -61, -59, -55, -52, -50, -47, -43, -39, -36,
-34, -31, -28, -25, -23, -21, -18, -15, -13, -11, -10, -9, -8, -6, -5, -4, -3,
-3, -3, -3, -4, -4, -5, -5, -6, -6, -8, -9, -10, -12, -14, -16, -17, -19, -21,
-23, -24, -26, -29, -30, -32, -35, -37, -38, -40, -43, -45, -47, -49, -50, -53,
-56, -58, -59, -60, -63, -66, -68, -69, -70, -73, -75, -76, -78, -80, -81, -83,
-85, -86, -88, -90, -92, -93, -94, -96, -97, -99, -100, -102, -103, -105, -106,
-107, -108, -110, -110, -111, -114, -114, -116, -116, -116, -117, -118, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -117, -116, -115, -114,
-113, -111, -110, -108, -106, -104, -102, -100, -97, -95, -92, -89, -87, -83,
-81, -78, -75, -72, -69, -65, -63, -59, -56, -52, -50, -47, -43, -40, -36, -34,
-31, -28, -25, -22, -19, -17, -14, -12, -9, -7, -6, -3, -1, };