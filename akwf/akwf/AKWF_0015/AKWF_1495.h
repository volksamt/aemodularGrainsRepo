#define DATA_LENGTH 512
#define DATA AKWF_1495

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 5, 6, 7, 8, 10, 12, 13, 15,
16, 18, 19, 21, 23, 24, 25, 26, 28, 30, 31, 33, 35, 36, 38, 38, 41, 42, 42, 45,
46, 47, 49, 50, 51, 52, 53, 55, 56, 57, 58, 59, 60, 62, 63, 63, 65, 66, 67, 69,
69, 70, 72, 74, 74, 75, 76, 77, 78, 80, 82, 82, 82, 83, 85, 85, 87, 88, 89, 90,
90, 91, 92, 93, 93, 94, 95, 96, 97, 97, 99, 99, 100, 101, 102, 102, 103, 104,
104, 105, 106, 106, 107, 107, 108, 108, 109, 110, 111, 112, 112, 113, 112, 114,
114, 114, 115, 115, 116, 117, 117, 117, 118, 119, 117, 119, 119, 119, 119, 119,
120, 119, 119, 119, 119, 118, 119, 119, 118, 117, 117, 116, 117, 116, 117, 115,
115, 116, 115, 114, 114, 114, 113, 113, 113, 113, 112, 112, 111, 111, 111, 110,
110, 109, 110, 109, 109, 110, 108, 108, 108, 107, 107, 108, 107, 107, 106, 105,
104, 103, 104, 103, 101, 101, 100, 100, 98, 97, 96, 96, 93, 93, 92, 90, 90, 88,
86, 86, 85, 83, 81, 80, 78, 78, 76, 76, 74, 73, 71, 70, 68, 68, 66, 66, 65, 64,
62, 61, 60, 60, 58, 58, 56, 55, 54, 53, 52, 52, 50, 49, 47, 47, 45, 44, 44, 42,
41, 40, 38, 37, 35, 34, 33, 31, 29, 28, 26, 24, 23, 21, 20, 18, 16, 15, 13, 12,
10, 8, 6, 5, 3, 2, 0, -2, -3, -5, -7, -8, -9, -10, -12, -14, -15, -16, -18, -19,
-20, -21, -23, -24, -26, -26, -28, -30, -31, -32, -34, -34, -36, -36, -39, -39,
-40, -42, -44, -45, -46, -48, -49, -50, -52, -53, -54, -56, -58, -58, -60, -60,
-63, -64, -65, -65, -67, -68, -69, -71, -71, -73, -74, -75, -77, -77, -79, -79,
-81, -81, -83, -84, -85, -86, -87, -87, -89, -90, -90, -92, -92, -94, -95, -95,
-97, -98, -97, -98, -99, -101, -102, -102, -103, -104, -105, -105, -106, -106,
-108, -107, -108, -109, -109, -109, -110, -110, -111, -111, -111, -112, -112,
-112, -112, -112, -113, -113, -113, -114, -114, -113, -114, -113, -113, -114,
-115, -114, -115, -115, -115, -115, -116, -116, -116, -116, -116, -116, -116,
-116, -117, -117, -117, -116, -117, -117, -117, -117, -117, -117, -117, -117,
-117, -116, -116, -116, -115, -115, -115, -114, -113, -112, -112, -112, -111,
-110, -109, -108, -108, -107, -106, -105, -105, -104, -104, -103, -101, -100,
-99, -98, -97, -97, -96, -95, -95, -94, -93, -92, -91, -91, -90, -89, -89, -87,
-87, -87, -86, -86, -85, -84, -84, -83, -82, -81, -80, -80, -78, -78, -76, -75,
-74, -74, -72, -71, -70, -69, -68, -67, -65, -64, -63, -61, -60, -59, -57, -55,
-54, -53, -51, -49, -48, -47, -45, -43, -42, -40, -38, -37, -36, -34, -33, -32,
-31, -28, -28, -26, -25, -24, -22, -21, -21, -19, -18, -16, -15, -15, -12, -12,
-11, -10, -9, -8, -6, -5, -4, -2, 0, };