#define DATA_LENGTH 512
#define DATA AKWF_1467

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 6, 7, 8, 9, 10, 12, 12,
14, 15, 15, 17, 18, 19, 21, 22, 22, 24, 26, 27, 28, 28, 29, 31, 32, 33, 34, 35,
36, 37, 38, 39, 41, 41, 43, 43, 44, 45, 46, 48, 49, 51, 51, 53, 54, 55, 55, 57,
58, 58, 59, 61, 62, 62, 64, 65, 66, 67, 68, 68, 68, 70, 71, 72, 72, 73, 74, 75,
76, 76, 77, 78, 78, 80, 80, 81, 82, 82, 83, 83, 84, 84, 86, 86, 87, 88, 87, 89,
89, 89, 90, 91, 91, 92, 92, 92, 93, 94, 94, 94, 95, 94, 96, 96, 97, 97, 97, 98,
98, 98, 99, 99, 99, 100, 100, 101, 100, 102, 102, 102, 102, 103, 103, 103, 103,
104, 104, 103, 104, 105, 105, 105, 105, 105, 106, 105, 106, 106, 105, 106, 106,
107, 106, 107, 106, 106, 107, 106, 106, 107, 107, 106, 106, 106, 107, 106, 107,
107, 107, 107, 107, 106, 106, 107, 106, 105, 105, 105, 106, 106, 105, 105, 105,
105, 104, 104, 104, 103, 103, 103, 102, 102, 102, 101, 101, 101, 100, 100, 100,
100, 98, 98, 98, 97, 96, 96, 96, 95, 94, 93, 92, 92, 92, 92, 91, 89, 88, 88, 88,
87, 86, 86, 85, 83, 83, 82, 81, 80, 79, 80, 79, 77, 77, 76, 74, 73, 73, 72, 71,
70, 70, 69, 68, 67, 66, 65, 64, 64, 62, 62, 61, 60, 59, 58, 57, 56, 56, 54, 53,
53, 51, 51, 49, 48, 47, 46, 46, 45, 44, 43, 42, 41, 41, 38, 34, 22, 8, -4, -14,
-23, -31, -37, -43, -48, -52, -56, -61, -64, -68, -73, -75, -79, -81, -83, -85,
-88, -90, -91, -93, -93, -95, -97, -98, -99, -99, -101, -102, -102, -103, -104,
-105, -106, -107, -107, -108, -109, -110, -110, -111, -111, -113, -113, -114,
-114, -114, -115, -115, -116, -116, -116, -116, -117, -116, -117, -118, -118,
-117, -118, -119, -118, -119, -118, -119, -119, -119, -119, -120, -118, -120,
-119, -119, -119, -118, -118, -118, -119, -119, -118, -118, -118, -118, -118,
-118, -118, -117, -116, -117, -117, -116, -116, -116, -116, -116, -116, -115,
-114, -114, -114, -114, -115, -113, -113, -112, -112, -112, -112, -112, -112,
-111, -111, -111, -110, -109, -109, -109, -109, -109, -107, -108, -107, -106,
-107, -106, -105, -104, -105, -104, -104, -103, -103, -103, -102, -101, -100,
-100, -100, -99, -99, -98, -98, -98, -97, -97, -96, -95, -94, -94, -94, -93,
-92, -92, -91, -90, -90, -89, -89, -87, -86, -86, -85, -85, -84, -83, -83, -82,
-81, -81, -79, -79, -78, -77, -76, -76, -73, -74, -73, -72, -71, -70, -69, -68,
-67, -66, -65, -64, -63, -62, -60, -59, -58, -57, -56, -55, -55, -53, -52, -50,
-50, -48, -48, -46, -45, -44, -42, -40, -41, -38, -38, -36, -35, -34, -33, -31,
-30, -29, -28, -27, -26, -24, -23, -21, -21, -20, -18, -17, -16, -15, -13, -13,
-12, -10, -8, -8, -5, -5, -3, -2, -1, 0, };