#define DATA_LENGTH 512
#define DATA AKWF_1441

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 3, 3, 3, 4, 5, 5, 6, 6, 7,
8, 9, 9, 10, 11, 11, 12, 13, 13, 14, 15, 17, 17, 17, 18, 20, 21, 22, 22, 23, 24,
24, 24, 26, 27, 27, 28, 29, 31, 30, 31, 32, 32, 33, 33, 33, 33, 33, 34, 35, 34,
35, 35, 36, 37, 36, 37, 38, 38, 38, 39, 40, 40, 40, 40, 41, 41, 42, 43, 43, 44,
45, 45, 45, 46, 46, 48, 48, 48, 49, 49, 49, 51, 52, 51, 53, 54, 53, 55, 55, 55,
59, 57, 57, 60, 58, 60, 63, 59, 64, 67, 57, 71, 69, 8, -36, -26, -26, -37, -31,
-32, -36, -31, -31, -31, -26, -26, -24, -19, -17, -12, -8, -5, -1, 4, 6, 13, 17,
21, 26, 30, 33, 39, 42, 45, 48, 52, 55, 59, 61, 64, 67, 70, 72, 75, 78, 81, 83,
85, 89, 91, 93, 96, 98, 100, 102, 105, 107, 110, 111, 112, 114, 115, 117, 117,
118, 119, 119, 118, 119, 119, 118, 118, 118, 117, 115, 114, 112, 111, 109, 107,
105, 102, 100, 97, 95, 91, 88, 85, 82, 78, 75, 72, 68, 65, 61, 58, 55, 51, 48,
46, 41, 38, 35, 31, 28, 24, 22, 18, 15, 12, 9, 6, 2, 0, -4, -6, -8, -12, -15,
-17, -20, -23, -25, -29, -30, -33, -36, -37, -40, -42, -45, -46, -48, -52, -53,
-56, -58, -60, -62, -64, -66, -68, -69, -71, -72, -74, -76, -78, -79, -80, -82,
-83, -83, -85, -86, -88, -88, -89, -89, -91, -92, -92, -92, -93, -93, -95, -95,
-95, -96, -96, -95, -96, -96, -97, -97, -97, -97, -96, -96, -97, -95, -96, -96,
-95, -95, -95, -94, -94, -93, -93, -92, -92, -91, -91, -89, -89, -87, -86, -85,
-85, -83, -82, -81, -79, -79, -77, -77, -75, -74, -73, -72, -70, -70, -70, -73,
-73, -73, -73, -73, -72, -71, -71, -70, -70, -69, -68, -68, -66, -65, -64, -63,
-62, -62, -61, -59, -57, -56, -55, -54, -52, -51, -50, -49, -47, -46, -44, -43,
-42, -41, -40, -39, -36, -35, -34, -32, -32, -30, -28, -27, -26, -24, -23, -22,
-20, -19, -18, -17, -15, -14, -13, -12, -10, -10, -8, -8, -7, -5, -5, -3, -2,
-1, -1, 0, 0, 0, 2, 2, 3, 3, 4, 4, 5, 6, 5, 6, 6, 7, 6, 7, 8, 10, 10, 11, 11,
12, 11, 13, 13, 13, 13, 13, 14, 14, 14, 14, 14, 13, 13, 13, 13, 13, 13, 12, 12,
13, 11, 11, 12, 11, 10, 11, 10, 10, 10, 9, 9, 8, 8, 9, 8, 8, 7, 7, 6, 5, 5, 4,
5, 3, 3, 2, 2, 2, 1, 1, 1, 1, 0, -2, -1, -2, -2, -3, -3, -2, -4, -5, -4, -5, -4,
-5, -5, -6, -5, -6, -6, -6, -6, -5, -6, -6, -6, -6, -6, -6, -6, -6, -5, -5, -6,
-6, -6, -4, -4, -5, -4, -4, -4, -4, -4, -3, -3, -2, -2, -1, -1, 0, 0, };