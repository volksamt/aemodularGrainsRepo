#define DATA_LENGTH 512
#define DATA AKWF_1476

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 23, 22, 22, 21, 22, 22, 22, 21, 22,
22, 21, 21, 21, 21, 20, 20, 20, 21, 21, 21, 20, 20, 20, 20, 20, 20, 20, 20, 20,
20, 19, 19, 20, 20, 19, 19, 19, 19, 19, 19, 19, 18, 18, 18, 18, 19, 19, 18, 18,
18, 17, 18, 17, 18, 18, 17, 18, 18, 17, 16, 17, 17, 17, 17, 17, 17, 17, 17, 16,
16, 17, 16, 16, 16, 17, 16, 16, 16, 15, 16, 16, 16, 15, 16, 15, 15, 15, 15, 14,
15, 14, 14, 15, 15, 14, 14, 14, 14, 15, 14, 14, 14, 14, 14, 13, 14, 14, 14, 14,
14, 13, 13, 14, 14, 13, 14, 13, 13, 13, 13, 13, 14, 14, 13, 12, 12, 13, 12, 13,
12, 12, 12, 13, 13, 13, 12, 12, 12, 12, 11, 12, 12, 12, 12, 11, 11, 11, 11, 11,
11, 11, 10, 12, 10, 11, 11, 10, 11, 11, 11, 11, 10, 10, 11, 11, 10, 11, 11, 10,
10, 10, 10, 10, 10, 9, 9, 10, 10, 10, 10, 9, 10, 9, 10, 9, 9, 10, 10, 9, 9, 9,
10, 10, 9, 9, 9, 9, 9, 9, 8, 8, 9, 8, 8, 8, 8, 8, 9, 8, 9, 9, 9, 9, 8, 8, 8, 8,
8, 8, 8, 8, 8, 8, 7, 8, 7, 8, 8, 8, 8, 7, 7, 7, 7, 8, 8, 7, 6, 8, 6, 7, 7, 7, 7,
8, 8, 8, 7, 7, 6, 7, 7, 7, 12, 42, 84, 101, 100, 98, 98, 98, 97, 97, 96, 96, 95,
94, 93, 92, 93, 91, 91, 91, 91, 90, 89, 88, 88, 88, 88, 87, 86, 86, 85, 84, 84,
84, 82, 82, 83, 81, 81, 80, 80, 79, 78, 78, 78, 77, 77, 76, 76, 75, 75, 75, 74,
74, 73, 73, 67, 36, -6, -24, -23, -22, -23, -22, -22, -22, -22, -22, -22, -21,
-23, -22, -22, -21, -21, -21, -21, -21, -21, -21, -21, -21, -22, -21, -20, -21,
-20, -21, -20, -20, -20, -20, -20, -20, -20, -19, -19, -19, -19, -19, -18, -20,
-20, -20, -19, -19, -19, -19, -18, -18, -19, -18, -19, -18, -17, -18, -18, -18,
-18, -18, -18, -17, -18, -17, -17, -17, -18, -17, -17, -17, -17, -17, -16, -17,
-17, -17, -16, -16, -16, -16, -16, -16, -16, -16, -15, -16, -15, -15, -16, -16,
-15, -15, -15, -15, -14, -15, -15, -15, -15, -15, -14, -15, -15, -14, -14, -14,
-15, -15, -14, -14, -14, -13, -14, -14, -14, -13, -13, -14, -14, -14, -13, -13,
-14, -13, -14, -13, -13, -14, -13, -13, -14, -13, -13, -13, -13, -13, -12, -13,
-12, -13, -28, -73, -113, -120, -117, -118, -116, -115, -114, -115, -113, -112,
-112, -111, -111, -110, -109, -108, -108, -107, -106, -107, -105, -105, -105,
-104, -103, -103, -102, -101, -101, -100, -99, -99, -98, -98, -97, -96, -96,
-95, -95, -93, -94, -93, -93, -92, -91, -91, -91, -90, -90, -88, -88, -87, -87,
-86, -70, -23, };