#define DATA_LENGTH 512
#define DATA AKWF_1443

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 116, 122, 116, 122, 117,
121, 117, 121, 118, 120, 118, 121, 118, 120, 118, 120, 119, 119, 118, 119, 119,
118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 120, 120, 119, 119,
120, 118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119,
119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 118,
119, 118, 119, 119, 119, 118, 119, 119, 119, 120, 119, 119, 119, 118, 119, 119,
119, 120, 120, 120, 119, 119, 119, 118, 119, 120, 119, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 120, 119, 119, 120, 120,
119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119,
119, 119, 120, 119, 119, 119, 119, 108, 96, 84, 72, 61, 48, 38, 26, 14, 2, -10,
-22, -33, -44, -56, -68, -79, -90, -103, -114, -119, -119, -119, -120, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -120, -119, -120, -119, -120, -118, -120, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -120, -120, -119, -119, -119, -120, -119, -119, -118, -120, -119, -119,
-119, -119, -120, -120, -119, -120, -119, -120, -119, -120, -118, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -118, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -120, -120, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -118, -118, -120, -119, -120, -119, -119, -119,
-118, -119, -120, -119, -119, -119, -119, -120, -120, -119, -120, -119, -120,
-119, -120, -119, -119, -119, -119, -119, -119, -120, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-118, -119, -119, -120, -120, -120, -118, -118, -119, -119, -119, -119, -119,
-120, -119, -119, -118, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -120,
-119, -120, -119, -119, -120, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -120, -119, -120, -120, -119, -118, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -118, -111, -101, -91, -82, -72, -62, -51, -41, -31, -22, -11, 0, };