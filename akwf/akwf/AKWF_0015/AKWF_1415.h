#define DATA_LENGTH 512
#define DATA AKWF_1415

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 11, 16, 20, 25, 29, 33, 39,
43, 48, 53, 59, 64, 68, 73, 78, 82, 88, 93, 96, 100, 103, 107, 109, 112, 113,
114, 115, 117, 118, 118, 119, 118, 120, 119, 119, 118, 118, 116, 115, 114, 113,
112, 111, 110, 109, 108, 107, 106, 106, 105, 105, 105, 104, 103, 103, 102, 102,
102, 102, 100, 99, 98, 95, 93, 91, 87, 84, 81, 77, 75, 71, 68, 63, 59, 56, 51,
46, 42, 38, 34, 30, 26, 22, 17, 13, 10, 6, 3, -1, -3, -6, -9, -11, -12, -15,
-15, -15, -15, -16, -15, -15, -15, -14, -12, -12, -10, -10, -8, -7, -8, -7, -6,
-6, -6, -7, -8, -8, -10, -10, -13, -15, -17, -20, -22, -25, -29, -31, -35, -37,
-39, -42, -44, -47, -51, -53, -55, -58, -60, -63, -66, -69, -71, -74, -77, -79,
-83, -86, -87, -90, -92, -92, -94, -95, -95, -95, -95, -96, -95, -95, -93, -93,
-93, -93, -92, -92, -92, -92, -91, -91, -92, -92, -93, -93, -93, -94, -94, -94,
-96, -95, -95, -97, -97, -97, -98, -98, -98, -99, -98, -99, -98, -99, -98, -98,
-96, -94, -93, -89, -88, -85, -80, -77, -74, -70, -65, -61, -56, -52, -47, -42,
-38, -33, -28, -24, -20, -15, -11, -7, -3, 0, 4, 8, 11, 15, 19, 21, 24, 26, 29,
31, 32, 35, 35, 37, 37, 37, 38, 39, 40, 42, 42, 44, 45, 47, 48, 51, 53, 55, 59,
61, 65, 67, 70, 73, 76, 79, 82, 85, 87, 91, 92, 94, 95, 97, 100, 100, 102, 103,
104, 104, 104, 105, 104, 105, 105, 105, 105, 105, 104, 106, 105, 104, 104, 104,
105, 104, 104, 104, 103, 103, 103, 102, 101, 101, 100, 99, 98, 97, 96, 94, 93,
92, 91, 90, 90, 88, 87, 87, 87, 86, 86, 86, 85, 85, 85, 84, 83, 83, 83, 82, 81,
81, 79, 79, 77, 75, 74, 71, 69, 68, 66, 63, 62, 59, 57, 55, 51, 49, 46, 43, 40,
36, 32, 29, 26, 22, 19, 15, 12, 9, 5, 2, -1, -5, -8, -11, -15, -19, -21, -25,
-28, -32, -34, -37, -41, -43, -46, -49, -53, -55, -58, -61, -62, -66, -68, -71,
-75, -77, -79, -81, -85, -86, -89, -91, -93, -95, -97, -99, -100, -101, -102,
-103, -103, -103, -104, -104, -103, -102, -103, -102, -101, -101, -100, -101,
-100, -100, -99, -98, -99, -98, -97, -98, -97, -95, -96, -94, -94, -93, -91,
-91, -90, -88, -87, -86, -84, -83, -81, -79, -78, -75, -74, -73, -71, -69, -67,
-66, -65, -65, -64, -63, -62, -61, -61, -60, -59, -59, -58, -57, -57, -56, -56,
-55, -54, -54, -53, -53, -53, -52, -52, -52, -51, -51, -50, -50, -50, -49, -48,
-47, -47, -45, -44, -42, -40, -39, -36, -35, -33, -31, -29, -28, -26, -26, -25,
-25, -24, -23, -23, -24, -25, -26, -26, -27, -28, -28, -29, -29, -28, -28, -27,
-26, -25, -23, -22, -20, -18, -16, -13, -9, -6, -2, };