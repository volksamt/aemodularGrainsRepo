#define DATA_LENGTH 512
#define DATA AKWF_1490

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 4, 5, 6, 6, 6, 6, 8, 9, 9,
9, 11, 11, 11, 12, 13, 13, 14, 15, 16, 17, 17, 19, 20, 20, 22, 24, 24, 25, 27,
28, 30, 31, 32, 34, 35, 37, 38, 39, 42, 43, 45, 47, 48, 49, 51, 52, 55, 56, 57,
59, 61, 62, 63, 64, 66, 67, 69, 70, 71, 73, 74, 75, 77, 77, 79, 79, 81, 81, 83,
84, 85, 85, 86, 88, 89, 89, 90, 91, 93, 93, 94, 95, 96, 97, 98, 99, 100, 101,
102, 103, 104, 105, 106, 107, 108, 110, 111, 112, 113, 114, 114, 116, 117, 117,
118, 118, 119, 120, 118, 118, 119, 119, 119, 118, 118, 117, 117, 115, 115, 114,
113, 112, 110, 109, 108, 106, 105, 105, 103, 102, 100, 100, 99, 98, 97, 95, 94,
94, 93, 91, 90, 89, 88, 86, 85, 83, 81, 80, 79, 76, 74, 72, 70, 68, 66, 63, 61,
58, 55, 52, 51, 48, 45, 43, 40, 38, 35, 33, 30, 28, 26, 24, 22, 19, 17, 15, 14,
11, 10, 8, 7, 4, 3, 0, -1, -2, -4, -6, -7, -8, -9, -11, -13, -14, -16, -17, -18,
-20, -21, -24, -25, -26, -27, -29, -30, -32, -33, -34, -35, -37, -38, -39, -41,
-42, -43, -45, -45, -47, -48, -49, -50, -50, -52, -52, -52, -52, -53, -53, -54,
-54, -55, -55, -54, -54, -54, -54, -53, -53, -53, -52, -52, -52, -51, -52, -51,
-51, -51, -49, -50, -49, -49, -50, -50, -50, -49, -50, -50, -50, -51, -50, -50,
-50, -50, -50, -50, -49, -49, -48, -48, -47, -47, -46, -45, -44, -44, -44, -42,
-42, -41, -42, -41, -42, -41, -41, -41, -40, -40, -40, -39, -39, -38, -38, -37,
-36, -36, -35, -34, -33, -33, -32, -30, -29, -29, -27, -27, -26, -25, -24, -24,
-24, -23, -23, -22, -21, -21, -21, -21, -21, -21, -21, -20, -19, -19, -19, -18,
-18, -18, -16, -15, -15, -14, -13, -13, -11, -10, -9, -8, -6, -6, -4, -4, -2,
-1, 0, 1, 4, 4, 4, 6, 6, 8, 8, 9, 10, 11, 12, 11, 12, 13, 13, 13, 13, 14, 14,
14, 13, 13, 13, 12, 13, 12, 11, 11, 10, 9, 9, 7, 6, 5, 4, 3, 2, 0, -1, -2, -4,
-5, -7, -8, -10, -12, -14, -15, -19, -20, -23, -24, -26, -28, -30, -33, -35,
-37, -38, -41, -43, -46, -48, -50, -52, -55, -57, -59, -62, -64, -65, -68, -70,
-72, -73, -76, -78, -79, -81, -83, -84, -86, -87, -88, -89, -91, -92, -94, -94,
-96, -95, -97, -98, -98, -99, -100, -99, -100, -100, -99, -100, -99, -99, -99,
-99, -99, -97, -97, -95, -96, -94, -94, -92, -91, -89, -88, -87, -85, -84, -82,
-80, -79, -76, -75, -74, -71, -70, -67, -65, -63, -60, -58, -57, -54, -51, -50,
-47, -44, -42, -40, -38, -36, -33, -31, -28, -27, -24, -23, -21, -19, -17, -15,
-14, -11, -10, -8, -7, -6, -4, -3, -2, -1, 0, };