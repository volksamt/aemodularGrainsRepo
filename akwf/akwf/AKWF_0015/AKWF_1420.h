#define DATA_LENGTH 512
#define DATA AKWF_1420

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 6, 11, 16, 23, 27, 33, 39, 46, 54,
60, 66, 71, 74, 78, 80, 82, 84, 85, 86, 86, 87, 87, 88, 88, 86, 84, 84, 82, 79,
76, 74, 71, 71, 69, 68, 67, 64, 63, 59, 57, 54, 54, 50, 49, 46, 45, 43, 42, 41,
40, 38, 35, 32, 29, 26, 22, 20, 16, 14, 8, 4, -2, -8, -14, -21, -27, -33, -40,
-48, -53, -59, -63, -70, -74, -78, -82, -85, -89, -92, -94, -97, -99, -100,
-100, -101, -102, -100, -100, -100, -98, -96, -94, -93, -90, -85, -81, -76, -72,
-66, -60, -53, -48, -42, -36, -31, -24, -19, -13, -7, -2, 3, 9, 13, 18, 23, 26,
29, 32, 35, 38, 42, 45, 47, 49, 50, 52, 53, 54, 55, 55, 56, 57, 59, 60, 60, 61,
61, 63, 63, 64, 64, 65, 67, 67, 68, 68, 68, 67, 66, 64, 63, 61, 59, 56, 54, 52,
49, 46, 43, 40, 35, 32, 28, 24, 20, 15, 11, 6, 0, -5, -10, -15, -21, -27, -32,
-39, -44, -49, -54, -58, -63, -65, -69, -72, -75, -77, -79, -80, -82, -82, -82,
-82, -81, -81, -79, -77, -75, -74, -71, -68, -66, -62, -59, -55, -51, -48, -44,
-40, -36, -32, -29, -24, -20, -17, -14, -12, -10, -10, -8, -5, -2, 2, 4, 8, 9,
11, 12, 13, 15, 17, 21, 24, 27, 29, 31, 33, 34, 35, 35, 35, 35, 38, 39, 42, 44,
44, 45, 44, 44, 45, 45, 44, 46, 47, 48, 48, 46, 44, 38, 31, 25, 21, 18, 14, 10,
4, -2, -9, -16, -25, -35, -42, -47, -50, -54, -59, -65, -70, -76, -81, -89, -95,
-100, -103, -105, -106, -108, -111, -114, -116, -117, -119, -118, -117, -115,
-111, -106, -101, -97, -93, -90, -86, -82, -78, -74, -68, -63, -57, -51, -46,
-41, -35, -31, -28, -24, -18, -13, -8, -5, -1, 4, 8, 12, 15, 18, 20, 23, 23, 25,
26, 26, 28, 28, 29, 30, 29, 29, 28, 29, 30, 30, 31, 30, 30, 29, 28, 27, 25, 24,
23, 21, 20, 18, 17, 15, 13, 13, 13, 16, 20, 23, 26, 27, 28, 30, 31, 30, 32, 31,
31, 29, 29, 29, 28, 26, 25, 24, 24, 25, 25, 25, 24, 24, 24, 25, 24, 23, 22, 23,
23, 22, 23, 23, 24, 25, 27, 27, 28, 32, 34, 39, 42, 45, 48, 50, 53, 57, 61, 66,
70, 75, 80, 84, 87, 90, 93, 96, 98, 98, 99, 100, 103, 104, 103, 102, 101, 100,
99, 96, 92, 90, 88, 87, 86, 84, 83, 81, 79, 76, 77, 75, 71, 67, 68, 71, 73, 71,
65, 62, 61, 62, 60, 59, 57, 55, 55, 49, 42, 35, 28, 21, 14, 9, 6, 3, -3, -10,
-15, -22, -32, -43, -55, -61, -62, -60, -60, -63, -68, -73, -83, -93, -100,
-104, -106, -108, -108, -106, -106, -107, -110, -114, -117, -119, -118, -116,
-112, -104, -95, -86, -79, -74, -69, -66, -63, -56, -48, -38, -30, -22, -15, -6,
};