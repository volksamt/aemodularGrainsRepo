#define DATA_LENGTH 512
#define DATA AKWF_1496

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 5, 8, 9, 10, 12, 14, 16, 17,
18, 20, 22, 23, 24, 25, 27, 28, 30, 31, 32, 34, 36, 37, 38, 39, 40, 41, 43, 44,
46, 47, 48, 50, 52, 53, 53, 56, 56, 57, 58, 60, 62, 63, 64, 65, 66, 67, 68, 69,
69, 71, 73, 73, 75, 75, 77, 78, 79, 79, 80, 81, 82, 82, 84, 86, 86, 86, 87, 89,
89, 90, 91, 92, 92, 93, 94, 95, 96, 97, 98, 98, 99, 99, 100, 100, 102, 103, 102,
103, 104, 104, 104, 105, 106, 106, 105, 106, 108, 107, 108, 109, 109, 110, 110,
111, 111, 112, 113, 113, 113, 114, 115, 115, 116, 116, 117, 117, 118, 117, 118,
119, 118, 119, 120, 120, 119, 119, 119, 118, 118, 118, 118, 117, 118, 117, 118,
117, 116, 116, 115, 114, 114, 114, 114, 113, 113, 112, 111, 111, 110, 109, 108,
107, 106, 106, 105, 104, 103, 102, 101, 99, 97, 96, 94, 93, 91, 89, 88, 85, 83,
81, 79, 77, 75, 72, 70, 67, 66, 62, 61, 59, 57, 53, 52, 49, 47, 45, 43, 41, 38,
37, 35, 33, 31, 29, 27, 26, 24, 22, 21, 19, 17, 15, 15, 14, 12, 11, 10, 9, 8, 7,
5, 5, 3, 3, 2, 1, 0, 0, -2, -2, -4, -4, -5, -7, -8, -9, -10, -11, -11, -13, -13,
-13, -14, -16, -17, -18, -19, -19, -20, -21, -22, -23, -23, -24, -24, -25, -25,
-25, -26, -26, -27, -27, -28, -27, -27, -28, -27, -27, -27, -27, -27, -26, -26,
-26, -26, -26, -26, -25, -25, -26, -26, -26, -26, -26, -26, -26, -27, -28, -28,
-28, -29, -29, -31, -32, -34, -34, -35, -37, -36, -39, -40, -42, -43, -44, -44,
-46, -48, -48, -51, -52, -53, -54, -55, -57, -57, -58, -59, -61, -63, -64, -64,
-66, -66, -68, -69, -70, -72, -73, -73, -74, -75, -76, -77, -78, -78, -79, -80,
-80, -82, -82, -83, -83, -83, -84, -84, -85, -85, -85, -84, -84, -83, -84, -83,
-82, -83, -82, -81, -81, -79, -79, -79, -77, -77, -76, -75, -74, -73, -73, -71,
-71, -71, -69, -69, -68, -67, -67, -67, -67, -67, -65, -66, -65, -65, -66, -65,
-65, -66, -65, -66, -66, -66, -66, -66, -67, -67, -66, -67, -68, -68, -68, -68,
-69, -68, -69, -68, -68, -68, -69, -69, -68, -69, -69, -69, -68, -69, -68, -69,
-69, -69, -69, -69, -68, -69, -69, -69, -70, -70, -70, -70, -70, -71, -72, -72,
-72, -73, -74, -74, -75, -76, -76, -76, -77, -77, -78, -80, -80, -80, -82, -82,
-82, -83, -83, -84, -84, -85, -85, -84, -85, -85, -85, -85, -84, -85, -84, -84,
-83, -83, -82, -81, -80, -80, -78, -77, -76, -75, -73, -72, -71, -70, -67, -67,
-65, -64, -62, -60, -58, -57, -56, -54, -53, -51, -49, -48, -47, -45, -43, -42,
-40, -38, -37, -35, -34, -31, -29, -28, -27, -24, -23, -20, -18, -16, -14, -13,
-11, -9, -7, -5, -3, -1, };