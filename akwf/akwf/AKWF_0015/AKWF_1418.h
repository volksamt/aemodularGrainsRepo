#define DATA_LENGTH 512
#define DATA AKWF_1418

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 7, 8, 11, 13, 14, 16, 18, 20,
22, 23, 26, 27, 30, 31, 33, 34, 36, 39, 40, 42, 44, 46, 48, 51, 52, 55, 57, 59,
62, 63, 66, 68, 69, 72, 73, 76, 78, 79, 80, 83, 84, 86, 87, 88, 88, 91, 91, 92,
93, 92, 94, 94, 94, 94, 95, 96, 96, 96, 96, 96, 97, 97, 96, 97, 95, 96, 95, 94,
93, 91, 90, 87, 85, 82, 79, 76, 71, 68, 63, 58, 53, 48, 42, 38, 33, 27, 23, 18,
12, 9, 4, 0, -4, -8, -11, -15, -18, -21, -24, -26, -30, -32, -34, -37, -40, -42,
-45, -47, -51, -54, -58, -60, -64, -67, -70, -74, -77, -80, -84, -87, -90, -93,
-95, -98, -101, -103, -105, -108, -109, -111, -113, -114, -115, -116, -118,
-118, -119, -119, -119, -120, -118, -118, -117, -116, -115, -114, -112, -110,
-108, -105, -103, -101, -98, -95, -93, -90, -86, -85, -82, -79, -77, -74, -72,
-69, -67, -64, -62, -60, -58, -55, -53, -50, -48, -46, -43, -39, -37, -35, -30,
-27, -24, -20, -16, -12, -8, -3, 1, 5, 9, 13, 18, 22, 26, 30, 33, 37, 40, 43,
47, 50, 51, 54, 57, 59, 61, 63, 65, 65, 68, 69, 70, 71, 72, 73, 74, 75, 75, 76,
76, 77, 77, 77, 77, 78, 79, 78, 78, 78, 78, 78, 77, 77, 77, 76, 75, 74, 73, 72,
70, 70, 68, 66, 65, 63, 62, 60, 58, 56, 53, 51, 49, 46, 43, 41, 38, 35, 32, 29,
26, 23, 20, 17, 14, 11, 7, 4, 1, -2, -4, -8, -10, -13, -16, -18, -21, -23, -25,
-28, -31, -32, -34, -36, -39, -40, -42, -43, -46, -48, -50, -52, -54, -55, -56,
-59, -60, -63, -63, -65, -66, -67, -69, -69, -70, -71, -71, -71, -72, -73, -72,
-72, -72, -71, -71, -70, -68, -68, -67, -66, -65, -64, -62, -61, -59, -57, -55,
-54, -52, -50, -48, -46, -44, -42, -39, -38, -35, -33, -30, -29, -26, -24, -21,
-19, -17, -15, -12, -11, -8, -6, -3, -1, 1, 4, 6, 9, 10, 13, 15, 17, 20, 22, 25,
27, 30, 31, 35, 36, 40, 40, 43, 45, 47, 50, 51, 53, 54, 57, 58, 59, 61, 61, 62,
63, 65, 65, 66, 65, 67, 66, 66, 65, 65, 66, 65, 65, 64, 63, 63, 61, 61, 60, 60,
57, 57, 55, 55, 52, 50, 49, 47, 46, 43, 42, 40, 39, 36, 35, 33, 30, 28, 26, 24,
22, 18, 17, 15, 11, 9, 7, 5, 3, 1, -2, -5, -8, -10, -12, -15, -19, -20, -23,
-25, -27, -29, -32, -35, -36, -39, -40, -42, -44, -46, -47, -49, -50, -51, -52,
-54, -54, -55, -55, -55, -56, -57, -57, -58, -58, -57, -57, -58, -59, -58, -58,
-57, -56, -56, -56, -55, -54, -53, -53, -51, -51, -50, -49, -47, -45, -44, -43,
-40, -40, -38, -37, -34, -32, -32, -30, -27, -25, -23, -21, -18, -16, -14, -12,
-11, -8, -6, -3, -2, };