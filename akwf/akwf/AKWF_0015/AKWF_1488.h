#define DATA_LENGTH 512
#define DATA AKWF_1488

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 30, 45, 57, 62, 68, 72, 75, 78,
81, 83, 85, 87, 89, 90, 93, 95, 97, 99, 100, 103, 106, 107, 110, 111, 113, 114,
116, 116, 117, 118, 119, 119, 119, 119, 119, 118, 117, 116, 116, 115, 114, 113,
111, 110, 109, 107, 106, 104, 102, 100, 99, 98, 96, 95, 95, 94, 93, 91, 89, 85,
83, 78, 71, 63, 54, 47, 39, 33, 27, 21, 16, 11, 6, 0, -6, -15, -23, -30, -38,
-43, -48, -52, -55, -57, -58, -59, -62, -64, -66, -69, -71, -73, -75, -78, -79,
-81, -82, -82, -83, -83, -83, -84, -82, -82, -82, -81, -81, -81, -80, -80, -79,
-79, -79, -78, -76, -75, -73, -70, -67, -63, -59, -55, -51, -48, -45, -41, -40,
-37, -35, -34, -31, -29, -26, -25, -23, -22, -20, -18, -16, -15, -14, -12, -12,
-10, -8, -6, -5, -4, -2, -2, 0, 0, 1, 0, 1, 1, 2, 3, 4, 5, 9, 13, 16, 21, 24,
27, 30, 34, 35, 36, 36, 35, 34, 32, 29, 26, 23, 19, 16, 13, 11, 9, 8, 8, 8, 7,
7, 5, 4, 2, -3, -5, -8, -12, -15, -18, -20, -25, -28, -32, -35, -39, -45, -51,
-57, -64, -70, -74, -74, -76, -77, -77, -77, -77, -77, -76, -74, -73, -75, -75,
-77, -77, -78, -79, -80, -80, -80, -80, -81, -80, -79, -79, -78, -77, -76, -75,
-74, -74, -73, -72, -72, -70, -69, -66, -63, -59, -55, -52, -48, -42, -37, -30,
-21, -12, -3, 5, 13, 21, 30, 37, 42, 47, 52, 57, 60, 63, 67, 69, 71, 71, 73, 73,
73, 75, 75, 76, 76, 78, 78, 80, 80, 81, 80, 81, 80, 79, 80, 78, 78, 77, 76, 75,
74, 75, 75, 76, 76, 77, 77, 77, 77, 75, 72, 69, 63, 57, 51, 45, 39, 35, 31, 27,
23, 21, 17, 14, 11, 9, 5, 3, -2, -4, -6, -6, -8, -7, -8, -8, -9, -12, -14, -17,
-20, -23, -26, -29, -33, -34, -35, -36, -36, -35, -33, -30, -27, -24, -21, -15,
-12, -9, -5, -3, -2, -1, -1, 0, -1, -1, 0, 1, 1, 2, 4, 6, 7, 8, 10, 12, 12, 14,
16, 16, 19, 20, 21, 23, 25, 27, 28, 31, 33, 35, 38, 40, 42, 45, 48, 52, 56, 59,
64, 67, 70, 73, 75, 77, 78, 79, 79, 79, 80, 80, 80, 81, 81, 82, 83, 83, 83, 84,
83, 82, 83, 81, 81, 79, 77, 75, 73, 70, 68, 65, 63, 62, 60, 58, 57, 54, 52, 48,
43, 37, 30, 22, 14, 5, -1, -5, -11, -16, -21, -27, -32, -39, -47, -55, -63, -72,
-78, -83, -86, -89, -91, -93, -94, -94, -95, -97, -98, -99, -101, -101, -103,
-105, -107, -108, -110, -111, -113, -114, -115, -116, -117, -118, -118, -119,
-119, -119, -118, -119, -118, -117, -116, -115, -114, -112, -111, -110, -108,
-105, -103, -100, -98, -97, -94, -93, -91, -88, -86, -85, -84, -80, -78, -76,
-72, -67, -62, -56, -44, -28, -11, };