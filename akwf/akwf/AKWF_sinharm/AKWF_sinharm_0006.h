#define DATA_LENGTH 512
#define DATA AKWF_sinharm_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 9, 12, 17, 21, 25, 30, 35, 39, 43,
47, 51, 55, 58, 62, 66, 69, 73, 76, 79, 83, 86, 90, 92, 93, 97, 99, 102, 104,
104, 107, 110, 111, 112, 114, 114, 116, 116, 116, 117, 118, 118, 119, 119, 118,
119, 119, 118, 119, 118, 118, 116, 116, 115, 114, 114, 112, 111, 111, 110, 108,
107, 105, 104, 103, 102, 100, 100, 98, 96, 95, 95, 93, 91, 90, 89, 88, 86, 85,
84, 83, 82, 81, 80, 78, 77, 77, 76, 75, 74, 73, 72, 72, 70, 70, 69, 68, 67, 67,
67, 65, 65, 65, 63, 63, 62, 62, 61, 61, 60, 59, 59, 58, 58, 56, 55, 55, 54, 53,
53, 51, 50, 50, 49, 48, 46, 45, 44, 43, 42, 41, 40, 38, 37, 37, 35, 34, 32, 31,
30, 29, 27, 26, 25, 23, 22, 21, 19, 19, 16, 15, 14, 14, 12, 10, 10, 9, 7, 6, 6,
6, 4, 4, 3, 3, 2, 1, 2, 1, 0, 0, 0, 1, 1, 1, 1, 2, 3, 3, 4, 4, 5, 5, 6, 7, 8, 9,
11, 12, 12, 14, 14, 16, 17, 19, 20, 21, 22, 24, 26, 27, 28, 30, 31, 32, 34, 35,
37, 36, 39, 39, 41, 41, 42, 42, 43, 44, 45, 45, 46, 46, 46, 46, 45, 46, 46, 46,
45, 45, 44, 44, 42, 41, 40, 39, 39, 37, 36, 35, 33, 31, 28, 27, 26, 24, 21, 20,
17, 15, 13, 12, 9, 7, 5, 2, 0, -3, -4, -6, -9, -11, -13, -16, -18, -20, -22,
-23, -26, -27, -29, -31, -32, -34, -35, -37, -38, -40, -41, -42, -42, -43, -44,
-44, -45, -45, -45, -46, -46, -45, -46, -46, -45, -45, -45, -44, -44, -43, -43,
-41, -40, -39, -38, -37, -36, -35, -34, -33, -32, -30, -29, -27, -25, -24, -23,
-21, -20, -19, -18, -16, -15, -13, -13, -12, -10, -9, -8, -7, -6, -5, -5, -3,
-3, -3, -3, -2, -1, -1, -1, 0, -1, -2, -1, -1, -2, -2, -2, -2, -3, -3, -4, -5,
-6, -7, -8, -9, -10, -11, -12, -12, -14, -15, -17, -18, -19, -21, -22, -23, -24,
-25, -27, -28, -30, -31, -33, -34, -35, -36, -37, -39, -40, -40, -41, -43, -45,
-46, -47, -48, -48, -50, -50, -51, -51, -52, -54, -55, -55, -56, -56, -57, -59,
-59, -60, -61, -61, -63, -63, -63, -64, -64, -64, -65, -66, -67, -67, -69, -68,
-70, -71, -72, -73, -73, -74, -75, -76, -77, -77, -79, -80, -81, -81, -83, -85,
-85, -87, -87, -89, -90, -91, -93, -94, -96, -96, -98, -99, -101, -102, -103,
-105, -105, -106, -107, -109, -110, -112, -112, -113, -115, -115, -116, -117,
-117, -118, -119, -119, -119, -119, -119, -118, -119, -119, -118, -118, -118,
-117, -115, -115, -113, -112, -110, -109, -108, -105, -104, -102, -99, -97, -95,
-92, -89, -86, -84, -80, -77, -73, -70, -66, -63, -59, -54, -52, -47, -43, -39,
-35, -30, -27, -22, -17, -14, -9, -4, 0, };