#define DATA_LENGTH 512
#define DATA AKWF_sinharm_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 8, 12, 15, 17, 21, 24, 27, 30,
33, 35, 39, 42, 44, 48, 50, 52, 55, 58, 60, 63, 65, 68, 70, 73, 75, 77, 80, 82,
84, 86, 89, 90, 92, 94, 96, 98, 100, 101, 102, 104, 105, 107, 107, 109, 109,
110, 112, 113, 114, 115, 115, 116, 116, 117, 118, 118, 118, 118, 118, 119, 120,
118, 119, 118, 119, 119, 118, 118, 117, 117, 116, 116, 116, 115, 114, 113, 112,
112, 110, 110, 109, 108, 107, 106, 105, 104, 103, 101, 100, 99, 98, 97, 95, 94,
93, 91, 90, 88, 88, 86, 83, 83, 82, 80, 79, 77, 76, 75, 74, 72, 70, 69, 68, 66,
65, 64, 64, 62, 60, 59, 58, 57, 56, 55, 53, 52, 52, 51, 49, 48, 48, 47, 46, 45,
45, 44, 42, 42, 41, 41, 40, 39, 39, 38, 38, 37, 36, 36, 37, 36, 35, 35, 34, 34,
34, 34, 33, 33, 33, 34, 34, 32, 33, 33, 33, 33, 33, 33, 32, 33, 33, 33, 34, 33,
33, 34, 33, 33, 33, 33, 34, 33, 34, 34, 34, 34, 34, 34, 34, 35, 35, 34, 34, 34,
35, 34, 35, 34, 34, 33, 34, 33, 33, 34, 32, 32, 32, 32, 32, 31, 32, 31, 30, 31,
30, 30, 30, 29, 29, 27, 26, 27, 26, 26, 24, 25, 24, 23, 22, 21, 20, 20, 19, 18,
17, 17, 16, 15, 14, 13, 11, 12, 11, 10, 9, 8, 7, 5, 5, 5, 3, 2, 0, 0, -1, -2,
-3, -4, -5, -6, -6, -8, -8, -10, -10, -11, -12, -13, -14, -15, -16, -17, -18,
-18, -19, -19, -20, -21, -22, -22, -23, -24, -25, -26, -25, -27, -27, -28, -27,
-29, -28, -30, -30, -31, -31, -31, -32, -32, -32, -32, -33, -33, -34, -34, -33,
-34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34,
-35, -34, -34, -34, -34, -33, -33, -33, -34, -33, -34, -33, -33, -33, -34, -32,
-33, -33, -32, -33, -33, -33, -33, -33, -33, -34, -33, -34, -34, -34, -34, -35,
-34, -35, -34, -35, -35, -36, -36, -37, -38, -38, -38, -39, -39, -40, -41, -41,
-42, -42, -44, -44, -45, -46, -48, -48, -48, -50, -50, -52, -52, -54, -55, -56,
-57, -58, -59, -60, -61, -64, -64, -65, -66, -68, -69, -70, -73, -74, -75, -76,
-77, -78, -81, -82, -83, -84, -86, -88, -88, -89, -92, -92, -93, -94, -96, -97,
-99, -100, -102, -102, -104, -104, -106, -107, -108, -109, -110, -110, -112,
-112, -114, -114, -115, -115, -116, -116, -117, -117, -118, -118, -119, -119,
-119, -118, -120, -119, -119, -119, -119, -118, -118, -118, -117, -117, -116,
-115, -115, -115, -114, -112, -111, -110, -109, -108, -107, -105, -103, -103,
-101, -99, -97, -95, -93, -93, -91, -88, -86, -84, -82, -80, -78, -75, -73, -70,
-68, -66, -64, -61, -58, -55, -53, -50, -47, -45, -42, -39, -36, -32, -30, -27,
-23, -21, -17, -15, -12, -8, -6, -3, 0, };