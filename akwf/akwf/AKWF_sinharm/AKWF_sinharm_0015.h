#define DATA_LENGTH 512
#define DATA AKWF_sinharm_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 11, 14, 17, 21, 25, 29, 32, 36,
39, 43, 47, 49, 52, 55, 59, 61, 64, 68, 71, 73, 76, 79, 81, 84, 86, 88, 91, 93,
95, 96, 98, 101, 102, 103, 105, 107, 108, 110, 111, 112, 113, 114, 114, 116,
117, 117, 117, 118, 118, 118, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119,
118, 119, 117, 117, 117, 117, 115, 115, 114, 114, 114, 114, 112, 112, 111, 110,
110, 109, 108, 106, 105, 105, 105, 104, 102, 102, 101, 100, 99, 98, 97, 96, 95,
94, 94, 92, 91, 91, 89, 88, 86, 85, 84, 82, 81, 81, 80, 77, 77, 75, 73, 72, 71,
69, 69, 66, 64, 63, 61, 60, 59, 57, 55, 53, 52, 50, 48, 45, 44, 42, 40, 38, 36,
34, 32, 30, 27, 26, 24, 22, 20, 18, 17, 14, 12, 10, 8, 7, 5, 2, 0, -2, -4, -6,
-7, -9, -10, -11, -13, -14, -16, -18, -18, -19, -21, -22, -23, -24, -25, -26,
-27, -28, -29, -30, -30, -30, -31, -32, -32, -32, -33, -32, -33, -32, -33, -32,
-32, -33, -32, -31, -31, -31, -31, -30, -30, -28, -28, -27, -27, -26, -25, -25,
-24, -24, -22, -21, -20, -19, -18, -18, -18, -17, -15, -14, -14, -13, -12, -11,
-10, -10, -9, -8, -8, -7, -7, -6, -6, -5, -5, -5, -3, -3, -2, -3, -3, -2, -1,
-1, -2, -1, -1, 0, 0, 0, 0, 0, -1, 0, 0, -1, -1, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0,
0, 0, 1, 1, 0, 0, 2, 0, 2, 1, 1, 2, 2, 2, 3, 3, 4, 4, 5, 6, 6, 6, 7, 8, 9, 8, 9,
11, 11, 11, 13, 14, 15, 16, 17, 18, 18, 19, 19, 20, 21, 23, 23, 24, 25, 25, 26,
27, 27, 28, 29, 29, 30, 31, 31, 31, 32, 32, 33, 32, 33, 33, 32, 33, 33, 32, 32,
32, 31, 31, 31, 30, 29, 29, 29, 28, 27, 26, 24, 24, 22, 22, 19, 19, 17, 17, 15,
13, 11, 10, 8, 7, 5, 3, 1, 0, -2, -4, -6, -8, -10, -12, -14, -16, -18, -20, -22,
-24, -26, -28, -30, -33, -33, -36, -38, -40, -42, -43, -46, -47, -49, -51, -53,
-55, -56, -58, -60, -62, -63, -65, -67, -67, -70, -71, -73, -73, -75, -76, -77,
-79, -81, -82, -82, -84, -86, -87, -88, -89, -90, -92, -92, -93, -94, -95, -96,
-97, -99, -99, -100, -101, -102, -103, -104, -104, -106, -106, -107, -108, -108,
-109, -110, -111, -111, -112, -113, -114, -114, -114, -115, -116, -116, -116,
-116, -118, -117, -119, -117, -118, -118, -118, -119, -119, -120, -118, -119,
-119, -119, -119, -118, -118, -117, -116, -115, -114, -113, -112, -112, -110,
-110, -109, -107, -106, -104, -102, -101, -100, -98, -95, -93, -91, -89, -86,
-84, -81, -79, -76, -74, -70, -68, -65, -62, -58, -56, -53, -49, -46, -42, -39,
-36, -32, -28, -25, -22, -18, -14, -10, -7, -3, -1, };