#define DATA_LENGTH 512
#define DATA AKWF_sinharm_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 7, 11, 16, 19, 23, 27, 30, 35, 39,
42, 45, 49, 52, 55, 59, 61, 63, 67, 69, 73, 74, 77, 79, 81, 83, 84, 87, 87, 88,
90, 91, 92, 92, 93, 93, 94, 93, 93, 94, 94, 94, 94, 92, 92, 91, 91, 91, 90, 88,
87, 86, 86, 84, 83, 82, 81, 80, 80, 78, 78, 76, 75, 75, 74, 73, 72, 71, 71, 70,
69, 69, 69, 69, 69, 68, 69, 70, 69, 69, 70, 70, 72, 71, 72, 73, 73, 75, 76, 77,
79, 80, 81, 82, 83, 85, 88, 89, 90, 91, 94, 95, 96, 98, 99, 100, 103, 104, 105,
107, 108, 109, 111, 112, 113, 114, 115, 115, 117, 117, 118, 118, 118, 119, 118,
119, 119, 119, 118, 118, 118, 117, 116, 116, 115, 114, 113, 112, 111, 109, 108,
106, 104, 103, 102, 99, 98, 95, 93, 93, 91, 88, 86, 84, 82, 81, 78, 76, 74, 73,
71, 69, 67, 65, 64, 63, 62, 60, 59, 57, 57, 55, 54, 54, 53, 52, 52, 51, 51, 52,
51, 51, 51, 51, 52, 52, 53, 54, 53, 55, 55, 56, 57, 58, 58, 60, 60, 62, 62, 64,
65, 65, 67, 68, 70, 70, 71, 73, 73, 74, 75, 77, 77, 78, 77, 78, 79, 79, 79, 80,
79, 79, 78, 78, 77, 77, 76, 75, 73, 71, 70, 69, 68, 65, 64, 61, 60, 57, 55, 52,
49, 47, 44, 41, 38, 35, 31, 28, 24, 21, 17, 15, 11, 8, 3, 0, -4, -7, -11, -14,
-18, -21, -25, -28, -31, -34, -37, -41, -43, -46, -49, -52, -54, -57, -59, -61,
-64, -65, -67, -69, -70, -72, -74, -75, -74, -77, -76, -78, -79, -78, -79, -79,
-79, -79, -78, -79, -78, -77, -77, -76, -75, -74, -74, -73, -72, -71, -69, -68,
-67, -66, -65, -64, -63, -61, -61, -60, -58, -57, -57, -56, -56, -54, -53, -53,
-52, -51, -51, -51, -51, -50, -52, -51, -52, -52, -52, -52, -53, -54, -54, -56,
-57, -57, -59, -60, -61, -63, -64, -66, -67, -69, -70, -72, -75, -76, -79, -80,
-82, -85, -86, -88, -91, -92, -94, -96, -97, -99, -100, -103, -104, -106, -108,
-108, -111, -112, -112, -114, -114, -116, -116, -117, -117, -118, -119, -120,
-119, -120, -119, -118, -119, -117, -118, -118, -116, -116, -115, -114, -113,
-112, -112, -110, -108, -107, -105, -104, -103, -101, -99, -97, -97, -95, -94,
-92, -90, -89, -87, -86, -84, -82, -81, -80, -79, -78, -75, -75, -75, -73, -72,
-71, -71, -70, -70, -70, -68, -68, -68, -68, -69, -68, -69, -69, -70, -70, -70,
-71, -72, -73, -74, -74, -74, -76, -78, -78, -79, -80, -80, -82, -83, -84, -85,
-85, -87, -87, -89, -90, -90, -91, -92, -92, -93, -93, -93, -94, -94, -94, -94,
-93, -92, -92, -91, -90, -90, -88, -87, -86, -84, -82, -81, -79, -77, -75, -72,
-70, -67, -64, -61, -59, -56, -52, -49, -46, -41, -39, -36, -31, -27, -24, -19,
-16, -12, -9, -4, 0, };