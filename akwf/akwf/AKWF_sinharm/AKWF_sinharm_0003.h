#define DATA_LENGTH 512
#define DATA AKWF_sinharm_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 13, 16, 21, 25, 29, 34, 37, 41,
45, 48, 51, 55, 58, 61, 63, 66, 68, 71, 73, 74, 75, 77, 77, 78, 79, 79, 79, 79,
78, 77, 78, 77, 75, 73, 72, 69, 68, 66, 64, 61, 59, 56, 54, 51, 48, 45, 42, 40,
36, 33, 30, 28, 23, 21, 17, 16, 12, 9, 7, 5, 2, 1, -2, -4, -5, -7, -8, -9, -11,
-11, -11, -11, -11, -12, -12, -11, -10, -9, -8, -6, -5, -3, -1, 1, 3, 7, 9, 12,
15, 17, 22, 25, 29, 32, 35, 39, 43, 47, 51, 55, 58, 63, 67, 71, 74, 78, 81, 85,
89, 92, 94, 98, 100, 102, 106, 108, 109, 112, 113, 115, 116, 117, 118, 118, 119,
119, 119, 119, 119, 117, 116, 115, 113, 112, 110, 108, 105, 103, 101, 97, 96,
91, 88, 86, 81, 78, 74, 70, 67, 63, 59, 55, 52, 48, 44, 41, 36, 32, 28, 25, 22,
18, 15, 13, 10, 6, 5, 1, 0, -2, -4, -6, -7, -9, -10, -10, -12, -12, -12, -12,
-12, -12, -10, -9, -8, -6, -6, -4, -2, -1, 2, 4, 6, 9, 12, 14, 17, 20, 23, 27,
29, 32, 36, 39, 42, 44, 47, 51, 53, 55, 58, 61, 64, 66, 69, 70, 72, 74, 74, 76,
77, 79, 79, 79, 79, 80, 79, 78, 77, 76, 76, 74, 72, 71, 69, 66, 64, 62, 58, 55,
52, 50, 46, 42, 38, 34, 30, 26, 22, 17, 13, 9, 4, 0, -4, -9, -12, -17, -22, -25,
-29, -34, -38, -41, -44, -49, -51, -55, -58, -61, -64, -67, -68, -71, -72, -74,
-76, -77, -77, -79, -78, -78, -79, -79, -78, -78, -77, -75, -74, -73, -72, -70,
-68, -66, -63, -61, -59, -56, -53, -51, -48, -45, -42, -39, -36, -33, -29, -27,
-23, -20, -17, -14, -12, -10, -7, -4, -2, 0, 2, 5, 5, 7, 9, 10, 10, 10, 11, 12,
12, 12, 11, 11, 10, 9, 8, 6, 4, 3, 1, -2, -4, -7, -9, -13, -15, -18, -22, -25,
-29, -32, -36, -40, -43, -47, -51, -56, -59, -63, -66, -71, -74, -78, -81, -85,
-87, -91, -94, -97, -100, -104, -105, -108, -111, -112, -114, -114, -116, -116,
-118, -118, -120, -120, -118, -119, -118, -117, -116, -115, -113, -111, -110,
-108, -105, -103, -101, -97, -95, -92, -88, -85, -81, -77, -74, -70, -67, -63,
-59, -55, -51, -47, -43, -40, -37, -32, -28, -25, -22, -18, -15, -12, -9, -7,
-4, -1, 1, 3, 5, 6, 7, 8, 11, 11, 11, 11, 13, 11, 11, 11, 10, 10, 8, 7, 6, 4, 1,
0, -2, -4, -7, -10, -12, -15, -18, -21, -24, -27, -30, -32, -36, -38, -42, -45,
-48, -50, -54, -56, -58, -61, -64, -66, -68, -70, -72, -73, -74, -77, -77, -78,
-78, -79, -79, -79, -79, -78, -77, -76, -75, -74, -72, -71, -68, -66, -63, -61,
-59, -55, -52, -48, -45, -42, -38, -34, -29, -26, -22, -17, -13, -8, -4, -1, };