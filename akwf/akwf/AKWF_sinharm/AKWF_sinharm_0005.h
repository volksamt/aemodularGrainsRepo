#define DATA_LENGTH 512
#define DATA AKWF_sinharm_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 15, 20, 25, 30, 35, 40, 44, 50,
54, 58, 63, 67, 72, 76, 80, 83, 86, 90, 93, 97, 99, 102, 104, 106, 109, 110,
113, 114, 115, 116, 117, 118, 118, 119, 119, 120, 118, 119, 119, 118, 117, 116,
115, 114, 113, 111, 110, 108, 108, 106, 103, 102, 100, 98, 97, 95, 93, 91, 89,
87, 85, 83, 82, 81, 79, 78, 75, 74, 73, 71, 70, 70, 69, 68, 66, 66, 66, 65, 65,
65, 64, 64, 64, 64, 66, 66, 66, 66, 67, 67, 67, 68, 69, 70, 70, 72, 73, 73, 75,
76, 76, 78, 79, 80, 81, 82, 83, 84, 85, 85, 86, 86, 87, 87, 87, 88, 87, 88, 88,
88, 87, 86, 85, 86, 85, 84, 83, 81, 81, 79, 78, 76, 74, 72, 70, 69, 67, 65, 62,
59, 57, 55, 53, 51, 48, 44, 42, 41, 38, 36, 32, 30, 26, 25, 23, 20, 17, 15, 13,
11, 9, 7, 5, 4, 2, 0, -1, -2, -3, -5, -5, -5, -7, -7, -7, -7, -7, -8, -7, -6,
-5, -4, -4, -2, -2, -1, 1, 3, 4, 5, 7, 9, 11, 13, 15, 17, 19, 21, 24, 25, 28,
31, 32, 34, 37, 38, 41, 43, 46, 46, 48, 51, 52, 54, 54, 56, 57, 59, 60, 60, 61,
61, 61, 62, 61, 62, 60, 60, 59, 59, 57, 56, 55, 54, 53, 50, 48, 46, 44, 41, 40,
37, 34, 32, 29, 26, 22, 20, 16, 13, 10, 7, 3, 0, -3, -6, -10, -13, -16, -19,
-22, -25, -28, -32, -34, -36, -40, -42, -44, -46, -48, -51, -52, -54, -56, -57,
-58, -59, -60, -60, -60, -62, -61, -62, -61, -61, -60, -61, -60, -58, -57, -56,
-56, -54, -52, -50, -49, -48, -45, -44, -41, -39, -37, -34, -32, -30, -29, -27,
-24, -22, -19, -17, -15, -14, -11, -9, -8, -6, -3, -2, -1, 1, 2, 4, 4, 5, 5, 7,
7, 7, 7, 8, 8, 7, 6, 6, 5, 5, 4, 2, 2, 0, -2, -4, -6, -6, -8, -11, -13, -15,
-18, -20, -22, -25, -27, -29, -32, -35, -37, -40, -43, -45, -47, -51, -53, -55,
-58, -60, -62, -64, -66, -69, -70, -72, -74, -76, -78, -79, -81, -82, -82, -83,
-85, -85, -86, -87, -87, -87, -87, -87, -88, -88, -87, -87, -87, -86, -85, -85,
-84, -83, -83, -82, -80, -80, -79, -77, -77, -76, -76, -73, -73, -72, -72, -70,
-69, -69, -67, -67, -66, -66, -65, -65, -65, -64, -65, -65, -64, -65, -65, -65,
-65, -66, -67, -67, -69, -70, -70, -72, -73, -74, -76, -77, -79, -80, -82, -83,
-86, -87, -89, -90, -92, -95, -97, -98, -100, -102, -103, -105, -107, -108,
-110, -111, -112, -113, -115, -116, -118, -118, -119, -118, -118, -119, -119,
-119, -118, -117, -117, -117, -116, -114, -113, -110, -109, -107, -104, -102,
-100, -97, -94, -90, -87, -83, -80, -76, -72, -68, -63, -59, -55, -50, -45, -40,
-36, -31, -25, -21, -15, -11, -5, 0, };