#define DATA_LENGTH 512
#define DATA AKWF_sinharm_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 10, 12, 15, 18, 19, 22, 24,
27, 29, 31, 34, 37, 38, 41, 44, 45, 48, 51, 53, 55, 58, 59, 62, 63, 65, 67, 69,
71, 74, 75, 77, 79, 80, 82, 84, 87, 88, 89, 91, 93, 94, 96, 97, 98, 100, 101,
103, 104, 105, 106, 107, 109, 109, 110, 110, 112, 112, 114, 114, 115, 116, 116,
117, 117, 118, 118, 119, 119, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119,
119, 118, 118, 118, 117, 116, 116, 116, 115, 114, 113, 114, 112, 111, 110, 109,
109, 107, 107, 106, 104, 104, 103, 100, 100, 99, 98, 96, 95, 94, 93, 91, 89, 88,
87, 85, 84, 81, 80, 79, 78, 77, 74, 72, 71, 69, 67, 66, 65, 63, 60, 60, 57, 55,
54, 52, 51, 49, 48, 46, 45, 43, 41, 39, 37, 36, 34, 32, 30, 29, 27, 27, 24, 22,
22, 19, 18, 16, 14, 13, 11, 10, 9, 8, 6, 5, 4, 3, 1, 0, -2, -2, -4, -5, -6, -7,
-8, -9, -10, -11, -13, -13, -14, -15, -16, -16, -17, -18, -18, -18, -19, -21,
-22, -22, -21, -22, -23, -23, -24, -24, -24, -24, -24, -24, -25, -25, -24, -25,
-25, -25, -24, -25, -25, -25, -25, -24, -24, -24, -24, -23, -24, -22, -22, -22,
-21, -21, -20, -19, -19, -19, -18, -17, -17, -17, -15, -15, -14, -13, -13, -12,
-11, -10, -10, -8, -8, -7, -7, -6, -5, -4, -3, -2, -2, -1, -1, 1, 2, 2, 3, 4, 4,
5, 6, 7, 8, 9, 9, 11, 12, 12, 13, 14, 14, 15, 15, 16, 16, 17, 18, 18, 20, 19,
20, 20, 21, 21, 22, 22, 23, 23, 23, 24, 25, 23, 24, 25, 24, 25, 25, 25, 26, 25,
25, 25, 25, 24, 24, 25, 24, 23, 24, 22, 22, 22, 22, 21, 21, 20, 20, 20, 19, 18,
17, 16, 16, 14, 14, 13, 12, 11, 10, 9, 8, 7, 6, 5, 4, 2, 2, 0, -1, -2, -4, -5,
-6, -7, -10, -11, -12, -13, -15, -17, -18, -19, -21, -22, -24, -26, -27, -30,
-31, -32, -34, -35, -38, -39, -40, -42, -44, -45, -47, -49, -50, -53, -54, -55,
-58, -59, -60, -62, -64, -66, -67, -69, -71, -72, -74, -76, -77, -79, -81, -82,
-84, -85, -87, -88, -89, -91, -92, -94, -94, -96, -98, -98, -100, -101, -103,
-104, -104, -106, -107, -108, -108, -109, -111, -110, -112, -113, -114, -114,
-114, -116, -117, -116, -117, -117, -117, -118, -119, -118, -118, -118, -119,
-119, -119, -119, -119, -118, -119, -119, -117, -118, -118, -117, -116, -116,
-116, -114, -114, -114, -113, -111, -111, -109, -110, -108, -107, -107, -106,
-103, -103, -101, -100, -98, -97, -95, -94, -93, -91, -90, -87, -86, -85, -83,
-81, -79, -78, -76, -73, -72, -70, -67, -66, -63, -61, -59, -57, -55, -52, -50,
-48, -45, -43, -41, -39, -37, -34, -31, -29, -27, -25, -22, -20, -16, -15, -13,
-10, -7, -4, -2, 1, };