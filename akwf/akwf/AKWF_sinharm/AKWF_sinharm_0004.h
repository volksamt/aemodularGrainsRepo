#define DATA_LENGTH 512
#define DATA AKWF_sinharm_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 11, 16, 22, 28, 32, 37, 43, 49, 54,
59, 64, 68, 73, 77, 81, 85, 89, 93, 96, 100, 102, 105, 108, 110, 112, 114, 115,
116, 118, 117, 119, 120, 119, 119, 118, 118, 118, 116, 116, 114, 112, 112, 109,
107, 106, 103, 101, 98, 96, 93, 91, 88, 85, 83, 80, 77, 75, 73, 70, 67, 65, 63,
60, 57, 55, 53, 51, 49, 47, 46, 45, 43, 42, 42, 41, 40, 39, 40, 39, 39, 39, 40,
41, 41, 41, 42, 43, 45, 46, 47, 49, 51, 53, 55, 57, 59, 62, 63, 65, 69, 71, 73,
75, 77, 81, 83, 85, 87, 89, 91, 93, 96, 97, 100, 101, 102, 105, 106, 106, 108,
108, 109, 110, 111, 112, 112, 112, 112, 111, 112, 110, 110, 109, 109, 107, 106,
105, 103, 102, 99, 98, 97, 94, 92, 90, 87, 85, 82, 80, 77, 76, 73, 71, 69, 66,
64, 62, 59, 58, 55, 53, 51, 50, 48, 46, 46, 44, 43, 42, 40, 40, 40, 39, 39, 40,
39, 39, 40, 41, 41, 41, 43, 44, 46, 48, 49, 51, 53, 54, 57, 60, 62, 65, 67, 69,
71, 74, 77, 80, 83, 86, 88, 90, 93, 96, 98, 100, 102, 105, 107, 108, 111, 112,
114, 116, 116, 117, 118, 118, 119, 119, 119, 119, 118, 117, 116, 115, 114, 112,
110, 107, 106, 102, 100, 96, 93, 90, 87, 82, 78, 74, 70, 64, 60, 54, 49, 44, 39,
34, 28, 23, 18, 12, 6, 1, -6, -11, -16, -23, -28, -34, -39, -44, -50, -54, -60,
-63, -69, -73, -78, -82, -86, -90, -92, -97, -100, -102, -106, -107, -110, -112,
-114, -115, -116, -117, -118, -118, -120, -119, -119, -119, -118, -117, -117,
-116, -114, -112, -111, -110, -107, -105, -103, -100, -99, -95, -92, -90, -88,
-86, -83, -80, -77, -75, -72, -69, -67, -64, -62, -59, -57, -55, -53, -52, -50,
-47, -46, -45, -43, -42, -41, -40, -40, -39, -39, -40, -39, -40, -39, -40, -41,
-42, -43, -44, -45, -46, -48, -49, -51, -53, -55, -57, -60, -62, -63, -65, -68,
-71, -72, -76, -78, -80, -83, -85, -87, -89, -92, -93, -97, -97, -99, -102,
-103, -105, -106, -107, -108, -109, -110, -111, -112, -112, -111, -112, -112,
-112, -111, -111, -110, -109, -107, -107, -106, -104, -103, -101, -100, -98,
-95, -94, -92, -90, -87, -85, -83, -80, -77, -75, -73, -71, -68, -66, -63, -61,
-59, -56, -55, -52, -52, -50, -47, -46, -46, -44, -43, -42, -40, -39, -39, -39,
-39, -38, -39, -40, -40, -40, -42, -43, -44, -45, -46, -48, -49, -51, -53, -55,
-58, -59, -62, -65, -67, -70, -72, -75, -77, -80, -83, -85, -89, -91, -93, -97,
-98, -101, -103, -106, -107, -109, -111, -113, -114, -115, -116, -117, -119,
-118, -119, -120, -120, -118, -118, -117, -116, -115, -114, -112, -109, -108,
-106, -102, -99, -95, -93, -89, -85, -82, -77, -74, -69, -64, -60, -54, -49,
-44, -39, -33, -28, -22, -17, -11, -5, -1, };