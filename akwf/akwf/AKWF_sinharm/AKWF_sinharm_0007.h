#define DATA_LENGTH 512
#define DATA AKWF_sinharm_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 12, 18, 22, 26, 31, 34, 39, 42,
45, 51, 54, 58, 61, 65, 68, 73, 76, 78, 81, 83, 86, 89, 91, 93, 96, 98, 100,
100, 103, 103, 104, 105, 107, 107, 107, 109, 109, 109, 109, 108, 108, 108, 108,
107, 107, 106, 105, 105, 104, 104, 103, 103, 101, 101, 99, 99, 98, 96, 96, 94,
93, 93, 92, 91, 91, 90, 90, 88, 88, 88, 87, 87, 86, 87, 86, 87, 86, 87, 87, 88,
88, 88, 88, 89, 90, 91, 92, 92, 93, 95, 94, 96, 97, 99, 99, 100, 102, 102, 104,
105, 106, 107, 108, 109, 110, 112, 113, 113, 114, 115, 116, 116, 117, 117, 119,
119, 119, 119, 119, 119, 119, 119, 119, 118, 117, 116, 115, 115, 114, 113, 112,
111, 109, 108, 106, 104, 102, 101, 99, 97, 96, 93, 91, 89, 86, 85, 82, 80, 77,
75, 73, 70, 68, 65, 64, 61, 60, 58, 55, 53, 52, 49, 48, 45, 44, 42, 40, 40, 38,
37, 35, 35, 33, 33, 32, 33, 32, 32, 31, 30, 31, 31, 30, 31, 31, 32, 32, 33, 33,
34, 35, 36, 37, 37, 40, 40, 42, 43, 44, 45, 47, 48, 49, 51, 51, 53, 53, 55, 56,
57, 57, 59, 59, 60, 60, 62, 61, 62, 61, 63, 62, 62, 62, 62, 61, 61, 60, 59, 58,
58, 55, 54, 52, 51, 49, 47, 46, 44, 40, 39, 37, 34, 31, 28, 26, 24, 20, 18, 15,
12, 9, 6, 3, 1, -3, -7, -9, -12, -15, -17, -20, -23, -26, -29, -31, -34, -36,
-40, -42, -43, -45, -47, -50, -51, -53, -54, -55, -56, -58, -59, -60, -60, -60,
-62, -61, -62, -63, -61, -63, -62, -62, -61, -61, -60, -59, -59, -57, -58, -56,
-55, -55, -53, -51, -50, -49, -48, -47, -46, -44, -43, -41, -41, -40, -39, -38,
-37, -36, -35, -33, -33, -33, -31, -31, -31, -30, -31, -31, -30, -31, -30, -32,
-32, -32, -33, -33, -35, -35, -37, -38, -39, -40, -42, -43, -46, -48, -49, -51,
-52, -55, -57, -58, -62, -63, -65, -68, -70, -73, -76, -77, -79, -82, -85, -86,
-89, -91, -93, -96, -97, -99, -101, -103, -105, -106, -108, -110, -110, -112,
-113, -114, -115, -116, -117, -117, -118, -118, -119, -118, -119, -119, -119,
-119, -119, -119, -118, -118, -117, -116, -115, -114, -113, -113, -112, -110,
-110, -108, -108, -106, -105, -104, -103, -102, -101, -99, -98, -97, -96, -96,
-94, -93, -92, -91, -91, -90, -89, -89, -88, -88, -87, -87, -87, -86, -87, -86,
-86, -86, -87, -87, -87, -88, -89, -89, -90, -90, -91, -92, -93, -93, -95, -95,
-97, -97, -98, -99, -100, -101, -103, -103, -104, -105, -105, -106, -106, -107,
-108, -108, -108, -109, -109, -109, -109, -108, -108, -107, -106, -106, -105,
-104, -103, -101, -100, -99, -97, -95, -93, -91, -88, -87, -84, -80, -78, -76,
-72, -69, -65, -62, -58, -54, -50, -46, -43, -39, -35, -31, -26, -21, -18, -13,
-9, -4, 0, };