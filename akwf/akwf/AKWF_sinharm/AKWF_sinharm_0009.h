#define DATA_LENGTH 512
#define DATA AKWF_sinharm_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 9, 15, 19, 24, 29, 34, 39, 43, 48,
52, 57, 61, 65, 70, 74, 77, 81, 84, 87, 91, 93, 97, 99, 102, 103, 106, 108, 111,
112, 114, 114, 116, 117, 117, 117, 118, 119, 119, 119, 119, 118, 118, 118, 117,
116, 115, 114, 113, 112, 110, 110, 108, 107, 105, 104, 103, 101, 100, 97, 96,
96, 94, 92, 90, 89, 87, 87, 86, 84, 82, 81, 80, 80, 79, 78, 78, 77, 76, 76, 75,
75, 76, 75, 76, 76, 76, 76, 76, 77, 78, 78, 79, 79, 80, 81, 82, 82, 84, 84, 86,
87, 87, 89, 89, 91, 92, 93, 94, 95, 96, 96, 98, 99, 100, 100, 101, 101, 102,
102, 103, 104, 103, 103, 103, 104, 104, 103, 103, 103, 102, 102, 102, 101, 99,
98, 98, 96, 95, 94, 93, 92, 90, 90, 89, 88, 85, 84, 82, 81, 79, 78, 77, 75, 73,
73, 71, 70, 68, 67, 66, 65, 64, 63, 62, 61, 61, 60, 59, 58, 58, 58, 58, 58, 58,
57, 58, 58, 59, 59, 60, 60, 61, 62, 64, 65, 65, 66, 68, 69, 70, 73, 73, 75, 76,
79, 80, 82, 83, 85, 86, 87, 89, 91, 92, 94, 95, 96, 97, 99, 99, 101, 102, 101,
103, 103, 104, 104, 103, 103, 102, 102, 101, 101, 100, 99, 98, 96, 94, 93, 90,
88, 87, 85, 82, 79, 76, 72, 70, 66, 63, 60, 55, 52, 47, 44, 39, 36, 32, 27, 23,
18, 14, 9, 4, 1, -4, -9, -13, -18, -22, -26, -31, -36, -40, -43, -47, -51, -55,
-59, -62, -66, -69, -73, -76, -78, -81, -84, -86, -88, -90, -93, -94, -96, -98,
-99, -100, -101, -101, -103, -102, -103, -104, -103, -104, -102, -103, -102,
-101, -101, -100, -99, -97, -96, -95, -94, -92, -90, -89, -88, -86, -84, -83,
-82, -80, -78, -78, -76, -73, -72, -71, -70, -68, -67, -65, -65, -64, -63, -62,
-60, -59, -60, -59, -59, -58, -58, -57, -57, -58, -58, -58, -59, -59, -59, -59,
-61, -62, -62, -64, -65, -67, -67, -69, -70, -72, -72, -74, -75, -76, -78, -79,
-80, -82, -84, -85, -87, -88, -90, -91, -92, -93, -95, -96, -97, -98, -99, -99,
-100, -101, -102, -102, -103, -104, -103, -103, -104, -103, -103, -103, -103,
-102, -103, -102, -101, -100, -100, -100, -99, -98, -97, -96, -95, -94, -93,
-93, -91, -89, -89, -87, -87, -86, -85, -84, -83, -81, -81, -80, -79, -79, -78,
-78, -77, -76, -76, -75, -75, -76, -75, -75, -75, -75, -75, -76, -77, -77, -78,
-78, -80, -81, -82, -82, -84, -85, -87, -87, -89, -89, -92, -93, -95, -96, -97,
-99, -101, -103, -103, -105, -107, -108, -109, -111, -112, -113, -114, -115,
-115, -117, -117, -118, -118, -119, -119, -119, -118, -118, -118, -118, -117,
-116, -114, -113, -113, -110, -109, -106, -104, -102, -100, -97, -94, -90, -88,
-84, -81, -78, -73, -70, -65, -61, -56, -53, -49, -43, -38, -34, -29, -25, -19,
-15, -9, -5, 0, };