#define DATA_LENGTH 512
#define DATA AKWF_sinharm_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 8, 12, 16, 21, 24, 29, 33, 37, 42,
46, 49, 53, 57, 60, 64, 68, 71, 74, 78, 80, 83, 86, 89, 92, 95, 97, 100, 101,
103, 105, 106, 108, 110, 111, 113, 114, 114, 116, 116, 116, 117, 119, 119, 118,
118, 119, 118, 119, 120, 118, 119, 118, 118, 118, 117, 116, 116, 114, 114, 114,
114, 112, 113, 111, 110, 109, 109, 109, 108, 107, 107, 106, 104, 105, 104, 104,
102, 102, 102, 102, 103, 102, 102, 101, 101, 100, 100, 100, 100, 101, 101, 101,
101, 100, 101, 100, 101, 101, 101, 102, 101, 102, 103, 102, 103, 102, 103, 103,
103, 102, 103, 104, 104, 103, 103, 103, 103, 103, 102, 103, 101, 101, 101, 101,
100, 100, 99, 99, 98, 97, 97, 95, 95, 94, 92, 92, 91, 90, 88, 87, 87, 85, 84,
83, 81, 81, 80, 78, 77, 76, 75, 73, 71, 71, 70, 69, 67, 67, 65, 64, 64, 62, 62,
62, 61, 59, 59, 59, 58, 58, 57, 57, 57, 57, 57, 56, 56, 56, 57, 57, 57, 57, 58,
58, 58, 59, 59, 60, 61, 61, 62, 63, 63, 64, 64, 65, 67, 67, 68, 69, 69, 70, 71,
71, 71, 72, 73, 74, 74, 75, 75, 75, 75, 74, 75, 75, 74, 74, 74, 73, 73, 72, 72,
70, 69, 68, 68, 66, 65, 63, 62, 60, 59, 57, 55, 53, 50, 48, 46, 43, 40, 38, 35,
32, 30, 28, 24, 21, 19, 15, 12, 10, 7, 4, 0, -3, -7, -9, -13, -15, -18, -21,
-25, -27, -29, -33, -35, -38, -41, -43, -46, -48, -50, -52, -54, -56, -59, -60,
-62, -64, -64, -66, -67, -68, -70, -71, -71, -73, -72, -74, -74, -74, -74, -75,
-75, -75, -74, -75, -74, -74, -74, -74, -73, -73, -71, -71, -70, -70, -70, -69,
-67, -67, -66, -66, -65, -64, -63, -62, -62, -62, -61, -60, -59, -59, -59, -57,
-58, -57, -57, -57, -57, -57, -56, -56, -57, -57, -57, -57, -57, -58, -58, -59,
-59, -60, -60, -61, -62, -62, -64, -65, -65, -67, -68, -69, -69, -71, -73, -74,
-74, -76, -77, -78, -79, -81, -81, -82, -84, -85, -87, -87, -89, -90, -91, -91,
-92, -94, -95, -96, -96, -96, -98, -98, -99, -99, -100, -101, -101, -101, -101,
-102, -102, -102, -104, -103, -103, -103, -103, -104, -103, -103, -103, -102,
-103, -102, -103, -103, -101, -102, -102, -101, -101, -101, -101, -101, -101,
-101, -101, -101, -101, -100, -101, -100, -100, -100, -100, -100, -101, -101,
-102, -103, -102, -103, -103, -104, -104, -105, -105, -106, -107, -107, -108,
-108, -110, -110, -110, -111, -112, -113, -113, -115, -114, -115, -116, -117,
-117, -117, -117, -119, -118, -119, -119, -120, -119, -120, -120, -119, -119,
-118, -118, -116, -116, -116, -115, -113, -113, -111, -110, -108, -108, -106,
-103, -102, -99, -96, -94, -91, -89, -86, -84, -81, -78, -75, -71, -68, -65,
-61, -58, -53, -49, -45, -42, -38, -34, -30, -25, -22, -17, -12, -9, -4, 0, };