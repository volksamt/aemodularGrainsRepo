#define DATA_LENGTH 512
#define DATA AKWF_sinharm_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 11, 16, 22, 27, 32, 38, 43, 48, 53,
58, 62, 67, 72, 76, 81, 84, 87, 92, 95, 97, 101, 104, 106, 109, 110, 112, 114,
116, 116, 117, 118, 119, 119, 119, 119, 118, 118, 118, 117, 115, 114, 113, 111,
109, 108, 106, 104, 102, 100, 98, 95, 93, 90, 88, 85, 83, 81, 78, 76, 74, 72,
69, 67, 65, 63, 61, 60, 58, 57, 54, 53, 53, 51, 51, 50, 50, 48, 49, 49, 49, 49,
50, 49, 50, 51, 52, 53, 54, 55, 56, 58, 60, 61, 63, 64, 66, 68, 69, 71, 74, 75,
77, 78, 80, 83, 83, 85, 87, 88, 90, 91, 92, 93, 94, 95, 95, 95, 96, 97, 96, 97,
96, 96, 95, 94, 93, 93, 91, 89, 88, 85, 83, 81, 79, 76, 74, 71, 68, 65, 62, 57,
55, 51, 47, 44, 40, 36, 31, 29, 25, 21, 16, 12, 8, 5, 1, -3, -6, -10, -14, -17,
-21, -24, -27, -30, -33, -34, -38, -40, -41, -44, -46, -47, -48, -49, -50, -51,
-50, -52, -52, -51, -51, -50, -49, -49, -48, -46, -45, -42, -41, -39, -37, -35,
-32, -30, -28, -25, -22, -18, -16, -13, -10, -7, -4, 0, 2, 6, 8, 12, 15, 17, 20,
23, 25, 28, 31, 33, 35, 38, 39, 40, 42, 43, 44, 46, 46, 47, 47, 47, 48, 48, 48,
47, 47, 46, 44, 43, 42, 40, 38, 36, 35, 32, 31, 28, 26, 24, 20, 17, 14, 13, 9,
7, 3, 1, -2, -6, -10, -12, -14, -18, -20, -23, -26, -28, -30, -33, -35, -36,
-39, -40, -42, -43, -44, -46, -46, -47, -48, -47, -48, -48, -47, -47, -47, -45,
-44, -44, -42, -40, -39, -36, -34, -33, -31, -28, -25, -24, -20, -17, -15, -11,
-9, -6, -3, 1, 4, 7, 9, 13, 16, 18, 22, 24, 28, 30, 32, 34, 37, 39, 42, 43, 45,
47, 48, 49, 49, 50, 50, 51, 51, 51, 51, 51, 50, 49, 48, 46, 45, 43, 42, 40, 38,
35, 32, 30, 26, 24, 21, 18, 14, 11, 8, 4, -1, -4, -8, -12, -15, -21, -24, -28,
-32, -36, -40, -43, -47, -51, -54, -58, -61, -65, -68, -70, -74, -77, -78, -81,
-84, -86, -87, -88, -91, -92, -93, -95, -95, -96, -96, -96, -97, -96, -97, -96,
-95, -95, -94, -93, -93, -91, -90, -88, -87, -85, -83, -82, -80, -79, -78, -74,
-73, -72, -70, -68, -66, -63, -62, -60, -60, -58, -56, -55, -55, -52, -52, -51,
-50, -50, -49, -50, -49, -49, -48, -49, -50, -50, -50, -51, -52, -54, -55, -56,
-58, -59, -61, -63, -64, -67, -70, -71, -73, -76, -78, -80, -82, -85, -87, -90,
-92, -95, -97, -99, -101, -104, -105, -108, -110, -111, -112, -114, -115, -116,
-118, -118, -119, -119, -119, -118, -119, -119, -117, -116, -116, -114, -113,
-111, -108, -106, -104, -101, -99, -95, -92, -89, -85, -80, -76, -72, -68, -63,
-58, -53, -49, -44, -38, -32, -27, -22, -16, -11, -6, 0, };