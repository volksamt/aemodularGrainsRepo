#define DATA_LENGTH 512
#define DATA AKWF_sinharm_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 9, 12, 15, 19, 22, 25, 28, 31,
34, 37, 40, 43, 46, 48, 52, 54, 57, 60, 62, 65, 67, 69, 72, 74, 77, 79, 81, 83,
85, 86, 88, 90, 92, 93, 95, 97, 98, 100, 101, 102, 104, 104, 106, 107, 107, 108,
110, 111, 111, 112, 112, 113, 113, 114, 115, 116, 115, 116, 117, 116, 117, 117,
117, 117, 118, 118, 118, 119, 118, 118, 119, 119, 119, 119, 119, 119, 120, 119,
119, 120, 119, 118, 119, 119, 119, 120, 118, 119, 118, 119, 119, 119, 119, 119,
120, 119, 119, 119, 119, 119, 118, 118, 118, 118, 118, 119, 117, 118, 118, 118,
117, 117, 117, 117, 116, 117, 116, 116, 115, 115, 114, 114, 114, 114, 113, 113,
112, 112, 111, 111, 110, 110, 110, 108, 108, 107, 108, 106, 106, 105, 105, 103,
103, 103, 102, 101, 101, 100, 100, 99, 99, 98, 97, 96, 96, 95, 95, 94, 94, 93,
93, 93, 92, 91, 91, 90, 89, 89, 89, 88, 88, 88, 87, 87, 87, 87, 87, 86, 86, 86,
85, 85, 84, 84, 84, 84, 83, 82, 82, 83, 83, 83, 82, 82, 81, 81, 80, 80, 80, 80,
79, 79, 79, 77, 77, 77, 76, 76, 75, 75, 73, 73, 72, 71, 71, 68, 68, 67, 67, 65,
63, 62, 61, 60, 58, 57, 55, 54, 52, 50, 49, 47, 46, 44, 41, 40, 38, 36, 34, 32,
29, 28, 25, 23, 21, 19, 17, 13, 12, 10, 7, 5, 3, 0, -2, -5, -8, -9, -11, -13,
-16, -18, -20, -23, -25, -27, -29, -31, -33, -36, -38, -39, -42, -43, -45, -47,
-49, -51, -52, -54, -55, -57, -58, -59, -61, -63, -64, -65, -66, -67, -69, -69,
-70, -71, -71, -73, -73, -74, -75, -75, -76, -78, -78, -79, -78, -79, -79, -79,
-80, -81, -80, -81, -81, -82, -81, -81, -82, -83, -83, -83, -83, -84, -83, -84,
-84, -84, -86, -85, -86, -85, -86, -87, -86, -87, -87, -87, -87, -87, -89, -88,
-89, -90, -91, -91, -91, -92, -92, -93, -95, -94, -94, -95, -95, -96, -97, -98,
-99, -99, -99, -101, -101, -101, -102, -102, -104, -104, -105, -105, -105, -106,
-106, -108, -109, -109, -110, -110, -110, -111, -112, -112, -113, -112, -113,
-114, -114, -114, -114, -115, -114, -115, -116, -116, -117, -117, -117, -117,
-117, -118, -118, -117, -117, -117, -118, -119, -119, -118, -118, -119, -119,
-118, -119, -118, -118, -119, -119, -119, -120, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -118, -118, -118, -118, -118, -118, -117, -116,
-117, -116, -116, -115, -115, -115, -114, -113, -113, -112, -112, -111, -110,
-109, -107, -107, -106, -105, -104, -103, -101, -100, -98, -97, -96, -94, -92,
-90, -89, -87, -85, -83, -81, -79, -77, -74, -73, -70, -67, -65, -62, -59, -56,
-54, -52, -49, -45, -44, -41, -38, -34, -31, -28, -25, -22, -19, -15, -13, -9,
-6, -2, 0, };