#define DATA_LENGTH 512
#define DATA AKWF_sinharm_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 11, 15, 19, 22, 26, 30, 33, 37,
40, 44, 47, 51, 54, 58, 61, 65, 67, 70, 74, 76, 79, 81, 84, 86, 89, 91, 94, 95,
97, 100, 102, 102, 105, 106, 108, 109, 110, 111, 113, 114, 115, 115, 116, 117,
117, 117, 117, 118, 119, 119, 119, 119, 119, 119, 119, 118, 118, 118, 118, 117,
117, 116, 116, 116, 115, 115, 115, 113, 112, 112, 111, 111, 110, 109, 109, 108,
108, 107, 105, 105, 104, 104, 103, 103, 102, 101, 101, 99, 99, 99, 98, 98, 97,
96, 95, 95, 96, 94, 94, 95, 93, 93, 93, 92, 92, 91, 91, 91, 90, 91, 90, 89, 90,
89, 89, 89, 88, 89, 87, 87, 86, 87, 86, 86, 86, 86, 85, 86, 86, 84, 85, 85, 84,
84, 83, 84, 83, 83, 83, 83, 83, 82, 82, 82, 83, 83, 82, 82, 82, 82, 81, 82, 83,
81, 82, 83, 83, 82, 82, 82, 83, 84, 83, 84, 85, 85, 85, 86, 86, 86, 86, 87, 87,
87, 88, 89, 90, 90, 90, 91, 91, 93, 93, 93, 94, 95, 96, 95, 96, 97, 97, 97, 98,
99, 99, 99, 99, 99, 100, 100, 100, 100, 99, 100, 99, 99, 99, 99, 98, 98, 97, 97,
96, 95, 95, 93, 92, 91, 90, 88, 87, 86, 84, 83, 81, 80, 77, 75, 72, 70, 68, 66,
64, 61, 58, 56, 52, 50, 47, 46, 42, 39, 36, 32, 30, 26, 23, 20, 16, 13, 10, 7,
3, 0, -4, -6, -10, -13, -16, -20, -23, -26, -29, -32, -36, -39, -41, -45, -48,
-50, -52, -56, -58, -61, -63, -66, -69, -70, -73, -75, -77, -79, -80, -83, -83,
-86, -87, -88, -90, -91, -93, -93, -94, -94, -96, -96, -97, -98, -98, -99, -99,
-99, -99, -100, -100, -100, -100, -100, -99, -99, -99, -98, -98, -99, -97, -98,
-96, -97, -96, -95, -94, -94, -94, -94, -92, -92, -92, -91, -90, -90, -90, -88,
-89, -88, -87, -87, -86, -87, -85, -85, -86, -84, -84, -84, -83, -83, -83, -83,
-83, -83, -83, -82, -82, -82, -83, -82, -81, -83, -82, -82, -82, -82, -81, -81,
-83, -83, -82, -82, -82, -83, -84, -83, -83, -84, -83, -85, -85, -85, -85, -85,
-86, -86, -86, -86, -86, -87, -88, -88, -88, -88, -88, -88, -89, -89, -89, -90,
-90, -90, -91, -90, -91, -92, -92, -93, -93, -93, -93, -94, -94, -95, -95, -96,
-96, -97, -97, -98, -98, -99, -99, -100, -101, -101, -103, -102, -103, -103,
-104, -105, -106, -106, -107, -107, -108, -109, -110, -110, -111, -112, -112,
-113, -113, -114, -115, -116, -116, -117, -117, -117, -118, -118, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -118, -118, -118, -117, -116, -116,
-115, -114, -114, -112, -111, -111, -109, -108, -106, -105, -104, -101, -99,
-97, -96, -93, -91, -88, -87, -84, -81, -78, -76, -72, -71, -67, -65, -61, -58,
-54, -51, -47, -44, -40, -37, -34, -30, -27, -23, -19, -15, -11, -7, -4, -1, };