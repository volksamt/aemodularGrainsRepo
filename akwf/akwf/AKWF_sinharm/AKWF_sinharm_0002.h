#define DATA_LENGTH 512
#define DATA AKWF_sinharm_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 10, 14, 19, 22, 26, 29, 33, 36,
40, 44, 48, 51, 55, 57, 60, 64, 67, 70, 74, 76, 78, 82, 84, 86, 89, 92, 94, 97,
99, 101, 103, 104, 107, 109, 109, 111, 112, 113, 115, 115, 117, 117, 117, 118,
119, 119, 119, 119, 119, 119, 119, 119, 118, 117, 116, 117, 115, 114, 113, 111,
111, 109, 108, 107, 106, 104, 101, 100, 98, 96, 94, 93, 90, 88, 87, 84, 83, 80,
78, 75, 72, 71, 67, 65, 63, 61, 59, 57, 54, 51, 49, 47, 44, 42, 40, 37, 36, 32,
31, 30, 28, 25, 23, 21, 20, 18, 17, 15, 13, 11, 10, 8, 7, 6, 5, 5, 4, 3, 1, 1,
2, 1, 0, -1, 0, 1, 1, 0, 1, 1, 1, 2, 2, 2, 4, 5, 5, 7, 7, 8, 10, 11, 12, 15, 15,
18, 20, 21, 22, 25, 26, 29, 31, 32, 36, 37, 39, 42, 43, 46, 48, 51, 53, 56, 57,
60, 62, 65, 67, 69, 73, 75, 76, 80, 81, 84, 86, 88, 90, 92, 94, 96, 98, 100,
101, 103, 105, 106, 108, 109, 110, 112, 113, 114, 115, 116, 116, 117, 118, 119,
119, 119, 119, 119, 118, 119, 119, 119, 117, 117, 116, 116, 115, 113, 112, 112,
110, 107, 107, 105, 103, 101, 99, 97, 94, 92, 91, 88, 86, 83, 79, 77, 74, 72,
68, 64, 61, 58, 55, 51, 48, 45, 40, 37, 34, 30, 26, 23, 19, 16, 11, 7, 4, 1, -4,
-8, -11, -15, -18, -22, -27, -30, -33, -37, -40, -44, -48, -52, -55, -57, -61,
-65, -67, -70, -73, -76, -80, -82, -85, -87, -91, -92, -94, -97, -99, -100,
-103, -105, -106, -108, -109, -111, -112, -114, -115, -116, -117, -118, -118,
-118, -118, -119, -119, -118, -119, -119, -119, -118, -118, -117, -117, -116,
-116, -115, -113, -112, -111, -110, -109, -107, -105, -103, -101, -99, -98, -96,
-94, -92, -90, -88, -86, -84, -82, -79, -78, -74, -73, -70, -68, -65, -63, -60,
-59, -56, -53, -52, -49, -46, -44, -42, -39, -37, -35, -33, -31, -29, -27, -26,
-23, -22, -19, -18, -16, -15, -14, -12, -11, -9, -8, -6, -5, -5, -4, -3, -2, -2,
-1, -1, -1, -1, 0, 0, 0, -1, 0, -1, -2, -2, -2, -3, -4, -4, -6, -6, -8, -9, -10,
-12, -12, -15, -16, -18, -19, -22, -23, -25, -26, -28, -32, -32, -35, -37, -39,
-42, -44, -46, -49, -51, -53, -56, -58, -61, -62, -65, -68, -71, -73, -75, -77,
-80, -82, -84, -86, -88, -90, -92, -94, -97, -99, -100, -102, -103, -105, -106,
-108, -110, -110, -112, -113, -114, -115, -116, -117, -118, -117, -119, -119,
-119, -119, -120, -120, -120, -119, -118, -118, -117, -116, -115, -114, -113,
-113, -112, -110, -108, -106, -105, -103, -101, -99, -97, -95, -92, -90, -87,
-85, -82, -79, -77, -74, -70, -67, -65, -61, -57, -54, -52, -47, -44, -40, -36,
-33, -29, -27, -22, -18, -15, -12, -7, -3, 0, };