#define DATA_LENGTH 512
#define DATA AKWF_sinharm_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 13, 19, 26, 31, 38, 43, 49, 56,
61, 66, 72, 76, 81, 85, 91, 94, 98, 101, 105, 107, 110, 113, 114, 115, 117, 119,
118, 119, 119, 119, 118, 118, 115, 115, 112, 111, 108, 106, 103, 99, 96, 93, 89,
85, 80, 77, 72, 68, 64, 59, 54, 49, 43, 39, 34, 29, 25, 20, 15, 10, 6, 2, -3,
-7, -10, -15, -18, -21, -25, -27, -31, -33, -35, -38, -39, -41, -43, -43, -45,
-45, -46, -46, -46, -46, -44, -45, -43, -42, -40, -39, -37, -36, -33, -31, -30,
-26, -23, -22, -19, -16, -14, -10, -8, -5, -2, 2, 3, 7, 10, 12, 14, 16, 19, 20,
23, 25, 26, 27, 28, 30, 30, 32, 32, 32, 32, 32, 32, 31, 31, 29, 28, 27, 24, 24,
21, 18, 16, 13, 10, 8, 5, 2, -1, -5, -8, -11, -15, -19, -22, -26, -30, -33, -37,
-41, -44, -48, -52, -55, -58, -60, -63, -66, -69, -71, -73, -74, -77, -77, -79,
-80, -81, -81, -81, -81, -81, -81, -80, -79, -77, -76, -74, -71, -70, -67, -64,
-61, -57, -53, -50, -46, -42, -37, -34, -28, -24, -19, -15, -10, -4, 1, 6, 11,
16, 21, 26, 32, 36, 41, 46, 50, 55, 59, 62, 66, 70, 73, 76, 80, 82, 84, 87, 89,
90, 92, 92, 92, 94, 93, 94, 92, 92, 91, 89, 88, 86, 84, 80, 78, 74, 72, 68, 63,
59, 55, 50, 47, 40, 36, 31, 27, 21, 16, 10, 4, 0, -6, -11, -17, -22, -27, -32,
-37, -42, -47, -52, -56, -61, -65, -67, -72, -75, -79, -81, -84, -87, -87, -90,
-91, -92, -93, -93, -94, -94, -94, -92, -91, -90, -88, -86, -84, -81, -78, -76,
-73, -69, -65, -62, -58, -53, -48, -44, -40, -35, -30, -25, -20, -16, -10, -4,
0, 6, 10, 16, 21, 25, 29, 34, 39, 42, 46, 51, 54, 58, 61, 65, 67, 70, 72, 74,
75, 77, 79, 79, 80, 81, 82, 82, 81, 81, 80, 79, 77, 76, 75, 73, 71, 67, 65, 62,
60, 56, 53, 50, 47, 43, 39, 36, 33, 29, 25, 22, 19, 14, 11, 7, 5, 1, -3, -5, -8,
-11, -14, -17, -18, -20, -23, -25, -26, -28, -30, -30, -31, -31, -32, -33, -32,
-32, -32, -30, -29, -29, -27, -25, -25, -22, -21, -18, -15, -14, -10, -8, -5,
-3, 0, 2, 5, 8, 12, 14, 17, 19, 21, 25, 27, 30, 32, 33, 36, 38, 40, 41, 42, 43,
45, 45, 45, 45, 46, 46, 45, 44, 44, 42, 41, 39, 37, 35, 32, 30, 27, 24, 21, 17,
13, 9, 6, 2, -2, -7, -11, -15, -21, -26, -31, -36, -40, -45, -50, -55, -59, -64,
-69, -73, -77, -82, -85, -90, -93, -97, -100, -103, -106, -109, -110, -113,
-114, -116, -117, -119, -119, -119, -119, -118, -118, -117, -115, -113, -112,
-109, -107, -105, -101, -97, -94, -89, -86, -80, -75, -70, -65, -60, -54, -48,
-42, -36, -30, -24, -17, -12, -4, };