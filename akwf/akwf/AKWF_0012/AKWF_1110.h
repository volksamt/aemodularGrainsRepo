#define DATA_LENGTH 512
#define DATA AKWF_1110

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -1, 0, 3, 3, 6, 6, 7, 7, 6, 4, 2,
1, 0, 0, -1, -1, 0, 2, 3, 5, 6, 6, 8, 9, 10, 11, 11, 13, 13, 13, 14, 15, 15, 12,
10, 9, 7, 4, -3, -8, -9, -11, -11, -11, -10, -10, -9, -9, -10, -10, -12, -14,
-17, -16, -18, -20, -21, -23, -25, -25, -25, -24, -21, -20, -17, -15, -14, -11,
-9, -8, -7, -7, -5, -4, -2, 0, 2, 3, 2, 3, 2, 3, 1, 0, 0, -2, -2, -1, -1, 0, -1,
-3, -4, -4, -5, -4, -5, -5, -3, -1, 0, 2, 3, 6, 10, 13, 15, 18, 20, 24, 27, 29,
30, 32, 33, 35, 34, 35, 35, 37, 37, 38, 39, 39, 39, 36, 35, 32, 29, 28, 26, 26,
25, 25, 25, 24, 23, 22, 21, 22, 22, 22, 23, 24, 25, 26, 26, 27, 27, 27, 28, 27,
24, 20, 17, 17, 14, 13, 11, 10, 10, 8, 7, 6, 5, 5, 5, 2, 1, 0, -2, -4, -8, -10,
-12, -16, -18, -19, -22, -23, -24, -25, -26, -29, -31, -33, -34, -36, -38, -38,
-38, -38, -37, -37, -37, -39, -39, -41, -42, -44, -45, -46, -47, -49, -50, -51,
-53, -55, -56, -57, -58, -59, -60, -62, -63, -67, -69, -71, -72, -72, -72, -72,
-70, -69, -67, -66, -65, -64, -64, -63, -63, -62, -61, -60, -60, -59, -57, -57,
-56, -56, -57, -58, -60, -59, -58, -56, -54, -54, -53, -52, -52, -51, -51, -51,
-52, -52, -51, -52, -53, -56, -57, -58, -58, -59, -61, -62, -62, -63, -62, -61,
-60, -60, -59, -59, -59, -60, -61, -62, -62, -62, -62, -62, -63, -63, -65, -66,
-68, -70, -72, -72, -74, -76, -76, -79, -80, -81, -84, -85, -87, -93, -97, -98,
-100, -105, -110, -114, -115, -116, -116, -114, -115, -112, -114, -113, -114,
-114, -115, -116, -116, -116, -117, -116, -117, -119, -118, -119, -119, -118,
-118, -119, -117, -117, -118, -118, -118, -117, -115, -114, -108, -102, -98,
-96, -95, -96, -96, -98, -100, -100, -101, -102, -102, -101, -101, -99, -98,
-95, -93, -89, -85, -82, -80, -78, -76, -74, -69, -66, -63, -61, -61, -59, -59,
-58, -59, -58, -58, -59, -59, -59, -61, -59, -60, -58, -56, -54, -50, -48, -47,
-45, -43, -43, -42, -40, -41, -41, -41, -40, -39, -33, -27, -24, -22, -21, -23,
-24, -26, -28, -30, -32, -34, -35, -33, -33, -34, -33, -32, -32, -33, -32, -32,
-32, -34, -36, -37, -38, -38, -37, -35, -35, -32, -30, -29, -26, -26, -25, -26,
-27, -28, -28, -29, -28, -28, -27, -27, -26, -26, -27, -27, -27, -30, -30, -30,
-30, -29, -24, -19, -16, -14, -14, -15, -16, -18, -20, -21, -22, -23, -23, -23,
-23, -22, -22, -20, -18, -16, -14, -12, -13, -14, -14, -15, -16, -17, -17, -18,
-16, -16, -16, -15, -14, -15, -16, -18, -20, -22, -23, -23, -22, -21, -18, -15,
-12, -11, -10, -8, -7, -6, -5, -5, -5, -4, -1, 0, };