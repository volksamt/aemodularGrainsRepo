#define DATA_LENGTH 512
#define DATA AKWF_1130

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 14, 18, 21, 25, 28, 32, 33, 36,
39, 42, 44, 45, 48, 50, 51, 52, 54, 55, 56, 58, 59, 59, 60, 61, 61, 63, 63, 63,
63, 64, 65, 65, 65, 66, 66, 67, 67, 67, 66, 68, 68, 67, 68, 68, 69, 68, 69, 68,
69, 69, 70, 69, 69, 69, 70, 69, 70, 70, 69, 70, 70, 70, 70, 70, 70, 70, 71, 71,
71, 71, 71, 71, 71, 71, 71, 71, 71, 72, 72, 72, 71, 71, 71, 71, 72, 72, 72, 73,
73, 73, 72, 72, 73, 72, 73, 72, 73, 72, 73, 72, 72, 73, 72, 73, 73, 74, 74, 73,
73, 73, 73, 74, 74, 74, 74, 73, 75, 75, 76, 76, 75, 75, 75, 75, 74, 74, 74, 74,
75, 73, 73, 73, 73, 74, 73, 73, 73, 74, 74, 73, 73, 73, 73, 72, 73, 73, 73, 73,
73, 72, 72, 72, 72, 72, 72, 72, 71, 72, 71, 71, 71, 71, 72, 71, 71, 71, 71, 72,
71, 70, 72, 69, 73, 67, 77, 25, 7, 19, -8, -12, -25, -28, -33, -33, -35, -35,
-36, -35, -36, -36, -36, -35, -35, -35, -34, -34, -33, -33, -32, -33, -32, -32,
-31, -31, -31, -31, -30, -30, -28, -29, -28, -29, -27, -28, -27, -27, -25, -26,
-25, -26, -24, -25, -23, -25, -22, 22, 23, 25, 41, 48, 56, 58, 64, 63, 67, 67,
68, 68, 70, 71, 71, 71, 72, 72, 75, 75, 75, 76, 77, 78, 79, 80, 79, 80, 81, 80,
81, 81, 81, 81, 81, 81, 81, 81, 81, 81, 81, 81, 81, 81, 82, 81, 81, 81, 82, 82,
81, 82, 83, 81, 82, 82, 82, 81, 82, 82, 83, 83, 82, 82, 82, 83, 83, 83, 83, 84,
83, 84, 83, 84, 84, 83, 82, 83, 84, 84, 83, 84, 83, 83, 84, 84, 84, 84, 85, 84,
84, 84, 84, 84, 84, 84, 84, 85, 84, 84, 85, 85, 85, 85, 86, 85, 85, 85, 85, 86,
86, 86, 85, 86, 86, 85, 87, 86, 86, 86, 86, 86, 86, 87, 87, 86, 87, 86, 86, 87,
87, 87, 87, 86, 87, 86, 86, 85, 86, 85, 85, 84, 83, 83, 82, 82, 80, 80, 79, 80,
80, 81, 80, 82, 81, 83, 83, 83, 85, 85, 86, 85, 86, 86, 88, 86, 87, 85, 88, 84,
88, 85, 88, 84, 88, 84, 88, 84, 88, 85, 87, 86, 85, 86, 83, 92, 75, 109, -18,
-31, -10, -69, -70, -101, -98, -115, -109, -119, -114, -121, -117, -120, -118,
-119, -118, -118, -119, -117, -118, -116, -117, -115, -117, -115, -116, -114,
-116, -114, -115, -113, -113, -113, -113, -111, -112, -110, -111, -110, -110,
-110, -109, -108, -108, -109, -107, -107, -107, -107, -105, -106, -105, -104,
-104, -105, -103, -103, -103, -102, -102, -102, -103, -101, -101, -101, -101,
-100, -99, -99, -99, -99, -98, -98, -97, -97, -96, -96, -96, -96, -95, -95, -94,
-94, -94, -84, -77, -70, -61, -50, -40, -31, -22, -14, -6, -1, };