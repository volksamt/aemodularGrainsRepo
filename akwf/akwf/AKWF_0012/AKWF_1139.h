#define DATA_LENGTH 512
#define DATA AKWF_1139

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 9, 16, 15, 18, 17, 18, 19, 20,
20, 21, 22, 22, 22, 24, 25, 25, 26, 27, 28, 29, 30, 31, 32, 33, 35, 36, 37, 39,
40, 40, 42, 43, 45, 46, 47, 49, 50, 50, 53, 53, 55, 56, 59, 59, 61, 63, 65, 65,
67, 68, 55, 53, 55, 54, 56, 56, 56, 57, 58, 57, 58, 58, 58, 58, 58, 58, 60, 59,
59, 59, 60, 60, 61, 60, 60, 60, 60, 61, 61, 61, 61, 62, 62, 61, 61, 61, 61, 61,
61, 61, 61, 60, 61, 61, 60, 61, 61, 61, 61, 61, 61, 61, 60, 61, 60, 60, 60, 60,
60, 59, 59, 59, 60, 59, 59, 59, 58, 59, 59, 58, 59, 58, 58, 58, 58, 59, 58, 58,
58, 57, 58, 57, 58, 57, 57, 58, 56, 58, 58, 57, 57, 58, 57, 57, 57, 57, 57, 57,
57, 56, 58, 57, 57, 57, 57, 57, 57, 57, 57, 56, 57, 57, 57, 57, 58, 57, 58, 58,
58, 58, 57, 58, 58, 57, 57, 57, 58, 58, 58, 59, 58, 58, 59, 58, 59, 59, 59, 59,
59, 59, 60, 59, 60, 59, 59, 60, 60, 61, 60, 61, 60, 61, 60, 60, 60, 61, 60, 61,
61, 61, 61, 61, 61, 61, 61, 61, 61, 60, 61, 61, 61, 61, 61, 60, 61, 60, 60, 60,
60, 59, 59, 59, 59, 60, 59, 59, 58, 58, 58, 58, 57, 58, 54, 61, 76, 71, 70, 69,
68, 65, 64, 63, 62, 60, 58, 57, 55, 54, 53, 52, 51, 49, 48, 46, 45, 44, 42, 41,
39, 38, 38, 36, 35, 33, 33, 31, 31, 29, 29, 28, 26, 25, 24, 23, 22, 22, 21, 19,
19, 18, 18, 16, 16, 15, 14, 14, 13, 13, 12, 11, 9, 10, 9, 10, -3, -11, -9, -12,
-13, -16, -16, -19, -19, -22, -22, -25, -26, -27, -29, -31, -32, -34, -36, -37,
-38, -40, -43, -44, -45, -47, -48, -49, -51, -53, -54, -55, -58, -59, -61, -62,
-64, -66, -67, -68, -69, -71, -72, -74, -76, -77, -77, -79, -81, -82, -83, -84,
-86, -88, -87, -89, -91, -91, -93, -95, -95, -96, -97, -99, -100, -100, -102,
-102, -103, -104, -105, -105, -106, -108, -108, -109, -110, -111, -112, -112,
-113, -113, -114, -115, -116, -115, -116, -116, -117, -116, -117, -118, -118,
-117, -118, -119, -119, -118, -120, -119, -119, -119, -119, -120, -119, -118,
-118, -118, -118, -118, -118, -118, -117, -117, -117, -116, -115, -115, -114,
-114, -113, -114, -113, -111, -111, -111, -110, -109, -109, -108, -107, -106,
-105, -104, -103, -102, -101, -100, -99, -98, -97, -96, -96, -94, -92, -91, -90,
-89, -88, -87, -86, -84, -83, -81, -79, -78, -77, -76, -75, -73, -72, -69, -69,
-67, -65, -64, -63, -62, -59, -58, -56, -56, -54, -52, -50, -49, -47, -46, -44,
-42, -41, -39, -37, -36, -34, -33, -30, -30, -29, -27, -24, -23, -21, -19, -19,
-16, -15, -13, -12, -10, -8, -7, -6, -4, -2, -1, };