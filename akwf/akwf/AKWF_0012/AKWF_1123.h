#define DATA_LENGTH 512
#define DATA AKWF_1123

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 14, 23, 32, 43, 54, 63, 73, 83, 90,
98, 104, 110, 114, 118, 119, 119, 117, 114, 110, 105, 98, 89, 81, 71, 60, 49,
38, 27, 14, 1, -4, -4, -3, 3, 10, 19, 27, 34, 39, 42, 43, 43, 41, 36, 32, 25,
17, 10, 2, -5, -13, -23, -32, -42, -51, -59, -67, -76, -83, -88, -94, -98, -101,
-103, -103, -102, -101, -97, -93, -90, -83, -78, -69, -63, -55, -48, -39, -32,
-25, -18, -12, -6, 0, 4, 9, 12, 16, 18, 21, 22, 21, 21, 20, 20, 17, 14, 11, 7,
3, -1, -5, -8, -13, -17, -21, -24, -28, -31, -34, -37, -39, -42, -44, -43, -44,
-44, -42, -43, -40, -39, -37, -34, -31, -28, -25, -23, -20, -17, -14, -12, -10,
-6, -5, -5, -3, -1, 0, 1, 1, 2, 1, 1, 1, 0, 0, 0, -1, -2, -3, -3, -4, -4, -5,
-5, -6, -7, -6, -6, -5, -5, -5, -4, -4, -4, -3, -2, -2, 0, 0, 1, 1, 1, 3, 3, 2,
2, 1, 2, 0, 0, -1, -2, -3, -4, -5, -7, -8, -9, -10, -11, -12, -13, -14, -15,
-15, -15, -13, -12, -12, -11, -9, -7, -6, -3, -1, 1, 4, 7, 10, 13, 16, 20, 22,
24, 28, 29, 31, 34, 34, 35, 35, 34, 34, 33, 31, 29, 26, 23, 20, 17, 13, 10, 5,
2, -2, -6, -8, -13, -16, -18, -21, -23, -24, -26, -27, -27, -27, -25, -23, -21,
-18, -14, -12, -7, -4, 2, 6, 11, 16, 23, 28, 33, 38, 43, 47, 51, 54, 58, 60, 61,
62, 61, 60, 59, 56, 53, 50, 44, 40, 35, 30, 23, 16, 11, 5, -2, -3, -4, -4, 0, 3,
8, 11, 15, 18, 19, 19, 19, 18, 17, 13, 10, 6, 3, -1, -6, -9, -15, -19, -24, -28,
-33, -37, -40, -43, -47, -49, -51, -52, -53, -53, -52, -51, -50, -47, -45, -43,
-39, -36, -33, -29, -25, -21, -18, -14, -11, -7, -5, -2, 0, 2, 4, 4, 6, 7, 7, 7,
7, 6, 6, 5, 4, 1, 0, -1, -2, -4, -7, -8, -11, -12, -14, -16, -17, -18, -20, -19,
-21, -22, -22, -22, -21, -22, -20, -20, -19, -18, -17, -15, -14, -13, -12, -11,
-10, -8, -8, -6, -5, -4, -4, -4, -4, -3, -3, -2, -2, -2, -3, -3, -3, -3, -2, -3,
-4, -4, -3, -5, -5, -4, -5, -5, -5, -5, -5, -4, -5, -4, -4, -4, -3, -5, -4, -4,
-3, -2, -3, -2, -3, -2, -2, -3, -2, -2, -3, -3, -4, -4, -4, -4, -5, -5, -5, -6,
-7, -6, -6, -7, -7, -8, -7, -7, -8, -8, -6, -8, -6, -6, -5, -5, -3, 2, 6, 11,
15, 21, 27, 32, 37, 42, 47, 51, 55, 58, 61, 63, 65, 65, 64, 63, 61, 57, 54, 48,
44, 38, 32, 25, 19, 12, 5, -1, -7, -12, -19, -25, -30, -34, -38, -41, -43, -45,
-44, -42, -41, -37, -34, -28, -22, -15, -9, -2, };