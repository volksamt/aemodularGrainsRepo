#define DATA_LENGTH 512
#define DATA AKWF_1189

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 46, 82, 102, 112, 114, 111, 99, 96,
94, 96, 99, 100, 94, 78, 67, 69, 79, 87, 90, 90, 91, 91, 86, 85, 86, 83, 70, 52,
34, 15, 13, 33, 57, 77, 88, 88, 88, 80, 68, 62, 61, 64, 68, 74, 72, 57, 44, 46,
55, 61, 62, 59, 58, 46, 27, 11, 0, -8, -17, -24, -28, -28, -17, 14, 49, 75, 89,
92, 91, 83, 69, 62, 58, 58, 58, 57, 51, 34, 22, 24, 34, 42, 46, 46, 48, 49, 47,
50, 52, 52, 41, 24, 5, -13, -16, 4, 28, 48, 57, 58, 56, 47, 34, 29, 26, 27, 28,
26, 14, -11, -31, -37, -34, -30, -32, -34, -34, -42, -55, -63, -65, -66, -69,
-70, -68, -65, -48, -13, 27, 57, 73, 78, 78, 71, 57, 52, 49, 50, 51, 50, 45, 27,
15, 18, 26, 34, 35, 35, 37, 35, 29, 28, 28, 25, 13, -5, -23, -41, -42, -22, 4,
24, 34, 35, 35, 28, 16, 12, 11, 14, 20, 25, 24, 12, 4, 9, 19, 25, 27, 24, 23,
11, -8, -22, -33, -40, -49, -56, -60, -60, -48, -16, 19, 46, 58, 60, 58, 50, 36,
30, 27, 26, 27, 25, 19, 1, -11, -7, 2, 10, 13, 12, 15, 13, 6, 3, 0, -8, -24,
-48, -70, -91, -94, -76, -54, -37, -29, -30, -33, -41, -54, -60, -61, -58, -56,
-56, -64, -85, -99, -100, -91, -84, -81, -80, -76, -83, -93, -97, -97, -94, -93,
-92, -88, -82, -62, -23, 19, 51, 69, 75, 78, 71, 58, 54, 53, 53, 55, 55, 49, 32,
20, 24, 33, 41, 43, 43, 46, 44, 39, 38, 39, 36, 23, 4, -14, -31, -32, -11, 13,
34, 43, 42, 42, 32, 20, 16, 15, 17, 22, 27, 24, 8, -2, 2, 10, 17, 18, 15, 14, 1,
-19, -33, -43, -50, -58, -65, -68, -69, -54, -21, 15, 40, 53, 55, 54, 46, 33,
27, 25, 25, 25, 25, 19, 2, -9, -3, 7, 15, 19, 19, 23, 24, 23, 26, 29, 29, 17,
-1, -20, -37, -39, -19, 6, 24, 32, 31, 29, 19, 6, 0, -1, 0, 0, -3, -17, -43,
-62, -65, -62, -59, -61, -63, -65, -74, -87, -93, -96, -96, -99, -99, -98, -94,
-75, -39, 0, 29, 43, 47, 47, 38, 24, 19, 16, 18, 18, 18, 11, -8, -17, -14, -5,
2, 3, 2, 5, 2, -3, -3, -2, -7, -19, -37, -56, -72, -71, -49, -24, -4, 5, 6, 6,
-3, -14, -17, -18, -14, -8, -2, -6, -22, -33, -30, -23, -19, -19, -23, -26, -41,
-61, -75, -87, -95, -104, -110, -114, -115, -100, -66, -32, -8, 4, 6, 3, -6,
-19, -25, -27, -27, -27, -27, -35, -52, -62, -57, -46, -38, -35, -33, -30, -32,
-36, -36, -39, -45, -60, -79, -100, -117, -115, -94, -69, -49, -41, -40, -41,
-50, -60, -62, -61, -56, -53, -51, -60, -80, -92, -89, -79, -71, -66, -64, -59,
-65, -73, -76, -73, -71, -68, -66, -59, -52, -26, };