#define DATA_LENGTH 512
#define DATA AKWF_1190

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 7, 11, 15, 17, 21, 24, 26, 30,
33, 36, 39, 43, 46, 49, 52, 55, 58, 60, 63, 66, 69, 71, 74, 75, 78, 80, 82, 84,
86, 88, 91, 93, 95, 97, 99, 101, 103, 104, 106, 108, 110, 110, 111, 112, 114,
115, 115, 117, 117, 118, 118, 119, 120, 119, 120, 119, 119, 119, 118, 118, 118,
116, 116, 115, 114, 114, 113, 112, 110, 108, 108, 107, 104, 103, 100, 99, 97,
95, 93, 91, 88, 84, 83, 80, 77, 74, 71, 68, 65, 62, 59, 55, 53, 50, 47, 45, 42,
39, 37, 33, 31, 28, 26, 22, 21, 18, 14, 12, 10, 8, 6, 3, 0, -2, -4, -7, -9, -12,
-13, -16, -18, -21, -22, -25, -27, -29, -30, -31, -34, -35, -37, -38, -41, -43,
-43, -45, -46, -48, -49, -50, -52, -52, -54, -54, -55, -57, -59, -59, -61, -62,
-63, -63, -65, -65, -66, -66, -68, -67, -68, -68, -68, -69, -69, -68, -69, -68,
-69, -68, -69, -68, -68, -68, -68, -68, -67, -67, -67, -66, -66, -66, -65, -65,
-64, -65, -64, -64, -64, -63, -63, -62, -62, -61, -61, -61, -60, -60, -59, -59,
-58, -57, -57, -58, -58, -57, -57, -56, -56, -56, -56, -56, -55, -55, -55, -55,
-55, -56, -56, -54, -55, -54, -54, -53, -52, -51, -52, -51, -49, -49, -48, -45,
-44, -43, -42, -41, -39, -37, -36, -35, -33, -31, -29, -27, -26, -24, -22, -20,
-19, -16, -14, -12, -11, -8, -7, -5, -2, 0, 1, 4, 6, 7, 9, 12, 15, 16, 18, 20,
22, 24, 26, 29, 30, 32, 33, 34, 36, 39, 40, 41, 42, 43, 45, 44, 46, 47, 49, 50,
51, 52, 53, 55, 55, 57, 57, 58, 59, 60, 60, 60, 61, 61, 62, 62, 63, 64, 63, 63,
63, 64, 64, 64, 63, 63, 63, 62, 62, 62, 62, 60, 60, 59, 59, 59, 59, 58, 57, 56,
55, 54, 52, 51, 50, 48, 47, 47, 45, 44, 42, 40, 39, 36, 35, 33, 32, 29, 27, 25,
24, 21, 20, 19, 17, 15, 13, 13, 11, 10, 8, 7, 5, 5, 3, 3, 0, -1, -2, -2, -4, -5,
-6, -7, -9, -10, -11, -12, -13, -13, -15, -15, -16, -17, -19, -19, -20, -21,
-22, -22, -22, -23, -25, -25, -26, -27, -27, -28, -29, -29, -30, -31, -31, -31,
-33, -33, -35, -34, -35, -37, -38, -37, -38, -39, -41, -41, -42, -43, -43, -44,
-43, -44, -44, -45, -45, -45, -46, -45, -46, -47, -47, -48, -48, -49, -48, -49,
-49, -49, -50, -50, -50, -51, -52, -52, -52, -52, -54, -53, -54, -55, -55, -55,
-55, -56, -56, -56, -57, -57, -57, -58, -58, -58, -59, -59, -59, -60, -60, -60,
-61, -61, -62, -63, -62, -62, -63, -64, -64, -65, -65, -64, -63, -63, -62, -62,
-62, -60, -59, -58, -57, -55, -55, -53, -51, -49, -48, -46, -45, -42, -40, -38,
-35, -33, -31, -27, -25, -23, -20, -18, -15, -13, -10, -6, -3, 0, };