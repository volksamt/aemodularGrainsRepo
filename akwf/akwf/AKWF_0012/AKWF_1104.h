#define DATA_LENGTH 512
#define DATA AKWF_1104

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 13, 17, 21, 25, 28, 31, 35,
38, 40, 45, 45, 49, 49, 50, 51, 52, 54, 54, 52, 52, 52, 51, 51, 51, 52, 53, 52,
54, 54, 54, 53, 53, 53, 54, 54, 56, 53, 54, 55, 54, 55, 53, 54, 55, 54, 55, 54,
55, 57, 59, 59, 62, 61, 61, 63, 63, 64, 65, 66, 65, 66, 65, 65, 66, 66, 68, 65,
78, 110, 117, 115, 117, 118, 118, 119, 119, 119, 119, 118, 118, 117, 118, 116,
115, 116, 115, 114, 112, 111, 109, 107, 105, 101, 98, 96, 91, 86, 82, 78, 74,
71, 67, 64, 61, 59, 55, 52, 50, 48, 45, 43, 41, 40, 37, 36, 35, 34, 32, 32, 32,
32, 31, 29, 29, 27, 27, 26, 25, 25, 24, 23, 22, 22, 22, 20, 22, 22, 22, 22, 22,
24, 23, 22, 23, 24, 24, 22, 22, 23, 21, 21, 20, 21, 19, 18, 18, 15, 13, 11, 8,
6, 5, 1, -2, -5, -9, -13, -17, -20, -24, -30, -33, -38, -42, -46, -50, -52, -56,
-56, -58, -61, -61, -63, -65, -64, -65, -67, -67, -66, -65, -65, -65, -63, -62,
-61, -58, -58, -55, -52, -49, -48, -46, -43, -40, -38, -36, -34, -32, -29, -27,
-26, -23, -21, -19, -18, -16, -14, -13, -13, -12, -11, -10, -9, -11, -11, -9,
-12, -12, -11, -13, -14, -16, -17, -18, -20, -22, -23, -25, -26, -29, -31, -33,
-34, -35, -36, -37, -37, -39, -40, -41, -42, -42, -44, -46, -45, -45, -47, -47,
-48, -50, -50, -50, -51, -52, -51, -50, -50, -49, -50, -48, -47, -47, -47, -46,
-44, -44, -44, -42, -41, -39, -38, -37, -37, -35, -35, -34, -33, -33, -33, -32,
-33, -34, -35, -36, -36, -40, -40, -43, -46, -47, -49, -51, -53, -53, -55, -57,
-57, -59, -59, -60, -59, -62, -63, -64, -65, -64, -65, -65, -65, -63, -63, -62,
-60, -58, -56, -54, -52, -49, -45, -43, -41, -38, -37, -35, -33, -34, -35, -34,
-36, -36, -37, -39, -36, -39, -39, -38, -38, -39, -40, -40, -40, -37, -38, -38,
-36, -36, -36, -33, -31, -30, -27, -24, -21, -20, -17, -13, -12, -8, -7, -3, -1,
2, 5, 7, 8, 13, 16, 18, 20, 21, 24, 25, 27, 30, 30, 31, 34, 35, 36, 37, 38, 40,
41, 42, 44, 44, 44, 45, 43, 43, 42, 41, 40, 39, 39, 37, 37, 37, 36, 35, 34, 32,
32, 31, 30, 28, 27, 26, 24, 22, 19, 16, 15, 13, 10, 10, 7, 5, 4, 1, 1, -1, -4,
-4, -5, -7, -8, -10, -11, -12, -14, -13, -14, -15, -16, -17, -20, -21, -22, -22,
-23, -25, -26, -28, -28, -28, -29, -30, -30, -30, -30, -31, -32, -32, -32, -35,
-37, -39, -40, -41, -44, -45, -48, -50, -52, -54, -55, -56, -58, -58, -57, -57,
-56, -55, -55, -54, -51, -49, -49, -47, -46, -44, -42, -40, -37, -36, -33, -31,
-27, -26, -22, -19, -16, -14, -12, -9, -6, -3, -1, };