#define DATA_LENGTH 512
#define DATA AKWF_1180

const PROGMEM int8_t DATA[DATA_LENGTH] = {66, 105, 91, 103, 99, 106, 106, 110,
110, 114, 114, 116, 116, 117, 118, 118, 119, 119, 119, 119, 119, 118, 119, 118,
117, 117, 117, 116, 116, 115, 114, 113, 113, 113, 112, 111, 111, 110, 110, 109,
109, 109, 108, 107, 107, 106, 106, 106, 104, 105, 105, 104, 104, 104, 103, 104,
104, 103, 103, 103, 103, 104, 103, 103, 103, 104, 103, 104, 103, 104, 103, 103,
103, 104, 104, 103, 104, 104, 104, 104, 103, 104, 104, 105, 105, 105, 105, 105,
105, 104, 105, 105, 104, 104, 105, 105, 105, 105, 106, 105, 105, 105, 106, 105,
105, 104, 105, 105, 105, 105, 105, 105, 105, 105, 105, 105, 104, 105, 105, 103,
104, 104, 104, 103, 103, 103, 102, 103, 102, 102, 102, 102, 102, 102, 101, 102,
101, 101, 101, 100, 99, 99, 99, 98, 99, 98, 98, 97, 97, 97, 97, 96, 96, 95, 95,
95, 94, 94, 94, 93, 92, 93, 92, 91, 90, 90, 89, 90, 90, 88, 88, 88, 87, 86, 85,
86, 85, 85, 84, 83, 82, 82, 81, 81, 81, 80, 80, 79, 79, 78, 77, 77, 75, 75, 74,
74, 74, 73, 72, 72, 70, 70, 70, 69, 68, 67, 68, 67, 66, 64, 64, 63, 63, 62, 62,
61, 60, 60, 59, 58, 58, 57, 56, 55, 55, 55, 54, 52, 52, 52, 50, 49, 49, 48, 46,
47, 46, 45, 45, 43, 44, 42, 42, 40, 41, 38, 39, 36, 38, 34, 37, 33, 36, 31, 37,
19, -58, -55, -54, -60, -62, -67, -68, -72, -73, -76, -76, -78, -78, -81, -81,
-83, -82, -84, -83, -85, -84, -85, -84, -84, -85, -85, -84, -84, -84, -83, -84,
-83, -82, -82, -82, -82, -81, -81, -81, -81, -81, -81, -81, -81, -80, -81, -80,
-81, -80, -80, -80, -81, -81, -81, -81, -81, -82, -82, -82, -83, -83, -83, -83,
-83, -83, -85, -84, -85, -85, -85, -86, -87, -87, -88, -88, -88, -88, -89, -90,
-89, -91, -90, -90, -91, -92, -93, -93, -93, -94, -94, -94, -94, -94, -95, -95,
-96, -96, -97, -97, -97, -97, -98, -98, -99, -98, -99, -99, -99, -100, -100,
-101, -101, -102, -101, -102, -102, -101, -101, -103, -102, -103, -103, -104,
-104, -102, -103, -104, -103, -104, -103, -104, -104, -104, -105, -104, -104,
-104, -104, -105, -105, -105, -104, -104, -105, -104, -105, -104, -105, -104,
-104, -104, -104, -104, -104, -104, -104, -104, -104, -104, -104, -104, -103,
-103, -103, -103, -102, -102, -102, -102, -102, -102, -102, -101, -102, -100,
-101, -100, -100, -100, -100, -100, -100, -99, -99, -99, -98, -98, -98, -97,
-97, -97, -96, -96, -96, -95, -95, -95, -94, -94, -93, -94, -93, -93, -92, -92,
-92, -92, -91, -91, -91, -91, -89, -89, -89, -87, -88, -88, -87, -86, -87, -86,
-85, -85, -84, -85, -84, -83, -83, -82, -83, -81, -81, -80, -80, -79, -80, -78,
-78, -77, -78, -76, -76, -75, -76, -74, -74, -73, -73, -74, -72, -73, -70, -73,
-67, -76, -35, };