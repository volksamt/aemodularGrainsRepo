#define DATA_LENGTH 512
#define DATA AKWF_1174

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 11, 16, 18, 22, 26, 33, 38, 43,
48, 53, 57, 62, 67, 72, 76, 80, 83, 85, 88, 92, 93, 94, 95, 96, 98, 99, 101,
102, 104, 104, 105, 105, 108, 110, 112, 112, 114, 116, 116, 117, 117, 117, 117,
117, 117, 117, 117, 118, 119, 119, 119, 119, 119, 119, 119, 118, 118, 117, 116,
116, 115, 113, 111, 110, 109, 107, 106, 104, 103, 101, 100, 98, 96, 94, 93, 91,
89, 88, 87, 85, 83, 82, 81, 79, 78, 76, 75, 74, 73, 72, 71, 70, 69, 67, 65, 65,
63, 61, 61, 60, 58, 59, 59, 57, 56, 57, 57, 57, 56, 56, 55, 55, 55, 56, 57, 59,
61, 62, 63, 64, 66, 68, 68, 69, 70, 72, 72, 72, 73, 73, 74, 74, 75, 75, 75, 76,
76, 76, 76, 76, 75, 75, 72, 71, 69, 68, 65, 65, 62, 62, 60, 59, 58, 58, 56, 55,
54, 54, 52, 52, 50, 49, 47, 44, 42, 39, 37, 35, 33, 32, 30, 28, 27, 26, 24, 21,
19, 17, 15, 12, 11, 8, 7, 5, 3, 2, 1, -1, -2, -5, -7, -9, -12, -15, -16, -19,
-22, -26, -28, -30, -33, -34, -36, -38, -40, -41, -42, -43, -43, -44, -44, -44,
-45, -44, -44, -44, -45, -46, -46, -48, -49, -49, -50, -51, -51, -51, -51, -52,
-51, -52, -50, -50, -49, -48, -47, -46, -44, -42, -39, -36, -32, -30, -27, -25,
-22, -20, -18, -16, -14, -13, -10, -8, -7, -4, -3, -1, 1, 2, 4, 5, 6, 6, 8, 9,
11, 14, 16, 18, 20, 22, 24, 26, 27, 28, 29, 30, 30, 32, 32, 33, 33, 34, 34, 35,
34, 33, 34, 33, 33, 34, 33, 32, 33, 32, 32, 32, 31, 29, 29, 25, 23, 22, 19, 17,
16, 13, 12, 11, 8, 8, 6, 5, 3, 2, 0, 0, -1, -3, -5, -8, -11, -12, -15, -17, -20,
-21, -24, -25, -27, -29, -30, -32, -35, -38, -41, -44, -46, -48, -51, -54, -59,
-61, -64, -66, -69, -72, -73, -75, -77, -78, -79, -81, -82, -84, -86, -89, -90,
-91, -93, -94, -95, -96, -96, -96, -96, -96, -96, -96, -95, -95, -94, -93, -93,
-92, -90, -89, -89, -87, -87, -86, -85, -85, -83, -82, -82, -82, -81, -80, -79,
-78, -77, -76, -76, -75, -73, -73, -73, -71, -70, -70, -70, -71, -73, -73, -73,
-74, -75, -76, -77, -78, -79, -79, -79, -81, -84, -85, -87, -89, -91, -92, -94,
-95, -96, -97, -97, -98, -99, -99, -100, -102, -102, -103, -103, -103, -103,
-104, -104, -103, -104, -103, -103, -104, -107, -108, -109, -109, -111, -112,
-112, -114, -114, -114, -115, -115, -115, -114, -115, -115, -114, -114, -114,
-113, -113, -113, -112, -112, -112, -110, -111, -110, -110, -109, -108, -107,
-107, -106, -103, -100, -98, -96, -95, -92, -90, -87, -86, -84, -82, -81, -78,
-75, -71, -67, -64, -62, -59, -56, -51, -46, -42, -39, -36, -33, -28, -24, -20,
-15, -11, -8, -5, -1, };