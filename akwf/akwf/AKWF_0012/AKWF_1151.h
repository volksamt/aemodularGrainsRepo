#define DATA_LENGTH 512
#define DATA AKWF_1151

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 12, 17, 22, 24, 27, 29, 30, 34,
41, 47, 48, 48, 48, 48, 47, 47, 47, 46, 46, 47, 48, 48, 49, 49, 52, 52, 54, 55,
56, 58, 59, 62, 64, 66, 69, 71, 73, 73, 76, 77, 79, 80, 81, 83, 83, 85, 84, 86,
87, 87, 87, 88, 88, 88, 89, 89, 89, 90, 90, 90, 90, 91, 91, 91, 91, 92, 92, 91,
91, 90, 89, 89, 88, 88, 88, 87, 87, 86, 85, 85, 84, 83, 83, 82, 82, 82, 80, 80,
79, 79, 79, 78, 77, 77, 76, 75, 74, 72, 71, 70, 70, 70, 70, 70, 72, 73, 74, 76,
78, 79, 79, 80, 80, 81, 81, 80, 81, 80, 80, 79, 80, 79, 78, 77, 77, 76, 76, 77,
81, 87, 89, 87, 87, 86, 85, 84, 83, 82, 81, 80, 79, 77, 77, 77, 76, 75, 74, 75,
75, 73, 73, 73, 73, 74, 73, 74, 73, 73, 73, 74, 73, 74, 74, 75, 75, 76, 77, 77,
77, 76, 77, 77, 77, 77, 77, 77, 77, 76, 76, 75, 75, 74, 74, 73, 73, 72, 71, 70,
69, 68, 68, 66, 65, 64, 62, 62, 61, 60, 58, 57, 56, 54, 53, 51, 50, 49, 48, 46,
44, 43, 43, 40, 40, 39, 37, 35, 35, 34, 33, 32, 30, 30, 29, 27, 25, 25, 24, 22,
20, 17, 14, 12, 10, 7, 6, 6, 4, 4, 4, 5, 5, 6, 8, 9, 8, 6, 7, 14, 18, 20, 21,
22, 23, 25, 26, 27, 27, 27, 27, 25, 23, 21, 19, 16, 12, 7, 4, 1, -4, -8, -13,
-18, -21, -25, -29, -33, -36, -40, -42, -45, -48, -50, -52, -53, -56, -58, -59,
-59, -61, -60, -62, -61, -62, -61, -61, -61, -61, -62, -63, -61, -62, -62, -62,
-61, -62, -61, -62, -62, -61, -62, -61, -61, -60, -61, -60, -59, -59, -59, -58,
-57, -57, -57, -57, -57, -57, -58, -58, -58, -58, -60, -60, -61, -63, -63, -65,
-66, -68, -71, -72, -74, -76, -78, -80, -82, -84, -87, -89, -92, -94, -97, -100,
-103, -106, -108, -112, -113, -116, -118, -118, -119, -119, -119, -119, -118,
-116, -116, -116, -115, -116, -111, -105, -101, -100, -100, -101, -101, -100,
-101, -99, -99, -98, -97, -96, -95, -94, -93, -91, -89, -88, -88, -87, -86, -85,
-84, -83, -82, -81, -80, -78, -78, -77, -76, -74, -73, -73, -72, -71, -70, -68,
-68, -67, -67, -65, -65, -64, -62, -62, -61, -60, -59, -57, -57, -56, -55, -55,
-54, -54, -53, -52, -51, -52, -51, -51, -49, -50, -49, -49, -49, -49, -48, -48,
-48, -48, -48, -48, -49, -48, -47, -47, -47, -48, -47, -47, -47, -45, -46, -45,
-45, -44, -44, -44, -44, -43, -43, -43, -42, -41, -41, -40, -39, -39, -39, -39,
-37, -37, -35, -36, -34, -34, -33, -34, -32, -32, -31, -32, -32, -33, -32, -27,
-20, -19, -18, -18, -19, -18, -18, -16, -14, -11, -8, 0, 6, 20, -2, -14, -18,
-29, -16, -12, -3, };