#define DATA_LENGTH 512
#define DATA AKWF_1150

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 7, 9, 12, 14, 17, 19, 22, 24,
27, 30, 33, 35, 37, 39, 43, 44, 46, 48, 51, 54, 55, 57, 59, 61, 62, 64, 66, 67,
69, 70, 72, 74, 74, 76, 77, 78, 81, 82, 83, 84, 86, 87, 88, 90, 90, 93, 93, 94,
95, 96, 97, 99, 99, 100, 100, 102, 102, 103, 103, 104, 105, 105, 105, 106, 107,
107, 106, 107, 107, 107, 107, 107, 106, 106, 105, 105, 104, 103, 103, 103, 101,
101, 100, 100, 100, 99, 99, 98, 98, 97, 97, 96, 97, 97, 96, 95, 95, 94, 94, 94,
94, 94, 93, 94, 93, 93, 93, 93, 93, 93, 93, 92, 93, 92, 93, 93, 93, 93, 93, 92,
93, 94, 93, 93, 92, 92, 92, 91, 90, 89, 89, 89, 88, 86, 85, 84, 84, 82, 82, 81,
79, 78, 77, 76, 75, 75, 74, 73, 73, 72, 72, 72, 71, 70, 70, 70, 71, 70, 70, 70,
70, 70, 70, 71, 71, 71, 71, 71, 71, 71, 71, 71, 71, 71, 70, 70, 70, 69, 69, 68,
68, 66, 67, 66, 64, 64, 63, 62, 61, 60, 59, 58, 57, 55, 54, 53, 52, 50, 49, 47,
46, 45, 43, 42, 40, 39, 37, 36, 35, 33, 30, 30, 28, 28, 25, 23, 23, 22, 20, 20,
19, 17, 17, 16, 15, 14, 13, 14, 13, 13, 12, 12, 12, 11, 9, 10, 9, 9, 10, 9, 9,
10, 10, 9, 10, 9, 10, 9, 9, 10, 10, 10, 10, 10, 10, 9, 9, 9, 10, 9, 8, 8, 8, 7,
6, 5, 4, 3, 3, 1, 0, -2, -4, -6, -7, -9, -11, -13, -15, -17, -20, -21, -25, -27,
-29, -31, -33, -35, -38, -39, -41, -43, -45, -46, -47, -50, -50, -51, -51, -52,
-52, -53, -54, -54, -54, -53, -54, -54, -54, -54, -54, -53, -54, -54, -53, -53,
-53, -52, -51, -52, -51, -51, -51, -50, -51, -51, -52, -52, -52, -53, -54, -54,
-55, -57, -58, -59, -60, -62, -63, -65, -66, -69, -71, -73, -75, -77, -78, -81,
-83, -86, -88, -90, -92, -95, -97, -99, -101, -103, -105, -107, -108, -110,
-112, -113, -113, -114, -115, -117, -117, -118, -118, -118, -119, -119, -119,
-119, -119, -119, -118, -118, -117, -116, -116, -116, -115, -113, -112, -111,
-111, -110, -109, -108, -106, -106, -104, -104, -103, -102, -100, -99, -98, -97,
-97, -95, -94, -93, -91, -91, -90, -90, -87, -86, -86, -85, -84, -82, -81, -81,
-81, -79, -79, -77, -76, -76, -75, -75, -74, -72, -71, -71, -70, -70, -69, -68,
-68, -68, -67, -66, -66, -66, -66, -65, -65, -65, -65, -65, -65, -64, -64, -63,
-64, -64, -63, -63, -62, -63, -62, -61, -61, -61, -61, -61, -60, -60, -59, -58,
-57, -57, -56, -55, -54, -54, -53, -53, -52, -51, -49, -49, -47, -46, -45, -44,
-42, -41, -38, -37, -34, -33, -31, -29, -26, -25, -23, -21, -21, -19, -17, -16,
-16, -14, -14, -12, -11, -9, -8, -5, -4, -3, -1, };