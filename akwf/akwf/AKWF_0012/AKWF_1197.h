#define DATA_LENGTH 512
#define DATA AKWF_1197

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 4, 5, 7, 8, 8, 9, 11, 12, 13,
15, 15, 17, 18, 18, 20, 20, 21, 21, 23, 24, 25, 25, 25, 27, 26, 28, 28, 29, 29,
30, 31, 31, 33, 32, 34, 34, 35, 36, 36, 38, 38, 40, 46, 50, 53, 57, 57, 60, 62,
65, 67, 68, 70, 70, 73, 75, 76, 77, 79, 79, 82, 82, 83, 85, 86, 86, 87, 88, 88,
90, 91, 91, 92, 92, 93, 93, 94, 95, 96, 96, 97, 98, 98, 98, 99, 99, 99, 100, 99,
100, 100, 101, 102, 101, 102, 102, 102, 102, 103, 102, 103, 103, 104, 104, 105,
105, 105, 106, 106, 107, 107, 107, 109, 109, 110, 111, 111, 111, 112, 114, 114,
114, 115, 115, 116, 117, 116, 118, 117, 119, 118, 119, 119, 119, 118, 118, 118,
118, 117, 118, 118, 118, 118, 118, 117, 117, 117, 118, 116, 116, 116, 116, 116,
115, 116, 114, 115, 113, 115, 112, 113, 110, 112, 109, 111, 106, 110, 105, 109,
103, 108, 95, 6, 6, 8, 6, 9, 7, 10, 8, 10, 9, 11, 9, 11, 10, 11, 11, 11, 9, 8,
7, 7, 5, 4, 4, 3, 2, 1, 1, 1, 1, -1, -1, -2, -2, -3, -4, -4, -5, -6, -6, -7, -7,
-8, -8, -9, -10, -10, -11, -11, -11, -11, -13, -13, -13, -13, -14, -14, -15,
-16, -16, -17, -17, -17, -18, -19, -20, -20, -21, -22, -23, -22, -24, -24, -24,
-24, -25, -25, -25, -25, -26, -27, -27, -27, -28, -28, -29, -29, -30, -30, -30,
-30, -30, -31, -32, -32, -33, -32, -33, -33, -34, -34, -33, -34, -34, -34, -35,
-35, -35, -35, -35, -36, -36, -36, -36, -37, -37, -36, -37, -38, -38, -38, -38,
-38, -38, -39, -39, -44, -48, -50, -51, -52, -54, -55, -56, -57, -58, -59, -60,
-60, -61, -61, -63, -63, -63, -64, -64, -64, -65, -65, -65, -65, -66, -65, -65,
-66, -66, -66, -67, -66, -66, -66, -66, -66, -67, -67, -67, -66, -66, -65, -65,
-66, -65, -64, -64, -65, -64, -64, -65, -65, -64, -64, -64, -65, -65, -65, -65,
-65, -66, -66, -65, -66, -65, -66, -67, -66, -68, -67, -68, -67, -68, -67, -68,
-68, -67, -67, -68, -68, -68, -69, -69, -69, -68, -68, -68, -68, -68, -68, -67,
-68, -67, -67, -67, -67, -66, -65, -65, -64, -64, -62, -62, -62, -61, -61, -61,
-59, -60, -60, -60, -59, -60, -58, -58, -58, -58, -58, -57, -56, -55, -54, -53,
-53, -52, -51, -50, -50, -49, -47, -46, -45, -44, -44, -43, -42, -41, -41, -39,
-40, -39, -38, -38, -36, -36, -35, -35, -36, -35, -35, -35, -35, -35, -34, -35,
-36, -35, -35, -35, -34, -34, -34, -33, -32, -32, -31, -31, -30, -28, -28, -27,
-26, -25, -23, -23, -22, -21, -21, -20, -19, -18, -18, -17, -17, -16, -17, -16,
-15, -14, -14, -14, -12, -12, -11, -11, -11, -9, -10, -9, -8, -8, -7, -6, -6,
-6, -5, -5, -3, -2, -1, };