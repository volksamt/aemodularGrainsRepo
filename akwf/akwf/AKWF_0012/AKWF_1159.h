#define DATA_LENGTH 512
#define DATA AKWF_1159

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 12, 19, 27, 35, 41, 48, 55, 62, 67,
73, 79, 85, 89, 94, 98, 102, 105, 107, 110, 112, 113, 113, 113, 111, 110, 109,
105, 103, 99, 96, 92, 87, 81, 75, 70, 62, 56, 48, 42, 33, 25, 18, 9, 2, -7, -15,
-22, -31, -38, -46, -53, -59, -66, -73, -79, -84, -89, -94, -98, -103, -105,
-108, -110, -111, -112, -113, -113, -111, -110, -108, -106, -103, -100, -97,
-92, -87, -83, -78, -72, -66, -59, -54, -46, -39, -33, -25, -18, -11, -4, 3, 11,
17, 24, 31, 38, 43, 50, 56, 62, 65, 71, 75, 79, 83, 86, 89, 91, 93, 95, 96, 97,
97, 97, 96, 95, 93, 92, 90, 87, 84, 82, 78, 74, 71, 66, 62, 58, 55, 51, 47, 45,
44, 42, 42, 42, 41, 41, 41, 43, 44, 46, 47, 50, 52, 54, 56, 58, 61, 62, 65, 66,
67, 68, 69, 67, 68, 67, 65, 63, 61, 58, 55, 51, 47, 42, 36, 32, 26, 19, 12, 6,
-1, -8, -17, -25, -31, -39, -46, -53, -60, -67, -74, -80, -85, -91, -96, -100,
-104, -107, -109, -111, -113, -114, -114, -113, -111, -110, -107, -104, -100,
-95, -89, -84, -78, -72, -65, -57, -49, -41, -32, -23, -15, -7, 2, 11, 20, 30,
38, 46, 54, 61, 69, 77, 83, 89, 96, 100, 104, 108, 112, 114, 116, 119, 119, 119,
118, 118, 116, 114, 111, 107, 104, 99, 95, 89, 83, 76, 71, 64, 56, 49, 41, 35,
27, 18, 12, 4, -4, -12, -19, -26, -33, -39, -47, -53, -57, -63, -68, -73, -77,
-82, -85, -88, -90, -93, -95, -96, -97, -97, -98, -97, -97, -95, -93, -93, -90,
-87, -84, -82, -79, -75, -71, -67, -64, -58, -56, -50, -45, -41, -37, -32, -27,
-22, -17, -13, -8, -4, 1, 6, 10, 14, 18, 22, 25, 29, 33, 35, 37, 42, 44, 46, 49,
51, 53, 53, 55, 56, 58, 58, 59, 59, 59, 59, 58, 59, 57, 55, 55, 54, 52, 49, 47,
46, 43, 41, 38, 35, 32, 28, 25, 22, 18, 15, 11, 7, 4, -1, -5, -8, -12, -16, -20,
-24, -27, -31, -34, -38, -41, -44, -47, -48, -52, -54, -56, -58, -59, -61, -62,
-63, -63, -64, -63, -62, -61, -60, -59, -57, -56, -53, -52, -48, -45, -43, -39,
-35, -32, -28, -24, -20, -16, -11, -6, -2, 2, 7, 11, 15, 20, 24, 28, 32, 36, 39,
42, 46, 48, 51, 53, 56, 57, 60, 60, 61, 62, 62, 61, 61, 59, 59, 58, 56, 54, 51,
50, 47, 43, 41, 36, 33, 28, 25, 21, 17, 11, 7, 3, -2, -6, -10, -15, -18, -23,
-27, -30, -34, -37, -40, -44, -47, -50, -53, -54, -56, -58, -61, -62, -64, -63,
-65, -67, -68, -69, -71, -73, -75, -76, -78, -79, -80, -82, -82, -84, -86, -87,
-87, -88, -88, -89, -88, -88, -88, -86, -85, -83, -81, -79, -75, -72, -69, -65,
-60, -55, -51, -45, -39, -33, -26, -20, -14, -7, -1, };