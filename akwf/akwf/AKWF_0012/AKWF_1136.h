#define DATA_LENGTH 512
#define DATA AKWF_1136

const PROGMEM int8_t DATA[DATA_LENGTH] = {45, 53, 49, 53, 49, 50, 49, 50, 48,
50, 48, 49, 48, 49, 47, 48, 47, 47, 47, 46, 46, 45, 45, 45, 45, 45, 44, 44, 44,
43, 43, 43, 43, 42, 41, 42, 42, 41, 41, 41, 40, 34, 27, 21, 14, 8, 1, -3, -2,
-2, -2, -1, 0, 1, 1, 2, 1, 2, 3, 3, 4, 5, 5, 6, 7, 7, 6, 8, 8, 8, 10, 10, 11,
11, 12, 12, 13, 14, 13, 15, 14, 16, 17, 17, 17, 18, 18, 18, 19, 20, 21, 22, 21,
22, 23, 23, 24, 25, 24, 26, 27, 27, 27, 27, 29, 29, 29, 30, 31, 31, 32, 32, 32,
34, 33, 34, 40, 41, 43, 43, 44, 45, 46, 46, 48, 48, 49, 50, 51, 53, 52, 53, 53,
55, 56, 57, 57, 58, 59, 61, 61, 62, 63, 63, 65, 65, 65, 67, 68, 69, 69, 70, 71,
71, 73, 74, 74, 74, 77, 76, 78, 77, 78, 76, 78, 76, 77, 74, 77, 74, 76, 74, 75,
74, 75, 73, 73, 73, 71, 74, 69, 74, 68, 76, 65, 79, 58, 92, -9, -128, -108,
-126, -114, -120, -115, -118, -116, -117, -116, -116, -116, -114, -117, -114,
-116, -113, -115, -113, -114, -113, -114, -111, -113, -111, -112, -111, -111,
-111, -111, -111, -110, -109, -110, -109, -109, -108, -108, -109, -108, -108,
-107, -107, -106, -107, -106, -106, -106, -106, -105, -104, -104, -105, -103,
-104, -103, -103, -102, -102, -103, -101, -101, -101, -101, -101, -101, -99,
-99, -100, -99, -99, -99, -98, -98, -98, -97, -97, -96, -97, -96, -96, -95, -95,
-95, -95, -91, -78, -67, -56, -47, -38, -31, -24, -17, -11, -7, -2, 2, 7, 9, 11,
14, 17, 20, 22, 22, 24, 25, 20, 17, 13, 8, 4, -2, -6, -5, -4, -3, -2, -2, -1, 0,
0, 1, 2, 2, 3, 3, 4, 4, 6, 5, 7, 7, 7, 8, 9, 9, 11, 11, 11, 12, 12, 13, 13, 14,
15, 15, 16, 16, 17, 17, 19, 18, 19, 20, 20, 21, 21, 22, 22, 23, 23, 24, 25, 25,
26, 26, 28, 28, 29, 28, 29, 30, 30, 31, 31, 31, 33, 32, 33, 34, 35, 41, 42, 44,
44, 45, 45, 47, 48, 48, 50, 50, 51, 51, 53, 53, 54, 55, 56, 56, 58, 58, 59, 60,
60, 61, 62, 63, 64, 65, 65, 66, 68, 68, 69, 70, 70, 71, 72, 73, 74, 75, 75, 77,
77, 79, 78, 79, 77, 77, 76, 77, 76, 75, 76, 75, 75, 75, 75, 74, 74, 73, 75, 72,
73, 72, 73, 71, 72, 71, 72, 70, 72, 69, 71, 69, 70, 69, 69, 68, 68, 69, 66, 70,
64, 70, 61, 73, 55, 86, -18, -128, -103, -121, -108, -116, -109, -114, -111,
-112, -111, -111, -111, -109, -111, -108, -111, -108, -111, -108, -110, -107,
-108, -106, -108, -106, -107, -106, -107, -105, -105, -106, -104, -105, -104,
-104, -103, -105, -102, -104, -102, -104, -101, -104, -99, -104, -98, -104, -96,
-107, -85, };