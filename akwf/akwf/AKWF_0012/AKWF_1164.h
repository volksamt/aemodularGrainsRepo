#define DATA_LENGTH 512
#define DATA AKWF_1164

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 7, 8, 10, 13, 15, 17, 17, 20,
22, 22, 25, 33, 40, 43, 47, 50, 54, 56, 60, 63, 66, 69, 71, 74, 75, 78, 81, 82,
85, 87, 88, 91, 92, 94, 95, 96, 98, 99, 101, 101, 102, 103, 105, 107, 107, 109,
110, 110, 111, 112, 112, 112, 113, 114, 114, 115, 115, 116, 116, 117, 117, 117,
117, 118, 118, 118, 117, 119, 118, 114, 110, 110, 109, 107, 105, 104, 102, 101,
99, 99, 98, 96, 95, 93, 92, 92, 90, 89, 88, 86, 85, 85, 83, 83, 82, 81, 79, 78,
78, 77, 76, 76, 74, 74, 73, 72, 72, 71, 70, 69, 69, 69, 67, 67, 66, 65, 65, 65,
63, 63, 62, 62, 61, 60, 60, 60, 58, 59, 58, 57, 57, 56, 56, 55, 55, 55, 54, 53,
53, 53, 53, 51, 51, 51, 51, 51, 50, 49, 49, 48, 48, 47, 47, 47, 46, 46, 45, 45,
45, 43, 44, 43, 43, 43, 42, 42, 42, 41, 41, 40, 40, 40, 39, 40, 39, 39, 39, 37,
38, 37, 37, 37, 36, 35, 35, 35, 34, 34, 34, 34, 33, 33, 33, 33, 32, 32, 31, 32,
31, 31, 30, 30, 30, 29, 30, 29, 29, 28, 28, 27, 27, 28, 26, 26, 26, 26, 25, 25,
25, 25, 24, 24, 23, 23, 23, 23, 22, 21, 22, 22, 21, 21, 20, 21, 20, 20, 19, 19,
19, 18, 19, 18, 17, 17, 18, 16, 16, 16, 15, 15, 15, 15, 14, 14, 14, 14, 13, 13,
12, 12, 12, 12, 12, 10, 11, 12, 10, 2, -3, -5, -7, -9, -13, -14, -17, -18, -21,
-23, -24, -27, -28, -31, -33, -33, -35, -37, -38, -39, -41, -43, -43, -46, -46,
-48, -49, -50, -51, -52, -52, -53, -54, -55, -56, -57, -57, -58, -59, -60, -60,
-61, -62, -62, -63, -63, -64, -64, -65, -66, -65, -66, -67, -67, -68, -69, -68,
-69, -68, -70, -69, -70, -70, -71, -71, -71, -72, -71, -72, -72, -72, -73, -73,
-74, -73, -73, -75, -74, -75, -74, -75, -74, -75, -75, -75, -75, -75, -76, -76,
-75, -76, -76, -76, -76, -77, -77, -77, -76, -77, -77, -77, -77, -78, -77, -78,
-77, -78, -78, -77, -78, -78, -78, -78, -79, -78, -79, -79, -80, -79, -79, -79,
-80, -80, -80, -80, -79, -79, -79, -80, -80, -81, -80, -81, -80, -81, -81, -81,
-81, -81, -82, -81, -82, -81, -81, -82, -82, -82, -81, -82, -83, -82, -82, -82,
-82, -83, -82, -82, -82, -83, -83, -83, -84, -83, -83, -83, -83, -83, -84, -84,
-84, -83, -83, -83, -84, -84, -84, -84, -84, -85, -84, -84, -85, -85, -85, -85,
-85, -84, -86, -85, -85, -85, -86, -85, -85, -85, -86, -84, -80, -77, -75, -74,
-71, -70, -69, -67, -65, -63, -61, -59, -57, -56, -53, -52, -50, -48, -46, -44,
-43, -41, -39, -37, -35, -33, -31, -30, -28, -26, -25, -23, -21, -20, -18, -16,
-15, -12, -11, -8, -7, -6, -5, -2, };