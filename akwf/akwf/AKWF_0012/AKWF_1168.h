#define DATA_LENGTH 512
#define DATA AKWF_1168

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 5, 5, 5, 10, 13, 13, 13, 16, 20,
19, 20, 24, 27, 27, 27, 30, 33, 35, 34, 36, 39, 41, 40, 43, 46, 46, 47, 48, 51,
53, 52, 54, 57, 59, 57, 59, 63, 64, 63, 65, 69, 70, 70, 71, 73, 75, 75, 76, 80,
82, 82, 82, 86, 87, 88, 87, 91, 93, 93, 94, 97, 100, 99, 100, 103, 106, 105,
106, 108, 112, 111, 111, 113, 117, 116, 117, 118, 120, 116, 116, 117, 113, 110,
107, 104, 99, 92, 87, 80, 72, 65, 58, 51, 41, 34, 28, 19, 12, 3, -2, -8, -12,
-15, -16, -18, -17, -18, -17, -17, -15, -14, -13, -12, -12, -10, -9, -8, -8, -8,
-7, -5, -5, -5, -5, -3, -4, -6, -11, -15, -18, -23, -28, -34, -37, -42, -47,
-52, -54, -57, -62, -65, -67, -69, -73, -74, -75, -76, -79, -81, -81, -81, -82,
-85, -84, -84, -85, -86, -85, -84, -85, -86, -85, -84, -84, -86, -84, -82, -83,
-84, -82, -80, -80, -81, -81, -78, -79, -78, -77, -75, -75, -76, -75, -72, -72,
-72, -72, -70, -68, -69, -69, -65, -64, -66, -65, -62, -61, -62, -62, -59, -57,
-57, -58, -54, -52, -54, -54, -50, -49, -49, -49, -47, -44, -46, -45, -42, -39,
-40, -40, -38, -35, -36, -36, -33, -30, -31, -31, -29, -25, -25, -24, -21, -20,
-18, -16, -15, -14, -12, -11, -9, -8, -8, -7, -6, -6, -4, -4, -3, -3, -3, -3,
-2, -2, -1, 0, 0, -3, -4, -1, -3, -5, -5, -3, -3, -4, -5, -2, -2, -4, -2, 0, 1,
-1, 0, 3, 5, 4, 4, 8, 8, 8, 9, 11, 14, 13, 13, 16, 19, 18, 18, 22, 24, 24, 23,
26, 29, 29, 29, 32, 35, 35, 34, 37, 40, 40, 39, 43, 46, 46, 45, 49, 52, 52, 51,
53, 58, 58, 58, 60, 62, 64, 64, 66, 70, 70, 69, 70, 75, 76, 75, 76, 79, 79, 78,
78, 79, 77, 74, 72, 69, 64, 61, 56, 50, 45, 41, 36, 30, 24, 20, 15, 8, 3, -1,
-5, -11, -15, -19, -20, -22, -22, -21, -21, -19, -18, -18, -16, -15, -14, -13,
-12, -10, -9, -9, -8, -8, -6, -5, -4, -4, -4, -4, -7, -7, -9, -13, -18, -20,
-22, -26, -31, -34, -35, -38, -42, -44, -45, -46, -49, -51, -50, -52, -54, -55,
-54, -54, -56, -57, -56, -56, -57, -58, -54, -55, -56, -55, -53, -53, -54, -54,
-51, -51, -51, -52, -49, -48, -48, -49, -46, -45, -45, -45, -42, -41, -41, -41,
-39, -37, -37, -37, -35, -32, -32, -33, -31, -29, -28, -30, -27, -25, -24, -25,
-23, -19, -19, -20, -18, -15, -15, -16, -14, -11, -10, -11, -10, -6, -6, -6, -5,
-2, -1, -2, -1, 3, 5, 4, 4, 8, 10, 8, 10, 14, 15, 14, 13, 12, 12, 10, 9, 8, 7,
6, 6, 4, 4, 5, 4, 3, 3, 2, 2, 2, 2, 2, 1, 0, 1, 1, -1, -2, -4, -1, };