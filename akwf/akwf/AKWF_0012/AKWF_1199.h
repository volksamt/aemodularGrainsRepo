#define DATA_LENGTH 512
#define DATA AKWF_1199

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 4, 6, 8, 10, 11, 14, 14, 16,
18, 18, 21, 22, 23, 25, 26, 28, 29, 31, 33, 34, 36, 37, 39, 40, 42, 43, 45, 46,
48, 48, 50, 52, 53, 55, 56, 58, 58, 60, 60, 65, 48, 38, 43, 42, 45, 46, 47, 49,
51, 51, 53, 54, 55, 56, 58, 59, 61, 62, 63, 64, 66, 67, 68, 69, 71, 72, 73, 74,
75, 77, 78, 79, 81, 81, 82, 83, 84, 86, 86, 88, 86, 93, 71, 58, 64, 62, 66, 65,
67, 67, 69, 69, 70, 72, 72, 73, 74, 75, 76, 77, 78, 79, 79, 80, 80, 82, 82, 84,
84, 85, 86, 86, 88, 88, 90, 89, 92, 90, 93, 90, 96, 90, 98, 90, 104, 108, 52,
60, 58, 59, 61, 60, 62, 61, 63, 62, 65, 63, 65, 64, 66, 65, 67, 66, 67, 67, 69,
67, 69, 70, 70, 70, 70, 70, 71, 71, 72, 72, 72, 72, 72, 74, 73, 74, 74, 74, 75,
75, 74, 74, 75, 75, 75, 76, 75, 76, 76, 77, 76, 75, 77, 76, 76, 76, 76, 76, 77,
77, 77, 76, 77, 77, 77, 77, 77, 77, 77, 77, 77, 78, 77, 78, 77, 76, 76, 76, 76,
77, 76, 78, 74, 51, 50, 52, 51, 50, 50, 51, 49, 49, 49, 50, 49, 50, 49, 49, 50,
48, 49, 48, 48, 49, 48, 48, 47, 48, 47, 47, 46, 47, 46, 47, 45, 47, 44, 46, 44,
46, 43, 46, 43, 46, 39, -24, -26, -24, -28, -25, -28, -36, -42, -44, -46, -46,
-50, -49, -49, -47, -46, -46, -48, -49, -49, -49, -50, -50, -49, -50, -51, -52,
-51, -52, -51, -52, -51, -53, -52, -53, -53, -53, -52, -52, -53, -52, -52, -50,
-69, -78, -75, -77, -76, -77, -76, -77, -76, -77, -76, -77, -76, -77, -78, -77,
-78, -77, -79, -78, -78, -79, -78, -78, -78, -78, -78, -78, -78, -77, -77, -77,
-76, -77, -76, -76, -74, -75, -75, -75, -74, -75, -74, -73, -74, -73, -74, -73,
-72, -73, -73, -73, -72, -72, -72, -71, -71, -72, -71, -70, -71, -69, -69, -68,
-69, -67, -67, -67, -67, -66, -65, -65, -64, -64, -62, -64, -61, -64, -60, -62,
-58, -63, -56, -65, -46, -51, -103, -93, -97, -93, -94, -93, -93, -92, -91, -91,
-90, -90, -88, -88, -87, -87, -85, -85, -83, -83, -82, -80, -79, -79, -78, -77,
-77, -75, -75, -74, -74, -73, -71, -71, -70, -69, -67, -67, -65, -67, -60, -76,
-95, -89, -91, -88, -87, -86, -86, -84, -83, -83, -81, -80, -78, -78, -76, -74,
-73, -72, -71, -71, -68, -68, -66, -65, -63, -62, -61, -59, -58, -57, -57, -54,
-54, -51, -52, -49, -48, -46, -46, -43, -42, -40, -44, -63, -62, -61, -59, -57,
-56, -54, -53, -51, -51, -48, -48, -46, -44, -43, -41, -40, -38, -37, -35, -34,
-32, -31, -29, -28, -26, -25, -23, -22, -20, -19, -16, -15, -13, -13, -10, -9,
-7, -6, -4, -3, 0, };