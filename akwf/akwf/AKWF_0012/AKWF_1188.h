#define DATA_LENGTH 512
#define DATA AKWF_1188

const PROGMEM int8_t DATA[DATA_LENGTH] = {20, 67, 98, 114, 119, 115, 104, 99,
95, 91, 94, 95, 92, 79, 67, 72, 83, 86, 84, 78, 80, 83, 84, 90, 90, 82, 73, 60,
42, 25, 15, 35, 64, 85, 93, 88, 78, 62, 43, 36, 35, 36, 47, 56, 63, 58, 50, 57,
67, 67, 59, 43, 33, 24, 14, 11, 4, -9, -20, -30, -40, -48, -44, -11, 33, 67, 87,
90, 86, 72, 52, 39, 27, 18, 17, 15, 9, -6, -19, -13, -1, 6, 5, 3, 9, 16, 22, 32,
36, 32, 28, 16, 3, -13, -19, 2, 31, 52, 59, 51, 39, 19, 0, -11, -17, -20, -14,
-8, -6, -15, -27, -21, -13, -16, -26, -41, -50, -58, -66, -65, -70, -77, -82,
-88, -91, -93, -82, -41, 9, 51, 76, 85, 86, 76, 60, 52, 43, 36, 35, 32, 26, 9,
-5, -3, 5, 7, 3, -5, -4, -3, -2, 3, 3, -4, -13, -27, -42, -59, -66, -44, -12,
11, 20, 16, 8, -5, -19, -23, -22, -16, -2, 11, 19, 16, 12, 25, 37, 41, 34, 22,
15, 9, 2, 1, -5, -14, -22, -32, -39, -47, -39, -4, 39, 75, 94, 97, 91, 77, 56,
44, 32, 22, 19, 15, 8, -8, -23, -18, -8, -3, -7, -9, -7, -2, 2, 11, 12, 6, -1,
-14, -29, -47, -54, -33, -5, 14, 19, 9, -4, -23, -43, -54, -60, -61, -54, -48,
-45, -54, -63, -56, -46, -47, -54, -67, -74, -79, -84, -81, -82, -86, -89, -91,
-92, -89, -73, -29, 26, 69, 96, 108, 110, 104, 91, 85, 78, 74, 75, 75, 71, 54,
41, 46, 55, 57, 53, 46, 47, 48, 49, 54, 52, 42, 32, 16, -1, -21, -27, -7, 22,
40, 47, 39, 27, 11, -6, -13, -16, -13, -2, 8, 11, 5, -1, 8, 18, 17, 7, -8, -17,
-26, -34, -37, -45, -56, -66, -76, -85, -93, -84, -48, -4, 30, 48, 52, 47, 33,
15, 4, -7, -14, -14, -15, -20, -34, -44, -35, -22, -15, -15, -15, -7, 0, 8, 19,
25, 22, 17, 8, -5, -20, -22, 3, 34, 53, 60, 51, 41, 22, 4, -5, -10, -10, -3, 3,
5, -4, -13, -6, 2, -1, -11, -25, -33, -40, -47, -46, -50, -57, -63, -68, -71,
-72, -56, -15, 35, 75, 99, 106, 105, 95, 79, 70, 60, 53, 53, 49, 41, 22, 9, 14,
20, 20, 15, 7, 6, 7, 7, 12, 9, 0, -10, -26, -43, -60, -65, -42, -13, 7, 14, 8,
-1, -16, -32, -35, -36, -30, -18, -7, -1, -5, -9, 4, 13, 15, 6, -7, -15, -23,
-30, -32, -40, -51, -60, -70, -80, -87, -77, -41, 2, 34, 51, 51, 45, 28, 9, -4,
-17, -26, -29, -34, -43, -61, -74, -66, -57, -54, -57, -60, -56, -52, -46, -37,
-37, -43, -50, -63, -78, -95, -98, -74, -46, -27, -24, -33, -44, -64, -82, -91,
-95, -94, -87, -79, -75, -84, -91, -80, -70, -70, -79, -88, -92, -97, -99, -94,
-95, -97, -97, -98, -96, -92, -72, -23, };