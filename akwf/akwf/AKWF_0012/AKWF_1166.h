#define DATA_LENGTH 512
#define DATA AKWF_1166

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 3, 3, 4, 5, 7, 7, 7, 9, 9, 11,
11, 13, 13, 13, 14, 14, 14, 14, 15, 14, 15, 15, 15, 14, 13, 14, 13, 14, 14, 14,
13, 12, 12, 11, 12, 10, 10, 10, 10, 10, 10, 9, 7, 7, 7, 6, 6, 6, 4, 4, 4, 6, 4,
2, 2, 3, 3, 2, 2, 3, 2, 2, 2, 1, 2, 1, 2, 2, 1, 1, 1, 1, 1, 1, 0, 1, 0, 0, 1, 1,
2, 2, 1, 1, 2, 1, 1, 2, 3, 3, 3, 4, 4, 4, 5, 5, 6, 5, 6, 7, 8, 8, 9, 9, 9, 8, 9,
11, 10, 11, 11, 12, 11, 12, 17, 19, 15, 14, 15, 16, 17, 17, 17, 19, 19, 19, 19,
20, 20, 21, 22, 22, 22, 22, 21, 22, 23, 23, 22, 24, 23, 23, 24, 25, 24, 24, 23,
24, 23, 23, 24, 24, 24, 24, 24, 24, 23, 23, 23, 23, 23, 23, 24, 23, 21, 22, 22,
22, 22, 20, 20, 21, 21, 20, 20, 20, 20, 19, 20, 20, 19, 18, 19, 18, 18, 17, 18,
18, 18, 18, 17, 16, 16, 17, 17, 18, 17, 16, 17, 16, 18, 17, 17, 18, 17, 17, 17,
17, 16, 16, 16, 16, 17, 16, 16, 16, 15, 15, 16, 15, 15, 15, 15, 15, 14, 13, 14,
14, 13, 13, 14, 13, 14, 14, 14, 13, 27, 36, 36, 41, 46, 55, 61, 70, 65, 63, 74,
79, 84, 88, 92, 96, 99, 102, 106, 109, 111, 112, 114, 116, 117, 117, 119, 119,
120, 119, 119, 118, 117, 116, 115, 113, 111, 110, 107, 105, 103, 101, 99, 95,
92, 90, 87, 84, 81, 77, 74, 69, 67, 63, 60, 55, 52, 49, 46, 42, 38, 34, 31, 28,
24, 21, 17, 13, 10, 8, 5, 3, -1, -5, -7, -10, -12, -14, -18, -20, -22, -24, -28,
-29, -32, -33, -35, -36, -38, -41, -42, -45, -46, -48, -48, -50, -51, -51, -54,
-55, -56, -57, -58, -59, -60, -61, -61, -62, -61, -63, -64, -64, -64, -64, -64,
-65, -65, -65, -64, -65, -65, -64, -65, -63, -64, -63, -64, -63, -64, -64, -63,
-63, -62, -62, -58, -56, -58, -59, -59, -59, -58, -57, -56, -56, -55, -54, -55,
-54, -54, -54, -53, -51, -51, -52, -51, -51, -50, -50, -49, -48, -49, -48, -48,
-47, -47, -47, -47, -46, -47, -46, -46, -46, -46, -46, -45, -45, -45, -45, -45,
-45, -44, -45, -44, -44, -44, -44, -44, -44, -44, -44, -45, -43, -42, -42, -44,
-45, -44, -44, -43, -42, -42, -44, -42, -43, -41, -42, -41, -41, -42, -40, -41,
-42, -40, -40, -41, -40, -40, -41, -39, -39, -39, -39, -38, -37, -37, -37, -38,
-38, -37, -37, -37, -37, -36, -36, -36, -35, -35, -34, -34, -35, -34, -33, -32,
-33, -33, -33, -32, -32, -32, -31, -31, -30, -29, -29, -28, -29, -27, -27, -28,
-28, -20, -16, -16, -13, -17, -16, -12, -10, -9, -7, -5, -4, -3, -2, };