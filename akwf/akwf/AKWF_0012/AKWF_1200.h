#define DATA_LENGTH 512
#define DATA AKWF_1200

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 8, 8, 12, 18, 20, 21, 26, 30, 29,
32, 34, 40, 42, 44, 46, 47, 52, 55, 57, 59, 59, 61, 62, 68, 71, 71, 72, 73, 76,
78, 79, 79, 80, 82, 83, 84, 85, 86, 86, 87, 89, 90, 90, 92, 93, 97, 100, 101,
102, 103, 104, 104, 106, 106, 102, 103, 104, 105, 105, 107, 107, 106, 108, 108,
109, 110, 111, 109, 106, 109, 108, 109, 110, 110, 111, 111, 114, 112, 112, 112,
115, 111, 118, 99, 74, 78, 75, 78, 76, 77, 77, 75, 72, 72, 72, 73, 71, 68, 68,
67, 68, 66, 63, 64, 64, 64, 64, 63, 64, 64, 60, 59, 59, 60, 59, 61, 61, 61, 60,
62, 61, 61, 62, 61, 62, 60, 104, 117, 110, 121, 114, 114, 112, 113, 112, 114,
112, 114, 112, 113, 112, 112, 112, 111, 111, 110, 111, 109, 105, 105, 105, 102,
102, 103, 100, 96, 98, 96, 96, 94, 95, 90, 87, 88, 87, 85, 85, 84, 84, 82, 77,
78, 77, 77, 76, 74, 74, 73, 73, 72, 72, 70, 66, 66, 64, 64, 64, 61, 62, 60, 59,
59, 55, 53, 53, 51, 52, 51, 50, 48, 49, 48, 47, 46, 45, 45, 45, 43, 43, 47, 48,
46, 46, 45, 45, 44, 43, 42, 41, 40, 40, 39, 38, 38, 38, 38, 37, 37, 35, 34, 34,
34, 32, 31, 33, 35, 35, 33, 34, 33, 33, 33, 38, 36, 38, 40, 42, 40, 44, 45, 46,
46, 49, 52, -21, -32, -24, -30, -23, -24, -31, -40, -37, -42, -41, -45, -44,
-40, -36, -36, -35, -38, -36, -37, -35, -36, -37, -38, -39, -34, -36, -36, -37,
-39, -37, -38, -39, -40, -41, -41, -42, -41, -43, -42, -43, -43, -44, -45, -45,
-46, -46, -42, -41, -42, -43, -44, -44, -46, -45, -48, -53, -53, -55, -55, -56,
-56, -58, -60, -60, -61, -62, -63, -61, -66, -70, -69, -70, -70, -70, -70, -70,
-71, -72, -72, -74, -73, -75, -74, -75, -75, -78, -83, -82, -83, -85, -86, -85,
-91, -93, -93, -94, -94, -99, -102, -102, -104, -103, -106, -109, -108, -109,
-108, -109, -111, -111, -111, -116, -116, -116, -116, -117, -116, -117, -116,
-117, -116, -117, -116, -117, -117, -117, -116, -70, -64, -67, -59, -64, -65,
-66, -65, -66, -64, -65, -65, -64, -64, -64, -63, -64, -65, -64, -64, -63, -65,
-69, -68, -68, -68, -68, -67, -70, -72, -72, -72, -73, -72, -71, -75, -77, -75,
-77, -75, -78, -72, -84, -114, -113, -114, -113, -112, -112, -112, -112, -110,
-110, -109, -108, -108, -112, -112, -111, -109, -110, -110, -109, -108, -108,
-106, -111, -111, -110, -108, -107, -107, -105, -105, -105, -103, -102, -101,
-99, -99, -98, -97, -96, -90, -88, -88, -86, -86, -85, -83, -82, -81, -80, -79,
-78, -77, -76, -75, -73, -71, -70, -68, -67, -66, -65, -64, -63, -62, -58, -53,
-53, -51, -48, -48, -46, -42, -38, -36, -33, -28, -26, -23, -18, -15, -14, -10,
-4, -3, -1, };