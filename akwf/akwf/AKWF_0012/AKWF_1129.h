#define DATA_LENGTH 512
#define DATA AKWF_1129

const PROGMEM int8_t DATA[DATA_LENGTH] = {18, 23, 20, 22, 21, 21, 21, 21, 21,
22, 21, 22, 22, 22, 21, 21, 22, 22, 21, 22, 21, 21, 22, 21, 22, 22, 22, 21, 22,
21, 22, 21, 22, 22, 22, 21, 22, 22, 21, 21, 22, 22, 21, 22, 22, 22, 21, 22, 22,
22, 22, 22, 21, 23, 21, 22, 22, 23, 22, 22, 22, 22, 22, 21, 22, 22, 22, 21, 22,
22, 23, 22, 22, 22, 22, 22, 22, 22, 22, 23, 22, 22, 22, 22, 21, 22, 23, 22, 23,
21, 22, 22, 22, 21, 22, 22, 23, 22, 22, 22, 22, 22, 22, 21, 22, 23, 22, 22, 22,
23, 22, 23, 22, 22, 21, 23, 22, 23, 20, 23, 20, 23, 21, 24, 20, 24, 20, 27, 114,
121, 116, 120, 116, 119, 117, 120, 117, 119, 117, 119, 117, 118, 118, 119, 118,
118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118,
117, 118, 117, 118, 118, 117, 117, 118, 118, 117, 118, 118, 118, 118, 117, 117,
118, 118, 118, 117, 118, 117, 116, 117, 118, 117, 117, 118, 117, 117, 117, 117,
116, 118, 117, 117, 117, 117, 117, 117, 116, 117, 117, 117, 117, 116, 116, 117,
117, 116, 117, 117, 117, 117, 116, 117, 116, 116, 117, 116, 117, 117, 117, 116,
116, 116, 116, 116, 116, 116, 116, 116, 116, 116, 116, 116, 116, 117, 116, 117,
115, 117, 114, 117, 115, 118, 113, 118, 113, 119, 113, 119, 112, 121, 105, -20,
-22, -18, -22, -19, -22, -18, -23, -20, -22, -19, -22, -19, -22, -20, -22, -20,
-21, -21, -22, -20, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21,
-21, -21, -20, -21, -20, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21,
-21, -20, -21, -21, -21, -21, -20, -21, -21, -22, -21, -22, -22, -21, -22, -21,
-21, -21, -22, -20, -21, -22, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21,
-21, -21, -21, -20, -22, -21, -22, -21, -21, -21, -21, -21, -21, -21, -22, -22,
-21, -22, -21, -21, -20, -22, -21, -21, -20, -22, -20, -21, -21, -21, -20, -22,
-20, -21, -20, -21, -22, -21, -22, -20, -23, -18, -25, -13, -81, -124, -112,
-120, -115, -120, -116, -119, -116, -118, -116, -118, -117, -118, -117, -117,
-117, -117, -117, -117, -118, -117, -117, -116, -117, -117, -118, -117, -117,
-117, -117, -116, -117, -117, -117, -117, -117, -117, -116, -116, -116, -117,
-117, -116, -117, -117, -116, -117, -117, -116, -117, -117, -116, -116, -117,
-117, -116, -116, -116, -117, -116, -116, -116, -116, -116, -116, -117, -115,
-115, -115, -116, -116, -116, -116, -115, -116, -116, -116, -115, -116, -115,
-116, -116, -116, -116, -116, -116, -115, -115, -116, -115, -116, -116, -116,
-115, -115, -115, -115, -116, -115, -115, -115, -116, -115, -115, -115, -116,
-115, -115, -116, -116, -115, -115, -115, -115, -115, -114, -116, -114, -116,
-114, -117, -113, -117, -113, -117, -112, -119, -109, -122, -95, };