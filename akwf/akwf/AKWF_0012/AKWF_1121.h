#define DATA_LENGTH 512
#define DATA AKWF_1121

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 0, 3, 3, 4, 5, 6, 8, 9, 10, 11,
12, 14, 15, 16, 18, 19, 21, 22, 25, 26, 27, 30, 31, 33, 35, 37, 38, 41, 42, 44,
46, 47, 49, 51, 53, 55, 57, 58, 59, 60, 63, 64, 66, 67, 69, 71, 72, 74, 75, 76,
77, 79, 81, 82, 84, 85, 85, 87, 88, 89, 91, 92, 94, 95, 96, 97, 98, 100, 101,
101, 102, 103, 104, 105, 107, 107, 109, 108, 110, 110, 111, 111, 112, 112, 113,
115, 115, 115, 116, 116, 117, 117, 118, 117, 118, 118, 118, 119, 119, 119, 119,
119, 119, 118, 119, 118, 118, 118, 118, 117, 117, 116, 116, 115, 114, 114, 113,
111, 111, 110, 110, 108, 107, 106, 105, 104, 103, 103, 102, 100, 98, 97, 97, 96,
96, 95, 93, 92, 92, 91, 90, 89, 88, 86, 86, 85, 84, 83, 82, 81, 81, 80, 78, 78,
78, 76, 75, 74, 73, 72, 71, 70, 69, 68, 67, 67, 65, 64, 63, 62, 61, 61, 60, 58,
57, 57, 56, 56, 54, 54, 53, 52, 52, 50, 49, 49, 48, 47, 46, 46, 44, 43, 43, 42,
41, 41, 40, 40, 39, 37, 37, 37, 35, 34, 33, 32, 32, 31, 31, 30, 29, 28, 27, 26,
25, 26, 25, 23, 23, 21, 21, 20, 19, 19, 19, 17, 16, 16, 15, 14, 13, 13, 12, 11,
10, 10, 9, 7, 7, 6, 6, 4, 3, 3, 3, 1, 0, 0, -1, -2, -2, -3, -5, -4, -5, -6, -8,
-9, -10, -9, -10, -11, -12, -13, -13, -15, -16, -15, -17, -17, -18, -19, -19,
-21, -22, -22, -23, -24, -25, -26, -25, -27, -27, -27, -28, -30, -30, -31, -31,
-33, -33, -34, -34, -35, -36, -37, -39, -40, -42, -44, -45, -47, -49, -51, -52,
-53, -55, -57, -58, -60, -61, -64, -66, -67, -68, -71, -73, -74, -75, -77, -78,
-79, -80, -82, -82, -84, -85, -86, -87, -89, -90, -91, -92, -93, -93, -94, -95,
-96, -97, -98, -98, -99, -100, -101, -102, -102, -103, -103, -104, -105, -104,
-105, -106, -105, -106, -107, -108, -108, -108, -109, -108, -109, -109, -110,
-110, -110, -110, -110, -110, -110, -110, -110, -110, -110, -109, -109, -110,
-109, -109, -109, -108, -107, -108, -107, -107, -106, -106, -106, -105, -105,
-105, -104, -103, -103, -102, -102, -102, -101, -100, -100, -99, -97, -97, -96,
-96, -95, -95, -94, -94, -92, -92, -91, -90, -89, -88, -87, -87, -85, -85, -84,
-83, -82, -82, -80, -80, -78, -78, -77, -75, -75, -74, -74, -72, -71, -70, -69,
-69, -67, -66, -67, -64, -64, -62, -62, -61, -60, -58, -58, -57, -55, -55, -54,
-53, -51, -50, -50, -49, -48, -47, -45, -44, -44, -43, -42, -41, -40, -39, -38,
-38, -37, -35, -34, -34, -33, -31, -31, -31, -30, -28, -27, -26, -25, -24, -24,
-22, -22, -21, -20, -19, -19, -18, -17, -16, -15, -14, -13, -13, -12, -11, -11,
-9, -9, -7, -7, -5, -5, -4, -3, -3, -1, -1, };