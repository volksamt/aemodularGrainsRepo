#define DATA_LENGTH 512
#define DATA AKWF_1181

const PROGMEM int8_t DATA[DATA_LENGTH] = {64, 71, 62, 74, 72, 79, 77, 83, 82,
86, 85, 87, 86, 88, 87, 88, 86, 86, 86, 85, 84, 83, 81, 80, 80, 79, 78, 75, 74,
73, 72, 69, 69, 67, 65, 65, 63, 61, 60, 59, 58, 57, 55, 54, 53, 52, 51, 50, 48,
48, 47, 45, 45, 44, 44, 43, 43, 41, 41, 40, 40, 40, 39, 39, 38, 38, 37, 37, 37,
36, 37, 35, 35, 35, 36, 35, 36, 35, 35, 35, 35, 34, 34, 34, 34, 34, 34, 34, 33,
34, 35, 34, 33, 33, 34, 33, 33, 34, 35, 33, 34, 34, 33, 35, 35, 34, 34, 33, 34,
35, 35, 34, 35, 35, 34, 34, 35, 35, 35, 35, 35, 35, 35, 35, 36, 35, 36, 36, 36,
36, 37, 37, 37, 38, 38, 37, 37, 38, 38, 39, 39, 39, 39, 40, 39, 39, 40, 39, 40,
40, 40, 41, 41, 40, 40, 41, 41, 42, 42, 42, 43, 43, 43, 43, 44, 44, 45, 44, 45,
45, 46, 45, 46, 46, 47, 48, 48, 47, 48, 49, 50, 49, 49, 50, 50, 50, 51, 52, 52,
52, 52, 53, 54, 54, 54, 54, 55, 56, 56, 57, 57, 58, 58, 58, 58, 59, 59, 60, 60,
61, 62, 61, 61, 63, 63, 63, 63, 63, 65, 65, 65, 66, 66, 67, 68, 68, 69, 70, 70,
70, 70, 72, 71, 72, 72, 73, 74, 74, 75, 75, 76, 76, 77, 77, 78, 78, 79, 78, 80,
78, 82, 79, 84, 79, 90, 48, -89, -107, -98, -107, -107, -112, -112, -117, -115,
-118, -117, -120, -118, -119, -118, -119, -118, -118, -115, -115, -115, -113,
-112, -110, -108, -106, -105, -104, -101, -101, -98, -97, -94, -93, -91, -90,
-89, -87, -86, -84, -82, -80, -79, -78, -76, -75, -74, -73, -71, -70, -69, -68,
-67, -66, -65, -63, -62, -62, -61, -59, -59, -59, -57, -57, -57, -56, -55, -54,
-54, -54, -53, -52, -51, -52, -51, -50, -50, -50, -49, -49, -48, -48, -47, -47,
-46, -46, -46, -46, -46, -45, -45, -45, -45, -44, -44, -44, -44, -43, -42, -43,
-42, -42, -41, -42, -40, -41, -41, -40, -41, -40, -40, -40, -39, -39, -39, -39,
-38, -39, -38, -38, -37, -38, -37, -37, -37, -37, -37, -36, -37, -36, -36, -36,
-36, -35, -36, -36, -35, -35, -34, -35, -35, -35, -35, -35, -35, -35, -35, -34,
-35, -34, -33, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34,
-34, -33, -34, -33, -33, -33, -34, -33, -34, -34, -33, -34, -33, -34, -34, -34,
-33, -34, -34, -33, -34, -34, -35, -34, -34, -35, -34, -34, -35, -35, -36, -35,
-35, -35, -36, -35, -36, -36, -35, -35, -36, -35, -35, -37, -36, -36, -36, -37,
-37, -36, -37, -38, -37, -38, -38, -38, -39, -38, -39, -38, -39, -39, -38, -39,
-39, -40, -40, -41, -39, -41, -40, -40, -40, -41, -42, -42, -41, -43, -43, -42,
-42, -43, -43, -42, -43, -43, -45, -42, -46, -41, -49, -27, };