#define DATA_LENGTH 512
#define DATA AKWF_1173

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 10, 13, 13, 16, 17, 17, 17, 16,
17, 17, 17, 15, 15, 14, 13, 13, 12, 12, 11, 10, 9, 9, 8, 6, 7, 6, 5, 4, 4, 4, 4,
3, 3, 2, 3, 2, 1, 2, 1, 1, 1, 1, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0,
0, 0, 0, -1, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 1, 1, -1, 0, 0, 0,
0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0,
0, 1, 0, 0, 0, -1, 0, -1, -1, 0, -1, 0, 0, 0, 1, 0, -1, 0, 1, 0, 1, 0, 0, 0, 1,
0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1,
-1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 1, 0, 0, 1, -1, 0, 0, 0,
0, 0, 0, 0, 0, 0, -1, 1, 1, 0, 0, 0, -1, -1, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0,
0, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, -34, -66, -93,
-87, -59, -39, -29, -58, -82, -102, -87, -57, -37, -23, -14, -8, -4, -32, -62,
-85, -83, -53, -33, -17, -9, -2, 2, 5, 7, 9, 9, 11, 11, 11, 11, 11, 11, 11, 11,
11, 10, 11, 9, 9, 8, 7, 8, 6, 6, 5, 5, 5, 5, 5, 4, 3, 2, 3, 2, 3, 2, 1, 2, 2, 1,
2, 1, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0,
1, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0, 1, 0, 0,
1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 1, 1, -1, -1, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, -1, 0, -1, 0,
0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0,
0, 0, -1, 0, 0, -1, -1, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 1,
0, 1, -1, 1, 0, 2, -15, -53, -80, -96, -71, -50, -29, -42, -71, -95, -100, -70,
-46, -28, -47, -74, -92, -105, -111, -117, -117, -85, -52, -32, -18, -9, -1, };