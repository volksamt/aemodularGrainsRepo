#define DATA_LENGTH 512
#define DATA AKWF_1138

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 6, 7, 10, 12, 14, 15, 18, 19,
20, 21, 23, 24, 25, 27, 27, 29, 30, 31, 33, 33, 34, 36, 36, 36, 37, 38, 39, 39,
40, 41, 42, 42, 43, 43, 44, 45, 44, 46, 46, 46, 46, 47, 47, 48, 48, 49, 50, 49,
49, 51, 50, 50, 51, 51, 51, 52, 52, 52, 52, 53, 52, 53, 54, 52, 54, 54, 53, 53,
54, 54, 54, 53, 53, 57, 54, 53, 54, 54, 54, 54, 54, 54, 55, 54, 54, 54, 54, 54,
55, 54, 54, 55, 55, 55, 55, 55, 55, 55, 55, 56, 54, 55, 56, 55, 55, 55, 55, 56,
56, 55, 56, 55, 55, 55, 55, 55, 56, 56, 55, 55, 55, 55, 56, 55, 56, 56, 55, 56,
55, 56, 55, 56, 55, 57, 55, 56, 56, 56, 56, 56, 55, 56, 56, 55, 56, 55, 57, 55,
57, 55, 56, 54, 57, 55, 59, 55, 58, 53, 58, 54, 58, 54, 58, 55, 55, 61, -98,
-128, -112, -124, -114, -124, -115, -123, -116, -121, -116, -121, -117, -120,
-117, -119, -118, -120, -118, -119, -119, -118, -119, -118, -120, -118, -120,
-118, -120, -118, -120, -117, -120, -118, -120, -117, -120, -119, -119, -119,
-118, -119, -118, -120, -116, -122, -114, -126, -109, -127, -18, 77, 46, 65, 52,
61, 53, 59, 55, 58, 57, 58, 56, 56, 57, 57, 58, 53, 49, 46, 45, 44, 43, 43, 28,
11, 8, -6, -5, 0, 3, 5, 6, 9, 10, 11, 12, 15, 15, 17, 18, 20, 21, 22, 22, 24,
24, 26, 26, 27, 27, 29, 30, 32, 32, 33, 34, 34, 35, 35, 36, 37, 37, 38, 38, 40,
40, 40, 41, 42, 42, 43, 43, 44, 44, 45, 45, 46, 46, 46, 47, 47, 48, 48, 49, 49,
49, 49, 50, 50, 50, 51, 51, 51, 51, 52, 52, 52, 52, 52, 52, 53, 53, 53, 54, 52,
53, 53, 53, 53, 53, 53, 53, 56, 53, 53, 54, 53, 54, 54, 53, 54, 54, 54, 54, 54,
54, 54, 54, 55, 54, 54, 54, 54, 54, 54, 55, 54, 53, 55, 54, 54, 55, 54, 55, 55,
54, 54, 55, 55, 54, 54, 56, 55, 55, 55, 55, 54, 55, 55, 56, 55, 55, 54, 55, 55,
55, 55, 56, 56, 55, 56, 55, 56, 54, 57, 55, 57, 54, 58, 52, 59, 53, 59, 51, 59,
51, 63, 42, -119, -120, -117, -121, -117, -121, -117, -121, -116, -120, -117,
-120, -117, -120, -117, -120, -119, -119, -118, -120, -118, -119, -119, -119,
-119, -118, -119, -119, -120, -119, -120, -118, -120, -119, -120, -119, -119,
-118, -119, -119, -118, -119, -119, -119, -119, -119, -120, -120, -119, -119,
-120, -119, -119, -119, -119, -119, -118, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -120, -118, -119, -119, -119, -119, -118, -118, -119,
-118, -119, -119, -119, -118, -119, -118, -119, -115, -110, -96, -81, -69, -58,
-48, -39, -32, -28, -27, -25, -21, -18, -15, -13, -10, -8, -5, -2, 0, };