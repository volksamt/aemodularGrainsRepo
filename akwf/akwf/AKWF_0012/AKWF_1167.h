#define DATA_LENGTH 512
#define DATA AKWF_1167

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 9, 12, 14, 14, 14, 14, 15, 14, 15,
15, 16, 18, 17, 17, 18, 18, 18, 19, 18, 22, 27, 27, 29, 29, 31, 30, 30, 30, 31,
30, 30, 32, 31, 37, 40, 39, 41, 41, 43, 42, 44, 42, 46, 52, 51, 53, 53, 53, 54,
54, 53, 55, 55, 56, 55, 55, 55, 55, 56, 55, 59, 63, 62, 63, 63, 64, 64, 64, 64,
64, 64, 64, 64, 63, 69, 71, 70, 71, 71, 71, 71, 71, 71, 71, 71, 72, 71, 73, 78,
74, 74, 74, 74, 74, 74, 75, 73, 74, 73, 74, 73, 75, 79, 77, 78, 78, 78, 78, 79,
79, 79, 78, 78, 79, 77, 82, 82, 83, 82, 82, 82, 82, 82, 83, 82, 81, 81, 81, 82,
86, 86, 85, 86, 61, 49, 51, 46, 47, 43, 43, 40, 41, 39, 39, 37, 37, 37, 38, 40,
40, 40, 40, 39, 40, 40, 40, 41, 41, 41, 41, 41, 41, 42, 42, 42, 42, 43, 43, 43,
46, 47, 47, 47, 47, 49, 49, 50, 50, 49, 51, 50, 51, 51, 53, 53, 55, 55, 55, 55,
56, 57, 58, 59, 59, 59, 60, 60, 60, 60, 60, 60, 61, 61, 62, 61, 63, 61, 63, 63,
64, 64, 66, 66, 66, 66, 67, 66, 67, 67, 66, 67, 68, 68, 68, 69, 69, 70, 69, 70,
71, 70, 72, 72, 73, 73, 73, 73, 73, 73, 73, 73, 74, 74, 75, 74, 76, 75, 76, 74,
78, 76, 78, 77, 79, 77, 78, 78, 80, 79, 78, 77, 75, 77, 72, 84, -30, -75, -68,
-87, -85, -98, -96, -107, -104, -112, -111, -115, -115, -117, -116, -119, -118,
-119, -119, -119, -120, -117, -118, -116, -116, -115, -114, -113, -112, -109,
-109, -107, -106, -104, -103, -100, -98, -97, -96, -94, -93, -91, -91, -88, -88,
-86, -85, -84, -82, -81, -80, -80, -79, -78, -77, -75, -74, -74, -72, -71, -70,
-71, -70, -68, -68, -67, -67, -67, -65, -64, -63, -62, -61, -61, -61, -61, -60,
-60, -59, -58, -58, -59, -57, -55, -55, -55, -54, -54, -54, -53, -53, -53, -52,
-51, -51, -52, -49, -49, -48, -48, -48, -48, -47, -47, -47, -47, -46, -47, -46,
-46, -46, -46, -46, -45, -42, -43, -42, -42, -42, -42, -41, -42, -42, -42, -67,
-73, -73, -76, -76, -78, -79, -81, -81, -83, -80, -80, -80, -80, -80, -81, -81,
-80, -81, -80, -81, -81, -80, -81, -81, -80, -77, -74, -75, -74, -75, -70, -67,
-67, -66, -66, -65, -65, -65, -64, -63, -65, -65, -66, -66, -65, -65, -65, -65,
-64, -64, -65, -63, -58, -57, -58, -57, -57, -56, -56, -55, -55, -54, -55, -54,
-54, -55, -49, -46, -46, -45, -45, -46, -40, -37, -36, -35, -35, -33, -33, -32,
-31, -31, -31, -30, -31, -30, -31, -29, -30, -29, -30, -29, -30, -26, -21, -20,
-19, -17, -17, -16, -15, -16, -15, -16, -15, -15, -16, -9, -5, -5, -5, -4, -4,
-5, -3, -2, -1, -1, -1, -1, 0, };