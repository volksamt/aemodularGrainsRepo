#define DATA_LENGTH 512
#define DATA AKWF_1119

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 2, 2, 2, 3, 4, 4, 6, 5, 7, 7,
8, 9, 9, 9, 10, 10, 11, 11, 12, 13, 14, 14, 15, 16, 16, 17, 17, 17, 18, 18, 19,
19, 21, 20, 21, 22, 22, 23, 25, 26, 27, 27, 29, 29, 30, 32, 33, 34, 37, 38, 39,
41, 43, 46, 47, 50, 53, 56, 59, 61, 64, 66, 69, 73, 76, 79, 81, 83, 87, 89, 90,
93, 95, 97, 99, 99, 101, 102, 102, 103, 103, 103, 102, 104, 104, 105, 106, 107,
109, 109, 111, 110, 110, 111, 111, 112, 111, 112, 112, 113, 115, 115, 116, 116,
117, 117, 118, 117, 118, 118, 118, 118, 119, 119, 119, 119, 119, 119, 118, 119,
119, 118, 117, 117, 117, 115, 115, 114, 114, 114, 114, 113, 112, 112, 112, 110,
110, 109, 108, 107, 106, 105, 104, 103, 103, 100, 99, 96, 95, 93, 91, 89, 87,
85, 83, 82, 80, 78, 75, 73, 71, 68, 67, 63, 62, 59, 57, 55, 53, 51, 49, 48, 45,
43, 42, 41, 41, 41, 41, 44, 46, 46, 45, 45, 42, 41, 38, 36, 35, 35, 34, 34, 35,
35, 35, 35, 33, 33, 32, 30, 30, 28, 26, 27, 25, 24, 24, 22, 22, 21, 21, 20, 19,
19, 17, 16, 15, 16, 15, 15, 15, 14, 15, 14, 13, 13, 12, 12, 12, 10, 9, 8, 8, 7,
7, 7, 6, 7, 7, 5, 6, 5, 5, 4, 3, 3, 2, 1, 1, 0, 0, -1, -2, -2, -3, -4, -4, -5,
-5, -5, -6, -7, -8, -9, -9, -8, -9, -10, -11, -11, -12, -13, -13, -14, -16, -16,
-17, -17, -18, -19, -20, -21, -21, -22, -23, -24, -24, -24, -25, -26, -26, -26,
-27, -29, -29, -29, -30, -31, -31, -32, -33, -33, -33, -34, -34, -35, -36, -35,
-37, -37, -38, -40, -40, -40, -40, -41, -42, -42, -42, -43, -44, -44, -44, -45,
-46, -47, -46, -47, -48, -47, -48, -48, -50, -50, -49, -50, -51, -51, -51, -53,
-55, -60, -67, -76, -85, -94, -100, -104, -103, -101, -98, -97, -96, -97, -100,
-104, -110, -113, -117, -119, -118, -117, -115, -114, -112, -110, -109, -108,
-108, -108, -110, -110, -111, -111, -111, -111, -109, -108, -106, -104, -104,
-105, -105, -106, -106, -108, -109, -109, -110, -110, -109, -106, -106, -106,
-104, -103, -102, -101, -101, -101, -101, -100, -100, -99, -100, -100, -99, -98,
-97, -97, -95, -94, -94, -92, -91, -89, -88, -86, -85, -85, -84, -83, -82, -81,
-80, -79, -78, -76, -75, -74, -73, -71, -71, -71, -70, -70, -69, -68, -68, -67,
-64, -64, -62, -60, -58, -57, -55, -54, -53, -51, -51, -50, -50, -50, -49, -47,
-47, -45, -43, -42, -41, -39, -39, -38, -37, -37, -37, -37, -36, -36, -35, -33,
-31, -30, -28, -27, -26, -25, -25, -24, -24, -23, -23, -21, -20, -18, -17, -16,
-15, -13, -13, -13, -12, -12, -10, -10, -9, -8, -7, -6, -6, -5, -5, -4, -3, -2,
-2, -1, 0, };