#define DATA_LENGTH 512
#define DATA AKWF_1135

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 0, 2, 2, 2, 3, 4, 3, 4, 4, 4,
5, 5, 5, 5, 6, 5, 6, 6, 7, 8, 7, 7, 8, 8, 8, 7, 8, 6, 8, 7, 6, 7, 6, 7, 7, 9, 8,
10, 9, 10, 14, 9, 13, 15, 14, 15, 16, 19, 17, 19, 20, 19, 21, 23, 20, 25, 22,
22, 20, 22, 21, 20, 22, 19, 22, 21, 21, 22, 24, 19, 21, 16, 15, 16, 14, 11, 9,
7, 8, 9, 12, 13, 14, 18, 19, 25, 32, 34, 37, 42, 45, 48, 47, 54, 51, 59, 60, 57,
57, 55, 60, 54, 59, 53, 55, 55, 50, 51, 50, 49, 43, 41, 41, 33, 31, 30, 28, 27,
21, 25, 28, 29, 27, 34, 33, 31, 36, 33, 44, 42, 46, 49, 56, 64, 67, 73, 67, 77,
77, 75, 78, 86, 82, 84, 84, 83, 89, 78, 74, 72, 72, 67, 61, 59, 61, 61, 56, 55,
50, 59, 55, 49, 54, 57, 56, 50, 54, 59, 52, 55, 48, 52, 53, 59, 62, 60, 65, 64,
82, 79, 85, 82, 88, 99, 100, 100, 100, 106, 110, 114, 115, 117, 113, 110, 102,
114, 110, 110, 111, 110, 111, 106, 113, 103, 112, 112, 103, 105, 98, 96, 92, 89,
87, 86, 91, 84, 92, 89, 95, 87, 81, 91, 85, 90, 90, 94, 84, 89, 91, 80, 90, 92,
87, 86, 92, 88, 91, 83, 85, 93, 78, 87, 73, 102, -17, -111, -69, -101, -86, -83,
-88, -79, -80, -87, -74, -91, -90, -85, -91, -86, -100, -97, -91, -93, -92, -88,
-90, -90, -82, -86, -81, -70, -84, -79, -81, -83, -78, -73, -76, -82, -68, -64,
-69, -58, -63, -56, -53, -56, -48, -51, -50, -58, -52, -58, -51, -56, -70, -51,
-69, -69, -66, -69, -70, -77, -70, -73, -76, -70, -78, -78, -74, -83, -72, -70,
-66, -71, -65, -63, -65, -57, -64, -59, -59, -62, -61, -50, -53, -45, -43, -42,
-34, -31, -28, -22, -25, -27, -30, -33, -33, -40, -40, -52, -60, -64, -68, -73,
-78, -78, -77, -85, -81, -92, -91, -85, -83, -80, -85, -77, -82, -72, -75, -73,
-66, -66, -63, -61, -53, -52, -50, -41, -40, -37, -36, -32, -26, -31, -33, -33,
-31, -37, -34, -34, -36, -35, -43, -40, -45, -45, -51, -54, -56, -60, -56, -62,
-60, -58, -59, -64, -59, -61, -59, -58, -61, -53, -50, -48, -47, -44, -39, -38,
-38, -37, -35, -33, -30, -34, -31, -29, -30, -31, -30, -27, -29, -30, -27, -27,
-24, -26, -25, -28, -28, -27, -28, -28, -33, -31, -32, -32, -33, -36, -36, -34,
-34, -34, -35, -35, -35, -35, -33, -31, -29, -32, -30, -29, -28, -27, -27, -26,
-26, -24, -25, -24, -21, -22, -19, -19, -19, -17, -15, -16, -15, -14, -14, -14,
-14, -12, -12, -12, -11, -11, -11, -11, -10, -10, -9, -8, -9, -8, -8, -6, -7,
-6, -5, -5, -5, -4, -4, -4, -3, -3, -3, -2, -2, -1, -1, -2, -1, 0, 0, };