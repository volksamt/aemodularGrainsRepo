#define DATA_LENGTH 512
#define DATA AKWF_1111

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 7, 9, 10, 12, 14, 15, 17, 19,
20, 23, 25, 27, 29, 31, 32, 33, 35, 36, 37, 40, 40, 40, 41, 42, 43, 43, 45, 46,
47, 48, 51, 52, 52, 53, 54, 55, 57, 57, 57, 59, 61, 63, 64, 66, 67, 69, 70, 72,
73, 75, 77, 77, 79, 81, 81, 83, 85, 86, 86, 87, 89, 91, 92, 93, 93, 95, 96, 96,
97, 97, 98, 100, 100, 101, 102, 103, 103, 104, 104, 105, 105, 105, 106, 107,
107, 109, 110, 109, 110, 111, 111, 114, 114, 115, 115, 115, 116, 116, 117, 117,
117, 118, 117, 118, 118, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119,
118, 118, 118, 116, 116, 115, 115, 114, 113, 112, 112, 111, 110, 109, 109, 108,
107, 106, 106, 104, 104, 103, 103, 102, 100, 100, 99, 97, 96, 95, 93, 92, 92,
91, 90, 88, 88, 88, 87, 87, 87, 86, 88, 87, 86, 86, 86, 85, 85, 84, 85, 84, 84,
85, 84, 84, 83, 84, 83, 84, 82, 82, 80, 80, 79, 79, 78, 77, 77, 76, 77, 75, 76,
75, 74, 74, 73, 74, 73, 72, 72, 72, 71, 70, 70, 68, 67, 66, 64, 64, 62, 60, 60,
59, 58, 57, 56, 55, 54, 53, 52, 51, 48, 47, 45, 44, 42, 39, 38, 36, 35, 32, 30,
28, 26, 24, 21, 20, 18, 16, 14, 13, 12, 9, 6, 2, -2, -3, -4, -7, -10, -11, -11,
-12, -13, -14, -15, -16, -16, -18, -19, -20, -21, -23, -24, -24, -25, -26, -28,
-28, -29, -30, -32, -33, -34, -35, -35, -37, -39, -40, -42, -43, -44, -45, -45,
-46, -47, -47, -49, -50, -51, -52, -53, -54, -55, -55, -57, -56, -58, -58, -60,
-61, -61, -61, -61, -63, -64, -65, -65, -66, -68, -69, -70, -71, -71, -72, -73,
-74, -76, -78, -79, -81, -83, -83, -86, -86, -88, -89, -89, -90, -91, -91, -94,
-95, -95, -96, -98, -98, -98, -100, -100, -100, -101, -102, -102, -103, -102,
-103, -104, -105, -105, -106, -106, -107, -107, -108, -109, -109, -108, -109,
-110, -111, -113, -113, -114, -114, -115, -115, -115, -115, -115, -114, -114,
-113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -112, -112,
-112, -111, -110, -109, -110, -108, -108, -106, -106, -105, -103, -103, -102,
-101, -100, -99, -100, -99, -99, -97, -98, -98, -96, -96, -96, -95, -95, -94,
-92, -91, -91, -91, -90, -89, -88, -88, -89, -88, -88, -87, -88, -87, -87, -87,
-86, -86, -86, -85, -85, -86, -85, -85, -84, -84, -83, -82, -82, -81, -80, -79,
-80, -79, -78, -76, -76, -74, -73, -72, -72, -70, -70, -69, -68, -68, -67, -67,
-66, -66, -66, -65, -65, -65, -63, -63, -63, -61, -60, -59, -57, -56, -55, -54,
-52, -50, -48, -46, -45, -44, -40, -40, -38, -36, -34, -32, -31, -30, -28, -27,
-26, -24, -23, -21, -20, -19, -19, -17, -16, -15, -14, -14, -12, -11, -10, -10,
-7, -3, 0, };