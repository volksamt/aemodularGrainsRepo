#define DATA_LENGTH 512
#define DATA AKWF_1137

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 4, 3, 4, 5, 5, 5, 4, 5, 4, 4,
4, 4, 3, 3, 2, 2, 2, 2, 2, 2, 2, 1, 1, 1, 0, 0, 1, 0, 0, 0, 1, 8, 14, 17, 20,
24, 26, 28, 31, 33, 36, 37, 39, 41, 42, 44, 45, 47, 50, 51, 52, 53, 54, 56, 57,
59, 59, 60, 62, 63, 64, 64, 66, 67, 68, 68, 70, 70, 71, 72, 73, 73, 74, 75, 75,
75, 76, 77, 78, 78, 78, 79, 79, 80, 80, 81, 81, 81, 82, 82, 83, 83, 82, 83, 82,
82, 83, 84, 84, 83, 83, 83, 76, 70, 65, 61, 58, 55, 51, 48, 46, 44, 42, 40, 38,
35, 33, 33, 31, 29, 27, 26, 24, 23, 22, 20, 19, 17, 17, 16, 14, 14, 12, 11, 11,
10, 9, 9, 8, 6, 7, 4, 5, 5, 4, 3, 3, 1, 1, 2, 1, 1, 0, 1, 0, 1, -1, 1, -1, 9,
13, 19, 20, 25, 25, 31, 29, 34, 35, 38, 40, -66, -84, -77, -86, -81, -88, -83,
-89, -88, -92, -90, -94, -92, -97, -95, -99, -99, -99, -100, -102, -102, -103,
-105, -104, -106, -105, -108, -106, -110, -107, -111, -110, -113, -110, -114,
-112, -114, -113, -116, -115, -115, -116, -116, -117, -115, -120, -112, -125,
-107, -128, 2, 106, 70, 92, 76, 88, 80, 87, 81, 77, 68, 65, 60, 57, 54, 52, 49,
45, 45, 42, 40, 37, 37, 33, 33, 30, 30, 27, 26, 24, 23, 21, 20, 19, 18, 16, 16,
14, 14, 13, 12, 12, 10, 9, 8, 8, 8, 6, 6, 5, 4, 3, 4, 3, 3, 3, 2, 2, 2, 2, 1, 1,
1, 1, 0, 0, 9, 15, 18, 22, 24, 26, 29, 32, 34, 35, 38, 40, 41, 43, 45, 46, 47,
50, 51, 52, 53, 55, 55, 57, 57, 60, 60, 62, 63, 63, 64, 66, 67, 67, 68, 69, 70,
71, 71, 72, 73, 74, 75, 75, 75, 77, 77, 77, 77, 78, 79, 79, 79, 80, 81, 80, 81,
81, 81, 82, 82, 82, 82, 82, 83, 83, 83, 83, 83, 83, 83, 74, 69, 64, 61, 57, 53,
50, 49, 46, 44, 41, 39, 37, 35, 34, 32, 29, 29, 27, 25, 24, 22, 21, 20, 19, 17,
16, 15, 14, 12, 12, 11, 10, 9, 8, 7, 7, 6, 6, 5, 5, 3, 4, 1, 3, 2, 2, 0, 1, 0,
2, -3, -37, -37, -36, -37, -37, -46, -50, -54, -58, -61, -63, -66, -67, -70,
-71, -74, -75, -77, -80, -81, -83, -84, -85, -86, -89, -89, -90, -92, -94, -94,
-96, -97, -98, -99, -100, -102, -101, -102, -103, -104, -105, -107, -107, -108,
-109, -109, -110, -111, -111, -111, -111, -113, -113, -114, -113, -115, -116,
-116, -116, -116, -117, -117, -117, -117, -118, -118, -118, -119, -119, -118,
-119, -119, -119, -119, -119, -118, -109, -105, -99, -95, -92, -89, -87, -84,
-82, -79, -68, -55, -46, -37, -30, -24, -19, -14, -10, -8, -5, -2, 0, };