#define DATA_LENGTH 512
#define DATA AKWF_1177

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 4, 5, 7, 7, 8, 10, 12, 12,
14, 15, 16, 18, 18, 20, 21, 22, 23, 25, 25, 26, 28, 29, 30, 31, 32, 34, 34, 36,
36, 37, 38, 40, 41, 41, 43, 44, 45, 46, 48, 49, 50, 50, 52, 53, 53, 54, 56, 56,
58, 59, 60, 61, 61, 62, 64, 64, 65, 67, 68, 68, 70, 71, 72, 72, 73, 74, 75, 76,
77, 78, 80, 81, 82, 82, 83, 85, 85, 86, 87, 88, 90, 90, 91, 92, 93, 95, 95, 96,
97, 98, 98, 100, 100, 101, 102, 103, 104, 106, 107, 107, 110, 109, 111, 111,
113, 112, 115, 112, 119, 107, 66, 63, 58, 56, 53, 50, 49, 46, 45, 42, 41, 39,
38, 36, 35, 33, 33, 32, 30, 29, 28, 27, 27, 26, 26, 25, 25, 24, 23, 23, 23, 22,
22, 22, 22, 22, 22, 22, 21, 22, 21, 21, 22, 22, 22, 22, 22, 23, 22, 22, 24, 24,
24, 25, 25, 25, 26, 26, 27, 27, 28, 28, 29, 29, 29, 30, 30, 31, 32, 33, 33, 34,
34, 35, 36, 36, 37, 37, 38, 40, 39, 41, 40, 42, 42, 43, 44, 45, 45, 47, 48, 48,
50, 49, 51, 50, 54, 51, 56, 52, 58, 54, 60, 54, 63, 55, 66, 52, -24, 5, -12,
-17, -20, -27, -27, -34, -34, -40, -39, -46, -44, -50, -48, -54, -52, -56, -55,
-57, -58, -59, -59, -60, -60, -60, -60, -60, -60, -59, -60, -60, -60, -60, -58,
-58, -59, -57, -56, -55, -55, -54, -54, -53, -52, -52, -51, -50, -50, -49, -49,
-48, -47, -47, -46, -45, -44, -44, -43, -41, -40, -40, -39, -40, -38, -36, -37,
-36, -35, -34, -34, -34, -33, -33, -32, -30, -30, -30, -28, -28, -27, -27, -26,
-26, -25, -24, -24, -24, -22, -22, -21, -20, -20, -19, -18, -18, -17, -17, -15,
-15, -14, -13, -13, -12, -12, -10, -11, -9, -8, -8, -7, -6, -6, -5, -4, -4, -3,
-2, -2, -1, 0, 0, 2, 2, 3, 4, 3, 6, 6, 7, 8, 8, 9, 10, 11, 11, 12, 12, 13, 15,
15, 14, 17, 16, 20, 16, 24, 5, -32, -33, -40, -41, -45, -48, -50, -51, -53, -55,
-56, -60, -60, -62, -63, -65, -66, -68, -68, -70, -70, -71, -71, -74, -74, -74,
-74, -75, -76, -76, -77, -77, -77, -78, -78, -78, -79, -78, -78, -78, -79, -79,
-78, -78, -78, -77, -78, -78, -78, -77, -77, -77, -77, -76, -77, -76, -75, -75,
-74, -75, -73, -73, -73, -71, -72, -71, -70, -70, -70, -69, -68, -68, -67, -65,
-65, -65, -64, -64, -63, -62, -62, -61, -60, -59, -59, -57, -56, -56, -55, -54,
-53, -52, -52, -51, -50, -50, -48, -47, -47, -46, -45, -44, -44, -42, -41, -40,
-40, -38, -37, -36, -36, -34, -34, -32, -31, -31, -30, -28, -27, -27, -25, -24,
-23, -22, -20, -20, -18, -18, -17, -16, -14, -13, -11, -11, -10, -8, -8, -6, -5,
-4, -3, -2, 0, };