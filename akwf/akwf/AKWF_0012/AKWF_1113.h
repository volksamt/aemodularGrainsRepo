#define DATA_LENGTH 512
#define DATA AKWF_1113

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 6, 8, 10, 11, 13, 14, 16, 16,
18, 17, 19, 20, 21, 22, 24, 24, 26, 29, 30, 32, 35, 36, 38, 41, 46, 50, 53, 56,
60, 62, 65, 66, 67, 69, 69, 71, 73, 74, 76, 77, 78, 78, 78, 78, 79, 80, 80, 81,
82, 83, 84, 85, 86, 87, 89, 90, 91, 92, 95, 96, 97, 98, 100, 100, 102, 102, 103,
104, 103, 104, 106, 106, 107, 107, 108, 107, 108, 107, 108, 108, 108, 109, 110,
110, 111, 112, 112, 113, 114, 114, 114, 115, 116, 116, 116, 116, 117, 116, 117,
117, 116, 116, 116, 116, 115, 115, 115, 114, 114, 113, 113, 112, 113, 112, 113,
113, 113, 115, 114, 114, 115, 114, 113, 113, 113, 113, 114, 113, 113, 113, 111,
109, 108, 107, 106, 106, 106, 105, 103, 102, 101, 101, 100, 99, 99, 99, 98, 98,
98, 96, 95, 94, 94, 93, 91, 91, 91, 91, 90, 89, 88, 87, 86, 84, 82, 81, 79, 78,
76, 75, 73, 70, 69, 66, 64, 62, 62, 61, 59, 60, 59, 58, 58, 58, 57, 58, 58, 57,
57, 58, 56, 57, 56, 55, 55, 53, 52, 52, 51, 50, 49, 49, 47, 47, 45, 45, 44, 43,
42, 42, 41, 41, 41, 41, 41, 41, 43, 43, 42, 42, 43, 43, 41, 41, 42, 39, 39, 38,
37, 35, 32, 31, 28, 27, 24, 23, 21, 20, 19, 18, 17, 16, 15, 14, 13, 12, 11, 11,
11, 11, 10, 9, 8, 6, 5, 2, 0, -1, -4, -6, -9, -10, -12, -15, -18, -22, -25, -28,
-31, -34, -36, -39, -41, -41, -44, -45, -47, -49, -50, -51, -49, -50, -49, -49,
-49, -50, -51, -53, -54, -57, -58, -59, -62, -64, -64, -67, -69, -73, -75, -78,
-79, -81, -83, -85, -87, -88, -90, -90, -92, -93, -94, -96, -95, -96, -96, -96,
-96, -96, -97, -98, -97, -99, -99, -100, -102, -101, -102, -102, -104, -104,
-105, -105, -107, -107, -108, -108, -109, -110, -110, -110, -111, -111, -112,
-113, -113, -114, -114, -114, -114, -114, -115, -114, -115, -115, -115, -117,
-118, -119, -118, -119, -119, -119, -119, -119, -118, -119, -119, -119, -118,
-117, -116, -116, -114, -114, -113, -113, -112, -111, -111, -110, -109, -108,
-108, -107, -108, -108, -109, -109, -108, -108, -108, -110, -109, -109, -108,
-108, -108, -107, -107, -106, -105, -104, -103, -101, -100, -99, -98, -96, -96,
-94, -94, -91, -89, -87, -86, -83, -82, -81, -81, -80, -79, -78, -75, -75, -74,
-73, -73, -73, -72, -71, -72, -70, -69, -69, -67, -65, -64, -62, -61, -60, -58,
-56, -54, -53, -51, -50, -49, -49, -47, -47, -48, -48, -48, -48, -47, -47, -47,
-48, -48, -48, -48, -48, -48, -48, -48, -48, -47, -47, -45, -45, -44, -42, -40,
-39, -37, -36, -34, -34, -34, -33, -32, -30, -29, -30, -29, -30, -30, -30, -31,
-30, -31, -30, -31, -30, -29, -27, -26, -24, -23, -22, -19, -17, -15, -12, -9,
-8, -6, -3, -1, };