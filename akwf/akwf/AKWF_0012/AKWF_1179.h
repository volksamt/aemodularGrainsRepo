#define DATA_LENGTH 512
#define DATA AKWF_1179

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 15, 20, 25, 30, 35, 40, 45, 50,
54, 59, 63, 67, 70, 74, 77, 81, 83, 86, 89, 91, 92, 90, 89, 86, 86, 84, 84, 82,
80, 80, 79, 78, 77, 77, 76, 75, 76, 75, 76, 76, 76, 77, 78, 77, 79, 78, 78, 78,
78, 79, 79, 79, 79, 78, 79, 80, 79, 79, 79, 79, 79, 79, 78, 74, 71, 67, 65, 60,
58, 55, 53, 50, 46, 45, 43, 41, 39, 37, 36, 35, 33, 32, 32, 31, 31, 34, 37, 39,
40, 40, 42, 43, 43, 44, 44, 45, 44, 45, 44, 44, 43, 42, 41, 41, 39, 38, 36, 35,
33, 31, 29, 28, 26, 25, 24, 23, 21, 20, 18, 16, 17, 15, 13, 13, 11, 11, 10, 13,
14, 16, 18, 19, 21, 22, 24, 25, 26, 27, 29, 29, 29, 30, 30, 31, 30, 31, 30, 30,
28, 25, 21, 17, 13, 10, 7, 3, 0, -2, -4, -8, -10, -12, -13, -15, -16, -18, -18,
-19, -19, -20, -19, -18, -18, -18, -17, -17, -14, -14, -13, -13, -12, -12, -10,
-10, -10, -9, -8, -8, -7, -6, -7, -11, -13, -15, -18, -21, -24, -26, -29, -30,
-32, -34, -36, -38, -39, -40, -41, -41, -42, -44, -43, -44, -43, -40, -36, -33,
-30, -26, -23, -21, -19, -16, -13, -11, -9, -7, -6, -5, -4, -2, -1, -1, 0, 0, 0,
0, 1, 0, 1, 1, 1, 0, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, 1, 0, -1, 3, 5, 6, 8, 10, 11,
14, 15, 16, 17, 17, 19, 18, 19, 19, 20, 19, 19, 18, 18, 17, 14, 10, 6, 1, -3,
-8, -10, -15, -19, -22, -26, -29, -31, -35, -36, -39, -42, -43, -45, -46, -48,
-49, -51, -52, -53, -55, -56, -57, -58, -59, -59, -61, -62, -63, -64, -66, -65,
-66, -67, -67, -70, -70, -72, -76, -79, -84, -88, -90, -93, -96, -99, -102,
-104, -107, -109, -111, -113, -115, -116, -117, -118, -118, -118, -119, -117,
-114, -110, -104, -100, -95, -90, -86, -81, -76, -72, -68, -64, -61, -56, -53,
-50, -47, -45, -43, -41, -38, -37, -34, -32, -30, -30, -27, -27, -25, -24, -22,
-20, -19, -18, -17, -15, -14, -13, -12, -12, -10, -8, -4, -1, 3, 7, 9, 12, 15,
19, 21, 23, 25, 28, 30, 31, 33, 35, 36, 37, 38, 38, 38, 37, 34, 30, 27, 24, 22,
18, 16, 12, 10, 8, 5, 4, 2, 0, -2, -4, -4, -5, -7, -7, -7, -8, -8, -6, -7, -6,
-6, -6, -5, -5, -5, -5, -5, -5, -4, -4, -4, -3, -4, -3, -3, -3, -8, -11, -15,
-17, -20, -23, -25, -28, -30, -31, -34, -36, -38, -39, -41, -41, -42, -43, -43,
-44, -44, -44, -39, -37, -34, -30, -27, -24, -22, -19, -17, -14, -12, -10, -8,
-6, -6, -4, -4, -2, -1, -1, -1, 0, -1, -1, -1, 0, 0, 0, 0, -1, 0, -1, -1, 0, 0,
0, 0, 0, 0, 0, 0, };