#define DATA_LENGTH 512
#define DATA AKWF_1128

const PROGMEM int8_t DATA[DATA_LENGTH] = {63, 76, 70, 74, 71, 73, 72, 75, 71,
73, 71, 73, 71, 73, 72, 73, 72, 72, 72, 72, 73, 72, 73, 72, 72, 72, 73, 73, 72,
72, 73, 72, 73, 72, 73, 72, 73, 72, 73, 73, 72, 72, 73, 72, 72, 73, 72, 72, 72,
72, 73, 73, 72, 72, 70, 80, 90, 86, 89, 86, 88, 88, 89, 87, 89, 105, 103, 104,
103, 103, 104, 104, 104, 103, 104, 103, 104, 103, 104, 104, 104, 102, 106, 121,
118, 119, 119, 119, 119, 118, 119, 119, 119, 120, 118, 119, 118, 119, 118, 120,
119, 119, 119, 118, 119, 119, 120, 118, 120, 118, 120, 116, 121, 116, 121, 116,
121, 116, 122, 115, 122, 115, 122, 116, 122, 115, 122, 112, -97, -115, -104,
-114, -104, -113, -105, -112, -105, -112, -106, -111, -107, -111, -107, -111,
-108, -109, -109, -110, -109, -109, -109, -109, -109, -108, -110, -109, -110,
-108, -110, -108, -109, -109, -109, -109, -110, -109, -109, -109, -109, -109,
-108, -109, -109, -109, -109, -109, -109, -109, -108, -109, -109, -109, -108,
-108, -109, -108, -109, -108, -108, -108, -109, -108, -108, -108, -108, -109,
-109, -109, -109, -108, -109, -108, -109, -107, -93, -93, -93, -92, -92, -92,
-93, -92, -93, -93, -93, -92, -93, -93, -92, -93, -93, -92, -92, -92, -93, -92,
-93, -89, -75, -77, -77, -77, -76, -77, -76, -77, -76, -77, -75, -59, -62, -60,
-62, -60, -62, -59, -62, -59, -63, -59, -63, -58, -63, -58, -64, -53, 56, 58,
55, 59, 55, 58, 55, 59, 56, 58, 55, 57, 56, 57, 56, 57, 55, 58, 57, 57, 56, 57,
57, 57, 57, 57, 57, 57, 57, 56, 57, 56, 57, 56, 56, 57, 58, 57, 57, 56, 57, 57,
57, 57, 56, 56, 57, 56, 56, 56, 57, 57, 56, 57, 57, 57, 57, 57, 57, 56, 57, 57,
56, 57, 57, 56, 56, 57, 57, 56, 56, 56, 56, 57, 57, 57, 56, 56, 57, 56, 56, 57,
56, 56, 56, 56, 56, 57, 57, 56, 56, 57, 56, 57, 55, 57, 56, 57, 56, 57, 57, 57,
56, 56, 55, 57, 56, 57, 56, 56, 57, 56, 57, 55, 57, 55, 57, 55, 58, 55, 58, 54,
59, 54, 59, 53, 61, 46, -48, -45, -45, -47, -45, -47, -45, -47, -44, -47, -45,
-47, -45, -47, -45, -46, -45, -46, -45, -46, -46, -46, -45, -45, -46, -45, -46,
-46, -46, -46, -46, -45, -46, -46, -45, -46, -46, -45, -45, -46, -46, -46, -45,
-45, -46, -46, -45, -46, -45, -46, -46, -47, -44, -52, -63, -61, -62, -61, -61,
-60, -62, -61, -61, -61, -61, -62, -61, -62, -61, -61, -61, -62, -61, -61, -61,
-61, -62, -62, -61, -61, -61, -62, -61, -61, -61, -61, -61, -61, -62, -60, -61,
-61, -61, -61, -60, -60, -61, -61, -60, -61, -61, -60, -60, -62, -61, -61, -61,
-61, -61, -61, -60, -60, -61, -61, -61, -61, -61, -60, -62, -60, -62, -59, -62,
-59, -62, -58, -65, -51, };