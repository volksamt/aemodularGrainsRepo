#define DATA_LENGTH 512
#define DATA AKWF_1140

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 2, 5, 5, 6, 6, 8, 9, 10, 11,
12, 12, 14, 14, 15, 16, 16, 18, 19, 20, 21, 21, 22, 23, 23, 24, 24, 25, 26, 26,
26, 27, 27, 29, 29, 29, 29, 30, 30, 30, 30, 31, 31, 31, 31, 31, 31, 32, 32, 32,
32, 32, 31, 31, 32, 31, 31, 31, 31, 31, 31, 30, 31, 29, 29, 29, 29, 28, 28, 28,
27, 27, 26, 26, 26, 27, 28, 29, 29, 32, 33, 33, 34, 35, 36, 37, 38, 40, 40, 41,
42, 43, 44, 46, 47, 47, 49, 50, 51, 52, 53, 54, 56, 56, 59, 59, 61, 61, 62, 63,
65, 65, 66, 68, 70, 70, 71, 72, 74, 74, 76, 77, 78, 79, 80, 81, 83, 84, 84, 85,
86, 87, 87, 86, 87, 87, 87, 86, 86, 86, 87, 87, 86, 86, 86, 86, 86, 87, 85, 86,
86, 86, 85, 85, 85, 85, 84, 84, 83, 83, 83, 82, 83, 83, 82, 83, 81, 81, 81, 81,
80, 80, 80, 79, 79, 78, 76, 77, 76, 75, 75, 74, 75, 74, 73, 72, 72, 71, 71, 70,
70, 70, 69, 69, 67, 67, 66, 65, 65, 64, 64, 63, 63, 61, 60, 61, 59, 59, 57, 57,
57, 55, 55, 55, 53, 52, 52, 51, 50, 49, 49, 47, 47, 47, 45, 44, 43, 42, 41, 40,
40, 39, 39, 37, 36, 36, 35, 34, 33, 32, 31, 30, 30, 29, 27, 26, 25, 25, 23, 22,
22, 21, 20, 19, 18, 16, 17, 15, 14, 13, 13, 12, 10, 9, 9, 8, 7, 6, 4, 3, 3, 1,
0, 0, -1, -2, -4, -4, -6, -7, -7, -10, -10, -12, -13, -15, -16, -17, -19, -15,
-15, -16, -18, -18, -18, -19, -20, -20, -20, -20, -22, -27, -27, -28, -29, -29,
-29, -29, -29, -29, -30, -30, -30, -30, -30, -31, -30, -30, -30, -30, -30, -30,
-31, -29, -30, -27, -38, -48, -47, -50, -50, -52, -54, -55, -57, -57, -52, -54,
-55, -56, -57, -59, -60, -60, -63, -64, -65, -66, -68, -69, -71, -71, -54, -55,
-59, -60, -64, -66, -70, -72, -76, -79, -81, -84, -87, -90, -92, -93, -93, -95,
-95, -97, -98, -100, -101, -102, -102, -104, -105, -106, -107, -108, -109, -111,
-111, -112, -114, -115, -116, -116, -117, -118, -118, -118, -117, -116, -115,
-114, -113, -113, -111, -110, -109, -109, -107, -106, -104, -103, -103, -102,
-100, -99, -98, -96, -95, -93, -93, -92, -91, -89, -88, -86, -85, -84, -83, -81,
-81, -78, -78, -76, -74, -73, -72, -71, -69, -68, -67, -66, -64, -63, -61, -61,
-59, -57, -56, -55, -53, -52, -51, -50, -49, -49, -48, -47, -46, -46, -44, -44,
-43, -43, -42, -41, -40, -40, -39, -39, -37, -37, -36, -36, -35, -35, -33, -32,
-31, -31, -30, -29, -28, -28, -27, -26, -24, -25, -22, -22, -21, -21, -20, -18,
-17, -16, -17, -15, -14, -14, -12, -12, -11, -10, -9, -8, -7, -6, -5, -3, -3,
-3, -1, 0, };