#define DATA_LENGTH 512
#define DATA AKWF_1143

const PROGMEM int8_t DATA[DATA_LENGTH] = {17, 69, 87, 84, 84, 88, 94, 98, 101,
102, 103, 106, 107, 109, 110, 111, 112, 113, 114, 114, 115, 116, 116, 116, 118,
118, 118, 118, 118, 118, 119, 118, 118, 119, 118, 119, 119, 119, 119, 118, 119,
118, 118, 119, 119, 118, 119, 119, 118, 119, 118, 118, 118, 118, 118, 118, 117,
117, 117, 117, 116, 116, 116, 115, 115, 115, 115, 115, 115, 115, 114, 115, 113,
113, 114, 113, 112, 113, 112, 112, 112, 112, 111, 110, 111, 110, 111, 111, 110,
109, 109, 109, 109, 109, 108, 108, 108, 108, 107, 107, 107, 106, 106, 106, 106,
106, 106, 105, 104, 104, 104, 104, 103, 104, 103, 102, 102, 102, 102, 101, 101,
100, 100, 100, 100, 100, 100, 99, 99, 98, 98, 97, 98, 97, 97, 97, 97, 97, 96,
96, 95, 95, 95, 95, 94, 94, 94, 93, 93, 93, 93, 92, 91, 92, 91, 91, 91, 90, 90,
91, 90, 89, 89, 89, 89, 88, 88, 88, 87, 87, 87, 87, 86, 85, 86, 85, 84, 84, 84,
84, 83, 83, 82, 83, 83, 82, 82, 82, 81, 80, 80, 79, 80, 80, 79, 78, 78, 77, 78,
77, 76, 77, 76, 76, 76, 75, 75, 74, 74, 74, 73, 72, 72, 72, 71, 71, 70, 70, 70,
69, 68, 68, 67, 67, 67, 66, 65, 65, 64, 64, 64, 62, 61, 61, 61, 59, 58, 57, 56,
56, 55, 53, 52, 50, 49, 47, 45, 44, 42, 40, 37, 34, 29, 22, 8, -24, -66, -95,
-103, -101, -101, -104, -107, -109, -110, -111, -113, -113, -114, -114, -116,
-115, -117, -117, -117, -117, -118, -118, -118, -118, -118, -118, -118, -119,
-119, -118, -119, -118, -118, -119, -118, -119, -118, -118, -117, -118, -117,
-117, -117, -117, -117, -116, -117, -117, -116, -115, -115, -115, -115, -116,
-115, -115, -114, -114, -114, -114, -114, -114, -113, -113, -113, -112, -112,
-113, -112, -111, -112, -111, -111, -110, -110, -111, -110, -109, -109, -109,
-109, -108, -107, -108, -108, -107, -108, -107, -106, -107, -106, -106, -106,
-106, -105, -104, -104, -104, -103, -103, -103, -103, -102, -102, -102, -102,
-102, -101, -101, -100, -100, -100, -100, -100, -99, -99, -99, -98, -98, -98,
-98, -98, -97, -96, -96, -96, -96, -95, -95, -95, -95, -95, -94, -94, -94, -93,
-92, -92, -93, -92, -92, -91, -92, -90, -90, -91, -90, -90, -90, -89, -90, -89,
-89, -88, -89, -88, -87, -87, -87, -87, -87, -86, -86, -85, -85, -85, -84, -84,
-83, -84, -84, -83, -83, -83, -82, -82, -82, -82, -82, -81, -80, -79, -80, -80,
-79, -78, -79, -79, -79, -78, -78, -77, -77, -77, -76, -77, -76, -76, -75, -75,
-75, -74, -74, -74, -73, -73, -72, -73, -72, -72, -72, -71, -71, -71, -70, -70,
-69, -69, -68, -68, -68, -68, -67, -67, -66, -67, -66, -65, -64, -65, -64, -64,
-64, -63, -63, -63, -61, -61, -61, -61, -59, -60, -59, -58, -58, -56, -57, -56,
-55, -53, -54, -51, -51, -47, -44, -28, };