#define DATA_LENGTH 512
#define DATA AKWF_1120

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 3, 4, 4, 5, 4, 6, 7, 6, 8, 8,
9, 9, 10, 10, 12, 12, 13, 13, 14, 15, 15, 15, 16, 17, 18, 19, 19, 19, 21, 21,
22, 23, 23, 24, 25, 26, 27, 28, 29, 31, 33, 33, 36, 37, 38, 41, 42, 44, 47, 49,
50, 53, 56, 58, 60, 62, 65, 68, 70, 71, 74, 76, 78, 80, 82, 84, 86, 87, 88, 90,
91, 93, 93, 95, 96, 97, 99, 100, 101, 102, 103, 104, 105, 106, 106, 106, 107,
108, 109, 109, 111, 111, 112, 112, 113, 114, 114, 116, 116, 116, 116, 117, 117,
117, 118, 118, 119, 119, 119, 120, 119, 119, 119, 119, 119, 118, 119, 118, 119,
117, 118, 118, 117, 117, 116, 115, 115, 115, 113, 113, 113, 112, 110, 111, 110,
108, 107, 106, 104, 103, 102, 100, 99, 98, 97, 95, 93, 92, 89, 87, 86, 84, 81,
79, 78, 76, 74, 72, 70, 68, 66, 65, 62, 61, 60, 58, 58, 56, 55, 55, 54, 54, 51,
52, 51, 49, 48, 47, 46, 45, 44, 44, 44, 43, 42, 41, 39, 39, 39, 37, 36, 36, 35,
33, 33, 32, 31, 31, 30, 29, 28, 27, 26, 25, 24, 23, 23, 23, 22, 21, 20, 20, 20,
19, 18, 18, 16, 17, 16, 15, 15, 14, 14, 12, 13, 12, 11, 10, 11, 11, 10, 9, 9, 8,
7, 7, 7, 6, 6, 5, 3, 4, 3, 2, 1, 1, 1, 0, 0, -1, -1, -2, -3, -3, -4, -4, -5, -6,
-6, -8, -8, -8, -8, -10, -11, -11, -12, -12, -13, -14, -14, -15, -16, -17, -17,
-17, -18, -19, -20, -21, -21, -22, -23, -23, -25, -24, -25, -26, -27, -27, -28,
-28, -29, -30, -31, -31, -32, -33, -33, -34, -34, -35, -36, -36, -36, -37, -38,
-39, -38, -40, -40, -41, -41, -42, -43, -43, -43, -44, -45, -44, -45, -46, -47,
-46, -46, -47, -48, -50, -51, -53, -55, -58, -62, -66, -68, -71, -73, -75, -77,
-78, -80, -83, -85, -88, -90, -92, -95, -96, -98, -99, -101, -102, -102, -103,
-104, -104, -105, -105, -107, -107, -107, -109, -109, -108, -108, -109, -108,
-109, -108, -108, -109, -109, -108, -109, -109, -109, -110, -110, -109, -110,
-109, -109, -108, -108, -108, -107, -107, -107, -107, -106, -106, -106, -106,
-106, -104, -104, -103, -103, -103, -102, -102, -100, -100, -99, -98, -97, -96,
-96, -94, -94, -92, -91, -91, -90, -90, -88, -87, -85, -85, -84, -83, -82, -82,
-80, -80, -79, -77, -77, -75, -75, -74, -72, -72, -71, -69, -67, -66, -65, -64,
-63, -62, -61, -60, -60, -58, -57, -56, -55, -53, -52, -51, -50, -49, -48, -48,
-47, -46, -45, -44, -43, -42, -41, -39, -39, -38, -37, -36, -35, -35, -33, -32,
-31, -30, -29, -29, -27, -25, -26, -24, -22, -21, -21, -20, -20, -19, -18, -16,
-15, -15, -14, -13, -12, -12, -11, -10, -9, -8, -7, -7, -6, -6, -5, -4, -4, -3,
-2, -1, 0, 0, };