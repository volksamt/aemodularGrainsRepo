#define DATA_LENGTH 512
#define DATA AKWF_1106

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 10, 13, 16, 19, 23, 27, 30, 33,
37, 40, 43, 47, 50, 54, 57, 61, 63, 66, 70, 73, 75, 79, 82, 85, 88, 90, 92, 95,
98, 100, 101, 104, 106, 106, 109, 111, 112, 113, 114, 116, 116, 117, 117, 118,
119, 119, 119, 119, 118, 118, 117, 117, 117, 116, 115, 114, 113, 113, 111, 111,
110, 108, 107, 106, 104, 103, 101, 99, 99, 96, 93, 92, 90, 87, 84, 82, 80, 77,
75, 71, 68, 66, 62, 59, 56, 53, 50, 46, 44, 41, 37, 34, 33, 29, 27, 24, 21, 19,
17, 14, 13, 11, 9, 7, 5, 5, 2, 1, -1, -1, -3, -4, -4, -5, -6, -6, -7, -6, -6,
-5, -4, -4, -3, -3, -1, -1, 1, 1, 3, 3, 5, 5, 5, 7, 7, 7, 8, 8, 9, 9, 9, 10, 9,
9, 10, 8, 8, 7, 7, 5, 4, 2, 0, -2, -3, -5, -7, -8, -10, -11, -11, -11, -11, -10,
-9, -7, -7, -7, -8, -8, -11, -12, -13, -15, -16, -17, -17, -17, -16, -15, -14,
-12, -10, -9, -7, -5, -3, -1, 1, 4, 8, 11, 14, 18, 22, 26, 27, 30, 32, 34, 34,
35, 36, 37, 38, 40, 42, 44, 47, 48, 49, 51, 51, 52, 52, 50, 49, 48, 45, 43, 40,
38, 34, 32, 28, 25, 21, 18, 13, 10, 6, 3, -2, -4, -8, -13, -16, -19, -23, -27,
-30, -33, -37, -41, -43, -45, -49, -52, -55, -57, -60, -62, -64, -67, -70, -70,
-73, -75, -78, -78, -80, -82, -83, -84, -85, -86, -88, -90, -91, -92, -93, -94,
-95, -95, -96, -98, -98, -100, -99, -101, -102, -103, -104, -105, -106, -107,
-108, -109, -109, -110, -111, -111, -111, -112, -111, -113, -112, -112, -112,
-113, -112, -112, -112, -111, -110, -109, -109, -107, -107, -105, -103, -102,
-99, -97, -94, -92, -89, -86, -82, -78, -75, -71, -68, -63, -60, -55, -52, -47,
-43, -39, -34, -29, -25, -21, -17, -12, -8, -5, 0, 3, 7, 10, 14, 17, 20, 23, 24,
28, 30, 31, 33, 35, 36, 38, 40, 40, 42, 42, 44, 44, 45, 45, 45, 45, 45, 45, 45,
45, 44, 43, 44, 42, 43, 41, 41, 40, 40, 39, 39, 38, 37, 37, 36, 36, 37, 36, 37,
37, 37, 37, 39, 41, 41, 42, 42, 44, 45, 45, 46, 45, 44, 44, 43, 40, 38, 36, 34,
32, 31, 30, 29, 29, 28, 29, 28, 28, 28, 28, 27, 26, 25, 23, 21, 20, 17, 15, 13,
9, 7, 5, 2, 0, -2, -5, -9, -11, -14, -16, -20, -23, -28, -32, -36, -39, -43,
-46, -50, -53, -56, -58, -59, -61, -62, -63, -63, -64, -63, -63, -63, -64, -65,
-65, -65, -68, -69, -70, -72, -72, -73, -74, -74, -76, -76, -76, -76, -77, -77,
-77, -77, -76, -76, -75, -75, -74, -73, -72, -70, -69, -66, -65, -63, -61, -59,
-57, -54, -52, -49, -46, -42, -39, -37, -33, -29, -25, -21, -16, -13, -10, -6,
-2, };