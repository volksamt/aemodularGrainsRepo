#define DATA_LENGTH 512
#define DATA AKWF_1186

const PROGMEM int8_t DATA[DATA_LENGTH] = {97, 115, 107, 113, 106, 111, 107, 110,
105, 109, 104, 107, 104, 106, 103, 105, 102, 104, 102, 102, 101, 101, 102, 100,
101, 99, 99, 99, 98, 97, 97, 97, 97, 96, 96, 95, 94, 94, 93, 93, 92, 93, 92, 92,
90, 90, 90, 90, 89, 89, 89, 87, 88, 87, 86, 86, 85, 85, 84, 84, 84, 83, 82, 82,
82, 81, 81, 80, 80, 80, 79, 79, 79, 78, 78, 77, 78, 77, 76, 76, 75, 74, 74, 74,
72, 73, 73, 72, 71, 71, 70, 70, 69, 69, 68, 68, 68, 68, 67, 66, 66, 66, 66, 65,
64, 64, 64, 63, 62, 63, 62, 61, 60, 60, 60, 59, 59, 58, 58, 58, 56, 57, 56, 55,
55, 55, 54, 54, 54, 53, 52, 51, 51, 51, 50, 49, 49, 50, 49, 48, 49, 48, 47, 46,
47, 45, 45, 45, 44, 44, 44, 43, 42, 42, 41, 40, 41, 40, 41, 40, 40, 39, 38, 38,
37, 37, 36, 36, 35, 35, 35, 34, 33, 33, 33, 32, 31, 32, 31, 31, 30, 29, 29, 29,
28, 28, 27, 27, 26, 26, 26, 25, 24, 24, 24, 23, 23, 23, 23, 20, 22, 21, 20, 20,
19, 18, 18, 18, 17, 17, 17, 16, 16, 15, 15, 14, 14, 13, 12, 13, 13, 12, 11, 10,
11, 10, 9, 9, 8, 8, 8, 6, 7, 6, 5, 5, 5, 4, 4, 4, 3, 2, 2, 2, 1, 1, 1, 0, -1,
-1, -2, -2, -2, -2, -4, -3, -4, -4, -5, -5, -6, -6, -6, -8, -8, -8, -9, -9, -9,
-9, -10, -11, -12, -12, -12, -12, -14, -13, -15, -15, -15, -16, -16, -16, -16,
-17, -18, -18, -19, -18, -19, -20, -20, -20, -22, -22, -22, -23, -22, -23, -24,
-24, -25, -25, -25, -26, -27, -27, -27, -29, -28, -29, -29, -30, -31, -31, -31,
-31, -32, -32, -33, -32, -35, -35, -34, -34, -35, -36, -37, -37, -38, -37, -39,
-39, -39, -40, -40, -40, -41, -41, -42, -42, -43, -44, -43, -44, -44, -44, -46,
-46, -45, -46, -47, -48, -47, -49, -50, -50, -50, -50, -51, -50, -52, -53, -52,
-53, -54, -54, -55, -55, -55, -56, -57, -57, -57, -58, -58, -58, -59, -59, -59,
-60, -61, -61, -62, -62, -62, -63, -63, -63, -64, -65, -66, -66, -67, -67, -68,
-67, -68, -68, -69, -69, -69, -70, -70, -71, -72, -72, -73, -73, -73, -74, -73,
-75, -75, -75, -76, -76, -77, -77, -78, -78, -78, -79, -79, -80, -80, -82, -80,
-81, -82, -82, -83, -84, -84, -84, -85, -85, -85, -86, -87, -87, -88, -88, -88,
-89, -89, -89, -91, -91, -91, -92, -92, -92, -93, -93, -94, -94, -95, -95, -96,
-97, -97, -97, -98, -98, -99, -99, -100, -100, -101, -101, -100, -102, -103,
-102, -103, -104, -104, -104, -105, -105, -104, -106, -105, -107, -106, -106,
-106, -107, -106, -107, -107, -108, -108, -108, -109, -107, -109, -108, -110,
-107, -111, -108, -111, -107, -113, -108, -115, -106, -118, -100, };