#define DATA_LENGTH 512
#define DATA AKWF_1194

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 5, 6, 7, 8, 9, 12, 13, 14,
16, 18, 19, 21, 22, 24, 25, 27, 30, 30, 32, 33, 34, 36, 38, 40, 42, 42, 44, 46,
47, 49, 50, 52, 52, 54, 55, 58, 58, 60, 61, 61, 63, 65, 65, 67, 69, 69, 70, 71,
73, 73, 75, 75, 76, 78, 78, 79, 80, 81, 82, 82, 83, 84, 86, 87, 88, 88, 89, 89,
90, 90, 92, 93, 93, 94, 95, 96, 96, 97, 98, 99, 100, 100, 101, 102, 102, 104,
104, 106, 106, 107, 108, 108, 110, 111, 111, 112, 113, 115, 116, 116, 118, 118,
118, 115, 113, 113, 112, 109, 108, 106, 105, 104, 102, 100, 99, 96, 95, 94, 91,
90, 87, 85, 85, 82, 81, 78, 75, 73, 72, 69, 68, 65, 63, 62, 59, 57, 54, 53, 49,
47, 45, 42, 40, 38, 35, 33, 31, 29, 25, 23, 21, 17, 15, 13, 11, 8, 6, 4, 1, -2,
-4, -7, -9, -13, -15, -17, -19, -14, -12, -7, -5, 0, 3, 7, 10, 14, 17, 21, 24,
28, 32, 35, 39, 43, 46, 44, 44, 43, 43, 41, 41, 41, 41, 39, 38, 39, 38, 37, 36,
36, 35, 35, 34, 33, 32, 31, 31, 31, 29, 29, 29, 28, 27, 27, 26, 26, 25, 24, 23,
24, 22, 22, 22, 21, 20, 19, 20, 18, 18, 18, 17, 17, 16, 15, 15, 14, 14, 13, 13,
13, 12, 11, 10, 10, 9, 9, 9, 7, 7, 7, 6, 5, 5, 4, 3, 2, 1, 0, -1, -2, -3, -3,
-4, -5, -7, -7, -8, -9, -10, -11, -13, -13, -15, -16, -16, -18, -19, -20, -22,
-22, -22, -24, -26, -26, -27, -28, -29, -30, -31, -31, -32, -33, -33, -35, -35,
-37, -38, -37, -38, -39, -40, -40, -40, -41, -42, -42, -43, -43, -44, -44, -45,
-45, -46, -46, -47, -47, -47, -48, -48, -48, -48, -48, -48, -50, -48, -50, -50,
-50, -50, -51, -51, -51, -52, -52, -52, -52, -52, -53, -54, -53, -53, -54, -54,
-55, -55, -56, -55, -56, -56, -56, -57, -58, -58, -58, -59, -59, -60, -60, -62,
-61, -62, -62, -63, -63, -63, -64, -64, -65, -65, -65, -65, -66, -66, -66, -66,
-67, -67, -66, -66, -66, -66, -66, -67, -65, -66, -66, -65, -65, -65, -64, -64,
-64, -64, -63, -62, -63, -62, -61, -61, -63, -65, -67, -69, -71, -74, -76, -77,
-79, -82, -83, -85, -86, -90, -91, -94, -95, -97, -99, -101, -103, -106, -107,
-109, -111, -114, -115, -117, -119, -115, -112, -109, -106, -102, -99, -96, -93,
-89, -87, -83, -80, -77, -73, -70, -66, -64, -60, -57, -54, -50, -48, -44, -41,
-37, -34, -31, -27, -45, -58, -54, -55, -53, -53, -52, -50, -48, -48, -47, -45,
-43, -43, -42, -41, -40, -39, -38, -36, -36, -34, -34, -32, -31, -29, -29, -28,
-26, -26, -24, -23, -22, -20, -19, -19, -18, -17, -16, -15, -13, -13, -12, -11,
-10, -9, -7, -6, -6, -4, -2, -2, -1, };