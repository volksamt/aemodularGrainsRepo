#define DATA_LENGTH 512
#define DATA AKWF_1141

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12,
13, 14, 15, 17, 17, 17, 19, 20, 20, 22, 23, 24, 24, 26, 27, 27, 28, 28, 30, 30,
31, 32, 32, 33, 34, 35, 36, 37, 37, 37, 38, 39, 40, 41, 41, 41, 42, 42, 43, 43,
44, 44, 44, 45, 46, 45, 46, 47, 46, 47, 47, 47, 47, 47, 48, 48, 48, 48, 49, 49,
48, 49, 49, 49, 48, 49, 49, 48, 48, 48, 49, 48, 49, 48, 48, 48, 48, 48, 47, 48,
47, 48, 48, 48, 48, 48, 47, 47, 47, 48, 47, 47, 47, 48, 48, 48, 48, 48, 48, 48,
48, 48, 48, 49, 48, 48, 49, 49, 49, 50, 50, 51, 50, 51, 51, 52, 52, 52, 54, 54,
53, 54, 54, 55, 55, 55, 56, 56, 57, 58, 57, 59, 58, 60, 60, 60, 61, 60, 62, 61,
62, 64, 63, 64, 65, 65, 65, 65, 67, 66, 67, 68, 67, 68, 69, 68, 70, 70, 71, 71,
72, 72, 71, 72, 72, 73, 73, 74, 74, 73, 73, 74, 75, 74, 75, 75, 74, 76, 76, 77,
76, 76, 76, 76, 76, 76, 76, 75, 76, 76, 76, 76, 75, 74, 74, 75, 74, 74, 73, 73,
72, 72, 72, 71, 71, 70, 69, 68, 68, 67, 67, 65, 65, 64, 63, 62, 60, 60, 59, 58,
57, 56, 55, 54, 52, 51, 50, 49, 47, 46, 45, 43, 42, 41, 39, 38, 37, 36, 34, 33,
32, 31, 28, 27, 26, 25, 24, 23, 21, 19, 18, 17, 15, 14, 13, 12, 11, 10, 9, 8, 7,
6, 5, 4, 3, 2, 2, 0, -1, -1, -2, -3, -4, -4, -6, -5, -7, -7, -7, -9, -9, -9, -9,
-10, -11, -11, -12, -13, -11, -13, -13, -14, -14, -14, -14, -14, -15, -16, -16,
-16, -16, -17, -16, -18, -17, -18, -18, -18, -19, -19, -20, -19, -21, -21, -21,
-22, -22, -23, -23, -24, -24, -25, -26, -26, -27, -28, -28, -28, -31, -30, -31,
-33, -33, -35, -35, -36, -37, -39, -39, -41, -42, -43, -44, -46, -47, -48, -50,
-51, -52, -53, -55, -57, -58, -60, -61, -63, -64, -65, -68, -69, -71, -72, -74,
-76, -77, -79, -80, -82, -84, -86, -86, -89, -90, -91, -93, -95, -96, -97, -98,
-101, -101, -103, -104, -105, -107, -107, -108, -109, -110, -112, -113, -113,
-115, -115, -116, -116, -117, -117, -117, -117, -119, -118, -118, -119, -120,
-119, -119, -120, -118, -118, -118, -118, -117, -117, -117, -116, -116, -115,
-115, -114, -113, -113, -111, -110, -108, -108, -107, -105, -105, -104, -102,
-102, -100, -98, -96, -95, -94, -92, -91, -89, -88, -87, -85, -83, -82, -81,
-78, -77, -75, -73, -72, -70, -69, -67, -66, -63, -62, -60, -58, -57, -55, -53,
-52, -50, -49, -47, -46, -44, -42, -41, -39, -36, -36, -34, -33, -31, -30, -28,
-27, -26, -25, -23, -22, -20, -19, -17, -16, -14, -14, -12, -11, -9, -9, -7, -6,
-5, -4, -3, -2, 0, };