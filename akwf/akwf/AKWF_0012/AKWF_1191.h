#define DATA_LENGTH 512
#define DATA AKWF_1191

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 9, 12, 14, 16, 20, 22, 25,
27, 31, 33, 37, 39, 42, 44, 47, 49, 52, 54, 57, 60, 62, 65, 67, 69, 73, 75, 76,
79, 81, 83, 85, 87, 89, 90, 93, 94, 96, 98, 100, 101, 102, 105, 106, 107, 109,
111, 111, 112, 114, 115, 115, 116, 117, 117, 118, 118, 119, 119, 119, 119, 119,
119, 118, 118, 118, 118, 116, 117, 116, 116, 114, 114, 112, 111, 110, 109, 107,
107, 104, 103, 101, 100, 97, 96, 94, 92, 90, 88, 85, 83, 81, 78, 76, 73, 70, 68,
64, 63, 60, 57, 55, 52, 49, 47, 45, 43, 40, 38, 36, 33, 31, 29, 27, 24, 23, 21,
18, 16, 13, 11, 10, 7, 5, 2, 1, -1, -3, -5, -7, -10, -11, -13, -16, -17, -18,
-21, -22, -25, -26, -28, -30, -32, -34, -35, -37, -38, -40, -41, -43, -44, -45,
-48, -48, -50, -51, -53, -55, -55, -57, -57, -59, -60, -60, -62, -63, -64, -65,
-66, -66, -66, -67, -67, -67, -68, -68, -68, -69, -69, -69, -69, -70, -69, -70,
-70, -71, -70, -70, -70, -70, -71, -70, -71, -71, -72, -70, -70, -70, -71, -69,
-70, -70, -70, -69, -68, -68, -67, -68, -67, -68, -68, -68, -68, -66, -67, -66,
-65, -66, -66, -65, -64, -65, -64, -65, -64, -63, -63, -63, -62, -62, -60, -59,
-59, -58, -57, -55, -54, -54, -52, -50, -49, -48, -46, -44, -43, -41, -39, -37,
-36, -34, -32, -30, -28, -26, -25, -22, -21, -18, -17, -14, -12, -11, -7, -6,
-4, -2, 1, 2, 5, 7, 9, 10, 13, 14, 17, 18, 20, 22, 23, 26, 27, 28, 30, 32, 33,
34, 36, 37, 38, 39, 41, 41, 43, 43, 46, 46, 48, 48, 49, 50, 51, 52, 52, 53, 54,
54, 54, 54, 56, 55, 56, 56, 57, 56, 56, 56, 57, 55, 56, 55, 54, 54, 53, 53, 52,
52, 51, 50, 49, 48, 48, 46, 45, 45, 44, 42, 41, 38, 38, 37, 35, 34, 32, 30, 28,
27, 24, 23, 22, 19, 18, 15, 13, 12, 9, 8, 6, 5, 4, 2, 0, -1, -2, -4, -5, -7, -7,
-9, -11, -12, -13, -14, -15, -16, -17, -19, -20, -20, -21, -23, -24, -25, -25,
-27, -27, -28, -30, -29, -31, -32, -32, -33, -33, -34, -34, -35, -36, -37, -37,
-37, -39, -39, -40, -41, -41, -42, -42, -43, -43, -43, -44, -45, -45, -46, -47,
-47, -48, -48, -49, -49, -50, -50, -50, -51, -50, -50, -51, -51, -51, -50, -50,
-50, -50, -50, -51, -51, -51, -51, -51, -51, -51, -52, -51, -50, -51, -50, -51,
-51, -52, -51, -52, -52, -50, -50, -50, -51, -50, -50, -50, -49, -50, -49, -49,
-49, -48, -49, -48, -48, -48, -48, -47, -48, -47, -47, -47, -47, -46, -47, -46,
-46, -46, -45, -45, -44, -43, -42, -41, -41, -39, -38, -37, -36, -35, -33, -32,
-30, -29, -26, -24, -23, -21, -18, -16, -15, -12, -10, -8, -6, -3, -1, };