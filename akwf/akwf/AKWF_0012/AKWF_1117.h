#define DATA_LENGTH 512
#define DATA AKWF_1117

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 2, 3, 4, 5, 6, 8, 9, 11, 13,
13, 13, 14, 14, 15, 16, 18, 19, 21, 21, 23, 23, 25, 25, 27, 28, 28, 29, 30, 31,
31, 33, 34, 35, 35, 36, 37, 37, 38, 39, 40, 40, 41, 42, 43, 44, 44, 45, 46, 46,
48, 48, 49, 49, 50, 51, 51, 52, 53, 54, 53, 55, 55, 56, 57, 57, 57, 59, 59, 59,
59, 61, 61, 62, 62, 63, 63, 64, 65, 66, 65, 66, 66, 67, 67, 70, 70, 72, 72, 72,
71, 71, 72, 72, 73, 72, 74, 74, 74, 74, 74, 75, 75, 75, 77, 76, 76, 77, 77, 78,
78, 78, 79, 79, 79, 79, 79, 79, 80, 80, 81, 81, 81, 81, 82, 81, 82, 81, 82, 82,
82, 82, 83, 82, 83, 82, 82, 82, 81, 80, 81, 81, 81, 82, 82, 82, 82, 83, 82, 82,
81, 82, 82, 81, 81, 81, 80, 81, 81, 81, 80, 78, 79, 79, 78, 78, 77, 78, 76, 76,
76, 76, 75, 75, 74, 74, 73, 72, 71, 71, 71, 70, 70, 70, 69, 69, 69, 68, 67, 67,
67, 65, 65, 65, 64, 64, 63, 62, 61, 61, 60, 60, 59, 59, 58, 57, 56, 56, 55, 53,
54, 53, 52, 51, 50, 50, 50, 49, 47, 47, 46, 46, 45, 44, 43, 43, 42, 41, 41, 40,
39, 38, 38, 37, 36, 36, 35, 34, 33, 32, 32, 30, 30, 29, 29, 27, 26, 26, 25, 24,
24, 23, 21, 20, 20, 19, 18, 17, 16, 15, 14, 13, 12, 11, 10, 9, 9, 6, 6, 4, 4, 2,
2, 2, -1, -1, -2, -3, -4, -5, -7, -8, -9, -10, -11, -12, -14, -15, -15, -17,
-18, -20, -19, -21, -22, -23, -24, -26, -26, -27, -28, -29, -30, -31, -32, -33,
-33, -34, -35, -36, -37, -37, -38, -39, -39, -40, -41, -42, -42, -43, -44, -45,
-45, -45, -46, -46, -47, -48, -47, -48, -49, -49, -50, -50, -50, -50, -51, -52,
-52, -52, -53, -52, -53, -54, -54, -54, -53, -54, -55, -54, -55, -55, -55, -56,
-56, -61, -79, -101, -115, -117, -112, -97, -81, -67, -62, -62, -65, -69, -71,
-70, -69, -70, -72, -72, -74, -75, -76, -78, -80, -82, -81, -77, -72, -71, -74,
-78, -84, -90, -93, -91, -90, -90, -91, -95, -99, -104, -106, -108, -109, -111,
-113, -115, -116, -116, -117, -116, -115, -113, -111, -110, -110, -111, -111,
-113, -115, -115, -116, -118, -118, -119, -119, -118, -115, -114, -112, -111,
-111, -109, -107, -104, -102, -100, -101, -102, -103, -103, -102, -101, -100,
-99, -97, -96, -96, -94, -93, -93, -92, -92, -91, -89, -87, -85, -83, -81, -79,
-78, -77, -75, -72, -70, -68, -67, -66, -64, -65, -64, -64, -63, -62, -61, -58,
-54, -52, -49, -47, -47, -46, -44, -44, -43, -42, -42, -41, -40, -37, -35, -31,
-29, -28, -25, -24, -23, -21, -21, -19, -18, -16, -15, -13, -12, -11, -10, -9,
-7, -7, -6, -4, -3, -2, 0, };