#define DATA_LENGTH 512
#define DATA AKWF_1134

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 1,
0, 1, 1, 1, 1, 2, 1, 2, 2, 1, 2, 2, 1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 3, 2, 3, 3,
3, 3, 3, 4, 3, 11, 19, 21, 25, 28, 31, 34, 36, 37, 40, 41, 44, 46, 48, 50, 51,
53, 55, 56, 58, 59, 60, 62, 64, 64, 66, 67, 68, 71, 71, 73, 74, 75, 77, 77, 78,
79, 80, 82, 83, 83, 85, 85, 86, 87, 88, 90, 89, 91, 92, 93, 94, 95, 95, 96, 97,
98, 99, 99, 101, 101, 100, 101, 103, 104, 104, 105, 105, 107, 107, 107, 109,
109, 110, 110, 111, 112, 111, 113, 113, 114, 114, 115, 115, 116, 116, 118, 118,
118, 119, 118, 118, 116, 116, 114, 115, 113, 112, 110, 111, 109, 108, 107, 107,
104, 105, 103, 103, 102, 100, 99, 98, 98, 96, 96, 93, 95, 91, 94, 88, 91, 86,
90, 82, 89, 79, 88, 76, 88, 64, -101, -100, -95, -97, -91, -95, -88, -91, -85,
-88, -82, -85, -80, -82, -78, -80, -75, -76, -73, -74, -71, -71, -70, -68, -67,
-66, -65, -64, -63, -61, -60, -59, -58, -57, -58, -55, -55, -54, -53, -52, -51,
-51, -50, -49, -49, -48, -47, -46, -46, -45, -44, -44, -43, -42, -41, -42, -41,
-40, -39, -39, -39, -39, -38, -37, -36, -37, -35, -35, -35, -34, -34, -34, -33,
-33, -33, -32, -32, -32, -31, -31, -31, -30, -31, -30, -30, -30, -30, -29, -28,
-29, -28, -28, -27, -29, -28, -28, -28, -28, -27, -26, -27, -26, -27, -27, -26,
-26, -26, -26, -26, -25, -25, -25, -25, -25, -25, -25, -24, -25, -24, -24, -24,
-24, -24, -24, -25, -23, -33, -38, -41, -45, -47, -49, -50, -52, -54, -55, -55,
-57, -57, -58, -59, -60, -61, -61, -62, -62, -62, -62, -63, -63, -63, -63, -62,
-62, -62, -62, -62, -62, -62, -62, -61, -62, -62, -62, -61, -60, -61, -60, -59,
-59, -59, -58, -58, -57, -57, -57, -56, -56, -55, -55, -54, -53, -53, -52, -52,
-52, -51, -50, -50, -49, -49, -49, -48, -48, -47, -47, -46, -44, -44, -43, -42,
-43, -42, -42, -41, -39, -40, -39, -39, -38, -38, -37, -36, -36, -35, -34, -33,
-32, -31, -31, -31, -29, -28, -27, -27, -26, -26, -24, -23, -23, -22, -21, -21,
-21, -21, -19, -19, -18, -18, -17, -16, -16, -16, -15, -14, -15, -14, -12, -12,
-12, -12, -11, -11, -11, -10, -10, -10, -8, -9, -8, -8, -8, -8, -7, -7, -6, -7,
-6, -6, -6, -5, -5, -4, -4, -4, -5, -4, -3, -4, -3, -3, -3, -3, -3, -3, -3, -2,
-2, -2, -2, -3, -3, -1, -2, -2, -2, -2, -1, -1, -2, -2, -1, -2, -1, -1, -2, -1,
-1, -1, -1, -2, -1, -1, -1, -1, -1, -2, -1, -1, -1, 0, -1, -1, -1, -1, -1, 0, 0,
-1, 0, -1, 0, 0, 0, 0, 1, 0, };