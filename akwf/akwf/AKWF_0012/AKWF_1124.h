#define DATA_LENGTH 512
#define DATA AKWF_1124

const PROGMEM int8_t DATA[DATA_LENGTH] = {22, 29, 18, 52, 77, 64, 66, 60, 59,
57, 54, 52, 51, 50, 48, 47, 46, 45, 43, 43, 42, 41, 40, 39, 41, 53, 50, 51, 49,
49, 48, 48, 47, 46, 46, 46, 46, 45, 45, 44, 44, 45, 44, 43, 43, 43, 43, 43, 43,
43, 42, 42, 42, 42, 41, 42, 41, 42, 42, 42, 42, 42, 42, 42, 42, 42, 42, 42, 41,
41, 42, 42, 42, 42, 41, 42, 41, 42, 41, 42, 41, 41, 41, 41, 43, 36, 32, 34, 33,
33, 33, 33, 33, 32, 33, 34, 33, 33, 34, 33, 33, 34, 33, 33, 33, 33, 24, 26, 24,
24, 24, 25, 25, 24, 25, 25, 26, 24, 26, 21, 16, 18, 16, 17, 17, 17, 17, 17, 16,
16, 18, 17, 16, 16, 17, 17, 18, 16, 17, 16, 8, 8, 9, 8, 8, 7, 9, 9, 9, 8, 8, 7,
8, 8, 9, 8, 8, 9, 8, 9, 4, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, -1, 1, -1, 1, -1,
1, -1, 1, -1, 1, -2, 1, -1, 2, -1, 0, 0, -1, 5, -102, -126, -114, -123, -116,
-122, -116, -122, -116, -121, -117, -121, -117, -121, -117, -120, -117, -119,
-118, -119, -119, -118, -120, -78, -69, -72, -70, -71, -71, -70, -71, -71, -72,
-70, -73, -68, -76, -54, -17, -26, -21, -23, -22, -23, -22, -23, -22, -24, -21,
-27, -2, 21, 14, 18, 15, 18, 16, 18, 17, 17, 17, 17, 17, 17, 17, 24, 25, 23, 30,
35, 33, 34, 33, 33, 34, 34, 33, 34, 33, 33, 33, 34, 34, 34, 33, 34, 32, 34, 33,
35, 43, 41, 41, 41, 42, 42, 42, 41, 42, 41, 42, 42, 42, 41, 42, 41, 41, 41, 41,
41, 41, 41, 42, 41, 41, 41, 41, 42, 41, 41, 41, 41, 42, 41, 41, 42, 42, 42, 42,
42, 42, 41, 42, 41, 41, 41, 42, 41, 42, 42, 41, 41, 42, 41, 42, 41, 42, 41, 41,
42, 34, 32, 34, 32, 34, 33, 34, 33, 33, 33, 33, 33, 33, 33, 32, 33, 33, 33, 32,
34, 30, 24, 25, 25, 24, 25, 25, 25, 25, 25, 24, 25, 24, 26, 19, 15, 17, 16, 17,
16, 16, 17, 16, 16, 16, 16, 16, 17, 16, 16, 16, 16, 16, 17, 15, 7, 9, 8, 8, 8,
8, 8, 8, 8, 8, 9, 8, 8, 9, 8, 8, 9, 8, 8, 9, 4, -2, 2, -2, 2, -2, 2, -2, 2, -2,
3, -3, 3, -7, -116, -121, -118, -121, -117, -121, -118, -121, -117, -121, -118,
-121, -118, -120, -118, -120, -118, -120, -118, -120, -119, -118, -119, -119,
-120, -118, -120, -119, -120, -118, -120, -118, -120, -118, -120, -118, -120,
-118, -119, -117, -75, -69, -73, -71, -71, -70, -72, -70, -70, -72, -70, -72,
-67, -76, -49, -16, -26, -21, -24, -21, -23, -22, -23, -22, -22, -22, -22, -22,
-23, -23, -23, -23, -22, -23, -23, -22, -22, -23, -22, -22, -24, -20, };