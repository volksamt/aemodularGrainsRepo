#define DATA_LENGTH 512
#define DATA AKWF_1170

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 114, 122, 117, 121, 116,
120, 118, 120, 118, 120, 120, 118, 119, 119, 120, 117, 120, 117, 121, 116, 124,
57, -61, -58, -60, -59, -60, -59, -60, -58, -60, -58, -61, -58, -60, -58, -60,
-58, -60, -57, -60, -60, -57, -68, 94, 127, 111, 125, 114, 123, 115, 122, 116,
121, 117, 120, 118, 119, 119, 118, 120, 117, 120, 116, 122, 115, 124, 79, -56,
-62, -56, -62, -56, -63, -56, -63, -57, -62, -57, -61, -58, -61, -59, -59, -61,
-57, -63, -50, -81, 45, 127, 109, 125, 113, 123, 115, 120, 117, 119, 118, 119,
119, 118, 118, 118, 120, 118, 119, 117, 118, 118, 119, 117, 119, 117, 119, 117,
119, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 119, 117, 118, 117, 118,
117, 118, 117, 117, 118, 118, 118, 117, 118, 118, 118, 117, 118, 117, 118, 116,
119, 116, 119, 114, 120, 113, 123, 28, -75, -55, -65, -58, -62, -59, -60, -61,
-60, -61, -61, -61, -60, -61, -60, -61, -60, -61, -61, -61, -60, -62, -60, -62,
-61, -61, -61, -61, -60, -60, -61, -61, -60, -61, -61, -60, -61, -60, -60, -60,
-61, -60, -60, -60, -60, -60, -60, -60, -60, -61, -60, -60, -60, -60, -60, -61,
-60, -61, -60, -60, -60, -60, -60, -61, -60, -61, -60, -61, -60, -61, -60, -60,
-61, -60, -60, -59, -60, -60, -60, -60, -59, -60, -60, -60, -60, -60, -60, -60,
-60, -60, -60, -59, -60, -60, -61, -60, -60, -61, -60, -60, -60, -59, -60, -60,
-60, -59, -59, -59, -60, -59, -60, -60, -59, -60, -59, -60, -60, -60, -60, -59,
-60, -60, -60, -60, -60, -60, -60, -60, -59, -60, -60, -59, -60, -60, -60, -60,
-59, -60, -59, -60, -59, -59, -60, -60, -60, -60, -60, -59, -59, -59, -60, -59,
-59, -60, -59, -59, -59, -60, -60, -59, -60, -59, -59, -59, -59, -60, -59, -59,
-59, -59, -59, -59, -60, -60, -59, -59, -60, -60, -60, -60, -59, -60, -58, -60,
-59, -60, -60, -59, -58, -60, -59, -58, -59, -59, -59, -59, -59, -60, -60, -59,
-59, -59, -59, -59, -59, -59, -60, -59, -59, -59, -59, -59, -59, -59, -59, -60,
-59, -59, -59, -59, -59, -59, -59, -59, -59, -59, -59, -58, -59, -59, -59, -58,
-59, -60, -59, -59, -59, -59, -60, -58, -59, -59, -59, -60, -59, -59, -59, -60,
-59, -59, -59, -59, -59, -59, -59, -59, -59, -59, -59, -59, -59, -60, -59, -58,
-58, -59, -59, -59, -59, -59, -59, -58, -59, -59, -59, -59, -59, -58, -59, -59,
-59, -59, -59, -59, -60, -59, -59, -59, -59, -58, -59, -59, -59, -58, -59, -59,
-59, -59, -59, -58, -59, -58, -59, -59, -59, -59, -59, -59, -59, -58, -59, -58,
-59, -59, -59, -59, -58, -59, -59, -59, -59, -59, -58, -58, -59, -59, -59, -59,
-58, -59, -59, -59, -59, -59, -59, -60, -60, -61, -62, -63, -63, -65, -62, -63,
-61, -63, -59, -62, -58, -62, -57, -62, -50, };