#define DATA_LENGTH 512
#define DATA AKWF_1105

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 3, 4, 5, 6, 6, 9, 9, 11, 12,
14, 16, 18, 20, 21, 24, 25, 28, 30, 32, 35, 37, 39, 42, 44, 46, 48, 51, 53, 55,
58, 61, 63, 64, 67, 69, 71, 75, 76, 79, 80, 83, 85, 88, 90, 92, 94, 95, 97, 99,
101, 103, 105, 105, 107, 109, 109, 111, 112, 113, 114, 115, 115, 117, 116, 116,
117, 117, 116, 116, 115, 113, 113, 113, 112, 112, 111, 111, 110, 109, 110, 109,
110, 110, 109, 108, 109, 109, 108, 109, 109, 109, 109, 109, 109, 109, 110, 110,
110, 110, 110, 110, 111, 111, 111, 111, 110, 111, 111, 110, 109, 109, 109, 109,
108, 106, 106, 104, 104, 102, 101, 101, 100, 98, 96, 95, 93, 91, 91, 89, 87, 86,
83, 81, 80, 79, 77, 75, 72, 71, 70, 68, 65, 64, 62, 61, 59, 59, 56, 55, 55, 53,
51, 50, 49, 48, 47, 46, 45, 45, 42, 42, 42, 42, 41, 40, 40, 41, 39, 40, 39, 40,
38, 38, 39, 40, 39, 39, 39, 39, 39, 39, 38, 39, 38, 38, 38, 37, 37, 37, 37, 35,
35, 33, 33, 33, 31, 30, 29, 28, 27, 26, 25, 23, 22, 20, 19, 18, 17, 15, 14, 13,
13, 12, 11, 10, 10, 9, 8, 8, 7, 7, 6, 6, 6, 5, 5, 5, 5, 5, 4, 4, 4, 4, 2, 3, 3,
1, 1, 0, -1, -2, -3, -3, -5, -6, -8, -10, -10, -12, -14, -14, -17, -18, -20,
-22, -23, -25, -27, -28, -30, -33, -35, -36, -39, -41, -43, -45, -47, -49, -51,
-53, -55, -58, -60, -62, -65, -66, -68, -70, -73, -75, -77, -79, -82, -83, -84,
-87, -89, -91, -93, -94, -96, -97, -100, -101, -103, -104, -105, -107, -108,
-109, -110, -111, -111, -113, -114, -114, -115, -116, -116, -118, -118, -118,
-118, -118, -119, -119, -118, -119, -118, -118, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -118, -119, -119, -119, -118, -118, -117, -117, -115,
-115, -114, -114, -113, -112, -111, -110, -108, -107, -106, -104, -104, -102,
-100, -99, -98, -96, -94, -93, -92, -90, -89, -87, -85, -84, -82, -81, -79, -79,
-77, -76, -73, -71, -70, -68, -67, -66, -64, -63, -61, -60, -57, -56, -54, -53,
-51, -51, -48, -47, -45, -44, -43, -40, -40, -39, -37, -36, -35, -33, -31, -30,
-30, -29, -27, -26, -26, -25, -24, -23, -22, -22, -22, -20, -20, -19, -20, -19,
-18, -18, -18, -19, -18, -18, -18, -18, -18, -18, -20, -20, -20, -20, -21, -21,
-21, -22, -22, -23, -23, -24, -24, -25, -25, -25, -26, -26, -27, -26, -27, -27,
-29, -28, -30, -31, -31, -32, -33, -34, -35, -35, -36, -37, -38, -38, -38, -39,
-39, -39, -39, -40, -38, -38, -38, -37, -35, -34, -33, -31, -31, -30, -28, -27,
-25, -23, -22, -21, -19, -17, -16, -16, -14, -13, -11, -11, -11, -9, -8, -8, -6,
-6, -6, -5, -4, -3, -4, -3, -3, -2, -1, -1, 0, };