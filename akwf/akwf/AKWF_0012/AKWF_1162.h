#define DATA_LENGTH 512
#define DATA AKWF_1162

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 4, 1, 6, 1, 10, 35, 51, 74, 70,
72, 71, 72, 73, 73, 74, 74, 74, 74, 75, 74, 74, 73, 74, 73, 74, 73, 74, 74, 74,
74, 74, 73, 73, 73, 73, 73, 74, 73, 74, 74, 74, 75, 75, 75, 76, 76, 75, 76, 76,
76, 76, 77, 77, 78, 78, 79, 79, 79, 80, 80, 80, 81, 82, 82, 83, 83, 84, 84, 85,
85, 85, 86, 87, 87, 87, 88, 89, 90, 90, 90, 91, 92, 92, 93, 93, 94, 94, 95, 96,
96, 97, 97, 98, 99, 100, 100, 100, 102, 102, 103, 104, 104, 104, 106, 106, 106,
107, 108, 108, 109, 109, 110, 110, 112, 112, 112, 113, 113, 114, 115, 115, 116,
117, 116, 117, 118, 118, 119, 119, 118, 116, 115, 113, 112, 110, 108, 106, 105,
104, 101, 100, 98, 96, 94, 93, 92, 91, 89, 87, 86, 85, 83, 82, 81, 79, 77, 77,
76, 74, 73, 72, 71, 71, 69, 68, 67, 66, 64, 64, 62, 62, 61, 60, 58, 59, 57, 55,
55, 54, 54, 52, 53, 51, 50, 49, 48, 48, 47, 46, 46, 45, 44, 43, 42, 42, 42, 41,
40, 39, 38, 37, 37, 36, 36, 35, 35, 33, 33, 31, 31, 30, 30, 30, 29, 29, 28, 26,
26, 26, 24, 24, 23, 22, 22, 21, 20, 20, 19, 18, 18, 17, 17, 16, 15, 15, 14, 13,
12, 12, 12, 11, 10, 9, 8, 8, 7, 7, 6, 6, 4, 4, 4, 2, 3, 2, 1, 0, 0, -2, -1, -42,
-70, -67, -69, -67, -69, -68, -70, -69, -70, -70, -70, -70, -70, -70, -70, -69,
-69, -69, -70, -69, -69, -69, -68, -69, -68, -68, -67, -68, -68, -68, -68, -69,
-68, -68, -68, -68, -69, -68, -69, -69, -68, -69, -69, -69, -70, -70, -69, -71,
-71, -71, -71, -71, -71, -72, -72, -72, -73, -73, -73, -74, -75, -75, -75, -76,
-77, -76, -77, -78, -77, -78, -79, -80, -80, -81, -81, -82, -82, -82, -83, -83,
-83, -84, -85, -85, -86, -87, -86, -88, -87, -88, -88, -88, -90, -90, -91, -91,
-92, -92, -92, -93, -94, -95, -95, -95, -96, -97, -96, -97, -98, -99, -99, -100,
-100, -101, -101, -101, -102, -102, -104, -103, -103, -104, -105, -105, -106,
-107, -107, -107, -108, -108, -108, -109, -110, -110, -110, -110, -111, -112,
-113, -113, -113, -114, -114, -114, -115, -115, -112, -112, -109, -107, -106,
-104, -102, -101, -98, -97, -95, -93, -91, -89, -88, -86, -85, -83, -82, -81,
-79, -77, -75, -74, -73, -72, -70, -69, -68, -66, -66, -64, -62, -62, -61, -59,
-58, -57, -56, -54, -54, -53, -52, -50, -49, -49, -47, -46, -46, -44, -44, -42,
-42, -41, -40, -39, -37, -37, -36, -35, -35, -34, -33, -31, -30, -30, -29, -28,
-27, -27, -25, -25, -24, -23, -22, -22, -21, -20, -19, -18, -17, -17, -16, -15,
-14, -14, -13, -12, -11, -10, -9, -9, -8, -8, -6, -5, -5, -4, -3, -3, -3, 0, 0,
};