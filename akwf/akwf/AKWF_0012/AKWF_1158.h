#define DATA_LENGTH 512
#define DATA AKWF_1158

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 4, 4, 5, 7, 8, 9, 11, 10, 12,
13, 14, 15, 16, 17, 19, 20, 21, 22, 23, 24, 25, 28, 28, 29, 30, 33, 33, 34, 35,
37, 39, 40, 41, 42, 44, 45, 47, 48, 50, 51, 52, 54, 56, 57, 58, 59, 62, 63, 65,
66, 68, 69, 71, 72, 74, 75, 76, 77, 80, 80, 82, 83, 85, 87, 87, 89, 90, 92, 93,
94, 95, 97, 97, 99, 100, 102, 102, 104, 105, 106, 107, 107, 109, 109, 111, 112,
112, 113, 113, 114, 114, 116, 116, 116, 117, 117, 117, 118, 118, 118, 118, 119,
120, 120, 119, 119, 118, 118, 119, 118, 118, 118, 117, 118, 117, 117, 115, 115,
114, 114, 113, 112, 111, 111, 111, 109, 107, 107, 105, 105, 103, 102, 101, 101,
100, 98, 97, 95, 94, 93, 91, 91, 89, 89, 89, 88, 87, 85, 84, 84, 83, 82, 82, 82,
82, 81, 81, 80, 79, 79, 79, 78, 77, 78, 77, 76, 77, 76, 76, 76, 75, 76, 74, 74,
74, 73, 73, 73, 71, 71, 69, 69, 68, 66, 65, 64, 62, 61, 60, 59, 57, 55, 53, 51,
49, 48, 46, 43, 42, 39, 37, 35, 33, 30, 28, 26, 23, 21, 19, 17, 15, 13, 11, 8,
7, 4, 2, 0, -1, -3, -4, -5, -6, -8, -10, -11, -12, -13, -14, -15, -17, -17, -18,
-19, -19, -20, -21, -21, -22, -22, -22, -23, -24, -24, -24, -25, -26, -26, -26,
-27, -28, -29, -29, -29, -31, -31, -32, -34, -35, -36, -36, -38, -39, -41, -43,
-44, -46, -47, -48, -50, -52, -53, -55, -56, -58, -60, -63, -64, -66, -68, -70,
-71, -72, -74, -76, -78, -78, -80, -82, -83, -84, -86, -87, -88, -89, -89, -90,
-91, -91, -92, -93, -94, -95, -95, -95, -96, -96, -96, -97, -97, -97, -97, -97,
-98, -97, -97, -97, -98, -97, -97, -97, -97, -96, -97, -96, -95, -96, -95, -95,
-95, -94, -94, -93, -93, -92, -91, -90, -89, -90, -88, -89, -87, -86, -85, -85,
-84, -84, -83, -82, -81, -81, -80, -79, -78, -78, -77, -76, -75, -74, -73, -72,
-73, -71, -70, -68, -68, -68, -66, -65, -64, -64, -62, -61, -61, -60, -59, -58,
-57, -57, -55, -56, -55, -54, -54, -53, -53, -53, -52, -52, -52, -52, -52, -52,
-52, -52, -52, -51, -52, -51, -52, -53, -53, -52, -54, -53, -54, -54, -54, -54,
-55, -55, -56, -55, -56, -56, -56, -56, -56, -57, -57, -57, -57, -57, -57, -58,
-57, -57, -57, -57, -57, -57, -56, -57, -57, -56, -57, -55, -56, -55, -55, -55,
-54, -54, -54, -53, -52, -52, -51, -51, -50, -50, -49, -49, -48, -47, -47, -45,
-45, -44, -43, -42, -42, -42, -40, -40, -39, -37, -37, -37, -36, -35, -34, -32,
-33, -32, -31, -30, -29, -27, -27, -26, -26, -24, -23, -22, -21, -20, -20, -18,
-18, -16, -16, -15, -14, -13, -12, -11, -10, -10, -8, -7, -6, -6, -6, -4, -3,
-2, -1, 0, };