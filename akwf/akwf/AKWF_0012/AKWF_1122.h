#define DATA_LENGTH 512
#define DATA AKWF_1122

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 6, 7, 10, 11, 12, 14, 17, 18,
20, 23, 24, 26, 27, 29, 31, 33, 34, 36, 38, 40, 41, 42, 44, 46, 47, 49, 49, 51,
53, 55, 56, 57, 59, 61, 62, 63, 63, 65, 67, 67, 69, 71, 71, 73, 74, 74, 76, 78,
79, 79, 82, 83, 83, 84, 86, 87, 88, 89, 90, 91, 92, 93, 94, 94, 95, 97, 97, 98,
100, 101, 103, 103, 103, 105, 106, 106, 107, 108, 109, 110, 110, 111, 112, 112,
113, 113, 116, 115, 117, 117, 119, 118, 121, 109, 95, 93, 88, 93, 82, 75, 67,
59, 53, 44, 39, 32, 29, 24, 20, 14, 10, 4, 1, -4, -9, -13, -17, -21, -24, -28,
-32, -35, -38, -41, -44, -47, -50, -52, -55, -57, -58, -61, -63, -64, -65, -67,
-69, -70, -71, -73, -74, -75, -76, -77, -77, -79, -79, -80, -80, -81, -81, -82,
-84, -83, -84, -84, -84, -85, -85, -84, -86, -87, -86, -86, -87, -86, -87, -87,
-87, -87, -87, -87, -87, -87, -87, -86, -87, -86, -86, -86, -87, -85, -86, -85,
-85, -84, -85, -84, -84, -84, -83, -82, -83, -82, -81, -81, -81, -80, -79, -79,
-79, -78, -77, -77, -76, -75, -75, -74, -73, -72, -72, -70, -70, -69, -69, -67,
-66, -65, -64, -64, -62, -61, -60, -59, -58, -56, -56, -54, -53, -51, -50, -48,
-47, -45, -43, -42, -40, -38, -36, -33, -30, -28, -26, -24, -21, -18, -15, -13,
-10, -9, -6, -4, -2, 0, 2, 5, 6, 7, 9, 11, 13, 14, 16, 17, 19, 20, 21, 23, 23,
25, 27, 28, 29, 29, 31, 31, 32, 32, 32, 33, 34, 34, 35, 35, 36, 36, 36, 37, 37,
37, 38, 39, 38, 39, 39, 38, 39, 39, 39, 39, 38, 39, 39, 39, 39, 38, 39, 39, 40,
39, 39, 38, 39, 38, 39, 38, 39, 38, 37, 38, 37, 38, 36, 37, 37, 36, 36, 36, 36,
36, 35, 36, 35, 35, 35, 34, 34, 34, 34, 34, 33, 33, 33, 32, 33, 32, 33, 33, 32,
28, 26, 26, 24, 25, 22, 21, 18, 18, 16, 14, 13, 11, 12, 10, 10, 8, 8, 6, 6, 5,
4, 4, 3, 2, 1, 1, -1, 0, -1, -1, -2, -2, -3, -3, -4, -3, -3, -4, -6, -5, -6, -6,
-7, -6, -7, -7, -7, -7, -8, -8, -8, -8, -9, -8, -9, -10, -9, -10, -10, -11, -11,
-11, -12, -11, -12, -11, -12, -12, -13, -13, -13, -13, -15, -14, -15, -14, -15,
-15, -15, -17, -16, -17, -17, -18, -17, -18, -18, -19, -19, -19, -19, -20, -20,
-20, -21, -22, -21, -22, -22, -22, -23, -24, -23, -24, -24, -25, -25, -26, -25,
-25, -27, -26, -26, -28, -27, -28, -28, -28, -28, -28, -29, -29, -29, -29, -29,
-29, -29, -29, -29, -30, -30, -30, -30, -29, -28, -29, -28, -28, -28, -27, -27,
-26, -25, -25, -23, -22, -21, -20, -19, -16, -14, -14, -11, -10, -8, -7, -4, -3,
-2, };