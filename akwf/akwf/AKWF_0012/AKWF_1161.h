#define DATA_LENGTH 512
#define DATA AKWF_1161

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 7, 10, 12, 14, 16, 17, 20,
21, 22, 24, 25, 27, 29, 30, 32, 32, 34, 35, 35, 37, 38, 39, 40, 41, 42, 43, 44,
45, 47, 47, 48, 49, 49, 50, 50, 51, 51, 52, 53, 53, 52, 52, 52, 52, 53, 53, 51,
53, 52, 51, 51, 50, 49, 48, 47, 45, 42, 41, 41, 41, 42, 44, 46, 47, 50, 52, 55,
58, 60, 64, 67, 69, 73, 76, 79, 82, 85, 88, 90, 93, 96, 99, 101, 103, 105, 107,
108, 110, 111, 112, 113, 114, 116, 117, 117, 117, 118, 118, 118, 119, 118, 118,
118, 117, 117, 116, 115, 116, 114, 113, 112, 112, 111, 109, 109, 107, 106, 105,
104, 102, 101, 99, 99, 97, 95, 94, 92, 91, 90, 89, 89, 87, 86, 84, 84, 83, 82,
80, 80, 78, 77, 76, 76, 76, 75, 73, 73, 72, 73, 72, 71, 70, 71, 70, 69, 69, 68,
68, 68, 68, 67, 68, 66, 67, 66, 65, 65, 65, 65, 65, 65, 65, 63, 64, 64, 63, 64,
65, 64, 64, 65, 66, 67, 66, 67, 68, 68, 68, 69, 69, 70, 70, 70, 71, 72, 71, 71,
72, 72, 72, 72, 72, 71, 72, 71, 71, 71, 70, 70, 69, 70, 69, 68, 67, 66, 66, 65,
64, 64, 62, 61, 60, 59, 58, 57, 55, 54, 53, 51, 50, 47, 46, 44, 42, 40, 38, 36,
35, 32, 30, 28, 26, 23, 21, 19, 16, 14, 12, 9, 7, 4, 2, 0, -1, -4, -6, -8, -10,
-12, -15, -17, -19, -20, -21, -23, -25, -27, -27, -29, -31, -32, -33, -34, -36,
-36, -38, -40, -40, -42, -43, -43, -45, -46, -47, -48, -49, -49, -50, -51, -51,
-51, -51, -53, -53, -53, -53, -52, -54, -53, -53, -53, -53, -53, -53, -52, -53,
-51, -51, -50, -48, -47, -45, -42, -41, -41, -41, -43, -44, -47, -49, -51, -54,
-56, -59, -62, -65, -69, -71, -74, -77, -79, -83, -86, -90, -92, -94, -97, -100,
-102, -105, -107, -108, -109, -111, -113, -114, -115, -115, -116, -117, -118,
-118, -118, -119, -119, -118, -119, -119, -118, -118, -117, -117, -116, -116,
-115, -115, -114, -113, -111, -111, -109, -108, -107, -105, -105, -104, -101,
-100, -99, -98, -97, -96, -94, -92, -91, -89, -88, -87, -86, -85, -84, -82, -81,
-80, -79, -79, -78, -78, -76, -76, -75, -75, -74, -73, -72, -72, -71, -71, -71,
-70, -70, -69, -68, -69, -69, -69, -68, -68, -68, -67, -67, -66, -66, -66, -65,
-66, -66, -66, -65, -66, -66, -65, -65, -65, -65, -65, -66, -66, -67, -67, -68,
-68, -69, -69, -70, -70, -70, -70, -71, -72, -71, -72, -72, -72, -73, -72, -72,
-73, -72, -73, -71, -71, -71, -71, -70, -70, -69, -69, -69, -68, -67, -66, -66,
-65, -64, -62, -62, -61, -59, -59, -56, -56, -54, -54, -51, -49, -48, -47, -44,
-43, -40, -38, -36, -34, -32, -30, -28, -27, -24, -21, -20, -18, -14, -12, -10,
-8, -6, -3, -1, };