#define DATA_LENGTH 512
#define DATA AKWF_1148

const PROGMEM int8_t DATA[DATA_LENGTH] = {27, 27, 24, 26, 25, 26, 25, 26, 25,
27, 25, 26, 25, 26, 25, 26, 25, 26, 26, 26, 25, 26, 25, 27, 25, 27, 25, 27, 24,
29, 20, 35, 108, 113, 112, 111, 112, 111, 113, 110, 113, 111, 113, 110, 113,
109, 114, 105, -33, -72, -65, -69, -66, -70, -68, -70, -68, -69, -67, -69, -67,
-70, -67, -71, -7, 29, 22, 26, 24, 26, 24, 26, 24, 26, 25, 25, 25, 25, 24, 25,
25, 26, 24, 25, 25, 25, 25, 25, 24, 25, 24, 25, 25, 25, 26, 24, 29, 41, 40, 41,
41, 40, 41, 41, 41, 41, 41, 40, 41, 40, 41, 41, 41, 40, 40, 41, 41, 41, 40, 40,
40, 41, 41, 41, 41, 41, 40, 41, 40, 41, 41, 41, 41, 41, 41, 40, 40, 40, 41, 41,
41, 40, 40, 40, 40, 41, 40, 40, 41, 41, 41, 41, 40, 40, 40, 40, 40, 41, 41, 41,
40, 40, 41, 40, 40, 40, 40, 41, 41, 41, 40, 40, 41, 41, 41, 41, 40, 40, 40, 41,
41, 40, 40, 40, 41, 40, 40, 40, 40, 39, 40, 41, 40, 40, 41, 40, 40, 40, 40, 40,
41, 40, 40, 40, 40, 40, 40, 40, 41, 39, 40, 40, 40, 41, 40, 39, 40, 41, 40, 40,
40, 40, 40, 40, 39, 40, 40, 40, 40, 40, 40, 41, 40, 40, 40, 41, 40, 40, 39, 40,
40, 40, 39, 41, 40, 40, 40, 40, 40, 40, 40, 40, 39, 39, 40, 30, 23, 25, 24, 24,
23, 24, 24, 24, 24, 23, 24, 24, 23, 23, 24, 24, 24, 24, 24, 24, 23, 24, 24, 23,
23, 24, 24, 23, 24, 23, 24, 21, 9, 9, 9, 8, 9, 9, 9, 9, 9, 9, 8, 9, 8, 9, 8, 12,
35, 40, 40, 39, 40, 39, 40, 39, 39, 39, 39, 40, 39, 40, 39, 41, 26, 18, 24, 22,
23, 23, 23, 21, 24, 22, 22, 22, 23, 22, 23, 22, 23, 22, 23, 22, 23, 22, 23, 23,
22, 23, 22, 24, 21, 26, 18, 33, -12, -73, -68, -73, -69, -72, -70, -71, -71,
-71, -70, -70, -70, -70, -71, -70, -71, -70, -72, -70, -71, -71, -71, -70, -70,
-71, -71, -70, -70, -71, -71, -70, -70, -70, -71, -70, -71, -70, -70, -70, -70,
-71, -70, -70, -70, -69, -70, -71, -70, -69, -70, -70, -70, -70, -71, -71, -70,
-70, -70, -70, -70, -70, -70, -70, -70, -69, -70, -69, -70, -70, -70, -70, -70,
-70, -70, -70, -70, -69, -70, -69, -69, -69, -69, -69, -69, -70, -69, -69, -69,
-70, -69, -69, -69, -69, -69, -69, -69, -69, -68, -68, -68, -69, -69, -69, -69,
-69, -70, -69, -69, -69, -69, -69, -69, -69, -70, -69, -68, -68, -68, -69, -69,
-68, -69, -69, -69, -69, -69, -69, -68, -68, -68, -69, -68, -68, -68, -68, -68,
-68, -68, -68, -68, -68, -68, -68, -68, -69, -68, -69, -67, -68, -67, -69, -67,
-69, -66, -68, -67, -68, -67, -6, };