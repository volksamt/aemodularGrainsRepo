#define DATA_LENGTH 512
#define DATA AKWF_1155

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 11, 15, 21, 24, 29, 33, 37, 42,
48, 53, 58, 64, 69, 73, 78, 82, 85, 89, 92, 96, 100, 103, 106, 108, 111, 114,
114, 116, 116, 117, 118, 119, 118, 119, 119, 119, 118, 117, 117, 115, 114, 112,
111, 110, 109, 106, 105, 103, 102, 100, 98, 96, 94, 92, 90, 88, 87, 85, 84, 82,
81, 80, 77, 76, 75, 73, 74, 71, 71, 70, 69, 68, 67, 66, 65, 64, 64, 64, 63, 62,
61, 61, 60, 59, 58, 57, 57, 56, 54, 53, 53, 51, 50, 49, 47, 47, 45, 43, 42, 41,
40, 38, 36, 35, 33, 31, 30, 27, 26, 24, 23, 21, 20, 18, 16, 15, 14, 13, 11, 9,
8, 7, 6, 4, 3, 2, 2, 1, 0, -1, -2, -3, -2, -2, -3, -4, -5, -5, -5, -5, -5, -6,
-5, -6, -6, -7, -6, -6, -7, -7, -7, -8, -8, -8, -8, -8, -9, -9, -10, -10, -10,
-11, -12, -12, -12, -13, -14, -14, -16, -15, -17, -18, -18, -18, -20, -20, -21,
-23, -23, -23, -24, -24, -25, -26, -27, -28, -28, -28, -29, -30, -30, -29, -30,
-30, -31, -31, -31, -31, -31, -31, -31, -30, -31, -31, -31, -31, -30, -31, -30,
-30, -30, -30, -29, -29, -29, -30, -29, -29, -28, -29, -29, -29, -28, -29, -29,
-28, -28, -29, -29, -30, -29, -30, -29, -30, -31, -31, -31, -31, -31, -32, -32,
-32, -32, -32, -33, -34, -34, -34, -35, -34, -34, -34, -35, -34, -35, -35, -35,
-34, -35, -35, -35, -35, -35, -34, -35, -34, -34, -35, -34, -34, -34, -33, -33,
-32, -32, -33, -32, -32, -31, -32, -31, -30, -30, -31, -30, -30, -30, -29, -29,
-29, -29, -29, -29, -30, -29, -29, -29, -28, -29, -28, -30, -29, -30, -30, -29,
-29, -29, -30, -30, -30, -30, -30, -31, -31, -30, -30, -30, -30, -30, -30, -30,
-31, -31, -31, -30, -30, -29, -29, -30, -29, -29, -28, -28, -28, -29, -29, -28,
-27, -27, -27, -27, -27, -27, -26, -26, -25, -24, -24, -24, -25, -24, -25, -24,
-24, -23, -24, -23, -23, -23, -23, -23, -22, -23, -23, -24, -23, -23, -23, -23,
-23, -23, -23, -23, -22, -24, -23, -23, -22, -23, -22, -23, -23, -22, -22, -23,
-23, -23, -22, -22, -22, -22, -21, -22, -22, -21, -21, -22, -21, -21, -21, -21,
-21, -20, -20, -20, -20, -20, -19, -19, -18, -18, -18, -18, -18, -17, -17, -17,
-17, -17, -17, -17, -17, -17, -16, -16, -16, -16, -16, -16, -17, -16, -15, -15,
-15, -16, -16, -16, -16, -16, -15, -16, -16, -15, -16, -15, -15, -15, -16, -16,
-15, -15, -14, -15, -15, -15, -15, -15, -15, -14, -15, -14, -14, -13, -14, -14,
-14, -13, -13, -13, -13, -12, -13, -12, -12, -11, -12, -12, -12, -12, -12, -12,
-12, -11, -11, -10, -10, -10, -11, -10, -10, -10, -11, -10, -10, -10, -9, -10,
-10, -10, -9, -10, -10, -9, -10, -9, -9, -10, -9, -7, -3, };