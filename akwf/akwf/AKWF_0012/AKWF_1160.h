#define DATA_LENGTH 512
#define DATA AKWF_1160

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 7, 9, 11, 12, 14, 17, 19, 19,
22, 24, 25, 26, 28, 29, 31, 32, 34, 35, 36, 37, 38, 38, 39, 40, 41, 41, 41, 41,
41, 41, 40, 41, 40, 39, 37, 36, 34, 32, 31, 30, 30, 31, 31, 33, 33, 34, 36, 38,
40, 41, 43, 45, 47, 49, 51, 52, 55, 57, 59, 60, 64, 64, 67, 68, 71, 71, 74, 75,
77, 78, 79, 80, 83, 83, 84, 86, 86, 87, 88, 89, 89, 91, 91, 91, 92, 93, 93, 94,
94, 94, 95, 95, 95, 94, 95, 95, 95, 96, 96, 95, 97, 96, 97, 96, 96, 97, 97, 99,
101, 109, 118, 117, 113, 109, 108, 106, 105, 103, 103, 101, 100, 99, 98, 97, 95,
70, 22, 14, 29, 37, 41, 41, 42, 43, 42, 42, 42, 42, 41, 41, 41, 39, 39, 37, 36,
35, 33, 32, 32, 30, 29, 28, 27, 25, 24, 23, 22, 21, 19, 19, 18, 18, 17, 16, 16,
16, 16, 16, 16, 17, 18, 20, 22, 29, 52, 67, 61, 53, 49, 45, 46, 45, 44, 44, 45,
44, 44, 45, 45, 45, 46, 45, 46, 47, 48, 48, 48, 49, 49, 50, 49, 50, 50, 50, 51,
51, 51, 51, 50, 51, 50, 50, 50, 50, 50, 49, 48, 48, 47, 47, 46, 45, 45, 44, 43,
42, 41, 41, 40, 38, 36, 35, 34, 33, 32, 31, 29, 28, 26, 25, 23, 22, 21, 19, 17,
17, 15, 13, 11, 9, 8, 6, 4, 2, 1, 0, -3, -5, -5, -7, -9, -10, -12, -14, -15,
-17, -18, -20, -21, -22, -24, -24, -26, -28, -28, -29, -30, -30, -31, -31, -33,
-33, -33, -34, -33, -33, -33, -33, -32, -32, -31, -30, -28, -27, -26, -24, -24,
-25, -24, -24, -26, -27, -28, -29, -31, -32, -34, -35, -37, -39, -39, -42, -43,
-45, -47, -49, -51, -52, -54, -56, -58, -60, -61, -62, -64, -65, -67, -67, -69,
-71, -72, -72, -73, -75, -76, -77, -77, -78, -78, -80, -80, -81, -82, -82, -83,
-83, -84, -85, -84, -84, -85, -85, -86, -86, -86, -87, -88, -87, -88, -88, -88,
-88, -89, -88, -88, -88, -90, -89, -90, -89, -77, -53, -39, -36, -37, -38, -40,
-40, -40, -41, -41, -41, -41, -40, -40, -41, -41, -40, -40, -39, -39, -38, -37,
-37, -36, -37, -36, -34, -34, -34, -34, -34, -33, -32, -32, -31, -32, -31, -32,
-32, -32, -32, -33, -33, -34, -35, -36, -38, -39, -41, -44, -50, -72, -92, -89,
-79, -74, -73, -72, -71, -71, -71, -71, -71, -71, -72, -72, -72, -72, -73, -73,
-74, -75, -74, -74, -75, -75, -75, -75, -76, -76, -76, -75, -76, -75, -75, -76,
-74, -75, -74, -74, -72, -72, -72, -71, -71, -70, -68, -67, -67, -66, -64, -64,
-63, -61, -60, -59, -58, -56, -55, -54, -52, -51, -50, -48, -47, -45, -43, -42,
-40, -39, -36, -34, -33, -30, -30, -27, -25, -23, -21, -18, -17, -15, -12, -10,
-8, -5, -4, -1, };