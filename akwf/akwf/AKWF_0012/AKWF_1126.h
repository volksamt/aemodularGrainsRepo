#define DATA_LENGTH 512
#define DATA AKWF_1126

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 5, 7, 8, 10, 12, 13, 15, 16,
17, 19, 20, 22, 24, 26, 27, 28, 29, 31, 32, 34, 35, 38, 39, 39, 41, 42, 45, 45,
47, 49, 50, 52, 52, 53, 54, 56, 57, 59, 61, 60, 62, 64, 66, 66, 68, 69, 70, 71,
73, 74, 76, 76, 77, 79, 80, 81, 83, 84, 85, 85, 87, 88, 89, 90, 91, 92, 94, 95,
95, 96, 97, 99, 99, 101, 102, 102, 103, 104, 104, 105, 105, 106, 107, 107, 108,
107, 109, 109, 110, 110, 111, 111, 112, 111, 113, 113, 114, 113, 115, 114, 114,
115, 116, 117, 116, 117, 116, 118, 115, 120, 115, 120, 116, 120, 115, 121, 115,
122, 115, 123, 115, 123, 114, 119, 106, -102, -119, -105, -112, -101, -110, -99,
-104, -96, -100, -93, -96, -91, -92, -88, -90, -86, -87, -85, -84, -83, -82,
-80, -78, -78, -76, -76, -74, -74, -72, -72, -69, -69, -67, -67, -66, -66, -63,
-63, -61, -60, -59, -60, -57, -56, -55, -54, -52, -50, -50, -49, -47, -46, -45,
-44, -42, -41, -40, -39, -38, -37, -36, -35, -33, -32, -32, -31, -30, -29, -28,
-26, -26, -26, -26, -25, -25, -24, -22, -22, -20, -21, -19, -19, -19, -18, -18,
-17, -17, -16, -15, -16, -14, -14, -13, -13, -12, -12, -11, -11, -11, -10, -10,
-9, -9, -8, -8, -8, -8, -7, -7, -7, -5, -5, -5, -4, -4, -4, -3, -3, -4, -3, -2,
-2, -2, -1, 0, -1, 0, 0, 1, 1, 1, 2, 2, 2, 3, 3, 4, 3, 5, 4, 5, 5, 6, 6, 7, 7,
7, 8, 8, 8, 9, 10, 9, 10, 10, 10, 11, 12, 12, 13, 13, 14, 15, 14, 16, 16, 16,
17, 18, 18, 19, 20, 19, 20, 21, 22, 23, 22, 23, 25, 25, 26, 26, 26, 28, 28, 29,
29, 31, 32, 32, 33, 34, 34, 35, 36, 37, 37, 38, 39, 39, 41, 41, 42, 43, 44, 45,
46, 47, 47, 49, 51, 52, 53, 54, 55, 57, 58, 59, 61, 63, 63, 66, 65, 68, 68, 71,
71, 74, 74, 77, 78, 80, 81, 83, 85, 86, 88, 88, 91, 91, 95, 93, 100, 96, 104,
99, 109, 102, 113, 104, 118, 104, 127, 93, -123, -119, -118, -121, -117, -122,
-116, -121, -116, -121, -116, -121, -116, -121, -116, -119, -116, -119, -116,
-118, -116, -117, -115, -115, -115, -115, -114, -114, -114, -113, -113, -112,
-112, -110, -112, -110, -111, -110, -110, -107, -109, -107, -107, -106, -106,
-105, -104, -104, -103, -102, -100, -101, -100, -100, -98, -98, -96, -96, -95,
-94, -93, -91, -92, -90, -90, -88, -88, -86, -85, -84, -83, -81, -80, -79, -77,
-76, -75, -73, -73, -71, -69, -69, -67, -66, -65, -63, -62, -61, -60, -58, -56,
-55, -54, -52, -52, -49, -49, -46, -44, -44, -42, -40, -39, -37, -36, -35, -33,
-31, -30, -28, -26, -25, -24, -22, -20, -19, -18, -16, -14, -13, -12, -10, -8,
-7, -5, -4, -2, -1, };