#define DATA_LENGTH 512
#define DATA AKWF_1195

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 7, 8, 9, 12, 14, 16, 18, 20,
20, 23, 25, 26, 28, 30, 32, 34, 35, 36, 38, 38, 40, 41, 42, 44, 43, 45, 46, 47,
49, 49, 50, 52, 52, 54, 55, 56, 57, 59, 59, 62, 63, 65, 66, 67, 68, 70, 72, 72,
74, 73, 75, 76, 77, 79, 81, 82, 82, 84, 85, 85, 86, 88, 87, 88, 89, 90, 89, 90,
90, 91, 91, 92, 93, 94, 95, 95, 95, 96, 96, 96, 95, 96, 96, 96, 96, 97, 98, 97,
97, 97, 98, 98, 98, 98, 97, 98, 97, 97, 98, 98, 99, 98, 99, 97, 98, 99, 99, 99,
100, 101, 101, 101, 101, 102, 102, 102, 103, 102, 103, 105, 105, 105, 107, 106,
106, 106, 106, 107, 108, 107, 108, 108, 109, 108, 109, 109, 110, 112, 111, 111,
112, 113, 113, 116, 115, 116, 116, 116, 116, 117, 118, 118, 119, 118, 118, 117,
119, 118, 119, 119, 118, 118, 117, 117, 118, 117, 115, 115, 114, 115, 116, 113,
113, 112, 111, 110, 110, 110, 109, 108, 107, 105, 104, 105, 104, 104, 102, 102,
99, 98, 96, 94, 91, 89, 87, 85, 84, 84, 81, 80, 78, 76, 74, 73, 72, 71, 69, 67,
65, 64, 62, 61, 60, 58, 57, 55, 54, 52, 50, 49, 49, 47, 45, 44, 43, 40, 39, 37,
37, 37, 36, 33, 32, 30, 29, 26, 25, 24, 22, 20, 20, 18, 16, 15, 14, 12, 10, 9,
8, 6, 5, 4, 2, 0, -2, -3, -2, -4, -5, -6, -7, -9, -10, -12, -12, -14, -15, -16,
-17, -18, -20, -21, -23, -23, -25, -25, -26, -27, -28, -29, -32, -32, -35, -35,
-35, -38, -39, -40, -41, -41, -43, -44, -46, -45, -48, -48, -49, -50, -52, -54,
-55, -56, -56, -57, -58, -59, -60, -60, -61, -62, -63, -65, -66, -66, -67, -69,
-70, -70, -72, -72, -73, -74, -74, -75, -75, -76, -77, -79, -81, -81, -81, -83,
-83, -83, -84, -85, -86, -86, -87, -88, -87, -89, -88, -89, -90, -91, -91, -92,
-93, -92, -94, -96, -96, -97, -98, -98, -99, -99, -101, -102, -102, -103, -103,
-103, -105, -106, -107, -108, -108, -108, -110, -110, -111, -113, -112, -114,
-113, -113, -114, -115, -116, -116, -116, -117, -117, -118, -117, -117, -118,
-117, -116, -119, -119, -119, -118, -117, -117, -117, -117, -117, -117, -116,
-115, -115, -115, -115, -115, -114, -114, -113, -113, -113, -114, -113, -113,
-113, -111, -110, -111, -110, -109, -109, -106, -105, -104, -103, -102, -101,
-100, -98, -96, -96, -94, -93, -92, -91, -89, -89, -87, -86, -85, -83, -81, -82,
-81, -81, -78, -78, -77, -77, -76, -75, -74, -75, -74, -73, -72, -72, -70, -69,
-69, -67, -65, -65, -63, -63, -60, -60, -56, -56, -54, -51, -50, -48, -47, -45,
-43, -43, -42, -40, -39, -38, -36, -35, -35, -32, -31, -30, -29, -27, -26, -25,
-24, -22, -20, -20, -20, -18, -17, -15, -15, -12, -11, -9, -8, -6, -5, -3, -1,
};