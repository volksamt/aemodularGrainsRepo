#define DATA_LENGTH 512
#define DATA AKWF_1144

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 3, 3, 3, 4, 4, 3, 4, 3, 3, 3,
3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 3, 3, 3, 2, 3, 4, 3, 3, 2, 3, 3,
2, 4, 3, 3, 3, 3, 3, 2, 3, 3, 2, 3, 4, 3, 3, 3, 3, 4, 3, 2, 3, 3, 4, 3, 2, 3, 4,
2, 4, 3, 4, 2, 3, 3, 3, 3, 2, 3, 3, 3, 3, 4, 3, 3, 3, 4, 4, 3, 3, 3, 3, 3, 2, 3,
4, 4, 4, 4, 5, 5, 6, 5, 5, 6, 6, 6, 7, 7, 7, 7, 7, 8, 8, 8, 9, 8, 8, 9, 10, 9,
10, 10, 11, 11, 11, 11, 11, 11, 12, 13, 12, 13, 13, 13, 14, 13, 14, 13, 14, 15,
15, 15, 15, 15, 16, 16, 17, 16, 16, 17, 17, 18, 18, 18, 18, 19, 19, 18, 19, 19,
20, 20, 20, 19, 21, 20, 22, 20, 22, 21, 23, 22, 22, 22, 23, 23, 24, 23, 24, 24,
23, 23, 22, 24, 21, 24, 18, 27, 11, 72, 119, 101, 109, 101, 105, 100, 102, 97,
97, 95, 95, 92, 90, 90, 88, 88, 85, 84, 82, 82, 79, 79, 76, 76, 73, 73, 71, 70,
67, 67, 65, 64, 63, 62, 60, 58, 57, 55, 55, 52, 52, 49, 48, 46, 47, 42, 44, 39,
42, 31, 5, 9, 7, 8, 6, 7, 6, 6, 6, 5, 6, 5, 5, 5, 5, 4, 4, 4, 4, 4, 3, 2, 2, 2,
2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 2, 1, 2, 2, 2, 1, 2, 2, 2, 1, 2, 2, 2, 2,
2, 2, 2, 2, 2, 2, 2, 3, 2, 2, 1, 1, 2, 1, 1, 2, 1, 1, 2, 2, 1, 2, 2, 1, 2, 2, 2,
2, 1, 2, 2, 3, 2, 2, 2, 2, 2, 2, 1, 2, 2, 2, 3, 2, 2, 2, 2, 2, 1, 2, 3, 2, 2, 1,
0, 2, 0, 0, 0, 0, 0, -1, -1, -1, -1, -2, -2, -2, -2, -3, -3, -3, -3, -3, -3, -5,
-4, -4, -5, -5, -6, -5, -6, -6, -7, -7, -6, -7, -6, -7, -7, -8, -8, -8, -9, -9,
-8, -9, -10, -10, -9, -10, -11, -11, -10, -11, -11, -12, -12, -12, -13, -13,
-13, -13, -14, -13, -15, -14, -15, -15, -16, -14, -16, -15, -16, -15, -17, -16,
-17, -17, -17, -18, -17, -19, -17, -23, -10, -94, -127, -111, -119, -110, -115,
-109, -111, -106, -108, -104, -105, -101, -101, -100, -99, -96, -94, -93, -92,
-91, -89, -88, -86, -85, -83, -82, -80, -79, -77, -76, -75, -74, -72, -71, -68,
-68, -66, -65, -63, -62, -60, -59, -57, -56, -55, -52, -52, -51, -49, -47, -46,
-45, -43, -42, -40, -39, -38, -36, -34, -33, -31, -29, -29, -27, -26, -24, -23,
-21, -21, -18, -17, -15, -15, -13, -12, -9, -9, -7, -5, -4, -3, -1, -1, };