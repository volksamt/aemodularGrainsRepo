#define DATA_LENGTH 512
#define DATA AKWF_1163

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 9, 18, 35, 42, 50, 55, 61, 66,
71, 76, 80, 84, 87, 91, 94, 96, 98, 101, 104, 106, 107, 109, 110, 112, 112, 113,
114, 114, 115, 116, 117, 117, 118, 118, 119, 119, 119, 120, 120, 119, 119, 119,
119, 117, 118, 117, 118, 117, 116, 115, 116, 115, 115, 114, 113, 113, 112, 113,
111, 112, 111, 111, 110, 111, 108, 110, 99, 82, 78, 72, 68, 63, 59, 54, 50, 46,
43, 40, 37, 34, 32, 30, 28, 26, 24, 22, 21, 20, 17, 17, 15, 15, 14, 13, 12, 12,
10, 10, 9, 9, 9, 8, 8, 7, 7, 7, 7, 7, 7, 7, 7, 7, 6, 6, 6, 7, 6, 6, 7, 6, 6, 7,
7, 6, 6, 7, 6, 8, -3, -14, -15, -21, -24, -27, -31, -34, -37, -39, -42, -44,
-45, -47, -49, -51, -53, -54, -56, -55, -58, -58, -59, -60, -61, -61, -62, -62,
-63, -64, -64, -65, -65, -65, -64, -65, -65, -65, -66, -66, -67, -66, -65, -66,
-65, -66, -66, -66, -66, -66, -66, -66, -66, -66, -65, -65, -65, -65, -66, -65,
-65, -64, -64, -65, -64, -64, -63, -64, -64, -64, -64, -64, -64, -64, -64, -63,
-63, -63, -63, -64, -62, -62, -62, -63, -63, -62, -63, -62, -62, -61, -63, -62,
-62, -62, -61, -62, -62, -61, -62, -62, -62, -61, -61, -61, -61, -61, -61, -61,
-61, -60, -61, -59, -62, -56, -32, -26, -19, -12, -6, -1, 4, 9, 13, 18, 21, 26,
28, 30, 27, 32, 38, 41, 43, 44, 47, 50, 54, 57, 58, 60, 63, 63, 65, 68, 73, 75,
78, 79, 81, 82, 84, 85, 86, 88, 89, 90, 90, 91, 92, 93, 92, 94, 94, 94, 94, 95,
95, 95, 96, 96, 95, 95, 96, 96, 96, 96, 96, 95, 95, 95, 95, 95, 94, 94, 95, 93,
94, 94, 94, 94, 94, 93, 94, 93, 93, 92, 93, 92, 93, 91, 81, 77, 75, 71, 69, 66,
64, 61, 60, 58, 56, 55, 53, 51, 50, 49, 48, 47, 46, 46, 44, 44, 43, 42, 42, 41,
41, 40, 40, 40, 39, 40, 39, 30, 24, 22, 18, 16, 13, 11, 9, 7, 5, 3, 1, -1, -1,
-3, -3, -8, -21, -25, -30, -33, -38, -41, -45, -48, -51, -54, -56, -58, -60,
-62, -65, -65, -67, -69, -70, -71, -72, -73, -74, -75, -75, -77, -76, -77, -77,
-78, -78, -78, -79, -79, -79, -80, -80, -79, -80, -80, -80, -80, -80, -80, -80,
-80, -80, -80, -79, -80, -79, -79, -79, -79, -80, -79, -79, -80, -78, -79, -79,
-78, -79, -78, -79, -78, -78, -78, -78, -77, -77, -79, -78, -77, -82, -85, -85,
-86, -87, -88, -89, -90, -91, -92, -92, -93, -94, -94, -94, -95, -96, -95, -97,
-97, -97, -96, -97, -97, -97, -98, -98, -97, -98, -97, -97, -95, -95, -94, -95,
-93, -94, -92, -93, -91, -91, -91, -91, -89, -91, -87, -90, -83, -55, -47, -40,
-31, -26, -23, -20, -15, -11, -5, };