#define DATA_LENGTH 512
#define DATA AKWF_1172

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 1, 1, 1, 2, 2, 3, 2, 3, 5, 5,
7, 8, 10, 11, 13, 15, 17, 19, 20, 22, 24, 26, 27, 29, 30, 32, 34, 35, 37, 39,
41, 41, 43, 45, 46, 47, 49, 50, 51, 53, 54, 54, 56, 57, 58, 59, 61, 61, 63, 64,
65, 65, 67, 67, 69, 69, 71, 71, 73, 73, 74, 75, 76, 76, 77, 77, 73, 62, 52, 45,
42, 40, 38, 38, 37, 37, 37, 37, 38, 38, 39, 40, 40, 41, 42, 43, 44, 44, 45, 46,
46, 48, 48, 48, 48, 49, 50, 59, 77, 92, 102, 107, 112, 114, 116, 117, 118, 119,
119, 119, 119, 118, 117, 117, 116, 115, 113, 112, 111, 110, 108, 108, 107, 105,
104, 102, 101, 100, 99, 99, 98, 96, 95, 94, 94, 93, 91, 90, 89, 89, 87, 87, 85,
85, 84, 83, 82, 81, 80, 78, 78, 78, 77, 75, 74, 73, 73, 72, 71, 70, 69, 67, 67,
66, 66, 64, 62, 61, 61, 61, 59, 58, 57, 56, 55, 54, 53, 52, 51, 50, 49, 48, 46,
46, 44, 44, 43, 42, 41, 40, 39, 37, 36, 35, 35, 13, -17, -38, -53, -62, -69,
-73, -78, -80, -82, -84, -85, -86, -87, -86, -87, -87, -86, -87, -86, -85, -85,
-85, -84, -84, -83, -84, -83, -83, -83, -83, -82, -83, -83, -83, -83, -83, -84,
-83, -83, -85, -84, -85, -85, -86, -86, -86, -87, -87, -89, -89, -89, -90, -89,
-90, -91, -91, -91, -91, -92, -93, -94, -93, -94, -94, -95, -96, -96, -97, -97,
-96, -98, -97, -97, -98, -98, -99, -99, -100, -100, -100, -100, -101, -101,
-100, -100, -101, -101, -101, -102, -101, -101, -103, -101, -103, -102, -102,
-101, -102, -103, -103, -102, -103, -102, -102, -103, -102, -102, -103, -102,
-102, -102, -101, -102, -101, -101, -98, -80, -64, -53, -46, -41, -38, -36, -34,
-32, -32, -31, -31, -32, -31, -31, -31, -31, -32, -32, -33, -33, -34, -35, -34,
-35, -36, -36, -36, -36, -37, -37, -38, -37, -37, -37, -37, -37, -36, -37, -36,
-36, -36, -35, -35, -36, -35, -35, -34, -40, -53, -63, -69, -71, -74, -75, -76,
-77, -77, -76, -76, -75, -74, -74, -73, -73, -71, -70, -68, -68, -67, -66, -65,
-63, -63, -62, -61, -60, -59, -58, -57, -56, -55, -55, -54, -52, -51, -52, -50,
-50, -49, -48, -47, -46, -46, -46, -45, -44, -44, -43, -42, -42, -41, -41, -40,
-39, -39, -38, -38, -37, -37, -36, -36, -35, -35, -34, -33, -33, -33, -33, -31,
-31, -30, -30, -30, -29, -28, -28, -28, -27, -27, -26, -26, -26, -25, -23, -24,
-23, -22, -22, -22, -22, -21, -20, -20, -20, -19, -18, -18, -17, -17, -17, -17,
-16, -15, -15, -15, -14, -14, -13, -13, -13, -12, -12, -11, -11, -10, -10, -10,
-10, -9, -8, -9, -8, -7, -8, -6, -7, -6, -5, -6, -6, -6, -5, -5, -4, -4, -3, -3,
-3, -3, -2, -2, -1, -1, -1, 0, 0, };