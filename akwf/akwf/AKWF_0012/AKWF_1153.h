#define DATA_LENGTH 512
#define DATA AKWF_1153

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 2, 2, 3, 2, 4, 3, 4, 4, 5, 5, 6,
7, 8, 7, 9, 8, 9, 9, 10, 10, 10, 12, 12, 12, 13, 13, 14, 14, 15, 15, 16, 16, 16,
17, 17, 18, 19, 19, 20, 20, 20, 22, 21, 23, 23, 23, 23, 24, 25, 25, 26, 26, 27,
26, 27, 27, 29, 29, 29, 29, 30, 30, 32, 31, 32, 33, 33, 34, 34, 34, 34, 35, 35,
36, 36, 38, 38, 38, 39, 38, 40, 40, 40, 41, 42, 42, 43, 43, 44, 44, 45, 45, 46,
46, 47, 47, 48, 49, 48, 48, 50, 50, 51, 51, 52, 52, 52, 53, 53, 53, 54, 54, 55,
55, 55, 56, 58, 58, 58, 58, 59, 60, 60, 61, 61, 62, 62, 62, 63, 63, 64, 64, 65,
66, 66, 66, 67, 68, 69, 69, 69, 70, 70, 70, 71, 71, 71, 72, 72, 73, 74, 75, 74,
75, 76, 76, 76, 77, 78, 78, 79, 80, 80, 80, 80, 81, 81, 82, 82, 83, 83, 84, 84,
85, 86, 86, 86, 86, 87, 88, 89, 89, 89, 89, 90, 90, 91, 91, 91, 93, 93, 93, 94,
94, 95, 95, 96, 96, 97, 98, 98, 98, 99, 99, 100, 101, 101, 101, 102, 102, 102,
103, 103, 104, 105, 105, 106, 106, 107, 106, 107, 108, 109, 109, 109, 109, 110,
110, 110, 111, 112, 113, 113, 114, 114, 115, 115, 115, 116, 117, 116, 117, 118,
118, 119, 117, 104, 90, 78, 65, 53, 41, 31, 19, 10, 1, -9, -17, -25, -33, -39,
-46, -52, -58, -63, -68, -73, -77, -81, -84, -88, -92, -95, -97, -99, -101,
-103, -105, -107, -108, -110, -111, -111, -112, -113, -114, -114, -114, -114,
-116, -116, -117, -117, -115, -116, -116, -115, -116, -115, -114, -115, -115,
-114, -114, -113, -112, -112, -111, -111, -111, -110, -109, -109, -108, -108,
-107, -106, -106, -105, -105, -104, -103, -102, -102, -101, -100, -99, -99, -98,
-97, -96, -96, -96, -94, -93, -93, -93, -92, -92, -90, -91, -90, -89, -88, -87,
-87, -86, -85, -85, -84, -84, -84, -83, -81, -81, -80, -79, -79, -79, -77, -77,
-76, -76, -75, -75, -74, -74, -73, -73, -72, -71, -71, -70, -69, -69, -68, -68,
-67, -66, -66, -65, -65, -63, -64, -63, -62, -62, -61, -61, -60, -60, -59, -59,
-58, -58, -57, -56, -56, -56, -55, -54, -53, -53, -53, -52, -52, -51, -51, -50,
-49, -50, -49, -48, -47, -47, -46, -46, -46, -45, -45, -44, -44, -43, -43, -42,
-42, -41, -41, -40, -39, -39, -39, -38, -38, -37, -36, -36, -35, -34, -34, -33,
-33, -34, -32, -32, -32, -31, -31, -31, -30, -29, -29, -28, -27, -27, -26, -26,
-25, -25, -25, -24, -24, -22, -23, -22, -22, -21, -21, -20, -20, -19, -18, -18,
-17, -18, -17, -17, -16, -15, -15, -14, -13, -14, -12, -12, -12, -12, -11, -10,
-9, -9, -9, -8, -8, -8, -8, -6, -5, -6, -5, -4, -4, -3, -3, -3, -3, -2, -1, 0,
0, };