#define DATA_LENGTH 512
#define DATA AKWF_1125

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 4, 5, 5, 4, 4, 4, 4, 4, 5, 4, 4, 5,
4, 5, 4, 4, 5, 5, 5, 5, 5, 4, 5, 4, 7, 13, 11, 12, 11, 12, 13, 11, 12, 12, 12,
12, 13, 11, 12, 11, 12, 11, 12, 11, 12, 50, 57, 54, 57, 54, 56, 55, 56, 54, 57,
54, 57, 53, 58, 51, 78, 103, 97, 101, 98, 100, 98, 99, 98, 99, 99, 99, 98, 99,
99, 99, 98, 99, 99, 99, 99, 98, 99, 98, 99, 98, 100, 97, 100, 97, 100, 96, 102,
87, 50, 56, 54, 55, 54, 54, 54, 54, 55, 55, 55, 54, 55, 54, 56, 53, 56, 53, 56,
53, 56, 52, 61, 38, 5, 14, 10, 12, 11, 11, 11, 11, 11, 11, 11, 11, 11, 11, 12,
11, 11, 11, 11, 11, 11, 12, 10, 12, 10, 13, 8, 17, -5, -39, -30, -34, -32, -33,
-33, -32, -32, -32, -33, -32, -33, -31, -33, -31, -33, -32, -33, -32, -31, -72,
-78, -74, -78, -75, -77, -74, -77, -75, -77, -75, -76, -75, -77, -75, -76, -76,
-76, -76, -76, -75, -76, -76, -76, -76, -76, -76, -76, -76, -75, -77, -75, -76,
-75, -75, -76, -76, -75, -76, -75, -76, -75, -76, -75, -76, -75, -76, -75, -77,
-75, -76, -74, -78, -72, -86, -127, -90, -72, -77, -75, -76, -74, -76, -75, -76,
-76, -76, -75, -76, -74, -76, -75, -76, -74, -76, -75, -76, -75, -76, -74, -76,
-74, -76, -74, -76, -74, -77, -73, -30, -32, -32, -31, -32, -31, -32, -32, -32,
-32, -32, -31, -32, -32, -33, -31, -32, -31, -32, -30, -33, -30, -34, -29, -37,
-11, 18, 9, 14, 11, 13, 12, 12, 12, 12, 12, 12, 13, 12, 12, 11, 12, 11, 12, 11,
13, 19, 20, 19, 21, 19, 20, 20, 19, 19, 20, 20, 21, 20, 20, 20, 24, 27, 26, 27,
27, 27, 27, 27, 27, 27, 26, 27, 27, 27, 27, 27, 27, 27, 28, 27, 27, 27, 26, 27,
26, 27, 27, 28, 28, 27, 27, 26, 28, 25, 18, 20, 19, 20, 19, 19, 19, 19, 20, 20,
20, 19, 19, 19, 19, 19, 19, 19, 19, 20, 19, 19, 21, 16, 10, 12, 12, 12, 11, 12,
12, 12, 12, 11, 11, 12, 12, 12, 12, 12, 12, 12, 11, 12, 11, 12, 12, 12, 11, 12,
12, 13, 8, 3, 5, 4, 4, 4, 5, 4, 5, 4, 4, 4, 4, 5, 4, 4, 5, 5, 4, 5, 4, -3, -3,
-3, -3, -3, -3, -3, -4, -3, -3, -3, -3, -3, -3, -3, -3, -4, -3, -4, -3, -4, -3,
-3, -3, -3, -3, -3, -2, -4, -3, -4, -3, -3, -2, -3, -3, -3, -3, -3, -3, -4, -3,
-4, -3, -3, -3, -4, -3, -4, -3, -4, -3, -3, -2, -6, -11, -5, -2, -4, -4, -4, -2,
-3, -4, -4, -3, -4, -3, -3, -3, -3, -3, -2, -2, -3, -3, -3, -3, -3, -3, -3, -3,
-2, -3, -3, -2, -3, -2, };