#define DATA_LENGTH 512
#define DATA AKWF_1178

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 3, 6, 11, 14, 16, 19, 22, 24,
27, 29, 31, 34, 36, 39, 42, 44, 45, 48, 51, 53, 55, 58, 60, 62, 63, 66, 68, 71,
73, 74, 76, 79, 80, 82, 84, 86, 88, 87, 82, 78, 73, 68, 63, 58, 53, 47, 42, 37,
29, 27, 27, 25, 24, 24, 23, 22, 21, 20, 19, 19, 19, 18, 17, 17, 18, 16, 12, 12,
11, 11, 12, 11, 12, 12, 12, 14, 14, 14, 14, 14, 16, 16, 16, 16, 16, 17, 16, 17,
18, 17, 17, 17, 16, 16, 15, 15, 13, 12, 11, 10, 9, 10, 13, 17, 21, 25, 29, 33,
36, 40, 43, 48, 53, 54, 52, 53, 52, 51, 50, 50, 49, 49, 48, 48, 47, 46, 46, 46,
45, 48, 50, 51, 52, 54, 55, 56, 57, 59, 60, 62, 64, 65, 67, 68, 70, 73, 75, 77,
80, 82, 84, 87, 90, 92, 95, 96, 99, 102, 105, 107, 109, 112, 115, 116, 119, 118,
114, 110, 107, 102, 100, 96, 92, 95, 97, 94, 88, 88, 88, 88, 87, 87, 86, 87, 86,
86, 86, 85, 84, 85, 84, 85, 85, 82, 77, 76, 74, 73, 71, 68, 67, 65, 64, 61, 62,
56, 59, 53, 56, 49, 53, 46, 50, 42, 48, 37, 46, 30, -49, -21, -40, -48, -53,
-61, -64, -73, -76, -83, -85, -89, -84, -86, -82, -82, -78, -77, -73, -72, -66,
-65, -57, -59, -59, -60, -60, -59, -60, -59, -60, -59, -58, -58, -58, -57, -57,
-55, -57, -53, -49, -48, -46, -43, -41, -40, -37, -36, -33, -31, -29, -27, -25,
-23, -22, -19, -18, -15, -13, -12, -10, -8, -7, -4, -3, -2, 1, 1, 4, 5, 6, 8, 9,
11, 13, 10, 5, 0, -4, -10, -16, -21, -26, -32, -38, -43, -52, -54, -54, -56,
-57, -59, -59, -61, -62, -64, -64, -65, -65, -66, -67, -67, -67, -70, -73, -74,
-75, -75, -75, -76, -76, -76, -75, -75, -75, -75, -75, -74, -74, -74, -73, -74,
-74, -73, -74, -74, -74, -74, -74, -75, -76, -77, -77, -78, -79, -80, -82, -84,
-85, -84, -79, -76, -72, -68, -65, -61, -59, -54, -51, -47, -42, -42, -43, -44,
-44, -45, -46, -46, -47, -48, -49, -49, -49, -50, -51, -50, -52, -50, -47, -46,
-44, -43, -42, -41, -40, -39, -37, -35, -34, -33, -31, -30, -28, -25, -23, -21,
-19, -16, -15, -12, -9, -6, -4, -2, 0, 3, 6, 8, 11, 13, 16, 18, 20, 19, 15, 11,
8, 3, 0, -5, -6, -4, -3, -6, -12, -12, -12, -12, -12, -12, -12, -13, -13, -13,
-13, -14, -14, -15, -15, -16, -15, -19, -23, -23, -26, -27, -29, -30, -33, -35,
-35, -37, -39, -41, -43, -45, -46, -48, -49, -50, -52, -53, -55, -56, -58, -59,
-61, -62, -63, -65, -66, -67, -69, -69, -71, -71, -73, -69, -66, -61, -56, -52,
-47, -42, -37, -31, -27, -21, -14, -13, -12, -11, -10, -8, -7, -6, -5, -4, -4,
-2, 0, };