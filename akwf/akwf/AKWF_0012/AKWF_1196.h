#define DATA_LENGTH 512
#define DATA AKWF_1196

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 13, 13, 15, 15, 17, 18, 19, 20,
21, 21, 23, 23, 25, 26, 28, 28, 29, 30, 31, 31, 32, 33, 33, 34, 35, 36, 35, 36,
37, 37, 37, 38, 38, 38, 40, 41, 41, 42, 42, 43, 43, 46, 47, 47, 48, 49, 50, 51,
52, 53, 52, 53, 55, 55, 55, 55, 56, 57, 57, 58, 58, 59, 59, 60, 61, 60, 60, 61,
60, 60, 60, 60, 62, 62, 61, 62, 60, 61, 61, 61, 62, 60, 61, 61, 62, 60, 61, 61,
61, 61, 60, 60, 59, 59, 59, 59, 59, 59, 58, 59, 58, 58, 59, 58, 57, 58, 58, 58,
58, 58, 59, 58, 59, 58, 59, 59, 60, 59, 61, 60, 62, 60, 63, 60, 63, 61, 65, 109,
112, 110, 112, 110, 112, 111, 113, 112, 113, 112, 113, 113, 113, 114, 115, 114,
116, 116, 116, 116, 117, 117, 118, 118, 118, 118, 119, 118, 119, 119, 120, 119,
118, 120, 119, 120, 118, 119, 118, 117, 117, 118, 117, 117, 116, 115, 116, 115,
114, 115, 113, 113, 113, 113, 112, 112, 111, 110, 111, 109, 109, 109, 107, 106,
104, 102, 101, 99, 98, 96, 95, 94, 93, 92, 91, 90, 89, 88, 87, 85, 84, 84, 82,
82, 81, 79, 78, 77, 76, 76, 75, 74, 73, 72, 72, 71, 70, 68, 68, 67, 66, 65, 65,
64, 64, 63, 62, 61, 60, 60, 58, 58, 57, 56, 56, 55, 53, 54, 52, 54, 51, 53, 49,
51, 47, 51, 43, -21, -23, -20, -23, -21, -23, -23, -25, -23, -25, -25, -26, -25,
-26, -26, -28, -28, -29, -28, -28, -29, -29, -30, -29, -29, -30, -31, -30, -31,
-31, -32, -31, -32, -31, -32, -33, -33, -33, -33, -34, -34, -34, -35, -36, -36,
-36, -36, -36, -36, -36, -36, -37, -37, -37, -37, -37, -39, -38, -38, -39, -39,
-39, -40, -39, -39, -40, -40, -41, -40, -40, -40, -41, -41, -41, -41, -41, -40,
-41, -42, -43, -43, -43, -43, -43, -42, -43, -42, -42, -43, -42, -42, -42, -42,
-43, -43, -42, -43, -43, -44, -44, -44, -45, -46, -45, -46, -45, -47, -47, -48,
-48, -48, -48, -49, -49, -50, -51, -52, -52, -53, -53, -52, -54, -52, -56, -51,
-85, -108, -102, -106, -103, -105, -104, -106, -104, -106, -105, -106, -106,
-107, -107, -107, -108, -107, -107, -107, -106, -106, -106, -105, -106, -105,
-105, -105, -105, -105, -105, -105, -106, -106, -106, -106, -106, -105, -105,
-105, -105, -104, -104, -104, -103, -101, -101, -100, -100, -99, -98, -97, -97,
-97, -96, -95, -95, -93, -93, -92, -92, -92, -91, -91, -91, -89, -89, -89, -89,
-89, -89, -89, -89, -89, -89, -89, -90, -90, -89, -89, -88, -88, -88, -89, -88,
-86, -86, -85, -84, -85, -84, -83, -82, -81, -80, -79, -78, -77, -78, -76, -76,
-74, -74, -73, -74, -72, -73, -72, -72, -71, -71, -70, -70, -69, -68, -67, -67,
-67, -66, -67, -65, -66, -64, -64, -63, -64, -61, -63, -58, -63, -48, };