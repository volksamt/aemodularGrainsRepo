#define DATA_LENGTH 512
#define DATA AKWF_1109

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 13, 17, 20, 24, 27, 29, 29, 29,
31, 33, 36, 38, 41, 43, 46, 49, 52, 54, 57, 60, 62, 66, 68, 70, 74, 76, 79, 81,
84, 87, 89, 91, 93, 96, 98, 100, 102, 103, 104, 106, 107, 110, 111, 112, 113,
115, 116, 118, 119, 118, 119, 118, 117, 115, 115, 114, 114, 114, 112, 110, 109,
108, 109, 109, 108, 107, 105, 104, 103, 104, 104, 104, 103, 101, 100, 99, 98,
97, 96, 94, 92, 89, 87, 85, 83, 83, 82, 79, 76, 73, 71, 69, 68, 66, 65, 61, 59,
57, 56, 55, 56, 55, 55, 55, 55, 55, 55, 56, 57, 57, 58, 58, 57, 58, 60, 62, 64,
64, 64, 65, 65, 64, 64, 63, 60, 59, 58, 57, 57, 57, 57, 56, 56, 55, 55, 55, 56,
56, 57, 57, 57, 59, 61, 65, 67, 69, 70, 70, 70, 72, 72, 72, 72, 72, 72, 71, 72,
73, 74, 75, 75, 76, 74, 74, 71, 69, 68, 67, 66, 64, 62, 59, 58, 59, 58, 57, 54,
52, 49, 46, 39, 33, 29, 25, 21, 19, 17, 17, 12, 9, 6, 2, -1, -5, -12, -15, -17,
-20, -22, -27, -29, -32, -38, -43, -46, -50, -55, -57, -60, -62, -63, -65, -66,
-68, -72, -77, -82, -84, -83, -84, -83, -84, -83, -83, -80, -79, -79, -79, -80,
-81, -81, -80, -78, -79, -78, -77, -77, -76, -74, -74, -72, -71, -70, -69, -70,
-69, -69, -69, -68, -66, -66, -65, -63, -60, -57, -55, -53, -51, -49, -47, -45,
-42, -40, -38, -36, -34, -30, -27, -23, -21, -20, -18, -17, -16, -15, -14, -14,
-16, -16, -16, -17, -18, -19, -20, -20, -21, -23, -24, -27, -29, -31, -34, -35,
-37, -38, -39, -41, -42, -41, -42, -41, -42, -42, -43, -45, -46, -47, -46, -48,
-49, -50, -52, -52, -53, -53, -54, -56, -59, -62, -66, -68, -71, -72, -73, -74,
-77, -79, -81, -81, -81, -82, -82, -86, -88, -93, -94, -94, -94, -96, -97, -98,
-99, -98, -97, -97, -96, -97, -98, -100, -99, -100, -99, -99, -99, -101, -101,
-104, -104, -105, -105, -103, -100, -99, -98, -95, -89, -85, -83, -82, -80, -74,
-73, -70, -69, -67, -67, -65, -61, -57, -56, -56, -54, -53, -51, -50, -49, -46,
-44, -43, -42, -41, -41, -42, -40, -35, -30, -31, -33, -33, -33, -33, -33, -33,
-32, -33, -33, -32, -31, -30, -29, -27, -24, -24, -23, -22, -23, -24, -25, -26,
-25, -25, -23, -23, -22, -23, -22, -21, -21, -23, -25, -28, -30, -34, -36, -37,
-38, -41, -44, -47, -49, -49, -51, -53, -57, -60, -64, -65, -69, -74, -76, -78,
-80, -79, -83, -86, -88, -89, -90, -90, -89, -90, -94, -96, -96, -97, -97, -95,
-94, -93, -90, -87, -86, -85, -86, -86, -86, -84, -84, -82, -81, -78, -73, -68,
-66, -62, -60, -57, -51, -49, -48, -46, -45, -43, -41, -36, -32, -30, -28, -25,
-22, -20, -17, -14, -13, -11, -10, -9, -7, -5, -2, };