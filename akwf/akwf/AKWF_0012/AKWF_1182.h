#define DATA_LENGTH 512
#define DATA AKWF_1182

const PROGMEM int8_t DATA[DATA_LENGTH] = {82, 93, 83, 97, 95, 105, 103, 110,
108, 115, 114, 118, 116, 118, 118, 119, 119, 119, 118, 118, 118, 118, 117, 116,
115, 114, 114, 112, 110, 109, 108, 109, 111, 110, 109, 107, 105, 103, 102, 101,
99, 98, 96, 94, 94, 93, 91, 91, 89, 88, 87, 86, 85, 84, 83, 84, 82, 81, 81, 80,
80, 80, 80, 78, 78, 77, 77, 76, 76, 76, 76, 76, 75, 75, 75, 74, 74, 74, 74, 74,
73, 73, 74, 74, 74, 74, 73, 73, 73, 72, 72, 73, 73, 73, 72, 73, 73, 72, 73, 71,
73, 72, 73, 72, 72, 72, 72, 72, 71, 71, 70, 71, 71, 70, 71, 71, 71, 71, 70, 71,
70, 70, 70, 71, 70, 70, 70, 69, 69, 69, 69, 69, 68, 69, 69, 68, 68, 69, 68, 68,
68, 68, 67, 68, 67, 67, 66, 66, 67, 66, 66, 66, 67, 66, 66, 66, 66, 65, 64, 64,
65, 65, 64, 64, 64, 63, 64, 64, 63, 64, 63, 63, 63, 63, 63, 63, 63, 63, 62, 62,
62, 62, 62, 62, 62, 62, 61, 62, 61, 61, 61, 61, 60, 60, 60, 60, 60, 60, 58, 54,
53, 50, 48, 46, 44, 42, 40, 39, 37, 35, 34, 33, 32, 32, 31, 30, 29, 30, 29, 29,
28, 29, 29, 29, 30, 30, 30, 30, 31, 32, 32, 33, 33, 35, 35, 36, 36, 38, 38, 38,
39, 39, 40, 41, 42, 42, 44, 43, 46, 45, 49, 46, 50, 46, 55, 23, -75, -85, -77,
-86, -87, -93, -93, -97, -97, -99, -99, -100, -100, -100, -101, -100, -100, -99,
-99, -97, -97, -95, -95, -93, -91, -89, -88, -86, -84, -83, -82, -80, -79, -77,
-75, -73, -73, -71, -69, -68, -68, -66, -66, -64, -63, -63, -62, -60, -60, -59,
-59, -58, -57, -57, -56, -56, -55, -55, -56, -54, -55, -54, -54, -54, -55, -54,
-54, -54, -54, -55, -55, -55, -55, -56, -56, -55, -56, -56, -56, -57, -57, -58,
-57, -58, -58, -58, -60, -60, -59, -60, -61, -61, -62, -61, -63, -68, -69, -72,
-74, -76, -78, -81, -82, -85, -87, -88, -90, -91, -92, -93, -94, -94, -95, -96,
-96, -96, -97, -97, -96, -97, -96, -95, -96, -95, -95, -94, -94, -93, -93, -92,
-92, -91, -90, -89, -88, -88, -88, -86, -86, -85, -84, -84, -82, -81, -80, -80,
-79, -79, -78, -76, -76, -75, -76, -74, -73, -72, -72, -71, -71, -70, -70, -68,
-69, -68, -67, -67, -67, -66, -65, -65, -64, -64, -63, -63, -63, -62, -62, -62,
-62, -62, -61, -61, -61, -61, -60, -60, -60, -60, -60, -59, -59, -60, -59, -60,
-60, -60, -59, -60, -60, -59, -60, -59, -59, -59, -58, -58, -57, -57, -57, -56,
-56, -54, -55, -55, -54, -55, -53, -54, -53, -53, -52, -53, -52, -51, -51, -51,
-51, -51, -51, -51, -50, -50, -49, -50, -49, -50, -49, -49, -49, -49, -47, -47,
-48, -47, -47, -46, -47, -45, -47, -44, -46, -44, -47, -43, -48, -26, };