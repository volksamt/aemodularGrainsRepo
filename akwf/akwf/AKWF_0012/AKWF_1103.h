#define DATA_LENGTH 512
#define DATA AKWF_1103

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 90, 108, 102, 108, 106, 111, 109,
113, 111, 113, 112, 113, 112, 114, 115, 116, 115, 117, 117, 118, 120, 119, 118,
116, 114, 109, 106, 103, 100, 94, 90, 84, 81, 78, 75, 72, 70, 68, 66, 62, 60,
57, 56, 53, 51, 50, 48, 46, 45, 45, 44, 43, 44, 43, 43, 43, 41, 39, 37, 35, 34,
32, 32, 30, 28, 28, 26, 26, 26, 27, 29, 29, 29, 30, 30, 30, 31, 32, 32, 32, 32,
32, 32, 31, 32, 32, 33, 32, 33, 32, 29, 28, 25, 24, 22, 19, 17, 13, 10, 6, 2,
-3, -7, -12, -18, -24, -29, -34, -38, -42, -44, -45, -47, -48, -51, -53, -55,
-56, -58, -60, -62, -64, -64, -65, -65, -64, -64, -63, -61, -59, -58, -56, -54,
-52, -50, -49, -46, -43, -40, -38, -36, -34, -32, -31, -28, -26, -23, -23, -20,
-18, -16, -14, -11, -10, -9, -7, -6, -5, -4, -4, -3, -2, -1, 0, -1, 0, 0, -1,
-1, -2, -2, -2, -3, -5, -5, -4, -3, -1, -1, 2, 3, 3, 4, 5, 4, 4, 3, 4, 5, 5, 5,
5, 5, 5, 5, 6, 6, 7, 8, 10, 11, 12, 14, 16, 16, 16, 16, 16, 18, 20, 22, 24, 26,
28, 31, 32, 34, 35, 37, 39, 40, 41, 41, 41, 41, 39, 38, 36, 34, 31, 27, 23, 19,
17, 14, 12, 10, 9, 8, 7, 5, 4, 2, 0, -1, -4, -8, -8, -10, -10, -11, -11, -10,
-10, -7, -5, -1, 3, 6, 11, 15, 22, 26, 30, 32, 35, 35, 36, 34, 31, 29, 27, 25,
22, 20, 19, 16, 15, 15, 13, 12, 9, 6, 3, 2, 0, -4, -5, -6, -7, -8, -8, -8, -7,
-6, -4, -4, -4, -4, -4, -4, -3, -5, -5, -4, -1, -2, 0, 1, 2, 2, 2, 1, 0, -1, -1,
-2, -3, -3, -4, -5, -5, -6, -7, -7, -6, -6, -7, -8, -9, -11, -14, -17, -20, -24,
-26, -28, -30, -31, -32, -31, -32, -31, -32, -33, -34, -36, -35, -38, -38, -41,
-42, -45, -48, -52, -55, -57, -59, -60, -61, -62, -62, -62, -64, -66, -67, -68,
-67, -67, -67, -67, -69, -69, -69, -68, -67, -65, -64, -63, -64, -65, -66, -64,
-63, -62, -61, -59, -56, -54, -51, -50, -46, -44, -41, -38, -37, -34, -32, -32,
-32, -32, -32, -34, -34, -35, -36, -37, -39, -40, -41, -40, -40, -39, -38, -36,
-34, -32, -29, -28, -27, -24, -23, -23, -23, -24, -24, -23, -21, -20, -18, -16,
-13, -12, -12, -10, -11, -10, -11, -11, -11, -10, -8, -8, -7, -3, 0, 4, 7, 9,
11, 13, 14, 15, 16, 17, 17, 17, 16, 14, 12, 10, 9, 6, 3, -1, -5, -8, -11, -12,
-11, -11, -11, -11, -11, -13, -16, -19, -20, -21, -21, -23, -23, -26, -26, -27,
-29, -29, -30, -30, -31, -30, -31, -29, -28, -25, -23, -20, -21, -20, -20, -20,
-19, -17, -17, -18, -18, -18, -19, -19, -17, -18, };