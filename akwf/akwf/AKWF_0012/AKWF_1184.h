#define DATA_LENGTH 512
#define DATA AKWF_1184

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 27, 42, 57, 70, 82, 93, 103, 110,
116, 118, 119, 117, 114, 108, 102, 92, 82, 72, 61, 48, 37, 26, 15, 3, -6, -14,
-21, -26, -30, -33, -33, -31, -28, -24, -17, -9, -1, 9, 20, 29, 37, 45, 52, 57,
59, 61, 61, 60, 57, 55, 50, 45, 40, 36, 30, 24, 20, 14, 9, 4, -1, -6, -11, -15,
-19, -24, -27, -30, -31, -32, -34, -36, -37, -38, -39, -40, -41, -43, -43, -44,
-43, -43, -42, -41, -38, -37, -35, -33, -31, -29, -27, -25, -23, -21, -19, -18,
-17, -16, -16, -14, -14, -14, -16, -18, -21, -26, -31, -38, -46, -54, -61, -69,
-76, -82, -86, -89, -90, -89, -86, -81, -73, -64, -53, -41, -28, -14, 0, 15, 30,
44, 58, 70, 83, 92, 102, 109, 113, 116, 116, 113, 109, 102, 94, 84, 73, 62, 49,
38, 25, 12, 1, -10, -20, -29, -37, -42, -47, -51, -50, -50, -46, -42, -35, -27,
-18, -7, 3, 13, 21, 30, 36, 42, 47, 49, 49, 50, 48, 46, 43, 40, 38, 33, 30, 25,
23, 19, 16, 12, 9, 6, 2, 0, -4, -5, -7, -9, -10, -11, -10, -11, -12, -11, -11,
-13, -13, -14, -13, -14, -14, -13, -13, -11, -10, -9, -7, -5, -4, -2, -1, 0, 1,
2, 2, 2, 3, 2, 3, 2, 2, 0, -1, -5, -10, -16, -23, -30, -39, -48, -57, -65, -73,
-79, -84, -88, -88, -89, -85, -80, -73, -64, -54, -42, -29, -15, 0, 13, 29, 43,
57, 70, 81, 93, 102, 109, 114, 115, 117, 115, 110, 104, 96, 87, 78, 67, 55, 44,
32, 19, 9, -1, -11, -20, -27, -32, -36, -37, -39, -37, -33, -28, -22, -14, -5,
6, 15, 24, 32, 40, 45, 51, 53, 55, 55, 54, 51, 48, 43, 39, 35, 30, 24, 19, 14,
9, 3, -1, -7, -12, -15, -20, -24, -27, -30, -33, -36, -36, -38, -40, -41, -42,
-43, -44, -45, -46, -47, -47, -46, -46, -44, -42, -41, -39, -36, -34, -32, -30,
-28, -26, -23, -23, -21, -19, -17, -17, -15, -14, -14, -14, -16, -18, -22, -26,
-32, -38, -46, -54, -62, -70, -77, -82, -87, -88, -89, -87, -84, -79, -71, -62,
-51, -39, -26, -11, 4, 18, 33, 46, 60, 73, 85, 95, 104, 110, 114, 116, 115, 114,
108, 102, 94, 84, 73, 60, 48, 36, 23, 11, 0, -13, -22, -31, -38, -44, -49, -52,
-51, -50, -47, -42, -36, -28, -19, -9, 1, 11, 20, 27, 34, 39, 44, 45, 46, 46,
44, 43, 40, 37, 33, 29, 25, 21, 17, 14, 10, 7, 3, 0, -3, -6, -9, -11, -13, -14,
-15, -16, -17, -17, -17, -18, -18, -19, -20, -20, -19, -20, -20, -18, -18, -17,
-15, -14, -12, -11, -9, -8, -6, -5, -4, -4, -2, -3, -2, -1, -2, -2, -2, -5, -6,
-10, -13, -19, -27, -34, -43, -51, -60, -68, -76, -82, -87, -90, -90, -89, -86,
-81, -73, -64, -54, -41, -28, -13, 0, };