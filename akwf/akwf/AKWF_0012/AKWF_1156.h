#define DATA_LENGTH 512
#define DATA AKWF_1156

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 7, 11, 14, 17, 22, 26, 30, 35,
37, 42, 46, 49, 54, 58, 62, 66, 69, 73, 77, 80, 83, 86, 89, 93, 96, 98, 100,
103, 106, 108, 109, 110, 113, 114, 116, 117, 117, 118, 118, 119, 119, 119, 120,
119, 118, 118, 118, 116, 116, 115, 113, 111, 111, 109, 107, 106, 104, 101, 100,
97, 95, 93, 90, 88, 85, 83, 80, 77, 75, 71, 69, 66, 63, 61, 56, 54, 50, 48, 45,
41, 38, 35, 32, 28, 25, 22, 19, 16, 13, 10, 6, 3, 1, -2, -5, -9, -11, -13, -15,
-18, -21, -22, -25, -26, -29, -29, -31, -33, -35, -35, -36, -37, -37, -38, -39,
-38, -38, -38, -38, -36, -36, -35, -34, -33, -31, -29, -28, -26, -24, -22, -19,
-17, -14, -11, -9, -6, -3, 0, 3, 7, 11, 14, 17, 21, 25, 28, 31, 35, 38, 42, 46,
49, 53, 56, 60, 63, 67, 69, 73, 76, 79, 83, 85, 88, 90, 93, 95, 98, 99, 102,
104, 106, 106, 108, 110, 111, 113, 113, 114, 116, 116, 115, 116, 116, 116, 117,
116, 116, 114, 113, 113, 112, 111, 109, 108, 107, 104, 103, 100, 98, 95, 93, 90,
87, 85, 82, 79, 76, 72, 68, 65, 62, 58, 55, 51, 46, 42, 39, 34, 30, 26, 21, 16,
13, 8, 5, -1, -4, -9, -14, -18, -23, -27, -31, -35, -39, -44, -48, -52, -55,
-59, -62, -66, -70, -73, -77, -80, -83, -85, -87, -90, -93, -95, -98, -100,
-101, -102, -104, -106, -107, -107, -109, -110, -110, -110, -111, -112, -111,
-110, -111, -110, -110, -109, -107, -106, -105, -104, -102, -102, -100, -98,
-95, -94, -92, -90, -88, -86, -83, -80, -78, -76, -73, -70, -68, -65, -62, -59,
-56, -54, -51, -48, -45, -43, -39, -36, -34, -31, -28, -26, -23, -21, -17, -15,
-13, -10, -8, -6, -4, 0, 1, 3, 5, 7, 9, 10, 11, 13, 15, 15, 17, 18, 19, 19, 20,
21, 22, 22, 23, 21, 22, 22, 21, 20, 21, 20, 19, 19, 18, 17, 16, 14, 13, 11, 11,
9, 7, 4, 3, 2, 0, -2, -5, -6, -10, -11, -14, -16, -18, -21, -24, -27, -28, -31,
-33, -35, -38, -41, -42, -45, -47, -50, -51, -54, -56, -58, -60, -62, -65, -66,
-69, -70, -71, -72, -74, -75, -76, -78, -80, -80, -82, -82, -83, -83, -84, -85,
-85, -86, -86, -85, -86, -86, -85, -86, -85, -84, -84, -83, -83, -81, -81, -81,
-78, -78, -76, -76, -74, -74, -73, -71, -70, -68, -66, -64, -63, -62, -60, -58,
-56, -54, -53, -52, -49, -48, -46, -44, -42, -40, -39, -37, -36, -34, -32, -31,
-30, -28, -27, -25, -25, -22, -22, -21, -20, -19, -18, -17, -17, -16, -16, -14,
-15, -14, -14, -15, -14, -14, -15, -15, -16, -16, -17, -18, -18, -20, -20, -22,
-23, -24, -25, -27, -29, -28, -29, -30, -30, -30, -29, -29, -28, -27, -25, -24,
-22, -21, -19, -16, -14, -11, -8, -5, -2, };