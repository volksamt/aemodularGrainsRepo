#define DATA_LENGTH 512
#define DATA AKWF_1131

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -1, 4, -2, 31, 49, 42, 47, 44, 47,
44, 47, 45, 48, 46, 47, 47, 48, 47, 48, 48, 49, 48, 48, 49, 48, 49, 49, 49, 50,
50, 49, 50, 51, 51, 50, 51, 51, 52, 52, 51, 52, 52, 53, 52, 53, 53, 53, 53, 54,
54, 54, 54, 54, 55, 55, 55, 55, 54, 56, 55, 56, 55, 56, 56, 56, 56, 57, 57, 57,
57, 57, 57, 58, 58, 58, 59, 58, 58, 59, 59, 59, 60, 60, 59, 61, 61, 61, 60, 61,
61, 61, 61, 62, 62, 62, 62, 63, 62, 62, 63, 63, 64, 64, 64, 64, 65, 65, 65, 64,
65, 65, 66, 66, 66, 66, 67, 66, 67, 66, 67, 67, 68, 67, 67, 69, 68, 68, 69, 69,
69, 69, 68, 69, 69, 68, 69, 69, 69, 68, 68, 67, 66, 66, 66, 66, 66, 66, 66, 66,
65, 65, 65, 65, 65, 65, 65, 65, 64, 64, 64, 63, 63, 63, 63, 62, 63, 63, 62, 62,
62, 62, 61, 61, 60, 61, 60, 61, 61, 59, 59, 60, 60, 59, 59, 59, 58, 58, 58, 58,
58, 57, 57, 57, 58, 56, 57, 56, 56, 56, 55, 56, 55, 55, 55, 55, 55, 54, 54, 54,
53, 53, 53, 52, 53, 53, 53, 52, 52, 52, 52, 51, 50, 51, 51, 51, 49, 50, 50, 50,
50, 49, 49, 49, 49, 49, 48, 49, 48, 48, 48, 47, 47, 47, 46, 47, 46, 46, 46, 46,
45, 45, 45, 45, 45, 44, 43, 44, 44, 43, 44, 42, 44, 42, 44, 41, 44, 39, 48, 23,
-14, -7, -12, -10, -13, -13, -15, -15, -16, -17, -18, -19, -20, -21, -22, -23,
-23, -25, -26, -27, -28, -29, -29, -31, -32, -33, -34, -35, -35, -37, -36, -38,
-39, -40, -41, -42, -44, -44, -45, -45, -47, -47, -48, -49, -50, -51, -52, -53,
-54, -55, -57, -57, -58, -58, -60, -60, -62, -63, -63, -65, -65, -66, -67, -68,
-69, -70, -71, -72, -72, -73, -75, -75, -77, -76, -79, -79, -81, -81, -82, -83,
-84, -84, -85, -86, -88, -88, -89, -90, -92, -92, -93, -95, -94, -96, -97, -97,
-99, -100, -101, -101, -103, -102, -104, -105, -107, -108, -108, -109, -110,
-112, -112, -113, -113, -115, -115, -117, -117, -118, -119, -119, -118, -117,
-116, -114, -114, -113, -112, -111, -109, -109, -107, -106, -106, -105, -104,
-103, -102, -101, -100, -99, -98, -96, -95, -95, -94, -93, -92, -91, -90, -89,
-88, -87, -87, -85, -84, -84, -83, -81, -80, -79, -79, -78, -77, -75, -75, -74,
-73, -72, -71, -70, -68, -68, -67, -66, -65, -64, -62, -63, -61, -60, -59, -58,
-57, -56, -55, -54, -53, -52, -51, -51, -49, -49, -47, -46, -45, -44, -44, -42,
-41, -40, -40, -39, -38, -37, -37, -35, -34, -33, -32, -31, -30, -29, -29, -27,
-27, -25, -25, -24, -23, -22, -21, -20, -19, -17, -17, -16, -15, -14, -14, -13,
-11, -11, -9, -9, -7, -7, -5, -4, -4, -3, -2, -1, };