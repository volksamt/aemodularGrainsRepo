#define DATA_LENGTH 512
#define DATA AKWF_1175

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 4, 3, 5, 5, 6, 9, 12, 15, 19, 21,
23, 26, 28, 31, 33, 34, 37, 39, 41, 43, 46, 47, 48, 50, 51, 52, 55, 55, 57, 58,
60, 61, 63, 63, 65, 67, 67, 68, 70, 71, 73, 73, 74, 75, 77, 77, 79, 80, 80, 82,
83, 83, 85, 85, 88, 86, 90, 87, 95, 80, 61, 69, 67, 70, 69, 69, 68, 67, 65, 64,
65, 62, 63, 62, 61, 60, 60, 58, 59, 58, 57, 57, 57, 58, 57, 57, 56, 56, 56, 55,
55, 56, 56, 56, 55, 55, 56, 56, 56, 55, 56, 55, 56, 54, 53, 53, 53, 54, 54, 53,
53, 52, 54, 53, 52, 54, 53, 53, 53, 53, 52, 52, 52, 53, 53, 52, 53, 52, 52, 52,
52, 52, 52, 52, 52, 52, 53, 52, 52, 52, 51, 52, 52, 52, 52, 52, 51, 52, 51, 52,
51, 52, 48, 42, 44, 43, 44, 43, 43, 43, 41, 42, 40, 40, 39, 39, 39, 38, 37, 37,
36, 37, 36, 36, 36, 35, 34, 35, 33, 35, 33, 33, 33, 33, 32, 33, 32, 32, 32, 31,
32, 31, 31, 30, 30, 30, 28, 28, 27, 27, 27, 27, 27, 27, 25, 26, 26, 24, 24, 25,
24, 24, 24, 23, 23, 24, 22, 23, 22, 22, 21, 21, 21, 21, 21, 20, 20, 20, 20, 21,
20, 20, 20, 19, 19, 18, 18, 19, 18, 18, 18, 18, 17, 17, 17, 16, 15, 15, 15, 14,
15, 14, 14, 14, 13, 13, 12, 13, 12, 12, 12, 11, 12, 11, 11, 10, 10, 11, 10, 9,
9, 10, 9, 9, 9, 8, 8, 8, 8, 8, 8, 8, 8, 7, 6, 7, 7, 6, 8, 5, -3, -2, -1, -2, -2,
-3, -3, -4, -5, -6, -6, -7, -7, -8, -8, -9, -9, -11, -10, -11, -11, -12, -12,
-13, -13, -14, -14, -14, -15, -15, -16, -17, -16, -17, -18, -17, -17, -17, -18,
-19, -19, -19, -20, -20, -20, -21, -21, -22, -21, -21, -22, -22, -24, -24, -24,
-24, -25, -25, -26, -26, -26, -27, -27, -28, -28, -28, -28, -28, -29, -29, -29,
-30, -30, -31, -30, -31, -31, -31, -32, -32, -32, -32, -33, -32, -33, -33, -33,
-33, -34, -33, -36, -33, -36, -32, -46, -66, -60, -62, -61, -63, -64, -66, -68,
-70, -72, -73, -76, -78, -79, -80, -82, -84, -85, -87, -88, -89, -91, -91, -92,
-94, -94, -96, -97, -98, -99, -100, -101, -101, -103, -103, -104, -105, -105,
-106, -107, -108, -110, -109, -110, -111, -112, -112, -114, -113, -115, -115,
-118, -115, -118, -115, -123, -109, -75, -85, -83, -85, -84, -84, -82, -79, -77,
-75, -73, -71, -71, -68, -67, -65, -64, -61, -61, -59, -59, -58, -57, -56, -56,
-54, -54, -52, -53, -52, -52, -50, -50, -49, -48, -48, -47, -47, -46, -47, -45,
-45, -44, -44, -44, -43, -43, -42, -41, -41, -41, -40, -40, -39, -39, -39, -38,
-38, -37, -37, -36, -37, -36, -36, -34, -36, -34, -37, -29, };