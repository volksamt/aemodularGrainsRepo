#define DATA_LENGTH 512
#define DATA AKWF_1145

const PROGMEM int8_t DATA[DATA_LENGTH] = {92, 107, 99, 106, 100, 106, 101, 106,
103, 105, 103, 106, 104, 106, 105, 107, 105, 107, 106, 107, 106, 107, 107, 108,
107, 108, 108, 108, 108, 108, 108, 108, 109, 109, 109, 109, 109, 110, 109, 110,
110, 110, 110, 110, 110, 111, 111, 110, 111, 112, 111, 111, 112, 112, 111, 113,
112, 112, 113, 113, 113, 113, 114, 113, 114, 115, 115, 114, 115, 116, 115, 115,
116, 116, 117, 115, 116, 116, 116, 117, 116, 117, 117, 118, 117, 118, 118, 118,
118, 118, 117, 118, 118, 119, 118, 120, 116, 113, 114, 113, 112, 112, 112, 110,
110, 109, 108, 108, 107, 107, 106, 105, 106, 104, 105, 104, 103, 103, 102, 101,
100, 99, 99, 99, 98, 98, 97, 96, 97, 95, 95, 95, 94, 93, 93, 92, 92, 91, 90, 90,
89, 89, 88, 87, 87, 87, 87, 86, 85, 84, 84, 84, 83, 83, 83, 82, 81, 80, 80, 80,
79, 79, 78, 77, 76, 77, 76, 75, 75, 75, 73, 73, 73, 72, 72, 72, 71, 70, 69, 69,
69, 68, 67, 67, 66, 67, 66, 66, 64, 64, 63, 63, 63, 62, 63, 61, 61, 61, 60, 60,
59, 58, 58, 58, 58, 56, 56, 56, 56, 54, 55, 54, 53, 54, 52, 51, 52, 51, 50, 52,
49, 53, 44, 58, -2, -40, -26, -35, -29, -33, -30, -32, -30, -32, -31, -32, -31,
-31, -31, -32, -31, -32, -31, -31, -32, -32, -31, -33, -30, -33, -30, -33, -30,
-33, -28, -38, -104, -104, -103, -105, -103, -105, -103, -105, -103, -106, -102,
-105, -104, -105, -103, -104, -103, -105, -104, -103, -104, -105, -103, -104,
-104, -105, -104, -103, -104, -104, -104, -103, -104, -103, -103, -103, -104,
-104, -103, -104, -103, -103, -103, -103, -103, -103, -102, -103, -103, -103,
-102, -103, -103, -102, -102, -103, -103, -102, -102, -102, -102, -102, -102,
-102, -102, -101, -102, -101, -101, -101, -100, -101, -101, -100, -101, -100,
-100, -100, -101, -99, -100, -100, -99, -100, -99, -99, -99, -99, -99, -99, -99,
-98, -98, -97, -98, -98, -97, -97, -96, -96, -96, -95, -95, -95, -94, -94, -93,
-93, -92, -91, -91, -91, -91, -91, -89, -89, -89, -88, -88, -88, -88, -87, -86,
-86, -86, -85, -84, -84, -84, -83, -83, -83, -82, -82, -82, -81, -81, -81, -80,
-80, -79, -79, -79, -78, -77, -77, -77, -76, -75, -76, -75, -75, -74, -73, -74,
-73, -74, -73, -73, -71, -72, -71, -72, -70, -70, -70, -70, -68, -69, -69, -68,
-68, -67, -67, -67, -67, -66, -66, -65, -65, -64, -64, -64, -63, -63, -63, -63,
-63, -62, -62, -61, -61, -60, -60, -60, -60, -59, -59, -59, -59, -59, -58, -58,
-58, -57, -57, -57, -55, -56, -56, -55, -55, -55, -54, -53, -52, -53, -53, -52,
-53, -52, -51, -50, -54, -30, -23, -27, -25, -27, -25, -25, -25, -25, -25, -26,
-25, -26, -25, -25, -25, -26, -26, -25, -25, -26, -25, -26, -25, -26, -25, -26,
-25, -25, -26, -27, -16, };