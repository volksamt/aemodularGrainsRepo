#define DATA_LENGTH 512
#define DATA AKWF_1142

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 3, 5, 6, 8, 9, 9, 11, 12, 13,
15, 15, 16, 16, 18, 19, 20, 21, 21, 23, 23, 24, 25, 26, 27, 28, 28, 29, 30, 31,
32, 32, 32, 33, 35, 35, 36, 36, 36, 38, 39, 39, 40, 40, 41, 41, 41, 42, 44, 43,
44, 45, 45, 46, 46, 47, 48, 48, 48, 49, 49, 50, 50, 51, 52, 51, 53, 52, 52, 53,
53, 54, 54, 54, 55, 56, 55, 56, 56, 57, 57, 57, 58, 58, 58, 58, 59, 59, 60, 60,
60, 61, 60, 61, 61, 61, 62, 62, 62, 62, 62, 63, 63, 64, 63, 64, 64, 64, 64, 64,
64, 65, 65, 65, 64, 65, 69, 70, 71, 72, 73, 73, 74, 74, 76, 76, 77, 77, 77, 77,
78, 79, 79, 79, 79, 79, 81, 79, 81, 80, 81, 82, 81, 81, 81, 81, 81, 81, 82, 82,
81, 82, 82, 82, 82, 82, 81, 82, 82, 81, 82, 81, 81, 81, 81, 81, 80, 80, 80, 80,
80, 80, 80, 79, 79, 79, 79, 78, 79, 78, 77, 76, 77, 77, 76, 75, 76, 75, 74, 74,
73, 73, 73, 72, 72, 72, 70, 70, 70, 69, 69, 68, 67, 66, 66, 65, 64, 61, 58, 57,
55, 53, 52, 52, 51, 50, 49, 48, 48, 46, 45, 44, 44, 43, 42, 41, 40, 39, 39, 39,
37, 36, 36, 35, 34, 34, 33, 32, 31, 31, 30, 30, 29, 28, 28, 26, 27, 26, 24, 25,
24, 23, 22, 22, 21, 21, 20, 20, 18, 18, 18, 18, 16, 15, 15, 15, 13, 13, 12, 12,
11, 10, 9, 9, 9, 9, 7, 7, 5, 2, 1, -2, -2, -3, -4, -4, -7, -6, -8, -8, -9, -11,
-11, -13, -13, -11, -12, -12, -13, -14, -14, -14, -15, -16, -16, -16, -17, -17,
-18, -19, -19, -20, -20, -20, -21, -22, -21, -22, -22, -23, -24, -24, -24, -25,
-25, -25, -26, -27, -27, -28, -28, -29, -29, -29, -30, -30, -31, -38, -40, -42,
-44, -45, -47, -49, -49, -51, -52, -52, -54, -55, -56, -56, -57, -58, -59, -59,
-59, -60, -61, -65, -69, -71, -71, -76, -81, -83, -85, -86, -89, -90, -92, -93,
-95, -96, -97, -99, -100, -100, -103, -103, -105, -106, -106, -107, -108, -109,
-110, -111, -112, -111, -113, -114, -114, -114, -115, -116, -116, -117, -117,
-117, -118, -117, -118, -118, -119, -118, -118, -118, -119, -119, -119, -119,
-119, -118, -118, -118, -119, -119, -117, -118, -117, -117, -116, -117, -115,
-116, -114, -115, -113, -115, -105, -86, -86, -82, -83, -83, -82, -81, -81, -80,
-79, -79, -79, -77, -77, -77, -79, -81, -81, -81, -81, -81, -81, -81, -80, -79,
-79, -78, -77, -76, -76, -75, -74, -73, -72, -71, -70, -68, -68, -67, -66, -64,
-63, -62, -62, -60, -56, -54, -53, -51, -49, -47, -47, -44, -43, -41, -40, -39,
-36, -31, -29, -27, -25, -24, -21, -20, -18, -17, -16, -14, -13, -11, -10, -9,
-8, -6, -5, -4, -2, -1, -1, };