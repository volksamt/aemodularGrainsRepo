#define DATA_LENGTH 512
#define DATA AKWF_1108

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 7, 8, 9, 11, 12, 14, 15, 16,
18, 20, 22, 24, 25, 27, 29, 28, 29, 29, 28, 28, 27, 27, 27, 26, 26, 26, 27, 26,
27, 26, 26, 25, 26, 25, 25, 25, 27, 28, 29, 32, 33, 37, 38, 39, 41, 42, 41, 43,
42, 44, 45, 46, 47, 47, 48, 49, 50, 50, 51, 51, 52, 51, 49, 47, 45, 45, 44, 45,
44, 43, 41, 41, 41, 40, 39, 38, 37, 37, 36, 36, 35, 34, 33, 32, 30, 29, 28, 27,
26, 25, 26, 25, 25, 24, 24, 25, 25, 24, 24, 25, 26, 25, 26, 25, 27, 27, 28, 30,
31, 33, 35, 36, 38, 40, 42, 45, 46, 47, 49, 51, 51, 53, 55, 56, 57, 58, 59, 60,
60, 60, 60, 60, 60, 61, 61, 62, 63, 64, 65, 66, 66, 67, 67, 66, 66, 67, 67, 68,
69, 69, 70, 72, 72, 74, 75, 75, 75, 76, 76, 75, 74, 74, 73, 73, 72, 70, 68, 65,
63, 61, 58, 56, 54, 51, 48, 46, 44, 42, 40, 39, 37, 35, 34, 33, 33, 32, 32, 32,
29, 26, 24, 22, 19, 18, 18, 18, 15, 15, 15, 13, 13, 12, 11, 12, 10, 8, 5, 3, 1,
-2, -4, -5, -7, -8, -11, -12, -14, -17, -19, -20, -22, -23, -26, -27, -27, -29,
-30, -29, -29, -28, -28, -28, -28, -29, -29, -31, -31, -32, -32, -33, -34, -35,
-34, -33, -34, -35, -35, -36, -36, -38, -40, -43, -45, -45, -48, -50, -52, -54,
-55, -55, -57, -59, -60, -62, -63, -64, -66, -68, -70, -71, -71, -73, -73, -73,
-72, -73, -71, -70, -71, -71, -71, -71, -71, -71, -70, -70, -69, -68, -69, -71,
-70, -71, -71, -72, -74, -76, -78, -79, -81, -84, -85, -86, -87, -87, -88, -90,
-90, -90, -91, -92, -91, -93, -93, -94, -95, -94, -94, -94, -94, -92, -90, -89,
-89, -88, -87, -86, -84, -84, -84, -83, -83, -82, -82, -81, -80, -79, -78, -78,
-77, -75, -74, -73, -72, -71, -70, -69, -69, -68, -68, -68, -68, -69, -68, -68,
-68, -67, -67, -68, -69, -69, -70, -72, -73, -74, -76, -77, -79, -81, -83, -85,
-86, -88, -91, -92, -94, -95, -96, -98, -99, -101, -102, -103, -104, -103, -103,
-104, -104, -104, -104, -105, -105, -107, -107, -108, -108, -109, -109, -110,
-110, -110, -112, -112, -112, -113, -114, -114, -114, -115, -118, -117, -118,
-119, -119, -119, -118, -118, -118, -118, -118, -116, -116, -114, -111, -110,
-108, -105, -102, -100, -97, -94, -92, -90, -88, -85, -85, -82, -81, -79, -78,
-76, -76, -76, -75, -75, -73, -70, -68, -68, -65, -62, -58, -57, -56, -57, -57,
-57, -55, -56, -55, -56, -55, -51, -49, -46, -44, -42, -40, -39, -37, -35, -33,
-31, -30, -28, -26, -24, -23, -21, -19, -18, -17, -15, -14, -14, -15, -16, -16,
-16, -15, -14, -14, -14, -13, -13, -12, -11, -10, -9, -9, -9, -9, -9, -9, -8,
-7, -6, -4, -2, -1, };