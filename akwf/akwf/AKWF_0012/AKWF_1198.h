#define DATA_LENGTH 512
#define DATA AKWF_1198

const PROGMEM int8_t DATA[DATA_LENGTH] = {18, 27, 24, 27, 25, 27, 24, 42, 46,
46, 46, 46, 45, 47, 44, 55, 75, 72, 73, 73, 73, 73, 71, 75, 102, 103, 102, 102,
102, 103, 102, 103, 102, 103, 102, 103, 102, 103, 101, 103, 101, 105, 118, 118,
117, 118, 117, 118, 117, 118, 117, 118, 117, 118, 118, 117, 117, 117, 118, 117,
117, 117, 117, 117, 117, 117, 118, 116, 118, 115, 120, 94, 67, 71, 69, 72, 72,
73, 72, 72, 71, 70, 70, 70, 70, 70, 69, 70, 70, 70, 69, 72, 54, 40, 45, 42, 44,
42, 44, 42, 51, 57, 57, 56, 57, 57, 56, 56, 56, 57, 56, 57, 56, 57, 55, 58, 38,
27, 30, 29, 30, 29, 30, 28, 29, 29, 30, 30, 30, 29, 30, 29, 29, 31, 29, 41, 46,
44, 45, 44, 45, 45, 45, 46, 48, 47, 48, 47, 48, 47, 48, 48, 47, 46, 42, 43, 42,
44, 40, 45, 32, 14, 16, 15, 15, 16, 15, 16, 14, 18, 32, 31, 31, 28, 30, 27, 33,
14, -4, 1, -2, -1, -2, 0, -1, 0, -2, -1, -2, -1, -1, -2, -1, -1, -1, -5, -1, -3,
1, -27, -51, -46, -50, -47, -48, -47, -49, -48, -48, -48, -48, -48, -48, -47,
-48, -47, -48, -48, -49, -48, -48, -48, -48, -48, -45, -71, -79, -77, -70, -59,
-63, -60, -62, -61, -62, -62, -61, -62, -61, -62, -61, -63, -49, -32, -36, -34,
-35, -34, -35, -32, -32, -32, -32, -33, -31, -34, -10, -3, -5, -4, -5, -5, -6,
9, 14, 13, 13, 13, 12, 14, 11, 25, 43, 38, 41, 40, 40, 40, 41, 40, 40, 39, 40,
40, 40, 40, 40, 40, 39, 40, 40, 40, 39, 41, 39, 41, 39, 44, 56, 55, 54, 52, 52,
53, 53, 52, 53, 52, 53, 51, 53, 52, 53, 51, 23, 22, 23, 23, 24, 23, 23, 22, 23,
22, 24, 20, 25, -5, -27, -22, -25, -21, -21, -21, -21, -22, -23, -25, -26, -25,
-26, -26, -26, -26, -26, -26, -27, -25, -45, -56, -52, -54, -52, -53, -52, -54,
-44, -39, -40, -40, -39, -40, -40, -40, -39, -40, -39, -40, -39, -39, -40, -39,
-61, -69, -66, -68, -66, -67, -66, -66, -66, -66, -67, -66, -67, -65, -63, -64,
-64, -64, -64, -52, -47, -49, -48, -49, -48, -49, -48, -49, -48, -49, -48, -49,
-48, -49, -48, -49, -48, -48, -51, -49, -51, -49, -52, -48, -63, -80, -77, -78,
-77, -77, -77, -77, -79, -73, -62, -63, -63, -64, -64, -64, -64, -64, -64, -64,
-65, -64, -65, -64, -65, -64, -65, -65, -65, -65, -65, -64, -65, -64, -64, -65,
-62, -62, -60, -92, -111, -107, -109, -108, -109, -109, -110, -108, -109, -108,
-109, -108, -108, -108, -109, -108, -109, -107, -110, -107, -112, -101, -76,
-80, -78, -79, -78, -80, -69, -63, -64, -63, -63, -62, -64, -62, -61, -61, -60,
-61, -59, -63, -45, -31, -35, -33, -34, -33, -34, -4, -1, -2, 0, -3, -1, -3, };