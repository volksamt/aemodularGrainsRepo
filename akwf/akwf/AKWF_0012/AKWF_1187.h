#define DATA_LENGTH 512
#define DATA AKWF_1187

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 71, 110, 120, 114, 99, 83, 68, 58,
54, 51, 51, 49, 48, 47, 44, 42, 42, 45, 45, 45, 44, 42, 40, 37, 35, 33, 34, 35,
33, 31, 26, 26, 27, 30, 32, 36, 38, 40, 39, 35, 34, 32, 30, 27, 26, 25, 22, 19,
20, 22, 23, 22, 21, 21, 20, 19, 19, 18, 15, 11, 7, 3, 2, 11, 20, 28, 34, 37, 37,
36, 33, 32, 33, 35, 37, 34, 34, 31, 27, 25, 24, 27, 28, 28, 27, 26, 23, 20, 18,
16, 17, 18, 15, 12, 8, 7, 9, 11, 13, 17, 20, 21, 20, 16, 14, 12, 11, 7, 8, 12,
11, 10, 10, 11, 11, 9, 7, 3, 1, -3, -5, -7, -9, -13, -15, -21, -20, -3, 11, 22,
27, 28, 28, 27, 26, 23, 23, 24, 24, 22, 21, 20, 17, 17, 16, 21, 27, 30, 30, 29,
25, 21, 18, 16, 17, 17, 15, 11, 8, 6, 7, 11, 13, 16, 20, 20, 18, 16, 14, 12, 11,
7, 6, 3, 1, -1, -2, 0, 2, 2, 0, -1, -1, -1, -3, -4, -7, -12, -15, -21, -20, -11,
-2, 6, 11, 13, 14, 13, 10, 8, 10, 12, 12, 11, 9, 8, 4, 0, 0, 3, 4, 4, 3, 1, -2,
-6, -8, -7, -3, 2, 3, 0, -4, -7, -7, -5, -3, 0, 2, 2, 0, -3, -5, -6, -9, -13,
-14, -16, -19, -22, -22, -21, -19, -20, -21, -24, -28, -31, -33, -36, -37, -42,
-43, -50, -45, -15, 10, 26, 31, 28, 23, 20, 14, 12, 12, 13, 13, 13, 13, 14, 12,
10, 11, 14, 16, 16, 15, 14, 11, 8, 6, 6, 7, 7, 6, 3, -1, -2, -1, 3, 6, 10, 16,
22, 22, 21, 19, 17, 13, 10, 6, 5, 2, -1, 0, 1, 3, 2, 0, 0, -1, -2, -3, -4, -7,
-11, -14, -20, -19, -10, -1, 7, 11, 14, 14, 14, 11, 8, 11, 13, 13, 12, 10, 8, 4,
1, 2, 4, 6, 5, 4, 3, -2, -5, -6, -7, -7, -7, -9, -12, -15, -17, -16, -12, -10,
-7, -4, -4, -6, -9, -10, -12, -14, -17, -17, -13, -14, -16, -15, -14, -14, -16,
-18, -21, -25, -29, -30, -33, -35, -38, -41, -48, -43, -27, -13, -3, 1, 2, 1, 0,
-2, -3, -3, -3, -2, -5, -5, -6, -9, -11, -11, -5, 1, 3, 4, 1, -3, -7, -9, -11,
-10, -11, -13, -16, -19, -21, -20, -16, -14, -10, -8, -8, -10, -12, -14, -16,
-18, -21, -22, -23, -27, -29, -29, -28, -27, -27, -29, -29, -29, -30, -32, -33,
-36, -40, -44, -50, -49, -39, -30, -23, -18, -15, -15, -16, -20, -22, -19, -17,
-17, -19, -20, -22, -26, -29, -29, -27, -26, -26, -27, -29, -33, -35, -38, -38,
-38, -38, -40, -44, -47, -48, -48, -44, -43, -39, -37, -37, -39, -42, -44, -45,
-48, -51, -53, -54, -58, -59, -60, -58, -57, -58, -59, -63, -66, -70, -72, -75,
-75, -81, -81, -91, -48, };