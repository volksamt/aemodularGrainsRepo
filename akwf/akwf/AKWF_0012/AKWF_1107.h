#define DATA_LENGTH 512
#define DATA AKWF_1107

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 5, 6, 6, 8, 9, 11, 12, 14,
14, 15, 16, 18, 20, 20, 21, 23, 23, 24, 25, 26, 28, 28, 29, 30, 31, 31, 32, 35,
34, 35, 35, 38, 38, 38, 40, 39, 40, 42, 42, 43, 44, 44, 45, 45, 47, 47, 48, 47,
47, 49, 50, 50, 50, 53, 55, 56, 56, 58, 58, 58, 60, 59, 60, 60, 61, 63, 62, 63,
64, 64, 66, 66, 69, 70, 71, 71, 72, 71, 72, 73, 73, 73, 73, 74, 74, 75, 78, 77,
78, 78, 79, 80, 79, 80, 80, 80, 80, 81, 82, 83, 83, 83, 84, 83, 84, 84, 84, 83,
84, 87, 86, 87, 86, 86, 86, 86, 86, 86, 87, 89, 89, 89, 88, 89, 89, 89, 88, 90,
92, 90, 92, 91, 90, 90, 90, 89, 92, 94, 93, 93, 93, 93, 92, 94, 94, 95, 94, 94,
93, 93, 95, 94, 95, 94, 94, 93, 93, 95, 93, 95, 93, 93, 92, 94, 94, 93, 92, 91,
91, 92, 93, 90, 90, 90, 88, 88, 89, 89, 88, 87, 86, 85, 85, 87, 86, 84, 83, 83,
83, 83, 83, 82, 81, 80, 79, 79, 79, 79, 79, 78, 77, 76, 74, 75, 74, 74, 72, 71,
70, 69, 69, 69, 69, 67, 67, 66, 65, 63, 62, 62, 62, 61, 60, 59, 58, 55, 56, 53,
52, 54, 52, 51, 49, 47, 47, 45, 44, 43, 41, 40, 40, 40, 37, 37, 35, 32, 31, 29,
28, 27, 25, 24, 23, 21, 19, 20, 20, 17, 16, 14, 13, 12, 10, 9, 8, 5, 4, 4, 1, 0,
-2, -3, -4, -6, -7, -9, -11, -12, -13, -15, -17, -18, -21, -21, -23, -24, -26,
-27, -28, -31, -31, -33, -35, -36, -37, -39, -39, -41, -42, -46, -47, -50, -50,
-52, -52, -54, -55, -55, -58, -57, -59, -60, -61, -62, -63, -66, -69, -69, -71,
-72, -71, -73, -75, -75, -77, -77, -79, -81, -82, -84, -84, -85, -86, -86, -88,
-89, -91, -92, -93, -95, -94, -96, -95, -98, -100, -100, -100, -101, -103, -101,
-103, -106, -106, -107, -108, -108, -107, -108, -111, -111, -113, -112, -113,
-111, -113, -115, -114, -115, -115, -114, -115, -114, -116, -117, -117, -117,
-116, -115, -118, -118, -117, -118, -117, -117, -118, -119, -119, -119, -118,
-117, -116, -118, -118, -117, -116, -116, -116, -115, -116, -117, -115, -115,
-113, -112, -113, -113, -112, -113, -111, -112, -110, -110, -111, -111, -109,
-110, -107, -106, -108, -107, -106, -104, -103, -102, -101, -102, -102, -101,
-100, -100, -97, -97, -95, -93, -93, -93, -93, -91, -90, -89, -87, -87, -84,
-84, -85, -82, -81, -79, -77, -76, -74, -73, -71, -71, -72, -69, -69, -67, -65,
-63, -62, -60, -59, -58, -58, -59, -55, -54, -53, -52, -50, -47, -47, -46, -44,
-42, -41, -41, -40, -40, -39, -36, -35, -34, -33, -31, -29, -27, -27, -25, -24,
-22, -21, -20, -17, -18, -17, -17, -15, -13, -11, -10, -9, -7, -6, -4, -4, -2,
0, };