#define DATA_LENGTH 512
#define DATA AKWF_1157

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 5, 7, 9, 10, 11, 13, 15,
16, 17, 19, 20, 22, 24, 25, 26, 28, 30, 31, 33, 35, 37, 38, 39, 41, 42, 44, 46,
47, 48, 50, 52, 54, 55, 56, 57, 59, 61, 62, 63, 64, 66, 67, 69, 70, 71, 73, 73,
75, 76, 77, 78, 78, 80, 80, 82, 83, 84, 83, 84, 86, 86, 87, 88, 88, 89, 90, 91,
91, 91, 92, 93, 93, 94, 94, 95, 95, 95, 96, 96, 97, 98, 97, 98, 98, 99, 100,
101, 101, 101, 102, 102, 103, 103, 104, 104, 104, 106, 107, 106, 107, 107, 108,
109, 109, 110, 110, 112, 111, 113, 113, 113, 114, 115, 114, 115, 115, 116, 116,
117, 116, 118, 117, 118, 118, 119, 119, 120, 119, 120, 119, 119, 118, 119, 119,
119, 119, 118, 118, 119, 118, 117, 117, 116, 117, 115, 115, 115, 114, 113, 113,
113, 111, 111, 110, 110, 109, 107, 107, 107, 105, 105, 104, 102, 101, 102, 100,
99, 98, 97, 97, 94, 94, 93, 92, 91, 90, 89, 88, 87, 86, 84, 83, 82, 81, 80, 79,
78, 76, 75, 74, 72, 72, 71, 70, 69, 67, 65, 65, 64, 62, 61, 60, 58, 57, 56, 55,
53, 53, 52, 50, 48, 48, 47, 45, 44, 43, 42, 41, 39, 39, 37, 36, 35, 34, 32, 31,
30, 29, 28, 27, 26, 25, 24, 22, 21, 20, 19, 18, 16, 15, 14, 13, 12, 11, 9, 8, 7,
6, 4, 4, 3, 1, -1, -1, -2, -5, -5, -8, -9, -10, -11, -13, -15, -16, -17, -19,
-21, -22, -23, -25, -27, -29, -30, -31, -34, -35, -36, -38, -40, -41, -43, -45,
-46, -47, -49, -51, -52, -54, -55, -56, -58, -60, -61, -62, -64, -65, -67, -67,
-70, -70, -71, -72, -74, -75, -75, -77, -77, -79, -80, -81, -81, -82, -84, -84,
-85, -86, -87, -87, -88, -89, -89, -90, -91, -91, -91, -93, -92, -93, -94, -94,
-95, -95, -95, -96, -97, -97, -97, -98, -98, -99, -99, -100, -100, -101, -101,
-102, -102, -103, -103, -104, -104, -105, -105, -105, -107, -107, -107, -108,
-108, -110, -110, -110, -111, -111, -113, -113, -114, -114, -114, -114, -115,
-116, -116, -116, -116, -117, -117, -119, -118, -119, -118, -118, -119, -118,
-118, -119, -119, -119, -120, -118, -119, -119, -119, -118, -118, -117, -117,
-117, -116, -117, -116, -115, -115, -114, -113, -113, -112, -112, -111, -110,
-110, -109, -108, -107, -106, -106, -104, -104, -103, -102, -101, -99, -99, -98,
-97, -96, -95, -94, -93, -92, -90, -89, -89, -88, -86, -86, -84, -84, -82, -81,
-79, -79, -77, -76, -75, -74, -73, -72, -70, -69, -68, -66, -65, -65, -63, -62,
-61, -60, -58, -57, -56, -55, -53, -52, -52, -50, -48, -47, -46, -45, -44, -43,
-42, -40, -39, -38, -37, -36, -34, -33, -32, -31, -31, -29, -28, -27, -26, -24,
-23, -22, -20, -20, -19, -18, -16, -16, -14, -13, -11, -10, -9, -8, -7, -6, -5,
-3, -2, -1, };