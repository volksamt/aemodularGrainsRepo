#define DATA_LENGTH 512
#define DATA AKWF_1171

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 116, 123, 116, 121, 117,
120, 117, 120, 118, 120, 118, 120, 119, 119, 118, 120, 118, 120, 118, 119, 119,
119, 118, 110, -11, -70, -53, -63, -55, -62, -56, -62, -57, -60, -57, -61, -58,
-60, -58, -60, -58, -60, -58, -59, -59, -59, -61, -56, -56, 86, 127, 113, 124,
115, 122, 116, 120, 117, 120, 118, 120, 118, 119, 118, 120, 118, 119, 118, 120,
117, 120, 116, 122, 115, 121, 17, -72, -54, -63, -57, -60, -59, -60, -59, -60,
-59, -60, -60, -60, -59, -61, -58, -62, -56, -64, -53, -68, -47, -84, 8, 127,
106, 125, 114, 121, 116, 120, 118, 118, 119, 118, 119, 117, 119, 118, 119, 117,
120, 117, 119, 117, 119, 118, 119, 117, 119, 118, 118, 118, 119, 118, 119, 118,
118, 118, 118, 118, 119, 118, 118, 118, 118, 118, 118, 117, 118, 117, 118, 117,
118, 117, 117, 117, 119, 117, 118, 118, 117, 119, 117, 119, 116, 120, 115, 120,
114, 121, 112, 123, 112, 125, 108, 127, 78, -81, -54, -63, -60, -60, -61, -60,
-62, -60, -62, -59, -62, -58, -63, -59, -62, -60, -62, -60, -62, -60, -62, -60,
-61, -61, -61, -61, -61, -60, -60, -61, -60, -61, -60, -61, -61, -61, -60, -61,
-60, -61, -60, -61, -60, -60, -61, -61, -60, -61, -60, -60, -61, -61, -61, -61,
-60, -60, -60, -60, -60, -61, -60, -60, -61, -61, -60, -60, -60, -60, -61, -61,
-60, -61, -60, -60, -60, -60, -60, -60, -60, -59, -60, -60, -60, -60, -60, -60,
-61, -61, -60, -59, -60, -60, -59, -60, -59, -60, -60, -60, -60, -60, -59, -60,
-60, -60, -60, -59, -60, -60, -59, -60, -60, -59, -61, -60, -61, -60, -60, -60,
-60, -60, -60, -59, -60, -60, -59, -60, -60, -60, -59, -60, -60, -60, -59, -60,
-60, -59, -59, -60, -60, -60, -60, -60, -59, -60, -60, -60, -60, -60, -60, -59,
-60, -59, -60, -60, -59, -60, -59, -60, -60, -59, -60, -59, -59, -59, -60, -60,
-59, -59, -60, -60, -60, -60, -60, -59, -59, -59, -59, -60, -60, -59, -59, -60,
-59, -59, -60, -60, -59, -60, -60, -58, -60, -60, -59, -60, -59, -60, -59, -60,
-60, -59, -58, -59, -59, -59, -59, -59, -59, -59, -59, -60, -59, -59, -58, -60,
-59, -60, -59, -59, -59, -59, -59, -59, -59, -59, -60, -60, -59, -59, -60, -59,
-59, -59, -59, -59, -59, -59, -60, -59, -59, -59, -58, -60, -59, -59, -59, -58,
-59, -60, -59, -58, -59, -58, -59, -58, -59, -58, -60, -60, -58, -59, -59, -58,
-59, -59, -59, -59, -59, -59, -59, -60, -59, -59, -59, -59, -58, -59, -60, -58,
-58, -59, -59, -59, -59, -59, -58, -59, -59, -59, -59, -58, -59, -60, -59, -58,
-59, -59, -58, -59, -59, -59, -58, -59, -59, -58, -59, -59, -59, -59, -59, -59,
-59, -59, -59, -59, -60, -59, -58, -58, -58, -59, -58, -58, -59, -59, -58, -60,
-57, -60, -57, -60, -57, -61, -59, -66, -51, };