#define DATA_LENGTH 512
#define DATA AKWF_1149

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 1, 3, -1, 19, 32, 30, 35, 35, 38,
38, 40, 40, 42, 41, 42, 42, 41, 38, 38, 35, 33, 33, 31, 31, 29, 29, 27, 27, 26,
26, 24, 24, 23, 23, 23, 23, 22, 21, 22, 21, 20, 20, 20, 20, 20, 20, 19, 19, 18,
19, 18, 18, 18, 18, 17, 18, 17, 17, 16, 16, 16, 17, 17, 16, 16, 16, 16, 15, 15,
15, 14, 15, 14, 15, 15, 14, 15, 14, 14, 13, 14, 13, 14, 13, 13, 13, 12, 12, 13,
12, 12, 12, 11, 12, 12, 11, 11, 12, 12, 12, 11, 11, 11, 10, 10, 10, 9, 9, 9, 9,
9, 9, 8, 9, 9, 8, 8, 9, 7, 8, 7, 8, 8, 7, 7, 7, 8, 6, 0, 2, 1, 5, 8, 7, 7, 7, 8,
8, 8, 9, 8, 9, 9, 8, 8, 8, 9, 8, 9, 9, 10, 9, 9, 10, 10, 10, 10, 10, 10, 10, 10,
10, 11, 11, 11, 11, 12, 12, 12, 12, 13, 12, 13, 12, 13, 13, 14, 11, 14, 13, 15,
12, 16, 12, 17, 8, 32, 86, 79, 83, 82, 83, 85, 85, 87, 87, 88, 87, 90, 90, 91,
91, 92, 92, 95, 93, 96, 96, 97, 97, 99, 100, 101, 101, 101, 103, 103, 104, 104,
107, 106, 108, 107, 110, 108, 111, 110, 113, 111, 115, 112, 116, 115, 118, 116,
119, 118, 28, 17, 24, 19, 23, 20, 23, 19, 20, 16, 17, 14, 14, 12, 12, 10, 10, 8,
5, -1, 1, 1, -4, -6, -6, -6, -7, -6, -8, -7, -8, -8, -7, -8, -8, -8, -8, -8, -8,
-8, -9, -9, -9, -9, -9, -10, -10, -9, -10, -11, -10, -10, -11, -11, -11, -11,
-11, -12, -11, -11, -11, -12, -12, -13, -12, -13, -12, -12, -12, -12, -13, -14,
-14, -13, -14, -14, -13, -14, -14, -14, -15, -15, -15, -15, -15, -15, -16, -15,
-16, -15, -16, -16, -16, -16, -16, -17, -17, -16, -17, -17, -17, -17, -17, -17,
-18, -18, -18, -18, -18, -18, -18, -18, -18, -18, -18, -19, -19, -19, -19, -20,
-19, -20, -20, -20, -20, -20, -20, -20, -21, -21, -21, -21, -21, -21, -21, -20,
-18, -17, -15, -14, -14, -13, -12, -10, -9, -9, -4, 0, 1, -3, -7, -8, -10, -11,
-12, -13, -15, -16, -16, -19, -20, -21, -21, -21, -21, -21, -20, -21, -20, -20,
-19, -21, -19, -20, -19, -19, -20, -18, -20, -19, -19, -18, -21, -16, -20, -14,
-23, -8, -55, -113, -96, -104, -97, -101, -97, -98, -96, -97, -95, -93, -93,
-93, -93, -91, -91, -90, -89, -87, -87, -86, -86, -83, -84, -82, -82, -81, -80,
-80, -79, -77, -78, -76, -76, -75, -73, -73, -72, -71, -71, -69, -69, -68, -67,
-67, -66, -64, -64, -64, -61, -61, -60, -60, -59, -58, -57, -56, -55, -55, -54,
-54, -52, -51, -51, -50, -49, -48, -47, -47, -46, -45, -45, -43, -43, -41, -41,
-40, -40, -37, -38, -35, -37, -34, -36, -27, };