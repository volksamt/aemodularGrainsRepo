#define DATA_LENGTH 512
#define DATA AKWF_1133

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 2, 3, 3, 4, 6, 5, 6, 6, 6, 5,
5, 5, 4, 5, 5, 5, 6, 6, 8, 8, 10, 11, 13, 14, 15, 16, 19, 21, 22, 22, 23, 23,
23, 23, 22, 21, 19, 18, 16, 16, 17, 17, 18, 18, 19, 19, 21, 21, 23, 24, 24, 25,
26, 27, 27, 27, 27, 27, 27, 27, 27, 25, 24, 25, 23, 23, 21, 20, 19, 18, 18, 16,
16, 15, 15, 15, 15, 16, 17, 17, 18, 19, 21, 22, 24, 26, 29, 31, 33, 33, 33, 32,
33, 32, 31, 31, 30, 29, 29, 29, 29, 30, 29, 30, 31, 32, 34, 35, 38, 39, 42, 45,
47, 48, 51, 53, 54, 57, 57, 58, 58, 59, 58, 58, 57, 55, 53, 52, 49, 47, 45, 45,
46, 49, 50, 52, 55, 57, 58, 61, 63, 65, 67, 68, 69, 69, 69, 70, 69, 68, 66, 65,
62, 59, 57, 53, 50, 47, 43, 40, 36, 33, 29, 27, 25, 23, 22, 21, 22, 22, 23, 24,
26, 30, 32, 36, 40, 46, 50, 55, 61, 64, 63, 60, 57, 54, 51, 47, 44, 41, 40, 39,
39, 40, 42, 45, 50, 55, 61, 67, 73, 80, 88, 94, 100, 106, 112, 116, 118, 120,
119, 117, 114, 112, 106, 101, 92, 86, 76, 72, 73, 79, 80, 87, 90, 97, 99, 106,
107, 111, 112, 113, 113, 111, 110, 103, 104, 86, 105, -32, -95, -59, -68, -49,
-51, -37, -38, -28, -30, -25, -27, -26, -30, -33, -38, -45, -50, -59, -66, -75,
-80, -81, -78, -75, -70, -65, -60, -57, -53, -51, -50, -50, -51, -54, -58, -65,
-69, -75, -82, -89, -95, -101, -106, -109, -112, -113, -114, -112, -108, -104,
-99, -91, -85, -76, -70, -66, -65, -65, -66, -67, -68, -70, -71, -73, -74, -75,
-77, -77, -78, -78, -77, -76, -75, -74, -73, -71, -68, -65, -62, -60, -56, -54,
-51, -47, -45, -41, -40, -37, -35, -34, -33, -33, -33, -33, -33, -34, -35, -36,
-39, -41, -43, -46, -48, -51, -52, -52, -51, -51, -48, -47, -46, -44, -43, -41,
-40, -40, -39, -39, -39, -38, -39, -40, -42, -42, -44, -45, -47, -49, -50, -51,
-52, -54, -54, -55, -55, -55, -55, -54, -53, -52, -50, -47, -46, -44, -41, -39,
-37, -35, -37, -38, -38, -39, -41, -41, -42, -43, -43, -43, -45, -44, -43, -44,
-43, -43, -41, -40, -38, -37, -34, -33, -31, -29, -27, -25, -23, -20, -20, -17,
-16, -14, -13, -12, -12, -11, -11, -11, -11, -12, -12, -13, -14, -15, -16, -17,
-18, -20, -20, -21, -21, -19, -18, -17, -15, -14, -14, -12, -11, -11, -11, -11,
-11, -12, -13, -13, -14, -15, -16, -16, -17, -18, -18, -19, -18, -19, -18, -18,
-18, -16, -15, -15, -13, -12, -11, -10, -9, -8, -8, -7, -8, -7, -8, -7, -7, -7,
-6, -7, -6, -5, -5, -5, -4, -4, -3, -2, -3, -1, -1, -2, -1, -1, -1, -1, -1, 0,
-1, 0, -1, -1, 0, };