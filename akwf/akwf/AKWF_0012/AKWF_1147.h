#define DATA_LENGTH 512
#define DATA AKWF_1147

const PROGMEM int8_t DATA[DATA_LENGTH] = {-36, 28, 33, 29, 34, 30, 33, 30, 33,
30, 33, 31, 33, 30, 32, 31, 34, 30, 33, 31, 33, 30, 32, 31, 33, 31, 32, 32, 32,
32, 33, 32, 31, 33, 31, 34, 30, 34, 29, 36, 26, 41, 16, 75, 89, 35, 56, 43, 53,
45, 51, 48, 50, 48, 49, 49, 48, 50, 48, 50, 48, 50, 49, 50, 48, 51, 49, 51, 48,
50, 49, 49, 49, 49, 49, 49, 49, 50, 50, 49, 49, 49, 51, 49, 50, 50, 51, 50, 50,
50, 51, 51, 52, 50, 50, 51, 51, 51, 52, 51, 51, 51, 51, 52, 51, 51, 51, 52, 51,
51, 51, 51, 51, 51, 51, 52, 51, 52, 52, 52, 51, 52, 52, 53, 52, 52, 53, 52, 52,
52, 52, 52, 52, 52, 52, 53, 53, 53, 53, 52, 52, 53, 53, 53, 52, 52, 52, 52, 52,
52, 51, 51, 52, 52, 51, 51, 52, 52, 51, 51, 52, 52, 51, 52, 51, 50, 51, 51, 51,
51, 50, 51, 51, 50, 51, 50, 50, 49, 50, 50, 50, 49, 50, 50, 50, 50, 50, 50, 50,
49, 49, 50, 49, 49, 48, 49, 49, 49, 49, 49, 49, 49, 49, 49, 49, 49, 48, 49, 49,
49, 48, 48, 48, 48, 48, 48, 48, 49, 48, 47, 48, 48, 47, 47, 47, 47, 48, 48, 47,
47, 47, 47, 46, 47, 46, 47, 46, 47, 45, 49, 41, 29, 32, 30, 31, 30, 31, 31, 31,
31, 31, 30, 30, 30, 31, 31, 31, 31, 31, 30, 30, 30, 30, 30, 31, 30, 31, 30, 31,
31, 30, 30, 30, 30, 31, 30, 31, 30, 30, 30, 31, 30, 30, 30, 30, 30, 31, 30, 31,
31, 31, 18, 17, 18, 16, 19, 16, 19, 14, 24, -31, -59, -48, -55, -50, -54, -51,
-55, -52, -54, -53, -54, -53, -55, -54, -54, -54, -54, -56, -55, -55, -56, -56,
-55, -57, -57, -57, -56, -56, -57, -58, -57, -58, -58, -59, -58, -59, -58, -60,
-59, -60, -59, -60, -60, -60, -60, -61, -60, -60, -61, -62, -62, -61, -62, -62,
-63, -63, -62, -63, -62, -63, -64, -64, -64, -64, -65, -64, -65, -65, -64, -65,
-66, -66, -66, -65, -66, -66, -66, -66, -67, -66, -67, -67, -68, -67, -68, -69,
-68, -68, -69, -68, -69, -69, -70, -71, -69, -70, -71, -71, -70, -70, -71, -71,
-72, -71, -72, -73, -72, -72, -73, -72, -73, -72, -73, -72, -72, -72, -72, -72,
-71, -71, -70, -70, -70, -69, -69, -69, -69, -68, -68, -68, -68, -67, -67, -67,
-67, -66, -65, -66, -66, -65, -65, -65, -65, -64, -64, -63, -63, -63, -63, -62,
-62, -62, -62, -61, -61, -62, -60, -61, -60, -61, -60, -59, -59, -59, -58, -58,
-57, -58, -58, -57, -57, -57, -57, -56, -56, -55, -56, -55, -55, -54, -54, -53,
-54, -54, -53, -53, -53, -52, -52, -52, -51, -51, -51, -50, -50, -50, -50, -50,
-49, -49, -49, -49, -47, -49, -47, -48, -45, -49, -44, -49, -39, };