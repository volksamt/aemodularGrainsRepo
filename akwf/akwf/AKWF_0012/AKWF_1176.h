#define DATA_LENGTH 512
#define DATA AKWF_1176

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 2, 3, 4, 5, 5, 5, 7, 7, 8, 8,
9, 10, 11, 11, 13, 13, 13, 14, 15, 16, 16, 16, 17, 18, 19, 19, 20, 21, 22, 22,
23, 24, 24, 25, 25, 25, 24, 24, 24, 23, 22, 22, 21, 21, 21, 21, 22, 24, 26, 30,
33, 37, 41, 46, 50, 53, 56, 58, 58, 58, 57, 55, 53, 50, 48, 47, 45, 44, 44, 45,
45, 47, 48, 50, 52, 54, 55, 58, 60, 61, 62, 63, 64, 65, 66, 66, 66, 67, 67, 67,
68, 68, 69, 69, 70, 70, 71, 72, 73, 74, 75, 75, 77, 77, 78, 79, 80, 81, 82, 82,
83, 84, 84, 85, 86, 86, 88, 87, 89, 89, 90, 91, 92, 92, 93, 94, 94, 96, 96, 98,
98, 99, 100, 100, 102, 102, 102, 104, 104, 105, 106, 106, 107, 108, 108, 109,
110, 111, 111, 113, 113, 115, 115, 115, 117, 117, 118, 119, 119, 119, 118, 118,
115, 113, 109, 105, 100, 96, 90, 87, 82, 79, 77, 75, 74, 74, 74, 74, 75, 75, 76,
77, 77, 77, 77, 76, 75, 74, 72, 71, 69, 66, 64, 62, 61, 58, 57, 55, 53, 53, 52,
50, 49, 47, 47, 44, 44, 43, 42, 40, 39, 37, 36, 35, 34, 31, 29, 28, 27, 26, 23,
21, 20, 18, 17, 15, 14, 12, 10, 10, 7, 6, 5, 3, 1, -1, -2, -5, -6, -8, -8, -11,
-12, -14, -16, -17, -20, -21, -24, -24, -27, -28, -30, -32, -33, -34, -36, -38,
-39, -39, -42, -42, -44, -45, -47, -48, -51, -52, -54, -56, -58, -59, -62, -63,
-65, -67, -69, -71, -72, -73, -75, -76, -77, -79, -80, -82, -84, -85, -85, -87,
-87, -85, -84, -82, -79, -76, -74, -71, -69, -67, -66, -65, -66, -66, -67, -69,
-71, -73, -74, -75, -77, -78, -79, -79, -80, -79, -80, -80, -79, -78, -78, -78,
-78, -77, -77, -76, -76, -76, -77, -76, -76, -77, -77, -77, -78, -79, -78, -78,
-78, -79, -78, -79, -78, -78, -78, -78, -79, -78, -76, -78, -76, -76, -76, -76,
-76, -75, -75, -75, -75, -74, -75, -74, -73, -74, -73, -73, -73, -72, -72, -72,
-72, -72, -72, -71, -71, -70, -70, -70, -69, -70, -69, -68, -68, -68, -67, -67,
-68, -66, -67, -66, -66, -66, -64, -62, -59, -57, -54, -50, -47, -45, -43, -42,
-43, -44, -47, -50, -54, -58, -62, -64, -67, -68, -70, -69, -70, -67, -67, -64,
-62, -59, -56, -54, -52, -49, -47, -46, -46, -45, -44, -43, -43, -44, -44, -45,
-46, -45, -45, -45, -45, -46, -45, -45, -44, -43, -41, -41, -40, -39, -38, -37,
-36, -35, -35, -34, -34, -33, -33, -32, -32, -32, -31, -31, -30, -30, -30, -29,
-28, -27, -27, -26, -26, -24, -24, -23, -23, -22, -22, -21, -20, -19, -19, -18,
-18, -17, -16, -16, -15, -15, -14, -14, -13, -13, -11, -11, -9, -9, -9, -8, -7,
-7, -6, -5, -5, -3, -3, -2, -1, -1, -1, };