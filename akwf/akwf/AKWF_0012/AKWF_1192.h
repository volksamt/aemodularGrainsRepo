#define DATA_LENGTH 512
#define DATA AKWF_1192

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 6, 8, 11, 14, 17, 19, 22, 24,
27, 30, 34, 37, 39, 42, 45, 47, 50, 53, 56, 58, 60, 63, 66, 68, 70, 73, 76, 77,
79, 82, 83, 84, 86, 89, 91, 93, 94, 95, 98, 100, 101, 102, 104, 105, 107, 109,
110, 111, 112, 113, 114, 115, 117, 116, 117, 118, 118, 118, 119, 119, 119, 119,
119, 119, 119, 117, 117, 117, 117, 116, 115, 114, 114, 114, 111, 110, 110, 108,
106, 105, 103, 102, 99, 98, 95, 93, 92, 88, 87, 84, 82, 79, 76, 74, 71, 68, 65,
63, 60, 58, 56, 53, 50, 47, 45, 43, 40, 38, 36, 33, 31, 28, 27, 23, 22, 19, 18,
15, 14, 12, 9, 7, 5, 3, 0, -2, -3, -5, -7, -9, -10, -13, -14, -16, -17, -18,
-21, -21, -23, -25, -26, -28, -29, -30, -31, -33, -35, -35, -37, -37, -39, -40,
-40, -43, -44, -45, -47, -47, -49, -50, -51, -52, -52, -54, -54, -55, -56, -56,
-56, -57, -57, -58, -58, -58, -58, -60, -59, -60, -60, -59, -60, -61, -61, -61,
-61, -60, -61, -60, -61, -62, -61, -63, -63, -62, -63, -62, -62, -62, -62, -62,
-63, -63, -63, -62, -63, -63, -63, -64, -64, -63, -64, -64, -63, -64, -65, -64,
-66, -66, -65, -66, -66, -67, -66, -66, -67, -66, -66, -66, -66, -65, -64, -64,
-63, -62, -61, -60, -59, -59, -58, -56, -55, -55, -53, -52, -50, -48, -46, -46,
-44, -42, -41, -39, -38, -35, -33, -32, -30, -28, -26, -25, -23, -20, -18, -15,
-14, -12, -10, -7, -6, -4, -2, 0, 2, 3, 6, 9, 9, 12, 13, 15, 16, 18, 20, 22, 24,
24, 26, 27, 29, 30, 32, 32, 35, 35, 38, 38, 40, 41, 42, 44, 45, 46, 47, 48, 49,
49, 50, 52, 52, 53, 54, 55, 54, 56, 55, 57, 56, 57, 56, 56, 56, 57, 57, 56, 56,
56, 56, 55, 55, 54, 54, 52, 53, 51, 50, 50, 48, 48, 47, 44, 44, 43, 41, 39, 38,
37, 34, 32, 31, 29, 27, 25, 22, 21, 20, 19, 17, 15, 13, 12, 10, 8, 8, 6, 3, 3,
2, 0, -2, -3, -5, -5, -7, -8, -10, -11, -12, -13, -15, -16, -17, -18, -19, -21,
-22, -23, -24, -25, -26, -26, -27, -28, -29, -30, -30, -32, -32, -32, -34, -34,
-35, -36, -37, -38, -38, -39, -40, -40, -41, -42, -43, -44, -44, -45, -46, -47,
-48, -48, -49, -49, -49, -50, -51, -51, -51, -51, -51, -53, -52, -53, -53, -53,
-53, -53, -53, -54, -53, -54, -54, -54, -55, -54, -54, -55, -54, -55, -56, -54,
-55, -55, -56, -55, -55, -56, -55, -56, -55, -55, -55, -55, -55, -55, -55, -55,
-55, -55, -55, -55, -54, -54, -55, -54, -54, -55, -54, -53, -54, -54, -53, -54,
-52, -52, -51, -50, -49, -49, -47, -46, -44, -43, -42, -40, -39, -37, -35, -33,
-31, -30, -27, -26, -23, -21, -19, -16, -14, -12, -10, -6, -4, -3, };