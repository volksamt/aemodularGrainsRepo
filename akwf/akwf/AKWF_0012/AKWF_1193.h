#define DATA_LENGTH 512
#define DATA AKWF_1193

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 0, 2, 0, 2, 2, 1, 2, 2, 1, 1,
1, 1, 2, 0, 2, 0, 2, 0, 4, -2, 6, -6, 22, 65, 59, 61, 62, 56, 76, 109, 102, 106,
104, 105, 104, 105, 105, 105, 107, 105, 107, 105, 107, 105, 106, 105, 107, 106,
107, 107, 108, 107, 107, 107, 108, 108, 109, 108, 108, 108, 109, 110, 109, 109,
109, 109, 110, 109, 110, 110, 110, 110, 110, 111, 111, 111, 111, 110, 111, 112,
111, 112, 111, 111, 112, 112, 112, 112, 112, 113, 113, 113, 113, 114, 114, 114,
115, 114, 115, 115, 114, 115, 115, 116, 115, 116, 115, 116, 116, 117, 116, 117,
117, 117, 118, 118, 118, 117, 118, 117, 118, 118, 119, 118, 119, 117, 118, 116,
118, 116, 118, 116, 116, 116, 116, 117, 64, 52, 58, 55, 57, 55, 57, 55, 56, 54,
57, 55, 56, 54, 55, 55, 55, 54, 54, 55, 53, 55, 53, 54, 52, 54, 52, 55, 51, 56,
45, 10, 13, 11, 11, 12, 10, 12, 10, 11, 11, 11, 11, 11, 10, 10, 10, 11, 10, 10,
10, 9, 9, 10, 9, 9, 8, 8, 9, 8, 8, 8, 8, 8, 8, 8, 8, 8, 7, 7, 7, 7, 7, 7, 7, 7,
7, 6, 6, 6, 6, 6, 7, 5, 6, 5, 6, 6, 5, 6, 6, 4, 5, 5, 5, 5, 4, 4, 4, 4, 4, 4, 3,
5, 2, 5, 1, 5, 1, 6, 0, 9, 44, 44, 42, 45, 40, 0, -1, 1, -2, 0, -2, 0, -1, 0,
-2, 1, -1, 0, -1, 0, -1, 0, -1, 0, -1, 0, -1, 0, -2, 0, -2, 2, -3, 3, -8, 17,
24, -10, 1, -6, -1, -5, -4, -5, -4, -4, -4, -5, -6, -4, -5, -4, -6, -6, -7, -5,
-7, -5, -7, -6, -7, -7, -8, -7, -7, -8, -8, -7, -8, -8, -8, -9, -9, -9, -9, -9,
-8, -9, -9, -9, -9, -9, -10, -10, -10, -10, -10, -11, -10, -12, -11, -12, -11,
-11, -12, -11, -12, -12, -12, -13, -12, -13, -13, -13, -14, -13, -14, -14, -15,
-14, -15, -13, -16, -13, -17, -11, -27, -60, -54, -57, -56, -57, -57, -57, -57,
-56, -58, -57, -58, -58, -59, -57, -59, -58, -59, -58, -58, -57, -57, -58, -57,
-58, -56, -59, -55, -60, -49, -91, -123, -112, -118, -114, -117, -114, -116,
-115, -115, -114, -114, -114, -114, -114, -114, -114, -113, -114, -113, -113,
-113, -113, -112, -113, -113, -113, -113, -113, -113, -112, -112, -112, -111,
-112, -111, -112, -112, -111, -111, -111, -111, -111, -111, -110, -111, -111,
-110, -110, -110, -110, -110, -110, -109, -109, -109, -109, -109, -109, -108,
-109, -109, -108, -108, -108, -108, -109, -108, -108, -107, -107, -107, -107,
-107, -106, -107, -107, -107, -105, -106, -106, -106, -105, -105, -105, -106,
-105, -105, -104, -105, -105, -104, -105, -105, -104, -104, -104, -103, -104,
-104, -104, -102, -104, -102, -104, -102, -105, -101, -105, -100, -105, -98,
-108, -87, };