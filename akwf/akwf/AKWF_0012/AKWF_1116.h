#define DATA_LENGTH 512
#define DATA AKWF_1116

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 34, 54, 61, 57, 59, 59, 53, 52, 56,
55, 46, 33, 12, 5, -5, -12, -11, -19, -9, 4, 5, 3, 5, 9, 11, 4, -12, -20, -25,
-34, -38, -27, -18, -10, 3, -3, -1, -3, 2, 10, 14, 18, 14, 12, 11, 8, 2, 7, 6,
3, 7, 12, 17, 15, 6, 7, 8, 10, 9, 7, 1, -12, -20, -30, -25, -17, -17, -8, 2, -2,
-7, -19, -25, -20, -12, -11, -15, -23, -31, -36, -33, -30, -23, -4, 12, 18, 16,
7, 6, 14, 23, 25, 25, 23, 7, 2, 4, 4, 12, 15, 10, 5, -7, -19, -17, -18, -13, 14,
18, 17, 11, 2, 3, 13, 13, 9, 14, 10, 4, -4, -16, -36, -76, -96, -63, -37, -10,
18, 36, 43, 37, 32, 30, 24, 18, 17, 19, 29, 32, 24, 25, 26, 19, 15, 10, 5, 3,
-3, -18, -19, -18, -15, -10, -14, -18, -13, -10, -17, -17, -12, -8, -1, 0, -4,
-6, -8, -1, 2, 3, 3, 2, 4, 8, 8, 9, 16, 13, 12, 10, 6, 2, -2, -6, 2, 0, 2, 12,
14, 17, 15, 7, 5, 2, -3, -4, 0, 0, -4, -5, -15, -23, -17, -9, -5, -3, -10, -20,
-27, -30, -33, -27, -17, -17, -18, -17, -11, 0, 12, 19, 29, 27, 15, 3, 2, 2, 10,
14, 13, 15, 1, -14, -18, -19, -27, -14, 0, 5, 15, 13, 8, 20, 25, 22, 21, 15, 9,
3, -3, -16, -32, -59, -73, -81, -78, -57, -30, 6, 27, 43, 55, 58, 54, 50, 44,
36, 30, 22, 13, 9, 0, -4, -7, -5, 5, 11, 19, 22, 20, 18, 19, 14, -3, -13, -15,
-18, -22, -24, -19, -10, 5, 15, 20, 13, 11, 14, 12, 13, 2, -5, -6, 0, -4, -10,
-10, -6, 1, 5, 8, 3, -4, -17, -19, -23, -24, -22, -23, -12, -12, -17, -19, -16,
-8, 8, 12, 16, 18, 10, 4, -2, -3, -6, -7, -6, -8, -15, -15, -14, -6, 5, 16, 14,
8, 1, -3, -4, -5, 5, 11, 6, -3, -3, -11, -14, -8, -6, 7, 5, -8, -10, -5, -16,
-16, -9, -6, 7, 12, 9, 9, 20, 26, 32, 33, 27, 28, 16, 8, -3, -7, 0, 7, 8, 2, 2,
2, 5, 9, 12, 6, -1, -6, -15, -9, -1, -1, -4, -7, -15, -17, -21, -27, -28, -24,
-23, -17, -11, -15, -14, -4, 0, -2, 0, 5, 7, 4, -1, 3, 8, 12, 24, 25, 19, 14,
10, 13, 15, 13, 8, 6, 9, 6, 5, 5, 4, -3, -3, 0, -2, -2, -11, -10, -11, -5, -5,
2, 5, 1, -1, -8, -10, -5, 4, 8, 18, 13, -1, -3, -2, 1, 7, 9, 7, -1, -14, -25,
-21, -17, -11, -3, 9, 8, 1, -2, -4, 4, 15, 19, 13, 10, -4, -14, -14, -19, -12,
1, -2, -11, -10, -18, -18, -17, -19, -7, -4, -5, -10, -9, -5, 11, 22, 18, 22,
21, 8, -4, -11, -27, -81, -124, -94, -57, -18, };