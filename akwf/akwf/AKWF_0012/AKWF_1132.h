#define DATA_LENGTH 512
#define DATA AKWF_1132

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 4, 5, 5, 6, 5, 6, 5, 6, 7, 8,
11, 13, 16, 18, 20, 24, 27, 29, 30, 32, 33, 35, 36, 37, 39, 40, 42, 42, 44, 46,
47, 49, 49, 50, 53, 54, 54, 56, 58, 59, 60, 61, 62, 64, 65, 66, 67, 69, 69, 71,
72, 73, 74, 76, 76, 77, 78, 80, 82, 83, 83, 84, 85, 86, 87, 88, 89, 91, 91, 93,
93, 93, 95, 95, 96, 98, 99, 99, 100, 101, 101, 102, 103, 104, 104, 105, 105,
106, 107, 108, 108, 109, 110, 109, 111, 112, 111, 112, 113, 113, 114, 114, 115,
115, 115, 116, 116, 116, 117, 117, 117, 117, 118, 118, 118, 119, 118, 118, 118,
119, 119, 118, 118, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 118, 119,
118, 118, 117, 118, 118, 117, 117, 117, 117, 116, 115, 116, 114, 114, 114, 114,
113, 112, 113, 111, 111, 110, 110, 109, 108, 109, 107, 107, 106, 106, 105, 104,
104, 103, 102, 101, 100, 100, 99, 97, 97, 96, 96, 94, 94, 92, 92, 91, 90, 90,
88, 87, 86, 85, 84, 84, 81, 81, 80, 79, 77, 77, 76, 74, 73, 74, 77, 81, 84, 87,
90, 93, 95, 98, 98, 94, 88, 81, 76, 71, 65, 60, 55, 50, 48, 47, 45, 44, 43, 41,
40, 39, 36, 36, 35, 32, 32, 31, 29, 28, 26, 25, 23, 22, 20, 18, 17, 15, 14, 13,
12, 10, 9, 8, 6, 4, 2, 1, 0, -1, -3, -3, -4, -5, -6, -6, -6, -5, -5, -7, -10,
-11, -13, -16, -19, -22, -24, -27, -28, -30, -32, -33, -35, -36, -37, -39, -40,
-42, -43, -44, -46, -47, -49, -50, -51, -52, -53, -54, -56, -58, -59, -61, -61,
-63, -64, -65, -66, -67, -69, -69, -71, -73, -73, -75, -76, -78, -78, -78, -80,
-81, -82, -84, -85, -85, -86, -87, -88, -89, -91, -91, -92, -93, -94, -95, -96,
-97, -97, -98, -98, -100, -101, -102, -103, -103, -104, -105, -105, -105, -107,
-107, -108, -108, -109, -110, -110, -111, -111, -112, -112, -113, -113, -113,
-113, -114, -114, -114, -116, -116, -116, -117, -117, -118, -117, -118, -118,
-118, -118, -118, -118, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-120, -119, -118, -120, -119, -119, -118, -119, -117, -119, -118, -117, -117,
-117, -117, -117, -117, -116, -115, -115, -114, -114, -114, -114, -113, -113,
-112, -111, -111, -110, -110, -110, -108, -108, -107, -107, -106, -106, -104,
-104, -104, -102, -102, -101, -101, -100, -99, -98, -98, -97, -95, -95, -94,
-93, -92, -91, -90, -89, -89, -87, -86, -85, -84, -83, -82, -80, -80, -79, -77,
-77, -75, -74, -73, -74, -78, -81, -84, -87, -91, -94, -96, -97, -98, -93, -86,
-81, -75, -69, -64, -60, -54, -50, -49, -47, -45, -44, -42, -41, -39, -38, -37,
-35, -34, -32, -32, -30, -29, -27, -26, -25, -23, -22, -20, -19, -18, -15, -14,
-13, -11, -10, -8, -7, -5, -5, -2, -1, };