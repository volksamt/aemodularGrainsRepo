#define DATA_LENGTH 512
#define DATA AKWF_1112

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 8, 9, 12, 13, 14, 15, 16,
16, 17, 17, 18, 19, 21, 22, 22, 24, 24, 25, 27, 26, 28, 28, 28, 29, 29, 30, 31,
32, 32, 33, 33, 34, 34, 35, 36, 37, 37, 38, 38, 38, 38, 38, 39, 41, 41, 42, 43,
43, 45, 46, 47, 48, 48, 49, 49, 50, 51, 52, 52, 53, 54, 55, 55, 57, 56, 58, 58,
58, 58, 59, 59, 60, 60, 61, 62, 62, 63, 64, 65, 67, 68, 70, 72, 72, 74, 76, 76,
77, 78, 79, 81, 82, 82, 83, 84, 85, 86, 87, 88, 89, 91, 92, 93, 94, 95, 96, 97,
98, 99, 101, 101, 102, 104, 104, 105, 106, 106, 107, 108, 110, 111, 111, 112,
113, 114, 114, 115, 117, 117, 118, 119, 119, 115, 111, 109, 107, 107, 105, 107,
107, 110, 112, 113, 114, 114, 113, 113, 112, 111, 110, 108, 108, 107, 106, 105,
105, 105, 104, 104, 102, 102, 101, 101, 99, 98, 96, 95, 94, 92, 91, 91, 90, 90,
89, 88, 86, 84, 84, 81, 79, 77, 75, 72, 72, 71, 70, 70, 68, 68, 68, 67, 66, 64,
63, 62, 59, 58, 57, 56, 55, 54, 53, 53, 51, 51, 49, 49, 48, 46, 45, 43, 43, 41,
40, 40, 39, 38, 38, 38, 36, 36, 35, 33, 32, 31, 29, 29, 28, 28, 26, 27, 26, 25,
24, 24, 23, 21, 21, 20, 19, 19, 18, 17, 17, 17, 17, 17, 15, 14, 13, 12, 10, 9,
7, 7, 5, 6, 4, 4, 4, 4, 3, 3, 2, 1, 1, -1, -2, -3, -4, -4, -5, -6, -7, -7, -8,
-8, -10, -11, -11, -12, -11, -11, -10, -10, -11, -12, -13, -14, -15, -16, -18,
-20, -22, -23, -23, -25, -25, -26, -27, -26, -27, -27, -29, -30, -31, -32, -34,
-35, -37, -38, -39, -40, -41, -41, -42, -42, -43, -42, -43, -45, -46, -46, -48,
-48, -50, -50, -50, -49, -50, -50, -50, -52, -52, -53, -54, -54, -55, -55, -54,
-53, -52, -53, -53, -54, -54, -55, -57, -57, -59, -59, -60, -62, -62, -63, -62,
-64, -64, -65, -64, -64, -65, -65, -65, -65, -64, -64, -63, -63, -64, -64, -64,
-65, -65, -66, -67, -67, -68, -68, -68, -69, -70, -71, -71, -72, -73, -73, -75,
-76, -77, -78, -79, -80, -81, -82, -83, -83, -86, -85, -86, -86, -87, -87, -87,
-87, -87, -87, -87, -87, -86, -87, -86, -86, -87, -87, -86, -86, -87, -86, -88,
-88, -88, -88, -89, -89, -88, -90, -89, -89, -90, -89, -88, -89, -87, -86, -86,
-86, -86, -87, -86, -86, -86, -86, -85, -85, -83, -83, -82, -82, -80, -79, -78,
-75, -74, -73, -72, -70, -69, -67, -66, -65, -65, -63, -62, -60, -59, -57, -55,
-54, -53, -52, -51, -50, -50, -49, -48, -47, -47, -45, -43, -42, -41, -39, -38,
-36, -35, -34, -32, -30, -29, -27, -25, -24, -23, -20, -17, -15, -13, -10, -9,
-8, -7, -6, -6, -4, -3, -1, 0, };