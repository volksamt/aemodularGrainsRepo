#define DATA_LENGTH 512
#define DATA AKWF_1152

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 1, 1, 1, 3, 3, 3, 4, 4, 5, 6, 7,
6, 7, 8, 8, 9, 9, 10, 10, 11, 12, 12, 14, 14, 13, 14, 15, 16, 16, 17, 17, 18,
19, 18, 20, 21, 21, 21, 22, 23, 23, 24, 25, 26, 25, 25, 26, 27, 28, 29, 29, 30,
30, 31, 31, 31, 32, 33, 34, 34, 34, 36, 35, 36, 37, 38, 38, 38, 39, 39, 41, 40,
42, 42, 42, 44, 44, 45, 45, 46, 46, 46, 47, 48, 48, 49, 50, 50, 51, 50, 52, 52,
53, 54, 54, 54, 55, 56, 56, 58, 58, 58, 59, 60, 61, 61, 60, 62, 62, 63, 64, 64,
65, 65, 66, 67, 67, 68, 68, 68, 69, 70, 70, 71, 72, 73, 73, 74, 74, 75, 76, 75,
76, 77, 77, 78, 79, 79, 79, 80, 81, 81, 82, 82, 84, 84, 84, 85, 85, 86, 88, 88,
88, 88, 89, 90, 91, 91, 91, 92, 93, 93, 95, 94, 95, 95, 97, 97, 98, 98, 99, 100,
99, 100, 101, 101, 102, 103, 104, 103, 104, 105, 105, 106, 106, 107, 107, 109,
108, 110, 110, 111, 111, 113, 112, 114, 113, 115, 115, 116, 117, 115, 120, 114,
126, 87, 78, 81, 68, 69, 59, 59, 51, 50, 43, 42, 37, 35, 31, 29, 26, 22, 20, 17,
15, 12, 10, 7, 6, 3, 0, -2, -4, -7, -8, -11, -12, -14, -16, -18, -19, -21, -24,
-24, -26, -27, -30, -31, -32, -33, -36, -36, -38, -39, -40, -41, -42, -44, -44,
-45, -47, -48, -49, -50, -50, -51, -53, -53, -54, -55, -56, -57, -58, -59, -59,
-59, -61, -61, -61, -61, -63, -64, -64, -64, -64, -65, -66, -66, -66, -67, -68,
-67, -68, -69, -69, -69, -69, -70, -70, -71, -70, -71, -71, -71, -72, -71, -72,
-72, -73, -72, -73, -73, -73, -74, -73, -73, -73, -73, -74, -74, -74, -73, -74,
-73, -73, -74, -73, -73, -73, -73, -73, -73, -73, -72, -73, -72, -73, -72, -72,
-72, -72, -73, -72, -71, -71, -72, -71, -71, -71, -70, -71, -70, -70, -70, -69,
-69, -70, -69, -69, -69, -68, -68, -67, -68, -67, -66, -66, -66, -67, -66, -66,
-65, -65, -64, -64, -64, -64, -64, -63, -63, -63, -62, -62, -62, -61, -60, -60,
-60, -60, -59, -59, -59, -58, -58, -56, -57, -56, -56, -55, -54, -55, -54, -54,
-54, -52, -53, -52, -52, -51, -51, -50, -50, -50, -49, -49, -48, -49, -48, -47,
-46, -46, -46, -45, -45, -44, -45, -44, -43, -43, -42, -42, -41, -41, -40, -40,
-39, -39, -38, -37, -37, -36, -36, -36, -36, -36, -34, -34, -34, -33, -33, -32,
-31, -32, -31, -30, -30, -29, -29, -28, -27, -27, -27, -26, -26, -25, -24, -24,
-23, -22, -22, -22, -21, -21, -19, -19, -19, -18, -18, -18, -17, -16, -16, -15,
-16, -14, -14, -13, -13, -13, -11, -12, -11, -10, -9, -8, -9, -9, -7, -7, -6,
-5, -6, -4, -5, -3, -4, -2, -2, -2, -2, 0, };