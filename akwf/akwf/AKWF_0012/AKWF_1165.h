#define DATA_LENGTH 512
#define DATA AKWF_1165

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 8, 10, 13, 15, 18, 19, 23,
24, 26, 28, 31, 33, 35, 37, 39, 41, 44, 46, 48, 49, 51, 53, 55, 57, 59, 61, 63,
65, 66, 67, 69, 71, 72, 72, 74, 75, 77, 78, 79, 82, 84, 84, 86, 87, 89, 91, 92,
93, 95, 96, 97, 99, 101, 101, 103, 103, 105, 107, 106, 108, 109, 110, 111, 112,
113, 113, 114, 115, 116, 116, 117, 117, 118, 118, 118, 119, 119, 120, 119, 119,
119, 119, 119, 118, 118, 118, 117, 116, 116, 115, 114, 113, 113, 111, 111, 110,
108, 106, 105, 105, 102, 101, 100, 97, 96, 95, 92, 90, 88, 86, 84, 81, 80, 78,
75, 73, 71, 70, 68, 66, 65, 64, 64, 62, 62, 62, 60, 60, 61, 61, 61, 59, 60, 60,
61, 60, 60, 60, 59, 60, 59, 60, 60, 60, 60, 60, 61, 62, 61, 61, 61, 61, 62, 62,
62, 63, 62, 63, 63, 63, 63, 64, 62, 63, 63, 62, 63, 63, 63, 63, 63, 63, 62, 63,
63, 62, 62, 62, 62, 62, 62, 62, 61, 62, 61, 61, 60, 60, 60, 59, 59, 59, 58, 58,
57, 57, 57, 56, 55, 55, 55, 54, 54, 54, 52, 52, 52, 51, 51, 49, 49, 48, 47, 47,
45, 45, 44, 44, 44, 42, 42, 40, 40, 39, 38, 37, 36, 36, 34, 33, 32, 31, 31, 29,
28, 27, 26, 25, 23, 22, 20, 20, 19, 18, 16, 15, 14, 12, 11, 9, 8, 7, 5, 4, 3, 2,
-1, -1, -3, -4, -6, -7, -8, -11, -12, -14, -14, -17, -17, -20, -21, -22, -24,
-26, -27, -29, -30, -32, -33, -35, -36, -38, -39, -41, -42, -44, -45, -47, -49,
-50, -52, -53, -55, -56, -58, -59, -60, -62, -63, -65, -67, -69, -69, -70, -72,
-73, -75, -75, -78, -78, -79, -81, -82, -84, -84, -86, -87, -88, -90, -91, -91,
-92, -94, -95, -96, -96, -97, -98, -99, -100, -101, -101, -102, -103, -104,
-104, -104, -106, -107, -107, -108, -108, -109, -109, -110, -110, -110, -111,
-111, -112, -111, -112, -112, -112, -112, -112, -112, -112, -113, -112, -112,
-112, -112, -112, -112, -112, -110, -110, -110, -109, -109, -108, -107, -106,
-106, -105, -105, -104, -103, -102, -101, -101, -100, -99, -97, -96, -95, -94,
-93, -91, -90, -89, -88, -86, -84, -84, -82, -81, -80, -77, -77, -75, -73, -73,
-72, -70, -69, -69, -68, -68, -67, -67, -66, -66, -66, -66, -65, -66, -66, -65,
-65, -65, -65, -65, -66, -65, -66, -65, -65, -65, -65, -66, -66, -66, -65, -66,
-65, -66, -65, -65, -65, -65, -66, -66, -65, -65, -65, -65, -65, -65, -66, -65,
-64, -65, -64, -63, -64, -63, -62, -62, -61, -61, -60, -59, -59, -59, -58, -57,
-57, -55, -55, -54, -53, -52, -51, -51, -49, -49, -47, -46, -45, -43, -43, -41,
-40, -38, -37, -36, -34, -32, -31, -31, -29, -28, -25, -23, -22, -19, -19, -17,
-16, -13, -11, -9, -8, -5, -3, -1, };