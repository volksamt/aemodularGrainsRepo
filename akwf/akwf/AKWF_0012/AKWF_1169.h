#define DATA_LENGTH 512
#define DATA AKWF_1169

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 4, 5, 7, 9, 12, 14, 18, 21,
25, 28, 32, 35, 39, 44, 49, 54, 59, 63, 69, 73, 78, 84, 87, 86, 84, 83, 80, 76,
73, 68, 63, 57, 51, 45, 39, 33, 28, 24, 20, 15, 13, 10, 8, 7, 6, 4, 3, 3, 2, 1,
1, 1, 0, 0, 1, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 2, 2, 3, 5, 8,
9, 12, 15, 17, 21, 24, 28, 32, 36, 40, 44, 49, 53, 57, 63, 68, 73, 78, 84, 89,
95, 100, 106, 110, 117, 120, 119, 114, 106, 98, 85, 74, 61, 48, 34, 22, 13, 7,
1, -3, -6, -8, -9, -10, -10, -10, -10, -11, -10, -9, -9, -7, -8, -7, -6, -6, -5,
-4, -4, -4, -4, -3, -4, -3, -2, -2, -4, -7, -9, -8, -8, -8, -6, -3, 0, 2, 6, 11,
14, 19, 23, 28, 32, 38, 43, 48, 53, 58, 64, 70, 75, 80, 87, 92, 98, 104, 109,
116, 119, 118, 115, 108, 99, 87, 75, 63, 49, 36, 24, 10, 0, -10, -18, -22, -26,
-28, -29, -29, -29, -27, -27, -25, -24, -22, -20, -19, -17, -16, -14, -12, -11,
-10, -9, -8, -7, -6, -5, -5, -5, -7, -10, -15, -20, -25, -31, -36, -41, -45,
-49, -53, -56, -58, -62, -62, -64, -64, -65, -63, -56, -50, -41, -31, -21, -9,
3, 14, 25, 37, 47, 58, 69, 76, 81, 81, 77, 71, 63, 53, 42, 32, 21, 9, -1, -11,
-20, -25, -30, -31, -33, -32, -33, -31, -30, -27, -26, -24, -23, -21, -19, -18,
-16, -14, -13, -12, -10, -9, -9, -7, -6, -6, -6, -5, -8, -11, -17, -21, -28,
-33, -38, -43, -48, -51, -56, -58, -60, -63, -63, -64, -65, -65, -65, -63, -62,
-60, -59, -56, -53, -51, -47, -44, -41, -36, -32, -28, -23, -22, -20, -20, -20,
-24, -28, -32, -39, -44, -49, -55, -61, -65, -65, -64, -63, -61, -57, -54, -50,
-46, -43, -40, -37, -33, -30, -26, -24, -22, -20, -17, -16, -15, -12, -12, -11,
-9, -8, -7, -8, -11, -14, -19, -24, -30, -35, -40, -44, -50, -53, -56, -59, -62,
-63, -64, -65, -66, -66, -66, -65, -62, -62, -60, -57, -53, -50, -49, -44, -40,
-36, -33, -29, -24, -22, -19, -18, -18, -18, -17, -18, -18, -18, -17, -18, -17,
-16, -16, -15, -13, -13, -11, -11, -9, -9, -8, -7, -7, -5, -5, -5, -5, -4, -3,
-4, -3, -3, -2, -1, -2, -1, -2, -1, -1, 0, 0, 0, 2, 3, 5, 6, 8, 11, 14, 17, 17,
15, 13, 8, 5, 0, -3, -7, -10, -14, -14, -18, -19, -19, -19, -20, -18, -18, -16,
-14, -11, -10, -9, -7, -8, -8, -9, -11, -11, -12, -12, -13, -14, -13, -13, -13,
-12, -12, -10, -10, -8, -8, -7, -7, -6, -6, -5, -4, -4, -3, -4, -3, -2, -2, -2,
-2, -2, -1, -1, -2, -1, -1, -1, 0, };