#define DATA_LENGTH 512
#define DATA AKWF_1185

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 7, 9, 11, 14, 16, 17, 20, 22,
23, 25, 27, 29, 31, 34, 34, 37, 37, 39, 41, 43, 44, 45, 46, 48, 49, 50, 51, 53,
55, 56, 57, 58, 59, 61, 61, 62, 63, 64, 65, 66, 66, 67, 68, 69, 70, 71, 71, 72,
73, 73, 74, 74, 76, 75, 76, 76, 77, 77, 78, 77, 78, 78, 79, 79, 80, 80, 79, 80,
80, 80, 81, 81, 81, 80, 81, 81, 81, 81, 81, 81, 80, 80, 81, 81, 80, 80, 80, 81,
80, 79, 79, 80, 79, 79, 80, 78, 79, 78, 78, 78, 77, 76, 77, 76, 77, 76, 76, 75,
75, 75, 74, 74, 73, 73, 73, 72, 72, 72, 70, 71, 69, 69, 69, 68, 68, 68, 67, 68,
66, 65, 66, 65, 64, 65, 64, 63, 62, 62, 62, 61, 60, 61, 60, 60, 58, 58, 58, 58,
57, 56, 56, 56, 55, 55, 54, 54, 54, 53, 52, 52, 52, 51, 51, 51, 51, 50, 49, 49,
48, 48, 48, 48, 46, 46, 46, 46, 46, 44, 44, 44, 44, 43, 43, 43, 43, 43, 43, 42,
41, 42, 41, 41, 40, 40, 40, 40, 39, 38, 39, 38, 38, 39, 39, 38, 38, 37, 38, 38,
37, 37, 37, 37, 37, 37, 37, 36, 36, 37, 36, 36, 36, 36, 35, 35, 36, 36, 36, 36,
35, 35, 35, 36, 35, 35, 35, 35, 35, 35, 36, 35, 35, 35, 35, 35, 35, 36, 35, 36,
36, 36, 36, 36, 36, 36, 36, 35, 36, 36, 36, 36, 36, 35, 36, 36, 36, 36, 36, 37,
36, 37, 36, 36, 37, 37, 37, 36, 37, 36, 38, 37, 36, 36, 36, 37, 37, 37, 36, 37,
37, 37, 37, 37, 37, 37, 37, 37, 37, 37, 36, 37, 36, 36, 36, 36, 36, 36, 35, 36,
36, 36, 36, 36, 35, 34, 35, 35, 36, 35, 35, 35, 34, 34, 33, 34, 34, 33, 34, 33,
33, 33, 32, 33, 33, 32, 33, 32, 31, 30, 31, 30, 30, 30, 29, 29, 30, 28, 28, 29,
28, 27, 27, 28, 28, 26, 25, 25, 25, 25, 25, 25, 24, 24, 24, 24, 23, 23, 22, 22,
21, 21, 20, 20, 20, 20, 19, 19, 19, 18, 18, 18, 16, 16, 16, 16, 15, 15, 13, 12,
11, 10, 8, 6, 4, 2, 1, -1, -4, -6, -9, -11, -14, -17, -20, -22, -26, -28, -33,
-35, -39, -42, -46, -49, -52, -56, -59, -61, -65, -69, -72, -74, -77, -81, -82,
-86, -89, -91, -94, -96, -98, -101, -103, -104, -105, -108, -109, -111, -112,
-114, -115, -115, -116, -117, -117, -118, -118, -118, -119, -119, -119, -119,
-119, -118, -118, -117, -116, -115, -116, -114, -113, -112, -110, -110, -109,
-107, -105, -103, -102, -101, -98, -96, -94, -92, -91, -89, -86, -85, -82, -79,
-77, -74, -72, -69, -67, -63, -61, -59, -56, -54, -51, -48, -46, -44, -41, -38,
-35, -32, -31, -27, -25, -23, -20, -18, -16, -13, -10, -8, -5, -4, -1, };