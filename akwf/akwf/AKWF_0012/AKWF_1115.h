#define DATA_LENGTH 512
#define DATA AKWF_1115

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 6, 10, 14, 17, 22, 26, 31, 36,
47, 58, 61, 67, 65, 68, 64, 59, 49, 59, 79, 75, 77, 76, 74, 73, 72, 70, 71, 71,
70, 66, 65, 66, 72, 76, 81, 83, 83, 79, 80, 77, 77, 73, 68, 66, 64, 60, 57, 57,
54, 61, 64, 66, 62, 79, 25, -9, 7, 1, 17, 24, 32, 36, 40, 38, 37, 33, 36, 33,
30, 28, 24, 19, 11, 11, 10, 9, 7, 11, 18, 25, 23, 28, 28, 33, 32, 38, 40, 43,
42, 44, 43, 46, 68, 66, 68, 51, 31, 28, 26, 28, 27, 35, 39, 43, 47, 46, 43, 44,
45, 46, 46, 47, 46, 48, 50, 51, 49, 49, 50, 49, 49, 49, 50, 47, 47, 45, 43, 46,
49, 51, 58, 63, 61, 66, 68, 69, 70, 70, 71, 67, 67, 64, 61, 59, 61, 63, 66, 64,
61, 63, 63, 62, 63, 65, 66, 65, 67, 69, 68, 69, 72, 76, 78, 76, 78, 68, 59, 59,
54, 55, 58, 63, 69, 74, 79, 86, 92, 97, 101, 104, 108, 115, 111, 108, 108, 108,
111, 113, 119, 119, 119, 118, 120, 117, 118, 120, 118, 118, 117, 116, 114, 110,
106, 104, 103, 106, 107, 107, 107, 104, 101, 92, 84, 81, 73, 70, 72, 54, 34, 32,
30, 31, 33, 35, 36, 36, 34, 33, 34, 34, 35, 30, 29, 29, 28, 26, 24, 23, 23, 23,
24, 22, 19, 18, 17, 15, 12, 8, 4, 3, -1, -6, -15, -24, -26, -18, -18, -21, -22,
-25, -30, -36, -40, -44, -50, -56, -61, -62, -63, -66, -68, -67, -67, -73, -75,
-76, -75, -77, -76, -74, -72, -77, -77, -75, -71, -64, -60, -56, -55, -49, -47,
-42, -38, -34, -31, -28, -26, -16, -8, -5, -3, 0, 2, 2, -1, -7, -8, -6, -3, -6,
16, 25, 19, 19, 12, 8, 2, -4, -8, -11, -13, -20, -28, -29, -31, -32, -34, -31,
-29, -29, -33, -36, -38, -46, -57, -64, -66, -66, -70, -74, -75, -79, -79, -79,
-82, -86, -88, -90, -95, -98, -98, -91, -84, -81, -78, -76, -73, -73, -73, -72,
-71, -67, -64, -64, -68, -69, -69, -65, -57, -55, -58, -56, -53, -54, -56, -57,
-56, -57, -58, -57, -59, -54, -50, -58, -55, -47, -46, -47, -46, -45, -46, -50,
-55, -55, -58, -58, -60, -62, -63, -64, -64, -63, -61, -58, -59, -68, -68, -64,
-60, -61, -58, -53, -50, -47, -45, -45, -44, -43, -44, -40, -38, -38, -37, -41,
-42, -42, -43, -45, -50, -52, -54, -58, -60, -59, -58, -58, -58, -60, -57, -57,
-56, -57, -59, -65, -75, -79, -82, -85, -96, -101, -106, -108, -107, -110, -113,
-116, -117, -105, -97, -94, -93, -94, -96, -100, -101, -101, -100, -100, -96,
-95, -94, -93, -89, -81, -77, -81, -80, -82, -83, -85, -84, -80, -80, -82, -84,
-82, -80, -77, -75, -73, -69, -57, -52, -51, -52, -57, -56, -52, -47, -43, -36,
-30, -28, -18, -11, -9, -4, -3, -1, 0, };