#define DATA_LENGTH 512
#define DATA AKWF_1183

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 4, 6, 7, 9, 11, 11, 12, 12, 12,
14, 15, 15, 16, 15, 16, 15, 15, 16, 16, 17, 17, 17, 16, 16, 16, 17, 15, 16, 16,
15, 16, 16, 16, 16, 17, 16, 17, 17, 17, 16, 16, 17, 17, 17, 16, 17, 17, 17, 18,
17, 18, 18, 19, 18, 18, 19, 20, 19, 20, 19, 21, 21, 21, 21, 21, 21, 22, 22, 22,
22, 22, 23, 23, 23, 23, 24, 23, 24, 23, 24, 24, 24, 23, 24, 25, 24, 24, 24, 23,
25, 24, 24, 24, 24, 24, 24, 23, 23, 23, 23, 23, 24, 23, 23, 23, 23, 24, 23, 24,
23, 23, 24, 23, 23, 23, 23, 24, 24, 24, 24, 24, 24, 25, 25, 25, 25, 26, 27, 27,
27, 27, 28, 28, 28, 28, 29, 29, 29, 29, 30, 29, 30, 29, 30, 30, 30, 30, 30, 29,
30, 29, 30, 30, 29, 30, 29, 29, 28, 28, 28, 27, 27, 27, 27, 27, 27, 26, 26, 24,
25, 24, 24, 25, 24, 23, 23, 24, 23, 24, 23, 22, 22, 21, 21, 22, 22, 23, 22, 22,
22, 22, 20, 19, 19, 19, 18, 18, 18, 18, 16, 16, 14, 9, 6, 5, 4, 1, 2, 5, 7, 3,
6, 4, 2, -7, -3, -7, -5, -10, 3, 2, 5, -2, 14, -5, -114, -85, -75, -78, -76,
-82, -80, -87, -85, -90, -89, -91, -89, -92, -89, -91, -88, -90, -88, -89, -87,
-88, -87, -87, -86, -86, -86, -86, -86, -86, -86, -85, -85, -84, -84, -82, -83,
-80, -79, -77, -77, -74, -74, -72, -71, -68, -72, -71, -75, -75, -81, -79, -84,
-85, -90, -91, -95, -97, -99, -104, -102, -118, -25, -8, -26, -12, -18, -9, -12,
-5, -8, -4, -6, -2, -4, -1, -2, -1, -1, -1, 0, -1, -1, -2, -3, -3, -3, -4, -4,
-5, -5, -7, -7, -7, -8, -9, -9, -11, -12, -13, -13, -13, -14, -15, -15, -16,
-17, -18, -17, -18, -19, -20, -20, -21, -22, -22, -21, -22, -22, -23, -23, -23,
-23, -23, -24, -25, -24, -24, -25, -25, -26, -25, -24, -25, -26, -25, -25, -26,
-25, -26, -26, -25, -26, -26, -26, -25, -26, -25, -26, -26, -25, -24, -25, -25,
-25, -24, -25, -25, -25, -23, -24, -25, -25, -24, -24, -24, -24, -23, -23, -24,
-24, -23, -24, -22, -23, -23, -22, -22, -24, -23, -23, -22, -23, -23, -23, -22,
-23, -22, -22, -22, -22, -22, -21, -22, -22, -22, -22, -21, -21, -21, -21, -21,
-20, -20, -20, -19, -19, -19, -19, -18, -18, -17, -16, -17, -16, -16, -16, -15,
-14, -14, -12, -12, -11, -11, -9, -8, -7, -5, -5, -4, -2, 0, 3, 4, 6, 8, 9, 11,
13, 13, 14, 14, 15, 15, 16, 16, 17, 16, 17, 17, 16, 17, 16, 16, 15, 10, -5, -21,
-29, -32, -32, -31, -30, -29, -27, -26, -25, -23, -23, -23, -22, -21, -20, -20,
-19, -18, -16, -14, -13, -12, -8, -7, -5, -3, -1, };