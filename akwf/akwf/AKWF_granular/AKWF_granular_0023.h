#define DATA_LENGTH 512
#define DATA AKWF_granular_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 14, 20, 26, 32, 39, 44, 50, 55, 60,
65, 70, 75, 79, 83, 87, 91, 95, 99, 102, 104, 107, 110, 113, 115, 117, 117, 118,
119, 119, 118, 109, 105, 101, 98, 95, 93, 90, 87, 85, 83, 81, 78, 77, 74, 74,
71, 69, 68, 65, 64, 62, 61, 59, 57, 56, 55, 54, 51, 50, 49, 48, 47, 45, 44, 42,
40, 40, 38, 37, 37, 34, 34, 32, 31, 30, 29, 28, 26, 26, 24, 23, 23, 21, 20, 19,
18, 17, 16, 15, 14, 13, 12, 11, 10, 9, 8, 7, 6, 6, 5, 3, 2, 1, 1, 0, -1, -1, -3,
-3, -4, -5, -6, -7, -8, -9, -9, -10, -10, -12, -12, -13, -14, -14, -15, -16,
-17, -17, -18, -19, -20, -20, -21, -22, -22, -23, -23, -23, -25, -25, -25, -25,
-26, -27, -26, -27, -27, -28, -29, -29, -28, -29, -30, -30, -30, -31, -30, -31,
-31, -32, -32, -32, -32, -33, -33, -34, -35, -34, -35, -36, -36, -37, -36, -36,
-37, -37, -38, -38, -38, -39, -39, -39, -40, -40, -40, -41, -42, -41, -42, -42,
-42, -43, -42, -43, -43, -44, -45, -44, -45, -45, -45, -45, -46, -45, -45, -46,
-47, -47, -47, -47, -47, -47, -48, -48, -48, -48, -47, -48, -48, -48, -48, -48,
-50, -49, -49, -49, -49, -50, -50, -49, -50, -49, -50, -50, -49, -50, -50, -49,
-50, -50, -51, -51, -50, -50, -50, -50, -50, -51, -50, -51, -49, -51, -47, -28,
-16, -5, 4, 11, 18, 25, 29, 34, 40, 46, 51, 55, 60, 64, 68, 71, 75, 77, 81, 83,
86, 88, 91, 93, 95, 96, 97, 98, 99, 100, 101, 101, 101, 94, 90, 87, 84, 81, 79,
77, 75, 73, 71, 69, 67, 65, 63, 63, 60, 60, 58, 56, 54, 53, 52, 51, 49, 47, 46,
45, 44, 44, 41, 40, 39, 38, 38, 35, 34, 33, 33, 31, 31, 29, 28, 27, 26, 25, 24,
23, 22, 21, 21, 19, 19, 17, 17, 17, 14, 14, 14, 12, 11, 11, 10, 10, 9, 8, 7, 6,
5, 4, 4, 3, 2, 2, 0, -1, -1, -2, -3, -3, -4, -4, -6, -6, -7, -8, -9, -10, -10,
-10, -11, -11, -12, -12, -13, -14, -14, -16, -16, -16, -17, -17, -18, -19, -19,
-20, -20, -20, -21, -23, -22, -23, -23, -24, -23, -24, -25, -26, -27, -27, -28,
-28, -29, -29, -28, -30, -30, -30, -30, -32, -32, -32, -32, -32, -34, -33, -34,
-35, -35, -35, -37, -37, -37, -37, -38, -38, -39, -38, -39, -39, -39, -39, -40,
-40, -41, -41, -41, -42, -42, -42, -42, -43, -43, -43, -43, -43, -44, -45, -44,
-45, -45, -45, -45, -47, -45, -46, -46, -46, -47, -47, -47, -48, -47, -48, -48,
-48, -49, -49, -49, -48, -49, -49, -48, -48, -49, -49, -49, -50, -50, -50, -50,
-49, -50, -50, -50, -50, -51, -50, -50, -50, -50, -50, -51, -50, -50, -51, -51,
-50, -50, -51, -49, -50, -37, -18, -11, 0, };