#define DATA_LENGTH 512
#define DATA AKWF_granular_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 15, 24, 31, 39, 44, 49, 51, 51, 51,
50, 47, 43, 39, 35, 31, 26, 23, 18, 14, 11, 9, 6, 5, 3, 2, 1, 0, 0, 0, 0, 0, -1,
0, 0, -1, -3, -3, -5, -7, -9, -14, -18, -22, -28, -34, -40, -48, -55, -62, -68,
-74, -78, -81, -81, -79, -75, -67, -56, -44, -28, -12, 5, 22, 39, 54, 67, 78,
85, 90, 92, 92, 89, 84, 77, 70, 62, 54, 47, 38, 32, 25, 20, 16, 12, 8, 6, 3, 2,
1, 0, 1, 1, 0, 0, -1, -1, -2, -3, -4, -7, -9, -14, -19, -25, -32, -40, -49, -59,
-69, -80, -91, -100, -109, -114, -118, -119, -115, -110, -99, -85, -67, -46,
-23, 0, 25, 47, 68, 86, 100, 109, 117, 119, 117, 114, 108, 100, 90, 80, 70, 60,
50, 41, 33, 26, 20, 15, 10, 8, 5, 2, 1, 1, 1, -1, 0, 0, 0, 0, -2, -2, -4, -6,
-9, -13, -16, -22, -28, -36, -43, -51, -60, -67, -77, -84, -91, -96, -99, -100,
-98, -93, -83, -72, -58, -41, -24, -4, 14, 33, 48, 63, 74, 82, 87, 89, 88, 85,
81, 74, 67, 59, 51, 44, 37, 31, 24, 19, 15, 11, 8, 5, 3, 2, 0, 0, 0, 0, 0, 0, 0,
0, -1, -1, -2, -3, -4, -7, -10, -13, -16, -21, -26, -30, -35, -40, -44, -50,
-53, -58, -59, -59, -59, -56, -51, -44, -37, -27, -17, -6, 6, 16, 25, 33, 40,
45, 47, 49, 48, 47, 44, 42, 36, 33, 29, 25, 19, 17, 13, 11, 8, 6, 4, 3, 2, 1, 1,
0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, -1, -3, -4, -4, -6, -8, -8, -11, -13, -14,
-15, -17, -18, -19, -19, -18, -19, -18, -16, -13, -12, -8, -5, -2, 0, 4, 5, 8,
8, 9, 9, 9, 8, 7, 7, 5, 5, 3, 3, 2, 2, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, -1, 0, 0, 0, 0, -1, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0,
1, 0, 0, 0, -1, -1, 0, 1, 1, 0, 1, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 1, 0, 1,
0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 1, 0, 0, 0, 1, -1, 0, 0, 0, 0,
-1, 1, 0, 1, 2, 4, 4, 5, 5, 6, 6, 5, 5, 6, 5, 5, 4, 3, 3, 3, 2, 1, 1, 1, 1, 0,
-1, 0, 0, 1, 0, 1, 1, 3, 4, 7, 7, 9, 9, 10, 12, 12, 11, 12, 10, 9, 9, 9, 7, 6,
5, 4, 3, 3, 2, 2, 0, 1, 1, 1, 0, 0, 1, 0, 0, 0, 0, -1, -1, -2, -3, -3, -5, -7,
-10, -11, -14, -17, -21, -24, -27, -31, -34, -38, -39, -41, -41, -38, -36, -32,
-26, -20, -11, -2, };