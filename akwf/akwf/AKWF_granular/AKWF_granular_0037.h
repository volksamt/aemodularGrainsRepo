#define DATA_LENGTH 512
#define DATA AKWF_granular_0037

const PROGMEM int8_t DATA[DATA_LENGTH] = {21, 31, 43, 57, 81, 97, 114, 118, 113,
113, 98, 87, 70, 52, 26, 12, -17, -36, -48, -57, -64, -68, -71, -73, -65, -58,
-49, -46, -37, -32, -20, -17, -6, -1, 3, 11, 22, 29, 39, 49, 47, 52, 52, 52, 48,
45, 30, 14, -6, -25, -41, -58, -71, -82, -90, -95, -95, -93, -85, -75, -64, -54,
-45, -32, -23, -17, -11, -9, -3, 3, 9, 17, 22, 25, 36, 40, 46, 52, 50, 47, 43,
30, 21, 11, -7, -21, -40, -54, -66, -73, -77, -76, -79, -72, -66, -61, -48, -36,
-27, -19, -6, -5, 4, 8, 8, 10, 18, 18, 24, 27, 28, 30, 34, 41, 46, 57, 59, 57,
55, 64, 51, 51, 38, 19, 12, 5, -8, -16, -22, -36, -30, -38, -32, -27, -19, -15,
-9, -13, -5, 0, -1, -1, -6, -2, 0, 6, 4, 5, 3, 12, 17, 32, 50, 64, 73, 88, 85,
83, 84, 74, 62, 53, 34, 15, -2, -20, -29, -44, -45, -52, -52, -49, -40, -45,
-37, -30, -30, -21, -12, -2, 6, 22, 27, 46, 52, 74, 82, 87, 96, 100, 93, 86, 77,
53, 45, 19, 0, -25, -42, -59, -72, -87, -89, -90, -90, -78, -77, -67, -56, -44,
-40, -24, -19, -9, -3, -2, 6, 12, 20, 24, 30, 30, 36, 35, 34, 30, 23, 17, 5, -5,
-19, -34, -49, -63, -77, -84, -91, -91, -87, -83, -77, -69, -58, -46, -34, -23,
-15, -7, 0, 4, 6, 12, 13, 14, 21, 19, 27, 33, 38, 42, 54, 56, 58, 56, 48, 38,
29, 16, -5, -16, -31, -44, -58, -64, -75, -74, -66, -62, -58, -44, -35, -29,
-15, -5, -1, 8, 14, 9, 11, 13, 14, 18, 25, 22, 29, 29, 30, 35, 45, 45, 59, 58,
55, 62, 50, 44, 31, 21, 10, 10, -3, -11, -22, -24, -26, -29, -19, -17, -10, -3,
-3, -11, 0, -6, -2, -1, -6, -7, -2, -7, -1, 15, 26, 56, 70, 94, 102, 112, 106,
102, 91, 86, 73, 47, 30, -2, -15, -37, -38, -57, -50, -53, -48, -51, -42, -41,
-42, -26, -31, -13, -10, 3, 1, 13, 14, 32, 43, 53, 73, 74, 81, 78, 75, 66, 65,
46, 30, 8, -11, -36, -55, -72, -84, -90, -97, -94, -96, -86, -79, -69, -60, -43,
-31, -18, -11, -4, -1, 1, 10, 11, 20, 23, 29, 26, 31, 32, 34, 32, 28, 20, 8, -2,
-19, -29, -47, -58, -70, -79, -84, -86, -87, -84, -78, -70, -59, -46, -35, -25,
-15, -11, -1, -1, 8, 10, 11, 13, 14, 15, 17, 22, 25, 31, 35, 48, 50, 58, 69, 61,
54, 44, 30, 20, 16, -4, -17, -35, -45, -52, -55, -51, -48, -40, -33, -28, -27,
-8, -6, -2, 3, -2, -5, 3, -7, -6, -2, -5, 4, 11, 13, 19, 29, 28, 40, 46, 61, 68,
80, 71, 69, 53, 42, 42, 29, 15, 6, -12, -33, -20, -34, -35, -25, -23, -33, -14,
-20, -24, -11, -16, -21, -16, -1, -1, };