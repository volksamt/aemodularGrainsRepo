#define DATA_LENGTH 512
#define DATA AKWF_granular_0031

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 14, 16, 19, 23, 27, 37, 41, 46, 56,
67, 77, 80, 80, 82, 81, 76, 76, 73, 65, 58, 54, 54, 50, 45, 42, 38, 36, 33, 31,
30, 29, 24, 27, 35, 41, 51, 64, 78, 90, 96, 101, 109, 115, 114, 112, 116, 119,
117, 119, 116, 106, 97, 89, 78, 70, 58, 42, 33, 27, 19, 10, 3, -2, -6, -7, -5,
-2, -2, 0, 9, 23, 33, 46, 65, 81, 88, 95, 101, 105, 104, 101, 106, 110, 103,
106, 109, 102, 97, 87, 71, 65, 55, 37, 21, 15, 3, -11, -13, -13, -16, -18, -16,
-11, -5, -2, 4, 14, 22, 35, 52, 64, 72, 76, 79, 85, 84, 79, 79, 79, 73, 70, 72,
64, 54, 45, 33, 23, 15, -2, -17, -25, -34, -44, -46, -45, -43, -40, -35, -27,
-22, -21, -18, -9, -5, -3, 2, 14, 23, 26, 32, 38, 41, 37, 33, 33, 25, 14, 6, -3,
-9, -17, -29, -37, -44, -55, -64, -71, -76, -79, -83, -80, -76, -72, -67, -57,
-52, -46, -39, -32, -26, -23, -22, -16, -12, -11, -8, -4, -3, -8, -13, -18, -29,
-40, -52, -63, -72, -80, -88, -93, -98, -101, -105, -107, -106, -107, -106,
-102, -98, -91, -84, -75, -65, -58, -50, -41, -33, -27, -24, -20, -16, -16, -16,
-14, -15, -19, -25, -31, -37, -46, -55, -65, -72, -80, -85, -90, -91, -91, -90,
-90, -87, -84, -82, -78, -74, -68, -63, -55, -47, -39, -33, -25, -20, -17, -15,
-14, -14, -17, -22, -26, -29, -33, -39, -46, -51, -56, -62, -67, -71, -75, -80,
-80, -81, -77, -74, -69, -65, -59, -51, -45, -38, -30, -23, -17, -8, -1, 6, 11,
15, 18, 19, 19, 18, 15, 10, 6, 1, -4, -8, -14, -19, -23, -28, -32, -34, -38,
-39, -39, -36, -33, -30, -26, -21, -15, -9, -4, 1, 8, 13, 16, 19, 20, 20, 20,
18, 15, 12, 7, 2, -2, -8, -14, -21, -26, -31, -35, -39, -42, -43, -45, -43, -44,
-41, -36, -33, -27, -20, -13, -7, -1, 4, 11, 13, 17, 20, 24, 27, 26, 26, 27, 24,
22, 20, 16, 13, 9, 5, 0, -3, -7, -11, -13, -13, -13, -10, -9, -7, -5, -3, 0, 2,
5, 7, 10, 12, 13, 15, 14, 13, 13, 13, 14, 14, 11, 10, 8, 4, 2, 0, -4, -9, -12,
-14, -17, -19, -21, -22, -22, -20, -18, -15, -14, -13, -10, -8, -7, -6, -1, 0,
4, 7, 8, 10, 12, 12, 12, 12, 9, 8, 9, 8, 6, 2, -1, -4, -6, -9, -11, -14, -16,
-17, -16, -15, -12, -13, -13, -9, -6, -5, -3, -4, -4, -2, -2, -2, -1, 0, -1, 0,
2, 2, -2, -3, -5, -6, -9, -14, -18, -17, -17, -16, -13, -8, -6, -4, 0, 8, 13,
12, 15, 21, 25, 27, 30, 35, 40, 40, 39, 43, 44, 41, 37, 34, 31, 28, 19, 19, 20,
14, 4, 1, 2, -1, -7, -11, -13, -12, -11, -12, -5, 1, 0, };