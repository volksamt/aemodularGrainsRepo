#define DATA_LENGTH 512
#define DATA AKWF_granular_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 8, 12, 15, 19, 23, 27, 30, 34,
37, 41, 43, 46, 50, 53, 54, 58, 59, 62, 63, 66, 67, 69, 71, 73, 75, 76, 77, 77,
80, 80, 82, 81, 85, 83, 85, 84, 86, 85, 89, 85, 89, 86, 90, 86, 90, 87, 90, 88,
90, 76, -79, -104, -93, -104, -97, -107, -101, -110, -105, -112, -109, -114,
-112, -116, -115, -118, -118, -118, -118, -118, -118, -116, -116, -114, -114,
-112, -110, -108, -107, -104, -102, -97, -94, -90, -87, -81, -77, -72, -66, -60,
-52, -45, -38, -30, -22, -13, -6, 3, 12, 21, 28, 37, 44, 51, 58, 64, 71, 75, 81,
86, 90, 94, 98, 100, 103, 106, 108, 109, 112, 112, 114, 115, 117, 117, 119, 118,
119, 119, 119, 119, 119, 118, 118, 118, 117, 117, 116, 116, 113, 115, 113, 114,
110, 112, 107, 111, 103, 111, 39, -100, -109, -110, -112, -112, -115, -114,
-116, -115, -119, -116, -119, -117, -119, -118, -120, -119, -119, -118, -118,
-117, -116, -116, -115, -114, -111, -110, -108, -107, -103, -100, -97, -94, -90,
-86, -81, -77, -71, -65, -58, -51, -44, -37, -29, -20, -12, -3, 5, 13, 21, 31,
37, 44, 52, 60, 65, 72, 77, 81, 86, 90, 95, 99, 101, 103, 106, 108, 111, 113,
113, 115, 116, 117, 117, 117, 115, 115, 114, 113, 111, 111, 109, 109, 106, 106,
104, 103, 101, 100, 97, 97, 95, 93, 92, 88, 88, 82, 89, -15, -82, -78, -85, -80,
-85, -81, -84, -80, -83, -81, -82, -80, -80, -78, -77, -76, -76, -74, -73, -72,
-70, -69, -67, -66, -64, -63, -60, -59, -55, -54, -51, -50, -46, -44, -41, -37,
-35, -31, -28, -25, -21, -18, -15, -11, -8, -4, 0, 2, 5, 8, 10, 13, 14, 17, 19,
20, 22, 23, 23, 24, 24, 23, 23, 23, 24, 23, 22, 22, 21, 21, 20, 18, 18, 17, 16,
15, 14, 12, 12, 11, 11, 10, 8, 7, 6, 4, 4, 2, 2, 1, -1, 0, 0, 0, 0, 0, 1, 0, 1,
0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 1, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, -1, 0, 0, 0,
0, -1, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1,
0, 1, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1,
-1, -1, 0, 0, 0, 0, 0, -1, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0,
1, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, -1, -2, -3, -5, -5, -6, -7, -7,
-9, -10, -10, -12, -14, -14, -15, -17, -17, -18, -20, -21, -22, -22, -23, -24,
-24, -26, -26, -25, -26, -27, -27, -27, -27, -26, -26, -25, -25, -23, -22, -21,
-19, -16, -14, -11, -9, -5, -2, };