#define DATA_LENGTH 512
#define DATA AKWF_granular_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 3, 3, 3, 4, 4, 4, 4, 4, 3, 4, 4,
4, 5, 4, 4, 5, 6, 6, 6, 6, 7, 6, 6, 7, 6, 6, 6, 6, 6, 9, 12, 15, 19, 19, 15, 8,
1, -5, -9, -10, -12, -12, -11, -7, -3, 1, 4, 7, 11, 12, 14, 17, 19, 20, 21, 21,
20, 16, 10, 3, -1, -2, 1, 5, 13, 19, 23, 25, 23, 19, 15, 12, 8, 7, 5, 4, 3, 1,
0, -1, 1, 3, 2, -3, -15, -35, -67, -90, -85, -66, -50, -38, -31, -23, -18, -14,
-10, -6, -3, 1, 4, 8, 11, 12, 14, 15, 29, 44, 41, 32, 23, 20, 20, 23, 29, 35,
41, 43, 41, 37, 31, 25, 20, 15, 13, 10, 8, 7, 5, 6, 6, 9, 11, 11, 9, 4, -2, -5,
-8, -11, -14, -18, -22, -26, -25, -17, -7, 1, 7, 8, 9, 7, 7, 6, 3, 2, 1, -1, -2,
-3, -4, -5, -5, -6, -6, -4, -4, -3, -3, -4, -4, -5, -7, -8, -8, -9, -9, -9, -9,
-11, -11, -11, -9, -9, -11, -18, -29, -54, -93, -119, -114, -91, -65, -47, -35,
-26, -18, -12, -7, -2, 0, 2, 5, 7, 8, 8, 8, 8, 8, 8, 7, 7, 7, 7, 7, 8, 7, 8, 8,
8, 8, 9, 8, 8, 7, 8, 7, 7, 7, 7, 6, 8, 9, 10, 12, 12, 12, 8, 3, 1, -1, -3, -4,
-3, -4, -2, 0, 1, 3, 5, 6, 6, 7, 8, 8, 8, 9, 8, 8, 7, 6, 4, 2, 3, 2, 3, 5, 6, 8,
10, 11, 14, 14, 12, 13, 13, 13, 14, 14, 15, 13, 11, 11, 13, 15, 11, 1, -15, -36,
-44, -37, -28, -22, -17, -13, -10, -8, -7, -5, -3, -2, 0, 2, 3, 5, 5, 7, 7, 9,
19, 24, 22, 18, 14, 13, 12, 13, 12, 13, 10, 9, 8, 6, 5, 4, 3, 2, 1, 0, 0, 0, 0,
0, 0, 1, 1, 1, 0, 0, -1, -2, -3, -2, -2, -3, -3, -4, -3, -3, 0, 0, 0, 0, 1, 0,
0, 0, 0, 0, -1, -1, 0, -1, -1, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, -1, 0,
0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0,
0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, -1, 0, 1, 0, 0, 0, 0, -1, 0, 0,
0, 0, -1, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0, -1, -1, -1, -1, -2,
-2, -2, -1, -1, -1, 0, 0, 0, 1, 0, 0, -1, -1, 0, -1, -1, 0, -1, 0, -2, -1, -1,
-1, -2, -1, -1, -1, -1, -2, -2, -2, -2, -2, -2, -3, -3, -3, -3, -2, -2, -3, -4,
-8, -14, -25, -36, -37, -32, -24, -18, -13, -10, -7, -5, -2, -2, -1, };