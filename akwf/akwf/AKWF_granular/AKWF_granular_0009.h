#define DATA_LENGTH 512
#define DATA AKWF_granular_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 13, 17, 22, 26, 31, 36, 40, 46,
50, 54, 59, 64, 68, 73, 77, 80, 85, 88, 93, 96, 100, 103, 106, 108, 110, 112,
114, 115, 116, 118, 119, 118, 119, 119, 118, 119, 117, 117, 115, 115, 114, 111,
109, 107, 104, 102, 100, 96, 92, 89, 86, 81, 78, 74, 69, 65, 60, 56, 52, 47, 42,
37, 31, 26, 21, 17, 12, 6, 0, -5, -11, -16, -21, -26, -31, -37, -41, -46, -51,
-55, -60, -65, -68, -74, -77, -81, -86, -89, -92, -96, -99, -101, -105, -106,
-109, -110, -112, -114, -115, -117, -118, -119, -119, -119, -119, -119, -118,
-118, -117, -115, -114, -112, -110, -109, -107, -104, -101, -98, -95, -92, -89,
-85, -81, -77, -73, -68, -64, -60, -54, -51, -45, -41, -35, -30, -25, -21, -15,
-10, -5, 0, 7, 11, 17, 22, 27, 33, 37, 42, 48, 52, 58, 62, 66, 70, 74, 78, 83,
86, 90, 94, 97, 99, 102, 104, 108, 109, 111, 113, 115, 115, 117, 118, 119, 118,
119, 118, 119, 117, 117, 116, 115, 114, 112, 109, 108, 105, 103, 100, 97, 94,
91, 88, 83, 80, 75, 72, 67, 63, 59, 54, 49, 44, 39, 34, 28, 24, 19, 13, 8, 3,
-2, -8, -12, -18, -23, -29, -34, -39, -44, -49, -53, -57, -62, -67, -72, -75,
-80, -83, -87, -91, -94, -96, -99, -103, -106, -108, -110, -112, -114, -115,
-116, -117, -118, -118, -118, -118, -117, -116, -115, -114, -111, -110, -107,
-106, -103, -99, -98, -94, -92, -88, -84, -80, -77, -73, -69, -65, -62, -56,
-53, -48, -44, -40, -34, -31, -27, -22, -18, -13, -9, -5, -1, 3, 8, 11, 15, 18,
23, 26, 30, 34, 36, 39, 42, 44, 48, 50, 53, 55, 57, 58, 61, 61, 64, 65, 66, 67,
67, 68, 69, 69, 70, 69, 70, 69, 68, 68, 67, 66, 66, 64, 63, 63, 61, 59, 57, 56,
54, 52, 50, 48, 46, 44, 42, 39, 37, 35, 33, 31, 28, 26, 23, 21, 19, 17, 15, 13,
10, 8, 5, 4, 2, -1, -2, -4, -5, -7, -9, -10, -12, -13, -14, -15, -16, -17, -18,
-19, -19, -20, -20, -21, -22, -21, -22, -21, -20, -20, -19, -19, -18, -18, -16,
-14, -13, -12, -11, -9, -8, -6, -5, -2, 0, 0, 3, 4, 6, 9, 10, 12, 14, 16, 17,
19, 20, 21, 23, 24, 25, 27, 28, 28, 29, 30, 29, 29, 29, 30, 30, 30, 28, 28, 28,
26, 26, 25, 24, 24, 22, 21, 20, 18, 16, 14, 13, 11, 9, 7, 5, 3, 0, -1, -4, -6,
-9, -12, -14, -16, -19, -22, -24, -26, -29, -33, -34, -37, -39, -42, -45, -47,
-50, -53, -54, -56, -59, -61, -64, -65, -67, -68, -70, -72, -72, -74, -75, -75,
-76, -77, -77, -78, -78, -77, -78, -77, -76, -76, -75, -74, -73, -72, -70, -68,
-65, -64, -62, -59, -56, -54, -50, -47, -44, -41, -38, -35, -29, -27, -22, -17,
-14, -9, -5, -1, };