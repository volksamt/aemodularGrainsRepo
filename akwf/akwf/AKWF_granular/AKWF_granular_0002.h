#define DATA_LENGTH 512
#define DATA AKWF_granular_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 8, 10, 12, 16, 19, 21, 23,
27, 29, 32, 35, 39, 42, 46, 48, 52, 55, 59, 61, 65, 67, 70, 73, 77, 78, 82, 84,
87, 89, 90, 92, 94, 95, 96, 98, 98, 103, 80, 64, 68, 68, 72, 73, 74, 76, 79, 79,
81, 83, 84, 86, 87, 88, 88, 88, 89, 90, 90, 92, 91, 92, 92, 92, 93, 94, 95, 95,
97, 97, 97, 98, 100, 100, 101, 102, 102, 102, 104, 104, 103, 104, 105, 105, 105,
106, 105, 108, 106, 109, 105, 110, 106, 112, 104, 113, 102, 118, 71, -56, -41,
-43, -41, -40, -41, -37, -38, -35, -35, -32, -34, -30, -31, -29, -29, -27, -26,
-24, -24, -21, -21, -19, -19, -17, -17, -15, -14, -13, -12, -11, -9, -8, -7, -6,
-5, -4, -2, -1, 0, 1, 1, 5, 5, 8, 7, 10, 10, 12, 14, 16, 15, 18, 19, 22, 22, 24,
26, 26, 36, -64, -110, -99, -103, -98, -101, -97, -100, -96, -97, -94, -94, -92,
-92, -91, -90, -88, -87, -86, -86, -85, -83, -83, -82, -81, -80, -79, -80, -78,
-78, -77, -77, -77, -76, -76, -76, -75, -75, -74, -74, -74, -74, -73, -73, -73,
-72, -71, -70, -69, -68, -68, -66, -64, -63, -63, -60, -59, -56, -55, -52, -53,
-67, -66, -63, -62, -59, -59, -56, -53, -50, -47, -44, -42, -36, -34, -30, -28,
-24, -21, -18, -15, -11, -8, -4, -2, 1, 4, 7, 10, 12, 14, 17, 19, 22, 24, 27,
28, 30, 32, 34, 34, 37, 37, 39, 40, 40, 41, 41, 42, 44, 43, 44, 45, 46, 46, 46,
47, 48, 47, 48, 48, 50, 50, 50, 51, 52, 52, 53, 53, 55, 57, 57, 58, 59, 61, 62,
64, 65, 66, 68, 69, 72, 73, 75, 77, 79, 80, 82, 84, 86, 87, 89, 90, 92, 93, 96,
95, 97, 98, 101, 100, 103, 102, 105, 104, 106, 109, 33, 6, 14, 12, 17, 15, 20,
20, 22, 22, 25, 26, 28, 29, 31, 31, 33, 34, 37, 37, 39, 39, 41, 43, 44, 44, 46,
47, 48, 49, 51, 52, 53, 53, 55, 55, 57, 58, 59, 60, 61, 63, 62, 64, 64, 66, 66,
68, 67, 71, 68, 73, 70, 76, 72, 80, 75, 83, 76, 87, 46, -109, -108, -103, -108,
-102, -106, -102, -105, -101, -104, -100, -102, -99, -101, -98, -98, -94, -94,
-92, -91, -90, -90, -87, -86, -85, -83, -83, -81, -81, -79, -78, -77, -75, -74,
-74, -72, -71, -69, -68, -67, -66, -64, -61, -60, -58, -56, -55, -53, -50, -50,
-45, -46, -42, -40, -37, -37, -32, -32, -26, -28, -85, -96, -90, -91, -88, -87,
-83, -82, -78, -77, -75, -73, -70, -68, -64, -62, -59, -57, -54, -52, -49, -47,
-45, -42, -40, -37, -35, -34, -32, -30, -29, -26, -26, -23, -23, -22, -20, -19,
-18, -16, -17, -15, -15, -14, -13, -12, -13, -11, -11, -10, -10, -9, -9, -8, -7,
-7, -6, -6, -4, -3, -2, -1, };