#define DATA_LENGTH 512
#define DATA AKWF_granular_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {15, 39, 60, 79, 95, 109, 116, 118,
116, 109, 97, 79, 59, 38, 13, -10, -33, -53, -70, -86, -94, -100, -100, -94,
-86, -73, -58, -40, -22, -3, 15, 32, 47, 59, 68, 73, 75, 73, 68, 59, 49, 37, 23,
10, -4, -16, -28, -38, -45, -50, -52, -52, -50, -45, -37, -30, -20, -11, -1, 8,
16, 24, 30, 34, 35, 36, 35, 31, 27, 21, 15, 9, 2, -5, -11, -16, -22, -25, -26,
-27, -27, -25, -23, -20, -14, -10, -5, -1, 4, 8, 12, 14, 16, 17, 16, 16, 14, 11,
8, 5, 3, -2, -5, -7, -10, -12, -14, -15, -15, -14, -13, -11, -10, -7, -6, -3,
-1, 2, 3, 5, 6, 7, 7, 7, 6, 5, 4, 3, 1, -1, -1, -3, -5, -6, -7, -7, -7, -8, -7,
-7, -6, -5, -4, -3, -1, 0, 1, 2, 2, 3, 4, 4, 5, 7, 8, 11, 13, 15, 17, 17, 18,
16, 11, 4, -5, -16, -29, -42, -54, -65, -74, -80, -83, -83, -79, -70, -60, -48,
-33, -16, 0, 16, 32, 45, 56, 63, 68, 71, 69, 64, 58, 48, 37, 24, 10, -1, -13,
-24, -33, -40, -44, -47, -47, -43, -40, -33, -24, -16, -6, 2, 11, 20, 27, 33,
37, 38, 39, 38, 35, 31, 27, 21, 14, 7, 1, -5, -10, -14, -18, -21, -21, -22, -20,
-17, -14, -10, -5, -1, 4, 9, 14, 17, 19, 21, 22, 23, 23, 22, 19, 16, 13, 9, 6,
2, 0, -3, -6, -8, -8, -9, -9, -9, -7, -5, -4, 0, 1, 4, 7, 9, 11, 13, 13, 14, 14,
14, 13, 11, 9, 8, 6, 5, 2, 1, -1, -2, -3, -4, -4, -4, -3, -3, -3, -1, 0, 1, 3,
5, 6, 6, 7, 7, 7, 7, 8, 6, 6, 5, 5, 3, 3, 1, 1, 0, -1, -2, -2, -3, -3, -2, -2,
-1, -2, 0, 0, 0, 1, 1, 5, 9, 13, 21, 29, 38, 48, 56, 65, 70, 74, 76, 73, 69, 60,
50, 38, 24, 10, -6, -20, -34, -45, -55, -62, -66, -68, -65, -61, -54, -45, -34,
-22, -9, 3, 15, 26, 35, 41, 47, 49, 47, 44, 40, 33, 25, 15, 5, -5, -15, -24,
-31, -37, -41, -43, -43, -41, -38, -33, -26, -19, -10, -3, 4, 11, 17, 22, 25,
27, 27, 27, 25, 20, 16, 10, 4, -2, -8, -13, -18, -23, -26, -27, -28, -27, -25,
-22, -19, -14, -9, -5, 0, 4, 8, 12, 14, 15, 17, 16, 15, 12, 11, 7, 4, 1, -4, -6,
-10, -12, -15, -16, -17, -16, -15, -13, -12, -10, -7, -5, -1, 1, 4, 6, 8, 9, 9,
10, 10, 9, 7, 6, 5, 2, 0, -2, -5, -5, -7, -8, -8, -9, -8, -9, -7, -6, -4, -3,
-1, 1, 2, 4, 5, 6, 7, 7, 6, 7, 5, 5, 4, 2, 2, 1, -1, -2, -3, -4, -6, -9, -14,
-20, -28, -37, -45, -54, -62, -67, -70, -69, -64, -53, -39, -22, -2, };