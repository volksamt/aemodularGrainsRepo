#define DATA_LENGTH 512
#define DATA AKWF_granular_0044

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 3, 4, 6, 7, 8, 9, 10, 11, 13,
13, 15, 15, 17, 17, 19, 20, 21, 21, 24, 24, 25, 25, 26, 28, 27, 29, 28, 32, 26,
37, -14, -42, -32, -40, -36, -41, -40, -43, -42, -46, -45, -47, -48, -50, -52,
-53, -53, -54, -56, -56, -56, -58, -59, -58, -59, -59, -58, -58, -58, -56, -56,
-54, -53, -50, -48, -45, -42, -39, -34, -30, -26, -20, -14, -8, -3, 4, 11, 17,
23, 30, 36, 43, 49, 54, 59, 64, 70, 74, 77, 82, 85, 89, 92, 95, 97, 101, 102,
105, 106, 109, 110, 113, 114, 115, 116, 118, 117, 119, 118, 118, 117, 116, 115,
115, 113, 112, 111, 108, 111, 105, 108, 96, 111, 9, -101, -103, -113, -110,
-115, -113, -117, -116, -118, -118, -119, -118, -119, -119, -119, -120, -119,
-118, -117, -117, -115, -116, -113, -113, -111, -110, -107, -104, -101, -98,
-94, -90, -86, -81, -76, -70, -64, -56, -49, -42, -33, -24, -16, -7, 1, 9, 18,
26, 33, 40, 47, 52, 58, 61, 66, 69, 73, 76, 79, 80, 81, 83, 84, 84, 84, 86, 85,
84, 83, 84, 82, 82, 81, 81, 78, 79, 76, 76, 73, 74, 69, 71, 67, 68, 65, 66, 61,
62, 58, 58, 57, 53, 66, -41, -63, -48, -57, -49, -55, -49, -52, -47, -50, -46,
-49, -44, -45, -42, -44, -41, -41, -38, -38, -36, -35, -35, -31, -32, -29, -28,
-26, -25, -23, -22, -20, -19, -16, -15, -13, -12, -10, -8, -6, -5, -3, -2, -1,
0, 0, 1, 1, 2, 2, 2, 1, 1, 1, 0, 0, -1, 0, 0, 1, 0, 0, 0, 1, 0, 0, 1, 0, 0, -1,
0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, -1, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0,
0, 0, 1, 0, 0, -1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 1, 0, 0, 0, 0,
0, 0, 0, 1, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 1, -1, -1, -1, 0,
1, 0, 1, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 1, 1, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0,
0, -1, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 1, 0, 0, -1, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 1,
0, -1, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0,
0, 0, 0, -1, 0, 1, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 1, 0, 0, 0, -1,
-2, -1, -2, -2, -2, -3, -2, -2, -2, -1, 0, -1, -1, 0, 0, 0, 0, };