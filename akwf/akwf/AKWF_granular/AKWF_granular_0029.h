#define DATA_LENGTH 512
#define DATA AKWF_granular_0029

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 11, 17, 22, 24, 26, 26, 24, 21, 19,
21, 25, 30, 37, 42, 47, 48, 45, 37, 31, 31, 31, 33, 35, 36, 37, 36, 39, 43, 48,
56, 61, 70, 77, 79, 82, 79, 77, 76, 80, 89, 97, 106, 114, 117, 119, 117, 115,
107, 103, 99, 100, 106, 107, 104, 102, 102, 103, 102, 102, 104, 100, 98, 95, 91,
86, 81, 78, 77, 79, 77, 75, 74, 72, 74, 72, 66, 57, 46, 41, 37, 34, 24, 12, 5,
-4, -6, -4, -5, -12, -16, -20, -21, -20, -22, -25, -33, -31, -26, -20, -17, -18,
-24, -32, -31, -33, -35, -39, -43, -40, -33, -25, -23, -30, -41, -49, -51, -51,
-48, -50, -53, -57, -58, -57, -57, -62, -67, -69, -65, -57, -51, -45, -44, -45,
-47, -43, -36, -27, -18, -5, 2, 4, 13, 17, 20, 23, 26, 28, 29, 33, 38, 38, 37,
39, 38, 41, 48, 50, 51, 49, 45, 40, 36, 34, 32, 33, 36, 36, 38, 38, 35, 30, 28,
28, 26, 26, 27, 28, 25, 22, 18, 16, 19, 20, 23, 25, 23, 18, 13, 7, 1, 0, -1, -3,
-8, -8, -6, -5, -5, -11, -17, -25, -27, -25, -24, -26, -31, -39, -44, -42, -38,
-35, -30, -30, -32, -35, -39, -40, -44, -46, -49, -51, -52, -49, -44, -43, -42,
-45, -49, -53, -48, -39, -29, -24, -20, -18, -19, -21, -27, -33, -38, -38, -36,
-29, -19, -10, -6, -6, -7, -8, -9, -10, -9, -7, -6, 0, 1, -2, -7, -12, -10, -1,
7, 16, 24, 24, 25, 24, 21, 15, 11, 9, 13, 23, 29, 30, 29, 27, 26, 25, 27, 28,
27, 26, 28, 29, 27, 21, 17, 12, 11, 15, 17, 17, 14, 11, 6, 3, 4, 6, 6, 4, 4, 5,
2, -4, -10, -16, -17, -16, -13, -10, -10, -13, -18, -21, -22, -25, -28, -31,
-28, -25, -21, -21, -23, -24, -27, -29, -31, -34, -36, -37, -37, -40, -44, -45,
-46, -45, -42, -43, -47, -54, -60, -60, -56, -57, -63, -67, -66, -60, -54, -55,
-59, -65, -68, -64, -60, -59, -62, -64, -67, -66, -62, -59, -61, -68, -70, -63,
-57, -51, -44, -42, -40, -36, -32, -32, -35, -38, -42, -42, -42, -38, -34, -30,
-24, -15, -8, -4, -4, -2, -1, 2, 7, 9, 9, 9, 11, 17, 25, 31, 36, 40, 49, 57, 69,
73, 75, 74, 72, 74, 82, 91, 99, 105, 112, 117, 119, 118, 115, 108, 104, 101, 99,
99, 95, 95, 94, 92, 92, 90, 85, 81, 80, 76, 73, 65, 57, 48, 44, 42, 42, 38, 34,
28, 22, 16, 8, 3, -7, -14, -15, -18, -24, -33, -39, -49, -56, -60, -67, -76,
-82, -85, -86, -83, -81, -86, -93, -98, -101, -97, -93, -93, -96, -101, -101,
-95, -88, -84, -81, -83, -89, -90, -91, -90, -88, -89, -91, -93, -92, -89, -87,
-85, -84, -83, -81, -83, -81, -79, -74, -70, -72, -74, -74, -69, -59, -47, -38,
-30, -27, -21, -13, -4, };