#define DATA_LENGTH 512
#define DATA AKWF_granular_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 7, 8, 11, 13, 15, 17, 20, 22,
24, 26, 28, 30, 32, 34, 37, 39, 41, 43, 45, 47, 48, 51, 53, 55, 57, 59, 61, 63,
64, 66, 67, 70, 71, 73, 75, 77, 79, 81, 82, 83, 85, 86, 88, 89, 91, 92, 93, 94,
96, 98, 99, 99, 101, 102, 103, 104, 105, 106, 107, 107, 110, 110, 111, 112, 112,
113, 114, 114, 114, 115, 116, 116, 117, 117, 117, 118, 118, 118, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 118, 117, 117, 117, 116,
117, 116, 116, 115, 115, 115, 115, 114, 112, 112, 112, 111, 110, 109, 109, 108,
107, 107, 106, 106, 104, 104, 103, 102, 102, 101, 100, 98, 97, 97, 96, 95, 94,
93, 92, 91, 90, 90, 89, 87, 87, 86, 85, 84, 83, 82, 80, 79, 78, 77, 76, 74, 74,
73, 72, 70, 71, 70, 69, 67, 66, 65, 64, 63, 62, 61, 60, 60, 58, 57, 56, 55, 55,
53, 52, 52, 50, 49, 49, 47, 47, 46, 45, 44, 43, 42, 41, 40, 39, 39, 38, 37, 36,
36, 35, 34, 32, 32, 31, 31, 30, 29, 28, 28, 27, 26, 26, 25, 24, 23, 23, 22, 21,
21, 20, 20, 19, 18, 18, 18, 16, 16, 16, 15, 14, 14, 14, 13, 13, 12, 12, 11, 10,
10, 9, 9, 8, 8, 7, 7, 7, 6, 5, 6, 5, 4, 4, 4, 4, 2, 3, 1, 0, 1, 0, 0, 0, -1, -1,
-2, -2, -3, -3, -4, -4, -5, -5, -5, -6, -7, -7, -7, -8, -8, -9, -9, -10, -10,
-10, -12, -11, -11, -12, -13, -14, -14, -15, -16, -16, -17, -16, -18, -18, -19,
-20, -20, -21, -21, -21, -22, -23, -23, -24, -26, -25, -26, -27, -27, -29, -29,
-29, -31, -31, -32, -33, -33, -34, -36, -36, -37, -37, -38, -40, -40, -40, -42,
-42, -44, -44, -46, -46, -47, -48, -49, -50, -51, -52, -53, -54, -55, -55, -57,
-58, -58, -59, -61, -61, -62, -63, -64, -65, -67, -68, -68, -70, -71, -71, -72,
-74, -74, -76, -77, -78, -79, -79, -81, -82, -82, -84, -85, -86, -87, -88, -89,
-89, -90, -92, -93, -93, -94, -95, -95, -97, -98, -99, -99, -100, -101, -103,
-103, -103, -105, -106, -106, -107, -108, -109, -108, -110, -110, -111, -112,
-113, -113, -113, -114, -114, -114, -116, -115, -116, -116, -117, -117, -117,
-118, -118, -118, -117, -119, -118, -119, -118, -119, -118, -119, -119, -118,
-118, -118, -117, -117, -117, -118, -116, -117, -116, -115, -115, -114, -114,
-113, -112, -112, -111, -110, -109, -109, -109, -107, -106, -106, -104, -103,
-103, -102, -100, -99, -98, -96, -96, -94, -92, -91, -90, -89, -87, -86, -85,
-82, -81, -79, -79, -77, -75, -73, -72, -69, -68, -67, -64, -63, -61, -59, -58,
-56, -53, -51, -50, -48, -44, -43, -41, -39, -37, -35, -32, -31, -28, -26, -24,
-22, -20, -18, -15, -14, -11, -9, -7, -5, -2, -1, };