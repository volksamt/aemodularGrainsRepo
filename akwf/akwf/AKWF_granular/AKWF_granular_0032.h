#define DATA_LENGTH 512
#define DATA AKWF_granular_0032

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 9, 10, 12, 15, 16, 19, 22, 27,
29, 32, 37, 43, 50, 58, 63, 68, 69, 71, 74, 77, 80, 84, 87, 92, 96, 103, 108,
113, 116, 118, 119, 119, 119, 118, 118, 117, 117, 116, 115, 117, 116, 116, 116,
116, 112, 111, 109, 105, 101, 97, 92, 88, 83, 78, 77, 74, 72, 70, 69, 66, 63,
58, 54, 50, 46, 43, 38, 34, 32, 29, 28, 27, 25, 23, 22, 19, 18, 15, 10, 4, 1,
-2, -6, -9, -13, -15, -17, -16, -18, -20, -25, -29, -32, -34, -38, -43, -48,
-51, -53, -55, -57, -61, -65, -67, -70, -72, -78, -82, -86, -89, -91, -94, -98,
-102, -108, -109, -108, -108, -110, -113, -116, -115, -113, -110, -109, -113,
-114, -114, -111, -106, -104, -104, -105, -106, -103, -99, -98, -97, -95, -94,
-90, -84, -79, -74, -72, -70, -68, -64, -64, -63, -62, -61, -58, -53, -51, -50,
-48, -44, -39, -35, -31, -30, -28, -26, -21, -16, -12, -9, -5, 2, 10, 20, 28,
34, 42, 48, 54, 61, 65, 67, 68, 69, 72, 76, 81, 86, 92, 97, 100, 104, 104, 105,
103, 102, 103, 104, 105, 104, 104, 101, 101, 102, 101, 102, 103, 103, 103, 104,
103, 102, 99, 97, 95, 94, 95, 97, 97, 98, 97, 95, 95, 95, 95, 94, 92, 90, 87,
85, 82, 79, 76, 72, 70, 68, 67, 66, 63, 61, 58, 55, 52, 48, 42, 38, 34, 30, 27,
23, 20, 16, 13, 9, 6, 0, -6, -13, -23, -30, -37, -43, -49, -52, -57, -61, -66,
-70, -74, -79, -82, -87, -91, -97, -101, -106, -109, -110, -110, -112, -113,
-115, -114, -111, -109, -110, -110, -112, -113, -112, -111, -111, -111, -111,
-110, -108, -105, -103, -102, -99, -96, -96, -95, -97, -99, -100, -99, -96, -92,
-91, -92, -91, -88, -83, -80, -79, -80, -81, -81, -77, -72, -68, -64, -61, -57,
-49, -41, -33, -23, -17, -10, -6, -1, 3, 4, 4, 5, 7, 13, 18, 25, 32, 39, 44, 46,
46, 47, 46, 47, 48, 50, 50, 51, 52, 54, 56, 59, 61, 65, 68, 71, 76, 78, 79, 79,
79, 79, 79, 83, 87, 93, 95, 99, 101, 103, 104, 106, 108, 107, 107, 107, 107,
108, 109, 108, 106, 106, 108, 110, 112, 113, 113, 112, 111, 110, 108, 104, 99,
95, 91, 89, 86, 83, 81, 80, 77, 76, 73, 67, 60, 53, 48, 41, 34, 26, 17, 11, 8,
6, 3, -1, -6, -13, -17, -23, -28, -35, -41, -46, -50, -54, -56, -57, -58, -59,
-59, -61, -66, -66, -69, -71, -74, -77, -81, -85, -86, -86, -85, -83, -81, -79,
-79, -80, -79, -80, -82, -84, -89, -93, -94, -95, -93, -91, -89, -88, -88, -87,
-87, -86, -88, -90, -92, -95, -96, -99, -98, -97, -95, -90, -84, -80, -75, -71,
-68, -65, -63, -62, -64, -64, -64, -63, -60, -58, -52, -51, -46, -41, -35, -30,
-25, -23, -22, -24, -26, -25, -24, -20, -16, -13, -9, -6, -2, };