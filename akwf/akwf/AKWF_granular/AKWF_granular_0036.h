#define DATA_LENGTH 512
#define DATA AKWF_granular_0036

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 3, 14, 11, 14, 19, 25, 34, 59, 72,
86, 96, 95, 100, 102, 115, 111, 120, 109, 108, 100, 98, 95, 88, 87, 78, 73, 65,
60, 46, 38, 20, 9, -3, -8, -18, -25, -35, -45, -47, -47, -44, -42, -40, -42,
-38, -38, -34, -34, -31, -31, -31, -27, -25, -19, -16, -11, -9, -5, 0, 6, 6, 8,
1, -3, -6, -8, -11, -18, -22, -31, -35, -37, -39, -42, -44, -49, -52, -56, -55,
-56, -59, -60, -64, -64, -62, -59, -56, -52, -49, -40, -35, -27, -19, -16, -15,
-10, -8, -4, 0, 1, 3, 4, 6, 11, 17, 19, 24, 27, 29, 34, 38, 38, 39, 37, 34, 32,
32, 30, 28, 27, 20, 19, 18, 12, 12, 9, 3, -2, -8, -15, -24, -29, -37, -41, -48,
-50, -52, -54, -56, -51, -55, -48, -44, -40, -35, -32, -31, -30, -24, -28, -20,
-22, -18, -16, -10, -13, -5, -3, 6, 21, 33, 41, 46, 42, 36, 37, 30, 32, 23, 21,
8, 7, -1, 0, -1, 0, 1, -1, 4, -1, -1, -8, -10, -18, -16, -18, -16, -15, -11, -8,
4, 18, 34, 57, 70, 83, 91, 91, 94, 95, 93, 93, 88, 88, 83, 85, 83, 80, 80, 78,
78, 75, 70, 64, 52, 39, 27, 16, 8, 1, -7, -12, -16, -18, -18, -16, -14, -14,
-12, -14, -15, -16, -23, -28, -33, -37, -38, -38, -33, -33, -30, -30, -27, -22,
-18, -15, -17, -22, -27, -30, -31, -34, -35, -35, -36, -36, -30, -27, -23, -17,
-13, -9, -6, -2, -2, -3, -4, -7, -6, -6, -8, -8, -8, -10, -12, -10, -11, -15,
-18, -25, -30, -37, -43, -50, -54, -59, -60, -58, -56, -54, -54, -50, -49, -47,
-43, -41, -38, -35, -31, -26, -22, -18, -13, -12, -7, -5, 0, 2, 7, 7, 7, 7, 5,
4, 4, 3, 1, 2, -3, -1, 0, 2, 6, 11, 10, 17, 16, 19, 23, 24, 29, 29, 30, 31, 32,
30, 41, 46, 60, 78, 91, 97, 101, 93, 95, 92, 89, 85, 73, 63, 49, 42, 29, 27, 16,
14, 10, 6, 0, -5, -15, -27, -37, -46, -50, -55, -56, -62, -61, -63, -57, -51,
-39, -30, -22, -14, -9, -7, -3, -1, -2, 1, 4, 9, 12, 17, 18, 17, 19, 18, 19, 20,
18, 11, 6, -2, -9, -15, -17, -20, -22, -20, -20, -17, -15, -13, -10, -6, -2, 3,
6, 7, 8, 7, 9, 12, 17, 25, 33, 39, 46, 49, 51, 53, 52, 48, 45, 38, 31, 25, 17,
9, 1, -6, -10, -13, -16, -20, -23, -28, -35, -38, -41, -43, -44, -45, -49, -50,
-48, -47, -45, -42, -37, -33, -25, -22, -21, -18, -21, -23, -21, -21, -22, -19,
-22, -22, -22, -21, -21, -17, -20, -20, -20, -24, -27, -29, -31, -32, -31, -31,
-28, -25, -27, -22, -26, -21, -18, -16, -13, -11, -15, -13, -12, -10, 0, 5, 10,
11, 10, 5, 12, 8, 14, 9, 13, 10, 9, 13, 5, 13, -1, };