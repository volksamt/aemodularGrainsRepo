#define DATA_LENGTH 512
#define DATA AKWF_granular_0026

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 5, 8, 9, 11, 13, 15, 16, 18,
20, 20, 22, 24, 26, 26, 28, 29, 30, 32, 33, 34, 36, 37, 38, 40, 42, 41, 42, 44,
45, 45, 47, 48, 49, 50, 50, 51, 51, 53, 54, 54, 55, 55, 56, 57, 57, 57, 58, 58,
59, 60, 59, 59, 60, 61, 62, 63, 64, 63, 62, 61, 58, 57, 56, 56, 56, 56, 55, 55,
55, 54, 55, 54, 53, 53, 52, 51, 50, 50, 50, 49, 48, 47, 48, 47, 45, 45, 44, 41,
42, 39, 39, 38, 37, 36, 35, 34, 33, 31, 30, 29, 28, 27, 25, 24, 23, 20, 19, 17,
16, 15, 13, 12, 9, 8, 6, 5, 3, 1, -1, -2, -4, -5, -7, -10, -10, -13, -14, -16,
-18, -21, -21, -24, -26, -27, -30, -32, -33, -34, -36, -38, -39, -41, -42, -44,
-45, -47, -48, -50, -52, -53, -55, -56, -58, -59, -61, -62, -64, -65, -67, -68,
-70, -71, -73, -74, -75, -76, -78, -79, -80, -82, -83, -84, -85, -85, -87, -87,
-89, -89, -91, -91, -92, -94, -94, -94, -95, -95, -97, -97, -98, -98, -98, -99,
-99, -100, -99, -100, -100, -100, -100, -100, -99, -100, -99, -99, -99, -99,
-98, -97, -97, -97, -95, -96, -96, -95, -94, -93, -92, -91, -90, -89, -89, -87,
-86, -85, -85, -83, -82, -81, -80, -78, -77, -76, -74, -73, -71, -70, -68, -67,
-65, -63, -62, -61, -58, -57, -55, -53, -53, -49, -48, -46, -45, -43, -42, -39,
-37, -36, -33, -33, -30, -29, -26, -24, -23, -21, -20, -17, -16, -14, -13, -11,
-8, -8, -6, -4, -2, -2, 0, 2, 4, 4, 6, 7, 8, 10, 10, 12, 13, 14, 15, 16, 17, 18,
19, 19, 20, 21, 22, 22, 24, 24, 24, 24, 24, 25, 25, 25, 26, 25, 26, 25, 25, 25,
25, 25, 24, 24, 24, 23, 22, 22, 21, 21, 21, 19, 19, 18, 16, 16, 14, 14, 13, 11,
10, 10, 8, 6, 5, 4, 2, 1, 0, -2, -4, -5, -7, -8, -10, -12, -13, -16, -17, -19,
-20, -23, -24, -26, -27, -29, -31, -33, -35, -36, -39, -40, -42, -44, -46, -48,
-50, -52, -53, -55, -57, -59, -60, -62, -64, -66, -68, -69, -71, -73, -74, -76,
-78, -79, -82, -82, -83, -85, -87, -88, -89, -91, -93, -94, -96, -97, -99, -99,
-100, -102, -103, -103, -106, -106, -108, -108, -108, -110, -111, -112, -111,
-113, -113, -114, -114, -116, -116, -116, -116, -117, -117, -118, -118, -119,
-119, -119, -119, -117, -117, -117, -117, -117, -116, -115, -115, -114, -114,
-113, -113, -112, -111, -111, -109, -109, -108, -107, -106, -105, -104, -103,
-103, -101, -100, -99, -98, -96, -94, -92, -91, -89, -87, -86, -84, -82, -81,
-79, -77, -75, -72, -71, -69, -67, -65, -63, -62, -59, -58, -56, -55, -52, -50,
-48, -46, -45, -43, -41, -38, -36, -35, -33, -31, -28, -28, -25, -23, -21, -18,
-17, -16, -13, -11, -10, -8, -6, -4, -2, -2, };