#define DATA_LENGTH 512
#define DATA AKWF_granular_0042

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 8, 10, 14, 17, 20, 22, 25,
28, 31, 34, 37, 39, 42, 46, 47, 50, 53, 55, 59, 61, 64, 66, 69, 71, 74, 76, 78,
80, 83, 84, 86, 88, 90, 92, 94, 96, 97, 100, 101, 102, 104, 105, 107, 108, 109,
111, 111, 112, 113, 114, 115, 116, 116, 116, 117, 118, 118, 119, 118, 119, 119,
119, 119, 119, 119, 118, 118, 118, 117, 116, 116, 116, 115, 114, 113, 112, 111,
110, 109, 109, 107, 106, 105, 103, 102, 99, 98, 98, 95, 94, 92, 90, 88, 86, 85,
82, 80, 79, 77, 74, 73, 69, 68, 65, 64, 61, 58, 57, 53, 51, 49, 45, 43, 42, 38,
36, 33, 31, 28, 25, 22, 19, 17, 15, 12, 8, 6, 3, 1, -2, -5, -7, -10, -13, -16,
-17, -21, -23, -26, -28, -32, -34, -35, -39, -41, -44, -46, -49, -52, -53, -56,
-59, -62, -63, -66, -68, -69, -72, -73, -77, -78, -81, -83, -85, -86, -89, -90,
-91, -94, -95, -97, -98, -100, -101, -102, -104, -105, -107, -108, -109, -109,
-111, -112, -112, -113, -114, -115, -114, -115, -116, -116, -117, -116, -117,
-117, -117, -117, -116, -117, -116, -116, -116, -115, -114, -113, -113, -113,
-111, -110, -110, -109, -107, -106, -106, -104, -102, -100, -99, -97, -96, -95,
-92, -90, -89, -87, -84, -83, -80, -79, -76, -74, -71, -69, -67, -64, -61, -59,
-57, -53, -50, -48, -45, -41, -39, -36, -33, -31, -27, -25, -21, -19, -15, -13,
-10, -6, -4, -1, 2, 5, 9, 12, 15, 17, 22, 24, 27, 29, 33, 36, 39, 42, 44, 47,
50, 52, 55, 58, 60, 63, 65, 68, 71, 73, 76, 78, 80, 82, 83, 87, 87, 91, 92, 93,
95, 97, 99, 101, 101, 103, 104, 106, 107, 108, 109, 110, 111, 111, 112, 114,
113, 115, 115, 115, 116, 116, 116, 116, 117, 117, 117, 117, 116, 116, 115, 114,
115, 114, 113, 112, 111, 111, 110, 108, 107, 106, 105, 104, 103, 101, 100, 98,
96, 95, 93, 92, 90, 89, 86, 84, 82, 80, 78, 76, 74, 72, 70, 67, 65, 63, 60, 58,
55, 52, 50, 48, 44, 43, 40, 37, 35, 32, 30, 26, 24, 21, 18, 15, 14, 10, 8, 5, 1,
-1, -4, -7, -9, -12, -15, -17, -21, -24, -26, -29, -31, -34, -37, -39, -41, -45,
-46, -49, -51, -54, -56, -59, -61, -64, -66, -69, -72, -73, -75, -77, -79, -82,
-83, -85, -88, -90, -91, -93, -95, -96, -98, -99, -102, -103, -104, -105, -106,
-107, -109, -110, -111, -112, -112, -114, -114, -115, -115, -115, -115, -117,
-117, -117, -117, -117, -118, -116, -117, -117, -116, -117, -116, -115, -115,
-115, -113, -112, -111, -111, -110, -108, -108, -106, -106, -104, -103, -101,
-99, -98, -96, -95, -93, -90, -88, -87, -85, -82, -80, -78, -76, -74, -71, -69,
-66, -64, -62, -59, -56, -53, -50, -48, -45, -43, -39, -37, -33, -30, -27, -25,
-22, -19, -15, -12, -10, -6, -3, -1, };