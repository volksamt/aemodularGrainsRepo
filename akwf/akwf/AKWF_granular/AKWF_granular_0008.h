#define DATA_LENGTH 512
#define DATA AKWF_granular_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 16, 22, 27, 33, 39, 43, 49, 52,
58, 59, 66, 66, 71, 71, 76, 76, 79, 81, 82, 84, 84, 86, 84, 90, 85, 92, 83, 97,
76, 116, 2, -120, -86, -110, -99, -112, -106, -114, -112, -117, -118, -118,
-118, -117, -116, -114, -113, -108, -108, -101, -98, -89, -85, -76, -67, -57,
-46, -33, -21, -7, 6, 19, 33, 44, 57, 66, 76, 82, 91, 96, 102, 105, 109, 112,
115, 116, 117, 118, 119, 120, 118, 121, 116, 120, 113, 119, 109, 118, 105, 118,
96, 125, 49, -128, -105, -118, -113, -117, -117, -117, -119, -119, -120, -117,
-121, -115, -119, -113, -114, -108, -108, -101, -99, -91, -87, -77, -69, -59,
-49, -37, -23, -11, 3, 16, 30, 42, 54, 64, 73, 81, 89, 94, 101, 105, 108, 111,
114, 117, 116, 117, 114, 115, 112, 113, 107, 108, 103, 104, 98, 99, 91, 93, 85,
90, 64, -75, -88, -82, -86, -81, -84, -79, -82, -77, -79, -74, -75, -70, -70,
-66, -65, -61, -59, -54, -51, -46, -42, -37, -32, -28, -22, -16, -10, -6, 0, 4,
9, 13, 16, 19, 21, 21, 23, 23, 24, 23, 23, 22, 21, 19, 19, 17, 15, 14, 13, 10,
9, 8, 5, 4, 3, 1, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 1, 0, 0, -1, 0, 1, -1, 0, 0,
0, 0, 1, 0, 0, 0, 0, -1, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0,
0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 1, 1, 0, -1, -1, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1,
-1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0,
1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0,
0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0,
0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, -1, 1, 0, 0, -1, 1, 0, 0, 0, 0, 0,
-1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, -2, -3, -5, -6, -8, -10, -11,
-13, -14, -16, -18, -19, -20, -23, -23, -24, -25, -26, -27, -27, -26, -26, -25,
-24, -21, -19, -15, -10, -6, 0, };