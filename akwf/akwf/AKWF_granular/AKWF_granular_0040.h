#define DATA_LENGTH 512
#define DATA AKWF_granular_0040

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 12, 23, 34, 44, 54, 63, 72, 81, 87,
94, 99, 103, 107, 109, 110, 111, 111, 109, 107, 105, 102, 99, 95, 91, 86, 81,
76, 71, 66, 61, 57, 52, 47, 43, 39, 35, 30, 27, 24, 21, 18, 16, 13, 11, 9, 7, 6,
5, 4, 3, 2, 1, 0, 1, 1, 0, 0, 0, -1, 1, 0, 0, 0, 0, 0, -1, -1, -1, -2, -3, -4,
-6, -6, -8, -10, -12, -13, -17, -19, -22, -26, -29, -33, -37, -41, -46, -51,
-56, -61, -67, -71, -77, -82, -88, -92, -98, -101, -105, -110, -113, -116, -117,
-119, -118, -118, -117, -115, -110, -105, -99, -92, -83, -75, -66, -55, -43,
-32, -20, -6, 5, 16, 29, 40, 51, 61, 70, 78, 86, 94, 98, 103, 107, 108, 110,
110, 110, 108, 106, 104, 102, 97, 94, 89, 84, 79, 75, 69, 65, 60, 55, 50, 46,
41, 37, 33, 29, 26, 23, 20, 17, 15, 12, 11, 9, 6, 6, 4, 3, 3, 2, 1, 1, 1, 0, 1,
0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, -1, -3, -2, -4, -4, -5, -6, -8, -9, -11,
-13, -15, -17, -20, -23, -25, -28, -31, -35, -38, -42, -45, -49, -53, -56, -59,
-63, -67, -69, -72, -75, -77, -79, -79, -81, -81, -81, -80, -78, -76, -72, -70,
-65, -60, -54, -48, -42, -35, -27, -19, -12, -4, 3, 10, 17, 24, 31, 36, 42, 45,
49, 53, 55, 57, 58, 59, 59, 59, 58, 55, 55, 52, 51, 47, 45, 43, 40, 37, 36, 34,
32, 30, 28, 27, 26, 25, 24, 23, 23, 23, 22, 23, 24, 23, 23, 24, 25, 25, 25, 25,
25, 24, 25, 24, 24, 23, 22, 22, 22, 22, 20, 18, 18, 17, 16, 15, 14, 13, 11, 11,
9, 8, 7, 6, 3, 3, 1, 0, -3, -3, -4, -6, -8, -10, -12, -14, -15, -16, -19, -20,
-23, -23, -25, -28, -30, -32, -33, -35, -36, -37, -39, -39, -41, -41, -41, -41,
-41, -40, -40, -39, -39, -37, -35, -33, -32, -31, -28, -26, -24, -21, -19, -18,
-16, -16, -14, -12, -13, -12, -12, -13, -13, -14, -15, -15, -17, -19, -20, -22,
-24, -25, -25, -26, -26, -26, -25, -25, -23, -21, -18, -15, -11, -8, -3, 2, 7,
12, 19, 26, 31, 36, 42, 47, 52, 56, 59, 63, 66, 68, 70, 71, 71, 70, 71, 68, 68,
65, 64, 62, 59, 56, 53, 50, 47, 44, 41, 37, 35, 31, 29, 25, 22, 20, 17, 15, 13,
13, 10, 8, 7, 5, 4, 4, 2, 2, 2, 1, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, -1, -2, -2, -3, -4, -4, -6, -7, -9, -10, -12, -15, -17, -19, -23, -26, -29,
-32, -36, -40, -45, -48, -52, -58, -62, -66, -71, -75, -80, -83, -87, -91, -94,
-96, -99, -100, -100, -100, -99, -97, -94, -90, -85, -80, -73, -67, -58, -49,
-39, -29, -18, -7, };