#define DATA_LENGTH 512
#define DATA AKWF_granular_0034

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 4, 12, 14, 14, 10, 14, 19, 15,
15, 13, 6, 12, 17, 14, 15, 14, 16, 22, 32, 41, 41, 38, 34, 30, 41, 43, 39, 44,
36, 27, 28, 37, 54, 56, 47, 39, 39, 41, 56, 65, 60, 50, 41, 43, 60, 74, 70, 54,
48, 46, 49, 59, 62, 56, 49, 44, 48, 57, 65, 70, 67, 66, 57, 54, 68, 72, 69, 67,
59, 55, 47, 57, 75, 73, 64, 56, 65, 79, 89, 100, 99, 88, 81, 79, 85, 91, 88, 72,
71, 73, 73, 94, 98, 92, 103, 101, 94, 102, 106, 109, 107, 95, 95, 106, 106, 113,
119, 106, 101, 108, 106, 106, 110, 99, 101, 106, 95, 102, 103, 87, 89, 99, 100,
106, 106, 103, 113, 115, 112, 108, 98, 89, 88, 82, 71, 66, 68, 73, 70, 69, 70,
73, 87, 84, 74, 74, 65, 58, 73, 82, 76, 63, 50, 55, 73, 77, 51, 35, 33, 25, 37,
52, 50, 49, 39, 41, 70, 80, 74, 75, 56, 42, 49, 50, 55, 50, 27, 19, 30, 31, 33,
45, 38, 20, 23, 35, 47, 56, 41, 23, 26, 30, 28, 26, 22, 14, 6, 5, 16, 21, 12, 1,
-7, -1, 6, 0, -7, -5, -4, -7, 0, 6, -5, -16, -12, -7, -9, -14, -28, -37, -29,
-23, -23, -19, -29, -42, -32, -21, -27, -28, -33, -40, -32, -23, -18, -21, -34,
-37, -36, -37, -35, -42, -49, -47, -53, -54, -44, -46, -53, -53, -54, -54, -44,
-43, -50, -52, -49, -43, -44, -45, -47, -55, -60, -64, -64, -61, -65, -72, -71,
-61, -52, -52, -59, -60, -55, -53, -53, -52, -55, -56, -59, -59, -54, -52, -61,
-68, -70, -67, -63, -66, -69, -69, -65, -62, -58, -60, -64, -61, -67, -67, -64,
-66, -64, -65, -69, -65, -64, -68, -68, -71, -76, -74, -73, -71, -69, -68, -65,
-63, -59, -61, -65, -63, -64, -69, -69, -67, -66, -68, -67, -61, -59, -59, -62,
-63, -65, -66, -63, -62, -61, -60, -61, -60, -55, -55, -59, -59, -64, -66, -66,
-63, -61, -61, -62, -59, -60, -61, -56, -58, -64, -68, -72, -67, -60, -56, -54,
-55, -56, -51, -43, -45, -49, -53, -56, -57, -56, -52, -53, -57, -57, -54, -53,
-54, -53, -53, -51, -51, -50, -44, -42, -41, -37, -37, -38, -40, -39, -32, -35,
-41, -39, -34, -38, -40, -39, -43, -44, -43, -43, -37, -34, -38, -36, -27, -21,
-17, -20, -30, -25, -20, -23, -22, -26, -31, -30, -32, -27, -26, -28, -32, -33,
-30, -27, -22, -20, -20, -16, -18, -15, -13, -17, -16, -16, -25, -32, -34, -30,
-28, -34, -36, -34, -38, -38, -31, -30, -31, -26, -30, -25, -16, -19, -18, -13,
-19, -17, -19, -27, -22, -22, -27, -24, -26, -30, -24, -20, -15, -10, -13, -13,
-7, -4, -2, 1, 0, 0, -1, -7, -3, 3, -6, -6, -5, -11, -10, -5, -4, -2, 2, 0, -1,
1, -6, -4, 2, -5, -6, -4, -10, -12, -6, -6, -3, };