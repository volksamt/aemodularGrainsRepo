#define DATA_LENGTH 512
#define DATA AKWF_granular_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 10, 12, 14, 16, 19, 21, 24,
26, 28, 31, 33, 35, 38, 40, 41, 44, 46, 48, 50, 52, 54, 56, 57, 60, 62, 63, 65,
67, 68, 70, 72, 73, 75, 77, 77, 79, 81, 82, 83, 84, 86, 87, 88, 89, 90, 92, 93,
94, 94, 95, 97, 98, 98, 99, 100, 100, 101, 103, 102, 103, 104, 105, 105, 106,
107, 108, 108, 109, 109, 110, 110, 111, 112, 112, 112, 112, 114, 113, 114, 115,
114, 115, 116, 115, 116, 115, 116, 115, 117, 117, 117, 117, 117, 118, 117, 119,
118, 118, 118, 119, 118, 119, 118, 118, 117, 116, 116, 113, 116, 111, 114, 110,
113, 108, 112, 106, 109, 106, 107, 105, 103, 104, 101, 112, -19, -119, -102,
-107, -106, -105, -105, -105, -107, -104, -106, -104, -106, -105, -105, -105,
-105, -105, -103, -105, -103, -105, -103, -104, -102, -104, -102, -103, -102,
-101, -101, -101, -101, -100, -101, -99, -100, -99, -99, -99, -97, -96, -97,
-97, -96, -95, -94, -94, -94, -93, -93, -92, -92, -91, -90, -89, -88, -89, -87,
-87, -86, -85, -84, -82, -82, -82, -81, -79, -79, -78, -76, -75, -74, -74, -71,
-71, -70, -68, -67, -67, -65, -63, -62, -61, -60, -59, -57, -55, -53, -52, -51,
-49, -48, -46, -44, -42, -41, -39, -37, -35, -33, -32, -30, -28, -26, -24, -22,
-20, -19, -16, -14, -12, -11, -8, -6, -4, -3, -1, 2, 3, 5, 6, 8, 10, 12, 13, 14,
16, 17, 20, 20, 21, 23, 24, 26, 27, 28, 28, 30, 32, 32, 33, 34, 35, 36, 37, 39,
40, 40, 41, 42, 43, 43, 44, 45, 46, 45, 47, 48, 49, 49, 50, 50, 51, 51, 52, 52,
52, 53, 55, 54, 55, 55, 56, 56, 56, 57, 57, 57, 58, 58, 58, 59, 59, 60, 59, 60,
59, 60, 60, 61, 61, 61, 61, 61, 60, 62, 61, 61, 61, 62, 62, 61, 61, 61, 62, 61,
62, 62, 62, 62, 63, 62, 62, 63, 63, 62, 63, 63, 62, 62, 62, 62, 61, 61, 61, 61,
60, 61, 60, 60, 60, 61, 61, 60, 61, 60, 60, 59, 60, 59, 60, 59, 59, 60, 53, 41,
42, 43, 44, 45, 45, 47, 46, 47, 47, 48, 48, 49, 50, 50, 52, 50, 53, 51, 55, 54,
-21, -67, -55, -61, -58, -61, -59, -63, -61, -63, -63, -64, -64, -65, -67, -65,
-67, -67, -69, -67, -70, -70, -71, -70, -71, -72, -73, -73, -73, -74, -75, -76,
-75, -77, -76, -77, -78, -79, -79, -79, -79, -80, -80, -81, -81, -82, -81, -81,
-82, -83, -84, -83, -84, -84, -83, -85, -84, -84, -85, -84, -84, -84, -85, -84,
-85, -85, -84, -83, -83, -84, -84, -83, -83, -82, -82, -81, -81, -79, -79, -79,
-78, -76, -77, -75, -74, -73, -72, -71, -70, -68, -67, -64, -64, -62, -60, -58,
-56, -55, -52, -50, -48, -46, -44, -41, -39, -37, -34, -31, -29, -25, -21, -19,
-16, -13, -10, -6, -3, 0, };