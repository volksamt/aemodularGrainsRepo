#define DATA_LENGTH 512
#define DATA AKWF_granular_0038

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 5, 9, 11, 14, 17, 19, 21, 24,
27, 29, 32, 35, 38, 41, 44, 45, 47, 50, 54, 57, 60, 61, 64, 67, 70, 73, 75, 78,
81, 84, 87, 88, 89, 92, 94, 98, 100, 102, 103, 106, 109, 112, 113, 114, 115,
117, 118, 119, 119, 118, 117, 117, 117, 117, 117, 115, 114, 114, 112, 110, 108,
106, 105, 103, 100, 97, 93, 91, 89, 85, 82, 77, 73, 71, 67, 62, 59, 54, 50, 47,
43, 37, 34, 30, 27, 23, 19, 15, 11, 9, 4, 2, -1, -3, -8, -11, -14, -18, -19,
-23, -25, -28, -30, -32, -33, -34, -36, -38, -39, -40, -43, -44, -45, -48, -49,
-49, -52, -53, -54, -54, -53, -54, -55, -56, -57, -57, -57, -57, -59, -61, -61,
-61, -61, -62, -62, -64, -64, -63, -62, -62, -63, -63, -63, -62, -62, -61, -61,
-60, -59, -59, -57, -55, -54, -53, -52, -51, -49, -47, -45, -43, -42, -39, -38,
-37, -35, -31, -30, -27, -25, -23, -21, -18, -15, -14, -13, -11, -10, -7, -6,
-4, -3, -2, 0, 1, 3, 4, 6, 6, 7, 8, 9, 10, 12, 13, 13, 14, 13, 13, 14, 14, 15,
15, 15, 15, 15, 15, 15, 15, 14, 14, 15, 14, 14, 14, 14, 13, 13, 12, 11, 11, 11,
9, 9, 8, 7, 6, 4, 4, 4, 2, 1, -1, -1, -1, -2, -3, -4, -5, -6, -7, -8, -9, -11,
-11, -13, -13, -14, -16, -16, -18, -19, -20, -21, -22, -23, -23, -24, -25, -26,
-26, -27, -29, -29, -29, -30, -30, -30, -30, -29, -30, -31, -30, -31, -30, -29,
-29, -29, -28, -29, -28, -27, -27, -26, -26, -26, -25, -25, -25, -24, -24, -23,
-23, -22, -22, -22, -21, -22, -21, -22, -22, -22, -22, -23, -23, -23, -24, -26,
-25, -26, -27, -28, -28, -30, -30, -31, -32, -33, -34, -34, -34, -34, -34, -35,
-36, -36, -36, -36, -36, -35, -36, -36, -35, -36, -36, -36, -36, -34, -35, -34,
-33, -32, -30, -29, -29, -28, -27, -24, -23, -21, -20, -18, -17, -14, -13, -10,
-7, -5, -2, 0, 2, 4, 6, 10, 11, 13, 15, 16, 18, 20, 22, 24, 25, 27, 27, 29, 29,
30, 30, 32, 32, 33, 32, 33, 34, 34, 34, 34, 34, 34, 35, 35, 34, 34, 34, 34, 34,
33, 33, 32, 31, 30, 32, 31, 30, 29, 29, 28, 26, 24, 23, 22, 22, 19, 18, 17, 15,
14, 11, 11, 9, 6, 5, 3, 2, 0, -1, -3, -5, -6, -7, -9, -9, -10, -12, -13, -13,
-15, -14, -16, -16, -18, -18, -18, -17, -18, -19, -20, -20, -21, -21, -23, -23,
-23, -23, -24, -25, -25, -25, -26, -27, -26, -27, -26, -27, -27, -27, -27, -28,
-28, -30, -30, -31, -30, -30, -31, -32, -33, -33, -33, -34, -35, -35, -35, -34,
-33, -33, -34, -34, -33, -33, -31, -31, -31, -29, -29, -27, -25, -24, -23, -23,
-20, -16, -14, -13, -11, -10, -7, -3, -1, };