#define DATA_LENGTH 512
#define DATA AKWF_granular_0033

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 14, 21, 26, 32, 37, 43, 48, 53,
59, 62, 68, 72, 77, 82, 84, 89, 92, 96, 99, 101, 104, 106, 109, 111, 113, 114,
116, 117, 117, 118, 119, 118, 119, 119, 118, 118, 117, 116, 115, 114, 113, 112,
109, 107, 106, 104, 103, 101, 99, 96, 94, 92, 88, 87, 85, 81, 79, 77, 74, 72,
70, 67, 65, 62, 60, 57, 55, 52, 50, 48, 45, 43, 41, 39, 37, 36, 33, 32, 30, 28,
27, 26, 24, 22, 20, 19, 18, 17, 15, 14, 14, 12, 12, 10, 9, 9, 8, 7, 7, 5, 5, 5,
5, 4, 3, 3, 2, 2, 2, 1, 1, 1, 1, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 0, 0, -1, 0, 0,
0, 0, 0, -1, 0, -1, 0, -1, -1, 0, -1, -1, -2, -2, -2, -1, -2, -2, -3, -3, -3,
-5, -4, -6, -6, -6, -8, -7, -9, -10, -10, -12, -12, -13, -15, -16, -17, -18,
-20, -21, -22, -23, -25, -27, -28, -30, -31, -33, -36, -37, -39, -41, -43, -44,
-47, -50, -51, -53, -56, -58, -60, -62, -64, -66, -69, -71, -74, -76, -78, -80,
-82, -85, -86, -89, -91, -93, -95, -96, -98, -99, -101, -103, -104, -104, -105,
-107, -108, -108, -109, -109, -110, -109, -108, -108, -107, -106, -106, -104,
-103, -102, -99, -97, -96, -93, -90, -87, -85, -82, -77, -74, -71, -67, -62,
-59, -54, -50, -45, -41, -36, -30, -26, -20, -15, -10, -5, 0, 5, 10, 15, 21, 26,
30, 36, 41, 44, 49, 53, 57, 61, 66, 69, 73, 75, 80, 82, 85, 88, 90, 92, 94, 95,
98, 99, 100, 101, 102, 103, 103, 103, 103, 103, 102, 102, 102, 101, 99, 99, 98,
96, 95, 94, 93, 90, 88, 87, 86, 83, 82, 80, 77, 75, 73, 71, 69, 67, 65, 63, 61,
58, 56, 54, 51, 50, 48, 46, 44, 42, 40, 38, 37, 35, 33, 31, 30, 27, 27, 25, 23,
22, 21, 20, 19, 17, 16, 16, 13, 13, 12, 11, 10, 10, 9, 8, 7, 6, 6, 5, 5, 4, 4,
4, 3, 2, 3, 3, 2, 1, 1, 2, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1,
1, 1, 0, 0, 0, -1, 0, 0, -1, -1, -1, -1, -1, -2, -2, -1, -2, -3, -3, -4, -4, -5,
-5, -5, -6, -7, -8, -8, -9, -10, -10, -11, -12, -13, -15, -16, -17, -18, -18,
-21, -22, -24, -25, -26, -28, -30, -31, -33, -35, -36, -39, -40, -42, -45, -47,
-50, -51, -54, -56, -58, -61, -63, -65, -68, -70, -73, -75, -77, -80, -82, -85,
-87, -89, -92, -94, -95, -98, -100, -102, -104, -106, -107, -109, -110, -111,
-113, -114, -114, -115, -115, -116, -116, -116, -116, -115, -114, -113, -112,
-111, -109, -107, -105, -102, -100, -97, -95, -90, -88, -84, -80, -77, -71, -68,
-63, -59, -53, -49, -43, -38, -33, -27, -22, -16, -10, -5, -1, };