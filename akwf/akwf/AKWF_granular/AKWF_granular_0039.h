#define DATA_LENGTH 512
#define DATA AKWF_granular_0039

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 12, 14, 16, 17, 18, 16, 17, 17,
17, 18, 22, 27, 30, 34, 39, 42, 46, 49, 51, 53, 52, 51, 49, 51, 52, 53, 54, 56,
60, 62, 62, 62, 63, 63, 62, 61, 59, 59, 57, 55, 55, 56, 56, 57, 57, 57, 57, 57,
57, 55, 55, 53, 53, 54, 54, 54, 55, 54, 55, 55, 54, 52, 50, 47, 45, 42, 38, 37,
35, 34, 33, 32, 32, 31, 32, 32, 31, 30, 27, 26, 22, 19, 16, 15, 13, 11, 10, 9,
6, 1, 1, 5, 7, 10, 12, 13, 12, 11, 10, 11, 12, 12, 13, 15, 17, 18, 20, 22, 24,
26, 28, 32, 33, 36, 35, 34, 34, 35, 34, 35, 37, 40, 43, 46, 46, 48, 47, 45, 46,
48, 50, 51, 53, 56, 60, 64, 66, 70, 75, 81, 85, 87, 89, 91, 92, 92, 94, 96, 98,
99, 104, 107, 109, 112, 112, 114, 115, 116, 116, 117, 118, 116, 115, 115, 114,
116, 117, 118, 119, 120, 119, 118, 116, 113, 111, 110, 109, 108, 106, 106, 105,
103, 99, 97, 95, 93, 90, 88, 84, 82, 78, 75, 74, 74, 74, 73, 72, 70, 65, 60, 56,
53, 51, 48, 46, 45, 42, 40, 37, 35, 34, 32, 33, 34, 32, 30, 26, 22, 17, 10, 6,
5, 6, 5, 3, 2, 0, -3, -6, -12, -15, -17, -18, -19, -21, -21, -21, -24, -24, -25,
-25, -26, -27, -25, -24, -23, -24, -28, -30, -31, -33, -34, -36, -37, -36, -31,
-28, -26, -22, -21, -20, -18, -18, -17, -19, -20, -21, -23, -24, -27, -28, -29,
-31, -32, -30, -29, -26, -23, -22, -22, -23, -25, -29, -33, -36, -40, -42, -42,
-41, -40, -40, -39, -39, -41, -41, -42, -43, -43, -46, -47, -48, -48, -48, -46,
-45, -43, -39, -37, -33, -32, -32, -31, -31, -33, -34, -35, -35, -33, -32, -29,
-26, -21, -18, -14, -11, -12, -12, -13, -19, -25, -28, -26, -20, -16, -19, -20,
-20, -17, -16, -15, -14, -15, -16, -18, -18, -20, -22, -21, -21, -20, -20, -18,
-19, -21, -24, -28, -33, -36, -33, -30, -30, -32, -30, -29, -28, -26, -24, -20,
-19, -19, -18, -19, -21, -21, -20, -20, -21, -21, -20, -18, -17, -14, -12, -10,
-10, -10, -10, -10, -10, -9, -7, -8, -9, -8, -6, -5, -7, -5, -3, -1, 1, 3, 3, 0,
-2, -3, -5, -3, -3, -1, 0, 0, -1, -1, -3, -5, -5, -4, -4, -3, -1, 0, -1, -2, -6,
-8, -9, -10, -8, -7, -6, -6, -9, -13, -18, -21, -25, -26, -23, -23, -25, -24,
-24, -24, -25, -26, -27, -25, -25, -25, -25, -25, -23, -26, -26, -26, -26, -27,
-25, -23, -22, -22, -19, -15, -11, -8, -8, -10, -13, -16, -19, -20, -22, -22,
-21, -21, -21, -21, -20, -21, -19, -18, -14, -10, -8, -7, -8, -10, -13, -15,
-16, -18, -17, -15, -11, -9, -7, -8, -10, -11, -13, -13, -12, -12, -11, -11,
-10, -7, -4, -1, };