#define DATA_LENGTH 512
#define DATA AKWF_granular_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 7, 9, 13, 16, 19, 23, 26, 28,
31, 35, 37, 41, 44, 46, 50, 52, 55, 57, 59, 62, 65, 67, 70, 72, 74, 76, 79, 80,
82, 84, 86, 87, 88, 90, 92, 93, 95, 96, 97, 99, 100, 102, 102, 104, 104, 105,
106, 107, 108, 109, 110, 110, 111, 111, 112, 113, 113, 114, 115, 115, 116, 115,
116, 116, 117, 117, 118, 117, 117, 117, 117, 116, 116, 115, 115, 114, 115, 114,
114, 114, 114, 112, 113, 113, 111, 111, 111, 111, 110, 109, 109, 108, 107, 107,
107, 105, 106, 104, 105, 104, 103, 103, 101, 102, 100, 100, 100, 98, 99, 97, 98,
95, 95, 95, 93, 94, 91, 94, 89, 92, 89, 90, 88, 88, 88, 84, 89, 82, 88, 79, 88,
82, -23, -101, -83, -88, -87, -86, -90, -86, -91, -87, -92, -88, -91, -90, -90,
-91, -91, -92, -90, -92, -92, -93, -92, -91, -93, -92, -93, -92, -93, -92, -93,
-93, -93, -94, -93, -95, -94, -94, -94, -94, -95, -94, -94, -94, -94, -93, -95,
-94, -94, -94, -93, -94, -93, -93, -93, -93, -92, -93, -92, -92, -91, -91, -90,
-90, -89, -89, -88, -88, -87, -86, -86, -86, -85, -84, -84, -83, -82, -82, -80,
-80, -79, -78, -77, -76, -74, -73, -73, -71, -70, -69, -67, -66, -65, -63, -61,
-60, -58, -56, -55, -52, -52, -49, -47, -44, -42, -40, -39, -36, -34, -31, -29,
-28, -24, -22, -20, -17, -15, -12, -10, -7, -5, -2, 1, 4, 7, 9, 12, 14, 16, 19,
22, 25, 27, 29, 31, 33, 36, 38, 40, 42, 44, 46, 48, 51, 53, 54, 56, 57, 59, 61,
62, 64, 65, 67, 68, 70, 71, 72, 74, 75, 76, 77, 78, 79, 80, 81, 81, 82, 84, 83,
85, 85, 85, 87, 87, 88, 87, 88, 89, 89, 90, 90, 90, 91, 91, 92, 91, 92, 93, 92,
93, 92, 94, 93, 93, 93, 94, 94, 94, 94, 94, 95, 93, 93, 93, 94, 94, 94, 94, 93,
94, 93, 93, 94, 92, 93, 94, 92, 93, 92, 92, 92, 92, 91, 92, 91, 91, 91, 91, 90,
90, 90, 90, 89, 89, 88, 88, 88, 89, 89, 89, 89, 88, 90, 88, 91, 87, 90, 87, 90,
87, 91, 86, 96, 73, -62, -105, -91, -97, -95, -97, -97, -99, -99, -100, -101,
-102, -101, -103, -102, -105, -103, -105, -105, -107, -106, -108, -108, -108,
-109, -109, -110, -111, -111, -112, -112, -114, -115, -115, -114, -115, -116,
-116, -117, -116, -118, -117, -118, -119, -119, -119, -118, -119, -119, -119,
-118, -118, -117, -118, -118, -118, -117, -116, -117, -116, -116, -115, -114,
-114, -114, -113, -112, -112, -112, -110, -110, -109, -108, -108, -107, -106,
-104, -104, -103, -102, -100, -99, -98, -97, -96, -93, -92, -91, -89, -88, -85,
-85, -82, -80, -79, -76, -74, -72, -70, -68, -66, -63, -60, -59, -55, -53, -50,
-47, -45, -41, -38, -36, -33, -30, -26, -23, -20, -17, -14, -10, -6, -3, 0, };