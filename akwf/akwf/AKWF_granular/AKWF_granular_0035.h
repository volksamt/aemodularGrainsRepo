#define DATA_LENGTH 512
#define DATA AKWF_granular_0035

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 3, 0, 4, 6, 15, 20, 25, 24, 24,
35, 42, 46, 47, 45, 35, 37, 46, 46, 40, 26, 22, 31, 34, 25, 20, 18, 8, 12, 26,
32, 33, 30, 24, 32, 50, 52, 46, 44, 28, 20, 25, 29, 27, 19, 8, 0, 9, 26, 28, 32,
24, 10, 22, 37, 45, 54, 48, 37, 42, 59, 69, 61, 49, 43, 48, 54, 61, 66, 57, 42,
44, 60, 78, 81, 71, 66, 80, 90, 96, 113, 118, 90, 81, 99, 110, 109, 99, 81, 71,
84, 88, 94, 113, 96, 74, 87, 98, 96, 102, 99, 84, 84, 91, 102, 116, 104, 91, 97,
91, 83, 87, 81, 74, 72, 61, 67, 87, 77, 62, 70, 78, 72, 81, 84, 70, 66, 62, 69,
77, 78, 73, 59, 57, 53, 48, 53, 55, 48, 38, 32, 50, 73, 69, 66, 76, 74, 67, 71,
72, 75, 77, 67, 59, 63, 58, 56, 65, 66, 62, 56, 49, 58, 71, 72, 84, 94, 81, 79,
92, 88, 92, 99, 84, 73, 69, 55, 72, 87, 70, 58, 57, 46, 47, 69, 77, 68, 55, 53,
69, 84, 88, 83, 65, 55, 60, 61, 60, 52, 37, 31, 35, 39, 43, 36, 22, 10, 16, 32,
30, 17, 11, 14, 27, 33, 33, 34, 22, 6, 9, 23, 19, 4, -10, -26, -33, -15, -6,
-15, -29, -41, -35, -17, -16, -29, -26, -23, -30, -24, -13, -5, -2, -10, -20,
-15, -9, -14, -19, -25, -33, -34, -35, -34, -21, -12, -24, -27, -18, -11, 1, 10,
3, 2, 10, 7, 6, 14, 6, -10, -15, -17, -15, -8, -16, -25, -25, -32, -25, -9, -10,
-16, -18, -23, -17, -6, -12, -23, -22, -26, -24, -24, -38, -50, -49, -49, -51,
-49, -53, -62, -63, -62, -57, -52, -62, -72, -67, -72, -73, -58, -58, -63, -68,
-74, -64, -58, -67, -70, -72, -84, -90, -85, -71, -67, -75, -81, -69, -58, -66,
-68, -58, -60, -59, -53, -51, -45, -44, -51, -50, -38, -35, -45, -48, -45, -46,
-36, -27, -32, -36, -38, -35, -27, -21, -24, -36, -43, -44, -38, -32, -34, -45,
-51, -54, -48, -41, -41, -44, -50, -55, -51, -44, -46, -56, -61, -59, -60, -63,
-63, -62, -64, -77, -76, -64, -65, -73, -76, -80, -76, -71, -81, -79, -77, -84,
-76, -65, -65, -64, -61, -63, -58, -53, -60, -65, -66, -72, -68, -64, -69, -73,
-71, -68, -62, -54, -60, -70, -66, -56, -50, -49, -47, -50, -51, -43, -36, -38,
-44, -56, -68, -64, -49, -56, -70, -70, -69, -66, -57, -52, -56, -57, -60, -58,
-47, -43, -52, -56, -56, -52, -43, -38, -43, -43, -42, -38, -26, -24, -33, -41,
-37, -35, -34, -34, -43, -50, -44, -37, -36, -37, -43, -47, -43, -34, -27, -32,
-39, -42, -43, -38, -33, -34, -43, -56, -60, -54, -48, -46, -52, -66, -66, -48,
-40, -41, -42, -49, -52, -38, -35, -39, -37, -43, -48, -34, -22, -24, -21, -19,
-20, -7, 6, 2, -10, -10, -3, };