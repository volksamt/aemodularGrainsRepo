#define DATA_LENGTH 512
#define DATA AKWF_granular_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 12, 17, 21, 26, 30, 33, 37, 41,
44, 46, 50, 52, 56, 57, 61, 63, 64, 67, 69, 71, 72, 74, 76, 77, 79, 80, 82, 83,
84, 85, 86, 87, 86, 87, 87, 88, 89, 89, 89, 91, 91, 92, 93, 93, 94, 94, 96, 96,
98, 98, 99, 100, 100, 100, 102, 103, 104, 105, 105, 106, 107, 108, 108, 109,
109, 110, 111, 111, 111, 111, 111, 111, 112, 112, 113, 114, 113, 113, 114, 113,
114, 114, 115, 114, 114, 115, 115, 115, 115, 115, 116, 116, 115, 116, 116, 117,
116, 117, 117, 117, 118, 117, 117, 117, 117, 117, 117, 117, 118, 118, 118, 118,
117, 118, 118, 118, 118, 118, 118, 119, 118, 118, 119, 118, 119, 118, 118, 120,
119, 119, 119, 120, 118, 119, 119, 120, 119, 119, 119, 118, 119, 119, 119, 118,
117, 117, 118, 118, 117, 116, 116, 115, 116, 116, 115, 116, 116, 115, 115, 116,
116, 115, 115, 116, 116, 116, 116, 115, 116, 116, 115, 116, 117, 108, 94, 82,
72, 64, 55, 48, 41, 34, 28, 22, 16, 11, 7, 2, -2, -6, -10, -13, -17, -19, -23,
-25, -27, -30, -31, -34, -36, -37, -39, -40, -43, -43, -45, -46, -47, -48, -48,
-50, -50, -50, -51, -53, -53, -53, -53, -53, -55, -55, -55, -55, -55, -56, -56,
-56, -56, -56, -56, -56, -56, -56, -56, -56, -57, -55, -56, -55, -55, -55, -55,
-54, -54, -54, -54, -54, -53, -53, -53, -53, -52, -52, -52, -50, -52, -51, -50,
-50, -49, -49, -49, -48, -48, -48, -47, -47, -46, -46, -45, -44, -45, -43, -43,
-43, -42, -42, -42, -42, -41, -41, -39, -39, -38, -38, -39, -37, -37, -36, -37,
-36, -35, -35, -34, -33, -33, -32, -33, -31, -31, -30, -30, -29, -28, -29, -28,
-27, -27, -26, -26, -25, -25, -24, -23, -23, -25, -30, -35, -40, -43, -46, -50,
-53, -55, -58, -61, -64, -66, -68, -70, -71, -74, -76, -78, -79, -81, -82, -84,
-85, -86, -87, -89, -89, -91, -91, -92, -93, -94, -96, -96, -97, -98, -98, -99,
-101, -101, -98, -93, -85, -82, -77, -73, -69, -67, -62, -60, -58, -54, -52,
-50, -49, -47, -45, -44, -43, -41, -40, -38, -38, -37, -36, -36, -34, -35, -33,
-34, -33, -32, -33, -32, -33, -31, -32, -32, -31, -32, -31, -31, -32, -32, -32,
-32, -32, -33, -33, -33, -33, -34, -34, -34, -34, -35, -35, -36, -35, -36, -36,
-37, -36, -38, -38, -38, -38, -39, -40, -40, -41, -41, -41, -41, -43, -43, -43,
-44, -44, -45, -45, -46, -46, -47, -47, -47, -48, -49, -48, -50, -51, -51, -52,
-51, -52, -53, -54, -53, -54, -54, -55, -56, -56, -57, -58, -58, -58, -58, -60,
-60, -60, -61, -62, -62, -62, -63, -64, -65, -65, -65, -66, -67, -67, -68, -68,
-69, -69, -69, -71, -71, -71, -72, -72, -73, -74, -74, -75, -75, -76, -77, -76,
-78, -79, -76, -66, -53, -44, -39, -30, -22, -16, -10, -3, };