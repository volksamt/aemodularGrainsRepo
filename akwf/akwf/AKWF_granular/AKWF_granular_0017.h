#define DATA_LENGTH 512
#define DATA AKWF_granular_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 3, 3, 5, 5, 6, 7, 7, 8, 8,
10, 10, 11, 12, 13, 13, 13, 14, 15, 15, 17, 18, 18, 18, 20, 21, 21, 22, 22, 23,
24, 25, 25, 27, 27, 27, 29, 29, 29, 31, 31, 32, 33, 34, 34, 35, 35, 36, 36, 38,
38, 40, 40, 41, 42, 42, 43, 43, 45, 44, 47, 45, 48, 47, 49, 48, 51, 50, 52, 51,
53, 52, 54, 55, 55, 57, 55, 61, 55, 64, 50, 84, -13, -77, -54, -72, -58, -68,
-63, -69, -64, -69, -68, -70, -70, -71, -72, -71, -73, -73, -75, -75, -75, -76,
-78, -77, -79, -79, -80, -80, -82, -81, -82, -83, -84, -85, -85, -86, -87, -87,
-88, -89, -90, -91, -91, -91, -92, -93, -93, -94, -94, -96, -97, -98, -97, -99,
-99, -100, -99, -101, -102, -103, -103, -104, -106, -104, -104, -104, -105,
-103, -104, -104, -106, -103, -104, -103, -106, -102, -105, -104, -106, -101,
-107, -103, -104, -102, -105, -107, -96, -82, 84, 116, 93, 111, 100, 106, 97,
106, 99, 100, 96, 101, 96, 96, 94, 97, 93, 93, 93, 92, 91, 89, 90, 89, 88, 86,
88, 86, 85, 85, 85, 83, 82, 82, 81, 80, 80, 79, 77, 77, 76, 76, 75, 73, 74, 73,
72, 70, 72, 69, 68, 65, 74, 9, -66, -63, -64, -61, -62, -60, -60, -60, -58, -58,
-58, -57, -56, -56, -55, -54, -53, -53, -52, -51, -51, -49, -48, -48, -47, -46,
-47, -45, -44, -44, -44, -42, -42, -41, -41, -39, -39, -38, -37, -37, -35, -35,
-33, -35, -32, -33, -29, -32, -30, -32, -25, -31, -26, 20, 25, 27, 25, 23, 24,
23, 23, 21, 21, 19, 20, 18, 18, 17, 17, 16, 15, 14, 14, 13, 12, 11, 11, 10, 10,
9, 8, 7, 6, 6, 5, 4, 3, 3, 1, 1, 0, 0, 1, -1, -1, 0, -1, -1, 1, 0, 0, 0, 0, 0,
0, 0, 0, -1, 0, 0, 1, 1, 0, 1, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, -1, 1, 0, 0, -1,
0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0,
0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, -1, -1, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, -1, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0,
0, 0, 0, 0, 1, -1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, -1,
0, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 1, 1, -1, 0, 0, 0, 1, -1, 0, 0, 0, 0, 1, 1, 0,
1, };