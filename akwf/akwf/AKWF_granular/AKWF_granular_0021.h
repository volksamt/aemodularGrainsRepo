#define DATA_LENGTH 512
#define DATA AKWF_granular_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 12, 21, 31, 41, 50, 61, 70, 79, 87,
97, 103, 108, 113, 116, 119, 119, 119, 116, 113, 107, 101, 93, 84, 74, 63, 52,
41, 28, 16, 2, -10, -24, -35, -47, -58, -67, -77, -85, -92, -97, -102, -105,
-107, -107, -106, -104, -100, -95, -89, -82, -76, -66, -58, -48, -39, -29, -18,
-8, 1, 11, 21, 29, 37, 43, 49, 55, 60, 63, 66, 67, 67, 66, 64, 61, 59, 54, 49,
44, 38, 31, 24, 16, 9, 1, -6, -13, -21, -28, -35, -40, -46, -50, -54, -57, -60,
-62, -63, -64, -63, -62, -60, -57, -53, -50, -45, -40, -33, -27, -20, -12, -6,
1, 9, 16, 22, 28, 34, 39, 44, 48, 50, 53, 54, 55, 55, 53, 53, 50, 46, 43, 38,
33, 29, 23, 18, 12, 7, 1, -6, -12, -17, -22, -27, -32, -36, -39, -43, -46, -48,
-49, -49, -50, -50, -50, -49, -47, -45, -43, -41, -38, -35, -31, -27, -23, -20,
-16, -12, -8, -3, -1, 3, 6, 10, 11, 13, 16, 17, 18, 19, 21, 20, 20, 20, 19, 18,
18, 16, 13, 13, 10, 9, 6, 4, 2, 0, -3, -5, -8, -11, -15, -20, -25, -30, -37,
-42, -49, -56, -63, -69, -75, -81, -87, -91, -96, -100, -101, -103, -103, -103,
-101, -97, -94, -89, -83, -75, -67, -58, -49, -39, -28, -18, -8, 4, 14, 24, 34,
44, 52, 60, 68, 73, 78, 83, 85, 88, 88, 87, 86, 83, 79, 75, 69, 63, 56, 48, 40,
32, 24, 14, 6, -3, -11, -19, -27, -34, -40, -46, -50, -55, -58, -61, -62, -61,
-62, -60, -59, -55, -52, -48, -42, -38, -31, -25, -18, -11, -5, 2, 8, 14, 21,
27, 33, 38, 42, 46, 49, 52, 53, 55, 55, 55, 54, 52, 51, 47, 43, 38, 32, 24, 17,
7, -2, -13, -23, -35, -45, -57, -67, -77, -87, -95, -101, -108, -113, -116,
-119, -119, -117, -114, -111, -105, -99, -90, -81, -71, -60, -46, -36, -16, 9,
21, 34, 47, 59, 69, 80, 88, 96, 103, 108, 112, 114, 115, 114, 113, 110, 105,
100, 92, 85, 77, 67, 57, 47, 37, 26, 16, 5, -5, -14, -24, -32, -41, -48, -54,
-59, -63, -65, -68, -69, -68, -67, -65, -61, -57, -53, -47, -40, -33, -26, -19,
-11, -2, 5, 13, 21, 27, 34, 41, 48, 55, 62, 67, 74, 79, 85, 90, 95, 99, 104,
107, 109, 110, 112, 111, 111, 108, 107, 103, 99, 93, 87, 80, 73, 65, 55, 47, 36,
27, 17, 7, -3, -13, -23, -32, -39, -48, -54, -61, -67, -71, -74, -76, -78, -79,
-78, -76, -74, -71, -66, -59, -54, -47, -40, -32, -24, -16, -8, 0, 8, 17, 25,
31, 37, 45, 49, 53, 58, 60, 64, 64, 65, 65, 63, 61, 59, 56, 52, 47, 42, 36, 30,
25, 19, 12, 6, 0, -6, -11, -18, -22, -27, -31, -35, -37, -40, -43, -44, -45,
-45, -44, -43, -42, -39, -36, -33, -29, -24, -18, -12, -4, };