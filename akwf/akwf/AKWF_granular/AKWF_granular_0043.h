#define DATA_LENGTH 512
#define DATA AKWF_granular_0043

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 18, 26, 37, 47, 56, 64, 72, 78, 83,
88, 92, 93, 94, 94, 94, 92, 90, 87, 83, 80, 74, 70, 65, 60, 55, 50, 45, 40, 36,
31, 29, 24, 20, 18, 15, 12, 9, 8, 6, 5, 3, 2, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1,
-1, -1, -1, -1, -3, -4, -5, -7, -9, -10, -13, -15, -20, -23, -27, -30, -35, -41,
-46, -52, -58, -64, -69, -76, -82, -89, -94, -100, -106, -110, -114, -116, -119,
-119, -119, -116, -114, -108, -102, -93, -84, -74, -61, -49, -35, -20, -6, 8,
23, 37, 49, 61, 70, 80, 87, 92, 97, 100, 102, 103, 102, 100, 97, 95, 90, 85, 81,
75, 69, 63, 58, 52, 47, 41, 38, 32, 28, 25, 21, 18, 16, 13, 10, 8, 7, 4, 3, 3,
2, 1, 0, 0, 1, 0, 0, 1, -1, 1, 0, 0, 0, 0, 0, 0, -1, -1, -1, -3, -3, -4, -4, -5,
-6, -8, -8, -10, -12, -14, -15, -16, -18, -19, -21, -23, -24, -25, -27, -27,
-29, -29, -29, -30, -29, -29, -29, -27, -25, -23, -22, -20, -17, -16, -13, -10,
-7, -6, -3, 0, 0, 3, 3, 5, 5, 6, 6, 6, 5, 5, 4, 2, 3, 2, 0, 0, 0, 0, 0, -1, 0,
0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 1, 1, 1, -1, 1, 0, 1, 0, 0, -1, 0, 0, 1, 0, 0,
-1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, -1,
0, 0, 0, 0, 1, 0, 1, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 1,
0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 1,
0, 0, -1, 0, 1, 0, 0, -1, 1, 0, 0, 0, -1, -1, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 1,
0, 0, 0, 1, 0, 1, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, -1, 0, 0, 1, -1, 0, 0, -1, 0, 0,
0, 0, 0, -1, -1, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 1, 0,
0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 1, 0, -1, 0, -1, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
-1, -2, -2, -2, -3, -3, -2, -2, 0, 0, 0, 0, 0, 0, 0, -1, -2, -2, -2, -3, -4, -6,
-7, -8, -10, -12, -13, -15, -18, -21, -24, -27, -30, -34, -38, -42, -45, -49,
-53, -56, -60, -62, -64, -66, -68, -69, -68, -66, -65, -60, -56, -51, -44, -37,
-28, -21, -10, -2, };