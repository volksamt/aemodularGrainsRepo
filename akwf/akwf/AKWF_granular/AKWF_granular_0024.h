#define DATA_LENGTH 512
#define DATA AKWF_granular_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 15, 21, 29, 36, 42, 50, 56, 63,
69, 75, 81, 87, 92, 97, 100, 105, 108, 111, 114, 116, 116, 118, 119, 120, 119,
119, 119, 119, 119, 118, 119, 118, 118, 119, 118, 118, 119, 117, 118, 117, 118,
116, 115, 116, 116, 114, 114, 115, 113, 113, 113, 112, 112, 112, 111, 110, 110,
109, 109, 108, 107, 106, 105, 105, 104, 103, 102, 101, 100, 100, 99, 97, 97, 95,
94, 93, 92, 91, 90, 88, 88, 86, 85, 83, 82, 80, 80, 79, 77, 74, 73, 72, 70, 68,
68, 66, 64, 63, 61, 59, 57, 56, 53, 53, 50, 48, 47, 45, 44, 42, 40, 37, 35, 33,
31, 30, 28, 26, 24, 22, 19, 18, 17, 14, 12, 10, 7, 5, 4, 2, 0, -2, -5, -7, -9,
-11, -13, -15, -17, -18, -21, -22, -23, -26, -28, -29, -32, -33, -35, -37, -38,
-39, -41, -43, -43, -44, -47, -48, -49, -51, -52, -54, -57, -58, -59, -61, -62,
-65, -66, -66, -69, -70, -71, -73, -74, -75, -77, -79, -80, -81, -83, -84, -85,
-86, -87, -88, -89, -91, -92, -93, -94, -95, -96, -97, -98, -98, -100, -101,
-101, -102, -103, -103, -104, -105, -105, -107, -107, -108, -108, -108, -109,
-110, -109, -111, -111, -111, -111, -111, -111, -112, -112, -113, -113, -112,
-112, -112, -112, -112, -112, -110, -110, -109, -107, -106, -104, -103, -100,
-97, -94, -90, -86, -81, -78, -72, -67, -62, -55, -50, -43, -37, -30, -23, -17,
-10, -3, 4, 11, 19, 25, 31, 38, 45, 51, 56, 63, 68, 73, 79, 83, 86, 90, 92, 95,
98, 99, 100, 101, 101, 101, 101, 102, 102, 101, 101, 101, 101, 101, 101, 100,
100, 100, 100, 99, 100, 100, 100, 99, 99, 99, 99, 98, 98, 97, 97, 97, 97, 96,
96, 95, 94, 94, 94, 93, 93, 92, 91, 91, 90, 89, 89, 88, 87, 87, 86, 85, 85, 83,
82, 82, 81, 79, 79, 77, 77, 76, 75, 74, 72, 72, 70, 69, 67, 68, 66, 64, 64, 62,
61, 60, 58, 57, 56, 54, 53, 51, 50, 49, 47, 45, 44, 43, 40, 40, 37, 36, 35, 34,
31, 30, 29, 27, 25, 23, 21, 19, 19, 16, 15, 13, 10, 9, 7, 6, 4, 2, 1, -1, -3,
-5, -7, -8, -10, -12, -13, -16, -18, -20, -21, -23, -24, -26, -28, -29, -32,
-34, -35, -37, -38, -41, -43, -43, -45, -47, -48, -51, -53, -54, -56, -57, -58,
-60, -61, -63, -64, -66, -68, -70, -71, -72, -74, -76, -77, -78, -79, -81, -82,
-82, -84, -85, -86, -87, -89, -90, -91, -93, -94, -95, -95, -96, -97, -98, -99,
-100, -101, -102, -102, -103, -104, -105, -106, -107, -107, -107, -108, -108,
-109, -109, -110, -110, -110, -110, -111, -112, -112, -111, -112, -112, -112,
-112, -112, -112, -112, -112, -112, -111, -111, -109, -109, -107, -105, -103,
-101, -98, -95, -91, -87, -83, -79, -74, -69, -63, -57, -52, -46, -40, -33, -26,
-19, -12, -6, };