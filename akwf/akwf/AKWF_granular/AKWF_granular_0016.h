#define DATA_LENGTH 512
#define DATA AKWF_granular_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {97, 109, 100, 105, 99, 105, 99, 102,
98, 101, 98, 99, 98, 98, 96, 98, 96, 96, 95, 95, 94, 94, 94, 93, 92, 91, 91, 91,
90, 90, 90, 88, 88, 87, 87, 86, 86, 85, 85, 85, 84, 83, 83, 83, 81, 82, 80, 80,
79, 80, 78, 79, 77, 78, 76, 78, 75, 77, 75, 75, 74, 74, 72, 72, 71, 72, 72, 70,
71, 68, 70, 67, 71, 64, 72, 61, 77, -2, -80, -55, -67, -60, -64, -60, -62, -59,
-60, -59, -59, -59, -58, -58, -57, -57, -55, -56, -55, -55, -53, -54, -53, -54,
-52, -52, -52, -51, -50, -49, -49, -50, -48, -48, -47, -46, -47, -46, -46, -44,
-45, -44, -43, -42, -43, -42, -42, -40, -40, -39, -39, -39, -38, -39, -37, -36,
-37, -36, -35, -35, -34, -34, -33, -34, -33, -32, -31, -32, -30, -31, -29, -30,
-27, -29, -26, -28, -28, 20, 29, 25, 27, 24, 25, 23, 24, 22, 23, 22, 23, 20, 22,
20, 20, 18, 19, 18, 17, 17, 17, 16, 16, 15, 15, 15, 14, 14, 13, 12, 12, 12, 11,
11, 10, 10, 9, 9, 7, 7, 7, 6, 6, 5, 6, 4, 4, 4, 3, 2, 3, 1, 0, 0, -1, -1, 0, 0,
0, 0, 0, -1, 0, -1, 0, 0, -1, 0, 1, 1, 0, 1, 0, 1, 1, -1, 0, 0, 1, 0, 0, 0, 0,
0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 1, 1,
2, 3, 4, 3, 5, 4, 5, 6, 7, 7, 7, 8, 9, 8, 9, 9, 9, 11, 11, 12, 12, 13, 13, 13,
14, 15, 14, 16, 16, 17, 16, 18, 18, 18, 19, 19, 21, 21, 21, 21, 22, 22, 23, 23,
24, 24, 25, 26, 27, 26, 27, 28, 27, 29, 29, 29, 30, 30, 31, 31, 32, 32, 33, 33,
34, 35, 35, 35, 36, 37, 37, 37, 38, 38, 38, 39, 39, 40, 40, 41, 41, 42, 43, 43,
43, 44, 44, 45, 45, 45, 47, 47, 47, 48, 47, 49, 49, 50, 50, 51, 52, 51, 52, 53,
52, 53, 54, 55, 55, 55, 56, 56, 58, 57, 59, 57, 62, 56, 68, 2, -71, -58, -64,
-61, -63, -63, -64, -64, -65, -65, -65, -66, -66, -68, -67, -68, -68, -69, -70,
-70, -70, -71, -71, -73, -72, -73, -74, -74, -74, -75, -75, -75, -76, -77, -78,
-77, -79, -79, -79, -79, -80, -80, -81, -81, -82, -82, -82, -83, -84, -84, -85,
-86, -86, -86, -87, -87, -87, -88, -88, -89, -90, -91, -90, -91, -91, -92, -93,
-93, -93, -94, -95, -94, -95, -96, -95, -97, -96, -97, -97, -99, -99, -99, -99,
-100, -100, -102, -102, -102, -102, -103, -103, -102, -102, -103, -103, -103,
-102, -103, -103, -102, -103, -103, -102, -101, -102, -102, -104, -102, -103,
-102, -103, -102, -104, -102, -103, -101, -104, -100, -104, -100, -103, -100,
-103, -102, -99, -113, -22, };