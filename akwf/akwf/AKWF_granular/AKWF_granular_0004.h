#define DATA_LENGTH 512
#define DATA AKWF_granular_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 5, 6, 8, 8, 5, 5, 8, 10, 12,
13, 16, 17, 19, 21, 23, 26, 28, 29, 31, 32, 34, 36, 38, 39, 41, 42, 45, 46, 47,
48, 49, 51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 59, 60, 62, 61, 62, 63, 64, 64,
65, 65, 65, 67, 66, 67, 67, 68, 69, 69, 69, 71, 70, 71, 72, 72, 73, 73, 74, 74,
75, 76, 76, 77, 79, 78, 80, 80, 80, 82, 83, 52, 30, 35, 35, 36, 37, 39, 40, 41,
42, 44, 44, 46, 47, 48, 50, 51, 51, 53, 55, 55, 56, 58, 59, 60, 61, 63, 63, 64,
66, 66, 68, 69, 69, 71, 71, 73, 74, 74, 76, 77, 78, 79, 79, 81, 80, 82, 82, 84,
85, 86, 87, 88, 88, 90, 91, 92, 93, 93, 95, 95, 96, 98, 97, 100, 101, 101, 104,
101, 104, 107, 103, 111, 104, 113, 115, 69, 16, 13, 24, 16, 24, 22, 25, 28, 28,
30, 32, 32, 35, 36, 39, 39, 41, 44, 43, 46, 47, 47, 50, 52, 52, 54, 54, 57, 59,
59, 61, 62, 63, 65, 66, 68, 68, 70, 70, 71, 72, 73, 74, 75, 77, 76, 77, 78, 78,
79, 79, 80, 80, 79, 81, 80, 80, 81, 81, 81, 81, 82, 82, 82, 84, 82, 84, 83, 84,
83, 85, 83, 88, 81, 98, 48, -47, -60, -52, -50, -53, -49, -50, -48, -47, -47,
-44, -44, -42, -42, -41, -40, -38, -38, -36, -36, -33, -32, -31, -29, -29, -27,
-26, -26, -24, -23, -22, -20, -18, -17, -17, -14, -12, -13, -11, -10, -8, -7,
-5, -5, -3, -2, 0, 0, 3, 4, 5, 7, 8, 10, 11, 11, 13, 13, 15, 17, 17, 20, 20, 22,
24, 23, 26, 27, 26, 32, 26, 35, 29, 34, 43, -25, -88, -96, -83, -90, -87, -85,
-89, -83, -87, -84, -83, -84, -82, -83, -82, -80, -82, -80, -80, -79, -77, -79,
-77, -77, -76, -76, -75, -74, -73, -73, -72, -71, -71, -70, -70, -69, -69, -68,
-67, -66, -65, -65, -63, -62, -63, -62, -61, -60, -58, -58, -57, -57, -56, -55,
-53, -53, -52, -52, -49, -49, -48, -47, -45, -43, -43, -43, -39, -40, -37, -37,
-34, -33, -32, -30, -23, -48, -103, -108, -101, -103, -100, -100, -99, -97, -96,
-94, -93, -93, -90, -90, -88, -87, -85, -84, -83, -82, -80, -79, -78, -77, -75,
-74, -73, -71, -71, -68, -67, -66, -65, -64, -62, -60, -60, -58, -57, -55, -53,
-52, -51, -49, -48, -46, -44, -43, -41, -40, -38, -36, -35, -34, -32, -30, -29,
-27, -26, -23, -22, -20, -19, -18, -16, -15, -13, -11, -11, -8, -8, -6, -4, -5,
2, -6, -26, -37, -32, -32, -32, -30, -31, -29, -29, -28, -27, -27, -25, -25,
-25, -24, -24, -22, -22, -22, -20, -20, -20, -19, -18, -18, -18, -16, -16, -16,
-15, -14, -14, -13, -12, -11, -10, -9, -8, -9, -7, -6, -5, -5, -3, -3, -1, 0, };