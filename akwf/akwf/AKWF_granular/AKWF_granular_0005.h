#define DATA_LENGTH 512
#define DATA AKWF_granular_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 6, 7, 8, 9, 11, 12, 14, 15,
18, 18, 19, 21, 23, 24, 25, 26, 28, 30, 30, 32, 34, 35, 36, 38, 38, 40, 41, 43,
45, 45, 47, 47, 49, 50, 51, 53, 54, 55, 56, 57, 58, 59, 60, 62, 62, 63, 64, 65,
67, 67, 69, 69, 70, 71, 72, 72, 74, 74, 76, 76, 77, 78, 79, 80, 80, 81, 82, 82,
84, 83, 84, 85, 86, 87, 88, 88, 89, 89, 90, 90, 91, 91, 92, 93, 92, 94, 94, 94,
95, 95, 95, 96, 97, 97, 97, 98, 99, 98, 99, 100, 100, 100, 101, 102, 101, 101,
102, 101, 102, 102, 102, 103, 104, 103, 104, 103, 105, 104, 105, 105, 105, 106,
106, 106, 105, 106, 106, 106, 106, 107, 107, 107, 107, 107, 107, 107, 107, 108,
108, 108, 107, 108, 108, 108, 108, 108, 109, 108, 108, 109, 109, 109, 108, 109,
109, 109, 108, 109, 109, 109, 110, 108, 108, 109, 108, 109, 109, 108, 109, 108,
108, 108, 108, 109, 108, 108, 108, 108, 108, 108, 107, 108, 107, 108, 107, 108,
107, 107, 107, 107, 107, 107, 107, 107, 107, 107, 107, 106, 106, 107, 107, 106,
105, 106, 106, 106, 105, 106, 105, 104, 104, 106, 104, 104, 104, 104, 104, 105,
104, 104, 103, 103, 103, 103, 102, 103, 102, 101, 101, 103, 102, 100, 101, 102,
101, 100, 99, 102, 103, 101, 91, 69, 48, 41, 47, 48, 47, 45, 47, 48, 48, 47, 47,
49, 49, 47, 48, 48, 49, 48, 48, 49, 50, 47, 50, 59, 47, -13, -80, -106, -106,
-104, -101, -100, -103, -103, -102, -102, -102, -103, -103, -103, -104, -104,
-104, -104, -104, -104, -105, -104, -105, -105, -105, -105, -105, -106, -107,
-107, -107, -107, -108, -108, -108, -108, -109, -109, -109, -109, -109, -109,
-110, -110, -110, -112, -112, -112, -111, -112, -112, -113, -113, -112, -114,
-114, -114, -113, -114, -113, -115, -115, -114, -115, -116, -116, -115, -116,
-117, -116, -117, -117, -116, -117, -117, -119, -118, -118, -118, -118, -118,
-118, -119, -119, -119, -119, -119, -118, -118, -118, -118, -117, -118, -116,
-116, -117, -117, -116, -115, -116, -114, -115, -114, -114, -114, -113, -113,
-113, -113, -112, -112, -112, -111, -111, -111, -110, -110, -110, -109, -110,
-108, -108, -107, -108, -107, -107, -107, -106, -106, -105, -104, -104, -103,
-103, -102, -102, -101, -100, -100, -101, -99, -99, -98, -98, -97, -97, -97,
-97, -95, -95, -95, -95, -94, -93, -93, -92, -92, -91, -90, -90, -89, -89, -88,
-89, -87, -85, -86, -86, -84, -83, -83, -83, -82, -81, -80, -79, -78, -78, -76,
-75, -75, -74, -73, -72, -71, -71, -70, -68, -67, -67, -66, -64, -63, -63, -62,
-60, -59, -58, -57, -57, -54, -53, -53, -51, -50, -49, -47, -47, -45, -44, -43,
-42, -41, -39, -38, -37, -35, -34, -32, -31, -30, -27, -26, -24, -24, -22, -21,
-20, -19, -16, -15, -14, -12, -10, -9, -8, -6, -5, -3, -2, 0, };