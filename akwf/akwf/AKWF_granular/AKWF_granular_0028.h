#define DATA_LENGTH 512
#define DATA AKWF_granular_0028

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 1, 3, 7, 16, 28, 38, 33, 23, 17,
21, 35, 34, 27, 16, 7, 3, 4, 8, 9, 11, 18, 28, 34, 42, 43, 51, 57, 65, 75, 90,
91, 76, 66, 71, 89, 97, 96, 84, 80, 83, 77, 61, 41, 32, 30, 30, 18, -4, -27,
-35, -35, -46, -54, -64, -66, -68, -71, -79, -87, -96, -110, -114, -116, -111,
-115, -119, -112, -103, -88, -80, -79, -78, -70, -51, -42, -39, -42, -42, -42,
-44, -43, -39, -28, -12, 5, 16, 31, 39, 39, 27, 28, 39, 40, 44, 33, 33, 42, 40,
39, 40, 41, 37, 30, 26, 15, 0, -12, -31, -51, -53, -55, -60, -59, -59, -53, -47,
-49, -46, -43, -43, -49, -54, -62, -62, -61, -67, -76, -79, -71, -61, -56, -56,
-61, -74, -73, -74, -70, -61, -63, -53, -35, -30, -30, -28, -15, 1, 9, 22, 27,
30, 34, 34, 22, 15, 12, 11, 21, 24, 24, 23, 28, 39, 41, 33, 37, 35, 31, 23, 16,
27, 33, 39, 43, 49, 60, 63, 63, 66, 67, 72, 71, 70, 69, 65, 56, 47, 54, 60, 52,
46, 44, 43, 43, 32, 21, 10, 1, -17, -42, -65, -83, -86, -97, -101, -94, -89,
-83, -75, -63, -58, -54, -48, -32, -28, -30, -24, -20, -3, 16, 27, 32, 30, 33,
28, 15, 4, -1, 0, -4, -8, -14, -10, 1, 5, 5, 5, 10, 20, 29, 25, 26, 33, 58, 71,
67, 60, 46, 35, 31, 23, 20, 18, 10, 5, -5, -11, -18, -32, -54, -69, -70, -63,
-66, -81, -87, -76, -59, -52, -51, -55, -61, -57, -50, -45, -49, -47, -35, -24,
-19, -26, -28, -37, -42, -40, -40, -42, -41, -31, -22, -18, -13, -2, 4, 7, 11,
16, 22, 32, 44, 50, 45, 47, 45, 43, 36, 23, 12, 6, 12, 12, 8, 8, 0, -8, 0, 6, 1,
-6, -14, 4, 23, 30, 30, 23, 31, 40, 36, 31, 26, 26, 36, 42, 43, 52, 55, 39, 27,
20, 19, 14, 0, -6, -7, -8, -4, -3, -5, -2, 2, 5, 10, 24, 28, 24, 16, 15, 18, 17,
15, 11, 7, 2, 0, 3, 5, -8, -19, -26, -24, -25, -32, -38, -41, -37, -24, -17,
-17, -8, -1, 6, 13, 17, 24, 27, 41, 53, 54, 65, 72, 74, 71, 59, 45, 46, 48, 46,
44, 37, 32, 32, 26, 16, 9, 2, -4, -7, -13, -18, -16, -19, -24, -20, -5, 9, 3,
-20, -45, -55, -60, -63, -65, -53, -33, -33, -47, -66, -85, -93, -89, -73, -57,
-39, -20, -9, -15, -21, -24, -23, -11, 10, 26, 24, 29, 31, 32, 31, 31, 33, 27,
15, 14, 12, 10, 4, -2, -2, 4, 15, 21, 25, 16, 14, 23, 35, 39, 34, 23, 22, 28,
40, 44, 41, 44, 53, 51, 39, 30, 19, 15, 21, 29, 29, 24, 25, 34, 34, 26, 22, 24,
28, 23, 23, 14, 7, -1, -7, -11, -21, -21, -11, -21, -32, -33, -28, -16, -6, -3,
-5, 1, -1, };