#define DATA_LENGTH 512
#define DATA AKWF_granular_0041

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 2, 3, 6, 7, 8, 10, 12, 14, 17, 19,
21, 22, 24, 25, 27, 29, 31, 31, 33, 34, 34, 36, 35, 37, 36, 38, 38, 40, 42, 43,
44, 46, 48, 51, 55, 58, 62, 66, 70, 76, 81, 87, 91, 96, 101, 105, 108, 112, 115,
117, 118, 118, 118, 116, 114, 112, 108, 103, 98, 91, 84, 78, 69, 61, 52, 43, 33,
24, 14, 5, -5, -15, -23, -34, -41, -50, -57, -65, -70, -75, -80, -83, -85, -87,
-87, -86, -85, -82, -78, -73, -67, -61, -55, -47, -39, -32, -24, -17, -9, -2, 4,
9, 15, 19, 23, 27, 28, 29, 29, 28, 26, 24, 20, 16, 12, 6, 1, -5, -12, -17, -25,
-31, -38, -45, -52, -58, -64, -70, -75, -81, -85, -90, -93, -96, -98, -100,
-101, -102, -101, -101, -99, -96, -94, -90, -87, -82, -77, -73, -67, -63, -57,
-53, -48, -43, -39, -35, -31, -28, -25, -22, -19, -19, -16, -14, -13, -12, -10,
-8, -6, -5, -2, 0, 3, 7, 11, 14, 18, 22, 27, 30, 35, 40, 44, 48, 51, 54, 57, 61,
63, 64, 65, 66, 67, 68, 66, 67, 65, 64, 63, 61, 58, 55, 52, 50, 47, 44, 40, 37,
33, 30, 26, 23, 20, 15, 14, 11, 9, 7, 7, 6, 6, 6, 9, 11, 14, 17, 21, 27, 32, 38,
44, 50, 57, 64, 70, 75, 81, 87, 91, 96, 99, 101, 103, 102, 102, 101, 99, 96, 91,
87, 80, 73, 66, 58, 50, 41, 32, 22, 12, 3, -7, -18, -27, -36, -46, -54, -64,
-71, -79, -85, -92, -96, -101, -104, -106, -108, -108, -109, -107, -104, -102,
-97, -93, -89, -83, -77, -72, -66, -59, -54, -47, -43, -38, -33, -29, -26, -23,
-22, -19, -19, -19, -20, -20, -21, -24, -25, -27, -30, -32, -34, -37, -39, -41,
-43, -46, -48, -49, -51, -53, -54, -55, -56, -56, -56, -56, -56, -55, -55, -54,
-53, -51, -48, -46, -43, -39, -37, -32, -28, -25, -21, -17, -14, -10, -6, -2, 1,
4, 6, 10, 11, 13, 14, 17, 18, 19, 20, 20, 23, 24, 27, 29, 31, 35, 38, 43, 47,
52, 56, 62, 69, 74, 80, 86, 93, 97, 101, 106, 108, 113, 114, 115, 117, 117, 116,
113, 112, 108, 105, 100, 95, 89, 84, 76, 69, 61, 53, 46, 38, 29, 21, 12, 5, -2,
-10, -16, -24, -29, -35, -39, -42, -45, -47, -47, -47, -45, -44, -40, -36, -31,
-25, -17, -10, -2, 6, 14, 22, 31, 39, 46, 53, 59, 64, 69, 73, 76, 77, 78, 77,
76, 73, 68, 63, 57, 50, 43, 35, 25, 17, 7, -3, -11, -21, -31, -40, -49, -59,
-67, -75, -83, -90, -96, -101, -106, -111, -114, -116, -119, -120, -119, -118,
-116, -115, -111, -107, -103, -99, -94, -88, -84, -78, -73, -68, -63, -58, -54,
-51, -48, -44, -42, -39, -38, -36, -36, -35, -35, -34, -33, -32, -32, -31, -30,
-29, -27, -25, -22, -19, -16, -13, -10, -6, -2, };