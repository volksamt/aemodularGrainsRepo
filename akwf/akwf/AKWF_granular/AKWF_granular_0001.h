#define DATA_LENGTH 512
#define DATA AKWF_granular_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 9, 11, 13, 16, 17, 20, 23,
25, 27, 29, 31, 33, 36, 37, 40, 41, 44, 46, 48, 49, 52, 53, 55, 57, 59, 60, 62,
64, 66, 67, 68, 70, 71, 74, 75, 77, 77, 79, 81, 81, 82, 84, 85, 86, 86, 87, 88,
89, 90, 90, 91, 91, 91, 94, 93, 94, 95, 96, 96, 96, 96, 98, 98, 98, 100, 99,
100, 101, 100, 101, 100, 101, 101, 102, 102, 102, 103, 103, 103, 103, 103, 103,
104, 105, 104, 104, 105, 104, 105, 104, 105, 105, 105, 105, 106, 106, 106, 106,
105, 107, 107, 106, 107, 107, 107, 107, 106, 107, 107, 108, 108, 108, 107, 107,
108, 108, 107, 108, 107, 107, 107, 107, 107, 107, 106, 108, 107, 106, 107, 106,
107, 106, 106, 107, 107, 107, 107, 107, 107, 107, 107, 107, 107, 107, 108, 107,
108, 108, 108, 108, 109, 109, 109, 109, 109, 109, 110, 110, 110, 110, 111, 110,
111, 111, 111, 111, 112, 112, 111, 112, 112, 111, 112, 114, 112, 113, 114, 113,
113, 115, 114, 113, 114, 115, 111, 115, 117, 120, 71, -36, -73, -59, -59, -59,
-57, -57, -58, -56, -56, -55, -54, -53, -53, -53, -52, -52, -51, -49, -49, -49,
-48, -48, -46, -47, -46, -46, -45, -43, -43, -42, -41, -41, -41, -40, -40, -39,
-39, -39, -38, -37, -36, -35, -35, -34, -33, -33, -32, -32, -31, -30, -29, -29,
-29, -28, -27, -27, -26, -26, -26, -25, -23, -24, -23, -22, -21, -21, -20, -20,
-19, -18, -17, -17, -17, -16, -16, -15, -14, -14, -13, -12, -12, -11, -9, -10,
-9, -8, -7, -7, -6, -5, -5, -4, -4, -2, -2, -1, -1, 0, 1, 2, 2, 2, 3, 4, 5, 6,
7, 7, 8, 9, 10, 10, 12, 13, 13, 14, 15, 14, 15, 18, 17, 19, 21, 21, 21, 22, 23,
23, 24, 27, 26, 27, 29, 30, 29, 32, 33, 32, 35, 37, 34, 37, 41, 35, 40, 55, 4,
-72, -106, -110, -98, -99, -105, -98, -97, -100, -99, -96, -98, -97, -94, -95,
-96, -93, -93, -93, -92, -91, -92, -90, -89, -89, -89, -87, -87, -88, -86, -85,
-85, -84, -83, -84, -83, -82, -82, -83, -81, -81, -80, -81, -80, -79, -79, -79,
-78, -78, -77, -77, -77, -76, -76, -76, -76, -76, -76, -75, -75, -75, -76, -75,
-75, -74, -74, -74, -75, -74, -74, -75, -74, -74, -74, -74, -73, -73, -74, -74,
-74, -74, -74, -73, -74, -74, -73, -74, -74, -73, -73, -74, -74, -73, -74, -73,
-74, -73, -73, -73, -74, -72, -73, -73, -72, -73, -72, -73, -72, -72, -71, -72,
-72, -71, -71, -70, -70, -69, -70, -69, -68, -67, -67, -67, -66, -66, -65, -64,
-64, -63, -62, -62, -61, -60, -60, -58, -57, -57, -56, -54, -53, -52, -51, -50,
-48, -47, -45, -44, -42, -42, -39, -38, -37, -36, -34, -32, -30, -28, -27, -25,
-23, -21, -19, -18, -15, -13, -11, -10, -8, -7, -4, -2, 0, };