#define DATA_LENGTH 512
#define DATA AKWF_granular_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 9, 14, 16, 18, 22, 24, 27,
30, 33, 36, 38, 42, 44, 46, 50, 52, 54, 57, 60, 63, 65, 67, 70, 72, 74, 77, 79,
81, 84, 85, 88, 89, 91, 93, 95, 97, 98, 100, 101, 103, 105, 105, 106, 108, 109,
110, 111, 111, 112, 112, 113, 114, 115, 114, 115, 115, 115, 115, 115, 114, 114,
114, 114, 114, 114, 113, 111, 112, 110, 110, 109, 108, 107, 106, 105, 104, 103,
101, 101, 99, 97, 96, 93, 94, 92, 89, 88, 86, 83, 83, 80, 79, 77, 74, 73, 71,
69, 66, 63, 62, 59, 57, 54, 53, 50, 48, 46, 42, 41, 38, 36, 34, 31, 28, 25, 24,
21, 18, 16, 14, 11, 8, 7, 4, 2, -1, -3, -5, -8, -11, -13, -15, -18, -20, -22,
-24, -26, -29, -31, -33, -36, -37, -40, -42, -43, -46, -47, -49, -51, -52, -55,
-56, -58, -59, -61, -62, -63, -66, -66, -68, -69, -71, -72, -73, -74, -76, -76,
-77, -77, -78, -79, -80, -80, -80, -82, -82, -82, -82, -84, -83, -83, -83, -85,
-84, -84, -84, -83, -84, -84, -84, -83, -83, -82, -82, -81, -80, -80, -79, -79,
-78, -77, -77, -77, -75, -75, -73, -72, -71, -70, -69, -67, -66, -65, -63, -63,
-61, -60, -58, -57, -56, -54, -52, -52, -50, -48, -46, -45, -43, -41, -40, -39,
-36, -35, -34, -32, -31, -29, -27, -26, -24, -21, -20, -19, -16, -15, -14, -11,
-10, -8, -6, -4, -2, -2, 1, 3, 5, 7, 9, 10, 11, 14, 16, 18, 19, 21, 23, 25, 27,
28, 31, 32, 33, 36, 38, 40, 41, 43, 45, 47, 48, 50, 52, 53, 55, 56, 58, 60, 61,
63, 65, 66, 66, 68, 70, 70, 73, 74, 74, 76, 77, 78, 80, 80, 81, 81, 83, 84, 84,
85, 86, 86, 87, 86, 87, 88, 88, 89, 89, 89, 89, 89, 90, 90, 89, 89, 90, 88, 89,
87, 87, 87, 86, 86, 85, 84, 84, 83, 83, 81, 81, 79, 77, 77, 75, 74, 73, 71, 70,
69, 68, 66, 64, 62, 60, 58, 58, 55, 54, 52, 50, 48, 46, 43, 42, 38, 37, 35, 32,
31, 27, 25, 23, 21, 19, 16, 13, 11, 9, 6, 4, 2, -2, -4, -7, -10, -12, -15, -17,
-20, -23, -25, -28, -31, -33, -35, -39, -41, -43, -45, -48, -50, -53, -55, -57,
-60, -63, -65, -67, -69, -72, -74, -77, -78, -80, -83, -85, -87, -89, -90, -92,
-94, -96, -97, -99, -100, -102, -104, -105, -106, -108, -109, -110, -111, -112,
-113, -114, -115, -116, -116, -118, -118, -118, -119, -120, -119, -120, -119,
-118, -119, -118, -118, -117, -116, -116, -115, -115, -113, -113, -113, -112,
-110, -109, -107, -106, -105, -104, -102, -101, -99, -98, -96, -95, -93, -91,
-88, -88, -85, -83, -80, -78, -76, -73, -72, -69, -67, -64, -62, -59, -57, -55,
-52, -49, -46, -44, -41, -38, -35, -33, -30, -27, -25, -21, -19, -16, -13, -9,
-6, -4, -1, };