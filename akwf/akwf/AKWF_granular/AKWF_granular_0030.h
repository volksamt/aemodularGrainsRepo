#define DATA_LENGTH 512
#define DATA AKWF_granular_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 7, 16, 25, 32, 33, 27, 23, 20, 21,
24, 26, 26, 25, 26, 27, 28, 30, 31, 35, 37, 41, 43, 45, 48, 51, 55, 59, 61, 67,
75, 83, 90, 92, 93, 94, 96, 98, 101, 103, 102, 101, 101, 100, 102, 99, 95, 92,
87, 87, 86, 85, 80, 77, 72, 69, 68, 70, 69, 65, 64, 60, 57, 55, 54, 54, 56, 57,
55, 50, 44, 37, 32, 27, 21, 14, 8, 5, 7, 9, 7, 4, -4, -10, -14, -19, -20, -24,
-30, -36, -42, -45, -48, -50, -47, -43, -43, -42, -44, -44, -46, -48, -51, -56,
-59, -63, -62, -62, -60, -61, -65, -68, -71, -71, -74, -75, -78, -81, -85, -90,
-97, -105, -109, -111, -112, -113, -115, -114, -114, -111, -111, -112, -112,
-113, -108, -101, -93, -84, -78, -72, -69, -69, -65, -64, -61, -55, -51, -47,
-39, -32, -26, -25, -22, -22, -23, -22, -20, -18, -18, -18, -16, -15, -13, -13,
-14, -13, -12, -6, 1, 5, 6, 8, 8, 12, 19, 22, 27, 32, 38, 44, 50, 55, 55, 55,
56, 60, 66, 69, 71, 72, 72, 75, 77, 79, 77, 71, 68, 70, 73, 75, 75, 73, 71, 73,
80, 85, 84, 81, 79, 81, 87, 95, 97, 96, 94, 94, 97, 97, 93, 85, 77, 74, 75, 77,
77, 73, 68, 66, 65, 63, 58, 52, 44, 40, 39, 36, 30, 24, 19, 15, 16, 19, 22, 25,
26, 27, 32, 34, 32, 28, 22, 18, 22, 26, 28, 25, 20, 16, 17, 16, 16, 13, 8, 1,
-3, -6, -13, -20, -30, -41, -49, -53, -56, -56, -58, -62, -64, -68, -70, -71,
-71, -70, -71, -75, -77, -74, -70, -68, -65, -65, -65, -64, -63, -59, -57, -58,
-59, -61, -61, -57, -54, -54, -55, -58, -60, -60, -57, -55, -54, -59, -64, -69,
-70, -66, -63, -62, -63, -63, -62, -56, -50, -45, -48, -52, -55, -54, -50, -43,
-37, -38, -39, -41, -41, -37, -29, -24, -25, -29, -31, -29, -24, -19, -17, -17,
-19, -16, -12, -5, 1, 6, 7, 10, 16, 22, 31, 40, 52, 63, 69, 74, 73, 73, 73, 75,
76, 76, 75, 77, 81, 87, 95, 95, 91, 86, 82, 79, 79, 78, 74, 69, 64, 62, 60, 58,
58, 62, 64, 70, 74, 75, 77, 78, 80, 81, 81, 83, 88, 93, 98, 101, 101, 101, 100,
100, 101, 101, 102, 101, 99, 96, 91, 84, 75, 69, 63, 57, 52, 47, 43, 37, 32, 29,
25, 23, 17, 15, 11, 7, 2, -5, -12, -13, -11, -10, -6, -8, -11, -13, -17, -19,
-27, -35, -43, -48, -47, -48, -47, -48, -53, -56, -59, -61, -62, -61, -62, -68,
-75, -82, -87, -87, -88, -88, -88, -88, -87, -83, -79, -79, -81, -87, -94, -97,
-97, -94, -94, -98, -103, -106, -108, -107, -105, -103, -105, -105, -106, -106,
-106, -109, -115, -118, -119, -117, -112, -108, -101, -94, -87, -81, -72, -68,
-64, -55, -44, -35, -29, -28, -31, -31, -25, -15, -7, -3, };