#define DATA_LENGTH 512
#define DATA AKWF_granular_0027

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 2, 7, 4, 2, 8, 8, 9, 15, 15, 12,
11, 13, 16, 19, 21, 21, 19, 20, 24, 22, 26, 30, 26, 24, 29, 29, 28, 38, 44, 37,
41, 48, 47, 47, 55, 58, 53, 54, 60, 63, 64, 69, 75, 71, 74, 78, 78, 82, 88, 81,
81, 93, 89, 86, 100, 103, 95, 99, 103, 100, 100, 103, 101, 100, 99, 101, 108,
107, 108, 113, 112, 111, 115, 116, 115, 116, 113, 110, 114, 112, 109, 109, 109,
106, 106, 109, 111, 108, 106, 109, 107, 104, 106, 107, 101, 98, 95, 89, 86, 85,
80, 77, 75, 69, 69, 69, 68, 68, 66, 61, 57, 55, 50, 49, 44, 39, 34, 28, 23, 23,
22, 16, 13, 10, 5, 3, 1, -3, -3, -8, -14, -17, -20, -25, -28, -33, -38, -43,
-47, -49, -52, -56, -58, -61, -63, -66, -67, -70, -73, -78, -80, -82, -85, -88,
-92, -94, -97, -99, -100, -101, -103, -105, -107, -109, -109, -110, -111, -113,
-115, -116, -116, -117, -117, -117, -117, -119, -119, -118, -117, -116, -115,
-114, -114, -113, -111, -109, -108, -106, -106, -104, -104, -101, -99, -95, -92,
-90, -89, -85, -81, -77, -75, -74, -72, -69, -66, -63, -60, -58, -56, -54, -51,
-47, -45, -43, -40, -37, -34, -31, -29, -26, -24, -23, -21, -19, -18, -17, -15,
-14, -13, -11, -11, -8, -6, -5, -3, -3, -1, 1, 1, 1, 2, 1, 1, 0, 0, -1, -1, -1,
-1, -2, -2, -2, -3, -4, -4, -5, -6, -6, -7, -8, -9, -11, -12, -14, -15, -16,
-17, -18, -19, -19, -20, -19, -19, -21, -22, -22, -21, -22, -23, -25, -26, -27,
-27, -27, -27, -28, -28, -29, -29, -29, -28, -28, -29, -28, -28, -28, -29, -27,
-26, -25, -25, -25, -24, -23, -23, -21, -20, -20, -21, -18, -17, -16, -15, -13,
-14, -13, -11, -12, -10, -9, -9, -9, -8, -7, -6, -6, -5, -4, -3, -3, -2, -2, -1,
0, 0, 0, 3, 3, 3, 4, 5, 5, 7, 7, 8, 9, 8, 9, 9, 10, 11, 12, 13, 12, 13, 13, 13,
16, 17, 16, 16, 17, 17, 17, 22, 21, 18, 19, 22, 22, 24, 26, 26, 23, 24, 24, 24,
27, 27, 25, 25, 25, 26, 28, 28, 26, 27, 26, 27, 27, 26, 25, 24, 24, 23, 22, 24,
22, 20, 21, 20, 20, 20, 20, 17, 16, 15, 15, 13, 11, 10, 9, 5, 5, 6, 4, 2, 0, -1,
-1, -1, -1, -3, -3, -4, -5, -6, -8, -7, -10, -13, -14, -14, -17, -19, -18, -17,
-18, -17, -17, -17, -17, -16, -17, -17, -16, -17, -19, -18, -17, -20, -19, -19,
-21, -22, -19, -18, -19, -17, -15, -15, -15, -14, -13, -13, -15, -13, -12, -13,
-13, -12, -14, -13, -11, -11, -10, -8, -9, -10, -8, -6, -5, -5, -4, -6, -8, -5,
-3, -5, -5, -5, -5, -6, -5, -4, -4, -5, -6, -7, -6, -3, -7, -10, -6, -4, -6, -4,
-2, -6, -4, };