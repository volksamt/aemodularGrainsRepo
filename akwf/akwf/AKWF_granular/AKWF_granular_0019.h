#define DATA_LENGTH 512
#define DATA AKWF_granular_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 0, 1, 1, 2, 2, 3, 3, 3, 5, 6,
6, 6, 8, 8, 9, 11, 11, 13, 13, 15, 16, 17, 18, 19, 20, 21, 22, 24, 25, 26, 27,
28, 30, 31, 32, 33, 34, 36, 36, 38, 41, 40, 42, 42, 45, 46, 47, 48, 49, 50, 52,
53, 54, 56, 57, 58, 59, 60, 61, 62, 64, 64, 65, 67, 67, 69, 70, 71, 72, 73, 75,
75, 75, 77, 78, 78, 79, 80, 81, 82, 83, 84, 85, 85, 87, 88, 89, 89, 90, 90, 92,
92, 93, 93, 95, 94, 96, 95, 97, 97, 99, 97, 99, 99, 99, 101, 101, 102, 102, 104,
102, 106, 102, 107, 20, -63, -95, -104, -73, -86, -100, -97, -96, -114, -115,
-113, -115, -116, -109, -102, -99, -93, -88, -87, -88, -88, -92, -96, -101,
-104, -107, -109, -108, -107, -105, -101, -99, -96, -95, -96, -96, -99, -101,
-105, -108, -111, -112, -114, -113, -113, -112, -110, -108, -108, -107, -108,
-109, -111, -114, -115, -117, -119, -118, -119, -118, -117, -116, -114, -113,
-113, -112, -113, -112, -113, -114, -114, -114, -114, -113, -111, -111, -108,
-106, -104, -101, -100, -98, -96, -95, -93, -92, -90, -88, -86, -84, -80, -78,
-75, -71, -67, -64, -60, -57, -54, -50, -47, -45, -41, -38, -34, -29, -26, -21,
-17, -13, -9, -5, 0, 3, 7, 11, 13, 18, 21, 25, 28, 32, 36, 40, 43, 46, 49, 53,
56, 59, 62, 65, 66, 69, 72, 73, 76, 79, 81, 83, 85, 87, 90, 92, 92, 93, 93, 94,
94, 95, 95, 95, 97, 96, 96, 97, 97, 96, 96, 96, 96, 96, 95, 95, 94, 94, 94, 93,
92, 92, 91, 91, 91, 89, 89, 88, 87, 86, 86, 84, 83, 83, 81, 80, 80, 79, 78, 77,
75, 75, 73, 72, 71, 71, 70, 69, 67, 66, 65, 64, 63, 62, 61, 59, 58, 57, 56, 55,
54, 53, 52, 51, 50, 48, 48, 46, 45, 44, 43, 42, 41, 40, 38, 38, 37, 35, 34, 34,
31, 33, 11, -16, -26, -29, -19, -19, -22, -22, -21, -23, -24, -23, -22, -20,
-19, -17, -15, -13, -12, -10, -10, -9, -9, -9, -9, -8, -8, -7, -6, -6, -4, -3,
-2, -2, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, -1, 0, -1, 1, 0, -1, 0, -1,
0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0,
0, -1, 0, -1, 0, 0, 1, 0, 0, 0, -1, 1, 0, 0, 0, 0, -1, 0, 0, 0, 1, 1, 0, 0, 0,
0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, -1, 0, -1, -1, -1, -1,
0, 0, 0, -1, -1, 0, };