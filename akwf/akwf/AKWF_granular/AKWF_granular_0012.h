#define DATA_LENGTH 512
#define DATA AKWF_granular_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 15, 22, 27, 33, 39, 44, 50, 57,
62, 66, 72, 78, 83, 87, 93, 97, 100, 105, 108, 111, 114, 116, 118, 118, 120,
118, 119, 119, 118, 116, 115, 113, 110, 108, 105, 102, 98, 95, 91, 87, 82, 77,
72, 68, 62, 57, 50, 44, 39, 34, 28, 21, 16, 10, 5, -1, -6, -11, -17, -22, -27,
-32, -37, -41, -45, -50, -53, -57, -59, -62, -65, -68, -70, -72, -74, -75, -76,
-77, -76, -76, -77, -76, -75, -74, -72, -71, -67, -68, -83, -97, -100, -95, -91,
-91, -90, -88, -89, -90, -90, -90, -89, -89, -87, -85, -84, -82, -80, -78, -75,
-72, -69, -65, -61, -57, -53, -48, -44, -38, -34, -28, -22, -16, -11, -3, 2, 8,
14, 21, 27, 33, 40, 46, 52, 57, 64, 68, 74, 80, 84, 90, 94, 98, 102, 105, 108,
110, 112, 115, 117, 117, 118, 120, 119, 120, 118, 117, 116, 114, 112, 109, 106,
104, 100, 97, 93, 89, 84, 80, 74, 69, 64, 59, 53, 48, 43, 36, 31, 26, 19, 14, 8,
2, -4, -9, -15, -20, -24, -30, -34, -39, -44, -48, -52, -55, -58, -61, -64, -67,
-68, -71, -73, -74, -75, -76, -76, -77, -77, -76, -75, -74, -73, -71, -70, -68,
-71, -92, -98, -99, -93, -90, -88, -87, -87, -86, -87, -86, -85, -83, -82, -80,
-78, -75, -74, -70, -68, -65, -61, -58, -54, -51, -47, -44, -38, -35, -30, -25,
-21, -16, -11, -6, -2, 4, 9, 13, 18, 23, 27, 32, 35, 39, 43, 47, 51, 53, 56, 59,
61, 63, 66, 67, 68, 70, 70, 72, 71, 71, 72, 71, 71, 70, 68, 68, 66, 64, 63, 61,
59, 56, 53, 51, 49, 46, 44, 41, 38, 35, 32, 29, 26, 24, 21, 18, 16, 13, 10, 6,
5, 2, 0, -3, -4, -7, -9, -10, -11, -13, -13, -15, -16, -17, -18, -18, -19, -19,
-20, -19, -19, -20, -20, -20, -19, -19, -17, -17, -16, -16, -16, -14, -14, -12,
-11, -15, -17, -16, -15, -13, -13, -12, -11, -10, -11, -10, -9, -8, -8, -6, -6,
-6, -4, -4, -3, -3, -3, -2, -2, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, -1, 0, 0,
0, 1, 0, 0, 1, 1, 1, 1, 1, 2, 2, 4, 3, 5, 5, 7, 7, 9, 9, 10, 12, 13, 13, 16, 16,
18, 18, 20, 20, 20, 22, 24, 24, 24, 25, 26, 26, 25, 27, 26, 26, 26, 26, 25, 25,
25, 23, 21, 21, 19, 19, 17, 16, 14, 12, 11, 9, 7, 4, 3, 0, -1, -4, -6, -9, -11,
-14, -15, -18, -20, -23, -24, -26, -28, -30, -32, -33, -35, -37, -38, -39, -40,
-41, -42, -42, -42, -43, -43, -43, -42, -41, -42, -39, -48, -59, -61, -61, -59,
-58, -58, -58, -59, -60, -60, -61, -62, -62, -62, -61, -60, -59, -59, -58, -57,
-55, -52, -50, -48, -45, -42, -40, -35, -32, -28, -24, -20, -15, -11, -5, 0, };