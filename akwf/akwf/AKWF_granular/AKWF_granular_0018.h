#define DATA_LENGTH 512
#define DATA AKWF_granular_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 12, 15, 17, 21, 25, 28, 30,
33, 37, 39, 42, 46, 48, 52, 54, 56, 59, 62, 63, 66, 68, 71, 72, 74, 76, 78, 80,
82, 83, 85, 87, 89, 90, 92, 92, 93, 93, 94, 95, 95, 96, 96, 95, 96, 96, 96, 97,
96, 97, 96, 97, 96, 96, 95, 96, 95, 95, 95, 93, 94, 93, 92, 92, 92, 91, 90, 90,
90, 89, 88, 89, 87, 87, 85, 85, 84, 84, 83, 81, 81, 80, 79, 79, 78, 77, 76, 76,
74, 74, 73, 72, 71, 69, 69, 67, 67, 66, 65, 64, 64, 63, 61, 60, 59, 59, 58, 56,
57, 56, 55, 53, 52, 51, 50, 49, 49, 47, 47, 45, 46, 44, 43, 41, 41, 40, 39, 38,
37, 37, 35, 35, 33, 33, 30, 33, 1, -21, -23, -30, -21, -19, -21, -24, -21, -20,
-23, -24, -23, -21, -22, -20, -19, -16, -15, -14, -13, -12, -11, -10, -10, -9,
-10, -9, -9, -8, -9, -7, -7, -6, -4, -4, -4, -2, -1, 0, 0, 0, 0, -1, 0, 0, 1, 1,
0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0,
0, 0, 1, 0, 0, -1, 0, 1, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, -1, 0, 0,
0, 1, 0, 1, 0, 0, 1, 0, 1, 2, 1, 2, 2, 3, 4, 4, 5, 6, 6, 6, 8, 8, 9, 10, 11, 12,
12, 13, 14, 15, 15, 17, 18, 18, 20, 21, 22, 23, 23, 25, 26, 26, 28, 30, 30, 31,
32, 33, 33, 35, 36, 37, 39, 40, 41, 42, 43, 44, 45, 46, 47, 47, 49, 50, 51, 52,
53, 54, 55, 56, 57, 57, 59, 60, 61, 62, 63, 64, 64, 66, 66, 67, 68, 69, 70, 71,
73, 73, 73, 75, 75, 76, 77, 77, 78, 79, 79, 81, 82, 83, 83, 84, 84, 85, 85, 87,
88, 87, 88, 89, 90, 90, 91, 92, 93, 93, 94, 94, 95, 95, 95, 96, 97, 97, 98, 99,
99, 99, 99, 101, 101, 102, 100, 103, 103, 103, 100, 104, 106, 110, 33, -65, -88,
-110, -90, -73, -86, -99, -98, -93, -106, -114, -115, -112, -116, -117, -112,
-105, -102, -98, -93, -87, -87, -87, -87, -88, -93, -97, -100, -104, -106, -108,
-109, -108, -108, -106, -104, -101, -98, -97, -95, -95, -96, -97, -99, -103,
-105, -108, -110, -112, -112, -114, -114, -112, -111, -109, -109, -108, -107,
-107, -108, -109, -110, -112, -113, -115, -116, -118, -119, -118, -119, -118,
-117, -116, -115, -114, -113, -112, -112, -112, -113, -113, -114, -114, -114,
-114, -113, -113, -112, -111, -109, -108, -105, -103, -102, -100, -98, -97, -96,
-95, -94, -92, -91, -89, -88, -86, -84, -80, -78, -75, -72, -70, -66, -63, -61,
-57, -55, -52, -50, -47, -45, -41, -38, -35, -31, -28, -24, -21, -18, -14, -11,
-6, -4, -1, };