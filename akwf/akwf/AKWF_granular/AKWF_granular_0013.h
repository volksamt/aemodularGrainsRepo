#define DATA_LENGTH 512
#define DATA AKWF_granular_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 8, 10, 14, 16, 18, 20, 23,
26, 28, 30, 33, 36, 38, 40, 42, 44, 47, 48, 51, 53, 54, 55, 56, 57, 58, 60, 61,
62, 61, 66, 72, 75, 75, 75, 75, 74, 75, 74, 74, 75, 76, 75, 75, 74, 73, 72, 71,
70, 67, 66, 64, 61, 60, 56, 54, 51, 48, 44, 42, 38, 34, 30, 25, 22, 18, 12, 8,
4, -1, -5, -10, -15, -20, -25, -30, -35, -39, -45, -49, -54, -58, -62, -67, -70,
-75, -79, -83, -86, -89, -92, -95, -97, -99, -101, -102, -104, -104, -103, -104,
-104, -104, -102, -102, -109, -116, -118, -116, -114, -112, -110, -108, -106,
-105, -103, -102, -100, -98, -96, -92, -90, -87, -83, -81, -76, -73, -69, -64,
-60, -56, -52, -47, -42, -37, -32, -28, -23, -17, -12, -6, -1, 4, 10, 15, 20,
24, 29, 34, 39, 45, 48, 53, 57, 62, 66, 69, 74, 77, 80, 84, 86, 89, 91, 93, 95,
97, 98, 98, 100, 100, 100, 100, 100, 109, 116, 119, 119, 116, 115, 114, 113,
111, 110, 109, 109, 107, 107, 105, 102, 100, 97, 94, 91, 88, 84, 82, 78, 73, 70,
64, 60, 55, 50, 46, 41, 36, 30, 25, 20, 14, 9, 3, -3, -8, -14, -19, -25, -30,
-35, -40, -45, -51, -55, -60, -64, -69, -72, -76, -80, -83, -87, -89, -92, -94,
-96, -98, -101, -102, -103, -103, -104, -104, -104, -104, -103, -102, -103,
-113, -117, -118, -117, -113, -112, -109, -108, -106, -105, -103, -102, -100,
-96, -94, -92, -90, -86, -82, -80, -76, -72, -67, -64, -59, -54, -51, -46, -41,
-36, -31, -26, -21, -16, -11, -6, -1, 5, 10, 16, 21, 26, 31, 35, 41, 45, 50, 55,
59, 63, 67, 71, 75, 79, 81, 85, 86, 90, 91, 94, 95, 97, 98, 99, 100, 100, 100,
100, 102, 112, 117, 119, 117, 113, 111, 111, 109, 107, 105, 104, 102, 100, 98,
97, 93, 91, 87, 84, 80, 77, 73, 71, 66, 62, 59, 54, 49, 46, 41, 36, 33, 28, 23,
19, 14, 10, 6, 1, -3, -7, -11, -16, -19, -23, -27, -31, -34, -38, -40, -44, -47,
-48, -52, -53, -55, -57, -58, -60, -62, -62, -63, -63, -64, -64, -64, -64, -64,
-62, -63, -61, -60, -59, -61, -64, -66, -65, -62, -61, -60, -58, -56, -55, -53,
-52, -51, -49, -47, -46, -44, -42, -40, -37, -36, -33, -31, -29, -27, -25, -23,
-21, -18, -15, -13, -11, -10, -7, -5, -3, -2, 0, 2, 4, 6, 7, 9, 11, 11, 13, 15,
15, 17, 16, 19, 18, 19, 20, 18, 19, 18, 19, 18, 18, 17, 15, 15, 14, 12, 11, 10,
9, 8, 6, 5, 5, 4, 1, 0, -2, -3, -5, -6, -7, -9, -10, -11, -12, -16, -19, -20,
-22, -22, -23, -24, -24, -26, -26, -27, -28, -29, -29, -28, -28, -28, -27, -26,
-26, -25, -25, -24, -22, -21, -21, -18, -18, -16, -14, -13, -11, -9, -8, -5, -3,
0, };