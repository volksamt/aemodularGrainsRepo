#define DATA_LENGTH 512
#define DATA AKWF_granular_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 7, 9, 10, 12, 14, 16, 17, 19,
21, 22, 23, 24, 26, 27, 29, 29, 31, 32, 34, 34, 36, 36, 39, 38, 40, 40, 42, 42,
43, 44, 45, 47, 47, 48, 49, 49, 50, 50, 51, 52, 53, 54, 53, 55, 54, 57, 56, 58,
57, 58, 57, 58, 58, 59, 59, 59, 61, 61, 61, 61, 60, 61, 60, 62, 60, 61, 64, 54,
78, -48, -115, -75, -92, -72, -77, -67, -67, -61, -59, -55, -51, -50, -45, -44,
-40, -38, -34, -33, -31, -28, -25, -23, -20, -18, -16, -15, -11, -11, -8, -7,
-3, -3, 0, 1, 2, 4, 5, 8, 8, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23,
24, 25, 24, 25, 25, 26, 26, 27, 27, 28, 28, 29, 29, 29, 29, 29, 29, 30, 29, 29,
29, 29, 28, 29, 28, 27, 25, 22, 21, 18, 18, 16, 15, 13, 13, 12, 11, 9, 8, 7, 7,
6, 6, 4, 4, 3, 3, 3, 3, 2, 2, 1, 1, 1, 0, -1, 0, -1, -1, 0, -1, -1, 0, -1, -1,
-1, -1, 0, -1, 0, 0, 0, 0, 1, 1, 1, 1, 1, 3, 2, 3, 3, 4, 4, 4, 5, 6, 5, 6, 6, 8,
8, 9, 8, 10, 10, 10, 11, 11, 11, 13, 13, 12, 15, 13, 15, 15, 16, 16, 17, 18, 16,
26, -23, -49, -38, -42, -37, -38, -35, -34, -32, -31, -29, -29, -27, -26, -24,
-24, -23, -21, -19, -19, -17, -17, -16, -15, -12, -12, -11, -9, -8, -8, -6, -5,
-3, -3, -1, 0, 1, 2, 4, 4, 5, 6, 7, 8, 9, 11, 12, 12, 13, 15, 15, 17, 18, 17,
19, 19, 20, 21, 21, 23, 23, 24, 24, 26, 26, 26, 27, 26, 27, 29, 29, 29, 30, 29,
30, 30, 31, 31, 31, 27, 25, 23, 22, 21, 20, 18, 18, 16, 15, 14, 13, 12, 11, 10,
8, 8, 7, 6, 5, 4, 4, 2, 1, 0, 0, -1, -3, -2, -4, -5, -5, -6, -6, -7, -8, -8,
-10, -9, -10, -11, -12, -12, -12, -13, -14, -14, -14, -15, -15, -16, -16, -17,
-17, -17, -18, -18, -19, -19, -19, -20, -20, -20, -20, -21, -21, -20, -21, -21,
-21, -22, -21, -22, -21, -22, -22, -21, -21, -21, -22, -21, -22, -21, -21, -21,
-21, -22, -22, -21, -22, -21, -22, -21, -21, -21, -21, -21, -22, -21, -22, -21,
-21, -22, -22, -21, -22, -21, -22, -21, -22, -22, -21, -21, -22, -22, -21, -21,
-21, -22, -21, -22, -21, -21, -22, -21, -22, -21, -22, -21, -21, -21, -21, -21,
-21, -21, -21, -22, -21, -21, -21, -22, -22, -21, -21, -21, -22, -21, -22, -22,
-21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -22, -20, -22, -21, -21,
-21, -21, -21, -21, -21, -21, -21, -21, -21, -22, -21, -21, -22, -22, -21, -22,
-21, -22, -21, -21, -21, -21, -21, -22, -18, -13, -9, -6, -4, -1, };