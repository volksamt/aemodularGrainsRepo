#define DATA_LENGTH 512
#define DATA AKWF_0297

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 4, 5, 6, 7, 7, 8, 9, 10, 10,
11, 11, 12, 13, 13, 13, 15, 15, 14, 16, 16, 17, 17, 18, 21, 25, 27, 30, 30, 31,
32, 33, 34, 36, 37, 38, 39, 40, 42, 42, 43, 45, 46, 45, 46, 48, 47, 48, 49, 48,
49, 49, 49, 50, 50, 50, 50, 50, 51, 50, 51, 50, 50, 51, 50, 50, 50, 51, 51, 51,
50, 51, 50, 50, 50, 51, 50, 51, 53, 56, 60, 62, 64, 66, 66, 68, 69, 71, 72, 73,
74, 77, 78, 78, 80, 81, 81, 82, 83, 84, 85, 85, 85, 87, 87, 87, 87, 88, 87, 87,
88, 88, 88, 88, 88, 88, 88, 88, 89, 89, 88, 88, 88, 88, 87, 87, 87, 87, 88, 88,
88, 88, 87, 86, 88, 92, 96, 98, 100, 101, 103, 107, 109, 109, 111, 112, 115,
116, 116, 118, 117, 118, 118, 118, 118, 119, 119, 119, 119, 119, 119, 119, 119,
118, 118, 118, 118, 118, 117, 117, 117, 116, 117, 115, 116, 115, 118, 118, 119,
119, 120, 119, 119, 119, 119, 118, 119, 119, 120, 119, 120, 119, 119, 118, 118,
118, 117, 117, 117, 116, 116, 115, 115, 114, 114, 114, 114, 112, 112, 111, 112,
110, 111, 109, 109, 108, 108, 108, 106, 106, 106, 105, 103, 102, 100, 98, 96,
94, 92, 90, 90, 90, 90, 90, 88, 87, 86, 85, 83, 82, 82, 81, 80, 78, 78, 77, 76,
75, 74, 72, 72, 70, 69, 68, 67, 67, 65, 64, 63, 62, 61, 60, 59, 57, 56, 55, 54,
53, 52, 50, 50, 48, 47, 45, 45, 44, 42, 41, 40, 40, 39, 37, 36, 36, 34, 33, 32,
30, 2, -23, -30, -36, -38, -41, -43, -44, -47, -50, -53, -56, -59, -63, -66,
-67, -71, -73, -74, -77, -78, -79, -81, -82, -83, -84, -85, -85, -86, -88, -87,
-87, -87, -88, -89, -88, -88, -87, -88, -88, -88, -87, -87, -87, -86, -85, -85,
-85, -84, -84, -83, -83, -82, -82, -81, -81, -80, -79, -79, -78, -77, -76, -76,
-75, -75, -74, -73, -73, -73, -71, -71, -70, -69, -68, -68, -68, -67, -66, -66,
-65, -64, -64, -64, -63, -63, -62, -61, -61, -62, -62, -62, -62, -63, -63, -63,
-63, -62, -63, -62, -63, -63, -63, -64, -64, -64, -63, -64, -64, -64, -65, -64,
-65, -65, -65, -65, -65, -64, -65, -65, -65, -65, -65, -65, -66, -66, -65, -66,
-65, -66, -67, -67, -66, -66, -66, -67, -67, -67, -67, -66, -66, -66, -65, -66,
-65, -66, -66, -65, -65, -65, -63, -61, -63, -78, -87, -89, -90, -89, -90, -89,
-89, -88, -89, -90, -91, -90, -90, -91, -92, -91, -91, -91, -91, -91, -91, -90,
-90, -89, -89, -89, -87, -88, -86, -86, -85, -84, -83, -83, -81, -81, -79, -79,
-78, -77, -75, -75, -74, -73, -72, -71, -70, -68, -67, -67, -65, -63, -63, -58,
-51, -41, -35, -31, -28, -25, -23, -20, -17, -12, -9, -6, -3, -1, 0, };