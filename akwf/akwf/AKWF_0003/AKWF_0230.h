#define DATA_LENGTH 512
#define DATA AKWF_0230

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 7, 9, 12, 15, 17, 20, 23, 26,
29, 31, 34, 36, 39, 41, 44, 45, 48, 50, 52, 55, 57, 59, 61, 64, 64, 66, 69, 71,
72, 74, 76, 78, 79, 81, 82, 84, 85, 87, 88, 89, 90, 92, 93, 95, 94, 96, 97, 98,
99, 100, 100, 101, 102, 103, 104, 104, 106, 106, 107, 108, 107, 108, 108, 109,
110, 110, 109, 110, 111, 111, 111, 111, 111, 111, 111, 110, 111, 111, 110, 111,
110, 110, 110, 109, 109, 108, 109, 108, 107, 107, 108, 106, 106, 106, 105, 105,
104, 103, 103, 102, 100, 101, 99, 99, 98, 98, 97, 96, 96, 95, 94, 93, 92, 92,
91, 90, 89, 87, 86, 85, 85, 84, 83, 82, 81, 79, 79, 77, 77, 76, 75, 75, 72, 72,
70, 69, 69, 68, 67, 65, 65, 64, 63, 62, 60, 60, 59, 58, 57, 55, 54, 53, 53, 51,
51, 50, 49, 47, 47, 46, 46, 45, 44, 43, 41, 41, 40, 39, 38, 38, 36, 36, 36, 34,
33, 33, 31, 32, 30, 30, 29, 28, 27, 27, 26, 25, 25, 24, 23, 23, 23, 22, 22, 21,
20, 19, 19, 18, 18, 17, 16, 17, 15, 16, 15, 15, 15, 14, 14, 13, 13, 13, 12, 11,
11, 11, 11, 10, 10, 10, 9, 9, 9, 9, 8, 9, 8, 8, 8, 8, 7, 7, 7, 7, 6, 6, 7, 6, 6,
7, 6, 5, 5, 5, 6, 5, 4, 5, 4, 4, 4, 4, 4, 5, 3, 4, 3, 3, 3, 2, 3, 3, 3, 3, 2, 3,
2, 2, 2, 2, 2, 1, 1, 1, 1, 1, 1, 0, 1, 0, -1, -1, -1, -1, -1, -1, -3, -2, -2,
-2, -3, -3, -3, -4, -4, -5, -5, -5, -6, -6, -7, -7, -7, -9, -9, -9, -9, -9, -9,
-11, -11, -12, -13, -13, -14, -14, -15, -15, -16, -17, -17, -18, -19, -20, -21,
-21, -22, -22, -23, -24, -25, -26, -26, -27, -28, -29, -29, -30, -31, -33, -33,
-34, -36, -36, -37, -38, -39, -39, -41, -42, -43, -44, -45, -46, -47, -49, -50,
-50, -51, -53, -54, -54, -56, -58, -58, -60, -61, -62, -62, -64, -65, -66, -67,
-68, -69, -71, -71, -73, -74, -75, -76, -76, -79, -79, -80, -82, -83, -84, -85,
-86, -87, -88, -90, -90, -91, -93, -93, -95, -96, -97, -97, -99, -99, -100,
-101, -102, -102, -104, -104, -105, -106, -106, -107, -109, -109, -110, -111,
-111, -112, -113, -113, -114, -114, -115, -115, -116, -116, -116, -117, -117,
-118, -118, -118, -119, -118, -118, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -117, -118, -118, -117, -116, -116, -116, -115, -114,
-114, -113, -113, -112, -110, -110, -109, -109, -107, -106, -104, -103, -101,
-100, -99, -97, -96, -95, -92, -91, -90, -87, -86, -84, -81, -79, -77, -75, -73,
-70, -68, -64, -63, -60, -58, -54, -51, -49, -46, -43, -41, -38, -34, -32, -28,
-25, -22, -18, -17, -13, -11, -7, -4, -2, };