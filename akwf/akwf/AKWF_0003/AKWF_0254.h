#define DATA_LENGTH 512
#define DATA AKWF_0254

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 7, 10, 13, 15, 18, 20, 23, 25,
29, 31, 34, 36, 38, 41, 43, 44, 47, 48, 51, 53, 55, 57, 58, 61, 62, 64, 65, 68,
69, 70, 72, 74, 74, 76, 77, 78, 79, 80, 81, 82, 83, 83, 84, 84, 85, 86, 85, 86,
86, 87, 86, 86, 86, 86, 85, 85, 84, 84, 83, 84, 82, 82, 82, 81, 80, 80, 79, 79,
78, 77, 76, 76, 75, 75, 74, 74, 72, 72, 71, 72, 71, 70, 69, 70, 69, 68, 69, 68,
68, 67, 68, 68, 67, 67, 68, 68, 68, 68, 68, 69, 68, 69, 69, 70, 69, 70, 70, 69,
70, 70, 69, 69, 70, 69, 70, 69, 69, 69, 68, 68, 67, 67, 66, 66, 65, 64, 64, 63,
62, 62, 60, 59, 58, 57, 55, 54, 53, 51, 50, 48, 46, 45, 42, 41, 39, 36, 35, 33,
31, 29, 26, 23, 22, 20, 17, 16, 14, 12, 9, 7, 5, 3, 0, -2, -4, -6, -9, -11, -14,
-16, -18, -20, -22, -25, -27, -29, -31, -33, -35, -38, -40, -42, -44, -46, -49,
-51, -54, -56, -57, -59, -60, -63, -64, -67, -67, -70, -71, -72, -74, -75, -76,
-76, -77, -79, -78, -79, -80, -80, -80, -79, -79, -79, -79, -77, -77, -75, -74,
-73, -72, -70, -69, -67, -64, -62, -61, -58, -56, -52, -49, -47, -44, -41, -38,
-35, -32, -29, -26, -22, -19, -17, -13, -11, -6, -4, 0, 3, 6, 9, 13, 15, 19, 22,
25, 27, 30, 34, 36, 38, 41, 43, 45, 48, 51, 53, 54, 57, 59, 61, 63, 65, 67, 68,
70, 71, 73, 75, 76, 77, 79, 80, 81, 82, 83, 84, 86, 86, 86, 87, 88, 88, 89, 89,
89, 90, 88, 89, 89, 89, 88, 87, 88, 85, 86, 84, 83, 82, 81, 79, 79, 76, 75, 73,
70, 69, 67, 65, 63, 60, 57, 55, 52, 50, 47, 44, 42, 39, 37, 34, 31, 28, 25, 23,
19, 17, 14, 11, 9, 7, 4, 2, 0, -2, -5, -7, -9, -11, -13, -15, -16, -17, -19,
-21, -22, -22, -24, -26, -26, -27, -28, -29, -29, -30, -31, -33, -32, -32, -34,
-35, -35, -36, -36, -37, -37, -37, -38, -39, -39, -40, -40, -40, -42, -42, -43,
-43, -44, -44, -45, -46, -45, -46, -47, -49, -49, -51, -51, -52, -53, -54, -55,
-56, -58, -58, -60, -61, -62, -63, -65, -66, -66, -69, -69, -70, -72, -73, -74,
-75, -76, -78, -78, -80, -81, -82, -82, -84, -85, -86, -87, -88, -90, -91, -93,
-92, -94, -95, -96, -98, -100, -101, -101, -102, -103, -105, -106, -108, -109,
-110, -111, -112, -112, -114, -114, -116, -116, -117, -117, -118, -118, -119,
-119, -119, -119, -119, -119, -118, -117, -117, -118, -116, -115, -114, -113,
-112, -111, -109, -107, -105, -103, -101, -98, -97, -94, -91, -90, -86, -83,
-81, -77, -75, -71, -68, -65, -62, -58, -55, -52, -48, -45, -41, -37, -35, -31,
-27, -24, -21, -18, -14, -11, -8, -5, -1, };