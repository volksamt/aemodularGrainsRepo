#define DATA_LENGTH 512
#define DATA AKWF_0273

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 13, 18, 23, 27, 32, 36, 41, 45,
49, 53, 56, 60, 63, 67, 71, 74, 77, 80, 83, 85, 87, 89, 92, 93, 96, 98, 99, 100,
101, 102, 103, 103, 104, 104, 104, 104, 103, 103, 103, 102, 100, 99, 97, 95, 92,
91, 89, 85, 83, 80, 77, 74, 71, 66, 63, 59, 55, 52, 47, 42, 38, 33, 30, 25, 21,
17, 12, 8, 4, -1, -4, -9, -12, -16, -20, -24, -27, -29, -32, -36, -38, -42, -44,
-46, -49, -51, -53, -55, -57, -58, -60, -60, -61, -62, -62, -62, -62, -61, -61,
-60, -60, -58, -57, -55, -54, -51, -49, -47, -44, -41, -38, -35, -31, -28, -24,
-21, -17, -12, -8, -5, 0, 4, 10, 14, 19, 23, 27, 31, 36, 40, 44, 47, 51, 54, 58,
61, 64, 66, 68, 71, 74, 74, 77, 78, 78, 79, 79, 80, 80, 79, 78, 78, 78, 76, 75,
75, 72, 71, 69, 67, 65, 63, 60, 58, 55, 52, 49, 45, 43, 39, 35, 32, 28, 24, 20,
17, 12, 9, 4, 0, -4, -10, -13, -17, -22, -25, -30, -35, -39, -43, -47, -51, -56,
-60, -63, -67, -70, -74, -77, -82, -84, -88, -91, -94, -96, -99, -102, -105,
-106, -109, -110, -112, -114, -115, -115, -117, -118, -119, -119, -119, -119,
-119, -118, -117, -116, -117, -116, -114, -112, -111, -109, -107, -104, -102,
-100, -97, -94, -91, -88, -84, -82, -78, -73, -69, -66, -62, -57, -54, -49, -44,
-40, -37, -32, -27, -22, -18, -14, -10, -4, 0, 4, 8, 12, 17, 21, 24, 29, 33, 36,
40, 43, 47, 51, 55, 58, 62, 65, 68, 70, 73, 76, 79, 81, 82, 86, 87, 89, 90, 92,
92, 94, 95, 95, 96, 96, 96, 97, 95, 95, 95, 93, 92, 91, 90, 88, 86, 84, 82, 80,
76, 75, 72, 69, 67, 64, 61, 57, 55, 50, 47, 45, 40, 37, 33, 30, 27, 23, 19, 15,
11, 7, 4, 1, -3, -7, -11, -14, -17, -21, -24, -27, -30, -33, -35, -37, -40, -41,
-43, -45, -45, -46, -47, -47, -47, -47, -47, -45, -44, -43, -41, -40, -38, -36,
-34, -32, -28, -26, -23, -19, -16, -13, -9, -6, -3, 0, 4, 8, 11, 15, 18, 22, 26,
29, 31, 35, 39, 41, 45, 47, 50, 53, 55, 58, 59, 62, 64, 65, 66, 68, 68, 70, 70,
72, 72, 73, 73, 73, 72, 72, 71, 70, 69, 68, 67, 65, 64, 61, 59, 58, 55, 52, 50,
46, 43, 39, 36, 32, 29, 24, 21, 16, 11, 7, 3, -1, -7, -12, -16, -21, -26, -30,
-35, -39, -45, -48, -53, -58, -61, -65, -69, -74, -77, -81, -84, -86, -90, -93,
-95, -98, -100, -103, -105, -107, -109, -111, -111, -113, -114, -116, -116,
-117, -118, -118, -117, -118, -118, -116, -117, -115, -114, -112, -110, -108,
-107, -104, -102, -100, -97, -93, -90, -87, -83, -80, -76, -71, -67, -62, -59,
-53, -50, -44, -40, -35, -31, -26, -21, -16, -11, -6, -1, };