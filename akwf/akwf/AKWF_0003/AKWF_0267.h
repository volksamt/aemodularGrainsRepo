#define DATA_LENGTH 512
#define DATA AKWF_0267

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 12, 18, 27, 32, 38, 45, 51, 57, 62,
68, 75, 79, 85, 89, 95, 98, 101, 105, 107, 109, 110, 112, 112, 112, 113, 113,
113, 114, 114, 114, 112, 112, 110, 108, 105, 104, 100, 98, 95, 94, 90, 89, 87,
84, 83, 80, 78, 74, 71, 67, 63, 58, 54, 48, 43, 39, 34, 31, 26, 23, 20, 18, 14,
13, 11, 8, 6, 4, 1, -1, -3, -6, -7, -9, -11, -12, -14, -16, -18, -20, -21, -22,
-24, -25, -26, -26, -26, -27, -27, -27, -27, -28, -28, -28, -29, -30, -31, -32,
-32, -34, -35, -36, -38, -40, -41, -42, -44, -46, -47, -47, -49, -50, -52, -53,
-55, -56, -56, -59, -60, -62, -63, -65, -65, -67, -69, -70, -71, -73, -73, -74,
-75, -76, -77, -79, -79, -80, -80, -80, -79, -79, -79, -77, -77, -76, -75, -74,
-72, -72, -70, -68, -66, -64, -62, -60, -58, -54, -52, -50, -47, -43, -40, -37,
-33, -30, -25, -21, -15, -11, -6, 0, 6, 12, 19, 26, 31, 39, 46, 52, 58, 65, 71,
76, 81, 86, 91, 95, 98, 101, 105, 107, 108, 110, 111, 111, 111, 110, 109, 107,
105, 102, 99, 95, 91, 86, 81, 75, 69, 63, 56, 49, 42, 35, 27, 20, 11, 4, -3,
-10, -16, -22, -29, -35, -40, -46, -50, -55, -57, -61, -63, -65, -67, -69, -70,
-69, -69, -69, -66, -65, -63, -59, -57, -52, -48, -43, -39, -34, -29, -24, -19,
-14, -9, -4, 0, 5, 10, 14, 19, 23, 26, 29, 33, 35, 36, 37, 37, 36, 36, 34, 33,
31, 29, 27, 24, 20, 16, 12, 7, 3, -2, -8, -13, -19, -23, -28, -34, -39, -43,
-46, -51, -54, -57, -61, -63, -65, -67, -68, -68, -69, -68, -65, -64, -61, -57,
-53, -48, -42, -36, -30, -24, -19, -12, -7, -2, 2, 7, 11, 15, 19, 22, 24, 27,
29, 31, 33, 35, 36, 37, 38, 38, 38, 37, 37, 37, 35, 34, 32, 32, 29, 27, 24, 21,
18, 15, 12, 9, 6, 3, 1, 0, -2, -3, -5, -4, -4, -5, -4, -4, -3, -2, 0, 0, 3, 4,
8, 10, 12, 14, 17, 20, 24, 26, 30, 32, 35, 39, 42, 44, 47, 49, 51, 54, 56, 58,
60, 61, 62, 63, 62, 62, 61, 60, 58, 57, 55, 53, 52, 49, 46, 43, 40, 35, 32, 29,
24, 21, 16, 13, 10, 6, 3, 0, -5, -8, -10, -14, -16, -20, -21, -24, -25, -28,
-28, -27, -28, -26, -25, -23, -20, -17, -15, -12, -8, -4, -1, 2, 5, 9, 12, 15,
18, 19, 22, 24, 26, 26, 28, 28, 28, 29, 27, 26, 25, 23, 23, 20, 17, 13, 10, 7,
2, -2, -7, -13, -19, -25, -31, -37, -43, -50, -56, -62, -68, -74, -79, -85, -89,
-93, -99, -102, -106, -108, -112, -115, -116, -117, -119, -118, -119, -119,
-118, -116, -113, -111, -109, -105, -101, -97, -92, -87, -81, -75, -68, -62,
-55, -47, -39, -32, -25, -17, -10, -2, };