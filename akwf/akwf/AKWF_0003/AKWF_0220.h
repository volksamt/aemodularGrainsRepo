#define DATA_LENGTH 512
#define DATA AKWF_0220

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 12, 13, 16, 20, 22, 25, 28,
30, 34, 36, 39, 41, 44, 46, 49, 51, 53, 56, 58, 59, 61, 64, 65, 67, 69, 70, 73,
75, 76, 77, 79, 80, 81, 83, 85, 86, 86, 88, 87, 89, 90, 91, 92, 93, 93, 95, 95,
96, 97, 97, 97, 98, 99, 99, 99, 99, 99, 100, 101, 101, 100, 101, 101, 101, 100,
102, 101, 101, 101, 101, 101, 101, 100, 100, 100, 99, 99, 99, 99, 98, 98, 99,
99, 98, 96, 97, 97, 96, 95, 95, 94, 93, 93, 94, 92, 92, 91, 91, 91, 89, 89, 88,
87, 87, 86, 86, 85, 85, 84, 83, 82, 82, 81, 80, 80, 79, 77, 76, 76, 75, 74, 73,
72, 71, 69, 69, 67, 67, 65, 64, 63, 61, 59, 58, 57, 55, 55, 53, 53, 51, 50, 48,
47, 46, 45, 44, 42, 41, 41, 40, 39, 38, 37, 35, 34, 34, 33, 33, 32, 31, 31, 31,
30, 30, 29, 30, 28, 28, 29, 28, 28, 29, 28, 27, 28, 29, 28, 28, 29, 30, 30, 30,
31, 31, 32, 32, 32, 34, 34, 35, 35, 36, 36, 36, 37, 39, 39, 40, 40, 40, 41, 41,
43, 43, 44, 43, 45, 45, 46, 46, 46, 47, 48, 47, 47, 49, 48, 49, 49, 49, 49, 50,
49, 49, 49, 50, 49, 49, 49, 48, 48, 47, 47, 47, 47, 46, 45, 45, 45, 45, 43, 43,
43, 42, 41, 40, 40, 39, 39, 38, 37, 36, 36, 36, 36, 35, 34, 35, 33, 32, 32, 32,
31, 30, 30, 29, 28, 27, 27, 26, 26, 25, 24, 24, 23, 22, 21, 21, 18, 18, 17, 16,
14, 15, 13, 12, 11, 10, 8, 7, 6, 5, 4, 2, 1, -1, -1, -4, -4, -5, -7, -9, -10,
-11, -13, -14, -16, -16, -19, -20, -22, -23, -24, -26, -28, -29, -30, -32, -33,
-34, -35, -37, -38, -40, -40, -43, -43, -45, -46, -47, -49, -50, -51, -51, -53,
-55, -55, -56, -57, -58, -59, -60, -61, -63, -63, -63, -64, -65, -66, -67, -68,
-68, -69, -70, -70, -71, -72, -73, -73, -74, -75, -75, -76, -77, -77, -78, -79,
-79, -80, -81, -82, -82, -83, -84, -84, -85, -85, -86, -87, -87, -89, -89, -90,
-90, -91, -91, -92, -92, -94, -95, -95, -96, -97, -97, -98, -99, -100, -100,
-101, -102, -103, -103, -104, -104, -106, -106, -107, -108, -108, -109, -110,
-111, -111, -112, -113, -113, -114, -115, -114, -115, -116, -116, -117, -117,
-117, -118, -117, -119, -119, -118, -119, -119, -119, -119, -119, -119, -118,
-119, -118, -119, -120, -119, -119, -118, -118, -118, -117, -118, -117, -116,
-116, -115, -115, -115, -115, -115, -114, -113, -113, -112, -111, -111, -109,
-109, -107, -106, -105, -104, -102, -101, -100, -99, -97, -96, -94, -93, -91,
-89, -88, -85, -83, -80, -78, -76, -74, -71, -68, -66, -64, -61, -58, -55, -51,
-48, -46, -43, -39, -36, -33, -30, -26, -24, -20, -16, -13, -10, -8, -4, -1, };