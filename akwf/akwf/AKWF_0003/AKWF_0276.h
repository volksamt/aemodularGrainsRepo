#define DATA_LENGTH 512
#define DATA AKWF_0276

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 10, 15, 21, 26, 29, 35, 39, 43, 48,
53, 57, 62, 66, 70, 75, 80, 83, 86, 90, 93, 95, 97, 99, 100, 102, 101, 102, 103,
101, 102, 101, 100, 100, 99, 98, 96, 96, 94, 92, 90, 87, 85, 83, 79, 76, 73, 70,
67, 63, 60, 57, 53, 50, 47, 44, 40, 38, 34, 31, 29, 26, 25, 22, 20, 18, 15, 14,
13, 10, 8, 6, 5, 3, 1, 0, -2, -2, -4, -4, -5, -5, -5, -6, -6, -5, -6, -6, -5,
-3, -3, -2, 0, 1, 4, 5, 7, 9, 10, 11, 15, 15, 18, 18, 20, 21, 23, 25, 25, 27,
28, 29, 31, 32, 33, 33, 34, 34, 35, 36, 37, 36, 38, 38, 37, 37, 37, 36, 36, 35,
35, 33, 33, 32, 30, 28, 27, 25, 22, 20, 16, 14, 10, 7, 3, 0, -3, -7, -11, -15,
-18, -22, -25, -30, -33, -37, -41, -47, -50, -53, -59, -62, -66, -70, -73, -75,
-80, -83, -86, -89, -92, -94, -96, -98, -101, -103, -105, -107, -109, -110,
-112, -114, -114, -117, -116, -118, -119, -118, -119, -118, -120, -118, -117,
-117, -116, -114, -112, -111, -108, -106, -105, -102, -99, -97, -93, -90, -86,
-83, -79, -75, -71, -67, -63, -59, -55, -51, -46, -42, -38, -33, -28, -25, -20,
-15, -12, -8, -4, -1, 3, 7, 10, 13, 17, 21, 24, 27, 30, 34, 37, 39, 42, 43, 46,
48, 50, 53, 55, 57, 59, 62, 63, 66, 68, 70, 71, 73, 75, 77, 77, 78, 80, 80, 82,
82, 85, 85, 85, 87, 87, 87, 88, 88, 87, 88, 87, 86, 85, 84, 83, 82, 80, 78, 76,
74, 73, 71, 68, 66, 62, 60, 57, 54, 51, 48, 45, 41, 38, 34, 31, 28, 25, 22, 19,
16, 12, 9, 6, 5, 3, 0, -2, -5, -6, -7, -9, -10, -11, -11, -11, -12, -12, -11,
-11, -11, -10, -9, -7, -7, -5, -4, -3, -1, 1, 3, 5, 6, 8, 10, 12, 13, 16, 17,
18, 19, 21, 21, 22, 22, 23, 23, 23, 22, 21, 20, 19, 18, 17, 14, 13, 10, 8, 5, 2,
-1, -4, -7, -11, -15, -17, -21, -25, -29, -32, -36, -40, -42, -47, -50, -54,
-57, -61, -64, -67, -70, -72, -75, -78, -81, -83, -84, -87, -88, -90, -92, -93,
-95, -97, -99, -101, -104, -106, -107, -109, -110, -110, -110, -109, -109, -106,
-105, -102, -100, -95, -93, -89, -86, -82, -78, -73, -69, -64, -59, -54, -49,
-44, -37, -31, -26, -19, -13, -7, 0, 6, 12, 18, 23, 28, 34, 40, 45, 49, 53, 56,
59, 62, 65, 67, 69, 71, 72, 72, 72, 71, 70, 69, 68, 65, 63, 59, 57, 53, 49, 45,
40, 35, 31, 26, 21, 16, 10, 4, -1, -5, -11, -16, -19, -23, -28, -31, -35, -39,
-44, -47, -52, -55, -58, -61, -63, -64, -64, -65, -64, -63, -62, -60, -59, -56,
-56, -54, -53, -50, -47, -44, -42, -38, -34, -28, -23, -18, -12, -5, 0, };