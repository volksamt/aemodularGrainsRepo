#define DATA_LENGTH 512
#define DATA AKWF_0209

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 5, 7, 10, 11, 13, 16, 18, 20,
21, 23, 26, 28, 29, 32, 33, 34, 35, 37, 38, 39, 39, 41, 40, 41, 41, 42, 41, 41,
41, 41, 42, 41, 41, 41, 41, 40, 41, 41, 42, 43, 43, 43, 44, 44, 46, 46, 48, 49,
48, 50, 50, 52, 53, 53, 54, 56, 56, 56, 57, 57, 59, 59, 59, 61, 61, 61, 62, 63,
63, 64, 64, 65, 66, 66, 67, 68, 69, 69, 70, 71, 72, 74, 76, 77, 78, 79, 81, 83,
85, 87, 89, 90, 92, 94, 95, 97, 98, 100, 101, 103, 103, 104, 105, 107, 107, 108,
108, 108, 109, 110, 110, 110, 110, 111, 111, 113, 113, 113, 113, 114, 114, 115,
114, 115, 116, 116, 116, 117, 117, 117, 118, 119, 118, 118, 119, 119, 119, 118,
118, 118, 117, 116, 116, 114, 113, 111, 110, 108, 107, 105, 103, 103, 101, 99,
99, 98, 98, 96, 94, 94, 94, 93, 91, 91, 91, 90, 91, 90, 89, 89, 89, 89, 89, 89,
88, 88, 87, 86, 86, 87, 86, 86, 84, 85, 84, 84, 84, 83, 82, 82, 81, 80, 79, 78,
77, 76, 75, 73, 73, 70, 70, 68, 67, 66, 65, 64, 62, 62, 60, 59, 59, 57, 56, 56,
54, 53, 52, 52, 50, 49, 48, 46, 44, 43, 41, 39, 36, 34, 31, 28, 25, 22, 19, 16,
12, 8, 5, 3, -2, -5, -8, -11, -14, -16, -19, -22, -24, -26, -27, -29, -30, -31,
-33, -33, -34, -35, -34, -34, -33, -34, -34, -33, -34, -33, -33, -32, -33, -32,
-32, -33, -34, -34, -34, -35, -36, -36, -36, -38, -39, -39, -40, -41, -42, -43,
-42, -43, -45, -44, -45, -45, -45, -46, -46, -46, -46, -47, -47, -47, -47, -48,
-48, -48, -48, -49, -49, -49, -49, -50, -50, -51, -51, -52, -53, -54, -55, -57,
-58, -60, -61, -64, -64, -67, -68, -70, -72, -74, -76, -78, -79, -82, -84, -86,
-88, -89, -92, -93, -95, -96, -98, -100, -101, -103, -103, -104, -106, -105,
-107, -107, -108, -109, -108, -110, -110, -110, -111, -111, -112, -113, -113,
-114, -114, -114, -115, -115, -115, -116, -116, -116, -116, -116, -116, -115,
-115, -114, -114, -113, -113, -112, -112, -112, -111, -110, -109, -108, -108,
-107, -107, -106, -105, -105, -104, -104, -102, -103, -102, -101, -101, -100,
-100, -99, -100, -100, -100, -99, -100, -100, -99, -100, -99, -99, -98, -99,
-99, -99, -99, -99, -100, -99, -99, -99, -99, -98, -98, -97, -96, -96, -95, -93,
-92, -91, -89, -88, -87, -84, -83, -81, -80, -77, -76, -74, -73, -70, -69, -68,
-66, -65, -64, -61, -60, -59, -57, -57, -55, -54, -53, -52, -50, -49, -47, -46,
-44, -42, -41, -39, -37, -34, -33, -32, -29, -28, -25, -24, -21, -20, -18, -17,
-15, -14, -13, -11, -9, -9, -8, -7, -6, -6, -6, -6, -6, -7, -7, -7, -7, -8, -8,
-8, -9, -9, -9, -10, -9, -9, -9, -8, -7, -5, -4, -3, -1, 0, };