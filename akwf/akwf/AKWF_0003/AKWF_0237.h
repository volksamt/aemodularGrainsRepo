#define DATA_LENGTH 512
#define DATA AKWF_0237

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 5, 6, 8, 10, 11, 12, 14, 15,
16, 18, 19, 21, 22, 23, 25, 27, 29, 29, 31, 32, 33, 35, 37, 38, 39, 40, 41, 44,
44, 47, 47, 49, 50, 52, 53, 54, 55, 56, 59, 60, 61, 62, 63, 64, 66, 67, 68, 70,
70, 72, 73, 74, 75, 76, 77, 78, 80, 81, 82, 83, 83, 84, 85, 87, 87, 89, 89, 91,
91, 92, 93, 94, 94, 96, 97, 98, 98, 98, 101, 100, 102, 102, 103, 104, 104, 105,
105, 106, 106, 107, 108, 108, 109, 108, 110, 111, 111, 112, 112, 112, 112, 113,
114, 114, 114, 115, 114, 115, 115, 116, 116, 116, 116, 117, 117, 116, 117, 117,
117, 116, 117, 117, 118, 117, 118, 117, 117, 117, 118, 118, 117, 117, 117, 116,
117, 117, 117, 115, 115, 114, 114, 114, 114, 114, 113, 113, 113, 112, 111, 110,
110, 109, 109, 109, 108, 107, 107, 106, 106, 104, 103, 103, 102, 101, 102, 100,
99, 99, 98, 97, 97, 95, 95, 94, 93, 93, 91, 90, 89, 88, 87, 86, 86, 85, 84, 83,
81, 81, 80, 78, 78, 77, 76, 74, 73, 72, 71, 70, 69, 67, 66, 65, 64, 63, 62, 61,
60, 58, 58, 56, 55, 53, 52, 51, 50, 49, 48, 46, 45, 44, 42, 40, 40, 38, 37, 36,
34, 33, 31, 30, 29, 28, 26, 25, 23, 23, 20, 19, 18, 16, 15, 14, 12, 12, 10, 8,
7, 5, 5, 3, 1, 1, -1, -2, -4, -5, -6, -7, -9, -10, -11, -12, -14, -15, -17, -18,
-19, -20, -22, -23, -24, -26, -26, -28, -29, -30, -31, -33, -33, -35, -37, -37,
-39, -40, -42, -43, -44, -45, -46, -47, -49, -51, -51, -51, -53, -55, -56, -58,
-58, -60, -61, -62, -63, -64, -66, -66, -68, -69, -70, -71, -72, -73, -74, -75,
-76, -77, -78, -80, -80, -81, -83, -84, -85, -86, -86, -88, -89, -90, -91, -92,
-93, -93, -95, -95, -97, -98, -99, -99, -99, -101, -102, -102, -103, -104, -105,
-106, -106, -107, -107, -109, -108, -110, -110, -110, -112, -112, -112, -114,
-113, -114, -114, -115, -116, -116, -115, -117, -117, -117, -117, -117, -118,
-118, -118, -118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -118, -119, -118, -118, -118, -118, -117, -117, -117,
-117, -116, -115, -116, -115, -114, -114, -114, -113, -113, -112, -112, -111,
-111, -110, -109, -109, -109, -108, -107, -106, -105, -105, -104, -103, -102,
-101, -101, -101, -99, -99, -97, -97, -95, -95, -93, -93, -92, -91, -90, -90,
-88, -87, -86, -85, -84, -83, -82, -81, -80, -79, -77, -76, -76, -75, -73, -73,
-71, -69, -68, -68, -67, -66, -64, -63, -62, -60, -59, -58, -57, -55, -55, -53,
-51, -50, -48, -47, -46, -45, -44, -43, -42, -39, -39, -38, -36, -34, -33, -33,
-31, -30, -28, -26, -25, -23, -22, -21, -19, -18, -17, -16, -15, -13, -12, -10,
-9, -8, -6, -4, -2, -1, 0, };