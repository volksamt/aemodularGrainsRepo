#define DATA_LENGTH 512
#define DATA AKWF_0270

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 10, 15, 20, 26, 32, 39, 47, 55,
63, 70, 76, 81, 83, 86, 88, 88, 89, 88, 89, 89, 92, 94, 97, 102, 106, 109, 113,
116, 118, 119, 119, 120, 117, 116, 115, 112, 110, 108, 105, 102, 99, 96, 92, 88,
84, 79, 76, 72, 68, 65, 63, 59, 56, 54, 52, 50, 46, 43, 39, 34, 29, 23, 18, 12,
6, 3, -1, -4, -6, -8, -9, -10, -9, -11, -12, -13, -15, -16, -18, -20, -22, -24,
-26, -29, -30, -30, -31, -31, -30, -30, -29, -28, -27, -27, -26, -25, -24, -23,
-23, -23, -22, -21, -20, -21, -20, -18, -17, -16, -15, -14, -13, -13, -13, -11,
-9, -9, -7, -7, -7, -6, -6, -5, -5, -6, -7, -7, -9, -11, -12, -13, -15, -15,
-15, -15, -15, -15, -14, -15, -15, -16, -17, -20, -22, -23, -25, -29, -31, -34,
-37, -40, -44, -46, -48, -50, -53, -54, -57, -59, -59, -60, -60, -61, -61, -62,
-62, -61, -60, -61, -60, -61, -60, -60, -59, -59, -57, -56, -54, -53, -50, -48,
-46, -43, -40, -38, -35, -32, -30, -26, -25, -23, -21, -20, -18, -16, -16, -15,
-13, -11, -11, -10, -9, -8, -7, -7, -7, -7, -8, -8, -9, -10, -10, -12, -14, -15,
-17, -18, -20, -22, -23, -25, -27, -28, -29, -30, -32, -32, -32, -33, -33, -34,
-34, -34, -34, -35, -34, -34, -34, -33, -31, -30, -28, -27, -26, -24, -21, -18,
-15, -12, -9, -4, -2, 3, 7, 10, 13, 15, 18, 19, 21, 21, 22, 23, 26, 27, 30, 34,
38, 41, 44, 47, 49, 50, 52, 52, 51, 49, 48, 44, 41, 37, 35, 32, 28, 25, 24, 22,
21, 19, 20, 19, 18, 19, 18, 19, 19, 20, 20, 20, 20, 19, 19, 18, 17, 17, 16, 15,
15, 14, 14, 15, 17, 18, 19, 21, 25, 26, 27, 30, 31, 31, 32, 32, 33, 33, 33, 32,
31, 31, 31, 31, 31, 31, 32, 31, 32, 30, 30, 29, 29, 26, 26, 25, 22, 21, 21, 18,
17, 17, 15, 14, 13, 12, 12, 11, 10, 10, 10, 10, 10, 9, 10, 10, 10, 11, 11, 11,
12, 13, 13, 15, 16, 17, 19, 21, 23, 24, 26, 28, 29, 31, 31, 30, 30, 30, 31, 31,
32, 34, 37, 39, 42, 45, 46, 47, 47, 47, 47, 46, 44, 43, 40, 38, 35, 32, 30, 26,
24, 20, 18, 15, 11, 9, 6, 4, 1, -1, -2, -5, -6, -9, -10, -13, -14, -17, -19,
-21, -25, -27, -29, -31, -33, -34, -36, -37, -38, -38, -38, -38, -37, -37, -38,
-38, -38, -39, -39, -40, -39, -40, -42, -42, -43, -43, -44, -43, -45, -45, -45,
-46, -46, -47, -48, -49, -50, -52, -53, -54, -56, -58, -59, -61, -62, -64, -67,
-68, -69, -70, -71, -72, -73, -74, -74, -74, -74, -73, -74, -73, -73, -72, -72,
-71, -70, -69, -67, -64, -62, -60, -57, -54, -51, -47, -43, -39, -34, -30, -25,
-20, -15, -10, -6, -2, };