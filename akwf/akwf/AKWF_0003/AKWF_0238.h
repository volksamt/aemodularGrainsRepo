#define DATA_LENGTH 512
#define DATA AKWF_0238

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 6, 7, 9, 10, 12, 13, 14,
17, 17, 19, 20, 21, 22, 24, 26, 26, 28, 30, 31, 33, 34, 36, 37, 38, 40, 41, 42,
44, 45, 47, 48, 49, 51, 52, 54, 55, 56, 57, 59, 60, 62, 63, 65, 66, 67, 70, 71,
71, 73, 75, 76, 77, 79, 81, 81, 83, 84, 85, 86, 88, 87, 89, 89, 90, 91, 90, 91,
91, 91, 91, 91, 91, 91, 91, 91, 89, 90, 90, 88, 87, 87, 86, 86, 85, 83, 83, 82,
81, 80, 79, 77, 76, 75, 74, 72, 72, 70, 69, 69, 67, 66, 64, 63, 62, 60, 59, 57,
56, 55, 54, 52, 50, 50, 49, 46, 45, 44, 43, 42, 40, 38, 36, 36, 35, 33, 31, 30,
29, 27, 26, 26, 24, 23, 23, 22, 21, 20, 20, 19, 20, 19, 20, 20, 20, 20, 22, 22,
23, 23, 24, 26, 28, 29, 31, 33, 34, 36, 38, 40, 43, 44, 47, 49, 51, 54, 55, 58,
60, 63, 65, 68, 70, 74, 76, 78, 81, 83, 86, 88, 91, 93, 96, 99, 102, 103, 105,
108, 109, 111, 112, 114, 115, 116, 116, 117, 119, 117, 119, 118, 118, 117, 117,
117, 115, 114, 113, 112, 110, 109, 108, 105, 105, 102, 100, 98, 96, 93, 92, 90,
87, 85, 83, 80, 78, 75, 73, 71, 68, 65, 62, 60, 57, 55, 52, 49, 46, 44, 41, 38,
35, 33, 30, 27, 25, 22, 19, 17, 14, 11, 8, 4, 3, 0, -3, -6, -9, -12, -14, -17,
-20, -23, -26, -29, -32, -34, -37, -40, -43, -45, -49, -51, -54, -56, -60, -63,
-65, -69, -71, -74, -77, -80, -82, -85, -88, -91, -93, -97, -99, -101, -103,
-106, -108, -110, -112, -113, -115, -115, -116, -118, -119, -118, -119, -119,
-118, -118, -118, -118, -117, -115, -115, -114, -113, -111, -110, -109, -106,
-105, -103, -101, -98, -98, -96, -93, -91, -88, -86, -84, -81, -80, -77, -73,
-72, -69, -66, -64, -60, -58, -56, -53, -51, -49, -45, -44, -41, -39, -37, -36,
-34, -31, -31, -29, -28, -26, -26, -25, -24, -24, -23, -23, -22, -23, -22, -22,
-23, -24, -23, -24, -25, -25, -26, -26, -27, -28, -29, -30, -30, -31, -33, -33,
-35, -36, -37, -38, -39, -40, -42, -43, -45, -45, -47, -48, -49, -51, -52, -53,
-54, -55, -56, -58, -59, -61, -62, -64, -66, -66, -67, -70, -71, -72, -73, -74,
-76, -77, -79, -80, -82, -82, -83, -85, -86, -86, -88, -88, -88, -89, -89, -90,
-90, -90, -91, -91, -90, -90, -90, -90, -89, -89, -89, -87, -87, -87, -86, -85,
-84, -83, -82, -82, -81, -79, -79, -77, -77, -75, -73, -72, -72, -70, -69, -68,
-67, -65, -64, -63, -62, -61, -59, -58, -56, -55, -54, -52, -51, -50, -48, -47,
-44, -44, -42, -41, -40, -38, -37, -35, -35, -33, -31, -30, -28, -27, -25, -24,
-22, -21, -20, -19, -17, -16, -14, -13, -12, -10, -9, -7, -6, -5, -2, -1, 0, };