#define DATA_LENGTH 512
#define DATA AKWF_0268

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 13, 17, 21, 25, 30, 34, 39,
43, 48, 52, 57, 61, 64, 69, 73, 76, 79, 83, 86, 89, 91, 93, 96, 97, 98, 98, 100,
101, 99, 99, 98, 97, 96, 94, 92, 89, 86, 82, 79, 75, 71, 65, 62, 56, 51, 44, 39,
33, 28, 21, 15, 9, 2, -4, -11, -18, -24, -31, -38, -44, -50, -57, -63, -69, -74,
-80, -85, -90, -95, -99, -103, -107, -109, -112, -115, -117, -118, -118, -119,
-119, -118, -117, -116, -113, -112, -109, -106, -101, -98, -94, -89, -85, -80,
-74, -69, -64, -59, -53, -47, -41, -35, -31, -25, -19, -14, -8, -3, 3, 7, 12,
16, 20, 24, 27, 31, 34, 37, 39, 41, 42, 43, 45, 46, 45, 46, 44, 44, 43, 40, 39,
37, 34, 32, 29, 26, 23, 19, 16, 12, 7, 3, -1, -5, -9, -14, -18, -21, -25, -30,
-33, -37, -39, -43, -46, -49, -52, -53, -55, -56, -57, -58, -58, -58, -58, -56,
-55, -54, -52, -51, -48, -45, -41, -39, -35, -32, -28, -24, -20, -16, -12, -8,
-4, -1, 3, 7, 10, 14, 17, 19, 22, 24, 25, 26, 27, 28, 28, 29, 29, 28, 28, 27,
27, 26, 24, 23, 22, 21, 20, 19, 17, 16, 15, 14, 13, 11, 10, 8, 7, 7, 6, 5, 4, 3,
4, 3, 2, 2, 2, 2, 1, 3, 2, 2, 4, 4, 4, 5, 8, 9, 10, 12, 13, 15, 18, 20, 22, 25,
27, 30, 32, 35, 37, 39, 43, 45, 47, 50, 52, 54, 57, 59, 60, 63, 64, 66, 67, 68,
69, 71, 71, 72, 73, 73, 72, 72, 73, 71, 71, 71, 70, 70, 68, 66, 65, 64, 62, 59,
58, 55, 54, 52, 50, 48, 45, 44, 41, 38, 36, 34, 32, 29, 26, 23, 21, 19, 15, 13,
10, 7, 3, 1, -4, -6, -11, -15, -19, -24, -28, -33, -37, -42, -47, -51, -56, -61,
-66, -70, -74, -78, -82, -84, -88, -92, -95, -97, -99, -100, -102, -103, -103,
-104, -104, -103, -103, -101, -100, -98, -95, -93, -91, -87, -84, -81, -77, -74,
-68, -64, -60, -56, -51, -46, -42, -36, -31, -26, -21, -17, -12, -8, -3, 1, 6,
10, 14, 18, 22, 25, 29, 32, 34, 37, 38, 40, 43, 44, 45, 46, 46, 48, 47, 48, 47,
46, 45, 45, 43, 42, 41, 38, 37, 35, 32, 30, 28, 25, 23, 19, 18, 15, 12, 9, 7, 4,
2, 0, -3, -4, -7, -9, -10, -11, -12, -13, -14, -14, -14, -14, -14, -14, -13,
-12, -11, -10, -9, -8, -6, -5, -3, -1, 0, 1, 3, 5, 7, 7, 9, 11, 11, 12, 13, 14,
16, 16, 18, 18, 19, 20, 21, 20, 19, 19, 18, 17, 17, 15, 14, 12, 10, 9, 6, 5, 2,
0, -3, -5, -8, -10, -12, -15, -17, -20, -21, -23, -25, -28, -29, -30, -31, -32,
-33, -34, -33, -35, -34, -34, -33, -32, -31, -29, -28, -25, -23, -22, -19, -15,
-13, -9, -5, -2, };