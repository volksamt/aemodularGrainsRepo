#define DATA_LENGTH 512
#define DATA AKWF_0228

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 10, 13, 16, 20, 24, 27, 30, 32,
35, 37, 40, 43, 45, 47, 50, 52, 54, 56, 58, 60, 61, 63, 65, 67, 67, 70, 72, 72,
75, 75, 76, 78, 78, 80, 81, 83, 83, 84, 85, 86, 87, 88, 88, 89, 90, 91, 91, 92,
93, 94, 95, 95, 96, 96, 97, 98, 98, 98, 99, 100, 100, 101, 101, 102, 102, 103,
102, 104, 104, 104, 104, 105, 106, 106, 107, 107, 107, 107, 107, 108, 108, 108,
109, 109, 109, 109, 110, 109, 109, 110, 110, 110, 111, 111, 112, 111, 111, 111,
112, 112, 113, 113, 113, 113, 113, 112, 113, 113, 113, 114, 114, 114, 114, 114,
114, 115, 115, 114, 115, 115, 116, 115, 115, 116, 116, 116, 116, 116, 116, 116,
116, 116, 116, 116, 117, 116, 117, 117, 117, 117, 117, 116, 117, 117, 117, 117,
116, 117, 117, 117, 117, 117, 117, 118, 117, 118, 118, 117, 118, 118, 118, 117,
118, 117, 118, 118, 118, 118, 118, 118, 119, 119, 118, 118, 117, 118, 118, 119,
118, 118, 119, 118, 118, 118, 118, 119, 118, 119, 119, 119, 118, 119, 119, 119,
118, 118, 119, 120, 119, 119, 118, 118, 119, 118, 119, 119, 118, 119, 119, 118,
119, 120, 119, 119, 118, 119, 119, 118, 119, 119, 119, 119, 118, 118, 119, 119,
119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 104, 89, 86, 77, 69, 63,
56, 50, 43, 37, 32, 26, 21, 16, 11, 7, 2, -1, -6, -10, -13, -16, -20, -23, -26,
-30, -32, -35, -37, -41, -43, -46, -48, -50, -53, -54, -57, -58, -60, -62, -63,
-64, -67, -67, -69, -72, -72, -73, -75, -77, -77, -78, -80, -82, -82, -83, -83,
-86, -86, -86, -88, -88, -90, -89, -91, -91, -92, -92, -94, -95, -96, -96, -96,
-97, -98, -98, -99, -99, -100, -100, -101, -102, -101, -102, -102, -103, -103,
-104, -105, -105, -105, -105, -106, -106, -107, -107, -108, -108, -107, -108,
-108, -109, -110, -108, -110, -110, -110, -109, -110, -111, -111, -110, -110,
-111, -111, -111, -112, -113, -113, -112, -113, -112, -112, -113, -113, -114,
-113, -114, -114, -114, -114, -114, -114, -115, -115, -115, -114, -115, -116,
-116, -115, -116, -115, -116, -115, -116, -116, -116, -116, -116, -116, -116,
-116, -116, -116, -116, -117, -117, -116, -118, -116, -117, -117, -117, -117,
-117, -117, -118, -117, -118, -117, -117, -118, -117, -117, -117, -118, -117,
-117, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118,
-118, -118, -118, -118, -119, -119, -118, -118, -118, -118, -118, -119, -118,
-118, -119, -118, -119, -119, -119, -119, -118, -119, -118, -118, -119, -119,
-118, -118, -119, -119, -119, -119, -118, -120, -119, -118, -118, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -118, -119, -118, -119, -119,
-119, -119, -119, -119, -118, -119, -118, -119, -119, -119, -119, -119, -118,
-103, -89, -85, -76, -70, -61, -55, -49, -43, -36, -31, -25, -20, -16, -11, -7,
-1, };