#define DATA_LENGTH 512
#define DATA AKWF_0236

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 7, 9, 11, 14, 15, 18, 20, 21,
23, 26, 27, 29, 31, 32, 35, 37, 38, 40, 42, 43, 45, 48, 49, 50, 51, 53, 55, 57,
58, 60, 61, 63, 64, 66, 67, 68, 69, 71, 73, 73, 75, 76, 76, 79, 80, 80, 82, 83,
84, 84, 85, 87, 87, 88, 89, 89, 91, 92, 91, 93, 93, 93, 95, 95, 96, 96, 97, 97,
98, 98, 99, 99, 99, 99, 99, 99, 100, 101, 100, 100, 101, 101, 101, 101, 102,
101, 101, 101, 101, 102, 102, 101, 101, 101, 102, 101, 101, 101, 101, 101, 101,
100, 100, 100, 100, 100, 100, 99, 99, 98, 99, 99, 98, 97, 97, 97, 97, 97, 96,
96, 95, 95, 94, 93, 94, 92, 93, 93, 92, 90, 91, 90, 89, 89, 89, 87, 87, 87, 86,
85, 84, 84, 84, 83, 82, 81, 81, 80, 79, 78, 78, 77, 76, 76, 75, 75, 73, 73, 73,
71, 70, 70, 69, 68, 68, 67, 67, 66, 65, 64, 65, 64, 62, 62, 61, 60, 59, 59, 58,
57, 55, 55, 54, 53, 52, 51, 51, 50, 49, 49, 48, 47, 46, 45, 43, 43, 43, 41, 41,
39, 39, 38, 38, 37, 36, 35, 34, 34, 32, 32, 30, 30, 29, 28, 28, 26, 25, 24, 25,
23, 22, 22, 21, 20, 19, 19, 18, 17, 17, 17, 16, 15, 14, 15, 14, 13, 12, 12, 11,
10, 10, 9, 9, 8, 7, 7, 7, 6, 5, 4, 5, 4, 3, 2, 2, 1, 1, 0, 0, 0, -1, -2, -3, -2,
-4, -4, -4, -6, -6, -6, -8, -9, -8, -9, -9, -10, -11, -12, -12, -12, -14, -14,
-14, -15, -15, -15, -17, -17, -18, -18, -19, -19, -20, -20, -21, -21, -22, -23,
-23, -24, -24, -25, -25, -26, -27, -27, -28, -29, -30, -30, -31, -32, -33, -34,
-33, -35, -36, -37, -38, -39, -41, -40, -42, -42, -43, -44, -45, -46, -47, -48,
-48, -50, -51, -52, -53, -54, -54, -56, -57, -57, -59, -59, -61, -61, -63, -64,
-65, -65, -66, -66, -69, -68, -70, -71, -71, -73, -74, -74, -75, -77, -78, -79,
-79, -80, -81, -82, -84, -84, -85, -86, -87, -88, -89, -89, -91, -92, -93, -93,
-95, -95, -96, -96, -98, -98, -98, -100, -101, -102, -103, -103, -104, -104,
-105, -106, -107, -108, -108, -109, -109, -111, -110, -111, -112, -113, -113,
-114, -115, -115, -115, -116, -116, -116, -117, -117, -118, -118, -118, -118,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-118, -118, -118, -117, -117, -116, -117, -116, -116, -114, -115, -115, -113,
-113, -111, -110, -110, -110, -108, -107, -106, -105, -104, -104, -102, -101,
-99, -99, -96, -95, -94, -93, -91, -90, -88, -88, -85, -84, -82, -80, -78, -78,
-75, -74, -72, -70, -67, -66, -63, -62, -60, -58, -55, -53, -51, -49, -47, -45,
-43, -41, -39, -36, -34, -31, -29, -27, -25, -23, -20, -19, -17, -14, -11, -10,
-7, -5, -3, -1, };