#define DATA_LENGTH 512
#define DATA AKWF_0269

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 12, 15, 19, 23, 27, 32, 36,
39, 44, 47, 52, 55, 59, 63, 65, 68, 71, 76, 78, 81, 84, 87, 91, 93, 96, 99, 102,
104, 107, 110, 111, 113, 114, 116, 117, 117, 118, 118, 118, 117, 115, 113, 111,
109, 106, 102, 99, 95, 91, 86, 82, 77, 71, 66, 62, 56, 52, 47, 41, 38, 33, 30,
24, 20, 17, 13, 9, 5, 1, -3, -7, -11, -16, -22, -27, -31, -37, -42, -47, -52,
-58, -62, -67, -72, -76, -79, -83, -88, -90, -93, -96, -98, -100, -101, -102,
-104, -105, -107, -107, -108, -109, -110, -112, -113, -112, -115, -115, -116,
-117, -118, -118, -118, -120, -119, -118, -119, -118, -116, -115, -113, -111,
-108, -104, -101, -97, -93, -89, -85, -80, -76, -70, -65, -61, -55, -50, -44,
-39, -35, -28, -24, -18, -13, -8, -3, 2, 7, 14, 18, 23, 29, 34, 39, 43, 50, 54,
59, 63, 68, 72, 76, 80, 83, 86, 90, 92, 94, 97, 98, 99, 99, 99, 99, 99, 98, 97,
97, 94, 92, 91, 89, 87, 85, 83, 82, 79, 77, 75, 74, 71, 68, 65, 63, 61, 58, 55,
51, 48, 44, 40, 35, 30, 25, 20, 15, 11, 5, 1, -3, -8, -11, -15, -18, -20, -23,
-26, -28, -31, -33, -35, -38, -41, -42, -45, -47, -50, -52, -54, -58, -60, -61,
-63, -64, -66, -68, -69, -69, -71, -70, -70, -69, -69, -67, -66, -64, -61, -59,
-56, -55, -52, -49, -46, -42, -40, -37, -33, -31, -27, -24, -21, -18, -15, -11,
-9, -5, -2, 0, 4, 6, 10, 13, 17, 19, 23, 26, 29, 33, 36, 39, 43, 45, 48, 51, 54,
56, 59, 61, 64, 66, 68, 70, 72, 74, 75, 76, 77, 77, 79, 80, 79, 79, 79, 79, 79,
77, 77, 75, 74, 73, 70, 68, 66, 65, 63, 60, 59, 56, 55, 52, 51, 47, 45, 44, 41,
38, 37, 34, 30, 28, 25, 21, 18, 14, 10, 6, 2, -2, -7, -10, -15, -20, -24, -28,
-32, -35, -38, -41, -43, -47, -48, -50, -53, -54, -57, -59, -60, -62, -65, -65,
-68, -70, -73, -74, -77, -79, -81, -83, -85, -88, -91, -93, -94, -96, -97, -98,
-100, -100, -100, -100, -99, -99, -99, -97, -95, -93, -91, -89, -87, -84, -82,
-78, -76, -73, -70, -66, -63, -60, -57, -52, -50, -45, -43, -39, -35, -30, -27,
-22, -19, -15, -11, -6, -3, 2, 5, 10, 14, 16, 19, 23, 26, 28, 30, 32, 33, 36,
36, 38, 38, 38, 38, 38, 37, 37, 36, 35, 34, 33, 31, 29, 27, 25, 23, 21, 19, 16,
14, 14, 12, 10, 9, 8, 7, 7, 5, 6, 5, 4, 4, 3, 2, 1, 1, -1, -2, -3, -6, -7, -9,
-10, -12, -13, -14, -15, -16, -16, -15, -15, -14, -13, -11, -10, -9, -8, -6, -4,
-4, -3, -2, -1, 0, -1, -1, -2, -3, -3, -4, -5, -6, -8, -8, -9, -10, -10, -9, -8,
-8, -7, -5, -3, 0, };