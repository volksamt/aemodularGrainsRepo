#define DATA_LENGTH 512
#define DATA AKWF_0272

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 7, 9, 12, 14, 16, 19, 22, 24,
27, 30, 33, 35, 37, 40, 42, 45, 47, 49, 51, 55, 56, 58, 59, 62, 64, 65, 68, 69,
70, 72, 73, 75, 76, 76, 79, 79, 80, 81, 81, 82, 83, 84, 84, 84, 84, 84, 83, 83,
83, 82, 82, 81, 80, 79, 77, 76, 74, 71, 69, 67, 64, 62, 58, 54, 51, 47, 43, 38,
34, 30, 26, 19, 15, 9, 5, -1, -7, -11, -17, -23, -28, -33, -39, -44, -49, -54,
-58, -63, -68, -72, -76, -80, -84, -87, -91, -95, -98, -101, -104, -106, -109,
-110, -113, -114, -116, -117, -117, -118, -119, -118, -119, -119, -119, -118,
-117, -115, -114, -111, -110, -109, -106, -103, -100, -96, -93, -89, -86, -81,
-78, -74, -70, -65, -60, -56, -51, -47, -41, -36, -32, -27, -23, -17, -13, -9,
-5, 0, 4, 8, 12, 15, 20, 23, 27, 29, 33, 36, 39, 43, 45, 47, 50, 52, 54, 56, 59,
60, 61, 62, 64, 64, 67, 66, 68, 68, 69, 69, 70, 70, 69, 69, 70, 69, 69, 67, 67,
66, 64, 63, 62, 60, 58, 56, 54, 52, 50, 47, 45, 42, 39, 37, 34, 30, 29, 25, 22,
20, 17, 14, 12, 9, 6, 4, 1, -1, -4, -5, -8, -10, -13, -14, -17, -19, -20, -22,
-23, -25, -27, -28, -30, -31, -31, -32, -33, -33, -34, -35, -35, -36, -35, -36,
-34, -34, -35, -34, -35, -34, -32, -31, -31, -29, -28, -27, -26, -24, -23, -21,
-20, -18, -16, -15, -13, -10, -8, -6, -5, -2, -1, 2, 5, 6, 9, 11, 14, 16, 19,
21, 24, 26, 29, 31, 33, 36, 38, 41, 43, 45, 48, 49, 51, 54, 56, 58, 60, 62, 63,
64, 66, 66, 68, 69, 70, 70, 71, 72, 72, 72, 71, 72, 71, 70, 69, 68, 68, 66, 65,
62, 60, 58, 56, 53, 51, 49, 46, 42, 39, 36, 31, 27, 23, 20, 15, 11, 6, 3, -2,
-6, -11, -16, -20, -24, -29, -33, -37, -41, -46, -50, -53, -56, -60, -64, -67,
-70, -74, -76, -79, -82, -85, -87, -89, -91, -93, -94, -95, -97, -97, -98, -99,
-100, -100, -99, -99, -99, -98, -97, -96, -94, -93, -92, -90, -88, -86, -83,
-82, -79, -77, -74, -71, -68, -65, -63, -59, -57, -53, -51, -48, -45, -41, -40,
-36, -34, -31, -28, -26, -22, -21, -19, -16, -13, -11, -9, -8, -5, -3, 0, 1, 2,
4, 5, 7, 9, 10, 12, 13, 15, 15, 18, 19, 19, 21, 22, 23, 24, 26, 26, 27, 27, 29,
30, 29, 31, 31, 32, 32, 33, 32, 33, 32, 33, 33, 31, 32, 32, 31, 30, 29, 28, 27,
26, 24, 22, 21, 20, 19, 16, 16, 14, 12, 10, 10, 8, 7, 5, 4, 2, 1, 0, -1, -2, -2,
-3, -4, -6, -6, -7, -8, -8, -10, -11, -11, -12, -12, -13, -13, -13, -14, -13,
-13, -13, -12, -12, -11, -11, -9, -9, -7, -6, -5, -3, -1, };