#define DATA_LENGTH 512
#define DATA AKWF_0287

const PROGMEM int8_t DATA[DATA_LENGTH] = {13, 26, 43, 73, 97, 109, 110, 102, 87,
70, 53, 40, 31, 21, 6, -37, -84, -108, -108, -95, -79, -65, -56, -49, -45, -40,
-30, -18, 6, 45, 74, 80, 72, 61, 50, 44, 40, 38, 34, 28, 21, 12, 4, -13, -35,
-48, -48, -42, -35, -29, -23, -18, -14, -2, 16, 30, 34, 32, 27, 22, 20, 19, 18,
17, 15, 13, 9, 7, 5, 3, -1, -8, -19, -25, -23, -19, -11, -1, 10, 15, 14, 13, 11,
10, 9, 9, 9, 9, 7, 7, 6, 7, 6, 5, 4, 4, 2, 2, 2, 2, 1, 1, 2, 2, 2, 3, 3, 4, 3,
3, 2, 3, 3, 3, 3, 3, 3, 3, 2, -2, -25, -68, -103, -118, -109, -82, -46, -12, 13,
25, 44, 73, 95, 107, 108, 100, 85, 68, 52, 39, 30, 21, 3, -38, -87, -109, -108,
-95, -78, -64, -55, -49, -46, -39, -29, -17, 7, 47, 74, 79, 71, 59, 48, 42, 39,
37, 33, 27, 20, 12, 3, -14, -36, -48, -49, -44, -37, -30, -25, -20, -15, -3, 16,
30, 33, 29, 25, 20, 18, 17, 16, 14, 13, 10, 8, 5, 3, 0, -2, -9, -16, -24, -24,
-19, -8, 3, 10, 11, 10, 7, 7, 6, 7, 8, 7, 6, 5, 4, 5, 3, 4, 3, 3, 2, 1, 0, 0,
-1, -1, -1, 0, 0, 2, 2, 1, 1, 2, 3, 2, 2, 2, 1, 0, -1, 1, 1, 1, -3, -28, -72,
-107, -120, -110, -82, -46, -11, 12, 25, 44, 73, 96, 107, 106, 97, 82, 65, 50,
37, 27, 19, 1, -42, -90, -111, -109, -96, -78, -65, -55, -51, -47, -39, -31,
-17, 9, 48, 74, 77, 69, 57, 47, 41, 39, 36, 32, 25, 19, 10, 2, -16, -37, -50,
-50, -44, -36, -31, -24, -20, -15, -3, 17, 29, 32, 29, 24, 20, 18, 16, 15, 14,
13, 11, 7, 5, 3, 0, -3, -10, -18, -24, -23, -18, -7, 4, 10, 11, 9, 8, 7, 6, 7,
7, 6, 7, 5, 5, 4, 3, 3, 3, 1, 1, 1, 0, -1, 0, 0, -1, 0, 0, 1, 2, 0, 1, 2, 2, 2,
2, 2, 2, 0, 0, 0, 0, 1, 1, 1, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0,
1, -1, -2, -1, -1, -1, 0, 0, -1, -1, -1, -1, -1, 0, 0, -1, -1, 0, 0, -1, 0, -1,
0, 0, 0, -2, -3, -3, -3, -2, -1, -2, -1, -2, -2, -2, -3, -1, -2, -2, -2, -2, -2,
-2, -1, -1, -2, -2, -2, -2, -2, -2, -1, -1, -1, -1, -2, -1, -2, -2, -2, -1, -2,
-1, -1, -1, -1, -1, -2, -2, -2, -1, -2, -2, -1, -1, -2, -1, -2, -2, -5, -9, -11,
-10, -8, -6, -6, -6, -5, -5, -6, -5, -5, -5, -5, -4, -4, -4, -5, -3, -4, -4, -3,
-3, -3, -3, -3, -3, -3, -2, -6, -29, -66, -97, -110, -100, -73, -38, -6, };