#define DATA_LENGTH 512
#define DATA AKWF_0248

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 8, 8, 11, 13, 14, 16, 17, 19,
20, 21, 23, 24, 25, 26, 28, 29, 30, 32, 33, 35, 36, 38, 39, 41, 41, 43, 44, 46,
47, 48, 50, 51, 52, 54, 55, 56, 57, 57, 59, 60, 61, 61, 62, 63, 65, 65, 65, 67,
68, 69, 70, 72, 73, 75, 74, 75, 76, 76, 77, 78, 78, 79, 81, 82, 83, 83, 84, 85,
85, 86, 86, 88, 88, 87, 89, 89, 89, 89, 89, 92, 92, 93, 94, 94, 96, 95, 96, 97,
96, 98, 98, 98, 99, 99, 99, 98, 99, 99, 99, 99, 101, 101, 100, 101, 102, 102,
103, 103, 104, 104, 105, 105, 105, 105, 105, 104, 105, 106, 106, 106, 107, 107,
108, 107, 107, 107, 108, 107, 108, 107, 108, 107, 108, 107, 107, 107, 107, 107,
107, 108, 110, 110, 109, 110, 110, 110, 109, 110, 109, 110, 109, 110, 109, 110,
110, 110, 109, 110, 110, 109, 110, 110, 109, 109, 109, 109, 109, 110, 108, 110,
109, 108, 109, 109, 110, 109, 110, 109, 109, 109, 109, 110, 108, 108, 108, 107,
107, 107, 107, 106, 106, 107, 106, 107, 106, 106, 106, 106, 106, 107, 106, 106,
106, 106, 106, 106, 107, 105, 105, 104, 104, 104, 104, 104, 104, 104, 104, 104,
104, 104, 104, 104, 103, 103, 103, 102, 102, 102, 102, 101, 101, 102, 100, 100,
99, 98, 96, 94, 91, 89, 87, 85, 80, 76, 72, 68, 64, 60, 55, 49, 43, 35, 32, 26,
22, 18, 13, 7, -1, -8, -13, -18, -24, -28, -34, -39, -43, -47, -51, -56, -60,
-62, -66, -68, -71, -75, -78, -80, -82, -84, -87, -89, -91, -92, -95, -96, -97,
-99, -101, -101, -103, -104, -105, -106, -107, -108, -109, -108, -109, -110,
-110, -110, -111, -112, -112, -113, -112, -113, -114, -114, -115, -115, -116,
-116, -116, -117, -117, -117, -117, -116, -117, -117, -117, -116, -117, -117,
-117, -118, -118, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119,
-120, -118, -120, -119, -118, -119, -118, -119, -119, -119, -119, -118, -118,
-120, -118, -118, -119, -119, -119, -119, -118, -119, -119, -119, -118, -118,
-118, -117, -118, -117, -117, -117, -117, -116, -116, -116, -116, -115, -116,
-116, -116, -116, -115, -115, -115, -114, -113, -113, -113, -113, -114, -113,
-113, -112, -112, -112, -111, -111, -110, -110, -109, -109, -109, -108, -110,
-109, -108, -108, -107, -108, -107, -107, -105, -105, -104, -104, -104, -103,
-103, -102, -102, -101, -101, -100, -100, -99, -98, -97, -96, -96, -95, -94,
-93, -94, -93, -93, -91, -91, -90, -88, -88, -87, -86, -86, -86, -84, -85, -83,
-83, -81, -81, -80, -79, -78, -77, -75, -75, -73, -72, -70, -69, -68, -68, -67,
-65, -64, -62, -62, -61, -60, -59, -58, -56, -54, -53, -52, -51, -49, -48, -46,
-45, -44, -43, -41, -40, -39, -38, -36, -35, -34, -32, -31, -30, -28, -26, -25,
-23, -21, -19, -19, -18, -15, -14, -11, -10, -9, -6, -5, -3, -1, };