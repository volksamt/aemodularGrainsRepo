#define DATA_LENGTH 512
#define DATA AKWF_0214

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 7, 13, 11, 11, 15, 16, 18,
21, 24, 29, 31, 34, 36, 37, 38, 38, 43, 43, 45, 48, 50, 50, 51, 53, 55, 56, 57,
59, 55, 54, 57, 55, 52, 51, 52, 52, 55, 53, 51, 51, 51, 52, 53, 54, 54, 55, 55,
55, 55, 54, 49, 45, 47, 48, 48, 48, 50, 54, 55, 56, 56, 56, 57, 57, 56, 55, 55,
56, 56, 56, 55, 56, 58, 56, 58, 58, 60, 59, 57, 59, 59, 59, 60, 59, 60, 62, 61,
62, 63, 63, 65, 67, 63, 51, 50, 51, 47, 45, 46, 47, 49, 46, 43, 43, 40, 38, 36,
35, 34, 33, 31, 28, 27, 25, 23, 22, 20, 21, 22, 23, 22, 23, 21, 20, 18, 15, 16,
13, 14, 13, 7, 6, 6, 4, 3, 1, 2, 1, 1, 1, -2, -4, -5, -5, -6, -7, -5, -4, -3,
-6, -5, -3, -2, -2, -1, 0, -6, -7, -3, -4, -5, -4, -1, 0, 3, 1, -1, 2, 2, 4, 5,
6, 8, 9, 12, 14, 16, 17, 11, 11, 15, 14, 14, 16, 18, 20, 22, 21, 22, 22, 23, 24,
22, 22, 23, 23, 21, 21, 20, 20, 21, 21, 22, 23, 22, 24, 25, 25, 27, 30, 31, 31,
32, 31, 31, 33, 33, 35, 37, 36, 24, 20, 23, 19, 16, 13, 12, 13, 11, 0, -5, -7,
-13, -19, -23, -26, -30, -31, -35, -37, -41, -45, -49, -51, -55, -56, -57, -60,
-63, -63, -65, -66, -68, -70, -70, -73, -74, -77, -85, -87, -88, -91, -93, -95,
-95, -95, -96, -97, -100, -100, -103, -106, -106, -106, -107, -108, -110, -111,
-113, -112, -115, -116, -117, -117, -118, -119, -119, -118, -118, -117, -115,
-113, -110, -105, -102, -99, -96, -93, -89, -85, -83, -82, -78, -72, -69, -67,
-63, -60, -56, -54, -51, -47, -45, -40, -38, -36, -34, -31, -27, -24, -22, -19,
-16, -15, -13, -9, -7, -4, -2, 1, 4, 8, 11, 16, 16, 19, 24, 28, 31, 34, 36, 38,
42, 47, 51, 54, 57, 58, 45, 49, 53, 50, 52, 54, 57, 61, 55, 47, 49, 47, 43, 41,
42, 42, 43, 43, 43, 43, 40, 37, 37, 36, 36, 38, 39, 39, 39, 39, 40, 39, 38, 38,
38, 37, 37, 38, 36, 36, 37, 38, 37, 37, 38, 40, 41, 41, 41, 40, 41, 38, 38, 37,
36, 37, 36, 34, 33, 32, 32, 30, 29, 30, 26, 21, 21, 18, 15, 12, 10, 8, 7, 7, 1,
-1, 0, -2, -2, -4, -7, -8, -7, -9, -11, -14, -18, -24, -27, -29, -31, -34, -34,
-34, -35, -37, -40, -40, -41, -43, -46, -48, -51, -54, -55, -58, -60, -60, -60,
-62, -64, -65, -65, -68, -71, -71, -71, -72, -71, -71, -73, -71, -70, -69, -70,
-72, -69, -67, -65, -62, -58, -54, -53, -50, -47, -43, -45, -47, -43, -40, -38,
-36, -34, -31, -30, -28, -26, -27, -27, -25, -23, -22, -18, -15, -12, -10, -9,
-6, -5, -3, 0, };