#define DATA_LENGTH 512
#define DATA AKWF_0226

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 6, 8, 10, 12, 13, 16, 17, 20,
21, 23, 24, 26, 29, 31, 32, 34, 36, 37, 38, 41, 42, 44, 45, 47, 49, 50, 51, 53,
55, 55, 57, 59, 60, 62, 63, 64, 65, 66, 68, 69, 70, 71, 73, 74, 75, 76, 78, 79,
79, 81, 82, 83, 84, 86, 86, 87, 87, 88, 90, 90, 92, 93, 94, 94, 95, 97, 97, 98,
99, 99, 100, 100, 101, 102, 102, 103, 103, 105, 105, 105, 107, 106, 107, 108,
108, 109, 109, 111, 110, 111, 112, 112, 112, 112, 113, 114, 114, 113, 115, 115,
115, 115, 115, 116, 116, 117, 117, 117, 117, 117, 117, 118, 118, 118, 119, 118,
119, 120, 118, 119, 119, 120, 118, 119, 119, 119, 119, 119, 120, 119, 119, 119,
119, 118, 118, 119, 118, 118, 118, 119, 118, 117, 117, 117, 117, 117, 116, 116,
117, 115, 115, 115, 114, 114, 114, 113, 113, 113, 113, 112, 111, 111, 111, 110,
110, 108, 108, 108, 108, 107, 106, 105, 104, 105, 103, 104, 102, 101, 101, 100,
99, 99, 99, 97, 96, 95, 95, 95, 94, 93, 91, 91, 90, 89, 88, 88, 86, 86, 83, 83,
81, 80, 79, 79, 78, 76, 75, 74, 73, 71, 71, 69, 67, 66, 65, 64, 62, 61, 60, 58,
56, 56, 53, 53, 51, 49, 48, 47, 45, 43, 41, 41, 38, 37, 35, 34, 32, 30, 28, 27,
25, 23, 22, 19, 17, 15, 14, 12, 10, 9, 6, 4, 2, 0, -3, -5, -6, -8, -10, -12,
-14, -16, -18, -20, -22, -24, -25, -26, -28, -30, -32, -33, -36, -37, -39, -40,
-43, -43, -46, -47, -48, -50, -51, -53, -55, -56, -57, -59, -60, -61, -63, -64,
-65, -67, -68, -69, -71, -71, -72, -74, -75, -76, -78, -80, -80, -81, -82, -83,
-84, -86, -85, -88, -88, -89, -90, -90, -92, -93, -93, -94, -95, -95, -96, -98,
-99, -99, -100, -100, -102, -102, -103, -104, -104, -105, -106, -106, -106,
-107, -107, -109, -109, -109, -110, -109, -111, -110, -111, -112, -112, -113,
-113, -114, -114, -115, -115, -115, -115, -115, -116, -117, -117, -117, -117,
-117, -118, -118, -118, -118, -117, -118, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -118, -119,
-118, -119, -118, -117, -117, -117, -118, -118, -117, -117, -117, -117, -117,
-116, -116, -115, -116, -114, -115, -115, -114, -114, -113, -113, -113, -112,
-113, -112, -111, -110, -110, -110, -108, -108, -108, -107, -106, -107, -106,
-105, -105, -103, -103, -102, -102, -100, -101, -100, -99, -98, -98, -96, -96,
-95, -94, -93, -92, -91, -90, -90, -88, -88, -86, -86, -84, -84, -83, -82, -80,
-79, -79, -78, -76, -76, -74, -73, -72, -70, -68, -68, -67, -65, -64, -63, -61,
-59, -58, -56, -56, -53, -52, -51, -49, -48, -46, -45, -43, -42, -41, -38, -37,
-35, -34, -31, -29, -28, -26, -24, -22, -21, -20, -17, -15, -13, -11, -9, -8,
-6, -4, -2, };