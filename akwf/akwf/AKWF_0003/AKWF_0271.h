#define DATA_LENGTH 512
#define DATA AKWF_0271

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 10, 15, 19, 23, 26, 32, 35, 39,
43, 47, 51, 55, 59, 61, 65, 69, 72, 76, 79, 82, 85, 88, 91, 94, 97, 99, 101,
103, 105, 108, 109, 112, 113, 115, 115, 116, 117, 118, 119, 119, 119, 119, 119,
119, 118, 118, 117, 116, 115, 114, 112, 110, 110, 108, 105, 104, 101, 99, 96,
95, 92, 89, 85, 83, 79, 77, 73, 69, 66, 63, 58, 55, 51, 48, 44, 40, 35, 32, 28,
24, 20, 16, 13, 9, 5, 1, -3, -7, -10, -14, -17, -21, -24, -28, -31, -34, -37,
-40, -42, -45, -47, -51, -52, -55, -58, -59, -60, -62, -63, -66, -66, -68, -68,
-70, -71, -71, -71, -72, -72, -73, -73, -73, -72, -72, -71, -71, -70, -69, -67,
-66, -65, -64, -62, -60, -59, -57, -56, -54, -52, -50, -48, -45, -44, -41, -40,
-37, -34, -33, -30, -27, -25, -23, -21, -19, -17, -14, -12, -10, -8, -6, -4, -2,
0, 2, 3, 4, 5, 7, 7, 8, 9, 10, 11, 11, 10, 11, 10, 10, 10, 9, 8, 7, 6, 4, 4, 2,
0, -1, -2, -4, -7, -8, -10, -13, -15, -16, -19, -21, -22, -26, -27, -30, -32,
-34, -36, -39, -40, -43, -44, -47, -49, -50, -52, -54, -55, -57, -58, -60, -62,
-62, -63, -64, -65, -66, -66, -67, -67, -67, -67, -67, -67, -66, -67, -66, -66,
-65, -64, -63, -63, -61, -61, -58, -59, -56, -55, -53, -52, -50, -48, -46, -44,
-41, -39, -38, -34, -32, -29, -28, -24, -22, -19, -16, -13, -11, -8, -4, -1, 2,
5, 8, 11, 15, 17, 22, 24, 28, 31, 34, 37, 41, 44, 46, 49, 52, 55, 57, 61, 64,
65, 67, 71, 72, 74, 75, 77, 78, 80, 82, 82, 82, 84, 85, 84, 85, 83, 83, 82, 83,
82, 80, 80, 78, 76, 74, 73, 72, 69, 69, 66, 64, 61, 59, 58, 54, 53, 49, 49, 46,
43, 41, 38, 36, 34, 32, 29, 27, 25, 23, 20, 19, 16, 14, 13, 12, 9, 9, 7, 5, 3,
3, 1, 0, -1, -2, -3, -3, -4, -5, -6, -6, -6, -7, -7, -7, -7, -7, -7, -6, -6, -6,
-6, -5, -6, -5, -4, -4, -3, -2, -2, -1, 0, 0, 1, 2, 2, 4, 5, 6, 7, 7, 9, 10, 10,
12, 13, 13, 15, 15, 16, 17, 17, 18, 20, 19, 20, 21, 21, 23, 23, 23, 23, 23, 23,
23, 23, 23, 23, 22, 22, 20, 20, 19, 18, 17, 16, 14, 13, 10, 8, 6, 4, 1, 0, -3,
-6, -9, -12, -14, -17, -20, -23, -27, -30, -33, -37, -39, -43, -46, -50, -53,
-55, -58, -61, -64, -68, -69, -73, -76, -78, -80, -83, -84, -87, -88, -90, -91,
-93, -93, -94, -95, -96, -96, -97, -97, -96, -96, -96, -94, -94, -93, -92, -90,
-89, -87, -85, -83, -81, -79, -76, -73, -71, -68, -65, -61, -58, -56, -52, -48,
-45, -40, -37, -33, -30, -25, -21, -17, -14, -9, -5, -1, };