#define DATA_LENGTH 512
#define DATA AKWF_0245

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 9, 12, 14, 16, 18, 20, 23,
25, 28, 31, 33, 34, 36, 38, 40, 42, 45, 48, 51, 53, 54, 57, 58, 60, 63, 64, 66,
68, 69, 71, 72, 73, 75, 76, 78, 80, 82, 82, 83, 84, 85, 86, 87, 87, 88, 87, 87,
88, 90, 90, 90, 91, 91, 90, 90, 90, 91, 91, 91, 91, 90, 91, 90, 90, 90, 90, 91,
90, 91, 91, 90, 90, 92, 92, 93, 93, 93, 93, 93, 93, 94, 93, 93, 94, 94, 95, 95,
96, 96, 96, 96, 97, 98, 98, 100, 101, 102, 103, 103, 103, 104, 104, 103, 105,
106, 107, 108, 109, 109, 110, 112, 112, 113, 113, 113, 112, 114, 114, 116, 116,
117, 119, 118, 119, 120, 119, 119, 119, 119, 120, 119, 120, 118, 119, 119, 118,
118, 119, 119, 118, 119, 119, 119, 118, 118, 116, 116, 115, 114, 113, 111, 111,
109, 108, 107, 107, 106, 105, 104, 103, 102, 101, 100, 99, 98, 97, 97, 95, 94,
92, 92, 90, 90, 87, 85, 85, 83, 83, 82, 81, 79, 78, 77, 77, 75, 75, 73, 72, 72,
71, 70, 69, 68, 67, 65, 66, 64, 62, 62, 61, 60, 59, 58, 57, 56, 56, 56, 55, 56,
54, 54, 53, 52, 50, 51, 49, 47, 48, 46, 45, 44, 43, 43, 42, 40, 39, 39, 38, 37,
36, 34, 32, 31, 29, 28, 27, 26, 24, 23, 20, 19, 18, 17, 16, 15, 13, 10, 8, 7, 4,
2, 1, -1, -3, -4, -7, -9, -11, -13, -15, -16, -20, -23, -25, -27, -30, -31, -33,
-37, -39, -42, -45, -46, -48, -49, -52, -53, -56, -59, -61, -64, -65, -66, -67,
-69, -71, -73, -74, -76, -78, -80, -81, -82, -82, -84, -85, -86, -86, -88, -87,
-88, -87, -88, -90, -89, -91, -91, -91, -91, -90, -90, -91, -91, -90, -91, -91,
-91, -91, -91, -91, -91, -90, -90, -90, -91, -90, -91, -91, -90, -90, -91, -92,
-94, -93, -94, -94, -93, -93, -93, -94, -94, -95, -97, -97, -97, -97, -97, -98,
-98, -99, -100, -100, -100, -100, -101, -101, -104, -104, -105, -106, -107,
-107, -109, -109, -110, -111, -112, -112, -113, -113, -112, -113, -115, -115,
-117, -117, -118, -119, -118, -119, -119, -120, -119, -119, -119, -119, -118,
-120, -119, -119, -119, -119, -118, -118, -119, -120, -119, -119, -118, -118,
-116, -116, -114, -114, -113, -112, -110, -110, -109, -108, -106, -106, -105,
-104, -104, -102, -101, -101, -100, -99, -98, -97, -96, -95, -93, -93, -92, -90,
-90, -89, -87, -87, -86, -84, -82, -80, -78, -78, -76, -76, -75, -74, -72, -72,
-71, -70, -68, -69, -67, -67, -65, -64, -64, -62, -62, -63, -63, -61, -61, -58,
-57, -56, -57, -56, -56, -54, -53, -53, -51, -51, -50, -49, -48, -46, -46, -45,
-44, -43, -43, -41, -41, -39, -38, -37, -36, -36, -35, -34, -33, -31, -28, -26,
-26, -25, -24, -22, -20, -17, -16, -16, -15, -14, -12, -10, -8, -6, -5, -2, 0,
};