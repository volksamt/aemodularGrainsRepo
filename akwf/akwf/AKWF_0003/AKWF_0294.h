#define DATA_LENGTH 512
#define DATA AKWF_0294

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 0, 0, 1, 1, -1, 0, -1, 1, -1,
34, 94, 118, 113, 90, 58, 24, -8, -36, -58, -74, -81, -80, -73, -58, -39, -17,
3, 24, 39, 51, 58, 59, 54, 43, 31, 16, 0, -14, -26, -36, -39, -40, -36, -29,
-19, -8, 3, 13, 22, 28, 31, 31, 27, 22, 14, 5, -4, -11, -18, -23, -26, -26, -23,
-19, -14, -8, -1, 5, 10, 13, 15, 14, 13, 9, 4, 0, -5, -10, -13, -15, -17, -17,
-15, -13, -10, -6, -1, 1, 4, 7, 7, 8, 5, 4, 2, -1, -4, -7, -9, -10, -10, -10,
-10, -8, -6, -3, -2, 1, 2, 3, 3, 3, 3, 2, 0, -2, -2, -5, -4, -6, -6, -6, -6, -4,
-3, -2, -1, 0, 2, 1, 2, 1, 1, 1, 0, -1, -2, -3, -3, -3, -3, -4, -3, -3, -3, -2,
-1, 0, 1, 1, 1, 0, 1, 0, -1, 0, -1, -1, -2, -1, -2, -2, -3, -1, -1, 0, -1, 0, 1,
1, 1, 1, 1, 0, 0, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, 0, 0, 0, 1, 1, 0,
0, 0, 0, -1, 0, 0, -1, 0, -1, -1, -1, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, -1, 0,
-1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
-1, 0, -1, 0, 0, 0, 1, 0, 0, 1, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, -1, -41, -99,
-119, -111, -86, -54, -20, 11, 38, 60, 75, 80, 80, 71, 56, 38, 17, -6, -25, -41,
-53, -58, -59, -53, -43, -30, -14, 1, 15, 28, 36, 40, 39, 35, 28, 17, 7, -5,
-15, -23, -28, -31, -30, -27, -22, -13, -4, 5, 13, 20, 23, 27, 26, 23, 19, 13,
7, 0, -6, -9, -13, -15, -14, -12, -9, -4, 1, 5, 9, 14, 16, 16, 17, 15, 12, 9, 5,
2, -2, -5, -6, -8, -7, -6, -4, -1, 1, 4, 6, 9, 10, 11, 9, 9, 7, 6, 3, 2, -1, -2,
-3, -4, -3, -3, -2, 0, 1, 3, 4, 6, 6, 6, 6, 6, 4, 4, 2, 0, -1, -2, -1, -2, -1,
-2, 0, 0, 0, 1, 2, 3, 3, 3, 4, 4, 3, 2, 2, 1, -1, 0, -1, 0, 0, -1, 0, 1, 0, 1,
1, 2, 2, 3, 3, 2, 2, 1, 2, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 0,
1, 0, 1, 0, 0, 0, 0, -1, 0, -1, 0, 0, 1, 1, 1, 1, 0, 0, 0, 1, 1, 0, 0, 0, 0, 1,
0, 0, 1, -1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0,
0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, };