#define DATA_LENGTH 512
#define DATA AKWF_0204

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 8, 11, 14, 16, 18, 22, 25,
28, 31, 34, 36, 40, 43, 46, 50, 53, 56, 59, 61, 65, 68, 71, 74, 77, 80, 82, 85,
89, 91, 94, 97, 99, 102, 104, 106, 108, 110, 112, 113, 115, 116, 117, 118, 118,
119, 119, 120, 118, 119, 119, 119, 117, 117, 116, 114, 113, 112, 111, 110, 108,
106, 104, 102, 101, 98, 97, 95, 92, 89, 87, 84, 82, 79, 77, 74, 71, 68, 65, 62,
59, 57, 53, 52, 48, 45, 42, 40, 38, 35, 31, 28, 26, 23, 21, 18, 15, 13, 11, 8,
6, 3, 2, -1, -3, -5, -6, -8, -10, -11, -14, -15, -16, -17, -19, -21, -22, -22,
-23, -25, -26, -26, -27, -27, -28, -29, -29, -30, -29, -30, -30, -30, -30, -30,
-29, -30, -30, -29, -30, -29, -29, -28, -28, -27, -27, -26, -26, -25, -25, -25,
-23, -22, -22, -22, -22, -21, -21, -20, -20, -19, -18, -17, -17, -17, -16, -17,
-16, -16, -16, -15, -15, -14, -14, -14, -15, -15, -14, -15, -15, -15, -15, -16,
-16, -17, -17, -18, -18, -18, -18, -19, -20, -20, -22, -22, -22, -23, -24, -25,
-27, -27, -28, -28, -30, -31, -32, -32, -34, -35, -36, -37, -38, -39, -40, -40,
-42, -43, -44, -44, -45, -45, -46, -47, -48, -48, -48, -49, -49, -50, -50, -50,
-51, -51, -51, -51, -51, -51, -50, -50, -49, -48, -48, -48, -47, -45, -44, -44,
-43, -42, -40, -39, -37, -36, -34, -31, -30, -28, -26, -24, -22, -19, -18, -16,
-12, -10, -8, -5, -2, 0, 3, 6, 9, 13, 15, 18, 22, 24, 28, 30, 34, 37, 39, 43,
46, 50, 52, 56, 59, 62, 65, 68, 71, 75, 78, 81, 84, 86, 87, 89, 90, 90, 91, 91,
91, 91, 91, 90, 89, 88, 87, 85, 84, 82, 80, 78, 76, 74, 71, 68, 66, 65, 61, 58,
56, 53, 49, 47, 43, 41, 38, 35, 31, 27, 24, 22, 18, 16, 11, 9, 6, 3, -1, -3, -6,
-9, -12, -14, -17, -20, -22, -26, -27, -30, -32, -34, -36, -39, -41, -43, -44,
-46, -48, -50, -52, -52, -53, -55, -56, -56, -59, -60, -60, -61, -61, -61, -62,
-62, -63, -63, -63, -63, -63, -63, -63, -63, -63, -61, -62, -62, -61, -60, -60,
-59, -59, -57, -57, -56, -55, -55, -53, -52, -51, -51, -50, -49, -49, -47, -47,
-46, -45, -43, -42, -42, -41, -40, -39, -38, -38, -37, -36, -35, -36, -34, -34,
-33, -33, -32, -32, -31, -31, -31, -30, -30, -29, -29, -29, -29, -29, -29, -30,
-29, -29, -29, -30, -29, -30, -30, -31, -31, -32, -31, -33, -33, -34, -34, -35,
-34, -36, -36, -36, -37, -37, -38, -38, -39, -39, -39, -39, -40, -40, -40, -40,
-41, -41, -41, -41, -42, -41, -42, -41, -41, -41, -41, -40, -40, -39, -39, -38,
-38, -36, -35, -34, -35, -33, -31, -30, -29, -27, -25, -24, -23, -21, -19, -16,
-15, -13, -11, -10, -7, -4, -1, };