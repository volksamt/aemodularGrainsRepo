#define DATA_LENGTH 512
#define DATA AKWF_0233

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 4, 6, 7, 8, 10, 10, 12, 12,
14, 16, 17, 19, 20, 20, 22, 23, 25, 26, 28, 29, 31, 31, 33, 34, 35, 35, 37, 38,
40, 41, 42, 43, 44, 46, 47, 48, 48, 50, 52, 53, 54, 55, 56, 57, 59, 59, 60, 62,
63, 64, 65, 66, 67, 69, 69, 71, 72, 73, 73, 75, 76, 77, 78, 79, 80, 81, 82, 82,
84, 85, 87, 87, 88, 90, 89, 92, 92, 93, 93, 94, 96, 96, 98, 99, 100, 100, 102,
103, 103, 105, 106, 106, 107, 108, 109, 110, 110, 112, 113, 113, 113, 115, 115,
115, 116, 116, 116, 118, 117, 118, 118, 119, 118, 118, 119, 120, 119, 119, 119,
119, 119, 119, 118, 119, 119, 118, 118, 118, 118, 118, 117, 116, 117, 117, 116,
115, 115, 114, 114, 114, 113, 113, 112, 111, 111, 111, 109, 110, 109, 108, 108,
107, 106, 106, 105, 105, 103, 103, 103, 102, 101, 100, 100, 99, 98, 98, 97, 95,
96, 95, 94, 92, 91, 91, 91, 89, 89, 87, 87, 86, 85, 84, 83, 82, 81, 80, 80, 79,
77, 77, 76, 75, 74, 73, 72, 70, 70, 68, 67, 67, 66, 64, 63, 62, 61, 61, 59, 57,
57, 55, 54, 53, 52, 51, 50, 48, 47, 47, 45, 44, 43, 41, 40, 39, 38, 37, 36, 34,
32, 32, 30, 29, 27, 26, 25, 24, 22, 20, 19, 18, 17, 15, 14, 12, 12, 10, 8, 8, 6,
5, 3, 2, 1, 0, -2, -4, -4, -5, -7, -8, -9, -12, -13, -13, -15, -16, -17, -18,
-20, -22, -23, -24, -25, -26, -28, -28, -31, -31, -32, -33, -35, -36, -38, -38,
-39, -40, -42, -44, -45, -45, -47, -48, -49, -51, -51, -54, -54, -55, -56, -57,
-59, -60, -61, -61, -63, -65, -66, -66, -67, -68, -70, -71, -71, -73, -74, -75,
-76, -78, -79, -79, -81, -81, -82, -84, -84, -86, -87, -88, -88, -90, -90, -92,
-92, -93, -94, -94, -96, -98, -97, -98, -100, -101, -102, -103, -104, -104,
-105, -107, -107, -108, -109, -109, -111, -112, -113, -113, -114, -114, -115,
-116, -116, -117, -118, -118, -118, -117, -118, -118, -119, -119, -118, -119,
-119, -119, -119, -120, -119, -119, -119, -118, -118, -118, -119, -117, -117,
-118, -117, -116, -116, -116, -115, -115, -115, -114, -114, -113, -112, -113,
-112, -112, -110, -111, -110, -110, -109, -108, -108, -107, -106, -107, -105,
-104, -103, -103, -103, -102, -101, -100, -100, -99, -98, -97, -97, -96, -95,
-94, -94, -93, -91, -91, -90, -90, -88, -87, -87, -86, -84, -84, -84, -82, -81,
-80, -80, -79, -78, -76, -75, -75, -74, -73, -71, -71, -70, -69, -68, -67, -65,
-65, -63, -62, -61, -60, -59, -57, -56, -56, -55, -53, -52, -51, -50, -48, -48,
-46, -44, -44, -43, -41, -40, -38, -38, -36, -35, -33, -32, -31, -29, -29, -27,
-26, -24, -23, -22, -20, -19, -18, -17, -15, -13, -13, -12, -10, -9, -8, -6, -5,
-4, -2, -1, };