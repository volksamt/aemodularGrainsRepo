#define DATA_LENGTH 512
#define DATA AKWF_0279

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 17, 24, 30, 35, 41, 46, 51, 58,
63, 68, 73, 77, 82, 85, 91, 94, 97, 100, 103, 106, 108, 110, 112, 113, 115, 116,
117, 118, 118, 118, 119, 119, 119, 119, 118, 118, 116, 115, 114, 112, 111, 109,
106, 104, 103, 101, 98, 96, 94, 91, 89, 86, 83, 82, 79, 76, 73, 71, 67, 64, 61,
57, 54, 50, 48, 45, 41, 37, 33, 29, 27, 21, 15, 9, 3, -2, -8, -13, -19, -24,
-28, -33, -38, -44, -47, -52, -57, -62, -66, -71, -75, -78, -83, -85, -89, -92,
-94, -95, -98, -100, -102, -103, -105, -106, -107, -107, -107, -108, -108, -109,
-107, -108, -107, -107, -106, -104, -103, -102, -102, -100, -99, -97, -94, -94,
-92, -90, -88, -86, -84, -82, -79, -78, -75, -72, -70, -68, -66, -62, -60, -58,
-55, -52, -48, -46, -43, -40, -38, -35, -32, -30, -28, -26, -23, -20, -18, -16,
-12, -9, -6, -1, 2, 6, 10, 14, 19, 22, 26, 31, 34, 37, 42, 45, 49, 51, 54, 57,
59, 61, 64, 66, 68, 69, 70, 71, 72, 73, 73, 73, 72, 72, 71, 70, 68, 67, 64, 62,
60, 56, 52, 48, 44, 39, 33, 29, 23, 19, 15, 11, 7, 2, -1, -4, -7, -10, -14, -17,
-20, -23, -26, -29, -31, -34, -37, -38, -40, -41, -43, -44, -45, -47, -47, -49,
-49, -50, -49, -50, -49, -49, -47, -48, -46, -44, -43, -41, -39, -36, -33, -30,
-27, -24, -19, -15, -10, -6, -1, 4, 9, 14, 18, 24, 27, 32, 37, 40, 44, 47, 50,
53, 57, 60, 62, 64, 66, 69, 70, 71, 72, 74, 75, 75, 76, 77, 77, 78, 77, 78, 78,
79, 78, 78, 77, 75, 74, 74, 73, 72, 71, 69, 67, 65, 64, 62, 61, 59, 57, 54, 53,
51, 49, 45, 43, 42, 39, 37, 35, 32, 29, 27, 24, 21, 19, 16, 14, 12, 10, 7, 5, 1,
-1, -5, -8, -12, -16, -19, -22, -26, -29, -34, -36, -39, -42, -46, -48, -51,
-53, -56, -57, -60, -62, -64, -65, -67, -67, -69, -69, -70, -69, -70, -71, -71,
-70, -70, -70, -69, -69, -68, -68, -67, -66, -64, -63, -61, -60, -58, -55, -54,
-52, -50, -46, -44, -41, -39, -35, -32, -28, -23, -20, -15, -11, -7, -2, 2, 7,
10, 15, 18, 22, 25, 28, 31, 35, 38, 41, 44, 46, 49, 51, 54, 56, 58, 59, 61, 61,
63, 63, 63, 65, 65, 65, 65, 64, 65, 64, 63, 63, 62, 61, 59, 58, 56, 55, 53, 50,
48, 46, 42, 39, 36, 32, 27, 23, 17, 12, 6, -1, -6, -12, -18, -22, -27, -32, -37,
-40, -46, -49, -53, -57, -61, -65, -68, -72, -74, -77, -79, -82, -84, -86, -87,
-88, -90, -91, -93, -92, -94, -94, -93, -95, -94, -94, -93, -93, -91, -90, -89,
-87, -86, -84, -83, -82, -79, -77, -76, -72, -70, -68, -65, -63, -60, -57, -54,
-51, -47, -44, -40, -36, -31, -24, -17, -9, -2, };