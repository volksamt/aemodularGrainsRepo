#define DATA_LENGTH 512
#define DATA AKWF_0300

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 17, 22, 26, 31, 35, 38, 41,
45, 47, 50, 53, 55, 57, 59, 61, 63, 64, 65, 67, 69, 69, 70, 70, 71, 72, 71, 71,
72, 71, 70, 69, 68, 68, 67, 65, 64, 63, 63, 61, 59, 58, 56, 54, 52, 51, 49, 48,
45, 44, 42, 40, 38, 36, 35, 32, 30, 28, 26, 25, 22, 21, 19, 18, 16, 13, 12, 10,
8, 7, 6, 5, 3, 2, 1, -1, -2, -3, -4, -5, -7, -7, -8, -8, -10, -10, -11, -12,
-12, -13, -14, -14, -15, -14, -15, -15, -16, -16, -16, -15, -16, -16, -15, -16,
-15, -16, -16, -16, -15, -14, -15, -14, -15, -14, -13, -14, -13, -13, -12, -12,
-11, -11, -11, -11, -10, -10, -9, -8, -8, -8, -7, -6, -6, -6, -5, -5, -5, -5,
-4, -3, -3, -2, -2, -2, -2, -1, -1, -1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 2, 2, 2, 2,
3, 3, 3, 3, 3, 3, 4, 4, 4, 3, 3, 4, 4, 3, 3, 3, 4, 3, 4, 3, 3, 3, 3, 3, 3, 3, 4,
4, 2, 2, 4, 3, 2, 3, 2, 3, 2, 2, 3, 2, 2, 2, 2, 1, 2, 2, 1, 1, 1, 2, 1, 1, 1, 1,
0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, -1, -1, -1, 0, -1,
-1, 0, 0, -1, -1, -1, 0, -1, -1, -2, -1, -1, -1, -1, -2, -2, -1, -1, 0, -1, -1,
0, 0, -1, 0, 0, -1, -1, 0, -1, 0, 0, 0, 0, -1, 0, 0, -1, -1, -1, 0, 0, 0, 0, -1,
0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 1, -1, 0,
0, 0, 0, -1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 1,
-1, 0, 0, 0, 0, 0, 1, 0, -1, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 1, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, -1, 0, -1, 0,
0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0,
0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0, 0, 0, -1, 0, -1, -1,
0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0,
0, -1, -5, -10, -15, -22, -33, -43, -54, -65, -76, -87, -96, -104, -111, -115,
-118, -119, -118, -116, -113, -108, -103, -97, -92, -87, -82, -78, -72, -69,
-65, -60, -57, -54, -50, -44, -40, -36, -31, -25, -19, -14, -9, -3, };