#define DATA_LENGTH 512
#define DATA AKWF_0258

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 23, 35, 46, 57, 66, 70, 72, 72, 71,
70, 68, 66, 65, 62, 61, 58, 57, 55, 53, 52, 49, 49, 48, 46, 44, 44, 42, 42, 40,
39, 38, 38, 37, 37, 37, 37, 36, 35, 35, 34, 34, 34, 35, 35, 35, 35, 35, 36, 36,
37, 37, 39, 38, 39, 39, 41, 41, 43, 44, 45, 46, 47, 48, 49, 50, 51, 53, 54, 55,
57, 59, 59, 61, 62, 63, 65, 67, 67, 70, 71, 72, 73, 76, 76, 78, 79, 82, 81, 84,
86, 86, 88, 89, 91, 93, 92, 94, 95, 96, 97, 99, 100, 101, 102, 103, 105, 106,
107, 107, 108, 109, 110, 111, 112, 112, 114, 114, 115, 114, 115, 117, 116, 117,
117, 118, 118, 118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119,
119, 118, 118, 119, 118, 117, 116, 117, 116, 116, 116, 115, 115, 114, 114, 113,
112, 111, 111, 110, 110, 109, 109, 108, 107, 106, 106, 105, 105, 104, 103, 102,
101, 101, 100, 99, 99, 98, 97, 97, 96, 95, 94, 93, 94, 93, 92, 91, 90, 90, 89,
89, 88, 87, 87, 87, 86, 85, 85, 84, 85, 83, 83, 82, 82, 82, 82, 80, 80, 81, 80,
80, 80, 80, 79, 79, 79, 78, 79, 78, 78, 78, 78, 78, 78, 78, 78, 78, 77, 78, 78,
77, 79, 78, 78, 78, 79, 79, 78, 80, 79, 77, 69, 57, 44, 30, 15, 2, -12, -25,
-37, -48, -58, -68, -74, -76, -77, -76, -76, -74, -71, -70, -67, -66, -64, -61,
-60, -59, -56, -55, -53, -52, -50, -49, -47, -46, -45, -44, -44, -42, -42, -41,
-41, -39, -39, -38, -38, -38, -37, -37, -37, -37, -36, -36, -37, -38, -37, -38,
-39, -38, -39, -40, -41, -40, -42, -42, -42, -44, -45, -46, -47, -48, -49, -50,
-50, -52, -53, -54, -56, -56, -59, -59, -60, -61, -63, -65, -67, -68, -69, -70,
-72, -73, -74, -75, -77, -79, -80, -81, -84, -84, -85, -87, -88, -90, -90, -91,
-93, -94, -95, -96, -98, -99, -100, -101, -102, -104, -104, -105, -106, -106,
-108, -108, -110, -110, -110, -111, -112, -113, -114, -114, -115, -115, -115,
-116, -116, -116, -117, -118, -117, -118, -118, -117, -118, -119, -117, -118,
-118, -118, -118, -117, -117, -117, -116, -117, -116, -116, -115, -115, -115,
-115, -114, -114, -113, -113, -112, -112, -112, -110, -110, -109, -109, -109,
-108, -108, -106, -106, -105, -104, -104, -103, -103, -102, -100, -100, -99,
-99, -99, -97, -97, -96, -95, -95, -94, -94, -93, -93, -92, -91, -91, -90, -90,
-88, -88, -88, -88, -87, -87, -86, -85, -84, -84, -84, -82, -83, -83, -82, -83,
-81, -81, -81, -80, -81, -81, -80, -79, -79, -79, -79, -78, -79, -79, -78, -78,
-78, -78, -78, -78, -77, -78, -78, -79, -78, -79, -78, -79, -79, -79, -79, -79,
-79, -80, -80, -80, -80, -80, -80, -81, -81, -81, -81, -82, -83, -82, -83, -82,
-79, -71, -58, -44, -31, -15, -1, };