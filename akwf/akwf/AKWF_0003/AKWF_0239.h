#define DATA_LENGTH 512
#define DATA AKWF_0239

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 2, 3, 4, 4, 5, 5, 7, 8, 9, 8,
9, 10, 10, 11, 12, 13, 13, 14, 15, 15, 16, 17, 18, 18, 18, 19, 21, 20, 22, 22,
23, 24, 25, 26, 27, 26, 27, 28, 29, 29, 30, 31, 31, 32, 34, 34, 34, 35, 35, 36,
37, 39, 39, 39, 41, 40, 42, 43, 43, 43, 44, 45, 45, 46, 48, 48, 48, 49, 50, 50,
51, 52, 53, 52, 54, 55, 56, 56, 56, 57, 58, 59, 59, 60, 61, 62, 62, 63, 64, 64,
65, 66, 66, 67, 68, 68, 69, 69, 71, 71, 73, 73, 73, 73, 74, 75, 76, 77, 78, 79,
79, 79, 81, 81, 81, 83, 83, 84, 85, 85, 86, 86, 87, 88, 89, 90, 90, 91, 92, 91,
88, 88, 87, 83, 81, 79, 78, 76, 74, 72, 69, 67, 65, 61, 59, 57, 54, 52, 51, 48,
47, 45, 43, 42, 41, 40, 38, 38, 37, 37, 36, 36, 36, 36, 36, 36, 37, 37, 38, 38,
39, 39, 39, 40, 41, 42, 44, 44, 45, 46, 48, 48, 49, 50, 51, 52, 54, 55, 57, 58,
59, 60, 61, 63, 64, 65, 67, 67, 69, 70, 71, 73, 74, 76, 77, 78, 80, 81, 83, 85,
86, 86, 89, 90, 90, 93, 94, 95, 97, 98, 100, 100, 102, 103, 106, 105, 107, 109,
111, 112, 114, 115, 116, 117, 119, 112, 105, 106, 100, 93, 85, 80, 74, 68, 61,
53, 46, 37, 29, 21, 12, 4, -5, -11, -19, -26, -33, -39, -45, -51, -56, -60, -64,
-69, -72, -76, -79, -81, -84, -85, -87, -90, -90, -92, -93, -94, -94, -95, -95,
-96, -95, -95, -95, -96, -94, -94, -94, -94, -93, -91, -91, -91, -89, -88, -87,
-86, -86, -85, -83, -83, -81, -80, -78, -78, -76, -74, -74, -73, -71, -70, -69,
-68, -66, -65, -64, -62, -61, -60, -57, -57, -55, -54, -52, -50, -49, -48, -47,
-45, -44, -43, -42, -40, -39, -37, -35, -34, -33, -32, -30, -32, -33, -32, -33,
-35, -36, -38, -39, -41, -43, -44, -47, -48, -51, -53, -55, -58, -60, -63, -64,
-67, -69, -70, -72, -73, -75, -76, -78, -78, -79, -80, -80, -81, -82, -83, -83,
-83, -83, -83, -83, -84, -83, -83, -83, -84, -83, -83, -82, -82, -81, -81, -81,
-80, -79, -79, -79, -78, -77, -77, -77, -76, -75, -74, -74, -74, -73, -73, -72,
-71, -70, -70, -70, -69, -68, -67, -67, -65, -65, -65, -64, -63, -64, -62, -61,
-61, -60, -60, -59, -57, -57, -56, -56, -55, -54, -53, -53, -52, -51, -51, -50,
-49, -49, -49, -47, -46, -46, -45, -45, -44, -42, -42, -42, -41, -41, -40, -39,
-38, -38, -37, -36, -36, -35, -34, -33, -32, -32, -31, -31, -30, -29, -28, -28,
-27, -27, -25, -25, -23, -23, -22, -22, -22, -21, -21, -19, -19, -18, -16, -16,
-16, -14, -14, -14, -13, -13, -11, -10, -11, -9, -8, -8, -7, -7, -6, -6, -4, -3,
-3, -2, -2, 0, };