#define DATA_LENGTH 512
#define DATA AKWF_0202

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 11, 15, 18, 21, 24, 27, 30,
33, 36, 39, 42, 46, 48, 51, 54, 57, 59, 62, 65, 68, 71, 74, 76, 79, 82, 84, 86,
89, 92, 93, 95, 97, 99, 101, 103, 104, 106, 108, 109, 111, 112, 113, 113, 115,
116, 117, 117, 118, 118, 119, 119, 119, 119, 120, 119, 119, 119, 117, 118, 116,
115, 114, 113, 113, 110, 109, 109, 107, 105, 103, 102, 100, 97, 96, 94, 91, 89,
86, 83, 82, 80, 76, 73, 71, 67, 65, 62, 60, 56, 53, 50, 47, 44, 41, 38, 35, 31,
29, 25, 22, 19, 16, 12, 9, 6, 3, 0, -3, -5, -8, -12, -14, -17, -20, -22, -26,
-29, -29, -26, -15, -6, 2, 10, 16, 23, 28, 33, 38, 40, 44, 47, 50, 52, 53, 54,
55, 56, 57, 56, 56, 55, 55, 54, 54, 53, 51, 49, 48, 46, 44, 42, 40, 36, 35, 32,
30, 27, 24, 22, 18, 15, 13, 9, 6, 3, 0, -2, -7, -10, -13, -16, -19, -23, -26,
-29, -32, -36, -39, -42, -44, -49, -52, -55, -58, -60, -63, -66, -68, -72, -75,
-76, -78, -81, -84, -86, -88, -90, -93, -94, -96, -97, -99, -100, -102, -104,
-104, -105, -107, -108, -109, -110, -110, -111, -111, -111, -112, -112, -112,
-111, -111, -111, -110, -110, -110, -108, -108, -107, -106, -105, -104, -102,
-100, -99, -98, -96, -94, -92, -91, -89, -86, -84, -83, -79, -77, -75, -72, -71,
-68, -65, -63, -60, -57, -55, -52, -49, -47, -44, -40, -38, -36, -33, -31, -27,
-24, -21, -19, -16, -13, -10, -8, -4, -3, 0, 3, 5, 8, 10, 12, 15, 16, 19, 21,
23, 25, 27, 29, 31, 32, 34, 34, 36, 38, 40, 40, 42, 42, 43, 44, 45, 45, 46, 46,
46, 46, 47, 47, 48, 47, 47, 47, 46, 46, 45, 45, 44, 43, 43, 41, 40, 40, 38, 37,
35, 35, 32, 31, 29, 28, 26, 24, 23, 21, 18, 18, 15, 13, 11, 9, 7, 4, 2, 0, -2,
-4, -6, -9, -10, -13, -14, -17, -19, -21, -24, -26, -28, -30, -32, -33, -36,
-38, -39, -41, -43, -45, -47, -48, -49, -51, -52, -53, -54, -56, -56, -57, -53,
-45, -39, -34, -27, -22, -17, -13, -8, -4, -2, 2, 4, 7, 9, 12, 13, 15, 17, 19,
19, 19, 21, 20, 21, 22, 22, 21, 22, 22, 22, 21, 21, 19, 20, 19, 17, 16, 15, 14,
14, 12, 10, 9, 7, 6, 5, 3, 1, -1, -3, -5, -6, -9, -10, -11, -14, -16, -17, -19,
-21, -23, -26, -27, -29, -31, -34, -35, -36, -38, -41, -42, -44, -45, -47, -48,
-50, -52, -52, -54, -54, -56, -57, -58, -59, -59, -60, -61, -62, -63, -63, -63,
-64, -65, -64, -64, -65, -65, -64, -64, -64, -62, -63, -61, -61, -60, -59, -58,
-57, -55, -54, -53, -52, -50, -48, -46, -44, -43, -40, -38, -37, -34, -31, -30,
-27, -25, -22, -19, -17, -14, -12, -9, -6, -2, -1, };