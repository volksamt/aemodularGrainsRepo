#define DATA_LENGTH 512
#define DATA AKWF_0224

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 8, 11, 13, 15, 16, 19, 21,
23, 25, 26, 28, 31, 33, 35, 37, 39, 40, 43, 45, 46, 49, 51, 52, 54, 56, 56, 59,
61, 62, 64, 67, 67, 70, 70, 73, 75, 75, 77, 78, 79, 81, 82, 84, 85, 86, 88, 89,
91, 92, 92, 94, 94, 96, 96, 98, 99, 100, 100, 101, 103, 102, 104, 105, 105, 106,
107, 108, 108, 109, 110, 110, 110, 111, 112, 113, 112, 112, 113, 114, 114, 115,
115, 115, 116, 116, 117, 117, 116, 117, 117, 118, 118, 118, 118, 118, 118, 119,
119, 119, 119, 119, 120, 119, 119, 119, 119, 120, 119, 119, 120, 120, 119, 119,
119, 119, 119, 118, 119, 119, 118, 118, 118, 118, 118, 118, 118, 117, 118, 117,
117, 117, 117, 116, 117, 117, 117, 117, 116, 115, 115, 116, 116, 114, 114, 115,
114, 114, 114, 113, 112, 112, 112, 112, 112, 112, 111, 110, 110, 109, 109, 109,
108, 108, 107, 107, 106, 106, 106, 106, 104, 105, 104, 103, 103, 102, 102, 100,
100, 99, 100, 98, 97, 96, 96, 96, 94, 94, 93, 92, 92, 91, 90, 90, 88, 87, 87,
86, 85, 85, 83, 81, 81, 79, 79, 77, 77, 75, 74, 74, 72, 71, 70, 69, 67, 66, 65,
63, 61, 61, 58, 58, 56, 54, 53, 51, 50, 49, 46, 45, 43, 41, 40, 39, 36, 35, 33,
31, 29, 27, 26, 23, 22, 20, 18, 16, 14, 11, 10, 7, 6, 3, 2, 0, -2, -4, -7, -8,
-10, -13, -14, -17, -18, -21, -23, -24, -26, -29, -31, -33, -35, -37, -39, -40,
-43, -45, -46, -49, -50, -52, -54, -56, -58, -59, -62, -62, -65, -66, -67, -68,
-71, -72, -74, -76, -77, -78, -81, -82, -82, -83, -85, -86, -88, -89, -91, -91,
-93, -93, -95, -96, -96, -98, -99, -100, -101, -101, -103, -103, -103, -105,
-105, -107, -107, -108, -108, -109, -110, -110, -111, -111, -112, -112, -113,
-114, -113, -114, -115, -115, -115, -116, -115, -116, -116, -116, -117, -117,
-117, -117, -118, -118, -118, -118, -119, -119, -118, -118, -119, -119, -119,
-119, -119, -118, -119, -120, -119, -119, -119, -118, -119, -119, -118, -119,
-118, -119, -119, -118, -118, -119, -119, -119, -118, -117, -117, -118, -118,
-117, -117, -117, -117, -117, -116, -116, -117, -115, -116, -115, -115, -116,
-114, -115, -115, -115, -113, -114, -112, -112, -113, -112, -111, -111, -111,
-111, -111, -110, -110, -110, -109, -109, -109, -108, -107, -107, -106, -106,
-106, -105, -105, -104, -103, -103, -102, -102, -101, -101, -99, -100, -98, -98,
-97, -97, -96, -95, -94, -94, -93, -92, -92, -91, -90, -89, -89, -87, -86, -86,
-85, -84, -82, -82, -81, -79, -79, -78, -77, -75, -74, -73, -72, -71, -69, -68,
-67, -66, -64, -64, -61, -60, -59, -57, -56, -54, -53, -51, -49, -47, -46, -44,
-42, -41, -39, -38, -36, -34, -33, -31, -29, -27, -25, -23, -21, -19, -18, -16,
-13, -12, -10, -7, -6, -3, -1, };