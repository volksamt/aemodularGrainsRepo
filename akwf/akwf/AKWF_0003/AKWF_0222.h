#define DATA_LENGTH 512
#define DATA AKWF_0222

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 3, 4, 5, 5, 6, 7, 7, 7, 8, 8,
9, 9, 9, 10, 9, 9, 9, 10, 10, 10, 10, 10, 10, 11, 11, 10, 10, 11, 10, 11, 11,
10, 10, 10, 10, 11, 10, 10, 11, 11, 11, 10, 10, 11, 10, 11, 11, 11, 11, 12, 12,
12, 12, 12, 13, 14, 13, 14, 13, 14, 15, 15, 16, 16, 16, 17, 18, 17, 19, 19, 20,
20, 20, 21, 21, 22, 23, 24, 24, 25, 27, 27, 27, 28, 29, 30, 30, 31, 32, 33, 33,
35, 35, 36, 37, 38, 40, 40, 40, 41, 43, 44, 44, 46, 46, 47, 48, 49, 50, 51, 52,
53, 54, 55, 56, 58, 60, 60, 61, 63, 64, 64, 66, 67, 68, 69, 71, 72, 73, 74, 75,
77, 78, 79, 80, 81, 83, 84, 85, 86, 88, 88, 90, 91, 92, 93, 95, 96, 97, 98, 99,
100, 102, 102, 104, 104, 105, 107, 107, 108, 109, 110, 110, 111, 112, 113, 114,
114, 115, 115, 116, 116, 117, 117, 118, 118, 119, 119, 118, 118, 120, 119, 119,
119, 119, 118, 118, 118, 118, 118, 117, 117, 116, 115, 115, 114, 112, 113, 112,
111, 110, 108, 108, 106, 104, 104, 102, 100, 99, 98, 96, 94, 92, 91, 89, 88, 85,
84, 81, 79, 77, 75, 73, 71, 68, 66, 64, 61, 59, 56, 54, 51, 48, 47, 44, 41, 39,
37, 33, 32, 29, 26, 24, 21, 19, 16, 15, 12, 10, 6, 4, 3, 0, -2, -4, -7, -8, -10,
-13, -16, -17, -19, -20, -21, -24, -25, -28, -29, -30, -31, -33, -33, -35, -37,
-38, -39, -40, -41, -42, -44, -44, -44, -46, -47, -47, -48, -48, -49, -50, -50,
-51, -51, -52, -52, -52, -52, -53, -54, -54, -54, -54, -54, -54, -55, -55, -56,
-56, -56, -56, -56, -57, -57, -57, -58, -57, -57, -58, -57, -58, -58, -58, -58,
-59, -59, -60, -60, -59, -60, -60, -60, -60, -60, -61, -60, -60, -61, -61, -62,
-62, -62, -62, -61, -63, -62, -62, -63, -63, -63, -63, -64, -63, -63, -65, -63,
-64, -65, -64, -65, -65, -64, -64, -64, -66, -65, -66, -66, -65, -66, -66, -67,
-66, -67, -67, -67, -67, -67, -67, -68, -68, -67, -68, -68, -68, -69, -69, -70,
-69, -70, -70, -70, -70, -71, -71, -71, -71, -71, -72, -72, -72, -73, -73, -73,
-74, -74, -74, -74, -74, -74, -74, -75, -75, -75, -75, -75, -77, -77, -77, -76,
-76, -77, -77, -77, -78, -78, -77, -78, -78, -78, -78, -78, -78, -77, -77, -78,
-77, -77, -77, -77, -77, -76, -76, -75, -75, -75, -74, -73, -73, -73, -73, -71,
-71, -71, -70, -69, -68, -67, -66, -65, -65, -64, -63, -61, -61, -59, -58, -57,
-56, -55, -53, -52, -51, -49, -49, -46, -45, -44, -43, -41, -39, -38, -37, -35,
-34, -32, -31, -29, -27, -27, -25, -23, -23, -20, -19, -18, -17, -14, -13, -12,
-11, -9, -8, -8, -6, -5, -5, -3, -2, -1, 0, };