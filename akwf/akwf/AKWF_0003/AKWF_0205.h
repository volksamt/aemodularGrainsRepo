#define DATA_LENGTH 512
#define DATA AKWF_0205

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 2, 4, 4, 4, 6, 6, 6, 7, 8, 9,
10, 11, 11, 12, 12, 12, 12, 14, 13, 14, 13, 13, 14, 14, 13, 14, 14, 15, 15, 15,
16, 16, 17, 19, 19, 20, 22, 22, 22, 24, 25, 27, 27, 29, 31, 32, 34, 35, 37, 38,
40, 41, 43, 45, 46, 47, 48, 49, 51, 52, 54, 55, 57, 58, 59, 61, 62, 64, 66, 67,
68, 69, 71, 72, 74, 75, 75, 77, 78, 80, 80, 81, 83, 83, 83, 85, 86, 86, 87, 88,
89, 89, 90, 91, 92, 92, 92, 94, 93, 94, 95, 95, 96, 96, 96, 97, 98, 97, 98, 98,
98, 99, 99, 99, 99, 100, 100, 101, 100, 101, 100, 101, 101, 100, 100, 100, 101,
101, 100, 101, 99, 99, 100, 100, 100, 100, 100, 99, 99, 99, 100, 92, 92, 91, 92,
87, 82, 84, 83, 83, 83, 84, 84, 84, 83, 83, 83, 83, 83, 82, 83, 82, 82, 82, 81,
82, 81, 80, 81, 80, 80, 79, 78, 78, 77, 77, 73, 69, 71, 67, 72, 75, 74, 73, 72,
71, 70, 69, 66, 66, 65, 63, 62, 60, 59, 58, 56, 55, 54, 53, 51, 50, 49, 48, 46,
45, 52, 52, 50, 49, 49, 49, 48, 46, 45, 46, 45, 44, 43, 43, 43, 42, 42, 42, 39,
35, 33, 29, 27, 23, 21, 18, 15, 12, 9, 6, 3, 1, -4, 0, 0, -5, -7, -10, -12, -16,
-18, -21, -24, -27, -29, -31, -32, -35, -38, -40, -45, -48, -52, -54, -57, -60,
-64, -67, -70, -74, -76, -79, -82, -85, -87, -91, -92, -96, -98, -101, -104,
-105, -107, -109, -111, -113, -114, -115, -116, -117, -118, -118, -119, -118,
-119, -118, -119, -119, -119, -115, -109, -109, -108, -108, -107, -106, -106,
-105, -103, -103, -108, -105, -105, -104, -103, -103, -101, -102, -101, -105,
-106, -104, -105, -105, -104, -104, -104, -103, -104, -104, -104, -104, -103,
-103, -101, -102, -101, -105, -106, -105, -105, -104, -103, -103, -101, -101,
-101, -100, -99, -98, -97, -97, -96, -95, -94, -94, -93, -92, -91, -90, -90,
-89, -88, -88, -86, -86, -86, -84, -83, -83, -83, -83, -82, -80, -80, -79, -79,
-78, -78, -78, -77, -77, -75, -76, -74, -74, -74, -73, -72, -71, -72, -71, -71,
-69, -70, -69, -75, -75, -75, -74, -74, -73, -72, -71, -70, -69, -70, -68, -67,
-67, -66, -64, -63, -62, -62, -62, -60, -59, -59, -58, -57, -57, -56, -55, -54,
-53, -53, -52, -51, -51, -50, -49, -48, -48, -48, -47, -46, -45, -46, -46, -45,
-45, -45, -45, -45, -45, -46, -46, -46, -46, -47, -47, -47, -47, -48, -49, -47,
-50, -45, -43, -43, -43, -44, -44, -44, -43, -43, -44, -44, -43, -43, -42, -42,
-41, -41, -40, -40, -39, -38, -38, -37, -36, -30, -29, -28, -28, -26, -26, -26,
-24, -23, -22, -23, -17, -13, -14, -12, -11, -10, -10, -8, -8, -6, -6, -5, -4,
-3, -2, -1, -1, -1, -1, 0, };