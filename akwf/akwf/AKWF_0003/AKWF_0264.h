#define DATA_LENGTH 512
#define DATA AKWF_0264

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -1, -3, -7, -8, -9, -12, -13, -16,
-17, -18, -20, -21, -23, -26, -26, -28, -30, -31, -33, -34, -36, -36, -38, -41,
-41, -43, -44, -45, -46, -48, -48, -50, -51, -52, -52, -54, -55, -56, -57, -57,
-58, -59, -59, -61, -62, -63, -63, -64, -64, -59, -55, -53, -55, -56, -54, -52,
-50, -50, -49, -49, -50, -51, -52, -54, -54, -54, -54, -55, -56, -55, -56, -56,
-57, -57, -57, -57, -58, -58, -58, -58, -58, -59, -59, -59, -59, -58, -59, -59,
-59, -58, -58, -59, -58, -59, -58, -58, -58, -58, -57, -57, -56, -56, -56, -55,
-56, -56, -55, -54, -54, -54, -53, -53, -52, -52, -52, -51, -51, -51, -51, -49,
-54, -70, -82, -83, -80, -82, -88, -94, -99, -101, -102, -101, -98, -96, -94,
-91, -90, -87, -86, -84, -83, -82, -80, -79, -77, -76, -74, -73, -72, -70, -69,
-67, -65, -64, -62, -60, -59, -57, -55, -54, -52, -51, -49, -47, -46, -45, -42,
-42, -41, -39, -38, -35, -33, -32, -30, -29, -28, -27, -24, -23, -22, -20, -18,
-17, -16, -14, -13, -11, -13, -33, -55, -59, -54, -54, -61, -70, -77, -81, -83,
-81, -78, -74, -70, -66, -62, -59, -58, -55, -53, -51, -49, -47, -44, -42, -40,
-38, -36, -33, -30, -29, -27, -25, -22, -20, -19, -16, -15, -12, -11, -9, -6,
-4, -2, 0, 2, 4, 6, 7, 9, 11, 12, 15, 16, 18, 19, 20, 23, 25, 26, 27, 29, 30,
32, 34, 34, 36, 37, 38, 40, 41, 43, 44, 45, 46, 47, 48, 49, 50, 51, 53, 50, 40,
31, 31, 34, 33, 30, 25, 22, 21, 21, 21, 23, 25, 26, 28, 31, 31, 32, 34, 34, 36,
35, 37, 38, 39, 40, 40, 42, 42, 43, 44, 45, 44, 46, 46, 46, 47, 48, 48, 49, 49,
50, 50, 51, 52, 52, 52, 53, 53, 53, 54, 54, 53, 54, 55, 55, 55, 55, 56, 56, 55,
56, 55, 56, 56, 56, 56, 56, 56, 55, 55, 55, 55, 54, 55, 54, 54, 53, 53, 53, 53,
52, 53, 51, 52, 52, 52, 51, 50, 51, 50, 50, 50, 49, 48, 48, 47, 47, 47, 47, 46,
46, 45, 45, 45, 44, 43, 43, 42, 40, 40, 39, 40, 39, 39, 38, 38, 36, 36, 36, 35,
35, 34, 34, 32, 32, 31, 31, 30, 28, 29, 28, 28, 27, 26, 26, 43, 73, 85, 82, 80,
86, 97, 108, 116, 119, 119, 116, 113, 109, 105, 101, 99, 96, 94, 92, 90, 88, 86,
85, 83, 81, 80, 77, 74, 72, 71, 69, 66, 64, 61, 59, 57, 56, 53, 51, 50, 48, 46,
43, 42, 39, 37, 35, 33, 32, 29, 27, 26, 23, 22, 20, 18, 16, 15, 13, 10, 8, 8, 6,
4, 1, 1, -1, -3, -5, -7, -8, -10, -12, -12, -15, -15, -17, -18, -20, -22, -21,
-11, 8, 13, 9, 8, 12, 19, 25, 28, 29, 28, 26, 24, 20, 17, 14, 11, 9, 7, 6, 4, 2,
};