#define DATA_LENGTH 512
#define DATA AKWF_0256

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 7, 10, 14, 16, 19, 21, 24, 27,
30, 32, 34, 38, 39, 43, 45, 47, 50, 53, 54, 57, 59, 61, 64, 66, 68, 70, 73, 74,
76, 78, 80, 82, 84, 86, 87, 89, 91, 92, 94, 96, 98, 98, 100, 101, 102, 105, 104,
107, 107, 109, 110, 111, 112, 112, 113, 113, 115, 115, 115, 116, 116, 117, 118,
117, 119, 119, 119, 118, 118, 118, 117, 117, 117, 116, 116, 115, 115, 113, 113,
112, 111, 110, 110, 108, 107, 105, 103, 102, 101, 99, 97, 96, 94, 92, 90, 88,
86, 84, 82, 79, 77, 75, 72, 69, 68, 65, 62, 59, 57, 54, 52, 48, 46, 42, 40, 36,
34, 31, 28, 26, 22, 19, 16, 13, 10, 7, 3, 2, -2, -5, -8, -11, -15, -17, -20,
-23, -26, -29, -32, -35, -37, -40, -43, -46, -48, -50, -54, -56, -60, -61, -64,
-67, -68, -71, -72, -75, -77, -78, -81, -83, -84, -87, -88, -89, -91, -93, -94,
-96, -96, -97, -98, -99, -101, -101, -101, -103, -104, -104, -104, -104, -105,
-105, -106, -105, -106, -106, -106, -107, -106, -105, -105, -104, -104, -103,
-104, -103, -103, -101, -101, -100, -99, -98, -97, -96, -95, -94, -93, -91, -91,
-89, -87, -86, -86, -83, -82, -81, -79, -78, -77, -74, -73, -72, -69, -69, -67,
-64, -63, -61, -59, -58, -56, -54, -52, -50, -49, -47, -45, -43, -40, -39, -36,
-34, -33, -31, -28, -26, -24, -23, -19, -18, -16, -14, -13, -10, -9, -6, -3, -2,
1, 2, 5, 7, 8, 11, 12, 15, 17, 18, 20, 22, 25, 26, 28, 30, 32, 34, 36, 38, 39,
42, 44, 45, 46, 49, 51, 52, 54, 55, 57, 58, 60, 62, 63, 65, 66, 68, 70, 71, 72,
73, 76, 77, 79, 80, 81, 82, 83, 85, 86, 87, 88, 89, 90, 91, 91, 93, 93, 94, 96,
96, 97, 97, 97, 98, 99, 99, 100, 99, 99, 100, 99, 99, 99, 99, 99, 99, 97, 97,
97, 96, 95, 94, 95, 93, 93, 91, 90, 89, 87, 87, 85, 84, 82, 80, 79, 77, 75, 74,
72, 70, 68, 66, 64, 61, 59, 57, 56, 53, 51, 49, 45, 43, 41, 38, 35, 33, 30, 27,
25, 23, 20, 17, 14, 12, 8, 5, 2, -1, -3, -7, -10, -13, -15, -18, -22, -24, -27,
-30, -34, -37, -40, -43, -45, -48, -51, -54, -57, -60, -62, -65, -68, -70, -72,
-75, -79, -81, -83, -85, -88, -90, -92, -94, -95, -98, -100, -101, -103, -104,
-106, -107, -109, -110, -111, -112, -114, -114, -115, -116, -116, -117, -118,
-118, -119, -118, -118, -119, -118, -119, -119, -119, -119, -118, -117, -118,
-116, -116, -114, -114, -113, -112, -111, -110, -108, -107, -106, -105, -104,
-102, -100, -98, -97, -95, -94, -91, -90, -88, -86, -84, -82, -79, -76, -74,
-72, -69, -68, -65, -62, -61, -58, -55, -52, -50, -47, -44, -41, -39, -36, -33,
-30, -28, -25, -22, -19, -17, -14, -10, -8, -6, -2, 0, };