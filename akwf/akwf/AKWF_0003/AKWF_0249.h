#define DATA_LENGTH 512
#define DATA AKWF_0249

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 4, 4, 5, 7, 8, 9, 10, 11, 12,
13, 14, 15, 16, 18, 19, 20, 20, 23, 24, 26, 26, 28, 30, 31, 32, 34, 35, 37, 38,
40, 42, 43, 45, 47, 48, 49, 52, 53, 54, 56, 58, 60, 62, 64, 65, 68, 69, 71, 74,
76, 77, 80, 82, 84, 86, 88, 89, 92, 93, 95, 98, 98, 101, 102, 103, 105, 106,
107, 108, 109, 110, 111, 112, 112, 113, 114, 114, 115, 114, 114, 115, 115, 116,
114, 115, 115, 116, 114, 114, 114, 114, 113, 114, 113, 113, 112, 112, 112, 111,
111, 110, 110, 110, 109, 108, 108, 108, 106, 106, 106, 106, 106, 104, 104, 103,
104, 103, 102, 102, 102, 100, 100, 100, 98, 99, 98, 98, 97, 96, 95, 95, 94, 93,
92, 91, 90, 88, 88, 87, 86, 84, 83, 82, 80, 79, 78, 76, 74, 73, 71, 70, 68, 66,
66, 65, 62, 62, 60, 57, 56, 55, 54, 52, 51, 50, 49, 47, 46, 45, 44, 43, 41, 40,
39, 38, 37, 36, 35, 34, 33, 33, 31, 31, 29, 29, 29, 27, 27, 26, 25, 24, 23, 23,
21, 21, 20, 19, 19, 18, 17, 16, 16, 15, 14, 15, 14, 14, 12, 12, 12, 10, 10, 9,
10, 8, 8, 7, 7, 6, 5, 5, 4, 4, 3, 3, 2, 1, 1, 1, 1, 1, 0, -1, -1, -1, -1, -2,
-1, -2, -3, -2, -2, -2, -2, -3, -3, -3, -3, -4, -5, -5, -5, -5, -5, -6, -7, -6,
-6, -8, -8, -8, -9, -10, -9, -11, -11, -11, -13, -13, -14, -14, -14, -15, -17,
-17, -18, -18, -20, -20, -21, -22, -22, -23, -23, -25, -25, -27, -27, -28, -30,
-31, -31, -32, -34, -34, -35, -36, -37, -39, -40, -41, -42, -43, -44, -46, -46,
-48, -48, -49, -50, -51, -51, -53, -53, -54, -55, -56, -57, -58, -59, -60, -61,
-63, -63, -64, -65, -67, -67, -69, -70, -71, -72, -73, -74, -76, -77, -78, -79,
-80, -81, -83, -85, -86, -87, -89, -89, -91, -93, -94, -96, -97, -98, -100,
-100, -103, -103, -104, -106, -107, -109, -109, -112, -112, -113, -114, -115,
-115, -117, -117, -117, -118, -119, -119, -119, -119, -118, -119, -119, -118,
-117, -116, -116, -115, -115, -113, -113, -112, -110, -110, -108, -108, -107,
-105, -105, -104, -102, -102, -100, -99, -98, -96, -96, -95, -94, -93, -91, -91,
-89, -88, -88, -86, -86, -85, -84, -82, -81, -81, -79, -78, -77, -76, -74, -73,
-72, -71, -70, -68, -67, -65, -64, -62, -60, -59, -57, -55, -54, -52, -51, -49,
-47, -46, -44, -42, -40, -38, -36, -35, -33, -31, -30, -29, -27, -26, -25, -24,
-23, -22, -22, -20, -20, -19, -19, -20, -18, -18, -18, -18, -18, -17, -18, -18,
-17, -18, -17, -17, -17, -18, -17, -17, -18, -17, -17, -16, -17, -17, -16, -17,
-16, -16, -15, -15, -15, -14, -14, -13, -12, -12, -10, -10, -10, -8, -8, -6, -6,
-5, -4, -2, -2, 0, };