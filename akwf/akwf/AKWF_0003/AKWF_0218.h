#define DATA_LENGTH 512
#define DATA AKWF_0218

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 7, 10, 10, 15, 12, 22, -1,
-21, -12, -14, -10, -10, -6, -5, -2, -1, 2, 4, 5, 7, 10, 10, 13, 14, 16, 18, 20,
21, 24, 25, 26, 28, 30, 32, 33, 35, 36, 37, 38, 40, 41, 43, 45, 46, 48, 49, 50,
52, 53, 54, 56, 57, 58, 59, 61, 62, 62, 64, 66, 66, 68, 70, 70, 71, 72, 73, 74,
75, 76, 78, 79, 79, 81, 82, 83, 85, 85, 85, 87, 88, 89, 89, 91, 92, 92, 93, 93,
95, 95, 96, 97, 98, 99, 100, 100, 101, 101, 102, 103, 104, 104, 105, 106, 106,
107, 108, 109, 109, 109, 109, 110, 111, 111, 112, 112, 112, 113, 114, 115, 114,
115, 114, 116, 116, 117, 117, 117, 117, 118, 119, 117, 119, 117, 120, 108, 99,
103, 101, 102, 102, 103, 102, 103, 101, 103, 103, 102, 102, 102, 102, 102, 103,
102, 103, 102, 102, 102, 102, 102, 102, 101, 101, 101, 101, 102, 101, 100, 100,
101, 100, 100, 99, 99, 99, 98, 98, 97, 97, 96, 96, 96, 96, 95, 95, 94, 93, 93,
93, 93, 92, 90, 91, 90, 89, 89, 88, 88, 87, 86, 86, 85, 84, 84, 83, 82, 82, 81,
80, 79, 79, 78, 78, 77, 76, 75, 75, 74, 72, 71, 71, 69, 69, 67, 67, 66, 65, 64,
63, 63, 61, 59, 59, 57, 57, 56, 54, 53, 52, 51, 50, 49, 46, 46, 44, 43, 42, 42,
39, 38, 36, 36, 33, 31, 31, 28, 27, 26, 25, 23, 23, 18, 22, -7, -23, -18, -24,
-24, -27, -27, -29, -30, -33, -34, -35, -37, -38, -38, -40, -43, -43, -45, -46,
-47, -48, -50, -51, -52, -53, -55, -56, -57, -58, -59, -60, -61, -62, -64, -64,
-66, -66, -68, -68, -69, -70, -70, -72, -73, -74, -75, -75, -76, -78, -78, -78,
-79, -80, -81, -82, -82, -83, -84, -85, -85, -86, -87, -87, -87, -89, -89, -90,
-89, -90, -91, -92, -92, -93, -93, -94, -94, -95, -95, -96, -96, -96, -97, -98,
-97, -97, -98, -99, -99, -99, -100, -99, -99, -100, -101, -101, -101, -102,
-102, -102, -102, -102, -102, -102, -103, -103, -102, -103, -102, -102, -102,
-103, -102, -102, -102, -103, -103, -103, -102, -103, -103, -102, -102, -101,
-102, -101, -101, -100, -115, -120, -118, -119, -118, -118, -117, -117, -117,
-117, -116, -116, -115, -115, -115, -114, -114, -114, -113, -113, -112, -112,
-111, -111, -110, -110, -108, -108, -107, -106, -106, -106, -104, -105, -103,
-102, -102, -101, -100, -100, -99, -99, -98, -96, -95, -95, -95, -93, -93, -92,
-91, -91, -89, -89, -88, -87, -86, -84, -83, -82, -82, -80, -80, -79, -78, -76,
-76, -74, -73, -72, -71, -70, -68, -67, -67, -65, -64, -63, -61, -60, -58, -58,
-57, -56, -54, -53, -51, -50, -48, -47, -46, -45, -43, -42, -41, -39, -37, -35,
-34, -33, -32, -30, -27, -26, -24, -23, -21, -20, -18, -16, -14, -13, -10, -10,
-8, -6, -4, -1, 0, };