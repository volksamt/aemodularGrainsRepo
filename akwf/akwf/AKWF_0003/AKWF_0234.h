#define DATA_LENGTH 512
#define DATA AKWF_0234

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 8, 11, 14, 17, 20, 24, 27, 30,
32, 36, 39, 42, 45, 48, 50, 53, 56, 59, 61, 64, 65, 67, 70, 72, 74, 75, 76, 79,
80, 81, 84, 85, 87, 88, 89, 92, 94, 94, 96, 97, 98, 100, 101, 103, 104, 106,
107, 108, 109, 110, 112, 111, 113, 114, 114, 115, 116, 117, 117, 117, 117, 118,
118, 117, 118, 117, 118, 118, 118, 118, 119, 119, 119, 120, 120, 119, 119, 119,
119, 119, 118, 118, 118, 117, 117, 117, 117, 116, 115, 115, 115, 113, 112, 112,
110, 109, 109, 108, 106, 106, 104, 103, 102, 100, 99, 98, 97, 96, 93, 93, 91,
90, 88, 86, 84, 83, 82, 80, 78, 77, 75, 74, 71, 70, 68, 67, 64, 63, 62, 60, 59,
57, 56, 55, 52, 52, 51, 50, 48, 48, 46, 46, 45, 44, 43, 43, 42, 42, 41, 41, 40,
39, 39, 38, 38, 36, 37, 36, 35, 34, 34, 33, 32, 32, 32, 30, 25, 24, 25, 24, 24,
23, 21, 20, 20, 18, 18, 17, 16, 15, 16, 14, 15, 13, 13, 11, 11, 9, 9, 8, 7, 6,
5, 4, 4, 3, 2, 1, 1, 0, 0, -1, -4, -3, -4, -5, -4, -6, -6, -6, -6, -6, -8, -8,
-8, -8, -8, -9, -9, -8, -10, -10, -9, -11, -10, -11, -11, -11, -12, -10, -10,
-11, -11, -12, -11, -11, -11, -11, -12, -12, -13, -13, -13, -13, -13, -15, -14,
-15, -16, -16, -17, -17, -19, -19, -22, -22, -22, -23, -23, -24, -24, -25, -26,
-26, -27, -26, -26, -26, -26, -28, -28, -28, -28, -29, -28, -29, -30, -30, -31,
-32, -32, -34, -35, -36, -35, -37, -37, -37, -38, -39, -39, -39, -39, -40, -40,
-40, -40, -40, -41, -41, -41, -42, -41, -41, -42, -42, -42, -43, -42, -43, -43,
-43, -43, -44, -45, -45, -46, -45, -46, -47, -48, -48, -49, -50, -50, -51, -51,
-52, -52, -53, -54, -54, -54, -54, -55, -55, -53, -54, -54, -53, -53, -53, -54,
-53, -53, -52, -53, -52, -53, -52, -52, -52, -51, -50, -50, -50, -51, -50, -49,
-49, -49, -49, -49, -49, -49, -48, -49, -47, -48, -48, -47, -48, -47, -47, -48,
-47, -48, -48, -48, -47, -48, -48, -48, -48, -49, -48, -47, -48, -47, -47, -47,
-46, -45, -45, -45, -44, -44, -44, -43, -42, -42, -41, -40, -39, -39, -37, -37,
-36, -35, -34, -34, -34, -33, -33, -32, -32, -32, -32, -32, -32, -34, -34, -37,
-37, -38, -40, -42, -43, -45, -47, -49, -51, -53, -56, -57, -60, -63, -65, -67,
-69, -72, -74, -78, -79, -82, -84, -87, -90, -91, -93, -95, -96, -98, -99, -100,
-101, -102, -101, -103, -104, -105, -105, -104, -104, -104, -104, -103, -102,
-101, -100, -99, -98, -97, -95, -94, -92, -91, -89, -87, -86, -84, -81, -79,
-77, -74, -72, -69, -67, -64, -62, -59, -56, -53, -50, -48, -45, -42, -39, -36,
-33, -30, -26, -24, -21, -18, -14, -12, -8, -5, -2, };