#define DATA_LENGTH 512
#define DATA AKWF_0210

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 7, 10, 12, 15, 18, 21, 24,
27, 31, 33, 37, 41, 45, 48, 52, 55, 57, 61, 65, 68, 72, 76, 78, 81, 84, 85, 88,
90, 92, 95, 97, 98, 99, 101, 101, 102, 103, 103, 104, 105, 106, 107, 109, 109,
111, 112, 112, 113, 113, 114, 115, 116, 117, 118, 119, 118, 116, 115, 114, 114,
112, 111, 110, 108, 106, 104, 103, 101, 98, 96, 93, 92, 90, 88, 87, 87, 85, 84,
82, 80, 77, 75, 74, 72, 73, 71, 70, 70, 70, 69, 68, 68, 67, 66, 65, 64, 63, 63,
62, 61, 60, 59, 58, 57, 57, 56, 55, 54, 52, 53, 53, 51, 51, 51, 50, 50, 49, 48,
48, 47, 46, 44, 43, 44, 42, 42, 42, 42, 42, 41, 41, 40, 40, 39, 39, 38, 37, 36,
37, 37, 38, 38, 38, 38, 37, 36, 35, 34, 34, 33, 33, 30, 30, 29, 27, 26, 26, 24,
23, 22, 21, 20, 20, 19, 16, 15, 14, 12, 11, 10, 8, 7, 7, 6, 5, 3, 2, 1, 2, 0, 0,
-1, -1, -4, -3, -3, -3, -4, -5, -4, -5, -4, -6, -6, -7, -8, -9, -10, -11, -12,
-12, -13, -13, -14, -15, -15, -16, -15, -16, -15, -16, -14, -14, -13, -12, -10,
-9, -8, -6, -5, -4, -3, -2, -1, 0, 2, 4, 5, 6, 7, 10, 12, 14, 15, 17, 18, 17,
16, 16, 17, 17, 16, 15, 14, 13, 11, 11, 9, 9, 8, 6, 3, 2, -1, -2, -4, -7, -10,
-13, -16, -18, -21, -24, -27, -31, -33, -38, -41, -45, -48, -52, -55, -59, -62,
-65, -68, -72, -75, -78, -82, -84, -86, -87, -90, -92, -95, -97, -98, -100,
-100, -102, -102, -103, -104, -105, -105, -107, -108, -109, -110, -110, -111,
-112, -113, -113, -114, -115, -116, -117, -118, -120, -118, -116, -116, -114,
-113, -113, -111, -109, -108, -107, -105, -103, -101, -99, -96, -94, -92, -90,
-89, -87, -86, -84, -83, -81, -80, -77, -75, -74, -73, -72, -71, -71, -70, -70,
-69, -68, -68, -67, -66, -65, -64, -62, -63, -61, -61, -59, -59, -58, -58, -57,
-56, -55, -53, -53, -52, -52, -52, -52, -51, -51, -50, -49, -48, -48, -46, -46,
-44, -44, -43, -42, -42, -42, -41, -42, -41, -41, -40, -39, -39, -38, -38, -37,
-38, -37, -37, -38, -38, -38, -37, -36, -36, -35, -35, -33, -33, -32, -30, -29,
-29, -28, -27, -25, -24, -23, -22, -20, -21, -19, -18, -17, -15, -13, -12, -11,
-9, -9, -8, -7, -6, -5, -4, -3, -2, -1, -1, 0, 1, 2, 3, 2, 3, 4, 4, 4, 4, 5, 5,
6, 6, 6, 8, 9, 11, 11, 12, 13, 13, 14, 14, 15, 15, 15, 15, 15, 16, 16, 15, 14,
13, 11, 11, 9, 7, 7, 6, 5, 3, 2, 0, -1, -2, -3, -5, -7, -8, -10, -12, -13, -15,
-17, -18, -17, -16, -16, -16, -16, -16, -14, -13, -13, -12, -11, -10, -9, -7,
-5, -5, -1, };