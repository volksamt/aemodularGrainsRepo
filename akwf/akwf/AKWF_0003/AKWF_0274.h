#define DATA_LENGTH 512
#define DATA AKWF_0274

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 11, 20, 29, 37, 47, 55, 63, 71, 78,
84, 91, 97, 101, 105, 110, 114, 116, 118, 119, 119, 119, 117, 114, 112, 109,
105, 101, 96, 90, 84, 80, 73, 67, 60, 54, 47, 41, 34, 28, 20, 14, 8, 2, -6, -11,
-18, -23, -29, -34, -40, -44, -49, -52, -57, -61, -65, -67, -70, -72, -74, -77,
-76, -77, -79, -78, -77, -77, -76, -73, -73, -71, -68, -65, -63, -60, -57, -55,
-51, -49, -46, -44, -41, -39, -37, -34, -32, -30, -28, -27, -26, -24, -23, -22,
-21, -21, -20, -20, -21, -21, -21, -22, -23, -23, -25, -25, -25, -27, -28, -30,
-31, -31, -33, -33, -34, -34, -34, -33, -33, -31, -31, -29, -27, -26, -23, -21,
-18, -16, -13, -11, -7, -4, -2, 1, 3, 6, 8, 10, 11, 13, 15, 16, 17, 18, 18, 19,
20, 19, 20, 19, 18, 18, 17, 17, 17, 15, 15, 15, 14, 14, 13, 13, 12, 13, 12, 12,
13, 13, 15, 15, 16, 17, 18, 21, 22, 23, 26, 28, 32, 33, 36, 38, 40, 44, 46, 50,
52, 55, 59, 62, 65, 69, 70, 74, 76, 79, 81, 83, 85, 86, 86, 87, 87, 88, 87, 85,
84, 82, 79, 76, 72, 68, 64, 59, 54, 48, 43, 36, 29, 21, 15, 8, 0, -8, -15, -22,
-30, -37, -44, -50, -56, -62, -68, -73, -77, -81, -84, -86, -88, -89, -90, -91,
-90, -90, -88, -86, -83, -79, -76, -71, -68, -64, -59, -54, -49, -44, -39, -33,
-29, -24, -19, -14, -9, -4, 1, 5, 8, 12, 14, 19, 20, 23, 25, 27, 29, 28, 31, 31,
31, 31, 31, 31, 29, 28, 27, 26, 25, 23, 22, 19, 19, 17, 16, 13, 12, 11, 10, 7,
7, 5, 3, 1, 0, -1, -3, -6, -7, -8, -10, -10, -12, -13, -14, -14, -16, -17, -18,
-18, -19, -19, -20, -20, -20, -21, -20, -19, -19, -18, -17, -15, -14, -12, -10,
-9, -6, -3, -1, 2, 5, 7, 9, 11, 14, 15, 17, 18, 19, 19, 20, 19, 18, 18, 16, 16,
13, 11, 9, 8, 5, 3, 1, -1, -3, -6, -8, -10, -12, -14, -17, -19, -19, -22, -22,
-23, -25, -26, -29, -29, -30, -30, -31, -31, -31, -30, -31, -30, -28, -27, -26,
-24, -23, -20, -18, -15, -12, -9, -8, -4, -1, 1, 5, 8, 10, 13, 16, 17, 20, 23,
24, 26, 28, 30, 31, 32, 33, 36, 37, 38, 39, 42, 42, 44, 45, 47, 49, 49, 50, 52,
53, 54, 54, 56, 57, 57, 57, 58, 59, 59, 58, 59, 59, 58, 58, 58, 57, 55, 55, 52,
52, 48, 47, 43, 41, 39, 35, 33, 31, 27, 25, 22, 20, 16, 12, 9, 5, 1, -4, -8,
-12, -17, -22, -29, -34, -40, -46, -53, -58, -64, -69, -75, -81, -86, -91, -94,
-99, -102, -105, -108, -109, -110, -110, -111, -109, -108, -106, -104, -101,
-98, -93, -88, -83, -78, -72, -67, -60, -52, -45, -37, -30, -21, -13, -4, };