#define DATA_LENGTH 512
#define DATA AKWF_0289

const PROGMEM int8_t DATA[DATA_LENGTH] = {-21, -81, -116, -119, -113, -102, -90,
-80, -70, -59, -50, -41, -34, -27, -21, -15, -10, -5, -2, 3, 6, 10, 12, 14, 17,
18, 20, 22, 23, 23, 25, 25, 25, 26, 26, 26, 27, 27, 27, 26, 25, 25, 25, 25, 24,
23, 23, 22, 21, 21, 21, 21, 20, 18, 18, 17, 17, 17, 16, 15, 15, 14, 13, 13, 12,
12, 12, 11, 9, 10, 10, 9, 7, 8, 7, 6, 6, 7, 6, 5, 4, 4, 5, 4, 3, 3, 3, 2, 3, 2,
2, 1, 2, 1, 1, 0, 0, 0, 0, -1, -1, 0, 0, -1, -1, -1, -1, -1, -2, -1, -2, -2, -2,
-2, -1, -2, -3, -2, -1, -3, -2, -2, -2, -2, -2, -3, -2, -2, -2, -2, -2, -2, -2,
-2, -2, -2, -2, -2, -2, -3, -2, -2, -2, -2, -2, -3, -3, -2, -2, -2, -2, -2, -2,
-2, -2, -2, -2, -2, -2, -2, -2, -1, -3, -2, -2, -2, -2, -2, -2, -2, -2, -1, -1,
-2, -2, -2, -1, -1, -1, -1, 0, -1, -1, -1, -1, -2, -1, -1, -1, 0, -1, -1, -2,
-1, -1, 0, -1, -1, 0, -2, -1, 0, -1, -1, 0, 0, -1, -1, -1, -1, 0, 0, -1, -1, 0,
0, 0, 0, 0, 0, -1, -1, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, -1, 1, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, -1, 1, 0, 1, 1, 1, 0, 0, 0,
0, 0, 1, 1, 1, 1, 1, 0, 1, 1, 0, 0, 1, 0, 1, 1, 1, 1, 0, 1, 0, 0, 0, 1, 1, 0, 0,
1, 1, 1, 1, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 0,
1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 0, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 1,
0, 0, 1, 1, 0, 1, 0, 0, 0, 1, 1, 0, 1, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 1,
0, 0, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 0, 0, 1, 1, 0, 1, 0, 1, 0, 0, 1, 0,
0, 1, 1, 1, 0, 1, 0, 1, 0, 1, 1, 1, 1, 0, 0, 1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 0, 0,
1, 1, 1, 0, 0, 1, 0, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 0, 0, 1,
1, 1, 1, 0, 1, 1, 1, 0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0,
1, 1, 0, 1, 0, 1, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 1, 0,
1, 0, 0, };