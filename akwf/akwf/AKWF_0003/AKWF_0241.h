#define DATA_LENGTH 512
#define DATA AKWF_0241

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 13, 17, 20, 24, 27, 32, 36,
41, 45, 47, 51, 53, 55, 59, 63, 66, 68, 71, 73, 77, 79, 82, 84, 85, 88, 90, 91,
93, 94, 96, 96, 98, 98, 99, 101, 104, 106, 106, 107, 107, 107, 107, 107, 108,
109, 109, 110, 111, 112, 113, 113, 113, 113, 113, 115, 115, 116, 117, 116, 116,
116, 117, 116, 116, 116, 116, 116, 117, 116, 116, 117, 118, 118, 120, 119, 119,
119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 120, 118,
118, 118, 118, 118, 118, 119, 118, 119, 119, 118, 119, 118, 119, 119, 119, 119,
118, 118, 119, 119, 119, 118, 119, 118, 118, 118, 118, 118, 118, 119, 117, 118,
118, 118, 117, 118, 118, 118, 117, 118, 119, 118, 118, 118, 118, 118, 119, 118,
118, 117, 118, 118, 118, 118, 118, 118, 117, 118, 118, 118, 118, 117, 118, 117,
118, 118, 117, 118, 118, 118, 118, 118, 118, 118, 117, 117, 118, 117, 118, 118,
118, 118, 118, 117, 117, 117, 118, 118, 117, 117, 117, 117, 117, 117, 117, 117,
116, 118, 117, 117, 117, 118, 117, 117, 116, 117, 117, 117, 118, 117, 113, 112,
109, 106, 103, 101, 98, 96, 93, 90, 87, 84, 82, 79, 75, 73, 69, 67, 63, 60, 59,
56, 53, 50, 49, 47, 46, 43, 41, 37, 36, 33, 33, 30, 29, 28, 27, 25, 24, 22, 21,
20, 19, 19, 17, 17, 16, 15, 14, 8, 4, -1, -5, -9, -14, -18, -21, -24, -28, -33,
-37, -41, -45, -48, -52, -55, -57, -60, -63, -66, -68, -71, -74, -76, -79, -82,
-84, -86, -89, -91, -91, -92, -93, -95, -97, -98, -100, -100, -101, -102, -103,
-104, -104, -106, -107, -107, -108, -109, -110, -111, -112, -112, -113, -113,
-114, -113, -114, -113, -113, -113, -114, -115, -116, -117, -116, -117, -117,
-117, -116, -116, -116, -117, -116, -117, -117, -119, -119, -120, -120, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -118, -119, -119, -118,
-118, -118, -119, -119, -119, -118, -119, -119, -118, -118, -118, -119, -119,
-118, -119, -118, -119, -119, -118, -118, -119, -119, -118, -119, -118, -119,
-118, -118, -118, -119, -118, -118, -118, -118, -118, -118, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -119, -118, -118,
-118, -119, -118, -118, -119, -118, -118, -118, -118, -117, -119, -118, -118,
-118, -118, -118, -118, -117, -117, -118, -119, -118, -117, -118, -117, -117,
-118, -117, -118, -118, -117, -117, -117, -117, -117, -118, -117, -117, -117,
-117, -117, -117, -118, -118, -117, -117, -117, -117, -117, -117, -117, -117,
-118, -117, -117, -118, -117, -118, -117, -117, -115, -111, -110, -106, -103,
-102, -99, -97, -95, -93, -91, -88, -86, -82, -79, -75, -73, -69, -67, -64, -61,
-58, -55, -53, -51, -48, -46, -44, -43, -40, -37, -35, -33, -31, -30, -30, -27,
-28, -25, -25, -22, -21, -20, -20, -18, -17, -17, -16, -14, -9, -7, -3, };