#define DATA_LENGTH 512
#define DATA AKWF_0280

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 16, 21, 27, 31, 37, 42, 48,
52, 57, 62, 67, 71, 74, 77, 80, 82, 83, 84, 84, 84, 83, 82, 81, 79, 77, 75, 74,
72, 70, 68, 66, 64, 62, 61, 60, 58, 56, 56, 55, 56, 56, 54, 54, 53, 53, 53, 52,
50, 50, 49, 47, 45, 44, 41, 39, 37, 34, 32, 30, 27, 25, 23, 22, 19, 19, 17, 16,
15, 15, 14, 13, 13, 12, 12, 12, 11, 11, 10, 9, 7, 6, 3, 0, -3, -6, -9, -12, -16,
-21, -25, -29, -34, -39, -43, -47, -51, -54, -56, -59, -61, -62, -63, -63, -62,
-60, -58, -57, -54, -51, -48, -44, -42, -39, -36, -34, -31, -28, -26, -25, -24,
-24, -22, -22, -22, -22, -22, -22, -23, -23, -23, -23, -24, -24, -24, -24, -22,
-23, -22, -21, -20, -21, -21, -20, -22, -22, -23, -26, -28, -31, -34, -37, -41,
-44, -48, -50, -54, -57, -59, -61, -62, -62, -62, -61, -59, -57, -54, -49, -44,
-39, -33, -27, -20, -13, -5, 1, 9, 16, 22, 29, 34, 40, 45, 50, 54, 57, 61, 64,
67, 70, 73, 75, 78, 81, 84, 87, 90, 93, 97, 99, 101, 104, 106, 108, 108, 107,
105, 104, 102, 98, 93, 88, 81, 76, 68, 60, 53, 44, 36, 29, 21, 15, 8, 2, -3, -7,
-10, -13, -15, -16, -17, -16, -15, -14, -13, -11, -8, -5, -4, -1, 1, 1, 3, 3, 4,
5, 4, 4, 3, 3, 2, 2, 1, 0, -1, -3, -3, -3, -4, -3, -3, -2, -1, -2, 0, 0, 0, 1,
0, 0, 0, -1, -2, -4, -6, -8, -11, -14, -17, -20, -25, -28, -33, -38, -42, -46,
-50, -55, -59, -62, -66, -69, -71, -73, -75, -76, -77, -78, -78, -78, -78, -77,
-78, -77, -77, -75, -75, -74, -74, -72, -73, -71, -72, -70, -69, -68, -66, -66,
-63, -63, -60, -58, -56, -52, -50, -46, -43, -39, -34, -31, -27, -23, -19, -16,
-12, -8, -4, -1, 2, 5, 6, 8, 9, 10, 12, 12, 12, 13, 13, 13, 13, 13, 13, 14, 16,
17, 18, 21, 23, 26, 30, 34, 37, 42, 48, 53, 58, 63, 70, 74, 80, 85, 90, 94, 97,
101, 105, 106, 108, 108, 110, 110, 110, 109, 109, 107, 106, 105, 105, 103, 102,
100, 99, 96, 95, 93, 90, 89, 85, 81, 77, 73, 68, 62, 58, 51, 44, 36, 28, 21, 14,
6, -2, -9, -15, -21, -27, -31, -35, -40, -42, -44, -46, -45, -47, -46, -44, -43,
-41, -40, -37, -35, -33, -31, -29, -28, -25, -24, -23, -22, -22, -22, -22, -21,
-22, -21, -21, -21, -20, -20, -19, -19, -18, -18, -17, -17, -16, -17, -16, -17,
-19, -20, -23, -27, -30, -35, -39, -45, -52, -57, -65, -71, -78, -85, -92, -98,
-103, -107, -112, -115, -117, -118, -119, -119, -117, -115, -112, -108, -105,
-100, -94, -89, -83, -77, -70, -64, -59, -52, -48, -42, -37, -32, -28, -24, -20,
-16, -12, -9, -5, -1, };