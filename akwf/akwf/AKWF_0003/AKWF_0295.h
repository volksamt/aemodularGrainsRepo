#define DATA_LENGTH 512
#define DATA AKWF_0295

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 9, 12, 14, 15, 17, 19, 21,
21, 23, 24, 26, 26, 29, 30, 31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 42, 43, 44,
45, 46, 48, 50, 50, 51, 51, 51, 52, 52, 52, 52, 52, 53, 52, 53, 53, 54, 54, 56,
56, 57, 58, 59, 58, 59, 59, 60, 61, 61, 63, 65, 66, 66, 68, 69, 71, 73, 74, 76,
78, 79, 81, 82, 84, 85, 87, 89, 90, 92, 93, 95, 96, 98, 99, 100, 102, 102, 104,
104, 105, 106, 107, 107, 109, 110, 111, 111, 111, 111, 112, 113, 113, 115, 114,
115, 115, 116, 117, 116, 116, 117, 118, 118, 119, 119, 119, 120, 119, 118, 119,
119, 120, 118, 119, 119, 118, 119, 118, 119, 118, 118, 118, 117, 117, 117, 116,
115, 114, 114, 113, 113, 112, 112, 110, 110, 110, 108, 107, 106, 105, 103, 103,
102, 101, 99, 99, 96, 96, 93, 92, 90, 89, 87, 85, 84, 82, 80, 79, 76, 75, 73,
72, 70, 69, 67, 66, 63, 62, 60, 58, 56, 55, 52, 51, 51, 48, 47, 46, 44, 42, 41,
39, 39, 37, 36, 35, 33, 32, 30, 30, 28, 26, 26, 25, 23, 22, 21, 21, 19, 17, 16,
16, 14, 14, 12, 12, 10, 9, 9, 8, 7, 5, 4, 3, 3, 1, 0, -1, -2, -2, -4, -4, -5,
-6, -7, -7, -8, -8, -9, -10, -10, -11, -12, -13, -14, -14, -14, -16, -17, -16,
-18, -17, -18, -18, -19, -20, -21, -21, -22, -22, -22, -25, -25, -26, -26, -26,
-28, -28, -28, -30, -30, -31, -31, -31, -32, -32, -33, -33, -34, -34, -35, -36,
-36, -37, -38, -37, -39, -39, -39, -40, -41, -41, -42, -42, -43, -44, -43, -45,
-45, -46, -46, -46, -47, -48, -48, -48, -49, -49, -49, -50, -50, -51, -51, -51,
-52, -53, -52, -54, -53, -54, -55, -55, -55, -56, -56, -56, -57, -57, -57, -58,
-59, -59, -58, -59, -60, -60, -60, -60, -61, -61, -61, -61, -62, -62, -63, -63,
-64, -64, -64, -64, -65, -65, -66, -67, -66, -67, -67, -67, -68, -68, -69, -69,
-69, -70, -70, -71, -71, -71, -71, -72, -72, -72, -73, -73, -74, -73, -74, -73,
-75, -74, -74, -75, -75, -76, -76, -75, -75, -76, -76, -75, -75, -76, -76, -74,
-75, -74, -74, -74, -75, -75, -75, -73, -74, -73, -73, -72, -73, -72, -71, -72,
-71, -70, -71, -69, -69, -68, -68, -67, -67, -66, -66, -65, -65, -64, -64, -63,
-63, -62, -61, -60, -59, -59, -58, -58, -57, -56, -56, -57, -61, -65, -70, -76,
-83, -89, -95, -100, -102, -105, -105, -107, -106, -105, -105, -104, -105, -105,
-106, -105, -107, -108, -108, -108, -109, -108, -106, -106, -103, -101, -98,
-95, -92, -90, -87, -83, -80, -77, -75, -72, -69, -67, -65, -62, -59, -57, -56,
-54, -51, -50, -47, -44, -42, -38, -35, -33, -30, -27, -24, -22, -19, -18, -15,
-14, -12, -12, -10, -10, -8, -7, -4, -3, 0, };