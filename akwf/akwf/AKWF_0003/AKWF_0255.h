#define DATA_LENGTH 512
#define DATA AKWF_0255

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 9, 14, 18, 22, 27, 30, 34, 38,
42, 45, 49, 53, 55, 59, 61, 64, 66, 68, 71, 72, 75, 77, 79, 80, 82, 83, 84, 85,
87, 88, 90, 90, 91, 92, 92, 93, 94, 94, 94, 95, 96, 95, 95, 97, 96, 97, 96, 96,
96, 96, 95, 95, 96, 95, 94, 94, 93, 93, 93, 91, 91, 91, 90, 89, 88, 87, 87, 87,
85, 85, 84, 83, 81, 81, 81, 80, 79, 78, 78, 76, 77, 76, 76, 74, 74, 74, 73, 73,
73, 72, 72, 72, 71, 71, 72, 71, 71, 71, 71, 71, 72, 72, 72, 72, 72, 73, 73, 73,
73, 74, 74, 73, 74, 74, 75, 73, 74, 75, 73, 74, 74, 73, 73, 72, 72, 72, 71, 71,
70, 70, 69, 67, 67, 66, 64, 64, 63, 62, 60, 59, 56, 55, 54, 52, 49, 48, 46, 44,
42, 40, 37, 35, 33, 30, 27, 25, 22, 19, 16, 12, 8, 6, 3, -1, -5, -9, -11, -15,
-18, -22, -25, -28, -31, -35, -37, -40, -44, -46, -48, -52, -55, -57, -60, -61,
-64, -66, -68, -70, -72, -74, -77, -78, -79, -81, -82, -84, -84, -86, -87, -89,
-89, -90, -90, -91, -92, -92, -91, -92, -92, -92, -92, -91, -91, -91, -89, -89,
-88, -87, -86, -84, -82, -81, -79, -77, -75, -73, -70, -68, -65, -62, -59, -56,
-53, -51, -46, -43, -39, -36, -32, -27, -24, -19, -14, -10, -5, 0, 4, 9, 14, 18,
22, 28, 31, 36, 40, 44, 48, 52, 55, 58, 61, 65, 67, 71, 73, 75, 78, 80, 82, 84,
85, 88, 88, 90, 92, 93, 93, 95, 96, 97, 97, 98, 98, 99, 99, 99, 99, 100, 100,
100, 100, 100, 100, 100, 100, 99, 98, 99, 99, 97, 96, 96, 95, 94, 93, 92, 90,
90, 88, 87, 84, 83, 81, 79, 77, 75, 73, 71, 69, 67, 63, 62, 59, 55, 53, 50, 47,
44, 42, 38, 35, 32, 29, 25, 21, 19, 15, 11, 7, 3, 0, -4, -7, -10, -14, -17, -20,
-24, -27, -29, -32, -33, -37, -39, -41, -43, -44, -46, -48, -49, -50, -50, -51,
-52, -53, -53, -54, -55, -55, -55, -55, -55, -56, -56, -56, -56, -56, -56, -56,
-56, -57, -57, -57, -56, -56, -57, -57, -57, -57, -58, -59, -59, -59, -60, -60,
-60, -61, -63, -62, -63, -65, -65, -66, -67, -68, -69, -70, -72, -73, -74, -75,
-75, -77, -77, -79, -81, -81, -83, -84, -85, -85, -87, -88, -89, -90, -91, -92,
-94, -94, -95, -96, -97, -98, -99, -101, -101, -102, -103, -104, -106, -106,
-107, -108, -109, -109, -111, -111, -112, -114, -113, -115, -115, -116, -116,
-117, -118, -118, -119, -119, -119, -119, -119, -119, -118, -119, -119, -118,
-117, -117, -116, -115, -115, -114, -112, -111, -111, -109, -106, -105, -103,
-102, -99, -97, -95, -93, -90, -87, -84, -82, -80, -76, -73, -69, -66, -63, -60,
-57, -52, -49, -46, -41, -37, -33, -30, -26, -21, -18, -13, -8, -3, };