#define DATA_LENGTH 512
#define DATA AKWF_0262

const PROGMEM int8_t DATA[DATA_LENGTH] = {44, 53, 49, 51, 49, 51, 49, 51, 49,
51, 49, 51, 49, 51, 50, 51, 49, 50, 50, 51, 51, 49, 50, 49, 51, 49, 50, 49, 51,
48, 54, 39, 17, 22, 20, 21, 20, 21, 20, 20, 21, 20, 21, 21, 22, 20, 20, 20, 21,
20, 21, 20, 21, 20, 21, 21, 21, 21, 21, 21, 21, 21, 20, 35, 50, 49, 50, 49, 49,
50, 50, 49, 49, 50, 50, 49, 50, 49, 49, 50, 50, 50, 50, 50, 50, 49, 50, 49, 50,
49, 50, 48, 51, 48, 54, 38, 18, 22, 20, 21, 21, 20, 20, 20, 20, 20, 21, 21, 21,
20, 20, 21, 20, 20, 20, 20, 20, 21, 19, 21, 20, 21, 20, 21, 19, 21, 19, 36, 50,
50, 50, 50, 49, 50, 50, 49, 52, 44, 102, 125, 114, 121, 116, 120, 116, 119, 117,
119, 118, 118, 117, 118, 118, 118, 118, 117, 120, 117, 122, 106, 85, 90, 88, 90,
89, 89, 90, 89, 88, 89, 89, 88, 89, 89, 89, 89, 89, 88, 89, 89, 89, 89, 88, 89,
89, 88, 88, 89, 89, 89, 87, 104, 119, 118, 118, 117, 118, 117, 118, 118, 118,
117, 118, 118, 118, 117, 117, 117, 118, 118, 118, 118, 117, 118, 117, 117, 118,
116, 118, 117, 119, 116, 121, 105, 85, 91, 87, 89, 87, 89, 87, 88, 88, 89, 88,
88, 89, 87, 89, 86, 89, 86, 91, 85, 91, 85, 90, 84, 91, 84, 92, 83, 92, 82, 95,
90, -86, -93, -86, -93, -86, -94, -87, -93, -87, -92, -87, -92, -89, -91, -88,
-92, -88, -91, -89, -91, -89, -91, -90, -90, -89, -90, -89, -90, -89, -91, -87,
-103, -123, -117, -121, -118, -120, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -118, -119, -118, -119, -118,
-119, -119, -119, -119, -118, -119, -101, -89, -90, -88, -90, -89, -89, -89,
-89, -89, -90, -88, -90, -90, -89, -89, -89, -90, -89, -89, -89, -89, -89, -89,
-89, -89, -90, -89, -90, -88, -91, -86, -104, -122, -116, -120, -116, -119,
-118, -120, -117, -119, -118, -118, -118, -118, -119, -118, -119, -117, -120,
-116, -121, -113, -126, -85, -40, -53, -46, -51, -48, -50, -48, -50, -31, -19,
-20, -20, -20, -20, -19, -20, -20, -19, -20, -19, -20, -19, -19, -19, -20, -19,
-20, -19, -19, -19, -19, -19, -19, -19, -20, -19, -21, -18, -22, -15, -35, -52,
-46, -50, -49, -49, -47, -49, -48, -49, -48, -49, -49, -48, -49, -49, -48, -48,
-49, -49, -49, -49, -49, -48, -49, -49, -49, -48, -49, -48, -49, -49, -30, -18,
-19, -19, -20, -19, -19, -19, -19, -20, -19, -19, -19, -19, -19, -19, -19, -19,
-19, -19, -19, -19, -19, -19, -20, -19, -19, -18, -20, -18, -21, -15, -35, -53,
-46, -49, -47, -48, -48, -49, -49, -48, -48, -49, -49, -48, -49, -48, -48, -48,
-48, -49, -48, -49, -49, -48, -49, -48, -48, -48, -48, -49, -47, -49, -27, };