#define DATA_LENGTH 512
#define DATA AKWF_0243

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 8, 10, 12, 14, 17, 20, 24, 27,
28, 31, 33, 36, 37, 39, 41, 42, 42, 44, 45, 46, 47, 48, 49, 50, 50, 52, 54, 55,
58, 59, 60, 62, 63, 64, 66, 69, 71, 74, 76, 78, 80, 82, 84, 87, 88, 91, 94, 97,
100, 103, 104, 106, 108, 111, 112, 115, 116, 118, 119, 118, 120, 119, 118, 119,
118, 118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120, 119,
119, 119, 119, 118, 118, 119, 118, 118, 118, 118, 119, 119, 118, 119, 119, 119,
118, 118, 118, 119, 118, 118, 119, 118, 119, 119, 118, 118, 118, 118, 118, 118,
118, 118, 118, 118, 118, 119, 118, 116, 115, 114, 114, 112, 112, 110, 109, 108,
107, 107, 105, 104, 102, 101, 100, 99, 98, 97, 96, 95, 94, 94, 92, 91, 90, 89,
88, 87, 85, 85, 84, 82, 81, 81, 79, 78, 79, 77, 78, 77, 76, 75, 75, 73, 72, 70,
70, 71, 71, 70, 68, 68, 67, 66, 67, 66, 66, 66, 64, 64, 63, 62, 61, 59, 59, 57,
57, 55, 54, 53, 52, 51, 51, 49, 47, 47, 45, 45, 42, 40, 39, 35, 30, 26, 20, 16,
10, 5, 1, -3, -8, -11, -14, -18, -21, -21, -22, -23, -26, -28, -29, -32, -32,
-33, -35, -36, -36, -38, -39, -38, -38, -39, -39, -40, -41, -41, -43, -42, -42,
-43, -44, -45, -45, -46, -45, -46, -45, -45, -45, -45, -46, -44, -45, -45, -45,
-45, -46, -45, -45, -45, -44, -43, -42, -42, -42, -41, -41, -42, -41, -42, -41,
-41, -41, -41, -41, -42, -42, -42, -44, -45, -45, -46, -48, -49, -52, -53, -55,
-57, -57, -59, -59, -63, -64, -67, -68, -69, -69, -70, -71, -71, -71, -71, -72,
-73, -74, -73, -74, -73, -74, -74, -74, -73, -74, -73, -74, -73, -74, -74, -75,
-76, -77, -77, -79, -81, -81, -80, -80, -81, -82, -83, -83, -84, -85, -84, -85,
-86, -87, -88, -88, -88, -88, -87, -88, -88, -88, -88, -88, -87, -88, -88, -88,
-88, -88, -87, -88, -88, -88, -88, -87, -88, -86, -86, -84, -84, -84, -83, -84,
-82, -82, -80, -80, -80, -81, -79, -79, -77, -76, -77, -77, -76, -76, -74, -74,
-73, -72, -70, -69, -70, -69, -70, -69, -67, -67, -65, -66, -65, -65, -65, -66,
-65, -65, -64, -63, -62, -62, -62, -62, -62, -61, -61, -62, -62, -61, -62, -62,
-63, -65, -66, -65, -65, -66, -65, -64, -65, -65, -65, -65, -66, -66, -65, -66,
-66, -65, -65, -65, -66, -66, -65, -65, -65, -65, -65, -65, -65, -66, -66, -66,
-65, -65, -65, -64, -62, -62, -62, -61, -62, -61, -61, -61, -62, -60, -59, -58,
-57, -56, -54, -54, -54, -54, -54, -53, -52, -51, -50, -48, -48, -46, -45, -45,
-43, -42, -41, -40, -39, -39, -37, -36, -34, -34, -33, -31, -30, -30, -29, -27,
-26, -25, -26, -24, -23, -21, -20, -18, -16, -14, -13, -9, -7, -5, -1, };