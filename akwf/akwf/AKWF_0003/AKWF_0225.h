#define DATA_LENGTH 512
#define DATA AKWF_0225

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 5, 7, 8, 9, 11, 12, 14, 15,
17, 19, 20, 23, 23, 26, 26, 27, 30, 31, 32, 34, 36, 37, 38, 40, 41, 43, 44, 45,
47, 49, 50, 52, 53, 54, 56, 58, 59, 60, 61, 63, 64, 66, 67, 68, 69, 71, 72, 74,
75, 75, 78, 79, 80, 81, 82, 83, 85, 86, 87, 88, 89, 90, 91, 92, 93, 95, 95, 96,
97, 98, 99, 100, 101, 102, 102, 103, 103, 104, 106, 106, 107, 108, 108, 109,
110, 111, 111, 112, 112, 113, 113, 114, 114, 114, 115, 115, 117, 117, 116, 117,
118, 118, 117, 118, 118, 119, 118, 119, 119, 119, 118, 119, 120, 120, 119, 119,
119, 119, 118, 119, 118, 118, 118, 118, 118, 117, 117, 117, 116, 117, 116, 116,
116, 115, 114, 114, 113, 113, 112, 111, 111, 111, 110, 110, 108, 108, 107, 107,
107, 105, 105, 104, 103, 102, 101, 101, 100, 99, 98, 97, 97, 95, 94, 93, 92, 92,
90, 89, 88, 87, 87, 86, 84, 84, 82, 81, 80, 78, 78, 77, 76, 74, 73, 71, 70, 70,
69, 66, 66, 64, 63, 62, 60, 59, 59, 57, 56, 54, 53, 52, 50, 48, 47, 46, 45, 44,
43, 42, 41, 39, 37, 36, 35, 33, 31, 31, 29, 28, 27, 25, 24, 23, 22, 21, 19, 18,
15, 15, 13, 11, 11, 10, 8, 7, 6, 4, 2, 2, 1, -1, -2, -3, -4, -5, -6, -8, -9,
-10, -11, -13, -15, -15, -17, -17, -19, -21, -21, -23, -25, -24, -25, -28, -28,
-30, -31, -32, -32, -34, -35, -36, -38, -38, -39, -41, -41, -42, -43, -44, -46,
-46, -47, -48, -50, -50, -51, -51, -53, -54, -54, -56, -57, -58, -58, -60, -60,
-61, -62, -62, -64, -64, -65, -66, -67, -67, -68, -69, -70, -71, -71, -72, -73,
-73, -73, -75, -75, -75, -76, -78, -78, -78, -79, -79, -80, -81, -81, -82, -83,
-84, -84, -85, -84, -85, -86, -87, -86, -87, -88, -88, -89, -89, -90, -90, -91,
-91, -92, -92, -92, -92, -92, -93, -94, -94, -94, -94, -95, -96, -96, -96, -96,
-97, -97, -96, -98, -98, -99, -98, -98, -98, -98, -99, -99, -99, -99, -100, -99,
-100, -99, -100, -100, -100, -100, -100, -100, -100, -100, -100, -100, -100,
-100, -100, -100, -100, -100, -101, -100, -100, -99, -100, -99, -99, -99, -99,
-98, -98, -99, -98, -98, -98, -97, -97, -97, -96, -96, -95, -95, -95, -94, -94,
-93, -94, -93, -93, -92, -92, -92, -90, -89, -89, -89, -88, -88, -87, -87, -87,
-85, -84, -84, -83, -83, -82, -81, -80, -80, -80, -78, -77, -77, -76, -75, -74,
-74, -72, -72, -71, -70, -69, -68, -66, -65, -65, -64, -62, -61, -60, -59, -58,
-57, -56, -55, -54, -52, -51, -50, -48, -48, -46, -45, -43, -43, -41, -40, -39,
-37, -36, -34, -34, -32, -30, -29, -28, -27, -25, -24, -22, -22, -20, -18, -17,
-15, -14, -13, -11, -10, -8, -7, -5, -4, -2, 0, };