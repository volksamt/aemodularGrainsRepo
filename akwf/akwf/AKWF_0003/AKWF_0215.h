#define DATA_LENGTH 512
#define DATA AKWF_0215

const PROGMEM int8_t DATA[DATA_LENGTH] = {40, 48, 45, 49, 48, 50, 50, 50, 51,
53, 51, 53, 52, 55, 54, 56, 55, 57, 56, 58, 59, 59, 60, 60, 61, 61, 62, 63, 64,
64, 65, 65, 66, 67, 67, 68, 69, 69, 70, 71, 72, 72, 72, 74, 74, 75, 75, 75, 76,
77, 78, 78, 79, 80, 80, 80, 81, 82, 82, 84, 84, 85, 85, 85, 86, 88, 87, 88, 89,
89, 91, 90, 91, 93, 94, 93, 94, 96, 96, 96, 97, 96, 98, 99, 100, 100, 101, 101,
102, 102, 103, 103, 105, 106, 106, 106, 107, 108, 108, 109, 109, 110, 111, 112,
112, 112, 114, 114, 115, 116, 116, 116, 117, 118, 117, 119, 118, 117, 115, 114,
114, 112, 111, 109, 109, 107, 106, 104, 104, 102, 101, 100, 99, 98, 96, 95, 94,
93, 92, 90, 88, 87, 86, 85, 84, 84, 82, 81, 79, 79, 77, 76, 74, 74, 73, 71, 69,
68, 67, 66, 65, 63, 63, 61, 61, 58, 59, 56, 56, 53, 54, 50, 52, 46, 51, 37, -3,
1, -1, 1, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1,
0, 0, 0, 1, -1, 1, -2, 4, -11, -33, -28, -31, -30, -32, -31, -33, -32, -34, -34,
-34, -35, -35, -35, -36, -37, -37, -38, -38, -39, -39, -39, -40, -40, -41, -41,
-40, -42, -43, -42, -43, -43, -44, -44, -45, -45, -46, -46, -47, -47, -48, -48,
-49, -50, -49, -50, -51, -51, -52, -51, -53, -53, -53, -54, -54, -56, -56, -55,
-57, -56, -57, -57, -58, -58, -59, -59, -60, -60, -60, -61, -61, -62, -62, -63,
-63, -63, -64, -64, -65, -66, -66, -66, -67, -67, -69, -69, -69, -69, -70, -70,
-71, -72, -72, -73, -72, -72, -73, -74, -75, -75, -76, -76, -76, -76, -74, -74,
-74, -73, -73, -73, -73, -71, -72, -71, -70, -70, -70, -69, -69, -68, -69, -68,
-68, -67, -67, -66, -66, -65, -64, -65, -65, -64, -63, -63, -63, -62, -61, -61,
-61, -60, -60, -59, -60, -59, -59, -58, -58, -58, -57, -57, -56, -55, -55, -56,
-55, -54, -54, -54, -52, -52, -52, -52, -52, -51, -50, -51, -50, -49, -49, -48,
-48, -48, -48, -47, -46, -46, -47, -45, -45, -45, -44, -43, -43, -43, -43, -43,
-42, -41, -41, -41, -41, -39, -39, -39, -39, -37, -37, -37, -37, -37, -36, -36,
-35, -35, -35, -35, -33, -34, -32, -33, -31, -32, -30, -30, -30, -30, -31, -4,
1, -1, 1, -1, 1, -1, 1, 0, 0, 0, 0, 0, 0, -1, 1, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0,
0, 1, 1, 0, 0, 0, 0, 1, 0, -1, 0, 1, 0, -1, 0, 0, 0, 1, 0, -1, -1, 0, -1, 0, 0,
-1, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, -1, 0,
-1, 0, 0, 1, 0, 0, 0, 0, };