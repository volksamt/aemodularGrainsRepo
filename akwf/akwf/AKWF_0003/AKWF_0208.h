#define DATA_LENGTH 512
#define DATA AKWF_0208

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 3, 4, -11, -22, -18, -13, 5, 11,
22, 11, 16, 17, 17, 19, 14, 12, 11, 24, 19, 21, 8, 2, 4, 6, 3, -1, 1, 6, 17, 24,
14, 6, 29, 31, 33, 27, 26, 33, 42, 46, 43, 37, 37, 39, 44, 48, 37, 47, 32, 51,
69, 56, 53, 53, 74, 71, 53, 58, 59, 69, 76, 66, 62, 51, 59, 57, 65, 70, 68, 80,
94, 114, 107, 107, 94, 80, 86, 74, 68, 54, 56, 71, 65, 79, 84, 84, 88, 94, 102,
98, 98, 88, 95, 99, 85, 101, 90, 78, 83, 85, 85, 86, 96, 112, 118, 111, 103,
101, 93, 94, 106, 104, 102, 89, 80, 78, 86, 88, 88, 93, 88, 77, 72, 79, 72, 74,
80, 72, 73, 72, 72, 67, 67, 69, 57, 64, 59, 51, 47, 38, 36, 36, 26, 27, 15, -6,
-9, 1, -7, -14, -22, -29, -22, -34, -19, -9, -21, 1, 1, 3, -1, -4, 16, 0, 5, 11,
15, 6, -10, -2, -2, 7, 3, 2, 6, 8, 10, 5, 8, 2, 0, 8, 0, -4, -22, -40, -29, -33,
-26, -18, -13, -6, -4, 0, -6, -13, -8, 0, -1, 8, 5, 7, 20, 19, 32, 34, 26, 26,
39, 48, 56, 72, 76, 86, 84, 73, 73, 65, 55, 47, 39, 36, 38, 37, 30, 41, 49, 46,
50, 38, 56, 64, 58, 58, 45, 52, 55, 53, 56, 55, 54, 56, 52, 59, 58, 57, 43, 39,
40, 45, 33, 26, 37, 41, 41, 27, 35, 14, 12, 15, 9, 27, 29, 19, 7, 6, -5, -5, -8,
-26, -34, -34, -47, -39, -44, -48, -37, -36, -40, -54, -48, -37, -37, -41, -32,
-35, -54, -68, -69, -68, -73, -89, -86, -89, -83, -82, -99, -98, -95, -88, -94,
-80, -70, -77, -71, -81, -78, -79, -80, -82, -81, -72, -83, -84, -85, -71, -55,
-63, -64, -54, -64, -68, -79, -87, -79, -90, -93, -89, -79, -82, -73, -72, -62,
-66, -71, -68, -80, -66, -70, -62, -65, -73, -81, -90, -95, -97, -87, -78, -75,
-86, -95, -101, -110, -104, -80, -92, -84, -82, -93, -84, -82, -78, -75, -81,
-74, -62, -50, -47, -40, -26, -36, -26, -29, -21, -16, -16, -15, -10, -3, -3,
15, 20, 12, -2, -4, -11, -8, -1, -15, -22, -27, -33, -33, -29, -31, -32, -33,
-29, -22, -20, -17, -8, -4, 3, 18, 31, 21, 26, 32, 15, 17, 0, 6, 32, 22, 28, 25,
20, 22, 39, 44, 38, 39, 26, 24, 19, 21, 2, -7, -8, -9, 5, -10, -19, -4, -18,
-26, -27, -38, -38, -36, -29, -30, -16, -23, -33, -34, -34, -36, -35, -41, -46,
-31, -35, -41, -50, -37, -44, -39, -31, -43, -55, -67, -62, -57, -55, -57, -58,
-67, -54, -47, -49, -52, -58, -63, -59, -48, -43, -39, -39, -42, -49, -57, -63,
-63, -74, -70, -68, -53, -52, -62, -50, -49, -43, -71, -69, -62, -51, -51, -63,
-72, -74, -66, -71, -54, -32, -20, -13, -12, -3, -1, };