#define DATA_LENGTH 512
#define DATA AKWF_0250

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 10, 13, 17, 20, 24, 26, 29, 32,
35, 38, 40, 43, 45, 47, 49, 51, 53, 54, 55, 55, 57, 59, 60, 60, 62, 63, 63, 64,
66, 65, 67, 68, 68, 69, 70, 70, 71, 72, 72, 73, 72, 73, 73, 73, 74, 74, 74, 75,
75, 76, 77, 78, 79, 80, 83, 84, 85, 87, 90, 91, 93, 96, 98, 99, 101, 105, 105,
108, 110, 111, 112, 114, 116, 116, 118, 119, 118, 119, 119, 120, 119, 119, 118,
118, 117, 116, 116, 115, 115, 114, 114, 115, 114, 114, 114, 115, 113, 111, 108,
106, 104, 101, 97, 93, 89, 85, 81, 76, 72, 69, 64, 61, 56, 51, 47, 43, 39, 35,
31, 27, 22, 18, 14, 11, 5, 2, -3, -8, -11, -16, -22, -25, -30, -34, -37, -41,
-44, -47, -50, -53, -56, -57, -58, -61, -62, -62, -64, -63, -64, -65, -66, -66,
-66, -67, -66, -67, -67, -69, -69, -70, -70, -72, -73, -75, -77, -77, -80, -81,
-83, -84, -85, -88, -89, -90, -91, -92, -93, -94, -95, -94, -95, -95, -95, -95,
-95, -95, -95, -95, -95, -94, -94, -93, -93, -94, -93, -92, -92, -92, -91, -91,
-91, -90, -90, -90, -89, -89, -89, -88, -89, -89, -89, -89, -90, -90, -90, -90,
-90, -91, -91, -91, -92, -91, -90, -90, -88, -87, -86, -83, -83, -80, -78, -75,
-73, -71, -68, -66, -63, -60, -56, -53, -50, -47, -44, -41, -37, -33, -31, -27,
-23, -20, -17, -12, -9, -6, -2, 1, 5, 8, 11, 15, 18, 20, 23, 27, 30, 33, 34, 37,
40, 43, 44, 47, 49, 51, 52, 54, 56, 58, 59, 60, 61, 61, 62, 63, 64, 65, 65, 66,
65, 65, 66, 65, 65, 64, 63, 62, 60, 60, 58, 57, 55, 55, 53, 52, 50, 50, 49, 47,
48, 47, 47, 48, 48, 48, 50, 51, 53, 54, 56, 58, 60, 63, 66, 69, 72, 77, 80, 84,
87, 89, 92, 93, 93, 94, 92, 92, 90, 89, 88, 84, 82, 81, 78, 74, 71, 69, 66, 63,
60, 58, 54, 52, 50, 46, 44, 42, 41, 37, 35, 34, 32, 30, 28, 26, 25, 23, 21, 20,
19, 17, 15, 13, 12, 11, 9, 8, 6, 4, 2, 0, -2, -4, -7, -9, -11, -13, -15, -17,
-19, -20, -22, -24, -25, -26, -27, -26, -27, -27, -27, -26, -25, -24, -24, -22,
-21, -20, -20, -18, -17, -15, -15, -15, -14, -14, -14, -14, -14, -14, -16, -18,
-18, -19, -22, -25, -27, -31, -33, -36, -40, -43, -47, -51, -55, -59, -62, -65,
-69, -72, -74, -77, -79, -81, -82, -83, -84, -85, -85, -86, -85, -86, -86, -86,
-85, -85, -85, -84, -85, -84, -85, -84, -84, -85, -85, -86, -86, -87, -88, -89,
-91, -93, -95, -97, -98, -100, -101, -101, -103, -102, -101, -100, -100, -96,
-95, -92, -89, -86, -84, -81, -77, -74, -70, -67, -63, -60, -55, -52, -48, -45,
-40, -37, -32, -29, -26, -21, -17, -14, -11, -8, -3, 1, };