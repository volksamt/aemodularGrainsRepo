#define DATA_LENGTH 512
#define DATA AKWF_0275

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 12, 15, 19, 21, 26, 29, 32,
36, 39, 42, 46, 49, 52, 57, 61, 64, 67, 71, 74, 78, 81, 84, 89, 91, 94, 97, 100,
103, 106, 108, 110, 112, 114, 115, 116, 117, 119, 119, 119, 119, 119, 118, 117,
117, 114, 112, 110, 108, 105, 103, 100, 95, 93, 88, 84, 80, 75, 71, 66, 61, 56,
51, 46, 40, 36, 31, 26, 21, 15, 10, 5, 0, -5, -9, -14, -18, -23, -27, -31, -35,
-39, -42, -45, -49, -52, -54, -56, -58, -60, -62, -63, -65, -65, -66, -66, -67,
-66, -66, -67, -65, -64, -64, -62, -62, -59, -58, -57, -54, -53, -51, -49, -46,
-44, -42, -39, -37, -34, -32, -29, -26, -23, -21, -18, -15, -12, -9, -7, -5, -2,
0, 3, 5, 6, 9, 11, 13, 15, 17, 19, 20, 22, 23, 24, 25, 27, 27, 27, 29, 30, 30,
31, 31, 31, 30, 32, 31, 31, 31, 30, 30, 29, 27, 28, 26, 24, 23, 20, 19, 17, 15,
14, 12, 9, 8, 6, 3, 1, -2, -5, -8, -10, -12, -15, -18, -20, -22, -25, -28, -29,
-31, -33, -35, -37, -38, -41, -41, -43, -44, -45, -45, -45, -46, -46, -46, -46,
-46, -46, -45, -44, -44, -43, -42, -41, -40, -39, -37, -35, -33, -32, -29, -27,
-25, -23, -20, -19, -17, -15, -12, -11, -7, -6, -4, -2, 0, 2, 4, 4, 7, 9, 10,
12, 14, 15, 17, 17, 19, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31, 32, 32, 33,
33, 34, 34, 34, 33, 34, 35, 34, 35, 34, 35, 34, 35, 35, 35, 35, 35, 35, 35, 35,
34, 34, 33, 34, 34, 33, 33, 33, 31, 31, 31, 30, 29, 28, 28, 26, 25, 25, 24, 22,
20, 20, 18, 17, 15, 13, 12, 10, 9, 7, 6, 4, 2, 0, -2, -4, -5, -7, -10, -10, -13,
-14, -15, -16, -18, -20, -22, -23, -23, -25, -26, -27, -27, -28, -28, -30, -29,
-30, -31, -30, -30, -30, -29, -29, -28, -27, -25, -24, -22, -20, -20, -18, -15,
-14, -12, -10, -8, -5, -3, -1, 2, 4, 6, 9, 12, 14, 17, 19, 21, 23, 26, 29, 31,
34, 35, 37, 40, 40, 43, 44, 46, 47, 48, 49, 49, 51, 51, 52, 52, 52, 51, 52, 52,
51, 51, 49, 48, 47, 46, 44, 43, 42, 40, 38, 37, 35, 33, 31, 29, 27, 25, 24, 21,
18, 17, 14, 12, 8, 6, 3, 2, -2, -4, -7, -10, -13, -15, -19, -22, -24, -27, -31,
-35, -38, -40, -44, -48, -50, -54, -57, -60, -63, -66, -68, -71, -73, -76, -78,
-81, -83, -85, -86, -89, -90, -91, -93, -94, -95, -97, -97, -98, -98, -98, -98,
-98, -98, -98, -97, -97, -95, -95, -94, -93, -91, -89, -88, -86, -84, -82, -81,
-79, -76, -74, -73, -69, -67, -65, -62, -60, -58, -55, -52, -49, -46, -43, -41,
-38, -35, -32, -29, -26, -22, -19, -17, -14, -10, -7, -3, 0, };