#define DATA_LENGTH 512
#define DATA AKWF_0286

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, -1, -1, -51, -114, -113, -108, -116, -112, -95, -69, -47, -32,
-25, -22, -22, -22, -21, -19, -12, -4, 5, 15, 24, 34, 42, 49, 54, 60, 64, 67,
70, 72, 74, 76, 76, 76, 75, 74, 72, 69, 67, 64, 61, 57, 52, 48, 43, 39, 34, 29,
24, 19, 15, 11, 5, 1, -3, -8, -12, -15, -18, -22, -25, -28, -29, -32, -33, -35,
-36, -37, -38, -38, -38, -38, -38, -37, -36, -35, -34, -32, -30, -30, -28, -25,
-24, -21, -19, -17, -15, -13, -10, -8, -6, -5, -2, -1, 1, 2, 5, 6, 8, 9, 10, 11,
12, 13, 13, 14, 14, 15, 15, 15, 16, 15, 15, 14, 14, 13, 12, 13, 12, 11, 10, 11,
9, 8, 7, 6, 5, 4, 4, 2, 2, 1, 1, 0, -1, -1, -3, -3, -3, -3, -5, -4, -5, -5, -5,
-6, -6, -5, -5, -6, -6, -5, -5, -6, -6, -5, -5, -5, -4, -4, -4, -2, -3, -2, -2,
-2, -1, -1, -1, -1, -1, 0, 0, 1, 1, 1, 1, 1, 1, 2, 2, 2, 2, 2, 3, 2, 3, 3, 2, 3,
2, 2, 3, 2, 2, 3, 2, 2, 2, 1, 2, 1, 1, 1, 1, 1, 2, 1, 1, 0, 1, 1, 0, 0, 0, -1,
0, -1, -1, 0, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, 0, 0, -1, -1, 0, -1, -1,
-1, 0, -1, 0, 0, -1, -1, 0, -1, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0,
1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, -1,
1, -1, 0, -1, 0, 0, 0, -1, -1, 0, -1, -1, 0, -1, 0, 0, -1, -1, 0, -1, 0, 0, -1,
0, -1, 1, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, -1, 0, 0, 0, 0, 0, -1, 0,
0, 0, 0, 0, 0, 0, -1, -1, 0, -1, 0, -1, 0, -1, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0,
-1, -1, -1, 0, 0, -1, 0, 0, -1, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, -1, -1,
-1, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0,
0, 0, 0, -1, 0, -1, -1, 0, 0, 0, -1, 0, -1, 1, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0,
0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, -1,
0, 1, 1, 0, -1, 0, 0, 0, 1, -1, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0,
-1, -1, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, -1, };