#define DATA_LENGTH 512
#define DATA AKWF_0277

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 3, 3, 4, 5, 4, 6, 5, 5, 5, 4,
5, 4, 4, 4, 4, 3, 4, 3, 4, 4, 3, 3, 3, 4, 4, 4, 4, 4, 5, 6, 6, 8, 8, 10, 11, 12,
14, 16, 17, 19, 20, 23, 24, 26, 29, 31, 34, 35, 39, 41, 43, 47, 49, 52, 55, 58,
60, 62, 66, 69, 70, 74, 76, 78, 80, 83, 85, 87, 89, 90, 92, 94, 95, 96, 97, 97,
98, 99, 99, 99, 99, 100, 100, 100, 99, 99, 100, 98, 98, 97, 96, 95, 94, 93, 91,
92, 90, 89, 87, 87, 87, 85, 84, 82, 81, 80, 79, 77, 76, 76, 74, 73, 71, 69, 67,
67, 65, 63, 62, 59, 58, 56, 55, 52, 52, 49, 48, 46, 44, 41, 40, 40, 37, 36, 35,
33, 32, 31, 29, 29, 29, 28, 26, 26, 26, 26, 25, 25, 26, 25, 25, 26, 27, 26, 28,
29, 30, 30, 31, 32, 34, 34, 36, 38, 39, 40, 41, 43, 44, 45, 46, 47, 48, 47, 46,
46, 44, 44, 42, 39, 37, 33, 30, 27, 24, 19, 15, 10, 6, 0, -5, -11, -15, -21,
-26, -31, -36, -40, -45, -49, -54, -57, -60, -64, -67, -68, -71, -72, -74, -74,
-75, -75, -75, -75, -73, -73, -71, -69, -67, -64, -61, -58, -54, -50, -46, -42,
-38, -34, -29, -24, -19, -15, -10, -4, 0, 5, 9, 14, 18, 22, 26, 29, 33, 35, 39,
41, 43, 46, 46, 48, 49, 51, 51, 51, 52, 51, 50, 50, 50, 48, 47, 45, 45, 42, 40,
39, 37, 35, 32, 31, 28, 26, 24, 22, 19, 17, 15, 13, 11, 9, 7, 5, 5, 3, 2, 1, 0,
-1, -2, -2, -3, -4, -3, -4, -4, -2, -3, -1, -2, -2, -3, -4, -4, -7, -8, -10,
-12, -15, -19, -22, -25, -28, -32, -37, -41, -46, -51, -56, -61, -66, -71, -76,
-80, -86, -90, -94, -98, -102, -104, -108, -111, -113, -114, -117, -118, -118,
-120, -119, -119, -118, -117, -115, -113, -111, -109, -105, -103, -98, -95, -91,
-86, -81, -77, -72, -67, -63, -57, -52, -46, -42, -36, -31, -26, -21, -16, -11,
-8, -3, 0, 3, 7, 9, 12, 14, 15, 17, 19, 19, 19, 20, 19, 20, 18, 17, 17, 15, 13,
11, 9, 7, 4, 2, -1, -4, -7, -9, -12, -14, -18, -20, -23, -26, -27, -30, -32,
-33, -35, -37, -38, -39, -40, -41, -42, -41, -41, -41, -39, -39, -37, -36, -34,
-32, -29, -27, -23, -21, -19, -17, -14, -13, -10, -9, -8, -6, -6, -4, -4, -4,
-4, -5, -5, -6, -8, -10, -12, -14, -17, -20, -22, -24, -27, -31, -34, -37, -40,
-43, -46, -48, -52, -54, -56, -59, -61, -63, -64, -67, -68, -69, -70, -72, -72,
-73, -72, -73, -73, -72, -71, -71, -69, -68, -66, -65, -63, -61, -59, -56, -53,
-51, -47, -45, -42, -39, -36, -33, -31, -26, -24, -22, -19, -17, -15, -12, -10,
-8, -6, -4, -3, -2, -1, };