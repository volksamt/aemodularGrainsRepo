#define DATA_LENGTH 512
#define DATA AKWF_0232

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 4, 6, 6, 7, 9, 11, 13, 14,
14, 16, 16, 18, 19, 21, 23, 23, 25, 26, 27, 28, 30, 31, 33, 34, 35, 36, 37, 39,
39, 41, 41, 43, 44, 46, 47, 47, 49, 50, 52, 53, 54, 55, 56, 57, 58, 60, 60, 62,
63, 64, 64, 66, 67, 69, 69, 70, 71, 73, 74, 75, 75, 78, 78, 80, 80, 81, 82, 84,
84, 85, 86, 87, 88, 89, 91, 91, 92, 93, 94, 95, 96, 97, 98, 98, 99, 101, 101,
102, 104, 104, 105, 107, 107, 108, 109, 109, 110, 111, 112, 114, 114, 115, 115,
116, 117, 116, 117, 117, 118, 118, 118, 119, 119, 119, 119, 119, 119, 119, 118,
119, 119, 119, 119, 119, 118, 118, 118, 118, 118, 117, 118, 117, 116, 115, 116,
115, 115, 114, 114, 113, 112, 113, 113, 112, 111, 110, 110, 110, 109, 108, 108,
107, 106, 106, 105, 105, 104, 103, 103, 102, 102, 101, 100, 99, 98, 97, 97, 97,
96, 95, 93, 93, 92, 91, 90, 90, 88, 88, 87, 85, 84, 84, 82, 82, 81, 80, 80, 79,
77, 76, 76, 74, 74, 72, 71, 71, 69, 69, 67, 66, 65, 65, 63, 62, 60, 59, 59, 58,
57, 55, 55, 53, 52, 51, 50, 49, 47, 45, 45, 43, 43, 42, 40, 38, 37, 36, 35, 34,
33, 31, 29, 29, 28, 26, 25, 23, 22, 22, 19, 18, 17, 15, 14, 13, 11, 9, 9, 7, 6,
5, 3, 2, 1, -1, -2, -3, -5, -6, -7, -7, -10, -10, -12, -13, -15, -16, -18, -19,
-20, -21, -22, -23, -25, -26, -27, -29, -30, -31, -32, -34, -35, -36, -38, -39,
-39, -41, -42, -44, -45, -46, -47, -48, -50, -50, -51, -53, -54, -55, -56, -57,
-58, -60, -60, -62, -63, -64, -65, -66, -67, -68, -70, -71, -72, -72, -74, -75,
-76, -77, -78, -79, -80, -81, -82, -83, -85, -85, -86, -87, -88, -90, -90, -91,
-92, -93, -95, -95, -96, -97, -97, -99, -100, -100, -102, -103, -103, -104,
-105, -106, -107, -108, -109, -109, -110, -112, -112, -113, -114, -114, -115,
-115, -116, -116, -117, -118, -119, -118, -119, -118, -119, -118, -119, -118,
-119, -120, -119, -119, -119, -118, -119, -118, -118, -118, -118, -118, -118,
-117, -117, -118, -117, -116, -116, -114, -115, -114, -114, -114, -113, -112,
-112, -111, -110, -110, -110, -109, -109, -108, -107, -107, -107, -105, -105,
-104, -104, -103, -103, -102, -102, -101, -100, -99, -98, -97, -96, -96, -96,
-94, -93, -93, -92, -90, -90, -89, -88, -87, -86, -86, -86, -84, -84, -82, -81,
-80, -79, -79, -77, -77, -76, -74, -73, -72, -71, -70, -69, -69, -68, -67, -65,
-65, -63, -62, -61, -60, -59, -58, -56, -55, -54, -53, -52, -50, -49, -48, -47,
-47, -45, -44, -43, -41, -40, -39, -38, -36, -35, -34, -32, -31, -30, -29, -27,
-26, -24, -23, -22, -20, -19, -17, -17, -15, -14, -13, -11, -11, -9, -8, -6, -5,
-4, -2, -1, };