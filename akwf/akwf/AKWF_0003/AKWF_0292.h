#define DATA_LENGTH 512
#define DATA AKWF_0292

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 1, 0, 0, 0,
0, 0, 0, -1, 0, -1, 1, 0, -1, 0, 0, 1, 1, -1, 0, -14, -65, -114, -112, -86, -66,
-57, -57, -58, -57, -50, -39, -28, -17, -6, 2, 8, 14, 20, 26, 32, 37, 43, 45,
49, 53, 54, 56, 57, 57, 58, 56, 54, 54, 52, 49, 45, 42, 39, 36, 32, 28, 25, 22,
18, 14, 10, 7, 3, 0, -3, -5, -8, -10, -13, -15, -17, -18, -19, -19, -21, -22,
-22, -22, -21, -22, -21, -20, -20, -19, -18, -17, -17, -15, -14, -14, -12, -10,
-9, -8, -7, -5, -4, -3, -2, 0, 0, 1, 3, 4, 5, 5, 5, 7, 6, 8, 7, 8, 8, 9, 10, 9,
10, 9, 9, 9, 9, 8, 9, 8, 8, 7, 7, 7, 6, 7, 5, 5, 5, 4, 4, 4, 3, 2, 2, 2, 1, 2,
2, 1, 0, -1, 0, 0, -1, -1, -1, -2, -2, -2, -2, -2, -2, -3, -3, -3, -2, -2, -2,
-3, -3, -4, -3, -3, -4, -3, -2, -3, -3, -2, -2, -2, -3, -2, -2, -2, -3, -2, -2,
-1, -2, -2, -1, -1, -1, -2, -2, -2, -2, -1, -1, -2, -2, -1, -1, -1, -1, -1, -1,
0, -2, 0, 0, -1, -1, 0, -1, -1, -1, -1, -1, -1, 0, -1, 0, -1, -1, -1, -1, -1,
-2, -1, -1, -1, 0, -2, -1, -1, -1, -1, -1, -1, 0, -1, -1, 0, 0, -1, 0, -1, -1,
-1, 0, -1, 0, -1, 0, -1, 0, 0, -1, -1, -1, -1, -1, 0, 0, 0, 0, 0, 0, -1, -1, 0,
-1, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, -1, 0, 0, 1, -1, 0, 0, 0, 0, 0, 1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1,
1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 1, 0, 1,
1, 0, 0, 0, 0, 1, -1, 0, 0, 1, 0, 1, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, 1, 1, 1,
0, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1,
1, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, 1, 1, 0, 0, -1,
0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0,
1, 1, 0, 0, 1, 0, -1, 0, 0, 0, 0, 1, 1, 0, -1, 0, 0, 1, 0, 0, 0, 0, 1, 0, };