#define DATA_LENGTH 512
#define DATA AKWF_0288

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 6, 9, 10, 12, 14, 15, 16, 17,
19, 18, 19, 19, 20, 19, 20, 21, 21, 19, 20, 19, 20, 19, 19, 18, 19, 18, 17, 17,
16, 16, 16, 15, 15, 15, 13, 13, 12, 12, 12, 11, 11, 11, 10, 9, 9, 9, 9, 8, 7, 7,
7, 6, 6, 6, 5, 4, 4, 4, 4, 4, 4, 3, 3, 2, 2, 3, 1, 1, 1, 2, 1, 0, 1, 1, 0, 0, 1,
0, 0, 0, 0, -1, 0, -1, -1, -1, -1, -2, -1, -1, -1, -2, -2, -1, -2, -1, -1, -1,
-1, -2, -2, -2, -2, -1, -2, -2, -2, -2, -2, -2, -1, -1, -2, -1, -2, -2, -2, -1,
-2, -1, -2, -2, -2, -2, -1, -1, -1, -2, -2, -1, -1, -2, -2, -1, -2, -2, -1, -1,
-2, -1, -1, -1, -1, -1, -1, -2, -1, -1, -2, -1, -1, -1, -1, -1, -1, -1, -1, -1,
-1, -1, 0, -1, -1, -1, -1, -1, -1, -1, -1, 0, 0, -1, 0, -1, -1, -1, 0, -1, -1,
-1, -1, -1, 0, -1, 0, 0, -1, 0, 0, 0, -1, -1, 0, -1, -1, 0, 0, 0, 0, 1, 0, 0,
-1, 0, 0, 0, -1, 0, -1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 0, 0, 0, 0, 1, 1, 1,
0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, 1, 0, 0, 0, 0, 0,
1, 0, 1, 1, 0, 0, 1, 0, 1, -1, 0, 0, 0, 1, 0, 1, -1, 0, 0, 1, 1, 1, 0, 1, 1, 1,
1, 1, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, -1, 0, 0, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0,
0, 0, 0, 0, 0, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 0, 1, 0, 0,
0, 1, 1, 1, 1, 0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 1, 1, 0, 1, 1, 0, 1, 0, 1, 1, 0, 0,
1, 1, 1, 1, 1, 0, 0, 0, 1, 1, 0, 0, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 1,
1, 1, 1, 0, 0, 0, 0, 1, 0, 1, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 1, 1, 0, 1, 1, 0, 1,
1, 1, 1, 1, 0, 0, 0, 1, 1, 1, 0, 0, 0, 1, 1, 0, 0, 1, 1, 1, 1, 0, 0, 0, 0, 1, 0,
0, 1, 0, 0, 1, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 0, 1, 1, 0, 0, 1, 0,
1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, -1, 1, -1, 2, -2, 2, -2, 4, -3, 5, -6, 10,
-25, -124, -99, -93, -79, -71, -62, -53, -47, -38, -34, -25, -22, -16, -13, -7,
-5, 0, };