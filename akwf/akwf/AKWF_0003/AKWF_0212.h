#define DATA_LENGTH 512
#define DATA AKWF_0212

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 1, 1, 2, 2, 3, 4, 3, 3, 4, 4,
4, 5, 5, 4, 4, 5, 4, 5, 5, 4, 4, 4, 4, 4, 5, 4, 4, 4, 3, 4, 3, 3, 3, 3, 3, 3, 3,
3, 3, 3, 3, 4, 4, 4, 5, 5, 6, 6, 7, 8, 8, 10, 10, 11, 13, 14, 15, 15, 17, 17,
18, 19, 21, 21, 23, 24, 26, 27, 28, 30, 31, 33, 35, 37, 38, 40, 42, 46, 48, 51,
53, 56, 57, 60, 63, 65, 68, 69, 73, 74, 77, 78, 81, 81, 84, 86, 86, 89, 90, 91,
92, 94, 96, 97, 97, 98, 98, 100, 100, 102, 102, 103, 104, 105, 105, 106, 107,
107, 108, 109, 109, 110, 111, 112, 112, 112, 113, 112, 113, 113, 113, 114, 113,
113, 113, 113, 114, 114, 114, 113, 113, 114, 112, 112, 113, 112, 111, 111, 110,
110, 108, 108, 108, 107, 106, 106, 105, 105, 104, 103, 102, 102, 101, 101, 100,
99, 98, 98, 98, 97, 97, 97, 96, 95, 94, 94, 94, 93, 93, 92, 92, 92, 91, 90, 90,
90, 90, 88, 88, 88, 87, 87, 85, 84, 84, 83, 83, 81, 81, 80, 79, 78, 77, 76, 76,
74, 74, 73, 72, 71, 70, 69, 68, 68, 68, 67, 65, 65, 64, 62, 62, 61, 59, 59, 57,
56, 55, 54, 52, 51, 50, 49, 47, 46, 44, 43, 41, 39, 36, 36, 34, 32, 31, 28, 26,
25, 22, 20, 19, 18, 15, 14, 12, 11, 8, 7, 6, 4, 3, 2, 1, -1, -2, -3, -5, -6, -7,
-9, -10, -11, -13, -14, -15, -16, -16, -17, -18, -19, -20, -21, -23, -24, -26,
-27, -27, -28, -29, -30, -31, -33, -33, -34, -36, -37, -38, -39, -41, -42, -44,
-44, -46, -48, -48, -50, -51, -52, -53, -55, -56, -58, -60, -61, -63, -65, -65,
-67, -68, -69, -71, -71, -73, -74, -75, -76, -79, -80, -81, -83, -83, -84, -86,
-87, -89, -91, -94, -94, -96, -97, -99, -100, -102, -103, -105, -106, -108,
-109, -110, -112, -112, -113, -113, -114, -115, -116, -117, -117, -118, -118,
-118, -119, -118, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119,
-118, -119, -119, -118, -118, -118, -118, -118, -117, -116, -116, -116, -115,
-115, -114, -114, -113, -113, -112, -111, -110, -109, -109, -107, -107, -105,
-103, -102, -101, -100, -99, -98, -97, -94, -93, -91, -89, -88, -87, -85, -84,
-83, -81, -79, -79, -77, -75, -73, -71, -69, -68, -67, -67, -64, -64, -63, -61,
-61, -59, -58, -58, -57, -56, -54, -53, -53, -51, -51, -49, -49, -48, -47, -46,
-47, -45, -45, -44, -43, -43, -42, -41, -40, -40, -40, -39, -37, -37, -36, -36,
-36, -35, -35, -33, -33, -32, -32, -32, -31, -31, -30, -30, -29, -28, -28, -27,
-26, -26, -25, -24, -24, -23, -22, -22, -21, -19, -19, -19, -18, -17, -16, -16,
-14, -13, -12, -13, -10, -9, -8, -7, -6, -5, -5, -4, -3, -2, -2, -2, 0, };