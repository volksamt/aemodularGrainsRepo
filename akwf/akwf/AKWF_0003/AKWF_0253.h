#define DATA_LENGTH 512
#define DATA AKWF_0253

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 11, 14, 17, 19, 22, 25, 28,
30, 34, 35, 39, 41, 43, 45, 48, 50, 52, 53, 56, 58, 60, 62, 63, 65, 67, 69, 70,
72, 73, 74, 76, 78, 79, 79, 81, 83, 83, 84, 85, 86, 88, 89, 89, 91, 91, 92, 94,
94, 95, 97, 97, 98, 98, 100, 101, 101, 103, 103, 104, 105, 106, 107, 107, 108,
108, 109, 110, 111, 111, 111, 112, 113, 112, 113, 113, 113, 113, 113, 113, 113,
114, 113, 112, 112, 112, 113, 112, 112, 112, 112, 111, 111, 111, 111, 110, 110,
109, 109, 109, 109, 109, 109, 108, 108, 108, 107, 108, 107, 107, 107, 106, 106,
108, 108, 107, 108, 107, 107, 107, 108, 107, 107, 108, 108, 109, 109, 109, 108,
108, 109, 108, 108, 109, 108, 109, 107, 107, 107, 107, 107, 106, 105, 104, 103,
102, 102, 100, 100, 98, 98, 97, 95, 94, 94, 92, 90, 89, 88, 87, 87, 85, 83, 82,
80, 79, 78, 76, 75, 74, 72, 71, 69, 68, 66, 66, 63, 62, 62, 60, 59, 57, 57, 56,
54, 53, 52, 51, 50, 50, 49, 47, 47, 45, 44, 43, 43, 41, 40, 40, 38, 37, 36, 35,
34, 32, 32, 31, 29, 29, 27, 26, 25, 23, 22, 22, 20, 19, 19, 17, 16, 15, 15, 14,
13, 12, 11, 11, 9, 9, 9, 7, 8, 6, 6, 6, 6, 5, 5, 5, 5, 4, 5, 4, 5, 5, 5, 4, 6,
6, 6, 5, 6, 6, 7, 8, 8, 8, 7, 8, 9, 7, 8, 8, 8, 7, 7, 7, 7, 7, 6, 5, 5, 4, 4, 4,
2, 2, 1, 0, -1, -2, -3, -4, -5, -6, -7, -8, -10, -11, -12, -13, -14, -16, -17,
-18, -20, -20, -21, -23, -25, -25, -27, -29, -29, -31, -32, -34, -36, -36, -38,
-39, -40, -40, -42, -43, -45, -46, -47, -48, -50, -50, -52, -53, -54, -55, -56,
-58, -59, -61, -62, -64, -65, -66, -68, -69, -72, -73, -75, -75, -77, -79, -80,
-81, -83, -85, -85, -87, -89, -90, -91, -93, -94, -95, -96, -98, -99, -99, -100,
-101, -102, -104, -104, -105, -106, -106, -107, -108, -108, -109, -110, -110,
-109, -110, -110, -111, -111, -110, -110, -110, -110, -110, -111, -111, -111,
-111, -110, -110, -110, -110, -110, -111, -110, -110, -110, -110, -110, -111,
-111, -112, -111, -112, -112, -112, -113, -113, -113, -113, -115, -114, -115,
-115, -116, -116, -116, -117, -117, -118, -117, -118, -118, -118, -118, -118,
-119, -119, -119, -120, -119, -119, -118, -119, -119, -118, -119, -118, -117,
-118, -117, -116, -116, -115, -114, -114, -113, -112, -112, -110, -109, -108,
-108, -107, -105, -104, -104, -103, -102, -102, -99, -99, -98, -97, -96, -95,
-94, -93, -92, -90, -89, -88, -86, -86, -84, -83, -82, -80, -79, -77, -75, -74,
-72, -70, -69, -66, -64, -63, -61, -59, -57, -55, -53, -50, -48, -46, -43, -40,
-37, -36, -34, -30, -28, -25, -22, -20, -16, -13, -10, -7, -3, -1, };