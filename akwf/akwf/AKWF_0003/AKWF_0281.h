#define DATA_LENGTH 512
#define DATA AKWF_0281

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 6, 8, 12, 15, 17, 22, 25, 28,
32, 34, 38, 42, 46, 49, 52, 55, 59, 62, 66, 69, 72, 75, 78, 81, 83, 86, 89, 92,
94, 95, 97, 99, 101, 103, 103, 105, 106, 106, 106, 107, 108, 107, 107, 107, 106,
106, 104, 104, 103, 102, 100, 99, 98, 96, 94, 92, 89, 87, 85, 83, 80, 78, 75,
72, 70, 67, 65, 62, 60, 57, 54, 52, 49, 47, 45, 42, 41, 38, 37, 35, 34, 33, 31,
30, 28, 27, 26, 25, 23, 22, 22, 21, 20, 19, 19, 17, 16, 15, 14, 14, 13, 12, 10,
10, 8, 7, 6, 5, 4, 4, 3, 2, 0, -1, -1, -4, -5, -6, -8, -10, -12, -14, -15, -18,
-21, -23, -26, -28, -31, -34, -36, -40, -43, -45, -48, -52, -55, -57, -61, -64,
-68, -70, -74, -77, -80, -83, -86, -88, -93, -95, -98, -100, -103, -105, -107,
-109, -112, -113, -115, -116, -116, -117, -118, -119, -118, -119, -119, -117,
-118, -117, -115, -114, -112, -111, -110, -109, -106, -104, -102, -100, -98,
-95, -93, -91, -89, -87, -84, -82, -79, -77, -75, -72, -70, -68, -66, -63, -61,
-58, -55, -53, -50, -47, -45, -42, -40, -37, -35, -32, -29, -26, -24, -21, -18,
-16, -14, -11, -8, -6, -3, -1, 1, 3, 6, 8, 10, 11, 13, 15, 16, 18, 19, 20, 21,
23, 24, 25, 26, 26, 27, 28, 29, 30, 30, 31, 32, 31, 33, 33, 35, 35, 36, 37, 39,
39, 41, 42, 42, 44, 45, 46, 48, 49, 50, 51, 53, 55, 56, 58, 60, 61, 63, 65, 66,
68, 70, 70, 72, 75, 75, 77, 78, 80, 81, 83, 83, 84, 84, 87, 87, 88, 89, 89, 89,
89, 90, 89, 89, 89, 88, 88, 89, 87, 87, 85, 85, 83, 81, 80, 78, 76, 75, 72, 69,
67, 65, 63, 59, 57, 54, 50, 47, 44, 41, 37, 35, 32, 28, 25, 22, 20, 16, 13, 12,
10, 7, 5, 3, 2, 1, -1, -2, -2, -2, -3, -3, -2, -3, -3, -2, -2, -1, -1, -2, -2,
-2, -2, -3, -3, -4, -4, -5, -7, -8, -10, -10, -12, -13, -15, -18, -19, -21, -23,
-24, -26, -29, -30, -32, -34, -36, -38, -40, -41, -43, -44, -46, -48, -50, -51,
-53, -53, -54, -56, -57, -58, -59, -60, -61, -62, -63, -64, -64, -65, -65, -66,
-66, -67, -67, -67, -68, -68, -68, -67, -67, -67, -67, -65, -65, -64, -62, -61,
-60, -58, -56, -54, -52, -50, -47, -46, -44, -41, -38, -36, -34, -32, -30, -27,
-26, -23, -23, -21, -19, -17, -17, -16, -16, -16, -14, -15, -16, -15, -16, -16,
-17, -18, -20, -20, -22, -22, -23, -25, -25, -26, -27, -28, -29, -29, -30, -30,
-31, -31, -31, -31, -31, -31, -31, -30, -31, -30, -29, -29, -29, -29, -28, -28,
-27, -27, -27, -26, -26, -27, -26, -26, -25, -25, -25, -25, -24, -23, -23, -22,
-20, -18, -18, -15, -13, -12, -10, -8, -5, -2, };