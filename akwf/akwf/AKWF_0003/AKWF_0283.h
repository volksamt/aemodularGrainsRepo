#define DATA_LENGTH 512
#define DATA AKWF_0283

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 9, 10, 14, 15, 17, 19, 21,
25, 26, 29, 30, 33, 36, 37, 39, 41, 44, 46, 48, 50, 52, 53, 54, 56, 57, 58, 58,
59, 60, 60, 61, 61, 60, 60, 61, 60, 61, 59, 60, 60, 59, 59, 58, 56, 56, 57, 56,
54, 53, 53, 52, 52, 50, 50, 48, 47, 45, 45, 43, 41, 39, 38, 36, 35, 32, 31, 28,
28, 25, 23, 20, 19, 16, 13, 11, 8, 5, 3, 0, -2, -6, -9, -11, -14, -17, -21, -23,
-25, -29, -31, -33, -36, -37, -40, -42, -44, -45, -47, -49, -50, -51, -53, -53,
-55, -55, -55, -56, -57, -57, -57, -56, -56, -56, -55, -53, -52, -52, -50, -48,
-47, -46, -43, -42, -41, -39, -36, -35, -32, -31, -28, -26, -24, -23, -21, -19,
-16, -15, -13, -12, -11, -10, -8, -7, -6, -4, -3, -2, -1, 0, 1, 2, 4, 5, 6, 8,
9, 9, 11, 13, 13, 15, 15, 17, 18, 19, 20, 22, 23, 23, 24, 26, 26, 27, 29, 30,
31, 32, 33, 35, 36, 37, 40, 41, 43, 44, 46, 49, 50, 52, 55, 57, 58, 61, 64, 66,
68, 71, 74, 76, 78, 80, 82, 84, 86, 88, 90, 92, 95, 96, 98, 100, 101, 103, 105,
106, 108, 109, 110, 112, 113, 114, 115, 116, 117, 117, 117, 119, 118, 119, 120,
119, 120, 119, 118, 118, 118, 117, 116, 115, 115, 114, 114, 111, 110, 109, 108,
106, 105, 104, 103, 101, 100, 97, 97, 95, 94, 92, 91, 89, 87, 85, 83, 82, 80,
78, 76, 75, 74, 72, 70, 69, 67, 66, 64, 61, 60, 58, 57, 55, 53, 52, 50, 49, 47,
45, 42, 40, 38, 35, 33, 31, 28, 25, 23, 20, 18, 14, 12, 9, 6, 4, 2, -1, -2, -5,
-7, -9, -11, -12, -15, -17, -19, -20, -22, -23, -26, -27, -29, -31, -33, -35,
-36, -37, -38, -40, -41, -43, -44, -45, -47, -48, -48, -49, -49, -50, -50, -51,
-51, -52, -54, -54, -55, -55, -55, -56, -56, -58, -58, -59, -59, -59, -59, -58,
-58, -57, -57, -57, -56, -55, -54, -53, -51, -51, -49, -49, -46, -45, -44, -43,
-41, -41, -39, -39, -38, -38, -38, -38, -38, -38, -40, -40, -40, -41, -41, -42,
-43, -43, -44, -44, -46, -47, -48, -49, -49, -51, -52, -53, -54, -56, -57, -58,
-60, -61, -63, -66, -68, -70, -71, -73, -76, -78, -80, -83, -84, -86, -89, -91,
-93, -94, -97, -98, -101, -103, -104, -105, -107, -108, -108, -110, -111, -112,
-113, -113, -114, -114, -114, -113, -113, -112, -110, -108, -107, -106, -104,
-101, -99, -97, -93, -91, -87, -85, -82, -78, -76, -73, -71, -67, -65, -62, -60,
-59, -56, -54, -52, -49, -48, -46, -44, -42, -41, -40, -38, -37, -36, -35, -33,
-33, -33, -32, -31, -31, -30, -30, -29, -29, -28, -28, -27, -27, -26, -24, -24,
-24, -23, -21, -20, -19, -19, -17, -16, -14, -12, -11, -8, -8, -5, -3, -1, };