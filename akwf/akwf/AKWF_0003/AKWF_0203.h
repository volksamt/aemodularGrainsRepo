#define DATA_LENGTH 512
#define DATA AKWF_0203

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 7, 10, 13, 16, 19, 21, 25, 28,
31, 34, 37, 39, 43, 45, 49, 51, 54, 57, 61, 63, 66, 69, 71, 74, 76, 79, 82, 85,
85, 89, 91, 93, 96, 97, 100, 101, 102, 105, 106, 108, 109, 111, 112, 113, 114,
114, 116, 117, 118, 118, 119, 120, 119, 119, 120, 119, 119, 119, 118, 118, 117,
117, 115, 114, 114, 112, 111, 109, 108, 106, 105, 103, 102, 100, 98, 96, 93, 91,
89, 86, 84, 81, 78, 76, 73, 71, 68, 64, 62, 58, 56, 53, 50, 46, 43, 41, 37, 34,
30, 27, 24, 21, 17, 14, 11, 8, 4, 1, -3, -6, -9, -12, -15, -18, -21, -24, -27,
-29, -33, -35, -38, -38, -30, -19, -11, -3, 5, 12, 17, 22, 26, 31, 34, 38, 41,
43, 45, 45, 47, 48, 47, 49, 48, 48, 47, 47, 46, 45, 44, 42, 41, 38, 36, 34, 33,
31, 29, 26, 23, 21, 17, 15, 12, 9, 6, 2, 0, -3, -7, -9, -12, -16, -19, -22, -26,
-29, -32, -35, -38, -42, -45, -48, -51, -54, -57, -61, -64, -67, -69, -72, -75,
-77, -80, -82, -85, -88, -89, -92, -94, -96, -98, -100, -102, -102, -105, -107,
-108, -109, -110, -112, -112, -114, -115, -114, -116, -116, -117, -117, -117,
-117, -117, -116, -116, -115, -115, -116, -114, -113, -113, -111, -110, -109,
-108, -106, -104, -103, -101, -100, -98, -96, -94, -93, -89, -88, -85, -83, -80,
-79, -76, -73, -71, -68, -65, -62, -60, -56, -54, -52, -47, -45, -43, -40, -37,
-34, -31, -28, -24, -22, -19, -16, -13, -10, -8, -5, -1, 1, 4, 6, 8, 11, 14, 16,
19, 21, 23, 26, 28, 29, 32, 34, 35, 37, 38, 41, 41, 42, 45, 46, 47, 48, 49, 50,
50, 51, 51, 52, 52, 52, 53, 54, 54, 53, 53, 52, 52, 51, 51, 50, 49, 49, 48, 47,
46, 46, 43, 42, 41, 40, 39, 37, 35, 34, 32, 30, 28, 26, 24, 22, 20, 18, 16, 15,
12, 10, 8, 6, 3, 2, -1, -3, -6, -7, -10, -11, -14, -17, -18, -21, -22, -24, -26,
-29, -31, -33, -34, -36, -38, -40, -41, -43, -44, -46, -47, -49, -50, -50, -52,
-53, -55, -55, -55, -55, -56, -57, -57, -57, -52, -44, -37, -30, -24, -18, -13,
-8, -4, 0, 4, 6, 10, 13, 14, 17, 18, 19, 20, 22, 23, 23, 23, 24, 24, 24, 23, 23,
23, 22, 22, 21, 20, 19, 18, 17, 15, 14, 12, 11, 10, 8, 7, 5, 3, 1, 0, -3, -5,
-6, -8, -10, -11, -13, -15, -17, -18, -21, -22, -24, -27, -27, -31, -31, -34,
-35, -37, -38, -39, -41, -41, -43, -45, -46, -46, -47, -48, -50, -51, -52, -52,
-52, -52, -53, -54, -54, -54, -55, -55, -54, -55, -53, -53, -53, -52, -51, -50,
-50, -49, -48, -47, -46, -44, -43, -41, -40, -39, -36, -35, -33, -31, -29, -27,
-26, -23, -21, -19, -16, -14, -11, -8, -5, -3, -1, };