#define DATA_LENGTH 512
#define DATA AKWF_0229

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 4, 5, 8, 9, 11, 12, 14, 16, 18,
19, 20, 22, 24, 26, 27, 29, 30, 31, 34, 34, 37, 38, 40, 41, 43, 44, 45, 46, 47,
49, 51, 52, 53, 54, 56, 56, 58, 60, 61, 62, 62, 64, 64, 67, 67, 69, 69, 71, 70,
72, 73, 74, 75, 76, 78, 78, 79, 80, 80, 81, 82, 83, 84, 86, 85, 87, 87, 88, 89,
89, 91, 91, 91, 92, 93, 94, 94, 94, 95, 97, 96, 97, 98, 99, 99, 99, 100, 101,
101, 102, 102, 103, 103, 103, 104, 104, 105, 105, 105, 106, 106, 107, 107, 107,
109, 108, 109, 109, 110, 110, 110, 110, 110, 112, 110, 111, 112, 113, 112, 112,
113, 113, 113, 114, 114, 114, 114, 114, 115, 115, 115, 116, 116, 115, 116, 115,
117, 116, 116, 116, 116, 116, 117, 117, 117, 117, 117, 117, 117, 119, 117, 118,
119, 118, 119, 118, 118, 118, 118, 118, 119, 118, 118, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 119,
119, 118, 119, 118, 119, 119, 118, 120, 118, 119, 119, 118, 119, 119, 118, 118,
118, 118, 119, 119, 118, 118, 118, 118, 118, 118, 117, 118, 117, 117, 117, 118,
116, 117, 117, 116, 117, 117, 116, 116, 116, 116, 116, 116, 116, 116, 116, 116,
115, 115, 116, 115, 115, 115, 115, 114, 116, 97, 84, 84, 72, 67, 59, 54, 47, 41,
34, 29, 24, 19, 14, 10, 5, 1, -2, -7, -11, -15, -17, -21, -23, -28, -30, -33,
-36, -39, -41, -44, -46, -48, -51, -52, -55, -57, -59, -61, -62, -63, -66, -67,
-70, -71, -71, -73, -74, -76, -77, -79, -80, -80, -82, -82, -84, -85, -85, -87,
-88, -89, -90, -90, -91, -93, -93, -94, -94, -95, -96, -97, -97, -98, -98, -99,
-100, -101, -101, -102, -102, -102, -102, -104, -104, -104, -105, -105, -106,
-106, -107, -107, -107, -108, -108, -109, -109, -109, -109, -110, -109, -110,
-111, -111, -111, -111, -112, -111, -112, -112, -112, -113, -113, -112, -113,
-114, -114, -113, -114, -113, -114, -114, -115, -114, -114, -114, -114, -115,
-115, -114, -114, -115, -115, -116, -116, -115, -115, -114, -114, -114, -115,
-114, -114, -114, -114, -115, -114, -115, -114, -114, -114, -114, -114, -114,
-114, -113, -113, -112, -112, -113, -112, -112, -112, -111, -111, -111, -111,
-111, -111, -110, -110, -110, -109, -109, -109, -109, -108, -108, -107, -106,
-106, -106, -106, -106, -105, -104, -103, -103, -103, -102, -102, -101, -101,
-100, -100, -99, -99, -98, -97, -96, -96, -96, -94, -93, -92, -92, -91, -90,
-90, -88, -88, -87, -87, -85, -84, -84, -83, -82, -80, -80, -79, -77, -76, -75,
-74, -73, -72, -71, -69, -68, -67, -65, -64, -63, -61, -59, -58, -57, -56, -54,
-52, -51, -50, -48, -46, -44, -43, -41, -38, -38, -36, -34, -32, -30, -29, -27,
-26, -24, -21, -19, -18, -16, -15, -13, -11, -8, -6, -5, -3, -1, };