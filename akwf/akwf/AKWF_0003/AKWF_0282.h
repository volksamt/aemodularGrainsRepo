#define DATA_LENGTH 512
#define DATA AKWF_0282

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 9, 11, 13, 16, 19, 21, 23, 26,
28, 31, 33, 36, 38, 41, 45, 47, 50, 53, 54, 58, 61, 64, 65, 68, 71, 73, 76, 78,
80, 82, 86, 88, 89, 92, 94, 97, 98, 100, 102, 103, 106, 107, 108, 108, 109, 110,
111, 111, 111, 112, 114, 116, 117, 118, 119, 119, 119, 118, 117, 116, 113, 112,
110, 109, 108, 107, 105, 105, 103, 101, 100, 97, 97, 94, 92, 90, 88, 85, 82, 79,
77, 73, 71, 69, 68, 66, 63, 61, 58, 55, 53, 51, 48, 44, 41, 38, 35, 31, 28, 25,
22, 18, 15, 12, 8, 5, 1, -2, -5, -8, -12, -16, -18, -21, -24, -27, -31, -35,
-37, -43, -46, -49, -53, -56, -61, -65, -69, -73, -78, -82, -86, -91, -94, -99,
-102, -104, -107, -110, -111, -112, -114, -114, -115, -115, -114, -114, -114,
-114, -113, -113, -112, -112, -110, -108, -106, -105, -103, -100, -98, -96, -94,
-91, -88, -87, -85, -84, -82, -82, -79, -78, -75, -73, -70, -68, -65, -62, -59,
-56, -53, -49, -47, -44, -40, -36, -32, -27, -24, -20, -15, -11, -7, -2, 4, 9,
14, 20, 25, 29, 33, 36, 39, 42, 44, 47, 49, 51, 54, 56, 58, 60, 62, 64, 68, 69,
70, 72, 73, 74, 76, 77, 77, 78, 79, 80, 81, 81, 80, 81, 79, 80, 79, 78, 76, 75,
75, 72, 72, 70, 67, 65, 62, 60, 59, 57, 54, 51, 48, 45, 42, 38, 33, 28, 24, 21,
16, 12, 8, 4, 0, -4, -9, -13, -16, -19, -22, -25, -29, -34, -37, -41, -44, -49,
-53, -57, -60, -64, -68, -72, -75, -78, -82, -82, -85, -86, -89, -90, -92, -93,
-94, -95, -97, -97, -98, -99, -98, -99, -99, -98, -97, -96, -95, -95, -95, -94,
-94, -95, -94, -93, -94, -93, -93, -91, -89, -88, -87, -85, -84, -83, -81, -80,
-79, -77, -76, -75, -74, -74, -73, -72, -70, -70, -70, -69, -68, -68, -66, -66,
-64, -62, -62, -59, -58, -56, -54, -52, -50, -47, -44, -41, -37, -34, -29, -25,
-21, -17, -13, -7, -4, 1, 6, 10, 16, 21, 26, 30, 35, 38, 41, 45, 48, 51, 53, 54,
57, 59, 61, 62, 63, 65, 66, 68, 69, 70, 73, 75, 76, 78, 81, 83, 85, 86, 88, 89,
90, 91, 93, 94, 94, 95, 97, 98, 99, 100, 100, 101, 101, 100, 100, 98, 96, 95,
92, 91, 89, 87, 84, 81, 78, 74, 71, 67, 63, 61, 56, 53, 50, 46, 42, 38, 34, 31,
27, 21, 19, 16, 11, 7, 3, -1, -5, -7, -12, -15, -20, -23, -27, -30, -34, -38,
-41, -43, -46, -49, -52, -55, -57, -60, -62, -64, -66, -67, -68, -69, -70, -72,
-74, -76, -78, -78, -80, -80, -82, -82, -82, -83, -82, -83, -83, -83, -83, -83,
-83, -83, -83, -82, -82, -80, -79, -75, -73, -69, -67, -63, -59, -56, -53, -50,
-49, -45, -42, -38, -34, -29, -27, -22, -18, -15, -11, -8, -4, -1, };