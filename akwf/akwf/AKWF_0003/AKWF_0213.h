#define DATA_LENGTH 512
#define DATA AKWF_0213

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 2, 10, 21, 22, 29, 34, 39, 43, 44,
44, 52, 54, 56, 57, 59, 61, 62, 61, 62, 72, 71, 74, 76, 79, 80, 82, 81, 84, 84,
86, 87, 85, 87, 87, 88, 86, 87, 86, 88, 88, 88, 87, 86, 85, 85, 84, 83, 84, 83,
82, 81, 81, 81, 82, 83, 84, 84, 83, 84, 85, 84, 85, 86, 86, 87, 88, 89, 91, 90,
90, 92, 94, 94, 94, 94, 94, 94, 95, 95, 97, 98, 100, 103, 103, 104, 103, 106,
104, 103, 106, 106, 106, 105, 104, 104, 104, 104, 105, 105, 105, 106, 106, 105,
107, 107, 107, 108, 109, 110, 110, 109, 110, 111, 111, 110, 112, 112, 111, 110,
108, 108, 107, 105, 105, 106, 105, 104, 108, 109, 108, 109, 108, 107, 107, 106,
104, 102, 100, 101, 101, 100, 98, 98, 96, 98, 97, 99, 93, 88, 88, 87, 86, 83,
82, 79, 84, 85, 79, 78, 78, 73, 72, 70, 69, 68, 65, 62, 63, 61, 57, 52, 49, 46,
44, 41, 36, 34, 31, 28, 25, 23, 19, 19, 17, 16, 15, 16, 12, 8, 8, 5, 4, 0, -1,
-2, -2, -3, -3, -5, -2, -8, -12, -12, -16, -16, -19, -21, -25, -26, -29, -30,
-33, -34, -35, -37, -36, -39, -40, -41, -40, -44, -44, -45, -48, -50, -52, -53,
-54, -57, -57, -60, -60, -59, -60, -62, -64, -64, -66, -67, -70, -73, -74, -75,
-76, -78, -80, -81, -81, -83, -88, -90, -94, -97, -98, -99, -99, -99, -101,
-101, -103, -104, -105, -108, -109, -110, -110, -109, -113, -115, -114, -115,
-117, -119, -119, -118, -116, -116, -114, -114, -113, -112, -112, -109, -110,
-107, -106, -103, -99, -98, -97, -94, -91, -90, -87, -86, -82, -78, -76, -74,
-72, -70, -69, -67, -66, -63, -62, -61, -59, -55, -51, -49, -46, -45, -41, -41,
-38, -36, -35, -33, -30, -27, -23, -19, -18, -15, -12, -9, -6, -3, -1, -7, -2,
0, 0, 1, 2, 2, -2, 1, -8, -16, -15, -21, -23, -22, -24, -24, -24, -26, -27, -30,
-33, -35, -35, -36, -37, -35, -45, -46, -44, -47, -45, -47, -47, -47, -45, -49,
-49, -52, -55, -54, -55, -55, -57, -55, -55, -55, -56, -58, -56, -54, -56, -57,
-58, -57, -57, -57, -58, -54, -54, -54, -52, -52, -51, -51, -52, -53, -54, -51,
-52, -52, -52, -51, -50, -50, -50, -48, -47, -47, -47, -47, -46, -42, -41, -40,
-38, -35, -35, -33, -34, -33, -32, -32, -28, -26, -26, -22, -21, -23, -23, -23,
-23, -22, -23, -24, -22, -21, -23, -24, -26, -23, -23, -24, -24, -25, -26, -26,
-27, -27, -28, -29, -28, -29, -30, -31, -30, -31, -32, -34, -33, -33, -35, -35,
-34, -37, -37, -40, -45, -44, -45, -47, -48, -48, -50, -50, -53, -58, -62, -56,
-56, -57, -55, -54, -51, -51, -50, -50, -47, -47, -44, -43, -40, -37, -37, -38,
-37, -36, -36, -35, -35, -32, -32, -24, -19, -19, -14, -10, -8, -4, -4, -2, };