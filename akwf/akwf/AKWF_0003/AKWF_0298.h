#define DATA_LENGTH 512
#define DATA AKWF_0298

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 4, 4, 5, 6, 6, 8, 8, 10, 10,
11, 12, 13, 14, 15, 15, 16, 17, 18, 19, 20, 21, 21, 22, 23, 23, 24, 25, 26, 27,
28, 28, 28, 30, 31, 31, 32, 33, 33, 34, 35, 36, 36, 37, 37, 38, 38, 39, 40, 40,
41, 42, 42, 43, 44, 44, 45, 45, 45, 46, 46, 47, 47, 48, 49, 50, 50, 50, 50, 50,
51, 52, 52, 52, 53, 53, 54, 54, 55, 55, 55, 56, 56, 57, 57, 57, 57, 58, 58, 58,
58, 59, 59, 60, 60, 60, 60, 60, 60, 62, 61, 62, 62, 62, 63, 62, 62, 63, 63, 63,
63, 63, 63, 63, 64, 64, 64, 64, 65, 64, 65, 65, 65, 64, 65, 64, 65, 64, 64, 65,
64, 65, 65, 66, 65, 66, 65, 64, 65, 65, 66, 65, 64, 65, 64, 65, 64, 64, 64, 64,
64, 64, 63, 64, 64, 63, 63, 63, 63, 63, 63, 63, 63, 62, 62, 62, 62, 62, 61, 61,
61, 60, 61, 59, 60, 59, 59, 60, 60, 58, 58, 58, 57, 58, 58, 56, 57, 56, 55, 56,
55, 55, 54, 55, 54, 53, 53, 53, 53, 52, 52, 51, 51, 51, 51, 50, 49, 50, 49, 49,
48, 48, 47, 46, 47, 46, 46, 45, 45, 44, 44, 44, 43, 43, 43, 41, 42, 41, 40, 40,
39, 40, 38, 38, 37, 38, 37, 36, 35, 36, 35, 35, 34, 33, 33, 33, 32, 32, 31, 30,
31, 30, 30, 29, 29, 28, 28, 27, 26, 26, 26, 24, 24, 24, 23, 23, 22, 22, 22, 22,
21, 21, 20, 19, 18, 18, 17, 17, 16, 17, 15, 15, 14, 15, 14, 12, 12, 12, 12, 11,
11, 10, 10, 10, 9, 8, 7, 8, 6, 6, 6, 6, 5, 5, 4, 3, 4, 2, 2, 2, 0, 1, 0, -1, -2,
-3, -4, -4, -6, -7, -8, -9, -10, -11, -13, -15, -15, -17, -19, -21, -23, -25,
-26, -29, -30, -33, -34, -36, -38, -40, -43, -45, -47, -50, -52, -54, -57, -60,
-61, -64, -67, -68, -71, -73, -76, -78, -80, -82, -85, -87, -87, -90, -92, -94,
-96, -98, -99, -100, -102, -104, -105, -106, -108, -109, -109, -111, -111, -112,
-114, -114, -115, -116, -116, -117, -117, -117, -118, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -117, -118, -117, -117, -115,
-116, -115, -114, -113, -112, -112, -111, -111, -109, -109, -108, -107, -106,
-105, -104, -104, -102, -101, -101, -98, -98, -97, -96, -96, -93, -93, -92, -90,
-89, -88, -86, -86, -84, -84, -82, -81, -80, -79, -77, -77, -74, -73, -73, -71,
-70, -69, -68, -66, -65, -64, -63, -61, -60, -58, -57, -57, -55, -54, -53, -52,
-51, -49, -48, -47, -45, -44, -42, -41, -40, -39, -37, -37, -36, -34, -33, -32,
-31, -30, -28, -28, -26, -25, -24, -24, -22, -22, -20, -19, -19, -17, -16, -14,
-14, -12, -11, -10, -10, -9, -7, -6, -5, -5, -3, -2, -1, 0, };