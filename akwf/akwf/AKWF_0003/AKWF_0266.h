#define DATA_LENGTH 512
#define DATA AKWF_0266

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 7, 10, 13, 15, 19, 21, 24, 27,
28, 31, 33, 36, 39, 41, 43, 45, 47, 50, 52, 53, 56, 58, 59, 62, 64, 64, 67, 68,
70, 72, 73, 75, 76, 78, 79, 80, 82, 82, 83, 84, 85, 86, 87, 88, 88, 88, 90, 90,
91, 91, 92, 93, 92, 93, 93, 93, 93, 93, 93, 93, 93, 93, 93, 93, 92, 92, 91, 91,
90, 90, 90, 89, 89, 87, 87, 87, 86, 85, 84, 83, 83, 82, 81, 80, 79, 78, 78, 76,
75, 75, 73, 72, 71, 70, 68, 67, 66, 65, 64, 62, 61, 60, 59, 58, 56, 55, 54, 52,
52, 50, 48, 47, 46, 44, 43, 41, 39, 38, 38, 35, 34, 33, 31, 30, 28, 27, 25, 24,
23, 22, 20, 19, 17, 15, 14, 12, 12, 10, 8, 7, 6, 4, 3, 1, -1, -2, -3, -4, -7,
-7, -9, -10, -11, -13, -14, -15, -17, -18, -20, -21, -22, -23, -24, -26, -28,
-28, -30, -30, -33, -33, -35, -35, -37, -37, -38, -40, -41, -42, -43, -43, -44,
-46, -47, -47, -49, -49, -49, -50, -51, -53, -52, -53, -54, -54, -55, -56, -55,
-56, -57, -58, -57, -57, -58, -58, -58, -58, -59, -58, -59, -58, -58, -58, -57,
-57, -58, -56, -57, -56, -56, -55, -54, -54, -54, -53, -53, -51, -51, -50, -49,
-48, -47, -45, -45, -44, -42, -42, -40, -39, -38, -36, -35, -34, -33, -31, -29,
-28, -27, -25, -23, -22, -20, -18, -17, -15, -13, -12, -10, -8, -6, -4, -3, -1,
2, 3, 5, 7, 8, 10, 13, 15, 17, 18, 21, 22, 23, 26, 28, 29, 31, 33, 35, 36, 38,
40, 42, 43, 45, 47, 48, 50, 51, 53, 54, 55, 56, 58, 60, 61, 61, 64, 64, 65, 67,
68, 68, 69, 70, 70, 72, 73, 73, 74, 74, 75, 75, 75, 76, 77, 77, 77, 77, 77, 77,
77, 77, 77, 77, 76, 75, 75, 74, 74, 75, 74, 72, 71, 71, 70, 70, 68, 67, 66, 64,
63, 63, 62, 60, 59, 57, 56, 54, 53, 51, 49, 48, 46, 44, 43, 40, 39, 38, 35, 32,
31, 29, 26, 25, 23, 20, 18, 16, 13, 11, 9, 7, 4, 3, 0, -3, -5, -8, -9, -13, -16,
-18, -20, -23, -25, -27, -29, -32, -35, -37, -39, -42, -45, -47, -50, -52, -54,
-56, -60, -61, -63, -66, -68, -70, -72, -75, -76, -79, -81, -82, -84, -87, -89,
-91, -92, -94, -96, -97, -98, -101, -103, -103, -105, -107, -108, -108, -110,
-110, -112, -112, -114, -115, -115, -116, -116, -117, -118, -117, -118, -119,
-119, -119, -119, -119, -119, -118, -118, -118, -118, -117, -117, -116, -115,
-115, -114, -113, -112, -112, -111, -108, -108, -107, -105, -103, -102, -100,
-98, -97, -95, -93, -91, -90, -88, -86, -84, -81, -79, -78, -75, -73, -70, -68,
-65, -63, -60, -57, -55, -53, -50, -48, -44, -41, -39, -36, -34, -31, -29, -25,
-21, -20, -17, -14, -11, -8, -6, -2, 0, };