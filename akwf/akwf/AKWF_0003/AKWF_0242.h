#define DATA_LENGTH 512
#define DATA AKWF_0242

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 4, 4, 4, 7, 11, 14, 17, 20,
23, 25, 25, 25, 24, 26, 29, 32, 34, 33, 34, 34, 36, 40, 43, 45, 45, 45, 45, 47,
50, 52, 54, 53, 54, 54, 57, 59, 61, 62, 63, 62, 63, 67, 70, 73, 73, 74, 74, 74,
73, 73, 73, 77, 79, 82, 82, 81, 82, 83, 86, 87, 90, 91, 90, 91, 91, 91, 90, 91,
93, 96, 98, 99, 99, 99, 99, 100, 99, 99, 99, 103, 106, 109, 111, 110, 111, 111,
111, 110, 111, 111, 111, 110, 111, 114, 116, 119, 120, 119, 120, 118, 119, 119,
119, 118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 118, 119, 119, 119, 118,
118, 118, 118, 118, 119, 119, 118, 119, 119, 118, 118, 119, 119, 119, 118, 118,
119, 119, 118, 115, 114, 111, 110, 110, 109, 110, 110, 109, 110, 110, 110, 109,
110, 110, 110, 110, 109, 106, 103, 99, 98, 98, 98, 98, 98, 98, 98, 95, 94, 90,
88, 90, 89, 89, 89, 88, 89, 87, 85, 83, 80, 81, 80, 80, 78, 77, 73, 72, 71, 71,
72, 69, 65, 61, 60, 60, 60, 60, 58, 56, 53, 51, 52, 51, 51, 48, 46, 43, 43, 42,
43, 42, 37, 34, 31, 31, 31, 32, 30, 28, 25, 22, 23, 23, 23, 21, 17, 15, 14, 15,
13, 14, 13, 9, 6, 3, 3, 2, 2, 2, -2, -4, -6, -7, -7, -6, -8, -10, -12, -15, -14,
-15, -14, -17, -20, -21, -24, -24, -24, -23, -26, -29, -33, -36, -35, -35, -36,
-37, -41, -43, -44, -43, -43, -43, -46, -49, -51, -52, -52, -52, -53, -52, -52,
-52, -56, -59, -63, -64, -64, -64, -63, -64, -63, -64, -65, -68, -70, -73, -73,
-72, -73, -72, -73, -72, -73, -76, -79, -81, -81, -81, -80, -81, -81, -81, -81,
-80, -81, -80, -81, -83, -86, -88, -89, -89, -89, -89, -89, -90, -89, -89, -89,
-89, -90, -88, -89, -89, -92, -96, -98, -101, -100, -101, -100, -100, -101,
-101, -100, -101, -100, -100, -100, -101, -101, -100, -100, -100, -100, -100,
-100, -100, -100, -101, -101, -100, -100, -101, -100, -100, -100, -100, -100,
-101, -100, -100, -99, -100, -100, -100, -99, -101, -100, -100, -99, -100, -100,
-100, -99, -100, -100, -100, -100, -100, -100, -100, -100, -100, -100, -100,
-99, -100, -99, -100, -100, -100, -100, -97, -94, -90, -88, -88, -88, -88, -88,
-88, -88, -88, -88, -88, -88, -88, -88, -88, -88, -88, -88, -87, -85, -82, -80,
-80, -79, -79, -79, -79, -80, -79, -80, -79, -80, -78, -75, -72, -70, -71, -71,
-71, -71, -70, -71, -69, -67, -64, -62, -61, -61, -61, -62, -61, -62, -61, -57,
-55, -51, -50, -50, -50, -50, -50, -51, -50, -49, -47, -44, -42, -42, -41, -42,
-42, -42, -41, -42, -39, -36, -35, -33, -33, -33, -33, -29, -27, -22, -21, -21,
-21, -20, -18, -16, -13, -13, -12, -13, -11, -9, -7, -4, -3, -4, -4, -4, -3, -1,
};