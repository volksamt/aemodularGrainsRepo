#define DATA_LENGTH 512
#define DATA AKWF_0223

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 8, 15, 21, 28, 32, 37, 41, 46, 50,
52, 56, 60, 61, 63, 65, 68, 68, 70, 72, 73, 74, 74, 75, 76, 77, 77, 77, 78, 77,
78, 78, 78, 77, 77, 77, 77, 76, 77, 76, 76, 75, 74, 73, 74, 73, 72, 71, 71, 70,
70, 69, 69, 68, 66, 66, 66, 65, 63, 63, 62, 61, 61, 59, 59, 58, 57, 56, 56, 55,
54, 53, 52, 51, 51, 50, 49, 48, 47, 46, 45, 44, 44, 42, 42, 41, 41, 40, 38, 37,
37, 35, 36, 34, 33, 33, 31, 31, 29, 29, 27, 27, 27, 26, 25, 24, 23, 22, 21, 20,
19, 18, 18, 18, 16, 15, 15, 13, 13, 11, 10, 10, 9, 9, 9, 9, 8, 9, 8, 9, 9, 10,
9, 10, 10, 10, 11, 11, 11, 13, 13, 13, 14, 15, 15, 16, 16, 16, 18, 18, 20, 20,
20, 21, 22, 23, 24, 24, 25, 26, 27, 28, 28, 29, 30, 31, 31, 32, 33, 34, 35, 36,
37, 37, 39, 39, 40, 40, 42, 43, 43, 44, 46, 46, 48, 48, 49, 50, 51, 52, 53, 53,
55, 55, 56, 56, 57, 59, 60, 61, 62, 62, 63, 64, 65, 66, 67, 67, 68, 69, 69, 71,
72, 73, 73, 75, 75, 77, 77, 78, 79, 80, 81, 81, 83, 83, 84, 86, 86, 87, 88, 88,
89, 90, 91, 92, 93, 94, 94, 95, 97, 97, 96, 94, 90, 83, 75, 65, 57, 47, 37, 29,
20, 12, 3, -4, -11, -17, -23, -29, -34, -38, -43, -47, -51, -53, -57, -60, -62,
-64, -66, -68, -70, -72, -72, -74, -73, -76, -75, -77, -77, -77, -77, -78, -79,
-79, -79, -78, -78, -77, -78, -77, -76, -77, -76, -75, -76, -74, -74, -73, -73,
-72, -72, -71, -70, -70, -69, -69, -68, -67, -66, -66, -64, -64, -64, -62, -62,
-62, -60, -59, -58, -58, -56, -56, -54, -55, -53, -52, -51, -51, -49, -49, -49,
-48, -47, -45, -44, -44, -42, -42, -42, -41, -39, -39, -38, -37, -37, -35, -35,
-34, -33, -32, -30, -29, -29, -29, -27, -27, -25, -24, -24, -22, -21, -21, -20,
-19, -18, -18, -16, -16, -15, -14, -12, -13, -12, -10, -10, -9, -9, -9, -8, -8,
-8, -8, -8, -8, -9, -9, -9, -9, -10, -10, -10, -11, -12, -13, -12, -13, -14,
-14, -15, -15, -16, -17, -17, -18, -19, -20, -21, -21, -23, -22, -24, -24, -26,
-26, -27, -28, -29, -29, -29, -31, -31, -33, -33, -34, -36, -37, -37, -38, -38,
-40, -41, -41, -42, -42, -44, -44, -46, -46, -47, -49, -49, -50, -51, -52, -52,
-54, -54, -55, -56, -57, -58, -59, -59, -60, -61, -62, -62, -64, -65, -66, -66,
-68, -68, -70, -70, -71, -72, -73, -74, -75, -76, -77, -76, -78, -79, -79, -80,
-81, -82, -84, -85, -86, -86, -87, -88, -88, -90, -90, -91, -91, -93, -93, -93,
-94, -94, -93, -92, -91, -89, -85, -80, -74, -66, -57, -46, -36, -25, -16, -7,
0, };