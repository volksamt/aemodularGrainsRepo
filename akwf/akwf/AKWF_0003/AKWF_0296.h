#define DATA_LENGTH 512
#define DATA AKWF_0296

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 7, 10, 13, 16, 20, 23, 25, 29,
31, 33, 37, 39, 41, 44, 46, 48, 49, 52, 53, 55, 57, 58, 60, 61, 62, 64, 65, 66,
66, 68, 69, 69, 70, 70, 70, 71, 72, 72, 72, 72, 71, 72, 72, 71, 71, 71, 71, 70,
70, 69, 69, 68, 67, 67, 66, 65, 64, 65, 63, 62, 62, 60, 60, 59, 57, 56, 56, 54,
53, 53, 51, 51, 48, 48, 46, 45, 44, 42, 42, 40, 38, 38, 37, 35, 34, 33, 31, 31,
29, 28, 27, 27, 18, 4, -6, -17, -28, -37, -47, -56, -64, -72, -80, -87, -91,
-96, -101, -106, -108, -111, -114, -115, -116, -117, -118, -118, -117, -116,
-115, -114, -112, -110, -108, -106, -103, -101, -98, -95, -92, -89, -85, -82,
-78, -74, -71, -67, -63, -60, -56, -53, -49, -45, -42, -37, -34, -31, -27, -23,
-20, -16, -13, -10, -5, -3, 0, 4, 6, 9, 12, 16, 18, 21, 23, 26, 29, 31, 32, 35,
37, 40, 41, 42, 45, 46, 47, 49, 51, 52, 54, 55, 55, 56, 57, 58, 59, 61, 60, 62,
62, 62, 63, 64, 64, 64, 64, 64, 64, 64, 63, 64, 63, 63, 63, 62, 62, 62, 62, 60,
60, 60, 59, 58, 57, 56, 56, 55, 54, 53, 53, 51, 51, 49, 49, 47, 48, 46, 45, 44,
43, 42, 41, 39, 39, 37, 37, 36, 34, 34, 32, 31, 30, 29, 28, 27, 26, 25, 23, 22,
21, 20, 20, 18, 17, 17, 15, 15, 13, 12, 11, 11, 10, 9, 9, 7, 6, 6, 6, 5, 4, 2,
2, 2, 1, 0, -1, -2, -2, -3, -4, -4, -4, -4, -5, -6, -7, -7, -8, -7, -8, -9, -9,
-9, -10, -10, -10, -10, -10, -11, -11, -11, -11, -12, -12, -12, -12, -12, -12,
-12, -12, -13, -13, -12, -12, -13, -13, -12, -13, -13, -12, -12, -13, -12, -12,
-12, -12, -12, -12, -12, -11, -11, -11, -11, -10, -11, -10, -10, -10, -11, -9,
-10, -10, -10, -9, -10, -9, -8, -8, -9, -7, -7, -8, -7, -7, -7, -6, -6, -7, -5,
-6, -6, -5, -5, -4, -5, -5, -4, -4, -4, -4, -3, -3, -3, -3, -3, -2, -3, -2, -2,
-2, -1, -2, -2, -2, -1, 0, -1, -1, 0, 0, -1, 0, 0, 0, 0, 0, 1, 2, 0, 1, 2, 2, 1,
2, 2, 1, 2, 2, 1, 2, 2, 2, 2, 2, 2, 3, 3, 2, 2, 1, 3, 3, 2, 2, 1, 2, 3, 3, 2, 2,
2, 2, 3, 3, 3, 2, 2, 2, 2, 2, 3, 3, 2, 2, 2, 2, 2, 3, 3, 2, 2, 2, 3, -5, -18,
-28, -37, -45, -55, -63, -71, -78, -85, -92, -97, -102, -107, -109, -113, -115,
-116, -117, -119, -119, -120, -119, -117, -116, -115, -113, -111, -109, -106,
-103, -101, -98, -94, -91, -87, -84, -80, -76, -73, -69, -65, -61, -56, -52,
-49, -45, -40, -37, -32, -28, -24, -21, -17, -13, -10, -6, -2, };