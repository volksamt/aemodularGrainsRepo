#define DATA_LENGTH 512
#define DATA AKWF_0207

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 2, 2, 3, 4, 5, 6, 7, 10, 10, 13,
14, 15, 17, 19, 21, 23, 25, 26, 28, 30, 31, 33, 34, 35, 38, 39, 41, 42, 43, 45,
45, 46, 47, 47, 48, 49, 49, 49, 49, 49, 50, 49, 49, 48, 47, 48, 47, 46, 45, 45,
44, 43, 43, 41, 40, 40, 39, 37, 37, 36, 34, 34, 33, 31, 31, 30, 28, 29, 28, 26,
26, 25, 25, 24, 25, 24, 24, 23, 23, 23, 23, 23, 23, 24, 24, 23, 23, 24, 24, 25,
25, 24, 25, 25, 26, 27, 27, 27, 28, 28, 28, 28, 30, 29, 31, 31, 31, 32, 31, 32,
31, 32, 32, 32, 32, 32, 32, 32, 32, 31, 31, 31, 31, 30, 30, 30, 30, 29, 30, 30,
29, 30, 30, 30, 30, 30, 31, 32, 31, 31, 31, 31, 31, 32, 31, 32, 33, 33, 32, 32,
32, 32, 32, 32, 31, 31, 31, 31, 30, 30, 29, 28, 28, 27, 27, 26, 25, 25, 24, 22,
22, 22, 20, 20, 19, 19, 18, 17, 17, 16, 15, 15, 15, 14, 14, 13, 12, 13, 13, 12,
12, 13, 12, 12, 12, 12, 12, 12, 13, 13, 13, 13, 13, 14, 15, 14, 15, 15, 16, 16,
17, 17, 16, 17, 17, 18, 18, 17, 18, 18, 17, 17, 18, 17, 17, 16, 16, 15, 15, 15,
14, 14, 12, 12, 11, 10, 9, 7, 7, 5, 4, 2, 1, 0, 0, -3, -4, -5, -6, -7, -8, -8,
-9, -9, -9, -10, -10, -10, -10, -9, -8, -8, -6, -4, -3, -1, 0, 2, 3, 6, 8, 10,
12, 16, 17, 20, 22, 26, 28, 30, 33, 36, 39, 40, 44, 45, 47, 49, 52, 54, 56, 57,
59, 60, 61, 62, 63, 64, 65, 66, 66, 65, 66, 66, 66, 66, 66, 65, 65, 64, 64, 62,
61, 61, 60, 59, 59, 57, 57, 55, 54, 53, 51, 50, 49, 48, 47, 45, 44, 43, 41, 40,
39, 38, 37, 36, 34, 33, 31, 30, 29, 28, 26, 25, 24, 22, 22, 20, 19, 18, 16, 14,
13, 12, 10, 8, 6, 5, 4, 2, 0, -2, -4, -6, -8, -10, -12, -15, -17, -20, -22, -25,
-28, -31, -33, -36, -40, -42, -45, -48, -51, -54, -57, -60, -63, -65, -68, -70,
-73, -75, -77, -80, -82, -84, -86, -88, -90, -92, -93, -96, -97, -98, -100,
-101, -103, -103, -105, -106, -107, -109, -109, -110, -111, -112, -113, -113,
-113, -115, -115, -115, -117, -117, -118, -118, -119, -119, -120, -120, -118,
-119, -119, -118, -119, -119, -119, -117, -116, -117, -115, -114, -114, -112,
-112, -111, -109, -108, -107, -105, -104, -102, -100, -97, -96, -94, -92, -90,
-87, -85, -83, -80, -78, -76, -72, -70, -67, -65, -61, -59, -56, -53, -50, -49,
-45, -42, -40, -38, -36, -32, -31, -29, -27, -24, -22, -20, -18, -17, -15, -13,
-13, -11, -9, -9, -8, -7, -6, -6, -5, -4, -3, -3, -3, -2, -2, -2, -2, -1, -1, 0,
0, 0, };