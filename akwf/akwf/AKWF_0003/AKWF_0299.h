#define DATA_LENGTH 512
#define DATA AKWF_0299

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 10, 15, 22, 28, 36, 43, 50, 56,
61, 66, 69, 71, 73, 75, 76, 76, 78, 78, 78, 76, 75, 73, 70, 67, 63, 59, 54, 50,
45, 40, 34, 28, 23, 17, 12, 6, 0, -5, -11, -16, -21, -25, -30, -33, -37, -40,
-42, -44, -47, -48, -49, -50, -50, -49, -49, -48, -46, -44, -42, -40, -37, -34,
-31, -27, -22, -20, -15, -11, -8, -3, 1, 6, 9, 12, 15, 19, 22, 25, 28, 31, 32,
34, 36, 37, 38, 37, 39, 38, 38, 37, 36, 36, 33, 31, 30, 27, 25, 22, 20, 16, 14,
11, 8, 6, 2, -1, -3, -7, -10, -12, -15, -18, -19, -21, -22, -24, -25, -26, -27,
-28, -28, -27, -28, -28, -26, -26, -24, -23, -23, -21, -19, -17, -15, -14, -12,
-10, -7, -5, -3, -1, 2, 4, 7, 7, 10, 11, 13, 15, 15, 17, 19, 19, 19, 20, 21, 20,
21, 20, 20, 19, 18, 17, 17, 16, 15, 14, 12, 11, 10, 7, 6, 4, 4, 2, -1, -2, -3,
-5, -6, -8, -9, -10, -11, -12, -13, -14, -14, -15, -15, -15, -15, -15, -15, -14,
-14, -13, -12, -12, -12, -10, -10, -9, -8, -7, -6, -4, -3, -2, 0, 1, 2, 4, 3, 6,
6, 7, 8, 8, 9, 10, 10, 11, 11, 11, 12, 11, 11, 10, 11, 10, 10, 9, 8, 9, 8, 7, 6,
5, 4, 4, 3, 2, 1, -1, -1, -2, -2, -3, -4, -5, -6, -6, -7, -7, -8, -7, -7, -7,
-8, -8, -8, -8, -8, -8, -7, -7, -7, -6, -7, -5, -5, -4, -4, -3, -3, -2, -1, -1,
1, 0, 2, 2, 2, 3, 4, 4, 4, 5, 4, 5, 6, 7, 6, 6, 7, 6, 7, 6, 6, 5, 5, 6, 5, 4, 4,
3, 3, 3, 3, 1, 0, 1, 0, 0, 0, -1, -1, -3, -2, -3, -2, -4, -4, -4, -4, -5, -5,
-4, -3, -4, -4, -4, -5, -4, -4, -4, -3, -3, -3, -2, -2, -2, -1, -1, -1, 0, 0, 0,
0, 1, 1, 2, 2, 2, 2, 2, 3, 3, 3, 3, 3, 3, 3, 4, 3, 4, 3, 3, 3, 2, 3, 2, 2, 2, 2,
1, 2, 1, 1, 0, 0, 1, 0, 0, -1, -1, 0, -1, -1, -2, -2, -2, -2, -3, -2, -3, -2,
-2, -2, -3, -3, -2, -1, -3, -1, -2, -2, -1, -1, -2, -1, -2, -1, 0, 0, 0, 0, 1,
1, 1, 1, 1, 1, 1, 2, 2, 2, 2, 2, 2, 2, 1, 1, 2, 2, 2, 2, 2, 2, 2, 1, 2, 2, 1, 1,
1, 1, 1, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, -2, -1, -1, -1, 0, -2, -1, -1, -2,
0, -1, -1, -1, -1, 0, -1, -1, 0, -1, 0, -1, 1, -1, 0, -2, 1, -34, -112, -109,
-63, -71, -95, -86, -50, -26, -26, -36, -45, -50, -56, -65, -68, -66, -58, -49,
-39, -29, -21, -13, -7, -2, };