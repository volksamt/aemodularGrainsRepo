#define DATA_LENGTH 512
#define DATA AKWF_0252

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 7, 9, 11, 14, 17, 19, 23, 24,
27, 29, 32, 34, 37, 39, 42, 43, 46, 48, 49, 51, 53, 56, 57, 59, 60, 63, 64, 65,
67, 69, 70, 72, 72, 75, 75, 77, 79, 79, 81, 82, 83, 84, 86, 87, 87, 89, 90, 92,
92, 92, 93, 95, 95, 96, 98, 97, 99, 100, 101, 101, 101, 103, 103, 103, 105, 105,
106, 107, 107, 107, 108, 109, 109, 111, 111, 111, 112, 112, 112, 113, 114, 114,
115, 115, 115, 116, 117, 117, 116, 118, 118, 117, 119, 119, 119, 118, 119, 119,
119, 119, 119, 118, 119, 117, 117, 118, 117, 115, 115, 115, 113, 112, 113, 111,
110, 109, 109, 106, 105, 104, 103, 101, 100, 99, 97, 95, 93, 92, 91, 88, 87, 86,
84, 82, 80, 77, 76, 74, 72, 70, 68, 66, 63, 61, 59, 57, 55, 53, 50, 48, 46, 44,
42, 39, 37, 35, 32, 30, 29, 26, 25, 21, 20, 18, 15, 14, 11, 9, 8, 5, 3, 1, 0,
-4, -5, -6, -8, -10, -13, -14, -16, -17, -19, -21, -22, -23, -26, -27, -28, -30,
-31, -32, -33, -36, -37, -38, -39, -41, -41, -42, -44, -45, -46, -47, -47, -48,
-49, -49, -50, -51, -51, -51, -53, -53, -53, -53, -54, -55, -55, -55, -55, -56,
-56, -56, -56, -56, -55, -57, -56, -56, -57, -57, -56, -57, -58, -56, -57, -56,
-57, -57, -56, -56, -56, -56, -57, -56, -57, -56, -56, -55, -55, -55, -56, -55,
-55, -56, -55, -55, -55, -54, -55, -55, -55, -54, -54, -53, -54, -54, -54, -53,
-53, -54, -54, -54, -53, -53, -52, -52, -52, -52, -52, -52, -52, -51, -52, -52,
-50, -51, -51, -51, -51, -50, -50, -51, -50, -50, -50, -49, -49, -49, -49, -49,
-49, -48, -48, -48, -48, -48, -48, -47, -47, -47, -47, -47, -47, -46, -47, -46,
-46, -46, -46, -46, -46, -45, -46, -45, -45, -45, -46, -45, -45, -46, -45, -45,
-45, -45, -45, -45, -45, -45, -46, -45, -45, -45, -45, -45, -46, -46, -46, -46,
-46, -46, -47, -47, -47, -47, -47, -47, -48, -48, -49, -49, -49, -50, -49, -50,
-51, -51, -51, -52, -52, -53, -53, -54, -54, -55, -55, -55, -56, -57, -57, -58,
-58, -58, -59, -60, -61, -61, -62, -62, -63, -64, -65, -64, -65, -66, -67, -67,
-68, -68, -69, -69, -70, -70, -71, -72, -73, -73, -74, -74, -74, -75, -77, -76,
-77, -77, -78, -79, -79, -80, -79, -80, -81, -82, -82, -83, -82, -84, -83, -84,
-85, -85, -84, -85, -85, -86, -86, -86, -86, -86, -86, -86, -86, -87, -86, -87,
-86, -86, -85, -86, -85, -85, -85, -84, -83, -83, -83, -82, -82, -81, -81, -80,
-80, -79, -78, -77, -76, -75, -74, -74, -72, -72, -70, -70, -68, -67, -65, -64,
-63, -61, -59, -58, -57, -55, -52, -51, -50, -48, -46, -44, -42, -40, -39, -36,
-34, -32, -30, -28, -25, -23, -21, -19, -17, -14, -12, -9, -7, -5, -2, -1, };