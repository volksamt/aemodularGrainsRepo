#define DATA_LENGTH 512
#define DATA AKWF_0227

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 3, 4, 4, 5, 6, 5, 7, 7, 7, 8,
9, 10, 10, 11, 12, 13, 13, 14, 15, 15, 16, 16, 17, 18, 19, 18, 20, 19, 21, 21,
22, 23, 23, 24, 24, 24, 25, 26, 26, 28, 28, 29, 29, 30, 31, 31, 31, 33, 33, 33,
34, 35, 36, 36, 37, 37, 37, 38, 39, 40, 41, 41, 42, 42, 43, 42, 44, 45, 44, 46,
46, 46, 47, 48, 48, 49, 50, 50, 51, 51, 52, 53, 53, 53, 53, 55, 55, 56, 56, 57,
57, 58, 58, 59, 59, 60, 61, 61, 62, 61, 62, 63, 64, 64, 64, 66, 66, 67, 67, 67,
67, 69, 70, 70, 70, 70, 71, 72, 72, 73, 73, 73, 74, 75, 74, 76, 77, 77, 77, 77,
77, 79, 79, 79, 80, 81, 80, 82, 82, 82, 84, 83, 84, 85, 85, 86, 86, 86, 87, 88,
88, 88, 88, 89, 90, 91, 90, 92, 92, 92, 92, 93, 93, 94, 94, 94, 95, 95, 96, 96,
96, 97, 97, 98, 99, 100, 99, 100, 100, 100, 102, 101, 102, 102, 104, 103, 103,
105, 104, 105, 106, 105, 106, 106, 107, 107, 108, 109, 109, 109, 109, 110, 111,
110, 111, 112, 112, 113, 112, 114, 114, 114, 114, 115, 115, 116, 116, 117, 116,
118, 118, 118, 118, 119, 117, 89, 86, 79, 69, 64, 55, 50, 41, 36, 30, 25, 19,
14, 9, 5, 0, -5, -9, -12, -17, -20, -22, -26, -30, -33, -36, -39, -40, -44, -46,
-48, -51, -53, -54, -56, -58, -60, -62, -63, -64, -66, -68, -69, -70, -71, -72,
-74, -74, -76, -76, -77, -78, -79, -80, -81, -81, -82, -82, -84, -84, -84, -85,
-86, -86, -87, -86, -87, -88, -88, -88, -88, -88, -89, -89, -90, -90, -91, -90,
-90, -91, -91, -91, -91, -91, -90, -90, -91, -92, -91, -91, -91, -91, -90, -90,
-90, -90, -90, -90, -90, -90, -90, -89, -90, -90, -90, -89, -88, -89, -88, -89,
-88, -88, -88, -88, -88, -88, -87, -87, -87, -87, -86, -86, -86, -85, -85, -85,
-85, -84, -84, -83, -83, -83, -83, -82, -82, -80, -81, -80, -80, -80, -79, -79,
-78, -79, -77, -77, -77, -77, -76, -76, -75, -75, -75, -74, -73, -73, -73, -73,
-72, -72, -72, -71, -70, -70, -69, -69, -68, -68, -67, -68, -67, -66, -65, -65,
-64, -64, -64, -63, -63, -62, -62, -62, -60, -61, -59, -59, -59, -59, -58, -57,
-57, -56, -55, -56, -54, -54, -54, -53, -53, -52, -51, -52, -50, -50, -50, -48,
-49, -48, -48, -47, -46, -45, -44, -44, -44, -43, -43, -42, -42, -41, -40, -40,
-38, -38, -38, -37, -36, -36, -35, -35, -34, -35, -33, -32, -32, -32, -30, -30,
-29, -29, -28, -28, -27, -26, -26, -25, -24, -23, -23, -22, -22, -21, -21, -20,
-19, -19, -17, -18, -17, -16, -16, -14, -14, -13, -13, -12, -11, -11, -10, -9,
-10, -8, -7, -7, -7, -5, -4, -4, -4, -3, -2, -1, 0, 0, };