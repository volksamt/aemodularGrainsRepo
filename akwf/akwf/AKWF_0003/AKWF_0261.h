#define DATA_LENGTH 512
#define DATA AKWF_0261

const PROGMEM int8_t DATA[DATA_LENGTH] = {43, 52, 48, 52, 49, 51, 49, 50, 48,
51, 50, 51, 50, 51, 49, 50, 50, 50, 50, 50, 50, 50, 50, 49, 51, 49, 51, 49, 52,
48, 53, 39, 18, 22, 19, 21, 20, 21, 21, 21, 21, 21, 21, 21, 21, 20, 20, 21, 21,
20, 21, 20, 21, 20, 21, 21, 20, 21, 20, 20, 20, 21, 19, 35, 51, 50, 50, 50, 50,
50, 50, 49, 50, 49, 49, 49, 49, 50, 49, 50, 50, 50, 50, 49, 50, 50, 51, 49, 50,
49, 50, 49, 51, 48, 53, 39, 17, 22, 19, 21, 19, 20, 20, 20, 20, 20, 20, 20, 21,
20, 20, 20, 21, 20, 21, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 21, 19, 35, 50,
49, 50, 50, 50, 49, 49, 50, 50, 49, 50, 50, 50, 49, 50, 50, 49, 50, 49, 49, 49,
50, 50, 49, 50, 48, 50, 48, 50, 47, 53, 37, 17, 22, 19, 21, 20, 20, 19, 20, 20,
20, 21, 19, 20, 20, 20, 20, 20, 20, 20, 20, 20, 19, 20, 20, 20, 20, 19, 20, 20,
21, 19, 36, 50, 48, 50, 49, 50, 49, 50, 49, 50, 49, 50, 48, 49, 49, 49, 48, 50,
49, 49, 49, 49, 49, 49, 50, 48, 52, 42, 98, 126, 113, 124, 103, 87, 89, 89, 89,
89, 89, 89, 89, 90, 88, 89, 89, 90, 88, 90, 87, 90, 86, 90, 87, 90, 86, 92, 86,
92, 86, 93, 85, 93, 83, 95, 92, -85, -93, -86, -92, -86, -93, -87, -93, -87,
-93, -87, -92, -87, -91, -87, -92, -89, -91, -89, -90, -89, -90, -89, -91, -90,
-90, -89, -90, -89, -91, -87, -103, -124, -115, -124, -113, -128, -83, -42, -54,
-47, -52, -48, -51, -48, -51, -49, -50, -49, -50, -50, -50, -50, -49, -50, -50,
-50, -50, -49, -49, -49, -49, -51, -33, -19, -21, -19, -19, -20, -20, -20, -19,
-20, -20, -20, -21, -20, -21, -20, -20, -20, -20, -19, -20, -20, -20, -20, -20,
-20, -20, -20, -21, -19, -22, -16, -34, -53, -47, -50, -48, -50, -50, -50, -49,
-49, -49, -49, -49, -49, -50, -50, -50, -49, -50, -49, -49, -49, -50, -49, -50,
-49, -49, -49, -49, -50, -49, -50, -32, -19, -21, -19, -20, -20, -20, -20, -20,
-20, -20, -20, -20, -20, -19, -20, -20, -20, -20, -20, -19, -19, -20, -20, -20,
-20, -21, -19, -20, -19, -22, -16, -35, -53, -47, -50, -48, -49, -49, -49, -48,
-49, -48, -49, -50, -48, -50, -49, -50, -49, -49, -49, -49, -49, -49, -48, -50,
-49, -49, -49, -49, -49, -49, -50, -31, -18, -20, -19, -20, -19, -20, -20, -20,
-19, -19, -20, -19, -20, -19, -19, -20, -20, -19, -19, -19, -20, -19, -20, -19,
-18, -20, -19, -21, -18, -22, -16, -36, -51, -47, -50, -48, -50, -48, -49, -49,
-48, -49, -49, -49, -48, -48, -48, -49, -49, -49, -48, -49, -49, -48, -49, -49,
-48, -48, -49, -48, -48, -48, -50, -27, };