#define DATA_LENGTH 512
#define DATA AKWF_0263

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 8, 12, 15, 19, 23, 27, 31, 35,
38, 42, 45, 49, 53, 56, 60, 63, 67, 70, 75, 77, 81, 83, 86, 89, 91, 93, 97, 99,
100, 102, 104, 106, 107, 110, 111, 112, 113, 115, 116, 116, 117, 118, 118, 119,
119, 119, 119, 119, 119, 118, 118, 118, 118, 116, 115, 115, 114, 113, 111, 110,
108, 107, 105, 104, 102, 100, 99, 95, 94, 92, 89, 88, 85, 83, 80, 78, 75, 72,
70, 67, 65, 62, 59, 56, 53, 50, 48, 45, 43, 39, 37, 34, 32, 29, 26, 23, 20, 18,
16, 12, 10, 7, 5, 2, 0, -3, -5, -6, -8, -11, -13, -15, -18, -19, -21, -23, -24,
-26, -29, -30, -32, -32, -34, -36, -37, -39, -39, -41, -42, -43, -44, -44, -45,
-45, -46, -47, -47, -48, -47, -47, -48, -48, -47, -47, -48, -46, -46, -46, -45,
-44, -44, -43, -41, -41, -40, -40, -38, -37, -35, -35, -33, -32, -30, -30, -29,
-27, -27, -25, -24, -22, -21, -20, -18, -17, -16, -15, -13, -13, -12, -11, -10,
-11, -10, -9, -9, -8, -6, -6, -6, -5, -5, -4, -4, -3, -3, -2, -2, -2, -2, -1,
-1, -1, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, -2, 0, -1, -1, -1, -1, -2, -3,
-3, -2, -3, -3, -4, -3, -4, -4, -5, -5, -5, -5, -6, -6, -6, -6, -7, -7, -7, -8,
-9, -8, -9, -9, -9, -10, -11, -10, -11, -11, -12, -12, -12, -12, -13, -13, -13,
-14, -14, -15, -14, -15, -15, -16, -16, -17, -16, -16, -16, -17, -17, -18, -18,
-18, -19, -19, -19, -19, -20, -20, -21, -21, -21, -22, -22, -21, -22, -23, -23,
-23, -23, -23, -24, -25, -24, -25, -26, -25, -26, -26, -26, -26, -27, -27, -27,
-28, -27, -28, -28, -29, -28, -28, -28, -29, -29, -29, -29, -29, -29, -30, -29,
-29, -30, -29, -29, -29, -29, -29, -28, -28, -28, -26, -26, -25, -24, -24, -23,
-22, -21, -21, -20, -20, -18, -17, -17, -16, -15, -13, -13, -12, -10, -9, -8,
-7, -7, -5, -3, -3, -1, -1, 0, 1, 2, 3, 5, 5, 6, 7, 8, 8, 9, 9, 10, 11, 11, 12,
13, 13, 13, 15, 15, 16, 16, 16, 17, 18, 18, 19, 19, 20, 21, 21, 23, 22, 23, 24,
25, 25, 26, 27, 27, 28, 28, 28, 28, 28, 27, 27, 26, 26, 26, 24, 23, 23, 22, 21,
20, 18, 18, 15, 15, 13, 11, 9, 8, 6, 5, 1, 0, -2, -4, -7, -9, -12, -14, -15,
-18, -21, -24, -26, -28, -32, -34, -37, -40, -42, -45, -47, -49, -52, -54, -57,
-59, -61, -63, -66, -68, -70, -71, -73, -74, -76, -77, -78, -80, -80, -78, -79,
-78, -78, -79, -81, -81, -81, -79, -80, -79, -78, -77, -76, -74, -73, -71, -70,
-69, -67, -65, -63, -61, -59, -56, -54, -51, -47, -45, -42, -39, -37, -33, -30,
-26, -23, -19, -16, -12, -9, -4, };