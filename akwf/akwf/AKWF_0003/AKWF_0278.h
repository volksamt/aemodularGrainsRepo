#define DATA_LENGTH 512
#define DATA AKWF_0278

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 1, 3, 3, 4, 5, 6, 8, 8, 9, 10,
11, 13, 14, 14, 17, 17, 18, 21, 21, 23, 24, 27, 27, 29, 30, 33, 33, 35, 38, 38,
40, 41, 43, 45, 46, 47, 49, 50, 52, 53, 55, 56, 58, 59, 60, 61, 62, 63, 64, 65,
67, 66, 66, 68, 68, 68, 69, 69, 69, 69, 69, 69, 70, 69, 70, 69, 69, 69, 68, 67,
67, 66, 66, 65, 63, 63, 62, 62, 61, 60, 59, 58, 57, 56, 56, 54, 54, 54, 53, 52,
52, 51, 50, 49, 49, 49, 48, 48, 48, 47, 47, 47, 46, 45, 45, 46, 45, 46, 46, 47,
47, 46, 46, 47, 46, 47, 47, 48, 49, 48, 49, 49, 49, 50, 50, 50, 51, 51, 51, 51,
51, 51, 51, 50, 51, 51, 51, 51, 50, 50, 50, 49, 49, 48, 48, 47, 46, 45, 45, 45,
43, 43, 41, 40, 40, 38, 38, 36, 36, 35, 33, 33, 31, 30, 30, 29, 28, 28, 26, 25,
24, 23, 23, 22, 21, 21, 21, 21, 20, 19, 18, 18, 17, 19, 17, 18, 18, 17, 18, 18,
18, 18, 19, 19, 19, 20, 20, 21, 22, 21, 23, 23, 24, 25, 25, 25, 27, 27, 28, 28,
28, 30, 30, 31, 31, 30, 31, 31, 32, 32, 32, 32, 32, 31, 32, 31, 31, 30, 29, 30,
30, 29, 28, 27, 26, 26, 26, 25, 22, 22, 21, 20, 20, 18, 17, 17, 15, 14, 13, 11,
11, 9, 9, 7, 5, 5, 3, 1, 1, -1, -1, -2, -3, -4, -5, -6, -7, -8, -8, -10, -10,
-10, -12, -12, -12, -13, -13, -13, -13, -15, -14, -14, -15, -15, -15, -14, -15,
-15, -17, -20, -22, -24, -28, -30, -33, -36, -39, -43, -46, -49, -53, -56, -60,
-65, -69, -73, -77, -81, -85, -89, -92, -95, -98, -101, -103, -106, -109, -111,
-113, -114, -116, -116, -117, -118, -119, -119, -119, -119, -118, -118, -117,
-116, -115, -113, -112, -110, -108, -106, -105, -102, -100, -98, -95, -92, -90,
-88, -85, -82, -79, -78, -74, -72, -70, -67, -64, -63, -61, -58, -56, -54, -52,
-50, -49, -47, -46, -45, -44, -43, -41, -40, -40, -39, -39, -38, -38, -38, -37,
-38, -37, -37, -37, -37, -38, -39, -39, -39, -40, -40, -41, -41, -42, -42, -42,
-43, -44, -44, -45, -46, -46, -46, -46, -47, -47, -47, -47, -47, -47, -47, -47,
-46, -46, -45, -44, -43, -43, -42, -41, -41, -39, -39, -38, -37, -35, -35, -32,
-31, -31, -29, -27, -27, -25, -23, -22, -21, -20, -18, -17, -16, -15, -13, -13,
-13, -11, -9, -9, -8, -7, -7, -6, -5, -6, -4, -4, -4, -4, -3, -2, -2, -3, -3,
-3, -2, -3, -3, -4, -3, -3, -4, -4, -4, -4, -4, -6, -6, -5, -5, -6, -7, -7, -7,
-7, -7, -7, -7, -7, -6, -7, -7, -7, -7, -7, -7, -6, -7, -7, -7, -6, -6, -5, -5,
-4, -4, -4, -3, -2, -3, -1, -1, -1, 0, };