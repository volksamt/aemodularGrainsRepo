#define DATA_LENGTH 512
#define DATA AKWF_0244

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 19, 33, 42, 45, 49, 53, 55, 57, 60,
63, 66, 68, 72, 74, 76, 78, 81, 81, 84, 85, 86, 87, 88, 89, 91, 92, 93, 93, 95,
96, 98, 99, 100, 102, 102, 104, 105, 107, 108, 109, 111, 111, 113, 114, 116,
116, 118, 120, 118, 119, 119, 119, 120, 119, 119, 118, 119, 119, 118, 119, 119,
119, 119, 119, 118, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119,
119, 119, 118, 119, 118, 119, 119, 119, 118, 118, 118, 118, 118, 118, 118, 118,
118, 119, 119, 118, 118, 118, 118, 118, 119, 118, 118, 118, 118, 118, 118, 118,
118, 118, 118, 118, 119, 118, 119, 118, 118, 117, 117, 118, 118, 119, 115, 107,
96, 89, 34, -24, -90, -122, -113, -118, -115, -118, -116, -117, -115, -115,
-113, -112, -110, -110, -108, -108, -107, -108, -108, -105, -105, -103, -103,
-101, -100, -98, -97, -95, -95, -92, -92, -90, -90, -88, -87, -85, -82, -79,
-76, -75, -73, -73, -71, -69, -66, -63, -62, -61, -59, -57, -52, -49, -42, -36,
-28, -20, -18, -2, 15, 33, 43, 44, 50, 52, 55, 58, 61, 63, 65, 68, 70, 73, 76,
79, 80, 81, 83, 83, 85, 86, 87, 89, 90, 92, 93, 94, 95, 96, 98, 99, 100, 102,
103, 104, 105, 107, 108, 110, 111, 112, 114, 114, 113, 114, 113, 116, 116, 118,
118, 118, 118, 118, 118, 118, 117, 118, 118, 119, 117, 118, 119, 117, 119, 116,
122, 64, -5, -78, -123, -114, -119, -115, -118, -116, -117, -116, -117, -117,
-117, -116, -117, -117, -117, -117, -117, -117, -116, -115, -113, -113, -110,
-109, -108, -108, -107, -108, -107, -106, -105, -104, -103, -101, -100, -98,
-98, -95, -95, -93, -92, -90, -89, -88, -87, -85, -82, -80, -77, -76, -74, -74,
-71, -68, -66, -63, -61, -58, -55, -53, -51, -48, -44, -37, -29, -22, -9, 5, 20,
32, 36, 42, 47, 50, 54, 59, 62, 65, 67, 69, 71, 72, 73, 76, 77, 81, 83, 82, 85,
86, 88, 87, 90, 91, 92, 94, 96, 95, 97, 99, 100, 101, 103, 104, 105, 107, 107,
110, 109, 112, 113, 113, 114, 113, 113, 116, 117, 118, 118, 118, 118, 117, 118,
117, 120, 59, -8, -82, -123, -113, -119, -116, -118, -116, -117, -117, -117,
-117, -117, -116, -116, -117, -116, -117, -116, -117, -117, -117, -116, -117,
-117, -117, -116, -117, -116, -117, -117, -116, -117, -117, -117, -117, -116,
-117, -117, -116, -116, -116, -117, -117, -117, -117, -117, -117, -117, -116,
-117, -116, -116, -117, -117, -116, -116, -116, -116, -116, -116, -116, -116,
-116, -116, -116, -116, -117, -117, -116, -116, -116, -116, -116, -116, -116,
-116, -117, -115, -114, -112, -112, -112, -111, -111, -110, -110, -108, -107,
-105, -104, -103, -101, -100, -99, -97, -96, -95, -93, -92, -92, -90, -88, -87,
-86, -84, -83, -82, -80, -78, -76, -73, -70, -69, -68, -66, -64, -62, -59, -58,
-56, -51, -48, -42, -35, -27, -19, -7, };