#define DATA_LENGTH 512
#define DATA AKWF_0219

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 5, 7, 8, 10, 12, 13, 15, 17, 18,
20, 22, 23, 24, 27, 30, 31, 34, 35, 37, 39, 41, 44, 46, 47, 49, 52, 54, 55, 57,
60, 60, 63, 65, 66, 69, 70, 72, 73, 75, 76, 77, 79, 80, 81, 82, 83, 85, 85, 85,
87, 87, 88, 89, 89, 89, 90, 92, 91, 92, 91, 92, 92, 92, 93, 92, 92, 92, 92, 91,
91, 92, 91, 90, 91, 89, 89, 89, 88, 88, 86, 87, 86, 85, 85, 85, 84, 82, 81, 80,
79, 79, 78, 78, 76, 75, 74, 73, 73, 70, 70, 69, 69, 67, 66, 65, 64, 63, 61, 61,
60, 58, 59, 57, 57, 55, 55, 53, 52, 51, 50, 49, 49, 47, 47, 46, 44, 44, 44, 44,
43, 42, 42, 43, 42, 42, 42, 42, 43, 42, 42, 43, 44, 44, 45, 46, 46, 47, 48, 50,
51, 52, 53, 55, 56, 58, 60, 62, 66, 69, 72, 75, 78, 81, 84, 87, 89, 92, 94, 97,
98, 100, 103, 105, 106, 107, 108, 110, 111, 113, 114, 115, 115, 117, 118, 118,
118, 118, 118, 119, 118, 119, 118, 118, 117, 116, 115, 114, 113, 111, 108, 107,
105, 104, 101, 99, 96, 94, 92, 90, 87, 84, 81, 80, 77, 74, 72, 70, 67, 64, 61,
59, 57, 54, 52, 50, 47, 44, 42, 39, 37, 34, 32, 30, 27, 25, 23, 21, 19, 17, 14,
12, 10, 8, 6, 5, 2, 0, -2, -4, -5, -7, -10, -11, -12, -14, -16, -17, -19, -21,
-23, -26, -27, -29, -31, -34, -36, -38, -40, -43, -44, -46, -49, -50, -52, -54,
-56, -58, -60, -62, -64, -65, -67, -68, -70, -72, -74, -75, -75, -78, -79, -80,
-81, -82, -83, -84, -85, -85, -87, -88, -88, -89, -89, -89, -90, -91, -90, -90,
-91, -92, -92, -92, -91, -92, -91, -91, -91, -91, -90, -91, -91, -90, -89, -89,
-89, -88, -89, -87, -86, -86, -85, -85, -84, -83, -83, -82, -80, -80, -79, -78,
-78, -77, -76, -74, -73, -73, -72, -70, -70, -69, -68, -67, -66, -65, -65, -63,
-61, -61, -60, -59, -58, -57, -56, -55, -54, -53, -52, -51, -51, -50, -48, -47,
-47, -45, -45, -44, -43, -42, -42, -41, -40, -39, -39, -38, -37, -36, -36, -35,
-35, -34, -33, -33, -32, -32, -31, -33, -31, -32, -33, -32, -32, -32, -33, -33,
-33, -34, -36, -35, -37, -37, -39, -39, -40, -43, -43, -46, -46, -49, -50, -51,
-53, -56, -59, -62, -65, -69, -73, -75, -79, -81, -84, -86, -89, -92, -93, -95,
-98, -100, -101, -103, -105, -106, -107, -109, -110, -111, -112, -113, -113,
-114, -115, -115, -115, -116, -116, -117, -116, -115, -113, -114, -112, -110,
-108, -107, -105, -103, -101, -100, -98, -95, -93, -91, -89, -86, -83, -81, -79,
-77, -73, -71, -68, -66, -64, -61, -58, -55, -54, -51, -48, -47, -45, -42, -39,
-36, -35, -32, -30, -28, -25, -24, -21, -19, -16, -15, -12, -11, -9, -6, -4, -2,
0, };