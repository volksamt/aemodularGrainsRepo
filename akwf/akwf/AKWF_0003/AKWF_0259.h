#define DATA_LENGTH 512
#define DATA AKWF_0259

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 12, 18, 23, 28, 33, 36, 41, 45, 49,
52, 56, 59, 62, 63, 63, 63, 61, 60, 59, 57, 55, 53, 52, 51, 49, 48, 47, 46, 45,
43, 43, 41, 41, 41, 40, 40, 39, 38, 38, 38, 37, 37, 37, 38, 37, 37, 38, 38, 37,
38, 39, 40, 40, 40, 41, 42, 42, 43, 45, 45, 47, 47, 48, 49, 49, 52, 53, 54, 54,
57, 57, 59, 60, 61, 63, 63, 65, 67, 69, 70, 72, 72, 74, 75, 77, 78, 80, 81, 83,
84, 85, 87, 88, 89, 91, 92, 93, 94, 96, 96, 98, 99, 100, 101, 103, 103, 105,
105, 106, 107, 109, 109, 110, 110, 112, 112, 113, 113, 114, 115, 115, 115, 116,
116, 117, 118, 118, 117, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 120,
118, 118, 119, 119, 119, 118, 118, 117, 117, 116, 117, 116, 116, 115, 115, 113,
113, 114, 113, 112, 112, 110, 110, 109, 109, 108, 107, 107, 107, 106, 106, 104,
103, 102, 102, 101, 101, 100, 100, 98, 98, 98, 97, 96, 95, 94, 94, 93, 93, 92,
91, 92, 90, 90, 89, 89, 88, 87, 87, 86, 86, 86, 85, 84, 84, 84, 84, 83, 82, 83,
81, 81, 81, 81, 81, 80, 80, 80, 80, 80, 80, 80, 79, 80, 79, 79, 79, 79, 78, 78,
79, 79, 79, 80, 80, 79, 79, 79, 79, 80, 80, 80, 81, 80, 80, 77, 72, 65, 56, 48,
40, 31, 23, 15, 8, 1, -7, -12, -18, -23, -28, -33, -38, -41, -45, -49, -53, -56,
-59, -62, -64, -64, -62, -62, -60, -58, -57, -54, -53, -52, -51, -50, -48, -46,
-45, -45, -43, -43, -42, -41, -41, -39, -39, -39, -39, -38, -38, -37, -38, -37,
-37, -36, -37, -38, -37, -37, -38, -40, -39, -41, -41, -42, -42, -42, -44, -45,
-45, -47, -47, -48, -50, -50, -52, -52, -53, -55, -56, -57, -58, -60, -61, -63,
-65, -66, -67, -69, -69, -70, -73, -74, -75, -77, -78, -80, -81, -83, -84, -85,
-87, -88, -89, -90, -92, -93, -94, -95, -97, -98, -99, -100, -101, -102, -104,
-104, -105, -107, -107, -108, -109, -110, -111, -111, -112, -113, -113, -114,
-115, -115, -115, -116, -116, -116, -117, -118, -118, -118, -118, -119, -118,
-118, -119, -119, -119, -120, -118, -119, -119, -118, -119, -119, -118, -118,
-117, -118, -117, -116, -116, -116, -115, -115, -114, -114, -114, -114, -112,
-112, -111, -110, -110, -109, -109, -107, -108, -107, -106, -106, -105, -104,
-103, -102, -101, -101, -100, -100, -99, -98, -98, -97, -97, -96, -96, -95, -94,
-94, -92, -92, -92, -91, -90, -89, -89, -89, -87, -87, -87, -86, -86, -85, -85,
-84, -84, -84, -84, -83, -83, -82, -82, -82, -81, -81, -81, -81, -81, -80, -79,
-80, -79, -80, -80, -79, -79, -78, -78, -79, -78, -79, -79, -78, -79, -79, -79,
-79, -79, -79, -80, -80, -80, -80, -81, -81, -80, -76, -71, -65, -56, -48, -39,
-31, -22, -14, -6, -1, };