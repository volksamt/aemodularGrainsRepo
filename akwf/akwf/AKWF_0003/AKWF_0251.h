#define DATA_LENGTH 512
#define DATA AKWF_0251

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 8, 11, 14, 17, 19, 22, 24,
26, 30, 32, 35, 37, 40, 42, 45, 48, 51, 53, 55, 57, 60, 61, 64, 67, 68, 70, 72,
74, 75, 78, 79, 82, 83, 85, 86, 87, 89, 90, 92, 93, 94, 95, 97, 98, 98, 99, 99,
101, 102, 103, 102, 104, 104, 105, 105, 105, 106, 107, 106, 107, 108, 108, 107,
107, 107, 107, 107, 107, 107, 107, 107, 106, 106, 106, 106, 104, 105, 104, 104,
103, 103, 102, 101, 101, 99, 99, 98, 97, 96, 96, 95, 94, 93, 92, 91, 90, 89, 89,
87, 87, 85, 84, 83, 81, 81, 80, 78, 77, 75, 74, 73, 72, 70, 69, 68, 66, 65, 64,
63, 61, 59, 58, 58, 56, 54, 54, 52, 50, 50, 48, 47, 45, 44, 42, 41, 40, 39, 38,
36, 35, 34, 33, 32, 30, 29, 28, 26, 26, 24, 24, 23, 22, 21, 19, 18, 18, 17, 16,
15, 15, 13, 13, 13, 11, 12, 10, 10, 10, 9, 9, 8, 8, 7, 7, 6, 6, 7, 6, 6, 6, 6,
5, 6, 6, 6, 6, 6, 6, 7, 8, 8, 7, 8, 9, 9, 10, 10, 10, 11, 11, 12, 13, 14, 14,
15, 15, 17, 17, 18, 20, 20, 21, 22, 23, 24, 25, 27, 27, 28, 30, 30, 31, 33, 33,
35, 35, 37, 37, 38, 38, 37, 35, 33, 30, 28, 26, 25, 22, 21, 19, 17, 15, 14, 13,
11, 10, 9, 9, 8, 7, 6, 5, 5, 4, 4, 3, 3, 3, 3, 1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 1,
1, 1, 1, 2, 2, 2, 3, 3, 2, 3, 3, 3, 3, 4, 3, 3, 4, 4, 3, 3, 4, 5, 5, 5, 5, 5, 5,
4, 5, 5, 5, 5, 4, 4, 5, 4, 4, 4, 4, 3, 2, 3, 3, 2, 2, 1, 0, 0, -1, -1, -1, -1,
-2, -3, -3, -5, -5, -5, -6, -8, -8, -9, -9, -11, -11, -13, -13, -14, -16, -17,
-17, -19, -20, -21, -22, -23, -24, -25, -26, -27, -29, -30, -31, -32, -33, -34,
-36, -38, -39, -40, -42, -43, -44, -45, -47, -48, -50, -51, -53, -54, -56, -57,
-59, -60, -61, -63, -64, -65, -67, -68, -70, -72, -73, -75, -76, -78, -78, -80,
-81, -83, -84, -85, -86, -87, -89, -90, -92, -93, -94, -96, -97, -97, -99, -99,
-101, -102, -103, -104, -104, -106, -107, -108, -108, -110, -110, -111, -111,
-112, -113, -115, -115, -115, -116, -116, -117, -117, -117, -118, -118, -118,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -118, -117, -117, -117, -117, -115, -115, -115, -115, -113, -112, -111,
-109, -109, -107, -107, -105, -104, -102, -101, -100, -98, -96, -94, -93, -91,
-88, -87, -85, -82, -81, -79, -77, -75, -73, -71, -68, -67, -64, -62, -60, -57,
-55, -54, -50, -49, -46, -43, -41, -39, -36, -33, -32, -29, -27, -25, -22, -19,
-17, -14, -12, -10, -7, -4, -1, };