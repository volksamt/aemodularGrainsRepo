#define DATA_LENGTH 512
#define DATA AKWF_0211

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 10, 15, 19, 22, 26, 31, 34, 37,
42, 45, 48, 51, 54, 58, 62, 66, 68, 71, 73, 76, 80, 83, 84, 86, 89, 92, 96, 98,
100, 100, 102, 106, 108, 110, 112, 112, 114, 116, 117, 117, 119, 119, 117, 116,
115, 115, 114, 111, 108, 106, 104, 103, 101, 97, 92, 89, 86, 83, 79, 75, 71, 66,
62, 57, 53, 48, 43, 39, 34, 29, 23, 17, 13, 8, 3, -2, -8, -14, -19, -24, -30,
-35, -40, -44, -49, -55, -59, -64, -67, -70, -74, -77, -80, -83, -86, -89, -93,
-95, -98, -100, -103, -105, -106, -107, -110, -110, -113, -113, -115, -117,
-118, -118, -118, -117, -114, -112, -112, -113, -109, -108, -105, -102, -100,
-98, -95, -91, -88, -84, -82, -78, -75, -72, -69, -64, -60, -56, -52, -48, -43,
-40, -36, -34, -31, -26, -22, -17, -14, -10, -7, -5, -1, 2, 5, 8, 11, 13, 17,
21, 24, 27, 29, 31, 35, 37, 41, 44, 48, 50, 53, 54, 56, 60, 63, 66, 67, 68, 70,
74, 77, 77, 79, 80, 81, 82, 83, 86, 86, 86, 87, 90, 90, 91, 90, 91, 93, 94, 93,
93, 92, 93, 94, 95, 96, 96, 96, 95, 95, 96, 96, 97, 97, 98, 97, 97, 97, 97, 98,
99, 100, 99, 98, 97, 97, 96, 95, 95, 93, 92, 90, 87, 84, 82, 80, 79, 76, 71, 68,
64, 62, 59, 56, 52, 47, 44, 39, 33, 29, 26, 23, 19, 14, 8, 4, 0, -2, -6, -11,
-14, -17, -21, -24, -27, -31, -34, -37, -40, -44, -46, -49, -50, -53, -57, -62,
-65, -68, -70, -71, -76, -80, -83, -86, -89, -90, -93, -97, -101, -103, -107,
-108, -108, -107, -109, -110, -111, -111, -110, -109, -108, -108, -107, -105,
-101, -97, -94, -93, -91, -88, -85, -82, -76, -72, -69, -66, -62, -57, -53, -50,
-46, -43, -38, -34, -30, -26, -21, -16, -13, -9, -3, 3, 7, 11, 15, 19, 24, 30,
34, 38, 41, 45, 49, 54, 59, 63, 68, 71, 74, 76, 80, 83, 85, 87, 90, 93, 94, 96,
98, 99, 101, 100, 101, 103, 105, 105, 105, 105, 106, 105, 106, 105, 106, 105,
103, 101, 100, 99, 99, 97, 94, 89, 84, 83, 82, 79, 75, 71, 67, 64, 61, 58, 54,
52, 48, 45, 41, 38, 34, 31, 27, 24, 21, 18, 14, 10, 5, 3, 1, -3, -7, -11, -14,
-18, -20, -25, -28, -32, -35, -38, -42, -45, -48, -52, -55, -59, -61, -63, -66,
-68, -71, -74, -74, -75, -77, -80, -80, -81, -82, -85, -85, -85, -86, -87, -89,
-90, -91, -92, -92, -93, -95, -95, -97, -96, -97, -98, -98, -101, -101, -102,
-102, -104, -105, -104, -105, -105, -106, -108, -108, -107, -108, -107, -108,
-106, -105, -104, -105, -104, -103, -99, -97, -95, -93, -92, -90, -87, -85, -82,
-79, -78, -76, -74, -72, -70, -67, -63, -60, -57, -55, -53, -49, -45, -40, -37,
-34, -30, -26, -22, -18, -14, -11, -6, -1, };