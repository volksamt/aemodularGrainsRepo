#define DATA_LENGTH 512
#define DATA AKWF_0260

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 6, 8, 10, 11, 13, 14, 15, 17,
17, 18, 18, 19, 20, 20, 20, 21, 20, 20, 22, 22, 22, 22, 22, 22, 22, 22, 23, 23,
22, 22, 22, 23, 22, 23, 24, 23, 23, 23, 23, 24, 23, 24, 23, 23, 23, 23, 23, 24,
23, 23, 24, 24, 22, 23, 24, 24, 23, 24, 24, 24, 23, 23, 24, 24, 23, 24, 23, 23,
23, 24, 24, 23, 23, 23, 23, 23, 24, 23, 24, 22, 24, 21, 30, 54, 42, 39, 43, 47,
53, 56, 59, 61, 64, 65, 66, 68, 69, 69, 71, 71, 72, 72, 73, 72, 73, 73, 74, 73,
73, 74, 73, 74, 74, 74, 74, 73, 74, 74, 74, 74, 74, 75, 74, 74, 73, 74, 74, 74,
74, 74, 74, 74, 74, 74, 74, 74, 74, 73, 74, 74, 73, 73, 73, 74, 73, 73, 74, 73,
73, 74, 74, 73, 73, 73, 73, 73, 73, 73, 73, 73, 73, 73, 72, 72, 73, 73, 72, 73,
73, 73, 72, 72, 73, 73, 72, 73, 72, 88, 85, 78, 82, 85, 89, 91, 94, 96, 99, 100,
101, 102, 103, 103, 104, 105, 105, 106, 106, 107, 107, 107, 106, 107, 107, 107,
108, 108, 108, 108, 108, 107, 108, 107, 108, 107, 107, 107, 108, 106, 108, 107,
107, 106, 107, 107, 108, 108, 106, 107, 106, 108, 106, 107, 106, 108, 105, 108,
104, 108, 104, 110, 103, 110, 101, 120, 79, -18, 64, 74, 55, 32, -5, -21, -38,
-46, -59, -63, -73, -75, -82, -83, -89, -90, -93, -94, -97, -97, -99, -99, -101,
-101, -101, -102, -103, -103, -102, -103, -103, -104, -103, -104, -103, -104,
-104, -104, -105, -104, -104, -104, -104, -104, -104, -104, -104, -104, -104,
-104, -104, -104, -104, -103, -104, -104, -103, -103, -104, -103, -104, -103,
-104, -103, -104, -102, -104, -96, -87, -97, -96, -94, -89, -87, -84, -82, -80,
-78, -76, -76, -74, -73, -73, -72, -71, -71, -70, -70, -70, -70, -69, -68, -69,
-68, -69, -68, -68, -68, -67, -69, -68, -68, -68, -68, -68, -68, -68, -67, -67,
-68, -68, -67, -68, -68, -67, -67, -67, -68, -67, -68, -67, -67, -67, -68, -67,
-67, -67, -67, -67, -67, -67, -66, -67, -67, -67, -67, -67, -67, -67, -67, -67,
-67, -67, -67, -66, -67, -67, -66, -67, -67, -66, -66, -67, -66, -66, -66, -67,
-66, -66, -66, -68, -62, -49, -57, -59, -56, -54, -50, -48, -45, -43, -39, -38,
-37, -36, -34, -34, -33, -33, -32, -31, -32, -31, -30, -31, -30, -30, -30, -30,
-30, -30, -29, -29, -29, -29, -29, -29, -29, -29, -29, -30, -29, -29, -29, -28,
-29, -29, -29, -29, -29, -29, -28, -28, -29, -30, -29, -29, -29, -29, -28, -29,
-29, -29, -29, -28, -29, -29, -29, -29, -29, -29, -29, -29, -29, -29, -29, -29,
-29, -29, -28, -29, -28, -28, -29, -29, -28, -29, -28, -28, -28, -28, -28, -29,
-27, -30, -13, -12, -22, -18, -16, -11, -9, -3, -1, };