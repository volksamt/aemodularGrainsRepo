#define DATA_LENGTH 512
#define DATA AKWF_0257

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 6, 8, 11, 14, 16, 19, 22, 25,
28, 30, 34, 37, 41, 43, 47, 49, 53, 56, 58, 61, 64, 67, 69, 72, 75, 77, 81, 83,
85, 87, 89, 91, 93, 94, 96, 98, 98, 100, 101, 102, 103, 103, 104, 104, 104, 105,
105, 104, 104, 103, 102, 101, 100, 99, 98, 97, 95, 92, 91, 88, 86, 84, 82, 79,
76, 73, 70, 67, 64, 61, 57, 54, 51, 47, 44, 40, 36, 32, 29, 26, 21, 17, 15, 10,
6, 2, -2, -5, -9, -12, -15, -19, -23, -26, -30, -33, -36, -40, -42, -45, -48,
-52, -54, -55, -58, -61, -63, -65, -67, -68, -71, -72, -74, -75, -75, -77, -78,
-79, -79, -79, -80, -81, -81, -81, -81, -81, -81, -80, -80, -80, -80, -79, -78,
-77, -77, -75, -74, -74, -73, -71, -69, -68, -68, -67, -64, -63, -62, -59, -58,
-57, -56, -54, -52, -51, -49, -48, -46, -45, -43, -42, -40, -38, -37, -36, -34,
-34, -32, -31, -29, -29, -27, -26, -25, -23, -23, -22, -21, -20, -19, -18, -17,
-17, -16, -15, -15, -14, -14, -14, -14, -13, -12, -12, -12, -11, -11, -11, -11,
-10, -10, -11, -10, -10, -10, -9, -10, -10, -9, -10, -9, -9, -9, -8, -8, -7, -7,
-7, -7, -6, -6, -5, -4, -4, -4, -3, -2, -1, 0, 2, 2, 4, 5, 5, 7, 9, 10, 12, 13,
15, 17, 18, 19, 22, 24, 25, 27, 29, 31, 33, 36, 37, 39, 41, 43, 46, 48, 50, 52,
53, 56, 57, 59, 61, 63, 65, 66, 69, 70, 72, 73, 75, 76, 77, 79, 80, 79, 80, 82,
82, 82, 83, 84, 83, 84, 85, 84, 84, 83, 83, 83, 81, 81, 80, 78, 77, 76, 74, 73,
72, 69, 68, 66, 63, 61, 58, 56, 53, 51, 48, 45, 42, 39, 36, 33, 29, 25, 22, 19,
15, 11, 7, 3, -1, -5, -8, -12, -17, -20, -25, -29, -33, -37, -40, -44, -49, -52,
-56, -60, -64, -68, -71, -74, -78, -81, -85, -88, -91, -93, -95, -99, -101,
-103, -106, -107, -109, -112, -114, -114, -116, -117, -117, -117, -119, -119,
-119, -119, -118, -119, -118, -118, -116, -116, -114, -114, -112, -109, -107,
-106, -104, -102, -99, -96, -95, -91, -89, -86, -83, -80, -77, -74, -69, -66,
-63, -59, -56, -52, -49, -45, -41, -38, -34, -31, -26, -23, -19, -16, -12, -8,
-4, 0, 2, 6, 8, 12, 15, 18, 21, 24, 27, 29, 31, 34, 37, 38, 41, 43, 44, 46, 48,
49, 49, 51, 52, 52, 53, 53, 54, 53, 53, 54, 53, 53, 53, 52, 51, 50, 49, 49, 46,
45, 44, 43, 42, 39, 37, 36, 34, 31, 30, 28, 26, 24, 20, 19, 16, 14, 12, 9, 7, 5,
3, 1, -2, -3, -6, -7, -9, -11, -13, -14, -16, -18, -18, -20, -21, -22, -22, -23,
-24, -25, -25, -24, -25, -25, -25, -24, -23, -23, -22, -21, -19, -19, -17, -15,
-13, -13, -10, -8, -6, -4, -2, };