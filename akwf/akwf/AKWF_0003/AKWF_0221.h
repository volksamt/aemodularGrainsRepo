#define DATA_LENGTH 512
#define DATA AKWF_0221

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 4, 6, 6, 8, 7, 8, 9, 11,
11, 12, 12, 12, 14, 15, 16, 16, 17, 19, 19, 19, 19, 21, 22, 22, 23, 23, 24, 25,
26, 27, 26, 28, 28, 29, 29, 30, 31, 30, 31, 31, 33, 32, 33, 33, 34, 35, 36, 39,
40, 42, 44, 47, 50, 53, 55, 58, 62, 65, 67, 70, 73, 76, 78, 80, 82, 84, 85, 86,
88, 88, 88, 89, 89, 89, 89, 88, 86, 86, 85, 85, 83, 81, 80, 79, 77, 76, 74, 72,
70, 68, 66, 64, 63, 60, 59, 56, 55, 52, 51, 49, 47, 45, 43, 42, 39, 38, 36, 34,
32, 31, 29, 28, 27, 25, 23, 23, 21, 19, 18, 16, 14, 13, 12, 11, 10, 8, 6, 5, 3,
2, 0, -1, -2, -3, -4, -6, -7, -8, -10, -10, -13, -14, -14, -16, -18, -18, -19,
-21, -22, -22, -24, -24, -26, -27, -28, -28, -29, -31, -31, -32, -33, -33, -34,
-35, -37, -37, -38, -38, -41, -43, -44, -46, -49, -52, -54, -58, -60, -63, -67,
-70, -73, -76, -79, -81, -84, -86, -89, -91, -92, -94, -95, -96, -96, -97, -97,
-99, -97, -98, -97, -96, -95, -94, -92, -93, -90, -88, -87, -85, -84, -81, -79,
-78, -76, -74, -71, -70, -67, -65, -63, -61, -59, -58, -56, -54, -52, -50, -48,
-46, -44, -42, -40, -38, -37, -35, -33, -31, -29, -28, -26, -24, -21, -20, -16,
-13, -11, -8, -5, -2, 0, 3, 6, 8, 11, 13, 15, 18, 20, 23, 25, 28, 30, 33, 36,
40, 43, 47, 49, 52, 55, 58, 61, 63, 66, 68, 69, 71, 72, 73, 74, 75, 75, 75, 74,
74, 72, 69, 68, 66, 64, 62, 59, 57, 55, 53, 52, 50, 49, 49, 49, 48, 49, 48, 48,
49, 49, 49, 49, 50, 50, 50, 51, 51, 51, 51, 50, 49, 48, 47, 44, 43, 40, 40, 37,
35, 33, 32, 30, 28, 25, 25, 24, 22, 21, 20, 19, 20, 18, 19, 19, 18, 19, 18, 19,
18, 18, 18, 18, 18, 18, 17, 18, 16, 16, 15, 13, 11, 10, 9, 6, 5, 4, 1, 0, -2,
-4, -5, -7, -7, -8, -9, -9, -9, -10, -9, -9, -10, -8, -8, -7, -7, -7, -6, -6,
-5, -5, -5, -5, -4, -3, -3, -3, -3, -3, -2, -3, -2, -3, -3, -3, -3, -4, -4, -4,
-5, -5, -6, -7, -6, -7, -8, -9, -9, -10, -11, -10, -12, -12, -13, -13, -14, -14,
-15, -16, -17, -18, -19, -22, -25, -28, -31, -33, -37, -40, -44, -46, -50, -54,
-57, -60, -62, -65, -67, -69, -70, -72, -73, -74, -75, -76, -75, -76, -76, -76,
-74, -74, -73, -72, -71, -70, -68, -67, -65, -64, -63, -61, -60, -57, -55, -54,
-53, -51, -50, -48, -46, -45, -43, -42, -41, -38, -36, -36, -34, -32, -32, -30,
-28, -26, -26, -24, -22, -21, -19, -17, -16, -15, -13, -12, -10, -10, -8, -8,
-6, -4, -3, -2, -2, 0, 0, };