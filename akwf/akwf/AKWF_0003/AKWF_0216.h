#define DATA_LENGTH 512
#define DATA AKWF_0216

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 3, 3, 4, 4, 7, 10, 10, 12,
13, 14, 14, 15, 16, 17, 18, 19, 21, 22, 22, 23, 22, 21, 21, 22, 22, 23, 23, 24,
25, 26, 26, 27, 27, 28, 28, 30, 32, 36, 37, 38, 39, 41, 41, 42, 44, 44, 45, 46,
48, 50, 51, 53, 50, 46, 48, 49, 48, 49, 50, 51, 53, 54, 56, 56, 58, 59, 61, 63,
72, 84, 87, 90, 94, 96, 98, 99, 100, 103, 104, 106, 109, 110, 113, 115, 113,
109, 110, 112, 111, 112, 112, 113, 113, 114, 114, 114, 113, 112, 113, 112, 115,
116, 117, 117, 116, 117, 117, 116, 116, 116, 115, 115, 114, 114, 115, 115, 111,
108, 108, 107, 106, 105, 105, 104, 104, 103, 102, 102, 100, 100, 98, 98, 99,
100, 100, 98, 98, 98, 97, 96, 95, 94, 94, 93, 93, 92, 92, 91, 88, 85, 85, 83,
82, 81, 81, 80, 80, 78, 77, 77, 75, 74, 73, 72, 72, 74, 73, 72, 72, 71, 70, 69,
69, 68, 66, 66, 65, 65, 64, 63, 60, 58, 56, 56, 56, 54, 52, 52, 51, 51, 50, 49,
47, 46, 45, 43, 44, 45, 45, 44, 43, 43, 41, 41, 40, 39, 38, 37, 37, 36, 36, 34,
33, 29, 29, 28, 27, 26, 25, 24, 23, 22, 22, 20, 19, 18, 17, 16, 17, 18, 17, 16,
16, 15, 15, 13, 13, 12, 11, 11, 11, 10, 9, 7, 5, 3, 2, 2, 0, -1, -1, -3, -4, -4,
-6, -6, -7, -8, -9, -10, -10, -8, -9, -8, -10, -10, -12, -12, -12, -14, -14,
-14, -16, -16, -17, -17, -20, -22, -24, -25, -27, -26, -27, -29, -29, -30, -31,
-33, -34, -34, -36, -37, -35, -33, -33, -34, -34, -35, -35, -38, -39, -38, -40,
-40, -41, -41, -41, -42, -47, -54, -55, -57, -59, -62, -65, -67, -68, -71, -73,
-76, -78, -82, -84, -88, -81, -74, -77, -77, -80, -80, -83, -86, -89, -90, -92,
-94, -95, -95, -97, -98, -103, -109, -109, -110, -112, -113, -114, -114, -115,
-115, -115, -116, -118, -118, -119, -119, -117, -114, -114, -114, -113, -113,
-112, -112, -112, -112, -111, -111, -110, -109, -108, -107, -109, -111, -109,
-111, -110, -109, -107, -108, -107, -106, -105, -105, -105, -104, -104, -103,
-102, -98, -97, -97, -96, -94, -94, -93, -93, -92, -91, -90, -89, -88, -87, -86,
-86, -87, -86, -86, -85, -85, -84, -82, -82, -81, -80, -80, -79, -79, -78, -78,
-75, -72, -71, -69, -69, -68, -67, -67, -65, -65, -63, -63, -62, -60, -58, -59,
-59, -60, -59, -58, -58, -56, -55, -55, -54, -53, -52, -51, -51, -50, -50, -49,
-46, -43, -43, -42, -41, -40, -39, -39, -37, -37, -35, -35, -33, -32, -32, -31,
-31, -32, -31, -31, -30, -29, -28, -27, -26, -25, -24, -24, -24, -22, -23, -21,
-18, -17, -15, -14, -14, -12, -11, -11, -11, -9, -8, -6, -6, -5, -4, -4, -4, -6,
-4, -4, -3, -2, -1, 0, };