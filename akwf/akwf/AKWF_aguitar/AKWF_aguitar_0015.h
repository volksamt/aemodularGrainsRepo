#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 10, 14, 18, 22, 27, 32, 34, 39,
43, 46, 50, 54, 56, 60, 63, 66, 68, 70, 73, 76, 77, 79, 81, 84, 83, 85, 87, 87,
88, 88, 89, 88, 88, 87, 87, 86, 85, 84, 82, 81, 79, 77, 75, 72, 70, 67, 64, 61,
58, 54, 52, 48, 44, 40, 37, 32, 29, 24, 19, 16, 11, 6, 2, -3, -8, -12, -16, -21,
-26, -30, -34, -39, -43, -47, -51, -55, -59, -63, -66, -70, -74, -77, -80, -83,
-87, -89, -92, -94, -97, -99, -101, -104, -106, -107, -109, -111, -112, -114,
-114, -115, -117, -118, -118, -119, -119, -119, -119, -119, -119, -118, -117,
-117, -116, -114, -114, -112, -111, -108, -107, -105, -103, -101, -98, -96, -93,
-90, -87, -83, -81, -76, -73, -69, -66, -62, -58, -54, -51, -46, -42, -37, -35,
-30, -25, -21, -17, -13, -9, -5, 0, 2, 7, 11, 14, 18, 22, 25, 29, 31, 35, 38,
41, 45, 47, 50, 53, 55, 58, 60, 62, 63, 65, 67, 69, 70, 72, 73, 75, 76, 77, 78,
79, 79, 80, 80, 81, 82, 82, 83, 82, 83, 84, 84, 84, 85, 84, 85, 85, 85, 84, 85,
84, 84, 84, 83, 82, 83, 82, 81, 80, 79, 78, 77, 75, 74, 73, 70, 69, 67, 65, 64,
62, 59, 56, 54, 52, 50, 48, 44, 42, 40, 37, 35, 33, 30, 27, 26, 23, 21, 19, 18,
16, 14, 13, 11, 9, 8, 7, 7, 6, 5, 4, 4, 4, 2, 2, 2, 2, 1, 1, 1, 2, 2, 2, 2, 2,
3, 2, 2, 2, 3, 4, 3, 2, 4, 3, 3, 4, 4, 4, 3, 3, 3, 3, 3, 2, 2, 2, 1, 1, 1, 1, 1,
0, 0, 0, -1, -1, -2, -2, -2, -2, -2, -2, -3, -3, -3, -3, -3, -2, -2, -3, -2, -3,
-2, -2, -2, -1, 0, 0, 0, 0, 0, 0, 1, 2, 1, 1, 2, 1, 3, 1, 2, 2, 2, 2, 1, 1, 1,
0, 0, -1, -1, -2, -2, -3, -4, -3, -5, -5, -6, -6, -7, -7, -8, -8, -8, -9, -10,
-10, -10, -9, -10, -9, -10, -9, -9, -8, -8, -7, -7, -6, -5, -3, -3, -1, 0, 0, 2,
3, 6, 6, 9, 10, 12, 13, 15, 17, 19, 21, 22, 25, 26, 29, 30, 32, 33, 36, 37, 38,
40, 41, 42, 43, 44, 45, 46, 46, 47, 48, 47, 47, 47, 46, 45, 45, 45, 44, 42, 41,
40, 39, 36, 35, 33, 31, 29, 26, 24, 22, 20, 17, 15, 13, 9, 7, 3, 1, -2, -5, -7,
-10, -14, -17, -20, -23, -27, -29, -33, -36, -39, -43, -45, -49, -51, -54, -58,
-62, -64, -66, -70, -72, -75, -77, -79, -82, -85, -86, -87, -89, -91, -92, -93,
-93, -95, -94, -96, -96, -95, -95, -95, -93, -93, -92, -90, -89, -87, -85, -83,
-79, -78, -75, -72, -69, -65, -63, -59, -55, -52, -49, -44, -41, -36, -32, -28,
-23, -19, -15, -11, -6, -2, };