#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 8, 11, 14, 16, 20, 21, 24,
28, 30, 33, 36, 38, 42, 44, 47, 50, 53, 55, 58, 61, 64, 66, 69, 72, 74, 77, 79,
82, 84, 87, 88, 90, 92, 95, 97, 99, 101, 103, 104, 106, 108, 109, 110, 112, 112,
114, 115, 116, 117, 118, 118, 118, 119, 119, 119, 119, 119, 119, 118, 118, 116,
116, 115, 115, 113, 112, 110, 108, 106, 105, 102, 100, 98, 96, 93, 91, 87, 85,
81, 79, 76, 71, 68, 64, 61, 57, 53, 49, 45, 42, 38, 34, 30, 26, 22, 18, 14, 10,
7, 2, -1, -5, -9, -13, -16, -20, -23, -26, -30, -33, -36, -39, -41, -44, -48,
-50, -52, -55, -57, -59, -61, -62, -64, -66, -67, -69, -70, -71, -72, -72, -73,
-74, -75, -74, -75, -75, -74, -74, -74, -74, -74, -73, -72, -71, -69, -69, -68,
-67, -65, -64, -63, -61, -59, -58, -56, -53, -53, -50, -48, -46, -43, -41, -39,
-38, -35, -32, -29, -27, -24, -22, -19, -16, -14, -11, -9, -6, -4, -1, 2, 5, 8,
10, 13, 14, 17, 20, 23, 25, 27, 30, 31, 34, 36, 38, 40, 42, 44, 46, 47, 49, 50,
51, 53, 54, 55, 56, 56, 57, 57, 59, 59, 60, 59, 60, 60, 60, 60, 59, 58, 59, 59,
58, 57, 57, 55, 54, 53, 53, 51, 50, 48, 48, 46, 44, 43, 42, 39, 38, 36, 34, 33,
31, 29, 27, 25, 23, 21, 21, 18, 15, 14, 12, 10, 8, 6, 4, 2, 0, -2, -4, -5, -8,
-10, -12, -14, -15, -18, -19, -21, -23, -24, -26, -29, -31, -32, -34, -35, -38,
-38, -40, -42, -43, -45, -47, -48, -50, -52, -53, -54, -55, -56, -57, -59, -60,
-61, -61, -63, -64, -64, -66, -66, -67, -67, -68, -68, -68, -70, -69, -69, -69,
-70, -70, -70, -70, -70, -70, -70, -69, -69, -70, -69, -69, -68, -68, -68, -68,
-67, -66, -66, -65, -64, -63, -63, -63, -62, -62, -61, -60, -59, -59, -59, -58,
-57, -57, -56, -55, -54, -53, -53, -52, -50, -50, -50, -49, -47, -46, -45, -44,
-43, -43, -42, -40, -39, -38, -37, -35, -34, -33, -32, -32, -29, -28, -27, -25,
-24, -22, -21, -19, -18, -16, -15, -13, -12, -11, -9, -8, -6, -4, -3, -1, 0, 1,
3, 4, 5, 7, 8, 9, 10, 11, 12, 13, 14, 15, 15, 16, 16, 16, 17, 17, 18, 19, 19,
18, 18, 18, 18, 19, 18, 18, 17, 17, 16, 16, 15, 14, 14, 13, 13, 12, 11, 10, 10,
9, 7, 6, 6, 5, 4, 2, 1, 0, -1, -2, -4, -4, -6, -7, -8, -9, -11, -11, -12, -14,
-16, -17, -17, -19, -20, -21, -21, -23, -25, -26, -26, -27, -28, -29, -30, -32,
-32, -33, -33, -34, -34, -35, -34, -36, -36, -36, -36, -37, -36, -35, -35, -36,
-35, -33, -34, -32, -32, -31, -30, -29, -28, -26, -25, -23, -22, -20, -18, -16,
-14, -13, -11, -8, -5, -4, -1, };