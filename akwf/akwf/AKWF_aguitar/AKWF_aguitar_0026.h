#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0026

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 9, 12, 15, 18, 20, 23, 27,
28, 32, 35, 38, 40, 43, 45, 47, 51, 53, 55, 58, 61, 63, 65, 67, 69, 72, 73, 76,
78, 79, 81, 84, 86, 88, 89, 92, 93, 94, 96, 97, 99, 100, 102, 104, 105, 106,
107, 109, 110, 112, 112, 113, 114, 115, 115, 116, 117, 117, 118, 118, 119, 120,
119, 119, 119, 119, 119, 118, 118, 118, 116, 115, 115, 113, 113, 111, 110, 109,
108, 106, 105, 104, 102, 100, 98, 96, 94, 92, 90, 89, 87, 84, 83, 81, 78, 76,
74, 72, 70, 67, 66, 63, 60, 58, 57, 54, 52, 50, 47, 45, 43, 42, 39, 37, 35, 33,
31, 29, 26, 25, 23, 22, 20, 18, 16, 14, 12, 11, 8, 7, 4, 3, 1, 0, -4, -5, -6,
-9, -11, -13, -14, -17, -19, -21, -22, -23, -26, -28, -30, -31, -33, -34, -36,
-37, -39, -40, -42, -43, -45, -45, -46, -47, -48, -49, -50, -50, -51, -52, -52,
-52, -52, -53, -54, -53, -54, -54, -54, -54, -53, -53, -53, -52, -53, -53, -53,
-51, -50, -50, -50, -50, -49, -48, -49, -47, -47, -47, -45, -46, -45, -44, -44,
-44, -43, -43, -42, -42, -41, -41, -41, -41, -41, -41, -41, -41, -41, -41, -42,
-41, -42, -41, -41, -42, -42, -41, -42, -43, -43, -43, -43, -44, -44, -44, -44,
-43, -44, -44, -45, -45, -45, -45, -45, -44, -45, -45, -45, -45, -45, -45, -44,
-45, -44, -44, -44, -44, -43, -43, -42, -42, -42, -41, -41, -40, -40, -38, -38,
-37, -36, -35, -34, -33, -32, -32, -31, -31, -29, -29, -27, -27, -25, -25, -24,
-23, -22, -21, -21, -20, -18, -17, -17, -15, -15, -14, -14, -13, -11, -10, -10,
-9, -8, -7, -5, -4, -4, -2, -1, -1, 0, 2, 3, 4, 5, 5, 6, 7, 9, 10, 10, 12, 12,
13, 14, 15, 15, 16, 16, 17, 17, 17, 18, 17, 17, 18, 18, 17, 17, 18, 17, 17, 17,
16, 15, 15, 14, 13, 13, 13, 12, 11, 10, 10, 9, 7, 8, 6, 5, 4, 4, 3, 2, 1, 1, -1,
-2, -2, -3, -4, -4, -5, -5, -7, -7, -8, -9, -9, -10, -10, -11, -12, -12, -13,
-13, -13, -13, -14, -14, -15, -14, -15, -16, -16, -16, -15, -16, -16, -16, -17,
-17, -17, -18, -18, -18, -18, -18, -20, -21, -21, -21, -22, -23, -24, -24, -26,
-26, -27, -28, -29, -29, -31, -32, -32, -34, -34, -35, -36, -36, -37, -38, -38,
-37, -39, -38, -39, -39, -38, -38, -38, -38, -38, -38, -38, -37, -37, -37, -36,
-36, -36, -36, -35, -35, -34, -34, -34, -33, -34, -35, -34, -34, -34, -34, -35,
-35, -35, -35, -36, -36, -36, -37, -37, -37, -37, -39, -38, -38, -40, -38, -39,
-39, -39, -39, -40, -39, -39, -39, -38, -38, -38, -38, -38, -37, -36, -35, -35,
-34, -32, -31, -30, -28, -27, -26, -24, -23, -20, -17, -15, -13, -11, -9, -7,
-4, -1, };