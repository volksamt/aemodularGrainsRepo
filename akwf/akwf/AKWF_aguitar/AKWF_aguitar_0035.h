#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0035

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 7, 10, 12, 14, 18, 21, 24, 26,
29, 32, 35, 37, 40, 43, 46, 48, 52, 54, 56, 59, 61, 64, 67, 70, 73, 75, 78, 80,
83, 86, 88, 90, 92, 95, 98, 101, 102, 104, 106, 107, 110, 111, 113, 114, 115,
116, 117, 117, 118, 118, 119, 119, 119, 119, 119, 118, 118, 118, 117, 117, 117,
116, 115, 114, 114, 113, 113, 112, 111, 111, 110, 110, 110, 109, 108, 108, 108,
107, 107, 106, 106, 106, 105, 105, 105, 105, 105, 104, 103, 102, 101, 101, 100,
99, 97, 96, 95, 94, 92, 89, 89, 86, 84, 82, 81, 77, 75, 73, 70, 68, 64, 63, 59,
58, 56, 53, 51, 48, 46, 43, 41, 39, 37, 35, 34, 32, 30, 29, 28, 26, 25, 25, 23,
23, 22, 21, 21, 20, 20, 18, 18, 18, 18, 17, 18, 17, 16, 15, 14, 13, 12, 11, 10,
9, 8, 7, 5, 4, 2, 1, -2, -4, -6, -8, -10, -12, -14, -16, -20, -21, -23, -26,
-28, -30, -31, -34, -36, -37, -39, -41, -41, -43, -44, -45, -46, -46, -47, -47,
-46, -47, -47, -47, -46, -46, -46, -45, -45, -43, -42, -41, -40, -39, -39, -38,
-37, -35, -34, -34, -32, -32, -30, -30, -29, -28, -27, -27, -27, -26, -25, -25,
-24, -25, -25, -24, -23, -24, -23, -23, -22, -22, -23, -23, -21, -22, -23, -22,
-22, -21, -22, -21, -21, -21, -21, -20, -21, -20, -20, -21, -19, -20, -20, -20,
-20, -21, -20, -21, -21, -21, -21, -21, -22, -22, -24, -24, -25, -25, -27, -27,
-29, -31, -32, -34, -35, -36, -38, -39, -41, -44, -46, -48, -51, -53, -56, -58,
-61, -64, -66, -69, -71, -74, -77, -79, -81, -84, -87, -89, -91, -94, -96, -99,
-100, -102, -103, -105, -107, -107, -110, -110, -112, -111, -112, -112, -114,
-113, -113, -113, -113, -112, -111, -111, -109, -109, -108, -107, -104, -103,
-102, -99, -98, -95, -93, -91, -88, -86, -83, -80, -78, -75, -72, -69, -66, -63,
-60, -56, -52, -49, -46, -42, -38, -34, -32, -27, -24, -20, -17, -12, -8, -5,
-1, 3, 6, 9, 13, 16, 21, 25, 27, 31, 33, 36, 39, 43, 46, 48, 51, 54, 56, 59, 60,
62, 65, 66, 67, 70, 71, 72, 73, 74, 75, 75, 75, 76, 76, 75, 76, 76, 74, 75, 73,
73, 71, 71, 69, 67, 65, 63, 61, 59, 57, 55, 52, 48, 46, 43, 40, 36, 34, 30, 27,
24, 21, 17, 14, 10, 7, 3, -1, -4, -7, -12, -15, -18, -22, -25, -28, -32, -34,
-38, -40, -44, -46, -49, -51, -55, -57, -60, -62, -64, -67, -67, -70, -72, -73,
-76, -77, -78, -80, -80, -82, -82, -83, -85, -85, -86, -86, -87, -87, -86, -87,
-86, -87, -86, -85, -85, -85, -84, -82, -81, -80, -79, -77, -76, -74, -73, -70,
-69, -66, -65, -63, -61, -58, -56, -52, -51, -47, -44, -42, -38, -36, -32, -30,
-27, -24, -20, -18, -14, -12, -8, -5, -2, };