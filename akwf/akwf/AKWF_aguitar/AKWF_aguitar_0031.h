#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0031

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, -4, -6, -9, -10, -14, -16, -17,
-19, -21, -23, -24, -26, -27, -30, -32, -32, -33, -34, -36, -36, -38, -38, -39,
-39, -39, -40, -40, -41, -41, -40, -41, -40, -40, -40, -40, -39, -38, -38, -37,
-36, -36, -35, -35, -33, -33, -32, -31, -30, -29, -29, -27, -26, -27, -25, -25,
-24, -23, -23, -21, -21, -21, -21, -21, -19, -19, -19, -19, -19, -18, -19, -19,
-19, -19, -20, -20, -20, -20, -21, -21, -23, -23, -24, -25, -25, -27, -28, -29,
-30, -31, -33, -35, -35, -37, -38, -40, -43, -43, -44, -46, -48, -49, -51, -52,
-54, -55, -57, -59, -60, -61, -63, -64, -65, -66, -67, -68, -70, -70, -71, -71,
-73, -73, -73, -74, -76, -75, -76, -76, -75, -76, -77, -76, -76, -77, -77, -76,
-77, -76, -76, -75, -75, -75, -74, -73, -73, -72, -72, -72, -70, -69, -68, -68,
-67, -67, -65, -64, -63, -63, -62, -62, -60, -59, -59, -58, -58, -56, -56, -55,
-55, -54, -54, -53, -53, -52, -52, -51, -51, -50, -50, -49, -49, -49, -48, -48,
-49, -49, -49, -50, -49, -49, -50, -50, -50, -50, -52, -51, -52, -53, -53, -54,
-55, -56, -56, -57, -58, -58, -59, -60, -61, -62, -64, -65, -66, -67, -69, -69,
-71, -72, -73, -75, -76, -76, -78, -79, -80, -80, -82, -81, -83, -83, -84, -84,
-85, -85, -86, -86, -86, -86, -86, -86, -86, -85, -85, -84, -84, -83, -82, -81,
-80, -79, -77, -76, -75, -74, -72, -70, -69, -66, -64, -62, -60, -58, -55, -53,
-51, -48, -46, -43, -40, -38, -35, -31, -29, -26, -22, -20, -16, -13, -11, -7,
-4, -2, 2, 6, 8, 11, 14, 16, 20, 23, 26, 29, 32, 35, 38, 41, 43, 46, 48, 52, 54,
56, 59, 61, 63, 66, 68, 70, 72, 74, 77, 77, 79, 81, 83, 84, 86, 86, 88, 88, 90,
91, 91, 91, 92, 92, 93, 93, 92, 93, 91, 92, 92, 91, 90, 90, 89, 88, 86, 85, 84,
83, 82, 81, 80, 78, 76, 74, 72, 71, 69, 68, 66, 64, 62, 59, 58, 56, 54, 53, 50,
49, 47, 45, 43, 42, 39, 37, 35, 34, 32, 30, 29, 27, 26, 25, 24, 22, 21, 20, 19,
18, 17, 17, 15, 15, 16, 14, 15, 14, 15, 15, 14, 15, 15, 15, 16, 17, 17, 18, 18,
21, 20, 22, 23, 24, 25, 27, 29, 30, 32, 34, 34, 38, 38, 41, 43, 44, 47, 49, 52,
53, 56, 58, 60, 63, 66, 68, 70, 73, 74, 78, 80, 82, 85, 87, 90, 91, 93, 96, 97,
100, 101, 104, 106, 106, 109, 111, 112, 113, 114, 115, 115, 116, 117, 118, 118,
119, 119, 118, 119, 120, 118, 118, 117, 117, 116, 115, 114, 113, 111, 110, 109,
107, 105, 103, 101, 99, 97, 94, 92, 89, 87, 85, 82, 79, 77, 73, 70, 68, 64, 61,
58, 54, 52, 48, 46, 41, 40, 36, 33, 29, 27, 23, 20, 17, 14, 12, 9, 6, 3, 1, };