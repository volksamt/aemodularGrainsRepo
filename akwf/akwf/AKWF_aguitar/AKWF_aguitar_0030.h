#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 10, 13, 15, 17, 21, 23, 25,
27, 30, 31, 33, 35, 36, 38, 40, 41, 43, 43, 44, 44, 45, 46, 47, 48, 48, 48, 49,
49, 49, 49, 51, 50, 50, 51, 50, 51, 50, 50, 50, 50, 50, 49, 50, 49, 49, 49, 48,
49, 48, 48, 48, 48, 48, 48, 49, 49, 49, 50, 50, 51, 52, 52, 54, 54, 57, 58, 58,
61, 62, 63, 66, 67, 70, 71, 74, 76, 78, 79, 82, 83, 85, 87, 89, 91, 92, 93, 96,
97, 98, 99, 99, 100, 101, 102, 102, 102, 102, 102, 101, 100, 100, 99, 98, 97,
95, 94, 93, 91, 89, 87, 86, 84, 82, 79, 78, 76, 74, 72, 70, 69, 67, 64, 63, 61,
60, 58, 57, 56, 54, 53, 51, 51, 49, 49, 47, 47, 45, 44, 43, 42, 42, 41, 41, 39,
39, 38, 37, 37, 35, 35, 34, 33, 32, 32, 30, 30, 29, 28, 28, 28, 26, 25, 24, 24,
22, 22, 21, 21, 20, 20, 18, 18, 17, 16, 16, 15, 14, 12, 12, 11, 10, 10, 9, 7, 7,
6, 4, 3, 3, 1, 0, -1, -3, -4, -6, -6, -8, -10, -11, -12, -13, -15, -17, -19,
-20, -21, -22, -24, -26, -27, -28, -30, -31, -33, -34, -35, -35, -37, -38, -38,
-39, -40, -40, -40, -40, -40, -41, -41, -41, -40, -40, -39, -39, -39, -38, -36,
-36, -35, -35, -34, -33, -32, -32, -31, -29, -29, -27, -27, -25, -25, -24, -24,
-21, -20, -20, -19, -18, -16, -16, -15, -12, -11, -10, -9, -8, -6, -5, -3, -2,
0, 2, 4, 6, 7, 9, 12, 13, 15, 17, 19, 21, 23, 25, 26, 27, 29, 30, 32, 32, 35,
36, 37, 38, 39, 39, 41, 41, 42, 43, 43, 43, 44, 44, 46, 45, 45, 46, 46, 46, 46,
46, 46, 46, 45, 45, 45, 45, 44, 45, 45, 45, 46, 45, 45, 45, 45, 45, 45, 44, 45,
45, 44, 45, 45, 45, 44, 45, 44, 44, 44, 43, 43, 43, 43, 42, 41, 40, 40, 38, 38,
36, 35, 34, 33, 31, 29, 26, 24, 23, 20, 18, 15, 12, 10, 7, 4, 0, -2, -6, -9,
-13, -17, -20, -24, -27, -31, -35, -38, -42, -45, -49, -51, -55, -57, -61, -64,
-66, -69, -71, -73, -76, -78, -80, -81, -83, -85, -86, -87, -88, -90, -90, -92,
-93, -93, -95, -95, -95, -95, -96, -97, -98, -97, -98, -99, -99, -100, -100,
-101, -102, -102, -103, -104, -104, -105, -106, -107, -107, -108, -109, -110,
-112, -111, -112, -113, -115, -115, -116, -116, -116, -117, -118, -118, -119,
-119, -119, -119, -119, -119, -118, -117, -119, -117, -116, -116, -115, -114,
-114, -112, -111, -110, -108, -107, -106, -104, -103, -101, -99, -98, -96, -94,
-93, -91, -89, -86, -85, -83, -81, -79, -76, -74, -72, -69, -67, -65, -62, -61,
-58, -56, -53, -51, -48, -46, -43, -40, -38, -35, -32, -30, -28, -25, -23, -20,
-17, -14, -11, -8, -6, -3, 0, };