#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0033

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 8, 12, 16, 19, 23, 27, 30, 35,
38, 42, 45, 49, 53, 56, 59, 62, 66, 69, 71, 74, 77, 80, 83, 85, 86, 88, 91, 92,
95, 96, 97, 99, 99, 100, 101, 101, 101, 102, 100, 101, 101, 99, 99, 98, 97, 95,
94, 92, 89, 88, 86, 82, 80, 77, 74, 71, 68, 64, 61, 57, 53, 49, 45, 41, 37, 32,
28, 24, 19, 15, 10, 4, 0, -5, -9, -15, -20, -24, -28, -33, -37, -42, -45, -50,
-55, -58, -63, -66, -70, -73, -76, -80, -84, -85, -89, -92, -94, -96, -99, -102,
-103, -105, -107, -109, -111, -112, -113, -114, -115, -116, -116, -117, -118,
-118, -119, -118, -120, -119, -119, -119, -118, -118, -118, -118, -117, -115,
-115, -114, -112, -112, -110, -108, -107, -105, -103, -101, -100, -97, -95, -92,
-89, -86, -83, -79, -77, -74, -71, -67, -64, -59, -57, -52, -48, -44, -41, -37,
-33, -28, -25, -20, -16, -12, -8, -5, -1, 3, 7, 10, 13, 17, 21, 24, 26, 30, 32,
35, 38, 40, 42, 44, 47, 48, 51, 54, 55, 57, 58, 60, 62, 63, 66, 66, 68, 69, 70,
72, 73, 75, 76, 78, 78, 80, 81, 81, 83, 84, 86, 86, 87, 88, 89, 90, 90, 91, 91,
92, 93, 93, 93, 93, 93, 93, 92, 91, 93, 91, 90, 89, 88, 87, 85, 84, 84, 82, 78,
77, 75, 73, 70, 67, 65, 63, 61, 58, 55, 51, 50, 46, 43, 41, 38, 35, 33, 30, 27,
25, 22, 20, 16, 15, 12, 10, 7, 6, 4, 1, 0, -3, -4, -6, -7, -9, -10, -12, -13,
-15, -15, -17, -17, -18, -19, -21, -23, -23, -24, -25, -25, -27, -28, -28, -30,
-31, -32, -32, -33, -35, -35, -35, -36, -38, -38, -40, -41, -41, -42, -43, -43,
-44, -45, -45, -46, -47, -47, -47, -46, -48, -47, -49, -48, -49, -48, -48, -47,
-47, -47, -47, -45, -46, -45, -45, -44, -43, -42, -40, -40, -39, -37, -37, -35,
-34, -33, -31, -31, -28, -27, -25, -24, -23, -21, -20, -18, -16, -15, -14, -13,
-12, -9, -8, -7, -5, -4, -2, -1, 0, 2, 3, 6, 8, 8, 9, 12, 13, 14, 16, 17, 19,
21, 22, 24, 25, 27, 28, 29, 31, 32, 35, 36, 37, 39, 40, 42, 43, 44, 46, 47, 47,
49, 50, 51, 51, 53, 54, 53, 55, 55, 55, 55, 55, 56, 55, 56, 54, 55, 54, 53, 52,
51, 50, 49, 48, 46, 45, 44, 42, 40, 38, 36, 34, 31, 29, 27, 24, 21, 19, 17, 14,
11, 8, 5, 3, 0, -4, -7, -9, -12, -15, -19, -21, -24, -27, -30, -33, -36, -37,
-40, -44, -45, -48, -50, -52, -54, -57, -59, -61, -62, -63, -65, -66, -66, -68,
-69, -71, -70, -72, -72, -72, -72, -71, -72, -71, -71, -70, -69, -69, -68, -66,
-66, -64, -62, -59, -58, -56, -54, -52, -50, -47, -45, -42, -39, -36, -33, -30,
-27, -24, -20, -17, -13, -9, -6, -2, };