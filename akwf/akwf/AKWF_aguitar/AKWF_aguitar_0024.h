#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 6, 8, 10, 12, 14, 16, 19, 21,
23, 25, 28, 30, 32, 36, 38, 41, 42, 45, 49, 50, 52, 55, 59, 61, 63, 65, 67, 70,
71, 73, 76, 77, 80, 81, 83, 86, 87, 88, 90, 92, 93, 95, 97, 98, 100, 101, 102,
103, 104, 106, 107, 108, 109, 110, 112, 112, 113, 115, 115, 115, 116, 116, 117,
118, 118, 118, 119, 118, 119, 120, 119, 119, 118, 119, 118, 118, 117, 117, 116,
116, 116, 114, 114, 113, 113, 111, 111, 109, 108, 106, 106, 104, 103, 101, 99,
98, 96, 95, 92, 92, 89, 87, 85, 83, 80, 78, 76, 73, 71, 68, 66, 63, 61, 59, 55,
54, 52, 49, 47, 44, 42, 40, 37, 34, 33, 31, 28, 26, 25, 23, 21, 19, 17, 15, 14,
13, 11, 9, 7, 5, 4, 3, 1, 0, -1, -2, -4, -6, -6, -8, -10, -11, -12, -13, -16,
-17, -18, -20, -22, -23, -24, -25, -27, -29, -31, -31, -33, -34, -35, -37, -37,
-39, -40, -41, -43, -44, -44, -46, -46, -48, -49, -50, -51, -51, -52, -53, -54,
-54, -56, -55, -57, -58, -58, -58, -58, -59, -60, -60, -61, -60, -60, -61, -60,
-62, -61, -61, -61, -61, -61, -61, -61, -61, -61, -60, -61, -61, -59, -60, -60,
-58, -59, -58, -58, -58, -58, -58, -57, -57, -57, -57, -57, -57, -57, -57, -57,
-57, -56, -56, -57, -56, -56, -56, -56, -55, -55, -55, -55, -55, -54, -55, -55,
-54, -54, -52, -53, -52, -52, -51, -51, -50, -50, -49, -48, -47, -47, -46, -45,
-44, -43, -43, -42, -42, -41, -40, -39, -38, -38, -38, -36, -36, -35, -34, -33,
-33, -32, -32, -31, -29, -29, -28, -27, -26, -25, -24, -23, -22, -20, -19, -19,
-17, -17, -14, -13, -13, -11, -10, -9, -7, -6, -6, -5, -4, -4, -2, -2, 0, 0, 0,
1, 2, 1, 2, 3, 3, 4, 4, 4, 5, 6, 6, 7, 7, 8, 7, 8, 9, 9, 9, 9, 10, 10, 10, 11,
11, 11, 11, 12, 11, 11, 12, 11, 11, 12, 11, 10, 10, 10, 10, 9, 8, 7, 6, 6, 5, 3,
3, 2, 1, -1, -1, -3, -4, -5, -6, -7, -8, -9, -9, -10, -11, -12, -13, -13, -14,
-15, -14, -15, -16, -16, -16, -15, -16, -17, -17, -17, -18, -17, -17, -18, -19,
-19, -20, -19, -19, -20, -20, -21, -21, -22, -22, -23, -24, -25, -26, -26, -26,
-28, -28, -28, -29, -30, -30, -31, -31, -32, -33, -34, -34, -35, -35, -37, -37,
-36, -37, -38, -39, -41, -40, -41, -42, -43, -43, -43, -45, -45, -46, -46, -47,
-47, -47, -48, -48, -48, -49, -48, -49, -49, -49, -49, -49, -49, -48, -47, -47,
-47, -46, -45, -45, -44, -43, -41, -41, -40, -39, -38, -37, -36, -34, -33, -32,
-31, -30, -29, -27, -27, -25, -24, -23, -22, -21, -21, -19, -18, -17, -17, -16,
-15, -14, -13, -12, -11, -9, -9, -7, -6, -5, -4, -2, -1, };