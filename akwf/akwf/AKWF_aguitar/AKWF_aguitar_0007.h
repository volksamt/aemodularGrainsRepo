#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 9, 11, 14, 17, 19, 23, 25,
28, 31, 34, 36, 38, 42, 43, 47, 49, 52, 55, 57, 60, 62, 65, 67, 70, 72, 75, 78,
80, 82, 85, 86, 90, 91, 94, 95, 98, 99, 102, 103, 106, 107, 109, 110, 112, 112,
114, 116, 115, 116, 117, 118, 119, 119, 119, 119, 119, 119, 119, 118, 118, 117,
118, 117, 117, 116, 116, 114, 113, 113, 112, 112, 111, 110, 109, 108, 106, 106,
103, 102, 102, 100, 99, 98, 98, 95, 95, 93, 92, 91, 90, 88, 87, 85, 83, 82, 80,
78, 77, 75, 74, 72, 70, 68, 66, 65, 63, 61, 58, 57, 55, 53, 52, 50, 48, 47, 45,
43, 41, 41, 39, 38, 36, 35, 35, 33, 32, 31, 30, 30, 28, 28, 26, 25, 25, 25, 23,
22, 21, 20, 19, 18, 17, 17, 15, 14, 13, 12, 11, 10, 9, 9, 7, 7, 5, 6, 5, 4, 4,
3, 2, 3, 3, 2, 2, 3, 3, 2, 3, 3, 5, 5, 5, 6, 6, 7, 7, 8, 9, 9, 11, 10, 10, 11,
12, 12, 13, 13, 14, 15, 15, 15, 16, 15, 17, 16, 17, 18, 17, 17, 18, 17, 17, 17,
17, 17, 16, 17, 17, 16, 16, 16, 15, 15, 14, 14, 14, 14, 13, 13, 12, 12, 11, 11,
11, 11, 10, 10, 8, 9, 7, 8, 7, 6, 5, 4, 3, 2, 1, 2, -1, -1, -3, -4, -5, -5, -7,
-8, -10, -10, -11, -13, -14, -15, -17, -18, -18, -20, -22, -22, -22, -24, -26,
-26, -28, -28, -29, -31, -31, -33, -33, -35, -36, -37, -38, -39, -40, -42, -42,
-43, -44, -44, -45, -46, -47, -48, -49, -50, -50, -52, -52, -54, -53, -54, -56,
-55, -56, -57, -57, -58, -59, -59, -60, -61, -62, -62, -62, -63, -62, -62, -63,
-63, -63, -63, -62, -63, -63, -62, -62, -62, -61, -61, -60, -58, -58, -56, -56,
-56, -54, -53, -53, -52, -50, -49, -47, -47, -46, -44, -43, -43, -42, -41, -40,
-39, -39, -38, -37, -37, -36, -36, -36, -35, -35, -34, -34, -34, -35, -34, -33,
-34, -34, -33, -33, -33, -33, -32, -32, -32, -32, -31, -31, -30, -30, -30, -29,
-29, -28, -28, -28, -27, -28, -27, -26, -27, -27, -26, -25, -25, -25, -26, -25,
-26, -26, -27, -27, -27, -27, -28, -29, -29, -30, -31, -31, -32, -32, -33, -34,
-35, -36, -36, -37, -38, -38, -40, -41, -42, -43, -44, -44, -46, -47, -47, -48,
-50, -50, -51, -52, -53, -54, -54, -55, -56, -57, -57, -59, -59, -60, -61, -62,
-62, -63, -64, -64, -66, -65, -66, -66, -67, -67, -69, -68, -69, -69, -70, -69,
-69, -70, -70, -70, -70, -69, -69, -69, -68, -68, -67, -66, -65, -66, -64, -63,
-62, -62, -61, -60, -58, -57, -55, -54, -53, -52, -51, -49, -47, -47, -45, -44,
-42, -41, -40, -38, -37, -36, -35, -33, -31, -29, -27, -26, -23, -22, -19, -17,
-15, -13, -10, -8, -6, -3, -1, };