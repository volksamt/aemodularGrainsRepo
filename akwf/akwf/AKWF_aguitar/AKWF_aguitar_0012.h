#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 11, 14, 18, 23, 27, 32, 36, 40,
45, 48, 52, 56, 59, 62, 65, 68, 72, 74, 78, 80, 83, 86, 87, 90, 91, 94, 96, 98,
100, 101, 104, 104, 106, 108, 109, 111, 112, 113, 114, 115, 115, 117, 117, 117,
118, 118, 119, 119, 119, 118, 118, 118, 117, 115, 113, 113, 111, 109, 107, 104,
103, 99, 97, 93, 90, 86, 82, 79, 75, 71, 68, 64, 59, 54, 50, 47, 44, 38, 34, 31,
26, 23, 19, 15, 11, 8, 4, 1, -2, -6, -9, -12, -15, -18, -20, -23, -25, -29, -30,
-33, -35, -38, -39, -42, -43, -46, -48, -51, -52, -54, -56, -58, -60, -62, -63,
-65, -67, -68, -70, -72, -73, -74, -75, -76, -77, -78, -79, -80, -80, -80, -80,
-82, -82, -83, -83, -84, -85, -85, -86, -87, -87, -88, -89, -91, -90, -93, -94,
-94, -95, -96, -97, -97, -99, -99, -100, -99, -100, -100, -100, -100, -101,
-100, -100, -99, -100, -99, -99, -98, -98, -98, -98, -96, -97, -95, -95, -94,
-94, -93, -92, -91, -90, -89, -87, -87, -86, -85, -83, -81, -80, -79, -77, -75,
-73, -73, -72, -70, -68, -67, -66, -63, -62, -60, -58, -57, -55, -53, -50, -49,
-46, -44, -42, -39, -36, -33, -31, -27, -24, -21, -18, -15, -11, -9, -6, -3, 0,
1, 5, 7, 9, 12, 14, 16, 19, 21, 23, 26, 28, 31, 33, 35, 38, 42, 45, 49, 51, 54,
57, 61, 65, 68, 71, 74, 77, 80, 82, 85, 86, 90, 91, 93, 93, 95, 95, 96, 97, 97,
98, 98, 97, 97, 97, 97, 97, 96, 96, 96, 95, 94, 94, 93, 92, 92, 91, 89, 89, 88,
87, 86, 85, 83, 82, 81, 79, 79, 77, 76, 75, 72, 70, 69, 67, 66, 65, 63, 61, 58,
57, 55, 53, 51, 49, 47, 45, 42, 39, 36, 34, 31, 29, 25, 22, 19, 17, 14, 11, 9,
6, 3, 0, -1, -4, -7, -8, -10, -13, -15, -16, -19, -19, -22, -22, -24, -25, -27,
-27, -29, -29, -30, -30, -31, -32, -31, -32, -31, -32, -32, -31, -31, -28, -29,
-27, -26, -24, -23, -22, -20, -18, -16, -14, -13, -10, -9, -7, -7, -6, -5, -4,
-2, -2, -2, -1, -1, -2, -2, -2, -3, -3, -4, -5, -5, -5, -6, -7, -8, -9, -8, -8,
-8, -8, -7, -8, -6, -6, -4, -3, -1, 0, 0, 3, 5, 7, 8, 9, 10, 12, 13, 15, 16, 16,
16, 16, 16, 16, 16, 15, 14, 11, 11, 8, 7, 3, 2, -2, -4, -6, -9, -12, -15, -18,
-21, -23, -25, -28, -29, -32, -33, -35, -36, -37, -38, -40, -40, -41, -41, -41,
-41, -41, -41, -41, -42, -41, -41, -40, -41, -42, -42, -42, -43, -44, -45, -46,
-47, -48, -49, -50, -51, -53, -54, -55, -56, -57, -59, -59, -59, -60, -60, -61,
-60, -59, -60, -58, -57, -56, -55, -52, -51, -48, -45, -43, -39, -37, -33, -29,
-26, -22, -18, -14, -9, -6, -2, };