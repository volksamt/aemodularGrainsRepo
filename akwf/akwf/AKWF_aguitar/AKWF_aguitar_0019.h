#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 13, 19, 23, 27, 31, 36, 40,
44, 48, 53, 56, 61, 65, 68, 72, 76, 79, 82, 86, 89, 93, 94, 97, 100, 103, 105,
106, 108, 110, 112, 114, 115, 115, 117, 117, 118, 119, 119, 119, 119, 119, 120,
119, 118, 118, 116, 115, 113, 112, 111, 109, 107, 105, 103, 101, 100, 96, 94,
92, 89, 87, 85, 82, 79, 76, 73, 70, 68, 64, 61, 59, 55, 52, 49, 47, 44, 41, 38,
36, 34, 33, 31, 29, 27, 25, 24, 23, 22, 20, 20, 19, 19, 19, 18, 17, 17, 16, 17,
17, 16, 16, 17, 17, 16, 16, 15, 17, 15, 15, 15, 15, 13, 13, 12, 12, 11, 10, 8,
7, 5, 4, 2, 0, -2, -3, -7, -8, -11, -13, -16, -19, -21, -23, -27, -29, -32, -36,
-38, -42, -44, -48, -50, -54, -57, -60, -62, -65, -69, -71, -74, -77, -79, -82,
-83, -86, -89, -90, -92, -94, -96, -97, -99, -101, -101, -102, -103, -104, -104,
-105, -106, -106, -105, -105, -105, -104, -103, -102, -100, -98, -97, -95, -93,
-92, -91, -87, -84, -83, -80, -77, -74, -71, -68, -64, -61, -58, -56, -52, -49,
-44, -41, -38, -35, -32, -29, -26, -23, -20, -17, -15, -12, -10, -7, -6, -3, -1,
0, 2, 3, 5, 5, 8, 8, 9, 10, 10, 11, 11, 12, 12, 13, 12, 13, 13, 12, 13, 13, 13,
14, 14, 14, 14, 14, 14, 14, 15, 15, 16, 16, 17, 18, 19, 20, 21, 22, 23, 25, 27,
28, 30, 31, 33, 35, 36, 38, 40, 43, 45, 46, 49, 50, 52, 55, 57, 59, 60, 62, 64,
66, 67, 68, 69, 71, 72, 73, 74, 74, 75, 75, 76, 76, 76, 76, 75, 75, 74, 74, 73,
72, 72, 70, 69, 68, 66, 65, 64, 62, 61, 59, 56, 55, 53, 52, 50, 48, 47, 45, 44,
43, 41, 39, 38, 37, 35, 34, 33, 31, 30, 30, 29, 28, 27, 26, 25, 23, 22, 22, 21,
20, 19, 17, 16, 14, 13, 12, 11, 9, 7, 6, 4, 3, 1, 0, -2, -4, -6, -9, -10, -12,
-13, -15, -18, -19, -22, -24, -26, -27, -31, -33, -33, -35, -37, -39, -42, -43,
-44, -47, -47, -50, -52, -53, -55, -56, -58, -58, -60, -62, -61, -63, -63, -65,
-66, -66, -66, -68, -68, -68, -69, -69, -68, -68, -69, -68, -67, -66, -66, -65,
-64, -63, -62, -61, -60, -58, -57, -56, -54, -52, -50, -47, -46, -43, -41, -40,
-39, -36, -34, -32, -30, -28, -27, -24, -23, -22, -20, -18, -18, -16, -15, -14,
-13, -14, -13, -13, -13, -13, -14, -14, -15, -16, -17, -18, -19, -21, -22, -24,
-26, -28, -30, -32, -35, -36, -38, -41, -42, -45, -46, -49, -52, -54, -55, -57,
-58, -60, -62, -63, -64, -66, -66, -68, -68, -69, -70, -69, -70, -69, -68, -67,
-67, -66, -64, -63, -61, -60, -57, -56, -54, -51, -48, -45, -41, -38, -35, -31,
-27, -23, -20, -15, -12, -7, -2, };