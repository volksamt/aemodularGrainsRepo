#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0036

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 2, 2, 3, 4, 5, 5, 6, 5, 6, 7,
8, 8, 9, 9, 9, 10, 9, 9, 10, 9, 10, 11, 11, 11, 11, 12, 11, 13, 13, 13, 13, 15,
14, 15, 15, 15, 15, 16, 16, 15, 16, 16, 17, 16, 17, 16, 17, 17, 17, 17, 17, 19,
18, 18, 20, 20, 20, 22, 23, 23, 24, 25, 26, 27, 29, 30, 30, 31, 32, 34, 34, 35,
35, 36, 35, 36, 36, 35, 35, 35, 35, 34, 34, 33, 33, 32, 31, 31, 30, 29, 28, 26,
27, 25, 25, 25, 23, 22, 22, 22, 21, 20, 20, 20, 21, 22, 22, 22, 23, 23, 25, 26,
26, 29, 29, 31, 32, 33, 35, 37, 37, 40, 41, 42, 43, 43, 45, 46, 47, 48, 48, 49,
49, 49, 51, 50, 50, 50, 51, 51, 52, 51, 50, 50, 51, 51, 52, 53, 53, 54, 55, 56,
56, 58, 59, 61, 63, 64, 66, 67, 69, 71, 73, 76, 78, 80, 82, 85, 86, 88, 90, 92,
95, 97, 99, 101, 102, 105, 106, 108, 110, 111, 113, 114, 115, 116, 116, 117,
118, 118, 118, 119, 119, 119, 119, 119, 118, 118, 117, 116, 117, 116, 114, 114,
113, 111, 110, 110, 108, 107, 106, 106, 105, 103, 103, 101, 99, 99, 97, 96, 96,
94, 94, 93, 91, 90, 89, 87, 87, 85, 84, 83, 81, 79, 78, 77, 75, 72, 71, 69, 67,
65, 63, 60, 59, 56, 53, 51, 48, 46, 43, 40, 36, 35, 32, 28, 26, 23, 19, 17, 14,
11, 8, 6, 4, 1, -2, -4, -7, -9, -12, -14, -16, -18, -20, -22, -24, -27, -29,
-30, -32, -35, -37, -38, -40, -42, -44, -45, -48, -49, -51, -52, -54, -55, -58,
-59, -61, -61, -64, -65, -66, -67, -68, -70, -70, -72, -73, -74, -75, -76, -78,
-78, -79, -81, -82, -83, -85, -85, -86, -87, -88, -89, -89, -91, -91, -93, -92,
-94, -94, -95, -95, -96, -97, -96, -96, -97, -97, -97, -97, -97, -97, -97, -97,
-96, -97, -96, -97, -95, -95, -95, -94, -94, -94, -94, -93, -94, -92, -92, -93,
-92, -91, -91, -91, -91, -90, -89, -90, -90, -90, -89, -89, -89, -88, -89, -88,
-88, -87, -86, -87, -87, -86, -85, -85, -85, -84, -83, -83, -83, -82, -82, -81,
-80, -79, -79, -78, -78, -77, -76, -75, -74, -74, -72, -72, -71, -70, -69, -68,
-68, -67, -66, -65, -64, -63, -63, -63, -62, -61, -60, -59, -58, -58, -57, -56,
-55, -55, -54, -54, -52, -51, -51, -50, -49, -47, -46, -46, -45, -44, -43, -42,
-42, -40, -40, -39, -37, -37, -36, -35, -35, -34, -34, -33, -33, -32, -32, -32,
-31, -31, -32, -30, -31, -30, -29, -28, -28, -27, -26, -25, -24, -23, -22, -20,
-19, -18, -16, -15, -13, -11, -11, -9, -8, -7, -6, -5, -4, -3, -3, -2, -2, -1,
-1, -1, -2, -1, -1, -2, -2, -2, -3, -2, -3, -2, -2, -2, -2, -2, -2, -1, -1, -1,
};