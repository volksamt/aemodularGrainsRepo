#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 13, 18, 21, 25, 29, 32, 36,
39, 43, 46, 49, 53, 56, 59, 63, 66, 69, 72, 76, 79, 82, 85, 88, 92, 93, 97, 99,
102, 105, 107, 108, 111, 112, 113, 115, 116, 117, 118, 118, 119, 119, 119, 119,
119, 119, 116, 117, 116, 114, 113, 112, 111, 109, 108, 106, 104, 103, 100, 98,
96, 93, 91, 88, 86, 83, 81, 78, 75, 72, 69, 66, 63, 60, 56, 54, 51, 47, 45, 41,
38, 34, 31, 27, 25, 22, 18, 16, 13, 10, 8, 6, 2, 0, -3, -5, -8, -10, -12, -13,
-16, -17, -20, -22, -23, -24, -26, -27, -29, -30, -32, -34, -34, -35, -36, -38,
-38, -39, -40, -42, -43, -44, -45, -47, -48, -49, -50, -51, -52, -54, -56, -57,
-58, -59, -61, -62, -64, -65, -65, -68, -68, -69, -71, -72, -73, -74, -75, -75,
-76, -77, -77, -79, -79, -80, -81, -82, -83, -84, -85, -86, -86, -87, -89, -89,
-90, -90, -91, -92, -92, -93, -93, -94, -94, -94, -93, -94, -94, -94, -93, -93,
-93, -93, -91, -92, -91, -90, -90, -89, -88, -88, -87, -87, -85, -86, -84, -83,
-83, -82, -82, -81, -80, -78, -77, -76, -75, -74, -72, -71, -70, -68, -66, -64,
-63, -60, -58, -56, -54, -51, -49, -47, -43, -40, -39, -36, -32, -29, -27, -23,
-20, -16, -13, -11, -8, -4, -1, 3, 6, 9, 13, 15, 19, 21, 24, 26, 30, 33, 35, 38,
40, 43, 46, 48, 50, 52, 53, 57, 58, 60, 62, 64, 66, 68, 69, 71, 73, 74, 75, 76,
77, 79, 80, 80, 81, 82, 82, 82, 84, 84, 84, 84, 83, 84, 84, 83, 84, 83, 83, 83,
83, 81, 81, 80, 80, 79, 79, 78, 78, 75, 75, 74, 72, 72, 70, 69, 67, 66, 63, 62,
60, 57, 56, 53, 50, 48, 44, 43, 40, 36, 34, 31, 27, 25, 22, 19, 17, 15, 11, 9,
7, 5, 3, 1, -1, -2, -3, -3, -5, -5, -6, -5, -6, -5, -5, -5, -5, -4, -2, -2, -2,
0, 0, 2, 2, 3, 4, 3, 4, 5, 5, 5, 4, 5, 5, 4, 3, 3, 3, 3, 2, 2, 1, 1, 0, -1, -1,
-1, -1, -1, -1, -1, -1, -1, 0, 1, 2, 3, 5, 6, 7, 8, 10, 11, 13, 14, 15, 17, 17,
19, 19, 21, 21, 21, 22, 22, 22, 22, 21, 21, 19, 19, 17, 17, 14, 12, 11, 9, 6, 5,
3, 1, -1, -3, -5, -8, -10, -11, -14, -15, -18, -19, -20, -22, -23, -25, -28,
-27, -29, -30, -31, -32, -33, -34, -35, -36, -37, -39, -39, -40, -42, -43, -44,
-45, -47, -48, -49, -50, -53, -54, -57, -57, -59, -61, -63, -64, -66, -68, -69,
-71, -72, -74, -74, -76, -77, -78, -79, -79, -79, -79, -79, -80, -79, -77, -76,
-76, -74, -73, -72, -69, -68, -65, -64, -61, -58, -55, -52, -49, -45, -42, -39,
-35, -33, -29, -26, -22, -18, -15, -11, -7, -4, 0, };