#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 12, 16, 20, 24, 28, 31, 35,
39, 42, 47, 50, 53, 56, 60, 64, 67, 70, 73, 76, 78, 81, 84, 86, 88, 91, 93, 95,
97, 99, 101, 103, 105, 106, 107, 108, 110, 111, 112, 112, 114, 114, 115, 116,
116, 117, 118, 118, 118, 118, 119, 119, 119, 120, 119, 119, 118, 118, 118, 116,
115, 116, 115, 113, 112, 112, 110, 108, 107, 106, 104, 102, 101, 99, 97, 96, 95,
92, 91, 90, 87, 86, 83, 82, 80, 78, 78, 75, 74, 73, 71, 69, 68, 67, 65, 63, 63,
61, 59, 59, 56, 55, 54, 52, 51, 50, 48, 46, 45, 45, 42, 41, 39, 38, 36, 34, 32,
31, 29, 28, 26, 25, 22, 21, 20, 18, 17, 15, 13, 11, 10, 10, 8, 6, 5, 4, 2, 3, 2,
1, 0, 1, 1, -1, 0, -1, 0, 0, 1, 0, 1, 1, 1, 2, 4, 4, 5, 6, 7, 7, 8, 8, 10, 11,
11, 13, 13, 14, 16, 17, 17, 18, 19, 20, 21, 23, 23, 25, 25, 28, 27, 29, 30, 32,
32, 33, 35, 36, 37, 37, 38, 39, 40, 42, 43, 43, 43, 44, 45, 46, 46, 46, 47, 48,
48, 48, 49, 49, 49, 50, 49, 49, 49, 49, 49, 49, 49, 48, 48, 47, 46, 46, 45, 44,
44, 43, 42, 42, 40, 40, 39, 38, 37, 36, 35, 35, 33, 33, 31, 31, 30, 29, 28, 27,
26, 25, 24, 22, 22, 20, 19, 18, 17, 16, 15, 14, 12, 12, 10, 9, 8, 6, 5, 3, 3, 1,
-1, -3, -4, -6, -8, -9, -11, -12, -13, -15, -18, -19, -21, -22, -24, -26, -26,
-27, -29, -30, -32, -33, -34, -35, -35, -35, -37, -37, -37, -37, -37, -38, -38,
-38, -38, -38, -38, -38, -37, -37, -37, -36, -37, -35, -35, -35, -34, -34, -34,
-33, -33, -33, -32, -33, -33, -33, -32, -32, -32, -31, -31, -32, -31, -31, -32,
-32, -32, -31, -31, -31, -31, -30, -31, -30, -30, -30, -30, -31, -30, -29, -29,
-30, -29, -29, -29, -28, -28, -28, -28, -28, -28, -28, -28, -28, -28, -27, -29,
-29, -29, -28, -29, -29, -29, -30, -30, -31, -32, -32, -33, -33, -34, -34, -35,
-36, -36, -36, -38, -39, -39, -39, -41, -42, -42, -43, -44, -45, -45, -47, -47,
-48, -49, -51, -51, -53, -54, -56, -57, -58, -59, -60, -62, -64, -65, -67, -68,
-70, -71, -73, -75, -76, -77, -80, -81, -83, -84, -87, -88, -89, -91, -92, -94,
-96, -96, -98, -99, -100, -101, -102, -103, -104, -105, -105, -106, -107, -108,
-108, -109, -109, -110, -110, -111, -110, -111, -112, -112, -112, -111, -111,
-112, -111, -110, -111, -110, -109, -108, -108, -107, -107, -106, -104, -103,
-102, -102, -101, -99, -98, -96, -96, -94, -92, -90, -89, -86, -86, -83, -81,
-79, -78, -75, -74, -71, -69, -66, -64, -62, -59, -57, -55, -51, -49, -46, -43,
-40, -37, -34, -30, -27, -24, -20, -16, -12, -9, -5, -2, };