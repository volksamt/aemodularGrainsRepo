#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 12, 17, 22, 26, 32, 36, 41, 46,
49, 52, 57, 60, 63, 65, 69, 71, 74, 75, 78, 80, 81, 84, 85, 87, 88, 90, 92, 92,
94, 96, 97, 97, 99, 100, 102, 102, 104, 105, 106, 107, 108, 109, 109, 109, 111,
111, 111, 112, 112, 112, 113, 113, 114, 113, 115, 114, 114, 114, 115, 116, 116,
116, 117, 117, 117, 118, 118, 118, 119, 119, 119, 119, 119, 118, 118, 116, 116,
114, 114, 111, 109, 106, 104, 102, 99, 95, 91, 88, 85, 81, 77, 72, 69, 65, 61,
57, 53, 49, 46, 42, 39, 35, 33, 30, 27, 25, 22, 21, 18, 16, 15, 13, 12, 10, 9,
7, 7, 5, 3, 2, 1, 0, -2, -3, -4, -7, -8, -8, -9, -11, -12, -13, -15, -16, -16,
-17, -18, -19, -19, -18, -19, -20, -19, -19, -19, -19, -18, -18, -18, -17, -17,
-16, -15, -16, -15, -15, -15, -15, -15, -15, -16, -16, -17, -18, -18, -19, -20,
-21, -23, -24, -25, -27, -28, -28, -31, -31, -32, -33, -34, -34, -35, -36, -36,
-36, -36, -36, -36, -34, -34, -33, -32, -32, -30, -30, -29, -28, -26, -25, -25,
-24, -23, -22, -21, -20, -20, -19, -19, -19, -19, -18, -19, -17, -18, -17, -17,
-17, -16, -16, -16, -17, -16, -16, -15, -15, -14, -13, -13, -13, -13, -12, -12,
-12, -11, -12, -12, -12, -13, -13, -14, -15, -16, -17, -19, -20, -21, -23, -25,
-26, -27, -29, -30, -32, -33, -34, -35, -35, -36, -37, -37, -37, -37, -37, -37,
-36, -37, -36, -36, -35, -35, -35, -34, -34, -34, -34, -35, -37, -37, -38, -39,
-41, -43, -44, -47, -48, -51, -52, -54, -57, -59, -61, -63, -65, -66, -68, -69,
-70, -71, -72, -72, -72, -72, -72, -71, -71, -69, -69, -68, -66, -66, -64, -63,
-62, -60, -59, -58, -57, -56, -55, -53, -54, -52, -52, -51, -51, -51, -51, -50,
-50, -50, -50, -49, -49, -49, -48, -47, -48, -46, -45, -44, -43, -42, -40, -37,
-36, -33, -31, -28, -27, -24, -21, -18, -15, -13, -10, -7, -3, -1, 2, 4, 8, 10,
12, 15, 18, 20, 23, 24, 27, 29, 30, 32, 35, 36, 37, 39, 41, 42, 44, 45, 46, 47,
48, 48, 49, 49, 50, 49, 51, 50, 50, 50, 49, 48, 47, 46, 45, 44, 41, 41, 39, 36,
35, 33, 31, 29, 27, 24, 22, 20, 18, 16, 14, 12, 10, 9, 7, 5, 3, 3, 2, 0, 0, -2,
-3, -4, -5, -6, -7, -8, -9, -10, -12, -13, -14, -15, -18, -19, -21, -22, -24,
-27, -28, -31, -31, -34, -35, -37, -39, -41, -42, -43, -45, -47, -47, -48, -49,
-50, -51, -52, -53, -53, -54, -54, -55, -56, -55, -56, -57, -58, -58, -60, -60,
-61, -61, -63, -64, -66, -66, -68, -69, -70, -71, -72, -73, -75, -74, -75, -75,
-75, -75, -74, -73, -71, -70, -69, -65, -63, -59, -56, -53, -49, -44, -39, -35,
-31, -24, -20, -15, -9, -3, };