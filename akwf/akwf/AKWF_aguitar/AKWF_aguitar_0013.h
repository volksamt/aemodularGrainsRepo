#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 10, 15, 18, 21, 24, 28, 31, 34,
37, 39, 42, 44, 47, 48, 50, 51, 52, 53, 55, 55, 56, 57, 57, 59, 59, 60, 60, 60,
61, 61, 60, 62, 61, 62, 62, 62, 63, 62, 63, 62, 61, 61, 61, 61, 60, 59, 58, 58,
57, 56, 53, 53, 52, 50, 48, 46, 45, 42, 41, 39, 38, 36, 34, 33, 32, 31, 29, 27,
28, 27, 26, 26, 26, 26, 26, 26, 27, 28, 28, 30, 31, 31, 33, 34, 35, 36, 38, 40,
41, 43, 44, 46, 47, 48, 50, 52, 53, 54, 56, 57, 59, 62, 62, 64, 66, 67, 69, 70,
71, 73, 74, 75, 75, 77, 76, 77, 78, 77, 77, 76, 75, 74, 72, 70, 68, 66, 63, 59,
57, 54, 50, 47, 41, 38, 33, 28, 24, 20, 14, 10, 6, 1, -4, -9, -12, -17, -21,
-26, -30, -34, -38, -42, -46, -49, -54, -57, -61, -64, -67, -71, -74, -77, -80,
-83, -86, -89, -91, -94, -96, -99, -101, -103, -105, -107, -108, -110, -112,
-114, -113, -115, -116, -116, -117, -116, -117, -117, -117, -117, -116, -115,
-113, -113, -112, -111, -109, -107, -106, -104, -102, -100, -99, -97, -95, -93,
-91, -88, -87, -84, -82, -80, -79, -75, -74, -72, -70, -68, -64, -63, -60, -57,
-55, -53, -50, -48, -44, -41, -39, -36, -33, -31, -27, -24, -21, -17, -14, -11,
-8, -5, -1, 2, 5, 8, 10, 13, 15, 18, 20, 22, 24, 26, 28, 29, 30, 31, 32, 33, 34,
34, 34, 35, 35, 33, 33, 33, 32, 31, 30, 29, 29, 28, 26, 26, 25, 24, 21, 21, 20,
18, 19, 17, 16, 15, 15, 12, 11, 11, 10, 9, 7, 6, 5, 4, 3, 2, 0, -1, -3, -4, -5,
-6, -7, -8, -9, -10, -11, -11, -12, -12, -13, -14, -15, -14, -15, -15, -15, -16,
-15, -15, -15, -15, -14, -13, -13, -13, -12, -11, -10, -9, -8, -8, -7, -6, -4,
-3, -2, 0, 1, 3, 6, 8, 9, 12, 14, 17, 20, 24, 26, 29, 32, 37, 39, 42, 46, 50,
53, 57, 59, 62, 66, 69, 70, 73, 75, 78, 79, 81, 83, 85, 86, 87, 87, 89, 90, 90,
91, 91, 91, 92, 92, 92, 92, 93, 91, 92, 92, 91, 92, 90, 90, 89, 89, 88, 87, 85,
84, 83, 82, 79, 77, 76, 74, 71, 69, 66, 64, 61, 59, 56, 53, 50, 48, 44, 41, 39,
36, 32, 31, 27, 24, 22, 19, 16, 12, 10, 6, 3, 0, -2, -5, -8, -12, -14, -17, -21,
-23, -27, -30, -33, -36, -41, -43, -47, -50, -54, -57, -62, -64, -68, -72, -75,
-78, -82, -86, -89, -92, -96, -98, -100, -104, -106, -108, -110, -113, -114,
-116, -116, -117, -119, -119, -118, -119, -119, -118, -118, -116, -115, -114,
-112, -111, -109, -106, -104, -103, -100, -96, -94, -91, -86, -84, -81, -76,
-73, -70, -65, -62, -57, -54, -50, -46, -41, -37, -33, -28, -25, -21, -16, -12,
-8, -4, 0, };