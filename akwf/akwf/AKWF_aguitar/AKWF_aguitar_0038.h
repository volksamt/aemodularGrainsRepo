#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0038

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 9, 11, 15, 17, 19, 23, 27,
29, 32, 34, 38, 40, 44, 47, 49, 52, 55, 58, 62, 64, 66, 69, 72, 74, 76, 78, 81,
84, 86, 88, 90, 91, 94, 96, 97, 99, 100, 102, 104, 105, 106, 108, 110, 110, 111,
112, 113, 114, 115, 116, 116, 117, 118, 118, 118, 119, 119, 119, 119, 119, 119,
119, 119, 118, 118, 117, 115, 115, 114, 114, 113, 112, 110, 109, 108, 106, 105,
104, 102, 101, 99, 97, 96, 94, 93, 91, 89, 87, 86, 84, 82, 81, 79, 77, 75, 74,
71, 70, 68, 66, 65, 63, 60, 58, 57, 56, 54, 52, 51, 49, 47, 45, 44, 42, 41, 39,
38, 37, 36, 34, 33, 31, 30, 29, 28, 26, 26, 24, 23, 23, 21, 21, 19, 18, 18, 18,
16, 16, 14, 14, 13, 12, 12, 11, 10, 9, 9, 9, 8, 7, 7, 6, 5, 5, 4, 3, 3, 3, 2, 2,
1, 1, 1, 0, -1, 0, -1, -1, -1, -2, -2, -1, -2, -2, -3, -2, -2, -2, -2, -3, -2,
-3, -4, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -2, -2, -1, -2, -1, -1, 0,
0, 0, 2, 2, 2, 3, 3, 4, 4, 5, 6, 6, 7, 7, 9, 10, 9, 9, 11, 11, 11, 12, 12, 12,
12, 12, 12, 13, 12, 12, 12, 12, 11, 11, 10, 9, 9, 9, 7, 7, 5, 4, 4, 2, 0, -1,
-2, -4, -6, -7, -8, -9, -11, -12, -15, -16, -18, -20, -22, -23, -25, -28, -30,
-31, -34, -36, -37, -39, -41, -44, -44, -47, -49, -51, -53, -54, -55, -57, -60,
-60, -62, -64, -65, -65, -67, -68, -69, -70, -71, -71, -72, -74, -74, -75, -75,
-76, -76, -77, -77, -77, -77, -78, -78, -79, -78, -78, -79, -78, -79, -79, -79,
-78, -79, -78, -78, -78, -78, -78, -78, -78, -77, -78, -77, -77, -76, -76, -76,
-76, -76, -75, -75, -75, -73, -73, -73, -73, -72, -71, -71, -71, -69, -69, -67,
-68, -67, -66, -65, -64, -63, -63, -61, -61, -59, -57, -56, -55, -54, -52, -51,
-49, -48, -46, -44, -43, -41, -39, -38, -36, -34, -33, -31, -29, -27, -26, -24,
-23, -21, -20, -18, -17, -16, -15, -13, -13, -12, -10, -10, -10, -9, -8, -8, -7,
-6, -6, -6, -5, -7, -6, -6, -5, -6, -6, -7, -7, -8, -7, -7, -8, -7, -9, -9, -10,
-10, -10, -11, -13, -12, -12, -14, -15, -15, -16, -16, -17, -17, -19, -19, -20,
-21, -20, -21, -23, -23, -24, -24, -24, -25, -27, -27, -28, -28, -29, -29, -30,
-31, -31, -32, -32, -34, -33, -34, -35, -35, -35, -36, -37, -38, -38, -39, -39,
-40, -40, -41, -42, -42, -42, -42, -43, -44, -44, -45, -44, -46, -45, -45, -45,
-45, -44, -45, -45, -44, -44, -44, -42, -42, -42, -41, -39, -37, -37, -37, -35,
-32, -31, -30, -29, -27, -24, -23, -21, -19, -17, -15, -12, -9, -6, -5, -1, };