#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 3, 4, 5, 6, 7, 8, 9, 11, 12, 14,
17, 19, 21, 23, 25, 29, 31, 34, 37, 40, 42, 45, 48, 50, 54, 57, 60, 63, 67, 69,
72, 74, 77, 81, 82, 86, 87, 89, 92, 92, 95, 97, 98, 100, 101, 103, 103, 105,
105, 106, 108, 108, 109, 110, 110, 112, 111, 112, 112, 113, 114, 113, 113, 114,
114, 114, 114, 115, 115, 115, 115, 116, 116, 116, 116, 117, 117, 117, 117, 119,
118, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 117, 117, 117,
116, 116, 114, 113, 111, 111, 109, 108, 105, 104, 101, 99, 98, 95, 92, 90, 87,
84, 81, 79, 76, 73, 70, 66, 64, 61, 58, 55, 51, 50, 46, 43, 40, 38, 34, 31, 28,
25, 22, 19, 17, 13, 11, 8, 7, 3, 1, -2, -3, -5, -9, -9, -13, -15, -16, -18, -20,
-23, -24, -26, -29, -31, -32, -35, -37, -38, -39, -41, -43, -45, -46, -48, -49,
-51, -52, -54, -56, -57, -59, -60, -62, -63, -65, -67, -68, -69, -70, -73, -73,
-75, -76, -76, -78, -79, -80, -80, -81, -83, -83, -84, -84, -85, -86, -86, -86,
-87, -88, -88, -87, -88, -88, -88, -87, -87, -87, -87, -86, -85, -86, -85, -84,
-84, -84, -83, -83, -82, -84, -83, -83, -83, -84, -83, -84, -84, -83, -83, -83,
-83, -83, -82, -84, -84, -83, -83, -83, -84, -84, -83, -82, -83, -83, -83, -83,
-82, -82, -82, -81, -81, -80, -80, -79, -79, -79, -78, -77, -77, -76, -75, -74,
-73, -73, -72, -71, -70, -69, -69, -68, -67, -67, -67, -66, -65, -63, -63, -63,
-62, -61, -61, -62, -60, -61, -59, -60, -59, -58, -58, -58, -58, -56, -56, -55,
-55, -53, -53, -53, -53, -52, -51, -50, -51, -49, -49, -48, -47, -46, -46, -45,
-43, -43, -42, -42, -40, -38, -38, -36, -35, -34, -32, -31, -30, -28, -26, -25,
-23, -22, -19, -18, -16, -15, -13, -12, -9, -8, -7, -5, -3, -2, -1, 0, 1, 2, 4,
4, 5, 6, 7, 7, 7, 9, 9, 9, 10, 10, 11, 11, 12, 11, 12, 12, 13, 12, 12, 14, 13,
12, 12, 12, 12, 11, 11, 11, 11, 10, 10, 9, 10, 9, 9, 9, 8, 9, 8, 7, 7, 7, 6, 7,
7, 7, 8, 6, 7, 7, 7, 7, 8, 8, 9, 10, 9, 10, 11, 10, 11, 12, 12, 12, 12, 13, 13,
13, 12, 13, 14, 14, 15, 14, 15, 15, 16, 16, 15, 15, 16, 16, 16, 16, 15, 16, 16,
15, 15, 14, 15, 14, 13, 13, 12, 12, 11, 11, 10, 10, 9, 7, 7, 6, 6, 4, 4, 3, 2,
0, 1, -2, -2, -3, -3, -5, -5, -7, -7, -7, -9, -9, -10, -10, -11, -11, -11, -11,
-11, -11, -12, -11, -12, -11, -11, -11, -11, -10, -10, -9, -9, -9, -10, -8, -8,
-7, -8, -7, -7, -7, -7, -6, -5, -4, -4, -4, -2, -2, -2, -1, -1, };