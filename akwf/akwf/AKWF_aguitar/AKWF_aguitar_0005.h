#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 10, 13, 15, 18, 21, 23, 25,
28, 30, 33, 35, 38, 40, 42, 43, 46, 48, 50, 52, 53, 56, 56, 59, 60, 61, 63, 64,
65, 66, 67, 68, 69, 70, 71, 72, 73, 72, 73, 74, 75, 74, 76, 75, 75, 75, 75, 75,
75, 76, 75, 74, 74, 74, 73, 73, 72, 71, 71, 70, 70, 68, 68, 68, 66, 66, 64, 64,
63, 62, 61, 60, 59, 57, 57, 55, 55, 53, 52, 51, 49, 49, 48, 46, 45, 43, 43, 41,
40, 38, 37, 36, 34, 32, 32, 31, 28, 28, 26, 24, 24, 22, 21, 20, 17, 16, 15, 14,
12, 10, 9, 7, 6, 5, 4, 2, 1, -1, -2, -3, -5, -5, -7, -8, -10, -10, -11, -14,
-13, -16, -15, -16, -18, -18, -19, -20, -20, -21, -21, -21, -22, -22, -22, -23,
-22, -23, -23, -23, -23, -23, -22, -22, -22, -21, -20, -21, -19, -19, -19, -18,
-17, -17, -15, -14, -14, -13, -12, -11, -10, -10, -9, -7, -5, -5, -4, -4, -3,
-2, -1, 0, 1, 3, 3, 4, 5, 5, 6, 7, 8, 9, 9, 10, 10, 11, 12, 11, 13, 12, 12, 13,
14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 13, 14, 13, 12, 13, 11, 11, 12, 11, 10,
10, 10, 9, 8, 8, 7, 6, 7, 5, 5, 4, 4, 2, 3, 2, 0, 0, 0, -1, -1, -2, -2, -3, -4,
-4, -4, -5, -5, -6, -5, -6, -6, -6, -7, -7, -8, -8, -8, -7, -7, -8, -8, -8, -8,
-7, -7, -6, -7, -7, -6, -5, -5, -4, -4, -3, -3, -2, -2, 0, 0, 1, 1, 2, 3, 4, 6,
7, 7, 9, 10, 12, 12, 13, 15, 16, 18, 18, 20, 20, 23, 23, 25, 26, 27, 28, 30, 30,
31, 33, 33, 35, 35, 37, 38, 40, 40, 41, 41, 43, 43, 44, 45, 46, 45, 47, 47, 47,
48, 47, 48, 49, 49, 49, 48, 49, 49, 50, 49, 49, 49, 49, 49, 50, 49, 49, 48, 49,
48, 48, 47, 47, 46, 47, 47, 46, 46, 45, 45, 45, 44, 42, 41, 41, 41, 41, 39, 38,
38, 37, 36, 35, 33, 33, 31, 29, 29, 27, 25, 25, 23, 22, 19, 18, 16, 14, 13, 10,
8, 6, 3, 1, 0, -4, -5, -8, -11, -13, -16, -19, -21, -25, -27, -30, -33, -35,
-38, -41, -44, -47, -50, -52, -55, -59, -61, -64, -67, -70, -71, -75, -78, -80,
-83, -85, -87, -90, -92, -94, -96, -99, -101, -103, -104, -106, -108, -109,
-111, -111, -113, -113, -115, -116, -116, -117, -118, -118, -119, -119, -120,
-119, -119, -119, -118, -117, -117, -116, -116, -116, -115, -114, -113, -112,
-111, -110, -107, -108, -106, -105, -103, -100, -99, -98, -96, -94, -92, -90,
-88, -87, -84, -82, -79, -77, -75, -73, -70, -68, -65, -62, -61, -58, -55, -53,
-49, -48, -45, -42, -40, -36, -34, -32, -28, -25, -23, -19, -17, -14, -11, -10,
-6, -3, 0, };