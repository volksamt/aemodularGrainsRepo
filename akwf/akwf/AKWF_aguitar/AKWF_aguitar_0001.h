#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 13, 18, 24, 28, 35, 39, 45, 52,
57, 63, 69, 73, 78, 82, 88, 92, 95, 99, 102, 105, 107, 110, 112, 114, 114, 115,
117, 116, 117, 117, 119, 118, 120, 118, 118, 119, 119, 119, 119, 119, 118, 119,
118, 117, 117, 117, 116, 116, 115, 114, 112, 112, 110, 109, 107, 105, 104, 103,
100, 97, 95, 93, 89, 87, 84, 80, 77, 73, 69, 66, 61, 57, 54, 49, 44, 39, 34, 29,
24, 20, 14, 10, 5, -2, -6, -11, -16, -21, -24, -29, -33, -38, -41, -44, -48,
-51, -54, -55, -58, -60, -63, -65, -67, -68, -69, -72, -74, -75, -77, -78, -80,
-81, -82, -84, -84, -87, -88, -89, -90, -92, -93, -94, -95, -96, -98, -98, -98,
-100, -102, -102, -104, -104, -104, -107, -107, -108, -109, -110, -110, -111,
-111, -112, -113, -112, -112, -112, -111, -112, -111, -111, -110, -110, -109,
-109, -108, -106, -107, -105, -105, -104, -104, -104, -103, -102, -102, -102,
-101, -100, -100, -99, -99, -98, -98, -95, -94, -93, -91, -91, -88, -88, -85,
-84, -82, -79, -78, -76, -74, -72, -69, -67, -63, -62, -59, -57, -53, -52, -48,
-46, -43, -41, -37, -34, -32, -29, -27, -24, -22, -19, -16, -13, -11, -9, -6,
-4, -1, 1, 3, 6, 8, 12, 14, 17, 20, 23, 26, 29, 32, 36, 39, 43, 46, 49, 53, 55,
57, 60, 63, 64, 67, 69, 70, 72, 74, 76, 78, 80, 81, 82, 85, 86, 89, 90, 93, 94,
97, 99, 100, 101, 103, 104, 105, 105, 107, 107, 107, 106, 106, 106, 104, 104,
103, 102, 101, 100, 100, 98, 98, 96, 96, 95, 93, 93, 92, 90, 89, 87, 85, 83, 80,
77, 74, 70, 67, 64, 59, 55, 51, 47, 43, 39, 37, 33, 30, 29, 26, 24, 23, 23, 22,
22, 21, 20, 21, 20, 19, 18, 17, 14, 12, 11, 8, 4, 0, -3, -6, -11, -15, -20, -24,
-27, -31, -35, -38, -41, -43, -45, -48, -49, -49, -51, -51, -51, -51, -52, -51,
-51, -51, -52, -52, -51, -52, -53, -53, -53, -52, -53, -52, -53, -52, -51, -50,
-49, -47, -45, -43, -41, -39, -38, -35, -33, -31, -27, -25, -23, -21, -19, -17,
-16, -15, -14, -12, -12, -11, -10, -9, -8, -8, -7, -6, -6, -5, -4, -4, -3, -2,
0, 0, 1, 1, 3, 4, 4, 4, 5, 5, 4, 5, 5, 5, 6, 5, 4, 5, 4, 6, 6, 6, 7, 8, 8, 10,
12, 13, 14, 16, 18, 19, 20, 22, 23, 23, 25, 25, 25, 25, 24, 23, 22, 19, 18, 15,
13, 10, 7, 3, -2, -5, -10, -13, -17, -21, -24, -27, -31, -34, -37, -40, -41,
-44, -44, -45, -46, -47, -46, -46, -46, -45, -45, -43, -43, -41, -40, -39, -38,
-37, -35, -35, -33, -33, -32, -31, -30, -30, -30, -29, -29, -29, -30, -30, -30,
-30, -31, -32, -32, -32, -31, -31, -30, -30, -29, -28, -27, -23, -23, -20, -16,
-13, -10, -6, 0, };