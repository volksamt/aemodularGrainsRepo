#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 5, 7, 9, 10, 12, 13, 15, 16,
19, 22, 22, 25, 27, 29, 31, 33, 35, 37, 39, 41, 44, 46, 48, 50, 52, 54, 57, 59,
62, 63, 65, 68, 70, 71, 74, 76, 78, 80, 81, 82, 85, 86, 87, 90, 91, 93, 95, 96,
97, 99, 100, 102, 102, 104, 105, 106, 108, 108, 110, 111, 111, 112, 113, 114,
115, 116, 116, 117, 117, 118, 119, 119, 120, 119, 119, 119, 120, 118, 118, 118,
118, 117, 117, 116, 114, 114, 114, 112, 110, 110, 109, 107, 106, 104, 102, 100,
99, 98, 96, 94, 91, 90, 88, 85, 83, 81, 79, 78, 75, 72, 70, 68, 65, 63, 61, 59,
57, 54, 51, 49, 47, 45, 42, 39, 38, 36, 33, 31, 29, 27, 24, 23, 20, 17, 16, 14,
12, 11, 9, 7, 5, 3, 2, -1, -3, -4, -5, -7, -9, -11, -12, -14, -15, -16, -18,
-19, -21, -22, -24, -25, -26, -28, -28, -31, -32, -33, -34, -35, -36, -37, -39,
-40, -40, -42, -42, -44, -45, -45, -46, -47, -48, -48, -49, -49, -50, -51, -51,
-51, -51, -52, -52, -52, -52, -53, -53, -53, -53, -52, -52, -53, -54, -53, -53,
-52, -52, -52, -53, -52, -53, -53, -52, -52, -51, -52, -51, -51, -51, -52, -51,
-50, -50, -50, -49, -49, -49, -49, -48, -47, -47, -47, -47, -46, -46, -45, -45,
-45, -44, -44, -44, -44, -44, -44, -44, -44, -43, -43, -43, -43, -42, -43, -43,
-43, -43, -43, -43, -43, -43, -42, -42, -43, -42, -42, -42, -41, -41, -40, -40,
-39, -39, -39, -38, -38, -37, -37, -35, -36, -35, -35, -33, -33, -32, -32, -31,
-30, -30, -29, -29, -28, -28, -26, -25, -26, -25, -25, -23, -23, -24, -22, -22,
-22, -21, -21, -20, -19, -18, -19, -17, -17, -17, -15, -15, -14, -14, -12, -12,
-11, -10, -10, -9, -8, -8, -6, -6, -6, -3, -3, -2, -1, 0, 0, 0, 1, 2, 1, 2, 2,
4, 3, 3, 4, 4, 3, 4, 3, 4, 3, 3, 3, 3, 3, 2, 2, 2, 2, 1, 0, -1, -1, -1, -2, -2,
-3, -4, -4, -5, -6, -7, -8, -8, -9, -9, -10, -12, -11, -12, -14, -14, -16, -16,
-15, -17, -18, -18, -19, -19, -21, -21, -22, -23, -23, -23, -24, -24, -25, -24,
-25, -25, -25, -25, -25, -25, -25, -25, -26, -25, -26, -25, -26, -26, -26, -26,
-26, -26, -26, -26, -27, -28, -27, -29, -29, -29, -29, -30, -31, -31, -31, -32,
-34, -33, -35, -35, -36, -36, -37, -37, -38, -39, -39, -40, -40, -40, -41, -41,
-41, -42, -41, -41, -41, -40, -41, -40, -41, -40, -39, -40, -40, -39, -39, -38,
-37, -37, -37, -36, -35, -35, -35, -34, -34, -33, -33, -31, -31, -31, -30, -31,
-29, -29, -28, -28, -26, -27, -26, -26, -25, -24, -23, -23, -22, -22, -21, -20,
-19, -17, -17, -16, -16, -14, -14, -13, -12, -11, -9, -9, -7, -6, -5, -4, -1, 0,
};