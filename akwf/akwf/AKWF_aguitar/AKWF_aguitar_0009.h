#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 7, 11, 16, 18, 23, 27, 30, 34,
38, 41, 45, 49, 53, 57, 61, 63, 67, 71, 74, 77, 82, 84, 87, 90, 93, 95, 98, 101,
102, 104, 107, 109, 110, 111, 113, 115, 116, 116, 117, 117, 118, 118, 119, 119,
119, 118, 119, 119, 119, 118, 118, 118, 115, 116, 115, 114, 113, 112, 111, 110,
109, 107, 105, 105, 104, 101, 101, 98, 97, 95, 93, 91, 89, 87, 86, 84, 81, 79,
78, 75, 73, 70, 69, 66, 64, 62, 60, 57, 56, 54, 51, 48, 47, 46, 43, 41, 39, 37,
36, 34, 32, 30, 29, 27, 26, 24, 22, 21, 19, 17, 16, 14, 13, 13, 12, 10, 10, 8,
7, 5, 4, 4, 3, 2, 2, 1, 1, 0, -1, -2, -2, -3, -2, -4, -5, -5, -5, -5, -6, -7,
-7, -8, -8, -9, -9, -10, -11, -10, -12, -12, -13, -13, -14, -14, -15, -16, -15,
-17, -17, -18, -17, -17, -17, -18, -18, -17, -17, -17, -17, -17, -17, -16, -15,
-14, -15, -15, -13, -13, -12, -12, -10, -9, -9, -8, -7, -6, -5, -5, -5, -3, -3,
-2, -1, 0, 0, 2, 2, 3, 3, 4, 4, 6, 6, 7, 7, 8, 9, 10, 10, 12, 13, 13, 14, 15,
15, 16, 16, 18, 17, 18, 19, 18, 19, 19, 19, 20, 19, 18, 18, 18, 18, 17, 17, 16,
15, 15, 13, 11, 11, 10, 9, 7, 6, 5, 2, 0, 0, -2, -5, -5, -7, -10, -11, -13, -15,
-16, -19, -21, -22, -25, -27, -29, -31, -33, -34, -37, -38, -41, -43, -44, -47,
-49, -50, -52, -53, -55, -57, -58, -59, -61, -63, -64, -64, -66, -66, -67, -68,
-69, -69, -70, -70, -71, -71, -72, -71, -72, -71, -71, -70, -71, -70, -70, -69,
-70, -69, -68, -67, -67, -66, -66, -66, -65, -65, -65, -63, -62, -62, -62, -61,
-60, -60, -58, -57, -56, -56, -54, -54, -53, -53, -51, -51, -50, -49, -48, -47,
-47, -46, -45, -43, -43, -42, -41, -40, -40, -38, -38, -38, -37, -36, -35, -34,
-33, -33, -31, -30, -28, -28, -27, -25, -25, -23, -21, -20, -18, -16, -16, -14,
-12, -10, -8, -7, -4, -3, -1, 0, 3, 4, 6, 9, 9, 11, 13, 14, 15, 18, 18, 20, 21,
22, 22, 24, 24, 24, 26, 25, 26, 26, 26, 26, 26, 26, 26, 25, 24, 25, 24, 23, 22,
21, 20, 20, 18, 17, 15, 14, 13, 12, 11, 9, 7, 6, 5, 3, 1, 0, -4, -5, -7, -9,
-11, -12, -14, -16, -18, -20, -22, -24, -26, -28, -30, -31, -33, -35, -36, -37,
-38, -40, -42, -43, -44, -46, -47, -49, -50, -52, -53, -53, -55, -56, -56, -58,
-60, -60, -61, -62, -63, -64, -64, -65, -65, -66, -67, -67, -68, -67, -68, -69,
-68, -68, -69, -67, -67, -66, -65, -63, -64, -62, -60, -59, -57, -55, -53, -51,
-50, -48, -45, -42, -40, -37, -34, -31, -29, -26, -22, -20, -15, -13, -9, -6,
-2, };