#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 15, 20, 26, 31, 36, 41, 47, 52,
57, 63, 67, 72, 76, 81, 85, 88, 93, 95, 99, 101, 104, 107, 109, 111, 113, 114,
116, 118, 118, 119, 118, 119, 119, 118, 119, 117, 117, 115, 114, 113, 111, 110,
108, 106, 104, 102, 100, 98, 95, 93, 91, 89, 86, 84, 81, 79, 76, 74, 71, 68, 66,
63, 61, 57, 55, 52, 49, 47, 45, 42, 39, 36, 34, 32, 30, 28, 25, 23, 22, 19, 18,
16, 15, 12, 11, 10, 7, 6, 5, 3, 1, 1, -1, -4, -4, -6, -7, -8, -9, -10, -11, -12,
-12, -13, -13, -14, -13, -13, -13, -12, -13, -13, -11, -10, -10, -9, -9, -9, -9,
-9, -9, -8, -10, -10, -11, -12, -12, -14, -15, -17, -19, -21, -23, -25, -27,
-30, -31, -34, -36, -38, -41, -42, -45, -47, -48, -52, -54, -56, -58, -60, -63,
-66, -68, -71, -73, -76, -78, -81, -83, -86, -89, -91, -94, -96, -99, -100,
-103, -104, -106, -107, -108, -108, -109, -109, -110, -109, -109, -109, -107,
-106, -105, -104, -103, -102, -99, -98, -97, -95, -94, -92, -91, -89, -87, -86,
-85, -82, -82, -79, -78, -76, -75, -73, -72, -69, -68, -66, -63, -60, -59, -57,
-54, -52, -49, -47, -45, -42, -39, -37, -35, -31, -28, -25, -23, -21, -18, -15,
-12, -10, -6, -3, -1, 2, 5, 9, 11, 15, 18, 21, 24, 28, 29, 32, 36, 38, 41, 44,
45, 49, 51, 53, 56, 57, 60, 61, 64, 65, 66, 68, 69, 71, 72, 73, 74, 75, 77, 77,
78, 78, 78, 80, 80, 79, 80, 79, 80, 79, 79, 79, 78, 78, 78, 78, 77, 76, 76, 75,
75, 73, 73, 72, 71, 70, 69, 66, 66, 64, 62, 60, 58, 56, 53, 51, 49, 46, 44, 39,
37, 34, 31, 27, 24, 20, 17, 13, 11, 7, 4, 2, -2, -4, -6, -8, -11, -13, -14, -16,
-17, -18, -19, -19, -21, -22, -22, -21, -22, -22, -21, -22, -21, -21, -21, -19,
-19, -18, -17, -18, -16, -15, -15, -14, -12, -12, -11, -9, -9, -8, -7, -5, -5,
-3, -3, -2, -1, 0, 1, 2, 3, 4, 5, 7, 8, 9, 10, 12, 13, 15, 16, 18, 20, 22, 24,
26, 28, 30, 32, 34, 36, 37, 38, 40, 41, 42, 44, 43, 44, 44, 44, 43, 43, 42, 42,
41, 40, 39, 38, 37, 35, 34, 33, 32, 30, 29, 27, 27, 25, 24, 23, 22, 21, 19, 18,
17, 15, 14, 13, 10, 8, 7, 4, 2, 0, -2, -5, -8, -11, -13, -16, -19, -21, -24,
-27, -31, -34, -36, -39, -41, -45, -46, -50, -52, -55, -58, -60, -63, -67, -70,
-72, -75, -78, -80, -84, -85, -88, -90, -93, -95, -97, -98, -100, -100, -101,
-103, -103, -104, -103, -103, -103, -101, -102, -101, -99, -98, -96, -95, -92,
-90, -88, -86, -83, -80, -78, -74, -72, -69, -66, -63, -59, -55, -51, -47, -42,
-40, -35, -31, -26, -21, -15, -10, -5, -1, };