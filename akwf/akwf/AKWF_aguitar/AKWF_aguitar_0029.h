#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0029

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 8, 11, 13, 16, 19, 21, 23, 26,
28, 30, 33, 34, 36, 38, 39, 42, 42, 44, 45, 46, 47, 48, 49, 51, 52, 52, 54, 54,
55, 56, 57, 59, 60, 61, 61, 62, 64, 65, 66, 67, 69, 70, 72, 73, 75, 76, 78, 79,
80, 82, 84, 86, 88, 89, 90, 92, 93, 94, 95, 96, 98, 100, 101, 102, 102, 103,
104, 105, 105, 106, 107, 106, 106, 106, 106, 107, 106, 106, 105, 105, 104, 104,
103, 102, 101, 101, 99, 98, 97, 95, 94, 93, 92, 90, 89, 88, 86, 85, 83, 82, 80,
78, 77, 76, 74, 72, 71, 70, 67, 66, 65, 63, 62, 60, 59, 57, 55, 54, 53, 51, 50,
49, 48, 47, 45, 43, 42, 40, 40, 38, 37, 35, 35, 35, 33, 32, 30, 29, 29, 27, 25,
25, 23, 23, 22, 21, 20, 18, 18, 17, 16, 15, 14, 13, 11, 11, 9, 9, 8, 7, 5, 5, 3,
2, 1, 0, -1, -2, -2, -4, -5, -6, -7, -8, -9, -11, -12, -13, -14, -16, -17, -18,
-21, -21, -22, -24, -25, -26, -28, -29, -29, -30, -31, -32, -34, -35, -35, -36,
-37, -37, -39, -40, -40, -40, -42, -42, -42, -44, -43, -43, -44, -44, -44, -45,
-45, -46, -46, -45, -47, -46, -46, -47, -47, -48, -48, -47, -48, -49, -50, -49,
-50, -49, -50, -51, -50, -51, -50, -51, -50, -52, -51, -52, -51, -50, -51, -51,
-50, -50, -49, -49, -50, -48, -48, -48, -47, -48, -46, -46, -45, -45, -44, -43,
-43, -42, -42, -41, -41, -39, -40, -39, -38, -37, -37, -37, -36, -35, -34, -33,
-32, -32, -31, -29, -29, -28, -27, -27, -25, -24, -23, -21, -22, -20, -19, -17,
-15, -13, -11, -10, -8, -6, -4, -2, 0, 2, 4, 7, 10, 12, 15, 17, 20, 22, 24, 26,
29, 32, 34, 37, 39, 40, 43, 45, 46, 47, 50, 51, 53, 54, 55, 57, 57, 58, 59, 59,
59, 60, 59, 59, 59, 58, 58, 58, 58, 56, 56, 55, 53, 53, 52, 50, 49, 47, 47, 45,
44, 43, 42, 41, 39, 39, 36, 36, 34, 33, 32, 31, 31, 28, 28, 27, 25, 25, 24, 23,
22, 21, 20, 19, 17, 18, 16, 16, 15, 13, 13, 11, 10, 9, 7, 6, 5, 3, 2, 0, -1, -2,
-4, -5, -7, -9, -11, -13, -14, -16, -17, -20, -22, -23, -26, -29, -31, -33, -35,
-37, -40, -42, -44, -46, -49, -51, -54, -56, -59, -62, -64, -67, -68, -72, -74,
-75, -78, -81, -83, -85, -88, -90, -92, -94, -95, -97, -99, -102, -102, -105,
-106, -107, -109, -110, -112, -113, -113, -114, -116, -116, -117, -117, -119,
-119, -118, -118, -119, -119, -119, -119, -119, -117, -117, -117, -115, -116,
-114, -113, -112, -110, -110, -108, -106, -104, -101, -99, -97, -94, -92, -90,
-87, -84, -81, -78, -76, -72, -69, -65, -63, -59, -56, -51, -48, -44, -41, -36,
-32, -30, -26, -23, -19, -15, -11, -8, -5, -1, };