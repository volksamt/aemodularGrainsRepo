#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 10, 13, 15, 18, 21, 24, 28,
31, 33, 35, 38, 41, 44, 46, 48, 52, 54, 56, 58, 60, 63, 64, 67, 69, 70, 73, 75,
77, 77, 80, 81, 83, 86, 87, 89, 90, 91, 92, 94, 95, 97, 98, 99, 99, 101, 101,
102, 103, 103, 103, 103, 103, 103, 102, 103, 103, 102, 100, 99, 98, 97, 95, 94,
91, 89, 86, 84, 82, 79, 77, 74, 71, 69, 64, 61, 58, 54, 50, 47, 43, 39, 35, 30,
27, 22, 19, 15, 10, 6, 2, -2, -6, -10, -14, -17, -21, -26, -30, -34, -37, -41,
-44, -47, -51, -54, -58, -60, -63, -65, -68, -71, -74, -76, -80, -81, -84, -86,
-89, -91, -92, -94, -97, -98, -100, -102, -103, -105, -106, -107, -109, -110,
-111, -112, -114, -115, -115, -116, -117, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -117, -115, -115, -115, -113, -112, -111, -109,
-108, -106, -104, -103, -101, -99, -98, -96, -94, -93, -91, -88, -87, -85, -83,
-82, -80, -78, -76, -74, -72, -71, -69, -67, -65, -64, -63, -59, -59, -56, -56,
-54, -51, -51, -50, -47, -46, -44, -42, -41, -40, -39, -37, -36, -35, -33, -32,
-30, -29, -29, -28, -26, -25, -23, -23, -22, -21, -20, -19, -18, -17, -15, -14,
-14, -13, -12, -10, -9, -9, -8, -7, -6, -4, -3, -3, -1, 0, 0, 1, 2, 3, 5, 5, 6,
7, 7, 7, 8, 9, 8, 10, 10, 11, 9, 11, 11, 12, 11, 12, 12, 12, 12, 12, 12, 13, 13,
13, 14, 14, 13, 15, 14, 15, 15, 15, 15, 16, 15, 16, 15, 15, 16, 15, 15, 16, 15,
15, 15, 15, 14, 15, 15, 15, 14, 14, 13, 14, 13, 13, 12, 13, 11, 12, 13, 12, 13,
11, 13, 13, 13, 13, 14, 13, 14, 15, 14, 15, 15, 15, 16, 16, 16, 16, 16, 15, 16,
16, 15, 15, 15, 15, 13, 13, 13, 12, 11, 10, 9, 8, 7, 6, 5, 4, 3, 1, 0, -2, -2,
-3, -4, -5, -7, -8, -9, -9, -10, -11, -12, -12, -13, -13, -14, -15, -15, -15,
-15, -15, -15, -15, -14, -14, -14, -14, -13, -12, -11, -11, -10, -9, -8, -6, -5,
-4, -4, -2, -1, 0, 1, 2, 4, 5, 6, 7, 8, 9, 10, 11, 13, 12, 13, 14, 15, 15, 17,
17, 18, 19, 19, 21, 21, 21, 22, 23, 23, 24, 25, 27, 27, 28, 29, 30, 31, 33, 34,
35, 37, 39, 40, 42, 44, 45, 46, 48, 49, 51, 51, 54, 54, 56, 56, 57, 59, 59, 59,
60, 60, 60, 60, 60, 60, 59, 58, 57, 56, 54, 53, 52, 50, 47, 46, 44, 41, 39, 36,
35, 32, 30, 27, 25, 22, 19, 16, 14, 12, 9, 7, 4, 2, 0, -3, -4, -7, -9, -10, -12,
-14, -15, -17, -19, -19, -20, -21, -21, -22, -22, -22, -22, -23, -22, -21, -21,
-19, -18, -18, -16, -13, -12, -9, -7, -6, -3, 0, };