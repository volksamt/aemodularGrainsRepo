#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 10, 14, 17, 21, 25, 29, 32, 36,
40, 44, 48, 51, 54, 58, 62, 65, 68, 72, 74, 76, 79, 82, 85, 88, 90, 92, 94, 96,
98, 99, 101, 104, 104, 106, 107, 109, 109, 110, 112, 113, 114, 115, 115, 116,
117, 117, 117, 117, 118, 118, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119,
119, 118, 118, 118, 118, 117, 118, 117, 116, 115, 116, 114, 114, 113, 112, 112,
110, 109, 109, 108, 107, 107, 104, 104, 102, 102, 100, 99, 97, 95, 94, 93, 91,
89, 87, 85, 83, 82, 80, 77, 76, 74, 72, 70, 69, 66, 65, 62, 59, 58, 55, 54, 52,
49, 48, 45, 44, 42, 40, 39, 36, 35, 33, 31, 30, 28, 27, 26, 24, 23, 21, 21, 19,
17, 16, 15, 14, 13, 11, 11, 9, 10, 9, 7, 7, 5, 5, 4, 4, 3, 2, 2, 2, 1, 1, 1, 1,
1, 0, 2, 1, 1, 2, 2, 3, 3, 3, 4, 5, 6, 7, 8, 9, 10, 11, 13, 15, 15, 18, 19, 19,
23, 23, 25, 28, 28, 31, 33, 34, 36, 38, 40, 42, 44, 46, 47, 48, 50, 51, 54, 55,
56, 57, 59, 60, 62, 63, 64, 64, 66, 67, 67, 68, 68, 69, 69, 70, 69, 69, 71, 70,
70, 70, 70, 69, 70, 69, 68, 68, 66, 67, 66, 66, 66, 64, 64, 63, 63, 62, 60, 59,
59, 58, 57, 58, 56, 56, 55, 54, 54, 53, 53, 52, 51, 51, 50, 51, 50, 49, 48, 48,
47, 46, 46, 44, 44, 43, 42, 41, 40, 40, 39, 37, 37, 36, 34, 32, 31, 29, 28, 26,
25, 23, 21, 18, 16, 14, 11, 9, 8, 5, 2, 0, -3, -6, -8, -12, -14, -17, -20, -22,
-25, -29, -31, -34, -37, -39, -42, -45, -48, -50, -53, -55, -58, -60, -62, -65,
-67, -68, -70, -71, -73, -74, -74, -77, -77, -78, -79, -79, -79, -80, -79, -80,
-81, -80, -80, -80, -80, -81, -79, -79, -79, -79, -77, -77, -77, -76, -76, -75,
-75, -75, -75, -73, -74, -73, -73, -73, -73, -73, -74, -72, -73, -73, -73, -73,
-73, -74, -75, -75, -75, -76, -76, -76, -77, -78, -80, -80, -80, -81, -82, -84,
-84, -85, -86, -86, -88, -89, -90, -90, -92, -92, -93, -95, -95, -96, -97, -97,
-97, -98, -99, -99, -99, -99, -101, -100, -100, -100, -100, -100, -100, -101,
-100, -99, -101, -99, -100, -100, -99, -99, -98, -98, -98, -97, -96, -97, -95,
-95, -95, -95, -94, -94, -93, -93, -92, -92, -92, -92, -91, -92, -92, -91, -92,
-91, -92, -92, -91, -92, -92, -92, -93, -93, -92, -93, -93, -95, -94, -94, -95,
-96, -95, -95, -95, -96, -97, -97, -97, -97, -97, -97, -97, -96, -96, -95, -95,
-95, -94, -93, -92, -90, -90, -88, -86, -86, -84, -82, -80, -77, -76, -73, -71,
-67, -64, -62, -59, -56, -53, -50, -46, -42, -39, -35, -33, -29, -25, -21, -17,
-13, -9, -5, -2, };