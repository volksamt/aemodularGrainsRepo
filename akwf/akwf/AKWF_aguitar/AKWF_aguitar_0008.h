#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 11, 15, 19, 23, 26, 29, 33,
37, 41, 44, 47, 50, 55, 58, 61, 64, 67, 71, 74, 77, 79, 83, 86, 87, 91, 93, 95,
97, 100, 101, 104, 105, 107, 109, 110, 112, 112, 114, 115, 116, 117, 117, 118,
119, 118, 119, 119, 119, 119, 119, 118, 118, 118, 117, 116, 115, 115, 114, 113,
112, 111, 110, 109, 107, 106, 104, 103, 102, 100, 98, 96, 95, 94, 91, 89, 87,
86, 84, 81, 80, 78, 77, 74, 72, 70, 68, 66, 65, 63, 61, 58, 56, 55, 53, 52, 50,
47, 46, 44, 42, 41, 40, 38, 37, 34, 32, 31, 29, 28, 26, 24, 23, 21, 20, 19, 17,
15, 14, 13, 11, 10, 9, 7, 6, 4, 3, 2, 0, 0, -2, -3, -4, -4, -6, -7, -7, -8, -10,
-10, -10, -11, -12, -13, -13, -14, -14, -14, -14, -15, -15, -15, -15, -14, -15,
-14, -14, -14, -14, -13, -12, -11, -11, -10, -9, -9, -7, -5, -5, -3, -2, -1, 0,
3, 3, 5, 6, 8, 10, 12, 12, 15, 17, 18, 19, 21, 22, 24, 26, 27, 29, 30, 31, 33,
34, 35, 36, 37, 38, 40, 40, 41, 42, 42, 42, 43, 43, 44, 44, 44, 44, 44, 43, 43,
43, 43, 42, 41, 41, 40, 38, 37, 37, 35, 34, 32, 31, 30, 28, 25, 25, 23, 21, 20,
17, 15, 13, 12, 10, 8, 6, 4, 3, 0, -2, -4, -6, -8, -10, -12, -13, -16, -18, -19,
-21, -22, -25, -26, -28, -29, -32, -34, -35, -37, -39, -40, -42, -44, -45, -48,
-49, -50, -52, -54, -56, -58, -58, -61, -61, -64, -66, -66, -68, -70, -70, -73,
-74, -75, -77, -77, -79, -80, -81, -82, -84, -84, -85, -86, -87, -89, -88, -89,
-91, -91, -91, -92, -92, -92, -93, -93, -92, -92, -93, -92, -93, -93, -92, -91,
-91, -90, -90, -89, -88, -87, -86, -86, -85, -84, -83, -81, -80, -79, -78, -76,
-74, -74, -73, -70, -70, -68, -67, -65, -64, -62, -60, -59, -57, -56, -53, -52,
-51, -49, -47, -45, -43, -43, -40, -39, -37, -35, -33, -31, -30, -27, -26, -24,
-22, -21, -19, -17, -14, -13, -12, -10, -7, -7, -4, -3, 0, 1, 3, 4, 7, 8, 10,
11, 13, 14, 16, 16, 19, 20, 21, 22, 23, 24, 25, 26, 27, 27, 28, 28, 29, 29, 29,
30, 29, 30, 30, 29, 28, 28, 28, 27, 26, 26, 23, 23, 21, 21, 19, 17, 15, 14, 12,
9, 8, 6, 3, 1, -2, -4, -7, -9, -11, -14, -16, -19, -21, -24, -27, -29, -32, -34,
-37, -40, -42, -45, -47, -49, -51, -53, -56, -58, -59, -61, -63, -65, -67, -68,
-69, -70, -72, -74, -74, -74, -75, -76, -76, -78, -77, -77, -78, -77, -77, -77,
-76, -76, -75, -74, -73, -72, -71, -69, -67, -67, -64, -63, -61, -59, -58, -55,
-53, -51, -48, -45, -43, -40, -37, -35, -32, -29, -25, -22, -19, -16, -12, -9,
-6, -2, };