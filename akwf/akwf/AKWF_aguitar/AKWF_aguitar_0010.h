#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 7, 9, 12, 14, 16, 18, 22, 24,
27, 29, 32, 36, 39, 42, 44, 47, 49, 53, 55, 59, 61, 65, 67, 71, 72, 76, 78, 81,
83, 86, 87, 90, 92, 93, 96, 98, 100, 102, 104, 106, 107, 109, 110, 112, 112,
114, 115, 115, 117, 118, 118, 119, 119, 119, 119, 119, 118, 117, 118, 117, 115,
114, 113, 111, 109, 108, 105, 104, 101, 99, 96, 95, 92, 89, 86, 84, 82, 79, 76,
74, 72, 70, 67, 64, 62, 59, 58, 55, 53, 51, 49, 46, 44, 43, 41, 39, 37, 36, 33,
32, 30, 28, 27, 25, 23, 22, 21, 20, 18, 17, 16, 14, 13, 12, 12, 11, 10, 9, 8, 8,
8, 8, 7, 7, 6, 5, 5, 5, 4, 4, 2, 2, 3, 1, 1, -1, -1, -2, -3, -3, -5, -6, -8, -8,
-9, -10, -12, -12, -13, -14, -15, -16, -18, -18, -18, -19, -20, -21, -21, -20,
-21, -20, -20, -20, -19, -19, -19, -19, -18, -17, -16, -16, -16, -15, -15, -14,
-14, -13, -13, -14, -13, -13, -13, -13, -13, -13, -13, -13, -12, -13, -12, -13,
-13, -13, -13, -12, -13, -13, -11, -12, -12, -10, -10, -9, -8, -8, -7, -6, -6,
-5, -4, -3, -2, -1, -1, 0, 1, 1, 2, 2, 2, 2, 3, 3, 4, 4, 3, 3, 3, 3, 2, 1, 2, 2,
0, 0, 0, -2, -2, -2, -3, -4, -3, -5, -7, -6, -7, -8, -8, -10, -11, -12, -13,
-14, -14, -17, -17, -19, -20, -22, -22, -24, -25, -26, -27, -28, -30, -31, -32,
-34, -34, -36, -36, -38, -38, -40, -39, -40, -42, -42, -43, -43, -45, -46, -47,
-47, -48, -49, -49, -51, -51, -52, -52, -54, -55, -56, -57, -58, -59, -60, -61,
-62, -63, -64, -65, -65, -66, -67, -68, -67, -68, -68, -68, -67, -67, -67, -65,
-65, -64, -62, -61, -61, -59, -57, -56, -54, -53, -50, -49, -47, -46, -43, -41,
-40, -39, -37, -34, -33, -32, -30, -29, -27, -25, -24, -22, -21, -20, -19, -17,
-16, -15, -14, -12, -12, -10, -9, -7, -6, -6, -5, -3, -2, -1, 0, 1, 2, 4, 5, 6,
7, 7, 9, 9, 11, 11, 11, 12, 13, 12, 12, 13, 14, 14, 14, 13, 13, 14, 14, 14, 13,
13, 13, 14, 13, 13, 12, 13, 13, 13, 13, 14, 14, 14, 14, 14, 14, 15, 14, 14, 14,
14, 14, 14, 12, 12, 13, 12, 10, 11, 10, 7, 7, 6, 4, 3, 2, 1, -1, -2, -5, -6, -8,
-9, -11, -14, -15, -17, -19, -21, -23, -25, -28, -29, -32, -34, -36, -38, -41,
-42, -43, -47, -48, -51, -53, -54, -56, -58, -60, -61, -64, -65, -66, -67, -69,
-69, -70, -71, -72, -72, -71, -71, -71, -72, -70, -70, -68, -67, -65, -64, -62,
-60, -58, -56, -55, -53, -49, -48, -46, -43, -41, -39, -37, -34, -32, -29, -28,
-25, -24, -21, -19, -17, -15, -13, -11, -10, -8, -5, -4, -1, };