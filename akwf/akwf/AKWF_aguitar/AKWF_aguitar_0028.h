#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0028

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 7, 10, 13, 17, 19, 22, 26, 28,
31, 33, 36, 37, 40, 42, 43, 44, 46, 48, 49, 49, 50, 50, 51, 52, 52, 52, 52, 53,
53, 53, 52, 54, 54, 53, 54, 54, 55, 55, 56, 58, 58, 59, 61, 62, 63, 64, 65, 67,
68, 70, 72, 73, 74, 76, 77, 78, 78, 80, 82, 82, 82, 83, 83, 83, 83, 83, 81, 82,
81, 80, 79, 78, 77, 76, 75, 74, 73, 71, 70, 70, 68, 68, 66, 66, 65, 65, 64, 64,
63, 64, 64, 64, 65, 65, 65, 67, 67, 67, 69, 69, 70, 71, 73, 73, 73, 74, 75, 75,
76, 76, 77, 77, 76, 75, 76, 75, 76, 74, 73, 72, 71, 70, 68, 67, 66, 65, 63, 62,
60, 58, 57, 55, 54, 52, 51, 50, 49, 46, 45, 44, 42, 42, 40, 39, 38, 37, 36, 35,
33, 32, 30, 28, 27, 25, 23, 22, 19, 16, 15, 12, 9, 7, 4, 0, -3, -7, -10, -13,
-18, -21, -26, -29, -33, -36, -40, -44, -48, -52, -56, -60, -63, -66, -69, -72,
-75, -77, -80, -82, -83, -86, -86, -88, -89, -90, -90, -91, -91, -90, -90, -89,
-89, -88, -87, -86, -85, -83, -83, -81, -79, -78, -76, -75, -72, -70, -69, -67,
-65, -63, -61, -58, -56, -53, -52, -49, -47, -44, -42, -40, -37, -35, -32, -29,
-26, -24, -22, -19, -16, -13, -11, -8, -5, -3, 0, 3, 6, 8, 11, 13, 15, 18, 21,
22, 24, 27, 29, 31, 32, 34, 36, 37, 37, 39, 39, 39, 40, 42, 41, 42, 42, 41, 42,
40, 41, 40, 39, 39, 38, 36, 35, 34, 33, 32, 30, 28, 28, 26, 25, 22, 22, 21, 19,
18, 17, 16, 15, 13, 12, 11, 10, 9, 8, 7, 7, 6, 5, 4, 4, 4, 3, 3, 3, 2, 2, 2, 2,
1, 2, 2, 2, 1, 2, 1, 2, 2, 2, 2, 2, 2, 3, 3, 3, 4, 4, 4, 5, 5, 6, 6, 6, 8, 8, 9,
10, 10, 11, 12, 12, 14, 14, 15, 16, 16, 17, 18, 19, 20, 20, 21, 22, 21, 23, 23,
24, 24, 25, 25, 25, 25, 26, 25, 26, 26, 27, 26, 26, 26, 26, 25, 25, 24, 23, 23,
22, 20, 19, 19, 18, 16, 15, 14, 12, 10, 8, 7, 5, 2, 0, -2, -4, -7, -9, -11, -14,
-17, -19, -21, -24, -26, -29, -31, -34, -36, -39, -42, -44, -46, -48, -51, -54,
-55, -57, -60, -62, -65, -66, -69, -70, -73, -76, -78, -80, -82, -85, -87, -89,
-91, -92, -95, -98, -100, -101, -103, -105, -108, -109, -111, -112, -114, -115,
-115, -117, -118, -118, -119, -119, -119, -120, -119, -119, -117, -117, -115,
-114, -112, -110, -108, -107, -104, -102, -99, -98, -95, -93, -90, -87, -84,
-83, -80, -78, -75, -73, -71, -68, -65, -63, -62, -59, -57, -56, -53, -51, -49,
-47, -45, -43, -41, -38, -36, -34, -32, -29, -26, -23, -21, -18, -15, -12, -8,
-6, -2, };