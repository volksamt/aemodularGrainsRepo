#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 6, 7, 9, 10, 12, 14, 16, 17, 18,
20, 20, 21, 22, 23, 22, 24, 23, 23, 22, 22, 21, 20, 19, 18, 17, 15, 14, 12, 10,
10, 9, 8, 7, 6, 6, 5, 5, 6, 5, 7, 8, 8, 8, 8, 10, 10, 11, 12, 13, 15, 14, 15,
17, 17, 19, 19, 21, 22, 24, 25, 27, 29, 31, 33, 35, 37, 39, 39, 41, 43, 45, 45,
47, 47, 47, 47, 48, 47, 46, 46, 45, 43, 42, 40, 39, 37, 35, 32, 31, 28, 25, 23,
20, 19, 17, 15, 12, 11, 9, 8, 6, 4, 4, 2, 0, -1, -1, -4, -5, -6, -8, -9, -11,
-12, -14, -16, -16, -18, -19, -20, -21, -21, -22, -22, -23, -22, -22, -22, -21,
-20, -19, -17, -16, -16, -14, -13, -11, -10, -10, -8, -8, -7, -7, -6, -7, -6,
-7, -6, -7, -7, -8, -8, -9, -9, -11, -11, -12, -12, -12, -13, -15, -13, -14,
-13, -12, -12, -11, -10, -8, -7, -5, -2, -1, 2, 5, 7, 9, 11, 13, 14, 16, 18, 20,
21, 23, 23, 23, 24, 26, 26, 25, 25, 25, 25, 25, 25, 25, 24, 26, 26, 26, 27, 29,
30, 31, 33, 34, 36, 37, 40, 40, 42, 43, 44, 45, 47, 48, 48, 49, 51, 52, 53, 54,
55, 57, 59, 61, 63, 64, 66, 68, 70, 72, 73, 75, 76, 78, 79, 81, 82, 83, 84, 85,
85, 85, 86, 87, 86, 87, 86, 86, 85, 85, 84, 84, 83, 82, 82, 81, 81, 82, 82, 82,
82, 84, 84, 85, 86, 86, 87, 87, 87, 87, 86, 86, 85, 82, 82, 80, 78, 77, 75, 72,
70, 68, 67, 65, 64, 63, 62, 61, 60, 60, 59, 58, 57, 56, 54, 53, 51, 49, 47, 44,
41, 38, 34, 31, 27, 23, 20, 15, 12, 8, 4, 1, -4, -7, -10, -13, -15, -18, -19,
-22, -23, -23, -23, -23, -22, -22, -21, -19, -19, -17, -15, -13, -12, -11, -8,
-7, -6, -5, -4, -4, -4, -3, -3, -3, -3, -3, -4, -4, -4, -4, -5, -5, -4, -5, -5,
-5, -4, -4, -5, -6, -7, -8, -10, -12, -15, -18, -21, -24, -29, -32, -37, -41,
-45, -49, -54, -58, -63, -68, -71, -76, -81, -85, -89, -93, -97, -101, -105,
-108, -111, -113, -115, -117, -118, -118, -119, -119, -119, -119, -118, -117,
-116, -116, -115, -114, -113, -113, -111, -110, -110, -107, -107, -106, -105,
-103, -100, -99, -96, -94, -92, -89, -88, -85, -83, -81, -79, -77, -75, -73,
-72, -70, -68, -67, -66, -64, -63, -61, -60, -58, -57, -55, -54, -51, -50, -47,
-46, -44, -43, -41, -40, -38, -38, -37, -36, -35, -36, -35, -35, -35, -36, -37,
-37, -38, -38, -39, -39, -40, -41, -42, -43, -42, -44, -44, -44, -44, -44, -43,
-43, -42, -41, -40, -39, -38, -37, -35, -33, -32, -29, -29, -27, -25, -24, -23,
-22, -20, -19, -17, -16, -15, -13, -12, -10, -8, -7, -5, -4, -1, 1, };