#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0032

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 5, 7, 8, 10, 12, 14, 15, 18,
20, 22, 23, 26, 28, 29, 32, 35, 36, 38, 40, 42, 43, 46, 47, 48, 51, 53, 54, 55,
58, 59, 61, 62, 63, 65, 66, 68, 69, 70, 71, 73, 74, 75, 75, 76, 77, 78, 79, 80,
79, 80, 81, 80, 81, 81, 81, 81, 81, 81, 80, 80, 79, 79, 78, 76, 75, 74, 74, 72,
70, 69, 68, 66, 65, 64, 62, 60, 58, 56, 55, 52, 51, 49, 47, 44, 43, 41, 40, 38,
36, 35, 34, 32, 31, 29, 28, 27, 26, 25, 24, 24, 24, 23, 23, 23, 23, 23, 23, 23,
25, 25, 25, 27, 27, 29, 30, 31, 32, 34, 36, 37, 39, 41, 44, 45, 47, 49, 50, 53,
55, 57, 59, 61, 64, 66, 68, 71, 72, 75, 77, 79, 80, 83, 85, 86, 88, 90, 93, 95,
97, 98, 100, 103, 104, 106, 108, 109, 110, 111, 112, 113, 115, 117, 117, 118,
118, 119, 119, 119, 119, 119, 119, 118, 118, 118, 117, 116, 116, 114, 113, 111,
109, 108, 107, 105, 103, 100, 97, 95, 94, 90, 87, 84, 82, 78, 76, 72, 68, 65,
61, 57, 53, 50, 46, 42, 37, 33, 29, 25, 21, 16, 12, 8, 4, 0, -4, -8, -12, -16,
-21, -23, -28, -31, -36, -39, -43, -46, -49, -52, -55, -59, -61, -64, -67, -69,
-72, -75, -78, -79, -81, -84, -86, -87, -89, -91, -92, -94, -95, -97, -99, -99,
-100, -101, -102, -103, -104, -105, -105, -106, -105, -106, -105, -106, -106,
-105, -105, -104, -103, -102, -101, -101, -100, -98, -98, -96, -94, -93, -91,
-90, -88, -87, -85, -83, -81, -79, -78, -76, -74, -72, -70, -68, -66, -65, -63,
-61, -59, -58, -56, -54, -53, -50, -50, -49, -46, -46, -44, -43, -42, -40, -40,
-38, -38, -37, -36, -35, -34, -34, -33, -33, -33, -32, -32, -32, -31, -31, -31,
-32, -32, -32, -32, -33, -32, -34, -33, -34, -35, -35, -37, -37, -39, -40, -39,
-41, -43, -43, -43, -44, -46, -46, -47, -48, -49, -51, -52, -52, -53, -54, -55,
-56, -57, -58, -58, -60, -61, -61, -62, -63, -64, -64, -65, -65, -66, -68, -67,
-69, -69, -68, -69, -69, -69, -70, -69, -69, -70, -68, -69, -68, -68, -67, -66,
-67, -65, -66, -64, -63, -63, -62, -60, -60, -59, -58, -58, -57, -56, -54, -52,
-51, -51, -49, -48, -47, -46, -45, -43, -41, -41, -39, -37, -35, -35, -33, -31,
-31, -30, -28, -27, -26, -24, -22, -20, -19, -18, -17, -16, -15, -13, -13, -11,
-11, -9, -8, -8, -7, -8, -6, -6, -6, -4, -5, -4, -4, -4, -4, -4, -4, -5, -4, -5,
-5, -5, -6, -5, -6, -6, -6, -5, -6, -7, -6, -7, -7, -8, -7, -7, -8, -9, -9, -9,
-9, -11, -10, -11, -11, -12, -11, -12, -11, -12, -12, -11, -12, -12, -13, -12,
-13, -12, -12, -11, -11, -10, -10, -10, -8, -7, -7, -6, -5, -4, -3, -1, };