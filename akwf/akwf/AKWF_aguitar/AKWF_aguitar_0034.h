#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0034

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 7, 7, 11, 12, 14, 16, 17, 20,
21, 24, 25, 28, 30, 31, 32, 35, 36, 37, 39, 40, 41, 43, 44, 46, 47, 48, 49, 52,
53, 55, 56, 59, 60, 62, 64, 66, 68, 71, 74, 75, 77, 79, 82, 83, 86, 88, 90, 91,
93, 95, 97, 98, 100, 102, 104, 104, 106, 108, 110, 110, 112, 113, 115, 116, 116,
116, 118, 118, 119, 118, 119, 118, 119, 120, 119, 119, 119, 119, 118, 117, 117,
117, 117, 116, 116, 117, 115, 115, 114, 115, 114, 113, 113, 112, 111, 110, 109,
107, 106, 104, 103, 101, 100, 98, 95, 93, 92, 89, 87, 84, 82, 80, 78, 77, 74,
72, 69, 68, 67, 66, 64, 63, 60, 60, 58, 57, 55, 54, 53, 52, 50, 49, 49, 47, 45,
45, 43, 41, 40, 38, 37, 35, 33, 32, 29, 27, 25, 23, 21, 20, 18, 16, 14, 13, 10,
9, 9, 6, 6, 5, 4, 5, 3, 3, 2, 2, 2, 2, 2, 1, 1, 1, 1, 1, 0, -1, 0, -2, -2, -2,
-3, -4, -3, -4, -5, -5, -5, -6, -6, -6, -7, -7, -7, -8, -7, -8, -9, -9, -10,
-10, -11, -11, -12, -12, -12, -14, -13, -13, -14, -14, -14, -14, -15, -15, -14,
-15, -15, -15, -14, -15, -15, -14, -15, -14, -14, -14, -15, -15, -15, -16, -17,
-17, -18, -18, -20, -20, -21, -21, -23, -24, -26, -26, -28, -30, -32, -33, -34,
-35, -36, -37, -39, -40, -39, -41, -42, -42, -42, -43, -44, -43, -45, -44, -45,
-46, -46, -46, -47, -47, -48, -49, -49, -51, -52, -53, -54, -55, -57, -57, -58,
-60, -62, -63, -64, -65, -66, -67, -69, -69, -70, -71, -71, -73, -73, -73, -74,
-75, -75, -76, -77, -77, -77, -77, -78, -78, -79, -79, -80, -81, -82, -81, -82,
-82, -83, -82, -83, -83, -84, -84, -83, -83, -83, -83, -82, -82, -82, -81, -81,
-81, -79, -79, -78, -78, -78, -77, -77, -76, -75, -74, -73, -73, -73, -72, -71,
-70, -70, -69, -68, -67, -67, -65, -64, -64, -62, -60, -60, -58, -57, -56, -54,
-52, -50, -49, -48, -47, -45, -44, -43, -41, -40, -38, -37, -37, -35, -34, -34,
-32, -31, -30, -29, -28, -27, -27, -26, -24, -24, -24, -23, -22, -20, -20, -19,
-17, -17, -16, -15, -14, -14, -13, -14, -12, -12, -13, -12, -12, -13, -12, -13,
-13, -13, -12, -13, -13, -13, -13, -13, -13, -12, -12, -12, -12, -12, -10, -10,
-9, -8, -8, -7, -6, -6, -7, -7, -5, -6, -6, -6, -6, -7, -8, -8, -9, -11, -11,
-12, -13, -14, -16, -15, -17, -18, -20, -20, -21, -21, -23, -23, -24, -25, -25,
-26, -26, -26, -27, -27, -28, -28, -28, -28, -28, -28, -27, -27, -26, -26, -26,
-25, -24, -25, -24, -23, -23, -22, -21, -21, -21, -20, -18, -19, -17, -17, -17,
-17, -16, -16, -15, -14, -14, -13, -12, -11, -10, -9, -9, -7, -6, -5, -4, -3,
-2, 0, };