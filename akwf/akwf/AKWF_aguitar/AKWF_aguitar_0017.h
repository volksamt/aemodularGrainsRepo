#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 6, 10, 13, 17, 21, 25, 28, 31,
34, 39, 42, 45, 49, 52, 56, 58, 61, 64, 67, 70, 73, 76, 78, 81, 83, 85, 88, 90,
92, 95, 96, 98, 100, 101, 103, 105, 106, 108, 110, 110, 111, 113, 114, 115, 115,
116, 117, 117, 118, 118, 119, 120, 119, 119, 118, 118, 119, 118, 117, 117, 116,
115, 115, 114, 113, 112, 110, 110, 108, 107, 105, 104, 102, 101, 97, 96, 94, 91,
89, 87, 84, 80, 78, 75, 71, 67, 64, 60, 56, 53, 49, 45, 41, 37, 33, 29, 24, 21,
17, 12, 8, 5, 1, -3, -6, -9, -13, -17, -21, -23, -26, -30, -32, -35, -39, -41,
-42, -46, -48, -49, -53, -55, -57, -59, -61, -64, -65, -68, -69, -71, -73, -75,
-78, -78, -80, -82, -84, -85, -87, -89, -90, -92, -93, -95, -95, -97, -98, -99,
-100, -101, -101, -102, -103, -104, -104, -104, -104, -104, -104, -104, -103,
-104, -102, -103, -102, -101, -100, -100, -98, -98, -97, -96, -96, -94, -92,
-92, -91, -88, -88, -86, -85, -84, -82, -81, -80, -78, -78, -76, -73, -72, -71,
-69, -67, -67, -64, -63, -62, -60, -59, -57, -56, -54, -52, -52, -50, -48, -47,
-46, -44, -43, -42, -41, -40, -39, -37, -37, -36, -34, -34, -33, -31, -30, -29,
-28, -28, -26, -26, -25, -23, -21, -21, -20, -18, -17, -16, -15, -13, -13, -11,
-11, -10, -8, -6, -5, -5, -3, -2, -2, -1, -1, 0, 1, 2, 3, 3, 3, 4, 4, 5, 5, 5,
5, 5, 7, 6, 7, 8, 8, 8, 9, 9, 9, 10, 10, 10, 11, 11, 11, 12, 13, 12, 13, 13, 13,
12, 13, 13, 13, 13, 13, 13, 13, 12, 13, 12, 12, 11, 11, 11, 11, 11, 10, 11, 10,
10, 10, 9, 10, 9, 10, 9, 10, 10, 11, 10, 10, 11, 11, 12, 11, 12, 11, 12, 11, 11,
11, 12, 11, 11, 11, 11, 10, 11, 9, 9, 8, 8, 8, 7, 7, 6, 4, 4, 4, 3, 2, 1, 0, -2,
-2, -2, -4, -5, -4, -6, -6, -8, -9, -9, -10, -10, -11, -13, -13, -13, -14, -14,
-16, -17, -17, -18, -18, -18, -18, -18, -19, -18, -18, -18, -18, -17, -16, -16,
-15, -14, -13, -13, -12, -10, -9, -9, -7, -6, -5, -4, -3, -1, 0, 0, 1, 3, 3, 4,
5, 5, 6, 6, 7, 7, 7, 7, 8, 9, 8, 9, 8, 8, 9, 9, 9, 9, 9, 8, 10, 10, 9, 9, 10,
11, 12, 11, 12, 13, 13, 15, 15, 15, 16, 16, 17, 19, 19, 19, 21, 21, 22, 22, 22,
23, 23, 24, 23, 23, 23, 24, 23, 22, 21, 21, 19, 19, 18, 16, 15, 13, 11, 10, 7,
6, 3, 1, -1, -4, -6, -7, -10, -11, -13, -16, -18, -19, -21, -23, -24, -26, -27,
-28, -29, -30, -30, -30, -31, -30, -30, -29, -29, -28, -27, -27, -25, -23, -21,
-19, -17, -15, -13, -10, -8, -5, -1, };