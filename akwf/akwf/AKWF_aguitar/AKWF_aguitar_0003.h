#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 5, 6, 8, 10, 13, 15, 17, 20, 22,
26, 27, 31, 33, 36, 37, 41, 44, 47, 49, 53, 56, 58, 61, 64, 67, 69, 72, 75, 78,
80, 82, 86, 87, 91, 93, 95, 96, 99, 101, 102, 105, 106, 108, 110, 111, 112, 113,
114, 115, 117, 117, 118, 118, 119, 119, 120, 119, 120, 120, 119, 119, 118, 117,
117, 117, 116, 116, 115, 114, 114, 113, 112, 112, 112, 111, 110, 108, 108, 108,
106, 106, 105, 105, 104, 103, 102, 102, 100, 99, 99, 97, 96, 95, 94, 93, 92, 90,
89, 88, 86, 85, 83, 82, 80, 79, 76, 75, 73, 72, 70, 68, 67, 64, 62, 60, 58, 57,
54, 53, 50, 50, 47, 46, 44, 42, 41, 39, 37, 35, 34, 32, 31, 30, 27, 26, 25, 24,
22, 19, 19, 17, 15, 15, 13, 11, 10, 8, 6, 6, 4, 4, 2, 1, -1, -2, -4, -4, -6, -6,
-8, -9, -10, -12, -12, -13, -14, -15, -16, -17, -17, -18, -19, -20, -20, -21,
-20, -21, -22, -22, -22, -22, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23,
-22, -22, -23, -22, -23, -22, -21, -21, -21, -20, -20, -21, -20, -20, -20, -19,
-19, -20, -19, -19, -19, -19, -20, -19, -20, -19, -20, -19, -19, -20, -20, -19,
-19, -20, -20, -20, -20, -21, -20, -20, -20, -20, -19, -20, -19, -20, -21, -20,
-20, -20, -21, -21, -21, -21, -22, -22, -22, -22, -23, -23, -24, -25, -25, -26,
-27, -27, -29, -29, -30, -32, -32, -33, -34, -35, -36, -38, -37, -39, -39, -40,
-41, -42, -43, -44, -44, -45, -45, -46, -47, -47, -46, -47, -48, -47, -47, -47,
-48, -48, -48, -48, -48, -47, -48, -48, -48, -47, -48, -47, -47, -47, -48, -46,
-47, -47, -47, -46, -47, -47, -48, -47, -47, -48, -48, -48, -47, -48, -49, -50,
-50, -49, -50, -51, -51, -51, -51, -51, -53, -52, -53, -53, -54, -54, -54, -55,
-55, -55, -56, -56, -57, -57, -56, -57, -57, -58, -57, -58, -57, -57, -57, -57,
-56, -57, -55, -56, -56, -56, -55, -54, -53, -53, -52, -51, -51, -49, -48, -48,
-47, -45, -44, -43, -43, -40, -40, -39, -37, -36, -35, -33, -32, -31, -31, -29,
-28, -26, -25, -25, -23, -23, -21, -21, -20, -19, -19, -17, -18, -17, -17, -17,
-16, -16, -16, -17, -17, -17, -18, -18, -19, -20, -20, -22, -22, -24, -25, -26,
-27, -27, -29, -31, -32, -33, -34, -35, -36, -37, -39, -39, -40, -40, -41, -41,
-41, -42, -42, -42, -43, -41, -42, -40, -41, -40, -39, -38, -38, -37, -36, -35,
-34, -33, -32, -31, -30, -29, -28, -27, -26, -25, -24, -24, -22, -23, -21, -20,
-19, -20, -18, -18, -17, -17, -16, -17, -17, -17, -16, -16, -16, -15, -15, -15,
-15, -15, -15, -15, -15, -16, -15, -15, -15, -15, -14, -15, -15, -15, -14, -15,
-14, -13, -13, -12, -12, -10, -10, -9, -8, -7, -6, -5, -2, -2, 0, };