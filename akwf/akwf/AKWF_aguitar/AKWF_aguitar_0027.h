#define DATA_LENGTH 512
#define DATA AKWF_aguitar_0027

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 6, 8, 12, 15, 17, 21, 24, 27,
30, 33, 37, 41, 44, 47, 51, 54, 58, 61, 64, 68, 70, 73, 77, 80, 82, 87, 88, 91,
94, 96, 100, 101, 104, 106, 108, 110, 111, 113, 113, 115, 117, 117, 118, 118,
119, 119, 119, 119, 119, 118, 118, 116, 116, 114, 113, 112, 110, 108, 107, 105,
103, 101, 99, 96, 94, 91, 88, 86, 83, 81, 77, 74, 72, 69, 67, 64, 60, 58, 55,
53, 50, 46, 43, 42, 39, 36, 33, 31, 29, 26, 25, 23, 19, 18, 16, 15, 13, 11, 9,
8, 6, 5, 4, 3, 2, 1, -1, 0, -1, -1, -1, -1, -1, -1, -1, 0, 0, 2, 2, 4, 4, 6, 6,
8, 9, 10, 13, 14, 15, 16, 19, 20, 22, 23, 25, 25, 26, 28, 30, 31, 31, 33, 33,
34, 35, 36, 35, 36, 36, 37, 37, 36, 37, 36, 35, 35, 35, 33, 34, 32, 32, 31, 29,
28, 27, 26, 24, 22, 21, 20, 17, 17, 16, 14, 13, 10, 8, 7, 5, 4, 2, 0, -3, -5,
-7, -9, -11, -14, -15, -17, -20, -22, -24, -25, -28, -29, -32, -34, -36, -38,
-40, -42, -44, -46, -47, -49, -50, -52, -52, -53, -55, -55, -56, -57, -57, -57,
-58, -58, -58, -58, -58, -57, -57, -56, -56, -55, -54, -53, -52, -51, -50, -48,
-48, -45, -44, -44, -42, -41, -39, -38, -36, -35, -33, -32, -31, -29, -28, -26,
-24, -23, -21, -21, -18, -17, -15, -14, -12, -11, -9, -8, -6, -4, -2, 0, 2, 3,
4, 7, 8, 11, 12, 14, 15, 17, 19, 21, 22, 23, 25, 26, 28, 28, 30, 29, 30, 31, 32,
31, 33, 33, 32, 33, 33, 31, 32, 30, 29, 29, 28, 26, 25, 24, 23, 21, 19, 18, 17,
15, 12, 12, 10, 8, 6, 4, 2, 0, -1, -4, -5, -7, -9, -11, -12, -15, -16, -19, -20,
-22, -25, -26, -28, -31, -32, -35, -37, -38, -40, -43, -44, -46, -48, -49, -52,
-54, -57, -57, -60, -61, -63, -65, -66, -67, -68, -69, -71, -71, -72, -73, -73,
-74, -74, -74, -74, -73, -74, -73, -73, -71, -71, -70, -69, -68, -66, -65, -63,
-63, -62, -60, -57, -56, -55, -53, -52, -50, -49, -47, -45, -45, -43, -41, -40,
-39, -38, -36, -34, -33, -32, -31, -30, -29, -27, -27, -26, -24, -24, -23, -22,
-22, -20, -19, -19, -18, -18, -16, -16, -14, -13, -14, -13, -12, -12, -10, -11,
-11, -10, -9, -9, -10, -9, -10, -10, -9, -10, -10, -10, -10, -11, -11, -13, -13,
-13, -14, -15, -17, -17, -18, -19, -21, -22, -22, -23, -25, -26, -27, -27, -29,
-30, -32, -32, -34, -34, -35, -35, -36, -38, -39, -39, -40, -40, -40, -41, -41,
-41, -42, -42, -42, -42, -43, -42, -42, -42, -42, -41, -40, -40, -40, -39, -38,
-38, -36, -35, -35, -34, -33, -31, -29, -28, -26, -26, -24, -21, -20, -18, -16,
-13, -11, -9, -7, -4, -1, };