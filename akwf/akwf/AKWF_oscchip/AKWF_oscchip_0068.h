#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0068

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 15, 14, 15, 14, 14, 15, 15, 14,
15, 15, 15, 15, 14, 14, 14, 17, 16, 17, 16, 16, 16, 16, 16, 17, 16, 16, 16, 16,
17, 16, 21, 30, 31, 31, 30, 31, 30, 30, 31, 31, 31, 30, 30, 30, 31, 30, 34, 49,
52, 51, 51, 51, 51, 51, 52, 51, 51, 52, 51, 51, 51, 51, 52, 61, 63, 63, 63, 63,
64, 63, 63, 64, 64, 63, 64, 64, 64, 63, 64, 67, 66, 66, 68, 67, 67, 67, 67, 67,
67, 66, 67, 67, 67, 66, 72, 91, 95, 95, 95, 94, 95, 94, 95, 95, 95, 94, 94, 94,
95, 95, 93, 90, 91, 91, 91, 91, 91, 91, 91, 91, 91, 91, 91, 91, 91, 92, 87, 80,
80, 81, 80, 80, 80, 81, 80, 81, 81, 81, 80, 80, 81, 80, 78, 68, 65, 66, 66, 66,
66, 66, 66, 67, 66, 66, 67, 66, 66, 67, 59, 51, 53, 52, 52, 52, 52, 52, 53, 52,
52, 52, 51, 52, 52, 53, 47, 39, 38, 38, 38, 38, 38, 38, 38, 39, 37, 38, 38, 38,
38, 39, 35, 22, 20, 21, 20, 20, 20, 21, 21, 21, 20, 20, 21, 20, 20, 21, 9, -4,
-2, -2, -2, -3, -3, -3, -3, -3, -2, -2, -2, -1, -3, -1, -9, -20, -19, -20, -20,
-20, -19, -20, -20, -20, -20, -20, -21, -20, -20, -19, -21, -30, -31, -31, -31,
-30, -31, -31, -31, -31, -30, -30, -31, -30, -31, -29, -39, -49, -48, -48, -47,
-48, -48, -48, -48, -48, -47, -47, -48, -47, -49, -47, -50, -55, -55, -55, -54,
-55, -55, -54, -56, -54, -55, -55, -55, -54, -55, -53, -60, -85, -90, -89, -90,
-89, -90, -89, -90, -89, -90, -89, -90, -89, -90, -89, -104, -119, -117, -118,
-117, -117, -118, -117, -118, -117, -117, -117, -116, -117, -115, -120, -99,
-65, -65, -64, -64, -65, -64, -64, -65, -64, -64, -64, -65, -64, -64, -65, -62,
-50, -46, -48, -47, -47, -48, -47, -48, -47, -47, -47, -47, -47, -47, -48, -38,
-29, -30, -29, -29, -29, -29, -30, -29, -29, -30, -30, -29, -30, -29, -30, -20,
-2, -1, -1, -2, -1, -2, -2, -1, -2, -2, -2, -1, -3, -1, -2, 3, 22, 26, 24, 25,
25, 25, 25, 26, 25, 24, 24, 25, 25, 25, 25, 29, 32, 32, 32, 32, 32, 32, 32, 32,
32, 32, 31, 31, 32, 32, 30, 40, 55, 56, 56, 56, 56, 57, 56, 57, 56, 57, 55, 57,
55, 57, 56, 68, 72, 72, 72, 72, 71, 71, 71, 72, 72, 71, 73, 70, 74, 69, 76, -24,
-124, -114, -118, -116, -117, -116, -118, -117, -118, -118, -117, -117, -117,
-117, -116, -117, -117, -118, -116, -118, -116, -117, -116, -117, -117, -117,
-116, -117, -116, -116, -116, -116, -116, -116, -117, -117, -117, -117, -117,
-116, -117, -116, -117, -116, -118, -115, -120, -64, -9, -15, -12, -15, -13,
-14, -14, -13, -13, -14, -13, -13, -13, -14, -15, -5, };