#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0085

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 12, 13, 13, 12, 13, 13, 13, 13, 13,
13, 12, 13, 13, 13, 12, 25, 37, 36, 36, 36, 37, 36, 36, 36, 36, 36, 36, 37, 37,
37, 36, 42, 52, 52, 53, 52, 53, 52, 51, 52, 51, 52, 52, 52, 52, 53, 53, 83, 96,
95, 95, 95, 95, 95, 97, 94, 96, 94, 96, 93, 98, 91, 100, -12, -124, -111, -118,
-113, -117, -115, -116, -115, -116, -115, -116, -115, -117, -113, -119, -77, -5,
-3, -2, -4, -3, -4, -3, -3, -4, -3, -4, -3, -3, -3, -3, -3, -3, -3, -3, -2, -3,
-3, -3, -3, -3, -2, -3, -3, -2, -3, -3, -3, -3, -3, -3, -4, -3, -3, -3, -3, -4,
-3, -3, -4, -3, -3, -4, -3, -3, -3, -3, -3, -3, -3, -4, -4, -3, -3, -3, -3, -3,
-4, -2, -2, -3, -3, -3, -3, -3, -3, -3, -2, -3, -3, -4, -3, -4, -4, -3, -2, -3,
-3, -3, -3, -2, -4, -3, -3, -3, -3, -4, -3, -3, -3, -3, -3, -2, -2, -3, -3, -3,
-4, -3, -3, -3, -4, -4, -3, -4, -3, -3, -3, -4, -4, -3, -4, -3, -3, -3, -3, -3,
-2, -2, -4, -3, -3, -4, -4, -3, -2, -4, -3, -3, -4, -3, -3, -4, -3, -4, -3, -3,
-3, -3, -3, -3, -3, -4, -4, -3, -3, -3, -3, -3, -3, -3, -3, -4, -3, -2, -2, -3,
-3, -3, -3, -3, -3, -3, -3, -3, -2, -4, -3, -4, -3, -3, -4, -3, -3, -4, -3, -3,
-3, -4, -3, -3, -4, -4, -3, -3, -4, -2, -3, -3, -2, -2, -3, -3, -3, -3, -3, -3,
-3, -3, -3, -2, -3, -3, -3, -3, -3, -3, -4, -3, -3, -4, -3, -3, -3, -3, -3, -3,
-3, -2, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -4, -3, -3, -3, -3, -3, -3, -3,
-3, -2, -3, -3, -3, -2, -3, -4, -3, -3, -3, -3, -3, -3, -4, -4, -4, -2, -3, -3,
-3, -3, -4, -3, -3, -3, -2, -3, -4, -3, -3, -4, -3, -3, -3, -3, -3, -3, -3, -3,
-3, -4, -3, -3, -3, -3, -2, -3, -3, -4, -3, -3, -3, -3, -3, -3, -2, -3, -4, -3,
-4, -3, -4, -3, -3, -3, -4, -3, -3, -3, -2, -3, -3, -3, -3, -3, -4, -3, -3, -4,
-4, -3, -4, -3, -3, -3, -3, -3, -2, -4, -3, -2, -3, -4, -3, -3, -4, -3, -3, -4,
-2, -4, -3, -3, -3, -3, -2, -2, -3, -3, -3, -4, -4, -3, -3, -3, -3, -3, -3, -3,
-3, -3, -3, -3, -2, -3, -3, -2, -2, -3, -3, -3, -4, -2, -3, -3, -3, -3, -3, -3,
-3, -4, -3, -3, -3, -3, -3, -3, -3, -4, -4, -3, -3, -4, -4, -3, -3, -3, -2, -1,
-1, -1, -2, -1, -2, 0, -1, -1, -1, 0, -2, -1, -1, -1, -1, -1, -1, -2, -1, -1,
-2, -1, -1, -1, -1, -1, -1, 0, -1, -1, };