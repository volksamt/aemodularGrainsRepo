#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0148

const PROGMEM int8_t DATA[DATA_LENGTH] = {79, 120, 107, 114, 108, 113, 110, 113,
110, 112, 111, 112, 110, 111, 111, 111, 111, 110, 111, 111, 111, 111, 110, 110,
111, 111, 111, 110, 111, 111, 111, 111, 112, 111, 110, 111, 111, 110, 111, 111,
111, 111, 111, 111, 111, 110, 111, 111, 111, 111, 111, 110, 110, 111, 111, 111,
111, 111, 111, 111, 110, 111, 111, 111, 111, 111, 111, 112, 110, 111, 111, 110,
110, 111, 111, 111, 111, 111, 110, 111, 111, 110, 110, 111, 111, 111, 110, 110,
111, 110, 110, 111, 111, 110, 111, 111, 111, 111, 111, 111, 110, 111, 111, 111,
110, 111, 111, 111, 111, 111, 110, 111, 110, 111, 111, 111, 111, 112, 110, 111,
111, 111, 111, 111, 110, 111, 111, 110, 111, 110, 111, 111, 111, 110, 111, 111,
111, 111, 111, 111, 111, 111, 111, 112, 111, 110, 111, 111, 110, 111, 111, 111,
111, 111, 111, 111, 111, 111, 110, 111, 111, 111, 111, 110, 111, 111, 111, 111,
111, 111, 110, 111, 111, 111, 111, 111, 111, 111, 110, 111, 111, 111, 111, 110,
110, 111, 111, 110, 111, 111, 111, 111, 110, 110, 111, 111, 111, 111, 110, 111,
111, 110, 111, 111, 111, 111, 111, 111, 111, 110, 110, 111, 110, 111, 111, 111,
111, 111, 110, 110, 111, 111, 112, 111, 111, 111, 111, 111, 110, 111, 111, 110,
111, 111, 111, 111, 111, 111, 111, 104, 98, 98, 98, 98, 97, 98, 98, 97, 97, 98,
98, 98, 98, 98, 98, 92, 82, 80, 80, 80, 81, 80, 80, 80, 81, 80, 80, 80, 80, 81,
80, 78, 71, 69, 70, 70, 70, 70, 70, 69, 69, 70, 70, 69, 69, 70, 69, 57, 48, 49,
49, 48, 49, 50, 49, 49, 49, 49, 48, 48, 49, 49, 49, 42, 35, 35, 35, 35, 35, 35,
35, 36, 34, 36, 35, 35, 35, 35, 35, 31, 23, 22, 23, 22, 23, 23, 23, 22, 23, 23,
22, 23, 22, 22, 24, 20, 14, 11, 12, 12, 13, 12, 12, 12, 12, 12, 12, 12, 12, 13,
12, 8, 5, 6, 5, 5, 6, 6, 5, 5, 5, 5, 5, 5, 5, 6, 5, 1, -3, -4, -4, -4, -4, -4,
-4, -4, -3, -4, -3, -4, -4, -4, -2, -41, -106, -114, -111, -113, -111, -112,
-112, -113, -112, -112, -112, -112, -112, -112, -112, -112, -111, -111, -112,
-111, -112, -111, -112, -112, -111, -112, -112, -112, -112, -112, -112, -111,
-112, -112, -112, -112, -111, -112, -111, -112, -111, -112, -112, -112, -112,
-112, -111, -111, -112, -112, -112, -112, -111, -112, -112, -112, -111, -112,
-111, -112, -112, -112, -113, -111, -112, -112, -112, -112, -112, -112, -111,
-111, -112, -112, -112, -111, -112, -112, -112, -112, -112, -112, -111, -112,
-112, -112, -111, -112, -111, -111, -112, -112, -112, -112, -111, -111, -112,
-112, -112, -112, -112, -112, -111, -112, -112, -112, -111, -112, -112, -112,
-112, -112, -111, -113, -112, -112, -111, -112, -111, -113, -111, -113, -111,
-112, -112, -111, -112, -35, };