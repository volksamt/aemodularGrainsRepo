#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0102

const PROGMEM int8_t DATA[DATA_LENGTH] = {15, 59, 64, 62, 64, 63, 63, 63, 64,
62, 63, 62, 64, 63, 63, 63, 64, 67, 68, 68, 69, 68, 68, 68, 69, 68, 68, 68, 69,
69, 69, 69, 69, 76, 79, 79, 79, 79, 79, 79, 79, 79, 79, 79, 79, 80, 79, 79, 80,
81, 81, 82, 81, 81, 81, 81, 81, 81, 81, 81, 81, 81, 81, 81, 81, 82, 83, 83, 83,
82, 83, 83, 82, 83, 82, 82, 82, 82, 83, 82, 83, 85, 87, 86, 86, 86, 87, 86, 86,
86, 86, 85, 86, 86, 86, 86, 86, 89, 87, 88, 89, 88, 87, 88, 88, 88, 87, 88, 87,
87, 87, 88, 89, 91, 91, 91, 91, 91, 91, 91, 91, 92, 91, 91, 92, 90, 91, 91, 92,
91, 91, 91, 91, 92, 92, 91, 91, 92, 91, 90, 92, 91, 91, 91, 92, 91, 91, 92, 92,
91, 91, 91, 91, 91, 91, 91, 92, 91, 91, 91, 91, 94, 94, 94, 94, 95, 94, 94, 95,
94, 95, 94, 94, 95, 95, 95, 95, 97, 97, 98, 98, 98, 97, 98, 99, 98, 98, 98, 98,
98, 98, 97, 99, 105, 105, 105, 105, 104, 105, 105, 105, 105, 106, 106, 106, 105,
106, 106, 104, 102, 101, 101, 102, 101, 102, 102, 102, 101, 101, 101, 101, 101,
101, 101, 102, 105, 104, 105, 104, 105, 104, 106, 104, 106, 103, 106, 103, 108,
100, 112, 49, -99, -113, -111, -113, -111, -112, -111, -112, -111, -112, -111,
-112, -111, -112, -111, -112, -111, -113, -111, -113, -111, -113, -111, -112,
-112, -112, -113, -111, -112, -111, -112, -110, -109, -108, -108, -108, -108,
-108, -108, -107, -108, -108, -108, -108, -108, -108, -108, -108, -108, -108,
-107, -108, -108, -108, -108, -108, -108, -109, -108, -107, -108, -107, -108,
-107, -105, -104, -104, -104, -104, -104, -104, -104, -104, -104, -104, -104,
-104, -103, -104, -104, -104, -103, -104, -103, -104, -103, -104, -104, -104,
-103, -103, -104, -103, -103, -103, -103, -102, -102, -102, -102, -102, -101,
-101, -102, -102, -102, -101, -102, -101, -101, -101, -101, -101, -102, -102,
-102, -102, -102, -101, -101, -102, -101, -101, -101, -102, -102, -102, -99,
-97, -98, -97, -97, -98, -98, -97, -97, -97, -98, -97, -97, -97, -98, -97, -97,
-99, -99, -99, -100, -99, -99, -99, -100, -99, -99, -98, -100, -100, -99, -99,
-99, -97, -95, -95, -95, -96, -95, -95, -96, -95, -95, -95, -96, -95, -94, -95,
-93, -89, -91, -90, -90, -90, -89, -89, -89, -90, -89, -90, -89, -89, -90, -89,
-88, -87, -88, -88, -88, -87, -87, -88, -87, -88, -87, -87, -87, -89, -86, -89,
-78, -17, -1, -4, -2, -3, -3, -4, -3, -3, -2, -4, -2, -3, -3, -4, -2, -1, -1,
-2, -1, -1, -1, -1, -1, -1, -1, -1, 0, -1, -1, -2, -1, -1, -1, 0, -1, -1, -1,
-2, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1,
-2, -1, -1, -2, -2, };