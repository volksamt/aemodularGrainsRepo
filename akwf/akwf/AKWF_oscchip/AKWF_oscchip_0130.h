#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0130

const PROGMEM int8_t DATA[DATA_LENGTH] = {79, 117, 104, 111, 106, 110, 108, 109,
107, 109, 107, 110, 108, 108, 109, 107, 97, 93, 95, 94, 94, 94, 94, 94, 94, 94,
94, 94, 95, 94, 94, 83, 75, 75, 75, 75, 75, 75, 75, 74, 75, 75, 75, 75, 75, 74,
75, 67, 56, 56, 56, 55, 56, 55, 55, 55, 56, 55, 56, 56, 55, 55, 56, 52, 45, 44,
44, 43, 43, 44, 44, 43, 43, 44, 44, 44, 44, 44, 43, 38, 18, 10, 12, 11, 12, 12,
12, 12, 12, 12, 12, 12, 13, 12, 12, 2, -7, -8, -8, -7, -7, -7, -7, -7, -7, -7,
-7, -8, -7, -8, -8, -13, -20, -20, -20, -19, -19, -20, -19, -19, -19, -19, -19,
-19, -21, -19, -20, -7, 20, 26, 24, 25, 24, 25, 25, 25, 24, 25, 25, 24, 24, 24,
23, 30, 52, 59, 58, 59, 58, 57, 58, 58, 58, 58, 58, 59, 58, 58, 59, 82, 102,
101, 103, 101, 101, 101, 102, 102, 102, 102, 102, 101, 102, 102, 101, 109, 119,
119, 118, 118, 118, 119, 119, 118, 119, 118, 118, 119, 119, 118, 119, 111, 96,
94, 95, 94, 94, 94, 94, 94, 94, 94, 95, 94, 94, 94, 95, 86, 55, 44, 46, 45, 46,
46, 45, 45, 47, 46, 46, 46, 45, 46, 44, 24, 8, 9, 10, 10, 9, 10, 9, 10, 11, 10,
9, 10, 9, 9, 9, 17, 27, 27, 27, 27, 26, 26, 26, 26, 27, 27, 27, 27, 27, 26, 26,
27, 27, 27, 27, 27, 27, 27, 26, 27, 27, 27, 26, 26, 27, 27, 26, 26, 20, 19, 19,
20, 19, 19, 19, 19, 19, 19, 19, 19, 20, 19, 19, 10, 4, 5, 4, 5, 5, 5, 5, 5, 5,
5, 5, 4, 6, 4, 4, 1, -3, -2, -2, -3, -2, -2, -3, -2, -3, -2, -2, -2, -3, -2, -2,
-6, -9, -10, -9, -10, -10, -9, -10, -9, -9, -10, -10, -10, -10, -10, -9, -12,
-18, -20, -19, -19, -19, -19, -19, -20, -20, -20, -19, -19, -20, -19, -19, -21,
-21, -22, -23, -22, -21, -22, -22, -22, -22, -22, -22, -21, -21, -22, -22, -23,
-25, -24, -24, -24, -24, -24, -24, -24, -24, -25, -25, -24, -25, -25, -24, -24,
-22, -21, -22, -21, -22, -22, -22, -22, -23, -21, -22, -21, -22, -22, -22, -16,
-2, 1, 0, 1, 0, 1, 0, 0, 0, 0, -1, 0, 1, 0, 1, 8, 12, 12, 12, 12, 12, 12, 11,
12, 13, 12, 12, 13, 11, 12, 12, 13, 11, 12, 12, 12, 12, 12, 13, 12, 12, 12, 12,
12, 12, 12, 13, 9, 5, 5, 5, 4, 5, 5, 5, 4, 5, 5, 5, 5, 5, 6, 4, 2, -3, -5, -5,
-4, -5, -4, -4, -4, -5, -5, -5, -5, -6, -4, -7, -16, -23, -21, -22, -21, -22,
-23, -22, -22, -22, -22, -21, -22, -22, -22, -22, -62, -98, -97, -97, -97, -96,
-97, -96, -98, -96, -97, -97, -97, -97, -97, -95, -27, };