#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0084

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 23, 27, 26, 28, 27, 27, 27, 26, 27,
27, 27, 27, 27, 27, 27, 34, 43, 43, 43, 43, 42, 42, 42, 42, 42, 42, 42, 43, 43,
43, 42, 47, 58, 59, 58, 58, 58, 58, 58, 59, 58, 58, 58, 58, 58, 59, 58, 59, 64,
65, 65, 65, 65, 65, 65, 64, 65, 65, 64, 65, 64, 64, 65, 69, 74, 73, 73, 73, 73,
73, 73, 74, 74, 74, 73, 74, 73, 74, 73, 75, 80, 80, 80, 80, 80, 80, 80, 81, 80,
80, 80, 80, 80, 80, 79, 82, 90, 91, 90, 91, 92, 91, 91, 91, 91, 91, 90, 92, 91,
91, 91, 95, 98, 98, 98, 97, 98, 98, 97, 97, 98, 98, 97, 98, 98, 97, 97, 100,
105, 105, 103, 104, 105, 105, 104, 104, 103, 104, 104, 104, 104, 104, 104, 105,
109, 110, 110, 110, 111, 111, 110, 110, 111, 110, 110, 111, 110, 111, 110, 112,
113, 113, 113, 113, 113, 113, 112, 112, 113, 113, 112, 112, 113, 113, 113, 113,
114, 115, 115, 115, 115, 115, 114, 115, 114, 114, 114, 115, 114, 114, 114, 116,
118, 119, 118, 119, 119, 118, 119, 118, 119, 118, 120, 117, 121, 115, 123, 27,
-90, -81, -87, -84, -85, -84, -85, -84, -85, -84, -84, -85, -84, -85, -84, -83,
-80, -80, -80, -80, -79, -81, -81, -81, -80, -80, -81, -80, -80, -80, -81, -83,
-85, -85, -85, -84, -85, -84, -85, -84, -85, -84, -85, -84, -85, -85, -85, -81,
-77, -77, -77, -77, -78, -78, -78, -78, -78, -78, -77, -78, -78, -78, -76, -80,
-84, -84, -84, -84, -84, -84, -84, -85, -85, -84, -84, -84, -84, -85, -84, -78,
-74, -75, -76, -75, -74, -75, -75, -75, -74, -75, -76, -75, -75, -75, -75, -74,
-73, -73, -72, -72, -73, -72, -73, -73, -72, -73, -72, -73, -73, -73, -72, -75,
-81, -81, -81, -81, -82, -82, -81, -81, -81, -82, -81, -82, -82, -82, -82, -74,
-70, -71, -70, -71, -70, -71, -70, -69, -70, -70, -69, -69, -71, -70, -71, -64,
-57, -57, -56, -56, -57, -57, -56, -57, -57, -56, -56, -57, -55, -57, -56, -63,
-78, -79, -78, -78, -79, -78, -79, -79, -79, -79, -78, -79, -78, -79, -78, -62,
-51, -52, -51, -52, -52, -52, -52, -52, -52, -52, -53, -53, -52, -52, -51, -64,
-79, -78, -79, -79, -79, -79, -79, -78, -78, -77, -79, -78, -79, -78, -79, -67,
-40, -38, -38, -38, -38, -38, -38, -38, -38, -38, -39, -37, -38, -38, -38, -35,
-33, -34, -34, -33, -34, -33, -33, -33, -33, -34, -33, -34, -34, -33, -34, -27,
-19, -21, -20, -20, -20, -20, -20, -21, -20, -20, -20, -20, -20, -19, -20, -19,
-16, -16, -16, -16, -16, -15, -15, -16, -16, -16, -15, -15, -15, -16, -15, -12,
-11, -11, -11, -12, -12, -12, -11, -10, -11, -11, -11, -11, -10, -11, -12, -6,
0, 0, 0, 0, 1, 1, 0, 1, 0, 0, 0, -1, 0, 0, 0, };