#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0064

const PROGMEM int8_t DATA[DATA_LENGTH] = {65, 121, 108, 112, 110, 112, 111, 111,
110, 111, 111, 111, 111, 110, 113, 98, 36, -3, 0, 0, 0, -1, 0, 1, 0, 0, 1, -1,
0, 1, 1, 0, 1, 1, 1, 0, 0, 1, 0, 1, -1, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, -2, -2, -2, -1, -1, -2, -2, -1, -2, -1, -2,
-1, -2, -2, -1, -2, -1, -2, -1, -1, -1, -2, -1, -2, -2, -2, -1, -2, -2, -1, -2,
-2, -3, -2, -2, -1, -1, -1, -2, -2, -2, -2, -1, -1, -2, -2, -1, -2, -1, -1, -2,
-3, -2, -2, -2, -3, -2, -1, -2, -2, -1, -2, -1, -2, -2, -2, -2, -2, -2, -2, -2,
-2, -2, -2, -2, -2, -2, -2, -2, -2, -1, -1, -2, -2, -1, -1, -2, -2, -2, -2, -1,
-2, -2, -1, -2, -1, -2, -1, -2, -1, -2, -2, -1, -2, -2, -2, -1, -2, -2, -2, -2,
-2, -2, -2, -2, -2, -1, -1, -1, -1, -2, -2, -1, -2, -2, -2, -2, -1, -2, -1, -2,
-2, -2, -2, -1, -1, -1, -2, -1, -1, -2, -2, -2, -2, -2, -2, -2, -2, -2, -1, -2,
-1, -2, -1, -2, -1, -2, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0,
0, 0, 0, 1, 1, 1, 0, 0, 1, 0, 1, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1, 1, -1,
0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, -1, -1, 1, 0, 1, 0, 0, -1, 0, 0, 1, 2, 3, 2, 2,
2, 2, 2, 2, 2, 1, 3, 2, 1, 2, 3, 2, 2, 2, 1, 2, 3, 2, 1, 2, 2, 2, 2, 2, 2, 1, 2,
2, 2, 1, 1, 2, 2, 2, 2, 2, 1, 2, 2, 2, 1, 1, 1, 2, 1, 1, 2, 1, 2, 2, 1, 2, 2, 2,
2, 2, 2, 2, 2, 2, 2, 2, 1, 2, 1, 3, 2, 2, 1, 1, 2, 2, 3, 2, 2, 2, 2, 2, 2, 2, 2,
2, 1, 2, 2, 1, 2, 2, 2, 1, 2, 2, 2, 1, 2, 2, 2, 2, 1, 2, 3, 2, 2, 1, 2, 2, 1, 1,
2, 2, 2, 2, 2, 1, 2, 1, 2, 1, 1, 1, 1, 2, 3, 2, 1, 2, 2, 2, 2, 3, 2, 2, 2, 2, 2,
2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 2, 1, 1, 1, 1, 2, 2, 2, 2, 1, 1, 2, 1,
2, 2, 1, 2, 2, 1, 2, 1, 1, 1, 1, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 1,
1, 0, 1, 1, -1, 0, 1, 1, 0, 0, 1, -1, 0, 1, -5, -60, -115, -117, -115, -115,
-115, -115, -115, -116, -114, -115, -115, -115, -115, -116, -114, -41, };