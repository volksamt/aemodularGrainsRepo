#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0066

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 2, 3, 2, 3, 3, 3, 3, 3, 3, 2, 2,
2, 2, 3, 4, 5, 5, 5, 4, 5, 5, 5, 4, 5, 4, 4, 5, 5, 4, 5, 5, 5, 5, 5, 5, 5, 4, 5,
5, 5, 5, 5, 5, 4, 5, 4, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 8, 7, 7, 7, 8, 8, 14, 19,
19, 19, 18, 18, 18, 19, 18, 19, 18, 18, 18, 19, 18, 19, 18, 18, 18, 19, 18, 18,
18, 18, 18, 18, 19, 19, 18, 17, 19, 18, 22, 31, 31, 32, 32, 31, 32, 32, 32, 32,
31, 32, 32, 32, 32, 32, 40, 46, 46, 45, 45, 45, 45, 45, 45, 45, 45, 45, 46, 45,
46, 45, 59, 74, 72, 72, 71, 72, 73, 72, 72, 72, 72, 72, 72, 71, 73, 71, 83, 103,
104, 104, 104, 104, 104, 103, 104, 104, 104, 104, 103, 104, 104, 101, 37, 1, 9,
5, 7, 6, 6, 6, 8, 7, 6, 7, 7, 6, 6, 7, 9, 12, 11, 12, 10, 11, 10, 11, 11, 11,
10, 12, 10, 11, 12, 12, 15, 16, 15, 15, 15, 15, 15, 16, 15, 15, 15, 15, 16, 16,
15, 16, 14, 13, 13, 13, 13, 13, 13, 13, 12, 13, 12, 13, 14, 13, 13, 14, 12, 12,
10, 11, 11, 12, 11, 11, 10, 10, 12, 11, 11, 11, 11, 11, 11, 11, 12, 10, 11, 11,
11, 11, 11, 10, 11, 11, 11, 11, 11, 11, 11, 14, 13, 13, 13, 13, 12, 12, 14, 13,
12, 13, 13, 13, 13, 12, 21, 29, 28, 30, 29, 29, 28, 29, 28, 30, 28, 29, 28, 29,
28, 31, 46, 50, 49, 49, 49, 49, 49, 50, 49, 49, 50, 48, 49, 48, 50, 50, 92, 116,
111, 113, 112, 112, 112, 113, 111, 113, 111, 113, 110, 114, 110, 116, 18, -81,
-70, -76, -71, -74, -73, -74, -73, -73, -73, -73, -73, -72, -73, -72, -64, -61,
-63, -62, -61, -61, -63, -61, -62, -61, -62, -62, -62, -61, -62, -60, -40, -28,
-31, -30, -30, -30, -31, -29, -30, -30, -30, -30, -30, -30, -30, -31, -25, -20,
-21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -20, -18,
-19, -19, -19, -19, -18, -19, -18, -19, -19, -19, -18, -19, -18, -19, -18, -17,
-16, -16, -16, -17, -16, -16, -16, -16, -16, -15, -18, -16, -19, -15, -67, -119,
-114, -116, -114, -116, -115, -116, -115, -115, -115, -115, -116, -115, -115,
-112, -103, -99, -100, -99, -101, -99, -100, -98, -99, -99, -99, -100, -100,
-99, -100, -98, -84, -76, -78, -76, -77, -76, -76, -77, -77, -77, -76, -77, -77,
-78, -77, -78, -62, -48, -50, -49, -50, -49, -50, -49, -50, -49, -50, -49, -50,
-49, -50, -46, -27, -22, -22, -22, -23, -22, -22, -22, -22, -23, -23, -21, -22,
-21, -23, -22, -9, -3, -5, -5, -4, -4, -5, -4, -5, -4, -5, -4, -4, -4, -4, -2,
};