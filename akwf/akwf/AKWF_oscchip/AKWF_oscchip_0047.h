#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0047

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 7, 7, 8, 8, 8, 6, 8, 7, 8, 7, 8, 7,
8, 8, 8, 7, 8, 7, 7, 7, 8, 8, 7, 8, 8, 7, 7, 8, 8, 8, 7, 8, 8, 7, 8, 7, 8, 8, 7,
8, 8, 7, 7, 8, 7, 7, 16, 33, 38, 37, 37, 37, 37, 38, 37, 37, 37, 37, 38, 38, 37,
33, 16, 6, 7, 8, 8, 7, 7, 7, 7, 7, 7, 8, 7, 7, 7, 7, 8, 7, 7, 8, 7, 7, 8, 8, 7,
7, 8, 7, 8, 7, 7, 8, 8, 7, 7, 7, 7, 7, 7, 8, 7, 8, 8, 7, 7, 8, 7, 7, 7, 7, 7, 7,
7, 7, 7, 8, 6, 7, 8, 7, 7, 8, 8, 8, 7, 8, 8, 7, 7, 7, 8, 7, 7, 7, 8, 7, 6, 7, 6,
17, 75, 118, 118, 116, 116, 115, 117, 115, 116, 117, 116, 117, 116, 116, 117,
113, 63, 8, 2, 5, 5, 4, 4, 5, 4, 4, 4, 4, 5, 4, 5, 4, 4, 5, 4, 5, 5, 5, 4, 4, 4,
5, 4, 4, 5, 4, 6, -9, -50, -70, -67, -68, -68, -68, -68, -67, -68, -68, -68,
-68, -67, -67, -68, -62, -24, 4, 3, 1, 2, 1, 2, 2, 2, 2, 2, 2, 2, 2, 1, 2, 1, 0,
0, -1, 0, -1, 0, 0, -1, -1, -1, -1, 0, -1, -1, -2, -5, -5, -6, -6, -5, -6, -5,
-5, -5, -5, -6, -5, -5, -5, -6, -6, -5, -5, -5, -6, -6, -5, -6, -5, -6, -6, -6,
-6, -5, -6, -6, -6, -6, -6, -5, -5, -6, -5, -6, -5, -5, -5, -6, -5, -5, -5, -5,
-5, -3, -3, -3, -3, -3, -3, -3, -4, -4, -3, -2, -3, -4, -3, -3, -2, -3, -3, -3,
-3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -2, -3, -3, -2, -3, -3, -3, -3, -2, -3,
-3, -3, -2, -3, -3, -3, -2, -3, 2, 24, 38, 37, 36, 36, 36, 37, 36, 37, 36, 37,
37, 36, 36, 35, 18, -2, -4, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -4, -3, -3,
-3, -3, -4, -2, -3, -3, -3, -3, -3, -2, -3, -3, -3, -3, -3, -4, -3, -2, -3, -3,
-3, -3, -2, -3, -3, -2, -3, -3, -3, -2, -3, -2, -13, -52, -77, -74, -75, -75,
-75, -74, -75, -75, -75, -75, -75, -75, -76, -71, -38, -1, 1, -1, 0, 0, -1, 0,
-1, -1, -1, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, -1, 0, 0, 0, -1, -1, -1, -1,
0, -2, -8, -10, -10, -10, -11, -11, -11, -10, -10, -10, -11, -11, -10, -10, -10,
-10, -11, -10, -10, -9, -11, -10, -9, -10, -10, -10, -10, -10, -11, -10, -10,
-16, -23, -23, -22, -22, -23, -23, -22, -22, -23, -23, -23, -23, -23, -22, -22,
-28, -38, -40, -39, -39, -39, -40, -40, -39, -40, -39, -40, -39, -40, -40, -41,
-27, -1, };