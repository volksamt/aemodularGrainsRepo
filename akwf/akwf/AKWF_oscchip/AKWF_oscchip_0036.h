#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0036

const PROGMEM int8_t DATA[DATA_LENGTH] = {37, 67, 60, 62, 61, 61, 61, 62, 60,
61, 61, 62, 60, 61, 60, 60, 61, 61, 61, 61, 61, 61, 61, 61, 61, 60, 61, 60, 61,
60, 61, 60, 63, 63, 64, 63, 64, 64, 64, 63, 64, 64, 64, 64, 63, 63, 63, 64, 63,
64, 63, 63, 63, 64, 64, 63, 63, 64, 63, 64, 63, 64, 63, 64, 63, 63, 64, 63, 63,
63, 63, 63, 63, 63, 64, 63, 63, 63, 62, 63, 63, 63, 63, 64, 63, 63, 62, 63, 63,
63, 62, 64, 63, 62, 63, 63, 62, 61, 62, 62, 61, 61, 62, 61, 61, 61, 61, 61, 62,
61, 61, 59, 58, 57, 57, 57, 57, 56, 57, 57, 56, 57, 57, 57, 56, 57, 56, 66, 97,
115, 113, 113, 112, 112, 113, 113, 113, 112, 113, 112, 113, 113, 113, 113, 113,
113, 113, 113, 112, 113, 113, 112, 113, 113, 113, 113, 113, 113, 113, 91, 62,
55, 58, 57, 57, 57, 57, 57, 58, 56, 57, 57, 57, 57, 57, 57, 55, 56, 56, 56, 56,
55, 55, 55, 55, 55, 55, 56, 55, 55, 56, 55, 56, 56, 56, 55, 55, 55, 55, 55, 56,
56, 55, 55, 55, 56, 56, 55, 55, 55, 55, 55, 55, 55, 56, 54, 55, 55, 55, 55, 55,
56, 54, 55, 55, 55, 55, 55, 54, 54, 54, 55, 55, 55, 55, 55, 55, 54, 57, 29, -40,
-76, -71, -70, -70, -70, -71, -72, -71, -70, -71, -71, -71, -72, -71, -71, -72,
-72, -72, -71, -71, -71, -72, -71, -71, -71, -71, -72, -70, -71, -72, -70, -71,
-71, -71, -71, -71, -71, -70, -71, -71, -71, -71, -71, -71, -70, -71, -71, -70,
-70, -71, -70, -70, -70, -71, -70, -70, -70, -70, -70, -70, -71, -70, -70, -70,
-70, -70, -70, -71, -70, -70, -71, -71, -70, -71, -70, -69, -70, -71, -70, -71,
-70, -69, -70, -70, -70, -70, -70, -70, -70, -70, -70, -71, -70, -70, -70, -70,
-70, -70, -70, -70, -70, -69, -71, -70, -69, -70, -70, -70, -69, -72, -28, 76,
120, 111, 114, 112, 113, 112, 113, 112, 113, 112, 113, 112, 113, 116, 91, -8,
-75, -69, -69, -70, -69, -70, -69, -70, -70, -69, -70, -69, -69, -70, -69, -69,
-69, -69, -69, -69, -69, -69, -69, -70, -69, -69, -69, -69, -69, -70, -70, -69,
-70, -69, -70, -69, -69, -69, -70, -69, -70, -69, -70, -69, -70, -70, -69, -69,
-70, -69, -69, -69, -69, -70, -69, -68, -68, -69, -69, -69, -69, -70, -69, -69,
-69, -69, -69, -69, -69, -69, -69, -69, -69, -68, -69, -69, -68, -69, -69, -68,
-69, -68, -69, -69, -68, -69, -69, -68, -69, -69, -68, -68, -68, -68, -68, -68,
-68, -68, -69, -67, -68, -68, -68, -68, -68, -69, -68, -68, -69, -68, -68, -68,
-68, -68, -68, -68, -68, -68, -69, -68, -68, -68, -68, -68, -68, -67, -67, -69,
-68, -67, -68, -68, -68, -67, -68, -68, -68, -68, -68, -67, -69, -67, -23, };