#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0155

const PROGMEM int8_t DATA[DATA_LENGTH] = {63, 97, 86, 92, 88, 91, 89, 90, 89,
90, 89, 89, 90, 90, 89, 88, 81, 79, 79, 79, 78, 79, 80, 78, 79, 79, 78, 79, 79,
79, 79, 78, 72, 68, 68, 68, 67, 67, 68, 69, 69, 68, 68, 68, 68, 68, 68, 67, 60,
50, 50, 50, 50, 50, 51, 50, 50, 50, 51, 50, 50, 50, 51, 43, 28, 24, 26, 25, 25,
25, 26, 25, 25, 25, 26, 25, 25, 25, 25, 23, 12, 9, 10, 8, 9, 9, 10, 9, 9, 8, 9,
8, 9, 9, 8, 8, 9, 8, 9, 10, 8, 9, 9, 9, 9, 9, 9, 9, 8, 9, 9, 8, -2, -14, -14,
-15, -15, -14, -15, -14, -13, -15, -14, -14, -14, -14, -14, -19, -27, -29, -28,
-29, -28, -29, -29, -28, -28, -29, -28, -29, -29, -28, -29, -31, -42, -45, -45,
-45, -45, -45, -45, -45, -45, -45, -44, -45, -45, -44, -45, -45, -48, -50, -50,
-50, -50, -50, -50, -51, -51, -50, -50, -50, -50, -50, -50, -51, -59, -67, -66,
-67, -66, -66, -66, -67, -67, -67, -66, -65, -66, -66, -67, -58, -39, -35, -36,
-35, -36, -36, -35, -36, -36, -36, -36, -36, -36, -36, -37, -34, -24, -21, -22,
-22, -21, -21, -21, -21, -22, -21, -22, -22, -22, -21, -21, -21, -11, -7, -8,
-6, -7, -7, -8, -7, -7, -7, -7, -7, -7, -7, -7, -7, 1, 8, 7, 7, 7, 7, 7, 7, 7,
8, 7, 7, 7, 8, 7, 14, 27, 29, 28, 29, 29, 29, 29, 29, 29, 29, 29, 29, 28, 29,
28, 31, 41, 43, 43, 43, 42, 43, 43, 43, 43, 42, 42, 44, 43, 43, 42, 44, 53, 57,
57, 57, 57, 57, 57, 57, 57, 57, 57, 57, 57, 57, 58, 57, 63, 67, 68, 68, 68, 69,
68, 68, 68, 68, 67, 68, 68, 68, 68, 71, 79, 79, 79, 79, 79, 79, 79, 79, 78, 78,
79, 79, 78, 78, 78, 83, 97, 101, 100, 100, 101, 101, 100, 101, 100, 101, 101,
100, 100, 100, 100, 101, 103, 104, 104, 104, 104, 104, 104, 104, 103, 104, 104,
104, 104, 105, 104, 104, 96, 91, 91, 91, 92, 91, 91, 92, 92, 91, 91, 91, 92, 91,
92, 88, 81, 81, 81, 81, 80, 80, 81, 81, 80, 80, 81, 81, 81, 80, 80, 76, 59, 55,
56, 55, 56, 55, 56, 55, 55, 56, 56, 55, 56, 56, 56, 55, 48, 44, 45, 44, 45, 44,
45, 45, 45, 45, 45, 45, 44, 45, 45, 44, 39, 34, 35, 34, 34, 34, 34, 34, 33, 35,
35, 33, 34, 34, 34, 27, 17, 16, 17, 16, 17, 17, 16, 16, 16, 16, 16, 16, 16, 16,
17, 14, 9, 7, 8, 7, 8, 8, 6, 7, 7, 7, 7, 7, 7, 7, 7, 7, 4, 3, 4, 4, 3, 3, 3, 3,
4, 3, 3, 3, 3, 2, 5, -3, -70, -119, -112, -116, -114, -115, -114, -116, -115,
-115, -115, -115, -115, -114, -115, -42, };