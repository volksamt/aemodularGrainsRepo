#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0139

const PROGMEM int8_t DATA[DATA_LENGTH] = {79, 119, 105, 114, 108, 112, 108, 112,
108, 111, 109, 111, 110, 110, 110, 110, 110, 110, 110, 110, 110, 110, 110, 109,
110, 109, 111, 109, 111, 109, 106, -9, -115, -110, -111, -110, -111, -111, -111,
-111, -111, -111, -111, -111, -111, -111, -111, -111, -110, -111, -110, -111,
-110, -111, -111, -112, -110, -110, -111, -111, -110, -111, -111, -110, -111,
-111, -111, -111, -111, -111, -111, -111, -111, -111, -111, -111, -111, -111,
-110, -111, -111, -110, -111, -111, -111, -110, -111, -111, -111, -111, -111,
-111, -110, -111, -110, -110, -111, -111, -111, -111, -112, -111, -111, -111,
-111, -111, -110, -111, -111, -111, -111, -111, -111, -111, -111, -110, -112,
-110, -111, -111, -111, -111, -111, -111, -111, -111, -111, -111, -110, -111,
-111, -110, -111, -111, -111, -110, -111, -111, -112, -111, -111, -111, -110,
-111, -111, -111, -110, -111, -111, -110, -111, -111, -111, -111, -111, -110,
-111, -111, -110, -111, -111, -112, -111, -111, -110, -111, -111, -111, -110,
-111, -111, -111, -111, -111, -110, -111, -110, -111, -111, -111, -111, -111,
-111, -111, -111, -111, -110, -111, -111, -110, -111, -111, -110, -111, -111,
-111, -111, -111, -110, -111, -111, -111, -111, -110, -111, -111, -111, -111,
-110, -111, -111, -111, -111, -111, -111, -110, -111, -110, -111, -111, -111,
-111, -110, -111, -111, -111, -110, -111, -111, -110, -111, -110, -111, -111,
-111, -110, -111, -111, -111, -111, -111, -111, -111, -111, -111, -112, -111,
-111, -111, -111, -111, -111, -111, -111, -111, -110, -110, -110, -110, -110,
-111, -111, -111, -111, -111, -111, -111, -111, -111, -111, -111, -111, -111,
-111, -111, -111, -110, -110, -110, -111, -111, -111, -111, -110, -111, -110,
-111, -111, -111, -111, -110, -111, -111, -111, -111, -111, -110, -112, -111,
-110, -110, -111, -111, -110, -111, -110, -111, -110, -111, -111, -111, -112,
-111, -111, -112, -111, -111, -111, -111, -110, -111, -111, -111, -111, -111,
-111, -110, -111, -112, -111, -111, -110, -111, -112, -111, -110, -111, -111,
-110, -111, -111, -110, -111, -111, -111, -110, -111, -112, -111, -111, -111,
-111, -111, -110, -111, -111, -111, -111, -111, -111, -110, -110, -110, -112,
-110, -111, -111, -111, -110, -110, -111, -111, -112, -111, -112, -111, -111,
-111, -110, -111, -111, -111, -111, -111, -111, -111, -111, -111, -112, -110,
-111, -110, -111, -111, -110, -111, -110, -111, -111, -111, -111, -111, -111,
-110, -111, -111, -111, -111, -112, -111, -110, -111, -111, -111, -110, -110,
-111, -111, -111, -111, -111, -111, -111, -111, -111, -112, -111, -111, -111,
-111, -111, -111, -110, -111, -111, -111, -111, -112, -110, -111, -111, -111,
-111, -111, -111, -112, -111, -111, -111, -111, -111, -112, -111, -111, -111,
-111, -111, -111, -111, -111, -111, -111, -112, -110, -111, -111, -111, -111,
-111, -112, -110, -111, -110, -111, -111, -111, -111, -111, -112, -111, -111,
-111, -111, -111, -110, -111, -111, -111, -110, -111, -110, -112, -110, -111,
-110, -112, -111, -111, -111, -112, -111, -111, -110, -111, -110, -112, -111,
-111, -111, -111, -111, -35, };