#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0067

const PROGMEM int8_t DATA[DATA_LENGTH] = {45, 65, 59, 63, 60, 62, 60, 63, 61,
61, 61, 62, 61, 62, 61, 62, 62, 62, 61, 61, 61, 62, 62, 61, 61, 61, 62, 61, 61,
61, 62, 61, 63, 61, 63, 61, 62, 61, 63, 61, 62, 61, 62, 60, 62, 61, 64, 43, -78,
-119, -109, -116, -112, -114, -112, -114, -113, -113, -114, -112, -115, -110,
-120, -49, 62, 61, 62, 61, 62, 61, 61, 61, 61, 62, 61, 61, 60, 62, 61, 62, 61,
62, 61, 61, 60, 62, 61, 61, 61, 61, 61, 62, 62, 61, 61, 61, 61, 61, 61, 61, 61,
62, 62, 61, 61, 61, 61, 62, 62, 61, 62, 61, 62, 61, 62, 61, 60, 62, 61, 61, 62,
61, 61, 61, 61, 60, 60, 61, 61, 62, 61, 61, 61, 62, 61, 61, 62, 61, 61, 61, 61,
60, 61, 61, 61, 61, 61, 61, 61, 61, 61, 61, 61, 61, 61, 61, 61, 61, 61, 61, 61,
62, 61, 61, 60, 61, 60, 61, 61, 61, 60, 61, 61, 60, 61, 61, 61, 60, 60, 61, 61,
61, 61, 60, 60, 61, 61, 61, 60, 61, 61, 61, 60, 61, 60, 60, 61, 60, 61, 60, 61,
60, 60, 60, 61, 61, 60, 61, 61, 60, 61, 60, 61, 61, 61, 60, 61, 61, 61, 60, 61,
60, 63, 51, -19, -44, -37, -40, -39, -41, -38, -39, -38, -40, -39, -39, -39,
-39, -39, -39, -39, -39, -39, -39, -39, -39, -39, -38, -39, -39, -38, -39, -39,
-39, -39, -39, -39, -39, -39, -40, -39, -39, -39, -39, -39, -39, -39, -39, -38,
-39, -39, -40, -38, -37, -37, -37, -37, -38, -37, -38, -38, -38, -38, -38, -37,
-37, -38, -38, -39, -39, -39, -39, -40, -39, -38, -39, -39, -38, -38, -39, -38,
-39, -39, -39, -39, -39, -38, -39, -38, -39, -39, -39, -39, -39, -39, -38, -38,
-38, -39, -39, -37, -37, -38, -37, -38, -37, -38, -38, -37, -37, -37, -37, -38,
-37, -37, -38, -38, -38, -39, -38, -38, -38, -38, -39, -38, -39, -39, -39, -39,
-39, -39, -39, -37, -37, -36, -38, -37, -37, -37, -38, -37, -37, -37, -37, -37,
-37, -37, -37, -37, -39, -39, -39, -38, -38, -39, -38, -39, -39, -38, -38, -39,
-39, -38, -38, -38, -38, -38, -38, -38, -38, -38, -38, -39, -39, -38, -38, -37,
-39, -39, -38, -38, -38, -39, -38, -38, -38, -39, -38, -38, -39, -38, -38, -38,
-39, -38, -38, -37, -37, -37, -37, -37, -37, -37, -36, -36, -37, -37, -37, -37,
-37, -37, -37, -38, -38, -38, -38, -38, -38, -38, -37, -38, -38, -38, -37, -38,
-39, -39, -38, -37, -36, -37, -37, -36, -37, -36, -37, -37, -36, -36, -36, -36,
-37, -37, -36, -37, -38, -38, -38, -38, -38, -38, -38, -38, -38, -38, -37, -38,
-38, -39, -38, -38, -38, -39, -39, -37, -38, -38, -38, -38, -38, -38, -38, -38,
-37, -38, -38, -37, -38, -37, -38, -38, -37, -38, -38, -37, -39, -38, -38, -38,
-37, -40, -16, };