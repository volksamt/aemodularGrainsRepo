#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0063

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 24, 25, 22, 24, 23, 24, 23, 24, 24,
24, 22, 24, 24, 24, 39, 52, 53, 53, 53, 53, 53, 53, 53, 53, 53, 53, 53, 53, 53,
54, 60, 72, 75, 74, 74, 74, 74, 74, 74, 74, 73, 74, 74, 74, 73, 73, 76, 82, 84,
84, 83, 84, 84, 84, 84, 85, 85, 84, 85, 84, 86, 75, 19, -21, -20, -18, -19, -19,
-18, -19, -20, -19, -19, -18, -20, -19, -19, -16, 36, 94, 102, 97, 100, 98, 98,
99, 98, 99, 99, 98, 99, 98, 98, 98, 99, 102, 103, 103, 102, 102, 103, 103, 102,
102, 102, 102, 102, 102, 102, 106, 75, -6, -49, -42, -42, -43, -43, -44, -43,
-43, -43, -43, -42, -43, -42, -43, -43, -43, -43, -43, -43, -43, -43, -43, -43,
-44, -43, -43, -44, -43, -44, -41, 15, 93, 108, 100, 103, 102, 103, 102, 103,
102, 102, 102, 103, 102, 102, 102, 102, 100, 99, 100, 99, 99, 99, 100, 99, 100,
101, 100, 99, 100, 99, 99, 94, 90, 91, 91, 91, 91, 91, 91, 91, 91, 91, 91, 91,
91, 91, 90, 84, 78, 78, 79, 78, 78, 78, 78, 78, 78, 78, 77, 78, 78, 78, 78, 66,
48, 43, 44, 44, 45, 44, 45, 44, 44, 44, 45, 44, 44, 44, 45, 39, 25, 20, 21, 20,
21, 21, 20, 21, 20, 20, 20, 22, 21, 21, 17, -2, -18, -17, -18, -18, -17, -18,
-17, -17, -17, -18, -17, -17, -17, -17, -17, -26, -36, -37, -35, -36, -37, -36,
-36, -36, -36, -36, -36, -36, -37, -36, -36, -43, -56, -61, -58, -60, -59, -59,
-59, -59, -60, -59, -59, -60, -60, -60, -59, -62, -73, -79, -77, -78, -78, -79,
-78, -77, -77, -78, -78, -78, -78, -78, -79, -87, -95, -96, -94, -95, -95, -95,
-95, -94, -94, -94, -95, -95, -95, -95, -94, -100, -107, -107, -106, -107, -107,
-107, -106, -107, -108, -107, -108, -107, -106, -107, -107, -108, -110, -112,
-112, -111, -111, -110, -111, -110, -111, -110, -111, -110, -110, -112, -92, -9,
47, 43, 43, 43, 43, 44, 44, 43, 43, 43, 43, 43, 44, 44, 43, 43, 43, 43, 44, 43,
43, 43, 43, 44, 43, 44, 43, 43, 43, 43, 43, 43, 41, 41, 41, 41, 41, 41, 42, 40,
42, 41, 41, 41, 41, 41, 41, 41, 39, 39, 39, 39, 39, 39, 38, 39, 39, 39, 39, 39,
39, 39, 38, 38, 37, 37, 36, 36, 36, 37, 37, 37, 38, 37, 37, 36, 37, 37, 33, -32,
-109, -119, -113, -116, -115, -115, -114, -114, -115, -115, -114, -115, -115,
-115, -114, -114, -112, -112, -112, -113, -112, -112, -112, -113, -113, -112,
-113, -113, -113, -113, -112, -111, -108, -106, -105, -106, -106, -107, -105,
-106, -106, -107, -107, -106, -105, -106, -104, -95, -86, -87, -87, -87, -86,
-86, -86, -87, -87, -86, -86, -87, -86, -86, -86, -72, -56, -51, -52, -53, -53,
-53, -53, -52, -53, -52, -53, -52, -54, -52, -54, -31, };