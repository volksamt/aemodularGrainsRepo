#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0110

const PROGMEM int8_t DATA[DATA_LENGTH] = {31, 33, 32, 34, 31, 34, 32, 33, 32,
33, 31, 33, 32, 33, 32, 40, 56, 56, 55, 56, 56, 56, 56, 56, 56, 56, 56, 56, 56,
56, 54, 34, 22, 24, 23, 24, 24, 24, 24, 23, 24, 23, 24, 24, 23, 23, 24, 22, 20,
21, 20, 21, 21, 21, 21, 21, 20, 21, 21, 20, 21, 20, 21, 20, 20, 20, 21, 20, 21,
20, 21, 21, 21, 21, 21, 20, 20, 20, 20, 21, 21, 20, 21, 21, 20, 21, 21, 21, 20,
21, 20, 21, 20, 21, 21, 22, 24, 23, 23, 23, 24, 23, 23, 24, 24, 24, 23, 23, 24,
23, 23, 23, 24, 23, 23, 23, 23, 24, 24, 23, 24, 23, 24, 23, 23, 23, 24, 22, 24,
23, 24, 23, 23, 24, 24, 23, 23, 24, 23, 24, 23, 24, 21, 65, 103, 97, 101, 99,
101, 100, 100, 100, 100, 99, 100, 99, 100, 99, 100, 91, 75, 76, 76, 77, 76, 77,
76, 77, 76, 76, 76, 76, 75, 76, 75, 60, 51, 53, 51, 52, 52, 52, 52, 52, 52, 52,
52, 52, 52, 52, 53, 46, 40, 41, 41, 40, 40, 40, 40, 41, 41, 40, 41, 39, 42, 39,
42, 18, -21, -22, -22, -21, -22, -21, -22, -21, -22, -22, -21, -22, -21, -22,
-22, -45, -56, -53, -54, -53, -53, -54, -55, -54, -53, -53, -53, -53, -54, -54,
-53, -63, -72, -71, -71, -71, -71, -71, -72, -70, -72, -70, -72, -70, -73, -68,
-77, -29, 49, 49, 49, 49, 49, 50, 49, 49, 48, 50, 48, 49, 49, 50, 48, 32, 24,
27, 24, 25, 25, 27, 25, 26, 26, 26, 26, 25, 26, 26, 25, 28, 32, 31, 32, 32, 33,
31, 32, 31, 31, 31, 31, 32, 32, 32, 32, 33, 34, 34, 34, 34, 35, 34, 34, 34, 35,
34, 34, 35, 34, 34, 35, 38, 41, 40, 41, 41, 41, 41, 41, 41, 41, 41, 41, 41, 40,
40, 40, 45, 49, 49, 49, 48, 49, 48, 48, 49, 50, 49, 48, 50, 48, 49, 49, 52, 58,
58, 58, 58, 58, 58, 58, 58, 57, 58, 57, 58, 57, 58, 58, 75, 81, 80, 82, 81, 82,
81, 81, 81, 81, 80, 82, 80, 82, 78, 84, -23, -124, -112, -119, -114, -118, -115,
-117, -115, -116, -115, -116, -115, -115, -116, -116, -113, -107, -108, -106,
-107, -106, -107, -107, -107, -107, -107, -106, -107, -107, -107, -106, -100,
-98, -98, -98, -98, -98, -98, -98, -98, -97, -98, -98, -97, -98, -98, -98, -98,
-98, -97, -98, -98, -98, -98, -98, -98, -98, -98, -98, -98, -98, -98, -95, -84,
-82, -83, -83, -83, -82, -84, -83, -82, -83, -83, -83, -82, -83, -83, -82, -81,
-80, -80, -80, -79, -80, -79, -80, -80, -81, -79, -79, -80, -80, -80, -80, -79,
-80, -80, -79, -80, -79, -80, -80, -80, -80, -79, -79, -80, -79, -80, -79, -79,
-78, -80, -79, -80, -79, -79, -78, -81, -78, -81, -78, -80, -78, -81, -71, -7,
};