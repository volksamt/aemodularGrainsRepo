#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3,
2, 3, 4, 6, 5, 5, 5, 6, 5, 5, 6, 6, 5, 5, 6, 6, 5, 6, 19, 27, 26, 25, 26, 25,
26, 26, 25, 26, 26, 26, 25, 26, 26, 25, 28, 29, 30, 29, 29, 28, 30, 30, 28, 29,
29, 28, 29, 29, 29, 28, 32, 44, 46, 46, 46, 45, 45, 46, 46, 46, 46, 46, 46, 45,
46, 46, 48, 55, 56, 56, 57, 56, 56, 56, 56, 55, 56, 56, 55, 55, 56, 55, 59, 67,
70, 69, 69, 69, 70, 69, 68, 70, 69, 69, 70, 69, 69, 69, 74, 82, 82, 82, 82, 82,
82, 82, 82, 82, 82, 82, 82, 81, 82, 82, 85, 92, 92, 93, 93, 93, 92, 92, 92, 92,
93, 92, 92, 92, 92, 92, 94, 96, 97, 97, 97, 96, 97, 96, 97, 97, 97, 96, 97, 96,
96, 96, 97, 98, 97, 98, 97, 97, 97, 98, 98, 97, 97, 97, 97, 98, 97, 97, 93, 88,
88, 88, 88, 87, 87, 87, 88, 87, 87, 88, 87, 88, 86, 87, 77, 67, 67, 67, 67, 67,
67, 67, 67, 67, 67, 67, 67, 67, 66, 66, 48, 32, 33, 33, 33, 32, 33, 32, 33, 32,
32, 33, 33, 33, 33, 32, 25, 19, 19, 20, 19, 19, 20, 19, 19, 19, 20, 18, 19, 20,
19, 18, 2, -9, -8, -9, -8, -9, -8, -8, -9, -8, -8, -9, -8, -8, -7, -10, -25,
-33, -32, -32, -32, -32, -32, -32, -32, -31, -31, -32, -32, -32, -32, -33, -50,
-59, -57, -59, -59, -59, -59, -59, -58, -59, -59, -58, -58, -59, -58, -61, -79,
-88, -86, -86, -86, -85, -86, -85, -86, -85, -85, -86, -86, -85, -87, -84, -93,
-112, -116, -115, -116, -115, -116, -116, -116, -116, -116, -115, -116, -115,
-116, -116, -116, -118, -118, -118, -119, -119, -118, -119, -118, -119, -119,
-118, -119, -118, -118, -119, -114, -105, -103, -104, -103, -103, -104, -103,
-103, -103, -103, -103, -102, -103, -103, -103, -96, -87, -86, -86, -86, -85,
-86, -86, -86, -86, -85, -86, -85, -86, -85, -86, -76, -62, -61, -62, -62, -61,
-61, -61, -61, -61, -62, -62, -62, -62, -61, -62, -50, -34, -34, -34, -35, -35,
-34, -35, -34, -34, -35, -34, -34, -34, -34, -34, -30, -24, -24, -24, -23, -24,
-24, -24, -24, -24, -24, -23, -23, -24, -25, -24, -21, -17, -17, -17, -17, -17,
-18, -18, -17, -16, -17, -17, -17, -17, -17, -17, -16, -15, -16, -14, -16, -15,
-15, -16, -16, -15, -15, -15, -15, -16, -15, -15, -14, -13, -13, -13, -14, -14,
-13, -13, -13, -13, -13, -13, -13, -14, -13, -13, -12, -11, -11, -12, -12, -12,
-12, -11, -12, -12, -12, -11, -12, -11, -12, -11, -10, -10, -10, -10, -10, -10,
-10, -10, -10, -9, -9, -10, -9, -10, -10, -10, -10, -11, -9, -10, -10, -10, -10,
-10, -10, -10, -10, -10, -9, -10, -9, -8, -2, };