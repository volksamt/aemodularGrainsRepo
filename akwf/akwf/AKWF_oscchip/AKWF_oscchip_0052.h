#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0052

const PROGMEM int8_t DATA[DATA_LENGTH] = {20, 75, 90, 87, 88, 87, 88, 86, 87,
86, 87, 86, 87, 87, 86, 87, 87, 84, 84, 83, 83, 83, 83, 84, 83, 83, 84, 84, 83,
83, 83, 84, 81, 69, 58, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59,
52, 45, 44, 45, 45, 45, 45, 45, 45, 46, 45, 44, 45, 45, 45, 41, 36, 34, 35, 34,
34, 34, 35, 35, 35, 34, 34, 35, 34, 35, 34, 32, 27, 26, 26, 26, 26, 26, 26, 25,
26, 26, 26, 25, 26, 26, 26, 25, 20, 17, 17, 17, 17, 17, 17, 17, 17, 17, 17, 17,
17, 17, 17, 16, 15, 15, 15, 15, 15, 16, 15, 15, 15, 15, 15, 16, 14, 15, 15, 14,
13, 14, 14, 13, 13, 14, 13, 13, 13, 14, 14, 14, 14, 13, 14, 12, 8, 6, 7, 7, 6,
6, 7, 7, 6, 6, 7, 7, 6, 6, 6, 6, 4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 2, 3, 1,
-1, 0, 0, -1, -1, 0, 0, 0, 0, -1, -1, -1, -1, 0, 0, -2, -2, -3, -3, -2, -2, -2,
-3, -3, -3, -3, -2, -3, -2, -3, -3, -3, -3, -4, -4, -5, -4, -4, -5, -4, -4, -4,
-4, -4, -4, -4, -4, -4, -4, -5, -5, -4, -4, -4, -5, -4, -4, -4, -4, -3, -4, -5,
-5, -5, -7, -8, -8, -7, -8, -7, -7, -7, -7, -7, -7, -7, -8, -7, -7, -7, -8, -7,
-7, -7, -8, -7, -8, -7, -8, -7, -8, -7, -8, -8, -8, -8, -8, -8, -8, -7, -8, -7,
-7, -8, -8, -7, -8, -8, -7, -7, -7, -7, -8, -7, -7, -8, -8, -8, -7, -7, -7, -8,
-7, -7, -7, -7, -7, -8, -7, -8, -7, -7, -8, -8, -7, -8, -7, -8, -7, -8, -7, -8,
-7, -7, -7, -8, -7, -8, -7, -7, -7, -8, -7, -8, -7, -8, -8, -8, -7, -12, -23,
-27, -26, -26, -26, -26, -26, -26, -26, -27, -26, -26, -27, -27, -24, -14, -9,
-9, -9, -8, -9, -9, -9, -8, -9, -9, -8, -9, -9, -7, -15, -69, -116, -117, -116,
-116, -116, -116, -116, -116, -117, -115, -116, -116, -116, -115, -115, -115,
-115, -115, -116, -116, -115, -115, -115, -115, -116, -116, -115, -115, -115,
-116, -95, -51, -34, -39, -37, -38, -38, -37, -38, -38, -38, -37, -37, -38, -37,
-38, -32, -12, 0, -1, -2, -2, -1, -1, -1, 0, -1, -1, -2, -1, -1, -1, -1, -2, -3,
-3, -3, -2, -4, -2, -3, -3, -2, -2, -3, -3, -3, -3, -2, -4, -4, -4, -4, -5, -4,
-4, -4, -5, -5, -4, -5, -4, -4, -3, -5, -7, -8, -8, -9, -8, -7, -8, -7, -8, -8,
-8, -9, -7, -8, -7, -8, -9, -10, -10, -9, -10, -10, -10, -9, -9, -9, -9, -10,
-10, -10, -9, -10, -9, -9, -9, -10, -10, -9, -9, -9, -9, -9, -10, -10, -10, -9,
-10, -7, };