#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0027

const PROGMEM int8_t DATA[DATA_LENGTH] = {35, 69, 61, 65, 63, 65, 64, 64, 63,
63, 64, 63, 64, 64, 64, 64, 64, 63, 64, 64, 64, 63, 64, 64, 65, 63, 64, 64, 64,
64, 64, 64, 64, 63, 64, 64, 64, 64, 64, 64, 64, 64, 64, 64, 63, 64, 64, 63, 64,
63, 64, 64, 65, 64, 63, 64, 64, 64, 64, 64, 64, 63, 63, 64, 64, 64, 63, 63, 64,
64, 63, 64, 64, 64, 64, 64, 64, 64, 63, 64, 64, 64, 64, 64, 63, 63, 64, 63, 64,
63, 63, 63, 64, 64, 64, 64, 63, 64, 64, 63, 63, 64, 63, 64, 63, 64, 63, 63, 63,
64, 63, 63, 64, 63, 63, 64, 63, 64, 63, 64, 63, 63, 64, 62, 63, 63, 63, 63, 63,
63, 63, 64, 63, 63, 63, 63, 63, 63, 64, 63, 63, 63, 64, 62, 63, 62, 63, 63, 63,
63, 64, 63, 63, 62, 63, 63, 63, 63, 63, 63, 63, 62, 63, 63, 63, 63, 63, 63, 63,
63, 63, 63, 63, 63, 63, 63, 63, 62, 62, 62, 63, 62, 62, 63, 62, 62, 63, 62, 62,
62, 62, 62, 62, 63, 62, 62, 63, 63, 62, 62, 63, 63, 63, 62, 63, 63, 63, 63, 62,
62, 63, 63, 62, 62, 62, 63, 62, 63, 62, 62, 62, 63, 62, 62, 62, 62, 63, 63, 63,
62, 62, 61, 62, 62, 63, 62, 64, 60, 67, -8, -113, -113, -112, -114, -112, -114,
-112, -113, -112, -113, -112, -113, -113, -114, -113, -113, -113, -113, -112,
-114, -113, -112, -113, -113, -113, -112, -112, -112, -113, -113, -113, -113,
-113, -113, -113, -113, -113, -112, -113, -113, -113, -112, -113, -112, -113,
-112, -113, -112, -113, -112, -113, -112, -113, -112, -113, -112, -113, -112,
-113, -112, -114, -111, -114, -96, -20, 7, 1, 4, 2, 5, 2, 4, 2, 4, 3, 4, 3, 4,
3, 3, 2, 2, 2, 1, 2, 2, 1, 2, 2, 2, 2, 2, 1, 1, 1, 2, 1, 0, 0, 1, 0, 1, 0, 2, 1,
1, 0, 0, 0, 0, 1, -1, -2, -2, -2, -3, -2, -2, -2, -3, -1, -3, -1, -3, -1, -4, 2,
-38, -108, -114, -112, -112, -112, -112, -113, -112, -112, -111, -111, -112,
-112, -110, -115, -74, -8, -5, -7, -5, -7, -6, -6, -6, -6, -6, -6, -7, -6, -6,
-6, -6, -9, -9, -9, -9, -9, -8, -8, -9, -10, -9, -9, -9, -9, -9, -9, -11, -14,
-14, -13, -13, -13, -14, -13, -12, -14, -13, -12, -13, -13, -13, -13, -20, -26,
-25, -26, -25, -26, -25, -25, -25, -26, -25, -25, -26, -25, -25, -26, -42, -54,
-53, -53, -53, -53, -52, -52, -53, -53, -52, -52, -53, -53, -52, -53, -54, -55,
-56, -55, -55, -55, -55, -55, -56, -55, -56, -55, -56, -55, -56, -54, -65, -104,
-114, -111, -112, -110, -113, -111, -112, -111, -112, -111, -112, -111, -112,
-112, -111, -112, -111, -111, -111, -111, -111, -112, -111, -111, -110, -112,
-110, -112, -108, -118, -63, };