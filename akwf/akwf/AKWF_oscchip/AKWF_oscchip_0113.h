#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0113

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 1, 2, 2, 2, 2, 2, 2, 2, 3, 2,
3, 0, 6, 40, 51, 47, 49, 48, 49, 48, 49, 48, 48, 49, 49, 49, 49, 48, 48, 49, 48,
49, 49, 48, 48, 48, 48, 49, 49, 49, 49, 48, 48, 48, 48, 48, 48, 49, 48, 49, 48,
47, 48, 49, 49, 49, 49, 48, 48, 48, 49, 48, 49, 48, 48, 48, 49, 48, 48, 48, 49,
48, 49, 48, 48, 48, 48, 47, 48, 48, 48, 48, 48, 49, 48, 48, 49, 48, 48, 48, 49,
48, 48, 48, 48, 48, 48, 47, 48, 48, 48, 48, 49, 48, 48, 48, 47, 48, 48, 49, 48,
47, 48, 48, 48, 48, 48, 47, 48, 48, 49, 48, 48, 48, 48, 47, 47, 48, 48, 48, 48,
48, 48, 48, 48, 48, 47, 47, 48, 48, 48, 48, 47, 48, 48, 47, 48, 48, 48, 47, 47,
49, 48, 48, 48, 48, 47, 48, 48, 47, 48, 48, 48, 48, 47, 48, 48, 47, 48, 48, 48,
48, 47, 48, 47, 48, 47, 48, 48, 48, 48, 48, 47, 48, 47, 48, 48, 47, 48, 47, 48,
47, 48, 48, 47, 47, 47, 47, 47, 47, 47, 48, 47, 47, 47, 48, 47, 46, 48, 47, 47,
48, 47, 47, 48, 47, 47, 48, 47, 47, 46, 47, 47, 47, 46, 48, 47, 48, 47, 47, 48,
47, 47, 46, 46, 47, 48, 47, 47, 47, 47, 47, 47, 47, 47, 47, 47, 48, 47, 47, 47,
47, 47, 47, 47, 46, 47, 47, 46, 48, 46, 47, 46, 48, 45, 48, 43, 53, -17, -115,
-113, -115, -114, -114, -115, -114, -115, -115, -114, -114, -114, -113, -114,
-114, -113, -104, -104, -103, -104, -103, -104, -104, -104, -104, -103, -103,
-103, -103, -102, -104, -97, -92, -93, -93, -93, -93, -92, -93, -93, -92, -92,
-93, -92, -92, -92, -93, -87, -80, -80, -80, -80, -80, -79, -80, -81, -80, -81,
-80, -80, -80, -79, -81, -79, -77, -76, -76, -76, -76, -75, -75, -76, -76, -75,
-75, -76, -75, -76, -75, -68, -61, -63, -61, -62, -61, -62, -61, -62, -62, -61,
-61, -62, -62, -62, -61, -58, -53, -54, -54, -53, -54, -53, -53, -53, -54, -53,
-53, -53, -54, -53, -53, -51, -45, -45, -46, -46, -46, -44, -45, -45, -45, -46,
-46, -45, -45, -46, -45, -41, -37, -37, -37, -36, -37, -37, -37, -36, -37, -37,
-37, -36, -37, -37, -37, -35, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34,
-34, -34, -34, -34, -34, -33, -26, -26, -26, -26, -25, -26, -26, -25, -26, -25,
-26, -25, -25, -26, -25, -21, -17, -18, -17, -18, -17, -17, -18, -18, -18, -17,
-17, -18, -17, -17, -17, -16, -12, -11, -13, -12, -12, -11, -12, -12, -12, -12,
-11, -11, -12, -12, -11, -11, -9, -7, -8, -8, -7, -8, -7, -7, -8, -7, -7, -7,
-8, -8, -8, -5, -2, -3, -2, -3, -3, -2, -2, -2, -2, -2, -2, -3, -2, -2, -2, 0,
};