#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {27, 28, 28, 28, 27, 29, 27, 28, 27,
29, 28, 29, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 29, 28,
29, 28, 28, 28, 28, 28, 28, 29, 28, 29, 28, 27, 28, 29, 28, 28, 28, 27, 28, 28,
29, 28, 28, 28, 28, 28, 28, 27, 27, 28, 28, 28, 27, 28, 28, 28, 28, 28, 28, 28,
27, 28, 27, 28, 28, 28, 28, 27, 28, 27, 29, 27, 28, 27, 28, 27, 28, 27, 27, 27,
27, 28, 27, 27, 28, 28, 28, 28, 27, 28, 27, 27, 28, 28, 27, 27, 28, 27, 27, 28,
27, 28, 28, 28, 28, 27, 28, 28, 27, 27, 27, 28, 28, 28, 27, 28, 27, 28, 27, 28,
27, 28, 27, 27, 28, 28, 27, 27, 27, 28, 27, 27, 27, 28, 27, 27, 27, 27, 27, 27,
27, 28, 27, 27, 28, 27, 27, 27, 27, 27, 29, 31, 30, 30, 31, 31, 30, 30, 29, 31,
30, 31, 30, 31, 30, 31, 31, 31, 32, 33, 32, 32, 32, 32, 33, 31, 32, 32, 33, 31,
32, 33, 79, 120, 116, 118, 117, 118, 117, 118, 117, 118, 117, 117, 116, 118,
117, 117, 117, 118, 118, 117, 117, 116, 117, 117, 117, 117, 117, 116, 117, 116,
117, 116, 117, 116, 117, 117, 117, 116, 117, 116, 117, 116, 116, 116, 116, 117,
116, 104, -23, -106, -92, -97, -94, -96, -95, -96, -95, -97, -96, -95, -95, -96,
-96, -96, -97, -95, -95, -95, -95, -95, -97, -96, -96, -95, -97, -95, -96, -95,
-97, -88, -29, -3, -9, -7, -8, -7, -8, -7, -8, -8, -7, -7, -7, -7, -7, -7, -6,
-6, -6, -5, -5, -6, -6, -6, -6, -6, -6, -6, -6, -5, -5, -5, -4, -4, -4, -4, -4,
-4, -4, -3, -4, -4, -4, -4, -4, -4, -3, -3, -2, -1, -1, 0, 0, -1, -1, 0, 0, 0,
-1, 0, 0, -1, 0, -1, -1, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, -1, 0, -1, -1, -1, -1,
-1, -1, 0, -1, -1, 0, 0, -1, -1, -1, -1, -1, -1, 0, -1, -1, -1, -1, -1, -1, -1,
-1, -1, 0, 0, 0, -1, -1, 0, -1, -1, -1, -1, 0, 0, 0, 0, -1, 0, -1, 0, -1, 0, -1,
-1, 0, 0, -3, -4, -4, -4, -4, -4, -3, -4, -4, -4, -4, -3, -4, -4, -4, -4, -3,
-3, -3, -4, -3, -3, -4, -4, -5, -4, -3, -4, -4, -4, -4, -6, -57, -99, -93, -96,
-95, -95, -95, -95, -94, -96, -94, -96, -95, -95, -95, -95, -95, -95, -96, -95,
-96, -95, -95, -95, -95, -95, -94, -95, -95, -95, -95, -94, -95, -95, -95, -94,
-95, -94, -95, -95, -94, -95, -94, -94, -94, -95, -95, -95, -95, -94, -95, -94,
-94, -94, -94, -94, -93, -94, -94, -94, -94, -93, -93, -93, -95, -93, -94, -94,
-95, -93, -94, -93, -94, -93, -94, -92, -95, -91, -98, -75, -4, };