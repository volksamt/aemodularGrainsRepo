#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0032

const PROGMEM int8_t DATA[DATA_LENGTH] = {22, 29, 25, 28, 27, 27, 27, 28, 27,
26, 26, 27, 27, 27, 27, 28, 32, 32, 33, 32, 33, 32, 33, 32, 33, 33, 33, 32, 33,
33, 33, 39, 42, 42, 42, 42, 42, 41, 42, 42, 41, 42, 42, 41, 42, 42, 42, 45, 46,
46, 46, 46, 46, 46, 46, 46, 46, 46, 45, 46, 46, 46, 47, 47, 47, 47, 47, 47, 47,
48, 47, 47, 48, 48, 47, 47, 47, 47, 46, 47, 48, 47, 47, 47, 47, 48, 47, 48, 47,
48, 48, 47, 48, 48, 47, 48, 49, 49, 48, 48, 49, 49, 49, 48, 48, 48, 48, 48, 49,
49, 48, 51, 53, 52, 53, 52, 52, 52, 52, 53, 52, 52, 52, 52, 52, 52, 53, 52, 53,
54, 54, 53, 53, 54, 54, 54, 53, 53, 54, 54, 54, 53, 54, 57, 58, 58, 57, 58, 58,
58, 58, 58, 58, 58, 58, 58, 57, 57, 58, 60, 61, 60, 60, 60, 60, 60, 60, 61, 61,
60, 60, 61, 60, 60, 61, 84, 114, 118, 117, 118, 117, 118, 118, 118, 117, 117,
117, 117, 117, 117, 117, 117, 117, 117, 118, 118, 117, 117, 117, 118, 117, 116,
117, 118, 117, 117, 116, 117, 117, 117, 117, 117, 117, 117, 117, 116, 117, 117,
117, 117, 116, 117, 117, 116, 116, 116, 116, 116, 116, 117, 117, 116, 117, 116,
117, 116, 116, 117, 117, 51, -44, -64, -57, -60, -59, -58, -59, -59, -59, -59,
-59, -59, -59, -59, -59, -58, -58, -59, -59, -58, -59, -59, -59, -59, -59, -58,
-58, -59, -59, -59, -59, -59, -59, -59, -59, -59, -59, -59, -58, -58, -59, -59,
-58, -59, -59, -58, -59, -59, -59, -58, -58, -59, -58, -59, -59, -59, -59, -59,
-58, -59, -58, -59, -58, -59, -59, -59, -58, -58, -59, -58, -59, -58, -59, -58,
-59, -58, -59, -58, -58, -59, -59, -59, -59, -59, -58, -58, -58, -59, -58, -58,
-58, -58, -58, -58, -58, -58, -58, -59, -59, -58, -57, -57, -58, -58, -59, -58,
-58, -58, -58, -58, -58, -58, -59, -58, -57, -58, -58, -58, -58, -58, -58, -58,
-58, -58, -58, -58, -58, -57, -58, -58, -58, -58, -59, -57, -57, -57, -58, -58,
-58, -58, -58, -58, -58, -58, -58, -59, -58, -57, -57, -57, -58, -58, -58, -59,
-58, -57, -58, -58, -58, -58, -58, -57, -58, -58, -57, -58, -59, -58, -58, -57,
-58, -58, -58, -58, -58, -57, -58, -58, -57, -57, -58, -58, -58, -58, -58, -57,
-58, -57, -58, -58, -58, -57, -58, -57, -57, -57, -57, -58, -58, -58, -57, -57,
-58, -57, -57, -57, -57, -58, -58, -57, -58, -57, -58, -57, -57, -58, -57, -57,
-57, -58, -56, -58, -57, -57, -57, -57, -57, -58, -57, -57, -56, -58, -58, -58,
-57, -56, -57, -57, -57, -58, -56, -56, -57, -56, -57, -57, -57, -57, -57, -57,
-56, -57, -57, -57, -57, -56, -57, -57, -57, -56, -56, -57, -57, -57, -56, -57,
-57, -58, -56, -60, -50, -12, };