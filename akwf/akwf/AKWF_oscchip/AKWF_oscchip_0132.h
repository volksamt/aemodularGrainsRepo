#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0132

const PROGMEM int8_t DATA[DATA_LENGTH] = {81, 120, 107, 114, 108, 113, 109, 112,
110, 112, 110, 112, 110, 112, 108, 96, 89, 91, 90, 89, 90, 89, 90, 90, 91, 90,
91, 90, 91, 90, 87, -1, -83, -78, -78, -79, -78, -78, -79, -79, -79, -79, -79,
-79, -78, -79, -79, -73, -67, -67, -67, -67, -67, -67, -67, -67, -67, -66, -67,
-67, -68, -65, -69, -35, 42, 58, 53, 56, 54, 55, 54, 55, 54, 55, 54, 55, 55, 56,
46, -13, -45, -39, -41, -40, -41, -41, -41, -41, -41, -41, -41, -40, -41, -41,
-39, -3, 29, 27, 27, 26, 28, 26, 27, 27, 27, 26, 26, 26, 27, 27, 26, 11, -9, -9,
-9, -9, -9, -9, -10, -9, -9, -9, -9, -9, -9, -9, -9, -5, 5, 7, 6, 7, 7, 7, 7, 7,
6, 7, 7, 7, 7, 6, 5, -2, -6, -5, -5, -6, -5, -5, -5, -5, -4, -5, -5, -5, -5, -5,
-4, 15, 32, 31, 30, 31, 31, 31, 32, 31, 31, 31, 31, 31, 31, 31, 30, 33, 35, 34,
34, 35, 34, 35, 34, 34, 35, 35, 35, 35, 34, 35, 34, 37, 40, 41, 40, 40, 40, 41,
40, 40, 40, 40, 40, 40, 41, 40, 41, 41, 42, 43, 42, 43, 42, 43, 43, 43, 43, 42,
42, 43, 43, 43, 42, 44, 45, 45, 44, 45, 44, 44, 44, 44, 44, 45, 44, 45, 44, 45,
44, 75, 111, 111, 111, 111, 111, 110, 112, 111, 111, 111, 111, 110, 111, 110,
112, 92, 52, 46, 49, 47, 49, 48, 48, 48, 49, 48, 48, 48, 48, 47, 48, 46, 47, 46,
46, 46, 46, 47, 46, 46, 45, 46, 46, 46, 46, 45, 45, 41, 37, 37, 37, 38, 37, 39,
38, 38, 38, 38, 38, 37, 38, 38, 38, 32, 24, 23, 24, 24, 24, 24, 24, 24, 24, 23,
25, 24, 25, 23, 24, 18, 7, 5, 6, 5, 6, 5, 6, 6, 6, 6, 6, 6, 5, 6, 4, -11, -17,
-16, -16, -15, -16, -16, -16, -16, -16, -16, -16, -16, -15, -16, -16, -23, -26,
-27, -25, -26, -27, -26, -26, -25, -26, -25, -26, -26, -26, -26, -26, -28, -28,
-28, -28, -28, -28, -28, -28, -27, -28, -27, -28, -28, -28, -29, -28, -29, -32,
-32, -32, -31, -31, -31, -32, -31, -32, -31, -31, -32, -32, -32, -32, -34, -34,
-34, -33, -33, -34, -34, -34, -33, -33, -34, -33, -33, -34, -33, -35, -38, -42,
-41, -41, -41, -42, -42, -42, -41, -41, -42, -41, -41, -42, -42, -42, -45, -48,
-48, -48, -47, -48, -48, -47, -48, -47, -47, -47, -48, -47, -48, -47, -49, -53,
-54, -53, -53, -53, -52, -53, -53, -54, -53, -53, -53, -53, -53, -54, -56, -57,
-57, -58, -57, -57, -58, -58, -58, -58, -56, -57, -56, -57, -56, -61, -93, -113,
-110, -111, -110, -111, -111, -111, -110, -111, -111, -110, -111, -110, -112,
-110, -107, -104, -105, -104, -105, -105, -105, -104, -105, -104, -105, -104,
-105, -103, -105, -103, -31, };