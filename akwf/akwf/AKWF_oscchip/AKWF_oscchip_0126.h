#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0126

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 11, 11, 12, 11, 11, 10, 10, 11, 11,
11, 10, 11, 11, 11, 11, 15, 17, 17, 17, 17, 18, 18, 18, 17, 18, 18, 17, 17, 17,
19, 40, 61, 60, 61, 60, 60, 60, 61, 60, 59, 60, 61, 60, 60, 61, 60, 66, 75, 76,
74, 76, 75, 76, 75, 76, 75, 76, 75, 76, 76, 75, 75, 80, 88, 91, 91, 90, 91, 91,
90, 91, 90, 91, 91, 91, 91, 90, 90, 92, 97, 100, 99, 99, 98, 99, 99, 99, 99, 98,
99, 99, 99, 99, 99, 98, 97, 96, 97, 97, 97, 97, 97, 97, 97, 98, 97, 97, 97, 97,
96, 99, 102, 102, 101, 101, 102, 101, 101, 101, 101, 101, 100, 101, 101, 102,
101, 103, 106, 105, 105, 105, 106, 106, 106, 106, 105, 106, 106, 106, 106, 106,
105, 107, 117, 119, 118, 119, 119, 119, 118, 119, 119, 118, 118, 119, 119, 119,
116, 56, 8, 12, 10, 11, 10, 11, 11, 11, 11, 11, 11, 11, 10, 10, 11, 11, 11, 10,
11, 11, 10, 11, 10, 11, 11, 11, 11, 10, 11, 11, 11, 11, 11, 11, 11, 11, 10, 11,
11, 11, 11, 10, 10, 10, 10, 11, 11, 11, 11, 10, 11, 10, 11, 11, 10, 11, 11, 11,
10, 10, 11, 11, 11, 11, 10, 11, 12, 11, 11, 12, 10, 11, 11, 11, 12, 11, 11, 11,
10, 5, -2, -2, -3, -2, -2, -2, -1, -2, -2, -2, -2, -2, -2, -2, -2, -5, -10, -11,
-10, -12, -12, -11, -11, -10, -10, -10, -11, -12, -10, -11, -10, -13, -20, -22,
-22, -22, -22, -21, -21, -21, -22, -22, -22, -22, -21, -22, -22, -23, -24, -23,
-24, -24, -24, -23, -24, -23, -24, -24, -24, -24, -24, -24, -25, -24, -25, -27,
-26, -25, -26, -26, -26, -26, -26, -26, -26, -26, -26, -26, -26, -26, -28, -27,
-27, -28, -28, -28, -28, -28, -28, -28, -28, -29, -28, -28, -27, -28, -28, -28,
-28, -28, -28, -27, -28, -28, -28, -28, -28, -28, -28, -28, -28, -28, -29, -28,
-28, -28, -28, -28, -28, -28, -28, -27, -28, -27, -28, -27, -29, -29, -28, -27,
-28, -28, -28, -27, -28, -27, -27, -28, -28, -28, -28, -28, -29, -27, -28, -29,
-28, -28, -28, -28, -29, -28, -28, -28, -29, -28, -28, -28, -28, -28, -28, -28,
-28, -27, -28, -28, -28, -28, -28, -28, -28, -28, -28, -28, -27, -27, -25, -26,
-26, -26, -27, -27, -26, -25, -26, -25, -26, -26, -25, -26, -26, -25, -24, -23,
-24, -24, -23, -24, -23, -23, -24, -23, -24, -24, -24, -24, -23, -24, -23, -24,
-24, -24, -23, -24, -24, -24, -24, -24, -23, -23, -24, -24, -23, -24, -22, -22,
-22, -22, -21, -22, -22, -22, -22, -21, -22, -22, -21, -22, -22, -20, -19, -20,
-19, -20, -19, -20, -20, -19, -19, -20, -20, -20, -19, -19, -19, -16, -13, -12,
-12, -13, -13, -13, -13, -13, -13, -13, -13, -12, -13, -12, -13, -4, };