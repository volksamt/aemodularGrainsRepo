#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0144

const PROGMEM int8_t DATA[DATA_LENGTH] = {29, 45, 39, 43, 40, 42, 41, 42, 40,
42, 41, 41, 41, 42, 41, 48, 72, 83, 80, 82, 81, 81, 81, 81, 82, 81, 81, 81, 82,
81, 80, 83, 93, 100, 99, 98, 98, 99, 99, 99, 99, 99, 99, 98, 99, 98, 99, 99,
108, 119, 118, 118, 118, 119, 118, 118, 119, 119, 118, 118, 118, 118, 118, 118,
119, 118, 119, 119, 119, 118, 118, 118, 118, 118, 119, 118, 119, 118, 119, 118,
119, 117, 119, 118, 119, 118, 118, 119, 118, 118, 118, 119, 118, 118, 118, 115,
88, 70, 74, 73, 73, 73, 73, 72, 74, 73, 73, 73, 73, 74, 73, 71, 1, -70, -67,
-67, -67, -68, -67, -68, -67, -66, -67, -66, -66, -66, -67, -75, -98, -101,
-100, -101, -100, -100, -101, -101, -100, -101, -100, -101, -101, -101, -100,
-102, -107, -110, -108, -109, -108, -108, -109, -108, -109, -109, -109, -109,
-109, -109, -108, -109, -111, -112, -112, -112, -113, -113, -113, -112, -112,
-113, -113, -112, -112, -113, -112, -113, -111, -108, -109, -108, -109, -108,
-109, -108, -109, -109, -109, -108, -109, -108, -108, -111, -114, -115, -115,
-114, -114, -115, -115, -114, -114, -114, -114, -114, -115, -114, -114, -115,
-114, -115, -114, -115, -115, -115, -114, -114, -115, -114, -114, -115, -114,
-114, -114, -114, -115, -114, -114, -115, -114, -115, -114, -114, -114, -114,
-114, -114, -115, -114, -115, -115, -114, -114, -114, -115, -114, -114, -114,
-114, -114, -114, -115, -114, -115, -115, -115, -101, -75, -73, -74, -73, -73,
-72, -73, -73, -73, -72, -73, -73, -73, -73, -74, -59, -15, -1, -6, -3, -4, -3,
-4, -4, -4, -3, -4, -3, -4, -3, -5, 4, 60, 89, 84, 86, 84, 86, 85, 85, 84, 85,
84, 85, 85, 85, 85, 83, 51, 24, 26, 25, 26, 26, 26, 25, 27, 26, 26, 25, 27, 26,
26, 19, 5, 4, 4, 4, 5, 4, 4, 4, 4, 4, 4, 3, 3, 4, 4, 3, -1, -2, -2, -2, -2, -3,
-2, -1, -2, -2, -3, -2, -2, -3, -2, -3, -6, -6, -5, -6, -6, -6, -6, -6, -6, -5,
-5, -6, -5, -5, -6, -6, -8, -8, -8, -8, -8, -8, -8, -8, -8, -8, -8, -7, -8, -9,
-8, -8, -10, -10, -11, -10, -9, -10, -10, -10, -10, -10, -10, -10, -10, -11,
-10, -10, -12, -12, -12, -12, -12, -13, -12, -12, -12, -12, -12, -13, -11, -13,
-12, -13, -14, -16, -16, -16, -16, -15, -15, -15, -16, -16, -16, -16, -16, -15,
-16, -16, -19, -20, -20, -20, -20, -19, -19, -20, -19, -20, -19, -19, -20, -20,
-19, -21, -23, -23, -24, -24, -24, -24, -23, -24, -23, -23, -24, -24, -24, -24,
-24, -24, -27, -28, -28, -28, -28, -28, -28, -27, -28, -28, -27, -28, -28, -28,
-28, -28, -31, -31, -32, -32, -32, -32, -32, -32, -32, -32, -32, -32, -31, -32,
-31, -33, -41, -48, -47, -47, -48, -47, -47, -48, -47, -47, -47, -47, -47, -48,
-48, -16, };