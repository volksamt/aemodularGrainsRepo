#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0026

const PROGMEM int8_t DATA[DATA_LENGTH] = {24, 67, 96, 113, 118, 119, 116, 111,
108, 109, 111, 113, 112, 112, 111, 111, 111, 112, 111, 111, 110, 112, 112, 112,
111, 111, 112, 111, 111, 111, 112, 112, 112, 112, 111, 111, 111, 112, 112, 111,
111, 112, 111, 111, 112, 111, 111, 111, 111, 111, 111, 111, 112, 111, 111, 111,
111, 112, 112, 111, 107, 100, 91, 80, 66, 55, 48, 44, 43, 44, 45, 47, 46, 46,
46, 46, 47, 47, 43, 37, 28, 17, 4, -6, -14, -18, -20, -20, -18, -17, -16, -15,
-17, -17, -22, -25, -29, -35, -40, -44, -46, -46, -47, -46, -46, -45, -46, -46,
-45, -46, -45, -46, -46, -46, -46, -46, -45, -45, -45, -46, -46, -46, -46, -45,
-45, -46, -46, -46, -45, -45, -46, -46, -46, -45, -45, -45, -46, -45, -46, -45,
-45, -45, -46, -46, -45, -44, -44, -45, -44, -44, -43, -44, -44, -44, -46, -48,
-44, -34, -17, 5, 34, 66, 91, 107, 115, 116, 116, 113, 109, 108, 110, 111, 112,
111, 111, 111, 110, 110, 111, 112, 111, 111, 110, 111, 111, 110, 111, 111, 111,
110, 111, 110, 110, 111, 111, 110, 110, 111, 110, 111, 111, 111, 110, 110, 111,
111, 110, 111, 110, 110, 110, 111, 111, 110, 110, 110, 110, 110, 110, 110, 110,
111, 110, 110, 110, 110, 110, 111, 110, 110, 109, 109, 111, 114, 116, 108, 91,
66, 33, -11, -51, -84, -104, -112, -114, -111, -106, -102, -104, -105, -106,
-107, -106, -106, -105, -105, -105, -106, -106, -106, -106, -105, -105, -106,
-105, -106, -105, -106, -105, -105, -105, -105, -106, -105, -105, -106, -105,
-106, -106, -105, -105, -107, -109, -106, -99, -85, -66, -41, -14, 11, 26, 34,
36, 36, 34, 31, 29, 29, 30, 34, 38, 45, 54, 65, 74, 80, 83, 84, 84, 84, 82, 82,
82, 82, 82, 83, 83, 83, 82, 81, 81, 81, 80, 79, 79, 79, 78, 79, 79, 80, 83, 83,
76, 61, 38, 9, -27, -63, -89, -105, -110, -112, -109, -105, -103, -105, -108,
-106, -96, -79, -57, -31, -4, 16, 29, 34, 35, 33, 30, 28, 28, 28, 31, 33, 34,
30, 21, 5, -13, -40, -66, -89, -103, -109, -110, -109, -106, -104, -105, -108,
-107, -99, -85, -65, -40, -14, 10, 24, 31, 33, 32, 30, 27, 28, 31, 30, 23, 10,
-9, -33, -60, -83, -100, -107, -110, -109, -106, -104, -104, -107, -108, -102,
-89, -71, -48, -21, 4, 21, 29, 33, 34, 31, 27, 27, 27, 28, 29, 32, 32, 26, 15,
-3, -25, -51, -77, -95, -106, -110, -110, -108, -104, -103, -104, -105, -106,
-106, -105, -105, -105, -105, -105, -105, -104, -105, -105, -106, -105, -105,
-104, -105, -104, -104, -104, -105, -105, -106, -105, -105, -105, -105, -104,
-105, -105, -105, -104, -105, -105, -105, -105, -105, -105, -104, -104, -105,
-105, -105, -104, -104, -105, -104, -104, -105, -104, -105, -104, -105, -105,
-104, -104, -104, -104, -105, -104, -104, -104, -106, -109, -107, -96, -75, -46,
-9, };