#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 6, 7, 6, 7, 7, 6, 7, 7, 7, 6, 6,
6, 6, 7, 11, 12, 12, 12, 12, 12, 12, 11, 12, 13, 12, 13, 11, 12, 12, 13, 20, 24,
22, 23, 23, 22, 23, 23, 22, 22, 22, 23, 22, 23, 23, 23, 24, 24, 25, 24, 24, 24,
24, 25, 25, 24, 25, 25, 25, 24, 24, 26, 33, 35, 36, 35, 35, 36, 36, 35, 35, 35,
35, 35, 35, 35, 35, 37, 40, 40, 40, 40, 40, 41, 40, 40, 40, 41, 40, 41, 39, 41,
38, 62, 111, 119, 117, 117, 116, 117, 117, 117, 116, 117, 116, 116, 117, 118,
117, 116, 112, 111, 111, 112, 112, 111, 111, 112, 112, 111, 112, 111, 111, 111,
112, 106, 95, 94, 95, 95, 94, 94, 95, 94, 95, 95, 95, 94, 95, 95, 95, 88, 79,
78, 78, 78, 79, 78, 78, 78, 78, 78, 78, 78, 78, 78, 78, 74, 71, 70, 72, 71, 71,
71, 71, 71, 70, 71, 70, 70, 70, 70, 71, 69, 57, 47, 50, 49, 49, 49, 49, 49, 49,
49, 49, 49, 48, 48, 50, 48, 40, 35, 36, 36, 36, 36, 37, 35, 35, 37, 36, 36, 36,
36, 36, 34, 28, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 23,
23, 24, 23, 23, 23, 22, 24, 23, 23, 23, 23, 23, 22, 23, 22, 16, 15, 14, 14, 14,
15, 14, 14, 14, 14, 15, 15, 14, 14, 13, 13, 13, 12, 12, 12, 12, 12, 12, 13, 12,
12, 12, 12, 12, 12, 12, 9, -4, -9, -7, -7, -8, -7, -8, -8, -8, -8, -7, -7, -7,
-8, -7, -11, -21, -24, -24, -24, -24, -24, -24, -24, -24, -23, -24, -24, -23,
-24, -24, -29, -40, -42, -41, -43, -41, -42, -41, -41, -41, -42, -41, -41, -42,
-42, -41, -45, -55, -57, -56, -56, -55, -56, -55, -56, -56, -56, -55, -56, -55,
-56, -56, -59, -66, -67, -66, -67, -67, -66, -66, -67, -66, -66, -66, -66, -67,
-67, -65, -69, -73, -73, -73, -73, -74, -73, -73, -73, -73, -73, -72, -72, -73,
-73, -73, -74, -75, -75, -75, -75, -75, -75, -75, -75, -75, -74, -74, -75, -74,
-74, -74, -75, -77, -78, -77, -79, -78, -78, -78, -78, -78, -78, -78, -78, -78,
-78, -78, -77, -76, -75, -75, -75, -76, -76, -75, -76, -76, -76, -76, -76, -76,
-75, -75, -76, -74, -74, -73, -73, -74, -73, -74, -74, -74, -73, -73, -73, -73,
-74, -74, -73, -70, -70, -70, -70, -70, -69, -69, -69, -71, -69, -69, -69, -70,
-69, -70, -68, -58, -53, -54, -53, -54, -54, -53, -53, -53, -53, -53, -53, -53,
-53, -53, -51, -43, -40, -41, -40, -41, -40, -41, -41, -40, -41, -41, -40, -40,
-40, -41, -38, -29, -26, -26, -26, -27, -26, -26, -26, -26, -26, -26, -26, -27,
-25, -26, -24, -14, -11, -12, -11, -11, -11, -12, -11, -12, -12, -12, -12, -11,
-11, -12, -8, };