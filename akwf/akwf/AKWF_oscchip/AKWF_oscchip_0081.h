#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0081

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 3, 4, 3, 3, 3, 3, 3, 3, 3, 4, 3,
3, 3, 4, 25, 34, 31, 33, 32, 33, 32, 32, 32, 32, 32, 32, 32, 33, 32, 32, 34, 37,
37, 38, 37, 37, 37, 37, 37, 38, 36, 38, 36, 38, 35, 49, 104, 116, 113, 115, 114,
116, 114, 115, 114, 114, 114, 115, 113, 114, 114, 114, 118, 119, 119, 119, 118,
118, 119, 119, 119, 120, 119, 119, 118, 120, 118, 119, 84, 54, 57, 55, 57, 55,
56, 55, 55, 56, 55, 56, 55, 56, 56, 57, 65, 66, 65, 65, 66, 65, 65, 65, 65, 66,
65, 65, 65, 65, 65, 65, 66, 65, 65, 66, 66, 65, 65, 65, 65, 66, 65, 65, 66, 65,
65, 65, 66, 66, 65, 66, 65, 65, 65, 65, 65, 65, 65, 65, 65, 65, 65, 67, 77, 81,
79, 80, 80, 80, 79, 80, 79, 80, 79, 80, 79, 79, 79, 79, 79, 79, 80, 80, 80, 78,
80, 80, 79, 80, 80, 79, 79, 80, 78, 81, 48, 18, 22, 21, 21, 21, 21, 21, 22, 21,
22, 21, 21, 22, 22, 20, 17, 16, 17, 17, 16, 16, 16, 17, 16, 17, 16, 17, 16, 16,
16, 16, 12, 10, 12, 11, 12, 11, 11, 12, 11, 12, 12, 11, 11, 12, 11, 11, 6, 2, 2,
1, 2, 1, 2, 2, 2, 1, 2, 1, 2, 2, 2, 1, -3, -3, -3, -4, -3, -3, -2, -3, -3, -3,
-3, -3, -3, -2, -2, -4, -10, -14, -12, -13, -13, -13, -13, -12, -13, -13, -13,
-13, -13, -12, -13, -12, -16, -17, -17, -18, -18, -18, -17, -18, -18, -18, -17,
-17, -18, -18, -17, -17, -13, -13, -12, -12, -12, -12, -13, -13, -13, -13, -13,
-12, -12, -13, -12, -13, -12, -13, -13, -13, -12, -13, -13, -13, -12, -13, -13,
-13, -12, -13, -11, -21, -41, -43, -42, -42, -42, -42, -42, -42, -41, -42, -41,
-42, -41, -43, -40, -44, -59, -62, -60, -60, -60, -61, -61, -62, -61, -61, -61,
-60, -61, -61, -61, -62, -67, -72, -70, -70, -70, -71, -70, -70, -71, -70, -70,
-70, -71, -70, -71, -72, -75, -75, -74, -75, -75, -76, -75, -76, -76, -75, -75,
-75, -75, -76, -74, -75, -75, -75, -74, -76, -75, -75, -75, -75, -75, -75, -75,
-75, -74, -75, -75, -75, -75, -75, -75, -75, -75, -75, -74, -75, -75, -74, -75,
-75, -74, -75, -74, -74, -75, -75, -75, -75, -74, -75, -75, -75, -75, -75, -74,
-75, -75, -74, -75, -75, -74, -75, -74, -74, -75, -74, -74, -75, -74, -74, -74,
-74, -74, -74, -74, -75, -71, -69, -70, -69, -69, -69, -70, -70, -70, -69, -70,
-69, -69, -69, -70, -64, -50, -50, -50, -50, -50, -49, -51, -50, -50, -49, -51,
-50, -51, -50, -50, -48, -37, -34, -36, -35, -36, -36, -35, -35, -35, -34, -36,
-35, -36, -35, -36, -35, -18, -9, -12, -11, -12, -11, -11, -11, -11, -11, -11,
-11, -12, -11, -12, -7, };