#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0034

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 11, 9, 9, 10, 10, 10, 10, 10, 9, 9,
9, 10, 9, 9, 13, 24, 30, 29, 30, 29, 29, 30, 30, 30, 30, 29, 30, 30, 29, 30, 31,
45, 55, 55, 55, 55, 56, 56, 55, 56, 55, 55, 56, 55, 56, 55, 65, 79, 83, 81, 82,
81, 81, 82, 82, 82, 81, 81, 82, 82, 82, 80, 84, 92, 94, 94, 94, 95, 95, 94, 94,
94, 95, 94, 94, 95, 94, 94, 95, 103, 107, 107, 108, 107, 108, 107, 108, 107,
107, 108, 107, 108, 108, 107, 107, 109, 110, 111, 111, 111, 111, 111, 111, 111,
111, 111, 111, 111, 110, 111, 111, 114, 115, 115, 115, 115, 115, 115, 115, 114,
114, 115, 114, 115, 115, 115, 116, 118, 119, 119, 119, 119, 120, 119, 119, 119,
120, 119, 120, 118, 118, 119, 117, 106, 99, 98, 100, 98, 99, 98, 99, 99, 100,
98, 99, 98, 99, 97, 11, -96, -114, -106, -109, -108, -108, -109, -108, -108,
-108, -109, -108, -108, -109, -108, -106, -104, -103, -105, -104, -104, -104,
-103, -104, -104, -103, -105, -103, -104, -104, -105, -95, -66, -47, -50, -50,
-49, -49, -49, -49, -50, -49, -50, -49, -49, -50, -49, -51, -66, -80, -80, -79,
-79, -80, -80, -80, -80, -79, -80, -80, -80, -79, -80, -67, -49, -46, -47, -46,
-46, -47, -47, -46, -47, -47, -47, -46, -47, -46, -46, -49, -57, -60, -59, -60,
-59, -60, -59, -59, -59, -59, -60, -59, -59, -59, -60, -58, -49, -44, -44, -44,
-44, -44, -44, -44, -44, -45, -45, -44, -43, -44, -44, -33, -21, -20, -20, -19,
-20, -20, -20, -20, -20, -20, -20, -20, -20, -19, -19, -20, -20, -20, -20, -20,
-20, -20, -19, -20, -19, -20, -20, -20, -20, -20, -20, -19, -18, -18, -17, -18,
-18, -18, -17, -17, -18, -17, -17, -17, -18, -18, -17, -17, -13, -10, -11, -11,
-10, -10, -11, -11, -11, -10, -10, -12, -10, -11, -11, -9, -5, -4, -4, -5, -4,
-4, -3, -5, -4, -4, -4, -4, -4, -4, -6, 24, 84, 107, 101, 103, 102, 103, 103,
102, 103, 103, 102, 102, 102, 102, 103, 97, 72, 56, 59, 59, 59, 59, 59, 58, 59,
59, 59, 59, 59, 58, 59, 54, 21, -11, -12, -11, -11, -11, -11, -12, -11, -11,
-11, -12, -11, -11, -11, -30, -61, -68, -65, -66, -65, -66, -66, -66, -65, -66,
-66, -66, -65, -66, -65, -70, -84, -91, -89, -89, -90, -89, -89, -90, -90, -89,
-89, -90, -90, -90, -89, -89, -83, -80, -81, -81, -80, -80, -81, -80, -81, -80,
-80, -80, -81, -80, -81, -75, -67, -67, -67, -67, -67, -67, -68, -68, -67, -68,
-68, -67, -67, -68, -68, -63, -56, -53, -54, -54, -53, -54, -54, -54, -54, -53,
-54, -54, -54, -54, -54, -49, -37, -31, -32, -32, -32, -32, -31, -32, -32, -32,
-32, -32, -32, -32, -31, -30, -24, -18, -18, -19, -18, -18, -19, -19, -19, -19,
-19, -19, -19, -19, -18, -8, };