#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0131

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 9, 7, 8, 7, 9, 8, 8, 8, 7, 7, 8, 8,
8, 8, 15, 19, 18, 19, 18, 18, 18, 19, 18, 18, 19, 18, 19, 19, 18, 18, 24, 30,
29, 30, 30, 29, 29, 30, 29, 29, 30, 29, 29, 29, 30, 30, 35, 43, 44, 44, 44, 43,
44, 44, 45, 44, 43, 44, 44, 44, 44, 44, 45, 47, 47, 47, 47, 47, 47, 48, 47, 47,
46, 47, 47, 48, 47, 48, 51, 52, 52, 52, 53, 53, 52, 53, 53, 53, 53, 53, 52, 53,
53, 53, 54, 54, 54, 54, 55, 55, 54, 54, 53, 55, 54, 55, 54, 54, 55, 54, 55, 56,
56, 55, 56, 56, 57, 56, 56, 56, 56, 57, 57, 56, 56, 55, 73, 111, 119, 116, 117,
117, 118, 116, 118, 116, 117, 117, 117, 116, 117, 111, 75, 57, 60, 59, 60, 58,
59, 59, 59, 60, 60, 59, 59, 59, 59, 59, 59, 57, 57, 58, 57, 57, 57, 58, 57, 58,
58, 57, 58, 58, 58, 58, 55, 50, 50, 50, 50, 50, 50, 50, 50, 50, 49, 51, 51, 50,
49, 50, 46, 38, 36, 37, 37, 38, 37, 37, 37, 38, 37, 37, 37, 37, 37, 35, 26, 20,
20, 22, 22, 21, 21, 21, 20, 21, 21, 21, 21, 21, 21, 20, 9, 0, 1, 1, 1, 1, 0, 1,
1, 0, 1, 1, 1, 1, 1, 1, -3, -8, -9, -8, -9, -8, -8, -8, -8, -8, -9, -8, -8, -8,
-8, -8, -9, -10, -10, -10, -10, -10, -10, -10, -10, -11, -10, -10, -11, -10,
-10, -10, -13, -14, -13, -14, -14, -14, -14, -14, -14, -14, -14, -13, -14, -14,
-13, -13, -14, -15, -15, -16, -15, -15, -16, -16, -16, -16, -16, -15, -15, -15,
-15, -16, -19, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -22, -22, -22,
-22, -23, -24, -28, -29, -29, -27, -28, -29, -29, -29, -29, -28, -28, -27, -28,
-28, -29, -32, -34, -34, -34, -34, -33, -34, -34, -33, -34, -34, -34, -34, -34,
-34, -34, -36, -36, -37, -38, -37, -37, -38, -37, -37, -37, -37, -37, -37, -37,
-38, -38, -61, -87, -86, -86, -86, -87, -86, -86, -86, -85, -86, -86, -87, -85,
-86, -86, -84, -81, -80, -80, -80, -80, -80, -80, -80, -81, -80, -80, -81, -80,
-80, -80, -77, -76, -77, -77, -77, -77, -77, -76, -77, -76, -77, -76, -77, -76,
-76, -76, -72, -68, -70, -70, -70, -70, -70, -69, -69, -70, -69, -69, -68, -70,
-69, -70, -62, -56, -57, -57, -56, -57, -56, -56, -56, -56, -57, -57, -56, -57,
-57, -56, -52, -47, -45, -45, -45, -45, -45, -45, -46, -46, -45, -45, -45, -45,
-45, -45, -42, -41, -42, -42, -41, -42, -42, -41, -41, -41, -42, -41, -42, -41,
-42, -40, -29, -21, -22, -21, -22, -21, -21, -21, -22, -22, -22, -21, -22, -22,
-22, -21, -13, -7, -6, -8, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -2,
};