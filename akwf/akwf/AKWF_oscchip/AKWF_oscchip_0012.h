#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 4, 5, 5, 5, 4, 4, 4, 5, 5, 6, 5,
5, 5, 5, 5, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 2, 2, 1, 1, 1, 1, 1, 1,
1, 1, 1, 1, 1, 1, 1, 2, 1, 3, 6, 6, 7, 6, 6, 7, 6, 7, 7, 6, 7, 7, 7, 6, 7, 6, 6,
7, 6, 6, 7, 7, 6, 7, 6, 6, 6, 6, 6, 6, 7, 8, 9, 10, 10, 10, 10, 10, 10, 10, 10,
9, 10, 10, 10, 10, 9, 13, 13, 14, 13, 14, 13, 14, 13, 13, 13, 13, 13, 14, 14,
13, 14, 18, 18, 18, 18, 18, 18, 18, 19, 19, 19, 18, 18, 19, 19, 18, 19, 20, 21,
21, 23, 21, 22, 21, 22, 22, 22, 22, 22, 22, 22, 23, 22, 24, 23, 23, 24, 24, 23,
24, 23, 24, 24, 23, 24, 24, 23, 23, 25, 30, 32, 30, 30, 30, 30, 31, 30, 30, 31,
30, 30, 30, 30, 30, 32, 35, 36, 35, 36, 36, 36, 36, 36, 36, 36, 36, 36, 35, 36,
35, 40, 51, 53, 52, 53, 52, 53, 53, 53, 53, 53, 52, 53, 53, 53, 52, 58, 70, 72,
70, 71, 71, 70, 70, 71, 70, 70, 70, 69, 71, 70, 70, 73, 80, 80, 80, 81, 80, 81,
81, 81, 81, 80, 80, 80, 81, 81, 80, 84, 91, 90, 91, 90, 90, 91, 90, 90, 90, 91,
90, 91, 90, 90, 90, 95, 101, 101, 101, 101, 101, 100, 100, 100, 100, 101, 100,
100, 100, 101, 100, 101, 104, 103, 105, 104, 103, 104, 104, 103, 105, 103, 104,
103, 104, 102, 107, 85, -61, -121, -106, -115, -109, -113, -110, -112, -110,
-112, -111, -112, -112, -112, -111, -110, -101, -96, -98, -97, -98, -97, -97,
-97, -97, -97, -97, -97, -97, -97, -97, -95, -89, -85, -86, -86, -87, -86, -87,
-87, -86, -86, -86, -86, -86, -86, -86, -83, -76, -74, -75, -74, -74, -73, -74,
-73, -74, -74, -74, -73, -74, -73, -74, -73, -70, -70, -70, -70, -70, -70, -70,
-70, -70, -70, -70, -70, -70, -70, -69, -67, -64, -62, -63, -63, -63, -62, -63,
-63, -63, -63, -64, -62, -64, -63, -63, -57, -49, -49, -49, -49, -49, -49, -49,
-48, -48, -49, -48, -48, -48, -49, -48, -45, -41, -42, -41, -41, -41, -42, -41,
-42, -42, -42, -41, -42, -42, -41, -41, -38, -36, -36, -35, -36, -36, -35, -36,
-36, -36, -36, -35, -35, -36, -36, -36, -33, -31, -31, -30, -31, -30, -30, -31,
-31, -30, -30, -30, -31, -31, -30, -30, -21, -14, -15, -14, -15, -14, -15, -14,
-15, -15, -15, -14, -15, -14, -14, -14, -6, -2, -2, -2, -2, -2, -3, -2, -2, -2,
-3, -3, -2, -2, -3, -2, -2, -1, 0, -1, -1, -1, 0, -1, -1, 0, -1, 0, 0, -1, 0, 0,
0, 0, 0, 0, 0, -1, -1, 0, 0, 0, -1, 0, -1, 0, 0, 0, };