#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0033

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 5, 4, 5, 5, 5, 5, 5, 5, 5, 4, 5,
4, 5, 4, 8, 13, 15, 14, 14, 15, 14, 14, 14, 14, 15, 15, 14, 15, 14, 14, 18, 25,
28, 27, 27, 28, 27, 28, 28, 27, 27, 27, 27, 27, 28, 27, 29, 36, 40, 40, 40, 41,
40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 47, 52, 54, 53, 53, 53, 53, 53, 52, 53,
53, 53, 53, 53, 53, 54, 55, 57, 59, 58, 58, 58, 58, 57, 58, 57, 58, 58, 58, 58,
58, 58, 58, 60, 61, 61, 61, 60, 61, 61, 61, 60, 62, 61, 61, 61, 60, 61, 63, 66,
65, 66, 66, 66, 66, 65, 65, 66, 65, 65, 65, 66, 66, 66, 66, 67, 67, 67, 68, 67,
67, 67, 66, 67, 67, 66, 67, 66, 67, 67, 67, 69, 69, 69, 68, 68, 68, 68, 68, 68,
69, 68, 68, 69, 69, 68, 69, 71, 72, 71, 71, 72, 72, 71, 71, 72, 71, 71, 71, 71,
71, 71, 72, 73, 73, 73, 73, 73, 73, 73, 73, 73, 72, 72, 72, 72, 73, 72, 76, 76,
78, 78, 77, 77, 77, 77, 77, 77, 76, 77, 77, 77, 77, 78, 81, 86, 87, 88, 87, 87,
87, 87, 87, 86, 86, 86, 86, 87, 87, 89, 34, -80, -120, -110, -112, -111, -112,
-112, -112, -112, -111, -111, -111, -111, -113, -109, -93, -83, -83, -84, -84,
-84, -85, -84, -85, -84, -84, -84, -84, -84, -85, -84, -82, -82, -82, -82, -83,
-82, -82, -82, -83, -82, -82, -83, -82, -82, -82, -82, -81, -78, -78, -78, -78,
-78, -79, -78, -79, -79, -79, -79, -79, -78, -79, -75, -70, -69, -69, -69, -69,
-70, -69, -68, -69, -68, -70, -69, -69, -69, -69, -68, -61, -59, -59, -59, -58,
-59, -58, -58, -59, -59, -59, -59, -59, -59, -59, -58, -53, -49, -49, -49, -49,
-49, -50, -48, -49, -49, -48, -49, -48, -49, -49, -49, -47, -45, -44, -46, -45,
-46, -45, -45, -45, -45, -45, -46, -45, -45, -45, -44, -43, -42, -41, -42, -42,
-41, -41, -42, -42, -42, -42, -42, -42, -42, -41, -40, -32, -28, -29, -29, -28,
-28, -29, -29, -28, -28, -28, -29, -29, -29, -28, -29, -27, -27, -26, -28, -27,
-27, -26, -26, -27, -27, -27, -27, -26, -27, -28, -27, -26, -25, -25, -26, -25,
-26, -25, -25, -24, -25, -26, -24, -25, -25, -25, -23, -18, -16, -18, -16, -18,
-17, -17, -17, -17, -16, -17, -16, -16, -17, -16, -17, -16, -16, -15, -15, -15,
-15, -15, -15, -14, -15, -15, -16, -15, -16, -15, -15, -14, -13, -13, -14, -14,
-13, -13, -14, -13, -14, -13, -14, -13, -13, -14, -14, -13, -14, -14, -14, -14,
-13, -13, -13, -13, -14, -13, -13, -14, -14, -14, -13, -12, -12, -11, -12, -11,
-11, -12, -11, -11, -13, -11, -12, -11, -11, -12, -9, -5, -2, -2, -2, -2, -2,
-2, -2, -1, -2, -1, -1, -2, -1, -2, -1, };