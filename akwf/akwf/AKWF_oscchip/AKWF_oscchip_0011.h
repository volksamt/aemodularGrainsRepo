#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {18, 90, 107, 103, 106, 103, 106, 104,
106, 104, 105, 104, 105, 104, 104, 104, 104, 102, 103, 102, 102, 103, 102, 102,
102, 103, 103, 103, 103, 102, 101, 103, 101, 96, 94, 95, 95, 95, 95, 95, 95, 95,
95, 94, 95, 94, 94, 95, 93, 91, 91, 91, 90, 90, 91, 91, 90, 91, 91, 91, 91, 91,
90, 91, 87, 79, 79, 79, 79, 79, 79, 79, 79, 80, 79, 79, 79, 79, 79, 79, 75, 68,
68, 68, 68, 68, 67, 68, 67, 67, 67, 67, 67, 67, 67, 68, 67, 65, 64, 64, 64, 63,
64, 64, 64, 63, 64, 64, 63, 63, 64, 64, 58, 52, 52, 52, 52, 53, 52, 52, 52, 51,
52, 52, 52, 52, 52, 52, 49, 46, 46, 47, 47, 46, 47, 46, 47, 46, 46, 46, 47, 46,
46, 46, 46, 46, 45, 46, 45, 46, 46, 45, 46, 46, 46, 46, 46, 46, 46, 46, 42, 40,
41, 40, 41, 40, 41, 41, 41, 41, 40, 40, 40, 41, 40, 40, 38, 35, 35, 35, 34, 35,
35, 35, 34, 35, 34, 35, 34, 34, 34, 34, 32, 30, 31, 30, 30, 31, 31, 31, 31, 31,
31, 30, 31, 31, 30, 30, 28, 27, 27, 27, 27, 27, 27, 27, 27, 26, 27, 27, 27, 27,
26, 27, 26, 23, 23, 23, 23, 23, 22, 23, 22, 23, 22, 23, 23, 23, 22, 27, -10,
-101, -120, -115, -117, -116, -117, -116, -117, -116, -116, -117, -116, -116,
-117, -117, -113, -102, -101, -101, -101, -102, -101, -102, -101, -102, -101,
-101, -101, -102, -101, -102, -99, -96, -95, -96, -95, -96, -96, -95, -95, -95,
-95, -95, -96, -95, -95, -95, -95, -96, -96, -94, -95, -94, -94, -95, -95, -95,
-95, -95, -95, -95, -95, -95, -93, -93, -93, -92, -92, -93, -93, -92, -93, -93,
-93, -92, -92, -92, -92, -93, -88, -83, -83, -83, -83, -83, -83, -82, -83, -83,
-84, -83, -83, -84, -83, -83, -78, -73, -73, -73, -73, -73, -73, -74, -73, -73,
-73, -73, -73, -73, -73, -73, -66, -60, -60, -60, -61, -60, -60, -59, -60, -60,
-60, -60, -59, -60, -60, -60, -52, -44, -46, -45, -45, -45, -45, -45, -45, -44,
-45, -45, -46, -45, -45, -44, -38, -31, -32, -32, -32, -31, -32, -32, -32, -32,
-32, -32, -31, -31, -31, -31, -26, -22, -23, -23, -22, -22, -22, -22, -22, -23,
-23, -22, -22, -22, -23, -22, -22, -22, -22, -22, -22, -21, -22, -22, -21, -22,
-21, -22, -22, -22, -22, -21, -21, -20, -20, -20, -19, -20, -20, -19, -21, -20,
-20, -20, -21, -20, -20, -20, -19, -17, -17, -16, -15, -17, -16, -15, -16, -16,
-16, -17, -16, -16, -17, -16, -16, -12, -12, -13, -13, -12, -13, -12, -12, -13,
-12, -12, -13, -12, -12, -13, -12, -11, -11, -10, -10, -10, -11, -11, -10, -11,
-11, -10, -10, -10, -10, -11, -8, -7, -7, -7, -7, -7, -7, -6, -7, -7, -6, -6,
-7, -6, -7, -8, };