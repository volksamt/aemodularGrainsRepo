#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 8, 7, 7, 6, 8, 7, 7, 7, 7, 7, 7, 6,
7, 7, 9, 22, 27, 26, 27, 26, 26, 26, 27, 27, 27, 25, 27, 26, 27, 26, 29, 44, 48,
47, 47, 47, 47, 47, 48, 48, 48, 47, 47, 47, 46, 47, 44, 35, 32, 33, 32, 33, 33,
33, 32, 32, 32, 33, 32, 33, 33, 32, 36, 46, 48, 47, 47, 46, 47, 46, 48, 47, 47,
47, 46, 47, 47, 47, 46, 43, 43, 43, 44, 43, 43, 43, 43, 44, 43, 44, 43, 44, 43,
45, 35, 14, 11, 12, 11, 12, 11, 10, 11, 11, 11, 11, 12, 10, 12, 9, 31, 68, 71,
71, 71, 71, 71, 70, 70, 70, 71, 70, 72, 70, 72, 69, 87, 116, 119, 118, 117, 118,
118, 118, 118, 118, 118, 118, 118, 117, 118, 117, 116, 73, 39, 42, 41, 41, 41,
41, 41, 41, 41, 42, 40, 41, 41, 41, 41, 65, 81, 79, 79, 79, 79, 79, 79, 79, 79,
79, 80, 80, 79, 79, 76, 31, 0, 4, 4, 5, 3, 4, 3, 3, 3, 4, 3, 4, 3, 4, -2, -45,
-70, -66, -68, -68, -68, -67, -68, -67, -67, -67, -68, -67, -67, -67, -66, -56,
-50, -52, -52, -52, -51, -51, -52, -51, -50, -51, -51, -52, -51, -51, -50, -50,
-50, -50, -49, -50, -50, -50, -49, -49, -49, -49, -49, -49, -49, -50, -50, -47,
-48, -48, -48, -48, -47, -48, -47, -48, -47, -47, -48, -48, -47, -47, -49, -58,
-60, -60, -60, -60, -60, -60, -60, -60, -60, -60, -61, -61, -60, -61, -56, -40,
-37, -38, -37, -38, -38, -37, -38, -37, -37, -38, -38, -38, -37, -38, -36, -34,
-35, -34, -34, -35, -34, -33, -34, -34, -34, -34, -35, -33, -35, -32, -47, -79,
-85, -84, -84, -84, -84, -83, -84, -83, -84, -84, -84, -84, -83, -86, -68, -30,
-26, -27, -27, -27, -27, -28, -27, -27, -26, -27, -27, -27, -28, -27, -26, -26,
-25, -25, -26, -25, -25, -25, -25, -25, -26, -26, -26, -26, -25, -25, -24, -22,
-23, -22, -22, -22, -23, -22, -23, -22, -22, -22, -22, -22, -23, -22, -22, -20,
-21, -20, -21, -21, -20, -20, -20, -20, -20, -21, -20, -20, -20, -20, -20, -19,
-19, -18, -18, -18, -18, -19, -18, -18, -18, -18, -18, -19, -18, -19, -19, -19,
-18, -18, -18, -19, -18, -19, -18, -19, -19, -19, -18, -18, -19, -19, -19, -17,
-15, -15, -15, -15, -14, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -9,
-7, -7, -7, -7, -7, -8, -7, -8, -7, -7, -7, -7, -7, -7, -5, 8, 13, 12, 12, 12,
13, 12, 12, 12, 12, 12, 12, 12, 12, 12, 15, 29, 33, 33, 34, 33, 34, 33, 32, 33,
33, 33, 34, 33, 32, 33, 31, 17, 13, 15, 14, 14, 13, 13, 14, 14, 13, 14, 13, 14,
14, 15, 10, -3, -7, -6, -6, -6, -5, -6, -5, -6, -6, -5, -6, -6, -6, -6, -3, };