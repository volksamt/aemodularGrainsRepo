#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0077

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 11, 10, 11, 11, 10, 11, 10, 10, 10,
9, 10, 11, 10, 10, 10, 14, 19, 19, 19, 19, 19, 18, 19, 18, 19, 18, 19, 19, 19,
18, 19, 20, 23, 24, 23, 24, 23, 23, 24, 23, 24, 23, 23, 24, 23, 23, 24, 30, 32,
32, 32, 32, 33, 32, 32, 31, 33, 32, 32, 33, 32, 33, 32, 34, 37, 37, 36, 36, 36,
37, 36, 37, 36, 36, 37, 37, 36, 37, 36, 39, 45, 46, 46, 45, 46, 46, 46, 45, 46,
45, 46, 45, 45, 45, 43, -39, -86, -76, -81, -78, -81, -77, -80, -78, -80, -77,
-80, -77, -81, -77, -83, -15, 56, 47, 51, 49, 52, 48, 51, 48, 51, 49, 52, 48,
52, 46, 57, -5, -113, -117, -114, -116, -114, -115, -114, -115, -114, -115,
-114, -114, -114, -115, -110, 5, 69, 54, 62, 57, 61, 57, 60, 58, 59, 58, 59, 59,
59, 59, 59, 64, 68, 67, 68, 68, 68, 68, 67, 68, 68, 68, 67, 67, 68, 68, 68, 68,
68, 67, 68, 68, 67, 68, 67, 67, 67, 68, 68, 68, 68, 67, 67, 68, 68, 68, 68, 69,
67, 68, 67, 67, 68, 68, 67, 67, 68, 67, 68, 68, 68, 68, 68, 67, 67, 67, 67, 67,
67, 68, 67, 68, 67, 68, 67, 67, 68, 68, 68, 67, 67, 68, 66, 67, 67, 67, 67, 67,
67, 67, 68, 68, 67, 67, 67, 67, 67, 66, 67, 67, 67, 67, 68, 67, 67, 66, 67, 65,
63, 62, 63, 63, 62, 62, 62, 63, 63, 63, 63, 62, 63, 63, 61, 51, 49, 49, 49, 49,
49, 49, 49, 50, 49, 49, 49, 50, 49, 49, 49, 43, 40, 41, 40, 40, 40, 39, 40, 41,
40, 40, 40, 40, 41, 40, 40, 26, 12, 14, 13, 14, 14, 14, 13, 13, 13, 14, 12, 13,
13, 13, 11, -2, -5, -5, -5, -5, -5, -4, -5, -4, -4, -5, -5, -5, -5, -5, -5, -29,
-42, -39, -40, -40, -40, -40, -41, -39, -40, -40, -40, -40, -40, -40, -40, -38,
-36, -36, -36, -36, -35, -36, -35, -36, -35, -36, -36, -36, -36, -36, -36, -39,
-39, -41, -40, -40, -41, -41, -41, -40, -41, -41, -40, -40, -40, -40, -40, -46,
-50, -49, -50, -48, -49, -49, -50, -49, -49, -49, -49, -49, -49, -50, -48, -80,
-114, -111, -112, -110, -112, -111, -111, -110, -111, -111, -111, -111, -111,
-111, -112, -112, -111, -111, -111, -112, -111, -111, -111, -112, -110, -111,
-110, -111, -111, -111, -111, -108, -106, -107, -106, -106, -107, -107, -107,
-107, -106, -107, -107, -106, -106, -106, -107, -98, -87, -89, -89, -89, -87,
-89, -88, -89, -87, -89, -88, -88, -88, -90, -84, -55, -47, -49, -47, -48, -47,
-48, -48, -49, -48, -48, -48, -48, -48, -49, -48, -26, -15, -18, -16, -17, -17,
-17, -16, -16, -17, -17, -16, -16, -16, -16, -17, -9, -3, -4, -3, -3, -3, -3,
-3, -4, -3, -4, -3, -3, -4, -3, -1, };