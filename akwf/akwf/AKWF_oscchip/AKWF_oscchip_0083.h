#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0083

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 6, 4, 5, 5, 5, 5, 6, 4, 5, 4, 5, 5,
5, 5, 5, 10, 11, 11, 11, 11, 11, 12, 10, 10, 11, 10, 11, 12, 10, 11, 13, 16, 14,
15, 16, 15, 15, 15, 15, 15, 15, 15, 15, 14, 15, 14, 17, 23, 23, 23, 24, 23, 22,
23, 24, 23, 23, 23, 23, 22, 23, 23, 25, 31, 32, 31, 32, 31, 32, 31, 31, 31, 31,
31, 31, 31, 31, 30, 32, 33, 33, 32, 33, 34, 33, 33, 33, 33, 33, 33, 32, 32, 33,
33, 34, 35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 36, 35, 35, 35, 35, 36, 38, 40,
39, 40, 39, 39, 40, 39, 39, 40, 38, 39, 40, 39, 38, 40, 43, 43, 44, 44, 44, 43,
43, 43, 42, 43, 43, 43, 42, 43, 42, 44, 47, 47, 47, 47, 47, 47, 47, 47, 47, 47,
46, 47, 47, 48, 48, 47, 51, 51, 51, 52, 52, 51, 51, 51, 51, 52, 52, 51, 50, 51,
51, 54, 57, 57, 57, 57, 57, 57, 56, 57, 57, 57, 57, 58, 57, 57, 56, 60, 67, 67,
67, 67, 67, 67, 66, 67, 67, 67, 67, 67, 66, 67, 67, 70, 84, 88, 86, 87, 87, 87,
87, 87, 87, 87, 87, 87, 86, 88, 87, 94, 102, 101, 101, 101, 101, 101, 100, 101,
102, 101, 101, 102, 100, 102, 100, 105, 115, 115, 115, 115, 115, 115, 114, 115,
115, 115, 114, 115, 115, 115, 114, 116, 118, 119, 118, 119, 120, 118, 120, 118,
120, 118, 120, 116, 122, 114, 124, 19, -107, -99, -103, -101, -102, -102, -101,
-102, -102, -102, -101, -103, -101, -102, -101, -101, -100, -101, -99, -100,
-100, -100, -100, -100, -99, -100, -101, -99, -99, -100, -101, -98, -90, -87,
-88, -87, -87, -88, -88, -87, -88, -88, -88, -88, -87, -88, -87, -88, -90, -90,
-90, -90, -90, -89, -89, -89, -89, -89, -90, -90, -89, -89, -90, -86, -78, -77,
-78, -77, -77, -77, -77, -77, -77, -78, -77, -77, -77, -76, -76, -76, -70, -68,
-70, -69, -69, -69, -68, -68, -69, -69, -69, -69, -69, -69, -69, -65, -60, -60,
-61, -61, -61, -61, -60, -61, -60, -61, -61, -61, -60, -61, -61, -59, -57, -56,
-57, -57, -56, -56, -57, -56, -57, -57, -57, -56, -56, -56, -57, -55, -52, -52,
-53, -52, -52, -52, -52, -53, -52, -52, -52, -52, -52, -53, -52, -50, -47, -48,
-48, -48, -48, -48, -48, -48, -48, -49, -48, -48, -48, -47, -48, -45, -40, -40,
-40, -40, -40, -39, -40, -41, -40, -41, -40, -40, -40, -40, -40, -36, -35, -36,
-36, -36, -36, -35, -35, -36, -36, -36, -36, -36, -36, -35, -35, -33, -30, -30,
-30, -30, -30, -30, -30, -29, -29, -30, -30, -30, -30, -29, -29, -26, -20, -19,
-20, -19, -20, -19, -20, -20, -20, -19, -20, -19, -19, -19, -19, -13, -8, -9,
-9, -10, -10, -9, -9, -10, -9, -9, -9, -9, -10, -8, -9, -4, };