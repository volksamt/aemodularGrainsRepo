#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0060

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 9, 7, 8, 8, 7, 7, 7, 8, 7, 8, 7,
7, 7, 7, 9, 13, 15, 16, 15, 16, 15, 16, 15, 15, 16, 15, 15, 16, 15, 15, 16, 17,
20, 20, 21, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 21, 23, 23, 24, 23, 23,
24, 23, 24, 23, 24, 23, 23, 23, 23, 24, 24, 26, 26, 27, 26, 26, 27, 26, 26, 26,
27, 26, 26, 26, 26, 26, 26, 27, 27, 28, 27, 29, 28, 27, 29, 28, 28, 28, 28, 28,
27, 28, 28, 29, 30, 32, 31, 31, 31, 31, 31, 32, 31, 31, 31, 30, 32, 30, 50, 99,
120, 115, 116, 115, 117, 115, 115, 116, 116, 116, 115, 116, 115, 118, 110, 82,
62, 63, 64, 64, 63, 63, 63, 63, 63, 63, 64, 64, 64, 63, 63, 51, 37, 36, 36, 36,
37, 37, 37, 36, 36, 37, 37, 36, 36, 36, 37, 30, 20, 17, 17, 18, 18, 18, 17, 18,
17, 17, 17, 18, 17, 18, 15, 7, 3, 4, 3, 3, 4, 3, 3, 3, 3, 3, 3, 3, 3, 4, 2, -5,
-11, -11, -12, -12, -12, -11, -11, -12, -11, -12, -11, -11, -11, -11, -11, -14,
-19, -19, -19, -19, -19, -19, -20, -20, -20, -19, -19, -20, -19, -19, -19, -20,
-21, -21, -21, -21, -21, -21, -21, -21, -20, -20, -20, -21, -20, -20, -21, -20,
-20, -20, -21, -20, -21, -21, -20, -21, -20, -21, -21, -20, -21, -20, -21, -21,
-23, -22, -23, -22, -23, -22, -22, -22, -22, -22, -22, -22, -22, -22, -22, -22,
-22, -22, -22, -22, -22, -22, -22, -21, -22, -23, -22, -22, -22, -22, -22, -23,
-24, -23, -24, -24, -23, -24, -24, -24, -23, -24, -24, -24, -23, -24, -24, -25,
-25, -25, -25, -25, -25, -25, -25, -25, -24, -25, -25, -24, -25, -26, -25, -25,
-25, -25, -25, -25, -26, -25, -25, -24, -25, -25, -25, -24, -25, -25, -26, -26,
-27, -26, -26, -27, -26, -27, -27, -27, -26, -26, -27, -27, -27, -27, -26, -26,
-26, -27, -27, -26, -26, -26, -25, -26, -26, -26, -27, -26, -26, -27, -26, -25,
-25, -25, -24, -25, -25, -24, -25, -24, -24, -24, -24, -25, -25, -25, -25, -25,
-24, -25, -25, -24, -24, -25, -24, -24, -24, -24, -24, -24, -25, -25, -23, -21,
-21, -21, -21, -21, -22, -22, -22, -22, -22, -22, -22, -21, -21, -21, -21, -20,
-19, -19, -20, -20, -20, -20, -19, -19, -19, -20, -20, -19, -20, -20, -20, -20,
-19, -20, -19, -19, -20, -20, -20, -20, -19, -19, -20, -20, -19, -20, -19, -18,
-17, -16, -16, -17, -16, -16, -16, -16, -16, -16, -16, -16, -17, -17, -15, -12,
-11, -11, -12, -11, -12, -12, -11, -12, -12, -12, -11, -12, -11, -11, -11, -11,
-10, -10, -9, -10, -9, -9, -11, -10, -9, -9, -10, -10, -10, -10, -10, -6, -2,
-1, -2, -3, -3, -3, -1, -2, -1, -2, -2, -1, -2, -1, };