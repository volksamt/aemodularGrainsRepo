#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0037

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 6, 6, 6, 6, 6, 6, 7, 6, 5, 6, 6, 6,
6, 6, 11, 19, 23, 21, 21, 22, 21, 22, 22, 22, 22, 22, 22, 21, 21, 22, 24, 35,
42, 40, 41, 40, 41, 41, 40, 40, 40, 40, 40, 41, 41, 41, 47, 53, 54, 53, 53, 52,
53, 53, 54, 52, 53, 53, 53, 52, 53, 53, 58, 65, 66, 65, 65, 65, 65, 65, 66, 65,
65, 66, 65, 65, 65, 65, 68, 73, 75, 75, 75, 75, 74, 74, 75, 74, 74, 74, 75, 74,
74, 76, 83, 88, 87, 87, 86, 87, 87, 87, 87, 87, 86, 87, 87, 87, 87, 87, 78, 68,
68, 68, 68, 67, 68, 68, 67, 68, 68, 68, 67, 68, 67, 68, 50, 17, 9, 11, 11, 11,
11, 11, 10, 11, 10, 10, 11, 11, 11, 12, 4, -19, -31, -30, -30, -31, -30, -31,
-30, -30, -31, -30, -30, -30, -29, -35, -78, -113, -113, -111, -112, -112, -112,
-112, -111, -111, -112, -113, -112, -112, -112, -111, -53, 23, 35, 30, 32, 32,
32, 31, 30, 31, 31, 31, 31, 32, 32, 31, 31, 32, 32, 31, 32, 32, 31, 31, 31, 32,
31, 31, 31, 31, 32, 31, 31, 32, 31, 31, 32, 31, 31, 31, 31, 31, 31, 32, 32, 31,
32, 31, 30, 30, 30, 30, 30, 30, 29, 29, 30, 30, 30, 30, 30, 30, 30, 29, 27, 25,
25, 25, 24, 24, 25, 25, 24, 25, 24, 25, 25, 24, 25, 24, 37, 74, 89, 87, 87, 87,
87, 87, 87, 87, 87, 87, 87, 87, 86, 87, 86, 87, 87, 87, 87, 87, 87, 87, 86, 87,
87, 87, 87, 86, 87, 85, 58, 29, 24, 26, 25, 26, 25, 25, 26, 26, 25, 26, 26, 26,
26, 26, 25, 23, 24, 24, 24, 24, 24, 23, 24, 23, 25, 24, 23, 23, 24, 24, 24, 24,
24, 24, 24, 23, 24, 24, 24, 24, 23, 24, 23, 24, 24, 23, 24, 24, 24, 24, 24, 24,
24, 24, 23, 24, 24, 23, 23, 24, 24, 24, 24, 23, 23, 24, 23, 24, 23, 24, 24, 24,
23, 24, 23, 24, 24, 26, -12, -90, -121, -114, -115, -114, -115, -115, -115,
-115, -115, -115, -115, -115, -115, -115, -115, -115, -114, -115, -114, -115,
-114, -114, -114, -114, -115, -115, -115, -114, -115, -115, -115, -114, -115,
-114, -114, -115, -114, -115, -115, -114, -114, -114, -114, -114, -114, -114,
-113, -114, -114, -114, -115, -114, -114, -115, -115, -113, -113, -113, -114,
-113, -114, -114, -114, -114, -114, -114, -114, -114, -114, -114, -114, -114,
-113, -114, -114, -113, -113, -112, -113, -113, -113, -113, -113, -113, -113,
-113, -113, -114, -113, -113, -112, -114, -112, -113, -112, -112, -112, -113,
-113, -113, -113, -113, -112, -112, -113, -112, -113, -112, -113, -113, -54, 60,
96, 86, 90, 88, 89, 88, 89, 89, 89, 88, 88, 88, 90, 74, 16, -17, -13, -13, -14,
-13, -14, -12, -13, -13, -13, -13, -14, -13, -13, -12, -3, };