#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0115

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 26, 21, 23, 22, 23, 22, 22, 23,
23, 22, 22, 23, 22, 21, 27, 91, 122, 114, 117, 115, 117, 116, 117, 116, 116,
116, 116, 116, 116, 116, 115, 116, 117, 116, 116, 116, 117, 116, 116, 116, 116,
117, 116, 116, 116, 116, 116, 116, 116, 116, 116, 115, 115, 116, 116, 115, 116,
115, 115, 115, 115, 116, 116, 117, 118, 118, 118, 117, 118, 117, 118, 117, 117,
117, 117, 118, 117, 117, 117, 117, 117, 117, 116, 117, 117, 118, 116, 117, 117,
117, 117, 118, 116, 119, 109, 69, 60, 62, 60, 62, 61, 61, 60, 61, 61, 61, 61,
61, 61, 62, 60, 61, 61, 60, 60, 62, 61, 62, 61, 61, 62, 61, 61, 60, 61, 61, 62,
60, 60, 61, 61, 61, 61, 61, 61, 61, 60, 61, 61, 61, 61, 61, 60, 61, 60, 61, 61,
62, 61, 61, 61, 61, 60, 61, 60, 61, 61, 60, 60, 60, 61, 61, 60, 60, 61, 61, 61,
61, 60, 61, 61, 61, 60, 60, 61, 53, 47, 48, 48, 48, 48, 49, 48, 48, 47, 47, 47,
48, 47, 47, 46, 41, 40, 41, 41, 40, 41, 41, 41, 40, 41, 40, 41, 40, 41, 41, 40,
36, 35, 35, 35, 35, 35, 35, 35, 35, 35, 34, 35, 36, 34, 35, 34, 33, 32, 31, 30,
31, 31, 31, 30, 32, 31, 31, 31, 32, 30, 34, 13, -64, -83, -79, -81, -80, -81,
-80, -81, -80, -81, -80, -81, -80, -81, -80, -79, -73, -69, -69, -70, -69, -70,
-70, -69, -70, -69, -70, -69, -70, -70, -69, -69, -57, -48, -48, -47, -47, -48,
-48, -48, -48, -47, -48, -48, -48, -48, -48, -46, -39, -36, -38, -37, -37, -38,
-36, -36, -37, -37, -37, -37, -36, -37, -37, -36, -26, -22, -23, -22, -23, -22,
-23, -23, -23, -22, -23, -22, -22, -22, -23, -19, -12, -11, -12, -11, -12, -11,
-12, -12, -12, -12, -12, -11, -12, -11, -12, -9, 1, 4, 3, 3, 2, 2, 3, 3, 2, 3,
3, 3, 3, 3, 3, 3, 10, 13, 13, 12, 12, 11, 13, 12, 12, 11, 13, 11, 13, 11, 16,
-20, -89, -91, -90, -91, -90, -91, -91, -90, -90, -91, -91, -91, -90, -92, -90,
-91, -91, -90, -91, -91, -90, -91, -91, -90, -91, -91, -90, -90, -90, -91, -90,
-90, -90, -90, -91, -91, -90, -90, -90, -90, -91, -90, -91, -90, -90, -90, -91,
-90, -90, -90, -91, -91, -90, -90, -90, -90, -90, -91, -90, -90, -90, -90, -90,
-90, -90, -90, -90, -90, -90, -90, -90, -91, -90, -90, -89, -90, -89, -90, -90,
-90, -89, -90, -90, -89, -90, -90, -90, -90, -90, -90, -89, -90, -89, -90, -90,
-89, -89, -89, -90, -89, -91, -90, -90, -90, -89, -90, -90, -90, -90, -90, -89,
-90, -90, -90, -90, -89, -89, -90, -90, -89, -90, -90, -90, -90, -90, -89, -89,
-89, -89, -89, -90, -88, -90, -89, -90, -88, -90, -89, -90, -88, -91, -87, -94,
-55, };