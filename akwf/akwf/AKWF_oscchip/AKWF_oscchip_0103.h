#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0103

const PROGMEM int8_t DATA[DATA_LENGTH] = {21, 98, 109, 105, 106, 105, 107, 105,
106, 105, 107, 106, 107, 105, 106, 105, 105, 97, 94, 95, 94, 95, 94, 95, 95, 95,
94, 95, 95, 95, 95, 96, 89, 80, 81, 80, 80, 81, 80, 80, 79, 80, 80, 81, 80, 80,
80, 80, 74, 57, 54, 55, 54, 54, 54, 54, 54, 54, 53, 53, 53, 54, 53, 54, 56, 68,
73, 72, 72, 72, 72, 73, 72, 72, 72, 73, 73, 73, 72, 73, 59, 36, 36, 36, 36, 35,
36, 35, 36, 35, 36, 35, 36, 35, 38, 33, 52, 111, 120, 117, 118, 118, 118, 117,
118, 117, 119, 117, 119, 117, 118, 118, 118, 113, 112, 113, 112, 113, 112, 111,
113, 112, 112, 113, 112, 113, 112, 113, 108, 102, 102, 102, 100, 101, 101, 101,
101, 101, 101, 101, 101, 101, 101, 101, 98, 91, 90, 90, 89, 90, 89, 90, 89, 90,
89, 90, 90, 90, 90, 90, 89, 78, 75, 76, 75, 75, 75, 75, 74, 75, 74, 75, 75, 75,
74, 75, 69, 60, 60, 60, 59, 60, 60, 61, 61, 60, 60, 59, 59, 61, 60, 61, 58, 50,
48, 49, 49, 49, 49, 48, 49, 48, 49, 48, 48, 49, 48, 49, 29, 10, 14, 12, 12, 13,
12, 12, 12, 13, 11, 14, 11, 14, 9, 15, -31, -101, -101, -102, -101, -102, -102,
-102, -102, -102, -101, -102, -102, -102, -102, -103, -99, -88, -87, -87, -87,
-87, -88, -87, -87, -87, -86, -87, -87, -88, -87, -87, -80, -75, -75, -76, -76,
-76, -75, -76, -76, -76, -76, -76, -76, -77, -75, -76, -70, -61, -61, -61, -61,
-61, -60, -62, -61, -61, -61, -61, -61, -61, -61, -62, -59, -51, -50, -50, -49,
-50, -50, -50, -50, -50, -50, -51, -50, -50, -50, -51, -35, -23, -24, -24, -24,
-24, -24, -24, -24, -24, -24, -24, -24, -25, -23, -25, -16, -4, -4, -4, -3, -4,
-4, -4, -3, -4, -4, -4, -4, -4, -3, -5, -3, 4, 5, 3, 3, 4, 3, 3, 4, 3, 4, 4, 4,
4, 2, 4, -46, -90, -84, -88, -85, -86, -87, -87, -87, -86, -87, -86, -87, -86,
-87, -86, -94, -104, -105, -104, -105, -105, -105, -105, -105, -104, -105, -104,
-104, -104, -105, -105, -103, -98, -97, -98, -98, -97, -97, -97, -97, -97, -98,
-97, -97, -96, -96, -98, -91, -86, -86, -85, -86, -86, -86, -87, -86, -86, -86,
-86, -86, -86, -86, -86, -85, -82, -82, -82, -82, -82, -82, -82, -82, -83, -82,
-81, -82, -81, -83, -82, -81, -75, -74, -74, -74, -74, -75, -75, -74, -74, -74,
-75, -75, -74, -74, -74, -68, -63, -63, -63, -64, -63, -63, -63, -63, -63, -63,
-64, -63, -63, -63, -64, -58, -49, -49, -48, -48, -49, -48, -48, -48, -48, -48,
-49, -48, -49, -47, -50, -42, -15, -11, -13, -11, -12, -10, -11, -11, -12, -11,
-12, -12, -12, -11, -12, -6, -2, -3, -3, -2, -2, -3, -3, -3, -2, -3, -2, -3, -2,
-3, -4, };