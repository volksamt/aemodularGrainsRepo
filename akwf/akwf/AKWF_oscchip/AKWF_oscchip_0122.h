#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0122

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 7, 8, 8, 7, 8, 7, 7, 7, 8, 7, 8, 8,
8, 7, 10, 11, 11, 11, 11, 11, 11, 11, 11, 10, 10, 11, 11, 10, 12, 11, 12, 12,
13, 13, 13, 13, 13, 13, 13, 12, 12, 13, 13, 13, 12, 13, 15, 15, 15, 15, 15, 14,
15, 14, 14, 14, 15, 15, 14, 15, 15, 15, 16, 17, 16, 16, 16, 17, 16, 17, 17, 17,
17, 17, 16, 16, 17, 16, 18, 19, 18, 18, 19, 17, 18, 18, 18, 18, 18, 19, 18, 18,
18, 19, 20, 20, 21, 20, 19, 19, 20, 21, 20, 20, 20, 21, 20, 20, 20, 22, 25, 26,
25, 26, 25, 26, 26, 26, 25, 26, 26, 26, 25, 26, 25, 26, 27, 27, 27, 28, 27, 28,
27, 28, 28, 28, 26, 28, 27, 27, 27, 36, 90, 120, 115, 116, 116, 116, 116, 115,
116, 116, 116, 116, 116, 116, 115, 116, 115, 115, 115, 116, 116, 116, 115, 117,
115, 116, 116, 115, 116, 115, 115, 116, 116, 116, 116, 116, 116, 115, 116, 116,
116, 116, 116, 115, 116, 116, 116, 115, 116, 117, 115, 116, 115, 115, 116, 116,
115, 116, 116, 116, 116, 115, 116, 116, 116, 116, 115, 115, 116, 116, 115, 116,
116, 116, 115, 116, 116, 116, 116, 116, 116, 116, 116, 115, 115, 115, 116, 116,
116, 116, 115, 115, 116, 116, 116, 115, 117, 115, 115, 115, 116, 116, 115, 116,
115, 116, 115, 115, 116, 116, 116, 116, 115, 115, 116, 116, 115, 116, 116, 116,
116, 116, 115, 116, 115, 116, 116, 116, 116, 116, 116, 115, 116, 116, 115, 117,
116, 116, 115, 116, 115, 115, 116, 116, 116, 116, 116, 116, 116, 116, 116, 116,
117, 115, 116, 115, 116, 114, 119, 40, -82, -93, -88, -90, -89, -90, -89, -89,
-89, -91, -89, -90, -89, -90, -89, -90, -89, -90, -89, -90, -89, -89, -89, -89,
-90, -89, -90, -89, -90, -90, -89, -88, -82, -80, -81, -80, -80, -80, -80, -80,
-80, -80, -80, -81, -80, -81, -80, -80, -79, -78, -78, -79, -79, -78, -79, -78,
-79, -79, -79, -79, -79, -78, -79, -73, -65, -63, -64, -64, -64, -63, -64, -63,
-64, -63, -64, -64, -65, -64, -65, -57, -39, -36, -37, -36, -36, -37, -36, -37,
-36, -37, -36, -37, -36, -36, -37, -36, -33, -32, -33, -33, -34, -33, -32, -33,
-33, -33, -34, -33, -33, -32, -34, -32, -27, -23, -24, -24, -23, -23, -24, -23,
-23, -24, -24, -24, -23, -23, -24, -22, -20, -19, -20, -21, -20, -20, -19, -21,
-20, -20, -20, -20, -19, -20, -19, -38, -78, -86, -83, -84, -84, -85, -83, -83,
-84, -83, -84, -84, -83, -84, -84, -83, -78, -77, -77, -76, -76, -77, -76, -76,
-76, -76, -77, -77, -77, -77, -77, -76, -67, -61, -62, -62, -62, -62, -62, -62,
-62, -62, -62, -63, -62, -62, -62, -61, -58, -58, -58, -58, -59, -58, -59, -58,
-58, -57, -59, -58, -59, -58, -60, -38, 0, };