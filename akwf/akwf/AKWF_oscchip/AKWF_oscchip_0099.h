#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0099

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 41, 39, 39, 39, 39, 40, 38, 39, 39,
40, 38, 38, 39, 39, 40, 34, 20, 20, 19, 20, 20, 20, 19, 19, 20, 19, 19, 20, 20,
19, 21, 52, 68, 65, 67, 65, 67, 66, 67, 66, 67, 66, 67, 66, 67, 67, 68, 42, 17,
20, 19, 20, 18, 20, 19, 19, 19, 20, 19, 21, 19, 21, 15, 47, 100, 100, 100, 99,
99, 100, 99, 100, 99, 101, 99, 99, 98, 100, 99, 102, 104, 104, 103, 104, 103,
103, 103, 103, 103, 102, 104, 103, 104, 102, 105, 63, 22, 26, 24, 26, 23, 25,
24, 25, 24, 25, 24, 25, 24, 26, 23, 52, 102, 103, 103, 103, 103, 103, 103, 102,
103, 104, 102, 103, 102, 103, 103, 101, 101, 101, 101, 101, 101, 101, 101, 101,
101, 100, 101, 102, 101, 101, 101, 100, 99, 98, 98, 99, 99, 100, 99, 99, 99, 99,
98, 99, 99, 98, 99, 97, 94, 95, 94, 95, 95, 95, 95, 95, 95, 95, 94, 94, 95, 94,
94, 91, 89, 89, 88, 89, 89, 89, 88, 88, 88, 88, 89, 89, 89, 88, 89, 87, 84, 85,
84, 85, 85, 84, 85, 84, 84, 84, 84, 84, 84, 84, 84, 80, 73, 73, 72, 72, 73, 73,
72, 72, 72, 72, 73, 72, 73, 73, 72, 70, 68, 68, 68, 69, 69, 68, 69, 69, 68, 68,
68, 68, 69, 68, 69, 56, 43, 45, 44, 46, 45, 45, 45, 46, 44, 45, 45, 45, 44, 45,
41, 23, 18, 19, 19, 19, 19, 19, 19, 20, 19, 19, 20, 19, 19, 19, 18, 0, -10, -7,
-9, -8, -9, -8, -8, -8, -9, -9, -9, -9, -9, -8, -9, -10, -13, -12, -13, -13,
-13, -12, -12, -12, -12, -12, -12, -12, -13, -11, -17, -41, -50, -47, -48, -47,
-49, -47, -48, -48, -48, -47, -48, -48, -47, -47, -48, -59, -64, -63, -64, -64,
-63, -62, -64, -63, -64, -63, -63, -63, -63, -64, -63, -69, -75, -75, -75, -75,
-75, -75, -75, -75, -75, -75, -75, -75, -76, -75, -76, -88, -92, -90, -91, -90,
-91, -91, -90, -90, -91, -91, -90, -91, -90, -90, -91, -93, -94, -93, -95, -95,
-94, -94, -94, -94, -94, -95, -94, -94, -95, -94, -94, -99, -106, -106, -106,
-106, -107, -106, -107, -105, -106, -106, -105, -106, -106, -106, -106, -109,
-110, -110, -109, -109, -110, -109, -109, -109, -109, -109, -110, -109, -110,
-109, -110, -115, -118, -117, -118, -117, -118, -117, -117, -118, -117, -117,
-118, -116, -117, -117, -117, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -120, -117, -109, -106, -107, -107, -107,
-107, -107, -106, -107, -107, -107, -107, -108, -107, -106, -107, -96, -91, -92,
-91, -91, -91, -91, -91, -91, -91, -91, -91, -90, -92, -90, -91, -83, -75, -76,
-76, -75, -75, -75, -74, -75, -76, -75, -75, -76, -75, -76, -70, -43, -34, -37,
-35, -37, -35, -36, -34, -37, -35, -36, -34, -37, -34, -37, -29, };