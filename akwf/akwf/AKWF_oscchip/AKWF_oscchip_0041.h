#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0041

const PROGMEM int8_t DATA[DATA_LENGTH] = {20, 85, 110, 105, 106, 106, 106, 106,
107, 106, 106, 107, 106, 105, 106, 105, 103, 103, 103, 102, 102, 103, 103, 103,
103, 103, 103, 102, 102, 103, 103, 102, 101, 99, 98, 98, 98, 99, 99, 98, 98, 98,
98, 99, 98, 98, 98, 99, 94, 89, 88, 88, 87, 87, 88, 88, 87, 88, 88, 87, 89, 89,
88, 87, 85, 84, 84, 84, 85, 84, 84, 84, 84, 83, 84, 84, 84, 84, 85, 84, 82, 80,
80, 80, 80, 80, 80, 80, 80, 80, 80, 80, 80, 79, 80, 80, 78, 75, 75, 75, 74, 75,
74, 74, 75, 75, 74, 74, 74, 74, 75, 75, 75, 73, 73, 74, 73, 73, 72, 73, 73, 72,
73, 73, 72, 72, 72, 72, 66, 61, 62, 63, 61, 62, 62, 61, 61, 62, 61, 62, 63, 62,
61, 61, 59, 59, 58, 59, 58, 57, 57, 59, 58, 58, 59, 57, 58, 58, 58, 58, 55, 52,
51, 52, 51, 51, 51, 50, 51, 51, 50, 51, 51, 51, 51, 50, 45, 43, 43, 44, 43, 44,
45, 43, 44, 44, 44, 44, 44, 43, 45, 42, 37, 32, 34, 33, 33, 33, 33, 33, 33, 33,
34, 32, 33, 33, 33, 32, 26, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 18, 19, 18,
19, 19, 14, 5, 2, 4, 3, 4, 4, 3, 4, 3, 3, 4, 3, 3, 6, -18, -85, -120, -114,
-114, -115, -115, -115, -115, -115, -114, -115, -114, -115, -114, -115, -114,
-103, -94, -94, -94, -94, -93, -94, -94, -94, -95, -93, -94, -94, -93, -94, -93,
-83, -70, -69, -69, -69, -69, -69, -69, -70, -69, -69, -69, -69, -68, -68, -68,
-67, -60, -58, -58, -59, -59, -58, -59, -59, -58, -59, -59, -59, -59, -59, -56,
-49, -44, -44, -44, -43, -44, -45, -45, -44, -44, -44, -44, -44, -44, -45, -44,
-38, -34, -34, -34, -34, -33, -35, -34, -34, -33, -34, -34, -34, -34, -34, -33,
-28, -21, -19, -20, -19, -20, -20, -20, -20, -19, -20, -19, -19, -20, -20, -17,
-9, -5, -6, -6, -6, -5, -6, -5, -6, -5, -5, -6, -6, -6, -5, -16, -69, -107,
-106, -105, -105, -105, -104, -105, -105, -104, -105, -105, -105, -104, -105,
-104, -102, -101, -101, -101, -101, -100, -101, -101, -101, -101, -101, -102,
-101, -100, -101, -102, -97, -92, -90, -90, -89, -89, -90, -89, -89, -90, -90,
-90, -90, -91, -90, -87, -77, -72, -72, -72, -73, -73, -72, -73, -72, -72, -72,
-72, -72, -72, -72, -71, -63, -55, -55, -55, -55, -55, -55, -54, -55, -55, -55,
-54, -55, -54, -55, -55, -48, -40, -39, -39, -39, -39, -39, -39, -39, -39, -39,
-38, -39, -39, -39, -38, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -36,
-37, -36, -36, -36, -35, -25, -20, -21, -21, -21, -21, -21, -21, -21, -20, -21,
-21, -21, -20, -21, -21, -16, -11, -10, -11, -11, -10, -11, -10, -11, -11, -11,
-11, -10, -9, -11, -9, };