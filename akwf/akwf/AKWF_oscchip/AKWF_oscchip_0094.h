#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0094

const PROGMEM int8_t DATA[DATA_LENGTH] = {47, 119, 107, 113, 111, 111, 111, 111,
111, 111, 112, 111, 111, 110, 111, 111, 110, 105, 108, 106, 108, 106, 107, 106,
107, 107, 107, 107, 106, 107, 107, 105, 96, 94, 94, 95, 95, 93, 94, 94, 94, 94,
94, 94, 94, 95, 93, 94, 91, 89, 90, 90, 90, 89, 90, 90, 90, 90, 90, 90, 90, 90,
90, 90, 75, 61, 62, 61, 62, 63, 62, 63, 62, 62, 63, 62, 62, 62, 61, 63, 71, 73,
73, 73, 73, 73, 72, 73, 73, 72, 73, 72, 72, 73, 73, 72, 51, 39, 42, 41, 41, 41,
41, 40, 41, 41, 42, 41, 41, 40, 41, 40, 47, 51, 51, 51, 51, 52, 52, 51, 51, 51,
51, 51, 51, 51, 51, 51, 48, 47, 47, 47, 47, 47, 47, 46, 47, 47, 47, 47, 47, 47,
46, 46, 45, 42, 43, 42, 43, 43, 43, 43, 42, 42, 42, 43, 42, 43, 42, 43, 41, 39,
39, 38, 39, 39, 39, 38, 39, 38, 39, 38, 38, 39, 39, 36, 24, 21, 22, 21, 22, 22,
22, 21, 22, 22, 22, 22, 22, 22, 21, 21, 20, 19, 19, 19, 19, 19, 19, 19, 20, 19,
20, 20, 20, 19, 20, 19, 18, 15, 16, 15, 16, 15, 15, 14, 15, 15, 16, 15, 15, 15,
15, 14, 5, 2, 3, 2, 3, 2, 3, 3, 3, 2, 3, 2, 3, 2, 2, 2, 0, -2, -2, -2, -1, -2,
-2, -2, -2, -2, -3, -2, -1, -2, -2, -2, -3, -4, -4, -4, -3, -3, -4, -3, -4, -4,
-4, -4, -4, -4, -4, -5, -10, -13, -12, -12, -12, -12, -12, -12, -12, -13, -12,
-13, -11, -12, -12, -12, -15, -16, -16, -17, -17, -16, -17, -16, -16, -16, -17,
-17, -16, -16, -17, -16, -18, -18, -18, -18, -18, -19, -18, -19, -18, -18, -19,
-18, -18, -19, -19, -20, -24, -25, -25, -25, -25, -25, -24, -25, -25, -25, -25,
-25, -25, -25, -25, -25, -26, -27, -26, -28, -27, -28, -27, -28, -27, -27, -27,
-28, -27, -27, -27, -32, -44, -46, -46, -46, -45, -45, -46, -46, -46, -46, -46,
-47, -46, -46, -45, -44, -35, -32, -34, -32, -33, -33, -33, -32, -33, -33, -34,
-33, -33, -33, -33, -33, -39, -42, -41, -41, -41, -41, -41, -42, -42, -42, -41,
-42, -41, -42, -40, -49, -68, -69, -68, -68, -68, -69, -69, -69, -68, -68, -68,
-68, -68, -70, -68, -69, -71, -71, -71, -71, -71, -71, -70, -71, -71, -71, -70,
-70, -71, -71, -71, -70, -72, -72, -73, -73, -73, -72, -73, -73, -72, -73, -73,
-73, -73, -72, -73, -69, -59, -58, -58, -58, -58, -58, -57, -58, -58, -57, -58,
-59, -58, -57, -57, -64, -91, -99, -97, -98, -97, -98, -97, -98, -98, -98, -98,
-98, -98, -98, -97, -98, -105, -109, -107, -108, -108, -108, -107, -108, -107,
-108, -107, -108, -108, -109, -108, -110, -115, -115, -117, -116, -116, -116,
-117, -115, -117, -115, -118, -114, -119, -112, -122, -83, };