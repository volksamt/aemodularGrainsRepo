#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0044

const PROGMEM int8_t DATA[DATA_LENGTH] = {16, 22, 18, 21, 19, 21, 20, 20, 19,
20, 20, 20, 20, 20, 20, 21, 20, 19, 20, 20, 20, 21, 20, 19, 20, 20, 21, 19, 20,
20, 20, 20, 20, 21, 20, 20, 20, 19, 20, 20, 20, 19, 20, 20, 20, 20, 21, 19, 16,
14, 14, 15, 14, 15, 15, 15, 14, 15, 14, 14, 15, 14, 15, 14, 14, 15, 14, 15, 14,
14, 15, 14, 14, 15, 14, 14, 15, 14, 14, 15, 16, 16, 16, 16, 16, 16, 16, 16, 16,
16, 15, 16, 16, 16, 16, 16, 16, 17, 17, 17, 17, 17, 17, 17, 17, 18, 17, 17, 18,
17, 17, 15, 16, 15, 16, 15, 16, 16, 15, 15, 16, 15, 16, 16, 16, 16, 15, 18, 21,
22, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 18, 16, 15, 16, 15, 15,
15, 16, 15, 15, 16, 16, 15, 16, 15, 15, 15, 16, 16, 16, 15, 16, 15, 15, 15, 16,
15, 16, 15, 15, 16, 15, 14, 13, 14, 14, 14, 14, 14, 13, 13, 14, 13, 14, 14, 13,
14, 15, 14, 13, 14, 13, 14, 15, 14, 14, 14, 14, 14, 14, 14, 13, 14, 13, 14, 13,
14, 13, 14, 13, 14, 14, 14, 14, 14, 14, 14, 14, 13, 13, 14, 15, 14, 13, 13, 14,
13, 14, 13, 14, 13, 15, 14, 14, 14, 14, 13, 13, 14, 14, 14, 14, 13, 14, 14, 13,
14, 13, 13, 14, 14, 14, 14, 14, 13, 14, 14, 13, 13, 14, 13, 13, 13, 13, 13, 13,
14, 13, 14, 13, 14, 14, 13, 14, 13, 13, 13, 13, 13, 14, 13, 13, 13, 20, 32, 39,
37, 38, 38, 37, 37, 37, 38, 37, 37, 38, 38, 38, 38, 38, 36, 36, 36, 36, 36, 36,
35, 36, 36, 36, 36, 36, 36, 36, 36, 35, 31, 27, 28, 27, 27, 27, 27, 28, 27, 28,
28, 27, 27, 27, 27, 27, 26, 24, 25, 25, 25, 25, 24, 24, 24, 25, 24, 24, 25, 24,
25, 23, 20, 19, 19, 19, 19, 18, 19, 18, 19, 19, 19, 18, 18, 19, 19, 18, 15, 13,
13, 13, 13, 13, 13, 12, 13, 13, 14, 13, 13, 13, 13, 12, 8, 4, 4, 4, 4, 4, 4, 4,
5, 5, 4, 4, 4, 5, 4, 0, -5, -7, -6, -7, -7, -7, -6, -6, -7, -7, -6, -7, -6, -7,
-7, -10, -18, -20, -19, -20, -19, -20, -20, -19, -20, -20, -19, -20, -19, -21,
-18, -35, -88, -119, -115, -116, -116, -116, -116, -115, -115, -115, -115, -116,
-115, -115, -115, -114, -105, -98, -98, -99, -99, -98, -99, -98, -98, -98, -98,
-98, -98, -98, -98, -90, -80, -78, -79, -78, -78, -78, -78, -78, -78, -78, -78,
-79, -78, -78, -78, -76, -71, -69, -69, -69, -70, -69, -69, -69, -69, -70, -70,
-70, -69, -69, -70, -67, -61, -58, -58, -57, -58, -58, -58, -58, -58, -58, -58,
-57, -58, -57, -60, -51, -14, };