#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 17, 15, 16, 16, 15, 15, 15, 15,
16, 15, 16, 15, 15, 15, 16, 16, 16, 16, 18, 18, 18, 18, 17, 18, 19, 18, 18, 17,
19, 17, 17, 17, 18, 18, 19, 18, 18, 0, 8, 95, 120, 110, 115, 112, 114, 113, 114,
113, 114, 113, 113, 114, 113, 113, 113, 114, 114, 113, 109, 107, 106, 107, 106,
106, 106, 106, 106, 106, 106, 107, 106, 105, 106, 106, 105, 106, 106, 104, 98,
94, 94, 95, 94, 95, 94, 95, 95, 94, 94, 94, 95, 94, 95, 95, 94, 94, 94, 88, 81,
80, 81, 81, 80, 80, 80, 80, 80, 80, 80, 81, 81, 80, 80, 80, 80, 81, 77, 64, 54,
56, 56, 55, 55, 55, 55, 55, 54, 54, 55, 55, 54, 56, 54, 56, 55, 55, 48, 33, 29,
30, 30, 29, 30, 30, 30, 31, 29, 30, 30, 30, 30, 30, 30, 29, 30, 28, 17, 5, 5, 5,
4, 5, 4, 5, 5, 5, 5, 4, 4, 5, 4, 5, 4, 4, 5, 1, -10, -15, -14, -13, -14, -13,
-14, -13, -14, -15, -14, -13, -14, -14, -14, -14, -14, -13, -14, -18, -26, -28,
-28, -27, -27, -27, -27, -28, -27, -27, -27, -26, -27, -28, -27, -27, -28, -28,
-28, -31, -34, -35, -34, -34, -34, -34, -34, -34, -34, -34, -34, -35, -34, -34,
-34, -35, -34, -34, -34, -35, -36, -37, -36, -36, -36, -36, -36, -36, -36, -36,
-35, -36, -37, -37, -36, -37, -36, -37, -36, -36, -35, -36, -35, -36, -37, -36,
-37, -36, -36, -36, -36, -36, -36, -37, -35, -36, -36, -35, -36, -37, -35, -36,
-35, -36, -36, -36, -36, -36, -36, -36, -35, -36, -36, -36, -35, -36, -36, -36,
-36, -36, -36, -35, -36, -35, -35, -35, -36, -35, -36, -36, -35, -35, -36, -36,
-36, -35, -35, -36, -35, -36, -35, -36, -36, -36, -36, -35, -35, -36, -35, -36,
-36, -35, -35, -35, -35, -35, -37, -16, 27, 43, 38, 39, 40, 39, 38, 39, 40, 39,
40, 39, 39, 39, 40, 39, 39, 40, 37, 2, -37, -39, -37, -38, -38, -38, -37, -38,
-38, -37, -38, -39, -37, -37, -37, -38, -37, -37, -38, -38, -37, -38, -37, -38,
-38, -38, -38, -38, -37, -37, -37, -37, -37, -38, -38, -37, -37, -38, -38, -37,
-38, -38, -37, -37, -38, -38, -37, -38, -37, -38, -37, -37, -38, -37, -37, -37,
-38, -38, -38, -37, -37, -37, -38, -37, -37, -37, -37, -38, -38, -38, -38, -38,
-38, -37, -37, -37, -37, -38, -37, -38, -37, -38, -37, -37, -37, -38, -37, -38,
-37, -37, -38, -38, -37, -37, -37, -37, -37, -37, -37, -38, -37, -37, -37, -37,
-37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37,
-37, -37, -37, -37, -37, -37, -37, -38, -36, -37, -36, -37, -36, -37, -38, -37,
-37, -37, -37, -37, -38, -37, -37, -36, -37, -36, -37, -36, -37, -37, -36, -37,
-37, -37, -37, -33, -10, };