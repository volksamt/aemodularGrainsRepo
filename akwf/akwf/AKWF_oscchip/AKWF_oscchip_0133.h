#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0133

const PROGMEM int8_t DATA[DATA_LENGTH] = {37, 56, 50, 53, 51, 53, 51, 52, 51,
52, 52, 52, 51, 51, 51, 51, 51, 51, 52, 51, 51, 52, 52, 51, 52, 51, 51, 51, 51,
51, 52, 47, 43, 43, 44, 43, 43, 43, 43, 43, 43, 43, 43, 43, 43, 43, 43, 41, 35,
35, 35, 35, 34, 35, 36, 35, 35, 34, 36, 36, 35, 36, 35, 34, 29, 29, 28, 27, 28,
28, 28, 29, 29, 28, 29, 28, 29, 28, 28, 22, 20, 20, 20, 20, 20, 21, 20, 20, 21,
20, 20, 20, 20, 20, 21, 17, 15, 16, 15, 15, 16, 15, 15, 14, 15, 15, 14, 14, 15,
15, 15, 12, 8, 8, 8, 8, 8, 9, 9, 8, 8, 9, 8, 8, 8, 8, 8, 7, 6, 5, 6, 5, 5, 6, 5,
5, 5, 5, 5, 6, 5, 5, 5, 4, 3, 3, 2, 3, 3, 2, 3, 3, 2, 3, 3, 2, 2, 3, 2, 0, -1,
-2, -1, -2, -1, -1, -2, -2, -2, -2, -1, -1, -1, -1, -1, -2, -3, -3, -3, -2, -3,
-2, -2, -3, -3, -4, -3, -3, -3, -4, -2, -3, -5, -6, -5, -6, -5, -6, -5, -6, -6,
-5, -5, -6, -6, -5, -5, -8, -10, -10, -9, -10, -10, -10, -10, -9, -9, -9, -10,
-9, -9, -9, -10, -15, -18, -17, -18, -17, -17, -17, -18, -18, -18, -18, -17,
-17, -17, -18, -18, -4, 14, 14, 13, 13, 13, 14, 13, 14, 13, 14, 13, 14, 13, 13,
13, 12, 10, 11, 11, 11, 11, 11, 11, 11, 10, 11, 11, 10, 10, 10, 10, 11, 11, 10,
11, 11, 11, 11, 11, 11, 10, 11, 11, 11, 10, 11, 11, 9, 8, 7, 8, 8, 8, 8, 8, 7,
8, 7, 8, 9, 7, 9, 8, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 6, 6, 7, 7, 6, 7, 6, 5, 4, 4,
4, 4, 4, 4, 4, 4, 4, 5, 4, 4, 4, 3, 4, 4, 3, 2, 3, 2, 2, 3, 3, 3, 3, 3, 2, 3, 3,
2, 2, 2, 1, 1, 2, 1, 1, 1, 2, 1, 1, 1, 1, 1, 2, 1, 0, -1, -1, -2, -1, -1, -1,
-1, -2, -1, -1, -1, -2, -2, -2, -1, -2, -5, -4, -4, -5, -4, -4, -4, -5, -4, -4,
-4, -4, -5, -5, -4, -5, -8, -9, -8, -8, -8, -9, -8, -9, -8, -8, -8, -8, -9, -8,
-8, -11, -10, -11, -12, -11, -11, -12, -10, -11, -10, -11, -11, -12, -11, -10,
-11, -14, -17, -17, -17, -18, -18, -18, -18, -18, -17, -18, -17, -17, -17, -17,
-17, -17, -19, -18, -19, -19, -19, -19, -18, -19, -18, -19, -18, -19, -18, -20,
-17, -42, -104, -118, -114, -116, -114, -116, -114, -117, -115, -116, -115,
-116, -115, -116, -111, -81, -61, -63, -63, -63, -63, -63, -63, -63, -63, -63,
-62, -64, -63, -64, -63, -52, -41, -41, -41, -41, -42, -41, -41, -41, -41, -41,
-42, -41, -41, -42, -40, -10, };