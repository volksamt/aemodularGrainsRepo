#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 0, 1, 0, 1, 1, 1, 1, 1, 1, 2, 1,
1, 0, 14, 30, 30, 30, 30, 30, 30, 30, 30, 31, 30, 30, 30, 30, 31, 29, 50, 71,
70, 70, 70, 71, 70, 70, 71, 71, 70, 71, 71, 71, 71, 70, 85, 100, 99, 100, 99,
100, 99, 99, 99, 100, 99, 99, 99, 100, 99, 100, 108, 114, 114, 114, 113, 114,
114, 113, 114, 114, 114, 114, 113, 114, 113, 113, 114, 118, 119, 119, 118, 118,
119, 118, 118, 118, 119, 119, 119, 119, 119, 118, 117, 112, 110, 112, 111, 111,
111, 111, 110, 111, 111, 112, 111, 111, 111, 111, 108, 98, 95, 96, 96, 96, 95,
96, 96, 96, 96, 96, 95, 95, 96, 96, 92, 82, 80, 81, 81, 81, 81, 80, 80, 81, 81,
81, 80, 81, 81, 81, 77, 66, 64, 65, 64, 65, 64, 64, 64, 64, 64, 64, 64, 64, 63,
64, 61, 52, 51, 51, 50, 50, 52, 52, 51, 51, 51, 51, 50, 51, 51, 51, 47, 39, 38,
38, 38, 38, 38, 38, 38, 37, 39, 38, 38, 38, 38, 39, 33, 25, 25, 25, 24, 24, 25,
25, 24, 25, 24, 24, 24, 25, 24, 25, 22, 18, 17, 18, 17, 18, 18, 17, 17, 17, 18,
17, 18, 17, 18, 17, 17, 17, 17, 17, 18, 18, 17, 17, 16, 17, 17, 17, 16, 17, 17,
17, 12, 6, 6, 6, 7, 7, 6, 7, 6, 6, 6, 6, 7, 6, 6, 6, 3, 0, 0, 1, 1, 1, 1, 1, 1,
1, 0, 1, 0, 1, 0, 0, -2, -5, -4, -5, -5, -5, -4, -5, -5, -5, -4, -5, -5, -4, -5,
-5, -17, -27, -26, -27, -27, -27, -27, -26, -27, -27, -27, -27, -27, -27, -26,
-27, -28, -35, -40, -39, -40, -39, -40, -39, -39, -40, -40, -39, -40, -39, -39,
-39, -42, -50, -53, -53, -52, -53, -53, -52, -52, -53, -51, -52, -53, -53, -52,
-52, -52, -55, -56, -56, -56, -56, -55, -55, -56, -55, -56, -55, -55, -55, -56,
-55, -58, -69, -73, -71, -72, -72, -72, -72, -72, -71, -71, -71, -72, -71, -72,
-72, -73, -75, -76, -74, -75, -75, -75, -75, -75, -75, -75, -74, -75, -75, -75,
-74, -79, -88, -91, -89, -90, -89, -90, -89, -89, -89, -89, -90, -89, -89, -89,
-89, -91, -96, -96, -96, -96, -96, -97, -97, -96, -96, -96, -97, -97, -96, -97,
-95, -96, -96, -96, -96, -96, -96, -96, -96, -96, -96, -96, -96, -96, -96, -96,
-95, -95, -94, -94, -94, -94, -94, -93, -94, -93, -93, -94, -93, -93, -94, -93,
-94, -92, -90, -89, -90, -89, -89, -89, -89, -90, -89, -90, -89, -89, -89, -89,
-89, -85, -80, -79, -79, -80, -80, -80, -80, -80, -79, -80, -80, -80, -80, -80,
-80, -66, -50, -51, -50, -51, -50, -51, -51, -50, -51, -50, -50, -50, -51, -51,
-51, -37, -25, -24, -24, -25, -25, -24, -25, -25, -24, -24, -24, -24, -25, -24,
-24, -10, };