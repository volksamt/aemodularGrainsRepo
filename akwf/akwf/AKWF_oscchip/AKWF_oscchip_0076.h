#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0076

const PROGMEM int8_t DATA[DATA_LENGTH] = {64, 119, 108, 114, 111, 113, 112, 113,
111, 113, 112, 112, 113, 112, 112, 112, 112, 112, 112, 112, 112, 112, 112, 111,
112, 112, 112, 112, 112, 112, 112, 111, 112, 111, 112, 112, 112, 112, 112, 112,
112, 112, 111, 111, 112, 112, 112, 112, 111, 112, 111, 111, 112, 112, 112, 111,
112, 112, 112, 111, 112, 111, 112, 111, 111, 111, 112, 112, 111, 111, 112, 112,
112, 111, 112, 111, 112, 111, 111, 112, 111, 111, 111, 111, 112, 111, 112, 111,
112, 111, 112, 111, 111, 112, 112, 111, 112, 111, 112, 110, 111, 111, 110, 111,
111, 111, 110, 112, 110, 112, 109, 114, -7, -105, -90, -97, -92, -95, -93, -94,
-94, -95, -94, -94, -94, -95, -94, -94, -93, -92, -93, -93, -92, -92, -92, -92,
-92, -92, -92, -92, -93, -92, -92, -93, -91, -91, -91, -90, -90, -91, -91, -90,
-90, -90, -91, -91, -90, -91, -90, -90, -103, -112, -111, -111, -111, -111,
-112, -110, -112, -111, -112, -110, -113, -108, -115, -87, 10, 28, 22, 26, 23,
25, 24, 26, 25, 25, 24, 26, 24, 25, 24, 26, 25, 25, 25, 25, 25, 25, 24, 25, 26,
25, 25, 25, 26, 25, 25, 24, 24, 23, 23, 24, 24, 23, 23, 23, 23, 23, 23, 23, 23,
23, 23, 24, 21, 21, 21, 21, 21, 22, 22, 22, 21, 21, 21, 22, 22, 21, 22, 21, 19,
18, 18, 19, 18, 18, 18, 19, 18, 18, 18, 18, 18, 18, 18, 18, 17, 16, 17, 16, 16,
16, 16, 16, 17, 16, 16, 17, 17, 17, 17, 14, 6, 4, 5, 3, 4, 4, 4, 4, 3, 4, 4, 4,
3, 4, 3, 4, -4, -8, -7, -7, -7, -7, -7, -6, -7, -7, -7, -7, -7, -7, -7, -7, -9,
-10, -10, -10, -10, -10, -10, -10, -10, -10, -10, -10, -11, -11, -10, -12, -17,
-18, -19, -19, -18, -19, -20, -19, -19, -19, -19, -19, -20, -19, -19, -19, -23,
-24, -23, -24, -25, -25, -24, -24, -24, -24, -24, -25, -24, -24, -24, -24, -26,
-30, -29, -29, -29, -29, -29, -29, -29, -29, -29, -29, -30, -29, -29, -29, -34,
-34, -34, -34, -34, -35, -34, -34, -35, -35, -34, -35, -35, -34, -34, -34, -36,
-36, -35, -36, -37, -36, -36, -36, -37, -35, -35, -36, -36, -36, -36, -37, -38,
-38, -38, -37, -38, -37, -38, -38, -38, -37, -38, -38, -37, -37, -38, -38, -41,
-41, -42, -41, -41, -42, -42, -41, -41, -41, -41, -42, -41, -41, -42, -41, -42,
-43, -43, -42, -43, -42, -43, -43, -43, -42, -43, -43, -42, -43, -42, -44, -48,
-48, -48, -48, -48, -47, -48, -48, -48, -48, -48, -48, -47, -49, -48, -48, -51,
-52, -51, -51, -51, -52, -51, -51, -51, -51, -51, -51, -52, -52, -51, -52, -66,
-74, -71, -73, -72, -72, -72, -73, -72, -73, -72, -72, -72, -72, -71, -75, -78,
-79, -79, -78, -79, -79, -79, -79, -80, -78, -79, -78, -81, -76, -84, -49, };