#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0028

const PROGMEM int8_t DATA[DATA_LENGTH] = {41, 90, 81, 85, 83, 84, 84, 84, 84,
83, 84, 84, 83, 83, 85, 84, 84, 83, 84, 84, 84, 84, 84, 84, 85, 84, 83, 83, 84,
84, 84, 84, 83, 81, 82, 82, 82, 81, 82, 82, 82, 82, 83, 82, 83, 81, 82, 82, 82,
82, 82, 82, 82, 82, 82, 83, 82, 82, 83, 83, 81, 82, 83, 81, 79, 79, 78, 79, 78,
79, 78, 78, 78, 78, 79, 79, 79, 78, 79, 76, 67, 65, 65, 65, 65, 65, 66, 65, 66,
66, 65, 66, 65, 65, 65, 63, 61, 60, 60, 60, 61, 60, 60, 61, 60, 61, 60, 60, 60,
61, 60, 60, 57, 57, 58, 58, 57, 57, 56, 57, 57, 57, 56, 57, 57, 57, 56, 57, 51,
47, 47, 47, 47, 47, 46, 46, 46, 46, 47, 46, 46, 47, 47, 47, 41, 36, 37, 36, 37,
37, 37, 37, 37, 36, 36, 37, 37, 37, 37, 37, 33, 31, 30, 30, 31, 30, 30, 31, 30,
29, 30, 31, 30, 31, 30, 31, 29, 27, 27, 27, 27, 26, 27, 27, 27, 26, 27, 27, 27,
27, 27, 27, 24, 23, 24, 24, 24, 23, 23, 23, 23, 23, 24, 23, 24, 24, 23, 23, 18,
17, 18, 17, 17, 17, 17, 17, 18, 17, 17, 17, 17, 16, 17, 16, 10, 7, 7, 7, 8, 7,
7, 7, 7, 8, 7, 7, 7, 8, 7, 6, -1, -3, -2, -3, -3, -3, -4, -2, -3, -3, -4, -3,
-2, -3, -3, -3, -5, -6, -6, -6, -6, -6, -6, -6, -7, -7, -6, -6, -5, -7, -7, -7,
-9, -10, -9, -10, -9, -10, -10, -9, -9, -9, -9, -9, -10, -9, -10, -10, -12, -13,
-13, -13, -12, -13, -12, -13, -12, -12, -13, -13, -13, -13, -12, -14, -19, -19,
-19, -19, -18, -19, -19, -18, -19, -19, -19, -20, -19, -19, -20, -20, -22, -23,
-23, -22, -22, -23, -23, -23, -23, -23, -22, -22, -22, -23, -22, -24, -26, -26,
-26, -25, -26, -26, -25, -26, -26, -26, -26, -26, -26, -26, -26, -27, -30, -31,
-30, -30, -30, -31, -30, -31, -30, -30, -31, -31, -31, -30, -31, -30, -33, -34,
-34, -33, -34, -33, -33, -34, -34, -34, -34, -33, -34, -34, -34, -35, -40, -44,
-43, -43, -43, -43, -43, -43, -44, -44, -43, -44, -43, -44, -44, -44, -45, -47,
-47, -46, -46, -47, -46, -47, -47, -47, -47, -48, -47, -47, -46, -47, -56, -61,
-60, -61, -60, -59, -60, -60, -60, -59, -61, -60, -59, -60, -60, -61, -67, -70,
-70, -70, -69, -69, -69, -70, -70, -70, -69, -69, -70, -70, -69, -71, -79, -83,
-82, -83, -82, -83, -82, -82, -82, -83, -83, -83, -82, -83, -82, -84, -92, -96,
-95, -96, -95, -95, -95, -96, -95, -95, -95, -95, -95, -96, -95, -97, -103,
-106, -105, -106, -104, -106, -105, -105, -105, -105, -104, -105, -104, -106,
-105, -107, -113, -115, -115, -115, -116, -114, -116, -114, -116, -114, -116,
-114, -117, -112, -122, -70, };