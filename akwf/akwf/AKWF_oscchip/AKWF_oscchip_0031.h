#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0031

const PROGMEM int8_t DATA[DATA_LENGTH] = {22, 79, 76, 76, 76, 75, 77, 76, 76,
76, 76, 75, 77, 75, 76, 75, 76, 76, 76, 76, 75, 76, 76, 76, 75, 75, 76, 75, 75,
76, 76, 77, 76, 76, 75, 76, 76, 76, 76, 76, 75, 75, 76, 75, 76, 76, 75, 75, 76,
76, 76, 75, 75, 75, 76, 76, 75, 75, 74, 75, 75, 76, 75, 76, 75, 75, 75, 75, 76,
75, 75, 75, 75, 75, 75, 75, 76, 75, 75, 74, 75, 74, 74, 74, 74, 75, 74, 75, 75,
74, 75, 75, 74, 75, 75, 74, 74, 74, 75, 75, 74, 75, 75, 74, 75, 75, 74, 74, 74,
74, 75, 74, 74, 75, 74, 74, 74, 75, 74, 74, 74, 75, 74, 75, 74, 74, 74, 74, 74,
73, 73, 73, 74, 74, 74, 73, 74, 74, 74, 74, 74, 74, 74, 73, 73, 73, 73, 74, 73,
73, 74, 73, 73, 73, 73, 74, 73, 74, 73, 74, 74, 73, 73, 73, 73, 73, 73, 73, 73,
73, 73, 73, 73, 73, 72, 72, 72, 73, 73, 72, 73, 72, 73, 73, 72, 72, 72, 72, 72,
73, 72, 73, 73, 72, 73, 72, 72, 72, 72, 72, 72, 73, 72, 73, 72, 73, 72, 72, 71,
73, 72, 72, 72, 72, 72, 72, 72, 71, 72, 71, 72, 72, 72, 72, 72, 72, 72, 72, 72,
72, 71, 71, 72, 72, 71, 72, 71, 72, 72, 65, -47, -125, -111, -116, -113, -115,
-113, -115, -114, -114, -114, -114, -115, -114, -114, -114, -114, -114, -114,
-115, -115, -114, -114, -114, -115, -113, -114, -115, -115, -114, -115, -108,
-65, -44, -49, -47, -47, -47, -47, -47, -47, -47, -47, -47, -48, -46, -47, -47,
-49, -50, -49, -49, -49, -49, -49, -50, -49, -50, -49, -50, -49, -49, -49, -50,
-52, -53, -53, -53, -52, -52, -52, -52, -52, -52, -53, -53, -52, -52, -52, -53,
-53, -53, -53, -54, -54, -53, -53, -54, -54, -54, -53, -53, -53, -53, -53, -53,
-54, -56, -55, -55, -55, -54, -55, -55, -55, -54, -54, -54, -55, -54, -55, -54,
-56, -56, -56, -56, -56, -56, -56, -56, -57, -56, -55, -56, -56, -56, -56, -55,
-57, -59, -58, -58, -59, -59, -58, -58, -58, -58, -58, -58, -58, -58, -58, -58,
-59, -58, -58, -58, -58, -58, -58, -58, -59, -58, -59, -58, -58, -58, -58, -58,
-59, -60, -59, -60, -60, -60, -60, -60, -59, -59, -60, -59, -59, -59, -59, -60,
-61, -63, -63, -62, -62, -62, -62, -63, -62, -63, -62, -63, -61, -61, -62, -62,
-63, -63, -63, -63, -63, -63, -63, -63, -63, -63, -63, -63, -64, -63, -63, -63,
-64, -64, -65, -64, -65, -64, -64, -64, -65, -64, -64, -64, -64, -65, -64, -64,
-64, -65, -65, -64, -64, -64, -63, -64, -64, -64, -64, -64, -64, -64, -64, -65,
-68, -70, -69, -70, -70, -70, -69, -69, -70, -70, -70, -70, -69, -70, -70, -69,
-70, -70, -70, -69, -70, -68, -70, -69, -70, -69, -70, -69, -71, -67, -74, -50,
};