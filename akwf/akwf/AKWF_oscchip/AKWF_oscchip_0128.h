#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0128

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 12, 13, 13, 14, 13, 14, 13, 13, 13,
12, 13, 12, 13, 13, 13, 15, 20, 22, 22, 21, 21, 22, 22, 23, 21, 22, 21, 23, 22,
22, 22, 22, 27, 28, 28, 29, 29, 29, 28, 28, 28, 28, 29, 29, 29, 29, 28, 33, 37,
38, 36, 37, 38, 37, 38, 36, 37, 36, 37, 36, 36, 38, 37, 38, 41, 42, 41, 41, 41,
42, 40, 42, 41, 41, 40, 42, 41, 42, 41, 44, 50, 52, 52, 52, 51, 53, 52, 52, 52,
52, 53, 52, 53, 52, 52, 53, 62, 66, 65, 65, 65, 66, 65, 65, 64, 65, 66, 65, 65,
65, 66, 73, 79, 78, 78, 78, 78, 79, 78, 79, 78, 78, 78, 78, 78, 78, 78, 82, 88,
89, 89, 89, 89, 89, 89, 89, 89, 90, 89, 88, 89, 90, 89, 91, 95, 96, 96, 96, 95,
96, 96, 95, 95, 96, 96, 95, 96, 96, 95, 97, 101, 103, 102, 102, 102, 102, 102,
102, 102, 103, 101, 102, 103, 102, 102, 106, 109, 108, 109, 109, 109, 108, 109,
108, 108, 109, 109, 108, 109, 109, 108, 109, 108, 109, 109, 109, 109, 109, 108,
109, 108, 109, 108, 108, 109, 109, 109, 109, 110, 112, 111, 110, 111, 111, 111,
111, 111, 110, 110, 111, 111, 111, 110, 111, 112, 113, 114, 113, 113, 113, 113,
113, 113, 112, 114, 113, 112, 113, 113, 112, 113, 113, 114, 113, 113, 113, 113,
113, 113, 113, 113, 113, 113, 113, 113, 114, 115, 115, 115, 116, 115, 115, 115,
115, 115, 115, 116, 115, 115, 115, 115, 115, 115, 115, 115, 115, 115, 115, 115,
115, 115, 115, 115, 116, 115, 115, 115, 115, 114, 115, 115, 114, 116, 115, 115,
115, 115, 116, 116, 115, 115, 115, 116, 115, 116, 115, 114, 115, 115, 116, 115,
115, 116, 116, 115, 115, 115, 116, 115, 116, 116, 115, 115, 115, 115, 115, 114,
116, 115, 115, 115, 115, 115, 115, 116, 115, 114, 113, 114, 113, 114, 113, 113,
113, 114, 112, 113, 113, 113, 112, 113, 112, 111, 110, 111, 111, 111, 111, 110,
110, 111, 111, 111, 111, 111, 111, 112, 92, -42, -121, -108, -112, -110, -112,
-110, -112, -110, -111, -111, -111, -110, -111, -111, -103, -96, -95, -96, -95,
-95, -95, -96, -96, -96, -95, -96, -95, -96, -96, -96, -92, -84, -83, -83, -82,
-83, -82, -82, -83, -82, -83, -82, -83, -83, -83, -83, -81, -74, -71, -72, -72,
-72, -72, -72, -72, -73, -72, -72, -71, -71, -72, -72, -71, -65, -60, -61, -61,
-61, -61, -62, -62, -61, -61, -61, -61, -61, -61, -60, -57, -52, -53, -52, -52,
-51, -52, -52, -52, -52, -52, -52, -52, -52, -53, -53, -48, -40, -39, -39, -39,
-39, -39, -39, -39, -39, -39, -40, -39, -39, -39, -39, -36, -25, -21, -22, -21,
-21, -22, -22, -21, -22, -21, -22, -22, -22, -22, -21, -20, -7, -1, -3, -1, -3,
-3, -2, -2, -2, -3, -2, -2, -1, -2, -2, };