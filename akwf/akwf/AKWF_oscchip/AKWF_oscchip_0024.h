#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {43, 110, 102, 104, 102, 103, 103, 103,
103, 103, 104, 103, 103, 104, 104, 103, 111, 113, 113, 114, 114, 113, 114, 113,
114, 113, 115, 114, 114, 113, 114, 113, 118, 119, 119, 118, 119, 119, 119, 118,
119, 118, 120, 118, 119, 117, 120, 95, -42, -104, -92, -97, -93, -97, -94, -95,
-95, -96, -95, -95, -94, -95, -96, -91, -74, -67, -69, -69, -69, -69, -69, -69,
-68, -68, -68, -68, -69, -69, -69, -67, -57, -54, -55, -55, -55, -54, -55, -54,
-55, -54, -55, -54, -54, -55, -55, -53, -44, -42, -42, -42, -42, -42, -42, -42,
-43, -42, -42, -42, -42, -41, -42, -40, -35, -33, -33, -33, -33, -34, -33, -33,
-33, -33, -33, -34, -33, -33, -33, -32, -27, -26, -27, -26, -26, -26, -26, -26,
-26, -26, -27, -25, -25, -25, -26, -24, -22, -23, -23, -22, -22, -22, -21, -22,
-23, -21, -23, -23, -21, -23, -23, -21, -19, -19, -19, -19, -19, -19, -19, -18,
-19, -19, -19, -19, -19, -19, -19, -16, -12, -11, -12, -12, -12, -12, -12, -12,
-13, -12, -12, -12, -11, -12, -11, -10, -8, -8, -8, -7, -8, -8, -8, -8, -8, -8,
-7, -8, -8, -7, -8, -4, 0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 0, 1, 0, 0, 0, 6, 10,
9, 9, 9, 9, 10, 9, 9, 9, 9, 9, 9, 9, 10, 10, 18, 23, 22, 21, 22, 21, 22, 22, 22,
22, 22, 21, 22, 22, 21, 22, 21, 22, 21, 22, 22, 21, 21, 22, 22, 22, 22, 22, 22,
21, 22, 22, 22, 21, 21, 22, 22, 21, 22, 21, 22, 22, 21, 22, 22, 21, 22, 21, 22,
23, 23, 24, 24, 23, 23, 23, 23, 23, 23, 23, 23, 24, 24, 24, 23, 23, 24, 23, 23,
23, 24, 23, 23, 23, 23, 23, 23, 23, 23, 23, 23, 23, 23, 23, 22, 23, 23, 23, 23,
23, 23, 22, 23, 23, 23, 23, 24, 25, 25, 24, 25, 25, 25, 25, 25, 25, 24, 24, 25,
25, 25, 24, 23, 22, 23, 23, 22, 23, 23, 23, 23, 23, 23, 22, 23, 22, 22, 21, 18,
17, 17, 17, 18, 18, 18, 17, 17, 17, 17, 17, 18, 18, 17, 16, 14, 14, 15, 14, 13,
14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 12, 9, 8, 8, 9, 9, 9, 8, 9, 9, 8, 9, 8,
8, 9, 8, 7, 4, 5, 5, 5, 4, 5, 5, 5, 5, 5, 5, 5, 4, 5, 5, 3, 0, -1, 0, 0, 0, -1,
0, -1, -1, 0, 0, 0, 0, 0, 0, -1, -4, -6, -5, -5, -6, -6, -5, -6, -5, -5, -6, -6,
-6, -6, -5, -8, -22, -32, -30, -31, -30, -31, -30, -30, -29, -31, -30, -31, -29,
-31, -29, -33, -68, -84, -79, -82, -81, -81, -81, -81, -80, -81, -81, -81, -81,
-81, -80, -81, -79, -77, -77, -76, -77, -77, -77, -76, -78, -76, -78, -75, -78,
-75, -82, -50, };