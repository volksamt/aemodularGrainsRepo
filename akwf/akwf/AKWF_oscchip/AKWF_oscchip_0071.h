#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0071

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 2, 2, 1, 1, 1, 2, 1, 0, 1, 0, 1, 1,
1, 1, 4, 3, 4, 3, 3, 4, 4, 4, 3, 3, 4, 4, 3, 4, 4, 3, 5, 6, 6, 6, 5, 6, 6, 6, 6,
6, 6, 5, 7, 6, 6, 6, 5, 3, 3, 4, 3, 4, 3, 4, 4, 4, 4, 4, 2, 4, 4, 4, 4, 5, 4, 4,
3, 4, 4, 3, 4, 3, 4, 3, 5, 2, 4, 3, 57, 99, 91, 95, 92, 94, 93, 94, 93, 93, 93,
94, 93, 93, 93, 94, 94, 93, 93, 93, 94, 94, 94, 94, 94, 93, 94, 93, 94, 93, 93,
92, 89, 88, 89, 89, 89, 89, 89, 89, 88, 88, 89, 88, 88, 89, 89, 89, 89, 89, 88,
88, 87, 89, 88, 88, 89, 89, 88, 88, 88, 88, 88, 89, 86, 83, 83, 83, 84, 83, 83,
83, 84, 84, 82, 83, 83, 82, 83, 83, 82, 81, 80, 80, 81, 81, 81, 80, 81, 80, 81,
80, 80, 81, 81, 81, 79, 78, 78, 79, 78, 78, 78, 78, 78, 78, 78, 79, 77, 79, 76,
81, 39, -21, -20, -21, -19, -20, -20, -20, -20, -19, -20, -19, -20, -20, -19,
-21, -35, -40, -39, -39, -39, -38, -39, -39, -39, -40, -39, -39, -40, -39, -39,
-39, -50, -59, -58, -58, -59, -58, -58, -59, -59, -59, -59, -57, -58, -58, -59,
-56, -73, -96, -95, -94, -95, -94, -95, -95, -95, -95, -95, -95, -95, -95, -95,
-94, -85, -82, -83, -83, -83, -82, -83, -83, -83, -83, -83, -83, -82, -83, -82,
-83, -82, -83, -82, -82, -82, -83, -83, -83, -83, -82, -82, -82, -82, -83, -83,
-82, -83, -83, -82, -82, -82, -82, -83, -83, -82, -82, -83, -83, -82, -83, -81,
-82, -82, -83, -83, -82, -82, -83, -82, -82, -82, -81, -81, -82, -82, -82, -81,
-82, -54, -34, -36, -36, -37, -34, -36, -35, -36, -36, -36, -36, -36, -35, -37,
-33, -16, -13, -14, -14, -13, -14, -13, -13, -13, -13, -14, -14, -15, -14, -13,
-13, -12, -11, -11, -11, -12, -11, -11, -11, -12, -11, -11, -12, -11, -12, -12,
-11, -4, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 2, 1, 1,
1, 0, 2, 1, 1, 0, 1, 1, 2, 1, 1, 1, 2, 2, 1, 1, 2, 0, 1, 1, 1, 1, 1, -3, -4, -4,
-4, -4, -4, -3, -4, -4, -4, -4, -4, -4, -3, -4, -3, -3, -1, -1, -1, -3, 0, -2,
0, -2, -1, -2, 0, -3, 0, -2, 6, 78, 108, 100, 105, 102, 105, 103, 104, 103, 104,
103, 103, 103, 103, 103, 104, 103, 102, 104, 102, 104, 102, 104, 103, 104, 102,
104, 101, 105, 101, 109, 66, -87, -119, -111, -115, -112, -116, -112, -115,
-113, -114, -113, -114, -113, -114, -113, -114, -112, -111, -111, -111, -112,
-111, -111, -111, -112, -111, -111, -111, -111, -111, -110, -111, -48, };