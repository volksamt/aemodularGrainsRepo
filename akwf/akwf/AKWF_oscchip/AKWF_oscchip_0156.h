#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0156

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 27, 21, 23, 21, 22, 22, 22, 23, 21,
22, 22, 22, 21, 22, 23, 26, 28, 27, 27, 28, 28, 28, 27, 27, 28, 28, 28, 27, 29,
28, 31, 33, 33, 33, 33, 33, 33, 33, 33, 34, 33, 34, 33, 33, 33, 33, 36, 36, 37,
37, 38, 37, 38, 37, 37, 36, 37, 37, 36, 37, 37, 37, 40, 47, 49, 48, 48, 48, 48,
49, 48, 49, 49, 48, 48, 48, 49, 49, 48, 50, 50, 50, 51, 50, 50, 50, 50, 50, 51,
50, 49, 50, 50, 50, 53, 54, 53, 54, 54, 54, 53, 54, 53, 53, 53, 54, 54, 54, 54,
53, 55, 58, 57, 57, 57, 58, 58, 57, 58, 57, 57, 57, 58, 57, 57, 58, 60, 64, 65,
64, 65, 65, 65, 65, 65, 65, 64, 64, 65, 65, 65, 64, 67, 74, 76, 76, 76, 76, 76,
77, 76, 76, 76, 76, 76, 76, 76, 76, 79, 80, 79, 80, 80, 80, 79, 79, 79, 80, 80,
80, 80, 80, 80, 79, 85, 91, 91, 90, 91, 90, 91, 91, 91, 91, 91, 90, 91, 90, 91,
91, 92, 96, 97, 97, 97, 95, 96, 96, 96, 97, 97, 97, 97, 96, 96, 97, 97, 104,
106, 105, 106, 106, 106, 106, 106, 106, 105, 105, 105, 106, 105, 106, 111, 114,
113, 113, 113, 113, 113, 113, 113, 113, 113, 113, 112, 114, 112, 113, 57, -9,
-10, -9, -10, -9, -10, -9, -9, -9, -9, -9, -9, -9, -10, -9, -10, -12, -13, -13,
-13, -12, -14, -13, -13, -13, -13, -13, -13, -13, -13, -13, -15, -25, -28, -27,
-28, -27, -28, -29, -28, -27, -28, -28, -28, -27, -28, -29, -34, -39, -39, -39,
-39, -39, -39, -39, -39, -39, -39, -39, -39, -40, -39, -39, -46, -54, -54, -53,
-54, -53, -54, -54, -53, -54, -54, -53, -54, -53, -54, -53, -60, -71, -73, -72,
-73, -72, -73, -72, -72, -72, -72, -72, -73, -73, -72, -72, -75, -83, -86, -85,
-85, -85, -85, -86, -86, -86, -86, -85, -86, -85, -85, -86, -98, -106, -105,
-106, -106, -106, -105, -105, -106, -106, -106, -106, -106, -106, -106, -105,
-106, -107, -108, -107, -108, -108, -107, -108, -107, -107, -107, -107, -108,
-107, -108, -108, -107, -107, -108, -107, -108, -107, -108, -107, -108, -108,
-108, -107, -107, -107, -107, -108, -110, -118, -119, -118, -119, -119, -118,
-119, -119, -118, -119, -118, -119, -118, -118, -119, -118, -119, -118, -118,
-118, -118, -119, -119, -119, -118, -119, -118, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -120, -119,
-119, -118, -118, -119, -119, -119, -119, -118, -118, -118, -119, -119, -119,
-119, -118, -119, -118, -119, -119, -118, -119, -118, -118, -118, -118, -119,
-118, -119, -119, -119, -119, -119, -118, -118, -119, -118, -119, -119, -118,
-119, -119, -119, -119, -119, -118, -118, -118, -119, -119, -118, -119, -118,
-119, -119, -119, -118, -118, -119, -118, -119, -118, -120, -117, -120, -118,
-121, -63, };