#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {22, 24, 23, 23, 22, 25, 23, 24, 23,
24, 23, 23, 23, 23, 24, 66, 98, 93, 95, 94, 94, 94, 95, 95, 95, 94, 95, 94, 94,
95, 95, 97, 99, 98, 100, 99, 99, 99, 99, 99, 98, 99, 99, 98, 98, 99, 100, 107,
112, 112, 112, 111, 112, 111, 111, 112, 111, 112, 112, 111, 112, 111, 112, 112,
112, 111, 111, 111, 111, 111, 110, 111, 111, 111, 111, 111, 111, 111, 112, 115,
116, 115, 115, 115, 115, 116, 115, 115, 116, 115, 115, 116, 115, 115, 116, 116,
115, 115, 114, 115, 115, 115, 114, 115, 115, 115, 115, 114, 115, 114, 115, 116,
120, 119, 118, 118, 119, 118, 119, 118, 119, 118, 119, 118, 120, 116, 121, 80,
-2, -11, -8, -9, -8, -9, -8, -9, -8, -9, -8, -8, -9, -8, -10, 6, 31, 34, 34, 33,
34, 34, 34, 33, 33, 34, 33, 33, 33, 34, 33, 40, 52, 52, 51, 52, 51, 51, 51, 52,
51, 51, 52, 51, 51, 51, 51, 52, 56, 55, 55, 55, 55, 55, 56, 55, 55, 55, 54, 55,
56, 55, 56, 60, 65, 65, 64, 64, 63, 64, 64, 64, 64, 63, 63, 64, 64, 64, 63, 73,
83, 82, 81, 82, 82, 81, 82, 81, 81, 81, 82, 81, 81, 82, 81, 90, 98, 97, 97, 97,
96, 97, 97, 97, 97, 97, 97, 96, 97, 96, 97, 102, 107, 105, 105, 105, 106, 105,
105, 105, 104, 106, 105, 106, 105, 105, 105, 110, 112, 113, 111, 112, 111, 111,
111, 112, 111, 111, 111, 112, 110, 113, 101, -31, -107, -92, -101, -96, -100,
-96, -98, -98, -99, -98, -97, -97, -98, -98, -97, -99, -100, -100, -100, -100,
-100, -100, -100, -100, -100, -101, -99, -100, -100, -99, -100, -102, -102,
-102, -103, -103, -102, -101, -101, -102, -103, -101, -101, -102, -101, -102,
-101, -102, -102, -102, -101, -102, -101, -102, -102, -101, -101, -102, -102,
-102, -102, -101, -101, -101, -98, -96, -97, -96, -97, -96, -96, -97, -96, -97,
-97, -96, -97, -96, -96, -96, -97, -96, -97, -95, -96, -96, -97, -96, -96, -96,
-96, -96, -96, -96, -96, -96, -96, -97, -96, -96, -96, -96, -96, -97, -96, -97,
-95, -96, -96, -96, -96, -95, -95, -96, -96, -95, -95, -95, -95, -96, -96, -95,
-95, -95, -95, -96, -95, -95, -93, -93, -93, -93, -93, -93, -93, -93, -93, -93,
-93, -93, -92, -93, -92, -92, -90, -90, -91, -91, -91, -90, -90, -91, -91, -89,
-90, -89, -89, -90, -90, -89, -87, -88, -88, -88, -88, -87, -87, -87, -88, -88,
-87, -87, -88, -87, -87, -86, -84, -85, -85, -84, -85, -85, -84, -85, -85, -85,
-85, -86, -85, -86, -85, -83, -82, -82, -82, -82, -83, -82, -82, -82, -83, -82,
-82, -82, -82, -81, -83, -81, -80, -79, -80, -80, -80, -80, -80, -79, -80, -80,
-80, -80, -80, -80, -79, -78, -77, -77, -77, -77, -77, -77, -77, -78, -76, -77,
-76, -78, -76, -80, -68, -11, };