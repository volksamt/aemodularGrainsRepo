#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0035

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, -1, 0, 0, 0, 0, 1, 1, 0, 0,
6, 18, 22, 22, 21, 21, 20, 22, 22, 21, 21, 21, 21, 20, 21, 21, 25, 37, 43, 42,
43, 42, 43, 42, 43, 42, 42, 42, 42, 42, 42, 42, 48, 53, 52, 52, 52, 53, 52, 52,
53, 52, 52, 52, 52, 52, 53, 52, 59, 69, 70, 70, 70, 70, 70, 70, 70, 69, 70, 70,
70, 69, 70, 70, 70, 70, 71, 71, 71, 70, 71, 71, 72, 71, 72, 71, 72, 70, 70, 71,
71, 71, 71, 70, 71, 71, 71, 71, 70, 71, 71, 70, 70, 70, 71, 70, 71, 71, 70, 71,
70, 70, 71, 70, 70, 70, 70, 70, 70, 70, 70, 71, 22, -52, -71, -64, -66, -66,
-65, -66, -66, -65, -66, -65, -65, -66, -65, -69, -37, 39, 76, 68, 70, 71, 70,
70, 70, 71, 70, 71, 70, 70, 70, 69, 66, 61, 62, 62, 61, 62, 61, 62, 61, 62, 62,
61, 61, 61, 61, 62, 61, 61, 61, 61, 62, 62, 62, 61, 61, 61, 61, 61, 61, 61, 61,
61, 62, 60, 61, 61, 62, 61, 61, 61, 61, 61, 61, 62, 62, 61, 61, 61, 61, 59, 57,
57, 57, 58, 58, 58, 57, 58, 57, 57, 57, 57, 57, 57, 56, 55, 55, 56, 56, 55, 56,
56, 56, 55, 55, 56, 55, 56, 56, 55, 51, 45, 44, 45, 45, 45, 45, 44, 45, 45, 45,
44, 45, 44, 44, 45, 41, 35, 31, 33, 32, 33, 32, 32, 33, 33, 31, 33, 32, 33, 33,
32, 30, 29, 29, 28, 29, 29, 29, 29, 28, 28, 29, 28, 28, 29, 28, 29, 28, 26, 27,
27, 27, 27, 26, 27, 27, 26, 27, 27, 27, 26, 26, 27, 24, 17, 16, 17, 16, 16, 17,
16, 16, 17, 16, 16, 17, 16, 15, 16, 14, 5, 2, 3, 2, 2, 2, 2, 2, 2, 3, 2, 2, 2,
3, 1, -4, -8, -8, -9, -8, -8, -8, -8, -8, -8, -8, -9, -8, -9, -8, -9, -22, -39,
-40, -39, -40, -39, -40, -39, -40, -40, -40, -39, -40, -39, -40, -40, -49, -69,
-76, -75, -75, -75, -74, -74, -75, -74, -75, -74, -74, -75, -74, -74, -78, -91,
-98, -97, -97, -97, -97, -96, -97, -97, -96, -97, -97, -97, -96, -98, -105,
-112, -112, -112, -112, -112, -112, -111, -112, -113, -113, -112, -112, -112,
-112, -112, -115, -118, -118, -119, -119, -118, -118, -119, -118, -119, -119,
-119, -119, -118, -119, -118, -119, -118, -118, -118, -119, -119, -118, -118,
-118, -118, -118, -118, -119, -118, -118, -118, -115, -114, -114, -115, -114,
-114, -114, -114, -113, -114, -114, -114, -114, -114, -115, -114, -105, -97,
-97, -97, -96, -97, -97, -97, -96, -97, -96, -96, -97, -97, -97, -96, -82, -58,
-51, -53, -53, -52, -53, -53, -53, -52, -53, -52, -53, -53, -52, -54, -44, -24,
-14, -15, -17, -15, -15, -16, -16, -16, -16, -15, -15, -15, -16, -15, -6, 1, 0,
0, };