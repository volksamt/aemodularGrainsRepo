#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0095

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 13, 12, 13, 13, 13, 12, 13, 13, 13,
12, 12, 13, 12, 13, 11, 25, 42, 42, 43, 42, 42, 43, 42, 42, 42, 43, 42, 42, 42,
42, 42, 49, 65, 67, 67, 66, 66, 67, 66, 68, 66, 67, 66, 66, 66, 67, 66, 70, 74,
74, 74, 74, 74, 73, 74, 74, 74, 74, 74, 74, 74, 74, 74, 75, 79, 79, 79, 79, 79,
79, 79, 79, 79, 79, 78, 79, 79, 78, 78, 83, 95, 96, 95, 96, 96, 95, 95, 95, 95,
97, 95, 95, 95, 97, 95, 101, 103, 103, 103, 104, 103, 103, 103, 103, 103, 103,
103, 103, 103, 102, 103, 105, 108, 108, 108, 108, 107, 108, 107, 107, 107, 107,
108, 107, 108, 108, 107, 108, 110, 111, 110, 110, 110, 109, 110, 110, 110, 110,
110, 109, 110, 110, 109, 110, 109, 109, 110, 109, 109, 109, 109, 110, 109, 110,
110, 110, 110, 109, 110, 109, 109, 109, 109, 109, 110, 109, 110, 109, 110, 109,
110, 109, 110, 109, 109, 108, 104, 105, 105, 104, 104, 104, 105, 104, 104, 104,
105, 105, 105, 104, 105, 95, 89, 90, 89, 89, 89, 89, 90, 90, 89, 89, 89, 88, 89,
89, 90, 80, 66, 67, 67, 68, 68, 67, 67, 67, 67, 67, 67, 67, 66, 67, 69, 62, 46,
45, 45, 45, 46, 45, 45, 44, 46, 45, 45, 45, 45, 45, 46, 31, 19, 21, 20, 20, 19,
20, 20, 20, 20, 20, 20, 20, 20, 20, 21, 10, -5, -5, -5, -4, -5, -5, -5, -4, -4,
-4, -4, -4, -4, -5, -4, -11, -28, -29, -29, -29, -29, -29, -29, -30, -30, -29,
-29, -29, -29, -30, -28, -43, -52, -51, -52, -51, -51, -52, -51, -51, -51, -52,
-51, -51, -50, -51, -50, -64, -84, -83, -84, -83, -82, -83, -83, -82, -83, -84,
-83, -83, -83, -84, -84, -94, -98, -97, -98, -97, -98, -98, -97, -97, -97, -97,
-98, -98, -97, -98, -97, -105, -111, -110, -109, -110, -110, -110, -109, -109,
-110, -109, -109, -109, -109, -110, -109, -112, -114, -115, -114, -114, -115,
-115, -114, -115, -114, -114, -114, -114, -114, -114, -114, -118, -120, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -118, -120, -119, -119,
-119, -119, -119, -118, -119, -118, -118, -118, -118, -119, -119, -118, -119,
-118, -118, -119, -115, -111, -111, -110, -111, -111, -112, -110, -110, -111,
-111, -111, -110, -110, -112, -110, -107, -105, -106, -106, -106, -106, -107,
-105, -107, -106, -106, -106, -106, -107, -106, -105, -99, -92, -94, -94, -93,
-93, -93, -94, -93, -94, -93, -93, -93, -93, -93, -94, -88, -81, -81, -82, -81,
-81, -81, -81, -81, -81, -81, -82, -80, -81, -81, -80, -69, -65, -66, -66, -66,
-66, -66, -66, -65, -66, -66, -66, -65, -66, -66, -65, -50, -37, -40, -39, -40,
-39, -39, -40, -39, -39, -38, -40, -39, -38, -38, -40, -28, -14, -14, -14, -15,
-15, -14, -14, -14, -14, -14, -14, -15, -15, -15, -11, };