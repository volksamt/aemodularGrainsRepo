#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {62, 95, 84, 90, 86, 89, 87, 90, 87,
89, 88, 89, 87, 88, 87, 89, 89, 88, 88, 87, 88, 88, 89, 88, 88, 88, 89, 89, 88,
88, 88, 87, 88, 88, 87, 88, 89, 87, 87, 87, 88, 87, 89, 88, 88, 89, 88, 88, 88,
88, 88, 87, 87, 87, 88, 88, 88, 87, 88, 88, 87, 88, 88, 88, 87, 88, 88, 87, 87,
88, 88, 87, 88, 87, 87, 88, 87, 87, 87, 88, 87, 87, 88, 87, 87, 87, 87, 87, 86,
86, 87, 88, 87, 87, 87, 87, 87, 87, 87, 87, 86, 87, 87, 87, 87, 87, 86, 86, 87,
86, 86, 86, 87, 87, 86, 87, 86, 87, 86, 87, 86, 86, 86, 86, 86, 87, 86, 86, 86,
87, 86, 86, 86, 86, 86, 85, 86, 86, 86, 86, 86, 86, 85, 85, 85, 86, 86, 86, 86,
86, 86, 86, 85, 85, 86, 86, 85, 85, 85, 85, 85, 85, 85, 86, 85, 85, 85, 85, 85,
86, 84, 85, 86, 84, 85, 85, 85, 84, 85, 84, 85, 85, 85, 85, 85, 84, 85, 85, 84,
84, 84, 85, 84, 84, 84, 84, 84, 84, 84, 84, 84, 84, 84, 84, 83, 84, 84, 84, 83,
84, 84, 84, 84, 84, 83, 84, 84, 84, 84, 83, 84, 84, 84, 83, 84, 83, 83, 83, 83,
84, 84, 83, 84, 84, 83, 83, 84, 83, 86, 69, 29, 21, 22, 22, 23, 21, 22, 21, 22,
21, 22, 22, 22, 21, 22, 21, 21, 22, 21, 22, 21, 21, 21, 22, 22, 21, 21, 22, 22,
22, 21, 19, 12, 11, 12, 11, 12, 12, 11, 12, 11, 12, 12, 12, 12, 12, 12, 11, 8,
8, 9, 9, 9, 9, 8, 9, 9, 9, 8, 9, 9, 8, 9, 8, 6, 6, 5, 5, 6, 6, 7, 6, 6, 5, 6, 5,
7, 4, 8, -44, -116, -116, -115, -116, -116, -116, -116, -116, -115, -116, -115,
-116, -115, -116, -116, -117, -115, -116, -116, -115, -115, -116, -116, -115,
-116, -116, -115, -115, -116, -115, -116, -115, -115, -115, -115, -115, -116,
-115, -115, -115, -115, -115, -116, -116, -115, -115, -115, -115, -115, -115,
-116, -115, -115, -115, -115, -115, -115, -115, -115, -114, -114, -115, -114,
-114, -114, -115, -114, -114, -115, -115, -114, -114, -114, -114, -113, -115,
-114, -114, -114, -114, -114, -113, -114, -113, -113, -113, -113, -114, -114,
-114, -113, -114, -113, -113, -113, -113, -114, -113, -113, -113, -114, -114,
-114, -113, -113, -113, -113, -113, -113, -113, -113, -112, -112, -113, -113,
-112, -112, -113, -113, -112, -112, -113, -113, -112, -112, -112, -113, -112,
-112, -112, -112, -113, -112, -112, -112, -112, -112, -112, -112, -112, -111,
-112, -111, -113, -112, -112, -112, -111, -112, -111, -111, -112, -111, -111,
-111, -112, -111, -111, -111, -112, -112, -111, -110, -111, -111, -111, -112,
-111, -111, -111, -111, -111, -111, -111, -111, -111, -110, -110, -110, -111,
-111, -110, -111, -111, -110, -110, -112, -111, -112, -109, -115, -50, };