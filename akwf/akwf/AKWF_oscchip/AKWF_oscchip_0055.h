#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0055

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 7, 6, 7, 5, 6, 6, 7, 6, 7, 7, 7, 7,
7, 7, 7, 7, 6, 6, 7, 7, 6, 7, 7, 7, 7, 6, 6, 7, 6, 7, 7, 7, 7, 7, 7, 7, 7, 6, 6,
6, 7, 7, 6, 7, 6, 7, 7, 6, 6, 7, 7, 6, 6, 7, 7, 7, 7, 6, 7, 7, 7, 7, 9, 8, 8, 8,
8, 9, 9, 8, 9, 9, 9, 8, 9, 8, 9, 9, 10, 11, 10, 11, 11, 11, 11, 10, 10, 10, 11,
10, 10, 10, 10, 10, 10, 10, 10, 11, 11, 10, 10, 10, 10, 10, 10, 11, 10, 11, 10,
11, 11, 12, 12, 12, 12, 12, 12, 13, 12, 11, 12, 11, 12, 12, 12, 12, 11, 10, 10,
11, 11, 11, 10, 10, 9, 10, 11, 10, 10, 10, 10, 10, 11, 13, 12, 12, 11, 12, 12,
12, 13, 12, 13, 13, 12, 12, 12, 12, 10, 11, 10, 10, 10, 10, 11, 11, 10, 10, 10,
11, 11, 10, 9, 10, 8, 8, 8, 8, 9, 8, 8, 8, 9, 8, 8, 8, 9, 8, 9, 8, 8, 7, 8, 9,
8, 8, 8, 8, 8, 9, 8, 8, 8, 9, 7, 9, 49, 105, 116, 111, 113, 113, 114, 113, 113,
113, 113, 113, 113, 112, 113, 112, 113, 112, 112, 113, 113, 112, 113, 113, 113,
113, 113, 113, 113, 113, 112, 113, 112, 113, 112, 113, 112, 112, 113, 112, 112,
112, 112, 112, 112, 112, 112, 112, 109, 106, 104, 105, 104, 105, 105, 105, 105,
104, 104, 104, 104, 105, 104, 106, 110, 110, 110, 109, 110, 109, 110, 109, 110,
110, 109, 110, 110, 110, 109, 109, 108, 108, 107, 108, 108, 107, 107, 107, 108,
107, 108, 107, 107, 107, 107, 107, 107, 107, 107, 107, 106, 106, 108, 107, 107,
108, 107, 107, 107, 106, 107, 107, 107, 106, 107, 107, 107, 106, 107, 106, 106,
107, 106, 107, 106, 106, 106, 107, 109, 109, 109, 111, 111, 109, 110, 110, 110,
110, 109, 110, 110, 109, 113, 80, -45, -119, -110, -111, -111, -112, -111, -111,
-111, -111, -112, -110, -111, -112, -111, -111, -111, -110, -111, -112, -111,
-111, -112, -111, -112, -111, -111, -110, -111, -111, -111, -112, -111, -111,
-112, -112, -110, -111, -112, -110, -111, -111, -111, -111, -110, -111, -111,
-111, -110, -111, -110, -111, -111, -111, -111, -111, -111, -111, -110, -110,
-111, -110, -110, -110, -111, -109, -111, -110, -110, -111, -109, -111, -109,
-110, -111, -110, -110, -110, -109, -110, -109, -110, -110, -110, -110, -110,
-110, -110, -110, -110, -109, -110, -109, -110, -109, -110, -110, -110, -110,
-109, -109, -110, -110, -110, -109, -110, -109, -110, -109, -110, -109, -109,
-109, -108, -108, -109, -109, -109, -108, -108, -110, -109, -109, -109, -109,
-109, -109, -108, -109, -108, -108, -109, -109, -108, -109, -109, -108, -108,
-109, -109, -107, -108, -108, -108, -108, -108, -107, -107, -108, -107, -108,
-108, -108, -108, -108, -108, -108, -108, -110, -78, -15, };