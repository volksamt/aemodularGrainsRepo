#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0056

const PROGMEM int8_t DATA[DATA_LENGTH] = {14, 66, 84, 79, 80, 79, 80, 80, 80,
79, 80, 79, 80, 79, 80, 80, 80, 79, 80, 79, 80, 80, 79, 80, 79, 80, 80, 80, 79,
80, 79, 79, 80, 80, 79, 79, 79, 80, 79, 80, 80, 79, 79, 79, 79, 79, 79, 79, 78,
77, 74, 72, 73, 73, 73, 73, 73, 73, 72, 73, 73, 72, 73, 72, 73, 77, 77, 78, 77,
77, 77, 77, 78, 76, 77, 77, 76, 77, 78, 77, 77, 76, 75, 76, 75, 75, 76, 76, 75,
75, 75, 76, 75, 75, 75, 75, 75, 75, 75, 74, 76, 74, 74, 75, 74, 75, 75, 75, 75,
75, 75, 75, 75, 75, 75, 74, 76, 74, 74, 75, 74, 74, 74, 75, 74, 74, 74, 74, 75,
78, 78, 78, 78, 77, 78, 77, 77, 77, 77, 78, 77, 78, 76, 81, 44, -67, -121, -114,
-115, -115, -115, -115, -115, -114, -114, -114, -114, -115, -115, -114, -115,
-114, -114, -115, -114, -115, -115, -115, -115, -116, -114, -115, -114, -114,
-114, -114, -115, -114, -115, -114, -114, -114, -114, -115, -114, -114, -114,
-114, -115, -114, -114, -115, -115, -114, -113, -113, -114, -114, -114, -114,
-113, -114, -113, -113, -113, -114, -113, -115, -96, -41, -15, -19, -19, -19,
-20, -19, -19, -20, -19, -19, -19, -19, -19, -19, -14, -12, -11, -11, -12, -11,
-11, -11, -11, -12, -11, -11, -11, -11, -12, -11, -12, -13, -12, -12, -13, -12,
-12, -13, -13, -12, -13, -12, -13, -12, -13, -12, -13, -14, -14, -14, -14, -14,
-14, -14, -14, -14, -14, -14, -14, -14, -14, -14, -14, -15, -16, -15, -16, -16,
-16, -16, -15, -15, -15, -15, -15, -15, -16, -16, -16, -15, -15, -15, -16, -15,
-16, -16, -15, -16, -15, -15, -16, -15, -15, -16, -14, -14, -14, -14, -14, -13,
-14, -14, -14, -14, -14, -14, -14, -14, -13, -14, -13, -14, -14, -14, -14, -14,
-14, -14, -14, -14, -13, -14, -13, -14, -14, -14, -13, -14, -14, -13, -13, -14,
-14, -13, -13, -13, -13, -13, -14, -14, -14, -14, -13, -14, -13, -13, -14, -14,
-13, -13, -13, -14, -13, -14, -14, -14, -14, -13, -12, -12, -12, -12, -12, -12,
-12, -12, -12, -11, -12, -12, -12, -12, -12, -11, -12, -10, -11, -11, -10, -10,
-10, -10, -10, -11, -10, -10, -10, -10, -10, -10, -11, -10, -9, -10, -10, -10,
-10, -11, -11, -10, -10, -10, -10, -10, -10, -10, -10, -9, -9, -8, -9, -8, -8,
-9, -8, -9, -9, -9, -9, -9, -8, -8, -9, -11, -10, -11, -10, -10, -10, -10, -10,
-10, -10, -10, -10, -10, -10, -10, -10, -8, -8, -8, -8, -9, -8, -9, -9, -9, -8,
-9, -9, -8, -8, -9, -10, -9, -10, -9, -10, -10, -10, -10, -10, -10, -10, -9,
-10, -10, -10, -10, -11, -12, -12, -11, -11, -12, -12, -12, -11, -12, -12, -12,
-12, -12, -11, -11, -12, -12, -12, -11, -12, -11, -12, -11, -12, -12, -12, -12,
-12, -11, -13, -11, };