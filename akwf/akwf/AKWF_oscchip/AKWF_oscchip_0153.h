#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0153

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 5, 3, 4, 4, 3, 4, 4, 3, 4, 3, 4, 3,
4, 4, 5, 11, 15, 13, 14, 13, 14, 13, 14, 13, 13, 14, 14, 14, 13, 14, 19, 26, 25,
26, 26, 25, 26, 25, 26, 25, 25, 25, 25, 25, 25, 25, 32, 40, 41, 41, 41, 40, 41,
41, 41, 41, 40, 40, 42, 42, 41, 41, 44, 51, 54, 53, 52, 52, 52, 53, 53, 53, 53,
52, 52, 53, 53, 51, 58, 81, 89, 88, 88, 88, 88, 87, 88, 87, 88, 88, 88, 88, 88,
87, 99, 107, 107, 107, 107, 107, 107, 107, 107, 108, 107, 106, 108, 106, 107,
107, 110, 115, 114, 114, 115, 115, 115, 115, 116, 115, 115, 115, 115, 115, 115,
116, 116, 118, 120, 119, 120, 119, 119, 119, 118, 119, 119, 119, 119, 120, 119,
119, 117, 110, 107, 108, 107, 107, 108, 107, 107, 106, 108, 107, 107, 107, 108,
107, 98, 91, 92, 91, 91, 92, 92, 91, 92, 92, 92, 91, 91, 91, 91, 92, 85, 76, 75,
77, 77, 76, 76, 76, 76, 76, 76, 76, 76, 76, 76, 77, 72, 65, 64, 64, 64, 64, 64,
65, 65, 65, 65, 64, 64, 64, 64, 65, 62, 52, 48, 50, 48, 49, 49, 50, 48, 49, 49,
48, 49, 48, 49, 47, 30, 17, 18, 17, 18, 17, 18, 17, 17, 18, 17, 18, 17, 18, 18,
18, -11, -47, -46, -47, -47, -47, -47, -47, -46, -47, -47, -47, -47, -47, -47,
-47, -45, -40, -39, -39, -38, -38, -39, -39, -38, -39, -39, -40, -39, -39, -39,
-39, -39, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -36,
-37, -36, -35, -35, -36, -36, -35, -35, -35, -35, -35, -36, -35, -35, -36, -35,
-34, -40, -45, -45, -45, -46, -45, -45, -45, -45, -45, -45, -45, -45, -44, -46,
-45, -52, -63, -65, -64, -65, -65, -65, -64, -63, -65, -64, -64, -64, -64, -64,
-64, -66, -74, -77, -76, -76, -76, -76, -76, -76, -76, -77, -76, -77, -76, -75,
-78, -94, -104, -103, -104, -103, -103, -103, -103, -103, -103, -103, -103,
-104, -103, -103, -104, -108, -111, -111, -111, -111, -111, -112, -111, -111,
-111, -110, -111, -112, -111, -111, -112, -113, -114, -115, -115, -114, -115,
-115, -114, -115, -116, -115, -115, -115, -115, -115, -115, -113, -105, -102,
-103, -103, -103, -104, -103, -104, -103, -104, -103, -104, -103, -103, -102,
-91, -83, -84, -83, -83, -84, -83, -84, -83, -84, -84, -84, -84, -84, -84, -84,
-76, -68, -68, -68, -68, -68, -69, -68, -68, -69, -69, -69, -68, -68, -68, -69,
-64, -57, -56, -58, -56, -57, -56, -57, -57, -57, -57, -56, -57, -57, -57, -57,
-53, -46, -45, -45, -46, -46, -45, -45, -45, -45, -45, -45, -45, -45, -45, -45,
-43, -31, -26, -27, -27, -28, -27, -27, -26, -27, -27, -27, -27, -27, -27, -27,
-18, -9, -10, -10, -10, -10, -10, -10, -10, -10, -10, -10, -10, -10, -11, -10,
-4, };