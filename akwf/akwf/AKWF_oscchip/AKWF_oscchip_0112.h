#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0112

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 1, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0,
-1, 0, 0, 1, 1, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 1, 0, 1, 2, 2, 1, 2, 2, 2,
2, 2, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 4, 3, 3, 4, 4, 4, 4, 4, 3, 3, 4, 4, 4, 4, 4,
4, 4, 4, 3, 4, 4, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 3, 3, 3, 4, 4, 4, 4, 3,
3, 4, 4, 4, 4, 4, 4, 4, 4, 2, 4, 3, 5, 2, 4, 2, 6, -1, 40, 109, 107, 107, 107,
108, 107, 107, 108, 108, 107, 107, 107, 108, 107, 107, 107, 102, 102, 102, 102,
102, 102, 102, 101, 101, 102, 101, 101, 102, 102, 101, 95, 90, 91, 90, 90, 90,
90, 90, 90, 90, 91, 91, 90, 91, 89, 91, 86, 79, 78, 79, 79, 79, 79, 79, 79, 79,
78, 79, 79, 79, 78, 80, 76, 66, 64, 63, 64, 63, 63, 63, 63, 64, 63, 63, 63, 64,
63, 64, 55, 48, 49, 49, 48, 49, 47, 49, 48, 48, 48, 48, 49, 48, 49, 48, 44, 38,
37, 37, 38, 37, 37, 36, 37, 37, 37, 37, 37, 36, 37, 35, 11, -4, 0, -2, -1, -2,
-1, -1, -1, 0, -2, -1, -1, 1, -4, 2, -61, -123, -116, -119, -117, -118, -117,
-118, -118, -118, -118, -118, -118, -117, -118, -118, -113, -102, -103, -103,
-103, -103, -103, -102, -103, -103, -103, -102, -102, -102, -102, -102, -94,
-90, -91, -91, -92, -91, -92, -91, -91, -92, -91, -91, -91, -91, -91, -92, -83,
-75, -76, -76, -76, -76, -76, -76, -76, -76, -75, -76, -76, -76, -75, -76, -72,
-64, -65, -64, -64, -64, -65, -65, -64, -65, -64, -65, -64, -65, -65, -63, -45,
-37, -39, -38, -39, -39, -38, -38, -38, -38, -38, -37, -37, -38, -38, -37, -27,
-16, -18, -17, -17, -18, -17, -17, -17, -17, -18, -18, -17, -18, -17, -17, -15,
-9, -9, -10, -9, -10, -10, -10, -10, -9, -9, -10, -10, -10, -9, -10, -6, -3, -4,
-4, -4, -4, -4, -4, -4, -4, -3, -3, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4,
-4, -4, -4, -4, -3, -4, -4, -4, -4, -3, -2, -2, -2, -1, -2, -1, -2, -2, -2, -1,
-2, -2, -3, -2, -2, -1, 0, 1, 1, 0, -1, 0, -1, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0,
0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, -2, -6, -5, -5, -6, -5, -6, -6, -5, -7,
-6, -5, -6, -6, -5, -5, -6, -5, -5, -6, -5, -6, -6, -5, -5, -5, -5, -6, -5, -6,
-5, -6, -3, -1, -2, -2, -2, -2, -2, -1, -2, -2, -2, -2, -2, -1, -1, -2, -2, -1,
-2, -2, -2, -1, -2, -2, -1, -1, -2, -2, -2, -2, -2, -2, -1, };