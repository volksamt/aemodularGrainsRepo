#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0158

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 3, 1, 2, 2, 2, 2, 2, 2, 2, 2,
2, 2, 2, 2, 1, 3, 2, 2, 3, 2, 2, 3, 2, 2, 1, 2, 2, 2, 1, 2, 2, 2, 2, 2, 3, 2, 1,
1, 2, 3, 2, 2, 2, 2, 1, 2, 2, 1, 2, 2, 2, 1, 2, 2, 2, 1, 2, 2, 2, 1, 2, 2, 2, 3,
2, 2, 2, 2, 2, 2, 2, 2, 1, 2, 1, 2, 2, 3, 2, 1, 1, 2, 2, 2, 2, 2, 1, 2, 2, 1, 2,
2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 2, 2, 2, 1, 2, 2, 4, 3, 3, 4, 3, 4, 3, 3, 3,
4, 2, 5, 3, 4, 1, 35, 104, 117, 113, 114, 113, 115, 114, 114, 113, 114, 115,
114, 114, 114, 113, 103, 98, 99, 98, 98, 99, 99, 98, 99, 98, 98, 99, 99, 99, 99,
97, 83, 69, 70, 70, 70, 70, 70, 71, 69, 70, 70, 70, 70, 69, 70, 70, 48, 20, 19,
20, 20, 20, 19, 19, 19, 19, 20, 19, 19, 20, 20, 20, 16, 8, 7, 7, 7, 6, 7, 7, 7,
8, 7, 8, 7, 7, 7, 6, 1, 0, 0, 0, 1, 0, -1, 0, 0, 0, 1, 0, 0, -1, 0, -1, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0,
0, 0, 0, -1, -1, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, -1, -2, -2, -2, -2, -3,
-2, -2, -2, -2, -2, -2, -1, -2, -2, -2, -1, -1, -3, -1, -1, -1, -1, -2, -2, -2,
-1, -3, -2, -2, -1, -2, -2, -3, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2,
-2, -2, -1, -2, -2, -2, -2, -1, -2, -2, -1, -2, -1, -2, -2, -1, -1, -2, -1, -2,
-1, -2, -1, -2, -1, -1, -3, -2, -1, -2, -2, -1, -1, -8, -74, -120, -114, -116,
-115, -115, -115, -116, -114, -115, -115, -115, -115, -114, -114, -114, -94,
-71, -72, -72, -72, -72, -72, -71, -72, -72, -71, -72, -72, -72, -72, -72, -64,
-51, -49, -51, -50, -50, -50, -50, -50, -50, -51, -50, -51, -50, -50, -48, -37,
-34, -34, -34, -35, -33, -34, -34, -35, -34, -34, -34, -34, -34, -35, -33, -24,
-16, -18, -18, -18, -17, -18, -18, -18, -19, -17, -18, -17, -18, -18, -17, -10,
-1, -1, -2, -2, -2, -2, -2, -1, -1, -2, -2, -2, -2, -2, -2, -3, -3, -4, -4, -3,
-4, -4, -4, -4, -4, -3, -3, -3, -4, -3, -4, -3, -3, -4, -3, -3, -4, -4, -4, -3,
-4, -4, -5, -3, -4, -3, -4, -3, -2, -2, -2, -2, -2, -2, -2, -2, -1, -1, -1, -2,
-1, -1, -1, -1, -1, -2, -2, -1, -2, -2, -1, -1, -2, -2, -2, -2, -2, -2, -2, 0,
};