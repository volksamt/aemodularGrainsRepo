#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {15, 52, 47, 49, 48, 48, 49, 48, 49,
47, 48, 48, 49, 48, 49, 48, 49, 49, 49, 48, 48, 48, 49, 47, 48, 48, 48, 48, 48,
48, 48, 49, 48, 48, 48, 47, 48, 48, 47, 49, 47, 48, 47, 49, 48, 49, 48, 48, 48,
48, 48, 48, 48, 48, 48, 48, 48, 48, 48, 48, 48, 48, 48, 48, 47, 48, 47, 48, 48,
48, 48, 48, 48, 48, 48, 48, 48, 48, 48, 48, 48, 47, 47, 47, 47, 47, 48, 48, 48,
47, 48, 48, 48, 48, 48, 47, 47, 48, 48, 47, 48, 47, 47, 47, 47, 47, 48, 47, 47,
47, 49, 46, 79, 118, 116, 117, 116, 117, 116, 116, 117, 116, 116, 116, 116, 116,
117, 116, 116, 116, 116, 115, 116, 116, 117, 116, 116, 115, 116, 115, 116, 116,
116, 115, 115, 114, 115, 115, 115, 115, 115, 114, 114, 114, 115, 114, 114, 114,
115, 114, 114, 115, 115, 114, 114, 114, 114, 114, 115, 114, 114, 114, 114, 114,
114, 112, 72, 42, 47, 44, 46, 45, 46, 45, 45, 46, 46, 45, 45, 45, 46, 45, 45,
43, 44, 44, 44, 43, 43, 43, 43, 43, 43, 43, 43, 43, 43, 43, 43, 43, 43, 43, 42,
44, 42, 43, 43, 43, 43, 44, 43, 43, 43, 43, 43, 43, 42, 42, 43, 43, 43, 43, 42,
42, 42, 42, 43, 42, 43, 43, 42, 43, 42, 43, 42, 43, 43, 42, 43, 42, 42, 43, 42,
42, 41, 43, 46, 46, 46, 47, 47, 46, 46, 46, 46, 45, 45, 45, 46, 45, 46, 46, 42,
42, 42, 43, 43, 42, 42, 42, 43, 42, 41, 42, 43, 42, 42, 42, 42, 42, 42, 41, 42,
41, 42, 41, 43, 42, 43, 41, 43, 41, 43, 32, 3, -3, -1, -1, -2, -2, -2, -3, -2,
-2, -2, -1, -3, -1, -3, 0, -42, -97, -95, -95, -95, -94, -95, -95, -95, -94,
-96, -95, -95, -95, -96, -95, -95, -95, -95, -95, -96, -95, -95, -95, -95, -95,
-95, -94, -94, -95, -95, -95, -96, -96, -97, -97, -96, -97, -97, -96, -96, -96,
-97, -96, -97, -96, -96, -96, -95, -94, -94, -94, -94, -94, -95, -95, -93, -94,
-94, -94, -95, -94, -93, -94, -93, -94, -93, -94, -93, -94, -94, -94, -94, -94,
-94, -94, -94, -94, -93, -94, -95, -96, -95, -95, -96, -95, -95, -95, -96, -95,
-95, -95, -95, -95, -95, -96, -96, -97, -97, -96, -96, -96, -96, -96, -96, -96,
-97, -96, -96, -96, -96, -96, -97, -96, -96, -97, -97, -97, -95, -96, -96, -95,
-96, -96, -96, -96, -96, -97, -96, -97, -96, -96, -96, -96, -96, -96, -95, -95,
-96, -95, -95, -95, -95, -95, -95, -95, -95, -95, -95, -95, -95, -95, -95, -95,
-95, -96, -94, -94, -95, -95, -94, -95, -95, -96, -94, -94, -94, -95, -95, -95,
-95, -96, -95, -95, -95, -94, -96, -95, -96, -96, -96, -95, -97, -95, -97, -95,
-97, -94, -97, -92, -102, -65, };