#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {19, 104, 118, 112, 116, 113, 116, 113,
115, 114, 115, 113, 115, 114, 115, 114, 114, 112, 113, 113, 112, 112, 113, 112,
111, 113, 112, 112, 112, 113, 111, 113, 109, 108, 106, 107, 107, 107, 107, 106,
107, 107, 106, 106, 106, 106, 106, 106, 105, 94, 83, 85, 84, 85, 84, 85, 85, 84,
85, 85, 84, 84, 84, 84, 83, 71, 63, 66, 65, 64, 65, 65, 65, 65, 64, 64, 64, 65,
64, 66, 58, 5, -22, -18, -20, -18, -19, -19, -19, -19, -20, -19, -19, -19, -19,
-19, -20, -19, -20, -19, -19, -20, -19, -20, -19, -20, -19, -20, -19, -20, -19,
-19, -19, -20, -19, -19, -19, -20, -19, -20, -19, -20, -19, -20, -19, -20, -19,
-20, -19, -20, -19, -19, -19, -20, -19, -19, -19, -19, -19, -19, -20, -19, -20,
-19, -19, -19, -19, -20, -19, -19, -20, -20, -19, -20, -19, -19, -19, -20, -19,
-18, -20, -19, -19, -20, -20, -19, -19, -20, -19, -20, -19, -18, -19, -19, -20,
-20, -19, -17, -17, -18, -17, -17, -18, -18, -17, -17, -17, -17, -18, -17, -17,
-18, -18, -20, -19, -19, -19, -19, -20, -19, -18, -19, -19, -19, -19, -19, -19,
-19, -18, -17, -18, -17, -18, -17, -17, -18, -18, -17, -17, -16, -17, -16, -17,
-17, -18, -19, -19, -18, -18, -19, -19, -19, -20, -18, -19, -19, -19, -19, -19,
-19, -18, -17, -17, -17, -17, -17, -17, -17, -17, -17, -16, -17, -16, -17, -16,
-18, -18, -19, -18, -19, -19, -18, -19, -19, -19, -18, -19, -19, -19, -18, -19,
-19, -19, -17, -17, -17, -18, -16, -17, -16, -17, -17, -17, -17, -17, -16, -16,
-17, -17, -19, -19, -19, -19, -18, -18, -18, -19, -19, -19, -19, -19, -18, -19,
-18, -18, -17, -17, -16, -16, -16, -17, -16, -17, -16, -17, -17, -17, -17, -17,
-17, -17, -18, -19, -18, -19, -18, -18, -18, -18, -19, -19, -18, -18, -19, -18,
-19, -18, -16, -17, -16, -17, -17, -16, -16, -17, -17, -17, -16, -16, -16, -16,
-16, -17, -18, -18, -18, -19, -19, -19, -18, -18, -19, -18, -18, -18, -18, -18,
-19, -17, -17, -16, -17, -17, -16, -16, -17, -17, -16, -17, -16, -17, -16, -16,
-16, -17, -18, -18, -18, -18, -18, -19, -19, -18, -18, -18, -18, -18, -19, -18,
-18, -18, -18, -18, -18, -18, -17, -17, -18, -18, -18, -17, -18, -18, -18, -18,
-18, -17, -18, -18, -17, -18, -18, -18, -18, -18, -18, -18, -18, -18, -18, -18,
-18, -18, -18, -18, -18, -18, -18, -17, -18, -18, -18, -18, -17, -18, -18, -18,
-18, -18, -17, -18, -18, -17, -18, -18, -18, -18, -18, -18, -17, -18, -18, -18,
-17, -16, -16, -15, -16, -15, -16, -15, -17, -16, -16, -16, -16, -16, -16, -16,
-17, -17, -17, -18, -18, -18, -18, -18, -18, -17, -17, -18, -18, -17, -18, -17,
-17, -18, -17, -17, -17, -18, -17, -17, -17, -18, -17, -19, -17, -19, -16, -19,
-17, };