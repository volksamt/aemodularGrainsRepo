#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {58, 116, 105, 111, 107, 109, 108, 108,
108, 109, 108, 109, 108, 108, 109, 108, 108, 108, 108, 107, 108, 108, 108, 108,
109, 108, 108, 107, 108, 108, 109, 108, 109, 107, 108, 108, 108, 108, 108, 108,
108, 108, 107, 108, 108, 108, 109, 108, 108, 108, 108, 108, 108, 108, 108, 108,
108, 108, 108, 108, 107, 108, 107, 108, 108, 108, 107, 108, 107, 107, 107, 108,
108, 108, 108, 107, 108, 107, 107, 107, 107, 108, 108, 107, 107, 107, 107, 107,
107, 107, 108, 107, 107, 107, 107, 107, 106, 108, 106, 107, 108, 107, 107, 107,
107, 107, 107, 107, 107, 107, 106, 107, 107, 107, 108, 106, 107, 107, 107, 107,
106, 107, 106, 106, 106, 107, 106, 107, 107, 106, 107, 106, 107, 106, 107, 107,
107, 106, 107, 106, 106, 107, 106, 107, 107, 107, 106, 107, 106, 107, 106, 106,
106, 106, 106, 107, 106, 106, 106, 106, 106, 107, 106, 106, 106, 106, 106, 106,
106, 106, 107, 106, 106, 106, 106, 106, 107, 106, 105, 106, 106, 106, 106, 106,
106, 106, 106, 106, 106, 106, 106, 105, 105, 106, 106, 105, 106, 106, 105, 106,
106, 106, 105, 105, 106, 105, 106, 105, 106, 106, 106, 105, 105, 106, 106, 106,
105, 106, 106, 105, 106, 105, 106, 105, 106, 105, 106, 104, 106, 104, 106, 105,
106, 104, 106, 105, 106, 104, 107, 76, -67, -125, -113, -118, -114, -117, -115,
-116, -116, -117, -115, -116, -115, -115, -116, -115, -116, -117, -116, -115,
-116, -116, -116, -116, -116, -116, -116, -116, -116, -116, -116, -116, -116,
-115, -116, -115, -115, -115, -116, -116, -115, -115, -115, -116, -115, -115,
-115, -115, -115, -115, -115, -115, -116, -116, -115, -116, -115, -115, -115,
-116, -115, -115, -116, -116, -115, -116, -116, -115, -116, -116, -116, -115,
-115, -115, -115, -115, -116, -115, -115, -115, -115, -115, -116, -115, -115,
-115, -115, -115, -115, -115, -115, -114, -115, -115, -115, -116, -115, -115,
-114, -115, -114, -115, -114, -116, -115, -114, -114, -114, -115, -115, -115,
-114, -115, -115, -114, -115, -114, -114, -114, -114, -115, -115, -114, -114,
-115, -115, -114, -115, -114, -114, -114, -115, -115, -114, -115, -114, -115,
-114, -114, -115, -114, -115, -113, -110, -12, 64, 56, 59, 56, 58, 57, 58, 58,
58, 57, 58, 58, 58, 57, 51, -54, -121, -112, -116, -113, -115, -113, -114, -114,
-114, -113, -114, -113, -113, -115, -106, 6, 68, 55, 61, 58, 61, 59, 60, 58, 59,
59, 60, 59, 59, 61, 46, -64, -123, -111, -116, -113, -115, -112, -114, -113,
-115, -114, -114, -114, -114, -113, -114, -113, -114, -114, -113, -113, -114,
-114, -114, -114, -114, -114, -114, -113, -113, -114, -113, -114, -114, -115,
-114, -114, -113, -114, -114, -113, -113, -114, -113, -113, -114, -113, -114,
-113, -114, -113, -113, -112, -113, -113, -114, -113, -113, -112, -114, -113,
-113, -114, -113, -113, -114, -113, -113, -113, -113, -114, -113, -114, -113,
-114, -112, -115, -111, -120, -66, };