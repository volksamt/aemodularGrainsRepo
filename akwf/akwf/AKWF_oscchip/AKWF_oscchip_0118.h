#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0118

const PROGMEM int8_t DATA[DATA_LENGTH] = {46, 109, 99, 104, 102, 103, 102, 101,
103, 102, 102, 102, 102, 102, 103, 100, 95, 94, 95, 94, 94, 94, 95, 94, 94, 94,
94, 93, 94, 94, 93, 98, 115, 119, 119, 119, 118, 118, 118, 119, 117, 118, 118,
119, 118, 119, 119, 117, 109, 104, 105, 104, 104, 104, 104, 104, 104, 104, 104,
104, 104, 103, 105, 102, 98, 97, 98, 97, 98, 98, 99, 97, 98, 98, 98, 96, 98, 97,
99, 86, 13, -7, 0, -4, -2, -3, -2, -3, -2, -3, -1, -3, -2, -2, -3, -3, -3, -3,
-3, -2, -2, -2, -2, -2, -3, -2, -3, -3, -3, -2, -2, -2, -2, -2, -2, -3, -3, -2,
-2, -2, -2, -3, -3, -2, -2, -2, -2, -2, -1, -1, 0, 0, 0, -1, -1, -1, -1, 0, 0,
0, -1, -1, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, -1, -1, -1,
-1, 0, -1, -1, -1, 0, -1, -1, -1, 0, 0, 0, 0, 0, 0, -1, -1, 0, -1, 0, -1, -1,
-1, 0, 0, 0, 0, -1, -1, 1, -1, -1, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0,
-1, -1, -1, -1, -1, -1, -1, -1, 0, -1, 0, 0, 0, 0, -1, -1, 0, -1, 0, -1, 0, -1,
0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, -1, -1, 0, 0, -1, 0, 0, 0, -1, -1, 0,
0, 0, -1, 0, 0, 0, 0, -1, -1, -1, -1, 0, 0, -1, -1, 0, -1, 0, -1, 0, 0, 0, -1,
0, 0, -1, -1, -1, -1, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, -1,
-1, 0, -1, -1, -1, -1, 0, -1, 0, 0, 0, -1, -1, -1, -1, -1, 0, 0, 0, 0, -1, 0, 0,
-1, 0, -1, 0, 0, 0, 0, -1, -1, 0, 0, 0, -1, 0, 0, -1, 0, -1, -1, -1, -1, 0, -1,
0, 0, 0, 0, -1, 1, 3, 4, 4, 4, 4, 4, 3, 3, 4, 4, 3, 4, 4, 4, 3, 3, 1, 0, 0, 0,
0, -1, -1, -1, 0, -1, 0, -1, 0, 0, 0, -1, -3, -2, -2, -2, -2, -2, -3, -2, -3,
-3, -3, -2, -2, -3, -2, -2, -2, -2, -2, -3, -2, -2, -3, -2, -2, -3, -3, -3, -3,
-2, -2, -3, -3, -2, -2, -2, -3, -3, -2, -2, -2, -3, -1, -3, -1, -4, 1, -46,
-105, -101, -103, -101, -102, -102, -102, -103, -101, -102, -102, -102, -103,
-103, -101, -103, -104, -104, -103, -104, -104, -104, -104, -105, -104, -104,
-104, -103, -104, -104, -104, -103, -94, -92, -92, -91, -92, -92, -91, -91, -92,
-92, -91, -92, -92, -92, -92, -96, -100, -100, -100, -100, -100, -101, -100,
-100, -100, -100, -100, -100, -100, -100, -100, -98, -95, -95, -96, -95, -97,
-94, -96, -94, -97, -94, -97, -93, -98, -92, -100, -68, };