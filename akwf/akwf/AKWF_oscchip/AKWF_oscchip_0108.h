#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0108

const PROGMEM int8_t DATA[DATA_LENGTH] = {34, 59, 54, 57, 55, 56, 55, 55, 55,
56, 55, 56, 56, 55, 55, 54, 55, 55, 55, 55, 55, 55, 55, 55, 55, 56, 56, 55, 55,
55, 55, 55, 55, 58, 57, 57, 57, 57, 58, 58, 57, 58, 58, 58, 58, 57, 58, 58, 58,
59, 60, 59, 59, 59, 59, 59, 60, 59, 60, 60, 60, 60, 60, 59, 69, 76, 76, 77, 77,
76, 77, 76, 76, 77, 76, 76, 76, 77, 76, 76, 77, 77, 79, 78, 78, 78, 78, 79, 78,
78, 78, 78, 79, 78, 78, 78, 84, 88, 86, 87, 86, 87, 87, 86, 86, 87, 86, 87, 86,
87, 87, 87, 87, 88, 88, 88, 89, 88, 89, 88, 89, 89, 89, 89, 89, 88, 88, 88, 89,
90, 91, 90, 90, 91, 90, 91, 90, 91, 90, 91, 91, 90, 90, 91, 95, 97, 96, 97, 97,
96, 97, 96, 97, 97, 96, 96, 96, 97, 97, 96, 99, 102, 101, 101, 101, 101, 101,
101, 100, 101, 100, 100, 101, 100, 100, 100, 102, 102, 103, 102, 102, 103, 102,
103, 103, 103, 103, 103, 102, 103, 102, 103, 110, 112, 111, 111, 111, 111, 111,
111, 110, 111, 111, 111, 111, 111, 111, 111, 115, 117, 116, 117, 117, 118, 117,
117, 117, 117, 117, 117, 117, 116, 117, 118, 119, 118, 119, 118, 120, 118, 120,
118, 120, 118, 120, 118, 119, 118, 119, 106, -27, -88, -75, -82, -77, -82, -77,
-81, -79, -79, -78, -80, -79, -80, -78, -79, -78, -77, -77, -77, -77, -77, -77,
-77, -76, -77, -77, -77, -77, -78, -77, -79, -87, -88, -88, -88, -88, -87, -87,
-88, -87, -88, -88, -87, -88, -87, -87, -88, -87, -88, -88, -88, -88, -87, -87,
-88, -88, -88, -86, -87, -88, -87, -87, -87, -86, -85, -85, -85, -86, -85, -85,
-85, -86, -85, -85, -85, -85, -86, -86, -85, -84, -86, -85, -85, -85, -86, -85,
-85, -86, -84, -85, -85, -84, -85, -85, -85, -84, -85, -85, -85, -85, -85, -84,
-85, -85, -85, -85, -85, -85, -84, -85, -84, -85, -85, -85, -85, -85, -84, -85,
-85, -84, -85, -84, -85, -85, -84, -84, -84, -84, -84, -85, -85, -85, -84, -84,
-85, -85, -84, -84, -84, -85, -84, -85, -83, -83, -82, -82, -82, -82, -82, -82,
-82, -82, -83, -82, -83, -83, -81, -81, -83, -82, -82, -82, -82, -82, -82, -82,
-82, -82, -81, -83, -82, -81, -82, -82, -81, -80, -80, -80, -80, -80, -80, -79,
-79, -79, -80, -79, -80, -79, -80, -80, -79, -78, -77, -78, -78, -78, -78, -77,
-77, -77, -78, -77, -77, -77, -77, -77, -77, -78, -77, -76, -78, -77, -77, -77,
-77, -77, -77, -77, -78, -77, -77, -78, -77, -77, -77, -77, -78, -77, -77, -77,
-77, -78, -77, -76, -77, -77, -77, -78, -75, -44, -31, -36, -34, -36, -34, -35,
-34, -34, -35, -35, -35, -33, -35, -34, -34, -33, -29, -30, -30, -30, -30, -30,
-30, -31, -29, -30, -30, -31, -29, -31, -16, };