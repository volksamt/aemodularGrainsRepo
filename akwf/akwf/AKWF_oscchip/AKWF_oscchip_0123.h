#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0123

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 2, 2, 1, 2, 3, 2, 3, 1, 3, 1, 2, 1,
2, 1, 5, 17, 21, 20, 21, 21, 20, 20, 20, 21, 20, 20, 20, 21, 21, 21, 20, 25, 27,
27, 26, 26, 27, 27, 27, 27, 27, 27, 27, 27, 27, 26, 28, 30, 31, 31, 31, 31, 31,
30, 31, 31, 31, 30, 30, 31, 31, 30, 32, 34, 35, 35, 35, 36, 35, 35, 35, 35, 34,
35, 35, 35, 34, 35, 36, 36, 37, 37, 37, 36, 37, 37, 37, 38, 36, 36, 37, 37, 37,
37, 37, 37, 40, 39, 38, 38, 39, 39, 39, 39, 39, 40, 39, 39, 38, 39, 39, 41, 42,
41, 41, 41, 41, 40, 41, 42, 41, 41, 41, 41, 41, 40, 41, 43, 44, 43, 43, 43, 42,
43, 43, 44, 42, 43, 43, 43, 43, 43, 44, 45, 45, 45, 45, 44, 46, 45, 45, 45, 45,
45, 44, 45, 46, 45, 45, 46, 47, 47, 47, 47, 47, 48, 48, 47, 47, 47, 48, 47, 47,
47, 49, 51, 51, 51, 51, 50, 52, 52, 51, 51, 51, 51, 51, 51, 51, 51, 52, 53, 54,
53, 53, 53, 54, 53, 53, 53, 54, 53, 53, 53, 53, 53, 54, 55, 56, 56, 55, 55, 56,
55, 55, 55, 55, 55, 55, 55, 55, 55, 55, 47, 43, 43, 43, 43, 43, 43, 43, 43, 43,
43, 43, 43, 44, 44, 50, 60, 59, 60, 60, 59, 60, 60, 60, 59, 60, 60, 59, 60, 60,
59, 60, 61, 62, 62, 61, 61, 60, 61, 61, 62, 61, 62, 61, 62, 60, 65, 27, -84,
-119, -110, -115, -112, -113, -112, -113, -112, -113, -113, -113, -113, -113,
-112, -112, -109, -108, -109, -109, -109, -109, -109, -108, -109, -108, -109,
-108, -108, -108, -109, -100, -92, -92, -92, -92, -92, -93, -92, -92, -92, -93,
-93, -92, -93, -92, -92, -86, -72, -71, -71, -72, -71, -71, -72, -72, -73, -72,
-72, -71, -72, -71, -72, -69, -61, -59, -59, -59, -59, -60, -60, -60, -60, -60,
-60, -59, -59, -59, -59, -59, -57, -55, -55, -55, -54, -56, -55, -55, -55, -55,
-55, -55, -55, -56, -55, -53, -51, -51, -51, -52, -52, -51, -51, -51, -51, -52,
-52, -51, -52, -51, -51, -47, -40, -39, -39, -39, -39, -39, -38, -39, -40, -39,
-39, -39, -39, -39, -40, -35, -24, -22, -23, -22, -23, -22, -23, -22, -22, -22,
-23, -22, -23, -23, -22, -21, -14, -10, -11, -11, -10, -10, -10, -10, -10, -11,
-10, -11, -10, -11, -10, -14, -18, -19, -19, -18, -18, -18, -18, -18, -19, -18,
-18, -18, -19, -18, -18, -16, -13, -12, -12, -12, -12, -12, -12, -13, -12, -13,
-12, -12, -12, -12, -13, -12, -9, -8, -8, -8, -8, -8, -9, -8, -9, -9, -8, -7,
-8, -8, -9, -7, -5, -3, -3, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -3, -4,
-2, -2, -2, -2, -2, -2, -1, -2, -2, -2, -2, -2, -1, -2, -2, 0, };