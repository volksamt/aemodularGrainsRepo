#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {60, 83, 73, 79, 75, 78, 75, 77, 75,
77, 76, 76, 76, 76, 75, 76, 76, 77, 77, 77, 76, 77, 76, 77, 77, 77, 76, 75, 77,
77, 75, 89, 115, 118, 118, 117, 117, 117, 118, 118, 117, 117, 118, 118, 117,
117, 117, 116, 115, 114, 114, 115, 113, 114, 114, 114, 113, 114, 113, 114, 114,
114, 114, 110, 104, 104, 104, 103, 103, 103, 104, 103, 103, 104, 103, 103, 103,
102, 103, 91, 74, 73, 73, 73, 72, 73, 73, 72, 74, 73, 73, 72, 73, 71, 74, 46,
14, 17, 16, 17, 16, 16, 16, 16, 16, 16, 16, 15, 16, 15, 16, 10, 5, 6, 6, 6, 6,
6, 6, 6, 5, 6, 6, 6, 6, 6, 6, 0, -5, -4, -4, -4, -4, -4, -5, -4, -5, -5, -5, -4,
-5, -5, -5, -10, -15, -14, -15, -14, -14, -14, -15, -15, -14, -14, -14, -14,
-15, -14, -15, -21, -25, -24, -24, -24, -24, -24, -24, -24, -24, -24, -25, -24,
-25, -24, -25, -27, -30, -29, -29, -29, -29, -28, -29, -28, -30, -29, -29, -29,
-30, -30, -29, -30, -30, -30, -30, -31, -30, -30, -31, -30, -31, -31, -30, -31,
-30, -30, -31, -30, -31, -30, -31, -30, -31, -31, -31, -30, -31, -30, -30, -31,
-30, -30, -30, -28, -22, -20, -21, -21, -21, -20, -21, -21, -20, -20, -20, -21,
-20, -20, -21, -16, -8, -6, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -5, -10,
11, 50, 54, 53, 53, 52, 53, 52, 53, 52, 54, 53, 53, 52, 54, 52, 59, 69, 70, 69,
70, 69, 70, 69, 69, 69, 69, 69, 69, 69, 69, 70, 75, 82, 83, 82, 83, 82, 83, 83,
82, 82, 83, 82, 82, 82, 83, 82, 84, 86, 86, 86, 86, 86, 85, 86, 85, 86, 85, 87,
84, 86, 84, 87, 20, -61, -58, -58, -58, -58, -58, -58, -58, -58, -58, -59, -58,
-57, -57, -58, -58, -58, -58, -57, -58, -58, -58, -57, -57, -58, -58, -58, -58,
-58, -57, -58, -59, -59, -59, -60, -59, -60, -60, -59, -60, -60, -59, -59, -59,
-59, -59, -59, -58, -57, -58, -58, -58, -58, -58, -57, -58, -57, -58, -57, -57,
-58, -58, -58, -57, -58, -57, -58, -57, -58, -57, -58, -57, -57, -57, -58, -58,
-58, -58, -56, -59, -59, -59, -59, -59, -58, -59, -58, -59, -59, -59, -58, -59,
-59, -59, -59, -59, -60, -60, -60, -60, -61, -60, -60, -60, -60, -60, -60, -60,
-60, -60, -60, -60, -60, -60, -60, -60, -60, -60, -60, -60, -60, -60, -60, -61,
-59, -60, -61, -60, -59, -59, -59, -60, -60, -59, -59, -60, -60, -60, -59, -59,
-60, -60, -60, -59, -59, -59, -60, -60, -60, -59, -59, -59, -59, -59, -59, -60,
-59, -59, -59, -60, -59, -58, -59, -59, -59, -59, -59, -59, -59, -58, -59, -59,
-59, -59, -59, -60, -60, -61, -60, -61, -60, -61, -60, -61, -60, -60, -59, -60,
-60, -60, -62, -16, };