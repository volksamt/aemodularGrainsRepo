#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0062

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 11, 10, 11, 10, 11, 11, 11, 11,
10, 11, 11, 10, 12, 25, 37, 38, 37, 36, 37, 37, 36, 37, 37, 37, 37, 38, 37, 37,
37, 44, 55, 56, 56, 55, 57, 55, 56, 56, 56, 56, 56, 57, 55, 55, 56, 59, 64, 66,
65, 64, 65, 66, 65, 66, 65, 65, 65, 65, 66, 65, 65, 66, 71, 72, 73, 72, 72, 72,
73, 72, 72, 73, 72, 72, 72, 72, 72, 75, 77, 79, 77, 78, 77, 77, 78, 77, 78, 78,
78, 78, 77, 78, 78, 79, 81, 82, 81, 81, 81, 81, 81, 81, 82, 81, 81, 81, 82, 81,
82, 81, 81, 81, 81, 81, 81, 81, 81, 81, 81, 82, 81, 81, 81, 81, 81, 81, 82, 81,
81, 81, 80, 81, 81, 81, 81, 81, 80, 81, 81, 81, 81, 81, 81, 80, 81, 80, 81, 81,
81, 80, 80, 81, 81, 81, 80, 80, 81, 80, 79, 79, 79, 78, 79, 78, 78, 78, 78, 78,
78, 78, 79, 77, 78, 77, 72, 70, 71, 71, 70, 71, 70, 71, 70, 71, 71, 71, 70, 70,
69, 64, 59, 59, 59, 58, 59, 59, 59, 59, 59, 59, 60, 59, 58, 59, 58, 47, 31, 28,
29, 29, 28, 28, 28, 29, 28, 29, 28, 29, 29, 28, 29, 23, 11, 6, 7, 7, 7, 8, 7, 8,
6, 7, 7, 8, 8, 7, 8, 2, -15, -28, -27, -27, -27, -27, -27, -27, -27, -27, -26,
-26, -28, -26, -28, -35, -43, -45, -44, -44, -44, -43, -44, -43, -43, -43, -43,
-44, -44, -43, -43, -51, -63, -65, -64, -65, -64, -64, -65, -65, -65, -64, -64,
-65, -65, -65, -63, -69, -78, -82, -81, -81, -81, -81, -82, -82, -81, -81, -82,
-82, -81, -81, -83, -90, -97, -96, -95, -96, -96, -96, -95, -96, -96, -97, -97,
-96, -96, -96, -96, -101, -107, -108, -106, -107, -107, -108, -108, -108, -107,
-108, -107, -108, -107, -107, -107, -109, -111, -111, -111, -111, -111, -110,
-111, -111, -110, -110, -111, -110, -110, -110, -112, -88, -12, 33, 27, 28, 28,
28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28,
28, 28, 27, 28, 28, 28, 27, 26, 26, 26, 26, 27, 25, 26, 26, 26, 26, 26, 27, 27,
26, 27, 25, 24, 24, 25, 24, 24, 25, 24, 24, 24, 23, 24, 25, 24, 24, 24, 24, 22,
23, 22, 22, 21, 22, 22, 21, 22, 22, 22, 23, 22, 23, 18, -44, -112, -116, -114,
-115, -114, -114, -114, -114, -115, -114, -115, -114, -114, -114, -114, -114,
-112, -111, -112, -112, -113, -112, -112, -113, -112, -111, -112, -111, -112,
-112, -112, -111, -107, -106, -106, -105, -106, -107, -106, -106, -106, -106,
-106, -106, -105, -106, -104, -96, -89, -89, -88, -89, -88, -89, -88, -89, -88,
-88, -88, -88, -88, -88, -87, -75, -60, -57, -58, -58, -59, -58, -58, -57, -58,
-58, -58, -58, -58, -57, -59, -38, -2, };