#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0119

const PROGMEM int8_t DATA[DATA_LENGTH] = {23, 112, 108, 110, 109, 108, 110, 107,
109, 108, 110, 108, 110, 108, 110, 108, 112, 116, 117, 116, 117, 116, 116, 117,
117, 117, 116, 116, 116, 115, 116, 116, 116, 117, 116, 116, 116, 117, 116, 117,
116, 116, 116, 116, 116, 117, 117, 116, 118, 119, 119, 119, 118, 118, 119, 119,
119, 119, 118, 118, 119, 118, 119, 119, 119, 118, 118, 119, 119, 118, 118, 118,
118, 119, 119, 119, 118, 118, 118, 119, 118, 119, 118, 119, 118, 119, 119, 119,
118, 118, 118, 118, 118, 118, 118, 118, 87, 59, 62, 61, 63, 62, 61, 61, 61, 62,
61, 61, 61, 62, 61, 62, 55, 43, 43, 43, 43, 43, 43, 43, 43, 44, 43, 44, 42, 43,
43, 43, 42, 36, 36, 35, 35, 35, 35, 36, 35, 35, 35, 36, 35, 36, 35, 35, 30, 25,
25, 26, 25, 25, 25, 24, 25, 25, 24, 25, 25, 24, 25, 26, 24, 23, 22, 23, 22, 22,
22, 22, 23, 22, 23, 23, 22, 22, 22, 22, 23, 22, 23, 22, 23, 23, 22, 22, 22, 22,
22, 23, 22, 22, 22, 22, 21, 20, 20, 19, 19, 19, 19, 20, 19, 20, 20, 21, 19, 19,
20, 19, 18, 15, 15, 15, 15, 15, 14, 15, 15, 15, 14, 14, 15, 15, 15, 14, 14, 15,
15, 14, 15, 15, 14, 15, 15, 15, 15, 15, 15, 14, 14, 14, 11, 9, 9, 9, 9, 9, 10,
9, 10, 9, 9, 10, 9, 9, 9, 10, 8, 5, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4,
-3, -6, -6, -6, -5, -7, -5, -6, -7, -5, -6, -7, -7, -6, -6, -6, -14, -20, -19,
-18, -19, -19, -19, -19, -19, -18, -19, -19, -19, -18, -19, -18, -22, -27, -27,
-27, -27, -27, -27, -26, -27, -26, -27, -27, -26, -26, -26, -27, -29, -32, -31,
-31, -32, -32, -31, -32, -32, -32, -31, -32, -33, -32, -32, -31, -37, -42, -42,
-42, -42, -42, -42, -42, -42, -42, -42, -41, -42, -42, -42, -42, -43, -48, -46,
-47, -47, -47, -46, -46, -47, -47, -47, -47, -46, -47, -46, -48, -54, -57, -57,
-57, -57, -57, -57, -57, -57, -57, -58, -57, -58, -57, -58, -56, -78, -98, -95,
-96, -96, -96, -95, -96, -96, -95, -95, -95, -96, -96, -95, -96, -95, -95, -95,
-95, -96, -96, -96, -96, -96, -96, -95, -96, -95, -96, -95, -95, -95, -95, -96,
-95, -95, -95, -96, -95, -95, -95, -95, -95, -95, -95, -94, -95, -93, -93, -92,
-93, -92, -93, -92, -92, -92, -93, -92, -92, -92, -92, -92, -92, -93, -93, -92,
-93, -92, -92, -92, -92, -92, -92, -92, -92, -92, -92, -92, -92, -93, -92, -92,
-92, -92, -93, -92, -92, -91, -91, -92, -92, -92, -92, -92, -92, -93, -95, -95,
-95, -94, -95, -94, -95, -94, -94, -95, -95, -94, -94, -94, -94, -95, -94, -95,
-93, -96, -94, -95, -93, -96, -93, -96, -92, -97, -90, -98, -78, };