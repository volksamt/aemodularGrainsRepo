#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0106

const PROGMEM int8_t DATA[DATA_LENGTH] = {21, 40, 37, 39, 38, 38, 37, 39, 38,
39, 38, 39, 38, 40, 37, 51, 77, 78, 78, 78, 78, 79, 79, 79, 78, 78, 77, 78, 78,
78, 78, 81, 93, 95, 94, 95, 94, 96, 94, 95, 95, 95, 95, 96, 95, 95, 94, 95, 95,
94, 95, 95, 95, 95, 95, 94, 95, 94, 95, 95, 95, 94, 97, 81, 49, 47, 48, 48, 49,
48, 49, 48, 48, 47, 48, 48, 48, 47, 49, 46, 37, 34, 35, 34, 36, 34, 35, 35, 34,
34, 35, 34, 35, 35, 35, 33, 10, -1, 2, 1, 2, 1, 1, 1, 2, 1, 1, 1, 1, 1, 2, -5,
-17, -18, -17, -16, -17, -17, -18, -16, -17, -18, -17, -17, -18, -16, -18, -16,
-10, -9, -9, -9, -8, -8, -9, -9, -8, -9, -9, -8, -9, -9, -8, -8, 0, 3, 3, 3, 3,
3, 3, 4, 4, 3, 4, 3, 2, 3, 2, 4, 6, 7, 7, 6, 6, 6, 6, 6, 5, 6, 6, 7, 6, 7, 5,
16, 59, 68, 65, 66, 65, 67, 65, 67, 66, 67, 66, 66, 66, 66, 66, 66, 67, 68, 68,
68, 68, 68, 68, 68, 67, 67, 67, 68, 68, 69, 66, 83, 117, 119, 118, 118, 118,
118, 119, 118, 119, 118, 118, 118, 118, 117, 120, 102, 23, 4, 10, 7, 8, 6, 9, 7,
8, 8, 8, 8, 8, 7, 8, 2, -3, -3, -2, -3, -3, -3, -2, -2, -3, -2, -3, -2, -2, -3,
-2, -8, -19, -19, -19, -19, -20, -19, -19, -19, -19, -19, -20, -20, -19, -20,
-19, -22, -34, -36, -35, -36, -36, -35, -35, -36, -36, -36, -36, -36, -36, -36,
-37, -32, -29, -29, -30, -29, -30, -29, -29, -29, -29, -30, -29, -29, -29, -29,
-28, -29, -29, -30, -28, -29, -28, -30, -28, -29, -29, -29, -29, -30, -29, -30,
-28, -38, -79, -87, -84, -87, -85, -87, -85, -86, -85, -85, -85, -86, -86, -86,
-86, -88, -89, -89, -89, -89, -89, -89, -89, -89, -89, -88, -89, -88, -90, -87,
-91, -70, -31, -29, -29, -28, -29, -30, -29, -29, -29, -29, -29, -28, -29, -29,
-28, -37, -72, -79, -77, -79, -78, -80, -79, -78, -78, -78, -78, -78, -79, -78,
-79, -70, -61, -62, -61, -62, -62, -61, -62, -61, -62, -61, -62, -61, -62, -61,
-64, -52, -30, -28, -28, -28, -28, -29, -29, -29, -28, -29, -28, -29, -29, -29,
-28, -31, -42, -46, -45, -46, -44, -44, -45, -45, -45, -45, -45, -45, -45, -45,
-45, -40, -34, -35, -34, -35, -35, -34, -34, -35, -35, -35, -34, -34, -34, -35,
-36, -33, -24, -24, -25, -25, -25, -25, -25, -25, -25, -26, -25, -24, -24, -25,
-25, -24, -16, -14, -15, -15, -14, -15, -15, -14, -16, -15, -15, -15, -15, -14,
-15, -8, -1, -3, -1, -2, -1, -1, -1, -2, -1, -1, 0, -2, -1, -1, -1, -9, -27,
-28, -28, -28, -28, -28, -28, -28, -29, -28, -28, -27, -29, -27, -29, -19, };