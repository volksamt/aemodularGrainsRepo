#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0146

const PROGMEM int8_t DATA[DATA_LENGTH] = {29, 52, 45, 48, 46, 48, 47, 47, 47,
47, 47, 48, 47, 47, 48, 48, 52, 54, 54, 53, 53, 53, 53, 54, 54, 54, 54, 53, 54,
54, 54, 54, 59, 62, 62, 62, 61, 62, 62, 62, 62, 63, 62, 62, 61, 61, 62, 66, 69,
71, 70, 71, 69, 70, 70, 69, 70, 70, 70, 70, 70, 70, 69, 74, 84, 85, 84, 85, 85,
84, 85, 85, 85, 84, 85, 85, 84, 84, 86, 74, 30, 11, 15, 14, 15, 14, 14, 14, 14,
14, 15, 14, 15, 14, 14, 18, 50, 70, 68, 68, 67, 68, 67, 68, 68, 68, 68, 69, 68,
67, 68, 68, 83, 98, 97, 98, 97, 97, 97, 98, 97, 96, 97, 97, 97, 97, 98, 100,
107, 108, 107, 107, 107, 108, 107, 107, 107, 108, 108, 108, 107, 108, 107, 108,
110, 110, 110, 110, 109, 109, 109, 109, 110, 110, 110, 110, 109, 109, 110, 109,
108, 108, 108, 107, 107, 108, 108, 106, 107, 108, 108, 108, 107, 108, 107, 107,
107, 107, 108, 107, 108, 108, 107, 107, 108, 107, 108, 107, 107, 107, 108, 108,
107, 107, 107, 107, 107, 107, 107, 107, 108, 108, 107, 107, 107, 108, 107, 108,
108, 107, 107, 108, 107, 107, 107, 107, 108, 107, 108, 107, 107, 108, 107, 107,
105, 103, 103, 103, 103, 103, 103, 104, 103, 103, 104, 103, 103, 103, 103, 103,
103, 103, 103, 104, 103, 104, 103, 103, 103, 103, 103, 103, 104, 103, 104, 103,
102, 102, 101, 101, 101, 101, 101, 101, 101, 102, 102, 102, 101, 101, 103, 94,
72, 65, 67, 65, 66, 66, 66, 65, 66, 65, 66, 66, 66, 66, 67, 59, 17, -7, -3, -5,
-3, -5, -4, -4, -4, -5, -4, -5, -5, -4, -4, -7, -49, -85, -82, -83, -83, -83,
-82, -82, -83, -82, -82, -82, -83, -83, -82, -94, -116, -118, -117, -118, -118,
-118, -117, -118, -117, -118, -118, -118, -118, -118, -118, -113, -101, -96,
-97, -97, -97, -98, -97, -97, -97, -96, -97, -97, -98, -97, -97, -98, -99, -99,
-99, -99, -99, -99, -99, -99, -99, -99, -99, -99, -100, -99, -99, -99, -99, -99,
-100, -99, -99, -98, -99, -100, -99, -99, -99, -98, -99, -99, -99, -98, -97,
-98, -97, -97, -96, -97, -98, -97, -97, -97, -97, -97, -97, -98, -97, -97, -95,
-95, -95, -95, -96, -95, -96, -95, -95, -95, -95, -94, -95, -95, -95, -96, -96,
-94, -95, -95, -95, -96, -95, -95, -94, -95, -95, -95, -95, -95, -95, -95, -96,
-97, -97, -98, -98, -96, -97, -97, -97, -97, -98, -97, -97, -97, -97, -98, -99,
-99, -99, -100, -99, -99, -99, -99, -99, -98, -99, -99, -99, -100, -100, -99,
-97, -96, -97, -96, -96, -97, -97, -98, -97, -97, -97, -97, -96, -97, -97, -97,
-97, -98, -96, -97, -97, -98, -97, -97, -96, -97, -97, -97, -97, -97, -97, -97,
-98, -100, -99, -99, -99, -99, -99, -99, -99, -99, -99, -98, -100, -98, -100,
-45, };