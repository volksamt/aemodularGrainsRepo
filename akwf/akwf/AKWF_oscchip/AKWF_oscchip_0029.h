#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0029

const PROGMEM int8_t DATA[DATA_LENGTH] = {83, 120, 107, 114, 109, 114, 110, 113,
111, 112, 111, 112, 111, 112, 112, 110, 109, 108, 109, 108, 109, 109, 109, 107,
109, 107, 108, 108, 109, 108, 109, 105, 98, 97, 98, 97, 98, 98, 98, 98, 97, 97,
97, 98, 96, 98, 98, 97, 93, 94, 94, 94, 94, 94, 94, 94, 93, 94, 95, 94, 94, 93,
94, 84, 67, 65, 66, 65, 65, 65, 65, 65, 66, 65, 66, 65, 66, 65, 66, 62, 58, 58,
58, 59, 59, 59, 58, 58, 58, 59, 58, 58, 58, 58, 59, 57, 55, 55, 55, 54, 55, 54,
55, 54, 55, 55, 55, 54, 55, 55, 55, 52, 50, 50, 49, 49, 49, 49, 50, 50, 50, 50,
49, 49, 49, 49, 49, 49, 45, 42, 43, 42, 43, 42, 42, 42, 43, 42, 43, 42, 42, 42,
43, 41, 40, 39, 39, 38, 39, 38, 39, 38, 39, 39, 38, 39, 39, 39, 38, 34, -3, -21,
-17, -18, -18, -18, -17, -18, -18, -18, -17, -18, -18, -17, -18, -13, 13, 24,
22, 23, 22, 23, 23, 22, 23, 23, 22, 22, 22, 23, 24, 21, 18, 15, 15, 15, 16, 16,
16, 16, 16, 15, 16, 16, 16, 15, 16, 14, 6, 3, 3, 3, 3, 4, 3, 4, 4, 3, 3, 3, 3,
3, 4, 2, -2, -3, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -1, -1, -3, -6, -6,
-5, -5, -6, -5, -5, -6, -6, -6, -5, -6, -5, -5, -5, -8, -12, -13, -13, -12, -13,
-12, -13, -13, -12, -12, -13, -13, -12, -13, -12, -15, -19, -20, -20, -20, -19,
-20, -20, -19, -19, -19, -19, -19, -19, -19, -19, -22, -26, -27, -26, -27, -27,
-27, -26, -26, -26, -27, -26, -27, -26, -27, -27, -28, -30, -30, -30, -30, -30,
-30, -30, -30, -30, -30, -31, -30, -30, -30, -29, -32, -33, -33, -34, -33, -34,
-34, -33, -33, -33, -33, -34, -33, -34, -34, -33, -34, -38, -37, -38, -37, -37,
-38, -37, -37, -37, -37, -37, -37, -37, -36, -37, -37, -37, -37, -37, -38, -37,
-37, -37, -37, -37, -36, -37, -37, -36, -36, -37, -37, -39, -41, -40, -40, -40,
-40, -40, -41, -40, -40, -39, -40, -40, -40, -40, -40, -41, -41, -42, -42, -42,
-42, -41, -42, -42, -42, -42, -42, -41, -42, -42, -42, -45, -46, -45, -46, -45,
-45, -45, -45, -45, -46, -46, -45, -45, -45, -45, -45, -47, -47, -47, -47, -47,
-47, -47, -47, -47, -47, -47, -47, -47, -47, -47, -47, -51, -53, -52, -53, -52,
-52, -52, -52, -52, -52, -52, -52, -52, -52, -53, -54, -62, -63, -63, -62, -62,
-62, -62, -63, -63, -62, -63, -63, -63, -62, -62, -66, -74, -75, -75, -75, -75,
-75, -75, -75, -76, -75, -75, -75, -74, -75, -74, -78, -86, -87, -87, -87, -86,
-87, -87, -87, -87, -87, -86, -87, -87, -87, -86, -89, -90, -92, -89, -91, -89,
-91, -90, -91, -90, -90, -90, -90, -90, -89, -93, -32, };