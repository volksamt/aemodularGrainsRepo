#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {20, 28, 26, 28, 26, 28, 26, 27, 27,
28, 26, 27, 27, 28, 26, 32, 53, 60, 57, 59, 58, 58, 58, 58, 59, 58, 58, 58, 58,
58, 58, 59, 61, 62, 62, 62, 62, 61, 62, 63, 62, 62, 62, 62, 62, 62, 61, 68, 84,
86, 85, 86, 85, 85, 85, 86, 85, 85, 85, 85, 84, 85, 85, 86, 89, 89, 89, 89, 89,
89, 89, 90, 89, 89, 90, 90, 88, 89, 89, 90, 92, 93, 93, 93, 93, 93, 92, 93, 93,
92, 93, 93, 93, 93, 92, 97, 104, 104, 105, 105, 103, 105, 104, 104, 104, 104,
104, 104, 104, 104, 103, 108, 116, 115, 116, 116, 115, 115, 115, 115, 115, 115,
115, 115, 116, 116, 115, 115, 118, 118, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 119, 119, 118, 118, 118, 119, 118, 118, 118, 118, 118, 119, 118,
118, 118, 118, 119, 117, 118, 118, 118, 117, 118, 118, 118, 118, 118, 117, 118,
118, 117, 117, 118, 118, 118, 118, 117, 118, 117, 117, 117, 118, 117, 117, 117,
117, 117, 117, 117, 116, 118, 117, 117, 117, 116, 117, 117, 117, 117, 116, 116,
116, 116, 116, 116, 116, 116, 116, 116, 117, 117, 116, 116, 116, 116, 116, 116,
116, 116, 117, 116, 116, 115, 113, 111, 112, 111, 112, 111, 112, 110, 113, 111,
113, 110, 113, 109, 117, 69, -77, -115, -107, -112, -107, -109, -108, -110,
-108, -110, -109, -110, -109, -109, -108, -109, -109, -109, -109, -109, -110,
-109, -109, -109, -110, -109, -109, -109, -109, -109, -109, -107, -106, -105,
-106, -105, -105, -105, -105, -104, -105, -105, -105, -106, -104, -105, -104,
-104, -104, -104, -104, -105, -105, -104, -104, -105, -103, -104, -104, -104,
-104, -104, -104, -103, -100, -100, -100, -100, -100, -100, -100, -100, -100,
-101, -99, -100, -99, -99, -100, -100, -99, -100, -100, -100, -99, -99, -100,
-99, -100, -99, -99, -100, -100, -99, -99, -100, -100, -99, -99, -100, -100,
-99, -99, -99, -99, -99, -99, -98, -99, -99, -100, -99, -100, -99, -100, -98,
-98, -99, -99, -98, -98, -98, -99, -98, -99, -98, -98, -98, -96, -95, -95, -95,
-95, -95, -94, -95, -93, -95, -95, -94, -94, -94, -93, -94, -93, -93, -94, -95,
-94, -94, -94, -94, -94, -93, -94, -94, -93, -93, -93, -94, -96, -98, -98, -97,
-97, -97, -98, -97, -97, -98, -97, -97, -97, -98, -97, -97, -94, -93, -94, -93,
-94, -93, -93, -93, -93, -93, -94, -92, -93, -93, -93, -92, -90, -89, -90, -89,
-89, -89, -88, -89, -89, -89, -88, -89, -89, -89, -89, -86, -76, -72, -73, -73,
-72, -73, -73, -73, -72, -72, -72, -73, -72, -72, -73, -68, -48, -44, -45, -44,
-45, -45, -45, -45, -45, -44, -45, -45, -45, -44, -45, -41, -34, -32, -33, -33,
-33, -32, -33, -32, -33, -32, -32, -32, -33, -32, -32, -27, -11, -8, -9, -9, -9,
-9, -9, -9, -8, -9, -9, -9, -8, -8, -8, 0, };