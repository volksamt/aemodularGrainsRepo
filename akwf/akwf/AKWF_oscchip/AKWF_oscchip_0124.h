#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0124

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 2, 2, 1, 1, 1, 2, 2, 3, 1, 2, 2,
2, 1, 10, 43, 59, 55, 57, 55, 56, 56, 56, 56, 57, 56, 56, 56, 56, 55, 60, 89,
110, 107, 109, 108, 109, 108, 109, 108, 108, 108, 108, 108, 109, 108, 108, 113,
119, 119, 119, 118, 119, 119, 119, 118, 118, 119, 119, 119, 118, 119, 119, 118,
119, 119, 119, 119, 119, 119, 118, 119, 119, 118, 119, 119, 119, 118, 117, 110,
108, 108, 108, 109, 108, 108, 108, 108, 108, 109, 109, 108, 108, 108, 107, 95,
89, 90, 90, 89, 89, 89, 90, 89, 89, 89, 89, 89, 89, 89, 89, 79, 70, 72, 71, 71,
71, 71, 71, 71, 70, 71, 70, 71, 72, 71, 67, 56, 53, 54, 54, 55, 54, 54, 54, 54,
53, 54, 54, 55, 54, 55, 53, 48, 45, 46, 46, 45, 45, 45, 46, 46, 45, 46, 46, 46,
46, 47, 45, 38, 35, 35, 35, 35, 35, 36, 35, 35, 35, 35, 36, 36, 36, 35, 35, 33,
31, 31, 31, 31, 32, 31, 31, 31, 31, 30, 31, 31, 31, 31, 30, 25, 25, 25, 25, 25,
25, 26, 25, 25, 25, 25, 25, 25, 25, 25, 24, 20, 19, 20, 18, 20, 18, 18, 19, 18,
19, 18, 19, 18, 18, 19, 19, 15, 14, 14, 14, 14, 15, 14, 15, 15, 15, 14, 14, 14,
15, 14, 15, 11, 8, 9, 9, 8, 8, 9, 8, 8, 8, 8, 9, 9, 8, 9, 6, 5, 4, 5, 4, 5, 4,
5, 4, 4, 4, 5, 3, 5, 3, 6, -18, -94, -120, -113, -115, -114, -115, -114, -115,
-114, -115, -114, -115, -114, -115, -114, -114, -111, -110, -111, -110, -111,
-110, -110, -111, -111, -110, -110, -110, -111, -110, -110, -109, -101, -94,
-94, -94, -93, -94, -94, -93, -93, -93, -93, -93, -94, -94, -94, -87, -74, -73,
-73, -72, -73, -73, -72, -73, -73, -73, -73, -73, -72, -72, -73, -70, -62, -60,
-61, -60, -60, -61, -60, -60, -60, -60, -60, -60, -61, -60, -61, -59, -57, -55,
-56, -57, -56, -57, -56, -56, -56, -56, -57, -57, -56, -56, -57, -56, -54, -52,
-52, -52, -52, -52, -53, -52, -52, -52, -52, -52, -52, -52, -52, -47, -41, -38,
-40, -40, -40, -39, -40, -40, -39, -39, -40, -40, -40, -39, -39, -35, -26, -22,
-23, -23, -23, -24, -23, -23, -23, -23, -23, -22, -22, -23, -23, -21, -14, -10,
-11, -11, -11, -11, -11, -10, -11, -10, -11, -10, -10, -11, -10, -11, -15, -19,
-18, -19, -19, -18, -19, -19, -19, -19, -19, -19, -19, -19, -19, -16, -12, -13,
-13, -13, -13, -13, -13, -12, -12, -12, -12, -12, -13, -12, -13, -11, -10, -8,
-9, -8, -8, -9, -8, -8, -8, -8, -9, -9, -8, -9, -9, -7, -5, -4, -5, -3, -4, -4,
-4, -4, -4, -5, -5, -4, -4, -4, -4, -4, -3, -2, -2, -2, -3, -2, -2, -3, -2, -2,
-2, -2, -2, -2, -2, 0, };