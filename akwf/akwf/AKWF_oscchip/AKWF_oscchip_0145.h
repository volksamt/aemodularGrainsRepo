#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0145

const PROGMEM int8_t DATA[DATA_LENGTH] = {43, 66, 59, 62, 61, 62, 60, 61, 60,
61, 61, 62, 60, 62, 61, 65, 79, 86, 84, 85, 85, 84, 85, 84, 84, 85, 85, 85, 85,
85, 85, 88, 91, 91, 91, 91, 91, 91, 90, 91, 90, 91, 90, 90, 90, 91, 90, 94, 98,
99, 99, 99, 98, 99, 98, 99, 99, 99, 98, 98, 99, 98, 98, 99, 98, 98, 99, 99, 98,
99, 98, 98, 99, 99, 99, 99, 98, 99, 99, 98, 96, 94, 95, 95, 94, 95, 94, 95, 95,
95, 94, 94, 94, 94, 95, 95, 97, 96, 97, 97, 96, 97, 97, 97, 97, 97, 96, 97, 97,
97, 97, 96, 94, 95, 95, 95, 95, 94, 95, 94, 95, 95, 95, 95, 95, 95, 95, 94, 95,
94, 95, 94, 94, 94, 94, 95, 94, 95, 95, 95, 94, 94, 94, 94, 93, 92, 93, 93, 93,
93, 93, 92, 93, 93, 93, 92, 93, 93, 93, 93, 93, 93, 93, 93, 93, 93, 93, 93, 92,
93, 93, 93, 93, 93, 92, 93, 93, 93, 93, 93, 92, 93, 93, 93, 92, 93, 93, 93, 93,
93, 93, 93, 93, 93, 93, 93, 92, 92, 93, 93, 93, 93, 93, 92, 92, 93, 93, 93, 93,
93, 92, 93, 93, 92, 93, 93, 93, 93, 93, 92, 93, 92, 92, 92, 92, 93, 92, 93, 93,
93, 93, 92, 92, 92, 93, 92, 93, 93, 93, 70, 41, 41, 41, 42, 41, 41, 41, 42, 42,
42, 41, 41, 40, 42, 41, 53, 78, 81, 81, 81, 81, 81, 81, 81, 81, 80, 80, 81, 81,
81, 81, 84, 96, 99, 98, 98, 99, 99, 99, 99, 99, 99, 99, 99, 98, 99, 99, 110,
119, 118, 119, 118, 118, 118, 118, 118, 118, 119, 119, 118, 119, 118, 118, 118,
118, 119, 119, 119, 118, 118, 119, 118, 118, 117, 119, 118, 119, 118, 119, 118,
119, 118, 118, 118, 118, 118, 118, 118, 119, 118, 118, 119, 119, 118, 119, 110,
80, 71, 74, 73, 73, 72, 73, 72, 74, 73, 72, 72, 73, 74, 65, -16, -72, -66, -68,
-67, -68, -67, -67, -67, -67, -66, -66, -67, -67, -68, -67, -83, -101, -100,
-101, -101, -101, -100, -100, -100, -101, -101, -101, -100, -101, -101, -101,
-103, -107, -109, -108, -108, -109, -108, -108, -108, -108, -108, -109, -109,
-108, -108, -108, -110, -112, -113, -113, -113, -113, -112, -112, -113, -112,
-112, -113, -113, -112, -113, -111, -111, -109, -109, -109, -108, -109, -109,
-108, -108, -108, -108, -109, -108, -109, -109, -108, -112, -115, -114, -115,
-114, -114, -115, -114, -114, -114, -114, -115, -115, -114, -114, -114, -115,
-115, -113, -114, -114, -115, -115, -114, -114, -115, -114, -114, -114, -114,
-114, -114, -114, -114, -115, -114, -114, -114, -115, -114, -115, -115, -114,
-115, -114, -114, -115, -114, -114, -114, -114, -114, -114, -115, -115, -114,
-114, -114, -114, -114, -114, -114, -114, -114, -93, -72, -73, -73, -73, -72,
-74, -73, -73, -73, -74, -73, -73, -74, -73, -73, -25, };