#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0157

const PROGMEM int8_t DATA[DATA_LENGTH] = {78, 120, 107, 114, 108, 113, 109, 112,
109, 111, 110, 111, 110, 110, 111, 108, 98, 94, 94, 93, 94, 94, 95, 94, 94, 94,
94, 94, 94, 95, 93, 84, 75, 75, 76, 75, 75, 75, 76, 75, 76, 76, 76, 76, 75, 75,
76, 71, 65, 64, 65, 64, 65, 65, 64, 64, 65, 65, 65, 65, 65, 65, 64, 62, 60, 59,
60, 59, 59, 59, 60, 59, 59, 59, 59, 60, 59, 59, 59, 59, 55, 55, 55, 55, 56, 55,
55, 55, 55, 55, 56, 55, 55, 55, 56, 53, 54, 53, 54, 54, 53, 54, 53, 53, 53, 54,
53, 54, 53, 53, 53, 55, 57, 56, 57, 57, 57, 57, 57, 57, 57, 57, 57, 58, 58, 57,
57, 59, 64, 65, 65, 65, 64, 64, 64, 65, 64, 65, 65, 64, 65, 65, 64, 67, 74, 76,
75, 76, 76, 75, 76, 76, 75, 76, 75, 76, 75, 75, 76, 78, 79, 79, 80, 79, 80, 79,
80, 80, 79, 79, 79, 79, 79, 79, 80, 84, 90, 91, 90, 90, 90, 90, 91, 91, 90, 91,
90, 90, 90, 91, 90, 92, 95, 96, 96, 96, 96, 96, 96, 96, 96, 97, 96, 96, 97, 96,
96, 98, 103, 105, 105, 105, 105, 105, 104, 105, 105, 106, 105, 105, 105, 106,
105, 110, 113, 112, 113, 112, 112, 111, 113, 113, 113, 112, 112, 112, 114, 112,
112, 58, -10, -10, -9, -9, -8, -9, -9, -9, -9, -10, -9, -9, -9, -9, -9, -11,
-12, -14, -13, -13, -12, -13, -12, -13, -13, -12, -12, -13, -12, -14, -13, -15,
-26, -28, -27, -28, -27, -28, -28, -28, -27, -27, -28, -27, -28, -27, -27, -34,
-39, -38, -39, -39, -39, -39, -39, -39, -39, -38, -39, -39, -40, -39, -39, -45,
-53, -53, -54, -54, -54, -53, -54, -53, -54, -53, -53, -54, -54, -54, -54, -59,
-70, -73, -72, -72, -72, -72, -73, -72, -72, -72, -72, -71, -71, -72, -72, -74,
-82, -85, -85, -85, -85, -85, -85, -85, -85, -85, -85, -85, -85, -84, -86, -98,
-106, -105, -105, -105, -106, -106, -105, -105, -105, -104, -105, -105, -105,
-106, -105, -106, -107, -107, -107, -106, -106, -106, -107, -107, -107, -107,
-106, -107, -107, -107, -107, -107, -107, -106, -107, -107, -106, -107, -106,
-106, -107, -107, -107, -107, -107, -106, -107, -109, -117, -118, -118, -118,
-118, -119, -118, -118, -119, -118, -119, -119, -118, -118, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -117, -117, -117, -118, -117, -119, -118,
-119, -118, -118, -118, -117, -119, -118, -118, -118, -118, -119, -118, -118,
-117, -118, -118, -118, -119, -119, -118, -118, -118, -119, -118, -119, -118,
-118, -117, -118, -118, -118, -118, -119, -118, -119, -118, -118, -119, -118,
-118, -118, -118, -118, -117, -118, -118, -118, -118, -118, -118, -118, -117,
-118, -117, -118, -118, -118, -118, -118, -118, -117, -117, -117, -118, -118,
-118, -117, -118, -118, -119, -118, -119, -117, -119, -117, -118, -117, -118,
-119, -118, -118, -39, };