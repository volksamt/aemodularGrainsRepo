#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0069

const PROGMEM int8_t DATA[DATA_LENGTH] = {19, 103, 118, 113, 117, 113, 116, 113,
115, 114, 116, 113, 116, 114, 115, 115, 114, 113, 113, 113, 112, 114, 112, 114,
112, 114, 111, 115, 110, 115, 108, 120, 41, -92, -94, -94, -94, -94, -95, -94,
-95, -94, -94, -93, -95, -93, -95, -94, -95, -94, -94, -94, -94, -95, -94, -94,
-95, -94, -94, -94, -94, -95, -94, -94, -87, -20, 9, 3, 7, 4, 6, 4, 6, 6, 5, 5,
6, 6, 5, 6, 6, 6, 5, 5, 5, 5, 6, 6, 6, 6, 5, 5, 5, 6, 6, 5, 6, 5, 5, 6, 6, 6, 5,
5, 6, 6, 5, 6, 5, 6, 5, 6, 5, 6, 5, 5, 6, 6, 5, 6, 6, 6, 5, 5, 5, 5, 6, 5, 4, 4,
4, 4, 3, 4, 4, 3, 3, 3, 3, 3, 3, 3, 3, 4, 2, -3, -5, -4, -5, -4, -4, -4, -5, -4,
-5, -5, -3, -4, -5, -5, -4, -4, -4, -4, -4, -4, -4, -5, -4, -4, -5, -5, -4, -5,
-5, -3, -3, -3, -2, -2, -2, -2, -2, -1, -2, -2, -2, -3, -3, -2, -2, -2, -2, -2,
-2, -2, -2, -2, -3, -2, -2, -2, -2, -3, -1, -2, -2, -2, -3, -3, -2, -3, -2, -2,
-2, -3, -2, -2, -3, -2, -2, -2, -2, -2, -2, -3, -3, -3, -3, -3, -2, -3, -3, -2,
-2, -2, -2, -2, -2, -2, -2, -2, -3, -3, -2, -2, -2, -2, -2, -2, -3, -3, -2, -2,
-2, -2, 1, 4, 4, 4, 4, 3, 4, 4, 4, 3, 3, 4, 3, 4, 4, 4, 1, -2, -2, -2, -2, -2,
-1, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -1, -3, -2, -3, -2, -2, -2, -3, -2,
-3, -2, -3, -2, -2, -3, -2, -2, -3, -1, -2, -2, -3, -2, -2, -2, -2, -3, -2, -3,
-2, -2, -2, -3, -1, -3, -2, -3, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2,
-3, -3, -2, -2, -2, -3, -2, -2, -3, -2, -2, -2, -2, -2, -3, -4, -4, -4, -4, -4,
-4, -5, -4, -4, -4, -5, -4, -4, -4, -4, -4, -4, -5, -5, -5, -5, -4, -4, -5, -4,
-4, -4, -4, -5, -5, -4, -4, -4, -4, -5, -4, -5, -5, -4, -4, -4, -4, -4, -4, -4,
-4, -4, -4, -4, -5, -5, -4, -4, -4, -5, -5, -5, -4, -5, -5, -4, -5, -4, -4, -5,
-5, -5, -4, -4, -4, -4, -3, -4, -3, -4, -4, -4, -4, -5, -3, 1, 1, 2, 1, 1, 2, 2,
1, 1, 1, 2, 1, 2, 2, 2, -1, -5, -4, -5, -4, -4, -4, -5, -4, -4, -5, -4, -4, -4,
-5, -4, -4, -3, -2, -3, -2, -3, -3, -2, -2, -2, -2, -2, -2, -1, -2, -2, -4, -5,
-4, -4, -3, -5, -4, -4, -4, -4, -4, -3, -4, -5, -4, -4, -4, -4, -4, -5, -5, -4,
-4, -4, -5, -4, -5, -4, -4, -4, -4, -5, };