#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0141

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 11, 9, 10, 10, 10, 10, 10, 10, 10,
10, 10, 10, 11, 10, 13, 26, 32, 31, 32, 32, 31, 32, 31, 32, 31, 31, 32, 31, 32,
32, 37, 42, 41, 41, 42, 42, 42, 42, 42, 42, 42, 42, 41, 42, 42, 42, 49, 62, 63,
63, 63, 62, 63, 63, 63, 62, 63, 63, 63, 62, 63, 62, 67, 76, 78, 77, 77, 77, 77,
77, 77, 77, 77, 77, 77, 77, 77, 76, 80, 89, 93, 92, 91, 92, 92, 93, 92, 92, 91,
92, 92, 92, 92, 93, 99, 106, 107, 106, 106, 107, 107, 106, 106, 106, 106, 106,
107, 106, 106, 106, 102, 96, 96, 96, 95, 96, 97, 96, 96, 95, 96, 97, 96, 96, 96,
97, 86, 66, 61, 62, 62, 62, 62, 63, 62, 63, 62, 63, 62, 62, 63, 63, 59, 45, 41,
42, 41, 41, 42, 42, 42, 41, 42, 42, 42, 41, 42, 40, 19, 1, 2, 1, 1, 2, 3, 2, 1,
2, 2, 2, 2, 2, 2, 2, -9, -22, -23, -22, -22, -24, -22, -23, -23, -23, -23, -22,
-24, -23, -23, -23, -34, -56, -60, -58, -59, -59, -58, -59, -59, -58, -58, -59,
-58, -58, -59, -59, -61, -72, -75, -75, -76, -75, -75, -75, -76, -75, -75, -76,
-76, -75, -76, -75, -75, -75, -75, -75, -74, -75, -76, -75, -75, -75, -74, -76,
-74, -75, -75, -75, -68, -58, -59, -58, -58, -59, -58, -58, -58, -59, -58, -59,
-58, -58, -58, -59, -52, -41, -40, -40, -40, -39, -40, -39, -40, -39, -39, -40,
-40, -40, -40, -40, -36, -22, -18, -20, -18, -19, -19, -18, -19, -18, -19, -20,
-18, -18, -18, -18, -12, -8, -8, -8, -9, -8, -8, -9, -8, -8, -8, -8, -8, -8, -9,
-9, -6, -4, -4, -4, -4, -4, -4, -5, -4, -4, -4, -5, -4, -3, -4, -4, -10, -17,
-18, -19, -19, -18, -19, -19, -19, -19, -19, -19, -18, -19, -19, -18, -25, -45,
-51, -50, -51, -50, -50, -50, -50, -51, -50, -49, -50, -50, -50, -51, -58, -63,
-62, -63, -62, -62, -62, -62, -62, -63, -63, -63, -62, -63, -63, -63, -70, -78,
-77, -77, -77, -77, -77, -77, -77, -76, -77, -77, -77, -76, -78, -77, -81, -87,
-88, -88, -88, -88, -87, -87, -88, -88, -88, -88, -88, -87, -88, -87, -93, -111,
-116, -114, -115, -115, -115, -115, -114, -115, -115, -114, -115, -114, -114,
-115, -117, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -120, -117, -115, -116, -115, -114, -115, -114, -115, -115,
-115, -115, -115, -115, -115, -115, -115, -108, -99, -97, -98, -98, -98, -97,
-98, -97, -98, -98, -98, -98, -99, -98, -99, -91, -73, -67, -69, -69, -68, -68,
-69, -69, -70, -69, -69, -69, -69, -69, -68, -57, -52, -52, -52, -52, -53, -52,
-53, -52, -52, -52, -53, -51, -52, -52, -52, -32, -14, -15, -14, -15, -15, -14,
-15, -14, -14, -16, -14, -14, -15, -15, -15, -6, };