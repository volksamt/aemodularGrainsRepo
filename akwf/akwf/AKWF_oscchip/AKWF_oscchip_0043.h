#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0043

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 4, 5, 4, 5, 5, 5, 5, 5, 5, 5, 5,
5, 5, 7, 11, 11, 12, 12, 12, 11, 12, 12, 12, 11, 12, 11, 11, 12, 12, 14, 20, 24,
24, 23, 23, 23, 24, 24, 25, 24, 23, 24, 24, 23, 24, 26, 29, 29, 28, 28, 28, 28,
30, 28, 29, 29, 29, 28, 29, 28, 29, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 31,
31, 31, 30, 30, 29, 30, 31, 30, 31, 30, 31, 30, 29, 30, 30, 30, 31, 30, 30, 30,
30, 31, 32, 32, 31, 32, 32, 32, 32, 32, 32, 32, 32, 32, 32, 31, 31, 34, 37, 37,
37, 37, 37, 37, 37, 38, 37, 37, 36, 37, 37, 37, 37, 38, 39, 39, 38, 39, 39, 38,
38, 39, 39, 39, 38, 39, 38, 38, 39, 39, 43, 44, 44, 44, 43, 44, 43, 44, 43, 43,
43, 43, 44, 44, 43, 44, 45, 46, 47, 47, 47, 46, 46, 47, 47, 47, 47, 46, 47, 47,
47, 78, 113, 119, 116, 117, 116, 117, 117, 117, 117, 117, 116, 117, 117, 117,
116, 116, 117, 117, 116, 117, 116, 116, 116, 117, 117, 116, 116, 116, 117, 117,
117, 116, 116, 116, 116, 117, 116, 116, 116, 116, 117, 116, 116, 117, 116, 117,
116, 117, 117, 116, 115, 117, 117, 116, 116, 116, 116, 117, 116, 116, 116, 116,
116, 32, -84, -105, -98, -100, -99, -98, -99, -98, -98, -99, -99, -99, -99, -99,
-99, -100, -99, -100, -99, -100, -99, -99, -100, -99, -99, -99, -99, -99, -99,
-99, -99, -99, -100, -100, -98, -99, -99, -100, -99, -100, -99, -100, -99, -99,
-99, -100, -99, -100, -99, -99, -99, -99, -99, -99, -99, -99, -99, -99, -99,
-98, -99, -99, -99, -98, -99, -99, -98, -99, -99, -99, -99, -99, -99, -98, -99,
-99, -99, -99, -99, -99, -98, -99, -99, -99, -98, -99, -98, -98, -99, -98, -99,
-98, -98, -98, -98, -98, -98, -99, -98, -99, -98, -98, -98, -99, -98, -98, -98,
-98, -99, -99, -98, -99, -98, -98, -98, -98, -98, -99, -99, -97, -98, -98, -98,
-98, -99, -98, -101, -45, 59, 94, 85, 87, 86, 86, 86, 86, 86, 86, 86, 86, 86,
85, 87, 82, 72, 65, 65, 65, 65, 65, 66, 66, 66, 65, 66, 65, 66, 65, 65, 58, 53,
52, 52, 52, 53, 52, 52, 52, 53, 52, 52, 51, 52, 52, 52, 47, 40, 38, 39, 39, 38,
39, 38, 38, 38, 39, 39, 39, 39, 39, 39, 33, 20, 14, 15, 15, 15, 14, 15, 15, 15,
15, 15, 14, 15, 15, 16, 12, -5, -16, -15, -16, -15, -15, -15, -16, -15, -16,
-15, -15, -15, -15, -17, -32, -49, -50, -49, -50, -50, -49, -49, -50, -49, -49,
-50, -49, -50, -49, -50, -65, -93, -100, -97, -98, -98, -98, -98, -99, -98, -98,
-98, -99, -97, -98, -98, -98, -99, -98, -99, -98, -99, -98, -99, -98, -98, -98,
-98, -98, -98, -100, -91, -38, };