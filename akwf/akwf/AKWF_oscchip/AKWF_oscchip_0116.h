#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0116

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 8, 7, 7, 7, 8, 7, 8, 7, 7, 7, 7, 8,
8, 8, 8, 10, 16, 14, 15, 15, 15, 15, 15, 15, 15, 15, 16, 16, 15, 16, 15, 17, 24,
24, 23, 25, 23, 24, 24, 24, 24, 25, 23, 25, 23, 25, 22, 55, 86, 82, 84, 83, 83,
83, 83, 83, 84, 84, 84, 84, 84, 83, 83, 83, 84, 84, 84, 83, 83, 83, 82, 83, 83,
83, 83, 83, 83, 84, 83, 83, 83, 83, 83, 83, 84, 84, 84, 83, 83, 83, 83, 83, 83,
83, 83, 83, 83, 83, 82, 83, 83, 83, 84, 83, 83, 83, 83, 83, 82, 83, 83, 83, 82,
83, 84, 82, 83, 83, 83, 82, 83, 84, 83, 82, 83, 83, 83, 83, 83, 82, 83, 82, 82,
83, 83, 83, 83, 83, 82, 83, 82, 83, 83, 82, 83, 82, 82, 83, 83, 82, 83, 82, 83,
83, 83, 82, 82, 82, 83, 83, 83, 83, 83, 83, 82, 83, 83, 82, 83, 83, 82, 83, 82,
83, 83, 82, 82, 82, 83, 82, 81, 82, 83, 82, 82, 82, 83, 82, 82, 81, 82, 82, 82,
81, 83, 81, 83, 82, 82, 81, 83, 80, 83, 81, 84, 79, 88, 45, -94, -120, -111,
-115, -113, -115, -114, -115, -113, -115, -114, -115, -113, -114, -114, -115,
-114, -114, -114, -113, -114, -113, -114, -114, -115, -114, -115, -112, -115,
-112, -117, -90, -42, -40, -41, -40, -40, -40, -40, -40, -41, -40, -40, -40,
-40, -40, -40, -39, -39, -38, -39, -38, -38, -39, -39, -39, -38, -38, -39, -39,
-39, -38, -37, -38, -38, -39, -38, -39, -38, -39, -38, -39, -38, -38, -37, -38,
-38, -39, -37, -39, -41, -41, -42, -42, -42, -41, -42, -41, -42, -41, -41, -41,
-41, -42, -42, -41, -39, -38, -39, -38, -38, -38, -38, -38, -38, -38, -38, -38,
-39, -39, -39, -40, -41, -41, -42, -41, -42, -41, -42, -41, -41, -41, -42, -42,
-41, -42, -41, -42, -41, -41, -41, -41, -42, -42, -41, -41, -42, -42, -41, -41,
-41, -42, -41, -41, -38, -37, -38, -38, -38, -38, -38, -38, -38, -38, -37, -38,
-37, -37, -38, -39, -43, -42, -42, -43, -42, -42, -42, -42, -43, -42, -42, -42,
-42, -42, -43, -43, -42, -43, -43, -42, -43, -42, -43, -42, -43, -42, -43, -42,
-42, -43, -42, -43, -42, -43, -43, -42, -42, -42, -42, -41, -43, -43, -43, -42,
-42, -43, -43, -43, -43, -42, -43, -42, -42, -42, -43, -42, -42, -42, -42, -43,
-42, -41, -42, -43, -42, -42, -41, -43, -42, -42, -43, -43, -42, -41, -42, -42,
-42, -43, -41, -42, -42, -42, -41, -42, -42, -43, -42, -42, -42, -42, -42, -42,
-42, -41, -41, -41, -40, -40, -40, -41, -41, -41, -41, -40, -40, -40, -41, -40,
-40, -40, -40, -40, -39, -38, -38, -39, -39, -39, -39, -39, -39, -38, -39, -38,
-40, -37, -40, -23, 1, -1, 0, 0, -1, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, };