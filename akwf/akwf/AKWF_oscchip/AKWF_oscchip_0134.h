#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0134

const PROGMEM int8_t DATA[DATA_LENGTH] = {15, 13, 13, 14, 13, 14, 13, 14, 12,
13, 13, 14, 13, 13, 18, 53, 72, 70, 71, 70, 71, 71, 70, 71, 71, 71, 71, 71, 71,
71, 71, 51, 33, 34, 34, 33, 33, 34, 34, 35, 34, 34, 34, 35, 35, 34, 34, 36, 39,
40, 39, 40, 40, 39, 40, 39, 39, 38, 39, 39, 39, 40, 36, 27, 22, 24, 23, 23, 22,
24, 24, 24, 23, 23, 23, 23, 24, 23, 22, 13, 8, 8, 7, 8, 8, 7, 8, 8, 8, 8, 8, 8,
8, 8, 9, 20, 32, 31, 31, 31, 32, 31, 31, 31, 30, 31, 31, 31, 31, 31, 31, 31, 32,
32, 31, 31, 31, 31, 31, 32, 31, 31, 31, 32, 32, 31, 31, 31, 31, 31, 31, 31, 31,
31, 31, 31, 31, 32, 31, 31, 31, 31, 31, 27, 26, 26, 26, 26, 26, 26, 26, 26, 26,
25, 26, 26, 26, 26, 25, 16, 10, 10, 10, 10, 10, 10, 10, 11, 11, 10, 10, 9, 10,
9, 10, 3, -6, -5, -5, -6, -6, -6, -6, -6, -5, -6, -6, -5, -6, -5, -11, -29, -32,
-31, -32, -31, -32, -32, -32, -32, -32, -32, -32, -32, -32, -32, -30, -22, -18,
-19, -18, -20, -18, -19, -19, -19, -19, -19, -19, -19, -18, -18, -20, -36, -49,
-48, -47, -47, -47, -47, -47, -47, -47, -48, -48, -47, -48, -47, -48, -48, -49,
-49, -50, -50, -50, -51, -51, -50, -50, -49, -49, -50, -50, -50, -50, -50, -50,
-50, -50, -50, -51, -50, -50, -49, -50, -50, -49, -50, -50, -50, -47, -35, -28,
-29, -30, -29, -29, -29, -29, -29, -29, -28, -29, -29, -29, -29, -29, -40, -47,
-47, -47, -47, -47, -47, -47, -46, -47, -47, -46, -47, -48, -47, -47, -19, 14,
13, 13, 14, 13, 13, 13, 14, 13, 13, 13, 13, 14, 12, 20, 41, 45, 44, 45, 44, 44,
45, 44, 44, 44, 44, 45, 44, 44, 44, 46, 57, 61, 59, 60, 60, 60, 61, 61, 60, 60,
60, 61, 60, 60, 60, 59, 44, 33, 34, 34, 34, 34, 33, 34, 34, 34, 34, 34, 33, 34,
34, 34, 15, -3, -3, -3, -2, -3, -2, -3, -3, -3, -2, -3, -2, -3, -2, -10, -27,
-30, -29, -29, -29, -29, -30, -29, -28, -29, -29, -28, -29, -29, -29, -26, -13,
-6, -8, -9, -8, -8, -8, -8, -8, -8, -9, -8, -8, -9, -8, -5, 16, 30, 28, 29, 29,
28, 29, 29, 29, 28, 28, 29, 28, 28, 28, 27, -32, -94, -92, -91, -92, -92, -92,
-92, -92, -91, -92, -91, -92, -91, -94, -58, 19, 35, 30, 32, 30, 32, 30, 32, 31,
32, 30, 31, 32, 31, 32, 28, 10, 4, 5, 5, 5, 4, 5, 5, 6, 5, 5, 5, 5, 5, 5, 5, -3,
-9, -7, -8, -8, -8, -8, -8, -8, -9, -8, -8, -8, -8, -8, -10, -64, -117, -115,
-115, -116, -114, -115, -114, -115, -114, -116, -114, -117, -114, -118, -76, -2,
};