#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0048

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 1, 1, 1, 1, 2, 2, 1, 2, 2, 2, 1,
1, 2, 2, 3, 4, 3, 4, 3, 3, 4, 3, 3, 4, 3, 4, 5, 4, 4, 5, 5, 5, 6, 5, 6, 6, 6, 6,
5, 5, 6, 6, 6, 6, 6, 8, 10, 10, 9, 10, 10, 11, 9, 10, 9, 10, 10, 10, 10, 10, 10,
11, 13, 15, 15, 15, 15, 14, 15, 14, 15, 15, 14, 14, 14, 13, 14, 14, 16, 15, 16,
16, 16, 17, 16, 17, 17, 16, 16, 16, 16, 17, 16, 19, 21, 20, 20, 20, 21, 21, 21,
20, 20, 21, 21, 20, 20, 20, 20, 21, 22, 23, 22, 23, 23, 22, 22, 23, 22, 22, 23,
22, 22, 22, 22, 23, 26, 27, 26, 26, 26, 27, 27, 27, 27, 26, 26, 26, 27, 26, 26,
27, 29, 31, 31, 30, 31, 31, 31, 30, 30, 31, 31, 31, 31, 30, 31, 31, 32, 33, 33,
32, 32, 32, 32, 32, 33, 33, 32, 32, 33, 33, 33, 34, 36, 36, 36, 37, 37, 37, 36,
36, 36, 36, 37, 37, 37, 36, 37, 36, 38, 39, 39, 38, 39, 38, 39, 38, 39, 38, 39,
39, 38, 39, 38, 40, 42, 42, 43, 43, 43, 43, 42, 43, 42, 42, 43, 42, 43, 43, 43,
43, 45, 44, 44, 45, 44, 45, 45, 44, 44, 45, 44, 45, 44, 44, 45, 45, 48, 48, 48,
49, 49, 49, 48, 49, 49, 49, 48, 48, 48, 48, 48, 49, 49, 50, 50, 50, 50, 50, 51,
50, 50, 50, 50, 50, 50, 50, 50, 53, 54, 55, 54, 54, 54, 54, 55, 54, 54, 54, 54,
55, 55, 54, 55, 55, 58, 59, 59, 59, 58, 59, 58, 58, 58, 58, 58, 58, 58, 57, 62,
27, -70, -121, -112, -114, -113, -114, -113, -113, -113, -113, -114, -112, -114,
-113, -112, -105, -101, -100, -101, -101, -100, -100, -101, -100, -100, -100,
-100, -100, -100, -100, -100, -93, -85, -84, -84, -84, -84, -84, -83, -84, -83,
-83, -83, -83, -83, -83, -83, -79, -69, -66, -67, -66, -67, -67, -67, -67, -66,
-66, -67, -66, -66, -66, -66, -63, -51, -45, -45, -45, -45, -45, -46, -45, -45,
-45, -45, -45, -45, -46, -45, -42, -39, -39, -39, -39, -39, -38, -40, -40, -39,
-39, -38, -39, -39, -39, -39, -34, -29, -28, -28, -28, -28, -29, -29, -28, -28,
-27, -28, -28, -27, -27, -28, -27, -24, -22, -22, -22, -22, -22, -21, -22, -22,
-22, -21, -22, -21, -22, -22, -21, -21, -19, -20, -19, -19, -19, -20, -20, -20,
-20, -20, -19, -20, -20, -20, -18, -16, -16, -15, -16, -15, -15, -15, -16, -16,
-15, -15, -15, -15, -16, -15, -15, -14, -13, -13, -14, -13, -13, -13, -13, -14,
-13, -14, -13, -13, -13, -13, -12, -10, -9, -9, -9, -8, -8, -9, -8, -9, -9, -8,
-9, -9, -8, -9, -7, -5, -5, -5, -5, -4, -4, -5, -5, -4, -4, -4, -5, -5, -4, -4,
-2, };