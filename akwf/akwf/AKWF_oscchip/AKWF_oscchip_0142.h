#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0142

const PROGMEM int8_t DATA[DATA_LENGTH] = {79, 120, 106, 113, 109, 112, 109, 112,
110, 112, 110, 111, 111, 111, 110, 110, 111, 111, 111, 110, 112, 110, 111, 111,
111, 111, 111, 110, 110, 111, 111, 110, 111, 110, 111, 111, 111, 111, 111, 110,
111, 110, 111, 111, 110, 110, 111, 110, 111, 112, 111, 111, 111, 110, 111, 110,
110, 111, 110, 111, 111, 110, 111, 110, 110, 111, 111, 111, 112, 111, 111, 111,
110, 111, 110, 111, 111, 111, 110, 111, 110, 111, 111, 110, 111, 110, 110, 110,
111, 111, 111, 111, 111, 111, 110, 100, 91, 91, 90, 90, 92, 91, 91, 91, 91, 91,
91, 91, 91, 91, 92, 66, 29, 27, 29, 29, 28, 29, 29, 29, 28, 28, 29, 29, 28, 28,
29, 24, 12, 10, 11, 11, 10, 11, 11, 10, 11, 11, 10, 11, 10, 11, 10, 3, -1, 0, 0,
1, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, -1, -24, -45, -42, -43, -43, -43, -43, -43,
-43, -43, -44, -43, -43, -43, -44, -43, -68, -101, -102, -101, -102, -102, -102,
-102, -102, -102, -101, -101, -102, -102, -102, -101, -102, -102, -102, -102,
-102, -102, -102, -102, -102, -102, -102, -102, -102, -102, -101, -102, -102,
-102, -102, -102, -102, -101, -102, -102, -102, -102, -102, -102, -101, -102,
-102, -102, -97, -95, -96, -95, -95, -95, -95, -95, -94, -95, -94, -95, -95,
-95, -94, -95, -94, -94, -95, -95, -94, -94, -95, -95, -94, -94, -95, -94, -95,
-94, -94, -94, -94, -94, -94, -95, -95, -94, -95, -95, -94, -94, -95, -95, -95,
-94, -96, -83, -23, 6, 0, 2, 1, 2, 2, 2, 2, 1, 1, 1, 2, 1, 1, 1, 1, 2, 2, 1, 1,
2, 2, 2, 1, 2, 1, 2, 2, 2, 2, 2, -1, -3, -3, -4, -3, -4, -4, -4, -3, -3, -3, -3,
-4, -4, -4, -4, -3, -3, -3, -4, -4, -3, -4, -4, -4, -4, -3, -3, -4, -4, -4, -4,
-3, -1, -2, -2, -2, -2, -1, -2, -2, -2, -2, -1, -1, -2, -2, -2, -3, -4, -4, -3,
-3, -4, -3, -4, -3, -3, -4, -4, -3, -4, -4, -4, -4, -4, -4, -4, -3, -4, -4, -3,
-4, -4, -4, -3, -3, -4, -3, -4, -4, -3, -4, -4, -4, -3, -4, -3, -3, -3, -3, -3,
-3, -3, -3, -4, -5, -5, -5, -5, -6, -5, -6, -6, -6, -6, -6, -5, -5, -6, -5, -5,
-5, -6, -5, -6, -6, -5, -5, -6, -6, -5, -5, -6, -5, -6, -6, -6, -5, -5, -6, -5,
-5, -6, -5, -6, -5, -5, -6, -5, -6, -5, -7, -4, -45, -110, -116, -114, -114,
-115, -115, -113, -115, -114, -114, -114, -115, -114, -114, -113, -114, -114,
-114, -114, -115, -114, -114, -114, -114, -114, -115, -114, -114, -115, -114,
-115, -113, -115, -114, -114, -114, -114, -114, -115, -115, -114, -114, -114,
-114, -114, -115, -114, -115, -114, -115, -114, -114, -114, -115, -114, -115,
-114, -115, -114, -114, -114, -114, -114, -36, };