#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0104

const PROGMEM int8_t DATA[DATA_LENGTH] = {21, 20, 20, 22, 20, 22, 20, 21, 20,
21, 20, 22, 20, 21, 20, 21, 21, 21, 21, 21, 20, 20, 21, 21, 21, 20, 21, 21, 21,
21, 21, 21, 21, 21, 21, 21, 21, 20, 21, 22, 21, 21, 22, 20, 20, 21, 21, 19, 18,
18, 18, 18, 18, 18, 19, 19, 19, 18, 18, 18, 18, 18, 18, 18, 18, 18, 19, 18, 18,
18, 18, 18, 17, 18, 19, 19, 18, 19, 18, 18, 19, 18, 18, 18, 18, 18, 18, 17, 19,
17, 18, 19, 18, 18, 18, 18, 18, 19, 18, 18, 18, 18, 19, 19, 18, 18, 18, 19, 18,
18, 18, 18, 18, 18, 18, 18, 17, 18, 19, 18, 18, 18, 18, 18, 18, 18, 18, 17, 17,
16, 16, 16, 17, 16, 16, 16, 16, 16, 17, 16, 17, 17, 17, 17, 16, 16, 16, 16, 16,
16, 16, 16, 16, 17, 16, 17, 17, 17, 16, 17, 16, 17, 17, 17, 17, 16, 17, 16, 17,
16, 17, 16, 16, 17, 17, 16, 17, 17, 16, 17, 16, 17, 16, 16, 16, 17, 17, 16, 17,
17, 16, 17, 17, 16, 16, 16, 17, 16, 17, 16, 17, 17, 17, 16, 17, 16, 18, 23, 25,
25, 24, 24, 25, 25, 25, 24, 24, 24, 25, 24, 25, 24, 25, 25, 26, 26, 26, 26, 26,
26, 26, 26, 26, 26, 26, 26, 26, 26, 27, 27, 27, 27, 28, 27, 28, 27, 27, 27, 27,
27, 27, 27, 28, 27, 28, 30, 30, 31, 30, 30, 30, 30, 30, 30, 29, 30, 30, 29, 30,
30, 31, 31, 31, 32, 31, 31, 31, 32, 31, 32, 31, 31, 32, 32, 31, 31, 32, 34, 35,
34, 35, 34, 35, 34, 34, 33, 34, 34, 34, 34, 34, 34, 34, 34, 33, 34, 34, 34, 35,
34, 34, 33, 34, 34, 33, 34, 34, 34, 34, 34, 33, 33, 33, 34, 35, 35, 33, 34, 34,
34, 33, 34, 33, 34, 35, 36, 36, 36, 36, 36, 36, 37, 37, 37, 36, 36, 36, 36, 37,
36, 37, 39, 39, 39, 38, 39, 39, 39, 39, 38, 39, 39, 39, 38, 40, 40, 40, 44, 44,
44, 44, 44, 45, 45, 45, 44, 44, 44, 45, 44, 45, 44, 44, 41, 42, 41, 42, 42, 41,
41, 41, 41, 41, 41, 42, 42, 42, 42, 42, 44, 44, 45, 44, 45, 44, 44, 44, 45, 43,
45, 44, 44, 42, 47, 28, -86, -124, -114, -119, -116, -119, -116, -117, -115,
-118, -116, -117, -116, -116, -116, -117, -116, -116, -117, -117, -117, -117,
-116, -117, -117, -117, -116, -116, -117, -117, -116, -116, -114, -114, -114,
-114, -114, -113, -114, -114, -114, -114, -114, -114, -114, -113, -115, -114,
-114, -114, -114, -114, -114, -114, -113, -114, -113, -113, -114, -113, -114,
-114, -113, -112, -111, -111, -110, -110, -110, -111, -111, -111, -111, -111,
-110, -110, -110, -110, -111, -110, -111, -111, -111, -110, -112, -110, -111,
-109, -112, -109, -112, -109, -112, -108, -114, -92, -6, };