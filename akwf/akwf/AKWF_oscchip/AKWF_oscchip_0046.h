#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0046

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 18, 14, 14, 15, 15, 15, 15, 16, 15,
16, 15, 15, 15, 15, 15, 15, 16, 15, 16, 15, 16, 16, 15, 15, 15, 15, 15, 15, 15,
16, 15, 15, 14, 15, 15, 15, 15, 15, 16, 15, 16, 15, 15, 15, 15, 15, 34, 63, 69,
67, 68, 67, 67, 67, 67, 67, 68, 68, 67, 67, 67, 68, 55, 25, 13, 15, 15, 15, 15,
15, 16, 15, 14, 15, 15, 15, 15, 14, 15, 15, 15, 15, 14, 15, 15, 15, 15, 15, 14,
15, 14, 15, 15, 14, 14, 15, 14, 15, 15, 14, 15, 15, 15, 15, 15, 15, 15, 15, 14,
15, 15, 15, 14, 15, 15, 15, 15, 15, 15, 14, 14, 15, 14, 14, 15, 14, 14, 15, 15,
15, 15, 15, 14, 15, 15, 15, 15, 15, 14, 15, 15, 15, 13, 10, 10, 11, 10, 10, 11,
10, 10, 9, 9, 10, 10, 10, 10, 11, 10, 10, 11, 10, 11, 10, 10, 10, 10, 10, 10,
10, 10, 10, 11, 10, 10, 10, 10, 10, 11, 10, 10, 10, 10, 9, 10, 10, 10, 10, 12,
-7, -75, -120, -116, -116, -117, -117, -116, -116, -116, -116, -117, -116, -117,
-116, -118, -111, -53, 4, 8, 5, 7, 6, 5, 6, 6, 6, 6, 6, 6, 6, 5, 6, 4, 2, 1, 2,
2, 1, 2, 2, 2, 2, 1, 1, 2, 2, 1, 0, -6, -8, -6, -8, -7, -7, -8, -7, -7, -7, -7,
-7, -8, -7, -6, -7, -7, -7, -6, -7, -7, -7, -8, -7, -7, -7, -7, -7, -7, -8, -7,
-7, -6, -7, -8, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -8, -7, -5, -4, -2,
-3, -2, -3, -2, -3, -3, -3, -2, -3, -3, -3, -2, -2, -3, -2, -2, -2, -3, -3, -3,
-2, -3, -2, -2, -3, -2, -3, -3, -2, -2, -2, -3, -2, -3, -3, -3, -3, -2, -2, -2,
-2, -2, -2, -3, -1, 25, 62, 69, 66, 68, 67, 68, 67, 67, 68, 67, 67, 67, 67, 67,
68, 48, 9, -6, -2, -3, -2, -3, -2, -3, -3, -3, -3, -3, -3, -3, -3, -2, -2, -2,
-3, -3, -3, -3, -3, -3, -4, -3, -3, -2, -2, -2, -3, -3, -2, -3, -3, -2, -2, -2,
-3, -3, -2, -3, -3, -3, -2, -2, -2, -2, -2, -4, -3, -3, -3, -3, -2, -3, -3, -3,
-3, -2, -2, -3, -1, 1, 2, 2, 1, 1, 2, 2, 1, 1, 2, 1, 1, 1, 2, 1, 2, 1, 2, 1, 1,
1, 1, 1, 2, 2, 1, 2, 2, 2, 2, 2, 2, -6, -16, -17, -16, -15, -15, -16, -15, -17,
-16, -15, -16, -16, -17, -16, -16, -16, -16, -16, -16, -16, -16, -16, -16, -16,
-16, -16, -16, -15, -16, -15, -20, -31, -38, -38, -37, -37, -37, -38, -38, -38,
-38, -38, -38, -37, -37, -37, -40, -55, -68, -68, -69, -69, -68, -69, -67, -68,
-68, -68, -69, -67, -68, -68, -68, -33, };