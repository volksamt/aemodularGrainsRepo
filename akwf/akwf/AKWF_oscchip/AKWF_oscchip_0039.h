#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0039

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 5, 5, 5, 6, 6, 6, 6, 5, 5, 5, 5,
4, 6, 5, 6, 9, 12, 11, 12, 11, 11, 11, 11, 10, 11, 12, 10, 11, 11, 11, 11, 13,
14, 14, 14, 14, 14, 14, 14, 14, 14, 15, 14, 14, 15, 13, 14, 23, 37, 40, 39, 39,
39, 39, 38, 39, 39, 40, 39, 38, 39, 39, 41, 48, 50, 51, 50, 50, 50, 50, 51, 50,
50, 50, 51, 50, 50, 50, 51, 56, 59, 59, 59, 58, 59, 59, 60, 59, 59, 58, 59, 59,
59, 58, 60, 67, 77, 77, 76, 77, 77, 76, 76, 77, 76, 76, 76, 77, 76, 76, 80, 86,
88, 88, 88, 88, 88, 88, 87, 87, 88, 87, 87, 87, 87, 87, 89, 96, 100, 99, 100,
99, 99, 98, 100, 99, 98, 99, 99, 99, 99, 98, 99, 105, 110, 111, 111, 110, 110,
111, 110, 111, 110, 110, 110, 111, 109, 110, 111, 114, 119, 118, 119, 119, 119,
118, 118, 118, 119, 119, 119, 119, 118, 118, 73, -26, -64, -55, -58, -56, -57,
-56, -57, -57, -57, -58, -56, -56, -56, -56, -56, -56, -55, -55, -55, -55, -55,
-56, -55, -56, -55, -55, -55, -55, -55, -55, -56, -52, -47, -48, -48, -48, -48,
-48, -48, -48, -47, -48, -48, -47, -48, -48, -47, -47, -46, -46, -47, -46, -47,
-47, -47, -46, -46, -46, -46, -46, -46, -46, -45, -45, -44, -45, -46, -45, -45,
-45, -44, -44, -44, -45, -44, -45, -44, -45, -45, -44, -43, -43, -43, -43, -43,
-43, -43, -42, -43, -43, -44, -43, -42, -43, -43, -42, -41, -42, -42, -41, -41,
-42, -42, -42, -42, -42, -41, -41, -42, -41, -40, -39, -38, -39, -38, -39, -38,
-38, -38, -39, -39, -38, -39, -38, -38, -38, -38, -35, -35, -35, -35, -34, -35,
-35, -35, -35, -35, -35, -35, -36, -35, -35, -35, -34, -34, -34, -33, -33, -34,
-34, -33, -34, -34, -34, -34, -34, -34, -33, -33, -33, -32, -32, -32, -32, -32,
-32, -33, -32, -33, -33, -32, -32, -32, -33, -31, -30, -31, -31, -30, -30, -31,
-31, -31, -30, -31, -30, -30, -30, -31, -31, -30, -28, -28, -28, -27, -28, -28,
-27, -27, -27, -28, -27, -28, -28, -27, -27, -27, -29, -31, -32, -32, -32, -32,
-31, -32, -32, -32, -32, -32, -31, -31, -32, -30, -29, -28, -29, -29, -29, -28,
-28, -29, -28, -29, -29, -28, -29, -29, -28, -27, -20, -17, -19, -18, -19, -18,
-18, -19, -19, -18, -19, -19, -19, -18, -18, -19, -20, -22, -21, -21, -21, -21,
-22, -21, -21, -21, -21, -21, -21, -21, -21, -20, -20, -18, -18, -18, -19, -18,
-18, -17, -18, -18, -18, -18, -18, -18, -19, -17, -16, -15, -14, -15, -15, -15,
-16, -16, -14, -15, -15, -16, -15, -15, -16, -13, -5, 1, 0, 0, 0, -1, 0, -1, -1,
-1, -1, -1, -1, 0, 0, 0, 0, 0, -1, -1, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, -1, };