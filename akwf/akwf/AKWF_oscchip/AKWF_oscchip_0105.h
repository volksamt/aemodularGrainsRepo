#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0105

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 5, 7, 6, 6, 6, 7, 6, 6, 7, 6, 6,
6, 7, 6, 19, 30, 29, 30, 29, 29, 29, 30, 30, 29, 29, 29, 29, 29, 30, 28, 38, 52,
53, 53, 54, 52, 52, 52, 52, 52, 54, 52, 53, 52, 54, 52, 63, 94, 100, 98, 100,
99, 99, 99, 100, 99, 100, 99, 100, 100, 99, 99, 109, 119, 118, 119, 119, 119,
118, 119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 118, 119, 119, 118, 118,
119, 119, 118, 118, 118, 119, 118, 120, 118, 120, 109, 69, 62, 65, 64, 65, 64,
65, 64, 64, 63, 64, 63, 64, 63, 64, 56, 48, 48, 47, 49, 49, 48, 48, 47, 48, 48,
48, 47, 48, 47, 50, 34, 9, 9, 10, 9, 10, 8, 10, 9, 9, 9, 9, 9, 9, 8, 10, 4, -10,
-13, -12, -12, -12, -12, -12, -12, -12, -12, -13, -12, -12, -13, -13, -8, -2,
-3, -2, -3, -3, -3, -2, -2, -2, -2, -3, -3, -4, -2, -4, 2, 10, 11, 10, 11, 11,
11, 11, 11, 11, 11, 11, 11, 11, 11, 11, 13, 15, 15, 15, 16, 15, 15, 15, 15, 15,
14, 15, 14, 16, 14, 16, 0, -17, -16, -16, -16, -16, -16, -16, -16, -17, -16,
-16, -16, -17, -15, -18, -5, 19, 19, 18, 18, 19, 19, 20, 19, 19, 19, 18, 18, 19,
19, 18, 20, 19, 19, 18, 18, 18, 19, 18, 19, 19, 19, 19, 19, 18, 19, 20, 18, 17,
16, 16, 16, 17, 16, 17, 17, 17, 17, 17, 17, 17, 16, 18, 13, 6, 5, 6, 5, 5, 5, 6,
5, 5, 5, 5, 5, 5, 6, 5, -8, -16, -14, -15, -14, -14, -13, -14, -14, -14, -15,
-15, -14, -14, -15, -15, -25, -35, -33, -34, -34, -35, -34, -34, -35, -33, -34,
-34, -34, -34, -34, -33, -42, -57, -57, -57, -57, -57, -56, -58, -56, -57, -56,
-57, -57, -58, -57, -57, -70, -78, -76, -77, -76, -76, -76, -76, -77, -77, -76,
-76, -76, -76, -77, -75, -85, -92, -92, -92, -92, -91, -92, -92, -92, -92, -92,
-92, -92, -91, -92, -91, -93, -95, -96, -95, -96, -95, -96, -95, -96, -96, -96,
-96, -95, -95, -95, -92, -27, 10, 3, 7, 4, 6, 5, 7, 5, 6, 5, 6, 5, 6, 4, 8, -41,
-88, -82, -85, -82, -85, -84, -84, -83, -84, -84, -84, -83, -84, -83, -85, -78,
-64, -64, -64, -64, -64, -65, -64, -64, -64, -64, -65, -64, -65, -64, -62, -11,
16, 11, 13, 10, 12, 12, 12, 12, 12, 11, 12, 12, 13, 10, 13, -17, -47, -44, -45,
-44, -45, -45, -45, -45, -44, -44, -45, -44, -45, -45, -45, -40, -33, -33, -33,
-34, -32, -33, -32, -32, -34, -33, -32, -32, -32, -33, -32, -25, -21, -21, -20,
-21, -20, -21, -21, -21, -20, -21, -21, -21, -20, -21, -21, -15, -9, -9, -9, -9,
-9, -10, -9, -9, -9, -9, -9, -9, -8, -10, -7, };