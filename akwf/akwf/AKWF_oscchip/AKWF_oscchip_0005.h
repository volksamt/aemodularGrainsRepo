#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {70, 102, 91, 97, 93, 97, 94, 97, 94,
96, 95, 95, 95, 96, 95, 99, 114, 115, 114, 116, 115, 116, 115, 115, 115, 115,
115, 114, 115, 114, 114, 115, 116, 114, 114, 114, 115, 114, 115, 115, 115, 115,
114, 115, 114, 114, 114, 115, 118, 119, 119, 118, 119, 119, 118, 118, 119, 119,
119, 119, 119, 118, 119, 114, 105, 105, 105, 104, 105, 105, 104, 105, 105, 104,
105, 104, 105, 105, 105, 103, 100, 100, 100, 101, 99, 100, 99, 100, 99, 100,
100, 100, 100, 99, 100, 91, 81, 81, 81, 82, 81, 82, 81, 82, 81, 81, 81, 82, 82,
80, 82, 70, 54, 55, 55, 54, 55, 54, 54, 55, 54, 54, 54, 54, 55, 53, 55, 50, 45,
45, 45, 45, 44, 44, 45, 45, 45, 45, 45, 45, 45, 45, 46, 35, 26, 28, 27, 27, 27,
27, 27, 27, 26, 26, 28, 27, 28, 27, 26, 22, 18, 18, 17, 18, 18, 17, 18, 18, 17,
18, 17, 17, 19, 18, 17, 5, -3, -2, -3, -3, -3, -3, -2, -2, -3, -2, -3, -3, -2,
-2, -5, -43, -68, -64, -66, -65, -66, -65, -65, -64, -65, -65, -65, -65, -64,
-65, -65, -69, -70, -69, -69, -69, -69, -69, -69, -70, -69, -69, -70, -69, -69,
-69, -70, -69, -70, -70, -69, -69, -69, -69, -69, -69, -69, -69, -70, -68, -69,
-69, -71, -59, -33, -28, -29, -28, -29, -28, -29, -29, -29, -29, -29, -29, -28,
-29, -28, -34, -48, -49, -49, -49, -49, -48, -49, -49, -49, -48, -48, -49, -48,
-49, -48, -51, -55, -55, -55, -56, -55, -56, -56, -55, -55, -55, -55, -55, -55,
-55, -55, -59, -63, -64, -64, -65, -63, -64, -63, -64, -64, -64, -64, -63, -64,
-63, -64, -55, -42, -41, -42, -42, -42, -41, -42, -41, -41, -41, -42, -40, -41,
-41, -42, -22, 8, 8, 8, 8, 8, 8, 8, 8, 8, 9, 8, 8, 8, 8, 8, 0, -10, -9, -9, -10,
-10, -9, -10, -10, -10, -10, -10, -9, -9, -9, -9, -26, -42, -40, -42, -41, -41,
-42, -41, -40, -41, -41, -40, -40, -41, -40, -41, -42, -45, -45, -45, -45, -45,
-45, -45, -45, -45, -45, -45, -45, -45, -45, -46, -63, -77, -76, -77, -77, -76,
-76, -77, -76, -76, -76, -75, -77, -76, -76, -76, -81, -83, -83, -83, -82, -82,
-83, -83, -83, -83, -83, -83, -84, -83, -83, -82, -82, -83, -82, -82, -82, -82,
-83, -83, -83, -82, -82, -83, -82, -82, -82, -76, -18, 16, 10, 13, 11, 11, 11,
12, 12, 12, 11, 12, 12, 12, 11, 14, 21, 26, 24, 25, 26, 25, 25, 26, 25, 26, 26,
25, 26, 26, 24, 27, 14, -22, -28, -26, -26, -26, -26, -25, -26, -26, -26, -26,
-26, -26, -26, -26, -30, -40, -42, -42, -42, -42, -42, -41, -42, -41, -42, -41,
-42, -41, -42, -41, -49, -66, -69, -67, -68, -68, -69, -68, -69, -68, -68, -67,
-68, -69, -67, -71, -22, };