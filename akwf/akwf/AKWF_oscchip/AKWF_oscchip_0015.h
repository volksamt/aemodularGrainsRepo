#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 67, 87, 81, 84, 82, 84, 82, 83, 82,
84, 83, 84, 82, 84, 82, 90, 113, 119, 116, 118, 117, 118, 117, 118, 118, 117,
118, 117, 118, 117, 119, 105, 67, 60, 62, 61, 61, 62, 62, 61, 61, 61, 62, 62,
61, 62, 60, 69, 88, 90, 89, 90, 89, 90, 90, 90, 90, 89, 89, 88, 90, 88, 91, 73,
36, 32, 34, 33, 34, 34, 33, 32, 34, 33, 34, 34, 34, 33, 34, 17, -16, -20, -17,
-19, -19, -19, -19, -19, -19, -20, -19, -19, -18, -19, -19, -17, -15, -16, -15,
-15, -16, -15, -16, -14, -16, -15, -16, -15, -16, -15, -15, -15, -14, -14, -14,
-14, -14, -14, -13, -15, -14, -14, -14, -13, -15, -14, -15, -14, -14, -14, -14,
-14, -14, -14, -14, -14, -14, -14, -14, -14, -14, -15, -14, -14, -13, -14, -13,
-14, -15, -14, -15, -14, -13, -14, -15, -14, -14, -14, -14, -14, -15, -14, -14,
-14, -14, -14, -13, -14, -15, -14, -14, -14, -14, -14, -14, -13, -14, -14, -14,
-14, -13, -13, -14, -14, -14, -14, -14, -13, -14, -13, -15, -13, -14, -13, -14,
-14, -13, -14, -14, -14, -14, -13, -13, -14, -13, -13, -14, -13, -14, -14, -13,
-13, -14, -14, -14, -13, -13, -14, -13, -13, -14, -13, -13, -14, -14, -13, -14,
-14, -14, -14, -14, -14, -13, -14, -13, -14, -14, -14, -14, -14, -15, -15, -14,
-15, -15, -15, -15, -14, -15, -15, -14, -15, -15, -14, -15, -15, -14, -13, -14,
-14, -14, -14, -14, -14, -14, -14, -14, -14, -13, -13, -13, -16, -23, -24, -23,
-24, -24, -23, -24, -24, -24, -24, -25, -24, -24, -25, -25, -20, -14, -13, -14,
-13, -14, -14, -13, -13, -14, -14, -14, -14, -14, -13, -14, -14, -14, -13, -14,
-13, -14, -13, -14, -13, -14, -13, -13, -14, -13, -13, -13, -14, -14, -15, -14,
-14, -15, -14, -14, -15, -14, -15, -14, -15, -15, -15, -15, -13, -13, -14, -13,
-13, -13, -13, -12, -13, -14, -13, -13, -13, -12, -13, -13, -13, -14, -14, -14,
-14, -15, -14, -14, -15, -14, -14, -14, -14, -14, -14, -14, -14, -13, -13, -13,
-13, -13, -13, -13, -13, -13, -14, -13, -13, -14, -13, -13, -13, -14, -13, -13,
-12, -13, -13, -13, -13, -14, -13, -13, -14, -13, -13, -13, -12, -12, -13, -13,
-14, -13, -13, -13, -13, -13, -13, -12, -12, -13, -14, -12, -12, -13, -12, -13,
-13, -13, -13, -13, -13, -13, -13, -12, -13, -13, -13, -13, -13, -13, -13, -12,
-13, -13, -13, -13, -13, -13, -13, -13, -13, -14, -13, -13, -13, -14, -14, -15,
-14, -14, -14, -15, -14, -14, -14, -14, -14, -13, -14, -14, -14, -14, -14, -14,
-14, -13, -15, -13, -14, -14, -14, -14, -15, -13, -13, -13, -13, -12, -13, -13,
-12, -13, -13, -13, -13, -12, -12, -12, -13, -13, -13, -13, -12, -12, -13, -12,
-13, -13, -13, -12, -14, -13, -13, -12, -13, -12, -14, -12, };