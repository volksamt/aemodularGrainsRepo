#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0070

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 2, 2, 1, 3, 1, 2, 1, 2, 1, 2,
2, 2, 2, 3, 5, 4, 5, 3, 5, 4, 5, 4, 6, 3, 6, 2, 7, 0, 43, 112, 111, 111, 112,
112, 112, 111, 112, 111, 112, 112, 112, 112, 111, 112, 112, 112, 111, 112, 111,
113, 111, 112, 111, 113, 111, 112, 111, 112, 111, 114, 93, -60, -121, -105,
-114, -109, -113, -109, -113, -110, -112, -110, -112, -111, -111, -111, -109,
-108, -108, -108, -108, -108, -108, -109, -107, -109, -107, -109, -106, -111,
-106, -112, -85, -6, 9, 6, 9, 6, 7, 6, 7, 7, 7, 7, 7, 6, 7, 7, 7, 8, 10, 9, 9,
8, 9, 9, 9, 9, 8, 10, 9, 9, 9, 9, 11, 12, 11, 12, 12, 12, 12, 12, 12, 12, 12,
12, 11, 12, 12, 11, 11, 10, 9, 9, 10, 10, 10, 9, 9, 9, 9, 10, 9, 9, 9, 9, 9, 9,
10, 9, 9, 10, 9, 10, 10, 10, 9, 8, 9, 9, 9, 9, 10, 9, 9, 9, 10, 9, 10, 9, 9, 10,
9, 9, 9, 10, 10, 10, 9, 9, 9, 9, 9, 8, 9, 9, 9, 9, 10, 9, 9, 10, 10, 9, 9, 9, 9,
9, 9, 9, 10, 9, 9, 9, 9, 9, 8, 9, 9, 10, 9, 6, 6, 6, 7, 7, 7, 6, 7, 7, 7, 7, 7,
7, 7, 6, 7, 6, 6, 7, 6, 7, 7, 6, 7, 7, 6, 7, 6, 7, 6, 7, 6, 3, 4, 4, 4, 5, 4, 5,
4, 5, 5, 5, 4, 4, 4, 4, 3, 2, 1, 2, 2, 2, 1, 2, 2, 2, 1, 2, 2, 2, 1, 2, -2, -12,
-14, -14, -14, -13, -13, -13, -14, -13, -13, -14, -13, -13, -14, -12, -23, -34,
-33, -34, -33, -34, -34, -34, -34, -33, -33, -34, -34, -33, -33, -32, -41, -53,
-54, -52, -54, -52, -53, -53, -54, -53, -53, -53, -54, -53, -54, -53, -60, -87,
-93, -90, -91, -90, -91, -91, -90, -90, -90, -90, -90, -91, -89, -93, -47, -4,
-11, -7, -9, -8, -8, -8, -8, -8, -7, -9, -8, -8, -8, -10, 3, 19, 20, 19, 20, 19,
19, 19, 20, 18, 20, 19, 19, 19, 20, 19, 20, 24, 25, 24, 25, 25, 24, 25, 24, 24,
24, 25, 25, 25, 24, 25, 24, 25, 25, 24, 24, 24, 25, 25, 24, 25, 25, 25, 24, 25,
24, 24, 24, 25, 25, 25, 25, 24, 25, 24, 24, 25, 24, 25, 25, 23, 25, 25, 25, 25,
24, 25, 24, 24, 24, 25, 24, 23, 24, 24, 25, 25, 24, 24, 21, 19, 19, 20, 20, 19,
20, 19, 19, 20, 19, 19, 19, 19, 19, 19, 13, 0, 0, -1, -2, -1, -1, 0, 0, 0, -1,
0, -2, 1, -1, 0, -8, -37, -42, -40, -41, -40, -42, -41, -41, -41, -41, -41, -41,
-41, -41, -42, -24, -6, -9, -9, -8, -8, -8, -8, -7, -8, -8, -8, -8, -8, -8, -9,
-4, };