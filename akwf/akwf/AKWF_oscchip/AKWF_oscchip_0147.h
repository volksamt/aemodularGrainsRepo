#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0147

const PROGMEM int8_t DATA[DATA_LENGTH] = {64, 101, 88, 95, 90, 93, 91, 93, 92,
93, 93, 92, 92, 92, 92, 90, 79, 73, 75, 73, 74, 74, 74, 74, 74, 73, 74, 73, 74,
74, 73, 68, 61, 61, 61, 62, 62, 62, 62, 62, 61, 61, 62, 61, 62, 61, 62, 56, 48,
47, 48, 47, 47, 48, 47, 48, 47, 47, 47, 47, 47, 47, 48, 46, 42, 41, 41, 41, 42,
42, 42, 41, 41, 41, 42, 42, 42, 41, 41, 40, 37, 37, 37, 37, 37, 37, 37, 36, 38,
37, 37, 36, 37, 36, 37, 35, 35, 35, 35, 35, 36, 35, 35, 34, 34, 35, 35, 35, 34,
35, 35, 37, 41, 40, 40, 41, 42, 42, 41, 40, 40, 40, 41, 41, 42, 41, 40, 42, 41,
41, 41, 41, 41, 41, 40, 41, 40, 41, 41, 40, 40, 40, 40, 41, 43, 43, 42, 43, 43,
43, 44, 43, 44, 43, 43, 43, 44, 43, 44, 46, 47, 47, 47, 47, 47, 47, 47, 48, 48,
47, 47, 47, 47, 47, 47, 50, 54, 53, 53, 53, 53, 53, 54, 54, 54, 53, 53, 53, 54,
53, 53, 55, 61, 62, 61, 62, 62, 61, 61, 61, 61, 62, 62, 61, 61, 61, 62, 64, 68,
70, 69, 70, 70, 69, 69, 70, 70, 70, 70, 70, 70, 69, 70, 79, 84, 85, 84, 84, 84,
83, 84, 84, 85, 84, 85, 84, 84, 83, 84, 53, 15, 14, 14, 14, 14, 14, 14, 14, 14,
14, 14, 14, 15, 15, 14, 31, 63, 69, 67, 68, 68, 68, 67, 67, 67, 67, 67, 68, 67,
68, 68, 73, 91, 97, 95, 97, 96, 96, 96, 97, 96, 96, 96, 96, 97, 96, 96, 103,
107, 107, 107, 106, 106, 107, 107, 107, 106, 106, 107, 107, 107, 107, 106, 108,
109, 109, 108, 108, 109, 109, 108, 109, 108, 108, 109, 109, 109, 108, 108, 107,
106, 107, 107, 107, 107, 107, 106, 106, 107, 107, 106, 107, 107, 106, 107, 106,
107, 106, 106, 107, 107, 107, 106, 106, 106, 107, 106, 106, 106, 106, 107, 107,
106, 106, 106, 106, 107, 106, 106, 106, 106, 107, 107, 106, 107, 106, 107, 106,
106, 107, 107, 106, 106, 107, 106, 107, 107, 106, 107, 106, 107, 107, 106, 105,
103, 102, 102, 102, 102, 103, 103, 102, 102, 102, 103, 103, 103, 102, 103, 103,
103, 103, 102, 103, 102, 102, 102, 102, 103, 102, 102, 103, 103, 102, 102, 101,
101, 101, 101, 100, 101, 100, 100, 100, 100, 100, 101, 101, 100, 101, 100, 83,
65, 66, 65, 66, 65, 66, 66, 66, 65, 65, 67, 66, 66, 65, 67, 40, -1, -6, -3, -4,
-3, -4, -4, -5, -4, -4, -5, -5, -4, -5, -2, -23, -73, -85, -81, -83, -81, -83,
-81, -82, -82, -82, -82, -83, -83, -83, -85, -106, -119, -116, -117, -116, -118,
-117, -117, -117, -116, -117, -117, -117, -118, -117, -116, -118, -119, -120,
-118, -119, -119, -120, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-44, };