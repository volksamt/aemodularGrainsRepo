#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0088

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 1, -1, 0, 0, 1, 0, 0, 0, 1,
-1, 1, 0, 1, 6, 7, 6, 7, 7, 6, 7, 7, 7, 7, 6, 6, 7, 7, 7, 10, 11, 12, 12, 12,
12, 11, 11, 11, 12, 12, 11, 11, 11, 11, 12, 13, 15, 15, 15, 15, 15, 15, 14, 15,
14, 15, 14, 14, 14, 15, 15, 16, 20, 20, 19, 20, 19, 20, 19, 20, 19, 19, 19, 20,
19, 20, 20, 25, 28, 28, 28, 28, 27, 27, 27, 28, 27, 27, 28, 27, 28, 28, 27, 29,
32, 31, 31, 32, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 32, 33, 32, 32, 33,
33, 32, 32, 33, 33, 33, 33, 33, 32, 32, 32, 38, 42, 41, 42, 43, 42, 41, 42, 41,
42, 42, 42, 43, 42, 43, 42, 43, 45, 45, 45, 46, 46, 45, 46, 45, 46, 45, 46, 46,
46, 45, 45, 47, 51, 52, 53, 51, 52, 52, 52, 51, 52, 52, 51, 51, 52, 52, 51, 53,
55, 55, 55, 55, 55, 55, 55, 55, 54, 55, 54, 56, 54, 56, 54, 65, 78, 79, 77, 78,
78, 78, 77, 79, 78, 77, 77, 77, 77, 79, 68, -67, -125, -110, -118, -113, -117,
-113, -116, -113, -116, -115, -115, -114, -116, -114, -115, -100, -88, -90, -90,
-90, -90, -90, -89, -91, -90, -91, -91, -90, -90, -90, -91, -81, -65, -66, -65,
-66, -65, -65, -65, -66, -65, -65, -65, -65, -66, -66, -65, -51, -44, -46, -46,
-46, -46, -46, -46, -45, -46, -47, -46, -46, -46, -46, -46, -36, -29, -30, -29,
-30, -29, -30, -29, -29, -30, -30, -30, -30, -30, -29, -30, -24, -16, -16, -16,
-16, -16, -16, -17, -16, -16, -16, -16, -16, -17, -16, -17, -14, -8, -6, -8, -6,
-7, -6, -7, -6, -6, -7, -7, -7, -7, -6, -6, -4, -2, -2, -2, -2, -1, -1, -1, -1,
-2, -2, -1, -2, -2, -2, -2, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 1, 0, 0, -1,
0, 0, -1, 0, -1, 1, 0, 0, 0, 0, 0, 0, 1, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, -1, -2, -1,
-2, -2, -2, -1, -1, -1, -1, -1, -2, -2, -1, -1, -2, -1, -1, -2, -2, -1, -2, -1,
-1, -1, -2, -1, -2, -1, -1, -1, -2, -3, -5, -6, -5, -5, -6, -5, -5, -5, -4, -4,
-5, -5, -5, -5, -5, -5, -5, -4, -5, -5, -5, -4, -5, -5, -4, -5, -5, -5, -5, -5,
-5, -5, -6, -6, -6, -6, -7, -7, -6, -6, -6, -7, -6, -6, -7, -7, -6, -7, -8, -9,
-8, -8, -8, -8, -8, -8, -8, -8, -8, -7, -8, -8, -9, -12, -12, -13, -12, -13,
-13, -14, -13, -13, -13, -13, -14, -13, -14, -13, -13, -6, };