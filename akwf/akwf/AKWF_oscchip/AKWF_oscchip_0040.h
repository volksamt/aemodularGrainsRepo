#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0040

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 9, 8, 9, 9, 9, 9, 8, 9, 9, 8, 9, 8,
9, 9, 10, 14, 19, 18, 18, 17, 17, 18, 17, 18, 18, 18, 18, 18, 18, 17, 19, 27,
36, 36, 36, 36, 37, 37, 37, 36, 36, 36, 37, 37, 36, 36, 37, 41, 47, 49, 48, 49,
48, 49, 48, 49, 48, 48, 49, 49, 49, 49, 51, 58, 61, 61, 61, 61, 60, 60, 61, 60,
60, 60, 61, 60, 61, 60, 61, 69, 73, 73, 73, 73, 73, 72, 73, 73, 73, 72, 72, 73,
73, 72, 73, 78, 82, 82, 82, 82, 82, 82, 82, 81, 81, 81, 81, 82, 81, 81, 81, 80,
79, 80, 80, 79, 80, 80, 79, 79, 79, 79, 81, 80, 80, 79, 80, 81, 81, 81, 81, 82,
81, 81, 80, 81, 82, 81, 81, 81, 82, 82, 81, 81, 80, 81, 81, 82, 80, 81, 80, 82,
81, 81, 81, 81, 81, 81, 80, 80, 80, 81, 81, 81, 80, 80, 81, 80, 81, 81, 81, 80,
80, 80, 80, 81, 80, 80, 80, 80, 80, 81, 80, 80, 80, 81, 80, 80, 80, 79, 80, 80,
80, 80, 80, 79, 80, 80, 80, 80, 80, 79, 79, 80, 80, 80, 79, 79, 80, 79, 80, 79,
79, 80, 80, 80, 80, 79, 80, 79, 79, 79, 79, 79, 80, 79, 80, 80, 80, 79, 79, 79,
80, 80, 79, 79, 79, 78, 1, -101, -119, -112, -114, -114, -113, -114, -113, -113,
-113, -114, -114, -113, -114, -113, -109, -103, -101, -101, -102, -101, -101,
-102, -101, -101, -101, -101, -101, -101, -101, -101, -99, -92, -89, -89, -89,
-88, -89, -88, -88, -89, -88, -88, -88, -88, -89, -89, -87, -85, -86, -86, -86,
-85, -85, -85, -86, -85, -85, -85, -85, -85, -84, -85, -84, -82, -82, -81, -82,
-82, -82, -81, -82, -81, -82, -82, -82, -81, -81, -81, -79, -73, -72, -72, -72,
-73, -72, -73, -72, -71, -72, -73, -72, -72, -73, -72, -73, -76, -76, -76, -77,
-76, -77, -76, -76, -76, -77, -76, -77, -76, -77, -76, -68, -63, -63, -62, -62,
-63, -62, -63, -62, -62, -62, -63, -62, -62, -62, -62, -57, -51, -50, -50, -50,
-50, -50, -49, -49, -49, -50, -50, -49, -50, -50, -50, -49, -49, -48, -48, -47,
-48, -49, -48, -48, -48, -48, -48, -48, -47, -48, -47, -46, -45, -45, -46, -45,
-45, -45, -45, -44, -45, -44, -44, -45, -44, -45, -45, -42, -40, -40, -40, -40,
-39, -40, -39, -40, -40, -40, -40, -39, -39, -40, -39, -35, -30, -30, -31, -31,
-30, -30, -30, -30, -31, -30, -30, -30, -30, -30, -31, -29, -26, -26, -26, -26,
-26, -25, -26, -25, -25, -26, -26, -26, -25, -26, -25, -23, -20, -21, -21, -21,
-21, -20, -21, -21, -20, -22, -21, -20, -21, -21, -21, -20, -20, -19, -19, -19,
-20, -20, -20, -19, -19, -19, -20, -19, -19, -20, -18, -12, -4, -4, -4, -4, -3,
-3, -4, -3, -3, -4, -4, -3, -4, -4, -3, 0, };