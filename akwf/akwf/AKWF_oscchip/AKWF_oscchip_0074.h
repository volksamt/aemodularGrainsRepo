#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0074

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 0, 1, 0, 0, 0, 1, 0, 1, 0, 1,
1, 1, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0,
0, 1, 0, 0, 1, 0, 1, 1, 3, 4, 4, 4, 5, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 5, 4, 4, 4,
5, 4, 4, 5, 4, 4, 4, 4, 5, 4, 4, 4, 5, 7, 6, 6, 6, 6, 6, 6, 7, 6, 5, 6, 5, 7, 6,
6, 7, 9, 9, 10, 9, 9, 9, 9, 9, 9, 9, 10, 9, 9, 10, 9, 11, 13, 12, 13, 13, 12,
13, 13, 13, 13, 12, 13, 12, 13, 13, 13, 14, 18, 19, 17, 18, 18, 18, 19, 19, 19,
18, 17, 19, 18, 19, 18, 21, 22, 22, 22, 21, 21, 21, 22, 22, 21, 21, 22, 22, 22,
22, 21, 25, 31, 30, 30, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 30, 33, 40,
41, 41, 42, 41, 42, 41, 42, 41, 42, 42, 41, 41, 41, 42, 48, 57, 55, 56, 56, 55,
55, 55, 55, 56, 56, 55, 55, 56, 56, 55, 63, 78, 79, 78, 80, 79, 79, 79, 78, 78,
79, 78, 80, 78, 79, 78, 80, 83, 84, 83, 84, 85, 84, 84, 84, 85, 83, 85, 83, 86,
80, 90, -18, -126, -114, -119, -115, -118, -116, -117, -115, -117, -116, -117,
-115, -117, -116, -119, -98, -55, -55, -55, -55, -55, -56, -56, -56, -55, -56,
-55, -55, -56, -56, -56, -53, -39, -36, -38, -37, -38, -38, -38, -37, -38, -37,
-38, -38, -38, -37, -37, -32, -28, -29, -28, -28, -28, -29, -29, -29, -28, -28,
-29, -28, -28, -28, -29, -27, -22, -24, -24, -22, -24, -24, -23, -23, -24, -24,
-23, -23, -23, -23, -23, -23, -21, -19, -19, -19, -19, -19, -19, -20, -19, -19,
-19, -20, -20, -19, -19, -19, -17, -18, -18, -18, -18, -18, -17, -18, -18, -18,
-18, -17, -18, -18, -18, -16, -15, -15, -14, -14, -14, -14, -14, -14, -14, -14,
-14, -15, -14, -13, -14, -14, -10, -10, -10, -10, -11, -10, -10, -11, -11, -10,
-10, -10, -11, -10, -10, -9, -9, -8, -9, -8, -8, -8, -9, -9, -8, -9, -9, -9, -9,
-8, -8, -8, -6, -7, -7, -7, -7, -6, -6, -6, -7, -6, -6, -7, -7, -6, -7, -7, -7,
-6, -7, -7, -7, -6, -7, -7, -6, -6, -6, -7, -6, -7, -7, -7, -7, -8, -7, -6, -7,
-7, -7, -6, -7, -7, -7, -7, -7, -7, -6, -6, -5, -5, -5, -5, -4, -5, -5, -4, -5,
-5, -5, -5, -4, -5, -5, -5, -5, -5, -4, -5, -5, -5, -5, -5, -5, -4, -5, -5, -4,
-5, -5, -3, -4, -4, -4, -3, -4, -3, -3, -3, -3, -3, -3, -3, -4, -3, -4, -3, -2,
-2, -1, -1, -1, -2, -1, -1, -1, -1, -2, -1, -1, -2, -2, 0, };