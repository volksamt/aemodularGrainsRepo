#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0097

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 3, 2, 3, 3, 2, 3, 3, 2, 3, 3,
2, 2, 3, 6, 9, 8, 9, 8, 8, 8, 9, 9, 9, 9, 8, 9, 9, 8, 8, 10, 16, 16, 16, 16, 16,
16, 16, 16, 16, 16, 16, 17, 16, 16, 16, 28, 37, 35, 36, 35, 36, 36, 36, 35, 36,
36, 36, 36, 35, 36, 36, 42, 52, 51, 51, 52, 51, 52, 51, 51, 51, 52, 51, 52, 51,
52, 50, 59, 82, 83, 83, 84, 82, 84, 83, 83, 83, 83, 83, 84, 82, 83, 82, 104,
120, 118, 118, 117, 118, 117, 118, 118, 118, 117, 119, 118, 118, 118, 118, 117,
114, 113, 114, 114, 114, 114, 114, 114, 114, 114, 114, 114, 113, 114, 114, 112,
108, 108, 108, 108, 108, 108, 108, 107, 107, 108, 108, 107, 107, 108, 108, 105,
103, 104, 103, 103, 104, 104, 104, 103, 103, 103, 104, 103, 103, 104, 104, 101,
95, 97, 96, 96, 95, 95, 95, 95, 95, 95, 95, 96, 96, 95, 96, 91, 80, 80, 79, 79,
79, 80, 79, 80, 80, 80, 79, 80, 79, 80, 80, 69, 63, 64, 63, 64, 64, 64, 64, 64,
63, 64, 64, 63, 64, 64, 65, 55, 44, 44, 44, 44, 43, 45, 45, 45, 44, 44, 44, 44,
44, 44, 42, 33, 28, 29, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 18,
11, 13, 12, 12, 13, 13, 12, 12, 12, 11, 12, 12, 13, 13, 13, 5, -3, -2, -4, -3,
-3, -3, -3, -3, -4, -3, -3, -4, -3, -3, -4, -16, -20, -19, -18, -19, -19, -19,
-19, -20, -18, -19, -19, -18, -19, -20, -19, -33, -44, -41, -43, -42, -42, -42,
-42, -43, -43, -42, -43, -43, -43, -42, -42, -47, -55, -54, -54, -54, -54, -54,
-55, -54, -54, -55, -55, -54, -55, -54, -55, -64, -69, -67, -69, -68, -68, -67,
-68, -69, -68, -68, -68, -67, -68, -68, -68, -79, -87, -85, -86, -84, -86, -85,
-85, -85, -85, -85, -85, -86, -85, -85, -85, -94, -106, -105, -105, -105, -105,
-104, -106, -106, -105, -104, -105, -105, -105, -105, -106, -115, -119, -118,
-119, -119, -119, -118, -119, -118, -118, -119, -119, -119, -118, -118, -118,
-118, -119, -118, -119, -118, -118, -119, -119, -118, -118, -119, -119, -118,
-117, -118, -118, -118, -118, -119, -118, -118, -118, -118, -118, -118, -118,
-118, -117, -118, -118, -118, -117, -113, -111, -112, -111, -111, -112, -112,
-112, -112, -112, -111, -112, -112, -111, -112, -112, -85, -66, -69, -69, -69,
-69, -68, -69, -68, -68, -68, -68, -68, -68, -67, -70, -51, -26, -27, -27, -27,
-27, -27, -27, -27, -28, -27, -28, -27, -27, -27, -26, -19, -16, -18, -17, -17,
-17, -17, -17, -17, -18, -18, -18, -17, -17, -16, -17, -11, -7, -8, -7, -8, -8,
-7, -7, -7, -7, -7, -7, -7, -8, -7, -7, -4, -1, -2, -2, -1, -1, -1, -1, -1, -2,
-1, -2, -1, -2, -1, -1, };