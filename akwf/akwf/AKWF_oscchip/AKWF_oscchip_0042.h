#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0042

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 71, 92, 86, 89, 89, 89, 88, 88,
88, 89, 88, 89, 87, 88, 88, 88, 85, 85, 85, 85, 85, 85, 85, 84, 85, 85, 85, 85,
85, 85, 85, 85, 83, 81, 80, 81, 81, 81, 82, 82, 81, 81, 82, 81, 81, 81, 81, 78,
72, 71, 71, 72, 71, 71, 71, 71, 71, 71, 71, 71, 71, 71, 71, 70, 68, 69, 68, 68,
67, 69, 68, 68, 68, 67, 68, 68, 68, 68, 68, 67, 66, 64, 64, 65, 64, 65, 64, 64,
65, 64, 64, 64, 65, 65, 65, 64, 62, 60, 60, 59, 59, 59, 60, 60, 60, 60, 60, 60,
59, 59, 60, 59, 57, 58, 57, 58, 58, 58, 58, 57, 57, 58, 58, 57, 58, 57, 58, 56,
50, 48, 48, 48, 47, 47, 48, 48, 47, 48, 48, 48, 47, 48, 48, 47, 46, 45, 45, 44,
44, 44, 44, 44, 44, 44, 44, 44, 45, 44, 44, 42, 38, 38, 38, 37, 38, 38, 37, 37,
37, 38, 38, 38, 38, 38, 38, 36, 33, 31, 31, 31, 31, 31, 31, 30, 31, 31, 31, 31,
31, 31, 31, 30, 24, 21, 21, 21, 20, 22, 21, 21, 22, 21, 21, 22, 21, 21, 21, 20,
15, 9, 8, 9, 9, 8, 9, 8, 8, 8, 9, 9, 8, 8, 9, 3, -5, -6, -6, -6, -6, -7, -6, -6,
-6, -6, -6, -6, -6, -6, -5, -29, -91, -120, -114, -115, -115, -115, -115, -115,
-115, -115, -115, -115, -114, -115, -115, -113, -103, -96, -96, -96, -95, -95,
-95, -95, -96, -95, -95, -96, -96, -96, -94, -86, -73, -73, -72, -73, -73, -73,
-74, -73, -73, -73, -72, -73, -72, -73, -73, -70, -64, -62, -63, -64, -63, -64,
-64, -63, -63, -63, -62, -63, -63, -62, -63, -61, -54, -50, -50, -50, -50, -49,
-50, -49, -49, -50, -50, -50, -50, -49, -50, -49, -44, -40, -40, -40, -40, -40,
-40, -41, -40, -40, -40, -39, -40, -40, -40, -35, -28, -26, -27, -27, -27, -27,
-28, -28, -27, -27, -27, -27, -26, -27, -27, -24, -16, -13, -15, -14, -14, -14,
-15, -15, -14, -14, -14, -14, -14, -14, -14, -26, -76, -108, -105, -105, -105,
-105, -105, -105, -105, -105, -105, -105, -105, -105, -105, -105, -103, -101,
-102, -102, -102, -101, -101, -101, -102, -101, -102, -102, -102, -101, -102,
-47, 45, 65, 60, 61, 60, 60, 60, 60, 60, 60, 61, 61, 60, 60, 60, 60, 56, 54, 53,
54, 54, 54, 54, 54, 54, 54, 54, 53, 53, 53, 56, 44, -18, -62, -60, -60, -60,
-60, -60, -60, -60, -60, -59, -59, -59, -60, -60, -53, -46, -45, -46, -45, -45,
-45, -45, -45, -46, -45, -45, -45, -45, -45, -45, -44, -44, -43, -44, -44, -44,
-44, -43, -44, -43, -44, -43, -44, -44, -44, -44, -41, -34, -29, -28, -30, -28,
-30, -29, -29, -29, -29, -28, -29, -29, -30, -29, -29, -23, -20, -19, -20, -18,
-19, -18, -20, -19, -21, -19, -20, -19, -21, -17, };