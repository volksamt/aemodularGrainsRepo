#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {86, 121, 107, 115, 109, 114, 110, 114,
111, 114, 112, 112, 112, 112, 112, 111, 105, 105, 105, 106, 105, 105, 105, 105,
106, 104, 105, 105, 105, 105, 105, 102, 97, 97, 96, 96, 97, 96, 97, 97, 97, 96,
97, 97, 97, 96, 96, 94, 91, 92, 92, 91, 91, 91, 91, 91, 91, 91, 92, 92, 92, 91,
91, 88, 84, 84, 85, 84, 85, 85, 84, 85, 85, 84, 84, 84, 84, 84, 84, 83, 80, 81,
81, 81, 81, 81, 81, 80, 80, 81, 81, 81, 81, 81, 81, 76, 69, 70, 71, 70, 70, 70,
70, 71, 70, 70, 71, 70, 71, 71, 71, 65, 60, 60, 61, 60, 60, 60, 59, 60, 60, 60,
60, 60, 59, 60, 59, 58, 57, 57, 56, 57, 56, 56, 57, 57, 56, 56, 57, 56, 57, 56,
56, 48, 42, 44, 42, 43, 43, 43, 43, 43, 43, 42, 43, 43, 43, 43, 43, 38, 36, 37,
36, 37, 36, 36, 36, 36, 36, 36, 35, 35, 36, 36, 36, 35, 35, 34, 34, 34, 34, 34,
34, 35, 33, 34, 34, 34, 34, 34, 34, 32, 28, 28, 27, 27, 27, 28, 27, 28, 28, 27,
27, 27, 27, 28, 28, 26, 20, 18, 19, 19, 19, 19, 19, 20, 19, 19, 19, 19, 18, 18,
19, 17, 12, 10, 10, 11, 11, 11, 11, 10, 11, 10, 10, 11, 11, 11, 10, 9, 7, 7, 7,
8, 6, 7, 7, 7, 7, 7, 6, 8, 7, 7, 7, 5, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0,
1, -2, -8, -8, -7, -7, -8, -8, -8, -8, -7, -7, -8, -9, -8, -8, -7, -16, -27,
-28, -27, -27, -28, -28, -28, -28, -27, -27, -28, -28, -28, -28, -27, -30, -32,
-31, -31, -31, -31, -31, -32, -31, -31, -31, -31, -31, -31, -32, -30, -36, -41,
-41, -41, -41, -40, -41, -40, -42, -41, -41, -40, -41, -40, -41, -41, -42, -44,
-45, -43, -44, -44, -44, -44, -44, -44, -43, -44, -44, -44, -44, -43, -50, -54,
-53, -53, -54, -54, -54, -54, -53, -54, -53, -54, -53, -53, -54, -54, -59, -62,
-62, -62, -62, -62, -61, -61, -63, -61, -62, -62, -61, -61, -62, -62, -68, -71,
-72, -72, -71, -72, -72, -71, -70, -72, -71, -72, -71, -71, -71, -71, -72, -72,
-73, -72, -72, -73, -73, -73, -73, -73, -73, -73, -73, -73, -73, -73, -73, -78,
-80, -79, -79, -80, -79, -79, -79, -79, -79, -79, -79, -79, -79, -79, -80, -82,
-83, -82, -82, -82, -82, -82, -81, -82, -82, -82, -82, -81, -82, -82, -84, -85,
-85, -85, -84, -85, -85, -85, -85, -86, -85, -84, -86, -84, -84, -85, -85, -89,
-88, -88, -88, -88, -88, -88, -88, -88, -88, -88, -88, -88, -87, -88, -89, -91,
-91, -91, -92, -91, -90, -90, -91, -91, -91, -90, -91, -90, -92, -91, -93, -96,
-98, -97, -97, -96, -98, -96, -98, -96, -98, -96, -98, -97, -96, -99, -29, };