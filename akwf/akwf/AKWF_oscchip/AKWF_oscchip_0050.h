#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0050

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 7, 7, 7, 6, 7, 7, 7, 7, 6, 7, 6,
7, 7, 8, 12, 14, 15, 14, 15, 14, 15, 14, 13, 14, 14, 14, 14, 14, 14, 16, 22, 25,
25, 26, 26, 27, 26, 26, 26, 25, 26, 26, 26, 26, 26, 26, 28, 29, 29, 29, 29, 29,
29, 29, 29, 29, 29, 29, 29, 29, 29, 29, 30, 31, 31, 32, 32, 31, 31, 31, 31, 31,
31, 32, 31, 32, 31, 33, 40, 43, 42, 42, 43, 42, 43, 42, 42, 43, 42, 42, 42, 42,
41, 42, 48, 52, 52, 51, 52, 51, 52, 51, 52, 51, 51, 51, 51, 51, 52, 51, 60, 71,
73, 71, 72, 73, 73, 72, 72, 72, 72, 72, 72, 72, 72, 76, 83, 85, 85, 86, 85, 85,
86, 85, 85, 86, 85, 85, 85, 85, 85, 87, 95, 101, 100, 101, 100, 100, 100, 100,
100, 100, 100, 100, 100, 99, 100, 100, 103, 106, 106, 106, 105, 105, 106, 106,
106, 105, 106, 105, 105, 105, 105, 105, 104, 101, 101, 101, 101, 102, 102, 102,
101, 101, 101, 101, 101, 101, 101, 99, 95, 93, 93, 93, 93, 93, 93, 93, 93, 94,
93, 93, 94, 93, 93, 92, 83, 77, 78, 78, 78, 78, 77, 77, 78, 78, 78, 77, 78, 77,
78, 78, 72, 67, 65, 67, 66, 66, 66, 66, 66, 66, 66, 66, 66, 66, 66, 61, 51, 48,
49, 48, 49, 49, 49, 49, 49, 49, 49, 48, 49, 49, 49, 49, 49, 49, 49, 48, 49, 49,
49, 49, 48, 48, 48, 48, 48, 47, 51, 37, -47, -117, -116, -113, -114, -114, -114,
-114, -114, -114, -114, -114, -114, -114, -115, -115, -111, -107, -106, -106,
-107, -106, -106, -106, -107, -107, -106, -107, -107, -106, -107, -106, -104,
-103, -102, -102, -103, -103, -102, -103, -102, -102, -102, -102, -102, -102,
-103, -101, -97, -94, -95, -95, -95, -95, -94, -95, -94, -94, -95, -94, -94,
-94, -95, -94, -94, -92, -93, -92, -93, -92, -93, -93, -92, -93, -92, -93, -92,
-91, -92, -92, -91, -89, -88, -88, -88, -89, -89, -89, -88, -89, -87, -88, -87,
-88, -89, -87, -83, -82, -83, -82, -83, -82, -82, -82, -82, -82, -82, -82, -82,
-82, -82, -81, -75, -70, -70, -71, -70, -71, -70, -70, -70, -71, -71, -71, -70,
-70, -69, -71, -68, -66, -66, -67, -66, -66, -67, -67, -67, -66, -67, -66, -66,
-66, -67, -62, -54, -52, -54, -53, -52, -53, -53, -52, -53, -53, -53, -52, -53,
-52, -53, -52, -51, -50, -51, -51, -51, -51, -52, -50, -51, -50, -51, -51, -50,
-51, -51, -50, -44, -39, -40, -39, -39, -39, -39, -40, -39, -39, -39, -39, -39,
-40, -39, -39, -34, -28, -27, -28, -27, -28, -27, -28, -27, -28, -28, -28, -28,
-27, -28, -24, -14, -11, -11, -11, -10, -10, -10, -10, -11, -11, -10, -10, -11,
-10, -10, -9, -6, -3, -3, -2, -3, -3, -2, -3, -2, -3, -4, -3, -3, -2, -3, -1, };