#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0061

const PROGMEM int8_t DATA[DATA_LENGTH] = {26, 41, 37, 39, 38, 38, 37, 38, 38,
38, 37, 39, 38, 38, 38, 43, 61, 69, 68, 68, 68, 68, 68, 67, 68, 69, 68, 68, 68,
68, 68, 70, 81, 90, 90, 90, 90, 90, 90, 90, 90, 90, 90, 90, 91, 90, 90, 94, 100,
101, 100, 100, 100, 101, 101, 100, 100, 100, 100, 100, 101, 101, 99, 102, 107,
109, 110, 109, 109, 109, 109, 108, 109, 109, 109, 108, 109, 109, 108, 109, 112,
115, 115, 115, 115, 114, 115, 114, 115, 114, 115, 115, 114, 115, 115, 116, 118,
119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 118, 119,
118, 118, 118, 118, 118, 118, 118, 119, 118, 118, 118, 117, 118, 118, 118, 118,
118, 119, 118, 118, 118, 118, 118, 117, 117, 118, 118, 118, 117, 118, 118, 118,
118, 118, 117, 117, 117, 118, 118, 118, 117, 117, 117, 117, 117, 117, 116, 115,
116, 115, 115, 115, 115, 115, 115, 114, 114, 114, 115, 114, 114, 115, 112, 106,
106, 106, 105, 105, 106, 105, 105, 105, 105, 106, 105, 106, 105, 106, 103, 96,
92, 92, 92, 92, 92, 92, 91, 92, 93, 92, 92, 92, 92, 90, 73, 58, 57, 57, 57, 58,
57, 57, 57, 57, 57, 56, 57, 57, 57, 56, 47, 35, 32, 33, 33, 34, 33, 33, 33, 33,
33, 32, 32, 33, 33, 34, 23, 1, -8, -7, -7, -6, -6, -7, -6, -7, -7, -6, -6, -6,
-6, -6, -8, -19, -27, -26, -26, -26, -26, -26, -26, -26, -26, -26, -26, -26,
-26, -27, -38, -49, -51, -49, -50, -49, -50, -50, -50, -50, -50, -50, -49, -50,
-49, -51, -56, -68, -70, -69, -69, -69, -69, -69, -70, -70, -69, -70, -69, -70,
-69, -69, -72, -83, -87, -86, -86, -87, -86, -87, -86, -86, -86, -86, -86, -87,
-86, -86, -88, -94, -99, -100, -100, -100, -99, -99, -99, -99, -99, -99, -99,
-100, -99, -99, -102, -103, -103, -103, -103, -103, -103, -103, -104, -104,
-103, -104, -103, -104, -103, -102, -104, -107, -108, -107, -107, -107, -107,
-108, -107, -107, -107, -107, -107, -107, -107, -106, -107, -106, -107, -106,
-107, -106, -107, -107, -107, -107, -107, -106, -106, -107, -107, -107, -106,
-107, -106, -107, -106, -107, -106, -107, -106, -106, -106, -106, -106, -106,
-106, -106, -106, -106, -105, -106, -106, -106, -106, -106, -106, -106, -106,
-106, -106, -106, -106, -105, -106, -105, -106, -105, -106, -106, -105, -106,
-106, -105, -105, -106, -106, -105, -105, -105, -104, -105, -105, -105, -105,
-105, -106, -105, -105, -105, -105, -105, -106, -105, -105, -104, -104, -103,
-103, -103, -103, -103, -103, -103, -102, -102, -102, -103, -102, -102, -102,
-103, -100, -96, -95, -96, -96, -95, -96, -95, -95, -95, -96, -96, -96, -95,
-96, -96, -91, -81, -76, -76, -76, -75, -75, -76, -76, -75, -75, -75, -75, -76,
-76, -76, -72, -54, -40, -41, -41, -40, -41, -41, -41, -40, -40, -41, -41, -40,
-42, -38, -11, };