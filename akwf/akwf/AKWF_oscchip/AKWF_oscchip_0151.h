#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0151

const PROGMEM int8_t DATA[DATA_LENGTH] = {50, 82, 71, 77, 73, 75, 74, 75, 74,
74, 74, 75, 74, 74, 74, 74, 74, 74, 74, 73, 74, 74, 75, 75, 74, 73, 74, 73, 74,
74, 75, 78, 80, 80, 80, 80, 80, 80, 80, 79, 80, 79, 80, 80, 80, 80, 80, 80, 82,
82, 81, 82, 81, 82, 81, 82, 82, 81, 81, 82, 82, 82, 82, 81, 82, 81, 82, 81, 82,
81, 82, 81, 82, 82, 81, 81, 81, 82, 82, 82, 82, 81, 82, 81, 82, 82, 81, 82, 81,
82, 81, 82, 82, 82, 81, 81, 82, 82, 82, 82, 82, 82, 82, 81, 82, 81, 82, 81, 82,
81, 82, 82, 82, 81, 82, 82, 81, 82, 82, 82, 81, 82, 82, 81, 81, 82, 81, 81, 81,
81, 82, 81, 81, 81, 82, 82, 82, 82, 81, 82, 81, 82, 82, 82, 81, 82, 81, 81, 82,
81, 81, 81, 81, 82, 82, 82, 82, 81, 81, 66, 55, 56, 56, 56, 56, 55, 56, 55, 56,
56, 56, 56, 55, 55, 55, 62, 71, 70, 71, 70, 70, 70, 70, 70, 70, 70, 71, 70, 70,
71, 70, 74, 84, 86, 85, 86, 85, 85, 84, 85, 85, 85, 85, 85, 85, 86, 83, 64, 55,
56, 55, 56, 55, 55, 56, 55, 56, 56, 56, 55, 55, 56, 54, 34, 18, 19, 18, 19, 18,
18, 19, 19, 19, 18, 18, 19, 19, 18, 19, -9, -44, -45, -44, -44, -45, -44, -45,
-45, -45, -44, -44, -45, -44, -46, -43, -52, -66, -68, -66, -67, -66, -67, -66,
-67, -66, -68, -66, -66, -67, -66, -67, -72, -74, -74, -74, -74, -75, -75, -74,
-75, -74, -75, -74, -74, -74, -75, -65, 37, 112, 104, 106, 104, 106, 106, 105,
106, 107, 105, 105, 106, 106, 106, 106, 108, 109, 109, 109, 109, 109, 109, 110,
109, 110, 110, 110, 109, 109, 109, 109, 104, 96, 94, 95, 94, 94, 94, 94, 95, 94,
95, 94, 95, 95, 95, 92, 80, 75, 77, 76, 76, 76, 76, 76, 76, 76, 77, 76, 76, 76,
76, 73, 53, 40, 42, 41, 41, 40, 41, 40, 41, 41, 41, 41, 40, 40, 40, 41, 31, 20,
20, 20, 20, 20, 20, 20, 20, 20, 20, 21, 20, 20, 20, 22, 14, 1, 1, 0, -1, 0, 0,
1, 0, 0, 0, 1, 0, -1, 0, -2, -10, -11, -11, -11, -12, -11, -11, -11, -11, -12,
-11, -11, -11, -12, -10, -12, -21, -27, -25, -27, -26, -26, -26, -26, -26, -26,
-26, -26, -26, -26, -26, -26, -37, -48, -48, -48, -49, -48, -48, -48, -48, -49,
-48, -48, -48, -47, -48, -49, -55, -66, -68, -66, -66, -66, -67, -67, -67, -66,
-66, -66, -67, -67, -66, -69, -79, -82, -81, -82, -81, -82, -81, -82, -81, -81,
-81, -81, -81, -82, -81, -84, -98, -109, -107, -108, -107, -108, -108, -108,
-108, -108, -107, -107, -108, -107, -108, -107, -113, -119, -119, -119, -119,
-118, -119, -119, -120, -119, -118, -119, -118, -119, -117, -121, -49, };