#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0092

const PROGMEM int8_t DATA[DATA_LENGTH] = {13, 101, 119, 112, 116, 113, 115, 114,
115, 114, 115, 114, 115, 114, 114, 114, 109, 103, 103, 102, 104, 104, 103, 103,
103, 104, 102, 103, 103, 103, 103, 103, 100, 98, 97, 98, 97, 97, 97, 97, 97, 97,
97, 98, 97, 98, 96, 98, 97, 97, 97, 97, 97, 97, 98, 97, 96, 97, 97, 97, 96, 97,
97, 97, 94, 92, 91, 92, 91, 92, 92, 91, 91, 91, 90, 91, 91, 91, 91, 92, 89, 86,
85, 85, 86, 86, 85, 85, 85, 85, 85, 86, 85, 85, 85, 86, 80, 62, 58, 59, 60, 59,
59, 59, 59, 59, 60, 59, 60, 59, 59, 59, 58, 56, 56, 56, 57, 56, 56, 57, 56, 56,
57, 56, 56, 57, 56, 57, 52, 45, 45, 44, 45, 45, 45, 46, 45, 45, 45, 45, 45, 44,
45, 45, 42, 29, 27, 28, 27, 27, 26, 27, 28, 28, 27, 28, 27, 27, 27, 27, 22, 15,
16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 17, 16, 16, 13, 4, 5, 5, 5, 5, 4, 4,
4, 4, 5, 4, 5, 5, 4, 4, -19, -30, -30, -30, -29, -30, -30, -30, -30, -30, -30,
-31, -30, -30, -29, -30, -21, -12, -13, -12, -12, -13, -13, -12, -13, -13, -13,
-13, -14, -11, -14, -11, -25, -49, -50, -49, -50, -50, -50, -50, -50, -50, -50,
-50, -49, -49, -50, -50, -50, -50, -49, -49, -51, -50, -50, -49, -49, -50, -50,
-50, -51, -50, -50, -49, -51, -52, -52, -53, -52, -52, -53, -52, -53, -52, -53,
-53, -52, -52, -52, -52, -57, -66, -67, -66, -67, -66, -66, -66, -67, -66, -67,
-67, -66, -67, -67, -65, -41, -27, -30, -29, -30, -29, -29, -29, -30, -29, -30,
-29, -29, -29, -30, -28, -38, -48, -46, -47, -46, -47, -46, -47, -46, -46, -47,
-47, -46, -46, -47, -48, -41, -29, -29, -29, -29, -30, -29, -29, -29, -29, -29,
-30, -29, -29, -29, -30, -45, -53, -52, -52, -51, -53, -52, -52, -52, -52, -52,
-52, -53, -52, -52, -53, -58, -63, -63, -63, -64, -64, -63, -63, -63, -64, -64,
-63, -63, -64, -62, -64, -60, -52, -51, -52, -51, -52, -52, -52, -51, -52, -52,
-51, -51, -52, -52, -51, -53, -55, -55, -54, -54, -55, -54, -54, -54, -54, -54,
-54, -55, -55, -54, -54, -51, -49, -49, -48, -48, -48, -49, -48, -49, -49, -49,
-48, -49, -49, -48, -49, -47, -46, -46, -46, -46, -46, -45, -45, -45, -46, -46,
-46, -45, -45, -46, -45, -51, -55, -54, -54, -54, -54, -54, -54, -54, -54, -54,
-55, -54, -55, -53, -56, -39, -22, -23, -22, -24, -23, -23, -22, -23, -23, -22,
-23, -23, -23, -22, -23, -20, -13, -14, -14, -14, -14, -15, -14, -14, -15, -15,
-14, -14, -14, -14, -14, -12, -11, -12, -11, -11, -11, -12, -11, -11, -11, -11,
-11, -12, -12, -11, -11, -12, -11, -11, -11, -11, -10, -11, -11, -12, -11, -11,
-11, -11, -10, -12, -11, };