#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0138

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 1, 2, 2, 2, 2, 2, 2, 1, 2, 1, 2,
1, 1, 1, 3, 3, 4, 4, 3, 3, 3, 4, 3, 3, 3, 3, 4, 4, 4, 3, 3, 3, 3, 3, 3, 4, 3, 3,
3, 3, 4, 3, 3, 3, 4, 4, 3, 4, 3, 3, 3, 3, 4, 4, 3, 4, 3, 4, 4, 4, 3, 3, 3, 3, 4,
3, 3, 4, 3, 4, 4, 4, 4, 3, 4, 4, 4, 4, 5, 5, 5, 5, 6, 5, 5, 6, 5, 5, 5, 5, 5, 5,
5, 5, 6, 7, 7, 7, 8, 7, 7, 7, 6, 7, 7, 7, 7, 8, 7, 8, 11, 13, 12, 13, 12, 12,
12, 12, 12, 12, 12, 13, 12, 13, 12, 13, 13, 15, 14, 14, 13, 14, 14, 14, 14, 13,
13, 14, 14, 14, 13, 17, 30, 35, 32, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33,
33, 37, 68, 86, 83, 84, 83, 84, 83, 83, 84, 83, 85, 83, 85, 82, 85, 0, -110,
-114, -111, -112, -111, -112, -112, -112, -112, -112, -111, -112, -111, -113,
-112, -112, -112, -111, -111, -112, -112, -112, -112, -112, -111, -112, -112,
-112, -112, -112, -112, -108, -95, -91, -91, -91, -91, -91, -91, -90, -91, -91,
-91, -91, -91, -90, -91, -87, -61, -45, -49, -47, -47, -48, -47, -47, -47, -47,
-47, -47, -48, -47, -47, -38, -26, -26, -26, -26, -26, -26, -25, -26, -26, -26,
-26, -26, -27, -26, -27, -22, -15, -13, -15, -14, -14, -14, -14, -14, -14, -14,
-14, -14, -14, -14, -14, -14, -11, -11, -11, -10, -11, -10, -11, -10, -11, -11,
-11, -10, -11, -10, -10, -10, -5, -3, -4, -3, -3, -3, -3, -4, -3, -4, -3, -4,
-3, -4, -3, -3, -1, -1, -1, -2, -2, -2, -1, -2, -2, -2, -2, -2, -3, -1, -2, -1,
0, 0, 1, 0, 0, 0, -1, 0, 0, 0, 1, 0, -1, 0, 0, 0, 2, 2, 2, 2, 2, 2, 1, 1, 2, 1,
2, 3, 2, 2, 1, 1, 2, 2, 1, 1, 2, 2, 3, 1, 1, 1, 1, 2, 2, 2, 2, -1, -3, -3, -4,
-3, -4, -3, -3, -4, -4, -3, -3, -4, -4, -3, -4, -4, -3, -4, -4, -3, -4, -3, -3,
-4, -3, -4, -3, -3, -3, -3, -3, -4, -5, -6, -5, -5, -5, -5, -5, -4, -5, -5, -5,
-5, -5, -6, -4, -5, -3, -2, -2, -2, -3, -2, -1, -2, -2, -2, -2, -1, -2, -2, -2,
0, 1, 0, 0, 0, 0, -1, -1, 1, -1, 1, 0, -1, 0, 0, 1, -1, -5, -5, -5, -6, -5, -5,
-6, -5, -5, -6, -6, -5, -6, -5, -5, -4, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0,
0, 1, 1, 0, 0, -1, 0, 1, 1, 0, 0, -1, 1, -1, -1, 0, 0, 0, -2, -4, -4, -3, -4,
-3, -3, -3, -4, -4, -4, -4, -4, -3, -4, -4, -2, };