#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0079

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 3, 2, 3, 2, 3, 3, 2, 3, 3, 3, 3,
3, 3, 3, 3, 3, 2, 2, 3, 3, 3, 3, 4, 2, 3, 2, 3, 2, 3, 2, 3, 3, 2, 3, 2, 4, 3, 3,
2, 3, 2, 4, 1, 5, -2, 44, 118, 116, 117, 116, 116, 116, 116, 116, 116, 117, 116,
116, 115, 116, 116, 116, 113, 112, 112, 113, 111, 112, 112, 112, 112, 113, 112,
112, 112, 112, 111, 107, 103, 104, 103, 104, 104, 104, 104, 104, 104, 103, 103,
104, 104, 104, 105, 99, 91, 91, 92, 92, 91, 91, 92, 91, 92, 92, 92, 92, 91, 91,
92, 90, 84, 83, 83, 83, 83, 84, 84, 83, 84, 83, 83, 83, 82, 83, 83, 79, 74, 75,
76, 75, 76, 75, 75, 75, 74, 75, 75, 75, 75, 74, 75, 73, 71, 70, 71, 70, 71, 70,
70, 70, 71, 70, 71, 70, 72, 69, 72, 56, 5, -3, -1, -4, -2, -3, -2, -3, -2, -3,
-2, -3, -3, -2, -2, 2, 7, 6, 6, 6, 6, 5, 5, 5, 5, 5, 5, 6, 5, 6, 5, 8, 14, 13,
14, 14, 13, 14, 14, 13, 14, 15, 13, 14, 13, 14, 13, 15, 17, 18, 17, 18, 17, 17,
18, 18, 17, 18, 17, 18, 17, 17, 18, 18, 18, 18, 18, 18, 18, 18, 18, 17, 18, 17,
18, 18, 18, 18, 17, 18, 17, 18, 18, 18, 17, 18, 18, 18, 17, 17, 18, 18, 17, 18,
18, 15, 14, 13, 13, 13, 13, 13, 14, 13, 14, 14, 14, 14, 13, 14, 14, 13, 13, 13,
13, 14, 13, 13, 13, 13, 14, 13, 13, 14, 14, 14, 14, 13, 13, 14, 13, 14, 13, 14,
14, 13, 13, 13, 14, 13, 13, 13, 14, 13, 14, 13, 13, 13, 13, 14, 14, 13, 13, 14,
13, 13, 13, 13, 14, 11, 10, 10, 10, 9, 10, 9, 9, 10, 9, 10, 9, 9, 9, 10, 9, 7,
1, 1, 1, 2, 1, 1, 1, 2, 1, 2, 1, 1, 1, 2, -2, -68, -101, -94, -97, -96, -96,
-95, -96, -96, -97, -95, -97, -96, -97, -96, -97, -87, -78, -79, -79, -80, -80,
-79, -79, -80, -81, -79, -80, -80, -79, -79, -79, -79, -75, -76, -76, -75, -76,
-75, -76, -75, -75, -75, -75, -75, -76, -75, -76, -76, -76, -75, -76, -76, -75,
-76, -76, -76, -76, -75, -75, -75, -75, -75, -75, -75, -75, -75, -75, -75, -75,
-74, -75, -75, -75, -75, -76, -76, -75, -76, -75, -77, -79, -79, -79, -79, -80,
-80, -79, -79, -78, -79, -78, -79, -79, -79, -79, -79, -79, -79, -79, -79, -79,
-80, -78, -78, -79, -80, -79, -78, -79, -79, -79, -80, -79, -80, -79, -79, -79,
-78, -78, -78, -78, -79, -78, -78, -78, -80, -79, -79, -79, -79, -79, -79, -78,
-79, -79, -79, -78, -78, -79, -79, -79, -79, -79, -79, -79, -78, -79, -78, -78,
-78, -78, -79, -78, -78, -79, -78, -79, -77, -80, -37, };