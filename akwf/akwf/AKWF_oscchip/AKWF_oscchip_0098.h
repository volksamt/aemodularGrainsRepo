#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0098

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 33, 31, 32, 32, 31, 33, 32, 33, 31,
33, 32, 32, 31, 34, 31, 42, 54, 54, 55, 54, 54, 55, 54, 55, 54, 55, 54, 55, 54,
54, 54, 55, 58, 59, 58, 58, 58, 58, 58, 58, 58, 59, 59, 59, 58, 58, 58, 68, 74,
72, 73, 73, 73, 74, 73, 73, 73, 73, 72, 73, 72, 73, 72, 81, 91, 90, 90, 89, 90,
89, 90, 89, 90, 90, 89, 89, 90, 90, 89, 90, 94, 94, 93, 94, 93, 93, 93, 93, 93,
93, 94, 93, 93, 93, 93, 93, 93, 93, 93, 94, 93, 94, 93, 94, 93, 93, 93, 93, 93,
93, 93, 92, 93, 93, 94, 92, 93, 93, 93, 92, 94, 94, 93, 93, 93, 92, 93, 92, 91,
90, 90, 91, 91, 90, 91, 91, 92, 90, 91, 91, 91, 91, 91, 90, 89, 90, 90, 88, 89,
89, 89, 89, 89, 89, 89, 90, 89, 88, 89, 87, 85, 85, 85, 84, 85, 85, 85, 85, 85,
85, 86, 84, 85, 84, 85, 83, 79, 80, 80, 79, 78, 80, 79, 79, 78, 79, 79, 80, 79,
79, 79, 77, 75, 75, 76, 75, 75, 75, 75, 75, 75, 76, 75, 75, 74, 75, 76, 71, 63,
63, 63, 64, 64, 64, 64, 64, 65, 63, 63, 63, 64, 64, 64, 62, 59, 60, 59, 59, 60,
60, 59, 60, 60, 60, 61, 59, 60, 60, 60, 46, 36, 37, 37, 37, 36, 37, 37, 37, 37,
37, 37, 38, 38, 37, 38, 26, 13, 13, 13, 13, 12, 12, 13, 13, 13, 13, 13, 12, 13,
12, 14, 6, -13, -14, -14, -14, -13, -13, -13, -14, -14, -14, -13, -14, -14, -14,
-14, -16, -18, -18, -17, -17, -17, -18, -17, -17, -17, -18, -17, -17, -17, -18,
-16, -33, -53, -51, -51, -51, -51, -50, -50, -52, -51, -51, -51, -51, -51, -51,
-53, -63, -66, -66, -67, -66, -66, -66, -66, -66, -66, -66, -67, -66, -66, -66,
-66, -73, -78, -77, -77, -78, -77, -77, -77, -77, -77, -77, -77, -77, -77, -78,
-76, -84, -93, -92, -93, -92, -92, -91, -91, -92, -92, -91, -92, -92, -91, -91,
-93, -94, -95, -96, -95, -96, -95, -95, -96, -95, -96, -95, -95, -95, -95, -96,
-96, -102, -107, -106, -107, -106, -106, -106, -106, -107, -107, -106, -106,
-106, -107, -106, -107, -108, -111, -110, -110, -110, -110, -110, -110, -110,
-109, -110, -111, -110, -110, -110, -110, -116, -117, -117, -117, -117, -117,
-117, -118, -117, -117, -117, -117, -117, -117, -117, -117, -118, -120, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -118, -119, -118, -119,
-114, -107, -107, -108, -108, -108, -108, -107, -108, -107, -107, -107, -108,
-107, -108, -106, -95, -92, -93, -93, -93, -91, -92, -92, -92, -92, -93, -92,
-92, -92, -91, -92, -83, -76, -77, -77, -77, -77, -77, -77, -77, -78, -77, -77,
-76, -78, -76, -77, -60, -38, -40, -39, -41, -39, -40, -39, -40, -39, -41, -38,
-40, -38, -41, -31, };