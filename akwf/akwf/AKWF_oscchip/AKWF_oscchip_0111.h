#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0111

const PROGMEM int8_t DATA[DATA_LENGTH] = {54, 120, 110, 115, 112, 114, 113, 113,
114, 113, 114, 113, 113, 113, 114, 114, 114, 113, 113, 113, 114, 113, 114, 114,
114, 113, 113, 113, 113, 114, 113, 113, 113, 113, 113, 114, 113, 113, 113, 113,
114, 114, 113, 113, 112, 113, 113, 113, 112, 110, 111, 110, 111, 109, 111, 110,
111, 109, 111, 109, 112, 107, 115, 76, -30, -43, -38, -41, -39, -41, -39, -41,
-39, -40, -39, -40, -39, -40, -40, -40, -38, -37, -37, -38, -37, -37, -37, -37,
-37, -37, -37, -36, -36, -36, -37, -36, -21, -12, -13, -13, -13, -13, -12, -13,
-12, -12, -12, -13, -12, -13, -12, -20, -43, -46, -46, -46, -45, -46, -45, -46,
-45, -46, -46, -46, -45, -46, -46, -47, -60, -64, -64, -63, -64, -64, -63, -64,
-63, -64, -63, -64, -63, -64, -63, -61, 16, 65, 55, 61, 58, 60, 58, 60, 59, 60,
59, 60, 59, 58, 59, 54, 37, 35, 36, 35, 35, 35, 36, 35, 36, 36, 35, 35, 35, 36,
35, 36, 41, 42, 42, 41, 41, 41, 42, 41, 41, 40, 41, 42, 41, 41, 41, 40, 43, 44,
44, 44, 44, 44, 44, 44, 44, 44, 44, 44, 44, 45, 44, 46, 50, 51, 50, 51, 50, 50,
50, 51, 50, 50, 50, 49, 50, 51, 50, 51, 57, 60, 59, 59, 58, 59, 59, 59, 59, 60,
58, 59, 58, 60, 58, 63, 68, 67, 68, 68, 68, 69, 67, 69, 68, 68, 68, 68, 67, 68,
67, 73, 90, 92, 92, 91, 92, 91, 92, 91, 92, 90, 92, 91, 93, 90, 96, 71, -72,
-118, -105, -112, -107, -111, -108, -110, -107, -109, -108, -110, -109, -109,
-110, -105, -99, -100, -101, -101, -100, -99, -100, -100, -100, -100, -100, -99,
-101, -99, -101, -97, -92, -90, -91, -91, -91, -91, -92, -91, -91, -90, -91,
-91, -90, -91, -91, -91, -90, -91, -91, -92, -91, -91, -90, -91, -91, -91, -92,
-90, -91, -91, -91, -84, -76, -76, -75, -76, -75, -76, -76, -75, -76, -75, -76,
-75, -76, -76, -75, -75, -73, -72, -73, -72, -72, -72, -72, -72, -73, -73, -72,
-73, -72, -73, -72, -72, -73, -72, -72, -72, -72, -72, -72, -72, -73, -72, -73,
-72, -72, -72, -72, -73, -73, -73, -72, -71, -73, -72, -72, -71, -73, -71, -73,
-70, -73, -70, -76, -47, 33, 45, 41, 42, 41, 42, 41, 42, 41, 43, 42, 42, 41, 43,
41, 45, 61, 68, 65, 66, 65, 66, 65, 66, 66, 65, 66, 66, 66, 65, 67, 53, 32, 32,
33, 33, 32, 32, 33, 33, 33, 32, 33, 32, 33, 32, 33, 31, 30, 29, 30, 30, 30, 29,
30, 29, 30, 29, 29, 29, 30, 29, 32, 19, -47, -70, -64, -67, -65, -67, -65, -66,
-66, -67, -66, -66, -66, -67, -65, -66, -66, -66, -67, -66, -65, -66, -65, -65,
-67, -67, -66, -66, -66, -66, -66, -64, -58, -56, -57, -57, -58, -57, -58, -57,
-58, -56, -58, -56, -58, -55, -59, -41, };