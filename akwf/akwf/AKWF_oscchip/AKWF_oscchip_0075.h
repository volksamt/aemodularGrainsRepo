#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0075

const PROGMEM int8_t DATA[DATA_LENGTH] = {26, 99, 109, 104, 106, 105, 107, 105,
107, 106, 106, 105, 106, 106, 106, 105, 106, 106, 106, 106, 105, 106, 106, 106,
106, 106, 105, 106, 106, 106, 105, 106, 106, 106, 105, 105, 106, 105, 106, 106,
106, 106, 105, 105, 106, 106, 106, 105, 105, 105, 106, 105, 105, 105, 105, 106,
105, 106, 105, 105, 106, 106, 105, 105, 106, 106, 106, 105, 104, 105, 105, 106,
105, 105, 105, 105, 105, 105, 105, 105, 105, 104, 104, 105, 105, 106, 106, 105,
105, 105, 104, 105, 105, 105, 105, 105, 105, 104, 105, 105, 105, 105, 105, 104,
105, 104, 105, 104, 105, 104, 105, 104, 104, 104, 105, 104, 105, 104, 104, 104,
103, 106, 103, 106, 101, 107, 100, 113, 23, -106, -100, -102, -100, -101, -101,
-101, -101, -100, -101, -101, -101, -101, -101, -101, -100, -99, -100, -98,
-100, -99, -100, -99, -99, -100, -100, -99, -99, -100, -99, -99, -98, -98, -98,
-97, -97, -97, -97, -97, -98, -98, -97, -97, -98, -97, -98, -96, -106, -119,
-118, -119, -118, -118, -118, -117, -118, -118, -118, -118, -118, -119, -118,
-116, -101, -95, -96, -95, -96, -95, -95, -96, -95, -95, -95, -95, -95, -95,
-94, -95, -93, -92, -91, -92, -92, -91, -92, -92, -91, -91, -92, -91, -91, -92,
-91, -92, -91, -88, -88, -88, -89, -88, -88, -87, -89, -88, -88, -88, -88, -88,
-88, -87, -85, -84, -84, -84, -84, -84, -85, -84, -85, -84, -84, -85, -84, -84,
-84, -84, -78, -73, -74, -74, -74, -74, -73, -74, -74, -74, -74, -73, -73, -74,
-74, -74, -69, -63, -63, -63, -63, -62, -63, -63, -63, -63, -62, -63, -63, -63,
-64, -61, -43, -38, -39, -38, -39, -39, -38, -39, -38, -38, -38, -38, -38, -39,
-38, -38, -30, -23, -24, -24, -24, -24, -25, -24, -24, -24, -24, -25, -23, -24,
-24, -25, -19, -10, -10, -10, -10, -11, -11, -10, -11, -10, -10, -10, -10, -10,
-11, -8, 1, 4, 3, 5, 4, 4, 3, 3, 4, 4, 3, 4, 4, 4, 4, 4, 15, 23, 22, 21, 21, 21,
21, 21, 21, 22, 22, 21, 22, 22, 22, 20, 27, 35, 35, 34, 35, 35, 35, 36, 35, 35,
36, 36, 35, 35, 36, 36, 39, 41, 41, 41, 41, 40, 41, 40, 41, 40, 41, 41, 41, 40,
40, 40, 36, 31, 32, 31, 31, 33, 31, 31, 32, 32, 32, 32, 32, 32, 32, 32, 26, 16,
16, 15, 16, 16, 16, 16, 16, 16, 15, 16, 16, 16, 16, 15, 7, 3, 5, 3, 4, 3, 3, 3,
4, 5, 4, 4, 4, 3, 4, 3, 0, -2, -1, -2, -2, -2, -1, -2, -2, -2, -2, -2, -1, -2,
-2, -3, -3, -3, -4, -3, -3, -4, -4, -3, -3, -3, -4, -3, -4, -4, -3, -3, -5, -5,
-5, -6, -4, -5, -5, -5, -5, -5, -6, -4, -6, -6, -6, -5, -2, 0, -1, 0, 0, 1, 0,
-1, -1, 0, 0, 0, 0, 0, 0, -2, };