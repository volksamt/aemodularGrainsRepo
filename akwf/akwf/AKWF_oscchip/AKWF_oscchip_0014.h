#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {14, 98, 95, 93, 95, 93, 95, 93, 95,
93, 95, 92, 95, 94, 95, 93, 73, 59, 62, 59, 61, 60, 60, 60, 61, 60, 59, 61, 59,
60, 59, 60, 60, 61, 59, 61, 59, 60, 60, 60, 60, 61, 60, 60, 60, 60, 60, 56, 31,
17, 20, 18, 20, 19, 20, 19, 19, 18, 19, 19, 19, 19, 20, 16, 0, -7, -6, -7, -7,
-8, -6, -8, -7, -7, -7, -7, -6, -7, -5, -15, -65, -84, -80, -80, -80, -81, -80,
-80, -81, -80, -81, -80, -81, -79, -82, -70, -20, -3, -8, -6, -7, -6, -7, -6,
-7, -6, -6, -6, -7, -7, -7, -6, -7, -7, -7, -6, -7, -6, -7, -6, -7, -6, -7, -6,
-6, -7, -6, -7, -6, -6, -7, -7, -7, -6, -7, -7, -7, -7, -7, -7, -6, -6, -7, -6,
-6, -6, -6, -7, -6, -6, -7, -6, -6, -6, -7, -6, -6, -6, -6, -6, -7, -7, -6, -7,
-6, -7, -6, -7, -6, -7, -7, -7, -7, -7, -7, -7, -7, -7, -6, -6, -6, -6, -6, -6,
-6, -7, -7, -6, -6, -7, -7, -6, -6, -6, -6, -7, -6, -6, -7, -6, -7, -6, -6, -6,
-6, -6, -7, -7, -6, -6, -6, -6, -6, -6, -7, -6, -6, -7, -6, -6, -6, -6, -6, -6,
-7, -7, -6, -6, -6, -7, -5, -6, -6, -6, -7, -6, -6, -6, -6, -7, -7, -7, -7, -6,
-6, -7, -6, -6, -7, -7, -7, -6, -6, -7, -6, -7, -4, -4, -5, -4, -5, -5, -5, -4,
-5, -5, -5, -4, -4, -4, -4, -6, -20, -27, -26, -27, -26, -27, -26, -27, -26,
-27, -26, -26, -26, -26, -26, -28, -44, -50, -48, -48, -49, -49, -48, -49, -48,
-49, -48, -48, -48, -48, -49, -47, -37, -33, -34, -33, -34, -33, -34, -33, -34,
-33, -34, -33, -33, -33, -34, -31, -16, -11, -12, -11, -12, -12, -12, -11, -12,
-11, -12, -11, -11, -11, -12, -7, 9, 13, 12, 12, 12, 13, 12, 13, 12, 13, 13, 13,
12, 12, 13, 12, 6, -4, -5, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4,
3, 12, 13, 12, 13, 14, 13, 13, 13, 13, 13, 13, 13, 13, 13, 13, 11, 9, 9, 9, 10,
10, 9, 10, 8, 9, 9, 9, 9, 9, 9, 9, -9, -28, -28, -27, -29, -28, -28, -27, -27,
-28, -28, -28, -27, -29, -27, -28, 8, 42, 39, 40, 40, 40, 41, 40, 41, 41, 40,
41, 41, 40, 41, 40, 72, 96, 94, 95, 94, 95, 94, 94, 95, 95, 94, 95, 94, 95, 94,
93, 43, 2, 8, 7, 7, 6, 7, 7, 6, 7, 6, 7, 7, 7, 7, 9, 34, 52, 50, 51, 50, 51, 51,
51, 51, 51, 51, 50, 51, 50, 51, 45, -9, -41, -33, -37, -35, -36, -35, -36, -34,
-36, -36, -36, -35, -36, -35, -41, -93, -120, -115, -116, -117, -116, -118,
-115, -118, -114, -119, -114, -119, -113, -125, -87, };