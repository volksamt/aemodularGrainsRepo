#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0149

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 19, 21, 20, 20, 21, 21, 20, 21, 20,
20, 20, 20, 21, 20, 26, 51, 63, 61, 62, 60, 61, 61, 62, 60, 62, 60, 61, 61, 61,
61, 62, 79, 90, 88, 89, 89, 89, 88, 89, 89, 89, 89, 88, 89, 89, 90, 89, 97, 106,
105, 106, 106, 105, 106, 105, 106, 105, 106, 106, 106, 106, 106, 106, 107, 110,
110, 109, 110, 109, 109, 110, 110, 110, 109, 109, 109, 109, 110, 107, 97, 94,
95, 94, 94, 95, 94, 95, 94, 95, 94, 95, 95, 94, 95, 93, 83, 75, 76, 75, 76, 76,
76, 76, 76, 76, 76, 76, 76, 76, 76, 76, 58, 40, 41, 40, 41, 41, 40, 41, 41, 41,
41, 41, 41, 41, 41, 41, 34, 21, 20, 21, 20, 20, 20, 20, 20, 21, 20, 21, 21, 20,
20, 17, 4, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, -1, -8, -12, -10, -11,
-11, -11, -12, -12, -12, -11, -11, -11, -11, -11, -11, -11, -19, -26, -26, -26,
-25, -25, -26, -26, -26, -27, -26, -26, -26, -26, -26, -26, -35, -48, -48, -49,
-49, -48, -48, -48, -48, -49, -48, -48, -48, -48, -48, -51, -63, -67, -67, -67,
-67, -66, -67, -67, -67, -66, -67, -67, -67, -67, -67, -68, -77, -82, -82, -82,
-81, -82, -81, -82, -81, -81, -82, -81, -82, -82, -81, -83, -96, -108, -108,
-108, -108, -108, -108, -108, -108, -107, -108, -107, -108, -107, -108, -108,
-112, -119, -119, -118, -118, -118, -118, -119, -118, -119, -119, -118, -119,
-119, -119, -112, -94, -88, -90, -88, -89, -89, -88, -89, -89, -89, -88, -89,
-89, -88, -89, -88, -83, -81, -83, -81, -81, -81, -82, -82, -81, -82, -82, -82,
-82, -82, -81, -82, -73, -67, -67, -67, -67, -67, -67, -66, -67, -66, -66, -68,
-66, -67, -67, -67, -50, -26, -25, -27, -25, -25, -26, -26, -25, -26, -26, -26,
-26, -25, -27, -21, -7, -3, -4, -3, -3, -3, -4, -3, -4, -3, -4, -4, -4, -3, -4,
-3, -1, 0, 0, 0, 0, 1, -1, 1, 0, 1, -1, 1, -1, 1, 1, 0, -1, -1, 0, 1, 0, -1, -1,
0, -1, -1, 0, 0, 0, 0, 1, 0, -2, -2, -2, -2, -2, -2, -2, -2, -1, -2, -1, -2, -2,
-2, -2, -2, -1, -1, -1, -2, -2, -2, -2, -2, -1, -2, -2, -2, -1, -2, -2, -1, -2,
-2, -2, -2, -2, -2, -2, -2, -2, -1, -2, -2, -1, -1, -2, -1, -2, -2, -2, -1, -2,
-2, -1, -2, -2, -2, -1, -3, -2, -2, -2, -2, -2, -1, -2, -1, -3, -2, -2, -1, -3,
-2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -1, -2, -2, -2, -1,
-1, -2, -1, -2, -2, -2, -1, -2, -2, -2, -1, -1, -1, -3, -1, -2, -2, -2, -2, -3,
-2, -1, -2, -2, -2, -2, -1, -2, -2, -3, -1, -2, -2, -2, -1, };