#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0096

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 2, 2, 2, 2, 2, 2, 2, 3, 2, 2, 3, 2,
3, 2, 4, 7, 8, 8, 7, 8, 8, 7, 8, 8, 8, 8, 7, 8, 9, 8, 11, 18, 20, 20, 20, 19,
19, 19, 19, 19, 20, 19, 21, 19, 20, 19, 29, 38, 37, 37, 37, 38, 38, 37, 38, 38,
38, 38, 38, 36, 38, 37, 44, 55, 55, 55, 55, 55, 55, 56, 56, 55, 55, 56, 56, 55,
54, 55, 55, 60, 61, 61, 61, 61, 61, 60, 61, 60, 61, 60, 61, 61, 62, 60, 68, 75,
74, 74, 75, 75, 75, 74, 74, 74, 74, 74, 74, 73, 75, 73, 84, 102, 101, 102, 102,
102, 102, 102, 102, 102, 102, 101, 102, 102, 101, 102, 106, 108, 108, 107, 108,
107, 107, 107, 108, 108, 108, 107, 107, 108, 107, 107, 105, 104, 104, 103, 103,
104, 104, 104, 103, 103, 103, 103, 103, 104, 103, 103, 101, 96, 96, 95, 96, 95,
95, 96, 95, 94, 95, 95, 94, 94, 95, 95, 84, 79, 80, 80, 79, 80, 79, 79, 80, 80,
80, 79, 80, 79, 79, 80, 71, 63, 63, 64, 64, 64, 63, 64, 63, 63, 64, 64, 64, 64,
63, 64, 56, 43, 44, 43, 44, 44, 44, 44, 44, 43, 44, 44, 44, 44, 43, 43, 33, 27,
28, 28, 28, 28, 28, 28, 28, 28, 27, 27, 27, 28, 27, 28, 19, 12, 13, 12, 13, 12,
12, 12, 12, 12, 12, 13, 12, 12, 12, 13, 7, -3, -3, -3, -3, -4, -4, -4, -3, -4,
-4, -3, -3, -4, -4, -4, -15, -20, -19, -20, -19, -20, -18, -20, -19, -20, -20,
-20, -20, -19, -20, -19, -32, -44, -42, -43, -43, -43, -43, -43, -43, -43, -43,
-43, -43, -43, -44, -42, -46, -54, -54, -54, -55, -55, -55, -54, -55, -55, -54,
-55, -55, -54, -54, -56, -64, -69, -67, -69, -68, -68, -68, -68, -68, -68, -68,
-68, -68, -67, -68, -69, -77, -86, -86, -86, -85, -86, -86, -85, -86, -86, -86,
-85, -86, -85, -86, -85, -92, -105, -106, -105, -105, -104, -105, -105, -105,
-105, -105, -105, -105, -105, -105, -105, -114, -119, -119, -118, -119, -119,
-119, -119, -119, -118, -119, -118, -119, -119, -118, -119, -118, -119, -118,
-118, -118, -119, -118, -119, -119, -119, -117, -119, -118, -119, -117, -119,
-108, -91, -91, -91, -91, -91, -91, -91, -91, -91, -90, -92, -91, -90, -91, -89,
-70, -60, -63, -61, -62, -61, -61, -61, -61, -61, -62, -60, -61, -62, -61, -62,
-52, -45, -45, -45, -45, -45, -45, -45, -45, -44, -46, -44, -45, -45, -46, -43,
-35, -33, -33, -33, -33, -33, -34, -33, -34, -34, -34, -33, -34, -34, -33, -33,
-24, -21, -21, -21, -21, -22, -21, -22, -22, -22, -22, -22, -22, -21, -22, -21,
-18, -15, -15, -15, -15, -15, -15, -16, -15, -16, -16, -16, -15, -16, -15, -15,
-11, -10, -10, -9, -10, -9, -10, -9, -10, -10, -9, -9, -10, -9, -9, -9, -2, };