#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0140

const PROGMEM int8_t DATA[DATA_LENGTH] = {15, 65, 71, 69, 70, 68, 70, 69, 70,
69, 70, 68, 70, 68, 70, 69, 78, 101, 108, 105, 107, 107, 106, 107, 107, 107,
106, 106, 106, 107, 107, 107, 114, 118, 118, 119, 118, 118, 118, 118, 118, 118,
118, 118, 117, 118, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119, 120,
120, 120, 119, 119, 119, 119, 118, 119, 118, 119, 119, 119, 119, 118, 119, 119,
120, 119, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119, 119, 118,
119, 120, 119, 119, 120, 119, 119, 118, 119, 118, 120, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 119, 120, 118, 116, 116, 116, 116, 117, 116, 115, 116, 116,
117, 116, 116, 117, 116, 116, 115, 113, 112, 112, 112, 113, 112, 112, 112, 112,
113, 113, 112, 112, 113, 110, 98, 89, 91, 89, 91, 91, 90, 90, 90, 90, 90, 90,
91, 90, 89, 89, 59, 33, 33, 34, 34, 33, 34, 34, 33, 34, 34, 34, 34, 34, 33, 35,
3, -43, -46, -45, -45, -44, -46, -45, -45, -45, -45, -45, -46, -44, -46, -44,
-60, -93, -101, -99, -100, -99, -99, -99, -99, -99, -99, -100, -99, -99, -99,
-101, -108, -112, -113, -113, -113, -112, -112, -113, -112, -113, -113, -112,
-112, -112, -112, -112, -114, -116, -117, -115, -116, -117, -117, -117, -116,
-117, -117, -117, -116, -117, -116, -116, -117, -116, -117, -116, -116, -116,
-116, -115, -116, -116, -116, -117, -117, -116, -117, -117, -116, -118, -118,
-118, -118, -118, -118, -118, -117, -118, -118, -119, -118, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118,
-118, -119, -118, -118, -116, -115, -116, -116, -116, -116, -116, -116, -117,
-116, -116, -116, -116, -116, -116, -116, -116, -116, -116, -117, -116, -116,
-116, -116, -116, -117, -116, -116, -116, -116, -116, -116, -114, -114, -114,
-114, -114, -115, -114, -115, -115, -114, -114, -114, -114, -114, -114, -111,
-111, -111, -111, -111, -110, -110, -110, -110, -111, -111, -110, -111, -110,
-111, -110, -104, -99, -99, -99, -99, -99, -100, -100, -100, -99, -100, -100,
-99, -99, -99, -99, -97, -94, -93, -94, -93, -94, -94, -94, -94, -93, -93, -94,
-94, -93, -93, -95, -93, -92, -93, -92, -92, -92, -92, -92, -93, -91, -92, -92,
-92, -92, -92, -93, -90, -84, -82, -83, -82, -82, -82, -82, -82, -82, -83, -82,
-83, -83, -82, -82, -75, -69, -69, -69, -69, -69, -69, -69, -70, -69, -70, -70,
-68, -69, -70, -69, -61, -51, -53, -53, -53, -52, -52, -52, -53, -52, -53, -53,
-52, -52, -53, -53, -48, -43, -41, -41, -42, -41, -41, -42, -41, -41, -41, -41,
-41, -41, -41, -42, -38, -30, -27, -28, -28, -28, -28, -28, -27, -29, -29, -29,
-28, -28, -28, -27, -20, -15, -15, -16, -15, -14, -16, -15, -15, -14, -15, -15,
-16, -15, -16, -13, };