#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0045

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 1, 1, 0, 2, 1, 0, 1, 0, 1, 0, 1,
1, 1, 2, 4, 5, 6, 5, 6, 5, 5, 5, 5, 6, 5, 5, 5, 6, 6, 5, 5, 5, 5, 6, 5, 4, 6, 6,
6, 6, 6, 6, 5, 6, 5, 5, 7, 8, 9, 10, 9, 9, 9, 10, 9, 9, 9, 9, 9, 9, 9, 9, 10, 9,
10, 9, 10, 9, 10, 10, 10, 10, 10, 9, 9, 10, 9, 10, 10, 10, 10, 10, 9, 9, 9, 10,
10, 9, 10, 10, 9, 9, 9, 14, 42, 60, 58, 58, 58, 58, 59, 59, 58, 59, 59, 58, 58,
58, 57, 36, 10, 8, 9, 9, 10, 9, 9, 9, 10, 10, 9, 9, 9, 9, 9, 9, 9, 10, 9, 9, 9,
9, 9, 10, 9, 9, 9, 9, 8, 10, 8, 9, 9, 9, 9, 9, 9, 10, 9, 9, 9, 8, 10, 9, 10, 9,
9, 10, 9, 8, 9, 10, 9, 9, 10, 9, 9, 9, 9, 9, 9, 9, 9, 8, 10, 9, 9, 9, 9, 8, 9,
9, 8, 9, 9, 9, 8, 9, 8, 8, 5, 4, 5, 5, 5, 5, 5, 5, 4, 5, 5, 5, 4, 5, 5, 5, 4, 5,
6, 5, 5, 4, 5, 5, 4, 4, 5, 5, 5, 4, 5, 5, 5, 4, 6, 5, 4, 5, 5, 4, 5, 4, 5, 5, 5,
6, 0, -55, -114, -116, -114, -114, -114, -115, -115, -114, -115, -114, -115,
-115, -115, -114, -114, -74, -9, 5, 0, 1, 0, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, -1,
-3, -4, -4, -4, -3, -4, -3, -3, -3, -3, -2, -3, -4, -3, -4, -8, -12, -12, -11,
-11, -12, -12, -12, -11, -12, -11, -12, -12, -11, -12, -11, -11, -11, -12, -12,
-11, -11, -12, -11, -11, -11, -12, -11, -12, -11, -11, -11, -11, -12, -12, -11,
-11, -11, -12, -10, -11, -12, -12, -12, -11, -11, -12, -11, -10, -8, -7, -8, -7,
-7, -7, -8, -7, -7, -7, -7, -7, -7, -7, -7, -6, -7, -7, -7, -7, -8, -7, -8, -7,
-7, -7, -7, -7, -6, -7, -7, -8, -7, -7, -8, -7, -7, -7, -7, -7, -7, -7, -6, -7,
-7, -8, -6, 19, 54, 60, 59, 59, 58, 60, 59, 59, 58, 59, 59, 60, 59, 60, 43, 4,
-10, -7, -7, -7, -7, -7, -7, -7, -7, -8, -6, -7, -7, -7, -8, -8, -7, -8, -7, -7,
-8, -8, -7, -8, -6, -7, -7, -8, -7, -7, -7, -8, -8, -8, -8, -8, -8, -8, -6, -7,
-7, -7, -8, -8, -7, -7, -8, -7, -7, -7, -8, -7, -7, -7, -8, -7, -7, -7, -7, -7,
-7, -7, -6, -4, -2, -3, -4, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -4, -3,
-3, -3, -3, -3, -4, -3, -3, -3, -3, -2, -4, -3, -3, -2, -3, -3, -3, -3, -3, -3,
-3, -3, -3, -3, -3, -3, -4, -3, -3, -2, -3, -1, };