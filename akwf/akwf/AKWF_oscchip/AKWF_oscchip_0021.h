#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {54, 89, 78, 84, 80, 83, 81, 83, 81,
83, 82, 82, 82, 82, 82, 82, 82, 82, 82, 81, 82, 82, 81, 82, 82, 82, 82, 81, 83,
82, 82, 81, 83, 82, 82, 82, 82, 83, 81, 82, 82, 83, 82, 82, 81, 82, 82, 82, 82,
81, 82, 82, 82, 82, 81, 81, 82, 83, 82, 81, 82, 81, 82, 81, 81, 82, 81, 81, 82,
81, 81, 82, 81, 81, 82, 81, 82, 82, 82, 81, 81, 81, 82, 81, 82, 82, 81, 82, 82,
81, 81, 82, 81, 82, 81, 81, 81, 81, 81, 81, 82, 81, 81, 81, 81, 82, 81, 81, 81,
81, 81, 81, 81, 81, 82, 81, 81, 81, 81, 81, 81, 81, 81, 80, 81, 81, 81, 81, 82,
81, 81, 81, 81, 81, 80, 81, 81, 80, 80, 81, 81, 81, 81, 81, 81, 81, 81, 81, 81,
81, 80, 81, 81, 81, 81, 81, 80, 80, 81, 81, 80, 81, 80, 80, 81, 80, 81, 80, 80,
80, 81, 80, 80, 80, 80, 80, 80, 81, 80, 80, 80, 80, 80, 80, 81, 80, 80, 80, 81,
80, 80, 80, 81, 80, 81, 81, 80, 80, 81, 81, 80, 81, 81, 80, 80, 80, 80, 80, 80,
80, 80, 80, 80, 80, 80, 80, 80, 80, 80, 81, 80, 80, 80, 80, 80, 80, 79, 80, 81,
80, 80, 79, 80, 79, 81, 79, 81, 78, 85, 38, -89, -119, -112, -115, -112, -114,
-113, -113, -112, -114, -112, -114, -113, -113, -113, -114, -113, -114, -113,
-113, -113, -113, -114, -113, -113, -113, -114, -113, -114, -114, -113, -114,
-113, -114, -114, -113, -113, -113, -113, -112, -113, -114, -114, -114, -113,
-113, -113, -113, -113, -113, -112, -113, -113, -113, -113, -113, -113, -113,
-113, -113, -114, -113, -113, -113, -114, -113, -113, -113, -113, -113, -113,
-114, -113, -113, -113, -112, -112, -112, -112, -113, -113, -113, -113, -112,
-113, -113, -113, -113, -112, -112, -112, -112, -112, -113, -112, -112, -113,
-113, -113, -112, -112, -112, -113, -112, -112, -113, -112, -112, -113, -113,
-113, -109, -24, 28, 18, 22, 21, 21, 21, 21, 21, 21, 21, 21, 21, 22, 21, 15,
-69, -121, -110, -113, -112, -113, -111, -113, -112, -112, -112, -111, -112,
-112, -113, -102, -29, 10, 3, 6, 4, 5, 4, 5, 4, 5, 4, 5, 4, 4, 5, 5, 2, 2, 2, 1,
2, 2, 3, 2, 2, 1, 3, 2, 2, 2, 1, 2, -2, -3, -3, -3, -2, -2, -3, -2, -2, -3, -2,
-3, -3, -3, -2, -5, -14, -17, -16, -16, -17, -16, -17, -16, -16, -17, -16, -16,
-17, -16, -16, -23, -42, -47, -46, -47, -46, -46, -46, -47, -47, -46, -46, -47,
-47, -46, -46, -47, -49, -49, -49, -49, -49, -49, -50, -50, -49, -50, -49, -50,
-49, -50, -48, -64, -106, -114, -111, -112, -111, -113, -111, -112, -111, -112,
-111, -111, -111, -112, -111, -111, -110, -112, -111, -111, -111, -112, -112,
-111, -112, -111, -111, -110, -112, -109, -117, -54, };