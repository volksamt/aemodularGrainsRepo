#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0059

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 3, 2, 3, 2, 2, 2, 3, 2, 2, 2, 2, 2,
3, 2, 3, 2, 2, 2, 2, 3, 3, 2, 2, 2, 2, 3, 3, 2, 2, 3, 48, 109, 120, 115, 117,
116, 116, 117, 117, 116, 117, 117, 116, 116, 116, 117, 114, 111, 109, 109, 109,
109, 109, 109, 109, 109, 109, 108, 109, 108, 110, 103, 77, 62, 63, 64, 64, 63,
64, 64, 64, 64, 64, 63, 64, 63, 64, 62, 50, 40, 41, 41, 41, 40, 41, 41, 40, 41,
40, 40, 40, 41, 41, 40, 34, 25, 24, 24, 23, 24, 24, 24, 24, 24, 23, 24, 24, 24,
23, 21, 16, 14, 14, 14, 15, 14, 14, 14, 14, 14, 15, 14, 14, 14, 14, 14, 11, 9,
9, 9, 8, 9, 8, 9, 8, 9, 8, 8, 8, 8, 9, 8, 6, 5, 5, 4, 4, 5, 6, 4, 5, 5, 4, 4, 4,
5, 5, 3, -39, -91, -99, -95, -97, -96, -96, -96, -96, -96, -97, -97, -96, -96,
-97, -92, -83, -80, -81, -82, -82, -81, -82, -81, -81, -81, -81, -81, -81, -81,
-82, -76, -60, -50, -51, -51, -51, -52, -51, -51, -52, -52, -51, -52, -51, -51,
-52, -50, -42, -37, -36, -36, -35, -36, -36, -36, -36, -36, -36, -35, -36, -37,
-36, -35, -22, -6, -5, -6, -5, -5, -6, -6, -6, -5, -7, -5, -5, -6, -5, -4, 0, 0,
0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1,
1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, -1, 1, 0,
0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
1, 0, 0, 1, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0,
0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 1, -1, 0, 1, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, -1, 0, 0, 1, 1, 0, 0, 0,
0, -1, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0,
0, 1, 1, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 1, 1, 1, -1, 1, 0, 1, 0, -1, 0, 0, 1, 0,
0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 1, 1, 0, 0,
0, 0, -1, 0, 0, 1, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, -41, -103, -117, -113, -114,
-115, -114, -114, -114, -115, -113, -114, -113, -115, -114, -117, -87, -20, };