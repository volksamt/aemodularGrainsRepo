#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {15, 16, 15, 16, 15, 15, 14, 15, 15,
15, 15, 14, 15, 16, 15, 17, 18, 18, 19, 18, 19, 19, 19, 19, 18, 18, 19, 18, 19,
18, 19, 21, 23, 22, 22, 23, 22, 22, 22, 22, 22, 21, 22, 22, 22, 22, 22, 29, 33,
32, 32, 32, 32, 32, 32, 32, 33, 32, 32, 33, 32, 33, 33, 46, 53, 50, 52, 51, 52,
52, 51, 52, 51, 51, 51, 51, 51, 51, 51, 54, 57, 56, 56, 57, 56, 56, 57, 57, 56,
56, 56, 57, 56, 56, 57, 60, 62, 62, 62, 61, 61, 62, 61, 62, 62, 61, 61, 61, 62,
60, 62, 70, 74, 73, 73, 73, 73, 73, 73, 72, 74, 73, 72, 72, 73, 73, 72, 76, 84,
85, 85, 85, 85, 85, 84, 85, 84, 85, 84, 85, 85, 84, 85, 86, 90, 90, 90, 90, 89,
89, 89, 90, 90, 89, 89, 89, 89, 89, 89, 91, 95, 95, 94, 94, 94, 95, 95, 94, 94,
94, 94, 94, 93, 94, 94, 94, 94, 95, 93, 94, 93, 94, 94, 93, 94, 94, 93, 93, 94,
93, 93, 91, 88, 88, 88, 89, 89, 88, 88, 88, 89, 88, 88, 88, 88, 88, 88, 68, 45,
45, 44, 45, 44, 45, 45, 44, 45, 45, 45, 45, 45, 44, 46, 25, 4, 5, 5, 5, 4, 5, 5,
5, 5, 6, 5, 5, 4, 5, 5, 23, 39, 37, 37, 37, 37, 37, 38, 37, 38, 37, 38, 38, 37,
38, 38, 37, 38, 38, 37, 37, 37, 38, 38, 37, 37, 37, 36, 38, 37, 37, 37, 32, 27,
27, 26, 27, 26, 26, 27, 27, 27, 27, 27, 27, 27, 26, 26, 24, 23, 24, 23, 23, 24,
23, 23, 23, 23, 23, 23, 23, 22, 24, 23, 21, 19, 20, 20, 20, 19, 21, 19, 20, 19,
20, 19, 20, 19, 22, 7, -79, -120, -112, -116, -113, -115, -115, -115, -114,
-115, -114, -115, -115, -115, -115, -114, -115, -115, -115, -114, -113, -115,
-115, -114, -114, -114, -115, -115, -114, -114, -115, -114, -113, -114, -113,
-114, -115, -113, -114, -114, -114, -113, -114, -114, -114, -114, -113, -114,
-114, -114, -114, -114, -113, -114, -114, -113, -113, -113, -113, -113, -113,
-113, -113, -114, -113, -113, -113, -113, -113, -113, -113, -113, -113, -114,
-113, -113, -112, -114, -112, -113, -90, -53, -52, -53, -53, -52, -52, -51, -53,
-53, -52, -52, -53, -51, -53, -51, -78, -112, -112, -112, -112, -113, -112,
-112, -112, -112, -112, -112, -111, -113, -110, -116, -38, 52, 46, 49, 48, 49,
48, 49, 48, 48, 49, 48, 48, 48, 49, 48, 48, 46, 47, 47, 48, 46, 46, 47, 46, 47,
47, 47, 46, 48, 46, 44, -40, -116, -110, -113, -111, -112, -111, -112, -111,
-112, -112, -111, -112, -112, -112, -112, -111, -111, -112, -112, -112, -111,
-112, -111, -112, -112, -112, -112, -111, -111, -111, -111, -112, -111, -112,
-111, -112, -111, -111, -111, -111, -111, -112, -110, -111, -110, -112, -102,
-32, };