#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0129

const PROGMEM int8_t DATA[DATA_LENGTH] = {81, 120, 106, 114, 109, 114, 109, 113,
110, 112, 110, 112, 111, 112, 112, 110, 100, 96, 97, 97, 97, 96, 96, 96, 96, 96,
96, 96, 97, 96, 98, 95, 83, 76, 77, 77, 76, 76, 77, 77, 77, 77, 77, 76, 77, 76,
77, 69, 58, 57, 57, 57, 57, 57, 58, 57, 56, 57, 57, 57, 57, 57, 57, 53, 46, 44,
45, 44, 44, 44, 44, 45, 44, 45, 45, 44, 45, 45, 45, 39, 20, 11, 13, 13, 12, 13,
12, 13, 12, 12, 12, 13, 13, 12, 13, 11, -1, -8, -8, -8, -8, -8, -7, -7, -7, -8,
-8, -7, -7, -8, -8, -13, -20, -19, -20, -19, -20, -19, -19, -20, -20, -19, -19,
-19, -20, -20, -19, -23, -29, -30, -29, -30, -29, -30, -30, -30, -30, -30, -29,
-29, -29, -30, -29, -30, -34, -35, -34, -35, -35, -35, -34, -34, -35, -35, -35,
-35, -34, -34, -35, -35, -34, -35, -35, -34, -35, -35, -35, -35, -35, -35, -34,
-35, -35, -35, -35, -28, -20, -20, -20, -19, -20, -20, -21, -19, -20, -19, -19,
-19, -20, -19, -21, -14, -2, 1, 0, 0, 0, 1, 0, -1, 0, 0, 0, 1, -1, 0, -1, 2, 8,
11, 10, 10, 9, 10, 10, 10, 10, 10, 10, 10, 10, 10, 11, 11, 18, 23, 21, 23, 22,
22, 22, 22, 22, 22, 22, 23, 22, 23, 23, 25, 27, 27, 28, 27, 27, 27, 27, 28, 28,
27, 28, 28, 27, 27, 27, 28, 26, 28, 27, 28, 27, 28, 28, 27, 28, 28, 28, 27, 27,
27, 27, 25, 22, 19, 19, 20, 19, 20, 20, 19, 20, 20, 19, 20, 19, 20, 21, 18, 9,
4, 5, 5, 5, 5, 5, 4, 5, 5, 5, 5, 5, 5, 5, 2, -3, -2, -3, -2, -2, -2, -2, -2, -2,
-2, -2, -2, -2, -2, -2, -4, -9, -10, -9, -9, -10, -10, -10, -10, -10, -10, -10,
-10, -10, -9, -9, -12, -18, -21, -20, -20, -20, -20, -20, -20, -20, -20, -20,
-20, -20, -19, -19, -20, -22, -23, -23, -22, -22, -23, -22, -22, -22, -22, -23,
-22, -23, -23, -22, -23, -25, -25, -25, -25, -25, -25, -25, -25, -24, -24, -25,
-25, -24, -25, -24, -24, -23, -22, -22, -22, -22, -22, -22, -22, -22, -22, -23,
-22, -22, -22, -23, -17, -4, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 2, 9, 13,
12, 13, 13, 13, 12, 13, 12, 12, 13, 13, 12, 12, 12, 12, 13, 12, 13, 12, 13, 12,
13, 12, 12, 12, 13, 12, 12, 12, 12, 10, 5, 6, 4, 5, 5, 4, 5, 5, 5, 5, 5, 5, 4,
5, 6, 3, -3, -5, -5, -5, -5, -6, -5, -5, -4, -5, -5, -6, -5, -5, -5, -7, -18,
-23, -22, -23, -23, -23, -22, -23, -22, -23, -21, -23, -22, -23, -23, -63, -100,
-99, -98, -99, -99, -99, -99, -99, -98, -99, -99, -99, -98, -99, -97, -28, };