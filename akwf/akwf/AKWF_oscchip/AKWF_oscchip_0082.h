#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0082

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 14, 15, 14, 14, 14, 14, 14, 14, 14,
14, 15, 14, 14, 15, 14, 15, 17, 18, 17, 17, 16, 17, 17, 17, 17, 17, 17, 17, 16,
17, 15, 34, 56, 53, 55, 53, 54, 54, 54, 54, 54, 54, 53, 54, 54, 54, 53, 55, 56,
56, 56, 57, 56, 57, 57, 56, 56, 56, 57, 56, 56, 57, 57, 51, 30, 25, 26, 25, 27,
26, 26, 26, 25, 26, 26, 25, 26, 26, 25, 28, 31, 31, 30, 30, 30, 30, 31, 30, 30,
30, 31, 31, 30, 30, 31, 30, 30, 30, 31, 30, 31, 30, 31, 31, 30, 30, 30, 30, 30,
31, 30, 31, 30, 30, 30, 30, 30, 31, 31, 30, 30, 30, 30, 31, 30, 30, 30, 34, 38,
37, 37, 38, 38, 37, 37, 38, 36, 37, 37, 37, 37, 37, 38, 37, 37, 38, 38, 37, 37,
37, 37, 36, 38, 37, 37, 38, 37, 37, 38, 33, 14, 7, 9, 8, 9, 9, 10, 9, 9, 8, 9,
9, 9, 8, 9, 8, 6, 6, 7, 6, 6, 6, 6, 6, 7, 6, 7, 6, 6, 7, 7, 6, 5, 5, 4, 4, 4, 4,
4, 5, 4, 5, 4, 5, 4, 3, 5, 4, 0, -1, -1, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, -1,
-2, -2, -3, -3, -3, -2, -4, -3, -4, -2, -4, -2, -4, -1, -5, 1, -35, -112, -115,
-115, -115, -115, -115, -114, -116, -115, -116, -114, -115, -115, -115, -115,
-110, -83, -77, -78, -78, -77, -77, -78, -77, -78, -77, -78, -78, -77, -77, -78,
-57, -29, -31, -30, -30, -31, -30, -31, -31, -30, -31, -31, -30, -31, -30, -32,
-22, 1, 3, 2, 3, 2, 3, 2, 3, 1, 3, 2, 3, 2, 3, 2, 4, 14, 16, 17, 16, 16, 16, 17,
17, 17, 17, 17, 16, 16, 16, 17, 15, 13, 13, 13, 14, 13, 14, 14, 13, 15, 14, 15,
14, 14, 14, 14, 11, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 1, 0, 0, -24, -40,
-36, -38, -37, -38, -38, -38, -37, -38, -36, -38, -37, -38, -36, -39, -23, -4,
-5, -5, -4, -5, -5, -5, -5, -4, -4, -5, -4, -5, -4, -4, -6, -9, -9, -10, -9, -9,
-9, -9, -9, -10, -9, -10, -10, -9, -9, -9, -12, -14, -14, -14, -15, -14, -14,
-13, -14, -14, -14, -14, -14, -14, -13, -13, -16, -19, -19, -19, -19, -18, -19,
-18, -20, -19, -19, -19, -18, -18, -19, -18, -21, -26, -26, -25, -26, -25, -26,
-26, -26, -25, -25, -26, -26, -25, -26, -25, -25, -26, -25, -26, -25, -25, -26,
-26, -25, -25, -25, -26, -26, -25, -25, -25, -23, -19, -18, -19, -19, -18, -19,
-19, -19, -18, -19, -19, -19, -19, -18, -19, -15, -7, -6, -7, -7, -7, -7, -6,
-7, -6, -6, -7, -6, -7, -7, -7, -2, 0, 0, 0, 0, 0, 1, 0, 1, 0, -1, 0, -1, 0, 0,
1, };