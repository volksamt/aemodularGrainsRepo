#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0090

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0,
0, 0, 0, 0, 0, 0, 1, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 2, 1, 1, 2, 2, 1, 2, 1,
2, 2, 2, 2, 1, 1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 2, 2, 2, 2, 2, 1, 2, 2, 1, 1, 1,
1, 1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 4, 3, 4, 4, 3, 3, 3, 3, 4, 3, 4, 3, 4, 4,
3, 10, 21, 20, 20, 20, 20, 20, 20, 21, 20, 21, 20, 21, 20, 21, 20, 20, 20, 20,
20, 21, 20, 20, 20, 20, 20, 21, 20, 19, 20, 20, 20, 24, 27, 27, 27, 27, 26, 27,
27, 27, 27, 27, 27, 27, 27, 27, 28, 29, 32, 32, 33, 32, 32, 32, 32, 32, 33, 32,
32, 32, 32, 31, 34, 54, 62, 60, 61, 60, 61, 60, 60, 60, 61, 61, 61, 60, 60, 60,
60, 81, 94, 92, 94, 93, 93, 93, 94, 93, 94, 92, 93, 92, 94, 92, 96, 55, 0, 3, 1,
1, 2, 2, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 0, 1, 1, 2, 2, 1, 1, 1, 1,
1, 3, 3, 3, 3, 4, 3, 3, 2, 2, 3, 2, 3, 3, 4, 3, 3, -1, -6, -5, -5, -6, -6, -6,
-5, -5, -6, -6, -5, -6, -6, -5, -5, -6, -5, -5, -6, -5, -5, -6, -6, -5, -6, -6,
-6, -5, -5, -6, -6, -6, -5, -6, -6, -6, -6, -6, -5, -5, -6, -6, -5, -5, -6, -6,
-6, -7, -7, -7, -7, -6, -7, -7, -7, -8, -7, -7, -7, -7, -7, -7, -7, -6, -6, -5,
-6, -6, -6, -6, -5, -5, -6, -6, -5, -5, -5, -5, -5, -25, -42, -38, -40, -38,
-40, -39, -39, -38, -40, -38, -40, -38, -41, -37, -55, -109, -118, -115, -116,
-116, -116, -116, -117, -116, -116, -116, -116, -117, -116, -117, -111, -62,
-43, -48, -45, -47, -45, -46, -45, -46, -45, -47, -45, -46, -46, -45, -45, -23,
-6, -7, -6, -7, -6, -7, -8, -6, -6, -6, -7, -6, -7, -7, -7, -7, -7, -6, -6, -7,
-7, -8, -7, -7, -7, -7, -7, -6, -7, -8, -7, -3, -1, -2, -2, -2, -2, -2, -2, -2,
-1, -2, -2, -2, -2, -1, -1, -5, -7, -7, -7, -6, -6, -7, -7, -6, -7, -7, -6, -7,
-7, -7, -6, -6, -5, -6, -5, -5, -4, -5, -5, -4, -5, -5, -4, -6, -5, -5, -5, -1,
1, 0, -1, 1, -1, 0, 0, -1, 0, 0, 0, 0, 1, 0, 1, 1, 0, 0, -1, -1, 1, 0, -1, 0, 0,
0, 0, 0, 1, 0, -1, -2, -2, -1, -1, -2, -2, -2, -2, -2, -2, -2, -2, -2, -1, -2,
-2, -6, -7, -7, -6, -7, -7, -6, -7, -7, -7, -7, -7, -6, -7, -7, -6, -3, 1, 0, };