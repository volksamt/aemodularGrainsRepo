#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 3, 3, 3, 3, 2, 3, 3, 4, 2, 3, 2,
4, 1, 16, 81, 102, 95, 98, 96, 98, 96, 97, 97, 97, 97, 98, 97, 97, 97, 97, 97,
98, 97, 97, 97, 97, 98, 97, 97, 97, 97, 96, 97, 97, 97, 97, 97, 98, 97, 97, 96,
96, 96, 97, 97, 97, 96, 96, 96, 97, 96, 97, 96, 96, 96, 96, 96, 97, 96, 96, 96,
97, 96, 96, 96, 96, 97, 96, 96, 96, 96, 96, 96, 96, 96, 95, 96, 96, 96, 96, 95,
96, 95, 96, 95, 96, 95, 96, 96, 95, 96, 96, 96, 96, 94, 96, 95, 95, 94, 95, 95,
95, 95, 95, 95, 96, 95, 95, 94, 95, 95, 95, 94, 96, 95, 95, 95, 95, 94, 95, 94,
94, 94, 95, 94, 94, 94, 94, 94, 94, 94, 94, 95, 94, 94, 94, 93, 95, 95, 93, 94,
94, 94, 94, 94, 94, 94, 94, 95, 94, 94, 93, 93, 94, 93, 93, 94, 93, 94, 93, 94,
93, 93, 94, 94, 93, 94, 92, 94, 93, 94, 93, 93, 93, 93, 93, 93, 93, 95, 74, -57,
-121, -110, -115, -112, -114, -113, -115, -113, -115, -113, -114, -114, -113,
-113, -113, -110, -109, -109, -108, -108, -108, -108, -108, -109, -108, -109,
-108, -108, -108, -108, -106, -100, -98, -97, -98, -98, -98, -98, -98, -99, -98,
-98, -98, -98, -97, -98, -96, -87, -85, -84, -84, -85, -84, -85, -85, -84, -84,
-85, -84, -84, -83, -85, -80, -67, -63, -64, -63, -63, -64, -64, -63, -63, -64,
-63, -63, -63, -63, -64, -63, -63, -63, -64, -63, -64, -63, -64, -63, -63, -64,
-64, -63, -64, -64, -63, -62, -57, -56, -57, -56, -56, -56, -57, -56, -56, -57,
-56, -57, -57, -55, -57, -56, -55, -54, -55, -54, -55, -55, -54, -55, -54, -54,
-54, -55, -54, -55, -55, -54, -53, -53, -53, -53, -53, -53, -52, -52, -52, -53,
-53, -53, -53, -53, -52, -53, -52, -53, -52, -52, -53, -53, -52, -53, -52, -53,
-52, -52, -52, -52, -52, -53, -49, -49, -49, -49, -49, -49, -49, -48, -48, -49,
-49, -49, -48, -48, -48, -48, -48, -48, -47, -47, -46, -47, -47, -46, -47, -46,
-47, -47, -47, -46, -46, -47, -43, -42, -41, -42, -41, -42, -42, -42, -41, -42,
-42, -41, -41, -41, -41, -41, -37, -36, -36, -36, -37, -37, -36, -36, -37, -36,
-37, -36, -36, -36, -36, -37, -34, -33, -34, -33, -32, -33, -33, -33, -33, -32,
-33, -33, -33, -33, -33, -33, -32, -32, -31, -31, -31, -31, -31, -32, -31, -31,
-31, -31, -30, -31, -31, -31, -28, -27, -28, -27, -28, -27, -27, -28, -27, -28,
-27, -28, -28, -28, -28, -27, -22, -20, -21, -20, -21, -21, -21, -21, -20, -21,
-20, -20, -21, -21, -21, -19, -15, -13, -15, -14, -13, -14, -13, -14, -13, -14,
-14, -14, -14, -14, -14, -12, -8, -7, -7, -7, -8, -7, -7, -7, -7, -8, -8, -7,
-7, -7, -8, -4, };