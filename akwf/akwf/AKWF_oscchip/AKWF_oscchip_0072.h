#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0072

const PROGMEM int8_t DATA[DATA_LENGTH] = {77, 121, 110, 116, 111, 116, 113, 114,
113, 114, 112, 113, 113, 113, 113, 114, 112, 112, 112, 111, 112, 111, 113, 112,
112, 111, 112, 112, 112, 112, 112, 112, 111, 111, 110, 110, 110, 111, 111, 110,
111, 111, 111, 110, 111, 111, 111, 110, 108, 108, 108, 108, 107, 107, 108, 108,
107, 108, 107, 108, 107, 107, 108, 108, 105, 103, 103, 103, 104, 103, 103, 103,
102, 103, 103, 102, 104, 103, 103, 103, 99, 94, 95, 94, 95, 94, 95, 94, 95, 94,
94, 95, 95, 93, 95, 92, 81, 76, 78, 77, 78, 77, 78, 78, 77, 78, 78, 77, 77, 77,
78, 77, 62, 50, 52, 52, 52, 51, 52, 52, 52, 52, 52, 52, 51, 52, 52, 53, 39, 22,
25, 23, 23, 23, 24, 24, 24, 24, 24, 24, 24, 24, 25, 23, 8, 3, 4, 5, 4, 4, 4, 4,
4, 4, 4, 3, 4, 4, 4, 4, -2, -9, -6, -8, -7, -7, -8, -8, -8, -6, -7, -7, -8, -7,
-6, -6, -13, -20, -20, -20, -20, -20, -19, -19, -20, -19, -20, -20, -19, -19,
-19, -20, -24, -25, -26, -25, -25, -25, -25, -25, -25, -25, -25, -25, -25, -26,
-26, -26, -29, -33, -33, -33, -32, -32, -32, -32, -33, -33, -32, -32, -32, -32,
-32, -32, -33, -36, -34, -35, -35, -35, -35, -35, -36, -36, -34, -36, -35, -36,
-35, -36, -37, -38, -38, -38, -37, -38, -38, -38, -39, -38, -38, -38, -37, -38,
-37, -38, -39, -38, -40, -40, -39, -39, -39, -40, -39, -39, -39, -39, -38, -39,
-39, -38, -39, -39, -40, -39, -39, -39, -38, -39, -39, -39, -38, -39, -39, -39,
-39, -39, -40, -40, -40, -40, -40, -40, -40, -41, -40, -41, -40, -40, -41, -41,
-40, -40, -40, -41, -40, -40, -40, -40, -41, -40, -40, -40, -39, -41, -40, -40,
-40, -40, -40, -40, -40, -40, -40, -40, -40, -40, -40, -40, -40, -40, -41, -40,
-40, -40, -40, -41, -41, -42, -41, -41, -42, -42, -42, -42, -42, -41, -42, -42,
-41, -41, -41, -42, -41, -42, -42, -41, -41, -42, -42, -41, -41, -42, -41, -42,
-41, -42, -41, -41, -41, -41, -41, -41, -41, -41, -41, -41, -42, -42, -41, -41,
-42, -41, -41, -41, -41, -41, -41, -41, -41, -41, -41, -42, -41, -41, -40, -42,
-42, -41, -42, -42, -41, -41, -41, -41, -41, -42, -41, -41, -41, -41, -42, -42,
-41, -42, -41, -41, -41, -41, -42, -42, -41, -40, -41, -41, -41, -41, -41, -41,
-41, -41, -40, -38, -38, -38, -39, -38, -38, -38, -38, -38, -38, -38, -38, -38,
-37, -38, -38, -38, -38, -38, -38, -38, -37, -38, -38, -38, -37, -39, -38, -38,
-38, -38, -40, -39, -39, -39, -40, -39, -39, -40, -40, -39, -39, -39, -40, -39,
-40, -39, -41, -41, -40, -40, -41, -40, -41, -40, -40, -42, -40, -41, -40, -41,
-41, -41, -41, -41, -41, -41, -40, -40, -41, -40, -41, -41, -41, -41, -41, -41,
-42, -17, };