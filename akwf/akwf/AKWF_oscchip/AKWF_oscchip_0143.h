#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0143

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 1, 1, 2, 2, 2, 2, 2, 2, 1, 1, 3, 2,
2, 1, 2, 4, 4, 4, 4, 4, 4, 3, 3, 4, 4, 3, 4, 3, 4, 7, 63, 117, 113, 114, 113,
114, 114, 114, 115, 113, 113, 114, 114, 114, 115, 109, 100, 97, 99, 98, 100, 98,
99, 98, 99, 99, 98, 99, 99, 98, 99, 93, 75, 69, 71, 70, 71, 70, 70, 70, 70, 71,
70, 70, 70, 70, 71, 66, 34, 17, 21, 18, 20, 19, 20, 20, 20, 20, 20, 20, 20, 20,
19, 19, 13, 7, 8, 7, 8, 7, 7, 8, 7, 7, 7, 7, 8, 7, 8, 4, 1, 0, 1, 0, 0, 0, 0, 0,
0, 1, 0, -1, 0, 0, 1, 1, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0,
0, -1, 1, 0, 1, 1, 0, 0, 0, -1, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
0, 0, 1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -2, -3, -2, -2, -2, -2, -2,
-2, -2, -2, -1, -2, -2, -1, -2, -1, -2, -2, -2, -1, -2, -1, -1, -2, -2, -2, -2,
-2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -1, -2, -2, -2, -2, -2, -2, -2, -1, -2,
-2, -1, -1, -2, -2, -2, -2, -2, -1, -2, -1, -1, -2, -2, -1, -3, -2, -1, -3, -1,
-3, 1, -28, -100, -119, -113, -115, -115, -115, -115, -115, -115, -116, -115,
-115, -115, -114, -116, -109, -83, -69, -72, -72, -73, -71, -72, -72, -73, -71,
-72, -71, -72, -71, -72, -71, -59, -50, -50, -49, -50, -50, -51, -51, -51, -50,
-51, -50, -50, -50, -51, -44, -35, -34, -34, -34, -34, -33, -34, -34, -34, -34,
-34, -34, -35, -33, -35, -30, -20, -18, -18, -18, -18, -17, -18, -18, -17, -18,
-18, -18, -18, -18, -18, -15, -4, 1, 0, 0, -1, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 2,
18, 29, 29, 29, 28, 29, 29, 29, 28, 29, 28, 29, 29, 29, 28, 33, 39, 39, 39, 39,
40, 39, 39, 39, 39, 39, 39, 40, 40, 40, 38, 47, 64, 67, 66, 67, 66, 67, 66, 67,
66, 66, 66, 66, 67, 66, 67, 66, 66, 66, 66, 66, 67, 67, 67, 66, 67, 66, 67, 66,
66, 67, 66, 67, 65, 65, 64, 64, 64, 65, 65, 65, 64, 65, 64, 64, 64, 64, 65, 49,
28, 27, 27, 27, 27, 27, 27, 27, 27, 26, 27, 27, 27, 26, 28, 17, -9, -14, -12,
-12, -13, -12, -12, -13, -12, -12, -11, -13, -13, -13, -13, -17, -41, -50, -48,
-48, -48, -49, -48, -48, -48, -49, -49, -49, -49, -49, -48, -51, -77, -93, -91,
-93, -91, -92, -92, -91, -91, -91, -91, -91, -92, -91, -92, -96, -103, -103,
-102, -102, -103, -102, -103, -102, -102, -103, -103, -102, -103, -101, -105,
-72, -8, };