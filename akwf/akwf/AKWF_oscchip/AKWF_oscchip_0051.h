#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0051

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 8, 9, 9, 8, 10, 9, 9, 9, 8, 9,
9, 9, 10, 9, 10, 14, 18, 17, 16, 17, 17, 16, 16, 16, 17, 17, 16, 17, 17, 17, 25,
32, 34, 33, 33, 33, 33, 34, 33, 34, 33, 34, 33, 33, 33, 32, 37, 43, 44, 43, 44,
43, 44, 44, 43, 44, 43, 43, 43, 43, 44, 44, 46, 53, 56, 56, 55, 55, 56, 55, 55,
56, 55, 55, 55, 54, 55, 55, 56, 58, 60, 60, 60, 59, 60, 59, 59, 60, 60, 59, 59,
59, 60, 60, 59, 56, 57, 57, 56, 57, 57, 56, 56, 56, 57, 56, 56, 55, 56, 56, 54,
52, 50, 50, 49, 51, 51, 50, 51, 50, 51, 50, 50, 50, 50, 51, 48, 40, 38, 39, 38,
38, 38, 37, 38, 38, 38, 38, 38, 38, 39, 38, 32, 30, 28, 29, 29, 29, 29, 29, 28,
28, 28, 29, 30, 29, 29, 28, 23, 16, 14, 15, 14, 15, 15, 14, 15, 15, 15, 15, 15,
15, 15, 15, 15, 15, 15, 15, 15, 16, 15, 15, 15, 16, 15, 14, 15, 15, 14, 18, -4,
-74, -119, -114, -114, -115, -115, -115, -115, -115, -114, -114, -114, -115,
-114, -114, -111, -108, -109, -109, -108, -109, -108, -109, -108, -109, -108,
-108, -108, -108, -108, -108, -107, -105, -105, -105, -105, -105, -105, -104,
-105, -105, -106, -105, -105, -104, -105, -107, -78, -4, 29, 22, 24, 23, 23, 23,
24, 23, 24, 23, 23, 23, 23, 23, 23, 23, 22, 22, 22, 23, 22, 22, 22, 22, 22, 22,
22, 22, 22, 22, 21, 21, 21, 21, 20, 20, 20, 20, 21, 20, 21, 20, 20, 21, 21, 21,
19, 19, 19, 19, 19, 19, 19, 20, 19, 20, 19, 19, 18, 19, 19, 19, 19, 17, 16, 15,
16, 16, 17, 16, 15, 16, 15, 16, 15, 16, 17, 10, -36, -78, -78, -77, -78, -77,
-77, -77, -77, -77, -78, -78, -78, -77, -78, -77, -41, 8, 15, 11, 13, 14, 13,
12, 13, 13, 13, 12, 13, 12, 13, 13, 12, 10, 10, 11, 10, 9, 10, 10, 10, 10, 10,
10, 9, 10, 10, 10, 10, 10, 10, 10, 10, 10, 9, 11, 10, 10, 10, 10, 10, 10, 11, 8,
-18, -47, -48, -46, -48, -47, -47, -46, -47, -47, -47, -48, -47, -47, -47, -47,
-43, -35, -33, -33, -33, -34, -33, -34, -34, -33, -33, -34, -34, -34, -34, -34,
-32, -28, -28, -28, -27, -28, -28, -28, -27, -27, -27, -27, -28, -27, -28, -27,
-23, -20, -19, -19, -20, -21, -20, -20, -19, -20, -19, -20, -19, -20, -20, -20,
-17, -14, -14, -14, -14, -13, -14, -14, -14, -14, -13, -14, -14, -14, -13, -14,
-11, -6, -4, -5, -5, -5, -5, -4, -5, -5, -4, -4, -5, -5, -5, -5, -4, -2, -1, -2,
-2, -2, -2, -1, -2, -1, -2, -1, -1, -1, -1, -1, 0, 0, -1, 1, 0, 0, 0, 0, 0, -1,
0, 0, 1, 0, 0, 0, };