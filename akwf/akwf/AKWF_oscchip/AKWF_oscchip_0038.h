#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0038

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 4, 4, 5, 4, 4, 4, 4, 4, 5, 4, 5,
5, 5, 6, 9, 12, 12, 11, 12, 12, 11, 11, 12, 11, 12, 11, 11, 11, 11, 18, 25, 27,
27, 26, 26, 26, 26, 26, 26, 26, 27, 27, 26, 26, 27, 29, 36, 38, 38, 37, 38, 37,
38, 38, 37, 38, 37, 37, 37, 37, 37, 40, 50, 57, 56, 56, 56, 56, 56, 56, 56, 56,
55, 56, 56, 56, 56, 56, 58, 60, 59, 59, 60, 60, 59, 60, 59, 59, 59, 59, 59, 59,
60, 64, 72, 74, 73, 73, 74, 73, 73, 74, 74, 74, 74, 74, 74, 74, 73, 76, 82, 86,
85, 85, 84, 85, 84, 84, 85, 84, 84, 84, 84, 84, 85, 85, 88, 89, 89, 88, 88, 89,
88, 88, 88, 87, 88, 89, 88, 88, 88, 88, 92, 97, 97, 97, 97, 97, 97, 97, 97, 97,
96, 97, 96, 97, 96, 100, 106, 108, 108, 108, 108, 108, 107, 107, 108, 108, 108,
108, 107, 107, 107, 108, 106, 105, 105, 106, 105, 105, 106, 104, 105, 106, 106,
104, 105, 105, 106, 103, 97, 91, 90, 91, 90, 90, 90, 91, 90, 90, 91, 90, 90, 90,
89, 77, 60, 55, 57, 57, 57, 56, 57, 57, 57, 57, 57, 56, 57, 57, 57, 52, 41, 37,
38, 37, 37, 38, 38, 37, 38, 38, 38, 37, 38, 38, 38, 34, 25, 18, 19, 20, 19, 19,
19, 19, 19, 20, 19, 19, 19, 19, 19, 18, 9, 0, 1, 1, 1, 0, 0, 0, 1, 0, 1, 0, 1,
1, 1, -7, -16, -18, -17, -18, -17, -18, -18, -19, -17, -18, -18, -18, -18, -17,
-17, -29, -59, -72, -69, -70, -70, -70, -70, -70, -69, -70, -69, -70, -69, -69,
-70, -71, -83, -91, -90, -90, -90, -90, -89, -90, -90, -90, -90, -89, -90, -89,
-90, -102, -117, -118, -117, -117, -118, -117, -117, -118, -117, -117, -117,
-117, -117, -117, -117, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -118, -118, -117, -110, -107, -108, -107, -107,
-108, -108, -107, -107, -107, -108, -107, -107, -108, -108, -107, -101, -95,
-96, -96, -95, -97, -97, -96, -95, -95, -95, -95, -96, -96, -95, -92, -84, -85,
-84, -84, -84, -85, -85, -85, -84, -84, -84, -83, -85, -84, -84, -79, -66, -61,
-63, -61, -61, -61, -62, -61, -62, -61, -62, -62, -61, -62, -62, -61, -57, -54,
-54, -55, -55, -54, -54, -54, -54, -54, -54, -54, -54, -54, -54, -54, -51, -48,
-48, -48, -49, -49, -48, -48, -48, -48, -48, -48, -48, -48, -49, -46, -41, -41,
-40, -41, -40, -41, -41, -41, -40, -40, -41, -41, -40, -40, -40, -38, -31, -29,
-30, -30, -29, -29, -30, -30, -29, -28, -30, -29, -29, -29, -30, -28, -20, -16,
-16, -16, -16, -16, -17, -16, -17, -16, -16, -16, -16, -16, -15, -11, -4, -3,
-3, -3, -3, -3, -4, -4, -2, -3, -3, -3, -4, -3, -3, -1, };