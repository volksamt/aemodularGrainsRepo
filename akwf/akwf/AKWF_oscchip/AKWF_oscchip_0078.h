#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0078

const PROGMEM int8_t DATA[DATA_LENGTH] = {32, 56, 48, 52, 51, 51, 50, 52, 51,
52, 51, 50, 51, 50, 51, 52, 80, 95, 92, 94, 93, 94, 93, 93, 93, 94, 94, 93, 93,
94, 93, 97, 102, 103, 103, 103, 103, 103, 102, 103, 102, 103, 103, 103, 103,
102, 103, 103, 103, 102, 103, 102, 103, 103, 103, 103, 104, 103, 102, 102, 102,
103, 103, 102, 103, 102, 103, 103, 103, 103, 102, 102, 103, 102, 102, 103, 103,
103, 103, 103, 100, 100, 99, 100, 100, 100, 101, 100, 100, 100, 99, 100, 100,
99, 100, 99, 98, 98, 97, 98, 97, 98, 98, 97, 98, 97, 98, 97, 98, 98, 97, 98, 92,
89, 90, 91, 91, 90, 90, 90, 89, 89, 90, 89, 90, 90, 90, 90, 88, 88, 87, 87, 88,
87, 88, 88, 88, 88, 88, 87, 88, 88, 87, 87, 85, 85, 85, 85, 85, 85, 86, 85, 85,
84, 85, 85, 85, 85, 85, 83, 80, 79, 80, 80, 80, 80, 80, 80, 79, 81, 80, 79, 79,
80, 80, 79, 78, 78, 78, 77, 78, 78, 77, 78, 78, 77, 77, 78, 77, 77, 77, 77, 70,
67, 68, 68, 68, 67, 68, 68, 68, 67, 68, 68, 68, 68, 68, 64, 58, 58, 58, 59, 59,
59, 58, 58, 58, 59, 58, 58, 59, 59, 59, 54, 47, 46, 46, 46, 47, 46, 45, 46, 47,
46, 46, 46, 46, 46, 46, 45, 34, 31, 33, 32, 32, 32, 32, 31, 32, 32, 32, 32, 32,
31, 33, 22, 6, 6, 6, 6, 6, 6, 5, 6, 6, 6, 7, 5, 6, 5, 6, 3, -7, -9, -8, -8, -7,
-9, -8, -9, -9, -8, -8, -9, -9, -9, -8, -8, -11, -11, -11, -10, -10, -11, -11,
-11, -11, -11, -11, -11, -11, -10, -10, -15, -21, -21, -21, -20, -20, -20, -20,
-21, -21, -21, -20, -20, -20, -20, -20, -20, -20, -20, -20, -21, -20, -21, -20,
-20, -20, -21, -19, -21, -20, -21, -19, -30, -94, -112, -106, -109, -107, -108,
-108, -108, -108, -109, -107, -107, -107, -108, -107, -109, -111, -110, -111,
-109, -111, -110, -110, -110, -110, -111, -109, -110, -109, -109, -110, -112,
-115, -115, -114, -115, -115, -115, -115, -115, -114, -115, -114, -114, -114,
-114, -114, -114, -116, -117, -116, -117, -117, -116, -117, -116, -117, -117,
-117, -116, -116, -117, -117, -117, -119, -119, -119, -120, -119, -119, -118,
-118, -118, -119, -119, -118, -118, -119, -119, -117, -116, -116, -116, -116,
-116, -116, -116, -116, -116, -116, -116, -117, -115, -116, -116, -116, -117,
-116, -116, -116, -116, -116, -116, -116, -116, -116, -116, -115, -116, -116,
-115, -116, -116, -117, -116, -116, -116, -116, -116, -116, -115, -116, -115,
-116, -115, -115, -116, -116, -116, -115, -116, -115, -116, -116, -115, -115,
-115, -115, -115, -116, -116, -115, -115, -112, -111, -110, -110, -111, -110,
-111, -110, -111, -111, -110, -111, -110, -110, -110, -112, -96, -76, -78, -78,
-77, -77, -77, -78, -78, -77, -76, -78, -76, -78, -76, -82, -45, };