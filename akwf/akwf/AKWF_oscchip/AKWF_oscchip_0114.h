#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0114

const PROGMEM int8_t DATA[DATA_LENGTH] = {20, 99, 111, 107, 110, 108, 110, 108,
109, 108, 109, 108, 110, 108, 109, 109, 110, 108, 109, 108, 109, 108, 108, 109,
108, 109, 109, 108, 108, 109, 108, 109, 109, 109, 108, 109, 108, 109, 108, 108,
108, 108, 109, 108, 108, 108, 109, 108, 109, 108, 109, 109, 109, 108, 108, 108,
109, 108, 108, 108, 108, 108, 109, 109, 108, 108, 108, 108, 108, 108, 108, 107,
108, 108, 108, 109, 108, 108, 108, 107, 108, 108, 107, 108, 108, 108, 108, 107,
108, 107, 108, 108, 107, 107, 108, 107, 108, 108, 107, 108, 108, 108, 108, 107,
108, 107, 107, 107, 108, 108, 108, 108, 107, 108, 107, 108, 107, 107, 108, 107,
107, 107, 107, 108, 107, 107, 107, 108, 107, 107, 108, 108, 108, 107, 107, 107,
107, 107, 107, 108, 107, 106, 106, 107, 108, 107, 106, 107, 108, 107, 108, 107,
107, 107, 107, 107, 107, 107, 106, 107, 107, 107, 107, 106, 107, 107, 106, 107,
107, 107, 106, 106, 107, 106, 107, 106, 106, 106, 107, 106, 106, 106, 106, 107,
106, 107, 106, 106, 106, 106, 107, 106, 107, 106, 106, 106, 107, 106, 107, 106,
106, 106, 107, 106, 106, 106, 107, 106, 106, 106, 106, 107, 106, 106, 106, 107,
105, 107, 105, 108, 103, 108, 101, 113, 29, -104, -103, -107, -105, -105, -106,
-105, -106, -106, -107, -105, -106, -105, -106, -105, -99, -94, -96, -94, -95,
-94, -95, -95, -95, -95, -95, -95, -96, -95, -95, -96, -84, -73, -74, -74, -73,
-75, -74, -74, -74, -74, -74, -74, -74, -75, -74, -75, -70, -64, -63, -64, -63,
-64, -64, -64, -64, -63, -63, -64, -64, -64, -64, -63, -54, -49, -50, -50, -49,
-50, -50, -49, -49, -49, -49, -50, -50, -49, -49, -51, -44, -39, -39, -39, -38,
-39, -39, -39, -39, -38, -39, -39, -40, -39, -39, -40, -34, -25, -24, -24, -24,
-25, -25, -25, -24, -25, -24, -25, -25, -26, -25, -25, -19, -16, -16, -16, -17,
-16, -16, -16, -17, -16, -17, -16, -17, -15, -17, -16, -71, -120, -112, -117,
-115, -116, -114, -116, -115, -115, -116, -116, -115, -115, -115, -115, -115,
-115, -116, -114, -116, -115, -115, -115, -115, -115, -115, -115, -115, -115,
-115, -115, -115, -115, -115, -114, -115, -115, -116, -115, -115, -115, -114,
-115, -115, -115, -115, -115, -116, -115, -114, -115, -115, -114, -114, -114,
-115, -115, -115, -114, -114, -115, -115, -114, -114, -114, -115, -114, -114,
-115, -114, -114, -114, -115, -115, -115, -114, -114, -115, -114, -115, -115,
-114, -114, -114, -114, -114, -114, -115, -114, -115, -114, -114, -114, -114,
-114, -115, -114, -114, -115, -114, -114, -114, -113, -113, -114, -114, -114,
-114, -113, -114, -114, -114, -113, -114, -113, -114, -113, -114, -113, -114,
-114, -114, -113, -114, -113, -114, -114, -113, -113, -114, -114, -114, -114,
-114, -114, -114, -114, -114, -113, -113, -115, -112, -115, -54, 0, -9, -3, -7,
-4, -6, -5, -6, -5, -5, -5, -6, -5, -6, -6, };