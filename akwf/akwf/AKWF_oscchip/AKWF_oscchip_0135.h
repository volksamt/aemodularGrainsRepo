#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0135

const PROGMEM int8_t DATA[DATA_LENGTH] = {82, 121, 107, 114, 109, 113, 109, 112,
110, 113, 111, 112, 110, 111, 111, 111, 108, 107, 108, 107, 108, 107, 108, 107,
108, 107, 107, 107, 108, 107, 107, 102, 97, 97, 97, 96, 97, 96, 97, 96, 96, 96,
96, 96, 96, 96, 96, 92, 86, 85, 86, 86, 85, 86, 86, 86, 85, 85, 85, 85, 85, 86,
86, 82, 72, 70, 71, 71, 70, 70, 70, 71, 70, 70, 71, 70, 71, 70, 71, 69, 64, 64,
63, 63, 63, 63, 64, 63, 63, 64, 63, 63, 64, 63, 62, 53, 44, 45, 45, 45, 45, 45,
45, 45, 46, 45, 44, 44, 44, 45, 46, 42, 40, 39, 39, 39, 39, 39, 39, 39, 38, 39,
39, 40, 38, 39, 39, 37, 33, 32, 33, 31, 33, 32, 31, 31, 31, 32, 32, 32, 32, 32,
32, 32, 29, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 25, 23, 22,
23, 22, 22, 23, 23, 22, 22, 22, 22, 23, 22, 22, 22, 22, 21, 21, 21, 21, 21, 21,
21, 21, 20, 20, 21, 20, 21, 21, 21, 17, 13, 11, 12, 12, 12, 11, 12, 11, 12, 12,
12, 12, 11, 11, 11, 11, 8, 7, 6, 7, 6, 6, 6, 7, 6, 7, 7, 6, 6, 6, 6, 4, 3, 3, 3,
2, 3, 2, 2, 3, 3, 3, 3, 2, 3, 2, 2, -44, -99, -99, -99, -100, -100, -100, -99,
-100, -99, -100, -100, -99, -99, -99, -99, -93, -81, -79, -80, -80, -80, -79,
-79, -79, -80, -79, -79, -78, -79, -79, -80, -78, -73, -71, -73, -72, -72, -71,
-72, -72, -72, -72, -73, -73, -72, -71, -71, -63, -57, -57, -57, -57, -57, -57,
-57, -57, -58, -57, -57, -57, -57, -57, -57, -52, -47, -46, -46, -46, -46, -46,
-46, -46, -46, -46, -45, -47, -46, -45, -47, -45, -45, -44, -45, -44, -44, -44,
-44, -44, -44, -44, -44, -44, -44, -44, -44, -42, -36, -35, -36, -36, -34, -35,
-35, -35, -35, -35, -35, -36, -35, -35, -36, -35, -31, -29, -30, -30, -29, -29,
-30, -30, -29, -30, -30, -29, -30, -29, -29, -28, -26, -26, -26, -25, -25, -26,
-26, -26, -26, -27, -25, -26, -25, -26, -27, -25, -24, -24, -24, -24, -24, -24,
-24, -24, -24, -24, -25, -24, -24, -24, -23, -22, -21, -20, -21, -20, -21, -20,
-20, -20, -20, -19, -20, -21, -20, -20, -20, -20, -17, -16, -17, -16, -17, -16,
-16, -17, -16, -16, -16, -16, -16, -17, -16, -16, -16, -16, -16, -17, -16, -17,
-17, -17, -16, -16, -17, -17, -16, -17, -16, -12, -6, -5, -5, -5, -5, -6, -5,
-5, -5, -6, -6, -6, -5, -5, -6, -9, -18, -20, -20, -21, -20, -20, -20, -21, -20,
-20, -20, -20, -20, -20, -19, -24, -43, -52, -50, -52, -50, -51, -51, -51, -51,
-51, -52, -51, -51, -51, -51, -77, -101, -100, -100, -100, -99, -100, -100,
-100, -99, -101, -99, -101, -99, -100, -99, -28, };