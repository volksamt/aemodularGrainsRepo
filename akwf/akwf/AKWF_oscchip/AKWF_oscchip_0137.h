#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0137

const PROGMEM int8_t DATA[DATA_LENGTH] = {82, 121, 107, 114, 109, 114, 110, 112,
111, 113, 111, 112, 112, 111, 112, 104, 69, 53, 56, 56, 57, 56, 56, 56, 56, 56,
57, 55, 56, 55, 57, 55, 56, 57, 56, 56, 56, 56, 56, 56, 56, 56, 56, 56, 56, 56,
56, 55, 52, 52, 52, 52, 52, 52, 53, 53, 52, 52, 53, 53, 52, 52, 52, 52, 52, 51,
50, 50, 51, 51, 50, 50, 51, 51, 51, 51, 51, 51, 50, 53, 63, 66, 66, 66, 66, 66,
66, 67, 65, 66, 66, 66, 67, 66, 66, 56, 49, 49, 48, 49, 49, 49, 49, 49, 49, 49,
48, 49, 48, 48, 49, 46, 44, 43, 43, 43, 43, 43, 44, 44, 43, 43, 43, 44, 43, 43,
43, 41, 36, 36, 35, 37, 36, 37, 36, 36, 36, 36, 36, 37, 36, 36, 35, 40, 55, 62,
61, 61, 61, 60, 61, 61, 60, 60, 60, 61, 60, 60, 62, 90, 112, 111, 110, 110, 110,
110, 111, 111, 110, 110, 111, 111, 111, 110, 111, 112, 112, 112, 113, 112, 112,
112, 113, 113, 111, 112, 113, 113, 113, 112, 112, 113, 113, 112, 112, 111, 112,
111, 112, 112, 112, 111, 113, 112, 112, 111, 114, 94, 29, 7, 12, 10, 12, 11, 11,
10, 12, 11, 11, 10, 11, 11, 11, 11, 8, 8, 8, 7, 8, 7, 7, 7, 7, 7, 8, 7, 8, 7, 8,
-36, -89, -89, -89, -89, -90, -91, -89, -90, -90, -89, -90, -90, -89, -90, -90,
-84, -71, -71, -71, -71, -71, -70, -71, -70, -71, -70, -71, -71, -71, -70, -71,
-68, -65, -63, -64, -63, -64, -63, -64, -64, -63, -63, -63, -64, -63, -63, -63,
-62, -53, -48, -50, -49, -50, -49, -50, -49, -50, -49, -49, -49, -49, -50, -49,
-44, -39, -39, -39, -39, -39, -39, -39, -38, -39, -39, -39, -39, -39, -39, -39,
-39, -40, -41, -41, -40, -41, -41, -41, -40, -40, -41, -41, -40, -40, -40, -41,
-41, -44, -44, -44, -44, -44, -44, -44, -44, -43, -44, -44, -44, -44, -44, -44,
-46, -55, -58, -58, -58, -57, -58, -58, -58, -58, -58, -58, -58, -57, -57, -58,
-49, -41, -40, -40, -40, -40, -40, -40, -41, -40, -40, -40, -40, -40, -41, -40,
-51, -74, -75, -74, -75, -75, -75, -75, -74, -75, -75, -75, -74, -75, -75, -75,
-78, -87, -90, -89, -89, -88, -88, -89, -88, -89, -89, -88, -88, -88, -89, -88,
-89, -92, -93, -93, -94, -94, -94, -94, -94, -94, -93, -95, -94, -94, -93, -93,
-64, -36, -36, -36, -35, -36, -35, -37, -36, -36, -36, -37, -36, -37, -36, -37,
-23, -1, 0, 1, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, -3, -12, -13, -14, -14, -13,
-13, -13, -13, -13, -14, -13, -13, -13, -13, -13, -18, -36, -44, -42, -43, -43,
-43, -43, -43, -42, -43, -43, -44, -43, -44, -43, -68, -90, -90, -89, -90, -90,
-91, -89, -91, -89, -90, -89, -90, -89, -90, -88, -22, };