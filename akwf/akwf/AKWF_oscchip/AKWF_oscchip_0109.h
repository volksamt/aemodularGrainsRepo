#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0109

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 22, 22, 21, 21, 21, 21, 21, 22, 22,
22, 22, 21, 21, 21, 22, 19, 16, 17, 17, 18, 17, 18, 17, 18, 17, 18, 18, 17, 17,
17, 16, 19, 25, 26, 26, 25, 26, 25, 25, 26, 27, 26, 26, 26, 26, 26, 25, 26, 26,
25, 26, 25, 26, 26, 26, 26, 26, 26, 26, 26, 25, 25, 26, 27, 28, 28, 27, 28, 28,
28, 28, 28, 28, 28, 28, 28, 27, 28, 27, 28, 30, 30, 30, 30, 30, 30, 30, 30, 30,
30, 30, 30, 31, 30, 30, 40, 48, 47, 48, 47, 47, 47, 47, 47, 47, 48, 48, 48, 47,
47, 47, 48, 50, 49, 50, 48, 50, 49, 50, 50, 49, 49, 49, 49, 49, 49, 49, 51, 57,
59, 58, 59, 58, 58, 58, 57, 58, 57, 59, 58, 57, 58, 58, 59, 60, 60, 61, 60, 59,
60, 60, 60, 60, 60, 59, 59, 59, 60, 59, 61, 62, 62, 62, 62, 63, 62, 62, 62, 63,
61, 62, 62, 62, 62, 63, 67, 68, 69, 68, 68, 68, 69, 68, 68, 68, 68, 68, 69, 68,
68, 68, 71, 73, 73, 73, 72, 72, 73, 73, 73, 72, 72, 72, 73, 72, 72, 73, 74, 75,
75, 75, 75, 75, 75, 75, 74, 75, 75, 75, 74, 75, 74, 75, 82, 83, 84, 83, 83, 83,
82, 82, 83, 83, 83, 84, 83, 83, 82, 83, 87, 90, 89, 89, 90, 89, 90, 90, 90, 89,
89, 88, 89, 88, 89, 89, 91, 91, 92, 91, 92, 90, 92, 91, 92, 90, 91, 90, 91, 91,
94, 76, -64, -121, -105, -113, -108, -112, -109, -111, -110, -110, -110, -111,
-110, -110, -111, -110, -109, -108, -107, -107, -109, -108, -108, -108, -109,
-108, -107, -108, -108, -108, -108, -108, -113, -119, -118, -119, -118, -119,
-119, -119, -118, -118, -118, -118, -118, -118, -118, -118, -119, -118, -119,
-119, -118, -118, -118, -119, -118, -118, -118, -118, -119, -118, -118, -118,
-117, -116, -116, -116, -117, -117, -115, -116, -116, -116, -116, -116, -116,
-116, -116, -116, -116, -115, -116, -116, -116, -115, -116, -115, -116, -115,
-115, -115, -116, -115, -117, -109, -42, -12, -18, -15, -18, -15, -17, -15, -16,
-15, -16, -16, -16, -17, -16, -16, -17, -18, -18, -18, -18, -18, -17, -18, -18,
-18, -18, -18, -18, -18, -18, -18, -19, -22, -22, -22, -22, -22, -22, -22, -22,
-22, -22, -22, -23, -23, -22, -22, -24, -25, -24, -23, -24, -24, -25, -24, -25,
-25, -25, -24, -25, -24, -25, -24, -27, -29, -28, -29, -29, -28, -28, -28, -29,
-29, -29, -29, -28, -28, -28, -29, -29, -28, -28, -28, -28, -29, -28, -28, -28,
-28, -29, -29, -29, -29, -28, -29, -28, -29, -29, -28, -29, -28, -29, -29, -28,
-28, -29, -29, -28, -28, -28, -28, -26, -26, -26, -26, -26, -27, -26, -27, -26,
-26, -26, -27, -26, -26, -27, -26, -25, -24, -24, -24, -24, -24, -24, -23, -24,
-23, -25, -24, -24, -23, -25, -19, };