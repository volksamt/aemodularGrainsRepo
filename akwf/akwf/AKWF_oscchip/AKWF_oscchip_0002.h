#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 8, 7, 8, 8, 8, 7, 7, 7, 8, 7, 8, 7,
8, 7, 10, 18, 20, 20, 21, 21, 21, 20, 21, 20, 21, 20, 21, 19, 20, 19, 34, 69,
76, 74, 75, 75, 74, 73, 74, 74, 75, 74, 76, 73, 75, 73, 87, 115, 119, 117, 118,
118, 117, 117, 118, 117, 118, 117, 118, 117, 117, 117, 114, 107, 106, 107, 106,
107, 106, 106, 106, 107, 106, 107, 105, 107, 105, 107, 90, 63, 62, 63, 62, 62,
63, 62, 62, 62, 62, 62, 61, 63, 62, 63, 49, 30, 29, 30, 31, 29, 29, 30, 30, 30,
29, 30, 30, 30, 30, 29, 30, 29, 27, 28, 27, 27, 28, 28, 27, 28, 27, 28, 28, 27,
27, 28, 29, 44, 53, 52, 54, 52, 53, 52, 53, 52, 53, 53, 53, 53, 52, 53, 53, 68,
77, 76, 76, 75, 76, 76, 75, 77, 76, 76, 76, 76, 76, 76, 76, 82, 85, 85, 85, 85,
84, 84, 85, 85, 85, 85, 84, 85, 85, 84, 87, 95, 100, 98, 99, 99, 100, 99, 98,
98, 99, 99, 99, 99, 99, 99, 99, 101, 102, 103, 102, 102, 102, 103, 102, 102,
102, 103, 102, 102, 102, 102, 96, 74, 66, 68, 66, 68, 67, 67, 67, 68, 68, 67,
67, 67, 67, 68, 62, 40, 35, 37, 36, 37, 36, 36, 36, 36, 35, 37, 37, 37, 36, 36,
31, 13, 10, 11, 10, 11, 10, 12, 11, 11, 11, 11, 11, 12, 9, 15, -18, -98, -109,
-105, -107, -106, -108, -107, -107, -106, -107, -107, -107, -106, -106, -106,
-103, -94, -94, -94, -93, -94, -94, -94, -94, -94, -93, -93, -94, -93, -94, -94,
-93, -92, -92, -92, -92, -91, -91, -92, -91, -92, -91, -92, -91, -91, -92, -92,
-90, -90, -90, -90, -89, -89, -90, -89, -90, -90, -89, -90, -89, -90, -89, -90,
-86, -79, -78, -78, -78, -78, -78, -78, -78, -78, -78, -78, -78, -78, -78, -79,
-78, -77, -74, -75, -74, -74, -75, -74, -74, -73, -74, -75, -74, -74, -75, -74,
-73, -71, -71, -71, -70, -70, -70, -70, -70, -70, -70, -71, -70, -71, -70, -70,
-69, -63, -60, -59, -59, -59, -59, -59, -59, -58, -60, -59, -59, -59, -59, -60,
-59, -54, -52, -51, -52, -51, -52, -52, -51, -52, -52, -51, -51, -52, -51, -52,
-52, -55, -54, -55, -55, -55, -55, -54, -54, -54, -55, -54, -54, -55, -55, -55,
-55, -51, -50, -49, -49, -50, -50, -50, -50, -50, -49, -49, -50, -49, -50, -49,
-48, -46, -46, -46, -46, -45, -45, -46, -45, -45, -46, -46, -46, -46, -45, -46,
-44, -42, -42, -42, -42, -42, -42, -41, -42, -41, -42, -41, -42, -42, -41, -42,
-40, -35, -34, -34, -34, -34, -34, -35, -34, -34, -34, -34, -34, -34, -35, -33,
-31, -25, -23, -24, -23, -23, -23, -23, -23, -24, -24, -24, -23, -23, -23, -24,
-18, -7, -7, -7, -7, -6, -7, -7, -7, -7, -6, -6, -7, -6, -7, -7, -3, };