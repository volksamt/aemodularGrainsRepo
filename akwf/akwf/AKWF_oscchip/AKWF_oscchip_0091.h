#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0091

const PROGMEM int8_t DATA[DATA_LENGTH] = {66, 120, 108, 115, 111, 114, 111, 113,
112, 113, 112, 112, 113, 112, 112, 113, 108, 105, 106, 105, 105, 104, 106, 104,
106, 105, 105, 105, 105, 104, 105, 105, 104, 101, 101, 102, 102, 102, 101, 101,
101, 102, 101, 101, 101, 101, 101, 101, 93, 90, 90, 89, 90, 90, 90, 90, 90, 90,
89, 90, 89, 91, 89, 89, 84, 78, 79, 78, 79, 78, 79, 78, 78, 79, 79, 79, 78, 79,
79, 79, 75, 67, 67, 67, 68, 68, 68, 68, 67, 67, 67, 67, 68, 67, 67, 66, 59, 56,
57, 57, 57, 56, 56, 56, 56, 56, 56, 57, 56, 56, 56, 57, 54, 52, 52, 53, 53, 52,
52, 53, 52, 53, 53, 53, 52, 52, 52, 53, 47, 38, 37, 38, 38, 38, 37, 38, 37, 38,
38, 38, 38, 38, 38, 36, 29, 26, 27, 26, 26, 26, 26, 26, 26, 27, 27, 27, 26, 27,
26, 27, 18, 12, 13, 11, 12, 12, 12, 12, 12, 11, 12, 12, 12, 12, 12, 12, 6, -3,
-3, -3, -3, -3, -3, -3, -2, -3, -3, -3, -3, -3, -3, -3, -7, -7, -6, -7, -6, -6,
-7, -8, -6, -6, -6, -7, -7, -7, -7, -6, -12, -18, -18, -18, -18, -18, -18, -17,
-17, -18, -18, -17, -17, -18, -19, -18, -22, -29, -29, -28, -28, -29, -29, -29,
-29, -28, -29, -28, -29, -29, -28, -29, -33, -35, -35, -35, -34, -34, -34, -34,
-34, -35, -34, -34, -34, -34, -34, -34, -36, -38, -38, -37, -37, -38, -38, -38,
-38, -38, -37, -38, -38, -39, -38, -40, -48, -49, -49, -49, -49, -50, -49, -49,
-49, -50, -49, -49, -49, -49, -49, -49, -52, -52, -52, -52, -52, -53, -53, -52,
-52, -53, -53, -52, -52, -52, -52, -52, -54, -57, -56, -56, -55, -56, -55, -56,
-55, -56, -57, -56, -56, -57, -56, -56, -55, -55, -55, -56, -55, -56, -56, -56,
-56, -56, -57, -56, -56, -56, -55, -56, -55, -55, -56, -56, -56, -56, -56, -56,
-56, -56, -56, -56, -56, -56, -56, -56, -55, -53, -54, -54, -54, -54, -55, -54,
-54, -53, -53, -54, -54, -54, -54, -53, -51, -50, -51, -49, -51, -51, -50, -49,
-49, -51, -50, -50, -49, -50, -50, -49, -46, -44, -44, -44, -44, -44, -44, -44,
-44, -44, -44, -44, -44, -45, -44, -44, -40, -35, -35, -35, -36, -35, -35, -34,
-35, -35, -35, -35, -35, -35, -35, -33, -25, -24, -24, -23, -25, -24, -24, -24,
-24, -24, -24, -24, -24, -23, -24, -24, -20, -18, -18, -18, -18, -19, -18, -17,
-18, -18, -18, -18, -19, -18, -19, -18, -17, -17, -17, -17, -17, -16, -17, -16,
-16, -16, -16, -17, -16, -17, -17, -16, -12, -11, -11, -11, -11, -10, -10, -11,
-11, -11, -11, -11, -10, -10, -11, -11, -23, -28, -27, -28, -27, -28, -28, -27,
-27, -28, -27, -28, -28, -27, -28, -26, -49, -68, -65, -67, -66, -66, -66, -66,
-66, -65, -66, -66, -67, -65, -70, -40, };