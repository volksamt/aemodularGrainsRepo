#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0150

const PROGMEM int8_t DATA[DATA_LENGTH] = {79, 114, 101, 108, 104, 107, 104, 107,
105, 107, 105, 107, 106, 106, 105, 107, 108, 110, 109, 109, 110, 109, 110, 109,
110, 109, 110, 110, 110, 109, 110, 101, 95, 94, 95, 94, 95, 95, 94, 95, 95, 94,
95, 94, 95, 95, 95, 87, 77, 75, 77, 76, 76, 76, 76, 76, 76, 76, 76, 77, 76, 76,
77, 66, 44, 39, 42, 40, 41, 41, 40, 41, 41, 41, 41, 41, 41, 40, 40, 37, 24, 19,
21, 21, 20, 20, 20, 20, 20, 20, 20, 21, 20, 21, 20, 9, -1, 1, 0, 0, 0, 0, 0, 0,
0, 0, 0, -1, 0, 0, 0, -5, -11, -11, -11, -12, -11, -12, -11, -12, -11, -12, -11,
-12, -12, -11, -11, -15, -25, -27, -27, -25, -26, -27, -26, -25, -25, -26, -26,
-26, -25, -25, -25, -30, -43, -50, -48, -48, -48, -49, -48, -49, -49, -49, -48,
-48, -48, -48, -49, -59, -67, -67, -66, -67, -67, -67, -67, -66, -66, -67, -67,
-67, -67, -67, -66, -74, -81, -82, -81, -82, -82, -81, -82, -81, -81, -82, -82,
-81, -81, -82, -81, -89, -105, -108, -107, -108, -107, -108, -107, -108, -108,
-108, -107, -107, -107, -108, -107, -109, -116, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -117, -101, -88, -89, -89, -89,
-88, -89, -89, -89, -88, -90, -89, -89, -89, -88, -89, -86, -82, -82, -82, -81,
-82, -81, -82, -81, -82, -82, -82, -82, -82, -82, -81, -77, -67, -66, -67, -67,
-67, -67, -66, -67, -67, -67, -67, -66, -66, -67, -67, -56, -21, -10, -14, -12,
-14, -12, -13, -13, -13, -13, -12, -13, -13, -12, -12, -8, -5, -5, -5, -6, -6,
-5, -6, -6, -6, -6, -5, -6, -6, -6, -5, -2, 2, 1, 2, 2, 2, 3, 2, 2, 1, 2, 1, 2,
2, 2, 2, 4, 7, 8, 7, 8, 7, 8, 7, 7, 7, 8, 7, 8, 7, 8, 7, 9, 12, 13, 14, 13, 13,
13, 13, 13, 12, 13, 14, 13, 13, 12, 14, 18, 22, 22, 22, 22, 23, 22, 22, 22, 22,
22, 23, 22, 22, 22, 22, 30, 39, 38, 39, 39, 39, 39, 39, 39, 39, 39, 38, 39, 39,
40, 39, 44, 55, 56, 56, 56, 55, 55, 56, 55, 56, 56, 56, 56, 56, 56, 56, 59, 68,
70, 70, 71, 71, 70, 70, 70, 71, 70, 71, 70, 70, 70, 72, 81, 86, 85, 85, 86, 85,
85, 84, 85, 85, 86, 84, 85, 85, 86, 85, 70, 56, 56, 56, 56, 55, 55, 56, 55, 56,
56, 55, 55, 57, 56, 56, 42, 20, 18, 19, 18, 18, 18, 18, 18, 19, 18, 19, 18, 19,
17, 20, 4, -37, -47, -44, -45, -44, -45, -44, -44, -45, -45, -44, -44, -45, -43,
-46, -59, -67, -66, -67, -66, -67, -67, -67, -67, -67, -67, -67, -67, -67, -66,
-67, -71, -74, -74, -73, -74, -73, -74, -74, -75, -73, -74, -74, -74, -74, -75,
-73, -15, };