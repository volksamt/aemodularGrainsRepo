#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0154

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 8, 7, 7, 7, 8, 7, 7, 8, 6, 7, 7, 7,
8, 7, 10, 24, 29, 28, 29, 29, 29, 29, 29, 28, 28, 28, 29, 28, 29, 29, 37, 43,
43, 43, 42, 44, 43, 43, 42, 43, 43, 43, 43, 43, 44, 43, 49, 57, 57, 57, 57, 57,
57, 57, 57, 57, 57, 57, 57, 57, 57, 57, 60, 67, 68, 68, 68, 68, 67, 68, 68, 69,
68, 68, 67, 67, 68, 67, 70, 76, 80, 78, 79, 79, 79, 79, 78, 79, 79, 79, 79, 78,
78, 79, 90, 101, 101, 99, 101, 101, 100, 100, 100, 101, 100, 100, 101, 101, 100,
101, 103, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 103, 104, 104,
104, 101, 93, 91, 92, 91, 92, 92, 91, 92, 91, 92, 91, 91, 92, 91, 91, 89, 83,
80, 81, 80, 80, 81, 81, 80, 81, 81, 81, 80, 81, 80, 79, 66, 55, 55, 55, 56, 55,
55, 55, 56, 56, 56, 56, 55, 55, 55, 55, 50, 45, 45, 45, 45, 45, 44, 45, 45, 45,
45, 45, 45, 44, 45, 44, 41, 36, 34, 33, 35, 34, 34, 34, 34, 34, 34, 35, 34, 34,
33, 34, 31, 20, 16, 17, 16, 17, 16, 16, 16, 16, 17, 16, 16, 16, 15, 15, 11, 7,
7, 7, 7, 8, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 5, 3, 4, 3, 3, 4, 3, 4, 4, 4, 3, 4, 3,
4, 3, 6, -33, -107, -118, -114, -115, -114, -114, -115, -114, -115, -115, -116,
-114, -115, -115, -117, -98, -43, -25, -30, -28, -30, -29, -29, -29, -29, -28,
-29, -29, -28, -28, -30, -38, -43, -42, -43, -43, -43, -43, -43, -44, -42, -42,
-43, -43, -43, -43, -42, -49, -58, -57, -57, -57, -57, -58, -57, -57, -57, -57,
-57, -58, -58, -57, -57, -59, -61, -61, -61, -61, -61, -61, -61, -61, -61, -60,
-61, -60, -61, -61, -60, -66, -85, -90, -89, -90, -89, -90, -90, -89, -89, -90,
-89, -89, -90, -89, -90, -102, -112, -111, -111, -111, -111, -111, -112, -112,
-111, -111, -111, -111, -111, -112, -111, -113, -115, -115, -114, -115, -114,
-115, -115, -115, -115, -115, -114, -115, -115, -114, -115, -114, -115, -115,
-114, -115, -115, -115, -114, -114, -115, -115, -114, -115, -115, -115, -115,
-111, -99, -96, -97, -97, -97, -98, -96, -97, -97, -97, -96, -96, -97, -97, -96,
-88, -82, -82, -83, -82, -82, -82, -82, -82, -82, -83, -82, -82, -82, -82, -82,
-70, -58, -58, -58, -57, -58, -57, -58, -57, -57, -57, -57, -57, -57, -57, -57,
-53, -47, -47, -47, -47, -46, -47, -47, -47, -46, -46, -47, -47, -46, -47, -47,
-44, -37, -35, -35, -36, -36, -36, -37, -35, -36, -36, -36, -36, -36, -36, -36,
-26, -22, -22, -22, -21, -22, -21, -21, -21, -21, -21, -22, -21, -21, -21, -21,
-14, -7, -7, -7, -6, -7, -7, -7, -8, -7, -8, -8, -7, -7, -7, -7, -2, };