#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0101

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 2, 2, 3, 2, 3, 2, 4, 2, 3, 2, 4, 3,
4, 3, 8, 17, 17, 17, 18, 17, 17, 17, 17, 17, 17, 17, 17, 17, 17, 17, 22, 26, 25,
25, 26, 25, 25, 25, 24, 25, 26, 25, 25, 25, 25, 26, 26, 26, 25, 25, 25, 25, 25,
26, 26, 26, 26, 25, 25, 25, 26, 26, 25, 25, 26, 25, 26, 25, 25, 26, 26, 25, 26,
26, 26, 25, 25, 25, 27, 29, 28, 28, 28, 27, 28, 28, 28, 28, 28, 28, 29, 27, 28,
27, 55, 79, 76, 78, 77, 79, 77, 78, 77, 77, 77, 78, 77, 78, 76, 80, 58, 20, 20,
19, 19, 20, 19, 20, 20, 20, 20, 20, 20, 20, 19, 19, 12, 8, 9, 8, 8, 8, 9, 9, 9,
9, 9, 8, 9, 8, 9, 8, 37, 66, 62, 64, 63, 63, 63, 64, 63, 63, 64, 64, 63, 63, 63,
63, 65, 66, 66, 66, 66, 67, 66, 66, 66, 66, 66, 67, 66, 66, 66, 66, 67, 69, 68,
69, 69, 70, 68, 69, 68, 68, 68, 68, 68, 69, 69, 68, 70, 71, 72, 71, 71, 72, 71,
71, 71, 70, 72, 71, 72, 71, 71, 72, 71, 71, 70, 71, 71, 71, 71, 71, 72, 71, 71,
70, 71, 71, 71, 71, 71, 71, 71, 72, 72, 71, 72, 71, 72, 71, 71, 71, 72, 71, 72,
71, 72, 71, 71, 71, 71, 71, 71, 71, 71, 70, 71, 71, 71, 71, 71, 70, 69, 68, 67,
68, 68, 68, 68, 68, 67, 69, 68, 68, 68, 68, 67, 68, 67, 67, 68, 68, 68, 68, 67,
68, 68, 67, 67, 67, 68, 68, 68, 67, 66, 64, 65, 66, 65, 66, 65, 65, 65, 65, 65,
65, 65, 66, 65, 63, 55, 53, 54, 53, 54, 53, 54, 53, 54, 54, 54, 54, 54, 53, 53,
51, 19, 2, 5, 4, 4, 4, 5, 5, 4, 4, 4, 4, 4, 4, 4, 4, -17, -39, -36, -38, -37,
-38, -37, -37, -37, -37, -37, -38, -37, -37, -37, -40, -55, -59, -59, -59, -58,
-59, -59, -59, -59, -60, -59, -59, -60, -60, -58, -59, -64, -67, -67, -67, -67,
-67, -67, -67, -67, -67, -68, -68, -67, -67, -68, -68, -72, -79, -77, -79, -79,
-79, -79, -79, -78, -77, -78, -78, -78, -79, -78, -78, -81, -81, -81, -81, -81,
-80, -81, -80, -81, -81, -80, -82, -81, -80, -80, -81, -87, -89, -88, -88, -89,
-89, -89, -90, -88, -89, -88, -90, -89, -89, -90, -88, -94, -100, -99, -100,
-100, -100, -99, -100, -100, -99, -100, -99, -100, -100, -99, -101, -107, -109,
-107, -108, -108, -108, -108, -108, -109, -108, -108, -108, -108, -108, -108,
-107, -115, -119, -118, -118, -118, -118, -119, -118, -119, -119, -119, -119,
-119, -118, -118, -119, -118, -118, -118, -118, -118, -118, -118, -119, -118,
-117, -118, -118, -119, -118, -118, -117, -116, -115, -116, -115, -116, -115,
-116, -115, -115, -115, -116, -115, -115, -115, -116, -109, -35, };