#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0152

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 3, 4, 3, 4, 3, 4, 4, 3, 4, 4, 4,
3, 3, 5, 11, 13, 12, 12, 12, 12, 12, 12, 12, 13, 13, 12, 12, 12, 13, 19, 23, 24,
23, 23, 23, 23, 24, 24, 23, 24, 23, 24, 23, 23, 23, 29, 37, 38, 37, 38, 37, 38,
38, 38, 37, 38, 38, 37, 37, 38, 37, 39, 47, 49, 48, 48, 48, 48, 48, 48, 48, 48,
47, 49, 48, 48, 48, 53, 74, 82, 80, 81, 80, 81, 80, 80, 81, 80, 80, 80, 81, 80,
81, 90, 99, 98, 98, 98, 99, 98, 98, 98, 98, 98, 98, 98, 98, 98, 98, 101, 105,
105, 105, 105, 105, 105, 105, 106, 105, 105, 105, 105, 105, 105, 105, 107, 109,
109, 108, 109, 109, 110, 108, 109, 109, 109, 109, 110, 109, 109, 109, 106, 100,
98, 98, 98, 98, 98, 98, 98, 99, 98, 99, 99, 97, 98, 98, 90, 83, 84, 83, 84, 84,
84, 84, 84, 84, 83, 84, 83, 84, 83, 84, 78, 70, 70, 70, 70, 69, 69, 69, 70, 70,
69, 70, 69, 70, 69, 70, 66, 60, 58, 58, 58, 59, 58, 58, 59, 59, 60, 58, 59, 59,
58, 59, 56, 48, 43, 44, 45, 44, 45, 45, 44, 44, 45, 44, 44, 45, 45, 43, 28, 15,
16, 16, 17, 16, 16, 16, 16, 16, 16, 16, 15, 16, 15, 16, -42, -114, -115, -114,
-114, -113, -114, -115, -114, -115, -115, -115, -114, -115, -114, -116, -81,
-16, -6, -11, -8, -9, -9, -9, -9, -9, -9, -9, -9, -9, -9, -9, -10, -12, -12,
-12, -12, -13, -13, -13, -13, -13, -13, -12, -12, -12, -13, -13, -22, -27, -27,
-27, -26, -26, -26, -27, -27, -26, -27, -27, -27, -27, -27, -27, -34, -41, -41,
-41, -41, -41, -42, -41, -40, -42, -42, -41, -41, -41, -42, -41, -47, -57, -59,
-59, -59, -59, -59, -59, -59, -59, -59, -59, -59, -59, -59, -59, -61, -67, -70,
-70, -70, -69, -69, -70, -69, -69, -70, -70, -70, -70, -69, -71, -85, -95, -95,
-95, -94, -95, -95, -94, -95, -95, -95, -94, -95, -95, -94, -95, -98, -102,
-101, -102, -102, -102, -102, -101, -102, -102, -101, -102, -102, -102, -102,
-102, -103, -106, -105, -104, -105, -105, -106, -106, -106, -105, -105, -106,
-105, -106, -106, -105, -103, -96, -94, -94, -95, -95, -94, -94, -95, -95, -95,
-94, -94, -95, -95, -93, -83, -76, -78, -76, -77, -77, -77, -77, -77, -77, -76,
-78, -77, -76, -76, -76, -70, -62, -62, -62, -63, -63, -63, -63, -63, -63, -63,
-63, -63, -63, -62, -63, -59, -51, -51, -51, -52, -52, -51, -52, -52, -52, -51,
-51, -52, -52, -52, -52, -50, -43, -41, -41, -40, -42, -41, -41, -40, -41, -41,
-42, -41, -41, -41, -41, -39, -29, -24, -25, -24, -24, -26, -25, -25, -26, -25,
-25, -25, -25, -25, -25, -17, -8, -8, -9, -9, -9, -9, -9, -9, -9, -8, -9, -9,
-9, -9, -9, -5, };