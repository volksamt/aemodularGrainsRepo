#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0086

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 9, 8, 8, 8, 9, 9, 8, 8, 9, 8, 8, 9,
9, 9, 8, 11, 18, 18, 19, 19, 18, 19, 19, 18, 18, 19, 19, 19, 19, 18, 19, 19, 24,
24, 24, 23, 23, 25, 23, 24, 23, 24, 23, 24, 23, 24, 24, 25, 28, 27, 27, 27, 27,
27, 28, 28, 27, 27, 27, 27, 27, 27, 27, 27, 29, 29, 29, 29, 29, 28, 29, 28, 29,
29, 29, 28, 29, 28, 28, 29, 32, 32, 32, 32, 32, 32, 32, 32, 33, 31, 32, 31, 32,
33, 32, 33, 35, 36, 36, 35, 35, 35, 35, 36, 35, 36, 35, 35, 36, 35, 35, 36, 38,
38, 38, 39, 39, 39, 39, 39, 38, 39, 39, 39, 38, 39, 39, 40, 45, 46, 45, 46, 45,
46, 45, 45, 45, 45, 45, 45, 45, 45, 44, 47, 49, 49, 48, 49, 49, 49, 49, 49, 49,
48, 48, 49, 49, 49, 48, 52, 58, 59, 58, 59, 59, 59, 59, 59, 58, 59, 58, 60, 58,
59, 58, 60, 62, 61, 61, 62, 62, 62, 61, 61, 62, 61, 61, 62, 61, 62, 62, 64, 65,
65, 66, 65, 65, 66, 65, 66, 65, 66, 66, 65, 65, 66, 65, 66, 68, 69, 69, 69, 68,
68, 69, 69, 68, 69, 68, 69, 68, 68, 69, 93, 104, 102, 103, 103, 103, 102, 103,
103, 104, 103, 104, 101, 105, 100, 108, -9, -124, -109, -116, -112, -114, -112,
-114, -112, -113, -113, -114, -114, -113, -113, -114, -98, -71, -70, -71, -71,
-70, -71, -70, -71, -70, -71, -71, -71, -70, -71, -70, -65, -61, -62, -62, -63,
-62, -61, -62, -62, -61, -61, -62, -62, -62, -62, -62, -59, -56, -57, -57, -57,
-57, -57, -58, -57, -57, -57, -58, -57, -57, -57, -58, -55, -51, -52, -52, -52,
-52, -52, -52, -52, -52, -51, -52, -51, -51, -51, -51, -50, -50, -50, -50, -50,
-50, -50, -50, -50, -50, -49, -49, -50, -50, -50, -50, -48, -46, -47, -46, -47,
-46, -47, -47, -46, -47, -47, -46, -46, -46, -46, -46, -44, -38, -38, -39, -38,
-38, -39, -38, -38, -38, -37, -39, -38, -38, -38, -38, -35, -34, -34, -34, -35,
-34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -35, -31, -28, -28, -27, -28,
-28, -27, -27, -27, -27, -28, -27, -27, -27, -28, -28, -27, -26, -25, -26, -25,
-26, -26, -26, -26, -25, -26, -26, -26, -26, -26, -25, -24, -23, -23, -22, -23,
-22, -22, -22, -22, -22, -22, -22, -22, -23, -23, -23, -20, -19, -19, -19, -19,
-19, -18, -18, -19, -18, -18, -19, -19, -19, -19, -20, -18, -16, -17, -17, -17,
-17, -17, -17, -17, -17, -18, -17, -17, -17, -17, -17, -17, -17, -18, -17, -17,
-17, -17, -17, -17, -17, -17, -17, -18, -17, -17, -17, -14, -11, -11, -10, -10,
-10, -10, -10, -10, -11, -11, -10, -11, -10, -10, -10, -7, 0, 0, 0, 0, 0, 0, -1,
0, 0, 0, -1, 1, 0, 0, 0, };