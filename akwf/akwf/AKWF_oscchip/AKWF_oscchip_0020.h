#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 13, 17, 15, 16, 16, 16, 16, 16, 16,
16, 16, 16, 16, 16, 17, 17, 25, 28, 26, 26, 27, 28, 26, 28, 27, 27, 27, 27, 27,
27, 27, 29, 37, 40, 39, 39, 40, 39, 39, 39, 39, 39, 39, 40, 39, 39, 39, 43, 55,
58, 56, 57, 57, 57, 57, 57, 57, 58, 58, 57, 57, 57, 58, 56, 67, 82, 82, 82, 82,
82, 81, 82, 82, 81, 82, 81, 82, 82, 83, 82, 90, 101, 102, 101, 101, 101, 102,
101, 102, 101, 101, 101, 101, 102, 102, 101, 106, 112, 112, 112, 113, 112, 112,
112, 112, 112, 111, 111, 112, 112, 111, 111, 116, 119, 119, 119, 118, 118, 118,
118, 118, 118, 118, 118, 118, 119, 119, 119, 108, 99, 100, 100, 101, 100, 100,
100, 101, 100, 100, 100, 99, 99, 101, 99, 87, 76, 77, 76, 76, 76, 77, 76, 75,
76, 77, 76, 76, 76, 76, 75, 62, 54, 55, 54, 55, 54, 54, 54, 54, 55, 54, 54, 54,
55, 55, 55, 46, 41, 42, 42, 41, 41, 41, 41, 42, 42, 42, 42, 41, 42, 41, 41, 34,
30, 31, 30, 30, 31, 30, 31, 31, 31, 31, 31, 31, 30, 30, 30, 21, 17, 19, 17, 18,
18, 18, 17, 17, 18, 19, 18, 18, 18, 18, 17, 9, 6, 7, 7, 8, 7, 7, 7, 7, 7, 7, 7,
7, 7, 7, 5, -2, -4, -4, -4, -4, -5, -3, -4, -3, -3, -4, -3, -4, -4, -4, -7, -17,
-21, -20, -21, -19, -20, -20, -20, -20, -19, -20, -20, -20, -20, -20, -22, -31,
-32, -33, -32, -33, -32, -32, -32, -33, -33, -32, -33, -33, -31, -32, -32, -38,
-47, -47, -47, -47, -47, -47, -46, -47, -46, -46, -47, -48, -46, -47, -47, -53,
-61, -61, -61, -61, -62, -62, -60, -61, -61, -62, -60, -60, -61, -61, -60, -68,
-78, -77, -76, -77, -77, -77, -77, -77, -77, -78, -76, -76, -77, -77, -78, -84,
-91, -91, -91, -92, -91, -92, -91, -91, -91, -91, -91, -91, -91, -91, -91, -98,
-104, -104, -104, -103, -103, -103, -103, -103, -103, -103, -102, -103, -103,
-102, -104, -108, -110, -110, -110, -110, -109, -109, -110, -110, -110, -110,
-110, -110, -110, -109, -109, -100, -92, -93, -94, -94, -93, -93, -93, -94, -93,
-93, -93, -93, -93, -93, -92, -81, -74, -76, -75, -75, -75, -75, -74, -76, -75,
-75, -75, -74, -74, -75, -74, -67, -64, -64, -64, -64, -63, -64, -64, -63, -64,
-64, -64, -64, -63, -64, -62, -51, -46, -48, -47, -47, -48, -47, -48, -47, -47,
-48, -47, -48, -47, -47, -46, -36, -31, -33, -32, -33, -32, -34, -33, -33, -33,
-33, -32, -33, -32, -33, -31, -20, -18, -18, -19, -18, -19, -19, -18, -18, -18,
-18, -19, -19, -18, -19, -17, -11, -9, -9, -9, -10, -8, -9, -9, -9, -9, -9, -9,
-9, -9, -9, -7, -2, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, };