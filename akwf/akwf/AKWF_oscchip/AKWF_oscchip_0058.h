#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0058

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1,
0, 2, 2, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 2, 3, 3, 3, 3, 2, 3, 3, 3,
3, 4, 2, 3, 2, 3, 4, 3, 3, 3, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 2, 2, 3, 3, 3, 3,
3, 3, 3, 3, 3, 2, 3, 3, 3, 3, 3, 2, 3, 3, 3, 3, 2, 3, 3, 3, 3, 3, 2, 3, 3, 3, 3,
3, 3, 3, 3, 3, 2, 3, 3, 2, 3, 3, 3, 2, 3, 3, 4, 1, 29, 93, 120, 116, 116, 116,
116, 115, 116, 116, 115, 116, 115, 116, 116, 116, 115, 110, 108, 108, 107, 108,
108, 108, 107, 108, 108, 108, 108, 108, 108, 106, 86, 62, 59, 61, 61, 60, 61,
61, 61, 60, 61, 61, 60, 60, 61, 61, 53, 40, 36, 37, 37, 37, 37, 37, 37, 36, 37,
37, 37, 37, 37, 37, 33, 23, 18, 20, 19, 19, 19, 20, 19, 19, 19, 20, 19, 19, 19,
20, 19, 14, 9, 10, 9, 9, 9, 10, 9, 9, 9, 9, 10, 8, 9, 10, 7, 4, 4, 4, 4, 3, 3,
4, 4, 4, 3, 4, 3, 3, 4, 3, 3, 0, 0, -1, 0, -1, -1, -1, 0, 0, 0, -1, 0, -1, 0, 2,
-16, -73, -109, -106, -107, -106, -106, -106, -105, -106, -106, -106, -106,
-106, -106, -106, -106, -98, -90, -90, -90, -91, -91, -90, -90, -90, -90, -90,
-90, -90, -91, -90, -79, -61, -57, -59, -59, -59, -59, -59, -58, -58, -59, -58,
-59, -58, -58, -59, -55, -46, -43, -43, -42, -43, -43, -44, -43, -43, -43, -43,
-43, -43, -43, -42, -39, -23, -10, -11, -12, -11, -11, -12, -12, -11, -11, -11,
-11, -11, -11, -12, -9, -6, -5, -6, -6, -5, -5, -6, -5, -6, -6, -5, -5, -6, -5,
-5, -6, -5, -5, -5, -6, -5, -5, -5, -5, -5, -6, -5, -5, -5, -5, -5, -5, -6, -8,
-8, -7, -7, -7, -8, -7, -7, -7, -7, -6, -7, -7, -7, -7, -6, -6, -6, -5, -5, -6,
-4, -6, -5, -5, -5, -6, -5, -5, -6, -5, -6, -6, -5, -5, -5, -5, -4, -5, -6, -5,
-4, -5, -5, -5, -5, -6, -7, -7, -7, -7, -7, -7, -8, -7, -7, -7, -7, -7, -7, -7,
-7, -7, -6, -5, -4, -6, -6, -5, -5, -5, -5, -5, -6, -5, -5, -5, -6, -5, -5, -5,
-5, -5, -5, -6, -5, -5, -5, -6, -5, -5, -5, -6, -6, -6, -9, -9, -9, -9, -9, -10,
-9, -9, -9, -9, -9, -9, -9, -9, -9, -7, -4, -3, -3, -3, -3, -3, -3, -3, -3, -3,
-4, -3, -3, -3, -4, -2, -2, 0, -1, -1, -1, -1, -1, -1, -1, -1, -2, -1, -2, -1,
-1, -1, -1, -1, -2, -1, -1, -1, -1, -1, -1, -1, -2, -1, -1, -1, -1, -1, };