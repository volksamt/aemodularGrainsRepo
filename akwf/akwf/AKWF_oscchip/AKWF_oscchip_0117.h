#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0117

const PROGMEM int8_t DATA[DATA_LENGTH] = {57, 119, 107, 113, 110, 111, 110, 111,
110, 111, 111, 111, 111, 111, 111, 110, 111, 111, 111, 110, 111, 111, 111, 111,
111, 110, 111, 110, 111, 111, 111, 111, 112, 110, 111, 112, 111, 111, 110, 111,
110, 111, 111, 112, 111, 112, 111, 111, 110, 111, 110, 111, 110, 111, 111, 111,
110, 111, 111, 111, 110, 111, 111, 110, 111, 110, 110, 110, 111, 110, 110, 110,
111, 110, 111, 109, 111, 108, 113, 91, 13, -4, 0, -1, 1, -1, 1, -2, 0, -1, 0,
-1, -1, 0, 0, -1, -1, -1, -1, -1, -1, -1, -1, -1, 0, 0, -1, -1, -1, -1, -2, -1,
-1, -1, -1, -1, -1, -1, -1, -1, -1, -2, -1, -1, -1, 0, -1, -1, 0, 1, 1, 1, 1, 1,
0, 1, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 0, 0, 1, 1, 0, 1, 0, 1, 0, 1, 1, 0, 1, 1,
0, 1, 0, 1, 1, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 1, 0,
1, 1, 1, 1, 1, 1, 0, 2, 1, 1, 1, 1, 0, 0, 0, 1, 0, 1, 1, 1, 1, 0, 0, 1, 1, 1, 1,
1, 0, 1, 0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 2,
0, 1, 1, 1, 1, 0, 2, 1, 0, 1, 1, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1,
1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 0, 2, 1, 1, 1, 1, 0, 1, 1, 1, 1, 0, 1, 1, 0, 1, 1,
0, 1, 1, 1, 1, 0, 0, 1, 1, 1, 1, 0, 0, 1, 1, 0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 1, 1,
1, 1, 1, 2, 0, 1, 0, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 1, 1, 0,
0, 1, 3, 5, 5, 4, 4, 4, 4, 5, 5, 4, 4, 4, 5, 3, 3, 5, 1, 0, 0, 1, 0, 0, 0, 0, 0,
0, 0, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 0, -1, -1, 0, -1, -1, -1, -1, -1, -1,
-1, -1, -1, -2, -1, -1, -1, -1, -1, -1, -2, -1, -1, -1, -1, -1, -1, -1, -1, -1,
-2, -1, -2, -1, -1, -1, -2, -1, -1, -1, -1, 0, -7, -84, -118, -110, -114, -111,
-114, -112, -113, -112, -113, -112, -114, -113, -113, -113, -113, -113, -113,
-112, -113, -113, -112, -113, -112, -112, -113, -113, -112, -113, -112, -113,
-113, -112, -112, -113, -113, -112, -112, -112, -113, -112, -112, -112, -112,
-112, -113, -112, -113, -113, -112, -112, -112, -112, -112, -112, -112, -112,
-113, -112, -112, -112, -113, -112, -112, -112, -112, -112, -112, -112, -111,
-113, -112, -112, -110, -114, -110, -115, -109, -119, -75, };