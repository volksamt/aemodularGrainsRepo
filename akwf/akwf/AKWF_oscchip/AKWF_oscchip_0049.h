#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0049

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 1, 1,
0, 2, 5, 10, 9, 8, 9, 9, 9, 10, 8, 9, 8, 9, 8, 9, 8, 9, 13, 19, 20, 20, 19, 20,
19, 20, 19, 19, 19, 19, 20, 20, 20, 19, 22, 26, 28, 28, 28, 28, 28, 28, 28, 28,
28, 28, 28, 28, 28, 28, 29, 31, 32, 32, 31, 33, 32, 32, 32, 33, 32, 32, 32, 32,
31, 32, 35, 38, 39, 39, 38, 38, 39, 38, 39, 38, 38, 37, 39, 38, 38, 38, 39, 40,
40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 41, 44, 44, 44, 44, 44,
45, 44, 44, 44, 44, 44, 44, 44, 44, 44, 45, 49, 51, 51, 50, 51, 50, 50, 50, 50,
51, 51, 51, 50, 50, 50, 55, 58, 59, 58, 58, 59, 58, 58, 58, 58, 59, 58, 58, 59,
59, 59, 61, 64, 64, 64, 65, 64, 64, 65, 65, 64, 64, 64, 65, 64, 64, 65, 65, 66,
67, 66, 66, 66, 66, 66, 67, 66, 66, 66, 66, 67, 66, 67, 68, 68, 68, 69, 68, 68,
68, 68, 68, 69, 68, 68, 68, 68, 69, 68, 68, 68, 68, 68, 67, 67, 68, 68, 68, 67,
68, 68, 68, 69, 68, 68, 68, 68, 67, 68, 68, 68, 68, 67, 67, 67, 68, 67, 68, 68,
67, 68, 70, 75, 77, 75, 76, 75, 76, 76, 76, 76, 77, 75, 75, 75, 76, 75, 77, 78,
78, 77, 78, 77, 78, 77, 78, 78, 78, 77, 77, 77, 78, 77, 71, 66, 67, 67, 67, 68,
67, 67, 66, 67, 67, 67, 67, 67, 67, 67, 67, 66, 66, 67, 67, 66, 66, 67, 67, 66,
67, 66, 67, 65, 68, 9, -93, -120, -112, -113, -114, -114, -114, -114, -115,
-114, -114, -115, -115, -115, -113, -112, -107, -106, -106, -106, -106, -106,
-105, -106, -105, -106, -105, -106, -105, -105, -105, -106, -103, -101, -102,
-101, -101, -101, -102, -100, -101, -102, -102, -102, -102, -101, -102, -101,
-97, -93, -93, -93, -92, -92, -92, -92, -92, -92, -93, -92, -92, -93, -92, -92,
-90, -90, -90, -90, -90, -89, -91, -90, -89, -90, -89, -90, -90, -90, -90, -89,
-86, -85, -85, -86, -86, -85, -85, -85, -86, -85, -85, -86, -85, -85, -85, -84,
-81, -79, -79, -79, -80, -79, -79, -79, -79, -79, -79, -79, -79, -78, -79, -78,
-72, -66, -65, -66, -66, -66, -67, -66, -66, -66, -66, -67, -66, -66, -65, -64,
-62, -61, -61, -61, -61, -62, -62, -62, -60, -61, -61, -61, -61, -62, -62, -58,
-49, -46, -47, -47, -47, -46, -46, -47, -45, -46, -46, -46, -47, -47, -46, -47,
-45, -44, -44, -44, -44, -44, -44, -45, -44, -44, -44, -45, -44, -44, -43, -37,
-32, -32, -32, -32, -31, -32, -31, -31, -31, -32, -31, -31, -31, -30, -31, -27,
-20, -18, -19, -18, -19, -19, -18, -19, -19, -18, -18, -18, -19, -18, -19, -14,
-4, };