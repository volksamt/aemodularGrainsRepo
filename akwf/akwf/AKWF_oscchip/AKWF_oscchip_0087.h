#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0087

const PROGMEM int8_t DATA[DATA_LENGTH] = {17, 18, 16, 18, 17, 18, 17, 18, 17,
18, 16, 17, 17, 18, 17, 18, 20, 19, 19, 18, 19, 19, 19, 19, 19, 18, 20, 20, 20,
19, 19, 24, 27, 26, 27, 26, 27, 26, 26, 27, 26, 26, 26, 27, 26, 27, 26, 29, 32,
32, 31, 31, 31, 31, 32, 32, 32, 31, 32, 32, 31, 31, 31, 34, 34, 34, 35, 35, 36,
35, 34, 35, 35, 35, 35, 35, 35, 35, 35, 38, 41, 40, 41, 40, 41, 40, 40, 40, 40,
40, 40, 41, 41, 41, 41, 48, 49, 48, 49, 50, 50, 49, 50, 49, 50, 49, 50, 50, 49,
49, 49, 51, 53, 53, 52, 54, 53, 53, 53, 53, 53, 54, 52, 53, 52, 53, 54, 54, 55,
55, 55, 55, 55, 55, 55, 54, 54, 54, 55, 54, 54, 54, 55, 64, 66, 65, 65, 64, 65,
65, 65, 64, 65, 64, 65, 65, 65, 65, 65, 67, 68, 68, 69, 69, 69, 69, 69, 68, 68,
68, 69, 69, 69, 69, 68, 71, 76, 76, 76, 75, 75, 76, 76, 75, 76, 75, 76, 76, 76,
76, 75, 79, 80, 79, 79, 79, 79, 79, 78, 79, 79, 79, 79, 80, 78, 80, 79, 95, 106,
103, 105, 104, 104, 103, 104, 103, 105, 103, 105, 101, 106, 100, 111, 15, -114,
-109, -113, -112, -111, -111, -111, -112, -111, -111, -111, -112, -111, -112,
-109, -92, -83, -85, -83, -85, -84, -85, -84, -85, -84, -85, -84, -84, -84, -84,
-84, -83, -82, -83, -82, -83, -83, -82, -82, -81, -83, -82, -83, -82, -83, -82,
-83, -76, -67, -68, -68, -68, -68, -68, -68, -69, -68, -67, -68, -68, -68, -67,
-67, -65, -64, -65, -64, -64, -64, -64, -65, -65, -64, -65, -64, -65, -64, -64,
-64, -59, -52, -53, -53, -53, -53, -53, -54, -53, -54, -53, -53, -53, -53, -53,
-53, -51, -45, -45, -45, -44, -43, -44, -44, -44, -43, -44, -44, -44, -44, -44,
-44, -42, -40, -41, -41, -40, -40, -41, -41, -41, -40, -40, -40, -40, -41, -40,
-40, -38, -34, -36, -35, -35, -35, -35, -35, -35, -35, -34, -35, -35, -35, -35,
-35, -35, -31, -31, -31, -31, -32, -32, -31, -31, -31, -31, -31, -31, -31, -31,
-32, -4, 18, 14, 16, 15, 16, 15, 16, 16, 16, 15, 15, 15, 16, 14, 17, 0, -23,
-22, -22, -22, -23, -23, -23, -22, -22, -22, -22, -22, -23, -22, -22, -21, -21,
-21, -20, -20, -21, -21, -20, -20, -20, -21, -20, -20, -20, -20, -20, -17, -15,
-15, -16, -15, -15, -15, -15, -15, -14, -15, -15, -14, -15, -16, -15, -14, -11,
-11, -11, -12, -11, -11, -12, -12, -12, -12, -11, -11, -11, -11, -11, -7, -5,
-6, -6, -6, -6, -6, -7, -7, -7, -5, -6, -6, -7, -5, -6, -6, -6, -6, -6, -6, -7,
-6, -5, -6, -5, -7, -6, -7, -6, -7, -4, -19, -43, -44, -42, -44, -43, -43, -43,
-44, -42, -45, -43, -44, -43, -44, -40, -8, };