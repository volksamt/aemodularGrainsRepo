#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0057

const PROGMEM int8_t DATA[DATA_LENGTH] = {14, 65, 85, 82, 83, 83, 82, 82, 82,
83, 82, 83, 83, 82, 82, 82, 83, 82, 83, 83, 82, 82, 82, 82, 82, 82, 82, 83, 83,
82, 82, 82, 80, 76, 76, 76, 76, 75, 76, 75, 76, 76, 76, 76, 76, 76, 75, 75, 78,
79, 80, 80, 81, 80, 80, 81, 80, 81, 80, 80, 80, 80, 80, 80, 79, 78, 78, 79, 79,
78, 78, 78, 78, 78, 78, 78, 78, 78, 78, 78, 78, 78, 78, 78, 79, 78, 78, 78, 78,
78, 78, 78, 78, 78, 78, 78, 78, 78, 78, 78, 77, 78, 77, 77, 77, 78, 78, 78, 77,
78, 77, 78, 79, 80, 80, 80, 81, 81, 80, 81, 81, 80, 80, 81, 80, 81, 79, 85, 52,
-56, -119, -112, -112, -113, -112, -112, -113, -112, -113, -113, -113, -112,
-112, -113, -113, -112, -112, -112, -113, -112, -112, -113, -112, -112, -112,
-113, -113, -112, -113, -112, -112, -111, -112, -112, -112, -113, -112, -112,
-112, -112, -112, -113, -112, -112, -112, -112, -113, -112, -111, -112, -112,
-112, -112, -113, -112, -112, -111, -112, -112, -111, -113, -103, -53, -14, -16,
-17, -17, -17, -16, -17, -16, -17, -16, -17, -16, -17, -17, -17, -12, -9, -8,
-8, -8, -9, -8, -9, -9, -8, -8, -8, -8, -9, -9, -8, -8, -9, -10, -10, -10, -10,
-10, -11, -11, -9, -10, -10, -10, -9, -11, -10, -10, -11, -11, -11, -11, -12,
-11, -12, -11, -12, -11, -11, -11, -12, -11, -12, -12, -13, -13, -13, -13, -13,
-13, -13, -13, -12, -13, -13, -13, -13, -13, -13, -13, -13, -13, -12, -12, -13,
-13, -13, -12, -12, -13, -13, -13, -13, -13, -13, -12, -12, -11, -11, -11, -11,
-11, -11, -11, -11, -11, -11, -11, -11, -12, -11, -10, -12, -11, -11, -11, -10,
-11, -11, -11, -12, -10, -11, -11, -12, -11, -11, -11, -12, -12, -12, -11, -10,
-12, -11, -11, -11, -10, -12, -11, -11, -11, -11, -10, -12, -12, -11, -11, -12,
-11, -11, -10, -11, -11, -12, -10, -12, -11, -11, -10, -11, -9, -9, -10, -10,
-10, -9, -10, -9, -9, -9, -10, -9, -9, -8, -9, -7, -8, -8, -8, -8, -7, -8, -9,
-8, -8, -8, -7, -8, -8, -8, -7, -8, -8, -8, -8, -8, -7, -7, -8, -7, -8, -8, -7,
-8, -7, -8, -8, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -5, -6, -6,
-7, -8, -7, -7, -8, -7, -7, -8, -8, -7, -8, -7, -8, -8, -8, -7, -7, -6, -6, -7,
-6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -7, -6, -8, -7, -8, -7, -8, -7, -8, -8,
-7, -9, -7, -8, -8, -7, -8, -8, -10, -10, -9, -10, -10, -9, -9, -9, -8, -9, -9,
-9, -10, -9, -10, -9, -9, -9, -10, -9, -9, -9, -10, -10, -9, -9, -9, -8, -9, -9,
-9, -7, -6, -6, -6, -6, -5, -6, -6, -7, -6, -6, -6, -6, -6, -7, -6, };