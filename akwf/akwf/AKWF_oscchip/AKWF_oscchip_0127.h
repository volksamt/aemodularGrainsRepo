#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0127

const PROGMEM int8_t DATA[DATA_LENGTH] = {59, 89, 79, 84, 80, 84, 81, 83, 81,
83, 81, 83, 82, 82, 81, 79, 77, 77, 77, 77, 77, 77, 77, 77, 77, 76, 76, 77, 76,
77, 77, 75, 73, 73, 74, 73, 73, 73, 73, 73, 73, 74, 73, 73, 73, 73, 72, 69, 64,
63, 64, 64, 64, 64, 64, 63, 63, 63, 64, 64, 64, 64, 64, 63, 59, 58, 59, 57, 58,
58, 59, 58, 58, 58, 58, 58, 57, 58, 57, 49, 45, 45, 46, 45, 45, 45, 46, 46, 45,
46, 45, 45, 46, 46, 45, 35, 27, 28, 27, 28, 27, 27, 27, 28, 28, 26, 27, 27, 26,
28, 27, 26, 25, 25, 26, 25, 26, 25, 24, 25, 26, 26, 25, 26, 25, 25, 25, 24, 24,
23, 24, 23, 23, 23, 24, 24, 23, 23, 23, 23, 24, 22, 29, 67, 86, 82, 84, 83, 83,
83, 84, 83, 83, 83, 83, 83, 83, 84, 83, 80, 78, 77, 77, 77, 77, 77, 77, 78, 77,
77, 78, 78, 78, 77, 78, 76, 73, 74, 74, 74, 74, 74, 75, 74, 73, 73, 74, 74, 74,
73, 74, 69, 61, 59, 59, 60, 59, 59, 59, 59, 60, 59, 59, 59, 59, 59, 59, 56, 55,
56, 54, 56, 56, 56, 55, 55, 55, 55, 55, 55, 55, 55, 55, 45, 37, 38, 37, 37, 36,
37, 38, 37, 38, 37, 37, 37, 37, 37, 37, 26, 13, 14, 13, 14, 13, 13, 13, 13, 13,
13, 14, 13, 13, 13, 13, 11, 9, 8, 7, 8, 8, 8, 8, 8, 7, 8, 8, 7, 9, 8, 7, 0, -4,
-2, -3, -2, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -11, -17, -15, -16, -16,
-16, -15, -16, -16, -16, -16, -16, -15, -16, -16, -16, -18, -21, -22, -21, -22,
-20, -21, -21, -21, -21, -21, -22, -22, -21, -21, -21, -24, -31, -30, -30, -30,
-31, -30, -30, -29, -29, -31, -31, -31, -30, -31, -31, -32, -33, -31, -32, -31,
-33, -32, -32, -31, -32, -32, -32, -32, -32, -32, -32, -35, -37, -38, -37, -37,
-38, -38, -37, -37, -38, -37, -37, -38, -37, -37, -37, -45, -53, -52, -52, -52,
-51, -51, -52, -52, -51, -52, -51, -52, -51, -52, -51, -57, -65, -67, -67, -66,
-66, -66, -66, -66, -66, -67, -67, -67, -66, -67, -65, -70, -79, -82, -80, -81,
-81, -81, -80, -81, -80, -81, -81, -80, -80, -81, -82, -95, -105, -103, -104,
-105, -104, -104, -104, -104, -103, -104, -104, -104, -104, -104, -104, -111,
-119, -119, -119, -118, -119, -118, -119, -119, -119, -118, -118, -117, -118,
-118, -120, -99, -66, -63, -64, -63, -64, -65, -64, -64, -63, -65, -64, -64,
-64, -64, -63, -66, -71, -72, -70, -70, -71, -71, -70, -71, -71, -70, -71, -71,
-71, -71, -71, -71, -73, -72, -72, -72, -73, -72, -72, -73, -72, -72, -72, -73,
-72, -72, -72, -77, -80, -80, -79, -80, -79, -80, -79, -80, -79, -80, -79, -80,
-80, -80, -79, -23, };