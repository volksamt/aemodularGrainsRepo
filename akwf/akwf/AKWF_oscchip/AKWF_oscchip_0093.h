#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0093

const PROGMEM int8_t DATA[DATA_LENGTH] = {40, 113, 104, 109, 106, 107, 106, 106,
107, 106, 108, 106, 108, 106, 108, 106, 106, 103, 103, 103, 104, 103, 103, 102,
103, 102, 104, 103, 103, 102, 102, 102, 94, 91, 92, 91, 91, 91, 91, 90, 91, 92,
91, 91, 91, 91, 91, 91, 81, 75, 76, 75, 76, 76, 76, 75, 76, 75, 75, 75, 76, 75,
77, 69, 49, 48, 49, 49, 49, 48, 49, 47, 49, 48, 49, 48, 48, 48, 48, 50, 65, 69,
68, 68, 68, 67, 67, 68, 68, 67, 67, 68, 67, 68, 67, 67, 42, 26, 30, 28, 29, 28,
29, 29, 28, 29, 28, 29, 27, 30, 25, 51, 111, 118, 115, 117, 115, 117, 116, 115,
116, 116, 115, 116, 116, 116, 115, 116, 110, 110, 109, 110, 109, 109, 109, 110,
110, 109, 110, 110, 109, 109, 110, 109, 102, 97, 98, 98, 98, 98, 99, 98, 98, 98,
97, 98, 99, 98, 98, 94, 87, 86, 86, 86, 86, 86, 87, 86, 86, 85, 86, 85, 87, 86,
86, 84, 73, 69, 71, 70, 70, 70, 70, 71, 70, 70, 71, 70, 70, 71, 70, 70, 61, 54,
55, 54, 55, 55, 54, 55, 54, 55, 55, 55, 55, 54, 55, 52, 43, 43, 43, 43, 43, 43,
44, 42, 43, 43, 44, 42, 44, 42, 44, 39, 11, 2, 5, 2, 4, 4, 4, 3, 5, 4, 4, 4, 3,
4, 3, 3, -74, -123, -114, -119, -115, -117, -116, -117, -116, -116, -116, -117,
-117, -117, -117, -113, -102, -100, -101, -101, -101, -100, -101, -101, -102,
-100, -100, -100, -100, -100, -102, -99, -91, -88, -89, -89, -89, -89, -90, -88,
-88, -89, -89, -89, -90, -89, -90, -88, -79, -72, -74, -73, -73, -74, -73, -73,
-74, -73, -73, -73, -74, -73, -74, -70, -62, -62, -61, -62, -62, -61, -62, -61,
-62, -62, -61, -61, -62, -61, -61, -57, -39, -34, -35, -33, -34, -34, -34, -34,
-34, -34, -34, -33, -34, -34, -34, -34, -20, -12, -13, -13, -13, -13, -14, -13,
-13, -13, -13, -13, -13, -12, -13, -11, -5, -5, -4, -5, -5, -5, -5, -5, -5, -6,
-6, -5, -5, -4, -5, -6, -7, -9, -9, -9, -9, -9, -9, -9, -9, -9, -9, -8, -8, -9,
-8, -14, -21, -21, -21, -20, -20, -20, -20, -20, -20, -20, -20, -21, -20, -21,
-20, -24, -35, -36, -36, -36, -36, -36, -35, -35, -36, -36, -35, -36, -36, -36,
-36, -37, -51, -57, -55, -56, -55, -55, -54, -56, -55, -55, -56, -56, -55, -55,
-54, -62, -71, -71, -71, -71, -70, -70, -71, -70, -71, -70, -70, -71, -70, -70,
-70, -74, -84, -84, -84, -84, -84, -84, -84, -84, -84, -84, -84, -84, -85, -84,
-83, -86, -100, -105, -103, -104, -103, -103, -103, -104, -103, -103, -104,
-104, -102, -103, -103, -108, -115, -115, -115, -115, -115, -116, -115, -116,
-114, -115, -114, -114, -115, -115, -115, -114, -116, -115, -116, -115, -117,
-116, -117, -115, -118, -115, -119, -114, -120, -113, -123, -86, };