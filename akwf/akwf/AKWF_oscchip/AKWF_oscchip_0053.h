#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0053

const PROGMEM int8_t DATA[DATA_LENGTH] = {19, 75, 94, 91, 92, 91, 91, 91, 91,
91, 91, 91, 91, 91, 92, 92, 91, 88, 87, 87, 87, 88, 88, 87, 88, 87, 88, 87, 88,
88, 87, 87, 85, 72, 62, 62, 63, 63, 62, 63, 63, 63, 62, 62, 63, 62, 62, 63, 63,
56, 49, 48, 48, 48, 48, 49, 48, 49, 49, 48, 49, 48, 48, 48, 46, 39, 37, 37, 37,
37, 37, 38, 38, 37, 37, 37, 37, 38, 37, 38, 36, 31, 27, 29, 29, 29, 28, 29, 29,
29, 28, 28, 28, 29, 29, 28, 27, 24, 19, 20, 20, 19, 19, 20, 19, 19, 19, 19, 20,
20, 20, 19, 18, 18, 18, 17, 17, 17, 18, 18, 17, 17, 18, 17, 18, 18, 17, 17, 16,
16, 16, 16, 15, 15, 16, 16, 16, 16, 15, 15, 15, 16, 15, 16, 15, 10, 9, 9, 9, 9,
9, 9, 9, 9, 9, 8, 9, 9, 8, 8, 7, 7, 4, 5, 5, 5, 5, 4, 5, 5, 4, 5, 5, 4, 5, 5, 3,
2, 1, 2, 2, 2, 1, 1, 1, 1, 2, 2, 2, 2, 2, 1, 1, 0, -1, -1, 0, 0, 0, -1, 0, -1,
0, 0, 0, 0, 0, 0, -1, -2, -2, -3, -2, -1, -1, -2, -2, -2, -2, -3, -2, -2, -1,
-2, 1, 15, 24, 24, 24, 25, 24, 25, 24, 24, 24, 25, 24, 25, 25, 24, -2, -32, -35,
-34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -35, -38, -40,
-39, -40, -38, -39, -39, -39, -39, -39, -39, -39, -39, -39, -39, -40, -39, -41,
-41, -41, -41, -41, -40, -41, -40, -40, -41, -41, -41, -41, -38, -19, -5, -6,
-5, -6, -6, -5, -5, -5, -5, -5, -5, -5, -5, -6, -5, -6, -5, -5, -6, -5, -5, -5,
-6, -5, -6, -5, -4, -5, -5, -5, -6, -6, -5, -4, -6, -5, -6, -5, -5, -5, -5, -5,
-5, -5, -5, -6, -4, -10, -21, -26, -24, -25, -24, -25, -25, -24, -25, -25, -25,
-25, -25, -25, -22, -14, -6, -6, -6, -7, -7, -7, -7, -7, -7, -6, -7, -7, -7, -6,
-11, -62, -113, -118, -115, -116, -116, -116, -115, -115, -116, -116, -116,
-116, -116, -116, -116, -115, -115, -115, -116, -117, -115, -115, -116, -115,
-115, -116, -116, -117, -115, -117, -98, -52, -34, -37, -37, -35, -36, -36, -36,
-36, -36, -36, -36, -36, -36, -37, -32, -12, 2, 2, 1, 1, 0, 2, 1, 1, 1, 1, 1, 1,
1, 1, 2, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, -1, 0, 0, -1, 0, -1, -1, -2, -2, -2,
-2, -2, -2, -2, -2, -3, -2, -2, -2, -3, -2, -3, -5, -6, -6, -5, -6, -6, -6, -6,
-6, -6, -5, -6, -5, -6, -6, -6, -6, -7, -8, -8, -7, -8, -8, -8, -8, -7, -7, -7,
-7, -8, -8, -8, -8, -7, -8, -7, -8, -7, -8, -7, -8, -7, -8, -8, -8, -8, -8, -7,
};