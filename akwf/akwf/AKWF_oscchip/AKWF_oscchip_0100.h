#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0100

const PROGMEM int8_t DATA[DATA_LENGTH] = {27, 52, 47, 49, 49, 50, 48, 49, 49,
49, 49, 50, 49, 49, 49, 49, 38, 27, 29, 27, 28, 27, 28, 27, 28, 27, 28, 27, 28,
27, 30, 25, 46, 78, 77, 78, 78, 77, 78, 78, 78, 77, 78, 78, 78, 78, 78, 76, 43,
26, 29, 27, 28, 27, 28, 27, 28, 27, 28, 27, 28, 26, 30, 27, 72, 117, 111, 114,
113, 113, 113, 113, 113, 113, 114, 113, 113, 113, 113, 112, 115, 117, 118, 117,
117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 115, 58, 28, 35, 32, 35,
32, 34, 33, 34, 33, 35, 34, 34, 33, 35, 32, 78, 121, 115, 117, 115, 117, 116,
117, 116, 118, 117, 117, 117, 117, 118, 116, 117, 114, 115, 113, 115, 114, 114,
114, 115, 114, 115, 115, 114, 115, 116, 107, 16, -28, -17, -23, -20, -22, -21,
-21, -21, -21, -20, -21, -22, -21, -22, -21, -48, -74, -70, -73, -71, -71, -71,
-73, -70, -72, -70, -72, -69, -73, -68, -78, -6, 104, 100, 102, 102, 102, 102,
102, 102, 102, 102, 101, 102, 101, 103, 101, 99, 97, 98, 97, 98, 96, 98, 97, 98,
98, 98, 98, 97, 98, 97, 97, 90, 85, 86, 85, 85, 84, 85, 85, 85, 84, 85, 85, 86,
85, 84, 84, 81, 80, 81, 80, 81, 80, 80, 81, 80, 80, 80, 81, 80, 81, 80, 79, 63,
54, 56, 55, 56, 55, 55, 55, 56, 56, 55, 55, 55, 55, 55, 56, 41, 27, 29, 28, 28,
27, 29, 27, 28, 29, 29, 28, 28, 28, 28, 24, 2, -2, -1, -1, -1, -1, -1, -2, -1,
-2, 0, -1, -1, -1, 0, -1, -4, -6, -5, -6, -5, -5, -5, -5, -5, -5, -6, -6, -5,
-5, -6, -5, -25, -44, -42, -44, -43, -43, -43, -43, -42, -43, -43, -42, -42,
-43, -42, -46, -57, -60, -60, -60, -60, -59, -59, -60, -59, -60, -59, -60, -60,
-60, -60, -60, -69, -72, -71, -73, -71, -72, -72, -72, -72, -72, -72, -73, -72,
-72, -72, -71, -81, -89, -88, -89, -88, -88, -89, -88, -88, -88, -88, -88, -89,
-88, -88, -89, -92, -93, -92, -92, -93, -93, -93, -93, -92, -92, -92, -93, -92,
-93, -93, -90, -45, -21, -26, -22, -24, -23, -24, -23, -24, -23, -24, -23, -25,
-23, -25, -23, -69, -112, -107, -111, -108, -110, -108, -109, -108, -109, -109,
-108, -109, -109, -108, -109, -116, -117, -117, -117, -117, -117, -117, -117,
-118, -117, -117, -117, -116, -117, -118, -118, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -118, -119, -119, -112, -106,
-107, -106, -106, -107, -107, -106, -106, -105, -106, -106, -106, -105, -106,
-104, -92, -88, -90, -89, -89, -89, -89, -89, -89, -89, -90, -89, -89, -89, -90,
-88, -76, -72, -72, -72, -72, -72, -72, -72, -73, -73, -73, -72, -72, -72, -72,
-74, -49, -28, -31, -30, -30, -30, -31, -30, -31, -30, -31, -30, -31, -30, -32,
-20, };