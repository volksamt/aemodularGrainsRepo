#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0125

const PROGMEM int8_t DATA[DATA_LENGTH] = {79, 120, 106, 115, 108, 112, 109, 112,
110, 111, 111, 112, 110, 111, 110, 111, 110, 111, 111, 111, 111, 110, 111, 111,
112, 110, 110, 111, 111, 111, 110, 110, 111, 111, 111, 111, 110, 112, 110, 111,
111, 111, 111, 111, 111, 111, 111, 111, 111, 110, 111, 111, 111, 110, 111, 110,
111, 111, 111, 111, 111, 111, 111, 111, 111, 111, 111, 111, 111, 110, 111, 110,
110, 110, 110, 111, 110, 111, 111, 111, 111, 112, 110, 111, 111, 111, 110, 111,
111, 110, 111, 110, 110, 111, 112, 110, 111, 111, 111, 110, 112, 111, 111, 112,
111, 110, 112, 111, 111, 110, 111, 111, 110, 110, 110, 111, 111, 111, 111, 111,
111, 111, 111, 110, 111, 111, 110, 111, 110, 111, 110, 111, 110, 111, 111, 111,
111, 112, 110, 110, 111, 111, 110, 110, 111, 111, 111, 111, 111, 111, 110, 111,
110, 111, 111, 111, 110, 111, 111, 110, 111, 110, 111, 112, 111, 110, 110, 111,
110, 111, 111, 111, 110, 111, 111, 111, 111, 111, 111, 111, 111, 111, 111, 110,
111, 111, 111, 110, 111, 111, 111, 112, 110, 110, 111, 111, 111, 111, 111, 112,
111, 111, 111, 111, 110, 111, 111, 111, 111, 111, 110, 111, 111, 111, 111, 111,
111, 111, 111, 111, 111, 110, 111, 110, 111, 111, 112, 111, 111, 111, 110, 111,
111, 111, 112, 110, 111, 109, 110, 58, -5, -6, -5, -5, -5, -6, -5, -5, -5, -6,
-6, -6, -5, -5, -4, -5, -5, -6, -5, -6, -6, -6, -4, -6, -6, -5, -5, -5, -5, -6,
-6, -5, -4, -4, -4, -4, -4, -4, -4, -3, -4, -3, -4, -4, -4, -3, -3, -4, -2, -2,
-1, -1, -2, -2, -2, -1, -2, -1, -1, -2, -1, -2, -1, -2, 0, 0, 0, 0, 0, 1, 0, 1,
0, 0, 0, 0, 0, 0, 0, -3, -8, -8, -8, -9, -9, -9, -9, -8, -8, -9, -8, -9, -9, -9,
-8, -8, -9, -9, -8, -9, -9, -9, -10, -8, -9, -8, -9, -9, -9, -9, -9, -8, -6, -5,
-5, -5, -6, -6, -6, -6, -6, -5, -5, -5, -6, -5, -6, -4, -2, -1, -1, -2, -2, -1,
-2, -2, -1, -2, -3, -2, -2, -1, -2, 0, 2, 2, 1, 2, 1, 1, 2, 1, 2, 1, 2, 2, 2, 2,
1, 1, -1, -3, -1, -2, -2, -2, -2, -2, -1, -2, -1, -2, -2, -1, -2, -1, -2, -2,
-2, -2, -2, -2, -2, -2, -2, -2, -1, -2, -2, -2, -2, -2, -2, -2, -1, -2, -2, -1,
-2, -1, -2, -3, -1, -2, -1, -3, -1, -42, -107, -114, -111, -113, -111, -112,
-111, -112, -111, -112, -111, -112, -111, -112, -111, -113, -111, -111, -112,
-111, -112, -112, -111, -111, -112, -112, -112, -112, -112, -111, -112, -112,
-112, -112, -112, -112, -112, -112, -112, -112, -112, -111, -111, -112, -112,
-112, -112, -112, -112, -111, -111, -112, -111, -112, -111, -113, -112, -113,
-112, -113, -111, -111, -111, -35, };