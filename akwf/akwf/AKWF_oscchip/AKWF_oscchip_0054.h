#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0054

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 2, 3, 3, 3, 4, 3, 2, 3, 3, 3, 3,
3, 3, 3, 4, 4, 5, 5, 4, 5, 5, 5, 5, 4, 4, 5, 4, 4, 5, 7, 9, 9, 9, 8, 9, 9, 9, 9,
9, 9, 9, 9, 9, 9, 9, 10, 11, 12, 11, 12, 12, 11, 12, 12, 11, 11, 11, 11, 12, 12,
10, 20, 54, 74, 71, 72, 72, 72, 72, 72, 71, 72, 72, 72, 72, 71, 72, 72, 71, 72,
72, 71, 72, 72, 71, 72, 71, 72, 71, 71, 72, 71, 71, 72, 71, 71, 72, 72, 71, 72,
72, 72, 71, 71, 72, 71, 72, 71, 72, 72, 72, 72, 72, 71, 71, 71, 72, 71, 71, 71,
71, 71, 72, 70, 75, 50, -51, -118, -114, -112, -115, -112, -114, -114, -113,
-113, -113, -113, -114, -114, -113, -113, -114, -114, -113, -112, -113, -113,
-113, -114, -113, -113, -113, -114, -113, -114, -114, -56, 39, 68, 58, 61, 61,
61, 60, 61, 60, 61, 60, 60, 61, 61, 61, 59, 58, 56, 57, 55, 56, 56, 57, 56, 56,
56, 57, 57, 56, 55, 56, 55, 53, 50, 51, 50, 50, 51, 51, 50, 50, 50, 50, 51, 51,
50, 50, 48, 45, 44, 44, 45, 45, 45, 44, 44, 44, 44, 45, 45, 45, 45, 45, 42, 35,
33, 33, 33, 32, 33, 32, 33, 33, 32, 32, 33, 33, 33, 33, 31, 25, 21, 22, 22, 21,
21, 21, 21, 20, 21, 22, 21, 21, 21, 21, 21, 20, 19, 18, 18, 19, 18, 18, 18, 18,
18, 18, 18, 19, 19, 18, 22, 26, 28, 26, 26, 27, 27, 27, 27, 27, 26, 27, 27, 28,
26, 27, 24, 17, 15, 15, 15, 15, 14, 16, 15, 15, 15, 15, 15, 15, 15, 15, 14, 7,
4, 4, 3, 4, 4, 4, 3, 3, 3, 3, 4, 4, 4, 4, -6, -16, -17, -16, -16, -17, -17, -17,
-17, -17, -17, -17, -17, -17, -16, -16, -25, -40, -44, -42, -43, -42, -43, -43,
-43, -43, -42, -42, -43, -43, -43, -43, -47, -64, -72, -72, -72, -71, -72, -71,
-71, -71, -72, -72, -71, -71, -72, -72, -75, -96, -115, -114, -114, -114, -113,
-114, -113, -113, -114, -114, -114, -114, -113, -114, -113, -114, -113, -113,
-114, -114, -114, -113, -113, -113, -113, -113, -113, -113, -113, -113, -91,
-39, -21, -26, -25, -25, -25, -24, -25, -25, -24, -25, -25, -25, -25, -26, -25,
-20, -19, -18, -19, -19, -20, -20, -19, -19, -19, -19, -20, -19, -19, -19, -13,
-8, -9, -9, -9, -9, -9, -9, -8, -8, -9, -9, -9, -8, -8, -9, -6, -5, -4, -4, -4,
-4, -5, -4, -4, -4, -4, -4, -3, -4, -4, -4, -5, -3, -3, -2, -3, -3, -3, -3, -3,
-3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -4, -2, -3, -3, -2, -3,
-3, -3, -3, -2, -1, -2, -1, -2, -2, -1, -2, -2, -1, -2, -1, -2, -1, -1, -2, 1,
};