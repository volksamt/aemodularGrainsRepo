#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0136

const PROGMEM int8_t DATA[DATA_LENGTH] = {83, 121, 107, 115, 110, 114, 110, 113,
110, 113, 112, 112, 112, 112, 112, 112, 110, 109, 108, 109, 108, 108, 108, 108,
109, 108, 109, 108, 109, 108, 109, 108, 102, 97, 98, 98, 99, 98, 99, 98, 99, 98,
98, 97, 98, 97, 98, 94, 88, 89, 89, 88, 87, 88, 88, 87, 88, 88, 88, 87, 88, 87,
88, 84, 76, 74, 74, 75, 74, 75, 75, 74, 75, 75, 75, 74, 75, 74, 75, 73, 69, 67,
68, 67, 69, 68, 68, 67, 68, 67, 68, 67, 68, 68, 68, 67, 57, 50, 50, 51, 51, 51,
51, 51, 51, 51, 50, 51, 51, 51, 51, 49, 45, 46, 45, 46, 46, 46, 45, 46, 46, 46,
45, 46, 46, 46, 46, 43, 40, 39, 39, 39, 39, 39, 39, 39, 39, 39, 39, 39, 39, 39,
39, 38, 36, 35, 35, 35, 35, 36, 35, 35, 35, 36, 34, 36, 35, 36, 36, 34, 32, 31,
30, 31, 31, 30, 30, 30, 30, 30, 30, 30, 30, 30, 31, 29, 29, 29, 28, 28, 28, 29,
28, 28, 29, 28, 29, 28, 28, 28, 28, 26, 22, 20, 20, 21, 20, 20, 20, 20, 20, 20,
20, 20, 20, 20, 20, 20, 16, 15, 15, 15, 15, 15, 15, 15, 14, 15, 15, 15, 15, 15,
15, 14, 13, 12, 13, 12, 12, 11, 12, 12, 12, 12, 12, 11, 13, 11, 11, -30, -82,
-83, -81, -82, -81, -82, -83, -82, -81, -82, -83, -83, -82, -82, -82, -76, -65,
-63, -63, -63, -64, -63, -63, -64, -63, -64, -64, -63, -63, -63, -64, -62, -58,
-56, -57, -57, -57, -56, -57, -57, -57, -56, -56, -57, -57, -57, -57, -55, -47,
-43, -44, -43, -43, -43, -43, -43, -42, -43, -44, -43, -44, -43, -43, -38, -33,
-33, -33, -34, -33, -33, -33, -33, -32, -32, -33, -32, -33, -33, -33, -34, -35,
-35, -35, -35, -35, -35, -35, -34, -35, -34, -34, -35, -35, -35, -35, -35, -38,
-38, -38, -38, -38, -39, -37, -38, -38, -38, -38, -38, -38, -38, -38, -40, -48,
-52, -50, -52, -52, -51, -50, -52, -51, -51, -52, -51, -52, -51, -51, -44, -35,
-35, -35, -35, -35, -34, -34, -35, -35, -35, -35, -34, -34, -34, -34, -45, -66,
-68, -68, -68, -68, -68, -69, -69, -68, -68, -67, -68, -68, -68, -67, -71, -79,
-82, -81, -82, -81, -81, -81, -81, -81, -81, -82, -80, -80, -81, -80, -82, -84,
-87, -86, -86, -86, -86, -86, -86, -86, -86, -86, -85, -85, -86, -85, -58, -29,
-30, -30, -31, -31, -31, -31, -30, -30, -31, -31, -30, -31, -30, -32, -18, 4, 5,
5, 5, 5, 5, 4, 5, 5, 5, 4, 5, 5, 4, 4, 2, -7, -10, -8, -9, -9, -9, -9, -9, -8,
-8, -9, -9, -8, -9, -8, -13, -31, -38, -37, -37, -37, -37, -36, -37, -37, -37,
-37, -37, -36, -37, -38, -62, -83, -83, -81, -82, -81, -83, -81, -83, -82, -82,
-81, -82, -81, -82, -80, -18, };