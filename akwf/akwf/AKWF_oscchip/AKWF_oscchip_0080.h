#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0080

const PROGMEM int8_t DATA[DATA_LENGTH] = {23, 92, 101, 97, 99, 98, 99, 97, 99,
98, 98, 98, 99, 98, 98, 98, 98, 95, 96, 95, 95, 94, 95, 94, 94, 94, 95, 95, 94,
95, 94, 94, 92, 87, 88, 87, 87, 88, 87, 88, 87, 87, 87, 88, 87, 87, 87, 88, 84,
77, 76, 77, 76, 76, 76, 76, 76, 76, 75, 76, 76, 76, 75, 77, 76, 70, 68, 69, 68,
69, 69, 69, 69, 69, 69, 69, 68, 69, 69, 68, 66, 61, 62, 60, 61, 62, 62, 62, 61,
61, 61, 61, 61, 62, 61, 62, 60, 58, 57, 57, 57, 58, 57, 57, 58, 57, 57, 58, 57,
57, 57, 59, 50, 5, -10, -6, -9, -7, -8, -7, -9, -6, -9, -7, -10, -5, -11, -3,
-51, -118, -116, -117, -115, -118, -116, -117, -116, -117, -115, -118, -115,
-118, -114, -121, -86, -1, 9, 5, 8, 5, 8, 6, 8, 6, 9, 5, 7, 5, 9, 3, 19, 93,
117, 109, 113, 110, 112, 111, 113, 113, 112, 113, 111, 113, 110, 116, 70, 8, 12,
10, 10, 11, 11, 11, 10, 11, 10, 12, 10, 11, 10, 11, 11, 10, 11, 10, 10, 10, 11,
10, 10, 10, 11, 10, 11, 10, 11, 8, 22, 91, 112, 105, 110, 107, 109, 107, 109,
107, 108, 108, 109, 107, 108, 108, 105, 101, 101, 101, 100, 101, 101, 101, 100,
101, 100, 102, 99, 102, 99, 104, 76, 12, 5, 7, 6, 7, 6, 7, 7, 7, 6, 7, 6, 7, 6,
6, 6, 6, 7, 6, 6, 6, 6, 6, 7, 6, 6, 6, 7, 6, 7, 6, 5, 2, 3, 3, 3, 2, 2, 3, 2, 3,
3, 3, 3, 4, 3, 3, 1, -4, -5, -4, -5, -4, -4, -4, -5, -5, -6, -4, -5, -4, -5, -3,
-14, -76, -96, -91, -93, -90, -92, -91, -92, -92, -91, -91, -91, -91, -91, -92,
-85, -77, -77, -77, -77, -77, -77, -77, -77, -77, -77, -78, -77, -77, -76, -77,
-76, -74, -73, -73, -73, -73, -74, -73, -73, -73, -74, -72, -73, -73, -74, -73,
-73, -74, -73, -73, -73, -74, -73, -73, -73, -73, -73, -72, -73, -74, -72, -73,
-73, -73, -73, -73, -73, -72, -73, -73, -73, -73, -73, -73, -72, -72, -73, -73,
-74, -76, -76, -76, -77, -76, -76, -77, -77, -76, -77, -77, -77, -76, -77, -76,
-77, -76, -77, -76, -75, -76, -76, -75, -76, -76, -76, -76, -77, -76, -77, -77,
-76, -77, -76, -76, -75, -76, -76, -76, -76, -76, -76, -76, -76, -76, -76, -76,
-76, -76, -76, -76, -76, -76, -76, -76, -75, -76, -76, -75, -76, -76, -76, -76,
-75, -75, -76, -76, -75, -76, -75, -76, -75, -75, -76, -77, -74, -78, -74, -78,
-46, -2, -3, -3, -3, -3, -3, -3, -3, -3, -2, -3, -4, -4, -3, -3, -2, -3, -3, -4,
-3, -3, -3, -3, -2, -3, -4, -3, -4, -3, -3, -3, -4, -3, -4, -3, -4, -3, -4, -2,
-4, -3, -3, -3, -4, -2, -3, -5, };