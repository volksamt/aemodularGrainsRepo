#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 100, 118, 110, 116, 112, 115, 112,
114, 113, 115, 113, 114, 113, 115, 113, 109, 98, 97, 96, 96, 96, 97, 97, 97, 97,
97, 97, 97, 97, 96, 97, 96, 92, 90, 90, 90, 89, 89, 90, 90, 90, 90, 90, 89, 89,
89, 90, 89, 80, 73, 74, 73, 73, 74, 74, 73, 73, 73, 74, 74, 74, 73, 73, 72, 64,
59, 59, 60, 59, 60, 60, 60, 59, 60, 59, 59, 59, 60, 60, 59, 49, 43, 43, 43, 43,
43, 44, 43, 43, 43, 43, 43, 43, 43, 43, 41, 28, 24, 24, 25, 25, 25, 25, 25, 25,
25, 25, 24, 25, 24, 25, 23, 12, 7, 9, 8, 8, 7, 9, 8, 9, 8, 8, 8, 8, 8, 9, 6, -2,
-4, -3, -3, -2, -4, -3, -3, -3, -3, -4, -4, -3, -3, -3, -5, -10, -13, -11, -11,
-11, -12, -12, -11, -11, -12, -12, -11, -12, -12, -12, -12, -17, -17, -18, -17,
-17, -18, -16, -17, -18, -17, -17, -16, -17, -17, -17, -18, -22, -22, -22, -21,
-22, -22, -22, -22, -22, -22, -22, -22, -22, -22, -21, -23, -25, -25, -26, -25,
-25, -25, -25, -25, -25, -25, -24, -25, -25, -25, -26, -26, -29, -29, -28, -29,
-29, -29, -29, -29, -28, -29, -28, -28, -29, -29, -29, -29, -30, -30, -30, -31,
-31, -31, -31, -31, -31, -31, -31, -30, -31, -31, -30, -33, -34, -34, -34, -34,
-35, -35, -34, -34, -34, -34, -34, -34, -34, -34, -35, -34, -34, -35, -34, -34,
-34, -34, -34, -34, -34, -35, -34, -34, -34, -34, -34, -34, -34, -35, -34, -33,
-34, -34, -34, -34, -34, -34, -35, -34, -34, -34, -35, -34, -34, -34, -34, -34,
-34, -34, -35, -34, -34, -34, -34, -34, -34, -34, -36, -20, 18, 26, 23, 25, 23,
24, 24, 24, 24, 24, 23, 24, 23, 23, 24, 23, 19, 18, 17, 18, 18, 17, 19, 18, 18,
18, 19, 17, 18, 18, 18, 17, 13, 13, 14, 13, 14, 13, 14, 14, 14, 13, 13, 13, 13,
13, 13, 13, 13, 12, 12, 13, 12, 13, 13, 11, 12, 12, 13, 12, 12, 12, 14, -8, -35,
-33, -35, -34, -34, -34, -33, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34,
-34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -33, -35, -33, -34, -34, -34,
-34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -33, -35, -34, -34, -34,
-34, -34, -34, -34, -34, -34, -34, -33, -34, -34, -33, -34, -34, -34, -34, -33,
-34, -34, -33, -34, -34, -34, -33, -33, -34, -34, -34, -34, -33, -34, -34, -34,
-34, -34, -34, -34, -34, -34, -33, -33, -34, -34, -34, -33, -34, -34, -33, -33,
-34, -34, -34, -33, -34, -33, -34, -33, -34, -33, -33, -34, -33, -34, -34, -34,
-34, -33, -34, -34, -33, -33, -33, -33, -33, -34, -33, -34, -34, -34, -34, -33,
-34, -33, -34, -33, -34, -33, -34, -32, -35, -33, -35, -32, -35, -31, };