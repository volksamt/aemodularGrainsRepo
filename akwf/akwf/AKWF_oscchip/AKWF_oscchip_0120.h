#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0120

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 11, 10, 11, 10, 11, 10, 10, 10, 11,
11, 11, 11, 11, 11, 12, 13, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14,
13, 13, 15, 15, 16, 16, 16, 15, 16, 16, 16, 16, 15, 16, 15, 16, 16, 16, 16, 17,
17, 17, 18, 17, 17, 17, 18, 16, 17, 17, 17, 17, 17, 18, 21, 22, 21, 22, 22, 22,
21, 22, 22, 22, 22, 22, 23, 22, 22, 23, 24, 25, 26, 25, 24, 26, 24, 25, 25, 25,
25, 25, 25, 26, 26, 25, 26, 27, 27, 26, 26, 26, 26, 27, 27, 26, 27, 27, 27, 27,
27, 28, 29, 28, 28, 28, 28, 29, 28, 28, 28, 28, 28, 27, 28, 29, 28, 29, 31, 31,
31, 32, 32, 31, 32, 32, 31, 31, 31, 31, 31, 31, 31, 32, 32, 33, 33, 33, 33, 32,
33, 33, 33, 33, 33, 33, 33, 32, 34, 33, 34, 34, 34, 34, 35, 35, 35, 34, 35, 35,
34, 34, 34, 34, 34, 29, 22, 22, 22, 21, 22, 22, 22, 21, 22, 22, 22, 22, 22, 21,
21, 26, 36, 38, 37, 37, 37, 38, 38, 38, 38, 38, 38, 38, 37, 38, 37, 38, 39, 38,
39, 39, 39, 39, 40, 38, 40, 39, 39, 40, 39, 39, 39, 39, 39, 40, 39, 40, 39, 39,
40, 39, 39, 39, 39, 39, 39, 39, 39, 39, 41, 42, 42, 42, 43, 42, 42, 43, 42, 42,
42, 42, 41, 42, 43, 41, 41, 41, 41, 41, 41, 40, 41, 41, 40, 41, 40, 41, 40, 40,
40, 42, 44, 43, 43, 44, 44, 44, 43, 44, 43, 44, 43, 43, 44, 44, 44, 45, 45, 48,
47, 46, 47, 47, 46, 47, 46, 47, 47, 47, 47, 47, 46, 48, 47, 47, 46, 47, 47, 47,
46, 47, 46, 47, 46, 47, 46, 46, 47, 48, 50, 49, 51, 49, 50, 50, 50, 49, 51, 49,
51, 50, 51, 48, 53, 16, -88, -119, -110, -114, -112, -114, -112, -114, -113,
-113, -113, -113, -113, -113, -113, -112, -109, -107, -107, -107, -107, -106,
-107, -107, -106, -107, -106, -106, -106, -106, -106, -105, -100, -94, -96, -95,
-95, -95, -95, -95, -94, -96, -96, -95, -95, -95, -95, -92, -88, -87, -86, -87,
-87, -87, -87, -86, -87, -87, -87, -87, -87, -87, -89, -75, -38, -29, -31, -29,
-30, -30, -30, -30, -30, -29, -30, -30, -30, -30, -30, -31, -34, -37, -36, -37,
-37, -36, -37, -36, -37, -37, -36, -37, -36, -37, -37, -36, -43, -47, -46, -46,
-47, -46, -46, -46, -46, -46, -46, -46, -46, -46, -46, -51, -59, -59, -59, -58,
-59, -58, -60, -59, -59, -59, -59, -58, -59, -59, -59, -62, -68, -71, -70, -71,
-70, -70, -70, -70, -70, -70, -70, -70, -71, -69, -71, -62, -24, -7, -12, -10,
-11, -10, -11, -10, -11, -11, -10, -10, -10, -11, -11, -11, -10, -8, -9, -9, -8,
-9, -8, -8, -8, -9, -8, -10, -9, -9, -9, -3, };