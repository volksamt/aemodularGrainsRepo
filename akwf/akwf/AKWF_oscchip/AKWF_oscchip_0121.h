#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0121

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 2, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1,
2, 3, 15, 22, 21, 20, 20, 20, 21, 21, 20, 21, 20, 21, 21, 20, 21, 20, 25, 28,
29, 28, 28, 28, 28, 28, 29, 28, 28, 28, 29, 28, 28, 28, 35, 47, 47, 47, 47, 47,
48, 46, 48, 46, 47, 47, 48, 47, 47, 49, 54, 55, 55, 55, 55, 55, 54, 55, 55, 55,
54, 54, 55, 55, 55, 53, 45, 39, 40, 40, 39, 40, 39, 40, 39, 39, 39, 39, 39, 40,
40, 40, 48, 56, 55, 55, 54, 55, 55, 55, 55, 54, 54, 54, 54, 55, 54, 54, 56, 58,
58, 58, 59, 58, 59, 59, 58, 58, 58, 59, 58, 58, 59, 59, 61, 62, 62, 62, 62, 63,
62, 62, 62, 62, 62, 62, 62, 63, 62, 63, 66, 66, 65, 66, 66, 66, 66, 67, 66, 66,
66, 66, 66, 66, 67, 66, 68, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 69, 70,
69, 69, 70, 72, 72, 71, 71, 72, 71, 72, 72, 72, 71, 72, 72, 72, 71, 73, 77, 80,
79, 79, 78, 79, 79, 80, 79, 79, 78, 79, 79, 80, 79, 81, 90, 95, 93, 94, 94, 94,
95, 94, 94, 94, 95, 94, 94, 95, 95, 92, 67, 46, 47, 47, 48, 47, 47, 47, 47, 48,
48, 47, 46, 48, 46, 47, -25, -113, -113, -113, -113, -112, -114, -113, -114,
-113, -114, -113, -113, -113, -113, -112, -109, -106, -108, -107, -108, -108,
-108, -108, -108, -108, -107, -107, -108, -108, -107, -107, -104, -103, -104,
-103, -103, -104, -104, -103, -104, -104, -104, -103, -104, -104, -104, -104,
-99, -96, -97, -97, -96, -96, -97, -96, -96, -96, -97, -96, -96, -97, -97, -95,
-98, -100, -99, -100, -100, -99, -100, -100, -99, -100, -99, -100, -100, -100,
-101, -97, -90, -89, -90, -88, -88, -88, -89, -89, -89, -89, -90, -89, -89, -89,
-89, -88, -83, -81, -81, -81, -81, -81, -81, -80, -81, -81, -82, -81, -80, -81,
-80, -81, -79, -77, -77, -77, -77, -77, -77, -78, -77, -77, -78, -78, -77, -77,
-77, -78, -75, -73, -74, -73, -74, -73, -73, -74, -74, -73, -73, -74, -74, -73,
-73, -72, -70, -70, -70, -70, -70, -70, -69, -70, -70, -70, -70, -70, -71, -70,
-70, -70, -67, -67, -66, -65, -66, -66, -66, -65, -66, -66, -66, -66, -66, -66,
-66, -65, -65, -64, -64, -64, -65, -64, -65, -64, -64, -64, -64, -63, -63, -65,
-64, -64, -61, -58, -59, -59, -59, -58, -58, -59, -58, -58, -59, -59, -58, -57,
-59, -55, -48, -47, -47, -47, -47, -46, -46, -47, -47, -48, -47, -48, -47, -47,
-47, -47, -46, -45, -44, -45, -45, -45, -46, -45, -44, -45, -45, -45, -45, -45,
-46, -45, -39, -36, -35, -36, -36, -36, -36, -36, -36, -36, -36, -37, -36, -37,
-36, -35, -25, -15, -16, -16, -15, -15, -15, -16, -15, -15, -15, -15, -15, -15,
-15, -10, 0, };