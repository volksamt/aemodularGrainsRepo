#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0107

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 11, 10, 12, 11, 11, 11, 11, 11,
11, 11, 11, 11, 11, 11, 13, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 15, 14,
14, 12, 42, 72, 67, 70, 69, 69, 69, 70, 69, 69, 69, 69, 69, 69, 70, 69, 70, 71,
71, 70, 71, 70, 72, 70, 71, 70, 72, 70, 71, 70, 71, 69, 80, 113, 119, 116, 117,
117, 117, 117, 117, 117, 117, 118, 116, 118, 115, 119, 65, 11, 17, 14, 16, 15,
15, 15, 15, 16, 15, 15, 15, 16, 15, 15, 11, 7, 5, 6, 6, 5, 6, 6, 6, 6, 5, 6, 7,
6, 6, 6, 3, -8, -10, -10, -10, -9, -10, -9, -10, -9, -10, -9, -9, -9, -10, -9,
-18, -25, -24, -25, -25, -24, -25, -25, -24, -25, -25, -26, -25, -25, -25, -25,
-22, -19, -19, -18, -19, -19, -19, -19, -19, -19, -19, -19, -18, -20, -18, -18,
-19, -19, -18, -19, -19, -19, -19, -18, -18, -18, -19, -18, -19, -18, -20, -17,
-45, -74, -71, -72, -71, -71, -71, -70, -71, -70, -71, -71, -70, -70, -71, -70,
-72, -73, -74, -74, -74, -74, -74, -74, -74, -74, -74, -74, -73, -74, -74, -73,
-35, -15, -20, -17, -19, -17, -19, -19, -18, -18, -18, -18, -19, -18, -19, -17,
-42, -67, -64, -65, -64, -64, -64, -65, -64, -64, -65, -64, -64, -65, -64, -65,
-55, -37, -36, -36, -36, -36, -36, -37, -37, -37, -36, -37, -37, -37, -36, -36,
-36, -37, -37, -37, -37, -37, -36, -37, -36, -37, -37, -37, -37, -36, -36, -37,
-34, -34, -34, -33, -33, -33, -34, -33, -34, -33, -34, -34, -34, -33, -34, -33,
-34, -36, -36, -37, -36, -37, -36, -37, -36, -36, -37, -36, -36, -36, -36, -36,
-22, -14, -16, -15, -16, -16, -15, -14, -15, -15, -14, -15, -15, -15, -14, -15,
-11, -5, -6, -6, -6, -6, -5, -6, -6, -5, -5, -5, -5, -6, -5, -6, -1, 6, 7, 6, 7,
6, 6, 6, 7, 7, 6, 7, 7, 7, 7, 6, -24, -39, -35, -38, -35, -36, -36, -37, -36,
-37, -36, -37, -35, -37, -36, -38, 4, 46, 42, 44, 43, 44, 43, 44, 43, 43, 44,
43, 44, 43, 44, 42, 57, 80, 80, 80, 81, 80, 80, 80, 81, 80, 80, 80, 80, 80, 79,
76, 0, -42, -34, -38, -35, -37, -35, -37, -36, -38, -35, -38, -36, -38, -34,
-39, 32, 101, 93, 97, 94, 97, 94, 97, 94, 96, 94, 96, 94, 97, 93, 100, 51, -35,
-38, -38, -38, -38, -39, -38, -38, -39, -39, -38, -37, -39, -37, -35, 15, 44,
38, 42, 39, 41, 40, 40, 40, 40, 39, 40, 40, 40, 39, 40, 25, 8, 10, 9, 9, 9, 9,
9, 10, 9, 9, 10, 9, 10, 9, 9, 4, -7, -7, -8, -7, -8, -7, -7, -8, -7, -7, -7, -8,
-7, -7, -8, -3, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, };