#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0065

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 3, 3, 2, 3, 2, 2, 3, 3, 3, 2,
3, 2, 4, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 5, 8, 12, 14, 14, 13, 13, 13,
14, 13, 14, 13, 13, 13, 13, 13, 12, 14, 17, 16, 17, 16, 17, 17, 17, 16, 17, 17,
17, 16, 16, 17, 17, 20, 28, 27, 28, 28, 28, 28, 27, 28, 28, 28, 27, 28, 27, 27,
27, 30, 41, 43, 41, 41, 41, 41, 41, 41, 41, 42, 41, 41, 42, 42, 41, 41, 41, 41,
42, 42, 42, 42, 41, 42, 42, 41, 42, 42, 41, 42, 41, 47, 57, 56, 56, 56, 56, 56,
56, 56, 56, 55, 56, 56, 56, 56, 56, 56, 59, 59, 59, 59, 59, 60, 58, 59, 60, 59,
59, 59, 59, 58, 58, 63, 67, 66, 66, 66, 66, 66, 66, 66, 66, 66, 66, 66, 66, 66,
66, 68, 74, 73, 74, 72, 73, 74, 73, 74, 73, 73, 73, 73, 73, 73, 72, 74, 76, 77,
77, 77, 77, 77, 77, 76, 77, 76, 77, 76, 77, 76, 76, 79, 82, 82, 81, 82, 82, 82,
81, 81, 82, 81, 82, 82, 82, 82, 82, 85, 91, 90, 91, 91, 90, 91, 91, 90, 90, 91,
90, 90, 91, 90, 90, 91, 94, 95, 93, 93, 94, 94, 93, 95, 94, 94, 94, 94, 94, 93,
94, 96, 99, 98, 99, 98, 99, 97, 100, 97, 99, 96, 100, 96, 101, 93, 103, 25,
-113, -118, -116, -116, -116, -117, -115, -117, -116, -117, -116, -117, -116,
-116, -116, -116, -112, -112, -112, -113, -112, -113, -112, -113, -113, -113,
-113, -112, -113, -113, -114, -105, -98, -98, -99, -99, -99, -98, -98, -98, -98,
-98, -99, -98, -99, -97, -99, -91, -79, -79, -79, -78, -79, -79, -79, -78, -79,
-78, -79, -79, -79, -79, -79, -77, -71, -69, -69, -69, -69, -69, -70, -70, -70,
-69, -70, -70, -69, -69, -70, -67, -64, -64, -64, -64, -65, -64, -64, -64, -64,
-64, -64, -64, -64, -63, -64, -61, -57, -57, -57, -57, -56, -57, -57, -57, -57,
-57, -56, -57, -57, -56, -57, -51, -48, -48, -48, -48, -47, -48, -48, -48, -48,
-48, -48, -48, -48, -48, -48, -43, -38, -38, -39, -38, -38, -39, -39, -39, -38,
-39, -39, -39, -39, -38, -39, -39, -37, -37, -37, -37, -37, -37, -37, -37, -37,
-37, -37, -37, -37, -37, -37, -35, -33, -33, -34, -33, -33, -34, -33, -34, -34,
-33, -33, -34, -34, -33, -34, -31, -28, -28, -27, -28, -28, -28, -28, -28, -28,
-27, -28, -28, -28, -27, -28, -26, -25, -25, -24, -24, -24, -24, -25, -24, -24,
-24, -24, -24, -24, -24, -24, -22, -22, -22, -22, -22, -22, -23, -23, -22, -22,
-23, -23, -23, -23, -22, -22, -17, -14, -13, -14, -14, -13, -13, -13, -13, -14,
-13, -13, -13, -14, -13, -14, -9, -3, -3, -4, -3, -3, -3, -3, -2, -3, -3, -3,
-2, -3, -2, -3, -1, };