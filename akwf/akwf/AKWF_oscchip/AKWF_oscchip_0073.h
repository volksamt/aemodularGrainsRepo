#define DATA_LENGTH 512
#define DATA AKWF_oscchip_0073

const PROGMEM int8_t DATA[DATA_LENGTH] = {83, 121, 110, 116, 111, 115, 113, 115,
113, 114, 113, 115, 114, 114, 114, 113, 106, 102, 103, 103, 103, 102, 103, 102,
102, 101, 103, 102, 103, 102, 103, 99, 92, 90, 91, 91, 91, 90, 91, 91, 92, 90,
91, 90, 92, 90, 92, 82, 29, 12, 16, 13, 15, 13, 14, 14, 15, 14, 14, 14, 14, 15,
14, 13, -11, -26, -23, -25, -23, -25, -24, -25, -24, -24, -23, -24, -24, -24,
-24, -25, -28, -27, -28, -27, -28, -27, -28, -28, -27, -27, -27, -28, -27, -27,
-27, -27, -24, -22, -23, -23, -23, -22, -23, -22, -22, -22, -22, -23, -23, -23,
-22, -20, 39, 78, 71, 74, 72, 74, 72, 74, 73, 74, 73, 74, 72, 74, 72, 81, 104,
108, 106, 106, 107, 106, 107, 107, 107, 107, 107, 106, 107, 107, 108, 103, 80,
74, 76, 75, 75, 75, 75, 75, 75, 75, 75, 74, 75, 74, 74, 74, 53, 41, 44, 41, 43,
42, 42, 42, 43, 42, 43, 42, 43, 41, 44, 32, 4, 2, 4, 2, 3, 2, 3, 2, 2, 3, 3, 2,
2, 2, 3, 1, -3, -6, -5, -6, -5, -5, -5, -6, -6, -6, -6, -5, -5, -6, -5, -7, -9,
-8, -9, -9, -9, -8, -8, -9, -8, -10, -9, -9, -9, -8, -9, -10, -13, -14, -14,
-13, -13, -14, -13, -14, -13, -13, -14, -13, -14, -14, -14, -15, -14, -16, -15,
-16, -15, -16, -15, -15, -15, -15, -14, -15, -15, -16, -15, -16, -18, -18, -18,
-19, -19, -18, -18, -18, -18, -18, -18, -18, -18, -18, -18, -19, -20, -22, -22,
-22, -21, -21, -21, -21, -21, -21, -22, -21, -21, -21, -22, -22, -24, -24, -25,
-25, -24, -24, -25, -24, -25, -24, -24, -25, -24, -25, -25, -25, -24, -25, -24,
-24, -25, -25, -25, -25, -25, -25, -24, -24, -24, -25, -24, -25, -28, -28, -27,
-28, -27, -28, -29, -27, -28, -27, -28, -28, -28, -28, -28, -27, -30, -29, -29,
-29, -29, -29, -29, -29, -30, -29, -29, -29, -29, -29, -30, -30, -30, -30, -30,
-30, -31, -32, -31, -30, -31, -31, -31, -31, -31, -31, -31, -31, -32, -32, -32,
-33, -33, -32, -32, -32, -32, -33, -32, -32, -32, -32, -33, -33, -34, -34, -34,
-33, -34, -34, -33, -34, -35, -34, -34, -34, -34, -33, -34, -35, -36, -35, -36,
-36, -35, -36, -35, -35, -35, -36, -36, -36, -35, -36, -35, -36, -36, -35, -35,
-36, -36, -35, -35, -36, -35, -35, -35, -35, -35, -35, -36, -35, -37, -37, -37,
-37, -36, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -36, -36, -37,
-36, -37, -37, -36, -37, -37, -37, -37, -37, -37, -37, -37, -37, -38, -38, -39,
-39, -38, -38, -38, -39, -39, -38, -38, -39, -38, -39, -38, -38, -40, -40, -40,
-40, -40, -39, -40, -39, -39, -40, -39, -40, -40, -40, -40, -40, -40, -40, -39,
-40, -39, -40, -39, -40, -39, -40, -39, -40, -40, -40, -41, -11, };