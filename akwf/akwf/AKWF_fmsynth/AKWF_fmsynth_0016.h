#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 16, 23, 32, 39, 48, 56, 62, 67, 73,
77, 83, 87, 90, 92, 95, 97, 99, 101, 102, 104, 104, 105, 105, 105, 107, 108,
108, 109, 110, 111, 111, 113, 113, 114, 116, 117, 118, 118, 119, 119, 117, 114,
109, 103, 96, 85, 72, 58, 40, 21, 1, -19, -40, -60, -78, -93, -102, -106, -105,
-99, -88, -72, -52, -29, -6, 17, 41, 62, 81, 96, 107, 114, 118, 118, 114, 108,
99, 88, 77, 65, 52, 40, 28, 17, 6, -3, -12, -19, -27, -33, -39, -45, -50, -55,
-59, -63, -68, -71, -75, -78, -81, -85, -88, -91, -95, -98, -101, -103, -105,
-106, -107, -106, -106, -105, -102, -97, -93, -87, -80, -73, -64, -54, -44, -34,
-24, -14, -3, 8, 16, 26, 34, 41, 48, 54, 58, 62, 66, 68, 69, 70, 71, 70, 70, 68,
65, 61, 57, 52, 47, 41, 33, 26, 19, 10, 1, -7, -14, -24, -32, -39, -47, -53,
-58, -63, -68, -71, -74, -78, -79, -79, -81, -81, -79, -78, -76, -73, -69, -64,
-59, -52, -45, -35, -26, -15, -3, 10, 23, 35, 48, 62, 74, 85, 95, 103, 109, 115,
118, 119, 118, 115, 111, 105, 98, 90, 81, 71, 62, 51, 43, 32, 23, 14, 6, -3,
-10, -18, -26, -34, -42, -48, -55, -63, -69, -75, -81, -87, -93, -97, -101,
-104, -107, -106, -105, -102, -97, -90, -80, -67, -52, -36, -16, 4, 24, 44, 64,
82, 97, 109, 117, 119, 116, 108, 95, 78, 57, 35, 13, -9, -31, -51, -67, -82,
-92, -100, -105, -107, -107, -105, -102, -98, -94, -89, -85, -81, -77, -74, -69,
-68, -66, -66, -65, -64, -65, -66, -67, -68, -70, -71, -72, -74, -75, -76, -77,
-79, -80, -80, -81, -80, -80, -79, -78, -77, -75, -73, -70, -68, -64, -60, -55,
-50, -45, -39, -33, -27, -20, -13, -6, 1, 8, 14, 20, 26, 32, 38, 42, 46, 50, 53,
55, 57, 58, 59, 58, 57, 57, 56, 53, 51, 48, 44, 40, 35, 32, 26, 22, 16, 11, 6,
1, -3, -8, -11, -14, -17, -19, -20, -21, -20, -19, -17, -14, -10, -4, 3, 10, 19,
28, 39, 50, 62, 73, 85, 96, 104, 112, 117, 120, 118, 112, 103, 90, 74, 55, 34,
12, -9, -30, -52, -69, -83, -95, -103, -106, -106, -103, -98, -90, -82, -71,
-60, -48, -36, -23, -12, -1, 12, 22, 32, 42, 51, 59, 68, 76, 82, 88, 95, 100,
105, 110, 113, 116, 118, 119, 119, 116, 114, 110, 102, 94, 82, 70, 55, 40, 23,
5, -13, -31, -47, -63, -78, -89, -98, -104, -106, -106, -103, -97, -89, -79,
-68, -57, -44, -33, -21, -10, 0, 9, 17, 24, 31, 36, 39, 42, 44, 45, 45, 44, 42,
39, 35, 32, 26, 22, 15, 9, 2, -6, -12, -19, -26, -33, -41, -46, -51, -57, -62,
-66, -70, -72, -75, -77, -77, -80, -79, -78, -79, -77, -76, -73, -70, -66, -62,
-57, -52, -46, -39, -33, -24, -16, -8, 0, };