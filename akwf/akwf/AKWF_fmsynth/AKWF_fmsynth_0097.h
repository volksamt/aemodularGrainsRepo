#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0097

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 7, 12, 15, 19, 22, 26, 31,
35, 39, 44, 48, 52, 56, 60, 65, 67, 71, 74, 78, 81, 82, 84, 86, 89, 90, 91, 92,
93, 95, 96, 97, 98, 99, 100, 101, 102, 103, 104, 106, 107, 108, 110, 112, 112,
114, 115, 117, 117, 118, 118, 119, 120, 120, 119, 119, 118, 118, 117, 115, 115,
114, 113, 112, 113, 113, 112, 113, 113, 113, 114, 113, 114, 114, 115, 115, 116,
116, 116, 116, 116, 116, 116, 115, 114, 114, 114, 113, 112, 110, 109, 107, 104,
102, 99, 95, 92, 87, 83, 77, 73, 68, 63, 57, 52, 46, 42, 37, 33, 29, 25, 21, 17,
14, 10, 7, 2, -1, -6, -11, -16, -21, -27, -32, -39, -46, -53, -59, -65, -71,
-79, -84, -90, -96, -101, -104, -107, -112, -114, -116, -117, -118, -118, -119,
-119, -119, -118, -118, -118, -117, -117, -116, -117, -116, -116, -117, -117,
-116, -117, -117, -116, -116, -116, -116, -117, -116, -117, -116, -115, -115,
-115, -114, -114, -114, -113, -112, -111, -109, -109, -107, -106, -105, -102,
-102, -100, -99, -97, -96, -95, -94, -93, -92, -91, -91, -90, -91, -90, -90,
-89, -89, -90, -89, -89, -89, -88, -87, -87, -87, -85, -84, -83, -80, -79, -76,
-73, -69, -66, -63, -59, -54, -50, -45, -41, -36, -31, -27, -22, -17, -13, -8,
-4, 0, 5, 8, 11, 13, 15, 17, 20, 21, 23, 25, 25, 26, 28, 29, 30, 31, 32, 33, 34,
36, 38, 39, 42, 43, 46, 47, 50, 53, 55, 58, 62, 64, 67, 69, 72, 74, 76, 78, 81,
82, 83, 85, 86, 87, 88, 87, 88, 88, 88, 87, 87, 87, 86, 84, 84, 83, 83, 83, 83,
82, 82, 82, 83, 83, 84, 85, 86, 88, 90, 92, 93, 97, 99, 102, 103, 105, 108, 110,
112, 113, 114, 116, 117, 118, 119, 119, 119, 119, 119, 118, 118, 118, 119, 118,
118, 117, 117, 116, 116, 115, 114, 113, 112, 112, 109, 108, 106, 103, 100, 97,
93, 89, 83, 77, 70, 62, 54, 45, 37, 25, 16, 5, -6, -16, -25, -32, -38, -44, -48,
-52, -55, -57, -59, -59, -59, -60, -59, -59, -58, -57, -55, -54, -53, -52, -50,
-50, -50, -50, -50, -52, -53, -55, -57, -60, -64, -66, -70, -75, -77, -81, -85,
-89, -93, -96, -99, -102, -103, -105, -107, -108, -110, -111, -111, -112, -114,
-115, -115, -114, -115, -116, -116, -117, -116, -117, -117, -117, -118, -118,
-118, -119, -118, -119, -120, -120, -119, -118, -117, -117, -116, -114, -112,
-110, -107, -104, -101, -98, -95, -91, -88, -85, -81, -78, -74, -72, -69, -67,
-64, -63, -61, -60, -59, -57, -58, -56, -55, -55, -55, -54, -54, -53, -53, -53,
-51, -50, -49, -49, -47, -45, -43, -41, -40, -37, -36, -32, -30, -27, -25, -22,
-20, -18, -15, -13, -11, -9, -8, -6, -5, -4, -3, -4, -3, -3, -4, -4, -3, -5, -6,
-5, -6, -6, -6, -5, -6, -6, -4, -4, -2, 0, };