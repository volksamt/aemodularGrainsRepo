#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0105

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 32, 50, 66, 79, 90, 99, 106, 112,
115, 117, 118, 118, 119, 118, 116, 116, 113, 112, 110, 109, 107, 105, 104, 103,
101, 101, 100, 100, 100, 99, 99, 98, 98, 98, 98, 98, 98, 99, 99, 99, 98, 98, 98,
97, 98, 95, 94, 93, 92, 90, 88, 86, 83, 81, 78, 75, 72, 68, 65, 61, 57, 54, 50,
45, 42, 38, 34, 31, 27, 24, 21, 18, 14, 12, 10, 7, 5, 3, 2, 0, -1, -3, -4, -4,
-6, -6, -6, -6, -7, -6, -6, -5, -4, -4, -2, -1, 1, 2, 3, 4, 5, 7, 9, 9, 10, 12,
12, 13, 15, 16, 16, 17, 18, 18, 18, 18, 17, 17, 17, 16, 16, 15, 13, 13, 13, 11,
9, 8, 7, 6, 4, 3, 2, 2, -1, 0, -1, -2, -3, -3, -3, -3, -2, -3, -2, -1, 1, 1, 3,
5, 7, 9, 11, 14, 17, 19, 23, 26, 29, 33, 37, 41, 45, 50, 55, 60, 64, 69, 74, 79,
83, 89, 93, 97, 101, 104, 107, 109, 112, 113, 115, 116, 117, 118, 118, 120, 119,
119, 119, 119, 118, 118, 118, 117, 116, 116, 114, 113, 112, 111, 108, 105, 102,
99, 94, 87, 80, 71, 59, 45, 27, 6, -18, -40, -59, -75, -90, -102, -110, -115,
-119, -119, -119, -115, -111, -105, -99, -92, -84, -76, -69, -62, -54, -48, -42,
-36, -30, -24, -20, -15, -10, -6, -3, 1, 5, 9, 12, 16, 19, 22, 25, 28, 30, 34,
37, 40, 42, 44, 48, 51, 54, 57, 60, 64, 67, 70, 75, 79, 84, 88, 93, 96, 101,
107, 110, 114, 116, 118, 119, 117, 113, 105, 94, 78, 55, 25, -11, -45, -71, -91,
-104, -113, -117, -119, -117, -114, -110, -104, -98, -91, -85, -77, -71, -64,
-58, -53, -48, -43, -38, -34, -30, -27, -24, -21, -18, -16, -13, -11, -9, -7,
-4, -4, -2, 1, 2, 4, 7, 8, 10, 12, 15, 17, 20, 22, 25, 28, 31, 35, 39, 43, 47,
53, 57, 63, 68, 75, 80, 86, 93, 98, 103, 108, 113, 116, 119, 118, 118, 116, 111,
103, 94, 83, 68, 52, 33, 14, -9, -27, -42, -55, -66, -74, -80, -86, -91, -94,
-97, -100, -101, -102, -104, -104, -105, -105, -106, -105, -105, -105, -105,
-105, -105, -104, -105, -105, -106, -106, -106, -107, -108, -109, -110, -112,
-113, -115, -117, -116, -118, -118, -119, -118, -118, -118, -117, -116, -114,
-112, -110, -108, -105, -103, -99, -96, -93, -92, -88, -86, -85, -82, -80, -79,
-78, -76, -76, -75, -75, -75, -76, -77, -78, -79, -80, -83, -85, -87, -89, -92,
-94, -97, -100, -103, -104, -108, -109, -112, -114, -115, -117, -118, -118,
-119, -118, -119, -119, -118, -118, -117, -117, -117, -116, -116, -114, -115,
-114, -115, -115, -115, -115, -115, -116, -116, -117, -117, -117, -117, -118,
-118, -118, -118, -118, -119, -117, -118, -118, -118, -117, -116, -115, -115,
-113, -110, -107, -104, -100, -93, -86, -77, -65, -51, -37, -16, -1, };