#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0122

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 11, 18, 25, 31, 37, 43, 49, 53, 58,
62, 66, 68, 70, 72, 73, 75, 75, 75, 74, 73, 72, 70, 68, 65, 63, 59, 55, 52, 48,
44, 38, 35, 30, 25, 22, 18, 13, 11, 7, 5, 3, 2, 0, 0, 1, 1, 2, 4, 5, 9, 12, 17,
22, 26, 31, 36, 43, 49, 55, 61, 67, 73, 79, 84, 89, 95, 98, 103, 106, 108, 111,
113, 115, 115, 117, 117, 118, 118, 118, 119, 119, 119, 119, 118, 117, 118, 117,
116, 115, 115, 113, 111, 110, 108, 106, 104, 101, 99, 97, 94, 92, 89, 87, 85,
84, 83, 82, 82, 83, 81, 84, 84, 86, 88, 91, 93, 95, 98, 102, 105, 107, 111, 113,
115, 116, 118, 118, 119, 118, 118, 117, 115, 113, 110, 110, 107, 105, 102, 100,
97, 96, 95, 94, 93, 93, 93, 94, 94, 95, 97, 98, 101, 101, 103, 106, 108, 110,
111, 113, 114, 115, 116, 116, 117, 118, 117, 118, 117, 118, 118, 118, 118, 118,
118, 119, 118, 118, 118, 118, 116, 117, 116, 114, 112, 111, 108, 106, 102, 97,
92, 88, 82, 77, 70, 64, 59, 52, 46, 40, 35, 30, 25, 22, 18, 15, 14, 12, 11, 11,
10, 11, 13, 14, 16, 19, 22, 26, 30, 35, 38, 43, 47, 51, 56, 60, 64, 67, 71, 74,
77, 80, 82, 82, 84, 85, 84, 85, 85, 83, 82, 80, 79, 75, 72, 67, 63, 58, 52, 47,
39, 33, 26, 18, 12, 4, -4, -12, -19, -25, -33, -40, -46, -51, -56, -60, -65,
-69, -71, -73, -75, -76, -78, -77, -77, -78, -76, -74, -72, -70, -67, -64, -61,
-57, -53, -49, -45, -40, -35, -31, -26, -22, -18, -14, -11, -7, -5, -3, -1, -1,
0, 1, -1, -2, -5, -7, -10, -13, -16, -22, -27, -33, -38, -45, -51, -58, -64,
-71, -77, -83, -89, -94, -98, -102, -105, -109, -111, -113, -115, -117, -118,
-118, -118, -118, -119, -120, -119, -119, -119, -119, -118, -119, -118, -118,
-117, -117, -116, -115, -113, -111, -110, -108, -106, -104, -102, -99, -97, -95,
-92, -91, -89, -87, -87, -85, -85, -85, -85, -86, -88, -90, -91, -94, -97, -99,
-103, -104, -108, -110, -113, -115, -117, -118, -118, -119, -119, -119, -117,
-115, -113, -111, -108, -107, -104, -101, -98, -96, -95, -93, -91, -91, -90,
-89, -90, -90, -91, -92, -94, -95, -97, -100, -101, -104, -105, -107, -109,
-110, -112, -114, -115, -116, -117, -117, -118, -118, -118, -118, -118, -118,
-118, -118, -118, -118, -118, -117, -117, -117, -117, -115, -114, -112, -110,
-108, -105, -102, -99, -95, -88, -84, -79, -73, -68, -61, -55, -49, -44, -39,
-33, -29, -25, -21, -18, -14, -13, -11, -11, -10, -10, -11, -12, -14, -17, -19,
-22, -26, -30, -34, -38, -42, -46, -50, -54, -58, -61, -66, -69, -71, -74, -76,
-78, -80, -80, -82, -82, -81, -81, -80, -78, -77, -75, -72, -68, -64, -60, -55,
-49, -44, -38, -31, -25, -17, -9, -3, };