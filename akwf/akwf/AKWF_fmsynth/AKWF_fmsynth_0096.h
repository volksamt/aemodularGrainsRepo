#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0096

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 3, 6, 10, 13, 17, 20, 24, 28,
32, 36, 40, 42, 46, 48, 51, 53, 55, 56, 58, 58, 58, 59, 61, 62, 63, 65, 66, 68,
71, 74, 77, 80, 84, 88, 91, 94, 97, 100, 104, 106, 109, 110, 111, 113, 114, 115,
116, 116, 116, 117, 117, 117, 118, 119, 119, 119, 119, 118, 118, 117, 115, 114,
110, 107, 103, 98, 92, 85, 78, 71, 63, 56, 49, 41, 34, 29, 22, 16, 9, 2, -6,
-14, -22, -30, -40, -48, -59, -67, -75, -84, -92, -99, -103, -108, -112, -115,
-117, -118, -119, -119, -119, -119, -118, -118, -117, -116, -116, -114, -114,
-112, -111, -110, -107, -104, -103, -99, -95, -91, -86, -80, -76, -70, -66, -60,
-55, -50, -44, -41, -36, -32, -29, -25, -23, -20, -16, -14, -11, -7, -4, 0, 4,
7, 12, 16, 23, 28, 33, 40, 45, 51, 58, 64, 68, 73, 77, 81, 84, 88, 91, 93, 94,
96, 99, 100, 101, 103, 105, 107, 108, 111, 112, 115, 115, 118, 118, 119, 119,
119, 118, 117, 114, 111, 108, 104, 102, 97, 94, 90, 86, 85, 81, 78, 75, 70, 66,
62, 57, 51, 42, 35, 24, 10, -3, -16, -30, -41, -54, -64, -71, -80, -85, -89,
-94, -98, -101, -103, -104, -106, -107, -108, -109, -109, -111, -111, -112,
-114, -115, -117, -117, -118, -120, -119, -119, -119, -118, -118, -116, -115,
-114, -113, -111, -110, -110, -108, -108, -107, -107, -106, -107, -106, -105,
-105, -105, -104, -103, -101, -100, -98, -96, -93, -91, -89, -86, -83, -81, -79,
-76, -73, -72, -70, -69, -68, -68, -67, -68, -68, -68, -68, -68, -68, -68, -68,
-68, -67, -65, -63, -62, -60, -57, -55, -52, -50, -47, -45, -44, -42, -40, -39,
-39, -38, -38, -40, -39, -41, -42, -42, -44, -44, -45, -46, -46, -46, -46, -44,
-43, -42, -40, -38, -36, -34, -32, -30, -29, -28, -28, -27, -26, -27, -27, -28,
-29, -31, -32, -35, -36, -38, -39, -41, -41, -41, -42, -41, -41, -39, -40, -37,
-35, -35, -33, -32, -31, -31, -29, -29, -29, -29, -31, -32, -33, -35, -37, -39,
-42, -43, -45, -47, -48, -49, -49, -49, -49, -49, -48, -48, -46, -45, -44, -42,
-42, -40, -40, -40, -40, -40, -42, -43, -44, -46, -48, -51, -53, -54, -57, -58,
-59, -60, -61, -61, -61, -61, -60, -59, -57, -57, -55, -55, -53, -52, -51, -50,
-51, -51, -51, -53, -54, -55, -57, -59, -60, -62, -64, -65, -66, -67, -68, -68,
-67, -67, -67, -65, -64, -62, -61, -59, -58, -57, -55, -54, -53, -53, -54, -54,
-55, -56, -57, -59, -60, -61, -62, -63, -64, -65, -65, -63, -64, -63, -61, -61,
-58, -56, -54, -52, -49, -48, -45, -44, -42, -41, -41, -41, -40, -41, -41, -42,
-43, -44, -43, -44, -44, -44, -44, -43, -42, -42, -39, -37, -34, -30, -28, -25,
-22, -19, -16, -13, -11, -9, -7, -6, -5, -4, -4, -3, -3, -3, -3, -3, -2, -1, -1,
};