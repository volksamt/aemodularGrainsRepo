#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0120

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 20, 33, 46, 61, 73, 83, 92, 100,
104, 108, 111, 114, 114, 114, 114, 114, 113, 111, 109, 105, 101, 96, 90, 83, 78,
71, 65, 60, 56, 54, 53, 53, 56, 60, 65, 71, 80, 88, 95, 103, 109, 114, 118, 119,
117, 115, 112, 107, 103, 99, 95, 92, 90, 90, 91, 92, 96, 99, 103, 107, 110, 113,
115, 116, 117, 117, 117, 116, 116, 116, 116, 117, 117, 117, 117, 117, 115, 112,
108, 101, 93, 82, 71, 57, 44, 31, 20, 9, 2, -6, -10, -14, -15, -15, -11, -9, -3,
4, 13, 21, 30, 39, 48, 56, 62, 69, 74, 77, 79, 79, 77, 76, 71, 66, 58, 47, 37,
23, 10, -5, -20, -34, -49, -62, -73, -84, -91, -96, -102, -104, -105, -107,
-108, -106, -104, -102, -99, -94, -88, -80, -74, -66, -57, -50, -42, -37, -32,
-29, -28, -28, -31, -35, -42, -49, -58, -69, -79, -89, -98, -106, -112, -117,
-118, -119, -117, -116, -113, -110, -108, -105, -103, -103, -104, -105, -107,
-109, -111, -114, -117, -117, -118, -117, -117, -117, -114, -113, -111, -111,
-111, -111, -113, -114, -116, -117, -117, -116, -115, -111, -105, -98, -89, -79,
-68, -58, -47, -38, -30, -22, -17, -14, -12, -14, -15, -20, -25, -31, -38, -45,
-54, -62, -69, -77, -83, -87, -90, -94, -94, -95, -94, -93, -89, -85, -79, -71,
-62, -50, -37, -24, -10, 5, 19, 32, 45, 56, 66, 73, 80, 83, 87, 88, 88, 86, 85,
81, 76, 69, 63, 55, 48, 39, 30, 23, 16, 9, 5, 2, 0, 1, 3, 7, 13, 21, 30, 40, 52,
63, 74, 85, 96, 103, 110, 114, 117, 119, 120, 119, 118, 117, 117, 116, 116, 117,
118, 118, 118, 119, 117, 116, 114, 111, 107, 104, 101, 99, 97, 95, 94, 95, 98,
100, 104, 108, 112, 115, 118, 117, 117, 113, 108, 102, 93, 84, 75, 67, 58, 52,
46, 43, 41, 42, 44, 47, 52, 58, 66, 72, 80, 86, 93, 98, 102, 105, 107, 109, 111,
110, 110, 108, 107, 105, 101, 94, 88, 78, 67, 54, 39, 25, 10, -4, -17, -30, -41,
-50, -59, -64, -68, -70, -69, -68, -66, -61, -55, -48, -41, -31, -23, -13, -4,
4, 12, 18, 23, 26, 28, 28, 26, 21, 16, 8, -2, -13, -25, -38, -52, -65, -77, -89,
-98, -106, -111, -115, -117, -119, -119, -120, -119, -119, -120, -119, -119,
-119, -118, -116, -114, -111, -107, -102, -98, -92, -88, -84, -82, -80, -79,
-80, -83, -86, -91, -97, -102, -108, -113, -117, -118, -118, -115, -112, -106,
-100, -93, -86, -80, -75, -69, -66, -65, -65, -67, -69, -74, -79, -84, -89, -94,
-100, -104, -108, -111, -112, -114, -116, -116, -116, -116, -115, -115, -113,
-111, -107, -101, -95, -86, -76, -64, -51, -38, -25, -12, 0, 12, 22, 29, 35, 39,
42, 42, 41, 38, 34, 27, 21, 13, 4, -5, -14, -23, -31, -37, -43, -48, -52, -53,
-53, -51, -48, -43, -36, -27, -16, -4, };