#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0049

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 2, 5, 8, 11, 14, 18, 21, 24, 28,
31, 34, 37, 40, 42, 46, 47, 50, 51, 54, 55, 57, 58, 59, 60, 60, 61, 61, 61, 60,
61, 61, 61, 60, 60, 59, 59, 59, 58, 58, 57, 57, 56, 57, 58, 58, 58, 59, 60, 61,
62, 63, 65, 66, 69, 70, 73, 75, 77, 79, 81, 85, 86, 88, 91, 93, 96, 97, 99, 101,
102, 104, 106, 106, 108, 108, 109, 109, 110, 111, 111, 111, 112, 112, 112, 112,
112, 112, 112, 111, 111, 111, 111, 111, 111, 110, 111, 111, 111, 111, 110, 110,
110, 111, 111, 111, 111, 113, 113, 114, 114, 115, 115, 116, 117, 117, 118, 119,
118, 119, 119, 119, 119, 119, 118, 118, 118, 117, 117, 116, 116, 115, 115, 114,
114, 114, 113, 112, 112, 112, 112, 111, 112, 112, 111, 112, 112, 112, 113, 112,
113, 113, 113, 114, 113, 114, 113, 113, 113, 112, 113, 112, 112, 111, 111, 111,
110, 108, 108, 106, 105, 103, 103, 100, 98, 96, 94, 91, 90, 88, 85, 83, 80, 79,
76, 73, 71, 69, 66, 65, 64, 62, 61, 60, 59, 58, 58, 57, 57, 57, 58, 58, 58, 58,
59, 59, 60, 60, 60, 61, 62, 62, 61, 61, 61, 60, 61, 60, 59, 58, 56, 55, 53, 51,
49, 47, 44, 42, 38, 36, 32, 29, 25, 22, 19, 15, 12, 8, 5, 3, -1, -4, -7, -8,
-11, -14, -15, -17, -19, -20, -21, -22, -24, -23, -24, -24, -24, -24, -23, -24,
-23, -22, -22, -22, -21, -21, -20, -19, -20, -19, -19, -19, -19, -21, -22, -23,
-24, -25, -27, -29, -31, -33, -35, -39, -41, -43, -48, -50, -53, -57, -59, -62,
-66, -69, -71, -73, -76, -78, -81, -83, -85, -86, -89, -89, -91, -91, -93, -93,
-93, -94, -95, -95, -96, -94, -95, -94, -94, -94, -93, -93, -94, -93, -92, -93,
-91, -91, -92, -91, -92, -93, -94, -93, -95, -94, -95, -97, -98, -99, -100,
-102, -103, -105, -106, -108, -109, -110, -112, -113, -114, -114, -116, -117,
-117, -118, -118, -118, -118, -120, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -118, -119, -119, -119, -118, -120, -119, -118, -119, -119, -119,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -118, -117, -117, -118, -116, -116, -116, -114, -114, -113, -111,
-111, -109, -107, -107, -104, -103, -102, -100, -98, -97, -95, -94, -93, -92,
-90, -90, -89, -88, -88, -87, -87, -87, -87, -87, -87, -88, -88, -88, -89, -89,
-88, -90, -90, -90, -90, -90, -90, -89, -89, -89, -89, -89, -88, -87, -86, -84,
-82, -81, -79, -78, -75, -73, -71, -67, -66, -63, -60, -56, -54, -51, -48, -44,
-41, -38, -36, -33, -30, -29, -27, -25, -23, -22, -21, -19, -18, -18, -16, -17,
-17, -17, -17, -17, -17, -18, -18, -18, -19, -19, -20, -21, -20, -21, -21, -21,
-20, -20, -19, -19, -18, -16, -15, -13, -12, -10, -7, -5, -3, 0, };