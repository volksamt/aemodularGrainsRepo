#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0083

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 7, 11, 16, 21, 27, 32, 39, 45,
49, 52, 57, 61, 63, 65, 66, 67, 66, 66, 66, 66, 67, 66, 67, 67, 69, 71, 74, 76,
80, 83, 87, 91, 94, 97, 100, 102, 103, 105, 106, 106, 106, 107, 108, 107, 108,
108, 108, 108, 109, 109, 110, 109, 109, 110, 110, 109, 107, 105, 103, 99, 97,
92, 88, 84, 80, 77, 73, 72, 70, 68, 68, 68, 67, 68, 67, 67, 66, 64, 62, 59, 54,
50, 44, 38, 30, 22, 15, 7, 0, -6, -13, -19, -23, -26, -29, -31, -32, -34, -33,
-35, -35, -35, -36, -38, -40, -42, -44, -46, -50, -53, -58, -60, -63, -65, -67,
-68, -67, -68, -66, -66, -66, -66, -64, -64, -63, -62, -63, -63, -61, -62, -62,
-60, -59, -58, -55, -52, -48, -44, -39, -34, -29, -23, -16, -10, -4, 0, 5, 9,
12, 15, 16, 17, 17, 18, 18, 19, 20, 22, 23, 26, 30, 35, 39, 45, 52, 58, 64, 71,
76, 82, 86, 90, 94, 97, 98, 99, 101, 101, 102, 102, 102, 102, 101, 101, 102,
103, 104, 105, 106, 108, 110, 111, 111, 112, 111, 111, 110, 109, 106, 105, 103,
101, 100, 99, 98, 98, 97, 98, 96, 97, 96, 95, 95, 93, 91, 88, 85, 82, 76, 72,
66, 59, 53, 48, 41, 37, 31, 27, 24, 22, 20, 20, 20, 21, 22, 22, 21, 21, 21, 20,
17, 14, 10, 6, 0, -5, -11, -18, -25, -30, -36, -41, -46, -49, -52, -54, -55,
-56, -56, -56, -55, -53, -53, -53, -51, -51, -52, -54, -56, -59, -62, -66, -70,
-74, -78, -81, -85, -89, -91, -93, -94, -95, -96, -96, -97, -96, -96, -96, -96,
-94, -94, -93, -93, -94, -94, -95, -97, -98, -100, -102, -104, -105, -107, -107,
-108, -109, -109, -109, -111, -110, -110, -110, -110, -111, -111, -111, -111,
-111, -111, -111, -111, -112, -112, -113, -113, -113, -115, -114, -115, -114,
-114, -114, -113, -113, -112, -112, -113, -112, -113, -114, -115, -116, -116,
-116, -118, -118, -117, -118, -117, -117, -117, -118, -117, -118, -117, -117,
-115, -114, -114, -113, -113, -112, -112, -112, -112, -112, -114, -115, -116,
-116, -117, -118, -118, -119, -119, -119, -119, -119, -118, -118, -116, -116,
-114, -113, -112, -111, -110, -109, -108, -107, -108, -108, -110, -110, -111,
-112, -113, -115, -115, -116, -116, -116, -117, -117, -115, -115, -114, -113,
-111, -109, -108, -106, -104, -102, -101, -100, -100, -99, -100, -101, -102,
-103, -105, -105, -106, -108, -109, -109, -108, -108, -108, -108, -107, -104,
-103, -101, -97, -95, -92, -90, -87, -85, -83, -83, -81, -82, -84, -84, -86,
-87, -89, -90, -91, -91, -92, -92, -91, -90, -89, -85, -83, -80, -77, -72, -68,
-65, -61, -58, -56, -53, -52, -51, -51, -51, -51, -52, -54, -56, -58, -59, -59,
-59, -58, -56, -55, -51, -49, -44, -39, -35, -29, -24, -18, -14, -10, -6, -3,
-1, 1, 2, 1, 1, 0, -1, -3, -4, -3, -4, -3, -1, };