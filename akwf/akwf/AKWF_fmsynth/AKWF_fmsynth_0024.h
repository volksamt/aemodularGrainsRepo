#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 2, 2, 4, 5, 6, 7, 8, 9, 11, 12, 13,
14, 15, 16, 18, 19, 21, 22, 23, 26, 26, 28, 29, 31, 33, 34, 35, 38, 38, 41, 42,
44, 46, 48, 50, 52, 54, 56, 58, 60, 62, 64, 67, 70, 72, 74, 77, 79, 81, 83, 87,
88, 92, 94, 96, 97, 101, 103, 105, 107, 109, 111, 113, 115, 116, 117, 118, 119,
119, 120, 118, 118, 116, 115, 113, 110, 106, 102, 97, 92, 85, 77, 68, 60, 49,
37, 23, 9, -7, -20, -33, -44, -54, -63, -71, -78, -84, -90, -93, -97, -100,
-101, -103, -105, -105, -104, -103, -102, -100, -98, -96, -94, -92, -88, -85,
-83, -79, -76, -73, -69, -66, -62, -58, -54, -51, -47, -45, -41, -39, -35, -32,
-28, -25, -22, -19, -15, -14, -10, -8, -5, -2, 0, 3, 6, 9, 11, 13, 16, 19, 22,
24, 28, 30, 33, 37, 39, 42, 45, 48, 52, 55, 59, 63, 65, 69, 74, 77, 80, 84, 87,
91, 94, 98, 101, 104, 107, 109, 112, 114, 115, 117, 118, 118, 119, 119, 117,
115, 113, 111, 106, 102, 97, 89, 82, 73, 63, 52, 40, 27, 12, -3, -17, -30, -42,
-51, -60, -68, -75, -81, -86, -90, -95, -97, -99, -102, -102, -103, -105, -104,
-103, -104, -103, -103, -100, -100, -97, -96, -94, -92, -91, -89, -86, -84, -82,
-80, -78, -76, -74, -71, -68, -66, -65, -62, -61, -58, -56, -55, -53, -51, -48,
-47, -45, -43, -42, -40, -38, -37, -36, -34, -32, -31, -29, -28, -28, -25, -24,
-23, -23, -20, -20, -19, -18, -17, -15, -15, -14, -13, -12, -11, -11, -9, -9,
-8, -8, -8, -7, -5, -5, -4, -4, -3, -2, -2, -1, 0, 0, 0, 0, 1, 1, 2, 3, 2, 3, 3,
4, 3, 4, 5, 5, 6, 4, 5, 6, 6, 6, 6, 6, 7, 7, 7, 7, 7, 7, 8, 7, 7, 8, 7, 7, 7, 7,
7, 8, 7, 8, 7, 7, 7, 8, 7, 7, 8, 7, 7, 7, 7, 7, 7, 7, 7, 6, 5, 5, 5, 5, 6, 5, 5,
4, 4, 5, 3, 4, 4, 4, 3, 3, 3, 3, 2, 1, 2, 1, 1, 0, 1, 0, -1, -1, -1, -1, -2, -2,
-2, -3, -3, -4, -4, -5, -4, -4, -5, -6, -5, -7, -6, -7, -7, -8, -8, -8, -9, -9,
-9, -9, -9, -11, -10, -11, -12, -12, -12, -12, -13, -14, -14, -13, -14, -14,
-15, -15, -15, -16, -15, -17, -17, -18, -17, -18, -18, -18, -19, -19, -18, -19,
-20, -20, -20, -20, -21, -21, -21, -21, -22, -21, -22, -22, -22, -22, -22, -23,
-22, -22, -22, -23, -23, -23, -23, -23, -23, -23, -23, -22, -22, -22, -23, -23,
-22, -22, -21, -22, -22, -22, -21, -21, -21, -20, -20, -19, -19, -19, -18, -18,
-17, -17, -17, -16, -16, -15, -15, -14, -14, -13, -12, -11, -11, -10, -10, -9,
-9, -7, -6, -5, -5, -4, -4, -3, -2, -1, 0, };