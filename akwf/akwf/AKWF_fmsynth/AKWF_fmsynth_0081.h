#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0081

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 5, 8, 10, 11, 12, 13, 14, 14, 15,
15, 14, 16, 16, 18, 18, 19, 20, 21, 22, 23, 24, 26, 26, 28, 29, 30, 30, 31, 31,
31, 31, 32, 30, 31, 31, 30, 31, 30, 31, 32, 32, 32, 34, 36, 37, 40, 43, 47, 50,
53, 57, 62, 65, 70, 74, 79, 83, 87, 92, 96, 100, 104, 107, 111, 113, 115, 118,
119, 119, 118, 117, 117, 114, 112, 108, 105, 101, 96, 92, 87, 83, 79, 74, 70,
68, 67, 65, 65, 65, 67, 67, 70, 73, 75, 79, 81, 83, 84, 86, 87, 86, 83, 81, 78,
73, 67, 61, 56, 49, 43, 36, 31, 25, 20, 15, 11, 8, 4, 3, 1, 1, 2, 2, 5, 7, 11,
14, 18, 22, 27, 32, 36, 40, 45, 49, 53, 55, 58, 59, 61, 60, 57, 54, 49, 44, 36,
28, 20, 9, -2, -13, -24, -35, -46, -55, -64, -72, -80, -87, -93, -98, -103,
-106, -110, -110, -111, -112, -111, -108, -106, -102, -97, -91, -85, -78, -71,
-65, -57, -53, -46, -41, -36, -33, -31, -31, -31, -33, -34, -39, -44, -49, -56,
-62, -70, -76, -83, -90, -96, -102, -106, -109, -112, -113, -114, -114, -113,
-111, -108, -105, -100, -97, -92, -87, -82, -77, -71, -67, -63, -59, -56, -52,
-50, -48, -48, -48, -49, -50, -52, -54, -58, -61, -65, -69, -73, -78, -82, -86,
-91, -94, -98, -100, -101, -101, -102, -101, -98, -94, -90, -84, -77, -68, -58,
-48, -36, -26, -14, -2, 9, 19, 30, 40, 49, 55, 60, 65, 70, 71, 72, 71, 70, 66,
61, 56, 50, 44, 36, 29, 21, 13, 5, -1, -9, -14, -19, -23, -26, -26, -27, -26,
-22, -18, -13, -5, 2, 11, 20, 31, 42, 52, 63, 74, 83, 91, 99, 104, 108, 111,
112, 112, 111, 108, 104, 100, 96, 91, 86, 81, 77, 75, 72, 70, 67, 66, 67, 66,
68, 68, 70, 72, 74, 77, 80, 83, 85, 89, 92, 97, 100, 104, 107, 111, 114, 116,
117, 118, 117, 117, 114, 111, 106, 100, 94, 86, 77, 68, 58, 49, 41, 31, 23, 16,
10, 5, 2, 0, -2, -1, 0, 3, 5, 9, 14, 21, 26, 32, 39, 44, 50, 56, 60, 64, 67, 70,
71, 71, 71, 69, 67, 64, 60, 55, 50, 44, 37, 30, 23, 16, 8, 0, -6, -14, -21, -28,
-33, -39, -44, -49, -53, -56, -59, -61, -62, -63, -64, -63, -62, -62, -61, -60,
-59, -59, -58, -60, -60, -61, -62, -64, -66, -68, -71, -73, -75, -77, -79, -80,
-82, -82, -84, -84, -84, -84, -83, -82, -82, -82, -81, -81, -81, -81, -80, -81,
-80, -80, -79, -78, -76, -75, -73, -68, -67, -62, -59, -56, -53, -50, -48, -48,
-48, -49, -50, -53, -56, -60, -65, -70, -76, -81, -87, -92, -97, -100, -103,
-105, -107, -108, -107, -105, -102, -99, -96, -92, -89, -84, -80, -75, -71, -66,
-61, -56, -52, -48, -42, -37, -31, -27, -22, -17, -11, -7, -4, -1, };