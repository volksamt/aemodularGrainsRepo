#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0117

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 12, 18, 26, 33, 39, 46, 52, 57, 62,
68, 73, 77, 81, 85, 88, 90, 93, 95, 97, 99, 101, 102, 103, 104, 104, 105, 105,
105, 105, 104, 103, 103, 103, 101, 100, 98, 97, 95, 93, 91, 88, 86, 83, 80, 76,
73, 69, 66, 62, 58, 54, 50, 46, 41, 37, 33, 30, 26, 23, 19, 16, 12, 10, 7, 5, 4,
2, 0, -1, -2, -2, -1, 0, -1, 1, 3, 5, 7, 10, 13, 15, 20, 23, 27, 32, 37, 42, 47,
53, 59, 63, 70, 75, 80, 84, 90, 94, 99, 102, 106, 110, 113, 114, 116, 117, 117,
118, 119, 118, 117, 116, 115, 113, 111, 109, 107, 104, 103, 99, 97, 96, 94, 91,
90, 88, 87, 86, 86, 85, 85, 85, 85, 86, 86, 87, 88, 91, 92, 94, 96, 97, 100,
102, 103, 106, 107, 109, 111, 112, 114, 115, 116, 117, 118, 118, 117, 118, 118,
118, 118, 116, 115, 116, 115, 114, 114, 113, 112, 111, 111, 110, 110, 111, 110,
110, 110, 110, 111, 112, 112, 113, 114, 115, 115, 116, 117, 118, 118, 118, 116,
117, 116, 114, 113, 111, 108, 106, 102, 99, 94, 89, 83, 78, 72, 66, 59, 52, 45,
38, 31, 24, 17, 11, 4, -2, -8, -12, -18, -23, -28, -33, -36, -40, -43, -46, -48,
-50, -52, -53, -54, -54, -55, -55, -54, -54, -53, -51, -50, -49, -46, -43, -41,
-37, -34, -31, -28, -22, -19, -14, -10, -5, -1, 4, 8, 13, 18, 22, 27, 31, 35,
40, 44, 47, 51, 53, 57, 59, 63, 64, 67, 68, 69, 70, 70, 72, 72, 71, 71, 70, 68,
68, 65, 63, 61, 58, 55, 51, 47, 42, 38, 33, 27, 22, 15, 10, 3, -4, -11, -18,
-25, -32, -40, -47, -54, -61, -67, -74, -80, -85, -90, -96, -100, -103, -106,
-109, -112, -114, -115, -117, -118, -118, -119, -119, -119, -119, -119, -118,
-118, -118, -117, -117, -117, -117, -117, -117, -116, -118, -117, -117, -118,
-117, -118, -118, -118, -119, -118, -119, -118, -118, -117, -117, -116, -115,
-114, -113, -111, -109, -107, -105, -103, -101, -99, -96, -93, -91, -88, -85,
-84, -81, -79, -77, -75, -73, -72, -71, -70, -70, -69, -68, -70, -70, -72, -72,
-74, -76, -79, -80, -83, -85, -89, -92, -95, -97, -101, -103, -106, -109, -112,
-114, -115, -117, -117, -117, -118, -118, -117, -115, -113, -110, -109, -106,
-101, -98, -94, -90, -85, -80, -75, -70, -66, -60, -56, -51, -48, -43, -39, -36,
-33, -29, -26, -24, -22, -21, -19, -18, -17, -18, -18, -17, -19, -20, -22, -24,
-25, -28, -30, -34, -35, -39, -43, -46, -50, -54, -57, -61, -65, -68, -72, -76,
-80, -83, -86, -89, -92, -93, -96, -99, -101, -103, -104, -105, -106, -108,
-108, -109, -110, -111, -111, -111, -112, -112, -111, -111, -110, -111, -109,
-109, -107, -106, -104, -102, -101, -99, -96, -93, -90, -86, -82, -78, -74, -68,
-62, -57, -50, -45, -38, -31, -23, -16, -9, -2, };