#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0085

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 11, 14, 18, 22, 27, 30, 33, 37,
41, 44, 48, 50, 53, 56, 59, 63, 65, 67, 70, 72, 76, 77, 80, 82, 84, 86, 88, 89,
91, 92, 94, 96, 97, 98, 100, 101, 102, 103, 104, 105, 106, 106, 107, 107, 108,
108, 109, 109, 110, 111, 111, 111, 112, 113, 112, 113, 114, 114, 114, 114, 114,
114, 115, 114, 114, 115, 115, 115, 115, 115, 116, 116, 116, 116, 115, 115, 117,
116, 117, 117, 117, 117, 117, 118, 117, 118, 118, 118, 119, 118, 117, 118, 118,
118, 118, 118, 119, 119, 119, 120, 119, 119, 119, 118, 119, 118, 118, 118, 119,
118, 118, 117, 117, 116, 116, 115, 114, 113, 111, 110, 109, 108, 106, 103, 102,
99, 97, 94, 92, 88, 85, 81, 76, 73, 68, 63, 58, 51, 46, 39, 32, 25, 17, 9, 0,
-8, -17, -24, -33, -40, -46, -54, -59, -65, -70, -76, -81, -86, -90, -94, -98,
-101, -103, -107, -109, -111, -113, -114, -115, -117, -118, -118, -119, -119,
-118, -119, -118, -119, -117, -117, -116, -115, -114, -112, -111, -111, -109,
-107, -107, -105, -103, -101, -99, -98, -96, -94, -92, -91, -89, -88, -86, -84,
-83, -81, -79, -77, -76, -74, -74, -72, -70, -69, -68, -67, -66, -64, -63, -62,
-62, -61, -59, -58, -58, -57, -56, -55, -55, -53, -53, -53, -52, -52, -51, -50,
-49, -50, -49, -48, -49, -48, -46, -47, -46, -45, -46, -45, -44, -44, -43, -43,
-43, -42, -42, -41, -40, -40, -39, -39, -38, -37, -36, -36, -34, -34, -33, -31,
-31, -29, -28, -27, -25, -24, -23, -21, -20, -18, -17, -15, -13, -11, -9, -8,
-5, -3, 1, 2, 4, 7, 9, 12, 14, 17, 19, 23, 25, 28, 33, 35, 38, 42, 44, 48, 51,
53, 57, 60, 64, 66, 69, 72, 76, 78, 81, 85, 88, 90, 93, 96, 98, 101, 103, 105,
107, 110, 111, 112, 114, 116, 116, 117, 119, 119, 118, 119, 118, 118, 119, 118,
116, 115, 114, 112, 110, 109, 106, 104, 101, 97, 95, 91, 87, 84, 81, 77, 72, 68,
63, 59, 54, 50, 44, 38, 34, 29, 23, 18, 13, 8, 2, -4, -9, -13, -18, -22, -26,
-29, -34, -36, -40, -43, -45, -47, -51, -53, -55, -57, -60, -61, -63, -64, -66,
-67, -69, -69, -71, -72, -73, -74, -76, -75, -76, -77, -79, -78, -79, -80, -81,
-81, -82, -83, -83, -83, -84, -83, -86, -85, -86, -87, -86, -87, -88, -88, -88,
-89, -89, -90, -90, -92, -93, -94, -94, -95, -96, -96, -97, -97, -100, -100,
-100, -102, -102, -103, -104, -105, -106, -107, -108, -110, -110, -111, -112,
-113, -114, -114, -116, -116, -116, -116, -118, -119, -119, -118, -119, -118,
-119, -119, -119, -118, -118, -118, -117, -116, -115, -114, -113, -111, -109,
-109, -107, -105, -103, -100, -98, -96, -93, -90, -88, -84, -82, -79, -75, -72,
-69, -64, -61, -57, -53, -50, -46, -42, -39, -33, -30, -26, -22, -17, -13, -9,
-6, -1, };