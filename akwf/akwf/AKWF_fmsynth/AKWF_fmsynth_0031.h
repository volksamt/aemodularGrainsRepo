#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0031

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 9, 14, 20, 23, 28, 33, 38, 43,
48, 53, 57, 62, 66, 70, 74, 78, 82, 84, 89, 91, 94, 97, 99, 102, 103, 105, 107,
109, 110, 111, 112, 114, 113, 115, 116, 116, 116, 117, 117, 117, 117, 118, 117,
118, 117, 117, 118, 118, 117, 118, 118, 117, 117, 117, 116, 115, 115, 115, 114,
114, 113, 112, 111, 110, 109, 108, 106, 106, 104, 101, 101, 99, 98, 96, 94, 93,
91, 89, 88, 85, 84, 82, 81, 79, 77, 76, 75, 73, 72, 71, 70, 69, 69, 68, 68, 67,
68, 68, 68, 68, 68, 69, 70, 71, 72, 73, 75, 77, 78, 81, 82, 84, 86, 88, 91, 92,
94, 97, 99, 102, 104, 106, 108, 110, 112, 114, 115, 116, 117, 118, 118, 119,
119, 119, 118, 116, 116, 114, 112, 110, 106, 103, 99, 96, 92, 88, 83, 78, 74,
69, 62, 57, 50, 45, 39, 33, 28, 22, 17, 11, 7, 0, -3, -7, -11, -15, -17, -19,
-21, -22, -24, -23, -25, -25, -24, -23, -23, -21, -19, -17, -16, -12, -10, -6,
-2, 2, 7, 11, 15, 19, 24, 28, 34, 38, 42, 46, 51, 56, 59, 63, 67, 70, 74, 77,
80, 83, 85, 89, 90, 91, 94, 96, 98, 99, 100, 101, 103, 104, 104, 105, 106, 106,
106, 106, 107, 107, 106, 106, 105, 104, 104, 103, 102, 101, 100, 97, 97, 95, 92,
89, 87, 84, 80, 76, 71, 66, 61, 55, 48, 43, 35, 27, 18, 8, -2, -12, -21, -30,
-39, -48, -56, -64, -70, -77, -83, -87, -92, -97, -101, -104, -107, -110, -112,
-114, -115, -117, -117, -118, -119, -119, -119, -119, -119, -118, -118, -118,
-117, -117, -116, -115, -114, -113, -113, -112, -111, -111, -111, -112, -110,
-112, -110, -110, -112, -111, -111, -112, -112, -112, -112, -113, -113, -114,
-115, -115, -117, -116, -117, -118, -118, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -117, -117, -116, -116, -114, -113, -113, -111,
-111, -109, -109, -107, -107, -105, -105, -104, -103, -103, -101, -101, -101,
-101, -101, -100, -101, -102, -101, -102, -103, -104, -105, -107, -107, -109,
-109, -110, -112, -113, -114, -116, -117, -117, -118, -119, -119, -119, -119,
-119, -118, -118, -117, -116, -114, -113, -111, -109, -107, -104, -101, -99,
-95, -93, -89, -85, -82, -78, -73, -70, -65, -61, -58, -54, -49, -46, -41, -37,
-33, -30, -26, -23, -19, -16, -12, -10, -7, -5, -3, 0, 3, 3, 6, 7, 9, 9, 11, 10,
12, 12, 12, 12, 12, 12, 11, 11, 9, 8, 7, 5, 4, 2, 0, -2, -3, -5, -8, -10, -12,
-15, -18, -21, -23, -25, -28, -30, -33, -35, -37, -40, -43, -45, -49, -51, -52,
-55, -57, -59, -60, -62, -64, -66, -68, -68, -70, -71, -71, -72, -72, -73, -73,
-74, -74, -73, -74, -72, -72, -72, -71, -70, -69, -67, -66, -64, -62, -60, -57,
-55, -51, -49, -47, -43, -40, -36, -32, -29, -24, -20, -17, -12, -7, -2, };