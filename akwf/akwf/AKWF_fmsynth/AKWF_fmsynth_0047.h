#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0047

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 14, 23, 30, 37, 46, 52, 60, 66,
74, 79, 85, 91, 95, 100, 104, 107, 111, 114, 115, 117, 118, 119, 120, 118, 118,
116, 115, 113, 111, 108, 105, 103, 99, 95, 92, 88, 83, 81, 76, 71, 68, 63, 59,
56, 51, 48, 44, 41, 37, 34, 31, 27, 25, 22, 20, 19, 16, 14, 12, 11, 10, 8, 7, 7,
5, 5, 5, 5, 5, 5, 5, 5, 6, 6, 7, 8, 10, 10, 12, 14, 14, 17, 18, 20, 23, 24, 26,
28, 31, 34, 35, 38, 41, 43, 45, 48, 51, 53, 56, 58, 61, 63, 65, 69, 70, 73, 74,
77, 79, 82, 84, 85, 88, 90, 91, 93, 94, 96, 98, 98, 100, 101, 102, 103, 104,
106, 105, 107, 107, 108, 108, 109, 110, 110, 110, 112, 111, 112, 112, 113, 113,
113, 113, 113, 113, 113, 113, 114, 113, 113, 114, 114, 113, 113, 113, 113, 113,
112, 111, 111, 111, 110, 110, 110, 110, 108, 109, 107, 107, 106, 106, 105, 104,
103, 102, 102, 100, 100, 99, 98, 95, 95, 94, 93, 91, 90, 89, 88, 86, 86, 83, 82,
81, 79, 77, 76, 75, 74, 73, 71, 69, 68, 66, 65, 63, 62, 60, 60, 58, 57, 55, 54,
52, 51, 49, 49, 47, 46, 46, 43, 42, 41, 40, 39, 38, 37, 36, 34, 34, 33, 32, 31,
29, 28, 27, 26, 25, 23, 23, 23, 22, 20, 19, 17, 17, 15, 15, 13, 12, 10, 9, 8, 7,
5, 3, 2, 1, -1, -2, -4, -6, -8, -9, -12, -15, -16, -18, -20, -23, -26, -28, -31,
-33, -36, -40, -41, -45, -48, -51, -54, -56, -61, -63, -68, -70, -72, -76, -79,
-82, -86, -89, -91, -95, -98, -100, -102, -105, -107, -110, -111, -112, -115,
-116, -118, -117, -118, -120, -119, -119, -118, -118, -117, -116, -114, -112,
-110, -108, -106, -103, -100, -98, -94, -90, -87, -82, -79, -74, -69, -66, -61,
-56, -51, -48, -42, -37, -33, -28, -24, -18, -15, -10, -5, -1, 2, 7, 11, 14, 19,
22, 25, 29, 31, 34, 37, 40, 43, 45, 47, 48, 50, 52, 53, 55, 56, 57, 57, 58, 60,
60, 60, 60, 60, 59, 59, 58, 58, 56, 56, 55, 54, 52, 51, 49, 47, 44, 42, 40, 37,
34, 32, 29, 24, 22, 17, 14, 10, 7, 2, -2, -6, -11, -16, -20, -24, -29, -33, -38,
-43, -47, -52, -56, -62, -65, -70, -74, -78, -83, -86, -90, -93, -96, -98, -102,
-104, -107, -109, -111, -113, -113, -116, -116, -117, -118, -118, -119, -119,
-119, -118, -118, -118, -119, -118, -117, -116, -115, -114, -114, -113, -113,
-112, -111, -110, -109, -110, -109, -109, -108, -107, -108, -107, -108, -108,
-108, -109, -109, -109, -110, -111, -111, -112, -114, -113, -115, -115, -117,
-117, -117, -118, -119, -119, -119, -119, -119, -118, -118, -117, -116, -114,
-113, -111, -108, -105, -103, -99, -95, -91, -87, -81, -76, -71, -64, -57, -51,
-44, -37, -30, -22, -14, -6, -1, };