#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 14, 17, 22, 26, 31, 34, 38, 43,
46, 49, 53, 55, 57, 61, 63, 66, 68, 70, 72, 73, 74, 76, 76, 78, 79, 80, 80, 81,
81, 82, 82, 82, 81, 82, 82, 81, 80, 79, 79, 77, 77, 75, 74, 72, 70, 68, 65, 63,
60, 57, 53, 50, 46, 42, 38, 33, 27, 22, 16, 10, 3, -3, -9, -15, -22, -30, -36,
-44, -51, -59, -66, -73, -80, -86, -92, -97, -103, -107, -111, -114, -117, -118,
-118, -118, -118, -115, -112, -109, -103, -99, -93, -85, -79, -71, -62, -53,
-44, -34, -24, -15, -4, 5, 14, 24, 33, 42, 51, 58, 66, 72, 77, 82, 88, 91, 94,
96, 98, 99, 99, 99, 98, 96, 94, 91, 87, 84, 81, 76, 72, 68, 64, 59, 54, 50, 45,
40, 37, 33, 29, 25, 23, 19, 16, 13, 12, 9, 9, 7, 7, 6, 5, 6, 6, 6, 8, 9, 11, 14,
15, 18, 22, 25, 29, 32, 38, 42, 46, 52, 57, 61, 66, 71, 76, 81, 85, 89, 92, 95,
97, 98, 99, 98, 96, 94, 89, 84, 78, 70, 61, 51, 40, 29, 16, 2, -11, -25, -40,
-53, -66, -79, -90, -100, -108, -114, -118, -118, -117, -114, -107, -98, -86,
-71, -56, -38, -20, -2, 16, 33, 50, 66, 78, 88, 94, 98, 99, 95, 88, 80, 68, 55,
40, 23, 5, -13, -32, -48, -64, -80, -92, -103, -111, -117, -119, -118, -115,
-110, -101, -91, -78, -64, -49, -34, -17, -2, 13, 27, 42, 54, 65, 74, 83, 89,
93, 96, 98, 98, 97, 95, 92, 87, 83, 78, 72, 65, 58, 52, 46, 40, 34, 27, 22, 16,
11, 6, 2, -2, -5, -8, -11, -13, -15, -15, -17, -16, -17, -17, -15, -14, -12,
-10, -7, -4, 0, 4, 8, 14, 20, 25, 31, 38, 43, 50, 57, 64, 70, 76, 81, 87, 92,
95, 98, 97, 98, 96, 92, 87, 79, 70, 58, 45, 31, 15, -1, -18, -35, -52, -68, -84,
-97, -107, -114, -118, -119, -116, -109, -99, -85, -69, -50, -31, -9, 12, 32,
51, 68, 82, 92, 97, 98, 94, 84, 70, 53, 31, 8, -15, -40, -63, -83, -100, -111,
-118, -119, -114, -105, -91, -75, -54, -33, -9, 14, 35, 56, 72, 85, 94, 99, 96,
91, 80, 66, 47, 26, 4, -18, -39, -60, -79, -94, -107, -114, -119, -119, -115,
-109, -98, -86, -71, -56, -38, -21, -4, 13, 29, 43, 57, 69, 80, 87, 92, 96, 99,
97, 95, 91, 87, 80, 72, 63, 52, 42, 32, 21, 12, 1, -9, -18, -27, -37, -45, -53,
-60, -67, -73, -78, -84, -88, -92, -96, -99, -102, -104, -106, -108, -110, -112,
-112, -113, -113, -114, -115, -115, -115, -116, -116, -116, -116, -115, -116,
-116, -115, -116, -115, -115, -113, -113, -111, -111, -111, -109, -107, -106,
-105, -103, -100, -98, -96, -94, -91, -88, -85, -81, -78, -74, -70, -66, -61,
-58, -53, -48, -44, -39, -34, -29, -24, -19, -14, -10, -5, -1, };