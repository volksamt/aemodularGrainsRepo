#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0061

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 11, 18, 27, 35, 42, 49, 56, 64, 70,
77, 84, 89, 95, 99, 104, 108, 111, 113, 116, 118, 119, 119, 118, 118, 116, 114,
112, 108, 104, 100, 95, 90, 84, 78, 70, 64, 57, 49, 42, 34, 26, 18, 11, 3, -4,
-11, -17, -22, -28, -32, -36, -39, -43, -44, -47, -49, -50, -51, -52, -53, -52,
-52, -52, -51, -50, -48, -47, -45, -42, -40, -36, -33, -31, -26, -23, -17, -13,
-7, -2, 5, 11, 17, 23, 30, 35, 41, 46, 51, 57, 61, 66, 72, 76, 80, 83, 86, 89,
93, 96, 99, 102, 103, 105, 107, 109, 110, 111, 113, 114, 114, 115, 115, 116,
117, 117, 118, 117, 118, 118, 118, 118, 118, 118, 118, 118, 119, 118, 119, 118,
118, 117, 117, 117, 116, 115, 114, 114, 112, 111, 109, 107, 104, 102, 99, 96,
91, 87, 82, 76, 68, 61, 53, 44, 33, 21, 9, -5, -20, -31, -43, -54, -65, -75,
-82, -90, -98, -103, -108, -112, -114, -117, -118, -119, -118, -118, -117, -113,
-111, -107, -103, -99, -93, -88, -82, -76, -70, -63, -57, -49, -42, -35, -28,
-22, -14, -6, 0, 7, 14, 19, 27, 32, 39, 43, 49, 53, 59, 63, 67, 70, 75, 79, 81,
85, 87, 90, 92, 94, 95, 97, 98, 101, 102, 103, 104, 104, 104, 105, 106, 107,
107, 106, 107, 107, 106, 105, 105, 105, 104, 104, 103, 102, 101, 100, 99, 98,
96, 95, 93, 91, 89, 87, 85, 82, 81, 77, 75, 73, 70, 67, 65, 62, 59, 56, 52, 49,
46, 42, 40, 37, 34, 30, 28, 24, 22, 19, 16, 13, 10, 8, 6, 3, 2, -1, -3, -4, -5,
-7, -7, -10, -10, -11, -11, -11, -12, -11, -12, -11, -11, -10, -9, -8, -6, -3,
-3, 0, 3, 5, 7, 11, 14, 17, 21, 25, 28, 32, 37, 41, 45, 50, 55, 60, 65, 70, 75,
79, 83, 88, 93, 97, 101, 105, 108, 111, 114, 116, 117, 118, 119, 118, 117, 116,
113, 108, 104, 99, 92, 82, 73, 62, 50, 38, 23, 5, -11, -28, -41, -53, -66, -75,
-84, -91, -98, -103, -108, -111, -115, -116, -118, -119, -118, -118, -118, -116,
-116, -114, -112, -110, -107, -106, -104, -101, -99, -97, -93, -90, -88, -86,
-84, -82, -81, -78, -77, -75, -73, -72, -71, -71, -70, -69, -68, -69, -67, -68,
-69, -69, -68, -70, -70, -71, -73, -74, -75, -77, -78, -80, -82, -84, -86, -87,
-89, -91, -92, -94, -96, -99, -100, -102, -104, -106, -107, -108, -110, -111,
-113, -115, -115, -116, -117, -118, -117, -119, -119, -119, -119, -120, -119,
-118, -119, -118, -118, -117, -116, -116, -116, -115, -114, -114, -113, -113,
-112, -112, -111, -111, -111, -111, -112, -112, -111, -112, -113, -113, -113,
-115, -115, -116, -116, -117, -118, -117, -118, -118, -119, -118, -119, -119,
-118, -117, -117, -115, -114, -112, -109, -107, -104, -100, -98, -94, -90, -84,
-80, -74, -68, -62, -55, -50, -42, -35, -28, -19, -12, -5, };