#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0094

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 13, 17, 21, 26, 29, 34, 37,
41, 45, 48, 52, 56, 60, 63, 66, 70, 72, 76, 78, 81, 84, 87, 90, 92, 94, 96, 98,
101, 102, 104, 106, 108, 109, 110, 112, 112, 113, 115, 115, 117, 116, 117, 117,
118, 119, 120, 118, 119, 119, 119, 119, 119, 119, 118, 118, 117, 117, 117, 116,
116, 115, 115, 114, 113, 114, 113, 112, 111, 110, 110, 109, 109, 109, 107, 107,
107, 106, 106, 105, 106, 104, 105, 104, 104, 105, 104, 104, 103, 104, 104, 103,
104, 104, 104, 105, 105, 105, 105, 106, 106, 105, 107, 107, 108, 108, 109, 109,
110, 110, 111, 111, 111, 112, 113, 112, 113, 115, 115, 116, 115, 116, 117, 116,
118, 118, 118, 117, 118, 118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118,
118, 118, 118, 118, 117, 115, 115, 114, 115, 113, 113, 111, 111, 110, 109, 108,
106, 106, 104, 104, 103, 101, 100, 98, 97, 96, 94, 93, 91, 89, 88, 86, 84, 82,
81, 79, 78, 75, 75, 72, 71, 68, 66, 65, 62, 61, 59, 56, 55, 52, 51, 49, 46, 44,
42, 40, 39, 38, 35, 34, 32, 30, 27, 25, 24, 22, 19, 18, 16, 15, 13, 10, 9, 8, 6,
4, 2, 1, -2, -3, -4, -6, -8, -8, -11, -11, -12, -14, -15, -17, -17, -20, -21,
-21, -23, -24, -25, -25, -27, -28, -29, -29, -30, -31, -33, -33, -33, -34, -34,
-35, -35, -36, -36, -37, -37, -38, -37, -39, -38, -38, -38, -39, -39, -38, -38,
-38, -37, -38, -37, -37, -37, -36, -35, -36, -35, -35, -33, -33, -32, -32, -30,
-29, -28, -27, -26, -25, -24, -23, -22, -20, -18, -18, -16, -14, -13, -11, -10,
-8, -7, -4, -3, 0, 1, 4, 5, 7, 11, 12, 14, 17, 20, 22, 25, 27, 29, 32, 35, 37,
40, 42, 46, 48, 51, 54, 57, 60, 62, 65, 68, 71, 74, 78, 80, 83, 85, 89, 92, 95,
96, 99, 102, 105, 106, 109, 111, 112, 113, 116, 117, 118, 118, 119, 119, 119,
118, 118, 116, 114, 113, 109, 106, 103, 97, 92, 86, 79, 72, 62, 53, 42, 29, 16,
1, -14, -27, -41, -52, -61, -71, -80, -88, -94, -99, -105, -109, -112, -115,
-117, -118, -118, -119, -119, -117, -117, -114, -112, -110, -107, -103, -99,
-96, -91, -86, -81, -77, -71, -67, -62, -56, -50, -44, -38, -33, -26, -19, -13,
-7, -2, 4, 11, 18, 23, 30, 36, 42, 48, 54, 60, 65, 71, 77, 81, 87, 91, 95, 100,
104, 107, 110, 113, 115, 117, 117, 119, 119, 119, 118, 115, 112, 109, 103, 98,
92, 84, 74, 65, 52, 39, 25, 8, -8, -24, -39, -52, -64, -74, -82, -91, -96, -102,
-107, -110, -114, -117, -118, -119, -119, -119, -119, -117, -115, -113, -111,
-109, -105, -103, -100, -96, -92, -89, -85, -81, -76, -71, -68, -63, -59, -54,
-49, -45, -40, -36, -31, -26, -22, -16, -12, -8, -3, 0, };