#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 10, 20, 27, 35, 42, 47, 53, 58, 62,
65, 69, 71, 74, 75, 76, 78, 78, 78, 79, 78, 77, 76, 74, 72, 69, 66, 62, 59, 54,
49, 44, 37, 30, 21, 12, 4, -6, -15, -26, -38, -49, -59, -70, -81, -90, -100,
-107, -113, -118, -119, -118, -114, -107, -97, -84, -68, -49, -29, -8, 14, 36,
56, 74, 90, 100, 106, 106, 101, 90, 73, 52, 27, 2, -27, -52, -77, -97, -111,
-118, -117, -107, -89, -64, -33, -2, 32, 62, 86, 102, 108, 101, 85, 61, 30, -4,
-39, -71, -97, -114, -118, -110, -90, -59, -21, 18, 55, 86, 102, 107, 96, 72,
40, 0, -40, -74, -102, -117, -117, -100, -70, -29, 13, 54, 86, 104, 105, 90, 62,
23, -20, -60, -93, -114, -118, -106, -76, -34, 9, 52, 86, 105, 105, 89, 57, 18,
-25, -66, -98, -116, -117, -101, -68, -27, 18, 58, 90, 105, 103, 85, 54, 14,
-28, -67, -98, -116, -118, -102, -73, -33, 9, 50, 83, 103, 106, 95, 70, 37, -2,
-42, -76, -102, -116, -117, -104, -77, -42, -4, 33, 67, 93, 105, 105, 93, 72,
42, 10, -26, -58, -86, -106, -117, -118, -108, -90, -64, -33, -2, 30, 58, 82,
98, 107, 105, 98, 84, 65, 41, 16, -9, -35, -58, -79, -97, -108, -116, -118,
-117, -110, -98, -84, -67, -46, -27, -6, 12, 30, 48, 63, 76, 87, 95, 101, 105,
107, 106, 105, 102, 97, 92, 86, 78, 71, 65, 58, 51, 43, 37, 31, 24, 19, 14, 10,
5, 2, -1, -3, -5, -6, -7, -7, -7, -6, -4, -1, 1, 4, 8, 12, 18, 22, 27, 34, 41,
48, 55, 62, 70, 76, 83, 90, 95, 100, 103, 106, 106, 105, 103, 97, 89, 79, 67,
51, 34, 15, -3, -23, -44, -64, -81, -97, -109, -116, -120, -117, -110, -97, -80,
-59, -36, -9, 17, 43, 66, 85, 99, 105, 105, 96, 79, 54, 24, -9, -40, -71, -96,
-112, -119, -114, -99, -77, -46, -12, 23, 56, 82, 101, 106, 100, 79, 47, 11,
-29, -67, -97, -115, -118, -107, -81, -48, -7, 33, 69, 94, 107, 101, 81, 45, 2,
-42, -81, -109, -119, -111, -88, -52, -9, 35, 73, 98, 107, 96, 68, 25, -21, -65,
-100, -117, -115, -95, -59, -15, 30, 71, 98, 107, 96, 66, 24, -23, -68, -102,
-119, -113, -91, -54, -10, 36, 74, 99, 107, 94, 63, 20, -27, -71, -103, -118,
-113, -92, -57, -13, 31, 68, 96, 107, 100, 74, 37, -8, -51, -89, -112, -120,
-108, -85, -48, -9, 33, 68, 93, 105, 103, 85, 54, 16, -25, -62, -93, -113, -119,
-111, -92, -63, -28, 7, 42, 72, 94, 105, 105, 94, 75, 46, 13, -21, -53, -82,
-104, -115, -119, -113, -101, -82, -57, -31, -2, 26, 51, 72, 88, 100, 106, 106,
100, 88, 72, 53, 31, 8, -14, -35, -55, -74, -90, -102, -111, -116, -119, -118,
-116, -110, -103, -93, -83, -72, -61, -48, -37, -25, -13, -5, };