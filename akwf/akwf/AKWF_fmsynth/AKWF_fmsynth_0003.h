#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 16, 24, 32, 39, 46, 52, 57, 62, 66,
69, 73, 76, 78, 80, 81, 83, 84, 84, 84, 85, 85, 84, 84, 83, 81, 80, 78, 76, 74,
71, 67, 63, 59, 53, 48, 41, 35, 27, 18, 10, 1, -10, -21, -31, -43, -53, -65,
-75, -85, -95, -104, -110, -116, -118, -119, -117, -113, -106, -96, -82, -67,
-49, -30, -9, 10, 31, 51, 68, 83, 92, 98, 98, 95, 85, 71, 52, 30, 7, -18, -43,
-67, -88, -103, -115, -119, -116, -105, -88, -63, -34, -5, 26, 53, 77, 91, 99,
97, 85, 66, 40, 10, -22, -53, -81, -102, -116, -119, -111, -92, -64, -32, 4, 39,
68, 90, 99, 95, 82, 57, 27, -9, -44, -76, -101, -115, -119, -108, -85, -52, -15,
22, 57, 83, 96, 97, 85, 61, 28, -8, -45, -77, -104, -117, -118, -105, -78, -44,
-5, 33, 66, 89, 99, 94, 78, 51, 17, -20, -55, -85, -108, -118, -115, -100, -72,
-38, -1, 37, 68, 90, 99, 95, 81, 56, 25, -9, -44, -75, -99, -114, -119, -112,
-94, -67, -35, 0, 32, 63, 84, 96, 99, 91, 75, 51, 24, -7, -37, -65, -88, -107,
-117, -119, -112, -99, -79, -53, -26, 2, 30, 54, 74, 89, 97, 99, 95, 85, 71, 53,
33, 11, -11, -34, -55, -73, -88, -102, -111, -117, -119, -116, -112, -104, -92,
-80, -64, -48, -33, -16, 0, 15, 29, 43, 55, 66, 75, 83, 89, 93, 96, 98, 99, 99,
98, 96, 94, 92, 89, 85, 83, 80, 76, 72, 70, 67, 65, 63, 61, 60, 59, 58, 57, 56,
57, 58, 58, 60, 62, 64, 66, 68, 71, 75, 78, 81, 84, 87, 90, 94, 95, 97, 98, 99,
98, 98, 94, 90, 85, 78, 70, 59, 48, 35, 20, 5, -10, -26, -43, -59, -75, -89,
-101, -110, -117, -119, -117, -113, -105, -92, -77, -58, -38, -15, 7, 30, 50,
69, 85, 94, 99, 97, 88, 73, 53, 28, 0, -28, -57, -82, -102, -114, -119, -115,
-103, -82, -57, -27, 3, 34, 61, 82, 96, 99, 92, 73, 46, 13, -21, -56, -87, -107,
-119, -117, -103, -79, -48, -12, 24, 56, 81, 96, 98, 87, 62, 27, -12, -50, -84,
-108, -119, -115, -98, -68, -33, 7, 44, 74, 93, 98, 88, 65, 29, -12, -51, -88,
-111, -119, -112, -90, -59, -20, 20, 56, 83, 97, 97, 80, 49, 11, -30, -69, -100,
-117, -118, -104, -78, -42, -3, 35, 67, 90, 99, 93, 72, 41, 1, -39, -74, -102,
-117, -118, -104, -80, -47, -10, 27, 59, 83, 97, 98, 87, 63, 30, -6, -42, -75,
-101, -116, -119, -110, -92, -66, -36, -3, 29, 58, 81, 95, 99, 95, 79, 58, 30,
-1, -32, -59, -85, -104, -116, -119, -115, -104, -87, -66, -41, -15, 10, 34, 56,
73, 87, 96, 100, 97, 91, 78, 64, 46, 25, 6, -16, -35, -56, -72, -88, -100, -109,
-115, -118, -119, -117, -113, -107, -99, -90, -81, -70, -59, -49, -36, -27, -13,
-1, };