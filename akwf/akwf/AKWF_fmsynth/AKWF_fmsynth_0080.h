#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0080

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 13, 20, 26, 34, 40, 47, 53, 60, 65,
69, 73, 76, 78, 79, 79, 78, 78, 76, 73, 71, 68, 64, 60, 58, 56, 53, 52, 50, 50,
49, 50, 52, 54, 57, 61, 64, 68, 75, 80, 85, 91, 96, 101, 106, 110, 113, 117,
118, 118, 118, 119, 116, 114, 110, 106, 102, 97, 92, 88, 82, 79, 75, 71, 68, 67,
64, 64, 63, 63, 64, 66, 67, 69, 73, 76, 78, 82, 85, 89, 92, 94, 95, 96, 95, 94,
92, 88, 85, 80, 74, 68, 61, 54, 48, 41, 33, 27, 21, 15, 10, 6, 3, 1, -1, -2, -3,
-2, 0, 0, 3, 6, 8, 12, 14, 18, 20, 23, 25, 25, 26, 26, 24, 22, 21, 16, 11, 6, 1,
-6, -13, -20, -28, -35, -42, -48, -56, -63, -67, -73, -78, -82, -86, -89, -89,
-91, -92, -91, -91, -89, -87, -83, -80, -77, -74, -70, -67, -64, -61, -59, -57,
-56, -55, -56, -57, -58, -59, -61, -62, -66, -68, -71, -75, -78, -81, -86, -89,
-93, -98, -101, -104, -109, -110, -114, -115, -117, -118, -118, -118, -116,
-114, -112, -109, -105, -102, -97, -93, -88, -84, -79, -73, -69, -65, -60, -55,
-52, -49, -47, -44, -42, -41, -40, -41, -41, -42, -44, -46, -49, -52, -56, -59,
-63, -65, -68, -70, -70, -71, -72, -71, -70, -68, -64, -60, -54, -50, -43, -36,
-29, -22, -14, -7, 1, 8, 17, 22, 29, 34, 39, 42, 45, 47, 47, 47, 46, 44, 43, 40,
36, 33, 29, 26, 22, 19, 15, 13, 12, 10, 11, 11, 13, 15, 17, 22, 28, 34, 39, 46,
54, 61, 68, 75, 82, 88, 93, 99, 103, 106, 108, 108, 108, 107, 106, 102, 100, 96,
92, 89, 84, 80, 77, 74, 71, 69, 67, 66, 65, 66, 66, 69, 71, 74, 76, 80, 85, 89,
93, 98, 102, 106, 110, 113, 115, 116, 117, 117, 114, 112, 107, 103, 97, 92, 85,
78, 71, 66, 60, 54, 49, 45, 41, 39, 36, 34, 34, 34, 35, 36, 38, 42, 45, 47, 51,
53, 56, 59, 61, 64, 64, 65, 64, 62, 61, 58, 53, 49, 44, 38, 31, 24, 17, 10, 3,
-3, -11, -17, -23, -29, -33, -37, -40, -44, -45, -46, -45, -45, -44, -42, -41,
-39, -37, -35, -32, -30, -28, -27, -27, -25, -26, -27, -29, -30, -33, -36, -39,
-43, -48, -51, -56, -61, -66, -71, -77, -81, -86, -91, -96, -100, -103, -106,
-109, -110, -111, -112, -112, -112, -110, -108, -105, -103, -99, -97, -93, -90,
-87, -84, -81, -79, -75, -74, -71, -69, -67, -65, -64, -63, -63, -63, -64, -65,
-66, -68, -71, -73, -77, -80, -84, -87, -91, -94, -97, -99, -101, -102, -103,
-103, -102, -101, -98, -96, -92, -88, -83, -77, -72, -65, -60, -53, -47, -41,
-34, -29, -22, -17, -12, -8, -4, -2, -1, 2, 2, 2, 1, -1, -3, -5, -8, -11, -14,
-17, -20, -22, -23, -25, -25, -25, -23, -22, -19, -15, -11, -6, -1, };