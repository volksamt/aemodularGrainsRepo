#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0092

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 27, 42, 52, 58, 67, 74, 81, 86, 92,
97, 102, 105, 108, 112, 113, 115, 117, 118, 118, 119, 119, 119, 118, 118, 117,
116, 114, 112, 111, 109, 107, 105, 102, 100, 98, 96, 93, 91, 88, 85, 83, 79, 76,
74, 70, 67, 65, 62, 59, 56, 54, 51, 48, 45, 43, 40, 36, 34, 31, 29, 26, 23, 22,
20, 17, 15, 13, 10, 9, 6, 4, 3, 0, -1, -3, -5, -6, -8, -10, -11, -12, -14, -14,
-16, -17, -17, -19, -19, -20, -21, -22, -22, -22, -23, -23, -23, -24, -22, -23,
-23, -24, -23, -22, -23, -22, -21, -21, -19, -20, -18, -18, -16, -15, -13, -12,
-11, -11, -9, -7, -5, -4, -2, 0, 2, 3, 6, 9, 9, 13, 16, 18, 19, 23, 26, 28, 32,
34, 38, 40, 43, 46, 50, 53, 56, 59, 64, 66, 70, 74, 76, 80, 83, 86, 90, 93, 96,
99, 102, 105, 107, 110, 112, 114, 115, 117, 118, 119, 118, 118, 118, 117, 114,
112, 109, 105, 100, 93, 86, 77, 68, 56, 42, 28, 11, -5, -24, -40, -54, -67, -78,
-87, -95, -102, -107, -112, -115, -117, -119, -119, -119, -117, -115, -113,
-109, -105, -101, -96, -91, -86, -78, -72, -65, -58, -51, -44, -36, -29, -20,
-12, -4, 4, 12, 20, 27, 37, 43, 52, 59, 66, 74, 81, 88, 93, 98, 104, 110, 113,
116, 118, 119, 119, 117, 115, 111, 104, 97, 87, 74, 59, 41, 21, -2, -26, -45,
-64, -78, -89, -99, -107, -112, -116, -119, -119, -119, -116, -115, -111, -108,
-103, -97, -92, -85, -78, -72, -64, -57, -49, -40, -34, -25, -17, -9, -1, 8, 16,
24, 31, 39, 47, 54, 61, 69, 75, 82, 88, 94, 99, 103, 108, 111, 114, 116, 119,
119, 119, 118, 115, 113, 108, 103, 96, 88, 79, 68, 55, 41, 23, 8, -11, -28, -44,
-58, -69, -79, -87, -94, -101, -107, -110, -113, -117, -118, -119, -120, -119,
-119, -118, -116, -114, -112, -110, -107, -104, -101, -98, -95, -92, -88, -85,
-81, -78, -73, -70, -67, -63, -59, -55, -51, -48, -44, -41, -37, -34, -30, -27,
-24, -21, -17, -14, -11, -9, -5, -3, 0, 2, 5, 7, 10, 11, 15, 16, 18, 21, 22, 24,
26, 26, 28, 30, 32, 33, 34, 35, 37, 38, 38, 39, 40, 40, 41, 42, 42, 43, 43, 43,
43, 42, 43, 43, 43, 42, 42, 43, 41, 42, 40, 40, 39, 38, 38, 36, 35, 34, 34, 32,
31, 29, 28, 27, 24, 24, 22, 19, 18, 17, 15, 13, 10, 8, 5, 4, 2, -1, -4, -6, -8,
-11, -14, -16, -19, -22, -25, -28, -31, -33, -37, -40, -42, -46, -48, -51, -55,
-59, -61, -64, -68, -71, -74, -76, -80, -83, -86, -88, -92, -95, -97, -100,
-103, -104, -107, -109, -111, -112, -115, -116, -117, -119, -118, -119, -119,
-118, -119, -117, -116, -115, -113, -111, -107, -104, -100, -96, -91, -85, -79,
-71, -64, -56, -47, -39, -26, -7, };