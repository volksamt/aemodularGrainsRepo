#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0121

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 9, 16, 24, 30, 37, 43, 48, 54, 59,
63, 67, 70, 74, 77, 79, 80, 81, 82, 82, 83, 83, 83, 82, 80, 79, 77, 74, 73, 68,
66, 62, 59, 55, 51, 47, 43, 38, 34, 29, 26, 21, 18, 14, 11, 9, 6, 4, 1, 0, 0, 0,
0, 1, 2, 3, 5, 9, 12, 15, 20, 24, 30, 34, 41, 45, 52, 58, 63, 70, 75, 82, 87,
92, 96, 99, 104, 107, 110, 112, 115, 115, 116, 118, 119, 119, 119, 119, 120,
119, 118, 118, 119, 118, 118, 118, 118, 118, 119, 119, 119, 119, 119, 118, 118,
118, 116, 115, 113, 112, 111, 110, 107, 105, 103, 101, 99, 97, 95, 95, 93, 91,
91, 91, 91, 91, 90, 92, 92, 93, 96, 97, 99, 102, 104, 107, 108, 111, 113, 115,
117, 118, 118, 119, 119, 118, 116, 114, 113, 110, 106, 103, 100, 96, 92, 89, 85,
81, 78, 75, 72, 69, 67, 65, 64, 64, 63, 64, 63, 65, 66, 68, 70, 72, 75, 78, 81,
84, 87, 90, 93, 97, 99, 101, 104, 105, 108, 109, 111, 112, 113, 113, 115, 115,
115, 116, 116, 115, 115, 116, 115, 115, 114, 113, 112, 111, 110, 108, 106, 104,
100, 97, 93, 88, 84, 78, 73, 65, 60, 52, 46, 38, 31, 24, 17, 10, 3, -2, -8, -13,
-17, -23, -27, -30, -33, -35, -37, -39, -40, -41, -40, -40, -39, -37, -36, -33,
-30, -28, -23, -20, -15, -11, -7, -2, 2, 6, 12, 16, 21, 25, 29, 33, 37, 40, 43,
45, 48, 49, 51, 52, 52, 52, 52, 50, 49, 47, 44, 42, 38, 33, 29, 24, 18, 12, 6,
0, -7, -13, -21, -29, -37, -43, -50, -58, -64, -71, -76, -82, -87, -91, -95,
-99, -102, -105, -107, -109, -109, -111, -112, -112, -113, -114, -114, -114,
-114, -114, -113, -112, -112, -111, -109, -107, -105, -104, -101, -99, -96, -93,
-90, -87, -83, -80, -77, -73, -69, -66, -64, -61, -58, -55, -54, -52, -52, -52,
-51, -51, -52, -54, -56, -59, -62, -64, -68, -72, -75, -81, -85, -88, -93, -98,
-101, -105, -108, -111, -114, -117, -118, -118, -119, -119, -119, -117, -117,
-116, -114, -111, -110, -108, -106, -104, -103, -102, -100, -100, -100, -99,
-99, -99, -99, -100, -101, -102, -104, -105, -107, -108, -110, -111, -112, -115,
-115, -116, -117, -117, -118, -118, -118, -118, -118, -118, -117, -117, -117,
-117, -116, -116, -116, -115, -115, -116, -117, -117, -117, -117, -118, -118,
-117, -118, -117, -117, -115, -115, -113, -110, -109, -105, -101, -97, -93, -89,
-83, -78, -72, -67, -61, -56, -50, -45, -39, -36, -31, -27, -23, -20, -18, -15,
-14, -13, -12, -12, -12, -13, -14, -16, -19, -21, -24, -27, -30, -35, -38, -42,
-46, -50, -55, -59, -62, -66, -69, -73, -76, -80, -81, -84, -85, -88, -88, -89,
-90, -91, -91, -91, -89, -90, -87, -86, -84, -81, -79, -75, -71, -67, -63, -57,
-52, -46, -39, -33, -25, -18, -11, -5, };