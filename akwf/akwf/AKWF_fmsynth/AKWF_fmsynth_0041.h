#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0041

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 5, 9, 12, 14, 18, 20, 23, 25,
28, 31, 35, 38, 40, 42, 45, 49, 51, 53, 57, 60, 62, 65, 67, 70, 73, 74, 77, 79,
81, 84, 86, 87, 91, 92, 93, 95, 97, 98, 99, 102, 103, 103, 106, 106, 107, 109,
110, 111, 112, 112, 112, 114, 114, 115, 116, 116, 116, 117, 116, 118, 118, 117,
118, 117, 118, 119, 118, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 119, 119,
119, 119, 119, 119, 118, 119, 119, 119, 118, 119, 119, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 118, 119,
120, 118, 119, 119, 118, 118, 117, 118, 118, 117, 117, 117, 115, 116, 116, 115,
114, 114, 114, 112, 112, 110, 110, 108, 108, 106, 105, 103, 102, 100, 99, 98,
96, 93, 92, 91, 88, 85, 84, 82, 79, 77, 74, 72, 69, 67, 64, 61, 58, 55, 52, 50,
46, 44, 41, 37, 34, 31, 28, 25, 22, 18, 16, 13, 10, 8, 5, 2, -1, -4, -7, -9,
-12, -14, -16, -18, -21, -24, -26, -28, -30, -32, -34, -36, -37, -39, -41, -43,
-45, -46, -47, -49, -50, -51, -52, -54, -55, -55, -56, -57, -58, -59, -60, -60,
-61, -61, -62, -63, -63, -64, -63, -64, -64, -64, -65, -64, -64, -64, -65, -64,
-64, -64, -65, -64, -64, -64, -64, -63, -64, -63, -64, -62, -63, -63, -62, -62,
-62, -62, -62, -61, -61, -60, -60, -60, -60, -60, -60, -60, -59, -59, -60, -60,
-60, -60, -60, -61, -61, -61, -62, -62, -62, -63, -63, -64, -65, -65, -66, -66,
-68, -68, -69, -69, -70, -72, -73, -74, -75, -76, -77, -79, -80, -82, -83, -84,
-86, -87, -89, -89, -92, -93, -94, -96, -97, -98, -100, -101, -103, -104, -105,
-107, -108, -109, -110, -111, -113, -114, -115, -115, -116, -117, -118, -118,
-118, -118, -119, -119, -120, -119, -119, -119, -118, -118, -118, -118, -116,
-117, -116, -114, -113, -113, -113, -111, -109, -109, -108, -106, -104, -104,
-103, -101, -99, -98, -96, -95, -93, -92, -91, -89, -88, -86, -84, -83, -82,
-80, -78, -77, -76, -75, -73, -72, -71, -69, -68, -67, -66, -65, -64, -63, -62,
-61, -61, -60, -59, -59, -57, -57, -57, -57, -56, -55, -55, -54, -55, -55, -53,
-54, -54, -54, -54, -54, -54, -55, -53, -54, -54, -54, -54, -54, -55, -55, -55,
-55, -56, -55, -56, -56, -57, -57, -57, -57, -58, -58, -57, -57, -57, -58, -58,
-58, -58, -59, -59, -58, -58, -57, -58, -58, -58, -58, -58, -57, -56, -56, -55,
-55, -55, -54, -53, -53, -51, -51, -51, -50, -48, -47, -45, -46, -43, -43, -41,
-39, -37, -36, -35, -33, -32, -29, -27, -25, -24, -21, -19, -18, -15, -13, -10,
-8, -5, -3, };