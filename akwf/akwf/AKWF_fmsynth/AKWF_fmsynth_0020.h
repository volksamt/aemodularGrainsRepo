#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 2, 3, 4, 4, 4, 4, 5, 6, 5, 7,
7, 8, 9, 8, 10, 11, 11, 11, 12, 13, 14, 15, 14, 15, 16, 16, 17, 17, 19, 19, 20,
20, 20, 22, 21, 22, 23, 24, 25, 25, 26, 26, 27, 27, 28, 28, 30, 30, 31, 32, 33,
34, 34, 34, 35, 35, 37, 37, 38, 39, 39, 40, 41, 42, 42, 43, 44, 45, 45, 46, 47,
48, 48, 49, 50, 51, 51, 52, 53, 54, 55, 55, 57, 57, 58, 59, 59, 60, 61, 62, 63,
64, 65, 66, 67, 67, 69, 68, 70, 70, 71, 73, 73, 74, 75, 75, 76, 77, 78, 79, 80,
81, 81, 83, 83, 83, 86, 85, 87, 87, 88, 89, 90, 91, 92, 92, 93, 94, 95, 96, 97,
97, 97, 98, 99, 101, 102, 101, 102, 103, 104, 104, 104, 105, 107, 107, 108, 108,
108, 110, 110, 111, 111, 112, 112, 113, 113, 114, 114, 115, 115, 116, 116, 116,
117, 117, 117, 118, 117, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119,
119, 118, 119, 119, 118, 119, 118, 118, 117, 117, 117, 117, 116, 115, 115, 114,
114, 113, 113, 111, 111, 110, 109, 109, 108, 107, 106, 105, 104, 103, 102, 101,
99, 98, 96, 95, 93, 92, 91, 89, 88, 85, 84, 83, 80, 78, 77, 75, 72, 70, 68, 67,
64, 61, 59, 57, 54, 52, 49, 47, 44, 41, 38, 36, 31, 29, 25, 22, 19, 16, 12, 9,
5, 1, -2, -6, -9, -13, -16, -19, -23, -25, -29, -31, -34, -38, -39, -43, -45,
-48, -50, -53, -55, -58, -60, -62, -65, -66, -68, -70, -72, -75, -76, -77, -79,
-80, -82, -85, -85, -87, -88, -89, -92, -92, -94, -96, -97, -96, -98, -99, -100,
-101, -102, -102, -103, -104, -106, -107, -107, -107, -108, -109, -110, -110,
-110, -112, -111, -112, -112, -112, -113, -113, -113, -114, -114, -114, -114,
-114, -115, -115, -114, -115, -115, -115, -114, -115, -115, -115, -115, -113,
-115, -115, -114, -113, -113, -113, -113, -113, -113, -112, -112, -111, -110,
-111, -111, -110, -109, -109, -109, -109, -108, -107, -107, -107, -106, -106,
-105, -104, -104, -103, -102, -102, -100, -100, -100, -100, -98, -98, -97, -96,
-96, -94, -94, -94, -94, -92, -91, -90, -90, -89, -89, -88, -87, -87, -86, -85,
-84, -83, -83, -81, -80, -79, -79, -78, -78, -77, -76, -75, -74, -73, -72, -72,
-71, -71, -70, -69, -68, -68, -66, -65, -64, -64, -62, -61, -61, -60, -59, -59,
-58, -57, -57, -55, -55, -54, -53, -53, -51, -51, -50, -49, -48, -47, -46, -46,
-45, -44, -43, -43, -42, -41, -40, -40, -39, -38, -37, -36, -36, -35, -34, -34,
-33, -32, -31, -31, -29, -29, -29, -27, -27, -26, -25, -25, -25, -23, -23, -22,
-21, -21, -20, -19, -18, -18, -17, -16, -15, -15, -14, -14, -13, -13, -12, -11,
-11, -11, -9, -9, -8, -8, -7, -6, -6, -5, -4, -3, -3, -3, -3, -1, 0, };