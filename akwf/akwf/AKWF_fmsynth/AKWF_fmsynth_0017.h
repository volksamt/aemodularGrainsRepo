#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 15, 28, 40, 53, 63, 73, 82, 90, 96,
101, 104, 106, 108, 109, 109, 109, 109, 108, 107, 106, 106, 107, 107, 107, 107,
108, 108, 108, 108, 108, 108, 108, 108, 109, 108, 109, 108, 109, 108, 108, 108,
109, 108, 107, 105, 103, 98, 93, 84, 72, 59, 43, 23, 2, -21, -44, -67, -87,
-104, -115, -120, -116, -106, -88, -67, -40, -12, 17, 43, 67, 86, 99, 107, 108,
104, 96, 83, 67, 51, 34, 16, 2, -12, -26, -37, -47, -54, -62, -68, -73, -76,
-80, -81, -82, -84, -85, -85, -85, -86, -87, -87, -87, -87, -88, -89, -92, -92,
-95, -98, -102, -105, -109, -111, -115, -116, -118, -119, -118, -116, -113,
-106, -99, -89, -77, -65, -50, -35, -20, -4, 12, 27, 41, 52, 63, 73, 81, 88, 92,
97, 100, 102, 103, 104, 105, 105, 105, 103, 102, 101, 99, 96, 91, 87, 80, 73,
65, 54, 43, 33, 20, 7, -6, -18, -30, -41, -51, -61, -68, -75, -81, -86, -89,
-92, -94, -95, -95, -93, -91, -88, -84, -78, -71, -63, -53, -41, -27, -13, 3,
18, 35, 51, 66, 80, 92, 100, 106, 108, 107, 103, 95, 86, 73, 59, 46, 31, 16, 3,
-10, -23, -33, -43, -52, -59, -66, -72, -76, -80, -84, -87, -89, -92, -95, -96,
-97, -99, -101, -103, -105, -107, -110, -111, -114, -116, -117, -119, -118,
-117, -114, -111, -103, -94, -82, -67, -50, -30, -7, 17, 39, 60, 80, 95, 105,
109, 105, 95, 77, 54, 27, 0, -28, -54, -77, -95, -107, -116, -118, -118, -113,
-106, -97, -88, -78, -70, -60, -52, -46, -40, -36, -32, -32, -31, -33, -33, -36,
-40, -44, -49, -54, -59, -63, -69, -75, -80, -84, -88, -91, -95, -97, -100,
-100, -102, -102, -102, -103, -100, -100, -97, -94, -90, -86, -79, -73, -67,
-58, -48, -38, -26, -16, -4, 8, 20, 32, 42, 53, 62, 70, 78, 84, 89, 93, 96, 98,
101, 102, 103, 103, 104, 103, 103, 101, 100, 98, 95, 92, 88, 83, 78, 71, 63, 56,
47, 40, 31, 22, 14, 6, 0, -8, -13, -17, -20, -22, -24, -22, -20, -17, -13, -6,
2, 11, 22, 35, 47, 60, 74, 85, 97, 104, 109, 108, 104, 93, 78, 58, 33, 7, -19,
-43, -68, -89, -104, -114, -118, -117, -112, -103, -91, -77, -63, -47, -31, -16,
-2, 11, 23, 34, 43, 51, 58, 63, 69, 73, 77, 80, 83, 86, 88, 91, 94, 96, 98, 100,
103, 105, 106, 107, 109, 110, 109, 107, 104, 98, 92, 83, 70, 55, 38, 20, 0, -22,
-43, -63, -82, -97, -109, -116, -119, -117, -110, -99, -85, -69, -51, -33, -15,
2, 19, 32, 44, 56, 64, 72, 78, 82, 85, 87, 88, 88, 88, 87, 84, 81, 78, 72, 66,
59, 51, 41, 32, 21, 10, -2, -14, -25, -36, -46, -56, -63, -71, -79, -84, -89,
-92, -94, -96, -97, -97, -97, -96, -95, -91, -88, -83, -78, -71, -63, -53, -44,
-33, -21, -8, };