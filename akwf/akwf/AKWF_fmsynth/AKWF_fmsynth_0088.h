#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0088

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 11, 14, 16, 20, 23, 25, 27, 28,
30, 32, 33, 34, 34, 34, 36, 35, 35, 36, 37, 38, 39, 40, 41, 43, 45, 47, 50, 53,
55, 59, 61, 65, 69, 72, 75, 78, 81, 85, 88, 91, 93, 95, 97, 99, 101, 101, 102,
103, 104, 105, 106, 106, 106, 106, 106, 107, 107, 107, 108, 108, 109, 109, 109,
111, 112, 112, 113, 115, 116, 116, 117, 118, 118, 120, 119, 119, 119, 119, 117,
117, 116, 115, 114, 113, 112, 110, 110, 109, 108, 108, 107, 107, 107, 107, 106,
106, 105, 106, 105, 104, 103, 102, 100, 99, 97, 95, 92, 89, 85, 82, 77, 72, 66,
60, 54, 48, 41, 33, 27, 21, 13, 7, 1, -5, -9, -12, -16, -19, -20, -23, -24, -25,
-25, -26, -27, -28, -30, -31, -32, -35, -38, -41, -44, -48, -51, -57, -61, -66,
-71, -75, -81, -85, -89, -93, -96, -99, -102, -105, -107, -110, -111, -113,
-113, -115, -115, -115, -116, -116, -117, -116, -116, -117, -117, -117, -117,
-117, -118, -117, -118, -118, -118, -119, -119, -119, -120, -119, -119, -118,
-118, -118, -117, -115, -115, -113, -111, -109, -108, -107, -105, -103, -101,
-100, -98, -97, -95, -94, -94, -93, -93, -93, -92, -92, -91, -91, -90, -89, -89,
-89, -88, -86, -85, -84, -83, -79, -78, -75, -72, -70, -66, -62, -60, -55, -52,
-48, -44, -40, -36, -33, -30, -27, -23, -21, -19, -17, -15, -14, -13, -12, -11,
-11, -10, -10, -9, -9, -9, -8, -6, -6, -5, -2, -1, 2, 5, 8, 11, 14, 17, 22, 25,
29, 33, 38, 42, 45, 49, 53, 55, 59, 62, 64, 67, 68, 70, 72, 73, 73, 74, 76, 75,
75, 76, 77, 77, 78, 78, 79, 80, 81, 81, 83, 85, 87, 89, 91, 93, 96, 98, 100,
102, 104, 107, 109, 111, 112, 114, 115, 116, 117, 118, 117, 117, 118, 119, 119,
119, 119, 119, 118, 119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 120, 118,
118, 119, 117, 117, 116, 114, 114, 112, 109, 107, 105, 101, 99, 96, 91, 89, 84,
82, 78, 74, 73, 70, 68, 65, 64, 64, 61, 61, 61, 60, 60, 59, 58, 56, 55, 54, 51,
49, 45, 41, 37, 32, 27, 19, 12, 4, -5, -13, -21, -29, -36, -44, -50, -57, -62,
-66, -71, -75, -79, -81, -83, -84, -86, -88, -88, -89, -90, -90, -91, -91, -92,
-92, -93, -94, -95, -96, -97, -99, -101, -102, -104, -106, -107, -110, -111,
-113, -115, -116, -117, -118, -118, -119, -119, -120, -119, -118, -118, -118,
-117, -117, -116, -116, -115, -115, -116, -115, -115, -114, -115, -113, -115,
-114, -113, -114, -113, -112, -112, -111, -110, -108, -107, -106, -104, -102,
-99, -97, -94, -92, -89, -86, -83, -81, -77, -75, -71, -69, -67, -65, -62, -62,
-60, -58, -57, -56, -55, -55, -55, -54, -54, -53, -53, -52, -52, -50, -49, -48,
-46, -44, -42, -39, -36, -32, -29, -26, -21, -18, -13, -10, -4, -1, };