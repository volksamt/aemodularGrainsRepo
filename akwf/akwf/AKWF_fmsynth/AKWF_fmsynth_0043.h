#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0043

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 9, 16, 22, 27, 34, 40, 45, 50,
56, 61, 67, 71, 76, 81, 85, 90, 93, 97, 101, 104, 106, 109, 111, 113, 114, 117,
116, 118, 118, 119, 119, 119, 118, 118, 117, 117, 117, 115, 114, 114, 113, 110,
110, 109, 107, 106, 105, 103, 103, 101, 100, 99, 99, 97, 97, 96, 96, 96, 96, 95,
95, 96, 95, 96, 96, 97, 97, 98, 99, 100, 100, 100, 102, 103, 105, 105, 106, 108,
108, 110, 110, 112, 112, 113, 114, 115, 116, 117, 117, 118, 118, 118, 118, 119,
119, 119, 118, 119, 118, 119, 118, 117, 116, 115, 115, 114, 113, 113, 111, 111,
109, 107, 107, 106, 104, 105, 103, 103, 101, 101, 100, 100, 98, 98, 98, 98, 97,
97, 98, 97, 97, 98, 98, 98, 99, 99, 100, 100, 101, 102, 104, 104, 105, 107, 107,
109, 110, 110, 113, 113, 115, 115, 117, 117, 117, 118, 119, 118, 119, 119, 119,
118, 117, 115, 115, 113, 111, 108, 107, 102, 100, 97, 93, 88, 84, 80, 75, 69,
63, 57, 53, 47, 40, 35, 27, 22, 16, 9, 4, -2, -9, -14, -19, -25, -31, -37, -41,
-48, -52, -56, -61, -65, -70, -73, -77, -79, -83, -86, -89, -92, -94, -96, -99,
-99, -102, -103, -103, -105, -107, -107, -108, -109, -110, -110, -110, -111,
-111, -111, -111, -111, -111, -111, -111, -110, -111, -111, -110, -110, -110,
-109, -109, -107, -107, -106, -105, -104, -103, -102, -100, -99, -98, -95, -93,
-92, -90, -88, -85, -84, -81, -79, -75, -73, -71, -67, -65, -61, -58, -55, -52,
-49, -46, -44, -40, -37, -34, -31, -29, -25, -23, -20, -17, -15, -12, -9, -8,
-6, -3, -2, 0, 1, 2, 3, 4, 6, 6, 8, 8, 8, 8, 8, 9, 8, 8, 7, 6, 6, 4, 3, 1, -1,
-3, -5, -7, -10, -12, -15, -18, -21, -25, -28, -31, -35, -39, -43, -47, -52,
-55, -59, -64, -68, -72, -77, -80, -85, -89, -92, -96, -99, -102, -105, -107,
-110, -112, -115, -116, -118, -119, -119, -119, -118, -119, -118, -117, -115,
-114, -112, -110, -107, -105, -101, -98, -94, -91, -87, -84, -79, -75, -71, -67,
-63, -59, -54, -50, -46, -41, -37, -34, -30, -27, -22, -19, -16, -12, -10, -6,
-4, -1, 0, 3, 6, 7, 8, 10, 11, 12, 13, 15, 15, 16, 16, 16, 16, 16, 16, 16, 15,
14, 12, 11, 10, 9, 7, 5, 4, 2, -1, -3, -5, -7, -10, -12, -15, -18, -21, -24,
-26, -29, -33, -34, -39, -41, -44, -47, -50, -52, -56, -59, -61, -64, -67, -69,
-72, -75, -78, -79, -81, -84, -86, -88, -90, -91, -93, -94, -96, -98, -98, -100,
-100, -101, -102, -102, -104, -104, -104, -104, -106, -106, -105, -106, -106,
-105, -105, -105, -104, -105, -104, -103, -103, -103, -101, -100, -99, -98, -97,
-95, -93, -91, -89, -87, -85, -83, -79, -77, -74, -70, -67, -63, -59, -56, -51,
-46, -42, -37, -32, -27, -22, -16, -11, -5, -1, };