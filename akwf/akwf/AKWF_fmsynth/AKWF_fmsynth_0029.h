#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0029

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 7, 8, 11, 15, 17, 20, 23, 26,
29, 31, 34, 37, 39, 42, 44, 48, 50, 52, 54, 57, 59, 60, 63, 63, 65, 66, 67, 68,
70, 70, 71, 71, 72, 71, 71, 71, 70, 70, 69, 69, 67, 67, 65, 64, 62, 62, 60, 58,
57, 56, 55, 53, 51, 50, 48, 47, 45, 45, 43, 43, 41, 40, 39, 38, 37, 37, 37, 36,
35, 36, 36, 36, 37, 37, 37, 39, 40, 40, 41, 43, 44, 44, 46, 47, 48, 50, 52, 53,
55, 55, 58, 59, 61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 69, 70, 71, 70, 71, 70,
70, 70, 69, 69, 67, 67, 65, 64, 63, 61, 60, 57, 56, 54, 52, 50, 48, 45, 43, 40,
38, 36, 33, 32, 28, 26, 24, 21, 17, 16, 13, 11, 7, 7, 3, 1, -2, -3, -6, -9, -10,
-13, -15, -17, -19, -22, -23, -26, -28, -30, -33, -35, -37, -39, -42, -44, -47,
-50, -52, -55, -59, -61, -64, -67, -70, -73, -77, -80, -83, -87, -90, -93, -96,
-100, -103, -105, -108, -111, -113, -114, -117, -117, -119, -119, -118, -119,
-117, -114, -111, -108, -102, -96, -90, -81, -71, -61, -48, -35, -19, -4, 8, 20,
30, 37, 45, 51, 56, 60, 64, 66, 68, 70, 71, 70, 70, 71, 69, 69, 66, 65, 62, 61,
59, 56, 55, 52, 49, 47, 45, 42, 41, 37, 34, 33, 30, 27, 26, 23, 21, 19, 17, 15,
13, 12, 10, 8, 6, 5, 4, 2, 0, -1, -3, -3, -6, -7, -8, -8, -10, -11, -12, -13,
-13, -15, -17, -16, -18, -18, -19, -20, -20, -21, -22, -22, -22, -24, -24, -24,
-24, -25, -26, -25, -26, -26, -27, -27, -27, -27, -27, -27, -27, -27, -26, -27,
-27, -26, -27, -26, -26, -25, -25, -25, -24, -23, -24, -23, -22, -21, -21, -20,
-20, -19, -18, -18, -16, -16, -14, -14, -12, -11, -10, -10, -9, -8, -6, -5, -4,
-2, 0, 1, 3, 5, 5, 9, 9, 11, 14, 15, 18, 20, 22, 25, 28, 30, 33, 35, 37, 40, 43,
45, 49, 52, 54, 57, 59, 61, 64, 65, 68, 68, 70, 71, 70, 70, 70, 67, 66, 62, 58,
52, 45, 36, 26, 14, 1, -16, -34, -51, -65, -77, -87, -96, -103, -109, -114,
-116, -117, -119, -119, -118, -117, -115, -113, -108, -106, -101, -98, -93, -89,
-85, -81, -76, -72, -67, -63, -60, -56, -52, -48, -44, -42, -37, -34, -31, -28,
-24, -22, -18, -15, -11, -7, -4, 0, 4, 8, 12, 16, 21, 25, 29, 34, 39, 43, 47,
52, 57, 60, 63, 66, 70, 70, 70, 70, 69, 65, 61, 54, 46, 35, 21, 6, -14, -35,
-55, -70, -83, -93, -102, -109, -113, -117, -118, -119, -118, -117, -115, -113,
-109, -107, -102, -98, -96, -91, -87, -82, -79, -75, -71, -67, -64, -60, -55,
-52, -50, -46, -43, -40, -37, -35, -33, -30, -27, -25, -21, -19, -16, -15, -11,
-9, -6, -4, -2, };