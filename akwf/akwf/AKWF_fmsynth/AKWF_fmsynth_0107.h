#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0107

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 9, 13, 18, 22, 26, 30, 34, 38,
42, 45, 49, 52, 55, 58, 61, 65, 68, 71, 74, 76, 79, 81, 84, 85, 89, 90, 92, 94,
95, 96, 98, 100, 101, 102, 103, 105, 106, 107, 108, 108, 108, 110, 111, 112,
112, 112, 113, 114, 114, 114, 114, 115, 114, 116, 115, 116, 115, 117, 117, 116,
117, 116, 117, 118, 116, 117, 118, 117, 116, 116, 117, 117, 117, 117, 117, 118,
118, 117, 117, 117, 118, 118, 117, 118, 117, 118, 118, 117, 118, 118, 118, 119,
118, 118, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 120, 118, 120,
119, 119, 119, 118, 118, 118, 117, 117, 116, 115, 114, 113, 113, 112, 110, 109,
107, 105, 104, 101, 99, 96, 93, 90, 86, 83, 79, 75, 70, 65, 60, 53, 47, 42, 34,
26, 18, 10, 2, -8, -16, -25, -33, -40, -48, -54, -61, -67, -73, -78, -83, -88,
-92, -95, -99, -102, -105, -108, -110, -112, -113, -114, -115, -116, -116, -118,
-117, -118, -117, -117, -116, -115, -114, -113, -112, -110, -110, -108, -106,
-104, -103, -101, -99, -97, -96, -93, -92, -89, -88, -86, -83, -82, -80, -78,
-76, -75, -72, -70, -69, -67, -67, -65, -63, -61, -60, -58, -57, -56, -54, -53,
-53, -51, -51, -49, -50, -49, -48, -47, -46, -45, -45, -43, -44, -43, -43, -43,
-42, -41, -42, -41, -41, -41, -41, -39, -40, -39, -40, -39, -39, -39, -38, -38,
-37, -37, -38, -37, -37, -36, -36, -36, -36, -35, -34, -34, -33, -32, -33, -30,
-30, -29, -28, -28, -27, -25, -24, -24, -22, -21, -18, -18, -16, -15, -13, -11,
-8, -7, -6, -4, -1, 2, 3, 6, 9, 11, 14, 16, 19, 22, 25, 27, 31, 33, 38, 40, 43,
47, 49, 53, 57, 59, 63, 65, 69, 72, 75, 78, 82, 85, 87, 90, 94, 97, 98, 102,
104, 106, 108, 110, 112, 113, 115, 116, 116, 118, 118, 119, 119, 120, 119, 118,
118, 116, 115, 113, 112, 109, 108, 105, 102, 99, 96, 92, 88, 84, 80, 76, 71, 66,
61, 56, 51, 45, 40, 33, 29, 23, 16, 10, 4, -2, -8, -14, -19, -24, -29, -33, -36,
-40, -44, -47, -50, -53, -56, -58, -61, -62, -65, -67, -69, -70, -72, -73, -75,
-76, -78, -78, -79, -80, -80, -81, -82, -83, -83, -84, -84, -86, -86, -86, -86,
-87, -87, -88, -88, -88, -88, -88, -88, -88, -89, -89, -90, -90, -90, -89, -89,
-90, -90, -90, -91, -91, -92, -93, -92, -94, -93, -94, -94, -96, -96, -96, -97,
-98, -98, -99, -100, -101, -103, -103, -104, -105, -105, -106, -108, -108, -109,
-110, -110, -112, -112, -113, -113, -114, -115, -115, -115, -116, -116, -116,
-117, -116, -116, -115, -115, -115, -114, -114, -112, -111, -110, -108, -107,
-106, -104, -102, -99, -98, -95, -93, -90, -88, -84, -82, -78, -75, -71, -68,
-64, -61, -56, -52, -49, -44, -40, -36, -32, -28, -24, -19, -16, -11, -7, -2, };