#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0103

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 6, 10, 13, 18, 23, 27, 33,
40, 47, 55, 62, 71, 78, 86, 93, 100, 105, 110, 113, 116, 117, 118, 119, 119,
119, 119, 120, 119, 119, 119, 118, 118, 116, 114, 112, 111, 108, 105, 103, 100,
98, 96, 94, 93, 91, 91, 91, 93, 94, 95, 98, 100, 102, 106, 109, 111, 115, 116,
118, 120, 119, 118, 117, 113, 109, 104, 100, 95, 90, 85, 80, 75, 72, 69, 67, 66,
65, 64, 63, 64, 64, 63, 64, 63, 61, 59, 57, 53, 48, 41, 32, 22, 9, -5, -21, -37,
-51, -64, -75, -85, -94, -100, -105, -110, -113, -115, -117, -117, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -117, -117, -114, -112, -109,
-107, -103, -98, -95, -90, -87, -84, -83, -82, -84, -87, -90, -95, -99, -106,
-111, -115, -117, -119, -118, -116, -112, -108, -101, -94, -86, -80, -71, -65,
-58, -53, -48, -43, -39, -37, -34, -31, -31, -30, -31, -31, -34, -35, -37, -41,
-44, -48, -52, -57, -62, -67, -72, -76, -81, -84, -88, -91, -93, -95, -95, -95,
-95, -93, -92, -89, -86, -81, -77, -72, -65, -59, -53, -46, -40, -34, -27, -22,
-17, -11, -6, -2, 2, 6, 9, 12, 14, 16, 19, 19, 20, 21, 21, 21, 19, 18, 17, 16,
15, 13, 10, 9, 9, 6, 6, 5, 3, 4, 3, 3, 4, 4, 6, 7, 8, 9, 11, 13, 16, 20, 21, 25,
26, 30, 32, 35, 38, 41, 43, 45, 47, 48, 50, 51, 53, 53, 53, 53, 53, 53, 52, 52,
52, 52, 52, 52, 52, 52, 54, 55, 56, 58, 61, 63, 67, 70, 74, 79, 83, 88, 93, 97,
103, 106, 111, 114, 117, 118, 119, 118, 119, 117, 116, 114, 113, 112, 112, 112,
113, 114, 115, 117, 118, 118, 119, 118, 117, 117, 115, 113, 110, 108, 104, 103,
101, 99, 99, 99, 100, 101, 102, 104, 106, 110, 113, 116, 118, 119, 117, 114,
105, 93, 74, 49, 17, -21, -51, -74, -90, -101, -109, -112, -116, -118, -119,
-119, -119, -119, -119, -119, -119, -118, -117, -115, -112, -108, -103, -95,
-86, -76, -63, -50, -36, -22, -10, 2, 11, 16, 18, 19, 15, 7, -3, -16, -31, -46,
-62, -76, -88, -99, -107, -112, -116, -119, -119, -118, -116, -112, -109, -106,
-102, -98, -95, -92, -90, -88, -87, -85, -84, -83, -84, -84, -85, -85, -86, -87,
-88, -88, -90, -90, -89, -90, -89, -90, -88, -87, -85, -85, -83, -80, -77, -74,
-71, -68, -65, -61, -58, -55, -53, -50, -48, -45, -43, -41, -40, -39, -38, -38,
-37, -37, -38, -38, -39, -41, -42, -43, -44, -46, -46, -47, -48, -49, -49, -49,
-49, -49, -47, -45, -42, -40, -36, -34, -29, -26, -20, -17, -12, -7, -2, 3, 8,
13, 17, 22, 27, 33, 36, 40, 44, 46, 49, 51, 52, 53, 53, 51, 51, 48, 45, 43, 39,
35, 32, 28, 24, 20, 17, 13, 10, 8, 4, 3, 1, 0, -1, -1, 0, };