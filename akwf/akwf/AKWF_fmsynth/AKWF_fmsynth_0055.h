#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0055

const PROGMEM int8_t DATA[DATA_LENGTH] = {23, 48, 68, 86, 98, 109, 114, 118,
118, 119, 114, 112, 108, 105, 102, 100, 98, 96, 97, 98, 101, 103, 106, 110, 114,
117, 118, 118, 117, 113, 105, 95, 80, 62, 42, 18, -7, -32, -57, -80, -98, -113,
-118, -117, -107, -88, -62, -31, 0, 33, 64, 89, 108, 117, 118, 111, 97, 77, 53,
28, 1, -25, -48, -70, -88, -101, -111, -116, -118, -119, -117, -113, -107, -101,
-95, -89, -85, -80, -79, -77, -76, -78, -80, -85, -89, -94, -100, -106, -112,
-115, -118, -119, -117, -111, -101, -86, -69, -46, -22, 6, 33, 59, 84, 104, 116,
119, 114, 99, 74, 43, 8, -27, -61, -88, -109, -118, -117, -107, -86, -60, -30,
2, 33, 61, 85, 103, 114, 119, 117, 110, 99, 83, 66, 48, 29, 12, -4, -19, -31,
-42, -52, -58, -64, -69, -72, -72, -73, -71, -67, -62, -57, -50, -39, -28, -15,
-1, 15, 32, 51, 69, 86, 100, 111, 118, 119, 114, 103, 87, 64, 37, 8, -22, -51,
-78, -100, -113, -119, -115, -104, -85, -57, -26, 5, 36, 64, 88, 106, 116, 119,
115, 108, 95, 80, 61, 41, 23, 4, -12, -28, -41, -53, -63, -71, -78, -84, -86,
-89, -90, -90, -89, -87, -84, -79, -73, -66, -56, -45, -31, -16, 1, 20, 38, 58,
77, 92, 107, 116, 119, 116, 105, 86, 61, 31, -3, -35, -67, -93, -111, -119,
-116, -103, -81, -53, -21, 15, 47, 75, 98, 113, 120, 116, 104, 85, 61, 34, 7,
-20, -45, -68, -86, -100, -110, -115, -119, -119, -118, -114, -110, -106, -102,
-99, -96, -95, -94, -94, -95, -96, -100, -103, -106, -110, -115, -118, -120,
-118, -115, -110, -100, -86, -69, -48, -23, 2, 28, 55, 80, 99, 113, 118, 117,
106, 89, 65, 36, 4, -26, -56, -82, -102, -114, -119, -115, -103, -84, -61, -34,
-5, 20, 46, 69, 87, 102, 112, 117, 118, 118, 115, 109, 105, 99, 93, 87, 83, 79,
75, 74, 73, 74, 77, 81, 84, 90, 96, 102, 108, 113, 117, 118, 118, 114, 105, 92,
74, 52, 27, -1, -28, -57, -83, -103, -115, -118, -113, -99, -77, -47, -14, 19,
53, 82, 103, 116, 119, 112, 94, 68, 37, 3, -28, -58, -84, -102, -115, -120,
-117, -110, -98, -84, -67, -49, -32, -15, 2, 15, 29, 38, 47, 56, 62, 65, 68, 69,
69, 68, 65, 62, 57, 49, 40, 30, 18, 4, -12, -29, -46, -64, -80, -95, -107, -116,
-119, -117, -108, -92, -71, -44, -14, 18, 48, 75, 99, 113, 119, 117, 104, 84,
60, 32, 1, -29, -57, -82, -99, -112, -119, -117, -112, -100, -86, -67, -47, -28,
-8, 10, 25, 41, 53, 64, 73, 80, 85, 89, 91, 93, 93, 93, 91, 88, 83, 77, 70, 61,
49, 35, 20, 2, -16, -36, -56, -76, -93, -107, -117, -118, -116, -105, -87, -64,
-35, -3, 29, 59, 86, 106, 117, 118, 108, 88, 61, 26, -8, -43, -74, -99, -113,
-120, -116, -104, -86, -64, -37, -6, };