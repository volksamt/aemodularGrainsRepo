#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0037

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 12, 15, 19, 24, 28, 32, 35, 40,
44, 48, 52, 55, 59, 63, 66, 71, 74, 76, 79, 83, 86, 89, 92, 95, 97, 98, 101,
103, 105, 106, 108, 110, 112, 113, 114, 115, 115, 116, 117, 117, 118, 118, 118,
118, 119, 120, 119, 118, 119, 119, 119, 119, 118, 117, 117, 118, 118, 117, 118,
116, 117, 117, 116, 116, 116, 117, 115, 116, 115, 116, 115, 117, 115, 116, 117,
116, 116, 116, 117, 116, 117, 117, 118, 117, 118, 118, 118, 117, 118, 118, 118,
119, 118, 119, 120, 119, 119, 119, 118, 118, 119, 118, 119, 118, 118, 119, 118,
118, 118, 117, 117, 118, 118, 117, 117, 117, 117, 116, 116, 116, 116, 116, 116,
116, 116, 115, 116, 115, 115, 116, 116, 115, 116, 116, 116, 116, 117, 117, 117,
117, 118, 117, 117, 118, 118, 118, 119, 119, 119, 119, 120, 119, 119, 119, 119,
118, 119, 117, 117, 117, 115, 115, 114, 112, 110, 109, 107, 106, 105, 102, 101,
98, 95, 93, 90, 87, 83, 80, 77, 74, 70, 66, 62, 57, 54, 51, 46, 41, 37, 33, 29,
25, 20, 15, 11, 8, 4, 0, -4, -9, -13, -16, -20, -24, -27, -31, -35, -37, -41,
-43, -46, -50, -53, -55, -57, -59, -62, -64, -67, -69, -70, -71, -73, -75, -75,
-77, -79, -80, -81, -82, -83, -82, -84, -85, -85, -85, -85, -86, -86, -86, -85,
-86, -86, -85, -86, -85, -85, -84, -83, -82, -82, -82, -81, -80, -79, -79, -77,
-77, -76, -75, -74, -72, -71, -70, -69, -67, -67, -66, -64, -62, -61, -60, -58,
-57, -56, -54, -53, -52, -50, -49, -48, -47, -46, -45, -43, -42, -41, -40, -40,
-39, -39, -38, -37, -38, -36, -36, -37, -36, -36, -37, -36, -36, -37, -37, -38,
-39, -40, -41, -42, -43, -44, -45, -48, -48, -50, -52, -54, -55, -57, -60, -61,
-63, -66, -68, -71, -73, -75, -78, -80, -83, -85, -87, -90, -92, -94, -96, -99,
-101, -103, -105, -107, -109, -111, -111, -113, -115, -116, -117, -117, -118,
-119, -120, -119, -119, -119, -118, -118, -117, -116, -116, -114, -114, -111,
-110, -108, -106, -105, -103, -100, -98, -96, -94, -92, -90, -87, -84, -82, -79,
-77, -75, -72, -69, -67, -65, -63, -60, -58, -56, -54, -51, -50, -47, -46, -45,
-43, -41, -40, -38, -37, -36, -35, -34, -33, -32, -31, -31, -31, -30, -30, -30,
-29, -30, -29, -30, -30, -30, -32, -32, -32, -32, -33, -34, -35, -36, -37, -38,
-40, -39, -42, -42, -44, -44, -46, -47, -48, -50, -52, -52, -55, -55, -56, -58,
-58, -59, -61, -63, -63, -66, -66, -67, -68, -69, -71, -71, -72, -73, -73, -75,
-75, -75, -76, -76, -77, -78, -77, -78, -79, -78, -78, -78, -78, -78, -77, -78,
-77, -77, -75, -75, -74, -73, -72, -72, -70, -69, -68, -67, -65, -64, -62, -60,
-59, -57, -53, -52, -49, -47, -45, -42, -39, -36, -33, -30, -26, -23, -19, -16,
-13, -10, -5, -2, };