#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0048

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 17, 27, 36, 46, 56, 65, 74, 83,
90, 96, 100, 103, 105, 106, 107, 107, 107, 106, 104, 103, 102, 101, 99, 99, 99,
99, 100, 102, 104, 107, 110, 113, 115, 117, 118, 119, 119, 118, 118, 117, 117,
117, 116, 117, 117, 118, 118, 119, 119, 119, 119, 118, 118, 117, 117, 117, 118,
118, 117, 118, 119, 119, 119, 118, 117, 115, 115, 115, 114, 114, 115, 115, 118,
118, 119, 119, 118, 118, 116, 115, 113, 111, 110, 109, 109, 109, 109, 109, 112,
113, 114, 115, 115, 116, 117, 117, 117, 117, 115, 115, 112, 109, 106, 102, 97,
90, 84, 77, 70, 64, 59, 55, 52, 51, 49, 50, 52, 53, 55, 57, 60, 62, 62, 61, 60,
58, 54, 49, 43, 35, 26, 17, 6, -5, -16, -26, -35, -44, -50, -57, -60, -63, -64,
-66, -65, -65, -64, -61, -60, -58, -58, -58, -59, -62, -65, -70, -75, -81, -88,
-95, -101, -106, -111, -114, -117, -118, -120, -119, -119, -118, -118, -118,
-118, -118, -118, -119, -119, -118, -120, -119, -119, -119, -118, -118, -117,
-116, -114, -110, -105, -101, -95, -87, -79, -72, -66, -60, -55, -52, -48, -48,
-49, -51, -53, -55, -58, -62, -64, -66, -67, -66, -66, -63, -60, -55, -48, -41,
-33, -24, -15, -6, 2, 9, 16, 22, 26, 29, 31, 30, 28, 25, 22, 17, 12, 7, 2, -2,
-6, -8, -9, -9, -8, -6, -1, 4, 9, 16, 23, 30, 36, 43, 47, 51, 52, 54, 54, 52,
49, 45, 38, 31, 24, 17, 8, 3, -5, -9, -14, -17, -19, -19, -18, -16, -12, -8, -5,
-1, 3, 7, 10, 12, 12, 12, 10, 5, -1, -7, -16, -24, -33, -44, -53, -63, -70, -77,
-84, -87, -90, -93, -95, -96, -96, -95, -95, -92, -91, -91, -91, -90, -92, -94,
-96, -100, -103, -109, -113, -115, -118, -119, -119, -117, -115, -111, -107,
-102, -97, -94, -91, -88, -86, -85, -84, -84, -84, -83, -82, -81, -78, -74, -69,
-62, -54, -46, -34, -22, -9, 6, 21, 35, 48, 60, 71, 80, 86, 93, 98, 101, 104,
106, 108, 108, 109, 111, 112, 112, 114, 116, 117, 119, 119, 119, 117, 113, 107,
99, 88, 76, 63, 49, 34, 20, 8, -3, -12, -21, -28, -34, -39, -42, -46, -50, -54,
-58, -62, -67, -74, -81, -89, -97, -104, -110, -115, -119, -118, -118, -112,
-106, -98, -90, -80, -70, -62, -54, -47, -41, -36, -31, -27, -24, -20, -16, -11,
-5, 2, 11, 20, 31, 43, 55, 68, 80, 91, 101, 109, 115, 118, 119, 119, 117, 114,
110, 108, 104, 101, 99, 96, 94, 92, 90, 88, 84, 79, 74, 67, 58, 47, 35, 21, 8,
-8, -24, -39, -53, -68, -79, -88, -96, -102, -107, -110, -113, -112, -114, -115,
-115, -116, -117, -117, -118, -118, -119, -119, -119, -118, -117, -115, -110,
-105, -98, -89, -80, -70, -60, -50, -40, -32, -25, -20, -16, -12, -11, -10, -9,
-10, -11, -11, -11, -9, -8, -4, 0, };