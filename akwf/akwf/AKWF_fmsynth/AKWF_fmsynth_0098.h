#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0098

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 6, 8, 11, 13, 16, 19, 21, 25,
28, 32, 36, 38, 41, 45, 47, 50, 54, 56, 60, 61, 64, 66, 68, 70, 71, 72, 74, 75,
76, 77, 79, 79, 81, 83, 84, 85, 87, 88, 90, 91, 93, 96, 98, 100, 102, 105, 107,
108, 110, 112, 114, 116, 117, 117, 118, 119, 119, 119, 119, 118, 119, 119, 118,
118, 118, 118, 118, 118, 119, 119, 119, 118, 119, 119, 119, 119, 120, 120, 119,
119, 119, 119, 119, 119, 119, 118, 118, 118, 118, 116, 115, 113, 111, 109, 106,
102, 97, 93, 89, 83, 77, 73, 66, 61, 55, 50, 43, 39, 34, 29, 24, 21, 15, 11, 6,
1, -4, -10, -15, -22, -29, -36, -44, -51, -59, -66, -73, -80, -87, -93, -100,
-104, -109, -112, -115, -117, -117, -119, -120, -118, -119, -117, -116, -114,
-113, -112, -111, -109, -108, -107, -107, -106, -106, -106, -105, -105, -106,
-106, -105, -106, -106, -106, -107, -106, -105, -105, -106, -105, -104, -103,
-102, -101, -100, -99, -97, -96, -94, -92, -90, -89, -87, -85, -83, -81, -80,
-78, -77, -74, -75, -73, -72, -71, -71, -71, -70, -70, -70, -70, -70, -69, -69,
-69, -69, -70, -68, -67, -66, -65, -63, -62, -60, -57, -56, -53, -50, -46, -43,
-41, -37, -34, -30, -26, -23, -20, -17, -14, -10, -7, -5, -2, 0, 3, 6, 6, 9, 11,
12, 14, 14, 16, 17, 17, 18, 20, 19, 20, 22, 22, 23, 24, 25, 26, 27, 29, 30, 33,
33, 36, 37, 39, 42, 44, 46, 49, 52, 54, 56, 57, 60, 61, 63, 65, 66, 67, 67, 67,
68, 68, 68, 68, 68, 67, 67, 65, 65, 65, 65, 63, 63, 64, 62, 64, 63, 63, 64, 64,
66, 67, 69, 71, 74, 76, 78, 80, 84, 86, 90, 92, 95, 97, 100, 103, 106, 108, 109,
112, 112, 114, 115, 115, 117, 117, 118, 118, 118, 118, 118, 119, 120, 119, 119,
118, 118, 119, 118, 116, 115, 114, 112, 110, 108, 104, 100, 95, 88, 81, 74, 63,
53, 43, 30, 17, 3, -10, -22, -33, -41, -49, -54, -60, -64, -67, -69, -71, -72,
-72, -72, -71, -70, -69, -68, -67, -65, -64, -62, -61, -61, -60, -60, -61, -63,
-64, -67, -70, -73, -77, -80, -84, -87, -92, -96, -99, -102, -105, -108, -109,
-113, -114, -115, -116, -117, -117, -118, -117, -118, -119, -119, -119, -119,
-119, -118, -118, -120, -119, -118, -119, -119, -119, -118, -118, -118, -117,
-116, -115, -114, -112, -111, -108, -106, -104, -101, -97, -93, -90, -86, -82,
-78, -74, -71, -68, -64, -61, -58, -55, -52, -50, -48, -46, -45, -44, -42, -41,
-41, -41, -40, -40, -39, -39, -38, -38, -38, -38, -37, -36, -36, -34, -34, -32,
-31, -29, -28, -26, -25, -24, -23, -19, -19, -16, -14, -12, -11, -11, -8, -7,
-6, -5, -4, -4, -3, -3, -2, -2, -2, -3, -2, -3, -3, -3, -3, -3, -4, -4, -5, -4,
-4, -3, -2, -2, 0, };