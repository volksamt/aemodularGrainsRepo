#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0072

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 12, 19, 27, 34, 40, 48, 55, 61, 67,
74, 78, 83, 87, 92, 95, 97, 99, 101, 102, 102, 102, 101, 100, 99, 98, 95, 94,
91, 89, 88, 85, 83, 81, 79, 77, 75, 73, 72, 71, 69, 67, 67, 66, 65, 64, 63, 62,
62, 62, 62, 62, 62, 63, 65, 65, 68, 68, 71, 74, 76, 79, 81, 84, 88, 91, 95, 98,
101, 103, 106, 109, 110, 110, 111, 111, 109, 109, 105, 103, 99, 95, 90, 84, 77,
71, 64, 57, 51, 44, 36, 29, 23, 17, 10, 5, -1, -5, -10, -14, -18, -21, -25, -27,
-28, -30, -31, -32, -32, -32, -31, -30, -29, -27, -26, -23, -21, -19, -14, -12,
-9, -6, -2, 0, 3, 7, 8, 11, 14, 15, 17, 18, 19, 20, 20, 20, 19, 18, 17, 14, 12,
9, 5, 2, -3, -9, -13, -19, -25, -30, -35, -41, -46, -52, -55, -59, -62, -65,
-66, -67, -68, -69, -70, -70, -70, -70, -70, -69, -70, -70, -71, -72, -73, -75,
-77, -79, -81, -83, -87, -89, -92, -96, -98, -101, -105, -107, -110, -112, -114,
-116, -117, -118, -119, -119, -119, -118, -118, -116, -116, -113, -112, -110,
-108, -106, -104, -103, -100, -99, -97, -95, -93, -91, -89, -86, -85, -81, -79,
-75, -70, -66, -60, -54, -48, -41, -34, -26, -18, -10, -1, 7, 17, 25, 32, 40,
46, 51, 58, 63, 67, 70, 72, 75, 75, 75, 76, 76, 75, 74, 71, 70, 68, 64, 62, 59,
55, 52, 49, 45, 40, 37, 32, 28, 24, 19, 15, 10, 5, 1, -2, -6, -8, -11, -13, -14,
-17, -16, -17, -16, -15, -13, -11, -7, -3, 1, 6, 11, 17, 25, 31, 39, 46, 53, 62,
69, 77, 85, 92, 99, 104, 110, 114, 116, 119, 119, 119, 117, 115, 112, 107, 102,
96, 90, 84, 77, 70, 64, 58, 51, 46, 40, 35, 31, 28, 25, 22, 20, 19, 18, 18, 19,
20, 20, 23, 26, 28, 31, 33, 36, 40, 43, 47, 50, 52, 56, 60, 63, 65, 68, 71, 73,
75, 77, 79, 82, 85, 86, 89, 90, 92, 93, 94, 94, 95, 94, 93, 90, 88, 85, 81, 76,
70, 63, 56, 47, 39, 31, 22, 12, 4, -5, -15, -23, -31, -40, -47, -53, -60, -65,
-70, -75, -80, -84, -87, -90, -93, -96, -98, -100, -103, -105, -106, -108, -110,
-111, -112, -113, -114, -114, -113, -113, -112, -110, -108, -107, -103, -101,
-98, -94, -92, -89, -84, -81, -78, -75, -71, -69, -67, -64, -62, -61, -59, -58,
-58, -58, -59, -59, -60, -61, -62, -63, -64, -65, -66, -67, -67, -67, -67, -66,
-65, -64, -61, -59, -56, -53, -50, -48, -43, -41, -37, -33, -31, -28, -26, -24,
-21, -21, -21, -20, -19, -21, -20, -22, -23, -24, -27, -30, -31, -35, -38, -40,
-43, -45, -49, -52, -54, -56, -59, -61, -63, -64, -65, -65, -65, -66, -65, -65,
-64, -63, -60, -58, -54, -52, -49, -45, -40, -36, -31, -26, -20, -13, -7, 0, };