#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0036

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 21, 34, 47, 59, 69, 78, 87, 93,
101, 106, 110, 114, 115, 118, 119, 119, 119, 118, 116, 116, 113, 112, 109, 107,
104, 103, 101, 99, 98, 95, 94, 94, 93, 92, 92, 91, 91, 93, 93, 94, 95, 97, 98,
100, 102, 104, 106, 108, 112, 112, 115, 115, 118, 118, 118, 119, 118, 118, 115,
112, 109, 104, 99, 91, 84, 75, 66, 56, 44, 31, 19, 5, -9, -23, -38, -52, -65,
-78, -90, -99, -108, -114, -118, -119, -118, -113, -105, -93, -80, -62, -44,
-22, 0, 22, 44, 65, 83, 98, 110, 117, 118, 117, 109, 99, 84, 66, 43, 20, -4,
-28, -51, -74, -92, -106, -116, -119, -116, -108, -93, -73, -47, -19, 11, 40,
67, 89, 107, 116, 119, 115, 103, 87, 65, 39, 10, -17, -46, -71, -93, -108, -117,
-118, -112, -97, -76, -48, -17, 16, 47, 75, 96, 112, 119, 117, 108, 92, 70, 44,
15, -16, -45, -71, -93, -109, -118, -118, -111, -96, -74, -47, -16, 16, 47, 75,
97, 111, 118, 118, 109, 95, 76, 52, 25, -4, -32, -57, -81, -99, -111, -118,
-118, -112, -98, -80, -55, -29, -1, 27, 53, 76, 95, 109, 117, 120, 115, 107, 94,
78, 59, 37, 15, -8, -31, -51, -71, -87, -101, -110, -117, -119, -118, -113,
-104, -91, -78, -60, -42, -23, -4, 16, 34, 52, 67, 81, 93, 103, 110, 115, 118,
119, 119, 115, 111, 106, 100, 93, 84, 76, 67, 57, 46, 39, 29, 18, 10, 2, -7,
-15, -22, -29, -35, -42, -48, -52, -57, -60, -65, -68, -71, -73, -76, -77, -79,
-80, -81, -82, -82, -83, -82, -81, -80, -80, -78, -75, -74, -71, -68, -65, -61,
-57, -52, -46, -41, -35, -29, -21, -14, -6, 2, 11, 20, 30, 39, 49, 59, 69, 78,
86, 95, 102, 108, 113, 116, 119, 119, 117, 113, 107, 98, 88, 73, 57, 39, 21, 1,
-19, -39, -57, -77, -91, -104, -113, -118, -120, -116, -108, -97, -82, -64, -43,
-20, 4, 28, 51, 73, 91, 105, 115, 119, 116, 108, 93, 72, 46, 17, -13, -43, -70,
-93, -108, -117, -118, -112, -98, -77, -51, -23, 8, 38, 66, 91, 107, 118, 118,
110, 92, 66, 34, -2, -36, -70, -95, -111, -119, -116, -104, -80, -53, -20, 14,
47, 77, 100, 114, 120, 112, 95, 68, 33, -4, -42, -76, -101, -115, -119, -111,
-92, -67, -34, 1, 36, 69, 94, 112, 118, 114, 99, 73, 39, 2, -38, -71, -97, -114,
-119, -112, -96, -73, -41, -6, 28, 60, 87, 107, 117, 118, 107, 87, 58, 23, -12,
-48, -79, -102, -116, -119, -113, -98, -75, -48, -16, 15, 46, 73, 95, 111, 118,
117, 108, 91, 67, 37, 5, -25, -56, -81, -100, -114, -118, -117, -108, -94, -75,
-52, -28, -2, 24, 48, 71, 89, 104, 114, 118, 118, 113, 102, 87, 70, 48, 24, 2,
-20, -43, -63, -80, -95, -106, -114, -118, -118, -116, -112, -104, -95, -84,
-72, -59, -44, -29, -14, -2, };