#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 2, 3, 4, 5, 7, 7, 8, 9, 11, 12,
12, 14, 15, 16, 17, 17, 19, 20, 22, 22, 22, 24, 25, 26, 27, 28, 29, 30, 32, 32,
33, 34, 36, 37, 38, 40, 41, 42, 43, 45, 45, 47, 49, 49, 51, 52, 54, 55, 57, 59,
61, 62, 64, 65, 67, 68, 70, 72, 73, 75, 77, 79, 81, 82, 84, 86, 88, 90, 91, 93,
96, 98, 99, 101, 103, 104, 107, 108, 109, 110, 112, 112, 115, 115, 117, 117,
119, 118, 118, 119, 118, 119, 119, 117, 116, 114, 113, 111, 109, 106, 103, 99,
95, 91, 85, 78, 72, 65, 58, 49, 40, 29, 18, 7, -4, -14, -23, -32, -39, -46, -53,
-59, -64, -69, -73, -76, -79, -81, -84, -86, -87, -90, -89, -90, -90, -90, -89,
-89, -88, -88, -86, -85, -84, -82, -80, -78, -76, -74, -72, -70, -67, -65, -63,
-60, -58, -56, -53, -51, -49, -46, -44, -41, -39, -36, -35, -32, -30, -29, -26,
-24, -22, -19, -18, -16, -14, -12, -10, -8, -6, -5, -3, -1, 0, 2, 4, 5, 6, 9,
11, 12, 12, 15, 16, 18, 19, 20, 22, 24, 25, 27, 28, 30, 31, 33, 35, 35, 37, 39,
40, 43, 44, 46, 47, 49, 51, 52, 54, 56, 58, 59, 61, 63, 64, 66, 68, 69, 72, 74,
75, 76, 78, 80, 82, 83, 86, 87, 89, 90, 92, 94, 96, 97, 99, 100, 101, 102, 105,
105, 106, 108, 109, 111, 112, 113, 114, 114, 115, 117, 117, 118, 118, 118, 118,
118, 118, 119, 119, 119, 118, 117, 117, 115, 115, 114, 113, 113, 112, 109, 108,
105, 103, 102, 100, 97, 95, 92, 89, 86, 82, 79, 75, 71, 67, 63, 58, 55, 49, 45,
40, 34, 28, 23, 17, 12, 6, 0, -5, -11, -16, -20, -25, -29, -32, -37, -40, -44,
-47, -49, -52, -56, -59, -60, -63, -65, -67, -69, -71, -73, -74, -76, -78, -80,
-80, -80, -82, -83, -83, -85, -86, -86, -87, -88, -88, -89, -89, -89, -89, -90,
-90, -91, -90, -91, -91, -91, -91, -90, -90, -91, -91, -90, -90, -91, -91, -90,
-90, -90, -90, -89, -88, -89, -89, -88, -88, -87, -87, -87, -87, -87, -87, -86,
-85, -86, -85, -84, -84, -84, -84, -82, -83, -82, -81, -81, -82, -80, -81, -80,
-79, -79, -78, -78, -79, -78, -78, -77, -76, -77, -77, -75, -75, -74, -74, -74,
-74, -73, -73, -72, -71, -72, -70, -70, -70, -69, -68, -69, -68, -68, -67, -67,
-66, -66, -65, -65, -63, -64, -64, -63, -61, -62, -60, -61, -60, -60, -59, -59,
-57, -57, -56, -55, -54, -54, -54, -52, -52, -52, -51, -51, -49, -49, -48, -47,
-46, -45, -45, -45, -43, -42, -42, -42, -40, -39, -39, -37, -36, -36, -34, -34,
-33, -32, -32, -30, -29, -28, -28, -27, -26, -24, -24, -23, -22, -21, -20, -19,
-18, -17, -16, -14, -14, -13, -12, -11, -10, -9, -7, -6, -7, -5, -4, -2, -2, -1,
};