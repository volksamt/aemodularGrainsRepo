#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0058

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 18, 29, 37, 44, 48, 50, 50, 49, 43,
37, 30, 20, 8, -5, -19, -33, -47, -60, -72, -81, -89, -97, -102, -105, -107,
-108, -109, -108, -105, -102, -97, -91, -82, -71, -58, -44, -28, -6, 15, 34, 47,
62, 75, 85, 93, 99, 104, 107, 108, 110, 109, 108, 106, 103, 97, 90, 82, 71, 60,
47, 33, 20, 6, -7, -18, -28, -36, -42, -45, -48, -47, -46, -41, -34, -25, -13,
0, 14, 30, 46, 61, 76, 87, 98, 106, 112, 116, 118, 120, 119, 118, 118, 119, 119,
119, 120, 118, 118, 115, 111, 104, 97, 89, 78, 68, 56, 44, 34, 26, 18, 13, 10,
7, 9, 14, 19, 28, 37, 49, 60, 73, 85, 96, 105, 113, 117, 119, 118, 116, 113,
109, 105, 101, 99, 98, 99, 100, 102, 107, 110, 113, 117, 118, 119, 118, 114,
109, 101, 94, 87, 81, 74, 68, 65, 62, 63, 65, 68, 74, 81, 90, 97, 106, 111, 116,
118, 118, 116, 111, 103, 95, 85, 76, 67, 61, 56, 52, 51, 53, 56, 62, 69, 77, 86,
95, 103, 110, 115, 118, 118, 118, 117, 114, 111, 108, 105, 103, 102, 103, 105,
107, 111, 114, 117, 119, 119, 117, 112, 104, 93, 82, 67, 53, 39, 26, 14, 5, -1,
-8, -9, -8, -6, -1, 6, 16, 27, 39, 52, 65, 77, 89, 99, 106, 111, 115, 118, 119,
119, 119, 119, 119, 119, 118, 118, 117, 115, 111, 105, 95, 84, 71, 54, 37, 20,
2, -13, -28, -40, -51, -58, -64, -66, -68, -67, -63, -58, -50, -41, -29, -16,
-1, 13, 29, 44, 57, 71, 81, 89, 95, 101, 103, 105, 106, 106, 104, 101, 97, 90,
80, 69, 55, 41, 23, 4, -14, -32, -49, -64, -76, -86, -94, -100, -104, -106,
-107, -107, -106, -104, -100, -95, -88, -79, -68, -55, -41, -26, -11, 5, 19, 31,
42, 51, 58, 63, 65, 65, 63, 59, 52, 45, 33, 20, 5, -12, -29, -47, -63, -78, -91,
-101, -108, -114, -116, -118, -119, -118, -119, -120, -119, -119, -119, -119,
-117, -115, -110, -105, -97, -86, -76, -62, -50, -38, -25, -15, -6, 1, 4, 6, 5,
3, -4, -12, -22, -34, -48, -62, -75, -89, -99, -108, -114, -118, -119, -118,
-115, -112, -109, -105, -104, -102, -101, -102, -104, -107, -111, -114, -117,
-119, -118, -117, -114, -109, -101, -93, -84, -77, -68, -62, -58, -54, -54, -55,
-59, -65, -73, -82, -90, -100, -108, -114, -118, -118, -118, -114, -109, -101,
-92, -84, -77, -70, -66, -61, -59, -61, -64, -68, -73, -81, -88, -97, -103,
-110, -115, -118, -119, -118, -117, -114, -110, -107, -102, -100, -100, -100,
-101, -104, -108, -112, -115, -117, -119, -117, -115, -109, -101, -90, -79, -67,
-54, -41, -31, -22, -14, -9, -7, -5, -8, -12, -18, -26, -36, -46, -58, -68, -81,
-90, -99, -107, -112, -116, -117, -119, -120, -119, -119, -119, -118, -119,
-119, -118, -116, -114, -109, -102, -93, -80, -68, -52, -38, -21, -6, };