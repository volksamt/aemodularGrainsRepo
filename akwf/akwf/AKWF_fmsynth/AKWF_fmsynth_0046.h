#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0046

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 9, 14, 18, 22, 27, 30, 34, 38, 41,
43, 46, 49, 50, 53, 54, 56, 57, 59, 60, 61, 62, 65, 66, 67, 69, 72, 73, 75, 77,
79, 82, 85, 87, 90, 93, 96, 99, 102, 104, 107, 110, 112, 115, 115, 116, 118,
119, 119, 119, 118, 118, 117, 116, 115, 113, 113, 112, 110, 109, 108, 106, 106,
105, 106, 105, 105, 106, 105, 106, 107, 108, 109, 110, 112, 112, 114, 115, 115,
116, 117, 118, 118, 119, 118, 119, 119, 120, 119, 119, 119, 120, 119, 118, 118,
119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 119, 120, 119,
118, 119, 119, 119, 118, 118, 120, 119, 119, 119, 119, 119, 119, 120, 118, 118,
118, 118, 117, 116, 115, 115, 114, 112, 111, 111, 109, 108, 107, 106, 106, 106,
105, 105, 105, 105, 105, 106, 107, 108, 109, 110, 112, 113, 114, 116, 116, 119,
119, 118, 119, 119, 118, 117, 115, 114, 113, 110, 108, 106, 103, 99, 97, 93, 90,
87, 85, 82, 78, 76, 74, 71, 70, 68, 65, 64, 62, 61, 59, 58, 56, 55, 53, 52, 49,
47, 45, 43, 39, 37, 33, 30, 26, 22, 17, 14, 8, 3, -2, -8, -13, -20, -25, -32,
-37, -44, -49, -55, -62, -67, -72, -77, -81, -85, -89, -92, -95, -96, -99, -100,
-101, -102, -103, -104, -104, -105, -104, -104, -103, -102, -101, -100, -98,
-97, -95, -93, -91, -90, -87, -85, -82, -79, -77, -74, -72, -70, -67, -64, -64,
-61, -60, -59, -59, -57, -57, -56, -57, -57, -57, -58, -59, -60, -60, -61, -63,
-64, -65, -65, -67, -67, -68, -68, -69, -69, -69, -69, -69, -67, -67, -67, -64,
-63, -61, -59, -56, -54, -51, -48, -45, -42, -39, -34, -32, -28, -24, -22, -19,
-16, -14, -12, -11, -8, -7, -7, -6, -7, -7, -9, -10, -13, -15, -18, -22, -25,
-29, -35, -40, -43, -50, -55, -60, -65, -70, -76, -81, -85, -90, -94, -98, -102,
-104, -106, -109, -111, -113, -114, -115, -117, -117, -118, -118, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -118, -118, -118, -119, -117, -117,
-118, -117, -117, -116, -116, -115, -114, -112, -110, -109, -108, -105, -102,
-99, -97, -92, -89, -85, -81, -76, -71, -67, -60, -55, -51, -45, -39, -34, -29,
-26, -21, -17, -13, -10, -9, -5, -4, -1, -2, 0, -1, -1, -2, -2, -4, -6, -8, -11,
-14, -16, -20, -23, -25, -29, -32, -36, -38, -41, -45, -47, -49, -52, -53, -56,
-57, -59, -60, -60, -61, -62, -61, -61, -61, -61, -60, -60, -59, -57, -56, -56,
-55, -53, -52, -51, -50, -49, -50, -48, -49, -49, -49, -49, -51, -51, -52, -54,
-56, -58, -60, -62, -65, -67, -69, -72, -75, -78, -80, -83, -84, -87, -89, -91,
-93, -94, -95, -96, -97, -98, -97, -97, -98, -97, -97, -95, -94, -92, -90, -88,
-86, -83, -79, -76, -71, -67, -62, -57, -51, -46, -40, -35, -29, -22, -17, -12,
-4, };