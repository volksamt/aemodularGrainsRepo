#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 7, 9, 12, 15, 16, 19, 20, 23,
24, 27, 28, 30, 33, 35, 37, 37, 40, 42, 43, 44, 45, 47, 49, 50, 51, 52, 53, 54,
56, 55, 57, 58, 57, 59, 59, 59, 59, 60, 61, 59, 60, 60, 60, 59, 59, 59, 59, 58,
58, 56, 55, 55, 54, 52, 51, 50, 49, 48, 46, 45, 44, 42, 41, 39, 37, 35, 34, 32,
30, 27, 25, 24, 21, 19, 18, 16, 13, 12, 9, 6, 5, 2, 0, -2, -4, -6, -9, -12, -13,
-16, -18, -22, -24, -27, -29, -32, -36, -39, -42, -46, -49, -53, -57, -60, -64,
-69, -73, -78, -82, -86, -90, -96, -100, -103, -107, -111, -113, -116, -118,
-119, -119, -118, -114, -110, -105, -96, -85, -72, -56, -37, -13, 12, 33, 49,
64, 75, 84, 91, 94, 97, 97, 98, 96, 93, 90, 86, 81, 76, 71, 66, 60, 54, 49, 44,
38, 34, 27, 23, 18, 14, 9, 5, 1, -3, -7, -11, -16, -19, -23, -28, -32, -36, -40,
-45, -49, -55, -61, -66, -70, -75, -81, -86, -92, -96, -101, -106, -110, -113,
-115, -118, -118, -119, -118, -114, -110, -104, -95, -85, -73, -58, -40, -19, 4,
23, 40, 54, 65, 75, 81, 89, 93, 95, 97, 98, 98, 98, 97, 94, 92, 89, 87, 83, 81,
76, 74, 70, 67, 63, 60, 56, 54, 49, 47, 43, 41, 38, 35, 33, 30, 27, 26, 23, 21,
19, 16, 14, 12, 11, 9, 8, 7, 5, 3, 2, 1, 0, -1, -2, -3, -5, -5, -6, -7, -8, -8,
-9, -10, -10, -11, -11, -11, -12, -12, -12, -13, -13, -13, -13, -12, -12, -12,
-13, -12, -12, -11, -11, -10, -9, -9, -8, -7, -7, -6, -6, -4, -3, -2, -1, 0, 1,
3, 4, 6, 8, 8, 11, 12, 15, 16, 17, 20, 22, 25, 28, 29, 32, 35, 38, 40, 44, 47,
50, 54, 57, 61, 64, 69, 72, 75, 79, 83, 86, 88, 91, 95, 96, 97, 98, 97, 96, 93,
89, 84, 76, 67, 55, 41, 22, 0, -25, -47, -65, -80, -92, -103, -110, -114, -117,
-120, -120, -117, -114, -111, -107, -101, -97, -91, -85, -79, -73, -67, -61,
-55, -50, -44, -38, -33, -28, -23, -19, -14, -9, -5, 0, 6, 10, 15, 21, 27, 33,
39, 46, 53, 60, 66, 74, 79, 85, 90, 95, 96, 97, 96, 92, 84, 74, 57, 37, 8, -25,
-53, -76, -93, -104, -112, -117, -119, -118, -116, -111, -106, -100, -94, -87,
-81, -73, -67, -60, -53, -47, -41, -36, -30, -24, -19, -14, -9, -4, 0, 5, 10,
16, 22, 27, 33, 39, 45, 53, 59, 65, 72, 78, 84, 89, 93, 96, 98, 97, 96, 93, 87,
77, 64, 48, 28, 4, -24, -49, -68, -83, -95, -105, -112, -115, -119, -119, -119,
-117, -114, -111, -107, -103, -98, -93, -89, -84, -79, -76, -70, -66, -62, -57,
-53, -48, -45, -41, -38, -35, -31, -28, -25, -22, -19, -16, -15, -11, -6, -4,
-1, };