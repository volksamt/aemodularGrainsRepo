#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0064

const PROGMEM int8_t DATA[DATA_LENGTH] = {17, 44, 65, 81, 94, 105, 111, 115,
118, 119, 119, 118, 115, 112, 108, 103, 99, 95, 90, 86, 81, 76, 71, 67, 63, 59,
55, 51, 47, 44, 40, 37, 34, 31, 28, 26, 23, 21, 19, 17, 15, 13, 10, 9, 7, 6, 5,
3, 2, 1, 0, -1, -2, -4, -4, -5, -5, -6, -6, -6, -7, -7, -8, -7, -7, -7, -6, -6,
-6, -6, -5, -5, -4, -2, -2, 0, 1, 2, 3, 5, 5, 7, 9, 11, 12, 15, 17, 19, 21, 23,
26, 29, 31, 35, 38, 42, 44, 49, 52, 57, 61, 65, 70, 75, 81, 86, 90, 95, 100,
104, 109, 113, 115, 118, 119, 119, 116, 112, 105, 94, 79, 62, 37, 6, -27, -53,
-76, -92, -105, -113, -118, -120, -118, -115, -111, -104, -97, -89, -80, -73,
-64, -55, -47, -38, -31, -25, -17, -10, -3, 4, 10, 17, 24, 32, 41, 50, 58, 69,
78, 89, 98, 107, 114, 118, 119, 114, 105, 85, 56, 14, -33, -71, -94, -110, -118,
-119, -116, -109, -100, -90, -79, -68, -56, -45, -36, -27, -17, -9, -1, 7, 15,
24, 33, 43, 53, 65, 77, 88, 98, 109, 116, 119, 117, 109, 90, 62, 15, -37, -74,
-98, -113, -119, -118, -114, -105, -95, -83, -72, -61, -50, -40, -31, -21, -13,
-4, 3, 12, 20, 29, 38, 48, 59, 71, 81, 91, 101, 110, 116, 119, 118, 110, 94, 70,
34, -13, -54, -84, -103, -114, -119, -118, -115, -109, -102, -92, -83, -72, -63,
-54, -44, -36, -29, -22, -15, -8, -1, 4, 10, 17, 24, 32, 39, 46, 54, 61, 69, 77,
85, 93, 99, 106, 112, 115, 118, 119, 119, 113, 107, 96, 84, 65, 46, 18, -12,
-38, -60, -77, -90, -100, -108, -113, -117, -118, -119, -119, -117, -115, -112,
-109, -106, -103, -100, -95, -91, -88, -83, -80, -76, -73, -71, -67, -64, -62,
-58, -56, -53, -50, -48, -47, -45, -42, -41, -40, -39, -37, -36, -36, -35, -33,
-33, -31, -31, -32, -31, -30, -30, -30, -31, -30, -31, -32, -32, -33, -34, -34,
-35, -36, -38, -38, -40, -40, -43, -44, -47, -47, -51, -53, -55, -57, -59, -63,
-65, -68, -72, -75, -77, -81, -84, -89, -92, -95, -99, -102, -106, -110, -112,
-115, -117, -119, -120, -118, -117, -115, -111, -106, -98, -88, -75, -59, -39,
-15, 13, 37, 58, 76, 90, 101, 109, 114, 117, 119, 119, 116, 112, 109, 103, 98,
91, 83, 77, 70, 62, 55, 48, 42, 35, 29, 22, 18, 12, 7, 0, -5, -10, -16, -23,
-28, -34, -42, -49, -56, -64, -72, -81, -89, -96, -103, -109, -114, -118, -120,
-117, -112, -102, -86, -66, -37, 0, 36, 65, 86, 101, 111, 118, 119, 118, 114,
109, 103, 96, 88, 79, 72, 64, 55, 48, 41, 34, 27, 20, 15, 9, 3, -3, -9, -14,
-20, -26, -32, -40, -46, -53, -60, -68, -75, -83, -90, -97, -103, -109, -114,
-117, -118, -119, -117, -112, -104, -93, -79, -60, -37, -10, };