#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0060

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 19, 35, 51, 65, 76, 85, 94, 99,
105, 108, 111, 113, 114, 115, 116, 115, 114, 112, 112, 109, 105, 100, 94, 87,
79, 68, 56, 42, 27, 12, -4, -20, -35, -51, -65, -77, -88, -97, -104, -110, -114,
-118, -119, -119, -118, -119, -119, -117, -117, -117, -118, -118, -118, -119,
-119, -119, -118, -115, -111, -105, -97, -87, -76, -61, -46, -28, -9, 10, 28,
46, 64, 79, 92, 102, 110, 116, 118, 119, 118, 115, 112, 108, 104, 100, 96, 93,
91, 90, 90, 92, 94, 96, 100, 104, 108, 112, 116, 118, 118, 118, 116, 112, 106,
97, 87, 75, 62, 49, 33, 18, 4, -10, -24, -35, -46, -56, -64, -70, -76, -79, -83,
-85, -86, -85, -83, -80, -77, -72, -65, -57, -48, -36, -23, -10, 6, 22, 37, 53,
69, 83, 96, 107, 113, 118, 119, 117, 112, 104, 94, 82, 70, 57, 44, 32, 21, 10,
2, -6, -11, -14, -16, -17, -16, -13, -8, -3, 3, 12, 22, 33, 45, 57, 70, 81, 92,
102, 109, 115, 118, 119, 117, 114, 108, 102, 93, 84, 74, 64, 56, 47, 38, 32, 25,
21, 17, 16, 15, 17, 21, 25, 31, 37, 46, 55, 64, 74, 85, 95, 104, 111, 115, 118,
119, 115, 109, 99, 86, 70, 53, 34, 15, -3, -21, -38, -51, -65, -77, -85, -92,
-98, -101, -105, -106, -107, -108, -108, -108, -106, -103, -100, -96, -90, -82,
-74, -63, -50, -37, -22, -6, 11, 28, 46, 61, 75, 87, 97, 107, 112, 116, 118,
118, 118, 116, 114, 113, 109, 108, 105, 105, 105, 105, 106, 108, 109, 112, 115,
118, 118, 119, 118, 115, 111, 103, 92, 79, 64, 45, 25, 6, -15, -35, -54, -71,
-86, -99, -107, -113, -118, -118, -120, -118, -116, -113, -110, -108, -105,
-103, -103, -102, -103, -104, -106, -108, -111, -114, -115, -118, -119, -118,
-117, -113, -106, -98, -88, -75, -60, -44, -29, -11, 5, 20, 36, 50, 62, 73, 81,
88, 94, 99, 102, 104, 105, 107, 106, 106, 103, 102, 98, 94, 87, 80, 69, 58, 45,
29, 12, -5, -25, -44, -61, -77, -92, -104, -113, -117, -120, -117, -113, -108,
-100, -90, -79, -69, -58, -48, -39, -31, -25, -19, -16, -13, -12, -12, -15, -18,
-23, -28, -36, -44, -53, -63, -73, -83, -91, -101, -109, -114, -118, -119, -118,
-114, -110, -102, -92, -82, -71, -58, -46, -35, -24, -15, -6, 0, 5, 10, 11, 12,
12, 9, 5, -2, -8, -17, -28, -40, -52, -63, -77, -89, -99, -108, -114, -118,
-119, -116, -111, -102, -91, -77, -62, -46, -30, -13, 2, 18, 32, 44, 55, 63, 70,
77, 81, 84, 86, 87, 88, 87, 85, 82, 78, 73, 66, 57, 48, 36, 24, 11, -3, -18,
-33, -48, -61, -75, -87, -97, -106, -112, -116, -119, -119, -118, -116, -113,
-109, -106, -101, -99, -96, -94, -94, -94, -95, -97, -100, -102, -107, -111,
-115, -117, -120, -119, -117, -114, -107, -97, -86, -71, -55, -38, -17, -2, };