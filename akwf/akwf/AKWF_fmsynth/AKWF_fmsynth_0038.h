#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0038

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 32, 50, 69, 84, 98, 109, 115, 118,
118, 117, 111, 105, 98, 90, 84, 78, 73, 68, 66, 66, 65, 66, 70, 72, 78, 82, 88,
92, 97, 102, 105, 109, 110, 113, 114, 116, 114, 115, 116, 114, 112, 110, 108,
102, 96, 86, 77, 63, 48, 30, 11, -8, -29, -47, -64, -81, -92, -103, -110, -115,
-118, -119, -118, -117, -115, -114, -112, -111, -111, -111, -112, -114, -115,
-117, -118, -119, -119, -119, -119, -117, -115, -113, -111, -110, -108, -107,
-107, -106, -108, -110, -112, -115, -117, -119, -118, -118, -115, -109, -101,
-87, -73, -57, -37, -18, 1, 19, 37, 53, 67, 78, 87, 94, 101, 104, 107, 108, 109,
110, 108, 107, 105, 102, 98, 93, 87, 80, 74, 66, 57, 49, 42, 35, 28, 25, 21, 19,
19, 20, 24, 30, 36, 45, 55, 65, 76, 88, 97, 107, 114, 117, 118, 118, 113, 105,
97, 87, 75, 64, 53, 43, 34, 27, 20, 16, 14, 14, 15, 17, 22, 28, 35, 43, 51, 60,
68, 76, 84, 91, 97, 102, 106, 108, 111, 113, 114, 114, 114, 113, 112, 110, 107,
103, 97, 89, 81, 69, 57, 42, 27, 10, -6, -23, -39, -52, -66, -76, -85, -93, -99,
-103, -106, -108, -109, -110, -109, -107, -107, -103, -99, -94, -88, -80, -71,
-62, -52, -40, -29, -19, -8, 2, 11, 18, 24, 29, 31, 33, 33, 31, 26, 21, 14, 6,
-5, -16, -29, -41, -55, -68, -80, -90, -99, -106, -112, -116, -118, -119, -119,
-119, -117, -116, -116, -116, -115, -117, -117, -119, -119, -119, -118, -116,
-112, -107, -101, -93, -84, -73, -64, -53, -41, -32, -22, -16, -9, -4, -1, 0, 0,
-2, -6, -11, -18, -26, -35, -45, -56, -67, -77, -87, -95, -103, -108, -113,
-116, -118, -118, -119, -119, -118, -119, -118, -119, -118, -119, -118, -119,
-118, -116, -112, -107, -99, -90, -79, -67, -53, -39, -25, -11, 3, 14, 25, 35,
42, 49, 53, 55, 58, 57, 56, 53, 47, 41, 34, 26, 16, 5, -6, -17, -28, -39, -50,
-58, -65, -73, -78, -83, -85, -87, -88, -87, -85, -82, -77, -70, -61, -52, -41,
-27, -10, 6, 24, 43, 59, 75, 88, 98, 105, 111, 116, 117, 118, 119, 119, 119,
119, 119, 119, 119, 118, 117, 117, 114, 111, 108, 104, 98, 93, 88, 81, 76, 72,
68, 67, 65, 66, 68, 72, 76, 83, 90, 97, 104, 111, 115, 118, 119, 116, 111, 102,
90, 77, 62, 46, 30, 13, -1, -15, -27, -38, -46, -53, -57, -61, -63, -62, -62,
-60, -56, -50, -45, -39, -31, -23, -15, -7, 1, 8, 14, 21, 24, 28, 30, 30, 28,
25, 20, 13, 5, -5, -18, -31, -45, -60, -74, -88, -99, -109, -115, -119, -119,
-115, -108, -99, -88, -77, -64, -52, -41, -31, -24, -17, -13, -10, -9, -10, -12,
-16, -20, -26, -33, -41, -48, -55, -63, -69, -75, -80, -84, -87, -89, -90, -90,
-88, -86, -83, -76, -68, -59, -47, -34, -18, -2, };