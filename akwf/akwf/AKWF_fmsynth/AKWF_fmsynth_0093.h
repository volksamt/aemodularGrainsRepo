#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0093

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 3, 5, 6, 10, 14, 19, 23, 27,
31, 34, 38, 43, 45, 49, 52, 56, 59, 62, 65, 68, 71, 74, 76, 79, 81, 84, 87, 88,
90, 92, 93, 95, 97, 99, 100, 102, 103, 105, 106, 106, 107, 109, 109, 110, 111,
111, 112, 112, 112, 113, 114, 114, 114, 116, 115, 115, 115, 115, 115, 115, 116,
116, 116, 116, 116, 115, 115, 115, 116, 115, 115, 114, 115, 114, 113, 113, 114,
113, 112, 112, 111, 110, 110, 110, 109, 109, 107, 106, 106, 104, 104, 103, 101,
100, 99, 98, 97, 96, 94, 92, 90, 89, 88, 85, 83, 82, 81, 79, 77, 75, 73, 71, 69,
67, 65, 63, 62, 60, 58, 55, 53, 51, 49, 47, 45, 42, 41, 40, 37, 35, 32, 31, 29,
27, 26, 24, 21, 21, 19, 17, 15, 14, 13, 12, 10, 9, 7, 6, 5, 4, 3, 2, 1, 0, 0,
-2, -2, -2, -2, -3, -3, -4, -4, -4, -3, -3, -4, -4, -4, -3, -2, -1, -1, 0, 1, 2,
2, 4, 5, 6, 8, 9, 10, 12, 13, 15, 17, 19, 21, 23, 25, 26, 28, 31, 34, 36, 39,
41, 44, 46, 49, 52, 54, 57, 60, 63, 66, 69, 72, 75, 78, 80, 84, 85, 89, 92, 94,
96, 99, 102, 104, 107, 109, 111, 112, 114, 115, 117, 118, 118, 119, 118, 119,
119, 118, 117, 115, 113, 111, 109, 105, 101, 97, 92, 87, 81, 76, 68, 60, 51, 42,
31, 21, 9, -2, -12, -23, -31, -41, -51, -59, -66, -74, -79, -84, -88, -92, -97,
-100, -104, -106, -109, -112, -113, -115, -116, -117, -118, -118, -119, -119,
-119, -118, -119, -118, -119, -118, -118, -117, -116, -115, -116, -115, -114,
-113, -113, -111, -111, -110, -110, -110, -109, -107, -107, -107, -106, -105,
-106, -106, -105, -105, -104, -103, -104, -104, -104, -104, -104, -104, -105,
-104, -105, -105, -105, -105, -106, -106, -106, -106, -108, -108, -108, -109,
-110, -110, -110, -111, -113, -113, -112, -114, -115, -115, -115, -116, -116,
-116, -118, -118, -118, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -118, -117, -117, -116, -115, -114, -113, -111, -111, -110, -108, -106,
-104, -102, -100, -98, -96, -93, -90, -87, -86, -83, -80, -76, -73, -71, -66,
-63, -60, -57, -53, -50, -46, -44, -39, -35, -33, -28, -25, -23, -19, -16, -13,
-10, -7, -5, -3, 0, 2, 4, 6, 6, 8, 9, 11, 10, 11, 11, 11, 11, 10, 9, 9, 7, 6, 4,
2, 0, -3, -6, -8, -11, -14, -17, -22, -25, -29, -33, -36, -41, -45, -49, -53,
-56, -60, -64, -68, -73, -76, -80, -84, -88, -91, -94, -97, -100, -104, -105,
-108, -110, -112, -114, -115, -116, -118, -118, -120, -119, -119, -119, -119,
-118, -118, -116, -115, -114, -112, -110, -108, -106, -104, -101, -99, -96, -93,
-90, -86, -83, -79, -75, -72, -69, -66, -61, -57, -53, -49, -45, -42, -37, -33,
-29, -24, -19, -14, -9, -5, -2, 1, };