#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0040

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 22, 32, 40, 43, 43, 39, 30, 19, 7,
-6, -20, -33, -43, -54, -61, -65, -66, -62, -55, -44, -30, -14, 2, 16, 30, 42,
54, 64, 70, 73, 72, 68, 59, 49, 36, 22, 8, -5, -16, -25, -31, -32, -32, -25,
-16, -4, 11, 24, 37, 50, 62, 72, 81, 88, 92, 95, 95, 91, 84, 74, 62, 48, 36, 23,
14, 6, 3, 3, 7, 15, 25, 37, 49, 59, 69, 77, 85, 91, 97, 103, 106, 110, 109, 108,
102, 93, 84, 71, 61, 51, 42, 38, 37, 40, 45, 54, 63, 71, 79, 84, 89, 93, 96,
100, 103, 107, 111, 114, 115, 114, 111, 106, 97, 89, 81, 74, 70, 68, 69, 73, 79,
86, 91, 96, 98, 98, 97, 95, 95, 95, 96, 100, 103, 108, 110, 112, 112, 109, 105,
100, 96, 93, 92, 93, 96, 99, 104, 108, 109, 108, 104, 99, 93, 86, 82, 79, 79,
82, 87, 92, 97, 101, 105, 106, 106, 104, 104, 104, 106, 110, 112, 116, 117, 116,
111, 104, 95, 85, 74, 66, 59, 55, 54, 56, 62, 69, 77, 85, 90, 96, 100, 103, 105,
109, 113, 116, 118, 119, 115, 110, 99, 87, 74, 61, 48, 37, 28, 24, 22, 26, 32,
40, 51, 61, 70, 79, 86, 92, 99, 104, 109, 111, 111, 107, 100, 88, 74, 59, 43,
28, 14, 1, -9, -11, -11, -4, 5, 15, 28, 40, 52, 64, 73, 80, 87, 92, 93, 92, 86,
77, 63, 48, 30, 14, -2, -16, -28, -37, -43, -45, -43, -37, -29, -15, -2, 11, 25,
38, 49, 58, 64, 67, 67, 62, 52, 39, 24, 9, -7, -23, -36, -49, -58, -68, -72,
-74, -73, -66, -57, -44, -32, -17, -3, 10, 21, 30, 34, 34, 30, 23, 11, -2, -16,
-30, -44, -55, -66, -75, -84, -90, -95, -97, -95, -90, -82, -70, -58, -44, -31,
-19, -9, -5, -2, -4, -9, -19, -30, -42, -54, -64, -73, -79, -86, -92, -98, -104,
-108, -110, -109, -106, -99, -90, -78, -67, -57, -47, -41, -37, -39, -42, -50,
-58, -68, -76, -82, -87, -90, -93, -96, -99, -103, -108, -110, -114, -115, -113,
-109, -102, -94, -86, -79, -72, -70, -70, -71, -77, -84, -89, -95, -98, -99,
-98, -96, -94, -93, -93, -95, -99, -104, -108, -110, -111, -111, -108, -103,
-99, -95, -94, -92, -96, -99, -103, -107, -109, -109, -106, -102, -96, -89, -84,
-80, -78, -79, -82, -88, -94, -99, -102, -105, -105, -106, -106, -106, -107,
-110, -113, -116, -117, -118, -115, -109, -100, -91, -81, -71, -62, -56, -53,
-54, -58, -63, -71, -79, -86, -91, -97, -101, -104, -108, -111, -115, -118,
-119, -118, -113, -105, -95, -82, -68, -56, -43, -33, -27, -23, -23, -28, -35,
-43, -53, -63, -73, -82, -89, -96, -101, -106, -110, -111, -108, -103, -95, -82,
-68, -53, -38, -23, -10, 1, 7, 10, 9, 5, -3, -14, -26, -38, -49, -60, -70, -78,
-85, -89, -92, -90, -86, -76, -64, -49, -34, -17, -3, };