#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0101

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 8, 15, 22, 29, 36, 43, 49, 57, 62,
68, 73, 79, 84, 90, 93, 98, 101, 105, 108, 110, 113, 115, 117, 117, 117, 119,
119, 119, 118, 118, 116, 116, 115, 113, 111, 109, 107, 105, 102, 100, 98, 95,
92, 89, 86, 84, 82, 80, 76, 74, 71, 69, 67, 64, 63, 60, 58, 57, 56, 54, 52, 51,
50, 50, 48, 48, 47, 47, 47, 47, 47, 47, 48, 47, 48, 49, 49, 50, 52, 52, 54, 56,
57, 59, 60, 62, 65, 67, 69, 71, 73, 74, 76, 80, 82, 84, 86, 88, 91, 93, 96, 98,
101, 102, 104, 106, 108, 110, 111, 112, 114, 115, 117, 117, 117, 118, 118, 118,
117, 117, 118, 116, 115, 115, 114, 111, 111, 109, 108, 105, 103, 101, 98, 96,
93, 90, 88, 84, 81, 79, 76, 71, 69, 65, 62, 59, 55, 52, 49, 46, 43, 40, 37, 34,
31, 28, 25, 23, 20, 17, 15, 13, 11, 8, 6, 5, 3, 2, 0, -1, -3, -4, -5, -6, -5,
-6, -6, -7, -7, -6, -6, -5, -5, -5, -3, -3, -3, -1, 0, 2, 5, 6, 9, 10, 13, 15,
18, 19, 22, 25, 29, 31, 36, 39, 42, 46, 50, 53, 57, 61, 64, 67, 72, 76, 79, 83,
86, 90, 94, 96, 99, 103, 105, 108, 110, 111, 113, 115, 116, 117, 117, 117, 117,
116, 115, 112, 110, 107, 104, 101, 97, 92, 88, 82, 77, 70, 65, 57, 51, 44, 37,
29, 21, 14, 7, -1, -9, -16, -23, -31, -38, -45, -53, -59, -66, -72, -78, -83,
-88, -93, -98, -101, -105, -107, -110, -114, -115, -116, -118, -119, -119, -119,
-119, -119, -117, -116, -115, -114, -112, -111, -109, -106, -104, -102, -99,
-97, -94, -91, -88, -86, -83, -81, -79, -76, -73, -71, -69, -67, -64, -62, -60,
-58, -57, -55, -54, -52, -50, -49, -48, -48, -47, -47, -46, -45, -46, -45, -45,
-45, -46, -46, -47, -47, -47, -49, -50, -51, -53, -54, -55, -57, -58, -60, -62,
-64, -66, -68, -70, -73, -75, -77, -80, -81, -84, -86, -89, -91, -93, -95, -97,
-99, -102, -104, -106, -107, -109, -111, -112, -114, -114, -115, -117, -117,
-118, -119, -118, -118, -118, -117, -117, -117, -115, -114, -113, -111, -110,
-108, -106, -103, -101, -99, -97, -93, -90, -88, -84, -81, -78, -74, -71, -68,
-64, -61, -58, -54, -50, -46, -44, -41, -38, -35, -31, -29, -26, -23, -20, -17,
-15, -12, -11, -9, -7, -5, -3, -2, 0, 2, 2, 4, 4, 5, 5, 6, 7, 7, 7, 6, 7, 6, 6,
5, 3, 2, 1, 1, 0, -2, -4, -7, -8, -10, -12, -15, -18, -20, -24, -26, -30, -33,
-37, -41, -44, -48, -51, -55, -59, -63, -67, -71, -76, -79, -83, -86, -89, -93,
-97, -100, -103, -106, -109, -111, -112, -114, -115, -117, -117, -118, -117,
-117, -116, -114, -112, -111, -108, -105, -102, -97, -93, -89, -84, -79, -73,
-68, -62, -55, -49, -41, -35, -27, -20, -13, -6, };