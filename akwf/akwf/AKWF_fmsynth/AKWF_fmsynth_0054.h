#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0054

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 16, 32, 48, 63, 76, 88, 98, 106,
112, 116, 118, 118, 119, 119, 118, 116, 116, 116, 116, 116, 117, 117, 118, 119,
119, 119, 117, 116, 112, 109, 103, 97, 90, 83, 75, 68, 60, 53, 46, 42, 37, 34,
34, 34, 35, 38, 43, 49, 56, 64, 72, 82, 91, 99, 107, 113, 117, 119, 119, 115,
110, 102, 93, 81, 68, 56, 44, 33, 22, 12, 5, -2, -7, -10, -11, -10, -9, -7, -2,
4, 10, 18, 27, 37, 47, 57, 68, 77, 86, 94, 100, 105, 110, 113, 115, 117, 118,
118, 118, 119, 119, 118, 118, 117, 115, 113, 109, 105, 98, 89, 80, 67, 52, 37,
19, 2, -15, -32, -48, -63, -76, -87, -97, -104, -109, -113, -116, -117, -118,
-119, -118, -118, -119, -119, -119, -118, -117, -115, -113, -110, -105, -100,
-93, -85, -77, -67, -58, -48, -38, -29, -19, -12, -5, 0, 3, 5, 7, 6, 4, -1, -6,
-13, -21, -31, -41, -53, -65, -78, -90, -99, -108, -114, -118, -119, -118, -115,
-108, -101, -93, -83, -74, -65, -56, -48, -42, -37, -33, -30, -30, -30, -31,
-34, -39, -44, -51, -59, -66, -74, -82, -90, -97, -103, -108, -112, -115, -118,
-118, -120, -119, -118, -118, -116, -117, -117, -116, -117, -118, -118, -119,
-118, -119, -116, -113, -106, -100, -91, -80, -67, -52, -36, -20, -3, 13, 28,
43, 55, 67, 76, 85, 92, 96, 101, 103, 105, 107, 106, 106, 105, 104, 102, 98, 93,
88, 81, 73, 64, 56, 45, 35, 25, 14, 3, -7, -16, -23, -30, -36, -39, -44, -45,
-45, -44, -42, -37, -32, -25, -16, -6, 6, 17, 30, 45, 58, 72, 84, 96, 104, 111,
116, 119, 119, 117, 113, 108, 102, 95, 89, 83, 78, 73, 71, 69, 68, 69, 71, 75,
79, 84, 89, 95, 100, 106, 111, 115, 117, 118, 119, 118, 117, 115, 112, 108, 105,
104, 100, 99, 98, 98, 99, 100, 103, 105, 109, 112, 116, 118, 118, 118, 116, 112,
105, 96, 84, 70, 55, 39, 23, 6, -8, -22, -36, -48, -57, -66, -72, -78, -82, -85,
-85, -86, -85, -83, -80, -75, -71, -63, -55, -47, -36, -25, -14, -3, 9, 20, 30,
41, 50, 59, 66, 71, 77, 79, 81, 83, 82, 81, 79, 75, 70, 63, 54, 44, 31, 19, 6,
-10, -26, -42, -59, -73, -87, -98, -107, -113, -117, -120, -119, -117, -115,
-111, -108, -104, -101, -98, -96, -95, -96, -96, -98, -101, -104, -106, -110,
-114, -116, -118, -119, -119, -118, -116, -112, -108, -103, -99, -93, -88, -83,
-79, -76, -74, -74, -72, -75, -77, -81, -87, -92, -97, -104, -109, -114, -118,
-119, -118, -116, -111, -103, -94, -81, -69, -55, -41, -27, -14, 0, 10, 21, 29,
36, 42, 46, 49, 49, 50, 48, 45, 40, 35, 28, 20, 12, 2, -9, -19, -30, -40, -50,
-60, -70, -77, -84, -89, -94, -98, -101, -103, -104, -105, -104, -102, -101,
-98, -94, -89, -83, -75, -63, -53, -39, -25, -9, };