#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0078

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 3, 4, 6, 7, 10, 12, 14, 16, 19,
21, 24, 26, 29, 32, 34, 37, 41, 44, 47, 50, 53, 56, 60, 62, 67, 70, 73, 75, 78,
81, 85, 88, 91, 93, 96, 99, 101, 103, 105, 108, 109, 111, 112, 114, 115, 116,
117, 118, 119, 119, 119, 119, 119, 118, 118, 117, 117, 115, 114, 113, 112, 110,
108, 106, 104, 103, 101, 98, 96, 93, 92, 89, 87, 85, 82, 81, 77, 75, 74, 72, 69,
66, 65, 63, 61, 60, 58, 56, 54, 53, 51, 50, 49, 47, 47, 45, 45, 43, 43, 42, 42,
40, 41, 40, 39, 39, 39, 39, 38, 38, 38, 37, 37, 37, 39, 37, 38, 39, 39, 40, 39,
40, 40, 40, 40, 40, 42, 42, 42, 42, 43, 43, 43, 43, 44, 45, 44, 44, 44, 44, 45,
44, 45, 44, 43, 44, 43, 43, 43, 42, 41, 41, 40, 40, 39, 37, 37, 36, 34, 33, 32,
31, 29, 27, 26, 24, 22, 20, 18, 16, 14, 11, 9, 6, 4, 1, -2, -5, -8, -10, -14,
-16, -20, -23, -26, -29, -32, -36, -39, -42, -45, -49, -51, -55, -58, -60, -63,
-66, -68, -71, -74, -76, -78, -80, -81, -81, -83, -85, -86, -87, -88, -88, -87,
-87, -88, -87, -86, -86, -85, -84, -83, -82, -81, -80, -77, -76, -75, -73, -71,
-70, -67, -65, -62, -60, -59, -56, -55, -53, -51, -48, -46, -44, -43, -40, -38,
-37, -36, -34, -33, -31, -30, -29, -28, -26, -26, -25, -25, -23, -23, -23, -22,
-21, -21, -21, -22, -22, -22, -22, -23, -24, -24, -25, -25, -26, -28, -28, -29,
-31, -31, -33, -34, -35, -38, -39, -40, -41, -43, -44, -46, -48, -51, -51, -53,
-55, -58, -59, -61, -62, -64, -66, -68, -70, -72, -73, -75, -77, -78, -80, -82,
-83, -85, -86, -88, -89, -90, -92, -93, -94, -95, -95, -97, -99, -99, -99, -101,
-101, -103, -103, -104, -104, -104, -105, -106, -106, -106, -106, -106, -106,
-107, -107, -106, -106, -106, -105, -105, -106, -105, -104, -104, -103, -102,
-102, -101, -100, -98, -97, -97, -95, -94, -93, -91, -89, -89, -88, -85, -83,
-81, -79, -77, -74, -73, -70, -67, -66, -63, -61, -58, -55, -53, -50, -48, -45,
-42, -40, -37, -34, -30, -29, -26, -22, -20, -17, -15, -12, -10, -7, -4, -2, 0,
3, 4, 7, 9, 12, 13, 16, 17, 19, 20, 22, 24, 25, 26, 28, 29, 31, 31, 33, 34, 34,
36, 36, 37, 38, 38, 39, 39, 39, 39, 41, 40, 40, 41, 41, 40, 40, 40, 40, 40, 40,
39, 39, 39, 38, 38, 37, 36, 35, 34, 33, 32, 32, 30, 30, 29, 27, 26, 25, 23, 22,
21, 20, 18, 17, 16, 15, 14, 12, 11, 9, 7, 7, 5, 4, 2, 2, 1, -1, -2, -3, -4, -5,
-6, -7, -8, -9, -9, -10, -10, -11, -11, -11, -11, -12, -12, -11, -12, -11, -11,
-10, -10, -9, -9, -8, -6, -6, -5, -4, -2, -1, };