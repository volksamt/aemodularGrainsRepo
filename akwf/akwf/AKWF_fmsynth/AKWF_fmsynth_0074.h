#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0074

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 15, 28, 41, 53, 65, 76, 85, 94,
102, 108, 112, 116, 117, 119, 119, 118, 116, 114, 111, 109, 105, 102, 99, 96,
94, 91, 89, 88, 88, 87, 86, 87, 88, 89, 90, 92, 94, 96, 98, 100, 102, 104, 105,
107, 108, 108, 109, 108, 109, 108, 107, 107, 106, 105, 103, 102, 101, 100, 100,
98, 97, 97, 95, 95, 94, 93, 93, 92, 91, 90, 89, 88, 85, 82, 79, 75, 70, 65, 58,
51, 42, 32, 23, 12, 1, -11, -23, -34, -45, -55, -65, -74, -80, -88, -94, -98,
-103, -106, -110, -111, -114, -116, -117, -117, -118, -118, -118, -118, -118,
-118, -116, -115, -115, -113, -111, -109, -106, -101, -97, -92, -85, -79, -71,
-62, -54, -44, -34, -24, -12, -2, 7, 18, 26, 34, 42, 48, 54, 60, 63, 67, 71, 75,
77, 78, 80, 82, 84, 84, 85, 84, 85, 83, 82, 81, 79, 76, 71, 66, 60, 52, 44, 34,
23, 11, -1, -14, -25, -37, -47, -55, -64, -68, -72, -74, -75, -73, -70, -66,
-60, -53, -45, -37, -29, -20, -10, -2, 6, 14, 21, 28, 35, 40, 45, 49, 52, 55,
57, 58, 60, 59, 60, 59, 58, 55, 54, 51, 48, 44, 40, 36, 31, 26, 21, 16, 11, 6,
1, -5, -10, -15, -19, -25, -29, -31, -36, -38, -42, -44, -46, -48, -49, -50,
-51, -50, -51, -49, -48, -46, -43, -41, -37, -33, -28, -23, -18, -12, -5, 2, 8,
16, 23, 30, 37, 43, 50, 55, 60, 63, 67, 70, 71, 73, 73, 73, 72, 70, 68, 66, 64,
61, 59, 57, 54, 52, 52, 50, 49, 49, 50, 50, 51, 53, 55, 57, 59, 62, 64, 66, 68,
70, 71, 72, 72, 71, 71, 69, 67, 64, 61, 56, 51, 46, 41, 36, 31, 25, 20, 16, 10,
6, 4, 0, -2, -4, -6, -6, -6, -6, -4, -2, 1, 4, 9, 14, 19, 25, 32, 39, 48, 55,
64, 71, 80, 87, 94, 99, 105, 108, 110, 110, 109, 106, 101, 95, 86, 76, 64, 51,
39, 24, 11, -1, -13, -23, -32, -40, -46, -52, -57, -59, -62, -65, -66, -67, -67,
-68, -69, -69, -69, -70, -70, -70, -69, -70, -70, -71, -71, -71, -70, -70, -70,
-69, -68, -67, -65, -63, -62, -59, -56, -54, -52, -49, -47, -44, -42, -40, -39,
-37, -36, -36, -37, -36, -38, -40, -42, -44, -49, -52, -56, -61, -66, -71, -76,
-82, -86, -91, -95, -100, -103, -105, -107, -108, -109, -108, -106, -104, -101,
-97, -92, -87, -80, -74, -69, -62, -55, -49, -44, -37, -32, -27, -23, -18, -16,
-12, -10, -8, -7, -7, -8, -8, -9, -11, -13, -17, -20, -24, -29, -33, -39, -44,
-49, -55, -62, -68, -74, -79, -85, -91, -95, -99, -102, -105, -106, -108, -109,
-109, -109, -107, -106, -104, -102, -99, -97, -95, -93, -92, -90, -88, -88, -87,
-86, -86, -87, -88, -88, -88, -89, -88, -87, -87, -86, -83, -79, -74, -67, -62,
-53, -43, -32, -21, -9, };