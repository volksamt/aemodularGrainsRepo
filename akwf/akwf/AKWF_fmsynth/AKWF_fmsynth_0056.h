#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0056

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 24, 43, 60, 76, 88, 100, 108, 114,
117, 119, 119, 116, 114, 111, 105, 100, 94, 89, 84, 80, 74, 70, 66, 63, 62, 60,
59, 60, 59, 62, 63, 66, 70, 75, 79, 84, 89, 95, 100, 104, 109, 114, 118, 119,
119, 118, 115, 108, 102, 92, 79, 64, 49, 30, 10, -12, -33, -52, -71, -89, -103,
-113, -119, -119, -113, -100, -83, -60, -34, -4, 24, 53, 78, 99, 112, 118, 116,
107, 89, 67, 39, 9, -21, -52, -79, -99, -113, -119, -115, -103, -83, -55, -24,
8, 41, 71, 94, 111, 119, 118, 109, 92, 69, 44, 16, -13, -42, -68, -89, -105,
-115, -119, -116, -107, -92, -74, -51, -26, -3, 21, 45, 65, 84, 98, 108, 115,
119, 119, 115, 110, 103, 95, 84, 74, 62, 51, 40, 29, 18, 9, 0, -9, -16, -24,
-28, -34, -38, -42, -44, -46, -48, -48, -47, -45, -44, -41, -38, -34, -29, -23,
-15, -7, 1, 11, 21, 31, 42, 54, 65, 77, 88, 97, 107, 113, 116, 119, 117, 112,
105, 91, 76, 56, 33, 9, -17, -41, -65, -87, -103, -114, -120, -118, -107, -92,
-69, -43, -14, 17, 46, 73, 96, 111, 119, 117, 105, 84, 55, 22, -13, -47, -78,
-102, -116, -118, -112, -95, -70, -40, -6, 29, 61, 88, 108, 117, 118, 108, 88,
59, 27, -7, -41, -71, -96, -112, -118, -117, -106, -89, -66, -39, -10, 19, 46,
71, 91, 107, 116, 119, 116, 108, 96, 77, 57, 35, 13, -8, -29, -49, -67, -83,
-95, -105, -112, -117, -119, -119, -118, -115, -111, -106, -101, -97, -91, -85,
-80, -75, -70, -66, -64, -61, -59, -57, -56, -56, -58, -59, -62, -65, -68, -71,
-77, -82, -88, -93, -98, -104, -108, -112, -116, -118, -119, -119, -115, -111,
-102, -92, -79, -64, -44, -25, -6, 11, 32, 54, 75, 92, 105, 115, 119, 117, 110,
98, 79, 58, 33, 6, -22, -50, -74, -94, -110, -118, -119, -110, -94, -71, -41,
-10, 22, 53, 81, 102, 115, 119, 114, 101, 81, 53, 23, -8, -39, -67, -90, -108,
-118, -118, -111, -95, -73, -46, -17, 14, 43, 70, 92, 107, 117, 119, 115, 104,
90, 71, 49, 26, 3, -21, -42, -63, -80, -95, -105, -114, -117, -119, -117, -113,
-107, -98, -88, -76, -65, -53, -42, -29, -19, -8, 0, 8, 17, 24, 30, 35, 39, 43,
46, 48, 50, 49, 49, 48, 46, 43, 40, 35, 28, 23, 15, 8, -1, -11, -21, -32, -44,
-56, -68, -80, -91, -101, -108, -115, -118, -119, -117, -112, -102, -88, -72,
-53, -32, -8, 15, 39, 63, 83, 100, 113, 118, 118, 109, 95, 72, 45, 15, -17, -47,
-76, -99, -114, -118, -114, -102, -81, -54, -23, 12, 44, 74, 98, 113, 120, 114,
99, 73, 42, 7, -29, -63, -90, -109, -118, -116, -106, -85, -58, -27, 6, 39, 67,
92, 109, 117, 118, 108, 93, 70, 40, 11, -18, -48, -73, -94, -109, -117, -119,
-115, -106, -92, -75, -55, -36, -13, };