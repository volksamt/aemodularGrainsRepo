#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 14, 20, 26, 31, 37, 43, 49, 53,
58, 62, 68, 73, 77, 82, 86, 89, 92, 97, 99, 103, 105, 107, 110, 112, 113, 115,
116, 117, 117, 118, 118, 119, 119, 119, 119, 119, 118, 116, 115, 115, 114, 111,
110, 108, 107, 105, 103, 102, 99, 97, 95, 93, 91, 89, 86, 83, 82, 80, 77, 74,
73, 70, 68, 65, 64, 61, 59, 56, 54, 52, 50, 47, 45, 43, 41, 40, 38, 37, 34, 32,
30, 29, 27, 25, 25, 23, 23, 21, 19, 18, 17, 17, 15, 14, 13, 13, 12, 12, 11, 10,
11, 9, 10, 9, 9, 10, 10, 9, 10, 10, 10, 11, 12, 12, 12, 14, 14, 16, 16, 18, 19,
21, 21, 22, 24, 26, 28, 30, 31, 33, 35, 38, 39, 41, 43, 46, 48, 50, 53, 55, 58,
62, 64, 67, 69, 72, 75, 78, 80, 84, 86, 89, 92, 95, 96, 99, 102, 105, 107, 108,
110, 113, 115, 115, 116, 117, 118, 118, 118, 119, 117, 116, 115, 112, 110, 108,
105, 101, 97, 92, 88, 83, 75, 70, 62, 56, 48, 40, 32, 24, 15, 6, -1, -10, -18,
-28, -37, -46, -54, -63, -71, -78, -85, -92, -98, -103, -107, -111, -113, -115,
-116, -117, -116, -114, -112, -106, -102, -97, -91, -82, -75, -66, -57, -48,
-37, -26, -16, -5, 6, 18, 29, 40, 51, 60, 70, 80, 88, 95, 101, 107, 112, 115,
117, 118, 117, 115, 113, 109, 103, 96, 89, 80, 70, 61, 49, 37, 25, 13, 1, -11,
-23, -34, -46, -57, -68, -77, -86, -94, -101, -106, -111, -114, -116, -116,
-116, -115, -112, -108, -104, -98, -90, -84, -75, -66, -57, -48, -38, -26, -17,
-6, 4, 16, 25, 34, 45, 55, 63, 71, 80, 86, 92, 99, 104, 107, 111, 114, 116, 118,
118, 117, 117, 115, 112, 109, 104, 101, 95, 89, 84, 77, 71, 64, 57, 48, 41, 33,
25, 17, 10, 3, -6, -12, -21, -27, -34, -42, -48, -55, -61, -67, -73, -77, -82,
-87, -91, -95, -99, -102, -104, -107, -110, -111, -113, -114, -115, -115, -117,
-116, -116, -117, -116, -116, -115, -114, -112, -111, -109, -108, -107, -105,
-102, -101, -99, -97, -95, -92, -90, -87, -86, -84, -81, -79, -77, -73, -72,
-69, -67, -65, -63, -61, -59, -57, -55, -54, -51, -48, -47, -46, -45, -43, -41,
-39, -38, -37, -35, -35, -34, -33, -32, -30, -30, -30, -29, -28, -28, -27, -27,
-28, -27, -27, -27, -27, -26, -27, -28, -29, -28, -29, -30, -31, -32, -33, -34,
-34, -36, -37, -38, -39, -42, -43, -45, -46, -48, -51, -52, -54, -56, -58, -60,
-62, -65, -67, -69, -72, -73, -76, -78, -80, -82, -85, -87, -90, -91, -94, -97,
-98, -101, -102, -104, -106, -108, -109, -110, -112, -113, -114, -114, -116,
-115, -116, -116, -116, -114, -114, -112, -111, -110, -108, -106, -103, -101,
-98, -95, -91, -88, -84, -80, -75, -70, -64, -59, -54, -48, -42, -37, -30, -24,
-18, -13, -6, };