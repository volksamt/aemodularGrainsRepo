#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0045

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 12, 19, 26, 32, 39, 45, 51, 56, 61,
66, 71, 75, 79, 83, 85, 89, 91, 94, 95, 98, 99, 100, 101, 102, 102, 103, 104,
104, 104, 103, 103, 103, 102, 102, 100, 98, 97, 95, 93, 90, 88, 85, 81, 77, 74,
69, 63, 58, 53, 46, 39, 31, 25, 17, 8, 0, -8, -16, -25, -34, -44, -52, -60, -69,
-77, -84, -93, -98, -104, -108, -112, -116, -118, -119, -119, -119, -117, -114,
-111, -106, -101, -95, -88, -81, -73, -65, -57, -49, -39, -31, -22, -13, -4, 4,
12, 20, 28, 36, 43, 48, 55, 61, 66, 71, 75, 80, 83, 87, 90, 93, 95, 97, 99, 101,
102, 104, 105, 105, 107, 107, 107, 107, 107, 107, 107, 106, 106, 104, 103, 102,
101, 100, 99, 97, 94, 91, 88, 86, 82, 79, 75, 70, 66, 61, 56, 50, 44, 39, 32,
26, 19, 12, 5, -2, -9, -17, -24, -31, -38, -46, -52, -59, -66, -72, -77, -82,
-88, -93, -98, -102, -106, -108, -110, -113, -115, -116, -118, -119, -119, -120,
-119, -118, -118, -117, -116, -116, -114, -114, -112, -111, -111, -109, -108,
-108, -107, -105, -106, -106, -105, -106, -105, -105, -106, -108, -107, -108,
-110, -111, -111, -113, -114, -116, -116, -117, -118, -119, -120, -119, -118,
-119, -118, -115, -114, -112, -108, -105, -101, -96, -92, -84, -78, -71, -63,
-56, -47, -38, -29, -20, -8, 6, 18, 27, 37, 47, 56, 65, 73, 81, 89, 96, 101,
106, 111, 114, 117, 118, 119, 119, 118, 116, 115, 111, 107, 103, 100, 94, 88,
82, 77, 71, 65, 59, 52, 47, 41, 35, 31, 25, 20, 16, 12, 8, 5, 2, -2, -3, -5, -8,
-8, -10, -10, -11, -11, -11, -11, -10, -8, -6, -5, -3, 0, 3, 6, 9, 12, 17, 20,
25, 29, 35, 40, 45, 50, 56, 61, 67, 72, 78, 83, 88, 92, 97, 101, 104, 108, 110,
113, 115, 118, 118, 120, 119, 118, 117, 116, 114, 112, 108, 106, 103, 98, 94,
90, 85, 81, 76, 71, 67, 62, 56, 52, 46, 43, 38, 34, 30, 25, 23, 19, 16, 13, 11,
8, 6, 4, 3, 3, 2, 2, 1, 2, 2, 3, 5, 6, 8, 10, 13, 15, 20, 22, 27, 31, 35, 40,
44, 50, 55, 61, 65, 72, 76, 81, 87, 92, 96, 101, 105, 109, 113, 115, 117, 118,
119, 119, 117, 117, 114, 110, 106, 99, 93, 85, 78, 69, 60, 50, 40, 29, 19, 9,
-1, -12, -23, -32, -42, -52, -61, -70, -77, -86, -91, -97, -102, -107, -109,
-113, -115, -117, -119, -120, -119, -120, -119, -117, -117, -114, -114, -112,
-111, -108, -106, -105, -103, -101, -101, -99, -99, -96, -96, -96, -95, -96,
-96, -95, -96, -96, -97, -98, -99, -100, -102, -103, -105, -106, -108, -109,
-112, -112, -114, -116, -117, -117, -118, -118, -119, -119, -118, -118, -116,
-115, -112, -111, -107, -103, -100, -94, -89, -84, -78, -73, -65, -59, -51, -45,
-36, -29, -22, -15, -7, 0, };