#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 15, 24, 33, 42, 50, 59, 66, 73, 79,
84, 90, 94, 98, 101, 103, 106, 107, 108, 109, 110, 110, 110, 110, 110, 110, 110,
110, 110, 111, 109, 110, 110, 110, 109, 108, 108, 106, 104, 102, 98, 94, 89, 82,
75, 66, 54, 44, 31, 18, 4, -12, -26, -41, -57, -71, -86, -96, -105, -113, -117,
-119, -117, -113, -104, -95, -83, -69, -54, -36, -19, -1, 16, 33, 48, 63, 76,
86, 95, 102, 106, 109, 110, 108, 105, 102, 95, 89, 81, 74, 66, 58, 49, 42, 35,
28, 22, 16, 12, 8, 4, 1, -1, -2, -4, -4, -3, -2, 1, 2, 5, 8, 13, 17, 22, 28, 32,
38, 44, 51, 59, 66, 71, 77, 83, 89, 93, 98, 102, 105, 107, 108, 110, 109, 109,
109, 106, 105, 101, 97, 94, 91, 87, 84, 80, 75, 73, 70, 67, 63, 61, 60, 58, 57,
57, 57, 59, 60, 61, 63, 66, 70, 72, 77, 80, 85, 89, 94, 98, 102, 104, 107, 109,
110, 108, 107, 102, 97, 89, 79, 69, 56, 41, 26, 9, -7, -23, -40, -57, -72, -85,
-97, -107, -114, -117, -118, -117, -115, -108, -100, -90, -78, -66, -52, -39,
-25, -10, 3, 17, 28, 40, 51, 60, 68, 76, 82, 88, 93, 96, 99, 102, 103, 105, 107,
107, 107, 108, 108, 109, 109, 108, 108, 108, 108, 106, 106, 105, 104, 103, 101,
98, 95, 92, 89, 84, 79, 73, 65, 58, 50, 43, 34, 25, 14, 6, -4, -14, -25, -33,
-43, -51, -60, -69, -76, -82, -87, -95, -98, -103, -106, -109, -112, -114, -115,
-116, -118, -119, -119, -118, -120, -119, -119, -119, -119, -119, -118, -118,
-118, -118, -115, -115, -112, -109, -107, -104, -98, -92, -87, -79, -70, -60,
-50, -38, -23, -11, -7, -2, 10, 24, 37, 48, 62, 74, 84, 92, 100, 105, 108, 109,
107, 102, 93, 84, 71, 55, 39, 22, 4, -14, -31, -48, -65, -80, -91, -102, -109,
-115, -117, -119, -118, -115, -111, -105, -99, -90, -83, -74, -66, -57, -49,
-41, -33, -26, -20, -14, -9, -5, -1, 3, 4, 7, 8, 8, 8, 7, 6, 5, 1, -2, -6, -9,
-14, -19, -26, -32, -37, -45, -52, -59, -65, -73, -79, -86, -93, -98, -104,
-108, -111, -115, -117, -118, -119, -119, -118, -115, -112, -109, -105, -100,
-95, -91, -85, -79, -74, -69, -63, -59, -55, -49, -46, -44, -41, -39, -38, -38,
-37, -38, -40, -42, -45, -48, -51, -55, -60, -66, -72, -77, -84, -90, -96, -102,
-107, -111, -115, -117, -119, -118, -115, -112, -107, -99, -90, -79, -67, -53,
-39, -22, -6, 10, 27, 43, 58, 71, 83, 93, 100, 106, 109, 110, 107, 103, 97, 89,
79, 67, 55, 42, 28, 16, 4, -9, -20, -31, -43, -51, -61, -68, -74, -80, -85, -90,
-94, -97, -99, -100, -103, -105, -105, -105, -105, -105, -104, -104, -103, -102,
-99, -97, -94, -90, -87, -83, -78, -73, -67, -61, -52, -46, -37, -29, -21, -11,
-2, };