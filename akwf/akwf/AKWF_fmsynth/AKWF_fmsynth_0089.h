#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0089

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 7, 7, 9, 11, 13, 15, 16, 16,
18, 19, 19, 20, 20, 20, 21, 22, 22, 23, 22, 23, 23, 23, 24, 24, 24, 25, 25, 26,
28, 27, 29, 30, 32, 33, 35, 36, 39, 40, 41, 43, 46, 48, 50, 52, 53, 55, 58, 59,
61, 62, 63, 65, 67, 67, 69, 69, 71, 71, 72, 73, 73, 73, 73, 73, 74, 75, 74, 75,
75, 75, 75, 75, 77, 76, 77, 77, 78, 79, 80, 80, 82, 83, 85, 85, 87, 88, 90, 91,
93, 94, 95, 96, 98, 99, 100, 102, 103, 103, 105, 106, 106, 106, 107, 107, 109,
109, 109, 109, 110, 110, 110, 110, 109, 110, 111, 110, 110, 111, 110, 111, 111,
111, 112, 112, 112, 112, 113, 113, 114, 114, 115, 116, 116, 116, 117, 117, 118,
119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 118, 118, 118, 117,
118, 118, 118, 117, 117, 117, 117, 117, 118, 117, 117, 117, 118, 118, 117, 117,
116, 116, 117, 116, 115, 116, 115, 115, 114, 114, 113, 112, 110, 110, 109, 108,
107, 104, 103, 101, 100, 98, 98, 95, 95, 92, 91, 90, 88, 87, 85, 85, 84, 84, 82,
82, 81, 81, 81, 81, 80, 80, 79, 80, 80, 78, 78, 78, 76, 76, 75, 75, 73, 71, 69,
68, 65, 64, 61, 59, 56, 52, 49, 46, 42, 38, 35, 31, 27, 23, 20, 15, 11, 8, 4, 1,
-2, -4, -6, -9, -11, -12, -13, -14, -15, -16, -17, -17, -17, -19, -18, -20, -20,
-20, -21, -22, -23, -24, -26, -28, -30, -32, -34, -36, -39, -41, -45, -48, -51,
-54, -58, -61, -63, -67, -70, -72, -74, -76, -79, -81, -84, -85, -87, -88, -90,
-91, -92, -93, -94, -93, -95, -95, -96, -96, -96, -96, -97, -96, -98, -96, -97,
-98, -98, -99, -98, -99, -101, -101, -101, -102, -104, -104, -105, -107, -108,
-109, -110, -110, -111, -112, -113, -114, -114, -115, -115, -117, -117, -117,
-118, -118, -118, -118, -118, -118, -119, -119, -118, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -120, -119,
-119, -119, -119, -118, -118, -118, -118, -119, -118, -117, -117, -116, -116,
-116, -114, -114, -113, -113, -111, -112, -111, -110, -109, -109, -107, -107,
-106, -105, -105, -105, -105, -103, -103, -103, -103, -102, -103, -102, -102,
-102, -102, -102, -102, -102, -101, -101, -100, -100, -100, -98, -98, -98, -96,
-96, -94, -94, -93, -91, -90, -89, -87, -86, -84, -82, -81, -79, -78, -77, -74,
-73, -71, -70, -69, -68, -67, -65, -65, -64, -63, -63, -62, -62, -61, -61, -61,
-61, -61, -60, -59, -59, -59, -59, -58, -58, -58, -58, -56, -55, -55, -53, -53,
-51, -49, -48, -45, -45, -42, -40, -39, -37, -34, -32, -30, -28, -27, -25, -22,
-20, -19, -17, -15, -15, -14, -11, -10, -9, -9, -8, -8, -8, -7, -7, -7, -5, -6,
-6, -5, -4, -5, -4, -5, -3, -3, -2, -1, 0, };