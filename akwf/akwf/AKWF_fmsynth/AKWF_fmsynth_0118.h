#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0118

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 20, 33, 47, 60, 73, 84, 93, 101,
107, 110, 115, 117, 118, 119, 119, 118, 118, 118, 119, 119, 118, 118, 115, 114,
110, 106, 102, 96, 91, 86, 80, 75, 69, 66, 63, 62, 62, 62, 65, 68, 73, 79, 85,
92, 98, 105, 110, 115, 117, 118, 117, 114, 109, 102, 95, 87, 79, 72, 65, 58, 54,
51, 49, 49, 50, 54, 58, 63, 68, 74, 80, 87, 94, 99, 104, 107, 110, 113, 115,
115, 116, 116, 116, 116, 116, 116, 115, 113, 110, 107, 102, 95, 87, 77, 65, 51,
37, 22, 6, -7, -20, -33, -44, -54, -62, -68, -73, -77, -79, -80, -80, -78, -76,
-71, -65, -58, -51, -44, -34, -25, -16, -6, 2, 9, 17, 23, 28, 31, 33, 33, 32,
30, 25, 19, 12, 3, -8, -18, -31, -44, -58, -71, -84, -93, -102, -110, -114,
-117, -118, -119, -118, -118, -117, -114, -114, -114, -112, -113, -114, -115,
-116, -117, -119, -119, -117, -117, -116, -113, -110, -106, -102, -98, -95, -92,
-90, -90, -90, -91, -93, -96, -100, -104, -108, -112, -115, -118, -118, -117,
-112, -107, -101, -92, -83, -74, -64, -53, -45, -35, -29, -23, -20, -16, -15,
-16, -18, -22, -26, -32, -39, -45, -54, -61, -69, -76, -83, -89, -93, -97, -100,
-103, -104, -104, -105, -105, -103, -102, -99, -94, -89, -83, -74, -64, -52,
-40, -26, -12, 3, 17, 32, 45, 56, 66, 75, 82, 88, 93, 96, 98, 99, 99, 98, 97,
94, 90, 86, 81, 75, 67, 60, 52, 44, 35, 27, 20, 14, 8, 5, 0, 0, 0, 1, 5, 9, 15,
24, 33, 43, 54, 65, 76, 86, 96, 104, 110, 115, 118, 118, 118, 116, 114, 111,
109, 106, 104, 102, 101, 101, 102, 104, 107, 108, 112, 114, 116, 117, 117, 118,
117, 115, 115, 111, 109, 107, 106, 105, 105, 105, 106, 108, 110, 112, 114, 116,
117, 117, 115, 112, 106, 98, 89, 78, 66, 54, 41, 30, 18, 9, 1, -7, -12, -15,
-17, -18, -17, -14, -10, -5, 2, 10, 18, 27, 35, 45, 54, 62, 69, 74, 81, 85, 88,
89, 91, 89, 89, 86, 83, 78, 72, 64, 54, 43, 30, 16, 2, -13, -28, -43, -57, -69,
-81, -89, -97, -102, -108, -111, -113, -114, -115, -116, -115, -114, -113, -112,
-110, -107, -103, -99, -92, -86, -79, -72, -64, -57, -51, -45, -38, -35, -33,
-32, -33, -36, -39, -46, -52, -60, -69, -79, -87, -97, -105, -111, -116, -118,
-118, -117, -114, -110, -105, -100, -93, -88, -84, -79, -77, -76, -76, -77, -78,
-81, -85, -89, -94, -98, -103, -107, -111, -113, -116, -116, -117, -117, -117,
-117, -117, -116, -116, -117, -116, -117, -117, -116, -115, -113, -110, -104,
-98, -89, -79, -68, -55, -41, -29, -15, -3, 9, 19, 29, 35, 41, 45, 48, 49, 49,
47, 44, 39, 34, 28, 20, 11, 3, -6, -15, -24, -33, -40, -46, -52, -57, -59, -62,
-62, -61, -59, -57, -52, -45, -37, -27, -17, -5, };