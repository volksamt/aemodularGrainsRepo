#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0032

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 17, 34, 49, 63, 76, 88, 98, 106,
112, 116, 118, 119, 118, 116, 112, 107, 101, 96, 90, 83, 76, 69, 62, 55, 50, 45,
40, 37, 34, 31, 29, 28, 28, 29, 29, 31, 35, 37, 42, 48, 53, 58, 66, 72, 79, 87,
94, 100, 106, 111, 115, 119, 119, 119, 115, 111, 103, 93, 81, 67, 52, 34, 15,
-4, -23, -42, -60, -76, -89, -100, -109, -115, -119, -120, -118, -112, -107,
-98, -88, -79, -67, -55, -44, -31, -20, -9, 3, 11, 20, 28, 36, 43, 49, 53, 58,
62, 64, 66, 67, 68, 68, 67, 66, 63, 61, 57, 54, 48, 42, 35, 28, 20, 11, 1, -9,
-19, -30, -42, -52, -63, -74, -84, -93, -102, -109, -114, -117, -119, -119,
-116, -112, -106, -97, -86, -76, -63, -48, -34, -19, -5, 9, 23, 35, 48, 60, 69,
78, 85, 92, 97, 101, 106, 109, 111, 114, 114, 116, 116, 116, 117, 117, 116, 117,
116, 116, 114, 113, 110, 108, 105, 101, 97, 90, 83, 74, 64, 54, 41, 28, 13, -2,
-17, -33, -50, -65, -78, -90, -102, -110, -115, -119, -119, -117, -111, -103,
-93, -80, -67, -51, -36, -17, 4, 24, 41, 54, 68, 80, 89, 99, 105, 111, 115, 117,
119, 120, 119, 117, 116, 113, 111, 108, 106, 104, 102, 101, 100, 99, 98, 99, 99,
101, 103, 105, 106, 109, 112, 114, 115, 117, 118, 119, 119, 118, 116, 112, 106,
100, 93, 84, 74, 63, 50, 37, 23, 8, -8, -21, -37, -51, -64, -76, -86, -97, -104,
-110, -115, -118, -119, -118, -117, -113, -109, -104, -98, -91, -85, -78, -71,
-65, -58, -52, -47, -42, -37, -34, -31, -31, -30, -30, -30, -33, -35, -38, -43,
-48, -52, -59, -67, -73, -80, -87, -94, -101, -108, -111, -116, -118, -119,
-119, -115, -111, -103, -95, -84, -71, -57, -41, -24, -7, 11, 28, 44, 61, 75,
89, 100, 108, 114, 117, 120, 117, 114, 108, 100, 90, 80, 67, 54, 42, 29, 17, 5,
-6, -16, -26, -35, -42, -49, -55, -60, -64, -68, -70, -72, -72, -73, -72, -71,
-70, -67, -64, -59, -56, -49, -43, -35, -28, -18, -9, 2, 14, 26, 38, 49, 62, 74,
84, 93, 102, 110, 115, 118, 119, 119, 115, 111, 105, 97, 87, 76, 65, 53, 39, 27,
12, -1, -14, -27, -38, -48, -58, -68, -76, -83, -90, -94, -98, -102, -105, -109,
-110, -112, -112, -113, -114, -114, -114, -115, -113, -113, -112, -111, -108,
-106, -102, -99, -94, -88, -82, -75, -66, -55, -45, -32, -21, -7, 8, 22, 36, 51,
66, 78, 91, 100, 109, 115, 119, 120, 117, 111, 104, 94, 81, 66, 49, 31, 12, -5,
-23, -40, -56, -70, -83, -92, -101, -108, -113, -117, -118, -119, -119, -118,
-115, -113, -110, -107, -105, -102, -100, -97, -95, -94, -94, -94, -95, -95,
-96, -97, -99, -102, -105, -107, -110, -112, -115, -117, -118, -120, -118, -118,
-115, -112, -106, -99, -91, -81, -69, -57, -41, -27, -11, };