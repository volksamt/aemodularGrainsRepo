#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0066

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 11, 21, 29, 36, 44, 51, 58, 65, 71,
77, 82, 87, 91, 95, 99, 102, 106, 109, 110, 113, 114, 116, 117, 118, 119, 120,
119, 120, 119, 118, 117, 117, 115, 114, 112, 111, 110, 108, 106, 104, 102, 101,
98, 95, 93, 91, 89, 87, 84, 82, 80, 78, 76, 73, 71, 68, 66, 64, 61, 60, 57, 55,
52, 51, 48, 47, 45, 43, 41, 39, 38, 35, 33, 31, 30, 28, 27, 24, 23, 22, 21, 19,
18, 16, 15, 14, 13, 11, 10, 9, 7, 7, 5, 4, 3, 2, 1, 0, -2, -2, -2, -4, -5, -6,
-7, -8, -8, -9, -9, -10, -12, -12, -12, -14, -14, -14, -15, -16, -16, -16, -17,
-18, -17, -18, -18, -18, -18, -18, -19, -19, -19, -19, -19, -19, -20, -19, -20,
-20, -18, -19, -19, -18, -18, -18, -17, -17, -16, -15, -15, -15, -15, -14, -13,
-12, -11, -10, -10, -9, -8, -7, -6, -5, -5, -3, -3, -1, 0, 1, 2, 3, 5, 6, 6, 9,
10, 12, 13, 15, 16, 18, 20, 21, 22, 26, 26, 29, 31, 33, 36, 38, 40, 42, 45, 48,
51, 54, 56, 59, 63, 66, 69, 72, 76, 78, 82, 86, 89, 93, 96, 99, 102, 106, 108,
111, 113, 115, 117, 118, 119, 120, 118, 117, 115, 112, 107, 101, 93, 85, 74, 61,
46, 29, 9, -13, -32, -50, -65, -77, -89, -98, -105, -110, -115, -117, -119,
-119, -119, -117, -115, -112, -108, -104, -100, -95, -91, -85, -80, -74, -70,
-65, -60, -54, -49, -44, -39, -35, -31, -26, -21, -18, -14, -9, -6, -2, 2, 7,
11, 15, 19, 23, 27, 32, 36, 41, 47, 52, 57, 63, 69, 74, 80, 86, 90, 96, 101,
106, 111, 114, 117, 118, 118, 118, 116, 112, 106, 98, 88, 76, 59, 38, 14, -12,
-35, -57, -73, -87, -98, -105, -112, -116, -118, -119, -118, -118, -115, -112,
-109, -104, -100, -95, -90, -85, -80, -73, -69, -64, -58, -53, -49, -44, -40,
-34, -31, -27, -23, -19, -16, -12, -8, -4, -1, 3, 5, 8, 12, 16, 20, 22, 26, 30,
33, 37, 40, 46, 49, 52, 57, 61, 65, 69, 73, 78, 81, 85, 89, 92, 97, 100, 104,
106, 109, 111, 113, 115, 117, 118, 119, 119, 119, 117, 117, 116, 113, 111, 107,
104, 99, 94, 89, 81, 75, 67, 60, 50, 41, 31, 21, 9, -3, -13, -23, -33, -42, -50,
-56, -62, -69, -74, -80, -83, -87, -91, -94, -97, -100, -103, -104, -105, -107,
-109, -111, -112, -113, -113, -115, -115, -116, -116, -117, -118, -118, -118,
-118, -118, -119, -119, -118, -118, -118, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -120, -120, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -118, -118, -118, -118, -118, -118, -118, -118, -117, -116, -116, -115,
-115, -113, -113, -111, -111, -109, -108, -106, -105, -103, -101, -98, -97, -94,
-91, -88, -85, -82, -78, -73, -68, -63, -57, -52, -45, -39, -32, -23, -16, -7,
};