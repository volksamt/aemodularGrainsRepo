#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0042

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 10, 17, 24, 31, 38, 44, 51, 57, 63,
69, 75, 80, 84, 89, 93, 96, 100, 103, 106, 108, 111, 113, 114, 116, 116, 118,
118, 119, 119, 119, 119, 119, 118, 119, 118, 119, 118, 117, 117, 117, 116, 117,
116, 116, 116, 116, 115, 115, 116, 116, 116, 116, 116, 116, 117, 118, 118, 118,
118, 119, 118, 118, 119, 119, 118, 118, 118, 117, 117, 116, 115, 114, 112, 111,
110, 107, 106, 103, 101, 99, 96, 93, 91, 87, 84, 80, 78, 73, 70, 67, 63, 60, 55,
53, 48, 45, 42, 39, 34, 30, 28, 24, 22, 19, 16, 14, 12, 8, 6, 4, 3, 1, 0, -1,
-3, -3, -3, -4, -4, -4, -4, -3, -3, -1, 0, 2, 3, 5, 6, 9, 12, 14, 17, 20, 24,
27, 31, 35, 39, 43, 47, 51, 55, 60, 65, 69, 73, 78, 82, 86, 90, 95, 99, 102,
105, 108, 111, 113, 115, 116, 117, 118, 117, 117, 117, 115, 114, 111, 108, 104,
101, 97, 92, 88, 82, 76, 71, 65, 58, 52, 45, 38, 32, 25, 19, 12, 6, 0, -5, -11,
-17, -22, -27, -33, -37, -43, -46, -51, -54, -59, -61, -64, -67, -70, -72, -74,
-76, -78, -79, -80, -82, -83, -83, -84, -84, -85, -85, -85, -85, -85, -84, -83,
-83, -81, -81, -79, -77, -76, -74, -71, -70, -68, -65, -62, -59, -56, -53, -50,
-46, -42, -38, -34, -30, -26, -22, -17, -13, -8, -4, 1, 6, 10, 15, 19, 24, 30,
33, 38, 43, 47, 50, 55, 59, 62, 66, 70, 73, 77, 79, 82, 84, 87, 89, 92, 94, 95,
96, 98, 99, 101, 101, 102, 102, 104, 104, 105, 105, 104, 105, 105, 105, 106,
105, 104, 103, 103, 102, 101, 100, 99, 97, 96, 95, 92, 90, 88, 85, 83, 79, 76,
71, 68, 64, 60, 55, 50, 45, 38, 32, 27, 20, 14, 8, 1, -6, -13, -19, -26, -34,
-41, -48, -55, -61, -68, -74, -80, -87, -91, -96, -99, -104, -107, -112, -113,
-115, -117, -119, -119, -118, -118, -118, -117, -116, -113, -111, -109, -106,
-104, -100, -97, -94, -90, -86, -83, -80, -76, -73, -68, -66, -62, -59, -55,
-52, -50, -47, -45, -42, -40, -38, -36, -36, -34, -33, -32, -30, -31, -30, -31,
-30, -31, -31, -32, -32, -35, -35, -37, -38, -41, -42, -44, -46, -49, -51, -54,
-56, -59, -62, -66, -69, -72, -74, -78, -81, -84, -87, -89, -92, -95, -98, -100,
-103, -104, -107, -109, -110, -112, -114, -114, -115, -116, -116, -117, -118,
-118, -118, -117, -117, -117, -117, -116, -115, -114, -113, -112, -111, -111,
-109, -108, -108, -107, -106, -105, -104, -104, -103, -102, -101, -102, -101,
-101, -101, -101, -102, -101, -102, -104, -104, -104, -106, -106, -108, -108,
-110, -110, -111, -112, -114, -114, -115, -116, -117, -117, -117, -117, -117,
-117, -116, -114, -115, -112, -111, -108, -106, -102, -99, -95, -91, -87, -82,
-77, -71, -65, -60, -53, -47, -40, -32, -26, -19, -11, -3, };