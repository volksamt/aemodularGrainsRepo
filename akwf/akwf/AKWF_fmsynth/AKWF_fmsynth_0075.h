#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0075

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 14, 18, 24, 28, 35, 41, 47,
53, 60, 66, 73, 79, 85, 91, 96, 101, 105, 109, 111, 114, 115, 115, 115, 114,
113, 110, 106, 102, 99, 93, 87, 83, 77, 71, 67, 61, 56, 52, 47, 43, 39, 35, 33,
30, 28, 26, 25, 24, 24, 24, 24, 25, 25, 27, 28, 30, 32, 34, 36, 38, 39, 42, 44,
46, 49, 51, 52, 54, 54, 56, 57, 57, 56, 57, 58, 56, 55, 54, 53, 51, 47, 45, 43,
38, 35, 30, 26, 20, 15, 9, 2, -6, -13, -20, -28, -36, -44, -52, -59, -67, -74,
-81, -86, -92, -98, -103, -107, -109, -112, -116, -117, -118, -119, -119, -119,
-119, -119, -118, -117, -117, -115, -114, -113, -113, -112, -113, -111, -111,
-111, -111, -111, -111, -111, -112, -113, -114, -114, -114, -115, -116, -115,
-116, -116, -115, -115, -115, -114, -113, -111, -111, -109, -107, -106, -103,
-103, -101, -98, -96, -95, -93, -92, -90, -90, -89, -88, -88, -87, -87, -87,
-87, -88, -88, -88, -89, -88, -88, -88, -87, -85, -83, -82, -79, -75, -71, -65,
-60, -55, -48, -41, -33, -25, -18, -9, -1, 8, 16, 24, 33, 40, 47, 55, 61, 67,
72, 78, 82, 86, 89, 93, 96, 98, 100, 102, 103, 103, 103, 105, 105, 105, 105,
104, 104, 102, 102, 101, 99, 97, 95, 93, 92, 89, 87, 85, 82, 79, 77, 74, 73, 68,
66, 65, 63, 61, 58, 57, 56, 55, 55, 54, 54, 53, 54, 55, 55, 56, 57, 59, 61, 62,
65, 67, 69, 72, 73, 75, 77, 79, 79, 80, 80, 80, 79, 78, 77, 75, 73, 69, 66, 62,
57, 52, 48, 42, 37, 31, 27, 22, 17, 12, 8, 4, 0, -3, -7, -8, -10, -11, -12, -12,
-12, -10, -9, -9, -6, -3, -1, 2, 6, 10, 13, 18, 22, 26, 30, 34, 38, 43, 47, 50,
54, 58, 61, 64, 66, 69, 71, 73, 75, 77, 80, 80, 82, 82, 83, 85, 85, 86, 86, 86,
86, 85, 84, 83, 81, 79, 76, 73, 69, 63, 58, 52, 46, 38, 31, 22, 13, 4, -5, -13,
-22, -29, -37, -43, -49, -55, -60, -63, -67, -68, -69, -70, -71, -71, -71, -70,
-68, -67, -66, -64, -63, -60, -59, -58, -56, -56, -55, -54, -54, -55, -54, -54,
-55, -56, -58, -58, -60, -61, -63, -64, -65, -67, -68, -70, -72, -73, -75, -77,
-77, -78, -80, -81, -83, -84, -85, -86, -86, -88, -89, -90, -90, -91, -92, -93,
-93, -94, -94, -93, -94, -93, -93, -92, -91, -90, -87, -85, -82, -78, -75, -71,
-66, -61, -56, -50, -44, -39, -33, -27, -21, -14, -9, -4, 2, 7, 12, 17, 22, 24,
28, 31, 34, 37, 39, 41, 42, 44, 45, 46, 47, 46, 47, 47, 46, 46, 45, 45, 43, 42,
40, 39, 36, 35, 32, 30, 28, 24, 21, 19, 15, 13, 10, 6, 4, 1, -1, -3, -6, -8, -9,
-10, -11, -11, -11, -10, -10, -9, -7, -5, -3, 0, };