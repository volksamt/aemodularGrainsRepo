#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0116

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 13, 19, 27, 34, 40, 47, 53, 59, 64,
71, 76, 80, 84, 88, 92, 95, 99, 101, 104, 105, 108, 109, 110, 113, 113, 114,
115, 115, 116, 116, 117, 117, 117, 117, 117, 116, 116, 117, 116, 116, 115, 114,
114, 114, 113, 112, 110, 109, 108, 106, 104, 102, 99, 97, 95, 92, 89, 86, 83,
79, 76, 72, 68, 64, 60, 56, 52, 49, 45, 40, 37, 34, 30, 26, 23, 19, 16, 13, 11,
8, 6, 5, 2, 2, 0, -1, -2, -2, -2, -2, -1, -1, 0, 2, 3, 5, 8, 10, 13, 16, 19, 23,
26, 30, 35, 39, 44, 49, 54, 59, 64, 68, 74, 79, 83, 88, 92, 97, 100, 105, 108,
110, 113, 116, 118, 118, 120, 118, 118, 118, 116, 114, 113, 111, 107, 103, 101,
96, 93, 88, 84, 79, 75, 71, 66, 62, 57, 54, 50, 47, 42, 40, 36, 33, 31, 29, 28,
26, 24, 24, 24, 23, 24, 23, 24, 24, 26, 27, 29, 31, 33, 35, 38, 40, 44, 46, 50,
53, 56, 60, 65, 68, 71, 75, 79, 82, 85, 89, 92, 95, 98, 100, 103, 105, 108, 109,
111, 112, 114, 114, 115, 116, 117, 117, 118, 118, 119, 118, 119, 119, 119, 119,
118, 119, 119, 118, 118, 118, 119, 118, 118, 118, 118, 118, 118, 118, 118, 117,
116, 117, 116, 114, 113, 112, 110, 109, 106, 103, 100, 96, 92, 88, 83, 78, 72,
67, 60, 54, 46, 40, 32, 24, 17, 9, 1, -6, -14, -21, -29, -35, -43, -49, -56,
-62, -69, -75, -79, -85, -88, -93, -95, -99, -102, -104, -107, -109, -111, -113,
-113, -114, -115, -116, -116, -117, -118, -117, -119, -118, -118, -118, -118,
-118, -118, -118, -117, -117, -117, -117, -116, -115, -115, -114, -112, -111,
-110, -108, -106, -105, -102, -100, -98, -95, -92, -89, -86, -82, -78, -75, -70,
-67, -62, -59, -55, -50, -47, -42, -38, -34, -29, -27, -23, -19, -16, -13, -11,
-8, -6, -4, -2, -1, 0, 0, 2, 3, 3, 2, 2, 1, 0, -2, -4, -5, -8, -10, -14, -16,
-19, -23, -28, -31, -36, -41, -45, -51, -56, -61, -67, -73, -77, -82, -86, -91,
-96, -101, -104, -108, -111, -113, -116, -117, -119, -119, -118, -118, -118,
-116, -115, -113, -109, -107, -104, -101, -96, -92, -89, -84, -80, -75, -72,
-67, -63, -59, -55, -51, -48, -45, -40, -38, -35, -33, -30, -28, -26, -25, -24,
-23, -23, -22, -23, -23, -23, -25, -25, -27, -28, -30, -32, -34, -37, -39, -42,
-46, -48, -52, -55, -59, -62, -66, -69, -72, -76, -80, -83, -86, -90, -92, -95,
-98, -100, -102, -105, -107, -109, -111, -112, -112, -113, -115, -116, -116,
-117, -117, -118, -118, -118, -118, -118, -118, -118, -118, -118, -119, -118,
-118, -118, -118, -119, -118, -118, -117, -117, -118, -117, -117, -115, -115,
-114, -113, -111, -109, -107, -105, -102, -99, -97, -93, -89, -84, -79, -74,
-69, -63, -57, -51, -45, -38, -30, -23, -16, -8, -1, };