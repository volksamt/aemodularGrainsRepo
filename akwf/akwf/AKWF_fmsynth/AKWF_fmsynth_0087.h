#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0087

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 4, 4, 6, 7, 9, 10, 12, 14,
14, 17, 18, 19, 21, 23, 26, 27, 29, 30, 33, 35, 37, 38, 40, 42, 44, 46, 48, 49,
52, 54, 55, 58, 59, 61, 63, 64, 67, 69, 71, 72, 74, 75, 76, 79, 80, 82, 83, 84,
85, 86, 87, 89, 90, 92, 92, 93, 94, 95, 97, 97, 98, 99, 99, 100, 100, 100, 102,
102, 103, 103, 103, 104, 104, 104, 106, 105, 106, 105, 106, 106, 106, 107, 107,
107, 107, 108, 107, 107, 107, 108, 108, 108, 109, 108, 108, 108, 108, 110, 110,
109, 110, 109, 110, 109, 111, 109, 109, 111, 110, 110, 110, 111, 111, 112, 111,
112, 112, 113, 113, 113, 113, 114, 114, 114, 114, 115, 116, 116, 116, 117, 116,
118, 117, 118, 118, 118, 118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 118, 118, 118, 118, 116, 116, 116, 115, 114, 113, 113, 111, 111, 110, 109,
108, 106, 105, 103, 102, 101, 99, 97, 96, 95, 93, 91, 89, 87, 85, 83, 82, 80,
78, 76, 74, 73, 71, 70, 67, 66, 65, 63, 61, 59, 57, 56, 55, 53, 52, 51, 50, 49,
48, 47, 46, 44, 44, 43, 42, 42, 40, 39, 40, 38, 38, 38, 38, 37, 35, 36, 36, 35,
34, 34, 34, 33, 33, 32, 32, 31, 31, 30, 30, 29, 28, 27, 27, 26, 25, 24, 23, 22,
20, 20, 18, 17, 15, 14, 11, 10, 8, 5, 4, 1, -1, -3, -7, -9, -12, -14, -17, -20,
-23, -26, -29, -32, -35, -38, -41, -44, -48, -50, -53, -55, -59, -61, -64, -67,
-70, -72, -74, -77, -79, -82, -84, -87, -88, -91, -92, -95, -96, -98, -100,
-101, -103, -104, -106, -106, -107, -109, -110, -111, -112, -113, -113, -115,
-114, -115, -116, -116, -116, -116, -117, -118, -118, -119, -118, -118, -118,
-119, -119, -119, -118, -119, -119, -118, -119, -119, -120, -119, -118, -118,
-119, -119, -119, -119, -119, -118, -119, -118, -118, -118, -119, -119, -119,
-118, -119, -118, -118, -118, -119, -118, -118, -118, -119, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -118, -117, -119, -118, -118, -117, -117,
-117, -117, -118, -116, -116, -117, -117, -116, -115, -116, -115, -115, -114,
-114, -113, -113, -112, -112, -111, -111, -110, -109, -109, -108, -108, -106,
-106, -105, -104, -102, -102, -101, -100, -98, -97, -95, -95, -93, -92, -89,
-89, -87, -86, -84, -83, -81, -80, -77, -76, -75, -73, -72, -70, -68, -67, -64,
-63, -61, -59, -58, -57, -55, -53, -52, -50, -49, -47, -45, -44, -42, -40, -39,
-39, -37, -36, -35, -34, -32, -32, -31, -30, -29, -27, -27, -26, -26, -25, -24,
-24, -24, -23, -22, -22, -21, -21, -21, -20, -20, -19, -19, -19, -19, -17, -18,
-18, -18, -17, -18, -17, -17, -17, -16, -16, -15, -15, -16, -15, -14, -14, -13,
-13, -13, -12, -11, -12, -10, -11, -9, -8, -8, -7, -6, -6, -4, -4, -3, -2, -1,
0, };