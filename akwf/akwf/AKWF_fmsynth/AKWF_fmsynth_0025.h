#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {15, 34, 48, 61, 71, 80, 88, 95, 101,
105, 109, 112, 114, 116, 117, 118, 119, 118, 119, 118, 117, 116, 116, 113, 111,
110, 108, 105, 104, 100, 97, 94, 91, 87, 84, 81, 77, 74, 70, 67, 63, 60, 57, 54,
51, 48, 45, 42, 41, 38, 35, 33, 32, 30, 29, 27, 25, 25, 23, 22, 22, 21, 20, 19,
18, 18, 17, 16, 16, 14, 14, 13, 12, 11, 11, 10, 9, 9, 8, 6, 6, 5, 4, 3, 3, 2, 1,
1, 0, 1, 1, 1, 1, 1, 1, 2, 4, 4, 5, 7, 7, 9, 11, 13, 15, 16, 19, 20, 24, 25, 28,
31, 34, 36, 37, 41, 42, 46, 48, 50, 53, 54, 57, 59, 63, 65, 66, 70, 71, 73, 76,
78, 81, 83, 86, 88, 91, 94, 97, 100, 102, 104, 107, 109, 111, 114, 116, 117,
118, 118, 118, 117, 115, 110, 106, 99, 91, 81, 69, 54, 38, 18, -4, -23, -41,
-57, -69, -81, -89, -97, -103, -107, -110, -113, -114, -115, -115, -114, -113,
-110, -107, -104, -101, -97, -92, -88, -83, -78, -72, -66, -60, -54, -48, -42,
-35, -28, -21, -14, -8, -1, 5, 13, 19, 27, 33, 40, 47, 54, 61, 67, 73, 80, 86,
91, 96, 102, 105, 109, 113, 115, 117, 118, 117, 116, 114, 109, 104, 97, 86, 75,
60, 41, 18, -7, -31, -51, -68, -83, -93, -102, -108, -112, -114, -115, -114,
-111, -108, -105, -99, -95, -88, -82, -76, -70, -63, -57, -50, -44, -38, -32,
-26, -21, -15, -10, -4, 1, 6, 10, 15, 20, 26, 30, 36, 40, 45, 49, 54, 59, 64,
69, 74, 79, 84, 88, 93, 97, 101, 105, 108, 112, 114, 117, 117, 118, 117, 116,
114, 110, 106, 102, 94, 87, 78, 68, 58, 45, 33, 21, 6, -7, -21, -31, -42, -50,
-58, -65, -70, -76, -82, -86, -89, -92, -97, -100, -103, -104, -107, -109, -110,
-112, -113, -114, -114, -116, -116, -115, -115, -114, -114, -113, -113, -111,
-111, -111, -108, -107, -106, -107, -105, -104, -103, -103, -102, -101, -101,
-100, -101, -101, -101, -101, -101, -101, -103, -103, -104, -103, -104, -104,
-105, -105, -106, -107, -107, -107, -108, -108, -108, -109, -109, -109, -110,
-110, -111, -111, -112, -112, -112, -112, -112, -112, -112, -113, -114, -114,
-115, -114, -114, -114, -113, -114, -113, -112, -111, -109, -107, -103, -100,
-97, -92, -87, -79, -72, -62, -53, -42, -30, -17, -3, 13, 27, 39, 50, 60, 68,
77, 85, 90, 96, 101, 104, 108, 111, 113, 116, 116, 119, 119, 119, 119, 118, 118,
116, 114, 112, 110, 108, 104, 101, 97, 93, 89, 84, 80, 74, 70, 64, 59, 54, 48,
43, 38, 32, 27, 23, 17, 12, 7, 2, -3, -7, -11, -16, -20, -25, -29, -34, -38,
-43, -46, -50, -54, -59, -63, -66, -71, -76, -79, -83, -87, -92, -95, -98, -102,
-106, -108, -110, -112, -113, -113, -114, -111, -110, -106, -101, -94, -87, -76,
-65, -51, -37, -18, -1, };