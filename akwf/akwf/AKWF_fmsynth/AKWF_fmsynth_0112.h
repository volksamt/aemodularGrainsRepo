#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0112

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 6, 8, 9, 11, 12, 14, 15, 17,
18, 20, 21, 23, 25, 26, 27, 29, 29, 31, 33, 35, 35, 37, 39, 40, 41, 41, 43, 44,
45, 46, 47, 47, 47, 49, 50, 50, 51, 51, 52, 52, 53, 54, 53, 54, 54, 54, 54, 54,
53, 55, 54, 54, 54, 55, 54, 53, 54, 53, 53, 52, 53, 52, 52, 51, 52, 50, 51, 50,
49, 49, 49, 49, 48, 48, 48, 47, 47, 46, 46, 46, 45, 46, 45, 45, 45, 46, 44, 45,
46, 46, 45, 45, 45, 45, 45, 46, 45, 45, 46, 45, 46, 47, 46, 46, 47, 48, 47, 47,
48, 49, 49, 49, 50, 50, 50, 50, 51, 51, 51, 52, 51, 51, 52, 52, 53, 53, 53, 53,
53, 54, 53, 54, 54, 54, 54, 54, 53, 53, 53, 53, 53, 53, 53, 53, 51, 52, 51, 51,
51, 49, 49, 48, 49, 48, 47, 47, 45, 45, 45, 44, 43, 42, 41, 40, 39, 39, 38, 37,
36, 35, 35, 34, 32, 32, 30, 29, 27, 28, 26, 25, 23, 23, 22, 21, 19, 18, 17, 16,
15, 14, 13, 12, 11, 10, 8, 8, 6, 6, 5, 3, 4, 1, 1, 0, -1, -2, -3, -4, -5, -5,
-6, -7, -7, -8, -10, -10, -11, -11, -13, -13, -14, -15, -15, -16, -17, -18, -19,
-19, -19, -19, -21, -21, -22, -22, -23, -23, -25, -25, -26, -26, -26, -27, -28,
-28, -29, -28, -30, -31, -30, -31, -32, -32, -32, -32, -33, -33, -33, -34, -35,
-35, -34, -35, -35, -35, -36, -37, -37, -36, -38, -37, -38, -37, -38, -38, -38,
-38, -38, -39, -38, -39, -39, -39, -38, -39, -39, -39, -39, -39, -39, -40, -38,
-39, -39, -38, -39, -38, -38, -38, -38, -38, -37, -36, -38, -37, -36, -35, -36,
-35, -35, -36, -34, -34, -33, -34, -33, -33, -33, -31, -31, -30, -31, -30, -28,
-29, -28, -27, -27, -27, -25, -25, -25, -23, -23, -24, -23, -21, -21, -19, -20,
-18, -17, -16, -16, -14, -14, -12, -12, -11, -10, -9, -8, -6, -5, -5, -3, -1,
-1, 1, 2, 3, 5, 6, 7, 9, 11, 11, 13, 15, 17, 18, 19, 20, 23, 24, 26, 27, 29, 31,
33, 34, 36, 37, 39, 40, 43, 44, 45, 47, 48, 49, 51, 51, 52, 53, 53, 54, 53, 53,
53, 53, 52, 52, 49, 48, 46, 43, 40, 36, 33, 27, 23, 17, 10, 3, -4, -14, -23,
-33, -43, -52, -61, -70, -76, -84, -89, -94, -99, -103, -106, -110, -112, -114,
-116, -118, -119, -119, -119, -119, -119, -118, -117, -117, -115, -114, -112,
-111, -109, -107, -105, -103, -102, -99, -97, -94, -92, -90, -88, -86, -84, -81,
-79, -77, -75, -73, -70, -69, -67, -64, -62, -61, -59, -57, -55, -53, -52, -50,
-48, -47, -45, -44, -42, -40, -38, -37, -35, -35, -33, -31, -30, -28, -27, -26,
-25, -23, -21, -20, -19, -17, -16, -15, -13, -10, -10, -8, -6, -5, -4, -2, -1,
};