#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0059

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 12, 29, 44, 56, 67, 75, 83, 88, 91,
94, 96, 97, 95, 94, 91, 86, 81, 72, 63, 54, 41, 28, 14, 0, -15, -31, -45, -57,
-70, -80, -89, -97, -101, -105, -109, -112, -112, -112, -113, -112, -111, -110,
-106, -103, -96, -88, -78, -68, -54, -41, -23, -6, 12, 30, 46, 63, 76, 87, 99,
106, 111, 114, 117, 119, 119, 118, 118, 119, 119, 119, 119, 119, 118, 117, 115,
111, 107, 100, 92, 82, 69, 58, 43, 30, 15, 1, -11, -23, -34, -44, -50, -56, -61,
-63, -65, -65, -63, -60, -54, -48, -38, -29, -16, -3, 11, 27, 43, 58, 73, 87,
97, 106, 114, 118, 119, 119, 116, 112, 106, 102, 96, 92, 89, 87, 85, 86, 88, 91,
95, 98, 104, 109, 113, 116, 119, 119, 118, 113, 109, 102, 93, 84, 72, 62, 52,
41, 33, 26, 20, 15, 12, 11, 11, 15, 20, 25, 32, 42, 52, 63, 74, 85, 96, 105,
113, 117, 119, 118, 115, 108, 99, 89, 78, 65, 53, 42, 33, 23, 18, 13, 10, 9, 10,
13, 18, 24, 32, 41, 52, 64, 75, 86, 95, 104, 111, 116, 119, 119, 118, 115, 111,
106, 101, 96, 91, 88, 85, 82, 83, 85, 86, 90, 94, 99, 104, 109, 113, 117, 119,
119, 116, 110, 102, 90, 77, 61, 44, 27, 10, -6, -20, -34, -45, -53, -60, -67,
-70, -71, -72, -71, -68, -63, -57, -50, -40, -28, -15, -2, 13, 28, 45, 58, 73,
85, 94, 103, 109, 113, 116, 118, 120, 119, 119, 119, 118, 118, 119, 119, 119,
119, 119, 117, 113, 108, 101, 92, 79, 65, 48, 30, 10, -9, -28, -46, -61, -75,
-87, -96, -103, -108, -112, -114, -115, -117, -116, -117, -116, -116, -113,
-111, -108, -102, -96, -88, -78, -65, -52, -37, -20, -5, 11, 27, 40, 54, 65, 75,
83, 89, 92, 96, 98, 99, 100, 98, 95, 91, 85, 78, 70, 58, 45, 29, 14, -6, -23,
-41, -60, -75, -89, -100, -108, -114, -118, -119, -118, -117, -114, -112, -109,
-108, -106, -105, -105, -106, -109, -110, -113, -115, -117, -119, -119, -117,
-114, -108, -101, -91, -79, -66, -54, -40, -27, -15, -3, 8, 15, 21, 26, 29, 31,
29, 26, 21, 15, 7, -4, -16, -29, -44, -58, -73, -86, -98, -108, -114, -118,
-119, -117, -112, -108, -99, -92, -82, -74, -66, -60, -53, -50, -48, -47, -48,
-50, -54, -60, -66, -74, -82, -91, -99, -105, -112, -116, -118, -118, -118,
-114, -109, -103, -95, -86, -79, -72, -66, -60, -56, -54, -54, -55, -59, -64,
-69, -76, -84, -93, -101, -108, -113, -117, -119, -118, -114, -107, -98, -87,
-75, -61, -47, -33, -20, -8, 2, 12, 19, 25, 29, 31, 31, 30, 27, 22, 14, 7, -3,
-13, -25, -37, -51, -63, -75, -87, -96, -105, -111, -115, -119, -119, -118,
-118, -116, -115, -112, -111, -110, -110, -111, -113, -115, -116, -118, -119,
-119, -117, -115, -108, -100, -90, -77, -63, -48, -31, -11, 0, };