#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0028

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 2, 2, 3, 5, 5, 6, 7, 8, 9, 10,
11, 12, 14, 14, 14, 15, 16, 18, 18, 20, 21, 21, 23, 24, 25, 25, 27, 28, 30, 30,
32, 33, 34, 36, 36, 37, 38, 40, 41, 42, 44, 45, 47, 47, 49, 51, 52, 53, 56, 57,
58, 60, 63, 64, 65, 67, 69, 71, 72, 74, 76, 78, 80, 81, 83, 86, 87, 89, 92, 93,
94, 96, 98, 100, 102, 103, 105, 107, 108, 110, 112, 112, 115, 116, 117, 117,
118, 118, 120, 119, 119, 119, 118, 117, 116, 116, 113, 111, 109, 106, 103, 99,
94, 90, 85, 78, 72, 66, 57, 49, 39, 30, 19, 8, -2, -12, -21, -28, -36, -42, -49,
-54, -59, -63, -68, -71, -73, -76, -78, -80, -81, -82, -83, -84, -84, -84, -84,
-83, -82, -81, -79, -78, -76, -75, -73, -71, -70, -68, -65, -63, -62, -58, -56,
-54, -52, -50, -47, -45, -42, -40, -38, -35, -33, -32, -29, -26, -25, -22, -20,
-18, -17, -14, -12, -10, -8, -6, -4, -2, -2, 1, 2, 5, 6, 7, 9, 11, 13, 14, 15,
17, 19, 20, 22, 23, 24, 26, 28, 30, 31, 33, 35, 36, 38, 40, 41, 43, 45, 46, 48,
49, 52, 54, 56, 57, 59, 61, 63, 65, 66, 69, 70, 72, 75, 76, 78, 80, 83, 84, 86,
88, 89, 92, 93, 95, 97, 98, 100, 102, 103, 105, 106, 108, 109, 110, 112, 113,
114, 115, 116, 116, 117, 117, 118, 119, 118, 118, 118, 118, 118, 118, 118, 117,
115, 115, 113, 112, 110, 109, 107, 105, 103, 100, 99, 97, 93, 91, 88, 85, 80,
77, 74, 69, 65, 61, 56, 51, 47, 41, 36, 30, 25, 19, 14, 8, 3, -3, -7, -12, -16,
-21, -24, -28, -33, -36, -39, -42, -44, -47, -49, -52, -54, -57, -58, -61, -63,
-64, -66, -67, -69, -70, -71, -73, -74, -75, -75, -76, -78, -78, -78, -80, -80,
-81, -82, -81, -82, -82, -83, -84, -83, -83, -83, -84, -84, -85, -84, -83, -84,
-85, -84, -84, -85, -85, -84, -84, -84, -83, -84, -84, -83, -83, -83, -82, -83,
-83, -81, -81, -81, -82, -81, -81, -80, -80, -80, -80, -79, -79, -78, -78, -78,
-77, -78, -78, -77, -77, -76, -76, -76, -74, -75, -74, -74, -74, -74, -73, -73,
-72, -72, -72, -72, -71, -71, -71, -70, -70, -69, -68, -68, -67, -67, -67, -67,
-66, -66, -66, -65, -65, -65, -63, -63, -63, -62, -62, -62, -61, -61, -60, -60,
-59, -60, -59, -57, -58, -57, -57, -56, -55, -55, -54, -54, -52, -52, -52, -51,
-51, -50, -50, -50, -49, -48, -48, -47, -46, -46, -44, -45, -43, -43, -42, -41,
-41, -40, -40, -39, -37, -38, -37, -35, -35, -34, -33, -33, -32, -31, -31, -31,
-29, -28, -28, -26, -26, -25, -25, -23, -23, -22, -22, -20, -20, -20, -17, -18,
-16, -16, -14, -13, -12, -13, -12, -10, -9, -9, -9, -6, -6, -5, -4, -3, -3, -2,
0, };