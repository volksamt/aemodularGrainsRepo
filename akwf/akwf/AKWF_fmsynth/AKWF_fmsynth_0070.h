#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0070

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 6, 7, 8, 10, 11, 12, 14, 15,
16, 19, 20, 22, 24, 26, 27, 28, 29, 31, 33, 35, 37, 39, 41, 41, 44, 46, 47, 49,
51, 53, 55, 56, 57, 60, 62, 63, 64, 67, 68, 70, 71, 74, 75, 77, 79, 80, 81, 83,
85, 87, 88, 89, 91, 93, 94, 95, 97, 99, 100, 100, 102, 103, 104, 106, 107, 108,
108, 110, 111, 111, 112, 114, 114, 114, 116, 116, 116, 117, 117, 118, 119, 118,
119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 118, 118, 117, 117, 116, 115,
114, 115, 114, 113, 112, 111, 109, 109, 108, 107, 106, 104, 103, 102, 99, 98,
97, 95, 94, 91, 91, 89, 87, 86, 83, 82, 79, 77, 76, 72, 71, 69, 67, 65, 63, 60,
59, 56, 53, 51, 49, 47, 45, 41, 40, 37, 34, 32, 30, 27, 25, 21, 20, 17, 15, 12,
10, 8, 4, 2, 1, -2, -4, -6, -9, -12, -15, -16, -18, -21, -24, -25, -28, -31,
-32, -34, -38, -40, -42, -44, -46, -48, -51, -53, -55, -57, -59, -61, -63, -64,
-67, -69, -71, -73, -75, -76, -79, -80, -82, -84, -84, -86, -88, -90, -92, -93,
-93, -96, -96, -97, -99, -100, -101, -103, -104, -104, -105, -106, -107, -108,
-109, -110, -110, -111, -112, -113, -113, -114, -115, -115, -116, -116, -116,
-117, -116, -117, -118, -118, -118, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -117, -118, -118, -117, -117,
-117, -116, -116, -116, -115, -116, -115, -115, -114, -113, -113, -112, -112,
-111, -111, -110, -110, -110, -109, -108, -108, -107, -107, -106, -106, -105,
-104, -104, -104, -103, -103, -103, -101, -101, -100, -100, -100, -99, -98, -98,
-97, -97, -95, -96, -94, -95, -94, -94, -92, -93, -92, -91, -91, -90, -90, -89,
-89, -89, -88, -88, -87, -88, -87, -86, -86, -86, -85, -85, -84, -85, -85, -84,
-84, -83, -83, -83, -82, -82, -82, -81, -81, -81, -81, -81, -80, -80, -80, -80,
-79, -79, -80, -79, -78, -79, -78, -78, -78, -79, -78, -78, -79, -78, -77, -77,
-77, -77, -78, -77, -77, -77, -77, -77, -77, -77, -76, -77, -76, -77, -76, -76,
-76, -75, -76, -76, -76, -76, -76, -76, -75, -76, -75, -76, -75, -75, -76, -75,
-74, -75, -74, -74, -73, -74, -74, -74, -73, -74, -73, -73, -73, -73, -72, -72,
-71, -71, -72, -72, -71, -71, -71, -71, -70, -70, -70, -70, -70, -69, -69, -68,
-68, -68, -67, -67, -67, -66, -66, -65, -65, -64, -64, -64, -64, -63, -63, -62,
-61, -61, -60, -60, -59, -59, -58, -58, -57, -56, -56, -56, -54, -55, -54, -53,
-53, -51, -50, -50, -49, -48, -48, -47, -46, -46, -45, -44, -43, -42, -41, -40,
-39, -38, -37, -37, -36, -36, -34, -33, -32, -31, -30, -29, -28, -27, -25, -24,
-24, -23, -22, -20, -20, -18, -16, -16, -14, -14, -12, -11, -9, -8, -7, -6, -4,
-3, -2, 0, };