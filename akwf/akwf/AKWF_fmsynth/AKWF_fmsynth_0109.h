#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0109

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 9, 11, 16, 18, 22, 25, 28, 31,
34, 37, 38, 41, 44, 46, 47, 50, 51, 54, 55, 57, 59, 59, 61, 62, 63, 64, 65, 66,
67, 67, 68, 68, 68, 68, 69, 70, 69, 70, 70, 70, 71, 70, 70, 70, 71, 70, 71, 70,
71, 69, 69, 70, 70, 70, 69, 69, 70, 70, 69, 68, 70, 69, 69, 69, 69, 70, 69, 70,
69, 69, 70, 69, 70, 70, 70, 70, 69, 70, 69, 70, 70, 70, 70, 70, 70, 70, 70, 70,
70, 69, 69, 68, 67, 67, 67, 66, 66, 65, 64, 63, 63, 61, 60, 60, 58, 57, 55, 55,
51, 50, 48, 47, 45, 43, 40, 39, 36, 33, 31, 28, 26, 22, 20, 17, 14, 11, 7, 4, 1,
-3, -6, -8, -13, -17, -20, -24, -28, -31, -35, -39, -42, -46, -51, -54, -58,
-61, -66, -69, -72, -76, -80, -83, -85, -89, -91, -96, -98, -101, -103, -105,
-108, -109, -112, -113, -116, -116, -117, -118, -119, -119, -119, -118, -118,
-117, -115, -114, -113, -111, -107, -104, -100, -97, -93, -89, -84, -77, -72,
-65, -57, -50, -42, -34, -24, -15, -8, 0, 8, 16, 21, 27, 34, 38, 43, 46, 51, 53,
57, 60, 62, 64, 65, 66, 68, 69, 69, 69, 70, 70, 69, 70, 69, 68, 67, 66, 64, 64,
63, 61, 59, 57, 55, 53, 53, 50, 48, 45, 44, 41, 39, 37, 34, 33, 30, 28, 25, 24,
22, 19, 17, 15, 13, 12, 9, 8, 4, 3, 1, -1, -3, -4, -6, -7, -10, -11, -12, -14,
-14, -17, -18, -19, -20, -21, -23, -23, -24, -25, -26, -27, -28, -27, -29, -29,
-29, -30, -29, -30, -31, -31, -30, -31, -31, -31, -30, -30, -30, -29, -29, -28,
-28, -27, -27, -26, -25, -24, -23, -22, -21, -20, -19, -17, -15, -15, -13, -12,
-10, -8, -6, -5, -3, -1, 1, 3, 5, 8, 9, 12, 13, 16, 18, 20, 22, 24, 27, 30, 32,
34, 36, 38, 41, 44, 46, 48, 51, 52, 55, 57, 59, 60, 62, 64, 65, 66, 68, 68, 69,
70, 70, 70, 70, 69, 68, 67, 65, 64, 62, 59, 55, 52, 47, 43, 38, 32, 25, 18, 10,
0, -8, -19, -30, -41, -50, -60, -68, -76, -83, -90, -94, -101, -104, -108, -111,
-115, -117, -118, -119, -119, -119, -118, -118, -116, -113, -112, -109, -106,
-102, -99, -95, -90, -86, -81, -76, -71, -66, -60, -55, -48, -42, -36, -30, -25,
-19, -12, -6, 0, 6, 12, 18, 23, 28, 33, 39, 42, 47, 51, 56, 59, 62, 64, 66, 68,
69, 69, 70, 70, 68, 66, 64, 61, 58, 53, 47, 41, 34, 27, 17, 8, -4, -14, -28,
-40, -51, -61, -70, -79, -86, -92, -98, -103, -107, -110, -113, -115, -117,
-118, -118, -118, -118, -118, -117, -116, -113, -111, -109, -106, -104, -100,
-97, -93, -89, -86, -82, -78, -74, -70, -65, -61, -57, -52, -47, -43, -39, -35,
-31, -26, -23, -18, -13, -10, -6, -2, };