#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0084

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 4, 8, 11, 14, 18, 22, 26, 31,
34, 39, 42, 46, 51, 54, 59, 62, 66, 69, 74, 77, 80, 83, 87, 89, 92, 95, 98, 100,
101, 104, 105, 108, 109, 111, 111, 112, 113, 115, 115, 115, 116, 118, 117, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120,
119, 119, 119, 119, 119, 118, 118, 117, 117, 117, 117, 117, 115, 115, 115, 113,
113, 113, 112, 111, 111, 110, 107, 107, 106, 105, 104, 104, 102, 102, 100, 100,
99, 97, 97, 97, 96, 95, 95, 94, 94, 94, 94, 93, 93, 94, 94, 94, 95, 96, 96, 97,
98, 99, 101, 101, 101, 104, 105, 106, 108, 108, 110, 111, 112, 113, 115, 115,
116, 117, 118, 118, 119, 119, 118, 119, 118, 118, 117, 116, 114, 112, 110, 108,
105, 102, 99, 96, 91, 88, 83, 78, 73, 69, 64, 58, 54, 48, 42, 36, 31, 24, 19,
13, 8, 1, -3, -8, -13, -16, -20, -22, -26, -27, -30, -31, -33, -34, -35, -36,
-36, -36, -35, -35, -34, -32, -32, -30, -28, -26, -23, -21, -18, -16, -12, -9,
-5, -2, 3, 7, 11, 15, 19, 23, 28, 31, 35, 39, 42, 46, 49, 51, 55, 57, 60, 62,
65, 67, 69, 70, 73, 75, 75, 76, 77, 79, 79, 80, 80, 79, 79, 79, 79, 79, 78, 76,
75, 73, 72, 70, 69, 65, 63, 60, 56, 53, 49, 45, 40, 35, 30, 23, 16, 9, 1, -7,
-15, -23, -30, -37, -44, -51, -57, -64, -69, -75, -80, -85, -89, -93, -97, -100,
-103, -106, -109, -111, -113, -114, -116, -117, -118, -118, -119, -119, -120,
-119, -118, -119, -119, -118, -116, -117, -117, -115, -115, -114, -114, -113,
-113, -112, -112, -112, -112, -111, -110, -111, -110, -110, -111, -110, -110,
-111, -110, -111, -112, -112, -112, -114, -114, -114, -114, -114, -115, -116,
-116, -117, -118, -117, -118, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -118, -117, -118, -117, -116, -117, -116, -116, -115,
-115, -115, -114, -114, -115, -114, -114, -114, -115, -115, -115, -115, -116,
-117, -117, -117, -117, -118, -117, -118, -119, -119, -119, -120, -119, -119,
-119, -119, -118, -117, -117, -116, -115, -113, -112, -110, -109, -106, -105,
-102, -99, -97, -95, -92, -89, -85, -82, -80, -75, -71, -68, -65, -62, -58, -54,
-50, -46, -43, -39, -36, -33, -30, -26, -23, -21, -17, -14, -12, -9, -7, -6, -3,
-1, 2, 2, 4, 6, 7, 6, 8, 8, 9, 9, 9, 8, 9, 8, 8, 7, 7, 6, 5, 4, 2, 0, -1, -2,
-4, -5, -8, -9, -11, -13, -15, -16, -19, -21, -24, -26, -27, -29, -32, -33, -35,
-37, -39, -41, -42, -45, -45, -47, -48, -49, -50, -52, -53, -54, -54, -54, -54,
-56, -55, -55, -56, -55, -54, -54, -54, -52, -52, -50, -50, -48, -47, -44, -43,
-41, -39, -36, -33, -31, -28, -25, -22, -19, -16, -13, -9, -4, -1, };