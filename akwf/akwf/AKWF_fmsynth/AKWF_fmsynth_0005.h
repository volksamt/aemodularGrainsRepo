#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 9, 15, 20, 23, 28, 33, 37, 41, 45,
48, 52, 54, 57, 60, 62, 64, 66, 68, 69, 70, 71, 72, 72, 73, 73, 73, 73, 73, 72,
72, 72, 70, 70, 68, 67, 66, 65, 64, 62, 62, 59, 58, 56, 55, 53, 51, 50, 49, 47,
46, 44, 43, 40, 40, 38, 37, 35, 34, 32, 30, 29, 28, 27, 26, 26, 24, 23, 23, 22,
21, 20, 19, 19, 19, 18, 18, 17, 18, 18, 17, 18, 17, 18, 18, 18, 18, 19, 20, 20,
21, 22, 22, 24, 24, 25, 26, 28, 29, 29, 31, 32, 34, 35, 37, 38, 39, 42, 43, 44,
45, 48, 50, 51, 52, 54, 55, 57, 59, 60, 62, 63, 65, 66, 67, 68, 70, 70, 71, 72,
73, 72, 72, 72, 73, 72, 72, 71, 70, 70, 68, 66, 65, 63, 61, 59, 56, 53, 51, 47,
44, 40, 36, 32, 27, 23, 19, 14, 9, 3, -2, -8, -14, -19, -24, -31, -36, -41, -48,
-53, -59, -64, -70, -75, -80, -85, -90, -94, -97, -102, -106, -109, -111, -113,
-116, -116, -118, -119, -119, -119, -119, -116, -115, -112, -110, -107, -102,
-99, -95, -90, -84, -79, -73, -66, -61, -54, -47, -40, -34, -26, -20, -13, -8,
-1, 5, 12, 18, 24, 29, 36, 41, 45, 50, 54, 57, 61, 64, 66, 68, 71, 71, 72, 73,
73, 73, 73, 71, 70, 69, 67, 65, 63, 61, 58, 56, 52, 50, 47, 43, 40, 37, 34, 30,
27, 23, 20, 16, 13, 10, 7, 3, 0, -2, -5, -8, -10, -13, -16, -19, -21, -23, -25,
-28, -29, -31, -32, -34, -35, -36, -37, -39, -39, -40, -41, -41, -41, -41, -41,
-40, -41, -40, -40, -40, -39, -37, -36, -35, -34, -32, -31, -29, -26, -26, -23,
-21, -19, -15, -13, -10, -8, -5, -1, 1, 6, 9, 13, 15, 20, 24, 28, 32, 35, 39,
43, 46, 49, 53, 55, 59, 61, 65, 67, 68, 70, 72, 72, 73, 72, 73, 71, 69, 66, 64,
61, 55, 51, 46, 40, 33, 26, 18, 10, 1, -6, -15, -24, -33, -42, -51, -60, -69,
-77, -85, -92, -98, -104, -109, -113, -116, -118, -119, -118, -117, -115, -111,
-107, -101, -95, -88, -80, -71, -62, -52, -41, -31, -20, -10, 2, 12, 21, 31, 39,
48, 55, 60, 65, 69, 72, 73, 73, 71, 68, 64, 58, 50, 43, 33, 24, 13, 1, -10, -22,
-33, -44, -55, -66, -76, -86, -94, -101, -107, -112, -115, -117, -118, -118,
-116, -114, -109, -104, -97, -89, -81, -73, -63, -53, -43, -32, -21, -12, -2, 9,
18, 27, 36, 44, 51, 57, 62, 66, 70, 71, 72, 73, 73, 69, 67, 63, 57, 52, 46, 38,
30, 21, 13, 4, -5, -14, -24, -32, -42, -50, -59, -67, -74, -82, -90, -94, -100,
-106, -109, -112, -115, -116, -118, -118, -118, -117, -117, -115, -112, -109,
-105, -101, -98, -93, -88, -83, -78, -72, -66, -60, -54, -49, -42, -35, -29,
-23, -19, -12, -6, -1, };