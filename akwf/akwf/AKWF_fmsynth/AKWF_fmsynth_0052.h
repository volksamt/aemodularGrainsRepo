#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0052

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 13, 21, 29, 36, 42, 49, 55, 61, 67,
72, 76, 82, 86, 90, 93, 96, 100, 102, 105, 107, 108, 111, 112, 112, 114, 115,
116, 117, 117, 117, 118, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 120,
119, 119, 118, 119, 118, 119, 118, 119, 119, 118, 118, 118, 117, 117, 116, 116,
115, 114, 113, 113, 111, 109, 108, 106, 104, 102, 99, 96, 93, 89, 86, 83, 79,
74, 69, 65, 60, 54, 49, 42, 37, 30, 24, 19, 12, 5, -1, -9, -14, -21, -28, -34,
-41, -47, -54, -61, -66, -72, -78, -83, -87, -92, -96, -100, -104, -107, -110,
-112, -114, -116, -118, -118, -118, -119, -119, -119, -118, -116, -114, -113,
-111, -109, -107, -104, -101, -98, -95, -92, -89, -85, -82, -78, -76, -72, -69,
-66, -62, -60, -57, -54, -52, -48, -46, -44, -43, -41, -39, -38, -36, -35, -35,
-34, -33, -34, -33, -33, -34, -35, -34, -36, -38, -39, -40, -42, -45, -47, -48,
-51, -54, -57, -60, -63, -66, -69, -73, -77, -80, -83, -88, -91, -94, -97, -101,
-103, -107, -110, -112, -114, -115, -117, -119, -118, -118, -119, -118, -116,
-115, -112, -109, -106, -102, -97, -92, -87, -80, -74, -66, -59, -51, -42, -34,
-24, -15, -6, 4, 14, 23, 33, 42, 50, 59, 68, 75, 83, 90, 96, 101, 106, 111, 114,
117, 118, 119, 119, 118, 117, 115, 111, 107, 102, 97, 91, 84, 78, 70, 63, 54,
46, 37, 28, 20, 11, 4, -4, -12, -20, -27, -35, -42, -49, -56, -62, -69, -74,
-79, -84, -88, -92, -96, -99, -102, -105, -106, -109, -111, -113, -113, -115,
-116, -117, -118, -117, -118, -118, -119, -118, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -120, -118, -119, -119, -119, -119, -119, -120,
-119, -118, -119, -119, -118, -119, -117, -117, -117, -117, -115, -114, -113,
-112, -110, -108, -107, -105, -102, -99, -97, -93, -90, -86, -81, -78, -73, -68,
-62, -57, -52, -46, -39, -33, -26, -20, -13, -7, 0, 7, 14, 21, 27, 34, 42, 48,
55, 62, 67, 73, 80, 85, 90, 94, 99, 102, 106, 110, 112, 114, 115, 117, 118, 119,
119, 119, 118, 117, 117, 115, 113, 111, 109, 106, 104, 101, 98, 95, 92, 89, 86,
83, 79, 76, 73, 71, 67, 64, 61, 58, 55, 52, 50, 47, 45, 43, 42, 40, 38, 37, 35,
34, 34, 33, 32, 31, 32, 32, 32, 33, 34, 35, 37, 37, 38, 40, 42, 44, 46, 49, 52,
54, 56, 60, 64, 65, 69, 73, 76, 80, 84, 87, 90, 94, 97, 100, 104, 105, 109, 111,
114, 116, 117, 119, 119, 119, 119, 118, 116, 115, 113, 109, 105, 101, 97, 91,
85, 78, 69, 62, 53, 44, 36, 25, 17, 6, -3, -13, -22, -32, -42, -51, -61, -69,
-77, -85, -91, -98, -105, -108, -112, -116, -117, -119, -119, -119, -118, -116,
-113, -109, -104, -100, -94, -88, -83, -75, -69, -61, -53, -45, -37, -29, -21,
-14, -4, };