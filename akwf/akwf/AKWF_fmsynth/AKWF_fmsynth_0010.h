#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 13, 19, 26, 29, 35, 41, 47, 51,
56, 60, 64, 69, 73, 77, 81, 83, 86, 89, 91, 95, 95, 98, 100, 100, 102, 103, 103,
104, 104, 104, 105, 103, 103, 103, 102, 101, 99, 99, 96, 95, 94, 93, 90, 88, 88,
85, 82, 81, 79, 76, 74, 71, 69, 67, 65, 63, 60, 58, 56, 53, 51, 49, 47, 45, 43,
40, 37, 36, 34, 32, 30, 29, 27, 25, 24, 21, 20, 18, 17, 16, 15, 13, 12, 10, 10,
8, 8, 7, 6, 5, 4, 4, 4, 2, 3, 2, 1, 2, 2, 2, 1, 3, 2, 2, 2, 3, 4, 5, 6, 6, 7, 9,
10, 10, 12, 13, 14, 15, 17, 19, 20, 23, 23, 26, 28, 30, 32, 34, 37, 39, 42, 44,
46, 49, 53, 54, 57, 60, 62, 65, 68, 70, 73, 77, 79, 81, 83, 86, 89, 91, 93, 94,
97, 98, 99, 101, 101, 103, 103, 104, 103, 103, 102, 100, 100, 96, 95, 91, 88,
84, 80, 76, 70, 64, 58, 52, 45, 37, 31, 22, 14, 6, -3, -11, -19, -28, -36, -45,
-53, -61, -70, -78, -85, -91, -97, -103, -108, -111, -115, -117, -118, -120,
-119, -117, -115, -111, -108, -102, -97, -90, -82, -73, -65, -56, -46, -35, -25,
-13, -3, 8, 19, 30, 39, 49, 59, 68, 76, 83, 90, 94, 98, 100, 102, 103, 102, 100,
96, 92, 86, 79, 70, 61, 52, 41, 29, 18, 6, -6, -18, -30, -41, -54, -64, -74,
-84, -92, -99, -106, -111, -115, -118, -118, -119, -118, -115, -112, -107, -102,
-95, -88, -80, -71, -61, -52, -41, -31, -20, -10, 1, 11, 21, 31, 41, 50, 59, 66,
74, 81, 86, 91, 95, 99, 100, 103, 103, 103, 102, 100, 98, 94, 90, 85, 79, 72,
66, 59, 51, 43, 36, 27, 19, 11, 2, -6, -14, -21, -29, -38, -45, -53, -60, -67,
-74, -79, -85, -90, -95, -99, -103, -107, -110, -112, -114, -116, -117, -118,
-119, -120, -119, -118, -117, -117, -116, -114, -112, -109, -108, -105, -102,
-101, -97, -94, -91, -87, -84, -80, -78, -74, -71, -68, -65, -60, -58, -54, -51,
-47, -44, -41, -38, -34, -31, -27, -25, -22, -19, -15, -12, -10, -8, -5, -3, 0,
2, 4, 6, 7, 10, 12, 13, 16, 17, 18, 20, 21, 22, 24, 25, 25, 26, 27, 28, 28, 29,
29, 30, 31, 31, 31, 30, 30, 31, 31, 30, 30, 30, 30, 29, 28, 28, 26, 26, 25, 24,
23, 22, 19, 18, 17, 15, 14, 13, 11, 9, 7, 5, 3, 1, -2, -4, -8, -10, -12, -14,
-18, -21, -24, -27, -30, -33, -37, -40, -43, -47, -50, -54, -58, -60, -64, -67,
-71, -75, -78, -81, -84, -88, -91, -94, -97, -100, -102, -105, -107, -109, -111,
-113, -114, -116, -116, -118, -119, -118, -119, -118, -118, -116, -115, -113,
-112, -109, -107, -103, -100, -96, -93, -88, -84, -79, -74, -67, -63, -57, -50,
-44, -38, -32, -24, -19, -14, -9, -3, };