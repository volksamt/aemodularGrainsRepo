#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0113

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 12, 24, 35, 45, 53, 62, 69, 77, 82,
89, 93, 98, 102, 106, 109, 112, 113, 115, 117, 118, 118, 119, 119, 119, 119,
117, 117, 116, 114, 114, 112, 110, 109, 106, 104, 103, 100, 98, 96, 94, 93, 90,
87, 85, 83, 80, 78, 77, 74, 71, 69, 67, 65, 63, 60, 59, 58, 55, 54, 51, 50, 48,
46, 45, 43, 42, 40, 37, 37, 35, 33, 32, 32, 30, 28, 27, 27, 24, 24, 23, 22, 21,
19, 19, 18, 16, 16, 15, 14, 13, 12, 11, 11, 10, 10, 8, 8, 8, 7, 6, 6, 5, 5, 4,
4, 3, 3, 3, 3, 3, 2, 2, 2, 2, 1, 1, 1, 1, 0, 0, 1, 1, 1, 1, 0, 1, 2, 2, 1, 1, 2,
2, 3, 3, 3, 4, 4, 5, 5, 6, 7, 7, 8, 9, 9, 10, 10, 11, 12, 13, 14, 15, 15, 17,
18, 19, 20, 21, 22, 24, 25, 26, 27, 29, 29, 31, 33, 34, 36, 37, 39, 41, 43, 44,
46, 48, 50, 52, 54, 56, 59, 61, 63, 66, 68, 71, 73, 76, 79, 81, 83, 86, 89, 92,
94, 98, 100, 102, 105, 107, 109, 111, 113, 114, 116, 117, 118, 118, 119, 117,
116, 114, 112, 109, 105, 100, 93, 86, 78, 69, 58, 45, 32, 16, -2, -19, -33, -47,
-59, -69, -77, -85, -91, -97, -100, -103, -106, -107, -108, -107, -107, -106,
-105, -102, -100, -97, -94, -90, -87, -83, -79, -75, -71, -68, -63, -59, -55,
-51, -47, -43, -40, -36, -32, -29, -25, -22, -19, -16, -13, -10, -6, -3, 0, 2,
5, 8, 11, 14, 16, 20, 23, 26, 29, 33, 35, 39, 43, 46, 50, 54, 57, 61, 64, 69,
72, 76, 80, 85, 88, 92, 95, 98, 102, 105, 108, 111, 113, 114, 117, 117, 118,
118, 118, 117, 114, 112, 109, 103, 99, 93, 87, 78, 68, 59, 46, 34, 20, 5, -11,
-25, -36, -47, -57, -66, -74, -80, -86, -91, -94, -98, -101, -103, -106, -106,
-107, -108, -108, -109, -107, -107, -106, -105, -103, -103, -101, -100, -97,
-96, -94, -92, -90, -88, -87, -85, -83, -81, -79, -77, -76, -73, -72, -70, -69,
-68, -64, -63, -62, -61, -59, -57, -56, -55, -54, -52, -51, -50, -49, -47, -47,
-46, -45, -43, -43, -42, -41, -40, -40, -39, -38, -39, -37, -37, -36, -36, -36,
-35, -35, -35, -35, -34, -34, -34, -34, -34, -35, -33, -34, -34, -34, -34, -35,
-35, -35, -35, -35, -36, -36, -37, -38, -37, -38, -39, -39, -40, -41, -41, -42,
-42, -44, -44, -45, -46, -47, -48, -49, -50, -51, -53, -54, -55, -56, -57, -59,
-60, -62, -64, -64, -66, -67, -69, -71, -72, -73, -75, -77, -79, -80, -82, -85,
-85, -87, -89, -90, -91, -93, -95, -97, -99, -99, -101, -101, -103, -104, -104,
-106, -107, -107, -107, -107, -107, -106, -106, -105, -103, -102, -100, -97,
-94, -92, -88, -84, -79, -74, -69, -61, -55, -47, -39, -29, -20, -8, };