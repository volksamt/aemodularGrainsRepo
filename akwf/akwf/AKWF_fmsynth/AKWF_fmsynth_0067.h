#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0067

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 3, 3, 4, 4, 5, 5, 6, 7, 8, 9,
9, 10, 11, 11, 12, 14, 15, 15, 16, 17, 18, 20, 20, 21, 23, 24, 24, 25, 27, 28,
30, 32, 32, 34, 35, 36, 37, 40, 41, 42, 43, 45, 47, 48, 50, 51, 53, 55, 56, 57,
60, 61, 63, 65, 67, 68, 69, 72, 74, 76, 78, 79, 81, 83, 85, 86, 88, 90, 93, 93,
95, 97, 98, 100, 102, 104, 104, 106, 108, 109, 110, 111, 112, 113, 114, 115,
116, 117, 117, 118, 118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 118, 117,
116, 116, 116, 114, 113, 112, 112, 110, 109, 107, 106, 104, 103, 101, 100, 98,
96, 94, 92, 90, 89, 87, 85, 83, 81, 79, 78, 75, 74, 72, 70, 68, 66, 63, 62, 62,
59, 57, 56, 54, 54, 52, 50, 49, 47, 46, 46, 44, 43, 42, 41, 41, 41, 39, 39, 38,
38, 37, 37, 37, 36, 37, 37, 37, 36, 36, 36, 37, 37, 37, 38, 38, 39, 39, 39, 40,
40, 41, 42, 42, 43, 43, 44, 45, 45, 46, 47, 47, 49, 48, 50, 50, 50, 51, 51, 53,
53, 53, 54, 54, 54, 54, 54, 55, 56, 56, 57, 56, 58, 57, 56, 57, 57, 57, 57, 57,
57, 56, 56, 56, 56, 55, 54, 54, 53, 53, 52, 51, 50, 49, 48, 47, 46, 44, 42, 40,
38, 37, 35, 33, 32, 28, 26, 23, 20, 17, 15, 11, 7, 4, 0, -4, -8, -12, -15, -20,
-24, -28, -32, -35, -40, -45, -48, -53, -56, -59, -63, -66, -70, -74, -76, -80,
-83, -86, -90, -92, -94, -97, -100, -102, -104, -105, -107, -110, -111, -112,
-113, -115, -116, -117, -118, -119, -118, -119, -119, -118, -119, -119, -119,
-118, -118, -118, -117, -116, -115, -114, -114, -112, -110, -110, -108, -107,
-106, -104, -102, -101, -99, -98, -97, -94, -92, -91, -89, -87, -86, -84, -83,
-80, -79, -77, -75, -73, -73, -70, -68, -67, -65, -64, -62, -60, -59, -56, -56,
-54, -52, -51, -49, -47, -47, -46, -44, -43, -41, -40, -39, -38, -37, -35, -34,
-33, -32, -31, -31, -29, -28, -27, -26, -25, -25, -23, -23, -22, -22, -21, -20,
-20, -19, -18, -17, -16, -16, -16, -15, -15, -14, -13, -12, -12, -12, -12, -11,
-11, -10, -10, -10, -9, -9, -9, -9, -8, -8, -8, -7, -7, -8, -7, -6, -7, -7, -6,
-6, -6, -5, -7, -7, -6, -6, -6, -6, -6, -6, -6, -5, -6, -6, -7, -7, -6, -6, -7,
-7, -6, -7, -7, -7, -8, -7, -7, -8, -8, -7, -8, -8, -8, -8, -7, -8, -9, -9, -9,
-8, -8, -9, -9, -9, -10, -10, -10, -9, -10, -10, -9, -10, -10, -10, -11, -11,
-10, -10, -10, -10, -10, -10, -10, -9, -10, -10, -9, -9, -9, -9, -9, -9, -8, -8,
-8, -8, -7, -7, -7, -6, -6, -7, -6, -5, -5, -5, -3, -4, -3, -3, -2, -1, -1, 0,
-1, 0, };