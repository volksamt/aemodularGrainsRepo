#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 13, 22, 29, 37, 44, 50, 56, 62, 66,
71, 74, 76, 80, 83, 85, 87, 89, 91, 93, 95, 97, 100, 101, 103, 105, 107, 109,
111, 113, 114, 117, 117, 118, 119, 119, 117, 116, 113, 109, 103, 95, 86, 76, 64,
52, 38, 23, 8, -7, -22, -37, -52, -66, -79, -89, -99, -106, -112, -116, -117,
-118, -117, -115, -112, -108, -103, -98, -92, -87, -81, -75, -71, -65, -60, -54,
-51, -46, -42, -38, -34, -31, -28, -23, -21, -17, -13, -10, -7, -2, 2, 7, 12,
17, 22, 28, 36, 43, 49, 56, 64, 71, 79, 87, 95, 100, 105, 111, 114, 118, 119,
119, 116, 114, 108, 101, 93, 84, 73, 61, 50, 37, 25, 12, 2, -9, -21, -31, -41,
-49, -57, -65, -71, -76, -82, -85, -89, -92, -95, -97, -99, -101, -102, -104,
-104, -105, -105, -107, -107, -108, -110, -110, -111, -113, -113, -114, -115,
-116, -117, -117, -118, -118, -117, -116, -115, -113, -110, -106, -101, -95,
-88, -80, -71, -60, -49, -36, -24, -9, 3, 18, 31, 45, 57, 69, 79, 88, 97, 104,
109, 113, 117, 118, 119, 118, 118, 116, 113, 111, 108, 104, 101, 97, 93, 90, 86,
82, 79, 76, 73, 69, 66, 63, 59, 55, 52, 47, 43, 39, 34, 29, 22, 17, 9, 3, -5,
-13, -23, -31, -41, -52, -61, -72, -81, -90, -99, -105, -111, -115, -118, -117,
-116, -112, -109, -101, -92, -82, -71, -59, -47, -33, -20, -7, 5, 18, 29, 40,
50, 60, 67, 75, 81, 88, 92, 96, 100, 103, 105, 108, 109, 111, 113, 113, 113,
114, 115, 116, 117, 118, 117, 119, 118, 118, 118, 118, 119, 119, 118, 116, 115,
114, 112, 109, 105, 101, 95, 89, 81, 72, 63, 53, 41, 29, 16, 3, -10, -22, -36,
-49, -62, -72, -83, -91, -99, -106, -111, -115, -116, -118, -118, -118, -115,
-114, -111, -107, -104, -101, -97, -95, -91, -89, -86, -83, -80, -77, -75, -73,
-71, -70, -67, -66, -64, -61, -59, -57, -54, -51, -48, -45, -39, -35, -30, -24,
-18, -11, -3, 5, 14, 23, 32, 43, 53, 63, 74, 83, 91, 99, 106, 113, 116, 118,
119, 117, 114, 109, 101, 93, 83, 72, 59, 47, 34, 21, 8, -3, -15, -25, -36, -45,
-54, -61, -69, -75, -81, -86, -90, -93, -97, -99, -102, -104, -107, -109, -109,
-111, -112, -114, -115, -115, -116, -117, -117, -118, -117, -117, -116, -115,
-114, -111, -108, -104, -100, -94, -88, -79, -71, -60, -50, -38, -26, -13, 2,
16, 29, 42, 56, 67, 79, 89, 97, 106, 112, 116, 117, 120, 119, 117, 115, 112,
108, 102, 98, 92, 86, 81, 77, 70, 67, 62, 58, 54, 51, 47, 44, 42, 40, 38, 35,
33, 31, 29, 27, 25, 21, 19, 16, 12, 8, 4, 0, -6, -12, -17, -25, -32, -40, -49,
-57, -65, -74, -83, -90, -97, -103, -109, -112, -116, -117, -117, -116, -112,
-108, -102, -95, -86, -77, -67, -57, -47, -35, -25, -15, -4, };