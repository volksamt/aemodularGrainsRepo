#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0077

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 2, 4, 5, 7, 8, 10, 10, 14, 14,
16, 18, 19, 21, 22, 25, 26, 27, 30, 31, 32, 36, 36, 38, 40, 41, 44, 45, 47, 49,
50, 52, 53, 56, 58, 59, 62, 63, 65, 67, 68, 69, 72, 73, 75, 76, 78, 79, 82, 83,
85, 86, 87, 89, 90, 92, 93, 94, 96, 97, 99, 99, 100, 102, 103, 105, 105, 106,
108, 109, 110, 111, 111, 111, 112, 113, 113, 115, 115, 116, 115, 117, 116, 118,
118, 118, 119, 119, 119, 120, 120, 118, 119, 119, 120, 118, 119, 118, 118, 118,
117, 117, 117, 117, 115, 115, 115, 114, 112, 113, 112, 111, 110, 110, 108, 108,
106, 106, 104, 104, 102, 101, 100, 99, 98, 96, 95, 93, 91, 90, 89, 88, 86, 84,
83, 82, 80, 78, 76, 76, 73, 71, 69, 68, 65, 65, 62, 60, 59, 57, 55, 53, 52, 49,
47, 45, 43, 41, 39, 37, 35, 33, 31, 29, 27, 26, 23, 20, 19, 16, 14, 12, 10, 8,
5, 4, 2, 0, -3, -5, -7, -9, -11, -13, -15, -17, -19, -21, -23, -26, -28, -30,
-31, -33, -34, -37, -39, -41, -42, -44, -45, -48, -49, -50, -53, -54, -56, -57,
-58, -60, -62, -63, -65, -65, -68, -69, -69, -71, -72, -73, -75, -75, -75, -76,
-79, -79, -80, -80, -82, -82, -83, -84, -85, -85, -86, -86, -87, -88, -89, -88,
-90, -90, -91, -90, -91, -91, -92, -93, -93, -93, -93, -94, -94, -94, -94, -94,
-94, -95, -95, -95, -95, -95, -95, -96, -96, -96, -96, -96, -96, -96, -97, -97,
-97, -96, -96, -97, -97, -97, -97, -97, -97, -97, -98, -96, -98, -97, -97, -98,
-97, -98, -98, -98, -98, -98, -98, -98, -98, -98, -98, -97, -99, -98, -99, -98,
-99, -98, -99, -99, -100, -99, -99, -99, -100, -99, -99, -99, -99, -99, -99,
-99, -99, -99, -99, -99, -99, -99, -100, -99, -99, -99, -100, -100, -99, -99,
-100, -99, -99, -99, -99, -99, -99, -99, -99, -98, -98, -98, -98, -99, -99, -98,
-98, -98, -97, -98, -97, -97, -96, -97, -97, -97, -96, -96, -96, -95, -95, -95,
-96, -95, -94, -94, -95, -93, -94, -93, -93, -92, -92, -91, -92, -92, -91, -90,
-90, -90, -89, -89, -89, -88, -88, -88, -87, -87, -87, -87, -86, -85, -85, -85,
-85, -83, -83, -83, -82, -82, -81, -81, -80, -81, -79, -80, -79, -78, -78, -77,
-78, -77, -76, -76, -75, -75, -74, -73, -74, -72, -72, -72, -71, -70, -70, -70,
-69, -68, -68, -67, -68, -68, -66, -66, -65, -64, -64, -63, -63, -62, -62, -61,
-61, -59, -59, -59, -58, -58, -57, -57, -55, -55, -55, -54, -53, -52, -52, -51,
-50, -50, -50, -48, -47, -46, -47, -45, -44, -44, -43, -42, -41, -40, -40, -39,
-38, -37, -37, -35, -34, -34, -32, -31, -30, -30, -28, -27, -27, -25, -23, -22,
-21, -21, -19, -18, -17, -15, -15, -13, -11, -10, -9, -8, -6, -5, -3, -2, 0, };