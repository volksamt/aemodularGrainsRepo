#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0102

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 11, 15, 19, 24, 27, 32, 35, 38,
42, 45, 46, 48, 50, 51, 51, 51, 51, 49, 48, 47, 44, 43, 40, 38, 36, 35, 32, 30,
29, 29, 27, 27, 27, 28, 29, 31, 31, 34, 37, 40, 44, 48, 52, 58, 63, 69, 74, 81,
86, 91, 97, 100, 104, 108, 111, 113, 115, 115, 116, 116, 116, 117, 117, 117,
117, 116, 114, 113, 111, 110, 109, 106, 105, 103, 101, 100, 99, 99, 98, 98, 99,
100, 102, 104, 107, 109, 112, 115, 118, 118, 119, 118, 117, 113, 107, 99, 88,
78, 64, 48, 33, 17, 3, -10, -19, -26, -29, -32, -31, -28, -23, -18, -9, 1, 12,
22, 33, 43, 51, 59, 65, 70, 73, 77, 77, 76, 75, 73, 69, 61, 52, 41, 26, 7, -15,
-37, -55, -71, -86, -97, -106, -112, -116, -118, -119, -119, -118, -116, -114,
-114, -113, -111, -111, -109, -110, -110, -110, -112, -112, -113, -115, -115,
-117, -117, -118, -119, -119, -120, -119, -119, -119, -118, -119, -119, -118,
-119, -119, -118, -118, -116, -113, -111, -106, -102, -98, -93, -88, -81, -75,
-70, -65, -60, -56, -51, -48, -45, -44, -41, -40, -39, -39, -38, -39, -40, -41,
-43, -45, -47, -49, -51, -54, -56, -58, -60, -61, -64, -64, -65, -65, -63, -63,
-62, -60, -57, -53, -50, -46, -43, -37, -33, -29, -25, -20, -16, -11, -7, -4,
-1, 4, 7, 9, 12, 14, 16, 17, 18, 18, 19, 20, 18, 17, 16, 14, 13, 11, 10, 7, 6,
4, 3, 1, 0, -1, 0, -1, -1, 0, 1, 2, 4, 6, 8, 11, 15, 19, 22, 26, 31, 36, 41, 46,
52, 56, 62, 66, 71, 74, 78, 82, 85, 85, 87, 88, 89, 88, 88, 86, 86, 83, 81, 79,
76, 75, 71, 69, 67, 66, 63, 63, 61, 61, 61, 61, 63, 64, 66, 69, 72, 76, 80, 85,
89, 96, 99, 105, 109, 113, 116, 118, 119, 118, 118, 116, 113, 111, 107, 104,
101, 100, 99, 98, 99, 101, 102, 104, 107, 109, 112, 114, 116, 117, 117, 119,
118, 120, 118, 119, 118, 119, 119, 118, 119, 118, 116, 115, 112, 107, 101, 92,
80, 65, 47, 23, -3, -29, -50, -66, -80, -90, -97, -103, -107, -111, -112, -114,
-114, -114, -114, -114, -114, -112, -109, -108, -106, -102, -98, -94, -89, -85,
-80, -75, -71, -69, -67, -66, -69, -72, -77, -81, -88, -94, -100, -106, -110,
-115, -117, -119, -118, -117, -115, -112, -108, -104, -99, -95, -91, -87, -84,
-81, -79, -78, -76, -75, -75, -76, -76, -77, -79, -81, -83, -85, -88, -90, -92,
-95, -97, -99, -100, -101, -101, -101, -101, -100, -100, -97, -96, -93, -90,
-86, -82, -76, -72, -66, -60, -56, -50, -44, -39, -35, -30, -26, -22, -20, -17,
-15, -13, -11, -10, -9, -9, -9, -9, -9, -11, -12, -13, -15, -17, -19, -21, -23,
-25, -26, -27, -28, -30, -30, -30, -29, -29, -28, -26, -23, -22, -18, -15, -12,
-9, -5, -1, };