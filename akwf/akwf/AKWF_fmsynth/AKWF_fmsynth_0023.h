#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 4, 5, 6, 6, 8, 8, 9, 9, 9, 9,
10, 11, 10, 11, 10, 10, 11, 11, 11, 11, 11, 12, 11, 12, 13, 13, 13, 14, 15, 16,
17, 18, 19, 19, 21, 22, 23, 25, 26, 28, 30, 31, 32, 33, 34, 36, 36, 38, 39, 40,
41, 41, 43, 44, 44, 44, 45, 45, 46, 46, 46, 45, 46, 47, 47, 47, 47, 48, 48, 48,
49, 50, 50, 50, 51, 52, 53, 54, 56, 57, 58, 59, 61, 63, 63, 66, 67, 69, 70, 71,
72, 74, 76, 77, 78, 80, 80, 81, 82, 82, 84, 84, 85, 85, 86, 86, 86, 87, 86, 88,
87, 88, 88, 89, 89, 89, 90, 90, 90, 91, 92, 93, 94, 95, 96, 97, 98, 100, 101,
102, 104, 104, 105, 106, 108, 108, 110, 110, 112, 112, 114, 114, 114, 115, 116,
115, 116, 116, 117, 117, 118, 117, 117, 118, 117, 118, 117, 118, 118, 118, 118,
119, 118, 119, 119, 118, 118, 119, 119, 118, 119, 119, 119, 118, 119, 118, 117,
117, 116, 115, 115, 113, 112, 111, 110, 108, 107, 106, 105, 102, 101, 100, 99,
98, 97, 96, 94, 94, 93, 91, 92, 91, 90, 90, 89, 88, 87, 87, 85, 85, 83, 82, 80,
79, 77, 74, 71, 68, 65, 61, 58, 53, 49, 44, 38, 33, 27, 21, 15, 8, 3, -3, -8,
-13, -17, -20, -24, -26, -29, -31, -33, -35, -36, -37, -39, -40, -40, -40, -42,
-41, -43, -43, -44, -45, -46, -47, -47, -49, -51, -51, -54, -55, -58, -60, -62,
-64, -67, -69, -71, -73, -76, -77, -79, -82, -82, -83, -85, -86, -87, -88, -88,
-90, -90, -90, -91, -92, -92, -91, -92, -92, -92, -92, -92, -92, -92, -92, -92,
-92, -93, -92, -92, -93, -92, -93, -93, -92, -93, -94, -94, -93, -93, -93, -94,
-94, -94, -93, -94, -94, -93, -93, -92, -92, -92, -92, -91, -91, -90, -91, -90,
-89, -88, -89, -89, -88, -87, -88, -87, -88, -87, -87, -88, -88, -87, -87, -87,
-88, -88, -88, -87, -88, -87, -87, -87, -87, -86, -86, -84, -85, -83, -83, -82,
-82, -81, -81, -79, -79, -78, -76, -75, -75, -74, -73, -72, -72, -71, -70, -70,
-70, -68, -69, -68, -67, -68, -67, -68, -67, -68, -67, -68, -67, -68, -69, -68,
-68, -68, -68, -68, -67, -67, -67, -67, -66, -65, -65, -64, -64, -62, -61, -60,
-59, -59, -57, -56, -55, -54, -52, -52, -52, -50, -49, -49, -48, -47, -47, -46,
-45, -45, -46, -45, -45, -44, -44, -45, -45, -45, -45, -45, -44, -45, -45, -45,
-45, -45, -45, -45, -44, -43, -43, -43, -42, -41, -40, -39, -38, -37, -36, -34,
-33, -32, -31, -30, -29, -28, -27, -26, -25, -23, -22, -22, -22, -21, -20, -20,
-20, -20, -20, -19, -19, -19, -19, -19, -19, -19, -19, -18, -19, -19, -19, -19,
-19, -18, -18, -17, -17, -16, -15, -13, -14, -13, -12, -10, -9, -8, -6, -5, -3,
-3, -2, 0, };