#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0079

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 5, 6, 8, 10, 11, 13, 16, 17,
20, 21, 23, 26, 28, 30, 32, 34, 37, 38, 41, 44, 45, 49, 51, 54, 56, 58, 60, 63,
65, 68, 71, 72, 74, 78, 80, 82, 84, 86, 88, 91, 92, 94, 97, 98, 100, 102, 104,
105, 107, 108, 109, 110, 112, 113, 114, 115, 116, 116, 116, 117, 118, 119, 118,
119, 119, 120, 119, 119, 120, 119, 119, 118, 117, 117, 116, 115, 115, 114, 113,
112, 111, 112, 110, 109, 108, 107, 106, 104, 103, 103, 101, 100, 98, 97, 95, 94,
93, 92, 91, 89, 87, 87, 85, 84, 82, 81, 80, 78, 77, 76, 74, 73, 72, 71, 69, 67,
65, 64, 63, 62, 61, 59, 58, 57, 55, 54, 53, 51, 50, 48, 46, 45, 43, 43, 41, 40,
37, 35, 34, 34, 32, 30, 27, 27, 25, 23, 21, 20, 18, 16, 15, 12, 11, 8, 7, 5, 3,
0, -2, -4, -5, -8, -9, -11, -13, -16, -19, -20, -23, -26, -27, -30, -33, -34,
-37, -39, -41, -43, -46, -47, -49, -52, -54, -56, -57, -60, -61, -64, -64, -66,
-68, -70, -71, -73, -74, -75, -76, -77, -78, -80, -80, -81, -81, -83, -83, -84,
-83, -83, -83, -84, -83, -84, -84, -84, -84, -83, -82, -82, -82, -81, -79, -80,
-78, -77, -76, -76, -74, -74, -74, -72, -71, -70, -69, -68, -66, -66, -64, -64,
-62, -61, -61, -59, -58, -56, -56, -55, -54, -53, -52, -52, -51, -50, -49, -48,
-48, -46, -47, -46, -46, -45, -45, -44, -44, -43, -43, -43, -43, -43, -43, -43,
-42, -42, -43, -42, -43, -43, -44, -44, -44, -43, -45, -45, -45, -45, -47, -46,
-47, -47, -48, -49, -50, -51, -51, -52, -52, -53, -53, -54, -55, -56, -56, -57,
-57, -58, -59, -60, -61, -61, -62, -63, -63, -63, -65, -65, -66, -66, -66, -68,
-69, -69, -69, -69, -71, -70, -71, -72, -71, -72, -73, -73, -74, -74, -74, -74,
-74, -74, -74, -75, -75, -75, -75, -75, -75, -74, -74, -74, -74, -74, -74, -73,
-74, -73, -73, -72, -72, -72, -70, -71, -70, -70, -69, -69, -67, -66, -66, -66,
-66, -65, -64, -62, -62, -61, -60, -60, -59, -58, -57, -56, -55, -54, -54, -53,
-51, -50, -49, -48, -47, -47, -46, -44, -44, -43, -42, -40, -41, -40, -39, -37,
-37, -35, -35, -34, -34, -32, -31, -30, -29, -29, -29, -28, -27, -27, -26, -25,
-24, -24, -25, -23, -23, -22, -22, -22, -21, -22, -22, -20, -20, -20, -20, -20,
-19, -19, -19, -19, -20, -19, -18, -19, -20, -19, -19, -19, -19, -19, -20, -19,
-19, -20, -21, -20, -21, -21, -21, -20, -21, -21, -22, -22, -22, -23, -22, -22,
-23, -23, -23, -23, -24, -24, -23, -23, -24, -24, -23, -23, -24, -24, -24, -24,
-23, -24, -23, -23, -23, -22, -21, -21, -21, -21, -20, -19, -18, -18, -18, -17,
-16, -16, -14, -13, -13, -12, -10, -10, -8, -7, -5, -4, -3, -1, 0, };