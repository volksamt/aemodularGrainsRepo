#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 18, 24, 30, 35, 41, 46, 52,
59, 63, 69, 73, 79, 82, 87, 92, 95, 98, 102, 105, 108, 110, 111, 112, 114, 116,
116, 117, 117, 117, 117, 118, 118, 118, 118, 118, 117, 118, 118, 118, 118, 117,
117, 116, 115, 114, 114, 113, 112, 111, 109, 108, 106, 104, 103, 101, 98, 97,
95, 93, 91, 90, 88, 86, 86, 84, 83, 82, 80, 80, 78, 80, 79, 79, 79, 80, 79, 81,
83, 83, 85, 87, 89, 92, 93, 97, 99, 101, 104, 107, 109, 111, 115, 116, 117, 118,
118, 116, 114, 110, 106, 99, 91, 81, 68, 52, 34, 13, -11, -33, -50, -65, -78,
-89, -97, -104, -109, -112, -115, -118, -118, -119, -119, -119, -118, -117,
-116, -115, -114, -114, -112, -111, -111, -109, -110, -109, -109, -108, -109,
-109, -109, -110, -110, -111, -113, -112, -113, -114, -116, -116, -117, -117,
-118, -118, -119, -119, -118, -118, -119, -117, -117, -116, -114, -114, -112,
-110, -109, -107, -106, -104, -103, -102, -101, -100, -100, -100, -101, -102,
-102, -103, -105, -106, -108, -110, -112, -113, -115, -116, -118, -119, -118,
-118, -118, -117, -115, -113, -110, -107, -104, -100, -95, -91, -86, -81, -76,
-70, -63, -58, -52, -47, -41, -36, -30, -24, -20, -15, -9, -4, 1, 6, 10, 14, 18,
22, 27, 30, 33, 36, 39, 42, 43, 46, 48, 50, 51, 52, 53, 54, 54, 55, 54, 54, 54,
52, 52, 51, 49, 48, 46, 45, 43, 41, 38, 36, 35, 32, 29, 27, 25, 23, 20, 17, 15,
13, 12, 9, 7, 5, 3, 2, 0, -1, -2, -3, -3, -4, -4, -5, -5, -5, -4, -2, -2, 0, 1,
4, 5, 7, 11, 13, 17, 19, 23, 27, 31, 35, 40, 44, 49, 53, 58, 64, 69, 74, 79, 84,
90, 95, 99, 103, 108, 111, 115, 116, 118, 119, 118, 117, 115, 111, 107, 101, 96,
88, 80, 70, 60, 50, 40, 29, 17, 6, -4, -13, -20, -27, -33, -36, -40, -41, -44,
-44, -45, -44, -42, -40, -37, -34, -30, -25, -20, -12, -5, 3, 13, 21, 29, 37,
44, 52, 59, 65, 71, 77, 82, 86, 89, 93, 97, 100, 101, 103, 105, 107, 108, 109,
109, 110, 111, 111, 111, 110, 110, 108, 108, 107, 105, 103, 100, 97, 93, 89, 83,
76, 68, 59, 47, 34, 18, 0, -19, -37, -53, -67, -79, -89, -98, -105, -110, -114,
-117, -118, -119, -118, -116, -114, -111, -107, -104, -100, -96, -91, -87, -81,
-77, -73, -68, -64, -61, -57, -54, -51, -48, -45, -43, -40, -38, -37, -35, -33,
-31, -31, -31, -30, -31, -30, -31, -31, -32, -33, -34, -36, -38, -39, -40, -42,
-44, -47, -49, -51, -53, -56, -57, -60, -63, -65, -68, -70, -72, -74, -77, -78,
-79, -82, -83, -84, -85, -87, -87, -88, -88, -88, -88, -87, -88, -87, -86, -84,
-83, -83, -80, -78, -76, -73, -71, -67, -64, -60, -56, -52, -48, -43, -39, -33,
-29, -24, -18, -13, -9, -3, };