#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0033

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 13, 23, 32, 39, 47, 54, 60, 66, 70,
75, 77, 82, 83, 85, 86, 88, 88, 89, 90, 89, 86, 86, 84, 81, 78, 75, 71, 66, 62,
56, 50, 43, 34, 26, 17, 7, -3, -12, -23, -35, -46, -56, -68, -77, -87, -95,
-104, -110, -114, -118, -119, -119, -116, -112, -105, -98, -87, -75, -62, -48,
-33, -15, -1, 4, 12, 29, 45, 59, 72, 83, 93, 102, 108, 113, 117, 119, 120, 118,
116, 113, 111, 106, 102, 96, 91, 85, 81, 74, 70, 65, 60, 57, 52, 50, 46, 44, 42,
42, 41, 40, 40, 41, 44, 46, 48, 51, 55, 60, 64, 69, 74, 80, 85, 91, 96, 102,
106, 110, 115, 117, 119, 119, 118, 115, 111, 105, 97, 87, 74, 61, 46, 29, 11,
-6, -24, -42, -59, -75, -88, -99, -110, -114, -119, -119, -117, -111, -104, -94,
-81, -68, -52, -36, -20, -3, 14, 31, 45, 60, 73, 84, 96, 103, 110, 114, 118,
119, 119, 118, 115, 110, 105, 100, 95, 87, 82, 74, 67, 62, 55, 49, 44, 38, 34,
30, 27, 25, 23, 22, 21, 22, 22, 24, 25, 28, 31, 35, 39, 44, 50, 55, 62, 67, 74,
81, 87, 93, 99, 105, 109, 114, 116, 118, 119, 118, 116, 114, 108, 101, 94, 84,
73, 61, 49, 35, 21, 6, -10, -24, -39, -53, -66, -77, -88, -97, -106, -112, -116,
-118, -120, -118, -114, -111, -105, -97, -88, -78, -69, -58, -46, -36, -25, -13,
-3, 5, 16, 24, 31, 40, 46, 53, 58, 62, 66, 70, 73, 75, 76, 77, 79, 78, 78, 78,
76, 74, 73, 69, 66, 61, 56, 50, 43, 36, 29, 20, 11, 2, -9, -20, -32, -43, -56,
-67, -77, -87, -96, -105, -110, -116, -118, -119, -118, -114, -108, -99, -90,
-77, -63, -47, -32, -14, 4, 21, 39, 55, 70, 84, 96, 105, 113, 117, 119, 117,
114, 109, 100, 89, 76, 62, 47, 31, 15, -1, -16, -31, -46, -59, -71, -81, -90,
-97, -103, -109, -113, -115, -117, -119, -119, -119, -118, -118, -116, -116,
-114, -114, -113, -111, -111, -110, -110, -110, -110, -110, -111, -112, -113,
-114, -115, -117, -118, -118, -119, -119, -119, -118, -116, -114, -112, -106,
-102, -95, -88, -79, -68, -58, -45, -33, -18, -3, 10, 26, 40, 55, 68, 81, 92,
100, 109, 115, 118, 119, 118, 116, 111, 105, 97, 87, 77, 66, 53, 40, 26, 14, 0,
-13, -25, -37, -48, -60, -68, -77, -85, -92, -97, -103, -107, -111, -113, -115,
-116, -118, -118, -120, -120, -119, -119, -119, -118, -118, -118, -119, -117,
-119, -118, -119, -119, -120, -119, -118, -119, -118, -116, -115, -113, -110,
-106, -102, -97, -91, -84, -75, -66, -56, -44, -31, -19, -4, 10, 24, 38, 52, 67,
79, 90, 100, 108, 115, 118, 120, 117, 113, 105, 95, 82, 68, 51, 32, 14, -6, -24,
-43, -60, -76, -89, -100, -108, -114, -118, -119, -117, -114, -109, -102, -94,
-85, -73, -63, -51, -39, -27, -17, -6, };