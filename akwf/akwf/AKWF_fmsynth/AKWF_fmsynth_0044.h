#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0044

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 6, 14, 21, 29, 36, 43, 50, 57, 64,
71, 77, 82, 89, 92, 98, 102, 105, 109, 112, 114, 116, 117, 118, 119, 119, 119,
118, 118, 116, 115, 112, 111, 108, 106, 103, 100, 97, 95, 92, 90, 86, 84, 82,
79, 77, 75, 73, 69, 68, 66, 65, 65, 63, 62, 61, 61, 60, 61, 61, 62, 63, 63, 65,
66, 67, 69, 70, 72, 74, 76, 78, 80, 83, 86, 88, 90, 93, 96, 97, 100, 102, 105,
106, 109, 110, 112, 114, 116, 116, 117, 117, 118, 119, 119, 119, 118, 119, 117,
117, 116, 114, 113, 111, 110, 108, 105, 104, 102, 98, 97, 95, 93, 89, 87, 86,
84, 82, 80, 78, 75, 74, 73, 71, 71, 69, 68, 68, 67, 67, 66, 67, 68, 68, 68, 69,
70, 71, 72, 74, 76, 77, 80, 82, 84, 87, 88, 92, 93, 96, 99, 102, 104, 106, 109,
111, 113, 114, 115, 117, 118, 119, 120, 119, 118, 118, 116, 115, 112, 108, 106,
102, 97, 93, 88, 82, 76, 69, 62, 55, 48, 40, 33, 24, 17, 8, 1, -7, -13, -21,
-29, -37, -42, -50, -57, -63, -69, -74, -79, -83, -89, -92, -97, -99, -103,
-105, -108, -110, -112, -113, -115, -115, -117, -117, -117, -118, -118, -119,
-118, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -118, -118, -118, -118, -117, -117,
-116, -116, -114, -112, -112, -111, -108, -107, -105, -102, -100, -97, -95, -92,
-88, -84, -81, -77, -73, -70, -65, -60, -56, -51, -46, -41, -37, -32, -27, -23,
-18, -13, -9, -5, 0, 4, 8, 11, 16, 19, 22, 25, 29, 31, 34, 36, 39, 41, 43, 44,
46, 47, 49, 49, 49, 50, 51, 51, 50, 50, 50, 48, 46, 45, 44, 42, 41, 38, 36, 32,
29, 26, 22, 18, 14, 10, 5, 2, -3, -8, -14, -18, -25, -30, -37, -42, -48, -54,
-60, -67, -72, -78, -83, -89, -93, -98, -103, -106, -109, -112, -115, -116,
-118, -118, -119, -119, -119, -116, -115, -113, -110, -107, -103, -99, -95, -91,
-85, -80, -74, -68, -63, -56, -50, -45, -39, -33, -27, -22, -15, -11, -5, 0, 5,
10, 15, 19, 23, 27, 30, 33, 36, 39, 42, 45, 47, 49, 50, 52, 54, 54, 56, 57, 57,
57, 57, 57, 57, 56, 56, 55, 53, 52, 51, 49, 46, 45, 42, 40, 37, 35, 31, 29, 25,
21, 17, 14, 10, 5, 2, -3, -7, -12, -16, -21, -25, -30, -35, -40, -43, -48, -52,
-57, -61, -65, -70, -74, -77, -81, -85, -87, -91, -93, -96, -99, -101, -103,
-104, -107, -108, -109, -112, -111, -113, -114, -115, -115, -116, -117, -117,
-118, -118, -118, -118, -119, -118, -118, -118, -119, -118, -118, -118, -118,
-117, -118, -118, -117, -116, -116, -115, -115, -114, -112, -112, -110, -108,
-106, -105, -102, -101, -98, -94, -91, -88, -83, -80, -74, -70, -64, -59, -54,
-47, -40, -34, -27, -20, -13, -4, 0, };