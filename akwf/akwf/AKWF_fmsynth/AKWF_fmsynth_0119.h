#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0119

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 12, 19, 27, 33, 41, 46, 52, 58, 62,
67, 71, 75, 78, 81, 83, 87, 89, 90, 92, 93, 93, 93, 93, 93, 93, 92, 92, 89, 88,
87, 84, 82, 79, 76, 74, 70, 67, 63, 59, 55, 51, 46, 42, 39, 35, 30, 26, 22, 18,
15, 12, 9, 7, 5, 3, 1, 0, -1, -2, -1, 0, 0, 3, 5, 7, 9, 13, 16, 20, 26, 30, 34,
40, 46, 50, 57, 63, 68, 74, 79, 85, 90, 94, 99, 102, 107, 110, 112, 114, 116,
118, 118, 119, 119, 119, 118, 118, 117, 116, 115, 115, 114, 113, 113, 112, 111,
111, 111, 110, 111, 112, 111, 112, 113, 115, 115, 116, 116, 117, 117, 117, 117,
118, 119, 118, 118, 117, 117, 116, 116, 114, 113, 111, 109, 108, 107, 106, 104,
103, 102, 101, 101, 99, 100, 101, 100, 101, 101, 103, 103, 105, 106, 108, 109,
111, 112, 114, 115, 117, 117, 117, 118, 118, 117, 116, 115, 112, 110, 107, 104,
100, 95, 90, 85, 81, 75, 70, 64, 59, 53, 48, 42, 38, 35, 31, 27, 24, 20, 19, 16,
16, 15, 14, 15, 15, 16, 17, 19, 21, 24, 26, 29, 32, 36, 40, 44, 48, 52, 56, 61,
64, 68, 72, 77, 80, 83, 86, 89, 92, 94, 96, 97, 99, 100, 102, 102, 103, 104,
104, 104, 104, 103, 102, 102, 101, 99, 98, 95, 92, 90, 86, 83, 79, 75, 70, 65,
59, 52, 45, 38, 31, 24, 16, 8, 1, -7, -13, -21, -28, -35, -43, -49, -55, -60,
-65, -70, -75, -79, -82, -85, -88, -91, -93, -94, -94, -95, -96, -96, -97, -96,
-95, -95, -94, -93, -91, -90, -87, -85, -82, -79, -77, -74, -69, -65, -61, -57,
-53, -48, -43, -40, -34, -31, -26, -22, -20, -16, -12, -9, -6, -5, -2, -1, -1,
0, 1, 1, 0, -1, -3, -5, -8, -11, -14, -18, -22, -27, -31, -36, -43, -48, -54,
-59, -65, -72, -77, -82, -88, -93, -98, -103, -106, -109, -111, -114, -116,
-118, -118, -119, -119, -120, -118, -118, -117, -115, -116, -114, -112, -112,
-111, -110, -109, -108, -108, -108, -109, -109, -109, -110, -110, -111, -112,
-113, -114, -114, -116, -117, -117, -117, -118, -119, -119, -118, -118, -118,
-117, -116, -115, -114, -114, -112, -111, -110, -108, -107, -106, -105, -104,
-104, -104, -103, -103, -104, -104, -105, -106, -107, -108, -108, -111, -112,
-113, -114, -116, -117, -117, -119, -119, -118, -118, -117, -115, -113, -111,
-106, -104, -100, -96, -92, -87, -83, -76, -72, -66, -61, -56, -51, -46, -42,
-37, -32, -29, -26, -23, -20, -18, -17, -15, -15, -15, -15, -15, -16, -17, -19,
-20, -23, -26, -29, -32, -35, -39, -43, -46, -51, -54, -58, -62, -67, -70, -73,
-77, -80, -82, -85, -88, -91, -93, -94, -96, -98, -99, -99, -101, -101, -100,
-101, -100, -100, -99, -99, -97, -96, -94, -92, -90, -87, -84, -79, -75, -71,
-67, -61, -55, -50, -43, -37, -30, -23, -15, -7, -1, };