#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0053

const PROGMEM int8_t DATA[DATA_LENGTH] = {18, 49, 75, 95, 109, 116, 119, 117,
115, 110, 106, 103, 101, 101, 103, 106, 109, 114, 118, 120, 117, 111, 99, 79,
52, 21, -12, -46, -77, -101, -115, -119, -112, -97, -76, -50, -24, 2, 27, 47,
65, 77, 87, 93, 97, 99, 98, 97, 93, 87, 79, 66, 50, 31, 8, -17, -43, -68, -90,
-107, -116, -118, -111, -94, -71, -43, -15, 12, 40, 61, 79, 93, 103, 109, 113,
115, 116, 116, 115, 114, 111, 106, 97, 85, 67, 46, 20, -8, -38, -67, -93, -110,
-120, -117, -104, -82, -55, -21, 26, 53, 76, 93, 106, 114, 118, 119, 118, 118,
117, 116, 117, 118, 118, 119, 118, 114, 107, 94, 78, 58, 31, 2, -27, -56, -82,
-102, -115, -120, -114, -102, -86, -63, -40, -18, 3, 20, 35, 47, 55, 60, 62, 61,
57, 50, 39, 25, 8, -11, -34, -59, -81, -101, -114, -119, -114, -101, -79, -48,
-16, 18, 51, 77, 98, 111, 118, 118, 114, 106, 96, 86, 77, 70, 66, 63, 65, 69,
76, 85, 95, 104, 112, 118, 119, 115, 103, 86, 62, 33, 2, -29, -59, -84, -103,
-115, -119, -117, -110, -98, -84, -70, -56, -45, -37, -32, -30, -30, -34, -42,
-52, -64, -79, -93, -106, -115, -119, -116, -105, -86, -60, -29, 4, 39, 69, 93,
111, 119, 118, 108, 93, 74, 53, 34, 16, 1, -11, -19, -25, -27, -25, -21, -12,
-2, 12, 29, 48, 68, 88, 103, 114, 119, 116, 104, 85, 60, 30, 0, -30, -58, -81,
-98, -111, -116, -119, -118, -115, -111, -107, -105, -103, -104, -106, -110,
-113, -117, -118, -118, -113, -104, -88, -65, -39, -8, 26, 57, 84, 106, 117,
119, 109, 92, 68, 40, 12, -14, -36, -57, -73, -84, -92, -98, -101, -102, -102,
-100, -94, -87, -77, -62, -44, -23, 2, 28, 56, 80, 101, 114, 119, 115, 103, 83,
58, 31, 3, -24, -47, -67, -82, -95, -103, -108, -112, -114, -115, -115, -113,
-111, -107, -99, -90, -76, -58, -35, -9, 20, 48, 75, 99, 114, 119, 114, 99, 75,
44, 11, -21, -50, -75, -95, -107, -115, -119, -119, -118, -117, -116, -115,
-115, -116, -118, -119, -118, -117, -111, -101, -84, -65, -37, -8, 22, 54, 80,
102, 115, 119, 114, 103, 86, 64, 43, 22, 0, -17, -32, -44, -52, -57, -59, -59,
-56, -50, -40, -28, -10, 8, 29, 53, 74, 95, 110, 118, 117, 107, 86, 57, 23, -13,
-46, -76, -98, -112, -118, -118, -113, -104, -95, -84, -75, -68, -64, -61, -62,
-66, -72, -80, -89, -99, -108, -116, -119, -117, -109, -92, -69, -40, -8, 25,
56, 83, 103, 115, 119, 116, 109, 96, 83, 70, 56, 45, 37, 30, 29, 28, 33, 38, 48,
60, 74, 87, 102, 112, 118, 118, 110, 94, 69, 38, 1, -34, -67, -93, -111, -118,
-116, -108, -94, -75, -55, -36, -19, -3, 8, 17, 22, 25, 25, 21, 15, 4, -9, -25,
-43, -63, -81, -98, -111, -119, -118, -110, -92, -67, -36, -6, };