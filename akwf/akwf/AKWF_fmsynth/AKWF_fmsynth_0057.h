#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0057

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 26, 40, 53, 65, 76, 85, 92, 97,
102, 105, 108, 110, 110, 112, 111, 111, 110, 108, 105, 102, 98, 92, 85, 78, 68,
57, 44, 32, 17, 3, -12, -27, -41, -55, -68, -79, -88, -97, -103, -109, -113,
-116, -117, -119, -119, -119, -120, -119, -118, -119, -119, -118, -119, -119,
-117, -116, -112, -108, -102, -95, -86, -75, -62, -47, -31, -14, 4, 21, 39, 55,
69, 83, 94, 104, 110, 115, 118, 119, 118, 117, 115, 113, 109, 106, 105, 103,
102, 102, 103, 104, 106, 109, 111, 113, 117, 117, 119, 119, 117, 114, 109, 104,
94, 84, 74, 61, 47, 33, 20, 6, -8, -21, -31, -41, -50, -59, -65, -70, -75, -77,
-79, -80, -80, -79, -76, -73, -68, -62, -54, -46, -34, -24, -11, 4, 18, 34, 50,
64, 78, 90, 101, 109, 116, 119, 119, 117, 112, 106, 97, 87, 76, 66, 55, 45, 37,
29, 23, 17, 15, 12, 12, 13, 14, 20, 25, 31, 38, 47, 57, 67, 77, 87, 96, 103,
110, 115, 118, 119, 118, 115, 110, 103, 95, 87, 78, 68, 60, 51, 42, 35, 28, 23,
19, 16, 15, 15, 16, 20, 24, 29, 35, 44, 52, 62, 71, 82, 91, 100, 108, 114, 118,
119, 118, 114, 106, 98, 84, 69, 54, 37, 21, 4, -10, -24, -38, -50, -59, -67,
-75, -80, -84, -86, -88, -89, -88, -86, -85, -80, -75, -70, -61, -52, -41, -30,
-17, -3, 11, 28, 42, 58, 71, 83, 94, 102, 110, 114, 118, 118, 119, 117, 116,
112, 111, 106, 105, 102, 100, 100, 100, 100, 101, 103, 106, 109, 113, 115, 118,
119, 119, 117, 114, 109, 100, 89, 76, 60, 43, 25, 5, -14, -31, -50, -65, -80,
-91, -100, -107, -113, -115, -118, -119, -119, -119, -118, -118, -117, -117,
-117, -117, -117, -119, -119, -119, -118, -117, -114, -111, -106, -99, -89, -80,
-67, -53, -38, -22, -6, 9, 25, 40, 53, 66, 76, 85, 93, 98, 103, 107, 109, 112,
113, 113, 114, 112, 113, 111, 108, 105, 102, 96, 89, 82, 70, 58, 44, 28, 10, -7,
-25, -43, -60, -77, -90, -102, -110, -115, -118, -119, -117, -114, -109, -103,
-96, -89, -82, -76, -70, -66, -63, -60, -60, -59, -61, -64, -67, -72, -77, -83,
-89, -96, -102, -108, -113, -116, -119, -119, -118, -115, -108, -101, -92, -81,
-69, -56, -44, -30, -18, -6, 4, 13, 21, 28, 32, 36, 38, 38, 39, 36, 33, 27, 20,
13, 3, -8, -19, -32, -47, -60, -74, -86, -98, -107, -114, -118, -120, -118,
-113, -106, -97, -86, -75, -61, -49, -35, -22, -11, 1, 10, 18, 25, 30, 35, 38,
40, 39, 38, 36, 32, 27, 20, 13, 4, -6, -16, -28, -41, -53, -64, -76, -87, -96,
-105, -111, -115, -119, -119, -118, -114, -111, -106, -101, -94, -88, -83, -79,
-74, -70, -69, -67, -68, -69, -72, -76, -81, -87, -93, -98, -105, -111, -114,
-118, -119, -119, -115, -110, -101, -90, -78, -63, -48, -32, -11, };