#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 2, 2, 3, 3, 5, 5, 5, 6, 7,
7, 8, 8, 9, 9, 10, 10, 11, 11, 12, 12, 13, 13, 14, 15, 15, 17, 16, 17, 18, 18,
18, 19, 20, 21, 22, 22, 22, 23, 24, 25, 25, 25, 27, 26, 28, 28, 28, 29, 29, 30,
31, 32, 32, 33, 33, 34, 35, 35, 36, 37, 37, 38, 39, 38, 40, 40, 42, 42, 42, 43,
43, 45, 45, 45, 47, 48, 48, 49, 49, 50, 50, 52, 53, 53, 53, 54, 55, 56, 57, 57,
58, 58, 60, 61, 60, 61, 62, 63, 64, 65, 65, 65, 67, 67, 69, 69, 70, 71, 71, 72,
72, 73, 75, 75, 75, 76, 77, 78, 78, 79, 79, 80, 81, 82, 83, 83, 84, 84, 86, 87,
87, 87, 88, 88, 89, 89, 91, 91, 92, 93, 93, 94, 94, 94, 96, 96, 97, 98, 98, 99,
99, 100, 100, 100, 101, 102, 102, 102, 104, 104, 104, 105, 106, 106, 106, 107,
106, 107, 107, 108, 107, 108, 108, 109, 108, 109, 109, 110, 109, 109, 110, 109,
110, 110, 111, 110, 110, 110, 110, 110, 110, 110, 109, 109, 109, 108, 109, 108,
108, 107, 106, 107, 107, 105, 105, 104, 104, 103, 103, 102, 101, 100, 99, 99,
98, 96, 96, 94, 93, 93, 91, 90, 89, 87, 85, 84, 83, 81, 79, 78, 77, 74, 72, 71,
69, 66, 64, 62, 60, 58, 55, 54, 51, 48, 46, 42, 39, 36, 33, 31, 28, 25, 22, 17,
15, 11, 7, 3, 0, -5, -8, -12, -15, -19, -23, -27, -30, -33, -37, -41, -43, -46,
-49, -52, -55, -58, -60, -63, -65, -67, -70, -73, -75, -77, -79, -82, -83, -86,
-87, -89, -90, -92, -93, -96, -97, -98, -100, -101, -102, -104, -105, -106,
-107, -108, -108, -110, -110, -111, -112, -113, -114, -114, -115, -116, -116,
-116, -116, -117, -118, -118, -118, -118, -119, -118, -119, -119, -118, -119,
-118, -118, -119, -119, -118, -119, -118, -119, -118, -118, -118, -117, -117,
-117, -116, -115, -116, -115, -115, -114, -113, -114, -113, -113, -111, -111,
-110, -109, -109, -109, -108, -108, -107, -106, -105, -104, -104, -103, -102,
-101, -100, -100, -99, -99, -97, -96, -95, -96, -95, -94, -93, -92, -91, -89,
-89, -88, -88, -87, -86, -85, -84, -84, -83, -82, -81, -80, -80, -78, -78, -76,
-76, -75, -74, -73, -72, -71, -70, -69, -68, -68, -68, -66, -65, -64, -64, -63,
-61, -61, -60, -60, -59, -57, -57, -56, -55, -54, -54, -53, -52, -51, -50, -49,
-49, -48, -47, -47, -46, -46, -44, -44, -42, -41, -42, -41, -40, -39, -38, -37,
-37, -36, -36, -34, -34, -33, -32, -33, -31, -31, -30, -29, -29, -29, -27, -27,
-25, -26, -25, -24, -23, -23, -22, -22, -21, -21, -20, -19, -20, -18, -17, -17,
-16, -15, -15, -15, -14, -13, -13, -12, -12, -12, -11, -10, -10, -8, -8, -8, -7,
-6, -6, -5, -5, -5, -3, -4, -3, -2, -2, -2, -1, -1, };