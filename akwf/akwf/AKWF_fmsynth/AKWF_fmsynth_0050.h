#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0050

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 11, 20, 30, 37, 46, 53, 60, 67, 72,
77, 82, 84, 89, 91, 93, 94, 95, 96, 94, 95, 92, 92, 89, 86, 83, 80, 76, 72, 67,
61, 56, 52, 46, 41, 36, 31, 27, 23, 21, 17, 16, 15, 14, 15, 15, 17, 21, 24, 29,
34, 40, 46, 51, 59, 66, 72, 79, 85, 91, 96, 101, 105, 109, 112, 114, 115, 118,
119, 119, 119, 119, 118, 118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118,
117, 115, 113, 112, 110, 107, 104, 102, 98, 96, 93, 90, 89, 88, 86, 86, 85, 86,
87, 89, 91, 94, 96, 99, 102, 106, 108, 111, 114, 116, 117, 119, 119, 119, 118,
115, 114, 111, 108, 105, 102, 98, 95, 93, 90, 88, 87, 86, 87, 87, 88, 90, 92,
94, 98, 99, 102, 105, 108, 111, 113, 115, 115, 117, 117, 119, 120, 119, 119,
119, 119, 118, 119, 120, 119, 119, 118, 119, 118, 118, 118, 117, 116, 114, 111,
108, 104, 100, 94, 88, 80, 74, 67, 59, 53, 46, 40, 33, 28, 23, 20, 16, 14, 12,
12, 12, 13, 15, 18, 21, 24, 28, 34, 38, 44, 49, 55, 61, 66, 71, 76, 80, 84, 87,
90, 92, 93, 94, 96, 96, 96, 96, 95, 92, 90, 87, 83, 79, 73, 68, 61, 53, 47, 38,
29, 20, 12, 2, -6, -15, -22, -31, -37, -45, -50, -55, -59, -62, -64, -66, -68,
-68, -68, -67, -65, -63, -59, -56, -51, -47, -42, -37, -31, -25, -18, -13, -7,
-1, 4, 9, 14, 18, 20, 24, 25, 26, 26, 25, 25, 23, 19, 15, 11, 5, -1, -6, -14,
-22, -29, -38, -47, -56, -62, -71, -78, -84, -90, -96, -100, -104, -106, -109,
-111, -113, -114, -115, -115, -115, -115, -115, -115, -115, -113, -112, -111,
-108, -107, -104, -102, -98, -95, -90, -86, -82, -78, -73, -69, -66, -63, -60,
-57, -57, -55, -54, -56, -56, -59, -62, -65, -69, -74, -79, -85, -89, -95, -99,
-104, -108, -112, -114, -116, -118, -119, -119, -119, -118, -117, -115, -113,
-112, -110, -110, -108, -108, -108, -107, -108, -108, -109, -111, -112, -113,
-114, -116, -117, -117, -118, -118, -118, -119, -117, -118, -117, -116, -115,
-114, -112, -112, -112, -111, -111, -112, -111, -113, -114, -114, -116, -118,
-119, -120, -119, -118, -117, -117, -115, -111, -108, -104, -99, -94, -89, -84,
-78, -74, -69, -64, -60, -57, -54, -52, -51, -50, -50, -52, -53, -55, -58, -62,
-65, -68, -74, -77, -82, -86, -90, -94, -97, -100, -102, -106, -108, -109, -111,
-111, -112, -113, -113, -112, -112, -112, -111, -110, -108, -104, -103, -98,
-95, -90, -85, -79, -71, -65, -57, -48, -41, -33, -25, -17, -10, -3, 4, 9, 14,
18, 22, 25, 27, 28, 29, 27, 27, 24, 22, 19, 15, 10, 6, 1, -5, -10, -16, -22,
-28, -34, -38, -43, -48, -52, -55, -58, -60, -61, -62, -63, -63, -61, -59, -57,
-54, -49, -45, -39, -33, -26, -19, -10, -4, -2, };