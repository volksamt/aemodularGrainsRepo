#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0071

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 13, 20, 25, 31, 37, 44, 51, 57,
63, 69, 76, 82, 88, 93, 97, 102, 106, 109, 112, 114, 115, 117, 117, 116, 115,
114, 113, 110, 108, 104, 101, 98, 95, 91, 88, 85, 81, 78, 75, 72, 69, 67, 65,
64, 61, 60, 60, 59, 59, 58, 59, 59, 60, 60, 61, 62, 63, 65, 66, 67, 70, 71, 74,
75, 77, 78, 80, 83, 85, 87, 89, 91, 94, 95, 96, 98, 98, 99, 98, 99, 99, 98, 96,
93, 91, 88, 85, 80, 75, 70, 65, 58, 53, 46, 38, 32, 26, 18, 12, 4, -4, -10, -18,
-24, -31, -37, -43, -48, -54, -59, -63, -67, -72, -75, -77, -81, -83, -86, -88,
-89, -91, -91, -93, -92, -93, -93, -92, -92, -90, -89, -88, -86, -84, -82, -79,
-78, -76, -75, -72, -69, -68, -66, -64, -63, -61, -60, -59, -58, -57, -57, -57,
-56, -57, -58, -58, -58, -60, -61, -61, -63, -63, -64, -65, -67, -68, -69, -70,
-70, -70, -71, -71, -72, -72, -74, -74, -74, -74, -74, -74, -74, -75, -76, -76,
-76, -77, -78, -78, -79, -79, -80, -81, -81, -82, -82, -83, -83, -83, -84, -84,
-83, -84, -84, -83, -81, -81, -80, -77, -77, -75, -72, -69, -67, -65, -62, -58,
-56, -51, -48, -43, -39, -36, -31, -27, -21, -16, -13, -8, -2, 3, 7, 13, 17, 22,
26, 31, 35, 39, 42, 46, 48, 52, 55, 57, 60, 61, 63, 65, 65, 66, 67, 66, 67, 66,
65, 64, 64, 63, 62, 61, 60, 59, 57, 56, 55, 54, 53, 52, 52, 51, 51, 51, 50, 50,
51, 51, 52, 53, 55, 56, 58, 60, 62, 64, 67, 70, 73, 76, 79, 82, 85, 89, 92, 95,
98, 101, 104, 107, 109, 112, 113, 115, 116, 117, 117, 116, 117, 116, 115, 113,
112, 109, 106, 104, 100, 97, 93, 89, 85, 81, 77, 73, 68, 64, 61, 57, 53, 49, 46,
43, 40, 37, 34, 32, 29, 28, 25, 24, 23, 22, 20, 19, 19, 19, 19, 18, 18, 20, 18,
19, 20, 20, 21, 21, 21, 22, 23, 23, 22, 23, 23, 22, 21, 21, 19, 17, 16, 14, 13,
10, 7, 5, 2, -2, -6, -9, -14, -18, -22, -26, -30, -34, -39, -42, -46, -50, -52,
-56, -60, -63, -65, -69, -71, -74, -77, -79, -82, -85, -87, -90, -91, -94, -97,
-99, -102, -104, -105, -107, -109, -112, -113, -115, -116, -117, -118, -119,
-119, -119, -119, -119, -119, -118, -118, -117, -115, -115, -113, -112, -111,
-109, -107, -106, -104, -102, -101, -99, -97, -96, -93, -92, -89, -87, -84, -81,
-78, -75, -73, -68, -65, -60, -56, -52, -47, -42, -37, -33, -26, -22, -18, -12,
-7, -4, 1, 5, 8, 12, 14, 16, 17, 19, 20, 21, 21, 21, 20, 19, 17, 16, 14, 13, 11,
8, 6, 3, 0, -3, -5, -8, -11, -13, -16, -17, -20, -21, -23, -24, -26, -26, -26,
-27, -26, -25, -25, -23, -21, -18, -15, -13, -10, -5, -1, };