#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0091

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 5, 6, 7, 8, 9, 11, 12, 14,
16, 17, 19, 20, 22, 25, 26, 29, 31, 33, 34, 37, 39, 41, 43, 46, 47, 50, 53, 55,
57, 60, 62, 65, 67, 69, 72, 74, 76, 78, 81, 84, 85, 87, 90, 91, 93, 95, 97, 98,
101, 101, 104, 106, 107, 108, 110, 111, 112, 113, 114, 114, 115, 115, 116, 118,
118, 117, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 117,
116, 116, 116, 116, 116, 116, 115, 114, 114, 114, 113, 113, 113, 113, 113, 112,
112, 111, 111, 112, 112, 112, 112, 112, 112, 112, 112, 112, 111, 113, 113, 113,
114, 113, 114, 114, 114, 114, 114, 115, 115, 115, 115, 116, 117, 116, 116, 117,
118, 118, 117, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 119, 119,
119, 118, 119, 118, 119, 120, 119, 119, 118, 119, 119, 118, 120, 118, 119, 119,
118, 119, 119, 118, 118, 118, 118, 118, 117, 118, 117, 117, 117, 117, 116, 115,
114, 115, 114, 113, 112, 111, 110, 109, 107, 107, 105, 102, 102, 99, 97, 95, 92,
89, 87, 84, 80, 76, 73, 68, 64, 59, 54, 49, 43, 37, 29, 23, 16, 8, 1, -6, -14,
-21, -28, -34, -42, -47, -53, -59, -64, -68, -73, -77, -80, -83, -87, -90, -94,
-96, -99, -101, -103, -105, -107, -108, -110, -111, -113, -114, -114, -114,
-116, -116, -117, -117, -118, -117, -118, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-118, -118, -119, -118, -118, -118, -118, -118, -119, -119, -118, -119, -119,
-118, -119, -118, -119, -120, -119, -120, -118, -119, -119, -120, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -118, -118, -119,
-118, -117, -118, -118, -118, -118, -118, -118, -117, -118, -118, -117, -116,
-117, -116, -117, -116, -117, -117, -116, -117, -117, -118, -116, -118, -117,
-118, -117, -118, -118, -118, -118, -118, -119, -119, -118, -118, -118, -118,
-118, -119, -119, -119, -118, -119, -119, -119, -118, -118, -118, -117, -116,
-116, -115, -114, -114, -113, -112, -110, -109, -108, -107, -105, -104, -103,
-101, -98, -97, -96, -94, -92, -90, -88, -85, -83, -80, -79, -76, -74, -72, -70,
-67, -65, -62, -60, -57, -55, -53, -51, -48, -45, -42, -40, -38, -35, -33, -30,
-28, -26, -24, -23, -21, -18, -15, -14, -12, -9, -8, -7, -4, -2, -2, 0, 1, 3, 5,
6, 7, 8, 9, 10, 12, 12, 12, 13, 14, 14, 15, 15, 17, 17, 17, 17, 17, 18, 18, 18,
18, 18, 18, 18, 17, 18, 18, 17, 17, 15, 15, 16, 14, 14, 13, 13, 12, 12, 11, 11,
10, 9, 8, 7, 7, 7, 5, 5, 5, 4, 3, 1, 2, 1, 0, -1, -2, -2, -2, -3, -3, -4, -4,
-5, -5, -5, -6, -5, -6, -5, -5, -5, -5, -6, -6, -5, -5, -4, -4, -4, -3, -2, -2,
0, };