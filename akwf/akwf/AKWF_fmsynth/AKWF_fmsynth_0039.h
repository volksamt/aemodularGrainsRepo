#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0039

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 7, 10, 13, 16, 18, 21, 23, 25,
27, 27, 28, 29, 28, 29, 28, 28, 28, 27, 28, 29, 30, 31, 33, 36, 37, 41, 43, 46,
49, 51, 54, 57, 58, 60, 60, 62, 63, 62, 61, 62, 62, 61, 61, 62, 62, 63, 64, 65,
67, 68, 70, 74, 76, 78, 81, 83, 84, 86, 88, 89, 89, 89, 89, 91, 90, 89, 89, 89,
89, 89, 90, 91, 92, 92, 95, 96, 98, 98, 100, 103, 104, 106, 107, 108, 108, 109,
109, 110, 109, 109, 109, 109, 109, 110, 108, 109, 109, 110, 111, 111, 113, 113,
114, 115, 116, 116, 117, 117, 118, 118, 118, 118, 118, 118, 118, 118, 119, 118,
118, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 118, 118, 118, 118,
118, 116, 116, 116, 116, 116, 117, 116, 117, 116, 116, 117, 116, 116, 116, 115,
115, 114, 113, 112, 111, 110, 109, 107, 106, 105, 104, 103, 103, 102, 102, 102,
102, 103, 103, 102, 103, 102, 102, 102, 100, 100, 99, 97, 95, 93, 91, 89, 86,
85, 83, 81, 80, 79, 77, 77, 77, 76, 78, 78, 79, 78, 77, 77, 76, 76, 74, 72, 71,
69, 66, 64, 60, 58, 55, 52, 49, 48, 47, 46, 44, 45, 45, 45, 45, 45, 45, 45, 45,
44, 44, 42, 40, 38, 35, 33, 30, 26, 23, 21, 18, 16, 13, 10, 9, 9, 8, 8, 8, 8, 8,
8, 8, 9, 9, 7, 6, 5, 2, 1, -3, -5, -9, -12, -15, -18, -21, -23, -25, -26, -28,
-28, -30, -29, -30, -29, -29, -28, -28, -29, -29, -30, -32, -34, -36, -39, -41,
-44, -47, -50, -53, -56, -58, -60, -62, -63, -64, -63, -64, -64, -64, -64, -63,
-63, -64, -64, -65, -65, -67, -69, -71, -74, -76, -77, -81, -84, -85, -87, -89,
-90, -92, -92, -93, -93, -93, -94, -93, -93, -92, -92, -92, -93, -93, -94, -96,
-97, -99, -101, -102, -103, -104, -106, -108, -109, -109, -110, -111, -111,
-112, -112, -112, -112, -112, -111, -112, -112, -111, -112, -112, -114, -114,
-114, -115, -115, -116, -117, -117, -118, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -120, -120, -119,
-118, -119, -119, -118, -119, -117, -117, -117, -115, -116, -115, -114, -114,
-115, -114, -114, -114, -115, -115, -115, -115, -115, -114, -114, -114, -113,
-111, -110, -109, -107, -107, -104, -104, -102, -101, -100, -100, -99, -99, -98,
-98, -99, -99, -100, -100, -99, -99, -98, -98, -97, -96, -94, -92, -91, -89,
-85, -84, -82, -80, -78, -76, -76, -75, -75, -74, -74, -74, -75, -75, -75, -75,
-74, -74, -73, -72, -70, -69, -66, -65, -62, -59, -56, -54, -51, -49, -47, -45,
-45, -44, -43, -43, -43, -43, -43, -44, -44, -44, -43, -43, -41, -39, -37, -35,
-32, -30, -27, -23, -21, -19, -15, -13, -11, -10, -9, -8, -8, -8, -7, -7, -8,
-8, -8, -8, -7, -6, -5, -3, -1, 0, };