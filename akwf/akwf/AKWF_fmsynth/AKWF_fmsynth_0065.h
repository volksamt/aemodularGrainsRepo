#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0065

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 11, 21, 29, 36, 45, 51, 58, 65, 71,
77, 83, 86, 91, 96, 100, 103, 106, 108, 111, 113, 115, 116, 117, 118, 119, 118,
119, 118, 119, 118, 118, 116, 115, 115, 114, 111, 109, 108, 106, 104, 102, 100,
99, 96, 93, 91, 89, 87, 84, 82, 80, 78, 76, 72, 71, 69, 66, 63, 61, 59, 57, 55,
53, 50, 48, 47, 44, 42, 41, 38, 37, 35, 33, 32, 31, 28, 27, 25, 23, 22, 21, 19,
18, 17, 14, 14, 12, 11, 10, 9, 8, 7, 5, 5, 3, 2, 1, 0, -2, -2, -3, -3, -5, -6,
-6, -7, -8, -9, -9, -10, -11, -12, -12, -13, -14, -14, -14, -16, -16, -17, -16,
-16, -18, -18, -18, -19, -19, -19, -18, -19, -20, -20, -20, -19, -19, -20, -19,
-19, -19, -18, -19, -18, -17, -17, -18, -17, -17, -15, -15, -15, -14, -14, -13,
-12, -11, -11, -10, -9, -8, -8, -7, -5, -5, -3, -2, -2, 0, 1, 3, 4, 5, 6, 7, 8,
10, 11, 12, 15, 16, 18, 20, 21, 23, 25, 28, 29, 31, 34, 36, 38, 41, 43, 46, 48,
51, 53, 56, 59, 63, 66, 69, 73, 76, 79, 83, 85, 90, 93, 95, 100, 102, 106, 108,
110, 113, 115, 118, 118, 119, 118, 118, 117, 115, 111, 107, 101, 94, 85, 74, 61,
46, 28, 8, -14, -33, -51, -66, -79, -90, -98, -105, -110, -115, -117, -118,
-119, -119, -117, -115, -111, -109, -104, -101, -95, -90, -85, -81, -76, -70,
-65, -59, -53, -49, -43, -40, -34, -30, -26, -22, -17, -13, -8, -6, -1, 3, 7,
10, 16, 19, 23, 28, 33, 36, 41, 47, 52, 58, 63, 68, 74, 81, 86, 92, 96, 101,
106, 110, 113, 116, 119, 119, 118, 116, 111, 107, 98, 87, 74, 57, 37, 12, -14,
-36, -57, -74, -87, -98, -106, -112, -116, -118, -119, -118, -117, -115, -111,
-109, -104, -99, -94, -89, -84, -79, -74, -69, -64, -59, -54, -49, -44, -40,
-35, -31, -27, -22, -19, -15, -12, -8, -5, -1, 2, 6, 8, 12, 16, 19, 23, 26, 30,
33, 37, 41, 45, 50, 52, 57, 61, 65, 70, 74, 78, 81, 86, 90, 93, 96, 100, 104,
106, 109, 112, 114, 116, 117, 118, 119, 119, 119, 118, 117, 116, 113, 111, 107,
103, 98, 93, 87, 82, 74, 67, 58, 49, 40, 31, 20, 9, -3, -15, -24, -34, -43, -50,
-57, -63, -69, -75, -80, -83, -88, -91, -95, -97, -99, -102, -105, -107, -108,
-109, -111, -112, -112, -114, -115, -115, -116, -116, -117, -117, -118, -117,
-119, -119, -119, -119, -118, -119, -119, -120, -118, -119, -119, -119, -119,
-118, -119, -119, -119, -118, -118, -120, -119, -119, -119, -118, -119, -118,
-119, -118, -118, -118, -117, -118, -118, -117, -117, -116, -115, -115, -115,
-114, -113, -112, -112, -110, -110, -108, -107, -105, -103, -101, -99, -96, -94,
-91, -88, -85, -81, -77, -73, -68, -63, -58, -52, -45, -38, -32, -23, -15, -6,
};