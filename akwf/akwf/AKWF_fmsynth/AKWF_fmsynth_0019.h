#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 8, 11, 14, 17, 21, 24, 27, 32,
35, 39, 43, 47, 52, 55, 60, 63, 68, 72, 76, 80, 84, 88, 91, 94, 97, 101, 104,
106, 109, 110, 111, 114, 114, 115, 115, 116, 116, 117, 117, 115, 115, 115, 113,
112, 113, 111, 110, 109, 108, 106, 105, 105, 103, 102, 102, 100, 100, 98, 98,
97, 97, 96, 95, 95, 95, 94, 93, 92, 92, 92, 91, 91, 90, 89, 89, 88, 87, 86, 84,
83, 82, 79, 77, 75, 73, 70, 67, 63, 59, 55, 49, 43, 37, 30, 22, 14, 3, -7, -18,
-29, -40, -49, -59, -68, -75, -83, -91, -96, -102, -106, -110, -114, -116, -117,
-118, -118, -118, -116, -115, -113, -111, -107, -104, -101, -96, -92, -87, -83,
-78, -74, -69, -64, -59, -56, -51, -48, -44, -38, -35, -31, -27, -24, -21, -17,
-14, -11, -9, -5, 0, 3, 6, 8, 11, 13, 16, 18, 20, 22, 25, 27, 28, 31, 32, 35,
36, 38, 40, 41, 42, 43, 45, 47, 47, 49, 49, 51, 51, 52, 52, 54, 54, 55, 55, 56,
56, 56, 57, 58, 58, 57, 58, 57, 59, 59, 59, 58, 60, 60, 60, 60, 60, 61, 61, 61,
62, 63, 64, 64, 64, 65, 67, 68, 68, 70, 71, 73, 75, 76, 77, 79, 81, 83, 85, 87,
90, 93, 94, 97, 99, 101, 103, 105, 108, 109, 111, 113, 114, 115, 115, 116, 114,
112, 110, 105, 100, 94, 86, 76, 64, 50, 33, 13, -8, -30, -47, -63, -76, -87,
-97, -103, -109, -114, -117, -118, -119, -119, -118, -117, -114, -112, -109,
-105, -103, -99, -95, -92, -88, -84, -81, -77, -73, -70, -67, -64, -61, -59,
-55, -52, -50, -47, -45, -44, -41, -39, -39, -36, -35, -33, -33, -32, -30, -29,
-28, -27, -25, -25, -25, -24, -23, -23, -23, -22, -21, -21, -22, -20, -20, -19,
-20, -19, -19, -19, -18, -19, -18, -18, -18, -17, -18, -18, -17, -17, -16, -16,
-16, -15, -14, -14, -14, -13, -12, -10, -10, -9, -8, -7, -6, -4, -4, -2, 0, 1,
4, 4, 6, 8, 9, 13, 14, 16, 19, 21, 23, 26, 30, 32, 34, 39, 42, 45, 49, 53, 57,
61, 65, 69, 74, 78, 81, 86, 90, 95, 99, 103, 106, 109, 112, 113, 115, 116, 116,
114, 112, 109, 105, 99, 92, 85, 74, 63, 49, 35, 19, 1, -17, -33, -46, -59, -69,
-78, -86, -91, -97, -102, -105, -109, -112, -113, -115, -117, -117, -118, -119,
-119, -120, -119, -118, -119, -118, -118, -118, -117, -117, -117, -116, -117,
-116, -115, -115, -115, -114, -114, -115, -113, -113, -114, -113, -114, -114,
-113, -113, -113, -114, -114, -113, -112, -112, -113, -112, -112, -112, -111,
-112, -111, -111, -109, -110, -109, -108, -108, -106, -106, -104, -104, -102,
-100, -99, -98, -96, -94, -92, -90, -87, -85, -83, -80, -77, -75, -72, -68, -65,
-62, -59, -56, -52, -48, -45, -41, -38, -35, -31, -28, -25, -21, -18, -15, -12,
-9, -6, -2, };