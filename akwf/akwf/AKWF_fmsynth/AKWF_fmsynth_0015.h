#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 14, 25, 35, 43, 52, 59, 65, 71, 77,
81, 85, 88, 90, 93, 96, 97, 99, 100, 101, 102, 102, 103, 104, 105, 106, 106,
107, 109, 110, 112, 113, 115, 115, 116, 118, 119, 119, 118, 116, 115, 111, 105,
98, 90, 79, 68, 53, 38, 22, 5, -12, -30, -46, -63, -77, -90, -98, -106, -110,
-112, -111, -107, -101, -94, -86, -77, -66, -55, -44, -34, -24, -14, -5, 3, 11,
18, 24, 29, 34, 39, 43, 47, 50, 53, 54, 57, 60, 61, 63, 66, 68, 71, 73, 76, 78,
82, 86, 89, 93, 97, 100, 104, 108, 112, 115, 117, 118, 118, 119, 116, 112, 107,
101, 92, 82, 71, 59, 46, 31, 16, 3, -11, -24, -38, -50, -61, -71, -79, -87, -93,
-98, -102, -104, -107, -108, -111, -110, -112, -111, -112, -112, -112, -111,
-112, -112, -111, -112, -111, -111, -112, -111, -111, -112, -111, -111, -112,
-111, -112, -111, -111, -111, -112, -112, -112, -110, -110, -108, -106, -103,
-99, -95, -90, -82, -76, -66, -56, -44, -31, -18, -4, 11, 26, 39, 54, 67, 79,
89, 98, 106, 111, 116, 118, 119, 119, 117, 114, 110, 106, 101, 95, 90, 84, 79,
73, 70, 65, 60, 56, 52, 49, 44, 42, 38, 35, 32, 29, 26, 22, 18, 14, 9, 5, -1,
-7, -13, -21, -28, -37, -46, -54, -63, -72, -81, -90, -97, -103, -108, -111,
-111, -109, -106, -100, -91, -80, -68, -53, -38, -22, -5, 12, 28, 45, 58, 72,
84, 93, 101, 107, 112, 115, 118, 118, 119, 118, 118, 116, 114, 112, 110, 108,
106, 105, 104, 103, 102, 102, 101, 101, 100, 100, 99, 99, 98, 98, 97, 96, 95,
92, 90, 88, 85, 81, 77, 72, 67, 60, 53, 44, 35, 26, 15, 5, -7, -19, -31, -42,
-54, -66, -76, -86, -94, -101, -106, -108, -112, -111, -112, -109, -105, -103,
-99, -93, -88, -82, -77, -72, -67, -63, -59, -54, -51, -49, -47, -44, -44, -42,
-41, -41, -41, -41, -41, -41, -41, -42, -41, -41, -40, -39, -38, -35, -34, -30,
-27, -23, -18, -13, -6, 1, 11, 19, 29, 39, 49, 60, 70, 81, 90, 99, 106, 112,
117, 118, 118, 116, 110, 103, 91, 80, 66, 50, 34, 18, 4, -11, -26, -40, -52,
-63, -73, -81, -89, -95, -99, -103, -105, -107, -109, -110, -111, -111, -112,
-112, -111, -111, -111, -109, -109, -109, -108, -106, -105, -103, -102, -100,
-97, -95, -91, -87, -82, -77, -71, -63, -55, -46, -36, -26, -13, -1, 13, 27, 40,
54, 67, 79, 91, 101, 109, 115, 118, 120, 118, 115, 110, 104, 95, 86, 76, 65, 54,
43, 32, 22, 14, 5, -2, -9, -16, -21, -25, -28, -33, -35, -36, -38, -39, -40,
-39, -39, -38, -38, -38, -36, -36, -35, -35, -35, -35, -35, -36, -38, -40, -42,
-45, -49, -53, -58, -63, -69, -75, -81, -86, -92, -98, -103, -106, -110, -111,
-112, -110, -108, -104, -97, -91, -83, -74, -63, -52, -41, -28, -16, -5, };