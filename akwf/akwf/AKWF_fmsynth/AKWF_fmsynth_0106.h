#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0106

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 2, 3, 4, 4, 5, 5, 7, 8, 7, 9,
9, 10, 11, 12, 12, 13, 14, 15, 16, 16, 17, 17, 18, 19, 20, 21, 21, 22, 23, 23,
25, 25, 26, 27, 28, 28, 29, 30, 31, 32, 33, 33, 34, 35, 36, 37, 38, 38, 39, 39,
40, 41, 42, 43, 44, 44, 46, 47, 47, 48, 49, 50, 50, 51, 52, 53, 54, 55, 56, 57,
58, 58, 59, 60, 60, 61, 62, 64, 64, 65, 65, 66, 67, 68, 69, 69, 70, 71, 72, 72,
73, 73, 75, 76, 76, 78, 77, 79, 79, 81, 81, 82, 83, 83, 84, 85, 85, 86, 86, 88,
88, 89, 90, 91, 91, 92, 93, 94, 94, 94, 95, 95, 96, 97, 98, 98, 99, 99, 100,
102, 100, 102, 103, 103, 104, 104, 105, 105, 105, 107, 107, 109, 108, 108, 109,
109, 110, 111, 110, 112, 112, 113, 113, 114, 114, 114, 115, 115, 115, 115, 116,
116, 116, 117, 118, 117, 117, 119, 118, 118, 119, 119, 120, 118, 119, 119, 119,
120, 119, 119, 118, 119, 119, 118, 119, 118, 118, 117, 117, 116, 116, 115, 116,
115, 114, 113, 113, 112, 111, 111, 110, 109, 108, 108, 106, 105, 103, 102, 102,
100, 99, 97, 95, 94, 92, 90, 89, 87, 85, 83, 81, 79, 76, 74, 73, 70, 67, 65, 62,
60, 57, 55, 52, 49, 46, 42, 39, 37, 33, 31, 26, 23, 20, 15, 11, 9, 5, 1, -3, -7,
-11, -15, -18, -22, -24, -29, -31, -35, -38, -40, -43, -46, -48, -52, -54, -56,
-59, -61, -64, -66, -68, -70, -72, -74, -76, -78, -79, -81, -82, -85, -86, -88,
-89, -90, -92, -94, -94, -96, -97, -98, -99, -100, -102, -103, -104, -105, -105,
-106, -107, -109, -108, -109, -111, -111, -112, -112, -114, -114, -114, -114,
-115, -116, -115, -116, -117, -117, -117, -117, -118, -119, -118, -119, -119,
-118, -119, -119, -120, -119, -119, -120, -119, -119, -119, -119, -119, -118,
-119, -119, -118, -117, -118, -117, -116, -116, -116, -116, -116, -115, -116,
-115, -114, -113, -114, -113, -112, -111, -111, -110, -110, -110, -109, -108,
-108, -106, -107, -106, -105, -104, -104, -102, -102, -102, -101, -99, -99, -98,
-98, -96, -97, -95, -95, -94, -93, -92, -91, -90, -90, -88, -88, -87, -86, -85,
-84, -84, -83, -81, -81, -80, -79, -78, -77, -77, -75, -75, -74, -73, -72, -71,
-70, -69, -69, -69, -67, -66, -66, -64, -64, -64, -62, -62, -60, -60, -59, -58,
-57, -56, -56, -55, -54, -54, -53, -52, -51, -50, -50, -50, -48, -47, -46, -45,
-46, -44, -45, -44, -43, -41, -41, -40, -40, -39, -38, -38, -37, -36, -36, -35,
-34, -34, -33, -32, -31, -31, -30, -29, -29, -28, -28, -27, -27, -25, -25, -25,
-24, -23, -23, -22, -22, -21, -20, -19, -19, -18, -17, -17, -16, -16, -15, -14,
-14, -13, -13, -11, -11, -10, -10, -9, -8, -8, -7, -6, -6, -5, -4, -3, -3, -3,
-2, -1, 0, };