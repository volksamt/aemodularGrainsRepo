#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0069

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 5, 7, 8, 10, 12, 14, 17, 19,
22, 24, 27, 31, 33, 37, 41, 44, 48, 53, 57, 62, 66, 70, 75, 80, 85, 90, 93, 98,
101, 106, 109, 112, 114, 117, 118, 118, 120, 119, 117, 116, 113, 111, 109, 105,
100, 96, 92, 87, 82, 78, 74, 70, 65, 62, 59, 56, 54, 53, 51, 50, 50, 49, 51, 51,
54, 55, 57, 59, 61, 64, 67, 69, 72, 75, 77, 80, 82, 84, 87, 88, 89, 91, 94, 94,
95, 96, 96, 97, 97, 97, 97, 96, 96, 94, 92, 90, 88, 86, 83, 79, 74, 68, 62, 55,
45, 35, 24, 10, -4, -19, -33, -48, -60, -71, -81, -90, -98, -105, -110, -113,
-116, -119, -119, -119, -118, -117, -115, -112, -110, -105, -102, -99, -95, -91,
-87, -83, -79, -74, -71, -67, -65, -61, -58, -55, -53, -51, -48, -45, -44, -42,
-40, -40, -38, -36, -36, -36, -35, -36, -35, -35, -35, -34, -35, -36, -36, -37,
-38, -39, -40, -40, -42, -43, -44, -45, -47, -48, -50, -51, -53, -53, -55, -56,
-57, -59, -61, -61, -63, -64, -64, -66, -66, -66, -66, -67, -67, -67, -66, -67,
-66, -65, -63, -63, -61, -61, -58, -57, -55, -53, -50, -48, -45, -43, -40, -37,
-34, -32, -29, -26, -24, -21, -17, -13, -11, -8, -4, -2, 2, 5, 7, 11, 14, 18,
20, 24, 28, 31, 33, 37, 40, 44, 47, 51, 54, 57, 61, 64, 66, 69, 71, 74, 76, 78,
79, 82, 83, 85, 85, 86, 88, 88, 89, 89, 90, 90, 89, 90, 90, 89, 89, 88, 87, 87,
86, 84, 84, 83, 81, 80, 79, 78, 77, 76, 75, 75, 74, 73, 71, 70, 71, 69, 69, 69,
69, 68, 68, 70, 69, 70, 71, 72, 72, 74, 76, 76, 79, 81, 83, 85, 87, 90, 93, 96,
98, 101, 105, 107, 109, 112, 115, 116, 118, 120, 119, 118, 116, 114, 109, 104,
95, 86, 75, 62, 46, 27, 5, -17, -36, -53, -67, -79, -90, -97, -103, -108, -112,
-115, -117, -118, -119, -119, -119, -118, -118, -118, -116, -116, -115, -114,
-113, -113, -111, -111, -110, -110, -109, -110, -109, -109, -109, -111, -110,
-110, -111, -112, -112, -113, -114, -115, -115, -115, -116, -116, -117, -118,
-118, -118, -118, -118, -118, -119, -119, -120, -118, -119, -119, -119, -119,
-118, -119, -119, -119, -119, -119, -120, -120, -120, -119, -119, -118, -117,
-117, -116, -115, -114, -112, -111, -108, -106, -104, -101, -99, -94, -91, -88,
-83, -80, -75, -71, -67, -63, -58, -55, -51, -48, -44, -39, -36, -32, -29, -26,
-22, -20, -17, -14, -11, -8, -6, -4, -2, 1, 2, 4, 7, 7, 9, 11, 11, 14, 15, 14,
16, 16, 17, 17, 18, 18, 18, 18, 17, 17, 18, 16, 16, 16, 15, 14, 13, 13, 12, 11,
10, 8, 7, 6, 6, 5, 3, 2, 1, 0, 0, -1, -1, -2, -4, -4, -4, -4, -5, -5, -5, -4,
-5, -4, -4, -3, -3, -1, -1, };