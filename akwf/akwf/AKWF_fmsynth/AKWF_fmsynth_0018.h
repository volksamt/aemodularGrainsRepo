#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 8, 13, 20, 27, 33, 40, 47, 56, 63,
72, 80, 87, 94, 100, 106, 111, 114, 117, 118, 119, 119, 117, 114, 111, 107, 103,
98, 93, 88, 82, 79, 73, 67, 63, 57, 52, 45, 39, 31, 24, 14, 5, 6, 14, 22, 29,
37, 45, 52, 60, 68, 76, 83, 90, 97, 101, 107, 110, 113, 115, 117, 117, 118, 119,
119, 118, 118, 118, 117, 117, 117, 116, 117, 116, 116, 116, 117, 116, 115, 116,
116, 115, 114, 114, 113, 111, 110, 108, 104, 100, 95, 88, 79, 67, 53, 35, 12,
-15, -39, -61, -78, -92, -103, -110, -116, -118, -117, -114, -111, -107, -100,
-94, -87, -81, -74, -67, -61, -55, -51, -45, -42, -37, -34, -30, -27, -25, -23,
-21, -19, -19, -18, -16, -16, -15, -16, -15, -15, -16, -16, -15, -15, -16, -16,
-18, -17, -17, -17, -17, -16, -16, -15, -14, -12, -11, -9, -7, -4, -1, 2, 5, 9,
14, 17, 22, 28, 34, 40, 48, 55, 65, 73, 82, 91, 100, 107, 114, 117, 118, 116,
106, 92, 69, 39, 0, -39, -66, -87, -100, -110, -115, -118, -118, -116, -114,
-111, -107, -103, -100, -97, -93, -90, -87, -84, -81, -78, -76, -75, -72, -70,
-68, -67, -64, -63, -61, -58, -56, -54, -51, -48, -44, -42, -38, -35, -31, -27,
-23, -19, -13, -10, -5, 0, 6, 11, 17, 22, 31, 37, 45, 53, 61, 71, 80, 88, 97,
105, 111, 116, 119, 118, 115, 108, 96, 82, 61, 40, 13, -14, -36, -54, -68, -79,
-87, -93, -99, -101, -105, -106, -108, -109, -109, -109, -109, -108, -108, -108,
-107, -106, -105, -104, -102, -101, -101, -100, -100, -99, -99, -99, -101, -103,
-105, -106, -108, -110, -113, -114, -116, -117, -118, -116, -115, -113, -109,
-105, -99, -93, -87, -80, -73, -67, -59, -52, -44, -38, -31, -25, -20, -15, -8,
-4, 0, 5, 10, 14, 18, 22, 26, 30, 34, 37, 39, 43, 46, 48, 50, 52, 53, 55, 57,
57, 58, 59, 61, 61, 61, 61, 63, 63, 64, 65, 66, 68, 70, 72, 74, 76, 79, 83, 87,
91, 96, 99, 104, 109, 113, 117, 118, 119, 116, 110, 99, 82, 56, 18, -28, -62,
-88, -105, -114, -117, -116, -111, -104, -95, -86, -77, -67, -58, -49, -41, -33,
-27, -21, -15, -9, -5, -1, 4, 7, 10, 14, 17, 20, 22, 24, 27, 30, 32, 33, 34, 35,
36, 38, 39, 40, 41, 43, 44, 44, 46, 47, 50, 51, 53, 55, 60, 62, 66, 70, 73, 79,
83, 88, 93, 98, 104, 109, 114, 117, 119, 118, 116, 110, 99, 85, 64, 36, 0, -35,
-62, -82, -97, -107, -114, -117, -117, -116, -114, -111, -108, -105, -102, -98,
-94, -91, -89, -86, -84, -84, -82, -80, -81, -79, -80, -80, -80, -82, -82, -83,
-84, -84, -86, -87, -88, -89, -90, -90, -90, -90, -90, -89, -88, -87, -87, -84,
-81, -79, -75, -73, -69, -63, -59, -53, -49, -43, -38, -32, -26, -20, -14, -9,
-3, };