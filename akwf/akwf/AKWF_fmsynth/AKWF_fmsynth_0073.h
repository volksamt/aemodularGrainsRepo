#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0073

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 11, 15, 20, 24, 28, 32, 36,
41, 45, 51, 56, 60, 65, 70, 74, 80, 84, 87, 92, 95, 100, 103, 105, 109, 112,
113, 115, 116, 118, 119, 119, 118, 119, 118, 117, 117, 114, 112, 109, 108, 105,
102, 98, 96, 92, 88, 85, 81, 78, 74, 71, 66, 62, 59, 55, 51, 47, 43, 39, 37, 33,
29, 26, 22, 19, 16, 12, 9, 5, 2, -2, -5, -9, -11, -14, -18, -22, -24, -28, -30,
-34, -38, -41, -44, -46, -49, -52, -56, -59, -62, -64, -67, -69, -73, -75, -78,
-80, -82, -84, -86, -89, -90, -93, -94, -96, -97, -100, -101, -102, -104, -105,
-106, -107, -108, -108, -110, -110, -110, -112, -112, -111, -112, -112, -112,
-112, -113, -113, -112, -111, -111, -110, -111, -109, -109, -108, -107, -107,
-105, -105, -104, -103, -101, -101, -100, -99, -98, -97, -95, -94, -93, -92,
-91, -89, -89, -88, -87, -87, -86, -86, -84, -84, -84, -84, -84, -84, -83, -84,
-83, -84, -84, -85, -84, -85, -84, -84, -85, -85, -84, -84, -83, -83, -82, -81,
-79, -78, -76, -74, -72, -70, -67, -63, -60, -56, -53, -48, -43, -40, -35, -31,
-25, -19, -15, -10, -3, 2, 7, 12, 17, 23, 28, 32, 37, 41, 45, 50, 55, 58, 62,
65, 68, 71, 74, 77, 79, 82, 83, 86, 88, 90, 90, 92, 93, 94, 96, 96, 97, 98, 98,
97, 99, 99, 99, 99, 98, 98, 98, 98, 98, 97, 96, 96, 96, 95, 93, 93, 92, 92, 91,
89, 88, 88, 86, 85, 84, 83, 81, 80, 79, 77, 76, 74, 73, 72, 70, 69, 67, 66, 65,
63, 62, 62, 59, 60, 59, 56, 56, 56, 54, 54, 53, 54, 53, 53, 52, 52, 52, 54, 52,
53, 54, 54, 54, 55, 56, 57, 57, 59, 59, 60, 60, 62, 62, 63, 65, 66, 66, 67, 69,
70, 71, 71, 73, 73, 74, 75, 76, 76, 77, 78, 79, 79, 80, 80, 81, 81, 81, 82, 81,
82, 82, 81, 80, 79, 78, 78, 76, 75, 72, 71, 67, 65, 62, 59, 56, 52, 47, 44, 39,
35, 31, 26, 21, 16, 13, 7, 2, -3, -8, -12, -18, -22, -27, -32, -35, -39, -43,
-46, -49, -53, -54, -58, -59, -61, -63, -65, -66, -67, -68, -68, -68, -69, -69,
-69, -69, -69, -69, -68, -69, -69, -67, -67, -67, -66, -66, -65, -65, -64, -63,
-63, -61, -61, -60, -59, -59, -59, -57, -57, -56, -55, -55, -54, -53, -53, -52,
-51, -50, -48, -48, -47, -46, -45, -44, -42, -42, -40, -39, -38, -36, -36, -34,
-33, -32, -31, -31, -30, -29, -27, -26, -26, -24, -24, -23, -23, -22, -21, -21,
-21, -21, -20, -20, -20, -19, -20, -20, -20, -20, -20, -21, -20, -22, -21, -22,
-23, -23, -25, -25, -25, -27, -27, -27, -28, -28, -28, -28, -29, -29, -29, -29,
-29, -29, -29, -30, -28, -28, -27, -27, -26, -24, -23, -22, -21, -19, -17, -15,
-12, -11, -7, -5, -2, };