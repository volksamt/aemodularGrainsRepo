#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0027

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 12, 15, 18, 20, 23, 26, 29,
32, 34, 37, 40, 43, 45, 47, 49, 52, 53, 56, 57, 58, 60, 61, 62, 63, 65, 65, 66,
67, 68, 69, 68, 68, 69, 68, 69, 68, 67, 66, 66, 65, 64, 63, 62, 61, 60, 58, 56,
55, 53, 51, 48, 46, 44, 42, 39, 37, 35, 32, 30, 26, 24, 21, 18, 16, 13, 9, 6, 3,
0, -2, -6, -8, -12, -15, -18, -22, -26, -29, -33, -37, -42, -47, -51, -55, -62,
-67, -72, -79, -84, -91, -96, -101, -106, -112, -116, -118, -119, -118, -116,
-109, -100, -87, -69, -45, -15, 18, 45, 66, 81, 91, 97, 101, 100, 99, 95, 89,
83, 76, 69, 61, 52, 45, 38, 30, 22, 16, 9, 4, -2, -8, -14, -20, -27, -33, -40,
-47, -55, -62, -71, -79, -88, -96, -103, -109, -114, -118, -119, -116, -109,
-97, -77, -50, -15, 23, 52, 74, 88, 96, 100, 101, 97, 93, 88, 80, 72, 65, 56,
49, 40, 32, 26, 18, 12, 6, 0, -6, -10, -17, -23, -29, -35, -41, -47, -54, -61,
-70, -76, -83, -91, -97, -103, -109, -113, -117, -118, -119, -116, -111, -102,
-90, -74, -54, -28, 1, 28, 49, 65, 77, 88, 93, 98, 101, 101, 101, 98, 96, 93,
90, 85, 80, 76, 71, 67, 62, 58, 53, 49, 45, 41, 37, 34, 30, 28, 25, 22, 19, 16,
15, 11, 9, 8, 5, 4, 2, 0, -2, -3, -5, -5, -6, -8, -9, -10, -10, -11, -13, -13,
-13, -14, -14, -14, -15, -16, -15, -16, -15, -15, -15, -14, -13, -13, -12, -12,
-11, -11, -9, -8, -6, -6, -3, -3, -1, 1, 3, 4, 7, 8, 11, 13, 15, 18, 21, 24, 27,
30, 33, 37, 41, 45, 49, 54, 58, 62, 68, 72, 78, 82, 86, 90, 95, 97, 100, 100,
100, 99, 95, 87, 76, 62, 42, 17, -14, -44, -68, -87, -101, -111, -116, -118,
-118, -116, -112, -106, -100, -92, -84, -76, -67, -58, -52, -44, -37, -28, -22,
-16, -10, -3, 3, 11, 18, 26, 34, 44, 53, 62, 72, 82, 90, 97, 101, 101, 95, 83,
63, 30, -16, -58, -87, -106, -116, -119, -117, -111, -103, -93, -83, -71, -60,
-50, -41, -32, -23, -15, -7, 2, 9, 19, 28, 39, 50, 61, 72, 83, 92, 98, 101, 97,
86, 64, 27, -23, -67, -95, -112, -119, -118, -113, -105, -94, -84, -72, -61,
-50, -40, -31, -22, -14, -5, 2, 11, 20, 30, 40, 50, 62, 73, 84, 92, 99, 101, 97,
87, 67, 37, -10, -56, -86, -106, -116, -119, -117, -112, -104, -95, -84, -74,
-64, -55, -45, -36, -30, -21, -15, -7, -1, 6, 14, 22, 29, 38, 47, 56, 65, 74,
83, 90, 96, 99, 100, 99, 93, 82, 67, 45, 14, -22, -54, -77, -95, -107, -115,
-118, -119, -118, -114, -110, -105, -99, -93, -86, -80, -74, -68, -61, -56, -52,
-46, -41, -36, -32, -27, -24, -20, -17, -13, -10, -7, -3, 0, };