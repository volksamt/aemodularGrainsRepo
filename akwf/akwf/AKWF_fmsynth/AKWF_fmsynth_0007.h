#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 6, 8, 10, 12, 15, 18, 21, 23,
26, 28, 32, 34, 37, 39, 43, 45, 49, 50, 54, 56, 59, 61, 63, 67, 69, 71, 74, 77,
78, 81, 82, 85, 88, 90, 92, 94, 96, 98, 99, 101, 103, 104, 106, 108, 109, 110,
112, 112, 114, 114, 115, 116, 116, 118, 118, 119, 118, 119, 119, 119, 119, 119,
119, 118, 117, 117, 116, 115, 114, 113, 112, 111, 108, 107, 106, 104, 101, 99,
98, 96, 93, 91, 88, 86, 83, 80, 76, 74, 71, 68, 65, 61, 58, 55, 52, 47, 44, 40,
37, 32, 28, 25, 21, 18, 13, 11, 6, 3, 0, -6, -9, -13, -17, -20, -24, -28, -31,
-35, -39, -42, -46, -50, -53, -57, -61, -63, -66, -69, -72, -75, -77, -80, -82,
-85, -87, -89, -90, -93, -94, -96, -97, -99, -100, -100, -101, -102, -103, -103,
-103, -104, -104, -104, -103, -103, -101, -100, -100, -99, -98, -97, -95, -94,
-92, -90, -89, -86, -83, -82, -79, -77, -75, -72, -69, -67, -63, -61, -58, -55,
-51, -48, -44, -41, -38, -35, -31, -28, -24, -20, -18, -14, -10, -6, -3, 1, 4,
8, 11, 15, 19, 23, 26, 29, 32, 36, 39, 43, 45, 49, 52, 55, 58, 61, 65, 67, 70,
72, 75, 78, 81, 83, 85, 88, 91, 93, 94, 97, 98, 100, 101, 103, 105, 106, 108,
109, 110, 111, 112, 113, 114, 115, 116, 116, 117, 117, 118, 118, 118, 119, 119,
119, 119, 119, 118, 119, 119, 117, 117, 116, 115, 116, 114, 114, 113, 112, 111,
110, 109, 108, 107, 106, 105, 104, 103, 101, 99, 98, 97, 94, 94, 92, 91, 89, 88,
85, 83, 82, 80, 79, 77, 74, 73, 71, 69, 67, 66, 64, 62, 60, 58, 56, 54, 52, 50,
48, 46, 44, 42, 39, 38, 36, 35, 32, 30, 28, 26, 24, 23, 20, 18, 16, 15, 13, 11,
9, 7, 5, 5, 2, 0, -1, -4, -5, -8, -9, -10, -12, -15, -16, -19, -19, -22, -23,
-25, -27, -29, -30, -32, -33, -35, -37, -39, -40, -41, -43, -45, -46, -48, -49,
-50, -53, -55, -56, -56, -59, -60, -61, -63, -63, -64, -66, -68, -68, -70, -70,
-73, -73, -74, -76, -76, -78, -79, -79, -81, -82, -83, -84, -85, -86, -87, -88,
-88, -90, -90, -91, -91, -93, -93, -94, -95, -95, -96, -96, -97, -97, -98, -98,
-99, -99, -99, -101, -101, -102, -102, -102, -103, -102, -102, -102, -104, -103,
-104, -103, -104, -104, -104, -104, -104, -103, -103, -103, -103, -103, -103,
-104, -103, -103, -102, -102, -102, -101, -101, -101, -100, -100, -100, -99,
-98, -98, -97, -97, -97, -95, -94, -93, -93, -92, -92, -91, -90, -89, -88, -87,
-86, -85, -85, -82, -82, -81, -80, -78, -77, -75, -74, -72, -72, -70, -69, -67,
-66, -63, -63, -61, -59, -57, -56, -54, -52, -49, -49, -46, -44, -42, -40, -38,
-36, -34, -31, -29, -27, -24, -23, -20, -18, -15, -13, -10, -8, -6, -3, 0, };