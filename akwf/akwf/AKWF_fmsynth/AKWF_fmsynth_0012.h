#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 6, 7, 9, 11, 12, 13, 15, 16,
18, 19, 20, 22, 23, 25, 25, 27, 28, 29, 30, 31, 33, 33, 34, 35, 37, 38, 39, 40,
41, 42, 43, 43, 44, 44, 45, 46, 47, 48, 48, 49, 49, 50, 50, 51, 51, 51, 53, 53,
52, 53, 54, 54, 54, 55, 55, 55, 55, 56, 56, 56, 56, 57, 56, 56, 57, 57, 57, 57,
57, 57, 57, 59, 58, 58, 58, 57, 58, 58, 58, 58, 58, 58, 58, 57, 59, 58, 58, 58,
58, 58, 59, 58, 59, 57, 57, 58, 58, 58, 58, 57, 58, 57, 57, 58, 56, 57, 57, 57,
56, 57, 56, 56, 56, 56, 56, 54, 55, 55, 55, 54, 54, 54, 54, 54, 52, 53, 52, 52,
51, 51, 50, 51, 50, 49, 48, 49, 48, 47, 46, 46, 46, 44, 44, 44, 43, 43, 42, 41,
40, 40, 39, 39, 37, 37, 36, 36, 34, 33, 33, 33, 31, 31, 30, 29, 28, 28, 26, 25,
25, 24, 22, 22, 21, 20, 19, 18, 17, 17, 16, 15, 14, 12, 11, 11, 10, 9, 8, 8, 7,
6, 5, 3, 2, 2, 0, 1, -1, -1, -2, -3, -3, -5, -5, -6, -8, -9, -9, -10, -10, -12,
-12, -14, -14, -15, -15, -17, -17, -17, -19, -19, -20, -21, -21, -22, -23, -23,
-24, -24, -25, -26, -26, -27, -28, -28, -28, -29, -29, -31, -31, -31, -32, -33,
-33, -33, -34, -35, -34, -35, -36, -35, -36, -36, -37, -37, -37, -38, -38, -39,
-38, -39, -39, -39, -39, -40, -39, -40, -39, -40, -40, -41, -41, -41, -40, -41,
-40, -40, -41, -40, -40, -39, -40, -40, -40, -39, -39, -39, -38, -39, -38, -38,
-38, -38, -37, -37, -36, -36, -35, -34, -34, -34, -33, -34, -32, -32, -31, -31,
-30, -29, -30, -28, -28, -28, -26, -25, -26, -24, -23, -23, -22, -22, -20, -19,
-18, -18, -17, -15, -15, -14, -13, -12, -10, -9, -8, -8, -6, -5, -4, -3, -2, 0,
1, 2, 3, 4, 7, 7, 8, 10, 11, 12, 14, 15, 17, 18, 20, 22, 22, 24, 26, 27, 28, 29,
31, 33, 35, 35, 38, 39, 40, 41, 42, 44, 46, 47, 48, 50, 51, 52, 54, 54, 54, 55,
57, 57, 57, 58, 59, 59, 59, 59, 59, 58, 58, 56, 55, 54, 53, 52, 49, 46, 43, 42,
38, 34, 30, 25, 21, 16, 10, 3, -3, -11, -19, -27, -35, -44, -52, -59, -67, -73,
-79, -84, -89, -93, -97, -100, -103, -106, -110, -111, -113, -115, -116, -117,
-118, -119, -119, -119, -119, -119, -118, -118, -118, -116, -115, -114, -113,
-112, -110, -108, -107, -106, -104, -103, -101, -99, -97, -95, -93, -91, -89,
-87, -85, -83, -80, -78, -77, -75, -72, -71, -68, -66, -65, -62, -61, -59, -57,
-55, -52, -51, -49, -48, -46, -43, -42, -39, -38, -36, -34, -32, -31, -29, -27,
-25, -24, -21, -20, -18, -16, -15, -13, -12, -9, -7, -6, -5, -4, -2, 0, };