#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0110

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 11, 20, 29, 37, 44, 52, 59, 65, 71,
77, 82, 86, 90, 94, 97, 100, 103, 105, 108, 111, 112, 114, 115, 117, 117, 118,
119, 119, 119, 119, 118, 118, 117, 117, 116, 115, 113, 113, 111, 109, 109, 106,
105, 103, 102, 99, 99, 96, 94, 92, 90, 89, 86, 83, 82, 80, 77, 76, 74, 71, 69,
67, 66, 65, 62, 61, 58, 56, 55, 53, 51, 50, 48, 46, 45, 43, 42, 41, 39, 37, 35,
34, 33, 31, 30, 29, 28, 26, 25, 23, 23, 22, 20, 20, 19, 18, 17, 16, 15, 15, 13,
13, 12, 11, 10, 8, 8, 8, 6, 6, 5, 4, 4, 3, 2, 2, 2, 1, 1, 0, 0, 0, 0, -2, -2,
-2, -2, -3, -2, -3, -4, -4, -5, -5, -4, -5, -5, -6, -5, -4, -5, -4, -4, -4, -4,
-4, -4, -3, -3, -3, -3, -2, -2, -2, -1, -2, 0, -1, -1, 1, 1, 1, 1, 2, 3, 4, 4,
5, 6, 6, 8, 8, 10, 10, 11, 12, 13, 14, 15, 17, 17, 18, 20, 20, 21, 22, 24, 24,
27, 27, 30, 31, 33, 34, 35, 36, 39, 41, 43, 45, 47, 49, 50, 52, 55, 57, 58, 61,
64, 65, 68, 71, 73, 75, 78, 79, 83, 85, 88, 91, 93, 96, 99, 102, 103, 106, 108,
111, 112, 114, 115, 116, 117, 117, 117, 117, 117, 117, 115, 114, 111, 107, 103,
99, 93, 86, 79, 69, 59, 46, 34, 19, 4, -13, -28, -41, -53, -63, -73, -81, -88,
-95, -101, -105, -109, -112, -114, -115, -116, -116, -115, -115, -114, -112,
-109, -107, -104, -102, -98, -95, -92, -88, -84, -82, -78, -74, -70, -67, -63,
-60, -56, -52, -49, -45, -42, -39, -35, -32, -29, -26, -23, -20, -17, -14, -12,
-8, -6, -3, -1, 1, 4, 6, 8, 11, 14, 17, 19, 22, 25, 28, 31, 34, 37, 41, 43, 47,
50, 54, 56, 60, 63, 66, 69, 73, 75, 79, 82, 85, 87, 91, 94, 98, 100, 103, 104,
108, 110, 112, 114, 115, 116, 117, 117, 118, 118, 117, 116, 115, 113, 111, 110,
106, 103, 100, 95, 91, 85, 80, 74, 67, 58, 51, 41, 32, 22, 10, -1, -11, -21,
-30, -40, -47, -53, -60, -65, -71, -76, -80, -84, -87, -91, -95, -97, -100,
-102, -104, -106, -107, -109, -111, -112, -113, -113, -115, -115, -115, -115,
-115, -116, -117, -116, -117, -116, -116, -116, -116, -116, -115, -116, -115,
-115, -116, -114, -114, -114, -114, -113, -114, -113, -114, -113, -113, -113,
-113, -112, -113, -112, -112, -112, -112, -112, -112, -112, -112, -112, -112,
-112, -112, -112, -112, -112, -113, -113, -112, -113, -113, -113, -114, -114,
-115, -114, -115, -114, -115, -115, -116, -116, -116, -116, -115, -115, -114,
-115, -115, -115, -115, -114, -114, -113, -113, -113, -112, -112, -111, -110,
-108, -108, -106, -104, -102, -100, -98, -95, -94, -90, -87, -83, -80, -77, -74,
-69, -64, -60, -55, -50, -44, -36, -31, -23, -14, -5, };