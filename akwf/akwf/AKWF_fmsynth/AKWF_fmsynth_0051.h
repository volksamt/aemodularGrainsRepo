#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0051

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 30, 47, 63, 77, 88, 99, 105, 111,
115, 117, 119, 118, 119, 119, 118, 117, 118, 118, 118, 118, 118, 119, 119, 118,
117, 115, 111, 105, 100, 92, 83, 72, 61, 48, 36, 22, 9, -5, -17, -29, -39, -49,
-57, -63, -70, -74, -78, -81, -81, -82, -82, -79, -77, -72, -67, -60, -53, -42,
-31, -18, -3, 11, 27, 44, 60, 75, 89, 101, 109, 116, 119, 118, 114, 108, 97, 86,
72, 58, 43, 28, 14, 2, -9, -18, -28, -34, -40, -44, -46, -48, -48, -46, -43,
-38, -33, -26, -18, -8, 1, 9, 21, 34, 47, 59, 72, 83, 93, 101, 108, 114, 117,
118, 120, 118, 116, 114, 112, 109, 106, 103, 101, 101, 100, 100, 101, 102, 105,
108, 111, 114, 117, 119, 118, 119, 116, 109, 103, 91, 78, 62, 44, 24, 4, -15,
-36, -55, -72, -86, -99, -107, -114, -118, -119, -119, -117, -114, -110, -106,
-103, -100, -97, -95, -95, -93, -95, -97, -99, -102, -105, -108, -112, -115,
-117, -119, -118, -117, -115, -111, -105, -97, -88, -77, -65, -53, -40, -28,
-16, -6, 4, 13, 20, 27, 32, 36, 38, 39, 40, 38, 33, 29, 23, 14, 5, -5, -16, -29,
-43, -56, -72, -85, -96, -106, -114, -118, -119, -117, -110, -101, -90, -77,
-62, -46, -29, -12, 4, 19, 32, 44, 54, 63, 71, 76, 81, 85, 87, 88, 88, 88, 86,
83, 79, 74, 68, 60, 53, 43, 31, 20, 7, -5, -19, -33, -47, -59, -70, -81, -90,
-98, -104, -109, -113, -116, -117, -118, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -116, -113, -110, -105, -98, -89, -78, -64, -47,
-32, -13, 6, 26, 44, 62, 78, 91, 103, 111, 116, 119, 119, 116, 112, 107, 99, 93,
85, 77, 71, 66, 62, 59, 57, 56, 58, 60, 63, 68, 74, 79, 86, 92, 98, 105, 111,
115, 117, 120, 119, 116, 113, 108, 102, 92, 85, 75, 66, 56, 48, 41, 33, 26, 21,
16, 14, 13, 13, 15, 18, 22, 28, 35, 43, 53, 62, 73, 83, 94, 102, 109, 115, 119,
120, 115, 109, 100, 86, 71, 52, 34, 16, -4, -21, -38, -54, -67, -80, -89, -97,
-103, -107, -111, -112, -115, -115, -116, -116, -116, -115, -114, -112, -110,
-106, -102, -97, -90, -82, -72, -61, -49, -34, -20, -7, 7, 22, 36, 49, 61, 71,
81, 89, 95, 101, 106, 108, 110, 112, 113, 114, 113, 113, 112, 110, 108, 104, 99,
93, 85, 75, 65, 50, 35, 17, 0, -18, -37, -55, -73, -88, -100, -110, -116, -120,
-119, -115, -108, -101, -92, -81, -71, -59, -47, -38, -30, -22, -16, -11, -8,
-5, -5, -6, -8, -11, -15, -21, -29, -38, -46, -56, -65, -75, -85, -92, -101,
-108, -112, -117, -119, -119, -117, -114, -111, -105, -100, -94, -88, -81, -76,
-71, -68, -66, -65, -64, -67, -68, -72, -78, -82, -89, -96, -102, -108, -114,
-117, -119, -119, -115, -110, -101, -89, -76, -60, -42, -23, -5, };