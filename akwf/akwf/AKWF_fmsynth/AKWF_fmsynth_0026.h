#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0026

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 15, 27, 38, 46, 54, 58, 61, 63, 62,
60, 57, 52, 44, 35, 24, 12, -2, -17, -34, -53, -74, -94, -111, -118, -105, -45,
56, 110, 114, 96, 62, 29, -8, -44, -84, -111, -114, -25, 97, 115, 88, 45, 1,
-43, -87, -117, -93, 43, 119, 98, 59, 10, -32, -80, -112, -108, 11, 111, 109,
76, 33, -9, -50, -90, -116, -109, -19, 91, 116, 104, 75, 43, 12, -17, -44, -70,
-93, -111, -118, -113, -89, -46, 14, 61, 89, 104, 111, 115, 117, 117, 117, 117,
116, 117, 115, 114, 108, 98, 77, 43, -16, -70, -103, -118, -116, -103, -82, -56,
-28, 1, 32, 62, 96, 114, 107, 16, -96, -118, -95, -57, -13, 27, 73, 107, 110,
-3, -113, -109, -69, -20, 27, 76, 113, 95, -47, -121, -94, -50, 0, 48, 93, 118,
54, -89, -117, -87, -44, 2, 44, 88, 113, 102, -9, -107, -115, -94, -60, -25, 8,
39, 68, 95, 113, 116, 94, 40, -40, -89, -112, -118, -116, -111, -104, -96, -89,
-85, -80, -78, -77, -78, -80, -84, -91, -97, -105, -112, -117, -118, -111, -88,
-35, 43, 95, 115, 113, 95, 70, 40, 9, -23, -55, -90, -113, -114, -34, 84, 118,
97, 60, 16, -24, -70, -105, -120, -30, 98, 114, 83, 36, -9, -56, -96, -120, -59,
79, 118, 89, 48, 3, -38, -83, -112, -112, -14, 98, 115, 94, 59, 23, -11, -45,
-77, -105, -118, -108, -55, 37, 97, 115, 115, 104, 90, 74, 60, 46, 35, 24, 16,
9, 4, 1, -1, -1, 2, 5, 10, 18, 27, 37, 50, 64, 79, 95, 108, 117, 111, 82, 1,
-82, -115, -115, -92, -62, -29, 7, 42, 79, 109, 114, 34, -93, -118, -92, -49,
-4, 41, 87, 117, 79, -66, -120, -90, -44, 5, 56, 98, 117, 24, -107, -111, -73,
-22, 22, 72, 108, 109, -3, -112, -111, -77, -34, 6, 48, 87, 113, 110, 35, -79,
-118, -112, -88, -58, -31, -4, 21, 45, 67, 87, 102, 113, 117, 115, 107, 92, 76,
60, 43, 32, 25, 25, 31, 42, 58, 75, 91, 105, 114, 117, 113, 103, 88, 70, 48, 25,
0, -25, -54, -81, -108, -117, -99, -4, 97, 116, 98, 63, 24, -15, -57, -96, -119,
-84, 49, 118, 100, 61, 13, -30, -77, -111, -109, 10, 113, 105, 70, 21, -20, -69,
-104, -119, -46, 85, 116, 95, 56, 18, -22, -59, -95, -116, -111, -43, 65, 112,
115, 98, 73, 49, 23, 1, -19, -38, -56, -71, -86, -97, -105, -111, -116, -118,
-118, -118, -120, -118, -118, -117, -115, -111, -105, -96, -85, -69, -54, -35,
-16, 6, 28, 54, 78, 102, 116, 107, 40, -72, -116, -112, -81, -45, -4, 34, 77,
108, 113, 15, -107, -113, -80, -31, 12, 65, 102, 116, 6, -114, -107, -67, -15,
32, 81, 115, 85, -58, -122, -93, -50, -1, 42, 88, 115, 91, -39, -117, -108, -77,
-36, 0, 39, 72, 104, 116, 99, 18, -77, -114, -117, -104, -85, -65, -44, -27, -8,
};