#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 27, 45, 62, 77, 89, 99, 106, 112,
117, 118, 118, 119, 119, 118, 116, 116, 115, 115, 115, 115, 115, 116, 117, 117,
117, 118, 119, 118, 119, 119, 118, 118, 118, 116, 117, 116, 116, 116, 117, 117,
118, 118, 119, 119, 117, 115, 113, 106, 98, 88, 75, 58, 40, 20, -1, -24, -45,
-66, -84, -100, -110, -116, -118, -114, -107, -97, -83, -69, -53, -37, -21, -6,
9, 22, 34, 43, 51, 58, 63, 67, 71, 73, 74, 73, 73, 73, 70, 68, 65, 62, 59, 54,
51, 47, 43, 39, 36, 34, 31, 29, 29, 29, 31, 34, 38, 42, 48, 55, 62, 71, 80, 89,
98, 105, 112, 116, 118, 117, 113, 105, 93, 78, 60, 39, 17, -5, -25, -46, -66,
-81, -95, -104, -112, -115, -118, -117, -116, -115, -111, -109, -105, -103,
-100, -99, -97, -97, -97, -98, -100, -101, -103, -105, -107, -110, -112, -114,
-115, -116, -117, -118, -118, -118, -118, -117, -117, -118, -117, -117, -118,
-118, -117, -116, -116, -113, -110, -105, -98, -88, -77, -64, -48, -31, -12, 9,
29, 50, 67, 84, 98, 109, 116, 119, 118, 113, 105, 94, 81, 67, 53, 39, 25, 12, 2,
-7, -17, -24, -29, -34, -37, -39, -41, -41, -41, -39, -37, -33, -29, -27, -23,
-18, -13, -9, -6, -2, 1, 3, 5, 5, 4, 4, 1, -2, -8, -13, -21, -30, -40, -51, -63,
-74, -86, -96, -105, -113, -116, -118, -114, -107, -96, -81, -63, -43, -20, 1,
24, 45, 63, 80, 94, 105, 112, 117, 119, 119, 116, 114, 109, 105, 101, 96, 93,
91, 87, 87, 87, 86, 87, 88, 91, 94, 97, 99, 102, 105, 107, 109, 111, 113, 115,
114, 116, 116, 117, 117, 116, 115, 115, 114, 112, 109, 104, 100, 93, 85, 75, 61,
48, 31, 14, -5, -24, -44, -63, -81, -95, -106, -114, -117, -118, -114, -106,
-97, -84, -72, -57, -44, -29, -17, -4, 6, 16, 23, 31, 36, 41, 42, 45, 45, 46,
43, 42, 40, 35, 31, 27, 22, 16, 10, 5, 0, -5, -10, -14, -17, -21, -22, -24, -23,
-22, -19, -16, -10, -5, 3, 12, 23, 34, 46, 60, 72, 84, 97, 106, 113, 119, 118,
114, 106, 94, 78, 58, 36, 14, -8, -30, -50, -68, -84, -97, -106, -112, -116,
-118, -118, -117, -115, -112, -109, -107, -104, -103, -102, -101, -101, -101,
-102, -103, -104, -106, -107, -109, -109, -111, -113, -114, -114, -115, -115,
-117, -116, -116, -115, -115, -114, -113, -111, -109, -106, -101, -95, -85, -77,
-64, -50, -35, -18, 2, 21, 41, 60, 78, 93, 104, 114, 118, 119, 115, 107, 95, 81,
65, 47, 30, 13, -1, -16, -29, -41, -51, -58, -66, -71, -74, -78, -80, -80, -79,
-78, -77, -75, -71, -68, -64, -59, -53, -48, -42, -36, -31, -25, -21, -16, -13,
-11, -8, -8, -9, -11, -14, -17, -23, -30, -39, -49, -58, -69, -80, -91, -100,
-108, -113, -116, -117, -113, -107, -96, -83, -67, -48, -29, -8, };