#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0063

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 9, 14, 17, 23, 27, 33, 38,
43, 47, 52, 57, 62, 67, 71, 73, 76, 79, 81, 82, 84, 85, 85, 85, 85, 85, 84, 83,
83, 82, 82, 81, 81, 80, 81, 82, 83, 84, 85, 87, 89, 92, 95, 98, 101, 104, 106,
109, 111, 113, 115, 116, 118, 118, 119, 119, 119, 120, 118, 119, 119, 118, 119,
119, 119, 119, 119, 119, 118, 119, 119, 118, 119, 119, 119, 119, 119, 118, 118,
118, 118, 117, 115, 113, 110, 108, 104, 101, 96, 91, 86, 80, 75, 69, 64, 58, 55,
50, 47, 44, 43, 43, 42, 43, 44, 44, 47, 48, 48, 50, 50, 52, 52, 51, 49, 47, 45,
40, 35, 29, 22, 14, 3, -7, -18, -28, -38, -48, -57, -64, -71, -77, -83, -87,
-90, -94, -95, -97, -98, -100, -101, -100, -100, -100, -100, -99, -98, -98, -96,
-96, -95, -95, -96, -96, -97, -99, -100, -103, -105, -107, -109, -112, -114,
-116, -117, -119, -118, -119, -119, -118, -118, -117, -116, -116, -114, -113,
-112, -112, -112, -111, -110, -110, -111, -110, -111, -112, -112, -113, -112,
-113, -113, -112, -112, -112, -111, -111, -110, -108, -107, -105, -102, -100,
-97, -92, -89, -86, -81, -77, -73, -69, -64, -60, -56, -54, -52, -49, -48, -45,
-45, -44, -44, -44, -44, -45, -46, -47, -47, -48, -49, -49, -49, -48, -47, -46,
-46, -43, -41, -37, -33, -29, -25, -21, -15, -10, -5, 2, 8, 13, 18, 22, 27, 32,
35, 39, 41, 43, 45, 45, 46, 46, 46, 46, 45, 45, 44, 43, 41, 41, 42, 41, 42, 41,
43, 44, 47, 49, 52, 55, 59, 62, 66, 72, 75, 80, 84, 89, 92, 95, 98, 101, 104,
105, 108, 109, 109, 111, 110, 111, 112, 112, 111, 111, 111, 110, 111, 110, 109,
109, 109, 109, 110, 109, 111, 111, 112, 113, 114, 115, 117, 118, 118, 119, 119,
119, 119, 118, 116, 115, 113, 110, 108, 107, 104, 102, 101, 100, 99, 99, 99, 99,
99, 100, 100, 101, 102, 102, 102, 103, 102, 102, 102, 100, 99, 98, 96, 93, 89,
84, 80, 74, 66, 60, 51, 41, 32, 22, 12, 1, -9, -17, -24, -31, -35, -39, -43,
-44, -46, -46, -47, -46, -45, -43, -41, -40, -39, -37, -37, -37, -38, -38, -41,
-42, -46, -50, -55, -61, -66, -72, -78, -84, -89, -95, -99, -103, -107, -109,
-111, -114, -116, -116, -117, -118, -118, -119, -119, -119, -118, -119, -119,
-119, -119, -118, -118, -118, -118, -119, -118, -118, -118, -119, -118, -118,
-119, -119, -119, -119, -118, -117, -118, -115, -113, -112, -110, -107, -104,
-102, -99, -96, -94, -92, -89, -88, -86, -84, -84, -84, -83, -83, -84, -85, -85,
-85, -85, -86, -87, -88, -87, -88, -86, -85, -85, -83, -81, -78, -75, -72, -69,
-64, -60, -55, -50, -44, -39, -34, -29, -24, -19, -15, -12, -8, -5, -3, -1, 0,
0, 2, 1, 0, 0, 0, -2, -2, -2, -4, -4, -5, -4, -4, -3, -1, };