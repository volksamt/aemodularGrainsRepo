#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0034

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 41, 65, 84, 99, 110, 117, 119,
118, 115, 110, 105, 100, 95, 91, 89, 88, 89, 89, 92, 97, 102, 107, 111, 115,
119, 119, 116, 111, 101, 86, 68, 46, 20, -7, -35, -60, -83, -102, -114, -119,
-116, -104, -85, -59, -30, 1, 30, 57, 80, 98, 110, 117, 119, 117, 112, 105, 96,
88, 78, 71, 64, 59, 55, 52, 51, 53, 56, 61, 68, 75, 84, 93, 102, 110, 116, 119,
117, 111, 98, 80, 56, 26, -7, -40, -71, -96, -112, -119, -114, -98, -74, -43,
-9, 27, 59, 87, 107, 117, 118, 110, 93, 69, 41, 13, -16, -41, -64, -82, -96,
-106, -112, -116, -119, -119, -119, -118, -118, -117, -117, -118, -118, -119,
-119, -118, -118, -115, -110, -101, -90, -75, -57, -33, -7, 18, 46, 72, 93, 108,
118, 119, 112, 98, 78, 53, 24, -5, -34, -60, -82, -101, -112, -118, -118, -113,
-105, -93, -78, -63, -47, -32, -19, -7, 2, 10, 15, 19, 20, 19, 16, 11, 3, -7,
-19, -32, -48, -64, -80, -94, -107, -115, -119, -117, -108, -92, -70, -42, -10,
23, 54, 82, 103, 116, 119, 109, 88, 57, 21, -16, -53, -82, -103, -116, -120,
-114, -101, -83, -62, -39, -17, 5, 25, 43, 58, 71, 80, 89, 95, 98, 102, 103,
103, 102, 101, 99, 94, 88, 81, 71, 60, 44, 28, 9, -12, -33, -55, -76, -94, -108,
-116, -119, -114, -102, -81, -54, -23, 9, 41, 70, 93, 108, 117, 119, 113, 103,
88, 70, 51, 32, 13, -7, -23, -37, -49, -60, -67, -73, -77, -80, -82, -81, -80,
-77, -72, -65, -56, -45, -30, -15, 3, 23, 42, 64, 84, 100, 112, 119, 118, 108,
89, 62, 27, -9, -45, -79, -102, -116, -118, -110, -90, -63, -33, 1, 34, 64, 89,
105, 115, 119, 115, 105, 91, 74, 55, 35, 17, 1, -14, -26, -36, -45, -50, -53,
-55, -54, -52, -47, -41, -32, -21, -9, 6, 22, 41, 59, 78, 93, 106, 115, 119,
116, 108, 93, 73, 47, 19, -11, -40, -67, -90, -106, -117, -119, -115, -102, -84,
-62, -37, -12, 13, 36, 55, 72, 87, 97, 105, 110, 115, 115, 118, 118, 119, 118,
119, 118, 117, 114, 111, 107, 99, 89, 75, 57, 37, 12, -13, -40, -65, -89, -106,
-117, -119, -112, -94, -69, -39, -4, 31, 63, 91, 109, 118, 117, 103, 80, 50, 16,
-19, -52, -77, -99, -112, -118, -119, -114, -106, -95, -84, -72, -60, -49, -40,
-32, -26, -22, -19, -19, -21, -25, -30, -38, -47, -57, -69, -81, -92, -104,
-111, -117, -119, -116, -107, -93, -72, -45, -16, 16, 47, 73, 96, 111, 118, 117,
108, 93, 72, 49, 22, -4, -28, -52, -72, -88, -100, -110, -115, -118, -119, -118,
-116, -114, -112, -110, -108, -108, -108, -109, -112, -115, -116, -118, -118,
-118, -114, -108, -97, -82, -64, -41, -16, 12, 41, 67, 91, 109, 117, 117, 106,
85, 53, 16, -22, -59, -88, -109, -118, -116, -106, -86, -61, -31, -5, };