#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0108

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 8, 10, 12, 14, 15, 17, 19,
21, 23, 24, 26, 27, 28, 30, 32, 33, 34, 36, 37, 38, 38, 40, 41, 42, 43, 44, 45,
45, 46, 47, 47, 47, 48, 49, 49, 49, 49, 49, 50, 50, 50, 51, 51, 51, 51, 51, 51,
50, 51, 50, 50, 50, 49, 50, 50, 48, 49, 49, 49, 49, 48, 48, 48, 47, 47, 46, 46,
46, 46, 46, 45, 45, 45, 44, 44, 44, 43, 43, 42, 43, 43, 42, 43, 42, 42, 42, 41,
41, 41, 42, 41, 41, 41, 41, 41, 40, 41, 41, 42, 41, 41, 42, 41, 42, 42, 42, 42,
42, 42, 43, 43, 43, 43, 44, 44, 43, 44, 44, 44, 46, 45, 46, 46, 47, 47, 46, 46,
47, 48, 48, 48, 48, 48, 48, 49, 48, 49, 49, 49, 50, 49, 49, 50, 50, 50, 50, 50,
50, 51, 50, 49, 50, 49, 49, 50, 50, 49, 50, 50, 48, 49, 48, 48, 47, 47, 47, 46,
46, 45, 45, 44, 43, 43, 43, 43, 42, 41, 40, 39, 39, 38, 38, 37, 35, 35, 35, 33,
32, 32, 31, 30, 29, 29, 27, 25, 25, 24, 23, 21, 21, 19, 19, 17, 17, 16, 14, 13,
11, 10, 10, 9, 8, 7, 5, 4, 3, 1, 0, -1, -2, -3, -4, -5, -6, -6, -9, -9, -11,
-12, -12, -14, -14, -16, -17, -18, -19, -20, -21, -21, -22, -24, -25, -26, -27,
-28, -28, -29, -30, -30, -32, -33, -34, -34, -34, -35, -36, -37, -38, -38, -39,
-39, -39, -41, -42, -42, -42, -43, -43, -43, -43, -44, -45, -45, -45, -45, -46,
-46, -47, -47, -46, -46, -47, -47, -47, -47, -48, -47, -46, -48, -47, -46, -48,
-46, -47, -46, -46, -46, -46, -45, -45, -45, -45, -44, -44, -43, -43, -42, -42,
-41, -40, -40, -40, -38, -39, -38, -36, -36, -35, -34, -34, -33, -32, -31, -30,
-29, -27, -27, -25, -25, -24, -22, -21, -20, -19, -18, -16, -15, -14, -12, -11,
-10, -9, -8, -5, -4, -2, -1, -1, 1, 2, 5, 6, 7, 9, 10, 12, 14, 15, 18, 18, 19,
21, 23, 24, 25, 28, 29, 31, 32, 33, 34, 36, 36, 38, 39, 41, 41, 42, 44, 44, 46,
46, 46, 48, 48, 48, 50, 50, 49, 50, 51, 50, 49, 49, 49, 48, 48, 47, 46, 45, 44,
42, 40, 39, 37, 35, 34, 30, 28, 25, 21, 18, 14, 11, 7, 2, -3, -7, -12, -18, -23,
-30, -36, -43, -48, -54, -59, -65, -70, -74, -78, -83, -87, -90, -93, -96, -100,
-102, -105, -107, -110, -111, -113, -114, -115, -116, -117, -118, -118, -119,
-118, -119, -119, -118, -118, -118, -117, -116, -116, -114, -113, -111, -110,
-109, -108, -105, -104, -102, -100, -98, -95, -93, -91, -90, -87, -85, -82, -80,
-78, -75, -72, -70, -68, -65, -62, -59, -56, -53, -51, -48, -45, -44, -41, -38,
-36, -32, -30, -27, -25, -22, -20, -17, -15, -12, -9, -7, -6, -4, -1, };