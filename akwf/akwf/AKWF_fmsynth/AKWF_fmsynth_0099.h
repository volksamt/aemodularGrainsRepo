#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0099

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 10, 15, 18, 21, 24, 25, 29, 30,
32, 34, 35, 36, 38, 39, 40, 41, 43, 45, 47, 49, 51, 54, 56, 58, 61, 64, 68, 71,
75, 77, 81, 83, 86, 88, 91, 93, 94, 96, 99, 99, 100, 101, 103, 103, 103, 103,
103, 103, 103, 102, 102, 101, 100, 100, 100, 98, 99, 98, 98, 98, 99, 98, 99,
101, 102, 102, 104, 106, 107, 109, 110, 112, 114, 115, 116, 117, 119, 119, 120,
119, 119, 119, 117, 117, 116, 115, 114, 113, 112, 110, 110, 108, 108, 106, 105,
104, 103, 101, 100, 99, 97, 96, 94, 91, 89, 86, 82, 79, 75, 71, 66, 59, 54, 48,
42, 35, 28, 21, 14, 8, 1, -6, -12, -18, -22, -26, -31, -34, -36, -39, -40, -41,
-42, -42, -42, -41, -41, -40, -38, -37, -37, -35, -35, -34, -34, -33, -33, -34,
-35, -36, -38, -40, -43, -45, -48, -51, -55, -58, -62, -66, -69, -72, -76, -79,
-83, -85, -87, -90, -92, -94, -95, -97, -98, -98, -101, -101, -102, -101, -102,
-103, -104, -104, -106, -106, -107, -108, -109, -110, -111, -111, -113, -114,
-115, -116, -118, -118, -119, -119, -119, -119, -118, -116, -114, -112, -110,
-108, -104, -102, -99, -95, -93, -90, -87, -85, -81, -80, -77, -76, -73, -74,
-72, -71, -70, -69, -69, -68, -68, -67, -67, -66, -66, -65, -63, -62, -60, -59,
-57, -55, -52, -50, -47, -44, -41, -37, -33, -31, -27, -25, -21, -19, -16, -14,
-12, -10, -8, -6, -6, -4, -5, -4, -4, -5, -5, -5, -6, -6, -8, -7, -8, -8, -8,
-7, -6, -6, -4, -3, -1, 3, 6, 9, 14, 18, 23, 28, 33, 38, 44, 49, 54, 59, 65, 69,
75, 78, 83, 86, 89, 92, 95, 97, 100, 101, 103, 105, 106, 107, 108, 109, 110,
110, 111, 112, 113, 114, 115, 114, 115, 116, 117, 117, 118, 118, 120, 119, 119,
120, 118, 117, 118, 115, 115, 113, 111, 110, 109, 107, 104, 103, 102, 101, 99,
99, 97, 97, 97, 97, 97, 97, 98, 99, 100, 99, 101, 101, 102, 103, 103, 103, 103,
103, 103, 102, 102, 100, 99, 98, 96, 94, 92, 89, 87, 83, 79, 75, 71, 67, 63, 58,
53, 49, 45, 40, 36, 32, 29, 26, 21, 19, 16, 14, 11, 9, 7, 5, 2, -1, -2, -6, -9,
-12, -17, -20, -25, -29, -34, -39, -45, -51, -57, -63, -68, -74, -79, -84, -90,
-93, -97, -101, -106, -108, -110, -111, -114, -115, -116, -117, -118, -118,
-118, -119, -119, -118, -119, -118, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -120, -119, -119, -120, -119,
-118, -118, -117, -117, -116, -115, -114, -114, -112, -111, -111, -110, -109,
-108, -108, -107, -106, -106, -106, -105, -105, -105, -104, -105, -105, -104,
-104, -104, -104, -103, -104, -102, -101, -100, -98, -97, -94, -91, -89, -86,
-82, -78, -74, -70, -65, -59, -54, -48, -41, -35, -29, -23, -18, -12, -7, -1, };