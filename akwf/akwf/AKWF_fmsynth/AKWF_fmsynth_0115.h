#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0115

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 8, 15, 22, 30, 37, 44, 50, 57, 63,
69, 75, 79, 84, 90, 94, 97, 102, 105, 108, 110, 113, 115, 116, 117, 118, 118,
118, 119, 118, 118, 116, 115, 115, 113, 110, 109, 107, 104, 102, 99, 97, 94, 92,
89, 86, 84, 82, 79, 76, 74, 72, 69, 67, 64, 62, 60, 59, 57, 55, 53, 53, 52, 50,
50, 49, 47, 47, 47, 46, 46, 47, 47, 47, 48, 48, 49, 50, 50, 51, 53, 55, 56, 58,
60, 61, 62, 64, 67, 69, 70, 73, 75, 77, 80, 82, 85, 86, 89, 91, 94, 96, 99, 101,
102, 104, 106, 108, 109, 111, 112, 114, 115, 116, 117, 117, 118, 118, 118, 118,
118, 118, 116, 115, 115, 114, 112, 111, 108, 107, 105, 102, 100, 98, 96, 93, 90,
87, 84, 80, 78, 75, 72, 68, 65, 61, 58, 55, 51, 49, 45, 42, 38, 36, 34, 30, 28,
25, 22, 20, 17, 15, 12, 10, 9, 6, 5, 2, 2, -1, -1, -3, -4, -5, -5, -6, -7, -7,
-6, -6, -7, -6, -7, -5, -5, -4, -2, -2, -1, 1, 2, 4, 6, 9, 9, 12, 15, 17, 20,
23, 26, 29, 32, 35, 38, 42, 45, 48, 53, 57, 61, 64, 68, 71, 76, 80, 82, 86, 90,
94, 98, 100, 103, 106, 109, 110, 113, 114, 115, 116, 117, 117, 116, 117, 116,
115, 113, 110, 108, 105, 101, 97, 92, 88, 82, 76, 70, 64, 57, 50, 43, 36, 28,
21, 13, 6, -1, -10, -16, -24, -32, -39, -46, -53, -59, -67, -72, -79, -84, -89,
-93, -98, -101, -105, -108, -111, -114, -116, -116, -117, -118, -119, -119,
-119, -118, -118, -117, -116, -114, -112, -110, -108, -106, -103, -102, -99,
-96, -94, -91, -88, -86, -84, -81, -78, -76, -74, -71, -68, -66, -64, -62, -60,
-59, -56, -55, -53, -52, -50, -49, -48, -48, -46, -46, -47, -46, -44, -46, -45,
-45, -46, -46, -47, -47, -48, -49, -50, -51, -52, -53, -56, -57, -58, -61, -62,
-64, -65, -68, -70, -73, -74, -77, -79, -82, -84, -86, -88, -91, -93, -95, -98,
-99, -102, -104, -105, -107, -109, -111, -112, -114, -115, -115, -116, -117,
-118, -118, -118, -119, -118, -117, -117, -116, -115, -114, -113, -110, -109,
-107, -105, -104, -101, -99, -95, -93, -91, -87, -85, -81, -77, -74, -71, -67,
-64, -61, -58, -54, -50, -47, -44, -41, -38, -34, -32, -28, -26, -23, -20, -18,
-15, -12, -10, -8, -7, -5, -3, -1, 0, 2, 2, 4, 4, 4, 6, 6, 6, 6, 6, 7, 6, 5, 5,
5, 4, 3, 1, 1, -2, -2, -5, -6, -9, -11, -13, -16, -18, -21, -24, -27, -30, -33,
-37, -40, -45, -48, -52, -55, -60, -64, -68, -72, -75, -79, -83, -87, -90, -94,
-97, -100, -103, -106, -109, -111, -113, -114, -116, -117, -117, -117, -118,
-117, -116, -115, -113, -110, -107, -105, -102, -98, -93, -89, -84, -78, -73,
-67, -61, -55, -47, -42, -34, -27, -20, -12, -5, };