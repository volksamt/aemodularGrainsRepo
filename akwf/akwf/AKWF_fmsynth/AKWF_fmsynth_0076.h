#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0076

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 14, 20, 25, 32, 38, 43, 48, 54,
58, 63, 67, 72, 76, 80, 83, 87, 89, 92, 94, 97, 99, 101, 102, 103, 104, 105,
106, 106, 108, 108, 108, 108, 108, 108, 108, 107, 106, 107, 106, 105, 103, 103,
101, 100, 100, 99, 97, 95, 95, 93, 92, 90, 89, 88, 85, 83, 82, 80, 78, 76, 74,
72, 71, 69, 66, 65, 62, 60, 58, 57, 55, 52, 52, 50, 49, 46, 45, 43, 42, 42, 40,
39, 39, 37, 37, 37, 37, 37, 37, 37, 37, 38, 38, 39, 39, 40, 41, 42, 44, 44, 46,
48, 49, 50, 52, 53, 54, 56, 57, 60, 61, 63, 64, 65, 66, 67, 69, 70, 71, 73, 73,
75, 76, 77, 78, 80, 79, 80, 82, 81, 83, 83, 83, 84, 84, 84, 83, 84, 83, 83, 82,
80, 80, 77, 76, 74, 71, 68, 65, 62, 57, 53, 47, 42, 37, 31, 25, 18, 12, 5, -2,
-8, -15, -20, -26, -31, -37, -40, -45, -50, -53, -56, -60, -61, -63, -65, -67,
-67, -68, -68, -68, -68, -68, -67, -67, -65, -64, -63, -61, -59, -58, -56, -55,
-53, -52, -51, -48, -47, -45, -44, -42, -41, -38, -37, -37, -35, -33, -32, -31,
-30, -29, -28, -27, -25, -24, -23, -21, -20, -19, -18, -17, -16, -14, -13, -12,
-11, -9, -8, -7, -6, -5, -4, -3, -1, -1, 1, 1, 3, 4, 5, 6, 7, 7, 8, 9, 9, 9, 10,
11, 11, 11, 10, 11, 11, 11, 11, 10, 10, 10, 9, 9, 8, 8, 6, 5, 5, 3, 3, 1, 0, -1,
-2, -4, -5, -6, -7, -9, -10, -11, -13, -13, -15, -16, -17, -18, -19, -20, -20,
-21, -21, -22, -22, -22, -21, -21, -21, -19, -19, -17, -16, -15, -13, -11, -9,
-6, -3, 0, 3, 6, 10, 14, 17, 22, 26, 31, 35, 40, 45, 50, 55, 60, 65, 70, 75, 80,
85, 89, 93, 98, 101, 104, 106, 109, 112, 114, 115, 116, 117, 117, 116, 115, 113,
112, 109, 107, 104, 101, 97, 94, 89, 85, 80, 75, 70, 66, 60, 54, 51, 45, 39, 34,
29, 24, 19, 14, 10, 5, 1, -3, -7, -11, -14, -18, -23, -26, -29, -33, -35, -39,
-42, -45, -48, -50, -54, -57, -59, -61, -64, -66, -70, -72, -74, -77, -79, -81,
-83, -85, -87, -90, -92, -93, -95, -96, -98, -100, -101, -103, -104, -105, -106,
-107, -109, -109, -110, -111, -112, -113, -113, -114, -115, -115, -116, -116,
-116, -117, -118, -119, -119, -118, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -118, -118, -117, -117, -116, -115, -115, -114, -114, -113,
-110, -111, -109, -108, -105, -105, -104, -102, -100, -100, -98, -96, -96, -94,
-94, -92, -91, -90, -90, -89, -89, -87, -87, -87, -86, -86, -86, -86, -86, -86,
-86, -86, -86, -86, -86, -87, -85, -86, -84, -83, -83, -82, -81, -78, -76, -75,
-71, -68, -65, -62, -57, -54, -48, -43, -38, -33, -28, -21, -15, -10, -3, };