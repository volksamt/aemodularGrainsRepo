#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0082

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 8, 10, 11, 13, 13, 13, 13,
14, 14, 14, 15, 15, 18, 20, 22, 26, 32, 37, 42, 49, 56, 64, 71, 78, 86, 93, 97,
103, 108, 111, 113, 114, 114, 113, 112, 108, 104, 100, 96, 90, 86, 80, 75, 69,
65, 63, 58, 56, 55, 55, 55, 57, 59, 63, 67, 72, 78, 83, 90, 96, 101, 106, 111,
114, 117, 119, 120, 118, 116, 112, 107, 101, 95, 90, 82, 75, 69, 62, 56, 52, 47,
44, 41, 40, 40, 39, 42, 44, 46, 47, 51, 53, 56, 57, 58, 60, 60, 59, 59, 58, 55,
53, 50, 46, 42, 39, 34, 31, 27, 26, 22, 21, 19, 19, 19, 20, 22, 23, 25, 29, 31,
35, 39, 42, 43, 46, 46, 45, 44, 42, 38, 33, 27, 19, 11, 1, -7, -18, -28, -40,
-50, -59, -68, -76, -83, -90, -97, -101, -104, -107, -107, -108, -108, -105,
-103, -99, -95, -92, -87, -83, -79, -75, -70, -68, -65, -64, -64, -64, -64, -66,
-69, -72, -75, -79, -83, -88, -93, -97, -101, -106, -108, -110, -112, -112,
-113, -112, -111, -108, -107, -103, -100, -97, -93, -89, -86, -82, -78, -75,
-71, -67, -65, -62, -59, -58, -56, -55, -55, -55, -55, -55, -57, -57, -59, -61,
-62, -64, -64, -64, -65, -65, -63, -61, -58, -55, -51, -47, -42, -37, -32, -29,
-24, -21, -17, -13, -12, -12, -11, -12, -13, -16, -19, -23, -27, -32, -37, -41,
-47, -50, -54, -56, -59, -58, -58, -57, -54, -49, -44, -37, -30, -21, -11, -1,
10, 21, 31, 41, 51, 60, 69, 75, 81, 85, 88, 90, 89, 89, 87, 84, 81, 78, 74, 71,
67, 64, 63, 61, 59, 60, 61, 62, 64, 67, 70, 75, 78, 84, 87, 92, 96, 100, 102,
105, 107, 108, 109, 108, 106, 105, 101, 97, 94, 90, 85, 81, 77, 74, 70, 67, 66,
66, 65, 66, 69, 71, 74, 78, 82, 87, 92, 94, 99, 102, 104, 104, 104, 101, 99, 94,
89, 82, 76, 68, 60, 53, 44, 36, 29, 23, 18, 13, 10, 8, 6, 7, 9, 12, 15, 19, 24,
30, 35, 43, 48, 54, 59, 64, 69, 72, 74, 74, 75, 73, 72, 69, 63, 57, 52, 44, 37,
30, 22, 14, 6, -2, -8, -14, -20, -24, -28, -32, -34, -36, -39, -40, -40, -42,
-43, -43, -44, -44, -45, -47, -49, -50, -52, -55, -58, -61, -65, -69, -73, -78,
-83, -88, -93, -98, -103, -107, -110, -113, -115, -116, -115, -114, -111, -107,
-104, -99, -94, -89, -84, -79, -74, -69, -66, -62, -60, -60, -59, -60, -61, -64,
-67, -71, -76, -80, -85, -90, -96, -100, -104, -108, -112, -114, -116, -116,
-116, -114, -112, -109, -104, -98, -92, -85, -78, -70, -62, -53, -45, -37, -30,
-23, -18, -14, -9, -7, -7, -6, -8, -11, -14, -18, -23, -29, -35, -41, -47, -52,
-58, -62, -66, -69, -70, -70, -70, -69, -65, -63, -58, -53, -47, -41, -36, -30,
-24, -18, -12, -7, -2, };