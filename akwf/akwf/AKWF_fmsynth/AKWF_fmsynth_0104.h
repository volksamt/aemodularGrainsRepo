#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0104

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 9, 11, 14, 17, 20, 23, 24,
27, 30, 32, 36, 38, 40, 44, 45, 48, 50, 53, 56, 58, 60, 63, 65, 67, 69, 70, 73,
75, 76, 79, 79, 81, 83, 83, 85, 86, 87, 89, 90, 91, 92, 93, 93, 94, 95, 96, 96,
97, 97, 97, 98, 98, 98, 98, 99, 99, 100, 100, 99, 99, 100, 101, 101, 101, 101,
101, 103, 102, 102, 103, 103, 104, 104, 104, 105, 104, 106, 106, 106, 107, 107,
107, 108, 108, 110, 110, 111, 110, 111, 112, 113, 113, 114, 114, 115, 115, 116,
116, 117, 118, 118, 118, 118, 118, 119, 120, 119, 119, 119, 119, 118, 118, 118,
116, 117, 116, 114, 114, 113, 112, 111, 110, 107, 106, 105, 105, 102, 101, 100,
99, 98, 97, 95, 94, 92, 92, 91, 90, 90, 89, 89, 90, 91, 90, 90, 91, 92, 93, 94,
95, 97, 97, 99, 100, 102, 103, 105, 107, 108, 110, 110, 112, 113, 115, 115, 117,
117, 118, 119, 119, 119, 119, 119, 118, 118, 117, 116, 115, 114, 113, 111, 110,
108, 107, 104, 103, 101, 99, 97, 94, 93, 90, 88, 86, 83, 82, 79, 77, 75, 73, 71,
69, 67, 66, 64, 62, 60, 58, 57, 56, 54, 54, 52, 51, 50, 48, 48, 47, 46, 45, 45,
44, 43, 42, 42, 41, 41, 41, 39, 40, 40, 39, 38, 39, 39, 38, 39, 39, 39, 39, 39,
39, 39, 40, 40, 39, 40, 40, 40, 40, 40, 39, 41, 41, 40, 40, 41, 41, 41, 41, 40,
41, 41, 40, 41, 40, 41, 40, 41, 40, 39, 39, 39, 39, 38, 37, 37, 36, 36, 35, 35,
34, 34, 34, 32, 31, 31, 30, 28, 28, 27, 26, 25, 24, 23, 23, 21, 20, 20, 18, 17,
16, 16, 15, 14, 13, 11, 11, 11, 9, 8, 7, 7, 6, 5, 5, 3, 2, 2, 2, 0, 0, 0, 0, -2,
0, -2, -3, -3, -2, -2, -2, -2, -3, -1, -2, -2, -2, -1, 0, 0, 0, 1, 2, 3, 3, 4,
5, 6, 8, 9, 10, 11, 12, 13, 15, 16, 18, 20, 21, 23, 24, 27, 28, 31, 32, 36, 37,
39, 42, 45, 46, 50, 53, 55, 57, 61, 63, 66, 69, 73, 75, 78, 81, 83, 86, 90, 93,
95, 98, 100, 102, 104, 107, 108, 111, 112, 114, 115, 117, 117, 119, 119, 119,
119, 119, 118, 118, 117, 117, 114, 113, 111, 110, 107, 106, 103, 100, 98, 94,
92, 88, 84, 80, 76, 73, 68, 64, 59, 54, 49, 43, 38, 32, 26, 19, 13, 6, -1, -8,
-15, -22, -29, -35, -41, -47, -54, -58, -63, -69, -74, -79, -83, -88, -92, -95,
-100, -102, -106, -109, -110, -112, -114, -117, -117, -118, -119, -119, -119,
-119, -118, -116, -116, -114, -112, -110, -108, -106, -102, -99, -96, -93, -89,
-85, -83, -79, -75, -71, -68, -63, -60, -56, -52, -49, -45, -42, -38, -35, -31,
-28, -26, -22, -19, -16, -12, -10, -7, -4, -2, };