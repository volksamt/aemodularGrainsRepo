#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0090

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 4, 5, 6, 7, 9, 9, 10, 13, 15,
15, 17, 18, 20, 21, 23, 24, 26, 27, 29, 30, 32, 34, 36, 37, 39, 40, 43, 44, 45,
47, 49, 51, 52, 54, 56, 57, 58, 61, 62, 64, 65, 67, 69, 70, 73, 74, 76, 78, 79,
80, 82, 84, 85, 87, 89, 89, 91, 92, 95, 95, 97, 97, 98, 101, 102, 103, 104, 105,
106, 107, 108, 108, 110, 111, 112, 112, 113, 114, 114, 115, 115, 116, 117, 118,
117, 118, 118, 118, 118, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 118,
118, 117, 118, 117, 117, 116, 115, 115, 114, 115, 113, 112, 112, 112, 111, 110,
109, 109, 108, 107, 106, 106, 105, 104, 103, 102, 102, 100, 100, 98, 98, 97, 96,
96, 94, 93, 92, 92, 91, 90, 89, 88, 88, 87, 86, 85, 85, 83, 82, 82, 81, 80, 81,
79, 79, 78, 77, 77, 76, 76, 75, 75, 74, 73, 73, 72, 72, 71, 71, 71, 70, 70, 69,
69, 69, 68, 68, 67, 67, 66, 67, 67, 66, 66, 65, 64, 65, 64, 63, 63, 63, 63, 62,
62, 61, 61, 62, 61, 60, 60, 59, 59, 59, 58, 58, 58, 57, 57, 57, 55, 55, 54, 54,
53, 53, 52, 52, 51, 50, 50, 49, 48, 47, 46, 45, 45, 43, 42, 42, 41, 39, 39, 36,
36, 35, 33, 32, 30, 29, 27, 25, 24, 22, 20, 19, 16, 15, 12, 10, 8, 6, 3, 0, -2,
-4, -7, -10, -12, -15, -17, -20, -22, -25, -28, -30, -32, -35, -39, -41, -43,
-46, -48, -50, -53, -56, -58, -61, -63, -66, -68, -70, -72, -75, -77, -79, -80,
-83, -85, -88, -88, -90, -92, -94, -96, -97, -99, -100, -102, -104, -104, -106,
-107, -108, -109, -111, -112, -112, -113, -114, -114, -115, -116, -117, -116,
-117, -119, -118, -119, -118, -119, -119, -118, -119, -118, -118, -119, -119,
-117, -119, -117, -117, -116, -117, -116, -115, -115, -114, -114, -112, -112,
-112, -110, -110, -108, -107, -106, -105, -105, -103, -103, -101, -101, -100,
-99, -97, -96, -95, -94, -93, -91, -91, -90, -88, -88, -86, -86, -84, -83, -83,
-81, -80, -78, -78, -77, -76, -75, -74, -73, -71, -70, -69, -69, -67, -67, -66,
-65, -64, -63, -62, -61, -59, -59, -58, -58, -56, -56, -55, -54, -53, -52, -51,
-52, -51, -50, -50, -49, -48, -48, -47, -47, -46, -45, -45, -44, -45, -43, -43,
-43, -42, -42, -42, -41, -41, -40, -40, -40, -40, -39, -40, -38, -38, -39, -37,
-37, -37, -37, -37, -36, -36, -37, -36, -36, -35, -36, -35, -35, -35, -34, -34,
-34, -34, -33, -33, -32, -33, -32, -32, -31, -32, -32, -31, -31, -31, -31, -30,
-30, -29, -28, -29, -27, -28, -28, -27, -27, -26, -26, -25, -25, -24, -24, -23,
-23, -23, -22, -21, -21, -20, -19, -18, -18, -17, -16, -16, -15, -13, -12, -13,
-11, -11, -9, -9, -7, -7, -5, -4, -4, -2, -1, -1, };