#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0062

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 13, 18, 23, 29, 34, 40, 44, 50,
54, 59, 63, 68, 72, 76, 81, 84, 87, 90, 94, 97, 100, 102, 104, 107, 108, 109,
111, 114, 114, 115, 116, 117, 117, 117, 118, 118, 118, 119, 119, 119, 119, 118,
119, 119, 118, 118, 118, 118, 117, 118, 116, 116, 116, 116, 116, 116, 115, 116,
116, 116, 115, 115, 115, 115, 115, 115, 115, 116, 115, 116, 116, 116, 117, 116,
116, 117, 117, 117, 118, 117, 118, 118, 118, 118, 118, 119, 119, 118, 119, 119,
119, 120, 119, 118, 119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 120, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 119, 118, 118, 117, 116,
116, 116, 115, 114, 113, 112, 111, 110, 109, 106, 104, 103, 99, 96, 93, 89, 86,
81, 76, 72, 65, 59, 52, 45, 38, 29, 19, 9, -1, -13, -22, -32, -41, -49, -57,
-65, -73, -79, -85, -91, -96, -101, -105, -107, -111, -113, -115, -117, -118,
-119, -119, -119, -119, -117, -116, -115, -114, -112, -110, -108, -105, -102,
-99, -97, -94, -91, -88, -84, -81, -77, -74, -71, -68, -64, -60, -57, -54, -50,
-48, -43, -41, -38, -36, -32, -30, -28, -25, -22, -20, -18, -16, -14, -12, -10,
-9, -8, -5, -5, -3, -3, -2, 0, 0, 1, 2, 2, 1, 2, 2, 2, 1, 2, 2, 1, 1, 1, 1, -1,
-1, -2, -2, -3, -3, -5, -6, -6, -7, -8, -8, -10, -10, -12, -12, -14, -14, -15,
-16, -17, -17, -18, -19, -20, -20, -20, -21, -22, -22, -23, -23, -22, -23, -22,
-23, -22, -23, -21, -21, -21, -21, -20, -19, -18, -16, -15, -15, -13, -12, -9,
-9, -7, -4, -2, 0, 3, 5, 8, 11, 13, 16, 19, 22, 26, 29, 33, 36, 39, 43, 46, 50,
54, 57, 62, 66, 70, 73, 77, 81, 85, 87, 91, 95, 97, 101, 104, 107, 108, 111,
113, 114, 116, 118, 118, 119, 120, 119, 118, 117, 115, 114, 111, 109, 106, 102,
97, 93, 87, 81, 75, 69, 63, 55, 47, 38, 29, 20, 10, 1, -10, -19, -28, -35, -44,
-50, -55, -62, -67, -72, -76, -80, -85, -87, -91, -94, -96, -99, -100, -102,
-104, -105, -107, -108, -110, -110, -111, -112, -112, -114, -114, -115, -114,
-115, -115, -115, -115, -116, -116, -117, -116, -116, -116, -117, -117, -116,
-116, -116, -116, -116, -116, -115, -115, -115, -115, -115, -114, -115, -114,
-114, -113, -112, -113, -112, -112, -111, -111, -110, -110, -109, -110, -109,
-108, -107, -107, -107, -107, -106, -106, -106, -106, -105, -104, -105, -106,
-105, -105, -106, -105, -105, -106, -106, -106, -107, -107, -109, -109, -110,
-110, -112, -112, -112, -113, -114, -115, -115, -116, -117, -117, -117, -117,
-119, -119, -120, -119, -120, -118, -119, -118, -117, -117, -114, -114, -112,
-111, -108, -107, -105, -102, -99, -97, -93, -90, -87, -82, -79, -75, -70, -66,
-62, -57, -52, -47, -42, -36, -31, -25, -20, -14, -9, -4, };