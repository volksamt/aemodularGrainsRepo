#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0068

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 1, 3, 3, 5, 4, 5, 7, 7, 8, 8,
9, 10, 10, 11, 13, 14, 14, 14, 16, 17, 18, 19, 18, 20, 21, 23, 23, 24, 25, 27,
28, 29, 30, 32, 32, 34, 35, 36, 37, 38, 41, 42, 44, 45, 47, 48, 50, 51, 51, 54,
55, 56, 58, 59, 62, 64, 65, 67, 69, 71, 73, 75, 76, 78, 79, 81, 83, 85, 87, 89,
91, 92, 95, 96, 98, 100, 101, 103, 104, 106, 107, 108, 110, 111, 113, 114, 114,
115, 116, 117, 118, 118, 119, 119, 119, 119, 119, 119, 119, 117, 115, 114, 113,
112, 109, 108, 105, 102, 99, 96, 93, 89, 86, 81, 76, 71, 66, 60, 53, 47, 40, 32,
24, 15, 7, -2, -11, -19, -27, -36, -43, -50, -55, -61, -68, -73, -77, -82, -86,
-90, -94, -96, -100, -103, -105, -107, -110, -111, -113, -114, -115, -116, -117,
-119, -118, -119, -119, -118, -118, -118, -118, -118, -118, -118, -117, -116,
-116, -114, -113, -113, -112, -110, -109, -107, -107, -105, -103, -103, -101,
-100, -98, -96, -96, -94, -92, -91, -90, -87, -85, -85, -83, -81, -79, -77, -76,
-75, -74, -72, -71, -68, -68, -65, -64, -62, -61, -59, -57, -57, -55, -54, -52,
-50, -49, -48, -47, -46, -44, -43, -41, -40, -38, -38, -36, -35, -35, -33, -31,
-31, -29, -28, -27, -26, -25, -23, -23, -21, -20, -20, -19, -18, -17, -17, -15,
-13, -13, -13, -11, -11, -10, -8, -7, -7, -7, -6, -5, -4, -3, -2, -2, -1, 1, 1,
2, 2, 3, 4, 4, 5, 6, 6, 6, 7, 8, 8, 9, 10, 10, 11, 11, 12, 12, 13, 14, 15, 14,
16, 15, 16, 17, 17, 17, 17, 18, 19, 18, 19, 20, 19, 20, 21, 21, 21, 22, 22, 22,
22, 23, 23, 23, 23, 23, 24, 23, 24, 24, 24, 24, 24, 23, 24, 24, 24, 25, 24, 24,
23, 24, 24, 24, 23, 23, 23, 23, 23, 23, 22, 22, 22, 22, 23, 21, 22, 21, 21, 21,
20, 20, 19, 20, 19, 19, 19, 18, 18, 17, 17, 17, 17, 16, 16, 15, 15, 14, 14, 13,
13, 13, 12, 13, 12, 11, 12, 10, 11, 10, 9, 8, 9, 8, 8, 6, 7, 7, 6, 6, 4, 5, 5,
3, 4, 3, 3, 2, 2, 1, 1, 0, 0, 0, -1, -1, -2, -2, -3, -3, -2, -4, -4, -4, -5, -4,
-6, -6, -6, -6, -6, -7, -8, -8, -7, -8, -8, -8, -9, -9, -10, -9, -10, -10, -11,
-10, -11, -10, -12, -11, -11, -12, -13, -13, -12, -12, -12, -13, -12, -13, -12,
-13, -12, -12, -13, -13, -13, -13, -13, -13, -13, -13, -12, -13, -13, -13, -12,
-13, -13, -13, -12, -12, -12, -12, -12, -12, -12, -11, -11, -11, -11, -10, -10,
-10, -10, -9, -10, -9, -9, -8, -9, -8, -7, -8, -8, -7, -7, -7, -6, -6, -5, -5,
-4, -4, -3, -4, -3, -2, -2, -2, -2, -1, -1, 0, };