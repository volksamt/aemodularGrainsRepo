#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0100

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 4, 5, 6, 8, 10, 11, 13, 15,
16, 18, 19, 21, 23, 25, 28, 30, 32, 35, 36, 39, 41, 44, 47, 50, 53, 55, 58, 61,
64, 67, 71, 75, 77, 80, 83, 86, 90, 93, 96, 99, 102, 104, 106, 109, 110, 112,
115, 116, 117, 118, 119, 119, 120, 118, 117, 116, 114, 112, 110, 107, 104, 100,
95, 90, 84, 78, 72, 65, 59, 50, 41, 34, 24, 14, 5, -6, -17, -26, -34, -42, -49,
-56, -62, -68, -74, -78, -83, -87, -92, -95, -98, -102, -105, -107, -109, -110,
-113, -114, -115, -116, -118, -118, -118, -119, -118, -119, -119, -118, -118,
-117, -116, -114, -114, -112, -112, -109, -108, -105, -103, -101, -99, -96, -93,
-90, -88, -84, -82, -78, -76, -73, -70, -66, -64, -60, -56, -54, -50, -46, -44,
-40, -37, -34, -31, -28, -26, -22, -20, -16, -14, -11, -8, -5, -2, 0, 3, 6, 9,
11, 15, 17, 21, 23, 27, 30, 33, 36, 39, 42, 45, 50, 52, 56, 59, 63, 66, 70, 73,
76, 80, 83, 86, 89, 91, 95, 98, 100, 103, 105, 107, 109, 110, 112, 114, 115,
116, 117, 118, 118, 118, 119, 119, 119, 119, 118, 117, 118, 117, 116, 114, 113,
112, 110, 110, 107, 107, 105, 103, 101, 99, 97, 94, 93, 90, 88, 86, 82, 80, 77,
75, 72, 68, 65, 62, 58, 55, 51, 46, 42, 38, 32, 28, 21, 16, 11, 3, -4, -10, -16,
-23, -29, -35, -41, -47, -52, -59, -63, -69, -73, -78, -82, -87, -90, -94, -97,
-101, -103, -105, -109, -111, -112, -114, -116, -117, -118, -118, -118, -119,
-118, -119, -119, -118, -118, -117, -116, -115, -114, -112, -111, -109, -109,
-107, -105, -103, -102, -100, -98, -97, -95, -93, -92, -91, -90, -87, -86, -84,
-83, -82, -80, -79, -78, -77, -75, -75, -74, -73, -72, -72, -71, -70, -69, -68,
-68, -67, -68, -67, -66, -66, -66, -67, -66, -67, -67, -67, -67, -67, -67, -67,
-68, -67, -69, -69, -69, -70, -71, -71, -71, -72, -73, -73, -74, -75, -75, -75,
-77, -77, -78, -79, -79, -79, -79, -81, -81, -82, -83, -83, -83, -84, -83, -84,
-84, -84, -85, -85, -85, -85, -85, -85, -86, -85, -85, -85, -85, -84, -84, -84,
-84, -83, -81, -82, -80, -79, -80, -79, -78, -77, -75, -75, -73, -73, -72, -71,
-70, -69, -68, -66, -64, -64, -62, -61, -60, -59, -57, -56, -55, -54, -52, -51,
-50, -49, -47, -46, -45, -43, -42, -40, -40, -38, -38, -37, -36, -35, -33, -32,
-31, -31, -31, -29, -28, -27, -27, -26, -25, -25, -24, -24, -23, -22, -22, -22,
-21, -21, -20, -20, -19, -19, -19, -19, -19, -19, -18, -18, -17, -17, -18, -18,
-18, -18, -18, -17, -16, -17, -17, -17, -17, -16, -17, -17, -17, -17, -17, -16,
-16, -16, -16, -15, -15, -16, -15, -15, -15, -14, -14, -13, -13, -12, -11, -11,
-11, -9, -9, -8, -7, -8, -6, -5, -5, -2, -2, -1, };