#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0035

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 39, 65, 87, 104, 116, 119, 113,
99, 74, 43, 8, -28, -64, -92, -110, -118, -116, -102, -79, -49, -14, 21, 55, 84,
104, 117, 118, 109, 89, 62, 27, -9, -41, -72, -95, -111, -119, -118, -110, -96,
-77, -56, -33, -9, 14, 36, 56, 73, 87, 99, 107, 113, 117, 119, 119, 118, 116,
114, 111, 107, 105, 103, 101, 100, 100, 100, 101, 102, 105, 108, 110, 113, 116,
118, 119, 119, 117, 114, 108, 101, 90, 77, 62, 43, 24, 2, -21, -43, -64, -84,
-99, -111, -118, -118, -111, -98, -77, -51, -21, 5, 32, 63, 87, 105, 116, 118,
114, 100, 80, 55, 29, -1, -31, -56, -79, -98, -111, -118, -119, -114, -102, -86,
-65, -43, -20, 4, 26, 47, 65, 80, 93, 102, 110, 115, 118, 119, 120, 117, 117,
114, 113, 111, 109, 108, 106, 106, 107, 108, 109, 111, 113, 115, 117, 118, 120,
119, 116, 113, 107, 99, 87, 72, 55, 34, 11, -12, -38, -61, -83, -101, -113,
-119, -117, -108, -93, -71, -43, -12, 20, 52, 79, 102, 115, 120, 112, 95, 67,
31, -7, -45, -78, -102, -116, -118, -109, -91, -65, -34, 1, 34, 65, 90, 107,
118, 118, 109, 93, 72, 43, 13, -15, -44, -69, -88, -104, -113, -118, -119, -116,
-109, -101, -90, -80, -69, -57, -46, -36, -25, -18, -10, -3, 2, 6, 9, 10, 11,
10, 7, 3, -1, -6, -13, -21, -30, -39, -50, -61, -71, -84, -94, -104, -111, -117,
-119, -118, -113, -104, -90, -70, -48, -23, 5, 33, 59, 82, 101, 114, 119, 116,
107, 91, 69, 43, 14, -16, -45, -72, -93, -109, -117, -119, -111, -97, -76, -49,
-20, 10, 39, 64, 86, 102, 113, 119, 118, 113, 105, 92, 78, 62, 45, 29, 13, -3,
-18, -31, -43, -54, -62, -70, -77, -82, -86, -89, -92, -93, -94, -93, -92, -92,
-89, -85, -80, -74, -68, -60, -50, -39, -26, -11, 4, 20, 39, 55, 72, 87, 101,
112, 117, 119, 114, 104, 86, 62, 33, 2, -31, -61, -87, -107, -118, -118, -109,
-91, -64, -32, 2, 36, 68, 94, 111, 119, 115, 99, 73, 39, 1, -36, -70, -96, -113,
-119, -115, -102, -80, -56, -25, 5, 34, 62, 84, 101, 113, 119, 118, 113, 101,
86, 69, 50, 29, 10, -9, -27, -42, -56, -68, -78, -87, -93, -98, -102, -106,
-108, -109, -110, -110, -110, -110, -108, -107, -105, -100, -96, -91, -84, -75,
-64, -52, -38, -22, -4, 14, 33, 52, 70, 88, 101, 111, 117, 119, 115, 105, 91,
72, 48, 22, -7, -34, -60, -83, -103, -114, -120, -115, -105, -87, -62, -31, 2,
33, 64, 88, 105, 117, 119, 114, 103, 87, 66, 43, 18, -7, -32, -54, -73, -90,
-102, -112, -117, -119, -118, -114, -107, -100, -90, -81, -71, -62, -52, -43,
-35, -29, -23, -19, -15, -14, -14, -13, -16, -19, -24, -30, -37, -45, -55, -65,
-75, -85, -95, -104, -110, -116, -119, -118, -115, -107, -94, -77, -58, -34,
-10, };