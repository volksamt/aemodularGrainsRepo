#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0111

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 7, 9, 10, 11, 11, 12, 14,
13, 14, 14, 16, 16, 17, 17, 17, 19, 20, 21, 22, 24, 25, 27, 29, 31, 32, 34, 35,
35, 37, 38, 38, 38, 39, 40, 39, 40, 40, 39, 40, 40, 41, 41, 42, 44, 44, 44, 46,
48, 49, 49, 51, 52, 53, 54, 54, 53, 53, 53, 53, 53, 53, 53, 52, 52, 51, 51, 51,
51, 52, 52, 54, 54, 55, 56, 56, 57, 57, 58, 58, 58, 57, 57, 57, 56, 56, 55, 55,
53, 53, 53, 52, 51, 50, 51, 51, 51, 51, 51, 53, 53, 53, 54, 52, 54, 53, 52, 52,
51, 50, 50, 48, 48, 45, 45, 44, 43, 42, 42, 40, 41, 40, 40, 40, 40, 40, 41, 40,
40, 41, 39, 39, 39, 37, 37, 35, 33, 33, 30, 29, 29, 27, 26, 25, 24, 23, 23, 23,
23, 22, 22, 21, 22, 22, 22, 21, 21, 19, 19, 18, 16, 15, 14, 12, 10, 10, 9, 7, 6,
5, 5, 3, 4, 4, 4, 3, 2, 2, 2, 3, 2, 2, 1, 1, -1, -2, -2, -3, -4, -6, -7, -8, -8,
-10, -11, -11, -12, -11, -13, -13, -13, -12, -13, -12, -13, -13, -13, -13, -14,
-15, -16, -15, -17, -19, -19, -20, -21, -21, -23, -23, -24, -24, -24, -24, -24,
-24, -24, -24, -23, -24, -24, -23, -24, -24, -24, -25, -25, -26, -26, -27, -27,
-29, -29, -29, -30, -30, -31, -31, -31, -30, -30, -30, -30, -29, -29, -28, -29,
-28, -29, -28, -28, -29, -28, -29, -29, -30, -30, -30, -31, -30, -31, -31, -31,
-31, -31, -30, -30, -29, -28, -27, -27, -26, -26, -25, -24, -23, -24, -24, -24,
-25, -23, -24, -25, -25, -24, -24, -24, -24, -23, -22, -22, -21, -20, -19, -18,
-17, -16, -15, -14, -13, -12, -12, -11, -11, -10, -10, -10, -9, -9, -9, -8, -8,
-7, -7, -5, -5, -3, -2, -1, 1, 2, 4, 5, 7, 9, 10, 12, 13, 13, 14, 15, 15, 17,
17, 18, 18, 19, 20, 22, 24, 24, 26, 29, 31, 34, 36, 38, 39, 42, 44, 47, 48, 50,
52, 53, 54, 55, 56, 57, 59, 59, 60, 62, 62, 62, 64, 65, 67, 69, 70, 70, 72, 72,
72, 71, 71, 70, 68, 68, 66, 65, 63, 61, 60, 57, 55, 53, 49, 46, 43, 38, 31, 24,
16, 7, -4, -18, -32, -44, -55, -64, -73, -79, -85, -90, -95, -97, -101, -103,
-106, -107, -109, -111, -112, -114, -116, -117, -118, -119, -119, -119, -119,
-118, -116, -115, -114, -112, -111, -109, -107, -105, -103, -103, -101, -100,
-98, -97, -95, -94, -92, -91, -89, -86, -84, -82, -79, -77, -74, -71, -68, -67,
-64, -61, -60, -58, -56, -55, -53, -51, -50, -49, -49, -48, -47, -45, -45, -43,
-41, -39, -39, -36, -35, -33, -32, -29, -28, -26, -24, -23, -22, -20, -19, -18,
-17, -16, -16, -15, -14, -13, -14, -12, -11, -10, -8, -8, -6, -5, -3, -1, };