#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0095

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 4, 5, 9, 10, 13, 16, 18, 21, 24,
27, 30, 34, 37, 40, 43, 47, 50, 53, 58, 62, 65, 68, 73, 76, 80, 83, 86, 90, 94,
96, 100, 102, 105, 108, 110, 112, 114, 116, 117, 118, 118, 118, 119, 118, 118,
116, 114, 112, 109, 107, 102, 98, 94, 88, 82, 76, 68, 61, 53, 44, 35, 24, 15, 3,
-8, -18, -28, -37, -44, -51, -59, -65, -71, -76, -81, -86, -90, -93, -97, -100,
-103, -105, -108, -109, -111, -112, -114, -115, -116, -117, -117, -118, -118,
-120, -119, -119, -119, -118, -118, -118, -117, -117, -117, -116, -114, -113,
-112, -111, -110, -108, -107, -104, -102, -100, -98, -96, -94, -90, -87, -85,
-82, -79, -75, -72, -68, -64, -61, -56, -52, -48, -43, -38, -34, -28, -24, -19,
-13, -8, -3, 3, 9, 14, 19, 25, 32, 37, 42, 48, 53, 59, 64, 70, 75, 80, 85, 89,
93, 99, 102, 105, 109, 112, 114, 116, 118, 119, 119, 119, 118, 117, 115, 112,
109, 106, 100, 95, 89, 81, 74, 66, 56, 46, 35, 22, 11, -2, -14, -26, -37, -46,
-54, -62, -69, -75, -80, -85, -90, -93, -96, -99, -102, -105, -108, -110, -111,
-112, -113, -114, -114, -116, -116, -117, -117, -118, -119, -119, -119, -118,
-119, -119, -120, -119, -119, -120, -120, -119, -118, -118, -118, -118, -118,
-117, -117, -117, -117, -115, -116, -115, -115, -114, -114, -113, -113, -112,
-112, -112, -111, -110, -109, -108, -107, -107, -105, -104, -103, -102, -100,
-99, -98, -96, -95, -93, -91, -90, -88, -85, -83, -81, -79, -77, -74, -72, -70,
-67, -65, -62, -59, -57, -55, -52, -48, -46, -43, -40, -38, -35, -32, -29, -27,
-24, -22, -19, -16, -13, -11, -8, -6, -4, -1, 1, 3, 5, 7, 9, 11, 12, 14, 15, 17,
18, 20, 20, 22, 23, 23, 25, 24, 26, 26, 27, 27, 27, 26, 26, 26, 26, 25, 25, 25,
24, 23, 22, 22, 20, 19, 18, 16, 15, 14, 13, 11, 9, 8, 6, 4, 2, 0, -1, -4, -5,
-7, -10, -12, -13, -16, -18, -20, -21, -24, -25, -27, -29, -31, -32, -34, -36,
-38, -39, -41, -42, -44, -45, -47, -48, -48, -50, -50, -51, -52, -53, -53, -54,
-55, -55, -55, -55, -56, -56, -55, -55, -56, -56, -56, -54, -54, -54, -53, -53,
-51, -52, -50, -49, -49, -47, -47, -45, -45, -43, -42, -41, -39, -38, -36, -35,
-34, -33, -31, -29, -28, -27, -25, -24, -22, -20, -19, -18, -16, -16, -14, -12,
-12, -11, -10, -9, -7, -6, -5, -4, -3, -3, -2, -2, -1, -1, 0, 0, 1, 0, 1, 1, 2,
2, 2, 2, 2, 1, 1, 0, 0, 0, 0, -1, -2, -2, -3, -3, -3, -5, -4, -6, -7, -8, -8,
-9, -10, -10, -11, -11, -12, -13, -13, -14, -14, -15, -16, -16, -16, -16, -17,
-17, -17, -17, -16, -16, -15, -16, -15, -15, -14, -12, -12, -11, -10, -9, -8,
-7, -4, -3, -1, -1, };