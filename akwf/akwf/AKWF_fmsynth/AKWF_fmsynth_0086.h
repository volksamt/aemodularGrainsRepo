#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0086

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 16, 31, 44, 58, 68, 78, 87, 95,
101, 106, 110, 113, 115, 116, 118, 119, 118, 119, 119, 119, 119, 118, 118, 119,
117, 117, 115, 114, 112, 108, 105, 101, 95, 91, 84, 78, 71, 63, 57, 48, 40, 33,
26, 20, 14, 9, 5, 2, -1, -2, -3, -3, -1, 2, 6, 10, 15, 21, 29, 37, 45, 55, 65,
74, 83, 92, 99, 106, 111, 115, 117, 117, 116, 111, 106, 99, 91, 80, 69, 58, 47,
35, 26, 17, 8, -1, -6, -13, -18, -21, -24, -25, -26, -26, -25, -22, -19, -15,
-10, -4, 3, 9, 16, 25, 33, 42, 51, 60, 68, 75, 82, 89, 94, 98, 103, 106, 109,
111, 113, 114, 114, 114, 115, 115, 115, 115, 113, 112, 112, 110, 108, 105, 101,
96, 90, 82, 72, 61, 50, 38, 23, 9, -7, -21, -36, -50, -64, -77, -87, -97, -105,
-111, -115, -118, -119, -118, -119, -117, -116, -113, -111, -111, -109, -106,
-106, -106, -105, -106, -107, -109, -110, -112, -113, -115, -116, -117, -119,
-119, -118, -116, -114, -111, -108, -104, -99, -93, -88, -82, -76, -71, -65,
-61, -58, -54, -51, -49, -49, -49, -50, -52, -56, -60, -65, -69, -75, -82, -89,
-95, -101, -107, -112, -115, -116, -117, -115, -113, -107, -102, -92, -82, -72,
-60, -48, -34, -22, -9, 2, 13, 24, 34, 41, 49, 56, 61, 64, 68, 69, 71, 73, 72,
71, 70, 67, 64, 60, 55, 49, 43, 36, 28, 21, 12, 3, -6, -15, -24, -33, -42, -48,
-56, -63, -69, -74, -79, -82, -85, -88, -90, -91, -91, -91, -90, -90, -87, -84,
-80, -77, -70, -63, -55, -47, -37, -26, -14, -1, 12, 26, 40, 52, 65, 77, 87, 96,
104, 110, 116, 117, 118, 118, 117, 114, 110, 105, 101, 96, 92, 87, 84, 80, 78,
77, 75, 75, 76, 77, 80, 83, 86, 90, 94, 99, 102, 107, 110, 113, 116, 116, 117,
118, 117, 116, 114, 112, 109, 106, 103, 99, 97, 93, 91, 90, 88, 88, 87, 88, 90,
92, 94, 97, 100, 103, 107, 111, 113, 116, 116, 116, 115, 112, 107, 102, 93, 82,
71, 57, 44, 29, 14, 0, -14, -28, -40, -52, -63, -72, -80, -87, -93, -97, -101,
-103, -105, -107, -108, -109, -109, -108, -107, -105, -105, -102, -99, -94, -90,
-85, -80, -72, -66, -57, -48, -39, -30, -21, -11, -3, 5, 14, 22, 28, 34, 40, 44,
47, 51, 53, 54, 54, 52, 51, 49, 45, 39, 34, 27, 18, 10, 0, -10, -23, -34, -46,
-60, -72, -83, -93, -102, -109, -114, -117, -118, -118, -114, -111, -106, -100,
-93, -85, -77, -69, -61, -54, -48, -41, -36, -32, -29, -27, -26, -25, -26, -28,
-31, -35, -38, -43, -48, -55, -61, -67, -74, -81, -86, -92, -98, -103, -107,
-110, -112, -114, -117, -118, -118, -117, -117, -116, -115, -115, -114, -114,
-114, -114, -114, -115, -116, -116, -117, -116, -116, -116, -114, -110, -106,
-100, -93, -85, -75, -64, -52, -37, -24, -9, };