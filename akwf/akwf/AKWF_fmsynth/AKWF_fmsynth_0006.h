#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 10, 19, 27, 35, 42, 49, 56, 63, 69,
75, 80, 84, 88, 93, 95, 99, 101, 104, 106, 107, 109, 110, 110, 112, 112, 113,
114, 113, 114, 113, 113, 114, 114, 114, 114, 114, 114, 114, 114, 114, 115, 114,
114, 113, 115, 113, 114, 113, 114, 113, 113, 113, 113, 112, 112, 112, 111, 111,
110, 111, 110, 110, 110, 110, 110, 110, 109, 109, 108, 109, 109, 109, 108, 110,
110, 110, 110, 111, 111, 111, 112, 112, 113, 113, 113, 114, 113, 113, 112, 111,
110, 108, 106, 104, 101, 96, 92, 87, 82, 76, 70, 63, 55, 47, 38, 29, 20, 10, 0,
-10, -19, -30, -40, -50, -59, -69, -77, -86, -92, -99, -104, -109, -112, -116,
-118, -119, -119, -118, -116, -115, -112, -108, -104, -99, -94, -90, -83, -77,
-72, -65, -60, -54, -47, -41, -36, -31, -25, -20, -16, -11, -6, -2, 2, 6, 9, 11,
15, 17, 18, 20, 22, 24, 24, 26, 26, 26, 27, 27, 27, 26, 27, 25, 25, 24, 23, 22,
21, 19, 19, 18, 16, 14, 14, 11, 10, 8, 8, 6, 5, 4, 4, 2, 2, 0, 1, 0, -1, -1, 0,
0, 1, 2, 3, 4, 5, 6, 9, 11, 14, 17, 19, 23, 27, 30, 34, 38, 42, 47, 51, 56, 60,
66, 71, 76, 81, 85, 90, 94, 98, 102, 105, 108, 111, 112, 113, 113, 113, 111,
110, 106, 103, 99, 93, 88, 80, 73, 64, 56, 47, 37, 28, 18, 8, 0, -10, -19, -29,
-37, -46, -54, -62, -69, -76, -82, -89, -93, -98, -102, -105, -108, -112, -113,
-115, -116, -117, -118, -118, -119, -118, -119, -119, -119, -119, -118, -117,
-118, -117, -117, -116, -117, -116, -116, -116, -116, -116, -116, -116, -117,
-116, -117, -117, -118, -118, -118, -118, -118, -119, -118, -118, -119, -119,
-118, -118, -119, -119, -119, -118, -118, -118, -118, -118, -117, -117, -118,
-116, -117, -117, -116, -117, -117, -116, -117, -116, -117, -118, -118, -117,
-119, -118, -118, -118, -118, -118, -117, -116, -116, -115, -114, -112, -111,
-108, -105, -102, -98, -94, -89, -84, -79, -72, -66, -59, -51, -42, -35, -26,
-17, -8, 2, 10, 21, 30, 39, 48, 56, 65, 73, 80, 87, 93, 98, 103, 107, 109, 111,
113, 114, 114, 113, 112, 110, 107, 104, 100, 96, 91, 87, 82, 76, 71, 65, 59, 54,
49, 43, 38, 34, 30, 25, 22, 18, 13, 10, 8, 5, 2, 0, -1, -3, -4, -6, -6, -7, -7,
-8, -8, -8, -8, -7, -7, -6, -5, -4, -3, -2, -1, 0, 2, 3, 5, 5, 7, 9, 9, 11, 12,
14, 15, 16, 16, 16, 16, 17, 17, 18, 17, 17, 16, 16, 14, 14, 12, 10, 9, 6, 4, 1,
-2, -6, -9, -13, -17, -22, -27, -32, -36, -42, -47, -53, -59, -65, -71, -77,
-83, -89, -94, -98, -103, -107, -111, -114, -116, -117, -117, -117, -116, -116,
-112, -109, -104, -100, -93, -88, -79, -73, -64, -55, -46, -37, -26, -18, -8, };