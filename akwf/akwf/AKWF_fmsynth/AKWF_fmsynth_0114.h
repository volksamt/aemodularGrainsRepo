#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0114

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 11, 15, 20, 24, 29, 33, 37, 41,
46, 51, 54, 58, 63, 67, 70, 74, 78, 81, 85, 88, 91, 94, 96, 99, 101, 104, 106,
108, 110, 112, 113, 114, 115, 117, 117, 119, 119, 119, 119, 120, 119, 119, 118,
118, 117, 116, 115, 114, 113, 112, 109, 108, 107, 106, 104, 102, 99, 97, 96, 93,
91, 89, 86, 85, 82, 80, 77, 75, 72, 70, 67, 65, 63, 61, 58, 56, 53, 50, 48, 46,
44, 42, 40, 38, 35, 34, 30, 29, 28, 25, 23, 21, 19, 17, 16, 15, 13, 12, 10, 9,
7, 7, 5, 4, 3, 2, 2, 1, -1, 0, -1, -2, -3, -3, -4, -4, -4, -4, -5, -5, -4, -4,
-5, -5, -4, -4, -3, -3, -2, -1, 0, 0, 1, 2, 2, 4, 5, 6, 7, 8, 10, 12, 13, 15,
16, 18, 19, 22, 23, 25, 28, 29, 32, 34, 36, 38, 41, 42, 46, 48, 50, 53, 56, 58,
61, 64, 67, 70, 72, 75, 77, 80, 83, 85, 87, 90, 92, 95, 98, 99, 102, 104, 106,
108, 109, 111, 112, 114, 115, 116, 117, 118, 117, 119, 118, 118, 118, 116, 115,
115, 113, 111, 108, 107, 105, 101, 98, 95, 90, 86, 83, 78, 73, 68, 63, 57, 52,
46, 40, 35, 27, 22, 15, 10, 3, -2, -9, -16, -22, -28, -36, -41, -47, -54, -58,
-64, -69, -74, -80, -83, -87, -91, -94, -97, -99, -101, -103, -104, -103, -104,
-103, -103, -101, -101, -98, -96, -93, -90, -86, -82, -77, -72, -68, -62, -56,
-51, -44, -39, -31, -26, -19, -12, -5, 2, 9, 15, 22, 29, 36, 42, 49, 55, 61, 67,
73, 77, 83, 88, 93, 97, 100, 104, 107, 109, 113, 114, 116, 118, 117, 118, 118,
117, 116, 116, 114, 111, 109, 106, 103, 99, 96, 91, 88, 83, 78, 73, 68, 63, 57,
51, 45, 40, 34, 28, 22, 18, 11, 5, 0, -6, -11, -16, -22, -27, -32, -37, -41,
-46, -51, -55, -60, -64, -68, -71, -75, -78, -80, -83, -86, -89, -91, -92, -94,
-97, -98, -99, -100, -101, -102, -102, -103, -104, -104, -104, -104, -104, -103,
-103, -104, -102, -102, -101, -101, -100, -99, -98, -97, -97, -96, -95, -94,
-92, -92, -91, -90, -89, -88, -87, -86, -84, -83, -83, -81, -80, -80, -78, -78,
-77, -77, -76, -75, -75, -73, -73, -73, -72, -72, -71, -70, -70, -70, -71, -71,
-71, -70, -70, -70, -70, -71, -71, -72, -71, -72, -73, -73, -73, -74, -75, -76,
-76, -76, -78, -77, -79, -79, -79, -80, -81, -83, -84, -84, -86, -86, -87, -88,
-89, -89, -91, -92, -93, -93, -95, -96, -97, -96, -98, -99, -99, -100, -100,
-101, -102, -102, -102, -102, -102, -103, -103, -102, -103, -103, -102, -102,
-101, -100, -100, -99, -97, -97, -96, -94, -92, -90, -89, -87, -85, -82, -80,
-78, -75, -72, -70, -67, -63, -61, -57, -53, -49, -46, -42, -39, -34, -31, -26,
-23, -18, -14, -9, -4, -1, };