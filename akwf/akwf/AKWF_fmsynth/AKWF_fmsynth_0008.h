#define DATA_LENGTH 512
#define DATA AKWF_fmsynth_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 24, 38, 52, 63, 72, 79, 85, 90, 93,
95, 97, 97, 98, 99, 99, 100, 99, 99, 99, 98, 98, 98, 98, 98, 97, 97, 98, 98, 98,
97, 97, 97, 97, 96, 97, 96, 96, 96, 96, 94, 95, 95, 94, 95, 94, 95, 95, 96, 97,
97, 98, 98, 98, 99, 98, 95, 92, 85, 78, 67, 52, 35, 15, -7, -30, -56, -79, -100,
-112, -118, -115, -102, -80, -50, -15, 21, 54, 80, 95, 98, 84, 57, 20, -21, -60,
-91, -112, -119, -112, -93, -66, -33, 0, 33, 60, 81, 93, 99, 96, 87, 73, 54, 34,
13, -8, -27, -45, -61, -75, -87, -97, -105, -111, -114, -118, -118, -118, -118,
-118, -116, -114, -110, -107, -103, -99, -94, -89, -83, -77, -71, -64, -57, -50,
-43, -35, -28, -20, -14, -6, 0, 7, 12, 18, 22, 26, 29, 32, 34, 34, 35, 33, 31,
29, 23, 19, 13, 4, -5, -15, -27, -40, -53, -66, -80, -93, -104, -112, -118,
-119, -116, -107, -95, -78, -55, -32, -8, 16, 40, 60, 77, 89, 95, 98, 98, 92,
85, 75, 63, 51, 41, 30, 19, 10, 3, -4, -8, -12, -13, -14, -12, -9, -6, -1, 6,
14, 21, 30, 41, 51, 61, 71, 79, 87, 92, 97, 99, 98, 95, 89, 80, 68, 55, 41, 24,
8, -9, -27, -42, -59, -74, -87, -98, -107, -114, -118, -119, -117, -114, -107,
-98, -87, -72, -55, -37, -17, 4, 25, 46, 64, 80, 91, 98, 97, 90, 74, 52, 22, -9,
-42, -73, -99, -115, -119, -111, -92, -65, -31, 7, 41, 70, 90, 99, 95, 78, 52,
19, -16, -48, -78, -99, -113, -118, -116, -109, -97, -81, -64, -48, -31, -16,
-1, 10, 21, 29, 36, 42, 45, 48, 50, 49, 49, 47, 44, 40, 35, 30, 23, 16, 9, 0,
-8, -17, -27, -36, -45, -53, -63, -71, -77, -85, -90, -95, -101, -105, -109,
-111, -114, -116, -117, -118, -118, -119, -118, -118, -118, -116, -115, -112,
-112, -108, -105, -101, -96, -90, -84, -76, -67, -58, -47, -36, -23, -11, 3, 18,
32, 46, 59, 70, 81, 90, 96, 98, 99, 97, 93, 86, 79, 68, 58, 46, 35, 25, 15, 5,
-3, -10, -16, -21, -23, -23, -24, -22, -18, -12, -5, 3, 13, 26, 39, 52, 65, 78,
89, 96, 99, 97, 89, 73, 52, 24, -6, -36, -65, -91, -108, -118, -117, -107, -87,
-62, -32, -2, 28, 55, 77, 91, 98, 98, 88, 72, 51, 26, -1, -26, -50, -72, -92,
-105, -115, -118, -118, -112, -102, -89, -72, -54, -33, -12, 8, 29, 48, 67, 80,
92, 98, 99, 94, 86, 71, 50, 28, 3, -22, -47, -72, -91, -106, -115, -118, -115,
-108, -95, -80, -61, -42, -21, -2, 17, 33, 47, 59, 69, 78, 83, 89, 91, 93, 95,
96, 97, 95, 94, 94, 92, 90, 86, 80, 73, 65, 54, 41, 26, 10, -7, -27, -46, -64,
-80, -95, -107, -114, -118, -117, -113, -104, -91, -76, -59, -40, -22, -6, };