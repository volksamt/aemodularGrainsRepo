#define DATA_LENGTH 512
#define DATA AKWF_tri_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 0, 1, 2, 2, 1, 2, 1, 1, 2, 2, 2,
3, 2, 4, 3, 4, 4, 4, 5, 5, 5, 5, 5, 6, 7, 6, 8, 7, 8, 8, 9, 9, 10, 9, 10, 11,
11, 11, 12, 13, 13, 14, 15, 15, 16, 16, 17, 18, 18, 19, 19, 20, 20, 22, 23, 23,
23, 24, 25, 26, 26, 28, 27, 29, 30, 30, 31, 33, 33, 33, 36, 36, 37, 37, 38, 40,
41, 41, 43, 44, 44, 45, 47, 48, 48, 50, 52, 52, 53, 54, 56, 57, 58, 60, 60, 61,
63, 65, 66, 67, 67, 69, 71, 72, 73, 75, 76, 77, 79, 80, 81, 83, 85, 85, 87, 89,
90, 90, 92, 94, 95, 97, 98, 99, 101, 102, 104, 105, 106, 108, 109, 111, 111,
113, 115, 116, 117, 119, 118, 118, 115, 112, 111, 109, 106, 104, 103, 101, 98,
97, 94, 94, 91, 89, 88, 86, 84, 82, 81, 79, 78, 76, 75, 72, 72, 71, 68, 67, 66,
64, 63, 62, 61, 59, 58, 56, 56, 54, 53, 52, 51, 50, 49, 47, 46, 45, 44, 43, 42,
40, 40, 40, 38, 37, 37, 35, 35, 33, 32, 31, 30, 30, 29, 28, 27, 26, 25, 25, 24,
23, 22, 21, 21, 20, 19, 19, 18, 17, 16, 16, 15, 15, 15, 13, 13, 12, 13, 11, 10,
10, 10, 9, 9, 8, 8, 7, 6, 6, 5, 6, 5, 4, 5, 4, 4, 3, 2, 3, 2, 1, 0, 1, 1, 0, 0,
1, 0, -1, -1, -1, -1, -2, -1, -2, -2, -3, -3, -3, -4, -3, -4, -3, -4, -5, -4,
-4, -5, -5, -6, -6, -6, -7, -7, -7, -8, -9, -8, -9, -9, -10, -10, -10, -11, -11,
-12, -12, -13, -13, -14, -16, -15, -17, -16, -17, -18, -18, -20, -20, -20, -21,
-21, -22, -23, -23, -25, -25, -26, -28, -28, -29, -29, -30, -31, -32, -32, -34,
-36, -36, -37, -37, -39, -39, -41, -42, -43, -43, -45, -46, -46, -49, -49, -50,
-52, -53, -54, -55, -56, -57, -58, -60, -61, -63, -64, -64, -66, -68, -69, -69,
-70, -72, -74, -74, -76, -77, -78, -80, -82, -83, -85, -86, -87, -88, -89, -91,
-93, -94, -96, -97, -98, -99, -101, -102, -104, -105, -107, -109, -109, -111,
-112, -114, -115, -116, -118, -119, -119, -117, -115, -113, -110, -108, -106,
-104, -102, -100, -99, -96, -95, -93, -91, -89, -87, -86, -84, -82, -80, -79,
-77, -76, -74, -73, -71, -71, -69, -67, -66, -65, -63, -62, -61, -58, -58, -56,
-55, -54, -53, -51, -51, -50, -48, -47, -45, -44, -44, -43, -42, -41, -40, -39,
-38, -37, -36, -35, -34, -33, -32, -31, -31, -30, -28, -28, -27, -26, -25, -25,
-23, -22, -22, -21, -21, -20, -20, -19, -18, -17, -17, -16, -16, -15, -14, -13,
-12, -12, -11, -11, -10, -11, -9, -10, -9, -9, -8, -6, -6, -6, -6, -5, -5, -5,
-4, -4, -3, -2, -2, -2, -2, -2, -1, -1, 0, 0, };