#define DATA_LENGTH 512
#define DATA AKWF_tri_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 3, 4, 4, 5, 6, 7, 8, 10, 10, 11,
12, 14, 15, 15, 16, 17, 18, 19, 20, 22, 22, 24, 25, 26, 27, 28, 30, 31, 31, 33,
34, 35, 36, 37, 38, 39, 40, 42, 43, 44, 44, 46, 47, 48, 49, 51, 52, 53, 54, 55,
57, 58, 59, 60, 61, 62, 63, 65, 66, 67, 68, 70, 70, 70, 72, 73, 75, 76, 77, 78,
78, 80, 81, 82, 82, 84, 85, 87, 86, 88, 89, 90, 91, 91, 93, 93, 94, 96, 96, 96,
98, 99, 100, 101, 101, 103, 103, 104, 105, 106, 107, 107, 108, 109, 110, 110,
112, 112, 112, 113, 115, 114, 115, 116, 116, 117, 118, 119, 119, 119, 118, 119,
118, 118, 117, 117, 117, 117, 116, 116, 115, 115, 115, 114, 113, 113, 113, 112,
111, 111, 110, 109, 109, 108, 108, 106, 106, 106, 105, 104, 104, 102, 102, 101,
100, 100, 99, 97, 97, 97, 95, 95, 93, 92, 92, 91, 90, 88, 87, 86, 85, 85, 84,
82, 82, 80, 80, 79, 77, 76, 75, 73, 73, 72, 71, 70, 68, 67, 66, 65, 64, 62, 62,
61, 59, 58, 57, 56, 55, 54, 52, 51, 51, 49, 48, 47, 46, 44, 43, 42, 42, 39, 39,
37, 37, 36, 34, 33, 32, 30, 30, 29, 27, 27, 25, 24, 24, 22, 21, 20, 19, 18, 17,
16, 15, 15, 13, 12, 11, 10, 10, 9, 7, 8, 6, 6, 5, 4, 4, 4, 3, 2, 1, 1, -1, -1,
-3, -3, -4, -5, -6, -7, -8, -9, -10, -11, -13, -13, -15, -15, -16, -17, -18,
-20, -20, -22, -23, -24, -25, -27, -27, -28, -29, -29, -32, -32, -33, -34, -36,
-37, -38, -40, -41, -41, -43, -45, -45, -46, -47, -48, -49, -51, -52, -53, -54,
-55, -57, -57, -58, -60, -61, -63, -63, -64, -65, -67, -68, -69, -69, -71, -72,
-73, -74, -75, -76, -77, -78, -79, -81, -82, -83, -84, -84, -86, -87, -89, -89,
-90, -91, -92, -93, -94, -94, -95, -96, -98, -97, -99, -99, -101, -102, -102,
-104, -104, -105, -106, -106, -107, -108, -109, -110, -110, -111, -112, -113,
-113, -115, -114, -115, -116, -116, -117, -117, -118, -118, -118, -119, -118,
-118, -119, -118, -117, -116, -116, -116, -115, -115, -115, -114, -114, -113,
-113, -112, -112, -111, -112, -110, -109, -110, -109, -107, -107, -107, -106,
-105, -105, -103, -104, -102, -101, -100, -99, -99, -98, -96, -96, -95, -94,
-93, -92, -92, -91, -89, -89, -87, -87, -85, -85, -83, -82, -81, -81, -79, -79,
-77, -76, -76, -74, -73, -72, -71, -70, -68, -68, -67, -65, -64, -64, -62, -61,
-60, -59, -57, -57, -55, -54, -53, -52, -51, -49, -48, -47, -46, -45, -44, -42,
-42, -41, -39, -38, -36, -36, -34, -34, -32, -31, -30, -29, -27, -27, -25, -24,
-23, -23, -22, -21, -19, -19, -17, -16, -15, -15, -13, -12, -12, -11, -10, -9,
-9, -7, -7, -5, -5, -5, -3, -3, -3, -3, -1, 0, };