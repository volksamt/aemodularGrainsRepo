#define DATA_LENGTH 512
#define DATA AKWF_tri_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 1, 1, 2, 1, 1, 2, 1, 2, 2, 2,
2, 2, 3, 2, 3, 2, 3, 3, 2, 3, 3, 3, 2, 3, 3, 4, 3, 3, 3, 3, 4, 4, 4, 5, 5, 5, 5,
5, 5, 6, 6, 6, 7, 7, 8, 7, 8, 9, 9, 9, 9, 10, 11, 11, 12, 12, 13, 13, 13, 14,
15, 16, 17, 17, 18, 19, 19, 19, 20, 22, 22, 23, 23, 25, 25, 26, 26, 27, 29, 29,
30, 31, 32, 33, 34, 36, 36, 37, 38, 39, 40, 41, 42, 44, 45, 46, 46, 47, 50, 50,
52, 53, 55, 55, 56, 58, 60, 61, 62, 64, 65, 67, 69, 70, 71, 73, 75, 76, 77, 78,
80, 82, 83, 85, 87, 88, 89, 91, 93, 95, 96, 98, 99, 101, 102, 104, 106, 108,
110, 111, 113, 114, 115, 118, 119, 119, 117, 113, 111, 109, 107, 104, 102, 100,
98, 95, 93, 90, 89, 87, 85, 82, 80, 80, 77, 75, 73, 71, 71, 69, 66, 65, 64, 62,
60, 58, 57, 56, 55, 53, 52, 50, 49, 48, 47, 46, 45, 43, 43, 41, 40, 38, 38, 36,
35, 35, 33, 33, 32, 31, 29, 29, 28, 27, 27, 25, 24, 23, 23, 22, 21, 20, 20, 18,
18, 17, 16, 15, 15, 15, 14, 13, 12, 12, 12, 11, 11, 10, 10, 9, 8, 7, 8, 8, 6, 5,
6, 5, 5, 4, 5, 4, 3, 3, 2, 2, 3, 2, 1, 1, 1, 0, 1, -1, 0, -1, -1, -1, -1, -1,
-1, -1, -2, -2, -2, -2, -2, -2, -2, -2, -3, -2, -3, -2, -2, -2, -2, -3, -3, -2,
-3, -3, -3, -3, -3, -3, -3, -4, -4, -4, -5, -5, -5, -5, -6, -5, -6, -7, -7, -7,
-7, -8, -8, -9, -10, -10, -10, -10, -10, -12, -13, -13, -13, -13, -13, -15, -16,
-15, -16, -17, -18, -18, -19, -19, -20, -21, -22, -23, -23, -23, -25, -26, -28,
-27, -28, -29, -30, -31, -32, -33, -34, -35, -36, -37, -39, -40, -40, -42, -43,
-44, -45, -45, -47, -48, -50, -51, -52, -54, -55, -56, -57, -58, -60, -61, -63,
-64, -65, -68, -69, -69, -72, -73, -75, -76, -78, -79, -80, -82, -83, -86, -87,
-88, -90, -92, -93, -94, -96, -98, -100, -101, -103, -105, -107, -107, -109,
-111, -113, -114, -117, -118, -119, -118, -116, -114, -110, -109, -105, -104,
-102, -99, -97, -95, -93, -91, -88, -87, -84, -83, -81, -79, -76, -75, -72, -71,
-70, -68, -66, -64, -63, -61, -61, -59, -57, -56, -54, -53, -52, -50, -48, -48,
-47, -46, -45, -44, -42, -41, -40, -39, -38, -36, -35, -34, -34, -33, -32, -30,
-30, -28, -28, -27, -26, -25, -25, -24, -22, -22, -21, -20, -19, -19, -18, -17,
-17, -16, -15, -15, -14, -14, -13, -12, -12, -11, -10, -10, -9, -8, -8, -7, -7,
-7, -6, -6, -6, -5, -5, -4, -4, -3, -3, -3, -3, -2, -2, -1, -2, -1, -1, -1, 0,
};