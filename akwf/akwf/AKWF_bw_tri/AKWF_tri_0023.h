#define DATA_LENGTH 512
#define DATA AKWF_tri_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 16, 24, 27, 30, 32, 36, 38, 40, 43,
45, 47, 48, 50, 52, 53, 55, 56, 58, 59, 60, 61, 63, 63, 65, 66, 68, 68, 69, 70,
71, 72, 73, 74, 76, 76, 77, 78, 79, 79, 80, 81, 82, 82, 83, 84, 84, 85, 86, 87,
88, 88, 89, 90, 90, 91, 91, 91, 92, 93, 94, 94, 95, 96, 96, 96, 97, 97, 97, 98,
99, 100, 100, 101, 100, 102, 102, 102, 103, 103, 104, 105, 104, 106, 106, 106,
107, 107, 107, 108, 108, 109, 109, 109, 109, 110, 110, 111, 111, 112, 111, 112,
112, 112, 114, 114, 114, 113, 115, 114, 116, 115, 116, 115, 116, 116, 116, 116,
117, 117, 118, 118, 119, 119, 118, 119, 118, 119, 119, 119, 118, 118, 117, 117,
117, 116, 115, 115, 115, 114, 113, 114, 113, 112, 112, 110, 111, 111, 110, 109,
109, 108, 107, 107, 107, 106, 106, 105, 105, 104, 104, 103, 103, 102, 102, 102,
102, 100, 100, 100, 99, 98, 98, 97, 97, 96, 95, 95, 95, 94, 94, 93, 93, 93, 91,
91, 90, 90, 89, 89, 89, 87, 86, 85, 85, 85, 84, 83, 83, 82, 81, 80, 80, 79, 79,
77, 77, 77, 76, 75, 74, 74, 73, 71, 71, 70, 70, 68, 67, 66, 66, 64, 63, 64, 62,
60, 60, 59, 58, 57, 55, 54, 54, 53, 51, 49, 48, 47, 46, 45, 43, 42, 40, 38, 36,
34, 33, 31, 29, 26, 23, 21, 18, 14, 10, 2, -8, -18, -23, -28, -30, -34, -36,
-39, -40, -42, -45, -46, -48, -50, -52, -54, -55, -57, -58, -60, -60, -61, -63,
-64, -65, -66, -67, -68, -69, -70, -71, -72, -73, -74, -74, -76, -76, -78, -78,
-79, -81, -80, -82, -82, -83, -84, -85, -86, -87, -87, -87, -88, -89, -89, -90,
-90, -91, -92, -92, -92, -93, -93, -95, -95, -96, -97, -97, -97, -98, -98, -99,
-100, -100, -101, -101, -101, -102, -103, -103, -103, -104, -105, -105, -105,
-105, -105, -107, -107, -107, -107, -108, -108, -109, -109, -110, -110, -111,
-111, -111, -111, -112, -112, -112, -113, -113, -114, -114, -115, -114, -114,
-115, -115, -115, -116, -116, -116, -117, -116, -118, -117, -118, -118, -119,
-118, -118, -119, -118, -119, -119, -119, -119, -118, -118, -117, -116, -116,
-115, -115, -115, -114, -114, -113, -113, -112, -111, -111, -110, -110, -110,
-110, -108, -108, -107, -107, -107, -106, -106, -105, -105, -104, -103, -104,
-103, -103, -102, -102, -101, -100, -100, -100, -99, -98, -98, -98, -98, -97,
-96, -96, -95, -94, -94, -93, -92, -92, -92, -90, -91, -90, -89, -88, -88, -87,
-86, -85, -85, -85, -84, -83, -83, -82, -81, -81, -80, -79, -78, -78, -77, -77,
-75, -75, -74, -73, -73, -72, -70, -70, -70, -68, -67, -67, -65, -65, -64, -63,
-62, -60, -60, -58, -58, -57, -55, -54, -53, -52, -51, -50, -48, -47, -46, -44,
-43, -41, -40, -38, -36, -34, -32, -30, -29, -25, -24, -20, -18, -13, -8, -2, };