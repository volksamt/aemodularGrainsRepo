#define DATA_LENGTH 512
#define DATA AKWF_tri_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 3, 4, 4, 5, 6, 7, 9, 9, 9,
11, 11, 13, 13, 15, 15, 16, 17, 19, 19, 19, 21, 21, 23, 24, 24, 26, 26, 27, 28,
28, 30, 31, 32, 33, 33, 34, 35, 37, 37, 38, 39, 39, 41, 42, 42, 43, 43, 45, 46,
46, 47, 49, 49, 50, 52, 53, 53, 54, 55, 55, 56, 57, 58, 59, 60, 60, 62, 63, 63,
65, 66, 66, 67, 68, 69, 70, 71, 72, 72, 74, 74, 75, 76, 76, 77, 79, 79, 81, 81,
82, 84, 84, 85, 86, 86, 88, 89, 90, 90, 91, 92, 93, 94, 94, 96, 96, 98, 98, 99,
100, 101, 102, 103, 105, 105, 105, 106, 107, 108, 109, 110, 111, 112, 113, 113,
115, 116, 117, 117, 117, 118, 119, 118, 115, 114, 110, 108, 105, 103, 103, 101,
100, 100, 98, 97, 97, 96, 95, 94, 93, 92, 91, 91, 89, 88, 87, 87, 86, 85, 84,
83, 82, 81, 80, 79, 79, 78, 77, 76, 75, 73, 73, 73, 71, 70, 69, 69, 68, 67, 66,
66, 64, 63, 63, 62, 60, 60, 59, 59, 57, 56, 55, 55, 54, 53, 52, 51, 50, 49, 48,
48, 46, 45, 44, 43, 42, 42, 41, 40, 40, 38, 38, 36, 36, 35, 35, 33, 32, 31, 30,
29, 28, 28, 27, 25, 25, 24, 24, 23, 21, 20, 19, 19, 18, 16, 16, 15, 15, 13, 13,
12, 11, 10, 9, 7, 8, 6, 5, 5, 3, 2, 2, 1, 0, -1, -2, -2, -4, -5, -6, -6, -7, -9,
-9, -10, -11, -12, -13, -14, -14, -15, -17, -18, -17, -19, -20, -21, -22, -22,
-24, -24, -25, -26, -27, -28, -29, -30, -30, -31, -32, -33, -35, -36, -37, -37,
-38, -39, -39, -40, -41, -42, -43, -44, -45, -46, -47, -48, -49, -50, -50, -51,
-52, -53, -54, -54, -55, -56, -57, -58, -58, -61, -61, -62, -63, -64, -64, -66,
-66, -68, -68, -69, -71, -71, -72, -72, -73, -75, -75, -76, -77, -78, -79, -80,
-81, -82, -82, -83, -84, -86, -86, -88, -88, -89, -90, -90, -91, -92, -94, -95,
-95, -97, -97, -97, -98, -99, -101, -101, -102, -104, -104, -105, -106, -107,
-108, -108, -110, -111, -112, -113, -113, -114, -115, -116, -116, -117, -118,
-119, -119, -117, -115, -112, -110, -107, -106, -104, -102, -101, -100, -99,
-98, -98, -96, -96, -94, -94, -93, -92, -91, -90, -89, -88, -87, -87, -86, -85,
-84, -83, -82, -81, -80, -80, -79, -78, -78, -77, -75, -74, -73, -73, -71, -71,
-70, -69, -67, -67, -66, -64, -64, -63, -62, -62, -61, -60, -59, -58, -57, -57,
-55, -54, -53, -53, -51, -50, -51, -49, -49, -47, -47, -46, -45, -43, -42, -42,
-41, -40, -39, -38, -38, -36, -36, -35, -34, -32, -31, -31, -30, -29, -28, -27,
-26, -26, -25, -24, -23, -21, -21, -20, -20, -18, -18, -17, -17, -14, -14, -14,
-12, -11, -11, -10, -9, -8, -7, -6, -6, -4, -4, -3, -1, -1, };