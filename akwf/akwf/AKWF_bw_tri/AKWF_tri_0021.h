#define DATA_LENGTH 512
#define DATA AKWF_tri_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 9, 13, 15, 17, 20, 22, 23, 26,
28, 30, 31, 33, 34, 36, 37, 38, 40, 41, 43, 44, 45, 47, 48, 50, 51, 51, 52, 54,
54, 56, 56, 58, 58, 60, 61, 62, 63, 63, 65, 66, 66, 67, 69, 69, 69, 71, 72, 72,
73, 74, 74, 75, 76, 76, 78, 79, 79, 80, 81, 83, 82, 84, 84, 85, 85, 86, 86, 88,
89, 89, 90, 90, 91, 91, 92, 92, 93, 94, 95, 96, 96, 97, 97, 97, 98, 99, 100,
100, 101, 101, 103, 103, 103, 104, 104, 106, 105, 105, 107, 107, 108, 108, 109,
109, 110, 111, 110, 111, 111, 111, 113, 113, 114, 114, 114, 115, 116, 116, 116,
117, 116, 117, 118, 118, 118, 118, 119, 119, 118, 117, 117, 117, 115, 115, 114,
114, 113, 112, 112, 111, 110, 109, 109, 108, 108, 107, 105, 105, 105, 104, 103,
102, 102, 101, 102, 99, 99, 99, 98, 97, 96, 96, 96, 95, 94, 93, 92, 92, 91, 91,
90, 90, 89, 88, 88, 87, 86, 84, 84, 84, 83, 83, 82, 81, 80, 79, 79, 78, 77, 77,
75, 75, 75, 74, 72, 72, 71, 70, 69, 68, 68, 67, 66, 65, 64, 63, 63, 61, 61, 60,
60, 58, 58, 57, 55, 55, 54, 53, 52, 51, 49, 50, 48, 47, 46, 45, 44, 42, 41, 41,
39, 39, 37, 36, 33, 34, 32, 30, 30, 27, 26, 25, 23, 22, 20, 19, 17, 15, 13, 11,
9, 6, 3, 2, -3, -5, -10, -13, -16, -18, -21, -22, -25, -27, -27, -30, -32, -33,
-34, -36, -38, -39, -39, -42, -43, -44, -46, -47, -48, -49, -50, -52, -53, -54,
-55, -55, -57, -58, -58, -59, -61, -62, -63, -64, -65, -66, -67, -67, -68, -69,
-70, -71, -71, -73, -74, -73, -75, -76, -76, -77, -78, -79, -80, -80, -81, -82,
-83, -83, -84, -85, -85, -87, -87, -88, -88, -89, -90, -90, -91, -92, -92, -93,
-93, -94, -94, -95, -96, -96, -98, -98, -98, -100, -99, -101, -101, -102, -102,
-103, -103, -104, -104, -105, -106, -105, -107, -107, -108, -108, -109, -109,
-110, -110, -111, -111, -112, -112, -113, -113, -114, -114, -114, -114, -115,
-116, -117, -116, -116, -117, -118, -118, -118, -118, -119, -119, -119, -118,
-117, -116, -116, -115, -115, -114, -113, -112, -111, -110, -110, -110, -109,
-108, -106, -106, -106, -105, -104, -103, -103, -102, -102, -101, -101, -100,
-99, -99, -98, -97, -96, -96, -95, -95, -94, -93, -93, -92, -92, -90, -89, -90,
-89, -88, -88, -87, -86, -85, -84, -83, -83, -82, -81, -81, -80, -79, -78, -78,
-77, -76, -76, -75, -74, -74, -72, -72, -71, -70, -69, -69, -68, -67, -66, -66,
-64, -63, -63, -62, -61, -61, -60, -58, -57, -57, -56, -54, -53, -53, -52, -51,
-50, -49, -49, -47, -46, -44, -44, -43, -42, -41, -38, -37, -37, -36, -34, -33,
-31, -31, -29, -28, -27, -24, -24, -22, -20, -18, -16, -15, -13, -10, -8, -5,
-3, -1, };