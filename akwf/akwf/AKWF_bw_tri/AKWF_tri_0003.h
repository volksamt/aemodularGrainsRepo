#define DATA_LENGTH 512
#define DATA AKWF_tri_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 6, 7, 8, 10, 11, 13, 14, 14,
17, 17, 19, 20, 22, 24, 25, 27, 29, 30, 33, 35, 37, 38, 42, 44, 46, 48, 51, 54,
58, 60, 62, 65, 67, 70, 72, 75, 78, 80, 83, 86, 88, 90, 92, 94, 96, 97, 99, 102,
103, 105, 106, 106, 108, 108, 109, 112, 112, 113, 113, 115, 115, 115, 115, 116,
116, 117, 118, 117, 118, 117, 118, 118, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119, 118, 118, 118, 118, 118,
118, 117, 117, 117, 117, 116, 116, 115, 115, 114, 113, 113, 112, 111, 111, 110,
108, 108, 106, 106, 105, 104, 104, 102, 102, 102, 101, 101, 100, 99, 99, 98, 97,
97, 97, 96, 96, 96, 96, 95, 94, 94, 93, 94, 94, 92, 93, 92, 93, 92, 92, 91, 92,
92, 92, 91, 90, 90, 91, 90, 89, 90, 90, 89, 89, 89, 89, 89, 88, 88, 87, 87, 87,
87, 86, 86, 86, 85, 84, 84, 84, 84, 83, 82, 82, 81, 81, 80, 80, 79, 78, 78, 77,
76, 75, 74, 75, 73, 73, 72, 71, 70, 70, 69, 67, 67, 66, 65, 64, 63, 63, 61, 59,
59, 57, 56, 56, 55, 53, 52, 51, 49, 49, 47, 46, 45, 44, 42, 41, 39, 38, 37, 35,
33, 32, 31, 30, 28, 27, 26, 25, 23, 21, 19, 18, 16, 16, 14, 12, 11, 10, 8, 6, 6,
4, 3, 0, -1, -2, -4, -6, -7, -8, -9, -11, -13, -13, -15, -16, -17, -20, -20,
-22, -23, -25, -26, -29, -30, -32, -34, -36, -38, -41, -43, -46, -48, -50, -53,
-56, -59, -61, -65, -67, -69, -73, -74, -77, -80, -82, -84, -87, -89, -91, -93,
-95, -97, -99, -100, -102, -103, -106, -107, -108, -109, -109, -111, -112, -113,
-114, -114, -115, -115, -116, -116, -116, -117, -117, -118, -118, -118, -118,
-118, -119, -119, -118, -119, -118, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -118, -118, -118, -119, -118, -118, -118, -118, -117,
-117, -117, -117, -116, -116, -115, -115, -115, -114, -114, -113, -112, -111,
-111, -110, -109, -108, -107, -106, -106, -105, -104, -103, -103, -102, -101,
-100, -100, -100, -98, -98, -98, -98, -97, -96, -96, -96, -95, -95, -94, -94,
-94, -93, -94, -93, -93, -93, -93, -92, -92, -92, -92, -92, -91, -91, -91, -90,
-90, -90, -90, -90, -89, -90, -89, -89, -89, -88, -88, -88, -88, -88, -87, -86,
-85, -86, -86, -85, -85, -84, -83, -84, -83, -83, -82, -82, -81, -80, -79, -78,
-78, -78, -77, -77, -76, -76, -75, -73, -73, -72, -72, -71, -69, -69, -67, -67,
-65, -64, -65, -63, -62, -61, -60, -58, -58, -56, -56, -54, -53, -51, -51, -50,
-49, -48, -45, -44, -44, -42, -41, -40, -38, -37, -36, -34, -33, -31, -30, -28,
-27, -26, -24, -23, -22, -20, -19, -17, -16, -14, -13, -12, -10, -8, -6, -5, -4,
-2, 0, };