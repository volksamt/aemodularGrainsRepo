#define DATA_LENGTH 512
#define DATA AKWF_tri_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 19, 27, 31, 35, 37, 40, 43, 45, 48,
49, 51, 52, 54, 56, 57, 59, 60, 62, 63, 65, 65, 67, 68, 69, 71, 72, 72, 74, 75,
75, 77, 77, 79, 79, 79, 82, 82, 82, 83, 85, 85, 85, 86, 88, 87, 89, 90, 90, 91,
91, 91, 92, 94, 94, 95, 94, 95, 95, 96, 97, 97, 98, 99, 99, 99, 100, 101, 101,
101, 102, 102, 103, 103, 104, 104, 104, 105, 106, 106, 107, 106, 106, 107, 107,
109, 108, 108, 109, 110, 109, 110, 111, 111, 112, 112, 112, 112, 113, 114, 113,
113, 114, 114, 114, 115, 114, 115, 116, 116, 116, 116, 117, 117, 117, 117, 117,
117, 117, 118, 119, 118, 118, 118, 118, 118, 119, 119, 118, 120, 118, 118, 118,
117, 116, 116, 117, 116, 115, 115, 114, 114, 114, 113, 112, 111, 112, 111, 111,
111, 110, 110, 109, 109, 109, 109, 108, 107, 107, 106, 106, 105, 104, 105, 104,
104, 103, 102, 102, 102, 102, 100, 100, 100, 100, 100, 99, 98, 98, 97, 96, 95,
96, 95, 94, 93, 94, 93, 93, 91, 92, 90, 90, 89, 88, 88, 88, 87, 87, 86, 84, 84,
84, 84, 82, 82, 80, 81, 79, 78, 78, 77, 77, 75, 75, 75, 74, 72, 72, 72, 70, 70,
68, 67, 67, 65, 64, 64, 62, 61, 60, 59, 58, 57, 56, 55, 53, 52, 50, 48, 46, 45,
44, 43, 40, 39, 38, 35, 32, 30, 28, 25, 21, 18, 12, 5, -8, -20, -28, -33, -35,
-38, -40, -43, -45, -48, -49, -51, -53, -55, -57, -58, -59, -61, -62, -64, -65,
-66, -67, -68, -70, -71, -72, -73, -74, -75, -76, -77, -78, -78, -79, -80, -81,
-82, -83, -84, -84, -85, -85, -86, -87, -88, -88, -89, -90, -90, -91, -91, -93,
-93, -93, -94, -95, -95, -95, -96, -96, -97, -98, -98, -99, -99, -101, -100,
-101, -101, -102, -103, -102, -103, -104, -104, -105, -105, -106, -105, -107,
-107, -107, -108, -108, -109, -109, -109, -110, -110, -110, -111, -111, -112,
-112, -112, -112, -112, -112, -113, -114, -113, -114, -114, -115, -115, -115,
-115, -115, -116, -116, -116, -115, -117, -117, -117, -117, -118, -118, -118,
-117, -118, -118, -119, -119, -120, -119, -119, -118, -119, -118, -118, -118,
-116, -117, -116, -116, -115, -115, -114, -114, -114, -114, -113, -113, -112,
-111, -111, -111, -111, -110, -110, -109, -109, -109, -109, -108, -107, -106,
-107, -105, -105, -105, -105, -104, -104, -104, -102, -102, -102, -102, -101,
-101, -100, -100, -98, -98, -98, -97, -97, -96, -95, -96, -95, -94, -94, -93,
-92, -92, -92, -91, -90, -89, -90, -88, -88, -87, -87, -86, -86, -85, -84, -84,
-83, -82, -82, -80, -80, -79, -78, -78, -77, -77, -75, -75, -74, -73, -72, -71,
-71, -70, -70, -68, -68, -66, -64, -64, -64, -61, -61, -60, -58, -58, -57, -55,
-54, -53, -51, -50, -49, -47, -45, -43, -42, -41, -39, -36, -35, -32, -30, -27,
-25, -21, -17, -12, -3, };