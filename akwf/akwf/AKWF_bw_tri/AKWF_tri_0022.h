#define DATA_LENGTH 512
#define DATA AKWF_tri_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 7, 14, 17, 22, 24, 26, 29, 32, 34,
36, 38, 40, 41, 43, 44, 46, 47, 48, 51, 51, 53, 54, 55, 56, 57, 59, 60, 61, 62,
62, 64, 65, 66, 67, 67, 68, 69, 71, 71, 72, 73, 73, 75, 75, 76, 78, 77, 78, 79,
80, 81, 81, 82, 83, 84, 84, 85, 86, 86, 88, 88, 89, 90, 90, 91, 91, 92, 92, 92,
93, 94, 95, 95, 95, 97, 97, 97, 98, 98, 99, 100, 100, 101, 101, 101, 102, 102,
104, 103, 104, 105, 105, 105, 106, 106, 107, 108, 108, 109, 109, 110, 110, 111,
110, 111, 112, 112, 112, 113, 113, 113, 114, 115, 115, 115, 115, 116, 116, 117,
117, 117, 118, 118, 118, 119, 118, 119, 119, 119, 119, 118, 117, 117, 116, 115,
115, 115, 114, 113, 113, 112, 111, 111, 110, 109, 110, 109, 108, 108, 107, 106,
105, 105, 104, 103, 103, 102, 102, 102, 101, 101, 100, 100, 99, 98, 98, 97, 97,
97, 96, 96, 94, 94, 94, 93, 92, 92, 91, 91, 89, 88, 88, 87, 87, 86, 85, 85, 83,
84, 82, 83, 81, 81, 80, 79, 78, 78, 77, 76, 76, 75, 75, 74, 72, 73, 72, 70, 69,
69, 68, 67, 67, 66, 65, 64, 63, 62, 61, 60, 59, 58, 58, 57, 55, 54, 53, 52, 52,
50, 50, 49, 47, 46, 45, 44, 42, 42, 41, 38, 37, 36, 34, 32, 31, 29, 28, 26, 23,
22, 20, 17, 14, 12, 9, 4, -1, -7, -13, -18, -22, -25, -27, -30, -32, -34, -36,
-38, -39, -42, -42, -44, -46, -47, -49, -50, -52, -53, -54, -54, -56, -57, -59,
-60, -61, -61, -64, -64, -65, -66, -66, -67, -69, -70, -70, -72, -72, -73, -75,
-74, -75, -77, -77, -77, -78, -80, -80, -81, -81, -82, -83, -84, -85, -85, -86,
-87, -86, -89, -89, -89, -90, -91, -91, -92, -92, -93, -94, -94, -95, -95, -96,
-96, -98, -97, -98, -99, -99, -99, -101, -101, -102, -102, -103, -103, -103,
-104, -104, -105, -105, -106, -106, -107, -107, -108, -108, -109, -110, -109,
-110, -111, -111, -111, -112, -112, -112, -112, -114, -113, -114, -114, -115,
-115, -115, -116, -116, -117, -117, -117, -116, -118, -117, -118, -119, -119,
-119, -119, -119, -118, -117, -117, -115, -116, -115, -114, -113, -113, -113,
-113, -111, -110, -110, -111, -109, -109, -108, -108, -107, -106, -106, -105,
-105, -104, -103, -103, -103, -102, -101, -101, -101, -99, -99, -98, -97, -98,
-97, -96, -95, -95, -95, -94, -93, -93, -91, -91, -91, -90, -90, -89, -89, -87,
-88, -87, -86, -85, -84, -83, -83, -82, -81, -81, -80, -79, -78, -78, -77, -77,
-76, -75, -75, -74, -72, -71, -71, -70, -70, -68, -69, -67, -66, -65, -65, -65,
-62, -62, -62, -60, -59, -59, -58, -56, -56, -55, -53, -53, -52, -51, -49, -48,
-46, -45, -44, -44, -42, -41, -39, -39, -37, -35, -34, -32, -30, -30, -27, -26,
-24, -22, -19, -17, -14, -11, -8, -4, };