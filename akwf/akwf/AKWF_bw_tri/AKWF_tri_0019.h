#define DATA_LENGTH 512
#define DATA AKWF_tri_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 2, 4, 6, 6, 8, 10, 11, 13, 14, 15,
15, 17, 18, 20, 20, 22, 23, 25, 26, 27, 28, 29, 30, 31, 32, 33, 35, 35, 37, 37,
39, 41, 40, 42, 43, 44, 46, 46, 47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 56, 58,
58, 60, 60, 62, 63, 63, 64, 66, 66, 67, 67, 68, 69, 71, 71, 72, 73, 74, 74, 76,
76, 77, 78, 79, 80, 81, 81, 82, 83, 84, 85, 85, 87, 87, 88, 89, 90, 91, 91, 92,
93, 94, 95, 95, 96, 96, 97, 98, 99, 100, 100, 101, 102, 103, 103, 104, 105, 106,
106, 108, 108, 108, 109, 110, 111, 111, 112, 112, 113, 114, 114, 115, 115, 115,
116, 117, 118, 118, 119, 119, 119, 117, 117, 116, 115, 114, 113, 112, 112, 109,
109, 108, 108, 106, 105, 104, 103, 102, 103, 101, 100, 99, 98, 97, 96, 96, 95,
94, 93, 92, 91, 90, 89, 88, 88, 88, 85, 85, 84, 84, 83, 82, 81, 80, 79, 79, 78,
77, 76, 74, 75, 73, 72, 71, 71, 70, 70, 68, 67, 67, 65, 65, 64, 63, 62, 62, 61,
60, 59, 58, 57, 55, 56, 54, 53, 52, 51, 51, 50, 48, 47, 47, 46, 44, 44, 43, 43,
41, 40, 39, 38, 37, 37, 35, 35, 33, 33, 31, 30, 29, 28, 27, 27, 25, 24, 23, 23,
21, 20, 19, 18, 17, 16, 13, 13, 12, 10, 10, 8, 7, 6, 5, 4, 2, 1, -1, -3, -4, -5,
-7, -8, -9, -11, -12, -13, -14, -17, -17, -19, -20, -21, -22, -23, -24, -26,
-27, -28, -29, -31, -32, -33, -34, -34, -36, -37, -38, -39, -40, -41, -42, -43,
-44, -45, -46, -47, -48, -49, -50, -51, -52, -53, -54, -55, -56, -57, -57, -59,
-60, -61, -61, -62, -63, -64, -66, -66, -66, -68, -69, -70, -70, -71, -72, -72,
-74, -75, -76, -76, -77, -78, -79, -80, -81, -81, -83, -83, -84, -85, -85, -86,
-88, -88, -89, -90, -91, -92, -92, -93, -94, -95, -95, -96, -97, -97, -99, -100,
-101, -101, -101, -102, -103, -104, -104, -105, -106, -107, -107, -108, -108,
-109, -110, -110, -111, -112, -112, -113, -113, -114, -115, -116, -116, -116,
-117, -117, -118, -119, -119, -119, -118, -117, -115, -115, -114, -114, -112,
-111, -110, -110, -108, -107, -106, -106, -105, -104, -102, -101, -100, -99,
-100, -97, -97, -96, -95, -94, -94, -93, -91, -91, -90, -89, -88, -88, -86, -86,
-85, -84, -83, -82, -82, -82, -81, -79, -78, -78, -76, -76, -75, -74, -72, -72,
-71, -71, -69, -70, -68, -67, -66, -66, -65, -64, -63, -61, -61, -60, -60, -59,
-58, -57, -55, -55, -53, -53, -51, -51, -50, -49, -49, -48, -46, -45, -44, -44,
-42, -42, -41, -40, -39, -38, -37, -36, -35, -34, -33, -32, -31, -31, -30, -28,
-28, -26, -24, -24, -23, -22, -21, -20, -19, -17, -15, -15, -14, -13, -12, -11,
-10, -8, -7, -5, -4, -3, -2, 0, };