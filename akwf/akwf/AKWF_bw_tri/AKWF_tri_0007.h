#define DATA_LENGTH 512
#define DATA AKWF_tri_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 1, 3, 3, 4, 5, 6, 6, 6, 8, 9,
10, 9, 11, 12, 12, 13, 14, 14, 16, 16, 16, 16, 18, 19, 19, 19, 21, 22, 23, 23,
23, 25, 25, 26, 27, 27, 29, 30, 30, 30, 31, 33, 33, 34, 35, 35, 37, 38, 39, 39,
40, 41, 43, 43, 44, 45, 46, 48, 49, 50, 50, 52, 53, 54, 55, 55, 56, 57, 59, 60,
61, 62, 62, 64, 65, 66, 67, 67, 68, 70, 71, 72, 72, 74, 75, 76, 77, 79, 79, 81,
82, 83, 83, 84, 85, 87, 87, 88, 89, 89, 92, 92, 93, 93, 95, 95, 96, 98, 98, 99,
100, 101, 102, 102, 103, 104, 105, 106, 107, 107, 108, 110, 110, 111, 113, 113,
115, 115, 115, 117, 116, 117, 118, 118, 118, 119, 119, 118, 119, 119, 119, 119,
119, 118, 118, 118, 117, 117, 116, 116, 114, 115, 114, 114, 112, 111, 110, 110,
109, 108, 107, 107, 105, 105, 104, 103, 102, 101, 101, 98, 98, 97, 96, 95, 94,
93, 91, 91, 90, 88, 87, 86, 85, 84, 83, 82, 81, 80, 79, 77, 77, 74, 74, 73, 72,
70, 70, 68, 67, 66, 65, 63, 62, 60, 58, 57, 56, 55, 53, 52, 51, 49, 48, 48, 46,
44, 43, 42, 40, 39, 37, 36, 35, 34, 33, 32, 30, 28, 28, 26, 24, 24, 22, 21, 20,
19, 17, 17, 15, 14, 14, 12, 12, 10, 9, 8, 6, 6, 5, 4, 3, 3, 2, 0, -1, -1, -2,
-3, -4, -4, -5, -6, -6, -8, -8, -8, -10, -11, -11, -12, -12, -13, -14, -14, -15,
-15, -17, -17, -18, -18, -20, -20, -20, -21, -23, -23, -24, -24, -25, -26, -26,
-27, -29, -29, -30, -32, -32, -32, -33, -35, -35, -37, -36, -38, -39, -40, -41,
-41, -42, -43, -44, -45, -47, -48, -47, -50, -50, -51, -52, -53, -55, -56, -56,
-58, -58, -59, -61, -62, -63, -64, -65, -65, -67, -67, -70, -70, -72, -73, -73,
-74, -75, -77, -77, -78, -78, -80, -81, -82, -84, -84, -85, -86, -87, -88, -89,
-91, -91, -92, -93, -93, -95, -96, -96, -97, -99, -100, -100, -101, -102, -103,
-103, -104, -105, -106, -107, -109, -108, -111, -110, -111, -113, -113, -114,
-116, -115, -116, -117, -116, -118, -118, -118, -118, -119, -119, -119, -119,
-120, -119, -119, -119, -117, -118, -118, -117, -117, -116, -116, -115, -114,
-114, -112, -111, -111, -111, -109, -108, -108, -107, -105, -105, -103, -103,
-101, -101, -100, -99, -98, -98, -96, -94, -94, -93, -92, -90, -89, -88, -88,
-86, -85, -84, -83, -82, -81, -80, -79, -77, -76, -75, -73, -73, -72, -71, -69,
-68, -66, -66, -64, -63, -62, -60, -59, -58, -56, -56, -54, -53, -52, -50, -48,
-47, -46, -45, -43, -42, -40, -39, -38, -36, -35, -33, -33, -31, -30, -28, -27,
-26, -24, -23, -22, -21, -20, -18, -17, -16, -15, -14, -13, -13, -11, -10, -8,
-7, -7, -5, -5, -4, -3, -2, -1, -1, };