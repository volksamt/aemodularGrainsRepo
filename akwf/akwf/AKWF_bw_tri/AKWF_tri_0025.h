#define DATA_LENGTH 512
#define DATA AKWF_tri_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 20, 28, 33, 37, 39, 42, 45, 47, 50,
52, 53, 55, 57, 58, 60, 62, 63, 64, 66, 67, 69, 70, 71, 72, 73, 74, 75, 76, 77,
79, 79, 79, 81, 82, 83, 83, 84, 85, 86, 86, 87, 88, 88, 90, 91, 91, 91, 92, 93,
93, 94, 94, 95, 97, 96, 98, 97, 98, 99, 100, 99, 100, 101, 101, 102, 102, 103,
102, 104, 104, 104, 105, 105, 105, 106, 106, 106, 107, 107, 109, 108, 108, 109,
110, 109, 110, 110, 111, 111, 111, 111, 112, 112, 112, 112, 113, 113, 113, 114,
114, 114, 114, 114, 116, 115, 116, 116, 116, 116, 117, 116, 116, 117, 117, 117,
117, 118, 118, 118, 118, 118, 118, 119, 118, 119, 119, 118, 119, 118, 119, 118,
118, 117, 117, 116, 117, 116, 116, 115, 115, 114, 114, 113, 113, 112, 113, 112,
112, 112, 112, 111, 111, 110, 110, 110, 108, 108, 108, 108, 107, 107, 106, 106,
105, 105, 105, 103, 104, 104, 103, 103, 102, 102, 101, 100, 101, 99, 99, 99, 99,
98, 97, 97, 96, 96, 95, 95, 94, 94, 93, 93, 92, 91, 91, 90, 90, 88, 89, 87, 88,
86, 86, 86, 85, 84, 83, 83, 82, 81, 81, 79, 79, 79, 78, 76, 76, 75, 73, 73, 72,
71, 71, 69, 69, 68, 67, 66, 65, 64, 63, 61, 60, 60, 58, 57, 56, 54, 53, 51, 49,
48, 47, 44, 43, 42, 39, 37, 34, 32, 29, 26, 23, 20, 14, 5, -8, -21, -30, -35,
-37, -40, -42, -45, -47, -50, -51, -54, -56, -57, -59, -61, -62, -63, -64, -66,
-68, -69, -70, -71, -72, -73, -74, -75, -77, -77, -78, -79, -79, -82, -82, -83,
-83, -85, -85, -86, -87, -88, -88, -89, -89, -91, -91, -91, -92, -93, -93, -94,
-94, -96, -96, -96, -97, -98, -98, -98, -99, -100, -100, -100, -101, -101, -101,
-103, -103, -103, -103, -105, -106, -105, -105, -106, -106, -106, -107, -107,
-108, -108, -109, -109, -109, -110, -109, -110, -110, -111, -111, -112, -112,
-112, -112, -112, -113, -113, -114, -114, -115, -115, -114, -114, -115, -116,
-116, -115, -116, -116, -117, -116, -117, -117, -117, -117, -118, -118, -118,
-118, -117, -117, -119, -119, -118, -119, -119, -119, -119, -119, -119, -118,
-117, -117, -117, -117, -117, -116, -115, -115, -115, -115, -114, -114, -114,
-113, -112, -112, -112, -111, -111, -110, -110, -110, -109, -109, -109, -108,
-109, -108, -107, -107, -106, -106, -105, -105, -104, -104, -104, -104, -102,
-103, -102, -102, -101, -100, -100, -100, -99, -99, -98, -98, -98, -97, -96,
-95, -95, -95, -94, -94, -93, -93, -92, -91, -91, -91, -90, -89, -88, -88, -87,
-87, -86, -85, -85, -85, -83, -82, -81, -81, -81, -80, -78, -78, -78, -76, -75,
-75, -75, -73, -72, -71, -70, -70, -68, -68, -67, -66, -64, -63, -62, -61, -60,
-60, -58, -56, -55, -54, -53, -50, -49, -47, -46, -44, -42, -40, -39, -36, -34,
-31, -30, -26, -22, -19, -13, -4, };