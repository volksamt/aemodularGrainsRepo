#define DATA_LENGTH 512
#define DATA AKWF_tri_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 7, 9, 11, 13, 15, 15, 17, 19,
21, 22, 24, 25, 26, 27, 29, 30, 32, 33, 34, 35, 36, 38, 39, 39, 41, 42, 43, 45,
45, 46, 47, 48, 50, 51, 52, 53, 54, 55, 56, 56, 57, 58, 59, 61, 61, 62, 63, 65,
66, 66, 67, 67, 68, 70, 71, 71, 72, 72, 73, 75, 75, 76, 76, 78, 78, 79, 81, 81,
81, 82, 83, 84, 84, 85, 86, 88, 87, 89, 89, 90, 90, 92, 93, 93, 94, 94, 96, 96,
96, 97, 98, 99, 100, 101, 101, 101, 102, 103, 103, 104, 105, 105, 106, 107, 107,
108, 109, 110, 109, 110, 110, 111, 112, 112, 113, 113, 114, 115, 115, 115, 116,
117, 118, 118, 118, 119, 119, 119, 119, 117, 116, 115, 115, 114, 114, 112, 112,
111, 109, 108, 108, 107, 106, 106, 104, 104, 102, 103, 101, 101, 100, 100, 98,
97, 97, 96, 95, 94, 93, 93, 92, 92, 90, 89, 89, 88, 88, 87, 85, 85, 84, 84, 82,
82, 82, 80, 79, 79, 78, 77, 76, 76, 74, 74, 73, 72, 72, 70, 70, 70, 68, 67, 66,
66, 64, 64, 63, 63, 61, 60, 59, 58, 58, 58, 56, 55, 54, 53, 52, 52, 51, 50, 48,
47, 46, 46, 45, 44, 43, 42, 41, 40, 39, 38, 37, 35, 34, 33, 32, 32, 31, 30, 28,
27, 26, 25, 24, 23, 21, 19, 18, 17, 16, 14, 13, 13, 10, 8, 7, 6, 4, 2, 1, -1,
-3, -6, -8, -10, -12, -13, -15, -16, -18, -19, -21, -23, -24, -25, -27, -28,
-30, -30, -32, -33, -34, -36, -37, -37, -38, -39, -41, -42, -44, -45, -45, -47,
-48, -49, -50, -51, -52, -52, -54, -54, -56, -57, -57, -59, -59, -60, -61, -62,
-62, -65, -65, -66, -67, -68, -69, -69, -70, -71, -72, -73, -73, -74, -75, -76,
-77, -78, -78, -79, -81, -80, -81, -82, -83, -83, -84, -85, -86, -87, -87, -88,
-90, -90, -91, -91, -92, -94, -94, -95, -96, -96, -97, -97, -99, -99, -99, -99,
-101, -102, -102, -103, -104, -104, -104, -105, -106, -107, -107, -108, -109,
-109, -110, -110, -110, -112, -111, -112, -113, -114, -114, -114, -116, -115,
-117, -117, -117, -117, -118, -119, -120, -119, -118, -117, -116, -115, -115,
-114, -113, -112, -111, -110, -110, -109, -108, -107, -107, -105, -105, -104,
-103, -102, -101, -100, -99, -99, -98, -97, -97, -96, -95, -94, -92, -93, -92,
-91, -90, -90, -89, -88, -87, -87, -85, -84, -84, -83, -82, -81, -81, -80, -79,
-79, -78, -78, -77, -76, -75, -74, -73, -72, -72, -70, -70, -69, -68, -67, -66,
-66, -65, -64, -62, -61, -60, -60, -58, -58, -58, -56, -56, -55, -55, -53, -53,
-51, -50, -49, -48, -47, -47, -45, -44, -44, -43, -41, -41, -39, -39, -38, -37,
-36, -34, -34, -33, -32, -30, -29, -27, -27, -26, -25, -23, -22, -21, -20, -18,
-17, -16, -14, -13, -12, -10, -8, -7, -6, -3, -1, 0, };