#define DATA_LENGTH 512
#define DATA AKWF_tri_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 1, 0, 1, 1, 2, 2, 2, 2, 2, 2,
3, 2, 2, 2, 2, 2, 3, 3, 3, 3, 2, 3, 3, 3, 3, 3, 4, 4, 4, 4, 4, 5, 4, 5, 5, 6, 6,
6, 7, 8, 7, 8, 7, 8, 9, 10, 9, 10, 10, 11, 12, 12, 12, 13, 14, 14, 14, 16, 15,
17, 17, 17, 19, 19, 20, 21, 22, 22, 23, 23, 24, 25, 26, 27, 28, 28, 28, 31, 31,
32, 32, 34, 34, 36, 37, 38, 39, 40, 41, 41, 44, 44, 46, 47, 47, 49, 50, 52, 53,
54, 55, 56, 58, 60, 61, 62, 63, 65, 66, 67, 69, 70, 72, 73, 75, 75, 78, 79, 81,
83, 84, 85, 87, 89, 90, 91, 93, 95, 97, 98, 100, 100, 103, 105, 106, 107, 109,
111, 112, 114, 116, 118, 118, 119, 117, 114, 111, 110, 107, 105, 103, 100, 98,
96, 93, 92, 90, 88, 86, 84, 82, 79, 78, 76, 74, 73, 71, 69, 67, 67, 64, 63, 62,
59, 59, 58, 56, 55, 53, 51, 51, 49, 48, 47, 45, 44, 44, 42, 42, 40, 39, 38, 37,
35, 35, 33, 32, 32, 31, 30, 29, 28, 27, 26, 26, 25, 25, 23, 21, 21, 20, 20, 19,
18, 18, 17, 16, 15, 14, 15, 13, 13, 13, 12, 11, 10, 11, 10, 10, 8, 8, 8, 7, 6,
6, 6, 5, 5, 5, 5, 4, 4, 3, 3, 2, 2, 2, 1, 1, 1, 0, 0, -1, 0, -1, 0, 0, -1, -1,
-1, -1, -1, -2, -2, -1, -2, -2, -2, -2, -3, -3, -3, -3, -3, -2, -2, -3, -4, -3,
-4, -4, -4, -3, -4, -4, -5, -5, -5, -4, -6, -6, -6, -6, -6, -7, -7, -7, -8, -8,
-8, -8, -9, -9, -10, -11, -11, -12, -12, -12, -13, -14, -14, -14, -15, -16, -16,
-18, -18, -18, -19, -20, -21, -21, -22, -22, -23, -24, -25, -26, -27, -28, -29,
-29, -30, -31, -33, -33, -34, -35, -36, -37, -38, -39, -40, -41, -42, -44, -45,
-46, -46, -49, -50, -50, -52, -53, -55, -56, -57, -58, -60, -61, -62, -64, -64,
-67, -68, -69, -70, -72, -73, -75, -77, -79, -79, -81, -83, -84, -86, -87, -89,
-91, -91, -93, -95, -97, -98, -99, -101, -102, -105, -106, -108, -110, -111,
-113, -114, -116, -118, -119, -119, -117, -114, -112, -110, -107, -104, -102,
-100, -97, -95, -93, -91, -89, -87, -85, -83, -81, -80, -78, -76, -75, -73, -71,
-69, -68, -66, -65, -63, -61, -60, -58, -57, -56, -54, -53, -51, -50, -49, -47,
-46, -45, -44, -43, -42, -41, -39, -39, -38, -36, -36, -35, -34, -32, -32, -31,
-30, -30, -28, -27, -26, -25, -24, -23, -22, -23, -21, -21, -20, -18, -19, -17,
-16, -16, -16, -15, -15, -14, -13, -12, -11, -11, -11, -11, -10, -9, -8, -9, -8,
-7, -7, -6, -6, -6, -6, -5, -5, -3, -4, -4, -2, -2, -3, -1, -1, -1, -1, -1, 0,
0, };