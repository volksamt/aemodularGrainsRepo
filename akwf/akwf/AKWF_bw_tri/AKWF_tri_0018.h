#define DATA_LENGTH 512
#define DATA AKWF_tri_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 2, 2, 3, 5, 5, 6, 7, 9, 9, 10,
11, 12, 13, 14, 16, 16, 17, 18, 19, 20, 21, 21, 23, 24, 25, 26, 26, 27, 28, 30,
30, 31, 32, 33, 34, 34, 36, 37, 38, 39, 39, 41, 41, 43, 43, 44, 45, 46, 47, 48,
49, 50, 51, 52, 53, 54, 56, 55, 57, 59, 58, 60, 62, 61, 63, 64, 64, 66, 66, 67,
69, 69, 70, 71, 72, 73, 73, 75, 76, 77, 78, 78, 79, 80, 81, 81, 83, 84, 85, 86,
86, 88, 89, 90, 91, 92, 92, 94, 95, 95, 96, 97, 98, 99, 99, 101, 102, 102, 103,
103, 104, 106, 107, 107, 107, 108, 109, 110, 111, 111, 113, 114, 114, 115, 114,
116, 117, 118, 119, 118, 119, 119, 117, 115, 114, 114, 113, 111, 110, 109, 109,
107, 105, 105, 104, 102, 101, 101, 99, 98, 98, 96, 95, 94, 92, 91, 90, 90, 89,
87, 86, 86, 85, 84, 83, 81, 80, 80, 79, 79, 77, 77, 75, 74, 73, 73, 72, 71, 70,
69, 68, 67, 66, 65, 64, 63, 62, 61, 60, 59, 58, 57, 56, 55, 56, 54, 54, 51, 50,
50, 50, 49, 48, 47, 45, 44, 44, 43, 42, 40, 39, 39, 38, 37, 36, 36, 34, 34, 33,
31, 31, 30, 29, 27, 28, 26, 26, 24, 23, 23, 21, 21, 19, 19, 18, 17, 16, 16, 15,
14, 12, 12, 11, 10, 9, 8, 8, 7, 5, 4, 4, 2, 1, 0, 0, -1, -2, -3, -4, -5, -6, -6,
-7, -8, -9, -11, -11, -12, -13, -13, -16, -15, -16, -18, -18, -19, -21, -22,
-22, -24, -25, -26, -27, -27, -29, -30, -30, -31, -32, -33, -35, -35, -36, -37,
-39, -39, -41, -41, -42, -42, -43, -45, -46, -47, -48, -49, -49, -51, -51, -53,
-53, -55, -56, -57, -58, -59, -58, -59, -61, -62, -63, -63, -64, -66, -67, -67,
-68, -70, -71, -71, -71, -73, -74, -75, -76, -77, -78, -79, -80, -80, -81, -83,
-83, -84, -86, -86, -87, -88, -89, -89, -90, -92, -93, -93, -95, -94, -96, -97,
-98, -99, -100, -101, -101, -103, -103, -104, -105, -105, -106, -106, -108,
-109, -110, -110, -111, -112, -112, -113, -114, -115, -115, -116, -117, -117,
-119, -119, -119, -119, -117, -116, -116, -113, -113, -111, -110, -108, -108,
-107, -106, -104, -103, -102, -101, -100, -99, -98, -98, -96, -94, -94, -93,
-92, -91, -90, -88, -88, -86, -86, -84, -83, -83, -82, -81, -80, -79, -78, -77,
-75, -75, -75, -74, -73, -71, -70, -69, -69, -68, -66, -65, -65, -64, -63, -61,
-61, -60, -59, -58, -57, -56, -56, -55, -54, -53, -52, -51, -50, -50, -48, -48,
-46, -45, -45, -43, -42, -41, -41, -40, -39, -38, -38, -36, -36, -34, -33, -33,
-31, -31, -30, -30, -29, -27, -26, -25, -24, -24, -22, -22, -21, -20, -19, -19,
-18, -16, -16, -14, -14, -13, -12, -10, -10, -8, -8, -6, -5, -5, -5, -3, -3, -2,
-1, };