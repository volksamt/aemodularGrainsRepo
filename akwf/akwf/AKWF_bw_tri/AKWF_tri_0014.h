#define DATA_LENGTH 512
#define DATA AKWF_tri_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 1, 1, 0, 2, 1, 2, 2, 2, 3, 2,
2, 3, 3, 2, 2, 3, 4, 3, 3, 4, 4, 4, 5, 5, 5, 5, 5, 5, 6, 6, 7, 7, 7, 7, 8, 8, 8,
9, 10, 10, 11, 10, 11, 12, 12, 12, 13, 13, 14, 15, 15, 16, 16, 16, 18, 18, 19,
19, 21, 20, 21, 23, 23, 24, 24, 26, 26, 27, 28, 29, 30, 30, 32, 33, 33, 34, 36,
36, 37, 38, 39, 40, 41, 42, 43, 44, 46, 46, 48, 49, 49, 51, 52, 53, 55, 56, 57,
59, 61, 61, 63, 63, 65, 66, 68, 69, 70, 72, 73, 75, 77, 77, 79, 80, 82, 83, 85,
86, 87, 90, 91, 91, 94, 96, 96, 98, 100, 101, 103, 104, 106, 107, 110, 111, 111,
113, 114, 116, 118, 119, 118, 117, 114, 110, 109, 106, 105, 103, 100, 98, 96,
94, 92, 90, 88, 86, 84, 82, 81, 79, 77, 76, 74, 73, 70, 70, 67, 66, 64, 63, 62,
61, 59, 57, 56, 55, 54, 52, 51, 49, 48, 47, 46, 45, 45, 43, 42, 41, 39, 39, 37,
36, 35, 35, 34, 33, 31, 31, 30, 28, 28, 28, 26, 25, 25, 23, 23, 22, 22, 21, 20,
19, 18, 18, 17, 16, 17, 16, 15, 15, 14, 13, 12, 11, 11, 11, 9, 10, 9, 8, 9, 7,
7, 7, 6, 6, 5, 5, 5, 5, 4, 4, 3, 3, 2, 3, 2, 2, 1, 1, 1, 1, 1, 0, -1, 0, -1, -1,
-1, -1, -1, -1, -2, -2, -1, -2, -3, -2, -2, -3, -3, -3, -3, -4, -4, -4, -4, -4,
-4, -4, -4, -6, -6, -5, -6, -6, -6, -7, -7, -8, -8, -8, -8, -9, -9, -9, -10,
-10, -12, -12, -12, -12, -13, -14, -15, -15, -16, -16, -16, -17, -18, -18, -19,
-19, -20, -22, -22, -22, -23, -24, -25, -26, -26, -27, -27, -28, -30, -31, -31,
-32, -32, -34, -35, -36, -37, -38, -39, -41, -42, -42, -43, -45, -46, -47, -48,
-48, -51, -52, -53, -54, -55, -56, -57, -58, -59, -61, -62, -64, -65, -67, -68,
-70, -70, -72, -73, -75, -76, -77, -79, -80, -82, -84, -85, -87, -88, -90, -91,
-92, -94, -95, -97, -98, -99, -102, -103, -104, -106, -107, -108, -110, -112,
-113, -115, -116, -119, -119, -119, -116, -113, -111, -109, -106, -104, -102,
-99, -98, -95, -94, -92, -89, -88, -86, -84, -83, -80, -79, -77, -75, -74, -72,
-71, -69, -67, -65, -65, -63, -62, -60, -59, -57, -55, -55, -53, -51, -52, -50,
-49, -47, -45, -45, -44, -43, -42, -41, -40, -38, -37, -37, -35, -35, -33, -33,
-32, -31, -29, -29, -28, -27, -26, -25, -25, -24, -23, -22, -22, -22, -20, -19,
-19, -18, -17, -16, -16, -15, -15, -15, -14, -12, -12, -12, -11, -11, -10, -10,
-9, -8, -9, -8, -7, -7, -6, -6, -6, -4, -5, -4, -4, -4, -3, -3, -3, -3, -2, -1,
-1, 0, -1, 0, -1, };