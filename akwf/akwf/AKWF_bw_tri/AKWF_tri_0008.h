#define DATA_LENGTH 512
#define DATA AKWF_tri_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 5, 6, 7, 9, 10, 12, 13, 13,
15, 17, 17, 20, 20, 22, 23, 24, 26, 27, 27, 29, 30, 31, 32, 34, 35, 36, 37, 38,
39, 41, 41, 43, 43, 45, 46, 47, 48, 49, 50, 51, 52, 54, 55, 55, 57, 57, 58, 58,
59, 60, 61, 63, 63, 64, 65, 66, 67, 67, 68, 69, 70, 70, 71, 72, 74, 74, 74, 75,
77, 76, 78, 78, 78, 80, 80, 81, 82, 82, 82, 83, 83, 85, 85, 85, 87, 86, 88, 88,
88, 89, 90, 90, 90, 90, 91, 91, 92, 94, 93, 94, 94, 95, 96, 95, 96, 97, 96, 97,
97, 98, 98, 98, 99, 99, 100, 99, 101, 100, 102, 101, 102, 103, 102, 102, 102,
102, 103, 103, 103, 104, 104, 105, 105, 105, 105, 104, 105, 105, 105, 105, 106,
106, 106, 106, 106, 107, 107, 108, 108, 107, 107, 108, 108, 107, 107, 108, 108,
108, 108, 109, 108, 108, 109, 108, 108, 108, 109, 108, 109, 108, 109, 108, 109,
109, 108, 109, 108, 108, 108, 108, 109, 108, 108, 107, 109, 108, 108, 108, 107,
108, 107, 108, 108, 108, 106, 110, 120, 118, 115, 114, 112, 111, 109, 107, 105,
103, 101, 99, 97, 96, 93, 92, 90, 88, 85, 84, 82, 78, 76, 76, 72, 70, 68, 67,
64, 62, 60, 58, 56, 53, 51, 48, 47, 44, 43, 40, 39, 36, 34, 32, 30, 27, 25, 24,
22, 18, 17, 15, 13, 10, 9, 7, 5, 3, 1, -1, -3, -4, -7, -9, -11, -13, -14, -16,
-18, -19, -21, -23, -25, -26, -29, -30, -32, -34, -35, -37, -38, -40, -42, -43,
-44, -46, -48, -49, -51, -52, -54, -56, -55, -58, -59, -60, -62, -62, -64, -65,
-67, -68, -69, -71, -72, -73, -74, -75, -76, -77, -78, -79, -80, -81, -82, -83,
-84, -85, -86, -87, -88, -88, -90, -90, -90, -91, -92, -93, -93, -95, -95, -96,
-97, -97, -97, -98, -100, -100, -100, -101, -101, -102, -102, -103, -103, -104,
-104, -105, -105, -106, -107, -107, -107, -107, -107, -108, -109, -108, -109,
-109, -109, -109, -110, -111, -110, -110, -110, -111, -111, -111, -112, -112,
-111, -112, -112, -112, -112, -112, -112, -112, -113, -113, -112, -113, -112,
-112, -113, -112, -112, -112, -112, -112, -111, -112, -113, -111, -112, -112,
-111, -112, -112, -111, -111, -111, -110, -111, -110, -110, -110, -110, -109,
-109, -108, -108, -109, -108, -107, -107, -107, -106, -106, -105, -104, -105,
-103, -104, -102, -102, -102, -101, -101, -101, -99, -98, -98, -98, -96, -95,
-95, -94, -93, -92, -91, -91, -88, -88, -87, -86, -84, -84, -83, -83, -82, -81,
-80, -79, -78, -76, -74, -75, -73, -72, -70, -70, -68, -68, -67, -66, -63, -62,
-61, -60, -59, -58, -57, -55, -54, -52, -51, -50, -48, -47, -45, -44, -43, -41,
-39, -38, -36, -36, -33, -31, -30, -29, -27, -26, -24, -23, -21, -19, -19, -17,
-16, -14, -13, -11, -10, -8, -7, -5, -4, -3, -2, };