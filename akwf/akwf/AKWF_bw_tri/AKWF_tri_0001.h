#define DATA_LENGTH 512
#define DATA AKWF_tri_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 3, 5, 6, 7, 8, 9, 10, 11, 12,
14, 15, 16, 17, 17, 20, 20, 20, 22, 23, 24, 25, 26, 28, 28, 29, 31, 31, 32, 33,
34, 35, 36, 37, 37, 39, 39, 40, 42, 43, 43, 45, 46, 47, 47, 47, 48, 50, 50, 51,
52, 53, 53, 55, 55, 55, 57, 58, 58, 59, 60, 61, 61, 63, 64, 64, 65, 65, 66, 66,
68, 68, 69, 69, 70, 71, 71, 73, 73, 74, 74, 75, 75, 76, 77, 77, 77, 80, 80, 80,
82, 81, 82, 82, 82, 84, 84, 85, 85, 86, 86, 87, 88, 88, 89, 90, 90, 90, 92, 92,
93, 93, 94, 94, 95, 94, 94, 97, 97, 97, 97, 98, 98, 99, 99, 99, 100, 100, 101,
102, 102, 102, 103, 103, 104, 104, 105, 105, 105, 106, 106, 106, 108, 108, 108,
108, 109, 109, 110, 110, 110, 111, 111, 112, 112, 112, 112, 113, 114, 114, 114,
114, 115, 115, 115, 116, 116, 116, 117, 117, 117, 118, 118, 117, 118, 119, 118,
118, 115, 113, 112, 110, 108, 106, 104, 103, 100, 99, 97, 95, 94, 92, 90, 89,
86, 85, 83, 82, 81, 79, 77, 74, 73, 72, 71, 69, 67, 65, 64, 62, 60, 59, 57, 56,
54, 53, 51, 50, 49, 46, 46, 45, 42, 42, 40, 39, 37, 35, 34, 33, 32, 30, 28, 27,
26, 24, 24, 22, 20, 19, 18, 17, 15, 15, 13, 12, 11, 9, 8, 7, 6, 5, 3, 2, 1, 0,
-2, -3, -4, -4, -5, -7, -8, -10, -11, -12, -13, -14, -15, -16, -18, -18, -19,
-20, -21, -22, -24, -24, -24, -26, -27, -29, -29, -30, -31, -31, -33, -34, -36,
-36, -37, -37, -39, -40, -41, -41, -43, -44, -44, -45, -45, -47, -48, -48, -49,
-50, -51, -52, -52, -54, -54, -55, -56, -57, -57, -58, -59, -59, -60, -62, -62,
-62, -64, -64, -65, -65, -66, -67, -68, -68, -69, -69, -70, -72, -72, -74, -73,
-73, -75, -76, -77, -77, -77, -78, -78, -80, -79, -81, -81, -82, -82, -82, -84,
-84, -85, -85, -85, -87, -87, -87, -88, -88, -89, -89, -91, -91, -91, -92, -92,
-93, -93, -94, -95, -94, -96, -96, -96, -97, -97, -98, -98, -99, -99, -100,
-100, -100, -101, -102, -102, -103, -103, -103, -103, -104, -104, -105, -105,
-105, -107, -106, -108, -108, -108, -108, -109, -109, -110, -109, -110, -110,
-111, -111, -111, -112, -112, -113, -114, -113, -114, -113, -115, -114, -115,
-115, -116, -116, -116, -116, -117, -117, -117, -118, -118, -115, -114, -111,
-111, -108, -106, -105, -103, -101, -99, -97, -95, -94, -92, -90, -88, -86, -84,
-84, -82, -79, -78, -77, -75, -73, -71, -70, -69, -67, -65, -64, -62, -61, -59,
-57, -57, -54, -53, -52, -50, -49, -47, -46, -45, -43, -42, -40, -38, -37, -36,
-34, -33, -31, -30, -28, -27, -26, -25, -23, -22, -21, -19, -18, -17, -15, -14,
-13, -12, -9, -10, -8, -7, -6, -4, -3, -2, -1, };