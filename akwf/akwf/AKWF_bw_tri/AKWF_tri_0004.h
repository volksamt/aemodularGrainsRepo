#define DATA_LENGTH 512
#define DATA AKWF_tri_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 4, 6, 7, 9, 11, 11, 13, 15,
16, 18, 18, 20, 22, 23, 24, 26, 28, 30, 31, 34, 35, 38, 40, 43, 45, 47, 49, 53,
55, 58, 60, 63, 66, 69, 71, 74, 77, 79, 82, 84, 87, 88, 91, 93, 95, 96, 98, 100,
102, 104, 104, 106, 108, 108, 110, 110, 111, 113, 113, 114, 115, 116, 116, 115,
116, 116, 117, 118, 118, 117, 118, 118, 118, 119, 119, 118, 118, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 118, 118, 118, 118, 119, 118,
118, 118, 117, 117, 116, 115, 115, 115, 115, 114, 114, 113, 113, 112, 111, 111,
109, 109, 107, 107, 106, 104, 103, 103, 103, 102, 102, 100, 99, 100, 99, 98, 98,
97, 97, 96, 97, 96, 96, 95, 95, 94, 93, 94, 93, 93, 93, 93, 93, 92, 92, 93, 91,
91, 91, 91, 91, 90, 90, 89, 90, 90, 90, 89, 89, 88, 89, 89, 88, 88, 88, 88, 87,
86, 86, 85, 86, 85, 84, 85, 85, 84, 82, 83, 82, 82, 81, 80, 80, 79, 79, 77, 78,
77, 76, 75, 75, 74, 73, 72, 71, 70, 70, 69, 68, 68, 67, 66, 64, 64, 63, 61, 60,
59, 58, 57, 56, 55, 53, 53, 51, 50, 49, 48, 46, 45, 44, 43, 41, 39, 38, 37, 36,
34, 34, 31, 30, 29, 28, 26, 25, 24, 22, 21, 19, 17, 17, 15, 13, 11, 9, 9, 6, 6,
4, 2, 1, 0, -2, -3, -5, -6, -7, -8, -10, -12, -13, -14, -16, -18, -18, -19, -21,
-23, -25, -26, -28, -30, -31, -34, -36, -37, -39, -43, -45, -47, -51, -52, -56,
-57, -61, -64, -66, -69, -71, -74, -77, -80, -82, -84, -87, -88, -91, -94, -95,
-97, -99, -100, -102, -104, -105, -107, -108, -108, -110, -110, -111, -113,
-113, -115, -114, -114, -115, -116, -116, -117, -117, -118, -117, -118, -118,
-119, -118, -118, -119, -119, -120, -118, -119, -119, -119, -119, -118, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -118, -118, -119, -118, -118,
-118, -116, -117, -117, -116, -115, -115, -116, -114, -113, -113, -112, -112,
-111, -110, -109, -108, -108, -107, -105, -105, -104, -104, -103, -103, -101,
-100, -100, -99, -99, -99, -98, -98, -97, -97, -97, -95, -95, -95, -94, -95,
-94, -93, -93, -93, -92, -92, -93, -92, -92, -91, -91, -91, -91, -91, -91, -90,
-90, -90, -90, -91, -90, -89, -89, -89, -88, -89, -88, -88, -88, -87, -87, -87,
-87, -86, -86, -85, -85, -84, -84, -83, -83, -83, -82, -82, -81, -81, -80, -78,
-79, -78, -77, -77, -76, -75, -75, -74, -74, -73, -72, -71, -70, -69, -68, -67,
-66, -65, -63, -62, -62, -60, -60, -59, -58, -57, -56, -55, -54, -53, -50, -50,
-48, -48, -46, -45, -45, -42, -41, -39, -39, -37, -36, -34, -33, -32, -30, -30,
-28, -26, -25, -24, -22, -20, -19, -18, -16, -15, -13, -12, -9, -8, -7, -5, -4,
-3, 0, };