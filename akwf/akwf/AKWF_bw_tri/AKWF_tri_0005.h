#define DATA_LENGTH 512
#define DATA AKWF_tri_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 4, 4, 6, 6, 7, 8, 9, 10, 12,
12, 13, 15, 15, 17, 17, 18, 19, 20, 21, 23, 23, 25, 26, 26, 28, 29, 30, 31, 32,
33, 34, 34, 36, 36, 37, 38, 39, 41, 42, 43, 43, 45, 46, 47, 48, 49, 50, 51, 52,
53, 55, 54, 55, 58, 58, 59, 60, 60, 62, 63, 64, 65, 66, 67, 69, 69, 70, 70, 73,
73, 75, 75, 76, 77, 78, 79, 81, 81, 82, 84, 84, 86, 86, 87, 88, 89, 90, 92, 92,
93, 95, 96, 96, 98, 98, 99, 101, 102, 103, 104, 104, 105, 106, 107, 108, 110,
111, 112, 113, 114, 115, 116, 117, 118, 118, 119, 119, 119, 119, 119, 119, 118,
119, 118, 118, 117, 117, 116, 116, 116, 114, 114, 114, 113, 113, 112, 112, 111,
110, 109, 109, 109, 107, 107, 106, 105, 104, 103, 103, 102, 101, 100, 99, 99,
97, 97, 96, 96, 94, 93, 92, 91, 91, 89, 89, 88, 86, 86, 85, 85, 82, 82, 82, 80,
80, 78, 77, 76, 76, 75, 73, 72, 71, 70, 69, 68, 67, 66, 65, 65, 63, 63, 60, 60,
59, 59, 57, 57, 56, 55, 53, 52, 52, 50, 49, 48, 47, 47, 44, 44, 43, 42, 42, 40,
38, 38, 37, 36, 35, 34, 32, 32, 31, 30, 29, 28, 26, 27, 25, 24, 23, 22, 22, 20,
19, 19, 17, 16, 14, 13, 13, 12, 11, 10, 8, 8, 7, 5, 5, 3, 3, 1, 0, 0, -2, -3,
-3, -4, -6, -7, -8, -9, -9, -11, -11, -12, -14, -15, -16, -17, -17, -19, -19,
-20, -21, -22, -25, -25, -26, -27, -27, -28, -30, -31, -32, -33, -33, -35, -36,
-37, -38, -39, -40, -41, -42, -43, -44, -45, -47, -47, -48, -49, -50, -52, -52,
-53, -54, -55, -56, -57, -58, -59, -60, -61, -63, -63, -63, -65, -66, -67, -69,
-69, -70, -71, -72, -73, -75, -75, -77, -77, -78, -79, -80, -81, -82, -83, -84,
-85, -86, -87, -88, -90, -90, -91, -93, -93, -94, -95, -96, -97, -99, -100,
-100, -102, -102, -104, -105, -105, -107, -108, -109, -110, -110, -112, -112,
-114, -115, -116, -117, -117, -119, -118, -119, -119, -119, -119, -118, -118,
-119, -118, -117, -118, -116, -116, -116, -116, -115, -114, -114, -114, -113,
-112, -111, -110, -110, -109, -109, -108, -107, -106, -105, -105, -104, -104,
-102, -102, -102, -100, -100, -99, -98, -96, -96, -95, -94, -93, -93, -91, -91,
-89, -89, -88, -86, -86, -85, -84, -82, -82, -81, -80, -78, -79, -78, -76, -75,
-74, -73, -72, -71, -70, -68, -68, -67, -66, -65, -64, -63, -62, -62, -60, -59,
-59, -57, -56, -55, -54, -53, -52, -52, -50, -49, -48, -47, -47, -45, -45, -43,
-42, -41, -40, -39, -38, -36, -36, -35, -34, -33, -32, -31, -30, -29, -27, -27,
-26, -26, -24, -23, -21, -21, -20, -19, -18, -16, -16, -15, -14, -12, -12, -11,
-10, -9, -7, -6, -7, -4, -4, -3, -2, -1, };