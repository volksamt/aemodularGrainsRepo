#define DATA_LENGTH 512
#define DATA AKWF_tri_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 7, 8, 10, 11, 13, 14, 15,
17, 19, 20, 22, 23, 24, 25, 27, 28, 29, 31, 32, 33, 34, 35, 37, 38, 40, 41, 41,
43, 44, 45, 46, 48, 49, 50, 51, 52, 54, 56, 55, 57, 58, 59, 60, 61, 63, 63, 65,
65, 67, 67, 68, 69, 70, 71, 72, 73, 74, 76, 76, 77, 78, 79, 80, 80, 81, 82, 83,
84, 86, 86, 87, 87, 89, 89, 91, 91, 92, 93, 93, 94, 96, 96, 97, 98, 98, 99, 99,
101, 102, 102, 103, 104, 105, 105, 105, 107, 107, 108, 108, 109, 110, 111, 111,
113, 113, 114, 115, 115, 115, 116, 117, 117, 119, 118, 119, 119, 118, 119, 118,
118, 118, 119, 118, 118, 118, 118, 117, 117, 117, 116, 116, 115, 115, 116, 115,
115, 114, 113, 112, 112, 111, 111, 110, 111, 109, 109, 108, 108, 107, 107, 106,
106, 105, 104, 104, 103, 103, 102, 101, 101, 99, 99, 99, 98, 96, 96, 96, 95, 94,
94, 93, 92, 91, 91, 89, 88, 88, 87, 86, 86, 84, 83, 83, 82, 81, 80, 79, 79, 77,
76, 75, 74, 74, 73, 72, 71, 70, 68, 67, 67, 65, 64, 63, 62, 62, 61, 60, 58, 57,
57, 55, 54, 53, 52, 50, 50, 49, 47, 46, 45, 44, 42, 41, 40, 38, 37, 36, 35, 33,
33, 31, 30, 29, 27, 26, 25, 23, 22, 21, 19, 17, 15, 15, 13, 12, 10, 9, 8, 6, 4,
3, 1, -1, -2, -4, -5, -7, -8, -10, -12, -12, -14, -15, -18, -19, -20, -21, -23,
-25, -26, -27, -28, -30, -30, -32, -34, -35, -36, -37, -38, -39, -40, -42, -44,
-44, -45, -47, -48, -48, -50, -51, -53, -54, -55, -56, -57, -59, -59, -60, -61,
-62, -63, -65, -65, -66, -68, -68, -69, -70, -72, -72, -73, -74, -75, -76, -78,
-77, -79, -79, -80, -81, -83, -83, -84, -85, -87, -87, -87, -89, -90, -90, -91,
-92, -93, -94, -95, -95, -96, -97, -98, -99, -99, -100, -100, -101, -102, -102,
-104, -105, -105, -106, -106, -107, -108, -109, -110, -110, -110, -112, -112,
-112, -113, -114, -115, -116, -116, -117, -117, -119, -119, -119, -119, -119,
-118, -119, -119, -119, -119, -118, -119, -118, -118, -118, -117, -117, -116,
-116, -116, -115, -115, -115, -113, -113, -113, -113, -113, -111, -111, -111,
-110, -110, -109, -108, -108, -107, -108, -107, -106, -105, -104, -104, -103,
-103, -102, -101, -101, -100, -99, -99, -98, -96, -96, -96, -95, -94, -93, -92,
-91, -90, -89, -88, -88, -88, -87, -86, -86, -84, -84, -82, -81, -81, -80, -79,
-78, -77, -77, -75, -74, -73, -72, -71, -70, -70, -68, -67, -67, -65, -64, -64,
-63, -62, -61, -59, -59, -57, -56, -54, -54, -53, -51, -50, -49, -48, -47, -46,
-45, -44, -42, -41, -40, -38, -37, -37, -35, -34, -32, -31, -30, -28, -26, -26,
-24, -23, -21, -21, -19, -18, -16, -15, -13, -12, -11, -9, -7, -5, -4, -2, -1,
};