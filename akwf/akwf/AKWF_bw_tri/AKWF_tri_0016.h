#define DATA_LENGTH 512
#define DATA AKWF_tri_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 0, 1, 2, 2, 2, 3, 3, 3, 3, 4, 5,
4, 5, 5, 6, 6, 7, 7, 7, 8, 9, 9, 10, 9, 11, 10, 11, 12, 13, 13, 13, 14, 15, 15,
17, 17, 17, 18, 18, 19, 19, 20, 21, 22, 22, 24, 24, 24, 26, 27, 27, 28, 29, 29,
30, 31, 32, 32, 34, 35, 35, 37, 37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 47, 48,
49, 51, 51, 52, 54, 54, 55, 56, 57, 58, 59, 61, 62, 63, 64, 66, 66, 68, 69, 70,
71, 72, 73, 75, 76, 77, 78, 80, 81, 82, 84, 85, 87, 86, 88, 90, 90, 92, 93, 94,
96, 97, 99, 99, 100, 101, 102, 104, 105, 106, 107, 108, 110, 111, 112, 114, 115,
115, 117, 119, 119, 119, 118, 115, 113, 111, 109, 107, 106, 104, 102, 100, 98,
97, 96, 94, 93, 91, 89, 89, 86, 84, 83, 83, 80, 79, 78, 76, 75, 74, 72, 72, 70,
69, 67, 67, 64, 63, 63, 61, 59, 59, 57, 57, 56, 55, 54, 52, 52, 50, 50, 48, 47,
46, 46, 45, 43, 42, 42, 40, 40, 38, 37, 37, 36, 34, 33, 32, 32, 31, 31, 29, 29,
28, 27, 27, 25, 25, 24, 24, 23, 21, 21, 20, 20, 18, 18, 17, 16, 16, 16, 15, 13,
14, 13, 12, 12, 11, 10, 10, 10, 8, 8, 8, 7, 6, 6, 5, 5, 5, 5, 3, 3, 3, 2, 2, 2,
1, 0, 0, 1, 0, 0, -1, -2, -1, -2, -3, -3, -3, -4, -4, -4, -5, -5, -6, -7, -6,
-7, -8, -8, -8, -8, -8, -9, -10, -10, -11, -12, -12, -13, -13, -13, -14, -15,
-15, -17, -16, -17, -18, -18, -19, -21, -21, -21, -22, -23, -23, -23, -25, -26,
-26, -27, -27, -29, -30, -30, -31, -32, -34, -34, -34, -35, -37, -37, -38, -39,
-40, -41, -42, -43, -44, -45, -47, -47, -48, -49, -50, -52, -52, -53, -54, -55,
-56, -58, -58, -59, -61, -62, -63, -65, -65, -67, -68, -69, -70, -71, -72, -74,
-75, -76, -77, -78, -80, -81, -82, -84, -84, -86, -87, -88, -89, -92, -91, -94,
-94, -96, -97, -98, -99, -101, -102, -102, -104, -106, -107, -107, -109, -110,
-112, -113, -114, -115, -117, -118, -119, -119, -118, -117, -114, -113, -110,
-109, -107, -106, -104, -102, -101, -99, -97, -96, -94, -92, -90, -88, -87, -87,
-85, -83, -81, -80, -79, -77, -76, -75, -73, -71, -71, -70, -69, -67, -66, -64,
-63, -62, -62, -60, -59, -58, -57, -55, -54, -53, -53, -51, -51, -49, -47, -47,
-46, -45, -44, -44, -42, -42, -40, -39, -39, -37, -37, -35, -35, -34, -33, -32,
-31, -31, -29, -28, -27, -27, -26, -26, -25, -24, -23, -23, -21, -21, -20, -20,
-19, -18, -18, -16, -16, -15, -14, -14, -13, -14, -12, -12, -11, -10, -10, -10,
-9, -9, -7, -7, -7, -6, -5, -5, -4, -4, -4, -3, -3, -2, -2, -1, 0, 0, 0, };