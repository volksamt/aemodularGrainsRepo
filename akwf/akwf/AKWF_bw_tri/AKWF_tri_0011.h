#define DATA_LENGTH 512
#define DATA AKWF_tri_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 0, 0, 1, 1, 2, 1, 2, 1, 2, 2, 1,
2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 4, 5, 4, 4, 4, 5,
5, 5, 6, 6, 5, 6, 7, 7, 8, 8, 8, 9, 8, 9, 9, 10, 10, 11, 12, 13, 14, 14, 14, 15,
15, 16, 17, 18, 18, 18, 19, 19, 21, 21, 22, 23, 23, 25, 25, 26, 26, 27, 28, 30,
31, 32, 32, 34, 34, 35, 35, 37, 39, 40, 40, 41, 42, 43, 46, 46, 47, 49, 50, 52,
52, 54, 55, 56, 57, 59, 60, 62, 64, 65, 66, 68, 69, 71, 72, 73, 75, 76, 78, 80,
81, 83, 85, 87, 88, 90, 90, 93, 95, 96, 97, 99, 101, 102, 103, 106, 107, 109,
111, 112, 115, 116, 118, 119, 119, 117, 114, 111, 108, 105, 103, 102, 98, 97,
96, 93, 91, 88, 86, 85, 83, 81, 78, 77, 76, 73, 72, 70, 68, 66, 64, 64, 61, 60,
59, 57, 56, 54, 53, 52, 50, 49, 47, 47, 46, 44, 44, 41, 41, 39, 39, 37, 36, 35,
35, 33, 32, 31, 31, 30, 29, 28, 27, 26, 24, 23, 23, 22, 22, 21, 21, 19, 19, 18,
17, 17, 15, 16, 14, 14, 14, 13, 12, 11, 11, 10, 10, 9, 9, 8, 7, 7, 7, 6, 5, 5,
4, 5, 4, 3, 4, 3, 3, 2, 2, 1, 2, 2, 1, 1, 0, 0, -1, 0, -1, -1, -1, -1, -1, -2,
-2, -2, -3, -2, -2, -2, -2, -3, -3, -2, -2, -2, -3, -2, -3, -2, -3, -3, -3, -3,
-3, -3, -3, -3, -3, -3, -3, -4, -3, -4, -5, -4, -5, -5, -6, -6, -6, -7, -7, -7,
-8, -8, -8, -8, -9, -10, -10, -11, -11, -11, -13, -12, -13, -14, -15, -14, -16,
-16, -16, -17, -18, -18, -19, -19, -20, -21, -22, -23, -23, -24, -25, -26, -26,
-28, -29, -30, -31, -32, -33, -34, -34, -35, -36, -37, -38, -40, -40, -41, -43,
-43, -46, -46, -47, -48, -50, -51, -53, -54, -55, -56, -57, -59, -60, -62, -64,
-65, -66, -68, -68, -71, -72, -73, -75, -77, -78, -80, -82, -83, -85, -87, -87,
-89, -91, -92, -94, -96, -98, -99, -101, -102, -104, -106, -107, -109, -111,
-113, -114, -116, -118, -119, -118, -116, -113, -110, -109, -106, -103, -101,
-99, -97, -94, -93, -90, -88, -87, -83, -83, -81, -78, -77, -74, -73, -72, -69,
-68, -66, -65, -63, -62, -60, -58, -57, -56, -54, -54, -51, -51, -49, -47, -46,
-46, -45, -43, -41, -40, -40, -38, -37, -36, -36, -35, -33, -32, -31, -30, -30,
-28, -27, -27, -25, -25, -24, -23, -23, -22, -21, -20, -20, -18, -18, -18, -16,
-16, -15, -14, -14, -13, -12, -12, -11, -11, -10, -10, -10, -8, -8, -7, -7, -7,
-6, -5, -6, -4, -4, -5, -4, -3, -2, -2, -2, -2, -1, -1, -1, -1, -1, 0, -1, };