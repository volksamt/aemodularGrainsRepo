#define DATA_LENGTH 512
#define DATA AKWF_violin_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 6, 8, 11, 13, 15, 18, 19, 21,
21, 22, 22, 22, 22, 21, 21, 20, 20, 20, 21, 21, 22, 23, 25, 26, 29, 31, 33, 34,
36, 39, 41, 43, 45, 45, 47, 47, 48, 48, 49, 48, 49, 48, 48, 46, 46, 44, 45, 46,
46, 47, 47, 49, 50, 54, 56, 58, 60, 62, 64, 65, 67, 68, 71, 71, 74, 74, 74, 76,
76, 77, 77, 77, 77, 77, 78, 79, 79, 80, 81, 82, 83, 84, 86, 86, 88, 88, 89, 90,
89, 88, 87, 85, 84, 81, 80, 78, 75, 72, 70, 66, 64, 60, 57, 54, 51, 48, 44, 41,
37, 34, 30, 28, 25, 22, 20, 17, 14, 11, 9, 6, 3, 1, -2, -4, -7, -10, -12, -14,
-19, -22, -25, -29, -32, -37, -42, -45, -50, -55, -58, -61, -66, -70, -75, -78,
-81, -83, -86, -88, -91, -93, -95, -97, -100, -101, -102, -103, -105, -105,
-106, -107, -109, -108, -109, -109, -108, -107, -105, -103, -101, -98, -95, -92,
-87, -83, -79, -73, -68, -63, -58, -51, -46, -41, -34, -30, -26, -23, -19, -15,
-13, -10, -8, -6, -4, -2, 0, 3, 6, 9, 13, 16, 20, 24, 28, 33, 37, 40, 43, 45,
47, 49, 51, 52, 54, 54, 54, 54, 54, 54, 53, 55, 54, 55, 55, 54, 55, 57, 57, 59,
61, 63, 65, 68, 70, 73, 77, 80, 85, 88, 91, 94, 97, 100, 103, 107, 108, 111,
112, 114, 115, 115, 117, 118, 119, 119, 119, 118, 117, 115, 114, 112, 110, 108,
105, 103, 102, 99, 97, 95, 91, 90, 87, 85, 82, 80, 77, 75, 73, 71, 68, 66, 63,
61, 58, 55, 51, 47, 43, 39, 35, 32, 29, 24, 21, 16, 13, 10, 8, 5, 3, 1, -2, -5,
-6, -8, -9, -11, -13, -15, -15, -17, -20, -21, -24, -26, -28, -31, -34, -36,
-38, -41, -42, -45, -45, -47, -46, -47, -48, -48, -47, -46, -47, -46, -48, -48,
-51, -53, -54, -57, -59, -61, -65, -68, -72, -76, -80, -84, -87, -90, -92, -93,
-94, -94, -92, -91, -89, -87, -84, -81, -78, -73, -70, -65, -60, -58, -54, -52,
-50, -48, -46, -46, -47, -48, -49, -50, -51, -53, -53, -56, -59, -60, -63, -64,
-65, -68, -69, -69, -68, -67, -65, -62, -61, -58, -55, -51, -48, -42, -39, -34,
-28, -24, -21, -17, -14, -10, -5, -2, 1, 3, 4, 6, 7, 8, 10, 11, 10, 10, 8, 8, 7,
5, 1, -2, -6, -11, -16, -21, -26, -32, -37, -42, -47, -52, -58, -63, -66, -69,
-70, -71, -71, -71, -70, -70, -69, -68, -66, -63, -61, -57, -54, -51, -49, -48,
-46, -44, -42, -40, -38, -37, -37, -37, -38, -39, -39, -40, -41, -41, -43, -43,
-44, -45, -47, -47, -47, -48, -46, -46, -45, -43, -41, -39, -38, -35, -34, -32,
-31, -31, -29, -27, -25, -23, -23, -21, -21, -22, -21, -22, -22, -21, -20, -18,
-18, -16, -16, -13, -12, -10, -8, -5, -4, -1, };