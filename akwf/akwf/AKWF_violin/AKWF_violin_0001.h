#define DATA_LENGTH 512
#define DATA AKWF_violin_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 3, 2, 1, 1, 1, 1, 3, 5, 9,
14, 22, 28, 35, 43, 50, 59, 68, 77, 85, 93, 100, 106, 111, 117, 118, 119, 118,
116, 112, 107, 102, 95, 88, 81, 72, 65, 58, 51, 45, 40, 35, 31, 27, 25, 24, 25,
26, 30, 34, 39, 44, 50, 57, 61, 67, 72, 77, 82, 86, 89, 90, 91, 92, 92, 92, 91,
91, 92, 93, 92, 93, 95, 96, 96, 95, 95, 94, 92, 89, 85, 82, 77, 71, 64, 59, 53,
46, 39, 32, 24, 17, 9, 2, -5, -13, -21, -30, -37, -44, -51, -57, -62, -65, -68,
-69, -70, -71, -73, -72, -72, -71, -70, -69, -68, -68, -68, -66, -67, -66, -64,
-64, -64, -64, -65, -66, -67, -68, -70, -71, -74, -77, -79, -82, -85, -88, -90,
-93, -95, -96, -98, -98, -98, -98, -98, -96, -94, -91, -87, -84, -78, -73, -68,
-62, -56, -51, -46, -40, -34, -29, -25, -20, -15, -12, -9, -6, -4, -3, -4, -3,
-4, -5, -5, -6, -6, -8, -9, -11, -13, -15, -16, -18, -20, -23, -26, -28, -30,
-32, -33, -36, -38, -39, -39, -40, -38, -35, -33, -29, -25, -20, -14, -9, -4, 2,
8, 14, 19, 25, 30, 34, 40, 42, 46, 48, 51, 52, 52, 53, 53, 54, 53, 53, 52, 52,
50, 50, 48, 47, 46, 44, 43, 41, 39, 35, 34, 32, 30, 27, 26, 25, 24, 23, 22, 22,
22, 22, 22, 21, 23, 22, 22, 21, 20, 20, 20, 18, 17, 18, 17, 16, 16, 15, 14, 14,
14, 14, 14, 14, 15, 16, 17, 19, 20, 23, 24, 26, 28, 30, 32, 34, 34, 35, 36, 35,
35, 32, 30, 26, 23, 20, 16, 12, 8, 5, 1, -1, -4, -6, -8, -7, -6, -4, -3, -1, 2,
5, 9, 11, 14, 17, 20, 22, 25, 25, 25, 27, 26, 26, 26, 24, 23, 22, 21, 21, 21,
19, 18, 19, 19, 19, 19, 18, 19, 18, 17, 16, 14, 12, 12, 9, 7, 5, 2, 0, -3, -5,
-6, -8, -8, -9, -8, -9, -7, -6, -4, -4, -2, -1, 1, 2, 2, 3, 2, 2, 1, 0, -1, -2,
-4, -6, -7, -9, -9, -11, -12, -13, -13, -15, -15, -16, -15, -15, -14, -13, -12,
-13, -11, -11, -9, -8, -7, -7, -6, -5, -4, -5, -3, -3, -3, -2, -2, -1, -1, 0,
-1, -1, -1, -1, -1, -1, -1, -1, -1, -2, -2, -3, -4, -5, -5, -8, -8, -9, -11,
-14, -16, -18, -20, -22, -23, -24, -24, -24, -24, -23, -23, -22, -22, -22, -21,
-21, -21, -22, -22, -23, -24, -24, -26, -29, -30, -34, -37, -42, -45, -50, -54,
-60, -63, -66, -70, -73, -76, -78, -80, -81, -81, -80, -79, -76, -72, -68, -64,
-59, -53, -49, -45, -40, -35, -31, -29, -28, -26, -25, -27, -27, -30, -33, -37,
-40, -43, -46, -48, -49, -51, -52, -52, -49, -45, -41, -37, -34, -28, -24, -20,
-16, -12, -8, -6, -3, 0, };