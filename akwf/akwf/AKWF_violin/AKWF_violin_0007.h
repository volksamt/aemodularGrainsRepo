#define DATA_LENGTH 512
#define DATA AKWF_violin_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 8, 10, 13, 13, 15, 16, 16,
16, 17, 18, 20, 21, 22, 24, 26, 28, 30, 34, 37, 41, 44, 47, 52, 55, 59, 61, 64,
67, 69, 71, 72, 74, 75, 76, 78, 78, 80, 81, 82, 83, 85, 87, 89, 91, 94, 95, 97,
101, 102, 105, 107, 109, 111, 113, 114, 115, 118, 118, 119, 119, 118, 119, 119,
118, 118, 118, 118, 116, 116, 115, 114, 112, 110, 108, 105, 102, 98, 95, 90, 85,
81, 75, 69, 63, 57, 53, 47, 40, 35, 29, 24, 18, 13, 7, 3, -1, -7, -11, -15, -19,
-23, -26, -29, -32, -35, -38, -39, -41, -43, -45, -44, -44, -44, -44, -43, -42,
-40, -40, -38, -38, -36, -35, -34, -33, -33, -33, -33, -33, -33, -33, -34, -34,
-35, -37, -38, -39, -39, -40, -41, -44, -45, -46, -48, -48, -50, -51, -52, -54,
-56, -59, -61, -64, -67, -70, -71, -76, -78, -81, -85, -86, -88, -88, -87, -85,
-84, -81, -77, -72, -65, -58, -51, -44, -38, -30, -23, -16, -8, -1, 5, 9, 12,
14, 15, 16, 15, 13, 11, 7, 1, -5, -12, -19, -26, -32, -36, -42, -47, -51, -56,
-60, -62, -64, -65, -64, -64, -62, -59, -56, -51, -47, -42, -38, -34, -30, -26,
-22, -18, -14, -9, -6, -3, 0, 2, 4, 7, 7, 10, 10, 10, 8, 5, 3, 1, 0, -3, -7,
-12, -17, -23, -30, -35, -40, -46, -52, -57, -61, -65, -69, -72, -74, -75, -77,
-77, -77, -75, -72, -69, -68, -64, -61, -59, -55, -51, -48, -45, -43, -43, -41,
-40, -38, -37, -36, -36, -35, -36, -38, -38, -38, -40, -40, -40, -38, -38, -36,
-35, -34, -32, -31, -28, -26, -24, -22, -20, -16, -14, -12, -10, -10, -8, -7,
-5, -4, -3, -2, -3, -4, -5, -6, -6, -9, -11, -13, -15, -17, -19, -20, -19, -20,
-18, -16, -13, -8, -4, 0, 3, 7, 12, 16, 20, 24, 26, 30, 32, 33, 34, 33, 33, 32,
32, 32, 32, 32, 33, 33, 33, 33, 34, 36, 38, 39, 41, 44, 46, 49, 51, 53, 55, 57,
58, 60, 61, 63, 64, 66, 67, 67, 68, 69, 69, 69, 69, 69, 70, 68, 68, 67, 67, 67,
66, 67, 67, 67, 69, 69, 71, 72, 71, 73, 74, 75, 76, 77, 76, 76, 77, 76, 76, 77,
77, 76, 76, 76, 76, 76, 77, 77, 77, 78, 76, 77, 76, 74, 72, 71, 69, 65, 62, 59,
54, 49, 45, 41, 35, 31, 26, 23, 19, 15, 11, 8, 4, 2, -1, -4, -7, -10, -12, -15,
-17, -19, -21, -22, -24, -25, -26, -27, -27, -28, -30, -32, -34, -37, -39, -43,
-47, -50, -54, -58, -63, -68, -73, -78, -83, -88, -93, -97, -101, -104, -107,
-109, -111, -111, -113, -113, -113, -113, -111, -111, -109, -107, -106, -105,
-102, -100, -99, -96, -95, -92, -89, -87, -85, -81, -77, -75, -70, -65, -61,
-56, -51, -46, -41, -35, -29, -24, -18, -14, -8, -3, -1, };