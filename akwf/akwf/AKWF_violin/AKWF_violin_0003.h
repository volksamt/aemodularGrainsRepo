#define DATA_LENGTH 512
#define DATA AKWF_violin_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 13, 19, 24, 30, 36, 42, 49, 55,
60, 64, 69, 74, 80, 84, 89, 92, 96, 100, 104, 107, 109, 112, 113, 117, 117, 119,
119, 119, 118, 117, 117, 116, 114, 112, 108, 106, 102, 100, 95, 92, 87, 83, 80,
76, 71, 67, 63, 60, 56, 52, 49, 45, 41, 39, 36, 33, 32, 30, 29, 28, 27, 27, 27,
26, 27, 27, 27, 27, 26, 25, 25, 23, 21, 20, 18, 16, 13, 10, 8, 6, 3, 0, -3, -7,
-10, -13, -15, -19, -22, -25, -27, -29, -32, -34, -37, -40, -42, -46, -49, -54,
-58, -61, -65, -69, -73, -76, -79, -82, -84, -86, -88, -89, -90, -91, -91, -90,
-89, -88, -86, -86, -85, -83, -81, -80, -79, -78, -77, -76, -76, -76, -76, -76,
-77, -77, -77, -77, -78, -78, -79, -79, -80, -80, -81, -81, -82, -81, -81, -80,
-79, -79, -77, -75, -72, -69, -67, -63, -59, -56, -52, -48, -46, -42, -38, -35,
-31, -28, -24, -20, -16, -13, -11, -7, -5, -3, -1, 1, 2, 2, 2, 1, 0, 0, -1, -1,
-3, -3, -5, -5, -5, -7, -8, -9, -10, -10, -11, -10, -10, -9, -9, -8, -7, -5, -3,
-2, 1, 2, 4, 5, 8, 8, 11, 13, 15, 17, 19, 22, 24, 26, 28, 31, 33, 35, 38, 40,
42, 44, 46, 47, 48, 50, 50, 50, 52, 50, 51, 51, 50, 50, 49, 50, 50, 49, 50, 52,
52, 53, 55, 57, 59, 61, 64, 67, 69, 71, 74, 76, 79, 81, 83, 85, 87, 89, 90, 91,
92, 93, 93, 94, 93, 92, 91, 92, 90, 89, 88, 87, 86, 84, 83, 82, 81, 80, 79, 78,
76, 75, 75, 74, 73, 72, 71, 69, 68, 68, 65, 65, 63, 62, 60, 58, 56, 54, 52, 50,
47, 44, 42, 40, 38, 35, 34, 32, 30, 30, 28, 26, 25, 23, 21, 19, 17, 15, 12, 9,
6, 3, 1, -2, -6, -10, -12, -16, -20, -24, -28, -32, -36, -40, -44, -47, -52,
-55, -59, -61, -64, -66, -69, -71, -74, -76, -78, -79, -81, -81, -83, -84, -85,
-84, -86, -85, -85, -84, -85, -84, -84, -84, -83, -85, -84, -83, -82, -82, -82,
-81, -79, -79, -79, -77, -77, -75, -75, -74, -73, -72, -71, -68, -67, -65, -64,
-63, -60, -58, -57, -56, -54, -52, -52, -51, -50, -50, -48, -47, -45, -45, -44,
-42, -41, -39, -37, -37, -36, -36, -34, -34, -32, -30, -29, -28, -26, -25, -22,
-21, -20, -19, -18, -17, -16, -15, -15, -14, -13, -13, -13, -12, -10, -9, -7,
-6, -4, -3, 1, 2, 3, 4, 5, 4, 4, 4, 3, 0, -1, -3, -6, -8, -10, -14, -17, -20,
-23, -24, -25, -26, -25, -25, -24, -23, -21, -18, -15, -12, -9, -7, -4, 0, 2, 4,
6, 8, 9, 9, 11, 12, 13, 14, 14, 12, 12, 12, 11, 9, 9, 7, 4, 3, 1, 0, -2, -4, -5,
-8, -10, -12, -13, -14, -13, -13, -12, -10, -6, -3, };