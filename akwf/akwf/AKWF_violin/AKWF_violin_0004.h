#define DATA_LENGTH 512
#define DATA AKWF_violin_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 7, 12, 16, 21, 25, 31, 37, 42, 48,
54, 60, 64, 69, 75, 79, 84, 89, 93, 97, 100, 104, 108, 110, 113, 114, 116, 117,
117, 119, 119, 119, 118, 118, 117, 115, 113, 111, 109, 107, 104, 100, 97, 95,
91, 88, 85, 81, 77, 74, 69, 66, 63, 60, 56, 52, 50, 45, 42, 40, 38, 37, 36, 35,
35, 35, 34, 35, 36, 35, 36, 34, 34, 33, 31, 29, 27, 24, 21, 17, 14, 11, 7, 3, 0,
-3, -7, -9, -13, -17, -19, -22, -25, -28, -30, -32, -35, -37, -39, -42, -44,
-47, -50, -53, -57, -60, -64, -67, -69, -72, -74, -76, -78, -79, -80, -81, -81,
-80, -81, -81, -81, -81, -79, -80, -79, -78, -78, -78, -78, -77, -78, -78, -78,
-78, -80, -80, -82, -81, -82, -83, -84, -85, -86, -86, -88, -89, -91, -92, -93,
-93, -93, -93, -93, -92, -91, -89, -86, -84, -81, -77, -72, -68, -64, -60, -55,
-51, -47, -42, -38, -34, -30, -25, -22, -18, -15, -12, -8, -7, -4, -2, -1, 0, 0,
1, 0, 0, -2, -3, -4, -5, -8, -9, -11, -12, -15, -16, -17, -19, -20, -20, -21,
-20, -19, -18, -17, -16, -13, -11, -9, -6, -4, -1, 2, 4, 7, 10, 13, 15, 18, 20,
24, 27, 29, 32, 34, 36, 39, 41, 42, 43, 45, 46, 47, 48, 48, 49, 49, 49, 49, 48,
48, 48, 49, 48, 50, 51, 51, 53, 55, 56, 58, 60, 62, 64, 66, 69, 72, 73, 75, 78,
80, 82, 83, 84, 85, 86, 86, 87, 88, 87, 88, 87, 86, 86, 86, 86, 85, 85, 84, 84,
84, 83, 83, 82, 82, 82, 81, 82, 81, 81, 80, 79, 78, 78, 77, 76, 74, 73, 72, 70,
68, 66, 65, 63, 62, 60, 58, 57, 56, 54, 52, 51, 50, 48, 47, 46, 44, 42, 41, 40,
37, 34, 32, 30, 28, 25, 22, 18, 14, 11, 8, 3, -1, -4, -8, -12, -16, -19, -23,
-27, -30, -33, -37, -40, -43, -46, -48, -51, -54, -56, -59, -61, -63, -64, -66,
-67, -69, -70, -72, -73, -74, -75, -76, -76, -77, -79, -80, -81, -82, -83, -84,
-86, -85, -87, -88, -89, -90, -89, -89, -89, -89, -88, -87, -86, -85, -83, -81,
-79, -76, -75, -73, -72, -69, -68, -67, -65, -64, -63, -61, -60, -58, -59, -57,
-56, -56, -54, -54, -54, -53, -52, -51, -50, -49, -48, -47, -45, -45, -43, -41,
-41, -39, -37, -36, -34, -32, -29, -29, -27, -25, -25, -25, -24, -22, -22, -21,
-20, -20, -20, -19, -18, -17, -15, -14, -12, -11, -9, -7, -6, -3, -3, -2, -2,
-2, -3, -3, -5, -6, -8, -10, -12, -15, -18, -20, -23, -24, -25, -25, -26, -24,
-24, -22, -20, -17, -13, -10, -7, -4, 0, 3, 5, 8, 10, 13, 15, 17, 18, 19, 20,
19, 18, 17, 17, 14, 14, 11, 10, 9, 7, 6, 5, 3, 2, 0, -2, -3, -4, -6, -7, -7, -8,
-7, -3, };