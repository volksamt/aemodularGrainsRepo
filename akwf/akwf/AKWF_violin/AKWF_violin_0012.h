#define DATA_LENGTH 512
#define DATA AKWF_violin_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 9, 11, 14, 15, 18, 20, 23,
26, 27, 30, 31, 35, 37, 39, 41, 44, 45, 47, 49, 51, 54, 56, 59, 60, 62, 63, 66,
68, 69, 71, 73, 75, 77, 79, 80, 82, 84, 86, 87, 89, 90, 92, 94, 95, 96, 97, 98,
100, 101, 102, 104, 104, 105, 106, 107, 109, 109, 110, 111, 112, 113, 113, 113,
113, 113, 115, 115, 115, 115, 114, 115, 114, 115, 115, 114, 114, 113, 112, 113,
112, 111, 111, 110, 109, 107, 106, 106, 105, 104, 103, 102, 100, 98, 97, 95, 94,
91, 89, 88, 85, 84, 81, 79, 77, 74, 73, 70, 67, 66, 64, 60, 58, 55, 52, 50, 47,
44, 41, 38, 36, 32, 30, 27, 24, 21, 17, 15, 12, 9, 6, 4, 0, -2, -5, -9, -11,
-13, -17, -19, -22, -26, -29, -31, -34, -36, -39, -41, -44, -47, -49, -51, -54,
-56, -59, -61, -64, -65, -68, -70, -71, -74, -77, -78, -80, -82, -83, -86, -88,
-89, -91, -93, -93, -96, -97, -98, -100, -101, -103, -104, -106, -106, -107,
-109, -110, -110, -112, -112, -113, -113, -114, -116, -115, -116, -118, -118,
-117, -119, -118, -119, -119, -119, -119, -119, -119, -118, -119, -119, -118,
-119, -118, -117, -117, -116, -117, -116, -115, -115, -114, -113, -112, -112,
-111, -110, -109, -108, -106, -105, -104, -103, -101, -99, -98, -97, -95, -93,
-92, -90, -88, -86, -85, -84, -81, -80, -76, -74, -73, -70, -67, -66, -63, -61,
-58, -56, -54, -51, -49, -47, -44, -42, -40, -37, -34, -31, -29, -26, -23, -20,
-17, -15, -13, -10, -8, -4, -2, 1, 3, 6, 8, 11, 13, 15, 18, 19, 23, 25, 27, 30,
32, 34, 36, 39, 40, 42, 44, 47, 48, 51, 52, 54, 56, 57, 58, 61, 62, 64, 65, 67,
67, 68, 71, 71, 73, 73, 74, 75, 75, 76, 78, 79, 79, 80, 81, 81, 81, 82, 82, 82,
83, 83, 84, 84, 84, 83, 84, 85, 84, 84, 85, 85, 84, 84, 84, 84, 83, 83, 83, 83,
82, 81, 81, 80, 79, 79, 78, 78, 77, 76, 75, 75, 74, 73, 71, 72, 70, 69, 68, 67,
65, 65, 63, 62, 61, 59, 57, 57, 55, 53, 51, 50, 49, 47, 45, 43, 41, 40, 38, 35,
33, 32, 29, 27, 25, 24, 21, 19, 17, 14, 13, 11, 8, 6, 2, 1, -2, -4, -6, -9, -12,
-14, -17, -20, -22, -24, -27, -30, -32, -34, -37, -40, -42, -43, -47, -49, -51,
-54, -56, -58, -60, -63, -65, -67, -69, -70, -72, -74, -77, -78, -78, -80, -82,
-83, -84, -86, -87, -87, -89, -90, -90, -91, -92, -92, -92, -92, -92, -93, -92,
-93, -92, -91, -91, -91, -91, -90, -89, -88, -87, -86, -85, -84, -83, -82, -79,
-79, -77, -76, -74, -72, -70, -69, -67, -65, -63, -61, -59, -57, -54, -52, -50,
-48, -46, -44, -42, -39, -38, -35, -33, -31, -28, -27, -25, -22, -20, -17, -14,
-13, -9, -6, -4, -1, };