#define DATA_LENGTH 512
#define DATA AKWF_violin_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 6, 7, 8, 10, 11, 13, 15, 15,
16, 18, 19, 20, 21, 22, 23, 23, 24, 26, 26, 28, 29, 29, 30, 32, 31, 33, 33, 34,
36, 35, 37, 38, 38, 39, 40, 41, 40, 42, 43, 43, 44, 45, 44, 45, 45, 46, 47, 47,
48, 49, 49, 49, 50, 50, 50, 51, 51, 52, 51, 52, 53, 53, 53, 54, 54, 54, 55, 56,
55, 56, 56, 57, 57, 57, 58, 59, 58, 59, 59, 60, 61, 60, 61, 61, 61, 62, 62, 62,
63, 63, 63, 64, 65, 64, 65, 65, 65, 66, 66, 67, 67, 67, 67, 68, 68, 67, 68, 69,
68, 69, 70, 70, 70, 70, 70, 70, 70, 71, 70, 71, 72, 71, 71, 71, 72, 71, 72, 71,
72, 72, 72, 73, 72, 72, 72, 73, 73, 72, 72, 73, 72, 72, 73, 73, 74, 73, 72, 73,
73, 73, 73, 73, 73, 74, 73, 73, 73, 73, 73, 73, 73, 73, 72, 73, 73, 74, 74, 73,
73, 74, 74, 74, 73, 73, 74, 74, 74, 74, 74, 74, 74, 74, 74, 74, 74, 74, 74, 74,
74, 75, 75, 75, 75, 74, 75, 75, 75, 75, 76, 75, 75, 75, 76, 74, 75, 76, 75, 76,
75, 75, 75, 75, 75, 75, 75, 75, 74, 74, 74, 75, 74, 75, 75, 74, 75, 75, 73, 74,
73, 74, 72, 72, 72, 72, 71, 71, 70, 70, 70, 69, 69, 68, 67, 67, 66, 65, 64, 64,
63, 63, 62, 62, 59, 60, 58, 58, 56, 56, 55, 53, 52, 51, 49, 49, 48, 46, 46, 43,
43, 42, 41, 39, 37, 36, 35, 33, 32, 30, 28, 27, 26, 25, 23, 21, 19, 18, 16, 14,
12, 11, 9, 8, 6, 4, 2, 1, -1, -3, -4, -6, -8, -9, -11, -14, -15, -17, -19, -20,
-23, -24, -26, -28, -29, -31, -33, -34, -37, -38, -40, -42, -43, -45, -46, -49,
-49, -52, -53, -55, -56, -59, -60, -61, -63, -64, -65, -68, -69, -70, -71, -73,
-74, -76, -77, -79, -80, -80, -82, -84, -85, -86, -87, -87, -89, -91, -92, -93,
-94, -94, -96, -97, -98, -99, -100, -101, -101, -102, -102, -103, -104, -104,
-106, -106, -107, -108, -108, -109, -109, -110, -111, -111, -112, -113, -112,
-113, -113, -115, -114, -115, -115, -116, -115, -116, -117, -116, -117, -118,
-118, -117, -118, -118, -118, -118, -119, -119, -119, -119, -119, -119, -120,
-118, -120, -119, -119, -119, -118, -119, -118, -118, -118, -118, -117, -117,
-117, -116, -116, -115, -115, -114, -114, -113, -112, -113, -111, -111, -110,
-110, -108, -107, -106, -105, -105, -103, -103, -101, -100, -99, -98, -96, -96,
-94, -93, -91, -90, -88, -88, -86, -84, -82, -82, -80, -79, -77, -75, -73, -72,
-71, -69, -67, -66, -64, -62, -60, -59, -57, -56, -55, -53, -50, -49, -47, -46,
-43, -42, -40, -39, -37, -36, -34, -32, -31, -28, -27, -26, -23, -23, -21, -21,
-19, -17, -15, -14, -13, -11, -10, -8, -6, -5, -3, -1, };