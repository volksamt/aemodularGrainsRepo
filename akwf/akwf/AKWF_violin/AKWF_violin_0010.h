#define DATA_LENGTH 512
#define DATA AKWF_violin_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 2, 3, 6, 10, 13, 16, 19, 21,
24, 26, 29, 32, 35, 36, 39, 42, 45, 45, 48, 50, 52, 53, 55, 58, 59, 60, 62, 63,
64, 65, 67, 67, 67, 69, 69, 70, 70, 69, 69, 69, 69, 69, 70, 69, 69, 68, 68, 66,
66, 65, 64, 63, 63, 63, 61, 60, 59, 58, 58, 55, 55, 54, 52, 52, 50, 50, 49, 48,
48, 48, 47, 46, 44, 43, 44, 42, 42, 42, 41, 40, 41, 40, 40, 40, 39, 39, 39, 39,
40, 39, 39, 39, 40, 40, 41, 42, 41, 41, 43, 44, 43, 44, 45, 46, 47, 49, 49, 50,
50, 51, 52, 55, 56, 57, 59, 60, 61, 63, 64, 65, 68, 70, 71, 73, 75, 77, 77, 80,
82, 84, 85, 88, 89, 92, 94, 96, 98, 98, 99, 102, 103, 105, 107, 107, 108, 111,
111, 113, 114, 115, 116, 117, 118, 118, 118, 118, 119, 118, 119, 119, 119, 119,
118, 117, 117, 116, 115, 115, 113, 111, 110, 108, 106, 105, 103, 101, 100, 97,
95, 93, 90, 88, 85, 82, 80, 77, 75, 71, 68, 66, 63, 59, 57, 54, 52, 48, 45, 42,
40, 37, 34, 31, 29, 27, 23, 21, 18, 16, 14, 11, 9, 7, 4, 3, 1, -2, -3, -5, -5,
-7, -9, -11, -11, -13, -14, -14, -15, -15, -16, -17, -17, -18, -18, -18, -18,
-18, -17, -18, -18, -17, -16, -17, -15, -15, -16, -14, -14, -13, -12, -11, -10,
-8, -8, -7, -6, -6, -4, -3, -2, -2, -1, 0, 2, 2, 3, 4, 5, 5, 6, 6, 7, 7, 8, 8,
9, 9, 11, 11, 12, 11, 11, 11, 11, 11, 10, 10, 10, 9, 9, 8, 8, 7, 6, 5, 4, 4, 2,
1, 0, -1, -2, -4, -6, -8, -8, -11, -13, -15, -16, -18, -20, -23, -25, -26, -28,
-31, -33, -36, -38, -41, -43, -45, -47, -51, -52, -54, -58, -60, -62, -65, -67,
-70, -72, -74, -77, -79, -80, -82, -85, -87, -89, -90, -92, -95, -96, -98, -100,
-101, -102, -103, -105, -105, -107, -108, -108, -109, -111, -110, -112, -111,
-112, -112, -112, -112, -112, -111, -112, -111, -110, -110, -111, -109, -109,
-108, -106, -105, -105, -104, -102, -101, -101, -98, -98, -96, -94, -93, -92,
-90, -88, -87, -86, -84, -83, -81, -80, -77, -76, -75, -73, -73, -72, -70, -69,
-67, -66, -64, -64, -62, -62, -60, -59, -60, -58, -58, -56, -57, -55, -56, -55,
-54, -55, -54, -54, -54, -53, -53, -53, -54, -54, -54, -54, -55, -55, -55, -56,
-57, -57, -58, -58, -58, -58, -60, -59, -60, -61, -61, -61, -62, -63, -62, -63,
-64, -64, -64, -65, -66, -66, -67, -66, -66, -67, -67, -67, -66, -67, -67, -67,
-66, -66, -66, -66, -64, -64, -64, -63, -63, -61, -60, -59, -59, -58, -56, -55,
-54, -52, -51, -50, -48, -46, -44, -41, -40, -38, -36, -34, -32, -30, -27, -24,
-22, -20, -17, -14, -12, -8, -5, -3, -2, -1, };