#define DATA_LENGTH 512
#define DATA AKWF_violin_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 13, 19, 24, 29, 34, 39, 44,
50, 55, 60, 65, 70, 75, 79, 83, 87, 92, 96, 100, 104, 106, 109, 112, 114, 115,
117, 117, 119, 119, 119, 120, 119, 119, 118, 116, 114, 112, 111, 108, 107, 104,
103, 99, 98, 95, 93, 90, 88, 86, 84, 82, 81, 79, 78, 77, 76, 75, 74, 73, 71, 70,
68, 66, 65, 63, 60, 58, 56, 53, 48, 45, 42, 38, 35, 31, 27, 23, 21, 18, 15, 13,
11, 9, 7, 6, 4, 2, -1, -2, -5, -6, -8, -9, -11, -12, -12, -12, -12, -12, -12,
-12, -10, -9, -8, -8, -7, -5, -4, -2, -1, 0, 1, 1, 2, 2, 2, 2, 1, 1, 0, -1, -3,
-4, -7, -9, -12, -14, -17, -21, -24, -28, -30, -32, -36, -38, -41, -44, -46,
-49, -51, -55, -57, -60, -62, -65, -67, -69, -71, -74, -75, -77, -78, -79, -81,
-82, -84, -84, -86, -87, -88, -89, -90, -91, -91, -92, -91, -90, -90, -91, -91,
-91, -90, -90, -91, -91, -91, -92, -92, -94, -94, -94, -92, -93, -92, -91, -91,
-90, -90, -88, -87, -86, -84, -83, -81, -79, -77, -75, -72, -70, -65, -63, -59,
-55, -51, -47, -43, -38, -33, -29, -25, -20, -17, -12, -9, -6, -2, 1, 5, 7, 10,
13, 16, 19, 21, 25, 27, 30, 32, 35, 36, 38, 39, 42, 43, 45, 46, 47, 47, 49, 49,
50, 50, 51, 52, 52, 54, 54, 56, 57, 59, 61, 63, 66, 69, 71, 73, 76, 77, 80, 83,
85, 87, 88, 89, 90, 91, 92, 91, 91, 91, 91, 91, 90, 91, 90, 90, 90, 89, 90, 90,
90, 89, 90, 91, 91, 91, 91, 92, 92, 92, 92, 92, 92, 91, 91, 90, 89, 89, 87, 86,
85, 82, 81, 79, 79, 76, 74, 73, 70, 70, 68, 67, 65, 65, 64, 62, 62, 61, 59, 59,
57, 57, 55, 53, 52, 52, 49, 47, 45, 43, 40, 38, 35, 33, 30, 27, 24, 21, 18, 16,
12, 10, 6, 5, 3, 0, -1, -4, -6, -7, -10, -12, -15, -17, -19, -21, -24, -27, -28,
-31, -34, -36, -39, -41, -43, -45, -46, -47, -49, -50, -53, -54, -55, -56, -58,
-60, -61, -64, -66, -67, -69, -71, -74, -76, -78, -80, -80, -82, -83, -83, -85,
-86, -85, -84, -84, -84, -83, -82, -80, -80, -79, -77, -76, -77, -77, -77, -76,
-76, -76, -76, -77, -77, -77, -76, -76, -74, -72, -72, -71, -69, -67, -65, -64,
-62, -62, -61, -61, -60, -59, -58, -57, -57, -57, -57, -56, -56, -57, -56, -57,
-57, -59, -59, -58, -57, -56, -54, -52, -50, -47, -45, -43, -40, -38, -35, -33,
-31, -29, -27, -25, -24, -23, -23, -22, -24, -25, -26, -28, -29, -32, -35, -37,
-39, -38, -40, -40, -41, -40, -40, -40, -38, -38, -38, -38, -36, -37, -36, -36,
-35, -36, -37, -37, -36, -36, -34, -34, -34, -33, -33, -31, -29, -27, -24, -22,
-19, -16, -13, -9, -5, -1, };