#define DATA_LENGTH 512
#define DATA AKWF_violin_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 7, 12, 16, 20, 24, 29, 31, 34,
37, 39, 41, 43, 46, 49, 52, 54, 57, 60, 63, 67, 71, 73, 77, 81, 82, 85, 87, 87,
89, 91, 91, 92, 93, 95, 94, 95, 95, 96, 98, 97, 99, 101, 102, 104, 106, 107,
110, 111, 114, 115, 116, 117, 119, 118, 119, 119, 118, 119, 117, 117, 116, 114,
112, 110, 107, 105, 101, 97, 94, 89, 85, 81, 76, 72, 68, 63, 58, 52, 46, 42, 36,
30, 24, 18, 14, 8, 4, -1, -5, -10, -15, -18, -22, -26, -30, -35, -38, -43, -48,
-52, -56, -60, -64, -68, -71, -74, -77, -80, -83, -85, -87, -89, -90, -91, -93,
-94, -95, -96, -98, -99, -100, -102, -104, -105, -105, -107, -109, -110, -110,
-112, -111, -111, -111, -110, -107, -106, -102, -100, -95, -91, -87, -84, -78,
-74, -69, -64, -58, -53, -47, -42, -38, -32, -28, -23, -18, -15, -10, -7, -4,
-2, 1, 3, 5, 7, 7, 9, 9, 9, 10, 11, 12, 12, 13, 15, 16, 18, 19, 21, 23, 25, 26,
28, 30, 31, 33, 34, 36, 37, 39, 40, 39, 40, 40, 40, 39, 38, 35, 33, 31, 29, 27,
23, 22, 20, 19, 17, 17, 17, 17, 17, 18, 18, 19, 19, 18, 18, 17, 17, 14, 12, 8,
4, 0, -5, -9, -13, -18, -24, -30, -34, -40, -45, -51, -55, -60, -64, -67, -71,
-73, -75, -76, -76, -76, -76, -75, -74, -72, -69, -68, -66, -66, -65, -65, -64,
-63, -64, -65, -66, -67, -67, -69, -68, -69, -69, -67, -64, -62, -59, -55, -50,
-44, -38, -30, -22, -14, -5, 2, 9, 18, 26, 35, 42, 49, 55, 60, 65, 68, 72, 74,
76, 76, 75, 75, 74, 74, 72, 70, 69, 65, 62, 60, 58, 57, 55, 53, 52, 51, 51, 52,
53, 54, 56, 60, 62, 65, 70, 73, 77, 80, 84, 88, 91, 94, 96, 98, 99, 99, 99, 98,
98, 98, 97, 96, 95, 94, 92, 90, 88, 86, 83, 79, 76, 73, 69, 65, 62, 57, 52, 48,
43, 38, 33, 26, 19, 14, 8, 2, -3, -9, -14, -19, -23, -25, -28, -30, -32, -34,
-36, -36, -37, -38, -38, -38, -40, -40, -41, -41, -42, -45, -46, -49, -51, -53,
-56, -57, -60, -62, -64, -65, -65, -65, -66, -66, -65, -65, -64, -63, -63, -62,
-61, -58, -57, -55, -53, -52, -50, -48, -46, -45, -44, -42, -40, -39, -36, -35,
-32, -30, -28, -25, -24, -21, -19, -16, -15, -14, -12, -12, -11, -10, -9, -9,
-8, -8, -7, -7, -6, -5, -6, -6, -6, -7, -8, -9, -10, -12, -12, -15, -15, -17,
-18, -20, -22, -24, -25, -25, -26, -26, -26, -25, -24, -23, -20, -18, -16, -15,
-14, -12, -12, -11, -12, -13, -14, -16, -19, -22, -26, -27, -32, -36, -41, -45,
-49, -53, -58, -64, -67, -71, -73, -75, -77, -77, -76, -75, -74, -72, -69, -66,
-61, -58, -54, -50, -45, -39, -35, -30, -24, -19, -14, -8, -2, };