#define DATA_LENGTH 512
#define DATA AKWF_violin_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 13, 15, 17, 20, 22, 25,
27, 29, 31, 33, 36, 37, 40, 42, 44, 46, 47, 49, 51, 52, 53, 55, 55, 56, 58, 59,
60, 61, 60, 61, 62, 62, 62, 63, 64, 65, 64, 64, 65, 65, 66, 64, 65, 64, 65, 64,
64, 63, 64, 63, 63, 62, 62, 61, 61, 61, 60, 59, 58, 58, 58, 56, 56, 54, 54, 53,
53, 51, 52, 51, 49, 48, 48, 48, 47, 46, 46, 45, 44, 43, 43, 43, 43, 41, 41, 41,
41, 41, 41, 40, 40, 40, 40, 41, 41, 41, 42, 44, 44, 44, 44, 45, 46, 47, 48, 49,
50, 52, 53, 54, 57, 58, 59, 61, 63, 65, 67, 68, 71, 71, 74, 75, 78, 79, 82, 83,
86, 87, 89, 91, 93, 95, 97, 99, 101, 103, 104, 105, 107, 108, 110, 111, 112,
113, 115, 116, 117, 117, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 117,
117, 116, 115, 114, 114, 112, 112, 109, 109, 108, 107, 104, 103, 101, 99, 97,
95, 93, 90, 88, 86, 84, 82, 79, 77, 74, 71, 69, 66, 64, 61, 59, 57, 55, 52, 49,
46, 45, 42, 39, 36, 33, 31, 29, 28, 25, 23, 22, 19, 17, 15, 14, 12, 11, 9, 7, 7,
6, 4, 3, 2, 1, 1, 0, -1, -2, -2, -3, -4, -4, -5, -5, -5, -5, -5, -6, -6, -5, -6,
-5, -5, -5, -5, -4, -4, -4, -3, -3, -2, -2, -1, -1, 1, 2, 2, 3, 4, 4, 5, 5, 6,
6, 7, 8, 8, 9, 9, 11, 11, 12, 13, 13, 14, 13, 14, 13, 14, 15, 15, 14, 15, 15,
15, 14, 14, 14, 13, 13, 12, 12, 11, 10, 9, 8, 7, 7, 5, 4, 3, 2, 0, 0, -2, -4,
-5, -8, -10, -12, -14, -16, -18, -20, -22, -24, -27, -29, -32, -33, -36, -39,
-40, -44, -46, -48, -50, -53, -56, -57, -60, -62, -64, -67, -70, -72, -73, -76,
-78, -80, -81, -84, -85, -88, -89, -91, -92, -94, -95, -97, -97, -99, -100,
-101, -102, -102, -103, -104, -104, -105, -106, -106, -106, -107, -106, -107,
-107, -106, -106, -106, -105, -106, -105, -104, -104, -103, -102, -102, -100,
-99, -99, -97, -96, -96, -94, -93, -93, -91, -90, -89, -88, -87, -86, -85, -84,
-83, -81, -80, -79, -78, -77, -76, -75, -74, -73, -72, -71, -71, -71, -70, -69,
-68, -69, -67, -67, -66, -66, -65, -65, -66, -65, -65, -65, -64, -64, -65, -65,
-65, -64, -64, -65, -65, -66, -66, -67, -67, -68, -69, -68, -69, -69, -70, -71,
-72, -72, -72, -73, -73, -74, -74, -75, -75, -76, -77, -77, -77, -77, -78, -78,
-78, -78, -78, -77, -78, -78, -78, -77, -77, -76, -77, -75, -75, -74, -73, -72,
-72, -70, -70, -68, -67, -66, -64, -63, -62, -58, -57, -55, -54, -52, -50, -49,
-45, -44, -42, -39, -37, -34, -32, -29, -27, -25, -22, -20, -16, -15, -12, -10,
-8, -5, -3, 0, };