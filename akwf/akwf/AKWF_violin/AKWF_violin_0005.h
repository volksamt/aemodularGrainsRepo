#define DATA_LENGTH 512
#define DATA AKWF_violin_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 14, 18, 21, 24, 28, 31, 36,
39, 43, 48, 52, 58, 61, 67, 71, 76, 80, 84, 89, 94, 98, 102, 105, 108, 110, 112,
114, 116, 117, 117, 119, 119, 119, 119, 118, 119, 117, 116, 115, 113, 112, 109,
107, 106, 104, 102, 100, 99, 97, 95, 94, 93, 93, 93, 92, 91, 91, 92, 91, 91, 89,
88, 86, 85, 82, 79, 76, 72, 68, 63, 59, 56, 51, 47, 43, 39, 34, 29, 25, 22, 18,
14, 11, 8, 5, 2, -1, -5, -7, -9, -11, -14, -14, -16, -17, -18, -18, -18, -16,
-16, -14, -14, -13, -11, -10, -8, -7, -6, -4, -4, -3, -3, -2, -1, -3, -4, -5,
-6, -7, -9, -11, -14, -16, -19, -22, -24, -28, -31, -33, -36, -39, -41, -42,
-45, -47, -49, -51, -53, -55, -57, -58, -62, -64, -68, -71, -73, -75, -78, -81,
-83, -85, -87, -88, -88, -88, -88, -88, -88, -86, -86, -84, -84, -83, -81, -81,
-79, -79, -79, -78, -79, -78, -79, -79, -81, -81, -82, -82, -84, -84, -85, -85,
-86, -85, -86, -87, -88, -88, -88, -88, -89, -89, -88, -88, -88, -87, -85, -83,
-80, -77, -73, -68, -65, -60, -55, -50, -45, -40, -35, -29, -25, -21, -16, -13,
-9, -5, -2, 2, 4, 8, 10, 13, 15, 18, 20, 22, 25, 26, 28, 30, 32, 33, 34, 34, 34,
33, 33, 33, 34, 33, 34, 34, 36, 37, 39, 40, 43, 44, 48, 51, 54, 57, 60, 63, 66,
69, 73, 77, 79, 81, 83, 86, 88, 89, 92, 92, 95, 95, 96, 98, 97, 98, 98, 97, 98,
97, 96, 97, 96, 95, 95, 95, 95, 95, 94, 94, 94, 93, 93, 92, 93, 92, 92, 92, 90,
90, 90, 88, 86, 84, 82, 80, 79, 77, 76, 75, 74, 73, 73, 71, 72, 72, 72, 72, 71,
71, 71, 72, 70, 70, 70, 70, 68, 67, 66, 65, 63, 61, 59, 57, 55, 52, 49, 48, 45,
43, 40, 37, 35, 32, 30, 27, 24, 21, 18, 14, 12, 9, 6, 2, 0, -2, -5, -9, -11,
-14, -17, -20, -22, -24, -27, -30, -32, -34, -36, -39, -41, -43, -46, -49, -51,
-53, -55, -58, -60, -62, -65, -67, -70, -72, -74, -77, -80, -82, -85, -86, -88,
-91, -91, -93, -95, -95, -96, -97, -97, -97, -97, -95, -95, -95, -93, -92, -91,
-90, -90, -89, -88, -87, -87, -87, -86, -86, -85, -84, -85, -84, -82, -82, -81,
-80, -79, -78, -77, -75, -73, -71, -70, -67, -65, -64, -61, -59, -58, -56, -54,
-52, -51, -51, -50, -49, -48, -48, -48, -48, -47, -48, -47, -47, -46, -46, -45,
-44, -44, -44, -44, -43, -42, -42, -43, -43, -41, -41, -40, -40, -41, -39, -39,
-39, -39, -38, -37, -35, -33, -31, -29, -27, -26, -23, -22, -20, -18, -17, -15,
-15, -15, -15, -16, -17, -18, -18, -19, -20, -22, -23, -24, -24, -26, -26, -26,
-25, -23, -21, -19, -17, -15, -13, -10, -8, -5, -1, };