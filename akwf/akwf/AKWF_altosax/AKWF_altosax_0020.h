#define DATA_LENGTH 512
#define DATA AKWF_altosax_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 7, 13, 16, 20, 24, 29, 32, 36, 41,
43, 47, 51, 55, 58, 62, 65, 69, 72, 75, 78, 82, 85, 87, 89, 92, 94, 96, 100,
102, 104, 106, 107, 109, 110, 111, 114, 115, 115, 116, 117, 118, 119, 118, 119,
119, 119, 119, 119, 118, 118, 117, 117, 117, 117, 116, 116, 114, 113, 113, 113,
111, 110, 109, 108, 107, 106, 105, 105, 104, 103, 102, 103, 101, 101, 100, 100,
101, 100, 99, 99, 99, 98, 97, 97, 95, 95, 95, 95, 94, 93, 93, 92, 91, 89, 88,
88, 86, 85, 83, 82, 80, 78, 76, 74, 73, 71, 69, 67, 65, 64, 61, 60, 58, 57, 54,
52, 51, 49, 49, 46, 44, 44, 43, 41, 41, 40, 39, 39, 39, 38, 38, 37, 37, 37, 38,
38, 38, 38, 40, 40, 41, 42, 43, 44, 45, 46, 47, 48, 48, 49, 50, 51, 52, 52, 53,
54, 55, 55, 56, 57, 56, 58, 57, 58, 58, 58, 59, 58, 58, 59, 57, 58, 58, 58, 57,
56, 57, 57, 56, 56, 57, 56, 54, 55, 55, 54, 54, 54, 52, 52, 52, 51, 50, 51, 49,
49, 48, 47, 47, 47, 45, 45, 43, 43, 41, 42, 41, 39, 38, 36, 36, 35, 33, 32, 31,
29, 28, 26, 24, 23, 21, 20, 18, 17, 15, 14, 13, 11, 9, 8, 7, 5, 4, 3, 1, 0, -1,
-4, -5, -6, -8, -10, -12, -13, -15, -16, -17, -19, -21, -22, -24, -24, -25, -26,
-27, -29, -30, -31, -31, -33, -33, -35, -36, -36, -37, -38, -40, -40, -41, -41,
-43, -44, -46, -45, -46, -47, -49, -49, -51, -51, -52, -53, -55, -56, -56, -57,
-58, -58, -60, -62, -62, -63, -64, -65, -67, -67, -68, -68, -70, -70, -71, -72,
-72, -73, -74, -74, -73, -74, -75, -75, -75, -76, -75, -76, -76, -75, -76, -74,
-74, -74, -72, -73, -72, -71, -70, -70, -70, -69, -68, -67, -67, -65, -64, -63,
-63, -63, -62, -61, -61, -60, -59, -59, -58, -57, -56, -54, -53, -53, -51, -51,
-50, -49, -49, -47, -47, -46, -46, -44, -44, -43, -43, -43, -41, -42, -40, -40,
-39, -39, -38, -38, -37, -37, -35, -35, -34, -34, -34, -33, -32, -33, -32, -32,
-33, -32, -33, -31, -32, -32, -33, -33, -34, -33, -34, -35, -36, -36, -37, -37,
-38, -39, -39, -40, -41, -41, -42, -43, -43, -45, -46, -46, -48, -50, -51, -51,
-52, -54, -55, -56, -58, -58, -60, -61, -62, -63, -65, -66, -67, -68, -70, -71,
-72, -73, -74, -75, -76, -76, -78, -79, -79, -80, -81, -83, -83, -84, -84, -85,
-87, -87, -88, -89, -90, -90, -91, -92, -92, -93, -93, -94, -94, -94, -94, -95,
-94, -94, -93, -94, -94, -94, -93, -93, -92, -93, -91, -91, -91, -89, -88, -88,
-86, -85, -84, -83, -81, -80, -78, -77, -75, -73, -71, -68, -66, -63, -62, -58,
-55, -53, -49, -47, -44, -40, -38, -34, -31, -28, -24, -20, -17, -12, -8, -4, 0,
};