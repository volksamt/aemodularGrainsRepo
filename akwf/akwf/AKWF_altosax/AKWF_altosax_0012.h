#define DATA_LENGTH 512
#define DATA AKWF_altosax_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 7, 10, 13, 15, 18, 20, 23,
25, 26, 28, 30, 32, 33, 35, 36, 37, 38, 37, 39, 39, 40, 40, 40, 42, 42, 42, 42,
41, 42, 42, 42, 42, 41, 42, 43, 42, 42, 42, 43, 42, 43, 43, 42, 43, 42, 43, 42,
44, 44, 44, 46, 45, 47, 47, 48, 49, 49, 50, 51, 52, 54, 55, 56, 57, 59, 59, 60,
60, 60, 60, 60, 61, 61, 61, 62, 64, 66, 67, 68, 69, 70, 71, 72, 73, 74, 75, 77,
79, 80, 82, 85, 85, 87, 88, 89, 90, 91, 92, 93, 94, 95, 96, 97, 99, 98, 100,
101, 102, 103, 103, 104, 105, 106, 107, 108, 109, 110, 109, 110, 107, 107, 106,
103, 102, 100, 98, 97, 94, 93, 91, 91, 89, 88, 86, 85, 83, 81, 79, 78, 76, 75,
74, 74, 74, 74, 75, 75, 76, 78, 78, 78, 79, 78, 80, 80, 81, 80, 80, 81, 81, 82,
83, 83, 84, 83, 84, 84, 84, 83, 81, 82, 82, 82, 83, 83, 84, 82, 82, 83, 84, 83,
84, 85, 85, 85, 85, 84, 84, 84, 83, 83, 81, 80, 79, 79, 78, 77, 75, 76, 75, 75,
76, 75, 75, 75, 76, 75, 75, 75, 76, 76, 76, 75, 75, 75, 74, 74, 73, 73, 73, 73,
72, 71, 71, 70, 68, 66, 64, 61, 60, 57, 53, 50, 46, 43, 39, 36, 33, 29, 25, 21,
17, 12, 7, 4, -1, -6, -9, -13, -16, -18, -20, -22, -25, -26, -30, -31, -32, -33,
-34, -34, -32, -29, -27, -24, -21, -18, -15, -13, -11, -10, -8, -6, -5, -2, -1,
2, 3, 5, 5, 6, 5, 2, 0, -5, -11, -16, -21, -24, -29, -32, -35, -37, -39, -41,
-43, -44, -47, -50, -52, -54, -56, -58, -60, -63, -64, -64, -67, -70, -72, -74,
-79, -80, -83, -84, -87, -88, -89, -90, -91, -90, -91, -90, -90, -90, -88, -88,
-87, -87, -87, -87, -86, -88, -90, -91, -94, -96, -98, -99, -100, -102, -103,
-103, -103, -104, -105, -105, -106, -108, -108, -109, -109, -109, -108, -107,
-108, -107, -106, -105, -105, -105, -105, -105, -105, -106, -103, -102, -101,
-100, -98, -96, -95, -94, -95, -93, -94, -94, -96, -96, -96, -97, -98, -98, -99,
-100, -100, -103, -104, -105, -106, -107, -108, -110, -110, -111, -114, -114,
-115, -115, -116, -117, -118, -119, -119, -119, -118, -119, -119, -117, -116,
-115, -113, -110, -108, -106, -105, -102, -100, -99, -98, -95, -93, -91, -88,
-86, -82, -80, -78, -75, -73, -71, -70, -68, -67, -65, -65, -63, -61, -60, -58,
-56, -55, -52, -52, -50, -51, -50, -50, -50, -50, -48, -48, -47, -47, -46, -45,
-46, -44, -43, -42, -42, -40, -40, -39, -38, -37, -37, -36, -35, -35, -33, -33,
-33, -32, -31, -30, -30, -29, -27, -27, -26, -27, -26, -28, -27, -27, -27, -26,
-25, -25, -24, -24, -23, -23, -23, -22, -22, -21, -19, -17, -15, -13, -12, -10,
-8, -6, -4, -2, 0, };