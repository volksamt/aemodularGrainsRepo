#define DATA_LENGTH 512
#define DATA AKWF_altosax_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 5, 6, 8, 9, 11, 14, 15, 16,
19, 21, 21, 24, 26, 28, 30, 32, 33, 36, 38, 39, 42, 44, 45, 47, 49, 52, 53, 56,
58, 60, 61, 63, 66, 67, 69, 72, 74, 76, 78, 79, 82, 84, 86, 86, 89, 91, 92, 93,
95, 97, 97, 100, 102, 103, 104, 105, 107, 108, 109, 110, 111, 112, 113, 114,
115, 116, 117, 117, 118, 119, 119, 119, 119, 119, 120, 119, 119, 119, 118, 118,
119, 119, 118, 119, 118, 116, 116, 116, 116, 114, 114, 113, 113, 111, 111, 109,
109, 108, 106, 105, 104, 102, 100, 99, 96, 94, 92, 91, 88, 86, 84, 81, 78, 75,
73, 70, 68, 65, 62, 60, 57, 54, 52, 51, 48, 47, 44, 42, 41, 40, 39, 38, 36, 34,
33, 31, 30, 28, 27, 24, 23, 21, 19, 15, 13, 10, 9, 6, 4, 2, -2, -5, -6, -9, -11,
-14, -15, -18, -19, -21, -23, -24, -26, -28, -28, -31, -32, -33, -34, -35, -36,
-38, -39, -40, -40, -41, -42, -43, -44, -45, -46, -46, -48, -47, -48, -49, -49,
-50, -51, -52, -52, -52, -52, -52, -53, -53, -52, -52, -53, -53, -53, -52, -53,
-51, -52, -52, -51, -52, -51, -51, -50, -50, -50, -49, -49, -49, -48, -48, -48,
-47, -46, -47, -46, -45, -45, -44, -44, -43, -42, -43, -41, -41, -41, -39, -40,
-38, -38, -37, -36, -36, -34, -33, -32, -30, -29, -29, -28, -26, -25, -24, -23,
-22, -21, -19, -18, -18, -16, -14, -14, -13, -12, -11, -11, -11, -10, -9, -9,
-8, -8, -7, -6, -6, -5, -5, -3, -3, -3, -3, -3, -2, -3, -3, -2, -2, -2, -2, -2,
-3, -3, -3, -2, -4, -3, -3, -3, -4, -4, -4, -5, -6, -6, -6, -6, -7, -7, -8, -9,
-9, -10, -10, -10, -11, -11, -12, -12, -13, -13, -14, -14, -15, -16, -17, -18,
-18, -18, -18, -20, -20, -21, -21, -22, -24, -24, -25, -25, -26, -27, -27, -27,
-28, -30, -30, -30, -31, -32, -32, -33, -33, -34, -34, -35, -36, -36, -37, -36,
-37, -38, -39, -39, -39, -40, -40, -41, -41, -41, -42, -41, -41, -42, -42, -42,
-42, -42, -42, -42, -42, -42, -43, -43, -42, -42, -42, -42, -42, -42, -42, -42,
-42, -43, -42, -43, -42, -43, -41, -41, -41, -41, -42, -41, -41, -42, -41, -40,
-41, -41, -40, -41, -40, -40, -40, -40, -40, -39, -39, -39, -40, -40, -40, -39,
-39, -39, -40, -39, -39, -39, -39, -38, -39, -39, -38, -39, -38, -38, -38, -38,
-38, -38, -38, -38, -38, -37, -38, -37, -36, -37, -38, -37, -36, -37, -37, -37,
-36, -37, -37, -37, -36, -36, -35, -36, -36, -35, -34, -34, -35, -34, -35, -34,
-33, -34, -34, -34, -33, -32, -31, -31, -31, -30, -30, -30, -29, -28, -28, -28,
-27, -26, -26, -25, -24, -23, -22, -22, -21, -20, -19, -18, -17, -17, -15, -14,
-13, -12, -11, -10, -9, -8, -5, -4, -2, -2, };