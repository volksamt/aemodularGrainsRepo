#define DATA_LENGTH 512
#define DATA AKWF_altosax_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 2, 3, 3, 4, 3, 5, 5, 6, 7, 7,
7, 7, 6, 5, 4, 3, 3, 3, 2, 2, 3, 5, 5, 5, 6, 6, 5, 6, 6, 7, 7, 7, 8, 9, 9, 8, 8,
8, 8, 9, 10, 10, 9, 9, 9, 9, 9, 9, 10, 10, 11, 11, 12, 13, 13, 13, 13, 13, 13,
13, 14, 12, 12, 12, 12, 11, 10, 9, 9, 8, 8, 7, 6, 5, 4, 3, 2, 1, 1, 0, 0, 0, 0,
1, 0, 1, 0, 0, 0, 1, 1, 2, 3, 3, 2, 3, 4, 3, 4, 4, 5, 7, 8, 10, 11, 13, 15, 15,
17, 18, 20, 21, 23, 24, 25, 27, 29, 31, 33, 36, 36, 38, 40, 40, 40, 41, 42, 44,
46, 47, 48, 49, 50, 51, 51, 52, 52, 52, 52, 53, 54, 54, 55, 54, 53, 51, 50, 50,
48, 46, 45, 44, 42, 41, 40, 39, 38, 37, 36, 35, 34, 33, 32, 30, 30, 29, 29, 27,
28, 27, 27, 26, 27, 26, 26, 26, 25, 24, 25, 24, 25, 25, 25, 26, 28, 28, 29, 30,
30, 31, 33, 33, 35, 36, 38, 40, 40, 42, 44, 45, 48, 49, 52, 54, 55, 57, 58, 60,
61, 62, 63, 64, 66, 68, 69, 71, 71, 73, 74, 76, 78, 80, 81, 83, 85, 86, 89, 92,
93, 95, 96, 96, 97, 96, 98, 98, 99, 98, 100, 101, 102, 104, 104, 106, 107, 107,
109, 109, 110, 110, 111, 112, 112, 111, 111, 112, 111, 110, 110, 110, 108, 107,
106, 104, 103, 101, 98, 96, 93, 91, 88, 87, 84, 82, 78, 74, 71, 66, 62, 57, 52,
46, 42, 38, 33, 28, 25, 21, 17, 14, 11, 8, 5, 3, 0, -1, -2, -2, -3, -4, -5, -5,
-6, -5, -5, -4, -2, 0, 3, 6, 9, 12, 14, 17, 19, 20, 22, 21, 21, 19, 17, 14, 12,
8, 6, 3, -1, -3, -5, -9, -11, -14, -14, -15, -15, -15, -14, -14, -14, -15, -17,
-18, -21, -23, -26, -28, -31, -34, -37, -39, -42, -44, -46, -47, -48, -49, -49,
-49, -50, -49, -49, -50, -51, -51, -52, -54, -55, -57, -60, -63, -65, -69, -71,
-74, -76, -78, -80, -82, -83, -85, -86, -87, -88, -89, -89, -89, -91, -92, -93,
-95, -97, -98, -100, -102, -103, -104, -105, -106, -107, -107, -107, -108, -106,
-107, -107, -108, -108, -109, -110, -110, -110, -111, -112, -113, -114, -116,
-117, -118, -119, -119, -120, -119, -119, -118, -117, -118, -117, -115, -115,
-113, -113, -111, -109, -109, -107, -105, -104, -102, -102, -99, -99, -97, -96,
-95, -92, -91, -87, -85, -81, -79, -75, -73, -70, -68, -66, -64, -62, -60, -60,
-57, -56, -55, -54, -52, -51, -50, -50, -48, -48, -47, -46, -45, -45, -44, -44,
-43, -41, -40, -39, -39, -38, -38, -36, -35, -34, -33, -32, -31, -29, -26, -26,
-24, -22, -20, -18, -17, -16, -14, -13, -12, -11, -10, -8, -6, -5, -3, -2, -1,
0, };