#define DATA_LENGTH 512
#define DATA AKWF_altosax_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 12, 19, 26, 32, 40, 48, 55, 60, 64,
68, 72, 76, 79, 82, 84, 86, 88, 89, 89, 87, 87, 86, 86, 86, 87, 86, 88, 88, 90,
91, 92, 94, 93, 95, 93, 93, 92, 95, 96, 98, 98, 98, 98, 98, 99, 100, 101, 103,
101, 102, 105, 106, 109, 112, 114, 116, 117, 117, 118, 118, 118, 116, 115, 113,
111, 109, 106, 104, 101, 96, 91, 85, 80, 74, 70, 68, 63, 61, 60, 56, 55, 53, 50,
47, 45, 44, 41, 39, 38, 38, 35, 34, 34, 32, 30, 29, 26, 23, 21, 20, 18, 17, 17,
19, 19, 21, 23, 24, 23, 22, 20, 17, 16, 14, 12, 10, 8, 7, 8, 7, 9, 9, 8, 6, 2,
-3, -8, -13, -18, -23, -30, -35, -40, -46, -52, -58, -65, -71, -76, -78, -78,
-77, -74, -69, -63, -57, -48, -42, -35, -29, -23, -14, -2, 11, 22, 27, 27, 21,
12, 1, -6, -14, -20, -24, -27, -29, -32, -35, -38, -43, -49, -56, -63, -70, -76,
-81, -87, -90, -95, -95, -97, -97, -98, -98, -98, -99, -100, -105, -109, -114,
-117, -118, -119, -117, -115, -112, -109, -107, -107, -105, -101, -99, -95, -92,
-88, -83, -76, -72, -67, -64, -63, -61, -60, -60, -60, -60, -60, -60, -61, -63,
-68, -71, -74, -77, -82, -87, -93, -98, -98, -97, -94, -88, -85, -84, -85, -86,
-88, -88, -84, -81, -78, -75, -71, -68, -63, -58, -54, -49, -44, -39, -33, -26,
-18, -10, 0, 6, 14, 20, 27, 33, 42, 49, 55, 61, 66, 70, 73, 78, 81, 84, 87, 90,
90, 91, 90, 88, 86, 86, 87, 86, 87, 87, 87, 88, 89, 91, 92, 93, 94, 94, 92, 93,
94, 96, 97, 99, 101, 100, 99, 100, 102, 102, 103, 103, 104, 105, 106, 108, 111,
114, 115, 117, 118, 118, 119, 119, 118, 118, 116, 114, 113, 109, 106, 103, 100,
96, 90, 85, 79, 74, 70, 67, 64, 60, 58, 55, 53, 50, 48, 44, 42, 40, 38, 36, 35,
35, 33, 33, 31, 30, 28, 27, 25, 23, 22, 19, 19, 18, 18, 18, 20, 21, 24, 24, 25,
23, 21, 18, 17, 15, 13, 12, 10, 9, 9, 9, 10, 10, 9, 7, 3, -2, -7, -13, -18, -24,
-29, -34, -40, -45, -51, -57, -64, -70, -74, -77, -77, -75, -73, -69, -63, -57,
-49, -43, -37, -30, -24, -16, -4, 7, 18, 21, 22, 17, 9, -1, -9, -17, -21, -25,
-28, -31, -33, -36, -39, -44, -48, -54, -62, -68, -74, -81, -86, -90, -93, -95,
-95, -96, -96, -95, -96, -96, -98, -102, -107, -112, -115, -117, -118, -116,
-114, -112, -111, -109, -107, -105, -102, -99, -97, -93, -89, -82, -76, -71,
-67, -64, -62, -61, -61, -61, -62, -64, -64, -66, -68, -70, -74, -78, -82, -86,
-89, -93, -96, -95, -95, -91, -88, -84, -81, -81, -81, -82, -83, -82, -81, -77,
-76, -73, -71, -68, -65, -61, -57, -52, -46, -40, -35, -26, -18, -10, -1, };