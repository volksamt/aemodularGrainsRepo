#define DATA_LENGTH 512
#define DATA AKWF_altosax_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 9, 12, 14, 16, 17, 20, 22,
25, 28, 31, 34, 37, 40, 44, 47, 51, 54, 57, 61, 64, 66, 69, 71, 74, 77, 79, 82,
83, 86, 88, 90, 91, 93, 94, 94, 95, 96, 96, 96, 96, 96, 97, 97, 99, 102, 104,
106, 108, 110, 112, 112, 113, 115, 115, 116, 117, 118, 119, 118, 119, 119, 119,
118, 117, 116, 116, 115, 113, 113, 111, 110, 108, 107, 106, 106, 105, 104, 103,
103, 102, 101, 101, 100, 98, 97, 96, 95, 94, 92, 91, 90, 88, 86, 84, 81, 78, 75,
72, 68, 66, 64, 61, 58, 56, 53, 51, 49, 46, 43, 41, 37, 35, 30, 28, 25, 23, 20,
17, 15, 13, 11, 7, 5, 1, -3, -7, -11, -13, -15, -16, -17, -20, -21, -23, -25,
-27, -30, -31, -33, -35, -38, -40, -42, -43, -44, -45, -46, -47, -48, -49, -51,
-52, -53, -54, -55, -56, -56, -58, -58, -58, -60, -62, -63, -64, -66, -67, -67,
-67, -68, -68, -67, -68, -69, -70, -71, -72, -72, -72, -73, -73, -73, -73, -72,
-71, -71, -71, -69, -68, -69, -69, -68, -67, -67, -65, -66, -65, -64, -62, -61,
-60, -58, -57, -55, -54, -53, -52, -49, -47, -45, -42, -41, -39, -37, -34, -33,
-31, -30, -27, -26, -25, -25, -23, -22, -20, -19, -19, -17, -15, -14, -13, -11,
-11, -9, -8, -7, -5, -2, -2, -1, 1, 2, 4, 4, 6, 7, 9, 10, 11, 12, 12, 12, 13,
13, 13, 14, 16, 16, 17, 16, 16, 16, 17, 17, 18, 18, 19, 19, 18, 19, 19, 19, 19,
19, 19, 18, 18, 18, 17, 17, 16, 16, 14, 13, 11, 11, 10, 8, 7, 6, 4, 4, 3, 3, 2,
2, 0, 0, 0, -2, -2, -4, -4, -5, -7, -8, -9, -11, -12, -14, -15, -16, -17, -18,
-20, -20, -22, -22, -24, -25, -25, -27, -28, -29, -30, -30, -31, -31, -31, -30,
-31, -30, -31, -32, -33, -34, -34, -35, -36, -36, -36, -36, -37, -37, -37, -37,
-37, -37, -38, -37, -38, -38, -38, -40, -40, -39, -38, -37, -37, -36, -36, -35,
-34, -34, -33, -33, -32, -33, -33, -32, -32, -32, -30, -30, -28, -27, -26, -27,
-27, -26, -26, -25, -25, -24, -24, -23, -23, -23, -22, -22, -22, -21, -19, -19,
-18, -18, -17, -17, -17, -16, -16, -17, -15, -15, -15, -14, -15, -15, -15, -15,
-14, -15, -14, -14, -13, -14, -14, -15, -15, -15, -15, -15, -15, -15, -15, -16,
-14, -16, -16, -15, -15, -15, -15, -15, -16, -16, -17, -17, -18, -19, -20, -20,
-21, -21, -22, -22, -23, -23, -24, -24, -25, -25, -26, -25, -27, -27, -27, -29,
-27, -29, -29, -28, -29, -28, -28, -29, -29, -29, -30, -30, -31, -30, -30, -30,
-30, -31, -31, -31, -30, -30, -30, -30, -30, -30, -29, -29, -28, -28, -27, -26,
-26, -24, -24, -23, -22, -21, -21, -20, -18, -18, -16, -15, -14, -12, -11, -9,
-7, -6, -3, 0, };