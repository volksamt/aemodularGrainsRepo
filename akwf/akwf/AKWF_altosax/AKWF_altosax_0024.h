#define DATA_LENGTH 512
#define DATA AKWF_altosax_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 7, 10, 12, 15, 16, 20, 21, 24,
27, 30, 32, 35, 38, 41, 43, 47, 49, 52, 54, 57, 60, 63, 66, 69, 73, 75, 77, 80,
82, 86, 88, 91, 92, 95, 97, 99, 101, 104, 105, 107, 108, 110, 111, 112, 113,
115, 115, 116, 118, 117, 118, 118, 120, 118, 120, 119, 119, 118, 118, 118, 116,
116, 114, 113, 112, 111, 110, 108, 107, 105, 104, 101, 100, 97, 96, 94, 91, 89,
86, 85, 83, 80, 77, 75, 73, 70, 69, 67, 64, 62, 60, 58, 55, 53, 52, 49, 48, 45,
44, 42, 40, 38, 36, 36, 34, 33, 31, 29, 28, 27, 26, 24, 23, 22, 21, 20, 19, 18,
16, 15, 14, 13, 12, 10, 10, 8, 7, 6, 5, 3, 1, 0, -2, -3, -5, -6, -8, -10, -11,
-13, -16, -17, -19, -20, -23, -25, -27, -29, -31, -34, -36, -38, -39, -42, -44,
-46, -49, -51, -53, -55, -58, -59, -62, -64, -66, -68, -70, -72, -74, -76, -77,
-80, -81, -84, -85, -86, -88, -89, -90, -92, -93, -93, -95, -95, -96, -96, -97,
-98, -98, -98, -98, -99, -98, -99, -97, -97, -96, -96, -95, -95, -93, -92, -91,
-89, -87, -86, -84, -82, -80, -78, -75, -73, -70, -68, -66, -63, -61, -57, -55,
-51, -49, -46, -43, -40, -37, -34, -31, -28, -25, -21, -18, -14, -12, -9, -5,
-2, 1, 4, 7, 11, 14, 17, 20, 22, 26, 28, 31, 33, 35, 38, 41, 42, 45, 47, 49, 51,
53, 55, 55, 57, 58, 60, 61, 62, 63, 64, 65, 65, 66, 66, 66, 67, 66, 66, 67, 66,
66, 66, 66, 64, 64, 64, 63, 61, 61, 59, 58, 57, 57, 55, 53, 52, 50, 48, 47, 45,
44, 42, 41, 38, 36, 35, 32, 31, 29, 27, 25, 23, 21, 19, 17, 16, 13, 12, 9, 8, 6,
4, 3, 2, 0, -1, -3, -4, -4, -7, -8, -9, -10, -11, -12, -12, -13, -14, -15, -16,
-16, -16, -17, -17, -17, -18, -18, -18, -19, -18, -19, -19, -19, -19, -18, -19,
-19, -18, -18, -19, -19, -18, -17, -17, -18, -18, -18, -19, -18, -18, -18, -18,
-19, -19, -19, -18, -19, -20, -19, -20, -20, -21, -22, -22, -22, -23, -23, -24,
-25, -25, -26, -27, -27, -27, -29, -29, -29, -30, -31, -32, -33, -33, -34, -35,
-35, -37, -37, -37, -39, -39, -40, -40, -41, -42, -42, -44, -44, -45, -46, -47,
-46, -48, -48, -48, -49, -49, -50, -50, -51, -50, -51, -51, -52, -52, -52, -52,
-52, -53, -53, -52, -53, -52, -52, -52, -52, -52, -52, -51, -51, -51, -51, -51,
-49, -49, -50, -48, -48, -48, -48, -47, -47, -46, -46, -46, -46, -45, -44, -44,
-43, -43, -43, -42, -42, -41, -42, -40, -41, -41, -40, -40, -40, -39, -39, -39,
-38, -38, -38, -38, -37, -36, -36, -36, -34, -34, -34, -33, -31, -30, -30, -28,
-27, -25, -23, -22, -20, -18, -16, -14, -11, -10, -7, -5, -2, 1, };