#define DATA_LENGTH 512
#define DATA AKWF_altosax_0026

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 10, 15, 20, 24, 27, 33, 38, 43,
47, 52, 57, 61, 64, 68, 72, 75, 78, 81, 84, 87, 90, 93, 95, 97, 100, 102, 105,
107, 109, 111, 113, 115, 116, 117, 117, 118, 116, 115, 114, 112, 110, 109, 106,
104, 101, 97, 96, 93, 90, 88, 86, 84, 82, 81, 79, 78, 76, 74, 73, 70, 67, 64,
62, 59, 57, 55, 52, 49, 48, 45, 43, 41, 37, 36, 32, 30, 26, 23, 18, 14, 11, 5,
1, -3, -9, -13, -18, -22, -28, -33, -38, -43, -47, -53, -56, -60, -65, -67, -73,
-75, -77, -81, -83, -87, -90, -91, -94, -95, -97, -99, -99, -102, -103, -105,
-107, -109, -112, -115, -117, -119, -119, -119, -118, -119, -118, -117, -117,
-115, -115, -113, -112, -111, -110, -108, -108, -106, -107, -106, -106, -106,
-106, -107, -107, -110, -109, -110, -110, -110, -110, -110, -110, -110, -109,
-110, -110, -110, -109, -109, -108, -107, -106, -105, -105, -105, -103, -103,
-102, -101, -99, -99, -98, -96, -95, -94, -93, -91, -90, -88, -86, -85, -82,
-81, -78, -77, -75, -72, -69, -66, -64, -61, -59, -56, -53, -49, -46, -43, -40,
-37, -34, -31, -28, -25, -21, -19, -15, -13, -10, -7, -4, 0, 2, 6, 9, 13, 16,
19, 22, 25, 29, 32, 35, 39, 42, 47, 49, 52, 56, 59, 61, 63, 67, 69, 72, 73, 75,
76, 78, 80, 81, 82, 84, 84, 86, 87, 88, 89, 88, 90, 91, 91, 91, 91, 91, 92, 92,
91, 92, 90, 89, 89, 88, 86, 84, 82, 80, 79, 77, 76, 73, 72, 69, 66, 64, 61, 59,
56, 53, 51, 48, 45, 44, 41, 38, 36, 33, 31, 28, 26, 22, 19, 17, 15, 12, 9, 6, 4,
2, 0, -3, -4, -5, -7, -9, -10, -11, -12, -13, -14, -15, -15, -16, -17, -18, -19,
-18, -19, -20, -20, -20, -20, -20, -19, -19, -19, -18, -18, -17, -16, -16, -16,
-15, -14, -12, -12, -10, -9, -8, -7, -5, -4, -3, -1, 0, 2, 2, 3, 4, 5, 6, 8, 8,
9, 11, 13, 14, 14, 15, 16, 17, 18, 20, 21, 22, 22, 23, 22, 24, 24, 24, 26, 26,
26, 25, 26, 25, 25, 25, 25, 25, 24, 24, 24, 23, 23, 22, 21, 22, 22, 21, 21, 20,
21, 19, 20, 19, 19, 19, 18, 18, 17, 16, 14, 14, 13, 13, 12, 11, 10, 9, 8, 6, 6,
4, 3, 3, 2, 0, 0, -1, -2, -3, -3, -4, -4, -5, -6, -6, -6, -8, -8, -9, -9, -10,
-10, -10, -11, -11, -11, -12, -12, -12, -12, -13, -13, -12, -12, -11, -12, -12,
-10, -11, -11, -11, -11, -9, -10, -8, -8, -9, -8, -7, -6, -6, -7, -7, -6, -7,
-7, -8, -7, -7, -8, -9, -9, -9, -10, -10, -12, -12, -13, -13, -14, -15, -16,
-17, -17, -18, -19, -21, -22, -23, -23, -24, -23, -25, -25, -25, -24, -23, -23,
-22, -20, -18, -17, -15, -13, -10, -7, -3, -1, };