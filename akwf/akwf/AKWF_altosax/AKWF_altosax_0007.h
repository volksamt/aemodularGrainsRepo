#define DATA_LENGTH 512
#define DATA AKWF_altosax_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 12, 17, 21, 25, 28, 32, 34, 38,
41, 44, 47, 49, 52, 53, 55, 56, 56, 56, 58, 59, 59, 62, 65, 66, 70, 73, 76, 80,
83, 87, 90, 95, 98, 101, 105, 108, 111, 114, 117, 117, 118, 119, 120, 119, 118,
117, 117, 116, 115, 115, 114, 113, 113, 113, 113, 113, 112, 112, 111, 110, 108,
108, 107, 106, 105, 103, 102, 98, 96, 93, 90, 88, 85, 81, 79, 76, 73, 70, 67,
63, 61, 58, 56, 54, 52, 49, 46, 43, 41, 39, 37, 35, 32, 30, 28, 25, 22, 20, 18,
16, 16, 15, 14, 14, 12, 12, 10, 9, 8, 7, 5, 4, 4, 4, 5, 4, 6, 5, 5, 5, 4, 4, 3,
2, 2, 3, 3, 3, 2, 1, -1, -2, -5, -7, -9, -9, -10, -12, -13, -16, -18, -19, -22,
-23, -25, -27, -29, -30, -32, -34, -36, -37, -39, -42, -46, -49, -51, -53, -57,
-58, -61, -63, -67, -70, -71, -72, -76, -77, -80, -81, -81, -83, -85, -85, -86,
-88, -88, -90, -91, -91, -93, -94, -94, -96, -96, -96, -97, -97, -98, -98, -98,
-98, -98, -97, -96, -94, -94, -92, -91, -89, -87, -86, -82, -81, -78, -76, -74,
-73, -70, -68, -66, -64, -60, -57, -53, -50, -47, -44, -41, -37, -34, -31, -27,
-23, -19, -16, -12, -9, -5, -1, 1, 5, 8, 11, 14, 16, 19, 21, 24, 28, 31, 33, 37,
40, 42, 46, 49, 50, 53, 55, 58, 60, 63, 64, 65, 66, 67, 68, 68, 70, 71, 73, 73,
73, 74, 74, 74, 74, 73, 72, 72, 72, 71, 70, 69, 67, 67, 65, 63, 61, 60, 59, 58,
57, 55, 54, 53, 50, 49, 47, 46, 43, 43, 42, 40, 38, 35, 33, 30, 28, 26, 23, 21,
20, 17, 14, 12, 9, 7, 5, 2, 0, -2, -4, -5, -6, -9, -10, -12, -14, -15, -16, -18,
-18, -18, -20, -21, -22, -23, -24, -24, -26, -26, -26, -25, -25, -24, -23, -24,
-24, -25, -24, -24, -25, -23, -21, -21, -20, -20, -19, -20, -20, -20, -19, -18,
-17, -16, -16, -16, -14, -14, -14, -13, -14, -14, -14, -13, -13, -13, -13, -13,
-13, -14, -14, -14, -15, -15, -15, -16, -15, -17, -17, -18, -19, -20, -21, -23,
-23, -24, -24, -25, -27, -28, -28, -29, -30, -30, -31, -32, -32, -33, -35, -36,
-36, -36, -37, -38, -39, -39, -41, -41, -42, -43, -43, -44, -45, -45, -44, -45,
-45, -46, -46, -47, -47, -48, -48, -48, -49, -48, -48, -48, -49, -48, -49, -49,
-49, -48, -47, -48, -48, -47, -47, -46, -47, -46, -45, -44, -44, -43, -42, -42,
-42, -40, -40, -39, -38, -37, -38, -37, -37, -36, -35, -35, -35, -33, -34, -34,
-33, -33, -32, -31, -32, -30, -30, -30, -30, -30, -30, -30, -29, -29, -28, -29,
-28, -29, -30, -29, -29, -29, -29, -29, -28, -27, -27, -27, -27, -26, -25, -25,
-23, -23, -21, -19, -17, -16, -14, -11, -8, -5, -1, };