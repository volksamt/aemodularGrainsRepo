#define DATA_LENGTH 512
#define DATA AKWF_altosax_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 4, 4, 5, 6, 7, 7, 10, 11, 12,
12, 14, 14, 16, 18, 19, 20, 21, 22, 23, 25, 26, 27, 28, 29, 31, 32, 33, 34, 35,
35, 37, 38, 39, 39, 40, 43, 42, 43, 45, 46, 47, 48, 49, 50, 51, 53, 53, 54, 55,
56, 58, 59, 59, 59, 61, 62, 62, 64, 64, 66, 66, 68, 68, 69, 69, 70, 71, 72, 73,
73, 74, 77, 76, 78, 79, 80, 81, 81, 82, 83, 84, 85, 85, 86, 86, 88, 89, 90, 91,
91, 92, 93, 94, 95, 96, 97, 98, 100, 100, 101, 102, 103, 104, 105, 106, 106,
108, 109, 109, 110, 111, 112, 114, 114, 115, 115, 115, 116, 116, 117, 117, 118,
118, 119, 119, 119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 118, 118, 117,
117, 116, 115, 115, 113, 112, 111, 111, 109, 107, 106, 104, 103, 101, 100, 98,
96, 95, 93, 92, 90, 88, 86, 84, 83, 80, 79, 77, 75, 73, 72, 70, 68, 66, 65, 63,
62, 60, 58, 57, 56, 53, 52, 50, 49, 47, 47, 45, 44, 42, 42, 41, 41, 38, 38, 38,
36, 36, 35, 35, 34, 34, 32, 32, 32, 30, 30, 30, 29, 28, 28, 28, 27, 25, 24, 23,
23, 21, 20, 18, 18, 16, 15, 14, 11, 10, 9, 7, 5, 5, 2, 1, -1, -2, -3, -5, -6,
-8, -9, -10, -12, -13, -14, -15, -16, -18, -20, -20, -22, -24, -24, -26, -26,
-28, -30, -30, -32, -34, -34, -36, -37, -39, -39, -41, -41, -42, -43, -44, -45,
-46, -48, -48, -50, -51, -51, -52, -53, -53, -55, -55, -55, -57, -57, -58, -59,
-60, -61, -61, -62, -63, -64, -65, -66, -67, -68, -69, -70, -71, -71, -72, -73,
-75, -75, -75, -76, -76, -77, -78, -80, -79, -80, -81, -82, -82, -83, -83, -83,
-84, -85, -85, -85, -85, -87, -86, -88, -88, -88, -88, -89, -89, -89, -90, -90,
-90, -90, -91, -91, -91, -92, -92, -91, -92, -93, -93, -93, -93, -92, -94, -93,
-93, -93, -92, -92, -92, -92, -92, -92, -92, -92, -92, -92, -91, -91, -91, -91,
-90, -89, -89, -89, -88, -89, -87, -87, -87, -86, -85, -85, -84, -83, -83, -82,
-82, -81, -79, -79, -78, -77, -75, -76, -75, -75, -73, -73, -72, -70, -70, -69,
-68, -67, -65, -64, -64, -63, -62, -61, -59, -59, -59, -58, -56, -56, -55, -54,
-53, -52, -50, -51, -49, -48, -48, -47, -46, -45, -45, -43, -43, -44, -43, -42,
-42, -42, -41, -40, -40, -39, -39, -39, -39, -38, -38, -38, -37, -37, -37, -36,
-35, -36, -36, -35, -35, -34, -35, -35, -33, -34, -33, -33, -34, -32, -32, -32,
-32, -33, -33, -33, -33, -33, -33, -32, -31, -31, -31, -31, -31, -30, -29, -28,
-28, -28, -27, -27, -26, -26, -24, -24, -24, -22, -22, -21, -20, -19, -19, -19,
-17, -16, -16, -15, -15, -13, -11, -11, -10, -9, -8, -7, -5, -4, -3, -3, -2, 0,
};