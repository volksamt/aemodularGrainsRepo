#define DATA_LENGTH 512
#define DATA AKWF_altosax_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 8, 9, 10, 12, 14, 16, 17,
19, 21, 22, 23, 25, 26, 28, 30, 32, 34, 35, 37, 39, 41, 42, 43, 46, 48, 50, 51,
54, 55, 58, 59, 61, 63, 65, 66, 67, 69, 71, 72, 75, 76, 78, 81, 82, 83, 84, 85,
88, 88, 89, 90, 92, 94, 95, 97, 98, 99, 99, 101, 102, 104, 105, 105, 107, 108,
110, 111, 111, 113, 112, 113, 114, 115, 115, 116, 116, 118, 117, 117, 118, 118,
119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 118, 118, 116, 117, 117,
116, 115, 115, 115, 114, 113, 113, 112, 111, 111, 109, 109, 108, 107, 105, 105,
105, 104, 102, 101, 100, 98, 97, 97, 95, 94, 93, 91, 89, 88, 87, 85, 83, 82, 80,
79, 77, 75, 74, 71, 70, 68, 66, 65, 63, 62, 61, 58, 57, 55, 54, 52, 49, 48, 47,
44, 42, 41, 39, 38, 36, 33, 32, 30, 28, 26, 24, 22, 21, 19, 18, 16, 14, 12, 9,
9, 7, 5, 3, 1, -1, -3, -4, -6, -8, -9, -11, -13, -14, -16, -17, -20, -21, -23,
-24, -26, -28, -29, -31, -33, -34, -35, -37, -38, -40, -41, -42, -44, -44, -46,
-48, -49, -49, -51, -52, -53, -55, -55, -57, -58, -59, -59, -61, -61, -62, -63,
-64, -64, -65, -65, -67, -66, -67, -68, -69, -69, -70, -71, -71, -71, -72, -71,
-72, -72, -72, -73, -73, -73, -73, -73, -73, -73, -73, -73, -72, -73, -72, -73,
-72, -72, -72, -71, -71, -71, -71, -71, -70, -69, -69, -69, -68, -69, -68, -67,
-66, -66, -65, -65, -63, -63, -62, -60, -61, -60, -58, -58, -58, -56, -55, -55,
-54, -52, -52, -50, -50, -49, -49, -48, -47, -46, -46, -45, -44, -42, -43, -41,
-40, -39, -38, -37, -36, -36, -35, -34, -33, -33, -32, -31, -31, -30, -29, -28,
-27, -27, -26, -26, -24, -24, -23, -23, -22, -21, -21, -21, -20, -19, -19, -19,
-17, -18, -18, -17, -17, -18, -16, -17, -16, -16, -15, -16, -15, -15, -14, -15,
-14, -15, -13, -14, -14, -14, -14, -15, -14, -14, -14, -15, -15, -14, -15, -16,
-16, -16, -17, -17, -17, -17, -18, -19, -20, -19, -20, -21, -21, -21, -22, -23,
-24, -25, -25, -24, -26, -26, -27, -27, -27, -29, -29, -29, -30, -30, -30, -31,
-32, -33, -33, -34, -34, -35, -36, -36, -36, -38, -38, -38, -39, -40, -39, -40,
-41, -41, -42, -42, -42, -43, -44, -45, -45, -45, -46, -46, -47, -47, -47, -48,
-47, -48, -49, -48, -49, -48, -49, -50, -50, -50, -50, -51, -51, -51, -51, -51,
-50, -51, -51, -51, -50, -50, -50, -49, -49, -49, -48, -49, -48, -48, -47, -47,
-46, -46, -46, -44, -44, -44, -43, -43, -42, -42, -41, -41, -40, -39, -38, -38,
-38, -38, -37, -36, -34, -34, -34, -32, -32, -30, -29, -27, -26, -24, -23, -22,
-20, -18, -17, -16, -13, -11, -10, -9, -7, -5, -4, -2, 0, };