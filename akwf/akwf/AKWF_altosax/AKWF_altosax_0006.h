#define DATA_LENGTH 512
#define DATA AKWF_altosax_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 10, 14, 17, 21, 26, 28, 33, 38,
41, 46, 51, 55, 60, 65, 69, 73, 78, 83, 88, 93, 98, 102, 106, 108, 112, 114,
116, 118, 119, 120, 119, 119, 119, 118, 118, 118, 116, 114, 113, 112, 110, 108,
107, 105, 104, 101, 99, 97, 95, 92, 88, 84, 81, 78, 73, 69, 64, 60, 54, 50, 46,
42, 37, 31, 26, 21, 17, 12, 10, 6, 4, 2, 0, -1, -2, -3, -4, -4, -5, -6, -6, -6,
-7, -6, -7, -6, -5, -4, -4, -2, -1, 0, 1, 3, 4, 6, 7, 10, 11, 14, 15, 17, 18,
19, 20, 22, 23, 23, 25, 25, 26, 26, 25, 26, 25, 25, 24, 23, 22, 21, 20, 19, 17,
16, 14, 11, 10, 7, 5, 3, 0, -3, -7, -9, -12, -15, -17, -21, -24, -28, -30, -35,
-37, -40, -44, -48, -51, -54, -56, -58, -61, -64, -66, -69, -72, -74, -74, -76,
-78, -79, -80, -81, -82, -83, -84, -83, -82, -82, -80, -80, -78, -77, -75, -73,
-71, -68, -67, -65, -63, -61, -59, -58, -54, -50, -47, -45, -43, -39, -36, -34,
-32, -29, -26, -23, -19, -17, -13, -10, -7, -3, 0, 4, 6, 9, 12, 15, 19, 22, 24,
27, 28, 30, 32, 34, 35, 39, 40, 40, 42, 45, 46, 47, 48, 50, 52, 53, 54, 55, 56,
56, 57, 58, 60, 61, 61, 61, 62, 61, 62, 61, 61, 61, 61, 60, 59, 58, 58, 58, 57,
56, 56, 54, 52, 51, 50, 49, 48, 47, 45, 42, 40, 39, 37, 35, 33, 31, 28, 26, 24,
22, 20, 18, 18, 16, 14, 12, 9, 7, 6, 4, 2, 0, 0, -2, -4, -6, -8, -9, -12, -13,
-15, -17, -18, -20, -21, -23, -24, -25, -26, -27, -27, -27, -28, -30, -31, -31,
-33, -32, -33, -34, -34, -35, -35, -36, -35, -36, -37, -38, -38, -39, -38, -38,
-38, -39, -39, -40, -39, -39, -40, -40, -40, -41, -41, -42, -42, -42, -42, -43,
-43, -43, -43, -44, -44, -45, -46, -46, -45, -46, -46, -45, -45, -45, -46, -45,
-45, -46, -45, -45, -45, -44, -42, -42, -42, -41, -41, -40, -39, -39, -37, -38,
-36, -36, -34, -33, -32, -31, -30, -28, -27, -25, -23, -23, -21, -20, -18, -16,
-15, -13, -11, -10, -8, -8, -7, -5, -4, -3, -1, 0, 1, 3, 3, 5, 5, 6, 6, 8, 8, 9,
9, 9, 10, 9, 10, 9, 9, 9, 9, 8, 7, 8, 7, 6, 5, 5, 4, 4, 2, 2, 1, 1, -1, -2, -3,
-4, -4, -7, -7, -8, -9, -10, -11, -12, -13, -14, -14, -16, -15, -17, -17, -18,
-19, -20, -22, -22, -23, -24, -25, -26, -27, -27, -28, -29, -30, -31, -30, -31,
-32, -33, -35, -36, -36, -38, -37, -38, -39, -39, -41, -41, -42, -43, -44, -43,
-43, -43, -44, -43, -44, -43, -42, -42, -42, -42, -41, -40, -40, -38, -37, -36,
-34, -31, -28, -26, -24, -22, -18, -16, -12, -8, -4, -1, };