#define DATA_LENGTH 512
#define DATA AKWF_altosax_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 6, 7, 9, 11, 13, 15, 18, 20, 22,
25, 26, 29, 31, 32, 35, 36, 39, 41, 43, 46, 47, 49, 51, 53, 55, 57, 59, 61, 63,
64, 65, 68, 69, 71, 74, 75, 76, 78, 78, 80, 82, 84, 85, 87, 88, 90, 91, 93, 94,
95, 96, 97, 98, 100, 101, 102, 102, 104, 105, 105, 107, 107, 108, 108, 109, 109,
110, 110, 111, 111, 112, 112, 113, 114, 113, 114, 114, 114, 115, 115, 115, 115,
116, 115, 116, 115, 116, 116, 117, 116, 117, 117, 116, 117, 117, 117, 116, 117,
117, 117, 117, 117, 117, 117, 118, 118, 118, 118, 119, 119, 118, 118, 118, 118,
119, 118, 119, 119, 118, 118, 119, 119, 118, 119, 118, 118, 118, 118, 116, 115,
115, 115, 115, 115, 115, 114, 113, 112, 111, 111, 110, 108, 109, 107, 105, 105,
103, 102, 101, 99, 97, 96, 95, 93, 91, 90, 88, 87, 84, 82, 80, 79, 77, 74, 72,
71, 68, 67, 63, 62, 60, 57, 56, 54, 52, 50, 47, 45, 44, 41, 40, 37, 35, 33, 32,
30, 28, 26, 26, 24, 23, 22, 20, 20, 19, 18, 18, 17, 17, 17, 16, 15, 15, 15, 15,
15, 15, 15, 14, 15, 15, 15, 16, 16, 16, 17, 17, 18, 17, 18, 17, 18, 17, 17, 17,
16, 15, 15, 14, 13, 12, 11, 10, 8, 7, 6, 4, 3, 0, -2, -3, -6, -7, -9, -10, -13,
-14, -16, -17, -19, -21, -23, -26, -28, -29, -31, -34, -35, -35, -38, -39, -41,
-42, -44, -46, -47, -49, -51, -52, -54, -55, -58, -59, -61, -62, -64, -65, -67,
-68, -70, -70, -72, -73, -75, -76, -77, -78, -80, -80, -82, -83, -84, -85, -87,
-88, -89, -89, -90, -92, -93, -93, -94, -96, -96, -98, -98, -99, -100, -101,
-102, -102, -103, -104, -105, -105, -106, -108, -108, -108, -110, -110, -111,
-112, -113, -113, -114, -114, -114, -115, -116, -115, -116, -117, -116, -116,
-116, -117, -117, -116, -116, -117, -116, -116, -116, -116, -116, -117, -116,
-115, -114, -114, -113, -113, -112, -110, -109, -109, -108, -106, -106, -105,
-104, -104, -103, -101, -99, -98, -98, -96, -96, -94, -93, -91, -90, -89, -88,
-86, -85, -85, -83, -82, -81, -81, -79, -79, -79, -78, -77, -76, -76, -74, -74,
-73, -72, -71, -71, -70, -69, -67, -67, -66, -65, -65, -64, -63, -63, -62, -61,
-60, -59, -59, -59, -58, -57, -56, -56, -55, -54, -53, -53, -52, -51, -51, -51,
-51, -51, -50, -49, -49, -48, -47, -47, -46, -45, -44, -44, -43, -42, -42, -41,
-41, -40, -40, -40, -39, -39, -38, -38, -37, -36, -36, -35, -35, -35, -35, -34,
-35, -34, -34, -33, -33, -33, -33, -33, -32, -32, -32, -32, -32, -32, -33, -32,
-32, -31, -31, -31, -30, -30, -30, -29, -29, -28, -29, -28, -27, -27, -27, -25,
-26, -24, -24, -24, -22, -21, -20, -19, -19, -18, -17, -16, -15, -13, -11, -11,
-10, -7, -5, -4, -3, 0, };