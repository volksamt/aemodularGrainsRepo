#define DATA_LENGTH 512
#define DATA AKWF_altosax_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 8, 10, 12, 15, 17, 19, 21,
24, 26, 28, 31, 33, 36, 38, 41, 43, 46, 50, 51, 55, 58, 61, 64, 68, 70, 73, 77,
79, 83, 86, 88, 91, 94, 97, 100, 102, 103, 106, 107, 109, 110, 112, 114, 115,
116, 116, 118, 118, 119, 119, 118, 119, 119, 118, 118, 117, 116, 115, 115, 114,
113, 111, 109, 107, 106, 103, 102, 100, 98, 96, 94, 92, 91, 90, 88, 86, 85, 84,
83, 82, 81, 81, 80, 80, 79, 79, 78, 78, 78, 78, 78, 78, 78, 78, 79, 78, 78, 80,
79, 80, 80, 80, 82, 83, 84, 86, 86, 88, 89, 92, 93, 94, 95, 96, 97, 98, 98, 99,
99, 100, 99, 99, 98, 97, 97, 95, 94, 93, 91, 90, 89, 87, 86, 84, 83, 80, 79, 77,
76, 74, 74, 73, 71, 70, 68, 68, 66, 66, 64, 63, 63, 62, 61, 61, 61, 61, 59, 58,
58, 58, 56, 57, 57, 56, 56, 55, 55, 55, 55, 55, 55, 54, 54, 53, 53, 53, 51, 51,
51, 49, 48, 46, 46, 44, 42, 41, 39, 38, 36, 35, 32, 32, 30, 28, 26, 24, 21, 19,
17, 15, 13, 10, 8, 5, 4, 1, -1, -4, -6, -8, -9, -11, -14, -15, -18, -19, -21,
-22, -25, -26, -27, -29, -31, -32, -34, -35, -37, -38, -40, -40, -42, -43, -44,
-46, -46, -47, -48, -47, -47, -48, -49, -48, -48, -48, -48, -48, -49, -48, -47,
-47, -47, -47, -46, -47, -47, -46, -47, -46, -47, -46, -47, -48, -46, -47, -48,
-48, -47, -48, -49, -49, -49, -49, -50, -49, -49, -50, -50, -50, -50, -51, -51,
-51, -53, -53, -53, -55, -55, -55, -56, -56, -57, -58, -60, -60, -59, -61, -61,
-61, -63, -63, -63, -64, -64, -65, -65, -66, -66, -66, -67, -67, -68, -68, -67,
-69, -68, -68, -69, -70, -70, -70, -70, -70, -70, -70, -70, -71, -72, -70, -71,
-71, -71, -72, -72, -72, -73, -71, -73, -73, -72, -73, -73, -72, -73, -72, -72,
-72, -72, -72, -71, -72, -72, -72, -71, -71, -71, -71, -72, -72, -71, -72, -71,
-72, -72, -72, -72, -71, -72, -72, -72, -72, -71, -70, -70, -70, -69, -68, -68,
-66, -66, -65, -64, -63, -62, -61, -61, -60, -59, -59, -58, -57, -57, -56, -56,
-55, -54, -55, -54, -53, -53, -53, -51, -50, -50, -50, -49, -47, -47, -47, -46,
-45, -45, -44, -43, -43, -42, -42, -41, -41, -41, -41, -40, -39, -39, -39, -38,
-38, -38, -38, -38, -37, -38, -38, -37, -38, -39, -37, -37, -37, -38, -37, -38,
-38, -38, -39, -39, -40, -39, -39, -39, -40, -40, -40, -41, -41, -41, -41, -42,
-43, -43, -44, -43, -43, -43, -43, -43, -43, -44, -43, -43, -42, -44, -42, -42,
-43, -42, -42, -41, -41, -39, -39, -39, -38, -37, -37, -35, -34, -32, -32, -31,
-29, -29, -28, -27, -25, -25, -24, -23, -22, -20, -18, -17, -15, -12, -11, -9,
-7, -5, -3, 0, };