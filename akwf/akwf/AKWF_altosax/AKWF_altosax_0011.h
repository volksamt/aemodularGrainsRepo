#define DATA_LENGTH 512
#define DATA AKWF_altosax_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 5, 7, 8, 11, 14, 16, 19, 20, 23,
25, 27, 31, 33, 35, 38, 40, 43, 46, 50, 52, 55, 57, 59, 62, 63, 66, 68, 72, 74,
78, 80, 83, 85, 88, 89, 91, 94, 95, 97, 99, 101, 101, 103, 105, 106, 106, 108,
108, 108, 109, 111, 112, 112, 113, 112, 114, 114, 114, 114, 115, 116, 116, 116,
117, 117, 118, 119, 119, 119, 119, 118, 117, 116, 116, 115, 114, 112, 112, 112,
111, 110, 109, 107, 106, 105, 104, 103, 101, 99, 97, 95, 93, 93, 91, 90, 89, 87,
85, 84, 81, 80, 78, 75, 74, 71, 68, 65, 65, 61, 59, 57, 54, 51, 48, 46, 43, 39,
37, 34, 31, 28, 24, 22, 20, 16, 15, 12, 10, 9, 6, 4, 2, 0, -2, -3, -6, -8, -10,
-12, -15, -16, -17, -20, -20, -21, -24, -25, -27, -28, -30, -34, -36, -37, -39,
-39, -42, -44, -44, -45, -47, -48, -50, -52, -53, -56, -56, -57, -58, -57, -57,
-57, -57, -58, -57, -59, -59, -59, -60, -62, -61, -61, -60, -61, -61, -60, -60,
-60, -60, -60, -60, -59, -58, -57, -56, -55, -54, -53, -51, -50, -49, -48, -47,
-45, -45, -43, -41, -40, -38, -37, -35, -34, -33, -32, -31, -30, -29, -28, -27,
-25, -23, -23, -22, -20, -19, -19, -18, -17, -15, -14, -13, -12, -10, -10, -8,
-7, -6, -5, -4, -3, -2, -2, -1, 1, 2, 2, 3, 4, 5, 5, 7, 6, 7, 7, 8, 7, 8, 9, 9,
9, 9, 9, 8, 8, 8, 9, 9, 8, 8, 9, 8, 9, 8, 8, 7, 7, 6, 6, 5, 5, 5, 6, 4, 4, 4, 4,
2, 2, 1, 0, -1, -3, -3, -5, -5, -6, -7, -8, -8, -9, -9, -11, -12, -12, -13, -15,
-15, -16, -16, -18, -19, -19, -19, -21, -22, -23, -24, -25, -27, -27, -27, -29,
-29, -30, -30, -32, -32, -32, -33, -34, -35, -36, -36, -37, -37, -37, -37, -38,
-37, -38, -38, -39, -39, -39, -40, -41, -40, -40, -40, -40, -41, -41, -42, -41,
-41, -42, -40, -40, -40, -40, -40, -40, -40, -40, -40, -40, -39, -39, -38, -38,
-37, -36, -35, -36, -35, -36, -35, -34, -33, -33, -33, -33, -32, -32, -31, -31,
-30, -29, -29, -28, -29, -28, -27, -27, -27, -25, -25, -26, -25, -25, -24, -23,
-23, -24, -23, -23, -23, -23, -22, -22, -22, -22, -22, -22, -22, -21, -21, -21,
-21, -21, -22, -22, -22, -22, -22, -23, -23, -24, -23, -24, -25, -25, -25, -27,
-26, -26, -27, -27, -28, -28, -28, -28, -29, -29, -30, -29, -30, -30, -30, -31,
-31, -32, -33, -33, -33, -33, -34, -33, -35, -35, -35, -35, -36, -36, -36, -37,
-37, -36, -37, -38, -37, -36, -37, -36, -37, -36, -36, -36, -36, -35, -34, -35,
-34, -34, -33, -33, -32, -32, -31, -30, -29, -29, -27, -27, -25, -24, -23, -22,
-19, -18, -17, -17, -15, -14, -11, -10, -7, -6, -5, -2, -1, };