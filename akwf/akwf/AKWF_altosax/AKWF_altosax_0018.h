#define DATA_LENGTH 512
#define DATA AKWF_altosax_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 25, 38, 53, 65, 81, 93, 102, 110,
115, 118, 119, 117, 115, 116, 111, 106, 103, 100, 99, 99, 98, 96, 96, 94, 91,
87, 81, 77, 68, 63, 59, 54, 47, 42, 35, 30, 24, 19, 13, 7, 0, -4, -5, -3, -1, 2,
10, 15, 20, 27, 32, 37, 40, 43, 43, 41, 39, 35, 30, 24, 17, 13, 6, 2, -3, -11,
-20, -31, -39, -48, -60, -68, -72, -76, -81, -83, -82, -74, -63, -45, -28, -18,
-14, -18, -22, -30, -37, -42, -46, -51, -57, -59, -60, -60, -62, -63, -67, -71,
-70, -70, -75, -80, -84, -88, -89, -86, -82, -84, -85, -81, -78, -76, -73, -68,
-66, -61, -59, -60, -59, -60, -59, -55, -47, -37, -27, -18, -2, 14, 28, 41, 55,
68, 83, 93, 101, 107, 110, 112, 113, 114, 113, 112, 110, 107, 106, 104, 105,
106, 104, 102, 99, 97, 92, 86, 80, 72, 65, 60, 57, 51, 45, 41, 37, 34, 30, 22,
15, 7, 0, -3, -4, -3, -1, 5, 12, 17, 21, 28, 33, 37, 41, 44, 44, 41, 38, 33, 26,
19, 13, 9, 4, 0, -4, -11, -20, -28, -37, -49, -59, -69, -77, -81, -82, -82, -77,
-68, -53, -36, -20, -12, -12, -18, -25, -35, -42, -45, -50, -55, -59, -61, -61,
-62, -61, -63, -67, -71, -72, -73, -78, -83, -88, -93, -92, -88, -84, -82, -81,
-79, -76, -75, -71, -69, -67, -65, -64, -64, -63, -60, -58, -51, -45, -35, -23,
-12, 1, 16, 28, 42, 55, 67, 81, 92, 100, 106, 110, 113, 114, 111, 110, 109, 106,
104, 102, 101, 102, 104, 105, 105, 105, 103, 99, 95, 88, 80, 72, 63, 57, 48, 43,
38, 31, 23, 19, 17, 12, 5, -2, -6, -5, -3, 0, 5, 13, 16, 22, 31, 37, 40, 44, 47,
46, 44, 40, 34, 26, 19, 13, 8, 4, -1, -6, -12, -21, -31, -41, -51, -63, -70,
-74, -77, -79, -81, -77, -68, -55, -37, -21, -12, -10, -14, -23, -32, -40, -44,
-49, -55, -60, -64, -62, -63, -63, -65, -68, -71, -71, -71, -75, -80, -86, -90,
-92, -88, -84, -83, -81, -78, -76, -75, -72, -68, -67, -65, -63, -64, -62, -60,
-58, -53, -49, -39, -28, -18, -3, 14, 28, 43, 56, 70, 83, 93, 102, 109, 110,
111, 114, 113, 112, 110, 108, 105, 102, 101, 102, 103, 102, 100, 99, 99, 97, 92,
86, 79, 69, 64, 57, 51, 45, 39, 32, 27, 23, 19, 11, 4, -2, -5, -6, -4, -3, 3,
11, 15, 21, 28, 33, 38, 44, 47, 47, 44, 41, 36, 29, 21, 16, 11, 5, 1, -3, -11,
-19, -29, -39, -51, -61, -71, -78, -82, -84, -84, -80, -69, -55, -37, -22, -12,
-11, -17, -25, -33, -40, -44, -48, -53, -58, -61, -61, -61, -61, -64, -68, -71,
-72, -73, -76, -81, -88, -90, -89, -85, -81, -80, -79, -78, -76, -74, -73, -70,
-68, -64, -62, -62, -62, -60, -58, -53, -47, -38, -27, -18, -3, };