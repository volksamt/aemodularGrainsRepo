#define DATA_LENGTH 512
#define DATA AKWF_altosax_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 10, 13, 18, 21, 23, 27, 31, 35,
40, 46, 53, 61, 67, 74, 79, 84, 87, 91, 95, 98, 100, 101, 103, 105, 104, 104,
105, 106, 107, 109, 111, 113, 114, 117, 118, 118, 119, 119, 119, 119, 118, 117,
116, 115, 114, 112, 111, 110, 108, 106, 104, 102, 100, 98, 96, 94, 91, 89, 87,
85, 81, 78, 74, 70, 65, 62, 59, 56, 52, 48, 45, 41, 38, 34, 32, 30, 27, 24, 23,
20, 19, 16, 14, 13, 11, 9, 8, 8, 7, 8, 8, 9, 9, 10, 10, 10, 10, 10, 10, 11, 11,
12, 12, 13, 13, 14, 15, 15, 17, 18, 20, 22, 23, 24, 24, 24, 25, 24, 25, 24, 24,
24, 24, 23, 22, 21, 20, 20, 19, 18, 17, 16, 15, 13, 13, 12, 11, 9, 8, 6, 3, 2,
-1, -4, -7, -10, -12, -15, -16, -19, -21, -22, -24, -26, -27, -29, -31, -33,
-36, -36, -38, -41, -43, -45, -47, -48, -50, -53, -54, -57, -58, -59, -62, -62,
-63, -64, -64, -65, -67, -67, -68, -68, -69, -70, -70, -71, -71, -71, -72, -72,
-71, -71, -70, -70, -69, -67, -66, -65, -63, -62, -60, -59, -58, -57, -54, -53,
-51, -48, -45, -43, -40, -39, -36, -33, -30, -27, -26, -23, -21, -17, -14, -11,
-10, -7, -5, -2, 0, 4, 7, 9, 11, 14, 16, 18, 20, 23, 24, 26, 29, 31, 33, 36, 36,
38, 39, 41, 41, 43, 44, 45, 47, 46, 47, 48, 49, 49, 50, 50, 51, 52, 51, 53, 52,
52, 51, 50, 48, 47, 45, 44, 43, 42, 41, 40, 37, 36, 34, 34, 33, 31, 30, 29, 27,
26, 24, 22, 19, 18, 16, 14, 12, 9, 7, 5, 3, 0, -2, -2, -5, -7, -7, -9, -9, -11,
-10, -12, -14, -14, -16, -17, -18, -20, -22, -23, -24, -25, -26, -26, -26, -28,
-29, -29, -30, -30, -30, -29, -30, -30, -31, -31, -32, -33, -33, -32, -33, -34,
-33, -34, -32, -33, -33, -33, -33, -33, -34, -35, -35, -34, -35, -35, -34, -35,
-36, -36, -36, -35, -36, -36, -34, -35, -35, -36, -34, -35, -35, -35, -36, -35,
-35, -35, -35, -35, -34, -35, -35, -36, -36, -36, -36, -35, -34, -34, -34, -35,
-33, -34, -34, -34, -32, -32, -32, -30, -30, -29, -30, -29, -28, -28, -26, -26,
-25, -24, -23, -22, -21, -21, -19, -18, -17, -15, -14, -14, -12, -10, -10, -10,
-7, -7, -5, -4, -3, -3, -1, -1, -1, 0, -1, 0, 1, 0, -1, 0, 0, 0, -1, -1, -2, -2,
-3, -3, -4, -5, -6, -6, -8, -9, -10, -10, -12, -12, -13, -14, -14, -15, -16,
-17, -17, -18, -20, -21, -21, -22, -23, -24, -25, -27, -29, -30, -32, -33, -34,
-36, -37, -40, -41, -44, -46, -47, -50, -52, -53, -55, -57, -57, -59, -61, -62,
-63, -64, -64, -65, -64, -64, -63, -61, -60, -58, -57, -55, -51, -47, -43, -38,
-34, -29, -23, -18, -13, -8, -2, };