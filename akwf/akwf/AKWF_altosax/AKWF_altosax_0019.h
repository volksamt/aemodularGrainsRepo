#define DATA_LENGTH 512
#define DATA AKWF_altosax_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 7, 8, 11, 12, 14, 16, 19, 21,
25, 27, 29, 33, 36, 38, 41, 44, 47, 48, 52, 55, 57, 60, 62, 64, 66, 67, 68, 69,
69, 70, 71, 71, 72, 74, 75, 76, 77, 77, 77, 76, 77, 78, 79, 80, 81, 80, 81, 82,
83, 84, 85, 86, 86, 87, 88, 89, 91, 93, 94, 96, 97, 99, 102, 103, 105, 107, 108,
109, 110, 112, 114, 114, 114, 114, 113, 114, 114, 113, 113, 111, 110, 107, 106,
104, 103, 101, 100, 99, 98, 98, 98, 97, 95, 95, 92, 91, 90, 89, 88, 86, 85, 83,
82, 81, 79, 78, 76, 75, 72, 71, 68, 68, 66, 65, 64, 63, 63, 63, 62, 61, 61, 61,
61, 60, 58, 57, 57, 56, 55, 56, 55, 55, 53, 52, 51, 50, 50, 49, 48, 48, 48, 47,
47, 47, 46, 45, 45, 45, 45, 45, 46, 47, 47, 48, 49, 49, 50, 50, 49, 50, 50, 50,
50, 49, 48, 47, 45, 45, 44, 42, 40, 38, 36, 33, 31, 28, 27, 25, 23, 21, 20, 19,
16, 15, 12, 9, 7, 6, 5, 3, 2, 1, -1, -2, -3, -3, -4, -3, -2, -2, -2, -2, -1, 0,
1, 3, 3, 6, 7, 8, 10, 12, 13, 13, 15, 16, 17, 18, 19, 19, 20, 20, 19, 18, 17,
16, 16, 16, 16, 17, 17, 17, 18, 19, 20, 20, 20, 22, 22, 22, 22, 22, 21, 22, 23,
23, 23, 24, 23, 22, 22, 21, 20, 19, 17, 15, 14, 13, 11, 9, 7, 6, 4, 2, 1, -1,
-4, -4, -7, -8, -10, -11, -12, -15, -15, -16, -17, -19, -19, -21, -22, -23, -22,
-23, -24, -24, -24, -24, -25, -25, -26, -27, -27, -28, -28, -29, -30, -31, -32,
-31, -31, -32, -31, -30, -29, -29, -29, -31, -33, -34, -35, -36, -37, -36, -37,
-36, -38, -38, -39, -42, -44, -48, -52, -54, -57, -60, -62, -65, -69, -71, -73,
-76, -77, -80, -81, -82, -84, -85, -84, -84, -83, -83, -81, -81, -79, -76, -73,
-70, -67, -62, -58, -54, -49, -44, -38, -33, -28, -21, -16, -11, -7, -5, -3, 0,
1, 2, 4, 3, 3, 1, -1, -3, -5, -8, -11, -14, -16, -21, -24, -26, -30, -34, -36,
-40, -43, -44, -47, -49, -52, -55, -58, -60, -63, -67, -70, -72, -76, -79, -81,
-84, -87, -89, -91, -93, -94, -96, -97, -96, -97, -98, -98, -99, -99, -99, -101,
-100, -101, -102, -103, -103, -104, -104, -105, -105, -106, -105, -107, -108,
-109, -110, -111, -112, -114, -114, -114, -116, -116, -117, -117, -119, -119,
-118, -118, -117, -115, -114, -110, -109, -107, -105, -103, -101, -99, -98, -97,
-94, -93, -91, -89, -86, -84, -81, -77, -74, -72, -69, -67, -64, -61, -57, -54,
-50, -48, -45, -41, -40, -38, -37, -36, -35, -33, -32, -31, -31, -29, -29, -28,
-28, -29, -29, -28, -26, -26, -24, -23, -23, -22, -20, -17, -16, -14, -12, -11,
-8, -7, -5, -4, -2, -1, };