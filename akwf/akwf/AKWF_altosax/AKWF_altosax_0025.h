#define DATA_LENGTH 512
#define DATA AKWF_altosax_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 1, 3, 3, 2, 2, 1, 2, 1, 2, 3, 3,
3, 5, 5, 5, 7, 8, 9, 12, 13, 16, 17, 21, 22, 25, 27, 29, 31, 33, 35, 37, 39, 42,
45, 48, 51, 54, 57, 59, 61, 62, 63, 64, 63, 64, 63, 63, 62, 61, 59, 58, 57, 55,
54, 52, 50, 48, 46, 46, 44, 43, 42, 40, 40, 38, 39, 38, 37, 37, 38, 39, 39, 41,
41, 43, 46, 49, 52, 55, 59, 61, 65, 69, 72, 75, 78, 82, 85, 88, 92, 94, 97, 101,
103, 106, 108, 109, 111, 111, 111, 112, 113, 112, 112, 113, 113, 113, 113, 112,
112, 112, 110, 108, 107, 105, 104, 102, 99, 97, 96, 94, 93, 91, 89, 88, 88, 86,
86, 85, 85, 84, 84, 83, 82, 82, 81, 79, 79, 78, 76, 75, 75, 75, 73, 73, 71, 70,
68, 67, 64, 62, 61, 60, 58, 57, 56, 55, 53, 52, 51, 50, 49, 49, 48, 48, 48, 49,
49, 49, 51, 53, 53, 54, 55, 56, 57, 59, 60, 61, 61, 64, 65, 65, 66, 68, 68, 67,
68, 68, 68, 66, 66, 64, 63, 61, 59, 56, 55, 52, 50, 47, 44, 42, 39, 36, 34, 31,
28, 25, 23, 20, 18, 15, 13, 12, 9, 7, 5, 3, 1, -1, -3, -4, -6, -7, -7, -8, -10,
-10, -11, -11, -12, -12, -12, -12, -12, -12, -12, -13, -12, -11, -11, -11, -10,
-11, -12, -12, -14, -14, -16, -17, -16, -17, -17, -17, -18, -17, -17, -18, -17,
-18, -17, -17, -16, -15, -15, -14, -13, -13, -12, -12, -11, -11, -11, -11, -11,
-11, -11, -12, -11, -13, -13, -13, -14, -14, -15, -16, -16, -17, -18, -17, -19,
-19, -20, -20, -21, -24, -25, -29, -31, -34, -38, -41, -46, -49, -54, -56, -60,
-63, -66, -69, -71, -75, -77, -78, -80, -83, -85, -86, -86, -87, -86, -86, -85,
-83, -81, -80, -77, -77, -74, -72, -70, -69, -67, -65, -64, -63, -61, -60, -59,
-56, -56, -55, -54, -54, -55, -55, -55, -54, -55, -55, -54, -54, -54, -54, -53,
-53, -52, -52, -50, -49, -48, -48, -48, -48, -48, -47, -48, -49, -49, -50, -52,
-53, -53, -54, -55, -55, -55, -55, -55, -54, -53, -53, -52, -50, -49, -49, -48,
-47, -46, -44, -44, -44, -43, -43, -42, -41, -41, -41, -42, -42, -41, -43, -44,
-45, -47, -50, -51, -55, -57, -61, -64, -67, -71, -74, -78, -82, -86, -91, -94,
-98, -102, -105, -109, -112, -115, -116, -118, -118, -119, -118, -119, -117,
-116, -115, -112, -109, -105, -100, -95, -88, -81, -73, -66, -59, -50, -43, -36,
-30, -24, -17, -12, -6, -1, 3, 7, 11, 13, 14, 14, 13, 10, 6, 1, -6, -11, -17,
-22, -27, -33, -36, -40, -43, -46, -47, -48, -49, -50, -51, -51, -50, -51, -51,
-50, -49, -49, -48, -49, -49, -50, -49, -49, -49, -49, -47, -47, -45, -43, -40,
-38, -33, -30, -26, -22, -18, -14, -10, -6, -4, -2, };