#define DATA_LENGTH 512
#define DATA AKWF_altosax_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 7, 9, 12, 14, 16, 19, 22, 23,
25, 28, 29, 31, 34, 35, 37, 39, 40, 42, 43, 45, 46, 48, 50, 51, 53, 54, 56, 57,
58, 59, 60, 61, 62, 63, 62, 64, 64, 64, 65, 66, 65, 66, 66, 67, 68, 68, 68, 69,
69, 71, 71, 72, 71, 72, 73, 74, 74, 76, 76, 78, 78, 79, 80, 81, 82, 84, 85, 87,
88, 90, 91, 94, 96, 98, 100, 102, 103, 105, 107, 107, 109, 111, 111, 112, 115,
116, 116, 117, 117, 117, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 118, 117, 117, 116, 115, 115, 114, 114, 113, 113, 112, 111, 110, 109, 108,
107, 106, 104, 103, 102, 100, 99, 98, 96, 96, 95, 95, 93, 92, 92, 91, 89, 89,
87, 86, 84, 82, 82, 81, 78, 79, 76, 75, 74, 73, 71, 70, 69, 67, 66, 63, 61, 60,
58, 56, 55, 52, 51, 49, 47, 45, 43, 41, 39, 38, 37, 35, 33, 32, 30, 29, 27, 25,
25, 23, 21, 20, 17, 16, 15, 13, 11, 11, 9, 8, 7, 5, 5, 3, 2, 1, 2, 1, 0, -1, -1,
-2, -2, -2, -3, -4, -4, -4, -5, -5, -6, -6, -7, -7, -6, -7, -6, -7, -7, -7, -7,
-7, -7, -7, -6, -7, -7, -6, -6, -5, -5, -6, -5, -6, -5, -4, -5, -5, -6, -6, -6,
-6, -6, -5, -6, -6, -7, -8, -7, -8, -9, -9, -11, -12, -12, -13, -14, -15, -16,
-17, -19, -18, -21, -21, -22, -24, -25, -26, -26, -27, -29, -30, -32, -32, -34,
-35, -37, -38, -39, -41, -42, -44, -45, -47, -48, -49, -51, -52, -54, -54, -55,
-57, -58, -59, -60, -61, -62, -64, -64, -65, -67, -67, -69, -70, -71, -71, -71,
-72, -72, -73, -73, -73, -73, -75, -75, -75, -75, -75, -77, -76, -76, -76, -76,
-75, -76, -75, -74, -74, -73, -73, -73, -72, -72, -71, -70, -70, -69, -69, -68,
-68, -67, -66, -65, -65, -64, -64, -63, -62, -61, -60, -59, -58, -57, -56, -56,
-54, -53, -52, -50, -49, -49, -48, -48, -46, -45, -44, -44, -43, -43, -41, -41,
-39, -38, -37, -36, -37, -36, -34, -34, -34, -34, -32, -32, -31, -31, -31, -29,
-29, -29, -29, -28, -27, -27, -27, -27, -27, -27, -25, -26, -25, -26, -26, -25,
-25, -26, -26, -27, -27, -27, -28, -28, -30, -30, -31, -31, -32, -33, -33, -34,
-35, -35, -37, -37, -39, -40, -41, -42, -43, -44, -45, -48, -49, -50, -53, -54,
-55, -57, -59, -60, -62, -63, -63, -65, -67, -67, -70, -70, -72, -73, -74, -75,
-76, -76, -77, -78, -79, -79, -81, -80, -82, -82, -83, -84, -84, -83, -84, -84,
-84, -83, -82, -81, -81, -80, -80, -79, -78, -77, -76, -74, -73, -71, -70, -68,
-66, -65, -63, -62, -60, -58, -57, -55, -53, -51, -49, -46, -43, -41, -39, -37,
-34, -32, -30, -27, -25, -23, -20, -18, -16, -14, -11, -8, -6, -2, };