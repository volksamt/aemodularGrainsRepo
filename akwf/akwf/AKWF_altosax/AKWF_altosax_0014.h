#define DATA_LENGTH 512
#define DATA AKWF_altosax_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 7, 10, 10, 13, 14, 15, 17,
19, 20, 22, 25, 26, 28, 30, 32, 33, 35, 38, 38, 41, 43, 44, 46, 49, 50, 52, 54,
57, 58, 61, 62, 65, 66, 67, 69, 71, 72, 75, 76, 78, 80, 82, 83, 84, 86, 88, 90,
90, 92, 95, 95, 98, 99, 100, 102, 103, 104, 106, 106, 108, 109, 110, 111, 112,
113, 113, 114, 115, 116, 116, 118, 117, 118, 119, 119, 118, 119, 119, 119, 119,
119, 119, 118, 118, 117, 118, 117, 117, 117, 116, 115, 115, 115, 115, 113, 113,
112, 111, 110, 109, 109, 108, 107, 106, 105, 103, 103, 102, 100, 98, 96, 94, 94,
92, 89, 88, 87, 85, 83, 81, 80, 78, 75, 74, 73, 72, 70, 68, 65, 65, 63, 61, 60,
57, 55, 54, 52, 50, 48, 46, 44, 42, 40, 38, 37, 35, 34, 32, 29, 27, 25, 23, 21,
19, 18, 16, 13, 12, 9, 7, 6, 4, 2, 1, -2, -3, -6, -7, -9, -10, -11, -13, -15,
-16, -18, -19, -20, -21, -23, -24, -24, -27, -27, -28, -29, -30, -32, -32, -34,
-35, -35, -36, -37, -38, -39, -40, -40, -42, -42, -43, -43, -43, -45, -45, -44,
-46, -46, -46, -46, -46, -46, -47, -46, -47, -46, -46, -46, -47, -46, -46, -46,
-46, -46, -47, -46, -46, -45, -45, -45, -45, -45, -44, -44, -44, -44, -43, -43,
-42, -40, -41, -40, -38, -38, -38, -37, -36, -36, -35, -35, -34, -33, -32, -32,
-30, -30, -30, -28, -28, -28, -27, -26, -26, -25, -25, -24, -23, -24, -23, -22,
-21, -21, -20, -20, -19, -18, -18, -18, -18, -17, -17, -17, -17, -17, -17, -15,
-15, -15, -14, -13, -14, -14, -14, -14, -13, -14, -14, -14, -13, -13, -13, -13,
-13, -13, -14, -13, -14, -14, -14, -15, -15, -15, -15, -15, -16, -15, -16, -15,
-15, -16, -16, -16, -17, -17, -17, -18, -19, -18, -19, -21, -20, -20, -21, -22,
-22, -22, -23, -24, -23, -25, -25, -26, -26, -26, -27, -29, -29, -30, -30, -32,
-31, -32, -32, -33, -34, -34, -35, -35, -36, -37, -37, -38, -38, -38, -39, -40,
-41, -40, -41, -42, -43, -43, -43, -44, -44, -44, -45, -45, -47, -47, -46, -47,
-47, -48, -48, -48, -50, -49, -49, -50, -50, -50, -52, -52, -52, -52, -52, -53,
-53, -52, -53, -54, -54, -54, -54, -53, -54, -54, -54, -55, -55, -55, -56, -55,
-56, -56, -57, -56, -56, -57, -57, -57, -57, -57, -56, -57, -57, -56, -57, -55,
-56, -57, -56, -56, -56, -56, -55, -55, -56, -55, -55, -54, -54, -54, -54, -53,
-53, -53, -53, -53, -53, -53, -52, -53, -51, -51, -50, -50, -49, -49, -49, -48,
-48, -48, -46, -45, -45, -45, -44, -43, -44, -42, -42, -41, -41, -40, -38, -39,
-37, -35, -35, -34, -33, -32, -31, -31, -30, -28, -27, -26, -25, -24, -23, -22,
-20, -19, -17, -17, -15, -14, -12, -11, -9, -8, -7, -5, -3, -1, 1, };