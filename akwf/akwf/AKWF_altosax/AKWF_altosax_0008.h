#define DATA_LENGTH 512
#define DATA AKWF_altosax_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 8, 11, 14, 17, 20, 23, 27, 30,
33, 37, 40, 44, 47, 51, 54, 58, 61, 65, 69, 72, 75, 78, 82, 84, 87, 88, 89, 91,
93, 94, 95, 97, 97, 98, 99, 100, 101, 103, 105, 106, 107, 109, 110, 112, 112,
113, 114, 115, 116, 115, 116, 116, 115, 116, 117, 117, 118, 118, 118, 119, 119,
119, 119, 118, 117, 116, 115, 113, 112, 109, 108, 107, 105, 103, 100, 98, 96,
92, 91, 87, 85, 83, 80, 78, 76, 73, 71, 68, 66, 64, 61, 59, 56, 53, 51, 49, 47,
46, 44, 42, 39, 36, 34, 31, 28, 24, 22, 19, 17, 15, 14, 13, 13, 12, 11, 10, 8,
7, 6, 4, 3, 2, 2, 0, 0, -2, -5, -6, -7, -9, -13, -15, -16, -18, -20, -21, -21,
-22, -24, -26, -28, -30, -32, -33, -35, -37, -38, -39, -40, -41, -43, -44, -45,
-47, -48, -48, -50, -52, -52, -55, -56, -56, -57, -59, -59, -60, -61, -61, -62,
-62, -63, -63, -63, -64, -64, -63, -64, -64, -64, -64, -63, -63, -62, -62, -61,
-60, -60, -59, -59, -59, -57, -56, -56, -54, -54, -52, -52, -51, -49, -47, -46,
-44, -42, -40, -39, -37, -36, -34, -33, -30, -29, -26, -23, -21, -19, -17, -16,
-14, -12, -10, -7, -6, -4, -2, 0, 1, 3, 3, 5, 8, 10, 11, 13, 14, 15, 16, 19, 20,
22, 23, 24, 25, 26, 27, 29, 29, 30, 30, 30, 31, 31, 32, 31, 32, 31, 31, 31, 31,
31, 29, 28, 28, 27, 26, 25, 23, 23, 22, 20, 20, 19, 17, 17, 15, 14, 12, 11, 9,
8, 5, 3, 2, 0, -2, -3, -5, -5, -8, -9, -11, -13, -14, -16, -17, -19, -19, -20,
-20, -22, -24, -25, -26, -27, -28, -29, -31, -31, -32, -32, -33, -35, -34, -34,
-34, -35, -36, -37, -37, -38, -38, -38, -37, -36, -37, -36, -36, -36, -35, -35,
-35, -35, -35, -35, -34, -33, -34, -32, -33, -32, -31, -31, -29, -29, -28, -28,
-27, -27, -26, -25, -25, -23, -22, -22, -21, -20, -20, -20, -19, -18, -18, -17,
-18, -17, -17, -16, -16, -15, -15, -15, -15, -14, -14, -14, -14, -14, -13, -12,
-13, -13, -12, -11, -12, -11, -11, -11, -12, -11, -11, -11, -12, -12, -12, -13,
-14, -14, -14, -14, -14, -14, -14, -15, -17, -17, -17, -17, -18, -18, -19, -18,
-19, -20, -20, -21, -21, -22, -21, -22, -23, -23, -24, -24, -25, -26, -25, -26,
-26, -27, -27, -27, -28, -28, -28, -28, -29, -28, -28, -29, -28, -29, -29, -28,
-30, -29, -28, -29, -29, -29, -28, -28, -29, -28, -29, -28, -29, -29, -30, -30,
-29, -29, -30, -30, -30, -31, -32, -31, -33, -34, -34, -35, -35, -35, -36, -37,
-38, -39, -39, -41, -41, -42, -43, -44, -44, -44, -45, -45, -46, -45, -45, -46,
-45, -45, -44, -44, -43, -42, -39, -38, -35, -34, -31, -29, -26, -24, -21, -18,
-16, -13, -8, -5, -2, };