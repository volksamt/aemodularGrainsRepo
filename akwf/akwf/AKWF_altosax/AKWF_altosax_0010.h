#define DATA_LENGTH 512
#define DATA AKWF_altosax_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 7, 8, 10, 13, 15, 18, 21, 23,
27, 28, 31, 34, 37, 39, 42, 44, 46, 49, 52, 55, 59, 62, 66, 70, 72, 75, 77, 78,
80, 81, 82, 84, 86, 88, 89, 91, 93, 95, 97, 98, 99, 100, 101, 102, 104, 105,
106, 107, 108, 109, 109, 111, 112, 113, 114, 115, 116, 116, 116, 117, 118, 118,
117, 117, 119, 119, 119, 119, 119, 119, 118, 117, 116, 115, 114, 112, 111, 110,
109, 109, 108, 107, 106, 105, 103, 102, 100, 98, 97, 95, 93, 92, 90, 88, 86, 83,
82, 80, 78, 76, 73, 71, 68, 65, 62, 59, 56, 53, 50, 47, 44, 42, 39, 36, 33, 32,
28, 25, 22, 18, 15, 11, 8, 4, 2, 0, -3, -5, -5, -6, -9, -11, -13, -16, -20, -23,
-26, -27, -29, -29, -30, -32, -34, -35, -37, -39, -41, -44, -45, -48, -48, -50,
-50, -51, -52, -53, -55, -56, -57, -58, -59, -60, -62, -64, -65, -66, -67, -67,
-69, -69, -70, -70, -71, -72, -72, -73, -74, -74, -74, -75, -75, -76, -76, -75,
-75, -75, -75, -75, -75, -73, -74, -74, -73, -72, -71, -71, -70, -68, -66, -64,
-63, -61, -61, -59, -59, -58, -56, -55, -53, -50, -46, -45, -41, -40, -38, -37,
-36, -34, -34, -33, -31, -28, -26, -24, -21, -20, -19, -17, -16, -14, -13, -12,
-10, -9, -7, -6, -4, -2, 0, 1, 3, 5, 6, 7, 8, 9, 10, 10, 11, 12, 14, 16, 17, 19,
19, 20, 20, 21, 22, 23, 23, 26, 26, 27, 27, 27, 28, 27, 27, 28, 27, 27, 28, 27,
27, 27, 27, 27, 25, 24, 23, 21, 20, 20, 21, 19, 20, 20, 19, 18, 16, 14, 13, 12,
11, 10, 9, 8, 8, 7, 5, 4, 2, -1, -2, -4, -5, -7, -8, -8, -9, -11, -11, -12, -13,
-14, -16, -17, -18, -19, -21, -21, -22, -22, -23, -24, -25, -26, -27, -29, -29,
-32, -33, -33, -34, -34, -34, -35, -35, -36, -37, -37, -39, -40, -40, -40, -41,
-41, -42, -41, -42, -42, -43, -44, -44, -44, -44, -45, -45, -44, -43, -42, -43,
-43, -42, -43, -43, -42, -42, -41, -40, -40, -39, -38, -38, -39, -38, -38, -37,
-36, -36, -35, -33, -32, -32, -32, -30, -30, -29, -29, -29, -29, -29, -29, -28,
-27, -26, -25, -25, -24, -23, -23, -22, -21, -21, -22, -22, -22, -22, -22, -22,
-21, -20, -21, -21, -21, -21, -21, -21, -21, -20, -20, -20, -20, -21, -20, -21,
-20, -20, -20, -20, -20, -20, -20, -21, -21, -21, -23, -22, -23, -23, -22, -24,
-23, -24, -24, -25, -26, -26, -27, -28, -28, -29, -30, -30, -29, -29, -30, -30,
-29, -31, -29, -30, -30, -30, -30, -30, -30, -30, -30, -31, -30, -30, -30, -30,
-29, -30, -30, -30, -30, -29, -29, -28, -28, -28, -27, -27, -26, -26, -26, -25,
-24, -22, -22, -20, -21, -19, -17, -16, -16, -14, -12, -11, -9, -8, -6, -4, -2,
0, };