#define DATA_LENGTH 512
#define DATA AKWF_altosax_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 3, 3, 4, 5, 6, 8, 8, 10, 11, 13,
14, 14, 16, 18, 20, 21, 23, 24, 25, 26, 28, 29, 31, 32, 33, 35, 36, 37, 39, 40,
43, 44, 44, 47, 48, 48, 51, 53, 53, 55, 56, 57, 59, 61, 62, 63, 66, 66, 68, 70,
71, 74, 74, 76, 78, 79, 81, 82, 83, 85, 87, 87, 90, 91, 93, 95, 96, 97, 99, 100,
102, 103, 104, 107, 107, 108, 110, 111, 113, 113, 113, 116, 115, 117, 117, 117,
118, 118, 120, 119, 120, 119, 119, 119, 118, 116, 116, 115, 114, 113, 112, 110,
108, 106, 105, 104, 102, 100, 98, 96, 95, 93, 90, 89, 87, 86, 83, 82, 80, 78,
76, 74, 74, 72, 71, 69, 69, 68, 68, 66, 66, 66, 65, 64, 64, 64, 64, 64, 63, 63,
64, 63, 64, 63, 64, 64, 63, 63, 64, 64, 63, 64, 63, 64, 63, 62, 62, 62, 62, 61,
60, 60, 59, 58, 57, 56, 56, 54, 52, 52, 51, 49, 49, 48, 46, 45, 44, 43, 42, 41,
39, 37, 36, 35, 34, 32, 30, 30, 29, 27, 26, 25, 24, 22, 20, 19, 18, 16, 15, 15,
12, 12, 11, 10, 9, 8, 7, 7, 6, 5, 5, 4, 4, 2, 2, 1, 2, 1, 0, 1, 0, 0, -1, -1,
-1, -1, -1, -2, -1, -1, -3, -2, -2, -3, -4, -4, -5, -4, -5, -5, -6, -6, -6, -8,
-7, -9, -10, -11, -12, -12, -13, -13, -14, -15, -15, -16, -16, -18, -19, -19,
-21, -22, -22, -24, -26, -27, -27, -29, -30, -30, -31, -33, -33, -34, -36, -37,
-38, -39, -41, -41, -42, -44, -45, -46, -47, -48, -49, -50, -50, -50, -51, -51,
-52, -53, -53, -53, -53, -54, -55, -54, -55, -55, -55, -56, -56, -55, -56, -56,
-57, -57, -58, -58, -59, -59, -59, -61, -62, -61, -62, -62, -63, -63, -65, -66,
-67, -68, -68, -69, -70, -71, -71, -72, -74, -75, -76, -76, -77, -79, -79, -81,
-81, -82, -83, -84, -84, -85, -85, -85, -87, -88, -88, -88, -89, -89, -90, -89,
-91, -90, -90, -90, -90, -90, -89, -89, -89, -88, -88, -87, -87, -87, -86, -86,
-85, -85, -84, -84, -83, -82, -81, -82, -81, -80, -81, -80, -80, -79, -79, -78,
-79, -78, -77, -77, -77, -76, -77, -77, -76, -75, -74, -74, -74, -74, -73, -73,
-73, -71, -71, -70, -70, -70, -67, -67, -67, -65, -65, -64, -64, -63, -61, -61,
-60, -59, -59, -57, -56, -55, -54, -52, -52, -51, -49, -48, -48, -46, -45, -44,
-43, -42, -41, -40, -40, -39, -38, -37, -36, -35, -34, -33, -31, -31, -30, -29,
-28, -26, -27, -26, -25, -24, -23, -22, -21, -21, -19, -19, -18, -17, -16, -15,
-16, -15, -15, -14, -14, -13, -14, -13, -13, -14, -13, -13, -12, -12, -12, -11,
-11, -11, -11, -11, -10, -10, -10, -10, -10, -10, -9, -8, -9, -7, -7, -7, -6,
-5, -5, -4, -4, -3, -2, -2, -1, 0, };