#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 11, 16, 20, 23, 28, 32, 37, 41,
45, 49, 54, 58, 61, 65, 69, 73, 75, 79, 82, 84, 87, 88, 90, 93, 93, 95, 95, 97,
97, 98, 100, 100, 100, 101, 101, 103, 103, 102, 103, 103, 103, 103, 104, 103,
104, 103, 103, 104, 104, 105, 105, 104, 106, 105, 106, 107, 108, 108, 108, 109,
111, 111, 112, 112, 114, 114, 115, 116, 117, 117, 118, 119, 119, 119, 119, 118,
118, 118, 117, 115, 113, 111, 108, 105, 103, 99, 95, 91, 87, 82, 78, 73, 67, 63,
58, 53, 49, 44, 39, 35, 32, 28, 24, 22, 19, 16, 13, 12, 9, 7, 6, 4, 3, 2, 0, -1,
-2, -2, -4, -5, -5, -7, -7, -8, -10, -12, -14, -15, -17, -20, -23, -25, -27,
-31, -34, -38, -42, -46, -49, -54, -58, -62, -67, -71, -75, -80, -83, -87, -90,
-94, -98, -99, -102, -104, -105, -105, -105, -106, -104, -104, -103, -101, -99,
-97, -95, -94, -90, -89, -85, -84, -83, -82, -79, -79, -78, -79, -78, -79, -80,
-80, -80, -83, -83, -85, -85, -87, -88, -89, -90, -90, -90, -91, -90, -89, -87,
-86, -85, -82, -78, -75, -71, -67, -63, -59, -53, -47, -42, -36, -30, -26, -20,
-15, -10, -6, -2, 2, 3, 6, 8, 8, 9, 8, 7, 6, 4, 2, -1, -5, -9, -11, -15, -19,
-23, -25, -29, -32, -34, -36, -37, -38, -38, -37, -36, -35, -32, -30, -27, -21,
-19, -13, -9, -5, 0, 5, 9, 13, 17, 20, 22, 25, 26, 26, 27, 26, 25, 23, 21, 17,
14, 10, 5, 1, -3, -7, -13, -16, -20, -25, -27, -31, -33, -36, -37, -38, -39,
-37, -37, -35, -33, -31, -27, -25, -21, -16, -12, -7, -3, 1, 5, 8, 12, 16, 19,
22, 25, 27, 29, 29, 31, 32, 30, 31, 30, 28, 27, 27, 24, 22, 20, 19, 17, 15, 13,
12, 11, 9, 8, 7, 6, 5, 5, 5, 5, 5, 5, 5, 7, 7, 8, 8, 9, 9, 9, 10, 11, 11, 12,
12, 12, 12, 12, 12, 11, 12, 10, 11, 10, 10, 9, 8, 8, 9, 9, 9, 9, 9, 10, 11, 12,
13, 15, 14, 16, 17, 17, 17, 18, 17, 16, 15, 13, 12, 9, 5, 3, 0, -4, -9, -14,
-18, -23, -27, -32, -36, -39, -43, -47, -48, -51, -52, -53, -53, -53, -52, -50,
-47, -44, -41, -37, -32, -27, -22, -17, -12, -6, -2, 3, 7, 11, 13, 16, 17, 19,
18, 17, 16, 14, 12, 6, 3, -2, -7, -13, -18, -24, -31, -37, -44, -49, -55, -60,
-66, -70, -74, -77, -80, -81, -82, -83, -82, -80, -78, -75, -70, -66, -61, -56,
-49, -43, -36, -30, -24, -18, -13, -6, -2, 2, 5, 8, 11, 12, 12, 12, 11, 9, 8, 6,
3, -1, -4, -7, -10, -14, -18, -21, -24, -27, -30, -33, -35, -37, -38, -40, -41,
-40, -40, -38, -38, -35, -34, -32, -29, -27, -22, -19, -15, -12, -8, -4, -1, };