#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 12, 17, 23, 29, 35, 40, 47, 53,
59, 64, 68, 72, 76, 79, 82, 83, 86, 87, 87, 87, 87, 86, 86, 84, 82, 79, 77, 73,
71, 68, 66, 64, 61, 59, 58, 57, 57, 58, 58, 59, 60, 62, 65, 67, 70, 74, 76, 81,
85, 88, 91, 94, 96, 98, 99, 99, 99, 99, 98, 97, 95, 93, 91, 88, 87, 83, 81, 79,
77, 73, 70, 67, 63, 60, 56, 52, 48, 44, 40, 37, 33, 30, 28, 25, 23, 22, 21, 20,
19, 18, 17, 17, 15, 16, 15, 15, 15, 15, 15, 16, 16, 16, 16, 16, 17, 17, 18, 17,
15, 14, 13, 12, 10, 8, 6, 4, 1, 0, -2, -4, -5, -6, -7, -9, -10, -11, -11, -12,
-12, -12, -12, -10, -9, -8, -7, -5, -3, -2, -2, -1, -1, -4, -5, -7, -8, -11,
-13, -14, -16, -18, -20, -21, -21, -23, -24, -25, -25, -26, -27, -26, -27, -26,
-26, -25, -25, -24, -23, -22, -21, -21, -20, -18, -18, -18, -17, -17, -16, -16,
-16, -16, -17, -17, -17, -18, -18, -17, -16, -14, -12, -11, -7, -5, -3, 0, 1, 3,
5, 7, 9, 9, 11, 11, 11, 10, 8, 6, 3, 0, -3, -7, -11, -14, -18, -20, -22, -24,
-26, -26, -26, -27, -27, -26, -26, -25, -22, -22, -21, -20, -18, -18, -18, -16,
-15, -15, -14, -12, -10, -9, -8, -5, -4, -1, 1, 3, 5, 7, 9, 11, 13, 15, 16, 17,
19, 19, 20, 20, 19, 18, 15, 12, 10, 5, 1, -3, -7, -12, -16, -20, -25, -28, -31,
-34, -35, -37, -38, -38, -38, -35, -33, -32, -28, -25, -22, -17, -13, -9, -3, 1,
6, 11, 15, 20, 23, 27, 30, 31, 34, 36, 37, 39, 38, 39, 39, 39, 39, 37, 36, 35,
32, 31, 28, 27, 24, 23, 20, 18, 17, 15, 13, 11, 10, 10, 9, 9, 10, 10, 11, 13,
14, 17, 21, 24, 27, 31, 34, 39, 43, 47, 51, 55, 59, 63, 65, 67, 68, 69, 68, 67,
64, 62, 58, 53, 47, 40, 33, 26, 18, 10, 1, -6, -14, -22, -28, -34, -41, -46,
-50, -55, -58, -62, -63, -66, -68, -69, -69, -69, -68, -67, -66, -64, -62, -60,
-57, -54, -50, -47, -44, -41, -37, -34, -31, -29, -26, -24, -23, -23, -22, -22,
-23, -24, -26, -28, -32, -37, -41, -46, -51, -58, -63, -71, -77, -84, -90, -95,
-102, -107, -111, -115, -117, -119, -120, -119, -115, -112, -108, -102, -95,
-88, -80, -71, -62, -54, -45, -38, -32, -25, -20, -15, -14, -11, -10, -10, -10,
-13, -16, -18, -22, -27, -33, -39, -45, -50, -56, -62, -68, -72, -76, -79, -82,
-84, -84, -84, -81, -79, -76, -72, -68, -64, -59, -54, -50, -45, -41, -36, -32,
-27, -23, -20, -15, -12, -10, -6, -3, -2, -1, -1, -1, -1, -2, -3, -4, -5, -6,
-6, -7, -9, -9, -9, -10, -10, -10, -11, -11, -10, -10, -9, -8, -6, -3, 0, };