#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 5, 7, 9, 10, 13, 15, 16, 18, 20,
22, 24, 26, 29, 30, 32, 33, 36, 38, 39, 40, 41, 43, 45, 46, 47, 49, 50, 51, 53,
54, 55, 57, 57, 59, 60, 61, 62, 62, 64, 63, 64, 65, 63, 64, 64, 63, 62, 61, 60,
59, 58, 57, 56, 54, 54, 52, 51, 50, 49, 48, 48, 47, 46, 45, 44, 43, 42, 41, 40,
38, 38, 36, 34, 33, 31, 29, 28, 26, 25, 22, 21, 18, 16, 14, 12, 10, 9, 6, 5, 3,
2, 0, 0, -1, -2, -2, -3, -3, -3, -4, -3, -3, -4, -3, -2, -2, -2, -1, -2, 0, 0,
0, 2, 3, 4, 5, 6, 8, 10, 13, 15, 18, 21, 23, 26, 30, 33, 37, 40, 43, 46, 49, 52,
55, 57, 60, 61, 64, 66, 67, 69, 71, 73, 74, 74, 76, 77, 78, 79, 80, 81, 82, 83,
85, 86, 86, 89, 90, 92, 93, 96, 97, 99, 101, 103, 105, 108, 110, 110, 111, 114,
116, 116, 117, 118, 118, 119, 119, 120, 119, 118, 119, 118, 117, 116, 115, 113,
112, 111, 110, 107, 106, 104, 101, 99, 97, 95, 92, 89, 87, 83, 81, 76, 74, 71,
68, 65, 62, 58, 55, 53, 49, 47, 43, 41, 38, 36, 34, 31, 28, 26, 25, 21, 20, 17,
14, 12, 10, 8, 5, 3, 0, -2, -5, -7, -9, -12, -14, -17, -20, -23, -26, -28, -31,
-34, -35, -38, -41, -43, -44, -46, -47, -49, -49, -51, -53, -53, -53, -54, -55,
-56, -56, -56, -56, -56, -56, -56, -56, -56, -56, -56, -56, -55, -55, -55, -55,
-54, -54, -54, -54, -54, -53, -54, -54, -54, -55, -54, -55, -55, -56, -56, -56,
-55, -56, -56, -56, -55, -56, -54, -54, -54, -53, -52, -53, -52, -50, -50, -50,
-49, -48, -48, -47, -46, -46, -45, -45, -44, -44, -44, -44, -44, -44, -44, -44,
-44, -43, -43, -43, -42, -42, -42, -42, -42, -43, -42, -43, -43, -42, -43, -44,
-43, -44, -44, -44, -44, -45, -46, -47, -46, -46, -47, -47, -46, -46, -45, -44,
-44, -42, -41, -39, -39, -37, -35, -33, -31, -29, -28, -25, -23, -21, -20, -18,
-17, -16, -15, -14, -13, -13, -13, -12, -12, -12, -11, -12, -11, -11, -11, -10,
-11, -11, -11, -11, -10, -10, -10, -10, -9, -10, -11, -11, -12, -12, -13, -14,
-15, -17, -19, -20, -21, -24, -24, -27, -27, -29, -30, -32, -32, -34, -34, -35,
-36, -35, -36, -36, -36, -37, -36, -37, -37, -38, -38, -39, -40, -41, -42, -43,
-45, -47, -48, -50, -52, -55, -57, -58, -61, -62, -64, -67, -69, -71, -72, -74,
-76, -75, -77, -78, -79, -80, -80, -80, -81, -82, -82, -81, -82, -82, -82, -82,
-82, -80, -81, -80, -79, -78, -77, -75, -74, -73, -71, -67, -67, -64, -62, -59,
-56, -52, -50, -47, -44, -41, -39, -36, -34, -31, -28, -26, -23, -22, -20, -18,
-16, -14, -11, -11, -8, -7, -5, -3, -2, 0, };