#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0026

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 10, 14, 19, 22, 27, 31, 34, 37,
40, 42, 45, 47, 48, 50, 51, 53, 54, 57, 58, 61, 63, 66, 69, 71, 73, 76, 80, 81,
83, 84, 86, 87, 87, 87, 88, 87, 87, 87, 86, 84, 84, 84, 83, 82, 80, 80, 79, 79,
77, 76, 75, 75, 73, 74, 73, 72, 72, 71, 69, 68, 68, 66, 65, 64, 64, 62, 62, 61,
61, 60, 60, 59, 59, 58, 57, 56, 53, 52, 49, 47, 44, 43, 39, 38, 35, 34, 32, 31,
31, 31, 31, 32, 33, 34, 36, 38, 40, 41, 43, 45, 47, 49, 50, 51, 53, 54, 54, 56,
55, 54, 55, 54, 52, 51, 49, 47, 44, 43, 41, 38, 36, 33, 31, 29, 27, 24, 23, 21,
19, 18, 16, 15, 14, 12, 12, 11, 10, 9, 9, 9, 10, 9, 11, 11, 13, 14, 16, 18, 20,
23, 24, 27, 29, 31, 32, 33, 34, 34, 34, 33, 33, 31, 30, 28, 26, 24, 22, 22, 20,
19, 16, 14, 13, 12, 10, 9, 7, 5, 3, 1, 0, -3, -4, -6, -8, -9, -10, -10, -12,
-11, -10, -9, -9, -7, -6, -5, -2, -1, 0, 2, 2, 2, 5, 4, 4, 4, 3, 2, 0, 0, -2,
-5, -6, -7, -9, -10, -12, -14, -15, -16, -18, -21, -23, -25, -27, -29, -32, -33,
-35, -36, -37, -38, -38, -37, -37, -36, -33, -31, -29, -27, -24, -22, -20, -18,
-18, -16, -15, -14, -15, -15, -16, -15, -16, -16, -16, -15, -15, -15, -13, -12,
-11, -11, -9, -8, -8, -8, -6, -7, -5, -6, -4, -3, -2, 0, 3, 6, 9, 12, 17, 21,
26, 30, 34, 40, 45, 50, 54, 58, 63, 67, 71, 75, 77, 81, 84, 87, 90, 93, 95, 95,
96, 97, 97, 96, 95, 93, 91, 88, 83, 80, 75, 70, 66, 61, 56, 50, 46, 42, 38, 33,
30, 26, 24, 21, 20, 17, 16, 15, 14, 13, 13, 13, 12, 11, 12, 11, 11, 10, 12, 11,
11, 11, 11, 11, 11, 11, 11, 9, 9, 8, 7, 5, 3, 0, -3, -6, -9, -13, -15, -19, -23,
-27, -29, -33, -35, -38, -41, -43, -45, -47, -49, -51, -53, -55, -56, -58, -60,
-60, -61, -63, -64, -66, -66, -66, -65, -66, -66, -64, -63, -62, -59, -57, -55,
-52, -50, -48, -46, -44, -42, -40, -39, -37, -35, -33, -33, -32, -32, -31, -31,
-32, -32, -33, -34, -36, -36, -39, -41, -44, -46, -49, -53, -55, -58, -62, -64,
-67, -70, -72, -75, -77, -80, -81, -82, -84, -86, -87, -88, -88, -88, -90, -91,
-91, -92, -93, -94, -95, -96, -97, -99, -100, -102, -105, -106, -108, -110,
-113, -115, -116, -117, -118, -119, -119, -118, -118, -118, -117, -115, -114,
-112, -110, -108, -106, -104, -103, -100, -98, -96, -94, -92, -91, -88, -86,
-83, -81, -78, -76, -74, -72, -69, -67, -65, -62, -59, -56, -54, -51, -49, -46,
-43, -41, -37, -34, -30, -28, -24, -20, -16, -11, -8, -3, };