#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 5, 7, 7, 10, 12, 13, 15, 16,
17, 18, 20, 22, 24, 24, 26, 27, 29, 30, 32, 32, 34, 36, 37, 38, 40, 41, 42, 45,
46, 47, 48, 49, 51, 52, 53, 54, 56, 57, 59, 59, 61, 61, 63, 64, 65, 66, 68, 68,
69, 71, 72, 73, 74, 75, 76, 77, 79, 79, 80, 81, 82, 83, 84, 85, 86, 87, 88, 88,
89, 91, 91, 92, 92, 93, 95, 94, 95, 96, 97, 97, 98, 99, 100, 100, 100, 101, 102,
102, 103, 103, 104, 104, 104, 105, 105, 106, 107, 106, 107, 108, 108, 108, 108,
108, 109, 109, 109, 110, 110, 110, 110, 110, 111, 110, 110, 111, 111, 111, 110,
111, 110, 111, 110, 111, 111, 110, 110, 111, 110, 110, 110, 110, 110, 110, 109,
109, 109, 108, 108, 108, 109, 107, 107, 107, 106, 107, 106, 105, 106, 105, 104,
104, 104, 103, 103, 102, 102, 101, 100, 100, 100, 98, 99, 98, 97, 96, 96, 95,
94, 94, 94, 93, 93, 91, 91, 91, 90, 88, 88, 87, 86, 86, 85, 84, 83, 82, 81, 80,
79, 78, 78, 78, 76, 75, 73, 73, 73, 71, 70, 69, 68, 67, 66, 65, 64, 64, 63, 62,
60, 59, 58, 57, 56, 55, 53, 53, 52, 50, 50, 48, 46, 45, 45, 44, 43, 41, 39, 39,
38, 36, 36, 33, 32, 32, 31, 28, 28, 27, 25, 24, 22, 22, 21, 20, 18, 17, 16, 14,
13, 12, 10, 9, 8, 7, 6, 4, 3, 2, 1, -1, -2, -4, -5, -7, -8, -10, -10, -12, -13,
-14, -15, -17, -18, -19, -20, -22, -23, -25, -26, -27, -29, -29, -31, -33, -33,
-34, -36, -37, -38, -41, -41, -42, -44, -45, -46, -47, -48, -50, -51, -53, -54,
-54, -56, -58, -59, -61, -61, -63, -63, -65, -66, -67, -68, -69, -71, -72, -73,
-74, -75, -76, -77, -78, -80, -81, -82, -82, -84, -85, -85, -87, -88, -89, -90,
-90, -91, -92, -93, -95, -95, -96, -97, -98, -99, -100, -100, -101, -102, -103,
-103, -104, -105, -106, -106, -107, -108, -108, -108, -110, -110, -110, -111,
-112, -112, -113, -113, -114, -115, -115, -115, -115, -116, -116, -117, -117,
-117, -117, -118, -118, -117, -118, -119, -118, -118, -120, -119, -119, -120,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -118, -118,
-118, -118, -117, -117, -116, -116, -115, -116, -116, -114, -115, -115, -113,
-113, -113, -113, -112, -112, -110, -110, -109, -109, -108, -107, -107, -106,
-105, -104, -104, -103, -102, -101, -100, -100, -98, -97, -97, -95, -94, -94,
-92, -92, -91, -90, -89, -88, -86, -86, -85, -83, -82, -82, -80, -79, -77, -77,
-74, -74, -72, -72, -70, -68, -67, -66, -65, -64, -63, -61, -60, -57, -57, -56,
-54, -52, -51, -49, -47, -46, -45, -44, -43, -40, -40, -38, -37, -35, -34, -32,
-30, -29, -28, -27, -25, -23, -21, -20, -19, -17, -15, -14, -13, -11, -9, -9,
-7, -6, -4, -3, 0, };