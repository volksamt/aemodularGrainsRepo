#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 18, 28, 38, 48, 58, 68, 77, 85,
94, 99, 105, 111, 115, 117, 119, 120, 118, 117, 115, 112, 108, 104, 100, 95, 89,
82, 76, 69, 61, 54, 47, 41, 36, 30, 27, 23, 23, 21, 22, 24, 27, 30, 34, 38, 41,
45, 49, 51, 54, 56, 58, 60, 60, 61, 60, 58, 58, 57, 56, 55, 55, 55, 55, 53, 50,
48, 45, 42, 39, 37, 33, 31, 27, 24, 22, 20, 17, 16, 15, 13, 13, 13, 13, 14, 14,
15, 14, 15, 14, 13, 12, 11, 10, 8, 7, 7, 6, 7, 7, 9, 10, 10, 11, 11, 12, 12, 13,
14, 14, 14, 14, 14, 13, 12, 11, 10, 8, 8, 6, 6, 5, 6, 6, 8, 8, 9, 10, 12, 12,
11, 11, 8, 7, 5, 3, 1, 1, 0, 1, 0, 0, 0, 0, 0, 1, 1, 0, 1, 1, 1, 0, 0, 0, 0, -1,
-2, -4, -6, -7, -10, -10, -10, -10, -9, -8, -7, -6, -6, -7, -9, -10, -11, -13,
-13, -12, -11, -11, -10, -9, -10, -10, -11, -12, -13, -16, -17, -19, -20, -19,
-19, -17, -15, -12, -9, -7, -6, -5, -6, -8, -10, -12, -15, -17, -18, -20, -21,
-22, -23, -23, -22, -20, -18, -16, -13, -12, -9, -8, -9, -9, -11, -11, -14, -16,
-17, -19, -20, -20, -20, -18, -17, -14, -12, -11, -9, -9, -9, -10, -12, -13,
-14, -17, -19, -20, -23, -25, -26, -28, -28, -27, -26, -23, -19, -13, -8, 0, 6,
12, 18, 23, 27, 30, 32, 34, 34, 33, 32, 31, 30, 28, 26, 25, 22, 21, 20, 19, 17,
18, 17, 17, 17, 15, 13, 11, 8, 4, 0, -2, -4, -6, -4, -4, -2, 2, 5, 10, 14, 20,
24, 28, 32, 35, 38, 40, 40, 40, 39, 37, 35, 33, 31, 30, 29, 30, 31, 32, 35, 36,
37, 38, 38, 36, 33, 26, 21, 13, 7, -1, -9, -17, -24, -30, -36, -41, -46, -51,
-57, -60, -64, -67, -69, -70, -71, -71, -70, -70, -69, -70, -70, -70, -71, -69,
-68, -66, -61, -56, -52, -46, -41, -36, -33, -30, -27, -26, -25, -24, -25, -23,
-22, -21, -21, -22, -22, -23, -26, -29, -32, -37, -40, -43, -46, -47, -48, -48,
-47, -47, -47, -47, -47, -49, -50, -49, -49, -47, -46, -43, -40, -36, -32, -29,
-26, -24, -22, -20, -19, -18, -17, -14, -12, -9, -6, -5, -2, 0, 2, 3, 5, 6, 7,
9, 12, 15, 18, 21, 24, 28, 30, 33, 36, 36, 36, 37, 35, 33, 30, 26, 22, 15, 8, 0,
-9, -19, -28, -38, -47, -57, -65, -72, -79, -84, -88, -91, -93, -93, -93, -91,
-90, -85, -79, -73, -66, -57, -50, -41, -32, -23, -17, -11, -4, -1, 2, 5, 6, 7,
7, 5, 4, 3, 1, -1, -5, -9, -11, -16, -20, -25, -29, -34, -38, -41, -43, -46,
-46, -47, -46, -45, -43, -40, -39, -36, -34, -32, -30, -28, -25, -23, -20, -16,
-12, -7, -2, };