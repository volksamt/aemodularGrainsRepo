#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0032

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 11, 13, 15, 17, 18, 18, 18, 20,
21, 23, 25, 29, 34, 38, 44, 49, 55, 62, 67, 73, 78, 83, 87, 89, 91, 92, 92, 92,
91, 90, 87, 84, 81, 77, 73, 68, 64, 59, 55, 51, 47, 44, 43, 45, 47, 49, 54, 61,
67, 75, 82, 90, 96, 101, 106, 109, 110, 111, 110, 106, 103, 98, 93, 88, 80, 75,
66, 58, 50, 41, 30, 21, 10, -2, -13, -24, -35, -44, -54, -61, -65, -69, -71,
-70, -66, -62, -54, -47, -38, -29, -19, -9, 0, 8, 15, 21, 25, 28, 30, 30, 28,
25, 20, 15, 7, -1, -11, -21, -32, -45, -57, -68, -78, -89, -98, -106, -111,
-115, -118, -119, -118, -116, -113, -109, -104, -99, -93, -85, -79, -72, -64,
-58, -49, -43, -36, -30, -24, -19, -16, -14, -12, -13, -15, -18, -24, -29, -36,
-44, -53, -61, -70, -78, -85, -92, -98, -103, -107, -110, -110, -109, -107,
-104, -99, -93, -85, -78, -69, -60, -49, -40, -31, -21, -13, -3, 3, 9, 14, 18,
20, 21, 21, 21, 19, 17, 15, 12, 9, 6, 3, -1, -5, -8, -11, -15, -17, -21, -23,
-25, -25, -26, -25, -22, -18, -14, -8, -3, 5, 13, 23, 30, 39, 48, 55, 63, 69,
76, 80, 84, 87, 90, 91, 91, 92, 91, 90, 88, 85, 82, 79, 75, 71, 66, 63, 57, 54,
49, 45, 42, 41, 38, 37, 36, 36, 35, 35, 36, 38, 39, 41, 42, 46, 48, 51, 55, 60,
64, 69, 75, 79, 84, 87, 90, 93, 93, 92, 91, 87, 83, 77, 71, 63, 56, 48, 41, 34,
27, 21, 15, 11, 7, 3, 0, -1, -3, -5, -5, -6, -6, -5, -4, -4, -3, -2, -1, 0, 2,
1, 2, 3, 3, 2, 3, 2, 1, 0, -1, -3, -5, -9, -11, -14, -18, -23, -28, -32, -38,
-44, -49, -54, -61, -66, -70, -72, -75, -77, -78, -78, -77, -74, -71, -69, -63,
-60, -55, -50, -46, -42, -39, -36, -33, -31, -30, -30, -30, -31, -32, -34, -37,
-39, -40, -43, -46, -46, -49, -50, -52, -53, -54, -54, -55, -55, -56, -56, -57,
-57, -57, -56, -56, -54, -52, -50, -45, -41, -37, -31, -24, -17, -9, -2, 6, 14,
21, 27, 33, 38, 42, 45, 47, 49, 49, 49, 47, 46, 43, 41, 37, 34, 30, 26, 22, 18,
14, 10, 7, 4, 2, 1, -1, 0, 1, 2, 5, 8, 11, 17, 20, 26, 32, 37, 44, 50, 57, 62,
69, 75, 80, 85, 89, 93, 94, 96, 96, 94, 91, 85, 77, 69, 60, 49, 38, 25, 13, 1,
-11, -23, -34, -43, -51, -56, -61, -64, -66, -66, -65, -63, -60, -57, -52, -48,
-42, -36, -32, -27, -22, -17, -14, -11, -9, -8, -8, -8, -12, -14, -17, -23, -27,
-34, -39, -46, -52, -57, -63, -68, -72, -76, -78, -80, -81, -81, -81, -81, -80,
-78, -76, -75, -72, -70, -66, -63, -60, -55, -50, -44, -39, -32, -25, -19, -12,
-6, -1, };