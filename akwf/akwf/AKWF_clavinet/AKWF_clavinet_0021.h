#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 17, 28, 38, 48, 58, 68, 79, 88, 96,
104, 111, 115, 118, 119, 118, 116, 111, 105, 99, 93, 85, 78, 72, 66, 60, 56, 53,
51, 49, 50, 51, 52, 52, 53, 53, 51, 50, 48, 45, 44, 42, 42, 43, 44, 47, 50, 55,
59, 63, 67, 69, 72, 72, 73, 72, 70, 68, 66, 62, 60, 58, 55, 53, 51, 49, 49, 48,
47, 45, 45, 43, 41, 40, 38, 36, 33, 30, 27, 25, 22, 21, 20, 20, 19, 20, 19, 18,
16, 14, 12, 11, 9, 9, 10, 10, 12, 14, 15, 15, 16, 15, 15, 13, 12, 11, 10, 10,
10, 9, 11, 10, 11, 11, 10, 10, 9, 8, 8, 8, 8, 9, 12, 12, 12, 12, 10, 8, 7, 4, 2,
1, -1, 0, 1, 3, 4, 5, 6, 7, 6, 5, 4, 3, 1, 2, 0, 0, 1, 2, 2, 3, 3, 3, 2, -1, -2,
-6, -7, -7, -8, -6, -5, -4, -2, -1, -1, -1, -2, -4, -5, -9, -10, -11, -12, -13,
-12, -13, -12, -11, -9, -7, -7, -6, -5, -3, -2, -1, 0, 1, 1, 1, 0, -1, -3, -5,
-7, -10, -13, -14, -15, -14, -13, -12, -10, -8, -6, -4, -3, -3, -3, -4, -5, -6,
-8, -8, -8, -6, -4, -1, 3, 6, 9, 11, 12, 14, 12, 9, 6, 2, -3, -10, -17, -23,
-28, -32, -35, -36, -36, -34, -32, -28, -24, -20, -16, -13, -10, -7, -5, -3, -1,
-1, 2, 4, 8, 11, 16, 20, 23, 28, 30, 33, 35, 38, 39, 38, 38, 36, 33, 30, 27, 23,
21, 19, 18, 16, 16, 16, 16, 15, 14, 14, 13, 13, 12, 12, 12, 11, 10, 9, 8, 7, 7,
7, 8, 9, 11, 13, 17, 20, 25, 29, 35, 41, 47, 52, 56, 59, 62, 64, 64, 63, 62, 60,
58, 54, 52, 47, 44, 40, 38, 34, 31, 27, 24, 18, 12, 7, 0, -7, -16, -24, -32,
-40, -48, -55, -61, -67, -72, -75, -78, -80, -80, -79, -78, -77, -75, -73, -70,
-67, -65, -63, -59, -57, -54, -51, -50, -47, -45, -44, -41, -39, -38, -36, -34,
-32, -33, -32, -33, -34, -37, -40, -42, -45, -48, -50, -53, -55, -57, -58, -59,
-59, -60, -59, -57, -57, -54, -51, -49, -47, -45, -43, -40, -40, -40, -41, -43,
-45, -48, -50, -53, -55, -56, -57, -57, -57, -55, -53, -50, -46, -42, -37, -30,
-23, -15, -5, 4, 14, 22, 31, 38, 45, 50, 54, 56, 57, 58, 56, 53, 51, 48, 42, 36,
28, 20, 10, -1, -10, -22, -32, -42, -50, -59, -66, -73, -77, -83, -86, -90, -92,
-92, -92, -90, -85, -80, -75, -69, -61, -56, -49, -42, -38, -34, -31, -30, -27,
-26, -24, -23, -21, -21, -19, -18, -16, -16, -14, -13, -12, -11, -11, -10, -9,
-10, -11, -14, -17, -22, -28, -36, -42, -49, -57, -64, -68, -73, -74, -75, -76,
-74, -74, -72, -68, -66, -62, -56, -50, -43, -36, -27, -19, -9, 0, };