#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0029

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 5, 8, 10, 11, 12, 13, 14, 14,
16, 17, 19, 21, 22, 24, 24, 27, 28, 29, 31, 34, 35, 38, 40, 43, 45, 49, 51, 54,
57, 59, 60, 63, 63, 64, 63, 63, 61, 59, 56, 53, 50, 46, 43, 40, 36, 34, 32, 30,
29, 29, 29, 31, 33, 35, 38, 40, 44, 49, 53, 58, 63, 68, 75, 79, 86, 91, 97, 102,
107, 110, 114, 116, 118, 120, 119, 118, 116, 114, 109, 105, 100, 94, 87, 81, 74,
66, 60, 54, 47, 40, 35, 29, 23, 19, 14, 10, 7, 5, 3, 3, 5, 5, 6, 9, 12, 16, 20,
26, 30, 35, 40, 45, 51, 54, 58, 61, 63, 64, 63, 63, 61, 57, 53, 50, 43, 38, 30,
23, 16, 8, 1, -8, -15, -22, -30, -36, -41, -46, -49, -54, -55, -57, -59, -59,
-60, -59, -58, -57, -55, -55, -53, -51, -50, -49, -47, -46, -46, -46, -47, -47,
-49, -51, -53, -56, -58, -61, -65, -67, -71, -75, -78, -82, -83, -87, -89, -92,
-94, -95, -96, -96, -95, -95, -95, -93, -91, -89, -88, -85, -82, -80, -78, -76,
-74, -73, -71, -69, -68, -66, -65, -64, -63, -62, -62, -61, -63, -62, -64, -65,
-67, -68, -70, -71, -72, -74, -74, -76, -75, -75, -73, -72, -70, -66, -63, -58,
-52, -46, -39, -33, -25, -19, -11, -5, 2, 8, 12, 18, 20, 24, 27, 29, 30, 30, 30,
31, 30, 29, 27, 25, 23, 19, 16, 13, 9, 7, 4, 0, -3, -6, -8, -10, -11, -13, -13,
-12, -12, -10, -8, -5, -3, 0, 2, 5, 7, 10, 13, 15, 16, 18, 19, 20, 21, 21, 22,
22, 23, 23, 22, 22, 23, 22, 22, 21, 21, 20, 19, 17, 14, 11, 9, 6, 4, 1, -1, -4,
-5, -8, -9, -10, -11, -10, -10, -9, -8, -7, -6, -5, -3, -1, 1, 3, 4, 6, 8, 9,
11, 12, 14, 15, 16, 18, 18, 19, 21, 20, 20, 21, 20, 19, 18, 17, 17, 15, 13, 12,
10, 10, 9, 8, 7, 8, 8, 9, 9, 12, 14, 16, 18, 21, 23, 26, 28, 31, 32, 34, 35, 36,
38, 39, 39, 38, 38, 37, 37, 36, 34, 33, 31, 30, 27, 25, 23, 20, 17, 13, 9, 6, 1,
-4, -7, -12, -18, -22, -26, -31, -33, -35, -38, -40, -40, -40, -40, -38, -35,
-34, -30, -26, -20, -16, -11, -6, 0, 4, 10, 16, 21, 26, 30, 34, 38, 40, 42, 44,
44, 44, 42, 41, 39, 35, 31, 26, 21, 16, 9, 2, -4, -11, -17, -23, -30, -35, -40,
-45, -49, -52, -56, -58, -59, -60, -62, -60, -60, -58, -56, -53, -50, -46, -42,
-37, -33, -27, -22, -18, -12, -7, -3, 2, 6, 9, 12, 14, 15, 16, 16, 14, 13, 11,
8, 3, -1, -6, -10, -15, -21, -25, -31, -36, -40, -44, -48, -52, -54, -55, -56,
-56, -56, -54, -52, -49, -45, -41, -37, -33, -28, -24, -20, -15, -11, -7, -3,
-1, };