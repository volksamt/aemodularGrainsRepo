#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 20, 37, 55, 73, 89, 96, 99, 95, 89,
83, 79, 76, 69, 61, 53, 47, 42, 38, 37, 34, 34, 31, 29, 25, 20, 13, 8, 8, 13,
22, 32, 43, 50, 52, 54, 54, 53, 50, 46, 42, 41, 42, 42, 41, 38, 37, 36, 36, 36,
35, 30, 23, 16, 10, 8, 5, 6, 8, 11, 15, 18, 16, 10, 2, -6, -12, -15, -17, -18,
-18, -16, -15, -13, -11, -12, -12, -16, -17, -17, -18, -21, -25, -28, -29, -26,
-21, -17, -16, -16, -16, -16, -19, -21, -26, -31, -32, -30, -24, -19, -16, -14,
-13, -12, -11, -10, -12, -15, -19, -20, -19, -17, -15, -15, -15, -13, -11, -8,
-9, -10, -15, -17, -17, -16, -13, -11, -9, -7, -2, 1, 3, 2, 0, -4, -5, -5, -3,
-3, -5, -8, -10, -10, -10, -8, -9, -9, -8, -5, -1, 2, 3, 0, -3, -4, -6, -6, -5,
-6, -4, -4, -1, 1, 1, 0, -1, -2, -1, 0, 0, -1, -2, -2, -3, -3, -1, 0, 3, 3, 5,
6, 7, 5, 1, -2, -7, -9, -9, -6, -4, -2, 0, 1, 1, 2, 1, -2, -5, -8, -9, -6, -2,
2, 6, 8, 9, 11, 11, 7, 3, -2, -9, -12, -14, -11, -6, -1, 6, 12, 17, 19, 16, 11,
4, 0, -3, -5, -5, -4, -1, 2, 5, 6, 5, 3, 2, -1, -2, -3, -6, -6, -7, -6, -4, -3,
0, 2, 3, 4, 5, 5, 4, 4, 1, 0, 1, 4, 6, 7, 8, 5, 0, -3, -4, -6, -4, -3, -3, -1,
2, 6, 9, 13, 14, 14, 14, 11, 5, -2, -9, -14, -18, -19, -16, -13, -7, -1, 4, 7,
10, 12, 14, 14, 14, 12, 9, 6, -1, -10, -18, -23, -23, -19, -14, -7, 3, 12, 19,
25, 28, 28, 25, 18, 9, -2, -12, -22, -29, -31, -29, -23, -13, -2, 8, 15, 21, 22,
21, 18, 14, 10, 3, -3, -9, -12, -14, -15, -15, -14, -11, -5, 1, 7, 10, 13, 12,
10, 7, 3, -4, -11, -15, -18, -20, -19, -15, -10, 0, 10, 21, 29, 36, 39, 38, 31,
24, 13, 1, -10, -23, -32, -37, -39, -37, -30, -21, -11, -2, 7, 14, 19, 20, 16,
12, 5, -2, -8, -15, -19, -21, -20, -14, -7, 1, 12, 21, 30, 39, 46, 52, 54, 54,
51, 45, 38, 32, 23, 16, 8, 1, -3, -6, -8, -12, -15, -18, -20, -22, -23, -26,
-28, -29, -28, -26, -23, -20, -15, -9, -2, 8, 19, 29, 39, 48, 56, 64, 67, 67,
64, 55, 48, 39, 32, 25, 18, 10, 4, -1, -5, -10, -14, -20, -28, -38, -48, -61,
-74, -86, -98, -108, -115, -119, -119, -118, -114, -108, -96, -82, -65, -46,
-30, -16, -2, 11, 25, 36, 43, 48, 49, 48, 42, 34, 21, 6, -8, -20, -27, -32, -34,
-35, -34, -34, -32, -30, -32, -34, -38, -41, -46, -49, -52, -55, -57, -56, -49,
-41, -33, -26, -22, -20, -17, -12, -5, };