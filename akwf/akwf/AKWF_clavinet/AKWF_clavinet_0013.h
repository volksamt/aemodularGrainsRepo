#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 10, 14, 18, 21, 23, 26, 28, 30,
31, 33, 33, 34, 34, 34, 34, 34, 33, 32, 32, 32, 32, 32, 33, 33, 35, 37, 38, 41,
44, 47, 51, 55, 59, 64, 69, 74, 80, 85, 90, 95, 99, 103, 108, 111, 113, 116,
118, 118, 119, 119, 119, 117, 115, 113, 110, 106, 103, 98, 94, 91, 86, 81, 77,
73, 68, 65, 60, 58, 54, 51, 49, 47, 45, 45, 44, 45, 44, 45, 47, 47, 49, 52, 54,
57, 60, 63, 66, 69, 71, 74, 77, 79, 80, 81, 82, 82, 82, 80, 79, 77, 75, 72, 69,
65, 60, 55, 51, 46, 40, 34, 28, 23, 17, 12, 7, 4, -2, -6, -10, -12, -15, -17,
-20, -21, -21, -23, -24, -24, -23, -23, -22, -22, -20, -21, -19, -18, -17, -15,
-14, -12, -12, -11, -9, -7, -6, -4, -4, -2, -1, 0, 0, 1, 0, 1, 1, 0, -1, -1, -1,
-3, -5, -7, -9, -12, -13, -14, -18, -20, -23, -26, -27, -29, -31, -33, -34, -35,
-36, -36, -36, -36, -35, -34, -34, -32, -29, -27, -25, -23, -19, -17, -14, -10,
-8, -4, -2, 1, 4, 5, 8, 10, 11, 13, 14, 15, 15, 16, 16, 17, 15, 15, 15, 13, 12,
12, 11, 10, 9, 8, 6, 6, 6, 5, 5, 4, 4, 3, 4, 4, 4, 5, 6, 6, 7, 8, 9, 9, 9, 11,
12, 13, 13, 13, 13, 13, 13, 13, 14, 13, 12, 11, 10, 10, 8, 7, 6, 3, 1, 0, -2,
-4, -7, -9, -11, -14, -15, -16, -18, -19, -20, -21, -21, -22, -20, -21, -19,
-17, -15, -14, -11, -8, -5, -2, 1, 3, 6, 9, 11, 14, 16, 17, 19, 21, 23, 24, 23,
24, 25, 24, 24, 24, 23, 23, 23, 22, 21, 21, 21, 21, 21, 23, 23, 24, 25, 26, 27,
28, 30, 31, 33, 35, 36, 38, 40, 41, 43, 43, 44, 45, 45, 45, 45, 46, 46, 45, 44,
45, 43, 43, 41, 39, 38, 36, 34, 31, 29, 27, 23, 20, 17, 14, 10, 6, 3, 0, -3, -7,
-10, -13, -17, -19, -21, -23, -25, -26, -27, -28, -28, -29, -29, -29, -28, -29,
-29, -28, -28, -27, -29, -29, -29, -30, -30, -32, -34, -35, -36, -38, -40, -42,
-45, -48, -49, -52, -54, -57, -59, -62, -63, -65, -67, -68, -70, -71, -73, -72,
-73, -74, -74, -75, -75, -75, -75, -75, -73, -72, -72, -71, -69, -68, -67, -65,
-63, -61, -59, -55, -55, -52, -50, -47, -46, -43, -43, -42, -40, -41, -41, -42,
-43, -46, -47, -50, -53, -57, -60, -63, -66, -69, -72, -75, -78, -80, -81, -81,
-83, -83, -83, -82, -81, -80, -77, -74, -73, -69, -67, -64, -62, -59, -57, -55,
-54, -52, -52, -51, -51, -51, -51, -53, -54, -55, -56, -57, -59, -61, -62, -63,
-64, -64, -65, -65, -66, -64, -64, -63, -61, -60, -57, -55, -53, -49, -45, -42,
-38, -34, -31, -26, -22, -18, -13, -9, -5, -2, };