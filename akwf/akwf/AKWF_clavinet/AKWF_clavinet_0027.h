#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0027

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 11, 14, 18, 21, 24, 26, 29,
31, 35, 37, 40, 44, 45, 48, 50, 54, 56, 58, 60, 63, 65, 66, 68, 71, 72, 74, 76,
77, 79, 80, 82, 83, 83, 84, 86, 87, 88, 89, 89, 88, 89, 90, 90, 91, 90, 91, 90,
90, 90, 88, 88, 87, 86, 85, 85, 84, 83, 81, 81, 80, 77, 77, 75, 75, 73, 72, 69,
69, 67, 66, 65, 63, 62, 60, 59, 58, 56, 55, 53, 51, 50, 49, 48, 46, 44, 44, 42,
41, 39, 39, 37, 35, 35, 34, 32, 32, 31, 30, 29, 28, 27, 26, 25, 25, 24, 24, 22,
23, 22, 21, 21, 21, 21, 20, 20, 19, 18, 18, 18, 18, 17, 17, 16, 16, 16, 16, 15,
14, 15, 14, 14, 13, 13, 13, 12, 12, 11, 10, 11, 10, 9, 9, 9, 8, 8, 8, 7, 6, 6,
5, 5, 5, 5, 4, 3, 3, 3, 3, 2, 2, 2, 1, 1, 0, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0,
1, 1, 1, 1, 1, 2, 2, 2, 3, 3, 3, 4, 5, 5, 5, 6, 6, 8, 7, 7, 9, 9, 10, 10, 11,
13, 13, 13, 14, 15, 15, 16, 17, 17, 19, 19, 20, 20, 21, 22, 22, 24, 23, 24, 24,
25, 26, 27, 27, 28, 28, 28, 29, 30, 30, 30, 30, 31, 31, 31, 31, 32, 32, 31, 32,
31, 32, 32, 32, 31, 31, 31, 31, 31, 30, 31, 30, 29, 29, 30, 30, 28, 28, 28, 28,
27, 27, 27, 26, 26, 26, 26, 25, 24, 24, 25, 25, 24, 23, 23, 23, 23, 23, 23, 23,
24, 23, 22, 23, 23, 23, 23, 24, 24, 23, 24, 25, 25, 25, 25, 25, 26, 26, 26, 26,
26, 27, 27, 28, 28, 28, 28, 28, 29, 29, 29, 30, 30, 30, 30, 31, 30, 30, 31, 30,
30, 30, 30, 30, 31, 30, 29, 30, 29, 29, 29, 29, 28, 28, 27, 26, 26, 26, 26, 25,
24, 22, 22, 22, 21, 20, 19, 18, 16, 15, 14, 14, 12, 10, 9, 7, 6, 3, 3, 1, -1,
-3, -5, -7, -8, -10, -12, -15, -16, -20, -22, -23, -26, -29, -31, -34, -36, -38,
-40, -42, -45, -48, -50, -53, -56, -57, -61, -63, -65, -67, -70, -73, -74, -77,
-79, -81, -84, -86, -88, -90, -91, -94, -95, -97, -99, -99, -102, -103, -105,
-106, -108, -109, -110, -111, -113, -113, -114, -115, -116, -117, -117, -117,
-118, -119, -120, -119, -119, -120, -119, -119, -119, -118, -118, -119, -119,
-119, -118, -117, -116, -116, -115, -115, -114, -114, -112, -113, -111, -111,
-109, -109, -108, -108, -106, -105, -105, -103, -102, -102, -101, -99, -98, -97,
-95, -94, -93, -91, -89, -88, -86, -86, -85, -82, -81, -79, -76, -75, -74, -71,
-70, -69, -66, -64, -62, -61, -59, -55, -54, -51, -49, -47, -45, -43, -41, -39,
-35, -34, -30, -28, -25, -22, -19, -17, -14, -11, -9, -6, -3, 0, };