#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 11, 16, 21, 27, 34, 41, 48, 55,
64, 72, 81, 88, 96, 103, 109, 114, 116, 119, 119, 119, 118, 116, 112, 108, 105,
101, 96, 91, 86, 80, 74, 68, 62, 55, 51, 44, 40, 36, 33, 30, 30, 28, 29, 31, 33,
37, 40, 45, 49, 53, 57, 59, 62, 64, 63, 64, 64, 65, 64, 63, 62, 61, 59, 57, 55,
53, 51, 47, 44, 41, 37, 34, 31, 29, 26, 23, 22, 19, 17, 16, 14, 12, 10, 10, 8,
8, 8, 7, 5, 5, 3, 3, 1, 1, 2, 2, 2, 2, 2, 2, 1, 1, 1, 0, 0, -1, -2, -2, -3, -4,
-5, -5, -6, -6, -7, -6, -8, -8, -10, -11, -11, -10, -11, -11, -11, -12, -11,
-11, -11, -10, -10, -9, -10, -9, -8, -10, -11, -11, -11, -13, -12, -12, -13,
-12, -13, -14, -14, -13, -14, -14, -15, -14, -15, -15, -16, -16, -18, -18, -18,
-18, -18, -18, -18, -17, -18, -18, -19, -19, -19, -20, -19, -18, -19, -19, -18,
-17, -17, -17, -17, -17, -17, -18, -19, -19, -18, -18, -17, -14, -12, -10, -9,
-10, -11, -11, -13, -13, -15, -14, -14, -12, -11, -9, -9, -9, -9, -10, -12, -13,
-16, -17, -18, -19, -17, -15, -14, -12, -10, -10, -10, -10, -12, -13, -13, -14,
-13, -12, -11, -10, -8, -9, -9, -10, -11, -11, -11, -10, -8, -6, -3, -1, 0, 0,
-1, -3, -7, -10, -13, -16, -17, -17, -14, -11, -7, -5, -2, -1, 1, 0, 0, -1, -2,
-3, -5, -4, -6, -5, -5, -6, -5, -6, -7, -8, -10, -12, -12, -13, -13, -12, -11,
-10, -8, -7, -6, -5, -3, -1, 1, 5, 9, 13, 17, 21, 24, 28, 33, 37, 42, 44, 47,
49, 50, 51, 49, 48, 45, 42, 37, 32, 26, 19, 13, 8, 4, 0, -2, -4, -4, -3, -3, -1,
1, 3, 5, 9, 14, 17, 22, 26, 30, 34, 37, 40, 43, 48, 50, 51, 53, 55, 56, 57, 57,
57, 57, 54, 53, 50, 48, 42, 39, 35, 30, 26, 22, 16, 11, 4, -4, -12, -20, -29,
-37, -44, -51, -57, -62, -66, -69, -72, -74, -76, -77, -76, -75, -75, -72, -70,
-67, -62, -57, -51, -45, -40, -34, -29, -23, -19, -14, -9, -6, -5, -3, -3, -5,
-8, -12, -19, -26, -35, -44, -52, -60, -67, -72, -77, -80, -83, -85, -87, -89,
-91, -93, -94, -95, -95, -95, -91, -89, -87, -84, -82, -79, -75, -71, -66, -61,
-54, -46, -39, -29, -22, -15, -9, -5, -1, 2, 3, 4, 5, 7, 7, 6, 5, 3, 0, -6, -12,
-20, -27, -35, -42, -49, -55, -59, -63, -67, -70, -71, -74, -75, -75, -73, -69,
-66, -61, -54, -46, -38, -28, -19, -10, -1, 8, 15, 23, 30, 35, 39, 44, 46, 47,
48, 46, 42, 38, 32, 27, 22, 17, 13, 8, 6, 2, -1, -4, -6, -8, -10, -14, -15, -17,
-18, -19, -20, -18, -18, -15, -13, -9, -6, -2, };