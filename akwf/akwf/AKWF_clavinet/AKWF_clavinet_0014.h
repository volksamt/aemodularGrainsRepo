#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 17, 26, 37, 44, 53, 58, 61, 59, 56,
51, 43, 35, 24, 15, 8, 4, 7, 17, 31, 48, 66, 81, 91, 101, 108, 113, 118, 119,
114, 105, 89, 70, 52, 36, 26, 23, 24, 28, 30, 32, 33, 35, 38, 45, 53, 59, 64,
65, 60, 53, 46, 41, 38, 38, 42, 47, 50, 52, 53, 50, 47, 44, 39, 35, 28, 21, 15,
7, 1, -5, -10, -13, -14, -15, -14, -14, -13, -13, -14, -16, -17, -19, -23, -27,
-33, -41, -50, -59, -69, -80, -87, -92, -95, -95, -93, -90, -85, -82, -78, -74,
-70, -69, -67, -66, -66, -65, -63, -63, -60, -55, -49, -43, -37, -32, -27, -23,
-19, -18, -18, -20, -24, -29, -34, -42, -48, -54, -59, -64, -68, -71, -72, -72,
-70, -68, -64, -60, -55, -50, -44, -39, -33, -27, -20, -15, -10, -7, -3, 0, 3,
4, 7, 9, 11, 11, 11, 11, 10, 9, 9, 10, 11, 11, 11, 12, 12, 12, 13, 14, 14, 15,
15, 16, 15, 15, 15, 15, 16, 17, 16, 17, 17, 17, 18, 18, 19, 20, 20, 20, 17, 16,
18, 17, 18, 18, 18, 17, 18, 17, 18, 18, 18, 20, 20, 20, 19, 19, 19, 17, 18, 16,
17, 17, 16, 16, 17, 16, 15, 16, 17, 17, 15, 14, 14, 13, 12, 12, 12, 12, 10, 9,
9, 10, 12, 12, 11, 10, 10, 8, 9, 8, 8, 7, 8, 7, 5, 3, 3, 2, 2, 3, 4, 4, 5, 4, 5,
3, 4, 4, 5, 5, 3, 4, 3, 3, 2, 1, 2, 3, 3, 3, 2, 2, 1, 1, 2, 3, 2, 1, 0, -1, -2,
-2, -1, -1, -2, -2, -3, -5, -5, -3, -3, -2, -1, -3, -3, -3, -3, -2, -2, -3, -1,
-3, -3, -4, -4, -4, -1, -1, 0, -2, -2, -3, 0, 0, 1, 0, -1, -1, -1, -1, -1, -2,
-2, -2, -1, -1, 0, 1, 0, -1, -1, 0, 0, 1, 2, 1, 1, 0, -2, -2, -2, -1, 0, 1, 1,
0, -1, -1, 0, 1, 2, 2, 2, 1, 1, 1, -1, -1, -1, -1, -1, 1, 2, 2, 2, 3, 2, 2, 2,
3, 4, 3, 3, 3, 2, 1, 2, 2, 2, 1, 1, 1, 2, 4, 4, 3, 2, 1, 0, 0, 1, 2, 4, 4, 1,
-1, -3, -5, -4, -2, 1, 1, 3, 3, 1, -1, -2, -3, -2, -3, -2, -2, -1, -2, -3, -5,
-5, -4, -3, -2, 0, 2, 4, 5, 3, 0, -4, -8, -10, -10, -9, -6, -5, -4, -3, -2, -1,
1, 4, 8, 14, 17, 18, 17, 11, 6, 0, -4, -7, -12, -17, -21, -26, -31, -35, -38,
-39, -40, -41, -39, -35, -31, -27, -27, -28, -32, -35, -37, -36, -30, -22, -15,
-10, -7, -7, -5, 0, 8, 19, 29, 34, 34, 30, 22, 13, 4, -3, -9, -16, -21, -27,
-32, -35, -36, -37, -37, -35, -33, -29, -24, -22, -24, -27, -31, -37, -39, -37,
-32, -22, -12, -1, };