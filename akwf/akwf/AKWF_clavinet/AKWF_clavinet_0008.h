#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 9, 14, 17, 18, 18, 17, 15, 14, 11,
11, 9, 10, 13, 16, 21, 29, 36, 47, 57, 66, 76, 86, 94, 101, 106, 110, 110, 110,
108, 104, 99, 94, 88, 82, 76, 72, 68, 66, 65, 65, 67, 70, 75, 79, 83, 88, 92,
94, 96, 97, 97, 95, 92, 88, 81, 74, 67, 58, 49, 40, 30, 23, 15, 9, 4, 1, -1, -2,
-2, 0, 0, 2, 3, 3, 3, 0, -3, -10, -17, -25, -34, -44, -54, -64, -73, -81, -86,
-92, -96, -98, -98, -97, -96, -94, -92, -89, -88, -86, -86, -87, -89, -91, -96,
-100, -105, -108, -112, -116, -118, -119, -118, -116, -114, -109, -103, -96,
-88, -80, -70, -62, -54, -45, -39, -33, -29, -27, -24, -23, -23, -24, -26, -27,
-29, -32, -34, -35, -35, -37, -36, -35, -33, -31, -27, -24, -19, -16, -11, -5,
0, 5, 10, 16, 22, 27, 31, 36, 40, 44, 49, 52, 56, 59, 62, 62, 63, 65, 64, 64,
62, 60, 59, 55, 51, 49, 45, 41, 39, 36, 34, 32, 30, 30, 31, 31, 33, 35, 39, 42,
47, 52, 57, 62, 68, 74, 78, 83, 87, 90, 92, 94, 95, 95, 95, 92, 88, 84, 80, 74,
67, 59, 52, 44, 34, 26, 18, 9, 3, -4, -12, -16, -20, -22, -25, -24, -23, -21,
-17, -12, -6, 0, 7, 14, 21, 28, 36, 41, 46, 50, 53, 55, 55, 54, 52, 47, 41, 34,
25, 16, 5, -6, -17, -29, -41, -51, -62, -71, -79, -87, -94, -98, -100, -102,
-101, -100, -96, -92, -85, -77, -67, -58, -47, -35, -23, -11, 1, 11, 20, 30, 37,
43, 47, 50, 52, 50, 47, 43, 36, 28, 20, 10, -2, -13, -23, -34, -45, -54, -62,
-69, -75, -79, -83, -84, -83, -82, -78, -73, -66, -57, -49, -37, -26, -15, -4,
9, 20, 31, 40, 49, 56, 63, 68, 71, 73, 74, 72, 70, 67, 62, 55, 48, 39, 29, 18,
8, -3, -14, -24, -35, -45, -55, -63, -69, -77, -81, -84, -86, -86, -84, -82,
-77, -71, -64, -57, -49, -42, -35, -28, -20, -14, -8, -2, 2, 8, 12, 16, 18, 21,
23, 23, 23, 22, 18, 15, 11, 6, 1, -5, -10, -14, -19, -23, -27, -32, -33, -36,
-38, -40, -40, -41, -39, -37, -34, -30, -25, -19, -12, -4, 4, 12, 20, 28, 36,
44, 50, 56, 62, 65, 69, 71, 72, 73, 74, 74, 74, 75, 75, 77, 77, 78, 78, 78, 78,
77, 73, 71, 67, 61, 54, 47, 39, 31, 24, 18, 12, 7, 4, 2, 1, 2, 3, 5, 7, 10, 12,
13, 13, 12, 11, 8, 3, -1, -7, -12, -19, -26, -31, -36, -40, -44, -47, -48, -49,
-48, -47, -45, -44, -43, -41, -42, -42, -44, -46, -48, -52, -56, -61, -65, -71,
-75, -81, -85, -88, -88, -90, -89, -86, -83, -78, -72, -65, -57, -49, -42, -34,
-29, -22, -20, -17, -18, -19, -20, -22, -24, -27, -29, -29, -28, -26, -23, -16,
-7, };