#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0028

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 18, 29, 39, 47, 53, 60, 63, 65, 66,
68, 68, 65, 65, 63, 60, 57, 52, 46, 39, 31, 23, 16, 9, 3, -1, -3, -4, -3, 0, 3,
8, 14, 19, 25, 31, 37, 41, 46, 50, 56, 59, 63, 67, 69, 70, 70, 69, 69, 67, 66,
66, 66, 66, 66, 66, 67, 65, 64, 62, 60, 58, 56, 55, 55, 55, 55, 56, 57, 57, 57,
58, 60, 60, 62, 65, 68, 72, 77, 82, 87, 90, 95, 97, 99, 99, 100, 100, 99, 98,
97, 95, 91, 88, 81, 73, 64, 54, 41, 30, 19, 10, 2, -5, -8, -11, -13, -14, -16,
-17, -17, -17, -17, -13, -10, -4, 4, 11, 18, 26, 33, 39, 44, 48, 51, 52, 54, 55,
55, 56, 55, 54, 51, 46, 40, 33, 26, 17, 8, 0, -9, -16, -23, -30, -37, -42, -48,
-55, -62, -69, -75, -82, -88, -91, -95, -96, -97, -96, -96, -95, -93, -92, -89,
-87, -85, -80, -76, -70, -65, -58, -54, -49, -46, -46, -45, -45, -45, -46, -47,
-46, -46, -47, -47, -50, -53, -57, -63, -69, -77, -83, -91, -97, -102, -106,
-109, -111, -114, -114, -116, -118, -118, -120, -118, -116, -112, -109, -104,
-100, -95, -91, -88, -85, -82, -80, -78, -73, -69, -63, -55, -48, -39, -33, -26,
-21, -16, -13, -10, -9, -7, -5, -3, -2, -1, -2, -1, -3, -4, -6, -8, -10, -10,
-10, -9, -8, -6, -4, -3, -4, -5, -8, -12, -16, -19, -23, -23, -23, -21, -17,
-12, -7, -2, 4, 10, 14, 19, 23, 28, 31, 35, 39, 43, 44, 46, 45, 44, 42, 40, 37,
36, 34, 31, 29, 29, 26, 26, 22, 19, 14, 12, 6, 2, -2, -6, -9, -12, -13, -13,
-12, -10, -6, -2, 4, 10, 15, 22, 29, 33, 37, 41, 43, 43, 43, 41, 39, 36, 33, 30,
26, 23, 20, 16, 13, 11, 8, 6, 5, 4, 3, 2, 0, 1, 0, 0, -1, -2, -2, -1, -1, 1, 1,
5, 7, 10, 12, 15, 19, 22, 25, 28, 32, 34, 36, 38, 40, 41, 42, 42, 41, 39, 37,
35, 32, 29, 26, 22, 18, 14, 11, 7, 4, 1, -2, -3, -5, -7, -8, -8, -9, -9, -7, -7,
-5, -4, -1, 1, 2, 4, 7, 10, 14, 17, 19, 22, 25, 27, 29, 30, 30, 29, 29, 27, 23,
19, 16, 12, 7, 2, -2, -7, -12, -14, -19, -20, -21, -21, -20, -18, -16, -12, -9,
-6, -2, 1, 4, 8, 10, 13, 16, 17, 19, 20, 21, 22, 22, 20, 18, 17, 15, 13, 11, 8,
4, 1, -3, -8, -14, -20, -26, -33, -37, -42, -45, -48, -49, -51, -51, -50, -48,
-46, -41, -37, -31, -24, -18, -10, -3, 3, 8, 13, 17, 19, 21, 22, 23, 22, 22, 21,
19, 18, 14, 10, 6, 0, -5, -11, -18, -24, -33, -41, -50, -61, -70, -81, -90, -99,
-106, -112, -115, -117, -116, -112, -107, -100, -93, -85, -74, -64, -52, -41,
-28, -15, -3, };