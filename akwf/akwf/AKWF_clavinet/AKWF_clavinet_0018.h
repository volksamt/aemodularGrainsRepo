#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 6, 7, 8, 9, 11, 12, 14,
15, 16, 17, 18, 20, 20, 22, 24, 25, 25, 27, 28, 29, 31, 31, 32, 34, 34, 36, 38,
39, 40, 41, 41, 42, 44, 45, 46, 47, 48, 49, 50, 51, 53, 54, 54, 56, 56, 57, 58,
60, 60, 61, 62, 63, 65, 65, 66, 67, 68, 69, 69, 70, 72, 72, 73, 74, 74, 76, 76,
76, 77, 78, 79, 80, 81, 81, 83, 83, 83, 85, 85, 86, 87, 87, 88, 89, 89, 90, 90,
91, 92, 92, 94, 94, 94, 94, 95, 96, 96, 97, 97, 97, 98, 99, 99, 100, 101, 100,
102, 102, 102, 102, 102, 103, 103, 104, 103, 104, 105, 105, 105, 106, 105, 105,
106, 107, 106, 106, 107, 107, 107, 108, 107, 108, 108, 108, 108, 108, 107, 108,
108, 107, 109, 108, 107, 107, 107, 107, 107, 107, 107, 107, 107, 106, 107, 106,
106, 105, 105, 105, 105, 104, 104, 103, 103, 102, 103, 102, 101, 101, 100, 99,
99, 99, 98, 98, 97, 96, 96, 96, 95, 94, 93, 93, 93, 92, 91, 90, 89, 89, 88, 87,
86, 86, 84, 83, 83, 81, 81, 81, 80, 78, 78, 76, 76, 75, 73, 72, 72, 70, 70, 69,
68, 66, 65, 65, 63, 62, 61, 60, 58, 57, 56, 55, 54, 52, 51, 51, 49, 48, 47, 45,
44, 42, 41, 40, 39, 37, 36, 34, 34, 32, 31, 29, 28, 27, 25, 24, 22, 21, 20, 18,
17, 16, 13, 13, 11, 10, 8, 6, 5, 4, 2, 1, 0, -1, -4, -5, -7, -8, -9, -10, -13,
-14, -16, -17, -18, -20, -22, -24, -25, -27, -28, -30, -31, -33, -33, -36, -37,
-38, -40, -42, -43, -44, -46, -47, -49, -51, -52, -53, -55, -56, -57, -59, -61,
-62, -63, -64, -66, -66, -68, -69, -71, -73, -74, -75, -76, -78, -78, -80, -82,
-82, -83, -84, -86, -86, -87, -89, -91, -91, -92, -94, -94, -96, -97, -97, -98,
-99, -99, -101, -102, -103, -103, -104, -105, -105, -106, -107, -107, -108,
-109, -110, -111, -111, -111, -112, -112, -113, -114, -113, -114, -115, -115,
-115, -116, -116, -117, -117, -118, -117, -118, -118, -119, -118, -118, -119,
-119, -119, -119, -119, -120, -118, -119, -119, -120, -119, -119, -118, -119,
-119, -119, -119, -118, -118, -117, -117, -117, -117, -116, -116, -116, -115,
-115, -114, -115, -113, -113, -113, -112, -112, -112, -110, -110, -109, -110,
-108, -108, -107, -106, -105, -105, -104, -103, -104, -102, -101, -100, -100,
-99, -97, -97, -97, -97, -95, -94, -93, -92, -91, -90, -90, -88, -87, -86, -85,
-85, -82, -82, -81, -80, -79, -78, -77, -76, -74, -73, -72, -70, -70, -69, -68,
-66, -65, -64, -62, -62, -59, -60, -58, -56, -55, -54, -53, -51, -50, -48, -47,
-46, -45, -43, -41, -40, -39, -38, -36, -35, -34, -32, -31, -29, -28, -27, -26,
-24, -22, -21, -20, -19, -17, -16, -14, -14, -13, -10, -9, -8, -7, -5, -4, -2,
-1, };