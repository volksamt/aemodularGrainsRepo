#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 30, 43, 58, 70, 83, 95, 108, 117,
119, 116, 110, 102, 90, 79, 71, 66, 61, 53, 43, 34, 30, 28, 29, 28, 27, 27, 25,
24, 24, 22, 23, 28, 34, 40, 41, 36, 24, 11, -5, -18, -28, -32, -29, -21, -6, 11,
26, 41, 51, 59, 64, 65, 61, 54, 49, 48, 50, 53, 54, 52, 47, 39, 29, 16, 3, -11,
-26, -39, -52, -64, -73, -76, -78, -78, -77, -76, -70, -62, -54, -50, -48, -48,
-49, -50, -50, -49, -44, -39, -31, -26, -23, -26, -32, -39, -49, -57, -62, -63,
-60, -55, -45, -36, -25, -15, -8, -6, -7, -11, -16, -24, -32, -41, -48, -53,
-55, -54, -52, -50, -46, -42, -35, -29, -24, -18, -12, -7, -4, -1, 3, 8, 12, 13,
12, 12, 13, 12, 13, 12, 11, 12, 13, 14, 15, 17, 19, 18, 18, 18, 17, 16, 16, 16,
17, 15, 16, 18, 19, 19, 19, 18, 17, 17, 17, 16, 16, 16, 17, 19, 21, 22, 22, 22,
22, 23, 22, 20, 20, 21, 21, 20, 20, 19, 19, 19, 16, 14, 12, 12, 11, 7, 6, 4, 2,
3, 3, 3, 2, 1, 2, 1, -1, -1, -2, -3, -4, -6, -6, -7, -7, -6, -5, -4, -5, -5, -4,
-4, -5, -4, -5, -4, -2, 1, 3, 3, 3, 2, 3, 3, 2, 0, 1, 1, 0, -2, -2, -1, -1, -3,
-4, -4, -4, -4, -4, -4, -5, -4, -2, 0, 0, 1, 2, 5, 4, 2, 1, 2, 3, 2, 1, 1, 1, 2,
4, 5, 2, 1, 2, 5, 6, 3, 2, 3, 7, 9, 9, 8, 9, 10, 9, 6, 4, 2, 2, 3, 1, -1, -1, 1,
2, 0, -1, -3, -2, -2, -3, -5, -3, -1, 0, 1, 2, 0, -1, 2, 1, -1, -3, -3, -2, -4,
-4, -3, -4, -5, -5, -3, -2, -3, -3, -2, -2, -2, -1, -2, -2, -2, 0, 1, 0, -1, -1,
1, 4, 3, -2, -5, -3, -2, -3, -5, -4, -2, 1, 2, -1, -4, -2, 2, 3, 0, -2, -2, 0,
0, -3, -3, -2, 1, 3, 3, 1, -2, -5, -4, -5, -6, -7, -2, 3, 5, 5, 4, 7, 7, 4, -3,
-7, -10, -9, -8, -7, -10, -8, 0, 7, 9, 9, 12, 16, 22, 25, 28, 25, 19, 12, 7, 6,
6, 6, 3, 5, 8, 10, 8, -1, -8, -8, -1, 3, -3, -8, -5, 4, 12, 11, 6, 6, 10, 11, 3,
-11, -22, -27, -22, -15, -7, 1, 10, 19, 22, 16, 10, 5, 3, 0, -5, -1, 9, 24, 38,
48, 52, 51, 47, 38, 21, -5, -29, -47, -59, -70, -78, -84, -87, -87, -83, -76,
-68, -62, -57, -47, -35, -26, -27, -33, -34, -24, -7, 5, 8, 4, 5, 7, 7, -6, -21,
-28, -23, -16, -13, -13, -9, 3, 17, 30, 36, 40, 41, 38, 30, 18, 5, -6, -15, -23,
-31, -35, -35, -37, -41, -45, -49, -50, -50, -53, -56, -57, -53, -40, -23, -4,
};