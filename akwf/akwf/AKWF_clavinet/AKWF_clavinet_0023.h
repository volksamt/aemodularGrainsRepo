#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 10, 11, 11, 10, 10, 10, 10,
9, 9, 10, 11, 11, 12, 12, 13, 13, 14, 15, 16, 20, 23, 27, 32, 39, 45, 52, 60,
67, 75, 82, 89, 95, 99, 103, 106, 108, 108, 108, 108, 107, 107, 106, 105, 105,
106, 106, 106, 108, 107, 106, 104, 101, 97, 92, 85, 78, 72, 67, 61, 56, 52, 49,
48, 45, 44, 44, 45, 46, 46, 48, 49, 50, 52, 53, 55, 57, 59, 60, 62, 64, 67, 70,
72, 77, 80, 84, 88, 91, 93, 96, 97, 98, 95, 94, 92, 88, 84, 79, 75, 70, 66, 61,
57, 52, 49, 46, 43, 40, 38, 37, 35, 33, 33, 31, 31, 28, 27, 24, 22, 21, 19, 17,
15, 15, 17, 18, 20, 23, 26, 30, 34, 38, 40, 43, 44, 46, 46, 46, 47, 47, 45, 45,
44, 43, 43, 44, 46, 48, 49, 51, 51, 53, 54, 53, 52, 49, 47, 42, 39, 35, 30, 26,
22, 19, 15, 13, 9, 5, 1, -3, -8, -13, -19, -24, -30, -34, -39, -42, -46, -47,
-46, -48, -46, -43, -39, -35, -29, -23, -17, -10, -2, 5, 12, 17, 24, 29, 35, 38,
42, 45, 47, 48, 47, 47, 45, 42, 38, 33, 26, 19, 11, 2, -7, -18, -27, -36, -45,
-53, -62, -70, -75, -82, -88, -91, -96, -99, -102, -105, -105, -107, -107, -106,
-104, -101, -96, -93, -86, -79, -71, -63, -54, -45, -36, -27, -17, -8, 1, 8, 15,
22, 29, 35, 39, 42, 44, 44, 45, 44, 43, 40, 38, 34, 31, 27, 22, 19, 15, 11, 8,
4, 0, -2, -4, -5, -6, -5, -4, -2, 1, 3, 7, 10, 13, 19, 23, 29, 34, 41, 48, 54,
61, 69, 75, 82, 87, 92, 96, 101, 104, 107, 110, 112, 113, 115, 114, 113, 111,
108, 103, 96, 88, 79, 69, 58, 48, 37, 26, 16, 6, -3, -13, -22, -31, -38, -45,
-52, -57, -62, -65, -66, -68, -68, -67, -64, -62, -58, -54, -51, -46, -43, -39,
-35, -33, -31, -28, -28, -28, -29, -29, -31, -34, -36, -38, -41, -42, -45, -48,
-49, -51, -53, -55, -56, -57, -58, -58, -59, -59, -60, -60, -60, -60, -60, -60,
-61, -62, -63, -64, -65, -65, -65, -67, -67, -67, -68, -68, -66, -65, -63, -60,
-57, -55, -50, -46, -42, -37, -31, -25, -20, -14, -8, 0, 5, 10, 14, 18, 21, 24,
26, 25, 26, 24, 24, 21, 18, 17, 14, 12, 8, 6, 3, 1, -1, -3, -5, -6, -8, -9, -9,
-9, -10, -10, -11, -12, -14, -17, -20, -23, -26, -30, -34, -40, -44, -50, -55,
-60, -66, -71, -77, -82, -87, -92, -95, -99, -103, -105, -107, -109, -110, -110,
-110, -109, -108, -107, -105, -104, -102, -100, -98, -96, -94, -92, -91, -91,
-92, -93, -95, -97, -100, -102, -105, -108, -111, -112, -115, -116, -118, -119,
-119, -119, -117, -116, -113, -109, -105, -98, -93, -85, -77, -70, -61, -54,
-46, -39, -32, -25, -17, -12, -6, -1, };