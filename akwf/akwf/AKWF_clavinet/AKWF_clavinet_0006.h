#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 12, 19, 25, 29, 32, 31, 30, 28, 26,
27, 30, 35, 42, 51, 58, 64, 68, 70, 71, 69, 70, 71, 74, 78, 83, 88, 92, 97, 98,
98, 98, 97, 95, 94, 91, 90, 89, 92, 96, 101, 107, 114, 118, 119, 117, 114, 107,
97, 86, 76, 66, 60, 58, 56, 58, 63, 66, 68, 69, 67, 62, 55, 44, 33, 23, 12, 4,
-1, -3, -3, -2, 1, 3, 3, 1, -4, -11, -21, -29, -38, -43, -45, -46, -45, -43,
-41, -41, -40, -42, -44, -48, -52, -55, -59, -62, -65, -68, -71, -73, -78, -81,
-85, -89, -94, -97, -99, -99, -97, -92, -87, -80, -73, -64, -56, -49, -44, -42,
-42, -47, -55, -66, -77, -89, -98, -105, -106, -103, -95, -82, -65, -47, -28,
-12, 2, 9, 13, 12, 8, 2, -3, -7, -9, -13, -15, -17, -20, -24, -28, -31, -32,
-33, -29, -24, -15, -5, 7, 19, 31, 42, 51, 56, 60, 59, 55, 49, 40, 31, 22, 14,
10, 7, 6, 6, 7, 6, 7, 5, 3, 1, 0, 0, 5, 14, 26, 40, 55, 69, 81, 89, 92, 89, 82,
69, 52, 31, 10, -8, -25, -40, -49, -54, -56, -54, -48, -39, -30, -18, -5, 10,
24, 38, 51, 62, 70, 73, 72, 67, 58, 46, 32, 15, -1, -15, -28, -38, -44, -47,
-47, -43, -38, -32, -25, -17, -9, -4, 1, 6, 9, 12, 13, 14, 13, 11, 9, 6, 2, -3,
-8, -12, -17, -20, -23, -23, -21, -18, -13, -5, 3, 15, 27, 40, 53, 64, 74, 78,
82, 80, 74, 64, 51, 33, 14, -7, -28, -47, -64, -77, -88, -94, -95, -92, -85,
-77, -64, -50, -34, -17, -1, 14, 28, 38, 48, 55, 59, 61, 62, 62, 59, 56, 51, 48,
45, 42, 40, 38, 36, 33, 31, 27, 23, 18, 11, 3, -6, -15, -25, -35, -45, -54, -64,
-71, -78, -83, -86, -87, -86, -83, -78, -70, -60, -48, -34, -20, -3, 11, 28, 41,
55, 66, 77, 85, 91, 95, 98, 98, 95, 93, 86, 78, 70, 59, 46, 34, 20, 6, -9, -23,
-35, -49, -61, -72, -81, -90, -96, -100, -104, -105, -104, -101, -96, -89, -81,
-70, -60, -48, -35, -21, -7, 7, 21, 34, 46, 57, 67, 75, 80, 83, 86, 86, 85, 81,
78, 72, 65, 58, 47, 38, 27, 17, 6, -5, -13, -22, -29, -35, -40, -43, -47, -46,
-48, -45, -43, -39, -35, -29, -23, -15, -8, 0, 10, 19, 28, 37, 45, 52, 59, 63,
68, 71, 74, 75, 75, 74, 72, 68, 63, 58, 51, 45, 37, 29, 21, 13, 4, -5, -12, -21,
-26, -32, -36, -40, -42, -44, -45, -47, -49, -51, -53, -54, -55, -56, -56, -54,
-53, -52, -51, -50, -51, -51, -50, -50, -49, -50, -49, -50, -49, -50, -50, -49,
-49, -48, -49, -49, -51, -53, -56, -57, -59, -63, -64, -67, -67, -67, -66, -64,
-61, -58, -53, -50, -46, -44, -44, -43, -42, -41, -38, -33, -27, -19, -10, -2,
};