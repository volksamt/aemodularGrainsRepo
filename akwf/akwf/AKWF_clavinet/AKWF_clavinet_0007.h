#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 15, 22, 28, 35, 42, 49, 54, 57, 61,
63, 63, 61, 60, 55, 51, 46, 41, 36, 33, 30, 29, 32, 36, 42, 50, 61, 70, 82, 92,
101, 109, 114, 118, 119, 118, 116, 112, 106, 97, 89, 79, 69, 58, 48, 38, 31, 24,
18, 15, 12, 12, 12, 11, 12, 13, 15, 15, 16, 17, 17, 17, 18, 17, 17, 17, 19, 18,
19, 21, 22, 23, 23, 25, 25, 24, 24, 22, 20, 17, 13, 7, 0, -7, -16, -24, -33,
-43, -53, -61, -71, -78, -84, -91, -95, -97, -99, -100, -98, -97, -94, -88, -83,
-77, -69, -60, -52, -42, -34, -24, -15, -8, 1, 7, 13, 17, 20, 23, 24, 23, 22,
20, 15, 10, 5, -2, -10, -18, -27, -36, -44, -52, -59, -67, -72, -76, -79, -82,
-81, -82, -80, -76, -71, -65, -57, -49, -40, -28, -18, -7, 4, 15, 26, 34, 44,
51, 58, 64, 67, 70, 72, 71, 70, 67, 63, 57, 52, 44, 36, 28, 19, 10, 2, -8, -15,
-24, -30, -37, -43, -47, -50, -53, -54, -54, -52, -49, -45, -42, -35, -29, -22,
-15, -7, 0, 7, 14, 22, 29, 34, 39, 43, 47, 48, 51, 51, 50, 49, 46, 43, 40, 35,
31, 26, 22, 16, 11, 7, 2, -2, -5, -10, -14, -16, -18, -20, -20, -22, -21, -21,
-21, -20, -17, -17, -14, -12, -11, -7, -5, -1, 2, 5, 9, 12, 15, 18, 20, 22, 23,
24, 23, 23, 21, 20, 18, 17, 15, 13, 12, 10, 8, 6, 3, 1, -2, -5, -7, -10, -12,
-13, -13, -13, -12, -10, -8, -7, -6, -5, -4, -5, -5, -4, -5, -3, -2, -1, 2, 3,
4, 6, 6, 6, 6, 7, 8, 9, 11, 13, 15, 18, 19, 19, 18, 17, 15, 12, 9, 6, 5, 3, 3,
4, 5, 9, 12, 14, 16, 17, 16, 14, 12, 8, 5, 1, -1, -3, -3, -3, -1, 0, 0, 0, 0,
-1, -3, -5, -9, -13, -15, -16, -16, -17, -17, -15, -14, -13, -13, -13, -15, -16,
-18, -20, -23, -25, -26, -27, -27, -28, -27, -26, -25, -23, -22, -19, -15, -11,
-7, -3, 1, 4, 7, 9, 7, 5, 3, -1, -6, -11, -15, -19, -21, -22, -20, -16, -10, -3,
4, 12, 20, 28, 32, 35, 37, 36, 33, 28, 23, 18, 12, 8, 5, 3, 4, 5, 8, 11, 14, 20,
24, 28, 34, 39, 44, 49, 55, 58, 61, 60, 60, 56, 52, 47, 40, 34, 27, 21, 16, 12,
10, 9, 7, 8, 8, 10, 11, 12, 15, 17, 19, 21, 24, 26, 27, 27, 25, 23, 17, 10, -1,
-13, -25, -38, -49, -60, -67, -72, -75, -73, -69, -64, -56, -49, -41, -34, -28,
-23, -20, -18, -18, -19, -24, -29, -35, -43, -53, -62, -71, -79, -86, -91, -95,
-95, -93, -91, -87, -80, -74, -66, -60, -53, -47, -41, -37, -34, -31, -29, -29,
-29, -29, -30, -30, -30, -32, -32, -33, -32, -30, -28, -25, -20, -16, -8, -1, };