#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0031

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 18, 28, 36, 41, 44, 46, 44, 42, 41,
39, 40, 40, 43, 47, 53, 59, 67, 76, 86, 96, 104, 110, 113, 113, 109, 105, 99,
93, 86, 78, 70, 63, 54, 47, 40, 34, 30, 28, 29, 30, 32, 33, 36, 39, 43, 48, 54,
62, 69, 77, 86, 93, 99, 104, 111, 114, 118, 119, 119, 115, 108, 97, 85, 69, 53,
36, 20, 5, -8, -20, -29, -38, -45, -50, -54, -57, -60, -63, -66, -69, -72, -75,
-79, -82, -83, -83, -80, -77, -70, -66, -60, -55, -51, -49, -47, -46, -46, -46,
-48, -49, -53, -55, -59, -63, -65, -67, -69, -71, -73, -73, -73, -74, -74, -74,
-75, -75, -76, -77, -81, -84, -88, -91, -93, -95, -95, -92, -90, -84, -78, -73,
-67, -63, -61, -58, -56, -53, -51, -49, -46, -45, -41, -38, -32, -27, -19, -12,
-5, 0, 4, 8, 12, 13, 16, 18, 20, 19, 18, 18, 18, 19, 19, 22, 25, 28, 31, 34, 38,
40, 42, 43, 41, 38, 36, 33, 29, 25, 20, 15, 13, 9, 8, 8, 8, 10, 13, 15, 17, 20,
20, 20, 19, 16, 12, 9, 6, 3, 0, 0, 2, 5, 10, 19, 26, 34, 41, 47, 50, 49, 46, 43,
36, 30, 24, 18, 13, 8, 5, 4, 5, 6, 7, 10, 13, 15, 15, 13, 11, 5, -2, -11, -18,
-26, -31, -35, -36, -35, -32, -26, -17, -10, 0, 8, 15, 22, 25, 27, 26, 22, 18,
13, 9, 6, 4, 3, 4, 6, 9, 14, 18, 24, 29, 34, 37, 39, 37, 33, 27, 20, 12, 5, 0,
-4, -6, -5, -3, 2, 6, 10, 16, 19, 21, 22, 21, 18, 14, 7, 1, -6, -11, -14, -16,
-17, -14, -11, -6, -2, 3, 8, 11, 15, 17, 18, 16, 13, 8, 2, -3, -8, -12, -13,
-14, -13, -11, -8, -3, 1, 6, 9, 11, 13, 13, 11, 10, 7, 4, -2, -6, -12, -15, -20,
-22, -22, -21, -19, -18, -15, -13, -9, -7, -4, -1, 1, 2, 3, 4, 3, 1, 0, -1, -2,
-2, -1, -1, -1, 0, -2, -2, -2, -3, -3, -5, -6, -8, -9, -11, -14, -16, -18, -18,
-19, -18, -16, -12, -8, -3, 4, 11, 17, 26, 34, 41, 48, 54, 56, 58, 58, 55, 50,
45, 39, 31, 25, 17, 9, 1, -6, -12, -18, -24, -29, -34, -38, -43, -47, -51, -54,
-56, -57, -56, -52, -46, -40, -30, -20, -8, 5, 17, 29, 40, 51, 59, 64, 67, 67,
65, 59, 51, 41, 32, 21, 12, 4, -4, -11, -15, -20, -22, -25, -28, -31, -33, -37,
-40, -44, -48, -52, -56, -60, -61, -61, -59, -55, -49, -42, -33, -25, -18, -11,
-6, -1, 1, 3, 3, 1, -2, -6, -10, -14, -16, -17, -17, -15, -11, -8, -5, -1, 1, 3,
5, 5, 3, 0, -3, -8, -13, -19, -23, -27, -31, -33, -34, -33, -32, -31, -30, -29,
-30, -32, -34, -36, -38, -40, -42, -42, -41, -39, -36, -30, -22, -12, -2, };