#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 13, 18, 21, 22, 20, 20, 19, 18, 20,
21, 25, 29, 33, 39, 45, 53, 62, 71, 78, 86, 91, 92, 90, 87, 84, 81, 78, 75, 72,
68, 63, 58, 52, 48, 46, 46, 47, 48, 49, 51, 52, 53, 55, 59, 64, 69, 75, 81, 86,
92, 97, 102, 107, 111, 115, 117, 119, 119, 115, 110, 101, 90, 78, 66, 55, 44,
34, 27, 18, 13, 7, 1, -2, -7, -10, -14, -17, -21, -26, -31, -37, -41, -45, -48,
-47, -46, -44, -41, -39, -36, -35, -35, -36, -37, -38, -38, -40, -42, -45, -49,
-52, -55, -59, -61, -63, -64, -66, -68, -69, -71, -72, -73, -72, -74, -75, -78,
-80, -83, -88, -91, -95, -97, -98, -98, -96, -93, -89, -85, -82, -79, -79, -77,
-77, -75, -74, -73, -70, -69, -68, -65, -61, -57, -52, -46, -38, -34, -30, -27,
-25, -21, -19, -16, -15, -13, -13, -12, -12, -11, -8, -6, -2, 2, 5, 8, 13, 15,
18, 20, 20, 20, 18, 17, 15, 13, 10, 8, 6, 4, 3, 3, 5, 7, 9, 12, 14, 16, 17, 18,
16, 13, 13, 9, 7, 3, 2, 2, 2, 5, 9, 15, 23, 28, 35, 39, 42, 43, 41, 38, 34, 28,
25, 20, 16, 14, 14, 12, 12, 13, 15, 18, 19, 20, 21, 21, 19, 15, 9, 3, -5, -11,
-15, -18, -21, -21, -18, -14, -11, -4, 3, 8, 14, 18, 21, 22, 21, 19, 15, 12, 8,
5, 4, 5, 4, 7, 9, 12, 16, 21, 24, 29, 32, 34, 34, 32, 27, 21, 16, 10, 6, 4, 2,
3, 5, 8, 12, 15, 18, 21, 23, 24, 23, 21, 18, 13, 8, 3, -1, -5, -7, -7, -6, -2,
1, 4, 7, 10, 13, 17, 17, 18, 17, 14, 10, 7, 3, -3, -5, -8, -8, -7, -5, -2, 0, 4,
6, 9, 11, 11, 12, 11, 10, 8, 6, 2, -2, -5, -8, -12, -14, -15, -14, -13, -12,
-10, -7, -7, -6, -5, -2, 0, 2, 2, 1, 1, -1, -2, -4, -5, -3, -2, -2, -2, -2, -2,
-2, -3, -4, -4, -4, -5, -6, -8, -9, -12, -13, -15, -16, -16, -15, -14, -13, -10,
-7, -2, 2, 8, 13, 20, 27, 32, 36, 40, 42, 42, 40, 38, 36, 31, 29, 24, 20, 15, 9,
4, 0, -5, -9, -12, -16, -20, -23, -27, -31, -35, -37, -39, -40, -39, -37, -32,
-27, -21, -12, -4, 6, 14, 22, 30, 37, 42, 44, 46, 45, 42, 36, 31, 25, 19, 12, 7,
2, -2, -5, -8, -9, -12, -14, -16, -18, -21, -24, -28, -32, -36, -39, -43, -46,
-47, -47, -45, -42, -37, -31, -27, -22, -17, -14, -12, -9, -8, -8, -9, -11, -14,
-18, -20, -23, -23, -23, -21, -17, -15, -11, -9, -7, -5, -4, -4, -4, -7, -9,
-12, -17, -21, -23, -27, -29, -32, -32, -31, -32, -30, -30, -28, -29, -31, -33,
-35, -38, -40, -41, -42, -43, -41, -40, -37, -32, -26, -18, -8, 0, };