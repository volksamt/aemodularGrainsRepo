#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 4, 4, 5, 7, 7, 8, 9, 9, 9, 9,
9, 10, 11, 13, 14, 16, 16, 19, 20, 19, 20, 20, 19, 19, 20, 21, 22, 24, 24, 25,
25, 26, 25, 25, 25, 25, 26, 27, 27, 28, 28, 29, 29, 28, 25, 24, 23, 20, 17, 16,
14, 12, 11, 9, 6, 5, 4, 4, 2, 2, 2, 2, 1, 0, 0, -1, 0, 2, 2, 3, 3, 3, 2, 0, -2,
-2, -2, -2, -3, -3, -3, -3, -3, -2, -2, -2, -1, 1, 2, 1, 1, -1, -1, -1, -2, -2,
-2, -2, -2, -1, 0, -1, -4, -6, -9, -9, -9, -9, -7, -5, 0, 3, 3, 0, -1, -1, 1, 2,
1, 2, 2, 5, 5, 3, 3, 3, 5, 8, 10, 10, 8, 5, 4, 0, 0, -1, 1, 2, 3, 4, 5, 7, 11,
13, 15, 15, 11, 9, 2, -4, -10, -13, -12, -9, -4, 2, 5, 9, 11, 12, 10, 4, -4,
-10, -11, -10, -6, 0, 4, 9, 12, 8, 1, -11, -19, -23, -21, -17, -11, -2, 6, 13,
17, 18, 16, 14, 11, 6, 0, -7, -17, -24, -27, -26, -22, -12, -2, 7, 13, 16, 14,
10, 2, -4, -11, -14, -15, -13, -9, -1, 7, 16, 24, 30, 29, 25, 15, 4, -7, -15,
-24, -31, -33, -33, -29, -21, -14, -6, 1, 9, 13, 14, 12, 10, 7, 8, 10, 13, 14,
12, 8, 0, -10, -20, -29, -36, -38, -35, -29, -21, -9, 5, 21, 37, 52, 62, 68, 68,
64, 56, 46, 37, 25, 12, -1, -17, -29, -40, -47, -50, -49, -47, -41, -35, -29,
-23, -20, -17, -14, -10, -5, 3, 13, 24, 37, 50, 60, 66, 67, 63, 54, 42, 29, 18,
10, 7, 6, 10, 13, 15, 14, 11, 7, 2, -2, -5, -6, -6, -6, -8, -9, -12, -18, -26,
-34, -45, -58, -70, -84, -96, -107, -115, -119, -118, -111, -98, -78, -56, -31,
-9, 10, 27, 41, 49, 53, 53, 50, 46, 43, 41, 38, 35, 28, 21, 8, -5, -22, -37,
-51, -61, -70, -73, -74, -72, -69, -65, -60, -55, -51, -48, -46, -44, -42, -41,
-37, -33, -27, -20, -12, -5, 4, 12, 20, 27, 32, 37, 43, 49, 56, 64, 73, 82, 91,
100, 108, 114, 115, 116, 114, 110, 104, 94, 82, 66, 52, 33, 19, 5, -5, -11, -16,
-18, -16, -12, -5, 2, 12, 22, 33, 42, 51, 57, 60, 63, 64, 63, 62, 63, 63, 62,
63, 62, 63, 63, 63, 62, 61, 59, 57, 54, 49, 45, 40, 33, 26, 19, 10, 3, -6, -15,
-23, -30, -37, -42, -46, -50, -53, -54, -55, -54, -54, -53, -51, -50, -49, -48,
-47, -46, -44, -44, -42, -40, -39, -40, -40, -41, -43, -44, -46, -49, -50, -50,
-52, -52, -54, -54, -55, -54, -55, -55, -56, -57, -56, -56, -55, -55, -54, -51,
-49, -48, -46, -44, -41, -39, -36, -34, -32, -29, -24, -21, -19, -15, -12, -8,
-6, -4, -4, -1, 0, };