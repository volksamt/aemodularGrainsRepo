#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {14, 36, 53, 68, 78, 83, 83, 79, 73,
71, 71, 75, 80, 86, 94, 100, 102, 104, 102, 97, 90, 82, 75, 73, 74, 78, 84, 88,
89, 87, 81, 69, 56, 39, 22, 8, -4, -10, -16, -17, -17, -14, -12, -8, -5, 0, 6,
12, 21, 32, 46, 60, 75, 87, 96, 102, 106, 106, 103, 95, 85, 72, 56, 37, 17, 1,
-13, -23, -30, -34, -38, -39, -40, -39, -39, -40, -42, -43, -46, -49, -54, -59,
-64, -67, -71, -74, -78, -80, -80, -79, -75, -72, -66, -61, -53, -47, -43, -39,
-37, -36, -36, -36, -37, -38, -40, -41, -43, -48, -49, -52, -55, -58, -60, -62,
-63, -63, -62, -60, -58, -55, -53, -49, -45, -42, -39, -37, -34, -31, -28, -24,
-21, -18, -16, -12, -7, -4, -1, 3, 4, 5, 7, 7, 9, 9, 10, 13, 16, 19, 20, 20, 20,
19, 19, 17, 17, 16, 17, 17, 18, 17, 17, 17, 19, 21, 20, 20, 21, 23, 23, 25, 24,
25, 28, 29, 30, 30, 29, 28, 29, 28, 27, 26, 25, 26, 25, 23, 24, 24, 23, 23, 20,
19, 17, 17, 15, 13, 12, 11, 11, 10, 8, 6, 5, 3, 2, -1, -4, -6, -8, -8, -8, -7,
-6, -5, -5, -4, -4, -3, -5, -4, -3, -1, 1, 1, 2, 2, 3, 4, 2, -1, -3, -3, -3, -3,
-5, -6, -5, -3, -3, -4, -4, -2, -1, -2, -3, -3, -2, 0, 1, 0, -1, -2, -2, -1, -1,
-1, -3, -1, -1, -2, -4, -5, -4, -1, 1, 3, 5, 8, 8, 7, 7, 6, 8, 10, 11, 10, 9, 6,
8, 8, 7, 6, 4, 5, 6, 6, 5, 2, -1, -1, 0, 1, 3, 2, 1, 2, 5, 8, 8, 3, -3, -3, -3,
-4, -6, -7, -3, 4, 6, 2, -3, -7, -6, -5, -5, -6, -7, -6, -4, -3, -5, -5, -3, 1,
5, 8, 7, 5, 1, -4, -9, -11, -12, -10, -8, -9, -8, -5, 0, 6, 10, 13, 14, 12, 7,
0, -7, -14, -18, -18, -12, -6, -1, 1, 3, 6, 8, 6, -2, -10, -13, -9, 0, 7, 13,
19, 26, 27, 21, 5, -14, -26, -31, -31, -30, -27, -19, -8, 2, 7, 9, 9, 10, 12,
11, 6, 1, -4, -9, -10, -6, 2, 14, 26, 35, 40, 39, 35, 25, 12, -1, -13, -21, -24,
-21, -15, -7, 5, 19, 34, 44, 49, 46, 39, 32, 22, 12, 1, -11, -21, -28, -32, -37,
-41, -44, -46, -45, -42, -37, -32, -23, -9, 12, 35, 58, 75, 87, 92, 90, 82, 72,
60, 48, 34, 19, 0, -16, -31, -41, -47, -50, -49, -50, -53, -56, -59, -61, -62,
-62, -62, -60, -58, -57, -57, -59, -60, -61, -58, -55, -50, -47, -46, -47, -49,
-54, -58, -61, -59, -52, -41, -25, -7, 15, 35, 51, 62, 67, 66, 61, 53, 44, 37,
32, 26, 21, 10, -4, -25, -45, -65, -84, -100, -112, -119, -118, -111, -96, -80,
-61, -41, -19, -1, };