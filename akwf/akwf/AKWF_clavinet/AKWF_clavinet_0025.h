#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 9, 16, 23, 30, 37, 44, 50, 55, 60,
65, 69, 73, 75, 79, 80, 82, 83, 83, 83, 81, 79, 75, 71, 68, 64, 60, 56, 54, 54,
53, 55, 57, 60, 65, 70, 75, 81, 85, 89, 95, 99, 101, 103, 104, 105, 107, 107,
108, 108, 108, 108, 106, 104, 101, 96, 90, 84, 75, 65, 54, 43, 32, 21, 10, 0,
-8, -17, -22, -26, -28, -29, -28, -26, -23, -20, -15, -9, -3, 3, 9, 15, 20, 27,
34, 39, 44, 48, 52, 55, 56, 57, 56, 52, 49, 44, 36, 31, 23, 16, 9, 2, -4, -9,
-14, -19, -22, -25, -28, -31, -32, -33, -34, -34, -33, -31, -27, -24, -20, -15,
-9, -3, 4, 9, 15, 20, 23, 26, 27, 28, 29, 26, 24, 20, 16, 10, 5, -2, -9, -15,
-22, -29, -35, -42, -48, -52, -57, -61, -64, -66, -66, -66, -65, -63, -60, -58,
-53, -48, -44, -39, -34, -30, -26, -22, -19, -17, -14, -13, -10, -10, -9, -8,
-8, -9, -9, -12, -13, -17, -19, -23, -28, -34, -38, -44, -49, -52, -56, -58,
-60, -60, -61, -60, -57, -55, -52, -48, -44, -39, -35, -30, -25, -20, -16, -10,
-7, -1, 2, 6, 11, 14, 17, 19, 22, 24, 23, 23, 22, 21, 19, 16, 14, 11, 8, 5, 4,
1, -2, -4, -6, -7, -9, -12, -14, -15, -16, -17, -17, -17, -16, -13, -10, -6, -1,
5, 11, 16, 22, 29, 33, 37, 40, 43, 43, 45, 44, 44, 42, 39, 38, 36, 34, 31, 29,
26, 25, 23, 20, 17, 15, 12, 10, 8, 6, 5, 3, 2, 1, 2, 2, 2, 3, 3, 4, 5, 6, 7, 8,
10, 11, 12, 14, 16, 16, 16, 17, 17, 17, 16, 15, 13, 9, 6, 3, -1, -6, -11, -15,
-19, -23, -26, -29, -32, -34, -34, -36, -35, -34, -34, -32, -30, -29, -25, -24,
-21, -18, -16, -14, -12, -11, -9, -8, -8, -8, -8, -7, -7, -8, -9, -9, -9, -10,
-11, -12, -13, -14, -16, -17, -20, -23, -25, -28, -30, -33, -35, -37, -39, -38,
-37, -38, -35, -33, -29, -24, -20, -15, -8, -2, 3, 11, 16, 21, 27, 32, 36, 41,
44, 48, 49, 52, 54, 55, 55, 55, 55, 52, 51, 48, 45, 42, 38, 35, 32, 27, 24, 22,
19, 18, 16, 15, 15, 16, 16, 18, 20, 22, 26, 29, 34, 39, 45, 51, 56, 64, 70, 77,
82, 89, 93, 96, 99, 98, 97, 95, 91, 86, 79, 71, 62, 53, 44, 34, 24, 15, 5, -4,
-13, -20, -28, -35, -42, -47, -52, -55, -59, -61, -64, -64, -65, -65, -63, -63,
-61, -60, -59, -57, -56, -55, -56, -56, -57, -59, -60, -62, -66, -68, -72, -77,
-80, -83, -86, -90, -93, -95, -98, -100, -103, -106, -108, -110, -112, -115,
-116, -118, -119, -119, -118, -117, -114, -111, -107, -102, -98, -92, -87, -81,
-76, -71, -66, -62, -58, -54, -51, -49, -45, -42, -38, -34, -29, -25, -18, -12,
-5, };