#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 5, 7, 9, 10, 11, 14, 14, 16, 17,
20, 20, 23, 23, 26, 26, 28, 30, 30, 31, 34, 34, 36, 37, 38, 40, 40, 42, 43, 44,
45, 46, 48, 49, 50, 51, 52, 53, 54, 55, 56, 58, 58, 60, 60, 61, 61, 63, 65, 65,
66, 66, 69, 68, 70, 71, 71, 72, 72, 74, 74, 76, 76, 77, 78, 79, 80, 80, 81, 82,
83, 84, 84, 86, 86, 86, 88, 89, 89, 89, 90, 91, 92, 93, 94, 95, 94, 96, 96, 97,
97, 98, 99, 100, 100, 101, 100, 101, 101, 102, 103, 104, 104, 105, 104, 105,
106, 106, 106, 106, 107, 108, 108, 108, 109, 108, 109, 109, 109, 110, 109, 109,
109, 110, 109, 109, 110, 109, 110, 109, 109, 109, 109, 109, 109, 108, 108, 107,
106, 107, 107, 106, 106, 106, 105, 105, 104, 104, 103, 103, 102, 102, 101, 100,
99, 99, 98, 97, 97, 96, 96, 95, 94, 93, 93, 93, 92, 91, 90, 89, 88, 87, 88, 87,
85, 85, 84, 84, 82, 81, 81, 79, 79, 78, 77, 76, 76, 74, 74, 73, 73, 72, 71, 70,
69, 69, 68, 66, 66, 65, 65, 64, 63, 62, 62, 60, 59, 59, 58, 57, 57, 55, 55, 54,
53, 52, 51, 50, 51, 50, 48, 48, 47, 47, 46, 45, 45, 44, 42, 42, 41, 40, 40, 39,
38, 38, 37, 36, 36, 34, 34, 33, 32, 30, 30, 29, 28, 28, 27, 25, 25, 24, 24, 21,
20, 20, 19, 17, 16, 17, 15, 14, 12, 11, 10, 9, 8, 7, 6, 5, 3, 2, 1, 0, -2, -2,
-5, -6, -7, -8, -9, -11, -12, -14, -14, -17, -18, -19, -21, -22, -24, -25, -26,
-28, -29, -30, -32, -33, -35, -36, -38, -39, -41, -42, -43, -44, -47, -48, -49,
-51, -52, -53, -55, -55, -57, -59, -60, -61, -62, -64, -64, -67, -67, -68, -70,
-71, -71, -74, -75, -75, -76, -78, -78, -80, -80, -81, -83, -83, -85, -86, -87,
-88, -89, -89, -90, -92, -92, -93, -93, -94, -95, -96, -96, -97, -98, -99, -99,
-101, -101, -102, -103, -103, -103, -105, -105, -105, -105, -107, -107, -108,
-108, -108, -110, -109, -110, -111, -111, -112, -112, -112, -112, -113, -114,
-114, -114, -115, -114, -115, -115, -115, -116, -116, -117, -118, -118, -118,
-118, -119, -118, -118, -119, -118, -118, -119, -119, -119, -119, -118, -119,
-119, -118, -119, -119, -119, -119, -119, -118, -119, -118, -118, -118, -118,
-117, -116, -116, -116, -117, -115, -114, -115, -114, -114, -112, -113, -112,
-112, -111, -110, -110, -108, -108, -107, -107, -105, -105, -104, -103, -102,
-101, -99, -98, -97, -96, -95, -94, -93, -92, -91, -88, -87, -86, -84, -84, -82,
-80, -78, -78, -76, -75, -73, -72, -70, -68, -67, -65, -63, -61, -60, -58, -57,
-54, -53, -51, -49, -47, -45, -44, -41, -39, -38, -37, -35, -33, -31, -29, -27,
-25, -23, -22, -19, -18, -15, -14, -12, -11, -9, -7, -5, -3, -2, 1, };