#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0033

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 13, 20, 29, 37, 45, 52, 57, 62, 66,
70, 73, 75, 78, 81, 85, 89, 92, 96, 99, 103, 104, 106, 108, 108, 107, 105, 103,
101, 98, 94, 92, 88, 85, 82, 80, 77, 76, 75, 76, 77, 78, 80, 81, 83, 82, 82, 81,
79, 77, 77, 75, 74, 75, 77, 79, 82, 88, 91, 96, 101, 105, 108, 111, 112, 114,
113, 111, 109, 104, 98, 92, 84, 76, 68, 61, 52, 45, 37, 31, 25, 21, 16, 11, 7,
3, 0, -4, -8, -10, -14, -15, -16, -15, -14, -12, -9, -4, 1, 7, 11, 17, 22, 25,
28, 29, 26, 24, 19, 13, 5, -3, -14, -24, -34, -42, -52, -60, -66, -72, -76, -80,
-82, -83, -82, -81, -80, -77, -76, -73, -71, -70, -67, -64, -63, -60, -59, -57,
-55, -52, -51, -48, -46, -44, -41, -40, -39, -38, -39, -39, -39, -40, -42, -44,
-47, -50, -54, -57, -61, -65, -70, -74, -78, -80, -83, -85, -86, -87, -86, -85,
-84, -81, -78, -74, -70, -65, -60, -55, -50, -45, -39, -35, -30, -26, -22, -17,
-13, -10, -8, -5, -4, -1, 0, 0, -2, -3, -5, -8, -12, -16, -19, -24, -29, -33,
-37, -40, -42, -44, -44, -43, -40, -36, -31, -24, -18, -9, -1, 7, 16, 23, 29,
36, 41, 45, 47, 49, 50, 50, 49, 47, 43, 41, 36, 32, 29, 24, 20, 15, 12, 8, 4,
-1, -4, -8, -11, -14, -16, -18, -17, -18, -16, -14, -9, -3, 3, 9, 18, 26, 35,
45, 53, 60, 68, 75, 79, 82, 84, 84, 82, 79, 75, 70, 62, 56, 48, 40, 32, 24, 16,
9, 1, -6, -13, -20, -26, -33, -41, -47, -52, -57, -62, -65, -66, -67, -65, -60,
-54, -45, -35, -22, -9, 5, 20, 35, 49, 63, 76, 88, 98, 105, 112, 115, 117, 116,
113, 108, 102, 93, 85, 73, 62, 51, 41, 30, 19, 9, 1, -8, -16, -23, -29, -34,
-37, -39, -39, -37, -32, -26, -18, -9, 2, 12, 23, 34, 44, 53, 61, 67, 71, 74,
74, 74, 72, 68, 63, 57, 50, 44, 35, 30, 23, 17, 11, 7, 4, 0, -2, -5, -6, -7, -8,
-9, -8, -8, -8, -7, -6, -6, -4, -2, 0, 1, 3, 5, 7, 9, 13, 16, 19, 22, 23, 25,
25, 25, 24, 21, 19, 14, 9, 3, -3, -11, -20, -29, -39, -50, -61, -72, -82, -93,
-101, -107, -111, -111, -112, -110, -105, -100, -93, -85, -76, -68, -58, -48,
-39, -28, -20, -11, -3, 3, 7, 11, 12, 11, 9, 5, 1, -5, -12, -19, -28, -37, -45,
-54, -64, -73, -82, -91, -99, -105, -110, -114, -117, -119, -119, -119, -118,
-116, -114, -112, -109, -105, -102, -97, -91, -86, -80, -73, -66, -60, -53, -46,
-40, -33, -27, -20, -14, -8, -4, 1, 2, 5, 6, 5, 3, 2, -1, -5, -7, -11, -13, -16,
-20, -24, -27, -30, -34, -38, -41, -45, -46, -48, -47, -46, -44, -40, -36, -31,
-25, -18, -10, -3, };