#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 17, 26, 34, 42, 47, 52, 55, 56, 57,
55, 53, 51, 47, 44, 40, 37, 34, 30, 26, 23, 20, 17, 15, 14, 13, 14, 17, 19, 24,
28, 33, 38, 43, 49, 54, 60, 65, 70, 75, 81, 85, 91, 95, 99, 102, 104, 105, 105,
105, 105, 105, 104, 101, 99, 96, 92, 89, 85, 81, 76, 71, 67, 61, 57, 51, 47, 43,
39, 37, 35, 33, 30, 28, 24, 22, 18, 17, 13, 11, 9, 6, 3, -1, -4, -8, -12, -15,
-19, -23, -26, -30, -34, -36, -38, -43, -45, -48, -50, -53, -54, -56, -58, -62,
-65, -69, -74, -78, -81, -81, -82, -82, -81, -81, -81, -82, -82, -83, -83, -80,
-79, -75, -73, -70, -68, -65, -62, -59, -55, -53, -50, -50, -50, -51, -51, -51,
-50, -49, -47, -46, -44, -40, -37, -34, -31, -27, -24, -22, -22, -23, -23, -25,
-25, -23, -20, -16, -8, -1, 6, 12, 15, 15, 10, 7, 2, -1, -1, 1, 8, 18, 28, 35,
41, 42, 41, 37, 33, 29, 28, 29, 32, 35, 38, 40, 40, 39, 37, 34, 31, 26, 21, 17,
14, 13, 16, 21, 26, 33, 39, 44, 44, 40, 34, 23, 13, 3, -6, -10, -12, -8, -1, 8,
19, 29, 34, 35, 35, 28, 20, 11, 2, -5, -9, -11, -8, -5, 0, 7, 11, 15, 15, 12, 6,
0, -8, -13, -17, -17, -15, -11, -6, -3, 2, 5, 7, 7, 7, 7, 3, 1, -1, -3, -6, -7,
-8, -10, -13, -18, -22, -25, -26, -25, -19, -12, -2, 9, 18, 25, 31, 35, 36, 36,
35, 30, 23, 14, 4, -9, -21, -33, -42, -46, -45, -40, -30, -14, 4, 23, 39, 49,
54, 52, 47, 38, 29, 20, 12, 6, 1, -2, -7, -13, -19, -26, -31, -35, -36, -32,
-26, -18, -8, 4, 16, 26, 36, 43, 48, 49, 48, 41, 32, 20, 7, -7, -19, -28, -34,
-38, -39, -40, -39, -41, -43, -45, -47, -47, -44, -36, -23, -6, 15, 37, 56, 73,
82, 87, 83, 73, 57, 40, 22, 5, -9, -22, -33, -40, -45, -46, -46, -43, -41, -37,
-33, -28, -24, -17, -9, -2, 5, 10, 13, 13, 10, 5, -3, -13, -22, -30, -35, -38,
-37, -33, -26, -15, -2, 11, 25, 38, 47, 57, 64, 68, 70, 72, 71, 68, 64, 56, 46,
35, 20, 5, -14, -32, -51, -67, -82, -93, -102, -107, -108, -106, -100, -89, -75,
-56, -36, -13, 10, 30, 49, 65, 77, 85, 90, 92, 89, 86, 79, 72, 66, 59, 54, 52,
51, 51, 52, 54, 55, 57, 55, 53, 48, 40, 30, 19, 5, -8, -25, -40, -55, -70, -81,
-91, -99, -104, -105, -104, -99, -91, -81, -68, -55, -39, -25, -10, 3, 14, 25,
34, 41, 47, 50, 52, 52, 50, 46, 41, 32, 24, 14, 3, -9, -20, -33, -43, -54, -64,
-74, -84, -91, -98, -105, -109, -115, -117, -118, -119, -118, -116, -111, -106,
-99, -91, -81, -73, -61, -50, -36, -25, -12, -3, };