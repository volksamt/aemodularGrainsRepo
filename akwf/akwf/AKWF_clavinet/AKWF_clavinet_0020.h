#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 12, 22, 33, 44, 51, 57, 58, 56, 51,
48, 43, 40, 36, 31, 25, 20, 16, 14, 14, 19, 24, 34, 45, 58, 70, 81, 91, 98, 103,
104, 101, 93, 83, 71, 61, 54, 53, 56, 64, 76, 88, 99, 107, 111, 111, 107, 103,
98, 94, 90, 85, 80, 74, 70, 66, 63, 60, 58, 57, 56, 55, 53, 51, 45, 41, 35, 29,
24, 19, 14, 9, 4, 1, 0, 0, 3, 7, 13, 18, 20, 19, 16, 7, -4, -19, -32, -46, -56,
-63, -65, -63, -54, -42, -27, -13, 1, 10, 13, 10, -1, -17, -36, -56, -72, -84,
-91, -90, -84, -74, -59, -44, -27, -12, -1, 6, 9, 10, 7, -1, -9, -19, -28, -35,
-40, -41, -39, -35, -29, -23, -15, -9, -2, 0, 2, 1, -2, -7, -15, -24, -33, -39,
-42, -43, -40, -35, -27, -18, -9, 0, 6, 9, 10, 7, 2, -7, -15, -24, -32, -38,
-40, -38, -32, -21, -9, 4, 15, 24, 31, 33, 33, 28, 22, 12, 0, -10, -19, -26,
-30, -30, -28, -23, -14, -5, 2, 9, 12, 12, 9, 4, -2, -10, -17, -22, -25, -26,
-25, -23, -18, -14, -10, -5, -1, 1, 3, 5, 7, 9, 11, 13, 14, 15, 14, 13, 10, 7,
4, 1, 0, 0, 0, 2, 5, 9, 15, 18, 21, 22, 19, 13, 6, -2, -9, -14, -18, -20, -18,
-17, -13, -10, -7, -6, -4, -4, -4, -4, -3, -1, 2, 6, 12, 18, 21, 24, 24, 21, 16,
9, 2, -3, -7, -8, -6, -2, 4, 9, 14, 15, 14, 9, 4, -2, -5, -7, -8, -6, -3, 1, 6,
11, 15, 18, 17, 16, 10, 4, -2, -8, -14, -15, -16, -15, -12, -10, -6, -4, -1, 1,
2, 4, 4, 6, 8, 7, 8, 8, 7, 5, 2, -1, -5, -7, -8, -8, -4, -1, 4, 11, 17, 23, 26,
27, 26, 22, 17, 11, 5, -1, -8, -14, -20, -25, -29, -34, -37, -37, -37, -37, -34,
-31, -27, -20, -14, -6, 1, 7, 12, 17, 21, 23, 25, 27, 28, 30, 31, 33, 33, 31,
31, 27, 22, 17, 11, 4, -1, -6, -11, -16, -21, -27, -32, -39, -45, -49, -53, -57,
-58, -58, -55, -50, -43, -36, -27, -18, -7, 3, 15, 26, 37, 47, 60, 70, 78, 86,
92, 95, 94, 91, 86, 76, 67, 55, 42, 28, 14, 0, -14, -26, -38, -48, -56, -62,
-65, -67, -66, -65, -59, -54, -46, -38, -29, -18, -9, 3, 16, 27, 39, 54, 66, 79,
90, 100, 107, 112, 115, 115, 113, 110, 102, 94, 84, 73, 62, 49, 37, 24, 13, 0,
-13, -26, -40, -54, -69, -84, -97, -106, -113, -117, -119, -117, -112, -107,
-97, -89, -78, -67, -54, -41, -26, -15, -5, 2, 6, 7, 7, 4, -3, -9, -17, -24,
-33, -40, -46, -50, -52, -54, -55, -60, -65, -73, -81, -90, -97, -102, -106,
-108, -110, -111, -113, -113, -113, -109, -104, -94, -81, -67, -53, -40, -30,
-22, -14, -5, };