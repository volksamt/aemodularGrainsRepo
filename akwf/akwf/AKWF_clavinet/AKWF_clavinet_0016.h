#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 16, 18, 20, 22, 23, 22, 22,
21, 20, 19, 17, 16, 16, 15, 14, 13, 13, 13, 12, 12, 10, 9, 8, 8, 7, 9, 10, 14,
19, 27, 35, 46, 56, 66, 77, 86, 95, 103, 110, 115, 117, 118, 119, 118, 118, 118,
117, 116, 116, 116, 116, 116, 115, 114, 111, 108, 106, 100, 94, 87, 78, 70, 61,
53, 48, 42, 39, 37, 38, 39, 42, 45, 49, 52, 55, 57, 59, 59, 58, 55, 53, 48, 44,
41, 39, 37, 36, 35, 34, 35, 36, 36, 38, 39, 38, 38, 36, 33, 29, 25, 18, 11, 3,
-5, -14, -24, -32, -41, -49, -58, -65, -72, -80, -85, -89, -94, -98, -100, -102,
-103, -103, -103, -102, -101, -98, -95, -92, -90, -88, -86, -84, -82, -81, -81,
-80, -78, -79, -78, -76, -76, -74, -72, -70, -68, -65, -63, -60, -56, -56, -54,
-54, -55, -55, -57, -56, -58, -60, -61, -62, -63, -64, -64, -64, -63, -62, -62,
-61, -60, -59, -57, -55, -52, -50, -45, -41, -36, -29, -24, -19, -13, -6, 0, 6,
11, 17, 20, 24, 27, 27, 27, 26, 25, 23, 21, 17, 15, 13, 9, 7, 3, 1, -2, -6, -8,
-11, -13, -15, -16, -17, -16, -15, -13, -9, -4, 1, 8, 13, 18, 24, 27, 31, 33,
34, 34, 31, 28, 23, 16, 9, 2, -4, -10, -16, -20, -23, -26, -27, -28, -27, -26,
-25, -25, -24, -22, -21, -18, -16, -13, -9, -4, 1, 7, 14, 19, 26, 32, 38, 44,
47, 48, 49, 47, 45, 41, 36, 30, 24, 18, 14, 11, 9, 8, 7, 8, 10, 12, 14, 16, 18,
18, 17, 16, 13, 11, 8, 7, 5, 6, 6, 8, 10, 16, 20, 26, 30, 36, 40, 42, 43, 45,
44, 42, 40, 36, 33, 31, 30, 28, 28, 28, 28, 30, 32, 34, 34, 35, 33, 31, 28, 23,
17, 11, 4, -1, -7, -13, -16, -18, -18, -18, -16, -14, -11, -9, -7, -7, -8, -10,
-14, -17, -21, -26, -30, -34, -36, -37, -36, -34, -29, -26, -20, -15, -9, -4, 0,
3, 5, 6, 7, 6, 6, 6, 7, 7, 10, 12, 15, 18, 22, 24, 27, 29, 28, 28, 25, 21, 17,
12, 7, 2, -3, -6, -10, -11, -13, -12, -10, -7, -4, -1, 3, 7, 11, 14, 18, 21, 23,
27, 28, 31, 33, 36, 39, 41, 45, 48, 49, 51, 52, 53, 53, 53, 51, 49, 46, 42, 39,
34, 30, 26, 22, 18, 14, 10, 7, 2, -3, -5, -10, -15, -18, -21, -26, -29, -34,
-35, -37, -39, -38, -38, -38, -36, -34, -31, -30, -27, -24, -22, -21, -19, -18,
-17, -17, -16, -16, -18, -18, -20, -22, -23, -27, -29, -33, -36, -39, -43, -45,
-48, -52, -54, -56, -57, -60, -63, -65, -67, -69, -71, -74, -75, -76, -76, -76,
-74, -72, -68, -65, -61, -56, -51, -46, -42, -38, -37, -33, -32, -30, -29, -29,
-27, -27, -26, -24, -22, -20, -16, -12, -7, -2, };