#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 12, 19, 23, 27, 29, 29, 26, 24, 20,
16, 12, 10, 9, 9, 12, 15, 21, 27, 33, 41, 49, 55, 61, 66, 71, 74, 77, 78, 79,
79, 80, 83, 86, 90, 95, 100, 107, 112, 116, 117, 118, 118, 115, 111, 104, 98,
91, 84, 79, 75, 70, 66, 63, 59, 55, 52, 47, 40, 35, 27, 21, 16, 12, 7, 3, 1, -1,
-1, -1, -1, 0, 1, 3, 5, 7, 8, 11, 12, 12, 12, 12, 13, 12, 12, 9, 9, 7, 6, 5, 3,
3, 1, -1, -3, -8, -11, -16, -21, -27, -31, -37, -40, -43, -44, -45, -46, -45,
-43, -42, -40, -37, -35, -33, -28, -24, -20, -16, -13, -9, -7, -5, -4, -4, -5,
-6, -8, -9, -9, -10, -9, -7, -5, -4, -2, -1, 0, 0, -3, -5, -8, -13, -18, -21,
-23, -26, -27, -26, -26, -23, -21, -18, -15, -12, -10, -10, -10, -10, -12, -15,
-20, -22, -25, -29, -31, -33, -34, -35, -34, -33, -31, -28, -25, -22, -18, -16,
-13, -12, -11, -9, -9, -7, -5, -2, 0, 4, 6, 11, 13, 15, 16, 15, 14, 12, 7, 2,
-1, -7, -12, -16, -19, -22, -25, -26, -28, -29, -29, -30, -31, -30, -31, -30,
-29, -27, -24, -21, -17, -13, -6, -1, 5, 14, 21, 27, 35, 40, 45, 48, 52, 52, 52,
50, 46, 40, 33, 25, 16, 7, -1, -11, -19, -27, -32, -36, -38, -40, -40, -38, -34,
-32, -28, -24, -20, -16, -12, -7, -3, 2, 8, 16, 22, 30, 37, 45, 51, 58, 62, 64,
64, 63, 60, 54, 47, 40, 30, 22, 14, 5, -3, -11, -18, -24, -30, -35, -40, -45,
-48, -50, -51, -49, -47, -44, -38, -33, -24, -17, -8, 2, 11, 21, 31, 39, 46, 53,
56, 59, 58, 56, 52, 47, 41, 32, 25, 18, 12, 6, 1, -3, -7, -12, -16, -20, -26,
-32, -38, -44, -50, -54, -58, -60, -60, -59, -56, -50, -45, -39, -31, -22, -15,
-7, 0, 7, 13, 18, 22, 26, 29, 31, 33, 32, 32, 31, 28, 25, 21, 16, 12, 6, 1, -5,
-9, -15, -18, -21, -24, -27, -27, -28, -28, -26, -23, -21, -17, -15, -11, -10,
-7, -6, -5, -5, -3, -4, -2, 1, 2, 6, 10, 15, 19, 25, 30, 35, 38, 41, 42, 43, 43,
41, 39, 36, 34, 31, 29, 28, 26, 26, 25, 25, 25, 25, 25, 23, 22, 21, 19, 18, 17,
18, 19, 19, 23, 26, 28, 32, 35, 37, 38, 40, 40, 38, 34, 31, 27, 23, 20, 16, 14,
11, 10, 11, 10, 11, 11, 10, 10, 8, 4, 1, -5, -11, -19, -25, -32, -39, -45, -49,
-52, -53, -53, -52, -49, -46, -44, -42, -43, -42, -44, -48, -51, -55, -59, -65,
-69, -72, -76, -77, -78, -79, -79, -79, -79, -80, -81, -82, -84, -85, -87, -87,
-89, -87, -87, -83, -80, -76, -71, -65, -59, -54, -49, -45, -42, -40, -39, -38,
-37, -36, -33, -29, -24, -17, -10, -2, };