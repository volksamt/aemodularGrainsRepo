#define DATA_LENGTH 512
#define DATA AKWF_clavinet_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 27, 40, 51, 62, 73, 84, 94, 103,
111, 117, 119, 118, 113, 103, 90, 74, 57, 44, 36, 35, 39, 48, 59, 67, 73, 74,
72, 64, 57, 49, 41, 33, 23, 14, 4, -3, -8, -11, -10, -6, 0, 6, 9, 9, 9, 7, 5, 4,
9, 18, 31, 47, 64, 77, 87, 90, 88, 84, 75, 66, 53, 41, 31, 21, 11, 3, -8, -19,
-31, -43, -54, -64, -72, -77, -77, -78, -74, -70, -65, -57, -49, -42, -37, -35,
-37, -40, -45, -52, -58, -63, -66, -66, -66, -64, -60, -54, -47, -41, -35, -30,
-26, -22, -21, -20, -21, -24, -28, -32, -35, -41, -45, -50, -54, -55, -56, -56,
-55, -52, -48, -45, -40, -36, -30, -26, -23, -21, -18, -14, -12, -7, -4, -1, 2,
5, 8, 9, 9, 9, 9, 11, 11, 12, 14, 15, 16, 17, 18, 18, 18, 20, 19, 18, 18, 17,
16, 17, 17, 18, 17, 17, 18, 18, 20, 19, 18, 19, 19, 20, 20, 20, 22, 23, 24, 25,
27, 27, 27, 25, 24, 23, 22, 21, 19, 19, 19, 19, 18, 18, 15, 12, 11, 11, 9, 8, 7,
6, 6, 5, 4, 3, 1, 1, 1, 0, -2, -5, -7, -5, -6, -6, -8, -8, -7, -4, -4, -6, -5,
-5, -3, -3, -2, -2, 0, 2, 2, 2, 2, 5, 3, 2, 1, -1, -1, -3, -4, -4, -4, -4, -3,
-3, -3, -4, -4, -3, -3, -2, -2, -2, -1, 0, 2, 3, 3, 2, 1, 0, 1, -1, -2, -2, -1,
0, 1, 2, 3, 4, 5, 5, 5, 5, 4, 6, 9, 9, 9, 7, 8, 9, 10, 8, 6, 5, 4, 4, 2, -1, 0,
1, 1, -2, -2, -3, 0, 2, 2, 1, 1, 1, 0, 0, -1, -3, -2, 1, 1, 0, -2, -2, -2, -3,
-4, -5, -4, -3, -4, -5, -7, -8, -5, -1, 1, -1, -1, 2, 2, 2, -1, -3, -4, -5, -3,
0, 0, 0, 0, 1, 3, 2, -1, -7, -11, -9, -5, -1, -1, -1, 2, 8, 9, 4, -3, -4, 1, 5,
2, -5, -10, -11, -8, -7, -8, -7, -1, 8, 15, 15, 11, 8, 5, 2, -2, -5, -7, -9,
-13, -17, -17, -13, -7, 0, 4, 4, 1, 1, 0, -1, 0, 3, 10, 17, 27, 34, 35, 30, 23,
16, 11, 0, -11, -18, -18, -6, 9, 20, 24, 24, 24, 22, 14, 0, -14, -19, -13, -6,
-2, -2, -2, 5, 13, 16, 13, 10, 9, 5, -4, -19, -35, -45, -48, -43, -33, -14, 7,
26, 43, 53, 61, 66, 67, 64, 58, 49, 40, 30, 18, 4, -9, -21, -32, -44, -56, -67,
-80, -89, -94, -94, -89, -82, -75, -65, -52, -39, -26, -19, -17, -17, -21, -27,
-36, -46, -51, -49, -42, -32, -24, -19, -15, -9, -4, 2, 7, 12, 16, 20, 23, 25,
24, 24, 25, 26, 28, 29, 26, 20, 10, 0, -10, -20, -33, -47, -62, -77, -89, -97,
-98, -93, -81, -63, -42, -22, -3, };