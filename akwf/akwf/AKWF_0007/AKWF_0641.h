#define DATA_LENGTH 512
#define DATA AKWF_0641

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 7, 9, 11, 13, 13, 17, 18, 20,
22, 24, 25, 27, 29, 31, 32, 34, 35, 37, 39, 41, 44, 45, 47, 48, 50, 53, 54, 56,
58, 59, 61, 63, 64, 66, 67, 69, 71, 73, 73, 76, 77, 78, 79, 81, 82, 84, 85, 87,
88, 89, 90, 91, 93, 93, 96, 96, 98, 98, 100, 101, 102, 103, 104, 104, 105, 106,
107, 108, 109, 109, 110, 112, 111, 113, 113, 113, 114, 116, 115, 116, 116, 116,
117, 117, 118, 118, 119, 118, 119, 119, 119, 120, 119, 120, 119, 119, 119, 120,
118, 119, 118, 119, 118, 117, 117, 116, 116, 117, 116, 115, 114, 114, 114, 112,
112, 111, 111, 111, 110, 109, 108, 108, 107, 105, 105, 104, 102, 101, 100, 99,
99, 97, 96, 95, 94, 92, 91, 90, 89, 88, 85, 84, 83, 82, 81, 79, 77, 76, 75, 71,
70, 69, 67, 66, 64, 62, 60, 59, 56, 55, 54, 50, 49, 47, 45, 43, 42, 39, 37, 36,
35, 33, 30, 28, 27, 25, 22, 21, 20, 18, 16, 14, 12, 10, 8, 7, 5, 3, 1, -1, -2,
-4, -5, -7, -9, -10, -12, -14, -15, -17, -19, -19, -21, -23, -25, -27, -27, -30,
-31, -32, -33, -35, -37, -38, -38, -40, -42, -42, -44, -45, -46, -47, -47, -49,
-50, -50, -52, -53, -54, -55, -56, -58, -57, -59, -59, -59, -62, -62, -63, -63,
-64, -64, -65, -66, -66, -67, -68, -68, -69, -70, -70, -70, -71, -71, -72, -71,
-72, -72, -73, -73, -73, -73, -73, -73, -73, -75, -75, -74, -75, -74, -75, -74,
-74, -74, -74, -74, -74, -74, -73, -74, -73, -74, -73, -72, -72, -72, -72, -71,
-72, -71, -70, -71, -70, -69, -69, -69, -69, -67, -67, -67, -66, -66, -66, -64,
-64, -63, -62, -62, -62, -62, -60, -59, -59, -58, -58, -56, -57, -56, -55, -54,
-53, -54, -52, -51, -51, -50, -50, -49, -49, -48, -48, -47, -46, -45, -45, -45,
-44, -44, -43, -43, -42, -42, -42, -40, -40, -40, -39, -39, -38, -37, -37, -37,
-36, -36, -36, -35, -34, -34, -34, -34, -33, -33, -33, -32, -32, -31, -31, -30,
-30, -30, -29, -29, -28, -28, -28, -27, -28, -28, -28, -27, -28, -28, -29, -28,
-28, -30, -30, -30, -31, -31, -32, -32, -33, -34, -35, -35, -36, -37, -37, -37,
-38, -39, -39, -40, -41, -42, -43, -43, -44, -45, -46, -46, -47, -48, -49, -50,
-51, -52, -53, -53, -53, -54, -55, -55, -56, -57, -57, -58, -58, -60, -60, -60,
-61, -61, -62, -62, -63, -63, -62, -63, -63, -63, -64, -64, -65, -64, -65, -64,
-65, -64, -65, -64, -64, -64, -63, -63, -63, -63, -63, -63, -62, -61, -61, -61,
-61, -60, -59, -58, -58, -57, -57, -56, -54, -54, -52, -52, -50, -50, -49, -47,
-46, -45, -44, -41, -40, -39, -38, -36, -34, -33, -31, -30, -28, -27, -24, -22,
-22, -20, -18, -16, -14, -13, -11, -10, -8, -5, -4, -2, -1, };