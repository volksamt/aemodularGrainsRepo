#define DATA_LENGTH 512
#define DATA AKWF_0665

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 11, 14, 18, 22, 24, 28, 30, 33,
34, 37, 39, 41, 44, 45, 47, 48, 50, 51, 53, 55, 55, 57, 58, 60, 60, 61, 62, 64,
65, 65, 67, 68, 68, 69, 70, 71, 71, 72, 72, 73, 74, 75, 74, 76, 76, 77, 76, 77,
77, 78, 77, 78, 78, 79, 78, 79, 79, 78, 80, 77, 82, 37, 14, 12, 3, 1, -4, -6,
-11, -11, -16, -17, -20, -21, -23, -25, -26, -28, -29, -31, -33, -33, -35, -36,
-37, -38, -39, -40, -40, -43, -43, -43, -45, -45, -45, -47, -47, -48, -48, -49,
-50, -50, -51, -51, -52, -52, -52, -53, -53, -54, -54, -54, -55, -56, -56, -56,
-57, -55, -56, -57, -57, -57, -57, -57, -58, -57, -58, -55, -60, -40, -19, -20,
-13, -13, -8, -8, -5, -4, -1, 0, 1, 2, 2, 5, 4, 6, 8, 8, 9, 10, 9, 11, 12, 13,
13, 14, 13, 15, 16, 16, 17, 17, 18, 18, 19, 19, 20, 20, 20, 21, 21, 21, 22, 23,
23, 24, 23, 24, 25, 25, 25, 26, 26, 26, 26, 27, 26, 28, 28, 29, 28, 29, 29, 29,
29, 29, 30, 30, 31, 30, 31, 30, 32, 31, 31, 31, 32, 32, 33, 32, 32, 32, 33, 32,
33, 33, 33, 34, 34, 34, 33, 34, 34, 34, 34, 34, 34, 35, 35, 34, 35, 35, 34, 34,
35, 35, 35, 36, 34, 35, 35, 35, 35, 35, 35, 34, 35, 35, 36, 41, 41, 43, 43, 43,
44, 44, 44, 44, 45, 45, 45, 46, 45, 46, 46, 47, 46, 47, 47, 46, 46, 47, 47, 47,
48, 47, 48, 48, 47, 48, 48, 48, 48, 49, 48, 48, 48, 48, 48, 49, 48, 48, 49, 49,
48, 48, 50, 49, 49, 50, 49, 50, 49, 49, 49, 49, 49, 50, 49, 50, 49, 50, 50, 50,
50, 50, 50, 50, 50, 50, 50, 49, 50, 50, 50, 50, 51, 50, 51, 51, 50, 50, 50, 50,
50, 50, 51, 50, 50, 50, 50, 51, 50, 51, 51, 51, 51, 51, 50, 51, 51, 51, 51, 50,
50, 50, 51, 51, 50, 51, 51, 51, 50, 51, 51, 51, 50, 50, 51, 19, 6, 5, -2, -2,
-7, -7, -11, -12, -15, -15, -18, -18, -20, -20, -22, -23, -24, -24, -26, -28,
-27, -28, -29, -29, -30, -31, -31, -33, -33, -34, -34, -35, -34, -36, -35, -36,
-36, -37, -37, -38, -39, -38, -38, -40, -39, -40, -40, -40, -41, -41, -42, -41,
-41, -42, -41, -42, -42, -42, -42, -42, -43, -42, -43, -42, -44, -40, -56, -79,
-78, -84, -85, -89, -90, -93, -94, -96, -97, -99, -99, -99, -101, -102, -103,
-104, -104, -105, -106, -107, -107, -108, -108, -109, -110, -111, -111, -110,
-112, -112, -113, -112, -113, -113, -115, -114, -114, -114, -115, -115, -116,
-116, -116, -117, -117, -116, -117, -117, -117, -118, -117, -118, -118, -118,
-118, -119, -118, -119, -118, -120, -118, -121, -117, -122, -115, -126, -102,
-33, -27, -14, -9, -2, };