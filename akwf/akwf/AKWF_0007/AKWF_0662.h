#define DATA_LENGTH 512
#define DATA AKWF_0662

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 13, 18, 21, 24, 26, 28, 31, 33,
35, 36, 38, 40, 42, 42, 43, 45, 46, 47, 49, 49, 51, 52, 53, 53, 54, 55, 56, 58,
58, 59, 60, 60, 60, 61, 62, 62, 63, 64, 65, 65, 66, 66, 66, 67, 68, 68, 69, 69,
70, 71, 71, 72, 71, 72, 72, 74, 73, 74, 75, 75, 75, 75, 75, 75, 76, 77, 77, 77,
77, 78, 79, 77, 78, 80, 79, 80, 80, 79, 80, 80, 80, 80, 81, 82, 81, 81, 82, 81,
82, 82, 83, 83, 83, 83, 82, 83, 83, 83, 83, 84, 84, 84, 84, 84, 84, 84, 84, 84,
83, 85, 83, 84, 85, 84, 84, 84, 85, 85, 85, 85, 86, 84, 85, 83, 97, 105, 103,
107, 106, 109, 108, 109, 109, 109, 110, 110, 111, 110, 112, 111, 111, 111, 112,
112, 112, 113, 113, 113, 114, 113, 114, 113, 114, 114, 113, 114, 114, 115, 115,
115, 114, 115, 115, 115, 116, 115, 115, 115, 115, 115, 115, 116, 116, 116, 116,
117, 116, 117, 117, 116, 116, 116, 116, 116, 117, 117, 116, 117, 116, 117, 117,
116, 117, 117, 117, 117, 117, 117, 116, 117, 117, 118, 117, 118, 117, 118, 117,
118, 118, 118, 118, 117, 118, 117, 118, 118, 118, 118, 118, 117, 118, 117, 117,
118, 117, 117, 118, 118, 118, 118, 117, 119, 118, 118, 117, 118, 117, 118, 117,
119, 117, 119, 117, 119, 117, 119, 117, 118, 117, 118, 117, 117, 121, 29, 0, 1,
-11, -11, -19, -19, -26, -25, -30, -30, -34, -34, -38, -39, -41, -41, -43, -45,
-45, -47, -48, -50, -51, -51, -53, -53, -55, -56, -56, -58, -58, -59, -59, -61,
-61, -62, -63, -64, -63, -65, -65, -66, -66, -66, -67, -68, -69, -69, -69, -69,
-71, -72, -72, -73, -72, -73, -73, -74, -74, -74, -75, -76, -76, -76, -76, -77,
-78, -78, -78, -78, -78, -79, -80, -79, -80, -81, -80, -79, -81, -81, -82, -81,
-82, -81, -82, -83, -82, -83, -82, -83, -83, -84, -84, -84, -83, -83, -85, -84,
-84, -85, -84, -85, -84, -85, -86, -85, -85, -85, -85, -85, -86, -85, -86, -86,
-86, -86, -86, -86, -86, -86, -86, -87, -86, -85, -86, -84, -99, -106, -106,
-108, -107, -110, -109, -110, -110, -111, -111, -111, -111, -112, -112, -113,
-113, -113, -114, -114, -114, -114, -115, -115, -115, -115, -115, -115, -115,
-115, -116, -115, -116, -116, -116, -116, -117, -116, -116, -117, -116, -116,
-116, -117, -117, -117, -117, -117, -117, -117, -117, -118, -117, -117, -118,
-118, -118, -118, -118, -119, -117, -117, -118, -118, -119, -119, -117, -118,
-118, -118, -118, -118, -119, -119, -118, -119, -118, -118, -120, -119, -119,
-119, -119, -118, -118, -119, -119, -119, -119, -119, -119, -118, -119, -119,
-118, -119, -119, -119, -119, -119, -118, -120, -119, -119, -119, -119, -119,
-120, -118, -120, -118, -120, -119, -120, -119, -119, -118, -120, -118, -119,
-119, -118, -119, -118, -121, -116, -128, -49, 1, -6, };