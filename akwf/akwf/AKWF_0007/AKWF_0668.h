#define DATA_LENGTH 512
#define DATA AKWF_0668

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 1, 4, 2, 17, 38, 46, 57, 63, 72,
78, 84, 89, 94, 98, 103, 106, 109, 112, 114, 116, 117, 118, 119, 118, 109, 103,
99, 96, 92, 90, 87, 84, 82, 80, 78, 76, 74, 71, 69, 68, 66, 64, 62, 61, 59, 57,
55, 55, 53, 52, 51, 49, 47, 46, 45, 45, 44, 43, 43, 42, 41, 38, 38, 37, 36, 35,
34, 33, 32, 31, 30, 28, 27, 25, 26, 23, 23, 22, 20, 19, 19, 18, 17, 16, 14, 22,
30, 31, 32, 32, 33, 34, 35, 34, 34, 33, 33, 33, 32, 31, 31, 29, 30, 29, 28, 27,
27, 26, 24, 24, 23, 22, 21, 20, 20, 19, 19, 17, 16, 16, 15, 14, 14, 12, 12, 11,
10, 10, 9, 9, 7, 11, 17, 19, 20, 22, 23, 24, 25, 27, 28, 29, 30, 31, 32, 33, 33,
34, 35, 36, 36, 37, 38, 39, 40, 40, 41, 41, 42, 43, 44, 44, 49, 51, 54, 55, 57,
60, 61, 62, 64, 65, 67, 68, 71, 71, 73, 74, 75, 77, 77, 80, 81, 81, 82, 84, 85,
85, 87, 88, 90, 90, 91, 92, 93, 94, 94, 96, 97, 97, 98, 98, 100, 101, 101, 101,
102, 102, 103, 104, 104, 105, 105, 106, 107, 107, 108, 108, 108, 109, 110, 109,
110, 110, 110, 111, 111, 111, 112, 112, 112, 112, 113, 113, 113, 112, 114, 112,
115, 105, 83, 72, 60, 53, 44, 38, 32, 26, 21, 16, 13, 9, 6, 3, 1, -1, -2, -4,
-2, -21, -38, -47, -57, -65, -72, -78, -84, -90, -95, -99, -103, -107, -109,
-113, -115, -116, -119, -118, -119, -117, -108, -104, -100, -97, -93, -91, -89,
-85, -82, -81, -79, -77, -74, -73, -71, -69, -67, -65, -64, -62, -60, -58, -57,
-55, -54, -52, -51, -49, -48, -47, -45, -44, -42, -41, -40, -40, -38, -37, -35,
-34, -33, -32, -31, -30, -28, -28, -28, -25, -25, -23, -23, -22, -21, -21, -20,
-19, -17, -17, -16, -15, -15, -14, -13, -13, -11, -11, -11, -11, -10, -8, -8,
-8, -6, -6, -6, -6, -5, -4, -4, -3, -4, -3, -3, -2, -1, -2, 0, 0, 0, 0, -1, 1,
1, 1, 1, 1, 1, 1, 1, 2, 2, 2, 2, 2, 2, 2, 3, -3, -10, -14, -18, -20, -23, -26,
-29, -31, -33, -35, -37, -39, -41, -43, -44, -47, -48, -50, -52, -54, -54, -57,
-58, -59, -60, -62, -64, -65, -65, -67, -68, -70, -71, -72, -73, -74, -75, -77,
-77, -79, -79, -81, -81, -83, -84, -85, -85, -87, -87, -88, -89, -91, -92, -92,
-92, -93, -94, -95, -95, -96, -97, -98, -99, -99, -100, -100, -102, -101, -102,
-103, -103, -105, -103, -105, -105, -106, -106, -107, -107, -108, -107, -108,
-109, -109, -110, -109, -110, -110, -110, -111, -111, -112, -111, -111, -111,
-112, -112, -112, -113, -113, -112, -113, -113, -112, -113, -112, -115, -102,
-80, -71, -60, -52, -44, -37, -31, -26, -20, -16, -12, -9, -6, -2, 0, };