#define DATA_LENGTH 512
#define DATA AKWF_0607

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 7, 9, 12, 15, 17, 21, 23, 27,
29, 32, 35, 37, 39, 42, 45, 47, 50, 52, 55, 57, 59, 62, 64, 67, 68, 71, 74, 76,
77, 80, 81, 83, 85, 87, 89, 91, 92, 94, 96, 98, 99, 100, 102, 103, 105, 106,
106, 108, 108, 110, 111, 112, 112, 114, 114, 115, 116, 116, 117, 117, 118, 119,
119, 119, 119, 119, 119, 119, 118, 117, 114, 111, 108, 105, 100, 95, 91, 86, 82,
77, 72, 66, 61, 55, 50, 44, 39, 33, 28, 21, 16, 11, 4, -2, -8, -13, -18, -23,
-29, -35, -41, -44, -50, -55, -60, -63, -69, -73, -77, -81, -84, -88, -92, -94,
-98, -100, -103, -105, -108, -109, -111, -112, -114, -114, -115, -116, -116,
-116, -114, -112, -108, -106, -103, -99, -95, -90, -86, -81, -76, -70, -66, -60,
-55, -50, -45, -38, -33, -27, -21, -14, -10, -4, 1, 8, 13, 18, 23, 30, 35, 40,
45, 51, 55, 60, 65, 69, 73, 78, 81, 85, 89, 93, 96, 99, 102, 104, 107, 108, 111,
113, 114, 116, 117, 117, 119, 118, 119, 119, 118, 116, 115, 113, 111, 109, 107,
105, 101, 100, 97, 93, 91, 88, 84, 81, 78, 76, 72, 69, 65, 61, 58, 54, 51, 48,
44, 40, 37, 33, 30, 26, 22, 18, 14, 10, 7, 4, 0, -4, -7, -12, -15, -17, -21,
-26, -29, -32, -36, -38, -42, -45, -49, -51, -54, -57, -61, -64, -67, -70, -73,
-74, -78, -79, -82, -85, -87, -89, -92, -94, -95, -98, -99, -101, -102, -103,
-105, -107, -108, -110, -110, -111, -113, -114, -114, -115, -115, -116, -116,
-116, -117, -117, -117, -115, -113, -111, -107, -104, -101, -97, -93, -88, -84,
-79, -76, -71, -66, -61, -55, -50, -45, -40, -35, -29, -24, -18, -13, -7, -1, 4,
10, 14, 20, 25, 30, 35, 40, 44, 49, 54, 59, 63, 68, 71, 75, 79, 83, 86, 89, 93,
96, 99, 102, 104, 107, 108, 111, 112, 113, 115, 115, 117, 117, 118, 118, 119,
119, 117, 116, 115, 114, 112, 110, 108, 107, 105, 103, 100, 99, 97, 93, 93, 90,
88, 85, 82, 80, 77, 75, 72, 69, 67, 64, 61, 58, 56, 52, 50, 46, 44, 40, 39, 35,
33, 30, 25, 24, 21, 18, 14, 12, 9, 6, 3, -1, -4, -6, -9, -12, -15, -18, -19,
-23, -26, -29, -30, -34, -37, -40, -42, -45, -48, -51, -52, -55, -58, -59, -61,
-65, -67, -69, -72, -73, -75, -78, -80, -82, -84, -85, -87, -89, -91, -93, -94,
-96, -98, -99, -101, -102, -103, -104, -106, -107, -108, -108, -109, -111, -111,
-113, -113, -114, -115, -116, -117, -116, -117, -117, -118, -117, -117, -118,
-117, -117, -117, -116, -116, -114, -113, -111, -110, -107, -106, -104, -102,
-99, -98, -96, -94, -91, -90, -87, -84, -82, -80, -78, -75, -72, -70, -67, -64,
-61, -59, -56, -54, -50, -47, -44, -43, -39, -36, -34, -30, -27, -25, -21, -19,
-16, -13, -10, -6, -3, -2, };