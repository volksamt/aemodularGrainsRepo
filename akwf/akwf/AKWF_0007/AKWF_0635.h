#define DATA_LENGTH 512
#define DATA AKWF_0635

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 7, 9, 12, 14, 16, 19, 22,
25, 28, 31, 35, 38, 41, 45, 49, 52, 56, 58, 62, 66, 69, 73, 75, 79, 82, 85, 88,
91, 94, 96, 100, 102, 104, 106, 108, 109, 111, 112, 114, 115, 116, 117, 118,
119, 120, 119, 119, 118, 118, 116, 114, 113, 111, 109, 107, 104, 101, 99, 96,
94, 91, 88, 86, 83, 80, 77, 74, 71, 68, 65, 63, 60, 56, 53, 50, 48, 44, 41, 39,
37, 33, 31, 29, 25, 23, 22, 20, 18, 15, 14, 12, 10, 8, 7, 6, 5, 3, 3, 2, 2, 1,
0, 0, 1, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, -1, 1, 1, 3, 4, 5, 7, 9, 11,
14, 15, 18, 20, 22, 26, 28, 32, 34, 37, 40, 42, 45, 48, 51, 53, 56, 59, 63, 66,
67, 71, 73, 76, 78, 81, 83, 86, 87, 91, 91, 95, 95, 98, 99, 101, 102, 104, 104,
106, 107, 106, 109, 107, 111, 103, 121, 36, -11, 6, -5, 3, -1, 2, -2, 2, -1, 0,
0, 0, 0, 0, 0, 0, 1, -1, -3, -13, -23, -28, -40, 22, 39, 15, 11, -1, 2, -2, 2,
-1, 1, -2, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, -3, -6, -10, -14, -21, -25, -31,
-36, -42, -48, -55, -61, -66, -73, -78, -83, -88, -93, -97, -100, -103, -106,
-108, -108, -110, -111, -109, -109, -108, -105, -104, -102, -100, -98, -96, -93,
-91, -88, -85, -83, -80, -76, -74, -71, -67, -65, -62, -59, -55, -53, -50, -46,
-44, -41, -38, -35, -32, -30, -27, -25, -22, -19, -17, -16, -14, -12, -10, -9,
-7, -6, -5, -4, -3, -2, -1, 0, -1, 0, 0, 1, 0, -1, 1, 0, 0, 0, 0, 0, 0, -1, 0,
1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0,
-1, -1, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, -1, 0, 0, 0, -1, 0, 0, 0, 1,
0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, -1, 1, 0, 0, 0, 0, 0, -1, 0, 0,
0, 0, 1, 0, -1, -1, -3, -5, -6, -8, -11, -13, -15, -17, -20, -22, -25, -29, -31,
-33, -37, -41, -43, -46, -49, -53, -55, -57, -60, -63, -67, -69, -72, -76, -78,
-80, -83, -85, -88, -90, -92, -93, -96, -98, -98, -100, -101, -103, -103, -104,
-105, -107, -107, -107, -107, -108, -107, -104, -103, -100, -98, -96, -93, -89,
-87, -83, -80, -76, -73, -69, -65, -62, -58, -54, -50, -47, -44, -40, -36, -32,
-30, -26, -23, -21, -17, -15, -12, -11, -8, -7, -4, -4, -2, -1, -1, 0, 1, 0, -1,
0, 0, 0, 1, 1, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, };