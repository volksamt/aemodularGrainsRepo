#define DATA_LENGTH 512
#define DATA AKWF_0643

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 6, 8, 9, 10, 13, 14, 15, 17, 19,
21, 22, 23, 25, 26, 28, 29, 30, 32, 34, 35, 37, 39, 40, 41, 42, 44, 45, 46, 48,
48, 51, 52, 53, 55, 56, 57, 58, 60, 61, 62, 63, 64, 66, 66, 67, 69, 70, 71, 72,
74, 75, 76, 78, 77, 80, 80, 82, 83, 83, 84, 85, 87, 87, 88, 90, 90, 91, 93, 93,
93, 95, 96, 96, 97, 97, 98, 100, 100, 101, 101, 102, 103, 105, 105, 105, 107,
107, 107, 107, 108, 109, 109, 110, 111, 111, 112, 112, 112, 113, 114, 114, 114,
114, 115, 115, 116, 116, 116, 117, 118, 117, 117, 118, 118, 119, 118, 119, 119,
119, 119, 119, 118, 119, 120, 119, 119, 117, 115, 114, 112, 110, 109, 107, 106,
104, 102, 101, 99, 97, 95, 94, 92, 91, 90, 88, 86, 86, 84, 82, 81, 80, 79, 77,
75, 74, 73, 71, 69, 69, 67, 66, 65, 63, 62, 61, 59, 58, 56, 56, 55, 53, 51, 51,
50, 48, 47, 46, 46, 44, 43, 42, 40, 39, 38, 38, 36, 36, 34, 33, 33, 31, 31, 29,
29, 27, 27, 26, 25, 25, 23, 23, 22, 21, 21, 19, 18, 18, 18, 16, 16, 16, 14, 14,
13, 12, 12, 11, 11, 9, 10, 9, 8, 8, 7, 7, 7, 6, 5, 5, 5, 4, 4, 3, 3, 3, 3, 3, 2,
2, 2, 2, 1, 2, 1, 1, 0, 0, 0, 1, 1, 0, 0, 0, 0, -2, -4, -5, -8, -8, -10, -12,
-14, -15, -17, -19, -20, -21, -23, -25, -27, -28, -30, -31, -33, -34, -35, -37,
-39, -39, -41, -42, -44, -46, -46, -48, -49, -51, -51, -53, -55, -56, -57, -58,
-60, -61, -62, -64, -65, -66, -67, -68, -69, -70, -71, -72, -74, -75, -76, -77,
-78, -80, -80, -81, -83, -83, -85, -86, -86, -87, -89, -89, -91, -91, -92, -93,
-94, -94, -95, -96, -98, -98, -99, -99, -100, -101, -102, -103, -103, -104,
-105, -105, -107, -107, -107, -108, -109, -108, -110, -110, -111, -111, -112,
-113, -113, -114, -114, -113, -114, -115, -115, -116, -116, -117, -117, -116,
-117, -117, -118, -118, -118, -118, -118, -119, -118, -119, -118, -118, -119,
-119, -119, -119, -120, -118, -116, -113, -112, -110, -108, -106, -105, -104,
-102, -100, -99, -97, -97, -94, -92, -90, -90, -88, -87, -85, -84, -82, -82,
-79, -78, -77, -75, -73, -73, -72, -70, -69, -67, -66, -64, -64, -62, -61, -59,
-59, -58, -56, -55, -53, -52, -51, -49, -48, -47, -46, -45, -44, -43, -42, -40,
-39, -39, -38, -37, -35, -35, -34, -32, -31, -30, -29, -29, -29, -27, -26, -25,
-24, -23, -23, -22, -21, -20, -20, -18, -18, -17, -17, -16, -16, -14, -14, -13,
-12, -11, -11, -11, -10, -9, -9, -9, -8, -8, -7, -6, -6, -6, -5, -5, -4, -4, -4,
-4, -4, -3, -2, -2, -2, -1, -1, -1, -1, -1, -1, -1, 0, 1, 0, -1, 0, -1, 0, -1,
};