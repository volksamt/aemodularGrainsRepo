#define DATA_LENGTH 512
#define DATA AKWF_0659

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 5, 7, 9, 10, 11, 12, 15, 16,
17, 18, 19, 20, 21, 23, 24, 25, 26, 27, 29, 29, 31, 31, 32, 33, 34, 36, 36, 37,
38, 38, 40, 40, 41, 43, 43, 43, 44, 46, 46, 47, 48, 48, 49, 50, 51, 51, 52, 53,
53, 55, 54, 55, 56, 57, 58, 56, 58, 58, 59, 59, 60, 61, 60, 62, 62, 62, 63, 63,
64, 64, 64, 65, 64, 66, 65, 67, 65, 68, 67, 67, 66, 68, 67, 69, 68, 68, 68, 69,
69, 68, 70, 68, 71, 68, 71, 67, 73, 65, 75, 63, 78, 59, 89, 13, -128, -98, -107,
-95, -94, -88, -87, -83, -80, -77, -72, -72, -66, -67, -62, -63, -57, -58, -52,
-53, -48, -48, -45, -43, -40, -39, -36, -35, -33, -31, -30, -28, -25, -25, -23,
-21, -20, -18, -16, -14, -13, -11, -11, -8, -6, -6, -4, -2, -1, 0, 1, 3, 4, 5,
6, 7, 8, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 21, 21, 22, 23, 24, 25, 25, 26,
27, 28, 28, 30, 30, 31, 31, 32, 33, 33, 34, 35, 35, 36, 36, 37, 37, 38, 38, 38,
38, 39, 40, 40, 40, 40, 40, 40, 42, 42, 41, 42, 43, 42, 43, 42, 43, 42, 42, 43,
42, 38, 36, 33, 33, 31, 30, 28, 27, 25, 24, 23, 22, 21, 20, 19, 18, 17, 16, 15,
14, 13, 13, 11, 10, 10, 9, 7, 7, 6, 6, 4, 5, 3, 3, 2, 1, 1, 0, 0, -1, -2, -2,
-3, -4, -4, -5, -5, -6, -7, -7, -8, -8, -8, -9, -10, -10, -10, -11, -12, -12,
-13, -13, -13, -14, -14, -14, -16, -15, -15, -17, -17, -17, -17, -18, -18, -19,
-20, -19, -20, -19, -20, -20, -20, -21, -21, -20, -21, -22, -22, -22, -22, -22,
-22, -22, -23, -23, -23, -24, -23, -24, -24, -25, -24, -24, -24, -24, -24, -24,
-24, -25, -24, -24, -25, -24, -24, -25, -24, -25, -24, -24, -25, -24, -25, -24,
-24, -24, -24, -24, -24, -24, -24, -25, -25, -25, -24, -23, -24, -25, -24, -24,
-25, -24, -24, -24, -24, -24, -25, -24, -25, -24, -24, -25, -25, -24, -24, -24,
-24, -25, -24, -25, -25, -24, -24, -24, -24, -24, -24, -24, -25, -24, -24, -24,
-24, -25, -25, -25, -24, -24, -24, -24, -24, -24, -24, -24, -24, -24, -23, -25,
-25, -24, -24, -25, -25, -24, -24, -25, -25, -24, -24, -24, -24, -25, -24, -24,
-24, -24, -24, -24, -24, -24, -24, -24, -24, -24, -23, -24, -24, -24, -24, -25,
-24, -24, -24, -24, -24, -24, -24, -24, -24, -24, -24, -23, -24, -24, -24, -24,
-23, -24, -24, -24, -24, -24, -24, -25, -24, -24, -24, -24, -24, -23, -25, -24,
-23, -24, -24, -23, -24, -24, -24, -24, -24, -24, -24, -25, -24, -25, -24, -24,
-24, -25, -25, -24, -23, -23, -24, -24, -24, -24, -24, -25, -20, -16, -14, -11,
-9, -6, -4, -2, -1, };