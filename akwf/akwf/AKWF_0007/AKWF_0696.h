#define DATA_LENGTH 512
#define DATA AKWF_0696

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 42, 52, 58, 63, 67, 71, 73, 77,
79, 81, 83, 84, 86, 88, 90, 91, 93, 95, 96, 96, 98, 98, 100, 101, 101, 103, 103,
104, 105, 106, 107, 106, 108, 109, 110, 109, 110, 110, 110, 111, 111, 112, 113,
113, 113, 114, 114, 114, 115, 115, 115, 115, 115, 116, 116, 117, 117, 117, 116,
118, 117, 117, 116, 117, 117, 118, 117, 118, 117, 118, 118, 119, 118, 119, 117,
84, 77, 74, 70, 68, 65, 65, 62, 61, 59, 59, 57, 57, 55, 54, 53, 52, 51, 51, 49,
48, 48, 48, 48, 46, 46, 45, 45, 44, 43, 43, 42, 42, 41, 42, 40, 40, 40, 39, 39,
39, 38, 38, 37, 37, 37, 36, 36, 36, 35, 35, 35, 34, 35, 35, 34, 33, 33, 33, 33,
33, 32, 32, 32, 32, 32, 32, 31, 32, 30, 32, 31, 31, 31, 31, 30, 30, 30, 30, 29,
30, 29, 30, 30, 29, 29, 29, 29, 28, 29, 29, 28, 28, 29, 28, 28, 28, 28, 28, 27,
28, 28, 28, 28, 28, 27, 29, 18, 9, 10, 8, 8, 6, 5, 4, 4, 3, 3, 2, 1, 1, 1, 1, 0,
0, -1, 0, -1, -1, -2, -1, -1, -3, -3, -2, -3, -3, -3, -4, -4, -4, -3, -5, -5,
-5, -5, -5, -5, -5, -5, -5, -6, -5, -5, -5, -5, -6, -6, -5, -5, -6, -6, -6, -6,
-6, -6, -6, -6, -6, -6, -7, -6, -8, -17, -19, -20, -21, -21, -23, -23, -23, -24,
-24, -25, -25, -25, -25, -26, -27, -27, -27, -27, -27, -27, -27, -28, -28, -28,
-29, -29, -29, -30, -29, -29, -30, -30, -30, -30, -31, -31, -31, -31, -31, -31,
-32, -31, -31, -31, -31, -32, -31, -32, -32, -32, -32, -31, -33, -32, -32, -32,
-33, -33, -33, -33, -34, -33, -34, -34, -34, -33, -34, -34, -34, -34, -34, -34,
-35, -34, -34, -34, -34, -34, -34, -34, -34, -35, -35, -34, -35, -34, -35, -35,
-34, -35, -35, -35, -36, -36, -36, -35, -36, -35, -35, -36, -35, -35, -36, -35,
-35, -37, -35, -35, -36, -36, -36, -36, -37, -35, -37, -36, -36, -36, -36, -37,
-37, -36, -36, -36, -37, -37, -36, -36, -36, -36, -37, -36, -36, -36, -37, -36,
-37, -36, -38, -37, -37, -36, -36, -38, -37, -37, -37, -37, -36, -37, -37, -37,
-36, -37, -37, -37, -37, -37, -36, -38, -37, -37, -37, -37, -37, -37, -37, -37,
-37, -37, -37, -37, -37, -37, -38, -36, -37, -37, -37, -36, -37, -37, -37, -38,
-34, -31, -30, -29, -29, -28, -29, -28, -28, -29, -28, -29, -26, -28, -25, -35,
-60, -63, -67, -68, -72, -73, -74, -76, -77, -78, -79, -80, -81, -82, -82, -83,
-83, -85, -85, -86, -87, -86, -87, -88, -89, -89, -89, -89, -90, -90, -91, -90,
-90, -91, -91, -92, -91, -92, -92, -93, -93, -93, -93, -92, -93, -92, -94, -92,
-94, -92, -95, -94, -96, -95, -96, -94, -97, -94, -98, -90, -19, 2, };