#define DATA_LENGTH 512
#define DATA AKWF_0636

const PROGMEM int8_t DATA[DATA_LENGTH] = {19, 30, 35, 41, 44, 49, 51, 55, 57,
61, 63, 66, 67, 69, 71, 73, 76, 78, 79, 81, 82, 83, 85, 86, 87, 89, 91, 92, 93,
94, 95, 97, 97, 99, 99, 100, 102, 102, 103, 104, 104, 106, 106, 107, 108, 109,
109, 110, 110, 110, 111, 112, 113, 112, 113, 113, 114, 114, 115, 113, 115, 114,
116, 114, 118, 115, 119, 114, 119, 112, 124, 95, 13, 5, -12, -6, 1, -1, 1, -1,
2, -1, 2, -1, 1, -1, 1, 18, 30, 33, 40, 42, 47, 50, 54, 55, 58, 61, 62, 64, 66,
68, 69, 72, 72, 75, 76, 77, 78, 80, 80, 82, 83, 83, 84, 85, 85, 86, 87, 87, 88,
88, 89, 89, 90, 88, 91, 89, 93, 83, 56, 49, 40, 34, 29, 24, 21, 17, 14, 11, 9,
7, 6, 3, 2, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, -16, -25, -29, -34, -37, -41, -43,
-46, -48, -51, -53, -55, -57, -59, -61, -62, -63, -65, -67, -69, -70, -71, -72,
-74, -75, -76, -78, -79, -80, -81, -82, -83, -85, -85, -85, -86, -88, -89, -89,
-91, -92, -93, -94, -93, -95, -96, -97, -98, -98, -98, -100, -100, -100, -102,
-101, -102, -103, -104, -104, -105, -106, -106, -106, -107, -108, -109, -109,
-109, -108, -109, -110, -111, -111, -111, -112, -112, -113, -113, -113, -113,
-113, -114, -115, -115, -115, -115, -116, -116, -116, -116, -118, -116, -117,
-117, -118, -118, -118, -117, -118, -118, -119, -119, -118, -119, -118, -119,
-119, -119, -119, -120, -118, -120, -116, -104, -100, -96, -93, -91, -88, -87,
-84, -83, -82, -80, -78, -77, -74, -73, -72, -72, -70, -69, -68, -68, -66, -66,
-64, -64, -62, -62, -60, -60, -60, -58, -57, -56, -56, -54, -54, -53, -53, -52,
-51, -49, -49, -49, -48, -47, -46, -47, -45, -46, -45, -44, -43, -42, -42, -41,
-41, -40, -39, -39, -39, -38, -38, -37, -37, -36, -35, -35, -34, -34, -34, -34,
-32, -32, -31, -32, -31, -30, -29, -29, -28, -29, -29, -27, -27, -27, -26, -26,
-26, -25, -25, -24, -23, -24, -23, -23, -23, -22, -22, -22, -22, -22, -20, -20,
-20, -19, -19, -19, -18, -18, -18, -17, -17, -17, -17, -16, -17, -15, -16, -15,
-15, -14, -15, -14, -13, -14, -13, -13, -13, -13, -12, -12, -11, -11, -11, -11,
-11, -11, -10, -11, -9, -9, -10, -10, -9, -9, -8, -8, -9, -8, -8, -8, -7, -7,
-7, -7, -6, -6, -7, -7, -6, -5, -5, -6, -5, -6, -5, -5, -4, -4, -5, -4, -4, -4,
-4, -4, -3, -3, -3, -3, -3, -3, -2, -2, -2, -2, -3, -2, -2, -1, -2, -1, -2, -2,
-2, -1, -1, -1, -1, -2, -1, -2, -1, 0, 0, -1, -1, 0, 0, -1, 0, -1, 0, -1, 0, 0,
0, -1, 0, -1, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, -1, 0, 0, -1,
0, 0, 1, };