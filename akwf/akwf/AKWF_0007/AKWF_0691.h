#define DATA_LENGTH 512
#define DATA AKWF_0691

const PROGMEM int8_t DATA[DATA_LENGTH] = {56, 61, 56, 60, 57, 59, 56, 57, 56,
57, 56, 56, 55, 56, 55, 55, 54, 55, 54, 54, 53, 55, 50, 90, 121, 116, 119, 116,
117, 116, 115, 114, 114, 113, 113, 112, 112, 111, 111, 110, 110, 109, 109, 108,
108, 107, 106, 106, 105, 105, 104, 103, 102, 102, 101, 102, 100, 100, 99, 98,
97, 97, 96, 97, 95, 96, 94, 94, 93, 93, 93, 92, 92, 90, 95, 57, 35, 39, 36, 38,
36, 36, 35, 35, 35, 35, 34, 35, 33, 34, 32, 33, 33, 32, 32, 32, 31, 30, 31, 30,
30, 30, 30, 30, 29, 30, 28, 29, 27, 29, 26, 30, 20, -11, -16, -15, -15, -15,
-15, -14, -15, -15, -15, -15, -15, -15, -16, -15, -15, -15, -15, -16, -15, -15,
-15, -16, -16, -15, -16, -15, -15, -15, -14, -15, -15, -15, -14, -15, -15, -14,
-15, -15, -14, -16, -15, -15, -14, -16, -14, -18, -39, -45, -42, -43, -41, -43,
-41, -42, -41, -41, -40, -40, -40, -40, -39, -40, -40, -39, -38, -38, -38, -37,
-38, -37, -37, -36, -36, -36, -35, -35, -36, -35, -36, -31, -41, -55, -51, -53,
-51, -51, -50, -50, -48, -48, -48, -47, -46, -47, -45, -44, -45, -43, -44, -42,
-43, -41, -41, -39, -40, -39, -38, -38, -38, -37, -37, -35, -35, -35, -33, -33,
-33, -32, -32, -31, -31, -30, -30, -29, -29, -28, -28, -27, -26, -25, -26, -24,
-24, -23, -24, -22, -22, -22, -21, -21, -19, -18, -19, -18, -17, -16, -15, -15,
-15, -14, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -14, -15, -15, -14,
-15, -14, -14, -14, -15, -14, -14, -14, -14, -14, -15, -14, -14, -14, -14, -15,
-15, -14, -15, -15, -14, -15, -14, -14, -15, -15, -14, -14, -15, -15, -15, -14,
-15, -15, -15, -14, -15, -15, -14, -15, -14, -14, -15, -15, -15, -14, -15, -14,
-14, -15, -14, -14, -14, -15, -14, -15, -15, -14, -14, -14, -15, -14, -14, -15,
-15, -15, -15, -14, -14, -15, -15, -14, -15, -14, -14, -14, -15, -14, -15, -14,
-14, -14, -15, -14, -14, -14, -14, -14, -15, -15, -15, -15, -15, -14, -15, -14,
-14, -14, -14, -14, -14, -14, -14, -15, -15, -14, -14, -14, -14, -14, -15, -14,
-14, -14, -15, -14, -14, -14, -14, -15, -15, -14, -15, -14, -15, -14, -14, -14,
-15, -14, -14, -14, -15, -14, -14, -14, -13, -14, -14, -14, -14, -15, -14, -14,
-14, -15, -15, -14, -14, -14, -15, -14, -15, -14, -14, -14, -14, -14, -14, -14,
-14, -15, -15, -15, -14, -14, -14, -14, -15, -14, -14, -14, -14, -14, -14, -15,
-14, -14, -14, -14, -14, -14, -14, -14, -15, -15, -15, -14, -14, -14, -14, -14,
-15, -14, -14, -14, -14, -14, -15, -14, -14, -14, -14, -14, -14, -15, -13, -14,
-14, -15, -14, -15, -14, -14, -14, -14, -14, -14, -14, -13, -14, -14, -15, -14,
-14, -13, -15, -14, -14, -14, -15, -13, -15, -12, };