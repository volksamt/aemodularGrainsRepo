#define DATA_LENGTH 512
#define DATA AKWF_0616

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 6, 8, 9, 12, 14, 17, 18, 19,
21, 24, 26, 28, 30, 33, 36, 37, 39, 41, 44, 45, 48, 50, 51, 54, 56, 58, 60, 62,
64, 66, 68, 70, 71, 74, 76, 78, 79, 81, 83, 85, 86, 88, 89, 92, 93, 94, 95, 97,
98, 99, 101, 103, 104, 105, 106, 106, 107, 109, 110, 111, 111, 111, 113, 113,
113, 115, 114, 116, 116, 117, 116, 118, 116, 119, 110, 60, 10, -13, -14, -11,
-11, -9, -6, -4, -2, 0, 3, 5, 8, 11, 13, 16, 19, 22, 23, 27, 30, 31, 34, 37, 40,
42, 45, 49, 51, 54, 56, 58, 60, 63, 64, 66, 70, 71, 73, 75, 76, 78, 79, 81, 82,
84, 85, 85, 86, 88, 88, 89, 89, 89, 90, 91, 90, 88, 85, 82, 77, 73, 69, 64, 59,
55, 50, 45, 40, 36, 32, 27, 21, 18, 13, 10, 6, 3, 0, -2, -6, -8, -10, -12, -13,
-13, -15, -15, -15, -14, -15, -15, -14, -14, -15, -15, -15, -15, -15, -14, -15,
-14, -15, -15, -15, -14, -14, -15, -15, -15, -15, -15, -14, -15, -15, -15, -15,
-15, -15, -15, -15, -15, -15, -14, -15, -14, -14, -14, -14, -15, -14, -14, -14,
-14, -15, -14, -15, -15, -15, -15, -14, -15, -16, -15, -15, -15, -14, -15, -14,
-15, -15, -15, -15, -15, -15, -15, -14, -14, -14, -14, -15, -14, -14, -15, -14,
-15, -15, -17, -21, -25, -30, -33, -38, -43, -50, -54, -58, -65, -69, -75, -79,
-85, -88, -93, -97, -101, -104, -107, -110, -113, -115, -116, -118, -118, -120,
-119, -118, -116, -115, -113, -110, -109, -106, -105, -102, -99, -98, -95, -93,
-90, -87, -85, -82, -79, -77, -74, -72, -69, -67, -64, -61, -59, -56, -54, -52,
-49, -46, -44, -42, -40, -38, -36, -33, -33, -31, -29, -28, -26, -24, -22, -21,
-20, -20, -18, -17, -17, -16, -15, -15, -14, -14, -14, -14, -13, -14, -13, -14,
-14, -14, -14, -15, -14, -14, -13, -14, -15, -14, -15, -14, -13, -14, -13, -14,
-13, -14, -13, -14, -14, -14, -14, -14, -14, -14, -14, -13, -14, -13, -14, -13,
-14, -14, -14, -14, -14, -14, -14, -14, -13, -14, -13, -14, -14, -14, -14, -14,
-14, -14, -13, -13, -14, -13, -14, -14, -13, -14, -14, -15, -14, -13, -13, -15,
-14, -14, -14, -14, -14, -13, -14, -14, -13, -14, -14, -14, -14, -14, -14, -14,
-13, -14, -14, -14, -15, -14, -13, -13, -13, -14, -14, -14, -13, -14, -14, -14,
-13, -14, -14, -14, -14, -14, -14, -14, -14, -13, -13, -14, -13, -13, -14, -14,
-14, -14, -14, -14, -14, -14, -14, -14, -13, -14, -14, -14, -13, -13, -13, -14,
-13, -14, -13, -14, -14, -14, -14, -14, -13, -14, -14, -13, -14, -14, -14, -14,
-14, -14, -13, -14, -13, -14, -13, -13, -14, -14, -14, -13, -13, -14, -13, -13,
-13, -14, -14, -13, -13, -14, -14, -12, -11, -10, -9, -7, -6, -4, -3, 0, };