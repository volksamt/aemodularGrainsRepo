#define DATA_LENGTH 512
#define DATA AKWF_0685

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 2, 12, 17, 22, 25, 30, 32, 36, 38,
41, 43, 45, 47, 49, 50, 52, 54, 54, 55, 56, 57, 57, 59, 58, 59, 59, 59, 60, 60,
60, 59, 59, 59, 59, 59, 58, 58, 58, 57, 57, 57, 56, 55, 55, 54, 54, 53, 52, 51,
50, 50, 49, 48, 48, 48, 46, 45, 44, 44, 44, 42, 41, 41, 41, 40, 40, 38, 38, 38,
37, 37, 36, 36, 35, 34, 34, 34, 34, 33, 33, 32, 32, 31, 31, 31, 31, 30, 30, 30,
29, 29, 29, 30, 29, 29, 30, 29, 29, 30, 30, 30, 31, 30, 29, 31, 30, 31, 31, 32,
32, 32, 33, 32, 33, 33, 32, 32, 31, 33, 31, 31, 31, 29, 29, 27, 27, 26, 25, 24,
22, 22, 20, 19, 17, 16, 14, 13, 11, 10, 9, 7, 5, 4, 2, 2, 0, 0, -2, -2, -5, -6,
-8, -9, -12, -13, -15, -17, -19, -23, -24, -27, -29, -31, -33, -36, -38, -41,
-44, -46, -48, -50, -53, -56, -58, -60, -63, -65, -67, -69, -71, -75, -76, -79,
-80, -83, -85, -87, -89, -91, -92, -94, -97, -98, -99, -101, -103, -104, -106,
-106, -108, -110, -110, -111, -113, -113, -114, -115, -115, -117, -117, -117,
-118, -118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -118, -117,
-117, -117, -115, -116, -114, -113, -112, -112, -111, -109, -108, -108, -106,
-105, -104, -102, -101, -99, -98, -96, -95, -92, -92, -89, -88, -85, -84, -82,
-80, -78, -77, -74, -73, -71, -69, -66, -65, -62, -60, -58, -57, -54, -52, -50,
-48, -46, -44, -42, -40, -38, -36, -35, -33, -30, -28, -27, -24, -23, -21, -19,
-18, -16, -14, -13, -12, -10, -8, -7, -5, -5, -3, -2, -2, -1, 0, 1, 2, 2, 3, 4,
6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 22, 23, 22, 24, 24, 25,
26, 27, 28, 28, 29, 29, 30, 30, 31, 31, 32, 32, 32, 34, 33, 33, 34, 33, 33, 33,
34, 34, 34, 33, 33, 34, 33, 33, 33, 32, 33, 32, 32, 32, 31, 31, 31, 30, 29, 29,
28, 28, 27, 26, 26, 26, 24, 24, 23, 23, 22, 20, 20, 20, 19, 17, 17, 16, 15, 14,
13, 12, 12, 11, 11, 10, 9, 8, 8, 8, 6, 5, 4, 4, 3, 3, 2, 2, 0, 1, 0, 0, -1, -1,
-2, -3, -4, -3, -3, -5, -5, -6, -7, -8, -8, -9, -9, -9, -10, -11, -11, -12, -13,
-13, -14, -15, -15, -16, -16, -17, -18, -18, -19, -19, -19, -20, -19, -21, -21,
-21, -21, -22, -22, -23, -23, -22, -22, -24, -24, -23, -23, -23, -24, -23, -23,
-24, -23, -24, -24, -22, -22, -23, -22, -22, -23, -21, -22, -21, -21, -21, -21,
-19, -19, -19, -19, -18, -17, -17, -17, -15, -16, -15, -14, -13, -14, -12, -12,
-11, -11, -10, -9, -9, -8, -7, -7, -6, -5, -4, -4, -4, -3, -2, -2, -1, -1, 0, };