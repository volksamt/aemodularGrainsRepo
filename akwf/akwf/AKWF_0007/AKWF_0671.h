#define DATA_LENGTH 512
#define DATA AKWF_0671

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 9, 11, 13, 16, 19, 21, 23,
26, 27, 29, 32, 34, 36, 38, 41, 42, 45, 47, 49, 51, 53, 56, 57, 59, 62, 63, 65,
66, 68, 71, 73, 74, 76, 78, 79, 81, 83, 85, 86, 88, 89, 91, 92, 93, 94, 97, 97,
99, 100, 101, 103, 104, 104, 106, 107, 108, 109, 110, 110, 112, 112, 113, 113,
114, 115, 115, 115, 117, 117, 118, 117, 118, 118, 119, 119, 119, 120, 119, 120,
118, 119, 119, 119, 119, 118, 118, 118, 117, 118, 116, 116, 115, 116, 114, 115,
114, 112, 112, 111, 110, 109, 108, 107, 107, 106, 105, 104, 104, 101, 101, 99,
98, 97, 96, 95, 92, 93, 90, 90, 88, 86, 84, 83, 82, 80, 78, 77, 75, 73, 71, 70,
69, 67, 65, 63, 61, 60, 57, 56, 54, 53, 50, 49, 47, 44, 43, 40, 38, 37, 35, 34,
31, 29, 27, 25, 23, 21, 19, 18, 15, 14, 11, 10, 7, 5, 3, 1, -1, -2, -5, -6, -8,
-10, -13, -14, -17, -19, -20, -22, -24, -27, -27, -30, -32, -34, -35, -36, -38,
-40, -43, -44, -46, -48, -50, -51, -53, -54, -56, -58, -59, -62, -62, -65, -66,
-68, -70, -70, -72, -73, -75, -76, -77, -79, -80, -82, -82, -85, -85, -86, -88,
-89, -90, -91, -93, -93, -94, -96, -96, -98, -98, -100, -100, -101, -102, -103,
-104, -105, -106, -107, -108, -108, -108, -109, -110, -110, -111, -112, -112,
-113, -113, -114, -114, -115, -115, -115, -116, -116, -117, -117, -117, -118,
-118, -118, -118, -118, -118, -118, -119, -119, -119, -118, -119, -119, -119,
-118, -118, -118, -118, -119, -118, -119, -119, -118, -118, -119, -117, -117,
-117, -116, -117, -116, -116, -116, -115, -115, -115, -114, -114, -113, -113,
-113, -113, -112, -111, -111, -110, -109, -109, -108, -108, -108, -107, -106,
-105, -105, -104, -104, -103, -102, -102, -101, -101, -99, -100, -99, -98, -97,
-96, -96, -95, -95, -94, -93, -92, -91, -90, -90, -90, -88, -87, -87, -86, -85,
-84, -85, -83, -82, -81, -80, -81, -78, -79, -77, -76, -76, -75, -75, -73, -72,
-71, -72, -70, -70, -69, -68, -67, -66, -66, -65, -64, -63, -62, -61, -60, -59,
-59, -58, -58, -57, -56, -55, -55, -53, -52, -53, -51, -50, -50, -49, -49, -48,
-46, -47, -45, -44, -44, -43, -42, -42, -41, -41, -40, -39, -39, -37, -36, -36,
-35, -36, -34, -34, -33, -33, -32, -31, -30, -30, -30, -29, -29, -27, -26, -26,
-26, -25, -24, -25, -24, -23, -22, -23, -21, -21, -20, -20, -19, -19, -18, -18,
-17, -17, -17, -16, -16, -14, -15, -14, -13, -13, -13, -13, -12, -12, -12, -10,
-11, -10, -10, -9, -10, -9, -8, -8, -7, -7, -8, -6, -7, -7, -6, -6, -5, -5, -5,
-5, -5, -5, -4, -5, -4, -4, -3, -3, -3, -4, -3, -3, -3, -2, -3, -3, -2, -2, -2,
-3, -1, -2, -1, -2, -2, -2, -2, -1, -1, -1, -1, -1, 0, };