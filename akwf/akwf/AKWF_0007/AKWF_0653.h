#define DATA_LENGTH 512
#define DATA AKWF_0653

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 10, 14, 17, 21, 25, 28, 32, 35,
39, 43, 46, 49, 52, 56, 58, 62, 65, 68, 71, 74, 76, 79, 82, 83, 87, 88, 90, 91,
95, 96, 97, 99, 101, 101, 103, 104, 105, 106, 106, 107, 107, 107, 107, 107, 108,
107, 107, 108, 107, 106, 107, 108, 107, 107, 107, 108, 107, 107, 107, 107, 107,
106, 107, 107, 107, 107, 107, 107, 106, 106, 107, 106, 107, 106, 107, 106, 106,
105, 105, 106, 105, 105, 105, 105, 105, 105, 104, 104, 104, 104, 103, 104, 103,
103, 103, 103, 103, 103, 103, 102, 101, 102, 102, 101, 101, 101, 101, 100, 100,
99, 99, 99, 99, 99, 98, 98, 98, 97, 97, 98, 97, 96, 96, 95, 95, 95, 94, 94, 94,
93, 93, 92, 92, 92, 92, 91, 91, 91, 89, 90, 89, 89, 88, 87, 87, 86, 86, 86, 86,
85, 84, 84, 84, 83, 82, 82, 80, 81, 80, 80, 79, 79, 78, 77, 76, 76, 75, 75, 75,
73, 73, 72, 73, 71, 71, 70, 69, 69, 68, 68, 66, 67, 65, 65, 64, 63, 62, 62, 61,
61, 59, 59, 59, 57, 57, 56, 55, 55, 54, 53, 53, 52, 50, 50, 49, 48, 47, 47, 46,
45, 44, 44, 43, 41, 41, 40, 39, 38, 37, 37, 36, 36, 35, 33, 32, 32, 30, 30, 28,
27, 27, 26, 25, 25, 23, 22, 22, 21, 20, 19, 19, 18, 17, 15, 15, 13, 13, 11, 11,
11, 10, 8, 7, 7, 5, 4, 3, 3, 2, 1, 0, -1, -2, -4, -4, -5, -6, -6, -8, -8, -10,
-11, -12, -12, -13, -14, -16, -17, -17, -18, -19, -21, -21, -22, -23, -24, -25,
-26, -27, -28, -28, -29, -30, -31, -33, -33, -34, -35, -36, -37, -38, -39, -40,
-41, -42, -43, -43, -45, -46, -46, -47, -48, -49, -50, -51, -52, -52, -53, -55,
-55, -55, -57, -58, -59, -60, -60, -61, -62, -63, -64, -64, -65, -66, -66, -68,
-68, -69, -71, -71, -72, -73, -73, -74, -76, -76, -77, -77, -77, -78, -80, -80,
-81, -81, -83, -82, -84, -84, -85, -85, -87, -88, -88, -89, -90, -90, -91, -91,
-92, -92, -93, -93, -95, -95, -95, -96, -97, -97, -98, -98, -99, -99, -101,
-100, -101, -102, -102, -103, -103, -103, -104, -106, -104, -106, -106, -107,
-107, -108, -108, -108, -108, -109, -110, -110, -111, -110, -111, -111, -112,
-112, -113, -112, -113, -114, -114, -115, -114, -115, -115, -115, -115, -116,
-116, -116, -117, -117, -117, -117, -118, -117, -117, -117, -118, -118, -117,
-118, -118, -118, -118, -118, -119, -119, -118, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -118, -118, -118, -118, -118, -117,
-116, -117, -116, -115, -114, -114, -114, -113, -111, -111, -109, -107, -107,
-105, -104, -101, -101, -98, -97, -94, -93, -90, -88, -85, -82, -79, -77, -74,
-72, -69, -67, -64, -61, -56, -54, -50, -48, -44, -40, -37, -34, -30, -27, -22,
-19, -15, -12, -7, -4, 0, };