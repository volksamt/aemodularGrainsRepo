#define DATA_LENGTH 512
#define DATA AKWF_0680

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 16, 25, 31, 30, 15, 14, 7, 30, 30,
17, 34, 22, 30, 35, 29, 27, 14, 38, 37, 21, 23, 4, 11, 21, 13, 15, 19, 8, 13, 3,
4, -15, -4, 7, -18, 2, 5, 3, 0, 10, 17, 9, 2, 8, 6, 3, 0, 32, 19, 11, 20, 20,
42, 22, 18, 15, 27, 22, 7, 19, 22, 1, 13, 30, 32, 40, 22, 19, 20, 16, 29, 43,
48, 45, 30, 37, 57, 54, 55, 54, 38, 70, 79, 54, 54, 79, 72, 54, 81, 82, 53, 64,
69, 52, 71, 58, 45, 64, 64, 54, 68, 41, 29, 42, 51, 60, 28, 33, 20, 29, 37, 15,
19, 34, 20, 6, 14, 10, 28, 4, 2, 8, 11, 13, -1, 17, 9, -19, 4, 4, -11, -1, -13,
4, -7, 0, 14, 9, 19, 21, 15, 2, 21, 24, 20, 21, 17, 22, 32, 33, 21, 21, 30, 33,
36, 20, 21, 29, 22, 29, 46, 56, 44, 44, 60, 71, 69, 70, 61, 67, 86, 88, 94, 101,
106, 110, 116, 120, 114, 120, 100, 96, 101, 86, 85, 95, 108, 75, 71, 60, 62, 71,
39, 17, 12, 8, -8, -7, -21, -15, -21, -39, -46, -49, -47, -48, -53, -58, -57,
-80, -75, -63, -87, -104, -100, -79, -74, -84, -82, -65, -57, -75, -86, -78,
-60, -66, -79, -56, -62, -56, -45, -66, -64, -36, -34, -38, -22, -46, -34, -22,
-15, -10, -11, 11, 1, 10, 10, 14, 39, 40, 40, 53, 36, 41, 61, 58, 76, 73, 87,
75, 74, 76, 64, 63, 57, 68, 62, 62, 50, 48, 55, 46, 56, 61, 34, 43, 40, 33, 29,
14, 30, 20, 15, 2, -2, 1, -10, -40, -30, -30, -55, -60, -64, -52, -43, -53, -72,
-72, -72, -71, -75, -60, -70, -93, -87, -86, -91, -77, -68, -94, -92, -60, -80,
-98, -81, -72, -65, -63, -43, -46, -41, -36, -41, -33, -33, -19, -6, 1, 1, -6,
-2, -4, -8, 0, 1, 9, 21, 21, 28, 17, 8, 14, 6, 31, 35, 16, 25, 27, 4, 11, 25,
24, 33, 28, 23, 6, 19, 26, 27, 31, 33, 33, 36, 37, 40, 33, 20, 35, 22, 5, 5, 24,
7, 15, 19, -2, 9, -12, -28, -26, -40, -28, -17, -49, -36, -25, -40, -68, -65,
-61, -64, -67, -72, -62, -64, -83, -94, -73, -88, -83, -97, -98, -90, -99, -103,
-92, -77, -92, -81, -73, -61, -68, -90, -89, -69, -80, -68, -70, -84, -85, -80,
-54, -77, -77, -54, -73, -70, -53, -80, -57, -58, -76, -68, -74, -46, -58, -52,
-46, -33, -36, -31, -38, -43, -19, -23, 1, -12, -17, -8, -18, -19, -13, -3, -16,
-28, -8, -7, -25, -22, -15, -13, 0, -1, -5, -5, -21, -5, 2, -16, -9, -9, -22,
-5, -2, -22, 8, 1, -15, -1, -10, 11, 1, -10, -7, -1, -12, -9, 14, -11, 6, 5, -6,
4, -12, -9, 3, 16, 11, 8, -2, -4, 15, 13, 8, 26, 8, 8, 30, 21, 14, -1, };