#define DATA_LENGTH 512
#define DATA AKWF_0656

const PROGMEM int8_t DATA[DATA_LENGTH] = {74, 89, 81, 87, 83, 86, 84, 86, 84,
85, 84, 86, 84, 85, 84, 85, 84, 86, 85, 84, 85, 85, 85, 84, 86, 84, 85, 84, 85,
84, 85, 84, 85, 84, 85, 85, 84, 85, 84, 85, 84, 85, 84, 86, 84, 85, 83, 85, 85,
86, 84, 85, 84, 84, 85, 82, 90, 19, -7, 4, -3, 4, -2, 2, -1, 1, -1, 2, 0, 1, 0,
1, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0,
0, 1, 0, 0, 0, 1, 0, 1, 1, 0, 0, 0, -1, 0, 0, 1, -1, 0, 0, 0, 1, 0, 0, 1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0,
1, 1, 1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 1, 0, 1, 0, 1, 0,
0, 0, 1, 0, 0, 1, -1, 1, -1, 1, -1, 1, -1, 2, -2, 2, -3, 2, -3, 3, -4, 6, -8,
22, 127, 117, 120, 119, 118, 120, 118, 120, 118, 120, 118, 120, 118, 120, 118,
120, 118, 119, 119, 119, 120, 119, 119, 118, 119, 118, 119, 119, 119, 118, 119,
118, 119, 119, 119, 119, 118, 119, 118, 119, 118, 120, 117, 121, 117, 121, 116,
122, 116, 123, 116, 122, 114, 123, 113, 125, 105, -81, -88, -81, -88, -82, -88,
-82, -88, -82, -86, -83, -87, -83, -86, -82, -86, -83, -86, -84, -85, -84, -84,
-85, -84, -85, -84, -85, -85, -85, -84, -85, -84, -85, -84, -85, -84, -85, -85,
-85, -85, -85, -85, -84, -85, -84, -86, -84, -85, -84, -86, -84, -86, -84, -84,
-85, -84, -87, -11, 4, -4, 2, -3, 2, -2, 2, -2, 1, -1, 1, -1, 1, -1, 0, 0, 0,
-1, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, -1, -1, -1, 1, 0, 1, -1, 0, -1, 0, 0, 0, -1,
0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, -1,
-1, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0,
1, -1, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 1, 0, 0, -1, 1, 0, 1, 0, 1, -1,
0, -1, 0, -1, 0, 0, 0, -1, 0, 0, -1, 0, -1, 1, -1, 1, -2, 2, -3, 3, -3, 4, -7,
12, -34, -128, -114, -122, -118, -120, -119, -119, -119, -118, -119, -118, -121,
-118, -120, -118, -119, -118, -119, -118, -120, -118, -120, -119, -120, -119,
-120, -119, -119, -119, -119, -119, -118, -119, -118, -119, -118, -118, -119,
-119, -119, -118, -119, -118, -119, -117, -120, -117, -120, -117, -121, -116,
-122, -116, -123, -113, -125, -100, };