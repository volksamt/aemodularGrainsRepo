#define DATA_LENGTH 512
#define DATA AKWF_0601

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 28, 28, 27, 28, 27, 28, 26, 27, 27,
27, 27, 28, 27, 28, 28, 28, 27, 28, 27, 27, 28, 28, 28, 27, 27, 27, 27, 27, 27,
28, 27, 27, 28, 27, 27, 27, 27, 27, 27, 27, 27, 27, 27, 27, 27, 27, 28, 27, 26,
27, 27, 45, 49, 48, 50, 50, 51, 52, 52, 53, 54, 54, 55, 55, 57, 57, 58, 58, 59,
60, 60, 62, 62, 62, 64, 64, 65, 66, 66, 66, 67, 67, 68, 68, 70, 70, 72, 72, 72,
74, 74, 75, 75, 76, 76, 77, 79, 79, 80, 79, 80, 81, 82, 83, 83, 84, 85, 86, 86,
87, 87, 88, 88, 90, 91, 92, 91, 93, 92, 93, 94, 95, 96, 97, 97, 97, 98, 99, 99,
101, 102, 102, 102, 103, 103, 105, 105, 105, 106, 107, 108, 108, 109, 110, 111,
111, 112, 113, 114, 113, 114, 115, 116, 116, 118, 118, 118, 118, 117, 116, 115,
114, 112, 111, 110, 109, 107, 105, 105, 103, 102, 100, 99, 98, 97, 95, 94, 92,
91, 90, 88, 88, 87, 85, 84, 82, 81, 79, 79, 77, 76, 74, 73, 72, 70, 69, 68, 66,
66, 65, 63, 62, 61, 60, 57, 57, 54, 55, 52, 53, 50, 50, 46, 49, 38, -5, -4, -6,
-8, -8, -10, -10, -13, -13, -15, -15, -18, -18, -20, -21, -23, -23, -25, -27,
-28, -29, -31, -31, -32, -34, -35, -36, -37, -39, -41, -41, -43, -44, -45, -47,
-48, -48, -51, -52, -52, -53, -55, -56, -58, -59, -60, -61, -62, -64, -65, -66,
-68, -69, -70, -72, -72, -73, -75, -76, -78, -79, -80, -81, -82, -84, -85, -86,
-88, -88, -89, -91, -93, -94, -94, -96, -97, -99, -99, -101, -102, -101, -100,
-99, -99, -98, -98, -97, -97, -97, -96, -95, -95, -95, -95, -94, -93, -93, -93,
-91, -92, -90, -90, -89, -90, -89, -88, -88, -88, -88, -87, -86, -86, -86, -85,
-85, -84, -83, -82, -82, -82, -81, -81, -81, -80, -79, -79, -78, -79, -78, -77,
-77, -76, -76, -75, -75, -75, -73, -74, -73, -72, -72, -71, -71, -71, -70, -70,
-69, -68, -68, -68, -67, -67, -67, -67, -65, -65, -64, -64, -64, -63, -63, -62,
-62, -61, -61, -61, -59, -59, -59, -58, -58, -57, -58, -56, -56, -56, -55, -55,
-55, -54, -52, -53, -52, -51, -52, -50, -50, -50, -49, -49, -49, -48, -48, -46,
-47, -46, -46, -46, -45, -44, -44, -43, -43, -43, -43, -41, -42, -41, -40, -40,
-39, -39, -38, -38, -38, -37, -36, -36, -36, -34, -35, -35, -35, -33, -32, -32,
-31, -32, -31, -30, -30, -29, -29, -28, -28, -28, -27, -27, -26, -27, -26, -24,
-24, -24, -23, -23, -23, -22, -22, -22, -21, -20, -19, -20, -19, -18, -18, -18,
-17, -16, -16, -15, -15, -14, -15, -14, -14, -14, -13, -13, -12, -10, -11, -10,
-11, -10, -9, -8, -8, -8, -7, -7, -6, -6, -5, -5, -5, -3, -4, -3, -3, -2, -1,
-2, -1, 0, };