#define DATA_LENGTH 512
#define DATA AKWF_0677

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 7, 14, 20, 27, 33, 40, 47, 52, 58,
65, 71, 76, 80, 85, 90, 94, 98, 102, 104, 109, 110, 113, 115, 116, 117, 118,
119, 119, 118, 118, 117, 116, 115, 113, 112, 108, 106, 103, 101, 98, 94, 90, 87,
83, 79, 75, 72, 68, 64, 58, 55, 51, 47, 42, 39, 35, 31, 28, 24, 21, 18, 15, 13,
10, 7, 6, 4, 2, 1, -1, -3, -3, -3, -4, -4, -4, -4, -4, -3, -2, -3, -1, 0, 0, 2,
3, 5, 6, 8, 10, 10, 14, 14, 16, 18, 20, 21, 22, 24, 25, 26, 27, 29, 30, 31, 31,
32, 32, 33, 33, 34, 34, 33, 33, 32, 32, 31, 30, 30, 29, 28, 27, 25, 25, 23, 22,
20, 19, 17, 16, 14, 12, 11, 9, 8, 6, 4, 4, 2, 0, -1, -2, -4, -4, -5, -6, -7, -7,
-8, -9, -9, -10, -10, -9, -10, -10, -9, -9, -9, -8, -8, -7, -7, -5, -4, -4, -3,
-2, 0, 1, 2, 3, 4, 5, 7, 7, 8, 9, 10, 11, 12, 12, 14, 14, 15, 15, 16, 16, 17,
17, 17, 18, 18, 17, 17, 16, 17, 17, 16, 16, 15, 14, 13, 12, 11, 10, 9, 8, 7, 6,
5, 4, 2, 1, 0, -1, -2, -3, -5, -5, -7, -8, -9, -11, -10, -12, -13, -14, -15,
-15, -15, -16, -16, -17, -18, -17, -17, -17, -17, -17, -17, -17, -16, -16, -16,
-15, -15, -14, -12, -13, -11, -10, -10, -9, -8, -7, -6, -5, -4, -2, -2, -1, 0,
1, 2, 4, 4, 4, 5, 6, 7, 7, 8, 8, 9, 8, 10, 10, 9, 9, 9, 9, 9, 9, 10, 8, 8, 8, 7,
6, 6, 5, 3, 3, 1, 1, 0, -2, -2, -4, -5, -7, -7, -9, -10, -11, -13, -13, -16,
-16, -18, -19, -20, -21, -23, -23, -25, -26, -27, -28, -29, -29, -30, -31, -31,
-32, -32, -32, -33, -33, -34, -33, -33, -33, -33, -33, -32, -32, -32, -32, -31,
-29, -29, -28, -28, -27, -26, -25, -23, -23, -21, -20, -19, -18, -17, -15, -15,
-14, -12, -11, -9, -9, -7, -6, -5, -4, -3, -2, -1, 0, 0, 1, 2, 1, 3, 3, 4, 4, 4,
4, 5, 4, 5, 4, 4, 3, 3, 2, 2, 1, 0, 0, -2, -3, -4, -6, -7, -9, -9, -11, -13,
-15, -18, -20, -21, -23, -25, -27, -30, -32, -34, -36, -40, -42, -44, -47, -49,
-51, -54, -57, -60, -62, -64, -67, -70, -72, -74, -77, -79, -82, -84, -87, -89,
-91, -94, -95, -97, -99, -100, -102, -104, -106, -108, -108, -110, -111, -112,
-114, -114, -116, -116, -118, -117, -118, -119, -119, -119, -120, -119, -119,
-118, -118, -118, -117, -117, -116, -115, -114, -113, -112, -110, -109, -107,
-106, -105, -103, -100, -100, -97, -95, -92, -90, -88, -86, -83, -80, -78, -76,
-73, -69, -66, -64, -62, -58, -55, -53, -49, -46, -43, -40, -37, -34, -30, -27,
-24, -21, -17, -14, -10, -8, -4, };