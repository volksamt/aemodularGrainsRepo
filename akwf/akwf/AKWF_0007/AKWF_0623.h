#define DATA_LENGTH 512
#define DATA AKWF_0623

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 8, 12, 13, 15, 17, 19, 21, 22, 24,
24, 26, 27, 28, 30, 31, 31, 32, 33, 35, 35, 36, 37, 37, 38, 39, 39, 41, 41, 40,
42, 41, 43, 43, 43, 44, 44, 44, 43, 44, 44, 44, 42, 41, 39, 39, 39, 38, 38, 36,
36, 35, 35, 34, 33, 33, 33, 32, 33, 32, 31, 30, 30, 29, 30, 29, 28, 28, 28, 28,
27, 27, 26, 26, 25, 25, 26, 25, 24, 24, 24, 24, 24, 23, 22, 22, 21, 22, 21, 21,
20, 20, 20, 20, 20, 20, 19, 19, 18, 19, 18, 17, 18, 17, 17, 17, 17, 16, 16, 15,
16, 16, 15, 16, 15, 15, 14, 13, 14, 13, 14, 14, 13, 13, 13, 13, 13, 11, 11, 12,
11, 11, 11, 10, 11, 10, 10, 10, 10, 9, 9, 9, 9, 9, 9, 8, 9, 8, 8, 8, 8, 7, 7, 8,
7, 7, 6, 7, 6, 6, 6, 6, 6, 5, 6, 5, 6, 5, 5, 4, 5, 4, 5, 5, 5, 4, 5, 4, 4, 4, 4,
3, 4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 2, 2, 2, 2, 2, 1, 2, 1, 2, 2, 1, 1, 1, 2,
2, 1, 1, 1, 2, 0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 0, 0, 0, 0, 1, 0, 1, 0, 0, 1, 0,
-1, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 1, -5, -25, -33, -43, -50,
-57, -64, -69, -75, -80, -85, -89, -93, -97, -101, -103, -107, -109, -112, -114,
-115, -116, -117, -118, -119, -121, -111, -101, -97, -91, -86, -82, -79, -75,
-71, -68, -65, -61, -59, -56, -53, -51, -48, -45, -43, -41, -38, -36, -34, -32,
-30, -29, -26, -25, -23, -21, -20, -18, -17, -17, -14, -13, -11, -11, -10, -8,
-8, -7, -5, -5, -4, -4, -4, -3, -2, -2, -1, -1, -1, 0, 0, -1, 0, 0, 0, -1, -1,
0, 0, -1, 0, -1, 0, -1, 0, 0, -1, 0, 0, -1, 0, 0, -1, -7, -15, -17, -22, -25,
-27, -31, -32, -35, -38, -39, -42, -42, -44, -47, -48, -48, -49, -50, -52, -52,
-53, -53, -53, -54, -52, -44, -41, -38, -35, -33, -31, -28, -25, -24, -22, -20,
-18, -17, -16, -15, -13, -11, -11, -9, -9, -7, -6, -5, -5, -4, -4, -3, -3, -1,
-1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, -1, 1, 0, 0, -1, 2, 8,
10, 14, 15, 18, 20, 21, 23, 24, 25, 26, 26, 27, 28, 28, 28, 26, 21, 19, 16, 14,
12, 10, 10, 8, 7, 5, 5, 3, 2, 2, 1, 0, 0, -1, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 1, 0, -1, 1, 0, -1, 0, 0, 0, 0,
0, 0, 0, -1, 1, 1, 0, };