#define DATA_LENGTH 512
#define DATA AKWF_0652

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 16, 20, 24, 26, 30, 33, 37,
40, 43, 48, 50, 52, 55, 59, 61, 64, 67, 69, 72, 73, 76, 78, 81, 83, 85, 88, 89,
91, 93, 94, 96, 98, 100, 101, 102, 104, 105, 107, 107, 109, 109, 111, 111, 113,
113, 114, 115, 115, 116, 118, 118, 118, 117, 118, 119, 120, 119, 120, 116, 111,
109, 107, 105, 102, 101, 99, 97, 96, 94, 93, 91, 91, 89, 89, 88, 86, 85, 84, 82,
82, 81, 79, 78, 77, 76, 75, 75, 73, 72, 72, 71, 70, 69, 68, 67, 66, 66, 65, 64,
62, 62, 62, 61, 60, 59, 58, 57, 56, 55, 55, 54, 54, 52, 52, 51, 51, 50, 49, 49,
47, 46, 47, 46, 45, 44, 43, 43, 42, 41, 41, 41, 40, 39, 38, 37, 38, 37, 36, 35,
35, 34, 34, 34, 33, 31, 32, 30, 30, 29, 29, 28, 28, 27, 27, 26, 26, 25, 24, 25,
23, 23, 22, 21, 21, 20, 20, 19, 19, 18, 19, 17, 16, 17, 16, 15, 14, 14, 14, 13,
13, 12, 12, 12, 11, 11, 10, 10, 9, 9, 8, 8, 7, 7, 6, 6, 5, 5, 4, 4, 4, 2, 3, 1,
2, 1, 1, 0, 0, -1, -1, -1, -2, -3, -3, -4, -4, -5, -5, -5, -5, -6, -5, -6, -7,
-7, -7, -8, -9, -9, -9, -10, -10, -11, -11, -11, -12, -12, -13, -13, -13, -14,
-14, -14, -15, -15, -16, -16, -17, -17, -17, -17, -17, -18, -18, -18, -19, -19,
-20, -20, -20, -20, -21, -21, -22, -22, -23, -23, -23, -23, -24, -24, -24, -25,
-26, -25, -26, -25, -27, -26, -27, -27, -27, -28, -28, -29, -29, -29, -29, -30,
-30, -29, -30, -31, -32, -31, -32, -32, -32, -33, -32, -34, -33, -34, -34, -33,
-34, -34, -35, -35, -35, -35, -36, -36, -36, -37, -37, -37, -37, -38, -38, -39,
-38, -39, -39, -40, -40, -40, -41, -39, -40, -41, -40, -41, -41, -41, -42, -41,
-42, -42, -42, -43, -43, -43, -43, -44, -44, -43, -44, -45, -44, -44, -45, -45,
-46, -46, -46, -45, -46, -46, -47, -48, -47, -48, -48, -48, -48, -48, -48, -48,
-48, -49, -49, -49, -49, -49, -50, -50, -51, -50, -50, -49, -50, -50, -51, -51,
-51, -52, -51, -52, -52, -52, -52, -52, -52, -53, -53, -53, -52, -53, -53, -53,
-53, -54, -54, -54, -54, -54, -54, -54, -54, -55, -54, -55, -55, -56, -54, -55,
-55, -56, -56, -56, -56, -56, -56, -56, -57, -57, -56, -56, -57, -56, -56, -56,
-57, -57, -58, -57, -57, -57, -57, -57, -57, -57, -57, -57, -58, -57, -58, -58,
-57, -58, -58, -58, -58, -58, -58, -58, -59, -58, -58, -59, -59, -58, -58, -58,
-59, -59, -59, -59, -59, -58, -59, -59, -59, -59, -60, -60, -59, -59, -59, -59,
-59, -59, -59, -59, -59, -59, -60, -60, -59, -59, -60, -59, -59, -59, -59, -60,
-59, -60, -59, -59, -59, -43, -32, -25, -18, -12, -6, -1, };