#define DATA_LENGTH 512
#define DATA AKWF_0682

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 9, 13, 17, 19, 21, 24, 27, 29, 30,
32, 35, 36, 38, 40, 41, 44, 45, 46, 49, 50, 51, 54, 55, 57, 58, 61, 61, 64, 66,
67, 69, 71, 72, 74, 75, 77, 79, 81, 82, 84, 87, 88, 90, 92, 94, 95, 97, 98, 101,
101, 106, 105, 109, 109, 114, 112, 119, 113, 88, 114, 118, 115, 114, 110, 111,
107, 106, 104, 102, 100, 100, 96, 97, 94, 93, 91, 90, 88, 87, 85, 85, 83, 81,
80, 79, 77, 76, 75, 74, 73, 72, 71, 69, 67, 66, 66, 65, 64, 63, 62, 61, 59, 58,
57, 57, 56, 55, 54, 52, 51, 51, 49, 50, 48, 47, 47, 45, 44, 43, 43, 42, 42, 41,
40, 39, 38, 38, 37, 35, 35, 35, 34, 33, 32, 32, 31, 30, 29, 28, 28, 27, 27, 26,
25, 25, 24, 24, 22, 22, 21, 21, 21, 19, 18, 18, 17, 17, 16, 16, 15, 15, 14, 14,
13, 12, 12, 10, 10, 10, 9, 8, 8, 7, 7, 6, 5, 5, 5, 4, 3, 3, 1, 1, 0, 0, -1, -1,
0, -2, -2, -3, -3, -4, -4, -5, -6, -6, -7, -7, -8, -9, -10, -9, -10, -11, -11,
-12, -12, -13, -13, -14, -14, -15, -16, -16, -17, -18, -19, -19, -19, -20, -21,
-21, -21, -22, -23, -23, -24, -25, -25, -26, -27, -27, -27, -29, -29, -30, -30,
-31, -31, -32, -32, -33, -34, -34, -35, -35, -36, -37, -38, -38, -39, -39, -40,
-41, -41, -43, -42, -43, -44, -46, -45, -46, -47, -47, -48, -49, -50, -51, -52,
-52, -53, -53, -55, -55, -55, -57, -57, -57, -59, -59, -61, -61, -62, -62, -64,
-64, -65, -65, -67, -67, -68, -69, -70, -71, -71, -73, -74, -74, -75, -76, -76,
-78, -79, -80, -81, -82, -82, -84, -85, -85, -87, -87, -89, -90, -90, -91, -92,
-93, -94, -95, -97, -98, -98, -100, -102, -102, -104, -105, -105, -107, -107,
-109, -109, -112, -111, -115, -114, -117, -114, -123, -96, -71, -120, -117,
-116, -116, -114, -113, -111, -112, -108, -109, -107, -106, -104, -105, -102,
-102, -99, -99, -98, -97, -96, -95, -94, -94, -93, -92, -90, -89, -88, -87, -86,
-86, -84, -83, -83, -82, -81, -81, -80, -78, -77, -76, -75, -74, -74, -73, -72,
-71, -71, -70, -69, -68, -68, -67, -66, -65, -63, -64, -62, -62, -62, -60, -60,
-59, -58, -57, -57, -56, -55, -55, -54, -53, -53, -51, -50, -50, -50, -49, -48,
-49, -47, -46, -45, -44, -45, -44, -44, -42, -43, -41, -42, -40, -39, -38, -38,
-38, -37, -36, -36, -36, -35, -34, -33, -33, -33, -32, -31, -31, -30, -31, -29,
-29, -29, -28, -26, -27, -27, -26, -25, -24, -24, -23, -23, -22, -22, -22, -20,
-21, -20, -19, -19, -18, -18, -17, -16, -17, -16, -15, -14, -14, -13, -14, -13,
-12, -12, -12, -10, -10, -10, -9, -9, -8, -7, -8, -7, -6, -6, -6, -4, -4, -3,
-4, -2, -3, -2, -2, -1, 0, };