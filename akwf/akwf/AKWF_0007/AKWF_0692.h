#define DATA_LENGTH 512
#define DATA AKWF_0692

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 1, 2, 5, 4, 6, 5, 13, 34, 44, 52,
58, 63, 67, 72, 76, 78, 82, 83, 87, 89, 91, 94, 96, 97, 99, 100, 101, 102, 105,
105, 107, 107, 109, 109, 110, 110, 111, 112, 112, 113, 113, 113, 114, 114, 115,
115, 115, 116, 116, 116, 116, 116, 117, 117, 118, 118, 118, 119, 118, 119, 118,
120, 119, 119, 119, 119, 118, 119, 118, 118, 117, 117, 117, 116, 116, 115, 114,
114, 112, 110, 107, 104, 98, 91, 82, 75, 71, 67, 62, 57, 51, 45, 39, 33, 28, 23,
16, 11, 6, 1, -4, -10, -14, -19, -23, -26, -31, -33, -37, -40, -43, -45, -49,
-51, -54, -56, -58, -60, -63, -66, -67, -68, -71, -72, -74, -76, -76, -78, -79,
-81, -81, -82, -83, -85, -85, -86, -86, -88, -89, -88, -88, -89, -91, -90, -90,
-91, -92, -93, -94, -95, -95, -95, -95, -96, -96, -96, -96, -97, -97, -98, -98,
-98, -98, -98, -98, -98, -99, -99, -98, -99, -99, -99, -99, -98, -98, -98, -98,
-98, -97, -97, -97, -97, -96, -96, -95, -96, -95, -95, -94, -94, -93, -93, -92,
-91, -91, -90, -90, -89, -88, -87, -87, -86, -84, -84, -83, -82, -80, -79, -79,
-77, -76, -76, -74, -72, -72, -70, -69, -68, -67, -64, -63, -62, -60, -58, -58,
-57, -55, -53, -53, -50, -49, -47, -46, -45, -42, -42, -39, -38, -37, -36, -34,
-33, -30, -29, -28, -27, -25, -23, -23, -20, -20, -18, -17, -15, -14, -13, -11,
-10, -9, -8, -6, -4, -4, -3, -2, 0, 1, 3, 3, 5, 5, 6, 8, 8, 10, 10, 12, 14, 13,
15, 16, 16, 18, 19, 19, 20, 22, 22, 24, 25, 25, 26, 26, 26, 25, 26, 26, 27, 29,
29, 29, 30, 31, 31, 31, 31, 32, 32, 33, 33, 33, 34, 34, 35, 36, 35, 36, 36, 37,
38, 37, 38, 38, 39, 38, 40, 40, 40, 41, 41, 40, 41, 42, 41, 42, 41, 42, 42, 43,
43, 43, 44, 43, 43, 43, 43, 43, 43, 43, 42, 43, 42, 41, 42, 41, 40, 40, 41, 40,
39, 38, 38, 37, 36, 35, 35, 34, 33, 33, 32, 31, 31, 28, 28, 27, 26, 24, 23, 22,
22, 21, 20, 19, 18, 16, 15, 15, 13, 13, 12, 12, 10, 9, 8, 7, 6, 6, 4, 3, 3, 2,
1, 0, 0, -1, -2, -3, -3, -5, -4, -6, -6, -6, -7, -8, -8, -9, -10, -10, -10, -10,
-11, -12, -12, -13, -13, -13, -14, -13, -14, -15, -14, -15, -15, -15, -15, -15,
-15, -16, -16, -16, -16, -16, -16, -16, -17, -17, -17, -16, -17, -17, -17, -17,
-18, -19, -20, -20, -19, -19, -19, -18, -19, -19, -19, -20, -20, -20, -20, -20,
-20, -20, -20, -20, -20, -20, -20, -19, -19, -19, -19, -19, -18, -19, -17, -18,
-18, -17, -16, -17, -16, -15, -15, -14, -14, -12, -13, -11, -11, -11, -10, -9,
-8, -8, -6, -6, -5, -4, -4, -2, -1, 0, };