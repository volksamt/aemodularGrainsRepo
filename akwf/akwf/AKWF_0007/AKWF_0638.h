#define DATA_LENGTH 512
#define DATA AKWF_0638

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 19, 34, 48, 61, 73, 83, 92, 98,
102, 106, 106, 106, 102, 97, 91, 82, 73, 61, 50, 39, 26, 13, 0, -11, -23, -34,
-43, -51, -59, -64, -68, -72, -73, -72, -70, -67, -62, -57, -50, -42, -33, -25,
-15, -6, 4, 13, 23, 30, 37, 44, 51, 55, 58, 61, 62, 62, 61, 58, 55, 51, 46, 41,
35, 28, 23, 15, 9, 2, -5, -10, -16, -21, -26, -29, -31, -33, -33, -35, -33, -31,
-30, -27, -23, -19, -15, -10, -6, 0, 4, 9, 15, 19, 23, 26, 29, 32, 34, 36, 36,
37, 36, 35, 34, 32, 29, 27, 23, 20, 16, 13, 9, 5, 2, -2, -4, -7, -10, -12, -13,
-13, -15, -15, -14, -14, -13, -12, -10, -8, -5, -3, 0, 2, 5, 7, 9, 12, 14, 16,
18, 20, 20, 21, 22, 22, 22, 21, 21, 19, 18, 17, 15, 14, 11, 9, 7, 6, 4, 2, 0,
-2, -2, -4, -5, -6, -6, -7, -6, -6, -5, -6, -4, -4, -2, -1, 0, 1, 3, 4, 6, 7, 8,
9, 10, 10, 11, 11, 11, 12, 12, 12, 11, 11, 10, 9, 8, 7, 6, 5, 3, 2, 2, 1, -1,
-1, -2, -2, -3, -4, -4, -4, -4, -4, -4, -4, -4, -3, -2, -2, -2, -1, 0, 1, 1, 1,
2, 4, 7, 10, 14, 20, 27, 35, 43, 53, 63, 73, 82, 92, 100, 106, 112, 116, 119,
119, 117, 115, 109, 101, 92, 81, 68, 56, 41, 26, 10, -6, -21, -36, -49, -62,
-75, -84, -92, -98, -103, -106, -106, -105, -102, -96, -89, -81, -71, -61, -49,
-37, -25, -11, 0, 13, 24, 34, 44, 52, 60, 64, 70, 72, 73, 72, 70, 67, 62, 56,
49, 41, 32, 23, 13, 3, -5, -15, -23, -32, -38, -46, -51, -55, -58, -60, -62,
-61, -61, -58, -55, -51, -46, -41, -34, -28, -22, -14, -8, -1, 5, 12, 16, 22,
25, 29, 32, 34, 34, 34, 34, 31, 30, 27, 22, 19, 14, 10, 5, 0, -5, -10, -15, -19,
-23, -27, -30, -32, -34, -36, -36, -36, -36, -35, -33, -32, -29, -27, -23, -20,
-16, -12, -9, -5, -2, 2, 4, 8, 9, 11, 13, 14, 14, 14, 14, 14, 13, 11, 10, 7, 5,
3, 0, -3, -4, -7, -10, -12, -14, -16, -19, -20, -20, -22, -21, -22, -22, -21,
-20, -19, -18, -17, -14, -13, -11, -8, -6, -5, -3, -1, 0, 1, 3, 4, 5, 6, 6, 6,
7, 6, 6, 4, 4, 3, 2, 2, 0, -1, -3, -5, -5, -7, -7, -10, -11, -11, -11, -11, -12,
-13, -11, -12, -11, -11, -10, -9, -9, -7, -6, -5, -4, -3, -1, -1, 1, 2, 2, 2, 3,
4, 3, 4, 4, 4, 5, 4, 3, 2, 3, 2, 1, 1, 0, -1, -2, -2, -3, -4, -6, -10, -14, -21,
-28, -35, -45, -54, -64, -74, -83, -92, -100, -108, -112, -117, -119, -120,
-117, -113, -108, -100, -92, -80, -67, -54, -39, -24, -8, };