#define DATA_LENGTH 512
#define DATA AKWF_0655

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 13, 18, 23, 26, 31, 33, 36, 39,
42, 45, 47, 51, 53, 55, 56, 58, 60, 62, 65, 66, 67, 68, 69, 71, 73, 74, 75, 75,
77, 78, 79, 80, 80, 81, 82, 82, 83, 83, 83, 84, 84, 85, 84, 86, 83, 88, 77, 51,
48, 42, 40, 36, 35, 32, 29, 27, 26, 25, 23, 22, 20, 19, 17, 17, 15, 15, 14, 13,
12, 12, 10, 10, 10, 9, 8, 7, 7, 6, 6, 5, 4, 4, 3, 3, 3, 3, 2, 2, 2, 1, 1, 2, 1,
1, 0, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 1, 0, 0, 1, 1, -1, 0, 0, 0, 1,
0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 0, 0, 1, 0, 1, 0,
0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, -1, 1, 0, -1, 0, -1, 0, -1, 1, -1, 2, -4, 31,
53, 55, 64, 66, 71, 73, 77, 79, 83, 84, 87, 88, 91, 92, 94, 95, 97, 99, 99, 101,
102, 103, 104, 106, 106, 107, 107, 110, 109, 111, 111, 113, 112, 113, 114, 114,
115, 115, 116, 116, 117, 117, 118, 118, 119, 117, 119, 117, 120, 118, 121, 116,
123, 110, 42, 29, 18, 9, 2, -4, -8, -15, -18, -24, -26, -31, -34, -38, -40, -44,
-45, -48, -51, -53, -54, -57, -58, -61, -62, -64, -65, -67, -68, -71, -71, -73,
-74, -75, -75, -77, -77, -78, -80, -80, -81, -81, -82, -82, -83, -83, -84, -84,
-85, -84, -86, -83, -88, -73, -50, -48, -41, -40, -36, -34, -31, -30, -27, -26,
-24, -23, -21, -20, -19, -18, -17, -16, -15, -14, -13, -12, -12, -10, -10, -9,
-9, -8, -7, -6, -5, -5, -5, -4, -4, -4, -3, -3, -3, -2, -2, -1, -1, -1, -1, -2,
-1, -1, -1, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0,
-1, 0, 0, -1, 0, -1, -1, 0, 1, -1, -1, 0, 0, 0, -1, 0, 0, -1, 0, -1, -1, -1, 0,
0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, -1, -1, 1, 0, 0, -1, 0, -1, 0, -1, -1,
0, 0, -1, 0, 0, 0, 0, 0, -1, -1, 0, -1, 0, -1, -1, 0, 0, -1, 0, -1, 0, -1, -1,
-1, -1, 0, -1, -1, 0, 2, -35, -52, -56, -64, -66, -72, -73, -78, -79, -83, -85,
-87, -88, -91, -92, -95, -96, -97, -99, -100, -101, -103, -103, -104, -105,
-106, -107, -108, -110, -110, -111, -111, -113, -113, -114, -114, -115, -115,
-116, -116, -116, -116, -117, -119, -117, -119, -117, -120, -117, -120, -117,
-122, -116, -124, -102, -38, -30, -16, -8, -2, };