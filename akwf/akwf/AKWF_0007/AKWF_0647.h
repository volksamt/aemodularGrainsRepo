#define DATA_LENGTH 512
#define DATA AKWF_0647

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 14, 22, 25, 28, 27, 27, 22, 19, 15,
11, 6, 3, 0, -4, -6, -9, -9, -11, -11, -14, -11, -14, -10, -15, -8, -14, -6,
-17, 0, -34, -125, -101, -89, -68, -52, -35, -19, -8, 3, 7, 14, 15, 17, 14, 13,
9, 7, 2, 0, -4, -7, -11, -12, -14, -15, -16, -17, -17, -18, -17, -18, -17, -17,
-17, -17, -16, -16, -16, -16, -15, -15, -15, -15, -16, -15, -16, -15, -15, -15,
-16, -16, -15, -15, -15, -16, -14, -15, -15, -14, -15, -15, -15, -14, -15, -15,
-14, -15, -15, -15, -15, -15, -15, -15, -14, -15, -15, -15, -15, -14, -14, -15,
-14, -14, -14, -15, -14, -14, -14, -14, -15, -14, -13, -14, -14, -14, -14, -13,
-14, -14, -14, -14, -14, -14, -14, -13, -14, -13, -13, -14, -12, -9, -5, -3, 0,
2, 2, 3, 3, 2, 1, 0, -1, -2, -3, -4, -6, -6, -7, -6, -8, -7, -8, -7, -7, -8, -7,
-7, -6, -7, -5, -5, -6, -4, -5, -4, -4, -3, -3, -4, -4, -3, -3, -3, -3, -2, -2,
-2, -2, -2, -2, -1, -1, -1, 0, -1, 0, 0, 0, 0, 1, 0, 0, 1, 1, 1, 2, 1, 2, 2, 2,
2, 1, 2, 2, 2, 2, 3, 3, 3, 3, 3, 3, 4, 4, 4, 4, 4, 5, 4, 5, 4, 5, 4, 6, 4, 6, 4,
7, 4, 7, 4, 7, 5, 6, 5, 7, 8, 2, 99, 109, 79, 66, 40, 26, 6, -4, -17, -22, -28,
-28, -30, -27, -24, -20, -16, -11, -7, -4, 1, 3, 6, 7, 10, 10, 10, 13, 11, 14,
11, 14, 9, 14, 6, 17, -1, 45, 127, 96, 88, 65, 51, 32, 19, 7, -3, -8, -13, -15,
-16, -13, -13, -8, -7, -1, 1, 5, 6, 11, 11, 14, 14, 16, 17, 17, 18, 18, 17, 17,
17, 16, 17, 16, 16, 16, 16, 15, 16, 15, 15, 15, 15, 15, 15, 15, 15, 15, 15, 15,
15, 15, 15, 15, 15, 15, 15, 15, 15, 14, 15, 15, 15, 14, 15, 15, 15, 15, 15, 15,
15, 15, 15, 15, 15, 15, 15, 15, 14, 14, 14, 14, 14, 13, 14, 15, 13, 14, 14, 14,
14, 14, 14, 14, 14, 14, 14, 14, 14, 13, 14, 13, 14, 14, 14, 14, 14, 13, 8, 5, 1,
0, -1, -2, -3, -2, -2, -1, 1, 2, 2, 4, 4, 5, 6, 7, 7, 8, 7, 8, 8, 7, 6, 6, 6, 6,
6, 6, 6, 5, 5, 5, 4, 4, 4, 4, 3, 4, 4, 3, 3, 2, 2, 1, 2, 2, 1, 1, 2, 1, 1, 0, 0,
0, 1, 1, -1, -1, -1, -1, -2, -1, -1, -1, -1, -1, -1, -2, -2, -2, -3, -2, -3, -3,
-3, -2, -3, -3, -3, -4, -4, -3, -4, -4, -4, -4, -3, -5, -4, -5, -4, -6, -4, -6,
-5, -6, -4, -7, -5, -8, -3, -8, -5, -8, -5, -8, -108, -105, -78, -64, -37, -24,
-4, };