#define DATA_LENGTH 512
#define DATA AKWF_0649

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1,
2, 1, 1, 1, 1, 1, 1, 0, 2, 2, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 0, 2, 0, 2, 0, 3, 0,
3, -2, 11, 42, 37, 41, 40, 41, 42, 42, 44, 44, 45, 45, 47, 47, 47, 48, 49, 49,
50, 51, 52, 52, 53, 54, 55, 55, 57, 57, 57, 58, 59, 59, 60, 61, 62, 63, 63, 64,
65, 64, 66, 66, 67, 68, 69, 69, 70, 70, 71, 72, 72, 74, 75, 74, 76, 76, 77, 77,
79, 79, 80, 81, 81, 82, 82, 84, 84, 85, 86, 86, 87, 87, 88, 88, 89, 90, 90, 91,
92, 93, 93, 95, 95, 95, 96, 96, 98, 99, 99, 99, 101, 102, 102, 103, 103, 103,
104, 105, 106, 107, 107, 108, 108, 110, 110, 112, 112, 112, 112, 112, 111, 110,
110, 109, 108, 107, 106, 106, 105, 104, 103, 103, 102, 102, 100, 100, 99, 99,
98, 97, 97, 95, 94, 95, 93, 93, 92, 91, 90, 90, 89, 89, 88, 87, 86, 86, 85, 84,
83, 83, 82, 81, 81, 80, 79, 78, 78, 77, 76, 75, 75, 74, 73, 73, 71, 71, 71, 70,
69, 69, 67, 67, 66, 66, 65, 64, 63, 63, 62, 61, 60, 60, 59, 58, 58, 57, 56, 56,
55, 54, 53, 52, 52, 51, 50, 50, 49, 48, 47, 47, 46, 45, 45, 44, 44, 41, 42, 40,
41, 39, 39, 38, 39, 35, -1, -1, -1, -1, 0, -1, 0, -2, 0, -2, -1, -1, -1, -2, 0,
-2, -1, -1, -1, -1, 0, -1, -1, -2, -1, -1, -1, -1, -1, -1, -1, 0, -1, 0, -1, 0,
-1, 0, -2, 0, -4, 3, -14, -43, -37, -41, -39, -42, -41, -42, -43, -43, -45, -45,
-46, -46, -48, -48, -49, -49, -51, -51, -52, -53, -53, -53, -55, -56, -56, -56,
-57, -58, -58, -60, -60, -61, -61, -62, -62, -64, -64, -66, -65, -67, -66, -68,
-69, -69, -70, -70, -72, -73, -73, -73, -74, -75, -75, -76, -77, -78, -79, -80,
-80, -80, -81, -82, -82, -84, -86, -86, -88, -89, -91, -92, -93, -94, -94, -95,
-97, -96, -98, -99, -100, -100, -101, -102, -103, -103, -105, -106, -107, -107,
-108, -108, -108, -110, -110, -112, -112, -112, -113, -114, -115, -116, -116,
-117, -118, -117, -120, -114, -112, -112, -110, -109, -109, -109, -107, -107,
-106, -105, -105, -105, -102, -102, -102, -102, -100, -99, -99, -98, -98, -96,
-96, -94, -94, -94, -94, -93, -92, -90, -90, -90, -89, -88, -87, -86, -86, -85,
-84, -84, -83, -82, -81, -81, -80, -80, -79, -78, -77, -77, -76, -75, -74, -74,
-73, -73, -71, -71, -71, -69, -69, -68, -67, -66, -66, -64, -64, -63, -63, -62,
-61, -61, -60, -59, -58, -58, -56, -57, -56, -55, -54, -53, -52, -53, -51, -51,
-49, -50, -48, -49, -48, -47, -47, -44, -45, -43, -44, -42, -42, -40, -41, -39,
-40, -37, -40, -31, };