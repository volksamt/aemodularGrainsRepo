#define DATA_LENGTH 512
#define DATA AKWF_0634

const PROGMEM int8_t DATA[DATA_LENGTH] = {31, 40, 36, 37, 36, 38, 35, 36, 35,
35, 34, 35, 34, 34, 33, 33, 32, 32, 31, 30, 30, 29, 29, 28, 28, 27, 27, 25, 26,
25, 24, 23, 22, 22, 21, 21, 21, 20, 19, 19, 18, 17, 17, 16, 16, 15, 14, 13, 12,
13, 12, 11, 11, 11, 9, 9, 9, 8, 8, 7, 7, 7, 6, 5, 5, 4, 5, 3, 4, 3, 3, 3, 2, 1,
2, 1, 1, 1, 0, 1, 0, 0, -1, 0, -1, 1, -2, 2, -5, 16, 41, 35, 38, 36, 37, 36, 35,
35, 34, 35, 34, 34, 33, 32, 32, 32, 31, 31, 30, 30, 29, 29, 28, 27, 27, 27, 25,
25, 24, 24, 24, 23, 22, 22, 22, 21, 21, 19, 19, 18, 17, 17, 17, 15, 15, 14, 14,
13, 13, 12, 11, 11, 10, 10, 9, 9, 8, 8, 7, 7, 7, 6, 6, 5, 5, 4, 4, 4, 3, 3, 2,
2, 2, 1, 2, 1, 1, 0, 0, 0, 0, -1, 0, 0, -1, 0, -1, -1, -1, -2, 0, 0, -1, -1, 0,
-1, -1, 0, -1, 0, 0, -1, -1, 0, -1, -1, 0, -1, -1, 0, 0, -1, 0, 0, 0, -1, -1,
-1, -1, -1, -1, 0, -1, 0, -1, -1, 0, 0, -1, 0, 0, -1, 0, -1, -1, 0, -1, 0, -1,
0, 0, -1, -1, -1, -1, -1, -4, -7, -12, -17, -23, -28, -35, -40, -47, -54, -61,
-67, -74, -80, -86, -92, -97, -102, -105, -109, -113, -116, -117, -118, -119,
-119, -115, -111, -104, -97, -90, -83, -74, -66, -58, -50, -42, -35, -28, -22,
-16, -11, -6, -4, -1, -1, 0, -1, -1, 0, 0, 0, 0, 11, 25, 40, 13, -5, 2, -2, 1,
-2, 1, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, -1, -1, 0, -1, 0, -1, 0, -1, -1, -1, -1,
0, 0, -1, 0, -1, 0, -1, 0, -1, 0, -1, -1, -1, -1, 0, -1, 0, -1, 1, -5, -19, -40,
-14, 4, -2, 1, -1, 0, -1, 1, -1, 0, -1, 0, 0, 0, 0, 0, -1, -1, -1, 0, 0, 0, 0,
0, 1, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
-1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, -1, -1, 0, 0, 0, 0, -1, -1,
0, 1, -1, 0, -1, 0, 0, 0, 0, -1, -1, 0, -1, 0, 0, -1, 0, -1, 0, 0, -1, -1, -1,
0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, -1, -1, 0,
-1, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0,
0, 0, -1, 0, 0, -1, 0, -1, 0, -1, 0, -1, 0, 0, -1, -1, 0, -1, 0, 0, -1, -1, -1,
0, -2, };