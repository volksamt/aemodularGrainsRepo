#define DATA_LENGTH 512
#define DATA AKWF_0660

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 14, 18, 22, 27, 31, 34, 36, 37, 40,
41, 44, 45, 48, 49, 51, 53, 54, 55, 56, 58, 58, 60, 60, 62, 63, 63, 65, 67, 66,
68, 68, 69, 71, 71, 72, 73, 72, 73, 75, 75, 75, 76, 76, 77, 78, 78, 79, 80, 80,
81, 82, 81, 82, 83, 84, 84, 85, 85, 85, 86, 87, 88, 88, 87, 89, 90, 90, 90, 91,
91, 92, 91, 92, 92, 93, 93, 93, 94, 94, 95, 95, 95, 96, 96, 97, 97, 97, 97, 97,
98, 98, 99, 100, 99, 99, 100, 101, 101, 100, 101, 101, 102, 102, 102, 103, 103,
103, 103, 104, 104, 103, 103, 104, 105, 105, 105, 105, 105, 106, 106, 107, 106,
107, 107, 107, 108, 107, 107, 107, 108, 109, 108, 108, 108, 108, 109, 109, 110,
109, 109, 109, 110, 110, 111, 110, 111, 110, 110, 111, 110, 111, 112, 111, 111,
111, 112, 112, 111, 112, 112, 112, 112, 112, 113, 113, 113, 113, 113, 113, 113,
113, 113, 113, 113, 114, 114, 114, 113, 113, 114, 114, 114, 114, 114, 114, 114,
114, 113, 114, 115, 115, 114, 115, 115, 115, 115, 115, 114, 115, 114, 115, 115,
115, 115, 116, 115, 115, 116, 115, 116, 115, 116, 115, 115, 115, 116, 116, 115,
115, 115, 115, 116, 115, 115, 115, 115, 115, 115, 116, 114, 116, 115, 116, 115,
116, 115, 116, 115, 116, 115, 116, 114, 116, 115, 115, 115, 114, 116, 112, 118,
110, 126, 58, 1, 8, -7, -6, -15, -14, -20, -20, -24, -25, -27, -28, -30, -33,
-33, -35, -36, -38, -38, -40, -40, -42, -41, -44, -43, -45, -45, -46, -46, -48,
-48, -49, -48, -50, -50, -51, -51, -52, -52, -53, -53, -53, -66, -69, -71, -72,
-73, -75, -75, -77, -77, -78, -78, -79, -80, -81, -81, -82, -81, -83, -84, -84,
-84, -86, -85, -86, -87, -87, -88, -88, -89, -89, -90, -91, -91, -91, -91, -92,
-92, -93, -93, -94, -93, -94, -94, -96, -96, -96, -96, -97, -97, -97, -98, -98,
-98, -99, -99, -99, -100, -99, -101, -100, -101, -101, -101, -102, -102, -102,
-103, -103, -103, -103, -104, -104, -104, -105, -104, -104, -106, -106, -105,
-105, -106, -106, -106, -107, -107, -107, -107, -107, -108, -108, -108, -108,
-109, -109, -110, -110, -109, -109, -109, -110, -110, -111, -110, -111, -111,
-111, -112, -111, -112, -112, -112, -112, -112, -113, -112, -112, -113, -113,
-113, -114, -113, -113, -114, -115, -115, -114, -115, -115, -115, -115, -115,
-115, -115, -115, -115, -116, -116, -116, -115, -116, -117, -117, -116, -116,
-116, -116, -117, -116, -117, -117, -116, -117, -117, -117, -117, -117, -117,
-117, -117, -118, -118, -118, -118, -117, -118, -118, -118, -118, -118, -118,
-118, -118, -119, -118, -118, -118, -118, -118, -119, -119, -118, -119, -119,
-119, -118, -119, -118, -119, -120, -119, -119, -118, -119, -119, -120, -119,
-120, -119, -120, -118, -120, -118, -121, -118, -120, -118, -119, -119, -120,
-118, -119, -120, -117, -123, -29, 6, };