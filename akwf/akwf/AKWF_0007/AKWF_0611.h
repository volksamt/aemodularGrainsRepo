#define DATA_LENGTH 512
#define DATA AKWF_0611

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 10, 18, 26, 34, 43, 51, 58, 66, 73,
80, 86, 92, 98, 102, 107, 111, 114, 116, 118, 119, 119, 119, 118, 115, 113, 109,
105, 100, 96, 89, 84, 76, 68, 61, 53, 44, 35, 26, 15, 7, -4, -6, -6, -5, -2, 1,
5, 9, 14, 18, 24, 28, 34, 39, 43, 47, 51, 53, 57, 58, 58, 59, 58, 57, 55, 52,
49, 45, 40, 35, 28, 22, 14, 6, -1, -9, -18, -27, -34, -43, -51, -59, -67, -74,
-80, -86, -93, -97, -101, -105, -107, -107, -109, -108, -107, -104, -101, -97,
-92, -87, -80, -73, -65, -57, -48, -38, -29, -19, -9, 0, 3, 4, 4, 4, 3, 3, 1, 0,
-2, -5, -6, -10, -12, -14, -16, -18, -21, -24, -25, -28, -31, -32, -35, -36,
-37, -40, -40, -42, -42, -42, -42, -42, -42, -41, -40, -39, -37, -36, -34, -31,
-29, -27, -23, -20, -18, -14, -10, -6, -2, 1, 5, 9, 13, 17, 22, 25, 29, 33, 36,
40, 45, 48, 51, 55, 56, 60, 63, 65, 67, 68, 71, 71, 72, 73, 72, 73, 73, 71, 70,
69, 67, 64, 63, 59, 57, 53, 51, 47, 43, 39, 35, 31, 26, 21, 16, 12, 7, 2, -3,
-5, -5, -6, -5, -3, -2, -1, 1, 3, 5, 7, 10, 11, 14, 16, 20, 21, 23, 25, 27, 28,
29, 29, 30, 31, 30, 30, 30, 29, 28, 27, 25, 24, 21, 19, 16, 13, 10, 6, 3, 0, -4,
-9, -12, -15, -19, -23, -28, -31, -35, -38, -41, -45, -48, -50, -53, -55, -58,
-59, -60, -61, -62, -63, -62, -62, -61, -60, -59, -57, -55, -52, -49, -47, -44,
-40, -36, -32, -28, -24, -20, -14, -10, -5, 0, 3, 6, 1, -2, -3, -6, -8, -11,
-15, -19, -21, -24, -27, -30, -34, -38, -40, -43, -46, -48, -51, -54, -56, -58,
-59, -61, -62, -63, -63, -63, -64, -63, -62, -61, -60, -58, -56, -54, -51, -47,
-45, -41, -36, -32, -28, -24, -18, -14, -9, -4, 2, 8, 14, 19, 25, 31, 36, 42,
48, 54, 59, 63, 68, 73, 76, 80, 84, 88, 91, 94, 96, 97, 99, 100, 101, 101, 102,
101, 101, 98, 97, 95, 92, 90, 87, 83, 79, 75, 70, 64, 60, 54, 49, 42, 37, 30,
24, 17, 10, 4, -2, -5, -4, -3, 0, 2, 6, 11, 15, 20, 25, 30, 34, 39, 43, 47, 52,
55, 58, 60, 63, 64, 65, 65, 65, 64, 61, 60, 56, 53, 48, 43, 38, 32, 26, 19, 11,
4, -3, -12, -19, -27, -36, -43, -51, -59, -66, -73, -80, -86, -92, -96, -101,
-104, -107, -111, -112, -112, -113, -112, -111, -108, -105, -101, -97, -92, -86,
-79, -72, -64, -57, -49, -39, -32, -21, -12, -2, 4, 2, 1, -3, -5, -9, -13, -17,
-22, -28, -32, -38, -42, -47, -51, -56, -60, -64, -68, -70, -73, -75, -76, -77,
-77, -77, -76, -74, -72, -69, -66, -62, -57, -52, -46, -41, -34, -27, -20, -12,
-4, };