#define DATA_LENGTH 512
#define DATA AKWF_0651

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 12, 15, 17, 21, 24, 27, 29,
31, 34, 37, 39, 42, 44, 46, 48, 50, 53, 54, 57, 58, 61, 63, 65, 66, 69, 70, 71,
75, 76, 78, 79, 81, 83, 84, 85, 86, 87, 89, 90, 92, 92, 95, 96, 96, 97, 99, 100,
101, 102, 103, 105, 105, 106, 107, 108, 109, 109, 110, 110, 112, 112, 112, 113,
114, 115, 115, 115, 116, 116, 116, 117, 118, 117, 117, 118, 119, 119, 119, 119,
119, 119, 119, 119, 115, 109, 108, 106, 103, 101, 100, 96, 96, 95, 93, 91, 89,
88, 86, 85, 84, 83, 82, 80, 79, 78, 78, 76, 74, 74, 73, 71, 71, 70, 68, 68, 66,
65, 64, 64, 63, 62, 62, 60, 59, 58, 57, 56, 56, 55, 54, 53, 52, 52, 50, 50, 48,
48, 47, 46, 45, 45, 45, 43, 42, 42, 41, 40, 40, 39, 38, 38, 37, 35, 35, 35, 34,
34, 32, 32, 32, 31, 30, 30, 28, 28, 27, 26, 26, 26, 25, 25, 24, 23, 22, 23, 22,
20, 20, 19, 18, 18, 17, 16, 17, 16, 15, 14, 13, 13, 13, 12, 11, 10, 10, 10, 10,
9, 8, 7, 7, 7, 6, 5, 5, 5, 5, 4, 4, 3, 2, 1, 1, 0, 0, 0, -1, -1, -2, -3, -2, -4,
-4, -4, -6, -5, -6, -6, -7, -7, -8, -8, -9, -9, -10, -10, -11, -10, -12, -13,
-12, -13, -14, -14, -14, -14, -14, -16, -17, -17, -17, -18, -17, -18, -19, -19,
-19, -19, -20, -21, -21, -21, -22, -22, -23, -23, -22, -24, -24, -24, -25, -25,
-25, -25, -26, -26, -27, -28, -28, -28, -29, -29, -29, -29, -31, -30, -30, -31,
-32, -32, -32, -32, -33, -32, -33, -34, -34, -34, -34, -34, -36, -36, -36, -36,
-37, -36, -38, -37, -37, -38, -39, -39, -39, -39, -40, -39, -41, -40, -40, -42,
-42, -42, -42, -42, -42, -42, -43, -44, -44, -45, -44, -44, -45, -45, -45, -46,
-45, -46, -46, -47, -48, -48, -47, -48, -48, -49, -48, -49, -49, -49, -50, -49,
-50, -50, -51, -50, -50, -50, -51, -52, -51, -52, -53, -52, -52, -53, -53, -53,
-53, -54, -54, -54, -54, -54, -54, -55, -55, -55, -55, -56, -56, -56, -56, -56,
-56, -57, -57, -56, -57, -56, -57, -57, -57, -57, -59, -58, -58, -59, -59, -59,
-59, -59, -60, -60, -59, -60, -60, -61, -60, -61, -61, -61, -60, -62, -61, -61,
-61, -61, -62, -62, -62, -62, -62, -62, -62, -63, -62, -63, -63, -62, -63, -62,
-63, -63, -63, -63, -63, -64, -64, -63, -63, -65, -64, -64, -64, -64, -64, -64,
-64, -65, -64, -65, -64, -65, -66, -64, -65, -65, -65, -65, -66, -65, -66, -65,
-66, -65, -66, -65, -65, -66, -65, -66, -65, -66, -66, -65, -65, -66, -66, -66,
-65, -66, -65, -66, -66, -66, -66, -67, -65, -67, -66, -66, -65, -65, -66, -67,
-65, -67, -63, -49, -42, -36, -31, -25, -20, -16, -12, -8, -3, -1, };