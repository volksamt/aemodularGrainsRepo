#define DATA_LENGTH 512
#define DATA AKWF_0679

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 9, 18, 26, 34, 42, 50, 58, 65, 73,
79, 86, 91, 96, 102, 105, 109, 113, 114, 117, 118, 119, 119, 119, 118, 117, 115,
113, 110, 107, 104, 100, 95, 90, 86, 81, 77, 71, 66, 61, 56, 50, 45, 41, 35, 31,
26, 22, 18, 15, 12, 8, 5, 2, 0, 0, -3, -3, -3, -5, -4, -4, -3, -3, -2, -1, 1, 2,
5, 6, 8, 11, 12, 14, 16, 17, 20, 22, 23, 25, 27, 28, 30, 31, 32, 32, 33, 33, 34,
33, 33, 32, 32, 31, 29, 28, 28, 25, 25, 23, 21, 19, 17, 15, 12, 11, 9, 6, 5, 2,
1, 0, -2, -3, -5, -5, -7, -8, -9, -9, -9, -10, -9, -9, -10, -9, -8, -7, -7, -7,
-5, -3, -3, -2, 0, 2, 3, 3, 5, 7, 7, 10, 10, 12, 13, 13, 14, 15, 16, 17, 17, 17,
18, 17, 17, 17, 17, 16, 16, 14, 14, 13, 12, 11, 10, 9, 7, 5, 4, 3, 1, 0, -3, -4,
-5, -6, -8, -9, -10, -11, -12, -14, -14, -14, -16, -16, -17, -17, -17, -17, -18,
-16, -17, -16, -16, -15, -15, -15, -13, -12, -11, -10, -9, -8, -7, -6, -4, -3,
-2, 0, 1, 2, 2, 4, 4, 5, 6, 7, 7, 9, 8, 10, 10, 9, 10, 9, 9, 9, 8, 8, 8, 7, 6,
5, 5, 4, 2, 1, 0, -2, -3, -4, -6, -7, -9, -10, -12, -14, -15, -17, -18, -20,
-20, -22, -23, -25, -25, -27, -28, -29, -30, -31, -32, -32, -33, -32, -33, -33,
-33, -34, -33, -32, -32, -32, -32, -31, -31, -30, -29, -29, -27, -26, -25, -23,
-22, -21, -19, -19, -17, -15, -15, -13, -12, -10, -10, -7, -6, -5, -5, -3, -2,
-2, -1, 1, 1, 2, 3, 3, 4, 4, 5, 4, 5, 5, 4, 3, 3, 3, 2, 2, 1, 0, 0, -1, -3, -4,
-6, -8, -9, -10, -12, -13, -15, -18, -19, -22, -23, -26, -29, -30, -32, -35,
-38, -40, -42, -45, -47, -51, -53, -56, -57, -60, -62, -66, -68, -70, -73, -75,
-76, -79, -81, -83, -85, -87, -90, -91, -94, -96, -98, -100, -101, -102, -104,
-105, -107, -108, -109, -110, -112, -112, -115, -115, -114, -116, -116, -117,
-117, -118, -118, -119, -119, -119, -118, -120, -119, -119, -119, -118, -117,
-118, -117, -116, -116, -115, -115, -113, -112, -112, -112, -110, -109, -108,
-107, -106, -104, -104, -102, -101, -100, -98, -98, -95, -94, -93, -92, -90,
-89, -86, -86, -84, -83, -81, -79, -78, -76, -75, -73, -72, -70, -69, -67, -66,
-63, -62, -61, -59, -58, -57, -55, -53, -52, -51, -50, -48, -47, -45, -44, -42,
-41, -40, -38, -37, -37, -36, -34, -32, -31, -30, -29, -28, -27, -26, -24, -24,
-23, -22, -21, -20, -19, -18, -17, -16, -16, -15, -15, -13, -13, -13, -11, -10,
-11, -9, -9, -9, -8, -8, -8, -8, -6, -7, -7, -6, -6, -6, -5, -5, -5, -4, -5, -5,
-6, -4, };