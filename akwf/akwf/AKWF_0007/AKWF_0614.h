#define DATA_LENGTH 512
#define DATA AKWF_0614

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 6, 9, 13, 16, 19, 23, 27, 31,
35, 39, 44, 47, 51, 55, 59, 63, 66, 69, 73, 76, 78, 80, 82, 85, 87, 88, 89, 90,
90, 91, 91, 91, 91, 91, 90, 90, 90, 90, 90, 91, 90, 90, 90, 90, 89, 89, 89, 88,
87, 86, 85, 84, 82, 80, 79, 76, 74, 72, 69, 65, 62, 59, 54, 51, 45, 41, 35, 30,
25, 19, 13, 8, 2, -5, -10, -17, -23, -28, -34, -39, -44, -49, -54, -59, -62,
-66, -69, -71, -74, -75, -76, -77, -77, -78, -78, -79, -79, -80, -80, -81, -82,
-82, -83, -84, -84, -84, -85, -85, -86, -87, -87, -88, -88, -89, -90, -89, -90,
-90, -90, -91, -92, -91, -92, -92, -93, -93, -94, -93, -93, -93, -94, -93, -92,
-93, -92, -92, -91, -91, -90, -90, -90, -89, -87, -87, -86, -84, -83, -82, -81,
-80, -78, -77, -74, -72, -71, -70, -67, -65, -63, -61, -59, -57, -53, -52, -48,
-46, -44, -41, -39, -36, -34, -31, -27, -25, -22, -20, -18, -14, -12, -10, -8,
-5, -2, 0, 3, 5, 7, 9, 10, 13, 14, 15, 17, 20, 19, 21, 22, 23, 24, 24, 24, 26,
26, 26, 27, 27, 26, 25, 26, 23, 22, 13, 11, -2, 1, -14, 10, 14, 11, 11, -33,
-26, -27, -8, 17, 44, 52, 50, 51, 46, 37, 19, 1, -15, -18, -20, -18, -19, -19,
-19, -18, -19, -19, -18, -18, -19, -18, -18, -19, -18, -17, -17, -17, -16, -15,
-14, -13, -12, -11, -10, -8, -5, -4, -2, 1, 4, 6, 9, 13, 15, 19, 22, 26, 29, 33,
35, 39, 43, 45, 49, 52, 55, 57, 60, 62, 63, 65, 66, 67, 68, 68, 67, 68, 68, 68,
68, 67, 68, 67, 66, 66, 63, 62, 60, 57, 53, 48, 44, 37, 31, 24, 16, 8, -2, -10,
-19, -28, -36, -42, -48, -54, -58, -61, -63, -62, -62, -61, -61, -62, -60, -55,
-51, -44, -35, -25, -13, -2, 10, 18, 23, 26, 26, 26, 26, 26, 26, 26, 26, 25, 26,
26, 26, 26, 26, 26, 26, 25, 26, 25, 25, 25, 24, 24, 22, 22, 21, 21, 19, 18, 17,
15, 14, 12, 10, 8, 5, 4, 1, -3, -5, -9, -11, -14, -18, -22, -26, -31, -34, -38,
-42, -47, -50, -55, -60, -64, -68, -72, -77, -81, -85, -90, -93, -96, -100,
-103, -106, -108, -112, -113, -115, -116, -117, -118, -118, -119, -120, -119,
-118, -119, -119, -119, -119, -119, -119, -118, -118, -117, -118, -117, -116,
-115, -114, -112, -111, -108, -106, -104, -100, -97, -93, -89, -84, -80, -74,
-70, -64, -59, -52, -47, -40, -35, -29, -23, -18, -14, -9, -5, -1, 2, 5, 6, 7,
7, 7, 7, 4, 2, -1, 1, -4, -1, -16, 12, 11, 15, 10, -30, -21, -26, -23, -25, -23,
-25, -24, -25, -24, -24, -25, -23, -25, -23, -24, -23, -24, -23, -23, -21, -21,
-19, -19, -18, -18, -15, -14, -13, -11, -8, -6, -5, -1, };