#define DATA_LENGTH 512
#define DATA AKWF_0676

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 125, 116, 122, 116, 121, 117,
121, 117, 120, 118, 121, 118, 120, 118, 120, 118, 120, 119, 119, 119, 120, 119,
119, 120, 118, 120, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 120, 119,
119, 119, 119, 120, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 120, 120, 119, 118, 119, 120, 119, 119, 119, 119, 119, 120, 119, 120,
119, 119, 119, 119, 119, 120, 120, 119, 120, 119, 118, 119, 119, 119, 120, 119,
119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 119, 119,
119, 118, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 120, 118, 119, 118, 119, 119, 119, 118, 119, 119, 120, 119, 118, 120,
119, 119, 119, 119, 119, 120, 119, 120, 118, 120, 117, 121, 116, 124, 44, -102,
-121, -118, -120, -119, -119, -119, -120, -118, -119, -118, -119, -119, -120,
-119, -119, -119, -119, -118, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -120, -120, -119, -119, -119, -118,
-120, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-118, -118, -119, -118, -119, -119, -119, -120, -119, -119, -118, -119, -119,
-119, -120, -120, -119, -118, -119, -120, -119, -119, -120, -119, -120, -120,
-119, -119, -120, -119, -120, -119, -119, -118, -119, -118, -119, -119, -119,
-119, -118, -120, -118, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -120, -118, -118, -119, -119,
-118, -119, -119, -119, -119, -119, -119, -118, -119, -119, -118, -120, -118,
-119, -119, -119, -119, -119, -120, -120, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -118, -119, -118, -119, -118, -119, -119, -118, -119, -118,
-119, -119, -120, -119, -118, -119, -119, -119, -119, -119, -118, -120, -120,
-119, -119, -120, -120, -119, -120, -118, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -120, -120, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -120, -120, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -118, -119, -119,
-118, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -120, -120, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -120, -120, -120, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -118, -119, -119, -118, -119, -119, -119,
-120, -119, -120, -119, -119, -119, -119, -118, -119, -120, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -120, -119, -119, -120, -119, -119, -120,
-119, -119, -120, -119, -120, -118, -119, -118, -120, -118, -120, -117, -121,
-117, -121, -116, -121, -117, -122, -117, -122, -115, -5, };