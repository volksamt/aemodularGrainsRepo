#define DATA_LENGTH 512
#define DATA AKWF_0626

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 29, 49, 62, 65, 60, 48, 35, 18, 11,
11, 7, 8, 10, 15, 19, 24, 24, 20, 21, 22, 21, 24, 35, 34, 45, 60, 64, 67, 67,
68, 68, 74, 80, 73, 73, 74, 75, 76, 76, 78, 78, 79, 80, 81, 81, 83, 83, 84, 85,
86, 85, 86, 86, 88, 87, 87, 88, 89, 89, 89, 90, 90, 90, 91, 90, 89, 88, 86, 86,
83, 82, 78, 79, 70, 64, 62, 61, 59, 58, 56, 56, 54, 54, 53, 53, 54, 45, 41, 40,
37, 33, 32, 26, 28, 19, 23, 12, 24, -23, -97, -89, -93, -94, -84, -80, -89, -87,
-85, -82, -78, -73, -66, -60, -52, -43, -35, -25, -19, -22, -38, -31, -58, -71,
-83, -116, -103, -108, -102, -102, -98, -96, -93, -91, -88, -84, -83, -79, -78,
-75, -70, -56, -43, -39, -41, -39, -39, -38, -39, -37, -37, -35, -38, -44, -39,
-45, -49, -48, -47, -48, -47, -53, -61, -60, -63, -65, -67, -71, -73, -60, -57,
-63, -63, -68, -68, -71, -74, -76, -76, -80, -81, -82, -83, -84, -84, -85, -85,
-85, -86, -86, -85, -85, -83, -85, -80, -71, -71, -69, -67, -66, -64, -61, -61,
-44, -33, -34, -30, -30, -27, -26, -24, -22, -21, -19, -17, -17, -16, -14, -17,
-18, -22, -20, -25, -18, -3, -3, -3, -2, -1, 1, 2, 4, 5, 7, 9, 12, 13, 17, 27,
25, 26, 23, 22, 17, 17, 11, 11, 2, 3, -7, -2, 13, 2, 13, -27, -22, -7, 11, 34,
45, 53, 46, 37, 19, 4, -11, -11, -18, -18, -19, -14, -12, -7, -5, -12, -12, -12,
-11, -13, -4, -2, 2, 18, 24, 27, 25, 26, 26, 27, 37, 32, 28, 31, 29, 32, 32, 33,
34, 35, 36, 37, 38, 39, 40, 42, 42, 44, 45, 46, 48, 50, 51, 52, 55, 55, 58, 58,
60, 62, 63, 65, 66, 67, 68, 67, 68, 67, 67, 66, 67, 64, 55, 55, 55, 55, 55, 56,
55, 57, 57, 59, 59, 62, 58, 55, 54, 55, 51, 52, 47, 50, 44, 48, 40, 46, 32, -54,
-64, -59, -65, -55, -46, -53, -53, -49, -47, -41, -37, -30, -22, -15, -4, 3, 15,
22, 25, 10, 11, -2, -26, -30, -57, -29, -33, -33, -29, -31, -27, -29, -26, -28,
-26, -29, -27, -30, -29, -27, -16, -7, -6, -9, -8, -9, -10, -12, -11, -12, -12,
-17, -24, -21, -29, -33, -34, -34, -37, -37, -46, -54, -56, -60, -64, -68, -72,
-76, -63, -65, -71, -75, -80, -82, -87, -90, -94, -97, -100, -103, -105, -108,
-109, -112, -113, -115, -116, -116, -117, -118, -119, -119, -119, -119, -120,
-112, -107, -109, -108, -108, -107, -106, -101, -99, -95, -90, -86, -82, -77,
-72, -66, -64, -63, -61, -60, -57, -59, -61, -61, -62, -61, -63, -46, -38, -39,
-37, -35, -33, -31, -27, -24, -21, -17, -15, -9, -9, 3, 7, 7, 7, 7, 5, 4, 3, -1,
-1, -6, -4, -14, 10, 3, 13, -2, -27, -4, };