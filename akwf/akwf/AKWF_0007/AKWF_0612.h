#define DATA_LENGTH 512
#define DATA AKWF_0612

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 2, 2, 3, 4, 5, 6, 5, 5, 4, 5,
4, 4, 5, 4, 4, 3, 3, 3, 3, 5, 7, 5, 7, 5, 9, 5, 8, 7, 8, 8, 10, 8, 9, 8, 7, 9,
2, 86, 109, 99, 107, 101, 105, 101, 105, 102, 104, 102, 105, 102, 104, 104, 105,
105, 105, 104, 105, 105, 104, 105, 105, 105, 105, 105, 105, 105, 106, 106, 105,
106, 105, 105, 106, 106, 106, 107, 106, 106, 106, 107, 107, 106, 107, 108, 107,
108, 107, 107, 108, 108, 108, 107, 107, 108, 108, 108, 108, 108, 108, 108, 108,
109, 109, 109, 109, 109, 109, 109, 109, 109, 110, 110, 109, 109, 110, 110, 111,
110, 111, 110, 111, 111, 111, 111, 111, 111, 111, 111, 111, 112, 111, 112, 112,
111, 111, 111, 112, 112, 112, 113, 112, 112, 113, 112, 113, 113, 113, 114, 114,
113, 113, 113, 114, 113, 115, 113, 114, 114, 114, 114, 114, 115, 115, 115, 115,
115, 115, 115, 116, 115, 115, 115, 116, 116, 115, 115, 116, 117, 116, 117, 116,
117, 116, 117, 117, 116, 116, 118, 116, 118, 117, 118, 117, 118, 118, 119, 117,
118, 118, 119, 119, 118, 120, 117, 120, 116, 122, 113, 127, 71, 17, 34, 23, 30,
25, 27, 24, 26, 24, 24, 24, 23, 23, 22, 22, 22, 22, 19, 20, 19, 20, 18, 18, 18,
18, 16, 16, 15, 16, 14, 14, 14, 14, 12, 12, 12, 11, 11, 4, 2, -1, -4, -6, -7,
-8, -11, -11, -14, -15, -16, -17, -19, -20, -21, -22, -23, -24, -25, -27, -28,
-30, -28, -32, -27, -69, -88, -80, -85, -81, -84, -81, -83, -81, -83, -81, -82,
-82, -81, -81, -81, -81, -81, -81, -81, -80, -81, -81, -80, -81, -79, -80, -80,
-80, -79, -80, -80, -80, -79, -79, -79, -79, -79, -78, -78, -79, -78, -77, -79,
-78, -78, -78, -78, -77, -77, -77, -77, -77, -76, -77, -77, -76, -76, -76, -76,
-75, -76, -76, -75, -76, -76, -76, -75, -75, -75, -75, -75, -75, -75, -74, -74,
-74, -74, -74, -75, -74, -74, -74, -73, -73, -74, -73, -72, -73, -73, -73, -72,
-73, -73, -72, -72, -72, -72, -72, -71, -71, -71, -71, -71, -71, -71, -70, -70,
-70, -69, -71, -70, -70, -70, -70, -69, -70, -69, -69, -69, -70, -68, -69, -68,
-69, -68, -68, -67, -69, -68, -67, -68, -67, -68, -67, -67, -67, -68, -65, -68,
-67, -67, -66, -67, -65, -67, -64, -68, -64, -67, -64, -68, -61, 6, 9, 6, 8, 6,
8, 5, 8, 5, 7, 5, 6, 4, 6, 4, 6, 4, 5, 3, 4, 4, 4, 3, 4, 3, 3, 3, 3, 1, 2, 3, 2,
1, 2, 1, 0, 1, 1, 2, -17, -23, -19, -21, -18, -20, -17, -19, -12, 0, -2, -3, -2,
-2, -3, -3, -4, -3, -4, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -2, -2, -2, -2,
-2, -3, -1, 0, -1, -1, -1, -2, -3, -2, };