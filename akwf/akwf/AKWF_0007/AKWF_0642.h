#define DATA_LENGTH 512
#define DATA AKWF_0642

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 5, 8, 10, 13, 15, 17, 19, 21, 23,
26, 27, 30, 32, 34, 37, 38, 41, 42, 44, 47, 49, 50, 52, 54, 56, 59, 60, 61, 64,
66, 67, 69, 70, 72, 73, 75, 77, 78, 80, 82, 83, 84, 86, 88, 89, 90, 91, 93, 95,
95, 96, 98, 98, 100, 101, 101, 103, 104, 105, 105, 107, 107, 109, 109, 110, 111,
112, 112, 113, 114, 114, 115, 116, 116, 116, 117, 117, 118, 119, 118, 118, 118,
118, 119, 119, 119, 120, 118, 116, 112, 111, 109, 106, 104, 102, 100, 97, 94,
93, 90, 88, 86, 84, 82, 80, 78, 76, 74, 72, 71, 69, 67, 64, 63, 61, 58, 57, 55,
53, 52, 50, 49, 46, 45, 43, 42, 39, 39, 37, 36, 34, 34, 31, 31, 29, 28, 26, 25,
23, 22, 22, 20, 19, 18, 17, 16, 14, 14, 13, 12, 11, 10, 10, 9, 8, 7, 7, 6, 5, 5,
4, 4, 3, 3, 2, 2, 1, 2, 1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, -1,
0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0,
-1, 0, 0, 0, 1, 1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, -3, -6, -7, -10, -13, -15,
-17, -20, -21, -24, -26, -28, -31, -33, -34, -36, -38, -40, -42, -45, -47, -49,
-51, -52, -54, -56, -58, -60, -62, -64, -65, -67, -68, -70, -72, -74, -76, -77,
-79, -80, -81, -83, -85, -87, -88, -89, -90, -91, -93, -95, -95, -96, -98, -99,
-100, -100, -102, -103, -105, -105, -107, -106, -108, -109, -109, -111, -112,
-112, -111, -113, -114, -114, -115, -116, -117, -116, -117, -118, -117, -117,
-117, -119, -118, -119, -118, -119, -119, -119, -118, -115, -113, -111, -108,
-106, -103, -101, -99, -97, -94, -92, -90, -87, -86, -84, -82, -79, -78, -76,
-73, -72, -70, -68, -66, -64, -62, -60, -59, -57, -55, -53, -51, -50, -48, -46,
-45, -43, -42, -40, -38, -38, -35, -34, -33, -31, -30, -29, -27, -25, -25, -24,
-23, -21, -21, -19, -18, -16, -16, -15, -14, -13, -12, -11, -10, -10, -8, -8,
-7, -6, -6, -6, -5, -4, -4, -3, -3, -2, -2, -2, -2, -1, 0, -1, 0, -1, 0, -1, -1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, -1, 0, 0, -1, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0,
1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0,
-1, 0, };