#define DATA_LENGTH 512
#define DATA AKWF_0675

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 3, 4, 6, 7, 9, 9, 11, 12, 13,
15, 16, 17, 17, 19, 20, 22, 22, 23, 25, 26, 28, 28, 29, 30, 32, 32, 33, 34, 35,
37, 38, 38, 40, 40, 41, 42, 44, 45, 45, 46, 48, 48, 49, 50, 52, 52, 53, 54, 55,
55, 57, 58, 59, 59, 60, 60, 62, 62, 63, 64, 64, 66, 67, 67, 68, 69, 70, 70, 71,
72, 73, 73, 74, 75, 75, 77, 77, 77, 78, 79, 80, 80, 80, 81, 82, 83, 83, 84, 85,
86, 86, 87, 87, 88, 88, 89, 89, 90, 91, 91, 92, 91, 92, 94, 93, 93, 94, 95, 96,
96, 96, 98, 97, 98, 98, 99, 99, 100, 100, 101, 101, 101, 102, 103, 102, 104,
103, 103, 104, 104, 104, 105, 105, 105, 106, 106, 106, 107, 106, 108, 108, 108,
109, 109, 109, 109, 110, 111, 110, 110, 111, 111, 111, 111, 111, 112, 112, 112,
113, 113, 113, 113, 113, 114, 113, 113, 115, 114, 114, 116, 115, 115, 115, 116,
116, 116, 116, 115, 116, 116, 116, 117, 117, 116, 117, 117, 117, 117, 118, 117,
117, 117, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 119, 118,
118, 118, 118, 118, 118, 119, 119, 119, 118, 118, 119, 118, 119, 120, 119, 119,
118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119,
118, 119, 119, 119, 118, 119, 118, 120, 118, 121, 113, 86, 77, 67, 60, 53, 47,
41, 35, 31, 26, 23, 17, 14, 10, 7, 3, 0, -3, -7, -9, -13, -16, -18, -21, -23,
-25, -28, -30, -33, -35, -37, -39, -41, -43, -45, -46, -49, -50, -52, -54, -56,
-57, -59, -61, -62, -65, -65, -67, -68, -70, -71, -73, -73, -75, -75, -76, -78,
-80, -81, -82, -83, -84, -85, -86, -87, -87, -90, -90, -90, -91, -92, -93, -94,
-94, -95, -97, -98, -98, -99, -100, -100, -100, -102, -102, -102, -103, -104,
-105, -104, -105, -105, -106, -107, -107, -107, -108, -108, -109, -109, -109,
-110, -110, -111, -111, -111, -111, -113, -112, -113, -113, -113, -114, -113,
-114, -114, -115, -115, -115, -115, -115, -115, -116, -116, -116, -116, -116,
-116, -117, -117, -116, -117, -118, -117, -117, -118, -118, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -119, -119, -118,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -117, -115, -113, -111, -110, -108, -106, -105, -104, -102, -101,
-99, -97, -95, -94, -91, -90, -89, -87, -85, -85, -82, -81, -80, -79, -77, -76,
-74, -72, -70, -69, -67, -66, -64, -64, -61, -60, -59, -57, -55, -54, -53, -51,
-50, -49, -47, -46, -44, -42, -40, -39, -38, -36, -36, -33, -33, -32, -30, -28,
-27, -26, -24, -23, -22, -20, -19, -18, -16, -15, -14, -13, -10, -10, -9, -7,
-5, -4, -3, -2, -1, };