#define DATA_LENGTH 512
#define DATA AKWF_0672

const PROGMEM int8_t DATA[DATA_LENGTH] = {25, 41, 48, 57, 62, 68, 72, 77, 80,
85, 87, 91, 92, 96, 98, 100, 101, 104, 105, 107, 108, 110, 111, 113, 113, 114,
114, 116, 116, 117, 118, 117, 117, 118, 119, 119, 119, 118, 120, 119, 119, 119,
119, 118, 119, 117, 118, 117, 117, 116, 117, 115, 115, 114, 113, 113, 112, 112,
112, 110, 109, 109, 108, 107, 107, 106, 105, 104, 103, 103, 101, 101, 99, 97,
97, 96, 94, 93, 93, 92, 91, 90, 88, 87, 86, 85, 83, 82, 81, 80, 78, 77, 76, 75,
73, 73, 71, 70, 68, 67, 66, 65, 64, 62, 61, 60, 58, 57, 55, 54, 53, 52, 50, 49,
47, 46, 45, 44, 43, 40, 40, 39, 37, 35, 33, 33, 31, 30, 28, 27, 27, 24, 23, 21,
21, 18, 18, 16, 15, 14, 12, 11, 10, 8, 7, 6, 5, 2, 1, 1, -1, -2, -4, -5, -5, -7,
-9, -10, -11, -13, -14, -14, -16, -17, -19, -20, -22, -23, -24, -25, -26, -27,
-28, -30, -31, -32, -33, -35, -36, -37, -37, -40, -41, -41, -43, -44, -45, -46,
-47, -49, -49, -51, -52, -53, -54, -54, -56, -56, -57, -59, -60, -61, -62, -63,
-64, -65, -65, -67, -68, -69, -70, -71, -71, -72, -72, -74, -75, -76, -77, -77,
-79, -79, -81, -80, -82, -82, -84, -85, -84, -85, -87, -87, -88, -89, -89, -90,
-91, -92, -92, -93, -93, -94, -95, -96, -96, -97, -98, -99, -99, -100, -100,
-100, -101, -102, -102, -103, -104, -104, -104, -105, -106, -106, -106, -107,
-108, -108, -108, -109, -108, -109, -110, -110, -111, -112, -111, -112, -112,
-112, -113, -113, -114, -115, -114, -115, -116, -115, -115, -115, -116, -116,
-116, -117, -116, -117, -117, -117, -118, -117, -118, -118, -118, -119, -118,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -118, -117, -118, -117, -117, -118, -117, -117, -117, -116, -117, -117,
-116, -116, -116, -115, -115, -115, -115, -114, -115, -114, -114, -112, -113,
-114, -113, -112, -112, -111, -111, -111, -110, -110, -109, -109, -109, -108,
-108, -107, -107, -107, -106, -106, -105, -106, -104, -104, -103, -103, -102,
-103, -101, -101, -100, -100, -100, -99, -98, -98, -97, -96, -97, -96, -95, -94,
-94, -93, -93, -92, -92, -90, -90, -90, -90, -88, -88, -87, -87, -85, -85, -85,
-84, -83, -82, -81, -81, -80, -80, -80, -79, -78, -77, -76, -75, -75, -74, -73,
-72, -73, -71, -70, -69, -69, -68, -67, -67, -65, -65, -65, -64, -62, -61, -60,
-60, -59, -59, -57, -57, -55, -55, -54, -53, -53, -52, -51, -50, -49, -48, -47,
-47, -46, -45, -44, -43, -42, -42, -41, -40, -38, -37, -36, -37, -35, -34, -34,
-32, -32, -31, -30, -29, -28, -27, -27, -26, -25, -23, -22, -22, -20, -21, -19,
-18, -17, -16, -16, -14, -14, -12, -11, -10, -10, -9, -7, -8, -6, -5, -5, -3,
-2, -1, 0, };