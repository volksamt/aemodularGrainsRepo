#define DATA_LENGTH 512
#define DATA AKWF_0663

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 11, 16, 21, 24, 28, 30, 33, 35, 37,
40, 41, 43, 45, 46, 48, 50, 51, 52, 54, 54, 56, 57, 57, 59, 59, 61, 62, 63, 64,
65, 65, 66, 66, 68, 69, 69, 70, 71, 71, 71, 71, 73, 73, 74, 74, 75, 76, 76, 77,
77, 78, 78, 78, 79, 80, 79, 81, 81, 81, 81, 83, 83, 83, 83, 84, 84, 84, 84, 85,
85, 85, 86, 86, 86, 87, 87, 87, 88, 88, 88, 88, 88, 88, 88, 88, 88, 89, 89, 89,
90, 90, 91, 91, 91, 91, 91, 91, 91, 91, 91, 92, 91, 92, 91, 92, 91, 92, 92, 92,
92, 93, 92, 92, 92, 92, 93, 93, 93, 91, 93, 90, 95, 88, 100, 59, 17, 22, 11, 13,
7, 7, 3, 2, -1, -1, -4, -4, -5, -7, -6, -8, -9, -11, -10, -11, -12, -13, -14,
-14, -15, -16, -16, -17, -17, -18, -19, -19, -19, -20, -21, -21, -21, -21, -22,
-23, -24, -24, -24, -25, -25, -25, -25, -26, -26, -26, -27, -27, -27, -27, -28,
-27, -28, -29, -29, -30, -29, -29, -30, -30, -31, -30, -31, -31, -31, -31, -31,
-32, -32, -32, -32, -33, -32, -32, -33, -33, -33, -33, -34, -34, -35, -34, -33,
-35, -34, -34, -34, -35, -35, -36, -35, -35, -35, -35, -36, -36, -35, -36, -36,
-35, -36, -35, -36, -37, -36, -36, -37, -37, -37, -36, -36, -36, -36, -37, -37,
-37, -37, -36, -36, -37, -37, -37, -35, -39, -8, 9, 8, 14, 13, 17, 16, 18, 19,
20, 20, 21, 21, 23, 24, 24, 25, 26, 26, 27, 27, 26, 27, 28, 28, 28, 29, 28, 29,
30, 30, 30, 31, 30, 30, 31, 31, 31, 31, 31, 32, 33, 31, 33, 32, 33, 33, 33, 32,
34, 33, 34, 32, 33, 34, 33, 34, 33, 35, 32, 35, 30, 40, -4, -39, -35, -45, -43,
-49, -50, -53, -53, -56, -56, -58, -59, -60, -60, -62, -63, -63, -64, -65, -66,
-66, -68, -68, -68, -68, -71, -69, -70, -71, -71, -71, -73, -72, -74, -74, -74,
-74, -75, -74, -74, -75, -75, -75, -75, -77, -76, -77, -76, -77, -76, -78, -77,
-79, -78, -79, -77, -79, -77, -78, -77, -77, -79, -75, -83, -15, 14, 12, 22, 21,
28, 28, 33, 33, 36, 36, 39, 40, 42, 42, 44, 44, 46, 48, 47, 49, 50, 51, 51, 52,
52, 54, 53, 54, 54, 56, 56, 56, 57, 57, 58, 59, 59, 59, 60, 60, 61, 60, 62, 61,
62, 61, 63, 61, 63, 61, 63, 62, 62, 62, 64, 63, 63, 64, 62, 66, 59, 74, -4, -56,
-50, -66, -63, -72, -71, -79, -78, -83, -84, -87, -88, -90, -92, -93, -95, -95,
-98, -99, -100, -100, -103, -102, -104, -104, -106, -106, -108, -107, -109,
-109, -110, -110, -111, -112, -113, -113, -114, -114, -114, -115, -115, -116,
-115, -117, -116, -118, -116, -118, -117, -119, -117, -119, -117, -119, -118,
-120, -118, -120, -120, -119, -119, -117, -124, -30, 3, };