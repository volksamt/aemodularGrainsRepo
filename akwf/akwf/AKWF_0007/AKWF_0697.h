#define DATA_LENGTH 512
#define DATA AKWF_0697

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 6, 7, 20, 30, 35, 41, 45, 49,
53, 58, 61, 65, 68, 71, 74, 77, 80, 83, 86, 88, 91, 93, 96, 98, 100, 102, 103,
105, 107, 108, 110, 110, 112, 113, 115, 115, 116, 117, 118, 118, 118, 118, 118,
119, 119, 119, 119, 119, 119, 118, 118, 117, 117, 116, 116, 115, 114, 114, 113,
112, 111, 110, 110, 110, 108, 108, 106, 105, 105, 104, 104, 103, 101, 101, 100,
100, 100, 99, 98, 98, 98, 97, 97, 97, 96, 96, 96, 96, 96, 96, 97, 97, 97, 97,
98, 98, 98, 99, 100, 100, 101, 101, 102, 103, 103, 104, 105, 105, 106, 107, 108,
109, 109, 109, 111, 111, 111, 113, 112, 113, 114, 115, 114, 115, 115, 115, 116,
116, 117, 117, 116, 116, 117, 116, 115, 116, 116, 116, 115, 115, 114, 113, 114,
112, 113, 112, 112, 110, 110, 109, 108, 108, 106, 106, 105, 104, 103, 102, 101,
100, 100, 98, 96, 96, 95, 93, 93, 92, 91, 88, 88, 87, 86, 84, 84, 82, 82, 80,
79, 78, 77, 76, 74, 73, 72, 71, 69, 68, 67, 66, 65, 63, 63, 62, 60, 58, 58, 57,
55, 54, 52, 52, 51, 49, 48, 46, 45, 44, 42, 42, 40, 38, 37, 36, 34, 32, 31, 30,
29, 26, 24, 22, 20, 19, 17, 15, 13, 11, 9, 7, 5, 3, 1, 0, -3, -4, -7, -9, -11,
-13, -15, -17, -19, -21, -23, -25, -27, -29, -32, -33, -35, -37, -39, -42, -43,
-46, -46, -49, -51, -52, -54, -57, -58, -60, -63, -64, -65, -67, -69, -71, -72,
-74, -76, -77, -80, -80, -82, -84, -85, -86, -88, -88, -89, -91, -93, -93, -94,
-95, -96, -97, -99, -99, -99, -101, -101, -101, -101, -102, -103, -103, -103,
-105, -103, -105, -104, -105, -104, -105, -105, -105, -104, -104, -105, -103,
-103, -103, -103, -102, -101, -101, -100, -100, -100, -98, -99, -98, -97, -96,
-96, -95, -94, -94, -93, -92, -91, -91, -90, -89, -89, -88, -87, -86, -86, -86,
-86, -85, -84, -84, -84, -83, -82, -82, -83, -82, -82, -81, -82, -81, -81, -82,
-82, -82, -82, -83, -83, -84, -83, -83, -84, -84, -85, -85, -85, -86, -87, -88,
-87, -89, -89, -90, -90, -91, -92, -91, -93, -93, -94, -95, -96, -96, -96, -98,
-98, -98, -99, -99, -99, -100, -101, -101, -101, -101, -101, -102, -102, -102,
-102, -102, -102, -102, -102, -102, -102, -102, -101, -100, -101, -100, -100,
-99, -99, -99, -98, -97, -97, -97, -96, -95, -94, -93, -93, -92, -90, -90, -89,
-89, -88, -86, -86, -84, -83, -83, -82, -81, -79, -78, -78, -76, -75, -74, -74,
-72, -71, -70, -69, -68, -67, -66, -65, -64, -63, -61, -60, -59, -58, -57, -57,
-55, -54, -53, -52, -50, -49, -48, -48, -47, -45, -44, -44, -42, -40, -39, -38,
-37, -36, -34, -33, -32, -31, -29, -28, -27, -26, -24, -24, -21, -20, -19, -17,
-16, -13, -12, -11, -9, -8, -6, -5, -3, -1, };