#define DATA_LENGTH 512
#define DATA AKWF_0627

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 11, 10, 11, 12, 13, 14, 15, 15, 16,
17, 18, 19, 19, 20, 20, 21, 23, 24, 24, 26, 27, 26, 28, 28, 29, 30, 31, 32, 32,
33, 33, 34, 35, 36, 37, 38, 37, 39, 39, 40, 42, 42, 42, 44, 44, 45, 46, 47, 48,
48, 48, 49, 50, 52, 52, 53, 54, 54, 56, 56, 58, 57, 59, 60, 60, 61, 61, 63, 63,
64, 65, 66, 66, 67, 68, 69, 68, 69, 71, 71, 73, 73, 74, 74, 75, 77, 77, 79, 78,
80, 80, 80, 82, 83, 83, 84, 85, 85, 87, 87, 87, 89, 90, 91, 91, 92, 93, 93, 94,
96, 96, 97, 98, 98, 99, 99, 101, 101, 102, 103, 103, 105, 105, 106, 107, 108,
108, 109, 110, 111, 111, 112, 112, 114, 114, 116, 116, 118, 117, 119, 119, 116,
114, 111, 109, 106, 103, 102, 98, 97, 94, 92, 89, 87, 84, 83, 80, 78, 75, 73,
70, 68, 65, 62, 60, 58, 55, 53, 50, 48, 46, 42, 41, 39, 36, 33, 31, 29, 27, 24,
22, 19, 16, 14, 11, 1, 0, 0, -1, 0, 0, 0, -1, 0, -1, 1, 0, 1, -1, 0, 0, 1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, -1, -1, 0, 0, 0, 0, -1,
0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0,
-10, -10, -11, -12, -12, -14, -14, -15, -16, -17, -17, -18, -19, -20, -20, -21,
-22, -23, -23, -24, -24, -25, -26, -27, -28, -29, -30, -31, -32, -32, -32, -33,
-34, -36, -36, -37, -37, -38, -40, -39, -40, -42, -42, -42, -43, -44, -46, -46,
-46, -47, -48, -49, -50, -51, -52, -52, -53, -54, -54, -56, -56, -57, -58, -58,
-60, -60, -62, -62, -62, -63, -64, -65, -66, -66, -67, -68, -69, -69, -70, -71,
-72, -72, -73, -74, -76, -76, -76, -78, -78, -79, -80, -81, -81, -82, -83, -84,
-84, -86, -85, -86, -87, -89, -89, -90, -91, -91, -93, -93, -93, -94, -95, -96,
-97, -97, -99, -99, -99, -101, -101, -102, -103, -103, -105, -105, -106, -106,
-108, -108, -109, -110, -111, -112, -112, -113, -114, -115, -115, -117, -118,
-117, -119, -118, -116, -114, -110, -108, -105, -104, -101, -98, -96, -94, -91,
-89, -86, -84, -82, -79, -77, -75, -72, -70, -67, -65, -62, -60, -57, -56, -52,
-51, -48, -45, -43, -41, -39, -36, -33, -31, -29, -26, -24, -21, -20, -15, -15,
-10, 0, 1, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 1, -1, 1, -1, 0, 0, 0, 0, 0, 0, 0,
0, -1, 0, 0, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0,
-1, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, };