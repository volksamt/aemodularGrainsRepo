#define DATA_LENGTH 512
#define DATA AKWF_0684

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 34, 50, 61, 70, 77, 85, 90, 95,
100, 105, 106, 111, 112, 114, 116, 118, 118, 119, 119, 119, 118, 118, 118, 118,
117, 115, 114, 113, 112, 111, 109, 108, 107, 106, 105, 103, 102, 101, 100, 99,
99, 97, 97, 97, 95, 96, 96, 95, 95, 95, 95, 95, 96, 97, 97, 98, 98, 99, 100,
100, 101, 102, 103, 104, 104, 105, 106, 108, 108, 109, 110, 111, 112, 112, 113,
114, 115, 114, 115, 116, 116, 117, 117, 117, 117, 118, 118, 118, 118, 117, 117,
116, 116, 116, 115, 115, 114, 114, 112, 113, 112, 111, 110, 109, 108, 108, 107,
105, 104, 103, 102, 100, 100, 98, 98, 96, 95, 94, 93, 92, 91, 89, 87, 87, 85,
84, 83, 81, 80, 79, 77, 76, 74, 74, 73, 72, 69, 68, 67, 67, 66, 64, 62, 61, 60,
58, 58, 57, 55, 54, 52, 52, 50, 49, 48, 46, 45, 44, 41, 41, 39, 38, 36, 34, 33,
32, 30, 29, 27, 25, 25, 22, 21, 19, 17, 15, 12, 12, 10, 8, 6, 3, 2, 0, -2, -4,
-7, -8, -10, -12, -15, -17, -19, -21, -24, -25, -27, -29, -31, -33, -35, -37,
-39, -41, -43, -45, -48, -49, -50, -53, -55, -56, -59, -60, -62, -65, -65, -68,
-69, -71, -73, -75, -77, -78, -80, -82, -83, -85, -86, -89, -89, -91, -92, -94,
-95, -98, -98, -100, -102, -103, -103, -104, -106, -106, -108, -108, -110, -110,
-112, -112, -113, -113, -114, -114, -115, -116, -117, -117, -117, -118, -118,
-119, -119, -118, -119, -119, -119, -119, -118, -119, -119, -119, -119, -118,
-117, -118, -117, -117, -117, -117, -116, -116, -115, -114, -114, -113, -114,
-113, -112, -111, -112, -109, -110, -108, -108, -107, -106, -106, -105, -105,
-105, -104, -102, -103, -101, -102, -101, -100, -100, -99, -98, -99, -98, -97,
-98, -97, -96, -97, -96, -97, -96, -96, -96, -96, -96, -96, -95, -96, -95, -96,
-95, -96, -96, -96, -96, -97, -97, -97, -98, -98, -99, -99, -99, -100, -101,
-101, -101, -102, -102, -103, -104, -104, -105, -105, -106, -107, -107, -107,
-108, -109, -109, -110, -110, -111, -111, -112, -112, -113, -114, -114, -113,
-115, -115, -116, -116, -116, -116, -117, -117, -117, -117, -118, -117, -117,
-117, -118, -117, -117, -117, -117, -118, -118, -117, -116, -116, -116, -115,
-116, -115, -115, -115, -113, -114, -113, -112, -112, -111, -111, -110, -110,
-108, -108, -107, -107, -106, -105, -105, -104, -103, -101, -102, -101, -100,
-99, -97, -96, -96, -95, -94, -93, -93, -91, -90, -89, -88, -88, -87, -85, -85,
-84, -83, -81, -81, -80, -79, -78, -77, -76, -75, -74, -73, -72, -71, -71, -69,
-69, -67, -67, -65, -65, -64, -63, -62, -60, -60, -58, -58, -57, -56, -55, -54,
-53, -52, -51, -49, -48, -46, -46, -45, -44, -43, -42, -40, -40, -39, -37, -36,
-35, -34, -32, -31, -29, -29, -28, -26, -25, -23, -22, -21, -18, -17, -16, -14,
-12, -11, -9, -8, -6, -4, -3, -1, };