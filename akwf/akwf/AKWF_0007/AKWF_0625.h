#define DATA_LENGTH 512
#define DATA AKWF_0625

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 7, 10, 11, 14, 16, 19, 21,
24, 26, 28, 31, 33, 35, 38, 40, 43, 44, 46, 49, 51, 54, 56, 58, 60, 62, 64, 66,
69, 70, 73, 73, 76, 79, 80, 82, 83, 86, 88, 88, 91, 92, 93, 96, 97, 99, 99, 101,
102, 103, 105, 106, 107, 109, 109, 110, 111, 111, 113, 114, 114, 115, 116, 116,
117, 117, 118, 119, 118, 118, 118, 119, 119, 119, 118, 118, 118, 119, 119, 119,
119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 118, 118, 119, 118, 118, 118,
118, 118, 119, 118, 117, 118, 118, 118, 118, 118, 118, 117, 117, 117, 118, 117,
117, 117, 116, 116, 116, 115, 116, 115, 116, 115, 115, 115, 114, 115, 114, 114,
113, 113, 114, 112, 111, 112, 111, 111, 111, 109, 111, 110, 110, 109, 108, 107,
107, 107, 105, 106, 104, 104, 104, 103, 103, 102, 102, 100, 100, 100, 98, 98,
97, 97, 96, 95, 93, 94, 93, 92, 91, 90, 90, 88, 87, 86, 86, 84, 83, 81, 81, 80,
79, 78, 76, 75, 75, 73, 72, 71, 69, 68, 67, 65, 64, 63, 61, 60, 59, 58, 56, 55,
53, 53, 51, 49, 47, 47, 44, 43, 42, 40, 39, 36, 35, 33, 31, 30, 28, 27, 25, 24,
22, 20, 18, 16, 15, 13, 11, 9, 8, 6, 4, 2, 0, -1, -3, -5, -8, -9, -11, -12, -14,
-17, -19, -20, -21, -24, -25, -28, -29, -30, -32, -34, -36, -38, -39, -42, -42,
-45, -47, -49, -50, -51, -53, -55, -57, -59, -60, -62, -64, -65, -67, -67, -70,
-71, -73, -74, -76, -78, -79, -80, -82, -83, -84, -86, -87, -88, -90, -92, -92,
-94, -95, -97, -97, -98, -99, -101, -102, -103, -103, -104, -106, -107, -107,
-108, -109, -111, -111, -111, -111, -113, -114, -115, -114, -115, -115, -116,
-117, -117, -118, -117, -118, -119, -118, -119, -118, -118, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -118, -119, -120, -119, -119, -118,
-119, -120, -119, -119, -119, -119, -119, -120, -119, -119, -118, -119, -119,
-119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -118, -118, -118, -118, -119, -118, -117, -118, -118, -117, -117, -117,
-118, -116, -117, -117, -116, -116, -117, -116, -116, -115, -115, -114, -114,
-114, -114, -113, -113, -113, -112, -111, -111, -111, -111, -110, -109, -108,
-107, -108, -107, -106, -106, -106, -104, -103, -103, -102, -101, -100, -99,
-99, -97, -97, -96, -94, -93, -93, -91, -90, -90, -88, -86, -85, -84, -82, -82,
-80, -78, -78, -75, -74, -72, -71, -69, -69, -67, -65, -63, -61, -59, -58, -56,
-54, -52, -51, -48, -47, -45, -43, -42, -38, -37, -34, -32, -31, -28, -26, -24,
-21, -20, -18, -15, -13, -11, -9, -6, -4, -1, };