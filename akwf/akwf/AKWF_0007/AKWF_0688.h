#define DATA_LENGTH 512
#define DATA AKWF_0688

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 5, 7, 8, 10, 11, 12, 14, 15,
17, 18, 19, 21, 21, 23, 25, 26, 27, 29, 30, 32, 34, 34, 36, 37, 39, 41, 41, 43,
44, 46, 47, 48, 49, 51, 53, 54, 55, 57, 58, 60, 61, 62, 63, 64, 66, 67, 69, 70,
70, 72, 73, 72, 73, 73, 73, 73, 73, 73, 73, 73, 73, 72, 72, 72, 72, 72, 73, 72,
72, 71, 72, 71, 71, 72, 72, 73, 72, 72, 72, 74, 75, 75, 75, 76, 76, 77, 77, 77,
79, 79, 80, 80, 82, 82, 84, 84, 86, 86, 88, 89, 89, 91, 92, 92, 94, 94, 96, 97,
98, 98, 100, 101, 102, 103, 104, 106, 107, 109, 110, 110, 111, 114, 114, 115,
116, 118, 118, 119, 119, 119, 118, 115, 112, 111, 108, 105, 101, 99, 95, 92, 87,
84, 80, 76, 73, 69, 66, 62, 59, 55, 52, 49, 45, 44, 41, 38, 35, 34, 31, 29, 28,
26, 25, 22, 21, 20, 19, 18, 17, 16, 15, 15, 14, 14, 13, 13, 13, 13, 12, 13, 13,
13, 13, 14, 14, 14, 15, 15, 16, 16, 17, 17, 18, 19, 20, 21, 21, 22, 22, 24, 24,
25, 26, 27, 28, 29, 30, 32, 32, 33, 35, 35, 35, 36, 37, 36, 37, 36, 36, 37, 37,
36, 36, 36, 36, 35, 36, 35, 34, 34, 35, 33, 34, 34, 34, 33, 34, 34, 34, 34, 34,
34, 35, 36, 35, 35, 36, 36, 36, 36, 37, 38, 39, 40, 40, 41, 41, 42, 43, 44, 44,
46, 45, 46, 47, 49, 50, 50, 51, 52, 53, 54, 55, 57, 57, 59, 59, 60, 62, 62, 64,
65, 66, 66, 68, 69, 71, 71, 73, 74, 75, 76, 77, 78, 79, 80, 80, 81, 78, 77, 73,
71, 68, 65, 61, 57, 54, 50, 45, 40, 37, 31, 28, 22, 18, 13, 11, 3, 6, -26, -61,
-58, -62, -57, -56, -52, -50, -45, -42, -40, -41, -40, -40, -41, -42, -43, -43,
-43, -42, -43, -41, -41, -39, -38, -37, -35, -33, -31, -30, -28, -26, -24, -21,
-19, -17, -16, -14, -11, -9, -6, -4, -2, 0, 3, 4, 3, 1, -3, -7, -11, -17, -23,
-30, -37, -42, -48, -54, -58, -65, -70, -73, -78, -82, -85, -89, -91, -93, -96,
-97, -98, -99, -101, -102, -102, -102, -103, -103, -103, -102, -102, -102, -101,
-100, -99, -98, -98, -97, -95, -94, -93, -92, -90, -90, -88, -86, -85, -84, -82,
-82, -80, -80, -79, -79, -78, -78, -79, -79, -79, -79, -79, -80, -80, -81, -82,
-81, -82, -81, -81, -82, -82, -81, -81, -80, -80, -80, -80, -79, -78, -78, -78,
-76, -75, -75, -74, -73, -72, -71, -70, -69, -67, -66, -65, -64, -63, -62, -60,
-59, -58, -56, -55, -54, -52, -51, -50, -49, -46, -45, -44, -42, -41, -39, -38,
-37, -35, -35, -33, -31, -30, -28, -27, -26, -24, -23, -21, -20, -19, -17, -16,
-15, -13, -12, -11, -8, -8, -5, -4, -3, -1, 0, };