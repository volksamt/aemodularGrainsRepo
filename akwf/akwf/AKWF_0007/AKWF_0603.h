#define DATA_LENGTH 512
#define DATA AKWF_0603

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 8, 27, 25, 27, 28, 28, 30, 30, 30,
31, 32, 32, 33, 34, 36, 35, 36, 37, 39, 39, 40, 40, 41, 42, 42, 43, 45, 45, 46,
46, 48, 47, 49, 50, 51, 52, 52, 53, 53, 54, 56, 55, 56, 58, 58, 58, 60, 60, 61,
62, 62, 63, 64, 65, 66, 66, 67, 67, 69, 70, 70, 72, 71, 73, 74, 74, 75, 76, 77,
78, 79, 79, 80, 81, 81, 82, 83, 84, 85, 86, 85, 87, 88, 88, 89, 89, 91, 92, 92,
93, 93, 94, 95, 96, 96, 98, 98, 98, 100, 100, 101, 101, 102, 104, 104, 105, 105,
107, 108, 108, 110, 111, 111, 112, 112, 113, 114, 115, 116, 116, 117, 118, 119,
119, 118, 118, 116, 117, 116, 114, 114, 114, 113, 112, 111, 110, 110, 109, 108,
107, 107, 106, 105, 105, 104, 103, 102, 101, 101, 100, 100, 99, 98, 98, 97, 96,
95, 94, 93, 92, 91, 91, 90, 90, 89, 88, 87, 87, 86, 85, 84, 84, 83, 81, 81, 80,
80, 79, 77, 77, 76, 76, 75, 74, 73, 73, 71, 71, 70, 70, 69, 69, 68, 66, 66, 65,
65, 63, 63, 62, 61, 61, 59, 59, 59, 58, 57, 56, 55, 54, 54, 54, 52, 51, 51, 50,
49, 49, 48, 48, 46, 46, 45, 45, 44, 42, 41, 41, 40, 40, 39, 38, 38, 36, 36, 36,
35, 34, 33, 33, 31, 30, 30, 28, 29, 27, 27, 26, 25, 24, 23, 24, 21, 23, -1, -26,
-24, -27, -26, -27, -29, -29, -29, -30, -31, -31, -33, -32, -33, -34, -35, -36,
-37, -37, -37, -38, -38, -39, -40, -41, -41, -42, -42, -43, -43, -44, -44, -46,
-46, -47, -47, -48, -49, -49, -50, -50, -52, -53, -53, -54, -55, -54, -55, -56,
-57, -57, -58, -58, -60, -60, -61, -62, -63, -63, -64, -64, -65, -65, -65, -67,
-67, -68, -69, -69, -69, -71, -71, -71, -73, -74, -73, -75, -75, -76, -76, -76,
-77, -79, -79, -80, -80, -80, -81, -82, -83, -83, -84, -85, -85, -86, -87, -87,
-88, -88, -89, -89, -90, -91, -91, -93, -93, -93, -94, -95, -96, -96, -96, -97,
-97, -99, -100, -100, -101, -101, -102, -103, -103, -104, -105, -105, -106,
-106, -107, -108, -108, -109, -110, -111, -111, -111, -112, -112, -114, -114,
-114, -115, -116, -117, -117, -117, -118, -117, -116, -115, -115, -114, -113,
-112, -110, -110, -109, -108, -108, -107, -106, -105, -104, -103, -103, -102,
-100, -100, -99, -98, -96, -96, -96, -95, -93, -92, -91, -91, -90, -89, -89,
-87, -86, -85, -84, -84, -82, -82, -81, -81, -79, -79, -77, -76, -76, -75, -74,
-73, -72, -72, -69, -69, -68, -67, -67, -66, -65, -64, -62, -62, -61, -60, -60,
-59, -58, -57, -56, -55, -54, -54, -52, -52, -51, -49, -50, -48, -47, -46, -45,
-44, -44, -42, -41, -41, -40, -39, -38, -37, -37, -35, -35, -34, -33, -32, -31,
-30, -29, -29, -27, -28, -25, -26, -24, -25, -22, -22, -18, };