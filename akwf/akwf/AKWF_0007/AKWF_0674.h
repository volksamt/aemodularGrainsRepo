#define DATA_LENGTH 512
#define DATA AKWF_0674

const PROGMEM int8_t DATA[DATA_LENGTH] = {57, 85, 91, 100, 102, 107, 107, 111,
111, 113, 113, 114, 114, 115, 115, 117, 117, 117, 117, 117, 118, 117, 118, 118,
119, 118, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 119, 119, 118, 118, 119, 119, 118, 119, 118, 119, 118, 118, 119, 118,
119, 119, 118, 118, 118, 118, 118, 118, 118, 118, 117, 117, 117, 117, 116, 117,
116, 116, 116, 116, 115, 115, 115, 115, 114, 113, 113, 113, 113, 112, 113, 112,
111, 111, 110, 110, 110, 109, 109, 108, 108, 108, 106, 106, 105, 104, 103, 103,
102, 101, 100, 99, 98, 97, 96, 94, 94, 93, 91, 90, 88, 87, 85, 84, 83, 81, 78,
76, 75, 72, 71, 69, 65, 64, 60, 58, 56, 53, 50, 47, 44, 41, 39, 36, 32, 28, 25,
22, 18, 15, 11, 7, 4, 1, -3, -5, -9, -12, -17, -20, -23, -26, -30, -33, -36,
-39, -42, -44, -47, -50, -52, -55, -56, -60, -62, -65, -66, -68, -71, -73, -75,
-75, -78, -79, -80, -82, -84, -85, -86, -87, -88, -90, -91, -92, -92, -94, -94,
-96, -97, -97, -99, -99, -100, -101, -101, -102, -103, -103, -104, -104, -104,
-105, -106, -106, -106, -106, -107, -108, -109, -109, -109, -110, -110, -110,
-110, -110, -111, -111, -111, -113, -112, -112, -113, -113, -113, -113, -113,
-114, -114, -114, -115, -114, -115, -114, -116, -116, -115, -115, -115, -116,
-116, -116, -116, -117, -116, -116, -117, -117, -117, -116, -117, -117, -117,
-117, -117, -118, -118, -117, -118, -117, -118, -117, -118, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -119, -119, -119, -118, -119, -119, -118,
-118, -119, -119, -119, -119, -119, -118, -119, -118, -118, -118, -119, -118,
-119, -119, -119, -118, -119, -118, -119, -119, -120, -118, -119, -119, -119,
-118, -119, -119, -119, -119, -119, -118, -119, -118, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-118, -119, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -117,
-118, -118, -118, -117, -118, -117, -118, -118, -117, -117, -117, -117, -117,
-117, -116, -117, -117, -117, -117, -116, -117, -117, -117, -115, -115, -116,
-116, -116, -115, -116, -116, -115, -115, -115, -114, -115, -114, -114, -115,
-114, -114, -113, -113, -114, -113, -113, -113, -113, -112, -113, -112, -112,
-112, -111, -111, -111, -110, -111, -110, -110, -110, -109, -109, -108, -108,
-109, -108, -107, -108, -107, -106, -106, -105, -105, -105, -104, -104, -103,
-103, -103, -102, -102, -100, -100, -99, -99, -98, -98, -98, -96, -96, -95, -94,
-94, -92, -92, -92, -91, -90, -88, -87, -86, -85, -84, -84, -82, -82, -80, -80,
-79, -77, -75, -75, -73, -72, -69, -68, -67, -65, -63, -62, -60, -58, -57, -54,
-53, -52, -49, -47, -46, -43, -41, -39, -37, -35, -33, -30, -27, -26, -23, -20,
-18, -15, -13, -11, -8, -5, -4, 1, };