#define DATA_LENGTH 512
#define DATA AKWF_0610

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 12, 18, 25, 30, 37, 44, 50, 56, 62,
69, 76, 81, 88, 94, 100, 107, 114, 118, 112, 105, 99, 93, 87, 79, 75, 67, 61,
55, 48, 42, 36, 29, 23, 16, 11, 4, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, -1, -1, -1,
0, 0, 0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 0, -1, -1, -1, -1, -1, 0, -1, 0, -1, -1,
-1, -1, 0, 0, -1, -1, -1, 0, -1, -1, -1, 0, -1, -1, -1, 0, 0, -1, 0, 0, 0, -1,
-2, -1, 0, -1, -1, 0, 0, -1, 0, -1, -1, 0, 0, 0, -1, 0, -1, 0, -1, -1, -1, -1,
-1, -1, -1, 0, -1, -1, -1, -1, -1, -1, -1, 0, 0, -1, 0, -1, -1, -1, -1, -1, 0,
-1, -1, -1, 0, -1, -1, 0, 0, 0, -1, -1, -1, -1, -1, 0, -1, -1, -1, 0, -1, -1,
-1, -1, -1, -1, -1, -1, -1, 0, 0, -1, -1, -1, 0, -1, -1, -1, -1, 0, 0, 0, -1, 0,
-1, 0, -1, 0, -1, -1, 0, -1, 0, 0, 0, -1, -1, -1, -1, 0, -1, -1, -1, -1, -1, -1,
0, 0, -1, -1, -1, -1, -1, -1, 0, -1, 0, 0, 0, -1, -1, -1, 0, -1, -1, 0, 0, -1,
0, -1, 0, -1, -1, 0, -1, 0, -1, -1, 0, -1, 0, -1, 0, -1, -1, -1, -1, 0, -1, 0,
0, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, 0, -1, -1, -1, -1, -1, -1, 0, 0, 0,
-1, 0, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, 0, 0, -1, 0, -1, -1, 0, 0, 0, -1,
-1, -1, 0, -1, 0, -1, -1, -1, 0, 0, 0, 0, -1, 0, -1, -1, 0, -1, 0, 0, -1, -1, 0,
0, -1, -1, -1, 0, 0, 0, -1, -1, -1, 0, -1, -1, 0, -1, -1, -1, -1, -1, -1, 0, -1,
-1, 0, -1, 0, 0, 0, -1, -1, -1, -1, 0, -1, -1, -1, -1, 0, -1, -1, 0, -1, 0, -1,
0, -1, -1, 0, 0, -1, 0, -1, -1, 0, -1, 0, 0, 0, -1, -1, -1, -1, -1, 0, 0, -1, 0,
-1, -1, 0, -1, -1, -1, 0, -1, -1, 0, 0, -1, 0, -1, 0, -1, -1, -1, -1, 0, -1, 0,
0, -1, -4, -10, -15, -21, -26, -32, -37, -43, -49, -54, -60, -65, -70, -77, -82,
-87, -93, -98, -105, -101, -95, -89, -84, -79, -73, -67, -61, -56, -51, -45,
-40, -34, -28, -22, -17, -12, -6, -1, -1, 0, -1, 0, 0, -1, 0, 0, 0, 0, -1, 0,
-1, 1, -1, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 1, -1, 0, 0, 0, 0, 0, 0,
0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, -1, 0, 0, 0, -1, 0, };