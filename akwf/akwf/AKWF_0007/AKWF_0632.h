#define DATA_LENGTH 512
#define DATA AKWF_0632

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 6, 9, 11, 14, 17, 20, 23, 26,
28, 31, 34, 36, 38, 40, 44, 47, 49, 52, 54, 57, 58, 61, 62, 65, 66, 68, 70, 72,
74, 75, 77, 79, 80, 81, 83, 84, 86, 86, 87, 88, 89, 89, 90, 91, 91, 91, 93, 92,
91, 93, 93, 92, 92, 92, 92, 92, 92, 92, 92, 92, 92, 91, 92, 92, 92, 92, 91, 91,
90, 91, 91, 91, 90, 90, 90, 89, 89, 88, 87, 86, 85, 84, 83, 81, 80, 79, 78, 77,
74, 72, 70, 68, 66, 64, 61, 58, 55, 52, 50, 46, 43, 40, 36, 33, 30, 25, 22, 18,
15, 11, 8, 3, 0, -4, -8, -12, -15, -18, -22, -25, -28, -32, -34, -37, -40, -42,
-44, -46, -48, -50, -51, -51, -53, -54, -54, -54, -55, -55, -55, -54, -54, -54,
-54, -54, -55, -54, -54, -55, -55, -54, -55, -54, -53, -54, -54, -54, -55, -55,
-54, -54, -53, -53, -54, -54, -54, -54, -54, -54, -54, -54, -54, -53, -53, -54,
-54, -53, -53, -52, -53, -53, -52, -52, -52, -51, -52, -51, -51, -51, -50, -50,
-49, -49, -48, -49, -47, -47, -47, -46, -46, -45, -44, -44, -43, -42, -42, -41,
-40, -40, -38, -38, -37, -36, -35, -34, -32, -32, -30, -30, -28, -27, -27, -24,
-24, -22, -21, -19, -18, -17, -16, -14, -12, -10, -9, -8, -6, -5, -3, -2, -1, 2,
4, 5, 5, 7, 9, 11, 13, 14, 16, 17, 19, 21, 22, 23, 24, 26, 28, 29, 30, 31, 33,
35, 36, 37, 38, 39, 41, 41, 44, 43, 45, 46, 46, 47, 48, 48, 49, 51, 51, 51, 51,
53, 52, 54, 53, 54, 54, 54, 53, 54, 54, 53, 53, 54, 53, 54, 54, 54, 54, 54, 54,
53, 53, 54, 54, 54, 53, 53, 54, 54, 53, 53, 53, 52, 52, 52, 51, 51, 50, 50, 50,
49, 49, 48, 47, 46, 45, 44, 43, 42, 41, 39, 38, 35, 34, 32, 31, 29, 27, 25, 23,
20, 17, 15, 12, 9, 6, 3, 0, -3, -6, -10, -13, -17, -20, -24, -28, -31, -34, -38,
-43, -46, -49, -54, -57, -61, -65, -68, -71, -75, -79, -82, -85, -89, -92, -94,
-97, -100, -102, -105, -107, -109, -110, -112, -114, -115, -116, -117, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -120, -119, -118, -119, -118, -119,
-120, -120, -118, -119, -119, -119, -119, -118, -118, -118, -118, -118, -117,
-118, -118, -118, -118, -118, -118, -117, -116, -117, -117, -117, -116, -116,
-116, -115, -115, -114, -114, -114, -113, -113, -112, -110, -110, -109, -108,
-109, -108, -106, -106, -105, -104, -103, -102, -101, -100, -98, -98, -97, -95,
-93, -92, -91, -89, -88, -87, -85, -83, -81, -80, -78, -75, -74, -72, -69, -68,
-65, -63, -61, -59, -57, -55, -52, -50, -47, -45, -42, -39, -38, -34, -32, -30,
-27, -24, -21, -19, -16, -13, -10, -7, -4, -1, };