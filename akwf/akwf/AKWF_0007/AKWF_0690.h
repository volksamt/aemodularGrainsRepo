#define DATA_LENGTH 512
#define DATA AKWF_0690

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 17, 25, 29, 34, 38, 42, 44, 47, 50,
53, 54, 57, 58, 61, 62, 63, 65, 66, 68, 69, 69, 71, 72, 72, 72, 74, 75, 76, 75,
76, 77, 76, 76, 77, 77, 78, 78, 78, 78, 79, 78, 79, 79, 78, 78, 78, 78, 78, 78,
77, 78, 78, 77, 77, 76, 75, 76, 75, 75, 74, 73, 74, 73, 72, 72, 72, 71, 70, 70,
70, 69, 69, 68, 68, 67, 67, 65, 65, 64, 63, 63, 63, 62, 61, 61, 60, 59, 59, 58,
58, 57, 56, 56, 55, 55, 54, 55, 53, 53, 54, 53, 53, 54, 55, 54, 55, 55, 55, 57,
56, 58, 58, 59, 60, 60, 61, 62, 63, 63, 64, 64, 66, 67, 66, 68, 68, 69, 70, 71,
72, 73, 74, 76, 77, 80, 81, 82, 84, 85, 87, 88, 90, 91, 93, 94, 95, 98, 99, 100,
103, 103, 105, 105, 107, 108, 109, 110, 111, 112, 112, 114, 114, 115, 115, 117,
117, 117, 117, 118, 118, 119, 118, 119, 119, 119, 119, 119, 119, 118, 119, 119,
119, 118, 117, 117, 117, 117, 115, 116, 116, 115, 115, 113, 113, 112, 112, 112,
110, 109, 109, 109, 107, 107, 106, 105, 103, 102, 101, 99, 98, 96, 95, 92, 91,
89, 88, 86, 83, 82, 79, 78, 75, 72, 71, 68, 66, 63, 60, 57, 54, 49, 40, 33, 29,
26, 23, 19, 16, 12, 8, 4, 0, -4, -7, -11, -15, -17, -21, -24, -27, -30, -32,
-35, -37, -40, -41, -44, -46, -47, -51, -51, -54, -55, -57, -58, -59, -60, -62,
-62, -64, -66, -67, -68, -68, -69, -70, -70, -72, -72, -73, -73, -73, -75, -75,
-76, -76, -77, -77, -78, -78, -78, -80, -79, -80, -79, -80, -80, -80, -80, -79,
-80, -81, -81, -80, -80, -80, -80, -79, -80, -79, -79, -79, -79, -78, -77, -78,
-78, -77, -77, -77, -76, -76, -75, -75, -74, -74, -74, -73, -73, -72, -72, -71,
-70, -70, -70, -69, -68, -68, -67, -67, -67, -66, -66, -64, -64, -63, -63, -63,
-62, -60, -60, -60, -58, -59, -57, -57, -57, -57, -57, -56, -55, -55, -56, -56,
-55, -55, -56, -55, -56, -56, -57, -57, -58, -58, -59, -60, -60, -61, -61, -62,
-62, -63, -64, -64, -65, -65, -66, -67, -68, -69, -69, -70, -71, -71, -72, -74,
-75, -76, -78, -80, -81, -81, -83, -85, -87, -87, -88, -90, -92, -93, -95, -97,
-98, -99, -100, -101, -102, -103, -105, -106, -107, -108, -109, -110, -111,
-111, -112, -113, -113, -114, -114, -114, -115, -115, -116, -117, -117, -116,
-117, -117, -117, -117, -118, -118, -118, -118, -117, -117, -117, -116, -116,
-116, -116, -115, -114, -114, -115, -114, -113, -113, -113, -112, -111, -110,
-110, -109, -107, -107, -107, -107, -106, -104, -102, -102, -101, -100, -99,
-97, -96, -94, -92, -90, -89, -87, -85, -84, -82, -80, -77, -76, -73, -71, -68,
-66, -65, -62, -59, -57, -53, -49, -41, -34, -28, -26, -23, -19, -15, -13, -9,
-5, -2, };