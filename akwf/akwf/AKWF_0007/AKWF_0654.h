#define DATA_LENGTH 512
#define DATA AKWF_0654

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 9, 14, 22, 26, 33, 37, 43, 48, 53,
56, 61, 65, 69, 72, 74, 77, 79, 82, 83, 84, 84, 85, 85, 85, 84, 85, 84, 84, 84,
84, 84, 82, 81, 81, 79, 79, 78, 75, 75, 73, 71, 70, 68, 66, 64, 62, 60, 57, 55,
53, 50, 48, 46, 43, 41, 38, 36, 33, 31, 29, 26, 23, 21, 19, 16, 15, 13, 12, 10,
8, 7, 6, 4, 4, 3, 2, 1, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0,
0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 0, -1, 0, 0, -1, -1, 1, 0,
1, -1, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 1, 1, 0, 0, -1, 0, 0, 0,
0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 1, 0, 1, -1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 2, 3, 3,
4, 5, 6, 8, 10, 11, 13, 15, 17, 20, 21, 25, 28, 30, 32, 36, 39, 43, 45, 49, 52,
57, 59, 63, 67, 71, 73, 77, 81, 84, 87, 90, 93, 97, 99, 101, 104, 106, 108, 110,
112, 113, 115, 117, 117, 118, 119, 118, 118, 119, 119, 118, 118, 118, 117, 115,
115, 113, 112, 110, 108, 105, 102, 99, 97, 92, 89, 85, 80, 76, 71, 66, 61, 56,
50, 44, 38, 33, 27, 20, 14, 8, 1, -5, -10, -17, -22, -28, -33, -39, -43, -48,
-53, -57, -62, -66, -69, -72, -76, -78, -80, -81, -83, -84, -85, -84, -85, -84,
-85, -84, -85, -84, -84, -83, -83, -82, -81, -80, -79, -78, -77, -75, -75, -73,
-72, -70, -68, -66, -64, -62, -59, -58, -56, -53, -51, -48, -46, -42, -40, -38,
-35, -33, -31, -29, -26, -24, -22, -19, -17, -15, -14, -11, -10, -8, -7, -5, -4,
-4, -2, -1, -2, 0, 0, -1, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, -1,
0, -1, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0,
-1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0,
0, 0, 0, -1, 0, 0, -1, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, -2, -2,
-3, -3, -5, -6, -6, -8, -9, -12, -13, -15, -18, -20, -23, -26, -28, -30, -33,
-37, -39, -43, -47, -50, -52, -56, -60, -63, -68, -71, -74, -77, -80, -84, -86,
-91, -93, -96, -100, -101, -105, -106, -108, -111, -113, -114, -116, -117, -117,
-119, -119, -119, -120, -120, -120, -119, -118, -117, -117, -115, -114, -114,
-111, -110, -107, -104, -101, -99, -96, -92, -88, -84, -80, -75, -70, -65, -60,
-55, -49, -43, -38, -32, -25, -20, -13, -7, -1, };