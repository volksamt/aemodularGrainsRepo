#define DATA_LENGTH 512
#define DATA AKWF_0666

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 11, 14, 20, 23, 27, 30, 35, 38,
42, 45, 48, 52, 55, 58, 61, 62, 66, 67, 70, 72, 74, 76, 78, 79, 81, 82, 83, 84,
84, 84, 85, 85, 85, 84, 84, 82, 81, 79, 77, 77, 74, 72, 70, 68, 66, 63, 61, 59,
56, 53, 50, 47, 44, 41, 38, 36, 32, 30, 27, 24, 20, 17, 15, 11, 9, 6, 2, 0, -3,
-7, -9, -12, -14, -17, -19, -22, -25, -27, -29, -32, -33, -36, -38, -39, -41,
-44, -45, -46, -47, -48, -50, -51, -52, -54, -54, -54, -55, -55, -55, -55, -55,
-55, -55, -55, -54, -55, -53, -53, -52, -51, -52, -51, -49, -50, -49, -48, -47,
-46, -46, -44, -44, -43, -42, -41, -41, -39, -38, -37, -35, -34, -34, -32, -31,
-31, -29, -29, -27, -26, -25, -23, -22, -22, -20, -19, -19, -17, -15, -15, -14,
-12, -12, -10, -9, -8, -6, -5, -4, -3, -2, -1, 1, 2, 3, 4, 5, 7, 8, 8, 10, 11,
11, 13, 14, 14, 16, 17, 18, 18, 19, 20, 22, 22, 24, 24, 25, 25, 26, 27, 27, 28,
29, 29, 31, 32, 32, 33, 33, 34, 34, 34, 35, 36, 37, 36, 38, 38, 38, 38, 38, 39,
39, 39, 39, 40, 40, 40, 41, 40, 40, 40, 40, 40, 40, 40, 40, 40, 41, 40, 40, 42,
41, 41, 41, 41, 41, 41, 41, 42, 41, 42, 42, 42, 43, 43, 42, 43, 43, 42, 43, 44,
43, 44, 44, 44, 44, 45, 44, 45, 45, 46, 46, 46, 46, 46, 47, 46, 47, 47, 48, 47,
47, 48, 49, 48, 49, 49, 48, 50, 49, 50, 49, 49, 50, 50, 50, 50, 50, 50, 51, 51,
51, 51, 52, 51, 51, 52, 53, 53, 52, 53, 53, 53, 54, 54, 53, 53, 54, 54, 54, 54,
54, 54, 55, 54, 55, 56, 54, 55, 55, 55, 55, 55, 55, 55, 56, 56, 55, 56, 56, 55,
56, 55, 56, 56, 56, 56, 57, 55, 56, 57, 55, 55, 55, 54, 53, 52, 51, 49, 49, 47,
45, 44, 41, 41, 38, 37, 35, 33, 31, 30, 28, 25, 23, 21, 18, 18, 14, 13, 11, 10,
6, 5, 2, 0, -2, -4, -5, -8, -10, -12, -13, -15, -17, -19, -20, -22, -24, -25,
-27, -28, -29, -31, -31, -32, -33, -35, -35, -37, -37, -37, -38, -38, -40, -39,
-39, -40, -40, -40, -41, -40, -41, -43, -42, -43, -44, -46, -47, -49, -50, -50,
-51, -53, -55, -57, -58, -60, -61, -62, -65, -66, -68, -69, -71, -73, -73, -75,
-77, -79, -82, -83, -84, -86, -88, -90, -90, -92, -95, -95, -97, -99, -101,
-101, -104, -104, -105, -106, -108, -109, -110, -111, -112, -113, -113, -115,
-115, -116, -117, -117, -118, -119, -119, -118, -120, -119, -119, -119, -119,
-117, -116, -115, -113, -110, -108, -105, -102, -99, -96, -92, -89, -86, -82,
-78, -75, -71, -67, -62, -58, -54, -50, -45, -41, -37, -32, -28, -23, -19, -14,
-10, -5, -1, };