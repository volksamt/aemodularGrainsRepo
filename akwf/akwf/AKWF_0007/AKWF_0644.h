#define DATA_LENGTH 512
#define DATA AKWF_0644

const PROGMEM int8_t DATA[DATA_LENGTH] = {21, 32, 36, 41, 44, 47, 49, 53, 55,
57, 59, 61, 61, 64, 65, 68, 69, 70, 72, 72, 73, 75, 76, 78, 78, 80, 81, 82, 83,
84, 86, 86, 87, 88, 89, 89, 90, 91, 91, 93, 93, 94, 95, 96, 96, 97, 98, 98, 99,
100, 100, 101, 102, 101, 102, 103, 104, 103, 105, 105, 106, 106, 106, 106, 107,
108, 108, 108, 108, 110, 109, 109, 111, 111, 111, 112, 112, 111, 113, 113, 113,
114, 114, 115, 114, 114, 115, 115, 116, 115, 116, 117, 116, 117, 117, 117, 117,
118, 117, 117, 117, 118, 117, 119, 118, 119, 118, 119, 118, 118, 119, 120, 118,
119, 119, 118, 119, 119, 120, 119, 121, 99, 88, 84, 78, 76, 72, 71, 67, 65, 62,
61, 58, 57, 54, 54, 52, 51, 50, 48, 47, 45, 43, 42, 42, 41, 39, 38, 37, 36, 35,
34, 34, 33, 32, 31, 30, 28, 28, 27, 27, 26, 25, 24, 24, 23, 23, 21, 21, 20, 20,
19, 19, 19, 18, 18, 16, 17, 16, 15, 14, 14, 13, 13, 13, 11, 12, 11, 11, 10, 10,
10, 9, 8, 8, 8, 7, 7, 7, 6, 6, 6, 6, 6, 4, 5, 5, 5, 4, 4, 3, 4, 3, 2, 2, 3, 2,
2, 2, 2, 1, 2, 2, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0, -1, 0, 0, 1, 0, 1, -1, 0,
0, 0, 0, 0, -1, 0, 0, 1, -1, 1, 0, 1, -1, -24, -32, -36, -41, -44, -47, -50,
-53, -55, -57, -59, -61, -63, -65, -65, -67, -69, -70, -72, -73, -74, -75, -76,
-78, -78, -81, -80, -82, -83, -84, -86, -86, -87, -88, -88, -88, -90, -91, -92,
-93, -94, -94, -95, -95, -96, -96, -97, -98, -99, -99, -100, -100, -101, -101,
-101, -103, -104, -104, -105, -105, -106, -105, -107, -106, -107, -108, -107,
-109, -109, -109, -109, -110, -111, -111, -111, -111, -112, -112, -112, -113,
-113, -114, -113, -114, -114, -115, -114, -115, -115, -115, -116, -116, -116,
-116, -116, -116, -117, -118, -116, -117, -117, -118, -117, -117, -118, -119,
-118, -119, -119, -119, -118, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -97, -87, -83, -78, -76, -72, -70, -66, -65, -62, -60, -59, -56,
-55, -54, -52, -50, -49, -48, -47, -45, -43, -43, -41, -41, -39, -38, -37, -36,
-35, -33, -33, -33, -32, -31, -30, -29, -28, -28, -27, -26, -26, -24, -24, -24,
-22, -22, -20, -20, -20, -20, -18, -19, -17, -17, -16, -16, -16, -16, -14, -14,
-13, -13, -12, -12, -11, -11, -11, -10, -10, -9, -9, -8, -8, -7, -8, -7, -8, -7,
-6, -6, -6, -5, -5, -5, -4, -5, -4, -4, -3, -3, -4, -3, -3, -3, -3, -2, -2, -2,
-1, -1, -2, -1, -2, -1, -1, 0, -1, 0, -1, -1, 0, 0, 0, -1, 0, 1, 0, 0, 0, 1, 1,
0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 1, 0, 0, };