#define DATA_LENGTH 512
#define DATA AKWF_0669

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 7, 9, 11, 13, 15, 16, 18, 19,
21, 23, 24, 25, 27, 29, 30, 30, 32, 33, 34, 36, 37, 38, 39, 41, 42, 42, 43, 45,
46, 46, 47, 49, 50, 50, 52, 52, 53, 54, 55, 56, 57, 57, 58, 59, 59, 60, 61, 62,
62, 63, 64, 65, 66, 66, 67, 67, 68, 69, 69, 70, 71, 71, 72, 71, 72, 73, 74, 74,
75, 75, 76, 76, 77, 77, 77, 78, 78, 78, 79, 80, 80, 80, 81, 80, 81, 81, 81, 82,
83, 82, 83, 83, 83, 84, 83, 83, 84, 84, 85, 85, 85, 85, 85, 85, 86, 85, 86, 85,
87, 86, 85, 86, 85, 86, 86, 86, 87, 82, 72, 69, 64, 61, 57, 54, 51, 48, 46, 44,
41, 40, 38, 35, 32, 31, 29, 27, 26, 23, 22, 20, 19, 16, 15, 13, 12, 11, 10, 9,
7, 6, 5, 4, 2, 1, 0, -2, -2, -3, -4, -5, -7, -7, -7, -8, -9, -10, -10, -11, -12,
-12, -14, -14, -14, -15, -15, -16, -16, -16, -17, -17, -17, -18, -18, -18, -19,
-18, -19, -19, -19, -18, -9, -3, 1, 4, 8, 11, 14, 17, 19, 22, 24, 26, 29, 31,
32, 34, 36, 38, 40, 42, 44, 45, 47, 48, 50, 51, 53, 54, 56, 57, 59, 60, 61, 62,
63, 65, 65, 67, 67, 68, 69, 69, 71, 73, 72, 74, 74, 75, 76, 77, 76, 78, 79, 80,
79, 80, 81, 81, 81, 82, 82, 83, 83, 84, 83, 84, 84, 84, 84, 84, 85, 83, 86, 73,
55, 49, 40, 33, 26, 21, 15, 11, 6, 2, -1, -5, -8, -9, -12, -14, -15, -18, -17,
-19, -18, -27, -44, -53, -62, -69, -75, -80, -85, -90, -94, -98, -101, -105,
-108, -109, -112, -113, -116, -117, -118, -118, -120, -115, -102, -95, -88, -83,
-78, -74, -70, -66, -62, -59, -55, -52, -50, -46, -44, -42, -38, -37, -35, -32,
-31, -30, -27, -26, -25, -23, -22, -21, -21, -19, -19, -18, -18, -15, -17, -15,
-15, -14, -16, -28, -36, -42, -47, -52, -58, -63, -67, -71, -73, -74, -77, -79,
-80, -82, -82, -83, -85, -85, -87, -88, -89, -93, -97, -98, -101, -103, -106,
-108, -109, -110, -112, -112, -114, -114, -116, -116, -116, -116, -110, -106,
-103, -100, -98, -95, -93, -91, -89, -87, -85, -84, -82, -79, -78, -78, -75,
-74, -73, -72, -70, -69, -67, -67, -65, -63, -63, -61, -60, -59, -57, -57, -55,
-55, -54, -53, -52, -51, -50, -49, -49, -47, -46, -46, -45, -44, -43, -42, -41,
-40, -41, -39, -39, -37, -36, -36, -35, -34, -34, -33, -33, -32, -31, -30, -30,
-29, -28, -27, -28, -27, -26, -26, -26, -25, -25, -24, -23, -23, -22, -23, -22,
-21, -21, -20, -20, -20, -19, -19, -18, -18, -18, -18, -18, -17, -17, -16, -16,
-17, -16, -15, -15, -15, -15, -15, -14, -14, -15, -14, -14, -14, -14, -13, -13,
-13, -12, -13, -14, -13, -13, -13, -13, -9, -3, 0, };