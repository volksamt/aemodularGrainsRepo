#define DATA_LENGTH 512
#define DATA AKWF_0613

const PROGMEM int8_t DATA[DATA_LENGTH] = {49, 75, 68, 71, 69, 71, 69, 71, 69,
71, 70, 71, 70, 70, 70, 71, 70, 70, 71, 70, 71, 69, 71, 70, 70, 70, 70, 70, 70,
70, 70, 70, 70, 69, 71, 70, 70, 69, 71, 70, 70, 70, 69, 70, 70, 71, 70, 71, 70,
70, 69, 71, 69, 71, 69, 71, 69, 71, 69, 71, 70, 71, 70, 71, 70, -7, -26, -18,
-23, -19, -23, -19, -22, -19, -21, -20, -21, -20, -21, -21, -21, -20, -20, -20,
-21, -20, -21, -21, -21, -20, -21, -21, -20, -20, -21, -21, -21, -20, -21, -21,
-20, -22, -21, -21, -21, -20, -20, -21, -20, -20, -21, -21, -21, -21, -21, -20,
-22, -20, -21, -20, -21, -19, -22, -19, -23, -19, -27, -86, -90, -88, -90, -87,
-89, -88, -90, -88, -89, -88, -89, -88, -89, -89, -89, -89, -89, -88, -89, -88,
-88, -88, -89, -89, -89, -89, -88, -88, -88, -88, -89, -89, -89, -89, -89, -89,
-89, -89, -88, -88, -89, -88, -89, -89, -89, -89, -88, -89, -89, -89, -89, -88,
-89, -88, -89, -89, -88, -88, -88, -88, -88, -88, -89, -88, -89, -89, -89, -88,
-89, -88, -89, -89, -89, -89, -89, -88, -89, -88, -88, -89, -89, -89, -89, -88,
-89, -89, -89, -88, -89, -89, -89, -88, -89, -88, -89, -88, -89, -88, -90, -89,
-89, -88, -88, -89, -88, -89, -89, -90, -87, -92, -84, -98, -25, 28, 12, 22, 15,
21, 16, 19, 17, 19, 18, 20, 17, 18, 4, -7, 18, 25, 22, 24, 23, 24, 33, 34, 35,
34, 34, 34, 35, 34, 48, 52, 51, 52, 51, 52, 52, 52, 52, 52, 51, 52, 51, 51, 51,
52, 52, 51, 52, 52, 52, 51, 51, 51, 52, 52, 52, 52, 52, 51, 52, 51, 51, 52, 53,
52, 52, 51, 52, 51, 52, 52, 52, 52, 52, 51, 52, 52, 51, 52, 51, 53, 51, 54, 49,
56, 31, 1, 8, 5, 7, 5, 6, 7, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 5, 6, 6, 5, 6, 6, 6,
5, 6, 6, 7, 4, 8, 3, 9, -3, -39, -39, -38, -38, -37, -39, -38, -38, -38, -38,
-38, -38, -38, -36, -40, -33, -69, -101, -92, -97, -94, -96, -95, -96, -95, -95,
-95, -95, -95, -96, -94, -95, -96, -95, -95, -95, -96, -95, -96, -96, -96, -95,
-96, -96, -96, -95, -96, -95, -96, -96, -97, -96, -96, -96, -96, -96, -96, -96,
-96, -96, -96, -97, -97, -97, -97, -97, -97, -97, -96, -97, -96, -97, -97, -97,
-97, -97, -97, -96, -97, -97, -97, -97, -97, -97, -98, -97, -98, -97, -98, -96,
-104, -118, -116, -118, -116, -118, -118, -117, -117, -118, -117, -118, -117,
-117, -118, -118, -118, -118, -119, -118, -118, -119, -118, -118, -119, -118,
-119, -119, -120, -115, -114, -112, -114, -112, -112, -111, -112, -111, -111,
-111, -110, -111, -108, -112, -107, -113, -104, -119, -41, 19, 2, 11, 7, 1, -15,
-10, -13, -11, 9, 19, 5, -2, };