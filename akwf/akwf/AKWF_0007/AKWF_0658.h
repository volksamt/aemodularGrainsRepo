#define DATA_LENGTH 512
#define DATA AKWF_0658

const PROGMEM int8_t DATA[DATA_LENGTH] = {74, 88, 81, 87, 82, 88, 82, 87, 82,
88, 81, 89, 78, 94, 48, -10, 5, -3, 2, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0,
0, 0, -1, 0, 0, 1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0,
0, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0,
0, 0, 1, 0, -1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 1, 1, 0, 0, 0,
0, 0, 1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 1, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 0, 0, 0, 1,
1, 0, 1, 1, 1, 0, 2, 1, 1, 1, 0, 1, 1, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0,
1, 0, 0, 0, 0, -1, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1,
0, -1, 0, 0, 0, 1, -1, 0, 0, 0, 0, -1, -1, 1, 0, 1, -1, 0, 0, 0, 0, 1, 1, -1, 1,
-1, 1, 0, 1, -1, 1, -1, 1, -1, 0, 0, 1, 0, 0, 0, 0, 1, -2, 1, -1, 3, -3, 5, -6,
8, -14, 46, 127, 114, 122, 118, 119, 121, 117, 122, 116, 122, 115, 124, 113,
126, 106, -81, -88, -81, -88, -81, -89, -81, -88, -80, -89, -79, -90, -76, -96,
-38, 8, -4, 3, -1, 1, -1, 0, -1, 1, 0, 0, -1, 1, -1, 0, -1, 0, 0, 0, 0, 0, -1,
-1, -1, 0, -1, 0, 0, 0, 0, 1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1,
0, 0, 0, 1, 0, 0, -1, 0, 0, 0, -1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0,
0, 0, 0, -1, -1, -1, 0, 0, 0, 0, 0, 0, 1, 1, 1, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0,
0, 0, -1, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0,
0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, -1, 0, 0, -1, -1, 0, -1, 1, 0, 0,
0, 0, 0, -1, 0, 0, 1, 0, -1, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, -1, 0,
-1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, -1, -1, 0, 0, -1,
0, -1, 0, -1, 0, -1, 1, -1, 0, -1, 1, -1, 1, -1, 0, -1, 0, 0, 0, 1, -2, 3, -3,
5, -8, 14, -60, -128, -112, -123, -117, -120, -118, -118, -120, -117, -121,
-116, -123, -114, -128, -100, };