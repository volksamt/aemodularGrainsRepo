#define DATA_LENGTH 512
#define DATA AKWF_0683

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 5, 6, 6, 8, 8, 9, 10, 12,
13, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 22, 22, 23, 25, 25, 26, 27, 28, 29,
30, 31, 31, 32, 33, 34, 35, 36, 36, 37, 38, 40, 40, 41, 41, 43, 43, 44, 45, 46,
46, 47, 48, 48, 48, 50, 51, 51, 51, 53, 53, 55, 55, 56, 56, 57, 57, 58, 59, 60,
62, 61, 61, 63, 64, 64, 65, 66, 66, 66, 67, 68, 69, 70, 70, 71, 71, 71, 72, 74,
74, 74, 75, 76, 76, 77, 77, 78, 79, 79, 80, 81, 81, 81, 82, 83, 83, 84, 85, 85,
85, 86, 86, 88, 88, 87, 88, 89, 90, 90, 91, 91, 92, 92, 92, 93, 94, 93, 94, 95,
95, 96, 96, 97, 97, 97, 98, 99, 99, 99, 99, 100, 100, 100, 102, 102, 101, 103,
102, 103, 103, 104, 104, 104, 104, 106, 105, 106, 106, 107, 108, 107, 107, 108,
108, 108, 109, 108, 109, 109, 110, 110, 110, 111, 111, 110, 111, 111, 112, 112,
111, 112, 113, 113, 112, 114, 113, 113, 114, 115, 115, 115, 114, 114, 115, 115,
116, 115, 116, 117, 116, 116, 117, 117, 117, 116, 116, 117, 117, 117, 118, 117,
118, 117, 118, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 118, 119, 119,
120, 119, 119, 118, 119, 119, 116, 116, 114, 113, 111, 110, 109, 107, 105, 104,
102, 100, 99, 99, 96, 95, 94, 93, 91, 89, 88, 86, 85, 83, 82, 81, 79, 78, 75,
75, 73, 72, 70, 69, 68, 66, 65, 63, 62, 60, 58, 57, 56, 54, 52, 51, 50, 48, 47,
45, 44, 42, 41, 40, 39, 37, 36, 34, 33, 31, 29, 28, 27, 26, 24, 23, 21, 20, 19,
17, 15, 14, 13, 10, 9, 8, 7, 5, 4, 3, 2, 0, -2, -2, -5, -6, -7, -9, -10, -11,
-12, -14, -15, -17, -18, -20, -20, -22, -24, -26, -27, -28, -30, -31, -33, -34,
-35, -37, -38, -39, -40, -42, -43, -45, -46, -47, -49, -51, -51, -53, -54, -56,
-57, -58, -61, -61, -63, -64, -65, -67, -68, -69, -71, -72, -74, -75, -75, -77,
-79, -80, -81, -83, -83, -85, -87, -88, -89, -90, -92, -93, -95, -96, -97, -98,
-99, -101, -102, -104, -105, -107, -107, -108, -110, -111, -112, -114, -115,
-116, -118, -119, -118, -116, -116, -114, -113, -112, -110, -109, -108, -107,
-105, -104, -103, -101, -101, -99, -99, -97, -95, -94, -93, -92, -91, -90, -89,
-88, -86, -85, -84, -82, -81, -81, -80, -78, -77, -76, -74, -73, -72, -70, -70,
-68, -68, -66, -65, -63, -63, -62, -61, -59, -58, -56, -55, -55, -54, -52, -51,
-50, -49, -48, -47, -45, -45, -44, -43, -41, -41, -39, -38, -37, -36, -34, -34,
-32, -31, -30, -29, -28, -27, -27, -25, -23, -23, -22, -21, -20, -19, -18, -17,
-16, -15, -13, -13, -12, -10, -10, -9, -8, -7, -5, -5, -3, -3, -1, -1, -1, };