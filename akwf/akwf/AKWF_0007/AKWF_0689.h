#define DATA_LENGTH 512
#define DATA AKWF_0689

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 6, 9, 13, 15, 18, 20, 24, 25,
27, 31, 32, 35, 38, 39, 42, 44, 47, 47, 50, 51, 52, 54, 55, 57, 57, 58, 59, 59,
59, 59, 59, 59, 58, 59, 58, 58, 58, 57, 56, 54, 54, 53, 52, 51, 50, 49, 47, 45,
44, 43, 41, 40, 39, 38, 36, 34, 33, 31, 30, 29, 29, 26, 26, 25, 23, 24, 22, 22,
22, 20, 21, 20, 21, 20, 20, 21, 21, 21, 22, 23, 23, 24, 25, 26, 26, 27, 27, 30,
29, 30, 31, 32, 32, 33, 34, 35, 35, 35, 35, 36, 35, 36, 35, 36, 36, 35, 35, 34,
35, 33, 33, 32, 32, 30, 30, 29, 29, 28, 27, 26, 25, 24, 24, 23, 22, 21, 19, 19,
18, 18, 17, 16, 16, 15, 14, 13, 12, 12, 11, 11, 11, 10, 11, 10, 10, 10, 10, 11,
12, 12, 12, 12, 14, 14, 15, 17, 18, 19, 20, 23, 24, 26, 28, 30, 33, 35, 36, 39,
42, 43, 46, 47, 48, 49, 48, 48, 50, 57, 73, 92, 108, 114, 112, 108, 101, 95, 94,
99, 107, 113, 117, 120, 118, 117, 115, 113, 113, 115, 115, 117, 117, 117, 116,
116, 115, 113, 112, 110, 109, 109, 108, 107, 105, 104, 103, 100, 99, 97, 96, 93,
92, 90, 89, 87, 85, 82, 80, 78, 76, 73, 71, 69, 67, 65, 63, 61, 59, 57, 55, 53,
52, 50, 48, 47, 45, 44, 42, 41, 40, 39, 38, 37, 36, 36, 35, 35, 35, 33, 32, 33,
32, 31, 32, 31, 30, 30, 30, 29, 29, 28, 27, 27, 26, 25, 25, 23, 22, 20, 21, 19,
18, 16, 14, 13, 12, 10, 8, 7, 5, 4, -1, 3, -32, -65, -69, -74, -65, -59, -48,
-42, -34, -32, -28, -27, -28, -28, -30, -33, -36, -39, -43, -48, -52, -57, -61,
-65, -69, -72, -76, -79, -81, -82, -83, -84, -84, -84, -82, -80, -78, -76, -75,
-73, -72, -72, -71, -72, -72, -72, -72, -73, -74, -74, -76, -78, -78, -77, -77,
-84, -97, -104, -100, -93, -95, -103, -105, -106, -104, -103, -103, -103, -104,
-101, -99, -97, -94, -91, -89, -86, -81, -77, -72, -67, -63, -58, -52, -47, -41,
-37, -35, -32, -22, 0, 19, 25, 21, 13, 14, 24, 34, 39, 40, 39, 40, 41, 43, 46,
47, 47, 48, 47, 46, 46, 46, 47, 46, 46, 43, 41, 40, 40, 38, 38, 35, 33, 31, 29,
29, 29, 29, 23, 15, 4, 0, 2, 9, 12, 11, 6, 0, -3, -2, 1, 3, 4, 5, 4, 3, 5, 5, 7,
9, 9, 12, 13, 12, 13, 13, 15, 16, 16, 17, 16, 16, 16, 16, 15, 14, 14, 13, 12,
11, 10, 8, 7, 5, 5, 2, 2, -1, -2, -3, -5, -6, -7, -9, -10, -12, -12, -13, -14,
-15, -16, -18, -18, -19, -20, -21, -21, -22, -23, -23, -23, -23, -22, -22, -21,
-21, -20, -19, -18, -17, -16, -14, -13, -11, -8, -6, -5, -3, 0, };