#define DATA_LENGTH 512
#define DATA AKWF_0629

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 5, 7, 10, 13, 15, 17, 20, 22, 25,
28, 30, 32, 36, 38, 40, 43, 45, 47, 51, 52, 55, 58, 60, 63, 66, 68, 70, 73, 76,
77, 81, 83, 86, 89, 91, 93, 96, 98, 102, 103, 107, 109, 111, 114, 116, 120, 119,
118, 119, 117, 117, 117, 117, 116, 116, 115, 115, 114, 114, 114, 112, 112, 112,
111, 112, 112, 111, 110, 109, 110, 108, 108, 109, 108, 107, 107, 106, 107, 106,
105, 105, 105, 104, 104, 104, 103, 103, 101, 102, 101, 101, 101, 101, 100, 100,
100, 98, 98, 98, 97, 97, 97, 96, 94, 92, 90, 89, 87, 85, 82, 82, 81, 77, 75, 75,
73, 71, 69, 67, 67, 65, 63, 61, 59, 58, 56, 54, 53, 51, 49, 47, 45, 44, 42, 40,
39, 37, 36, 33, 31, 31, 29, 27, 25, 23, 22, 20, 18, 17, 15, 13, 12, 10, 8, 7, 4,
3, 1, 0, -1, 0, 1, 0, -1, 0, 0, 0, 0, 1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 1, -1, 1, -1, 0, -1, 0, 0, 0, 0, -1, 0, 0, -1, -1, 0, 0, -1, 0, 0, 0, 0,
1, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 1,
0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, -1, -2, -4, -6, -7, -9, -11, -14, -15,
-16, -19, -21, -23, -25, -26, -28, -30, -32, -33, -36, -38, -39, -42, -44, -46,
-47, -49, -52, -53, -54, -57, -59, -61, -62, -65, -67, -68, -71, -72, -75, -76,
-78, -80, -82, -83, -85, -88, -90, -91, -93, -94, -97, -98, -101, -103, -105,
-106, -108, -111, -112, -114, -117, -119, -119, -118, -118, -117, -117, -116,
-116, -115, -115, -114, -114, -114, -113, -113, -113, -112, -111, -111, -110,
-110, -110, -109, -108, -108, -108, -107, -106, -105, -105, -106, -105, -104,
-103, -103, -102, -102, -101, -101, -100, -100, -100, -99, -99, -99, -98, -98,
-96, -96, -96, -93, -91, -89, -86, -85, -83, -81, -79, -76, -74, -73, -72, -70,
-68, -65, -63, -61, -59, -57, -55, -53, -52, -49, -47, -45, -44, -42, -39, -38,
-35, -33, -31, -30, -27, -26, -24, -22, -21, -18, -16, -14, -12, -10, -8, -6,
-3, -3, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0,
0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 1, 0, 0, 1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0,
0, -1, 0, 0, 0, 0, };