#define DATA_LENGTH 512
#define DATA AKWF_0673

const PROGMEM int8_t DATA[DATA_LENGTH] = {23, 38, 45, 53, 57, 65, 67, 72, 75,
80, 82, 86, 88, 91, 93, 96, 97, 99, 101, 103, 103, 106, 107, 108, 109, 111, 112,
113, 113, 114, 115, 116, 116, 116, 117, 117, 118, 119, 118, 118, 120, 119, 119,
119, 119, 119, 119, 119, 119, 118, 118, 118, 117, 117, 117, 116, 116, 115, 115,
114, 114, 114, 112, 113, 112, 111, 110, 109, 109, 108, 107, 106, 106, 104, 104,
103, 102, 102, 101, 99, 99, 98, 96, 96, 95, 93, 93, 91, 91, 89, 88, 87, 86, 85,
84, 83, 82, 80, 79, 78, 76, 76, 74, 74, 71, 70, 70, 68, 67, 66, 65, 64, 62, 61,
60, 58, 56, 57, 55, 52, 52, 51, 49, 48, 47, 46, 44, 43, 41, 40, 40, 37, 37, 35,
33, 32, 31, 29, 28, 27, 26, 24, 23, 22, 20, 19, 18, 16, 16, 13, 12, 11, 10, 8,
7, 6, 5, 3, 2, 1, -1, -3, -3, -5, -5, -8, -9, -10, -11, -12, -14, -15, -16, -18,
-18, -20, -21, -22, -24, -25, -26, -27, -29, -29, -30, -32, -33, -35, -35, -36,
-38, -39, -40, -41, -42, -43, -45, -46, -47, -48, -50, -50, -51, -53, -53, -54,
-56, -57, -57, -58, -60, -61, -62, -62, -63, -64, -66, -66, -68, -68, -70, -71,
-71, -72, -73, -74, -75, -76, -76, -77, -78, -79, -80, -81, -82, -83, -84, -84,
-85, -86, -86, -87, -88, -90, -90, -91, -91, -92, -93, -93, -93, -95, -95, -95,
-96, -97, -98, -98, -99, -99, -100, -101, -101, -102, -102, -103, -104, -104,
-105, -105, -106, -106, -107, -107, -108, -108, -108, -109, -110, -110, -110,
-110, -111, -111, -112, -112, -112, -112, -113, -113, -114, -114, -114, -114,
-115, -114, -116, -116, -116, -117, -117, -116, -116, -117, -118, -118, -118,
-117, -118, -118, -119, -118, -118, -118, -119, -119, -119, -119, -119, -119,
-119, -120, -118, -120, -119, -120, -119, -119, -120, -118, -119, -119, -119,
-118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -117, -117, -117,
-117, -117, -117, -117, -117, -115, -115, -115, -116, -115, -115, -115, -113,
-113, -114, -113, -112, -113, -111, -111, -111, -112, -111, -110, -110, -109,
-109, -108, -109, -108, -107, -106, -106, -106, -106, -105, -104, -104, -104,
-103, -103, -102, -102, -101, -100, -99, -100, -99, -98, -98, -97, -97, -96,
-95, -94, -94, -94, -92, -92, -91, -91, -91, -89, -89, -88, -88, -87, -87, -86,
-84, -85, -83, -84, -83, -82, -81, -80, -79, -78, -78, -77, -75, -75, -75, -74,
-73, -72, -72, -71, -69, -69, -69, -68, -67, -66, -65, -64, -63, -62, -62, -60,
-60, -59, -59, -58, -56, -56, -55, -53, -53, -53, -51, -51, -50, -49, -48, -46,
-47, -46, -44, -43, -42, -41, -41, -40, -39, -37, -37, -36, -35, -34, -33, -32,
-31, -31, -30, -28, -28, -27, -26, -25, -24, -23, -22, -20, -20, -19, -17, -17,
-16, -15, -14, -13, -12, -11, -10, -9, -8, -7, -5, -5, -4, -4, -2, -2, 1, };