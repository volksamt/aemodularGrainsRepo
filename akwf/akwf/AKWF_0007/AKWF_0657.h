#define DATA_LENGTH 512
#define DATA AKWF_0657

const PROGMEM int8_t DATA[DATA_LENGTH] = {74, 89, 81, 88, 83, 86, 83, 87, 83,
85, 83, 85, 83, 86, 84, 84, 84, 85, 84, 84, 85, 84, 85, 84, 85, 83, 86, 83, 87,
82, 86, 81, 87, 82, 89, 74, -2, 1, 0, -1, 0, 0, 2, -1, 1, -1, 1, -1, 1, -1, 1,
-1, 0, 0, 0, -1, 1, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 1, 0, 1, 0, 0, 0,
1, 0, 0, 0, 1, 0, 0, -1, 1, 0, 1, 1, 0, 1, -1, 0, 1, 1, 0, 0, 0, 1, 1, 1, 1, 1,
0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 1, 0,
-1, 0, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, -1, -1, 1, 0, 0, 0,
1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, -1, 1, 0, 0, -1, 0, 0, 0, -1, 0, -1, 1, -1,
0, 0, 1, -1, 0, -1, 0, 1, -1, 1, -2, 5, -12, 86, 127, 112, 123, 116, 121, 117,
120, 118, 120, 118, 119, 119, 119, 119, 118, 119, 118, 119, 119, 118, 120, 118,
120, 118, 120, 117, 121, 116, 123, 116, 122, 115, 123, 113, 126, 106, -81, -88,
-81, -88, -81, -88, -81, -88, -82, -88, -82, -87, -82, -87, -82, -87, -83, -86,
-84, -85, -84, -85, -85, -83, -86, -83, -86, -83, -86, -82, -87, -81, -88, -80,
-91, -67, 5, -2, 1, 0, 0, 1, -1, 0, -1, 0, -1, 1, -1, 0, 0, 0, -1, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 1, 0, -1, 1, 0, 0,
0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, -1, 0, -1, -1, 1, -1, 0,
0, 0, 0, 0, 0, 1, 0, -1, 0, 0, -1, -1, -1, 0, -1, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0,
0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 1, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0,
-1, 1, 0, 1, -1, 0, 0, 0, -1, 0, 0, 0, 1, -1, 0, -1, 0, -1, 0, -2, 1, -1, 1, -2,
1, -1, 1, 0, 1, -1, 1, 0, 0, 1, -3, 7, -99, -128, -114, -123, -116, -121, -117,
-122, -117, -119, -119, -120, -118, -120, -119, -119, -118, -119, -119, -119,
-118, -119, -119, -119, -118, -119, -118, -120, -118, -121, -116, -122, -115,
-123, -114, -126, -101, };