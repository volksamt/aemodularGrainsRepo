#define DATA_LENGTH 512
#define DATA AKWF_0639

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 9, 17, 24, 30, 34, 39, 42, 44, 45,
46, 45, 44, 43, 40, 37, 34, 32, 28, 26, 22, 19, 16, 12, 9, 7, 4, 3, 1, -1, -2,
-3, -3, -4, -4, -4, -4, -4, -3, -2, -1, -1, 1, 2, 2, 4, 5, 6, 6, 7, 8, 8, 10,
10, 10, 10, 10, 11, 12, 11, 11, 11, 12, 11, 10, 12, 11, 11, 10, 11, 10, 9, 9,
10, 10, 10, 10, 9, 9, 9, 9, 9, 9, 10, 9, 9, 10, 10, 10, 11, 10, 10, 10, 9, 11,
11, 10, 10, 10, 10, 10, 10, 10, 10, 10, 10, 11, 11, 10, 11, 10, 11, 10, 11, 10,
11, 11, 11, 11, 10, 10, 9, 10, 10, 11, 11, 10, 11, 9, 11, 10, 10, 10, 10, 9, 10,
10, 10, 10, 10, 10, 10, 9, 10, 9, 9, 8, 9, 10, 8, 9, 9, 9, 9, 9, 9, 9, 8, 9, 8,
8, 9, 8, 8, 8, 8, 8, 7, 7, 7, 7, 8, 7, 7, 7, 7, 7, 7, 7, 6, 7, 5, 7, 6, 6, 6, 6,
5, 5, 5, 5, 5, 5, 5, 5, 5, 4, 5, 4, 5, 4, 4, 4, 5, 4, 3, 4, 3, 4, 3, 3, 2, 3, 3,
2, 2, 3, 2, 2, 2, 2, 2, 1, 2, 5, 8, 12, 19, 26, 35, 44, 54, 65, 75, 84, 94, 101,
109, 112, 117, 118, 119, 118, 115, 110, 104, 97, 87, 79, 68, 59, 48, 37, 27, 17,
8, -1, -9, -17, -25, -30, -34, -38, -42, -44, -45, -45, -45, -44, -42, -40, -38,
-34, -32, -29, -25, -21, -18, -16, -13, -10, -7, -4, -3, 0, 0, 2, 3, 3, 3, 4, 4,
4, 3, 3, 2, 1, 1, -1, -1, -3, -4, -5, -5, -6, -7, -8, -9, -9, -10, -10, -10,
-12, -11, -11, -11, -12, -11, -12, -11, -12, -11, -11, -11, -11, -10, -10, -10,
-9, -10, -9, -9, -10, -9, -10, -10, -10, -9, -9, -9, -10, -9, -9, -10, -9, -10,
-10, -10, -10, -10, -11, -10, -11, -10, -11, -11, -11, -11, -11, -11, -11, -10,
-10, -10, -11, -11, -10, -10, -11, -11, -10, -11, -11, -10, -10, -11, -10, -10,
-11, -10, -10, -11, -10, -10, -11, -10, -10, -10, -9, -9, -10, -10, -10, -10,
-10, -9, -10, -9, -9, -9, -9, -9, -9, -8, -9, -9, -10, -9, -10, -8, -9, -8, -8,
-8, -8, -8, -8, -8, -8, -8, -8, -7, -7, -7, -8, -8, -8, -7, -8, -7, -6, -7, -7,
-7, -6, -6, -6, -7, -7, -6, -6, -6, -6, -6, -6, -5, -5, -5, -6, -5, -4, -5, -5,
-4, -5, -4, -4, -3, -5, -4, -4, -3, -3, -3, -3, -4, -2, -2, -2, -3, -2, -3, -3,
-2, -2, -2, -2, -1, -2, -3, -4, -7, -12, -19, -27, -36, -45, -56, -66, -76, -85,
-94, -102, -109, -114, -117, -119, -118, -117, -114, -109, -102, -96, -87, -78,
-68, -58, -48, -37, -26, -16, -6, };