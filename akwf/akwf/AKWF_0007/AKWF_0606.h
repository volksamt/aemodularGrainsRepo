#define DATA_LENGTH 512
#define DATA AKWF_0606

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 9, 12, 14, 18, 21, 22, 24,
27, 30, 32, 34, 36, 39, 41, 43, 44, 47, 48, 50, 52, 54, 57, 58, 60, 61, 64, 66,
66, 68, 69, 72, 73, 75, 76, 78, 78, 80, 81, 82, 84, 86, 86, 88, 89, 90, 91, 92,
93, 94, 96, 96, 98, 98, 99, 100, 101, 102, 103, 104, 104, 106, 106, 107, 107,
108, 110, 109, 110, 111, 111, 112, 113, 113, 112, 114, 114, 114, 115, 116, 115,
116, 116, 117, 117, 117, 117, 117, 117, 117, 118, 117, 117, 117, 119, 116, 119,
100, 79, 68, 57, 49, 39, 32, 24, 19, 12, 6, 0, -5, -11, -15, -19, -25, -29, -34,
-37, -42, -45, -49, -52, -56, -60, -63, -66, -69, -71, -75, -77, -79, -82, -84,
-86, -89, -91, -93, -95, -96, -97, -100, -101, -102, -104, -105, -106, -106,
-107, -109, -108, -110, -110, -111, -111, -112, -111, -113, -102, -77, -65, -54,
-45, -36, -28, -22, -15, -8, -2, 4, 9, 14, 20, 25, 30, 33, 37, 41, 46, 50, 54,
57, 61, 64, 68, 71, 73, 77, 79, 81, 85, 87, 89, 91, 94, 95, 98, 99, 101, 103,
105, 106, 107, 109, 110, 111, 112, 113, 113, 114, 115, 116, 116, 117, 117, 118,
117, 119, 104, 87, 79, 70, 63, 57, 51, 45, 39, 35, 30, 25, 22, 17, 13, 9, 5, 2,
-2, -6, -8, -12, -16, -18, -22, -24, -27, -30, -33, -36, -38, -41, -43, -46,
-48, -51, -52, -55, -56, -59, -62, -63, -65, -67, -69, -71, -72, -74, -76, -77,
-79, -81, -82, -85, -86, -87, -89, -90, -91, -92, -92, -94, -96, -97, -97, -98,
-99, -101, -101, -102, -103, -104, -104, -105, -106, -106, -108, -107, -107,
-108, -108, -109, -110, -109, -111, -111, -110, -111, -112, -111, -112, -110,
-113, -104, -81, -68, -57, -48, -40, -33, -25, -17, -12, -6, 0, 5, 10, 15, 21,
24, 28, 33, 37, 41, 45, 49, 53, 56, 59, 62, 65, 69, 72, 74, 77, 80, 82, 84, 87,
89, 91, 94, 95, 97, 99, 100, 102, 104, 105, 106, 108, 109, 110, 111, 112, 113,
114, 115, 115, 115, 116, 117, 117, 118, 117, 118, 114, 98, 87, 79, 72, 67, 61,
55, 51, 47, 42, 38, 34, 31, 27, 23, 19, 16, 13, 10, 6, 4, 0, -2, -4, -7, -11,
-12, -15, -18, -20, -22, -25, -27, -29, -31, -34, -36, -38, -40, -43, -44, -46,
-48, -50, -51, -53, -55, -58, -58, -60, -61, -63, -65, -67, -69, -70, -71, -72,
-74, -75, -77, -78, -80, -81, -82, -83, -84, -85, -86, -88, -89, -89, -91, -92,
-93, -93, -95, -96, -96, -97, -99, -99, -100, -100, -101, -102, -103, -102,
-104, -104, -106, -106, -105, -107, -107, -108, -108, -108, -109, -109, -109,
-109, -110, -110, -110, -110, -111, -111, -111, -111, -111, -112, -111, -111,
-111, -112, -106, -90, -81, -73, -67, -61, -55, -50, -46, -41, -37, -33, -29,
-25, -22, -19, -15, -12, -8, -5, -3, };