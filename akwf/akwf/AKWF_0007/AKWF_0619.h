#define DATA_LENGTH 512
#define DATA AKWF_0619

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 5, 6, 13, 10, 20, 15, 41, 104, 94,
98, 96, 97, 96, 97, 96, 96, 96, 96, 96, 95, 97, 95, 97, 94, 96, 95, 97, 95, 96,
94, 97, 94, 97, 93, 100, 83, 42, 47, 44, 45, 43, 43, 43, 42, 41, 40, 40, 39, 39,
38, 37, 37, 36, 35, 35, 34, 33, 33, 32, 31, 31, 31, 30, 30, 28, 28, 27, 26, 25,
24, 25, 25, 23, 22, 22, 21, 21, 19, 19, 18, 19, 18, 17, 16, 16, 15, 14, 13, 13,
13, 12, 11, 11, 10, 9, 9, 8, 7, 7, 6, 5, 4, 4, 4, 3, 2, 2, 1, 1, -1, 0, -2, -2,
-4, -4, -5, -4, -6, -6, -7, -7, -8, -10, -9, -10, -10, -12, -10, -14, -11, -16,
-11, -19, -9, -38, -95, -85, -90, -88, -90, -89, -90, -91, -91, -91, -92, -93,
-92, -92, -92, -92, -92, -94, -94, -95, -94, -96, -95, -96, -96, -96, -96, -97,
-96, -97, -98, -98, -99, -99, -99, -99, -99, -100, -100, -100, -100, -100, -101,
-101, -102, -103, -103, -103, -104, -103, -104, -105, -104, -105, -106, -105,
-105, -106, -106, -107, -107, -107, -107, -108, -108, -108, -109, -110, -110,
-110, -111, -111, -112, -110, -112, -112, -112, -113, -113, -113, -114, -114,
-114, -115, -114, -115, -115, -116, -115, -117, -116, -118, -116, -119, -116,
-120, -115, -124, -102, -64, -68, -62, -60, -56, -53, -50, -47, -45, -41, -38,
-34, -32, -27, -26, -21, -18, -16, -13, -9, -5, -3, 2, 2, 9, 8, 17, 10, 43, 95,
83, 89, 86, 89, 87, 89, 89, 89, 89, 89, 90, 89, 90, 89, 90, 90, 91, 90, 91, 90,
91, 91, 97, 92, 97, 91, 100, 78, 43, 50, 46, 47, 45, 45, 44, 43, 43, 43, 42, 41,
40, 39, 39, 38, 38, 37, 36, 35, 35, 34, 34, 32, 32, 31, 30, 29, 29, 29, 28, 28,
26, 26, 25, 24, 24, 23, 22, 22, 21, 21, 19, 18, 18, 18, 17, 17, 16, 15, 14, 14,
13, 13, 12, 11, 11, 10, 9, 8, 8, 7, 7, 7, 5, 4, 4, 4, 3, 2, 2, 1, 1, 0, -1, -1,
-2, -3, -3, -3, -5, -5, -5, -6, -7, -7, -8, -8, -9, -9, -11, -10, -13, -11, -15,
-11, -18, -7, -44, -91, -79, -86, -81, -84, -83, -84, -85, -85, -85, -86, -86,
-86, -87, -85, -87, -86, -87, -87, -88, -87, -89, -88, -91, -94, -94, -94, -94,
-95, -95, -95, -96, -96, -97, -97, -97, -98, -98, -97, -98, -99, -99, -99, -99,
-100, -101, -101, -100, -102, -101, -102, -102, -103, -103, -103, -104, -104,
-104, -105, -105, -105, -106, -106, -106, -107, -107, -107, -107, -108, -108,
-108, -109, -109, -109, -110, -110, -111, -111, -112, -111, -112, -112, -114,
-113, -113, -114, -114, -115, -114, -115, -115, -116, -115, -118, -116, -119,
-115, -123, -96, -64, -68, -60, -60, -54, -53, -48, -46, -42, -39, -36, -32,
-29, -26, -22, -19, -15, -12, -9, -5, -3, };