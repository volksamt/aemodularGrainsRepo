#define DATA_LENGTH 512
#define DATA AKWF_0640

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 6, 7, 9, 10, 12, 14, 15, 18,
18, 20, 22, 23, 25, 25, 28, 30, 31, 32, 34, 35, 37, 39, 40, 41, 42, 44, 46, 46,
49, 50, 52, 53, 54, 55, 57, 57, 60, 60, 62, 64, 65, 66, 67, 68, 70, 70, 72, 74,
74, 76, 77, 78, 79, 81, 81, 82, 84, 84, 86, 87, 88, 89, 89, 90, 91, 92, 93, 95,
95, 96, 96, 97, 99, 100, 100, 100, 102, 102, 104, 104, 104, 105, 106, 107, 107,
108, 108, 109, 110, 109, 111, 111, 112, 112, 113, 113, 113, 113, 114, 114, 114,
116, 115, 115, 116, 116, 116, 117, 117, 117, 118, 118, 117, 119, 119, 118, 119,
118, 118, 118, 118, 119, 120, 118, 119, 119, 120, 118, 119, 119, 119, 119, 118,
119, 118, 118, 118, 117, 117, 117, 118, 117, 118, 116, 117, 117, 117, 116, 116,
115, 114, 114, 113, 114, 113, 113, 113, 112, 111, 111, 110, 110, 109, 109, 108,
108, 107, 107, 107, 106, 104, 105, 102, 102, 102, 101, 100, 101, 99, 97, 97, 97,
96, 96, 94, 93, 93, 91, 90, 90, 89, 88, 87, 85, 85, 84, 82, 82, 80, 80, 78, 77,
77, 75, 73, 73, 71, 71, 68, 68, 67, 64, 64, 62, 61, 59, 58, 57, 55, 54, 52, 51,
49, 48, 46, 44, 43, 41, 40, 38, 36, 35, 33, 32, 30, 28, 27, 25, 23, 22, 20, 18,
17, 16, 14, 12, 11, 9, 7, 5, 3, 3, 0, -2, -3, -4, -6, -8, -9, -11, -12, -14,
-16, -18, -19, -20, -22, -24, -25, -27, -28, -29, -31, -32, -34, -36, -38, -38,
-40, -41, -43, -45, -46, -47, -49, -50, -52, -53, -54, -56, -57, -58, -59, -61,
-62, -63, -65, -67, -68, -68, -69, -70, -73, -74, -75, -75, -77, -78, -80, -81,
-81, -82, -83, -85, -85, -87, -87, -89, -89, -91, -91, -92, -93, -95, -95, -96,
-97, -98, -98, -99, -99, -101, -102, -103, -104, -104, -104, -106, -106, -107,
-107, -108, -109, -109, -109, -110, -110, -110, -111, -112, -112, -113, -112,
-113, -114, -114, -115, -114, -115, -116, -116, -116, -117, -117, -117, -117,
-118, -117, -118, -118, -118, -118, -118, -119, -119, -120, -119, -118, -120,
-119, -119, -120, -119, -118, -119, -119, -119, -119, -119, -118, -119, -118,
-118, -118, -118, -117, -117, -118, -117, -117, -117, -116, -116, -115, -115,
-115, -115, -114, -113, -113, -113, -112, -112, -112, -112, -111, -111, -110,
-109, -109, -108, -108, -107, -106, -106, -105, -104, -104, -103, -102, -102,
-101, -101, -100, -100, -98, -98, -97, -96, -95, -94, -94, -93, -91, -90, -89,
-89, -88, -87, -85, -85, -83, -82, -81, -81, -80, -79, -78, -77, -75, -74, -73,
-72, -71, -69, -68, -66, -66, -64, -62, -61, -59, -58, -56, -54, -53, -53, -50,
-49, -47, -46, -45, -43, -41, -40, -38, -36, -34, -33, -31, -30, -28, -26, -25,
-23, -22, -20, -19, -17, -15, -13, -12, -10, -8, -8, -5, -4, -2, -1, };