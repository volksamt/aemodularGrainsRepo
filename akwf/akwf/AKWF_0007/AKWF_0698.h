#define DATA_LENGTH 512
#define DATA AKWF_0698

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 95, 116, 113, 99, 86, 80, 72, 68,
63, 60, 54, 53, 48, 47, 44, 43, 41, 40, 36, 36, 33, 31, 29, 28, 25, 24, 22, 20,
18, 18, 14, 19, 30, 30, 34, 33, 34, 33, 33, 33, 33, 31, 31, 30, 29, 27, 26, 26,
24, 24, 22, 21, 20, 19, 18, 17, 17, 15, 14, 14, 12, 11, 10, 9, 9, 7, 11, 17, 18,
20, 23, 24, 25, 27, 28, 30, 30, 31, 33, 33, 35, 36, 36, 37, 37, 38, 39, 40, 41,
42, 43, 43, 44, 45, 50, 52, 54, 56, 58, 60, 61, 64, 64, 66, 68, 70, 71, 72, 74,
74, 77, 77, 79, 80, 81, 82, 83, 84, 85, 86, 87, 89, 90, 90, 92, 92, 94, 94, 96,
96, 97, 97, 97, 99, 99, 100, 102, 101, 102, 103, 104, 104, 105, 105, 106, 107,
107, 107, 108, 108, 108, 108, 110, 109, 110, 110, 110, 111, 111, 111, 111, 111,
112, 112, 113, 112, 112, 112, 112, 112, 113, 113, 114, 109, 88, 76, 66, 57, 51,
43, 38, 32, 27, 21, 18, 14, 12, 8, 6, 2, 1, -1, -2, -3, -3, -6, -26, -38, -47,
-55, -63, -69, -75, -81, -85, -90, -95, -99, -102, -105, -107, -110, -112, -114,
-116, -117, -118, -118, -120, -116, -108, -105, -101, -98, -95, -92, -90, -87,
-86, -84, -82, -80, -79, -77, -75, -72, -72, -70, -68, -67, -65, -64, -62, -62,
-59, -58, -56, -56, -54, -53, -51, -50, -49, -48, -47, -46, -45, -44, -43, -42,
-41, -39, -39, -38, -38, -35, -35, -34, -33, -32, -32, -30, -29, -28, -27, -27,
-26, -25, -25, -24, -24, -22, -22, -20, -20, -20, -18, -18, -17, -17, -16, -15,
-15, -14, -14, -14, -12, -12, -11, -11, -10, -10, -9, -9, -8, -8, -8, -6, -6,
-6, -6, -5, -5, -4, -4, -4, -3, -3, -3, -2, -2, -2, -2, -1, -1, -1, 0, -1, 0, 1,
1, 0, 1, 1, 2, 0, 1, 1, 2, 2, 2, 3, 2, 2, 2, 3, 2, 2, 2, 2, 3, -4, -9, -12, -15,
-17, -20, -22, -24, -27, -28, -30, -32, -34, -35, -37, -38, -40, -42, -43, -44,
-46, -47, -49, -50, -52, -52, -53, -55, -55, -57, -58, -60, -61, -61, -62, -64,
-65, -65, -66, -68, -69, -70, -71, -72, -73, -73, -74, -76, -76, -76, -77, -79,
-79, -80, -81, -82, -83, -83, -84, -85, -85, -86, -88, -87, -88, -89, -90, -90,
-91, -92, -92, -93, -94, -94, -94, -95, -96, -96, -97, -97, -98, -99, -99, -99,
-100, -100, -101, -102, -103, -103, -103, -103, -103, -103, -105, -105, -106,
-106, -106, -106, -107, -107, -107, -107, -107, -109, -109, -109, -108, -109,
-109, -109, -109, -110, -111, -111, -111, -110, -111, -111, -111, -112, -112,
-112, -112, -111, -112, -113, -113, -112, -113, -113, -113, -113, -112, -113,
-113, -112, -114, -111, -92, -79, -71, -63, -56, -50, -45, -39, -35, -29, -25,
-21, -17, -15, -12, -9, -7, -4, -2, -1, };