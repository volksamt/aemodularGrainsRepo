#define DATA_LENGTH 512
#define DATA AKWF_0687

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 16, 27, 38, 48, 57, 66, 72, 79, 84,
88, 93, 97, 98, 102, 104, 107, 108, 110, 111, 112, 113, 114, 115, 116, 116, 116,
116, 116, 118, 117, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 119, 118, 118, 119, 119,
119, 120, 119, 119, 120, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 118,
120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 119, 119, 118, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
118, 120, 119, 119, 119, 118, 119, 119, 119, 118, 119, 119, 118, 118, 119, 119,
119, 119, 120, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120, 120, 119,
119, 119, 119, 118, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 119,
119, 118, 119, 119, 119, 119, 120, 120, 119, 120, 119, 119, 118, 119, 119, 120,
118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 119, 119, 120, 119, 119, 119, 120, 120, 119, 118, 119, 119, 119, 118,
119, 119, 119, 120, 119, 119, 120, 119, 119, 119, 118, 119, 119, 120, 119, 118,
118, 119, 120, 119, 119, 120, 119, 118, 119, 119, 120, 119, 120, 119, 119, 119,
119, 119, 119, 119, 117, 114, 108, 99, 89, 76, 62, 47, 34, 17, 5, -29, -53, -65,
-76, -84, -91, -96, -100, -103, -107, -108, -111, -112, -114, -114, -115, -116,
-116, -117, -117, -118, -118, -118, -119, -118, -118, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -118, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -120, -118, -119, -120, -119, -118,
-119, -118, -119, -119, -119, -118, -119, -119, -119, -119, -120, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-118, -119, -119, -118, -120, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -118, -119, -118, -119,
-119, -119, -120, -119, -120, -118, -119, -119, -120, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -120, -119, -120, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -118, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -118, -120, -119, -120, -120, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -118, -119, -119, -119, -119, -119, -118,
-119, -120, -120, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -120, -120, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -119, -120, -119, -119, -120, -119, -119, -118, -117, -111,
-103, -92, -80, -66, -52, -37, -22, -7, };