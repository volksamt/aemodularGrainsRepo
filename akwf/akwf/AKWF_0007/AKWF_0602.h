#define DATA_LENGTH 512
#define DATA AKWF_0602

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 5, 3, 10, 18, 17, 19, 19, 20, 20,
22, 23, 24, 25, 25, 27, 28, 29, 30, 31, 32, 32, 33, 35, 35, 36, 37, 39, 40, 40,
41, 43, 43, 44, 45, 46, 46, 47, 49, 50, 51, 52, 53, 54, 54, 56, 56, 58, 58, 60,
61, 61, 62, 64, 65, 65, 67, 68, 68, 69, 70, 71, 72, 73, 74, 75, 76, 77, 78, 78,
79, 81, 81, 83, 84, 84, 85, 86, 87, 87, 89, 90, 91, 92, 93, 94, 95, 96, 96, 98,
99, 99, 100, 101, 102, 103, 104, 105, 106, 107, 109, 108, 109, 111, 111, 113,
114, 115, 115, 117, 117, 118, 119, 118, 117, 116, 115, 114, 114, 113, 112, 111,
111, 110, 109, 109, 108, 107, 105, 106, 105, 104, 102, 101, 101, 101, 99, 98,
99, 97, 97, 95, 94, 95, 93, 92, 91, 90, 89, 89, 88, 87, 87, 86, 84, 84, 83, 83,
81, 81, 80, 79, 78, 77, 77, 76, 75, 75, 73, 73, 72, 72, 70, 70, 68, 68, 66, 67,
65, 65, 63, 62, 62, 61, 61, 60, 60, 58, 57, 56, 56, 56, 55, 53, 53, 52, 51, 50,
49, 48, 48, 47, 47, 45, 45, 44, 44, 43, 42, 40, 40, 39, 38, 38, 36, 35, 35, 34,
34, 34, 33, 31, 30, 29, 28, 28, 27, 26, 25, 24, 24, 23, 22, 21, 20, 19, 19, 18,
18, 16, 16, 15, 15, 13, 14, 10, -1, 1, 0, 2, -1, -12, -11, -13, -13, -13, -14,
-14, -15, -16, -17, -17, -18, -20, -21, -21, -21, -22, -24, -24, -24, -25, -26,
-26, -27, -28, -28, -29, -31, -31, -31, -32, -32, -33, -34, -35, -36, -36, -37,
-38, -38, -39, -41, -40, -42, -42, -42, -44, -43, -44, -45, -45, -47, -47, -48,
-48, -49, -50, -50, -52, -53, -53, -54, -54, -56, -56, -57, -57, -57, -59, -59,
-60, -62, -61, -63, -63, -63, -64, -65, -65, -67, -67, -68, -68, -69, -70, -71,
-71, -72, -72, -73, -74, -74, -75, -76, -77, -78, -79, -79, -79, -80, -80, -82,
-82, -83, -83, -85, -85, -85, -87, -87, -87, -89, -90, -89, -91, -90, -92, -93,
-93, -93, -95, -95, -96, -96, -96, -98, -98, -99, -100, -101, -102, -102, -102,
-103, -104, -105, -105, -106, -107, -107, -109, -109, -109, -109, -111, -112,
-112, -112, -113, -112, -112, -111, -110, -109, -108, -107, -106, -105, -104,
-104, -102, -101, -100, -100, -99, -98, -97, -96, -95, -94, -93, -92, -91, -90,
-89, -89, -87, -86, -85, -83, -82, -82, -81, -80, -80, -78, -77, -77, -75, -75,
-74, -73, -71, -71, -70, -69, -68, -67, -66, -66, -64, -63, -63, -62, -60, -60,
-59, -58, -57, -56, -54, -53, -53, -52, -51, -49, -49, -48, -47, -45, -46, -44,
-43, -42, -41, -40, -39, -38, -38, -37, -36, -35, -34, -32, -32, -30, -30, -28,
-28, -27, -26, -26, -24, -24, -22, -22, -21, -19, -19, -18, -17, -16, -14, -13,
-13, -13, -11, -11, -9, -8, -6, };