#define DATA_LENGTH 512
#define DATA AKWF_0664

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 12, 15, 18, 22, 24, 26, 29,
31, 34, 36, 38, 41, 43, 46, 47, 49, 51, 52, 54, 55, 57, 59, 60, 63, 63, 64, 66,
66, 67, 69, 71, 71, 72, 74, 74, 75, 75, 76, 76, 77, 78, 79, 79, 78, 80, 79, 81,
79, 81, 79, 82, 73, 51, 45, 36, 32, 27, 22, 19, 15, 12, 9, 6, 3, 1, -2, -4, -8,
-9, -11, -14, -15, -17, -18, -21, -24, -25, -26, -28, -29, -31, -32, -34, -35,
-35, -37, -39, -39, -40, -42, -43, -43, -45, -46, -46, -47, -48, -49, -49, -50,
-50, -51, -52, -53, -53, -54, -54, -54, -54, -56, -56, -56, -56, -56, -57, -56,
-57, -57, -57, -56, -42, -38, -35, -32, -29, -27, -25, -23, -21, -19, -18, -16,
-14, -13, -13, -10, -10, -8, -7, -5, -4, -4, -3, -2, -1, 1, 1, 3, 4, 4, 5, 6, 6,
7, 8, 8, 9, 10, 11, 11, 13, 13, 14, 14, 15, 16, 16, 16, 18, 18, 18, 19, 19, 21,
21, 21, 22, 22, 23, 23, 24, 24, 24, 24, 25, 25, 26, 26, 26, 28, 27, 28, 28, 28,
29, 29, 30, 29, 31, 30, 31, 31, 31, 32, 32, 33, 33, 32, 33, 33, 33, 33, 34, 33,
34, 35, 34, 35, 35, 34, 35, 35, 35, 35, 35, 35, 35, 36, 36, 36, 36, 36, 35, 36,
36, 36, 36, 36, 36, 37, 39, 39, 40, 40, 41, 41, 42, 42, 42, 43, 44, 42, 43, 44,
43, 43, 44, 44, 44, 44, 45, 45, 45, 45, 45, 46, 46, 46, 47, 46, 46, 47, 46, 47,
47, 47, 48, 47, 47, 48, 48, 47, 48, 48, 49, 48, 48, 48, 49, 49, 48, 49, 49, 49,
49, 49, 50, 50, 50, 50, 49, 50, 50, 50, 50, 50, 50, 50, 50, 51, 50, 51, 50, 51,
51, 51, 51, 52, 51, 52, 52, 51, 51, 52, 51, 51, 51, 52, 51, 51, 52, 52, 52, 51,
52, 51, 52, 52, 52, 52, 52, 52, 52, 52, 52, 51, 52, 51, 52, 52, 52, 52, 52, 51,
52, 52, 52, 50, 54, 46, 31, 27, 21, 18, 15, 12, 9, 7, 5, 2, 1, -2, -3, -5, -6,
-9, -10, -12, -12, -14, -15, -18, -19, -19, -20, -21, -22, -24, -25, -25, -27,
-28, -28, -30, -30, -31, -32, -32, -32, -33, -34, -35, -36, -36, -37, -36, -37,
-38, -38, -38, -38, -39, -40, -40, -40, -41, -41, -41, -41, -42, -42, -42, -41,
-41, -42, -42, -42, -56, -61, -65, -69, -71, -74, -76, -78, -80, -82, -84, -86,
-87, -88, -90, -90, -93, -94, -94, -95, -97, -98, -99, -100, -101, -101, -103,
-104, -104, -105, -106, -106, -107, -108, -109, -109, -110, -110, -111, -112,
-112, -113, -114, -114, -114, -115, -116, -115, -116, -115, -116, -116, -117,
-117, -117, -118, -118, -119, -118, -119, -119, -118, -120, -119, -119, -119,
-118, -122, -92, -70, -63, -52, -46, -38, -34, -27, -23, -18, -14, -9, -5, -1,
};