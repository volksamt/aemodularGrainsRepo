#define DATA_LENGTH 512
#define DATA AKWF_0615

const PROGMEM int8_t DATA[DATA_LENGTH] = {22, 25, 24, 26, 24, 26, 24, 26, 25,
25, 25, 26, 24, 25, 24, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25,
24, 25, 24, 25, 24, 24, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25,
25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 24,
26, 25, 25, 25, 25, 25, 25, 24, 24, 25, 25, 24, 25, 25, 24, 25, 24, 25, 25, 26,
25, 24, 25, 25, 24, 24, 25, 25, 24, 25, 24, 25, 25, 25, 25, 24, 25, 24, 25, 25,
25, 25, 25, 24, 25, 24, 25, 23, 26, 23, 26, 24, 27, 23, 27, 24, 26, 23, 28, 114,
122, 117, 120, 117, 120, 117, 121, 118, 120, 118, 119, 118, 120, 118, 120, 118,
120, 119, 119, 119, 119, 119, 119, 118, 118, 118, 119, 118, 118, 119, 118, 119,
119, 119, 118, 118, 119, 119, 119, 118, 118, 118, 118, 118, 119, 119, 119, 118,
118, 119, 118, 118, 118, 118, 118, 119, 119, 119, 118, 118, 118, 118, 118, 118,
119, 118, 118, 118, 119, 118, 118, 117, 118, 118, 118, 118, 117, 118, 118, 118,
117, 118, 119, 117, 118, 118, 118, 118, 118, 119, 118, 118, 117, 118, 117, 118,
117, 119, 118, 118, 118, 118, 118, 117, 117, 117, 118, 116, 118, 116, 119, 116,
119, 116, 119, 116, 119, 115, 120, 115, 120, 115, 118, 116, 116, 122, -49, -82,
-65, -77, -66, -76, -67, -75, -69, -75, -70, -74, -70, -73, -70, -73, -71, -72,
-71, -72, -72, -72, -73, -72, -72, -71, -72, -71, -72, -72, -72, -72, -73, -71,
-72, -71, -72, -71, -71, -72, -72, -72, -72, -72, -72, -71, -72, -72, -72, -72,
-71, -72, -71, -72, -72, -72, -72, -72, -71, -72, -71, -72, -72, -72, -71, -71,
-72, -72, -72, -71, -71, -71, -72, -72, -72, -71, -71, -71, -71, -72, -72, -71,
-71, -72, -71, -71, -71, -72, -71, -71, -72, -71, -71, -71, -71, -71, -71, -72,
-71, -72, -71, -72, -71, -71, -71, -72, -72, -71, -71, -71, -72, -71, -71, -71,
-72, -71, -71, -71, -71, -71, -71, -72, -71, -71, -72, -72, -71, -70, -71, -71,
-71, -71, -71, -71, -71, -71, -71, -71, -70, -71, -72, -71, -71, -71, -71, -71,
-71, -70, -71, -71, -72, -70, -71, -71, -71, -70, -71, -71, -71, -70, -70, -70,
-70, -71, -71, -71, -71, -71, -70, -71, -70, -71, -70, -70, -70, -71, -71, -71,
-70, -71, -71, -70, -70, -71, -71, -70, -70, -70, -70, -70, -70, -70, -70, -70,
-70, -70, -71, -70, -70, -70, -70, -70, -70, -70, -69, -71, -71, -70, -71, -70,
-70, -70, -71, -71, -70, -70, -71, -71, -70, -70, -71, -70, -71, -70, -70, -70,
-70, -70, -70, -69, -70, -70, -70, -70, -70, -70, -71, -70, -69, -70, -70, -70,
-70, -70, -69, -71, -69, -71, -68, -70, -68, -71, -68, -72, -66, -74, -59, };