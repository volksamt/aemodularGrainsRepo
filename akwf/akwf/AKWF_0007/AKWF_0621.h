#define DATA_LENGTH 512
#define DATA AKWF_0621

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 11, 14, 16, 20, 22, 24, 26, 28, 30,
32, 34, 36, 38, 39, 42, 43, 44, 45, 48, 49, 51, 52, 53, 54, 56, 57, 58, 60, 61,
63, 63, 64, 65, 67, 68, 69, 70, 71, 72, 73, 74, 75, 76, 77, 78, 79, 79, 81, 83,
83, 84, 85, 85, 86, 87, 88, 89, 90, 90, 91, 91, 92, 93, 93, 95, 95, 96, 97, 98,
98, 98, 100, 101, 102, 101, 102, 103, 104, 104, 104, 106, 106, 105, 107, 106,
107, 108, 109, 109, 109, 110, 109, 111, 112, 111, 112, 112, 112, 113, 114, 114,
114, 114, 114, 115, 115, 115, 116, 116, 116, 116, 117, 117, 118, 117, 118, 118,
118, 118, 118, 117, 118, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118,
111, 106, 103, 99, 96, 93, 90, 87, 85, 82, 80, 78, 75, 74, 72, 70, 69, 67, 65,
63, 62, 59, 58, 57, 55, 53, 51, 49, 48, 48, 46, 44, 43, 42, 41, 39, 38, 38, 36,
34, 33, 32, 31, 30, 29, 29, 27, 26, 25, 24, 23, 22, 22, 21, 20, 19, 18, 17, 17,
15, 15, 14, 13, 13, 12, 11, 11, 10, 10, 9, 8, 9, 8, 7, 6, 6, 5, 5, 5, 4, 4, 3,
3, 2, 2, 2, 2, 2, 1, 2, 1, 1, 1, 1, 1, 1, 1, 0, 0, -1, 0, 1, -1, 0, 0, 0, 0, 0,
0, 0, -1, 0, -1, 0, 0, -7, -13, -15, -19, -22, -25, -27, -31, -33, -34, -37,
-40, -42, -44, -45, -47, -49, -50, -53, -55, -56, -58, -59, -60, -62, -63, -64,
-66, -68, -69, -71, -72, -73, -74, -75, -77, -78, -80, -81, -81, -83, -84, -85,
-86, -87, -88, -90, -90, -91, -92, -93, -94, -95, -95, -96, -97, -98, -99, -99,
-100, -101, -103, -103, -104, -104, -104, -105, -106, -107, -107, -107, -109,
-110, -109, -111, -111, -111, -112, -113, -113, -114, -113, -114, -114, -114,
-115, -115, -115, -116, -116, -116, -117, -116, -117, -118, -118, -118, -117,
-118, -118, -118, -118, -119, -118, -117, -119, -117, -111, -107, -103, -101,
-99, -96, -94, -91, -89, -88, -86, -83, -81, -80, -79, -76, -76, -74, -72, -71,
-69, -68, -67, -65, -64, -63, -61, -60, -58, -57, -56, -55, -54, -53, -52, -50,
-50, -49, -47, -47, -46, -44, -44, -42, -41, -40, -39, -38, -38, -37, -36, -35,
-34, -32, -32, -31, -30, -30, -28, -28, -28, -27, -26, -25, -24, -24, -23, -23,
-21, -21, -20, -19, -19, -19, -18, -16, -16, -16, -16, -15, -14, -14, -13, -13,
-13, -12, -12, -11, -10, -9, -9, -8, -8, -8, -8, -7, -7, -7, -6, -5, -5, -5, -5,
-4, -5, -4, -3, -4, -3, -3, -3, -2, -2, -1, -2, -2, -1, -2, -1, -1, -1, 0, 0,
-1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 1, 0, 0, 0,
0, 0, 0, 1, 0, 0, 1, };