#define DATA_LENGTH 512
#define DATA AKWF_0633

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 2, 3, 3, 4, 6, 7, 8, 10, 10, 12,
14, 16, 17, 20, 21, 23, 25, 26, 28, 31, 32, 34, 36, 38, 41, 42, 44, 47, 49, 51,
53, 55, 58, 60, 62, 64, 67, 68, 71, 72, 75, 76, 78, 80, 82, 84, 85, 88, 89, 92,
93, 94, 96, 97, 98, 100, 101, 103, 104, 106, 106, 108, 108, 111, 111, 112, 112,
114, 114, 115, 116, 116, 116, 117, 118, 117, 118, 116, 121, 53, -3, 3, -1, 1,
-1, 0, 0, 0, -1, -2, -2, -4, -4, -6, -8, -8, -10, -12, -12, -14, -16, -18, -20,
-22, -23, -25, -28, -29, -31, -34, -36, -37, -40, -42, -44, -46, -48, -50, -53,
-55, -57, -59, -61, -64, -65, -68, -70, -71, -74, -76, -77, -79, -82, -84, -85,
-88, -88, -91, -92, -93, -95, -97, -98, -100, -101, -102, -104, -104, -106,
-107, -108, -108, -110, -110, -112, -112, -112, -113, -113, -114, -114, -115,
-115, -115, -115, -115, -113, -112, -110, -107, -104, -102, -99, -95, -91, -89,
-85, -81, -78, -74, -70, -66, -62, -58, -54, -49, -46, -42, -39, -34, -31, -28,
-24, -23, -19, -16, -14, -11, -9, -7, -5, -4, -2, -2, -1, -1, 0, 0, 0, 1, 2, 3,
5, 6, 8, 11, 13, 15, 18, 20, 24, 26, 29, 33, 36, 38, 41, 44, 48, 51, 54, 57, 60,
63, 66, 70, 73, 76, 79, 81, 84, 87, 89, 92, 95, 97, 100, 102, 104, 106, 108,
109, 112, 113, 113, 114, 117, 116, 118, 116, 121, 116, 125, 76, 3, 0, -1, 1, 0,
0, 0, 0, 0, 0, -1, -2, -3, -4, -4, -6, -7, -9, -10, -11, -13, -14, -15, -17,
-19, -21, -23, -24, -27, -29, -31, -33, -35, -38, -39, -41, -44, -46, -48, -49,
-52, -54, -55, -58, -59, -62, -64, -66, -69, -70, -72, -74, -77, -79, -80, -82,
-84, -85, -87, -89, -91, -92, -94, -96, -96, -98, -99, -101, -103, -103, -105,
-106, -107, -108, -109, -110, -111, -111, -112, -112, -114, -113, -115, -115,
-116, -115, -115, -116, -116, -115, -111, -109, -104, -100, -94, -89, -83, -77,
-72, -65, -59, -53, -48, -43, -37, -31, -27, -22, -17, -14, -11, -7, -5, -3, -2,
-1, 0, 1, 0, 0, 0, -1, 0, 0, 0, 1, -1, 0, -1, 0, 0, 0, 1, 0, 0, 1, -1, 1, 0, 2,
4, 6, 8, 10, 12, 14, 17, 19, 23, 26, 29, 33, 35, 38, 42, 45, 49, 51, 55, 59, 63,
65, 69, 71, 75, 77, 82, 84, 88, 90, 93, 96, 98, 100, 102, 104, 105, 109, 109,
113, 110, 116, 112, 119, 113, 123, 111, 127, 85, -12, 5, -3, 1, -3, -5, -8, -11,
-14, -19, -22, -28, -30, -37, -40, -46, -50, -56, -60, -65, -69, -75, -78, -84,
-87, -91, -95, -99, -102, -104, -107, -108, -112, -112, -114, -115, -116, -116,
-111, -103, -91, -78, -64, -49, -36, -24, -15, -6, -1, 1, 0, 0, 0, 0, 0, -1, -1,
};