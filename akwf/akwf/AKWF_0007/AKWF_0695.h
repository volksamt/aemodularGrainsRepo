#define DATA_LENGTH 512
#define DATA AKWF_0695

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 7, 8, 11, 11, 16, 11, 43, 79,
87, 98, 103, 109, 111, 115, 115, 118, 118, 119, 119, 118, 118, 117, 116, 115,
115, 112, 110, 107, 106, 103, 101, 100, 97, 94, 91, 88, 85, 82, 79, 76, 73, 69,
66, 62, 58, 55, 52, 48, 45, 41, 38, 34, 30, 27, 23, 20, 17, 13, 9, 6, 3, 0, -4,
-6, -9, -11, -14, -16, -18, -20, -23, -25, -27, -29, -31, -33, -34, -36, -37,
-39, -40, -42, -43, -44, -44, -45, -47, -48, -49, -49, -49, -50, -51, -50, -51,
-52, -53, -52, -52, -53, -52, -53, -52, -53, -52, -52, -52, -52, -52, -51, -51,
-49, -50, -49, -48, -48, -47, -46, -46, -45, -43, -43, -42, -41, -40, -39, -38,
-37, -36, -34, -33, -32, -30, -29, -29, -26, -25, -23, -22, -21, -19, -17, -16,
-14, -13, -12, -10, -7, -6, -5, -2, -1, 0, 3, 5, 6, 9, 10, 12, 14, 15, 17, 19,
21, 23, 24, 26, 29, 30, 31, 33, 35, 37, 39, 40, 42, 42, 45, 46, 48, 50, 51, 52,
54, 55, 56, 58, 58, 60, 61, 62, 64, 65, 66, 66, 67, 68, 71, 71, 71, 73, 74, 75,
75, 76, 77, 78, 78, 79, 80, 81, 81, 82, 82, 83, 82, 83, 84, 85, 85, 85, 86, 86,
85, 87, 86, 86, 87, 88, 87, 88, 88, 87, 87, 87, 87, 87, 87, 87, 87, 86, 87, 85,
86, 86, 86, 85, 84, 84, 83, 83, 82, 81, 82, 81, 80, 80, 79, 79, 78, 77, 77, 76,
76, 74, 73, 72, 72, 71, 70, 68, 68, 67, 66, 65, 64, 63, 62, 61, 60, 57, 56, 56,
55, 53, 53, 50, 49, 48, 46, 45, 44, 43, 40, 39, 38, 36, 35, 33, 32, 30, 28, 27,
26, 23, 21, 20, 18, 17, 15, 14, 11, 10, 8, 6, 5, 3, 2, 0, -2, -4, -5, -7, -8,
-10, -11, -13, -15, -17, -18, -20, -21, -22, -24, -26, -27, -28, -30, -32, -32,
-34, -35, -37, -38, -40, -41, -42, -43, -44, -46, -47, -49, -49, -50, -52, -52,
-53, -55, -57, -57, -58, -59, -60, -61, -62, -62, -64, -64, -65, -67, -68, -68,
-70, -70, -70, -71, -72, -73, -74, -73, -74, -75, -76, -77, -77, -77, -77, -78,
-79, -79, -80, -80, -80, -81, -81, -81, -81, -83, -83, -83, -83, -83, -83, -83,
-84, -83, -85, -83, -85, -85, -84, -84, -85, -84, -84, -84, -84, -83, -85, -84,
-84, -85, -83, -84, -83, -83, -83, -82, -83, -83, -82, -82, -82, -81, -80, -81,
-80, -79, -79, -79, -78, -77, -77, -77, -76, -75, -74, -74, -74, -73, -73, -71,
-70, -70, -69, -68, -67, -67, -66, -65, -65, -64, -62, -62, -61, -60, -59, -58,
-58, -56, -54, -53, -53, -52, -50, -49, -48, -47, -46, -44, -43, -41, -40, -40,
-38, -36, -35, -34, -32, -31, -30, -28, -25, -25, -23, -22, -20, -19, -17, -15,
-14, -12, -11, -8, -7, -5, -4, -2, 0, };