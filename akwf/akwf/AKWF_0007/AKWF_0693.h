#define DATA_LENGTH 512
#define DATA AKWF_0693

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 5, 6, 7, 9, 10, 12, 13, 15,
17, 19, 20, 21, 19, 19, 18, 16, 16, 16, 17, 18, 19, 19, 19, 18, 18, 17, 17, 16,
16, 15, 17, 17, 17, 18, 18, 18, 18, 18, 18, 17, 18, 16, 14, 11, 11, 9, 10, 10,
12, 11, 9, 5, 5, 3, 4, 8, 12, 13, 16, 17, 18, 57, 80, 86, 92, 94, 100, 99, 105,
104, 104, 104, 109, 111, 113, 117, 118, 118, 118, 116, 114, 116, 116, 115, 116,
117, 117, 119, 117, 118, 118, 112, 111, 112, 112, 109, 104, 102, 101, 102, 100,
102, 104, 104, 103, 101, 102, 102, 103, 98, 100, 98, 104, 96, 108, 75, -10, -28,
-41, -40, -41, -40, -41, -41, -40, -41, -39, -39, -38, -41, -41, -42, -40, -41,
-40, -42, -41, -40, -41, -41, -41, -44, -46, -47, -46, -45, -43, -45, -47, -50,
-52, -53, -55, -56, -56, -55, -53, -52, -49, -48, -47, -44, -44, -45, -43, -44,
-43, -44, -45, -43, -44, -44, -44, -43, -42, -41, -40, -39, -38, -37, -37, -39,
-38, -38, -38, -36, -31, -29, -26, -22, -18, -15, -14, -12, -14, -18, -20, -21,
-21, -19, -19, -18, -15, -14, -16, -18, -19, -20, -18, -20, -22, -22, -23, -23,
-24, -23, -21, -20, -18, -13, -11, -8, -8, -8, -8, -10, -11, -12, -13, -11, -10,
-10, -8, -7, -6, -7, -4, -4, -2, 0, 2, 4, 6, 5, 4, 3, 1, 0, -1, -1, 0, 0, 0, -1,
-2, -3, -4, -5, -4, -5, -4, -4, -1, 1, 1, 2, 1, 1, 1, 0, -1, -1, -3, -6, -8, -8,
-9, -9, -10, -11, -12, -11, -11, -10, -12, -11, -12, -12, -13, -12, -12, -13,
-14, -14, -16, -17, -19, -20, -21, -21, -23, -26, -25, -24, -23, -24, -23, -23,
-23, -22, -22, -22, -23, -24, -23, -22, -23, -23, -25, -26, -26, -26, -26, -25,
-25, -25, -25, -26, -29, -32, -33, -33, -34, -35, -37, -37, -37, -38, -36, -32,
-30, -28, -25, -24, -25, -25, -24, -25, -24, -24, -25, -24, -23, -20, -19, -19,
-18, -17, -17, -15, -15, -16, -14, -12, -11, -10, -9, -10, -8, -8, -10, -10,
-10, -11, -11, -10, -9, -8, -8, -8, -6, -7, -7, -7, -6, -4, -4, -2, -2, -1, -2,
-2, -2, -2, -1, -1, -2, -4, -5, -7, -7, -6, -6, -7, -7, -7, -6, -6, -5, -6, -7,
-6, -7, -6, -6, -6, -6, -6, -4, -5, -4, -4, -5, -7, -9, -10, -11, -11, -13, -13,
-14, -15, -14, -14, -14, -13, -13, -12, -10, -10, -9, -9, -8, -8, -8, -7, -8,
-8, -8, -8, -10, -9, -8, -8, -9, -9, -8, -9, -8, -9, -9, -9, -8, -7, -7, -6, -7,
-8, -8, -7, -7, -7, -7, -8, -7, -7, -7, -6, -5, -4, -2, -2, -2, -1, -1, -1, 0,
-1, -1, -1, -1, -1, -1, 0, 0, -1, 0, 0, 0, -1, -1, -2, -3, -3, -4, -4, -2, -2,
0, };