#define DATA_LENGTH 512
#define DATA AKWF_0645

const PROGMEM int8_t DATA[DATA_LENGTH] = {13, 22, 28, 32, 36, 41, 44, 48, 51,
54, 56, 59, 62, 64, 66, 69, 72, 73, 74, 77, 78, 80, 83, 84, 86, 88, 89, 91, 92,
94, 96, 96, 97, 99, 100, 102, 103, 104, 105, 106, 106, 108, 109, 109, 110, 111,
113, 112, 113, 114, 114, 115, 114, 115, 116, 117, 116, 117, 118, 117, 118, 118,
119, 118, 119, 118, 120, 112, 99, 95, 88, 84, 80, 76, 73, 69, 66, 64, 61, 59,
55, 53, 51, 48, 47, 45, 43, 41, 40, 37, 36, 33, 31, 30, 29, 27, 26, 24, 24, 21,
20, 20, 18, 17, 16, 14, 14, 13, 12, 11, 11, 9, 9, 8, 6, 6, 6, 5, 4, 4, 4, 3, 2,
2, 2, 2, 2, 1, 1, 0, 1, -1, 1, 1, 0, 1, 0, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0, 0, 0,
0, 1, 1, 1, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 1, 0, 1, 0, 0, 1, 0, 0, 0, -1, 0, 0,
0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 2, 2, 2, 2, 2, 1, 2, 1, 2, 1, 2, 2, 1, 2, 1, 2, 1,
1, 1, 1, 1, 2, 1, 1, 2, 2, 1, 1, 2, 1, 1, 0, 1, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, 0,
0, 1, 0, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 0, 0, 0, -1, 1, 0, 1,
0, -15, -23, -27, -33, -37, -41, -44, -48, -50, -54, -56, -60, -61, -64, -66,
-70, -71, -74, -75, -78, -79, -81, -83, -84, -86, -88, -89, -91, -92, -94, -96,
-97, -98, -99, -101, -101, -102, -104, -104, -105, -107, -107, -108, -109, -110,
-111, -112, -112, -113, -113, -115, -115, -116, -116, -116, -117, -117, -117,
-118, -118, -118, -118, -119, -118, -119, -118, -120, -111, -98, -94, -88, -84,
-79, -77, -72, -69, -66, -63, -61, -59, -56, -53, -51, -48, -47, -44, -43, -40,
-39, -37, -35, -33, -32, -30, -29, -27, -25, -24, -24, -21, -21, -18, -18, -17,
-16, -15, -14, -13, -12, -11, -10, -9, -9, -8, -7, -7, -6, -5, -4, -3, -3, -4,
-3, -1, -2, -2, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, -1, -1,
0, 1, 0, 0, 0, 0, 0, 1, 1, -1, 0, 1, 0, 0, 0, 0, 0, 1, 1, -1, 1, 0, 0, 1, 0, -1,
0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0,
0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0,
0, 1, 0, 0, 0, 0, };