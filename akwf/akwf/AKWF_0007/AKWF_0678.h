#define DATA_LENGTH 512
#define DATA AKWF_0678

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 14, 22, 29, 36, 44, 52, 59, 65, 71,
77, 83, 89, 93, 99, 102, 106, 109, 113, 114, 116, 117, 118, 118, 119, 119, 118,
117, 115, 113, 111, 109, 105, 102, 98, 95, 90, 87, 81, 78, 73, 68, 64, 58, 55,
49, 45, 40, 36, 32, 28, 24, 21, 17, 13, 11, 8, 6, 3, 2, -1, -1, -2, -4, -4, -4,
-5, -4, -4, -3, -3, -1, 0, 2, 3, 5, 6, 7, 10, 11, 14, 15, 17, 18, 20, 22, 23,
25, 26, 28, 29, 30, 31, 32, 32, 32, 33, 34, 33, 33, 32, 32, 32, 30, 30, 29, 27,
26, 25, 22, 22, 19, 18, 16, 14, 13, 11, 9, 7, 5, 4, 3, 1, -2, -2, -4, -4, -5,
-6, -7, -9, -8, -9, -9, -9, -9, -9, -9, -9, -9, -8, -8, -6, -6, -5, -4, -2, -2,
0, 1, 2, 4, 4, 6, 7, 9, 10, 10, 11, 13, 12, 14, 15, 16, 16, 17, 17, 17, 18, 17,
17, 17, 17, 17, 16, 16, 14, 14, 13, 13, 11, 10, 9, 8, 7, 6, 4, 2, 2, 0, -1, -2,
-4, -5, -6, -7, -9, -10, -11, -12, -13, -14, -15, -16, -15, -16, -17, -17, -17,
-18, -17, -18, -17, -17, -17, -16, -15, -15, -14, -14, -12, -12, -11, -9, -9,
-7, -7, -5, -4, -4, -3, -1, -1, 0, 1, 2, 4, 5, 6, 6, 6, 7, 8, 9, 8, 9, 10, 10,
10, 9, 9, 9, 8, 9, 8, 8, 7, 6, 6, 4, 4, 3, 2, 0, 0, -2, -3, -4, -6, -6, -8, -9,
-11, -13, -14, -15, -16, -18, -19, -21, -21, -23, -24, -25, -26, -28, -28, -28,
-30, -31, -32, -32, -32, -33, -34, -32, -34, -33, -33, -33, -33, -33, -32, -32,
-31, -30, -31, -30, -28, -27, -28, -26, -25, -24, -23, -22, -20, -20, -19, -18,
-16, -15, -14, -12, -11, -9, -8, -7, -7, -5, -3, -4, -1, -1, 0, 0, 2, 2, 3, 3,
3, 4, 4, 4, 5, 5, 4, 4, 5, 4, 3, 3, 3, 1, 1, 0, 0, -2, -2, -4, -6, -7, -8, -10,
-11, -13, -14, -16, -18, -20, -21, -24, -25, -28, -29, -33, -34, -37, -38, -41,
-43, -46, -47, -51, -53, -55, -57, -60, -63, -64, -66, -69, -72, -73, -75, -78,
-79, -82, -84, -87, -88, -90, -92, -94, -96, -98, -100, -100, -103, -104, -105,
-107, -107, -109, -110, -111, -113, -114, -115, -116, -116, -116, -117, -118,
-118, -118, -119, -119, -118, -119, -119, -119, -119, -119, -118, -118, -118,
-118, -117, -116, -115, -116, -114, -113, -112, -111, -110, -110, -109, -108,
-107, -105, -105, -102, -101, -100, -98, -97, -96, -94, -92, -90, -89, -88, -85,
-85, -83, -82, -80, -78, -75, -74, -72, -70, -69, -66, -66, -64, -61, -60, -58,
-56, -54, -52, -50, -48, -47, -45, -42, -41, -39, -36, -35, -34, -32, -30, -28,
-26, -24, -23, -21, -19, -17, -17, -15, -13, -12, -10, -9, -6, -5, 0, };