#define DATA_LENGTH 512
#define DATA AKWF_0700

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 9, 11, 14, 15, 18, 21, 23,
24, 27, 29, 30, 32, 33, 35, 37, 39, 40, 42, 44, 44, 46, 47, 50, 51, 53, 53, 54,
56, 56, 58, 59, 59, 61, 61, 63, 63, 64, 65, 67, 67, 67, 69, 69, 70, 70, 72, 70,
73, 72, 75, 73, 75, 74, 75, 75, 75, 76, 76, 77, 75, 78, 74, 81, 69, 95, -35,
-127, -103, -110, -93, -95, -84, -84, -75, -74, -67, -65, -60, -56, -53, -50,
-46, -43, -40, -36, -33, -30, -28, -24, -23, -19, -18, -14, -12, -9, -7, -5, -2,
0, 1, 5, 6, 9, 10, 12, 14, 16, 18, 19, 21, 23, 24, 26, 27, 27, 29, 30, 32, 33,
34, 35, 36, 38, 38, 39, 39, 40, 42, 42, 43, 43, 44, 44, 45, 45, 45, 46, 46, 47,
46, 47, 47, 47, 47, 42, 38, 35, 33, 31, 29, 27, 26, 23, 22, 20, 19, 17, 16, 14,
13, 11, 11, 10, 8, 7, 6, 5, 3, 3, 2, 1, 0, -1, -3, -3, -4, -5, -6, -6, -7, -8,
-9, -10, -11, -11, -12, -13, -14, -14, -14, -15, -17, -16, -18, -17, -18, -18,
-20, -19, -20, -21, -21, -21, -22, -22, -22, -23, -23, -24, -24, -25, -24, -25,
-25, -26, -26, -25, -26, -27, -26, -27, -26, -26, -26, -27, -26, -27, -26, -26,
-26, -27, -27, -27, -27, -27, -26, -27, -27, -27, -27, -28, -26, -27, -27, -27,
-26, -27, -26, -27, -26, -27, -27, -27, -27, -26, -27, -27, -27, -27, -28, -27,
-26, -27, -26, -26, -26, -27, -27, -26, -27, -27, -27, -27, -27, -27, -27, -27,
-27, -27, -26, -26, -26, -27, -27, -26, -27, -27, -26, -27, -26, -26, -26, -27,
-27, -27, -27, -27, -26, -28, -26, -26, -26, -27, -26, -26, -27, -26, -26, -27,
-26, -27, -27, -26, -26, -27, -26, -27, -27, -27, -27, -27, -26, -26, -27, -26,
-26, -26, -26, -27, -26, -26, -26, -27, -26, -27, -26, -27, -26, -27, -26, -26,
-26, -26, -26, -26, -26, -27, -27, -27, -27, -26, -26, -27, -26, -27, -27, -27,
-25, -26, -27, -27, -26, -27, -26, -26, -26, -26, -26, -26, -27, -27, -26, -27,
-27, -26, -26, -26, -26, -26, -26, -26, -27, -26, -27, -26, -27, -26, -26, -27,
-26, -26, -26, -26, -26, -26, -27, -27, -26, -26, -26, -26, -26, -27, -26, -26,
-26, -27, -26, -26, -26, -26, -26, -27, -27, -27, -26, -26, -27, -27, -26, -27,
-26, -26, -26, -26, -27, -27, -27, -26, -27, -27, -26, -26, -27, -27, -27, -27,
-26, -27, -27, -27, -26, -27, -26, -26, -27, -27, -27, -26, -26, -23, -21, -20,
-19, -18, -17, -16, -15, -15, -13, -13, -12, -12, -11, -11, -10, -10, -10, -9,
-9, -8, -7, -7, -7, -7, -6, -5, -5, -5, -6, -4, -4, -4, -4, -4, -4, -4, -3, -2,
-2, -2, -2, -2, -2, -2, -2, -1, -2, -1, -1, -2, -2, -1, 0, 0, -1, -1, -1, 0, };