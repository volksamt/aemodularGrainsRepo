#define DATA_LENGTH 512
#define DATA AKWF_0608

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 9, 12, 15, 17, 21, 23, 25,
28, 31, 33, 35, 39, 40, 43, 46, 49, 50, 52, 55, 57, 60, 62, 65, 67, 69, 72, 73,
75, 77, 79, 81, 83, 84, 87, 89, 90, 92, 93, 95, 97, 98, 100, 102, 102, 103, 105,
106, 107, 109, 109, 111, 111, 113, 113, 114, 115, 115, 116, 117, 117, 118, 118,
118, 119, 119, 119, 119, 120, 119, 119, 117, 115, 113, 109, 106, 102, 98, 94,
89, 85, 79, 75, 71, 64, 59, 55, 49, 44, 39, 33, 27, 22, 16, 11, 5, -1, -5, -10,
-17, -22, -26, -31, -36, -41, -45, -50, -55, -58, -62, -66, -70, -75, -78, -81,
-84, -86, -89, -92, -94, -96, -97, -100, -101, -102, -102, -104, -104, -104,
-105, -103, -101, -98, -96, -93, -89, -85, -80, -76, -72, -68, -62, -58, -52,
-47, -42, -36, -31, -26, -21, -16, -10, -4, 1, 6, 12, 17, 23, 28, 33, 38, 43,
48, 52, 57, 62, 66, 71, 75, 78, 82, 86, 90, 93, 97, 99, 102, 104, 107, 109, 111,
113, 114, 116, 116, 118, 117, 118, 118, 118, 118, 116, 115, 114, 112, 109, 107,
105, 103, 100, 98, 95, 92, 89, 86, 83, 81, 78, 74, 71, 68, 64, 61, 58, 54, 51,
47, 44, 40, 37, 34, 30, 26, 22, 20, 16, 12, 9, 6, 3, -1, -5, -9, -12, -15, -18,
-21, -25, -28, -32, -34, -37, -40, -43, -47, -50, -52, -55, -57, -60, -63, -66,
-68, -71, -73, -76, -77, -79, -81, -83, -85, -87, -89, -90, -91, -94, -95, -97,
-97, -99, -100, -101, -102, -102, -103, -104, -104, -106, -106, -105, -106,
-106, -106, -105, -104, -103, -101, -99, -96, -94, -92, -89, -87, -85, -81, -79,
-75, -73, -69, -67, -64, -60, -57, -54, -51, -48, -45, -42, -38, -36, -33, -30,
-26, -24, -21, -18, -16, -13, -11, -8, -6, -4, -2, 0, 2, 4, 5, 7, 9, 10, 11, 12,
13, 14, 14, 15, 15, 16, 15, 18, 34, 57, 80, 99, 113, 118, 118, 118, 116, 115,
114, 113, 112, 110, 108, 106, 105, 103, 100, 99, 96, 94, 92, 90, 87, 85, 83, 81,
78, 76, 73, 70, 67, 65, 62, 59, 58, 54, 51, 49, 46, 43, 41, 37, 34, 33, 29, 26,
24, 21, 18, 15, 12, 9, 6, 4, 1, -2, -5, -7, -10, -12, -14, -19, -21, -23, -26,
-28, -31, -33, -35, -38, -41, -43, -46, -47, -51, -52, -55, -57, -59, -61, -63,
-65, -68, -70, -71, -73, -74, -76, -78, -80, -81, -83, -85, -87, -87, -89, -91,
-92, -92, -94, -95, -96, -97, -99, -99, -99, -101, -102, -102, -103, -104, -104,
-105, -104, -106, -105, -106, -106, -106, -106, -106, -106, -104, -103, -102,
-100, -99, -99, -97, -95, -93, -91, -90, -88, -86, -83, -80, -79, -77, -75, -72,
-69, -67, -65, -62, -60, -58, -55, -53, -50, -48, -45, -42, -40, -37, -34, -31,
-28, -27, -24, -21, -18, -14, -12, -9, -7, -4, 0, };