#define DATA_LENGTH 512
#define DATA AKWF_0646

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 7, 8, 9, 12, 12, 14, 17, 18,
19, 22, 22, 24, 26, 27, 29, 31, 32, 34, 36, 37, 39, 40, 43, 44, 45, 47, 48, 50,
53, 54, 55, 57, 59, 60, 62, 64, 65, 67, 70, 70, 72, 74, 75, 77, 78, 80, 82, 83,
85, 86, 88, 89, 92, 93, 95, 96, 98, 100, 101, 103, 105, 107, 108, 109, 111, 114,
115, 117, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 119,
119, 119, 119, 119, 119, 118, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 118, 119, 120, 118, 119, 119, 119, 118, 119, 119, 118, 119,
118, 118, 118, 118, 118, 118, 118, 118, 119, 119, 118, 118, 119, 118, 118, 118,
119, 118, 118, 119, 118, 119, 119, 119, 119, 118, 118, 119, 118, 119, 119, 119,
119, 118, 118, 118, 118, 118, 118, 119, 117, 118, 118, 119, 118, 118, 118, 118,
118, 118, 118, 118, 117, 118, 118, 117, 119, 118, 118, 118, 118, 118, 118, 118,
118, 118, 118, 117, 115, 114, 112, 110, 109, 107, 105, 103, 103, 100, 99, 98,
96, 94, 93, 91, 89, 88, 86, 85, 82, 80, 80, 77, 76, 75, 73, 72, 69, 68, 66, 64,
63, 60, 59, 58, 56, 55, 53, 51, 50, 48, 46, 45, 43, 42, 40, 39, 36, 35, 33, 32,
30, 28, 27, 25, 24, 21, 20, 18, 17, 14, 14, 11, 10, 8, 7, 5, 3, 2, 0, -1, -2,
-5, -6, -7, -10, -12, -13, -15, -17, -18, -20, -21, -23, -25, -26, -27, -30,
-30, -33, -35, -36, -38, -39, -40, -42, -44, -46, -47, -49, -50, -52, -55, -56,
-58, -59, -61, -63, -64, -65, -68, -69, -71, -72, -74, -75, -76, -79, -80, -83,
-83, -85, -87, -89, -91, -92, -94, -95, -96, -99, -100, -102, -103, -105, -106,
-109, -110, -112, -113, -115, -116, -118, -120, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -118, -118, -118, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -118, -119, -118, -118, -119, -119, -119, -119, -118, -118, -118,
-119, -118, -119, -119, -118, -118, -119, -119, -119, -119, -119, -118, -119,
-118, -118, -119, -118, -119, -119, -119, -119, -119, -119, -118, -119, -118,
-118, -118, -118, -119, -118, -119, -119, -119, -118, -118, -118, -119, -119,
-118, -118, -119, -118, -118, -119, -118, -118, -118, -119, -117, -119, -119,
-118, -118, -118, -118, -119, -117, -118, -118, -118, -118, -118, -118, -118,
-118, -118, -117, -116, -113, -113, -110, -109, -108, -105, -103, -103, -100,
-98, -97, -95, -94, -93, -90, -89, -88, -86, -84, -82, -81, -78, -77, -76, -74,
-72, -71, -70, -68, -67, -64, -63, -61, -59, -58, -56, -54, -53, -51, -50, -48,
-46, -44, -43, -41, -40, -38, -36, -35, -33, -31, -30, -28, -27, -26, -23, -21,
-21, -18, -17, -15, -13, -11, -10, -8, -7, -5, -3, -2, -1, };