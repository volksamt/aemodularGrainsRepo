#define DATA_LENGTH 512
#define DATA AKWF_0617

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 15, 20, 23, 26, 29, 31, 32,
34, 35, 36, 38, 38, 40, 40, 39, 39, 39, 38, 38, 38, 38, 38, 38, 36, 36, 36, 35,
35, 34, 35, 33, 33, 32, 34, 33, 32, 32, 32, 30, 31, 31, 30, 30, 30, 30, 29, 30,
30, 29, 28, 30, 30, 29, 30, 30, 30, 29, 30, 29, 31, 31, 31, 32, 32, 33, 33, 35,
35, 36, 37, 39, 39, 41, 42, 43, 44, 46, 47, 48, 50, 50, 52, 53, 55, 56, 57, 59,
60, 62, 62, 64, 65, 65, 67, 69, 69, 71, 71, 73, 73, 74, 76, 76, 77, 78, 79, 80,
81, 81, 84, 83, 85, 85, 86, 86, 87, 99, 96, 95, 95, 94, 93, 92, 91, 89, 89, 88,
86, 85, 86, 84, 83, 82, 81, 80, 79, 78, 76, 75, 75, 73, 73, 71, 70, 69, 68, 67,
66, 65, 63, 63, 62, 60, 59, 58, 57, 57, 55, 54, 53, 53, 52, 51, 50, 50, 51, 51,
51, 51, 52, 51, 52, 52, 53, 52, 53, 53, 54, 55, 55, 55, 56, 57, 56, 58, 58, 58,
60, 61, 63, 65, 66, 66, 67, 66, 66, 66, 66, 65, 65, 65, 64, 63, 64, 63, 63, 61,
61, 61, 60, 60, 59, 57, 57, 57, 55, 55, 55, 54, 53, 53, 51, 52, 50, 50, 49, 49,
48, 48, 47, 46, 45, 45, 44, 44, 43, 42, 43, 40, 42, 39, 43, 36, 47, 1, -35, -24,
-32, -28, -32, -31, -34, -34, -35, -36, -37, -39, -40, -41, -42, -44, -44, -46,
-47, -49, -49, -51, -53, -54, -54, -54, -55, -55, -56, -57, -56, -57, -58, -58,
-58, -59, -59, -59, -60, -59, -59, -60, -61, -61, -61, -61, -61, -61, -60, -59,
-59, -57, -57, -55, -51, -47, -42, -38, -35, -32, -29, -26, -25, -22, -19, -17,
-13, -10, -6, -3, 0, 1, 4, 7, 9, 12, 15, 20, 24, 28, 32, 34, 36, 36, 37, 38, 38,
38, 38, 39, 39, 39, 38, 38, 38, 37, 37, 37, 36, 36, 35, 35, 35, 34, 34, 33, 33,
32, 32, 33, 32, 32, 30, 31, 31, 30, 30, 29, 30, 28, 29, 28, 30, 27, 30, 25, 38,
-20, -115, -118, -120, -118, -119, -118, -119, -118, -118, -118, -118, -118,
-118, -118, -117, -118, -117, -117, -117, -116, -115, -115, -115, -115, -114,
-113, -113, -113, -113, -111, -111, -110, -110, -109, -109, -109, -108, -107,
-106, -106, -105, -104, -104, -103, -102, -101, -100, -100, -100, -99, -97, -96,
-97, -95, -96, -95, -94, -93, -92, -93, -92, -91, -90, -90, -89, -89, -89, -88,
-87, -87, -86, -87, -85, -85, -86, -85, -84, -84, -84, -83, -83, -83, -82, -83,
-83, -81, -82, -82, -81, -80, -81, -80, -80, -80, -80, -80, -80, -80, -79, -78,
-78, -78, -78, -78, -78, -77, -77, -76, -76, -76, -74, -74, -72, -71, -68, -65,
-61, -58, -54, -50, -48, -45, -43, -40, -37, -35, -32, -27, -24, -21, -18, -14,
-12, -9, -5, -3, };