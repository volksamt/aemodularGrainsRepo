#define DATA_LENGTH 512
#define DATA AKWF_0630

const PROGMEM int8_t DATA[DATA_LENGTH] = {20, 41, 66, 81, 34, 30, 41, 28, 26,
17, 11, -5, 3, -2, 1, -2, 3, -9, -17, -14, -15, -14, -9, 4, -2, 2, -1, 0, -1, 1,
0, 0, 0, 0, 0, -1, 1, -1, 1, -1, 1, -1, 0, -1, 4, 17, 14, 17, 16, 19, 18, 19,
18, 19, 17, 18, 11, -3, 2, 0, 1, -1, 0, 0, 0, 0, 0, 1, -1, 1, 0, 1, -1, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, -1, 1, 1, 0, 0, 1, 0, 0, -1, 1, 0, 0, 0, 0, -1, 0, -1, 0,
-1, 1, 0, 0, -1, 0, 0, 0, 1, -1, 1, -1, 2, -3, 4, -18, -25, -29, -32, -29, -25,
-18, -5, 4, -4, 3, -4, 16, 22, 21, 24, 22, 22, 19, 18, 12, -2, 0, 1, -1, 1, -1,
1, -1, 0, -1, 1, -1, 1, -1, 0, -1, 0, -1, -1, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0,
-1, 1, 0, 0, -1, 1, -1, 1, -1, 1, -1, 1, -2, 8, 17, 14, 18, 16, 20, 16, 20, 2,
2, -3, -17, -14, -4, 3, -2, 1, -1, 1, 0, 0, 0, 0, -1, 1, 0, 1, 0, 0, 0, 0, 1, 0,
0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1,
-1, 1, -1, 0, -1, 1, 2, -15, -11, 26, -21, -85, -53, -58, -5, 3, -44, -10, 1, 0,
-2, 8, 25, 34, 49, 67, 40, 17, 29, 19, 18, 3, -2, 1, -1, 2, -1, 1, -1, 1, 0, 0,
-1, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, -1, 0, -1, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 1, -1, 0, 0, 1, 1, 0, 0, 0, 0,
0, -1, 0, 0, 1, 0, 1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 1, -1,
0, 0, 0, 0, 0, 0, 1, 0, -1, 1, 0, 0, -1, 2, -2, 7, 18, 15, 4, 0, 2, -1, 0, -3,
-13, -16, -7, 2, -1, 0, 0, -1, 0, -1, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 1, 1,
0, 1, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 1,
0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 1, 1, 0, 1, 0, 1, 0, 0, -1, 0, 0, 0, 0,
0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 1, 0, 1,
-1, 1, -1, 1, -1, 2, -1, 1, -2, 2, -1, 1, -1, 1, -1, 0, 1, -3, 17, 29, -5, -92,
-64, -61, -20, 13, -37, -12, -1, 2, -1, };