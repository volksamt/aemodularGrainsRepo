#define DATA_LENGTH 512
#define DATA AKWF_0631

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 116, 123, 117, 122, 117,
122, 117, 121, 117, 120, 118, 119, 117, 119, 117, 117, 117, 116, 115, 115, 113,
112, 111, 108, 107, 106, 103, 100, 98, 94, 92, 88, 84, 81, 76, 72, 68, 64, 59,
53, 50, 45, 39, 34, 30, 25, 19, 16, 10, 7, 2, -1, -6, -6, -12, -13, -16, -16,
-20, -18, -20, -8, 47, 51, 49, 50, 48, 47, 42, 37, 26, 17, 3, -5, -16, -20, -22,
-9, 18, 21, 21, 21, 19, 18, 13, 7, -2, -11, -25, -35, -45, -51, -54, -42, 9, 25,
21, 22, 22, 23, 22, 22, 21, 21, 19, 18, 14, 14, 8, 5, -2, -6, -14, -20, -30,
-37, -47, -52, -63, -67, -78, -78, -87, -84, -93, -58, 84, 90, 85, 90, 87, 90,
85, 89, 85, 87, 83, 84, 79, 78, 72, 69, 62, 57, 48, 42, 33, 25, 16, 9, 1, -6,
-12, -16, -21, -22, -24, -10, 41, 55, 52, 54, 52, 51, 47, 41, 33, 23, 10, -1,
-12, -18, -20, -17, 8, 23, 20, 22, 19, 19, 14, 12, 0, -6, -22, -31, -45, -48,
-58, -29, 82, 86, 84, 87, 83, 86, 83, 86, 83, 84, 80, 81, 76, 75, 69, 66, 59,
54, 46, 40, 31, 24, 15, 8, 1, -6, -12, -16, -21, -22, -23, -10, 41, 55, 52, 54,
52, 51, 46, 42, 33, 23, 10, -1, -11, -18, -22, -17, 9, 23, 18, 22, 18, 19, 13,
11, 0, -8, -24, -32, -48, -50, -61, -27, 88, 89, 88, 89, 87, 89, 86, 88, 86, 87,
83, 83, 79, 77, 71, 68, 61, 56, 48, 42, 32, 25, 15, 9, 0, -6, -12, -16, -21,
-22, -23, -8, 42, 56, 52, 54, 52, 51, 46, 42, 32, 22, 10, -1, -11, -19, -21,
-17, 9, 22, 20, 22, 18, 20, 14, 11, 1, -6, -19, -29, -41, -45, -53, -35, 19, 18,
19, 19, 19, 20, 19, 19, 18, 19, 19, 19, 19, 20, 18, 18, 17, 17, 17, 16, 15, 14,
14, 12, 11, 8, 8, 5, 3, 1, -3, -6, -8, -12, -16, -19, -23, -28, -32, -37, -41,
-47, -52, -56, -61, -66, -72, -75, -81, -85, -90, -93, -99, -101, -106, -106,
-113, -111, -118, -114, -123, -113, -126, -75, 61, 56, 57, 58, 55, 54, 47, 41,
29, 20, 4, -5, -17, -18, -23, -5, 19, 22, 20, 21, 20, 18, 12, 7, -3, -13, -26,
-37, -47, -52, -54, -36, 15, 24, 22, 23, 22, 22, 22, 21, 21, 20, 18, 17, 15, 13,
9, 4, -2, -7, -14, -20, -31, -36, -46, -51, -62, -65, -76, -75, -86, -81, -91,
-47, 58, 53, 55, 53, 51, 51, 44, 40, 27, 17, 3, -5, -17, -20, -22, -4, 19, 22,
20, 21, 19, 17, 12, 7, -4, -14, -27, -36, -48, -51, -55, -34, 14, 24, 21, 23,
21, 23, 22, 22, 21, 21, 19, 18, 16, 12, 8, 3, -2, -8, -16, -23, -30, -39, -47,
-56, -63, -69, -77, -81, -86, -86, -90, -45, };