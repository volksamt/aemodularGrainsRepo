#define DATA_LENGTH 512
#define DATA AKWF_0628

const PROGMEM int8_t DATA[DATA_LENGTH] = {30, 38, 37, 40, 38, 41, 42, 43, 43,
45, 46, 47, 48, 49, 51, 52, 53, 54, 55, 56, 57, 57, 59, 61, 61, 62, 64, 64, 66,
67, 68, 69, 70, 70, 72, 73, 74, 75, 77, 77, 79, 80, 80, 82, 83, 84, 85, 87, 88,
88, 90, 91, 91, 94, 95, 95, 96, 98, 99, 99, 100, 102, 102, 104, 105, 107, 108,
109, 109, 111, 111, 113, 114, 115, 116, 117, 118, 116, 94, 75, 57, 5, -2, 2, -1,
1, -1, 1, -1, 1, 0, 0, -1, 1, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1,
0, 0, 0, 0, 0, 0, 1, 0, 1, 0, -1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 0,
0, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0,
0, 0, 0, 1, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1,
0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0,
0, 0, 0, 1, -1, 1, 0, 0, -1, 0, 0, 1, 0, 0, -1, 1, -2, -34, -37, -36, -39, -40,
-41, -41, -43, -43, -46, -45, -48, -48, -50, -50, -52, -53, -53, -54, -56, -57,
-58, -59, -60, -61, -62, -63, -64, -67, -67, -68, -70, -70, -71, -72, -74, -74,
-75, -76, -78, -79, -80, -81, -82, -84, -84, -85, -86, -88, -89, -89, -90, -92,
-93, -94, -95, -96, -98, -99, -99, -101, -102, -102, -105, -105, -107, -107,
-109, -109, -110, -111, -113, -113, -115, -116, -117, -119, -115, -91, -75, -51,
-1, 1, -1, 1, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, -1, 0, -1, 0, -1, 0, 0, 1, 1,
0, 0, 0, 0, -1, -1, -1, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 1, -1, 0, 1, 0, 0, 0,
0, -1, -1, 0, 1, 0, 0, 1, -1, -1, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0,
-1, -1, 1, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 1, 0, -1, 1,
0, 0, 0, -1, -1, -1, 1, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 1, -1, 0,
1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 1, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, -1, 0, 0, };