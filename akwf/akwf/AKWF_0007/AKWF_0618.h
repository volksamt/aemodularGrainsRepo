#define DATA_LENGTH 512
#define DATA AKWF_0618

const PROGMEM int8_t DATA[DATA_LENGTH] = {101, 127, 112, 126, 112, 127, 103, 0,
-1, 3, -2, 3, -2, 3, -2, 2, -1, 2, -2, 2, 0, 2, 0, 1, -1, 1, 0, 0, 0, 1, 1, -1,
1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, -1, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0,
-1, -1, 0, 0, -1, 0, 0, -1, 0, 0, 0, -1, 0, -1, 0, -1, -1, -1, 0, 0, -1, 0, -1,
-1, 0, -1, 0, -1, -1, -1, 0, 0, 0, 0, -1, -1, 0, -1, -1, -1, 0, 0, -1, -1, -1,
-1, 0, 0, 0, -1, -1, -1, -1, -1, -1, 0, -1, 0, 0, 0, -1, 0, -1, -1, -1, -1, -1,
-1, -1, -1, -1, -1, -1, 0, 0, -1, 0, 0, 0, -1, -2, -1, -1, -1, -1, -1, -1, -1,
-2, -1, -1, -1, -2, -1, -1, -1, -1, -1, -1, -1, -2, -1, -2, -2, -1, -1, -1, -1,
-1, -2, -1, -1, -1, -1, -1, -1, -2, -2, -1, -2, -1, -2, -1, -2, -2, -2, -1, -2,
-1, -2, -2, -1, -1, -2, -1, -1, -2, -2, -2, -1, -1, -2, -2, -1, -1, -1, -1, -1,
-1, -1, -1, -1, -1, -2, -1, -1, -2, -2, -2, -2, -1, -2, -2, -2, -1, -2, -1, -2,
-1, -2, -1, -2, -2, -1, -2, -2, -1, -1, -2, -1, -2, -2, -1, -2, -1, -2, -2, -2,
-1, -2, -2, -2, -2, -1, -2, -2, -2, -2, -1, -2, -2, -2, -3, -2, -2, -1, -2, -2,
-2, -2, -2, -1, -2, -1, -1, -2, -2, -1, -2, -2, -2, -1, -2, -2, -2, -2, -2, -2,
-1, -1, -2, -2, -2, -2, -2, -1, -2, -2, -1, -3, -1, -1, -2, -3, -2, -2, -1, -1,
-2, -2, -3, -1, -2, -2, -2, -1, -1, -2, -1, -2, -2, -1, -2, -1, -2, -2, -1, -3,
-2, -2, -2, -1, -2, -2, -1, -1, -2, -1, -2, -2, -2, -1, -2, -1, -2, -1, -2, -2,
-2, -3, -2, -2, -1, -1, -1, -1, -2, -2, -2, -1, -2, -2, -2, -2, -2, -1, -2, -1,
-2, -1, -2, -2, -2, -2, -1, -2, -1, -1, -3, -2, -1, -1, -1, -1, -2, -2, -1, -1,
-1, -1, -1, -1, -1, -2, -2, -2, -1, -2, -1, -1, -2, -2, -2, -1, -1, -2, -1, -2,
-1, -1, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -1, -2, -1, -2, -2, -1,
-2, -1, -1, -1, -1, -2, -2, -2, -1, -1, -1, -2, -1, 0, -1, -2, -1, -1, -2, -1,
-1, -1, -1, -1, -1, 0, -1, -2, -1, -1, -2, -1, -1, -1, -1, -1, -1, -1, -1, -1,
-1, -2, -2, -1, 0, -2, -1, -2, -1, -1, -1, -1, -1, -2, -1, -1, -1, -2, -1, -2,
-1, -1, -2, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, 0, -1, -1, -1, 0, 0, -1,
0, -1, -1, -1, -1, -1, };