#define DATA_LENGTH 512
#define DATA AKWF_0699

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 14, 20, 26, 31, 35, 38, 41, 45, 47,
49, 51, 53, 55, 57, 59, 60, 61, 63, 64, 65, 67, 68, 68, 70, 72, 72, 74, 74, 75,
75, 76, 77, 78, 79, 80, 80, 81, 82, 82, 82, 83, 84, 84, 85, 85, 86, 86, 87, 86,
87, 88, 88, 89, 89, 89, 89, 90, 90, 90, 91, 91, 90, 92, 91, 91, 90, 92, 92, 92,
92, 92, 92, 93, 91, 93, 92, 93, 93, 93, 88, 29, 13, 13, 5, 5, 0, 0, -5, -4, -8,
-8, -10, -10, -13, -13, -15, -15, -16, -17, -17, -18, -19, -20, -20, -22, -22,
-22, -23, -24, -24, -25, -26, -26, -26, -28, -27, -28, -28, -29, -29, -30, -30,
-29, -30, -31, -31, -31, -31, -32, -32, -33, -33, -32, -33, -33, -34, -34, -33,
-34, -35, -35, -34, -35, -35, -36, -35, -36, -36, -36, -36, -36, -36, -35, -37,
-36, -37, -36, -36, -37, -37, -36, -37, -36, -37, -35, -38, -35, -38, -22, 10,
10, 14, 14, 18, 19, 20, 21, 22, 23, 23, 25, 25, 26, 26, 27, 28, 28, 28, 29, 29,
30, 30, 30, 30, 31, 31, 31, 32, 32, 32, 32, 34, 32, 33, 32, 34, 33, 34, 33, 34,
34, 34, 33, 33, 34, 33, 32, -16, -41, -40, -47, -48, -52, -52, -56, -56, -58,
-60, -60, -62, -63, -64, -65, -65, -67, -68, -69, -69, -69, -70, -70, -71, -72,
-73, -73, -73, -73, -74, -74, -75, -75, -75, -76, -76, -76, -76, -76, -76, -77,
-77, -78, -77, -79, -76, -78, -76, -79, -76, -80, -76, -80, -75, -84, -67, 2,
11, 17, 20, 24, 29, 30, 33, 33, 36, 37, 40, 41, 42, 43, 45, 45, 47, 47, 49, 49,
50, 50, 52, 52, 53, 53, 54, 55, 55, 56, 56, 57, 57, 57, 57, 58, 58, 60, 59, 60,
59, 61, 61, 60, 61, 61, 61, 62, 62, 61, 63, 62, 63, 62, 63, 62, 63, 62, 64, 62,
64, 62, 65, 62, 65, 62, 66, 62, -19, -51, -50, -60, -61, -68, -68, -72, -73,
-77, -79, -80, -82, -84, -85, -87, -87, -89, -90, -92, -93, -93, -95, -96, -96,
-97, -99, -100, -100, -101, -101, -102, -103, -103, -104, -104, -105, -106,
-106, -106, -107, -107, -107, -108, -109, -109, -110, -110, -111, -111, -111,
-111, -112, -112, -112, -113, -112, -112, -113, -113, -113, -114, -114, -114,
-115, -114, -115, -115, -116, -116, -116, -116, -116, -116, -117, -116, -117,
-116, -117, -117, -117, -117, -117, -118, -117, -118, -118, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -118, -119, -118, -119, -119, -119, -118,
-118, -119, -119, -118, -118, -119, -118, -119, -119, -119, -119, -118, -118,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -120, -119, -120, -119, -119, -112,
-98, -82, -65, -50, -35, -24, -15, -10, -6, -5, -3, -2, -1, -2, -2, -3, -3, -3,
-3, -2, -3, -2, -2, -2, -3, -3, };