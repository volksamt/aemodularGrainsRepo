#define DATA_LENGTH 512
#define DATA AKWF_0620

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 6, 9, 11, 13, 15, 17, 19, 21,
23, 25, 27, 28, 30, 32, 34, 36, 37, 40, 42, 43, 45, 47, 48, 50, 52, 52, 53, 55,
57, 58, 60, 61, 62, 65, 66, 67, 69, 70, 71, 73, 73, 75, 76, 78, 79, 80, 82, 82,
83, 84, 85, 86, 88, 89, 90, 91, 92, 93, 94, 95, 95, 96, 97, 97, 98, 99, 100,
101, 102, 103, 104, 104, 105, 106, 106, 107, 107, 108, 109, 110, 110, 111, 111,
112, 113, 112, 113, 113, 114, 115, 115, 115, 115, 115, 116, 117, 117, 118, 118,
118, 117, 118, 119, 118, 119, 118, 119, 120, 119, 119, 119, 118, 120, 113, 110,
106, 103, 101, 98, 96, 94, 92, 90, 88, 86, 85, 83, 80, 80, 78, 77, 74, 73, 71,
70, 68, 67, 65, 64, 62, 61, 59, 58, 57, 56, 55, 53, 52, 51, 50, 48, 47, 46, 45,
43, 42, 41, 40, 38, 38, 37, 36, 35, 34, 33, 31, 30, 30, 28, 27, 27, 26, 24, 23,
23, 21, 21, 18, 18, 17, 16, 14, 14, 13, 12, 11, 11, 9, 8, 7, 6, 6, 5, 4, 3, 2,
1, 1, 0, -2, -2, -3, -4, -4, -5, -6, -7, -8, -9, -9, -10, -11, -13, -13, -14,
-14, -15, -16, -17, -19, -18, -19, -21, -20, -22, -23, -23, -25, -25, -25, -27,
-27, -29, -30, -30, -30, -32, -32, -33, -33, -34, -35, -36, -37, -37, -38, -39,
-39, -39, -40, -42, -41, -43, -43, -43, -44, -45, -46, -47, -47, -48, -48, -49,
-50, -50, -51, -52, -53, -53, -53, -54, -55, -56, -56, -56, -57, -58, -59, -60,
-60, -61, -60, -62, -62, -63, -63, -63, -64, -65, -65, -67, -67, -68, -68, -68,
-69, -70, -70, -71, -72, -72, -71, -72, -73, -74, -74, -75, -75, -76, -77, -77,
-77, -78, -79, -79, -80, -81, -81, -81, -82, -81, -82, -83, -84, -84, -85, -85,
-85, -85, -86, -87, -87, -88, -88, -89, -90, -89, -90, -91, -91, -91, -92, -91,
-93, -93, -94, -91, -91, -91, -90, -90, -91, -91, -91, -91, -91, -92, -91, -91,
-92, -92, -92, -92, -93, -94, -93, -94, -94, -94, -95, -95, -96, -95, -96, -96,
-97, -97, -97, -98, -99, -98, -99, -99, -99, -100, -100, -100, -101, -101, -101,
-102, -101, -102, -103, -103, -102, -103, -104, -105, -105, -105, -105, -106,
-106, -106, -107, -107, -106, -107, -108, -108, -108, -109, -109, -109, -110,
-110, -110, -110, -110, -111, -111, -111, -111, -111, -112, -112, -111, -113,
-113, -113, -113, -113, -113, -114, -114, -115, -115, -115, -115, -115, -116,
-115, -115, -115, -116, -116, -116, -116, -116, -117, -117, -117, -117, -117,
-117, -117, -118, -118, -117, -117, -117, -118, -117, -118, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -118, -120, -113, -102, -96, -90, -86, -80,
-76, -73, -69, -65, -62, -58, -54, -52, -48, -45, -42, -39, -36, -33, -32, -28,
-26, -22, -21, -18, -16, -13, -11, -8, -6, -4, -2, };