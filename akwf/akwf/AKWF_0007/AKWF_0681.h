#define DATA_LENGTH 512
#define DATA AKWF_0681

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 8, 10, 13, 15, 18, 21, 24,
27, 31, 34, 36, 41, 44, 47, 50, 53, 55, 60, 63, 66, 69, 71, 74, 76, 76, 79, 79,
81, 81, 81, 80, 80, 79, 78, 76, 75, 73, 71, 68, 65, 63, 61, 59, 56, 54, 52, 50,
47, 45, 43, 43, 41, 40, 39, 39, 40, 40, 40, 42, 42, 45, 47, 48, 51, 51, 54, 55,
57, 59, 59, 60, 60, 61, 60, 60, 60, 59, 58, 58, 57, 56, 55, 54, 54, 54, 54, 55,
54, 54, 53, 52, 52, 51, 51, 50, 48, 47, 45, 43, 42, 41, 40, 37, 36, 34, 33, 31,
30, 28, 27, 25, 24, 21, 19, 17, 13, 11, 8, 5, 1, 0, -3, -7, -9, -10, -13, -14,
-15, -16, -17, -18, -18, -18, -18, -18, -19, -18, -17, -16, -16, -15, -14, -12,
-12, -10, -8, -6, -4, -3, 0, 3, 7, 11, 13, 18, 22, 24, 28, 32, 36, 39, 44, 47,
50, 54, 56, 59, 59, 62, 61, 62, 62, 61, 60, 58, 56, 54, 51, 48, 44, 42, 38, 35,
32, 28, 24, 21, 18, 16, 14, 11, 9, 8, 6, 5, 5, 3, 2, 2, 1, 0, -1, -3, -5, -6,
-8, -9, -11, -12, -13, -15, -16, -16, -18, -19, -19, -20, -20, -19, -20, -19,
-19, -18, -17, -15, -15, -13, -12, -11, -9, -8, -7, -4, -3, -1, 0, 2, 3, 6, 9,
10, 14, 16, 19, 21, 24, 27, 30, 31, 35, 37, 39, 41, 43, 46, 47, 50, 51, 53, 55,
57, 58, 60, 61, 62, 64, 63, 65, 65, 65, 65, 65, 63, 63, 62, 61, 59, 58, 56, 55,
52, 50, 48, 47, 44, 42, 40, 38, 37, 36, 35, 35, 34, 34, 34, 34, 33, 33, 33, 33,
32, 31, 29, 27, 26, 23, 20, 19, 15, 12, 8, 5, 1, -2, -7, -10, -13, -16, -19,
-22, -25, -25, -28, -30, -30, -31, -31, -31, -31, -30, -31, -30, -29, -29, -28,
-27, -27, -27, -26, -26, -26, -25, -25, -27, -27, -28, -27, -28, -29, -30, -30,
-31, -32, -32, -32, -32, -34, -36, -36, -36, -37, -38, -39, -40, -41, -42, -41,
-42, -43, -43, -43, -45, -45, -46, -46, -47, -48, -49, -49, -50, -51, -52, -53,
-54, -55, -56, -57, -59, -59, -59, -60, -61, -61, -62, -62, -62, -62, -61, -61,
-61, -60, -60, -59, -58, -57, -57, -56, -55, -54, -55, -54, -55, -55, -55, -56,
-57, -58, -59, -61, -64, -66, -69, -72, -74, -78, -81, -84, -87, -90, -93, -96,
-99, -102, -104, -106, -108, -111, -113, -114, -115, -116, -117, -118, -119,
-119, -119, -119, -118, -118, -116, -115, -113, -110, -108, -105, -102, -99,
-94, -90, -86, -82, -77, -73, -67, -63, -58, -53, -50, -44, -40, -36, -31, -28,
-23, -19, -16, -12, -10, -5, -2, 0, 3, 4, 6, 8, 8, 9, 9, 9, 8, 8, 6, 5, 3, 3, 1,
0, -1, -3, -4, -4, -4, -5, -4, -4, -3, -2, -1, -1, };