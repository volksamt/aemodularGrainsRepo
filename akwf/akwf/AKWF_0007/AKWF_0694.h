#define DATA_LENGTH 512
#define DATA AKWF_0694

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 30, 46, 60, 72, 81, 90, 98, 103,
108, 112, 114, 116, 117, 116, 115, 113, 111, 106, 103, 97, 92, 85, 79, 72, 65,
59, 53, 47, 41, 36, 29, 26, 20, 16, 12, 8, 5, 3, 0, -2, -4, -7, -7, -9, -11,
-14, -15, -17, -18, -20, -23, -26, -28, -30, -33, -36, -38, -40, -42, -44, -44,
-44, -42, -38, -33, -27, -19, -10, 1, 13, 26, 39, 54, 67, 80, 91, 102, 110, 115,
118, 119, 118, 112, 107, 97, 87, 73, 60, 47, 33, 19, 5, -7, -19, -30, -39, -47,
-53, -57, -61, -62, -62, -61, -59, -56, -53, -47, -42, -36, -31, -26, -21, -15,
-10, -4, 1, 6, 9, 12, 16, 19, 22, 23, 26, 27, 27, 29, 29, 30, 30, 30, 31, 32,
31, 31, 32, 32, 33, 34, 33, 33, 33, 31, 31, 30, 27, 27, 24, 22, 19, 16, 13, 10,
7, 3, 0, -2, -5, -9, -10, -12, -14, -16, -19, -20, -22, -22, -25, -25, -25, -26,
-25, -30, -49, -66, -76, -84, -88, -90, -91, -88, -85, -79, -74, -67, -60, -53,
-46, -38, -32, -26, -20, -15, -11, -6, -2, -1, 1, 3, 5, 5, 4, 4, 3, 2, 1, 0, -1,
-2, -4, -6, -6, -8, -8, -8, -9, -9, -10, -9, -9, -9, -8, -7, -6, -6, -5, -4, -4,
-3, -3, -4, -4, -4, -5, -6, -7, -8, -8, -7, -7, -8, -8, -7, -7, -7, -7, -7, -7,
-7, -8, -8, -8, -7, -8, -8, -7, -7, -8, -7, -7, -7, -7, -7, -7, -7, -8, -8, -7,
-6, -8, -7, -7, -8, -8, -7, -8, -7, -7, -7, -7, -8, -7, -7, -7, -8, -7, -7, -7,
-7, -7, -7, -7, -7, -7, -7, -8, -7, -8, -7, -7, -8, -7, -7, -7, -7, -7, -7, -7,
-8, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -8, -7, -7, -7, -8, -8, -7, -8, -7,
-7, -7, -7, -7, -8, -8, -7, -7, -7, -7, -8, -7, -8, -7, -7, -7, -7, -7, -7, -7,
-7, -7, -8, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -6, -8, -8, -8, -7, -7, -8,
-7, -7, -7, -7, -7, -7, -7, -8, -7, -8, -8, -8, -7, -7, -7, -7, -7, -8, -6, -7,
-8, -7, -7, -7, -7, -7, -7, -7, -8, -7, -7, -8, -7, -7, -8, -7, -7, -7, -7, -7,
-7, -7, -6, -7, -7, -7, -7, -7, -7, -8, -7, -8, -7, -6, -7, -7, -7, -7, -7, -8,
-7, -7, -7, -7, -6, -7, -6, -7, -8, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7,
-7, -7, -7, -7, -8, -7, -6, -7, -7, -8, -7, -7, -7, -7, -7, -7, -7, -7, -7, -8,
-7, -7, -7, -6, -7, -8, -8, -7, -7, -7, -7, -7, -7, -7, -7, -8, -7, -7, -7, -8,
-7, -8, -7, -7, -7, -7, -7, -7, -7, -6, -7, -8, -7, -7, -7, -7, -7, -7, -7, -7,
-7, -7, -4, };