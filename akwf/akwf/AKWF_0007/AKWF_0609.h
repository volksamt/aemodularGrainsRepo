#define DATA_LENGTH 512
#define DATA AKWF_0609

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 10, 14, 17, 22, 25, 29, 33, 36,
40, 43, 47, 51, 54, 58, 62, 65, 68, 72, 75, 77, 81, 84, 86, 90, 92, 94, 96, 98,
101, 103, 105, 108, 109, 111, 112, 113, 115, 115, 116, 117, 118, 118, 119, 119,
119, 119, 119, 119, 119, 118, 119, 119, 118, 119, 119, 118, 118, 118, 117, 116,
115, 115, 113, 111, 110, 109, 107, 104, 101, 97, 94, 90, 87, 82, 76, 72, 67, 62,
56, 51, 45, 40, 34, 29, 24, 19, 16, 11, 8, 4, 1, -1, -3, -4, -5, -5, -5, -4, -4,
-5, -4, -3, -2, 1, 5, 10, 17, 23, 32, 42, 52, 63, 73, 83, 92, 98, 104, 106, 107,
106, 105, 106, 106, 106, 107, 106, 106, 106, 105, 104, 103, 102, 101, 100, 97,
95, 91, 87, 83, 79, 74, 68, 63, 57, 49, 42, 36, 28, 21, 15, 8, 1, -5, -11, -16,
-19, -23, -25, -27, -27, -28, -27, -27, -27, -23, -20, -13, -5, 4, 13, 19, 22,
22, 22, 22, 21, 21, 22, 21, 21, 22, 22, 22, 21, 21, 20, 20, 20, 18, 18, 16, 16,
14, 11, 10, 8, 5, 2, -1, -4, -8, -12, -16, -20, -24, -29, -34, -38, -43, -48,
-53, -57, -62, -66, -69, -73, -75, -79, -81, -83, -83, -85, -85, -85, -85, -85,
-85, -86, -84, -84, -84, -85, -83, -83, -83, -82, -80, -79, -78, -75, -72, -68,
-65, -60, -54, -48, -43, -35, -28, -21, -13, -4, 4, 12, 20, 28, 37, 44, 50, 58,
63, 67, 71, 73, 75, 76, 75, 76, 75, 76, 75, 74, 74, 72, 69, 66, 62, 56, 49, 40,
33, 24, 16, 8, 1, -4, -7, -9, -9, -9, -9, -7, -4, 0, 7, 17, 27, 36, 43, 45, 47,
45, 46, 46, 45, 45, 46, 46, 46, 45, 46, 45, 45, 45, 45, 45, 45, 46, 46, 46, 46,
45, 46, 45, 44, 44, 45, 45, 44, 44, 45, 44, 43, 43, 43, 42, 41, 41, 41, 40, 39,
39, 37, 36, 36, 34, 34, 33, 31, 30, 29, 27, 26, 24, 23, 21, 18, 17, 14, 14, 11,
9, 6, 3, 1, -1, -4, -6, -9, -12, -15, -17, -21, -24, -27, -30, -33, -36, -39,
-42, -45, -48, -51, -55, -57, -60, -63, -67, -69, -73, -76, -78, -80, -84, -87,
-90, -92, -94, -97, -99, -101, -102, -105, -107, -109, -110, -111, -112, -113,
-114, -115, -115, -116, -117, -116, -117, -117, -116, -116, -116, -117, -116,
-117, -116, -117, -116, -117, -116, -116, -116, -116, -116, -116, -116, -116,
-116, -116, -116, -116, -116, -116, -116, -115, -115, -115, -115, -115, -114,
-114, -114, -114, -114, -113, -113, -113, -112, -112, -111, -111, -110, -109,
-109, -108, -107, -106, -105, -105, -104, -103, -102, -101, -99, -98, -96, -96,
-94, -92, -90, -89, -87, -85, -83, -81, -79, -77, -75, -72, -69, -67, -65, -62,
-60, -57, -53, -51, -48, -45, -42, -39, -35, -32, -29, -24, -22, -19, -15, -11,
-8, -5, -1, };