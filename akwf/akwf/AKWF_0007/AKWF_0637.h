#define DATA_LENGTH 512
#define DATA AKWF_0637

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 9, 15, 20, 26, 32, 37, 42, 47, 53,
58, 63, 67, 72, 77, 82, 86, 89, 94, 98, 100, 104, 107, 110, 112, 114, 115, 117,
118, 119, 119, 119, 119, 118, 118, 116, 115, 112, 111, 109, 106, 103, 99, 95,
93, 88, 85, 81, 75, 71, 66, 62, 57, 52, 47, 41, 37, 32, 26, 22, 17, 12, 7, 2,
-2, -7, -12, -15, -19, -23, -26, -30, -32, -35, -38, -40, -42, -44, -46, -48,
-49, -51, -51, -51, -52, -52, -50, -51, -50, -50, -48, -47, -46, -43, -42, -40,
-38, -36, -34, -32, -30, -27, -24, -22, -19, -17, -13, -12, -10, -6, -4, -2, 1,
3, 5, 8, 9, 11, 12, 15, 15, 17, 18, 19, 19, 20, 21, 21, 21, 22, 21, 22, 20, 20,
19, 19, 17, 16, 16, 13, 12, 11, 10, 8, 6, 5, 2, 1, 0, -3, -5, -7, -8, -11, -13,
-14, -15, -17, -19, -20, -21, -23, -24, -26, -28, -29, -29, -30, -31, -31, -32,
-33, -33, -33, -33, -33, -33, -33, -32, -31, -31, -31, -29, -28, -27, -26, -24,
-24, -23, -21, -20, -19, -17, -15, -13, -11, -10, -8, -7, -5, -4, -3, 0, 2, 3,
4, 6, 7, 8, 10, 10, 12, 13, 14, 16, 15, 16, 17, 18, 17, 18, 18, 20, 19, 18, 20,
19, 19, 19, 18, 18, 17, 17, 16, 16, 15, 14, 13, 13, 11, 10, 9, 8, 7, 7, 5, 4, 3,
3, 2, 1, 0, -1, -3, -4, -4, -4, -6, -5, -6, -7, -8, -7, -8, -8, -9, -9, -9, -8,
-8, -8, -8, -8, -8, -8, -7, -7, -6, -6, -6, -5, -4, -4, -2, -2, 0, 0, 2, 1, 3,
4, 4, 5, 6, 7, 9, 9, 9, 10, 11, 12, 12, 14, 13, 15, 15, 15, 16, 16, 17, 17, 17,
17, 17, 18, 18, 18, 17, 17, 17, 17, 17, 17, 16, 15, 16, 14, 13, 13, 12, 11, 11,
11, 9, 8, 8, 8, 6, 5, 4, 3, 2, 2, 0, 0, -3, -4, -4, -5, -5, -6, -8, -9, -10,
-10, -10, -12, -13, -13, -14, -14, -15, -15, -16, -16, -17, -18, -19, -19, -18,
-19, -19, -19, -20, -20, -20, -20, -20, -19, -19, -19, -18, -18, -18, -19, -18,
-17, -17, -17, -17, -16, -15, -15, -15, -14, -14, -13, -11, -11, -11, -11, -9,
-8, -9, -6, -6, -6, -5, -5, -3, -3, -2, -2, -1, 0, 0, 2, 2, 3, 4, 3, 5, 6, 6, 6,
6, 7, 7, 8, 7, 7, 8, 8, 8, 8, 6, 6, 6, 6, 4, 3, 3, 2, 2, 0, -1, -2, -4, -4, -7,
-7, -10, -11, -14, -15, -16, -19, -21, -23, -25, -28, -30, -33, -34, -38, -39,
-42, -44, -46, -49, -51, -54, -55, -57, -59, -61, -63, -65, -66, -67, -68, -70,
-71, -71, -72, -72, -73, -72, -72, -71, -70, -69, -67, -66, -64, -62, -60, -58,
-54, -51, -48, -45, -41, -37, -34, -29, -25, -21, -15, -10, -5, 0, };