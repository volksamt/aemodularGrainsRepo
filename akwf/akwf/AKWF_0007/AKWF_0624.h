#define DATA_LENGTH 512
#define DATA AKWF_0624

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 10, 16, 20, 26, 31, 36, 41, 45,
51, 55, 59, 64, 68, 72, 76, 79, 82, 85, 88, 90, 91, 93, 94, 94, 95, 94, 94, 95,
94, 95, 95, 94, 95, 94, 94, 94, 93, 93, 93, 93, 90, 90, 88, 86, 85, 82, 79, 75,
72, 68, 63, 58, 51, 45, 39, 32, 24, 16, 8, -1, -10, -18, -27, -35, -44, -53,
-61, -69, -77, -84, -90, -95, -101, -105, -108, -111, -113, -114, -113, -113,
-113, -113, -113, -113, -113, -113, -113, -113, -114, -113, -114, -113, -113,
-114, -113, -113, -112, -112, -112, -111, -112, -111, -111, -109, -109, -108,
-108, -106, -105, -103, -102, -101, -99, -97, -94, -93, -91, -89, -85, -83, -82,
-78, -75, -72, -69, -65, -62, -58, -55, -52, -49, -44, -42, -38, -34, -31, -28,
-25, -22, -19, -16, -13, -10, -8, -5, -3, -2, 1, 2, 3, 3, 4, 5, 5, 5, 5, 5, 2,
1, -2, -2, -3, -3, -2, -3, -3, -3, -2, -2, -1, 0, 1, 3, 4, 6, 9, 12, 13, 17, 19,
22, 24, 26, 28, 28, 28, 29, 28, 28, 28, 27, 26, 22, 17, 10, 1, -10, -22, -35,
-48, -61, -71, -79, -83, -84, -82, -83, -83, -83, -84, -84, -84, -83, -83, -83,
-83, -84, -82, -83, -83, -83, -82, -82, -83, -82, -82, -80, -80, -79, -79, -77,
-76, -75, -74, -72, -70, -69, -67, -65, -62, -60, -57, -54, -52, -48, -44, -41,
-37, -33, -29, -25, -21, -16, -11, -7, -2, 3, 8, 13, 17, 23, 28, 32, 36, 41, 46,
51, 54, 59, 62, 66, 69, 72, 75, 78, 80, 82, 84, 85, 85, 87, 87, 87, 87, 87, 86,
87, 86, 86, 87, 87, 86, 86, 86, 86, 85, 84, 83, 81, 79, 77, 75, 72, 69, 65, 62,
56, 51, 46, 40, 33, 26, 18, 10, 3, -6, -15, -23, -32, -42, -50, -59, -67, -75,
-82, -89, -96, -102, -107, -111, -114, -116, -118, -119, -119, -119, -118, -120,
-119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -118, -118, -119, -118, -118, -118, -118, -118, -117,
-116, -117, -116, -116, -116, -115, -115, -115, -114, -113, -112, -111, -110,
-110, -108, -107, -106, -105, -104, -103, -101, -99, -98, -97, -94, -93, -91,
-90, -88, -85, -82, -80, -78, -76, -74, -71, -69, -66, -63, -61, -58, -55, -54,
-50, -48, -44, -42, -39, -37, -34, -32, -29, -25, -23, -21, -18, -15, -14, -11,
-9, -6, -4, -2, -1, 1, 3, 4, 6, 7, 8, 9, 11, 12, 12, 13, 13, 14, 13, 13, 13, 13,
13, 12, 12, 8, 3, -3, -11, -23, -35, -48, -60, -70, -78, -83, -84, -83, -83,
-84, -84, -84, -83, -83, -84, -84, -84, -83, -83, -84, -83, -84, -82, -83, -82,
-82, -81, -81, -81, -79, -80, -78, -78, -76, -75, -74, -72, -70, -69, -67, -64,
-62, -59, -56, -53, -50, -46, -43, -40, -36, -31, -27, -23, -19, -13, -8, -3, };