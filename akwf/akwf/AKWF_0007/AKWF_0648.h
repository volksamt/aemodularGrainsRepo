#define DATA_LENGTH 512
#define DATA AKWF_0648

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 1, -1, 0, -1, 1, -1, 2, -4, 25,
111, 89, 21, -24, -59, -72, -76, -69, -58, -42, -26, -10, 5, 17, 24, 30, 33, 32,
31, 27, 24, 19, 13, 8, 4, 0, -4, -7, -8, -10, -10, -9, -10, -8, -9, -5, -6, 64,
113, 58, 7, -32, -55, -68, -68, -62, -50, -36, -21, -8, 4, 14, 21, 26, 28, 29,
27, 24, 21, 17, 12, 7, 3, 1, -3, -5, -7, -7, -8, -8, -8, -7, -7, -6, -5, -3, -2,
-3, 0, 0, 0, 0, 1, 1, 2, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 0, 0, 0, -1, 1, 0, 0,
0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, -1, -1, 0, 1, 0, -1, 0, 0,
-1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -3, -7, -9, -9,
-8, -7, -4, -1, 2, 4, 6, 6, 6, 6, 6, 5, 3, 3, 1, 0, -1, -1, -2, -2, -2, -2, -3,
-3, -3, -3, -1, -1, -2, -1, -1, 0, 0, 0, 0, -1, 1, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0,
0, -1, 0, 0, -1, -1, 0, 0, 0, -1, 0, 0, 0, 2, 2, 1, 0, 0, 0, -1, -1, -1, -2, -1,
-1, -1, -1, 0, -1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, -1, 1,
0, 1, 0, 1, 0, 1, -3, 4, -32, -107, -75, -14, 28, 58, 69, 72, 64, 53, 36, 22, 7,
-6, -17, -25, -30, -31, -31, -29, -25, -21, -16, -12, -7, -3, 2, 4, 7, 8, 10,
10, 9, 9, 8, 7, 6, 2, -75, -114, -52, -3, 38, 59, 70, 69, 63, 50, 36, 21, 7, -6,
-15, -22, -28, -29, -29, -28, -25, -20, -16, -13, -8, -4, -1, 3, 5, 7, 7, 8, 8,
8, 7, 6, 5, 5, 4, 3, 2, 1, 0, 0, 0, -1, 0, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1,
0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 1, 1, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 1, 0, 0,
3, 7, 10, 10, 8, 7, 3, 0, -3, -4, -6, -7, -7, -6, -6, -5, -4, -2, -1, 0, 1, 2,
1, 3, 3, 3, 4, 4, 2, 2, 2, 1, 2, 0, 0, 0, -1, 1, 0, 0, 0, -1, 0, -1, 1, -1, 0,
0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 1,
-1, 0, 1, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1,
-1, };