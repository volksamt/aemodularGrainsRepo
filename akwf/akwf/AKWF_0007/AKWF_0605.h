#define DATA_LENGTH 512
#define DATA AKWF_0605

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 11, 11, 12, 12, 11, 11, 11, 12,
11, 11, 11, 11, 11, 11, 11, 12, 11, 11, 12, 11, 12, 12, 11, 12, 11, 11, 11, 12,
12, 11, 11, 12, 11, 12, 11, 11, 11, 12, 11, 11, 12, 12, 11, 11, 12, 11, 12, 12,
12, 11, 12, 11, 11, 11, 12, 11, 11, 12, 11, 11, 11, 12, 12, 12, 11, 11, 12, 11,
11, 12, 11, 11, 12, 12, 11, 11, 12, 11, 11, 11, 11, 11, 11, 12, 12, 11, 12, 11,
12, 11, 12, 12, 11, 11, 11, 11, 12, 11, 11, 11, 12, 11, 12, 12, 11, 10, 11, 11,
11, 12, 11, 11, 12, 12, 11, 12, 12, 12, 10, 11, 12, 11, 11, 12, 11, 11, 12, 12,
11, 11, 11, 11, 11, 11, 11, 11, 11, 11, 11, 12, 12, 12, 11, 11, 12, 11, 12, 11,
10, 12, 12, 11, 11, 11, 12, 11, 11, 11, 11, 10, 10, 11, 11, 10, 11, 11, 11, 11,
11, 12, 12, 11, 11, 10, 11, 11, 12, 11, 11, 11, 11, 11, 12, 11, 11, 10, 11, 11,
11, 11, 11, 11, 11, 12, 11, 12, 11, 11, 11, 11, 10, 11, 11, 11, 11, 12, 11, 11,
11, 10, 10, 11, 11, 10, 11, 11, 10, 11, 11, 11, 11, 11, 11, 11, 10, 11, 11, 11,
10, 12, 11, 11, 10, 11, 10, 11, 12, 11, 10, 11, 11, 11, 11, 11, 11, 11, 11, 10,
12, 11, 10, 10, 11, 10, 12, 11, 11, 11, 10, 10, 10, 10, 11, 11, 11, 11, 11, 11,
10, 10, 11, 11, 11, 11, 11, 11, 10, 11, 11, 10, 11, 10, 11, 11, 10, 10, 11, 10,
11, 10, 10, 11, 10, 11, 10, 10, 11, 10, 11, 11, 11, 11, 10, 10, 11, 11, 11, 10,
11, 11, 10, 11, 10, 10, 10, 11, 11, 11, 11, 10, 10, 10, 11, 10, 10, 10, 11, 10,
11, 11, 11, 11, 10, 11, 11, 11, 11, 10, 11, 11, 11, 11, 11, 10, 11, 10, 11, 11,
11, 11, 11, 11, 10, 11, 10, 11, 11, 10, 11, 11, 11, 10, 10, 11, 11, 11, 10, 11,
11, 11, 11, 10, 10, 11, 11, 11, 10, 11, 11, 11, 11, 11, 11, 10, 10, 11, 10, 11,
10, 11, 10, 11, 10, 10, 10, 10, 10, 10, 11, 11, 10, 10, 10, 10, 11, 10, 11, 10,
11, 10, 11, 10, 11, 10, 11, 11, 10, 10, 10, 9, 11, 10, 10, 11, 10, 10, 11, 10,
4, 1, -2, -5, -8, -11, -14, -17, -19, -23, -25, -29, -32, -35, -38, -41, -43,
-47, -50, -53, -55, -58, -61, -65, -68, -69, -72, -75, -79, -82, -85, -88, -90,
-93, -97, -99, -102, -105, -108, -112, -114, -117, -119, -115, -111, -110, -106,
-103, -100, -97, -95, -91, -88, -85, -82, -79, -76, -73, -70, -67, -64, -62,
-58, -56, -52, -49, -47, -43, -40, -38, -34, -31, -28, -25, -23, -20, -17, -14,
-10, -8, -5, -1, };