#define DATA_LENGTH 512
#define DATA AKWF_0622

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 16, 23, 29, 33, 38, 42, 46, 49, 54,
56, 61, 63, 66, 69, 71, 74, 77, 78, 81, 84, 86, 88, 90, 92, 94, 96, 98, 100,
101, 103, 104, 105, 106, 108, 109, 110, 111, 112, 113, 114, 115, 115, 116, 117,
117, 117, 118, 118, 119, 119, 119, 117, 107, 100, 95, 90, 85, 81, 79, 75, 70,
68, 65, 62, 59, 56, 54, 52, 48, 46, 43, 41, 40, 37, 35, 33, 31, 30, 28, 26, 24,
22, 21, 20, 18, 17, 16, 14, 14, 12, 10, 10, 9, 8, 7, 6, 5, 5, 4, 4, 3, 2, 2, 2,
1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, -1, -10, -15, -19, -23, -25,
-28, -31, -35, -36, -39, -41, -44, -45, -48, -50, -52, -54, -56, -57, -58, -61,
-63, -64, -65, -67, -69, -70, -71, -72, -73, -75, -75, -77, -78, -79, -80, -81,
-83, -83, -85, -85, -86, -86, -87, -88, -89, -90, -90, -90, -91, -92, -92, -93,
-94, -93, -94, -94, -94, -94, -94, -95, -95, -94, -94, -84, -79, -75, -71, -68,
-64, -62, -58, -57, -54, -51, -49, -47, -45, -42, -41, -39, -37, -35, -34, -32,
-30, -29, -26, -25, -24, -23, -21, -19, -19, -18, -16, -15, -14, -13, -11, -11,
-10, -9, -8, -7, -7, -6, -5, -4, -5, -4, -3, -3, -2, -2, -1, -1, -1, -1, 0, -1,
0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 7, 14, 18, 23, 26, 30, 33, 36, 38, 42,
43, 47, 48, 51, 53, 55, 57, 60, 61, 63, 64, 66, 68, 70, 72, 72, 75, 76, 77, 78,
80, 81, 83, 83, 84, 86, 87, 88, 89, 89, 90, 91, 92, 91, 93, 93, 94, 95, 95, 95,
96, 97, 97, 97, 97, 98, 98, 97, 97, 89, 83, 79, 75, 71, 68, 65, 62, 59, 57, 55,
52, 50, 48, 46, 43, 42, 40, 37, 35, 34, 32, 31, 29, 27, 26, 26, 23, 21, 21, 20,
18, 16, 15, 15, 14, 13, 12, 11, 10, 9, 8, 7, 7, 6, 6, 5, 3, 3, 4, 2, 2, 1, 1, 1,
1, 1, -1, 0, 1, 0, -1, 1, 0, -1, 0, -1, 0, -1, -1, 1, 0, 1, -2, -12, -18, -23,
-27, -30, -34, -38, -41, -44, -47, -50, -53, -55, -57, -61, -64, -65, -67, -69,
-71, -74, -75, -77, -79, -81, -83, -84, -86, -88, -89, -90, -91, -94, -95, -96,
-97, -99, -99, -100, -102, -103, -104, -104, -105, -107, -108, -107, -108, -109,
-109, -110, -111, -112, -112, -112, -112, -113, -113, -113, -114, -113, -114,
-113, -102, -94, -90, -84, -80, -75, -71, -68, -64, -61, -57, -54, -52, -48,
-47, -44, -42, -39, -37, -34, -32, -29, -28, -27, -24, -23, -22, -19, -17, -16,
-14, -14, -12, -11, -9, -8, -8, -6, -5, -5, -4, -4, -3, -2, -1, -2, -1, -1, 0,
0, 0, 0, 0, 0, 0, 0, -1, 0, -1, };