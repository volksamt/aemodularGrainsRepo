#define DATA_LENGTH 512
#define DATA AKWF_0650

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 4, 6, 7, 8, 11, 11, 13, 14,
15, 17, 17, 18, 20, 21, 22, 23, 24, 25, 26, 28, 28, 30, 30, 33, 34, 34, 35, 36,
37, 38, 39, 40, 41, 42, 44, 45, 45, 46, 47, 48, 49, 50, 51, 52, 53, 54, 54, 55,
56, 57, 58, 59, 59, 61, 62, 63, 63, 63, 64, 65, 66, 67, 68, 68, 70, 70, 71, 72,
73, 73, 74, 75, 75, 76, 76, 78, 78, 79, 79, 80, 81, 81, 82, 83, 83, 84, 84, 86,
86, 87, 87, 88, 88, 89, 89, 90, 92, 91, 93, 92, 93, 94, 93, 95, 95, 95, 96, 97,
97, 98, 99, 99, 99, 99, 100, 100, 101, 102, 102, 102, 103, 104, 103, 104, 105,
105, 105, 106, 105, 107, 106, 107, 108, 108, 109, 109, 109, 109, 109, 111, 111,
110, 110, 111, 112, 111, 112, 112, 112, 113, 113, 113, 114, 113, 114, 115, 115,
115, 115, 114, 116, 116, 116, 116, 116, 116, 117, 116, 116, 117, 117, 118, 118,
117, 118, 117, 118, 118, 119, 117, 119, 118, 119, 119, 118, 118, 119, 118, 119,
118, 118, 119, 119, 119, 118, 118, 119, 120, 119, 120, 109, 103, 99, 95, 92, 88,
85, 82, 79, 76, 74, 71, 68, 66, 64, 62, 59, 57, 55, 54, 51, 49, 47, 45, 43, 42,
40, 38, 36, 34, 33, 31, 29, 28, 26, 25, 23, 21, 20, 19, 17, 16, 14, 12, 12, 10,
8, 7, 5, 4, 3, 1, 0, -1, -3, -4, -5, -7, -7, -9, -10, -11, -13, -13, -15, -16,
-17, -19, -20, -21, -22, -23, -24, -25, -26, -27, -28, -30, -30, -32, -33, -35,
-35, -36, -37, -38, -39, -41, -40, -41, -42, -44, -45, -46, -47, -47, -49, -49,
-51, -51, -52, -53, -53, -55, -55, -56, -57, -58, -58, -60, -61, -62, -62, -63,
-63, -64, -65, -66, -68, -68, -69, -69, -70, -72, -72, -72, -73, -74, -75, -75,
-76, -77, -77, -78, -79, -80, -80, -81, -81, -82, -82, -83, -84, -84, -86, -85,
-86, -87, -88, -88, -89, -89, -90, -90, -91, -92, -92, -92, -94, -94, -94, -94,
-95, -96, -97, -96, -97, -97, -98, -98, -99, -99, -99, -100, -100, -100, -102,
-102, -103, -103, -103, -103, -104, -104, -104, -105, -106, -106, -106, -107,
-107, -107, -108, -109, -108, -109, -110, -110, -110, -110, -110, -111, -111,
-111, -112, -112, -112, -113, -112, -113, -113, -114, -114, -114, -114, -114,
-115, -115, -115, -115, -116, -115, -115, -116, -116, -116, -116, -116, -117,
-117, -117, -118, -117, -117, -117, -117, -118, -118, -117, -117, -118, -118,
-118, -118, -118, -118, -118, -118, -118, -119, -118, -118, -119, -118, -118,
-118, -119, -116, -105, -100, -96, -92, -88, -85, -82, -79, -77, -73, -71, -69,
-65, -63, -61, -59, -56, -55, -53, -51, -49, -47, -44, -43, -41, -40, -37, -36,
-34, -32, -30, -29, -27, -25, -23, -22, -21, -18, -17, -15, -14, -13, -12, -11,
-8, -7, -6, -4, -3, -2, -1, };