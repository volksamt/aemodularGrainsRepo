#define DATA_LENGTH 512
#define DATA AKWF_0686

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 24, 25, 33, 42, 49, 53, 57, 58,
60, 63, 63, 65, 67, 70, 71, 74, 77, 78, 81, 84, 87, 89, 91, 93, 95, 96, 99, 100,
103, 103, 105, 108, 108, 109, 111, 111, 113, 114, 114, 115, 116, 116, 117, 117,
118, 119, 118, 119, 119, 120, 119, 119, 118, 119, 119, 118, 119, 119, 118, 118,
118, 117, 116, 117, 117, 115, 115, 116, 115, 114, 113, 111, 98, 86, 85, 83, 79,
72, 66, 60, 56, 52, 50, 48, 47, 45, 44, 42, 41, 40, 39, 37, 35, 33, 31, 29, 28,
25, 24, 21, 20, 17, 15, 14, 11, 10, 8, 6, 4, 2, 1, -1, -2, -4, -5, -6, -8, -9,
-10, -11, -12, -14, -14, -15, -16, -18, -18, -19, -20, -20, -21, -22, -21, -22,
-23, -24, -23, -24, -24, -24, -25, -26, -25, -25, -25, -25, -25, -26, -26, -26,
-25, -25, -26, -25, -24, -24, -24, -24, -24, -24, -24, -24, -23, -23, -23, -22,
-22, -20, -21, -21, -20, -20, -20, -18, -19, -19, -18, -17, -16, -17, -16, -15,
-16, -15, -15, -13, -14, -13, -13, -12, -13, -11, -11, -10, -11, -10, -10, -10,
-9, -9, -8, -9, -8, -8, -8, -6, -6, -6, -6, -5, -5, -5, -4, -4, -4, -3, -3, -3,
-3, -3, -2, -3, -2, -2, -1, -2, -2, -1, -1, 0, -1, 0, 0, 0, 0, 1, 0, 1, 2, 0, 2,
1, 1, 1, 2, 2, 1, 3, 3, 2, 2, 3, 2, 2, 3, 3, 3, 3, 2, 3, 3, 3, 2, 4, 2, 2, 3, 2,
3, 3, 3, 3, 3, 4, 3, 2, 3, 3, 2, 2, 3, 3, 3, 3, 3, 3, 3, 2, 3, 2, 2, 3, 2, 3,
-1, -10, -19, -24, -24, -25, -27, -30, -33, -37, -41, -45, -48, -50, -53, -55,
-57, -57, -59, -59, -60, -61, -61, -62, -62, -63, -64, -65, -65, -66, -67, -68,
-69, -71, -72, -74, -74, -75, -77, -78, -78, -80, -82, -82, -84, -85, -87, -87,
-89, -90, -91, -92, -93, -94, -95, -96, -97, -98, -99, -100, -101, -103, -103,
-103, -104, -105, -106, -108, -107, -109, -108, -109, -110, -111, -111, -112,
-112, -114, -114, -114, -114, -115, -115, -116, -116, -116, -117, -116, -117,
-117, -118, -118, -118, -118, -119, -118, -119, -119, -118, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -118, -117, -109, -99, -94, -91, -92, -90,
-88, -84, -80, -77, -73, -69, -66, -63, -62, -59, -57, -56, -54, -55, -53, -53,
-52, -51, -50, -48, -49, -48, -47, -45, -44, -43, -42, -41, -38, -38, -36, -35,
-33, -32, -30, -28, -27, -26, -24, -23, -22, -20, -19, -18, -16, -14, -13, -11,
-11, -9, -8, -7, -5, -4, -3, -3, 0, -1, 18, 25, 22, 24, 21, 20, 16, 15, 13, 12,
10, 9, 7, 6, 5, 4, 2, 2, 2, 1, 0, 0, 0, -1, -1, -2, -2, -2, -2, -2, -3, -3, -3,
-3, -3, -3, -2, -3, -3, -3, -3, -3, -3, };