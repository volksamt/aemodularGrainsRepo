#define DATA_LENGTH 512
#define DATA AKWF_tannerin_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 5, 7, 8, 10, 12, 14, 15,
16, 20, 20, 22, 23, 25, 26, 27, 29, 31, 32, 33, 35, 37, 38, 39, 41, 42, 43, 44,
46, 48, 48, 49, 51, 52, 54, 55, 56, 58, 58, 60, 62, 62, 64, 65, 66, 67, 69, 70,
71, 72, 74, 74, 76, 77, 78, 79, 80, 81, 82, 83, 84, 86, 86, 87, 89, 89, 90, 91,
93, 93, 94, 95, 95, 97, 97, 98, 99, 101, 101, 102, 102, 103, 104, 105, 105, 106,
107, 108, 108, 108, 109, 110, 110, 111, 112, 111, 112, 112, 113, 113, 114, 115,
115, 115, 115, 116, 116, 117, 116, 117, 117, 117, 117, 117, 118, 118, 119, 119,
119, 119, 119, 118, 119, 119, 119, 118, 119, 119, 119, 118, 118, 118, 119, 117,
117, 118, 118, 117, 117, 116, 115, 116, 115, 116, 114, 115, 114, 114, 113, 113,
113, 112, 112, 111, 111, 110, 109, 109, 108, 107, 107, 106, 105, 105, 104, 104,
103, 101, 101, 101, 99, 98, 98, 98, 97, 96, 94, 94, 92, 91, 92, 90, 90, 89, 87,
86, 86, 85, 84, 82, 81, 80, 79, 77, 76, 75, 74, 73, 72, 71, 70, 68, 67, 67, 65,
63, 63, 62, 61, 59, 57, 56, 55, 54, 53, 51, 50, 48, 47, 45, 44, 42, 42, 39, 38,
38, 35, 35, 33, 31, 31, 29, 27, 27, 24, 23, 21, 20, 18, 17, 16, 14, 13, 11, 11,
9, 7, 6, 5, 3, 1, 0, -1, -3, -4, -6, -7, -9, -10, -12, -14, -14, -16, -17, -19,
-20, -22, -23, -25, -26, -27, -29, -31, -32, -34, -35, -35, -38, -39, -40, -42,
-43, -45, -46, -47, -48, -50, -51, -53, -53, -54, -56, -58, -58, -60, -60, -62,
-63, -65, -65, -67, -68, -70, -70, -72, -73, -73, -75, -76, -77, -79, -80, -81,
-82, -83, -84, -85, -85, -87, -88, -88, -90, -90, -91, -91, -93, -94, -94, -95,
-96, -97, -97, -98, -99, -100, -101, -101, -102, -103, -103, -104, -105, -105,
-107, -107, -108, -108, -109, -110, -110, -111, -111, -112, -113, -113, -113,
-113, -113, -114, -114, -114, -115, -116, -115, -116, -116, -116, -116, -117,
-117, -117, -117, -117, -117, -117, -117, -117, -117, -117, -118, -118, -117,
-118, -118, -118, -118, -117, -117, -118, -117, -116, -117, -117, -116, -116,
-116, -116, -116, -115, -115, -114, -114, -114, -113, -113, -112, -111, -111,
-110, -111, -111, -110, -109, -108, -107, -107, -107, -105, -104, -105, -104,
-103, -102, -102, -101, -100, -100, -99, -97, -96, -96, -95, -94, -93, -92, -91,
-91, -89, -88, -87, -86, -85, -84, -83, -82, -82, -80, -79, -78, -78, -77, -75,
-75, -73, -73, -72, -70, -69, -67, -67, -65, -63, -63, -62, -60, -58, -56, -56,
-55, -53, -52, -51, -50, -48, -47, -45, -45, -44, -42, -40, -39, -37, -36, -34,
-33, -32, -31, -30, -27, -26, -25, -24, -22, -21, -19, -18, -17, -15, -14, -12,
-10, -9, -7, -7, -5, -4, -3, -1, 0, };