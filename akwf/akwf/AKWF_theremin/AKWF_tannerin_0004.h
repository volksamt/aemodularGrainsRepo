#define DATA_LENGTH 512
#define DATA AKWF_tannerin_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 10, 14, 16, 18, 19, 19, 21, 22,
24, 25, 26, 28, 29, 31, 32, 33, 35, 36, 38, 39, 40, 43, 43, 45, 46, 48, 49, 51,
52, 53, 55, 56, 57, 58, 59, 61, 61, 63, 64, 65, 66, 68, 69, 70, 71, 72, 73, 74,
75, 77, 78, 79, 80, 81, 83, 83, 85, 85, 87, 87, 88, 89, 90, 91, 92, 93, 94, 95,
96, 96, 98, 98, 99, 99, 101, 101, 102, 103, 103, 104, 106, 105, 105, 107, 107,
108, 109, 109, 110, 110, 111, 111, 112, 113, 112, 113, 114, 114, 114, 114, 116,
115, 115, 116, 116, 117, 117, 118, 118, 117, 118, 118, 118, 119, 119, 119, 120,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 118, 118, 118, 117,
117, 118, 117, 117, 117, 116, 115, 115, 116, 115, 114, 114, 113, 113, 113, 112,
112, 111, 110, 110, 109, 109, 108, 108, 106, 106, 105, 104, 104, 103, 104, 102,
101, 101, 100, 100, 98, 99, 97, 96, 95, 94, 94, 92, 92, 91, 89, 89, 88, 87, 86,
85, 84, 82, 82, 81, 80, 78, 77, 76, 75, 74, 72, 71, 70, 69, 68, 66, 65, 64, 63,
62, 61, 60, 58, 57, 55, 54, 53, 51, 51, 49, 47, 46, 45, 43, 42, 41, 40, 38, 37,
35, 34, 33, 31, 30, 29, 27, 25, 24, 23, 21, 20, 18, 17, 15, 14, 14, 11, 11, 8,
7, 5, 4, 2, 1, 0, -1, -4, -5, -7, -8, -9, -10, -12, -13, -14, -16, -19, -19,
-21, -22, -24, -25, -26, -28, -30, -31, -32, -34, -36, -37, -37, -39, -41, -42,
-44, -45, -46, -48, -49, -51, -51, -53, -54, -56, -57, -58, -60, -61, -62, -64,
-65, -65, -67, -69, -70, -71, -73, -74, -75, -76, -77, -79, -80, -80, -81, -83,
-83, -85, -86, -87, -87, -88, -89, -90, -92, -92, -94, -94, -95, -95, -97, -98,
-98, -99, -100, -101, -101, -103, -103, -104, -105, -106, -106, -106, -107,
-108, -109, -110, -110, -110, -111, -112, -111, -113, -114, -113, -113, -114,
-115, -115, -116, -116, -116, -116, -117, -117, -118, -117, -118, -118, -118,
-119, -119, -119, -118, -119, -119, -119, -119, -120, -119, -119, -118, -119,
-118, -119, -119, -118, -118, -119, -118, -117, -118, -117, -116, -117, -116,
-117, -116, -115, -115, -115, -115, -114, -114, -114, -113, -112, -112, -111,
-111, -110, -110, -109, -109, -108, -108, -107, -106, -106, -105, -104, -103,
-104, -102, -101, -100, -100, -98, -98, -97, -97, -96, -95, -95, -93, -92, -91,
-90, -90, -89, -88, -86, -85, -85, -85, -83, -82, -80, -80, -79, -77, -77, -76,
-74, -72, -72, -71, -69, -69, -66, -65, -64, -64, -62, -60, -60, -57, -56, -55,
-54, -53, -51, -50, -49, -48, -46, -44, -43, -42, -40, -39, -36, -35, -34, -32,
-31, -29, -27, -27, -25, -25, -22, -21, -20, -19, -19, -17, -17, -16, -15, -14,
-12, -12, -11, -11, -11, -10, -10, -11, -10, -9, -8, -6, -2, };