#define DATA_LENGTH 512
#define DATA AKWF_theremin_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 11, 23, 39, 52, 61, 69, 70, 73, 73,
75, 76, 77, 79, 79, 80, 82, 83, 84, 86, 87, 88, 89, 90, 90, 92, 94, 94, 94, 95,
96, 96, 96, 98, 98, 98, 98, 100, 100, 101, 101, 101, 103, 104, 103, 105, 105,
106, 106, 107, 108, 108, 109, 109, 110, 109, 111, 111, 111, 112, 112, 112, 113,
114, 114, 114, 114, 115, 114, 115, 116, 117, 117, 116, 117, 116, 117, 117, 117,
117, 117, 117, 117, 118, 118, 118, 118, 118, 119, 118, 119, 119, 119, 118, 120,
119, 120, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 119,
119, 118, 118, 118, 117, 118, 117, 117, 117, 116, 117, 116, 116, 116, 116, 116,
116, 116, 116, 116, 116, 117, 116, 117, 117, 117, 117, 116, 116, 116, 115, 114,
115, 114, 114, 114, 114, 116, 116, 116, 117, 117, 118, 118, 116, 115, 112, 108,
105, 100, 95, 90, 85, 78, 71, 67, 60, 54, 49, 42, 37, 31, 26, 22, 18, 13, 11, 9,
7, 5, 4, 2, 1, -1, -2, -3, -5, -7, -9, -12, -13, -15, -17, -19, -20, -21, -22,
-23, -24, -25, -26, -28, -28, -30, -31, -33, -34, -35, -35, -36, -38, -39, -41,
-42, -42, -43, -44, -45, -46, -46, -47, -48, -49, -49, -51, -51, -51, -52, -53,
-54, -55, -55, -55, -56, -57, -57, -57, -57, -58, -58, -59, -59, -59, -61, -60,
-62, -62, -62, -62, -62, -63, -64, -64, -64, -64, -64, -64, -64, -64, -65, -64,
-65, -65, -66, -66, -66, -66, -66, -67, -66, -67, -67, -67, -67, -67, -67, -67,
-67, -67, -66, -66, -67, -67, -67, -67, -66, -66, -66, -66, -66, -67, -65, -66,
-67, -66, -66, -66, -66, -66, -67, -66, -66, -67, -66, -66, -67, -67, -66, -67,
-67, -67, -67, -67, -67, -66, -66, -66, -66, -66, -66, -67, -66, -67, -67, -67,
-67, -66, -66, -66, -66, -66, -65, -66, -66, -66, -66, -66, -66, -66, -66, -66,
-66, -66, -65, -66, -66, -66, -66, -65, -66, -64, -64, -65, -64, -64, -64, -64,
-64, -65, -64, -65, -64, -65, -64, -65, -64, -65, -64, -63, -64, -64, -63, -63,
-63, -63, -62, -63, -62, -62, -62, -61, -62, -62, -62, -63, -61, -62, -62, -62,
-62, -62, -62, -62, -62, -63, -62, -61, -62, -61, -62, -63, -62, -63, -61, -62,
-63, -62, -62, -62, -62, -62, -61, -61, -62, -62, -62, -62, -62, -62, -62, -62,
-62, -62, -63, -62, -62, -61, -62, -62, -62, -61, -61, -62, -61, -62, -62, -62,
-61, -60, -61, -61, -61, -60, -60, -60, -60, -60, -60, -59, -59, -59, -59, -59,
-58, -60, -59, -59, -59, -58, -58, -57, -58, -56, -57, -56, -55, -55, -54, -54,
-54, -54, -54, -53, -53, -53, -54, -53, -52, -51, -51, -50, -48, -48, -46, -46,
-44, -44, -43, -43, -43, -44, -44, -43, -43, -42, -41, -41, -38, -34, -30, -26,
-21, -17, -12, -7, -4, -3, -1, -3, -4, -2, };