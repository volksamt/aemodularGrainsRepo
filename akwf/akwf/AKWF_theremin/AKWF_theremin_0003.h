#define DATA_LENGTH 512
#define DATA AKWF_theremin_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 16, 25, 34, 42, 48, 52, 56, 58, 60,
62, 63, 65, 68, 70, 73, 75, 79, 81, 85, 87, 91, 93, 95, 97, 100, 102, 105, 106,
108, 110, 111, 113, 114, 115, 116, 117, 118, 118, 118, 119, 119, 119, 120, 119,
119, 119, 119, 119, 118, 118, 117, 117, 116, 117, 116, 116, 116, 116, 115, 114,
115, 115, 115, 114, 114, 114, 115, 114, 114, 115, 114, 115, 114, 114, 115, 116,
116, 116, 116, 116, 116, 117, 117, 117, 117, 117, 118, 118, 119, 117, 119, 119,
119, 118, 119, 119, 118, 118, 119, 119, 119, 120, 119, 119, 119, 119, 118, 118,
119, 118, 118, 118, 117, 117, 117, 116, 116, 114, 114, 113, 113, 112, 112, 111,
109, 109, 108, 107, 106, 104, 103, 103, 101, 100, 99, 97, 96, 93, 92, 91, 88,
86, 83, 83, 80, 77, 75, 72, 70, 67, 65, 61, 58, 55, 53, 49, 46, 43, 39, 36, 33,
30, 26, 23, 20, 16, 13, 11, 6, 4, 1, -2, -4, -8, -10, -13, -16, -17, -19, -22,
-24, -26, -28, -30, -31, -33, -35, -37, -38, -40, -41, -42, -43, -45, -47, -47,
-48, -49, -50, -50, -52, -52, -53, -54, -55, -56, -57, -57, -57, -57, -57, -59,
-58, -58, -58, -59, -59, -60, -59, -59, -60, -60, -60, -60, -60, -60, -61, -60,
-60, -61, -60, -60, -61, -61, -61, -61, -61, -60, -61, -61, -62, -62, -63, -62,
-62, -62, -63, -63, -63, -64, -64, -63, -63, -63, -63, -65, -64, -64, -64, -64,
-64, -64, -64, -64, -63, -64, -63, -63, -63, -64, -63, -63, -62, -63, -62, -62,
-62, -61, -62, -61, -61, -61, -61, -61, -61, -60, -61, -60, -60, -60, -61, -61,
-60, -60, -61, -60, -60, -61, -61, -61, -61, -62, -61, -63, -63, -63, -62, -63,
-63, -64, -63, -63, -64, -64, -64, -64, -64, -64, -64, -64, -65, -64, -64, -65,
-65, -64, -65, -65, -65, -65, -65, -65, -65, -65, -65, -64, -64, -64, -64, -64,
-64, -65, -64, -64, -64, -64, -63, -64, -64, -64, -64, -63, -63, -63, -63, -64,
-63, -62, -63, -62, -63, -62, -62, -62, -61, -62, -61, -62, -60, -61, -61, -62,
-61, -60, -60, -60, -60, -60, -60, -60, -59, -59, -59, -59, -58, -59, -59, -58,
-59, -59, -59, -59, -58, -57, -57, -58, -57, -58, -57, -57, -58, -57, -58, -58,
-58, -58, -58, -58, -59, -58, -58, -58, -58, -59, -58, -59, -59, -60, -60, -59,
-60, -60, -61, -60, -60, -60, -60, -61, -60, -61, -60, -60, -61, -61, -60, -60,
-60, -60, -60, -60, -60, -60, -60, -59, -59, -59, -58, -58, -59, -59, -58, -58,
-59, -57, -58, -58, -57, -58, -57, -58, -58, -58, -58, -58, -58, -58, -59, -59,
-60, -60, -60, -60, -60, -60, -60, -61, -61, -60, -59, -59, -60, -59, -59, -58,
-57, -56, -55, -54, -53, -51, -50, -49, -46, -45, -43, -41, -39, -35, -34, -32,
-30, -27, -25, -25, -24, -21, -20, -18, -14, -8, 0, };