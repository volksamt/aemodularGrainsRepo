#define DATA_LENGTH 512
#define DATA AKWF_theremin_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 16, 27, 37, 45, 54, 61, 69, 77, 84,
91, 95, 98, 101, 102, 103, 105, 106, 108, 108, 110, 111, 111, 112, 113, 114,
114, 114, 115, 115, 116, 116, 117, 116, 117, 117, 117, 117, 118, 118, 118, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 118, 119, 119, 118, 119,
119, 118, 119, 118, 118, 117, 117, 117, 118, 117, 116, 116, 115, 115, 115, 115,
115, 115, 115, 114, 114, 113, 113, 113, 113, 113, 113, 113, 112, 112, 112, 112,
112, 111, 111, 110, 110, 109, 109, 110, 110, 109, 108, 108, 109, 109, 108, 109,
108, 108, 108, 108, 108, 108, 108, 108, 107, 107, 107, 106, 106, 106, 105, 106,
105, 106, 105, 105, 105, 105, 105, 104, 104, 104, 104, 104, 102, 103, 103, 101,
101, 101, 102, 101, 101, 102, 102, 100, 101, 99, 99, 99, 99, 98, 98, 98, 99,
100, 99, 100, 99, 96, 93, 88, 85, 78, 72, 66, 58, 50, 42, 35, 26, 19, 11, 6, 0,
-3, -7, -9, -13, -15, -18, -20, -22, -24, -26, -28, -30, -31, -33, -34, -36,
-38, -39, -40, -42, -43, -44, -46, -47, -49, -50, -51, -51, -53, -54, -55, -56,
-58, -57, -59, -60, -60, -61, -62, -62, -63, -64, -65, -65, -66, -66, -68, -68,
-68, -69, -68, -69, -70, -70, -70, -71, -71, -71, -71, -71, -72, -72, -73, -73,
-73, -73, -73, -72, -73, -74, -73, -74, -73, -73, -73, -73, -73, -73, -72, -72,
-72, -72, -72, -71, -71, -71, -71, -71, -70, -71, -71, -70, -71, -71, -70, -71,
-70, -71, -70, -70, -70, -70, -71, -71, -71, -70, -69, -69, -69, -69, -69, -69,
-68, -68, -68, -68, -67, -68, -67, -67, -67, -67, -67, -67, -66, -66, -66, -65,
-65, -66, -66, -66, -66, -65, -65, -65, -64, -64, -64, -64, -64, -64, -64, -63,
-63, -62, -62, -62, -62, -62, -62, -62, -62, -62, -62, -61, -61, -61, -60, -60,
-61, -60, -60, -60, -60, -60, -59, -60, -58, -59, -58, -58, -59, -59, -59, -58,
-57, -57, -58, -57, -57, -58, -56, -56, -57, -57, -57, -56, -56, -56, -55, -56,
-56, -54, -55, -54, -55, -54, -54, -54, -54, -54, -54, -54, -53, -53, -52, -53,
-52, -52, -53, -52, -52, -52, -52, -52, -52, -51, -51, -51, -52, -51, -51, -50,
-50, -50, -51, -50, -50, -50, -50, -50, -49, -49, -49, -49, -49, -48, -48, -49,
-47, -48, -48, -48, -48, -48, -47, -48, -46, -46, -47, -46, -45, -46, -45, -46,
-46, -47, -46, -46, -47, -47, -47, -47, -46, -46, -47, -47, -47, -47, -46, -47,
-46, -46, -46, -46, -45, -46, -45, -46, -46, -45, -45, -44, -45, -45, -45, -45,
-45, -44, -44, -44, -43, -43, -43, -42, -41, -42, -41, -41, -42, -40, -40, -40,
-39, -38, -38, -37, -37, -36, -36, -35, -35, -34, -33, -33, -32, -32, -30, -29,
-29, -28, -27, -25, -24, -24, -22, -22, -20, -19, -17, -15, -15, -14, -12, -9,
-2, };