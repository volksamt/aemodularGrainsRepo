#define DATA_LENGTH 512
#define DATA AKWF_theremin_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 17, 26, 39, 52, 65, 76, 83, 90,
95, 98, 101, 104, 107, 108, 110, 112, 112, 114, 116, 117, 117, 117, 118, 118,
118, 118, 119, 119, 118, 118, 119, 118, 117, 118, 116, 117, 116, 116, 115, 114,
114, 113, 113, 113, 113, 112, 112, 111, 111, 109, 109, 109, 109, 108, 107, 107,
107, 105, 105, 106, 105, 104, 104, 103, 101, 101, 101, 101, 100, 100, 100, 99,
98, 98, 97, 97, 96, 95, 95, 94, 94, 94, 94, 93, 92, 92, 91, 92, 91, 91, 90, 90,
89, 89, 89, 89, 88, 88, 87, 87, 87, 86, 86, 85, 85, 84, 84, 84, 83, 83, 83, 82,
82, 81, 81, 81, 81, 80, 80, 80, 79, 79, 78, 78, 78, 78, 78, 77, 77, 76, 77, 76,
75, 75, 75, 75, 74, 74, 74, 73, 73, 73, 73, 74, 73, 74, 73, 73, 74, 73, 74, 73,
74, 72, 73, 73, 73, 72, 74, 73, 73, 72, 73, 73, 72, 72, 73, 71, 71, 70, 69, 68,
64, 57, 48, 36, 23, 9, -3, -12, -19, -24, -29, -33, -36, -39, -43, -45, -48,
-51, -53, -56, -57, -59, -61, -63, -65, -66, -68, -68, -69, -70, -72, -72, -72,
-73, -74, -75, -75, -75, -75, -76, -75, -75, -77, -77, -77, -77, -78, -78, -77,
-78, -78, -78, -78, -78, -78, -78, -77, -78, -78, -78, -77, -77, -77, -76, -76,
-76, -77, -76, -76, -75, -74, -74, -74, -73, -73, -73, -73, -73, -72, -72, -72,
-72, -71, -70, -70, -70, -70, -68, -69, -69, -68, -69, -67, -67, -66, -66, -66,
-65, -65, -65, -65, -64, -64, -64, -64, -63, -62, -62, -62, -62, -61, -60, -60,
-61, -59, -60, -59, -59, -59, -59, -59, -58, -57, -57, -58, -56, -57, -57, -56,
-55, -55, -55, -55, -55, -55, -54, -54, -54, -54, -54, -53, -53, -52, -53, -52,
-52, -51, -52, -51, -51, -50, -50, -50, -50, -50, -50, -49, -49, -49, -48, -49,
-49, -48, -47, -47, -48, -47, -47, -47, -47, -46, -47, -46, -46, -47, -45, -47,
-46, -46, -45, -45, -45, -46, -45, -44, -45, -44, -44, -45, -43, -44, -43, -42,
-43, -42, -43, -43, -42, -43, -43, -43, -42, -42, -42, -42, -42, -41, -41, -42,
-41, -41, -41, -42, -41, -40, -41, -40, -41, -40, -40, -40, -40, -40, -40, -40,
-40, -39, -39, -39, -39, -39, -39, -39, -39, -39, -38, -39, -39, -39, -38, -39,
-37, -38, -38, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -36, -37, -36,
-36, -36, -37, -35, -36, -35, -35, -35, -35, -35, -35, -36, -36, -34, -36, -35,
-34, -34, -35, -34, -34, -33, -34, -33, -34, -33, -34, -33, -33, -32, -33, -33,
-32, -33, -32, -31, -31, -31, -31, -31, -30, -30, -30, -29, -29, -28, -28, -28,
-26, -26, -26, -25, -25, -24, -25, -24, -24, -24, -24, -23, -23, -22, -21, -21,
-21, -20, -19, -17, -17, -16, -14, -13, -12, -11, -11, -10, -8, -6, -5, -2, 0,
};