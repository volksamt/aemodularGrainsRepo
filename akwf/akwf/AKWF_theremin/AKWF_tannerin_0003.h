#define DATA_LENGTH 512
#define DATA AKWF_tannerin_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 7, 9, 11, 12, 14, 15, 16, 17,
18, 20, 21, 23, 24, 25, 26, 28, 30, 31, 33, 35, 37, 37, 39, 41, 42, 44, 45, 47,
48, 50, 50, 52, 53, 55, 56, 57, 59, 60, 61, 63, 64, 65, 66, 68, 69, 70, 71, 72,
74, 75, 77, 77, 77, 79, 80, 81, 83, 83, 84, 86, 86, 87, 88, 89, 90, 91, 92, 92,
94, 95, 95, 96, 97, 98, 99, 99, 101, 101, 102, 102, 103, 105, 105, 106, 106,
108, 107, 108, 110, 110, 110, 111, 112, 113, 113, 113, 113, 114, 114, 115, 115,
115, 115, 117, 116, 117, 117, 117, 118, 118, 118, 118, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 118, 118,
118, 118, 117, 118, 117, 117, 116, 116, 115, 115, 115, 114, 114, 114, 112, 112,
112, 111, 111, 109, 109, 109, 108, 108, 106, 106, 106, 104, 105, 104, 102, 102,
101, 101, 100, 99, 97, 98, 96, 95, 95, 94, 93, 93, 92, 90, 89, 88, 87, 87, 85,
84, 83, 82, 82, 80, 79, 78, 76, 76, 75, 74, 72, 71, 71, 69, 68, 66, 65, 64, 63,
62, 60, 59, 58, 56, 54, 53, 52, 51, 50, 49, 47, 45, 45, 43, 42, 40, 38, 37, 37,
35, 32, 32, 30, 29, 27, 26, 24, 22, 21, 20, 18, 17, 16, 14, 12, 11, 9, 9, 6, 4,
4, 2, 0, 0, -2, -4, -6, -7, -9, -11, -12, -12, -14, -15, -18, -19, -20, -21,
-23, -24, -26, -27, -29, -30, -32, -33, -34, -37, -37, -39, -39, -41, -42, -44,
-45, -47, -47, -49, -50, -52, -53, -54, -56, -56, -57, -59, -60, -61, -63, -64,
-65, -66, -67, -68, -69, -71, -72, -72, -73, -75, -75, -77, -78, -79, -80, -81,
-81, -82, -84, -84, -85, -85, -88, -88, -89, -90, -91, -92, -92, -93, -94, -95,
-96, -97, -97, -98, -99, -99, -101, -100, -101, -102, -103, -103, -104, -104,
-105, -105, -106, -106, -107, -107, -108, -108, -109, -110, -110, -110, -111,
-111, -112, -112, -112, -112, -113, -114, -114, -113, -114, -113, -114, -115,
-114, -115, -115, -115, -115, -115, -115, -115, -114, -115, -115, -115, -116,
-115, -115, -115, -114, -115, -114, -114, -114, -115, -114, -114, -113, -113,
-112, -113, -112, -112, -112, -111, -111, -110, -110, -110, -109, -108, -108,
-108, -107, -107, -106, -105, -105, -105, -103, -103, -103, -102, -101, -100,
-100, -99, -98, -98, -97, -96, -94, -94, -94, -92, -92, -92, -91, -90, -89, -88,
-87, -85, -84, -84, -83, -82, -81, -79, -79, -78, -78, -77, -75, -75, -74, -72,
-71, -69, -69, -67, -67, -65, -64, -64, -62, -61, -60, -58, -57, -56, -55, -53,
-52, -51, -49, -48, -47, -46, -44, -44, -41, -40, -40, -38, -36, -35, -34, -32,
-31, -30, -29, -28, -26, -25, -23, -23, -22, -21, -21, -18, -18, -16, -16, -14,
-14, -13, -12, -12, -11, -11, -10, -9, -7, -4, -2, };