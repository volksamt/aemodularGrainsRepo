#define DATA_LENGTH 512
#define DATA AKWF_theremin_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 18, 31, 42, 48, 52, 52, 52, 52, 53,
54, 55, 56, 58, 59, 60, 62, 63, 64, 65, 67, 68, 70, 71, 71, 73, 74, 74, 75, 76,
76, 77, 77, 79, 80, 80, 81, 82, 83, 83, 84, 85, 85, 86, 87, 87, 88, 88, 89, 90,
90, 91, 92, 92, 92, 92, 92, 94, 93, 94, 95, 94, 96, 95, 95, 97, 97, 97, 97, 97,
98, 98, 98, 99, 99, 99, 99, 99, 99, 100, 100, 101, 100, 100, 101, 101, 102, 101,
101, 101, 101, 101, 102, 101, 102, 101, 102, 102, 102, 103, 102, 101, 101, 101,
101, 101, 101, 101, 101, 101, 101, 101, 100, 100, 100, 99, 100, 100, 99, 99, 99,
98, 99, 99, 99, 99, 99, 99, 98, 99, 99, 99, 99, 99, 99, 99, 99, 99, 99, 100,
100, 100, 100, 100, 100, 100, 100, 101, 100, 101, 100, 101, 101, 101, 102, 100,
100, 101, 101, 100, 101, 101, 101, 100, 100, 101, 100, 100, 101, 101, 100, 101,
101, 101, 100, 100, 100, 100, 100, 100, 100, 100, 101, 100, 100, 100, 100, 100,
99, 99, 100, 100, 99, 100, 99, 100, 99, 100, 99, 99, 99, 100, 100, 99, 98, 99,
99, 98, 98, 98, 98, 97, 97, 97, 97, 98, 98, 97, 98, 98, 98, 98, 98, 98, 97, 97,
97, 96, 95, 95, 95, 94, 94, 95, 95, 96, 97, 98, 98, 99, 100, 100, 98, 97, 95,
91, 88, 84, 79, 73, 68, 62, 57, 51, 46, 39, 32, 26, 21, 14, 9, 4, -2, -7, -12,
-14, -18, -20, -22, -24, -27, -27, -29, -31, -32, -34, -35, -38, -40, -42, -44,
-46, -48, -50, -52, -54, -55, -57, -58, -60, -62, -63, -64, -65, -66, -67, -69,
-70, -72, -74, -75, -76, -78, -79, -81, -82, -82, -84, -84, -86, -87, -88, -88,
-89, -91, -91, -92, -93, -94, -95, -96, -97, -98, -98, -98, -99, -101, -101,
-101, -102, -103, -103, -104, -105, -105, -105, -106, -107, -107, -108, -108,
-109, -109, -111, -110, -110, -112, -111, -112, -112, -112, -113, -113, -113,
-114, -114, -114, -114, -114, -114, -114, -114, -115, -115, -115, -115, -115,
-116, -116, -116, -115, -115, -116, -116, -115, -116, -116, -116, -115, -116,
-116, -117, -116, -116, -116, -117, -117, -117, -117, -117, -117, -118, -118,
-118, -117, -117, -117, -118, -118, -118, -117, -118, -118, -118, -119, -118,
-118, -119, -119, -118, -119, -119, -119, -119, -119, -118, -119, -118, -118,
-119, -118, -118, -118, -118, -118, -117, -118, -118, -118, -117, -118, -117,
-117, -117, -117, -117, -117, -116, -116, -116, -116, -114, -115, -114, -114,
-114, -113, -114, -113, -113, -113, -113, -112, -113, -111, -111, -111, -110,
-110, -109, -108, -109, -107, -106, -106, -106, -106, -106, -104, -104, -104,
-104, -103, -103, -101, -101, -99, -99, -98, -96, -96, -94, -94, -93, -93, -91,
-90, -89, -89, -88, -87, -86, -85, -83, -83, -81, -79, -78, -76, -74, -72, -68,
-64, -61, -57, -53, -50, -46, -40, -31, -22, -8, };