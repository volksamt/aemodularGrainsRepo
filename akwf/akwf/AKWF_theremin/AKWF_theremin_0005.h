#define DATA_LENGTH 512
#define DATA AKWF_theremin_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 2, 2, 1, 2, 2, 1, 1, 1, 1,
1, 1, 2, 2, 4, 6, 7, 8, 10, 12, 13, 15, 17, 18, 20, 23, 23, 25, 27, 27, 28, 30,
30, 30, 31, 32, 32, 31, 32, 32, 32, 32, 32, 32, 31, 31, 31, 30, 30, 29, 28, 29,
28, 26, 26, 24, 23, 24, 21, 21, 21, 20, 18, 17, 16, 16, 14, 14, 13, 12, 12, 11,
10, 8, 8, 7, 7, 6, 5, 5, 5, 5, 4, 3, 3, 4, 3, 4, 4, 3, 3, 3, 4, 5, 5, 5, 6, 6,
8, 7, 9, 9, 9, 10, 11, 13, 12, 14, 14, 14, 16, 17, 18, 18, 20, 21, 22, 23, 25,
26, 27, 28, 30, 31, 32, 34, 36, 36, 39, 40, 41, 43, 44, 47, 47, 50, 52, 52, 55,
56, 58, 59, 61, 62, 65, 66, 68, 71, 72, 73, 75, 76, 78, 80, 82, 84, 85, 87, 88,
90, 91, 93, 94, 95, 98, 99, 101, 102, 103, 105, 106, 106, 108, 109, 110, 111,
111, 112, 112, 113, 114, 115, 116, 117, 117, 117, 118, 117, 118, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 118, 117, 118, 117, 116, 116,
116, 115, 115, 114, 114, 114, 113, 113, 111, 112, 111, 111, 109, 109, 108, 107,
106, 104, 104, 103, 103, 101, 99, 98, 97, 95, 95, 93, 91, 91, 89, 87, 86, 85,
82, 81, 80, 78, 76, 75, 74, 72, 70, 69, 66, 65, 63, 62, 59, 58, 56, 54, 52, 50,
50, 47, 45, 43, 42, 40, 38, 36, 35, 33, 30, 29, 28, 25, 23, 22, 20, 19, 16, 15,
13, 12, 9, 7, 6, 5, 2, 0, -1, -3, -5, -6, -7, -10, -11, -13, -15, -16, -18, -19,
-20, -22, -24, -26, -27, -29, -31, -32, -34, -35, -36, -38, -40, -41, -43, -44,
-46, -47, -49, -50, -51, -53, -54, -56, -57, -58, -60, -62, -63, -64, -66, -67,
-69, -71, -72, -73, -76, -76, -77, -79, -80, -82, -83, -84, -85, -87, -87, -89,
-89, -91, -91, -92, -94, -94, -95, -96, -97, -97, -99, -99, -99, -100, -100,
-100, -101, -102, -102, -103, -103, -103, -104, -104, -105, -104, -105, -106,
-106, -106, -107, -106, -107, -107, -107, -107, -106, -106, -106, -106, -105,
-106, -105, -105, -106, -106, -105, -105, -104, -104, -105, -104, -104, -104,
-104, -105, -103, -104, -103, -103, -103, -104, -104, -103, -102, -103, -102,
-102, -102, -103, -102, -102, -101, -101, -101, -101, -100, -100, -100, -100,
-99, -99, -99, -99, -98, -98, -98, -98, -97, -96, -97, -96, -96, -96, -95, -94,
-93, -94, -93, -93, -92, -92, -91, -90, -90, -89, -88, -87, -87, -86, -85, -84,
-83, -82, -81, -79, -78, -77, -76, -75, -73, -72, -70, -68, -67, -66, -64, -63,
-61, -59, -57, -55, -53, -51, -50, -48, -46, -43, -41, -39, -38, -34, -32, -29,
-27, -24, -22, -19, -17, -14, -13, -10, -8, -6, -5, -3, -2, 0, 1, };