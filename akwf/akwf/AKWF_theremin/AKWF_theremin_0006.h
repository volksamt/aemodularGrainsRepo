#define DATA_LENGTH 512
#define DATA AKWF_theremin_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 10, 11, 12, 14, 16, 19, 21, 22,
24, 27, 28, 31, 33, 35, 37, 39, 41, 44, 46, 47, 50, 51, 53, 55, 56, 57, 59, 62,
63, 65, 67, 67, 69, 70, 72, 73, 74, 76, 76, 79, 80, 80, 81, 84, 84, 86, 86, 87,
89, 89, 91, 92, 93, 94, 95, 96, 97, 99, 99, 100, 102, 102, 103, 104, 105, 105,
106, 107, 107, 108, 108, 109, 109, 109, 109, 109, 111, 110, 109, 110, 111, 111,
110, 110, 110, 111, 110, 111, 111, 110, 110, 109, 109, 109, 109, 109, 108, 109,
108, 109, 108, 108, 108, 107, 107, 107, 107, 107, 107, 107, 106, 106, 106, 106,
106, 105, 105, 104, 104, 104, 103, 103, 103, 102, 101, 100, 100, 99, 98, 98, 96,
96, 95, 95, 93, 93, 92, 91, 89, 89, 87, 87, 85, 86, 83, 82, 82, 80, 78, 78, 75,
74, 72, 71, 70, 68, 67, 65, 64, 62, 60, 58, 58, 55, 55, 54, 52, 52, 50, 49, 48,
48, 47, 46, 46, 45, 44, 44, 44, 43, 43, 42, 43, 43, 41, 42, 41, 42, 42, 41, 42,
43, 42, 43, 43, 43, 45, 44, 44, 44, 44, 43, 43, 42, 40, 40, 39, 38, 36, 34, 34,
31, 29, 27, 25, 23, 20, 18, 14, 12, 9, 6, 3, 0, -3, -7, -10, -13, -16, -20, -23,
-25, -28, -32, -35, -37, -41, -42, -45, -48, -50, -51, -54, -56, -57, -59, -61,
-62, -64, -64, -66, -68, -67, -68, -69, -70, -70, -70, -71, -71, -71, -71, -70,
-70, -70, -68, -68, -68, -67, -66, -65, -64, -63, -62, -60, -60, -58, -57, -56,
-53, -52, -50, -49, -47, -46, -44, -43, -41, -39, -37, -35, -35, -32, -31, -30,
-28, -26, -25, -23, -21, -20, -18, -17, -16, -15, -14, -12, -11, -10, -10, -9,
-9, -8, -8, -7, -7, -7, -7, -7, -7, -7, -8, -9, -9, -9, -10, -11, -12, -13, -13,
-14, -16, -16, -18, -19, -21, -21, -22, -23, -25, -26, -27, -29, -30, -31, -32,
-35, -37, -38, -40, -41, -43, -45, -47, -47, -49, -51, -53, -55, -56, -57, -59,
-60, -61, -62, -64, -65, -66, -69, -70, -71, -74, -75, -77, -78, -80, -81, -83,
-85, -86, -86, -89, -90, -91, -92, -94, -94, -95, -98, -98, -99, -101, -101,
-103, -103, -106, -107, -107, -108, -110, -110, -111, -112, -113, -114, -115,
-115, -117, -116, -118, -118, -118, -119, -119, -120, -120, -119, -119, -119,
-119, -118, -118, -118, -119, -118, -118, -117, -118, -118, -118, -118, -117,
-117, -117, -117, -116, -116, -114, -113, -113, -112, -112, -111, -110, -109,
-108, -106, -106, -104, -102, -102, -100, -100, -98, -96, -95, -93, -92, -89,
-89, -88, -86, -84, -83, -81, -79, -78, -76, -74, -73, -70, -68, -66, -64, -62,
-61, -59, -57, -56, -53, -52, -50, -49, -47, -46, -43, -41, -40, -38, -36, -34,
-32, -30, -28, -25, -24, -22, -19, -18, -15, -14, -12, -11, -9, -7, -6, -5, -5,
-3, 0, };