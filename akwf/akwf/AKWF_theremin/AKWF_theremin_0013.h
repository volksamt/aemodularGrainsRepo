#define DATA_LENGTH 512
#define DATA AKWF_theremin_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 16, 27, 41, 53, 64, 74, 82, 87, 90,
94, 97, 99, 102, 104, 105, 107, 109, 110, 112, 112, 113, 114, 115, 116, 117,
118, 118, 119, 118, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 118, 118,
117, 117, 116, 116, 115, 114, 113, 113, 113, 114, 112, 113, 112, 112, 112, 111,
111, 110, 110, 110, 109, 109, 109, 108, 107, 107, 107, 106, 105, 105, 104, 105,
103, 104, 103, 102, 102, 102, 101, 101, 100, 100, 99, 99, 98, 98, 98, 98, 97,
96, 96, 95, 95, 95, 94, 93, 93, 93, 92, 92, 91, 91, 91, 91, 90, 90, 90, 89, 88,
88, 88, 88, 87, 86, 87, 87, 86, 86, 85, 85, 85, 85, 84, 84, 82, 83, 82, 82, 82,
81, 81, 81, 80, 81, 80, 80, 79, 78, 79, 79, 78, 78, 77, 77, 77, 77, 76, 75, 76,
76, 76, 76, 75, 74, 74, 74, 75, 74, 74, 74, 73, 72, 72, 72, 72, 72, 71, 71, 71,
70, 71, 71, 70, 70, 70, 70, 69, 69, 70, 69, 68, 69, 69, 68, 67, 67, 67, 68, 67,
67, 66, 66, 66, 66, 66, 65, 65, 65, 65, 65, 65, 65, 65, 64, 65, 64, 64, 64, 63,
63, 63, 63, 63, 63, 63, 63, 63, 63, 64, 64, 63, 64, 63, 63, 63, 63, 63, 64, 64,
64, 63, 64, 63, 63, 63, 64, 64, 64, 63, 63, 64, 63, 63, 63, 63, 63, 63, 62, 62,
63, 62, 60, 55, 48, 36, 25, 12, -2, -13, -23, -29, -34, -38, -43, -47, -50, -54,
-57, -60, -64, -66, -69, -71, -75, -76, -78, -81, -83, -86, -88, -89, -92, -93,
-94, -96, -98, -99, -101, -101, -103, -104, -104, -106, -107, -107, -110, -110,
-111, -111, -111, -110, -112, -112, -113, -113, -114, -115, -115, -116, -117,
-117, -117, -117, -117, -117, -118, -117, -118, -118, -117, -118, -117, -118,
-118, -118, -118, -118, -118, -117, -118, -118, -117, -117, -117, -116, -116,
-117, -116, -116, -115, -115, -115, -115, -114, -114, -113, -113, -114, -112,
-112, -111, -111, -111, -111, -111, -110, -110, -109, -110, -109, -108, -108,
-107, -107, -106, -107, -106, -106, -105, -105, -104, -104, -104, -103, -103,
-102, -102, -102, -101, -100, -101, -101, -100, -101, -100, -99, -98, -99, -99,
-98, -97, -97, -97, -97, -97, -95, -94, -95, -94, -95, -93, -94, -93, -93, -92,
-92, -92, -91, -91, -90, -90, -90, -90, -89, -89, -89, -88, -88, -87, -88, -87,
-87, -86, -87, -86, -86, -85, -85, -84, -84, -84, -83, -83, -82, -82, -82, -81,
-81, -82, -81, -80, -80, -80, -79, -79, -79, -79, -78, -77, -76, -76, -76, -75,
-74, -74, -73, -73, -72, -71, -71, -70, -69, -69, -69, -67, -66, -66, -65, -63,
-63, -63, -62, -61, -62, -60, -60, -59, -58, -57, -56, -55, -54, -53, -53, -51,
-50, -49, -47, -46, -44, -43, -41, -41, -38, -37, -35, -34, -31, -30, -28, -26,
-24, -22, -20, -18, -17, -13, -9, -5, 0, };