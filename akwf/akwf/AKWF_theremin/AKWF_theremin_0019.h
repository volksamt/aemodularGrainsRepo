#define DATA_LENGTH 512
#define DATA AKWF_theremin_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 0, 2, 6, 13, 22, 30, 40, 50, 60,
71, 81, 89, 95, 100, 104, 106, 107, 109, 110, 112, 113, 114, 115, 115, 116, 116,
117, 117, 118, 117, 117, 118, 119, 118, 118, 119, 119, 119, 119, 119, 119, 118,
120, 119, 119, 119, 118, 118, 119, 119, 118, 118, 117, 117, 117, 117, 116, 116,
115, 115, 116, 114, 114, 113, 113, 112, 112, 112, 111, 110, 110, 109, 109, 108,
108, 107, 106, 106, 106, 105, 105, 105, 105, 105, 104, 105, 105, 104, 103, 103,
102, 102, 101, 102, 101, 101, 99, 99, 99, 98, 97, 98, 97, 97, 96, 96, 96, 96,
96, 97, 95, 95, 96, 95, 95, 95, 94, 94, 94, 94, 94, 94, 95, 93, 93, 93, 93, 93,
92, 92, 92, 92, 92, 91, 91, 91, 90, 90, 90, 89, 90, 89, 90, 89, 89, 87, 87, 87,
87, 86, 86, 87, 87, 86, 85, 85, 84, 83, 84, 84, 85, 85, 84, 82, 79, 75, 69, 62,
55, 46, 35, 24, 15, 5, -2, -8, -13, -17, -20, -23, -27, -30, -32, -33, -36, -37,
-40, -42, -44, -46, -47, -48, -50, -51, -53, -54, -55, -57, -58, -59, -61, -62,
-62, -64, -65, -66, -67, -68, -68, -69, -70, -70, -71, -71, -71, -72, -73, -73,
-74, -75, -75, -75, -76, -76, -76, -75, -76, -76, -76, -76, -76, -75, -76, -76,
-75, -75, -75, -74, -75, -75, -75, -74, -74, -75, -75, -75, -75, -75, -74, -74,
-74, -74, -74, -74, -74, -73, -74, -73, -73, -72, -73, -72, -72, -72, -71, -71,
-71, -71, -70, -71, -70, -70, -70, -70, -69, -69, -69, -68, -68, -68, -68, -67,
-67, -66, -66, -66, -67, -65, -65, -65, -65, -65, -64, -65, -65, -63, -64, -64,
-63, -62, -63, -62, -62, -62, -61, -62, -61, -60, -61, -59, -59, -60, -59, -59,
-58, -59, -58, -57, -58, -57, -58, -57, -58, -57, -57, -56, -56, -56, -55, -56,
-56, -56, -55, -55, -54, -53, -53, -53, -54, -53, -52, -52, -53, -52, -52, -52,
-52, -51, -51, -51, -51, -51, -51, -51, -51, -49, -49, -50, -49, -49, -49, -50,
-49, -48, -48, -48, -48, -48, -48, -48, -47, -47, -48, -47, -47, -47, -47, -47,
-46, -46, -46, -45, -46, -45, -46, -45, -45, -45, -45, -44, -44, -44, -43, -44,
-45, -45, -44, -43, -44, -44, -43, -44, -42, -43, -42, -42, -42, -43, -42, -42,
-41, -41, -41, -41, -41, -42, -41, -41, -41, -41, -40, -39, -40, -39, -39, -40,
-39, -39, -39, -39, -39, -39, -39, -39, -40, -39, -39, -39, -39, -38, -37, -38,
-37, -37, -36, -37, -36, -36, -37, -36, -36, -37, -37, -36, -37, -37, -36, -36,
-36, -36, -37, -36, -36, -36, -37, -37, -36, -36, -36, -35, -35, -34, -34, -34,
-33, -33, -33, -32, -33, -30, -31, -29, -29, -29, -29, -27, -28, -26, -26, -25,
-24, -22, -22, -20, -20, -19, -18, -17, -16, -14, -13, -11, -9, -8, -6, -4, -2,
-1, -1, 0, };