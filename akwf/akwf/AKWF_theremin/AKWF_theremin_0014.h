#define DATA_LENGTH 512
#define DATA AKWF_theremin_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 18, 29, 38, 46, 52, 53, 56, 56, 56,
57, 59, 59, 61, 62, 63, 63, 66, 67, 68, 70, 70, 71, 73, 74, 75, 76, 78, 78, 79,
79, 81, 82, 82, 83, 83, 84, 85, 86, 86, 87, 88, 89, 90, 90, 91, 91, 91, 92, 92,
94, 94, 95, 96, 96, 96, 98, 98, 98, 98, 99, 99, 100, 99, 100, 100, 101, 101,
101, 102, 102, 102, 103, 102, 103, 103, 103, 104, 104, 104, 104, 105, 104, 106,
106, 106, 106, 106, 106, 106, 107, 107, 108, 108, 108, 108, 109, 109, 109, 109,
110, 110, 111, 109, 111, 110, 111, 111, 111, 111, 111, 111, 111, 111, 110, 111,
111, 112, 111, 112, 112, 112, 112, 112, 112, 112, 112, 113, 112, 111, 112, 111,
111, 111, 111, 112, 111, 111, 111, 111, 112, 112, 111, 111, 110, 111, 112, 111,
111, 110, 111, 111, 111, 111, 111, 111, 111, 110, 111, 111, 111, 111, 111, 111,
112, 111, 111, 112, 112, 112, 112, 112, 112, 112, 112, 112, 111, 111, 111, 111,
110, 111, 111, 110, 110, 111, 110, 111, 111, 111, 111, 111, 111, 111, 111, 110,
110, 110, 110, 109, 109, 109, 109, 109, 109, 108, 109, 109, 108, 109, 109, 110,
110, 110, 109, 109, 110, 111, 110, 110, 110, 109, 109, 109, 108, 107, 105, 103,
100, 97, 94, 89, 85, 79, 73, 68, 62, 54, 49, 42, 36, 30, 25, 21, 16, 12, 8, 5,
2, -1, -4, -7, -9, -12, -14, -17, -18, -20, -22, -24, -26, -28, -29, -30, -32,
-34, -36, -38, -40, -41, -42, -45, -47, -47, -49, -52, -52, -55, -56, -58, -59,
-61, -62, -62, -64, -66, -67, -68, -69, -70, -71, -73, -74, -76, -76, -78, -79,
-80, -81, -83, -83, -85, -86, -86, -87, -88, -89, -90, -90, -91, -92, -93, -94,
-94, -94, -95, -96, -98, -98, -99, -100, -100, -101, -101, -102, -103, -103,
-104, -104, -105, -105, -106, -105, -106, -107, -107, -107, -107, -108, -108,
-108, -109, -110, -110, -110, -111, -110, -111, -111, -112, -112, -113, -112,
-113, -113, -114, -114, -114, -114, -115, -115, -115, -115, -115, -115, -116,
-117, -117, -118, -118, -118, -118, -118, -119, -119, -119, -118, -118, -119,
-118, -118, -118, -117, -118, -117, -117, -117, -118, -117, -118, -118, -119,
-119, -119, -118, -119, -119, -118, -119, -119, -119, -118, -119, -119, -119,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -118, -120,
-119, -119, -119, -120, -120, -118, -118, -118, -118, -117, -116, -117, -117,
-116, -117, -115, -115, -115, -115, -115, -115, -115, -114, -114, -116, -115,
-114, -114, -114, -114, -113, -112, -112, -111, -111, -109, -109, -108, -108,
-108, -107, -107, -107, -106, -106, -106, -106, -105, -105, -104, -103, -101,
-102, -99, -98, -97, -95, -95, -93, -93, -91, -90, -90, -89, -88, -89, -88, -87,
-86, -86, -86, -85, -83, -82, -79, -76, -72, -69, -65, -60, -57, -52, -48, -42,
-38, -33, -31, -27, -25, -24, -20, -16, -9, -1, };