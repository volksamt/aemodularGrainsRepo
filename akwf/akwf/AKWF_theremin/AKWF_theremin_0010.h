#define DATA_LENGTH 512
#define DATA AKWF_theremin_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 2, 3, 4, 4, 5, 6, 7, 7, 7, 7,
8, 9, 9, 9, 10, 10, 11, 11, 12, 11, 11, 12, 13, 13, 14, 14, 14, 14, 14, 14, 14,
14, 15, 15, 16, 14, 15, 14, 15, 16, 15, 15, 15, 15, 14, 16, 15, 15, 15, 15, 16,
16, 16, 16, 15, 15, 15, 16, 15, 16, 15, 16, 16, 15, 15, 16, 15, 15, 15, 15, 15,
16, 15, 15, 15, 15, 15, 15, 15, 14, 15, 15, 15, 14, 14, 14, 14, 14, 14, 13, 14,
13, 13, 13, 13, 13, 12, 12, 12, 12, 12, 13, 12, 13, 12, 12, 13, 12, 12, 12, 12,
13, 13, 13, 13, 13, 14, 14, 14, 15, 15, 15, 15, 16, 16, 17, 17, 18, 18, 19, 20,
20, 20, 21, 21, 24, 24, 25, 27, 28, 29, 30, 31, 33, 35, 37, 39, 41, 43, 45, 47,
49, 52, 55, 58, 61, 64, 68, 71, 75, 79, 82, 85, 88, 93, 96, 100, 102, 106, 109,
111, 113, 114, 115, 117, 117, 119, 119, 119, 119, 119, 118, 118, 118, 117, 117,
117, 115, 114, 114, 112, 111, 111, 110, 109, 108, 107, 106, 105, 105, 104, 103,
102, 102, 101, 100, 99, 98, 98, 96, 97, 95, 95, 94, 94, 93, 93, 93, 91, 91, 90,
90, 90, 89, 89, 89, 87, 86, 84, 83, 81, 77, 72, 64, 54, 41, 26, 12, -3, -16,
-27, -37, -44, -50, -52, -55, -57, -60, -61, -62, -62, -64, -64, -65, -65, -65,
-65, -66, -66, -66, -66, -66, -66, -66, -67, -66, -67, -66, -67, -66, -67, -67,
-66, -66, -66, -66, -65, -65, -65, -65, -66, -65, -64, -64, -64, -63, -63, -62,
-62, -62, -62, -61, -61, -60, -60, -60, -60, -59, -58, -58, -57, -57, -57, -56,
-56, -56, -55, -54, -54, -53, -54, -53, -52, -53, -52, -51, -51, -51, -49, -50,
-49, -49, -49, -48, -48, -48, -47, -47, -46, -47, -46, -46, -46, -46, -45, -45,
-45, -44, -44, -44, -44, -44, -44, -43, -44, -43, -43, -42, -42, -41, -42, -41,
-42, -41, -41, -41, -41, -42, -40, -41, -40, -40, -41, -39, -40, -39, -40, -40,
-40, -39, -39, -39, -39, -39, -38, -37, -38, -38, -38, -37, -37, -39, -37, -37,
-38, -37, -37, -36, -37, -37, -36, -36, -37, -37, -37, -37, -36, -36, -35, -36,
-36, -36, -36, -36, -35, -35, -36, -35, -35, -35, -35, -35, -35, -34, -35, -35,
-34, -34, -34, -34, -34, -34, -34, -34, -33, -34, -33, -33, -33, -33, -32, -33,
-33, -33, -32, -32, -32, -32, -33, -32, -32, -31, -31, -31, -31, -31, -31, -30,
-31, -30, -30, -30, -31, -30, -29, -28, -30, -29, -29, -28, -28, -27, -28, -27,
-26, -27, -27, -25, -25, -25, -24, -23, -24, -23, -23, -22, -21, -22, -20, -20,
-19, -19, -18, -17, -17, -16, -16, -15, -14, -13, -12, -12, -12, -10, -11, -9,
-8, -8, -8, -6, -6, -5, -4, -3, -4, -2, -1, -1, 0, };