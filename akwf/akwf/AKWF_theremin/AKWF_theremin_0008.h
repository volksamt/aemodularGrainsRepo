#define DATA_LENGTH 512
#define DATA AKWF_theremin_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 12, 19, 27, 37, 48, 59, 70, 79,
89, 94, 99, 104, 105, 107, 110, 110, 111, 113, 113, 114, 115, 116, 116, 117,
118, 118, 117, 118, 118, 118, 118, 119, 118, 119, 118, 120, 118, 119, 119, 119,
119, 119, 118, 119, 119, 118, 118, 118, 117, 117, 116, 117, 116, 116, 116, 116,
115, 114, 114, 114, 113, 113, 112, 111, 110, 111, 109, 109, 109, 108, 108, 107,
107, 107, 106, 106, 106, 104, 104, 104, 104, 104, 104, 104, 103, 103, 102, 102,
101, 101, 101, 100, 101, 99, 99, 98, 98, 97, 97, 97, 96, 97, 96, 96, 96, 95, 96,
95, 95, 96, 95, 95, 95, 95, 95, 94, 94, 94, 92, 93, 93, 92, 92, 91, 92, 92, 92,
91, 90, 91, 90, 90, 91, 90, 89, 89, 89, 89, 89, 88, 89, 87, 86, 87, 87, 87, 87,
85, 86, 85, 85, 84, 83, 84, 84, 83, 83, 83, 83, 82, 82, 79, 74, 66, 59, 51, 41,
31, 23, 13, 4, -4, -9, -16, -20, -22, -25, -27, -30, -32, -35, -37, -40, -41,
-43, -45, -46, -47, -49, -51, -51, -54, -55, -56, -58, -59, -59, -61, -62, -63,
-64, -65, -66, -67, -68, -69, -69, -70, -70, -71, -71, -72, -72, -74, -74, -74,
-74, -75, -74, -74, -75, -75, -76, -75, -75, -76, -75, -75, -76, -75, -75, -75,
-75, -75, -74, -75, -74, -74, -74, -74, -74, -75, -74, -75, -75, -75, -75, -74,
-74, -73, -74, -73, -73, -73, -73, -72, -72, -73, -72, -71, -71, -71, -71, -70,
-71, -71, -69, -70, -69, -69, -69, -69, -68, -68, -68, -68, -68, -67, -67, -66,
-67, -66, -66, -66, -65, -66, -65, -65, -64, -65, -63, -64, -63, -62, -63, -63,
-62, -63, -62, -61, -62, -61, -62, -61, -60, -60, -60, -60, -60, -60, -59, -59,
-58, -58, -58, -57, -57, -57, -57, -57, -56, -56, -56, -56, -56, -55, -56, -55,
-55, -54, -54, -54, -54, -54, -52, -52, -52, -53, -53, -52, -52, -51, -51, -52,
-51, -51, -51, -50, -51, -50, -49, -50, -50, -49, -49, -49, -50, -49, -49, -48,
-49, -48, -48, -48, -48, -48, -47, -48, -47, -47, -47, -46, -47, -46, -45, -46,
-45, -45, -45, -45, -45, -44, -44, -44, -44, -44, -43, -43, -44, -43, -44, -43,
-44, -43, -43, -43, -42, -41, -43, -42, -42, -42, -42, -41, -40, -41, -41, -41,
-41, -40, -41, -41, -41, -40, -41, -40, -39, -39, -39, -39, -39, -40, -39, -39,
-39, -39, -38, -38, -39, -39, -38, -38, -38, -38, -38, -37, -37, -37, -37, -37,
-37, -37, -37, -36, -36, -36, -35, -36, -35, -36, -35, -36, -36, -36, -36, -36,
-36, -36, -36, -36, -35, -36, -35, -35, -36, -35, -35, -34, -33, -34, -34, -34,
-33, -33, -31, -32, -31, -30, -30, -29, -29, -28, -28, -28, -27, -26, -26, -25,
-22, -22, -21, -20, -20, -18, -17, -17, -15, -14, -12, -11, -10, -8, -7, -5, -3,
-2, -2, -1, -1, 0, };