#define DATA_LENGTH 512
#define DATA AKWF_theremin_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 3, 4, 5, 6, 7, 8, 9, 10, 12, 12,
13, 14, 15, 16, 17, 18, 19, 20, 21, 21, 22, 22, 24, 25, 25, 27, 28, 28, 28, 29,
31, 32, 32, 33, 33, 34, 36, 35, 37, 37, 39, 39, 39, 41, 42, 42, 42, 43, 44, 45,
46, 46, 47, 48, 49, 48, 49, 51, 51, 51, 53, 53, 53, 55, 55, 56, 56, 57, 58, 58,
59, 60, 60, 61, 62, 63, 62, 64, 64, 65, 65, 66, 66, 67, 68, 67, 68, 69, 70, 71,
71, 72, 72, 73, 73, 74, 74, 76, 75, 76, 77, 78, 78, 78, 79, 80, 80, 80, 81, 82,
82, 83, 82, 83, 84, 83, 85, 84, 85, 87, 86, 86, 87, 87, 88, 89, 89, 89, 91, 90,
91, 91, 91, 92, 92, 93, 93, 93, 94, 93, 94, 94, 95, 95, 95, 95, 96, 96, 96, 96,
97, 96, 96, 97, 98, 97, 98, 98, 99, 98, 98, 98, 98, 98, 99, 98, 98, 99, 98, 98,
98, 98, 98, 98, 97, 97, 97, 96, 96, 96, 96, 97, 96, 95, 96, 94, 95, 94, 94, 93,
93, 93, 92, 92, 91, 91, 91, 89, 90, 90, 88, 88, 88, 87, 85, 84, 85, 83, 83, 81,
81, 80, 80, 78, 78, 78, 76, 75, 74, 74, 72, 71, 71, 70, 69, 67, 67, 65, 65, 63,
62, 61, 60, 58, 57, 55, 54, 53, 52, 50, 49, 48, 46, 44, 43, 42, 41, 40, 38, 37,
35, 34, 31, 31, 29, 28, 26, 23, 23, 20, 19, 17, 15, 13, 13, 11, 10, 8, 5, 4, 3,
1, -1, -3, -4, -5, -8, -9, -10, -12, -14, -15, -17, -19, -21, -22, -23, -25,
-27, -29, -31, -33, -35, -36, -38, -40, -40, -42, -44, -47, -48, -50, -52, -53,
-54, -56, -57, -59, -60, -63, -64, -66, -67, -69, -70, -71, -74, -74, -76, -78,
-78, -80, -81, -83, -83, -84, -87, -88, -88, -90, -91, -92, -93, -95, -95, -97,
-97, -99, -99, -101, -102, -102, -104, -105, -105, -106, -107, -108, -108, -109,
-109, -111, -111, -112, -113, -114, -114, -115, -114, -115, -116, -117, -117,
-117, -117, -118, -117, -118, -117, -118, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -118,
-118, -117, -117, -117, -117, -116, -116, -115, -114, -115, -114, -114, -113,
-113, -112, -111, -111, -109, -109, -109, -108, -107, -107, -106, -105, -104,
-103, -103, -101, -101, -100, -100, -99, -98, -97, -96, -95, -94, -92, -92, -91,
-91, -88, -88, -87, -85, -85, -84, -83, -81, -81, -80, -78, -77, -76, -76, -74,
-73, -71, -70, -69, -67, -67, -65, -64, -63, -61, -61, -60, -58, -57, -55, -55,
-53, -52, -51, -50, -49, -48, -46, -45, -45, -43, -42, -40, -39, -37, -36, -36,
-34, -33, -32, -31, -30, -28, -28, -26, -25, -24, -23, -22, -20, -20, -19, -18,
-16, -15, -15, -12, -12, -11, -9, -8, -7, -6, -5, -5, -3, -2, -2, 0, };