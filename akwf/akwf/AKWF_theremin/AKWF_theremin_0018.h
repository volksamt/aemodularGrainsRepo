#define DATA_LENGTH 512
#define DATA AKWF_theremin_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 13, 17, 20, 24, 28, 30, 34,
36, 40, 42, 46, 48, 52, 54, 57, 60, 64, 67, 70, 72, 76, 79, 80, 84, 86, 88, 90,
91, 93, 94, 94, 96, 97, 96, 99, 99, 99, 100, 100, 100, 101, 101, 101, 101, 101,
102, 101, 103, 102, 103, 104, 103, 103, 104, 105, 105, 105, 106, 106, 107, 106,
107, 108, 107, 108, 108, 108, 109, 109, 110, 110, 109, 110, 110, 111, 111, 111,
112, 112, 112, 112, 113, 112, 112, 113, 113, 113, 113, 114, 114, 114, 114, 113,
114, 113, 113, 113, 113, 113, 114, 114, 114, 113, 114, 113, 113, 114, 115, 115,
114, 115, 114, 115, 116, 116, 116, 116, 116, 117, 117, 118, 118, 118, 118, 119,
118, 118, 118, 119, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 118, 119,
118, 116, 116, 115, 115, 113, 113, 110, 109, 108, 105, 103, 101, 99, 96, 93, 89,
86, 83, 79, 76, 72, 68, 65, 60, 57, 54, 49, 47, 42, 39, 35, 32, 30, 27, 24, 21,
18, 16, 15, 12, 10, 8, 5, 3, 1, -1, -1, -3, -5, -7, -8, -9, -12, -11, -13, -14,
-16, -17, -18, -20, -20, -21, -22, -23, -24, -24, -24, -26, -26, -26, -28, -28,
-29, -29, -31, -31, -31, -33, -33, -34, -34, -36, -36, -37, -36, -39, -39, -39,
-40, -40, -41, -41, -43, -43, -43, -44, -45, -45, -45, -46, -47, -47, -47, -47,
-48, -49, -49, -49, -50, -50, -51, -52, -52, -52, -52, -52, -54, -55, -53, -55,
-55, -56, -57, -56, -56, -57, -58, -58, -59, -60, -60, -59, -61, -61, -62, -62,
-61, -62, -62, -62, -63, -63, -63, -63, -64, -64, -64, -64, -64, -65, -64, -65,
-64, -65, -65, -65, -65, -65, -65, -66, -66, -66, -66, -66, -66, -67, -67, -67,
-67, -66, -67, -67, -68, -67, -68, -68, -68, -68, -67, -69, -68, -68, -68, -69,
-68, -69, -69, -68, -69, -68, -69, -68, -69, -68, -69, -68, -69, -69, -69, -69,
-69, -69, -69, -69, -69, -69, -69, -69, -70, -70, -69, -70, -69, -70, -70, -71,
-69, -70, -70, -70, -70, -71, -70, -70, -70, -71, -71, -71, -71, -71, -71, -71,
-70, -71, -70, -71, -71, -71, -70, -71, -71, -70, -70, -71, -71, -71, -70, -71,
-71, -71, -70, -71, -71, -70, -71, -71, -70, -70, -70, -70, -70, -70, -70, -69,
-69, -69, -69, -69, -68, -68, -68, -68, -67, -67, -67, -67, -66, -65, -67, -65,
-65, -65, -64, -65, -63, -64, -63, -63, -62, -62, -63, -62, -62, -62, -61, -61,
-61, -62, -61, -60, -61, -60, -60, -60, -59, -59, -59, -58, -58, -58, -57, -56,
-56, -56, -55, -55, -54, -54, -53, -53, -52, -52, -50, -51, -50, -49, -48, -48,
-47, -47, -47, -46, -45, -45, -44, -45, -43, -44, -43, -43, -41, -41, -41, -39,
-39, -38, -38, -36, -36, -34, -33, -32, -31, -31, -30, -28, -26, -25, -24, -22,
-19, -17, -14, -12, -7, -5, -1, };