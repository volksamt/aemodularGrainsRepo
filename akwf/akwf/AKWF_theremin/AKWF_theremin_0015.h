#define DATA_LENGTH 512
#define DATA AKWF_theremin_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 11, 16, 19, 24, 29, 33, 37, 42,
47, 52, 58, 62, 67, 72, 76, 80, 84, 86, 88, 91, 92, 94, 96, 96, 97, 98, 98, 99,
99, 100, 100, 101, 102, 103, 103, 105, 104, 105, 105, 106, 107, 107, 108, 108,
109, 109, 109, 109, 110, 110, 111, 111, 111, 111, 112, 112, 112, 112, 112, 112,
114, 112, 114, 114, 114, 115, 115, 114, 114, 116, 115, 115, 116, 116, 116, 116,
116, 116, 117, 117, 117, 117, 117, 118, 118, 118, 118, 118, 118, 117, 117, 117,
117, 117, 118, 117, 118, 118, 118, 118, 118, 117, 117, 118, 118, 119, 119, 118,
119, 119, 119, 119, 119, 120, 120, 119, 118, 118, 118, 119, 118, 117, 117, 116,
116, 116, 116, 116, 116, 115, 116, 117, 117, 116, 118, 118, 118, 120, 118, 120,
119, 119, 119, 118, 118, 117, 116, 115, 114, 112, 111, 108, 106, 104, 101, 97,
95, 91, 87, 83, 79, 75, 69, 64, 58, 53, 48, 43, 38, 34, 30, 25, 21, 17, 13, 11,
7, 6, 3, 1, -2, -3, -5, -8, -10, -11, -12, -14, -15, -16, -18, -19, -21, -23,
-23, -25, -26, -27, -29, -30, -31, -31, -32, -33, -35, -34, -36, -37, -38, -39,
-38, -39, -41, -41, -42, -43, -43, -43, -45, -45, -46, -46, -47, -47, -48, -49,
-50, -50, -50, -51, -51, -51, -53, -52, -54, -53, -54, -54, -55, -55, -56, -56,
-57, -57, -58, -57, -58, -58, -59, -59, -60, -60, -59, -60, -60, -59, -61, -61,
-61, -61, -61, -61, -61, -61, -63, -62, -62, -62, -63, -63, -63, -64, -63, -63,
-64, -64, -64, -64, -64, -64, -65, -65, -63, -64, -64, -64, -64, -64, -64, -65,
-64, -64, -65, -65, -65, -65, -65, -65, -65, -65, -64, -65, -65, -65, -65, -66,
-65, -64, -66, -65, -65, -65, -64, -65, -64, -65, -64, -64, -63, -64, -64, -65,
-64, -64, -63, -63, -64, -63, -64, -65, -64, -64, -64, -63, -64, -63, -63, -64,
-64, -64, -63, -64, -64, -63, -63, -63, -63, -64, -63, -63, -63, -63, -63, -63,
-63, -64, -63, -64, -64, -64, -63, -64, -64, -63, -63, -64, -63, -64, -63, -64,
-64, -64, -65, -64, -64, -64, -65, -64, -65, -64, -65, -65, -64, -64, -64, -64,
-64, -64, -64, -64, -64, -64, -64, -64, -64, -64, -64, -64, -64, -64, -63, -64,
-64, -63, -63, -63, -63, -63, -63, -63, -63, -62, -63, -63, -63, -63, -63, -62,
-63, -62, -62, -63, -62, -62, -62, -62, -62, -62, -61, -61, -61, -61, -61, -61,
-60, -60, -61, -61, -59, -60, -60, -59, -58, -59, -59, -58, -58, -58, -58, -58,
-57, -57, -57, -56, -57, -56, -55, -56, -55, -55, -54, -54, -54, -54, -54, -53,
-53, -52, -51, -52, -51, -51, -50, -50, -50, -49, -48, -48, -47, -45, -44, -44,
-44, -43, -42, -42, -41, -39, -38, -37, -37, -36, -34, -33, -32, -31, -29, -29,
-26, -25, -23, -22, -21, -18, -16, -13, -11, -7, -4, -1, };