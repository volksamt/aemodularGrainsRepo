#define DATA_LENGTH 512
#define DATA AKWF_theremin_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 4, 4, 5, 7, 7, 9, 9, 11, 13,
15, 17, 22, 27, 34, 41, 51, 61, 70, 80, 89, 97, 103, 109, 113, 115, 117, 118,
118, 119, 118, 118, 118, 118, 117, 116, 115, 115, 113, 111, 112, 110, 109, 108,
107, 106, 105, 103, 103, 102, 101, 99, 98, 97, 97, 96, 95, 95, 93, 92, 92, 90,
90, 89, 88, 88, 86, 85, 85, 84, 83, 82, 81, 81, 80, 80, 79, 78, 78, 76, 76, 76,
75, 74, 73, 74, 73, 72, 71, 71, 70, 70, 70, 69, 68, 68, 67, 67, 66, 66, 66, 65,
64, 64, 64, 64, 63, 63, 62, 62, 62, 62, 61, 61, 60, 60, 59, 59, 60, 58, 59, 58,
57, 58, 57, 57, 56, 56, 56, 55, 56, 55, 55, 54, 56, 54, 54, 54, 54, 54, 54, 53,
53, 52, 53, 52, 52, 52, 51, 52, 51, 51, 51, 50, 52, 50, 50, 51, 50, 51, 49, 50,
49, 48, 49, 48, 49, 49, 48, 49, 49, 50, 50, 51, 50, 50, 50, 51, 51, 50, 50, 51,
51, 51, 50, 48, 47, 42, 37, 27, 14, 0, -14, -28, -38, -46, -52, -56, -59, -62,
-64, -67, -69, -70, -72, -73, -74, -75, -76, -76, -78, -78, -77, -78, -78, -79,
-78, -78, -78, -79, -79, -78, -79, -79, -78, -79, -79, -79, -78, -78, -77, -77,
-77, -77, -76, -76, -76, -75, -76, -75, -74, -74, -73, -72, -72, -71, -71, -70,
-71, -69, -69, -69, -67, -67, -66, -66, -65, -65, -64, -64, -64, -63, -62, -62,
-61, -61, -59, -59, -59, -59, -58, -58, -57, -56, -55, -56, -55, -55, -54, -53,
-53, -52, -53, -53, -51, -51, -50, -51, -49, -49, -49, -48, -48, -48, -47, -46,
-47, -46, -46, -46, -46, -45, -45, -44, -44, -44, -44, -43, -43, -42, -42, -42,
-42, -42, -40, -41, -41, -41, -40, -40, -39, -40, -40, -39, -39, -39, -38, -38,
-39, -38, -38, -38, -37, -38, -37, -37, -37, -36, -36, -37, -36, -37, -36, -36,
-36, -36, -35, -35, -35, -34, -35, -35, -34, -34, -34, -34, -34, -33, -33, -34,
-33, -34, -34, -33, -33, -32, -33, -32, -33, -33, -33, -33, -32, -32, -32, -32,
-32, -32, -32, -31, -32, -32, -31, -31, -31, -31, -31, -32, -31, -32, -32, -31,
-31, -31, -31, -30, -30, -31, -31, -31, -31, -30, -30, -30, -30, -30, -30, -30,
-30, -30, -29, -30, -30, -29, -30, -29, -30, -29, -29, -29, -30, -29, -30, -29,
-29, -29, -29, -28, -28, -29, -29, -28, -28, -29, -28, -28, -28, -29, -28, -28,
-29, -28, -28, -28, -28, -27, -27, -28, -28, -27, -26, -27, -27, -26, -26, -26,
-25, -26, -26, -26, -25, -26, -26, -24, -24, -25, -24, -24, -24, -24, -24, -23,
-22, -23, -22, -22, -21, -21, -20, -20, -20, -19, -19, -19, -19, -17, -17, -16,
-16, -16, -14, -14, -13, -13, -12, -11, -11, -11, -8, -8, -7, -7, -5, -5, -4,
-3, -2, -1, -1, 0, };