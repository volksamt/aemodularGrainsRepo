#define DATA_LENGTH 512
#define DATA AKWF_theremin_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 10, 19, 30, 43, 56, 68, 78, 85, 91,
95, 99, 101, 104, 106, 107, 110, 111, 112, 113, 115, 116, 116, 117, 118, 118,
118, 118, 119, 118, 119, 119, 120, 120, 119, 118, 118, 118, 117, 116, 115, 115,
114, 115, 115, 113, 113, 113, 113, 113, 111, 111, 111, 111, 109, 109, 110, 109,
108, 108, 107, 107, 106, 105, 104, 105, 104, 103, 103, 102, 102, 102, 101, 101,
101, 99, 100, 99, 99, 98, 97, 97, 97, 97, 95, 96, 94, 94, 94, 94, 93, 92, 92,
91, 91, 92, 91, 91, 90, 89, 89, 89, 88, 88, 87, 87, 86, 87, 85, 86, 86, 85, 86,
86, 86, 85, 86, 85, 86, 85, 84, 84, 85, 85, 84, 84, 84, 84, 83, 83, 84, 83, 82,
83, 83, 82, 81, 79, 79, 77, 74, 69, 61, 50, 39, 27, 15, 4, -5, -10, -16, -20,
-24, -27, -30, -32, -36, -38, -40, -42, -44, -46, -48, -50, -50, -53, -54, -55,
-57, -58, -58, -60, -60, -61, -61, -62, -62, -62, -63, -63, -64, -63, -64, -63,
-64, -65, -64, -65, -66, -65, -65, -65, -66, -66, -66, -66, -65, -66, -64, -64,
-64, -64, -64, -64, -63, -63, -64, -64, -63, -62, -63, -61, -62, -62, -61, -62,
-61, -61, -60, -60, -61, -59, -59, -58, -59, -58, -57, -57, -57, -58, -57, -57,
-56, -56, -56, -55, -55, -55, -55, -54, -54, -54, -53, -53, -53, -53, -52, -52,
-51, -51, -51, -50, -51, -50, -50, -50, -49, -49, -49, -49, -48, -48, -47, -47,
-47, -47, -47, -47, -46, -46, -46, -46, -46, -45, -44, -45, -44, -44, -44, -43,
-43, -43, -43, -43, -43, -42, -43, -42, -42, -42, -41, -41, -41, -41, -40, -40,
-40, -41, -40, -40, -39, -39, -39, -39, -40, -40, -39, -38, -37, -38, -38, -37,
-37, -38, -37, -37, -37, -37, -37, -36, -37, -37, -36, -37, -36, -37, -36, -35,
-36, -35, -35, -35, -34, -34, -35, -35, -35, -34, -34, -34, -34, -34, -34, -34,
-33, -33, -34, -34, -34, -33, -34, -34, -33, -33, -34, -33, -33, -33, -32, -33,
-32, -33, -32, -32, -31, -32, -31, -32, -31, -31, -31, -31, -31, -31, -31, -30,
-31, -31, -30, -30, -30, -30, -31, -31, -31, -30, -30, -30, -29, -29, -30, -30,
-30, -29, -29, -29, -30, -29, -29, -30, -29, -29, -28, -29, -29, -28, -29, -29,
-29, -29, -28, -28, -28, -28, -29, -28, -29, -27, -28, -28, -28, -28, -27, -28,
-27, -27, -27, -27, -28, -27, -27, -26, -27, -28, -27, -27, -26, -26, -26, -26,
-26, -27, -27, -26, -26, -26, -27, -26, -25, -26, -26, -26, -26, -26, -25, -25,
-26, -25, -25, -25, -24, -25, -25, -25, -24, -25, -24, -24, -24, -24, -23, -23,
-22, -22, -23, -22, -21, -21, -21, -21, -21, -20, -20, -21, -20, -21, -20, -20,
-19, -20, -19, -19, -18, -18, -18, -17, -17, -16, -14, -15, -14, -13, -12, -11,
-10, -10, -9, -8, -5, -5, -3, -1, };