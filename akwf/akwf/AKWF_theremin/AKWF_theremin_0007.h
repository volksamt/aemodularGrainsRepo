#define DATA_LENGTH 512
#define DATA AKWF_theremin_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 1, 2, 2, 1, 1, 1, 0, 1, 1, 0,
2, 3, 3, 5, 6, 8, 10, 13, 15, 18, 19, 21, 23, 25, 26, 28, 30, 32, 32, 34, 36,
37, 38, 40, 41, 42, 43, 44, 45, 47, 49, 50, 50, 51, 52, 53, 54, 55, 55, 56, 57,
58, 58, 60, 60, 60, 60, 62, 63, 62, 62, 63, 63, 63, 64, 64, 65, 65, 65, 66, 66,
66, 67, 67, 66, 68, 68, 68, 68, 69, 69, 68, 70, 70, 70, 70, 71, 72, 72, 73, 74,
74, 74, 75, 76, 77, 77, 78, 78, 80, 81, 82, 83, 83, 84, 85, 87, 87, 88, 89, 89,
91, 91, 92, 93, 94, 96, 96, 96, 96, 97, 97, 98, 99, 99, 98, 98, 98, 98, 98, 98,
96, 96, 94, 94, 92, 92, 90, 89, 86, 86, 83, 81, 79, 78, 76, 74, 71, 70, 67, 64,
63, 60, 58, 55, 53, 50, 48, 46, 43, 41, 39, 36, 35, 32, 30, 28, 26, 23, 22, 20,
19, 17, 15, 14, 12, 10, 9, 8, 7, 7, 4, 5, 4, 3, 2, 2, 1, 0, 1, 0, 0, 0, 0, 0, 1,
0, 2, 2, 3, 3, 3, 5, 6, 6, 7, 8, 8, 10, 11, 11, 13, 15, 16, 16, 19, 20, 21, 23,
24, 25, 26, 29, 29, 31, 32, 34, 35, 37, 39, 39, 41, 42, 43, 45, 46, 47, 48, 49,
50, 51, 52, 53, 53, 54, 54, 54, 55, 55, 55, 56, 56, 55, 55, 56, 57, 57, 57, 56,
56, 55, 56, 55, 56, 55, 55, 54, 54, 54, 53, 53, 50, 51, 49, 49, 48, 47, 46, 45,
44, 42, 42, 40, 39, 37, 36, 34, 32, 31, 29, 27, 25, 24, 22, 21, 20, 18, 15, 14,
12, 11, 8, 7, 5, 3, 2, -1, -2, -4, -6, -9, -10, -11, -14, -15, -18, -19, -20,
-23, -24, -26, -28, -30, -31, -33, -35, -36, -39, -39, -41, -43, -44, -46, -48,
-50, -51, -53, -54, -56, -58, -60, -62, -64, -65, -67, -69, -71, -72, -73, -76,
-76, -78, -80, -82, -83, -85, -86, -87, -89, -91, -91, -93, -95, -95, -97, -98,
-100, -100, -101, -102, -104, -105, -105, -106, -107, -108, -108, -110, -111,
-111, -112, -112, -113, -113, -114, -114, -114, -114, -114, -116, -116, -116,
-116, -117, -117, -117, -118, -118, -118, -118, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -118, -118,
-118, -118, -117, -117, -117, -116, -116, -115, -114, -113, -113, -112, -110,
-110, -109, -107, -107, -105, -104, -104, -102, -101, -99, -99, -98, -96, -94,
-93, -93, -91, -90, -88, -87, -85, -85, -84, -83, -80, -79, -77, -76, -76, -73,
-73, -72, -69, -69, -67, -66, -65, -63, -62, -60, -59, -57, -55, -54, -52, -51,
-50, -48, -46, -46, -43, -42, -41, -40, -38, -37, -35, -34, -32, -31, -30, -27,
-26, -24, -23, -21, -20, -17, -15, -14, -11, -10, -7, -6, -4, -3, -2, -1, };