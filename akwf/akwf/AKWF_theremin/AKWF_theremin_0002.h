#define DATA_LENGTH 512
#define DATA AKWF_theremin_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 11, 25, 41, 59, 73, 84, 91, 93, 94,
94, 95, 96, 98, 101, 103, 105, 106, 108, 109, 110, 113, 113, 115, 115, 116, 117,
118, 118, 119, 119, 119, 119, 120, 118, 119, 118, 119, 119, 119, 119, 119, 119,
119, 118, 118, 119, 118, 118, 118, 118, 118, 118, 118, 118, 117, 118, 118, 118,
118, 118, 118, 117, 118, 119, 118, 118, 118, 118, 118, 119, 119, 119, 118, 118,
118, 118, 117, 118, 118, 117, 117, 117, 116, 117, 117, 116, 117, 115, 116, 117,
116, 116, 116, 115, 116, 115, 115, 115, 115, 114, 115, 114, 114, 114, 115, 114,
114, 114, 114, 113, 112, 112, 112, 111, 110, 109, 108, 108, 107, 106, 105, 104,
102, 102, 100, 99, 97, 96, 95, 93, 91, 89, 88, 85, 82, 81, 78, 76, 74, 71, 69,
66, 63, 61, 57, 54, 52, 48, 46, 41, 39, 36, 33, 29, 26, 23, 19, 18, 15, 10, 7,
5, 2, -1, -3, -7, -9, -11, -15, -17, -19, -22, -24, -26, -28, -31, -33, -35,
-37, -38, -41, -42, -43, -46, -47, -48, -50, -51, -51, -53, -53, -54, -55, -55,
-57, -56, -56, -57, -58, -59, -59, -59, -59, -59, -60, -60, -61, -62, -62, -62,
-63, -62, -61, -63, -62, -64, -63, -63, -63, -63, -64, -63, -63, -63, -64, -64,
-64, -65, -64, -65, -64, -64, -64, -65, -64, -65, -65, -64, -66, -64, -65, -65,
-64, -64, -64, -65, -65, -64, -65, -65, -64, -64, -64, -64, -63, -63, -63, -62,
-63, -62, -63, -61, -62, -61, -62, -62, -61, -61, -60, -60, -61, -60, -60, -61,
-61, -60, -61, -61, -61, -61, -61, -62, -62, -62, -63, -64, -63, -63, -64, -63,
-64, -64, -64, -65, -64, -63, -65, -64, -64, -64, -64, -64, -64, -64, -63, -63,
-63, -63, -62, -63, -61, -62, -62, -61, -61, -61, -61, -60, -60, -60, -60, -59,
-59, -60, -59, -59, -58, -59, -59, -59, -58, -58, -58, -58, -59, -58, -58, -58,
-57, -58, -59, -57, -58, -58, -58, -57, -58, -57, -57, -58, -57, -58, -57, -57,
-57, -58, -57, -58, -57, -58, -58, -57, -58, -57, -58, -58, -58, -58, -58, -59,
-59, -60, -60, -60, -60, -60, -60, -60, -60, -61, -61, -60, -60, -61, -60, -60,
-60, -61, -59, -60, -60, -60, -60, -59, -60, -59, -58, -59, -58, -59, -58, -58,
-58, -57, -58, -58, -58, -58, -57, -58, -58, -57, -58, -58, -57, -57, -58, -58,
-58, -58, -58, -59, -57, -58, -58, -58, -58, -58, -58, -58, -57, -57, -57, -57,
-57, -56, -56, -55, -55, -55, -56, -55, -54, -55, -55, -54, -54, -54, -54, -54,
-54, -55, -55, -54, -54, -55, -55, -55, -56, -55, -55, -56, -57, -56, -56, -56,
-56, -54, -54, -54, -54, -52, -51, -50, -48, -47, -45, -43, -41, -39, -37, -34,
-32, -29, -27, -24, -22, -20, -17, -16, -14, -11, -10, -8, -7, -5, -4, -3, -3,
-2, -1, -1, 1, 1, 1, 1, -1, -3, -6, -7, -4, };