#define DATA_LENGTH 512
#define DATA AKWF_theremin_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 3, 5, 6, 6, 7, 9, 10, 11, 12,
12, 14, 14, 15, 17, 18, 18, 19, 21, 21, 22, 24, 24, 25, 25, 26, 27, 28, 29, 29,
30, 31, 32, 33, 34, 34, 35, 36, 36, 37, 38, 39, 39, 41, 41, 42, 42, 43, 44, 45,
46, 46, 46, 47, 48, 50, 50, 50, 51, 52, 53, 53, 53, 55, 55, 56, 56, 56, 58, 58,
59, 59, 60, 60, 62, 62, 63, 63, 64, 65, 65, 65, 67, 67, 67, 69, 69, 70, 70, 70,
71, 71, 71, 73, 73, 74, 75, 75, 76, 76, 77, 76, 78, 78, 79, 79, 80, 81, 81, 82,
83, 82, 82, 84, 83, 84, 85, 85, 85, 86, 86, 86, 87, 88, 88, 89, 89, 89, 90, 90,
91, 91, 92, 92, 92, 93, 93, 93, 93, 94, 95, 94, 95, 95, 95, 95, 95, 96, 96, 96,
97, 97, 97, 96, 98, 97, 97, 98, 97, 98, 97, 99, 98, 97, 98, 99, 98, 98, 98, 99,
97, 98, 97, 97, 97, 98, 97, 97, 96, 96, 97, 96, 95, 96, 95, 94, 95, 94, 93, 93,
93, 92, 92, 91, 91, 91, 91, 90, 89, 89, 89, 87, 87, 87, 86, 85, 84, 84, 84, 82,
82, 80, 79, 78, 77, 76, 76, 75, 75, 74, 73, 72, 71, 70, 69, 68, 67, 66, 64, 64,
62, 61, 61, 59, 57, 56, 54, 53, 51, 52, 50, 48, 46, 45, 43, 42, 41, 40, 38, 36,
36, 34, 32, 30, 29, 27, 26, 24, 22, 20, 19, 18, 15, 15, 13, 12, 9, 8, 6, 5, 3,
2, -1, -2, -4, -6, -7, -9, -10, -13, -14, -15, -17, -19, -20, -22, -23, -26,
-28, -29, -31, -33, -35, -36, -37, -40, -42, -43, -45, -46, -48, -49, -51, -53,
-55, -55, -58, -59, -60, -62, -63, -65, -67, -68, -69, -71, -73, -74, -76, -77,
-78, -80, -81, -83, -83, -84, -86, -88, -88, -90, -91, -92, -93, -94, -96, -96,
-97, -99, -99, -101, -101, -102, -103, -105, -106, -106, -107, -108, -109, -109,
-110, -110, -111, -112, -112, -113, -113, -115, -115, -114, -116, -117, -116,
-116, -116, -117, -118, -117, -118, -119, -118, -119, -119, -120, -118, -119,
-119, -120, -118, -119, -120, -119, -119, -118, -119, -118, -118, -119, -118,
-118, -117, -117, -117, -117, -116, -116, -116, -115, -114, -113, -114, -114,
-112, -112, -111, -111, -110, -109, -109, -109, -107, -106, -106, -105, -104,
-104, -102, -102, -101, -101, -100, -99, -98, -97, -96, -95, -94, -93, -92, -91,
-91, -89, -88, -87, -85, -85, -85, -83, -82, -80, -80, -79, -77, -76, -75, -74,
-73, -72, -70, -69, -67, -67, -66, -64, -63, -62, -61, -59, -59, -57, -56, -55,
-54, -52, -51, -50, -49, -47, -46, -45, -44, -43, -41, -40, -39, -38, -37, -36,
-35, -33, -32, -31, -30, -29, -27, -26, -25, -24, -23, -22, -20, -19, -18, -18,
-16, -15, -14, -13, -12, -11, -9, -9, -7, -6, -5, -4, -3, -3, 0, 0, };