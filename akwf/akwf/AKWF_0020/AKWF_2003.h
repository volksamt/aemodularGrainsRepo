#define DATA_LENGTH 512
#define DATA AKWF_2003

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 8, 10, 11, 14, 16, 18, 20,
21, 23, 25, 27, 28, 30, 32, 33, 35, 36, 39, 39, 41, 42, 43, 45, 46, 48, 49, 51,
51, 52, 54, 54, 55, 57, 57, 58, 59, 59, 60, 61, 62, 62, 61, 62, 63, 64, 63, 63,
64, 64, 63, 63, 64, 64, 63, 63, 63, 62, 61, 61, 61, 60, 59, 58, 58, 56, 56, 54,
53, 52, 50, 49, 47, 46, 44, 42, 41, 40, 37, 36, 34, 32, 31, 28, 28, 25, 24, 23,
21, 19, 18, 16, 15, 13, 12, 11, 10, 8, 7, 7, 6, 5, 5, 5, 4, 4, 5, 4, 4, 4, 4, 6,
6, 7, 8, 9, 9, 11, 12, 14, 15, 17, 20, 21, 22, 25, 27, 30, 32, 34, 37, 39, 41,
44, 46, 49, 51, 55, 58, 59, 63, 65, 68, 70, 72, 75, 78, 80, 83, 85, 88, 89, 92,
93, 96, 98, 99, 102, 104, 105, 107, 108, 109, 110, 111, 112, 112, 114, 115, 115,
116, 117, 117, 117, 118, 119, 118, 119, 119, 119, 119, 119, 118, 119, 118, 117,
118, 117, 117, 116, 115, 114, 114, 112, 112, 111, 109, 108, 107, 106, 105, 103,
102, 100, 98, 97, 95, 93, 93, 90, 88, 86, 83, 81, 79, 78, 74, 73, 71, 68, 65,
62, 59, 57, 53, 50, 48, 44, 41, 38, 35, 32, 28, 25, 23, 19, 15, 12, 9, 6, 3, -1,
-5, -7, -11, -14, -17, -20, -23, -26, -29, -31, -34, -37, -40, -42, -45, -47,
-50, -52, -54, -57, -58, -60, -61, -64, -65, -66, -68, -69, -70, -71, -72, -73,
-74, -74, -76, -76, -77, -77, -77, -78, -79, -78, -78, -79, -79, -79, -79, -79,
-79, -78, -78, -77, -77, -77, -77, -77, -76, -75, -74, -74, -74, -73, -73, -72,
-72, -70, -71, -70, -69, -68, -67, -68, -67, -66, -66, -65, -64, -63, -63, -62,
-62, -61, -60, -60, -59, -58, -58, -57, -56, -56, -54, -53, -53, -52, -52, -51,
-50, -50, -48, -48, -48, -46, -45, -46, -44, -43, -42, -42, -42, -40, -40, -40,
-39, -38, -38, -37, -37, -37, -35, -34, -34, -34, -33, -33, -33, -32, -32, -31,
-31, -30, -30, -30, -29, -29, -29, -29, -28, -28, -28, -27, -28, -28, -28, -27,
-26, -27, -26, -27, -27, -27, -26, -27, -26, -27, -27, -27, -27, -27, -27, -27,
-29, -28, -29, -30, -29, -29, -31, -31, -32, -33, -32, -34, -34, -34, -35, -37,
-36, -38, -39, -40, -40, -41, -42, -44, -46, -47, -49, -49, -51, -52, -53, -54,
-56, -57, -59, -61, -62, -62, -65, -65, -67, -69, -70, -71, -72, -73, -75, -76,
-76, -77, -79, -78, -80, -81, -81, -81, -82, -83, -83, -82, -83, -84, -83, -83,
-83, -82, -81, -81, -81, -79, -78, -77, -76, -76, -74, -73, -72, -69, -68, -66,
-65, -63, -60, -59, -57, -54, -53, -51, -48, -45, -43, -40, -38, -36, -33, -31,
-28, -26, -23, -20, -18, -16, -13, -10, -9, -6, -3, 0, };