#define DATA_LENGTH 512
#define DATA AKWF_1939

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 7, 9, 12, 16, 19, 21, 24, 26,
28, 29, 32, 33, 35, 37, 39, 41, 42, 44, 46, 48, 50, 52, 54, 55, 57, 60, 61, 63,
65, 66, 69, 71, 72, 75, 76, 78, 79, 81, 83, 85, 87, 89, 92, 93, 94, 96, 98, 100,
102, 104, 106, 108, 109, 106, 104, 102, 101, 98, 96, 94, 93, 91, 88, 86, 84, 82,
80, 78, 76, 74, 72, 71, 68, 66, 64, 62, 61, 57, 57, 55, 52, 50, 48, 46, 44, 43,
40, 37, 37, 34, 33, 31, 28, 26, 24, 22, 21, 19, 16, 16, 18, 18, 20, 21, 21, 22,
23, 24, 25, 26, 27, 27, 28, 30, 30, 32, 33, 33, 35, 35, 36, 37, 38, 38, 41, 41,
43, 42, 43, 45, 45, 47, 47, 48, 49, 51, 51, 52, 53, 54, 54, 55, 57, 57, 59, 59,
56, 54, 51, 48, 46, 44, 42, 40, 37, 34, 32, 30, 27, 25, 22, 19, 18, 14, 12, 11,
8, 6, 2, 0, -2, -4, -6, -10, -11, -14, -16, -18, -21, -23, -26, -27, -30, -32,
-36, -38, -41, -42, -44, -47, -49, -52, -52, -52, -51, -51, -50, -49, -49, -48,
-48, -48, -47, -47, -47, -46, -46, -46, -45, -44, -44, -44, -43, -43, -42, -42,
-41, -41, -40, -39, -39, -38, -39, -38, -37, -36, -36, -35, -36, -34, -34, -34,
-33, -33, -33, -32, -32, -31, -30, -28, -25, -22, -20, -17, -15, -12, -10, -7,
-6, -3, -1, 2, 5, 8, 9, 12, 13, 17, 19, 21, 24, 27, 29, 32, 34, 36, 38, 41, 44,
46, 49, 51, 54, 56, 59, 61, 63, 65, 68, 71, 73, 77, 78, 80, 83, 81, 79, 76, 73,
71, 68, 66, 63, 60, 57, 54, 52, 49, 47, 44, 41, 39, 36, 33, 30, 27, 24, 23, 20,
17, 14, 12, 9, 6, 4, 1, -1, -4, -7, -9, -12, -16, -19, -21, -23, -27, -29, -31,
-34, -37, -40, -41, -41, -42, -42, -42, -43, -43, -43, -44, -44, -44, -45, -45,
-45, -46, -45, -46, -46, -46, -47, -47, -48, -48, -49, -48, -49, -48, -49, -49,
-49, -50, -51, -51, -51, -51, -51, -52, -53, -52, -53, -53, -53, -53, -53, -55,
-54, -55, -54, -53, -53, -52, -51, -50, -50, -49, -49, -48, -48, -47, -45, -45,
-44, -44, -43, -42, -41, -42, -41, -39, -39, -39, -38, -37, -36, -36, -34, -34,
-34, -33, -32, -31, -31, -31, -29, -29, -27, -27, -26, -26, -25, -24, -23, -23,
-23, -25, -27, -30, -31, -33, -35, -37, -40, -42, -44, -46, -47, -50, -52, -55,
-57, -58, -61, -63, -64, -67, -69, -70, -72, -75, -77, -79, -82, -84, -86, -88,
-90, -92, -94, -96, -98, -100, -102, -105, -107, -109, -111, -113, -115, -117,
-119, -119, -114, -112, -109, -106, -102, -99, -97, -94, -91, -87, -84, -81,
-78, -75, -72, -69, -66, -63, -60, -57, -53, -50, -48, -44, -42, -38, -35, -32,
-29, -27, -24, -20, -17, -14, -10, -7, -5, -1, };