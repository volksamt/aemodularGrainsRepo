#define DATA_LENGTH 512
#define DATA AKWF_2000

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 5, 7, 10, 12, 13, 16, 17, 19,
21, 24, 27, 29, 31, 34, 37, 38, 42, 44, 46, 49, 51, 53, 56, 59, 61, 63, 66, 69,
71, 74, 76, 78, 81, 84, 85, 88, 91, 93, 96, 98, 101, 102, 106, 107, 110, 110,
108, 107, 106, 106, 105, 104, 103, 102, 101, 101, 98, 98, 98, 96, 95, 95, 93,
93, 91, 91, 91, 89, 88, 87, 85, 86, 85, 84, 83, 82, 81, 80, 78, 77, 77, 75, 72,
69, 66, 63, 61, 58, 55, 52, 50, 46, 43, 41, 38, 35, 32, 29, 27, 23, 20, 18, 15,
12, 10, 7, 3, 1, -2, -4, -8, -10, -13, -16, -20, -22, -25, -27, -28, -28, -29,
-30, -30, -29, -30, -30, -31, -30, -30, -31, -31, -31, -32, -31, -32, -32, -33,
-32, -32, -32, -33, -32, -33, -34, -33, -34, -34, -35, -34, -35, -34, -35, -35,
-35, -36, -32, -32, -29, -29, -27, -25, -23, -22, -19, -18, -17, -15, -13, -12,
-10, -8, -7, -5, -3, -2, -1, 2, 3, 5, 6, 9, 10, 12, 13, 14, 18, 18, 20, 21, 23,
25, 26, 28, 30, 31, 33, 34, 36, 37, 38, 40, 42, 43, 44, 46, 48, 49, 51, 51, 53,
55, 57, 58, 60, 61, 62, 64, 65, 67, 68, 70, 72, 73, 75, 76, 77, 79, 80, 81, 83,
83, 84, 86, 87, 87, 90, 90, 91, 92, 94, 93, 95, 96, 97, 99, 100, 101, 101, 103,
103, 105, 106, 108, 108, 109, 111, 111, 112, 113, 115, 116, 117, 118, 119, 118,
115, 113, 110, 109, 107, 104, 102, 100, 98, 95, 93, 91, 89, 86, 84, 81, 80, 78,
76, 74, 71, 69, 66, 65, 62, 59, 58, 56, 54, 51, 49, 46, 44, 41, 40, 37, 33, 30,
26, 22, 18, 14, 11, 6, 3, -1, -5, -9, -12, -16, -20, -24, -28, -31, -36, -39,
-43, -47, -50, -54, -58, -62, -66, -70, -73, -78, -80, -85, -88, -92, -97, -100,
-103, -102, -102, -102, -102, -101, -101, -100, -100, -100, -100, -99, -100,
-100, -99, -100, -99, -98, -99, -98, -98, -97, -97, -97, -97, -97, -96, -97,
-96, -96, -95, -95, -96, -94, -94, -94, -95, -93, -93, -92, -92, -90, -89, -88,
-88, -87, -86, -86, -85, -83, -83, -81, -81, -80, -80, -78, -78, -78, -76, -75,
-75, -74, -72, -72, -71, -70, -69, -69, -68, -67, -67, -66, -64, -64, -65, -66,
-66, -67, -68, -68, -69, -70, -71, -71, -72, -73, -74, -75, -75, -76, -76, -77,
-78, -78, -79, -80, -81, -81, -82, -83, -85, -85, -85, -86, -87, -87, -88, -90,
-90, -91, -90, -89, -88, -87, -87, -85, -85, -83, -82, -82, -80, -79, -78, -77,
-76, -75, -75, -73, -72, -71, -71, -70, -69, -67, -66, -66, -64, -63, -63, -61,
-61, -60, -58, -58, -57, -56, -54, -52, -51, -48, -46, -44, -42, -39, -38, -36,
-34, -32, -30, -28, -26, -23, -21, -19, -17, -15, -13, -11, -9, -7, -5, -3, 0,
};