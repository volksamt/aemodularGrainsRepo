#define DATA_LENGTH 512
#define DATA AKWF_1949

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 15, 21, 26, 31, 36, 41, 44, 49,
53, 56, 60, 63, 66, 69, 71, 74, 77, 80, 81, 84, 86, 88, 90, 93, 95, 97, 99, 101,
102, 104, 107, 109, 110, 111, 112, 114, 114, 114, 114, 113, 113, 113, 111, 109,
107, 105, 103, 99, 95, 92, 88, 84, 80, 74, 69, 64, 60, 54, 50, 44, 39, 34, 28,
23, 18, 12, 7, 2, -2, -7, -13, -18, -22, -27, -32, -36, -41, -46, -50, -54, -59,
-63, -67, -71, -75, -80, -84, -87, -91, -94, -97, -101, -104, -107, -109, -111,
-113, -114, -116, -117, -119, -119, -119, -119, -119, -118, -116, -116, -113,
-112, -110, -108, -106, -102, -100, -97, -94, -91, -87, -84, -79, -76, -72, -69,
-64, -61, -56, -52, -49, -44, -40, -36, -32, -27, -24, -19, -14, -10, -6, -1, 3,
7, 12, 17, 20, 26, 30, 34, 38, 42, 46, 50, 54, 58, 61, 64, 67, 69, 72, 75, 77,
78, 80, 82, 84, 84, 85, 85, 86, 86, 86, 86, 86, 86, 85, 85, 83, 83, 82, 80, 80,
79, 76, 75, 74, 73, 71, 70, 68, 66, 63, 62, 59, 57, 55, 51, 50, 47, 44, 41, 39,
36, 33, 29, 26, 24, 22, 18, 15, 12, 9, 6, 3, 1, -2, -5, -7, -10, -12, -13, -16,
-17, -20, -21, -22, -25, -26, -27, -29, -30, -31, -33, -33, -35, -36, -37, -38,
-39, -39, -41, -42, -42, -44, -44, -44, -44, -45, -46, -47, -47, -48, -48, -48,
-49, -49, -49, -48, -48, -48, -47, -47, -47, -47, -46, -46, -45, -44, -43, -42,
-42, -42, -40, -39, -39, -38, -37, -36, -36, -35, -34, -34, -33, -32, -32, -31,
-29, -29, -27, -26, -26, -25, -24, -22, -20, -19, -18, -16, -15, -14, -12, -10,
-8, -6, -4, -2, 0, 2, 4, 6, 9, 9, 12, 14, 16, 19, 20, 22, 24, 26, 28, 30, 32,
34, 36, 38, 39, 41, 44, 45, 47, 48, 50, 52, 53, 55, 57, 59, 61, 61, 63, 64, 65,
66, 67, 69, 69, 69, 70, 70, 70, 70, 70, 70, 70, 69, 68, 68, 66, 65, 64, 62, 60,
59, 58, 57, 55, 52, 50, 48, 46, 44, 42, 38, 35, 33, 30, 28, 24, 21, 18, 15, 10,
7, 4, 0, -4, -7, -11, -16, -19, -23, -27, -32, -36, -40, -44, -47, -52, -55,
-59, -62, -66, -69, -72, -75, -78, -80, -84, -86, -88, -90, -92, -93, -96, -96,
-98, -99, -101, -101, -104, -104, -105, -106, -107, -108, -109, -110, -111,
-112, -112, -114, -114, -114, -115, -115, -114, -113, -113, -112, -111, -110,
-108, -107, -104, -101, -99, -95, -92, -88, -85, -81, -77, -73, -69, -66, -61,
-57, -53, -51, -46, -44, -42, -41, -38, -37, -36, -36, -36, -37, -38, -41, -42,
-45, -47, -51, -53, -58, -60, -65, -69, -72, -76, -79, -82, -85, -87, -89, -89,
-92, -91, -92, -90, -89, -88, -84, -82, -78, -73, -70, -65, -59, -53, -47, -41,
-34, -28, -21, -16, -9, -2, };