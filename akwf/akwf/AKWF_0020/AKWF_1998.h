#define DATA_LENGTH 512
#define DATA AKWF_1998

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 6, 8, 10, 12, 13, 15, 17, 19,
20, 23, 25, 26, 28, 31, 33, 34, 37, 39, 41, 43, 45, 47, 48, 51, 53, 54, 57, 58,
60, 63, 65, 66, 69, 71, 72, 74, 77, 79, 80, 82, 84, 87, 88, 88, 89, 90, 91, 92,
93, 93, 95, 95, 97, 98, 98, 100, 100, 101, 101, 102, 104, 104, 105, 106, 107,
108, 109, 110, 110, 112, 112, 114, 113, 115, 115, 116, 117, 118, 119, 119, 118,
117, 117, 116, 116, 116, 115, 115, 113, 113, 113, 113, 112, 111, 111, 110, 111,
110, 109, 108, 108, 108, 107, 107, 107, 106, 105, 104, 104, 104, 103, 102, 102,
101, 101, 100, 99, 98, 97, 96, 95, 93, 93, 91, 91, 90, 89, 88, 87, 85, 85, 84,
83, 82, 80, 80, 79, 78, 76, 76, 74, 74, 73, 71, 71, 70, 68, 67, 67, 65, 65, 63,
62, 60, 59, 59, 57, 56, 56, 54, 53, 52, 51, 50, 50, 47, 47, 46, 44, 44, 42, 41,
39, 39, 38, 37, 36, 34, 34, 32, 31, 30, 29, 29, 28, 26, 25, 23, 22, 23, 22, 22,
23, 22, 21, 21, 21, 20, 21, 20, 19, 19, 19, 19, 19, 18, 18, 18, 17, 18, 17, 16,
17, 17, 16, 15, 15, 15, 15, 15, 15, 14, 14, 13, 14, 13, 13, 13, 13, 13, 14, 13,
13, 13, 13, 12, 13, 13, 12, 12, 13, 13, 12, 13, 13, 12, 13, 13, 13, 12, 13, 11,
13, 12, 12, 12, 12, 12, 12, 13, 12, 12, 11, 9, 9, 7, 6, 6, 4, 3, 2, 3, 0, 0, 0,
-1, -3, -4, -5, -6, -7, -7, -10, -10, -11, -12, -13, -15, -15, -16, -18, -18,
-19, -20, -21, -23, -24, -24, -26, -26, -28, -29, -30, -31, -32, -33, -35, -36,
-37, -38, -40, -41, -43, -44, -44, -46, -46, -48, -49, -51, -52, -53, -54, -55,
-56, -57, -59, -59, -61, -62, -64, -65, -66, -68, -69, -69, -70, -70, -70, -70,
-71, -72, -72, -72, -73, -73, -73, -74, -75, -75, -75, -76, -77, -76, -77, -78,
-78, -78, -79, -79, -79, -80, -80, -80, -81, -81, -83, -82, -83, -83, -83, -84,
-84, -85, -84, -85, -86, -85, -86, -86, -87, -88, -88, -88, -89, -88, -88, -90,
-89, -90, -90, -90, -91, -91, -91, -92, -91, -92, -93, -93, -93, -93, -94, -94,
-94, -94, -95, -95, -96, -96, -96, -97, -97, -97, -98, -98, -98, -99, -99, -100,
-101, -101, -101, -101, -102, -102, -102, -103, -104, -104, -104, -105, -105,
-105, -105, -106, -107, -107, -108, -107, -107, -108, -109, -109, -109, -108,
-106, -104, -103, -101, -99, -97, -95, -95, -92, -91, -90, -87, -87, -84, -83,
-82, -80, -78, -77, -75, -74, -73, -70, -69, -67, -67, -64, -62, -62, -59, -59,
-56, -54, -53, -51, -50, -48, -45, -45, -42, -41, -38, -37, -35, -33, -31, -30,
-28, -26, -25, -23, -21, -19, -18, -15, -13, -12, -11, -9, -7, -4, -3, -1, };