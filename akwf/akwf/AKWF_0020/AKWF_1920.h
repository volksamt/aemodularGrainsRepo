#define DATA_LENGTH 512
#define DATA AKWF_1920

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 8, 11, 13, 16, 20, 23, 25,
28, 30, 33, 35, 37, 40, 42, 45, 46, 49, 51, 53, 54, 56, 57, 59, 60, 60, 62, 62,
62, 63, 63, 62, 63, 63, 63, 62, 62, 62, 61, 61, 60, 60, 59, 59, 58, 57, 57, 57,
57, 55, 55, 55, 54, 55, 55, 55, 55, 55, 54, 54, 55, 54, 54, 54, 53, 53, 53, 52,
51, 51, 50, 47, 46, 45, 43, 41, 39, 36, 33, 31, 27, 24, 20, 16, 13, 9, 5, 1, -4,
-8, -13, -17, -21, -25, -30, -34, -38, -42, -46, -49, -53, -55, -58, -62, -63,
-66, -67, -69, -72, -73, -75, -75, -76, -76, -77, -77, -78, -79, -78, -78, -77,
-78, -77, -76, -76, -75, -74, -74, -74, -72, -71, -70, -70, -68, -67, -65, -64,
-63, -62, -60, -59, -58, -56, -54, -52, -49, -49, -46, -44, -42, -40, -38, -36,
-33, -30, -28, -26, -22, -20, -18, -16, -12, -10, -6, -4, -1, 4, 7, 9, 12, 15,
18, 21, 24, 27, 31, 33, 35, 38, 40, 42, 45, 47, 48, 50, 52, 53, 54, 55, 56, 57,
57, 58, 58, 58, 58, 58, 58, 59, 59, 58, 57, 58, 57, 56, 57, 56, 56, 55, 56, 55,
54, 55, 54, 55, 54, 54, 55, 54, 54, 55, 53, 54, 54, 54, 55, 54, 55, 54, 54, 54,
54, 54, 54, 54, 54, 55, 55, 54, 54, 54, 54, 54, 53, 54, 54, 54, 54, 54, 53, 54,
54, 55, 54, 54, 54, 53, 55, 54, 54, 54, 55, 54, 54, 54, 54, 54, 54, 53, 54, 53,
53, 53, 54, 53, 54, 53, 53, 53, 54, 53, 53, 53, 52, 52, 52, 52, 52, 53, 53, 53,
54, 54, 54, 54, 55, 55, 56, 56, 57, 57, 59, 59, 59, 60, 60, 61, 61, 60, 62, 61,
60, 60, 60, 59, 59, 57, 57, 55, 54, 52, 50, 49, 46, 44, 41, 39, 35, 32, 30, 25,
23, 19, 15, 13, 9, 5, 0, -3, -7, -11, -15, -18, -23, -26, -30, -35, -39, -42,
-46, -51, -55, -59, -62, -67, -71, -75, -79, -82, -87, -90, -93, -97, -100,
-104, -106, -109, -110, -113, -115, -116, -118, -118, -118, -119, -119, -119,
-120, -118, -117, -116, -114, -112, -111, -108, -107, -104, -102, -100, -96,
-95, -93, -90, -88, -86, -84, -81, -80, -79, -76, -76, -75, -74, -73, -74, -72,
-72, -73, -73, -73, -74, -74, -75, -76, -75, -75, -76, -75, -76, -76, -75, -75,
-73, -73, -71, -69, -67, -64, -63, -60, -55, -52, -48, -45, -39, -35, -30, -27,
-21, -17, -12, -7, -3, 2, 5, 9, 14, 16, 19, 22, 24, 26, 27, 29, 29, 28, 27, 27,
25, 23, 21, 18, 15, 12, 8, 4, 2, -3, -7, -11, -15, -19, -22, -26, -30, -33, -36,
-39, -41, -43, -45, -46, -46, -47, -48, -48, -47, -47, -47, -45, -45, -42, -41,
-40, -39, -36, -34, -31, -29, -27, -25, -22, -20, -17, -14, -12, -9, -6, -4, -1,
};