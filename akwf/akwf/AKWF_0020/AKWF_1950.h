#define DATA_LENGTH 512
#define DATA AKWF_1950

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 14, 22, 29, 36, 44, 50, 56, 62, 66,
70, 73, 74, 77, 78, 78, 78, 77, 75, 74, 73, 70, 68, 65, 62, 61, 58, 56, 55, 53,
53, 51, 51, 52, 52, 53, 54, 55, 56, 59, 61, 63, 65, 67, 69, 71, 72, 73, 73, 72,
71, 70, 68, 65, 62, 57, 52, 47, 40, 34, 25, 19, 10, 2, -7, -15, -24, -32, -40,
-48, -54, -60, -66, -71, -75, -78, -79, -80, -80, -78, -75, -71, -68, -62, -54,
-47, -39, -30, -21, -11, 0, 9, 20, 31, 40, 50, 59, 69, 77, 85, 92, 98, 102, 106,
110, 112, 112, 113, 111, 109, 107, 103, 97, 92, 85, 79, 71, 62, 54, 45, 36, 27,
18, 10, 1, -8, -16, -24, -31, -38, -44, -50, -55, -59, -62, -65, -67, -67, -67,
-67, -66, -62, -59, -55, -50, -46, -40, -33, -26, -18, -10, -2, 6, 14, 22, 31,
40, 47, 55, 63, 69, 76, 83, 88, 91, 94, 97, 100, 101, 101, 99, 97, 94, 91, 86,
81, 75, 67, 60, 51, 43, 33, 24, 15, 4, -5, -15, -25, -33, -42, -51, -59, -66,
-72, -78, -82, -86, -88, -90, -90, -90, -90, -88, -85, -81, -76, -72, -65, -59,
-50, -43, -34, -26, -17, -8, 2, 10, 19, 28, 36, 43, 51, 57, 64, 68, 74, 77, 81,
82, 84, 85, 84, 83, 80, 76, 73, 67, 62, 55, 48, 39, 32, 22, 13, 3, -7, -18, -27,
-38, -48, -57, -67, -75, -84, -91, -98, -104, -109, -113, -115, -118, -119,
-118, -118, -114, -111, -106, -99, -92, -85, -76, -65, -55, -44, -33, -20, -8,
3, 15, 27, 39, 49, 60, 69, 77, 85, 92, 97, 101, 104, 105, 105, 104, 102, 97, 93,
86, 80, 71, 62, 53, 43, 31, 20, 9, -2, -12, -24, -34, -44, -53, -61, -68, -75,
-78, -83, -86, -87, -88, -87, -84, -81, -76, -71, -64, -56, -48, -39, -28, -20,
-9, 2, 13, 23, 34, 44, 55, 64, 73, 82, 88, 95, 100, 106, 110, 112, 115, 116,
116, 115, 112, 110, 106, 101, 96, 89, 83, 75, 67, 58, 50, 41, 31, 22, 12, 3, -6,
-15, -25, -33, -41, -48, -55, -61, -68, -72, -77, -79, -82, -84, -84, -85, -84,
-82, -79, -75, -72, -66, -60, -53, -46, -38, -31, -21, -13, -4, 5, 15, 24, 32,
41, 49, 56, 64, 70, 75, 79, 84, 87, 89, 91, 90, 89, 87, 84, 81, 75, 69, 63, 56,
48, 40, 32, 22, 13, 3, -6, -15, -25, -34, -42, -50, -57, -64, -70, -75, -78,
-81, -84, -84, -84, -83, -81, -79, -74, -70, -65, -59, -52, -44, -36, -28, -19,
-11, -2, 6, 15, 23, 31, 37, 45, 51, 57, 61, 64, 68, 69, 71, 70, 70, 68, 65, 62,
57, 52, 46, 39, 32, 24, 17, 8, -1, -9, -19, -27, -35, -42, -49, -58, -64, -70,
-74, -79, -82, -84, -86, -87, -86, -84, -82, -79, -76, -71, -65, -58, -51, -45,
-36, -28, -20, -11, -2, };