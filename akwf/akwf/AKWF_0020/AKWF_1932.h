#define DATA_LENGTH 512
#define DATA AKWF_1932

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 13, 18, 23, 28, 32, 38, 41, 47,
51, 54, 59, 63, 67, 71, 74, 78, 83, 85, 89, 92, 95, 97, 101, 103, 105, 107, 109,
111, 112, 114, 115, 116, 117, 118, 118, 119, 119, 119, 119, 118, 118, 117, 117,
116, 114, 113, 111, 110, 108, 107, 105, 103, 101, 99, 97, 94, 91, 90, 86, 84,
81, 78, 77, 73, 71, 68, 65, 63, 59, 58, 55, 52, 49, 47, 45, 42, 40, 38, 35, 34,
32, 30, 29, 26, 25, 23, 22, 21, 20, 19, 18, 17, 17, 16, 16, 15, 15, 15, 16, 17,
16, 16, 18, 18, 19, 20, 20, 22, 22, 24, 25, 26, 28, 28, 30, 31, 33, 35, 36, 37,
39, 40, 42, 43, 44, 46, 47, 49, 50, 51, 52, 53, 54, 55, 56, 57, 57, 57, 58, 58,
58, 58, 58, 58, 58, 57, 57, 56, 54, 54, 53, 52, 50, 49, 46, 45, 43, 40, 39, 37,
35, 32, 29, 27, 24, 21, 18, 15, 11, 10, 6, 3, 0, -5, -7, -11, -13, -18, -21,
-24, -27, -30, -34, -37, -41, -44, -47, -49, -52, -55, -58, -61, -63, -65, -67,
-70, -72, -73, -75, -77, -78, -80, -81, -82, -83, -83, -83, -84, -83, -84, -84,
-82, -83, -82, -81, -80, -79, -77, -76, -73, -73, -69, -68, -65, -63, -61, -58,
-56, -52, -49, -46, -43, -39, -36, -32, -29, -25, -21, -18, -14, -10, -6, -3, 1,
6, 8, 13, 16, 20, 24, 27, 31, 34, 39, 42, 45, 47, 51, 55, 57, 60, 62, 65, 67,
70, 72, 73, 75, 77, 78, 80, 81, 82, 82, 83, 84, 85, 84, 85, 84, 84, 84, 82, 82,
81, 80, 78, 78, 76, 74, 72, 70, 68, 65, 64, 61, 58, 56, 53, 51, 47, 45, 41, 38,
35, 32, 27, 25, 21, 18, 15, 11, 8, 4, 1, -4, -6, -10, -13, -16, -20, -22, -26,
-30, -33, -36, -39, -41, -44, -46, -49, -52, -54, -57, -59, -61, -63, -64, -66,
-68, -70, -70, -72, -72, -73, -75, -75, -76, -76, -77, -77, -77, -77, -77, -77,
-77, -76, -75, -74, -74, -73, -71, -70, -69, -68, -66, -66, -65, -62, -61, -59,
-58, -56, -54, -52, -50, -49, -47, -45, -43, -40, -39, -38, -35, -33, -33, -31,
-29, -27, -25, -25, -22, -21, -20, -18, -17, -16, -15, -14, -14, -12, -12, -11,
-12, -11, -11, -11, -11, -11, -11, -11, -13, -13, -14, -14, -16, -17, -18, -19,
-20, -22, -24, -26, -28, -30, -31, -33, -35, -38, -40, -43, -44, -47, -49, -52,
-55, -58, -60, -63, -65, -68, -72, -74, -76, -80, -82, -84, -87, -89, -91, -94,
-96, -99, -101, -102, -105, -106, -108, -110, -111, -112, -114, -115, -116,
-117, -117, -119, -118, -119, -118, -119, -118, -118, -117, -117, -116, -115,
-113, -112, -110, -109, -108, -104, -103, -100, -97, -94, -92, -89, -85, -82,
-78, -74, -72, -67, -63, -60, -55, -51, -46, -43, -38, -33, -29, -24, -18, -13,
-9, -4, 0, };