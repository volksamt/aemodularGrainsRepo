#define DATA_LENGTH 512
#define DATA AKWF_1925

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 12, 17, 23, 28, 33, 38, 43, 47,
52, 57, 61, 65, 69, 72, 77, 80, 83, 86, 88, 91, 94, 95, 98, 99, 101, 102, 104,
104, 105, 106, 107, 107, 108, 108, 108, 108, 107, 107, 107, 107, 105, 105, 104,
104, 103, 101, 100, 99, 97, 97, 95, 94, 92, 91, 89, 89, 87, 86, 85, 83, 81, 80,
79, 77, 76, 75, 74, 73, 71, 70, 68, 67, 66, 64, 63, 62, 61, 59, 57, 56, 54, 53,
52, 50, 48, 48, 46, 45, 43, 42, 41, 40, 39, 37, 37, 36, 34, 33, 32, 32, 31, 31,
28, 29, 28, 28, 27, 27, 27, 26, 26, 26, 25, 25, 25, 26, 27, 27, 27, 27, 28, 29,
30, 31, 32, 33, 34, 35, 36, 38, 39, 39, 42, 42, 43, 45, 45, 47, 47, 47, 49, 50,
50, 51, 52, 52, 52, 52, 52, 52, 52, 51, 51, 50, 49, 48, 47, 46, 44, 43, 41, 39,
36, 34, 32, 30, 27, 24, 21, 17, 14, 11, 7, 3, -1, -4, -7, -11, -15, -19, -23,
-27, -31, -34, -39, -41, -46, -49, -53, -55, -59, -62, -65, -67, -70, -72, -74,
-77, -79, -80, -82, -83, -84, -85, -85, -86, -86, -85, -86, -85, -85, -83, -83,
-81, -80, -78, -76, -75, -72, -70, -68, -65, -63, -59, -58, -54, -51, -49, -46,
-42, -38, -35, -32, -29, -25, -23, -18, -15, -12, -7, -4, -2, 2, 5, 8, 12, 15,
17, 20, 23, 26, 29, 31, 35, 36, 39, 41, 44, 46, 49, 52, 54, 57, 59, 60, 63, 64,
67, 69, 70, 73, 74, 75, 78, 79, 81, 82, 83, 84, 85, 86, 87, 89, 89, 90, 90, 91,
91, 91, 91, 91, 91, 91, 91, 91, 89, 89, 89, 88, 87, 85, 84, 82, 81, 79, 77, 75,
74, 71, 69, 66, 64, 60, 58, 55, 52, 50, 46, 43, 40, 38, 34, 31, 28, 26, 22, 19,
16, 13, 11, 7, 4, 2, -1, -4, -6, -10, -12, -14, -16, -19, -21, -23, -24, -26,
-28, -29, -30, -32, -33, -34, -35, -36, -36, -38, -38, -39, -39, -39, -41, -40,
-40, -40, -41, -41, -40, -41, -41, -41, -40, -41, -39, -40, -39, -39, -39, -39,
-38, -38, -38, -38, -37, -37, -37, -36, -36, -36, -36, -36, -37, -36, -36, -36,
-36, -36, -36, -36, -37, -37, -37, -36, -37, -37, -36, -37, -36, -36, -37, -37,
-36, -36, -37, -37, -37, -37, -38, -39, -38, -38, -39, -39, -41, -41, -42, -42,
-43, -43, -44, -45, -46, -46, -47, -49, -49, -50, -52, -53, -55, -56, -57, -58,
-60, -62, -64, -67, -68, -69, -72, -74, -76, -78, -81, -83, -85, -88, -90, -93,
-95, -96, -99, -101, -103, -106, -107, -108, -111, -113, -113, -115, -116, -117,
-118, -119, -118, -119, -119, -119, -119, -118, -118, -116, -115, -114, -111,
-110, -109, -105, -103, -100, -97, -94, -90, -86, -84, -78, -74, -70, -65, -60,
-57, -50, -46, -40, -35, -30, -24, -18, -13, -8, -3, };