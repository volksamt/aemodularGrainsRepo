#define DATA_LENGTH 512
#define DATA AKWF_1968

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 5, 6, 7, 10, 12, 14, 15,
17, 20, 21, 23, 25, 28, 30, 32, 34, 35, 38, 39, 41, 43, 45, 47, 49, 51, 53, 54,
55, 57, 60, 61, 63, 65, 67, 68, 69, 72, 73, 75, 77, 79, 79, 81, 81, 83, 84, 85,
86, 87, 89, 89, 91, 92, 93, 93, 95, 95, 96, 98, 99, 99, 100, 101, 101, 101, 103,
103, 103, 104, 104, 105, 106, 106, 107, 107, 107, 108, 109, 109, 110, 110, 110,
111, 112, 111, 111, 112, 112, 113, 112, 113, 113, 114, 114, 115, 114, 115, 116,
116, 115, 116, 117, 116, 117, 116, 118, 117, 118, 118, 118, 117, 118, 118, 119,
119, 119, 119, 119, 118, 118, 118, 118, 118, 117, 117, 117, 117, 116, 116, 116,
116, 115, 116, 115, 114, 113, 113, 112, 111, 111, 109, 109, 108, 106, 105, 105,
103, 103, 102, 101, 99, 98, 98, 97, 95, 94, 92, 90, 89, 86, 85, 83, 82, 80, 78,
76, 75, 73, 70, 69, 68, 66, 64, 62, 60, 59, 57, 55, 53, 50, 48, 46, 44, 43, 41,
39, 36, 35, 32, 31, 28, 27, 25, 23, 22, 20, 19, 17, 15, 14, 11, 10, 8, 7, 5, 4,
2, 1, -1, -3, -4, -5, -5, -7, -7, -8, -9, -10, -11, -12, -12, -13, -14, -15,
-16, -17, -18, -18, -19, -20, -20, -20, -21, -21, -21, -21, -22, -22, -23, -22,
-22, -23, -23, -23, -24, -24, -24, -24, -24, -25, -25, -26, -26, -27, -27, -26,
-27, -27, -27, -28, -28, -28, -29, -28, -30, -30, -30, -29, -31, -31, -32, -32,
-33, -34, -34, -35, -36, -37, -37, -38, -39, -39, -40, -41, -42, -42, -43, -44,
-46, -46, -47, -49, -50, -52, -51, -53, -54, -55, -56, -58, -58, -59, -60, -61,
-63, -63, -65, -66, -66, -68, -69, -70, -71, -72, -74, -74, -76, -76, -78, -78,
-80, -81, -82, -84, -85, -85, -85, -87, -88, -89, -89, -90, -90, -92, -92, -94,
-94, -96, -96, -97, -98, -99, -99, -100, -100, -102, -101, -101, -102, -102,
-101, -102, -102, -103, -103, -104, -104, -104, -104, -105, -104, -105, -106,
-105, -105, -105, -104, -104, -104, -103, -104, -103, -104, -103, -103, -102,
-101, -101, -102, -101, -101, -101, -100, -100, -99, -99, -98, -97, -97, -97,
-95, -95, -94, -93, -93, -93, -92, -92, -91, -91, -90, -90, -89, -88, -88, -87,
-88, -87, -86, -85, -85, -85, -84, -83, -83, -82, -82, -82, -81, -80, -80, -80,
-79, -79, -78, -77, -77, -77, -76, -77, -76, -75, -75, -75, -74, -74, -74, -73,
-73, -73, -72, -71, -71, -70, -70, -70, -69, -69, -68, -67, -67, -67, -66, -66,
-66, -65, -65, -64, -63, -62, -61, -59, -58, -57, -56, -55, -55, -53, -52, -51,
-50, -48, -48, -46, -45, -44, -42, -41, -40, -39, -37, -35, -35, -32, -32, -31,
-29, -27, -26, -24, -22, -22, -20, -19, -17, -16, -15, -13, -11, -10, -9, -8,
-7, -6, -4, -4, -2, -1, };