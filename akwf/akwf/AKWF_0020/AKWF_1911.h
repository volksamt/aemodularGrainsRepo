#define DATA_LENGTH 512
#define DATA AKWF_1911

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 10, 13, 16, 18, 21, 24, 26,
28, 30, 33, 34, 36, 38, 39, 40, 43, 43, 44, 46, 46, 47, 48, 49, 49, 49, 50, 48,
49, 50, 49, 49, 49, 49, 49, 49, 49, 48, 48, 49, 47, 48, 47, 47, 47, 47, 48, 48,
47, 47, 47, 46, 47, 47, 47, 47, 47, 47, 47, 47, 48, 47, 47, 46, 47, 46, 47, 47,
47, 48, 47, 47, 46, 47, 47, 47, 47, 47, 47, 47, 46, 47, 47, 47, 47, 47, 47, 46,
47, 46, 47, 47, 47, 48, 47, 46, 46, 46, 47, 46, 47, 47, 47, 46, 47, 47, 47, 47,
46, 47, 47, 47, 47, 46, 47, 46, 47, 47, 47, 47, 46, 47, 46, 46, 47, 47, 47, 46,
46, 47, 46, 46, 47, 47, 47, 46, 47, 46, 47, 47, 46, 46, 47, 47, 47, 47, 47, 48,
48, 48, 47, 46, 47, 47, 47, 47, 46, 46, 46, 46, 45, 44, 44, 44, 43, 43, 43, 42,
41, 40, 40, 40, 40, 40, 40, 40, 40, 40, 42, 43, 43, 44, 44, 47, 48, 50, 52, 54,
56, 60, 62, 64, 67, 72, 75, 78, 82, 86, 88, 92, 96, 99, 102, 105, 107, 110, 113,
115, 115, 117, 118, 119, 119, 118, 119, 117, 116, 115, 112, 110, 108, 105, 102,
99, 95, 90, 87, 82, 78, 73, 68, 64, 59, 54, 49, 43, 38, 33, 27, 22, 17, 11, 6,
1, -5, -10, -17, -22, -27, -33, -38, -45, -50, -56, -61, -67, -72, -78, -82,
-86, -91, -94, -99, -102, -105, -109, -111, -114, -116, -117, -117, -119, -118,
-118, -118, -118, -115, -115, -113, -110, -108, -105, -101, -100, -95, -92, -89,
-84, -82, -78, -75, -71, -68, -64, -62, -58, -55, -53, -51, -49, -47, -46, -45,
-43, -42, -41, -41, -40, -40, -39, -39, -38, -39, -39, -40, -40, -40, -40, -40,
-40, -41, -41, -41, -42, -42, -42, -42, -43, -43, -43, -43, -43, -43, -43, -42,
-42, -43, -43, -43, -43, -43, -43, -43, -42, -42, -42, -43, -43, -43, -43, -42,
-42, -43, -43, -43, -43, -43, -42, -43, -43, -43, -43, -43, -43, -43, -43, -43,
-42, -43, -43, -43, -42, -43, -42, -43, -43, -42, -42, -43, -42, -42, -43, -42,
-42, -43, -43, -42, -42, -43, -43, -43, -43, -42, -42, -43, -42, -43, -42, -42,
-42, -43, -43, -42, -43, -43, -43, -43, -42, -42, -43, -42, -43, -42, -42, -42,
-42, -42, -42, -43, -42, -43, -42, -42, -42, -42, -43, -42, -42, -42, -42, -41,
-42, -41, -42, -42, -42, -43, -42, -42, -42, -42, -42, -43, -42, -42, -42, -43,
-43, -43, -43, -43, -43, -43, -43, -43, -44, -43, -43, -43, -44, -43, -44, -43,
-44, -43, -43, -43, -44, -43, -43, -42, -43, -42, -42, -42, -42, -42, -42, -42,
-42, -42, -41, -42, -40, -40, -41, -39, -38, -38, -37, -36, -35, -35, -33, -32,
-31, -28, -27, -26, -24, -22, -21, -18, -16, -13, -10, -8, -6, -3, -1, };