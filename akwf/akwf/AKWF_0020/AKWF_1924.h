#define DATA_LENGTH 512
#define DATA AKWF_1924

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 16, 21, 26, 31, 35, 41, 45,
49, 54, 59, 63, 68, 72, 77, 82, 86, 91, 95, 95, 96, 95, 94, 94, 94, 94, 93, 93,
93, 93, 92, 92, 91, 91, 91, 91, 90, 90, 89, 89, 89, 89, 88, 88, 87, 87, 87, 86,
87, 86, 86, 86, 85, 85, 84, 85, 84, 83, 83, 83, 83, 81, 81, 81, 81, 81, 79, 77,
77, 76, 74, 74, 73, 71, 70, 69, 67, 66, 65, 64, 63, 63, 61, 60, 59, 57, 56, 55,
54, 53, 52, 50, 49, 48, 47, 46, 44, 44, 42, 41, 40, 39, 38, 37, 35, 34, 33, 32,
31, 30, 29, 28, 27, 28, 29, 29, 30, 30, 31, 31, 32, 32, 33, 33, 33, 34, 34, 34,
35, 36, 36, 36, 37, 36, 38, 38, 38, 39, 40, 40, 41, 41, 41, 42, 42, 43, 43, 44,
43, 44, 45, 45, 46, 46, 47, 47, 48, 48, 47, 44, 41, 38, 35, 32, 29, 26, 22, 20,
16, 14, 10, 8, 4, 2, -2, -5, -7, -10, -13, -17, -20, -22, -25, -29, -32, -34,
-38, -41, -44, -47, -49, -53, -55, -59, -62, -65, -67, -71, -74, -77, -80, -83,
-86, -89, -91, -89, -86, -84, -82, -80, -77, -73, -72, -68, -66, -64, -61, -57,
-55, -52, -50, -48, -45, -43, -39, -37, -35, -32, -28, -27, -24, -21, -19, -16,
-13, -11, -8, -5, -2, 0, 2, 5, 8, 10, 13, 15, 18, 22, 23, 27, 29, 31, 33, 34,
35, 36, 38, 40, 40, 42, 44, 44, 46, 47, 49, 50, 51, 53, 54, 55, 57, 59, 59, 61,
63, 65, 65, 66, 68, 70, 71, 73, 74, 75, 77, 78, 79, 80, 82, 83, 85, 86, 87, 89,
90, 91, 93, 94, 92, 89, 87, 84, 82, 79, 77, 74, 72, 69, 66, 64, 61, 57, 55, 53,
50, 47, 46, 43, 40, 37, 34, 32, 29, 26, 24, 22, 19, 15, 14, 11, 9, 6, 3, 0, -2,
-4, -8, -10, -13, -15, -18, -21, -22, -26, -28, -28, -28, -29, -28, -30, -29,
-30, -30, -29, -30, -30, -30, -31, -30, -31, -32, -31, -33, -32, -33, -33, -33,
-33, -34, -33, -34, -34, -35, -34, -35, -35, -35, -35, -36, -36, -37, -38, -37,
-37, -37, -37, -38, -38, -38, -39, -39, -39, -40, -40, -41, -41, -42, -41, -42,
-43, -43, -43, -43, -45, -44, -46, -45, -47, -47, -47, -47, -48, -48, -49, -49,
-49, -49, -50, -50, -51, -52, -52, -52, -53, -54, -53, -53, -53, -54, -55, -55,
-55, -55, -57, -56, -57, -58, -58, -60, -62, -63, -64, -66, -67, -68, -68, -70,
-72, -74, -74, -76, -78, -79, -79, -81, -82, -84, -85, -86, -87, -89, -90, -92,
-93, -94, -96, -97, -98, -100, -101, -102, -103, -106, -107, -108, -109, -110,
-112, -113, -114, -116, -116, -118, -120, -116, -111, -107, -101, -97, -92, -89,
-83, -79, -74, -70, -65, -61, -56, -51, -46, -41, -37, -32, -28, -23, -19, -14,
-9, -5, 0, };