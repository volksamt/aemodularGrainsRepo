#define DATA_LENGTH 512
#define DATA AKWF_1938

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 10, 16, 20, 25, 29, 34, 39, 44,
48, 53, 57, 60, 65, 69, 73, 77, 81, 84, 88, 90, 93, 97, 99, 101, 104, 107, 109,
111, 112, 113, 115, 116, 116, 118, 118, 118, 119, 119, 119, 119, 118, 117, 117,
116, 115, 113, 112, 111, 108, 108, 105, 103, 101, 99, 97, 94, 92, 90, 87, 85,
82, 79, 77, 74, 72, 67, 65, 62, 60, 57, 55, 52, 49, 47, 44, 43, 40, 38, 37, 34,
33, 31, 29, 27, 25, 24, 23, 20, 21, 19, 18, 18, 17, 17, 16, 16, 16, 16, 16, 16,
17, 17, 17, 17, 19, 19, 21, 22, 21, 24, 25, 26, 28, 28, 30, 32, 33, 34, 34, 37,
38, 40, 40, 43, 44, 45, 46, 48, 49, 50, 51, 52, 53, 53, 55, 55, 55, 57, 57, 57,
58, 57, 57, 57, 56, 56, 56, 55, 55, 53, 52, 51, 50, 48, 47, 45, 43, 42, 39, 37,
34, 33, 29, 28, 25, 22, 20, 16, 14, 11, 8, 4, 2, -1, -4, -9, -12, -15, -18, -20,
-24, -27, -30, -34, -37, -40, -42, -45, -48, -52, -54, -57, -59, -62, -64, -65,
-68, -70, -73, -73, -75, -77, -78, -80, -80, -81, -82, -83, -82, -83, -83, -83,
-83, -83, -82, -81, -80, -79, -78, -77, -75, -74, -72, -70, -68, -64, -63, -60,
-58, -55, -52, -49, -46, -43, -40, -36, -33, -29, -26, -21, -17, -14, -9, -6,
-2, 1, 6, 9, 14, 17, 22, 26, 30, 34, 38, 41, 46, 48, 52, 57, 60, 63, 67, 70, 73,
76, 79, 82, 84, 88, 89, 92, 93, 96, 98, 100, 102, 103, 104, 105, 106, 108, 109,
109, 109, 109, 109, 110, 109, 109, 108, 107, 106, 106, 105, 104, 103, 101, 100,
97, 95, 93, 91, 90, 86, 85, 81, 79, 76, 74, 71, 67, 64, 62, 59, 55, 52, 48, 46,
42, 39, 36, 32, 29, 25, 22, 19, 15, 12, 9, 5, 3, 0, -4, -8, -10, -12, -16, -19,
-21, -24, -27, -29, -30, -33, -35, -38, -39, -41, -43, -44, -46, -47, -48, -49,
-50, -52, -53, -52, -54, -54, -53, -54, -55, -54, -54, -54, -55, -54, -53, -53,
-52, -52, -50, -50, -49, -48, -46, -46, -45, -43, -43, -41, -40, -39, -37, -36,
-34, -34, -32, -30, -30, -29, -27, -27, -26, -24, -23, -22, -22, -20, -20, -19,
-19, -18, -17, -17, -17, -17, -17, -17, -18, -18, -18, -18, -19, -21, -21, -22,
-22, -23, -25, -26, -27, -29, -30, -32, -34, -37, -37, -40, -42, -44, -47, -50,
-52, -54, -57, -59, -61, -64, -66, -68, -71, -74, -77, -80, -81, -84, -86, -89,
-91, -94, -96, -99, -100, -102, -104, -106, -108, -109, -111, -112, -114, -114,
-115, -116, -117, -117, -117, -118, -118, -118, -117, -117, -116, -115, -113,
-113, -111, -109, -108, -105, -104, -102, -99, -96, -94, -92, -88, -85, -82,
-78, -75, -71, -67, -62, -58, -54, -50, -46, -40, -36, -32, -28, -22, -18, -13,
-7, -3, };