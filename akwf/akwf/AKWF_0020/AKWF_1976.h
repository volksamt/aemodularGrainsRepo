#define DATA_LENGTH 512
#define DATA AKWF_1976

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 16, 21, 25, 28, 33, 37, 41, 45,
50, 54, 59, 62, 67, 70, 75, 78, 84, 88, 92, 95, 96, 97, 98, 100, 102, 102, 104,
105, 107, 108, 110, 110, 112, 113, 114, 116, 118, 119, 118, 117, 114, 113, 110,
108, 104, 103, 100, 98, 96, 93, 91, 89, 87, 84, 82, 80, 78, 76, 74, 72, 70, 68,
66, 64, 63, 61, 60, 57, 55, 53, 52, 51, 48, 46, 45, 43, 41, 43, 43, 44, 44, 45,
47, 47, 47, 48, 49, 50, 50, 51, 51, 53, 53, 54, 54, 56, 58, 61, 63, 65, 67, 70,
73, 75, 77, 79, 81, 83, 85, 88, 90, 93, 96, 97, 99, 100, 101, 101, 101, 103,
103, 104, 105, 106, 106, 106, 107, 108, 108, 109, 109, 110, 111, 110, 108, 107,
105, 103, 101, 100, 98, 96, 94, 92, 91, 89, 88, 85, 84, 82, 81, 79, 77, 74, 72,
71, 69, 67, 66, 63, 61, 60, 58, 55, 54, 52, 50, 48, 46, 45, 42, 42, 43, 43, 44,
45, 45, 46, 46, 47, 47, 49, 49, 50, 50, 51, 52, 52, 53, 54, 56, 58, 61, 63, 65,
68, 71, 74, 76, 79, 80, 83, 85, 88, 91, 93, 95, 99, 101, 102, 103, 104, 104,
106, 107, 108, 108, 109, 109, 111, 112, 113, 113, 114, 116, 115, 117, 117, 115,
112, 109, 106, 103, 99, 97, 93, 90, 86, 84, 81, 77, 74, 71, 68, 65, 61, 58, 54,
47, 43, 36, 31, 26, 20, 15, 9, 4, -1, -7, -12, -18, -23, -29, -35, -41, -46,
-50, -54, -57, -60, -64, -68, -70, -75, -79, -83, -86, -89, -92, -97, -101,
-104, -108, -111, -114, -114, -114, -113, -113, -112, -112, -113, -111, -110,
-110, -110, -109, -109, -109, -108, -108, -108, -107, -106, -104, -102, -98,
-97, -94, -90, -89, -86, -83, -81, -79, -76, -74, -70, -69, -66, -64, -60, -58,
-57, -56, -55, -54, -54, -53, -51, -51, -50, -49, -48, -46, -46, -46, -45, -43,
-42, -41, -41, -42, -44, -45, -47, -48, -50, -52, -54, -55, -57, -59, -60, -62,
-64, -66, -67, -69, -72, -72, -74, -76, -79, -80, -82, -85, -86, -88, -90, -91,
-94, -96, -97, -100, -102, -103, -106, -108, -109, -109, -108, -109, -107, -108,
-107, -107, -106, -105, -105, -106, -105, -105, -105, -103, -103, -103, -104,
-102, -100, -98, -96, -93, -91, -88, -86, -85, -81, -80, -78, -75, -73, -71,
-68, -66, -63, -60, -60, -58, -58, -56, -55, -55, -53, -52, -52, -51, -49, -48,
-46, -46, -45, -45, -43, -42, -42, -41, -42, -44, -45, -47, -49, -50, -52, -54,
-56, -56, -59, -60, -61, -63, -65, -66, -67, -70, -71, -73, -76, -78, -80, -83,
-86, -89, -91, -93, -96, -98, -100, -104, -105, -107, -110, -112, -115, -115,
-115, -114, -114, -113, -113, -112, -111, -110, -110, -108, -109, -108, -106,
-106, -105, -104, -104, -103, -100, -93, -87, -82, -76, -69, -63, -56, -51, -44,
-38, -31, -25, -20, -13, -7, -1, };