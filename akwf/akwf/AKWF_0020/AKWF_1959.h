#define DATA_LENGTH 512
#define DATA AKWF_1959

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 15, 20, 27, 32, 36, 41, 44, 49,
51, 53, 56, 58, 60, 61, 62, 64, 64, 65, 66, 67, 67, 67, 67, 67, 67, 68, 68, 69,
69, 70, 71, 72, 73, 73, 75, 76, 78, 78, 80, 81, 82, 83, 84, 85, 86, 87, 88, 88,
89, 90, 91, 91, 91, 91, 92, 92, 91, 92, 91, 91, 92, 92, 92, 92, 92, 92, 93, 92,
93, 93, 93, 94, 95, 95, 95, 96, 98, 97, 98, 98, 99, 99, 101, 101, 100, 101, 101,
101, 101, 101, 101, 100, 100, 101, 100, 100, 100, 99, 99, 99, 98, 98, 98, 98,
98, 97, 98, 97, 98, 98, 98, 98, 99, 98, 99, 99, 99, 99, 99, 100, 99, 99, 99, 99,
99, 98, 98, 98, 98, 98, 97, 98, 97, 96, 96, 96, 96, 96, 96, 97, 96, 95, 97, 97,
96, 97, 97, 97, 98, 98, 99, 98, 99, 100, 100, 100, 100, 100, 101, 101, 101, 100,
101, 100, 100, 99, 100, 100, 99, 99, 98, 98, 98, 97, 96, 96, 96, 96, 96, 96, 97,
96, 96, 97, 97, 98, 98, 99, 99, 99, 99, 99, 99, 100, 100, 100, 101, 101, 100,
100, 99, 99, 99, 99, 98, 97, 97, 96, 96, 94, 94, 94, 93, 93, 92, 93, 92, 92, 92,
92, 92, 92, 93, 94, 95, 95, 96, 96, 98, 98, 99, 99, 100, 101, 100, 101, 101,
100, 100, 99, 99, 97, 96, 94, 91, 89, 86, 83, 80, 77, 73, 69, 65, 61, 56, 52,
47, 43, 38, 32, 28, 24, 19, 14, 9, 5, 1, -3, -7, -11, -15, -19, -21, -24, -27,
-30, -33, -35, -38, -40, -41, -43, -45, -47, -48, -50, -52, -52, -54, -55, -57,
-57, -59, -60, -60, -62, -64, -65, -65, -66, -69, -69, -70, -71, -73, -73, -75,
-76, -77, -79, -80, -81, -83, -84, -86, -86, -87, -89, -90, -91, -92, -93, -95,
-95, -96, -98, -98, -98, -99, -100, -100, -101, -102, -102, -102, -103, -103,
-103, -104, -105, -104, -105, -105, -105, -105, -106, -106, -106, -107, -106,
-107, -107, -108, -108, -109, -109, -110, -111, -110, -111, -113, -112, -113,
-114, -114, -114, -114, -115, -115, -115, -114, -115, -115, -116, -115, -115,
-114, -114, -114, -113, -113, -113, -113, -113, -112, -112, -111, -112, -111,
-112, -113, -112, -113, -113, -114, -113, -114, -115, -114, -116, -117, -116,
-117, -118, -118, -119, -119, -120, -119, -119, -118, -118, -118, -118, -118,
-118, -117, -116, -117, -116, -115, -115, -114, -114, -114, -113, -112, -112,
-112, -112, -112, -113, -112, -113, -113, -114, -114, -115, -115, -116, -116,
-117, -116, -117, -118, -117, -117, -117, -117, -117, -116, -115, -115, -114,
-113, -112, -111, -109, -109, -107, -106, -105, -104, -103, -101, -101, -100,
-99, -99, -98, -98, -99, -99, -99, -100, -100, -101, -102, -102, -103, -104,
-105, -104, -106, -106, -105, -105, -104, -104, -102, -100, -97, -95, -91, -89,
-85, -81, -76, -70, -66, -59, -53, -47, -41, -35, -29, -21, -14, -9, -1, };