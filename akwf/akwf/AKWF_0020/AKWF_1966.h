#define DATA_LENGTH 512
#define DATA AKWF_1966

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 1, 2, 2, 2, 2, 3, 3, 3, 3, 3,
3, 4, 4, 4, 5, 4, 5, 6, 6, 6, 6, 6, 7, 8, 8, 8, 8, 8, 8, 8, 9, 9, 9, 10, 10, 11,
14, 16, 20, 24, 27, 31, 33, 37, 40, 43, 47, 50, 54, 57, 61, 64, 68, 71, 73, 75,
76, 77, 78, 80, 82, 82, 84, 85, 86, 88, 88, 90, 90, 92, 93, 94, 96, 97, 97, 97,
98, 98, 98, 99, 98, 99, 99, 100, 101, 101, 102, 101, 101, 103, 102, 103, 103,
104, 105, 105, 105, 105, 107, 107, 107, 108, 108, 109, 109, 109, 110, 110, 112,
111, 112, 112, 112, 112, 111, 111, 111, 111, 111, 111, 111, 111, 111, 110, 110,
110, 110, 110, 109, 109, 109, 109, 109, 108, 109, 108, 108, 108, 107, 107, 106,
107, 107, 106, 106, 106, 106, 105, 105, 105, 104, 103, 102, 102, 101, 100, 99,
99, 99, 98, 97, 96, 96, 95, 95, 93, 93, 92, 92, 90, 89, 89, 89, 87, 86, 86, 84,
84, 82, 82, 81, 80, 80, 79, 77, 77, 77, 75, 74, 73, 72, 70, 70, 69, 67, 67, 65,
64, 63, 62, 61, 60, 59, 57, 57, 55, 54, 53, 52, 51, 49, 48, 48, 45, 45, 43, 42,
40, 39, 38, 37, 35, 34, 33, 31, 30, 28, 28, 26, 24, 24, 22, 20, 20, 19, 17, 15,
15, 12, 12, 10, 9, 8, 6, 5, 4, 2, 1, -2, -3, -4, -4, -6, -8, -9, -10, -12, -14,
-14, -17, -17, -19, -21, -21, -23, -25, -26, -27, -29, -30, -31, -33, -34, -35,
-37, -38, -39, -40, -43, -44, -45, -46, -48, -49, -50, -52, -53, -54, -55, -57,
-57, -58, -61, -62, -63, -63, -66, -66, -68, -68, -70, -72, -72, -73, -74, -75,
-76, -78, -78, -80, -81, -82, -83, -84, -85, -86, -87, -88, -89, -90, -90, -92,
-93, -94, -94, -95, -96, -96, -97, -98, -99, -100, -101, -101, -103, -103, -105,
-105, -105, -107, -107, -107, -108, -109, -109, -110, -109, -110, -111, -112,
-112, -113, -113, -113, -114, -114, -114, -116, -116, -116, -116, -116, -117,
-117, -117, -117, -117, -118, -118, -118, -118, -118, -118, -118, -118, -118,
-119, -120, -119, -119, -119, -118, -118, -118, -118, -118, -118, -118, -117,
-118, -117, -117, -117, -117, -118, -117, -117, -116, -115, -114, -114, -114,
-114, -114, -113, -112, -112, -110, -112, -110, -109, -109, -109, -109, -108,
-107, -106, -105, -104, -104, -103, -103, -102, -101, -99, -99, -98, -98, -97,
-96, -95, -94, -92, -92, -91, -91, -89, -87, -86, -85, -84, -84, -82, -81, -80,
-78, -77, -75, -75, -73, -72, -71, -70, -69, -67, -65, -64, -62, -62, -60, -58,
-57, -54, -54, -52, -50, -50, -48, -47, -44, -43, -42, -40, -39, -38, -36, -36,
-33, -33, -31, -29, -28, -28, -25, -25, -23, -22, -20, -19, -18, -17, -15, -14,
-14, -13, -12, -11, -10, -8, -8, -7, -7, -6, -5, -4, -2, -2, -1, -1, };