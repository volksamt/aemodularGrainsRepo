#define DATA_LENGTH 512
#define DATA AKWF_1909

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 4, 5, 6, 7, 8, 8, 10, 10, 12,
13, 13, 14, 14, 16, 16, 18, 18, 19, 20, 22, 23, 23, 25, 25, 27, 27, 29, 30, 31,
32, 33, 34, 36, 37, 38, 40, 40, 42, 43, 45, 46, 48, 49, 51, 52, 52, 54, 56, 57,
59, 60, 62, 63, 65, 66, 68, 70, 71, 74, 76, 77, 79, 81, 83, 85, 87, 89, 92, 94,
97, 99, 103, 106, 108, 110, 114, 117, 119, 119, 119, 119, 119, 119, 119, 119,
118, 120, 119, 119, 119, 119, 119, 119, 118, 115, 112, 106, 100, 94, 88, 80, 73,
64, 57, 49, 40, 30, 22, 13, 3, -5, -14, -21, -29, -38, -44, -51, -58, -64, -69,
-73, -78, -81, -85, -87, -88, -90, -90, -90, -90, -89, -88, -87, -84, -82, -80,
-78, -74, -71, -68, -64, -62, -58, -54, -51, -48, -44, -41, -39, -35, -32, -31,
-28, -26, -22, -21, -19, -17, -14, -13, -11, -8, -6, -5, -3, -2, 1, 3, 4, 5, 7,
8, 11, 12, 14, 16, 18, 20, 22, 24, 26, 27, 30, 31, 33, 35, 36, 38, 39, 42, 43,
45, 47, 49, 50, 52, 54, 56, 58, 59, 60, 62, 64, 66, 68, 70, 71, 74, 75, 77, 79,
80, 83, 85, 87, 88, 91, 92, 94, 96, 98, 99, 101, 103, 105, 105, 108, 109, 111,
111, 113, 114, 115, 116, 116, 118, 118, 119, 118, 119, 118, 118, 118, 118, 118,
119, 119, 118, 118, 118, 118, 118, 118, 116, 115, 113, 112, 111, 109, 107, 105,
103, 100, 98, 95, 92, 90, 86, 83, 79, 76, 72, 68, 64, 59, 55, 50, 46, 41, 37,
32, 28, 23, 19, 15, 10, 6, 1, -2, -7, -9, -14, -17, -21, -24, -28, -31, -34,
-37, -40, -43, -46, -48, -50, -53, -55, -57, -59, -61, -64, -66, -67, -68, -71,
-72, -74, -75, -76, -78, -80, -81, -82, -83, -84, -86, -87, -87, -89, -88, -90,
-90, -91, -92, -92, -92, -93, -93, -95, -94, -94, -95, -95, -94, -95, -94, -94,
-95, -94, -93, -94, -94, -94, -92, -93, -91, -91, -90, -90, -89, -87, -88, -86,
-86, -85, -84, -84, -83, -83, -82, -81, -80, -79, -78, -77, -78, -77, -76, -76,
-75, -74, -75, -74, -74, -74, -74, -73, -74, -74, -73, -74, -73, -73, -73, -73,
-74, -74, -73, -74, -74, -74, -74, -73, -73, -73, -73, -72, -72, -72, -71, -70,
-70, -70, -70, -69, -69, -68, -67, -67, -66, -65, -65, -64, -63, -63, -62, -60,
-61, -59, -59, -58, -57, -56, -56, -55, -54, -54, -54, -54, -53, -52, -51, -51,
-50, -49, -49, -47, -48, -47, -47, -45, -46, -45, -44, -43, -43, -43, -42, -42,
-41, -40, -40, -38, -39, -37, -37, -36, -36, -35, -34, -33, -32, -32, -31, -30,
-30, -29, -28, -27, -26, -25, -24, -24, -24, -22, -21, -20, -19, -18, -17, -18,
-15, -15, -15, -14, -12, -11, -11, -10, -9, -8, -7, -6, -6, -5, -3, -2, -2, -1,
0, };