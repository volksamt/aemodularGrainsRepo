#define DATA_LENGTH 512
#define DATA AKWF_1918

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 2, 2, 3, 3, 4, 6, 5, 8, 8, 8,
10, 11, 12, 13, 14, 16, 17, 18, 20, 21, 22, 23, 26, 27, 28, 30, 31, 33, 34, 36,
36, 37, 38, 39, 40, 42, 42, 43, 43, 45, 46, 46, 47, 47, 47, 48, 48, 49, 49, 49,
50, 51, 51, 50, 51, 52, 52, 52, 53, 54, 54, 55, 56, 56, 57, 58, 58, 59, 59, 60,
61, 62, 62, 63, 64, 65, 66, 68, 67, 68, 71, 71, 71, 72, 74, 75, 76, 78, 79, 80,
81, 82, 83, 85, 86, 87, 88, 89, 92, 92, 93, 95, 96, 97, 98, 101, 101, 103, 103,
105, 105, 107, 108, 109, 111, 111, 112, 112, 114, 114, 114, 116, 117, 117, 117,
117, 117, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119,
120, 119, 119, 117, 117, 117, 116, 116, 115, 114, 114, 112, 112, 110, 110, 110,
108, 107, 106, 106, 103, 103, 102, 101, 100, 100, 99, 98, 97, 96, 97, 95, 95,
94, 93, 93, 93, 92, 91, 90, 90, 90, 89, 89, 88, 87, 87, 86, 86, 85, 84, 83, 84,
83, 82, 81, 81, 80, 79, 78, 77, 76, 75, 75, 74, 73, 72, 70, 69, 69, 68, 67, 65,
63, 63, 61, 60, 58, 57, 55, 53, 51, 49, 48, 46, 44, 41, 39, 37, 34, 32, 30, 26,
25, 21, 18, 16, 14, 11, 8, 6, 4, 2, -1, -3, -6, -8, -9, -12, -13, -16, -17, -19,
-21, -21, -23, -24, -26, -27, -28, -29, -30, -30, -31, -33, -33, -33, -34, -34,
-35, -36, -36, -37, -38, -38, -39, -39, -40, -40, -41, -41, -42, -42, -42, -42,
-42, -42, -43, -44, -43, -44, -45, -45, -44, -45, -45, -46, -46, -47, -48, -48,
-49, -49, -50, -50, -52, -51, -53, -53, -54, -56, -56, -58, -58, -60, -60, -62,
-63, -64, -65, -67, -67, -69, -70, -71, -72, -73, -75, -76, -78, -80, -80, -81,
-83, -85, -87, -88, -90, -91, -92, -94, -96, -97, -98, -100, -101, -104, -104,
-105, -107, -108, -109, -110, -111, -112, -112, -113, -114, -114, -115, -116,
-117, -116, -117, -117, -117, -117, -116, -118, -117, -118, -117, -116, -117,
-117, -116, -116, -115, -115, -114, -115, -113, -113, -114, -113, -113, -112,
-112, -111, -112, -111, -111, -110, -109, -110, -109, -109, -109, -109, -108,
-107, -106, -106, -107, -105, -105, -105, -105, -104, -102, -102, -102, -101,
-101, -101, -100, -99, -99, -99, -99, -98, -97, -96, -95, -95, -94, -93, -93,
-92, -91, -90, -90, -89, -87, -87, -85, -84, -83, -81, -81, -79, -77, -76, -75,
-73, -72, -71, -68, -67, -64, -62, -62, -59, -57, -56, -55, -52, -51, -49, -48,
-46, -43, -43, -40, -39, -38, -35, -35, -33, -32, -30, -29, -28, -27, -26, -25,
-22, -22, -20, -19, -19, -17, -17, -15, -15, -13, -13, -12, -11, -10, -9, -8,
-8, -7, -6, -5, -5, -5, -3, -4, -3, -3, -2, -2, -1, -1, 0, 0, };