#define DATA_LENGTH 512
#define DATA AKWF_1931

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 12, 15, 19, 22, 25, 28, 32,
34, 38, 42, 45, 48, 51, 54, 58, 61, 63, 67, 70, 72, 75, 78, 81, 83, 86, 88, 90,
92, 95, 97, 99, 101, 102, 104, 105, 107, 107, 108, 110, 111, 112, 113, 112, 113,
114, 113, 113, 112, 112, 111, 111, 109, 108, 108, 107, 104, 102, 100, 98, 96,
94, 91, 88, 86, 84, 81, 78, 74, 72, 69, 66, 64, 61, 58, 55, 51, 49, 46, 43, 41,
38, 35, 34, 32, 28, 27, 25, 24, 21, 21, 19, 18, 17, 17, 16, 15, 15, 16, 16, 15,
15, 16, 17, 19, 19, 20, 21, 23, 24, 25, 27, 28, 30, 32, 34, 36, 36, 39, 40, 42,
45, 46, 47, 49, 50, 52, 54, 54, 56, 57, 57, 58, 59, 60, 60, 60, 60, 61, 60, 60,
59, 57, 57, 56, 55, 53, 52, 50, 49, 47, 44, 42, 40, 38, 36, 33, 31, 28, 26, 23,
20, 17, 14, 12, 8, 6, 3, 0, -3, -7, -8, -12, -15, -18, -20, -23, -25, -28, -30,
-32, -35, -37, -39, -41, -43, -44, -46, -47, -49, -50, -52, -53, -55, -56, -57,
-57, -58, -60, -60, -61, -61, -62, -63, -63, -64, -64, -64, -65, -64, -64, -64,
-64, -64, -63, -63, -62, -62, -61, -59, -60, -58, -57, -56, -55, -54, -52, -51,
-49, -47, -46, -44, -42, -39, -37, -35, -34, -30, -28, -25, -23, -20, -16, -13,
-10, -6, -3, 1, 4, 7, 11, 14, 19, 21, 25, 29, 32, 36, 40, 43, 46, 50, 53, 56,
59, 61, 65, 68, 70, 73, 75, 76, 78, 80, 81, 83, 83, 84, 84, 86, 85, 85, 86, 85,
84, 83, 83, 81, 79, 78, 75, 74, 71, 69, 66, 64, 61, 57, 55, 51, 48, 45, 42, 38,
35, 31, 28, 25, 21, 16, 13, 10, 6, 2, -1, -5, -8, -11, -14, -18, -21, -24, -26,
-29, -31, -34, -36, -38, -40, -42, -44, -45, -46, -49, -50, -51, -53, -53, -54,
-56, -57, -58, -60, -60, -61, -61, -62, -62, -62, -62, -63, -64, -63, -63, -64,
-64, -64, -64, -63, -63, -63, -63, -62, -62, -61, -61, -60, -60, -59, -58, -58,
-57, -58, -57, -56, -56, -55, -54, -53, -51, -50, -50, -48, -47, -46, -45, -43,
-41, -40, -39, -38, -36, -35, -33, -32, -30, -29, -28, -27, -25, -25, -23, -22,
-21, -19, -19, -19, -18, -17, -17, -17, -17, -17, -16, -17, -17, -17, -18, -19,
-20, -20, -21, -23, -24, -26, -28, -30, -32, -34, -36, -38, -41, -45, -46, -50,
-52, -56, -58, -61, -65, -67, -70, -74, -77, -80, -83, -86, -88, -91, -94, -96,
-99, -102, -104, -106, -109, -110, -112, -114, -115, -116, -116, -118, -119,
-118, -119, -120, -118, -118, -118, -117, -115, -115, -115, -112, -111, -109,
-107, -104, -103, -100, -98, -95, -93, -89, -86, -83, -80, -77, -74, -71, -66,
-63, -60, -56, -53, -49, -45, -42, -37, -33, -30, -26, -22, -19, -15, -11, -8,
-4, -1, };