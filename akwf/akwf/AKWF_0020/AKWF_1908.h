#define DATA_LENGTH 512
#define DATA AKWF_1908

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 5, 6, 8, 8, 10, 10, 12, 13,
13, 15, 16, 17, 18, 18, 20, 20, 21, 20, 22, 22, 22, 23, 24, 24, 23, 24, 23, 24,
25, 25, 24, 24, 25, 24, 25, 24, 24, 24, 24, 23, 24, 23, 23, 23, 23, 24, 22, 22,
22, 22, 21, 22, 21, 21, 21, 20, 21, 20, 20, 20, 20, 20, 20, 20, 21, 21, 21, 21,
22, 22, 23, 24, 24, 24, 25, 27, 26, 28, 29, 30, 31, 32, 33, 34, 35, 37, 38, 39,
40, 41, 42, 43, 44, 46, 48, 48, 49, 51, 51, 52, 53, 54, 55, 56, 57, 58, 58, 60,
60, 61, 62, 62, 63, 63, 65, 64, 66, 66, 67, 67, 67, 68, 68, 68, 68, 69, 69, 69,
69, 69, 68, 69, 69, 69, 68, 69, 68, 69, 68, 68, 68, 67, 68, 68, 68, 66, 66, 66,
67, 67, 66, 66, 67, 66, 65, 66, 66, 65, 65, 66, 67, 67, 66, 67, 67, 67, 67, 68,
68, 69, 69, 69, 70, 71, 71, 71, 72, 74, 75, 76, 77, 77, 79, 80, 80, 83, 84, 85,
86, 87, 89, 91, 92, 94, 95, 97, 98, 100, 101, 102, 104, 104, 106, 108, 109, 111,
112, 113, 114, 117, 117, 117, 117, 116, 116, 118, 117, 118, 117, 117, 117, 117,
117, 117, 117, 117, 117, 118, 117, 116, 115, 113, 110, 106, 103, 99, 95, 90, 86,
81, 75, 69, 64, 58, 52, 46, 40, 33, 27, 22, 15, 10, 3, -2, -9, -13, -18, -25,
-30, -35, -40, -45, -49, -54, -58, -63, -67, -71, -75, -79, -82, -86, -89, -93,
-96, -99, -102, -104, -107, -110, -111, -113, -116, -118, -118, -120, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -118,
-120, -118, -117, -117, -115, -113, -112, -111, -110, -108, -107, -105, -105,
-103, -102, -100, -98, -97, -96, -93, -92, -90, -89, -88, -87, -84, -83, -82,
-80, -78, -78, -76, -75, -74, -73, -72, -71, -70, -69, -68, -68, -67, -66, -66,
-67, -66, -65, -65, -66, -64, -65, -64, -65, -65, -66, -65, -64, -65, -65, -66,
-66, -67, -67, -67, -68, -67, -68, -67, -68, -68, -68, -69, -68, -68, -69, -69,
-70, -69, -70, -70, -71, -70, -70, -71, -70, -70, -70, -70, -70, -69, -69, -68,
-67, -67, -66, -65, -65, -63, -63, -62, -61, -58, -58, -57, -56, -54, -53, -52,
-50, -48, -47, -46, -45, -44, -42, -40, -40, -39, -37, -37, -36, -34, -34, -32,
-32, -31, -30, -29, -29, -29, -27, -26, -25, -25, -25, -24, -23, -24, -23, -23,
-22, -22, -22, -21, -21, -22, -20, -21, -20, -21, -20, -21, -20, -20, -20, -21,
-21, -21, -21, -21, -21, -21, -21, -23, -22, -23, -22, -22, -22, -23, -22, -22,
-21, -22, -22, -22, -22, -22, -21, -21, -21, -21, -20, -19, -19, -19, -18, -18,
-18, -17, -16, -15, -14, -15, -14, -12, -12, -11, -11, -10, -8, -8, -6, -5, -5,
-3, -2, -1, 0, };