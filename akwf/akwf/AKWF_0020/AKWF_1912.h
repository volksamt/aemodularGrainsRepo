#define DATA_LENGTH 512
#define DATA AKWF_1912

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 7, 11, 13, 17, 20, 23, 26, 28,
32, 35, 37, 39, 41, 43, 44, 47, 47, 49, 50, 52, 52, 53, 54, 55, 55, 56, 56, 56,
56, 56, 57, 56, 56, 56, 56, 55, 54, 54, 53, 53, 53, 51, 51, 50, 49, 48, 46, 46,
45, 44, 43, 41, 40, 38, 36, 35, 35, 33, 32, 31, 29, 28, 27, 26, 25, 24, 23, 23,
22, 22, 22, 21, 20, 21, 21, 21, 20, 20, 21, 21, 22, 22, 21, 21, 23, 22, 23, 23,
23, 23, 23, 24, 23, 24, 23, 23, 23, 22, 23, 23, 22, 21, 21, 20, 21, 20, 20, 19,
19, 19, 19, 20, 20, 20, 21, 22, 23, 24, 26, 27, 29, 31, 33, 36, 38, 41, 44, 48,
51, 53, 57, 61, 65, 69, 72, 75, 79, 82, 86, 90, 93, 96, 98, 101, 103, 106, 108,
110, 111, 113, 114, 115, 116, 116, 116, 117, 117, 118, 117, 116, 115, 115, 114,
114, 112, 110, 110, 108, 107, 105, 103, 102, 100, 99, 96, 94, 92, 90, 87, 86,
84, 81, 78, 77, 74, 71, 69, 65, 63, 60, 58, 55, 53, 50, 46, 44, 41, 39, 36, 33,
31, 27, 26, 22, 21, 18, 15, 14, 11, 8, 6, 4, 2, -1, -2, -4, -7, -8, -10, -12,
-16, -17, -19, -21, -22, -26, -27, -30, -31, -34, -36, -38, -39, -43, -44, -47,
-49, -51, -53, -56, -58, -60, -61, -63, -65, -66, -68, -68, -70, -71, -72, -73,
-73, -74, -72, -73, -73, -71, -71, -71, -69, -68, -67, -64, -62, -61, -59, -57,
-55, -53, -51, -48, -48, -45, -43, -41, -40, -39, -38, -37, -38, -36, -36, -36,
-37, -37, -38, -40, -40, -42, -43, -45, -46, -49, -50, -53, -54, -57, -59, -61,
-63, -66, -67, -69, -70, -72, -74, -75, -76, -78, -78, -78, -80, -80, -80, -80,
-80, -79, -80, -79, -79, -79, -79, -78, -78, -77, -77, -78, -78, -77, -78, -78,
-78, -78, -80, -80, -81, -83, -84, -85, -87, -88, -91, -93, -95, -96, -98, -101,
-103, -105, -107, -109, -111, -112, -115, -116, -117, -118, -119, -119, -120,
-120, -119, -118, -118, -117, -115, -115, -112, -111, -108, -106, -103, -100,
-98, -94, -92, -87, -85, -81, -78, -74, -70, -66, -63, -58, -55, -50, -47, -43,
-39, -35, -31, -27, -24, -19, -15, -11, -7, -3, 2, 6, 10, 14, 17, 20, 24, 28,
31, 33, 36, 39, 40, 43, 45, 46, 48, 48, 50, 50, 51, 50, 50, 49, 49, 48, 47, 45,
44, 43, 40, 39, 36, 35, 32, 32, 29, 28, 26, 24, 23, 22, 21, 19, 18, 17, 17, 16,
16, 16, 15, 15, 16, 15, 15, 15, 16, 16, 15, 16, 16, 15, 15, 16, 16, 16, 14, 14,
14, 13, 12, 11, 9, 8, 6, 5, 3, 1, -1, -3, -6, -7, -9, -11, -13, -15, -17, -19,
-21, -22, -23, -25, -25, -26, -26, -26, -26, -26, -25, -24, -23, -22, -20, -17,
-15, -14, -11, -7, -5, -1, };