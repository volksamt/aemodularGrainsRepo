#define DATA_LENGTH 512
#define DATA AKWF_1923

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 9, 14, 18, 22, 27, 32, 35, 40,
44, 48, 52, 57, 60, 63, 67, 71, 74, 76, 79, 83, 86, 88, 91, 93, 96, 97, 100,
101, 102, 104, 105, 106, 107, 109, 109, 110, 110, 111, 110, 111, 110, 110, 110,
110, 108, 108, 107, 107, 105, 104, 103, 100, 100, 98, 96, 95, 93, 91, 89, 87,
86, 84, 82, 79, 77, 76, 72, 70, 68, 66, 64, 62, 59, 57, 55, 54, 51, 48, 47, 45,
44, 42, 40, 38, 36, 35, 33, 31, 30, 28, 27, 25, 24, 23, 22, 22, 20, 19, 19, 18,
18, 18, 17, 16, 16, 16, 16, 17, 16, 16, 17, 18, 18, 18, 18, 19, 19, 20, 21, 21,
22, 23, 25, 25, 27, 27, 29, 30, 30, 32, 33, 34, 35, 37, 38, 39, 40, 41, 42, 44,
44, 47, 46, 49, 49, 51, 52, 51, 54, 54, 55, 55, 55, 57, 57, 57, 58, 58, 58, 58,
58, 59, 58, 58, 57, 57, 56, 55, 55, 53, 52, 52, 50, 50, 48, 47, 45, 44, 42, 40,
38, 35, 34, 32, 30, 28, 25, 23, 20, 16, 15, 11, 9, 6, 4, -1, -3, -5, -9, -12,
-15, -18, -21, -24, -27, -31, -33, -35, -38, -42, -44, -46, -49, -52, -55, -57,
-60, -62, -63, -66, -67, -70, -72, -72, -74, -76, -77, -77, -78, -80, -80, -80,
-81, -80, -81, -80, -79, -80, -78, -77, -76, -76, -74, -72, -70, -69, -67, -64,
-62, -60, -57, -55, -52, -49, -46, -42, -39, -36, -32, -29, -26, -21, -17, -14,
-11, -6, -2, 1, 5, 10, 13, 17, 21, 25, 29, 32, 36, 39, 43, 47, 49, 53, 56, 60,
62, 65, 67, 69, 72, 74, 75, 78, 80, 81, 83, 84, 84, 85, 86, 85, 86, 86, 86, 85,
86, 84, 83, 82, 81, 80, 78, 77, 75, 73, 71, 67, 65, 63, 60, 57, 55, 51, 48, 44,
42, 38, 35, 32, 28, 24, 20, 17, 13, 10, 7, 3, -1, -4, -7, -11, -14, -17, -21,
-24, -27, -30, -33, -35, -38, -40, -42, -44, -46, -50, -51, -52, -54, -55, -56,
-58, -58, -59, -60, -61, -60, -61, -61, -60, -61, -61, -59, -58, -59, -57, -56,
-56, -54, -53, -51, -51, -49, -48, -45, -44, -43, -41, -40, -39, -36, -33, -33,
-31, -29, -28, -26, -24, -22, -21, -21, -19, -18, -17, -16, -14, -13, -12, -12,
-12, -12, -11, -11, -11, -12, -12, -11, -13, -14, -13, -16, -16, -17, -18, -20,
-22, -23, -25, -27, -29, -31, -34, -35, -38, -41, -43, -46, -48, -50, -54, -56,
-59, -62, -65, -68, -71, -73, -76, -79, -82, -84, -87, -90, -93, -95, -98, -100,
-102, -104, -106, -108, -110, -111, -113, -114, -115, -116, -117, -119, -119,
-119, -119, -119, -119, -119, -118, -118, -116, -115, -114, -113, -112, -109,
-108, -106, -103, -101, -98, -96, -92, -89, -87, -84, -80, -76, -73, -69, -65,
-62, -57, -52, -48, -44, -40, -35, -31, -26, -21, -17, -12, -8, -3, };