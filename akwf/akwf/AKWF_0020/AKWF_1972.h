#define DATA_LENGTH 512
#define DATA AKWF_1972

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 2, 3, 4, 4, 6, 7, 6, 7, 9, 8,
9, 10, 11, 11, 12, 12, 13, 14, 14, 15, 17, 17, 17, 19, 19, 20, 20, 22, 22, 23,
24, 25, 25, 26, 26, 27, 28, 30, 30, 31, 31, 32, 33, 34, 33, 35, 35, 36, 37, 38,
38, 39, 39, 40, 40, 41, 42, 43, 44, 45, 45, 46, 46, 48, 48, 50, 50, 51, 52, 52,
53, 53, 54, 55, 56, 56, 57, 58, 59, 60, 60, 60, 61, 61, 62, 63, 64, 65, 65, 66,
66, 67, 68, 69, 69, 70, 70, 72, 72, 73, 73, 74, 75, 74, 75, 77, 77, 78, 79, 79,
80, 81, 81, 82, 82, 83, 84, 84, 85, 85, 85, 87, 87, 88, 88, 89, 90, 90, 90, 90,
91, 92, 93, 94, 93, 95, 95, 96, 96, 97, 97, 98, 98, 98, 99, 100, 100, 101, 102,
102, 103, 104, 103, 104, 105, 105, 106, 107, 106, 106, 108, 108, 109, 108, 109,
109, 110, 110, 111, 111, 111, 112, 112, 112, 113, 113, 113, 113, 114, 114, 114,
115, 115, 115, 115, 116, 116, 116, 116, 116, 117, 117, 117, 117, 117, 117, 118,
118, 118, 118, 117, 118, 118, 118, 119, 120, 119, 119, 118, 118, 118, 118, 117,
116, 116, 116, 116, 114, 115, 114, 114, 113, 113, 112, 112, 112, 111, 110, 109,
108, 108, 107, 107, 106, 105, 106, 105, 104, 103, 102, 102, 101, 100, 100, 99,
99, 95, 89, 84, 79, 74, 68, 63, 58, 53, 48, 43, 37, 32, 26, 22, 17, 12, 6, 1,
-5, -11, -17, -23, -28, -34, -40, -46, -52, -58, -64, -70, -75, -81, -87, -93,
-99, -105, -110, -112, -112, -113, -114, -113, -113, -114, -114, -114, -114,
-114, -116, -116, -117, -116, -117, -117, -117, -118, -117, -117, -118, -118,
-119, -118, -118, -117, -118, -118, -118, -118, -117, -117, -118, -117, -118,
-118, -118, -117, -117, -118, -117, -117, -117, -116, -116, -116, -116, -115,
-114, -114, -114, -114, -114, -114, -114, -113, -112, -111, -111, -111, -110,
-110, -110, -109, -108, -107, -107, -106, -106, -106, -106, -105, -104, -104,
-104, -103, -102, -103, -102, -101, -101, -101, -100, -100, -100, -98, -98, -98,
-97, -96, -96, -95, -96, -95, -94, -93, -93, -92, -91, -91, -91, -90, -88, -88,
-87, -87, -87, -86, -85, -84, -84, -83, -82, -82, -81, -80, -80, -80, -79, -79,
-78, -78, -76, -76, -75, -74, -74, -74, -73, -72, -71, -71, -71, -70, -69, -68,
-67, -67, -66, -65, -64, -64, -63, -62, -62, -60, -60, -60, -59, -59, -57, -57,
-56, -56, -54, -54, -53, -52, -52, -50, -50, -49, -49, -48, -47, -48, -46, -45,
-44, -45, -43, -42, -42, -41, -41, -39, -39, -39, -37, -37, -36, -34, -35, -34,
-33, -32, -32, -31, -30, -29, -29, -29, -27, -26, -26, -24, -25, -24, -24, -22,
-21, -20, -20, -19, -18, -18, -17, -16, -15, -14, -12, -12, -11, -11, -9, -9,
-7, -6, -5, -5, -3, -2, -2, -1, };