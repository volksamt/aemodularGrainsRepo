#define DATA_LENGTH 512
#define DATA AKWF_2011

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 8, 11, 13, 15, 17, 20, 21,
23, 26, 27, 30, 32, 34, 35, 37, 39, 41, 43, 44, 46, 48, 49, 51, 53, 55, 56, 58,
59, 61, 62, 63, 66, 66, 68, 69, 71, 71, 73, 74, 76, 77, 78, 79, 80, 81, 82, 84,
84, 86, 86, 88, 89, 91, 91, 92, 93, 95, 96, 96, 98, 98, 100, 101, 101, 102, 103,
104, 106, 106, 107, 108, 109, 110, 110, 111, 113, 113, 114, 114, 116, 116, 117,
117, 117, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 118,
116, 116, 115, 114, 114, 113, 111, 110, 110, 108, 106, 105, 103, 102, 100, 98,
95, 94, 92, 90, 87, 85, 82, 79, 76, 73, 71, 68, 64, 63, 59, 56, 53, 50, 47, 43,
40, 37, 34, 31, 27, 23, 20, 17, 15, 11, 8, 5, 2, -2, -4, -7, -10, -14, -16, -19,
-22, -24, -27, -30, -32, -35, -37, -40, -41, -45, -46, -48, -50, -52, -53, -56,
-58, -59, -60, -62, -64, -65, -66, -68, -69, -70, -71, -72, -74, -75, -76, -76,
-78, -78, -79, -80, -81, -80, -82, -82, -82, -83, -83, -84, -84, -84, -85, -84,
-85, -86, -85, -85, -86, -85, -85, -85, -85, -84, -84, -84, -84, -84, -83, -83,
-82, -83, -81, -81, -80, -80, -78, -78, -77, -76, -76, -75, -74, -73, -71, -71,
-70, -69, -68, -67, -65, -64, -63, -61, -60, -59, -57, -56, -55, -53, -51, -50,
-49, -47, -46, -44, -42, -40, -39, -38, -35, -34, -33, -31, -28, -26, -25, -22,
-22, -20, -18, -16, -13, -12, -9, -8, -6, -3, -1, 1, 3, 5, 6, 9, 10, 13, 15, 16,
18, 20, 23, 25, 27, 28, 31, 33, 34, 36, 38, 39, 41, 43, 44, 46, 48, 50, 51, 52,
53, 55, 56, 57, 58, 59, 60, 61, 63, 63, 64, 65, 65, 67, 67, 67, 69, 69, 69, 70,
71, 71, 71, 71, 71, 71, 72, 72, 71, 71, 71, 71, 72, 71, 71, 70, 69, 69, 69, 68,
67, 66, 66, 64, 64, 63, 61, 60, 59, 58, 57, 55, 54, 52, 50, 49, 47, 46, 44, 42,
40, 38, 37, 33, 31, 29, 27, 24, 21, 19, 16, 13, 11, 8, 5, 3, -1, -4, -6, -10,
-12, -16, -19, -22, -24, -29, -32, -34, -37, -40, -43, -47, -49, -52, -54, -58,
-60, -64, -65, -69, -70, -72, -75, -77, -79, -82, -84, -86, -87, -90, -91, -93,
-94, -96, -97, -98, -99, -101, -102, -103, -103, -105, -105, -106, -107, -108,
-108, -108, -109, -109, -110, -109, -110, -110, -110, -109, -109, -109, -109,
-109, -109, -107, -107, -106, -106, -105, -105, -105, -102, -102, -101, -100,
-99, -97, -97, -96, -95, -93, -92, -90, -90, -88, -87, -85, -83, -82, -80, -79,
-77, -75, -73, -72, -69, -67, -66, -64, -61, -59, -57, -55, -52, -50, -48, -46,
-43, -41, -39, -37, -34, -32, -29, -27, -24, -22, -19, -17, -15, -11, -9, -7,
-5, -2, 0, };