#define DATA_LENGTH 512
#define DATA AKWF_1930

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 13, 14, 17, 19, 21, 23,
25, 28, 30, 32, 34, 36, 38, 41, 43, 45, 47, 49, 52, 54, 55, 58, 60, 62, 64, 67,
69, 70, 73, 76, 78, 80, 82, 84, 86, 88, 92, 94, 95, 97, 100, 101, 104, 106, 108,
110, 113, 112, 109, 109, 106, 104, 102, 100, 98, 95, 93, 92, 88, 87, 85, 82, 81,
79, 76, 75, 73, 71, 68, 67, 64, 62, 60, 58, 57, 54, 52, 50, 47, 46, 43, 41, 39,
37, 35, 32, 31, 29, 27, 25, 23, 21, 18, 18, 17, 19, 19, 20, 22, 22, 24, 24, 25,
26, 27, 28, 29, 29, 30, 31, 33, 33, 34, 35, 35, 37, 38, 39, 40, 41, 42, 43, 44,
44, 45, 47, 47, 47, 49, 49, 51, 52, 53, 54, 55, 55, 56, 57, 58, 60, 58, 56, 53,
51, 49, 46, 45, 43, 40, 37, 35, 33, 31, 28, 27, 24, 21, 19, 17, 15, 13, 11, 8,
6, 3, 1, 0, -4, -5, -8, -10, -12, -15, -17, -20, -21, -24, -27, -28, -31, -33,
-35, -37, -40, -43, -44, -47, -46, -46, -46, -46, -45, -44, -45, -45, -45, -44,
-44, -44, -44, -45, -43, -44, -44, -44, -43, -43, -43, -43, -42, -42, -42, -42,
-42, -42, -41, -41, -42, -41, -41, -40, -40, -41, -40, -40, -40, -40, -41, -39,
-40, -39, -39, -40, -37, -35, -32, -29, -27, -24, -22, -18, -16, -13, -11, -8,
-5, -2, -1, 3, 6, 8, 11, 14, 16, 18, 22, 24, 27, 30, 32, 35, 37, 40, 42, 45, 48,
51, 54, 56, 60, 62, 64, 67, 70, 73, 76, 79, 80, 83, 86, 83, 81, 77, 75, 72, 70,
67, 65, 61, 59, 57, 54, 51, 49, 46, 43, 40, 39, 35, 33, 31, 28, 25, 22, 20, 17,
14, 12, 9, 6, 4, 1, -1, -4, -8, -10, -12, -14, -18, -20, -22, -25, -28, -31,
-33, -36, -38, -38, -38, -39, -40, -39, -40, -40, -41, -41, -42, -42, -43, -43,
-43, -43, -44, -44, -45, -45, -46, -47, -47, -47, -48, -47, -48, -49, -49, -49,
-50, -51, -51, -51, -52, -52, -52, -54, -54, -54, -55, -54, -54, -56, -56, -57,
-58, -56, -55, -54, -54, -52, -52, -51, -51, -50, -49, -48, -47, -46, -46, -46,
-44, -43, -43, -42, -41, -40, -40, -39, -37, -37, -36, -35, -34, -34, -33, -32,
-32, -31, -30, -29, -28, -28, -26, -26, -26, -24, -23, -22, -23, -21, -20, -21,
-23, -26, -28, -31, -32, -34, -36, -38, -40, -43, -45, -47, -49, -51, -53, -55,
-58, -59, -63, -63, -66, -69, -70, -73, -74, -76, -79, -81, -83, -85, -88, -90,
-92, -94, -95, -99, -101, -103, -105, -106, -108, -110, -114, -115, -117, -119,
-117, -113, -111, -109, -106, -102, -99, -97, -94, -91, -89, -85, -83, -80, -77,
-74, -72, -68, -65, -63, -60, -57, -54, -52, -48, -46, -43, -40, -38, -35, -31,
-29, -27, -24, -20, -18, -15, -13, -9, -7, -4, 0, };