#define DATA_LENGTH 512
#define DATA AKWF_1983

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 6, 8, 9, 10, 13, 13, 16, 17,
17, 19, 20, 22, 23, 25, 26, 28, 29, 30, 32, 32, 34, 35, 36, 38, 39, 40, 41, 42,
43, 45, 46, 47, 48, 49, 51, 51, 52, 54, 55, 56, 57, 57, 59, 59, 60, 62, 61, 63,
64, 65, 65, 66, 67, 69, 69, 70, 71, 71, 72, 74, 74, 75, 76, 78, 78, 79, 80, 81,
83, 82, 84, 84, 85, 86, 87, 87, 88, 88, 90, 91, 91, 91, 93, 93, 94, 94, 95, 96,
97, 98, 99, 99, 99, 101, 100, 101, 102, 103, 104, 105, 106, 106, 107, 107, 109,
109, 109, 111, 111, 112, 113, 113, 114, 114, 115, 115, 115, 115, 116, 117, 117,
116, 117, 117, 118, 117, 118, 118, 117, 119, 119, 118, 119, 118, 117, 116, 116,
115, 114, 113, 113, 112, 111, 110, 110, 110, 109, 108, 108, 106, 105, 105, 104,
103, 102, 102, 101, 100, 98, 98, 97, 97, 95, 95, 93, 93, 91, 92, 90, 89, 89, 88,
87, 87, 85, 85, 84, 83, 82, 82, 81, 80, 79, 78, 78, 77, 76, 76, 75, 75, 73, 72,
71, 70, 69, 68, 68, 67, 66, 66, 64, 63, 62, 61, 61, 59, 59, 58, 57, 56, 55, 54,
54, 53, 51, 50, 49, 49, 47, 47, 46, 44, 44, 43, 42, 42, 40, 39, 38, 37, 35, 34,
33, 31, 31, 30, 28, 26, 26, 24, 23, 22, 21, 19, 19, 17, 16, 14, 12, 11, 8, 8, 6,
4, 2, 1, -1, -2, -4, -6, -8, -9, -10, -12, -14, -15, -17, -18, -19, -22, -22,
-23, -26, -27, -28, -30, -31, -32, -34, -35, -37, -38, -40, -41, -43, -43, -45,
-45, -47, -47, -48, -49, -51, -51, -53, -53, -54, -56, -56, -57, -59, -60, -60,
-61, -62, -63, -64, -65, -66, -67, -68, -69, -69, -71, -71, -72, -73, -73, -75,
-76, -77, -78, -78, -80, -80, -81, -82, -83, -83, -84, -85, -86, -86, -88, -87,
-89, -89, -91, -91, -91, -93, -93, -94, -95, -95, -96, -96, -98, -98, -99, -100,
-100, -101, -103, -103, -104, -104, -105, -105, -106, -107, -107, -108, -109,
-110, -110, -111, -112, -111, -113, -114, -114, -115, -115, -115, -117, -117,
-118, -118, -119, -119, -118, -117, -118, -118, -117, -117, -117, -117, -117,
-117, -116, -116, -115, -116, -115, -115, -115, -114, -113, -113, -112, -111,
-110, -108, -108, -107, -106, -105, -105, -103, -103, -102, -100, -100, -99,
-98, -97, -97, -95, -95, -95, -94, -93, -92, -91, -91, -90, -90, -88, -87, -86,
-85, -85, -85, -83, -83, -83, -81, -80, -79, -78, -78, -77, -76, -75, -74, -73,
-72, -71, -71, -70, -69, -68, -67, -67, -66, -65, -64, -62, -63, -61, -60, -60,
-58, -58, -57, -56, -55, -54, -54, -53, -52, -51, -50, -49, -47, -46, -46, -44,
-43, -42, -42, -40, -39, -38, -38, -35, -36, -35, -32, -32, -31, -29, -27, -25,
-24, -21, -19, -17, -16, -14, -12, -10, -8, -6, -4, -2, 0, };