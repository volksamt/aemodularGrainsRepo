#define DATA_LENGTH 512
#define DATA AKWF_1901

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 18, 27, 39, 48, 59, 68, 78, 85, 93,
101, 107, 111, 117, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 118,
119, 118, 116, 113, 110, 105, 102, 97, 93, 88, 84, 79, 75, 70, 66, 62, 57, 53,
50, 47, 43, 41, 39, 36, 34, 31, 30, 28, 27, 26, 26, 25, 23, 23, 22, 22, 21, 21,
21, 21, 22, 23, 23, 24, 25, 25, 26, 26, 27, 27, 28, 28, 28, 28, 28, 29, 28, 28,
28, 28, 28, 27, 28, 28, 27, 27, 27, 26, 26, 27, 27, 26, 27, 27, 27, 26, 26, 27,
27, 27, 27, 27, 27, 26, 27, 27, 26, 26, 27, 26, 27, 27, 26, 27, 27, 26, 27, 27,
27, 26, 26, 27, 26, 27, 27, 26, 27, 28, 27, 27, 27, 27, 26, 27, 27, 26, 26, 26,
27, 26, 26, 26, 26, 26, 26, 27, 26, 27, 26, 27, 27, 26, 27, 26, 27, 26, 26, 27,
26, 26, 27, 26, 26, 26, 26, 26, 27, 27, 26, 26, 26, 26, 27, 26, 26, 26, 27, 26,
26, 26, 26, 26, 26, 26, 26, 27, 26, 26, 27, 26, 26, 27, 27, 27, 27, 26, 27, 26,
27, 26, 27, 26, 27, 26, 26, 26, 26, 26, 25, 24, 24, 24, 23, 24, 25, 23, 25, 24,
24, 25, 25, 26, 26, 28, 29, 29, 29, 31, 31, 33, 33, 34, 34, 33, 34, 34, 33, 32,
31, 30, 28, 27, 26, 24, 21, 18, 15, 12, 9, 5, 1, -4, -10, -15, -21, -28, -35,
-42, -50, -57, -65, -72, -81, -88, -94, -100, -106, -111, -116, -119, -119,
-119, -120, -120, -119, -119, -119, -119, -119, -119, -119, -119, -118, -115,
-112, -109, -105, -101, -96, -93, -88, -83, -78, -73, -68, -62, -58, -54, -49,
-45, -42, -37, -35, -33, -30, -28, -26, -25, -24, -24, -24, -23, -24, -24, -23,
-24, -24, -24, -24, -25, -25, -26, -25, -25, -25, -25, -26, -26, -26, -26, -26,
-27, -27, -27, -27, -27, -27, -28, -26, -27, -27, -27, -27, -27, -27, -27, -26,
-27, -27, -27, -27, -27, -26, -27, -26, -26, -26, -26, -26, -26, -26, -27, -27,
-27, -27, -26, -26, -27, -26, -26, -27, -26, -27, -26, -27, -26, -26, -26, -26,
-25, -26, -26, -26, -26, -26, -26, -26, -26, -26, -27, -27, -26, -26, -26, -26,
-27, -26, -26, -27, -27, -26, -26, -26, -27, -26, -27, -26, -27, -26, -26, -26,
-27, -26, -26, -26, -26, -26, -27, -26, -27, -25, -26, -26, -26, -27, -27, -26,
-26, -27, -26, -26, -27, -26, -26, -27, -27, -26, -27, -26, -26, -27, -26, -26,
-27, -27, -26, -26, -27, -26, -26, -26, -26, -27, -26, -26, -27, -26, -26, -27,
-26, -26, -27, -26, -26, -27, -26, -26, -27, -25, -25, -25, -25, -24, -23, -23,
-23, -22, -22, -22, -22, -22, -22, -23, -23, -24, -27, -29, -30, -33, -36, -38,
-40, -42, -44, -45, -46, -45, -44, -41, -39, -35, -29, -23, -16, -7, -1, };