#define DATA_LENGTH 512
#define DATA AKWF_1952

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 10, 16, 23, 29, 36, 42, 47, 52, 58,
62, 67, 71, 73, 77, 80, 83, 86, 88, 90, 92, 93, 94, 95, 97, 99, 100, 101, 101,
103, 104, 105, 105, 107, 107, 108, 110, 111, 111, 112, 112, 113, 113, 114, 115,
115, 116, 116, 116, 115, 116, 116, 116, 115, 115, 114, 115, 113, 113, 113, 112,
111, 111, 109, 109, 108, 107, 107, 106, 105, 104, 104, 102, 102, 101, 100, 99,
98, 97, 97, 95, 95, 93, 91, 90, 88, 86, 85, 83, 81, 80, 78, 76, 74, 72, 71, 69,
68, 66, 65, 64, 62, 60, 60, 59, 58, 57, 56, 56, 56, 56, 55, 56, 56, 55, 56, 56,
56, 57, 57, 58, 59, 60, 60, 61, 61, 62, 63, 63, 63, 64, 65, 66, 66, 66, 67, 68,
69, 69, 68, 69, 70, 69, 69, 69, 70, 71, 70, 71, 70, 71, 70, 70, 70, 70, 68, 68,
68, 67, 66, 65, 65, 63, 63, 61, 60, 59, 56, 55, 53, 51, 50, 48, 46, 44, 42, 40,
38, 36, 35, 32, 30, 29, 26, 25, 22, 21, 20, 18, 15, 14, 13, 10, 9, 8, 6, 4, 3,
1, 1, -1, -2, -5, -6, -8, -9, -11, -12, -14, -15, -17, -19, -21, -21, -25, -26,
-28, -29, -31, -33, -36, -37, -38, -41, -43, -45, -47, -48, -49, -52, -53, -55,
-56, -57, -59, -59, -60, -61, -61, -62, -62, -61, -61, -61, -60, -58, -55, -54,
-52, -49, -46, -43, -40, -36, -31, -28, -22, -18, -13, -9, -3, 1, 6, 12, 16, 22,
26, 31, 35, 39, 44, 47, 50, 53, 55, 58, 59, 61, 62, 64, 63, 63, 63, 63, 62, 61,
60, 58, 57, 56, 54, 52, 51, 48, 45, 43, 42, 39, 37, 36, 35, 32, 30, 30, 27, 26,
25, 23, 21, 21, 19, 18, 17, 15, 14, 13, 11, 10, 8, 7, 5, 4, 1, -1, -2, -4, -6,
-8, -10, -13, -14, -16, -19, -20, -23, -24, -26, -28, -30, -31, -33, -35, -36,
-38, -39, -42, -42, -44, -45, -47, -48, -50, -52, -53, -54, -56, -57, -59, -60,
-62, -64, -64, -66, -66, -67, -69, -71, -70, -71, -72, -73, -73, -73, -74, -73,
-73, -73, -73, -73, -72, -72, -70, -70, -69, -67, -67, -66, -66, -64, -63, -62,
-62, -61, -60, -59, -60, -59, -58, -58, -58, -58, -58, -57, -57, -58, -58, -58,
-58, -59, -59, -59, -60, -60, -60, -61, -60, -61, -61, -62, -63, -63, -65, -65,
-66, -66, -68, -68, -70, -71, -72, -74, -76, -78, -79, -81, -83, -85, -88, -89,
-92, -94, -96, -97, -100, -102, -103, -104, -106, -107, -108, -109, -110, -111,
-112, -111, -111, -111, -110, -111, -110, -109, -109, -110, -108, -108, -107,
-107, -107, -107, -106, -107, -107, -107, -108, -109, -110, -111, -112, -114,
-114, -114, -116, -117, -119, -118, -119, -119, -119, -118, -117, -116, -115,
-113, -111, -108, -105, -102, -97, -92, -86, -80, -75, -69, -63, -56, -48, -41,
-33, -27, -19, -11, -4, };