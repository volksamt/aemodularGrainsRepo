#define DATA_LENGTH 512
#define DATA AKWF_1970

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 12, 19, 24, 28, 33, 37, 40, 44, 48,
53, 57, 60, 65, 68, 73, 77, 81, 85, 90, 93, 98, 100, 101, 102, 102, 105, 104,
106, 107, 109, 109, 111, 111, 112, 113, 114, 115, 117, 118, 119, 119, 119, 119,
119, 119, 119, 119, 118, 118, 118, 118, 118, 118, 118, 119, 119, 118, 119, 118,
118, 117, 116, 115, 114, 113, 113, 112, 111, 110, 110, 109, 108, 106, 106, 105,
105, 103, 102, 101, 100, 98, 96, 95, 92, 91, 89, 88, 85, 85, 83, 80, 79, 78, 76,
75, 72, 71, 70, 70, 69, 68, 68, 68, 67, 66, 65, 65, 64, 64, 62, 62, 61, 61, 60,
61, 60, 59, 60, 61, 62, 62, 64, 63, 65, 65, 66, 66, 67, 67, 68, 69, 69, 69, 70,
71, 71, 71, 71, 71, 71, 72, 72, 72, 72, 72, 72, 72, 73, 72, 72, 73, 73, 73, 72,
72, 71, 69, 68, 67, 65, 64, 63, 61, 60, 59, 58, 56, 55, 53, 52, 51, 49, 47, 46,
45, 43, 40, 38, 36, 35, 33, 30, 29, 27, 25, 23, 21, 20, 17, 15, 14, 12, 9, 7, 5,
4, 3, 2, -1, -2, -4, -5, -7, -9, -11, -12, -13, -15, -17, -18, -20, -22, -24,
-26, -27, -30, -32, -33, -35, -37, -39, -41, -43, -45, -46, -48, -51, -52, -54,
-56, -56, -56, -56, -56, -55, -54, -54, -55, -54, -53, -53, -53, -53, -52, -53,
-52, -52, -52, -51, -47, -42, -37, -33, -29, -23, -19, -13, -8, -5, 0, 5, 10,
14, 19, 23, 29, 33, 37, 39, 40, 42, 43, 44, 45, 47, 48, 48, 51, 51, 53, 54, 56,
58, 59, 60, 61, 61, 60, 58, 56, 54, 53, 50, 49, 46, 45, 42, 41, 39, 37, 35, 34,
32, 29, 28, 26, 24, 23, 20, 19, 18, 17, 15, 13, 11, 10, 8, 7, 5, 3, 2, 0, -2,
-3, -5, -6, -9, -10, -13, -15, -17, -18, -20, -22, -25, -27, -28, -31, -32, -33,
-36, -38, -40, -42, -44, -45, -46, -48, -50, -51, -53, -54, -55, -57, -58, -60,
-61, -64, -64, -66, -68, -69, -71, -70, -70, -71, -71, -72, -72, -71, -72, -72,
-71, -72, -72, -73, -73, -72, -73, -73, -74, -73, -73, -72, -71, -72, -70, -70,
-69, -68, -67, -66, -66, -66, -64, -64, -64, -62, -61, -61, -61, -61, -61, -62,
-62, -62, -62, -63, -63, -63, -64, -65, -65, -65, -65, -65, -67, -66, -67, -67,
-69, -71, -72, -73, -75, -77, -77, -79, -82, -83, -83, -86, -87, -89, -90, -92,
-93, -96, -96, -97, -99, -99, -101, -102, -103, -105, -105, -107, -108, -109,
-110, -111, -112, -112, -114, -115, -116, -117, -117, -116, -116, -117, -118,
-118, -117, -117, -118, -116, -117, -118, -117, -118, -117, -118, -118, -117,
-117, -117, -116, -115, -115, -115, -115, -113, -113, -113, -112, -112, -112,
-111, -111, -110, -109, -109, -108, -104, -97, -91, -84, -76, -70, -63, -56,
-49, -43, -35, -29, -22, -15, -9, -1, };