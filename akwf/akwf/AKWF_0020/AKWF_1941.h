#define DATA_LENGTH 512
#define DATA AKWF_1941

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 10, 15, 20, 24, 29, 34, 38, 44,
47, 51, 57, 60, 65, 69, 73, 76, 80, 83, 87, 90, 93, 95, 99, 102, 104, 106, 107,
111, 112, 114, 114, 116, 117, 118, 118, 119, 118, 119, 120, 118, 118, 118, 117,
116, 114, 114, 113, 112, 110, 108, 106, 105, 102, 100, 98, 95, 93, 90, 89, 86,
83, 80, 77, 74, 71, 69, 66, 64, 61, 58, 56, 53, 51, 49, 47, 43, 41, 39, 36, 34,
32, 31, 28, 27, 26, 24, 22, 21, 20, 19, 19, 17, 18, 16, 16, 15, 16, 16, 16, 16,
16, 17, 17, 18, 18, 19, 20, 21, 23, 23, 25, 25, 27, 28, 30, 31, 32, 34, 35, 37,
39, 40, 41, 43, 44, 46, 47, 48, 50, 50, 52, 52, 54, 55, 56, 57, 57, 58, 58, 58,
58, 58, 58, 57, 58, 58, 57, 55, 55, 54, 54, 51, 50, 49, 48, 46, 44, 42, 39, 37,
36, 33, 30, 28, 26, 23, 19, 17, 13, 11, 8, 4, 1, -2, -5, -9, -12, -16, -19, -22,
-25, -28, -33, -35, -38, -41, -44, -47, -50, -52, -56, -59, -61, -64, -65, -67,
-69, -71, -74, -75, -77, -78, -79, -79, -80, -82, -82, -83, -82, -83, -83, -83,
-81, -81, -81, -80, -79, -77, -75, -74, -73, -71, -68, -66, -64, -62, -60, -56,
-53, -51, -48, -44, -41, -38, -34, -30, -28, -23, -20, -16, -13, -9, -6, -2, 2,
6, 9, 14, 17, 20, 25, 28, 31, 34, 38, 42, 45, 48, 52, 54, 56, 59, 62, 65, 66,
69, 71, 73, 75, 76, 77, 79, 80, 80, 81, 83, 83, 83, 83, 83, 83, 83, 82, 81, 82,
80, 79, 77, 77, 75, 73, 72, 69, 68, 65, 63, 61, 58, 56, 53, 50, 47, 44, 42, 38,
35, 32, 29, 25, 22, 18, 14, 12, 9, 5, 1, -3, -6, -9, -12, -16, -19, -23, -26,
-28, -31, -35, -37, -41, -43, -46, -49, -51, -54, -56, -58, -60, -62, -64, -66,
-67, -69, -70, -71, -72, -74, -75, -75, -76, -77, -77, -77, -77, -78, -77, -76,
-77, -76, -76, -75, -74, -74, -73, -72, -70, -69, -68, -66, -65, -64, -63, -61,
-60, -57, -56, -54, -52, -50, -48, -47, -45, -43, -41, -39, -37, -34, -34, -32,
-30, -29, -27, -25, -24, -22, -21, -20, -19, -17, -17, -15, -14, -14, -13, -12,
-12, -12, -11, -12, -11, -11, -12, -12, -13, -13, -13, -15, -15, -17, -17, -19,
-20, -22, -23, -26, -26, -29, -30, -33, -35, -37, -39, -41, -44, -47, -49, -52,
-54, -57, -59, -62, -65, -67, -70, -74, -75, -78, -81, -84, -86, -89, -91, -93,
-96, -99, -100, -102, -104, -105, -108, -110, -111, -113, -114, -116, -116,
-117, -118, -118, -118, -119, -119, -119, -119, -118, -118, -117, -116, -116,
-114, -112, -111, -109, -106, -105, -103, -100, -98, -95, -91, -89, -86, -81,
-78, -75, -71, -67, -63, -58, -54, -49, -46, -42, -36, -32, -27, -22, -18, -13,
-8, -3, };