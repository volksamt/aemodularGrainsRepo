#define DATA_LENGTH 512
#define DATA AKWF_1986

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 7, 12, 14, 18, 21, 24, 27, 31,
34, 37, 40, 42, 44, 47, 50, 51, 53, 56, 57, 60, 62, 64, 67, 69, 71, 72, 75, 77,
79, 81, 83, 86, 89, 90, 93, 95, 97, 99, 101, 104, 105, 107, 110, 111, 115, 116,
119, 119, 116, 115, 114, 112, 110, 108, 106, 105, 103, 101, 100, 99, 96, 95, 92,
92, 89, 88, 87, 85, 82, 81, 79, 77, 77, 74, 73, 70, 69, 68, 66, 64, 63, 61, 59,
58, 57, 57, 56, 55, 54, 54, 52, 52, 52, 50, 51, 50, 48, 47, 47, 47, 45, 45, 44,
44, 43, 43, 41, 41, 41, 40, 39, 38, 38, 36, 36, 36, 35, 34, 34, 33, 33, 36, 38,
40, 42, 45, 45, 48, 50, 53, 54, 56, 59, 60, 63, 64, 66, 69, 71, 74, 75, 78, 80,
82, 83, 86, 88, 90, 92, 94, 97, 99, 101, 102, 105, 107, 108, 108, 105, 104, 102,
101, 100, 98, 96, 95, 93, 91, 89, 88, 87, 85, 84, 81, 80, 79, 77, 75, 74, 72,
71, 68, 68, 66, 64, 63, 60, 59, 58, 56, 54, 53, 51, 49, 47, 45, 42, 40, 38, 35,
32, 30, 28, 26, 23, 21, 19, 16, 14, 11, 9, 7, 4, 2, -1, -3, -6, -8, -10, -13,
-14, -17, -20, -22, -24, -27, -29, -31, -33, -37, -36, -34, -32, -30, -29, -29,
-27, -24, -22, -22, -20, -19, -17, -15, -14, -12, -10, -8, -7, -5, -4, -3, -1,
1, 2, 4, 5, 7, 9, 10, 12, 13, 15, 16, 17, 20, 21, 20, 19, 19, 18, 17, 17, 16,
15, 15, 14, 14, 14, 13, 12, 12, 12, 10, 10, 9, 10, 8, 8, 7, 7, 6, 6, 5, 5, 4, 3,
3, 2, 2, 1, 0, 0, -2, -4, -7, -10, -12, -15, -17, -20, -22, -25, -28, -30, -33,
-36, -38, -41, -43, -46, -48, -51, -53, -56, -59, -61, -64, -66, -68, -72, -74,
-77, -80, -82, -84, -87, -90, -92, -94, -94, -93, -93, -93, -92, -91, -91, -90,
-90, -90, -89, -88, -89, -88, -87, -88, -86, -86, -85, -84, -85, -84, -84, -83,
-83, -82, -81, -81, -80, -80, -80, -79, -79, -79, -77, -78, -76, -74, -72, -71,
-70, -67, -66, -64, -63, -61, -60, -58, -56, -55, -53, -52, -50, -48, -46, -44,
-43, -41, -40, -37, -37, -34, -33, -31, -30, -29, -26, -25, -23, -21, -20, -18,
-17, -18, -20, -22, -24, -26, -28, -29, -32, -34, -35, -38, -40, -41, -43, -45,
-47, -49, -50, -52, -54, -57, -59, -61, -63, -64, -67, -68, -70, -72, -74, -76,
-78, -80, -82, -84, -85, -86, -86, -87, -85, -85, -86, -85, -84, -84, -85, -84,
-83, -84, -84, -84, -83, -82, -83, -82, -82, -81, -80, -81, -81, -80, -81, -80,
-80, -80, -79, -79, -79, -79, -78, -78, -78, -78, -75, -72, -68, -65, -62, -59,
-55, -52, -49, -46, -42, -39, -37, -33, -30, -26, -23, -21, -17, -14, -10, -7,
-4, -2, };