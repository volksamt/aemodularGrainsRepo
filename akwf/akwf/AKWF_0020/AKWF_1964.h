#define DATA_LENGTH 512
#define DATA AKWF_1964

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 11, 14, 18, 22, 26, 30, 34, 38, 42,
46, 49, 54, 58, 62, 65, 69, 74, 77, 81, 85, 87, 89, 90, 93, 94, 96, 98, 100,
101, 103, 105, 106, 108, 110, 113, 114, 116, 117, 119, 117, 114, 111, 108, 105,
102, 98, 95, 92, 89, 86, 83, 80, 78, 74, 71, 68, 65, 62, 57, 52, 46, 42, 36, 31,
25, 20, 14, 10, 4, -2, -6, -12, -17, -22, -27, -33, -38, -42, -47, -50, -54,
-58, -62, -66, -70, -75, -78, -83, -85, -90, -94, -99, -103, -106, -109, -113,
-114, -113, -114, -112, -113, -111, -112, -112, -111, -110, -110, -111, -110,
-109, -109, -109, -109, -108, -107, -104, -100, -96, -92, -88, -84, -81, -76,
-73, -68, -64, -60, -56, -52, -48, -45, -41, -37, -33, -28, -24, -20, -15, -10,
-5, -1, 4, 8, 13, 17, 21, 26, 30, 35, 39, 43, 48, 53, 54, 57, 58, 61, 63, 64,
66, 68, 71, 73, 75, 77, 78, 80, 83, 85, 86, 89, 90, 88, 88, 87, 85, 85, 83, 82,
80, 80, 79, 77, 76, 75, 74, 73, 72, 70, 70, 69, 65, 62, 60, 56, 54, 52, 49, 46,
43, 41, 38, 35, 33, 30, 26, 24, 22, 18, 16, 14, 11, 8, 7, 4, 2, -1, -3, -6, -8,
-10, -13, -15, -17, -21, -23, -25, -28, -29, -30, -31, -32, -32, -33, -35, -36,
-37, -38, -40, -40, -41, -42, -44, -44, -46, -46, -47, -48, -47, -48, -48, -48,
-48, -47, -48, -47, -48, -48, -47, -47, -47, -47, -47, -47, -47, -47, -46, -46,
-45, -45, -44, -43, -41, -41, -41, -40, -39, -39, -37, -37, -36, -35, -35, -34,
-33, -32, -30, -29, -27, -26, -25, -23, -22, -20, -19, -17, -15, -15, -13, -11,
-10, -9, -7, -5, -5, -2, 0, 2, 5, 6, 9, 10, 13, 14, 16, 19, 20, 24, 25, 27, 29,
31, 33, 35, 37, 39, 41, 43, 44, 46, 47, 49, 51, 53, 55, 56, 58, 61, 61, 64, 64,
66, 67, 68, 67, 68, 67, 67, 67, 68, 67, 67, 67, 67, 66, 67, 66, 67, 67, 66, 67,
65, 62, 60, 58, 54, 53, 51, 47, 45, 42, 41, 39, 35, 33, 31, 29, 26, 24, 21, 18,
14, 10, 6, 2, -2, -6, -11, -14, -18, -22, -26, -30, -34, -38, -41, -46, -49,
-53, -57, -60, -62, -65, -67, -70, -72, -75, -78, -80, -83, -86, -88, -91, -93,
-97, -99, -101, -105, -105, -106, -107, -107, -108, -109, -110, -111, -112,
-112, -113, -114, -114, -115, -117, -117, -118, -118, -119, -117, -114, -112,
-109, -105, -103, -101, -98, -95, -92, -89, -87, -85, -82, -79, -76, -73, -71,
-68, -66, -65, -65, -64, -63, -63, -61, -60, -59, -59, -58, -56, -56, -55, -55,
-53, -52, -51, -50, -53, -54, -57, -58, -61, -63, -65, -68, -70, -72, -75, -77,
-78, -82, -84, -86, -88, -90, -93, -88, -83, -77, -72, -65, -61, -55, -50, -45,
-38, -34, -28, -22, -16, -12, -6, -1, };