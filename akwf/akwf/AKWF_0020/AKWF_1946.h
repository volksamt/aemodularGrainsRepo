#define DATA_LENGTH 512
#define DATA AKWF_1946

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 9, 12, 18, 22, 27, 31, 35, 40,
44, 48, 54, 57, 60, 65, 70, 73, 77, 80, 84, 88, 91, 95, 97, 100, 102, 106, 107,
109, 112, 113, 115, 116, 117, 117, 119, 118, 118, 119, 118, 119, 117, 117, 115,
114, 113, 111, 109, 107, 105, 103, 100, 98, 95, 92, 90, 87, 84, 82, 79, 76, 72,
69, 68, 64, 61, 58, 55, 52, 50, 47, 45, 43, 41, 38, 36, 35, 33, 32, 31, 29, 29,
27, 27, 26, 25, 25, 24, 25, 24, 24, 24, 25, 25, 26, 26, 26, 27, 28, 30, 30, 31,
32, 33, 34, 34, 35, 37, 37, 40, 40, 41, 41, 44, 44, 45, 45, 46, 47, 48, 48, 48,
49, 49, 49, 49, 49, 49, 49, 48, 49, 47, 48, 47, 46, 46, 46, 45, 44, 43, 42, 41,
41, 39, 38, 36, 36, 35, 33, 32, 31, 29, 28, 26, 25, 23, 21, 20, 19, 17, 15, 13,
11, 10, 8, 7, 5, 4, 2, 0, -2, -3, -5, -8, -8, -11, -13, -15, -16, -18, -21, -23,
-24, -26, -28, -30, -32, -35, -38, -39, -41, -43, -46, -48, -49, -50, -53, -55,
-58, -59, -61, -62, -63, -65, -67, -68, -70, -71, -72, -72, -74, -75, -75, -76,
-77, -78, -77, -77, -77, -78, -77, -76, -76, -75, -75, -74, -73, -72, -71, -69,
-68, -67, -66, -64, -62, -60, -58, -56, -53, -52, -50, -48, -46, -44, -40, -38,
-35, -33, -31, -28, -27, -23, -21, -18, -16, -13, -11, -8, -6, -4, -1, 1, 3, 6,
8, 10, 13, 14, 16, 19, 20, 23, 25, 27, 29, 32, 33, 35, 38, 39, 42, 43, 45, 47,
48, 50, 52, 54, 55, 56, 58, 59, 60, 61, 63, 63, 65, 65, 67, 67, 67, 69, 68, 69,
68, 68, 68, 68, 68, 67, 66, 65, 64, 62, 62, 61, 60, 57, 55, 54, 51, 49, 46, 44,
42, 38, 36, 32, 29, 26, 23, 20, 17, 13, 10, 7, 3, 1, -4, -6, -10, -13, -16, -20,
-24, -26, -28, -31, -34, -37, -39, -42, -44, -45, -49, -51, -52, -53, -54, -55,
-56, -58, -58, -58, -58, -59, -59, -58, -58, -57, -57, -56, -54, -54, -52, -51,
-51, -48, -47, -45, -43, -42, -40, -38, -38, -34, -33, -32, -30, -30, -27, -26,
-24, -22, -22, -20, -19, -17, -18, -17, -16, -15, -15, -16, -15, -15, -15, -17,
-16, -17, -19, -20, -21, -22, -23, -25, -26, -28, -30, -32, -34, -36, -37, -40,
-42, -44, -47, -49, -52, -55, -56, -59, -61, -63, -67, -69, -71, -73, -76, -77,
-80, -82, -84, -86, -87, -88, -90, -92, -93, -94, -96, -97, -97, -98, -98, -99,
-100, -100, -101, -101, -101, -101, -102, -101, -100, -101, -100, -100, -99,
-99, -98, -97, -96, -95, -95, -93, -92, -91, -90, -89, -87, -85, -83, -82, -80,
-79, -76, -74, -72, -71, -67, -65, -62, -60, -58, -55, -51, -48, -45, -43, -40,
-37, -34, -30, -27, -23, -18, -15, -11, -6, -3, };