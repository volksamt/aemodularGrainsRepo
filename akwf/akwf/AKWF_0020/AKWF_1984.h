#define DATA_LENGTH 512
#define DATA AKWF_1984

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 3, 4, 5, 6, 7, 9, 10, 11, 12,
13, 15, 15, 17, 18, 19, 20, 21, 23, 24, 25, 25, 28, 28, 29, 30, 32, 33, 34, 36,
37, 38, 39, 40, 41, 41, 44, 45, 45, 46, 48, 49, 50, 52, 53, 55, 57, 58, 58, 60,
61, 62, 64, 66, 67, 69, 70, 71, 73, 75, 76, 77, 78, 79, 81, 82, 84, 86, 87, 88,
90, 92, 92, 93, 95, 96, 98, 100, 101, 102, 102, 103, 103, 104, 104, 105, 105,
106, 105, 106, 107, 107, 108, 108, 108, 108, 110, 110, 110, 110, 110, 112, 111,
112, 112, 113, 113, 113, 114, 114, 115, 114, 115, 117, 116, 116, 117, 114, 112,
110, 108, 107, 105, 102, 101, 98, 97, 96, 94, 92, 90, 87, 85, 84, 81, 79, 78,
76, 73, 71, 69, 68, 67, 64, 63, 61, 59, 57, 54, 54, 51, 50, 48, 46, 46, 44, 44,
44, 42, 42, 42, 41, 41, 40, 39, 38, 37, 37, 37, 36, 35, 34, 34, 33, 32, 31, 30,
31, 30, 28, 28, 27, 27, 27, 25, 25, 23, 23, 22, 23, 22, 21, 21, 20, 21, 21, 21,
20, 20, 20, 20, 19, 20, 19, 20, 19, 19, 18, 19, 19, 18, 18, 18, 17, 17, 17, 16,
17, 17, 17, 16, 17, 16, 16, 15, 16, 15, 14, 14, 13, 13, 12, 12, 11, 10, 10, 9,
9, 9, 8, 7, 6, 5, 6, 5, 4, 4, 3, 2, 3, 1, 1, 0, 0, -1, -1, -2, -2, -3, -3, -4,
-5, -5, -6, -6, -7, -8, -8, -9, -10, -10, -11, -10, -12, -12, -13, -13, -14,
-15, -15, -16, -17, -17, -18, -18, -19, -19, -21, -21, -22, -22, -23, -22, -23,
-24, -24, -25, -26, -26, -27, -27, -27, -28, -28, -27, -28, -27, -27, -28, -28,
-28, -28, -29, -28, -28, -29, -29, -29, -30, -29, -29, -30, -30, -30, -30, -29,
-31, -31, -31, -31, -30, -31, -31, -31, -32, -31, -33, -33, -33, -35, -34, -36,
-37, -37, -38, -38, -40, -40, -40, -41, -43, -43, -43, -44, -45, -45, -46, -47,
-48, -48, -49, -50, -50, -51, -51, -52, -53, -54, -54, -56, -57, -57, -57, -59,
-62, -63, -64, -66, -68, -70, -72, -74, -75, -76, -78, -79, -81, -84, -85, -87,
-89, -90, -92, -94, -96, -97, -98, -100, -101, -104, -106, -107, -109, -111,
-112, -115, -116, -117, -118, -119, -118, -117, -115, -115, -115, -114, -113,
-112, -112, -110, -109, -110, -108, -107, -108, -107, -105, -105, -104, -103,
-103, -101, -100, -100, -100, -99, -98, -97, -97, -96, -96, -94, -93, -93, -91,
-90, -89, -87, -86, -84, -82, -80, -79, -77, -75, -73, -72, -70, -69, -67, -65,
-63, -62, -60, -58, -57, -55, -54, -52, -50, -49, -46, -45, -44, -41, -40, -38,
-36, -35, -32, -31, -29, -29, -27, -26, -25, -23, -24, -22, -21, -20, -20, -18,
-17, -16, -15, -14, -12, -12, -11, -9, -9, -8, -7, -6, -5, -3, -3, -2, 0, };