#define DATA_LENGTH 512
#define DATA AKWF_1989

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 8, 11, 13, 16, 18, 20, 23,
24, 28, 30, 31, 35, 36, 39, 41, 43, 47, 48, 50, 53, 55, 56, 58, 60, 61, 64, 65,
68, 70, 72, 74, 75, 77, 79, 82, 83, 85, 87, 89, 90, 92, 95, 96, 98, 100, 102,
104, 105, 109, 110, 111, 114, 115, 117, 120, 118, 118, 117, 116, 116, 114, 114,
113, 112, 112, 112, 111, 109, 108, 109, 108, 108, 106, 106, 105, 104, 103, 102,
102, 101, 100, 99, 98, 98, 97, 97, 96, 96, 94, 93, 93, 92, 90, 89, 87, 85, 83,
82, 80, 80, 77, 76, 75, 73, 72, 70, 69, 67, 64, 63, 62, 60, 59, 57, 56, 55, 52,
51, 49, 48, 46, 44, 43, 41, 40, 39, 37, 35, 36, 35, 36, 35, 36, 36, 35, 35, 36,
36, 36, 37, 36, 36, 37, 36, 36, 38, 37, 37, 37, 37, 38, 37, 37, 38, 38, 38, 39,
39, 38, 38, 38, 38, 38, 38, 38, 39, 39, 39, 40, 39, 40, 39, 40, 40, 40, 40, 41,
41, 41, 41, 42, 41, 42, 43, 42, 43, 42, 42, 43, 43, 44, 44, 44, 44, 44, 44, 45,
44, 45, 45, 45, 45, 46, 45, 47, 47, 48, 48, 48, 48, 48, 50, 50, 50, 49, 51, 51,
51, 52, 53, 52, 53, 53, 54, 55, 54, 55, 55, 55, 56, 56, 56, 58, 57, 58, 57, 59,
58, 55, 53, 50, 48, 45, 42, 39, 36, 34, 31, 29, 26, 24, 21, 18, 15, 13, 10, 7,
4, 2, -1, -4, -6, -9, -12, -14, -17, -20, -22, -25, -28, -31, -33, -36, -38,
-40, -42, -43, -45, -46, -48, -50, -51, -53, -54, -56, -57, -59, -60, -62, -64,
-65, -66, -68, -69, -71, -72, -74, -76, -77, -78, -80, -82, -83, -85, -86, -88,
-89, -90, -92, -94, -95, -95, -93, -93, -92, -91, -91, -89, -89, -88, -88, -87,
-86, -85, -84, -83, -83, -81, -81, -80, -79, -79, -78, -77, -76, -76, -75, -74,
-73, -72, -71, -71, -70, -69, -69, -68, -67, -67, -67, -67, -68, -68, -67, -68,
-68, -68, -69, -68, -68, -69, -70, -69, -71, -70, -70, -71, -71, -71, -71, -72,
-72, -72, -72, -71, -73, -72, -73, -73, -73, -74, -74, -74, -74, -75, -73, -74,
-73, -73, -72, -72, -70, -70, -69, -69, -69, -68, -68, -68, -67, -66, -66, -65,
-64, -64, -63, -63, -63, -63, -62, -62, -61, -60, -60, -60, -59, -59, -59, -58,
-57, -56, -56, -57, -57, -57, -57, -57, -58, -57, -58, -57, -58, -57, -58, -57,
-57, -57, -58, -59, -59, -59, -58, -59, -59, -59, -58, -59, -59, -59, -59, -59,
-59, -60, -59, -60, -60, -61, -60, -60, -59, -59, -57, -57, -57, -56, -55, -53,
-54, -53, -53, -52, -51, -51, -50, -49, -49, -47, -47, -47, -45, -45, -44, -43,
-43, -42, -41, -41, -41, -40, -39, -38, -39, -36, -37, -35, -32, -30, -28, -26,
-24, -22, -19, -17, -14, -12, -10, -8, -5, -3, -1, };