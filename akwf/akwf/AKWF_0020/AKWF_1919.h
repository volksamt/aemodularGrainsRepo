#define DATA_LENGTH 512
#define DATA AKWF_1919

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 6, 7, 9, 12, 14, 15, 17, 19,
22, 26, 28, 31, 33, 36, 39, 42, 44, 48, 51, 54, 57, 60, 62, 66, 69, 71, 74, 77,
79, 81, 84, 87, 89, 90, 93, 95, 97, 98, 100, 102, 104, 105, 107, 108, 109, 110,
112, 113, 114, 114, 116, 115, 116, 118, 118, 118, 119, 118, 119, 119, 119, 119,
120, 119, 119, 118, 117, 117, 116, 116, 116, 115, 114, 113, 113, 112, 111, 110,
109, 108, 108, 107, 105, 106, 104, 103, 104, 102, 103, 102, 101, 100, 100, 100,
99, 99, 98, 98, 98, 97, 96, 96, 96, 96, 95, 96, 94, 94, 92, 92, 92, 91, 90, 89,
88, 88, 87, 87, 85, 85, 84, 82, 81, 80, 79, 78, 76, 75, 74, 73, 72, 71, 69, 69,
67, 67, 65, 64, 64, 62, 61, 60, 59, 58, 57, 55, 54, 54, 52, 52, 51, 50, 48, 48,
47, 46, 45, 44, 44, 44, 42, 42, 41, 41, 40, 39, 40, 39, 38, 37, 38, 38, 37, 38,
37, 37, 37, 37, 36, 37, 36, 36, 36, 37, 36, 35, 35, 35, 34, 34, 33, 32, 32, 31,
29, 29, 27, 25, 24, 23, 21, 20, 19, 17, 14, 13, 11, 9, 8, 6, 4, 2, -1, -2, -4,
-7, -8, -10, -12, -15, -17, -19, -21, -22, -24, -26, -28, -30, -32, -34, -35,
-37, -39, -41, -42, -44, -46, -48, -49, -50, -53, -54, -55, -56, -58, -60, -60,
-61, -63, -64, -65, -65, -66, -68, -68, -69, -70, -71, -72, -72, -73, -73, -74,
-74, -74, -75, -76, -76, -76, -77, -77, -78, -79, -79, -80, -80, -81, -81, -82,
-83, -83, -84, -84, -85, -85, -86, -87, -88, -88, -88, -88, -89, -90, -90, -91,
-91, -91, -91, -91, -91, -91, -91, -92, -91, -91, -91, -90, -90, -90, -89, -89,
-88, -87, -86, -86, -85, -84, -84, -82, -82, -81, -81, -79, -78, -78, -76, -75,
-74, -74, -72, -71, -70, -68, -68, -65, -64, -63, -62, -61, -60, -58, -57, -55,
-53, -53, -51, -50, -49, -48, -46, -45, -44, -43, -41, -41, -39, -38, -37, -36,
-35, -35, -34, -32, -31, -30, -29, -29, -28, -27, -26, -26, -26, -24, -25, -24,
-23, -23, -24, -23, -22, -23, -23, -23, -24, -23, -23, -23, -24, -25, -25, -24,
-25, -26, -27, -28, -28, -29, -30, -31, -30, -32, -33, -34, -35, -35, -36, -36,
-38, -39, -40, -41, -41, -42, -44, -44, -45, -45, -47, -47, -48, -49, -49, -51,
-52, -52, -53, -53, -54, -55, -54, -55, -55, -56, -57, -57, -56, -57, -57, -57,
-57, -56, -56, -56, -57, -56, -55, -55, -54, -53, -53, -53, -52, -52, -51, -50,
-50, -49, -47, -47, -47, -45, -45, -44, -43, -43, -42, -41, -40, -40, -39, -38,
-38, -36, -36, -36, -34, -33, -31, -32, -31, -30, -28, -28, -27, -26, -26, -25,
-23, -22, -21, -20, -19, -19, -18, -17, -16, -16, -14, -13, -13, -11, -9, -9,
-7, -6, -5, -4, -3, -2, };