#define DATA_LENGTH 512
#define DATA AKWF_1947

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 13, 18, 22, 28, 32, 37, 41, 46,
50, 56, 60, 64, 68, 72, 76, 79, 82, 85, 89, 92, 94, 97, 100, 101, 104, 105, 107,
108, 110, 110, 111, 111, 113, 113, 113, 114, 113, 113, 112, 112, 110, 110, 109,
107, 106, 104, 102, 101, 99, 98, 95, 93, 91, 89, 87, 83, 82, 79, 77, 74, 72, 69,
67, 65, 63, 59, 57, 55, 53, 51, 48, 47, 43, 42, 40, 38, 37, 35, 33, 32, 30, 29,
28, 27, 25, 25, 24, 24, 22, 22, 22, 21, 20, 21, 22, 21, 21, 21, 22, 22, 22, 23,
24, 24, 25, 26, 27, 28, 28, 30, 31, 32, 33, 34, 35, 35, 37, 37, 39, 40, 40, 42,
42, 43, 44, 45, 45, 46, 47, 47, 47, 48, 48, 48, 49, 49, 49, 49, 49, 48, 48, 48,
47, 47, 46, 46, 45, 44, 43, 42, 41, 39, 38, 36, 35, 34, 32, 30, 29, 27, 26, 23,
21, 19, 18, 15, 12, 11, 10, 7, 4, 2, 0, -3, -5, -7, -9, -12, -15, -16, -19, -21,
-23, -25, -27, -30, -33, -35, -37, -38, -41, -43, -45, -46, -48, -51, -51, -54,
-56, -57, -58, -59, -61, -63, -64, -65, -66, -66, -68, -69, -70, -71, -71, -72,
-73, -73, -74, -73, -74, -74, -74, -74, -74, -73, -73, -72, -71, -72, -71, -71,
-69, -68, -67, -66, -64, -64, -62, -61, -60, -58, -57, -54, -52, -51, -49, -47,
-45, -43, -41, -39, -36, -34, -32, -28, -26, -24, -21, -18, -17, -12, -10, -7,
-6, -2, 0, 4, 7, 9, 13, 15, 17, 20, 23, 26, 29, 32, 34, 37, 39, 41, 44, 47, 48,
51, 53, 54, 56, 58, 60, 61, 63, 65, 66, 67, 68, 69, 70, 71, 71, 72, 72, 72, 72,
72, 71, 71, 70, 70, 70, 68, 67, 66, 65, 64, 62, 60, 58, 56, 55, 52, 50, 49, 46,
43, 41, 38, 35, 32, 30, 27, 24, 21, 17, 15, 11, 9, 6, 2, 0, -3, -6, -9, -12,
-15, -17, -21, -23, -26, -28, -31, -33, -36, -38, -41, -42, -44, -46, -48, -49,
-51, -52, -53, -55, -56, -56, -57, -58, -58, -58, -59, -59, -58, -58, -58, -57,
-58, -56, -56, -54, -54, -53, -51, -51, -49, -48, -47, -46, -44, -42, -40, -39,
-38, -36, -35, -34, -32, -29, -28, -27, -25, -23, -22, -20, -20, -18, -18, -17,
-15, -15, -14, -14, -13, -13, -13, -12, -13, -12, -13, -14, -14, -14, -15, -17,
-17, -19, -21, -22, -23, -25, -27, -28, -31, -33, -35, -38, -40, -43, -45, -48,
-51, -53, -55, -59, -62, -65, -67, -71, -74, -76, -79, -82, -86, -88, -90, -94,
-95, -98, -101, -102, -104, -106, -109, -111, -112, -113, -115, -116, -116,
-118, -118, -118, -119, -120, -119, -119, -118, -117, -116, -115, -113, -113,
-110, -109, -108, -104, -102, -99, -96, -93, -90, -87, -83, -80, -76, -72, -68,
-64, -58, -55, -49, -46, -40, -35, -31, -25, -21, -16, -11, -7, -1, };