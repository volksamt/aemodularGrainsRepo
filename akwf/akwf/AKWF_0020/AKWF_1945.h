#define DATA_LENGTH 512
#define DATA AKWF_1945

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 7, 10, 15, 18, 22, 25, 28, 32,
35, 39, 42, 46, 49, 53, 56, 60, 63, 67, 71, 73, 78, 81, 84, 88, 91, 95, 98, 103,
105, 109, 112, 116, 119, 118, 115, 114, 111, 109, 107, 106, 104, 102, 100, 98,
96, 94, 92, 90, 88, 86, 84, 83, 81, 79, 77, 75, 72, 71, 68, 67, 65, 63, 61, 59,
57, 55, 54, 52, 49, 47, 46, 43, 41, 40, 37, 35, 34, 31, 29, 29, 30, 30, 31, 31,
32, 32, 33, 33, 33, 34, 35, 35, 35, 36, 36, 37, 37, 37, 38, 38, 38, 39, 40, 40,
40, 41, 41, 42, 42, 43, 43, 43, 44, 44, 45, 45, 45, 46, 47, 47, 48, 48, 48, 49,
49, 50, 48, 47, 46, 45, 44, 42, 41, 40, 39, 37, 36, 36, 34, 32, 32, 30, 28, 27,
26, 24, 24, 22, 21, 20, 18, 18, 16, 15, 14, 13, 11, 10, 8, 8, 6, 5, 4, 3, 2, 0,
-1, -3, -3, -5, -7, -7, -9, -10, -12, -13, -15, -16, -18, -20, -21, -22, -24,
-25, -26, -29, -30, -31, -33, -34, -36, -37, -39, -40, -41, -44, -45, -46, -48,
-48, -51, -51, -54, -55, -57, -58, -60, -61, -63, -65, -66, -68, -69, -70, -72,
-73, -74, -76, -78, -77, -74, -72, -70, -67, -66, -64, -63, -60, -59, -56, -54,
-52, -50, -48, -47, -45, -43, -41, -39, -37, -35, -32, -31, -28, -27, -25, -23,
-21, -19, -17, -16, -14, -11, -10, -6, -6, -3, -2, 1, 2, 5, 8, 8, 10, 13, 14,
16, 16, 17, 18, 19, 21, 21, 23, 24, 25, 26, 28, 28, 30, 30, 32, 33, 33, 34, 35,
36, 38, 39, 40, 41, 42, 44, 44, 45, 46, 47, 49, 51, 52, 51, 53, 54, 56, 57, 57,
58, 60, 61, 61, 63, 64, 62, 59, 55, 54, 51, 49, 46, 44, 41, 38, 36, 33, 31, 29,
26, 23, 20, 18, 15, 12, 9, 8, 4, 2, -1, -3, -6, -9, -11, -14, -17, -18, -21,
-25, -27, -29, -31, -34, -38, -39, -42, -45, -48, -50, -52, -55, -56, -55, -55,
-54, -53, -52, -51, -50, -50, -49, -48, -47, -46, -45, -44, -43, -42, -41, -41,
-40, -39, -38, -37, -36, -35, -35, -34, -32, -31, -30, -30, -29, -29, -28, -27,
-25, -25, -24, -23, -23, -21, -21, -20, -19, -18, -17, -16, -17, -19, -22, -23,
-25, -27, -28, -30, -32, -33, -35, -37, -38, -40, -42, -44, -46, -48, -50, -52,
-54, -55, -56, -58, -61, -62, -65, -66, -68, -69, -71, -73, -75, -77, -79, -79,
-82, -84, -86, -87, -89, -91, -93, -95, -96, -97, -99, -97, -96, -96, -94, -93,
-92, -91, -89, -88, -87, -86, -85, -83, -82, -81, -80, -78, -77, -76, -75, -73,
-72, -71, -70, -68, -68, -67, -65, -63, -63, -62, -61, -59, -58, -57, -56, -54,
-53, -52, -50, -50, -49, -47, -46, -45, -43, -40, -37, -33, -30, -26, -23, -20,
-16, -12, -9, -5, -2, };