#define DATA_LENGTH 512
#define DATA AKWF_1965

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 11, 18, 25, 32, 39, 47, 54, 61, 68,
75, 79, 78, 77, 75, 74, 73, 71, 71, 68, 68, 67, 64, 63, 62, 60, 60, 58, 57, 56,
56, 57, 57, 58, 60, 61, 62, 63, 64, 66, 66, 68, 70, 71, 72, 74, 73, 75, 77, 74,
67, 61, 54, 48, 41, 34, 27, 21, 14, 8, 1, -5, -12, -19, -25, -33, -39, -45, -48,
-46, -46, -44, -43, -41, -41, -39, -38, -37, -36, -35, -34, -33, -31, -30, -29,
-28, -26, -21, -14, -7, 2, 10, 16, 25, 33, 41, 48, 56, 63, 71, 79, 86, 95, 102,
110, 117, 116, 109, 102, 94, 87, 81, 73, 66, 60, 52, 46, 38, 32, 25, 18, 10, 3,
-4, -12, -15, -17, -19, -21, -22, -25, -27, -28, -31, -33, -35, -37, -38, -41,
-43, -45, -47, -49, -51, -46, -38, -31, -23, -16, -7, 0, 9, 16, 23, 32, 39, 47,
54, 63, 70, 78, 85, 93, 93, 88, 84, 80, 77, 73, 68, 65, 60, 57, 53, 49, 46, 42,
38, 34, 30, 26, 22, 16, 11, 5, -3, -8, -14, -20, -27, -33, -40, -45, -50, -57,
-63, -69, -76, -82, -88, -93, -89, -82, -74, -65, -59, -50, -43, -36, -28, -21,
-12, -5, 2, 10, 18, 25, 32, 40, 48, 49, 48, 49, 49, 49, 49, 49, 49, 48, 49, 48,
48, 49, 48, 48, 47, 48, 48, 48, 40, 30, 21, 13, 5, -5, -14, -23, -31, -41, -50,
-58, -68, -77, -85, -95, -104, -113, -119, -116, -108, -101, -95, -88, -81, -75,
-68, -61, -54, -48, -41, -34, -27, -21, -14, -7, 0, 6, 11, 16, 20, 24, 28, 33,
38, 42, 47, 52, 55, 60, 64, 69, 74, 78, 82, 87, 89, 81, 71, 62, 52, 43, 33, 24,
14, 5, -5, -14, -24, -33, -42, -52, -62, -71, -81, -89, -82, -76, -69, -62, -55,
-49, -42, -35, -28, -22, -15, -8, -1, 5, 12, 18, 24, 32, 38, 42, 45, 50, 53, 57,
59, 63, 67, 71, 75, 78, 82, 86, 89, 93, 97, 101, 105, 105, 97, 88, 79, 71, 62,
54, 45, 35, 27, 19, 9, 1, -8, -17, -26, -35, -43, -52, -59, -58, -56, -56, -55,
-54, -53, -52, -51, -50, -49, -48, -48, -46, -46, -45, -44, -43, -42, -40, -31,
-25, -18, -11, -3, 4, 11, 19, 26, 33, 41, 48, 55, 63, 69, 77, 84, 92, 94, 86,
81, 73, 67, 60, 53, 46, 39, 33, 25, 18, 11, 4, -2, -10, -16, -24, -31, -35, -36,
-37, -39, -40, -40, -42, -43, -44, -46, -46, -48, -48, -50, -51, -53, -53, -55,
-55, -53, -47, -40, -32, -26, -19, -12, -5, 2, 9, 16, 23, 30, 37, 44, 50, 57,
64, 72, 73, 66, 60, 54, 48, 41, 34, 28, 22, 16, 10, 3, -2, -9, -15, -21, -28,
-33, -40, -44, -45, -46, -46, -47, -47, -48, -48, -50, -50, -52, -52, -53, -53,
-54, -54, -55, -56, -58, -53, -46, -39, -32, -25, -18, -11, -3, };