#define DATA_LENGTH 512
#define DATA AKWF_1940

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 8, 11, 14, 18, 22, 24, 27, 31,
34, 37, 40, 43, 46, 49, 52, 55, 59, 62, 64, 66, 69, 72, 74, 77, 79, 82, 83, 86,
88, 90, 92, 94, 95, 97, 99, 100, 101, 102, 103, 105, 106, 106, 107, 108, 108,
108, 108, 109, 109, 108, 108, 107, 107, 107, 105, 105, 104, 102, 101, 99, 97,
94, 93, 91, 89, 87, 83, 81, 79, 76, 74, 70, 68, 65, 63, 60, 58, 54, 52, 49, 46,
43, 41, 39, 36, 34, 32, 30, 28, 26, 24, 23, 21, 19, 18, 17, 16, 16, 15, 15, 15,
15, 14, 15, 16, 16, 16, 17, 19, 20, 22, 22, 24, 25, 27, 29, 30, 32, 34, 36, 37,
38, 41, 42, 44, 45, 47, 49, 50, 52, 53, 54, 56, 56, 57, 58, 59, 59, 60, 59, 60,
59, 59, 59, 58, 57, 56, 55, 54, 53, 51, 49, 47, 46, 43, 40, 38, 36, 33, 31, 28,
25, 22, 19, 16, 14, 10, 7, 4, 1, -2, -5, -8, -11, -14, -17, -20, -23, -26, -28,
-31, -33, -36, -38, -40, -42, -45, -46, -49, -50, -52, -53, -55, -56, -57, -58,
-59, -59, -61, -61, -62, -62, -63, -63, -63, -64, -64, -64, -64, -64, -63, -63,
-63, -62, -62, -62, -61, -60, -59, -58, -58, -57, -55, -54, -53, -52, -50, -48,
-47, -46, -44, -42, -40, -39, -37, -34, -33, -30, -28, -25, -23, -20, -18, -16,
-12, -9, -6, -3, 0, 3, 6, 10, 13, 17, 20, 23, 27, 30, 33, 36, 40, 43, 46, 50,
52, 55, 58, 60, 62, 66, 67, 70, 73, 74, 76, 77, 79, 80, 81, 82, 82, 83, 83, 82,
83, 82, 82, 81, 79, 78, 77, 76, 73, 73, 70, 67, 65, 62, 60, 57, 54, 50, 48, 44,
40, 37, 34, 31, 26, 23, 20, 17, 12, 8, 5, 1, -2, -5, -9, -13, -16, -18, -22,
-24, -28, -30, -34, -35, -37, -39, -42, -43, -46, -47, -49, -50, -52, -53, -55,
-56, -56, -58, -59, -60, -60, -61, -61, -62, -62, -63, -63, -63, -64, -64, -64,
-64, -63, -63, -64, -62, -63, -63, -62, -62, -61, -61, -60, -60, -60, -58, -58,
-57, -57, -57, -56, -56, -55, -54, -52, -52, -52, -50, -49, -49, -46, -46, -45,
-44, -43, -41, -40, -39, -37, -37, -34, -33, -32, -31, -30, -28, -28, -26, -25,
-23, -23, -23, -22, -21, -21, -20, -19, -19, -17, -18, -18, -17, -18, -18, -19,
-19, -20, -20, -21, -23, -24, -25, -27, -28, -29, -32, -34, -36, -38, -41, -43,
-46, -49, -52, -55, -56, -61, -64, -66, -69, -73, -75, -78, -82, -85, -87, -90,
-93, -95, -98, -101, -103, -105, -108, -109, -111, -112, -114, -116, -117, -118,
-118, -119, -119, -120, -118, -119, -118, -118, -116, -115, -114, -112, -110,
-109, -106, -104, -102, -99, -96, -94, -91, -88, -85, -82, -79, -74, -71, -67,
-64, -60, -56, -52, -48, -44, -40, -36, -33, -29, -25, -21, -18, -14, -9, -5,
-2, };