#define DATA_LENGTH 512
#define DATA AKWF_2005

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 10, 13, 17, 21, 24, 28, 31, 34,
38, 41, 44, 46, 49, 52, 55, 58, 59, 62, 64, 67, 69, 71, 74, 75, 78, 81, 82, 83,
85, 87, 89, 91, 92, 94, 95, 97, 98, 99, 101, 101, 103, 103, 104, 105, 107, 107,
107, 108, 109, 108, 109, 110, 109, 111, 110, 110, 110, 110, 111, 110, 111, 110,
110, 108, 108, 109, 108, 107, 106, 106, 104, 103, 103, 101, 100, 99, 97, 96, 95,
93, 92, 90, 88, 87, 85, 83, 82, 80, 78, 77, 76, 74, 72, 71, 68, 67, 65, 64, 62,
61, 60, 59, 58, 55, 55, 55, 53, 53, 52, 52, 50, 51, 50, 49, 48, 50, 49, 49, 50,
50, 50, 51, 51, 52, 52, 53, 55, 55, 56, 58, 59, 60, 61, 62, 63, 64, 66, 67, 69,
71, 72, 74, 74, 76, 77, 79, 80, 81, 83, 84, 85, 86, 87, 88, 90, 89, 91, 91, 91,
92, 91, 92, 93, 92, 92, 92, 92, 91, 92, 90, 90, 89, 88, 88, 86, 85, 83, 82, 81,
80, 79, 77, 75, 73, 72, 70, 68, 67, 64, 63, 61, 59, 58, 56, 54, 52, 49, 47, 46,
44, 42, 39, 38, 36, 34, 33, 32, 30, 27, 26, 25, 24, 22, 21, 20, 18, 18, 16, 15,
14, 13, 12, 12, 10, 10, 9, 9, 8, 8, 7, 7, 6, 5, 5, 4, 4, 4, 3, 4, 3, 3, 3, 2, 2,
2, 2, 2, 2, 3, 3, 2, 2, 2, 0, 1, 1, 1, 0, 1, 0, 0, -1, -1, 0, -2, -1, -2, -3,
-3, -3, -4, -5, -5, -5, -6, -7, -8, -8, -9, -8, -9, -10, -11, -11, -12, -12,
-14, -14, -15, -15, -16, -17, -17, -17, -18, -19, -20, -21, -22, -22, -24, -24,
-25, -26, -27, -28, -29, -30, -30, -32, -33, -34, -35, -36, -37, -38, -39, -40,
-40, -42, -43, -44, -45, -47, -48, -49, -51, -52, -53, -54, -56, -57, -60, -60,
-62, -64, -65, -66, -68, -70, -70, -72, -74, -74, -77, -77, -78, -80, -81, -83,
-84, -85, -87, -87, -88, -90, -90, -91, -91, -92, -93, -94, -94, -95, -95, -95,
-96, -96, -96, -96, -97, -97, -96, -97, -96, -96, -95, -95, -94, -93, -92, -91,
-90, -90, -88, -88, -87, -86, -84, -83, -82, -80, -79, -78, -77, -75, -74, -73,
-72, -70, -69, -67, -67, -65, -66, -64, -62, -61, -61, -60, -61, -59, -58, -58,
-58, -57, -58, -58, -58, -58, -58, -58, -59, -60, -60, -61, -62, -63, -65, -65,
-67, -68, -71, -71, -74, -75, -76, -79, -81, -82, -84, -86, -88, -90, -92, -94,
-96, -97, -99, -102, -103, -105, -106, -108, -110, -111, -112, -114, -114, -116,
-117, -117, -118, -119, -118, -119, -119, -119, -119, -118, -118, -116, -116,
-115, -114, -112, -111, -109, -107, -105, -103, -100, -98, -95, -92, -89, -86,
-83, -80, -77, -74, -70, -66, -63, -58, -55, -52, -48, -44, -39, -36, -32, -28,
-23, -20, -15, -12, -8, -4, 0, };