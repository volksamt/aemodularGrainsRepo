#define DATA_LENGTH 512
#define DATA AKWF_1963

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 15, 20, 26, 31, 36, 41, 43, 47,
49, 53, 56, 59, 62, 66, 68, 71, 74, 77, 80, 83, 86, 89, 92, 95, 93, 81, 72, 62,
51, 41, 31, 20, 11, 1, -10, -20, -30, -40, -50, -60, -70, -79, -91, -91, -85,
-82, -76, -71, -67, -62, -57, -52, -47, -42, -37, -32, -28, -24, -18, -13, -8,
-4, 1, 7, 14, 20, 26, 31, 38, 43, 50, 55, 61, 67, 73, 79, 86, 91, 97, 103, 109,
104, 92, 81, 70, 59, 48, 37, 25, 15, 4, -8, -18, -31, -41, -52, -63, -74, -86,
-96, -96, -91, -86, -81, -76, -70, -66, -61, -55, -51, -46, -40, -35, -30, -24,
-20, -15, -9, -5, 1, 7, 13, 20, 26, 32, 38, 45, 52, 58, 65, 70, 76, 83, 89, 96,
102, 108, 113, 107, 95, 84, 73, 62, 50, 40, 29, 19, 7, -4, -15, -26, -36, -47,
-59, -69, -81, -92, -92, -87, -84, -80, -77, -73, -69, -66, -63, -59, -55, -51,
-47, -45, -41, -38, -34, -30, -26, -19, -13, -5, 3, 10, 18, 26, 33, 40, 48, 56,
63, 71, 78, 86, 93, 101, 108, 115, 107, 95, 85, 74, 63, 52, 43, 32, 22, 10, 0,
-11, -22, -33, -43, -53, -64, -76, -85, -83, -80, -76, -73, -71, -68, -65, -60,
-57, -54, -52, -48, -45, -42, -39, -36, -33, -29, -25, -19, -11, -4, 6, 13, 20,
28, 35, 43, 51, 58, 67, 74, 81, 89, 97, 105, 113, 117, 108, 97, 87, 76, 65, 54,
43, 32, 22, 11, 0, -11, -21, -32, -42, -53, -64, -75, -83, -81, -77, -74, -72,
-69, -65, -63, -60, -56, -53, -50, -48, -45, -42, -38, -36, -33, -30, -26, -19,
-11, -3, 5, 13, 21, 28, 36, 45, 52, 60, 67, 75, 83, 91, 99, 106, 115, 117, 108,
99, 87, 78, 67, 56, 47, 37, 25, 16, 6, -4, -15, -26, -36, -46, -56, -67, -74,
-73, -72, -71, -70, -70, -68, -68, -66, -66, -65, -64, -63, -62, -62, -60, -60,
-59, -58, -55, -47, -38, -30, -22, -14, -5, 3, 12, 19, 28, 36, 44, 52, 61, 69,
77, 85, 93, 97, 88, 79, 71, 62, 53, 45, 36, 28, 19, 11, 2, -7, -16, -24, -33,
-41, -49, -59, -64, -62, -60, -59, -59, -56, -55, -54, -52, -52, -50, -49, -48,
-46, -45, -43, -42, -40, -40, -35, -27, -19, -10, -2, 7, 15, 23, 32, 40, 49, 57,
66, 73, 82, 90, 99, 107, 116, 116, 106, 96, 85, 76, 66, 55, 45, 35, 25, 15, 4,
-5, -15, -27, -36, -45, -56, -66, -70, -68, -66, -64, -63, -60, -59, -56, -54,
-53, -51, -48, -48, -45, -44, -42, -39, -38, -36, -30, -23, -15, -7, 1, 10, 17,
25, 32, 40, 49, 56, 65, 73, 80, 88, 97, 103, 113, 109, 100, 91, 82, 72, 63, 53,
43, 35, 25, 15, 6, -3, -13, -22, -32, -41, -50, -60, -60, -55, -50, -44, -38,
-33, -27, -22, -17, -12, -5, -1, };