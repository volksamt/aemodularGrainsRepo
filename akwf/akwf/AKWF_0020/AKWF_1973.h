#define DATA_LENGTH 512
#define DATA AKWF_1973

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 10, 20, 30, 38, 48, 58, 64, 67, 70,
73, 75, 78, 81, 85, 87, 91, 93, 97, 100, 104, 106, 109, 112, 115, 118, 119, 117,
115, 115, 114, 112, 110, 109, 107, 106, 105, 104, 102, 101, 100, 97, 97, 96, 93,
93, 93, 92, 93, 92, 92, 92, 92, 91, 91, 91, 92, 91, 90, 90, 90, 90, 90, 89, 88,
88, 88, 86, 85, 85, 84, 83, 82, 82, 81, 80, 79, 79, 78, 77, 76, 75, 75, 74, 74,
74, 73, 71, 72, 71, 71, 71, 69, 70, 69, 68, 67, 68, 66, 66, 66, 65, 64, 63, 64,
62, 62, 61, 61, 60, 60, 59, 59, 58, 58, 56, 56, 55, 55, 55, 53, 53, 53, 52, 52,
51, 50, 50, 48, 48, 48, 47, 47, 45, 46, 44, 45, 44, 42, 42, 42, 42, 40, 40, 39,
38, 39, 37, 37, 37, 36, 36, 35, 34, 34, 33, 33, 33, 31, 31, 31, 30, 29, 29, 28,
27, 27, 27, 25, 25, 25, 23, 23, 22, 21, 22, 21, 20, 20, 19, 19, 18, 17, 17, 16,
15, 15, 14, 14, 13, 12, 12, 11, 11, 10, 9, 8, 8, 9, 8, 7, 7, 6, 6, 6, 4, 5, 4,
3, 3, 3, 2, 2, 1, 1, 1, 0, 1, 1, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1,
0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0,
-1, 0, -1, 0, 0, -1, 1, -1, 0, 0, 0, 0, -1, -1, 1, -1, -1, 0, -1, 0, 0, 1, 1, 0,
1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, -1, -1, 0, 0, 0, 0, 0, -1, -1, -1, 0, 1,
0, 0, 0, 0, -1, -2, -2, -2, -3, -3, -4, -4, -5, -6, -5, -6, -6, -7, -7, -7, -7,
-8, -9, -9, -10, -10, -11, -11, -13, -13, -14, -14, -15, -15, -16, -18, -17,
-18, -19, -19, -20, -20, -21, -22, -21, -23, -24, -24, -24, -25, -25, -27, -27,
-27, -27, -29, -29, -30, -30, -31, -31, -32, -33, -32, -34, -34, -35, -35, -36,
-36, -37, -38, -39, -39, -40, -40, -41, -41, -42, -43, -43, -44, -44, -44, -46,
-46, -46, -47, -48, -48, -49, -50, -50, -50, -52, -52, -53, -53, -54, -54, -55,
-55, -56, -56, -58, -58, -59, -59, -60, -60, -61, -62, -62, -63, -64, -64, -65,
-66, -66, -66, -67, -68, -67, -68, -68, -68, -70, -70, -71, -71, -71, -72, -72,
-72, -74, -73, -74, -76, -77, -78, -77, -79, -79, -80, -81, -82, -83, -84, -85,
-85, -86, -86, -88, -88, -89, -89, -89, -90, -90, -89, -91, -90, -90, -91, -90,
-91, -91, -91, -91, -91, -91, -92, -92, -93, -94, -96, -97, -98, -99, -102,
-103, -104, -105, -107, -109, -110, -112, -113, -114, -115, -118, -118, -112,
-102, -94, -83, -74, -64, -54, -45, -37, -26, -16, -6, };