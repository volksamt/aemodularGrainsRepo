#define DATA_LENGTH 512
#define DATA AKWF_1969

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 12, 18, 26, 33, 36, 40, 44, 47, 51,
55, 58, 62, 66, 69, 72, 76, 79, 84, 87, 91, 94, 98, 101, 102, 102, 103, 103,
104, 104, 105, 105, 105, 107, 107, 108, 109, 108, 109, 110, 110, 110, 111, 112,
112, 113, 113, 114, 113, 115, 114, 115, 115, 116, 116, 116, 117, 118, 119, 118,
120, 119, 118, 118, 117, 117, 117, 116, 116, 114, 113, 113, 112, 112, 111, 110,
109, 109, 108, 108, 107, 106, 105, 104, 102, 101, 99, 98, 97, 96, 95, 94, 92,
91, 90, 89, 87, 86, 85, 84, 81, 80, 79, 78, 76, 74, 74, 72, 70, 69, 68, 66, 64,
63, 62, 60, 59, 57, 57, 58, 58, 60, 61, 61, 62, 63, 64, 65, 66, 68, 69, 69, 71,
73, 73, 74, 76, 76, 75, 75, 74, 74, 75, 75, 74, 74, 74, 74, 74, 74, 73, 73, 73,
73, 72, 73, 72, 70, 68, 67, 64, 63, 61, 60, 57, 56, 54, 52, 50, 49, 48, 45, 44,
41, 40, 39, 37, 35, 33, 32, 30, 30, 28, 26, 25, 24, 22, 20, 19, 17, 16, 15, 13,
11, 10, 9, 8, 6, 5, 3, 2, 1, -2, -3, -4, -5, -7, -8, -9, -11, -12, -13, -16,
-16, -19, -20, -21, -23, -25, -27, -28, -30, -32, -33, -36, -38, -39, -40, -42,
-44, -45, -48, -48, -49, -49, -50, -51, -51, -52, -52, -53, -53, -54, -55, -55,
-55, -56, -56, -57, -58, -57, -55, -50, -44, -39, -34, -29, -23, -18, -12, -7,
-1, 4, 9, 14, 20, 25, 32, 36, 42, 44, 44, 46, 46, 46, 48, 48, 49, 50, 50, 52,
53, 53, 53, 53, 54, 56, 56, 57, 56, 54, 52, 50, 47, 45, 44, 41, 40, 37, 36, 33,
32, 29, 28, 26, 24, 22, 19, 19, 17, 16, 14, 13, 12, 11, 9, 7, 6, 6, 4, 3, 2, 1,
0, -2, -3, -4, -6, -7, -9, -11, -13, -13, -15, -17, -18, -20, -21, -23, -26,
-27, -28, -30, -31, -33, -34, -35, -38, -39, -41, -43, -44, -46, -48, -49, -50,
-52, -54, -56, -56, -59, -60, -61, -63, -65, -65, -67, -68, -69, -70, -70, -71,
-71, -73, -73, -74, -75, -76, -77, -77, -78, -79, -79, -80, -79, -78, -77, -75,
-75, -73, -71, -70, -69, -69, -67, -66, -64, -63, -62, -61, -59, -58, -57, -57,
-58, -59, -60, -62, -64, -64, -66, -66, -67, -69, -71, -70, -72, -72, -73, -75,
-77, -77, -78, -80, -82, -83, -84, -86, -87, -89, -91, -91, -93, -94, -95, -97,
-98, -100, -101, -102, -104, -105, -106, -107, -107, -108, -108, -110, -109,
-111, -112, -112, -113, -113, -114, -116, -116, -117, -118, -119, -118, -118,
-118, -117, -117, -116, -116, -115, -116, -115, -115, -114, -113, -114, -113,
-113, -113, -112, -112, -111, -111, -111, -110, -109, -110, -109, -109, -108,
-108, -108, -107, -108, -107, -107, -107, -107, -106, -104, -98, -90, -83, -76,
-68, -61, -54, -46, -39, -32, -25, -17, -10, -3, };