#define DATA_LENGTH 512
#define DATA AKWF_1999

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 1, 1, 1, 2, 2, 3, 4, 3, 4, 5, 5,
6, 6, 7, 7, 8, 8, 9, 9, 10, 11, 11, 11, 12, 12, 13, 14, 15, 15, 15, 16, 16, 17,
18, 18, 18, 19, 19, 21, 20, 21, 21, 21, 22, 23, 22, 22, 24, 24, 24, 25, 25, 25,
25, 26, 27, 27, 27, 28, 28, 28, 29, 29, 29, 30, 31, 31, 31, 32, 33, 33, 34, 33,
33, 34, 34, 35, 35, 36, 37, 38, 38, 38, 39, 39, 40, 40, 41, 42, 42, 43, 44, 45,
45, 45, 46, 46, 46, 47, 48, 48, 49, 49, 50, 51, 51, 51, 52, 53, 53, 53, 55, 55,
56, 56, 56, 56, 57, 58, 59, 59, 59, 59, 61, 61, 62, 61, 62, 62, 62, 63, 63, 64,
64, 65, 65, 66, 67, 66, 67, 68, 68, 68, 68, 69, 70, 71, 70, 71, 72, 72, 72, 73,
73, 73, 73, 74, 74, 75, 75, 75, 76, 76, 77, 77, 78, 78, 78, 79, 80, 80, 80, 80,
81, 81, 81, 82, 82, 82, 84, 83, 83, 83, 85, 85, 86, 86, 86, 88, 89, 89, 91, 91,
92, 93, 94, 94, 96, 97, 97, 97, 99, 100, 100, 102, 103, 104, 104, 104, 106, 107,
108, 108, 109, 110, 111, 112, 113, 114, 114, 116, 116, 113, 107, 103, 99, 95,
90, 86, 82, 77, 73, 69, 65, 60, 55, 51, 46, 43, 39, 34, 30, 26, 21, 17, 12, 8,
5, 0, -5, -10, -13, -18, -21, -26, -30, -35, -39, -43, -45, -48, -49, -51, -53,
-55, -59, -61, -62, -65, -66, -68, -71, -72, -75, -77, -79, -81, -84, -86, -88,
-90, -91, -94, -96, -98, -100, -102, -104, -106, -109, -111, -113, -115, -117,
-119, -118, -117, -116, -115, -113, -111, -110, -109, -108, -106, -105, -105,
-102, -101, -100, -98, -98, -96, -94, -93, -92, -90, -90, -88, -87, -84, -84,
-82, -80, -80, -78, -77, -76, -74, -73, -71, -70, -70, -70, -71, -70, -70, -70,
-71, -71, -71, -71, -71, -71, -70, -71, -71, -70, -70, -71, -70, -71, -71, -71,
-71, -70, -70, -70, -71, -71, -71, -70, -71, -70, -71, -71, -70, -71, -70, -70,
-69, -69, -66, -66, -66, -64, -64, -63, -62, -62, -60, -60, -59, -58, -57, -56,
-55, -56, -54, -53, -52, -51, -50, -49, -49, -49, -48, -47, -46, -44, -44, -43,
-42, -42, -41, -41, -41, -40, -40, -40, -40, -39, -39, -39, -39, -38, -38, -38,
-37, -37, -37, -37, -36, -35, -35, -35, -35, -35, -35, -35, -34, -33, -33, -32,
-32, -33, -31, -31, -31, -31, -30, -30, -29, -29, -28, -28, -27, -26, -26, -26,
-24, -24, -24, -23, -21, -22, -21, -20, -20, -20, -19, -18, -17, -16, -16, -15,
-14, -15, -13, -12, -12, -11, -10, -10, -10, -9, -9, -8, -7, -7, -7, -7, -6, -6,
-6, -6, -6, -6, -5, -5, -5, -4, -4, -5, -3, -4, -2, -3, -3, -2, -2, -1, -2, -1,
-2, 0, -1, 0, -1, -1, };