#define DATA_LENGTH 512
#define DATA AKWF_1967

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 4, 5, 6, 7, 9, 10, 11, 13,
15, 17, 19, 20, 23, 25, 27, 29, 29, 32, 33, 36, 37, 39, 40, 42, 44, 45, 47, 49,
51, 52, 53, 55, 57, 57, 60, 61, 63, 64, 66, 67, 68, 70, 72, 73, 75, 76, 77, 78,
80, 82, 83, 84, 84, 85, 87, 89, 91, 92, 93, 94, 95, 97, 97, 98, 99, 100, 101,
102, 103, 103, 103, 105, 106, 106, 108, 108, 109, 110, 111, 111, 113, 113, 113,
113, 114, 114, 115, 115, 115, 116, 116, 116, 117, 117, 117, 118, 118, 118, 119,
120, 119, 119, 119, 119, 119, 118, 119, 118, 119, 118, 119, 119, 119, 118, 118,
118, 118, 119, 118, 118, 118, 117, 117, 117, 116, 117, 116, 116, 115, 114, 114,
114, 113, 113, 113, 113, 112, 112, 110, 110, 110, 110, 109, 108, 107, 107, 107,
106, 105, 104, 104, 104, 102, 102, 101, 101, 100, 99, 99, 98, 97, 96, 95, 95,
94, 94, 93, 92, 91, 90, 89, 88, 88, 87, 86, 86, 85, 83, 82, 82, 81, 80, 79, 78,
77, 76, 75, 74, 73, 72, 72, 70, 69, 68, 67, 66, 65, 64, 62, 62, 61, 59, 59, 57,
56, 55, 54, 53, 52, 51, 50, 48, 47, 46, 45, 44, 42, 41, 40, 39, 38, 36, 35, 33,
33, 30, 30, 29, 27, 27, 24, 23, 22, 21, 19, 19, 17, 16, 15, 13, 12, 11, 9, 9, 6,
6, 4, 3, 1, 1, -2, -2, -4, -5, -5, -8, -8, -10, -11, -12, -12, -14, -15, -18,
-18, -19, -20, -21, -23, -24, -26, -26, -27, -28, -29, -30, -30, -32, -33, -34,
-35, -36, -37, -37, -38, -39, -40, -41, -43, -43, -43, -44, -45, -45, -46, -45,
-46, -47, -48, -48, -49, -49, -49, -49, -51, -51, -53, -53, -53, -53, -53, -54,
-53, -54, -54, -54, -54, -55, -55, -55, -56, -56, -56, -57, -57, -58, -57, -58,
-58, -57, -58, -57, -58, -57, -58, -58, -58, -58, -59, -58, -59, -58, -59, -59,
-60, -59, -59, -60, -60, -60, -61, -60, -60, -61, -62, -61, -61, -62, -62, -63,
-63, -63, -63, -64, -63, -64, -64, -65, -65, -65, -66, -66, -66, -66, -67, -68,
-69, -69, -68, -70, -70, -70, -71, -70, -70, -72, -72, -72, -72, -72, -72, -73,
-74, -74, -75, -74, -75, -76, -76, -76, -76, -77, -77, -77, -78, -77, -77, -77,
-78, -78, -78, -79, -77, -78, -77, -78, -78, -79, -78, -78, -79, -79, -79, -79,
-79, -78, -78, -77, -78, -76, -76, -77, -76, -75, -75, -75, -76, -74, -74, -74,
-74, -73, -71, -71, -70, -69, -69, -68, -68, -66, -66, -65, -64, -63, -62, -61,
-61, -60, -59, -58, -57, -56, -54, -53, -51, -50, -49, -49, -46, -45, -44, -43,
-41, -40, -38, -37, -37, -34, -34, -32, -31, -29, -28, -28, -26, -25, -23, -22,
-21, -21, -19, -18, -17, -16, -15, -14, -12, -12, -10, -10, -8, -7, -6, -5, -4,
-4, -2, -1, -1, };