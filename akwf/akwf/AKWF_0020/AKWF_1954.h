#define DATA_LENGTH 512
#define DATA AKWF_1954

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 2, 3, 4, 5, 6, 7, 7, 7, 8, 9,
10, 10, 11, 11, 12, 12, 13, 13, 15, 15, 15, 16, 16, 18, 18, 19, 20, 20, 21, 22,
23, 24, 24, 25, 26, 27, 28, 29, 29, 30, 31, 31, 32, 33, 34, 34, 36, 35, 37, 36,
37, 38, 39, 40, 40, 41, 42, 42, 44, 43, 44, 45, 46, 47, 47, 47, 48, 49, 50, 50,
52, 52, 53, 54, 54, 55, 55, 56, 57, 57, 58, 59, 59, 60, 61, 61, 63, 63, 63, 64,
65, 66, 66, 66, 67, 67, 69, 69, 69, 71, 71, 72, 72, 72, 74, 74, 74, 76, 76, 76,
77, 78, 79, 80, 80, 81, 82, 81, 83, 83, 84, 85, 85, 85, 86, 86, 87, 87, 89, 89,
89, 90, 90, 90, 92, 91, 92, 93, 93, 94, 94, 94, 95, 96, 96, 97, 97, 98, 98, 99,
100, 99, 101, 101, 102, 102, 103, 103, 104, 105, 105, 105, 105, 106, 107, 107,
108, 108, 107, 108, 108, 109, 109, 110, 109, 110, 110, 110, 110, 111, 110, 111,
111, 112, 112, 112, 112, 113, 112, 113, 114, 114, 114, 115, 114, 115, 116, 116,
116, 116, 116, 116, 116, 115, 116, 115, 116, 115, 116, 115, 114, 114, 113, 114,
113, 112, 112, 110, 111, 110, 109, 109, 108, 108, 108, 107, 107, 107, 106, 107,
106, 106, 106, 106, 106, 105, 105, 105, 105, 104, 102, 102, 100, 99, 97, 95, 93,
90, 87, 84, 80, 76, 72, 67, 62, 57, 52, 46, 39, 33, 27, 20, 13, 6, -1, -8, -15,
-23, -30, -37, -44, -51, -57, -64, -70, -76, -81, -85, -91, -95, -99, -103,
-105, -109, -111, -112, -115, -117, -117, -119, -118, -119, -119, -119, -118,
-118, -118, -117, -116, -116, -115, -114, -114, -114, -114, -112, -112, -112,
-112, -112, -111, -111, -112, -112, -113, -113, -113, -112, -113, -114, -114,
-114, -114, -114, -115, -116, -115, -115, -115, -115, -114, -114, -114, -113,
-112, -112, -111, -111, -111, -109, -109, -108, -107, -108, -106, -105, -105,
-105, -104, -104, -103, -103, -102, -103, -101, -101, -101, -101, -100, -101,
-100, -100, -100, -100, -99, -99, -97, -98, -98, -97, -96, -96, -95, -94, -94,
-94, -93, -92, -92, -91, -90, -89, -89, -88, -87, -87, -86, -86, -85, -84, -84,
-83, -81, -82, -81, -81, -80, -80, -79, -79, -78, -77, -76, -76, -76, -75, -75,
-74, -74, -73, -73, -72, -71, -71, -70, -69, -68, -68, -67, -66, -66, -65, -64,
-64, -62, -63, -61, -60, -60, -59, -58, -58, -57, -56, -56, -56, -55, -54, -53,
-53, -52, -52, -51, -51, -49, -49, -49, -47, -46, -47, -45, -45, -44, -43, -42,
-42, -41, -40, -39, -38, -38, -37, -36, -35, -35, -34, -34, -33, -33, -32, -31,
-30, -30, -28, -28, -28, -27, -26, -26, -25, -25, -25, -23, -23, -22, -21, -21,
-20, -18, -19, -17, -16, -15, -14, -13, -13, -11, -10, -9, -8, -7, -7, -6, -4,
-4, -2, -2, -1, 0, };