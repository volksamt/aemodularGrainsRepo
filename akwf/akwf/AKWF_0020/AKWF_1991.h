#define DATA_LENGTH 512
#define DATA AKWF_1991

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 12, 15, 19, 22, 26, 28, 33,
36, 40, 43, 48, 51, 54, 56, 58, 59, 61, 62, 64, 65, 66, 69, 71, 72, 73, 75, 77,
77, 80, 81, 83, 84, 85, 87, 88, 90, 92, 93, 96, 97, 98, 100, 101, 103, 105, 106,
108, 108, 111, 112, 112, 111, 111, 110, 110, 110, 109, 109, 108, 107, 108, 106,
107, 107, 107, 105, 105, 105, 104, 103, 104, 104, 103, 103, 102, 103, 102, 101,
101, 101, 100, 100, 100, 99, 99, 97, 99, 98, 99, 99, 100, 100, 100, 101, 100,
100, 101, 101, 102, 102, 102, 102, 103, 103, 103, 103, 104, 103, 104, 105, 104,
104, 106, 105, 105, 106, 105, 107, 107, 107, 107, 107, 108, 107, 107, 107, 107,
106, 106, 105, 105, 104, 105, 105, 104, 105, 104, 103, 104, 103, 103, 103, 102,
102, 102, 101, 102, 101, 101, 101, 101, 100, 100, 100, 99, 100, 99, 98, 98, 99,
98, 98, 100, 100, 100, 100, 101, 100, 101, 101, 102, 102, 103, 103, 103, 103,
104, 104, 104, 104, 105, 106, 105, 106, 105, 106, 106, 107, 107, 108, 108, 108,
108, 109, 108, 109, 109, 108, 107, 107, 107, 107, 107, 107, 106, 105, 105, 104,
104, 104, 103, 103, 103, 102, 101, 101, 101, 100, 99, 98, 99, 98, 97, 97, 97,
96, 96, 96, 96, 95, 95, 94, 94, 94, 95, 96, 98, 97, 98, 100, 99, 101, 101, 102,
102, 104, 104, 104, 105, 106, 106, 107, 108, 108, 110, 110, 111, 111, 112, 113,
113, 114, 116, 115, 117, 117, 118, 118, 118, 117, 115, 113, 112, 110, 108, 105,
104, 103, 100, 98, 96, 94, 93, 91, 89, 87, 85, 83, 81, 80, 77, 74, 73, 71, 70,
67, 66, 64, 62, 60, 58, 57, 54, 52, 51, 47, 44, 39, 35, 30, 26, 22, 18, 14, 9,
5, 1, -3, -7, -12, -15, -21, -24, -29, -33, -37, -42, -45, -49, -55, -59, -62,
-66, -71, -75, -79, -83, -87, -92, -97, -100, -105, -106, -105, -106, -106,
-106, -105, -106, -105, -106, -106, -106, -106, -105, -106, -106, -105, -105,
-105, -106, -106, -106, -105, -106, -105, -105, -105, -106, -105, -105, -106,
-106, -106, -106, -106, -106, -105, -106, -106, -105, -105, -105, -104, -104,
-104, -104, -104, -102, -102, -103, -103, -103, -102, -101, -101, -101, -101,
-101, -101, -100, -101, -100, -100, -99, -100, -99, -98, -99, -98, -97, -97,
-97, -97, -97, -97, -98, -99, -98, -99, -99, -100, -100, -101, -101, -101, -103,
-103, -103, -104, -103, -105, -105, -106, -106, -107, -106, -107, -108, -108,
-109, -109, -109, -111, -110, -111, -112, -112, -111, -113, -113, -113, -112,
-112, -110, -110, -108, -108, -106, -106, -104, -103, -102, -101, -100, -98,
-98, -97, -96, -95, -94, -92, -91, -90, -89, -89, -87, -86, -85, -84, -83, -82,
-81, -80, -79, -77, -77, -77, -74, -70, -66, -63, -60, -56, -52, -49, -45, -42,
-38, -35, -31, -28, -24, -20, -17, -13, -9, -6, -2, };