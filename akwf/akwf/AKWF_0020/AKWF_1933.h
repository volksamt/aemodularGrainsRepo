#define DATA_LENGTH 512
#define DATA AKWF_1933

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 9, 11, 13, 16, 19, 20, 24,
26, 27, 30, 32, 35, 37, 40, 42, 44, 46, 48, 51, 53, 55, 57, 60, 63, 65, 67, 69,
72, 74, 77, 79, 81, 83, 86, 88, 89, 92, 95, 97, 100, 101, 105, 106, 108, 111,
114, 114, 113, 110, 109, 107, 105, 102, 100, 98, 96, 94, 91, 89, 88, 86, 84, 81,
79, 77, 75, 72, 71, 69, 67, 64, 63, 59, 57, 55, 54, 51, 50, 48, 45, 43, 42, 39,
37, 34, 33, 31, 28, 26, 25, 22, 20, 18, 18, 19, 19, 20, 21, 22, 23, 24, 25, 26,
27, 28, 29, 29, 30, 31, 32, 33, 34, 35, 36, 38, 38, 39, 39, 41, 42, 43, 43, 44,
46, 47, 47, 47, 49, 49, 50, 51, 52, 54, 55, 55, 56, 57, 57, 59, 59, 57, 55, 53,
51, 48, 46, 44, 41, 39, 38, 36, 32, 31, 28, 25, 23, 21, 19, 17, 15, 13, 9, 8, 5,
3, 1, -1, -3, -6, -8, -10, -12, -15, -16, -18, -21, -23, -25, -27, -29, -32,
-33, -36, -39, -41, -43, -45, -46, -46, -47, -48, -50, -50, -51, -52, -53, -54,
-55, -56, -56, -57, -58, -60, -60, -61, -62, -63, -65, -64, -65, -66, -67, -69,
-69, -71, -70, -72, -73, -74, -74, -76, -77, -77, -77, -79, -81, -81, -83, -83,
-84, -85, -85, -86, -83, -80, -77, -74, -71, -68, -65, -62, -59, -56, -54, -50,
-47, -45, -41, -38, -36, -32, -29, -27, -24, -20, -17, -15, -11, -8, -6, -2, 0,
4, 6, 9, 12, 15, 19, 22, 23, 28, 30, 33, 37, 39, 42, 45, 48, 51, 52, 52, 51, 51,
51, 50, 50, 50, 50, 49, 48, 48, 48, 47, 47, 46, 46, 46, 46, 44, 45, 44, 44, 43,
43, 42, 41, 41, 41, 41, 40, 40, 39, 39, 38, 38, 37, 38, 37, 37, 35, 36, 36, 35,
35, 34, 34, 32, 30, 27, 27, 24, 22, 20, 17, 16, 14, 12, 10, 9, 6, 4, 2, 0, -2,
-3, -6, -8, -10, -11, -13, -16, -17, -20, -21, -23, -25, -28, -29, -31, -33,
-35, -37, -40, -41, -42, -45, -47, -49, -50, -53, -55, -57, -57, -56, -56, -55,
-54, -54, -52, -52, -51, -50, -49, -49, -47, -46, -46, -45, -45, -43, -43, -42,
-40, -41, -40, -39, -37, -37, -36, -35, -34, -33, -33, -32, -31, -30, -29, -28,
-27, -27, -26, -25, -25, -24, -22, -22, -21, -20, -19, -22, -24, -26, -28, -31,
-32, -34, -37, -39, -40, -43, -45, -47, -49, -52, -53, -56, -58, -60, -62, -64,
-67, -68, -71, -72, -75, -77, -79, -82, -84, -86, -89, -90, -92, -95, -96, -99,
-100, -104, -106, -107, -110, -111, -114, -115, -119, -118, -115, -113, -110,
-107, -104, -101, -99, -96, -93, -91, -88, -85, -83, -79, -77, -75, -72, -68,
-66, -64, -61, -58, -55, -53, -49, -47, -44, -41, -39, -35, -34, -30, -27, -26,
-23, -20, -17, -15, -11, -9, -6, -3, 0, };