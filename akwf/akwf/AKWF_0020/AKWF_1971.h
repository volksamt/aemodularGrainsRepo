#define DATA_LENGTH 512
#define DATA AKWF_1971

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 9, 13, 15, 20, 24, 27, 31, 34, 38,
41, 44, 48, 52, 55, 58, 62, 66, 69, 73, 77, 78, 81, 83, 85, 89, 90, 92, 94, 97,
99, 100, 103, 105, 108, 110, 111, 114, 117, 119, 119, 118, 116, 116, 115, 115,
114, 114, 113, 112, 111, 111, 109, 109, 108, 108, 107, 106, 106, 103, 101, 99,
97, 95, 93, 91, 90, 87, 85, 83, 81, 79, 77, 75, 73, 71, 69, 67, 65, 63, 62, 60,
58, 56, 55, 54, 51, 50, 48, 46, 44, 44, 42, 40, 39, 37, 35, 35, 35, 35, 35, 35,
35, 35, 35, 35, 36, 35, 35, 36, 35, 35, 36, 36, 35, 36, 38, 37, 39, 41, 41, 43,
44, 45, 46, 47, 49, 50, 51, 52, 53, 54, 56, 57, 58, 59, 60, 60, 60, 61, 61, 62,
63, 63, 65, 65, 65, 66, 68, 68, 69, 70, 70, 70, 70, 69, 68, 66, 65, 64, 63, 61,
60, 59, 58, 57, 55, 55, 53, 52, 51, 50, 48, 46, 43, 40, 37, 34, 32, 29, 26, 23,
20, 18, 15, 13, 10, 6, 4, 1, -2, -4, -7, -10, -12, -16, -18, -21, -23, -26, -28,
-32, -34, -37, -39, -43, -44, -47, -50, -53, -56, -57, -57, -58, -59, -60, -60,
-61, -62, -63, -64, -64, -64, -66, -67, -67, -67, -68, -70, -69, -67, -66, -64,
-62, -61, -59, -58, -55, -54, -52, -50, -47, -46, -44, -43, -41, -40, -38, -35,
-31, -28, -25, -23, -19, -16, -12, -9, -7, -3, -1, 3, 6, 9, 12, 15, 19, 21, 25,
27, 29, 31, 34, 36, 38, 40, 42, 45, 47, 50, 52, 54, 55, 58, 61, 62, 65, 66, 66,
66, 65, 65, 64, 65, 65, 64, 65, 65, 64, 64, 64, 63, 63, 63, 63, 63, 62, 59, 56,
54, 52, 49, 47, 44, 41, 39, 37, 34, 32, 29, 26, 25, 22, 20, 18, 15, 11, 9, 5, 3,
0, -3, -6, -9, -13, -15, -18, -20, -24, -28, -29, -33, -36, -38, -40, -42, -44,
-46, -47, -49, -51, -52, -53, -55, -56, -57, -59, -60, -63, -65, -66, -67, -69,
-69, -69, -69, -68, -69, -67, -68, -66, -67, -66, -66, -66, -65, -65, -65, -64,
-64, -63, -62, -61, -60, -60, -58, -57, -56, -54, -53, -52, -51, -49, -49, -48,
-46, -46, -44, -43, -42, -40, -40, -40, -38, -38, -38, -38, -37, -37, -36, -35,
-35, -35, -34, -34, -34, -33, -33, -33, -32, -32, -34, -35, -36, -39, -40, -41,
-43, -44, -46, -46, -48, -49, -50, -52, -54, -55, -55, -57, -60, -62, -64, -65,
-68, -69, -73, -74, -77, -78, -80, -83, -84, -87, -88, -92, -92, -95, -97, -99,
-99, -100, -103, -103, -104, -106, -106, -108, -109, -110, -111, -113, -114,
-115, -115, -116, -118, -119, -118, -117, -115, -113, -112, -111, -109, -107,
-106, -104, -103, -101, -99, -99, -97, -96, -94, -92, -91, -87, -81, -76, -70,
-64, -60, -55, -49, -44, -38, -34, -28, -22, -18, -11, -6, -1, };