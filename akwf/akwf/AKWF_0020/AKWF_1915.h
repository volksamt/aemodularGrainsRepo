#define DATA_LENGTH 512
#define DATA AKWF_1915

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 4, 6, 9, 11, 12, 14, 16, 17, 19,
21, 22, 25, 26, 28, 31, 32, 34, 36, 37, 40, 41, 43, 46, 47, 49, 51, 53, 56, 58,
59, 62, 63, 66, 68, 69, 71, 73, 75, 77, 78, 80, 82, 84, 86, 88, 89, 91, 92, 94,
95, 97, 99, 100, 101, 102, 104, 105, 107, 108, 108, 110, 112, 113, 113, 115,
116, 116, 117, 117, 118, 119, 118, 119, 119, 119, 119, 119, 119, 120, 118, 119,
119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 118, 119, 119, 119, 118, 118,
118, 118, 118, 117, 117, 117, 117, 118, 117, 117, 117, 117, 117, 117, 116, 117,
116, 116, 117, 117, 116, 117, 116, 117, 117, 117, 117, 117, 117, 117, 117, 117,
118, 117, 117, 118, 117, 117, 118, 118, 118, 118, 118, 118, 117, 118, 118, 118,
118, 118, 117, 118, 118, 118, 117, 117, 117, 116, 116, 115, 116, 115, 115, 114,
113, 113, 112, 111, 111, 110, 109, 108, 107, 106, 106, 104, 103, 102, 101, 100,
99, 97, 96, 95, 93, 91, 90, 88, 87, 84, 83, 81, 78, 77, 75, 73, 71, 69, 67, 66,
63, 62, 60, 58, 55, 54, 53, 51, 49, 47, 46, 45, 43, 42, 42, 40, 38, 38, 36, 35,
34, 33, 32, 31, 29, 29, 27, 27, 25, 24, 23, 22, 20, 19, 17, 17, 16, 14, 13, 11,
9, 8, 6, 5, 3, 2, 0, -2, -4, -6, -6, -8, -9, -11, -12, -14, -15, -16, -17, -18,
-20, -21, -21, -22, -22, -23, -23, -23, -24, -24, -24, -24, -24, -24, -25, -24,
-24, -24, -24, -24, -24, -23, -24, -24, -24, -24, -24, -24, -25, -25, -27, -27,
-28, -28, -29, -31, -32, -33, -33, -35, -37, -38, -39, -40, -42, -42, -45, -46,
-47, -49, -50, -52, -54, -55, -56, -58, -60, -61, -62, -63, -64, -65, -67, -69,
-70, -71, -73, -74, -75, -76, -77, -79, -81, -81, -83, -84, -86, -86, -88, -88,
-90, -90, -92, -94, -95, -95, -97, -98, -100, -100, -102, -103, -104, -106,
-106, -107, -108, -109, -111, -111, -112, -113, -114, -114, -115, -116, -117,
-118, -118, -118, -118, -119, -118, -119, -119, -119, -118, -118, -119, -119,
-118, -119, -119, -119, -119, -118, -118, -119, -118, -118, -118, -118, -117,
-117, -117, -118, -117, -117, -116, -116, -117, -116, -116, -116, -116, -117,
-116, -115, -116, -115, -116, -116, -116, -115, -115, -115, -116, -116, -116,
-116, -116, -116, -116, -116, -116, -116, -117, -116, -116, -116, -116, -117,
-116, -117, -117, -117, -117, -117, -118, -117, -117, -118, -117, -118, -117,
-118, -116, -116, -115, -115, -115, -114, -114, -112, -111, -110, -109, -108,
-108, -106, -105, -104, -102, -101, -98, -97, -96, -94, -92, -91, -89, -88, -86,
-84, -82, -81, -78, -77, -74, -72, -70, -67, -65, -63, -61, -59, -57, -54, -53,
-50, -48, -45, -43, -41, -38, -36, -34, -32, -29, -28, -26, -23, -20, -18, -16,
-14, -12, -10, -8, -6, -4, -2, -1, };