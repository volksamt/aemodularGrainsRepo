#define DATA_LENGTH 512
#define DATA AKWF_1917

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 6, 9, 11, 13, 16, 19, 20, 24,
26, 28, 32, 34, 37, 41, 44, 46, 50, 52, 56, 60, 62, 65, 68, 71, 74, 76, 80, 82,
85, 88, 90, 93, 96, 97, 99, 102, 104, 105, 107, 109, 111, 112, 114, 114, 115,
117, 117, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 118,
120, 118, 117, 115, 114, 113, 112, 111, 109, 108, 106, 104, 102, 99, 97, 95, 92,
90, 88, 86, 83, 80, 78, 75, 72, 70, 67, 64, 61, 58, 56, 53, 49, 47, 44, 40, 37,
34, 31, 28, 26, 23, 20, 18, 15, 13, 12, 9, 7, 6, 5, 4, 3, 2, 2, 3, 3, 3, 4, 6,
7, 8, 10, 13, 16, 18, 20, 22, 24, 27, 30, 32, 34, 37, 39, 41, 42, 44, 45, 46,
46, 47, 48, 47, 47, 46, 45, 44, 43, 42, 40, 38, 36, 34, 31, 29, 26, 24, 20, 18,
16, 13, 9, 7, 4, 1, -4, -6, -9, -12, -15, -18, -21, -26, -28, -31, -34, -37,
-40, -44, -47, -50, -54, -57, -61, -64, -66, -69, -71, -75, -77, -80, -82, -85,
-87, -89, -92, -94, -97, -98, -99, -101, -103, -105, -105, -106, -109, -109,
-110, -111, -111, -112, -113, -113, -113, -113, -113, -114, -113, -113, -113,
-111, -112, -112, -110, -109, -109, -107, -106, -105, -104, -101, -100, -99,
-98, -95, -94, -92, -88, -87, -85, -83, -80, -78, -75, -73, -71, -68, -66, -62,
-60, -57, -55, -51, -49, -45, -44, -40, -38, -35, -32, -29, -27, -23, -20, -17,
-14, -12, -9, -6, -3, -2, 2, 5, 7, 9, 12, 14, 16, 17, 20, 22, 25, 26, 29, 29,
31, 32, 34, 36, 37, 38, 40, 41, 42, 44, 44, 45, 45, 46, 46, 47, 47, 47, 48, 47,
47, 47, 46, 46, 45, 45, 45, 43, 43, 42, 41, 40, 38, 37, 37, 35, 34, 32, 30, 28,
27, 25, 22, 21, 19, 17, 14, 13, 10, 8, 6, 2, 0, -2, -5, -8, -11, -13, -15, -18,
-21, -22, -24, -27, -28, -30, -33, -34, -34, -35, -37, -37, -37, -37, -36, -37,
-37, -36, -36, -34, -34, -32, -31, -29, -27, -26, -25, -22, -21, -19, -17, -16,
-14, -12, -11, -9, -7, -6, -5, -3, -2, 0, 1, 3, 4, 5, 6, 8, 8, 9, 10, 12, 11,
12, 12, 13, 14, 14, 15, 15, 14, 15, 14, 13, 13, 13, 12, 11, 10, 9, 8, 6, 5, 2,
2, -1, -3, -5, -6, -9, -10, -13, -15, -17, -19, -22, -24, -26, -28, -29, -31,
-33, -36, -38, -39, -41, -43, -44, -46, -48, -49, -51, -52, -53, -54, -55, -57,
-58, -59, -60, -61, -61, -62, -62, -63, -64, -64, -64, -64, -64, -64, -63, -63,
-63, -62, -62, -61, -60, -58, -58, -57, -55, -55, -52, -52, -50, -49, -46, -46,
-44, -42, -40, -38, -37, -35, -33, -32, -29, -28, -26, -24, -23, -21, -18, -17,
-15, -13, -11, -8, -6, -4, -2, -1, };