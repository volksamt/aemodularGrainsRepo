#define DATA_LENGTH 512
#define DATA AKWF_1948

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 21, 31, 43, 54, 63, 74, 82, 90, 97,
101, 106, 110, 111, 113, 112, 110, 107, 102, 96, 89, 81, 73, 62, 51, 40, 27, 16,
3, -10, -22, -35, -46, -57, -68, -76, -86, -93, -100, -104, -107, -110, -110,
-109, -107, -103, -98, -91, -83, -75, -65, -54, -42, -29, -17, -5, 9, 21, 34,
46, 57, 67, 78, 87, 94, 100, 105, 108, 111, 113, 112, 110, 106, 101, 96, 88, 80,
73, 63, 52, 41, 30, 19, 8, -3, -13, -23, -32, -41, -48, -55, -60, -64, -67, -69,
-70, -69, -67, -64, -60, -54, -46, -39, -31, -22, -12, -3, 8, 18, 29, 40, 50,
60, 69, 78, 86, 92, 98, 104, 109, 111, 113, 115, 114, 112, 109, 105, 101, 95,
88, 80, 72, 63, 52, 43, 32, 22, 10, -2, -13, -23, -34, -43, -54, -62, -70, -78,
-84, -89, -94, -97, -100, -100, -101, -99, -97, -93, -88, -84, -76, -68, -59,
-50, -41, -31, -19, -8, 2, 14, 26, 38, 48, 59, 68, 77, 86, 94, 100, 104, 109,
112, 114, 114, 112, 109, 106, 100, 94, 86, 78, 69, 59, 48, 36, 23, 11, -2, -15,
-26, -39, -51, -61, -71, -81, -90, -96, -103, -107, -110, -111, -112, -112,
-110, -106, -101, -94, -87, -78, -68, -58, -47, -34, -22, -10, 4, 17, 30, 41,
54, 65, 75, 85, 94, 100, 107, 111, 116, 118, 119, 118, 118, 113, 110, 104, 97,
89, 80, 71, 60, 49, 37, 25, 13, 1, -11, -23, -35, -47, -56, -67, -77, -84, -92,
-98, -103, -108, -110, -112, -112, -111, -109, -105, -101, -95, -87, -79, -71,
-61, -51, -39, -28, -17, -5, 7, 19, 31, 42, 54, 64, 73, 81, 89, 96, 102, 106,
109, 111, 112, 111, 109, 106, 101, 95, 88, 80, 71, 60, 50, 38, 26, 14, 2, -11,
-22, -35, -47, -58, -69, -78, -87, -95, -100, -105, -109, -112, -112, -112,
-111, -107, -102, -97, -89, -81, -72, -62, -50, -39, -27, -14, -2, 12, 24, 37,
48, 60, 71, 80, 89, 97, 104, 109, 113, 115, 116, 116, 114, 113, 108, 101, 95,
87, 78, 68, 58, 47, 35, 23, 11, -2, -14, -26, -38, -49, -58, -69, -78, -86, -92,
-98, -102, -105, -107, -107, -107, -105, -101, -97, -91, -84, -77, -68, -58,
-48, -37, -27, -15, -2, 10, 22, 34, 45, 54, 66, 75, 84, 91, 98, 104, 108, 111,
113, 115, 114, 113, 109, 105, 100, 93, 85, 77, 68, 57, 47, 35, 22, 11, -1, -13,
-25, -37, -48, -60, -69, -78, -87, -94, -101, -106, -110, -113, -114, -113,
-114, -111, -106, -102, -97, -89, -81, -73, -62, -53, -42, -31, -20, -9, 4, 14,
26, 35, 46, 54, 64, 71, 77, 82, 87, 90, 92, 93, 92, 90, 87, 83, 79, 72, 65, 58,
49, 40, 30, 20, 9, -1, -13, -22, -33, -42, -53, -61, -68, -77, -82, -87, -92,
-94, -96, -98, -98, -96, -94, -89, -84, -78, -70, -63, -54, -44, -34, -23, -12,
-2, };