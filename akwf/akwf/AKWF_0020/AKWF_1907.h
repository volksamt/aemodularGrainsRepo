#define DATA_LENGTH 512
#define DATA AKWF_1907

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 4, 6, 7, 8, 9, 11, 13, 14,
15, 18, 19, 20, 21, 23, 25, 26, 28, 30, 32, 34, 35, 37, 38, 40, 43, 45, 47, 48,
49, 52, 53, 55, 56, 58, 59, 61, 63, 63, 65, 65, 67, 69, 70, 70, 71, 72, 73, 74,
75, 75, 76, 76, 77, 78, 79, 78, 79, 80, 80, 80, 81, 81, 82, 82, 84, 84, 85, 86,
87, 87, 88, 88, 89, 90, 90, 91, 92, 93, 94, 94, 95, 96, 97, 98, 99, 99, 100,
101, 102, 102, 102, 104, 105, 106, 106, 108, 108, 110, 110, 111, 111, 112, 113,
114, 115, 115, 116, 117, 117, 118, 119, 118, 119, 120, 119, 119, 119, 119, 119,
119, 118, 118, 117, 117, 116, 116, 115, 115, 113, 112, 111, 110, 109, 107, 108,
106, 104, 103, 102, 100, 100, 98, 97, 95, 93, 92, 91, 89, 88, 87, 85, 83, 80,
80, 77, 76, 75, 73, 71, 68, 67, 65, 63, 61, 59, 56, 55, 52, 50, 49, 46, 43, 42,
39, 36, 34, 31, 30, 27, 24, 21, 20, 17, 14, 12, 10, 8, 6, 3, 2, 0, -2, -4, -7,
-8, -10, -11, -12, -14, -16, -17, -18, -20, -21, -23, -23, -24, -25, -26, -27,
-29, -29, -30, -31, -32, -33, -33, -35, -36, -36, -37, -39, -40, -41, -41, -43,
-44, -44, -45, -47, -46, -48, -49, -50, -51, -51, -52, -53, -53, -54, -55, -56,
-56, -57, -58, -58, -59, -60, -61, -61, -62, -62, -63, -63, -63, -63, -65, -64,
-65, -66, -66, -66, -67, -68, -69, -69, -70, -70, -71, -71, -71, -71, -73, -73,
-74, -74, -74, -76, -76, -77, -77, -78, -78, -78, -80, -81, -81, -81, -82, -82,
-82, -84, -84, -83, -84, -85, -84, -86, -86, -85, -86, -86, -86, -86, -87, -87,
-86, -87, -86, -86, -86, -86, -86, -85, -86, -86, -85, -86, -85, -85, -84, -85,
-85, -83, -83, -83, -83, -82, -81, -81, -81, -80, -80, -79, -79, -78, -77, -77,
-76, -76, -75, -74, -74, -73, -73, -72, -72, -72, -71, -70, -69, -69, -69, -68,
-68, -68, -66, -67, -65, -65, -65, -64, -64, -62, -63, -61, -61, -62, -61, -61,
-60, -60, -59, -58, -58, -58, -58, -57, -57, -57, -56, -56, -55, -55, -55, -54,
-54, -54, -54, -53, -52, -51, -51, -50, -50, -49, -48, -47, -46, -45, -43, -42,
-41, -39, -38, -37, -35, -34, -32, -31, -29, -27, -27, -25, -24, -22, -21, -20,
-19, -17, -17, -15, -15, -12, -13, -12, -10, -10, -10, -9, -8, -9, -8, -7, -7,
-6, -7, -6, -7, -6, -6, -5, -5, -5, -6, -5, -6, -5, -5, -5, -4, -5, -5, -4, -4,
-4, -4, -4, -4, -4, -5, -4, -5, -4, -4, -4, -4, -3, -4, -4, -5, -5, -5, -4, -5,
-5, -5, -5, -6, -6, -6, -6, -7, -7, -7, -7, -8, -7, -9, -8, -9, -9, -9, -8, -8,
-9, -8, -8, -8, -7, -6, -6, -5, -4, -3, -3, -2, -2, 0, };