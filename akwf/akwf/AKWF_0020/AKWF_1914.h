#define DATA_LENGTH 512
#define DATA AKWF_1914

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 14, 21, 29, 35, 42, 49, 54, 60,
65, 70, 74, 80, 83, 87, 90, 94, 97, 99, 102, 104, 106, 108, 109, 110, 111, 112,
113, 114, 115, 115, 115, 116, 116, 117, 116, 117, 117, 117, 117, 117, 117, 117,
118, 118, 119, 118, 119, 119, 119, 119, 118, 119, 118, 119, 119, 119, 119, 119,
119, 119, 119, 118, 119, 118, 119, 118, 119, 119, 118, 118, 118, 118, 118, 117,
117, 118, 117, 117, 118, 117, 117, 117, 117, 118, 117, 117, 118, 117, 117, 117,
118, 117, 118, 118, 118, 118, 117, 117, 118, 117, 118, 118, 117, 117, 117, 117,
117, 117, 116, 117, 116, 117, 116, 118, 117, 117, 117, 116, 118, 118, 117, 116,
117, 118, 117, 118, 117, 117, 117, 117, 118, 118, 118, 118, 118, 117, 118, 118,
118, 118, 119, 119, 118, 118, 117, 118, 118, 117, 116, 116, 115, 115, 114, 113,
112, 111, 111, 109, 109, 108, 107, 105, 104, 103, 102, 100, 98, 97, 95, 93, 91,
90, 87, 85, 83, 80, 79, 76, 73, 70, 67, 65, 61, 58, 56, 52, 49, 44, 40, 37, 33,
29, 26, 21, 17, 14, 9, 5, 1, -3, -8, -11, -16, -19, -24, -27, -31, -34, -38,
-41, -44, -48, -51, -55, -57, -60, -63, -66, -69, -71, -74, -76, -78, -80, -82,
-85, -86, -88, -90, -91, -93, -94, -95, -95, -98, -97, -97, -100, -99, -99, -99,
-100, -99, -98, -97, -98, -97, -95, -95, -93, -92, -91, -90, -87, -86, -85, -84,
-82, -81, -78, -78, -76, -75, -73, -71, -69, -68, -66, -65, -65, -63, -63, -61,
-61, -60, -59, -58, -57, -56, -56, -56, -55, -54, -53, -53, -52, -51, -51, -50,
-50, -49, -49, -48, -47, -46, -46, -45, -45, -45, -43, -43, -42, -41, -40, -40,
-39, -39, -38, -37, -37, -36, -35, -35, -35, -35, -35, -35, -36, -36, -37, -38,
-39, -41, -42, -43, -45, -47, -48, -51, -54, -57, -59, -62, -66, -69, -71, -75,
-78, -80, -85, -87, -91, -94, -97, -100, -102, -105, -108, -110, -111, -114,
-116, -117, -117, -117, -117, -117, -116, -117, -118, -116, -117, -117, -117,
-116, -117, -116, -117, -116, -114, -113, -112, -109, -108, -107, -104, -103,
-100, -97, -96, -93, -91, -89, -86, -84, -81, -78, -75, -71, -68, -65, -62, -59,
-55, -53, -49, -46, -43, -41, -38, -36, -33, -30, -28, -26, -24, -22, -21, -20,
-20, -18, -17, -18, -18, -19, -18, -20, -20, -21, -22, -22, -25, -27, -28, -30,
-30, -33, -35, -36, -38, -40, -41, -43, -44, -47, -48, -50, -50, -51, -51, -52,
-53, -55, -55, -55, -55, -55, -56, -56, -56, -57, -56, -57, -57, -57, -57, -58,
-58, -58, -58, -59, -59, -60, -61, -62, -63, -64, -65, -66, -68, -69, -72, -73,
-76, -77, -79, -81, -84, -85, -87, -88, -91, -92, -93, -94, -95, -96, -96, -95,
-95, -95, -93, -92, -89, -86, -84, -80, -77, -73, -67, -63, -57, -52, -45, -38,
-32, -26, -19, -12, -4, };