#define DATA_LENGTH 512
#define DATA AKWF_1990

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 13, 17, 21, 26, 28, 29, 30,
31, 33, 34, 34, 36, 36, 38, 39, 41, 41, 42, 43, 45, 45, 47, 47, 49, 50, 51, 53,
53, 55, 55, 57, 58, 59, 60, 62, 62, 64, 64, 66, 68, 69, 68, 68, 68, 69, 68, 67,
68, 68, 68, 68, 68, 69, 69, 68, 69, 69, 68, 68, 69, 68, 68, 69, 69, 68, 68, 68,
68, 68, 69, 68, 68, 68, 68, 68, 68, 68, 68, 69, 68, 70, 71, 70, 71, 71, 72, 71,
72, 73, 74, 73, 74, 74, 75, 76, 75, 76, 77, 77, 78, 78, 78, 79, 80, 80, 79, 80,
81, 81, 82, 83, 82, 82, 83, 84, 83, 84, 84, 85, 85, 85, 85, 85, 85, 86, 85, 86,
86, 86, 86, 87, 86, 87, 87, 87, 87, 88, 88, 88, 89, 89, 89, 89, 90, 89, 90, 89,
90, 90, 90, 90, 91, 91, 92, 92, 92, 92, 92, 93, 92, 92, 92, 93, 94, 94, 94, 95,
94, 95, 95, 95, 95, 95, 96, 96, 96, 96, 96, 96, 97, 97, 97, 97, 98, 98, 98, 98,
98, 99, 100, 100, 101, 101, 102, 102, 103, 103, 104, 104, 104, 105, 107, 107,
107, 107, 107, 109, 109, 109, 110, 111, 111, 112, 112, 112, 113, 113, 115, 114,
115, 116, 116, 117, 117, 113, 109, 106, 101, 98, 93, 90, 86, 83, 79, 74, 71, 67,
62, 59, 56, 51, 47, 43, 40, 36, 31, 28, 24, 20, 15, 12, 8, 4, 1, -4, -7, -11,
-15, -18, -22, -25, -28, -29, -32, -35, -37, -38, -40, -43, -46, -47, -49, -52,
-54, -56, -58, -61, -62, -65, -67, -68, -70, -73, -75, -77, -79, -82, -83, -85,
-88, -90, -92, -95, -97, -99, -101, -102, -101, -100, -99, -98, -97, -95, -94,
-92, -92, -91, -89, -88, -86, -85, -84, -82, -82, -80, -78, -78, -76, -75, -73,
-72, -70, -69, -68, -67, -65, -64, -62, -62, -61, -59, -57, -57, -56, -57, -57,
-57, -59, -59, -60, -61, -61, -62, -62, -63, -63, -64, -65, -65, -66, -66, -67,
-68, -68, -69, -70, -71, -71, -72, -72, -74, -73, -74, -76, -75, -76, -77, -78,
-78, -79, -78, -77, -74, -74, -73, -71, -70, -68, -68, -66, -65, -64, -63, -62,
-61, -59, -58, -56, -56, -54, -53, -51, -51, -49, -47, -47, -45, -44, -42, -41,
-40, -38, -37, -36, -35, -33, -33, -35, -36, -37, -39, -40, -43, -43, -45, -47,
-49, -50, -51, -53, -55, -56, -57, -59, -60, -62, -63, -65, -67, -69, -69, -71,
-72, -74, -76, -77, -79, -80, -82, -84, -85, -87, -88, -90, -90, -91, -92, -93,
-93, -94, -95, -96, -97, -98, -99, -98, -100, -101, -102, -103, -103, -105,
-106, -107, -107, -107, -109, -109, -110, -111, -112, -113, -114, -115, -115,
-116, -117, -117, -118, -118, -115, -111, -106, -102, -99, -95, -91, -86, -83,
-79, -74, -71, -66, -62, -58, -55, -51, -46, -42, -39, -35, -31, -26, -23, -18,
-14, -11, -7, -3, };