#define DATA_LENGTH 512
#define DATA AKWF_2007

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 10, 15, 19, 24, 28, 32, 36, 39,
44, 48, 51, 55, 58, 62, 65, 68, 71, 74, 76, 78, 81, 83, 85, 88, 90, 91, 93, 95,
97, 97, 98, 101, 101, 102, 103, 104, 105, 105, 107, 107, 106, 107, 107, 107,
108, 107, 108, 107, 107, 107, 107, 107, 106, 106, 105, 106, 104, 104, 104, 103,
102, 101, 101, 99, 100, 98, 98, 97, 96, 96, 96, 94, 94, 93, 92, 90, 89, 89, 87,
86, 85, 83, 83, 81, 81, 78, 77, 76, 74, 73, 72, 70, 68, 68, 66, 64, 63, 62, 61,
59, 58, 58, 56, 55, 54, 52, 52, 52, 50, 50, 49, 48, 48, 47, 47, 46, 47, 47, 46,
47, 47, 47, 47, 47, 49, 48, 50, 50, 52, 52, 54, 54, 56, 57, 59, 60, 61, 63, 64,
66, 68, 69, 71, 73, 75, 75, 78, 79, 81, 81, 84, 85, 86, 88, 89, 91, 92, 93, 94,
94, 96, 96, 97, 97, 98, 98, 98, 99, 97, 98, 97, 96, 97, 96, 95, 94, 92, 92, 90,
87, 86, 84, 82, 80, 79, 76, 74, 72, 70, 67, 64, 61, 58, 56, 53, 51, 48, 46, 42,
40, 37, 34, 31, 29, 25, 23, 21, 17, 14, 13, 10, 8, 6, 3, 0, -1, -3, -4, -6, -7,
-9, -10, -11, -12, -14, -15, -16, -17, -17, -18, -19, -19, -20, -20, -20, -21,
-20, -19, -21, -20, -19, -20, -20, -19, -18, -17, -18, -17, -16, -16, -15, -14,
-13, -12, -12, -11, -11, -10, -9, -8, -8, -8, -7, -7, -5, -4, -5, -3, -4, -3,
-2, -2, -2, -2, -1, -1, -1, -1, 0, 0, 0, -1, 0, 0, 0, 1, 1, 0, 1, 1, 1, 1, 1, 1,
0, 0, 0, 0, -1, 0, 0, -1, -2, -2, -2, -3, -3, -4, -5, -5, -6, -7, -8, -9, -9,
-10, -11, -12, -12, -15, -15, -15, -17, -18, -20, -21, -22, -24, -25, -27, -29,
-30, -32, -35, -37, -38, -41, -41, -45, -47, -49, -51, -53, -55, -57, -60, -62,
-65, -67, -69, -72, -74, -75, -78, -81, -82, -85, -86, -88, -91, -92, -94, -95,
-97, -99, -100, -101, -103, -104, -106, -107, -107, -108, -109, -110, -109,
-110, -110, -111, -110, -109, -109, -109, -108, -107, -107, -106, -105, -104,
-103, -101, -100, -100, -98, -95, -94, -92, -91, -89, -88, -86, -84, -83, -81,
-79, -77, -75, -74, -73, -70, -69, -67, -66, -66, -65, -64, -61, -61, -60, -59,
-59, -57, -58, -58, -57, -57, -57, -57, -58, -58, -58, -59, -60, -61, -62, -63,
-64, -66, -68, -69, -71, -73, -74, -76, -78, -80, -82, -85, -87, -89, -91, -93,
-95, -97, -99, -101, -104, -105, -107, -109, -110, -111, -113, -114, -116, -116,
-118, -118, -118, -119, -119, -120, -119, -119, -119, -118, -117, -116, -114,
-113, -111, -110, -107, -105, -103, -100, -97, -95, -91, -88, -85, -82, -77,
-74, -69, -66, -62, -57, -53, -49, -44, -39, -35, -31, -25, -22, -17, -12, -8,
-3, };