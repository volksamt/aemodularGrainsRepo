#define DATA_LENGTH 512
#define DATA AKWF_1937

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 11, 16, 21, 26, 32, 37, 41, 47,
51, 56, 60, 65, 70, 73, 78, 83, 86, 90, 93, 97, 100, 103, 105, 108, 110, 112,
113, 115, 116, 117, 117, 118, 119, 119, 118, 119, 118, 118, 116, 115, 113, 113,
111, 110, 107, 106, 104, 101, 99, 97, 95, 93, 90, 87, 84, 82, 79, 77, 74, 71,
69, 67, 63, 62, 59, 57, 55, 53, 50, 48, 47, 46, 43, 42, 41, 41, 40, 38, 38, 37,
36, 35, 34, 34, 34, 34, 34, 33, 34, 34, 33, 33, 33, 34, 34, 34, 34, 34, 35, 36,
37, 37, 36, 38, 38, 38, 38, 39, 39, 40, 39, 40, 41, 40, 41, 41, 41, 42, 41, 41,
42, 42, 41, 41, 41, 41, 41, 41, 42, 41, 41, 41, 41, 41, 40, 40, 40, 40, 39, 39,
39, 39, 39, 39, 37, 37, 36, 36, 35, 35, 34, 33, 32, 31, 30, 29, 28, 27, 26, 24,
23, 21, 20, 19, 16, 15, 14, 12, 10, 8, 6, 3, 1, -2, -5, -6, -9, -13, -15, -18,
-21, -24, -27, -30, -32, -36, -39, -42, -44, -47, -50, -53, -56, -59, -61, -64,
-65, -68, -70, -72, -75, -76, -77, -78, -80, -81, -82, -83, -82, -83, -83, -84,
-83, -82, -81, -81, -79, -78, -76, -74, -72, -70, -68, -65, -62, -59, -57, -52,
-50, -47, -42, -39, -35, -31, -27, -23, -20, -16, -11, -7, -4, 1, 5, 9, 12, 18,
22, 25, 28, 32, 36, 40, 43, 47, 49, 52, 56, 59, 62, 64, 66, 69, 71, 73, 76, 77,
79, 82, 83, 85, 86, 87, 88, 90, 91, 91, 93, 94, 94, 96, 95, 96, 96, 97, 96, 96,
97, 96, 96, 96, 95, 95, 94, 94, 94, 92, 91, 91, 89, 87, 87, 85, 84, 83, 81, 79,
77, 76, 74, 72, 70, 67, 64, 62, 59, 57, 54, 50, 48, 44, 41, 38, 35, 31, 28, 24,
21, 17, 15, 10, 7, 3, 0, -3, -7, -10, -12, -16, -19, -22, -25, -28, -30, -33,
-36, -37, -40, -41, -44, -45, -47, -49, -50, -50, -52, -53, -53, -54, -55, -54,
-54, -54, -54, -54, -53, -52, -52, -51, -50, -49, -48, -47, -46, -44, -43, -42,
-41, -39, -37, -36, -35, -33, -32, -31, -30, -29, -27, -26, -25, -24, -23, -22,
-22, -22, -21, -20, -20, -20, -20, -20, -20, -21, -21, -21, -23, -23, -24, -25,
-26, -27, -28, -29, -30, -32, -33, -35, -36, -37, -40, -42, -43, -45, -47, -48,
-49, -52, -53, -56, -57, -59, -62, -63, -64, -66, -67, -70, -71, -73, -74, -75,
-78, -79, -79, -82, -82, -84, -84, -86, -87, -87, -89, -90, -91, -91, -93, -93,
-94, -95, -96, -97, -98, -97, -98, -98, -98, -99, -100, -100, -100, -100, -100,
-100, -100, -99, -99, -99, -99, -97, -96, -96, -95, -93, -91, -90, -88, -87,
-85, -84, -81, -80, -77, -75, -71, -69, -66, -63, -59, -56, -51, -48, -44, -39,
-35, -31, -26, -22, -18, -12, -7, -2, };