#define DATA_LENGTH 512
#define DATA AKWF_1934

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 7, 11, 13, 17, 20, 23, 27, 31,
34, 37, 41, 44, 47, 50, 54, 56, 60, 62, 66, 69, 73, 75, 78, 82, 83, 86, 88, 91,
93, 96, 98, 100, 102, 103, 106, 108, 108, 110, 110, 113, 113, 114, 114, 114,
115, 115, 115, 115, 115, 114, 113, 112, 112, 110, 108, 107, 105, 104, 101, 99,
96, 95, 91, 89, 87, 84, 81, 78, 74, 73, 69, 67, 64, 59, 56, 55, 51, 49, 45, 43,
40, 38, 35, 33, 31, 29, 26, 25, 23, 21, 21, 20, 18, 17, 17, 16, 17, 16, 16, 15,
16, 17, 17, 18, 19, 19, 20, 22, 23, 25, 26, 28, 29, 31, 33, 34, 36, 38, 40, 41,
42, 45, 46, 48, 49, 51, 51, 53, 56, 56, 57, 58, 58, 59, 59, 60, 60, 60, 59, 59,
59, 59, 57, 57, 57, 54, 54, 52, 51, 49, 47, 45, 44, 42, 40, 38, 35, 33, 30, 28,
26, 24, 21, 18, 16, 13, 10, 6, 4, 0, -1, -4, -8, -10, -12, -15, -18, -21, -24,
-27, -29, -31, -34, -36, -39, -41, -43, -45, -47, -49, -52, -54, -56, -58, -60,
-61, -64, -67, -68, -70, -72, -74, -75, -77, -79, -81, -81, -83, -85, -86, -87,
-88, -89, -90, -91, -92, -92, -94, -94, -93, -94, -94, -94, -94, -93, -93, -93,
-92, -92, -91, -89, -88, -88, -85, -85, -83, -81, -79, -77, -74, -72, -70, -66,
-65, -61, -58, -54, -51, -48, -45, -41, -38, -33, -31, -27, -23, -19, -16, -11,
-8, -5, 0, 3, 6, 10, 14, 17, 21, 23, 27, 30, 33, 35, 38, 41, 44, 46, 48, 50, 51,
53, 55, 57, 58, 59, 60, 61, 62, 64, 63, 65, 66, 66, 66, 65, 66, 66, 66, 66, 65,
65, 65, 64, 64, 63, 63, 61, 61, 59, 58, 56, 55, 55, 54, 53, 51, 49, 47, 46, 45,
44, 42, 40, 38, 37, 35, 34, 32, 30, 28, 26, 24, 22, 20, 17, 15, 13, 11, 8, 6, 3,
0, -2, -4, -6, -9, -12, -14, -18, -19, -22, -23, -26, -29, -31, -34, -35, -38,
-39, -42, -43, -45, -47, -48, -50, -50, -52, -54, -54, -56, -57, -56, -58, -57,
-58, -58, -58, -58, -57, -57, -56, -56, -56, -54, -53, -52, -51, -50, -48, -47,
-45, -44, -42, -41, -38, -38, -36, -34, -32, -31, -29, -28, -27, -26, -24, -23,
-22, -21, -20, -19, -19, -18, -18, -17, -18, -18, -17, -19, -19, -19, -21, -22,
-23, -24, -27, -29, -29, -31, -34, -36, -38, -41, -44, -47, -49, -53, -56, -58,
-62, -65, -67, -70, -74, -77, -80, -83, -86, -89, -92, -95, -97, -100, -103,
-104, -107, -109, -111, -112, -114, -115, -116, -118, -118, -118, -119, -118,
-120, -118, -118, -117, -117, -115, -115, -113, -112, -110, -109, -106, -104,
-102, -100, -97, -95, -93, -89, -86, -84, -81, -77, -74, -71, -68, -64, -61,
-56, -53, -49, -46, -42, -39, -35, -31, -27, -23, -20, -17, -12, -9, -6, -2, };