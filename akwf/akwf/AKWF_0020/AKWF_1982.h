#define DATA_LENGTH 512
#define DATA AKWF_1982

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 0, 1, 0, 1, 1, 1, 2, 2, 2, 2, 1,
2, 1, 3, 3, 3, 3, 2, 3, 4, 4, 4, 4, 5, 4, 5, 5, 6, 5, 7, 7, 6, 7, 7, 8, 8, 8, 8,
9, 9, 10, 10, 10, 11, 12, 12, 13, 13, 14, 15, 16, 16, 16, 17, 18, 18, 18, 20,
20, 21, 21, 23, 23, 24, 25, 26, 27, 27, 28, 28, 29, 30, 31, 32, 33, 34, 35, 35,
36, 37, 38, 40, 42, 42, 44, 45, 46, 46, 48, 50, 50, 51, 53, 54, 56, 57, 58, 59,
60, 61, 62, 65, 66, 67, 67, 69, 71, 72, 73, 74, 76, 77, 78, 79, 82, 83, 85, 87,
89, 89, 92, 93, 95, 98, 98, 101, 103, 105, 107, 108, 109, 111, 113, 112, 113,
113, 113, 112, 113, 112, 112, 112, 111, 111, 111, 111, 111, 110, 110, 110, 110,
109, 108, 105, 104, 101, 99, 97, 95, 93, 92, 89, 86, 85, 82, 81, 78, 76, 74, 72,
70, 69, 68, 66, 65, 63, 62, 60, 59, 59, 56, 57, 55, 54, 52, 51, 50, 48, 47, 46,
45, 44, 43, 42, 41, 39, 38, 37, 37, 35, 34, 33, 32, 32, 31, 29, 28, 27, 26, 26,
25, 25, 23, 22, 22, 21, 20, 19, 19, 18, 17, 16, 16, 15, 14, 15, 13, 13, 12, 11,
11, 10, 10, 10, 9, 9, 8, 7, 8, 6, 7, 6, 4, 5, 4, 3, 4, 4, 3, 2, 2, 3, 2, 1, 1,
1, 1, 1, 0, 0, -1, -1, -1, -1, -1, -2, -2, -2, -2, -2, -3, -3, -3, -3, -3, -3,
-3, -3, -3, -4, -4, -5, -4, -4, -4, -5, -5, -6, -6, -6, -7, -8, -8, -8, -8, -10,
-10, -10, -11, -11, -11, -12, -12, -12, -13, -14, -14, -14, -15, -17, -17, -18,
-17, -19, -19, -20, -20, -20, -22, -22, -22, -22, -25, -25, -26, -27, -28, -29,
-29, -31, -31, -33, -33, -34, -35, -37, -38, -38, -40, -41, -40, -42, -43, -45,
-46, -47, -48, -49, -50, -51, -53, -53, -55, -56, -58, -59, -59, -61, -62, -64,
-65, -66, -68, -69, -71, -72, -74, -76, -77, -79, -80, -81, -83, -84, -86, -88,
-89, -91, -93, -94, -96, -96, -98, -99, -101, -102, -103, -105, -107, -108,
-109, -110, -112, -113, -114, -116, -117, -119, -118, -117, -115, -115, -113,
-111, -111, -109, -108, -106, -105, -104, -103, -101, -99, -99, -98, -96, -95,
-93, -91, -89, -87, -86, -84, -81, -80, -78, -76, -74, -72, -71, -68, -67, -65,
-64, -61, -60, -58, -57, -56, -55, -53, -53, -51, -51, -50, -48, -48, -46, -45,
-44, -43, -41, -41, -39, -38, -38, -36, -35, -34, -33, -33, -32, -30, -29, -29,
-28, -28, -26, -25, -23, -22, -22, -21, -19, -20, -18, -19, -17, -17, -16, -17,
-15, -15, -15, -13, -13, -13, -12, -11, -10, -10, -9, -9, -9, -8, -7, -7, -6,
-6, -6, -5, -4, -3, -3, -2, -3, -2, -1, -2, 0, };