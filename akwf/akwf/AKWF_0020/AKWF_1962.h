#define DATA_LENGTH 512
#define DATA AKWF_1962

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 8, 10, 11, 13, 14, 16, 16,
18, 20, 21, 22, 23, 25, 26, 27, 28, 29, 31, 32, 33, 35, 36, 37, 38, 39, 41, 42,
43, 44, 44, 46, 47, 49, 49, 50, 52, 53, 55, 54, 57, 58, 59, 60, 61, 61, 62, 63,
64, 64, 65, 66, 66, 68, 69, 69, 70, 71, 72, 73, 73, 74, 75, 76, 76, 77, 78, 80,
81, 81, 81, 83, 84, 84, 86, 86, 88, 88, 89, 90, 90, 92, 91, 92, 94, 94, 95, 96,
96, 97, 98, 99, 99, 99, 100, 101, 100, 102, 102, 102, 103, 105, 105, 106, 106,
107, 108, 108, 109, 110, 111, 111, 113, 114, 114, 115, 116, 116, 117, 117, 118,
118, 118, 118, 119, 119, 120, 119, 119, 119, 119, 118, 118, 117, 116, 117, 116,
115, 114, 114, 114, 113, 112, 111, 110, 110, 108, 107, 107, 105, 105, 104, 103,
103, 101, 100, 99, 98, 98, 97, 96, 95, 95, 94, 93, 92, 92, 91, 90, 89, 89, 88,
87, 85, 85, 84, 84, 83, 83, 81, 80, 80, 79, 78, 78, 77, 77, 76, 74, 75, 73, 72,
72, 70, 69, 69, 68, 67, 66, 65, 64, 63, 62, 62, 61, 59, 59, 58, 57, 55, 55, 54,
53, 53, 50, 50, 49, 48, 47, 46, 46, 45, 44, 42, 43, 41, 39, 39, 39, 37, 36, 35,
34, 34, 32, 31, 29, 28, 28, 26, 25, 23, 23, 22, 19, 18, 17, 15, 14, 12, 10, 9,
7, 5, 4, 2, 1, -2, -3, -5, -6, -9, -10, -12, -14, -15, -16, -18, -20, -21, -22,
-24, -26, -26, -29, -30, -31, -33, -34, -35, -37, -38, -39, -40, -41, -43, -44,
-45, -45, -48, -48, -49, -50, -51, -52, -52, -54, -54, -56, -57, -57, -59, -60,
-60, -61, -62, -63, -64, -64, -65, -66, -66, -69, -69, -71, -71, -72, -73, -74,
-74, -75, -76, -77, -78, -79, -80, -82, -82, -83, -83, -85, -86, -86, -86, -88,
-89, -89, -89, -90, -90, -92, -93, -93, -94, -94, -95, -95, -96, -97, -97, -99,
-99, -99, -100, -101, -103, -103, -103, -104, -104, -106, -107, -106, -107,
-108, -109, -110, -111, -111, -112, -113, -114, -115, -114, -115, -116, -116,
-116, -117, -118, -117, -118, -118, -118, -119, -119, -119, -119, -118, -119,
-118, -118, -117, -117, -117, -116, -115, -114, -114, -113, -113, -111, -111,
-109, -109, -107, -107, -106, -105, -104, -103, -102, -102, -101, -99, -99, -98,
-97, -97, -95, -94, -93, -92, -92, -91, -90, -89, -88, -88, -87, -86, -86, -86,
-84, -84, -84, -82, -82, -82, -81, -80, -79, -78, -77, -77, -75, -75, -74, -73,
-72, -72, -71, -69, -69, -67, -67, -65, -64, -63, -62, -61, -61, -59, -58, -58,
-57, -56, -55, -54, -53, -52, -52, -51, -50, -50, -50, -49, -48, -47, -46, -46,
-45, -44, -43, -42, -41, -39, -39, -38, -36, -34, -33, -31, -30, -28, -26, -25,
-23, -21, -19, -17, -16, -13, -12, -9, -8, -5, -4, -1, };