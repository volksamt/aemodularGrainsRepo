#define DATA_LENGTH 512
#define DATA AKWF_1936

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 8, 13, 16, 22, 26, 30, 34, 37,
42, 46, 50, 54, 59, 63, 68, 72, 76, 80, 83, 88, 93, 96, 100, 104, 109, 113, 117,
119, 117, 116, 114, 113, 111, 109, 108, 106, 104, 103, 101, 99, 98, 96, 94, 93,
91, 90, 87, 87, 85, 84, 81, 80, 79, 77, 75, 74, 73, 70, 69, 67, 66, 64, 61, 61,
58, 57, 56, 54, 51, 51, 49, 47, 46, 45, 45, 44, 44, 44, 44, 45, 45, 43, 43, 44,
43, 43, 44, 43, 43, 43, 43, 44, 44, 43, 43, 43, 43, 44, 44, 43, 44, 43, 44, 44,
44, 44, 44, 44, 43, 44, 43, 43, 43, 43, 43, 43, 43, 43, 44, 42, 43, 42, 42, 41,
41, 39, 39, 38, 38, 37, 37, 36, 35, 35, 34, 33, 33, 33, 32, 30, 30, 30, 28, 28,
28, 26, 26, 25, 25, 25, 24, 23, 23, 22, 21, 21, 19, 18, 19, 18, 17, 16, 16, 14,
15, 13, 13, 11, 10, 8, 5, 3, 1, -1, -4, -5, -7, -10, -12, -14, -16, -19, -21,
-22, -25, -28, -29, -31, -32, -35, -37, -39, -41, -44, -46, -48, -50, -52, -54,
-57, -59, -61, -63, -64, -68, -70, -72, -73, -76, -78, -80, -82, -85, -84, -81,
-78, -74, -71, -67, -65, -61, -58, -55, -52, -48, -45, -42, -38, -35, -32, -28,
-25, -21, -18, -16, -12, -8, -6, -2, 2, 5, 8, 11, 15, 18, 22, 25, 28, 31, 34,
38, 42, 45, 47, 51, 54, 57, 61, 65, 67, 68, 68, 69, 70, 69, 70, 70, 71, 70, 70,
71, 72, 71, 72, 73, 72, 73, 72, 73, 73, 74, 75, 74, 74, 76, 76, 76, 76, 75, 76,
76, 77, 77, 77, 77, 77, 78, 78, 79, 79, 79, 79, 79, 80, 80, 81, 80, 77, 74, 71,
69, 65, 63, 60, 58, 54, 51, 49, 45, 42, 40, 37, 33, 31, 29, 26, 22, 20, 17, 14,
11, 8, 6, 3, 0, -4, -7, -9, -12, -15, -17, -21, -23, -25, -29, -32, -36, -38,
-41, -44, -46, -49, -52, -53, -51, -51, -51, -49, -49, -48, -46, -47, -46, -46,
-45, -44, -43, -43, -41, -41, -41, -40, -39, -39, -37, -37, -36, -35, -35, -34,
-33, -33, -32, -32, -31, -31, -30, -29, -28, -27, -27, -27, -25, -25, -24, -24,
-23, -22, -21, -21, -23, -23, -26, -26, -29, -30, -32, -32, -34, -35, -37, -38,
-40, -41, -43, -44, -45, -48, -48, -49, -51, -53, -54, -55, -58, -58, -59, -62,
-63, -64, -65, -67, -69, -70, -71, -74, -74, -76, -78, -78, -80, -82, -84, -84,
-85, -87, -87, -87, -87, -87, -86, -85, -86, -85, -85, -84, -85, -85, -84, -83,
-83, -83, -82, -82, -82, -83, -82, -81, -81, -80, -81, -80, -80, -79, -79, -79,
-79, -78, -78, -78, -78, -77, -78, -76, -76, -76, -76, -75, -75, -75, -74, -74,
-74, -69, -65, -60, -56, -52, -49, -44, -40, -35, -32, -27, -23, -19, -15, -12,
-6, -3, };