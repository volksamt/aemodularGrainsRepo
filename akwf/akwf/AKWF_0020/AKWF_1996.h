#define DATA_LENGTH 512
#define DATA AKWF_1996

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 12, 14, 16, 19, 22, 23,
26, 29, 32, 34, 37, 39, 42, 44, 47, 50, 53, 54, 58, 60, 62, 65, 68, 70, 73, 75,
77, 81, 83, 86, 89, 90, 93, 96, 98, 101, 103, 106, 109, 112, 114, 115, 118, 119,
119, 118, 119, 120, 119, 119, 119, 119, 119, 118, 119, 120, 119, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119,
120, 119, 120, 119, 118, 116, 116, 114, 113, 111, 111, 109, 108, 107, 106, 105,
104, 102, 101, 101, 99, 99, 97, 97, 95, 94, 93, 91, 90, 90, 88, 87, 86, 85, 84,
82, 82, 80, 79, 77, 78, 76, 76, 75, 74, 74, 72, 72, 71, 71, 70, 70, 69, 68, 66,
66, 65, 65, 64, 63, 62, 62, 60, 61, 59, 59, 58, 57, 56, 56, 55, 54, 54, 53, 52,
52, 51, 50, 49, 48, 47, 47, 46, 45, 44, 44, 43, 42, 41, 41, 40, 39, 39, 38, 37,
37, 35, 35, 35, 34, 33, 32, 31, 30, 29, 29, 28, 28, 27, 26, 25, 24, 24, 24, 23,
22, 22, 22, 21, 21, 21, 20, 19, 18, 19, 18, 18, 17, 17, 17, 17, 15, 15, 15, 15,
14, 13, 14, 13, 12, 12, 11, 11, 10, 9, 10, 8, 8, 8, 8, 7, 7, 6, 6, 5, 5, 4, 4,
4, 2, 3, 1, 1, 0, 1, 0, 0, -1, -2, -3, -3, -4, -4, -4, -5, -6, -6, -6, -6, -7,
-7, -8, -8, -9, -10, -10, -10, -11, -12, -11, -12, -12, -13, -14, -14, -15, -16,
-16, -16, -16, -16, -17, -18, -18, -18, -18, -19, -20, -19, -21, -21, -22, -22,
-23, -22, -24, -23, -24, -24, -25, -26, -25, -27, -26, -28, -27, -28, -29, -30,
-29, -30, -31, -30, -31, -31, -33, -33, -33, -34, -34, -34, -34, -35, -36, -37,
-37, -38, -38, -38, -39, -40, -40, -40, -41, -41, -41, -42, -42, -43, -45, -44,
-45, -46, -47, -48, -47, -49, -49, -49, -51, -52, -52, -53, -53, -55, -54, -55,
-56, -57, -58, -58, -59, -59, -61, -61, -62, -63, -63, -64, -65, -65, -65, -66,
-67, -68, -68, -70, -70, -71, -71, -71, -73, -73, -73, -74, -74, -75, -76, -76,
-76, -76, -78, -78, -78, -79, -80, -80, -81, -82, -82, -83, -83, -84, -84, -85,
-86, -86, -87, -88, -88, -88, -90, -90, -91, -91, -92, -93, -94, -95, -95, -97,
-97, -98, -99, -100, -101, -100, -102, -102, -104, -104, -105, -105, -107, -108,
-108, -109, -111, -110, -112, -112, -113, -114, -115, -116, -116, -117, -118,
-118, -118, -116, -115, -113, -111, -111, -109, -107, -106, -104, -103, -101,
-100, -99, -98, -96, -95, -92, -91, -90, -89, -87, -85, -84, -83, -82, -80, -78,
-78, -76, -75, -73, -71, -69, -69, -68, -65, -64, -61, -59, -55, -53, -51, -48,
-46, -43, -41, -37, -35, -33, -31, -28, -25, -23, -20, -17, -15, -13, -11, -9,
-6, -3, 0, };