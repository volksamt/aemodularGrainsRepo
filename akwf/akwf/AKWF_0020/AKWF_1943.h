#define DATA_LENGTH 512
#define DATA AKWF_1943

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 8, 10, 16, 19, 23, 26, 31, 35,
38, 42, 46, 50, 54, 57, 61, 65, 68, 71, 75, 79, 82, 85, 88, 91, 93, 97, 100,
101, 105, 106, 108, 111, 111, 114, 115, 116, 117, 118, 119, 119, 119, 119, 119,
119, 118, 117, 115, 115, 113, 111, 111, 107, 106, 104, 101, 98, 97, 93, 90, 88,
84, 82, 79, 76, 73, 69, 66, 64, 61, 57, 55, 52, 49, 47, 43, 41, 37, 35, 33, 31,
29, 28, 26, 25, 23, 23, 21, 20, 19, 19, 18, 18, 19, 19, 19, 19, 20, 21, 21, 22,
23, 24, 26, 26, 28, 29, 31, 32, 33, 35, 36, 37, 39, 40, 42, 44, 45, 46, 48, 49,
50, 51, 53, 53, 54, 55, 56, 56, 56, 55, 57, 56, 55, 56, 55, 55, 53, 53, 52, 51,
50, 49, 47, 47, 45, 44, 42, 40, 38, 36, 34, 32, 30, 29, 26, 25, 22, 21, 18, 16,
13, 12, 9, 6, 5, 2, 0, -2, -5, -7, -9, -11, -14, -15, -18, -20, -21, -24, -25,
-27, -29, -30, -32, -34, -35, -37, -38, -41, -43, -44, -46, -48, -50, -50, -53,
-54, -55, -57, -58, -59, -61, -62, -63, -63, -65, -65, -66, -66, -67, -68, -68,
-68, -69, -69, -69, -69, -68, -67, -66, -66, -65, -64, -62, -61, -60, -58, -57,
-55, -52, -51, -48, -46, -42, -39, -36, -32, -30, -26, -22, -19, -15, -12, -8,
-3, 1, 5, 9, 13, 17, 21, 25, 29, 34, 36, 41, 45, 49, 52, 56, 58, 61, 64, 68, 70,
73, 75, 76, 79, 79, 82, 82, 84, 84, 85, 85, 85, 85, 85, 84, 83, 82, 81, 79, 78,
76, 75, 72, 70, 68, 66, 63, 60, 58, 54, 51, 48, 45, 42, 40, 36, 32, 29, 26, 23,
19, 17, 14, 10, 7, 4, 1, -1, -5, -8, -11, -13, -16, -18, -20, -22, -24, -26,
-28, -31, -32, -34, -36, -38, -38, -41, -42, -44, -46, -46, -48, -49, -50, -51,
-53, -53, -55, -55, -56, -56, -57, -57, -58, -59, -59, -60, -60, -60, -60, -61,
-61, -61, -60, -61, -60, -60, -61, -60, -59, -59, -59, -59, -59, -57, -57, -56,
-55, -55, -53, -53, -50, -49, -48, -47, -46, -45, -43, -41, -39, -39, -37, -35,
-34, -32, -31, -29, -28, -26, -25, -24, -22, -21, -20, -19, -18, -17, -16, -16,
-15, -15, -15, -14, -13, -14, -14, -15, -15, -16, -16, -18, -18, -20, -20, -22,
-23, -25, -28, -29, -33, -34, -37, -39, -42, -44, -47, -50, -52, -54, -57, -60,
-63, -67, -70, -72, -74, -78, -80, -83, -85, -88, -90, -93, -94, -97, -99, -100,
-103, -104, -105, -107, -108, -109, -110, -110, -111, -111, -111, -111, -111,
-111, -111, -110, -109, -108, -107, -106, -106, -104, -103, -102, -101, -98,
-96, -95, -93, -91, -89, -86, -84, -81, -79, -77, -74, -71, -69, -65, -63, -60,
-56, -54, -51, -48, -44, -42, -39, -35, -32, -29, -26, -22, -19, -16, -12, -9,
-6, -3, };