#define DATA_LENGTH 512
#define DATA AKWF_1987

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 7, 10, 14, 17, 20, 24, 26, 29,
33, 36, 39, 42, 46, 49, 51, 55, 58, 61, 65, 68, 70, 72, 72, 74, 75, 76, 78, 79,
80, 80, 81, 82, 84, 85, 86, 87, 88, 90, 91, 92, 93, 94, 95, 96, 98, 98, 100,
101, 103, 103, 104, 106, 107, 108, 108, 111, 112, 111, 111, 111, 109, 109, 109,
108, 107, 106, 106, 105, 105, 104, 103, 103, 102, 102, 101, 101, 99, 99, 98, 97,
97, 97, 96, 95, 95, 95, 94, 93, 92, 92, 90, 90, 90, 89, 89, 87, 86, 84, 83, 82,
82, 79, 78, 77, 77, 75, 74, 73, 71, 71, 69, 69, 67, 66, 65, 64, 62, 61, 60, 59,
58, 57, 56, 55, 54, 52, 51, 50, 49, 47, 46, 42, 39, 36, 33, 30, 27, 23, 21, 17,
14, 12, 8, 5, 2, -1, -5, -8, -10, -14, -18, -21, -23, -26, -30, -32, -36, -39,
-42, -46, -48, -51, -55, -58, -61, -64, -67, -67, -67, -69, -69, -69, -71, -71,
-71, -72, -73, -74, -75, -75, -76, -77, -77, -77, -78, -79, -79, -79, -81, -81,
-81, -83, -83, -84, -84, -84, -86, -86, -87, -87, -88, -88, -89, -89, -90, -92,
-92, -93, -94, -95, -96, -96, -98, -97, -98, -99, -100, -101, -102, -102, -103,
-105, -105, -107, -107, -108, -109, -109, -110, -111, -112, -112, -114, -114,
-116, -115, -117, -118, -119, -119, -117, -113, -110, -108, -104, -100, -98,
-94, -90, -87, -83, -80, -77, -73, -70, -67, -64, -60, -57, -54, -50, -47, -44,
-40, -37, -34, -30, -27, -24, -20, -17, -14, -10, -7, -4, 0, 3, 4, 6, 8, 10, 11,
13, 15, 17, 19, 20, 22, 23, 25, 27, 29, 31, 32, 33, 36, 37, 39, 40, 42, 45, 45,
47, 49, 51, 53, 55, 56, 58, 59, 61, 63, 65, 64, 64, 62, 60, 58, 58, 57, 55, 53,
53, 51, 49, 49, 47, 46, 44, 43, 42, 40, 39, 38, 37, 35, 33, 33, 31, 29, 28, 27,
25, 24, 22, 21, 20, 19, 18, 16, 16, 16, 15, 16, 15, 15, 15, 14, 14, 15, 14, 14,
13, 13, 13, 13, 13, 13, 12, 12, 11, 12, 12, 12, 10, 11, 10, 10, 10, 10, 10, 10,
10, 9, 9, 10, 9, 8, 7, 7, 5, 5, 3, 4, 2, 2, 2, 1, -1, -1, -2, -2, -3, -4, -5,
-6, -7, -7, -8, -8, -9, -10, -11, -11, -13, -14, -13, -15, -15, -16, -17, -19,
-19, -19, -19, -20, -22, -21, -22, -24, -24, -24, -25, -25, -26, -26, -28, -28,
-29, -29, -31, -31, -31, -32, -32, -33, -34, -35, -35, -36, -37, -37, -38, -38,
-39, -40, -41, -41, -42, -41, -42, -43, -42, -43, -43, -42, -42, -42, -43, -43,
-43, -43, -43, -44, -43, -43, -44, -44, -43, -44, -44, -44, -44, -45, -44, -45,
-44, -45, -45, -45, -46, -45, -45, -45, -45, -45, -43, -39, -36, -34, -29, -27,
-24, -21, -17, -14, -12, -8, -5, -2, };