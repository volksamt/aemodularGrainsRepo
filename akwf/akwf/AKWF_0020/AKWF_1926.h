#define DATA_LENGTH 512
#define DATA AKWF_1926

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 13, 18, 22, 28, 32, 37, 41, 46,
51, 55, 59, 63, 68, 71, 75, 79, 83, 87, 90, 93, 96, 98, 101, 104, 106, 108, 110,
112, 114, 114, 116, 117, 117, 118, 118, 119, 120, 119, 119, 118, 118, 118, 115,
114, 112, 112, 110, 107, 107, 105, 103, 100, 98, 95, 93, 90, 88, 85, 82, 78, 76,
73, 71, 68, 65, 62, 60, 56, 53, 51, 47, 45, 42, 39, 38, 35, 33, 31, 28, 27, 26,
23, 21, 20, 18, 17, 16, 14, 14, 13, 13, 12, 12, 11, 12, 11, 12, 13, 13, 14, 13,
15, 15, 16, 17, 19, 19, 21, 22, 23, 25, 27, 28, 30, 31, 34, 35, 36, 39, 40, 41,
43, 44, 47, 48, 49, 51, 51, 53, 54, 55, 56, 58, 57, 58, 58, 60, 60, 60, 60, 61,
59, 59, 59, 57, 58, 56, 55, 54, 53, 51, 49, 48, 47, 45, 42, 40, 39, 35, 34, 31,
27, 25, 22, 19, 16, 13, 10, 7, 3, 0, -3, -6, -10, -14, -17, -20, -22, -27, -29,
-33, -36, -38, -42, -45, -48, -51, -54, -57, -59, -61, -63, -65, -67, -69, -71,
-73, -75, -75, -76, -77, -78, -80, -80, -80, -80, -79, -80, -80, -79, -80, -78,
-78, -76, -76, -73, -73, -70, -69, -67, -65, -63, -60, -58, -56, -52, -50, -47,
-44, -41, -38, -35, -32, -28, -25, -21, -19, -14, -11, -7, -4, 0, 3, 6, 11, 13,
18, 21, 24, 28, 32, 34, 38, 41, 44, 47, 50, 53, 56, 58, 61, 64, 67, 69, 71, 73,
75, 77, 78, 81, 82, 83, 85, 85, 87, 88, 88, 89, 90, 90, 90, 90, 91, 90, 90, 90,
90, 89, 89, 89, 87, 86, 85, 83, 83, 82, 80, 78, 76, 75, 73, 72, 69, 68, 65, 63,
61, 59, 56, 53, 51, 48, 47, 43, 41, 39, 37, 34, 31, 29, 26, 23, 21, 18, 16, 14,
11, 9, 6, 4, 1, -2, -3, -6, -9, -11, -13, -14, -17, -19, -21, -23, -25, -26,
-28, -30, -31, -32, -34, -36, -37, -38, -39, -41, -41, -41, -42, -43, -43, -44,
-44, -44, -45, -46, -46, -46, -46, -46, -46, -45, -46, -45, -45, -45, -44, -43,
-42, -42, -41, -41, -40, -40, -39, -37, -37, -36, -35, -34, -33, -33, -32, -32,
-30, -29, -29, -27, -28, -26, -25, -25, -25, -24, -23, -23, -23, -22, -22, -22,
-22, -23, -22, -23, -22, -22, -23, -24, -24, -25, -25, -26, -27, -28, -29, -31,
-32, -34, -35, -37, -38, -40, -41, -43, -45, -47, -50, -51, -53, -56, -57, -60,
-62, -64, -67, -69, -71, -73, -76, -78, -80, -82, -84, -86, -89, -91, -93, -94,
-96, -98, -101, -101, -103, -104, -106, -106, -108, -109, -109, -110, -110,
-111, -111, -111, -111, -112, -111, -110, -109, -108, -107, -106, -104, -104,
-101, -98, -97, -95, -92, -90, -87, -84, -80, -77, -75, -70, -67, -63, -59, -55,
-51, -46, -43, -38, -34, -29, -24, -19, -15, -11, -5, -1, };