#define DATA_LENGTH 512
#define DATA AKWF_1927

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 14, 18, 22, 26, 30, 34, 38,
42, 46, 51, 53, 58, 62, 66, 69, 69, 69, 70, 70, 71, 71, 72, 72, 72, 73, 73, 74,
75, 75, 75, 76, 77, 76, 77, 77, 78, 78, 78, 80, 79, 81, 80, 81, 81, 81, 83, 83,
84, 83, 85, 85, 85, 86, 87, 87, 87, 88, 88, 88, 90, 89, 88, 87, 84, 84, 82, 81,
79, 78, 75, 75, 73, 72, 70, 68, 67, 65, 64, 63, 62, 60, 58, 56, 55, 53, 52, 51,
49, 47, 46, 44, 44, 42, 40, 39, 38, 35, 34, 33, 31, 30, 27, 27, 25, 23, 22, 20,
20, 21, 22, 22, 22, 24, 25, 26, 25, 27, 27, 29, 29, 30, 31, 30, 32, 32, 34, 34,
35, 36, 37, 37, 37, 39, 39, 40, 41, 41, 42, 43, 43, 43, 45, 46, 47, 47, 48, 48,
50, 50, 51, 51, 52, 53, 53, 52, 51, 49, 48, 46, 45, 44, 42, 40, 39, 37, 37, 35,
34, 32, 31, 30, 28, 26, 25, 23, 22, 20, 19, 18, 15, 15, 13, 12, 11, 9, 7, 6, 5,
3, 2, 0, -1, -3, -4, -5, -6, -8, -10, -11, -13, -15, -15, -16, -18, -19, -20,
-22, -23, -24, -24, -27, -28, -29, -30, -32, -33, -33, -35, -36, -38, -39, -40,
-41, -43, -44, -45, -47, -47, -48, -49, -50, -52, -53, -54, -56, -57, -58, -60,
-60, -62, -63, -64, -65, -66, -68, -70, -71, -67, -64, -60, -57, -54, -51, -48,
-44, -41, -37, -35, -31, -28, -24, -21, -18, -15, -10, -8, -4, -2, 2, 5, 9, 12,
16, 19, 22, 25, 28, 31, 35, 38, 42, 46, 48, 51, 55, 58, 61, 65, 68, 71, 75, 78,
82, 82, 80, 79, 75, 75, 71, 71, 68, 67, 64, 62, 60, 59, 57, 54, 52, 50, 48, 46,
45, 42, 40, 39, 37, 35, 33, 30, 29, 26, 25, 23, 21, 19, 16, 15, 13, 10, 9, 7, 4,
3, 1, -1, -3, -5, -7, -9, -10, -10, -12, -13, -13, -13, -14, -15, -15, -16, -18,
-18, -18, -20, -21, -22, -22, -23, -24, -25, -24, -26, -26, -27, -28, -28, -30,
-30, -31, -32, -32, -33, -34, -35, -36, -36, -37, -38, -39, -39, -40, -41, -41,
-42, -43, -44, -44, -44, -44, -44, -44, -44, -44, -43, -44, -43, -43, -43, -44,
-43, -43, -43, -43, -44, -43, -43, -42, -42, -42, -42, -42, -43, -43, -42, -42,
-42, -42, -41, -41, -41, -42, -42, -41, -41, -41, -40, -41, -41, -41, -41, -41,
-40, -41, -42, -44, -45, -48, -49, -51, -53, -54, -56, -57, -60, -61, -63, -64,
-66, -68, -70, -71, -73, -75, -76, -78, -80, -82, -83, -85, -86, -88, -90, -91,
-94, -96, -97, -99, -100, -102, -104, -105, -107, -109, -110, -112, -113, -116,
-117, -119, -119, -115, -110, -106, -102, -98, -94, -90, -85, -83, -78, -75,
-70, -67, -61, -58, -54, -50, -46, -41, -37, -33, -30, -26, -22, -17, -13, -9,
-6, -1, };