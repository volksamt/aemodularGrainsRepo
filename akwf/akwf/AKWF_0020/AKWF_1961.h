#define DATA_LENGTH 512
#define DATA AKWF_1961

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 1, 2, 1, 2, 2, 2, 3, 3, 3, 3,
3, 2, 2, 3, 3, 2, 2, 3, 4, 4, 3, 3, 3, 4, 4, 3, 4, 4, 6, 5, 6, 5, 7, 7, 8, 7, 8,
8, 9, 10, 11, 10, 11, 12, 12, 13, 14, 14, 14, 15, 15, 16, 17, 17, 18, 18, 19,
19, 20, 21, 21, 22, 23, 23, 24, 24, 25, 26, 27, 27, 29, 30, 31, 32, 33, 34, 35,
37, 37, 38, 39, 40, 42, 42, 44, 45, 46, 48, 49, 50, 51, 52, 54, 54, 55, 57, 57,
59, 59, 62, 62, 64, 65, 66, 68, 68, 70, 72, 72, 75, 76, 78, 79, 80, 82, 84, 86,
88, 89, 92, 93, 95, 96, 99, 101, 102, 104, 106, 108, 110, 111, 112, 113, 114,
116, 117, 118, 118, 119, 119, 119, 118, 119, 118, 117, 116, 116, 114, 113, 112,
111, 108, 106, 104, 102, 100, 98, 96, 93, 91, 90, 87, 85, 83, 80, 78, 76, 75,
72, 71, 69, 66, 66, 64, 62, 61, 59, 58, 57, 56, 55, 53, 52, 51, 50, 49, 48, 47,
45, 45, 44, 43, 42, 41, 40, 38, 38, 38, 36, 34, 34, 32, 32, 30, 30, 28, 27, 27,
25, 24, 24, 22, 22, 21, 20, 19, 19, 18, 18, 17, 16, 15, 15, 15, 14, 13, 13, 11,
11, 12, 10, 11, 10, 9, 9, 8, 8, 8, 7, 6, 6, 6, 5, 5, 4, 4, 3, 3, 3, 2, 1, 1, 1,
0, 0, -1, 0, -1, -1, -1, -1, -2, -2, -1, -1, -2, -2, -2, -2, -2, -2, -2, -3, -2,
-3, -4, -4, -3, -4, -4, -4, -4, -3, -5, -5, -5, -6, -5, -6, -7, -7, -8, -7, -8,
-8, -9, -9, -10, -10, -12, -12, -12, -12, -12, -13, -13, -15, -16, -15, -17,
-17, -17, -18, -18, -19, -20, -20, -21, -21, -22, -22, -24, -24, -24, -26, -26,
-27, -29, -29, -30, -31, -32, -33, -33, -35, -35, -37, -38, -39, -40, -42, -42,
-44, -45, -46, -48, -50, -50, -51, -52, -53, -55, -56, -58, -58, -59, -60, -62,
-63, -64, -65, -66, -68, -69, -70, -71, -73, -74, -76, -78, -79, -81, -83, -85,
-85, -88, -90, -92, -93, -95, -97, -99, -101, -102, -104, -105, -107, -110,
-111, -112, -114, -115, -116, -117, -118, -118, -119, -118, -119, -119, -119,
-118, -117, -116, -116, -115, -114, -112, -111, -108, -107, -104, -102, -100,
-99, -96, -94, -91, -90, -87, -85, -83, -80, -78, -77, -74, -73, -71, -69, -67,
-65, -64, -62, -60, -59, -59, -56, -56, -54, -53, -52, -51, -50, -49, -49, -47,
-46, -45, -44, -43, -41, -41, -39, -38, -37, -38, -35, -34, -34, -33, -31, -30,
-30, -28, -27, -27, -25, -24, -24, -23, -22, -21, -20, -20, -19, -17, -17, -17,
-16, -16, -15, -14, -14, -13, -13, -12, -12, -11, -10, -10, -10, -9, -9, -8, -7,
-7, -5, -6, -6, -4, -4, -4, -3, -3, -2, -2, -2, -1, 0, };