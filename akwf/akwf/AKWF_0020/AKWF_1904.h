#define DATA_LENGTH 512
#define DATA AKWF_1904

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 2, 3, 4, 4, 4, 5, 5, 6, 6, 6,
7, 7, 8, 8, 9, 10, 11, 11, 13, 13, 14, 15, 16, 17, 18, 20, 20, 22, 23, 24, 25,
26, 27, 28, 29, 29, 30, 32, 33, 34, 35, 36, 37, 38, 38, 40, 41, 41, 42, 43, 43,
46, 46, 46, 48, 48, 50, 51, 52, 54, 54, 55, 56, 56, 57, 58, 60, 61, 62, 62, 63,
64, 66, 67, 68, 68, 69, 70, 71, 72, 74, 75, 75, 76, 77, 78, 79, 79, 81, 82, 83,
84, 84, 86, 86, 88, 88, 90, 90, 91, 91, 92, 94, 95, 96, 97, 97, 99, 100, 101,
101, 104, 104, 104, 106, 108, 108, 110, 112, 112, 113, 114, 115, 116, 117, 117,
117, 118, 118, 118, 119, 118, 118, 118, 117, 117, 116, 117, 116, 116, 115, 114,
113, 112, 112, 110, 109, 108, 107, 106, 105, 104, 103, 101, 100, 99, 99, 97, 96,
94, 93, 93, 92, 91, 90, 89, 88, 87, 86, 85, 84, 83, 83, 81, 81, 79, 78, 77, 76,
76, 74, 74, 73, 73, 71, 70, 69, 68, 67, 65, 65, 64, 63, 62, 61, 60, 60, 58, 58,
56, 55, 53, 53, 52, 51, 50, 48, 48, 47, 46, 45, 45, 44, 42, 41, 40, 39, 38, 37,
37, 36, 34, 34, 32, 32, 30, 30, 29, 27, 26, 26, 24, 23, 23, 21, 21, 20, 19, 18,
17, 16, 14, 14, 14, 12, 11, 10, 9, 8, 7, 7, 5, 4, 4, 3, 0, 0, -1, -1, -2, -4,
-5, -6, -6, -7, -8, -9, -10, -11, -12, -14, -15, -16, -15, -17, -18, -19, -20,
-20, -22, -23, -25, -25, -27, -27, -28, -28, -30, -31, -32, -33, -33, -35, -35,
-36, -37, -39, -40, -41, -42, -42, -44, -44, -45, -46, -47, -48, -49, -50, -51,
-52, -53, -54, -55, -56, -57, -58, -59, -60, -61, -62, -63, -64, -64, -66, -66,
-68, -68, -70, -71, -71, -73, -73, -75, -75, -76, -77, -78, -78, -79, -81, -82,
-83, -84, -85, -85, -86, -87, -88, -90, -91, -91, -92, -93, -95, -95, -96, -97,
-98, -98, -100, -101, -102, -103, -104, -105, -107, -107, -109, -110, -111,
-111, -113, -114, -115, -115, -116, -117, -118, -118, -118, -118, -119, -119,
-118, -118, -118, -118, -117, -117, -116, -116, -115, -114, -112, -112, -111,
-110, -109, -108, -107, -106, -106, -104, -103, -102, -101, -100, -99, -98, -97,
-96, -95, -94, -92, -92, -90, -89, -89, -88, -86, -86, -85, -84, -83, -82, -81,
-80, -78, -78, -77, -76, -75, -73, -73, -71, -71, -70, -69, -68, -67, -67, -65,
-65, -63, -62, -61, -61, -59, -58, -57, -56, -55, -54, -53, -53, -52, -50, -50,
-48, -47, -46, -46, -45, -43, -42, -41, -40, -39, -39, -38, -36, -36, -36, -33,
-32, -31, -30, -29, -28, -27, -27, -26, -26, -25, -23, -22, -21, -20, -20, -19,
-17, -16, -16, -14, -13, -12, -11, -10, -8, -8, -7, -7, -5, -4, -3, -2, -1, 0,
};