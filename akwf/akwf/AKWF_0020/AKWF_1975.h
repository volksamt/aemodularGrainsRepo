#define DATA_LENGTH 512
#define DATA AKWF_1975

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 11, 21, 30, 40, 49, 59, 68, 70, 73,
75, 78, 81, 84, 87, 89, 93, 95, 97, 101, 104, 107, 109, 112, 114, 117, 118, 117,
114, 111, 109, 108, 105, 102, 100, 97, 95, 93, 90, 88, 85, 83, 81, 79, 76, 74,
73, 73, 71, 70, 68, 69, 67, 66, 65, 65, 64, 62, 61, 60, 60, 59, 57, 57, 56, 54,
52, 50, 49, 48, 45, 43, 42, 40, 38, 37, 35, 33, 31, 30, 29, 26, 25, 24, 21, 21,
20, 19, 18, 16, 15, 15, 13, 12, 11, 9, 8, 8, 6, 6, 4, 3, 2, 2, 2, 2, 2, 2, 2, 2,
1, 2, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 1,
0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 1, 0, 0, 0, -1, 0, 0, 1, 0,
0, 1, 0, 0, 0, 0, 1, -1, -1, 1, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 1, 0, 1, 0, 0, 1,
0, 0, 0, 1, -1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, -1, 0, -1, 1, -1, 0, 0, 0,
1, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, -1,
0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 1, -1, 0, -1, 0,
0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 1, -1, 1, 0,
1, 0, 1, 0, 0, 0, 0, -1, 0, 1, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 1, 1, 1, 0, 0, -1,
0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0,
0, 0, 0, 0, 0, 1, -1, 0, -1, 0, 0, 0, 0, 0, -1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0,
0, -1, -1, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, 1,
0, 0, 0, 0, 0, -1, 1, 1, 0, 1, 1, -1, 0, 1, 1, 1, 0, 0, 0, 0, -1, -1, 0, -1, -2,
-1, -1, -1, -2, -2, -1, -2, -2, -2, -2, -3, -4, -5, -6, -7, -8, -9, -10, -11,
-11, -13, -14, -15, -17, -18, -18, -20, -20, -21, -23, -26, -27, -29, -30, -32,
-34, -35, -37, -39, -41, -43, -45, -46, -48, -50, -52, -53, -55, -56, -57, -57,
-58, -59, -60, -61, -62, -63, -64, -65, -66, -67, -68, -68, -70, -71, -71, -72,
-75, -77, -80, -82, -84, -87, -89, -92, -94, -97, -99, -101, -104, -106, -109,
-111, -113, -117, -115, -104, -95, -85, -76, -66, -56, -47, -37, -27, -18, -8,
};