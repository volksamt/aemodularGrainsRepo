#define DATA_LENGTH 512
#define DATA AKWF_1910

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 11, 16, 22, 27, 32, 38, 42, 48,
52, 58, 61, 65, 69, 73, 77, 80, 82, 86, 89, 91, 93, 97, 98, 101, 102, 104, 106,
108, 109, 110, 111, 112, 114, 115, 116, 117, 118, 118, 118, 119, 119, 119, 120,
119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 118, 120, 119, 119, 118, 118,
118, 117, 117, 117, 116, 117, 116, 116, 115, 116, 116, 115, 115, 115, 115, 116,
115, 116, 114, 114, 114, 115, 114, 115, 115, 115, 116, 116, 116, 115, 115, 115,
115, 115, 115, 116, 115, 115, 115, 116, 116, 115, 116, 116, 115, 115, 116, 115,
116, 116, 116, 116, 115, 116, 115, 116, 115, 115, 115, 114, 116, 114, 114, 115,
116, 115, 115, 114, 115, 115, 115, 115, 114, 114, 114, 115, 115, 115, 115, 114,
114, 114, 115, 114, 115, 115, 115, 115, 114, 115, 115, 115, 115, 115, 115, 115,
114, 115, 115, 115, 115, 115, 115, 116, 115, 116, 115, 115, 116, 116, 115, 115,
116, 115, 115, 116, 115, 116, 116, 116, 117, 117, 116, 117, 118, 116, 117, 117,
117, 117, 116, 114, 114, 112, 111, 110, 107, 105, 102, 99, 95, 92, 88, 83, 79,
73, 67, 62, 56, 48, 42, 35, 29, 22, 15, 8, 1, -7, -13, -20, -26, -33, -39, -45,
-50, -56, -60, -65, -69, -73, -76, -78, -81, -83, -85, -85, -84, -84, -84, -84,
-85, -84, -85, -84, -84, -84, -85, -84, -85, -85, -84, -84, -84, -84, -83, -82,
-81, -82, -82, -82, -82, -81, -81, -82, -81, -81, -80, -82, -81, -82, -81, -81,
-81, -82, -82, -81, -81, -82, -82, -82, -81, -82, -81, -82, -82, -82, -81, -81,
-81, -81, -81, -81, -81, -82, -82, -80, -80, -81, -81, -81, -81, -81, -81, -81,
-81, -81, -81, -82, -80, -81, -81, -81, -81, -81, -81, -82, -81, -81, -80, -82,
-81, -81, -81, -81, -81, -81, -81, -81, -81, -81, -81, -81, -81, -81, -81, -81,
-82, -80, -81, -80, -80, -81, -81, -81, -80, -81, -81, -80, -80, -81, -81, -81,
-80, -82, -80, -81, -80, -81, -81, -81, -81, -80, -81, -80, -80, -80, -80, -80,
-81, -81, -80, -81, -81, -80, -80, -80, -80, -81, -80, -80, -80, -81, -80, -80,
-81, -80, -80, -81, -80, -80, -80, -80, -80, -81, -81, -80, -80, -81, -80, -80,
-79, -80, -80, -80, -81, -80, -80, -80, -81, -79, -80, -79, -80, -80, -80, -80,
-79, -80, -80, -80, -81, -80, -79, -80, -80, -80, -80, -80, -80, -79, -80, -79,
-79, -80, -79, -79, -79, -79, -79, -79, -80, -79, -79, -79, -80, -80, -80, -80,
-80, -81, -80, -80, -80, -80, -80, -80, -81, -80, -81, -80, -80, -81, -80, -80,
-80, -80, -80, -81, -81, -80, -81, -80, -81, -81, -80, -81, -81, -81, -81, -81,
-81, -80, -81, -81, -81, -80, -80, -79, -77, -77, -76, -75, -73, -71, -68, -67,
-64, -61, -58, -55, -51, -48, -43, -39, -34, -30, -25, -20, -15, -9, -4, };