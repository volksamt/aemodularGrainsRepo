#define DATA_LENGTH 512
#define DATA AKWF_2004

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 6, 8, 11, 13, 15, 17, 19, 21,
22, 25, 26, 28, 30, 32, 34, 35, 37, 39, 40, 43, 45, 46, 48, 49, 52, 54, 55, 57,
59, 61, 62, 63, 65, 66, 68, 70, 72, 73, 75, 75, 78, 79, 80, 83, 84, 85, 87, 89,
91, 93, 93, 95, 96, 98, 100, 101, 103, 103, 105, 106, 107, 108, 109, 110, 111,
112, 114, 114, 115, 116, 117, 117, 118, 118, 118, 118, 119, 119, 119, 119, 118,
118, 119, 118, 117, 117, 117, 115, 115, 114, 113, 111, 110, 108, 107, 105, 104,
102, 99, 98, 96, 93, 90, 88, 86, 84, 82, 79, 76, 74, 71, 68, 66, 62, 59, 57, 55,
51, 48, 46, 42, 39, 37, 35, 32, 29, 26, 24, 20, 19, 16, 13, 10, 9, 6, 5, 2, 1,
-2, -3, -6, -6, -9, -11, -11, -13, -14, -15, -17, -19, -19, -20, -21, -22, -22,
-25, -25, -25, -26, -27, -27, -28, -28, -29, -29, -29, -29, -29, -30, -31, -30,
-30, -31, -31, -31, -31, -32, -30, -31, -31, -31, -31, -31, -31, -31, -32, -30,
-31, -32, -31, -31, -31, -31, -31, -31, -31, -31, -31, -32, -31, -31, -31, -31,
-30, -30, -31, -29, -30, -30, -30, -30, -30, -29, -29, -29, -28, -28, -28, -28,
-27, -28, -28, -27, -26, -27, -27, -27, -26, -26, -26, -25, -26, -26, -26, -25,
-25, -25, -25, -24, -24, -25, -24, -24, -24, -24, -24, -25, -24, -24, -24, -24,
-24, -24, -25, -25, -25, -26, -25, -26, -25, -26, -26, -26, -26, -27, -27, -27,
-26, -27, -27, -28, -27, -27, -28, -27, -27, -27, -26, -27, -27, -26, -26, -25,
-26, -25, -25, -24, -23, -22, -21, -21, -20, -19, -17, -17, -16, -15, -13, -13,
-11, -9, -8, -6, -5, -3, -2, 0, 2, 4, 6, 7, 9, 11, 13, 14, 17, 19, 20, 22, 24,
25, 27, 30, 31, 33, 35, 36, 38, 40, 41, 42, 43, 45, 47, 47, 48, 49, 50, 52, 52,
52, 53, 54, 54, 54, 54, 54, 53, 54, 52, 52, 52, 53, 52, 50, 50, 49, 47, 47, 46,
45, 43, 42, 41, 40, 38, 36, 34, 33, 31, 29, 27, 26, 23, 22, 20, 18, 16, 14, 11,
9, 7, 5, 3, 1, -2, -3, -6, -9, -11, -13, -15, -18, -19, -21, -24, -26, -29, -30,
-33, -35, -37, -40, -42, -44, -47, -49, -52, -54, -55, -58, -61, -63, -66, -68,
-70, -73, -75, -78, -79, -82, -84, -87, -88, -91, -92, -94, -96, -98, -99, -101,
-102, -104, -105, -106, -108, -108, -110, -111, -113, -113, -113, -114, -114,
-115, -115, -115, -115, -114, -114, -114, -114, -114, -114, -112, -111, -110,
-109, -109, -108, -106, -105, -103, -101, -101, -98, -96, -95, -93, -91, -89,
-87, -85, -82, -81, -78, -76, -74, -71, -69, -66, -64, -61, -59, -56, -54, -51,
-49, -46, -43, -42, -39, -37, -34, -32, -29, -27, -25, -22, -20, -19, -16, -14,
-12, -10, -8, -5, -4, -1, };