#define DATA_LENGTH 512
#define DATA AKWF_1997

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 7, 9, 10, 13, 15, 17, 19, 22,
25, 26, 29, 30, 33, 36, 38, 40, 42, 44, 46, 49, 51, 54, 55, 58, 60, 63, 65, 67,
69, 71, 73, 76, 78, 80, 83, 84, 86, 89, 91, 93, 96, 99, 99, 99, 100, 100, 100,
100, 100, 100, 100, 100, 101, 101, 101, 101, 101, 101, 102, 102, 102, 101, 101,
102, 102, 101, 102, 101, 103, 102, 101, 102, 102, 102, 102, 102, 102, 103, 104,
102, 100, 99, 96, 95, 93, 91, 89, 89, 87, 84, 83, 81, 79, 78, 76, 74, 72, 71,
69, 68, 65, 64, 62, 61, 58, 58, 56, 54, 52, 51, 48, 47, 45, 44, 42, 40, 40, 39,
38, 38, 37, 36, 35, 34, 34, 33, 33, 32, 32, 31, 30, 29, 28, 27, 27, 27, 26, 25,
24, 24, 23, 22, 22, 21, 21, 19, 18, 18, 18, 16, 16, 15, 15, 15, 17, 17, 18, 19,
19, 19, 21, 21, 22, 22, 23, 24, 24, 24, 26, 27, 26, 27, 27, 29, 30, 29, 31, 31,
31, 32, 32, 33, 34, 35, 35, 36, 36, 37, 38, 38, 39, 40, 40, 41, 41, 41, 43, 44,
43, 44, 45, 45, 46, 47, 47, 47, 49, 49, 49, 50, 51, 51, 52, 52, 53, 54, 55, 54,
56, 56, 57, 57, 58, 58, 59, 59, 59, 59, 58, 58, 56, 56, 56, 56, 54, 54, 54, 54,
54, 53, 51, 52, 51, 51, 51, 50, 50, 49, 49, 48, 48, 48, 48, 46, 46, 45, 45, 44,
44, 43, 43, 42, 41, 40, 38, 38, 37, 35, 34, 33, 32, 30, 30, 28, 28, 26, 25, 22,
22, 21, 19, 18, 17, 16, 15, 14, 12, 11, 9, 9, 8, 7, 4, 3, 2, 1, 0, -1, -3, -5,
-5, -7, -8, -9, -10, -11, -13, -14, -15, -17, -18, -20, -21, -22, -23, -24, -26,
-27, -27, -29, -31, -32, -34, -35, -35, -37, -39, -40, -41, -43, -44, -45, -46,
-47, -49, -51, -51, -52, -53, -53, -54, -55, -56, -57, -58, -58, -59, -60, -60,
-61, -63, -63, -64, -65, -66, -67, -67, -69, -70, -70, -72, -72, -73, -73, -75,
-76, -76, -77, -78, -79, -80, -80, -81, -82, -83, -83, -84, -85, -85, -86, -87,
-87, -87, -88, -89, -89, -90, -91, -93, -92, -93, -94, -95, -95, -96, -96, -97,
-97, -98, -99, -100, -101, -101, -102, -102, -103, -104, -104, -104, -105, -106,
-106, -106, -107, -107, -107, -108, -108, -109, -109, -109, -111, -110, -112,
-111, -112, -112, -112, -112, -113, -114, -113, -114, -115, -115, -115, -117,
-116, -116, -118, -118, -118, -118, -119, -119, -118, -116, -115, -113, -110,
-109, -107, -106, -104, -103, -101, -100, -97, -97, -94, -93, -92, -89, -88,
-86, -85, -83, -81, -81, -79, -76, -76, -74, -72, -71, -69, -68, -65, -64, -62,
-61, -58, -56, -55, -53, -50, -49, -46, -45, -42, -40, -38, -35, -34, -30, -30,
-27, -25, -22, -20, -19, -17, -14, -12, -10, -8, -6, -4, -1, };