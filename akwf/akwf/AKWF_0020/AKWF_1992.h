#define DATA_LENGTH 512
#define DATA AKWF_1992

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 5, 6, 7, 11, 11, 13, 15, 16, 18,
19, 21, 22, 22, 21, 21, 20, 20, 19, 20, 19, 19, 19, 18, 18, 17, 17, 17, 16, 16,
15, 15, 16, 15, 15, 13, 14, 13, 13, 12, 12, 12, 12, 11, 12, 10, 11, 10, 9, 10,
10, 10, 10, 11, 10, 11, 10, 11, 11, 11, 12, 11, 12, 12, 12, 13, 13, 13, 14, 13,
14, 13, 13, 13, 14, 15, 14, 14, 15, 15, 15, 15, 16, 16, 16, 16, 16, 16, 15, 15,
15, 15, 16, 15, 14, 14, 14, 14, 14, 14, 14, 14, 14, 13, 14, 13, 13, 13, 12, 13,
13, 13, 12, 13, 13, 12, 11, 12, 11, 12, 12, 12, 11, 12, 12, 13, 12, 13, 13, 12,
12, 13, 13, 13, 13, 13, 12, 13, 13, 13, 14, 14, 14, 13, 14, 13, 14, 14, 14, 15,
14, 14, 15, 15, 14, 15, 15, 14, 15, 15, 15, 14, 14, 14, 14, 13, 14, 14, 14, 14,
13, 13, 13, 14, 13, 13, 13, 13, 13, 13, 13, 13, 12, 13, 12, 12, 12, 11, 13, 12,
12, 12, 11, 11, 11, 11, 11, 12, 12, 12, 13, 12, 12, 12, 12, 13, 13, 12, 13, 13,
14, 13, 13, 13, 13, 14, 14, 14, 14, 15, 15, 15, 15, 15, 15, 16, 15, 16, 15, 15,
16, 16, 15, 15, 15, 15, 15, 15, 14, 14, 14, 14, 14, 13, 13, 13, 13, 13, 13, 12,
12, 13, 13, 12, 11, 12, 12, 11, 11, 11, 11, 11, 10, 10, 11, 9, 10, 10, 10, 10,
11, 11, 10, 11, 11, 11, 12, 11, 12, 12, 13, 13, 12, 13, 13, 13, 14, 14, 15, 14,
15, 15, 15, 15, 15, 16, 16, 16, 16, 17, 16, 16, 17, 17, 17, 16, 18, 17, 16, 16,
15, 15, 16, 14, 14, 15, 15, 14, 13, 13, 14, 13, 12, 12, 12, 11, 12, 11, 12, 11,
11, 10, 10, 10, 10, 9, 9, 9, 8, 8, 8, 8, 8, 9, 8, 9, 9, 9, 9, 10, 9, 10, 11, 10,
10, 10, 11, 12, 13, 12, 13, 12, 13, 13, 14, 13, 14, 15, 14, 14, 15, 14, 15, 15,
16, 16, 17, 16, 16, 16, 16, 15, 14, 14, 15, 14, 14, 13, 14, 13, 13, 12, 12, 12,
12, 12, 12, 11, 11, 11, 11, 10, 9, 10, 9, 8, 9, 8, 8, 9, 8, 8, 7, 8, 6, 3, -1,
-5, -8, -12, -15, -18, -22, -26, -28, -32, -35, -39, -42, -46, -50, -53, -57,
-60, -64, -67, -70, -74, -77, -81, -84, -88, -91, -94, -98, -102, -105, -108,
-112, -115, -119, -117, -115, -114, -110, -109, -105, -104, -102, -99, -98, -95,
-93, -91, -89, -86, -85, -82, -80, -77, -75, -73, -71, -69, -67, -65, -63, -59,
-58, -56, -53, -51, -49, -47, -45, -42, -40, -38, -37, -35, -33, -31, -30, -28,
-26, -25, -23, -22, -20, -18, -16, -15, -14, -11, -10, -8, -7, -5, -3, -1, -1,
};