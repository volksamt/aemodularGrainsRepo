#define DATA_LENGTH 512
#define DATA AKWF_1913

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 13, 17, 24, 29, 34, 39, 43, 48,
52, 57, 61, 66, 69, 73, 76, 80, 83, 86, 89, 91, 93, 97, 98, 100, 102, 104, 106,
107, 108, 110, 111, 112, 114, 114, 116, 116, 117, 118, 118, 119, 118, 119, 119,
119, 118, 118, 119, 119, 118, 118, 119, 118, 119, 119, 118, 118, 118, 118, 118,
117, 118, 117, 116, 117, 117, 115, 116, 116, 115, 114, 114, 115, 114, 114, 115,
115, 114, 114, 114, 115, 115, 115, 115, 115, 115, 115, 115, 115, 115, 115, 115,
115, 115, 116, 115, 115, 115, 116, 115, 115, 115, 115, 115, 115, 115, 115, 115,
115, 115, 115, 115, 114, 114, 115, 115, 115, 115, 114, 114, 114, 114, 115, 114,
115, 115, 115, 115, 114, 114, 114, 113, 114, 114, 114, 113, 113, 113, 113, 114,
114, 114, 113, 114, 113, 115, 113, 114, 115, 115, 116, 116, 115, 116, 116, 117,
118, 117, 117, 117, 118, 118, 117, 117, 117, 117, 117, 118, 117, 118, 118, 117,
117, 117, 117, 116, 116, 115, 114, 113, 112, 111, 110, 108, 107, 105, 104, 102,
101, 98, 96, 93, 92, 89, 86, 82, 80, 76, 72, 69, 66, 62, 56, 52, 47, 42, 36, 31,
26, 21, 14, 8, 2, -3, -11, -16, -23, -27, -34, -39, -45, -50, -56, -60, -64,
-68, -71, -75, -79, -81, -81, -81, -82, -82, -81, -81, -81, -81, -81, -81, -81,
-80, -81, -81, -81, -81, -81, -81, -81, -81, -81, -81, -80, -79, -79, -78, -78,
-77, -77, -76, -76, -76, -76, -76, -76, -75, -75, -77, -76, -76, -76, -76, -77,
-76, -76, -77, -76, -77, -77, -77, -77, -78, -78, -77, -78, -78, -77, -77, -77,
-77, -77, -78, -77, -77, -78, -77, -77, -77, -78, -78, -78, -78, -77, -78, -77,
-77, -78, -78, -78, -77, -78, -78, -77, -78, -78, -78, -77, -78, -78, -78, -77,
-77, -77, -77, -77, -77, -77, -77, -77, -78, -77, -77, -77, -78, -77, -76, -77,
-76, -77, -77, -77, -77, -77, -77, -78, -77, -77, -76, -77, -77, -76, -77, -78,
-77, -77, -76, -76, -77, -77, -76, -78, -78, -76, -77, -76, -77, -77, -77, -77,
-77, -77, -76, -76, -76, -77, -77, -76, -77, -76, -77, -76, -76, -77, -77, -76,
-77, -76, -76, -77, -76, -76, -77, -77, -77, -77, -76, -76, -76, -77, -76, -76,
-76, -77, -76, -76, -76, -77, -76, -77, -77, -77, -76, -76, -77, -77, -76, -76,
-76, -76, -77, -76, -77, -76, -77, -76, -76, -76, -75, -76, -75, -76, -76, -76,
-76, -76, -75, -76, -76, -75, -76, -76, -76, -76, -77, -76, -76, -76, -76, -76,
-77, -76, -77, -76, -76, -76, -77, -76, -77, -77, -77, -77, -76, -77, -77, -77,
-77, -76, -77, -76, -76, -77, -76, -77, -77, -77, -77, -77, -77, -77, -77, -76,
-77, -76, -77, -77, -76, -76, -76, -74, -74, -72, -70, -70, -68, -66, -63, -61,
-58, -56, -52, -49, -45, -42, -37, -33, -28, -22, -18, -13, -8, -2, };