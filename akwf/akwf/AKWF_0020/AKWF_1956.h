#define DATA_LENGTH 512
#define DATA AKWF_1956

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 17, 27, 37, 47, 57, 67, 75, 82, 90,
96, 102, 106, 111, 113, 117, 118, 118, 119, 119, 117, 116, 115, 112, 110, 106,
103, 100, 97, 95, 91, 88, 86, 83, 80, 78, 75, 74, 73, 71, 71, 70, 68, 68, 67,
67, 66, 66, 66, 66, 64, 65, 64, 63, 62, 61, 59, 60, 58, 56, 54, 53, 52, 49, 48,
46, 44, 41, 40, 39, 36, 35, 33, 32, 30, 29, 27, 27, 26, 23, 22, 21, 21, 20, 20,
17, 16, 16, 14, 14, 12, 12, 11, 9, 9, 8, 7, 5, 5, 3, 3, 1, 0, 0, -1, -1, -1, -2,
-3, -3, -3, -3, -2, -3, -3, -2, -2, -1, -1, 0, 0, 1, 2, 2, 2, 2, 2, 2, 3, 2, 2,
3, 2, 2, 2, 1, 1, 0, 0, -1, 0, -1, -1, -2, -3, -2, -2, -3, -2, -2, -2, -2, -2,
-1, -1, -1, -1, 0, 0, 0, 2, 1, 1, 3, 2, 3, 2, 2, 3, 2, 2, 2, 2, 1, 1, 1, 0, 0,
-2, -1, -1, -2, -3, -2, -2, -3, -2, -3, -2, -2, -2, -1, -2, -1, 0, 0, 1, 1, 0,
1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 0, 1, 0, 0, -1, -1, -1, -1, -1, -2, -2, -2,
-2, -3, -2, -2, -2, -1, -2, -2, -1, -1, 1, 1, 0, 1, 1, 2, 2, 2, 1, 2, 2, 2, 2,
2, 1, 1, 1, 1, 1, -1, -1, 0, -1, -2, -2, -1, -2, -2, -2, -2, -2, -2, -2, -2, -1,
-1, 0, -1, 0, 0, 1, 1, 1, 2, 2, 2, 3, 2, 3, 3, 2, 2, 2, 1, 1, 0, 1, 1, -1, -2,
-1, -1, -2, -2, -3, -2, -2, -3, -3, -2, -2, -2, -1, -1, 0, 0, 0, 0, 0, 2, 1, 2,
2, 3, 2, 2, 3, 3, 2, 2, 2, 2, 1, 2, 1, -1, 0, -1, -1, -1, -2, -2, -3, -3, -2,
-3, -2, -2, -2, -2, -2, -1, -1, 0, 0, 1, 1, 1, 2, 2, 3, 3, 2, 4, 3, 3, 3, 2, 2,
2, 1, 0, 1, -1, -1, -2, -2, -3, -2, -3, -4, -4, -4, -4, -4, -3, -3, -2, -2, -1,
-1, 0, 1, 0, 1, 3, 2, 3, 4, 5, 4, 5, 3, 4, 4, 4, 4, 3, 1, 1, 1, 0, 0, -2, -2,
-3, -4, -4, -4, -5, -5, -4, -5, -5, -4, -4, -4, -3, -3, -2, -1, -1, 0, -1, -1,
0, 0, -1, -1, -1, -3, -4, -5, -7, -9, -11, -13, -15, -19, -21, -24, -27, -29,
-31, -34, -37, -39, -41, -44, -44, -46, -48, -49, -49, -50, -49, -50, -50, -49,
-48, -48, -47, -47, -47, -46, -45, -45, -46, -47, -48, -49, -50, -52, -54, -57,
-60, -64, -68, -71, -77, -80, -85, -89, -93, -97, -101, -105, -107, -110, -112,
-114, -113, -113, -113, -111, -108, -104, -100, -94, -88, -81, -72, -65, -55,
-46, -35, -25, -14, -3, };