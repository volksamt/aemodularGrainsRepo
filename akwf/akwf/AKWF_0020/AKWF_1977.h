#define DATA_LENGTH 512
#define DATA AKWF_1977

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 11, 14, 17, 20, 23, 27, 30, 33,
36, 39, 42, 45, 48, 51, 54, 58, 60, 63, 67, 69, 71, 72, 74, 75, 76, 78, 80, 81,
82, 84, 85, 87, 88, 90, 91, 92, 94, 95, 97, 96, 95, 94, 94, 93, 92, 90, 91, 89,
89, 88, 87, 86, 85, 84, 83, 83, 83, 81, 81, 80, 80, 80, 78, 78, 77, 77, 77, 76,
75, 74, 75, 74, 73, 73, 71, 71, 71, 72, 72, 73, 74, 74, 75, 76, 78, 78, 78, 80,
79, 82, 82, 83, 84, 84, 85, 86, 88, 88, 90, 92, 93, 95, 96, 98, 100, 101, 103,
105, 106, 107, 109, 110, 112, 114, 114, 114, 115, 116, 115, 116, 116, 117, 116,
117, 118, 117, 117, 117, 119, 119, 119, 119, 120, 118, 117, 115, 115, 113, 111,
110, 108, 107, 105, 104, 102, 101, 99, 98, 97, 95, 93, 92, 91, 89, 87, 85, 83,
82, 80, 78, 77, 75, 73, 71, 70, 69, 66, 64, 63, 61, 60, 59, 58, 59, 57, 57, 58,
58, 57, 57, 56, 56, 56, 56, 56, 55, 55, 55, 55, 54, 55, 56, 57, 58, 60, 60, 61,
62, 63, 65, 65, 66, 68, 69, 70, 71, 71, 72, 74, 75, 74, 75, 75, 75, 75, 75, 76,
76, 75, 76, 76, 77, 77, 77, 76, 77, 77, 78, 76, 74, 72, 69, 68, 66, 64, 61, 59,
56, 54, 53, 50, 48, 46, 44, 43, 40, 37, 36, 31, 28, 23, 20, 17, 14, 10, 7, 3,
-1, -4, -7, -12, -14, -18, -21, -26, -28, -30, -33, -36, -38, -40, -43, -45,
-48, -50, -53, -55, -57, -60, -62, -65, -67, -69, -72, -74, -75, -75, -76, -76,
-75, -76, -75, -75, -76, -76, -76, -76, -75, -76, -76, -75, -77, -76, -77, -76,
-75, -74, -72, -72, -71, -69, -69, -67, -66, -65, -64, -62, -62, -61, -60, -59,
-58, -57, -57, -56, -56, -57, -56, -56, -56, -56, -56, -57, -56, -56, -56, -57,
-56, -55, -56, -56, -57, -57, -59, -60, -63, -63, -65, -66, -69, -71, -72, -73,
-75, -76, -79, -80, -82, -83, -85, -86, -88, -90, -91, -93, -95, -95, -98, -99,
-101, -103, -104, -106, -108, -110, -110, -113, -114, -116, -116, -117, -117,
-118, -117, -117, -117, -117, -117, -117, -116, -117, -117, -117, -116, -117,
-118, -117, -117, -117, -116, -114, -112, -112, -110, -108, -106, -104, -103,
-103, -101, -99, -98, -97, -95, -93, -92, -90, -89, -89, -86, -86, -85, -84,
-83, -83, -81, -80, -79, -78, -78, -77, -75, -75, -74, -73, -72, -71, -71, -73,
-72, -72, -73, -74, -75, -74, -75, -75, -76, -77, -77, -77, -77, -79, -79, -79,
-80, -80, -81, -83, -83, -84, -85, -86, -86, -87, -88, -90, -89, -92, -92, -93,
-93, -95, -96, -96, -95, -93, -93, -92, -91, -90, -89, -88, -86, -86, -84, -84,
-82, -82, -81, -78, -78, -77, -75, -71, -66, -61, -57, -52, -47, -43, -38, -34,
-29, -25, -21, -16, -11, -7, -2, };