#define DATA_LENGTH 512
#define DATA AKWF_1988

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 10, 14, 17, 22, 25, 29, 32, 36,
41, 44, 47, 51, 53, 56, 58, 59, 61, 62, 64, 66, 68, 71, 72, 73, 76, 77, 79, 80,
83, 84, 86, 89, 90, 92, 94, 95, 97, 99, 101, 102, 105, 107, 109, 110, 112, 114,
115, 117, 119, 119, 118, 116, 115, 114, 114, 112, 112, 110, 110, 109, 107, 107,
106, 104, 104, 103, 102, 100, 100, 98, 98, 97, 96, 95, 93, 93, 91, 91, 90, 89,
88, 87, 86, 85, 83, 84, 83, 84, 85, 84, 84, 84, 84, 85, 86, 85, 85, 86, 86, 85,
86, 86, 87, 86, 87, 88, 87, 87, 87, 88, 89, 89, 90, 89, 89, 89, 90, 90, 90, 90,
90, 91, 92, 92, 93, 94, 94, 95, 95, 97, 97, 98, 99, 99, 99, 100, 102, 102, 102,
103, 104, 105, 105, 106, 107, 107, 107, 109, 109, 110, 110, 111, 112, 113, 113,
114, 114, 115, 116, 115, 115, 116, 115, 115, 114, 113, 113, 113, 113, 113, 112,
112, 112, 111, 111, 110, 109, 109, 109, 109, 108, 108, 108, 106, 107, 107, 106,
106, 104, 105, 105, 104, 103, 103, 103, 102, 102, 103, 102, 102, 102, 102, 101,
102, 101, 102, 101, 101, 101, 100, 101, 100, 101, 100, 100, 100, 99, 99, 99, 99,
100, 99, 99, 98, 98, 98, 99, 98, 98, 97, 98, 97, 93, 89, 87, 83, 79, 75, 72, 68,
64, 61, 57, 54, 50, 46, 43, 40, 36, 32, 29, 25, 21, 18, 14, 10, 7, 3, -1, -5,
-8, -12, -15, -19, -22, -26, -29, -33, -35, -37, -40, -42, -44, -46, -48, -50,
-52, -54, -56, -59, -60, -62, -64, -67, -69, -71, -73, -74, -77, -79, -81, -83,
-86, -87, -89, -91, -94, -96, -97, -99, -101, -103, -106, -107, -110, -109,
-109, -109, -109, -109, -109, -108, -109, -108, -109, -108, -107, -109, -108,
-108, -108, -107, -108, -107, -107, -107, -107, -106, -107, -106, -107, -106,
-106, -106, -105, -105, -105, -105, -105, -105, -104, -105, -104, -105, -106,
-106, -106, -107, -107, -107, -108, -108, -108, -108, -108, -109, -109, -109,
-110, -110, -111, -111, -111, -111, -112, -111, -112, -113, -113, -113, -113,
-113, -114, -113, -114, -115, -115, -115, -114, -113, -112, -110, -110, -108,
-108, -107, -105, -104, -103, -102, -100, -99, -98, -96, -95, -94, -93, -91,
-91, -90, -89, -87, -87, -85, -84, -82, -81, -81, -79, -78, -77, -76, -74, -74,
-72, -74, -76, -75, -77, -78, -79, -80, -80, -82, -83, -84, -86, -87, -88, -89,
-90, -91, -92, -92, -94, -95, -96, -98, -98, -100, -100, -102, -102, -103, -105,
-105, -106, -107, -110, -111, -110, -110, -110, -108, -108, -107, -107, -105,
-105, -104, -103, -103, -102, -100, -100, -98, -99, -97, -97, -96, -95, -95,
-93, -93, -91, -91, -90, -90, -90, -89, -87, -86, -86, -86, -83, -83, -82, -81,
-78, -74, -70, -66, -63, -60, -56, -51, -48, -44, -41, -38, -34, -30, -26, -23,
-19, -14, -11, -8, -3, 0, };