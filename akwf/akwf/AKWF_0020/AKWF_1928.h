#define DATA_LENGTH 512
#define DATA AKWF_1928

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 11, 16, 21, 24, 29, 34, 38, 42,
46, 49, 53, 56, 60, 63, 66, 68, 71, 73, 76, 77, 81, 81, 84, 85, 87, 89, 90, 92,
93, 94, 95, 96, 97, 96, 97, 98, 98, 99, 99, 98, 99, 99, 98, 99, 98, 97, 97, 97,
96, 96, 96, 94, 94, 93, 92, 91, 90, 89, 89, 88, 87, 85, 85, 84, 83, 81, 80, 78,
77, 76, 73, 73, 70, 69, 67, 65, 63, 61, 60, 58, 56, 53, 52, 50, 48, 46, 44, 42,
40, 40, 37, 36, 34, 33, 31, 30, 28, 28, 26, 25, 24, 23, 22, 21, 21, 20, 19, 19,
19, 19, 18, 18, 19, 19, 19, 20, 20, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 31,
31, 33, 34, 34, 36, 37, 40, 39, 42, 43, 43, 44, 45, 47, 47, 48, 48, 49, 50, 51,
52, 51, 51, 53, 52, 52, 52, 52, 50, 50, 50, 50, 49, 48, 48, 47, 46, 45, 44, 43,
41, 41, 39, 39, 36, 36, 34, 32, 30, 29, 28, 26, 25, 22, 20, 19, 18, 15, 14, 12,
10, 8, 5, 4, 2, 1, -1, -3, -5, -6, -9, -11, -13, -15, -16, -19, -20, -23, -25,
-27, -29, -31, -32, -35, -37, -40, -42, -44, -46, -47, -50, -52, -54, -55, -58,
-60, -60, -62, -64, -66, -67, -68, -69, -70, -71, -72, -73, -73, -74, -75, -75,
-74, -73, -73, -72, -72, -70, -70, -68, -67, -66, -64, -62, -60, -57, -55, -51,
-48, -45, -43, -39, -36, -31, -26, -23, -20, -16, -11, -7, -3, 1, 5, 10, 14, 19,
22, 27, 31, 35, 38, 42, 47, 50, 52, 56, 60, 63, 65, 68, 70, 72, 75, 75, 77, 78,
79, 80, 81, 82, 82, 82, 81, 82, 80, 80, 79, 78, 76, 74, 73, 72, 70, 68, 65, 62,
60, 58, 55, 53, 50, 47, 44, 42, 39, 36, 33, 30, 27, 24, 21, 20, 16, 13, 12, 9,
6, 2, 1, -1, -4, -6, -8, -9, -11, -13, -14, -17, -18, -19, -20, -23, -24, -24,
-26, -27, -28, -28, -30, -31, -32, -32, -34, -34, -35, -36, -37, -37, -38, -38,
-38, -38, -39, -40, -40, -41, -41, -40, -41, -42, -42, -41, -42, -42, -43, -42,
-42, -43, -42, -43, -42, -42, -43, -43, -42, -42, -41, -42, -41, -40, -40, -39,
-40, -39, -38, -38, -37, -38, -37, -36, -35, -35, -34, -34, -33, -33, -33, -33,
-32, -32, -31, -32, -31, -32, -32, -32, -32, -32, -32, -34, -33, -34, -35, -37,
-37, -38, -39, -41, -42, -43, -46, -48, -49, -51, -53, -55, -59, -60, -63, -65,
-68, -71, -73, -76, -78, -81, -84, -87, -90, -92, -95, -97, -99, -101, -105,
-106, -107, -110, -111, -113, -115, -115, -117, -118, -118, -119, -119, -119,
-119, -118, -118, -117, -117, -114, -114, -111, -109, -107, -105, -102, -99,
-95, -92, -89, -85, -82, -78, -74, -69, -64, -60, -56, -51, -47, -41, -37, -32,
-26, -22, -17, -12, -7, -2, };