#define DATA_LENGTH 512
#define DATA AKWF_2008

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 11, 15, 18, 21, 25, 28, 31,
34, 38, 41, 43, 47, 49, 52, 54, 57, 59, 62, 63, 65, 68, 70, 71, 74, 75, 77, 78,
81, 82, 84, 85, 86, 87, 89, 89, 91, 93, 93, 94, 95, 96, 96, 97, 99, 99, 99, 99,
100, 101, 102, 102, 103, 104, 104, 104, 104, 105, 105, 105, 105, 105, 107, 107,
108, 107, 108, 107, 108, 109, 108, 108, 108, 109, 108, 109, 107, 108, 108, 108,
107, 108, 108, 107, 107, 107, 106, 106, 106, 105, 105, 104, 104, 103, 104, 104,
102, 102, 102, 102, 101, 101, 100, 100, 100, 99, 98, 99, 98, 98, 98, 97, 96, 97,
96, 95, 95, 95, 95, 95, 95, 94, 94, 93, 94, 94, 93, 94, 94, 94, 93, 93, 93, 92,
93, 93, 93, 93, 92, 92, 93, 92, 92, 92, 92, 92, 93, 91, 92, 91, 91, 91, 90, 91,
91, 90, 89, 89, 89, 88, 88, 87, 87, 86, 85, 84, 84, 83, 82, 81, 80, 80, 78, 77,
76, 74, 74, 73, 72, 71, 70, 68, 66, 65, 64, 62, 61, 60, 59, 57, 56, 54, 52, 52,
50, 49, 47, 46, 44, 42, 41, 39, 39, 37, 35, 34, 32, 31, 30, 28, 28, 26, 25, 24,
22, 22, 21, 20, 18, 17, 17, 16, 15, 14, 13, 13, 12, 11, 10, 10, 9, 9, 9, 7, 6,
7, 6, 5, 5, 4, 4, 4, 4, 3, 3, 2, 3, 2, 1, 2, 1, 1, 1, 1, 0, 0, -1, 0, -1, -2,
-2, -2, -3, -2, -3, -4, -4, -4, -4, -5, -6, -6, -6, -7, -7, -7, -8, -8, -9, -10,
-10, -10, -11, -12, -12, -12, -12, -14, -14, -14, -15, -16, -16, -17, -17, -18,
-19, -19, -20, -21, -21, -22, -22, -23, -23, -24, -25, -26, -27, -28, -29, -30,
-31, -31, -31, -33, -33, -35, -35, -36, -37, -38, -39, -41, -41, -42, -43, -44,
-45, -47, -48, -49, -50, -51, -52, -54, -54, -55, -58, -59, -59, -61, -62, -64,
-65, -66, -68, -69, -70, -71, -72, -74, -74, -76, -77, -78, -80, -81, -82, -83,
-84, -85, -86, -88, -88, -89, -89, -91, -92, -93, -93, -95, -95, -96, -96, -97,
-97, -98, -99, -99, -99, -100, -100, -100, -101, -102, -102, -102, -102, -102,
-102, -102, -102, -102, -102, -103, -103, -103, -103, -103, -103, -102, -103,
-103, -103, -103, -102, -103, -103, -103, -103, -103, -103, -103, -103, -104,
-103, -103, -104, -104, -105, -105, -105, -106, -106, -106, -106, -106, -107,
-108, -109, -109, -110, -110, -111, -111, -112, -113, -113, -114, -115, -116,
-116, -117, -118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -120, -119, -118, -119, -120, -119, -119, -119, -119, -119, -120, -119,
-119, -118, -118, -117, -115, -114, -111, -110, -108, -106, -105, -103, -100,
-98, -95, -92, -89, -87, -84, -81, -78, -75, -72, -68, -65, -61, -58, -55, -52,
-46, -43, -41, -37, -32, -29, -24, -21, -17, -13, -10, -6, -2, };