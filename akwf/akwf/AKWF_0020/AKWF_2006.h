#define DATA_LENGTH 512
#define DATA AKWF_2006

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 10, 13, 19, 22, 26, 31, 35, 39,
42, 46, 50, 52, 56, 59, 62, 65, 68, 70, 72, 76, 77, 80, 82, 84, 87, 88, 89, 91,
93, 94, 95, 97, 98, 99, 100, 101, 102, 102, 104, 104, 105, 104, 105, 105, 106,
106, 107, 107, 106, 106, 106, 106, 106, 105, 105, 105, 105, 105, 104, 104, 103,
103, 101, 102, 101, 101, 100, 99, 99, 98, 97, 98, 96, 95, 95, 92, 92, 90, 88,
89, 87, 86, 84, 83, 82, 80, 79, 78, 76, 75, 73, 71, 70, 69, 67, 66, 65, 63, 63,
61, 60, 58, 58, 56, 55, 54, 54, 52, 52, 51, 51, 51, 50, 49, 49, 49, 48, 49, 48,
48, 49, 49, 50, 49, 51, 51, 52, 53, 55, 55, 56, 57, 59, 61, 62, 63, 65, 67, 68,
70, 71, 73, 74, 76, 77, 80, 81, 83, 84, 86, 87, 89, 90, 92, 93, 94, 95, 96, 97,
98, 98, 100, 99, 99, 100, 99, 100, 100, 100, 99, 98, 97, 97, 96, 95, 93, 91, 91,
90, 88, 85, 84, 82, 79, 77, 75, 73, 70, 68, 65, 62, 60, 57, 55, 52, 49, 46, 43,
40, 37, 35, 31, 29, 27, 24, 21, 18, 15, 13, 11, 9, 6, 4, 2, 0, -3, -3, -6, -8,
-8, -10, -12, -13, -14, -14, -15, -16, -17, -17, -18, -17, -18, -19, -19, -19,
-20, -19, -18, -19, -19, -19, -18, -17, -18, -17, -16, -16, -16, -14, -14, -13,
-13, -12, -11, -10, -9, -9, -9, -8, -6, -6, -6, -6, -4, -4, -4, -3, -2, -2, -2,
-2, -1, -1, -1, 0, 0, 0, 0, 0, 0, 1, 1, 1, 2, 1, 1, 2, 2, 2, 1, 1, 2, 1, 2, 1,
0, 1, 1, 0, -1, -1, -1, -1, -1, -2, -3, -4, -4, -5, -6, -6, -7, -8, -8, -10,
-10, -12, -13, -14, -15, -16, -18, -18, -20, -21, -23, -23, -26, -27, -29, -31,
-33, -34, -37, -38, -41, -42, -45, -48, -49, -52, -54, -56, -58, -60, -63, -65,
-67, -70, -71, -74, -76, -79, -81, -83, -86, -87, -89, -90, -93, -95, -96, -97,
-100, -101, -102, -103, -104, -105, -106, -107, -108, -109, -109, -110, -110,
-109, -111, -109, -110, -109, -110, -108, -108, -107, -106, -106, -104, -104,
-102, -100, -98, -98, -97, -95, -93, -91, -90, -88, -87, -84, -83, -82, -80,
-78, -76, -74, -73, -72, -70, -69, -68, -65, -65, -64, -62, -62, -60, -60, -59,
-59, -59, -58, -58, -58, -59, -59, -58, -59, -60, -61, -60, -62, -63, -65, -66,
-68, -68, -70, -72, -75, -75, -78, -80, -81, -83, -86, -88, -90, -91, -93, -96,
-97, -100, -102, -104, -105, -107, -109, -111, -111, -113, -114, -116, -116,
-116, -118, -118, -120, -119, -120, -120, -118, -119, -118, -117, -115, -115,
-114, -111, -109, -107, -106, -104, -100, -98, -95, -92, -89, -86, -82, -78,
-74, -71, -67, -63, -60, -55, -52, -46, -42, -38, -34, -29, -25, -20, -16, -11,
-7, -2, };