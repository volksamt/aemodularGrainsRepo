#define DATA_LENGTH 512
#define DATA AKWF_1929

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 11, 17, 22, 25, 30, 35, 38, 42,
47, 51, 54, 59, 62, 65, 68, 73, 75, 78, 81, 83, 86, 90, 92, 93, 96, 97, 99, 101,
102, 104, 104, 106, 106, 108, 107, 108, 109, 108, 108, 109, 108, 107, 108, 106,
106, 106, 104, 104, 101, 100, 99, 99, 96, 95, 93, 91, 90, 88, 86, 83, 82, 81,
79, 77, 75, 72, 70, 68, 66, 65, 62, 60, 58, 56, 54, 52, 50, 49, 46, 44, 42, 42,
40, 38, 36, 35, 33, 31, 30, 28, 28, 27, 25, 26, 24, 23, 21, 21, 21, 21, 19, 20,
20, 19, 19, 18, 18, 18, 18, 20, 18, 19, 20, 19, 21, 20, 22, 22, 21, 23, 24, 24,
25, 25, 27, 28, 28, 30, 30, 32, 32, 34, 34, 35, 36, 36, 38, 40, 40, 42, 42, 43,
44, 45, 46, 46, 47, 47, 48, 49, 49, 50, 50, 51, 51, 51, 51, 52, 51, 51, 52, 52,
51, 51, 51, 50, 50, 49, 48, 47, 46, 45, 45, 44, 42, 41, 39, 38, 36, 35, 32, 30,
29, 26, 24, 22, 20, 18, 16, 13, 10, 8, 6, 2, 1, -2, -5, -9, -11, -14, -16, -20,
-21, -25, -28, -31, -33, -36, -38, -41, -43, -47, -49, -51, -53, -56, -58, -59,
-62, -64, -65, -68, -68, -70, -72, -73, -74, -76, -76, -76, -77, -78, -78, -77,
-77, -77, -77, -76, -75, -75, -74, -73, -72, -69, -68, -67, -64, -63, -61, -58,
-54, -53, -51, -48, -44, -40, -38, -35, -31, -28, -24, -21, -17, -13, -10, -6,
-1, 2, 5, 9, 13, 17, 21, 25, 28, 31, 35, 39, 42, 45, 48, 53, 55, 57, 61, 64, 67,
69, 71, 73, 74, 77, 77, 80, 81, 82, 83, 84, 84, 85, 85, 85, 85, 85, 85, 83, 82,
81, 81, 79, 78, 76, 73, 72, 69, 67, 65, 63, 59, 56, 53, 51, 48, 45, 41, 37, 35,
31, 27, 24, 21, 16, 13, 10, 6, 3, -1, -4, -8, -11, -15, -18, -21, -24, -27, -30,
-33, -36, -38, -41, -43, -45, -48, -50, -51, -53, -54, -56, -57, -58, -59, -59,
-61, -61, -60, -62, -62, -62, -61, -61, -60, -60, -59, -58, -57, -56, -55, -54,
-52, -50, -49, -47, -47, -44, -43, -40, -39, -38, -35, -33, -32, -30, -29, -26,
-26, -23, -22, -21, -20, -18, -17, -16, -14, -14, -14, -13, -11, -10, -10, -10,
-11, -11, -10, -10, -11, -12, -13, -13, -14, -15, -16, -17, -19, -21, -22, -24,
-26, -29, -31, -33, -35, -38, -40, -43, -45, -48, -51, -54, -56, -59, -62, -65,
-68, -71, -74, -77, -79, -83, -85, -88, -92, -93, -96, -98, -100, -103, -104,
-107, -108, -111, -112, -114, -114, -116, -116, -117, -118, -119, -119, -119,
-119, -119, -119, -118, -117, -117, -115, -114, -112, -111, -109, -107, -105,
-102, -99, -97, -94, -91, -88, -85, -81, -77, -74, -71, -66, -62, -59, -55, -50,
-46, -40, -37, -32, -27, -24, -19, -13, -10, -5, -1, };