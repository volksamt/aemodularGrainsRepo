#define DATA_LENGTH 512
#define DATA AKWF_1916

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 5, 6, 7, 10, 10, 12, 13, 15, 16,
16, 17, 18, 19, 19, 20, 21, 22, 22, 22, 23, 24, 24, 25, 26, 27, 27, 28, 28, 29,
30, 30, 31, 31, 33, 33, 34, 34, 34, 35, 36, 37, 37, 38, 38, 38, 39, 39, 41, 41,
42, 43, 43, 43, 44, 45, 46, 46, 46, 48, 49, 50, 50, 51, 51, 53, 54, 54, 55, 55,
56, 57, 58, 58, 58, 59, 60, 61, 60, 61, 62, 62, 61, 63, 62, 62, 63, 63, 63, 63,
64, 63, 64, 63, 63, 64, 64, 64, 64, 64, 65, 65, 65, 65, 66, 67, 67, 67, 68, 68,
69, 69, 69, 70, 70, 71, 72, 73, 74, 74, 76, 77, 77, 78, 79, 80, 81, 82, 82, 84,
85, 85, 86, 87, 88, 88, 89, 90, 91, 92, 94, 94, 94, 96, 97, 98, 98, 99, 101,
101, 103, 103, 104, 104, 105, 107, 107, 107, 108, 107, 109, 109, 110, 110, 110,
110, 110, 111, 112, 112, 111, 111, 112, 112, 112, 112, 111, 111, 111, 112, 111,
110, 110, 109, 109, 110, 109, 109, 108, 108, 108, 107, 107, 106, 105, 105, 105,
104, 102, 103, 101, 100, 100, 99, 97, 97, 96, 95, 94, 93, 91, 91, 90, 88, 86,
84, 83, 81, 81, 79, 76, 75, 74, 71, 69, 68, 66, 63, 61, 60, 58, 55, 53, 52, 49,
48, 45, 42, 40, 38, 36, 34, 32, 29, 26, 25, 23, 20, 18, 15, 13, 11, 9, 7, 4, 2,
-1, -2, -4, -6, -8, -10, -11, -13, -15, -16, -16, -18, -19, -19, -20, -21, -22,
-21, -21, -22, -21, -21, -22, -21, -21, -21, -20, -20, -20, -20, -19, -18, -19,
-19, -18, -18, -19, -19, -19, -20, -20, -21, -21, -22, -22, -24, -24, -25, -26,
-27, -28, -28, -30, -31, -32, -34, -34, -36, -36, -37, -38, -40, -40, -40, -42,
-42, -43, -44, -44, -44, -45, -46, -47, -46, -47, -48, -48, -48, -48, -49, -50,
-49, -50, -49, -50, -51, -51, -52, -52, -53, -53, -54, -54, -55, -56, -56, -57,
-58, -60, -60, -60, -62, -64, -63, -64, -65, -67, -68, -69, -70, -72, -72, -74,
-75, -76, -77, -78, -79, -81, -81, -83, -84, -85, -86, -87, -89, -89, -92, -93,
-92, -94, -95, -96, -98, -98, -100, -100, -101, -102, -103, -104, -106, -106,
-107, -108, -109, -110, -110, -111, -111, -112, -113, -113, -114, -115, -116,
-116, -116, -117, -116, -118, -118, -117, -118, -118, -118, -119, -119, -119,
-118, -118, -119, -118, -119, -118, -119, -119, -118, -118, -118, -119, -117,
-117, -117, -117, -117, -115, -115, -115, -114, -113, -113, -112, -112, -111,
-111, -110, -109, -109, -107, -106, -105, -105, -105, -103, -103, -101, -99,
-99, -98, -97, -96, -95, -94, -92, -91, -90, -89, -87, -86, -84, -82, -80, -79,
-77, -75, -72, -71, -69, -66, -64, -61, -58, -56, -53, -50, -47, -44, -42, -39,
-36, -32, -30, -27, -25, -21, -18, -16, -14, -10, -9, -7, -5, -2, 0, };