#define DATA_LENGTH 512
#define DATA AKWF_1978

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 11, 14, 17, 20, 23, 26, 30, 32,
36, 39, 42, 45, 48, 52, 55, 57, 60, 63, 67, 69, 72, 74, 77, 78, 81, 83, 85, 88,
90, 93, 95, 97, 99, 101, 104, 106, 108, 110, 112, 112, 113, 114, 114, 114, 114,
114, 114, 115, 116, 116, 118, 117, 118, 118, 119, 119, 119, 119, 118, 118, 118,
118, 117, 117, 116, 116, 115, 114, 114, 114, 113, 112, 112, 112, 111, 110, 109,
109, 109, 109, 108, 107, 106, 106, 104, 105, 104, 102, 102, 101, 100, 100, 98,
99, 98, 98, 97, 97, 96, 96, 96, 96, 95, 95, 94, 93, 93, 94, 92, 92, 91, 91, 91,
90, 91, 90, 90, 90, 89, 90, 89, 88, 89, 88, 88, 87, 87, 86, 86, 86, 86, 86, 86,
85, 85, 85, 85, 85, 84, 85, 85, 84, 84, 84, 84, 84, 84, 84, 83, 83, 83, 83, 83,
84, 83, 83, 84, 84, 84, 84, 85, 84, 84, 85, 85, 85, 86, 86, 85, 86, 87, 87, 87,
87, 87, 88, 89, 89, 90, 91, 91, 92, 91, 94, 94, 94, 95, 94, 96, 96, 97, 96, 96,
96, 97, 97, 97, 98, 98, 98, 99, 99, 99, 99, 100, 99, 100, 100, 101, 99, 98, 97,
96, 96, 95, 93, 92, 92, 91, 89, 89, 88, 87, 85, 85, 84, 83, 82, 79, 78, 75, 72,
69, 68, 64, 62, 59, 57, 54, 52, 49, 47, 44, 42, 40, 37, 35, 32, 28, 25, 22, 18,
15, 12, 9, 5, 2, 0, -4, -8, -12, -14, -18, -20, -25, -28, -30, -32, -35, -37,
-41, -43, -45, -49, -51, -54, -56, -59, -62, -64, -67, -70, -73, -75, -78, -79,
-80, -81, -81, -83, -84, -86, -88, -88, -90, -90, -92, -92, -94, -95, -95, -98,
-99, -99, -99, -100, -99, -99, -99, -98, -100, -99, -99, -98, -98, -98, -97,
-97, -97, -98, -97, -98, -96, -96, -97, -96, -95, -94, -93, -93, -93, -92, -92,
-92, -91, -90, -90, -89, -88, -88, -88, -87, -87, -86, -86, -86, -86, -86, -85,
-85, -84, -85, -84, -84, -84, -84, -83, -83, -84, -83, -82, -83, -83, -83, -83,
-83, -84, -84, -84, -83, -83, -84, -84, -85, -85, -85, -84, -85, -84, -84, -85,
-86, -86, -87, -86, -87, -87, -87, -87, -88, -88, -88, -88, -88, -88, -90, -89,
-90, -89, -90, -91, -92, -91, -92, -91, -92, -93, -93, -93, -94, -95, -94, -95,
-95, -96, -96, -96, -96, -96, -98, -99, -100, -100, -100, -102, -103, -104,
-103, -104, -104, -105, -106, -106, -108, -108, -109, -109, -109, -111, -110,
-111, -111, -112, -113, -113, -114, -114, -115, -116, -116, -116, -117, -118,
-118, -119, -119, -118, -119, -118, -118, -117, -117, -116, -116, -117, -116,
-116, -116, -116, -115, -115, -114, -114, -114, -113, -111, -108, -108, -105,
-103, -101, -100, -97, -95, -94, -91, -89, -87, -85, -83, -80, -79, -77, -74,
-70, -65, -60, -55, -51, -47, -43, -38, -34, -28, -24, -20, -15, -10, -5, -1, };