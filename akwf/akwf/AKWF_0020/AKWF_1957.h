#define DATA_LENGTH 512
#define DATA AKWF_1957

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 9, 15, 21, 27, 32, 36, 41, 47, 50,
54, 58, 62, 66, 70, 73, 76, 79, 82, 85, 87, 90, 92, 94, 96, 98, 101, 103, 105,
105, 107, 109, 110, 111, 113, 113, 113, 114, 113, 113, 112, 112, 111, 111, 109,
108, 106, 104, 102, 100, 97, 95, 91, 88, 86, 82, 80, 78, 74, 71, 69, 66, 63, 60,
57, 55, 53, 51, 50, 49, 46, 45, 43, 43, 41, 41, 40, 40, 39, 40, 40, 39, 38, 40,
40, 40, 40, 40, 42, 42, 44, 45, 45, 47, 48, 50, 51, 52, 54, 55, 58, 60, 61, 64,
66, 68, 71, 73, 75, 79, 79, 82, 85, 87, 90, 92, 94, 95, 98, 100, 101, 103, 103,
105, 106, 106, 107, 108, 108, 107, 108, 107, 107, 106, 106, 105, 103, 102, 101,
100, 99, 97, 95, 94, 91, 89, 89, 87, 85, 83, 81, 79, 76, 74, 72, 71, 68, 66, 64,
62, 59, 58, 56, 54, 52, 51, 48, 47, 45, 44, 43, 42, 41, 39, 38, 38, 37, 37, 37,
36, 37, 37, 37, 39, 39, 40, 42, 43, 44, 46, 48, 50, 52, 54, 56, 58, 61, 64, 66,
68, 71, 74, 76, 79, 81, 83, 86, 88, 90, 93, 95, 96, 99, 102, 103, 104, 106, 108,
108, 109, 111, 111, 112, 113, 114, 113, 114, 113, 113, 111, 110, 110, 108, 107,
105, 102, 100, 98, 95, 93, 89, 86, 81, 78, 74, 69, 66, 61, 56, 51, 46, 41, 36,
31, 25, 20, 15, 9, 4, -1, -7, -12, -17, -22, -27, -33, -38, -43, -47, -52, -57,
-61, -65, -69, -73, -78, -81, -85, -88, -91, -93, -97, -100, -102, -105, -106,
-108, -109, -112, -112, -113, -114, -114, -114, -115, -115, -114, -113, -112,
-111, -110, -109, -107, -105, -103, -102, -99, -97, -95, -91, -89, -87, -84,
-82, -79, -76, -74, -72, -69, -67, -64, -63, -60, -57, -55, -53, -52, -49, -48,
-47, -44, -44, -43, -42, -41, -40, -40, -39, -38, -37, -38, -37, -38, -38, -39,
-38, -40, -41, -41, -43, -44, -46, -47, -49, -50, -53, -54, -58, -59, -61, -63,
-66, -69, -70, -73, -76, -78, -80, -82, -85, -86, -89, -91, -92, -94, -96, -97,
-99, -101, -102, -103, -104, -104, -105, -105, -105, -105, -106, -106, -106,
-106, -104, -105, -105, -104, -102, -102, -100, -99, -98, -97, -96, -93, -92,
-90, -89, -87, -84, -82, -81, -77, -75, -73, -70, -68, -65, -63, -61, -59, -56,
-53, -52, -50, -47, -47, -45, -43, -42, -41, -39, -38, -37, -37, -37, -37, -37,
-37, -38, -39, -39, -40, -40, -42, -43, -44, -45, -47, -49, -51, -52, -53, -55,
-57, -59, -62, -63, -66, -67, -70, -71, -73, -75, -78, -79, -82, -85, -87, -89,
-92, -94, -97, -99, -102, -104, -106, -109, -111, -113, -114, -115, -117, -118,
-119, -119, -120, -118, -118, -117, -116, -115, -112, -110, -107, -103, -100,
-96, -92, -86, -82, -76, -71, -65, -58, -53, -46, -41, -34, -27, -21, -15, -9,
-1, };