#define DATA_LENGTH 512
#define DATA AKWF_2010

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 4, 5, 7, 7, 8, 10, 11, 11,
13, 13, 15, 16, 17, 18, 19, 22, 21, 23, 24, 25, 28, 29, 30, 31, 32, 34, 35, 36,
38, 39, 41, 41, 43, 44, 46, 48, 48, 50, 51, 53, 54, 56, 57, 58, 60, 61, 62, 64,
65, 67, 69, 69, 70, 71, 74, 74, 75, 77, 78, 80, 81, 82, 82, 84, 86, 87, 88, 88,
89, 91, 92, 93, 93, 94, 95, 96, 97, 98, 99, 99, 100, 100, 102, 101, 103, 103,
104, 105, 106, 106, 106, 107, 107, 108, 108, 108, 108, 110, 109, 110, 110, 110,
109, 111, 110, 110, 110, 110, 110, 110, 109, 109, 108, 109, 108, 107, 107, 106,
106, 106, 105, 104, 103, 101, 101, 100, 99, 98, 96, 96, 95, 93, 92, 91, 89, 88,
86, 84, 83, 81, 81, 78, 76, 75, 73, 72, 70, 68, 66, 65, 63, 61, 59, 58, 56, 55,
53, 51, 50, 48, 46, 45, 44, 42, 41, 40, 38, 38, 36, 35, 33, 32, 32, 31, 31, 29,
29, 28, 28, 27, 26, 26, 26, 25, 24, 25, 25, 24, 23, 24, 23, 24, 23, 23, 24, 24,
23, 25, 23, 24, 23, 25, 24, 24, 25, 25, 25, 24, 25, 25, 25, 25, 25, 25, 26, 26,
26, 26, 25, 26, 25, 25, 25, 25, 24, 25, 25, 24, 24, 24, 24, 23, 23, 23, 22, 21,
22, 21, 21, 21, 20, 20, 19, 18, 18, 17, 17, 17, 16, 16, 15, 13, 13, 12, 12, 12,
10, 9, 8, 7, 6, 6, 5, 3, 2, 2, 1, 0, -2, -3, -5, -7, -7, -9, -11, -12, -13, -15,
-17, -18, -20, -22, -24, -25, -28, -28, -31, -33, -36, -38, -39, -42, -44, -46,
-47, -50, -52, -54, -57, -59, -61, -63, -65, -68, -69, -72, -74, -76, -78, -80,
-83, -84, -86, -87, -89, -92, -93, -96, -97, -99, -99, -101, -103, -104, -105,
-106, -107, -108, -109, -110, -111, -112, -113, -114, -115, -115, -116, -117,
-116, -117, -118, -119, -119, -119, -118, -120, -119, -118, -119, -119, -120,
-119, -119, -119, -118, -119, -118, -117, -116, -117, -117, -115, -115, -114,
-113, -113, -112, -111, -110, -110, -110, -108, -108, -106, -106, -105, -103,
-104, -102, -101, -100, -99, -98, -97, -95, -94, -93, -92, -90, -88, -88, -85,
-84, -83, -81, -79, -78, -77, -74, -73, -72, -71, -69, -67, -65, -63, -62, -61,
-60, -59, -57, -56, -54, -52, -51, -50, -47, -46, -46, -44, -43, -41, -40, -40,
-38, -37, -36, -36, -35, -33, -33, -32, -32, -31, -30, -29, -30, -29, -29, -28,
-28, -26, -27, -26, -27, -27, -26, -25, -25, -25, -25, -25, -25, -24, -25, -25,
-24, -25, -25, -25, -25, -25, -25, -25, -24, -25, -25, -24, -24, -24, -24, -24,
-24, -22, -23, -22, -22, -22, -21, -21, -21, -21, -19, -19, -19, -18, -17, -18,
-17, -16, -15, -14, -13, -14, -12, -11, -11, -10, -9, -8, -7, -7, -5, -5, -4,
-2, -2, -1, -1, };