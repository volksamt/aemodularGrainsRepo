#define DATA_LENGTH 512
#define DATA AKWF_1980

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 11, 16, 22, 24, 27, 29, 31, 33, 36,
39, 42, 44, 47, 49, 51, 54, 56, 59, 61, 65, 66, 68, 69, 70, 71, 71, 72, 73, 73,
74, 75, 76, 76, 77, 78, 78, 80, 80, 81, 81, 83, 83, 84, 85, 85, 86, 86, 87, 87,
87, 88, 89, 89, 90, 92, 92, 93, 93, 94, 94, 94, 94, 95, 95, 96, 96, 97, 97, 97,
97, 97, 98, 98, 98, 98, 99, 99, 99, 99, 100, 100, 100, 100, 100, 100, 100, 101,
100, 102, 101, 102, 101, 102, 102, 102, 101, 102, 102, 102, 102, 102, 102, 101,
101, 102, 102, 102, 102, 102, 102, 101, 101, 102, 101, 102, 101, 101, 100, 101,
101, 100, 101, 101, 100, 99, 100, 100, 99, 101, 100, 100, 99, 99, 99, 99, 99,
99, 100, 98, 99, 101, 100, 101, 100, 100, 101, 101, 101, 101, 101, 101, 102,
102, 102, 102, 103, 102, 101, 101, 102, 102, 101, 102, 101, 101, 101, 101, 100,
101, 100, 100, 100, 101, 100, 100, 99, 101, 100, 100, 101, 101, 101, 101, 100,
101, 101, 101, 102, 102, 101, 101, 102, 102, 101, 101, 101, 100, 101, 100, 100,
99, 99, 100, 99, 99, 99, 98, 98, 98, 97, 96, 97, 97, 98, 98, 98, 97, 98, 98, 98,
98, 99, 99, 98, 99, 99, 99, 100, 101, 100, 100, 99, 98, 98, 96, 95, 95, 94, 92,
92, 92, 91, 90, 89, 88, 88, 86, 86, 85, 82, 77, 72, 68, 63, 59, 54, 50, 45, 41,
37, 32, 27, 23, 18, 14, 10, 6, 1, -3, -6, -9, -11, -14, -16, -18, -21, -25, -27,
-30, -33, -35, -37, -41, -43, -45, -49, -52, -52, -54, -56, -55, -58, -59, -60,
-61, -62, -64, -65, -67, -68, -69, -70, -71, -72, -73, -75, -76, -77, -79, -79,
-81, -82, -83, -85, -85, -87, -88, -89, -90, -92, -93, -94, -95, -96, -98, -97,
-99, -99, -99, -101, -100, -102, -102, -103, -103, -103, -104, -105, -105, -105,
-106, -106, -108, -107, -108, -107, -109, -109, -109, -110, -110, -110, -111,
-112, -113, -113, -113, -113, -114, -113, -114, -115, -115, -116, -115, -116,
-115, -116, -115, -115, -116, -115, -116, -116, -115, -116, -116, -115, -115,
-116, -116, -116, -116, -116, -117, -116, -116, -116, -116, -117, -117, -117,
-117, -117, -118, -117, -117, -118, -119, -119, -118, -118, -119, -118, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -118, -119, -120, -119, -119, -119, -118, -118, -118, -118, -118,
-118, -118, -118, -118, -117, -118, -117, -117, -117, -117, -117, -116, -116,
-116, -116, -115, -116, -115, -115, -115, -115, -114, -115, -114, -113, -114,
-113, -113, -113, -112, -111, -110, -110, -110, -109, -107, -107, -107, -106,
-105, -106, -104, -103, -104, -103, -102, -101, -101, -100, -101, -100, -98,
-98, -98, -97, -96, -96, -95, -94, -94, -94, -93, -92, -92, -90, -83, -78, -72,
-66, -59, -54, -48, -42, -36, -30, -24, -19, -12, -7, -1, };