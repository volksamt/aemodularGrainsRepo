#define DATA_LENGTH 512
#define DATA AKWF_1993

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 9, 11, 15, 17, 18, 17, 17,
17, 16, 16, 17, 16, 16, 15, 17, 15, 15, 15, 16, 16, 15, 14, 14, 14, 14, 14, 14,
13, 14, 13, 13, 13, 13, 13, 12, 12, 12, 12, 11, 12, 11, 11, 11, 12, 11, 12, 13,
13, 12, 13, 13, 13, 13, 14, 14, 13, 14, 14, 15, 14, 14, 15, 15, 16, 15, 16, 16,
16, 17, 16, 17, 16, 16, 17, 17, 16, 17, 17, 18, 18, 17, 17, 17, 17, 17, 16, 17,
16, 17, 16, 17, 16, 17, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 15, 16,
15, 16, 16, 15, 16, 15, 15, 15, 16, 15, 15, 15, 15, 16, 15, 16, 16, 16, 15, 17,
15, 16, 15, 16, 16, 16, 16, 16, 16, 16, 16, 17, 16, 16, 16, 16, 17, 17, 16, 18,
17, 17, 17, 18, 17, 18, 17, 17, 17, 17, 17, 17, 17, 17, 17, 17, 17, 17, 16, 17,
17, 16, 18, 16, 17, 17, 16, 16, 16, 17, 16, 17, 16, 16, 16, 16, 16, 16, 16, 16,
16, 16, 16, 16, 16, 16, 16, 16, 17, 16, 16, 17, 17, 17, 16, 17, 16, 17, 16, 17,
16, 16, 16, 17, 16, 17, 16, 17, 17, 16, 16, 16, 17, 16, 17, 17, 17, 16, 17, 17,
17, 18, 17, 17, 17, 17, 17, 17, 16, 16, 17, 17, 16, 16, 16, 16, 16, 16, 17, 16,
15, 17, 17, 15, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 15, 16, 16, 16, 16,
16, 16, 15, 17, 17, 16, 16, 15, 17, 17, 17, 17, 16, 16, 16, 16, 17, 17, 16, 18,
17, 17, 17, 17, 17, 16, 16, 17, 16, 17, 17, 17, 18, 17, 17, 16, 17, 16, 17, 17,
17, 16, 17, 17, 17, 17, 17, 17, 17, 17, 16, 17, 17, 17, 17, 17, 16, 16, 16, 16,
17, 17, 17, 16, 17, 16, 17, 17, 17, 16, 16, 16, 17, 16, 16, 16, 16, 16, 15, 15,
16, 16, 15, 15, 16, 15, 15, 15, 15, 15, 14, 14, 15, 14, 14, 15, 14, 14, 14, 13,
14, 14, 14, 13, 14, 14, 14, 14, 13, 15, 14, 14, 14, 14, 14, 14, 14, 14, 14, 15,
15, 14, 15, 14, 15, 15, 14, 15, 15, 15, 15, 15, 16, 16, 16, 16, 15, 16, 16, 15,
11, 7, 4, 0, -4, -7, -12, -15, -18, -22, -26, -30, -34, -36, -41, -44, -48, -51,
-55, -59, -63, -67, -70, -73, -78, -81, -85, -89, -92, -97, -99, -103, -107,
-111, -115, -118, -119, -117, -116, -114, -113, -111, -110, -110, -107, -106,
-105, -103, -102, -100, -100, -98, -96, -95, -93, -92, -91, -90, -88, -87, -86,
-84, -83, -82, -80, -80, -77, -76, -75, -74, -72, -71, -70, -66, -64, -62, -59,
-57, -55, -53, -51, -48, -45, -43, -41, -38, -36, -33, -31, -28, -26, -24, -21,
-19, -17, -14, -12, -9, -8, -5, -2, 0, };