#define DATA_LENGTH 512
#define DATA AKWF_1985

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 10, 11, 13, 15, 18, 19,
21, 24, 26, 28, 30, 32, 34, 36, 38, 41, 43, 45, 46, 50, 50, 51, 51, 51, 50, 50,
50, 50, 50, 49, 50, 50, 49, 49, 49, 49, 49, 49, 48, 49, 48, 48, 47, 47, 48, 47,
48, 47, 48, 47, 46, 47, 47, 46, 46, 47, 45, 45, 44, 44, 44, 43, 42, 41, 41, 40,
39, 38, 38, 37, 37, 35, 35, 35, 34, 33, 32, 32, 31, 31, 29, 30, 29, 28, 27, 27,
26, 24, 24, 23, 23, 22, 22, 21, 22, 23, 24, 25, 27, 28, 29, 30, 31, 32, 32, 34,
36, 36, 38, 38, 39, 40, 42, 43, 44, 45, 46, 47, 47, 49, 50, 50, 52, 53, 55, 56,
56, 57, 59, 59, 61, 61, 62, 63, 65, 66, 66, 66, 68, 69, 70, 71, 72, 72, 74, 74,
75, 76, 77, 77, 79, 80, 81, 82, 83, 83, 85, 85, 87, 87, 88, 89, 90, 90, 91, 92,
93, 94, 93, 92, 92, 93, 91, 91, 91, 91, 90, 91, 90, 90, 90, 89, 89, 89, 89, 88,
88, 87, 87, 87, 86, 87, 86, 86, 85, 85, 85, 84, 84, 84, 83, 83, 83, 83, 83, 85,
85, 86, 86, 87, 87, 88, 89, 89, 91, 92, 91, 92, 92, 93, 94, 95, 95, 96, 96, 97,
98, 98, 99, 99, 100, 101, 102, 102, 103, 104, 104, 105, 106, 106, 105, 102, 101,
99, 98, 96, 94, 92, 91, 88, 86, 85, 83, 81, 79, 77, 75, 73, 72, 70, 68, 65, 64,
62, 61, 59, 57, 54, 53, 51, 48, 47, 46, 43, 42, 40, 38, 34, 29, 25, 21, 16, 12,
8, 4, 0, -4, -8, -14, -17, -22, -26, -30, -34, -38, -42, -47, -51, -55, -59,
-63, -68, -72, -76, -80, -85, -89, -93, -97, -101, -106, -110, -114, -116, -116,
-115, -115, -116, -115, -116, -116, -116, -116, -117, -117, -117, -117, -117,
-117, -117, -118, -118, -117, -118, -118, -118, -118, -118, -118, -118, -119,
-118, -119, -119, -119, -119, -119, -118, -119, -118, -118, -116, -115, -113,
-112, -111, -110, -109, -107, -106, -104, -103, -101, -101, -99, -97, -97, -95,
-94, -92, -91, -90, -89, -87, -85, -85, -83, -82, -81, -78, -77, -77, -75, -73,
-72, -71, -70, -69, -70, -69, -68, -68, -67, -67, -67, -65, -65, -64, -64, -63,
-63, -62, -62, -61, -60, -60, -60, -59, -58, -59, -57, -57, -56, -56, -55, -55,
-54, -53, -53, -52, -52, -51, -51, -51, -51, -52, -52, -52, -52, -53, -53, -53,
-53, -53, -54, -54, -54, -54, -54, -55, -55, -55, -56, -56, -56, -56, -57, -56,
-57, -57, -58, -58, -59, -58, -58, -59, -59, -59, -59, -59, -59, -57, -57, -56,
-55, -53, -53, -51, -51, -50, -49, -48, -47, -47, -46, -45, -44, -43, -41, -42,
-40, -39, -38, -38, -36, -36, -35, -34, -33, -32, -32, -30, -29, -28, -27, -27,
-25, -23, -21, -19, -17, -14, -12, -9, -8, -5, -3, -1, };