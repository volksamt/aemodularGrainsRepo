#define DATA_LENGTH 512
#define DATA AKWF_2001

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 7, 10, 12, 13, 17, 18, 22,
23, 26, 28, 29, 32, 34, 36, 37, 39, 41, 43, 44, 46, 48, 50, 52, 53, 56, 57, 58,
60, 63, 64, 65, 67, 69, 71, 71, 73, 75, 76, 77, 79, 80, 81, 81, 83, 83, 84, 84,
85, 85, 85, 86, 86, 86, 85, 85, 84, 84, 83, 83, 82, 81, 80, 78, 76, 75, 73, 70,
68, 66, 63, 60, 58, 54, 52, 48, 45, 41, 36, 32, 28, 24, 19, 14, 10, 5, 0, -4,
-9, -13, -19, -24, -29, -33, -38, -43, -48, -53, -57, -62, -66, -71, -74, -79,
-83, -86, -90, -94, -97, -101, -103, -106, -108, -110, -113, -114, -115, -117,
-117, -119, -119, -119, -119, -119, -118, -118, -116, -115, -114, -112, -111,
-108, -107, -104, -102, -99, -96, -93, -90, -87, -84, -80, -77, -73, -69, -66,
-62, -58, -54, -50, -46, -42, -38, -34, -29, -26, -22, -18, -15, -10, -7, -4, 1,
4, 8, 11, 14, 16, 20, 23, 25, 28, 30, 32, 35, 37, 39, 42, 44, 46, 48, 49, 52,
53, 55, 57, 57, 59, 61, 62, 63, 64, 65, 66, 67, 69, 69, 70, 70, 70, 72, 72, 72,
72, 73, 72, 73, 72, 72, 72, 72, 72, 71, 71, 70, 70, 69, 68, 68, 67, 65, 65, 64,
63, 62, 60, 59, 58, 56, 54, 52, 50, 48, 47, 43, 42, 40, 37, 35, 33, 30, 27, 25,
23, 19, 18, 15, 13, 10, 7, 4, 2, -1, -3, -5, -8, -10, -12, -15, -17, -19, -21,
-23, -25, -27, -28, -30, -32, -33, -35, -36, -37, -38, -39, -41, -41, -41, -41,
-42, -43, -43, -43, -43, -43, -43, -43, -43, -43, -42, -42, -41, -40, -40, -39,
-39, -38, -37, -36, -35, -34, -34, -32, -31, -30, -29, -28, -27, -26, -25, -24,
-23, -23, -23, -21, -20, -20, -19, -18, -18, -18, -17, -17, -16, -16, -16, -16,
-15, -16, -16, -16, -16, -16, -16, -16, -16, -18, -18, -18, -18, -19, -20, -20,
-20, -21, -21, -22, -22, -23, -24, -24, -25, -25, -26, -26, -28, -27, -28, -29,
-29, -28, -29, -28, -29, -29, -29, -29, -29, -29, -28, -28, -28, -27, -28, -26,
-25, -25, -24, -23, -22, -20, -19, -18, -17, -15, -13, -12, -10, -9, -8, -5, -4,
-2, 0, 2, 5, 7, 9, 10, 12, 14, 16, 18, 19, 22, 23, 25, 27, 29, 30, 31, 34, 34,
36, 38, 39, 39, 41, 41, 41, 42, 43, 44, 44, 44, 44, 44, 44, 43, 42, 41, 41, 40,
38, 37, 35, 34, 32, 32, 29, 27, 25, 23, 21, 20, 16, 15, 11, 9, 7, 5, 3, -1, -2,
-5, -8, -11, -12, -15, -17, -19, -22, -24, -26, -29, -30, -33, -34, -36, -36,
-38, -39, -40, -41, -42, -44, -44, -44, -44, -44, -44, -44, -44, -44, -43, -43,
-42, -42, -41, -40, -38, -37, -36, -34, -32, -31, -30, -29, -27, -25, -23, -20,
-18, -16, -14, -12, -10, -8, -5, -3, -1, };