#define DATA_LENGTH 512
#define DATA AKWF_1935

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 10, 15, 21, 25, 31, 36, 40, 45,
49, 54, 58, 63, 67, 71, 76, 79, 82, 87, 90, 92, 96, 99, 101, 104, 107, 108, 111,
112, 113, 116, 115, 117, 118, 119, 119, 119, 120, 119, 118, 118, 117, 116, 116,
114, 113, 112, 110, 108, 106, 105, 103, 101, 98, 95, 94, 91, 88, 86, 84, 80, 78,
75, 71, 70, 68, 64, 62, 58, 56, 53, 50, 48, 46, 43, 41, 39, 37, 35, 33, 30, 29,
27, 26, 24, 23, 22, 21, 19, 19, 18, 17, 17, 17, 16, 16, 16, 16, 16, 17, 18, 18,
18, 18, 20, 20, 21, 23, 23, 24, 26, 27, 29, 30, 31, 32, 33, 36, 37, 37, 39, 41,
42, 43, 45, 46, 47, 49, 50, 50, 51, 52, 53, 54, 54, 56, 56, 55, 57, 57, 57, 57,
56, 56, 56, 56, 56, 54, 53, 53, 52, 50, 50, 48, 46, 45, 43, 42, 40, 37, 36, 34,
30, 28, 26, 24, 19, 18, 16, 13, 10, 6, 3, -1, -3, -6, -9, -12, -15, -18, -22,
-24, -27, -32, -35, -37, -41, -43, -47, -49, -53, -55, -58, -61, -64, -67, -69,
-71, -73, -75, -77, -79, -83, -84, -86, -87, -89, -90, -91, -92, -94, -94, -94,
-95, -96, -96, -97, -97, -96, -96, -97, -97, -96, -95, -94, -94, -94, -91, -90,
-89, -88, -86, -85, -83, -81, -78, -77, -74, -72, -70, -67, -66, -62, -60, -57,
-55, -51, -48, -45, -42, -39, -36, -33, -30, -26, -23, -20, -17, -14, -9, -6,
-3, 0, 3, 6, 9, 13, 15, 19, 22, 25, 27, 30, 34, 36, 39, 41, 44, 47, 50, 52, 54,
56, 58, 59, 61, 63, 64, 66, 67, 68, 70, 71, 72, 72, 73, 73, 73, 74, 74, 74, 73,
73, 73, 73, 71, 70, 70, 69, 68, 66, 65, 63, 61, 60, 58, 56, 54, 52, 50, 47, 45,
43, 40, 38, 35, 32, 30, 27, 24, 21, 18, 15, 12, 11, 8, 4, 0, -1, -5, -8, -10,
-13, -16, -18, -21, -22, -26, -28, -30, -33, -34, -36, -39, -40, -43, -44, -46,
-46, -48, -49, -50, -52, -53, -52, -54, -55, -55, -55, -55, -56, -56, -55, -55,
-55, -55, -54, -53, -53, -52, -51, -50, -49, -48, -47, -46, -45, -44, -42, -41,
-39, -38, -37, -35, -35, -33, -31, -31, -29, -28, -27, -26, -24, -23, -23, -21,
-21, -20, -20, -19, -18, -17, -18, -17, -17, -17, -18, -17, -17, -18, -19, -20,
-21, -22, -22, -24, -25, -27, -28, -30, -32, -33, -35, -38, -40, -42, -45, -47,
-49, -52, -54, -57, -60, -62, -64, -67, -70, -74, -76, -79, -80, -84, -86, -89,
-92, -94, -97, -98, -101, -103, -105, -107, -109, -110, -112, -113, -115, -116,
-117, -117, -119, -118, -118, -119, -118, -118, -118, -118, -116, -115, -114,
-112, -111, -108, -108, -105, -103, -100, -98, -94, -92, -88, -84, -81, -78,
-74, -70, -65, -61, -57, -52, -48, -43, -38, -33, -29, -23, -18, -13, -8, -3, };