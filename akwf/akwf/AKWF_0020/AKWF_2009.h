#define DATA_LENGTH 512
#define DATA AKWF_2009

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 5, 7, 8, 9, 13, 14, 15, 18,
19, 21, 23, 25, 26, 28, 30, 32, 33, 36, 38, 38, 41, 43, 45, 46, 48, 50, 52, 54,
56, 58, 61, 62, 65, 66, 69, 72, 74, 75, 78, 80, 82, 84, 87, 88, 91, 92, 94, 96,
99, 99, 102, 104, 105, 107, 108, 110, 111, 112, 113, 115, 116, 116, 116, 117,
117, 118, 118, 119, 119, 118, 119, 118, 118, 117, 116, 116, 115, 113, 112, 111,
109, 108, 106, 104, 101, 100, 97, 94, 92, 89, 87, 84, 81, 78, 75, 72, 69, 66,
62, 58, 56, 53, 49, 46, 43, 40, 37, 34, 30, 27, 25, 22, 19, 16, 13, 12, 9, 6, 4,
2, 0, -3, -3, -5, -7, -9, -10, -10, -12, -13, -13, -13, -14, -14, -15, -16, -16,
-16, -16, -16, -16, -16, -15, -14, -14, -13, -13, -12, -11, -11, -9, -8, -7, -6,
-5, -3, -2, 0, 1, 2, 5, 6, 8, 9, 10, 13, 14, 16, 18, 20, 22, 23, 26, 27, 29, 31,
32, 35, 37, 39, 40, 43, 45, 47, 49, 52, 54, 56, 59, 61, 63, 65, 68, 70, 73, 76,
78, 80, 82, 84, 87, 88, 91, 93, 96, 98, 99, 101, 103, 105, 107, 108, 109, 111,
112, 114, 114, 116, 116, 117, 118, 118, 118, 118, 118, 118, 118, 117, 118, 117,
116, 114, 113, 112, 110, 109, 107, 105, 103, 101, 98, 97, 94, 90, 88, 85, 82,
80, 77, 73, 70, 67, 64, 60, 57, 52, 50, 47, 43, 39, 37, 32, 28, 25, 22, 19, 15,
12, 9, 5, 2, -1, -4, -7, -9, -12, -15, -18, -20, -24, -25, -27, -30, -32, -34,
-35, -37, -40, -42, -43, -45, -46, -49, -50, -51, -53, -54, -56, -57, -57, -59,
-60, -61, -62, -63, -64, -65, -65, -66, -68, -69, -69, -70, -70, -71, -73, -72,
-73, -74, -74, -75, -75, -75, -75, -77, -77, -77, -78, -79, -79, -80, -80, -81,
-81, -82, -81, -82, -82, -82, -83, -84, -84, -83, -84, -83, -84, -84, -84, -84,
-85, -84, -85, -85, -86, -85, -85, -85, -85, -84, -85, -85, -84, -84, -85, -84,
-84, -84, -84, -85, -85, -84, -84, -84, -84, -84, -84, -85, -84, -84, -84, -85,
-84, -84, -84, -84, -84, -84, -84, -85, -84, -84, -84, -84, -85, -85, -85, -85,
-85, -84, -85, -86, -84, -85, -85, -85, -85, -85, -86, -85, -86, -86, -86, -86,
-85, -85, -85, -85, -86, -85, -85, -85, -85, -85, -84, -84, -84, -83, -83, -83,
-82, -82, -82, -82, -81, -80, -80, -80, -79, -79, -78, -78, -77, -76, -76, -76,
-75, -75, -74, -74, -73, -72, -71, -70, -70, -69, -69, -67, -67, -65, -65, -64,
-62, -62, -61, -60, -59, -58, -58, -56, -55, -54, -53, -51, -51, -49, -48, -47,
-46, -45, -43, -42, -41, -40, -38, -37, -36, -35, -33, -31, -31, -28, -27, -26,
-25, -23, -21, -19, -18, -17, -16, -14, -12, -11, -9, -7, -6, -5, -3, -1, };