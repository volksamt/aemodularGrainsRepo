#define DATA_LENGTH 512
#define DATA AKWF_1955

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 17, 27, 37, 47, 56, 65, 73, 81, 87,
94, 99, 103, 106, 111, 112, 114, 115, 116, 116, 116, 115, 114, 112, 110, 108,
105, 103, 102, 99, 97, 95, 93, 91, 90, 88, 88, 87, 86, 85, 86, 85, 86, 85, 86,
86, 86, 87, 87, 88, 87, 87, 88, 88, 88, 87, 86, 86, 85, 84, 84, 83, 81, 81, 80,
78, 78, 76, 76, 75, 73, 73, 72, 71, 70, 71, 70, 69, 69, 70, 68, 69, 68, 69, 68,
68, 68, 67, 68, 66, 67, 66, 65, 65, 64, 64, 62, 61, 62, 60, 59, 58, 58, 57, 56,
55, 54, 53, 53, 53, 51, 52, 51, 51, 51, 50, 51, 50, 50, 49, 50, 49, 49, 48, 48,
48, 47, 46, 46, 45, 45, 45, 44, 44, 42, 42, 41, 40, 39, 38, 36, 36, 36, 35, 34,
34, 33, 32, 31, 31, 30, 30, 31, 30, 29, 29, 28, 29, 29, 28, 28, 28, 27, 28, 27,
27, 26, 26, 24, 24, 23, 22, 23, 20, 20, 20, 19, 18, 17, 16, 15, 14, 13, 12, 12,
11, 11, 10, 10, 10, 9, 9, 9, 9, 8, 9, 8, 7, 7, 7, 7, 7, 6, 6, 6, 5, 5, 4, 3, 2,
2, 2, 1, 0, 1, 0, -1, -1, -2, -2, -3, -3, -2, -3, -3, -2, -2, -2, -2, -1, -2,
-1, 0, 0, 1, 1, 1, 1, 1, 2, 2, 3, 2, 2, 3, 2, 1, 1, 1, 1, 1, 0, 0, -1, -1, -1,
-1, -2, -2, -2, -2, -3, -3, -2, -2, -2, -2, -1, -1, -1, 0, 1, 1, 1, 1, 2, 2, 1,
2, 2, 3, 3, 2, 2, 2, 1, 2, 1, 1, 0, -1, -1, -1, 0, -1, -2, -1, -2, -3, -2, -3,
-2, -1, -1, -1, -1, -1, -1, 0, 0, -1, 1, 0, 0, 0, 0, 0, -1, -1, 0, -2, -2, -3,
-4, -5, -5, -6, -6, -8, -9, -10, -11, -12, -13, -14, -14, -15, -16, -16, -17,
-17, -17, -18, -18, -18, -18, -18, -19, -18, -18, -19, -19, -19, -19, -20, -19,
-20, -21, -21, -22, -23, -24, -24, -26, -26, -28, -29, -30, -31, -33, -34, -34,
-34, -36, -36, -37, -37, -37, -38, -38, -38, -38, -39, -38, -38, -38, -38, -39,
-37, -38, -39, -38, -38, -39, -39, -40, -41, -41, -43, -44, -44, -46, -47, -49,
-49, -51, -52, -54, -55, -55, -57, -58, -59, -59, -60, -60, -60, -60, -60, -60,
-59, -60, -60, -59, -58, -57, -58, -58, -57, -58, -58, -57, -57, -59, -59, -60,
-61, -61, -63, -64, -66, -67, -70, -72, -73, -75, -75, -78, -79, -81, -82, -83,
-84, -84, -85, -85, -84, -85, -84, -83, -82, -80, -79, -78, -77, -75, -74, -74,
-74, -72, -72, -73, -73, -73, -74, -76, -78, -79, -82, -85, -88, -91, -94, -97,
-100, -104, -107, -110, -113, -115, -117, -118, -119, -120, -119, -117, -116,
-112, -109, -104, -100, -93, -87, -80, -71, -62, -52, -43, -34, -22, -12, -2, };