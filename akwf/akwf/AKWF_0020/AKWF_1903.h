#define DATA_LENGTH 512
#define DATA AKWF_1903

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 0, 1, 1, 1, 1, 2, 2, 2, 2, 3, 3,
3, 4, 4, 4, 6, 6, 6, 7, 7, 7, 8, 9, 9, 10, 10, 12, 11, 12, 12, 13, 14, 14, 14,
15, 16, 15, 17, 17, 17, 17, 18, 19, 19, 20, 20, 21, 21, 22, 23, 22, 24, 24, 24,
24, 25, 26, 25, 26, 26, 27, 27, 29, 29, 30, 30, 31, 31, 32, 31, 32, 33, 33, 34,
35, 34, 35, 36, 35, 37, 37, 38, 38, 39, 38, 39, 40, 39, 41, 40, 42, 42, 43, 43,
44, 44, 45, 45, 46, 47, 47, 47, 47, 47, 49, 48, 50, 50, 50, 51, 51, 51, 52, 53,
53, 54, 54, 55, 55, 55, 56, 57, 57, 57, 58, 58, 59, 59, 59, 60, 61, 61, 62, 62,
63, 63, 64, 64, 64, 65, 65, 66, 66, 67, 67, 68, 68, 70, 68, 70, 70, 71, 71, 71,
72, 72, 73, 74, 74, 75, 74, 76, 76, 76, 77, 78, 78, 78, 79, 78, 79, 80, 81, 80,
82, 82, 83, 83, 83, 83, 85, 85, 86, 86, 86, 86, 88, 88, 88, 88, 89, 90, 91, 91,
92, 91, 92, 93, 94, 94, 94, 94, 94, 95, 95, 95, 95, 95, 95, 95, 95, 95, 95, 96,
97, 98, 98, 100, 101, 102, 104, 106, 108, 110, 112, 114, 116, 117, 119, 118,
119, 119, 119, 120, 118, 116, 114, 110, 107, 102, 98, 93, 89, 83, 77, 72, 66,
59, 52, 46, 41, 34, 26, 21, 13, 6, 0, -8, -14, -21, -28, -34, -41, -48, -54,
-59, -64, -70, -74, -78, -83, -87, -90, -95, -97, -100, -103, -105, -108, -109,
-110, -112, -114, -114, -114, -115, -113, -113, -112, -112, -111, -110, -108,
-108, -106, -104, -104, -103, -102, -101, -101, -101, -99, -99, -98, -98, -98,
-97, -97, -96, -96, -96, -96, -95, -94, -94, -94, -94, -93, -92, -92, -92, -92,
-90, -90, -90, -89, -88, -88, -87, -87, -86, -86, -86, -85, -85, -84, -84, -83,
-82, -82, -81, -81, -81, -80, -79, -79, -78, -78, -78, -77, -77, -76, -76, -75,
-74, -74, -74, -73, -73, -73, -72, -71, -70, -70, -70, -69, -69, -68, -68, -66,
-66, -66, -66, -65, -65, -64, -64, -63, -63, -62, -62, -61, -61, -60, -60, -60,
-59, -58, -58, -57, -57, -56, -56, -55, -55, -55, -54, -53, -52, -53, -53, -51,
-50, -50, -50, -50, -49, -48, -48, -47, -47, -46, -47, -45, -45, -44, -44, -44,
-42, -44, -41, -42, -41, -40, -40, -40, -39, -39, -38, -37, -37, -37, -37, -37,
-35, -34, -34, -34, -34, -33, -33, -31, -31, -31, -31, -30, -30, -29, -28, -28,
-27, -26, -27, -26, -25, -25, -25, -24, -24, -23, -23, -22, -21, -21, -21, -20,
-20, -19, -19, -18, -18, -17, -16, -16, -15, -15, -15, -14, -14, -13, -13, -13,
-12, -12, -11, -10, -10, -9, -8, -9, -8, -7, -7, -6, -6, -5, -6, -4, -4, -3, -3,
-2, -3, -2, -1, -1, -1, 0, 0, };