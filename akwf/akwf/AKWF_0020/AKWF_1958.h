#define DATA_LENGTH 512
#define DATA AKWF_1958

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 12, 16, 20, 24, 28, 32, 36, 40,
43, 47, 49, 52, 55, 58, 62, 65, 67, 69, 72, 75, 77, 80, 82, 85, 87, 89, 92, 94,
97, 99, 102, 102, 105, 106, 108, 110, 112, 113, 114, 116, 116, 117, 118, 119,
118, 118, 118, 119, 119, 118, 118, 117, 118, 116, 116, 115, 114, 113, 112, 112,
111, 110, 109, 108, 107, 107, 107, 106, 105, 105, 104, 105, 104, 104, 103, 104,
103, 102, 103, 102, 102, 101, 102, 102, 100, 100, 100, 100, 99, 100, 99, 99,
100, 99, 99, 99, 99, 98, 98, 98, 98, 99, 99, 99, 99, 100, 100, 100, 99, 101,
100, 101, 102, 102, 102, 103, 102, 103, 103, 102, 102, 101, 101, 101, 101, 100,
99, 99, 99, 97, 96, 96, 95, 94, 92, 91, 90, 89, 89, 87, 86, 86, 85, 83, 82, 81,
80, 78, 77, 77, 75, 75, 74, 73, 71, 71, 69, 69, 68, 66, 66, 64, 63, 62, 62, 61,
60, 59, 59, 58, 57, 57, 56, 56, 56, 55, 55, 55, 55, 54, 54, 55, 55, 56, 55, 56,
57, 58, 58, 59, 60, 60, 61, 62, 62, 63, 65, 64, 66, 66, 67, 68, 69, 69, 70, 71,
70, 72, 71, 72, 72, 73, 73, 73, 73, 72, 73, 73, 73, 72, 72, 71, 71, 71, 71, 69,
69, 68, 68, 66, 65, 64, 62, 61, 59, 57, 55, 54, 52, 49, 47, 45, 43, 40, 37, 35,
32, 29, 26, 23, 21, 17, 15, 11, 7, 5, 2, -1, -4, -7, -10, -13, -16, -19, -21,
-23, -26, -30, -33, -35, -37, -39, -42, -44, -47, -48, -51, -52, -54, -57, -59,
-60, -62, -64, -65, -66, -68, -69, -70, -71, -72, -73, -73, -74, -74, -74, -74,
-74, -74, -74, -74, -74, -73, -72, -73, -72, -70, -71, -70, -69, -68, -68, -67,
-67, -66, -65, -64, -64, -64, -62, -61, -61, -61, -59, -59, -59, -58, -58, -58,
-57, -57, -57, -57, -56, -55, -56, -56, -55, -56, -56, -56, -56, -57, -56, -58,
-57, -57, -58, -59, -59, -61, -61, -62, -63, -64, -65, -67, -68, -69, -70, -72,
-73, -74, -76, -76, -78, -79, -80, -81, -82, -83, -85, -87, -87, -88, -89, -90,
-91, -92, -92, -93, -93, -94, -94, -96, -96, -97, -97, -97, -98, -98, -100,
-100, -100, -101, -101, -101, -101, -102, -102, -102, -102, -102, -102, -102,
-102, -102, -101, -102, -101, -101, -101, -101, -101, -101, -99, -99, -99, -99,
-99, -98, -97, -97, -97, -97, -98, -98, -98, -98, -98, -99, -99, -100, -99,
-100, -101, -102, -103, -104, -104, -105, -105, -106, -107, -108, -108, -108,
-109, -110, -111, -110, -111, -111, -111, -111, -112, -113, -112, -113, -113,
-113, -114, -113, -114, -114, -114, -114, -115, -115, -115, -116, -116, -115,
-115, -114, -115, -115, -115, -114, -113, -112, -111, -110, -109, -107, -105,
-103, -101, -98, -95, -91, -87, -84, -80, -77, -72, -68, -63, -59, -53, -48,
-43, -38, -33, -27, -22, -17, -12, -7, -2, };