#define DATA_LENGTH 512
#define DATA AKWF_1944

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 17, 21, 25, 31, 35, 40, 44,
49, 53, 57, 62, 65, 69, 74, 76, 80, 84, 87, 89, 93, 95, 98, 101, 104, 105, 107,
110, 112, 112, 115, 116, 116, 117, 118, 118, 120, 119, 119, 119, 119, 117, 117,
116, 116, 115, 114, 112, 110, 109, 107, 105, 103, 100, 98, 97, 94, 92, 88, 87,
83, 81, 78, 76, 73, 70, 67, 65, 63, 60, 57, 53, 52, 48, 46, 43, 41, 40, 37, 35,
32, 30, 29, 27, 25, 24, 22, 21, 20, 19, 18, 17, 16, 15, 15, 14, 14, 15, 14, 14,
15, 15, 16, 17, 17, 18, 19, 19, 21, 22, 23, 23, 25, 26, 28, 29, 31, 33, 35, 35,
37, 39, 41, 43, 43, 46, 47, 48, 49, 51, 52, 53, 54, 55, 56, 57, 58, 58, 59, 59,
58, 59, 59, 59, 59, 59, 59, 57, 56, 56, 55, 53, 52, 50, 49, 47, 46, 43, 41, 38,
36, 33, 32, 29, 25, 23, 19, 17, 14, 11, 8, 4, 1, -2, -6, -9, -13, -16, -20, -23,
-27, -30, -34, -37, -40, -44, -47, -50, -52, -56, -58, -62, -64, -66, -69, -72,
-74, -75, -77, -79, -81, -81, -83, -84, -84, -85, -85, -86, -86, -87, -85, -86,
-85, -84, -83, -81, -80, -79, -77, -76, -74, -72, -69, -66, -65, -61, -58, -56,
-52, -49, -47, -42, -39, -35, -32, -28, -24, -21, -17, -13, -9, -4, -1, 3, 7,
12, 15, 19, 22, 27, 30, 33, 37, 41, 44, 47, 51, 53, 57, 60, 62, 65, 68, 70, 72,
74, 76, 78, 79, 80, 81, 82, 84, 84, 84, 85, 85, 85, 85, 85, 83, 84, 83, 82, 80,
79, 78, 76, 74, 73, 70, 68, 66, 64, 61, 58, 56, 52, 51, 48, 43, 41, 37, 35, 31,
28, 24, 21, 18, 14, 10, 7, 3, 0, -3, -6, -10, -13, -16, -20, -22, -25, -29, -32,
-35, -38, -40, -43, -46, -47, -51, -52, -54, -57, -59, -60, -62, -63, -65, -67,
-68, -68, -69, -70, -71, -71, -71, -71, -72, -72, -72, -72, -72, -72, -70, -70,
-70, -69, -69, -66, -66, -65, -64, -63, -61, -60, -59, -57, -55, -54, -52, -50,
-49, -47, -46, -44, -43, -41, -38, -38, -35, -34, -32, -31, -29, -27, -27, -25,
-24, -21, -21, -19, -18, -17, -16, -16, -15, -14, -13, -13, -13, -13, -12, -12,
-12, -12, -13, -12, -12, -13, -14, -14, -16, -16, -17, -18, -20, -21, -23, -24,
-26, -27, -29, -31, -33, -35, -38, -40, -42, -43, -46, -48, -51, -53, -55, -58,
-60, -62, -64, -68, -71, -73, -76, -78, -81, -84, -86, -88, -90, -93, -95, -96,
-98, -101, -102, -103, -105, -107, -108, -110, -111, -112, -114, -114, -115,
-115, -116, -116, -117, -116, -116, -117, -117, -116, -115, -114, -113, -111,
-111, -108, -107, -105, -103, -100, -98, -95, -93, -90, -87, -84, -80, -76, -74,
-70, -66, -62, -60, -54, -51, -47, -43, -38, -33, -29, -24, -20, -15, -9, -6,
-1, };