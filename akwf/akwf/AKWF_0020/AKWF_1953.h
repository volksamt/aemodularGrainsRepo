#define DATA_LENGTH 512
#define DATA AKWF_1953

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 12, 17, 21, 26, 31, 33, 38, 42,
45, 48, 51, 54, 58, 61, 64, 66, 69, 72, 74, 77, 79, 82, 85, 88, 89, 92, 95, 97,
100, 102, 104, 107, 108, 111, 112, 113, 114, 116, 116, 118, 119, 118, 119, 119,
119, 118, 117, 117, 116, 116, 113, 112, 110, 109, 107, 106, 104, 102, 99, 97,
95, 93, 91, 89, 87, 85, 83, 82, 79, 77, 75, 73, 72, 69, 67, 65, 64, 62, 60, 58,
56, 54, 53, 51, 49, 47, 47, 44, 42, 42, 40, 38, 36, 35, 34, 33, 33, 32, 31, 30,
29, 30, 29, 29, 30, 29, 29, 30, 30, 31, 31, 32, 34, 34, 36, 37, 38, 39, 40, 41,
43, 45, 45, 47, 48, 48, 50, 51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 61, 62, 63,
64, 64, 65, 65, 66, 67, 68, 68, 69, 70, 69, 69, 69, 69, 69, 69, 69, 68, 67, 66,
65, 65, 62, 62, 60, 58, 56, 54, 52, 51, 48, 45, 43, 40, 38, 36, 33, 30, 28, 26,
22, 20, 17, 15, 11, 8, 5, 2, -1, -3, -6, -9, -13, -15, -19, -21, -24, -27, -29,
-32, -35, -37, -40, -42, -45, -48, -49, -52, -54, -57, -57, -60, -62, -64, -64,
-65, -66, -67, -69, -69, -69, -70, -70, -70, -69, -70, -69, -68, -68, -67, -65,
-64, -63, -62, -61, -59, -58, -56, -53, -52, -50, -47, -44, -43, -40, -37, -35,
-33, -30, -26, -24, -21, -18, -15, -12, -9, -5, -2, 1, 5, 7, 11, 14, 17, 21, 23,
27, 29, 33, 36, 39, 41, 44, 47, 49, 50, 53, 55, 57, 58, 60, 62, 63, 64, 65, 65,
66, 67, 67, 68, 69, 68, 68, 69, 68, 67, 67, 66, 66, 65, 64, 63, 61, 61, 59, 58,
57, 54, 52, 51, 48, 46, 43, 41, 38, 36, 33, 30, 27, 24, 20, 18, 15, 12, 8, 5, 2,
-1, -4, -7, -10, -14, -16, -19, -22, -24, -27, -30, -32, -35, -38, -39, -42,
-44, -47, -48, -50, -52, -54, -56, -57, -59, -60, -62, -63, -64, -65, -66, -67,
-68, -69, -70, -70, -70, -71, -70, -70, -70, -70, -69, -69, -68, -69, -68, -66,
-66, -65, -63, -62, -60, -59, -58, -57, -55, -54, -53, -52, -51, -49, -48, -47,
-45, -44, -43, -43, -42, -40, -39, -39, -38, -36, -36, -36, -35, -34, -33, -34,
-33, -32, -32, -32, -32, -32, -32, -31, -31, -31, -31, -32, -32, -32, -33, -34,
-35, -36, -38, -39, -40, -41, -43, -45, -47, -49, -50, -53, -55, -57, -60, -62,
-65, -67, -69, -72, -73, -76, -78, -81, -83, -84, -86, -88, -90, -92, -94, -95,
-96, -98, -100, -100, -102, -103, -104, -106, -107, -107, -109, -110, -111,
-112, -114, -115, -114, -115, -115, -117, -117, -117, -117, -117, -118, -117,
-116, -116, -113, -113, -111, -110, -107, -104, -101, -98, -95, -90, -86, -82,
-77, -72, -67, -62, -57, -52, -46, -40, -35, -30, -23, -18, -13, -7, -2, };