#define DATA_LENGTH 512
#define DATA AKWF_1922

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 11, 15, 19, 24, 27, 31, 35, 38,
41, 46, 48, 51, 54, 57, 60, 63, 65, 68, 70, 72, 74, 77, 78, 81, 82, 83, 86, 86,
88, 89, 91, 92, 94, 94, 94, 96, 97, 96, 98, 97, 98, 98, 99, 98, 99, 99, 98, 98,
99, 98, 98, 98, 97, 97, 95, 94, 94, 94, 92, 92, 91, 89, 88, 87, 85, 84, 82, 81,
79, 78, 75, 74, 71, 70, 67, 66, 63, 61, 60, 57, 54, 53, 50, 48, 46, 44, 42, 40,
39, 36, 34, 32, 31, 29, 28, 26, 25, 23, 22, 21, 20, 19, 18, 18, 17, 17, 17, 16,
16, 16, 16, 17, 17, 17, 19, 19, 19, 21, 21, 21, 24, 24, 26, 27, 28, 29, 31, 31,
34, 35, 36, 37, 38, 40, 42, 43, 43, 46, 47, 47, 48, 50, 51, 51, 52, 53, 52, 54,
54, 55, 54, 55, 55, 55, 55, 54, 54, 53, 52, 52, 51, 51, 50, 50, 49, 48, 47, 46,
45, 44, 43, 41, 40, 39, 37, 36, 35, 34, 32, 30, 28, 27, 25, 24, 22, 20, 19, 16,
15, 13, 12, 9, 8, 6, 3, 1, 0, -3, -4, -6, -8, -10, -13, -15, -17, -19, -22, -25,
-27, -29, -32, -34, -37, -39, -41, -45, -47, -49, -52, -53, -56, -58, -60, -62,
-64, -65, -67, -69, -70, -72, -72, -74, -74, -76, -76, -77, -76, -77, -77, -77,
-76, -75, -75, -74, -73, -72, -71, -68, -66, -64, -62, -59, -56, -54, -49, -47,
-44, -40, -36, -32, -28, -25, -20, -16, -13, -8, -4, 0, 5, 8, 13, 17, 22, 26,
29, 33, 37, 42, 45, 48, 51, 54, 57, 59, 63, 65, 68, 70, 71, 73, 74, 75, 76, 77,
77, 78, 78, 78, 78, 78, 77, 76, 75, 74, 73, 72, 71, 69, 67, 65, 63, 62, 59, 56,
55, 52, 49, 47, 45, 43, 40, 38, 35, 32, 30, 28, 24, 22, 20, 18, 15, 13, 10, 9,
6, 5, 2, 0, -1, -3, -4, -6, -8, -9, -11, -13, -15, -17, -18, -19, -20, -21, -24,
-25, -26, -27, -28, -29, -31, -32, -33, -34, -34, -35, -37, -37, -39, -38, -40,
-41, -41, -42, -43, -43, -44, -44, -44, -45, -44, -46, -46, -46, -46, -46, -46,
-46, -46, -45, -45, -46, -45, -45, -44, -44, -44, -43, -42, -41, -41, -40, -39,
-39, -37, -36, -35, -34, -34, -34, -32, -31, -31, -31, -29, -29, -29, -29, -28,
-28, -27, -27, -27, -28, -28, -28, -28, -29, -30, -30, -30, -32, -32, -33, -34,
-37, -38, -40, -41, -44, -46, -49, -50, -53, -56, -59, -60, -64, -67, -69, -72,
-75, -77, -81, -84, -86, -89, -92, -94, -97, -99, -102, -104, -107, -109, -111,
-112, -113, -115, -116, -117, -118, -118, -118, -118, -119, -119, -119, -118,
-117, -115, -114, -113, -111, -108, -106, -104, -101, -98, -95, -93, -88, -85,
-82, -77, -73, -69, -65, -61, -56, -52, -48, -43, -38, -34, -30, -24, -20, -15,
-11, -6, -2, };