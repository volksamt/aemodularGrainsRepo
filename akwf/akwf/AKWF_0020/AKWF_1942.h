#define DATA_LENGTH 512
#define DATA AKWF_1942

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 10, 13, 17, 18, 22, 26, 28,
30, 34, 36, 39, 43, 46, 48, 52, 55, 58, 60, 63, 66, 70, 71, 74, 78, 81, 84, 86,
89, 92, 95, 98, 101, 104, 107, 111, 113, 116, 119, 117, 115, 114, 111, 110, 106,
105, 103, 101, 98, 97, 94, 93, 89, 88, 86, 83, 82, 80, 77, 76, 73, 71, 69, 67,
64, 63, 61, 58, 56, 55, 53, 50, 48, 45, 44, 42, 39, 38, 35, 34, 31, 29, 27, 25,
23, 21, 22, 22, 24, 24, 25, 25, 26, 27, 28, 29, 30, 31, 31, 31, 33, 34, 34, 35,
36, 36, 38, 39, 39, 38, 40, 40, 42, 42, 42, 44, 45, 45, 46, 47, 47, 48, 49, 49,
50, 51, 51, 53, 54, 54, 55, 56, 54, 53, 51, 49, 48, 45, 44, 42, 40, 38, 37, 34,
33, 31, 30, 27, 26, 24, 23, 21, 19, 17, 15, 14, 12, 10, 8, 6, 4, 2, 1, -1, -2,
-4, -6, -8, -9, -11, -13, -15, -16, -19, -20, -22, -24, -26, -27, -28, -29, -29,
-30, -30, -31, -31, -32, -34, -34, -35, -35, -36, -37, -37, -37, -38, -39, -39,
-40, -40, -43, -42, -43, -44, -45, -45, -45, -47, -47, -48, -48, -49, -49, -50,
-51, -51, -53, -54, -54, -54, -55, -55, -57, -56, -57, -56, -53, -49, -46, -43,
-41, -37, -34, -31, -29, -24, -22, -18, -16, -13, -9, -6, -4, -1, 2, 5, 9, 12,
14, 18, 21, 24, 27, 30, 33, 36, 40, 43, 45, 48, 52, 55, 58, 60, 64, 67, 70, 74,
77, 79, 83, 84, 81, 80, 78, 75, 73, 71, 68, 66, 63, 62, 59, 57, 55, 52, 50, 48,
46, 43, 41, 39, 36, 34, 31, 29, 28, 25, 22, 20, 19, 15, 13, 11, 9, 7, 5, 2, -1,
-3, -5, -7, -9, -11, -14, -16, -18, -21, -22, -22, -24, -24, -25, -26, -27, -27,
-28, -29, -30, -30, -32, -33, -33, -34, -35, -36, -36, -37, -38, -38, -40, -40,
-42, -42, -43, -44, -44, -45, -45, -47, -47, -49, -49, -50, -51, -52, -52, -54,
-55, -55, -56, -57, -57, -58, -59, -58, -58, -56, -55, -54, -53, -53, -52, -51,
-50, -49, -48, -47, -46, -44, -44, -44, -42, -41, -41, -39, -38, -38, -36, -35,
-35, -34, -33, -33, -31, -30, -30, -28, -27, -27, -25, -25, -24, -23, -21, -22,
-20, -20, -18, -18, -16, -17, -19, -22, -24, -25, -28, -30, -32, -34, -36, -38,
-40, -42, -43, -47, -48, -50, -52, -54, -57, -59, -60, -63, -64, -66, -68, -70,
-72, -75, -77, -79, -80, -83, -86, -86, -88, -90, -93, -96, -97, -99, -102,
-103, -105, -107, -109, -111, -109, -107, -105, -103, -101, -99, -97, -94, -93,
-91, -89, -86, -84, -82, -80, -79, -76, -74, -73, -71, -68, -66, -64, -62, -60,
-58, -57, -54, -52, -51, -49, -46, -45, -42, -39, -38, -36, -35, -32, -30, -28,
-26, -24, -21, -20, -17, -16, -13, -9, -6, -3, -1, };