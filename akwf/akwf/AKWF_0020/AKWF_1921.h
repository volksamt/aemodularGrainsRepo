#define DATA_LENGTH 512
#define DATA AKWF_1921

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 8, 12, 16, 20, 22, 27, 30, 35,
38, 41, 46, 49, 52, 54, 56, 56, 56, 58, 59, 60, 60, 62, 62, 63, 63, 65, 66, 66,
67, 68, 69, 70, 71, 72, 72, 74, 75, 75, 76, 77, 78, 79, 79, 80, 81, 83, 83, 84,
84, 85, 87, 87, 89, 89, 91, 91, 93, 93, 95, 93, 92, 90, 89, 87, 86, 84, 83, 81,
79, 78, 76, 75, 73, 70, 69, 67, 65, 65, 63, 61, 58, 57, 56, 54, 53, 51, 50, 47,
45, 44, 42, 42, 38, 38, 36, 34, 33, 31, 29, 28, 26, 24, 23, 22, 19, 18, 18, 19,
20, 20, 21, 22, 22, 24, 24, 25, 26, 26, 27, 28, 29, 30, 30, 31, 32, 34, 35, 35,
36, 37, 37, 38, 39, 40, 41, 41, 42, 43, 44, 45, 45, 46, 47, 48, 49, 49, 50, 52,
53, 53, 54, 55, 55, 54, 52, 52, 50, 49, 48, 47, 45, 43, 43, 41, 40, 38, 38, 36,
35, 34, 33, 32, 30, 28, 27, 26, 25, 24, 23, 21, 19, 19, 18, 15, 15, 14, 12, 11,
10, 8, 7, 6, 4, 3, 2, 0, 0, -1, -3, -4, -6, -7, -10, -11, -12, -13, -15, -16,
-17, -19, -21, -22, -24, -26, -27, -29, -30, -31, -33, -34, -36, -38, -39, -42,
-42, -45, -46, -47, -48, -50, -52, -53, -55, -56, -58, -60, -61, -62, -65, -66,
-67, -69, -70, -72, -73, -73, -71, -67, -65, -61, -57, -55, -51, -49, -46, -41,
-39, -35, -31, -29, -26, -22, -19, -16, -12, -9, -7, -3, 0, 4, 7, 11, 13, 16,
20, 24, 27, 30, 33, 35, 39, 42, 46, 49, 52, 55, 58, 62, 65, 68, 71, 76, 75, 74,
72, 70, 68, 67, 65, 64, 62, 60, 59, 57, 55, 53, 52, 51, 49, 47, 46, 44, 42, 41,
40, 38, 36, 34, 32, 31, 29, 28, 26, 25, 23, 22, 20, 18, 17, 15, 13, 11, 10, 8,
6, 6, 4, 1, 1, -1, -1, -3, -3, -5, -6, -7, -8, -8, -10, -11, -12, -13, -15, -15,
-16, -18, -18, -19, -20, -20, -22, -23, -24, -26, -26, -26, -28, -29, -31, -31,
-32, -33, -34, -36, -37, -37, -38, -39, -40, -42, -42, -43, -44, -45, -47, -47,
-47, -46, -45, -46, -45, -45, -45, -44, -44, -44, -44, -43, -43, -43, -43, -42,
-42, -41, -40, -40, -40, -40, -39, -40, -40, -39, -39, -39, -38, -39, -38, -37,
-37, -36, -36, -36, -36, -36, -35, -35, -35, -35, -34, -33, -33, -33, -35, -37,
-39, -41, -43, -44, -45, -48, -51, -52, -54, -56, -56, -60, -61, -63, -65, -67,
-69, -71, -72, -75, -76, -77, -79, -82, -83, -85, -87, -89, -91, -92, -94, -96,
-99, -100, -101, -103, -106, -108, -109, -111, -113, -115, -116, -119, -117,
-113, -109, -106, -103, -99, -95, -91, -87, -84, -81, -76, -73, -69, -65, -61,
-57, -54, -51, -47, -43, -39, -35, -32, -28, -24, -21, -18, -13, -10, -5, -2, };