#define DATA_LENGTH 512
#define DATA AKWF_1981

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 3, 5, 5, 7, 7, 8, 9, 10, 11,
12, 13, 14, 15, 16, 16, 18, 18, 19, 20, 22, 22, 23, 24, 25, 27, 28, 28, 30, 31,
31, 32, 34, 35, 36, 36, 37, 38, 40, 41, 42, 43, 44, 44, 46, 47, 47, 50, 50, 50,
51, 53, 54, 55, 55, 56, 58, 59, 60, 61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 72,
72, 73, 75, 76, 77, 77, 78, 80, 80, 82, 83, 83, 84, 86, 87, 88, 88, 90, 91, 92,
92, 93, 94, 95, 97, 97, 98, 100, 101, 102, 103, 103, 105, 105, 106, 107, 109,
109, 110, 112, 113, 113, 114, 115, 116, 116, 116, 115, 116, 116, 116, 116, 116,
116, 117, 116, 117, 117, 117, 118, 117, 117, 117, 117, 115, 115, 115, 113, 113,
112, 112, 110, 111, 110, 108, 108, 106, 106, 106, 106, 104, 104, 103, 103, 100,
101, 100, 98, 97, 97, 96, 95, 94, 93, 92, 91, 92, 89, 89, 88, 87, 86, 85, 84,
83, 83, 81, 80, 79, 78, 78, 76, 75, 74, 73, 72, 72, 71, 69, 69, 67, 66, 66, 64,
64, 62, 62, 61, 60, 58, 57, 56, 56, 54, 54, 52, 52, 51, 50, 49, 47, 46, 46, 44,
43, 42, 41, 40, 39, 38, 37, 36, 36, 34, 34, 32, 32, 31, 29, 28, 28, 26, 24, 23,
23, 22, 21, 20, 19, 19, 17, 16, 15, 14, 13, 12, 11, 10, 8, 9, 7, 5, 5, 4, 3, 2,
1, 0, -1, -3, -3, -4, -6, -5, -8, -8, -9, -11, -12, -12, -14, -14, -16, -17,
-17, -19, -20, -21, -21, -22, -24, -24, -25, -27, -27, -29, -30, -31, -31, -33,
-34, -35, -36, -37, -38, -39, -40, -41, -42, -42, -43, -46, -46, -46, -48, -49,
-50, -52, -52, -53, -54, -55, -57, -57, -58, -59, -60, -62, -62, -63, -64, -65,
-67, -67, -69, -69, -71, -71, -73, -73, -74, -74, -76, -77, -79, -80, -81, -81,
-82, -84, -85, -85, -86, -87, -89, -89, -90, -91, -92, -94, -95, -96, -97, -98,
-99, -100, -101, -102, -103, -104, -105, -106, -107, -108, -107, -109, -111,
-110, -112, -112, -112, -114, -114, -115, -116, -117, -117, -118, -119, -119,
-118, -118, -117, -117, -118, -116, -116, -117, -115, -115, -116, -115, -115,
-114, -114, -113, -114, -113, -112, -111, -111, -110, -108, -109, -107, -107,
-105, -104, -105, -103, -102, -101, -102, -101, -99, -99, -98, -96, -96, -95,
-94, -93, -92, -92, -90, -89, -89, -88, -87, -86, -85, -84, -83, -82, -82, -80,
-79, -79, -78, -76, -75, -74, -73, -72, -72, -69, -69, -69, -68, -66, -66, -65,
-63, -62, -61, -61, -59, -59, -58, -56, -55, -54, -53, -52, -52, -51, -49, -48,
-48, -47, -45, -45, -44, -42, -42, -41, -39, -38, -37, -36, -36, -34, -34, -33,
-31, -30, -29, -28, -27, -26, -25, -24, -23, -22, -20, -19, -18, -16, -15, -13,
-13, -11, -10, -8, -7, -5, -4, -3, -1, -1, };