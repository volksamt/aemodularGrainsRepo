#define DATA_LENGTH 512
#define DATA AKWF_2002

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 10, 15, 20, 26, 29, 35, 39, 45,
49, 53, 58, 62, 66, 71, 74, 78, 81, 84, 89, 91, 94, 97, 99, 101, 104, 106, 107,
109, 111, 112, 114, 115, 116, 116, 117, 118, 118, 118, 119, 119, 119, 119, 118,
118, 118, 117, 116, 115, 115, 113, 112, 110, 110, 108, 107, 105, 103, 102, 99,
98, 96, 94, 93, 90, 88, 86, 83, 82, 79, 77, 75, 72, 70, 66, 64, 62, 60, 57, 53,
52, 48, 45, 42, 39, 36, 32, 29, 26, 23, 19, 16, 13, 9, 5, 2, -2, -5, -9, -12,
-15, -19, -22, -25, -29, -32, -35, -38, -41, -44, -47, -50, -52, -55, -58, -59,
-62, -64, -66, -67, -69, -71, -73, -73, -75, -75, -77, -77, -77, -78, -78, -78,
-78, -77, -78, -77, -76, -75, -75, -74, -73, -71, -69, -69, -67, -65, -63, -62,
-60, -57, -55, -53, -51, -49, -47, -44, -42, -40, -38, -36, -33, -31, -28, -27,
-24, -22, -21, -19, -16, -15, -14, -12, -10, -9, -7, -6, -4, -4, -2, -2, -1, -1,
0, 2, 1, 2, 2, 3, 2, 3, 3, 3, 3, 3, 3, 3, 2, 2, 2, 1, 1, 1, 0, -1, -1, -1, -2,
-2, -2, -3, -5, -4, -6, -6, -6, -6, -7, -8, -8, -9, -9, -9, -10, -10, -10, -10,
-10, -11, -10, -11, -11, -10, -10, -10, -10, -10, -10, -9, -10, -10, -8, -8, -8,
-9, -7, -8, -7, -6, -6, -6, -5, -5, -4, -4, -3, -3, -2, -2, -2, 0, 0, 0, 1, 2,
2, 1, 2, 3, 3, 3, 4, 3, 3, 4, 5, 5, 4, 5, 5, 5, 5, 5, 5, 5, 4, 5, 5, 4, 4, 3, 4,
4, 3, 3, 3, 3, 1, 2, 1, 0, 1, 0, 0, -1, -1, -3, -2, -3, -3, -4, -4, -4, -6, -5,
-6, -6, -6, -7, -7, -8, -8, -8, -8, -8, -9, -9, -9, -9, -10, -11, -10, -10, -10,
-10, -10, -10, -10, -11, -11, -10, -10, -11, -11, -10, -9, -10, -10, -9, -9, -9,
-9, -10, -9, -8, -8, -8, -8, -8, -7, -7, -6, -6, -6, -6, -5, -5, -5, -4, -4, -3,
-3, -2, -2, -1, -1, -1, -1, 1, 1, 1, 2, 2, 3, 3, 4, 5, 5, 6, 7, 7, 8, 8, 9, 11,
11, 13, 13, 14, 15, 17, 17, 18, 19, 19, 20, 21, 22, 22, 23, 24, 24, 25, 25, 25,
25, 26, 27, 26, 27, 27, 27, 27, 26, 26, 26, 25, 24, 25, 23, 23, 21, 20, 19, 18,
16, 16, 13, 11, 9, 7, 5, 3, 0, -2, -5, -8, -11, -14, -16, -20, -23, -26, -29,
-32, -36, -39, -43, -45, -49, -51, -55, -58, -61, -63, -67, -69, -72, -75, -77,
-80, -80, -83, -84, -86, -87, -89, -91, -91, -92, -91, -92, -92, -93, -91, -90,
-90, -88, -87, -85, -84, -81, -79, -76, -73, -71, -68, -64, -61, -57, -53, -49,
-46, -40, -37, -32, -28, -23, -17, -13, -8, -3, };