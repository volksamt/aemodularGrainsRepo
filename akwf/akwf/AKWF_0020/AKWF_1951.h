#define DATA_LENGTH 512
#define DATA AKWF_1951

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 2, 3, 4, 4, 5, 7, 6, 7, 7, 7,
8, 7, 7, 6, 6, 6, 5, 5, 4, 4, 2, 3, 2, 1, 1, 1, 1, 1, 2, 2, 2, 4, 5, 5, 8, 10,
13, 14, 17, 19, 23, 26, 30, 33, 37, 41, 44, 48, 51, 55, 59, 62, 65, 69, 73, 76,
78, 81, 83, 85, 88, 90, 91, 93, 93, 94, 94, 95, 96, 96, 96, 96, 96, 96, 96, 95,
97, 96, 95, 95, 97, 96, 97, 98, 98, 97, 98, 99, 100, 100, 101, 102, 103, 103,
105, 106, 106, 106, 107, 109, 109, 109, 110, 111, 112, 112, 111, 111, 111, 112,
112, 112, 111, 111, 112, 111, 111, 110, 111, 110, 110, 110, 109, 109, 110, 109,
109, 110, 109, 109, 110, 109, 109, 110, 109, 109, 108, 108, 109, 108, 107, 108,
108, 107, 107, 106, 105, 105, 105, 104, 104, 104, 102, 101, 101, 101, 100, 99,
97, 97, 97, 97, 96, 94, 94, 93, 93, 92, 92, 91, 90, 89, 89, 88, 87, 87, 86, 84,
84, 83, 83, 81, 80, 80, 78, 77, 77, 76, 74, 73, 72, 70, 71, 69, 68, 68, 66, 65,
63, 62, 62, 60, 59, 58, 58, 56, 55, 53, 52, 51, 50, 49, 48, 46, 45, 43, 43, 42,
41, 38, 37, 36, 35, 34, 32, 32, 29, 28, 26, 25, 24, 22, 21, 20, 18, 17, 15, 14,
13, 11, 11, 10, 8, 6, 5, 4, 3, 1, 0, -1, -3, -4, -6, -7, -8, -10, -11, -13, -14,
-16, -17, -18, -20, -21, -23, -24, -25, -27, -28, -31, -31, -32, -34, -36, -37,
-38, -39, -41, -42, -43, -45, -46, -47, -49, -49, -50, -51, -53, -55, -56, -58,
-58, -59, -61, -62, -63, -64, -67, -67, -68, -70, -71, -72, -73, -75, -76, -77,
-79, -79, -80, -81, -82, -83, -84, -85, -86, -87, -88, -89, -89, -91, -91, -92,
-93, -94, -95, -95, -97, -97, -97, -99, -99, -100, -102, -102, -102, -104, -104,
-105, -106, -106, -107, -108, -108, -109, -109, -110, -111, -112, -112, -112,
-113, -114, -114, -114, -114, -115, -115, -115, -115, -117, -116, -117, -117,
-117, -116, -117, -117, -117, -118, -117, -117, -118, -118, -119, -119, -118,
-119, -119, -119, -120, -120, -119, -119, -119, -119, -119, -119, -118, -119,
-118, -118, -118, -117, -116, -117, -117, -115, -115, -115, -114, -113, -113,
-113, -113, -112, -112, -111, -110, -111, -110, -110, -109, -109, -108, -107,
-107, -106, -106, -105, -104, -104, -102, -103, -101, -100, -100, -99, -98, -96,
-95, -94, -94, -92, -92, -91, -89, -89, -87, -86, -84, -83, -83, -81, -79, -78,
-77, -76, -75, -73, -73, -71, -71, -69, -68, -67, -65, -64, -62, -61, -59, -58,
-57, -55, -53, -52, -51, -50, -47, -46, -44, -41, -40, -39, -37, -36, -34, -32,
-31, -29, -28, -26, -25, -24, -23, -22, -21, -20, -19, -17, -17, -16, -15, -13,
-14, -12, -11, -11, -10, -8, -8, -7, -7, -5, -4, -3, -2, -2, -1, };