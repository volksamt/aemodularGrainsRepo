#define DATA_LENGTH 512
#define DATA AKWF_1979

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 10, 14, 18, 21, 25, 28, 32, 35,
39, 43, 45, 48, 53, 56, 59, 63, 66, 70, 73, 76, 79, 80, 82, 84, 87, 89, 92, 94,
96, 98, 100, 102, 104, 107, 110, 111, 114, 115, 118, 118, 117, 118, 118, 117,
118, 117, 118, 117, 117, 117, 118, 117, 117, 117, 117, 117, 116, 117, 116, 116,
115, 114, 114, 113, 113, 112, 112, 111, 111, 109, 110, 109, 109, 108, 107, 107,
106, 106, 105, 105, 105, 104, 105, 104, 104, 104, 104, 104, 103, 103, 103, 103,
103, 102, 102, 102, 103, 102, 102, 102, 103, 102, 103, 103, 103, 104, 104, 104,
104, 104, 104, 105, 105, 104, 104, 104, 104, 103, 103, 104, 103, 102, 101, 100,
101, 99, 100, 99, 99, 98, 99, 98, 97, 96, 96, 94, 93, 92, 91, 90, 89, 88, 87,
86, 84, 84, 82, 81, 80, 79, 78, 77, 76, 75, 74, 73, 72, 71, 70, 70, 68, 67, 67,
66, 65, 64, 63, 62, 62, 60, 59, 59, 59, 60, 60, 59, 60, 59, 60, 59, 60, 60, 60,
60, 60, 60, 60, 60, 60, 61, 61, 62, 62, 63, 65, 65, 66, 66, 66, 67, 68, 69, 69,
70, 71, 71, 72, 74, 73, 74, 74, 73, 73, 73, 72, 72, 72, 72, 71, 72, 72, 72, 71,
71, 70, 71, 71, 70, 69, 67, 64, 62, 60, 58, 56, 56, 53, 52, 50, 47, 45, 43, 42,
38, 38, 36, 32, 30, 27, 24, 22, 19, 15, 12, 10, 6, 4, 1, -3, -6, -9, -12, -15,
-18, -21, -23, -27, -28, -31, -33, -35, -38, -40, -41, -44, -46, -49, -50, -52,
-55, -57, -60, -62, -64, -67, -67, -67, -69, -69, -70, -70, -70, -71, -71, -70,
-72, -72, -72, -72, -74, -74, -74, -75, -75, -75, -74, -73, -73, -71, -71, -71,
-71, -69, -68, -68, -67, -67, -66, -65, -64, -64, -63, -63, -63, -61, -61, -62,
-61, -61, -61, -60, -59, -60, -60, -60, -59, -59, -58, -58, -58, -58, -59, -59,
-59, -60, -60, -62, -62, -63, -64, -65, -66, -67, -67, -68, -69, -70, -70, -72,
-72, -74, -75, -75, -76, -77, -78, -81, -81, -82, -84, -84, -86, -86, -87, -88,
-90, -91, -92, -94, -94, -95, -95, -97, -97, -98, -98, -99, -99, -99, -99, -101,
-102, -102, -102, -103, -103, -104, -104, -105, -104, -104, -104, -104, -104,
-104, -104, -104, -104, -103, -103, -103, -103, -103, -103, -102, -102, -101,
-102, -102, -103, -103, -102, -103, -103, -103, -102, -103, -104, -104, -104,
-104, -103, -105, -105, -105, -105, -105, -105, -106, -107, -107, -107, -109,
-109, -110, -110, -110, -112, -112, -112, -113, -113, -114, -114, -115, -116,
-116, -117, -116, -117, -116, -116, -117, -117, -117, -118, -117, -118, -117,
-118, -118, -119, -119, -120, -119, -118, -115, -113, -112, -110, -108, -106,
-104, -103, -101, -99, -97, -95, -94, -91, -91, -87, -86, -84, -79, -74, -69,
-64, -60, -55, -50, -44, -39, -33, -29, -24, -19, -14, -9, -4, };