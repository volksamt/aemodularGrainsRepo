#define DATA_LENGTH 512
#define DATA AKWF_1902

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 15, 24, 34, 42, 51, 59, 66, 73, 78,
83, 86, 90, 90, 91, 91, 90, 88, 85, 82, 79, 76, 71, 69, 65, 61, 57, 53, 51, 48,
45, 42, 40, 38, 35, 33, 30, 27, 26, 25, 23, 22, 20, 19, 18, 17, 17, 17, 17, 18,
17, 18, 19, 19, 20, 21, 22, 22, 22, 23, 24, 24, 23, 23, 23, 22, 21, 21, 21, 20,
20, 19, 18, 18, 18, 18, 18, 18, 18, 19, 20, 21, 20, 22, 23, 24, 24, 26, 27, 28,
29, 30, 31, 32, 33, 33, 33, 35, 35, 36, 37, 36, 38, 38, 38, 39, 41, 40, 41, 42,
43, 44, 43, 44, 44, 45, 46, 47, 47, 48, 49, 50, 50, 51, 52, 53, 54, 56, 57, 59,
60, 61, 64, 65, 66, 68, 70, 71, 72, 74, 75, 76, 77, 78, 79, 80, 79, 81, 80, 81,
81, 80, 81, 80, 80, 80, 81, 81, 80, 81, 81, 80, 81, 81, 81, 82, 82, 83, 83, 83,
84, 83, 84, 85, 85, 84, 84, 84, 84, 84, 84, 83, 83, 83, 82, 82, 81, 81, 80, 80,
79, 79, 78, 78, 76, 77, 76, 76, 75, 75, 74, 73, 74, 73, 73, 73, 73, 73, 72, 72,
73, 73, 74, 74, 74, 75, 76, 77, 77, 77, 78, 80, 80, 80, 81, 82, 82, 82, 82, 83,
82, 82, 82, 81, 82, 82, 82, 82, 83, 83, 83, 84, 85, 86, 87, 89, 90, 92, 95, 95,
97, 98, 99, 101, 102, 101, 102, 100, 99, 97, 94, 91, 88, 85, 81, 76, 71, 66, 60,
55, 49, 43, 37, 31, 25, 18, 12, 6, 0, -8, -14, -20, -27, -33, -40, -46, -51,
-57, -62, -68, -72, -76, -81, -83, -86, -88, -91, -92, -95, -95, -97, -98, -98,
-98, -99, -100, -101, -101, -101, -103, -103, -105, -105, -106, -108, -108,
-108, -109, -110, -112, -112, -113, -114, -114, -115, -115, -117, -116, -117,
-117, -117, -118, -118, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-118, -118, -118, -117, -117, -117, -116, -115, -115, -114, -114, -112, -111,
-111, -110, -108, -108, -106, -105, -104, -102, -101, -100, -98, -97, -95, -94,
-92, -91, -89, -87, -87, -85, -83, -81, -80, -79, -78, -76, -74, -74, -73, -71,
-70, -68, -67, -66, -64, -64, -62, -60, -59, -56, -56, -53, -53, -52, -50, -48,
-47, -46, -45, -45, -44, -44, -44, -44, -43, -44, -45, -46, -47, -49, -49, -50,
-52, -52, -54, -54, -55, -55, -56, -57, -57, -57, -57, -57, -56, -56, -56, -56,
-55, -55, -54, -54, -52, -52, -52, -52, -52, -53, -53, -53, -54, -54, -54, -55,
-55, -56, -56, -56, -57, -57, -57, -57, -57, -58, -58, -58, -57, -58, -57, -57,
-57, -57, -57, -56, -55, -55, -54, -54, -52, -52, -51, -50, -48, -48, -47, -45,
-43, -42, -41, -40, -40, -39, -38, -38, -37, -38, -37, -39, -39, -41, -42, -42,
-45, -45, -46, -47, -47, -45, -43, -41, -39, -35, -30, -23, -17, -8, -1, };