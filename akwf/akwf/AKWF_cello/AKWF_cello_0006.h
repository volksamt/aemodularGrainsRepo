#define DATA_LENGTH 512
#define DATA AKWF_cello_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 6, 9, 12, 16, 19, 22, 25, 27,
30, 33, 36, 39, 42, 46, 48, 52, 55, 57, 59, 63, 63, 65, 66, 69, 71, 72, 73, 75,
76, 77, 78, 80, 81, 82, 83, 83, 85, 85, 86, 86, 87, 88, 90, 90, 92, 93, 93, 95,
95, 95, 96, 96, 97, 97, 98, 97, 98, 97, 98, 98, 98, 98, 99, 99, 101, 101, 102,
103, 104, 104, 105, 106, 108, 109, 111, 112, 114, 116, 117, 118, 118, 118, 119,
119, 120, 119, 118, 116, 115, 111, 111, 107, 106, 104, 103, 100, 97, 94, 92, 90,
86, 84, 82, 78, 77, 75, 72, 72, 70, 69, 67, 66, 65, 64, 63, 62, 60, 58, 57, 56,
55, 54, 53, 51, 49, 47, 45, 42, 39, 36, 32, 28, 24, 22, 19, 14, 12, 9, 8, 4, 2,
0, -1, -5, -5, -7, -8, -8, -10, -10, -11, -10, -11, -11, -11, -12, -12, -13,
-13, -14, -15, -16, -18, -20, -23, -25, -27, -29, -32, -35, -38, -41, -45, -47,
-51, -54, -57, -60, -63, -67, -69, -73, -75, -77, -80, -81, -82, -82, -82, -82,
-82, -81, -81, -81, -80, -80, -80, -81, -80, -79, -78, -78, -77, -76, -75, -75,
-74, -74, -75, -74, -73, -74, -73, -73, -73, -72, -70, -68, -67, -64, -62, -60,
-57, -54, -50, -47, -44, -41, -37, -33, -30, -26, -22, -18, -15, -12, -8, -6,
-3, 1, 3, 6, 8, 11, 14, 15, 16, 17, 18, 20, 21, 22, 23, 24, 24, 25, 26, 26, 25,
27, 26, 26, 26, 27, 26, 25, 25, 26, 26, 26, 27, 26, 27, 26, 26, 26, 25, 24, 23,
22, 22, 21, 20, 19, 17, 15, 13, 11, 8, 6, 5, 2, 1, -1, -2, -3, -3, -3, -3, -3,
-2, -1, -1, -1, -1, -2, -1, -2, -2, -2, -2, -2, -4, -5, -5, -8, -8, -10, -12,
-14, -17, -21, -23, -25, -27, -29, -32, -35, -37, -39, -40, -41, -43, -43, -44,
-45, -45, -44, -45, -44, -45, -45, -46, -47, -48, -49, -50, -51, -53, -55, -56,
-56, -57, -58, -57, -58, -59, -59, -57, -58, -58, -58, -57, -58, -58, -58, -58,
-58, -59, -59, -59, -60, -60, -60, -60, -59, -59, -59, -59, -58, -58, -58, -57,
-58, -57, -57, -56, -57, -56, -56, -56, -56, -56, -55, -55, -55, -54, -54, -55,
-53, -54, -53, -53, -52, -53, -52, -51, -52, -51, -50, -49, -48, -48, -46, -44,
-43, -41, -40, -38, -36, -33, -32, -29, -29, -27, -26, -25, -24, -22, -21, -21,
-19, -19, -19, -18, -17, -18, -16, -16, -16, -15, -16, -16, -16, -16, -16, -16,
-15, -15, -15, -16, -15, -15, -15, -16, -16, -15, -16, -16, -17, -18, -18, -18,
-19, -20, -19, -21, -21, -21, -21, -21, -22, -22, -22, -21, -22, -22, -22, -22,
-22, -22, -22, -23, -22, -23, -23, -24, -25, -24, -25, -23, -23, -24, -24, -23,
-23, -22, -21, -21, -21, -19, -17, -16, -15, -14, -12, -10, -8, -5, -2, };