#define DATA_LENGTH 512
#define DATA AKWF_cello_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 8, 9, 10, 12, 13, 13, 14, 15,
17, 18, 21, 24, 26, 29, 31, 32, 35, 37, 39, 41, 42, 44, 46, 47, 47, 48, 48, 49,
49, 50, 52, 53, 54, 56, 57, 59, 60, 61, 63, 64, 67, 69, 70, 72, 73, 75, 75, 75,
76, 77, 76, 77, 77, 76, 76, 76, 76, 75, 75, 73, 73, 73, 71, 71, 70, 72, 71, 70,
71, 71, 71, 70, 70, 71, 70, 71, 72, 72, 73, 74, 75, 76, 78, 78, 80, 81, 82, 83,
84, 86, 86, 86, 87, 88, 88, 89, 90, 91, 92, 94, 97, 99, 103, 106, 108, 111, 113,
115, 117, 117, 118, 119, 119, 118, 118, 117, 115, 112, 109, 107, 105, 103, 102,
101, 100, 99, 97, 97, 95, 94, 93, 91, 89, 88, 86, 85, 83, 82, 80, 77, 76, 75,
73, 72, 72, 70, 71, 70, 71, 70, 70, 69, 68, 66, 65, 63, 62, 59, 58, 55, 52, 50,
46, 43, 40, 36, 33, 31, 27, 25, 22, 18, 16, 14, 11, 8, 5, 1, -2, -6, -10, -14,
-18, -22, -27, -32, -35, -39, -42, -46, -50, -52, -54, -55, -57, -58, -60, -62,
-62, -64, -65, -67, -69, -70, -72, -75, -77, -79, -81, -84, -86, -88, -91, -93,
-94, -95, -97, -98, -99, -100, -102, -103, -104, -105, -106, -107, -108, -107,
-108, -109, -109, -110, -109, -109, -108, -106, -106, -105, -103, -102, -101,
-100, -99, -99, -99, -98, -99, -100, -100, -100, -101, -101, -102, -103, -103,
-103, -103, -103, -103, -103, -102, -101, -99, -97, -96, -93, -91, -89, -86,
-83, -80, -77, -74, -72, -69, -66, -62, -59, -56, -51, -48, -44, -40, -36, -32,
-28, -23, -18, -14, -8, -4, 1, 4, 8, 12, 14, 16, 16, 17, 16, 16, 16, 16, 15, 14,
14, 11, 11, 9, 9, 10, 9, 9, 9, 9, 10, 10, 8, 8, 8, 6, 5, 5, 3, 3, 2, 2, 2, 3, 3,
3, 5, 5, 7, 8, 9, 10, 12, 14, 15, 16, 17, 18, 18, 20, 20, 21, 21, 21, 22, 23,
23, 25, 24, 25, 23, 23, 22, 20, 19, 17, 16, 14, 12, 11, 9, 8, 6, 5, 3, 2, 1, 1,
1, -1, 0, -1, 0, 0, 0, 0, 0, 1, 1, 0, 1, 2, 1, 1, 2, 2, 1, 2, 1, 1, 1, 1, 1, 1,
1, 0, -1, -2, -2, -4, -4, -6, -7, -10, -12, -14, -18, -20, -23, -26, -30, -32,
-37, -41, -44, -47, -50, -53, -55, -58, -60, -63, -65, -68, -70, -72, -76, -77,
-80, -82, -84, -86, -87, -89, -90, -90, -92, -91, -91, -91, -90, -90, -88, -87,
-85, -83, -81, -80, -78, -75, -73, -71, -69, -65, -62, -59, -55, -51, -48, -45,
-40, -37, -34, -30, -28, -25, -22, -21, -19, -17, -16, -15, -13, -13, -13, -13,
-13, -14, -13, -14, -13, -13, -14, -14, -14, -15, -15, -15, -18, -18, -20, -19,
-18, -19, -18, -18, -17, -17, -16, -15, -14, -12, -9, -6, -2, };