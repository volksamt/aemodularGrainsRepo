#define DATA_LENGTH 512
#define DATA AKWF_cello_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 9, 11, 14, 18, 20, 24, 26, 28,
30, 32, 34, 35, 36, 39, 39, 40, 42, 43, 43, 45, 46, 48, 49, 50, 52, 53, 55, 57,
59, 61, 63, 66, 68, 72, 74, 78, 81, 85, 88, 92, 96, 99, 102, 105, 108, 110, 112,
115, 117, 118, 118, 118, 119, 119, 118, 117, 116, 115, 112, 111, 109, 106, 104,
101, 99, 96, 94, 91, 88, 86, 82, 80, 76, 74, 71, 68, 66, 64, 61, 59, 56, 56, 54,
52, 50, 48, 47, 46, 44, 42, 41, 40, 39, 37, 35, 33, 31, 30, 28, 25, 23, 21, 18,
16, 14, 11, 8, 6, 4, 0, -2, -5, -9, -12, -14, -18, -21, -23, -26, -29, -31, -33,
-35, -37, -40, -41, -42, -44, -45, -46, -47, -48, -48, -48, -48, -47, -47, -46,
-44, -43, -42, -41, -39, -37, -35, -34, -32, -30, -30, -28, -28, -27, -26, -26,
-25, -26, -26, -26, -25, -26, -26, -26, -25, -26, -26, -25, -25, -25, -25, -24,
-24, -24, -24, -24, -24, -24, -24, -23, -23, -23, -23, -22, -22, -22, -22, -23,
-23, -23, -23, -22, -22, -23, -25, -24, -25, -25, -27, -28, -29, -30, -30, -31,
-30, -31, -32, -33, -33, -32, -32, -32, -31, -31, -30, -29, -28, -27, -26, -25,
-23, -22, -20, -18, -15, -13, -11, -8, -5, -2, 1, 5, 7, 10, 13, 17, 21, 24, 29,
32, 35, 39, 42, 45, 48, 50, 53, 55, 57, 59, 61, 63, 62, 64, 63, 64, 63, 64, 61,
60, 58, 57, 55, 53, 51, 49, 46, 45, 44, 43, 42, 41, 42, 41, 41, 42, 43, 42, 44,
43, 43, 43, 43, 43, 42, 41, 41, 40, 38, 37, 35, 34, 32, 29, 26, 23, 19, 16, 13,
9, 5, 1, -2, -6, -9, -12, -14, -16, -19, -20, -21, -22, -22, -23, -23, -23, -23,
-22, -22, -22, -20, -19, -17, -16, -14, -12, -10, -8, -5, -4, -2, -2, 0, 1, 0,
0, 0, -1, -1, -2, -3, -3, -5, -5, -6, -6, -6, -7, -7, -6, -6, -5, -6, -7, -6,
-6, -6, -7, -8, -7, -8, -10, -10, -12, -14, -15, -17, -18, -19, -20, -21, -23,
-24, -25, -26, -26, -27, -26, -26, -26, -25, -25, -24, -23, -23, -23, -22, -22,
-21, -20, -21, -20, -20, -21, -21, -23, -23, -24, -24, -27, -28, -30, -31, -33,
-36, -37, -39, -41, -42, -44, -44, -46, -47, -48, -48, -48, -47, -47, -46, -46,
-43, -43, -40, -38, -38, -36, -33, -32, -31, -28, -27, -25, -25, -23, -23, -23,
-23, -23, -23, -24, -24, -25, -26, -28, -29, -31, -32, -33, -34, -36, -37, -37,
-37, -37, -37, -36, -35, -33, -32, -29, -27, -25, -22, -20, -16, -15, -12, -9,
-6, -4, -1, -1, 2, 2, 3, 3, 3, 2, 1, -1, -2, -4, -8, -11, -13, -16, -19, -22,
-24, -27, -29, -29, -32, -31, -32, -33, -32, -31, -31, -30, -28, -26, -25, -22,
-21, -18, -16, -14, -10, -9, -6, -2, };