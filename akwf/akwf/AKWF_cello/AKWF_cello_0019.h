#define DATA_LENGTH 512
#define DATA AKWF_cello_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 5, 6, 9, 10, 11, 13, 14,
16, 17, 18, 21, 22, 25, 26, 28, 29, 32, 33, 36, 38, 39, 40, 42, 43, 45, 46, 47,
48, 49, 50, 51, 52, 53, 54, 55, 56, 56, 57, 57, 57, 59, 59, 60, 60, 61, 61, 62,
64, 64, 65, 67, 67, 69, 70, 71, 73, 74, 75, 77, 79, 81, 81, 83, 84, 85, 86, 87,
88, 88, 88, 87, 88, 87, 86, 85, 84, 83, 81, 79, 77, 73, 72, 68, 66, 63, 60, 57,
55, 52, 50, 47, 46, 44, 42, 41, 40, 39, 39, 38, 38, 38, 37, 38, 38, 39, 39, 38,
38, 39, 39, 39, 40, 39, 39, 39, 40, 39, 38, 38, 37, 35, 35, 34, 32, 31, 29, 25,
23, 21, 18, 15, 12, 9, 5, 0, -4, -7, -11, -16, -20, -23, -28, -32, -35, -39,
-42, -45, -49, -51, -54, -56, -58, -59, -61, -62, -64, -64, -64, -65, -65, -64,
-63, -62, -61, -60, -58, -57, -56, -54, -52, -50, -49, -47, -45, -43, -42, -39,
-38, -37, -35, -34, -33, -32, -33, -31, -31, -31, -31, -31, -31, -33, -33, -34,
-36, -39, -40, -42, -45, -47, -50, -54, -57, -60, -63, -67, -71, -75, -78, -82,
-85, -88, -92, -96, -98, -100, -103, -106, -109, -111, -112, -114, -115, -116,
-117, -118, -119, -119, -119, -119, -119, -118, -117, -116, -115, -113, -112,
-110, -109, -107, -106, -105, -103, -102, -99, -98, -97, -95, -95, -92, -92,
-91, -90, -88, -86, -86, -84, -84, -82, -80, -80, -79, -76, -75, -73, -71, -69,
-67, -65, -61, -60, -57, -54, -51, -48, -45, -43, -39, -36, -33, -30, -28, -24,
-21, -18, -14, -12, -8, -6, -2, 1, 4, 6, 10, 13, 16, 18, 21, 24, 27, 29, 32, 34,
36, 38, 41, 44, 46, 47, 50, 52, 53, 55, 56, 58, 60, 60, 62, 63, 65, 64, 65, 66,
66, 66, 67, 67, 66, 65, 66, 65, 64, 63, 63, 62, 62, 62, 60, 59, 59, 59, 59, 59,
59, 59, 60, 60, 60, 61, 62, 63, 64, 64, 66, 67, 67, 69, 69, 70, 70, 71, 71, 71,
71, 70, 70, 70, 68, 68, 66, 65, 64, 62, 59, 57, 55, 52, 50, 47, 42, 40, 36, 34,
31, 27, 24, 22, 20, 18, 15, 13, 11, 9, 7, 5, 3, 2, 2, 0, 0, -1, -2, -3, -3, -4,
-5, -6, -6, -7, -7, -7, -7, -8, -8, -9, -9, -9, -10, -10, -11, -12, -12, -11,
-12, -11, -12, -11, -13, -13, -12, -13, -13, -13, -13, -13, -13, -14, -13, -14,
-13, -12, -13, -13, -13, -13, -12, -10, -9, -9, -9, -8, -7, -6, -5, -4, -3, -3,
-1, 0, 0, 1, 2, 2, 3, 4, 4, 4, 3, 4, 3, 2, 2, 1, 0, 0, -2, -2, -4, -5, -6, -7,
-8, -9, -10, -10, -10, -11, -12, -11, -11, -11, -11, -11, -11, -9, -10, -9, -8,
-8, -7, -7, -6, -6, -4, -3, -2, -2, 0, 0, };