#define DATA_LENGTH 512
#define DATA AKWF_cello_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 6, 8, 9, 10, 11, 12, 12, 13, 13,
14, 14, 13, 13, 13, 12, 13, 13, 12, 12, 12, 13, 13, 14, 16, 17, 19, 20, 23, 25,
28, 30, 33, 36, 39, 43, 46, 49, 51, 53, 57, 60, 60, 63, 64, 65, 65, 65, 65, 65,
64, 63, 62, 60, 58, 57, 56, 54, 52, 51, 50, 48, 48, 48, 48, 48, 49, 50, 51, 53,
54, 56, 57, 59, 60, 62, 64, 64, 64, 64, 64, 65, 64, 63, 61, 60, 58, 56, 54, 52,
51, 49, 48, 46, 45, 45, 43, 43, 42, 42, 42, 44, 44, 46, 45, 47, 49, 51, 53, 56,
57, 59, 62, 65, 67, 68, 70, 71, 73, 73, 73, 72, 71, 69, 67, 65, 61, 57, 53, 47,
43, 37, 31, 26, 20, 13, 7, 2, -4, -11, -15, -20, -25, -28, -33, -36, -38, -41,
-43, -46, -47, -48, -47, -49, -48, -48, -49, -49, -48, -48, -49, -48, -50, -49,
-50, -52, -52, -53, -55, -57, -57, -59, -60, -61, -62, -63, -64, -65, -65, -66,
-66, -65, -65, -64, -63, -60, -58, -56, -52, -48, -45, -40, -36, -31, -26, -20,
-16, -11, -5, 1, 6, 12, 17, 22, 27, 30, 36, 40, 44, 48, 53, 54, 56, 59, 61, 63,
63, 64, 64, 64, 63, 62, 61, 59, 58, 58, 56, 53, 52, 48, 46, 43, 39, 35, 30, 28,
25, 21, 17, 14, 11, 9, 6, 4, 3, 0, -1, -3, -4, -2, -2, 0, 0, 0, 1, 2, 3, 5, 6,
7, 8, 8, 10, 12, 13, 12, 11, 10, 10, 9, 9, 6, 5, 4, 1, -1, -4, -6, -10, -12,
-14, -15, -16, -17, -18, -18, -21, -21, -21, -20, -20, -19, -17, -14, -11, -9,
-7, -5, -3, -2, 1, 3, 6, 9, 11, 13, 15, 16, 19, 22, 23, 25, 27, 29, 32, 33, 34,
36, 35, 33, 32, 29, 26, 22, 19, 15, 11, 6, -3, -10, -15, -20, -24, -30, -34,
-38, -40, -43, -44, -45, -45, -47, -46, -47, -48, -49, -50, -51, -53, -54, -56,
-57, -61, -63, -67, -71, -75, -78, -83, -88, -93, -97, -101, -104, -109, -112,
-115, -118, -119, -119, -119, -118, -116, -114, -111, -108, -106, -102, -99,
-96, -93, -88, -84, -80, -76, -73, -68, -65, -61, -58, -55, -53, -50, -47, -44,
-41, -39, -37, -35, -32, -30, -27, -25, -22, -19, -17, -15, -12, -10, -8, -7,
-4, -2, -1, 1, 2, 4, 6, 7, 9, 10, 12, 15, 16, 18, 21, 24, 27, 30, 32, 35, 38,
41, 45, 47, 49, 52, 54, 55, 56, 56, 57, 57, 55, 56, 55, 54, 53, 51, 48, 47, 44,
40, 38, 35, 32, 30, 28, 26, 25, 23, 22, 21, 19, 17, 17, 15, 13, 12, 11, 10, 9,
8, 8, 6, 7, 6, 5, 4, 2, 0, -1, -2, -5, -6, -9, -10, -12, -13, -16, -18, -19,
-21, -23, -23, -24, -25, -24, -24, -24, -24, -22, -20, -18, -15, -13, -11, -8,
-4, -3, -1, };