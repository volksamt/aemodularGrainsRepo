#define DATA_LENGTH 512
#define DATA AKWF_cello_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 8, 11, 14, 18, 20, 23, 25, 26,
28, 28, 29, 29, 30, 29, 28, 27, 26, 25, 23, 22, 21, 20, 19, 19, 19, 19, 20, 20,
21, 22, 24, 26, 29, 30, 34, 36, 38, 40, 43, 46, 48, 49, 51, 53, 54, 55, 55, 54,
54, 53, 53, 51, 49, 47, 45, 42, 40, 37, 35, 33, 31, 29, 27, 25, 23, 22, 20, 19,
18, 18, 17, 18, 18, 17, 19, 19, 20, 22, 23, 24, 25, 27, 29, 28, 31, 31, 33, 34,
34, 34, 34, 35, 34, 34, 33, 31, 30, 28, 27, 25, 23, 20, 18, 16, 14, 12, 10, 9,
8, 5, 5, 4, 3, 2, 2, 3, 3, 3, 5, 5, 8, 9, 13, 15, 18, 22, 26, 30, 35, 40, 46,
51, 56, 62, 69, 75, 80, 86, 90, 95, 101, 105, 108, 111, 114, 117, 118, 119, 119,
119, 118, 117, 114, 111, 108, 104, 100, 94, 90, 85, 80, 74, 69, 63, 56, 51, 46,
40, 35, 29, 24, 19, 14, 10, 5, 2, -4, -8, -12, -16, -20, -23, -28, -31, -34,
-37, -41, -43, -46, -50, -53, -57, -61, -63, -66, -69, -71, -73, -75, -77, -79,
-80, -79, -80, -80, -81, -80, -78, -76, -74, -71, -68, -65, -61, -58, -55, -51,
-48, -44, -41, -37, -34, -30, -27, -24, -20, -19, -17, -15, -13, -12, -11, -11,
-11, -10, -10, -10, -11, -11, -11, -12, -13, -15, -17, -18, -18, -20, -21, -23,
-26, -27, -30, -31, -32, -34, -36, -38, -39, -40, -41, -41, -43, -43, -44, -44,
-45, -45, -45, -46, -46, -46, -45, -45, -44, -42, -42, -40, -39, -38, -37, -36,
-35, -35, -33, -32, -32, -32, -32, -33, -33, -33, -34, -35, -37, -37, -40, -41,
-43, -44, -45, -48, -49, -51, -52, -55, -56, -58, -60, -61, -62, -63, -63, -65,
-65, -66, -66, -67, -68, -68, -69, -70, -69, -69, -71, -71, -71, -71, -71, -72,
-72, -73, -73, -74, -73, -73, -73, -72, -72, -71, -69, -69, -67, -64, -63, -60,
-57, -54, -50, -44, -41, -37, -32, -27, -23, -17, -13, -9, -4, 0, 4, 7, 11, 15,
18, 21, 24, 25, 27, 30, 30, 32, 32, 33, 33, 34, 35, 34, 35, 35, 35, 35, 35, 34,
34, 34, 34, 34, 33, 34, 35, 35, 35, 36, 37, 37, 38, 39, 41, 42, 42, 43, 45, 47,
47, 49, 50, 51, 52, 53, 54, 56, 57, 57, 59, 60, 60, 60, 62, 62, 62, 61, 61, 61,
61, 61, 61, 60, 59, 59, 58, 56, 55, 53, 51, 48, 45, 41, 38, 34, 30, 26, 21, 18,
12, 8, 2, -2, -7, -12, -15, -19, -22, -24, -27, -29, -31, -32, -32, -34, -33,
-32, -32, -30, -28, -26, -24, -21, -17, -13, -10, -6, -3, 1, 4, 6, 10, 13, 14,
16, 17, 18, 18, 17, 17, 14, 11, 10, 6, 3, 1, -3, -6, -8, -12, -13, -16, -18,
-19, -21, -21, -21, -21, -20, -17, -15, -12, -9, -5, -3, -1, };