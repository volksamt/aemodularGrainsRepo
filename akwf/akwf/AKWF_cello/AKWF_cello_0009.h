#define DATA_LENGTH 512
#define DATA AKWF_cello_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 11, 16, 21, 25, 29, 32, 37, 39,
43, 46, 47, 48, 49, 51, 50, 49, 49, 48, 46, 44, 41, 39, 36, 34, 32, 29, 26, 25,
23, 22, 23, 22, 23, 25, 26, 29, 32, 36, 40, 46, 51, 57, 63, 69, 75, 81, 86, 92,
97, 101, 106, 109, 113, 115, 117, 119, 119, 119, 118, 116, 113, 110, 106, 102,
98, 93, 87, 82, 76, 72, 65, 61, 56, 51, 47, 44, 39, 37, 34, 31, 29, 27, 26, 25,
25, 25, 25, 26, 27, 26, 27, 27, 28, 28, 29, 27, 26, 26, 25, 23, 21, 19, 16, 13,
11, 8, 5, 2, -2, -5, -9, -11, -15, -18, -21, -23, -26, -29, -31, -34, -36, -38,
-40, -41, -42, -43, -45, -45, -45, -44, -44, -43, -41, -40, -39, -38, -36, -33,
-31, -29, -27, -24, -22, -19, -15, -13, -10, -7, -5, -3, -1, -1, 1, 2, 2, 1, 0,
-1, -3, -6, -7, -11, -14, -17, -20, -22, -25, -28, -29, -31, -32, -32, -33, -33,
-33, -32, -31, -30, -29, -27, -25, -24, -22, -21, -20, -18, -18, -17, -15, -15,
-14, -14, -13, -12, -12, -12, -12, -13, -13, -15, -15, -17, -17, -19, -20, -22,
-23, -24, -26, -27, -27, -28, -28, -28, -28, -28, -27, -25, -25, -23, -22, -21,
-18, -16, -15, -14, -11, -10, -7, -6, -3, -2, 0, 1, 4, 7, 8, 11, 13, 16, 18, 22,
23, 25, 28, 31, 33, 36, 38, 39, 42, 43, 44, 45, 46, 48, 48, 50, 51, 51, 51, 51,
50, 47, 46, 44, 43, 41, 39, 38, 37, 36, 36, 37, 37, 37, 38, 38, 39, 39, 41, 41,
43, 43, 44, 45, 46, 45, 45, 45, 45, 43, 42, 40, 37, 33, 30, 25, 21, 17, 11, 6,
0, -6, -10, -16, -20, -24, -29, -32, -35, -36, -39, -40, -40, -40, -40, -40,
-38, -36, -35, -33, -31, -28, -25, -21, -17, -12, -7, -3, 1, 4, 7, 10, 12, 12,
13, 14, 15, 14, 15, 14, 14, 13, 12, 12, 10, 10, 9, 9, 9, 10, 10, 11, 12, 11, 11,
12, 11, 11, 11, 11, 10, 10, 9, 9, 7, 7, 5, 3, 1, -3, -5, -8, -9, -13, -15, -16,
-18, -20, -22, -23, -25, -26, -26, -27, -27, -27, -28, -27, -27, -27, -27, -27,
-29, -28, -29, -29, -30, -32, -33, -34, -36, -38, -39, -41, -43, -45, -47, -48,
-50, -52, -53, -54, -55, -55, -55, -53, -53, -51, -48, -44, -40, -36, -33, -29,
-25, -21, -17, -13, -10, -7, -5, -2, 0, 1, 2, 2, 2, 2, 2, 0, -2, -4, -7, -9,
-14, -16, -19, -24, -27, -31, -35, -37, -40, -43, -43, -44, -44, -44, -42, -41,
-39, -36, -35, -31, -28, -24, -20, -15, -11, -7, -3, 1, 3, 6, 9, 10, 11, 12, 12,
12, 10, 8, 5, 2, -1, -5, -9, -12, -17, -20, -23, -26, -28, -29, -31, -31, -32,
-32, -30, -28, -26, -22, -20, -15, -11, -9, -4, 0, };