#define DATA_LENGTH 512
#define DATA AKWF_cello_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 8, 11, 13, 17, 20, 23, 29,
32, 36, 41, 46, 50, 55, 60, 64, 69, 73, 79, 81, 86, 90, 92, 95, 99, 101, 102,
105, 106, 108, 108, 109, 109, 110, 109, 110, 109, 108, 109, 109, 108, 109, 108,
108, 108, 107, 107, 107, 107, 107, 107, 106, 105, 104, 104, 102, 100, 99, 97,
95, 93, 90, 88, 85, 82, 79, 75, 73, 69, 67, 63, 61, 57, 55, 52, 51, 48, 46, 44,
42, 41, 41, 39, 39, 39, 39, 39, 39, 40, 41, 41, 43, 44, 46, 48, 50, 51, 54, 55,
57, 59, 61, 63, 65, 66, 69, 69, 72, 73, 76, 78, 79, 80, 82, 84, 85, 87, 89, 91,
93, 94, 96, 97, 98, 100, 102, 102, 103, 103, 104, 105, 105, 106, 105, 105, 105,
104, 105, 104, 104, 102, 102, 101, 101, 99, 98, 98, 95, 95, 92, 91, 89, 87, 84,
82, 80, 78, 75, 72, 69, 67, 63, 61, 58, 55, 51, 48, 44, 41, 37, 34, 31, 26, 23,
19, 16, 11, 9, 4, 0, -4, -7, -11, -14, -17, -21, -24, -26, -30, -32, -35, -38,
-40, -42, -44, -45, -46, -48, -48, -47, -48, -47, -47, -45, -44, -42, -39, -36,
-32, -28, -25, -20, -17, -12, -7, -2, 2, 6, 11, 16, 20, 24, 28, 32, 36, 40, 43,
45, 49, 51, 53, 55, 57, 58, 60, 61, 62, 64, 66, 65, 65, 66, 65, 66, 66, 68, 67,
68, 66, 66, 65, 64, 63, 62, 59, 56, 54, 51, 47, 45, 40, 35, 31, 25, 20, 14, 8,
1, -6, -12, -19, -26, -32, -39, -45, -52, -59, -65, -71, -77, -83, -89, -92,
-96, -100, -105, -107, -109, -112, -113, -115, -115, -117, -118, -119, -119,
-119, -118, -117, -115, -114, -113, -111, -108, -105, -103, -102, -100, -98,
-96, -94, -92, -91, -90, -89, -88, -87, -86, -86, -85, -84, -83, -82, -80, -79,
-77, -76, -73, -71, -67, -63, -60, -55, -51, -47, -41, -37, -32, -26, -21, -16,
-11, -6, -3, 1, 4, 7, 10, 11, 12, 12, 12, 11, 9, 9, 6, 4, 1, -3, -6, -10, -14,
-18, -20, -23, -25, -28, -29, -31, -32, -33, -33, -33, -34, -33, -33, -33, -32,
-33, -33, -32, -32, -32, -33, -32, -33, -33, -34, -36, -38, -39, -41, -44, -45,
-48, -50, -52, -56, -58, -61, -63, -67, -70, -73, -78, -80, -83, -86, -88, -91,
-93, -95, -98, -100, -103, -104, -105, -107, -107, -108, -108, -108, -108, -107,
-105, -104, -102, -100, -97, -93, -90, -87, -83, -78, -74, -69, -65, -60, -55,
-50, -44, -40, -34, -30, -26, -21, -18, -14, -10, -7, -5, -3, -1, 1, 0, 1, 1, 0,
-2, -3, -6, -7, -10, -13, -17, -21, -24, -29, -33, -36, -41, -44, -48, -51, -55,
-58, -59, -62, -63, -64, -65, -65, -65, -63, -62, -61, -59, -56, -53, -51, -47,
-44, -40, -36, -34, -30, -27, -24, -22, -19, -16, -16, -13, -12, -9, -9, -6, -4,
-2, 0, };