#define DATA_LENGTH 512
#define DATA AKWF_cello_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 3, 4, 4, 4, 6, 6, 6, 6, 7, 7,
7, 7, 8, 8, 8, 8, 8, 8, 8, 9, 10, 9, 10, 11, 12, 12, 13, 15, 16, 19, 21, 23, 27,
30, 33, 36, 41, 46, 49, 54, 58, 62, 67, 70, 75, 78, 81, 85, 87, 89, 91, 93, 93,
94, 94, 95, 93, 93, 91, 90, 87, 85, 83, 82, 79, 77, 75, 73, 72, 69, 68, 68, 68,
67, 67, 66, 68, 68, 70, 71, 73, 73, 75, 77, 78, 80, 81, 83, 84, 85, 86, 87, 87,
87, 86, 87, 85, 85, 84, 82, 81, 79, 75, 73, 69, 65, 61, 54, 50, 45, 39, 33, 27,
22, 16, 10, 6, 1, -4, -9, -12, -16, -19, -22, -24, -26, -28, -30, -31, -31, -31,
-31, -31, -30, -29, -27, -26, -23, -22, -20, -16, -14, -11, -7, -4, 0, 3, 7, 9,
12, 14, 16, 18, 18, 20, 21, 21, 21, 21, 22, 21, 21, 20, 19, 18, 16, 15, 14, 12,
11, 10, 8, 6, 4, 2, 1, -1, -3, -5, -7, -7, -9, -10, -11, -13, -13, -15, -15,
-14, -13, -13, -11, -9, -8, -5, -3, 0, 3, 7, 11, 15, 19, 23, 28, 33, 37, 41, 44,
47, 50, 53, 56, 59, 60, 61, 64, 64, 64, 64, 62, 62, 59, 56, 53, 50, 48, 44, 42,
39, 35, 31, 28, 23, 20, 17, 15, 14, 11, 9, 5, 3, 0, -4, -8, -11, -14, -17, -21,
-23, -25, -27, -30, -32, -34, -34, -36, -36, -37, -36, -36, -36, -35, -34, -33,
-32, -30, -30, -27, -26, -24, -22, -22, -21, -21, -19, -19, -18, -18, -18, -17,
-17, -16, -15, -15, -15, -16, -16, -16, -18, -20, -21, -21, -23, -25, -26, -28,
-29, -31, -33, -36, -38, -39, -41, -41, -41, -40, -38, -37, -36, -34, -33, -31,
-28, -25, -22, -16, -12, -7, -2, 3, 9, 14, 20, 26, 30, 35, 40, 44, 47, 49, 50,
49, 47, 45, 42, 39, 35, 31, 26, 22, 17, 10, 5, 0, -5, -11, -15, -19, -21, -24,
-25, -27, -26, -27, -27, -27, -27, -26, -26, -26, -26, -27, -28, -30, -31, -34,
-36, -41, -44, -48, -53, -58, -63, -69, -74, -81, -86, -92, -98, -103, -108,
-112, -115, -117, -119, -119, -119, -118, -118, -118, -116, -115, -113, -111,
-109, -108, -105, -103, -102, -100, -98, -96, -96, -94, -94, -93, -92, -92, -93,
-93, -93, -94, -95, -96, -96, -97, -98, -98, -97, -97, -96, -95, -95, -94, -92,
-89, -85, -82, -77, -73, -67, -61, -56, -49, -43, -36, -28, -22, -15, -7, 0, 6,
14, 19, 27, 32, 38, 43, 49, 54, 59, 62, 67, 70, 73, 75, 77, 77, 79, 80, 81, 82,
84, 84, 84, 84, 84, 83, 81, 80, 78, 76, 72, 69, 65, 61, 58, 52, 48, 44, 38, 34,
28, 23, 18, 14, 10, 6, 1, -2, -5, -7, -8, -10, -11, -12, -12, -12, -12, -11,
-10, -9, -8, -7, -6, -4, -3, -1, 0, };