#define DATA_LENGTH 512
#define DATA AKWF_cello_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 12, 16, 21, 25, 29, 33, 36, 40,
42, 45, 48, 49, 50, 50, 50, 49, 49, 48, 47, 44, 42, 39, 37, 35, 32, 29, 27, 25,
24, 23, 23, 22, 24, 25, 26, 29, 32, 36, 41, 45, 50, 56, 61, 68, 74, 80, 86, 92,
96, 101, 106, 109, 113, 116, 118, 119, 118, 119, 118, 116, 113, 110, 107, 103,
98, 92, 88, 82, 76, 72, 67, 61, 57, 52, 48, 44, 39, 37, 34, 31, 30, 28, 26, 25,
25, 25, 24, 26, 26, 26, 27, 28, 28, 28, 28, 27, 27, 27, 25, 24, 22, 19, 16, 14,
11, 8, 5, 2, -2, -5, -8, -12, -14, -17, -21, -23, -27, -29, -31, -34, -37, -38,
-40, -41, -43, -44, -44, -44, -44, -44, -44, -43, -42, -41, -39, -38, -37, -34,
-32, -29, -27, -24, -21, -19, -16, -14, -11, -8, -5, -3, -2, 0, 2, 2, 2, 2, 0,
0, -3, -5, -8, -10, -13, -16, -20, -22, -25, -27, -30, -30, -32, -32, -32, -32,
-32, -32, -30, -30, -29, -28, -26, -24, -23, -21, -20, -20, -18, -18, -16, -15,
-14, -13, -13, -12, -12, -12, -12, -13, -13, -14, -16, -17, -18, -19, -21, -21,
-23, -24, -25, -27, -27, -28, -28, -28, -28, -27, -27, -26, -24, -23, -22, -20,
-19, -16, -15, -13, -12, -9, -7, -5, -5, -2, 0, 2, 4, 7, 8, 11, 14, 16, 18, 20,
23, 25, 28, 31, 32, 36, 38, 40, 41, 43, 44, 45, 46, 48, 50, 51, 51, 51, 51, 51,
50, 48, 46, 44, 42, 41, 39, 38, 37, 36, 37, 36, 36, 38, 38, 38, 39, 39, 40, 41,
42, 43, 44, 45, 45, 46, 45, 46, 45, 44, 43, 40, 36, 35, 30, 26, 22, 17, 11, 7,
0, -6, -10, -15, -21, -24, -28, -31, -34, -36, -39, -38, -41, -40, -40, -40,
-39, -37, -35, -34, -31, -28, -25, -21, -16, -13, -8, -4, 0, 4, 7, 9, 12, 13,
15, 15, 15, 15, 14, 14, 14, 13, 13, 12, 11, 10, 8, 10, 9, 10, 9, 10, 11, 12, 11,
11, 11, 12, 10, 10, 10, 9, 9, 9, 8, 6, 5, 2, 1, -2, -5, -7, -9, -12, -14, -17,
-18, -20, -22, -23, -25, -25, -26, -27, -27, -28, -27, -28, -27, -27, -27, -27,
-28, -28, -29, -29, -31, -32, -32, -34, -36, -37, -39, -41, -43, -44, -47, -48,
-50, -52, -53, -54, -55, -56, -55, -54, -52, -51, -48, -45, -41, -38, -33, -29,
-25, -21, -18, -13, -11, -7, -5, -3, 0, 2, 3, 3, 3, 1, 1, 0, -2, -4, -7, -10,
-12, -16, -19, -22, -27, -30, -33, -36, -39, -41, -43, -45, -43, -44, -43, -42,
-39, -36, -35, -31, -27, -24, -21, -15, -12, -8, -3, 0, 4, 7, 8, 11, 11, 12, 11,
11, 10, 8, 6, 2, -1, -5, -8, -13, -16, -19, -23, -26, -29, -30, -31, -31, -32,
-32, -30, -28, -25, -22, -20, -16, -13, -9, -5, 0, };