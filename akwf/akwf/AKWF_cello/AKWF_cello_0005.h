#define DATA_LENGTH 512
#define DATA AKWF_cello_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 6, 9, 12, 14, 19, 22, 25, 27, 31,
34, 37, 40, 44, 47, 50, 54, 56, 59, 62, 64, 66, 69, 71, 74, 76, 79, 82, 84, 86,
88, 90, 91, 91, 90, 90, 89, 89, 87, 85, 83, 80, 77, 74, 72, 68, 64, 60, 56, 52,
48, 46, 41, 38, 33, 28, 25, 22, 18, 14, 12, 9, 6, 5, 4, 4, 1, 2, 1, -2, -2, -1,
-2, -2, -2, -2, 0, 1, 1, 1, 2, 1, 1, 0, 0, -1, -2, -4, -5, -8, -9, -12, -13,
-15, -17, -18, -19, -19, -20, -20, -20, -19, -18, -17, -16, -16, -13, -11, -8,
-5, -2, 0, 3, 5, 6, 7, 9, 10, 11, 13, 14, 15, 16, 18, 19, 19, 22, 24, 25, 27,
29, 31, 33, 36, 39, 41, 44, 47, 51, 54, 58, 59, 62, 64, 66, 68, 70, 73, 75, 76,
79, 81, 83, 85, 87, 88, 88, 87, 87, 87, 86, 86, 85, 86, 84, 84, 84, 83, 82, 81,
79, 77, 77, 76, 74, 74, 74, 74, 73, 74, 72, 71, 68, 67, 64, 63, 61, 60, 58, 57,
55, 54, 51, 51, 49, 48, 45, 45, 44, 44, 44, 45, 44, 43, 43, 42, 42, 42, 42, 41,
40, 39, 37, 36, 35, 33, 30, 28, 26, 24, 21, 18, 14, 12, 9, 8, 5, 3, 0, -2, -2,
-3, -3, -3, -3, -5, -7, -7, -7, -7, -6, -7, -7, -7, -9, -10, -11, -15, -17, -21,
-24, -27, -28, -30, -32, -34, -37, -38, -40, -41, -40, -41, -40, -39, -38, -37,
-36, -36, -36, -38, -38, -38, -39, -41, -42, -45, -48, -49, -53, -56, -58, -61,
-63, -66, -66, -66, -66, -65, -64, -62, -61, -58, -55, -51, -50, -48, -44, -41,
-38, -36, -33, -32, -29, -27, -24, -22, -18, -17, -14, -13, -8, -6, -2, 2, 6,
10, 14, 19, 24, 28, 33, 37, 41, 44, 48, 51, 54, 57, 59, 62, 62, 65, 65, 64, 64,
64, 64, 62, 61, 60, 59, 58, 55, 55, 54, 54, 56, 56, 57, 57, 58, 59, 58, 58, 58,
57, 55, 54, 54, 52, 49, 46, 45, 40, 37, 34, 31, 27, 24, 20, 16, 14, 11, 9, 6, 3,
1, 0, -2, -2, -3, -3, -5, -5, -5, -5, -6, -6, -7, -9, -10, -12, -15, -16, -19,
-23, -25, -28, -31, -32, -34, -35, -37, -39, -39, -41, -40, -43, -45, -48, -50,
-53, -55, -58, -60, -62, -64, -67, -69, -72, -74, -77, -81, -84, -87, -90, -95,
-97, -100, -102, -104, -106, -107, -108, -108, -110, -110, -110, -111, -112,
-114, -116, -117, -117, -119, -120, -119, -119, -118, -118, -118, -117, -115,
-114, -113, -112, -111, -110, -108, -107, -105, -103, -101, -100, -98, -97, -95,
-94, -92, -91, -89, -88, -86, -83, -81, -79, -77, -75, -74, -72, -71, -69, -67,
-67, -66, -66, -66, -65, -64, -63, -62, -61, -60, -58, -57, -55, -52, -50, -48,
-46, -43, -41, -38, -35, -31, -27, -23, -19, -15, -11, -7, -4, };