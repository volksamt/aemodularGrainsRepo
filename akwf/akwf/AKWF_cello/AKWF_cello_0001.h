#define DATA_LENGTH 512
#define DATA AKWF_cello_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 6, 8, 10, 11, 14, 16, 19, 22,
25, 27, 27, 27, 27, 26, 26, 24, 24, 23, 23, 21, 18, 17, 15, 13, 12, 12, 12, 12,
15, 18, 22, 28, 34, 39, 45, 49, 53, 57, 61, 65, 67, 68, 68, 69, 69, 68, 70, 71,
75, 78, 81, 86, 91, 97, 104, 108, 113, 117, 119, 118, 117, 115, 111, 108, 106,
105, 102, 100, 98, 95, 91, 87, 83, 81, 78, 77, 75, 74, 71, 68, 65, 63, 59, 56,
54, 50, 47, 45, 42, 39, 34, 31, 26, 20, 16, 11, 5, 1, -6, -10, -15, -21, -24,
-27, -31, -32, -34, -34, -36, -40, -43, -46, -52, -58, -63, -70, -75, -83, -90,
-95, -99, -102, -104, -106, -107, -107, -105, -103, -99, -98, -96, -96, -95,
-94, -92, -90, -89, -89, -89, -90, -92, -94, -95, -96, -97, -98, -98, -96, -94,
-90, -85, -80, -77, -72, -69, -64, -60, -59, -59, -61, -65, -67, -70, -72, -74,
-76, -77, -76, -76, -75, -74, -70, -68, -66, -63, -60, -60, -57, -54, -52, -51,
-49, -47, -46, -44, -42, -40, -38, -35, -33, -30, -26, -24, -22, -19, -14, -9,
-3, 1, 7, 10, 11, 12, 14, 17, 19, 23, 23, 26, 26, 28, 28, 31, 32, 32, 32, 31,
30, 27, 26, 25, 24, 22, 22, 19, 18, 18, 17, 16, 16, 15, 14, 10, 6, 2, -1, -5,
-9, -12, -15, -17, -18, -20, -20, -20, -19, -18, -16, -14, -14, -14, -16, -16,
-18, -18, -18, -19, -20, -20, -21, -20, -19, -19, -16, -13, -9, -5, -2, 3, 7,
13, 16, 20, 21, 24, 26, 27, 24, 23, 22, 23, 22, 19, 21, 25, 27, 27, 27, 28, 30,
30, 30, 30, 32, 36, 40, 40, 40, 41, 44, 44, 41, 42, 43, 45, 46, 46, 45, 46, 47,
46, 50, 55, 59, 61, 64, 68, 68, 66, 65, 68, 72, 75, 74, 72, 73, 75, 74, 72, 69,
68, 65, 63, 58, 56, 56, 54, 48, 43, 38, 36, 37, 37, 34, 30, 27, 22, 13, 5, -2,
-6, -12, -16, -20, -22, -21, -21, -19, -15, -9, -6, -1, 3, 6, 7, 7, 8, 8, 6, 4,
0, -2, -3, -3, -1, 0, 2, 7, 14, 18, 23, 27, 33, 39, 43, 43, 44, 41, 35, 30, 21,
12, 5, -2, -10, -16, -22, -27, -31, -34, -36, -37, -38, -40, -44, -49, -53, -59,
-64, -70, -74, -79, -84, -88, -92, -92, -92, -91, -89, -84, -81, -77, -75, -71,
-66, -60, -56, -52, -49, -46, -46, -45, -43, -42, -39, -37, -34, -32, -30, -28,
-24, -22, -19, -15, -10, -6, -3, -1, 1, 1, 1, -1, -4, -6, -7, -9, -9, -8, -9,
-8, -6, -4, 1, 6, 11, 16, 20, 21, 22, 20, 18, 16, 12, 11, 8, 6, 5, 2, 0, -2, -3,
-3, -3, -1, -2, -3, -2, -3, -5, -6, -8, -9, -11, -13, -14, -15, -14, -14, -13,
-12, -11, -9, -8, -6, -5, -3, -2, -1, 0, };