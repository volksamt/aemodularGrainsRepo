#define DATA_LENGTH 512
#define DATA AKWF_cello_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 6, 8, 9, 12, 14, 14, 16, 18, 20,
22, 23, 25, 25, 26, 26, 28, 27, 27, 27, 28, 31, 34, 37, 39, 40, 41, 43, 45, 45,
46, 47, 48, 50, 51, 52, 52, 55, 56, 57, 59, 60, 64, 66, 69, 74, 76, 80, 83, 86,
88, 90, 92, 93, 94, 96, 97, 98, 97, 97, 97, 98, 98, 98, 99, 100, 101, 102, 101,
100, 99, 96, 94, 92, 88, 84, 79, 74, 70, 64, 59, 54, 48, 43, 37, 33, 28, 24, 20,
16, 11, 7, 3, -2, -8, -14, -20, -25, -31, -37, -42, -48, -53, -58, -63, -67,
-69, -70, -73, -72, -73, -73, -74, -75, -77, -78, -81, -83, -86, -88, -90, -92,
-94, -96, -97, -97, -98, -97, -96, -97, -95, -93, -91, -88, -86, -82, -80, -77,
-73, -71, -67, -66, -64, -61, -59, -58, -56, -54, -52, -49, -47, -45, -43, -40,
-36, -33, -30, -27, -24, -21, -17, -14, -11, -9, -5, -2, -1, 1, 4, 4, 6, 8, 10,
11, 14, 14, 17, 18, 21, 22, 24, 25, 27, 30, 32, 34, 36, 38, 39, 41, 41, 43, 45,
47, 49, 51, 53, 56, 59, 62, 63, 67, 68, 70, 71, 72, 72, 72, 72, 71, 70, 70, 70,
70, 70, 70, 72, 72, 73, 73, 73, 73, 72, 70, 69, 68, 65, 65, 61, 58, 55, 52, 50,
47, 43, 39, 37, 34, 32, 30, 29, 26, 25, 24, 23, 22, 22, 21, 21, 22, 23, 24, 25,
28, 29, 30, 32, 34, 35, 35, 34, 36, 35, 35, 35, 34, 33, 33, 33, 34, 35, 37, 39,
42, 45, 48, 52, 55, 58, 62, 63, 67, 67, 67, 67, 67, 65, 65, 64, 64, 62, 62, 61,
61, 60, 60, 60, 59, 58, 58, 58, 57, 57, 57, 57, 55, 55, 54, 53, 51, 49, 47, 45,
44, 42, 41, 39, 39, 38, 37, 36, 34, 34, 32, 31, 30, 29, 28, 25, 24, 22, 20, 18,
16, 16, 13, 11, 9, 7, 5, 2, -1, -3, -7, -11, -16, -21, -25, -30, -35, -40, -44,
-49, -52, -57, -60, -63, -67, -70, -73, -75, -78, -81, -83, -86, -89, -92, -94,
-96, -99, -101, -105, -108, -110, -112, -115, -117, -118, -119, -119, -119,
-118, -117, -116, -115, -112, -112, -109, -107, -105, -104, -104, -102, -102,
-103, -103, -104, -105, -105, -104, -104, -104, -104, -105, -103, -103, -103,
-103, -102, -102, -101, -102, -101, -101, -100, -99, -98, -97, -96, -95, -92,
-90, -88, -85, -82, -79, -74, -72, -68, -66, -62, -60, -56, -52, -50, -45, -41,
-38, -35, -32, -28, -25, -22, -19, -16, -11, -7, -3, 1, 5, 8, 9, 12, 15, 16, 18,
21, 20, 19, 19, 19, 18, 16, 15, 14, 12, 10, 9, 8, 6, 6, 4, 3, 2, 2, 2, -1, -3,
-5, -5, -5, -7, -9, -8, -8, -10, -10, -11, -11, -12, -13, -14, -14, -14, -16,
-15, -15, -15, -13, -13, -12, -11, -9, -9, -10, -8, -8, -7, -5, -3, 0, };