#define DATA_LENGTH 512
#define DATA AKWF_cello_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 10, 15, 19, 25, 30, 34, 40, 44,
50, 53, 58, 61, 65, 69, 73, 76, 78, 80, 82, 83, 84, 84, 84, 83, 83, 80, 79, 78,
76, 74, 71, 69, 66, 64, 61, 59, 56, 54, 53, 50, 49, 48, 46, 45, 44, 44, 43, 43,
43, 42, 43, 44, 44, 44, 44, 46, 46, 46, 48, 48, 49, 49, 49, 50, 49, 50, 49, 49,
47, 47, 46, 44, 43, 41, 37, 36, 32, 29, 27, 24, 20, 17, 14, 10, 7, 4, -1, -4,
-9, -14, -17, -20, -25, -28, -32, -36, -40, -43, -46, -49, -54, -56, -60, -64,
-65, -68, -70, -73, -76, -77, -80, -81, -83, -84, -85, -85, -85, -86, -86, -84,
-83, -83, -81, -80, -78, -76, -74, -71, -68, -65, -62, -58, -56, -52, -49, -46,
-43, -39, -36, -34, -31, -28, -26, -24, -21, -19, -18, -16, -15, -13, -13, -13,
-13, -13, -13, -12, -14, -15, -16, -17, -20, -21, -23, -26, -27, -29, -31, -33,
-36, -38, -40, -42, -43, -44, -45, -46, -47, -47, -48, -48, -47, -47, -46, -45,
-43, -42, -41, -39, -36, -33, -31, -28, -25, -22, -20, -16, -13, -10, -7, -4,
-1, 2, 5, 7, 10, 12, 13, 15, 17, 19, 19, 21, 20, 21, 21, 21, 20, 20, 18, 16, 15,
15, 12, 10, 9, 6, 3, 1, -1, -4, -6, -9, -11, -14, -17, -19, -22, -25, -27, -29,
-32, -34, -35, -38, -40, -42, -44, -46, -47, -49, -51, -52, -54, -54, -54, -55,
-55, -55, -55, -54, -53, -52, -51, -49, -46, -44, -41, -38, -37, -32, -30, -26,
-23, -18, -15, -12, -8, -4, 0, 3, 5, 9, 12, 15, 18, 20, 22, 23, 25, 26, 26, 27,
27, 28, 26, 26, 25, 24, 22, 21, 18, 16, 14, 12, 10, 7, 5, 3, 1, -1, -2, -4, -5,
-6, -8, -8, -8, -8, -8, -7, -6, -4, 0, 4, 9, 13, 17, 22, 26, 31, 36, 43, 47, 53,
59, 63, 69, 73, 78, 83, 88, 93, 97, 101, 104, 108, 111, 114, 116, 118, 119, 119,
119, 118, 116, 115, 113, 110, 107, 103, 99, 94, 88, 83, 78, 72, 67, 61, 55, 49,
44, 38, 32, 27, 22, 17, 13, 8, 4, 0, -3, -4, -8, -10, -12, -13, -15, -15, -16,
-15, -15, -15, -15, -14, -14, -12, -11, -10, -8, -6, -6, -4, -2, 0, 2, 4, 5, 8,
9, 11, 13, 15, 18, 18, 21, 21, 23, 22, 23, 24, 23, 23, 23, 22, 21, 19, 17, 16,
13, 11, 8, 7, 3, 1, -2, -6, -9, -12, -15, -18, -22, -24, -26, -29, -31, -32,
-35, -36, -37, -37, -37, -38, -37, -36, -36, -35, -34, -33, -31, -30, -28, -26,
-23, -22, -19, -17, -14, -13, -10, -7, -5, -4, -2, -1, 1, 0, 1, 2, 2, 1, 2, 1,
0, -2, -3, -4, -6, -7, -9, -11, -13, -15, -16, -18, -19, -20, -21, -22, -23,
-22, -23, -22, -21, -20, -17, -15, -12, -10, -6, -3, };