#define DATA_LENGTH 512
#define DATA AKWF_cello_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 5, 5, 6, 8, 10, 10, 10, 12,
14, 17, 21, 28, 34, 39, 45, 47, 49, 51, 52, 52, 51, 52, 54, 58, 63, 68, 73, 79,
86, 92, 98, 102, 106, 106, 105, 106, 106, 106, 106, 107, 107, 107, 107, 106,
108, 110, 111, 116, 119, 119, 117, 114, 111, 107, 100, 94, 88, 81, 74, 68, 62,
57, 51, 47, 42, 39, 34, 28, 19, 11, 2, -5, -11, -16, -22, -27, -31, -34, -36,
-38, -42, -44, -46, -48, -51, -53, -55, -57, -58, -60, -61, -62, -65, -67, -69,
-70, -73, -73, -75, -75, -76, -77, -78, -80, -82, -84, -86, -89, -91, -93, -95,
-97, -99, -101, -100, -98, -96, -94, -93, -90, -85, -82, -79, -78, -76, -75,
-73, -73, -71, -71, -70, -69, -66, -64, -61, -59, -55, -50, -47, -42, -39, -35,
-34, -31, -31, -29, -27, -24, -20, -18, -14, -10, -9, -6, -3, 0, 1, 4, 8, 10,
12, 16, 20, 22, 26, 28, 30, 32, 32, 30, 30, 28, 27, 27, 26, 27, 28, 28, 29, 29,
30, 31, 33, 34, 33, 34, 35, 36, 37, 38, 41, 43, 47, 50, 52, 53, 55, 56, 54, 55,
54, 53, 52, 52, 52, 53, 54, 56, 57, 58, 59, 62, 64, 64, 63, 63, 63, 64, 65, 67,
68, 71, 73, 74, 77, 79, 81, 82, 85, 85, 86, 85, 84, 83, 82, 79, 77, 74, 72, 69,
66, 62, 59, 55, 52, 49, 46, 43, 40, 36, 32, 29, 25, 22, 17, 15, 13, 10, 8, 4, 1,
-1, -5, -9, -12, -15, -19, -22, -24, -27, -31, -33, -33, -35, -37, -39, -41,
-42, -45, -46, -47, -49, -51, -52, -54, -55, -58, -60, -62, -63, -65, -65, -66,
-66, -67, -65, -65, -64, -64, -63, -62, -63, -63, -64, -64, -65, -64, -63, -63,
-63, -62, -63, -61, -61, -59, -57, -55, -53, -51, -49, -46, -43, -40, -38, -36,
-33, -31, -30, -28, -26, -26, -24, -24, -23, -22, -20, -18, -16, -15, -13, -10,
-7, -6, -4, -2, 0, 0, 0, 1, 0, 0, -1, -2, -3, -2, -1, -2, -2, -1, -1, 0, 3, 3,
4, 4, 3, 0, 0, -3, -7, -8, -11, -13, -15, -17, -17, -19, -19, -18, -18, -18,
-17, -18, -17, -17, -18, -18, -17, -15, -13, -10, -9, -5, -2, 3, 7, 11, 15, 19,
23, 26, 29, 33, 37, 39, 42, 44, 46, 49, 50, 52, 55, 58, 59, 61, 63, 66, 67, 67,
66, 67, 67, 67, 66, 65, 64, 63, 61, 60, 58, 57, 56, 54, 52, 50, 47, 45, 42, 38,
35, 33, 30, 27, 26, 23, 21, 17, 12, 9, 3, -1, -6, -12, -16, -19, -23, -27, -30,
-32, -35, -38, -39, -41, -45, -48, -54, -59, -65, -69, -73, -77, -77, -77, -80,
-79, -81, -81, -80, -82, -84, -82, -82, -82, -82, -82, -80, -77, -76, -76, -74,
-72, -69, -69, -68, -65, -62, -62, -60, -56, -47, -41, -38, -35, -29, -24, -20,
-16, -10, -1, };