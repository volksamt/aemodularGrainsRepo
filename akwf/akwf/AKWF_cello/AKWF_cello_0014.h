#define DATA_LENGTH 512
#define DATA AKWF_cello_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 9, 16, 23, 29, 36, 41, 46, 51, 53,
57, 59, 62, 64, 66, 68, 71, 72, 74, 76, 77, 79, 81, 83, 86, 88, 92, 93, 94, 96,
96, 95, 95, 93, 91, 88, 85, 81, 78, 73, 68, 64, 59, 54, 49, 46, 41, 39, 36, 34,
32, 29, 29, 29, 29, 28, 30, 31, 33, 34, 35, 37, 38, 40, 41, 43, 45, 47, 49, 50,
52, 54, 55, 57, 58, 59, 60, 60, 61, 61, 61, 60, 58, 58, 54, 53, 50, 46, 43, 40,
36, 33, 30, 26, 23, 21, 17, 15, 12, 9, 7, 4, 2, 0, -1, -3, -5, -6, -6, -7, -8,
-7, -7, -5, -4, -3, -2, 0, 2, 3, 3, 5, 6, 7, 6, 7, 7, 8, 8, 8, 9, 10, 11, 13,
16, 20, 24, 29, 32, 38, 44, 49, 55, 60, 65, 69, 73, 76, 78, 82, 83, 82, 82, 81,
79, 76, 71, 67, 63, 57, 51, 44, 37, 29, 23, 14, 6, -1, -9, -16, -25, -33, -39,
-46, -52, -57, -63, -67, -70, -73, -75, -75, -74, -73, -70, -67, -64, -59, -53,
-47, -39, -32, -25, -17, -10, -2, 4, 12, 18, 25, 31, 36, 41, 45, 48, 50, 52, 54,
55, 55, 54, 54, 52, 49, 47, 43, 40, 35, 30, 25, 21, 16, 11, 6, 1, -2, -6, -8,
-12, -14, -15, -16, -15, -13, -12, -9, -7, -3, 2, 7, 12, 19, 25, 33, 41, 48, 54,
61, 68, 76, 83, 89, 93, 96, 100, 101, 103, 102, 98, 96, 92, 88, 82, 76, 69, 60,
54, 45, 37, 30, 21, 14, 5, -5, -15, -24, -34, -43, -52, -60, -66, -73, -79, -86,
-93, -102, -107, -110, -114, -116, -118, -119, -118, -116, -113, -112, -108,
-105, -100, -93, -87, -78, -70, -64, -57, -50, -42, -35, -28, -21, -13, -5, 0,
6, 11, 19, 26, 33, 38, 46, 51, 57, 63, 69, 74, 78, 81, 86, 89, 93, 95, 97, 99,
101, 103, 104, 104, 104, 103, 102, 99, 97, 94, 91, 87, 84, 81, 78, 74, 69, 64,
61, 56, 54, 50, 45, 39, 34, 28, 21, 14, 7, -1, -9, -17, -25, -34, -43, -53, -62,
-69, -77, -84, -89, -94, -98, -101, -103, -104, -103, -101, -98, -93, -88, -82,
-76, -70, -64, -58, -54, -49, -45, -41, -39, -37, -37, -40, -42, -45, -48, -53,
-59, -66, -71, -77, -81, -87, -90, -93, -95, -96, -96, -94, -92, -87, -83, -77,
-71, -65, -58, -51, -44, -37, -31, -24, -16, -9, -3, 2, 8, 13, 16, 18, 21, 23,
25, 25, 25, 24, 22, 20, 17, 15, 12, 10, 9, 7, 5, 3, 2, 1, 0, -2, -1, -1, 0, 1,
1, 2, 4, 4, 6, 7, 8, 9, 10, 9, 10, 9, 8, 5, 3, 0, -5, -8, -13, -18, -23, -29,
-35, -41, -47, -53, -61, -67, -74, -80, -85, -90, -94, -98, -100, -102, -102,
-101, -99, -96, -94, -90, -85, -81, -75, -68, -62, -57, -49, -41, -34, -27, -19,
-12, -4, };