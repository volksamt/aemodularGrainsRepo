#define DATA_LENGTH 512
#define DATA AKWF_cello_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 6, 11, 16, 23, 29, 35, 41, 47, 54,
59, 65, 70, 75, 80, 84, 89, 92, 95, 98, 101, 102, 104, 105, 105, 105, 104, 103,
101, 99, 96, 92, 89, 85, 80, 75, 71, 64, 59, 53, 48, 42, 36, 30, 25, 19, 14, 9,
4, 0, -5, -8, -12, -15, -18, -21, -22, -24, -26, -25, -26, -25, -25, -25, -23,
-21, -18, -15, -13, -9, -6, -2, 0, 4, 8, 11, 14, 17, 20, 23, 26, 28, 29, 32, 33,
36, 38, 41, 43, 44, 46, 48, 51, 53, 56, 59, 61, 66, 70, 73, 78, 83, 86, 90, 95,
100, 104, 108, 111, 114, 117, 119, 120, 119, 118, 117, 116, 113, 110, 107, 103,
98, 93, 89, 83, 78, 73, 67, 61, 56, 51, 46, 41, 36, 32, 26, 22, 18, 14, 10, 7,
4, -1, -5, -7, -10, -14, -16, -19, -22, -25, -28, -31, -34, -39, -43, -49, -53,
-57, -60, -64, -68, -71, -74, -76, -78, -80, -81, -81, -82, -81, -81, -81, -80,
-79, -78, -76, -75, -74, -72, -70, -67, -66, -63, -61, -58, -57, -53, -50, -45,
-42, -37, -33, -27, -22, -17, -12, -5, 0, 5, 11, 15, 18, 22, 26, 28, 30, 32, 34,
33, 34, 32, 30, 27, 23, 20, 14, 10, 5, 1, -4, -9, -13, -19, -23, -27, -30, -33,
-34, -35, -35, -34, -35, -34, -34, -33, -32, -31, -30, -29, -27, -27, -27, -26,
-26, -28, -28, -30, -31, -33, -36, -39, -42, -47, -52, -56, -59, -64, -67, -69,
-70, -73, -73, -74, -75, -75, -75, -73, -70, -67, -62, -57, -51, -47, -41, -35,
-30, -25, -20, -16, -12, -8, -8, -6, -5, -5, -5, -6, -8, -9, -11, -13, -15, -18,
-20, -20, -20, -18, -16, -13, -9, -4, 1, 6, 12, 18, 23, 28, 33, 39, 43, 46, 49,
52, 53, 54, 54, 54, 53, 52, 49, 48, 44, 40, 39, 35, 32, 30, 27, 25, 23, 20, 18,
15, 14, 12, 11, 11, 11, 11, 12, 12, 12, 12, 13, 13, 14, 16, 17, 19, 20, 22, 22,
24, 25, 28, 29, 31, 33, 35, 37, 39, 40, 41, 41, 42, 43, 44, 41, 42, 40, 38, 36,
33, 28, 25, 20, 16, 11, 6, 0, -5, -11, -16, -22, -28, -32, -36, -41, -45, -48,
-51, -53, -54, -55, -54, -53, -50, -47, -43, -40, -36, -32, -28, -23, -18, -14,
-9, -4, 0, 4, 8, 11, 14, 16, 19, 21, 23, 25, 25, 27, 28, 28, 29, 31, 30, 30, 31,
31, 30, 28, 26, 24, 22, 20, 17, 14, 11, 9, 6, 4, 2, -1, -2, -4, -6, -6, -7, -8,
-8, -7, -7, -8, -8, -7, -8, -7, -8, -8, -10, -11, -13, -15, -17, -19, -22, -23,
-25, -27, -30, -32, -34, -34, -36, -38, -39, -39, -38, -39, -38, -38, -37, -36,
-36, -34, -33, -32, -30, -29, -27, -26, -24, -23, -22, -21, -21, -19, -19, -19,
-20, -20, -20, -20, -20, -19, -20, -18, -17, -14, -12, -8, -3, };