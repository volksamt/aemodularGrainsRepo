#define DATA_LENGTH 512
#define DATA AKWF_cello_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 4, 5, 5, 6, 6, 5, 6, 7, 7,
6, 7, 8, 7, 9, 7, 7, 8, 8, 8, 8, 8, 7, 7, 7, 8, 8, 8, 9, 9, 9, 9, 11, 11, 11,
12, 12, 12, 12, 12, 12, 13, 14, 16, 16, 16, 17, 18, 19, 19, 20, 21, 21, 22, 23,
24, 27, 29, 31, 33, 34, 37, 40, 42, 46, 49, 52, 57, 61, 65, 70, 75, 81, 85, 91,
94, 98, 101, 104, 107, 109, 112, 114, 116, 117, 117, 119, 118, 120, 118, 117,
115, 114, 111, 108, 104, 100, 97, 93, 88, 84, 79, 73, 67, 61, 56, 51, 45, 41,
34, 30, 24, 20, 14, 9, 4, 0, -5, -9, -13, -17, -20, -23, -26, -29, -32, -32,
-35, -37, -38, -39, -41, -41, -41, -40, -40, -39, -37, -37, -34, -32, -29, -28,
-24, -21, -16, -13, -8, -4, 1, 5, 11, 15, 19, 23, 27, 31, 34, 37, 40, 43, 46,
47, 49, 52, 53, 54, 56, 57, 58, 58, 58, 60, 62, 62, 64, 64, 66, 67, 69, 70, 72,
73, 75, 77, 78, 81, 82, 84, 86, 87, 89, 89, 90, 91, 91, 91, 91, 90, 89, 89, 88,
85, 84, 82, 79, 77, 75, 70, 66, 62, 57, 53, 49, 43, 38, 32, 26, 19, 15, 8, 2,
-3, -9, -15, -19, -24, -28, -33, -38, -41, -44, -47, -50, -51, -52, -55, -54,
-57, -57, -57, -58, -58, -59, -59, -59, -59, -59, -59, -59, -58, -58, -58, -57,
-57, -57, -58, -57, -57, -57, -57, -56, -56, -56, -56, -56, -56, -55, -55, -55,
-54, -56, -56, -56, -56, -58, -59, -59, -60, -60, -62, -61, -62, -63, -63, -63,
-62, -63, -62, -61, -59, -58, -56, -54, -52, -49, -47, -42, -38, -34, -30, -26,
-21, -16, -11, -6, -1, 5, 10, 15, 19, 24, 29, 33, 36, 40, 42, 45, 47, 50, 51,
52, 53, 52, 52, 52, 51, 50, 47, 44, 42, 39, 36, 33, 29, 25, 21, 17, 13, 10, 5,
1, -5, -9, -12, -16, -22, -24, -29, -33, -38, -41, -44, -47, -52, -55, -58, -62,
-66, -69, -73, -76, -79, -82, -85, -88, -91, -94, -95, -97, -100, -102, -103,
-104, -106, -106, -107, -107, -107, -107, -107, -107, -106, -106, -105, -104,
-103, -102, -101, -100, -99, -99, -96, -95, -93, -92, -89, -87, -85, -83, -80,
-77, -75, -71, -69, -65, -62, -58, -55, -50, -47, -43, -39, -35, -30, -27, -23,
-19, -15, -12, -8, -5, -1, 1, 5, 8, 10, 13, 15, 17, 19, 21, 23, 25, 27, 28, 30,
32, 33, 35, 36, 37, 40, 40, 41, 41, 44, 44, 44, 45, 46, 46, 45, 46, 46, 47, 47,
48, 48, 47, 48, 48, 49, 50, 50, 49, 49, 49, 49, 48, 48, 48, 48, 46, 44, 43, 42,
41, 38, 36, 34, 30, 28, 25, 22, 20, 18, 15, 11, 9, 7, 4, 2, 0, -1, -3, -5, -5,
-6, -7, -7, -7, -7, -6, -5, -4, -3, -2, -1, };