#define DATA_LENGTH 512
#define DATA AKWF_cello_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 11, 15, 20, 25, 29, 33, 36, 40,
43, 45, 47, 49, 49, 50, 51, 50, 49, 48, 47, 44, 41, 39, 37, 35, 32, 29, 27, 25,
23, 22, 22, 22, 23, 25, 27, 29, 32, 36, 40, 45, 51, 57, 63, 69, 75, 81, 86, 92,
97, 101, 106, 110, 113, 116, 117, 119, 119, 118, 118, 116, 113, 110, 107, 102,
97, 93, 87, 81, 77, 71, 66, 60, 56, 51, 48, 43, 41, 37, 34, 32, 29, 28, 26, 25,
25, 25, 25, 26, 27, 26, 27, 27, 28, 28, 28, 28, 28, 26, 25, 24, 21, 19, 17, 14,
11, 8, 4, 1, -2, -6, -8, -12, -14, -18, -21, -24, -27, -29, -31, -35, -36, -38,
-40, -41, -42, -44, -44, -44, -44, -44, -44, -43, -42, -40, -39, -37, -35, -34,
-32, -29, -27, -24, -21, -19, -15, -13, -10, -8, -6, -4, -2, 1, 2, 2, 1, 2, 0,
-1, -4, -5, -8, -10, -14, -17, -19, -22, -25, -28, -28, -30, -32, -32, -32, -33,
-33, -31, -31, -30, -28, -27, -26, -25, -23, -22, -20, -19, -18, -16, -15, -15,
-14, -14, -14, -13, -12, -12, -12, -13, -14, -14, -16, -16, -18, -20, -20, -22,
-23, -24, -26, -26, -27, -28, -27, -27, -27, -27, -26, -26, -25, -23, -22, -21,
-19, -17, -15, -13, -12, -10, -8, -6, -4, -2, 0, 1, 4, 6, 9, 11, 14, 17, 18, 21,
24, 26, 27, 31, 33, 35, 38, 39, 41, 43, 43, 45, 47, 47, 49, 51, 52, 51, 50, 50,
50, 48, 46, 44, 43, 41, 39, 38, 38, 37, 36, 36, 36, 37, 37, 38, 39, 40, 40, 41,
42, 44, 44, 45, 45, 46, 46, 45, 45, 43, 43, 39, 36, 34, 30, 26, 21, 17, 11, 6,
0, -6, -10, -16, -21, -25, -28, -31, -35, -36, -39, -39, -40, -40, -39, -40,
-38, -37, -35, -33, -30, -29, -25, -21, -17, -12, -8, -3, 1, 4, 7, 9, 11, 13,
15, 15, 15, 14, 14, 15, 14, 13, 12, 12, 10, 10, 9, 9, 9, 10, 10, 10, 11, 12, 11,
12, 11, 11, 11, 11, 9, 10, 10, 8, 7, 7, 4, 2, 0, -2, -5, -7, -10, -12, -15, -17,
-19, -20, -22, -23, -24, -26, -27, -27, -27, -27, -27, -27, -27, -27, -27, -28,
-28, -28, -29, -30, -30, -32, -33, -35, -36, -37, -39, -41, -43, -44, -47, -49,
-50, -52, -53, -53, -55, -56, -55, -53, -52, -51, -48, -44, -41, -38, -33, -29,
-26, -21, -17, -14, -10, -8, -4, -2, 0, 2, 2, 3, 3, 2, 1, -1, -2, -4, -7, -10,
-13, -16, -20, -23, -27, -30, -33, -37, -40, -41, -43, -44, -44, -44, -43, -42,
-39, -37, -33, -30, -28, -23, -19, -16, -11, -7, -3, 0, 4, 7, 8, 10, 11, 12, 12,
11, 11, 7, 6, 3, -1, -5, -9, -12, -17, -19, -23, -26, -28, -30, -31, -32, -31,
-31, -30, -28, -26, -23, -20, -16, -12, -8, -4, 0, };