#define DATA_LENGTH 512
#define DATA AKWF_cheeze_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 3, 4, 5, 5, 6, 7, 7, 9, 10,
11, 12, 13, 13, 15, 16, 17, 18, 18, 20, 20, 22, 21, 23, 24, 25, 25, 27, 27, 29,
29, 31, 32, 32, 34, 35, 35, 36, 37, 38, 39, 40, 41, 41, 42, 43, 45, 46, 46, 47,
48, 48, 50, 51, 51, 52, 52, 54, 55, 55, 57, 57, 59, 59, 60, 60, 61, 62, 64, 65,
65, 66, 67, 68, 68, 69, 70, 70, 71, 72, 73, 74, 75, 76, 76, 76, 77, 79, 79, 80,
80, 81, 83, 83, 84, 85, 86, 86, 86, 88, 88, 89, 89, 90, 91, 92, 93, 93, 94, 95,
95, 95, 96, 97, 98, 98, 99, 100, 101, 102, 102, 103, 102, 104, 103, 104, 105,
105, 106, 107, 107, 107, 107, 108, 109, 109, 110, 110, 111, 110, 111, 112, 112,
112, 113, 113, 114, 115, 115, 115, 115, 116, 115, 117, 116, 116, 116, 117, 118,
118, 118, 118, 118, 119, 118, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119,
119, 118, 119, 119, 119, 118, 119, 118, 118, 118, 117, 117, 116, 116, 117, 115,
115, 115, 114, 115, 113, 113, 112, 112, 111, 110, 110, 109, 108, 108, 107, 106,
105, 104, 103, 102, 101, 100, 100, 97, 97, 95, 93, 93, 91, 90, 88, 87, 85, 83,
82, 81, 78, 76, 75, 72, 70, 68, 65, 63, 61, 60, 57, 53, 52, 49, 46, 43, 41, 38,
34, 32, 30, 26, 23, 21, 17, 13, 11, 8, 4, 0, -2, -6, -9, -13, -17, -19, -22,
-26, -29, -32, -36, -38, -40, -43, -46, -50, -52, -55, -58, -60, -63, -65, -68,
-70, -72, -74, -76, -79, -80, -82, -84, -86, -87, -89, -90, -92, -94, -95, -97,
-98, -99, -100, -102, -103, -104, -104, -105, -106, -107, -108, -109, -109,
-110, -111, -112, -113, -113, -114, -113, -114, -116, -115, -115, -116, -117,
-117, -117, -118, -117, -118, -119, -118, -118, -119, -118, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -118, -119, -118,
-118, -118, -117, -117, -117, -116, -116, -116, -116, -116, -115, -115, -115,
-114, -114, -113, -113, -112, -113, -113, -111, -111, -111, -111, -110, -109,
-110, -109, -108, -108, -107, -106, -106, -105, -105, -105, -104, -103, -102,
-103, -102, -101, -100, -100, -99, -98, -98, -98, -96, -95, -95, -95, -94, -93,
-93, -92, -91, -90, -89, -89, -89, -88, -87, -86, -85, -85, -84, -83, -82, -82,
-81, -80, -80, -78, -78, -77, -76, -75, -74, -74, -73, -73, -71, -70, -70, -68,
-69, -67, -65, -65, -65, -64, -62, -62, -61, -61, -60, -58, -58, -56, -56, -56,
-54, -54, -53, -52, -51, -50, -50, -48, -47, -47, -46, -45, -44, -43, -42, -41,
-39, -39, -38, -37, -37, -35, -34, -35, -34, -32, -31, -30, -30, -29, -27, -27,
-26, -24, -23, -23, -21, -21, -20, -19, -18, -17, -16, -16, -15, -14, -12, -12,
-10, -9, -9, -9, -6, -6, -5, -3, -3, -2, -1, 0, };