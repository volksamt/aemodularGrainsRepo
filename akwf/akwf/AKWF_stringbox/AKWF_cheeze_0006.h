#define DATA_LENGTH 512
#define DATA AKWF_cheeze_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 2, 3, 3, 4, 5, 6, 7, 7, 8, 9,
10, 10, 11, 12, 12, 13, 14, 14, 15, 16, 16, 17, 18, 18, 19, 20, 20, 21, 22, 23,
23, 25, 24, 26, 26, 27, 28, 28, 29, 29, 30, 31, 31, 32, 32, 33, 35, 34, 36, 37,
37, 38, 38, 40, 40, 40, 41, 42, 42, 44, 44, 44, 46, 46, 46, 48, 48, 49, 49, 49,
51, 52, 52, 53, 53, 54, 54, 55, 56, 57, 56, 58, 58, 59, 60, 61, 61, 61, 63, 63,
63, 65, 65, 66, 66, 67, 68, 69, 69, 70, 70, 71, 71, 73, 72, 72, 73, 75, 75, 76,
76, 77, 77, 78, 79, 80, 80, 80, 81, 81, 83, 83, 83, 84, 85, 85, 86, 86, 87, 87,
88, 88, 89, 90, 91, 91, 91, 92, 92, 94, 94, 94, 95, 95, 97, 96, 97, 98, 98, 98,
99, 99, 99, 100, 101, 102, 101, 102, 102, 103, 104, 104, 105, 105, 106, 106,
106, 107, 107, 108, 108, 108, 109, 109, 110, 110, 111, 110, 111, 111, 113, 112,
112, 113, 113, 113, 114, 114, 114, 115, 115, 116, 116, 116, 117, 117, 117, 117,
117, 118, 118, 118, 118, 118, 119, 119, 118, 118, 118, 119, 119, 119, 119, 119,
119, 119, 120, 119, 119, 119, 119, 120, 118, 118, 119, 119, 117, 117, 117, 116,
117, 116, 115, 115, 115, 113, 113, 113, 111, 111, 111, 110, 108, 107, 106, 106,
103, 102, 100, 99, 97, 94, 93, 89, 87, 85, 82, 78, 74, 69, 65, 60, 54, 46, 38,
28, 18, 7, -6, -23, -39, -56, -73, -89, -101, -108, -112, -114, -115, -117,
-117, -117, -117, -118, -118, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -118, -117, -118, -117,
-118, -118, -118, -117, -117, -116, -116, -117, -116, -116, -115, -115, -115,
-114, -114, -114, -114, -112, -112, -112, -112, -112, -111, -111, -110, -110,
-110, -109, -109, -109, -108, -108, -107, -106, -106, -106, -105, -104, -104,
-103, -104, -103, -103, -103, -101, -102, -101, -100, -100, -99, -99, -99, -98,
-97, -96, -96, -96, -95, -94, -93, -94, -93, -93, -92, -91, -90, -90, -90, -89,
-88, -88, -87, -86, -86, -85, -85, -85, -84, -83, -83, -82, -81, -80, -80, -79,
-79, -78, -78, -77, -76, -75, -75, -74, -74, -75, -73, -73, -71, -71, -70, -70,
-69, -68, -67, -67, -66, -66, -65, -65, -65, -64, -63, -62, -61, -61, -61, -60,
-59, -58, -57, -57, -56, -55, -55, -54, -53, -52, -53, -51, -51, -50, -49, -49,
-49, -48, -47, -46, -46, -45, -44, -43, -42, -42, -41, -41, -41, -40, -39, -39,
-37, -37, -36, -35, -35, -34, -34, -33, -32, -31, -31, -30, -29, -28, -28, -27,
-26, -26, -25, -24, -23, -23, -23, -21, -21, -19, -19, -19, -19, -17, -17, -15,
-15, -14, -13, -12, -12, -11, -11, -11, -10, -9, -8, -8, -7, -6, -5, -4, -5, -3,
-3, -2, -1, 0, };