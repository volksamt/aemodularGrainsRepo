#define DATA_LENGTH 512
#define DATA AKWF_cheeze_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 2, 4, 5, 6, 7, 8, 9, 10, 11,
12, 13, 14, 15, 16, 18, 18, 20, 20, 22, 23, 24, 25, 27, 27, 28, 29, 30, 31, 33,
34, 34, 36, 36, 37, 39, 39, 40, 42, 43, 43, 44, 46, 46, 47, 49, 50, 51, 51, 52,
53, 55, 56, 56, 58, 58, 60, 60, 61, 62, 63, 63, 66, 66, 67, 67, 68, 70, 70, 71,
72, 74, 74, 75, 76, 77, 77, 78, 79, 79, 81, 81, 83, 83, 84, 85, 86, 87, 88, 88,
89, 89, 91, 91, 92, 93, 93, 94, 95, 96, 97, 97, 98, 99, 100, 100, 101, 101, 103,
103, 103, 104, 105, 104, 105, 106, 107, 108, 108, 109, 109, 110, 110, 110, 111,
111, 112, 112, 113, 113, 114, 114, 115, 114, 115, 115, 115, 116, 116, 116, 116,
117, 118, 118, 118, 118, 118, 118, 117, 118, 119, 119, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 118, 119, 119, 118, 117, 118, 117, 117, 117,
117, 116, 116, 115, 115, 115, 114, 114, 113, 113, 111, 112, 111, 111, 110, 109,
108, 107, 107, 106, 105, 104, 104, 102, 101, 101, 100, 99, 98, 97, 95, 95, 94,
92, 91, 90, 88, 88, 86, 85, 84, 83, 80, 79, 77, 75, 74, 73, 70, 69, 67, 66, 65,
62, 61, 59, 58, 55, 53, 51, 49, 47, 45, 44, 41, 39, 37, 35, 33, 30, 29, 26, 23,
22, 20, 16, 15, 13, 11, 9, 6, 3, 1, -2, -3, -5, -8, -10, -13, -15, -17, -19,
-22, -24, -27, -29, -31, -33, -35, -37, -39, -42, -44, -46, -48, -49, -52, -53,
-57, -58, -59, -61, -64, -65, -66, -68, -69, -72, -73, -76, -77, -79, -80, -81,
-83, -85, -85, -86, -89, -89, -91, -93, -93, -94, -96, -96, -98, -99, -100,
-102, -102, -102, -103, -105, -106, -106, -107, -108, -108, -109, -110, -110,
-111, -112, -112, -112, -114, -114, -114, -115, -116, -116, -116, -116, -116,
-117, -117, -117, -117, -118, -118, -118, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -118, -118, -119, -119, -119, -118, -117, -118,
-118, -117, -117, -117, -117, -116, -116, -116, -116, -115, -116, -115, -114,
-115, -114, -113, -113, -113, -112, -112, -111, -110, -111, -110, -109, -109,
-109, -108, -107, -107, -106, -106, -105, -104, -103, -103, -102, -101, -101,
-101, -100, -100, -98, -97, -97, -96, -96, -95, -94, -94, -93, -92, -91, -90,
-90, -90, -89, -88, -87, -85, -84, -84, -83, -82, -82, -81, -80, -79, -79, -78,
-76, -75, -74, -73, -73, -72, -71, -69, -69, -68, -67, -67, -66, -65, -64, -62,
-62, -60, -60, -58, -57, -57, -55, -55, -54, -54, -53, -51, -50, -49, -48, -47,
-46, -45, -44, -44, -42, -41, -40, -39, -38, -37, -36, -35, -34, -33, -31, -30,
-29, -28, -27, -26, -26, -24, -22, -23, -22, -21, -19, -18, -17, -16, -15, -14,
-13, -11, -10, -10, -9, -7, -7, -5, -5, -3, -2, -1, };