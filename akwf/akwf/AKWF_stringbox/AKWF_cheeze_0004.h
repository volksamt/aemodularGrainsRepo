#define DATA_LENGTH 512
#define DATA AKWF_cheeze_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 2, 3, 4, 5, 6, 8, 9, 9, 10,
11, 11, 12, 13, 13, 14, 16, 17, 17, 18, 19, 20, 20, 21, 22, 22, 24, 24, 26, 25,
27, 28, 29, 30, 31, 31, 31, 32, 34, 34, 35, 36, 37, 38, 39, 39, 40, 41, 42, 43,
43, 45, 45, 46, 47, 47, 48, 49, 49, 51, 51, 52, 53, 53, 55, 55, 57, 57, 58, 59,
59, 60, 60, 62, 62, 64, 64, 65, 65, 66, 67, 67, 68, 68, 70, 70, 71, 72, 73, 73,
74, 75, 76, 76, 78, 78, 79, 78, 80, 81, 81, 82, 82, 84, 83, 85, 85, 86, 87, 87,
88, 89, 89, 89, 91, 90, 92, 92, 93, 94, 94, 95, 95, 96, 97, 97, 98, 99, 98, 99,
100, 101, 102, 102, 103, 103, 103, 104, 104, 105, 105, 106, 106, 107, 107, 108,
109, 109, 109, 109, 111, 110, 111, 111, 111, 112, 113, 113, 113, 113, 114, 115,
114, 115, 115, 116, 117, 115, 117, 117, 117, 117, 118, 117, 118, 118, 119, 119,
118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 118, 118, 119, 118, 118, 117, 117, 117, 117, 116, 116, 115, 115, 114, 114,
113, 112, 112, 111, 111, 110, 109, 108, 108, 107, 105, 104, 104, 102, 102, 100,
98, 97, 96, 95, 93, 91, 90, 88, 85, 83, 81, 80, 76, 75, 72, 70, 67, 64, 61, 58,
54, 50, 48, 43, 40, 36, 31, 27, 22, 17, 13, 9, 3, -3, -9, -13, -19, -24, -28,
-34, -39, -44, -49, -54, -59, -62, -66, -69, -74, -76, -79, -83, -85, -87, -89,
-90, -93, -95, -97, -98, -100, -101, -103, -104, -105, -106, -107, -108, -108,
-110, -111, -111, -111, -113, -114, -113, -114, -114, -114, -116, -116, -117,
-117, -117, -118, -117, -118, -118, -118, -118, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -118, -118, -119,
-118, -118, -118, -117, -118, -117, -116, -116, -116, -116, -115, -116, -115,
-115, -115, -113, -113, -114, -113, -112, -111, -112, -111, -111, -111, -110,
-109, -109, -108, -109, -108, -107, -107, -107, -105, -105, -104, -104, -104,
-103, -102, -101, -101, -101, -100, -100, -100, -98, -98, -97, -96, -96, -96,
-95, -94, -94, -93, -92, -92, -91, -90, -90, -89, -89, -87, -87, -87, -85, -85,
-85, -84, -83, -83, -82, -82, -80, -80, -79, -78, -78, -77, -76, -76, -75, -74,
-73, -74, -72, -72, -70, -70, -68, -69, -67, -67, -66, -65, -65, -63, -63, -61,
-61, -61, -60, -60, -58, -58, -56, -56, -56, -54, -53, -53, -52, -52, -51, -49,
-49, -48, -47, -47, -46, -45, -44, -43, -43, -42, -41, -39, -39, -39, -37, -37,
-36, -34, -35, -34, -32, -33, -30, -30, -30, -28, -27, -27, -26, -25, -25, -24,
-23, -23, -22, -20, -20, -19, -18, -18, -16, -16, -14, -13, -13, -12, -11, -9,
-9, -9, -7, -7, -6, -5, -4, -4, -2, -1, 0, };