#define DATA_LENGTH 512
#define DATA AKWF_cheeze_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 4, 6, 7, 9, 10, 11, 12, 13,
15, 16, 18, 18, 19, 21, 22, 23, 25, 26, 27, 28, 30, 31, 31, 33, 34, 35, 36, 37,
39, 40, 41, 42, 43, 44, 46, 47, 48, 49, 51, 52, 52, 54, 56, 56, 57, 58, 59, 61,
62, 62, 64, 65, 66, 67, 68, 69, 70, 71, 71, 73, 74, 75, 76, 77, 77, 79, 80, 81,
82, 83, 84, 85, 86, 86, 87, 88, 89, 90, 91, 92, 92, 94, 94, 95, 96, 96, 98, 98,
99, 99, 100, 101, 101, 102, 104, 104, 104, 105, 105, 106, 107, 107, 108, 108,
109, 109, 110, 111, 111, 112, 113, 113, 114, 113, 113, 115, 114, 114, 115, 116,
116, 116, 117, 117, 117, 117, 118, 118, 118, 118, 118, 118, 118, 118, 120, 120,
118, 119, 118, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 118, 118, 118,
117, 117, 117, 116, 117, 117, 116, 115, 115, 115, 114, 114, 114, 113, 113, 111,
111, 111, 110, 110, 109, 108, 108, 107, 106, 106, 104, 104, 103, 103, 101, 101,
100, 99, 99, 97, 97, 95, 94, 93, 93, 90, 89, 89, 88, 87, 86, 84, 83, 82, 81, 79,
78, 78, 76, 74, 73, 72, 70, 69, 68, 66, 65, 64, 61, 61, 58, 57, 55, 55, 53, 51,
50, 48, 46, 45, 44, 42, 40, 38, 37, 35, 33, 32, 31, 28, 27, 25, 23, 22, 20, 18,
15, 14, 13, 11, 9, 8, 6, 3, 2, 0, -2, -3, -6, -6, -9, -11, -12, -14, -16, -17,
-18, -21, -23, -24, -26, -28, -29, -31, -34, -34, -36, -38, -40, -40, -42, -45,
-46, -48, -50, -51, -52, -54, -55, -57, -58, -60, -61, -62, -65, -66, -67, -69,
-70, -71, -73, -74, -75, -77, -78, -79, -81, -82, -83, -84, -85, -87, -88, -89,
-90, -90, -92, -93, -94, -95, -96, -97, -98, -99, -100, -101, -102, -102, -103,
-103, -104, -105, -107, -107, -108, -108, -109, -109, -110, -111, -110, -112,
-112, -113, -113, -113, -114, -116, -115, -115, -116, -117, -116, -117, -116,
-117, -118, -118, -118, -119, -118, -119, -118, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -118, -119, -118, -118, -118, -118,
-118, -118, -116, -117, -116, -117, -116, -115, -116, -115, -115, -115, -114,
-113, -113, -112, -113, -112, -111, -111, -110, -110, -109, -109, -109, -108,
-107, -107, -106, -106, -104, -103, -103, -102, -101, -101, -100, -100, -99,
-98, -97, -96, -96, -96, -94, -93, -93, -92, -91, -90, -89, -89, -87, -87, -86,
-86, -84, -84, -82, -81, -80, -79, -79, -77, -77, -76, -74, -73, -72, -71, -70,
-69, -68, -67, -65, -65, -65, -63, -61, -61, -59, -59, -58, -57, -55, -54, -53,
-52, -51, -49, -48, -48, -46, -45, -43, -42, -42, -40, -39, -38, -36, -36, -34,
-33, -32, -31, -29, -29, -27, -26, -24, -23, -23, -21, -20, -18, -17, -16, -15,
-13, -12, -12, -10, -8, -7, -7, -5, -3, -2, -2, };