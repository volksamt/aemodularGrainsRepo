#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0116

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 13, 23, 32, 40, 47, 54, 60, 66, 71,
76, 81, 85, 87, 91, 94, 97, 99, 102, 103, 106, 107, 110, 110, 112, 113, 114,
115, 116, 117, 118, 117, 118, 118, 119, 118, 119, 119, 119, 120, 119, 118, 118,
117, 117, 116, 116, 114, 115, 113, 112, 111, 110, 107, 106, 105, 103, 101, 99,
96, 95, 91, 89, 85, 82, 77, 75, 71, 67, 64, 59, 56, 51, 47, 42, 38, 34, 30, 26,
21, 17, 12, 9, 4, 0, -4, -8, -11, -14, -18, -20, -23, -26, -27, -29, -31, -33,
-34, -36, -38, -38, -39, -41, -42, -42, -43, -43, -43, -43, -43, -43, -43, -43,
-42, -41, -41, -39, -38, -37, -35, -34, -32, -31, -29, -26, -23, -20, -18, -15,
-12, -7, -5, -3, 1, 4, 6, 10, 12, 15, 17, 19, 22, 24, 25, 26, 29, 30, 32, 33,
35, 36, 36, 37, 38, 39, 40, 40, 41, 41, 42, 42, 42, 41, 42, 42, 42, 41, 42, 40,
41, 40, 40, 39, 37, 36, 35, 32, 31, 28, 27, 24, 21, 18, 15, 11, 8, 3, -2, -6,
-11, -15, -20, -25, -30, -34, -37, -42, -45, -49, -52, -56, -57, -60, -64, -66,
-67, -70, -72, -73, -75, -76, -78, -80, -81, -82, -83, -83, -84, -84, -85, -85,
-86, -86, -87, -86, -86, -85, -85, -84, -84, -84, -84, -82, -81, -80, -78, -77,
-75, -73, -71, -69, -67, -64, -61, -58, -55, -52, -48, -43, -39, -35, -30, -24,
-17, -12, -4, 2, 10, 16, 22, 28, 32, 38, 43, 46, 50, 55, 57, 60, 64, 66, 69, 71,
73, 75, 77, 78, 80, 80, 82, 82, 83, 85, 85, 85, 86, 86, 86, 86, 86, 86, 86, 85,
85, 84, 83, 83, 81, 80, 80, 78, 77, 76, 74, 72, 71, 69, 67, 64, 62, 59, 55, 53,
50, 46, 43, 39, 35, 31, 26, 22, 17, 12, 8, 3, -2, -6, -10, -14, -17, -20, -23,
-25, -29, -30, -32, -34, -36, -37, -38, -39, -40, -40, -41, -42, -43, -43, -43,
-42, -42, -42, -43, -43, -42, -41, -42, -40, -39, -40, -38, -37, -36, -35, -33,
-33, -30, -29, -28, -26, -25, -22, -21, -19, -17, -14, -12, -8, -7, -3, 0, 3, 7,
10, 13, 16, 19, 22, 24, 27, 29, 30, 33, 34, 36, 37, 38, 39, 41, 41, 41, 43, 43,
43, 43, 43, 42, 43, 42, 40, 41, 39, 38, 37, 36, 35, 33, 31, 31, 28, 26, 24, 21,
18, 15, 12, 8, 5, 0, -3, -8, -12, -16, -20, -24, -28, -34, -37, -42, -45, -50,
-54, -58, -62, -66, -69, -73, -77, -81, -84, -88, -90, -93, -96, -98, -100,
-102, -104, -106, -107, -109, -110, -111, -113, -113, -114, -116, -115, -117,
-117, -118, -117, -119, -119, -119, -119, -118, -119, -119, -118, -118, -118,
-117, -116, -116, -115, -114, -114, -111, -111, -110, -108, -106, -104, -101,
-100, -97, -95, -91, -88, -85, -81, -77, -71, -67, -61, -55, -49, -42, -33, -25,
-16, -5, };