#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0047

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 4, 8, 12, 15, 20, 25, 28, 32, 36,
40, 44, 47, 51, 54, 58, 61, 65, 66, 70, 73, 75, 79, 81, 83, 86, 88, 90, 93, 95,
98, 98, 103, 91, 86, 89, 90, 93, 94, 95, 95, 97, 98, 99, 100, 101, 102, 102,
103, 104, 104, 104, 105, 105, 105, 105, 106, 105, 106, 106, 106, 105, 105, 104,
104, 93, 85, 86, 85, 85, 84, 84, 83, 82, 81, 80, 78, 78, 77, 75, 74, 73, 72, 71,
70, 68, 67, 65, 64, 62, 61, 59, 58, 56, 55, 52, 53, 39, 30, 30, 27, 28, 26, 25,
24, 24, 21, 21, 20, 19, 18, 15, 15, 13, 13, 11, 9, 9, 8, 6, 5, 5, 3, 1, 1, -1,
-2, -3, -4, -5, -8, -11, -14, -17, -19, -21, -25, -26, -29, -31, -33, -35, -37,
-39, -40, -43, -45, -46, -47, -49, -49, -51, -54, -54, -56, -56, -57, -58, -58,
-60, -59, -71, -80, -78, -80, -79, -81, -80, -81, -81, -81, -81, -83, -83, -82,
-82, -82, -82, -81, -81, -81, -81, -80, -79, -78, -77, -77, -77, -75, -76, -74,
-74, -72, -80, -90, -86, -87, -85, -84, -81, -81, -80, -78, -77, -76, -74, -73,
-71, -71, -69, -67, -66, -65, -64, -62, -61, -59, -58, -56, -55, -54, -52, -50,
-49, -47, -53, -63, -60, -59, -56, -56, -53, -51, -50, -47, -46, -43, -42, -39,
-39, -36, -34, -33, -31, -29, -28, -26, -26, -24, -22, -20, -19, -16, -16, -13,
-13, -11, -9, -8, -3, -1, 2, 5, 9, 11, 14, 18, 21, 24, 26, 29, 32, 34, 38, 40,
42, 45, 47, 50, 53, 54, 57, 59, 62, 64, 65, 68, 70, 74, 64, 55, 60, 60, 62, 64,
66, 67, 69, 71, 72, 73, 74, 76, 76, 78, 79, 79, 80, 81, 83, 84, 85, 86, 86, 87,
87, 89, 88, 91, 89, 92, 85, 72, 77, 76, 78, 78, 79, 78, 80, 80, 81, 81, 81, 82,
81, 81, 82, 81, 81, 80, 80, 80, 79, 79, 78, 77, 77, 76, 75, 75, 73, 75, 64, 55,
54, 53, 53, 52, 53, 51, 51, 50, 49, 48, 47, 46, 46, 45, 43, 43, 42, 41, 39, 38,
36, 36, 35, 33, 32, 31, 29, 28, 26, 25, 24, 21, 17, 14, 11, 7, 4, 2, -1, -6, -8,
-11, -14, -16, -19, -23, -25, -28, -30, -33, -35, -38, -40, -43, -44, -48, -50,
-51, -53, -55, -59, -58, -75, -83, -83, -86, -86, -89, -88, -91, -92, -93, -93,
-96, -96, -98, -98, -100, -99, -101, -101, -101, -102, -103, -102, -103, -103,
-101, -102, -101, -102, -100, -102, -100, -111, -119, -114, -114, -114, -112,
-111, -110, -109, -107, -105, -105, -103, -102, -100, -99, -97, -96, -94, -93,
-90, -89, -88, -87, -85, -83, -81, -79, -77, -74, -72, -69, -81, -84, -80, -78,
-74, -73, -69, -66, -63, -61, -58, -56, -52, -49, -46, -43, -40, -37, -34, -31,
-28, -26, -22, -19, -16, -13, -11, -8, -6, -3, -1, };