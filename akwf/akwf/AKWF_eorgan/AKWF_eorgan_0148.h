#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0148

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 13, 18, 21, 25, 31, 35, 40,
45, 50, 56, 60, 64, 69, 74, 78, 82, 86, 91, 92, 97, 99, 103, 106, 108, 109, 111,
113, 114, 115, 116, 117, 119, 118, 119, 118, 119, 119, 118, 119, 118, 118, 117,
116, 115, 115, 113, 111, 111, 110, 108, 107, 105, 104, 104, 101, 100, 100, 98,
97, 96, 95, 95, 94, 94, 94, 93, 93, 93, 93, 94, 93, 93, 94, 93, 94, 94, 94, 93,
94, 93, 92, 91, 91, 90, 89, 87, 86, 84, 82, 80, 79, 77, 73, 71, 69, 67, 64, 60,
58, 55, 54, 49, 47, 44, 40, 38, 35, 33, 31, 27, 25, 22, 19, 17, 14, 11, 10, 8,
6, 4, 1, 0, -1, -3, -3, -4, -4, -5, -4, -5, -4, -3, -4, -4, -2, -1, 0, 1, 2, 2,
3, 4, 5, 6, 7, 7, 8, 8, 8, 8, 7, 6, 5, 6, 4, 3, 2, 1, 0, -1, -3, -4, -6, -6, -9,
-10, -11, -13, -14, -16, -17, -19, -20, -22, -24, -26, -26, -29, -30, -31, -32,
-33, -33, -35, -36, -36, -37, -37, -37, -38, -37, -37, -37, -35, -35, -34, -33,
-32, -32, -30, -29, -28, -26, -25, -24, -23, -21, -21, -20, -20, -20, -20, -20,
-20, -22, -22, -22, -23, -24, -26, -26, -28, -30, -30, -32, -34, -35, -37, -38,
-39, -41, -43, -44, -46, -47, -48, -50, -51, -53, -53, -54, -56, -55, -56, -57,
-58, -58, -58, -58, -58, -57, -57, -55, -54, -53, -51, -49, -48, -46, -43, -42,
-38, -36, -34, -30, -28, -25, -22, -21, -18, -15, -13, -11, -9, -8, -6, -5, -4,
-3, -2, -2, -3, -1, -2, -2, -3, -2, -2, -3, -5, -5, -6, -8, -9, -10, -11, -12,
-13, -15, -16, -18, -20, -21, -23, -24, -25, -27, -28, -30, -31, -32, -34, -34,
-35, -35, -36, -36, -36, -36, -36, -35, -34, -33, -32, -31, -30, -28, -28, -26,
-24, -23, -21, -20, -19, -17, -16, -15, -14, -13, -12, -12, -11, -11, -11, -12,
-12, -12, -12, -12, -13, -15, -15, -15, -16, -17, -18, -19, -20, -21, -22, -24,
-24, -25, -26, -27, -28, -29, -31, -31, -32, -33, -34, -35, -35, -36, -36, -36,
-36, -36, -36, -36, -35, -35, -33, -33, -32, -30, -29, -27, -25, -24, -21, -19,
-19, -17, -15, -14, -12, -11, -10, -8, -7, -7, -7, -6, -6, -6, -7, -7, -7, -9,
-8, -10, -11, -12, -14, -15, -17, -18, -21, -21, -24, -26, -26, -29, -30, -32,
-34, -36, -38, -38, -41, -43, -45, -46, -47, -48, -50, -50, -52, -53, -54, -54,
-55, -55, -55, -54, -54, -54, -53, -53, -52, -50, -49, -48, -47, -45, -44, -43,
-41, -40, -38, -37, -35, -35, -34, -32, -32, -31, -31, -30, -30, -29, -30, -30,
-30, -30, -29, -30, -29, -28, -30, -30, -29, -29, -30, -30, -28, -28, -28, -28,
-27, -26, -26, -25, -25, -24, -23, -21, -20, -19, -17, -15, -13, -10, -8, -6,
-3, 0, };