#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0063

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 12, 18, 23, 28, 32, 37, 41, 46,
49, 52, 55, 59, 60, 63, 64, 65, 66, 67, 67, 65, 65, 64, 64, 61, 60, 57, 55, 53,
51, 47, 45, 42, 40, 37, 34, 31, 30, 28, 25, 24, 22, 21, 21, 20, 20, 21, 22, 22,
24, 25, 28, 29, 32, 35, 39, 42, 46, 49, 54, 58, 63, 67, 72, 75, 80, 83, 88, 92,
95, 99, 101, 105, 107, 109, 112, 113, 115, 115, 115, 115, 115, 115, 114, 112,
111, 108, 105, 103, 100, 97, 94, 90, 87, 83, 79, 76, 72, 68, 65, 61, 59, 55, 53,
50, 48, 47, 45, 43, 44, 43, 42, 43, 44, 44, 47, 48, 51, 52, 55, 58, 61, 65, 68,
71, 75, 79, 83, 86, 90, 93, 98, 100, 104, 106, 110, 112, 114, 116, 116, 117,
118, 118, 118, 117, 117, 116, 113, 112, 109, 107, 104, 100, 97, 92, 89, 84, 80,
75, 71, 67, 63, 58, 54, 50, 46, 42, 38, 35, 32, 29, 28, 25, 23, 22, 20, 21, 21,
20, 21, 21, 23, 24, 26, 28, 30, 33, 36, 38, 41, 43, 46, 50, 52, 55, 58, 61, 63,
64, 66, 68, 70, 71, 71, 71, 71, 71, 71, 69, 68, 66, 63, 60, 58, 55, 51, 48, 43,
40, 35, 31, 26, 21, 18, 12, 8, 4, -1, -5, -9, -13, -15, -19, -22, -24, -27, -28,
-30, -31, -31, -33, -32, -31, -31, -29, -28, -26, -23, -21, -20, -17, -14, -10,
-7, -3, 0, 4, 6, 10, 14, 16, 19, 21, 24, 26, 27, 29, 30, 30, 30, 30, 31, 30, 28,
27, 24, 21, 20, 17, 14, 9, 5, 2, -3, -7, -11, -15, -20, -25, -29, -34, -38, -43,
-47, -50, -54, -58, -60, -63, -66, -67, -69, -71, -72, -73, -73, -73, -72, -71,
-69, -68, -67, -64, -63, -60, -58, -55, -52, -50, -47, -44, -41, -38, -34, -33,
-31, -28, -27, -25, -24, -23, -22, -21, -21, -21, -23, -23, -25, -27, -29, -31,
-34, -37, -40, -45, -48, -53, -56, -60, -65, -70, -73, -78, -82, -87, -91, -95,
-99, -103, -106, -109, -111, -113, -115, -116, -119, -118, -119, -119, -119,
-118, -117, -114, -113, -111, -108, -106, -104, -100, -97, -93, -89, -85, -82,
-77, -74, -71, -67, -63, -60, -57, -54, -51, -49, -47, -45, -44, -43, -43, -43,
-42, -43, -44, -46, -48, -49, -51, -54, -57, -59, -63, -66, -69, -73, -76, -80,
-85, -88, -91, -94, -98, -102, -104, -106, -108, -110, -112, -113, -115, -115,
-115, -115, -114, -113, -112, -110, -108, -105, -102, -99, -96, -92, -89, -85,
-81, -76, -72, -68, -63, -59, -55, -51, -46, -43, -39, -36, -33, -30, -28, -25,
-23, -22, -21, -20, -19, -18, -19, -19, -20, -22, -23, -25, -26, -28, -31, -34,
-37, -39, -41, -44, -47, -49, -52, -55, -57, -58, -60, -62, -63, -64, -65, -65,
-64, -64, -63, -62, -60, -58, -55, -53, -50, -46, -42, -37, -33, -29, -24, -18,
-14, -8, -2, };