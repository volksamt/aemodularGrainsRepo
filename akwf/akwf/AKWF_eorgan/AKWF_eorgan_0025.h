#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 14, 19, 22, 25, 31, 34, 38,
41, 46, 49, 53, 57, 60, 64, 66, 69, 73, 76, 79, 82, 85, 88, 90, 92, 96, 97, 100,
102, 104, 105, 108, 109, 111, 112, 114, 115, 115, 117, 117, 118, 118, 119, 119,
120, 119, 119, 119, 119, 118, 118, 117, 116, 115, 114, 113, 112, 110, 109, 108,
107, 105, 102, 102, 99, 98, 95, 93, 91, 89, 87, 84, 82, 80, 78, 74, 73, 69, 67,
65, 63, 60, 57, 54, 52, 49, 47, 44, 41, 38, 36, 33, 31, 29, 26, 23, 20, 17, 16,
13, 11, 9, 7, 4, 1, 0, -2, -5, -6, -8, -10, -11, -14, -15, -17, -18, -19, -22,
-23, -25, -26, -27, -29, -30, -31, -33, -33, -34, -35, -37, -37, -39, -38, -40,
-41, -41, -42, -43, -44, -44, -45, -46, -46, -46, -47, -47, -48, -48, -48, -49,
-49, -50, -51, -50, -51, -51, -52, -52, -52, -51, -53, -53, -53, -53, -54, -54,
-54, -54, -54, -54, -54, -55, -54, -55, -55, -56, -56, -56, -56, -57, -57, -56,
-57, -56, -57, -58, -57, -56, -57, -56, -57, -57, -58, -57, -57, -57, -56, -57,
-56, -56, -56, -56, -55, -55, -54, -54, -54, -54, -53, -53, -52, -51, -51, -51,
-50, -49, -49, -48, -47, -47, -45, -44, -44, -43, -42, -40, -40, -39, -37, -36,
-35, -33, -33, -31, -29, -29, -27, -26, -25, -23, -21, -21, -19, -17, -15, -13,
-13, -11, -10, -8, -5, -5, -3, -1, 0, 1, 4, 6, 7, 8, 10, 12, 13, 15, 16, 18, 19,
21, 22, 24, 25, 26, 29, 30, 31, 32, 32, 35, 35, 37, 38, 39, 40, 41, 41, 43, 44,
45, 46, 47, 47, 48, 49, 50, 50, 51, 51, 52, 53, 53, 53, 54, 54, 55, 55, 55, 55,
55, 56, 56, 57, 56, 57, 57, 57, 57, 56, 57, 57, 57, 56, 57, 57, 56, 57, 56, 56,
56, 56, 56, 56, 56, 55, 56, 56, 55, 56, 54, 54, 54, 54, 54, 54, 53, 53, 52, 53,
52, 52, 51, 51, 52, 51, 51, 50, 50, 50, 50, 49, 49, 49, 48, 48, 47, 47, 46, 45,
45, 44, 44, 43, 42, 42, 42, 40, 40, 38, 38, 37, 36, 35, 34, 34, 31, 30, 29, 29,
27, 26, 24, 23, 22, 19, 18, 16, 14, 12, 11, 9, 7, 5, 3, 0, -1, -3, -5, -7, -10,
-12, -13, -17, -19, -21, -23, -26, -29, -32, -35, -37, -39, -42, -45, -48, -50,
-52, -55, -57, -60, -62, -66, -67, -71, -73, -76, -78, -81, -83, -85, -87, -90,
-92, -94, -97, -99, -100, -101, -103, -106, -107, -109, -109, -111, -112, -114,
-115, -116, -117, -116, -117, -119, -119, -119, -119, -119, -119, -119, -118,
-118, -118, -117, -117, -114, -113, -113, -111, -110, -109, -108, -105, -104,
-102, -99, -96, -95, -91, -90, -86, -84, -82, -77, -75, -72, -68, -65, -62, -59,
-55, -51, -47, -43, -40, -37, -32, -29, -25, -21, -16, -13, -9, -2, };