#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0056

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 8, 12, 16, 19, 22, 26, 29, 33,
36, 39, 43, 45, 49, 53, 55, 59, 62, 64, 67, 71, 73, 76, 78, 81, 83, 85, 88, 91,
93, 94, 97, 99, 101, 102, 103, 105, 107, 108, 109, 110, 113, 114, 115, 115, 116,
117, 118, 117, 117, 118, 119, 119, 119, 119, 118, 119, 118, 118, 117, 117, 117,
115, 115, 114, 113, 112, 110, 109, 109, 108, 106, 105, 102, 100, 99, 98, 96, 94,
93, 90, 88, 87, 85, 82, 80, 78, 76, 73, 71, 70, 68, 66, 62, 60, 58, 57, 54, 53,
50, 48, 45, 44, 41, 39, 37, 35, 33, 30, 28, 27, 24, 23, 21, 20, 18, 16, 14, 13,
10, 9, 7, 6, 4, 2, 1, 1, 0, -2, -3, -4, -5, -6, -7, -7, -9, -8, -9, -10, -10,
-10, -11, -11, -11, -11, -11, -12, -11, -12, -12, -12, -11, -11, -10, -10, -11,
-10, -9, -9, -9, -8, -7, -6, -5, -5, -4, -3, -3, -2, 0, 1, 2, 2, 3, 5, 5, 6, 6,
8, 9, 10, 11, 12, 12, 14, 14, 16, 17, 16, 17, 19, 20, 20, 21, 22, 23, 23, 24,
25, 25, 26, 27, 27, 28, 28, 28, 29, 29, 29, 29, 30, 30, 31, 30, 30, 30, 29, 30,
30, 29, 29, 28, 28, 28, 28, 27, 26, 26, 26, 25, 24, 23, 23, 22, 21, 20, 20, 19,
18, 17, 16, 15, 13, 13, 12, 11, 10, 8, 7, 6, 5, 4, 2, 2, 1, -1, -1, -3, -4, -6,
-6, -8, -9, -10, -10, -12, -13, -14, -15, -16, -17, -18, -18, -20, -20, -22,
-22, -23, -24, -25, -25, -26, -26, -27, -28, -28, -29, -29, -29, -30, -29, -30,
-31, -30, -30, -30, -31, -31, -30, -29, -30, -30, -30, -29, -29, -29, -28, -27,
-27, -26, -27, -25, -25, -24, -23, -23, -23, -22, -21, -20, -19, -18, -17, -16,
-15, -14, -13, -12, -12, -11, -10, -8, -7, -6, -6, -5, -4, -2, -2, -1, 0, 1, 1,
2, 2, 5, 6, 5, 6, 6, 7, 8, 8, 9, 10, 9, 10, 10, 11, 11, 11, 11, 11, 11, 11, 11,
11, 11, 11, 10, 10, 9, 9, 9, 8, 7, 7, 5, 5, 4, 2, 2, 0, 0, -2, -3, -5, -6, -8,
-8, -10, -11, -13, -14, -17, -19, -21, -23, -25, -26, -28, -31, -32, -35, -37,
-38, -41, -42, -45, -47, -50, -52, -54, -56, -58, -60, -63, -65, -66, -69, -72,
-73, -75, -77, -80, -82, -84, -86, -87, -90, -92, -93, -95, -96, -99, -100,
-101, -103, -105, -106, -108, -109, -110, -112, -112, -113, -113, -115, -115,
-117, -117, -117, -117, -117, -118, -118, -119, -118, -119, -118, -118, -117,
-117, -116, -116, -115, -114, -113, -111, -111, -109, -107, -107, -105, -104,
-102, -101, -98, -96, -94, -92, -89, -88, -84, -83, -81, -77, -75, -72, -70,
-66, -64, -61, -58, -56, -52, -49, -45, -43, -39, -37, -32, -28, -26, -22, -18,
-15, -11, -8, -5, -2, };