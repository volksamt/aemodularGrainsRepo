#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 13, 17, 21, 25, 27, 31, 34,
37, 40, 44, 46, 49, 52, 55, 57, 60, 62, 63, 66, 67, 69, 70, 71, 73, 75, 76, 77,
78, 79, 80, 81, 82, 82, 83, 83, 84, 85, 84, 84, 85, 85, 85, 86, 86, 86, 86, 86,
87, 87, 86, 87, 86, 86, 87, 86, 87, 87, 87, 87, 88, 88, 88, 88, 88, 88, 88, 89,
89, 90, 90, 90, 90, 92, 91, 92, 93, 93, 94, 95, 95, 96, 97, 97, 97, 98, 99, 99,
99, 101, 101, 102, 103, 103, 103, 104, 104, 104, 105, 104, 105, 104, 104, 105,
104, 104, 105, 104, 104, 103, 103, 102, 102, 100, 99, 99, 97, 95, 94, 92, 91,
90, 87, 86, 84, 81, 79, 77, 74, 72, 69, 65, 62, 60, 56, 52, 50, 46, 42, 39, 37,
33, 30, 27, 25, 21, 19, 17, 15, 13, 11, 10, 8, 6, 4, 3, 2, 0, -2, -3, -4, -4,
-5, -6, -7, -7, -9, -9, -10, -11, -12, -12, -11, -13, -13, -13, -14, -12, -14,
-14, -14, -14, -15, -14, -15, -16, -16, -16, -16, -17, -16, -17, -18, -18, -18,
-18, -19, -19, -20, -20, -20, -20, -21, -22, -22, -22, -23, -23, -24, -24, -25,
-25, -25, -26, -26, -27, -28, -28, -27, -29, -29, -28, -29, -29, -29, -29, -29,
-30, -29, -29, -28, -28, -28, -28, -28, -26, -26, -25, -24, -23, -21, -21, -20,
-18, -16, -15, -14, -11, -9, -7, -6, -4, -1, 1, 3, 7, 9, 11, 14, 18, 19, 21, 24,
26, 27, 29, 30, 32, 33, 35, 36, 37, 38, 38, 38, 40, 41, 40, 41, 41, 41, 40, 41,
41, 41, 40, 40, 40, 39, 38, 37, 36, 36, 34, 33, 32, 31, 31, 29, 28, 27, 26, 25,
23, 23, 21, 20, 18, 17, 17, 15, 14, 13, 12, 11, 10, 9, 8, 7, 6, 5, 4, 3, 3, 2,
0, 1, -1, -1, -2, -2, -2, -3, -3, -4, -4, -5, -5, -6, -6, -6, -6, -6, -6, -6,
-7, -7, -7, -8, -8, -8, -9, -9, -9, -9, -9, -10, -10, -11, -12, -13, -13, -14,
-15, -15, -17, -17, -18, -19, -21, -22, -23, -24, -27, -28, -30, -32, -34, -36,
-38, -41, -42, -44, -48, -50, -53, -56, -59, -62, -65, -68, -72, -75, -78, -81,
-84, -87, -90, -92, -96, -97, -100, -101, -104, -105, -107, -109, -110, -111,
-112, -114, -115, -115, -116, -117, -117, -118, -119, -118, -119, -119, -119,
-119, -119, -118, -118, -118, -118, -117, -116, -116, -115, -116, -115, -114,
-114, -113, -112, -112, -111, -110, -109, -108, -107, -106, -106, -104, -104,
-103, -102, -101, -101, -99, -100, -98, -98, -97, -96, -96, -94, -93, -93, -92,
-91, -90, -89, -89, -88, -87, -87, -85, -84, -84, -82, -82, -80, -79, -77, -77,
-75, -74, -73, -72, -70, -68, -68, -65, -63, -61, -60, -58, -56, -53, -52, -49,
-46, -45, -42, -40, -37, -34, -30, -27, -24, -21, -18, -14, -10, -7, -2, };