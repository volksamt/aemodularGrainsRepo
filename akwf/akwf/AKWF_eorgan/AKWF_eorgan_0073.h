#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0073

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 10, 16, 21, 25, 30, 34, 38, 44,
47, 51, 56, 60, 64, 67, 71, 74, 78, 81, 84, 87, 90, 93, 95, 98, 100, 103, 105,
107, 108, 110, 111, 112, 114, 115, 116, 117, 117, 119, 118, 119, 119, 119, 119,
118, 118, 117, 117, 116, 115, 113, 112, 111, 109, 107, 106, 104, 102, 100, 99,
96, 94, 91, 87, 86, 83, 81, 78, 76, 73, 69, 67, 65, 61, 59, 56, 53, 51, 47, 45,
42, 40, 37, 34, 32, 30, 27, 25, 23, 21, 18, 16, 14, 12, 10, 9, 7, 6, 4, 2, 2, 0,
-1, -3, -2, -4, -5, -5, -6, -6, -7, -7, -7, -8, -8, -7, -7, -8, -7, -6, -6, -5,
-4, -3, -3, -2, -1, 0, 0, 2, 2, 4, 6, 6, 8, 8, 10, 11, 11, 13, 14, 15, 15, 17,
18, 18, 19, 21, 21, 23, 23, 24, 24, 25, 26, 27, 27, 27, 28, 29, 30, 30, 30, 31,
31, 31, 31, 32, 32, 31, 33, 32, 32, 31, 30, 30, 30, 30, 28, 29, 27, 26, 25, 25,
23, 23, 22, 21, 19, 18, 17, 16, 14, 13, 13, 10, 9, 8, 6, 6, 5, 3, 1, 0, -1, -2,
-3, -3, -5, -7, -6, -8, -8, -10, -9, -11, -12, -11, -12, -13, -13, -14, -14,
-15, -15, -15, -15, -15, -15, -15, -14, -15, -15, -15, -14, -14, -14, -13, -13,
-12, -12, -12, -10, -10, -10, -8, -8, -6, -6, -5, -4, -4, -3, -2, -1, 0, 1, 1,
3, 4, 5, 6, 6, 8, 9, 9, 9, 11, 11, 12, 12, 12, 13, 14, 13, 14, 14, 15, 15, 15,
15, 14, 15, 15, 14, 14, 14, 14, 14, 14, 12, 12, 11, 11, 11, 10, 9, 9, 7, 7, 6,
5, 4, 3, 2, 0, 0, -1, -3, -4, -5, -6, -8, -8, -10, -12, -13, -14, -15, -17, -19,
-20, -21, -23, -23, -24, -24, -26, -26, -28, -28, -29, -30, -31, -30, -32, -32,
-31, -31, -31, -31, -32, -32, -32, -32, -31, -31, -31, -30, -31, -29, -30, -29,
-28, -27, -27, -26, -26, -24, -24, -23, -22, -22, -20, -19, -18, -17, -16, -16,
-14, -13, -12, -12, -11, -9, -9, -7, -6, -5, -4, -4, -1, -2, -1, 1, 2, 3, 3, 4,
5, 5, 5, 6, 6, 7, 6, 7, 7, 6, 6, 6, 6, 5, 4, 4, 3, 2, 1, 0, -1, -3, -3, -5, -6,
-8, -9, -12, -14, -16, -18, -20, -22, -24, -26, -29, -31, -34, -36, -38, -42,
-44, -46, -49, -52, -55, -57, -60, -63, -66, -68, -71, -75, -77, -79, -82, -85,
-87, -90, -91, -94, -96, -99, -100, -103, -105, -106, -108, -110, -112, -113,
-114, -115, -116, -117, -117, -118, -119, -119, -119, -118, -118, -118, -117,
-117, -116, -115, -114, -113, -111, -110, -107, -107, -104, -103, -100, -99,
-96, -92, -90, -87, -84, -81, -78, -75, -71, -67, -63, -60, -56, -52, -47, -44,
-39, -34, -30, -26, -21, -16, -11, -7, -2, };