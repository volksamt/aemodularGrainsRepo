#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0112

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 8, 12, 15, 17, 18, 22, 24,
26, 29, 31, 33, 34, 37, 40, 41, 44, 46, 48, 49, 52, 54, 55, 57, 59, 60, 61, 64,
65, 67, 68, 69, 70, 71, 74, 74, 76, 77, 78, 79, 80, 81, 82, 83, 83, 85, 85, 86,
86, 87, 88, 89, 88, 90, 90, 90, 91, 91, 91, 92, 92, 92, 93, 92, 94, 94, 93, 94,
95, 94, 94, 94, 95, 94, 95, 96, 94, 95, 96, 96, 96, 96, 96, 96, 96, 97, 96, 97,
98, 98, 99, 98, 99, 99, 100, 99, 100, 100, 101, 101, 102, 102, 102, 102, 102,
103, 104, 105, 105, 105, 105, 106, 107, 107, 107, 109, 109, 110, 110, 110, 111,
111, 112, 112, 113, 114, 114, 115, 115, 115, 116, 116, 116, 117, 118, 118, 117,
118, 118, 118, 118, 119, 119, 118, 118, 119, 119, 119, 118, 118, 118, 117, 118,
118, 118, 117, 117, 116, 115, 115, 114, 113, 113, 111, 112, 111, 110, 109, 107,
106, 106, 104, 104, 103, 101, 101, 100, 98, 97, 96, 94, 93, 92, 91, 89, 88, 86,
84, 84, 82, 80, 79, 78, 76, 74, 72, 71, 70, 69, 67, 66, 65, 63, 61, 61, 58, 57,
55, 54, 52, 51, 49, 48, 46, 45, 44, 42, 42, 39, 39, 37, 36, 35, 33, 32, 31, 30,
28, 26, 26, 25, 23, 23, 21, 20, 20, 17, 17, 15, 14, 14, 12, 11, 10, 9, 9, 7, 7,
5, 4, 2, 2, 0, -1, -2, -3, -4, -5, -5, -6, -7, -9, -10, -11, -12, -13, -14, -15,
-16, -17, -19, -19, -21, -22, -23, -25, -25, -26, -27, -29, -30, -31, -31, -33,
-35, -36, -36, -38, -40, -41, -42, -43, -45, -46, -47, -49, -51, -51, -53, -54,
-56, -57, -58, -61, -62, -63, -65, -66, -68, -69, -71, -73, -74, -76, -76, -79,
-80, -81, -84, -84, -85, -87, -88, -90, -91, -92, -93, -95, -97, -98, -99, -100,
-101, -102, -104, -105, -105, -106, -108, -108, -110, -110, -110, -112, -113,
-114, -114, -115, -115, -116, -116, -117, -117, -117, -118, -117, -118, -119,
-118, -119, -119, -120, -119, -119, -119, -120, -118, -118, -118, -119, -118,
-117, -118, -117, -116, -116, -117, -115, -115, -115, -114, -114, -114, -113,
-112, -112, -111, -111, -111, -110, -109, -109, -109, -108, -106, -107, -106,
-105, -106, -105, -105, -104, -103, -102, -102, -102, -102, -101, -100, -100,
-100, -100, -99, -99, -99, -99, -98, -97, -98, -97, -97, -97, -96, -96, -96,
-95, -95, -95, -95, -96, -95, -94, -94, -95, -94, -93, -94, -93, -94, -93, -93,
-92, -93, -92, -92, -92, -92, -91, -91, -90, -89, -89, -90, -89, -89, -88, -87,
-86, -86, -85, -85, -84, -83, -82, -82, -80, -80, -79, -78, -77, -76, -74, -73,
-72, -70, -70, -68, -66, -65, -63, -62, -62, -59, -58, -55, -54, -52, -51, -49,
-46, -44, -43, -40, -38, -36, -34, -32, -29, -27, -25, -22, -21, -18, -15, -13,
-10, -8, -6, -3, -1, };