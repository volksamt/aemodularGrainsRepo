#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0108

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 13, 18, 22, 27, 32, 36, 41, 46,
49, 54, 57, 60, 64, 67, 70, 72, 75, 77, 80, 82, 84, 85, 87, 89, 90, 91, 93, 95,
96, 97, 99, 100, 101, 102, 103, 105, 106, 107, 108, 109, 110, 111, 112, 114,
114, 116, 116, 116, 118, 117, 118, 119, 120, 120, 118, 118, 119, 118, 117, 118,
117, 116, 115, 114, 114, 113, 111, 111, 110, 109, 108, 107, 107, 107, 105, 106,
105, 105, 105, 104, 104, 105, 104, 104, 105, 105, 104, 106, 106, 106, 107, 106,
107, 107, 107, 109, 108, 108, 107, 108, 108, 108, 107, 107, 107, 107, 107, 107,
106, 106, 106, 105, 105, 104, 104, 104, 103, 103, 103, 102, 102, 101, 101, 101,
101, 100, 100, 100, 100, 99, 99, 99, 98, 98, 98, 97, 97, 97, 96, 95, 95, 94, 93,
93, 93, 92, 92, 91, 91, 91, 90, 90, 90, 90, 88, 89, 88, 88, 89, 88, 88, 87, 89,
88, 87, 87, 88, 86, 87, 87, 86, 86, 85, 85, 84, 83, 82, 81, 79, 77, 76, 74, 73,
71, 70, 68, 66, 63, 62, 60, 57, 56, 53, 52, 49, 47, 45, 44, 42, 41, 39, 38, 36,
36, 33, 32, 31, 30, 29, 27, 27, 25, 24, 23, 23, 22, 21, 19, 18, 16, 14, 13, 12,
11, 9, 7, 6, 5, 3, 3, 1, 0, -1, -3, -5, -5, -7, -7, -9, -8, -9, -9, -10, -9, -9,
-8, -8, -8, -7, -6, -5, -4, -3, -2, -1, 0, 1, 2, 3, 5, 6, 6, 7, 7, 7, 7, 8, 7,
7, 7, 6, 5, 4, 3, 3, 1, -1, -2, -2, -5, -6, -7, -8, -10, -12, -13, -14, -15,
-17, -18, -20, -21, -23, -23, -25, -26, -26, -28, -29, -30, -31, -32, -34, -34,
-35, -38, -39, -39, -41, -42, -44, -46, -48, -50, -52, -53, -56, -58, -59, -62,
-64, -66, -67, -70, -71, -74, -75, -76, -78, -79, -81, -81, -83, -84, -86, -85,
-87, -88, -88, -87, -88, -88, -89, -89, -88, -89, -89, -90, -89, -90, -89, -89,
-90, -89, -90, -91, -91, -90, -91, -91, -92, -92, -92, -92, -94, -94, -94, -95,
-95, -96, -96, -97, -97, -98, -98, -98, -99, -99, -99, -100, -100, -100, -100,
-101, -101, -101, -101, -102, -102, -103, -103, -103, -104, -104, -104, -104,
-104, -106, -105, -106, -106, -107, -107, -108, -107, -108, -108, -108, -107,
-108, -109, -108, -108, -107, -107, -107, -107, -107, -107, -106, -106, -106,
-105, -104, -105, -105, -104, -104, -104, -104, -104, -104, -104, -106, -105,
-106, -107, -107, -108, -109, -109, -110, -111, -112, -112, -114, -115, -116,
-116, -117, -117, -118, -118, -118, -118, -117, -117, -117, -117, -116, -117,
-116, -115, -114, -113, -111, -110, -109, -108, -107, -106, -104, -104, -102,
-100, -99, -98, -97, -95, -94, -92, -92, -90, -88, -86, -85, -84, -82, -80, -77,
-76, -74, -71, -68, -65, -62, -58, -56, -52, -49, -45, -40, -36, -32, -27, -22,
-17, -12, -7, -1, };