#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0052

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 12, 17, 21, 25, 28, 32, 36,
40, 42, 46, 50, 53, 55, 59, 62, 63, 65, 68, 71, 73, 75, 76, 78, 80, 82, 83, 85,
86, 88, 89, 90, 92, 92, 93, 94, 94, 95, 96, 96, 97, 97, 98, 98, 99, 99, 100,
101, 100, 101, 100, 102, 102, 102, 103, 103, 103, 104, 104, 105, 105, 105, 106,
106, 107, 107, 107, 108, 109, 110, 110, 111, 111, 111, 113, 113, 114, 115, 115,
116, 117, 117, 118, 117, 118, 118, 119, 119, 119, 120, 119, 119, 119, 119, 119,
118, 119, 118, 117, 117, 117, 116, 115, 115, 114, 114, 112, 112, 112, 111, 110,
109, 109, 107, 107, 106, 105, 105, 103, 101, 100, 100, 99, 99, 97, 96, 96, 94,
93, 92, 90, 90, 89, 87, 87, 86, 85, 85, 83, 82, 82, 80, 78, 79, 77, 76, 76, 75,
73, 72, 72, 71, 70, 69, 69, 69, 67, 67, 66, 65, 64, 64, 63, 62, 62, 60, 60, 60,
58, 57, 57, 56, 56, 55, 55, 53, 53, 51, 51, 51, 49, 49, 49, 48, 46, 45, 45, 44,
43, 42, 41, 41, 40, 39, 38, 37, 36, 35, 34, 32, 31, 31, 30, 28, 26, 26, 24, 23,
23, 22, 20, 19, 18, 18, 16, 16, 14, 14, 13, 13, 11, 11, 10, 10, 10, 8, 9, 8, 8,
8, 7, 7, 6, 6, 6, 5, 4, 4, 3, 4, 4, 3, 4, 3, 2, 2, 1, 1, 1, 0, 0, 0, -1, -1, -2,
-1, -2, -3, -3, -3, -5, -5, -5, -6, -7, -8, -8, -9, -9, -10, -11, -11, -12, -13,
-13, -14, -15, -15, -17, -18, -18, -19, -19, -22, -22, -22, -24, -25, -26, -26,
-27, -28, -29, -30, -32, -32, -33, -35, -36, -36, -38, -39, -39, -40, -42, -42,
-43, -44, -45, -46, -47, -47, -49, -49, -50, -51, -52, -53, -53, -53, -54, -55,
-56, -57, -57, -58, -57, -59, -59, -60, -60, -61, -60, -61, -60, -62, -62, -62,
-62, -63, -64, -63, -64, -65, -66, -67, -67, -67, -68, -70, -70, -71, -71, -73,
-73, -75, -75, -76, -76, -78, -79, -80, -81, -81, -83, -83, -84, -85, -86, -86,
-87, -88, -89, -90, -92, -92, -92, -94, -95, -95, -96, -96, -97, -98, -98, -99,
-99, -101, -101, -101, -101, -102, -102, -102, -103, -104, -104, -104, -104,
-105, -105, -105, -106, -106, -106, -106, -106, -106, -107, -105, -106, -107,
-106, -106, -105, -105, -105, -106, -105, -105, -105, -104, -105, -104, -104,
-103, -102, -102, -102, -102, -102, -101, -101, -100, -99, -100, -100, -100,
-98, -99, -98, -98, -98, -96, -96, -96, -95, -96, -95, -94, -93, -94, -93, -93,
-93, -93, -93, -92, -92, -91, -90, -91, -89, -89, -89, -89, -89, -88, -87, -86,
-85, -85, -84, -83, -82, -81, -81, -80, -78, -77, -76, -75, -74, -73, -71, -70,
-68, -67, -65, -63, -62, -61, -59, -57, -56, -53, -50, -48, -45, -41, -38, -35,
-31, -27, -24, -19, -15, -11, -6, -3, };