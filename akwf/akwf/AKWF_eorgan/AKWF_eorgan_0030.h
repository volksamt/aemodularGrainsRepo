#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 8, 13, 19, 25, 31, 37, 42, 48, 53,
57, 60, 63, 65, 67, 68, 69, 69, 68, 67, 68, 67, 67, 66, 65, 64, 63, 62, 62, 61,
61, 59, 58, 57, 56, 54, 52, 49, 47, 44, 40, 37, 34, 29, 27, 23, 20, 17, 14, 13,
10, 9, 7, 4, 2, 0, -2, -1, -3, -3, -3, -5, -3, -3, -4, -3, -2, -1, 1, 2, 4, 4,
6, 9, 10, 12, 13, 14, 16, 18, 21, 22, 26, 29, 32, 35, 38, 40, 44, 47, 49, 52,
55, 58, 60, 61, 63, 62, 61, 61, 59, 57, 56, 54, 52, 50, 49, 47, 46, 45, 44, 44,
45, 44, 45, 46, 48, 49, 52, 54, 57, 59, 63, 65, 69, 72, 75, 78, 82, 85, 88, 93,
96, 99, 104, 109, 111, 114, 116, 118, 119, 119, 118, 118, 118, 115, 114, 113,
111, 110, 108, 106, 104, 102, 100, 98, 95, 94, 90, 88, 84, 81, 76, 73, 70, 64,
60, 54, 48, 42, 37, 31, 25, 20, 15, 10, 5, 1, -3, -8, -12, -18, -22, -26, -32,
-36, -40, -44, -48, -50, -54, -57, -60, -62, -65, -66, -69, -70, -72, -75, -75,
-77, -77, -79, -81, -80, -81, -81, -82, -82, -82, -82, -82, -82, -82, -82, -81,
-81, -81, -81, -81, -81, -81, -81, -82, -84, -86, -87, -90, -93, -95, -98, -99,
-102, -102, -103, -104, -104, -105, -104, -103, -102, -101, -100, -97, -95, -92,
-89, -85, -82, -79, -74, -70, -67, -63, -59, -56, -50, -47, -42, -37, -33, -28,
-24, -18, -15, -12, -9, -7, -7, -6, -5, -6, -7, -8, -8, -10, -11, -13, -13, -15,
-15, -16, -17, -18, -19, -20, -20, -21, -23, -24, -26, -28, -31, -33, -35, -38,
-40, -44, -47, -52, -54, -57, -60, -61, -63, -66, -67, -69, -70, -71, -73, -74,
-75, -76, -76, -77, -76, -76, -75, -75, -75, -73, -72, -70, -69, -67, -66, -64,
-63, -61, -59, -58, -56, -54, -52, -49, -47, -44, -40, -38, -35, -32, -29, -26,
-22, -19, -17, -15, -12, -10, -8, -7, -6, -7, -8, -10, -11, -13, -16, -17, -19,
-21, -23, -23, -24, -25, -25, -26, -25, -24, -23, -23, -21, -19, -17, -14, -12,
-9, -6, -3, 0, 2, 6, 9, 11, 16, 19, 23, 27, 31, 36, 39, 42, 44, 47, 47, 49, 49,
49, 48, 47, 47, 46, 45, 45, 43, 42, 41, 40, 40, 38, 36, 36, 33, 32, 30, 27, 24,
21, 17, 13, 9, 5, 0, -5, -10, -14, -19, -24, -28, -31, -35, -39, -43, -46, -50,
-54, -56, -61, -64, -67, -70, -73, -75, -77, -80, -81, -82, -83, -85, -86, -86,
-86, -86, -86, -87, -87, -86, -86, -85, -85, -84, -83, -82, -81, -80, -79, -77,
-75, -73, -72, -70, -69, -67, -65, -64, -63, -61, -61, -61, -61, -61, -63, -63,
-65, -67, -69, -71, -71, -71, -72, -70, -70, -69, -67, -65, -63, -61, -57, -54,
-51, -47, -41, -38, -32, -27, -22, -17, -12, -8, -3, };