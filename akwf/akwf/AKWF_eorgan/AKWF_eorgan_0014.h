#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 3, 4, 5, 7, 8, 9, 11, 12, 14,
15, 16, 17, 18, 20, 21, 22, 23, 24, 26, 27, 28, 29, 31, 32, 33, 34, 35, 37, 38,
39, 39, 42, 42, 43, 44, 45, 46, 47, 49, 50, 52, 53, 54, 54, 56, 58, 58, 59, 60,
60, 62, 64, 64, 66, 66, 68, 68, 70, 71, 72, 73, 74, 75, 76, 76, 77, 78, 78, 80,
81, 82, 82, 83, 85, 85, 86, 87, 88, 89, 89, 90, 91, 92, 92, 93, 94, 94, 96, 96,
96, 97, 98, 99, 99, 100, 100, 100, 102, 102, 102, 103, 104, 104, 105, 106, 105,
106, 107, 106, 107, 107, 107, 108, 109, 108, 109, 109, 109, 109, 111, 110, 110,
110, 111, 110, 111, 111, 111, 111, 111, 111, 110, 111, 111, 111, 110, 111, 110,
111, 110, 109, 111, 110, 110, 111, 110, 109, 109, 108, 109, 108, 108, 107, 107,
106, 106, 106, 105, 105, 104, 104, 104, 103, 102, 101, 101, 100, 100, 100, 99,
99, 98, 97, 96, 95, 95, 95, 93, 93, 93, 91, 90, 89, 88, 88, 87, 87, 86, 84, 84,
82, 82, 81, 80, 78, 77, 77, 76, 75, 74, 73, 72, 70, 70, 68, 67, 67, 65, 64, 63,
62, 60, 60, 59, 57, 56, 56, 54, 53, 51, 51, 49, 48, 47, 46, 44, 44, 41, 40, 39,
37, 36, 35, 33, 32, 31, 30, 29, 27, 26, 25, 23, 22, 21, 20, 18, 17, 15, 14, 12,
12, 10, 9, 8, 7, 6, 3, 2, 2, -1, -1, -3, -4, -6, -7, -7, -9, -11, -12, -12, -15,
-16, -17, -18, -20, -20, -23, -23, -24, -26, -27, -28, -30, -31, -32, -34, -35,
-36, -37, -40, -40, -41, -43, -44, -46, -47, -48, -49, -51, -52, -53, -55, -57,
-57, -58, -60, -61, -62, -63, -64, -66, -67, -68, -70, -71, -73, -73, -75, -75,
-77, -77, -80, -80, -82, -83, -84, -85, -86, -87, -88, -89, -89, -91, -92, -92,
-93, -95, -95, -96, -97, -98, -99, -100, -101, -101, -102, -104, -104, -105,
-106, -106, -108, -108, -109, -109, -109, -110, -112, -112, -112, -112, -113,
-114, -113, -114, -115, -115, -116, -117, -117, -117, -117, -118, -118, -118,
-119, -118, -119, -119, -118, -118, -118, -118, -119, -119, -119, -119, -119,
-119, -119, -118, -118, -118, -118, -118, -118, -117, -117, -117, -117, -116,
-116, -115, -115, -115, -114, -114, -114, -112, -112, -111, -111, -111, -110,
-110, -110, -109, -107, -108, -106, -105, -104, -104, -103, -103, -101, -101,
-100, -99, -99, -97, -96, -96, -94, -93, -92, -92, -90, -89, -88, -88, -87, -86,
-84, -83, -82, -81, -80, -78, -78, -76, -75, -74, -73, -72, -71, -69, -67, -67,
-65, -64, -63, -62, -60, -59, -59, -57, -56, -54, -53, -51, -50, -49, -47, -46,
-44, -43, -43, -41, -39, -38, -36, -36, -34, -33, -30, -30, -29, -27, -27, -24,
-24, -23, -21, -20, -18, -17, -16, -15, -13, -11, -11, -9, -8, -7, -5, -4, -3,
-2, -1, };