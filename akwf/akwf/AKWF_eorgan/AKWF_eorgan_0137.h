#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0137

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 7, 11, 15, 17, 20, 25, 27, 32,
36, 39, 43, 46, 50, 55, 57, 61, 65, 68, 72, 74, 78, 82, 85, 88, 91, 94, 97, 99,
101, 103, 105, 107, 109, 112, 113, 114, 115, 116, 117, 118, 118, 119, 118, 119,
119, 118, 118, 117, 117, 115, 114, 113, 112, 110, 109, 106, 104, 102, 100, 98,
94, 93, 89, 87, 83, 81, 77, 73, 71, 67, 64, 60, 56, 53, 50, 46, 43, 39, 36, 32,
27, 24, 20, 17, 14, 12, 8, 4, 2, -2, -5, -7, -10, -12, -15, -17, -19, -21, -22,
-24, -25, -26, -28, -29, -29, -31, -31, -31, -32, -31, -32, -30, -30, -30, -29,
-28, -28, -26, -25, -23, -22, -20, -17, -16, -14, -11, -9, -7, -5, -2, 1, 4, 6,
9, 12, 15, 18, 21, 24, 26, 29, 32, 35, 38, 42, 45, 47, 50, 54, 55, 58, 61, 63,
65, 67, 69, 70, 72, 74, 75, 76, 77, 79, 80, 79, 80, 80, 80, 80, 79, 80, 79, 78,
77, 76, 74, 73, 71, 70, 68, 65, 64, 61, 59, 56, 54, 51, 48, 45, 41, 38, 34, 31,
28, 23, 19, 16, 12, 8, 3, 0, -4, -8, -12, -16, -20, -25, -29, -33, -38, -41,
-45, -49, -53, -56, -60, -62, -67, -69, -73, -76, -79, -81, -84, -85, -88, -90,
-92, -94, -96, -98, -97, -98, -100, -101, -101, -102, -101, -102, -102, -102,
-100, -100, -100, -99, -97, -97, -95, -93, -91, -90, -88, -86, -84, -82, -80,
-76, -74, -72, -68, -66, -63, -60, -58, -54, -51, -48, -45, -42, -39, -35, -33,
-30, -26, -23, -20, -18, -14, -12, -10, -7, -4, -2, 1, 2, 5, 7, 9, 10, 11, 13,
15, 15, 17, 17, 17, 18, 18, 18, 19, 18, 18, 17, 16, 16, 16, 14, 13, 11, 10, 9,
7, 4, 2, 1, -1, -3, -7, -9, -11, -13, -17, -20, -23, -25, -29, -33, -34, -38,
-41, -45, -47, -51, -54, -57, -60, -63, -67, -70, -73, -75, -78, -80, -83, -86,
-89, -90, -92, -94, -97, -98, -99, -101, -103, -103, -104, -105, -106, -106,
-106, -106, -106, -106, -106, -106, -104, -104, -103, -102, -100, -99, -99, -96,
-94, -92, -90, -88, -85, -83, -80, -77, -75, -71, -68, -64, -61, -58, -54, -51,
-46, -44, -40, -36, -32, -29, -25, -21, -17, -14, -10, -5, -2, 1, 5, 9, 12, 15,
19, 22, 25, 29, 31, 34, 36, 39, 41, 43, 45, 48, 49, 51, 52, 54, 55, 57, 57, 58,
59, 59, 59, 60, 59, 59, 59, 58, 58, 57, 56, 55, 55, 52, 51, 49, 48, 46, 44, 42,
41, 39, 36, 34, 31, 29, 26, 24, 21, 19, 16, 14, 11, 8, 5, 3, -1, -3, -5, -8,
-10, -13, -15, -17, -20, -21, -24, -26, -28, -29, -30, -32, -33, -35, -36, -36,
-36, -37, -38, -38, -37, -38, -37, -37, -37, -36, -35, -34, -33, -32, -30, -28,
-26, -24, -23, -20, -18, -16, -12, -10, -7, -5, -1, };