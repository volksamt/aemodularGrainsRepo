#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 3, 4, 5, 5, 7, 8, 8, 10, 10,
12, 13, 13, 15, 15, 16, 17, 19, 20, 21, 22, 23, 24, 26, 27, 30, 31, 32, 35, 37,
38, 41, 42, 45, 47, 50, 52, 55, 58, 60, 63, 66, 68, 71, 73, 77, 78, 81, 85, 86,
89, 90, 92, 94, 96, 97, 99, 102, 102, 103, 103, 105, 106, 106, 107, 108, 108,
107, 107, 107, 107, 108, 107, 108, 108, 107, 107, 106, 106, 106, 106, 107, 106,
106, 106, 107, 106, 107, 107, 107, 109, 109, 109, 110, 111, 112, 113, 114, 114,
114, 115, 117, 116, 117, 117, 119, 119, 119, 119, 118, 119, 118, 117, 117, 117,
116, 116, 114, 113, 111, 110, 109, 106, 105, 102, 99, 98, 95, 93, 90, 87, 84,
82, 78, 76, 74, 70, 67, 64, 61, 58, 55, 52, 49, 46, 43, 41, 38, 35, 32, 30, 27,
26, 23, 21, 19, 17, 14, 13, 11, 9, 7, 6, 3, 2, 1, -1, -2, -4, -6, -6, -8, -10,
-11, -12, -14, -15, -16, -17, -18, -20, -21, -22, -24, -25, -26, -28, -28, -31,
-31, -33, -34, -35, -37, -38, -40, -40, -41, -42, -45, -44, -46, -48, -50, -50,
-51, -53, -54, -56, -56, -57, -59, -60, -61, -62, -63, -64, -66, -66, -68, -68,
-69, -70, -72, -72, -73, -74, -75, -75, -77, -78, -77, -78, -80, -81, -80, -81,
-82, -82, -83, -83, -83, -84, -84, -85, -85, -86, -86, -87, -87, -87, -88, -88,
-89, -90, -90, -91, -91, -92, -92, -93, -93, -94, -94, -94, -94, -95, -96, -96,
-95, -96, -96, -96, -96, -96, -95, -94, -95, -94, -94, -92, -92, -90, -89, -87,
-86, -84, -82, -81, -79, -77, -74, -71, -69, -67, -64, -62, -59, -55, -53, -51,
-48, -46, -43, -41, -38, -35, -33, -31, -29, -27, -27, -25, -22, -20, -19, -18,
-17, -17, -15, -16, -16, -15, -14, -15, -15, -15, -16, -17, -17, -17, -17, -18,
-19, -19, -20, -20, -21, -21, -22, -22, -22, -21, -22, -21, -21, -20, -21, -20,
-19, -19, -18, -17, -17, -15, -15, -13, -12, -11, -11, -10, -9, -8, -7, -6, -6,
-5, -4, -4, -3, -4, -4, -4, -4, -4, -3, -4, -4, -4, -4, -4, -5, -5, -6, -6, -6,
-7, -8, -8, -9, -10, -10, -11, -11, -11, -11, -11, -12, -12, -13, -12, -13, -13,
-13, -12, -12, -12, -12, -12, -12, -10, -11, -11, -9, -9, -8, -8, -7, -7, -6,
-5, -4, -4, -4, -3, -2, -2, -1, 0, -1, 0, 0, 0, 0, 1, 1, 0, 1, 0, 0, 0, -1, -2,
-1, -2, -3, -3, -3, -4, -4, -4, -6, -6, -7, -8, -9, -10, -11, -11, -12, -14,
-15, -15, -16, -17, -18, -19, -19, -20, -20, -22, -23, -23, -23, -24, -23, -24,
-25, -24, -25, -24, -25, -25, -23, -24, -24, -23, -23, -22, -21, -20, -20, -19,
-18, -17, -16, -15, -13, -12, -12, -10, -10, -9, -7, -6, -5, -4, -3, -2, 0, };