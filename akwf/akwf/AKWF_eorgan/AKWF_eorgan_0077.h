#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0077

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 15, 27, 40, 52, 62, 72, 81, 90, 97,
103, 108, 113, 116, 117, 118, 119, 117, 115, 114, 109, 104, 99, 94, 89, 82, 77,
71, 64, 59, 53, 49, 44, 40, 37, 33, 32, 30, 29, 29, 30, 30, 32, 33, 36, 38, 41,
43, 46, 49, 52, 54, 57, 58, 60, 61, 63, 63, 63, 62, 61, 59, 58, 55, 53, 50, 47,
45, 41, 39, 36, 33, 30, 27, 26, 22, 20, 18, 17, 17, 16, 16, 16, 16, 17, 18, 20,
22, 23, 23, 25, 26, 27, 26, 27, 27, 27, 26, 25, 24, 23, 22, 20, 18, 17, 15, 12,
9, 7, 4, 2, 0, -3, -4, -5, -6, -8, -8, -8, -8, -9, -8, -8, -8, -6, -5, -3, -2,
1, 2, 4, 5, 7, 8, 9, 10, 10, 11, 11, 11, 10, 9, 9, 8, 7, 5, 4, 3, 1, -1, -1, -3,
-4, -5, -6, -7, -6, -7, -5, -5, -5, -3, -2, -1, 2, 4, 6, 9, 11, 15, 17, 19, 23,
25, 27, 29, 29, 31, 31, 30, 29, 29, 27, 27, 25, 23, 22, 19, 17, 16, 13, 11, 8,
7, 6, 5, 4, 3, 4, 3, 5, 6, 7, 9, 11, 13, 16, 19, 21, 23, 26, 29, 30, 33, 34, 33,
34, 34, 33, 31, 29, 26, 22, 17, 12, 6, 1, -6, -12, -20, -28, -35, -43, -50, -57,
-62, -69, -75, -78, -82, -85, -86, -87, -87, -85, -83, -79, -75, -70, -63, -56,
-47, -39, -30, -19, -9, 2, 13, 23, 33, 42, 51, 59, 66, 72, 76, 80, 84, 86, 86,
87, 86, 84, 81, 77, 73, 67, 61, 54, 47, 39, 32, 25, 17, 11, 3, -3, -9, -14, -20,
-24, -28, -30, -32, -34, -35, -35, -35, -34, -32, -30, -28, -26, -23, -21, -18,
-16, -14, -11, -9, -7, -5, -5, -4, -3, -4, -4, -5, -6, -9, -9, -12, -14, -15,
-18, -20, -22, -24, -25, -27, -28, -29, -30, -30, -30, -30, -29, -28, -26, -25,
-22, -19, -16, -14, -10, -8, -5, -3, -1, 0, 2, 3, 4, 5, 5, 6, 6, 6, 5, 5, 4, 3,
1, 0, -2, -4, -5, -7, -8, -9, -9, -10, -11, -11, -12, -11, -10, -9, -8, -8, -6,
-4, -3, -1, 0, 2, 4, 5, 7, 8, 9, 9, 8, 9, 8, 8, 6, 5, 4, 3, 1, -1, -3, -5, -8,
-11, -13, -16, -18, -20, -21, -23, -24, -25, -27, -26, -27, -27, -27, -27, -27,
-26, -26, -24, -23, -21, -20, -19, -17, -17, -15, -16, -15, -17, -18, -20, -21,
-24, -25, -29, -31, -33, -37, -40, -43, -46, -49, -51, -54, -57, -59, -60, -61,
-62, -62, -63, -62, -61, -59, -58, -56, -54, -51, -48, -45, -42, -39, -38, -35,
-32, -31, -29, -29, -29, -29, -30, -31, -34, -37, -41, -45, -50, -54, -60, -66,
-71, -77, -84, -90, -95, -100, -106, -110, -113, -116, -117, -118, -117, -116,
-113, -110, -105, -99, -93, -86, -77, -67, -57, -46, -34, -22, -8, };