#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 5, 8, 9, 10, 11, 13, 14,
16, 17, 19, 20, 21, 22, 23, 26, 27, 28, 29, 31, 32, 33, 35, 36, 37, 39, 39, 41,
42, 45, 45, 47, 48, 48, 51, 51, 54, 54, 56, 56, 58, 60, 61, 61, 63, 65, 65, 66,
67, 69, 71, 71, 72, 74, 75, 76, 76, 78, 80, 80, 82, 83, 84, 85, 85, 87, 87, 89,
90, 91, 91, 93, 93, 94, 96, 96, 97, 97, 99, 99, 100, 101, 102, 103, 104, 104,
106, 106, 106, 107, 108, 108, 108, 110, 110, 110, 111, 111, 112, 112, 113, 114,
114, 115, 116, 115, 116, 116, 116, 116, 118, 117, 117, 118, 117, 118, 118, 119,
119, 119, 119, 119, 119, 118, 118, 119, 120, 119, 118, 119, 119, 118, 119, 118,
119, 118, 117, 118, 117, 117, 116, 116, 116, 117, 116, 115, 115, 115, 115, 114,
113, 112, 112, 112, 112, 111, 110, 110, 109, 109, 108, 107, 108, 107, 106, 105,
104, 104, 103, 103, 102, 101, 101, 100, 100, 99, 99, 97, 97, 96, 95, 95, 93, 92,
92, 91, 90, 89, 88, 87, 86, 85, 84, 82, 82, 80, 80, 79, 77, 76, 76, 75, 73, 71,
71, 69, 68, 67, 65, 64, 63, 62, 61, 59, 57, 57, 55, 55, 52, 51, 50, 48, 48, 46,
45, 43, 41, 40, 39, 37, 36, 33, 32, 31, 30, 28, 26, 24, 24, 22, 20, 20, 18, 16,
14, 13, 11, 10, 8, 7, 6, 4, 2, 1, -1, -3, -4, -6, -7, -8, -11, -11, -12, -14,
-17, -17, -20, -21, -21, -23, -25, -27, -29, -29, -31, -32, -34, -36, -37, -38,
-39, -41, -42, -43, -45, -47, -49, -50, -51, -52, -53, -55, -56, -57, -58, -59,
-60, -62, -63, -64, -65, -68, -68, -69, -71, -71, -73, -74, -74, -76, -77, -78,
-79, -80, -81, -83, -84, -84, -86, -86, -87, -89, -89, -90, -91, -91, -92, -94,
-95, -95, -97, -97, -98, -99, -99, -99, -101, -101, -102, -103, -104, -105,
-104, -106, -106, -107, -108, -108, -109, -109, -110, -110, -111, -111, -111,
-112, -112, -113, -113, -115, -114, -114, -115, -115, -116, -117, -116, -117,
-116, -116, -117, -117, -117, -118, -117, -118, -117, -118, -118, -119, -118,
-118, -118, -119, -118, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -118, -118, -118, -117, -116, -116, -117, -116,
-115, -115, -114, -114, -114, -113, -113, -112, -112, -111, -110, -109, -109,
-108, -108, -107, -106, -105, -105, -104, -103, -102, -101, -101, -99, -99, -97,
-96, -96, -95, -94, -93, -92, -91, -89, -89, -88, -87, -85, -85, -83, -82, -81,
-81, -79, -77, -76, -75, -73, -73, -71, -70, -68, -67, -67, -65, -64, -62, -61,
-60, -58, -58, -55, -54, -52, -52, -50, -48, -47, -45, -45, -44, -42, -41, -40,
-38, -36, -34, -34, -32, -31, -29, -27, -25, -24, -23, -22, -21, -19, -18, -17,
-15, -14, -13, -12, -10, -8, -7, -5, -3, -2, -1, };