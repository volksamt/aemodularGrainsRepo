#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0088

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 17, 21, 26, 30, 35, 40, 44,
49, 52, 56, 61, 64, 68, 71, 74, 78, 81, 85, 88, 91, 94, 95, 98, 100, 103, 105,
106, 108, 109, 111, 113, 114, 114, 116, 117, 118, 118, 119, 118, 119, 119, 119,
118, 119, 118, 117, 117, 117, 116, 115, 114, 113, 111, 111, 110, 108, 107, 105,
104, 103, 101, 99, 97, 96, 94, 92, 91, 90, 87, 86, 85, 82, 81, 80, 78, 76, 75,
72, 70, 70, 68, 66, 65, 64, 62, 61, 60, 58, 57, 56, 54, 53, 51, 51, 50, 48, 48,
45, 45, 44, 42, 41, 40, 39, 38, 37, 36, 34, 33, 33, 32, 31, 29, 28, 27, 26, 25,
24, 23, 21, 20, 20, 19, 17, 17, 16, 14, 14, 12, 12, 10, 10, 8, 7, 7, 6, 5, 5, 3,
2, 1, 1, -1, -1, -2, -4, -3, -4, -6, -7, -7, -8, -9, -10, -11, -11, -13, -13,
-14, -16, -15, -16, -19, -20, -21, -21, -22, -23, -25, -25, -26, -27, -29, -31,
-32, -33, -34, -36, -37, -39, -40, -41, -43, -44, -45, -48, -50, -51, -52, -54,
-56, -57, -59, -60, -61, -63, -64, -66, -67, -68, -70, -71, -71, -74, -75, -75,
-75, -76, -76, -78, -78, -78, -79, -79, -80, -79, -79, -78, -77, -77, -77, -76,
-76, -75, -74, -72, -71, -70, -69, -66, -66, -63, -62, -59, -58, -55, -52, -51,
-48, -45, -42, -39, -36, -33, -30, -27, -23, -20, -16, -13, -9, -6, -2, 1, 5, 9,
12, 16, 19, 23, 26, 30, 33, 36, 39, 42, 44, 47, 50, 52, 55, 57, 59, 62, 63, 66,
67, 69, 69, 71, 72, 73, 75, 76, 76, 77, 77, 78, 79, 79, 80, 80, 79, 79, 79, 77,
77, 77, 76, 76, 75, 74, 74, 73, 72, 71, 69, 68, 67, 65, 64, 63, 61, 59, 58, 56,
54, 53, 51, 49, 48, 46, 45, 43, 42, 39, 39, 37, 36, 34, 32, 31, 30, 30, 28, 27,
26, 25, 23, 22, 21, 20, 19, 17, 16, 15, 15, 14, 13, 12, 11, 10, 9, 9, 7, 7, 7,
5, 4, 3, 3, 2, 1, 0, -1, -1, -3, -3, -4, -5, -7, -8, -8, -9, -10, -11, -13, -13,
-15, -16, -16, -16, -18, -19, -20, -21, -22, -23, -24, -25, -26, -28, -29, -30,
-30, -32, -32, -34, -35, -36, -37, -38, -40, -40, -42, -42, -44, -44, -46, -47,
-48, -50, -51, -53, -53, -54, -55, -56, -58, -59, -62, -62, -63, -65, -66, -68,
-69, -71, -73, -74, -76, -77, -79, -81, -82, -84, -86, -87, -88, -90, -92, -93,
-94, -97, -99, -100, -102, -103, -104, -106, -108, -108, -110, -110, -112, -112,
-114, -116, -116, -116, -118, -118, -118, -119, -119, -118, -119, -118, -117,
-117, -117, -116, -116, -114, -113, -113, -112, -109, -108, -106, -104, -102,
-100, -99, -96, -94, -91, -88, -85, -82, -79, -74, -72, -68, -64, -60, -57, -52,
-48, -44, -40, -35, -31, -27, -21, -18, -12, -7, -3, };