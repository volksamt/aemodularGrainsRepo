#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0050

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 10, 14, 19, 25, 30, 35, 40, 46,
51, 55, 60, 62, 65, 68, 71, 75, 78, 83, 86, 90, 94, 97, 101, 105, 107, 110, 112,
114, 117, 118, 118, 119, 119, 119, 118, 119, 118, 117, 116, 114, 114, 111, 110,
109, 106, 105, 102, 99, 96, 92, 87, 82, 77, 72, 68, 62, 57, 51, 45, 39, 34, 28,
24, 19, 14, 9, 6, 3, 0, -1, -3, -6, -7, -9, -11, -13, -13, -15, -17, -19, -19,
-20, -21, -20, -21, -22, -21, -20, -21, -21, -20, -20, -22, -23, -25, -26, -27,
-28, -29, -30, -30, -32, -32, -31, -32, -33, -31, -32, -31, -30, -30, -29, -29,
-28, -27, -27, -26, -25, -23, -22, -21, -19, -19, -18, -18, -18, -18, -17, -16,
-16, -15, -16, -15, -14, -14, -14, -13, -12, -12, -12, -12, -11, -10, -10, -9,
-10, -9, -9, -9, -8, -9, -8, -9, -10, -9, -10, -11, -11, -13, -13, -15, -16,
-17, -19, -20, -20, -20, -22, -21, -21, -21, -20, -21, -20, -20, -20, -20, -20,
-21, -21, -22, -22, -22, -22, -23, -24, -25, -26, -27, -27, -28, -29, -30, -30,
-31, -31, -31, -31, -32, -32, -32, -30, -31, -31, -31, -32, -32, -31, -33, -32,
-32, -32, -31, -31, -31, -31, -31, -32, -34, -34, -36, -39, -41, -43, -46, -49,
-51, -53, -56, -58, -59, -60, -61, -61, -60, -60, -58, -57, -56, -53, -51, -49,
-46, -43, -39, -36, -33, -29, -24, -20, -16, -12, -9, -6, -3, 1, 2, 6, 11, 15,
19, 24, 28, 33, 37, 41, 45, 47, 51, 53, 56, 59, 63, 67, 71, 74, 78, 82, 86, 90,
92, 96, 98, 101, 102, 104, 105, 106, 107, 106, 107, 107, 106, 106, 105, 104,
104, 103, 102, 100, 98, 98, 95, 92, 89, 86, 82, 78, 73, 68, 65, 58, 54, 49, 44,
38, 34, 29, 24, 19, 15, 12, 8, 4, 2, -1, -2, -3, -5, -6, -7, -7, -9, -11, -12,
-12, -13, -14, -13, -14, -13, -13, -13, -13, -13, -12, -12, -12, -13, -13, -14,
-15, -16, -17, -18, -19, -20, -20, -20, -20, -21, -20, -19, -19, -18, -17, -16,
-17, -16, -15, -15, -13, -14, -12, -12, -10, -10, -9, -8, -8, -8, -7, -7, -8,
-8, -7, -8, -8, -7, -8, -7, -7, -8, -7, -7, -7, -6, -7, -7, -6, -7, -7, -8, -8,
-8, -9, -9, -9, -9, -10, -12, -13, -14, -15, -18, -19, -22, -23, -25, -27, -28,
-30, -31, -31, -32, -33, -34, -34, -33, -33, -33, -33, -34, -35, -34, -36, -36,
-37, -37, -38, -39, -39, -41, -40, -42, -44, -44, -45, -46, -46, -46, -47, -47,
-47, -47, -47, -46, -47, -45, -46, -45, -45, -46, -45, -45, -44, -44, -44, -44,
-42, -43, -43, -43, -43, -43, -44, -46, -47, -49, -51, -53, -55, -58, -59, -62,
-62, -63, -65, -65, -65, -63, -62, -61, -58, -56, -53, -50, -47, -44, -41, -38,
-33, -29, -24, -21, -15, -11, -8, -4, 0, };