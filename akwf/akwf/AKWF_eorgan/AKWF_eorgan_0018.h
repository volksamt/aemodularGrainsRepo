#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 8, 12, 15, 20, 24, 27, 31, 35,
38, 41, 45, 49, 51, 55, 58, 61, 64, 66, 70, 73, 75, 79, 81, 83, 86, 89, 91, 93,
95, 97, 100, 102, 103, 105, 106, 108, 110, 112, 113, 113, 115, 115, 116, 116,
118, 118, 119, 118, 119, 118, 119, 119, 119, 120, 119, 118, 117, 117, 116, 116,
115, 114, 113, 113, 112, 111, 109, 109, 108, 106, 106, 105, 103, 102, 101, 99,
98, 97, 96, 94, 94, 93, 92, 89, 89, 86, 87, 84, 83, 81, 80, 78, 78, 77, 75, 75,
73, 72, 70, 69, 68, 66, 65, 64, 63, 63, 61, 61, 59, 59, 58, 57, 56, 56, 55, 53,
52, 51, 51, 50, 49, 49, 47, 47, 46, 46, 45, 44, 43, 43, 41, 41, 40, 39, 38, 36,
36, 35, 33, 32, 32, 30, 29, 28, 27, 26, 25, 23, 22, 21, 20, 18, 17, 15, 14, 12,
11, 9, 8, 7, 5, 3, 2, 0, -1, -4, -5, -7, -8, -11, -12, -13, -16, -18, -20, -22,
-25, -26, -28, -29, -30, -32, -35, -36, -38, -39, -41, -44, -45, -46, -49, -49,
-51, -52, -55, -55, -56, -58, -58, -59, -60, -61, -62, -63, -64, -65, -65, -66,
-66, -66, -66, -66, -66, -66, -66, -66, -65, -66, -65, -64, -64, -63, -63, -61,
-61, -60, -58, -57, -56, -55, -53, -52, -50, -48, -46, -45, -43, -40, -38, -36,
-34, -31, -28, -27, -24, -23, -20, -18, -15, -13, -10, -7, -5, -3, 0, 4, 6, 7,
10, 13, 16, 18, 21, 23, 25, 28, 29, 32, 33, 36, 38, 40, 42, 43, 46, 47, 49, 51,
52, 54, 56, 57, 57, 58, 60, 61, 62, 62, 64, 64, 66, 65, 66, 66, 66, 67, 66, 66,
66, 66, 66, 65, 65, 64, 63, 62, 62, 61, 60, 59, 58, 58, 55, 53, 53, 51, 49, 49,
46, 46, 44, 41, 40, 38, 37, 34, 33, 31, 30, 27, 25, 24, 22, 20, 18, 17, 15, 13,
11, 9, 8, 6, 4, 2, 1, -1, -3, -4, -7, -8, -9, -11, -13, -14, -16, -18, -20, -20,
-22, -23, -25, -26, -27, -28, -29, -30, -31, -32, -33, -34, -36, -37, -37, -39,
-40, -40, -40, -42, -43, -43, -44, -44, -46, -46, -47, -47, -49, -50, -51, -51,
-52, -53, -53, -54, -55, -56, -57, -57, -59, -59, -61, -62, -63, -64, -64, -66,
-66, -68, -68, -69, -71, -71, -73, -75, -74, -76, -77, -78, -80, -80, -83, -83,
-85, -85, -87, -88, -89, -90, -92, -94, -95, -96, -98, -99, -100, -102, -102,
-104, -105, -106, -106, -108, -109, -111, -111, -112, -112, -114, -114, -115,
-115, -116, -117, -117, -116, -117, -117, -117, -117, -117, -117, -115, -116,
-115, -114, -115, -113, -112, -112, -111, -109, -108, -106, -106, -105, -103,
-101, -99, -98, -96, -94, -92, -89, -87, -85, -82, -80, -77, -75, -72, -69, -66,
-62, -60, -56, -53, -49, -46, -43, -40, -36, -33, -29, -26, -21, -18, -14, -10,
-7, -2, };