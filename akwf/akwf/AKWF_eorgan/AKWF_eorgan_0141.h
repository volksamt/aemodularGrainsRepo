#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0141

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 9, 16, 24, 30, 37, 42, 47, 53, 56,
60, 64, 67, 69, 72, 72, 75, 76, 78, 79, 79, 80, 81, 82, 82, 82, 82, 82, 82, 82,
82, 82, 81, 81, 81, 81, 80, 80, 80, 79, 78, 78, 79, 77, 78, 78, 78, 78, 78, 78,
78, 78, 80, 79, 79, 79, 79, 78, 77, 78, 77, 76, 75, 74, 72, 71, 69, 67, 65, 64,
62, 60, 58, 57, 56, 54, 52, 51, 50, 50, 47, 48, 47, 46, 47, 46, 46, 46, 46, 46,
46, 45, 45, 43, 42, 41, 40, 38, 37, 35, 32, 31, 28, 26, 23, 22, 20, 17, 16, 15,
13, 11, 11, 10, 9, 10, 10, 9, 10, 11, 10, 11, 12, 12, 13, 13, 14, 14, 15, 13,
13, 13, 11, 11, 10, 9, 8, 7, 6, 4, 3, 3, 2, 1, 0, 0, 1, 1, 2, 2, 2, 4, 4, 6, 8,
9, 10, 12, 13, 14, 15, 16, 17, 18, 19, 19, 19, 19, 21, 20, 20, 20, 21, 20, 21,
20, 20, 21, 21, 21, 21, 22, 22, 23, 23, 23, 24, 25, 25, 26, 25, 26, 26, 26, 26,
26, 27, 28, 26, 28, 27, 27, 28, 27, 27, 27, 27, 28, 27, 26, 25, 26, 24, 24, 21,
21, 18, 16, 13, 10, 6, 4, -1, -5, -10, -15, -19, -25, -29, -34, -38, -43, -46,
-50, -53, -55, -58, -58, -59, -60, -59, -57, -55, -52, -48, -46, -42, -36, -31,
-26, -20, -14, -8, -2, 3, 8, 14, 19, 23, 26, 31, 34, 37, 39, 40, 41, 43, 43, 44,
43, 43, 42, 41, 40, 38, 36, 35, 33, 30, 28, 27, 24, 23, 21, 19, 17, 14, 11, 10,
7, 5, 3, 1, -2, -3, -5, -6, -9, -9, -11, -13, -14, -13, -15, -16, -15, -16, -16,
-16, -16, -16, -16, -16, -17, -17, -17, -18, -19, -19, -20, -21, -21, -23, -23,
-24, -26, -26, -27, -28, -29, -29, -29, -29, -29, -30, -28, -27, -25, -26, -23,
-23, -20, -19, -17, -15, -15, -14, -12, -11, -10, -8, -9, -8, -8, -8, -9, -9,
-10, -10, -10, -11, -12, -13, -12, -13, -15, -14, -13, -13, -12, -13, -11, -10,
-9, -9, -6, -5, -5, -2, -2, 0, 1, 1, 1, 2, 2, 2, 1, 0, -1, -2, -3, -5, -6, -7,
-9, -10, -12, -13, -15, -16, -17, -18, -18, -19, -20, -20, -20, -21, -20, -21,
-20, -20, -20, -20, -22, -22, -22, -23, -24, -25, -26, -28, -29, -31, -33, -34,
-36, -38, -40, -40, -43, -44, -45, -47, -48, -50, -51, -52, -54, -54, -56, -57,
-57, -58, -59, -59, -62, -61, -63, -63, -64, -65, -66, -66, -67, -68, -68, -68,
-69, -69, -70, -70, -70, -70, -71, -71, -71, -72, -72, -73, -75, -76, -78, -80,
-81, -84, -87, -89, -91, -95, -98, -101, -104, -107, -110, -112, -114, -116,
-118, -119, -119, -119, -118, -116, -115, -111, -107, -103, -98, -92, -86, -80,
-73, -65, -56, -48, -40, -32, -22, -14, -5, };