#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0074

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 8, 15, 22, 28, 34, 40, 46, 51, 57,
63, 68, 72, 77, 82, 86, 90, 94, 98, 101, 104, 106, 109, 111, 113, 114, 116, 117,
118, 119, 120, 119, 118, 118, 118, 117, 116, 114, 113, 111, 108, 107, 105, 102,
99, 96, 94, 92, 88, 86, 83, 80, 76, 75, 71, 68, 66, 63, 61, 58, 55, 53, 51, 48,
46, 44, 41, 39, 38, 36, 35, 33, 32, 31, 31, 29, 29, 27, 28, 27, 27, 27, 27, 27,
27, 27, 28, 28, 28, 29, 29, 29, 30, 30, 30, 30, 30, 31, 30, 30, 31, 30, 29, 29,
28, 28, 27, 27, 26, 25, 24, 24, 23, 22, 20, 20, 18, 18, 15, 15, 12, 11, 9, 8, 6,
4, 3, 1, 0, -2, -4, -4, -6, -8, -9, -10, -11, -12, -13, -14, -13, -13, -15, -14,
-15, -15, -14, -14, -13, -12, -11, -11, -10, -9, -7, -6, -4, -2, -1, 1, 3, 6, 7,
10, 12, 14, 16, 19, 21, 24, 27, 29, 31, 33, 35, 37, 40, 41, 43, 43, 46, 46, 47,
48, 48, 48, 48, 48, 48, 48, 47, 46, 44, 43, 42, 40, 39, 37, 34, 33, 30, 28, 25,
23, 20, 18, 15, 11, 8, 5, 3, -1, -4, -7, -10, -13, -17, -19, -22, -24, -27, -29,
-32, -33, -35, -37, -39, -40, -40, -42, -43, -43, -43, -43, -44, -43, -43, -42,
-41, -40, -39, -39, -36, -35, -33, -30, -28, -26, -23, -20, -18, -15, -13, -9,
-5, -3, 1, 5, 7, 11, 13, 16, 19, 22, 25, 27, 29, 31, 34, 36, 37, 38, 40, 41, 42,
42, 43, 44, 43, 44, 42, 42, 42, 41, 39, 38, 37, 35, 34, 32, 30, 28, 25, 24, 20,
17, 15, 11, 8, 5, 1, -1, -4, -8, -10, -13, -16, -19, -21, -25, -27, -29, -33,
-34, -36, -38, -40, -42, -42, -44, -46, -47, -47, -48, -48, -49, -49, -48, -48,
-48, -47, -46, -45, -44, -43, -40, -39, -37, -35, -32, -30, -28, -25, -22, -20,
-18, -15, -13, -11, -9, -7, -5, -2, 0, 2, 3, 5, 6, 8, 9, 10, 10, 12, 12, 14, 14,
14, 15, 14, 14, 14, 14, 13, 13, 11, 11, 10, 9, 9, 6, 6, 4, 2, 1, -1, -3, -4, -5,
-8, -9, -10, -12, -13, -14, -16, -17, -19, -21, -22, -23, -23, -23, -25, -26,
-27, -27, -28, -28, -29, -30, -30, -30, -30, -30, -31, -30, -31, -30, -30, -30,
-29, -29, -29, -28, -29, -28, -28, -27, -27, -27, -27, -26, -28, -28, -28, -28,
-29, -31, -31, -33, -33, -35, -36, -37, -38, -40, -42, -46, -47, -50, -52, -54,
-57, -58, -62, -65, -67, -70, -73, -76, -79, -81, -84, -87, -90, -92, -94, -98,
-100, -103, -105, -107, -110, -111, -113, -114, -115, -116, -117, -118, -118,
-118, -118, -118, -116, -115, -114, -113, -111, -109, -107, -104, -101, -97,
-95, -91, -88, -83, -78, -74, -69, -63, -58, -53, -47, -42, -35, -30, -23, -16,
-11, -3, };