#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 6, 6, 8, 9, 11, 12, 13, 15,
15, 18, 18, 20, 22, 22, 24, 25, 26, 28, 29, 31, 31, 33, 34, 35, 36, 38, 39, 40,
41, 43, 44, 45, 45, 47, 48, 49, 50, 51, 53, 53, 55, 55, 57, 58, 59, 61, 61, 62,
63, 65, 65, 66, 68, 68, 69, 71, 71, 72, 73, 74, 76, 77, 77, 78, 79, 80, 80, 81,
83, 84, 85, 86, 86, 88, 88, 89, 90, 92, 92, 92, 94, 95, 95, 96, 96, 98, 99, 100,
100, 100, 101, 102, 103, 103, 104, 105, 106, 106, 107, 108, 108, 109, 109, 109,
110, 111, 112, 111, 112, 112, 113, 113, 113, 114, 115, 115, 115, 115, 116, 116,
117, 116, 117, 117, 117, 117, 118, 117, 117, 117, 117, 118, 117, 117, 117, 117,
117, 117, 117, 117, 117, 116, 117, 117, 117, 117, 117, 117, 118, 118, 118, 117,
118, 118, 119, 119, 119, 118, 119, 119, 118, 118, 118, 118, 118, 117, 117, 117,
116, 116, 115, 114, 114, 114, 113, 111, 112, 110, 110, 109, 108, 107, 106, 104,
105, 104, 102, 101, 99, 99, 98, 97, 95, 94, 94, 92, 90, 90, 88, 87, 86, 85, 83,
82, 81, 78, 77, 76, 74, 73, 72, 70, 69, 68, 66, 64, 62, 61, 59, 57, 56, 54, 52,
51, 49, 48, 45, 44, 41, 40, 39, 37, 35, 34, 32, 30, 28, 26, 24, 24, 21, 20, 18,
17, 15, 14, 12, 9, 9, 7, 5, 5, 2, 0, -2, -2, -4, -5, -7, -9, -10, -12, -14, -15,
-17, -18, -20, -21, -23, -24, -25, -27, -29, -30, -32, -33, -34, -36, -37, -39,
-40, -42, -43, -44, -46, -47, -48, -50, -51, -53, -53, -55, -56, -57, -59, -60,
-61, -62, -63, -64, -65, -67, -68, -69, -70, -72, -73, -74, -74, -76, -77, -78,
-79, -80, -82, -82, -84, -84, -85, -86, -88, -88, -90, -91, -91, -92, -94, -95,
-95, -96, -97, -98, -99, -100, -100, -102, -103, -103, -104, -104, -105, -106,
-106, -107, -108, -108, -109, -111, -110, -111, -112, -112, -114, -113, -114,
-115, -115, -115, -116, -116, -116, -117, -116, -118, -118, -118, -118, -118,
-118, -118, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -118,
-118, -118, -118, -118, -118, -118, -117, -117, -118, -116, -116, -116, -115,
-115, -115, -115, -114, -112, -113, -112, -112, -111, -112, -111, -111, -112,
-111, -111, -111, -111, -110, -110, -111, -110, -110, -110, -110, -110, -109,
-110, -110, -108, -109, -108, -108, -108, -106, -106, -105, -105, -104, -103,
-103, -103, -101, -100, -99, -98, -98, -96, -94, -94, -93, -92, -91, -90, -89,
-87, -86, -85, -84, -83, -81, -81, -79, -78, -76, -75, -74, -73, -71, -71, -69,
-67, -66, -65, -63, -62, -61, -59, -57, -56, -54, -53, -51, -50, -49, -46, -45,
-43, -41, -40, -39, -37, -36, -34, -33, -31, -29, -27, -25, -24, -23, -21, -19,
-18, -16, -15, -14, -12, -11, -9, -7, -6, -5, -3, -2, -1, };