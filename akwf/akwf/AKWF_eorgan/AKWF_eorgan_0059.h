#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0059

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 10, 18, 26, 34, 42, 50, 56, 65, 71,
78, 83, 90, 93, 99, 103, 107, 110, 113, 114, 117, 118, 119, 119, 119, 119, 118,
116, 114, 112, 110, 108, 104, 101, 97, 94, 90, 87, 83, 79, 76, 72, 68, 65, 62,
59, 55, 52, 50, 47, 45, 43, 41, 40, 39, 38, 38, 38, 37, 37, 37, 38, 38, 39, 40,
40, 41, 43, 44, 46, 46, 47, 48, 49, 50, 50, 51, 52, 52, 52, 52, 52, 51, 51, 50,
49, 48, 46, 44, 42, 40, 38, 36, 33, 32, 29, 26, 24, 21, 18, 15, 13, 11, 9, 6, 4,
2, 0, -2, -4, -4, -6, -6, -8, -9, -9, -10, -10, -10, -9, -9, -8, -7, -6, -4, -3,
-3, -2, 1, 2, 3, 4, 5, 8, 8, 9, 11, 11, 12, 13, 13, 15, 15, 16, 15, 15, 15, 15,
14, 13, 13, 12, 12, 11, 10, 9, 7, 6, 5, 4, 4, 2, 2, 1, 1, 0, -1, -1, -1, -1, -1,
0, 1, 1, 3, 4, 6, 7, 9, 11, 13, 15, 17, 19, 22, 24, 27, 29, 31, 33, 36, 37, 40,
41, 43, 45, 45, 47, 46, 47, 47, 46, 46, 46, 44, 42, 40, 38, 35, 33, 30, 26, 22,
18, 14, 10, 6, 1, -3, -9, -14, -18, -23, -27, -32, -37, -41, -44, -48, -51, -55,
-57, -60, -62, -63, -64, -64, -65, -64, -65, -63, -61, -59, -58, -55, -52, -48,
-44, -39, -36, -30, -26, -21, -15, -10, -5, 0, 7, 12, 18, 23, 28, 32, 38, 42,
46, 50, 53, 56, 58, 60, 62, 64, 64, 65, 65, 65, 64, 63, 61, 58, 55, 53, 50, 46,
42, 39, 33, 30, 26, 21, 15, 12, 7, 2, -3, -7, -12, -17, -21, -24, -28, -31, -34,
-37, -39, -41, -43, -45, -46, -47, -48, -47, -48, -47, -46, -45, -45, -43, -41,
-39, -38, -35, -33, -31, -28, -27, -23, -22, -19, -17, -15, -13, -11, -8, -7,
-6, -4, -3, -2, -2, 0, 1, 1, 0, 0, 0, 0, -1, -1, -2, -3, -4, -5, -6, -8, -8, -9,
-10, -12, -13, -13, -13, -15, -15, -15, -15, -15, -15, -15, -14, -14, -14, -13,
-12, -12, -11, -9, -8, -7, -4, -4, -2, -2, 0, 2, 3, 4, 6, 7, 6, 8, 8, 9, 9, 9,
9, 8, 7, 8, 6, 5, 4, 2, 1, 0, -4, -5, -7, -10, -12, -14, -17, -20, -23, -25,
-28, -30, -33, -35, -38, -40, -41, -43, -45, -47, -48, -49, -50, -51, -52, -52,
-52, -52, -52, -52, -51, -51, -49, -49, -48, -46, -46, -45, -43, -43, -41, -40,
-40, -39, -38, -38, -37, -37, -37, -37, -37, -39, -40, -41, -42, -44, -46, -47,
-51, -54, -57, -59, -62, -65, -70, -73, -77, -81, -85, -87, -91, -96, -98, -102,
-105, -107, -110, -113, -114, -116, -116, -118, -117, -118, -117, -116, -114,
-113, -109, -107, -104, -100, -95, -90, -84, -78, -73, -66, -60, -52, -44, -37,
-29, -21, -13, -5, };