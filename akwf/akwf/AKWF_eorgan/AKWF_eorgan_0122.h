#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0122

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 14, 24, 33, 42, 52, 60, 68, 75, 82,
88, 93, 98, 102, 106, 108, 111, 113, 114, 116, 117, 118, 118, 118, 119, 119,
119, 119, 119, 118, 119, 119, 118, 119, 119, 118, 119, 119, 119, 119, 118, 118,
117, 118, 117, 116, 116, 115, 115, 114, 114, 114, 113, 114, 113, 113, 113, 113,
114, 114, 113, 114, 114, 113, 114, 112, 112, 111, 109, 107, 105, 102, 99, 96,
93, 89, 85, 80, 76, 71, 66, 62, 57, 52, 48, 42, 37, 33, 30, 26, 23, 18, 15, 12,
10, 8, 5, 3, 1, -1, -4, -5, -6, -9, -10, -13, -14, -16, -19, -19, -21, -22, -23,
-25, -26, -27, -27, -27, -28, -27, -26, -25, -24, -22, -20, -18, -14, -13, -9,
-7, -4, -1, 2, 5, 7, 9, 11, 12, 13, 14, 14, 16, 17, 16, 16, 17, 17, 17, 17, 17,
17, 17, 18, 18, 19, 20, 20, 20, 21, 22, 22, 23, 23, 23, 23, 23, 23, 22, 22, 20,
19, 17, 16, 15, 12, 10, 8, 5, 3, 1, -1, -3, -4, -5, -6, -6, -7, -7, -8, -6, -6,
-5, -4, -3, -2, -1, 1, 1, 3, 4, 5, 6, 6, 6, 7, 7, 7, 7, 7, 5, 5, 3, 3, 1, 1, 0,
-1, -3, -4, -7, -7, -9, -11, -12, -14, -16, -18, -21, -23, -26, -28, -30, -33,
-36, -38, -40, -42, -45, -46, -48, -48, -49, -50, -49, -48, -47, -45, -43, -39,
-37, -32, -27, -22, -17, -11, -6, 0, 8, 13, 18, 24, 30, 33, 37, 41, 43, 46, 48,
48, 49, 49, 49, 48, 47, 46, 44, 41, 40, 37, 34, 32, 29, 27, 25, 22, 20, 18, 15,
14, 12, 9, 9, 6, 5, 3, 1, 1, 0, -2, -2, -3, -4, -6, -6, -7, -7, -8, -7, -8, -7,
-7, -7, -5, -4, -4, -3, -1, 1, 2, 3, 5, 5, 6, 7, 7, 6, 6, 6, 5, 5, 3, 1, -1, -2,
-4, -7, -9, -12, -13, -15, -16, -19, -20, -21, -22, -23, -23, -24, -24, -23,
-23, -23, -23, -22, -22, -21, -20, -20, -19, -19, -17, -18, -17, -17, -17, -17,
-16, -17, -16, -16, -17, -16, -15, -14, -13, -12, -10, -7, -6, -3, 0, 2, 5, 7,
11, 13, 15, 18, 20, 22, 24, 26, 27, 27, 27, 28, 26, 26, 25, 25, 23, 22, 19, 18,
16, 14, 13, 11, 8, 7, 6, 4, 2, 0, -2, -4, -7, -9, -12, -14, -18, -20, -25, -27,
-31, -36, -40, -45, -50, -55, -59, -65, -69, -74, -79, -83, -88, -91, -94, -99,
-101, -104, -106, -108, -110, -111, -113, -114, -114, -114, -114, -115, -114,
-114, -113, -114, -113, -114, -114, -113, -113, -114, -114, -114, -115, -115,
-116, -116, -116, -116, -117, -117, -117, -118, -118, -118, -117, -117, -118,
-118, -118, -118, -118, -118, -118, -118, -118, -117, -117, -117, -116, -116,
-115, -114, -112, -111, -108, -104, -102, -98, -94, -89, -83, -77, -70, -62,
-55, -45, -37, -27, -17, -6, };