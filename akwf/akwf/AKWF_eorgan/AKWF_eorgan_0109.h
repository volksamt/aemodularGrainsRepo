#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0109

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 12, 18, 24, 29, 32, 37, 42, 46,
51, 54, 57, 61, 64, 67, 70, 72, 76, 77, 79, 82, 84, 84, 86, 88, 89, 90, 91, 92,
94, 95, 96, 97, 99, 100, 101, 102, 104, 105, 107, 107, 110, 110, 112, 113, 114,
116, 116, 117, 117, 119, 118, 119, 119, 119, 119, 118, 119, 117, 118, 116, 115,
114, 114, 112, 110, 109, 108, 106, 105, 104, 103, 102, 101, 99, 98, 98, 97, 97,
96, 95, 96, 95, 95, 95, 94, 95, 95, 94, 94, 94, 94, 94, 95, 95, 95, 94, 94, 94,
94, 93, 93, 92, 92, 91, 90, 91, 89, 90, 89, 88, 87, 86, 85, 85, 85, 84, 83, 84,
83, 82, 83, 82, 82, 82, 81, 81, 81, 81, 81, 81, 81, 81, 80, 80, 80, 79, 80, 80,
79, 79, 78, 78, 78, 77, 77, 76, 76, 76, 76, 76, 75, 76, 75, 76, 76, 75, 76, 76,
76, 77, 77, 77, 78, 79, 79, 79, 79, 79, 80, 79, 79, 80, 80, 80, 80, 79, 78, 77,
76, 75, 74, 73, 72, 70, 68, 67, 65, 63, 62, 60, 58, 57, 55, 53, 51, 49, 48, 46,
45, 44, 43, 42, 41, 40, 39, 38, 37, 37, 36, 36, 35, 34, 33, 32, 31, 31, 29, 29,
28, 26, 25, 24, 23, 21, 19, 18, 16, 14, 13, 10, 9, 8, 6, 3, 1, 0, -1, -2, -3,
-4, -4, -5, -6, -6, -6, -6, -6, -5, -5, -4, -4, -4, -2, -2, -1, 0, 1, 2, 2, 3,
3, 4, 4, 5, 5, 5, 4, 3, 3, 2, 1, -1, -2, -3, -5, -6, -8, -9, -11, -12, -14, -17,
-18, -20, -22, -23, -24, -26, -28, -29, -29, -31, -32, -33, -34, -35, -35, -35,
-36, -37, -38, -38, -39, -40, -40, -42, -42, -44, -44, -46, -47, -48, -51, -51,
-53, -55, -56, -58, -60, -62, -63, -65, -66, -69, -70, -71, -73, -75, -76, -76,
-78, -79, -79, -80, -81, -80, -80, -81, -80, -81, -81, -80, -79, -79, -79, -79,
-78, -77, -78, -77, -78, -76, -76, -76, -76, -76, -77, -77, -76, -76, -77, -76,
-77, -78, -78, -78, -79, -78, -79, -79, -79, -80, -80, -80, -81, -81, -81, -80,
-81, -81, -82, -81, -82, -82, -81, -82, -83, -82, -82, -83, -84, -84, -85, -85,
-85, -86, -86, -87, -88, -88, -89, -90, -90, -90, -91, -92, -92, -93, -92, -92,
-93, -94, -93, -95, -94, -94, -94, -95, -94, -94, -95, -93, -94, -94, -94, -94,
-94, -95, -96, -95, -95, -96, -97, -97, -98, -100, -100, -101, -103, -104, -105,
-106, -108, -109, -110, -111, -113, -113, -115, -115, -116, -117, -117, -118,
-119, -118, -118, -118, -117, -117, -117, -115, -114, -113, -113, -111, -110,
-108, -107, -106, -104, -102, -102, -101, -100, -97, -96, -95, -93, -92, -91,
-90, -88, -86, -86, -84, -83, -81, -80, -77, -76, -73, -72, -69, -65, -63, -60,
-57, -53, -49, -46, -41, -38, -32, -27, -22, -18, -12, -7, -2, };