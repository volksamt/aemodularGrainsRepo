#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0127

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 13, 21, 29, 37, 44, 51, 57, 63, 68,
71, 75, 78, 80, 83, 83, 83, 85, 84, 84, 83, 83, 81, 80, 78, 76, 75, 72, 70, 68,
64, 62, 59, 56, 53, 51, 47, 44, 40, 37, 34, 31, 28, 25, 21, 19, 16, 14, 12, 10,
9, 8, 6, 6, 5, 5, 5, 6, 6, 8, 9, 10, 11, 14, 15, 17, 17, 20, 22, 23, 24, 26, 28,
29, 30, 31, 32, 32, 34, 35, 35, 36, 36, 36, 36, 36, 36, 36, 37, 36, 36, 35, 35,
33, 32, 31, 31, 28, 26, 25, 22, 20, 17, 15, 12, 9, 6, 4, 2, 0, -3, -4, -5, -5,
-6, -5, -5, -4, 0, 2, 6, 10, 13, 18, 23, 28, 33, 39, 43, 48, 51, 56, 61, 64, 67,
69, 71, 73, 73, 75, 74, 74, 73, 72, 72, 70, 68, 66, 65, 62, 61, 59, 57, 55, 53,
50, 48, 48, 45, 44, 42, 41, 39, 38, 36, 35, 34, 32, 31, 30, 29, 29, 29, 28, 27,
28, 28, 28, 28, 29, 29, 31, 32, 34, 36, 36, 38, 39, 42, 43, 46, 47, 48, 50, 51,
53, 54, 55, 54, 55, 55, 54, 53, 53, 52, 50, 49, 47, 46, 43, 41, 38, 36, 33, 32,
28, 26, 23, 20, 17, 14, 12, 9, 6, 2, 0, -3, -7, -10, -13, -17, -20, -23, -25,
-28, -29, -32, -33, -34, -34, -35, -33, -31, -29, -25, -22, -18, -12, -5, 1, 8,
16, 23, 32, 40, 48, 56, 64, 72, 79, 85, 91, 97, 102, 106, 110, 113, 115, 117,
119, 120, 119, 119, 118, 117, 115, 114, 112, 109, 106, 104, 99, 97, 93, 90, 85,
81, 78, 73, 69, 65, 61, 55, 50, 46, 40, 36, 32, 27, 22, 18, 13, 9, 6, 2, -2, -5,
-8, -10, -12, -15, -17, -17, -18, -19, -20, -21, -20, -21, -21, -21, -21, -21,
-20, -21, -20, -20, -20, -20, -21, -22, -22, -22, -22, -23, -25, -26, -27, -28,
-29, -31, -31, -33, -34, -36, -37, -40, -41, -43, -45, -47, -50, -53, -55, -58,
-61, -65, -68, -72, -75, -80, -84, -86, -90, -94, -97, -99, -102, -104, -105,
-107, -107, -107, -105, -103, -102, -99, -97, -92, -89, -84, -79, -76, -71, -66,
-62, -58, -54, -51, -47, -46, -43, -42, -41, -39, -40, -40, -40, -41, -43, -44,
-45, -46, -49, -51, -54, -55, -57, -59, -61, -62, -64, -66, -67, -70, -71, -73,
-74, -76, -76, -78, -79, -80, -80, -80, -81, -82, -82, -83, -82, -83, -82, -82,
-80, -80, -78, -77, -75, -73, -71, -69, -68, -65, -62, -60, -58, -55, -53, -52,
-49, -46, -45, -43, -43, -41, -41, -40, -39, -38, -39, -40, -41, -41, -42, -44,
-46, -45, -48, -50, -51, -53, -55, -57, -59, -61, -62, -65, -67, -69, -72, -73,
-75, -79, -80, -82, -86, -87, -89, -93, -94, -95, -97, -98, -98, -98, -97, -96,
-94, -92, -89, -85, -81, -75, -68, -61, -53, -46, -38, -29, -21, -12, -3, };