#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0089

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 12, 18, 23, 28, 33, 38, 42, 47,
51, 56, 60, 65, 68, 72, 75, 79, 83, 86, 90, 91, 95, 97, 101, 103, 104, 106, 109,
110, 112, 113, 114, 115, 116, 117, 118, 119, 118, 118, 118, 119, 118, 118, 117,
117, 116, 115, 114, 114, 112, 111, 109, 107, 105, 103, 102, 100, 98, 95, 93, 91,
88, 85, 82, 80, 76, 74, 71, 69, 67, 65, 62, 59, 56, 54, 52, 50, 48, 45, 43, 42,
40, 38, 35, 34, 32, 31, 29, 28, 26, 25, 25, 22, 22, 20, 19, 18, 17, 16, 15, 14,
13, 12, 12, 12, 10, 10, 9, 9, 9, 9, 8, 8, 8, 8, 9, 8, 8, 7, 7, 8, 8, 9, 8, 9, 9,
10, 10, 11, 11, 12, 12, 12, 12, 13, 14, 13, 13, 14, 15, 14, 14, 14, 15, 15, 14,
15, 14, 15, 14, 13, 13, 13, 13, 13, 12, 11, 11, 10, 9, 10, 8, 7, 7, 6, 5, 4, 2,
1, 0, -1, -3, -4, -4, -6, -8, -10, -11, -14, -16, -17, -19, -21, -24, -25, -28,
-31, -32, -34, -37, -40, -43, -45, -48, -50, -52, -55, -57, -59, -62, -63, -65,
-67, -68, -70, -71, -73, -74, -76, -77, -78, -78, -81, -80, -81, -82, -83, -83,
-82, -83, -82, -83, -81, -81, -81, -81, -79, -78, -77, -76, -74, -73, -70, -69,
-67, -65, -62, -60, -58, -55, -52, -50, -47, -44, -41, -37, -33, -30, -27, -22,
-19, -15, -11, -7, -3, 1, 7, 10, 13, 18, 21, 26, 29, 32, 36, 40, 43, 46, 49, 52,
54, 58, 59, 63, 64, 66, 68, 70, 73, 74, 76, 76, 78, 79, 79, 80, 81, 81, 82, 82,
82, 82, 83, 82, 83, 82, 81, 80, 80, 78, 77, 76, 75, 74, 72, 71, 69, 68, 66, 64,
62, 60, 59, 55, 54, 51, 48, 46, 44, 41, 38, 35, 33, 30, 28, 25, 24, 22, 19, 18,
15, 14, 12, 10, 8, 7, 5, 4, 2, 1, 0, -2, -3, -4, -5, -6, -7, -7, -9, -9, -10,
-11, -11, -12, -12, -13, -13, -14, -14, -14, -15, -14, -15, -14, -15, -15, -15,
-15, -15, -15, -15, -14, -14, -14, -14, -14, -13, -13, -14, -13, -12, -12, -11,
-11, -10, -10, -10, -9, -9, -8, -9, -9, -9, -8, -8, -9, -9, -8, -8, -9, -9, -9,
-10, -10, -11, -11, -12, -13, -14, -14, -15, -16, -17, -18, -19, -20, -20, -22,
-24, -24, -26, -28, -28, -30, -32, -34, -35, -38, -40, -41, -42, -45, -47, -49,
-52, -54, -56, -59, -61, -63, -65, -68, -70, -72, -75, -78, -80, -84, -87, -89,
-92, -94, -96, -99, -100, -102, -104, -106, -107, -110, -112, -112, -114, -115,
-115, -117, -117, -117, -118, -118, -118, -118, -119, -118, -118, -117, -116,
-116, -114, -113, -112, -110, -108, -106, -105, -102, -100, -98, -96, -92, -89,
-86, -83, -79, -76, -72, -69, -64, -60, -57, -52, -49, -44, -38, -33, -29, -24,
-19, -13, -8, -2, };