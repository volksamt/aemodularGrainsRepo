#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0144

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 6, 9, 11, 16, 19, 22, 26, 29,
32, 35, 39, 42, 47, 49, 52, 56, 60, 63, 65, 69, 72, 76, 77, 80, 83, 86, 87, 90,
92, 94, 96, 98, 100, 101, 103, 104, 105, 107, 108, 109, 110, 111, 111, 112, 112,
114, 113, 113, 113, 114, 114, 114, 113, 114, 113, 112, 112, 112, 110, 110, 109,
108, 107, 106, 105, 104, 102, 101, 99, 98, 98, 96, 95, 93, 92, 90, 89, 88, 86,
84, 83, 81, 79, 77, 76, 74, 73, 70, 69, 68, 66, 64, 63, 62, 60, 59, 57, 56, 54,
54, 53, 53, 52, 52, 51, 51, 51, 51, 52, 52, 54, 54, 57, 57, 58, 60, 62, 64, 65,
68, 71, 73, 76, 78, 79, 80, 82, 84, 86, 89, 91, 94, 97, 99, 101, 103, 106, 108,
109, 111, 112, 115, 116, 117, 117, 118, 118, 120, 120, 118, 118, 117, 117, 116,
115, 114, 112, 110, 108, 106, 104, 101, 97, 94, 91, 89, 86, 82, 79, 75, 71, 68,
63, 60, 56, 53, 49, 45, 42, 38, 35, 31, 28, 25, 22, 18, 16, 13, 11, 8, 5, 2, -1,
-2, -5, -6, -9, -11, -13, -16, -17, -19, -20, -21, -23, -25, -26, -27, -28, -29,
-29, -31, -32, -33, -33, -34, -34, -34, -33, -33, -34, -34, -34, -33, -34, -33,
-32, -33, -31, -31, -30, -29, -28, -27, -26, -25, -23, -22, -22, -20, -18, -17,
-15, -14, -13, -12, -10, -8, -6, -5, -3, -2, -1, 0, 0, 0, 2, 3, 5, 7, 8, 10, 11,
13, 14, 15, 16, 18, 20, 20, 22, 23, 24, 25, 26, 27, 27, 29, 29, 29, 30, 30, 31,
31, 31, 31, 31, 31, 30, 30, 30, 31, 30, 29, 28, 27, 25, 25, 23, 22, 21, 20, 18,
17, 15, 13, 11, 10, 7, 6, 4, 1, -1, -4, -5, -7, -10, -12, -14, -17, -20, -23,
-26, -28, -30, -32, -35, -38, -41, -43, -46, -49, -52, -54, -57, -60, -63, -66,
-69, -71, -75, -77, -80, -82, -85, -88, -90, -92, -95, -97, -100, -102, -104,
-106, -107, -109, -111, -111, -113, -113, -114, -115, -116, -116, -116, -115,
-115, -115, -113, -112, -111, -110, -109, -107, -105, -103, -101, -98, -96, -94,
-93, -91, -89, -87, -85, -82, -80, -76, -74, -72, -69, -66, -65, -62, -60, -58,
-55, -54, -52, -50, -49, -48, -47, -47, -45, -45, -45, -45, -45, -46, -46, -46,
-47, -49, -49, -51, -52, -55, -55, -59, -60, -61, -64, -66, -69, -72, -74, -76,
-79, -81, -83, -86, -89, -91, -93, -96, -97, -101, -102, -104, -106, -107, -108,
-110, -112, -113, -114, -115, -116, -116, -117, -116, -117, -118, -119, -118,
-119, -118, -118, -117, -117, -116, -116, -116, -115, -114, -114, -112, -111,
-111, -109, -108, -106, -105, -103, -101, -100, -97, -95, -93, -90, -87, -85,
-83, -79, -77, -74, -70, -66, -63, -60, -57, -54, -50, -47, -44, -41, -37, -34,
-31, -28, -25, -21, -18, -14, -12, -9, -6, -4, -1, };