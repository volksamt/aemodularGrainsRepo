#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 5, 6, 8, 9, 10, 12, 13, 16,
17, 19, 20, 21, 23, 24, 26, 28, 29, 29, 30, 33, 34, 35, 36, 38, 38, 40, 41, 43,
44, 45, 45, 47, 48, 49, 50, 51, 52, 53, 54, 54, 56, 56, 57, 58, 59, 59, 61, 61,
62, 62, 63, 63, 64, 65, 65, 66, 67, 68, 68, 69, 69, 69, 70, 71, 71, 71, 71, 72,
72, 73, 74, 74, 74, 74, 75, 75, 76, 77, 77, 77, 78, 78, 77, 78, 79, 79, 80, 80,
80, 80, 81, 81, 81, 82, 83, 84, 84, 85, 86, 86, 87, 89, 90, 91, 92, 93, 94, 94,
96, 97, 99, 99, 100, 101, 102, 104, 104, 105, 106, 107, 108, 108, 109, 111, 111,
111, 111, 113, 113, 113, 114, 116, 115, 116, 115, 117, 117, 117, 117, 118, 117,
119, 118, 118, 120, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 118, 119,
118, 117, 117, 117, 116, 115, 115, 113, 113, 113, 111, 111, 109, 109, 108, 106,
106, 105, 103, 103, 101, 100, 99, 98, 96, 95, 94, 92, 92, 90, 89, 87, 86, 85,
83, 82, 80, 78, 77, 75, 74, 72, 71, 70, 67, 66, 64, 63, 61, 60, 58, 56, 55, 54,
52, 51, 49, 47, 47, 44, 43, 42, 40, 38, 37, 35, 34, 33, 32, 29, 28, 27, 26, 24,
23, 21, 19, 19, 17, 16, 15, 13, 12, 10, 9, 9, 7, 6, 4, 3, 2, 1, -1, -2, -3, -5,
-6, -7, -8, -9, -11, -12, -13, -14, -15, -17, -19, -20, -22, -23, -24, -24, -26,
-28, -29, -30, -31, -32, -34, -35, -37, -39, -40, -41, -43, -44, -44, -47, -48,
-49, -51, -52, -53, -54, -55, -56, -58, -60, -61, -62, -64, -64, -67, -68, -68,
-70, -72, -73, -75, -75, -77, -78, -79, -80, -82, -83, -85, -86, -86, -88, -90,
-90, -92, -93, -93, -95, -96, -96, -97, -99, -100, -100, -102, -102, -103, -104,
-104, -106, -107, -107, -107, -108, -108, -109, -110, -111, -111, -112, -112,
-113, -112, -112, -114, -113, -114, -114, -113, -114, -114, -114, -113, -113,
-114, -113, -114, -113, -114, -113, -113, -112, -112, -111, -111, -111, -111,
-110, -110, -110, -108, -109, -108, -107, -107, -107, -106, -105, -105, -104,
-104, -102, -101, -101, -101, -100, -99, -99, -98, -97, -96, -95, -94, -93, -93,
-92, -92, -91, -90, -89, -89, -87, -87, -86, -85, -85, -84, -84, -83, -81, -81,
-80, -80, -79, -78, -77, -76, -75, -74, -74, -73, -72, -72, -71, -71, -70, -69,
-68, -68, -68, -66, -66, -65, -65, -64, -64, -63, -64, -63, -62, -62, -63, -62,
-62, -61, -62, -61, -61, -61, -60, -60, -60, -61, -60, -59, -59, -58, -58, -57,
-56, -55, -54, -54, -52, -52, -51, -50, -48, -48, -47, -45, -43, -43, -41, -40,
-39, -37, -36, -35, -33, -32, -31, -29, -28, -27, -25, -24, -23, -22, -20, -19,
-17, -16, -14, -13, -11, -11, -9, -7, -5, -4, -3, -1, -1, };