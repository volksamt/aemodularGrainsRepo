#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0142

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 16, 21, 25, 31, 36, 40, 44, 49,
53, 56, 61, 65, 68, 71, 74, 77, 80, 82, 85, 87, 90, 92, 94, 96, 98, 100, 101,
103, 105, 106, 107, 108, 109, 110, 111, 111, 111, 112, 113, 113, 114, 114, 114,
113, 113, 114, 114, 113, 113, 113, 113, 112, 110, 111, 110, 108, 107, 107, 105,
104, 103, 102, 101, 99, 98, 96, 95, 94, 92, 91, 90, 88, 86, 86, 84, 83, 82, 80,
80, 79, 77, 77, 75, 75, 74, 74, 72, 72, 71, 70, 69, 69, 69, 69, 68, 68, 67, 67,
66, 66, 66, 66, 66, 65, 65, 66, 66, 67, 66, 67, 67, 68, 69, 69, 69, 70, 71, 72,
72, 73, 73, 74, 75, 75, 77, 78, 78, 79, 80, 80, 82, 82, 82, 83, 85, 85, 85, 86,
88, 88, 89, 89, 91, 91, 92, 93, 93, 94, 95, 95, 96, 96, 97, 97, 98, 98, 98, 98,
97, 97, 98, 97, 97, 97, 95, 96, 95, 94, 94, 93, 92, 91, 90, 89, 87, 86, 85, 83,
83, 81, 80, 77, 77, 76, 75, 72, 71, 69, 67, 65, 64, 62, 60, 59, 57, 54, 52, 50,
49, 46, 45, 43, 41, 38, 36, 34, 32, 30, 27, 25, 23, 21, 19, 16, 14, 12, 9, 7, 5,
3, 1, 0, -3, -4, -5, -8, -9, -10, -12, -13, -13, -14, -14, -14, -15, -14, -15,
-13, -13, -13, -12, -10, -9, -8, -7, -5, -4, -1, -1, 1, 2, 4, 5, 7, 8, 9, 10,
11, 13, 13, 14, 15, 15, 16, 16, 17, 16, 16, 16, 16, 16, 15, 14, 13, 13, 13, 12,
10, 9, 9, 7, 5, 4, 3, 1, 0, -1, -4, -5, -7, -8, -10, -12, -14, -16, -17, -19,
-21, -23, -25, -26, -30, -31, -33, -35, -36, -39, -40, -43, -45, -47, -50, -52,
-53, -56, -58, -59, -62, -63, -66, -67, -69, -71, -73, -75, -77, -77, -80, -80,
-81, -83, -85, -85, -86, -88, -89, -89, -90, -90, -91, -92, -93, -93, -93, -93,
-94, -93, -94, -94, -94, -93, -94, -94, -95, -94, -93, -94, -93, -92, -93, -91,
-92, -91, -90, -89, -89, -89, -87, -87, -86, -85, -84, -83, -83, -82, -81, -80,
-79, -78, -77, -76, -76, -75, -74, -74, -73, -73, -71, -71, -70, -70, -69, -69,
-69, -67, -68, -66, -66, -66, -65, -65, -64, -64, -64, -65, -64, -64, -64, -64,
-64, -64, -65, -64, -65, -65, -66, -68, -68, -68, -70, -70, -71, -72, -74, -75,
-75, -78, -78, -80, -81, -83, -84, -85, -87, -88, -89, -91, -92, -93, -94, -96,
-98, -98, -101, -102, -102, -104, -106, -106, -107, -109, -109, -110, -111,
-112, -112, -114, -115, -114, -116, -116, -117, -117, -117, -118, -118, -119,
-118, -119, -119, -119, -119, -118, -119, -118, -118, -117, -117, -116, -115,
-114, -113, -111, -109, -108, -105, -103, -101, -99, -95, -92, -89, -85, -82,
-77, -74, -69, -65, -61, -56, -50, -45, -40, -34, -29, -23, -18, -11, -6, 0, };