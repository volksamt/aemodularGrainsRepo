#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0034

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 9, 16, 21, 27, 35, 41, 46, 53, 57,
63, 67, 74, 78, 82, 87, 90, 96, 98, 101, 105, 108, 110, 113, 114, 116, 117, 117,
118, 119, 119, 119, 119, 119, 117, 115, 115, 113, 110, 107, 105, 103, 100, 96,
94, 89, 86, 82, 78, 73, 70, 66, 62, 56, 52, 47, 42, 36, 31, 26, 22, 16, 12, 7,
3, -1, -5, -8, -10, -13, -15, -16, -18, -17, -17, -18, -17, -17, -15, -14, -13,
-11, -9, -7, -5, -4, -1, 1, 3, 6, 8, 9, 12, 13, 16, 17, 18, 20, 21, 22, 22, 23,
24, 24, 23, 24, 23, 23, 22, 21, 19, 19, 17, 16, 14, 13, 10, 9, 6, 4, 2, 0, -3,
-6, -8, -11, -13, -15, -18, -20, -23, -24, -27, -29, -31, -33, -35, -36, -37,
-38, -39, -38, -39, -39, -40, -39, -39, -39, -39, -37, -36, -36, -34, -33, -31,
-29, -26, -24, -21, -19, -17, -14, -11, -7, -4, -1, 2, 5, 9, 12, 17, 19, 24, 27,
30, 34, 38, 41, 45, 48, 52, 55, 60, 62, 67, 70, 73, 75, 79, 81, 83, 86, 89, 92,
93, 95, 97, 98, 100, 100, 100, 99, 98, 96, 94, 92, 89, 85, 83, 79, 75, 71, 67,
62, 58, 53, 49, 45, 40, 36, 31, 28, 23, 19, 16, 12, 9, 6, 2, 0, -2, -4, -6, -9,
-10, -11, -12, -13, -14, -14, -15, -16, -17, -19, -18, -18, -16, -14, -12, -11,
-9, -8, -8, -6, -5, -2, 1, 3, 5, 7, 9, 12, 15, 16, 19, 21, 23, 25, 28, 30, 31,
32, 34, 36, 38, 38, 39, 40, 41, 41, 41, 40, 41, 40, 38, 38, 37, 36, 34, 33, 31,
29, 27, 23, 21, 18, 16, 13, 10, 7, 3, 0, -4, -7, -11, -14, -18, -21, -24, -27,
-31, -34, -37, -39, -42, -44, -47, -50, -51, -54, -56, -58, -60, -61, -60, -59,
-59, -57, -55, -54, -52, -49, -46, -43, -40, -37, -34, -29, -26, -21, -18, -14,
-10, -7, -3, 1, 4, 8, 11, 14, 16, 20, 22, 24, 26, 27, 30, 31, 32, 33, 33, 35,
34, 34, 33, 34, 32, 32, 30, 28, 28, 25, 23, 21, 18, 16, 14, 11, 8, 6, 2, -2, -5,
-8, -12, -15, -18, -20, -25, -28, -31, -35, -38, -41, -44, -48, -51, -54, -57,
-59, -62, -64, -67, -69, -72, -73, -75, -77, -77, -79, -79, -81, -83, -82, -82,
-82, -83, -82, -82, -81, -81, -79, -79, -77, -77, -74, -73, -71, -70, -68, -66,
-65, -62, -60, -58, -57, -55, -52, -50, -48, -46, -45, -43, -40, -39, -37, -35,
-34, -33, -30, -29, -29, -27, -27, -27, -27, -27, -29, -30, -32, -34, -36, -39,
-41, -45, -48, -52, -55, -59, -62, -66, -70, -73, -76, -80, -83, -86, -89, -91,
-93, -96, -98, -99, -100, -101, -102, -102, -103, -102, -101, -101, -98, -97,
-95, -92, -88, -84, -79, -76, -70, -65, -60, -56, -51, -46, -40, -34, -28, -20,
-14, -7, -1, };