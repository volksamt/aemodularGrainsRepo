#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0031

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 12, 21, 29, 36, 44, 51, 57, 63, 68,
74, 77, 82, 86, 88, 91, 95, 96, 99, 100, 103, 103, 105, 106, 107, 109, 109, 110,
111, 113, 112, 112, 114, 115, 114, 115, 116, 116, 116, 117, 117, 117, 118, 118,
118, 118, 118, 118, 120, 118, 119, 117, 116, 112, 110, 107, 104, 101, 98, 95,
93, 90, 88, 84, 81, 76, 72, 67, 64, 59, 56, 52, 49, 47, 45, 43, 42, 41, 39, 38,
37, 37, 37, 36, 36, 36, 36, 35, 36, 35, 35, 35, 35, 35, 35, 35, 35, 35, 34, 35,
34, 33, 32, 30, 28, 27, 26, 23, 22, 20, 18, 16, 14, 13, 13, 12, 15, 15, 17, 20,
21, 24, 27, 28, 31, 31, 31, 33, 33, 36, 38, 40, 42, 44, 46, 46, 47, 48, 49, 49,
50, 49, 49, 50, 50, 49, 49, 50, 50, 49, 49, 48, 48, 48, 48, 47, 48, 48, 47, 47,
47, 47, 48, 47, 48, 46, 47, 46, 46, 47, 46, 47, 46, 46, 47, 46, 46, 47, 46, 44,
41, 39, 36, 33, 30, 26, 24, 21, 19, 16, 14, 10, 5, 2, -3, -8, -12, -15, -20,
-23, -26, -28, -32, -34, -36, -38, -40, -42, -44, -45, -47, -47, -50, -51, -51,
-53, -54, -55, -56, -57, -58, -59, -61, -61, -62, -63, -64, -65, -65, -64, -63,
-62, -61, -61, -60, -58, -58, -55, -55, -52, -52, -51, -49, -46, -43, -40, -37,
-32, -29, -25, -22, -19, -17, -18, -13, -8, -2, 3, 9, 14, 19, 24, 28, 32, 37,
39, 42, 44, 44, 46, 47, 48, 49, 49, 49, 50, 49, 49, 49, 49, 49, 48, 48, 48, 48,
47, 48, 47, 48, 47, 46, 46, 46, 46, 45, 45, 45, 44, 44, 45, 44, 43, 44, 43, 43,
42, 42, 40, 38, 35, 32, 29, 25, 22, 19, 16, 14, 12, 9, 5, 0, -3, -9, -13, -17,
-21, -25, -28, -31, -33, -36, -37, -39, -40, -41, -42, -43, -43, -44, -44, -44,
-45, -45, -45, -45, -46, -45, -45, -46, -46, -46, -47, -46, -47, -46, -45, -47,
-48, -50, -51, -53, -54, -55, -57, -60, -61, -64, -65, -67, -68, -68, -69, -67,
-65, -63, -61, -59, -56, -54, -53, -50, -50, -50, -48, -47, -44, -44, -40, -39,
-37, -35, -34, -34, -33, -32, -32, -32, -31, -31, -31, -31, -32, -31, -33, -33,
-33, -32, -33, -34, -33, -34, -34, -33, -33, -34, -34, -34, -34, -34, -35, -35,
-34, -34, -34, -34, -34, -34, -34, -35, -34, -35, -35, -35, -35, -36, -37, -40,
-43, -45, -48, -52, -55, -58, -61, -62, -66, -67, -73, -76, -80, -85, -89, -94,
-98, -102, -105, -107, -109, -109, -111, -112, -112, -112, -112, -112, -112,
-111, -111, -110, -109, -109, -108, -106, -105, -106, -104, -103, -103, -102,
-102, -100, -99, -99, -98, -96, -94, -92, -90, -87, -85, -84, -81, -78, -76,
-74, -72, -70, -67, -65, -62, -58, -53, -50, -45, -41, -37, -33, -29, -25, -18,
-12, -3, };