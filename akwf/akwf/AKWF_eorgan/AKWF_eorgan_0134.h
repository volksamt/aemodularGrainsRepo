#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0134

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 10, 14, 19, 24, 29, 34, 38, 45,
49, 54, 58, 63, 66, 71, 75, 79, 81, 85, 88, 91, 93, 95, 96, 98, 99, 100, 101,
102, 102, 101, 102, 101, 99, 100, 98, 98, 97, 96, 94, 92, 91, 90, 88, 86, 85,
82, 81, 80, 78, 77, 75, 74, 72, 71, 69, 68, 67, 65, 65, 63, 62, 60, 60, 59, 57,
57, 55, 55, 53, 52, 51, 50, 49, 49, 47, 46, 46, 45, 43, 43, 41, 41, 40, 39, 38,
36, 36, 36, 34, 34, 32, 31, 29, 28, 27, 27, 25, 24, 23, 21, 19, 19, 18, 16, 15,
13, 12, 11, 9, 8, 6, 5, 4, 2, 1, 1, -1, -2, -3, -3, -5, -5, -5, -6, -7, -7, -8,
-8, -8, -9, -10, -10, -9, -9, -9, -10, -11, -11, -10, -11, -11, -11, -11, -11,
-11, -12, -12, -12, -13, -13, -13, -14, -14, -14, -14, -15, -15, -15, -15, -16,
-16, -16, -17, -16, -17, -17, -17, -17, -16, -17, -16, -16, -15, -16, -15, -13,
-13, -13, -13, -12, -11, -10, -10, -9, -9, -8, -6, -6, -5, -5, -3, -2, -2, -1,
1, 2, 2, 3, 5, 5, 7, 8, 8, 9, 11, 11, 12, 12, 13, 14, 15, 15, 16, 17, 16, 17,
17, 17, 18, 18, 17, 17, 16, 16, 16, 15, 16, 14, 15, 14, 14, 14, 14, 12, 13, 13,
13, 14, 14, 15, 15, 17, 18, 19, 20, 22, 25, 27, 29, 32, 36, 39, 42, 44, 48, 52,
55, 59, 63, 67, 71, 75, 79, 83, 87, 90, 94, 97, 100, 103, 106, 109, 111, 113,
114, 116, 117, 117, 119, 118, 118, 118, 119, 118, 117, 116, 114, 112, 111, 110,
107, 105, 102, 100, 97, 95, 92, 90, 87, 84, 81, 78, 75, 74, 70, 68, 65, 62, 60,
58, 55, 52, 50, 48, 45, 42, 40, 38, 36, 33, 31, 30, 27, 25, 22, 21, 19, 17, 15,
13, 11, 8, 7, 4, 2, 0, -1, -4, -5, -8, -9, -12, -14, -15, -17, -19, -20, -23,
-25, -26, -30, -31, -33, -35, -38, -39, -42, -44, -46, -48, -50, -54, -56, -57,
-60, -62, -63, -66, -67, -70, -72, -73, -76, -76, -78, -80, -81, -83, -84, -85,
-86, -88, -89, -89, -91, -92, -92, -94, -93, -94, -95, -95, -97, -97, -98, -98,
-98, -98, -100, -99, -100, -101, -102, -101, -103, -104, -104, -105, -105, -106,
-107, -107, -107, -108, -109, -109, -109, -109, -110, -109, -110, -110, -110,
-109, -110, -110, -109, -110, -109, -109, -108, -108, -107, -106, -106, -105,
-103, -102, -102, -100, -100, -100, -98, -97, -96, -95, -93, -92, -91, -89, -88,
-87, -85, -84, -83, -82, -80, -79, -78, -76, -74, -73, -72, -71, -70, -69, -68,
-66, -65, -65, -63, -62, -61, -61, -60, -59, -59, -58, -58, -57, -58, -57, -57,
-56, -56, -55, -55, -53, -54, -53, -52, -52, -51, -49, -48, -47, -44, -43, -41,
-38, -35, -33, -30, -27, -24, -19, -16, -12, -7, -3, };