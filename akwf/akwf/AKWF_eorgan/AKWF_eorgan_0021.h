#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 6, 7, 9, 11, 13, 15, 17, 17,
21, 23, 25, 27, 29, 30, 33, 35, 37, 39, 42, 44, 46, 49, 51, 53, 55, 57, 60, 63,
64, 66, 68, 71, 73, 76, 78, 79, 81, 84, 85, 87, 90, 91, 93, 95, 96, 98, 99, 101,
102, 103, 105, 106, 107, 109, 110, 111, 112, 113, 114, 114, 114, 116, 117, 116,
117, 118, 118, 118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 118, 118, 118,
117, 116, 116, 115, 114, 113, 112, 112, 110, 109, 109, 107, 107, 105, 103, 103,
101, 100, 98, 97, 96, 94, 93, 91, 90, 87, 86, 84, 82, 81, 79, 78, 75, 73, 71,
69, 67, 65, 63, 62, 59, 57, 55, 53, 51, 49, 47, 45, 43, 42, 38, 36, 35, 32, 30,
29, 27, 25, 23, 21, 18, 17, 15, 14, 11, 9, 7, 6, 4, 2, 0, -2, -4, -4, -6, -8,
-10, -11, -13, -14, -17, -18, -19, -21, -23, -24, -26, -28, -28, -31, -32, -33,
-36, -36, -38, -40, -41, -42, -44, -46, -48, -48, -50, -51, -53, -54, -56, -57,
-59, -60, -61, -63, -64, -66, -67, -69, -70, -71, -72, -74, -75, -76, -78, -79,
-80, -81, -82, -84, -85, -87, -88, -88, -89, -90, -91, -93, -94, -95, -96, -97,
-97, -98, -99, -100, -100, -101, -101, -102, -103, -103, -103, -104, -104, -105,
-105, -104, -104, -105, -105, -104, -105, -104, -105, -104, -103, -103, -102,
-101, -101, -101, -101, -98, -99, -97, -96, -95, -95, -94, -92, -91, -89, -88,
-87, -85, -83, -82, -80, -79, -77, -75, -73, -71, -70, -67, -65, -63, -62, -60,
-57, -56, -53, -51, -49, -47, -44, -43, -40, -38, -36, -34, -32, -30, -28, -26,
-24, -22, -20, -18, -16, -14, -12, -11, -9, -8, -5, -3, -3, -1, 1, 3, 3, 5, 7,
7, 9, 9, 12, 12, 14, 14, 15, 16, 18, 19, 19, 20, 21, 21, 22, 23, 23, 23, 23, 24,
24, 25, 25, 24, 26, 25, 25, 25, 25, 26, 25, 25, 25, 25, 25, 24, 24, 23, 23, 23,
22, 21, 22, 20, 20, 20, 18, 19, 18, 18, 17, 16, 15, 14, 13, 13, 12, 12, 10, 9,
8, 8, 7, 6, 5, 5, 4, 3, 1, 1, 0, 0, -2, -3, -3, -4, -5, -5, -7, -7, -8, -9, -10,
-9, -10, -12, -11, -12, -12, -14, -14, -15, -14, -16, -16, -16, -17, -17, -17,
-17, -17, -19, -19, -18, -20, -19, -20, -20, -21, -20, -21, -20, -21, -22, -22,
-22, -22, -21, -22, -23, -23, -23, -23, -23, -23, -23, -24, -24, -24, -24, -25,
-25, -25, -24, -25, -25, -25, -26, -25, -26, -26, -25, -26, -26, -25, -26, -26,
-26, -26, -26, -26, -26, -26, -26, -27, -27, -26, -26, -27, -26, -26, -26, -26,
-25, -26, -25, -25, -25, -24, -24, -23, -23, -22, -23, -21, -20, -20, -19, -18,
-18, -16, -17, -15, -14, -13, -12, -11, -9, -8, -7, -6, -4, -3, -1, -1, };