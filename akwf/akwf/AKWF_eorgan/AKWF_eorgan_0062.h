#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0062

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 17, 33, 47, 61, 73, 84, 94, 103,
110, 115, 117, 119, 118, 117, 115, 110, 105, 100, 93, 87, 81, 73, 68, 63, 57,
52, 49, 46, 44, 42, 41, 41, 42, 41, 43, 44, 46, 47, 47, 48, 48, 48, 48, 48, 47,
46, 44, 43, 41, 40, 39, 38, 37, 36, 37, 38, 38, 38, 41, 42, 44, 45, 47, 49, 51,
52, 53, 53, 52, 52, 50, 48, 45, 41, 38, 33, 29, 23, 20, 15, 11, 8, 5, 2, 0, -1,
-1, 0, 2, 3, 6, 10, 14, 18, 22, 26, 29, 32, 36, 38, 38, 39, 38, 36, 33, 30, 26,
21, 16, 10, 5, -1, -7, -12, -18, -21, -24, -27, -28, -28, -28, -25, -23, -20,
-15, -10, -5, 1, 7, 11, 16, 21, 24, 27, 29, 30, 30, 29, 27, 24, 20, 15, 11, 7,
1, -4, -8, -13, -17, -21, -23, -23, -24, -24, -23, -19, -17, -13, -8, -3, 2, 7,
12, 18, 22, 26, 30, 32, 34, 35, 35, 35, 33, 31, 29, 25, 22, 20, 16, 12, 9, 6, 5,
3, 2, 1, 1, 2, 3, 4, 6, 9, 11, 14, 17, 18, 21, 22, 24, 25, 25, 25, 25, 24, 22,
22, 21, 19, 18, 16, 14, 13, 13, 13, 12, 11, 11, 12, 12, 12, 13, 13, 13, 11, 10,
8, 6, 2, -2, -7, -13, -20, -27, -35, -42, -50, -58, -67, -74, -81, -85, -91,
-93, -95, -94, -93, -89, -85, -78, -70, -60, -49, -37, -24, -11, 2, 15, 29, 42,
52, 64, 73, 80, 86, 91, 94, 96, 94, 93, 89, 84, 78, 72, 64, 56, 48, 40, 31, 25,
17, 11, 6, 1, -4, -7, -10, -11, -13, -13, -14, -13, -13, -14, -13, -13, -12,
-13, -14, -14, -15, -16, -17, -19, -21, -22, -22, -24, -25, -26, -25, -25, -24,
-24, -23, -20, -17, -15, -13, -11, -7, -6, -4, -2, -2, -2, -1, -2, -4, -6, -7,
-10, -13, -17, -20, -24, -28, -29, -32, -34, -35, -35, -34, -33, -31, -29, -24,
-21, -16, -11, -6, -1, 4, 10, 13, 18, 20, 23, 24, 24, 23, 21, 19, 16, 12, 7, 3,
-3, -8, -13, -18, -22, -26, -27, -29, -30, -30, -28, -27, -23, -19, -15, -9, -4,
1, 7, 12, 16, 20, 23, 27, 28, 29, 27, 26, 24, 20, 16, 10, 5, 0, -7, -12, -18,
-24, -28, -32, -35, -38, -39, -38, -39, -37, -35, -31, -29, -25, -20, -17, -13,
-9, -6, -3, -2, 0, 1, 1, 0, -2, -5, -8, -12, -17, -22, -27, -30, -35, -38, -43,
-46, -48, -50, -52, -52, -53, -53, -51, -51, -49, -47, -45, -44, -42, -40, -39,
-38, -37, -36, -37, -38, -38, -40, -40, -42, -44, -45, -46, -47, -48, -48, -48,
-47, -47, -47, -47, -45, -43, -43, -41, -41, -40, -41, -41, -44, -47, -50, -53,
-57, -63, -69, -75, -81, -88, -94, -101, -106, -111, -114, -116, -117, -117,
-115, -112, -106, -99, -89, -80, -67, -55, -40, -26, -10, };