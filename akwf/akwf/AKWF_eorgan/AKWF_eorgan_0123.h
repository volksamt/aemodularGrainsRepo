#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0123

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 12, 23, 34, 43, 52, 60, 68, 76, 82,
86, 91, 95, 98, 100, 101, 101, 101, 101, 99, 98, 97, 96, 93, 92, 89, 88, 85, 84,
83, 82, 81, 79, 79, 77, 77, 76, 76, 75, 75, 75, 76, 75, 76, 75, 76, 76, 77, 77,
78, 80, 81, 82, 84, 86, 89, 91, 94, 97, 100, 102, 105, 108, 110, 113, 115, 117,
118, 119, 119, 119, 118, 116, 114, 112, 109, 105, 101, 96, 92, 87, 82, 77, 71,
66, 61, 56, 52, 47, 43, 40, 36, 33, 30, 27, 25, 22, 19, 17, 15, 13, 12, 9, 7, 4,
1, -1, -4, -8, -11, -12, -16, -19, -20, -23, -25, -26, -28, -29, -29, -28, -28,
-28, -26, -24, -23, -20, -16, -15, -12, -9, -6, -4, -1, 1, 3, 4, 6, 7, 8, 8, 8,
8, 8, 8, 8, 6, 6, 7, 7, 7, 6, 8, 9, 10, 11, 13, 15, 17, 18, 20, 22, 24, 26, 27,
27, 30, 30, 31, 31, 31, 31, 31, 30, 29, 29, 28, 27, 26, 26, 26, 26, 27, 29, 30,
32, 35, 37, 41, 44, 49, 53, 58, 63, 68, 72, 77, 82, 86, 91, 94, 97, 100, 103,
105, 107, 109, 109, 111, 112, 110, 111, 110, 109, 108, 106, 106, 104, 102, 100,
97, 95, 91, 88, 84, 81, 76, 71, 66, 60, 55, 49, 43, 37, 31, 25, 18, 11, 6, 0,
-4, -9, -13, -17, -20, -22, -22, -23, -23, -23, -20, -18, -16, -12, -8, -4, 1,
4, 8, 12, 14, 18, 19, 20, 21, 21, 21, 19, 17, 14, 11, 7, 1, -4, -10, -16, -21,
-28, -34, -40, -47, -52, -58, -64, -69, -74, -79, -82, -87, -90, -94, -97, -100,
-102, -104, -106, -108, -109, -110, -111, -111, -112, -112, -112, -111, -110,
-109, -108, -106, -103, -100, -97, -93, -90, -85, -80, -75, -70, -66, -61, -56,
-52, -47, -43, -39, -35, -32, -31, -29, -27, -26, -26, -26, -26, -27, -26, -28,
-29, -29, -30, -30, -30, -31, -30, -30, -29, -29, -28, -26, -25, -24, -20, -19,
-18, -16, -14, -12, -11, -10, -8, -8, -7, -6, -6, -7, -6, -7, -7, -7, -8, -8,
-8, -7, -6, -5, -4, -3, -2, 0, 2, 4, 7, 10, 12, 15, 18, 21, 22, 25, 27, 28, 29,
29, 29, 28, 27, 25, 23, 21, 20, 16, 15, 11, 8, 6, 2, -1, -3, -6, -8, -11, -12,
-15, -18, -20, -23, -25, -26, -29, -33, -35, -38, -43, -46, -49, -54, -58, -63,
-68, -74, -79, -84, -89, -95, -99, -103, -106, -110, -112, -115, -117, -118,
-118, -119, -118, -118, -116, -114, -112, -109, -106, -104, -101, -98, -96, -92,
-90, -87, -85, -83, -82, -80, -79, -78, -76, -76, -75, -74, -75, -74, -74, -75,
-74, -75, -74, -74, -76, -76, -76, -77, -78, -80, -81, -81, -84, -85, -88, -89,
-91, -93, -95, -96, -98, -98, -100, -100, -99, -99, -97, -95, -91, -88, -83,
-76, -71, -64, -57, -47, -38, -28, -17, -7, };