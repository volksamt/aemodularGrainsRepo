#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0048

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 11, 16, 19, 23, 26, 30, 35, 39,
43, 48, 52, 57, 60, 64, 68, 69, 73, 74, 77, 79, 80, 81, 82, 82, 82, 81, 81, 79,
79, 76, 75, 72, 69, 67, 66, 64, 62, 61, 61, 61, 60, 61, 62, 62, 63, 64, 66, 67,
69, 71, 73, 75, 77, 79, 81, 83, 86, 88, 91, 93, 95, 98, 100, 101, 104, 105, 107,
108, 110, 112, 112, 114, 115, 116, 117, 117, 118, 118, 119, 119, 119, 118, 117,
116, 115, 113, 112, 111, 108, 105, 103, 99, 96, 92, 88, 85, 81, 77, 72, 70, 65,
61, 57, 53, 49, 46, 43, 39, 37, 35, 34, 31, 31, 29, 28, 29, 29, 30, 31, 32, 33,
35, 37, 39, 41, 42, 44, 45, 47, 47, 49, 48, 47, 47, 47, 47, 47, 48, 47, 47, 47,
46, 44, 43, 41, 40, 38, 36, 34, 32, 28, 27, 23, 21, 19, 16, 13, 11, 8, 5, 3, 2,
1, -1, -2, -3, -4, -5, -5, -7, -7, -9, -9, -9, -9, -10, -10, -10, -9, -9, -9,
-8, -8, -7, -7, -7, -6, -5, -5, -4, -4, -4, -4, -4, -4, -4, -3, -4, -2, -3, -2,
-3, -2, -1, -1, -1, 0, 1, 1, 1, 1, 1, 2, 1, 0, 0, -1, -1, -2, -4, -4, -6, -8,
-11, -12, -14, -18, -20, -23, -26, -29, -32, -34, -36, -38, -40, -41, -43, -44,
-43, -42, -43, -42, -40, -39, -36, -34, -31, -28, -24, -22, -18, -15, -11, -9,
-6, -4, -3, -1, -1, 0, 2, 3, 6, 6, 9, 10, 12, 13, 13, 14, 15, 15, 16, 15, 15,
14, 14, 12, 11, 9, 8, 6, 5, 3, 2, -1, -2, -3, -4, -5, -6, -9, -10, -12, -14,
-16, -18, -18, -21, -22, -23, -25, -26, -27, -28, -29, -29, -31, -31, -32, -32,
-32, -33, -34, -33, -34, -33, -34, -34, -34, -35, -33, -34, -34, -34, -34, -34,
-34, -34, -34, -35, -35, -36, -35, -36, -35, -37, -37, -38, -39, -40, -42, -44,
-45, -47, -50, -52, -54, -56, -59, -61, -65, -68, -71, -73, -77, -79, -82, -85,
-87, -89, -91, -92, -94, -95, -95, -96, -95, -94, -94, -92, -90, -87, -83, -81,
-77, -73, -69, -65, -61, -57, -53, -49, -47, -44, -42, -40, -39, -37, -36, -33,
-31, -30, -29, -28, -26, -26, -24, -24, -25, -23, -24, -25, -25, -26, -27, -28,
-29, -31, -33, -35, -36, -37, -40, -42, -43, -44, -46, -48, -50, -50, -51, -52,
-54, -53, -53, -54, -54, -54, -53, -53, -53, -52, -51, -50, -50, -48, -47, -47,
-46, -44, -42, -42, -41, -40, -40, -39, -39, -39, -38, -37, -37, -37, -36, -35,
-34, -33, -33, -32, -30, -30, -30, -28, -28, -28, -27, -27, -28, -27, -28, -28,
-30, -30, -31, -33, -33, -35, -37, -39, -40, -42, -45, -47, -47, -50, -51, -53,
-54, -55, -55, -56, -56, -55, -54, -53, -51, -49, -46, -42, -39, -35, -30, -26,
-21, -17, -11, -7, -3, 0, };