#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0044

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 13, 14, 19, 10, 0, 4, 8, 12,
16, 19, 23, 26, 29, 32, 35, 38, 41, 44, 47, 50, 53, 56, 58, 62, 64, 67, 68, 70,
72, 73, 75, 77, 79, 79, 81, 82, 85, 87, 91, 93, 95, 99, 100, 103, 105, 107, 108,
110, 111, 113, 115, 115, 116, 116, 117, 118, 119, 119, 119, 119, 118, 119, 119,
119, 117, 117, 115, 98, 92, 92, 91, 90, 89, 88, 86, 86, 85, 84, 81, 81, 77, 76,
75, 72, 71, 70, 66, 66, 63, 60, 59, 56, 54, 53, 51, 47, 45, 42, 42, 23, 11, 13,
9, 8, 5, 4, 1, -1, -3, -6, -8, -10, -12, -14, -15, -18, -19, -21, -23, -24, -27,
-28, -30, -32, -34, -35, -37, -38, -39, -40, -41, -55, -67, -65, -66, -66, -67,
-65, -66, -65, -66, -65, -66, -66, -64, -64, -64, -64, -62, -62, -62, -61, -61,
-61, -59, -59, -58, -58, -57, -56, -55, -56, -55, -54, -55, -57, -58, -58, -59,
-61, -62, -62, -63, -62, -63, -62, -64, -64, -63, -63, -63, -62, -62, -61, -62,
-60, -60, -59, -58, -57, -56, -54, -53, -51, -52, -66, -71, -70, -68, -65, -65,
-63, -61, -59, -57, -55, -54, -52, -51, -48, -48, -44, -43, -41, -38, -37, -35,
-33, -31, -29, -28, -26, -23, -23, -18, -19, -12, -30, -38, -30, -30, -27, -26,
-22, -21, -18, -16, -13, -11, -10, -8, -5, -3, -1, 1, 2, 4, 6, 8, 9, 10, 11, 14,
16, 16, 18, 19, 20, 22, 6, 1, 3, 5, 7, 9, 10, 12, 14, 15, 16, 18, 20, 21, 23,
24, 24, 25, 26, 27, 26, 28, 28, 29, 30, 31, 32, 33, 33, 33, 34, 34, 34, 36, 38,
40, 43, 46, 48, 50, 53, 56, 57, 59, 61, 63, 64, 66, 68, 69, 71, 72, 73, 74, 75,
76, 79, 79, 79, 80, 81, 82, 83, 81, 67, 59, 62, 61, 62, 62, 62, 62, 63, 63, 63,
62, 63, 62, 63, 62, 61, 62, 61, 61, 62, 60, 61, 60, 59, 59, 58, 57, 57, 57, 54,
59, 37, 28, 34, 30, 33, 31, 32, 32, 32, 31, 31, 30, 30, 29, 29, 28, 27, 26, 25,
24, 24, 22, 20, 20, 19, 18, 17, 15, 14, 13, 12, 10, -7, -16, -15, -16, -17, -17,
-18, -17, -18, -19, -20, -21, -22, -21, -23, -23, -23, -24, -25, -25, -26, -27,
-28, -28, -29, -30, -30, -30, -32, -32, -34, -34, -35, -37, -41, -43, -46, -49,
-51, -53, -55, -58, -60, -62, -64, -66, -67, -68, -70, -72, -74, -75, -76, -77,
-78, -79, -80, -81, -82, -84, -84, -84, -85, -87, -104, -109, -107, -107, -106,
-106, -105, -105, -104, -103, -102, -101, -100, -100, -97, -96, -95, -93, -90,
-89, -88, -86, -83, -81, -79, -77, -74, -72, -70, -66, -65, -60, -77, -81, -74,
-72, -67, -65, -61, -58, -54, -52, -48, -44, -42, -38, -34, -32, -28, -25, -22,
-18, -16, -13, -9, -7, -3, 0, };