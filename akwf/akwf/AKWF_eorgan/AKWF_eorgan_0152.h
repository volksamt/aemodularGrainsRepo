#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0152

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 6, 9, 11, 13, 15, 17, 19, 21,
24, 26, 28, 31, 33, 35, 37, 40, 43, 45, 46, 48, 52, 54, 56, 59, 61, 63, 65, 68,
69, 72, 74, 76, 77, 80, 82, 84, 87, 89, 90, 92, 94, 95, 96, 98, 99, 101, 103,
104, 105, 106, 107, 109, 110, 111, 112, 113, 114, 115, 115, 116, 116, 117, 117,
117, 118, 119, 119, 118, 119, 119, 118, 119, 118, 119, 118, 119, 118, 117, 117,
116, 116, 115, 115, 115, 114, 113, 112, 111, 110, 109, 109, 107, 107, 105, 104,
103, 102, 101, 100, 98, 97, 97, 95, 93, 92, 91, 89, 88, 87, 84, 84, 83, 80, 79,
78, 76, 75, 73, 72, 70, 69, 68, 66, 64, 63, 61, 59, 58, 57, 54, 53, 52, 50, 49,
47, 46, 43, 43, 41, 39, 38, 37, 34, 33, 31, 30, 28, 27, 26, 24, 21, 21, 19, 18,
16, 14, 13, 11, 9, 9, 8, 5, 4, 3, 1, -1, -2, -5, -6, -6, -9, -10, -12, -13, -15,
-16, -17, -19, -20, -22, -22, -25, -26, -28, -29, -30, -32, -33, -34, -36, -37,
-39, -40, -42, -43, -44, -46, -46, -48, -49, -50, -52, -53, -54, -54, -56, -57,
-58, -59, -60, -60, -62, -62, -63, -64, -65, -66, -67, -67, -68, -69, -68, -69,
-70, -71, -70, -71, -71, -72, -72, -72, -71, -72, -71, -72, -72, -72, -72, -71,
-71, -71, -71, -70, -69, -68, -69, -68, -67, -67, -65, -65, -65, -64, -63, -61,
-61, -60, -59, -58, -56, -55, -55, -53, -51, -50, -49, -48, -47, -45, -44, -43,
-42, -40, -39, -38, -35, -34, -33, -31, -30, -28, -27, -25, -23, -23, -21, -19,
-19, -17, -16, -15, -14, -13, -10, -9, -8, -7, -6, -5, -3, -3, -2, -1, 0, 0, 2,
3, 4, 4, 4, 6, 5, 5, 6, 7, 8, 7, 8, 8, 10, 8, 9, 9, 9, 10, 9, 9, 8, 9, 8, 8, 8,
8, 7, 6, 7, 6, 6, 5, 4, 3, 3, 3, 1, 2, 0, -1, -1, -2, -2, -3, -4, -5, -6, -6,
-8, -9, -9, -11, -12, -13, -13, -14, -16, -16, -17, -19, -19, -20, -21, -23,
-23, -24, -24, -26, -26, -28, -29, -29, -30, -31, -32, -33, -33, -35, -35, -36,
-37, -38, -39, -39, -39, -40, -41, -41, -42, -42, -43, -44, -44, -46, -45, -47,
-47, -47, -47, -48, -49, -49, -50, -49, -51, -51, -50, -51, -52, -52, -52, -53,
-53, -53, -54, -54, -54, -55, -55, -54, -55, -55, -55, -56, -55, -55, -56, -56,
-57, -57, -56, -56, -57, -56, -56, -56, -57, -56, -56, -56, -56, -57, -56, -55,
-55, -57, -57, -55, -55, -55, -55, -55, -54, -54, -53, -54, -53, -53, -52, -52,
-50, -50, -50, -50, -49, -48, -48, -47, -47, -45, -45, -44, -43, -43, -42, -39,
-39, -38, -36, -36, -35, -34, -32, -31, -30, -28, -27, -26, -24, -23, -22, -20,
-17, -16, -14, -13, -11, -9, -7, -5, -3, -1, };