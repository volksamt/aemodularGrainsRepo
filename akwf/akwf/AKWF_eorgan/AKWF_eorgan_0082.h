#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0082

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 11, 18, 26, 34, 41, 49, 56, 62, 68,
74, 79, 83, 88, 92, 95, 99, 101, 103, 105, 107, 109, 110, 110, 113, 112, 114,
114, 115, 115, 116, 117, 117, 117, 118, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 117, 116, 116, 115, 115, 114, 113, 112, 112, 110, 109, 108, 108,
106, 105, 103, 102, 100, 99, 98, 95, 94, 92, 89, 87, 86, 82, 81, 78, 75, 73, 70,
68, 66, 63, 61, 59, 58, 57, 55, 53, 52, 52, 50, 50, 49, 49, 48, 49, 50, 49, 49,
50, 51, 51, 51, 52, 51, 52, 51, 51, 51, 51, 51, 52, 51, 51, 51, 52, 51, 52, 52,
53, 53, 55, 54, 56, 57, 58, 60, 61, 64, 66, 67, 69, 71, 71, 73, 75, 77, 78, 78,
79, 81, 80, 82, 82, 82, 83, 83, 83, 84, 84, 85, 86, 86, 87, 87, 89, 89, 91, 91,
92, 93, 94, 95, 96, 97, 97, 97, 97, 98, 97, 98, 96, 96, 95, 94, 92, 91, 89, 87,
86, 83, 81, 78, 76, 74, 71, 70, 67, 65, 63, 62, 59, 57, 55, 53, 51, 49, 48, 46,
44, 42, 40, 37, 36, 34, 32, 30, 28, 26, 25, 23, 21, 18, 17, 14, 13, 11, 8, 7, 5,
3, 1, -1, -3, -5, -7, -10, -11, -14, -16, -17, -20, -22, -24, -26, -28, -29,
-31, -33, -34, -34, -36, -36, -36, -35, -35, -33, -32, -30, -28, -25, -22, -19,
-16, -12, -8, -4, 0, 4, 8, 12, 16, 20, 21, 25, 28, 30, 32, 33, 34, 35, 35, 34,
34, 33, 32, 31, 30, 28, 26, 24, 22, 20, 18, 16, 13, 11, 10, 6, 5, 3, 0, 0, -3,
-4, -7, -10, -12, -13, -15, -17, -19, -22, -22, -25, -28, -29, -31, -33, -35,
-36, -39, -41, -42, -44, -46, -49, -50, -52, -54, -55, -57, -59, -61, -63, -66,
-68, -69, -72, -74, -76, -78, -80, -83, -85, -87, -88, -91, -92, -94, -95, -96,
-97, -98, -98, -99, -99, -97, -99, -97, -96, -96, -95, -95, -93, -93, -91, -90,
-89, -88, -88, -87, -86, -86, -85, -84, -85, -84, -83, -83, -82, -82, -82, -81,
-81, -79, -79, -77, -76, -75, -73, -72, -69, -68, -66, -65, -62, -60, -60, -58,
-56, -56, -55, -54, -54, -53, -52, -51, -52, -52, -52, -51, -51, -50, -52, -51,
-51, -51, -52, -51, -52, -50, -51, -51, -50, -50, -50, -49, -49, -49, -49, -49,
-50, -50, -51, -51, -53, -54, -54, -57, -58, -60, -62, -64, -66, -69, -71, -73,
-77, -80, -81, -84, -86, -88, -89, -92, -95, -96, -98, -99, -101, -102, -103,
-105, -107, -107, -109, -110, -110, -111, -113, -112, -113, -113, -116, -116,
-116, -116, -117, -117, -118, -117, -118, -117, -118, -118, -117, -116, -117,
-117, -115, -115, -115, -114, -114, -113, -113, -111, -110, -110, -108, -107,
-105, -104, -101, -100, -97, -93, -91, -87, -83, -79, -74, -69, -63, -57, -50,
-43, -36, -28, -20, -12, -5, };