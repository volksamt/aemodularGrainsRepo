#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0149

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 11, 15, 19, 22, 25, 27, 31,
33, 36, 38, 40, 42, 43, 45, 47, 48, 49, 50, 50, 50, 51, 50, 51, 51, 50, 49, 48,
48, 47, 45, 43, 42, 40, 38, 37, 36, 33, 31, 31, 28, 26, 25, 24, 21, 20, 19, 17,
17, 14, 14, 13, 14, 13, 12, 13, 13, 12, 14, 14, 16, 17, 18, 19, 22, 23, 24, 27,
29, 32, 35, 37, 40, 43, 45, 49, 52, 55, 59, 62, 66, 69, 73, 76, 80, 82, 86, 88,
91, 94, 97, 99, 102, 104, 105, 108, 109, 111, 112, 112, 113, 114, 115, 115, 114,
114, 114, 114, 113, 112, 111, 109, 108, 107, 104, 103, 100, 99, 96, 94, 92, 89,
86, 84, 81, 78, 75, 72, 71, 68, 66, 63, 62, 59, 57, 55, 53, 52, 50, 50, 49, 48,
46, 46, 46, 46, 46, 46, 46, 47, 48, 50, 50, 51, 53, 54, 57, 59, 61, 62, 64, 66,
68, 71, 73, 76, 78, 81, 82, 84, 86, 88, 91, 93, 94, 95, 97, 99, 99, 101, 101,
102, 102, 102, 102, 102, 101, 100, 100, 100, 99, 96, 95, 93, 92, 90, 87, 85, 83,
80, 77, 73, 71, 69, 65, 62, 59, 54, 51, 47, 44, 40, 37, 34, 30, 27, 23, 21, 17,
15, 13, 9, 7, 5, 3, 2, 0, -2, -3, -5, -6, -7, -7, -7, -7, -8, -7, -7, -7, -6,
-5, -4, -3, -2, -1, 0, 2, 3, 6, 7, 9, 11, 13, 14, 15, 17, 18, 20, 21, 23, 23,
25, 26, 26, 27, 27, 27, 28, 27, 27, 27, 25, 25, 24, 22, 20, 19, 17, 15, 14, 12,
9, 6, 3, 1, -3, -6, -9, -12, -16, -20, -23, -27, -30, -33, -38, -42, -45, -49,
-52, -55, -59, -62, -65, -68, -71, -74, -75, -78, -81, -82, -84, -86, -86, -88,
-89, -90, -90, -91, -90, -90, -89, -89, -89, -88, -87, -85, -85, -83, -81, -80,
-78, -75, -73, -71, -70, -67, -65, -64, -61, -58, -57, -54, -53, -50, -49, -47,
-46, -45, -43, -42, -42, -41, -41, -40, -39, -41, -41, -40, -41, -42, -43, -44,
-45, -46, -49, -50, -52, -55, -57, -60, -62, -64, -67, -69, -73, -76, -77, -81,
-84, -87, -90, -92, -95, -98, -100, -102, -105, -107, -109, -111, -112, -114,
-116, -116, -118, -118, -118, -119, -119, -119, -119, -119, -118, -116, -116,
-115, -113, -112, -110, -108, -106, -103, -102, -98, -96, -94, -90, -88, -84,
-81, -78, -75, -72, -69, -66, -63, -61, -58, -54, -51, -49, -47, -44, -42, -40,
-37, -36, -34, -33, -31, -30, -31, -29, -29, -28, -29, -28, -29, -29, -30, -30,
-31, -33, -33, -34, -36, -38, -39, -41, -43, -44, -46, -47, -50, -52, -53, -55,
-57, -59, -60, -62, -63, -65, -65, -66, -67, -68, -69, -69, -69, -69, -69, -68,
-68, -67, -66, -64, -64, -63, -60, -58, -57, -55, -52, -50, -47, -44, -40, -38,
-34, -31, -27, -24, -19, -16, -13, -9, -6, -2, };