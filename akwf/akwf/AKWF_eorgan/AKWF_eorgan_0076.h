#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0076

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 12, 23, 34, 43, 53, 62, 70, 79, 85,
92, 98, 103, 107, 111, 115, 116, 117, 119, 119, 118, 117, 115, 113, 110, 107,
101, 98, 93, 89, 84, 79, 74, 68, 64, 60, 56, 52, 48, 46, 43, 40, 39, 36, 35, 34,
33, 33, 34, 36, 36, 38, 40, 42, 43, 45, 48, 49, 51, 54, 56, 56, 58, 59, 60, 60,
61, 61, 61, 61, 60, 58, 57, 55, 52, 50, 47, 44, 41, 38, 35, 32, 28, 27, 23, 22,
19, 17, 16, 13, 12, 10, 8, 7, 7, 6, 6, 6, 4, 5, 5, 6, 8, 8, 10, 11, 12, 14, 14,
13, 14, 15, 17, 17, 16, 16, 16, 15, 15, 13, 13, 12, 10, 8, 7, 5, 4, 1, 0, -2,
-4, -6, -7, -8, -10, -11, -11, -12, -12, -12, -11, -11, -11, -10, -9, -9, -6,
-5, -3, -2, 0, 3, 6, 8, 10, 12, 15, 16, 17, 19, 20, 21, 20, 22, 22, 22, 23, 22,
22, 22, 22, 22, 21, 20, 17, 17, 16, 15, 13, 11, 9, 8, 8, 6, 6, 5, 6, 4, 5, 7, 7,
9, 10, 12, 14, 17, 18, 21, 23, 25, 27, 30, 32, 35, 36, 38, 40, 40, 41, 41, 42,
40, 39, 38, 35, 32, 29, 25, 21, 17, 12, 6, 2, -5, -10, -16, -23, -29, -36, -41,
-46, -51, -57, -62, -66, -69, -72, -74, -76, -78, -78, -77, -76, -74, -72, -69,
-64, -60, -56, -50, -44, -37, -31, -23, -14, -7, 1, 10, 18, 25, 33, 40, 47, 53,
57, 63, 67, 70, 73, 75, 77, 77, 78, 77, 76, 74, 71, 67, 64, 60, 55, 50, 44, 38,
32, 26, 20, 14, 8, 1, -4, -9, -14, -19, -23, -26, -31, -34, -36, -39, -39, -41,
-42, -42, -41, -41, -39, -37, -36, -33, -32, -29, -27, -26, -23, -20, -19, -16,
-14, -13, -10, -9, -7, -6, -6, -5, -4, -5, -6, -6, -8, -9, -9, -11, -12, -14,
-16, -18, -18, -20, -21, -22, -22, -23, -22, -22, -23, -23, -23, -22, -21, -21,
-20, -19, -17, -16, -14, -12, -9, -7, -5, -3, 0, 1, 4, 5, 6, 9, 10, 10, 11, 12,
12, 12, 11, 11, 10, 10, 9, 8, 7, 5, 3, 2, -1, -2, -4, -7, -8, -10, -11, -12,
-12, -14, -15, -15, -16, -16, -16, -16, -16, -16, -15, -14, -14, -13, -13, -10,
-9, -10, -8, -7, -6, -6, -5, -7, -5, -7, -9, -9, -10, -12, -13, -15, -16, -18,
-20, -23, -26, -28, -31, -33, -36, -39, -42, -45, -47, -51, -54, -55, -57, -58,
-61, -61, -61, -62, -61, -60, -60, -59, -57, -56, -54, -53, -51, -49, -47, -45,
-44, -41, -39, -38, -36, -35, -35, -34, -35, -35, -36, -36, -39, -41, -44, -47,
-49, -53, -58, -61, -67, -70, -75, -80, -85, -89, -93, -98, -103, -106, -110,
-112, -114, -117, -118, -118, -117, -115, -113, -112, -109, -104, -100, -93,
-87, -81, -74, -66, -57, -49, -38, -28, -18, -6, };