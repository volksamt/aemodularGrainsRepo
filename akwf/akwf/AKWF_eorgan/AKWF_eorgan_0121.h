#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0121

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 9, 17, 24, 30, 37, 43, 49, 55, 60,
65, 71, 75, 79, 83, 88, 91, 94, 98, 100, 103, 106, 107, 110, 111, 113, 115, 116,
117, 118, 118, 119, 120, 118, 118, 118, 118, 117, 116, 116, 115, 113, 112, 110,
108, 106, 104, 102, 99, 96, 93, 91, 89, 84, 82, 78, 75, 70, 66, 62, 57, 53, 50,
44, 40, 34, 30, 26, 21, 17, 13, 9, 5, 2, -1, -5, -7, -10, -13, -15, -18, -19,
-21, -22, -25, -26, -27, -29, -30, -30, -31, -33, -33, -34, -34, -35, -35, -36,
-36, -37, -35, -36, -35, -36, -34, -35, -34, -33, -33, -31, -31, -30, -28, -27,
-26, -25, -23, -21, -19, -17, -14, -12, -10, -8, -5, -1, 2, 5, 8, 12, 15, 19,
22, 25, 27, 30, 32, 36, 37, 40, 42, 43, 45, 46, 49, 51, 52, 54, 56, 56, 57, 59,
60, 61, 62, 62, 63, 64, 65, 66, 67, 67, 68, 68, 68, 69, 70, 69, 69, 69, 69, 68,
68, 67, 66, 66, 65, 63, 62, 61, 58, 57, 55, 53, 49, 47, 44, 40, 36, 33, 29, 26,
20, 16, 12, 7, 3, -1, -5, -10, -13, -18, -21, -24, -27, -32, -35, -37, -41, -44,
-46, -49, -51, -53, -56, -59, -60, -63, -64, -65, -66, -69, -69, -70, -72, -72,
-72, -72, -73, -73, -73, -72, -72, -71, -70, -69, -68, -66, -65, -63, -60, -59,
-56, -53, -50, -47, -44, -40, -37, -32, -29, -24, -20, -14, -9, -3, 2, 8, 12,
18, 22, 26, 30, 35, 39, 43, 47, 50, 52, 55, 57, 60, 62, 64, 65, 68, 68, 70, 70,
72, 72, 73, 73, 73, 73, 72, 72, 71, 70, 69, 68, 67, 66, 65, 63, 62, 59, 58, 54,
53, 50, 47, 44, 41, 38, 36, 33, 30, 26, 23, 18, 15, 11, 7, 3, -2, -5, -10, -15,
-19, -24, -29, -32, -36, -40, -43, -46, -49, -51, -54, -57, -59, -60, -63, -64,
-64, -66, -68, -67, -68, -69, -69, -69, -69, -69, -69, -69, -69, -69, -68, -68,
-67, -66, -66, -66, -64, -63, -63, -61, -60, -59, -58, -57, -56, -54, -53, -51,
-50, -48, -47, -45, -42, -40, -38, -36, -33, -31, -29, -25, -22, -19, -16, -13,
-10, -7, -4, 0, 3, 5, 8, 11, 14, 16, 18, 21, 22, 24, 25, 26, 29, 29, 30, 31, 32,
33, 33, 35, 34, 35, 35, 35, 35, 36, 35, 36, 36, 35, 35, 34, 34, 32, 32, 31, 30,
29, 28, 26, 26, 24, 22, 20, 18, 16, 13, 11, 8, 5, 2, -1, -4, -8, -11, -15, -20,
-24, -28, -33, -38, -43, -47, -52, -56, -61, -65, -69, -73, -76, -80, -83, -86,
-89, -92, -95, -98, -101, -102, -104, -108, -108, -110, -112, -113, -115, -115,
-116, -118, -118, -118, -118, -118, -118, -118, -117, -116, -116, -115, -113,
-112, -110, -108, -105, -104, -101, -98, -95, -92, -88, -85, -80, -75, -72, -67,
-62, -56, -51, -45, -39, -32, -26, -19, -11, -4, };