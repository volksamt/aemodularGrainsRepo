#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0096

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 13, 16, 19, 23, 26, 30, 33,
35, 39, 42, 45, 48, 50, 53, 56, 58, 60, 63, 65, 67, 69, 71, 73, 74, 76, 78, 80,
81, 82, 84, 85, 85, 86, 87, 88, 88, 90, 91, 91, 91, 91, 92, 92, 92, 94, 93, 94,
94, 94, 94, 94, 94, 94, 94, 94, 93, 94, 93, 94, 93, 93, 93, 92, 93, 92, 91, 91,
91, 90, 89, 89, 88, 89, 88, 87, 87, 86, 85, 84, 84, 84, 83, 82, 82, 81, 80, 80,
79, 79, 78, 77, 77, 78, 77, 77, 76, 77, 76, 76, 76, 76, 77, 76, 76, 78, 78, 79,
78, 79, 80, 80, 81, 81, 83, 84, 85, 86, 86, 89, 89, 91, 92, 93, 95, 97, 97, 98,
100, 102, 103, 104, 105, 106, 108, 108, 110, 111, 111, 112, 114, 114, 115, 116,
116, 117, 117, 119, 118, 119, 119, 118, 119, 118, 119, 119, 118, 118, 118, 117,
117, 116, 116, 114, 114, 114, 113, 113, 112, 110, 110, 109, 108, 107, 106, 105,
104, 103, 103, 101, 100, 98, 97, 96, 94, 93, 93, 91, 89, 88, 88, 86, 85, 82, 81,
80, 78, 76, 76, 74, 72, 70, 68, 67, 65, 64, 62, 61, 59, 56, 55, 54, 52, 50, 48,
46, 45, 43, 40, 40, 37, 36, 34, 32, 30, 30, 27, 26, 24, 23, 21, 20, 19, 17, 16,
15, 14, 13, 12, 10, 9, 8, 8, 6, 5, 5, 5, 3, 3, 2, 2, 1, 0, -1, -1, -2, -4, -4,
-4, -4, -5, -6, -7, -7, -8, -9, -10, -11, -13, -13, -14, -16, -16, -18, -19,
-21, -21, -23, -23, -25, -28, -28, -31, -31, -33, -34, -37, -38, -40, -42, -44,
-45, -48, -49, -51, -52, -54, -55, -57, -59, -61, -63, -65, -67, -68, -70, -71,
-73, -74, -77, -78, -79, -80, -82, -83, -85, -87, -88, -90, -90, -92, -94, -94,
-96, -97, -98, -99, -101, -101, -102, -104, -104, -106, -107, -108, -109, -110,
-110, -112, -112, -113, -113, -114, -115, -115, -116, -116, -118, -118, -117,
-118, -119, -119, -119, -119, -119, -120, -119, -119, -118, -118, -117, -118,
-117, -117, -116, -115, -114, -113, -112, -112, -110, -110, -108, -107, -106,
-104, -103, -102, -100, -100, -97, -96, -96, -94, -92, -91, -90, -89, -87, -86,
-85, -84, -84, -82, -81, -80, -79, -78, -78, -78, -78, -77, -76, -76, -76, -75,
-76, -75, -76, -75, -76, -77, -77, -76, -77, -77, -77, -79, -79, -79, -80, -80,
-81, -81, -82, -82, -82, -85, -85, -85, -86, -86, -87, -87, -88, -88, -88, -89,
-89, -90, -91, -91, -91, -92, -91, -92, -92, -92, -93, -93, -94, -92, -92, -94,
-93, -93, -93, -93, -93, -93, -93, -91, -92, -91, -91, -91, -90, -89, -90, -88,
-88, -87, -85, -86, -84, -83, -82, -81, -79, -79, -77, -75, -73, -71, -70, -67,
-66, -64, -61, -59, -57, -55, -52, -50, -47, -43, -40, -39, -35, -32, -29, -25,
-22, -19, -15, -12, -8, -4, -1, };