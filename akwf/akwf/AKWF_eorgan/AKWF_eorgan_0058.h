#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0058

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 14, 20, 27, 32, 38, 45, 50, 56,
61, 66, 71, 76, 80, 85, 88, 93, 96, 101, 103, 105, 109, 111, 112, 114, 116, 117,
118, 119, 118, 119, 119, 118, 117, 117, 115, 114, 113, 112, 109, 107, 104, 103,
100, 97, 94, 91, 88, 85, 83, 79, 76, 73, 71, 68, 65, 62, 60, 57, 54, 51, 49, 47,
44, 43, 41, 39, 37, 36, 34, 32, 32, 30, 30, 29, 29, 28, 28, 27, 27, 27, 28, 27,
27, 27, 27, 28, 28, 28, 29, 29, 30, 29, 30, 29, 30, 30, 30, 30, 31, 30, 30, 30,
29, 29, 28, 28, 27, 26, 25, 24, 23, 22, 21, 20, 19, 17, 15, 14, 13, 12, 9, 8, 6,
4, 3, 2, -1, -1, -3, -5, -7, -7, -8, -10, -11, -11, -13, -13, -13, -14, -14,
-15, -15, -14, -15, -14, -13, -12, -11, -10, -9, -8, -7, -5, -4, -1, 0, 3, 4, 7,
8, 10, 12, 15, 17, 20, 23, 25, 26, 29, 30, 33, 34, 36, 37, 40, 41, 43, 44, 44,
46, 47, 47, 47, 48, 48, 47, 46, 46, 45, 44, 43, 42, 40, 39, 37, 35, 33, 31, 28,
26, 23, 20, 17, 14, 11, 8, 4, 2, -1, -5, -7, -10, -14, -16, -18, -22, -25, -27,
-29, -32, -34, -36, -37, -39, -40, -42, -43, -43, -45, -44, -44, -45, -45, -44,
-44, -43, -41, -41, -39, -37, -35, -33, -30, -28, -26, -24, -21, -17, -14, -12,
-9, -5, -2, 1, 4, 8, 10, 13, 15, 19, 22, 25, 27, 29, 31, 34, 36, 38, 39, 40, 42,
42, 43, 45, 44, 44, 45, 45, 44, 43, 43, 40, 40, 38, 36, 35, 33, 30, 27, 26, 22,
20, 17, 14, 11, 8, 5, 2, 0, -3, -7, -9, -14, -17, -20, -21, -25, -27, -30, -33,
-34, -37, -39, -40, -42, -43, -44, -46, -46, -47, -48, -48, -48, -48, -48, -47,
-46, -46, -45, -44, -42, -40, -40, -37, -36, -35, -32, -30, -28, -26, -23, -21,
-19, -17, -14, -12, -10, -7, -6, -3, -1, 1, 1, 4, 6, 6, 8, 10, 10, 11, 12, 13,
14, 14, 14, 14, 14, 14, 14, 13, 13, 12, 11, 10, 9, 8, 6, 5, 3, 3, 1, -1, -2, -5,
-5, -7, -8, -10, -12, -13, -15, -16, -18, -19, -21, -21, -24, -25, -25, -27,
-28, -27, -29, -30, -30, -30, -30, -30, -30, -31, -30, -31, -31, -31, -31, -30,
-30, -30, -29, -29, -29, -28, -28, -27, -28, -27, -27, -27, -28, -27, -28, -28,
-28, -30, -30, -30, -32, -33, -34, -35, -37, -38, -40, -42, -43, -46, -48, -50,
-53, -55, -58, -60, -63, -66, -69, -72, -74, -78, -81, -83, -86, -90, -92, -95,
-98, -100, -103, -104, -106, -109, -110, -113, -115, -115, -116, -116, -117,
-118, -118, -118, -117, -116, -116, -115, -113, -111, -109, -106, -103, -100,
-97, -93, -90, -86, -81, -77, -72, -68, -63, -56, -52, -45, -40, -35, -28, -22,
-16, -10, -3, };