#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0086

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 9, 13, 15, 18, 22, 25, 28, 32,
35, 38, 40, 43, 46, 49, 52, 55, 58, 60, 63, 65, 68, 71, 73, 76, 77, 79, 81, 84,
85, 87, 89, 92, 94, 95, 97, 99, 100, 101, 103, 104, 105, 107, 108, 110, 110,
111, 111, 113, 114, 115, 116, 116, 116, 116, 117, 118, 117, 118, 118, 118, 118,
119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 118, 117, 117, 117, 117,
116, 116, 116, 115, 115, 115, 113, 113, 113, 113, 112, 112, 111, 111, 110, 110,
110, 109, 109, 107, 107, 107, 106, 106, 106, 105, 105, 104, 103, 104, 103, 102,
101, 101, 101, 101, 100, 100, 99, 99, 99, 97, 97, 97, 96, 95, 95, 95, 95, 94,
94, 93, 92, 92, 91, 92, 91, 91, 90, 89, 89, 89, 88, 87, 87, 86, 86, 86, 86, 84,
84, 83, 82, 82, 81, 81, 80, 79, 78, 78, 77, 77, 76, 74, 74, 74, 72, 71, 71, 69,
68, 67, 67, 66, 65, 64, 64, 63, 62, 60, 59, 59, 58, 56, 54, 53, 52, 52, 51, 49,
49, 48, 46, 45, 43, 43, 42, 40, 39, 39, 37, 36, 35, 34, 33, 32, 31, 30, 29, 28,
27, 26, 25, 23, 23, 22, 20, 21, 20, 18, 18, 17, 16, 16, 15, 14, 13, 13, 13, 11,
12, 10, 10, 9, 9, 8, 7, 7, 6, 6, 5, 5, 5, 4, 3, 4, 3, 3, 2, 3, 1, 1, 1, 0, 1,
-1, -1, 0, -1, -1, -3, -2, -3, -3, -3, -4, -4, -4, -6, -5, -5, -6, -7, -7, -7,
-8, -8, -9, -9, -10, -11, -11, -11, -13, -13, -13, -14, -14, -15, -16, -17, -18,
-19, -19, -19, -21, -21, -22, -22, -24, -25, -26, -26, -28, -28, -29, -30, -31,
-33, -33, -34, -36, -36, -38, -39, -40, -41, -42, -43, -44, -45, -47, -47, -49,
-49, -51, -52, -53, -54, -55, -57, -58, -59, -59, -61, -62, -63, -63, -65, -66,
-67, -68, -68, -69, -71, -71, -72, -73, -74, -75, -76, -77, -77, -77, -78, -79,
-80, -81, -81, -82, -82, -83, -84, -84, -85, -85, -86, -87, -87, -87, -88, -89,
-89, -89, -90, -90, -91, -91, -92, -92, -93, -93, -93, -94, -94, -95, -96, -96,
-96, -97, -97, -97, -97, -97, -99, -99, -99, -100, -100, -101, -102, -102, -101,
-102, -103, -103, -104, -105, -104, -105, -106, -106, -107, -107, -107, -108,
-109, -109, -108, -110, -110, -111, -111, -112, -111, -112, -112, -113, -114,
-114, -115, -115, -115, -115, -116, -116, -116, -117, -117, -117, -117, -118,
-118, -118, -118, -117, -118, -118, -118, -118, -118, -117, -118, -117, -117,
-117, -116, -116, -114, -115, -114, -114, -113, -112, -111, -110, -109, -108,
-107, -106, -105, -103, -101, -101, -98, -97, -96, -94, -92, -90, -89, -87, -84,
-83, -81, -79, -77, -75, -71, -69, -67, -65, -61, -58, -56, -53, -50, -48, -45,
-43, -39, -36, -32, -29, -27, -23, -21, -17, -13, -10, -7, -4, -2, };