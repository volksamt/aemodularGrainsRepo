#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0093

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 11, 15, 17, 21, 23, 26, 30,
33, 35, 39, 41, 44, 46, 49, 51, 54, 57, 60, 61, 65, 67, 69, 71, 74, 76, 78, 80,
83, 84, 86, 89, 90, 92, 94, 95, 97, 98, 100, 101, 103, 104, 105, 107, 108, 108,
109, 111, 111, 112, 113, 114, 114, 116, 115, 117, 117, 118, 118, 118, 118, 118,
119, 118, 119, 120, 119, 119, 118, 119, 119, 118, 118, 118, 118, 118, 116, 117,
117, 116, 115, 113, 114, 113, 113, 111, 111, 110, 109, 109, 108, 107, 106, 104,
104, 104, 102, 101, 101, 100, 97, 97, 96, 96, 95, 93, 92, 91, 89, 89, 87, 86,
85, 84, 83, 82, 79, 80, 77, 76, 75, 74, 72, 72, 70, 69, 68, 67, 66, 64, 62, 61,
60, 60, 58, 57, 56, 54, 53, 53, 51, 50, 49, 47, 48, 45, 46, 44, 44, 43, 42, 41,
40, 38, 38, 37, 36, 36, 35, 34, 33, 31, 32, 31, 30, 29, 28, 28, 27, 27, 26, 25,
24, 23, 23, 23, 21, 20, 21, 20, 19, 19, 18, 18, 17, 17, 16, 16, 15, 14, 14, 13,
13, 12, 12, 11, 11, 10, 9, 10, 9, 9, 8, 8, 7, 7, 7, 7, 6, 5, 5, 5, 5, 4, 4, 3,
4, 3, 3, 2, 2, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, -1, 0, 0, 1, -1, 0, 0, 0, -1,
-1, 0, 0, -1, -1, -1, -1, -1, 0, 0, 0, 0, -1, 0, -1, -1, -1, 0, 0, 0, -1, -1, 0,
0, 1, 0, 0, 0, 0, 0, -1, -1, -1, -1, -2, -1, -1, -2, -1, -1, -2, -2, -2, -2, -2,
-2, -3, -2, -3, -3, -3, -4, -5, -5, -5, -5, -6, -6, -6, -7, -8, -7, -7, -9, -8,
-10, -10, -10, -10, -12, -12, -12, -13, -12, -14, -14, -15, -15, -16, -16, -17,
-17, -18, -18, -19, -20, -20, -20, -20, -22, -22, -22, -23, -24, -24, -26, -26,
-27, -28, -28, -29, -29, -31, -31, -32, -33, -33, -34, -34, -36, -37, -37, -39,
-40, -40, -40, -41, -43, -44, -44, -45, -47, -48, -48, -50, -51, -51, -53, -55,
-55, -56, -57, -57, -58, -60, -61, -62, -64, -65, -66, -67, -69, -71, -72, -72,
-74, -75, -76, -78, -78, -80, -82, -82, -84, -86, -86, -87, -88, -90, -91, -91,
-93, -94, -96, -97, -98, -98, -99, -101, -101, -102, -103, -103, -105, -106,
-106, -108, -108, -108, -110, -110, -111, -111, -113, -114, -114, -114, -115,
-115, -116, -117, -117, -117, -118, -118, -118, -118, -118, -118, -119, -118,
-118, -118, -118, -118, -118, -118, -117, -117, -117, -117, -116, -115, -115,
-114, -113, -112, -111, -111, -110, -108, -108, -107, -105, -104, -103, -102,
-100, -99, -98, -95, -94, -92, -91, -89, -87, -85, -84, -81, -80, -78, -75, -73,
-71, -69, -66, -63, -61, -59, -56, -54, -51, -48, -46, -43, -39, -37, -34, -31,
-28, -26, -22, -20, -16, -14, -10, -7, -4, -1, };