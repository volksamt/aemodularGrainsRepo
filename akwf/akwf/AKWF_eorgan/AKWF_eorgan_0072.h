#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0072

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 13, 16, 21, 24, 27, 31, 35,
38, 41, 44, 48, 50, 54, 57, 60, 63, 66, 68, 72, 75, 78, 80, 82, 85, 87, 89, 91,
93, 95, 97, 99, 101, 103, 104, 106, 107, 109, 110, 111, 113, 114, 114, 116, 116,
117, 117, 118, 118, 119, 119, 120, 119, 119, 119, 119, 118, 118, 117, 117, 117,
116, 115, 114, 114, 112, 112, 110, 109, 108, 105, 105, 103, 102, 100, 98, 96,
95, 93, 91, 88, 86, 85, 82, 81, 79, 76, 74, 71, 70, 67, 65, 62, 60, 58, 56, 54,
51, 49, 48, 45, 42, 41, 38, 36, 35, 33, 30, 29, 27, 24, 24, 21, 19, 18, 16, 14,
12, 11, 9, 8, 6, 5, 3, 2, 0, -1, -1, -3, -3, -6, -7, -7, -7, -9, -9, -10, -12,
-11, -12, -12, -12, -12, -13, -13, -14, -13, -14, -13, -13, -13, -13, -12, -12,
-11, -11, -11, -10, -9, -8, -7, -7, -6, -6, -5, -3, -3, -2, -1, 1, 2, 3, 3, 5,
5, 7, 9, 9, 10, 11, 12, 13, 14, 15, 17, 16, 17, 19, 20, 21, 21, 22, 23, 23, 25,
25, 26, 26, 27, 27, 27, 28, 28, 28, 30, 29, 29, 29, 30, 30, 30, 30, 30, 30, 30,
30, 30, 30, 30, 30, 28, 29, 28, 28, 27, 26, 26, 25, 26, 25, 24, 23, 22, 22, 21,
20, 18, 18, 18, 17, 15, 14, 13, 12, 11, 10, 9, 9, 7, 6, 4, 3, 2, 1, 0, -2, -3,
-4, -6, -7, -7, -9, -10, -12, -12, -13, -15, -16, -17, -17, -19, -19, -20, -21,
-22, -22, -23, -24, -25, -25, -27, -26, -28, -27, -29, -28, -29, -28, -29, -30,
-30, -30, -30, -30, -31, -31, -30, -30, -30, -30, -30, -30, -30, -29, -29, -29,
-29, -28, -27, -27, -27, -25, -25, -24, -24, -23, -23, -22, -20, -20, -20, -18,
-18, -16, -16, -15, -14, -13, -12, -12, -9, -9, -8, -7, -6, -4, -4, -2, -2, 0,
1, 2, 3, 4, 5, 6, 7, 7, 8, 9, 9, 10, 11, 11, 11, 12, 12, 12, 13, 13, 12, 13, 12,
13, 12, 12, 12, 12, 12, 11, 10, 9, 8, 9, 8, 7, 6, 5, 4, 3, 2, 0, 0, -1, -3, -5,
-6, -8, -9, -11, -13, -13, -15, -17, -18, -20, -23, -25, -26, -29, -30, -33,
-35, -36, -38, -40, -42, -45, -47, -49, -51, -52, -56, -58, -59, -62, -64, -66,
-68, -71, -73, -76, -77, -80, -82, -84, -85, -88, -90, -91, -93, -96, -97, -99,
-101, -103, -104, -105, -106, -109, -109, -110, -112, -113, -114, -115, -115,
-116, -116, -117, -117, -118, -117, -118, -118, -118, -118, -119, -118, -118,
-117, -117, -116, -116, -115, -114, -113, -113, -111, -110, -108, -107, -105,
-103, -103, -101, -98, -98, -95, -93, -91, -90, -86, -84, -82, -80, -77, -74,
-71, -69, -66, -63, -60, -56, -54, -50, -47, -44, -40, -37, -34, -30, -27, -24,
-20, -17, -13, -9, -5, -1, };