#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0092

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 11, 14, 18, 23, 26, 30, 34, 39,
42, 45, 49, 52, 55, 60, 62, 65, 69, 72, 76, 78, 81, 83, 86, 89, 91, 93, 95, 98,
99, 100, 103, 104, 106, 107, 109, 111, 111, 112, 113, 114, 115, 116, 116, 117,
117, 118, 118, 118, 118, 120, 118, 119, 118, 119, 119, 119, 119, 119, 118, 118,
118, 118, 117, 118, 117, 117, 116, 116, 116, 116, 115, 114, 114, 115, 114, 114,
113, 112, 112, 112, 112, 111, 111, 111, 110, 110, 109, 109, 108, 108, 108, 107,
107, 107, 107, 106, 106, 105, 104, 104, 103, 103, 103, 101, 101, 101, 101, 100,
99, 99, 99, 97, 97, 96, 96, 95, 94, 94, 93, 93, 92, 92, 91, 91, 90, 90, 89, 88,
88, 86, 87, 85, 86, 86, 85, 84, 83, 84, 83, 82, 83, 81, 81, 81, 81, 81, 80, 81,
81, 81, 80, 81, 81, 80, 80, 80, 80, 80, 80, 80, 80, 81, 81, 81, 80, 80, 81, 80,
80, 81, 80, 79, 79, 79, 79, 79, 78, 79, 78, 77, 77, 77, 75, 74, 73, 72, 72, 72,
71, 70, 68, 67, 67, 66, 65, 63, 62, 61, 58, 58, 56, 55, 53, 52, 50, 49, 47, 46,
44, 43, 41, 39, 39, 37, 35, 33, 32, 30, 29, 28, 26, 24, 24, 22, 21, 19, 19, 17,
16, 15, 14, 13, 13, 11, 10, 9, 8, 8, 7, 6, 5, 4, 5, 3, 4, 3, 2, 1, 2, 1, 1, 0,
0, 0, -1, -1, -1, -3, -3, -3, -3, -4, -4, -5, -6, -6, -7, -7, -8, -8, -9, -10,
-10, -11, -13, -13, -14, -15, -15, -17, -19, -19, -20, -22, -23, -24, -25, -27,
-28, -30, -31, -33, -34, -35, -37, -39, -40, -42, -43, -45, -46, -48, -50, -50,
-52, -53, -56, -57, -58, -59, -61, -62, -64, -65, -66, -68, -68, -69, -70, -71,
-72, -74, -74, -74, -75, -76, -78, -77, -78, -79, -79, -80, -79, -80, -81, -81,
-81, -81, -80, -81, -81, -81, -82, -81, -80, -81, -81, -81, -81, -81, -81, -80,
-81, -80, -81, -81, -81, -82, -81, -80, -81, -82, -82, -82, -82, -82, -82, -83,
-83, -83, -84, -84, -85, -86, -85, -86, -87, -87, -87, -88, -88, -89, -89, -89,
-91, -91, -92, -92, -93, -93, -94, -95, -95, -96, -96, -97, -98, -98, -99, -100,
-100, -101, -101, -101, -102, -103, -104, -104, -104, -104, -104, -105, -106,
-106, -106, -107, -107, -108, -108, -108, -108, -109, -109, -110, -110, -110,
-110, -112, -111, -111, -112, -112, -113, -114, -114, -113, -114, -113, -115,
-115, -116, -116, -115, -115, -117, -116, -117, -116, -118, -117, -117, -117,
-118, -118, -117, -118, -117, -117, -118, -117, -117, -116, -116, -116, -115,
-115, -114, -113, -113, -111, -111, -110, -108, -107, -106, -105, -103, -102,
-100, -98, -96, -95, -92, -89, -87, -85, -83, -79, -77, -74, -71, -68, -66, -61,
-59, -55, -52, -48, -45, -42, -37, -33, -29, -26, -21, -17, -14, -9, -5, -2, };