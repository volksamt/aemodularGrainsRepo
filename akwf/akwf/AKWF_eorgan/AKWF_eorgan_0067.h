#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0067

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 12, 15, 18, 22, 25, 29, 32,
35, 38, 41, 44, 47, 51, 53, 57, 60, 62, 66, 67, 71, 73, 76, 78, 81, 83, 84, 87,
89, 92, 94, 96, 99, 100, 101, 103, 104, 106, 108, 109, 110, 111, 113, 113, 115,
115, 116, 116, 118, 118, 118, 119, 119, 118, 119, 119, 119, 118, 118, 118, 118,
118, 118, 116, 116, 116, 115, 114, 113, 113, 111, 111, 109, 109, 106, 106, 105,
104, 103, 102, 100, 99, 98, 96, 94, 93, 92, 90, 89, 87, 86, 84, 84, 82, 81, 80,
79, 76, 75, 74, 73, 71, 70, 68, 67, 66, 65, 64, 64, 61, 61, 59, 60, 59, 57, 57,
57, 56, 55, 55, 53, 54, 54, 53, 53, 52, 52, 53, 52, 53, 53, 53, 52, 53, 53, 54,
54, 54, 55, 55, 56, 57, 57, 58, 59, 59, 61, 61, 62, 63, 64, 65, 66, 67, 69, 69,
71, 71, 73, 75, 76, 77, 78, 79, 81, 81, 83, 84, 85, 87, 88, 89, 90, 92, 92, 94,
95, 96, 97, 97, 99, 100, 101, 101, 102, 103, 104, 104, 105, 105, 105, 106, 107,
107, 107, 107, 108, 107, 107, 107, 107, 106, 106, 106, 105, 105, 105, 103, 102,
102, 101, 100, 99, 98, 96, 95, 94, 92, 91, 89, 87, 85, 84, 82, 80, 78, 76, 74,
71, 69, 67, 64, 62, 58, 57, 54, 52, 49, 46, 43, 40, 38, 35, 32, 28, 26, 23, 19,
17, 13, 11, 8, 4, 2, -2, -5, -8, -12, -14, -17, -20, -23, -26, -29, -32, -35,
-39, -41, -45, -47, -50, -52, -54, -58, -60, -62, -65, -67, -69, -72, -75, -77,
-78, -80, -82, -84, -87, -88, -90, -91, -93, -94, -95, -98, -99, -99, -101,
-102, -103, -103, -104, -105, -105, -106, -107, -107, -108, -108, -108, -108,
-108, -108, -109, -108, -108, -107, -107, -108, -106, -106, -106, -105, -105,
-104, -102, -101, -100, -100, -100, -99, -96, -96, -95, -95, -93, -91, -90, -89,
-88, -86, -85, -84, -83, -81, -80, -80, -78, -77, -75, -74, -73, -72, -70, -69,
-68, -67, -65, -65, -64, -63, -62, -61, -60, -59, -58, -58, -56, -56, -55, -55,
-55, -54, -54, -53, -52, -52, -53, -52, -52, -53, -53, -53, -52, -52, -53, -53,
-53, -55, -54, -54, -55, -56, -56, -58, -58, -58, -59, -61, -61, -63, -64, -64,
-66, -67, -67, -69, -70, -71, -73, -75, -75, -77, -78, -80, -81, -82, -84, -86,
-87, -88, -90, -90, -92, -94, -94, -95, -98, -99, -101, -102, -103, -103, -105,
-107, -107, -108, -109, -111, -111, -111, -113, -114, -114, -115, -115, -115,
-116, -117, -117, -118, -117, -118, -118, -117, -118, -117, -117, -117, -117,
-117, -116, -115, -114, -113, -112, -111, -111, -109, -107, -106, -105, -104,
-102, -100, -98, -97, -95, -93, -91, -88, -86, -85, -82, -80, -77, -75, -73,
-70, -67, -65, -61, -59, -55, -53, -50, -47, -43, -40, -38, -34, -31, -27, -25,
-21, -18, -15, -12, -8, -5, -2, };