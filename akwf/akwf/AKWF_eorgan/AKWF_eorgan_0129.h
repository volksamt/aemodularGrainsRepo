#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0129

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 11, 16, 20, 24, 29, 33, 37, 41,
46, 51, 55, 58, 63, 66, 70, 74, 79, 83, 85, 89, 92, 95, 97, 100, 103, 105, 107,
109, 111, 113, 115, 115, 116, 117, 118, 119, 119, 119, 119, 119, 119, 118, 118,
116, 115, 115, 113, 112, 110, 108, 106, 104, 102, 99, 97, 95, 93, 90, 87, 84,
81, 78, 75, 72, 69, 65, 62, 59, 55, 53, 49, 45, 42, 37, 34, 31, 28, 23, 20, 16,
12, 8, 5, 2, -2, -5, -9, -13, -17, -20, -23, -27, -30, -32, -36, -39, -42, -46,
-48, -52, -54, -56, -59, -62, -65, -65, -68, -71, -72, -73, -75, -76, -78, -78,
-79, -80, -80, -82, -81, -81, -81, -82, -81, -80, -79, -79, -77, -77, -75, -75,
-74, -72, -70, -68, -66, -65, -62, -61, -58, -56, -54, -52, -50, -48, -46, -44,
-42, -41, -38, -36, -35, -32, -31, -30, -27, -27, -26, -24, -22, -21, -20, -20,
-18, -18, -16, -16, -15, -15, -14, -14, -13, -12, -13, -13, -12, -12, -12, -13,
-13, -13, -12, -13, -13, -13, -14, -14, -14, -14, -14, -14, -16, -15, -16, -16,
-17, -17, -18, -18, -19, -19, -20, -20, -21, -20, -22, -21, -22, -23, -23, -23,
-25, -24, -24, -25, -25, -26, -26, -26, -27, -27, -26, -27, -27, -27, -27, -27,
-27, -27, -27, -26, -26, -26, -25, -25, -25, -24, -23, -22, -21, -20, -20, -19,
-17, -16, -14, -13, -11, -9, -7, -6, -4, -2, 1, 4, 6, 8, 10, 12, 15, 18, 20, 23,
26, 27, 31, 32, 36, 38, 41, 42, 45, 47, 49, 51, 53, 55, 57, 59, 60, 62, 63, 65,
65, 67, 68, 68, 68, 69, 69, 69, 69, 70, 69, 69, 69, 67, 67, 67, 66, 65, 65, 63,
62, 60, 60, 58, 57, 56, 54, 52, 51, 49, 47, 45, 43, 42, 40, 38, 37, 35, 33, 31,
29, 27, 25, 24, 22, 20, 18, 16, 13, 13, 11, 9, 7, 5, 3, 2, 0, -2, -4, -5, -6,
-7, -10, -11, -12, -13, -16, -16, -18, -19, -20, -21, -22, -23, -24, -24, -25,
-26, -26, -27, -29, -28, -29, -29, -29, -28, -29, -29, -29, -28, -28, -27, -26,
-26, -25, -25, -23, -22, -21, -19, -18, -17, -16, -14, -13, -11, -10, -8, -6,
-5, -3, -2, 1, 2, 3, 5, 6, 7, 8, 9, 10, 12, 12, 13, 13, 14, 14, 15, 15, 15, 15,
15, 14, 14, 14, 13, 12, 11, 10, 9, 7, 6, 6, 4, 3, 0, -1, -3, -4, -6, -7, -10,
-12, -14, -16, -18, -20, -22, -24, -26, -27, -30, -31, -34, -35, -37, -39, -41,
-42, -45, -46, -47, -49, -52, -52, -54, -56, -56, -59, -59, -60, -61, -62, -63,
-64, -64, -66, -67, -67, -67, -67, -67, -68, -68, -67, -68, -67, -67, -67, -67,
-66, -65, -64, -63, -61, -60, -58, -57, -55, -54, -52, -50, -47, -45, -43, -40,
-38, -34, -32, -28, -25, -22, -19, -14, -12, -8, -4, 0, };