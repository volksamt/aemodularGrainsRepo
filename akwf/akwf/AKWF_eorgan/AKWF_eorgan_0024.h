#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 9, 13, 16, 18, 20, 23, 26,
29, 31, 35, 37, 40, 42, 46, 48, 51, 54, 56, 59, 61, 63, 67, 68, 72, 73, 76, 78,
80, 82, 85, 86, 88, 90, 93, 94, 95, 97, 98, 100, 101, 102, 104, 105, 107, 107,
109, 110, 111, 112, 113, 114, 115, 115, 116, 116, 116, 117, 118, 119, 118, 119,
118, 119, 119, 119, 120, 119, 119, 118, 119, 118, 118, 118, 117, 117, 116, 116,
115, 114, 114, 113, 112, 112, 111, 110, 110, 108, 107, 106, 106, 105, 105, 103,
104, 103, 101, 101, 102, 101, 101, 99, 99, 99, 99, 99, 98, 98, 97, 97, 96, 97,
95, 95, 94, 94, 92, 92, 91, 91, 90, 88, 88, 87, 86, 85, 84, 82, 81, 80, 79, 78,
77, 75, 74, 73, 71, 70, 69, 67, 67, 64, 63, 61, 59, 59, 57, 55, 54, 51, 50, 49,
46, 45, 43, 41, 39, 36, 35, 33, 31, 30, 28, 25, 23, 21, 18, 16, 15, 13, 10, 9,
6, 4, 2, 0, -1, -4, -6, -8, -9, -11, -13, -15, -17, -19, -20, -21, -23, -25,
-26, -28, -29, -30, -32, -33, -33, -35, -36, -36, -37, -39, -39, -41, -41, -42,
-42, -43, -43, -44, -44, -44, -44, -45, -45, -45, -45, -45, -45, -44, -43, -42,
-43, -41, -42, -41, -41, -40, -39, -39, -38, -37, -35, -34, -33, -31, -31, -29,
-29, -26, -25, -24, -23, -22, -20, -19, -18, -17, -16, -14, -13, -12, -10, -10,
-8, -7, -6, -4, -3, -2, -1, 0, 2, 2, 3, 4, 5, 6, 8, 8, 10, 10, 11, 12, 13, 14,
14, 15, 16, 18, 18, 18, 19, 20, 22, 21, 22, 22, 22, 23, 23, 24, 24, 25, 25, 25,
25, 24, 24, 24, 24, 24, 23, 23, 23, 23, 23, 22, 22, 20, 21, 20, 20, 18, 18, 16,
16, 15, 14, 13, 12, 11, 9, 9, 8, 7, 6, 5, 4, 2, 1, 0, -1, -3, -4, -5, -6, -8,
-9, -10, -12, -13, -14, -16, -18, -18, -20, -20, -23, -23, -25, -27, -27, -28,
-30, -31, -33, -33, -35, -36, -37, -39, -39, -40, -43, -43, -44, -45, -47, -48,
-49, -49, -50, -51, -52, -55, -54, -56, -57, -58, -60, -60, -61, -61, -63, -63,
-64, -66, -67, -68, -68, -70, -71, -71, -73, -74, -75, -76, -77, -77, -78, -79,
-81, -81, -82, -83, -85, -85, -87, -87, -88, -90, -91, -91, -92, -93, -95, -96,
-96, -98, -98, -99, -100, -101, -101, -103, -104, -104, -105, -105, -106, -107,
-108, -108, -109, -110, -109, -110, -111, -110, -111, -112, -111, -111, -112,
-113, -112, -112, -113, -114, -114, -114, -115, -115, -115, -116, -116, -116,
-116, -116, -116, -115, -115, -115, -114, -113, -112, -111, -110, -110, -108,
-107, -105, -104, -101, -99, -98, -95, -94, -90, -88, -85, -83, -80, -77, -75,
-72, -70, -67, -63, -60, -58, -55, -52, -48, -46, -42, -39, -36, -32, -30, -26,
-23, -21, -16, -14, -11, -8, -5, -1, };