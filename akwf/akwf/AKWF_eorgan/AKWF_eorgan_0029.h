#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0029

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 11, 16, 19, 22, 26, 28, 31, 32, 34,
37, 38, 41, 43, 44, 47, 51, 55, 57, 59, 62, 64, 66, 68, 69, 71, 73, 74, 76, 77,
78, 80, 85, 83, 81, 81, 81, 81, 82, 83, 83, 84, 86, 86, 87, 88, 90, 90, 92, 93,
94, 95, 96, 97, 97, 99, 100, 101, 102, 103, 104, 104, 105, 110, 113, 115, 117,
114, 113, 113, 115, 115, 115, 116, 115, 116, 116, 115, 115, 114, 114, 113, 112,
113, 111, 111, 110, 110, 109, 108, 108, 107, 107, 105, 105, 102, 100, 95, 90,
86, 84, 81, 80, 78, 78, 76, 75, 74, 73, 72, 71, 68, 66, 62, 58, 56, 52, 50, 48,
48, 51, 53, 53, 53, 53, 54, 56, 59, 60, 60, 59, 58, 58, 57, 56, 54, 54, 52, 51,
49, 49, 47, 46, 42, 22, 7, -2, -9, -12, -15, -17, -17, -19, -20, -20, -21, -21,
-22, -23, -24, -24, -28, -32, -35, -37, -38, -40, -40, -41, -43, -43, -44, -45,
-45, -46, -47, -47, -48, -49, -50, -50, -50, -51, -51, -52, -52, -54, -54, -55,
-54, -55, -55, -53, -51, -50, -54, -54, -54, -54, -53, -53, -53, -52, -53, -52,
-52, -52, -51, -51, -51, -50, -50, -49, -49, -49, -49, -48, -47, -46, -46, -45,
-42, -43, -42, -39, -40, -42, -45, -45, -44, -43, -43, -42, -42, -41, -41, -40,
-39, -36, -27, -23, -21, -18, -17, -16, -14, -12, -15, -18, -19, -19, -19, -18,
-14, -10, -2, 7, 12, 17, 20, 22, 24, 26, 28, 30, 30, 32, 33, 35, 37, 36, 40, 42,
45, 47, 49, 50, 51, 53, 54, 54, 56, 56, 57, 59, 59, 61, 57, 43, 31, 26, 23, 23,
23, 24, 24, 25, 26, 27, 28, 28, 29, 30, 31, 32, 32, 33, 34, 35, 35, 36, 37, 37,
38, 38, 39, 39, 39, 40, 44, 47, 50, 50, 48, 46, 47, 47, 47, 47, 47, 47, 46, 46,
45, 45, 43, 42, 42, 41, 40, 39, 38, 38, 36, 36, 35, 33, 33, 31, 31, 30, 26, 22,
18, 13, 10, 7, 4, 3, 1, -2, -2, -4, -5, -7, -7, -9, -12, -15, -19, -24, -25,
-29, -32, -35, -33, -30, -29, -29, -28, -29, -28, -26, -22, -21, -23, -23, -24,
-24, -26, -26, -28, -28, -30, -30, -32, -32, -35, -35, -42, -61, -76, -84, -90,
-93, -95, -98, -97, -99, -100, -100, -100, -100, -101, -100, -100, -101, -104,
-108, -110, -111, -113, -114, -114, -115, -116, -117, -117, -117, -117, -118,
-118, -118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -118, -115, -109, -106, -103, -102, -105, -106, -104, -104, -102, -101,
-101, -100, -99, -98, -98, -97, -95, -94, -93, -92, -91, -90, -90, -87, -87,
-86, -84, -83, -82, -80, -79, -75, -68, -64, -65, -66, -65, -65, -63, -62, -60,
-59, -56, -55, -52, -51, -49, -48, -50, -48, -45, -42, -40, -38, -36, -34, -36,
-39, -39, -36, -35, -34, -28, -24, -7, };