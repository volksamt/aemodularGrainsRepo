#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0124

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 15, 28, 39, 50, 61, 71, 80, 87, 94,
101, 106, 110, 114, 117, 118, 119, 119, 118, 117, 116, 113, 110, 107, 104, 101,
97, 93, 89, 85, 81, 76, 73, 69, 65, 61, 58, 54, 52, 50, 48, 46, 45, 44, 43, 42,
41, 42, 42, 44, 44, 46, 47, 50, 53, 55, 58, 61, 64, 67, 71, 75, 78, 81, 84, 86,
89, 90, 92, 92, 93, 91, 91, 90, 88, 84, 80, 76, 73, 69, 64, 59, 53, 48, 43, 38,
35, 30, 24, 20, 17, 13, 9, 5, 2, 0, -3, -5, -8, -11, -12, -14, -15, -16, -18,
-20, -22, -24, -24, -25, -26, -28, -29, -30, -31, -32, -31, -32, -31, -31, -29,
-28, -26, -25, -22, -20, -17, -13, -10, -7, -4, 0, 2, 6, 8, 10, 13, 14, 15, 17,
19, 19, 20, 21, 22, 22, 23, 23, 23, 24, 25, 27, 27, 27, 29, 30, 32, 32, 32, 33,
34, 34, 34, 34, 34, 33, 33, 32, 32, 30, 28, 28, 27, 25, 24, 21, 20, 18, 16, 15,
15, 14, 13, 13, 14, 16, 18, 21, 24, 27, 31, 36, 40, 45, 50, 55, 60, 64, 68, 72,
76, 80, 83, 87, 88, 90, 91, 93, 93, 94, 93, 92, 92, 89, 88, 86, 82, 79, 76, 71,
67, 63, 57, 51, 46, 39, 33, 26, 18, 11, 5, -3, -10, -17, -23, -29, -35, -40,
-44, -48, -52, -54, -56, -57, -57, -56, -55, -53, -50, -46, -41, -35, -29, -22,
-15, -6, 1, 9, 17, 24, 30, 37, 41, 47, 51, 52, 56, 56, 57, 56, 54, 52, 50, 46,
42, 37, 32, 26, 20, 13, 6, 0, -9, -15, -22, -29, -36, -42, -49, -55, -61, -65,
-70, -74, -77, -82, -84, -87, -90, -91, -93, -94, -95, -94, -94, -93, -92, -90,
-89, -85, -83, -80, -75, -71, -67, -63, -59, -53, -49, -43, -39, -35, -29, -25,
-23, -20, -17, -15, -14, -13, -12, -14, -14, -15, -17, -18, -20, -22, -23, -26,
-26, -28, -30, -31, -31, -33, -34, -34, -34, -34, -34, -34, -33, -33, -33, -32,
-31, -30, -29, -28, -27, -26, -26, -24, -24, -23, -23, -22, -21, -20, -21, -18,
-18, -17, -15, -14, -11, -9, -6, -5, 0, 2, 5, 8, 12, 15, 18, 20, 22, 26, 28, 29,
30, 30, 31, 32, 31, 32, 31, 30, 28, 27, 27, 25, 24, 23, 20, 18, 17, 16, 15, 13,
11, 9, 7, 5, 1, -1, -5, -7, -11, -15, -18, -23, -26, -31, -36, -41, -45, -51,
-55, -60, -66, -70, -75, -78, -82, -86, -88, -90, -92, -92, -93, -92, -92, -89,
-88, -86, -83, -79, -76, -74, -70, -66, -64, -60, -57, -54, -51, -49, -47, -45,
-43, -42, -42, -42, -41, -42, -42, -44, -45, -47, -49, -50, -52, -56, -59, -62,
-65, -69, -73, -77, -82, -85, -89, -93, -97, -101, -105, -108, -111, -113, -116,
-116, -118, -118, -117, -116, -115, -111, -108, -103, -97, -90, -83, -74, -65,
-55, -45, -33, -22, -8, };