#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 2, 4, 6, 6, 7, 9, 9, 11, 13, 13,
14, 16, 16, 18, 19, 20, 22, 22, 24, 25, 27, 28, 29, 30, 30, 32, 33, 35, 36, 36,
39, 39, 40, 41, 42, 43, 44, 45, 47, 48, 49, 51, 51, 52, 53, 54, 56, 56, 57, 59,
60, 61, 62, 63, 64, 66, 67, 67, 69, 69, 71, 72, 72, 74, 75, 76, 78, 77, 79, 80,
82, 82, 84, 84, 86, 86, 87, 89, 89, 90, 91, 91, 92, 93, 94, 95, 97, 98, 98, 99,
99, 100, 101, 102, 102, 103, 104, 104, 105, 106, 106, 107, 108, 109, 109, 109,
111, 110, 111, 111, 111, 112, 113, 113, 113, 113, 114, 114, 115, 114, 115, 114,
115, 115, 116, 115, 115, 116, 116, 116, 116, 115, 115, 115, 115, 116, 116, 115,
114, 114, 114, 114, 113, 113, 113, 113, 113, 112, 112, 112, 111, 112, 110, 110,
110, 109, 109, 108, 108, 108, 108, 108, 107, 108, 107, 107, 107, 107, 107, 107,
107, 106, 106, 106, 106, 106, 105, 105, 105, 105, 104, 105, 103, 103, 102, 103,
101, 100, 99, 98, 99, 98, 96, 95, 94, 93, 93, 91, 90, 88, 89, 87, 86, 84, 84,
83, 81, 80, 78, 78, 77, 75, 73, 73, 71, 70, 68, 67, 65, 64, 62, 61, 60, 58, 56,
54, 53, 51, 50, 48, 47, 44, 43, 41, 40, 38, 36, 34, 33, 32, 29, 27, 26, 24, 21,
20, 18, 17, 14, 12, 11, 9, 8, 6, 4, 3, 1, -1, -3, -4, -6, -8, -9, -11, -13, -15,
-16, -18, -20, -21, -23, -24, -27, -28, -29, -30, -32, -34, -36, -36, -38, -40,
-41, -43, -44, -45, -47, -49, -50, -50, -52, -54, -55, -56, -57, -57, -59, -60,
-62, -63, -64, -65, -66, -67, -67, -69, -70, -71, -71, -72, -74, -75, -76, -76,
-77, -79, -79, -80, -81, -82, -82, -83, -84, -85, -86, -87, -88, -88, -89, -90,
-91, -91, -91, -93, -93, -93, -96, -96, -95, -96, -98, -99, -99, -99, -100,
-100, -101, -102, -103, -103, -104, -104, -104, -105, -105, -106, -106, -107,
-108, -108, -108, -109, -109, -109, -110, -110, -110, -111, -111, -111, -111,
-111, -112, -113, -112, -113, -112, -113, -113, -113, -113, -113, -113, -113,
-113, -113, -112, -113, -113, -112, -112, -113, -113, -114, -114, -114, -114,
-114, -115, -116, -116, -117, -116, -117, -117, -118, -118, -118, -119, -120,
-118, -119, -119, -118, -119, -119, -119, -118, -118, -117, -117, -116, -116,
-115, -114, -114, -113, -112, -111, -110, -109, -109, -108, -107, -106, -105,
-103, -103, -102, -100, -100, -98, -97, -96, -95, -94, -92, -91, -90, -89, -88,
-86, -85, -84, -83, -81, -80, -78, -76, -75, -73, -71, -71, -69, -67, -66, -64,
-63, -62, -59, -58, -56, -54, -54, -51, -51, -48, -47, -45, -43, -42, -41, -38,
-37, -35, -34, -33, -31, -30, -28, -26, -25, -23, -22, -20, -20, -18, -17, -16,
-14, -13, -12, -10, -8, -7, -7, -5, -3, -3, -1, };