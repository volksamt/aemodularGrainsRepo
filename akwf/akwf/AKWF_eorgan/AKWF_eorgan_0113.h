#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0113

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 11, 15, 18, 22, 26, 28, 32, 36,
38, 41, 44, 47, 49, 52, 55, 57, 59, 62, 64, 65, 68, 70, 72, 73, 75, 76, 78, 79,
80, 82, 83, 85, 86, 87, 88, 89, 89, 91, 91, 92, 93, 93, 95, 96, 96, 96, 97, 98,
98, 98, 99, 99, 100, 101, 101, 101, 101, 102, 101, 102, 101, 102, 102, 103, 103,
103, 103, 103, 104, 104, 103, 103, 104, 104, 104, 104, 105, 105, 105, 105, 104,
104, 105, 105, 105, 105, 106, 106, 106, 107, 106, 107, 107, 107, 107, 107, 107,
109, 108, 109, 109, 109, 109, 110, 110, 109, 110, 110, 111, 111, 111, 112, 112,
113, 112, 113, 114, 114, 113, 114, 115, 115, 115, 115, 116, 116, 117, 117, 117,
118, 117, 117, 117, 117, 118, 118, 118, 119, 119, 119, 119, 119, 118, 118, 119,
119, 119, 119, 118, 119, 118, 118, 119, 118, 117, 118, 117, 117, 117, 116, 117,
116, 115, 115, 114, 115, 114, 113, 112, 111, 111, 111, 110, 110, 109, 108, 107,
107, 106, 105, 104, 103, 102, 101, 100, 99, 98, 97, 96, 95, 94, 92, 92, 91, 89,
87, 87, 85, 84, 82, 82, 80, 78, 77, 76, 75, 72, 71, 69, 68, 67, 65, 64, 63, 60,
59, 58, 56, 55, 52, 51, 50, 49, 47, 45, 44, 41, 40, 40, 38, 36, 34, 33, 31, 30,
29, 27, 25, 24, 22, 21, 19, 17, 16, 14, 13, 11, 10, 8, 6, 4, 3, 1, -1, -2, -3,
-6, -7, -9, -11, -12, -14, -15, -18, -18, -20, -22, -24, -25, -27, -28, -30,
-31, -32, -34, -36, -37, -38, -39, -41, -43, -44, -45, -46, -48, -51, -52, -53,
-54, -56, -58, -58, -60, -62, -64, -64, -66, -68, -69, -71, -72, -74, -74, -75,
-78, -78, -81, -81, -83, -85, -86, -86, -88, -90, -91, -92, -93, -94, -96, -97,
-98, -99, -99, -101, -102, -102, -103, -104, -106, -106, -106, -107, -108, -109,
-110, -110, -111, -112, -113, -113, -113, -114, -114, -115, -115, -116, -116,
-117, -117, -117, -117, -117, -118, -118, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -120, -119, -120, -120, -118, -119, -118, -119, -118,
-118, -118, -118, -117, -118, -117, -117, -117, -117, -116, -116, -116, -115,
-114, -115, -114, -113, -114, -114, -113, -112, -112, -112, -112, -111, -111,
-111, -110, -110, -110, -110, -109, -109, -108, -109, -109, -108, -107, -107,
-107, -107, -106, -107, -107, -105, -105, -106, -105, -104, -106, -105, -105,
-105, -105, -105, -104, -104, -104, -104, -103, -104, -103, -103, -103, -102,
-103, -103, -103, -102, -102, -102, -102, -102, -101, -102, -101, -101, -100,
-100, -100, -100, -99, -99, -99, -98, -98, -97, -97, -96, -96, -95, -94, -93,
-93, -92, -91, -91, -90, -89, -88, -86, -86, -85, -83, -83, -81, -79, -79, -77,
-74, -73, -72, -70, -68, -65, -64, -63, -60, -57, -55, -52, -50, -48, -44, -42,
-40, -37, -33, -30, -26, -24, -20, -16, -12, -9, -4, 0, };