#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0106

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 14, 18, 24, 29, 34, 38, 43, 48,
52, 56, 59, 64, 68, 71, 75, 78, 82, 84, 88, 91, 94, 95, 98, 100, 103, 105, 106,
108, 110, 111, 112, 114, 115, 115, 116, 117, 118, 118, 119, 119, 119, 119, 119,
118, 119, 118, 117, 117, 116, 115, 114, 112, 112, 110, 109, 108, 106, 104, 102,
101, 99, 97, 94, 93, 90, 89, 87, 85, 84, 81, 80, 77, 76, 74, 72, 71, 69, 67, 65,
64, 63, 61, 60, 60, 58, 56, 57, 55, 53, 52, 52, 51, 50, 50, 49, 48, 47, 47, 46,
46, 46, 45, 44, 44, 45, 44, 44, 44, 44, 45, 44, 44, 44, 44, 44, 44, 45, 45, 45,
46, 46, 46, 46, 47, 47, 48, 49, 48, 49, 49, 49, 49, 49, 49, 48, 47, 48, 48, 46,
46, 45, 44, 42, 41, 40, 39, 37, 36, 33, 32, 30, 28, 27, 25, 23, 22, 19, 18, 16,
14, 12, 10, 9, 6, 5, 3, 1, -1, -3, -5, -8, -10, -13, -15, -17, -19, -21, -23,
-26, -28, -31, -33, -36, -39, -40, -43, -46, -48, -51, -54, -56, -58, -61, -63,
-66, -67, -69, -71, -74, -75, -77, -78, -79, -81, -82, -84, -84, -86, -85, -86,
-87, -87, -88, -88, -89, -88, -89, -88, -87, -87, -87, -86, -85, -83, -83, -81,
-79, -78, -77, -75, -74, -73, -70, -68, -65, -63, -61, -58, -56, -52, -49, -46,
-43, -40, -37, -33, -29, -26, -22, -18, -14, -11, -6, -3, 1, 5, 10, 14, 17, 21,
25, 29, 33, 36, 39, 42, 45, 48, 51, 54, 57, 60, 62, 65, 67, 69, 71, 73, 75, 76,
78, 80, 82, 82, 83, 84, 85, 86, 87, 87, 88, 88, 88, 88, 88, 88, 88, 87, 86, 87,
85, 84, 83, 82, 81, 80, 79, 77, 76, 74, 72, 70, 67, 66, 63, 61, 59, 57, 54, 51,
48, 46, 43, 42, 39, 37, 33, 31, 28, 26, 24, 21, 18, 18, 15, 12, 10, 8, 6, 4, 2,
-1, -3, -5, -6, -10, -11, -13, -15, -16, -18, -21, -22, -24, -26, -28, -29, -31,
-33, -34, -36, -38, -40, -41, -42, -42, -44, -45, -45, -47, -48, -49, -49, -50,
-49, -49, -50, -49, -50, -50, -49, -49, -49, -49, -48, -47, -47, -47, -46, -46,
-46, -45, -45, -45, -45, -44, -45, -45, -44, -44, -44, -44, -44, -44, -44, -45,
-46, -45, -46, -47, -47, -48, -48, -49, -50, -50, -50, -52, -52, -54, -54, -55,
-57, -57, -58, -60, -61, -62, -63, -66, -67, -68, -70, -71, -73, -76, -77, -78,
-80, -82, -84, -86, -88, -90, -91, -94, -96, -98, -99, -102, -103, -106, -107,
-108, -110, -111, -111, -113, -115, -115, -116, -117, -117, -118, -118, -119,
-119, -119, -118, -118, -118, -117, -117, -116, -115, -114, -113, -112, -111,
-110, -107, -106, -103, -102, -100, -98, -96, -93, -90, -88, -85, -82, -79, -75,
-72, -67, -65, -60, -56, -52, -47, -42, -38, -34, -28, -24, -19, -13, -7, -2, };