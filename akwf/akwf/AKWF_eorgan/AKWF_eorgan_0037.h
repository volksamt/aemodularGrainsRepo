#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0037

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 15, 22, 27, 32, 37, 42, 48, 55,
59, 66, 72, 77, 81, 86, 91, 96, 101, 106, 110, 115, 117, 118, 118, 115, 110,
102, 93, 82, 70, 58, 47, 37, 28, 22, 16, 14, 14, 14, 16, 20, 23, 29, 33, 37, 42,
45, 47, 49, 49, 49, 46, 44, 40, 37, 34, 31, 30, 29, 28, 28, 29, 30, 32, 35, 35,
36, 35, 32, 29, 25, 21, 15, 9, 5, -1, -6, -10, -15, -19, -23, -27, -30, -31,
-31, -30, -27, -24, -19, -14, -8, -4, 0, 5, 11, 17, 24, 30, 35, 41, 47, 53, 58,
63, 69, 74, 79, 81, 84, 85, 85, 85, 82, 80, 77, 74, 70, 67, 64, 62, 61, 61, 62,
65, 65, 65, 63, 58, 51, 42, 31, 18, 5, -9, -22, -32, -42, -51, -61, -71, -79,
-85, -88, -89, -89, -88, -87, -83, -78, -74, -69, -66, -62, -60, -58, -57, -56,
-55, -54, -54, -53, -51, -49, -47, -42, -37, -32, -26, -20, -16, -11, -6, 2, 8,
16, 23, 28, 32, 34, 36, 36, 34, 32, 29, 27, 24, 23, 21, 21, 21, 22, 23, 22, 22,
20, 17, 11, 4, -3, -11, -18, -24, -30, -36, -42, -48, -53, -56, -58, -57, -55,
-54, -50, -47, -43, -39, -36, -34, -32, -31, -31, -31, -32, -34, -35, -38, -41,
-43, -47, -51, -56, -60, -64, -67, -73, -78, -82, -85, -89, -93, -96, -98, -100,
-101, -100, -99, -97, -93, -89, -83, -78, -71, -63, -54, -45, -37, -28, -19,
-12, -4, 3, 7, 11, 16, 21, 25, 30, 35, 40, 43, 49, 52, 57, 62, 66, 70, 74, 77,
76, 74, 70, 64, 56, 46, 35, 25, 15, 6, 1, -5, -8, -11, -13, -14, -11, -9, -6,
-3, 0, 3, 6, 9, 11, 12, 13, 13, 12, 10, 8, 6, 5, 2, 1, 0, -1, 0, 0, 1, 2, 2, 3,
4, 3, 2, 2, -1, -3, -6, -10, -15, -22, -30, -36, -44, -50, -56, -61, -65, -67,
-67, -67, -65, -61, -56, -48, -41, -34, -26, -19, -11, -5, 0, 5, 9, 12, 16, 20,
25, 29, 35, 39, 44, 49, 51, 53, 54, 55, 54, 53, 50, 47, 45, 41, 39, 38, 38, 38,
40, 42, 43, 44, 43, 40, 37, 30, 22, 13, 3, -5, -15, -27, -40, -55, -66, -76,
-84, -91, -96, -98, -98, -96, -93, -89, -85, -80, -74, -69, -64, -60, -57, -55,
-53, -52, -51, -49, -48, -47, -44, -40, -35, -30, -25, -18, -10, -2, 6, 11, 18,
24, 29, 34, 39, 44, 47, 49, 48, 48, 46, 44, 42, 39, 37, 37, 35, 36, 36, 37, 38,
37, 36, 35, 30, 27, 21, 16, 10, 5, -1, -8, -16, -22, -26, -29, -30, -30, -29,
-26, -23, -18, -14, -9, -6, -3, 0, 3, 4, 4, 3, 2, 1, 0, -2, -5, -8, -11, -14,
-18, -23, -26, -30, -34, -39, -42, -46, -50, -52, -55, -57, -58, -58, -56, -56,
-53, -50, -44, -39, -32, -25, -17, -9, -3, };