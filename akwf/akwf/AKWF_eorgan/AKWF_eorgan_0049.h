#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0049

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 9, 15, 19, 24, 29, 33, 37, 42,
46, 50, 53, 55, 57, 59, 62, 65, 69, 72, 75, 80, 84, 88, 92, 96, 99, 103, 106,
108, 110, 113, 115, 116, 116, 115, 114, 112, 110, 109, 106, 103, 99, 97, 93, 90,
88, 84, 81, 79, 76, 73, 70, 66, 62, 57, 52, 47, 43, 38, 34, 30, 24, 20, 15, 10,
7, 3, 0, -2, -4, -6, -9, -11, -12, -14, -15, -16, -16, -16, -16, -17, -17, -16,
-17, -16, -17, -15, -13, -13, -12, -11, -9, -9, -8, -8, -8, -8, -8, -9, -10,
-12, -13, -14, -16, -18, -19, -20, -22, -23, -22, -22, -21, -20, -19, -18, -17,
-14, -13, -13, -11, -10, -9, -9, -6, -5, -5, -4, -4, -3, -3, -3, -3, -4, -4, -4,
-4, -4, -3, -4, -3, -4, -4, -4, -5, -4, -4, -5, -4, -5, -5, -6, -6, -7, -8, -9,
-9, -10, -10, -11, -13, -15, -17, -19, -22, -23, -25, -28, -30, -33, -33, -35,
-37, -38, -39, -38, -38, -37, -37, -35, -35, -34, -35, -34, -34, -34, -34, -34,
-35, -36, -36, -36, -37, -38, -40, -41, -41, -42, -43, -43, -44, -43, -44, -44,
-44, -43, -43, -42, -41, -41, -40, -40, -41, -40, -40, -39, -39, -39, -38, -37,
-38, -38, -38, -39, -40, -43, -44, -47, -50, -52, -55, -58, -62, -63, -66, -67,
-68, -67, -67, -65, -62, -59, -56, -51, -45, -41, -36, -31, -27, -22, -17, -11,
-6, -3, -1, 2, 7, 12, 17, 22, 27, 32, 36, 41, 46, 50, 54, 58, 61, 64, 66, 67,
69, 72, 75, 79, 83, 86, 90, 94, 98, 101, 103, 108, 110, 112, 115, 117, 119, 118,
119, 118, 117, 115, 113, 111, 107, 105, 102, 98, 94, 91, 87, 85, 81, 78, 74, 72,
69, 65, 60, 56, 50, 46, 40, 36, 31, 27, 21, 16, 12, 7, 3, 0, -2, -4, -7, -10,
-12, -15, -16, -18, -19, -21, -22, -22, -22, -22, -23, -24, -23, -23, -22, -22,
-20, -19, -19, -18, -17, -16, -14, -14, -14, -15, -14, -16, -16, -17, -20, -21,
-23, -23, -26, -27, -27, -28, -28, -29, -27, -26, -24, -24, -21, -19, -17, -17,
-15, -14, -13, -10, -10, -8, -7, -6, -6, -6, -5, -5, -4, -4, -4, -4, -4, -4, -4,
-4, -4, -4, -4, -3, -3, -4, -4, -4, -3, -3, -4, -3, -4, -4, -3, -4, -5, -5, -5,
-6, -7, -8, -9, -11, -13, -16, -17, -20, -22, -23, -25, -27, -28, -29, -30, -30,
-30, -29, -27, -27, -26, -25, -26, -26, -26, -26, -26, -26, -26, -27, -28, -28,
-29, -31, -32, -33, -34, -35, -37, -37, -37, -38, -38, -38, -38, -37, -37, -37,
-36, -36, -37, -36, -36, -37, -36, -36, -36, -36, -35, -35, -35, -36, -36, -38,
-39, -41, -45, -46, -49, -53, -56, -60, -62, -65, -67, -69, -70, -71, -69, -68,
-66, -63, -59, -55, -51, -47, -42, -38, -32, -28, -23, -17, -13, -9, -4, -1, };