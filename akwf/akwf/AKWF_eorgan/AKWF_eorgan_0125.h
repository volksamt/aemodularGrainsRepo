#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0125

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 15, 23, 29, 36, 42, 47, 53, 59,
63, 68, 72, 74, 78, 81, 82, 84, 85, 85, 86, 86, 86, 85, 84, 82, 81, 79, 76, 73,
71, 68, 64, 61, 57, 54, 49, 46, 41, 38, 34, 29, 25, 22, 18, 15, 12, 9, 7, 5, 4,
2, 1, 0, 0, 1, 1, 2, 3, 5, 6, 8, 11, 13, 15, 18, 21, 22, 24, 27, 29, 30, 33, 34,
36, 36, 38, 38, 39, 40, 39, 39, 39, 39, 39, 37, 36, 35, 34, 33, 32, 30, 29, 27,
26, 24, 23, 21, 19, 16, 15, 13, 11, 9, 9, 6, 5, 5, 3, 2, 2, 1, 1, 2, 3, 4, 5, 6,
8, 11, 13, 15, 19, 22, 26, 29, 33, 36, 40, 44, 47, 50, 52, 56, 58, 60, 62, 65,
67, 67, 69, 69, 69, 70, 69, 70, 69, 69, 67, 67, 66, 64, 62, 62, 59, 58, 55, 54,
51, 50, 47, 46, 43, 41, 39, 38, 35, 33, 31, 30, 29, 28, 25, 25, 24, 24, 23, 23,
23, 24, 25, 26, 28, 29, 31, 33, 36, 38, 41, 43, 46, 48, 49, 52, 54, 56, 56, 58,
60, 60, 60, 60, 60, 58, 57, 56, 54, 53, 50, 47, 44, 42, 39, 35, 32, 28, 24, 21,
16, 13, 9, 5, 2, -2, -4, -8, -12, -14, -17, -20, -22, -24, -26, -27, -29, -30,
-30, -30, -29, -28, -27, -25, -22, -20, -15, -11, -7, -3, 2, 9, 14, 20, 27, 33,
40, 47, 53, 61, 66, 73, 78, 83, 89, 93, 98, 103, 106, 109, 112, 114, 116, 118,
118, 119, 119, 119, 118, 116, 114, 113, 110, 107, 104, 101, 97, 93, 89, 84, 79,
75, 69, 64, 59, 52, 47, 42, 37, 32, 26, 21, 15, 11, 6, 1, -2, -6, -9, -12, -14,
-16, -18, -21, -21, -22, -22, -22, -22, -22, -21, -21, -20, -18, -18, -18, -17,
-17, -16, -16, -16, -15, -15, -16, -17, -17, -18, -20, -20, -23, -23, -25, -28,
-30, -33, -35, -37, -39, -43, -45, -48, -51, -53, -56, -60, -63, -66, -69, -72,
-75, -77, -80, -82, -86, -88, -90, -92, -93, -95, -96, -97, -97, -98, -97, -98,
-97, -95, -94, -91, -89, -87, -84, -82, -79, -75, -73, -70, -67, -64, -61, -58,
-56, -54, -53, -50, -49, -48, -48, -46, -45, -45, -46, -46, -47, -47, -47, -49,
-50, -50, -52, -54, -54, -57, -59, -61, -62, -65, -67, -67, -70, -72, -73, -76,
-77, -79, -80, -82, -83, -85, -86, -86, -86, -87, -87, -87, -85, -86, -84, -83,
-81, -79, -77, -75, -71, -69, -65, -63, -60, -56, -54, -51, -49, -46, -43, -41,
-39, -38, -36, -36, -35, -34, -35, -35, -36, -37, -38, -39, -41, -44, -45, -48,
-52, -53, -55, -59, -62, -65, -68, -71, -73, -76, -80, -81, -85, -87, -89, -91,
-93, -94, -96, -97, -98, -98, -98, -97, -96, -95, -92, -90, -89, -85, -81, -76,
-72, -67, -61, -55, -48, -41, -34, -27, -20, -13, -4, };