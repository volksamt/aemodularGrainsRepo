#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0117

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 9, 15, 21, 27, 33, 38, 43, 49, 54,
59, 63, 67, 72, 77, 80, 84, 88, 91, 94, 97, 100, 102, 105, 107, 109, 110, 113,
114, 115, 116, 117, 117, 119, 119, 119, 119, 119, 118, 118, 117, 117, 116, 115,
114, 112, 110, 110, 107, 106, 104, 101, 99, 96, 94, 90, 87, 84, 81, 77, 74, 69,
66, 62, 57, 54, 49, 45, 40, 36, 32, 29, 24, 21, 17, 13, 9, 5, 1, -3, -7, -9,
-13, -16, -19, -22, -25, -28, -31, -34, -36, -37, -39, -42, -43, -46, -47, -48,
-50, -52, -52, -54, -54, -56, -55, -56, -57, -56, -57, -57, -56, -56, -55, -56,
-55, -53, -52, -52, -50, -49, -48, -46, -45, -43, -41, -39, -36, -34, -32, -29,
-27, -24, -22, -20, -16, -15, -12, -10, -7, -5, -3, 0, 2, 4, 6, 8, 11, 13, 14,
17, 17, 19, 22, 23, 25, 25, 27, 29, 31, 32, 34, 35, 37, 38, 39, 40, 40, 42, 43,
43, 44, 45, 46, 46, 46, 46, 47, 47, 46, 45, 45, 44, 43, 42, 40, 40, 37, 36, 35,
33, 30, 29, 26, 23, 21, 19, 16, 13, 10, 8, 6, 3, 2, 0, -3, -4, -6, -9, -11, -13,
-14, -16, -17, -20, -21, -22, -23, -24, -25, -26, -27, -29, -29, -29, -30, -31,
-30, -31, -31, -31, -33, -32, -31, -32, -31, -30, -29, -29, -29, -28, -27, -26,
-26, -23, -22, -20, -19, -17, -16, -15, -12, -10, -7, -5, -3, -1, 1, 3, 6, 7,
10, 11, 13, 16, 17, 18, 20, 22, 23, 25, 25, 27, 28, 29, 29, 30, 30, 30, 31, 32,
31, 32, 31, 32, 32, 31, 31, 30, 30, 29, 28, 28, 27, 26, 25, 24, 22, 21, 20, 18,
17, 14, 13, 11, 9, 7, 5, 3, 2, -1, -3, -6, -8, -10, -12, -15, -17, -20, -22,
-25, -28, -29, -31, -34, -36, -37, -39, -40, -43, -44, -44, -45, -46, -46, -46,
-46, -47, -46, -46, -46, -45, -45, -44, -43, -42, -42, -41, -40, -38, -37, -36,
-35, -33, -32, -30, -28, -28, -25, -24, -21, -20, -18, -17, -15, -13, -11, -10,
-7, -5, -3, -1, 2, 4, 5, 9, 11, 14, 16, 17, 21, 24, 26, 29, 30, 33, 36, 38, 40,
41, 44, 46, 47, 49, 50, 52, 52, 54, 54, 55, 56, 57, 56, 56, 57, 56, 57, 56, 55,
55, 55, 53, 52, 51, 50, 49, 47, 46, 44, 42, 40, 38, 36, 34, 31, 28, 26, 22, 20,
16, 14, 11, 6, 4, 0, -4, -7, -12, -14, -19, -23, -27, -30, -35, -39, -43, -47,
-51, -57, -60, -64, -68, -71, -76, -80, -83, -86, -89, -91, -95, -98, -100,
-103, -105, -106, -108, -110, -112, -113, -114, -116, -116, -118, -117, -118,
-118, -119, -119, -119, -118, -118, -116, -116, -114, -113, -112, -111, -109,
-107, -105, -103, -100, -98, -95, -92, -89, -85, -81, -78, -74, -69, -65, -60,
-55, -50, -45, -39, -34, -28, -22, -16, -11, -3, };