#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0041

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 6, 9, 10, 14, 15, 18, 19, 20,
20, 20, 20, 21, 22, 23, 26, 27, 29, 31, 33, 36, 37, 40, 40, 43, 43, 45, 45, 47,
48, 48, 48, 49, 49, 49, 49, 49, 48, 48, 47, 46, 45, 44, 42, 42, 40, 38, 36, 34,
33, 31, 30, 29, 26, 24, 22, 20, 18, 16, 14, 12, 9, 7, 5, 4, 1, -1, -3, -6, -8,
-10, -14, -22, -35, -47, -54, -57, -57, -55, -55, -58, -63, -73, -79, -79, -77,
-74, -71, -66, -65, -62, -60, -60, -68, -79, -89, -96, -95, -92, -87, -82, -80,
-77, -75, -72, -69, -65, -61, -57, -53, -48, -43, -39, -36, -37, -45, -53, -59,
-60, -57, -52, -45, -39, -33, -28, -23, -17, -11, -6, -2, 3, 8, 13, 17, 21, 24,
25, 27, 28, 29, 32, 33, 35, 38, 39, 41, 44, 44, 46, 48, 48, 48, 49, 49, 50, 52,
49, 40, 26, 6, -6, -9, -4, 1, 8, 14, 18, 22, 25, 29, 31, 32, 35, 37, 37, 38, 39,
40, 38, 37, 34, 33, 29, 23, 15, 8, 7, 9, 13, 15, 19, 21, 22, 23, 26, 29, 30, 32,
35, 38, 40, 43, 44, 45, 44, 44, 43, 44, 44, 44, 44, 46, 46, 46, 47, 48, 47, 48,
48, 48, 45, 37, 26, 15, 7, 6, 8, 10, 12, 14, 15, 17, 18, 17, 17, 18, 18, 18, 18,
18, 19, 16, 10, 0, -15, -26, -33, -34, -32, -29, -27, -25, -24, -22, -21, -20,
-18, -17, -16, -15, -15, -13, -13, -13, -14, -16, -18, -18, -18, -19, -19, -19,
-19, -18, -18, -18, -17, -17, -17, -16, -16, -16, -16, -16, -23, -42, -67, -98,
-117, -118, -113, -104, -94, -87, -80, -73, -68, -63, -58, -53, -46, -42, -37,
-33, -28, -27, -29, -32, -35, -36, -34, -33, -31, -27, -24, -20, -18, -14, -10,
-6, -3, 1, 4, 7, 11, 13, 16, 17, 12, 5, -3, -7, -6, -1, 5, 9, 13, 16, 19, 21,
23, 25, 26, 27, 28, 30, 32, 32, 30, 25, 19, 8, 2, 1, 4, 7, 10, 12, 15, 17, 19,
20, 22, 22, 23, 24, 25, 26, 28, 28, 27, 27, 26, 26, 26, 26, 25, 26, 27, 27, 27,
28, 28, 29, 29, 29, 28, 21, 11, 4, 0, -1, 0, 0, 2, 3, 4, 5, 6, 7, 9, 10, 10, 10,
11, 12, 12, 12, 11, 9, 7, 5, 1, -9, -26, -48, -61, -63, -58, -52, -45, -40, -35,
-31, -27, -23, -19, -16, -12, -9, -6, -2, 0, 0, 0, -3, -4, -4, -4, -3, -3, -1,
2, 3, 6, 7, 8, 11, 12, 12, 13, 14, 15, 16, 17, 16, 13, 7, -1, -6, -5, -2, 1, 4,
7, 8, 10, 12, 11, 13, 14, 15, 16, 17, 18, 19, 17, 11, 2, -7, -13, -13, -11, -9,
-6, -3, -2, 1, 3, 1, -6, -14, -21, -22, -19, -15, -11, -6, -9, -17, -27, -34,
-36, -33, -28, -21, -16, -11, -6, -2, };