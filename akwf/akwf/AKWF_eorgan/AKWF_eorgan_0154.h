#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0154

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 11, 15, 19, 24, 27, 29, 32,
35, 38, 40, 43, 44, 46, 48, 49, 49, 51, 53, 55, 56, 58, 61, 62, 64, 66, 68, 70,
72, 73, 75, 78, 80, 82, 85, 85, 86, 89, 90, 91, 92, 94, 94, 95, 95, 96, 96, 97,
98, 99, 99, 100, 99, 99, 97, 97, 96, 94, 93, 92, 91, 91, 90, 90, 91, 92, 91, 92,
93, 95, 96, 97, 98, 101, 101, 103, 104, 105, 108, 109, 111, 112, 111, 110, 110,
109, 108, 107, 106, 106, 105, 105, 105, 104, 103, 102, 101, 100, 99, 98, 97, 95,
95, 93, 91, 90, 89, 89, 89, 86, 85, 84, 83, 83, 83, 84, 84, 84, 85, 86, 87, 87,
90, 91, 91, 93, 94, 96, 97, 98, 99, 99, 100, 100, 98, 98, 98, 97, 95, 92, 90,
87, 84, 81, 78, 76, 72, 70, 69, 65, 63, 62, 60, 59, 57, 57, 56, 55, 56, 56, 57,
57, 57, 58, 58, 58, 59, 59, 60, 60, 60, 59, 60, 59, 60, 60, 60, 60, 59, 57, 56,
54, 50, 47, 44, 41, 36, 34, 29, 26, 24, 21, 18, 16, 14, 11, 10, 10, 7, 8, 6, 7,
6, 8, 8, 9, 11, 12, 13, 14, 14, 13, 13, 15, 14, 15, 15, 16, 17, 18, 19, 21, 21,
22, 23, 23, 24, 24, 23, 23, 23, 20, 20, 18, 17, 16, 14, 13, 11, 9, 6, 4, 3, 1,
0, -1, -1, -2, -2, -3, -3, -2, -2, -1, 0, 1, 2, 3, 4, 6, 8, 8, 9, 10, 9, 10, 10,
10, 9, 9, 8, 6, 5, 4, 3, 2, 2, 1, 2, 1, 0, 1, 1, 0, 0, -1, -1, -2, -1, -1, -2,
-2, -3, -3, -3, -4, -6, -6, -8, -9, -10, -11, -13, -15, -16, -17, -18, -20, -21,
-24, -27, -30, -33, -36, -38, -40, -43, -46, -47, -49, -49, -51, -52, -53, -53,
-54, -54, -53, -54, -54, -54, -53, -53, -52, -52, -52, -52, -52, -54, -55, -56,
-59, -61, -62, -64, -64, -66, -69, -70, -70, -72, -74, -76, -78, -79, -81, -83,
-85, -87, -89, -91, -92, -93, -94, -95, -97, -100, -101, -101, -103, -102, -102,
-102, -102, -101, -100, -100, -98, -96, -97, -95, -94, -93, -90, -89, -89, -87,
-86, -87, -87, -87, -88, -88, -88, -91, -92, -95, -97, -99, -102, -104, -107,
-109, -111, -113, -114, -116, -117, -119, -119, -119, -119, -120, -119, -117,
-116, -114, -113, -113, -111, -110, -109, -108, -105, -105, -103, -102, -101,
-99, -99, -97, -96, -95, -94, -94, -94, -94, -95, -98, -99, -100, -102, -105,
-107, -110, -111, -113, -113, -114, -115, -115, -115, -115, -115, -114, -112,
-112, -110, -107, -105, -101, -99, -96, -92, -90, -87, -86, -83, -82, -79, -76,
-73, -71, -69, -65, -62, -59, -55, -52, -50, -46, -44, -41, -40, -37, -36, -33,
-33, -32, -31, -29, -29, -28, -27, -27, -27, -27, -26, -25, -23, -23, -22, -19,
-18, -15, -13, -10, -8, -5, -2, };