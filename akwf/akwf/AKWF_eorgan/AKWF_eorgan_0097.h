#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0097

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 9, 16, 22, 28, 35, 41, 47, 53, 59,
64, 69, 74, 79, 84, 88, 92, 96, 100, 103, 105, 107, 111, 112, 115, 116, 116,
118, 119, 120, 119, 119, 119, 117, 118, 117, 116, 115, 112, 111, 109, 108, 106,
103, 101, 99, 96, 94, 90, 88, 85, 82, 79, 75, 73, 70, 66, 63, 59, 56, 52, 48,
44, 41, 37, 33, 30, 25, 22, 18, 13, 9, 5, 2, -2, -6, -10, -14, -17, -22, -26,
-29, -34, -37, -42, -45, -49, -52, -56, -59, -63, -65, -68, -71, -75, -76, -79,
-81, -84, -86, -87, -88, -89, -90, -91, -91, -91, -91, -90, -90, -88, -87, -85,
-83, -82, -79, -76, -73, -69, -66, -63, -58, -54, -51, -45, -41, -36, -31, -26,
-22, -17, -11, -7, -1, 3, 7, 12, 16, 20, 25, 29, 32, 36, 39, 42, 45, 48, 50, 53,
55, 57, 58, 60, 62, 62, 62, 63, 63, 64, 63, 64, 64, 63, 63, 63, 61, 60, 60, 59,
58, 56, 55, 55, 52, 51, 50, 49, 47, 46, 44, 42, 40, 39, 36, 35, 33, 32, 29, 27,
24, 22, 21, 17, 16, 14, 11, 9, 7, 5, 2, 0, -2, -5, -8, -10, -12, -14, -16, -19,
-21, -23, -26, -28, -31, -33, -35, -37, -40, -41, -43, -45, -47, -49, -50, -52,
-52, -54, -55, -56, -57, -58, -58, -57, -58, -57, -56, -56, -55, -53, -52, -51,
-49, -46, -44, -41, -38, -36, -33, -29, -26, -22, -19, -15, -11, -7, -2, 1, 5,
9, 13, 16, 21, 24, 28, 31, 34, 38, 40, 43, 46, 48, 49, 51, 53, 55, 55, 57, 56,
58, 57, 57, 58, 57, 57, 55, 54, 53, 52, 51, 50, 47, 46, 43, 42, 41, 38, 36, 33,
32, 29, 27, 24, 22, 20, 17, 15, 13, 10, 8, 6, 3, 1, -1, -4, -6, -9, -11, -13,
-15, -18, -19, -21, -24, -26, -29, -30, -33, -35, -36, -38, -39, -41, -43, -46,
-47, -48, -49, -50, -52, -54, -55, -56, -58, -58, -60, -61, -61, -62, -62, -62,
-63, -64, -63, -64, -64, -63, -63, -61, -61, -60, -58, -57, -56, -54, -51, -49,
-46, -43, -40, -38, -34, -30, -26, -22, -18, -14, -9, -5, 0, 5, 10, 14, 19, 24,
30, 35, 39, 43, 48, 52, 57, 61, 65, 68, 71, 75, 77, 80, 83, 84, 86, 88, 89, 90,
90, 91, 91, 91, 91, 89, 88, 87, 86, 84, 82, 79, 77, 75, 73, 69, 67, 64, 60, 57,
53, 50, 46, 43, 39, 35, 31, 27, 23, 19, 15, 11, 7, 4, -1, -5, -9, -12, -17, -21,
-24, -28, -33, -37, -40, -44, -47, -51, -54, -58, -61, -65, -69, -71, -75, -77,
-81, -83, -86, -89, -92, -95, -96, -99, -102, -103, -106, -109, -110, -112,
-114, -115, -116, -117, -118, -118, -118, -118, -119, -119, -118, -118, -116,
-114, -113, -111, -108, -106, -103, -100, -97, -93, -89, -85, -80, -76, -71,
-66, -61, -55, -49, -42, -37, -30, -24, -18, -11, -4, };