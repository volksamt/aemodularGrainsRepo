#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0126

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 5, 8, 10, 13, 15, 17, 19, 23,
25, 29, 32, 36, 39, 43, 46, 49, 53, 58, 61, 65, 69, 73, 76, 80, 84, 87, 90, 94,
97, 100, 102, 104, 107, 109, 111, 113, 115, 116, 117, 118, 118, 119, 119, 119,
118, 118, 118, 117, 116, 115, 112, 110, 109, 107, 106, 103, 101, 99, 97, 94, 92,
90, 87, 84, 81, 79, 76, 73, 70, 68, 66, 63, 61, 59, 56, 54, 51, 49, 46, 44, 41,
38, 36, 34, 31, 30, 26, 24, 23, 19, 17, 15, 12, 10, 7, 4, 1, -2, -4, -7, -10,
-14, -17, -20, -23, -26, -29, -32, -36, -39, -42, -45, -48, -52, -54, -58, -62,
-64, -66, -69, -72, -74, -76, -79, -80, -83, -85, -86, -87, -89, -89, -90, -91,
-92, -92, -92, -91, -92, -92, -91, -90, -90, -89, -88, -86, -85, -84, -82, -81,
-80, -77, -76, -75, -73, -71, -71, -69, -68, -66, -66, -65, -65, -64, -62, -62,
-62, -61, -62, -62, -62, -62, -62, -63, -63, -64, -65, -66, -66, -68, -69, -71,
-72, -74, -74, -75, -77, -78, -79, -81, -81, -83, -83, -84, -85, -85, -87, -87,
-87, -88, -88, -89, -89, -89, -89, -89, -89, -88, -87, -87, -86, -86, -85, -84,
-84, -83, -82, -81, -80, -79, -78, -77, -76, -75, -74, -73, -72, -71, -71, -70,
-69, -69, -68, -67, -66, -65, -64, -64, -63, -62, -61, -61, -60, -59, -58, -56,
-55, -54, -53, -52, -51, -49, -46, -45, -43, -41, -39, -36, -34, -31, -28, -24,
-22, -19, -15, -11, -8, -4, -1, 4, 9, 13, 16, 22, 25, 30, 34, 39, 43, 47, 51,
56, 61, 64, 68, 71, 75, 78, 82, 85, 86, 90, 93, 94, 96, 99, 100, 101, 102, 104,
104, 105, 105, 105, 106, 105, 105, 104, 103, 102, 102, 101, 101, 99, 97, 96, 94,
94, 92, 89, 88, 87, 85, 83, 82, 81, 79, 77, 76, 74, 73, 71, 70, 69, 67, 65, 64,
61, 60, 60, 57, 57, 55, 53, 52, 50, 49, 47, 45, 44, 41, 40, 38, 36, 34, 32, 29,
27, 25, 23, 19, 18, 15, 13, 10, 8, 4, 2, 0, -2, -6, -8, -11, -14, -15, -18, -20,
-22, -24, -26, -27, -28, -31, -32, -33, -34, -34, -35, -35, -35, -35, -36, -36,
-35, -33, -34, -33, -31, -30, -28, -27, -25, -24, -22, -20, -18, -16, -14, -13,
-11, -9, -7, -5, -4, -2, -1, 0, 1, 3, 4, 4, 5, 6, 7, 7, 7, 7, 7, 7, 7, 7, 5, 5,
4, 3, 2, 2, 0, -1, -2, -3, -5, -5, -7, -7, -9, -10, -12, -12, -14, -14, -15,
-16, -17, -18, -17, -17, -18, -18, -19, -19, -19, -18, -18, -18, -19, -18, -18,
-17, -16, -16, -16, -15, -15, -14, -14, -13, -13, -13, -12, -12, -11, -11, -11,
-11, -10, -9, -9, -9, -8, -9, -9, -8, -9, -9, -8, -8, -7, -8, -7, -7, -7, -6,
-5, -5, -4, -4, -2, -2, 0, };