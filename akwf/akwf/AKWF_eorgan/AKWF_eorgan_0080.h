#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0080

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 13, 24, 34, 44, 54, 61, 70, 76, 83,
90, 95, 99, 103, 106, 107, 109, 111, 110, 110, 110, 109, 109, 107, 106, 105,
104, 104, 103, 103, 102, 102, 102, 102, 102, 103, 104, 105, 106, 107, 108, 110,
111, 112, 113, 114, 115, 117, 117, 118, 118, 119, 119, 119, 118, 119, 119, 118,
118, 117, 116, 114, 114, 112, 110, 109, 107, 105, 102, 99, 97, 94, 91, 88, 85,
82, 79, 76, 72, 70, 67, 64, 62, 61, 59, 58, 57, 57, 56, 56, 56, 56, 57, 56, 57,
57, 59, 58, 59, 59, 59, 59, 58, 58, 57, 56, 54, 52, 50, 49, 46, 44, 42, 40, 39,
37, 36, 35, 34, 33, 34, 34, 34, 34, 37, 37, 38, 40, 42, 43, 45, 47, 48, 49, 49,
51, 52, 52, 51, 51, 50, 50, 50, 49, 48, 47, 46, 45, 45, 43, 43, 44, 44, 44, 45,
45, 46, 49, 50, 53, 55, 57, 59, 61, 64, 66, 67, 69, 72, 72, 74, 76, 75, 76, 76,
75, 74, 73, 72, 70, 69, 67, 65, 64, 61, 60, 57, 57, 54, 53, 51, 50, 48, 47, 46,
45, 44, 43, 42, 42, 41, 41, 40, 41, 40, 39, 39, 39, 39, 39, 38, 38, 37, 37, 37,
36, 36, 35, 34, 33, 32, 30, 29, 27, 24, 22, 20, 16, 13, 8, 4, 0, -4, -9, -14,
-18, -23, -26, -29, -33, -35, -39, -41, -41, -41, -41, -40, -39, -37, -34, -30,
-25, -21, -16, -11, -5, 0, 7, 11, 17, 21, 26, 31, 34, 36, 39, 40, 41, 40, 40,
38, 36, 34, 30, 27, 24, 20, 15, 11, 6, 2, -2, -7, -11, -15, -18, -21, -24, -27,
-28, -31, -32, -33, -34, -36, -36, -37, -37, -38, -39, -39, -39, -39, -40, -40,
-40, -40, -41, -41, -42, -42, -43, -43, -43, -44, -45, -46, -47, -47, -48, -49,
-51, -53, -53, -56, -57, -60, -61, -62, -64, -66, -68, -69, -71, -73, -74, -75,
-76, -76, -77, -76, -75, -74, -73, -71, -70, -67, -65, -63, -61, -59, -57, -54,
-53, -49, -48, -47, -46, -45, -43, -43, -43, -44, -44, -45, -45, -46, -47, -48,
-49, -51, -51, -51, -52, -51, -52, -51, -51, -49, -48, -48, -46, -44, -42, -41,
-40, -38, -37, -35, -35, -34, -33, -34, -33, -35, -36, -37, -38, -39, -41, -44,
-46, -47, -49, -52, -53, -54, -56, -57, -59, -59, -59, -60, -59, -59, -59, -58,
-58, -57, -56, -57, -56, -56, -56, -55, -57, -57, -58, -60, -61, -63, -65, -68,
-70, -74, -77, -79, -83, -86, -89, -93, -95, -98, -101, -103, -104, -107, -109,
-111, -113, -114, -115, -117, -117, -118, -118, -118, -119, -119, -118, -118,
-117, -118, -117, -115, -114, -113, -113, -112, -111, -110, -107, -107, -105,
-104, -104, -103, -101, -101, -100, -100, -100, -100, -100, -101, -101, -103,
-104, -104, -106, -106, -108, -109, -107, -108, -107, -106, -105, -102, -98,
-95, -89, -85, -78, -71, -64, -56, -46, -37, -27, -16, -6, };