#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0081

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 14, 26, 37, 47, 57, 67, 75, 84, 91,
97, 103, 107, 111, 114, 117, 118, 120, 119, 119, 118, 117, 114, 113, 111, 109,
106, 104, 102, 101, 98, 96, 95, 93, 92, 90, 90, 88, 88, 86, 86, 85, 85, 84, 83,
83, 83, 82, 82, 82, 81, 80, 81, 80, 79, 79, 79, 78, 78, 78, 77, 75, 76, 75, 74,
73, 72, 70, 69, 68, 66, 64, 63, 61, 60, 58, 55, 54, 52, 51, 49, 48, 48, 48, 47,
46, 47, 47, 49, 48, 49, 50, 51, 52, 52, 54, 54, 56, 57, 56, 56, 57, 57, 56, 56,
55, 54, 52, 51, 49, 48, 47, 45, 44, 43, 42, 41, 41, 41, 40, 41, 42, 43, 44, 46,
48, 49, 52, 55, 57, 58, 61, 62, 64, 66, 67, 67, 68, 68, 69, 69, 68, 67, 67, 65,
64, 63, 62, 61, 60, 59, 58, 58, 59, 58, 59, 59, 59, 61, 62, 64, 66, 66, 67, 70,
71, 73, 75, 74, 76, 77, 78, 78, 79, 78, 78, 77, 76, 74, 74, 72, 70, 69, 67, 65,
63, 62, 61, 59, 58, 56, 55, 53, 52, 51, 50, 48, 48, 47, 47, 45, 44, 42, 41, 41,
39, 37, 36, 34, 32, 31, 30, 27, 26, 24, 21, 20, 16, 15, 12, 9, 6, 3, -1, -4, -8,
-13, -16, -20, -25, -30, -35, -39, -43, -48, -52, -55, -60, -63, -65, -66, -67,
-68, -68, -67, -65, -62, -59, -55, -50, -45, -38, -31, -24, -16, -8, 1, 10, 17,
25, 32, 40, 45, 50, 55, 59, 62, 65, 67, 67, 67, 66, 66, 62, 60, 58, 54, 49, 45,
41, 37, 31, 26, 22, 18, 13, 8, 6, 2, -2, -5, -8, -11, -14, -16, -19, -22, -24,
-25, -28, -30, -31, -33, -34, -37, -38, -39, -41, -41, -43, -44, -45, -46, -48,
-49, -49, -50, -52, -53, -54, -55, -56, -59, -59, -60, -62, -64, -65, -67, -68,
-70, -71, -73, -75, -75, -76, -77, -78, -78, -79, -79, -78, -77, -76, -74, -74,
-72, -71, -69, -68, -67, -66, -64, -62, -61, -60, -60, -59, -59, -58, -59, -59,
-60, -60, -61, -62, -64, -64, -66, -67, -68, -68, -68, -69, -69, -68, -67, -66,
-65, -63, -61, -59, -58, -56, -53, -50, -48, -47, -45, -44, -43, -41, -40, -40,
-41, -41, -41, -42, -43, -44, -46, -48, -48, -51, -51, -53, -54, -54, -56, -57,
-57, -57, -57, -57, -56, -56, -55, -54, -52, -51, -51, -50, -49, -49, -47, -46,
-47, -47, -47, -47, -47, -49, -50, -51, -53, -54, -56, -59, -59, -62, -63, -65,
-66, -69, -69, -70, -72, -73, -74, -75, -76, -76, -76, -78, -78, -78, -78, -78,
-79, -80, -81, -80, -80, -80, -81, -81, -82, -83, -83, -83, -84, -84, -85, -86,
-86, -87, -89, -89, -91, -92, -94, -96, -98, -100, -102, -103, -105, -108, -110,
-112, -114, -116, -117, -116, -117, -116, -115, -113, -111, -108, -103, -98,
-92, -86, -78, -70, -61, -51, -41, -29, -19, -7, };