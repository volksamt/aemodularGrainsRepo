#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0146

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 5, 6, 9, 11, 14, 19, 21, 26,
29, 35, 39, 43, 48, 54, 60, 64, 69, 74, 79, 84, 88, 92, 96, 101, 103, 106, 109,
111, 113, 114, 117, 117, 118, 119, 118, 119, 119, 118, 118, 118, 116, 116, 114,
111, 110, 109, 106, 105, 102, 101, 98, 96, 93, 91, 88, 86, 84, 82, 80, 78, 75,
73, 71, 69, 67, 66, 66, 65, 64, 64, 63, 64, 65, 66, 66, 67, 69, 71, 71, 73, 73,
74, 75, 77, 78, 78, 80, 79, 79, 79, 79, 79, 77, 76, 75, 74, 73, 71, 69, 68, 65,
63, 61, 59, 56, 54, 51, 49, 46, 44, 43, 40, 38, 35, 33, 31, 28, 27, 24, 22, 20,
19, 17, 16, 15, 14, 13, 13, 13, 12, 13, 13, 14, 16, 17, 20, 21, 23, 26, 28, 31,
34, 36, 39, 42, 44, 47, 49, 51, 54, 55, 57, 59, 60, 60, 61, 62, 62, 61, 61, 61,
60, 58, 57, 56, 54, 53, 51, 49, 48, 45, 43, 41, 39, 36, 34, 31, 30, 27, 24, 22,
19, 17, 15, 13, 10, 8, 6, 3, 2, 0, -2, -3, -4, -5, -6, -6, -6, -6, -6, -6, -5,
-4, -4, -3, -1, -1, -1, 1, 2, 3, 2, 3, 4, 3, 3, 3, 2, 0, -1, -3, -5, -7, -9,
-11, -14, -17, -19, -22, -26, -30, -32, -35, -39, -42, -45, -48, -51, -55, -58,
-61, -64, -66, -70, -72, -74, -77, -79, -81, -83, -85, -86, -87, -89, -89, -91,
-90, -89, -89, -88, -87, -85, -83, -81, -78, -76, -72, -70, -67, -64, -60, -56,
-53, -50, -47, -43, -41, -38, -36, -33, -31, -30, -29, -27, -27, -26, -26, -27,
-26, -28, -29, -29, -30, -32, -34, -35, -38, -40, -42, -44, -47, -49, -52, -54,
-56, -60, -63, -66, -69, -70, -74, -76, -79, -82, -83, -86, -89, -90, -92, -93,
-94, -96, -96, -97, -97, -97, -96, -96, -95, -94, -92, -91, -90, -87, -85, -83,
-81, -79, -77, -76, -73, -72, -71, -69, -68, -67, -67, -65, -66, -65, -66, -65,
-66, -66, -67, -68, -68, -69, -69, -71, -71, -73, -73, -74, -75, -76, -77, -78,
-79, -79, -80, -81, -82, -82, -82, -84, -83, -83, -84, -84, -83, -82, -82, -81,
-79, -77, -76, -75, -72, -69, -66, -62, -59, -56, -53, -49, -45, -40, -37, -31,
-28, -23, -20, -16, -12, -9, -6, -3, 0, 2, 5, 7, 8, 9, 9, 11, 11, 12, 13, 12,
12, 11, 11, 11, 10, 9, 7, 7, 6, 5, 4, 2, 1, -1, -1, -3, -5, -5, -6, -8, -9, -11,
-11, -13, -13, -13, -14, -14, -15, -14, -14, -13, -13, -11, -10, -8, -7, -5, -3,
0, 2, 5, 6, 9, 11, 13, 15, 17, 19, 21, 23, 23, 24, 26, 26, 25, 25, 26, 24, 24,
24, 22, 21, 21, 19, 18, 16, 15, 14, 13, 10, 9, 9, 7, 5, 4, 4, 2, 2, 1, 0, -1,
-2, -2, -1, -2, -1, -1, 0, };