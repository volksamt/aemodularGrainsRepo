#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0027

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 5, 8, 10, 12, 14, 15, 17, 19,
21, 24, 25, 27, 29, 31, 34, 36, 37, 40, 42, 44, 46, 48, 50, 53, 53, 56, 59, 60,
63, 64, 65, 69, 71, 72, 74, 76, 77, 79, 82, 84, 85, 86, 88, 90, 91, 93, 95, 96,
98, 98, 100, 101, 102, 103, 104, 106, 106, 107, 108, 108, 108, 109, 109, 110,
110, 110, 111, 112, 111, 112, 111, 113, 111, 113, 112, 112, 112, 112, 112, 112,
111, 112, 110, 111, 111, 110, 110, 109, 110, 109, 110, 108, 109, 106, 109, 106,
108, 104, 108, 104, 107, 101, 107, 100, 105, 100, 104, 98, 103, 91, -85, -113,
-100, -110, -102, -110, -104, -110, -106, -111, -108, -112, -108, -112, -109,
-112, -110, -112, -110, -112, -111, -113, -113, -112, -113, -113, -113, -113,
-114, -113, -113, -113, -112, -112, -112, -112, -112, -111, -111, -110, -111,
-110, -110, -109, -108, -108, -106, -105, -105, -105, -103, -102, -101, -99,
-99, -97, -96, -93, -92, -90, -89, -87, -85, -84, -81, -80, -77, -75, -74, -71,
-70, -67, -66, -63, -61, -59, -56, -54, -53, -50, -48, -45, -43, -40, -39, -37,
-34, -32, -30, -28, -25, -23, -22, -18, -17, -15, -12, -11, -8, -6, -4, -2, 1,
2, 4, 6, 8, 11, 13, 15, 17, 19, 22, 23, 26, 27, 30, 31, 35, 35, 39, 40, 43, 44,
46, 47, 49, 51, 30, 26, 31, 31, 34, 35, 37, 38, 40, 41, 43, 44, 47, 47, 49, 49,
52, 53, 54, 55, 57, 58, 60, 60, 61, 61, 63, 64, 64, 66, 67, 68, 67, 69, 69, 70,
71, 73, 72, 76, 71, 79, 55, 21, 28, 24, 29, 27, 29, 30, 31, 31, 32, 33, 34, 35,
35, 37, 37, 38, 40, 41, 41, 43, 43, 45, 45, 46, 47, 48, 49, 49, 49, 50, 50, 52,
52, 53, 53, 53, 54, 54, 55, 54, 56, 56, 57, 56, 57, 57, 57, 58, 57, 58, 58, 59,
59, 60, 60, 60, 61, 61, 62, 62, 62, 63, 64, 64, 65, 65, 66, 65, 68, 66, 69, 67,
71, 68, 73, 69, 75, 71, 77, 72, 79, 73, 83, 61, -67, -75, -70, -73, -68, -71,
-68, -70, -65, -68, -65, -67, -64, -65, -63, -64, -62, -63, -62, -62, -61, -61,
-60, -60, -59, -60, -59, -59, -59, -58, -58, -58, -57, -57, -57, -56, -56, -55,
-56, -55, -55, -53, -53, -53, -52, -52, -51, -50, -50, -49, -49, -47, -48, -47,
-45, -44, -44, -43, -42, -41, -40, -40, -38, -36, -35, -34, -34, -32, -32, -31,
-30, -28, -29, -26, -27, -25, -24, -23, -22, -21, -20, -20, -18, -18, -15, -55,
-70, -63, -65, -62, -64, -60, -61, -59, -58, -57, -56, -55, -54, -52, -51, -49,
-49, -46, -45, -43, -42, -40, -38, -39, -36, -35, -32, -30, -28, -27, -25, -24,
-22, -20, -17, -16, -13, -13, -9, -8, -4, -7, -28, -28, -26, -24, -21, -21, -17,
-16, -13, -13, -9, -8, -5, -4, -2, 0, };