#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 5, 7, 8, 9, 10, 12, 14, 15,
16, 17, 19, 20, 21, 22, 24, 25, 27, 27, 29, 29, 31, 33, 34, 34, 36, 37, 38, 39,
40, 42, 43, 44, 45, 47, 48, 49, 50, 51, 52, 53, 54, 56, 57, 58, 59, 60, 61, 62,
64, 64, 65, 66, 68, 68, 69, 70, 71, 72, 73, 74, 75, 76, 77, 78, 78, 80, 81, 81,
82, 83, 84, 84, 85, 85, 86, 87, 87, 88, 89, 90, 91, 91, 92, 93, 93, 94, 94, 94,
95, 95, 96, 98, 97, 97, 98, 99, 99, 100, 100, 100, 101, 102, 102, 102, 102, 102,
103, 103, 104, 104, 104, 105, 105, 105, 105, 105, 105, 105, 105, 105, 106, 105,
106, 107, 106, 107, 106, 106, 106, 106, 106, 107, 106, 106, 106, 105, 106, 107,
106, 105, 105, 105, 105, 105, 105, 105, 104, 104, 104, 104, 103, 103, 102, 101,
102, 101, 101, 100, 100, 99, 100, 99, 98, 98, 97, 97, 96, 96, 95, 94, 94, 93,
92, 92, 92, 91, 91, 90, 89, 88, 87, 86, 86, 86, 86, 84, 83, 83, 82, 81, 81, 79,
79, 78, 76, 76, 75, 75, 74, 72, 73, 71, 69, 69, 68, 67, 66, 64, 64, 63, 62, 61,
60, 58, 58, 57, 55, 56, 54, 53, 52, 51, 50, 49, 48, 46, 46, 45, 42, 42, 40, 38,
37, 37, 36, 34, 33, 32, 31, 30, 29, 27, 26, 25, 23, 23, 21, 20, 19, 17, 16, 15,
14, 12, 11, 10, 8, 8, 6, 5, 3, 2, 0, 0, -2, -4, -4, -6, -6, -8, -10, -10, -12,
-14, -15, -16, -17, -19, -20, -21, -22, -23, -26, -26, -28, -30, -30, -31, -33,
-35, -36, -37, -38, -40, -41, -43, -44, -45, -47, -48, -49, -51, -52, -53, -53,
-56, -57, -58, -60, -60, -62, -64, -65, -65, -66, -68, -70, -71, -72, -73, -74,
-75, -76, -78, -79, -80, -82, -82, -83, -84, -86, -86, -87, -88, -90, -90, -91,
-93, -94, -94, -95, -96, -98, -98, -99, -99, -101, -101, -103, -103, -104, -105,
-106, -106, -107, -109, -109, -110, -110, -111, -111, -111, -112, -113, -114,
-113, -115, -114, -114, -115, -116, -116, -117, -117, -117, -118, -117, -118,
-118, -119, -118, -119, -119, -119, -119, -119, -120, -118, -119, -118, -120,
-119, -118, -119, -118, -118, -118, -118, -118, -118, -117, -117, -116, -116,
-116, -116, -116, -115, -114, -115, -114, -113, -113, -113, -112, -112, -111,
-110, -110, -109, -109, -108, -106, -107, -106, -105, -105, -104, -103, -102,
-101, -101, -99, -99, -98, -97, -96, -95, -94, -93, -92, -90, -90, -89, -87,
-87, -85, -85, -84, -82, -81, -79, -79, -79, -77, -76, -74, -73, -72, -70, -69,
-68, -66, -65, -64, -62, -61, -60, -59, -56, -55, -54, -53, -51, -50, -49, -47,
-45, -44, -43, -41, -41, -38, -36, -35, -34, -32, -31, -30, -28, -26, -25, -24,
-22, -21, -20, -17, -16, -15, -13, -12, -10, -8, -7, -6, -4, -3, -1, 0, };