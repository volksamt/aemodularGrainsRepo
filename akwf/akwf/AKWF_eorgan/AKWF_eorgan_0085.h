#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0085

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 12, 23, 32, 41, 50, 58, 66, 74, 81,
87, 93, 97, 102, 107, 110, 113, 115, 117, 118, 119, 119, 119, 117, 116, 113,
110, 107, 104, 100, 95, 90, 85, 80, 75, 71, 66, 61, 57, 53, 49, 45, 43, 40, 37,
36, 34, 33, 33, 33, 32, 33, 34, 34, 36, 39, 41, 44, 46, 51, 54, 58, 62, 67, 72,
75, 80, 85, 88, 92, 96, 99, 102, 105, 107, 110, 112, 113, 114, 114, 115, 116,
116, 115, 114, 113, 112, 110, 109, 107, 105, 102, 99, 96, 92, 88, 84, 81, 78,
73, 70, 68, 64, 61, 60, 57, 55, 54, 52, 51, 50, 49, 49, 48, 48, 48, 49, 49, 50,
52, 53, 54, 56, 58, 60, 62, 64, 68, 71, 73, 76, 78, 80, 83, 83, 85, 87, 88, 89,
89, 89, 91, 91, 90, 90, 89, 89, 88, 86, 84, 83, 80, 77, 75, 72, 69, 66, 63, 59,
55, 51, 46, 42, 40, 36, 33, 30, 27, 26, 23, 22, 21, 19, 17, 17, 17, 17, 17, 18,
18, 19, 21, 22, 23, 26, 29, 31, 34, 37, 40, 44, 48, 51, 55, 58, 61, 64, 67, 69,
71, 74, 73, 74, 74, 74, 74, 74, 72, 70, 67, 66, 63, 58, 55, 50, 45, 40, 35, 29,
24, 16, 11, 4, -3, -11, -17, -24, -31, -37, -42, -47, -52, -57, -60, -63, -65,
-67, -69, -70, -70, -70, -69, -69, -67, -64, -62, -58, -55, -49, -45, -39, -33,
-28, -21, -14, -7, 1, 9, 16, 22, 29, 35, 40, 45, 51, 55, 58, 62, 65, 66, 68, 69,
70, 70, 70, 67, 66, 64, 61, 57, 53, 48, 44, 39, 33, 27, 20, 13, 7, 0, -7, -13,
-21, -27, -33, -38, -44, -49, -53, -57, -62, -64, -68, -70, -72, -74, -75, -76,
-76, -76, -75, -74, -73, -71, -69, -66, -64, -61, -58, -54, -50, -47, -43, -39,
-36, -33, -31, -28, -26, -24, -23, -21, -19, -19, -17, -18, -17, -18, -18, -20,
-20, -21, -23, -25, -27, -29, -32, -36, -38, -42, -46, -49, -54, -57, -61, -65,
-68, -71, -74, -76, -80, -82, -83, -85, -87, -87, -89, -89, -90, -90, -91, -91,
-90, -90, -89, -88, -87, -85, -83, -82, -80, -77, -75, -73, -69, -66, -65, -62,
-60, -57, -55, -54, -53, -51, -51, -50, -49, -49, -49, -49, -50, -50, -50, -51,
-52, -55, -56, -59, -61, -63, -66, -69, -72, -74, -80, -82, -86, -90, -94, -97,
-99, -102, -105, -107, -109, -111, -112, -113, -114, -115, -115, -115, -114,
-114, -113, -112, -110, -108, -106, -103, -101, -98, -94, -91, -86, -83, -78,
-74, -68, -64, -60, -55, -52, -48, -44, -43, -39, -37, -34, -33, -32, -31, -31,
-31, -32, -32, -34, -36, -37, -40, -43, -45, -50, -54, -57, -62, -66, -72, -76,
-81, -86, -91, -95, -100, -103, -107, -110, -113, -114, -115, -116, -117, -117,
-116, -115, -113, -111, -107, -102, -99, -93, -88, -82, -76, -69, -61, -52, -44,
-35, -25, -15, -6, };