#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0087

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 17, 22, 27, 31, 37, 40, 45,
49, 54, 58, 63, 66, 70, 74, 78, 81, 85, 87, 91, 94, 96, 99, 101, 104, 106, 107,
109, 111, 113, 114, 115, 116, 118, 118, 118, 118, 119, 119, 120, 119, 119, 118,
117, 117, 116, 115, 114, 113, 112, 110, 109, 108, 105, 104, 102, 100, 98, 97,
95, 92, 91, 88, 86, 84, 82, 79, 77, 75, 73, 71, 69, 67, 64, 63, 60, 58, 57, 56,
54, 52, 50, 49, 47, 46, 44, 43, 42, 40, 39, 38, 36, 35, 35, 33, 33, 31, 31, 30,
30, 29, 28, 26, 26, 25, 26, 24, 24, 23, 23, 23, 23, 22, 22, 21, 22, 20, 21, 21,
20, 22, 21, 21, 21, 21, 21, 22, 22, 22, 21, 22, 21, 21, 21, 22, 22, 22, 23, 22,
22, 22, 23, 22, 21, 22, 22, 22, 21, 21, 21, 20, 19, 20, 19, 19, 18, 18, 18, 17,
17, 16, 15, 15, 14, 13, 12, 12, 10, 10, 9, 7, 6, 5, 3, 2, 1, -1, -3, -5, -6, -8,
-10, -12, -14, -15, -17, -20, -22, -23, -25, -28, -30, -32, -35, -36, -39, -41,
-42, -45, -47, -48, -50, -52, -54, -55, -56, -58, -59, -61, -62, -64, -64, -65,
-66, -66, -67, -68, -68, -68, -68, -68, -68, -68, -68, -67, -66, -65, -65, -64,
-63, -61, -60, -59, -57, -55, -53, -51, -49, -47, -45, -42, -39, -37, -34, -31,
-28, -25, -22, -20, -15, -12, -10, -6, -3, 0, 5, 8, 11, 15, 18, 22, 24, 27, 31,
34, 36, 39, 41, 43, 46, 48, 51, 52, 55, 56, 58, 60, 61, 63, 62, 64, 65, 66, 67,
67, 68, 68, 68, 68, 68, 68, 68, 67, 67, 66, 66, 65, 64, 63, 60, 60, 58, 58, 55,
54, 52, 50, 49, 47, 44, 43, 41, 39, 37, 34, 33, 31, 29, 26, 24, 22, 20, 18, 16,
15, 11, 10, 9, 7, 4, 3, 1, 0, -2, -3, -4, -7, -7, -9, -9, -11, -12, -12, -13,
-15, -14, -16, -16, -17, -17, -18, -19, -19, -19, -20, -21, -21, -21, -22, -21,
-22, -22, -23, -22, -23, -22, -23, -23, -23, -23, -23, -23, -23, -22, -23, -22,
-23, -23, -22, -22, -22, -22, -22, -22, -21, -22, -22, -22, -22, -21, -21, -22,
-22, -22, -22, -22, -23, -23, -23, -25, -25, -25, -26, -25, -26, -27, -27, -28,
-30, -29, -30, -32, -32, -33, -34, -36, -36, -37, -38, -39, -42, -43, -43, -45,
-47, -48, -49, -51, -53, -55, -57, -59, -60, -63, -64, -66, -68, -70, -73, -74,
-76, -78, -81, -83, -84, -87, -89, -92, -93, -95, -97, -100, -101, -103, -105,
-105, -108, -110, -110, -113, -114, -114, -116, -116, -116, -118, -118, -118,
-119, -118, -118, -118, -118, -116, -117, -115, -115, -113, -112, -111, -109,
-107, -105, -103, -101, -99, -96, -94, -90, -88, -85, -81, -77, -74, -71, -67,
-63, -58, -54, -49, -46, -42, -37, -32, -27, -22, -18, -12, -7, -2, };