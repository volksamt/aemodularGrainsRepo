#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0131

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 8, 10, 11, 13, 16, 17, 19,
21, 24, 26, 28, 29, 32, 34, 37, 39, 41, 42, 44, 47, 50, 51, 54, 55, 57, 60, 61,
63, 66, 68, 69, 72, 73, 75, 77, 78, 81, 82, 84, 85, 87, 87, 90, 91, 91, 93, 95,
95, 97, 98, 98, 99, 101, 100, 101, 101, 102, 102, 102, 103, 103, 103, 103, 103,
103, 103, 102, 101, 101, 100, 100, 99, 98, 97, 96, 94, 95, 93, 92, 90, 90, 88,
86, 84, 83, 81, 80, 77, 76, 74, 72, 70, 67, 65, 63, 61, 59, 56, 55, 51, 50, 47,
44, 42, 39, 36, 34, 31, 28, 25, 23, 21, 17, 14, 12, 9, 6, 4, 1, -2, -5, -7, -10,
-14, -15, -18, -22, -25, -27, -29, -32, -36, -37, -41, -43, -46, -49, -51, -53,
-56, -59, -61, -63, -66, -68, -70, -72, -74, -77, -80, -81, -84, -85, -87, -89,
-90, -93, -94, -96, -97, -99, -101, -102, -104, -104, -106, -107, -109, -110,
-110, -111, -112, -113, -114, -115, -115, -117, -117, -117, -118, -118, -118,
-119, -119, -119, -119, -118, -119, -120, -119, -118, -118, -117, -117, -116,
-116, -116, -116, -114, -114, -113, -112, -111, -111, -110, -109, -108, -106,
-105, -104, -103, -101, -100, -99, -97, -96, -94, -93, -92, -90, -88, -87, -86,
-84, -82, -81, -79, -77, -75, -73, -71, -70, -67, -65, -64, -62, -60, -57, -56,
-54, -53, -50, -49, -46, -44, -43, -41, -38, -36, -34, -32, -30, -28, -26, -24,
-23, -20, -17, -16, -13, -11, -10, -8, -6, -5, -2, 0, 2, 4, 6, 8, 9, 11, 13, 15,
17, 19, 20, 22, 24, 25, 27, 29, 31, 33, 35, 36, 37, 38, 41, 42, 44, 45, 46, 48,
49, 51, 51, 52, 55, 56, 57, 57, 58, 60, 61, 61, 62, 62, 64, 66, 66, 66, 67, 67,
68, 68, 68, 70, 70, 70, 70, 71, 71, 71, 71, 72, 71, 73, 72, 72, 72, 71, 72, 71,
71, 71, 70, 70, 70, 70, 69, 68, 68, 67, 67, 66, 66, 65, 65, 64, 63, 63, 62, 61,
61, 59, 59, 58, 57, 56, 54, 54, 52, 52, 51, 50, 49, 47, 46, 45, 44, 43, 42, 41,
40, 39, 38, 36, 34, 34, 32, 32, 29, 29, 28, 25, 24, 23, 23, 21, 19, 19, 16, 15,
14, 12, 12, 10, 9, 7, 6, 4, 4, 2, 1, -1, -2, -4, -6, -6, -8, -9, -10, -11, -14,
-15, -16, -17, -18, -19, -21, -22, -23, -24, -26, -26, -28, -28, -29, -30, -31,
-32, -34, -34, -36, -36, -36, -38, -38, -39, -40, -41, -41, -42, -43, -43, -43,
-43, -44, -45, -45, -45, -46, -46, -46, -46, -46, -46, -47, -46, -46, -47, -47,
-46, -46, -45, -45, -45, -45, -44, -44, -43, -43, -42, -41, -41, -41, -39, -39,
-39, -37, -36, -36, -34, -34, -33, -30, -31, -29, -27, -27, -25, -24, -23, -21,
-19, -18, -17, -15, -13, -11, -10, -8, -8, -5, -3, -2, };