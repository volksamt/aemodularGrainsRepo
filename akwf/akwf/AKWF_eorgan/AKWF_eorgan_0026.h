#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0026

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 9, 20, 29, 38, 46, 53, 61, 67, 71,
77, 82, 85, 88, 92, 95, 98, 100, 102, 104, 106, 108, 108, 109, 110, 111, 112,
113, 114, 114, 115, 115, 115, 116, 116, 117, 118, 118, 119, 119, 118, 118, 119,
119, 118, 119, 118, 119, 119, 119, 120, 119, 118, 118, 117, 116, 116, 115, 114,
113, 111, 110, 106, 105, 102, 100, 98, 96, 95, 92, 90, 88, 87, 85, 84, 82, 80,
79, 77, 74, 72, 69, 67, 64, 61, 58, 54, 52, 48, 46, 42, 40, 38, 36, 34, 33, 31,
29, 28, 27, 25, 25, 24, 23, 21, 21, 19, 17, 17, 16, 14, 12, 11, 8, 6, 5, 2, 0,
-2, -6, -8, -11, -13, -17, -20, -23, -25, -28, -31, -33, -36, -39, -42, -44,
-48, -51, -52, -56, -58, -61, -63, -65, -67, -68, -69, -70, -72, -74, -75, -75,
-76, -76, -77, -78, -78, -78, -77, -77, -78, -77, -77, -76, -75, -73, -71, -70,
-68, -65, -64, -61, -59, -55, -53, -50, -48, -45, -43, -42, -40, -39, -38, -38,
-37, -37, -37, -37, -37, -38, -39, -40, -41, -44, -46, -48, -49, -50, -52, -53,
-55, -55, -56, -57, -57, -57, -57, -59, -57, -58, -58, -59, -58, -58, -58, -59,
-58, -58, -58, -57, -57, -58, -57, -57, -56, -56, -55, -56, -54, -54, -54, -54,
-53, -53, -52, -51, -51, -50, -49, -47, -46, -45, -44, -43, -40, -38, -36, -34,
-32, -29, -28, -24, -22, -19, -15, -11, -7, -3, 0, 4, 8, 12, 15, 19, 23, 24, 28,
30, 33, 35, 37, 39, 41, 42, 44, 45, 46, 48, 49, 50, 50, 52, 52, 53, 54, 54, 54,
55, 55, 55, 56, 56, 57, 57, 57, 57, 58, 58, 58, 58, 58, 57, 58, 59, 59, 58, 59,
58, 57, 58, 57, 57, 57, 56, 56, 55, 54, 53, 52, 51, 48, 47, 44, 43, 42, 39, 39,
38, 37, 37, 37, 36, 37, 37, 38, 39, 40, 42, 44, 47, 48, 50, 53, 57, 58, 62, 65,
66, 68, 70, 72, 74, 74, 75, 77, 77, 78, 77, 78, 78, 78, 78, 76, 77, 76, 75, 75,
73, 72, 72, 70, 68, 66, 65, 62, 61, 58, 55, 53, 50, 47, 45, 42, 39, 36, 32, 30,
27, 24, 21, 19, 16, 14, 10, 7, 5, 2, -1, -3, -5, -8, -9, -11, -12, -14, -16,
-16, -19, -19, -20, -22, -23, -24, -25, -26, -27, -29, -30, -31, -33, -34, -37,
-39, -40, -42, -46, -49, -52, -55, -58, -61, -64, -68, -70, -73, -75, -77, -79,
-81, -82, -85, -86, -88, -89, -90, -92, -95, -96, -98, -100, -104, -105, -107,
-110, -111, -113, -114, -115, -116, -117, -118, -118, -118, -119, -119, -119,
-119, -118, -119, -119, -118, -119, -119, -119, -118, -118, -118, -118, -117,
-117, -117, -116, -116, -115, -115, -114, -114, -113, -112, -111, -110, -109,
-108, -107, -105, -103, -102, -99, -98, -94, -91, -88, -84, -80, -76, -71, -65,
-59, -52, -44, -36, -27, -18, -7, };