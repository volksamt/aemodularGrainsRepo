#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 5, 6, 7, 9, 10, 13, 13, 15,
16, 18, 19, 21, 22, 23, 24, 25, 26, 29, 30, 31, 31, 32, 34, 36, 37, 39, 39, 40,
41, 43, 43, 45, 46, 47, 48, 48, 49, 50, 51, 53, 53, 54, 56, 56, 57, 58, 58, 60,
60, 60, 61, 62, 63, 64, 65, 65, 66, 67, 67, 68, 68, 70, 70, 71, 72, 72, 73, 74,
74, 74, 74, 75, 76, 76, 78, 78, 78, 79, 80, 80, 81, 81, 82, 83, 83, 83, 85, 85,
86, 85, 86, 87, 88, 88, 88, 88, 89, 90, 90, 91, 92, 92, 92, 93, 93, 94, 95, 95,
95, 96, 96, 97, 97, 97, 98, 98, 98, 98, 99, 100, 100, 100, 100, 101, 102, 102,
103, 103, 104, 105, 105, 106, 107, 108, 109, 110, 111, 111, 112, 113, 113, 115,
116, 116, 118, 117, 117, 118, 118, 118, 118, 119, 119, 118, 119, 119, 118, 119,
118, 118, 117, 117, 117, 116, 117, 115, 115, 115, 115, 113, 113, 112, 111, 111,
110, 110, 109, 108, 107, 106, 106, 104, 103, 102, 101, 100, 99, 97, 96, 94, 93,
93, 91, 90, 89, 87, 85, 84, 82, 80, 79, 78, 75, 74, 73, 72, 70, 67, 67, 64, 63,
61, 59, 57, 56, 55, 52, 52, 49, 48, 46, 44, 42, 41, 39, 38, 36, 34, 33, 32, 30,
28, 27, 24, 24, 22, 21, 20, 17, 16, 14, 14, 12, 11, 9, 7, 7, 6, 4, 2, 1, 0, -1,
-3, -4, -6, -7, -9, -10, -10, -12, -13, -15, -17, -17, -18, -20, -21, -23, -23,
-24, -27, -27, -28, -29, -31, -32, -32, -34, -36, -37, -38, -38, -40, -41, -43,
-44, -45, -46, -47, -48, -50, -51, -51, -53, -54, -55, -57, -57, -59, -61, -62,
-62, -64, -65, -66, -67, -68, -69, -72, -72, -73, -74, -75, -76, -78, -79, -81,
-81, -83, -83, -84, -85, -87, -87, -89, -90, -91, -92, -93, -93, -95, -96, -96,
-98, -98, -99, -100, -100, -102, -102, -104, -104, -104, -105, -106, -107, -107,
-108, -108, -109, -109, -110, -111, -111, -111, -110, -112, -111, -112, -112,
-112, -113, -112, -113, -112, -113, -113, -113, -112, -113, -113, -112, -112,
-112, -112, -112, -111, -112, -110, -110, -110, -110, -109, -109, -108, -108,
-107, -107, -106, -106, -105, -105, -104, -103, -102, -101, -101, -101, -100,
-99, -98, -97, -96, -97, -95, -95, -94, -93, -92, -91, -91, -89, -89, -89, -87,
-87, -87, -86, -85, -85, -85, -84, -84, -85, -85, -85, -84, -84, -84, -84, -84,
-84, -84, -84, -84, -84, -84, -83, -83, -83, -83, -82, -82, -82, -80, -81, -80,
-80, -78, -78, -77, -76, -74, -73, -73, -71, -71, -70, -69, -68, -67, -65, -64,
-64, -62, -61, -60, -59, -58, -56, -56, -54, -53, -52, -50, -49, -48, -46, -44,
-43, -42, -41, -39, -37, -37, -35, -34, -31, -31, -29, -28, -25, -24, -23, -21,
-19, -17, -16, -15, -14, -12, -10, -8, -7, -6, -4, -2, -1, };