#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0054

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 5, 6, 7, 8, 10, 11, 13, 14,
17, 17, 18, 20, 22, 23, 25, 27, 27, 29, 31, 31, 33, 35, 36, 38, 39, 40, 42, 42,
44, 45, 47, 48, 50, 51, 52, 54, 55, 56, 57, 59, 60, 61, 63, 64, 64, 66, 67, 68,
71, 71, 71, 73, 74, 76, 77, 78, 79, 79, 81, 83, 83, 85, 85, 86, 87, 89, 89, 90,
91, 92, 94, 93, 95, 96, 96, 98, 98, 99, 100, 100, 102, 103, 103, 104, 104, 105,
105, 106, 108, 107, 108, 109, 109, 110, 111, 111, 112, 113, 113, 113, 113, 115,
115, 114, 114, 116, 116, 116, 116, 116, 117, 118, 117, 118, 119, 119, 118, 119,
119, 118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119,
118, 118, 118, 118, 118, 117, 116, 117, 116, 116, 116, 116, 115, 115, 115, 114,
114, 113, 112, 112, 111, 111, 110, 110, 109, 109, 109, 108, 107, 107, 106, 105,
104, 103, 103, 102, 101, 100, 100, 98, 98, 97, 96, 95, 95, 94, 93, 92, 91, 90,
89, 89, 87, 86, 85, 85, 83, 82, 81, 79, 78, 78, 77, 75, 75, 73, 72, 71, 70, 68,
68, 67, 64, 64, 62, 61, 60, 59, 58, 56, 55, 54, 52, 51, 49, 48, 47, 46, 44, 43,
41, 41, 39, 37, 35, 34, 33, 32, 30, 28, 27, 26, 25, 23, 22, 21, 19, 17, 16, 14,
13, 12, 10, 9, 7, 5, 4, 2, 0, 1, -2, -3, -5, -6, -8, -9, -10, -12, -13, -15,
-15, -18, -19, -21, -22, -24, -25, -26, -28, -29, -31, -32, -33, -35, -36, -38,
-39, -40, -41, -42, -44, -46, -47, -48, -49, -51, -52, -54, -55, -56, -58, -59,
-61, -61, -63, -63, -65, -66, -68, -69, -69, -71, -73, -73, -74, -75, -77, -78,
-79, -80, -82, -82, -84, -85, -85, -86, -88, -89, -89, -91, -91, -92, -92, -93,
-94, -96, -97, -97, -98, -99, -100, -101, -101, -102, -103, -104, -104, -105,
-106, -106, -107, -107, -108, -109, -109, -110, -111, -111, -112, -112, -113,
-113, -113, -114, -114, -114, -115, -115, -116, -117, -117, -118, -117, -118,
-118, -117, -118, -118, -118, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -120, -119, -119, -120, -119, -119, -118, -118, -118, -119, -119, -118,
-117, -117, -117, -117, -117, -116, -115, -116, -115, -114, -114, -114, -114,
-113, -113, -112, -112, -111, -110, -110, -110, -109, -108, -108, -107, -106,
-105, -105, -104, -103, -103, -103, -102, -101, -100, -98, -98, -97, -96, -95,
-95, -93, -93, -91, -91, -90, -90, -89, -87, -86, -84, -84, -83, -82, -81, -79,
-78, -77, -76, -75, -74, -73, -72, -71, -69, -68, -67, -66, -65, -64, -62, -61,
-60, -59, -58, -55, -54, -53, -52, -50, -49, -48, -47, -46, -44, -43, -41, -40,
-39, -37, -36, -34, -33, -31, -31, -28, -27, -26, -24, -23, -21, -20, -19, -17,
-15, -14, -13, -11, -10, -8, -7, -5, -4, -2, -1, };