#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0115

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 14, 22, 31, 39, 46, 53, 58, 64, 70,
74, 78, 83, 86, 89, 93, 95, 98, 100, 102, 104, 106, 107, 109, 110, 112, 112,
113, 115, 114, 116, 117, 117, 117, 117, 118, 119, 119, 118, 118, 118, 118, 117,
117, 117, 117, 116, 115, 115, 114, 112, 111, 110, 109, 108, 107, 105, 104, 102,
100, 98, 96, 93, 91, 88, 86, 83, 80, 77, 74, 72, 69, 66, 64, 60, 58, 56, 53, 51,
48, 46, 43, 41, 39, 37, 36, 34, 32, 31, 30, 28, 27, 27, 27, 26, 25, 25, 25, 25,
25, 26, 25, 26, 27, 27, 29, 31, 33, 34, 34, 36, 38, 41, 42, 45, 46, 50, 52, 55,
57, 59, 62, 65, 67, 71, 73, 75, 78, 81, 84, 87, 88, 91, 93, 95, 97, 99, 100,
102, 104, 104, 105, 107, 108, 109, 111, 111, 111, 113, 113, 114, 115, 115, 115,
116, 117, 117, 118, 118, 118, 118, 118, 118, 119, 120, 119, 119, 118, 119, 119,
118, 118, 117, 117, 117, 117, 115, 114, 113, 113, 112, 112, 109, 108, 106, 105,
103, 102, 99, 97, 95, 92, 88, 87, 83, 80, 77, 73, 71, 66, 64, 59, 55, 52, 47,
44, 40, 36, 32, 28, 24, 20, 15, 11, 8, 4, 0, -4, -8, -11, -15, -16, -19, -21,
-23, -26, -27, -28, -30, -31, -32, -33, -34, -35, -36, -35, -36, -35, -35, -35,
-34, -33, -33, -32, -30, -29, -26, -25, -23, -21, -19, -16, -13, -11, -7, -4, 0,
3, 6, 9, 12, 15, 18, 20, 23, 23, 26, 27, 29, 30, 31, 32, 32, 33, 33, 34, 33, 33,
33, 32, 32, 31, 30, 29, 27, 26, 25, 23, 20, 17, 16, 12, 10, 7, 3, 0, -5, -7,
-11, -16, -19, -24, -27, -32, -35, -40, -44, -47, -52, -54, -60, -63, -67, -70,
-73, -76, -79, -83, -86, -89, -91, -94, -97, -99, -101, -103, -104, -106, -108,
-109, -110, -112, -113, -113, -115, -115, -116, -116, -117, -117, -119, -119,
-118, -118, -119, -119, -119, -119, -119, -120, -119, -119, -118, -118, -118,
-117, -117, -117, -116, -115, -116, -114, -113, -114, -113, -111, -110, -110,
-109, -107, -106, -105, -104, -102, -101, -99, -98, -96, -94, -91, -89, -87,
-85, -83, -79, -77, -74, -70, -69, -66, -63, -60, -58, -55, -53, -49, -48, -45,
-42, -41, -39, -37, -36, -33, -32, -31, -30, -29, -28, -26, -26, -25, -25, -24,
-25, -23, -24, -25, -26, -27, -27, -28, -29, -30, -31, -33, -34, -36, -38, -40,
-43, -44, -47, -50, -52, -54, -56, -58, -62, -65, -67, -70, -73, -76, -80, -81,
-84, -86, -90, -91, -94, -96, -98, -101, -102, -104, -106, -107, -108, -110,
-110, -112, -113, -113, -115, -115, -115, -116, -117, -117, -118, -117, -117,
-117, -118, -117, -117, -117, -117, -116, -116, -115, -115, -114, -114, -112,
-110, -110, -108, -107, -106, -104, -101, -100, -97, -95, -92, -89, -85, -82,
-78, -73, -70, -64, -60, -53, -46, -40, -31, -24, -15, -4, };