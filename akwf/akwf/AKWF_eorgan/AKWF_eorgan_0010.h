#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 5, 7, 8, 9, 12, 12, 14, 16,
17, 18, 20, 21, 22, 23, 25, 26, 28, 29, 30, 32, 34, 35, 36, 37, 37, 40, 41, 41,
43, 44, 45, 46, 47, 48, 49, 50, 52, 52, 54, 54, 55, 56, 57, 57, 58, 60, 61, 61,
62, 62, 62, 64, 65, 65, 66, 67, 67, 69, 68, 70, 70, 70, 71, 71, 72, 73, 73, 73,
74, 75, 75, 76, 76, 77, 77, 77, 78, 79, 79, 80, 80, 80, 80, 81, 82, 82, 82, 82,
83, 84, 84, 85, 84, 86, 86, 87, 88, 89, 89, 91, 91, 91, 92, 94, 95, 95, 97, 97,
98, 100, 100, 101, 102, 104, 104, 105, 107, 107, 108, 109, 109, 110, 111, 113,
113, 114, 113, 114, 115, 116, 116, 117, 117, 116, 117, 118, 118, 117, 117, 118,
119, 119, 119, 118, 118, 120, 119, 119, 119, 119, 119, 118, 119, 118, 118, 118,
117, 117, 116, 116, 115, 115, 114, 113, 113, 111, 111, 110, 109, 108, 107, 107,
105, 104, 103, 102, 100, 100, 98, 97, 96, 95, 93, 92, 90, 89, 87, 86, 85, 84,
82, 81, 79, 77, 76, 75, 73, 72, 69, 68, 66, 65, 63, 62, 60, 59, 57, 56, 54, 53,
51, 49, 48, 46, 45, 43, 41, 41, 38, 38, 36, 35, 32, 31, 29, 29, 27, 25, 24, 23,
21, 20, 18, 17, 16, 14, 13, 11, 11, 9, 8, 6, 6, 4, 3, 1, 1, -1, -2, -3, -5, -6,
-7, -8, -10, -11, -13, -14, -15, -16, -18, -19, -20, -22, -22, -24, -25, -27,
-27, -28, -30, -32, -33, -34, -35, -36, -37, -39, -40, -41, -42, -44, -45, -46,
-48, -49, -51, -52, -52, -53, -55, -57, -57, -58, -60, -61, -62, -64, -65, -66,
-68, -69, -70, -72, -73, -74, -74, -76, -77, -78, -80, -81, -82, -84, -84, -85,
-86, -88, -89, -90, -90, -92, -93, -94, -95, -96, -97, -97, -98, -99, -100,
-101, -101, -103, -102, -104, -104, -105, -106, -106, -107, -107, -107, -108,
-109, -110, -109, -110, -110, -110, -110, -111, -111, -111, -111, -112, -111,
-112, -112, -112, -112, -112, -111, -111, -111, -111, -111, -111, -110, -109,
-109, -110, -109, -109, -108, -108, -108, -107, -106, -107, -105, -104, -105,
-104, -103, -103, -102, -101, -101, -101, -100, -99, -99, -97, -97, -96, -95,
-95, -94, -94, -93, -93, -91, -90, -90, -89, -88, -87, -87, -86, -86, -84, -85,
-83, -83, -82, -80, -80, -80, -79, -78, -78, -77, -76, -75, -74, -73, -73, -73,
-71, -70, -70, -70, -69, -68, -68, -66, -66, -66, -66, -65, -66, -65, -64, -65,
-63, -63, -63, -63, -62, -62, -62, -62, -61, -61, -61, -61, -59, -60, -59, -58,
-57, -57, -56, -55, -55, -53, -52, -51, -50, -49, -48, -46, -46, -45, -43, -42,
-41, -40, -39, -38, -36, -35, -33, -33, -31, -30, -28, -27, -26, -25, -23, -21,
-20, -19, -19, -17, -15, -14, -13, -10, -10, -8, -7, -5, -4, -3, -1, 0, };