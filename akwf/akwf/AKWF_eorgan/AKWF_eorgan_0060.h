#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0060

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 12, 21, 32, 41, 51, 60, 68, 77, 84,
91, 97, 102, 107, 111, 114, 117, 118, 119, 119, 118, 117, 115, 113, 110, 106,
102, 98, 94, 90, 83, 79, 74, 69, 65, 60, 56, 53, 48, 45, 43, 40, 38, 36, 35, 34,
34, 34, 35, 36, 36, 37, 40, 41, 44, 45, 46, 49, 51, 53, 55, 56, 57, 58, 59, 60,
61, 60, 60, 59, 59, 57, 57, 53, 52, 49, 47, 45, 42, 39, 37, 33, 30, 27, 24, 21,
19, 17, 14, 13, 11, 10, 8, 7, 7, 6, 6, 6, 6, 6, 7, 8, 9, 10, 10, 11, 13, 14, 13,
15, 15, 16, 17, 17, 16, 17, 16, 16, 15, 14, 13, 12, 10, 9, 7, 6, 3, 1, 0, -2,
-4, -6, -7, -9, -10, -11, -11, -12, -13, -13, -12, -12, -11, -10, -10, -7, -6,
-4, -2, 0, 1, 4, 5, 8, 10, 12, 14, 16, 18, 18, 21, 21, 23, 23, 24, 24, 24, 23,
24, 22, 22, 21, 20, 19, 17, 16, 14, 12, 11, 10, 8, 7, 6, 6, 5, 4, 4, 5, 7, 7, 8,
9, 11, 12, 14, 17, 19, 21, 24, 25, 27, 31, 33, 35, 37, 38, 39, 40, 41, 41, 41,
40, 39, 37, 34, 32, 29, 26, 21, 17, 11, 6, 1, -5, -11, -16, -23, -29, -35, -42,
-47, -53, -58, -62, -66, -70, -73, -76, -78, -78, -79, -78, -77, -75, -73, -69,
-65, -60, -55, -50, -44, -36, -29, -21, -14, -7, 2, 9, 17, 25, 32, 40, 46, 51,
58, 62, 67, 70, 73, 76, 77, 79, 79, 77, 77, 75, 72, 68, 65, 60, 55, 50, 45, 40,
33, 27, 20, 15, 8, 3, -4, -8, -15, -19, -23, -27, -31, -33, -36, -38, -39, -41,
-42, -41, -42, -41, -40, -38, -36, -34, -33, -31, -28, -25, -23, -20, -18, -15,
-13, -11, -10, -8, -7, -6, -5, -6, -5, -5, -6, -6, -7, -7, -9, -11, -12, -13,
-14, -16, -18, -19, -20, -22, -22, -23, -23, -24, -24, -24, -24, -23, -22, -22,
-20, -19, -17, -15, -14, -12, -9, -8, -6, -3, -1, 1, 3, 5, 7, 8, 9, 10, 11, 12,
13, 12, 12, 12, 11, 10, 9, 8, 6, 5, 3, 1, 0, -2, -4, -6, -7, -9, -10, -12, -13,
-15, -15, -15, -16, -17, -17, -17, -17, -16, -15, -16, -14, -13, -12, -12, -11,
-10, -9, -8, -7, -7, -7, -7, -7, -8, -7, -7, -9, -10, -13, -14, -16, -18, -20,
-22, -26, -28, -31, -34, -38, -40, -43, -46, -48, -51, -52, -54, -57, -58, -59,
-60, -61, -61, -61, -59, -60, -59, -58, -57, -54, -53, -51, -49, -46, -45, -42,
-40, -39, -37, -36, -35, -34, -34, -35, -35, -36, -36, -39, -41, -43, -46, -50,
-53, -57, -62, -65, -70, -76, -80, -85, -90, -94, -98, -103, -106, -109, -111,
-114, -115, -118, -118, -117, -116, -114, -112, -109, -103, -99, -94, -87, -81,
-72, -64, -56, -46, -36, -27, -16, -6, };