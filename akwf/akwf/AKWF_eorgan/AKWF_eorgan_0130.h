#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0130

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 7, 8, 9, 11, 14, 16, 18, 19,
22, 24, 27, 28, 30, 32, 35, 38, 40, 43, 45, 48, 50, 52, 55, 57, 59, 63, 65, 67,
71, 73, 75, 78, 81, 84, 86, 87, 90, 92, 94, 96, 98, 100, 101, 104, 105, 106,
108, 109, 111, 111, 112, 114, 114, 115, 115, 115, 116, 116, 116, 116, 116, 116,
116, 115, 114, 114, 112, 111, 110, 109, 108, 106, 105, 104, 102, 101, 99, 97,
94, 92, 91, 88, 87, 84, 82, 79, 77, 75, 72, 70, 67, 64, 63, 60, 57, 54, 51, 49,
47, 43, 40, 38, 35, 32, 29, 27, 24, 20, 17, 15, 12, 9, 7, 3, 0, -3, -6, -9, -11,
-14, -17, -19, -23, -25, -28, -31, -34, -36, -40, -42, -45, -47, -50, -52, -55,
-58, -60, -63, -64, -68, -70, -72, -74, -76, -78, -80, -82, -84, -86, -88, -90,
-92, -94, -95, -97, -98, -100, -101, -103, -104, -105, -106, -107, -110, -109,
-111, -111, -113, -114, -114, -115, -116, -116, -117, -117, -117, -118, -119,
-119, -119, -118, -119, -120, -119, -119, -119, -119, -118, -118, -118, -118,
-118, -117, -116, -116, -115, -115, -113, -113, -113, -112, -111, -110, -109,
-108, -107, -106, -105, -104, -102, -101, -100, -98, -97, -95, -93, -93, -92,
-89, -88, -86, -86, -84, -82, -80, -79, -78, -76, -75, -72, -71, -69, -68, -65,
-64, -62, -61, -58, -58, -56, -54, -52, -50, -48, -47, -46, -43, -42, -40, -38,
-36, -35, -33, -32, -29, -26, -26, -23, -21, -19, -17, -15, -14, -11, -9, -7,
-6, -3, -1, 1, 4, 6, 9, 10, 12, 15, 17, 20, 22, 24, 27, 29, 32, 33, 36, 38, 41,
43, 45, 48, 50, 51, 54, 55, 57, 59, 62, 63, 65, 66, 68, 70, 72, 72, 74, 76, 77,
78, 79, 80, 80, 81, 82, 82, 83, 83, 84, 84, 84, 84, 84, 84, 84, 84, 84, 84, 84,
84, 82, 81, 81, 81, 81, 80, 79, 78, 78, 76, 76, 74, 75, 73, 72, 71, 70, 70, 67,
67, 65, 65, 64, 62, 61, 61, 59, 58, 56, 55, 54, 53, 52, 51, 50, 48, 47, 46, 45,
43, 42, 42, 39, 38, 36, 35, 34, 33, 31, 30, 28, 28, 26, 25, 23, 22, 21, 20, 18,
17, 15, 15, 13, 11, 9, 8, 7, 5, 4, 3, 1, 0, -1, -2, -3, -4, -5, -7, -8, -9, -10,
-12, -13, -13, -16, -16, -17, -19, -20, -20, -21, -23, -24, -25, -26, -27, -27,
-29, -29, -30, -31, -31, -33, -33, -34, -34, -35, -36, -37, -38, -38, -38, -39,
-40, -40, -41, -41, -41, -42, -43, -42, -43, -43, -43, -43, -45, -45, -43, -44,
-43, -43, -44, -44, -43, -43, -43, -43, -43, -42, -42, -42, -41, -41, -40, -39,
-39, -39, -37, -37, -36, -35, -35, -35, -33, -32, -32, -31, -29, -29, -28, -26,
-26, -25, -24, -22, -22, -20, -20, -17, -16, -16, -14, -13, -11, -10, -8, -7,
-5, -4, -2, -1, };