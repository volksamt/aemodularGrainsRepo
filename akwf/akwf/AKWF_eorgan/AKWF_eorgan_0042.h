#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0042

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 12, 14, 17, 19, 22, 24, 26,
27, 28, 30, 31, 31, 32, 32, 33, 31, 32, 41, 49, 56, 62, 68, 73, 75, 79, 79, 81,
80, 81, 78, 78, 73, 72, 67, 65, 59, 56, 50, 48, 40, 36, 31, 27, 23, 16, 16, 5,
15, -77, -109, -87, -91, -78, -77, -65, -62, -54, -49, -41, -38, -30, -25, -18,
-12, -5, 0, 7, 11, 18, 20, 27, 28, 33, 33, 38, 35, 42, 35, 46, 19, -70, -53,
-48, -37, -29, -22, -15, -10, -2, 0, 7, 7, 12, 10, 15, 12, 14, 11, 12, 8, 9, 2,
3, -2, -1, -5, -7, -10, -11, -10, -17, -6, -96, -120, -97, -97, -81, -77, -63,
-59, -46, -40, -29, -25, -17, -11, -5, 0, 5, 9, 13, 16, 18, 21, 21, 23, 23, 24,
22, 23, 20, 20, 18, 17, 12, -1, -12, -22, -32, -40, -48, -55, -60, -65, -68,
-72, -73, -76, -74, -76, -72, -72, -68, -67, -62, -60, -55, -52, -47, -47, -40,
-36, -33, -26, -26, -10, -95, -111, -84, -79, -58, -50, -32, -23, -7, 1, 14, 21,
32, 38, 48, 53, 61, 65, 70, 73, 78, 77, 81, 79, 82, 78, 82, 75, 79, 67, 79, 43,
-45, -28, -28, -20, -16, -9, -4, 0, 6, 9, 15, 16, 22, 22, 28, 27, 32, 30, 34,
30, 34, 31, 32, 30, 34, 32, 34, 34, 36, 37, 35, 45, -48, -63, -41, -38, -22,
-18, -3, 0, 11, 17, 26, 30, 37, 43, 50, 52, 56, 58, 60, 61, 60, 59, 57, 54, 50,
47, 42, 38, 33, 28, 22, 16, 14, 20, 24, 27, 30, 33, 35, 36, 38, 37, 38, 37, 38,
36, 36, 32, 32, 27, 28, 22, 23, 16, 17, 12, 12, 6, 5, 2, -1, -4, -7, -1, -98,
-114, -96, -96, -83, -80, -67, -64, -54, -49, -40, -35, -28, -25, -18, -16, -10,
-8, -4, -3, 1, 1, 3, 2, 6, 3, 7, 2, 8, -1, 13, -26, -109, -87, -88, -78, -74,
-65, -59, -52, -44, -38, -29, -24, -16, -12, -4, -1, 7, 8, 16, 16, 21, 19, 24,
23, 28, 25, 29, 27, 30, 28, 28, 32, -64, -74, -55, -53, -38, -35, -23, -19, -9,
-5, 3, 6, 13, 16, 21, 23, 27, 28, 29, 30, 31, 32, 31, 30, 29, 29, 27, 26, 22,
21, 17, 18, 10, -3, -13, -21, -30, -35, -41, -44, -46, -49, -49, -49, -49, -48,
-44, -44, -40, -38, -32, -32, -24, -23, -16, -14, -5, -2, 5, 6, 12, 14, 18, 24,
-71, -78, -60, -57, -43, -39, -26, -22, -12, -10, -1, 2, 8, 12, 17, 20, 25, 28,
31, 31, 35, 35, 39, 37, 40, 36, 41, 35, 41, 30, 45, -2, -79, -55, -56, -43, -38,
-29, -23, -16, -9, -4, 2, 7, 13, 16, 22, 23, 28, 27, 32, 31, 35, 31, 34, 30, 34,
28, 31, 26, 27, 21, 22, 20, -79, -84, -67, -65, -53, -49, -37, -34, -22, -19,
-10, -6, 0, };