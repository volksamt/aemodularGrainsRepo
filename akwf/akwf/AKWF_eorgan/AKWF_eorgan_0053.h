#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0053

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 16, 21, 27, 32, 37, 42, 46, 51,
55, 59, 63, 68, 72, 75, 78, 82, 86, 88, 91, 93, 95, 96, 98, 99, 99, 101, 101,
102, 103, 103, 105, 106, 107, 108, 109, 111, 112, 114, 116, 117, 117, 118, 119,
119, 119, 119, 119, 119, 118, 118, 117, 117, 115, 115, 115, 115, 113, 113, 113,
112, 112, 112, 111, 112, 111, 110, 111, 110, 110, 107, 106, 105, 104, 104, 102,
101, 100, 100, 99, 99, 98, 97, 96, 96, 95, 93, 93, 91, 88, 86, 83, 81, 77, 75,
72, 70, 67, 66, 63, 60, 57, 56, 53, 52, 49, 47, 43, 41, 39, 36, 34, 31, 29, 28,
26, 24, 23, 23, 22, 21, 21, 22, 21, 21, 22, 22, 22, 23, 24, 25, 26, 26, 26, 26,
26, 26, 27, 25, 26, 25, 26, 24, 24, 24, 23, 22, 20, 20, 19, 17, 15, 14, 12, 11,
9, 8, 7, 4, 4, 2, 1, 1, 0, -1, 0, 0, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1, -1, -1, -1,
-2, -3, -4, -5, -5, -7, -8, -9, -9, -10, -11, -12, -14, -13, -15, -15, -17, -17,
-17, -17, -18, -18, -18, -18, -17, -16, -15, -14, -13, -13, -11, -11, -10, -10,
-9, -9, -9, -8, -9, -8, -8, -8, -8, -8, -7, -7, -6, -5, -4, -3, -2, 0, 1, 3, 4,
6, 9, 10, 12, 13, 16, 17, 20, 22, 24, 26, 28, 32, 34, 36, 40, 43, 46, 48, 52,
55, 58, 60, 64, 66, 68, 71, 72, 74, 74, 76, 78, 78, 79, 81, 81, 80, 81, 79, 79,
77, 76, 74, 72, 71, 67, 65, 63, 61, 58, 56, 53, 52, 49, 47, 45, 44, 42, 41, 39,
38, 36, 36, 33, 32, 30, 29, 27, 25, 23, 22, 19, 17, 16, 15, 13, 12, 9, 9, 7, 5,
4, 4, 1, 0, -1, -1, -3, -4, -4, -5, -8, -9, -10, -10, -11, -12, -11, -12, -12,
-13, -13, -13, -14, -14, -15, -17, -17, -19, -20, -22, -23, -25, -25, -27, -29,
-30, -32, -33, -34, -36, -37, -38, -38, -41, -41, -41, -43, -43, -44, -45, -45,
-45, -45, -46, -45, -46, -46, -45, -44, -43, -43, -42, -40, -40, -38, -36, -34,
-33, -31, -28, -28, -25, -24, -23, -22, -22, -22, -22, -21, -21, -21, -21, -22,
-23, -24, -24, -25, -27, -28, -31, -33, -36, -37, -39, -44, -46, -50, -53, -56,
-58, -61, -63, -66, -69, -71, -72, -74, -76, -78, -80, -81, -84, -85, -88, -89,
-92, -93, -95, -97, -99, -100, -102, -104, -105, -105, -107, -108, -110, -111,
-112, -112, -114, -114, -113, -114, -114, -114, -114, -114, -114, -114, -113,
-113, -111, -110, -109, -108, -105, -104, -103, -101, -99, -98, -96, -95, -94,
-92, -92, -90, -90, -87, -88, -86, -86, -84, -82, -81, -80, -79, -78, -76, -74,
-71, -70, -67, -64, -63, -61, -58, -57, -54, -51, -49, -47, -44, -40, -37, -33,
-30, -25, -20, -15, -11, -5, 0, };