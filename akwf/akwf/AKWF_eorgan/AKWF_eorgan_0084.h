#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0084

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 13, 24, 34, 45, 55, 64, 72, 80, 87,
93, 99, 104, 108, 111, 115, 116, 117, 118, 119, 118, 117, 116, 113, 112, 108,
105, 101, 98, 93, 89, 84, 78, 74, 68, 63, 58, 54, 50, 46, 41, 38, 35, 31, 28,
26, 24, 23, 21, 19, 19, 19, 18, 20, 19, 21, 21, 22, 24, 26, 28, 31, 32, 35, 37,
40, 42, 44, 46, 46, 48, 49, 50, 51, 51, 51, 51, 51, 51, 51, 50, 50, 50, 49, 49,
50, 49, 48, 47, 48, 47, 46, 45, 44, 43, 42, 40, 39, 39, 38, 37, 35, 35, 35, 34,
34, 33, 34, 33, 33, 33, 32, 33, 32, 32, 33, 33, 33, 34, 34, 35, 36, 36, 38, 39,
40, 42, 43, 44, 46, 47, 49, 50, 50, 51, 53, 53, 54, 55, 54, 54, 54, 55, 56, 55,
55, 54, 53, 54, 54, 53, 53, 53, 52, 51, 51, 50, 49, 47, 46, 46, 43, 42, 41, 40,
39, 37, 37, 36, 37, 36, 35, 34, 35, 34, 33, 32, 32, 31, 30, 30, 30, 30, 30, 29,
30, 30, 32, 34, 34, 37, 38, 40, 42, 42, 45, 46, 47, 48, 49, 50, 50, 50, 50, 49,
48, 46, 45, 43, 40, 38, 36, 31, 27, 23, 18, 14, 8, 4, -2, -7, -13, -19, -25,
-33, -38, -45, -50, -55, -60, -65, -71, -75, -79, -82, -85, -86, -88, -89, -90,
-90, -89, -86, -84, -82, -78, -74, -69, -63, -58, -50, -42, -35, -26, -17, -8,
2, 11, 20, 30, 39, 46, 53, 59, 66, 71, 76, 79, 83, 86, 88, 89, 88, 88, 89, 87,
85, 82, 80, 76, 72, 69, 63, 58, 53, 47, 41, 34, 29, 22, 16, 10, 5, -1, -7, -11,
-17, -22, -25, -30, -35, -37, -40, -43, -45, -47, -48, -49, -50, -51, -51, -51,
-51, -50, -48, -48, -46, -46, -43, -42, -39, -38, -36, -35, -34, -32, -32, -31,
-31, -31, -31, -31, -31, -31, -32, -32, -33, -33, -34, -34, -34, -35, -36, -36,
-37, -38, -40, -39, -40, -41, -43, -45, -46, -48, -49, -49, -51, -52, -52, -53,
-54, -54, -54, -54, -55, -54, -55, -55, -55, -55, -55, -56, -55, -54, -54, -54,
-54, -52, -52, -50, -49, -48, -46, -45, -43, -41, -40, -39, -38, -38, -36, -36,
-35, -34, -33, -33, -33, -33, -33, -32, -32, -32, -33, -33, -33, -33, -34, -34,
-35, -34, -35, -36, -37, -38, -39, -40, -42, -43, -44, -45, -46, -47, -47, -47,
-48, -48, -48, -48, -49, -49, -50, -50, -50, -51, -51, -52, -51, -51, -51, -50,
-49, -48, -48, -46, -45, -43, -40, -39, -37, -34, -31, -29, -27, -25, -24, -22,
-21, -20, -19, -18, -18, -19, -19, -20, -21, -22, -24, -26, -29, -31, -35, -39,
-43, -47, -50, -56, -60, -65, -70, -74, -79, -84, -90, -94, -97, -102, -106,
-109, -111, -113, -116, -117, -118, -118, -117, -116, -114, -112, -108, -105,
-99, -95, -89, -82, -76, -67, -59, -49, -40, -29, -18, -7, };