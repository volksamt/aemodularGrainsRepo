#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 8, 11, 13, 15, 16, 19, 21,
24, 25, 27, 30, 32, 33, 35, 37, 39, 42, 43, 44, 46, 48, 50, 51, 53, 55, 57, 57,
58, 61, 62, 63, 65, 67, 67, 69, 71, 71, 72, 73, 74, 76, 77, 78, 79, 81, 82, 82,
84, 85, 86, 86, 87, 89, 90, 91, 92, 92, 94, 94, 96, 97, 98, 99, 99, 100, 101,
102, 102, 104, 105, 105, 106, 106, 107, 108, 109, 109, 109, 110, 111, 111, 112,
112, 112, 113, 114, 115, 114, 115, 115, 116, 116, 116, 117, 117, 118, 117, 118,
117, 118, 119, 119, 119, 119, 119, 118, 120, 119, 120, 119, 119, 119, 118, 118,
119, 118, 118, 118, 118, 117, 118, 118, 117, 116, 117, 116, 115, 116, 115, 114,
115, 114, 114, 113, 113, 112, 112, 111, 110, 110, 109, 110, 109, 108, 107, 106,
105, 104, 104, 104, 103, 102, 102, 100, 100, 99, 98, 97, 96, 96, 95, 93, 92, 92,
90, 89, 89, 88, 87, 86, 85, 84, 83, 82, 81, 80, 79, 78, 77, 75, 75, 74, 72, 72,
70, 70, 68, 67, 66, 65, 64, 63, 61, 60, 58, 57, 56, 54, 53, 51, 50, 50, 48, 46,
46, 44, 43, 41, 40, 38, 37, 36, 34, 33, 32, 31, 28, 27, 26, 24, 24, 21, 20, 18,
18, 17, 15, 13, 13, 11, 10, 9, 8, 6, 6, 5, 3, 2, 1, 0, -1, -3, -4, -4, -7, -6,
-8, -8, -10, -11, -11, -13, -13, -14, -15, -16, -17, -18, -19, -19, -20, -20,
-21, -22, -23, -24, -24, -25, -26, -26, -27, -28, -29, -29, -30, -32, -31, -33,
-34, -35, -35, -37, -37, -38, -38, -40, -40, -41, -42, -43, -44, -45, -46, -46,
-47, -48, -49, -49, -50, -52, -52, -53, -54, -55, -56, -56, -56, -57, -59, -60,
-60, -61, -61, -63, -62, -64, -65, -65, -67, -67, -68, -68, -69, -70, -70, -71,
-73, -74, -73, -75, -75, -75, -77, -77, -77, -79, -79, -80, -81, -82, -82, -83,
-84, -85, -84, -85, -86, -87, -88, -88, -90, -90, -91, -90, -91, -92, -92, -94,
-94, -94, -95, -95, -97, -97, -98, -98, -99, -99, -99, -100, -100, -101, -102,
-103, -102, -103, -104, -104, -105, -105, -105, -106, -106, -107, -107, -108,
-107, -108, -108, -109, -108, -109, -109, -110, -110, -111, -110, -111, -111,
-110, -111, -111, -112, -112, -111, -112, -112, -111, -112, -111, -112, -112,
-111, -112, -111, -111, -111, -111, -110, -110, -110, -110, -110, -110, -109,
-108, -109, -108, -107, -107, -106, -107, -106, -105, -105, -104, -103, -102,
-102, -101, -100, -100, -98, -98, -98, -96, -95, -94, -93, -93, -91, -90, -89,
-88, -88, -86, -85, -83, -83, -81, -81, -78, -77, -76, -74, -73, -72, -71, -68,
-67, -67, -64, -63, -61, -60, -59, -57, -56, -55, -53, -51, -50, -48, -47, -45,
-44, -43, -41, -40, -39, -36, -35, -33, -32, -31, -28, -28, -25, -23, -21, -19,
-17, -15, -13, -10, -9, -6, -4, -2, };