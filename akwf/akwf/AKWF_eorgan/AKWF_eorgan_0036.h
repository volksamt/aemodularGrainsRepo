#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0036

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 7, 10, 14, 17, 20, 23, 27, 30,
34, 37, 39, 39, 36, 32, 25, 18, 11, 5, 3, 2, 3, 6, 9, 14, 18, 23, 26, 31, 35,
38, 42, 45, 48, 49, 47, 43, 39, 34, 28, 25, 23, 23, 24, 28, 33, 36, 42, 46, 51,
55, 57, 60, 62, 64, 64, 66, 66, 68, 69, 71, 72, 74, 75, 77, 79, 80, 81, 82, 82,
83, 83, 84, 84, 83, 81, 76, 68, 50, 29, 5, -17, -35, -46, -50, -52, -49, -45,
-38, -31, -24, -18, -12, -5, 0, 6, 11, 16, 21, 24, 30, 34, 38, 42, 46, 51, 54,
58, 61, 65, 68, 71, 73, 75, 75, 75, 75, 73, 72, 69, 65, 59, 52, 44, 37, 31, 26,
24, 25, 26, 29, 32, 36, 39, 43, 46, 48, 52, 53, 55, 55, 53, 51, 48, 44, 40, 38,
36, 36, 38, 40, 43, 46, 48, 49, 52, 55, 58, 61, 63, 65, 66, 68, 69, 71, 72, 74,
75, 77, 79, 81, 84, 85, 87, 90, 92, 93, 94, 93, 89, 82, 73, 65, 56, 49, 44, 42,
41, 42, 44, 47, 50, 53, 56, 57, 60, 62, 63, 66, 67, 69, 70, 71, 71, 66, 59, 46,
31, 15, 1, -12, -18, -22, -22, -21, -18, -13, -9, -5, -2, 1, 3, 6, 7, 10, 11,
13, 15, 18, 20, 22, 24, 26, 29, 30, 33, 35, 37, 37, 40, 42, 43, 43, 44, 43, 41,
38, 35, 29, 22, 13, 4, -6, -14, -19, -22, -24, -24, -21, -18, -15, -13, -11, -7,
-6, -4, -1, 0, -1, -4, -9, -16, -22, -28, -33, -36, -36, -35, -32, -29, -28,
-28, -31, -36, -40, -46, -50, -53, -55, -56, -58, -61, -64, -68, -72, -75, -76,
-77, -75, -75, -72, -68, -65, -61, -56, -52, -48, -45, -43, -40, -38, -35, -33,
-31, -30, -28, -26, -23, -19, -19, -17, -15, -15, -14, -12, -11, -10, -9, -7,
-6, -7, -6, -7, -6, -5, -5, -4, -4, -3, -2, 0, 1, 2, 4, 5, 6, 7, 9, 10, 11, 12,
13, 14, 16, 17, 17, 17, 18, 20, 20, 20, 21, 21, 22, 22, 23, 23, 24, 23, 23, 23,
23, 22, 22, 21, 19, 15, 8, 1, -6, -15, -22, -29, -34, -41, -47, -55, -59, -65,
-68, -70, -70, -70, -67, -64, -64, -64, -66, -70, -73, -75, -77, -81, -81, -82,
-80, -79, -77, -73, -70, -68, -64, -63, -62, -60, -59, -58, -57, -58, -60, -65,
-70, -78, -86, -93, -98, -101, -102, -100, -97, -95, -92, -89, -85, -82, -79,
-77, -76, -75, -73, -72, -71, -69, -66, -64, -62, -60, -57, -54, -51, -49, -46,
-44, -41, -38, -35, -33, -31, -31, -32, -37, -46, -60, -75, -91, -104, -113,
-117, -119, -118, -114, -109, -103, -97, -91, -84, -78, -73, -69, -63, -57, -53,
-49, -45, -40, -39, -40, -42, -46, -50, -52, -54, -54, -52, -49, -44, -39, -33,
-28, -24, -21, -18, -17, -16, -14, -13, -11, -9, -7, -3, -1, };