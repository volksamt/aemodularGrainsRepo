#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0083

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 14, 25, 35, 46, 55, 64, 73, 80, 87,
94, 99, 105, 109, 111, 114, 117, 119, 119, 119, 119, 117, 116, 113, 111, 108,
105, 101, 96, 92, 87, 82, 77, 71, 67, 63, 58, 54, 50, 46, 44, 42, 38, 36, 35,
33, 32, 32, 32, 30, 31, 32, 32, 34, 35, 37, 38, 40, 42, 45, 47, 51, 52, 56, 58,
60, 63, 65, 67, 69, 69, 70, 70, 71, 70, 70, 70, 68, 67, 65, 64, 63, 60, 59, 57,
56, 54, 53, 50, 49, 47, 45, 43, 41, 38, 35, 33, 32, 30, 28, 26, 25, 24, 24, 23,
23, 22, 22, 21, 21, 21, 22, 21, 23, 22, 24, 24, 25, 27, 29, 30, 32, 33, 37, 39,
41, 44, 46, 50, 53, 56, 59, 61, 64, 66, 69, 70, 71, 73, 75, 75, 76, 76, 76, 78,
77, 78, 77, 77, 76, 77, 75, 75, 74, 74, 72, 71, 69, 68, 65, 63, 60, 59, 56, 53,
52, 49, 46, 45, 42, 40, 39, 37, 35, 33, 31, 30, 27, 27, 24, 23, 22, 21, 21, 19,
20, 21, 21, 22, 23, 25, 27, 29, 31, 33, 35, 37, 39, 39, 41, 42, 43, 44, 44, 45,
44, 44, 44, 42, 41, 38, 37, 34, 30, 27, 24, 20, 15, 10, 5, 0, -6, -12, -18, -23,
-30, -36, -43, -48, -54, -60, -65, -68, -73, -76, -79, -82, -84, -86, -86, -86,
-86, -85, -83, -80, -76, -73, -68, -63, -57, -49, -43, -35, -26, -18, -8, 2, 11,
21, 29, 36, 45, 51, 58, 63, 70, 74, 78, 80, 84, 84, 86, 87, 86, 85, 83, 81, 77,
74, 70, 66, 61, 57, 52, 45, 40, 34, 27, 21, 14, 7, 3, -4, -9, -14, -18, -23,
-26, -30, -33, -36, -39, -41, -42, -44, -44, -45, -46, -46, -45, -45, -45, -43,
-41, -40, -40, -38, -34, -34, -30, -29, -26, -25, -24, -23, -21, -21, -21, -21,
-21, -21, -24, -24, -25, -27, -29, -30, -32, -35, -36, -38, -40, -42, -44, -47,
-48, -50, -53, -55, -57, -60, -62, -64, -67, -69, -70, -72, -73, -74, -76, -76,
-77, -77, -78, -78, -78, -78, -77, -77, -77, -77, -76, -75, -74, -73, -70, -69,
-68, -66, -63, -61, -58, -56, -52, -49, -45, -42, -39, -38, -34, -33, -30, -29,
-27, -26, -24, -24, -23, -22, -21, -21, -22, -22, -22, -22, -22, -22, -23, -23,
-23, -25, -26, -27, -30, -31, -33, -35, -38, -39, -42, -44, -45, -48, -49, -51,
-53, -54, -56, -58, -59, -62, -64, -65, -65, -67, -69, -69, -70, -70, -70, -70,
-70, -69, -68, -66, -64, -62, -59, -56, -54, -51, -48, -46, -43, -41, -39, -36,
-35, -34, -33, -32, -31, -31, -30, -31, -31, -32, -33, -35, -37, -39, -41, -45,
-47, -51, -54, -58, -63, -68, -72, -77, -82, -88, -92, -96, -101, -104, -107,
-110, -114, -114, -116, -117, -117, -117, -116, -115, -112, -109, -105, -100,
-95, -89, -83, -75, -68, -58, -49, -40, -29, -18, -7, };