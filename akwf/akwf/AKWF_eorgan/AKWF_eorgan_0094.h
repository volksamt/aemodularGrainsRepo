#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0094

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 11, 14, 19, 24, 27, 30, 34, 39,
43, 46, 50, 53, 56, 60, 63, 66, 69, 72, 75, 77, 80, 83, 85, 87, 89, 91, 94, 95,
96, 99, 101, 102, 103, 105, 105, 107, 108, 108, 109, 110, 111, 112, 112, 113,
114, 115, 116, 116, 116, 116, 118, 117, 117, 117, 118, 118, 118, 119, 119, 119,
119, 120, 120, 119, 119, 119, 119, 118, 118, 118, 119, 118, 118, 118, 118, 117,
116, 116, 116, 116, 115, 113, 113, 113, 112, 112, 111, 110, 109, 108, 108, 107,
106, 105, 104, 103, 103, 102, 101, 100, 99, 98, 97, 96, 95, 94, 93, 92, 91, 90,
89, 88, 87, 86, 85, 84, 82, 82, 81, 80, 78, 77, 77, 75, 75, 74, 72, 72, 70, 70,
69, 68, 67, 66, 65, 63, 62, 62, 62, 60, 59, 58, 57, 56, 55, 54, 54, 52, 51, 50,
49, 48, 47, 47, 46, 45, 44, 43, 42, 41, 40, 40, 38, 38, 36, 35, 35, 33, 33, 32,
32, 31, 30, 29, 29, 28, 27, 26, 26, 25, 24, 23, 23, 22, 21, 20, 20, 19, 18, 18,
17, 16, 15, 15, 14, 13, 12, 12, 10, 9, 9, 8, 7, 6, 5, 4, 2, 2, 0, 0, -1, -2, -3,
-3, -4, -6, -6, -7, -8, -9, -9, -10, -11, -11, -12, -13, -13, -14, -13, -13,
-15, -14, -14, -14, -14, -14, -14, -13, -13, -12, -12, -12, -10, -11, -9, -9,
-8, -7, -6, -5, -5, -3, -3, -1, -1, 0, 2, 3, 4, 6, 5, 6, 7, 7, 9, 9, 10, 11, 11,
12, 13, 13, 13, 13, 13, 13, 14, 14, 13, 13, 13, 12, 13, 11, 11, 11, 10, 9, 8, 8,
7, 6, 6, 3, 3, 3, 1, 0, 0, -1, -2, -3, -4, -6, -6, -7, -8, -9, -9, -11, -11,
-12, -13, -14, -15, -15, -16, -17, -19, -20, -20, -21, -21, -22, -22, -24, -24,
-24, -26, -26, -27, -28, -28, -29, -30, -31, -32, -33, -33, -33, -35, -36, -37,
-37, -38, -39, -39, -41, -41, -42, -44, -45, -44, -45, -46, -48, -49, -49, -51,
-52, -53, -54, -55, -55, -57, -58, -59, -60, -61, -61, -62, -63, -64, -65, -67,
-67, -68, -69, -70, -71, -72, -73, -73, -74, -76, -77, -78, -79, -80, -81, -82,
-83, -83, -85, -86, -87, -88, -89, -90, -90, -91, -93, -94, -94, -95, -97, -97,
-98, -99, -101, -102, -102, -103, -105, -105, -106, -107, -107, -108, -110,
-110, -111, -111, -112, -112, -113, -113, -114, -115, -115, -115, -116, -117,
-117, -117, -117, -117, -117, -118, -118, -118, -118, -119, -118, -118, -118,
-118, -118, -119, -118, -117, -117, -117, -116, -116, -117, -117, -116, -116,
-116, -115, -114, -114, -113, -113, -112, -111, -110, -109, -108, -108, -107,
-105, -104, -103, -102, -100, -99, -98, -95, -94, -92, -90, -87, -86, -83, -81,
-79, -77, -74, -71, -68, -66, -61, -59, -56, -53, -49, -46, -42, -39, -33, -30,
-26, -22, -18, -14, -10, -6, -1, };