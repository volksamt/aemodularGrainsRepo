#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0064

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 13, 16, 20, 23, 26, 28, 32,
34, 38, 39, 43, 44, 47, 49, 50, 52, 53, 54, 55, 57, 56, 57, 58, 58, 58, 58, 58,
58, 58, 57, 57, 57, 57, 57, 56, 56, 56, 56, 57, 58, 57, 57, 58, 58, 60, 61, 62,
64, 64, 66, 68, 70, 72, 73, 75, 77, 79, 81, 84, 86, 88, 91, 92, 95, 97, 99, 101,
102, 105, 106, 108, 109, 111, 111, 112, 113, 114, 115, 115, 115, 114, 115, 114,
114, 113, 112, 112, 110, 109, 108, 107, 105, 103, 103, 100, 99, 98, 96, 95, 94,
93, 91, 91, 90, 89, 89, 89, 89, 88, 88, 88, 88, 89, 89, 91, 91, 93, 94, 95, 96,
97, 99, 101, 102, 103, 106, 107, 109, 110, 112, 112, 115, 114, 116, 116, 118,
119, 119, 119, 119, 119, 118, 117, 117, 116, 114, 114, 112, 110, 109, 107, 105,
104, 101, 99, 96, 94, 91, 90, 87, 84, 83, 80, 77, 75, 72, 72, 70, 68, 65, 64,
62, 61, 61, 58, 59, 58, 57, 56, 56, 56, 57, 57, 57, 57, 57, 58, 58, 59, 59, 60,
60, 61, 60, 60, 62, 60, 61, 61, 60, 60, 59, 60, 58, 57, 56, 56, 53, 51, 51, 49,
46, 45, 42, 41, 38, 35, 34, 30, 28, 25, 22, 21, 17, 15, 13, 10, 8, 6, 4, 2, 1,
-2, -3, -4, -5, -6, -7, -8, -8, -9, -8, -8, -8, -8, -8, -7, -6, -6, -4, -3, -3,
-2, 0, 0, 1, 2, 3, 5, 5, 6, 6, 7, 6, 6, 7, 6, 6, 5, 6, 4, 3, 3, 1, -1, -3, -4,
-6, -8, -11, -13, -15, -17, -20, -22, -26, -28, -30, -33, -36, -38, -41, -42,
-45, -47, -49, -51, -53, -53, -56, -57, -58, -60, -60, -61, -61, -62, -63, -62,
-63, -62, -62, -62, -61, -62, -61, -61, -60, -60, -59, -59, -59, -59, -58, -58,
-58, -57, -58, -58, -58, -60, -60, -61, -63, -63, -64, -66, -67, -70, -71, -72,
-75, -77, -79, -82, -85, -86, -89, -91, -93, -96, -98, -101, -103, -105, -107,
-108, -111, -112, -114, -115, -116, -117, -118, -119, -118, -119, -119, -119,
-118, -118, -118, -117, -116, -115, -114, -112, -111, -110, -108, -107, -105,
-104, -102, -101, -99, -97, -95, -95, -93, -92, -91, -90, -90, -89, -88, -89,
-88, -88, -88, -88, -89, -89, -90, -91, -92, -92, -94, -95, -97, -98, -99, -101,
-102, -104, -105, -106, -108, -109, -109, -111, -112, -112, -112, -114, -114,
-114, -114, -114, -114, -114, -111, -111, -110, -110, -107, -107, -104, -103,
-101, -100, -97, -95, -93, -90, -88, -86, -83, -81, -78, -76, -75, -72, -71,
-69, -66, -65, -64, -62, -61, -59, -59, -58, -58, -56, -56, -54, -55, -55, -55,
-55, -55, -55, -55, -54, -55, -56, -56, -56, -56, -56, -55, -55, -56, -55, -55,
-54, -54, -52, -52, -50, -49, -48, -46, -44, -41, -39, -37, -34, -31, -29, -25,
-22, -19, -16, -12, -8, -5, -1, };