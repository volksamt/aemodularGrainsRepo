#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 10, 12, 14, 17, 19, 23, 26,
28, 30, 33, 35, 38, 40, 43, 45, 47, 50, 53, 56, 57, 59, 62, 64, 67, 68, 71, 73,
74, 76, 79, 80, 83, 84, 86, 88, 90, 91, 93, 95, 96, 99, 99, 101, 102, 103, 105,
106, 107, 108, 110, 110, 112, 112, 113, 114, 115, 115, 116, 116, 117, 117, 118,
118, 118, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 117, 118, 117, 117,
116, 116, 115, 114, 114, 113, 112, 111, 111, 109, 108, 107, 105, 105, 103, 102,
101, 99, 98, 97, 96, 94, 92, 91, 89, 87, 86, 84, 82, 81, 79, 78, 75, 75, 71, 70,
68, 66, 64, 63, 60, 58, 57, 54, 52, 50, 48, 46, 45, 42, 39, 38, 36, 34, 31, 30,
27, 26, 24, 21, 19, 18, 14, 13, 12, 9, 8, 5, 4, 2, 0, -2, -5, -6, -7, -9, -11,
-13, -15, -16, -18, -19, -21, -23, -24, -26, -26, -28, -30, -32, -32, -34, -34,
-36, -37, -38, -39, -40, -42, -42, -44, -44, -45, -44, -46, -47, -48, -48, -49,
-48, -49, -49, -50, -50, -50, -50, -51, -51, -51, -51, -52, -51, -51, -51, -51,
-50, -50, -50, -50, -50, -50, -49, -49, -48, -47, -47, -46, -45, -44, -43, -42,
-42, -41, -40, -39, -38, -37, -36, -36, -33, -33, -32, -31, -29, -29, -27, -26,
-25, -24, -22, -21, -19, -18, -17, -15, -14, -13, -11, -10, -8, -7, -6, -4, -3,
-2, 0, 3, 4, 4, 6, 7, 9, 10, 12, 13, 14, 16, 16, 18, 20, 21, 23, 23, 25, 26, 28,
28, 29, 31, 32, 33, 34, 35, 36, 37, 38, 38, 40, 41, 42, 43, 43, 45, 44, 45, 46,
46, 47, 48, 47, 48, 48, 49, 49, 50, 50, 49, 50, 51, 51, 50, 50, 51, 50, 50, 50,
50, 49, 49, 49, 48, 47, 46, 46, 46, 45, 45, 44, 43, 43, 42, 40, 39, 38, 38, 37,
35, 34, 33, 32, 30, 29, 28, 26, 26, 24, 22, 21, 19, 17, 16, 15, 13, 11, 9, 7, 6,
4, 3, 1, -1, -4, -6, -7, -9, -10, -13, -15, -16, -19, -21, -23, -25, -27, -29,
-31, -33, -35, -37, -39, -41, -44, -46, -47, -50, -52, -53, -55, -58, -60, -62,
-63, -65, -66, -69, -71, -72, -74, -77, -79, -80, -81, -83, -84, -87, -88, -90,
-91, -92, -94, -96, -97, -98, -99, -101, -102, -104, -104, -106, -106, -107,
-109, -110, -110, -111, -113, -113, -114, -114, -115, -115, -116, -116, -116,
-117, -118, -117, -118, -118, -118, -118, -118, -117, -117, -117, -117, -116,
-117, -116, -116, -115, -114, -113, -114, -112, -111, -110, -109, -109, -107,
-106, -106, -104, -103, -102, -101, -100, -98, -96, -95, -92, -91, -89, -87,
-87, -85, -83, -81, -79, -76, -75, -73, -70, -69, -66, -64, -62, -60, -58, -55,
-53, -51, -48, -46, -43, -41, -38, -36, -33, -31, -28, -26, -23, -21, -18, -14,
-12, -10, -7, -4, -2, };