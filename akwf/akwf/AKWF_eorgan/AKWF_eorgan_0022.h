#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 3, 5, 7, 8, 10, 12, 13, 16, 16,
19, 21, 22, 25, 27, 28, 30, 33, 36, 36, 38, 44, 43, 45, 49, 50, 52, 55, 58, 60,
62, 64, 66, 69, 70, 73, 75, 77, 79, 81, 83, 85, 87, 89, 91, 93, 95, 97, 99, 100,
101, 104, 105, 106, 107, 109, 110, 111, 112, 113, 114, 115, 115, 116, 116, 117,
118, 118, 118, 119, 119, 120, 119, 119, 119, 118, 118, 117, 118, 117, 117, 116,
115, 115, 113, 112, 111, 111, 109, 109, 107, 106, 105, 104, 102, 100, 99, 97,
95, 94, 93, 92, 89, 88, 86, 84, 82, 81, 79, 77, 75, 74, 72, 70, 68, 67, 65, 63,
60, 59, 58, 55, 55, 52, 50, 48, 47, 45, 43, 42, 40, 39, 37, 36, 33, 32, 30, 29,
27, 26, 25, 23, 22, 21, 18, 17, 16, 15, 14, 13, 11, 10, 8, 7, 6, 5, 3, 3, 0, 0,
-1, -3, -4, -5, -6, -8, -9, -10, -10, -12, -14, -15, -16, -17, -18, -19, -21,
-22, -23, -25, -26, -27, -29, -30, -32, -34, -34, -36, -38, -40, -40, -42, -43,
-45, -47, -48, -49, -50, -52, -54, -56, -58, -59, -61, -62, -63, -65, -66, -68,
-70, -71, -73, -75, -75, -77, -79, -80, -82, -84, -84, -85, -87, -89, -90, -91,
-92, -93, -94, -96, -96, -97, -98, -99, -100, -101, -102, -103, -103, -104,
-103, -104, -105, -105, -105, -105, -105, -105, -105, -105, -105, -105, -104,
-103, -103, -103, -102, -102, -101, -99, -99, -98, -97, -96, -95, -93, -92, -92,
-89, -88, -87, -85, -83, -82, -80, -79, -76, -74, -75, -70, -69, -68, -65, -64,
-62, -60, -57, -55, -54, -52, -48, -47, -46, -43, -41, -39, -37, -35, -33, -32,
-28, -27, -26, -24, -22, -20, -18, -16, -15, -13, -11, -10, -9, -8, -6, -5, -3,
-2, -1, 1, 1, 2, 3, 5, 5, 6, 6, 8, 7, 8, 8, 10, 10, 11, 10, 10, 11, 11, 11, 11,
11, 10, 11, 11, 10, 10, 10, 8, 10, 8, 8, 7, 7, 7, 6, 6, 5, 4, 3, 3, 3, 2, 1, 0,
0, -2, -1, -2, -4, -4, -4, -5, -5, -6, -8, -7, -8, -9, -9, -10, -10, -11, -11,
-11, -12, -12, -12, -14, -13, -14, -14, -14, -14, -15, -14, -15, -15, -15, -14,
-14, -15, -14, -15, -15, -15, -15, -14, -14, -13, -14, -14, -14, -13, -13, -13,
-12, -12, -12, -12, -11, -11, -11, -11, -11, -10, -10, -10, -9, -9, -8, -9, -8,
-8, -9, -8, -8, -8, -7, -8, -7, -8, -8, -8, -8, -8, -7, -8, -7, -8, -8, -8, -8,
-8, -10, -9, -10, -9, -10, -10, -11, -10, -11, -11, -12, -11, -12, -12, -13,
-13, -13, -14, -14, -14, -14, -14, -15, -15, -15, -15, -15, -16, -16, -17, -16,
-16, -16, -15, -16, -16, -15, -16, -15, -16, -14, -14, -14, -14, -13, -12, -11,
-11, -10, -10, -9, -8, -7, -6, -4, -3, -3, -1, 0, };