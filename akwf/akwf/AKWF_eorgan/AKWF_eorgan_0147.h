#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0147

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 12, 16, 20, 24, 28, 35, 39,
44, 50, 55, 59, 64, 70, 75, 79, 84, 89, 93, 96, 99, 103, 106, 108, 110, 112,
115, 117, 117, 118, 118, 119, 119, 119, 119, 118, 117, 117, 117, 115, 114, 112,
111, 110, 108, 106, 105, 103, 100, 99, 96, 94, 92, 89, 88, 85, 84, 81, 80, 78,
77, 76, 75, 74, 73, 72, 72, 72, 72, 71, 72, 73, 72, 74, 74, 74, 75, 76, 76, 77,
76, 77, 76, 76, 75, 75, 74, 72, 71, 69, 67, 66, 64, 61, 59, 57, 54, 52, 49, 46,
43, 41, 39, 35, 32, 30, 28, 24, 21, 19, 16, 14, 12, 9, 7, 5, 3, 1, -1, -3, -4,
-5, -7, -7, -7, -7, -6, -7, -6, -5, -4, -3, -1, 1, 3, 5, 8, 11, 13, 16, 18, 21,
23, 26, 28, 29, 32, 34, 35, 37, 37, 37, 39, 40, 39, 39, 40, 40, 39, 38, 38, 36,
36, 35, 34, 32, 32, 31, 29, 29, 26, 26, 24, 22, 22, 19, 18, 17, 16, 14, 12, 11,
10, 9, 8, 7, 6, 5, 4, 4, 4, 4, 5, 4, 6, 6, 7, 8, 9, 10, 12, 14, 15, 16, 16, 18,
19, 19, 20, 20, 20, 20, 20, 20, 18, 17, 15, 15, 13, 10, 8, 7, 3, 1, -2, -4, -7,
-10, -14, -16, -19, -22, -26, -28, -31, -35, -38, -40, -43, -45, -48, -52, -55,
-57, -59, -61, -63, -66, -66, -69, -69, -70, -72, -72, -72, -71, -71, -70, -68,
-69, -66, -65, -63, -62, -59, -56, -54, -53, -50, -47, -45, -44, -41, -40, -38,
-38, -37, -36, -35, -35, -35, -36, -35, -36, -37, -39, -40, -41, -43, -44, -46,
-48, -50, -52, -54, -57, -60, -62, -63, -67, -69, -71, -75, -77, -79, -81, -84,
-86, -88, -90, -93, -94, -96, -97, -98, -100, -100, -101, -101, -101, -101,
-101, -100, -98, -98, -96, -94, -93, -90, -88, -86, -84, -82, -80, -77, -75,
-74, -71, -68, -67, -66, -64, -63, -61, -61, -59, -59, -58, -59, -57, -56, -57,
-57, -58, -57, -57, -58, -58, -57, -58, -58, -57, -58, -58, -58, -58, -58, -59,
-59, -59, -59, -59, -58, -58, -58, -57, -56, -56, -55, -53, -52, -51, -49, -47,
-44, -42, -39, -37, -34, -30, -27, -23, -20, -16, -12, -9, -5, -2, 2, 5, 8, 11,
13, 15, 17, 19, 20, 22, 23, 23, 23, 25, 24, 24, 24, 24, 22, 21, 20, 19, 18, 17,
15, 13, 13, 10, 8, 7, 4, 4, 0, -1, -2, -5, -7, -8, -10, -11, -12, -14, -16, -18,
-18, -20, -19, -21, -20, -21, -21, -21, -20, -19, -18, -17, -15, -14, -12, -11,
-9, -7, -6, -5, -3, -1, -1, 1, 1, 3, 3, 3, 4, 4, 3, 3, 3, 3, 2, 1, -1, -1, -2,
-3, -5, -5, -6, -7, -8, -9, -9, -11, -12, -12, -13, -14, -14, -14, -14, -14,
-14, -14, -13, -13, -12, -11, -10, -8, -7, -5, -3, 0, };