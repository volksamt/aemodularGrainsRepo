#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0136

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 8, 13, 16, 22, 26, 31, 35, 39,
43, 48, 52, 57, 60, 64, 69, 73, 77, 81, 85, 88, 91, 94, 97, 101, 103, 105, 108,
110, 112, 113, 115, 116, 117, 119, 118, 118, 120, 119, 119, 118, 117, 116, 115,
114, 112, 111, 109, 107, 105, 103, 100, 97, 94, 91, 88, 84, 81, 78, 74, 72, 67,
65, 60, 58, 54, 51, 47, 43, 40, 36, 33, 29, 26, 23, 20, 17, 13, 10, 7, 5, 2, 0,
-3, -5, -7, -10, -13, -14, -16, -18, -20, -21, -23, -24, -26, -28, -29, -30,
-31, -34, -35, -35, -37, -37, -39, -39, -41, -42, -43, -43, -44, -46, -46, -48,
-49, -50, -50, -51, -53, -54, -55, -56, -57, -59, -59, -60, -62, -63, -63, -64,
-65, -67, -68, -69, -70, -71, -72, -73, -73, -74, -75, -75, -76, -76, -77, -77,
-77, -77, -77, -77, -77, -76, -76, -76, -75, -75, -74, -72, -71, -70, -70, -68,
-67, -64, -64, -61, -60, -58, -56, -54, -52, -49, -47, -45, -43, -41, -39, -36,
-35, -32, -30, -28, -25, -23, -22, -20, -17, -16, -14, -13, -11, -9, -8, -7, -6,
-5, -4, -3, -2, -2, 0, 0, -1, 0, 1, 0, 0, 0, -1, -1, -2, -2, -3, -4, -4, -5, -6,
-7, -8, -9, -10, -11, -12, -13, -14, -15, -15, -17, -18, -19, -19, -20, -20,
-20, -21, -20, -21, -22, -21, -21, -20, -19, -19, -18, -18, -16, -16, -13, -13,
-11, -10, -8, -6, -5, -3, 0, 2, 4, 6, 9, 11, 14, 16, 18, 21, 23, 26, 27, 30, 32,
36, 37, 40, 42, 44, 46, 48, 49, 50, 52, 54, 56, 57, 58, 58, 59, 58, 60, 60, 61,
59, 60, 60, 59, 59, 57, 56, 55, 54, 52, 51, 49, 48, 47, 45, 43, 41, 39, 36, 36,
34, 31, 29, 27, 25, 22, 21, 18, 15, 14, 13, 11, 9, 7, 6, 4, 2, 1, 1, -1, -2, -2,
-3, -4, -5, -5, -5, -6, -6, -5, -6, -5, -5, -4, -4, -3, -2, -2, -1, 1, 1, 2, 3,
5, 6, 7, 7, 8, 9, 11, 12, 13, 14, 15, 16, 16, 17, 18, 18, 19, 20, 19, 20, 19,
20, 21, 20, 20, 20, 20, 19, 19, 19, 19, 17, 17, 15, 14, 15, 13, 13, 11, 10, 8,
7, 6, 5, 3, 2, 2, 0, -1, -2, -3, -5, -6, -8, -8, -10, -10, -12, -13, -12, -14,
-14, -16, -16, -17, -17, -17, -18, -18, -19, -19, -19, -20, -19, -20, -20, -20,
-20, -20, -20, -19, -20, -20, -20, -20, -21, -20, -20, -20, -20, -21, -22, -21,
-22, -22, -22, -23, -23, -24, -25, -26, -26, -27, -28, -29, -29, -31, -31, -33,
-34, -35, -37, -37, -38, -40, -41, -42, -43, -45, -45, -47, -47, -49, -48, -50,
-51, -52, -52, -52, -52, -53, -53, -52, -52, -52, -52, -51, -50, -48, -47, -47,
-45, -43, -41, -40, -37, -35, -33, -29, -27, -23, -20, -18, -13, -10, -6, -3, };