#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0100

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 13, 25, 34, 44, 53, 62, 69, 76, 80,
86, 88, 90, 92, 92, 92, 91, 89, 88, 86, 84, 80, 79, 76, 75, 72, 71, 69, 67, 66,
65, 63, 62, 59, 58, 57, 56, 55, 52, 51, 49, 47, 44, 43, 42, 39, 37, 35, 34, 32,
30, 29, 29, 29, 29, 29, 30, 32, 33, 34, 37, 40, 43, 45, 48, 51, 55, 58, 60, 63,
66, 68, 70, 73, 73, 76, 76, 78, 78, 78, 78, 78, 79, 78, 78, 77, 78, 78, 77, 77,
78, 77, 77, 76, 77, 75, 75, 75, 74, 73, 71, 69, 68, 65, 63, 60, 57, 53, 50, 46,
43, 39, 35, 32, 30, 28, 27, 26, 26, 28, 29, 33, 37, 42, 47, 52, 60, 67, 73, 82,
89, 95, 100, 105, 110, 114, 116, 117, 119, 119, 118, 116, 114, 110, 108, 104,
99, 96, 91, 87, 84, 80, 77, 74, 72, 69, 67, 65, 63, 62, 60, 60, 59, 58, 57, 56,
55, 54, 54, 53, 52, 51, 50, 49, 48, 47, 46, 46, 45, 45, 45, 45, 45, 46, 46, 49,
50, 51, 52, 55, 57, 58, 61, 62, 64, 66, 66, 68, 68, 68, 68, 68, 66, 65, 64, 61,
59, 56, 53, 50, 47, 44, 40, 36, 33, 29, 26, 22, 19, 15, 12, 9, 7, 3, 0, -2, -6,
-9, -12, -17, -19, -23, -27, -30, -35, -39, -44, -48, -51, -55, -58, -62, -63,
-65, -64, -64, -63, -60, -57, -53, -48, -40, -33, -25, -17, -9, 2, 11, 19, 27,
35, 42, 48, 53, 57, 60, 63, 63, 63, 63, 61, 58, 57, 52, 49, 45, 41, 36, 33, 28,
24, 20, 17, 13, 10, 7, 4, 0, -3, -5, -9, -12, -15, -18, -21, -25, -29, -32, -36,
-39, -42, -46, -50, -53, -55, -59, -61, -64, -65, -66, -68, -69, -70, -70, -69,
-69, -68, -66, -65, -62, -61, -58, -57, -55, -53, -51, -50, -48, -47, -47, -46,
-45, -46, -46, -46, -46, -48, -48, -49, -49, -51, -53, -52, -54, -55, -56, -56,
-58, -58, -59, -60, -62, -62, -64, -65, -66, -68, -70, -73, -75, -79, -82, -86,
-89, -93, -98, -101, -105, -109, -112, -114, -118, -118, -119, -118, -118, -116,
-112, -109, -103, -98, -91, -85, -79, -71, -64, -58, -51, -45, -40, -35, -31,
-29, -26, -25, -25, -26, -28, -31, -33, -36, -40, -43, -48, -50, -55, -57, -61,
-64, -67, -68, -69, -72, -73, -73, -75, -74, -75, -76, -77, -76, -77, -77, -76,
-76, -77, -77, -77, -77, -78, -78, -77, -78, -77, -77, -76, -76, -74, -73, -71,
-70, -67, -65, -61, -58, -56, -52, -50, -46, -43, -41, -38, -36, -33, -31, -30,
-29, -28, -28, -28, -29, -29, -30, -32, -33, -35, -37, -39, -41, -42, -45, -47,
-48, -51, -52, -53, -55, -57, -58, -59, -60, -63, -63, -65, -67, -68, -70, -72,
-74, -76, -78, -80, -82, -85, -86, -89, -89, -90, -90, -89, -87, -85, -81, -76,
-72, -64, -57, -49, -38, -29, -18, -7, };