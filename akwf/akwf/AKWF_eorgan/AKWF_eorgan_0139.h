#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0139

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 17, 24, 31, 37, 43, 49, 54, 59,
64, 67, 71, 74, 77, 79, 81, 83, 83, 84, 83, 83, 82, 80, 79, 77, 74, 72, 69, 65,
61, 58, 55, 51, 46, 42, 38, 34, 30, 25, 21, 18, 14, 9, 7, 3, 0, -1, -5, -7, -8,
-10, -10, -11, -11, -12, -11, -12, -10, -9, -8, -7, -5, -4, -2, 1, 2, 5, 8, 10,
12, 15, 17, 20, 23, 25, 27, 30, 33, 35, 37, 39, 40, 41, 44, 44, 45, 46, 47, 47,
47, 47, 47, 46, 45, 44, 43, 41, 40, 39, 37, 35, 34, 33, 32, 30, 28, 27, 27, 25,
26, 26, 26, 26, 27, 28, 30, 30, 32, 35, 38, 40, 42, 45, 49, 52, 55, 58, 61, 64,
67, 70, 73, 75, 78, 79, 82, 83, 85, 85, 87, 87, 88, 89, 88, 88, 87, 86, 86, 84,
83, 81, 80, 78, 76, 74, 73, 70, 68, 66, 63, 62, 59, 57, 55, 54, 51, 49, 48, 47,
45, 45, 43, 43, 43, 41, 42, 41, 41, 42, 41, 43, 43, 44, 45, 46, 47, 49, 50, 51,
52, 53, 54, 54, 56, 57, 57, 58, 58, 58, 57, 58, 57, 56, 56, 54, 53, 53, 51, 49,
46, 45, 42, 40, 38, 35, 32, 29, 26, 23, 19, 16, 12, 9, 6, 2, -1, -5, -7, -9,
-12, -15, -17, -18, -20, -20, -20, -20, -19, -18, -16, -15, -11, -8, -5, 0, 4,
10, 14, 20, 25, 31, 38, 44, 50, 57, 62, 68, 74, 80, 86, 90, 95, 100, 104, 107,
111, 113, 116, 117, 117, 118, 120, 119, 118, 116, 115, 113, 111, 108, 104, 100,
96, 91, 87, 82, 77, 70, 65, 58, 52, 47, 41, 35, 28, 23, 17, 11, 5, 0, -5, -10,
-15, -19, -23, -27, -31, -34, -37, -40, -43, -44, -46, -47, -48, -50, -50, -51,
-51, -51, -51, -50, -50, -49, -48, -48, -47, -46, -45, -44, -43, -42, -42, -41,
-41, -40, -40, -40, -38, -39, -39, -40, -41, -41, -41, -42, -43, -45, -47, -49,
-51, -54, -57, -59, -61, -64, -68, -69, -72, -76, -77, -80, -82, -84, -86, -87,
-90, -90, -91, -91, -91, -92, -91, -89, -88, -88, -85, -83, -82, -79, -77, -74,
-71, -69, -67, -64, -61, -60, -57, -56, -54, -52, -50, -49, -48, -47, -46, -46,
-46, -46, -46, -46, -48, -49, -49, -50, -52, -53, -55, -57, -59, -60, -63, -64,
-67, -69, -70, -73, -75, -77, -78, -79, -81, -83, -84, -85, -86, -87, -87, -87,
-87, -87, -87, -87, -86, -85, -84, -83, -83, -80, -79, -77, -75, -74, -72, -70,
-68, -67, -64, -63, -62, -61, -59, -58, -57, -56, -56, -55, -54, -54, -55, -55,
-55, -55, -57, -57, -58, -60, -61, -62, -64, -66, -68, -70, -72, -75, -77, -79,
-81, -84, -88, -89, -91, -94, -95, -97, -99, -100, -100, -101, -102, -100, -100,
-100, -97, -95, -93, -88, -85, -81, -76, -71, -65, -59, -53, -47, -39, -32, -25,
-18, -11, -3, };