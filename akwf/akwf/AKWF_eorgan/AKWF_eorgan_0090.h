#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0090

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 17, 21, 28, 32, 36, 41, 46,
49, 54, 59, 61, 66, 70, 72, 77, 80, 83, 86, 90, 92, 95, 96, 99, 102, 104, 105,
108, 109, 110, 113, 114, 115, 116, 117, 117, 117, 119, 119, 120, 119, 119, 119,
118, 118, 118, 117, 117, 115, 114, 114, 113, 111, 110, 108, 106, 105, 103, 100,
100, 98, 95, 93, 91, 89, 86, 85, 82, 80, 78, 76, 75, 72, 70, 69, 68, 65, 64, 62,
60, 59, 58, 57, 56, 54, 52, 50, 50, 49, 48, 46, 46, 44, 44, 43, 42, 41, 41, 40,
40, 38, 38, 37, 37, 37, 37, 36, 36, 36, 35, 35, 35, 34, 34, 35, 35, 35, 35, 35,
36, 35, 35, 35, 36, 36, 37, 36, 37, 37, 38, 39, 39, 40, 39, 40, 40, 40, 40, 40,
41, 41, 40, 41, 40, 40, 40, 40, 40, 39, 39, 38, 38, 38, 37, 38, 36, 36, 35, 35,
34, 33, 32, 32, 31, 29, 28, 28, 26, 26, 25, 23, 22, 20, 18, 16, 16, 14, 11, 10,
9, 6, 5, 2, -1, -1, -4, -6, -9, -12, -13, -16, -18, -21, -22, -26, -28, -30,
-32, -34, -36, -37, -39, -41, -44, -45, -47, -48, -50, -50, -52, -52, -54, -55,
-55, -57, -57, -57, -58, -58, -58, -58, -58, -58, -58, -58, -57, -57, -56, -56,
-55, -54, -53, -52, -50, -49, -47, -46, -44, -42, -40, -38, -35, -34, -30, -29,
-26, -24, -20, -17, -15, -11, -9, -5, -1, 1, 4, 8, 10, 13, 17, 19, 22, 25, 27,
30, 33, 35, 38, 38, 41, 43, 45, 47, 48, 49, 51, 53, 53, 55, 55, 56, 57, 58, 57,
57, 58, 59, 58, 58, 58, 57, 57, 57, 56, 56, 55, 54, 53, 51, 51, 49, 48, 46, 45,
43, 41, 40, 39, 36, 34, 32, 30, 28, 26, 24, 21, 19, 16, 13, 11, 9, 7, 4, 2, 0,
-3, -4, -7, -8, -10, -13, -14, -16, -17, -19, -20, -21, -22, -24, -26, -26, -28,
-29, -30, -31, -32, -33, -33, -34, -35, -36, -36, -37, -38, -38, -39, -39, -40,
-40, -40, -41, -40, -41, -41, -41, -40, -41, -41, -40, -41, -40, -41, -41, -41,
-40, -39, -40, -40, -39, -38, -38, -38, -37, -38, -36, -36, -36, -36, -35, -36,
-35, -35, -35, -36, -35, -35, -35, -35, -36, -36, -36, -36, -37, -37, -38, -38,
-38, -39, -40, -41, -40, -42, -42, -43, -44, -45, -45, -46, -48, -48, -50, -51,
-51, -53, -54, -55, -57, -58, -60, -62, -63, -65, -67, -68, -70, -72, -73, -76,
-78, -80, -81, -84, -85, -88, -90, -91, -94, -96, -98, -99, -102, -104, -105,
-107, -109, -110, -111, -113, -113, -115, -116, -116, -117, -117, -117, -118,
-119, -118, -118, -117, -118, -117, -117, -115, -115, -114, -113, -111, -111,
-108, -107, -105, -103, -101, -99, -97, -94, -92, -88, -86, -82, -79, -77, -73,
-69, -65, -62, -57, -54, -50, -46, -41, -37, -32, -27, -23, -18, -13, -7, -3, };