#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0132

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 12, 16, 19, 23, 26, 30, 34,
38, 41, 45, 48, 52, 56, 59, 63, 66, 69, 72, 75, 80, 83, 85, 88, 91, 93, 96, 98,
100, 103, 104, 106, 109, 110, 112, 113, 114, 116, 116, 118, 118, 119, 118, 118,
119, 119, 119, 119, 117, 117, 117, 116, 115, 114, 111, 111, 109, 107, 106, 104,
101, 98, 97, 94, 92, 89, 86, 83, 81, 77, 75, 71, 68, 64, 61, 57, 53, 50, 46, 42,
39, 35, 31, 27, 24, 20, 15, 12, 8, 4, 0, -3, -6, -10, -14, -18, -21, -25, -28,
-31, -34, -37, -41, -44, -47, -50, -52, -55, -58, -61, -62, -64, -67, -69, -72,
-73, -74, -77, -78, -79, -81, -82, -83, -84, -84, -87, -86, -88, -88, -88, -88,
-89, -88, -89, -88, -88, -88, -87, -88, -87, -86, -86, -85, -83, -83, -83, -82,
-81, -78, -78, -76, -76, -75, -74, -72, -70, -70, -69, -67, -66, -65, -62, -61,
-60, -59, -58, -56, -55, -54, -52, -51, -49, -48, -47, -45, -45, -43, -43, -40,
-40, -38, -37, -37, -35, -35, -33, -33, -32, -31, -30, -29, -28, -28, -27, -27,
-25, -26, -24, -24, -24, -24, -24, -23, -23, -22, -23, -22, -21, -21, -21, -21,
-20, -20, -20, -20, -19, -19, -19, -19, -18, -18, -18, -17, -17, -16, -16, -15,
-15, -15, -14, -13, -12, -12, -11, -11, -10, -10, -8, -8, -7, -6, -5, -4, -3,
-1, -1, 0, 1, 2, 3, 3, 6, 7, 8, 8, 10, 11, 11, 14, 14, 16, 18, 19, 20, 22, 23,
24, 25, 26, 28, 29, 30, 30, 32, 34, 34, 36, 37, 37, 38, 40, 40, 42, 42, 42, 42,
44, 45, 45, 45, 46, 46, 47, 47, 47, 47, 48, 48, 48, 47, 48, 47, 47, 47, 46, 46,
46, 45, 45, 44, 44, 43, 43, 41, 40, 40, 39, 39, 37, 36, 36, 35, 34, 32, 31, 30,
29, 28, 26, 25, 24, 23, 22, 21, 20, 19, 18, 16, 15, 15, 14, 11, 11, 11, 10, 8,
7, 7, 7, 6, 6, 3, 3, 3, 3, 3, 2, 2, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1,
1, 2, 1, 1, 2, 3, 3, 4, 4, 4, 4, 4, 5, 5, 6, 7, 6, 7, 7, 7, 8, 8, 9, 9, 10, 9,
10, 10, 10, 10, 10, 11, 10, 10, 11, 9, 10, 10, 8, 9, 8, 8, 7, 7, 7, 6, 5, 4, 3,
2, 1, 0, -1, -2, -4, -5, -6, -7, -9, -10, -11, -12, -14, -16, -17, -19, -21,
-22, -25, -26, -28, -29, -30, -32, -35, -36, -37, -39, -41, -43, -44, -46, -47,
-49, -50, -51, -52, -55, -56, -57, -57, -58, -60, -60, -61, -62, -63, -63, -64,
-64, -64, -63, -64, -63, -64, -63, -62, -61, -61, -60, -59, -59, -58, -56, -55,
-54, -52, -50, -49, -46, -45, -43, -41, -37, -36, -33, -31, -28, -25, -22, -21,
-17, -14, -11, -8, -3, -2, };