#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0069

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 10, 16, 20, 24, 29, 33, 38, 41,
45, 49, 54, 58, 62, 66, 70, 73, 76, 79, 83, 85, 88, 91, 94, 97, 100, 101, 103,
105, 107, 109, 110, 112, 112, 115, 115, 116, 117, 118, 118, 119, 118, 119, 119,
119, 119, 119, 118, 118, 117, 118, 117, 116, 115, 115, 113, 113, 112, 112, 110,
109, 108, 107, 106, 105, 104, 103, 101, 100, 99, 98, 97, 96, 95, 93, 92, 90, 91,
89, 87, 87, 85, 83, 82, 81, 79, 78, 76, 75, 74, 72, 71, 69, 68, 66, 66, 63, 61,
59, 58, 56, 56, 53, 51, 49, 48, 46, 45, 42, 40, 39, 38, 35, 34, 31, 31, 28, 26,
25, 24, 21, 20, 18, 16, 15, 12, 12, 11, 10, 8, 7, 5, 5, 4, 3, 2, 0, 0, 0, -1,
-2, -1, -2, -2, -1, -2, -2, -1, -1, -1, 0, 1, 2, 3, 3, 4, 5, 7, 8, 9, 10, 11,
13, 14, 16, 17, 20, 21, 22, 24, 25, 27, 28, 30, 32, 34, 35, 36, 38, 39, 40, 42,
43, 44, 45, 46, 47, 48, 49, 49, 50, 51, 51, 51, 52, 51, 51, 52, 52, 51, 51, 51,
50, 49, 49, 48, 49, 47, 47, 45, 44, 43, 42, 41, 41, 39, 38, 36, 36, 35, 34, 32,
30, 29, 28, 26, 25, 24, 23, 21, 21, 19, 18, 17, 16, 15, 14, 13, 12, 11, 10, 9,
8, 8, 6, 6, 5, 5, 4, 3, 2, 2, 1, 0, 1, 0, -1, -2, -3, -4, -4, -4, -6, -6, -7,
-8, -7, -9, -9, -10, -11, -12, -14, -14, -15, -17, -17, -18, -19, -21, -21, -24,
-24, -26, -26, -29, -29, -30, -31, -32, -34, -36, -37, -38, -40, -40, -41, -43,
-43, -45, -46, -46, -47, -48, -49, -49, -50, -50, -51, -52, -52, -52, -51, -52,
-52, -53, -52, -52, -52, -50, -50, -49, -50, -49, -47, -47, -45, -44, -43, -42,
-40, -40, -38, -36, -34, -33, -31, -30, -29, -27, -24, -23, -22, -20, -18, -18,
-16, -14, -13, -11, -10, -9, -8, -7, -5, -5, -3, -3, -2, -1, -1, -1, 1, 1, 1, 1,
1, 1, 1, 2, 1, 0, -1, -2, -1, -2, -3, -4, -5, -7, -8, -9, -10, -11, -13, -14,
-15, -18, -19, -21, -23, -25, -27, -28, -30, -31, -34, -35, -36, -38, -41, -42,
-45, -46, -48, -50, -52, -53, -55, -56, -59, -60, -61, -62, -65, -67, -68, -68,
-71, -72, -73, -75, -76, -78, -79, -80, -81, -83, -84, -85, -86, -87, -89, -90,
-91, -93, -94, -95, -96, -97, -98, -100, -101, -103, -103, -104, -106, -106,
-108, -108, -110, -110, -111, -112, -113, -114, -115, -115, -116, -116, -116,
-117, -117, -117, -117, -118, -117, -118, -117, -118, -117, -116, -115, -115,
-113, -113, -112, -110, -110, -108, -106, -104, -102, -100, -98, -96, -94, -91,
-88, -85, -83, -79, -75, -72, -69, -65, -62, -57, -54, -50, -46, -42, -37, -34,
-29, -25, -20, -16, -11, -7, -2, };