#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0098

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 14, 20, 25, 32, 38, 44, 49, 54,
59, 65, 69, 75, 78, 83, 87, 91, 94, 97, 99, 103, 105, 108, 110, 112, 113, 116,
116, 117, 119, 119, 119, 119, 119, 119, 118, 118, 117, 116, 117, 116, 113, 112,
111, 109, 108, 106, 105, 102, 101, 98, 96, 95, 92, 90, 87, 85, 83, 80, 77, 74,
72, 68, 66, 63, 60, 56, 53, 50, 47, 44, 40, 37, 34, 31, 28, 25, 21, 18, 14, 12,
8, 4, 1, -3, -5, -8, -12, -15, -18, -21, -24, -26, -28, -31, -33, -36, -38, -40,
-41, -43, -44, -46, -47, -48, -48, -49, -49, -49, -48, -48, -47, -47, -45, -45,
-43, -42, -39, -37, -36, -33, -30, -28, -25, -22, -20, -16, -13, -10, -7, -4,
-1, 2, 5, 8, 11, 14, 17, 19, 22, 24, 26, 29, 30, 31, 33, 34, 35, 37, 38, 38, 39,
39, 39, 39, 40, 40, 39, 38, 38, 38, 37, 36, 36, 35, 34, 32, 32, 31, 29, 27, 26,
25, 24, 23, 21, 20, 18, 17, 15, 13, 12, 11, 9, 7, 6, 4, 3, 1, -1, -2, -4, -6,
-8, -10, -11, -13, -15, -17, -18, -20, -21, -23, -25, -28, -29, -30, -32, -34,
-35, -37, -39, -39, -41, -42, -44, -47, -47, -49, -50, -50, -52, -53, -54, -54,
-55, -55, -55, -56, -56, -56, -56, -54, -55, -53, -52, -51, -49, -48, -46, -45,
-42, -41, -38, -35, -33, -30, -27, -23, -20, -17, -13, -9, -6, -3, 2, 5, 8, 12,
15, 19, 23, 25, 28, 31, 35, 36, 39, 42, 44, 47, 48, 50, 51, 53, 53, 54, 54, 55,
56, 56, 56, 56, 56, 56, 55, 55, 53, 53, 52, 51, 49, 47, 47, 45, 44, 42, 41, 39,
37, 36, 34, 33, 31, 30, 28, 25, 24, 22, 21, 18, 17, 15, 13, 12, 9, 8, 7, 5, 3,
1, 0, -2, -3, -6, -8, -10, -10, -12, -13, -15, -17, -18, -18, -21, -23, -23,
-25, -25, -27, -28, -29, -31, -32, -33, -34, -34, -36, -37, -37, -38, -39, -39,
-39, -40, -39, -40, -39, -40, -38, -37, -37, -36, -35, -34, -32, -30, -28, -27,
-25, -23, -21, -18, -16, -13, -10, -7, -3, -1, 1, 5, 8, 12, 15, 18, 21, 24, 27,
29, 32, 34, 35, 39, 40, 43, 44, 45, 46, 47, 47, 48, 49, 48, 48, 48, 48, 47, 46,
44, 44, 43, 40, 39, 37, 34, 33, 29, 27, 25, 21, 19, 16, 12, 9, 6, 2, 0, -3, -6,
-10, -14, -17, -20, -24, -26, -29, -33, -36, -40, -42, -46, -49, -53, -55, -59,
-62, -64, -68, -70, -73, -76, -79, -82, -84, -87, -89, -91, -94, -96, -97, -99,
-102, -103, -105, -107, -109, -110, -112, -113, -114, -115, -116, -117, -118,
-117, -118, -118, -119, -118, -118, -116, -117, -116, -114, -114, -112, -110,
-108, -106, -103, -100, -98, -94, -91, -88, -84, -80, -75, -71, -65, -61, -55,
-51, -45, -39, -33, -28, -22, -15, -9, -4, };