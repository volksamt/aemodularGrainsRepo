#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 4, 5, 6, 7, 8, 11, 10, 12,
13, 15, 17, 18, 18, 21, 22, 23, 24, 25, 27, 28, 31, 32, 32, 33, 34, 36, 37, 38,
38, 40, 41, 42, 43, 43, 45, 45, 46, 47, 47, 49, 49, 50, 49, 50, 51, 52, 52, 53,
53, 54, 54, 54, 55, 54, 55, 55, 55, 55, 57, 56, 56, 57, 57, 57, 57, 56, 57, 57,
57, 58, 57, 58, 57, 57, 57, 58, 57, 57, 58, 57, 57, 58, 58, 57, 57, 58, 57, 57,
58, 58, 58, 59, 60, 60, 61, 61, 64, 64, 66, 67, 67, 70, 70, 72, 74, 76, 77, 78,
80, 82, 83, 85, 87, 89, 90, 91, 92, 93, 95, 95, 96, 99, 100, 100, 102, 103, 103,
105, 106, 106, 107, 109, 109, 110, 111, 112, 112, 112, 113, 114, 116, 116, 116,
116, 117, 117, 118, 118, 118, 119, 119, 120, 119, 119, 120, 118, 119, 120, 117,
118, 117, 118, 117, 116, 114, 115, 114, 113, 112, 111, 110, 109, 109, 106, 106,
105, 103, 102, 100, 98, 97, 96, 94, 93, 91, 90, 88, 86, 84, 83, 81, 80, 78, 76,
75, 73, 71, 68, 68, 65, 64, 62, 60, 59, 57, 55, 53, 51, 50, 47, 46, 44, 43, 40,
39, 38, 36, 34, 33, 31, 30, 29, 27, 25, 24, 23, 20, 20, 18, 17, 16, 14, 14, 11,
10, 9, 8, 7, 6, 5, 4, 3, 2, 0, -1, -2, -4, -5, -6, -8, -9, -10, -11, -13, -14,
-15, -16, -17, -18, -19, -20, -22, -22, -23, -24, -25, -27, -27, -28, -29, -30,
-31, -33, -34, -34, -35, -36, -37, -39, -39, -41, -42, -42, -44, -45, -46, -47,
-48, -49, -51, -52, -53, -54, -55, -56, -57, -60, -61, -62, -62, -64, -65, -67,
-68, -69, -70, -72, -73, -75, -77, -77, -79, -79, -82, -83, -84, -85, -87, -88,
-90, -91, -92, -94, -94, -96, -97, -98, -100, -101, -101, -103, -104, -105,
-105, -106, -107, -109, -109, -110, -111, -111, -111, -112, -113, -114, -113,
-115, -114, -115, -115, -115, -115, -116, -115, -115, -115, -115, -115, -114,
-113, -114, -114, -112, -112, -112, -111, -111, -110, -108, -108, -107, -107,
-105, -104, -103, -102, -101, -100, -99, -98, -96, -95, -95, -92, -93, -91, -89,
-88, -86, -86, -84, -83, -82, -80, -78, -77, -76, -75, -74, -73, -71, -70, -69,
-68, -67, -65, -64, -64, -62, -61, -59, -58, -58, -56, -55, -54, -54, -51, -52,
-51, -49, -49, -48, -48, -45, -46, -44, -44, -43, -42, -42, -41, -40, -39, -39,
-38, -38, -38, -37, -36, -36, -36, -36, -36, -35, -35, -36, -37, -36, -37, -38,
-38, -40, -40, -40, -41, -43, -42, -43, -44, -45, -45, -46, -47, -46, -47, -48,
-47, -47, -47, -46, -46, -46, -45, -44, -43, -41, -40, -40, -39, -37, -36, -35,
-34, -33, -31, -30, -30, -27, -27, -25, -24, -23, -22, -20, -18, -17, -15, -15,
-14, -12, -11, -9, -8, -6, -4, -3, -3, -1, };