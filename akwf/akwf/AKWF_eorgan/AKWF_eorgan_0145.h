#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0145

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 10, 14, 19, 23, 30, 35, 42, 48,
54, 58, 65, 72, 78, 83, 88, 93, 97, 101, 106, 108, 112, 114, 116, 118, 119, 119,
119, 118, 119, 117, 115, 115, 111, 110, 108, 105, 103, 101, 97, 95, 92, 89, 87,
85, 81, 78, 77, 75, 73, 70, 69, 67, 66, 64, 64, 63, 63, 62, 62, 62, 63, 62, 63,
64, 66, 66, 69, 70, 72, 73, 74, 75, 76, 77, 78, 79, 78, 79, 79, 79, 78, 77, 78,
76, 74, 72, 71, 70, 67, 65, 62, 60, 57, 55, 52, 50, 48, 45, 44, 42, 39, 37, 36,
34, 32, 32, 31, 29, 28, 27, 26, 25, 25, 23, 23, 22, 23, 22, 21, 21, 20, 21, 21,
21, 21, 21, 23, 23, 23, 25, 26, 27, 29, 30, 31, 33, 34, 36, 37, 39, 40, 42, 42,
45, 44, 46, 47, 47, 47, 48, 48, 48, 49, 48, 48, 48, 48, 47, 47, 47, 47, 46, 45,
45, 43, 42, 42, 41, 40, 38, 36, 35, 33, 32, 30, 28, 26, 24, 21, 18, 16, 13, 11,
8, 6, 3, 1, -1, -4, -4, -8, -9, -10, -11, -11, -12, -12, -11, -12, -11, -11,
-10, -10, -9, -8, -7, -6, -5, -4, -5, -3, -3, -4, -3, -4, -3, -3, -5, -6, -7,
-9, -10, -12, -15, -16, -18, -22, -24, -28, -31, -34, -38, -41, -45, -49, -53,
-57, -60, -64, -68, -72, -75, -79, -82, -85, -87, -90, -91, -93, -93, -95, -94,
-94, -93, -92, -91, -89, -85, -82, -78, -75, -71, -66, -62, -58, -53, -48, -44,
-39, -36, -31, -28, -25, -22, -19, -17, -16, -15, -14, -14, -14, -14, -16, -17,
-19, -20, -23, -26, -29, -33, -35, -38, -42, -46, -48, -52, -56, -59, -62, -66,
-68, -71, -74, -77, -78, -81, -83, -85, -86, -87, -88, -89, -89, -89, -89, -89,
-89, -88, -87, -86, -84, -83, -81, -79, -77, -75, -73, -72, -70, -68, -66, -65,
-63, -62, -61, -61, -61, -61, -60, -61, -62, -63, -63, -64, -65, -67, -67, -68,
-70, -70, -72, -74, -74, -75, -76, -77, -76, -78, -77, -77, -78, -77, -78, -78,
-77, -77, -77, -76, -76, -75, -74, -72, -72, -71, -71, -69, -68, -67, -66, -64,
-63, -61, -59, -57, -55, -52, -51, -48, -45, -42, -39, -37, -33, -31, -28, -26,
-23, -20, -18, -15, -13, -11, -9, -7, -5, -4, -2, -1, 1, 2, 3, 3, 4, 5, 6, 7, 7,
7, 8, 8, 9, 9, 9, 9, 8, 9, 9, 8, 8, 7, 6, 5, 3, 3, 1, -1, -3, -3, -5, -6, -7,
-9, -10, -11, -12, -13, -13, -14, -13, -13, -12, -12, -11, -10, -8, -6, -5, -2,
0, 2, 4, 7, 8, 12, 13, 15, 17, 20, 21, 22, 23, 24, 26, 26, 26, 27, 27, 27, 27,
27, 26, 25, 24, 22, 21, 20, 18, 17, 14, 12, 10, 9, 7, 4, 2, 0, -1, -3, -5, -6,
-8, -8, -9, -9, -8, -7, -6, -4, -3, 1, };