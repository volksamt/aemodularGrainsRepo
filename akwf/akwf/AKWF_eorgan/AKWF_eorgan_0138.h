#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0138

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 10, 14, 20, 24, 29, 33, 38, 42,
46, 51, 55, 59, 63, 66, 70, 74, 77, 79, 83, 86, 89, 90, 92, 94, 96, 96, 97, 98,
99, 98, 99, 99, 98, 98, 97, 96, 95, 94, 92, 91, 89, 87, 85, 83, 82, 79, 77, 76,
74, 71, 69, 67, 65, 63, 61, 59, 56, 54, 54, 51, 50, 48, 47, 45, 43, 42, 41, 39,
38, 37, 36, 34, 34, 32, 31, 30, 29, 28, 27, 26, 25, 24, 22, 21, 20, 19, 17, 16,
15, 12, 12, 10, 8, 7, 6, 4, 3, 1, -1, -2, -3, -5, -6, -8, -8, -9, -11, -11, -12,
-13, -14, -13, -14, -13, -14, -13, -13, -11, -11, -10, -8, -8, -7, -5, -2, -2,
1, 3, 5, 7, 10, 12, 14, 17, 19, 21, 24, 26, 29, 31, 33, 34, 37, 39, 39, 42, 43,
44, 44, 46, 47, 48, 47, 47, 47, 47, 46, 46, 45, 44, 42, 42, 40, 38, 37, 36, 33,
32, 29, 27, 25, 23, 22, 20, 17, 15, 13, 11, 9, 7, 5, 3, 2, 0, -2, -2, -3, -5,
-5, -6, -7, -8, -8, -9, -9, -9, -10, -9, -9, -10, -9, -9, -9, -8, -8, -8, -8,
-7, -7, -7, -6, -6, -5, -6, -4, -5, -4, -4, -4, -3, -3, -3, -3, -3, -3, -2, -2,
-2, -1, 0, 0, 1, 1, 2, 4, 4, 5, 7, 8, 10, 11, 13, 15, 16, 20, 22, 25, 27, 29,
33, 37, 40, 42, 47, 50, 53, 58, 61, 65, 69, 73, 76, 79, 83, 86, 90, 93, 96, 99,
102, 105, 108, 109, 112, 114, 115, 117, 117, 118, 118, 119, 119, 119, 118, 118,
117, 115, 113, 113, 110, 109, 105, 103, 101, 98, 95, 92, 88, 85, 82, 79, 74, 72,
67, 64, 61, 57, 53, 51, 47, 44, 40, 36, 33, 30, 27, 24, 21, 19, 15, 13, 10, 8,
5, 3, 1, -2, -5, -7, -9, -11, -13, -16, -17, -19, -22, -24, -26, -28, -31, -32,
-35, -37, -40, -42, -44, -47, -48, -52, -54, -56, -58, -60, -63, -66, -67, -69,
-71, -73, -76, -78, -80, -81, -83, -84, -86, -87, -87, -89, -89, -89, -90, -89,
-90, -89, -90, -88, -87, -87, -86, -85, -84, -82, -81, -79, -77, -76, -75, -72,
-70, -68, -66, -64, -63, -61, -60, -58, -56, -55, -53, -52, -51, -50, -50, -49,
-48, -49, -49, -48, -48, -49, -50, -51, -51, -53, -54, -56, -57, -59, -60, -62,
-65, -66, -68, -70, -72, -74, -76, -79, -81, -82, -84, -87, -89, -90, -92, -94,
-95, -96, -98, -100, -100, -100, -101, -103, -104, -104, -103, -103, -103, -104,
-103, -102, -102, -102, -101, -101, -100, -99, -97, -97, -97, -96, -94, -93,
-92, -91, -90, -89, -87, -86, -86, -84, -83, -82, -81, -80, -79, -78, -77, -76,
-74, -73, -71, -71, -69, -67, -67, -66, -64, -62, -60, -57, -55, -52, -51, -48,
-45, -42, -40, -36, -33, -30, -26, -22, -18, -14, -10, -7, -2, };