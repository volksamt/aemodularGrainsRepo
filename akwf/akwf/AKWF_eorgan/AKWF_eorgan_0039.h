#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0039

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 15, 19, 22, 27, 33, 38, 45, 50,
55, 61, 67, 71, 77, 80, 85, 90, 94, 100, 105, 107, 107, 106, 101, 92, 81, 67,
52, 38, 23, 13, 5, -2, -5, -5, -5, -5, -3, -2, 1, 3, 5, 7, 8, 9, 7, 6, 4, 1, -2,
-4, -6, -8, -8, -7, -5, 0, 5, 11, 19, 27, 35, 40, 44, 45, 42, 37, 29, 20, 12, 2,
-5, -10, -14, -16, -18, -19, -20, -22, -24, -27, -29, -30, -30, -28, -26, -21,
-18, -14, -11, -5, -1, 6, 11, 18, 22, 25, 29, 31, 33, 34, 35, 36, 37, 37, 36,
35, 32, 29, 24, 18, 13, 8, 2, -1, -4, -6, -6, -4, -2, 1, 4, 9, 12, 16, 17, 14,
8, -2, -14, -27, -40, -56, -73, -91, -105, -114, -118, -119, -116, -109, -101,
-90, -78, -66, -54, -44, -34, -26, -22, -17, -16, -17, -18, -20, -21, -22, -22,
-22, -21, -17, -15, -12, -8, -6, -4, -3, -1, 0, 3, 5, 8, 11, 15, 18, 21, 22, 21,
18, 14, 8, 2, -3, -7, -12, -15, -17, -16, -16, -14, -12, -11, -13, -15, -21,
-27, -36, -46, -55, -61, -66, -68, -68, -66, -62, -56, -48, -41, -33, -26, -18,
-11, -3, 1, 5, 7, 8, 7, 6, 6, 3, 2, 1, 1, 2, 3, 5, 5, 5, 5, 2, -1, -6, -13, -21,
-30, -40, -49, -57, -63, -69, -73, -74, -74, -72, -67, -63, -57, -50, -43, -36,
-29, -21, -14, -6, 0, 7, 13, 19, 24, 29, 33, 35, 41, 46, 52, 55, 61, 67, 71, 75,
81, 85, 90, 94, 98, 100, 101, 96, 90, 81, 68, 55, 41, 27, 17, 9, 5, 2, 0, -1, 1,
1, 2, 5, 6, 8, 8, 10, 11, 10, 10, 8, 6, 5, 4, 1, 0, -1, 0, 2, 4, 7, 11, 17, 24,
30, 37, 43, 45, 45, 41, 34, 26, 18, 10, 3, 0, -3, -6, -9, -12, -13, -17, -19,
-23, -24, -26, -27, -25, -23, -19, -15, -8, -4, 2, 5, 9, 14, 20, 24, 28, 33, 36,
38, 39, 40, 42, 42, 43, 44, 43, 41, 38, 34, 29, 23, 19, 14, 10, 7, 5, 5, 5, 7,
9, 14, 17, 20, 25, 27, 26, 23, 15, 4, -8, -21, -34, -52, -71, -86, -97, -104,
-106, -104, -100, -92, -82, -70, -59, -47, -35, -24, -17, -9, -6, -3, -2, -3,
-5, -5, -8, -8, -8, -7, -4, -3, 0, 4, 6, 7, 9, 12, 13, 16, 19, 22, 25, 29, 32,
34, 36, 37, 35, 32, 26, 19, 12, 6, 1, -1, -4, -5, -5, -3, -1, -1, -1, -3, -6,
-11, -19, -27, -35, -44, -50, -52, -52, -52, -48, -43, -35, -28, -21, -13, -5,
1, 6, 10, 12, 15, 17, 17, 17, 14, 14, 12, 11, 9, 9, 11, 12, 13, 13, 13, 12, 10,
6, 2, -3, -11, -20, -29, -38, -46, -53, -56, -60, -62, -60, -58, -53, -49, -42,
-37, -29, -22, -16, -9, -3, 1, };