#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0065

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 9, 16, 24, 31, 38, 45, 51, 57, 63,
69, 74, 78, 83, 87, 89, 92, 95, 97, 98, 100, 101, 101, 101, 102, 102, 101, 100,
100, 99, 98, 97, 96, 95, 94, 93, 92, 91, 91, 89, 89, 88, 88, 88, 88, 88, 88, 88,
89, 89, 90, 91, 91, 91, 92, 93, 94, 95, 97, 97, 98, 100, 100, 101, 102, 103,
104, 105, 106, 106, 107, 109, 108, 110, 111, 111, 112, 113, 114, 115, 115, 116,
116, 117, 117, 118, 118, 119, 119, 119, 119, 119, 119, 119, 118, 117, 118, 117,
116, 116, 115, 114, 113, 112, 112, 112, 110, 109, 108, 107, 107, 106, 105, 104,
104, 102, 102, 102, 101, 102, 101, 101, 101, 102, 102, 101, 102, 103, 102, 103,
103, 103, 103, 103, 103, 102, 102, 101, 102, 100, 100, 99, 98, 98, 96, 94, 93,
92, 90, 89, 86, 86, 84, 82, 81, 80, 78, 76, 74, 74, 71, 70, 69, 67, 66, 65, 64,
62, 61, 61, 59, 59, 59, 57, 57, 56, 55, 55, 54, 53, 53, 51, 52, 50, 50, 49, 48,
46, 47, 46, 45, 45, 43, 42, 41, 40, 40, 39, 38, 37, 37, 35, 34, 32, 31, 29, 28,
28, 25, 24, 22, 19, 18, 15, 13, 11, 7, 4, 3, 0, -5, -7, -11, -15, -17, -21, -24,
-27, -32, -34, -37, -40, -42, -45, -46, -47, -50, -50, -51, -52, -51, -50, -50,
-48, -46, -44, -42, -38, -34, -31, -27, -23, -18, -13, -9, -4, 0, 5, 10, 15, 20,
24, 28, 32, 36, 39, 41, 43, 46, 48, 49, 49, 50, 50, 50, 49, 48, 46, 44, 42, 40,
37, 35, 32, 28, 25, 22, 18, 15, 12, 9, 5, 2, -2, -5, -7, -10, -13, -16, -18,
-20, -22, -25, -25, -28, -29, -31, -32, -34, -35, -35, -37, -37, -38, -40, -40,
-41, -42, -44, -44, -44, -46, -46, -48, -49, -48, -49, -50, -50, -51, -53, -53,
-54, -55, -55, -56, -57, -57, -59, -60, -60, -60, -61, -62, -63, -64, -66, -66,
-68, -69, -70, -72, -73, -75, -76, -79, -80, -81, -83, -84, -86, -87, -89, -91,
-92, -93, -94, -96, -98, -98, -100, -100, -101, -102, -103, -103, -103, -104,
-104, -104, -104, -103, -104, -104, -103, -103, -103, -102, -102, -103, -102,
-101, -102, -102, -102, -103, -103, -103, -104, -105, -105, -105, -107, -107,
-108, -109, -110, -111, -112, -113, -113, -114, -115, -116, -117, -117, -118,
-118, -118, -119, -118, -119, -119, -118, -119, -118, -118, -117, -117, -117,
-115, -115, -114, -113, -113, -112, -111, -110, -109, -109, -108, -107, -107,
-105, -104, -103, -102, -101, -101, -99, -99, -97, -96, -96, -95, -94, -93, -92,
-91, -90, -89, -89, -88, -88, -86, -86, -86, -85, -86, -86, -86, -86, -88, -87,
-88, -89, -91, -91, -93, -93, -94, -95, -96, -98, -98, -99, -99, -100, -99,
-100, -99, -97, -96, -96, -94, -91, -88, -86, -82, -78, -73, -69, -64, -58, -52,
-46, -39, -32, -26, -18, -11, -4, };