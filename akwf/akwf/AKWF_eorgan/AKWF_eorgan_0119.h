#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0119

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 16, 21, 25, 29, 34, 38, 43,
47, 50, 55, 58, 62, 66, 69, 72, 76, 79, 82, 84, 87, 90, 92, 96, 97, 100, 101,
103, 105, 106, 108, 110, 111, 113, 113, 114, 115, 117, 117, 118, 117, 118, 118,
119, 119, 119, 120, 119, 119, 119, 118, 117, 117, 116, 115, 114, 113, 113, 111,
110, 109, 108, 107, 105, 103, 102, 101, 99, 97, 96, 93, 92, 91, 89, 87, 85, 83,
81, 80, 78, 76, 74, 72, 71, 68, 66, 65, 62, 60, 59, 57, 55, 53, 51, 49, 48, 45,
44, 42, 40, 39, 36, 35, 34, 31, 30, 28, 26, 24, 24, 21, 20, 18, 17, 14, 13, 11,
10, 8, 6, 5, 3, 1, -1, -2, -4, -6, -7, -8, -10, -12, -12, -14, -16, -17, -18,
-18, -20, -22, -23, -23, -25, -25, -27, -28, -29, -29, -30, -30, -31, -33, -33,
-35, -35, -36, -37, -37, -39, -39, -39, -40, -41, -41, -42, -43, -43, -44, -45,
-46, -46, -48, -48, -49, -49, -50, -51, -52, -53, -54, -54, -55, -56, -57, -57,
-59, -59, -60, -60, -61, -62, -63, -64, -64, -65, -66, -67, -68, -67, -68, -68,
-69, -70, -70, -71, -70, -71, -71, -71, -71, -71, -71, -70, -71, -70, -70, -69,
-69, -69, -68, -67, -67, -66, -64, -64, -63, -63, -61, -60, -58, -57, -56, -54,
-53, -51, -48, -47, -46, -43, -41, -39, -37, -35, -32, -29, -28, -25, -22, -20,
-17, -14, -11, -8, -5, -1, 1, 4, 7, 11, 14, 17, 19, 22, 24, 27, 30, 32, 34, 37,
40, 41, 43, 46, 47, 49, 51, 52, 54, 56, 57, 59, 60, 61, 62, 62, 64, 66, 65, 66,
68, 69, 69, 69, 69, 70, 70, 70, 71, 71, 72, 71, 71, 70, 70, 71, 70, 71, 70, 70,
69, 68, 68, 68, 67, 66, 65, 65, 64, 63, 62, 62, 61, 60, 60, 58, 58, 56, 56, 55,
54, 53, 53, 51, 51, 51, 50, 50, 48, 47, 47, 45, 46, 45, 43, 43, 42, 41, 41, 40,
40, 38, 38, 37, 36, 36, 35, 33, 33, 32, 32, 31, 30, 28, 28, 27, 26, 25, 24, 23,
22, 21, 20, 19, 17, 16, 15, 13, 11, 11, 9, 8, 6, 4, 3, 0, -1, -2, -4, -6, -7,
-8, -11, -12, -13, -16, -17, -19, -21, -21, -24, -24, -27, -29, -30, -32, -34,
-35, -37, -39, -40, -42, -45, -46, -48, -50, -51, -52, -55, -57, -58, -61, -62,
-64, -66, -68, -70, -71, -74, -76, -77, -79, -81, -83, -85, -87, -89, -89, -91,
-92, -95, -97, -99, -101, -101, -103, -104, -106, -107, -108, -110, -111, -111,
-113, -114, -115, -116, -116, -117, -117, -118, -119, -118, -119, -118, -119,
-118, -118, -118, -118, -117, -117, -115, -116, -114, -112, -112, -111, -108,
-108, -106, -105, -103, -100, -99, -97, -94, -92, -90, -87, -85, -82, -78, -76,
-73, -68, -66, -63, -59, -55, -51, -48, -43, -39, -35, -31, -26, -22, -17, -12,
-7, -2, };