#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0035

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 5, 6, 8, 9, 10, 11, 11, 12, 12,
14, 14, 15, 15, 16, 17, 16, 17, 17, 18, 18, 18, 18, 18, 18, 19, 19, 19, 19, 18,
20, 20, 20, 20, 20, 21, 22, 22, 22, 23, 23, 24, 25, 26, 27, 27, 28, 28, 30, 31,
32, 33, 33, 35, 35, 37, 37, 39, 40, 42, 45, 46, 48, 50, 52, 55, 56, 58, 60, 62,
63, 64, 67, 68, 69, 70, 71, 71, 72, 72, 72, 72, 72, 72, 71, 70, 70, 69, 68, 67,
66, 66, 65, 63, 62, 61, 59, 58, 57, 56, 55, 55, 52, 52, 52, 50, 49, 49, 48, 49,
49, 47, 48, 47, 47, 48, 47, 48, 48, 49, 50, 49, 50, 51, 52, 53, 54, 54, 56, 57,
58, 59, 61, 61, 64, 65, 66, 68, 70, 70, 73, 74, 75, 77, 79, 80, 81, 83, 84, 86,
86, 89, 89, 91, 92, 92, 94, 95, 96, 97, 99, 99, 99, 101, 101, 102, 102, 103,
103, 103, 102, 103, 102, 102, 102, 101, 101, 100, 98, 99, 97, 96, 95, 93, 92,
91, 89, 87, 85, 84, 82, 81, 79, 77, 75, 73, 71, 70, 67, 65, 64, 62, 61, 59, 57,
56, 54, 52, 52, 50, 49, 48, 46, 45, 45, 44, 42, 42, 42, 41, 40, 40, 39, 39, 39,
39, 39, 40, 38, 39, 39, 39, 39, 40, 40, 41, 41, 41, 41, 41, 42, 42, 43, 43, 44,
43, 43, 44, 43, 44, 44, 45, 45, 44, 44, 43, 44, 43, 41, 41, 41, 39, 38, 37, 36,
35, 33, 32, 31, 29, 28, 26, 23, 22, 20, 18, 17, 15, 12, 9, 7, 5, 3, 2, -1, -3,
-4, -5, -8, -9, -11, -11, -14, -15, -17, -18, -18, -20, -20, -21, -21, -21, -22,
-24, -23, -24, -24, -23, -24, -25, -24, -24, -24, -25, -24, -24, -24, -24, -23,
-23, -22, -22, -22, -23, -22, -22, -22, -22, -23, -22, -23, -23, -24, -25, -26,
-27, -27, -28, -28, -30, -31, -31, -33, -35, -38, -39, -42, -44, -47, -50, -53,
-55, -59, -62, -65, -68, -71, -74, -77, -80, -83, -85, -88, -91, -93, -96, -98,
-99, -102, -104, -105, -107, -109, -110, -111, -113, -113, -116, -115, -117,
-118, -117, -118, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-118, -117, -116, -116, -116, -115, -114, -112, -111, -112, -110, -109, -108,
-107, -106, -104, -103, -102, -101, -99, -97, -96, -96, -93, -93, -91, -90, -89,
-88, -85, -84, -83, -83, -80, -80, -79, -78, -78, -77, -76, -75, -76, -75, -75,
-74, -75, -74, -75, -75, -75, -75, -76, -76, -76, -77, -78, -78, -78, -79, -80,
-81, -81, -81, -82, -83, -82, -83, -83, -84, -84, -84, -83, -84, -84, -84, -83,
-83, -82, -82, -81, -79, -80, -78, -78, -75, -75, -73, -72, -69, -67, -65, -63,
-62, -59, -58, -55, -53, -50, -48, -47, -44, -41, -38, -35, -33, -30, -28, -26,
-23, -20, -18, -16, -13, -10, -8, -6, -2, -1, };