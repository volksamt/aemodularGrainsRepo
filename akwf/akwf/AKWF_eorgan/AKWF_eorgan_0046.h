#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0046

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 11, 17, 24, 30, 36, 42, 48, 53, 57,
62, 66, 69, 72, 77, 84, 89, 95, 100, 103, 107, 111, 113, 115, 117, 118, 120,
118, 120, 116, 97, 95, 95, 94, 92, 89, 88, 83, 82, 78, 74, 70, 67, 63, 59, 52,
32, 26, 23, 17, 13, 8, 6, 1, -3, -7, -10, -16, -18, -24, -23, -39, -54, -51,
-55, -53, -56, -55, -56, -55, -56, -56, -56, -56, -55, -54, -54, -55, -55, -59,
-61, -63, -65, -66, -66, -68, -68, -68, -67, -66, -64, -64, -59, -60, -78, -75,
-72, -70, -65, -62, -59, -56, -53, -49, -45, -42, -38, -35, -29, -34, -43, -39,
-34, -29, -25, -21, -17, -13, -9, -5, -1, 1, 5, 8, 12, 5, -6, 1, 4, 8, 11, 15,
17, 20, 22, 23, 24, 26, 30, 31, 32, 33, 36, 41, 47, 50, 55, 58, 63, 67, 70, 72,
75, 76, 81, 80, 84, 83, 64, 66, 67, 67, 67, 67, 67, 67, 68, 66, 67, 64, 65, 63,
63, 54, 41, 40, 39, 40, 39, 39, 37, 35, 34, 32, 30, 28, 26, 21, 23, 6, -7, -5,
-10, -9, -12, -12, -15, -16, -17, -18, -21, -22, -25, -26, -28, -30, -34, -39,
-45, -50, -54, -59, -63, -67, -70, -73, -75, -78, -80, -83, -83, -88, -107,
-106, -106, -105, -104, -103, -101, -99, -97, -94, -91, -87, -83, -80, -74, -75,
-84, -79, -73, -67, -61, -55, -49, -43, -36, -31, -25, -20, -12, -9, 2, -11,
-14, -1, 2, 13, 17, 25, 30, 37, 43, 49, 54, 58, 62, 66, 70, 73, 78, 84, 90, 94,
100, 104, 108, 111, 113, 114, 118, 118, 120, 118, 120, 114, 96, 97, 95, 93, 92,
89, 87, 83, 81, 78, 74, 70, 66, 62, 60, 50, 31, 25, 22, 17, 12, 7, 5, 0, -3, -8,
-12, -17, -19, -25, -23, -43, -55, -51, -55, -54, -56, -55, -57, -56, -56, -55,
-56, -56, -55, -55, -55, -54, -56, -59, -61, -64, -65, -66, -66, -68, -67, -68,
-66, -66, -63, -64, -58, -63, -79, -74, -71, -69, -66, -63, -59, -56, -52, -49,
-44, -42, -37, -34, -30, -34, -43, -38, -34, -29, -25, -20, -16, -12, -9, -5, 0,
2, 7, 8, 14, 2, -5, 1, 3, 8, 10, 15, 17, 20, 22, 23, 25, 27, 29, 31, 33, 33, 36,
41, 46, 51, 55, 59, 64, 66, 71, 72, 76, 78, 80, 80, 84, 81, 62, 66, 67, 67, 67,
67, 67, 67, 67, 66, 66, 65, 65, 63, 63, 53, 41, 40, 39, 40, 40, 39, 37, 35, 34,
31, 29, 27, 26, 22, 22, 4, -8, -6, -9, -10, -11, -13, -14, -15, -17, -19, -21,
-22, -25, -26, -28, -29, -34, -40, -45, -51, -55, -60, -62, -67, -69, -74, -75,
-79, -79, -83, -82, -90, -109, -105, -106, -106, -104, -103, -101, -99, -96,
-93, -90, -87, -83, -79, -74, -76, -84, -78, -72, -67, -60, -54, -49, -42, -36,
-31, -24, -19, -13, -8, 2, -12, -13, -1, };