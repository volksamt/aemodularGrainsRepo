#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0033

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 28, 53, 74, 86, 97, 104, 108, 111,
113, 115, 116, 117, 118, 119, 118, 118, 118, 119, 119, 119, 118, 118, 119, 117,
116, 116, 115, 116, 114, 114, 113, 113, 112, 111, 110, 110, 109, 108, 107, 107,
105, 105, 105, 103, 103, 101, 102, 100, 100, 99, 98, 97, 95, 95, 95, 94, 92, 92,
91, 91, 90, 89, 88, 86, 87, 85, 84, 84, 83, 82, 81, 81, 79, 80, 79, 77, 76, 75,
74, 74, 73, 73, 72, 71, 70, 70, 69, 68, 66, 66, 65, 65, 63, 63, 62, 60, 60, 60,
58, 57, 57, 57, 56, 55, 54, 53, 52, 51, 50, 50, 49, 48, 47, 46, 45, 44, 44, 43,
42, 41, 41, 40, 39, 38, 37, 36, 36, 35, 34, 33, 32, 31, 31, 30, 29, 28, 27, 26,
25, 25, 24, 23, 22, 21, 20, 20, 18, 18, 17, 17, 15, 15, 14, 14, 12, 12, 11, 10,
9, 9, 8, 6, 6, 5, 5, 3, 3, 1, 1, 0, -1, -1, -2, -3, -4, -4, -6, -7, -7, -8, -10,
-10, -10, -11, -12, -13, -13, -15, -16, -17, -17, -17, -19, -20, -20, -21, -22,
-23, -23, -24, -25, -25, -26, -27, -29, -29, -31, -30, -31, -33, -33, -34, -35,
-36, -37, -38, -38, -38, -40, -41, -42, -42, -43, -44, -45, -46, -46, -47, -48,
-50, -49, -51, -51, -52, -53, -54, -54, -55, -56, -56, -56, -57, -57, -58, -58,
-58, -57, -56, -55, -55, -53, -50, -40, -25, -10, 5, 20, 36, 48, 51, 53, 55, 56,
57, 58, 57, 57, 57, 57, 56, 56, 55, 55, 54, 53, 53, 52, 52, 51, 50, 49, 48, 47,
47, 46, 45, 44, 43, 42, 41, 41, 40, 40, 39, 38, 37, 36, 35, 34, 34, 33, 32, 31,
31, 29, 29, 28, 27, 27, 25, 25, 24, 23, 23, 22, 20, 19, 19, 18, 17, 16, 15, 15,
14, 13, 12, 12, 11, 9, 10, 8, 7, 6, 5, 4, 4, 3, 2, 1, 1, 0, -1, -2, -3, -3, -4,
-5, -6, -6, -7, -9, -9, -10, -12, -11, -13, -13, -14, -15, -15, -16, -17, -19,
-19, -19, -21, -22, -23, -22, -24, -24, -25, -26, -28, -28, -29, -30, -30, -31,
-31, -32, -34, -35, -36, -36, -37, -37, -39, -39, -40, -42, -42, -43, -44, -45,
-45, -46, -47, -48, -48, -49, -50, -51, -52, -52, -53, -55, -55, -56, -57, -58,
-59, -59, -59, -61, -61, -62, -63, -64, -65, -66, -66, -66, -68, -69, -69, -70,
-71, -73, -73, -74, -75, -75, -76, -77, -78, -79, -80, -80, -82, -82, -83, -84,
-85, -85, -85, -88, -88, -89, -90, -91, -91, -92, -93, -93, -95, -96, -96, -96,
-97, -99, -99, -100, -101, -102, -103, -103, -104, -105, -106, -106, -107, -108,
-108, -109, -111, -111, -112, -112, -113, -113, -114, -115, -115, -116, -117,
-116, -117, -119, -118, -119, -119, -119, -119, -118, -119, -118, -118, -117,
-116, -115, -113, -112, -108, -105, -96, -86, -75, -57, -35, -11, };