#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 6, 9, 11, 14, 15, 17, 20, 22,
24, 26, 27, 29, 31, 34, 36, 38, 39, 41, 43, 44, 47, 48, 50, 52, 53, 55, 57, 58,
60, 61, 62, 64, 65, 67, 69, 70, 71, 72, 74, 75, 76, 78, 79, 80, 81, 82, 83, 84,
84, 85, 87, 87, 89, 90, 90, 91, 93, 93, 93, 94, 95, 95, 96, 97, 98, 98, 98, 99,
100, 100, 101, 102, 101, 103, 103, 102, 103, 104, 103, 104, 105, 105, 105, 105,
106, 107, 106, 107, 107, 107, 108, 108, 108, 107, 107, 108, 107, 108, 108, 107,
109, 108, 109, 108, 108, 108, 109, 108, 109, 108, 108, 109, 108, 108, 108, 108,
108, 108, 108, 108, 108, 107, 107, 108, 107, 107, 107, 107, 106, 107, 106, 106,
106, 106, 106, 105, 106, 106, 105, 105, 105, 105, 105, 104, 105, 104, 104, 104,
103, 104, 103, 103, 103, 103, 102, 102, 103, 102, 102, 101, 102, 101, 101, 101,
99, 100, 100, 99, 99, 99, 98, 99, 97, 98, 96, 96, 96, 96, 96, 95, 95, 93, 94,
94, 93, 93, 92, 91, 91, 91, 90, 90, 89, 88, 88, 87, 86, 86, 85, 84, 83, 83, 83,
82, 81, 79, 79, 78, 77, 76, 75, 75, 74, 73, 72, 71, 71, 69, 68, 67, 66, 65, 64,
63, 61, 60, 58, 57, 56, 55, 54, 52, 51, 49, 47, 46, 46, 43, 42, 41, 39, 38, 36,
34, 33, 31, 29, 27, 26, 24, 22, 21, 20, 16, 14, 12, 12, 9, 7, 5, 4, 1, -1, -3,
-5, -7, -10, -11, -13, -16, -19, -21, -22, -25, -28, -30, -32, -33, -36, -38,
-40, -41, -44, -46, -48, -50, -51, -54, -56, -57, -59, -60, -63, -64, -65, -67,
-69, -71, -71, -74, -74, -77, -78, -79, -80, -82, -83, -85, -86, -87, -88, -89,
-91, -92, -93, -94, -94, -95, -97, -98, -99, -99, -101, -102, -102, -103, -104,
-104, -105, -106, -107, -107, -107, -108, -110, -109, -111, -110, -111, -111,
-111, -112, -114, -113, -114, -115, -115, -115, -116, -115, -116, -116, -117,
-117, -117, -117, -117, -118, -119, -118, -119, -118, -119, -118, -118, -119,
-118, -118, -119, -119, -119, -119, -118, -119, -120, -118, -119, -119, -119,
-119, -119, -119, -119, -118, -118, -119, -118, -118, -118, -118, -118, -117,
-118, -117, -117, -116, -117, -116, -117, -116, -116, -115, -116, -115, -115,
-114, -114, -114, -113, -113, -112, -113, -112, -112, -111, -111, -111, -111,
-110, -110, -109, -109, -108, -107, -108, -106, -106, -106, -105, -105, -105,
-104, -104, -103, -102, -102, -101, -100, -99, -98, -97, -97, -96, -96, -95,
-95, -93, -92, -92, -91, -91, -90, -88, -88, -87, -86, -85, -84, -82, -82, -80,
-80, -78, -77, -77, -75, -74, -72, -71, -70, -68, -68, -66, -65, -64, -62, -61,
-59, -57, -56, -55, -53, -51, -49, -48, -46, -46, -43, -41, -40, -39, -36, -35,
-32, -31, -29, -27, -25, -23, -21, -19, -17, -14, -12, -11, -8, -7, -5, -2, 0,
};