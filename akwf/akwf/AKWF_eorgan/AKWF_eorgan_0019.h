#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 5, 8, 15, 17, 23, 26, 31, 34, 38,
43, 47, 50, 54, 57, 62, 66, 69, 72, 74, 78, 80, 84, 87, 90, 92, 94, 97, 99, 100,
103, 104, 107, 108, 109, 111, 112, 114, 114, 116, 116, 117, 118, 118, 119, 119,
119, 119, 119, 118, 118, 117, 117, 117, 117, 116, 115, 114, 113, 112, 110, 109,
107, 106, 104, 103, 101, 100, 97, 97, 94, 93, 90, 90, 87, 87, 84, 82, 81, 78,
77, 75, 74, 72, 71, 70, 67, 66, 64, 63, 62, 60, 59, 58, 57, 56, 54, 53, 53, 51,
50, 50, 49, 48, 47, 46, 46, 45, 46, 44, 44, 43, 44, 43, 42, 43, 42, 42, 41, 42,
40, 41, 40, 41, 41, 41, 41, 41, 41, 41, 41, 42, 42, 41, 41, 41, 41, 41, 41, 41,
41, 40, 39, 39, 39, 38, 38, 37, 36, 36, 34, 33, 32, 32, 31, 29, 27, 26, 25, 24,
22, 20, 19, 18, 16, 14, 13, 10, 8, 7, 5, 2, 0, -2, -4, -5, -8, -11, -12, -16,
-17, -19, -22, -24, -27, -28, -31, -34, -36, -38, -40, -42, -44, -46, -49, -51,
-54, -55, -56, -58, -61, -63, -64, -65, -67, -68, -70, -70, -72, -72, -73, -73,
-74, -75, -75, -75, -75, -76, -75, -75, -75, -74, -73, -73, -72, -71, -70, -70,
-68, -67, -65, -64, -62, -60, -58, -56, -54, -52, -50, -48, -45, -42, -39, -37,
-35, -32, -30, -28, -25, -21, -19, -15, -11, -8, -6, -3, 0, 5, 8, 9, 12, 17, 19,
22, 26, 28, 31, 33, 36, 40, 42, 44, 46, 49, 51, 53, 55, 57, 60, 61, 63, 64, 65,
68, 68, 70, 70, 71, 72, 73, 73, 74, 74, 74, 74, 74, 74, 74, 73, 74, 73, 72, 71,
71, 69, 68, 68, 65, 65, 63, 62, 60, 59, 57, 55, 54, 51, 49, 47, 45, 42, 40, 38,
37, 33, 31, 28, 27, 23, 21, 19, 17, 15, 11, 10, 8, 6, 3, 2, 0, -3, -5, -7, -9,
-11, -12, -14, -16, -17, -20, -21, -22, -24, -26, -26, -28, -29, -30, -31, -32,
-33, -34, -35, -36, -37, -38, -37, -38, -39, -39, -40, -40, -40, -41, -41, -42,
-41, -42, -43, -43, -42, -42, -41, -41, -42, -42, -42, -41, -42, -42, -42, -41,
-40, -41, -41, -41, -42, -41, -42, -42, -43, -43, -43, -44, -43, -44, -45, -46,
-47, -48, -49, -50, -50, -52, -53, -54, -54, -56, -58, -59, -60, -62, -62, -64,
-65, -66, -67, -70, -72, -72, -74, -76, -78, -79, -81, -84, -84, -86, -87, -90,
-91, -93, -94, -96, -98, -99, -101, -103, -105, -105, -107, -108, -110, -111,
-112, -113, -115, -116, -116, -118, -117, -118, -118, -119, -118, -118, -118,
-118, -118, -118, -117, -116, -116, -114, -113, -112, -111, -110, -107, -107,
-104, -102, -101, -99, -97, -93, -92, -89, -87, -84, -81, -78, -75, -72, -68,
-65, -62, -57, -54, -50, -47, -44, -40, -36, -32, -29, -24, -20, -16, -11, -7,
-3, };