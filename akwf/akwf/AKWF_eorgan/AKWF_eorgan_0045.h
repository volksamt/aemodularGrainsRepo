#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0045

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 9, 12, 16, 18, 21, 26, 28,
33, 16, 11, 16, 19, 23, 27, 30, 34, 37, 41, 43, 47, 50, 53, 55, 58, 61, 64, 67,
69, 71, 74, 75, 77, 79, 81, 82, 83, 84, 86, 87, 88, 89, 91, 93, 96, 98, 102,
103, 105, 108, 109, 111, 113, 113, 114, 117, 117, 117, 118, 118, 118, 120, 119,
119, 119, 118, 118, 117, 116, 116, 115, 113, 113, 91, 84, 85, 82, 83, 80, 80,
77, 77, 74, 73, 70, 70, 67, 65, 63, 62, 58, 57, 54, 52, 50, 47, 46, 44, 41, 37,
37, 32, 32, 26, 29, 10, -8, -4, -9, -9, -12, -14, -16, -18, -21, -23, -25, -26,
-28, -29, -31, -33, -35, -37, -38, -39, -41, -43, -45, -46, -47, -47, -49, -50,
-51, -51, -51, -72, -80, -77, -78, -77, -77, -75, -76, -74, -74, -73, -73, -71,
-70, -69, -68, -67, -67, -66, -64, -63, -62, -62, -61, -59, -58, -57, -55, -54,
-54, -53, -52, -50, -51, -53, -54, -55, -55, -56, -57, -57, -57, -58, -58, -57,
-57, -57, -57, -57, -56, -56, -56, -54, -53, -52, -52, -50, -50, -48, -47, -45,
-43, -42, -40, -62, -65, -61, -60, -57, -56, -54, -53, -49, -49, -46, -44, -42,
-41, -39, -37, -35, -32, -31, -28, -27, -25, -23, -21, -19, -17, -15, -13, -12,
-8, -9, -2, -19, -31, -22, -22, -19, -18, -14, -12, -9, -9, -6, -4, -2, 0, 2, 4,
6, 8, 10, 11, 13, 14, 16, 17, 19, 19, 22, 22, 24, 24, 26, 28, 5, 3, 7, 7, 10,
11, 14, 14, 17, 17, 18, 20, 21, 21, 23, 24, 25, 25, 27, 27, 27, 29, 29, 29, 30,
31, 31, 32, 33, 32, 32, 33, 33, 34, 38, 40, 42, 45, 47, 50, 52, 53, 56, 58, 59,
62, 63, 65, 67, 69, 71, 71, 72, 74, 76, 76, 78, 78, 80, 79, 80, 81, 82, 80, 58,
56, 58, 58, 60, 59, 60, 59, 60, 59, 59, 59, 59, 58, 59, 58, 58, 56, 57, 56, 57,
56, 56, 55, 54, 54, 53, 52, 52, 53, 50, 52, 33, 21, 26, 24, 26, 24, 25, 24, 25,
24, 23, 24, 23, 22, 22, 21, 21, 19, 19, 17, 18, 15, 15, 13, 13, 11, 10, 9, 8, 6,
6, 4, -21, -24, -22, -24, -24, -25, -24, -26, -25, -27, -27, -27, -27, -27, -28,
-29, -29, -30, -30, -31, -32, -32, -32, -33, -33, -34, -35, -34, -35, -36, -36,
-36, -37, -40, -44, -46, -49, -52, -55, -56, -58, -61, -63, -64, -67, -68, -69,
-72, -73, -75, -75, -77, -77, -79, -80, -82, -81, -82, -83, -84, -84, -86, -85,
-87, -110, -111, -109, -109, -107, -107, -105, -105, -104, -104, -101, -100,
-98, -97, -95, -94, -91, -90, -87, -85, -82, -81, -78, -75, -72, -69, -67, -64,
-62, -58, -57, -51, -68, -73, -65, -64, -59, -56, -52, -48, -44, -41, -36, -34,
-30, -26, -23, -20, -16, -12, -9, -5, -2, };