#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0135

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 14, 23, 33, 41, 51, 58, 68, 75, 83,
89, 95, 102, 105, 110, 113, 116, 118, 119, 120, 119, 119, 117, 116, 114, 113,
111, 108, 106, 103, 101, 98, 97, 95, 92, 90, 88, 86, 85, 82, 81, 79, 77, 75, 73,
70, 68, 66, 64, 61, 59, 57, 55, 53, 52, 50, 47, 46, 45, 43, 43, 41, 39, 38, 37,
36, 35, 33, 32, 31, 29, 27, 24, 22, 19, 16, 13, 9, 6, 2, 0, -4, -8, -10, -13,
-16, -19, -21, -23, -25, -27, -28, -28, -29, -29, -30, -30, -29, -31, -31, -30,
-31, -31, -32, -33, -34, -35, -38, -40, -42, -44, -47, -49, -52, -56, -58, -62,
-63, -65, -67, -68, -70, -70, -72, -71, -71, -69, -69, -68, -66, -64, -63, -61,
-60, -57, -57, -55, -53, -53, -52, -52, -52, -53, -54, -54, -55, -56, -58, -59,
-60, -60, -61, -62, -63, -62, -61, -60, -60, -58, -57, -55, -54, -50, -48, -46,
-42, -40, -37, -35, -33, -31, -29, -27, -26, -25, -23, -23, -23, -22, -22, -22,
-22, -21, -22, -22, -21, -21, -20, -20, -19, -18, -16, -16, -15, -13, -13, -11,
-10, -8, -7, -5, -4, -3, -2, -2, -1, 0, 1, 2, 3, 2, 3, 3, 4, 4, 4, 5, 5, 5, 5,
6, 5, 7, 7, 6, 5, 4, 3, 2, 0, -2, -3, -7, -10, -13, -15, -19, -23, -26, -30,
-33, -36, -38, -40, -43, -42, -44, -44, -42, -40, -37, -34, -30, -25, -20, -14,
-8, 0, 7, 15, 21, 28, 36, 42, 48, 54, 60, 64, 68, 72, 73, 76, 77, 77, 77, 76,
75, 74, 72, 69, 67, 64, 62, 58, 55, 52, 49, 47, 44, 42, 39, 36, 35, 33, 31, 29,
27, 25, 24, 23, 21, 19, 17, 16, 15, 14, 13, 12, 10, 10, 9, 8, 8, 7, 8, 7, 7, 8,
8, 8, 9, 9, 10, 10, 10, 10, 11, 11, 11, 10, 10, 9, 8, 6, 6, 4, 4, 2, 0, 0, -2,
-2, -2, -2, -2, -2, -1, 0, 1, 2, 3, 6, 8, 9, 11, 13, 14, 16, 17, 18, 19, 19, 19,
18, 18, 17, 16, 14, 12, 11, 8, 7, 5, 4, 3, 1, 0, 0, -1, 0, 0, 0, 1, 2, 3, 5, 7,
9, 9, 11, 12, 14, 14, 14, 14, 13, 13, 12, 11, 9, 7, 5, 3, 1, -2, -4, -6, -9,
-10, -12, -14, -16, -17, -17, -18, -17, -17, -17, -16, -16, -15, -14, -14, -13,
-13, -12, -12, -13, -12, -13, -14, -15, -16, -17, -19, -20, -23, -24, -26, -27,
-29, -29, -31, -32, -33, -34, -36, -36, -35, -36, -36, -35, -35, -35, -34, -34,
-34, -33, -33, -33, -32, -32, -33, -32, -31, -31, -32, -31, -30, -31, -30, -30,
-29, -28, -28, -27, -26, -26, -25, -25, -25, -24, -24, -25, -25, -25, -27, -28,
-29, -31, -33, -34, -37, -40, -42, -44, -45, -47, -47, -47, -47, -47, -46, -44,
-41, -38, -33, -27, -22, -16, -8, -1, };