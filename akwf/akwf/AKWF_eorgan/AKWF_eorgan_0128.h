#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0128

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 7, 9, 11, 14, 16, 18, 21,
22, 25, 28, 30, 33, 36, 38, 41, 43, 46, 50, 53, 55, 59, 61, 65, 67, 70, 73, 76,
78, 81, 84, 87, 88, 90, 93, 97, 98, 100, 102, 104, 105, 108, 109, 111, 112, 113,
114, 115, 116, 117, 117, 117, 118, 119, 119, 119, 119, 119, 119, 118, 118, 116,
117, 116, 115, 114, 113, 112, 111, 110, 108, 106, 105, 103, 103, 101, 100, 98,
94, 94, 92, 90, 89, 87, 85, 84, 80, 79, 77, 76, 73, 71, 70, 68, 66, 65, 64, 62,
60, 59, 56, 55, 54, 53, 52, 50, 48, 48, 46, 45, 44, 43, 42, 41, 40, 40, 38, 38,
37, 37, 36, 36, 34, 34, 34, 34, 33, 32, 32, 32, 31, 31, 31, 31, 31, 30, 30, 30,
30, 30, 29, 30, 30, 30, 30, 29, 30, 30, 31, 30, 30, 31, 31, 31, 31, 30, 30, 31,
32, 31, 32, 32, 32, 32, 33, 33, 33, 33, 33, 33, 34, 33, 34, 33, 33, 34, 33, 33,
33, 34, 32, 32, 33, 33, 32, 32, 32, 32, 32, 31, 31, 30, 29, 29, 28, 27, 27, 25,
25, 24, 24, 23, 21, 21, 18, 18, 16, 14, 13, 11, 11, 9, 7, 5, 3, 2, 0, -2, -4,
-6, -7, -10, -12, -14, -15, -17, -19, -22, -24, -26, -27, -29, -32, -33, -35,
-37, -39, -41, -43, -45, -46, -48, -50, -50, -53, -54, -55, -57, -58, -59, -60,
-61, -62, -62, -63, -64, -64, -64, -65, -66, -65, -65, -66, -66, -66, -66, -65,
-65, -65, -65, -64, -63, -63, -62, -62, -62, -61, -61, -59, -58, -59, -57, -56,
-56, -56, -55, -54, -54, -53, -53, -52, -51, -51, -51, -51, -50, -50, -49, -50,
-49, -50, -50, -49, -50, -51, -52, -51, -52, -52, -53, -53, -53, -55, -55, -56,
-57, -59, -60, -60, -62, -63, -64, -66, -66, -67, -69, -70, -71, -72, -72, -75,
-75, -76, -78, -80, -80, -81, -82, -83, -84, -85, -86, -86, -86, -87, -88, -89,
-89, -89, -91, -91, -91, -91, -90, -91, -90, -90, -90, -90, -90, -89, -88, -88,
-88, -87, -86, -86, -84, -83, -82, -81, -80, -80, -79, -77, -76, -74, -74, -72,
-71, -69, -69, -66, -64, -64, -62, -60, -59, -58, -56, -55, -53, -51, -49, -49,
-47, -46, -43, -41, -40, -39, -37, -36, -35, -33, -32, -30, -29, -27, -25, -25,
-24, -22, -21, -19, -18, -17, -16, -15, -14, -12, -11, -9, -9, -7, -7, -6, -5,
-4, -3, -2, -1, -1, 0, 1, 1, 3, 3, 3, 5, 5, 5, 6, 5, 5, 7, 7, 6, 7, 8, 7, 7, 7,
7, 6, 6, 6, 6, 6, 6, 5, 5, 4, 3, 2, 3, 2, 1, 1, 0, 0, -1, -2, -3, -3, -4, -5,
-5, -5, -7, -7, -8, -8, -9, -9, -10, -10, -10, -10, -10, -10, -10, -11, -11,
-11, -11, -10, -9, -10, -9, -9, -8, -7, -7, -5, -4, -3, -2, 0, };