#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0105

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 13, 17, 23, 27, 32, 37, 42, 47,
52, 55, 59, 64, 67, 70, 75, 78, 81, 85, 87, 90, 93, 96, 98, 100, 102, 104, 107,
108, 110, 111, 113, 114, 116, 116, 117, 118, 119, 119, 119, 119, 118, 118, 119,
119, 118, 117, 117, 116, 114, 113, 112, 111, 109, 108, 106, 104, 102, 100, 98,
97, 94, 91, 88, 87, 85, 82, 79, 77, 75, 73, 70, 69, 66, 64, 62, 60, 58, 57, 55,
53, 52, 50, 49, 48, 47, 45, 44, 43, 42, 42, 41, 40, 38, 38, 38, 37, 38, 37, 36,
37, 37, 37, 38, 37, 37, 38, 39, 39, 40, 40, 42, 42, 43, 44, 45, 46, 47, 48, 50,
51, 53, 53, 54, 57, 58, 60, 61, 63, 64, 66, 68, 69, 69, 71, 72, 73, 73, 75, 74,
75, 76, 76, 77, 78, 76, 76, 76, 76, 76, 76, 75, 75, 73, 72, 71, 70, 69, 68, 67,
65, 63, 63, 60, 58, 56, 54, 52, 50, 48, 45, 43, 41, 38, 35, 33, 31, 26, 24, 21,
18, 14, 13, 9, 5, 3, -1, -4, -7, -10, -14, -17, -20, -23, -26, -30, -33, -37,
-39, -42, -44, -46, -48, -50, -53, -54, -56, -59, -60, -61, -62, -64, -64, -66,
-66, -67, -68, -69, -68, -69, -69, -69, -68, -68, -68, -68, -67, -66, -65, -64,
-62, -61, -60, -59, -57, -55, -53, -51, -49, -47, -44, -42, -40, -38, -35, -31,
-29, -26, -23, -20, -17, -13, -9, -6, -3, 2, 4, 8, 11, 15, 18, 22, 25, 27, 30,
32, 36, 38, 41, 43, 45, 48, 51, 52, 54, 56, 57, 59, 60, 62, 63, 64, 65, 66, 67,
67, 67, 68, 68, 68, 68, 68, 67, 67, 67, 66, 66, 65, 64, 62, 60, 60, 58, 57, 54,
53, 51, 49, 46, 43, 42, 38, 35, 33, 30, 28, 24, 22, 17, 14, 11, 7, 5, 0, -2, -6,
-9, -12, -15, -17, -21, -24, -27, -30, -32, -35, -38, -40, -43, -46, -48, -51,
-52, -54, -56, -59, -59, -62, -65, -66, -67, -69, -70, -71, -72, -73, -74, -75,
-76, -76, -77, -77, -77, -78, -77, -77, -78, -77, -77, -77, -77, -74, -74, -74,
-73, -72, -70, -69, -68, -67, -65, -63, -62, -61, -59, -57, -56, -54, -53, -51,
-50, -48, -47, -46, -45, -44, -43, -42, -41, -41, -40, -39, -38, -38, -38, -37,
-37, -37, -37, -37, -37, -38, -38, -38, -38, -39, -39, -40, -40, -41, -42, -43,
-43, -44, -46, -47, -49, -49, -51, -53, -54, -55, -58, -60, -61, -63, -65, -67,
-69, -71, -74, -75, -77, -80, -82, -86, -88, -91, -92, -95, -97, -99, -101,
-102, -105, -107, -108, -110, -111, -113, -114, -115, -116, -117, -117, -118,
-117, -118, -118, -118, -118, -118, -117, -117, -116, -115, -114, -113, -111,
-111, -110, -107, -106, -104, -102, -100, -98, -96, -92, -90, -87, -84, -81,
-77, -73, -70, -67, -62, -59, -55, -50, -46, -41, -37, -33, -28, -23, -18, -12,
-7, -2, };