#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0133

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 3, 5, 6, 8, 10, 11, 14, 16,
19, 22, 24, 27, 30, 33, 36, 40, 43, 46, 51, 55, 58, 61, 65, 69, 74, 77, 81, 84,
88, 92, 95, 98, 100, 103, 105, 107, 110, 112, 113, 115, 117, 117, 118, 118, 119,
119, 120, 118, 118, 118, 116, 116, 114, 113, 111, 110, 109, 106, 104, 103, 100,
98, 97, 94, 91, 90, 87, 85, 82, 80, 77, 76, 73, 71, 68, 66, 64, 60, 59, 56, 53,
51, 49, 45, 43, 41, 39, 35, 34, 32, 29, 27, 23, 21, 19, 16, 13, 11, 8, 7, 4, 2,
-1, -3, -6, -9, -11, -13, -16, -18, -20, -24, -26, -28, -30, -33, -35, -37, -41,
-43, -45, -48, -49, -52, -54, -56, -59, -61, -62, -65, -67, -68, -71, -72, -74,
-75, -77, -78, -80, -81, -82, -83, -85, -86, -86, -87, -88, -89, -90, -90, -91,
-92, -92, -92, -93, -93, -93, -94, -93, -94, -95, -94, -95, -95, -95, -95, -95,
-96, -95, -96, -96, -96, -95, -96, -95, -96, -96, -96, -96, -95, -95, -96, -95,
-95, -94, -95, -94, -93, -92, -92, -92, -91, -90, -90, -89, -87, -88, -87, -86,
-85, -84, -83, -82, -81, -79, -79, -78, -77, -75, -75, -72, -72, -71, -69, -68,
-66, -65, -64, -63, -62, -61, -60, -58, -57, -56, -55, -54, -52, -51, -50, -49,
-48, -47, -46, -45, -43, -44, -43, -41, -41, -40, -40, -39, -39, -38, -38, -37,
-36, -35, -35, -34, -33, -32, -31, -31, -30, -28, -27, -25, -23, -23, -20, -18,
-15, -14, -10, -8, -6, -2, 1, 5, 8, 12, 15, 18, 22, 25, 30, 34, 38, 40, 45, 48,
52, 56, 59, 63, 66, 68, 71, 74, 76, 79, 81, 83, 84, 86, 87, 89, 88, 90, 89, 91,
91, 90, 90, 91, 89, 89, 88, 87, 87, 85, 85, 82, 82, 80, 79, 77, 76, 75, 74, 73,
71, 70, 68, 66, 67, 65, 63, 63, 61, 59, 58, 56, 56, 55, 53, 53, 51, 50, 49, 48,
46, 46, 44, 43, 42, 42, 41, 39, 38, 37, 36, 35, 34, 33, 31, 30, 30, 28, 27, 26,
25, 25, 24, 22, 21, 20, 19, 17, 17, 16, 14, 13, 11, 11, 10, 9, 7, 6, 5, 4, 3, 2,
1, -1, -1, -3, -4, -4, -5, -5, -6, -8, -9, -9, -9, -11, -10, -10, -11, -12, -12,
-12, -14, -13, -14, -14, -15, -14, -15, -15, -15, -15, -15, -15, -16, -17, -17,
-17, -18, -19, -19, -19, -20, -20, -20, -22, -21, -21, -22, -23, -24, -24, -24,
-25, -26, -26, -26, -27, -28, -28, -27, -27, -28, -28, -29, -29, -28, -28, -29,
-29, -29, -28, -28, -29, -28, -28, -27, -26, -26, -26, -26, -25, -25, -25, -24,
-24, -24, -22, -21, -22, -21, -20, -20, -19, -19, -17, -16, -16, -15, -15, -15,
-13, -13, -12, -12, -12, -10, -10, -9, -9, -9, -7, -7, -7, -7, -6, -5, -5, -4,
-4, -4, -4, -2, -1, -1, -1, };