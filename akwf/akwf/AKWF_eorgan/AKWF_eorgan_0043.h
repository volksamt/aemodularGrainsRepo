#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0043

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 4, 6, 7, 8, 9, 11, 11, 12,
14, 15, 15, 17, 18, 19, 19, 20, 23, 30, 37, 44, 49, 56, 61, 65, 70, 74, 76, 80,
82, 84, 86, 88, 88, 89, 88, 88, 87, 86, 85, 84, 83, 79, 78, 73, 74, 65, 71, 27,
-15, -10, -15, -10, -14, -12, -13, -12, -13, -12, -14, -14, -15, -13, -12, -12,
-11, -11, -8, -9, -6, -7, -3, -5, 0, -1, 2, 0, 5, 0, 11, -6, -64, -54, -52, -45,
-39, -34, -30, -27, -22, -18, -14, -13, -9, -8, -5, -3, -1, -1, 0, 0, 1, -1, -1,
-2, -2, -3, -1, -4, -2, -7, 0, -38, -77, -70, -70, -63, -61, -56, -54, -49, -47,
-42, -40, -37, -33, -30, -27, -26, -21, -20, -18, -17, -14, -12, -11, -10, -7,
-5, -4, -4, -3, -3, -3, -3, -5, -12, -19, -25, -30, -35, -40, -45, -49, -52,
-56, -58, -61, -63, -65, -65, -68, -67, -69, -68, -69, -68, -67, -66, -66, -66,
-64, -65, -59, -61, -50, -93, -125, -110, -109, -96, -93, -82, -77, -67, -61,
-52, -45, -37, -30, -22, -15, -8, 0, 7, 15, 20, 27, 32, 40, 43, 50, 52, 61, 59,
69, 66, 78, 59, 5, 18, 21, 28, 32, 37, 42, 46, 50, 53, 56, 58, 61, 63, 66, 67,
68, 68, 68, 68, 68, 66, 66, 65, 66, 64, 66, 63, 66, 61, 70, 24, -10, 0, 0, 8, 9,
14, 16, 21, 24, 28, 31, 34, 36, 39, 43, 46, 47, 48, 50, 50, 52, 52, 52, 51, 51,
49, 48, 46, 45, 42, 40, 37, 38, 43, 45, 49, 51, 54, 55, 57, 57, 58, 58, 60, 59,
58, 57, 57, 55, 54, 52, 51, 48, 46, 43, 41, 38, 36, 34, 29, 28, 22, 27, -28,
-60, -50, -56, -50, -53, -48, -50, -47, -48, -45, -46, -44, -43, -42, -41, -40,
-40, -39, -37, -38, -36, -36, -33, -35, -32, -33, -30, -33, -27, -35, -23, -48,
-102, -89, -89, -83, -81, -76, -73, -68, -64, -60, -56, -52, -48, -44, -40, -36,
-31, -27, -25, -21, -19, -16, -12, -9, -6, -4, 0, 2, 6, 6, 16, -34, -59, -45,
-45, -34, -32, -22, -20, -13, -9, -3, 1, 5, 9, 12, 16, 20, 22, 23, 26, 28, 30,
30, 32, 32, 33, 33, 34, 33, 32, 31, 31, 29, 23, 15, 9, 3, -2, -8, -13, -18, -20,
-23, -26, -29, -31, -32, -34, -33, -35, -34, -34, -33, -34, -33, -31, -29, -26,
-23, -22, -20, -17, -18, -8, -63, -85, -69, -70, -59, -59, -49, -48, -40, -38,
-31, -29, -23, -20, -16, -12, -7, -3, 0, 4, 7, 11, 12, 18, 19, 24, 23, 29, 27,
35, 29, 43, 14, -38, -21, -22, -14, -11, -6, -3, 2, 6, 11, 14, 17, 21, 23, 25,
28, 29, 32, 34, 35, 35, 36, 36, 37, 37, 37, 37, 36, 37, 34, 40, -19, -41, -29,
-31, -23, -23, -17, -16, -12, -10, -6, -5, -2, -1, };