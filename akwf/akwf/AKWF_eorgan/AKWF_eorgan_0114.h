#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0114

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 15, 20, 26, 30, 34, 39, 43, 47,
52, 54, 58, 62, 64, 67, 70, 73, 75, 77, 80, 82, 84, 85, 86, 88, 89, 90, 91, 93,
94, 96, 96, 96, 97, 99, 98, 100, 99, 99, 99, 100, 100, 100, 100, 101, 101, 99,
99, 100, 100, 99, 98, 98, 98, 95, 95, 94, 94, 92, 92, 91, 90, 89, 88, 86, 85,
83, 83, 82, 81, 80, 78, 78, 76, 76, 74, 73, 73, 72, 70, 70, 68, 68, 67, 67, 67,
67, 66, 65, 66, 65, 65, 65, 66, 66, 66, 66, 66, 67, 68, 68, 69, 70, 70, 71, 72,
72, 74, 75, 76, 78, 79, 80, 81, 83, 84, 85, 86, 88, 89, 92, 93, 94, 95, 97, 98,
99, 101, 103, 104, 105, 106, 107, 108, 110, 110, 111, 112, 112, 113, 114, 115,
115, 116, 116, 117, 117, 117, 118, 118, 118, 119, 119, 119, 119, 119, 119, 119,
118, 118, 119, 117, 117, 117, 117, 116, 116, 114, 115, 113, 113, 113, 111, 110,
109, 109, 107, 106, 104, 103, 102, 100, 98, 97, 95, 93, 91, 89, 87, 85, 82, 80,
78, 75, 73, 69, 67, 63, 61, 58, 55, 52, 49, 46, 44, 41, 38, 35, 32, 29, 27, 24,
21, 19, 16, 14, 11, 9, 6, 4, 2, 0, -2, -3, -5, -7, -8, -10, -10, -11, -13, -12,
-13, -13, -14, -14, -15, -15, -15, -15, -15, -14, -14, -13, -12, -11, -11, -10,
-9, -8, -7, -6, -5, -3, -3, -1, 0, 2, 2, 3, 5, 6, 7, 9, 8, 10, 11, 11, 12, 12,
12, 12, 12, 12, 12, 11, 11, 11, 10, 10, 9, 8, 7, 6, 4, 3, 1, 0, -1, -3, -6, -7,
-10, -12, -14, -16, -20, -22, -24, -27, -29, -32, -35, -38, -41, -44, -46, -49,
-53, -56, -58, -61, -64, -67, -69, -72, -74, -76, -79, -82, -84, -87, -88, -91,
-93, -95, -96, -98, -100, -101, -103, -105, -105, -106, -108, -109, -110, -112,
-112, -113, -114, -114, -115, -116, -116, -117, -117, -118, -117, -118, -119,
-118, -119, -119, -119, -119, -119, -119, -118, -119, -119, -118, -118, -118,
-117, -117, -117, -115, -115, -114, -114, -112, -113, -112, -111, -109, -109,
-108, -107, -105, -104, -103, -102, -100, -99, -97, -95, -94, -93, -91, -90,
-89, -87, -86, -85, -83, -81, -80, -79, -77, -76, -75, -75, -73, -73, -71, -70,
-69, -69, -68, -67, -67, -66, -66, -66, -65, -66, -64, -65, -65, -65, -66, -66,
-66, -67, -66, -67, -67, -68, -69, -70, -71, -72, -72, -74, -74, -76, -77, -78,
-78, -80, -80, -83, -83, -85, -85, -86, -87, -89, -90, -91, -91, -92, -93, -95,
-96, -96, -97, -97, -97, -98, -98, -98, -99, -99, -99, -100, -100, -100, -98,
-100, -99, -98, -98, -97, -97, -97, -96, -95, -94, -93, -92, -91, -90, -89, -87,
-86, -84, -83, -81, -78, -76, -74, -71, -69, -66, -63, -61, -57, -55, -50, -46,
-43, -38, -34, -29, -24, -19, -13, -8, -2, };