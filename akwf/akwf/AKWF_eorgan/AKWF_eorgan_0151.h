#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0151

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 5, 7, 8, 11, 13, 13, 15, 17,
19, 21, 23, 24, 26, 29, 31, 32, 34, 36, 39, 40, 41, 45, 46, 49, 50, 53, 54, 57,
59, 60, 63, 65, 67, 69, 71, 73, 75, 77, 79, 81, 83, 85, 87, 88, 90, 93, 94, 95,
96, 99, 100, 100, 103, 104, 105, 106, 108, 108, 109, 111, 112, 112, 113, 114,
116, 116, 116, 117, 118, 118, 118, 118, 119, 119, 118, 118, 119, 119, 118, 119,
119, 118, 118, 118, 117, 117, 117, 116, 116, 114, 115, 113, 113, 112, 111, 110,
109, 108, 108, 108, 106, 105, 103, 102, 101, 101, 99, 99, 97, 97, 95, 94, 92,
91, 90, 89, 88, 86, 85, 83, 83, 82, 80, 79, 78, 77, 75, 74, 73, 71, 71, 70, 67,
67, 66, 65, 63, 62, 61, 60, 58, 57, 56, 55, 54, 53, 52, 51, 50, 48, 48, 46, 45,
44, 42, 42, 41, 40, 39, 37, 37, 36, 34, 33, 33, 31, 31, 30, 28, 26, 26, 24, 24,
22, 22, 20, 18, 17, 17, 16, 14, 12, 11, 10, 9, 7, 6, 5, 4, 2, 2, 0, -1, -2, -4,
-7, -7, -9, -11, -11, -12, -14, -15, -17, -19, -20, -22, -23, -24, -25, -28,
-29, -30, -32, -32, -34, -36, -37, -39, -41, -41, -42, -44, -44, -46, -48, -49,
-50, -50, -53, -53, -55, -56, -57, -57, -59, -59, -61, -61, -61, -63, -63, -64,
-64, -66, -65, -66, -66, -67, -66, -67, -68, -67, -68, -68, -68, -68, -67, -68,
-67, -67, -67, -67, -66, -66, -67, -65, -66, -66, -64, -64, -64, -63, -63, -61,
-61, -60, -60, -57, -58, -56, -56, -55, -54, -54, -52, -51, -51, -49, -48, -48,
-46, -46, -45, -44, -44, -42, -41, -40, -40, -39, -38, -38, -36, -35, -35, -34,
-34, -33, -33, -31, -31, -31, -30, -29, -29, -29, -29, -29, -28, -28, -28, -27,
-28, -27, -26, -27, -27, -27, -27, -27, -27, -27, -27, -28, -27, -29, -28, -28,
-30, -30, -31, -30, -32, -32, -32, -33, -33, -34, -34, -36, -35, -37, -37, -38,
-39, -39, -40, -41, -41, -41, -43, -43, -44, -45, -45, -46, -46, -48, -48, -49,
-49, -50, -50, -51, -51, -52, -53, -53, -54, -55, -55, -55, -56, -56, -56, -56,
-57, -56, -57, -58, -57, -58, -57, -58, -58, -58, -58, -58, -58, -57, -58, -58,
-58, -56, -57, -56, -57, -56, -56, -56, -55, -56, -54, -55, -54, -54, -53, -54,
-53, -52, -51, -52, -50, -50, -50, -50, -49, -50, -49, -48, -48, -48, -46, -47,
-46, -45, -45, -44, -44, -44, -44, -43, -43, -42, -42, -41, -41, -41, -39, -40,
-40, -39, -38, -38, -37, -37, -37, -37, -36, -36, -35, -35, -35, -35, -35, -33,
-33, -33, -32, -31, -32, -31, -30, -29, -29, -29, -29, -29, -28, -27, -26, -26,
-26, -24, -24, -23, -23, -22, -21, -20, -20, -19, -18, -16, -15, -14, -14, -12,
-11, -11, -9, -7, -7, -6, -5, -3, -2, 0, };