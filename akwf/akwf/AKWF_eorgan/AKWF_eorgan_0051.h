#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0051

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 9, 12, 16, 18, 23, 26, 29,
34, 38, 43, 48, 53, 57, 62, 66, 70, 75, 79, 84, 88, 91, 95, 97, 99, 102, 104,
108, 109, 111, 113, 113, 114, 115, 117, 117, 118, 119, 119, 118, 119, 119, 119,
119, 118, 119, 118, 117, 116, 115, 114, 113, 111, 110, 108, 107, 105, 103, 102,
100, 97, 94, 92, 90, 87, 85, 82, 80, 77, 73, 71, 68, 65, 62, 59, 56, 55, 51, 49,
46, 44, 41, 39, 36, 34, 31, 29, 27, 24, 22, 19, 16, 14, 12, 10, 8, 7, 5, 4, 2,
1, 0, 0, -1, -2, -2, -3, -4, -4, -4, -5, -5, -6, -6, -6, -7, -7, -7, -8, -10,
-9, -10, -10, -11, -11, -12, -11, -12, -13, -14, -14, -15, -15, -15, -16, -16,
-17, -17, -17, -18, -18, -18, -19, -19, -19, -19, -20, -20, -20, -22, -22, -22,
-23, -25, -25, -27, -28, -28, -29, -30, -31, -31, -33, -33, -34, -34, -35, -36,
-37, -37, -37, -38, -38, -39, -38, -40, -40, -40, -42, -42, -43, -44, -45, -46,
-48, -50, -50, -52, -53, -54, -55, -58, -58, -60, -62, -64, -64, -66, -68, -70,
-71, -72, -73, -74, -75, -75, -77, -77, -78, -79, -80, -81, -82, -82, -83, -83,
-85, -84, -85, -85, -85, -85, -84, -84, -82, -81, -80, -78, -78, -74, -72, -70,
-67, -65, -61, -57, -53, -50, -46, -42, -38, -35, -29, -26, -22, -18, -14, -11,
-7, -5, -3, 0, 2, 5, 6, 10, 12, 15, 17, 20, 23, 26, 29, 33, 36, 40, 44, 48, 52,
56, 60, 64, 69, 72, 75, 79, 81, 85, 88, 90, 92, 94, 96, 97, 99, 101, 102, 102,
103, 104, 105, 105, 104, 104, 105, 105, 105, 104, 103, 104, 103, 102, 102, 100,
99, 98, 97, 95, 94, 92, 90, 87, 86, 84, 83, 80, 78, 76, 75, 72, 71, 68, 66, 64,
61, 59, 57, 54, 52, 50, 47, 45, 43, 42, 39, 38, 35, 34, 31, 29, 28, 25, 23, 22,
19, 18, 15, 14, 12, 11, 10, 8, 6, 5, 5, 3, 3, 1, 0, 1, 0, 0, 0, -2, -1, -1, -2,
-1, -2, -2, -2, -3, -2, -3, -4, -4, -3, -4, -5, -6, -4, -5, -6, -6, -7, -8, -8,
-9, -8, -9, -11, -11, -11, -12, -12, -13, -13, -13, -14, -15, -15, -16, -17,
-17, -18, -19, -20, -22, -23, -25, -25, -26, -28, -30, -31, -33, -34, -35, -38,
-39, -40, -41, -43, -44, -46, -47, -48, -50, -52, -52, -55, -56, -58, -59, -63,
-64, -66, -69, -71, -73, -76, -78, -80, -82, -83, -85, -87, -88, -88, -90, -91,
-94, -95, -96, -98, -99, -101, -101, -103, -104, -105, -106, -107, -108, -108,
-109, -110, -110, -110, -111, -111, -111, -111, -111, -111, -112, -110, -110,
-109, -108, -106, -105, -103, -101, -98, -96, -94, -91, -87, -83, -79, -75, -70,
-66, -61, -57, -52, -47, -43, -38, -33, -28, -24, -20, -15, -11, -7, -4, -2, -1,
};