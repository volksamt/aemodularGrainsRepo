#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0061

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 13, 27, 38, 50, 60, 70, 80, 89, 96,
103, 108, 113, 115, 118, 118, 119, 117, 116, 114, 110, 104, 100, 94, 89, 82, 77,
71, 65, 59, 53, 49, 44, 40, 36, 34, 32, 30, 30, 30, 29, 31, 33, 34, 36, 38, 40,
44, 46, 49, 52, 54, 57, 58, 60, 60, 62, 62, 62, 61, 61, 59, 58, 55, 53, 50, 46,
45, 41, 38, 35, 32, 29, 28, 25, 22, 20, 19, 19, 18, 17, 17, 17, 17, 18, 19, 20,
21, 21, 23, 24, 25, 25, 26, 27, 27, 28, 26, 26, 26, 24, 22, 22, 20, 17, 15, 12,
10, 8, 5, 3, 1, -1, -3, -4, -6, -8, -8, -8, -8, -9, -8, -8, -6, -7, -4, -3, -2,
1, 3, 3, 5, 6, 8, 8, 9, 10, 11, 11, 11, 11, 10, 9, 8, 7, 5, 5, 3, 2, 0, -1, -2,
-4, -5, -6, -6, -6, -6, -6, -5, -4, -3, -1, 1, 4, 6, 8, 10, 12, 16, 17, 21, 23,
25, 26, 28, 28, 29, 30, 29, 30, 29, 28, 26, 25, 23, 21, 19, 16, 15, 13, 11, 9,
7, 6, 5, 4, 3, 3, 3, 5, 6, 8, 8, 12, 13, 16, 18, 21, 24, 26, 28, 31, 32, 34, 35,
34, 34, 34, 31, 29, 26, 22, 17, 13, 6, 1, -7, -14, -20, -29, -36, -43, -51, -57,
-64, -70, -76, -79, -83, -85, -87, -89, -88, -86, -84, -79, -74, -69, -62, -55,
-47, -38, -29, -18, -8, 1, 11, 22, 31, 41, 50, 58, 65, 72, 76, 81, 84, 86, 88,
87, 87, 85, 81, 78, 73, 67, 61, 55, 47, 40, 33, 26, 18, 11, 4, -3, -9, -14, -19,
-23, -28, -31, -32, -34, -35, -35, -34, -35, -33, -30, -29, -26, -23, -21, -18,
-15, -14, -11, -9, -7, -6, -4, -4, -4, -4, -5, -6, -6, -8, -10, -11, -13, -16,
-17, -19, -22, -24, -25, -26, -28, -28, -30, -29, -29, -29, -28, -27, -24, -23,
-22, -19, -16, -15, -12, -9, -7, -4, -3, 0, 2, 3, 4, 4, 5, 6, 6, 5, 5, 5, 3, 2,
1, 0, -3, -4, -6, -6, -7, -9, -9, -10, -10, -10, -11, -11, -10, -10, -8, -7, -6,
-4, -3, -2, 1, 2, 3, 5, 6, 8, 8, 8, 8, 9, 9, 7, 7, 5, 3, 2, 0, -2, -4, -7, -10,
-11, -14, -16, -18, -20, -23, -24, -26, -26, -27, -27, -29, -28, -27, -26, -26,
-24, -25, -23, -22, -21, -20, -19, -18, -17, -17, -17, -16, -17, -18, -20, -21,
-23, -25, -27, -31, -33, -36, -39, -43, -45, -47, -50, -54, -56, -57, -60, -61,
-61, -63, -62, -62, -61, -59, -58, -56, -54, -51, -48, -45, -43, -40, -37, -35,
-32, -32, -30, -29, -29, -30, -30, -33, -34, -37, -41, -44, -50, -54, -60, -66,
-72, -78, -84, -90, -95, -101, -105, -109, -112, -115, -117, -118, -117, -116,
-113, -110, -105, -99, -92, -84, -76, -66, -56, -43, -32, -21, -8, };