#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0091

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 14, 20, 24, 30, 36, 41, 47, 51,
57, 61, 65, 69, 73, 77, 81, 84, 87, 92, 94, 97, 100, 102, 105, 107, 109, 110,
111, 113, 115, 116, 117, 118, 119, 118, 119, 119, 119, 119, 118, 118, 117, 116,
114, 114, 112, 111, 109, 107, 106, 103, 101, 97, 96, 93, 90, 86, 83, 80, 76, 72,
69, 65, 61, 57, 52, 49, 46, 42, 38, 35, 31, 29, 26, 23, 20, 17, 16, 13, 11, 9,
8, 6, 3, 2, 1, 0, -2, -3, -4, -5, -6, -7, -6, -6, -7, -7, -7, -7, -7, -7, -6,
-6, -6, -5, -3, -2, 0, 0, 1, 3, 4, 6, 8, 11, 12, 15, 16, 19, 22, 24, 28, 31, 34,
37, 40, 43, 47, 51, 55, 58, 62, 64, 67, 71, 73, 76, 78, 81, 82, 85, 87, 89, 91,
93, 95, 96, 97, 98, 100, 101, 102, 103, 103, 104, 104, 104, 104, 105, 105, 104,
105, 104, 104, 104, 103, 102, 101, 100, 98, 97, 96, 94, 92, 91, 89, 87, 84, 81,
78, 76, 73, 70, 66, 63, 60, 55, 52, 47, 44, 39, 34, 30, 27, 22, 18, 14, 11, 6,
2, -2, -4, -8, -12, -15, -18, -21, -23, -26, -29, -31, -34, -35, -38, -40, -41,
-42, -45, -46, -47, -48, -49, -50, -51, -52, -52, -52, -52, -52, -53, -52, -52,
-51, -50, -50, -49, -47, -46, -44, -44, -41, -40, -37, -35, -33, -32, -28, -25,
-23, -20, -16, -13, -11, -6, -3, 1, 4, 8, 11, 14, 18, 21, 23, 26, 29, 32, 34,
36, 39, 40, 41, 43, 44, 46, 48, 49, 49, 50, 50, 51, 51, 51, 51, 51, 52, 51, 51,
50, 49, 48, 46, 46, 44, 42, 41, 40, 37, 35, 34, 31, 29, 27, 24, 21, 18, 15, 12,
9, 6, 3, -1, -5, -9, -13, -17, -21, -25, -30, -34, -38, -42, -46, -52, -54, -59,
-62, -66, -69, -72, -75, -78, -81, -84, -86, -88, -91, -92, -94, -96, -97, -99,
-99, -101, -102, -103, -104, -104, -105, -105, -105, -106, -106, -105, -105,
-105, -104, -105, -104, -102, -102, -100, -100, -98, -97, -96, -94, -92, -90,
-88, -86, -84, -82, -80, -77, -74, -71, -68, -65, -62, -59, -56, -53, -49, -45,
-42, -38, -35, -31, -29, -26, -23, -20, -18, -15, -13, -11, -9, -7, -4, -3, -1,
0, 1, 2, 3, 3, 5, 5, 7, 7, 7, 7, 8, 7, 8, 7, 7, 7, 6, 6, 5, 4, 3, 1, -1, -1, -2,
-4, -6, -8, -9, -12, -14, -17, -19, -22, -25, -27, -31, -34, -36, -40, -44, -47,
-51, -56, -58, -63, -67, -70, -74, -78, -81, -84, -88, -91, -93, -96, -98, -101,
-103, -106, -108, -110, -111, -112, -114, -115, -116, -116, -117, -118, -118,
-118, -118, -118, -117, -116, -116, -115, -114, -113, -111, -110, -109, -106,
-104, -102, -100, -98, -93, -90, -88, -85, -81, -78, -74, -70, -65, -61, -57,
-52, -47, -41, -36, -32, -26, -20, -14, -9, -4, };