#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0110

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 10, 16, 20, 25, 30, 33, 37, 42,
46, 49, 52, 57, 59, 63, 66, 69, 72, 75, 78, 80, 83, 84, 86, 88, 89, 91, 93, 94,
95, 96, 98, 98, 99, 100, 101, 102, 102, 103, 103, 105, 105, 105, 105, 106, 108,
107, 108, 109, 109, 110, 110, 111, 112, 112, 113, 113, 113, 114, 114, 115, 116,
116, 116, 117, 118, 118, 118, 119, 118, 119, 119, 119, 119, 119, 119, 118, 119,
119, 118, 117, 117, 116, 115, 114, 114, 113, 112, 111, 110, 110, 108, 107, 106,
105, 104, 102, 101, 100, 99, 99, 97, 96, 96, 94, 94, 93, 93, 92, 92, 91, 91, 91,
91, 91, 91, 91, 90, 91, 91, 91, 92, 91, 92, 93, 93, 93, 95, 94, 95, 95, 96, 96,
96, 97, 97, 97, 97, 97, 97, 97, 98, 97, 97, 96, 96, 95, 94, 94, 93, 91, 91, 90,
88, 87, 86, 84, 83, 82, 81, 80, 78, 77, 76, 74, 73, 72, 70, 69, 68, 65, 65, 64,
62, 61, 59, 59, 58, 57, 56, 55, 54, 53, 53, 52, 51, 51, 50, 49, 49, 48, 47, 47,
45, 45, 44, 43, 42, 42, 41, 39, 39, 38, 36, 35, 33, 32, 32, 30, 28, 27, 26, 24,
22, 21, 19, 18, 16, 13, 12, 10, 10, 8, 6, 4, 3, 1, 0, -2, -3, -3, -4, -5, -6,
-8, -8, -8, -8, -9, -8, -9, -10, -9, -9, -8, -8, -8, -7, -6, -5, -4, -5, -3, -3,
-2, -1, 0, 2, 2, 3, 3, 4, 5, 5, 6, 7, 7, 7, 7, 8, 8, 8, 7, 6, 7, 5, 5, 5, 3, 3,
1, 1, -2, -2, -4, -4, -7, -7, -9, -10, -13, -14, -17, -18, -19, -21, -23, -24,
-27, -27, -28, -31, -31, -34, -35, -36, -36, -39, -39, -41, -41, -42, -43, -44,
-45, -45, -47, -46, -48, -49, -49, -50, -51, -52, -53, -53, -54, -53, -55, -57,
-57, -57, -58, -60, -61, -62, -63, -63, -65, -66, -68, -68, -70, -72, -73, -75,
-75, -77, -79, -79, -81, -82, -84, -86, -87, -87, -89, -89, -91, -91, -93, -94,
-94, -95, -95, -96, -97, -97, -98, -99, -98, -99, -98, -98, -98, -97, -97, -97,
-96, -96, -96, -95, -95, -94, -93, -94, -94, -92, -92, -92, -92, -91, -91, -90,
-91, -90, -91, -90, -90, -91, -91, -92, -93, -93, -94, -94, -95, -97, -97, -98,
-98, -99, -101, -101, -103, -104, -105, -106, -107, -108, -109, -110, -111,
-113, -113, -113, -115, -116, -116, -117, -117, -117, -118, -119, -118, -118,
-118, -118, -118, -119, -118, -118, -118, -118, -116, -116, -116, -115, -114,
-114, -114, -114, -112, -112, -111, -111, -110, -110, -110, -109, -108, -107,
-107, -106, -106, -105, -104, -104, -104, -103, -102, -102, -101, -100, -100,
-98, -98, -97, -97, -95, -94, -92, -91, -90, -88, -86, -85, -83, -80, -79, -76,
-73, -71, -68, -65, -61, -59, -55, -52, -48, -44, -40, -37, -32, -28, -24, -19,
-15, -11, -6, -2, };