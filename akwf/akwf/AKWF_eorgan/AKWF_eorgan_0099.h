#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0099

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 12, 20, 30, 37, 46, 54, 60, 68, 74,
79, 83, 87, 91, 93, 96, 98, 99, 99, 100, 100, 100, 99, 99, 98, 97, 95, 93, 90,
88, 86, 84, 80, 77, 75, 72, 68, 65, 62, 59, 56, 52, 48, 46, 42, 38, 36, 34, 32,
29, 28, 27, 25, 25, 25, 26, 28, 29, 33, 35, 39, 43, 46, 51, 56, 60, 65, 70, 73,
78, 81, 84, 87, 90, 93, 95, 97, 97, 97, 97, 97, 97, 96, 95, 94, 93, 92, 91, 89,
88, 87, 85, 84, 81, 80, 78, 76, 74, 72, 70, 68, 66, 64, 63, 61, 59, 57, 55, 54,
52, 51, 49, 48, 47, 47, 47, 48, 49, 50, 51, 54, 57, 60, 62, 67, 71, 75, 79, 85,
90, 94, 98, 102, 105, 109, 113, 114, 116, 118, 118, 118, 119, 119, 118, 117,
115, 114, 111, 110, 107, 105, 102, 101, 98, 96, 93, 91, 88, 85, 83, 80, 77, 76,
72, 70, 68, 65, 63, 60, 58, 56, 54, 51, 49, 48, 47, 46, 45, 44, 43, 43, 44, 45,
46, 47, 49, 52, 54, 56, 60, 63, 67, 69, 73, 77, 79, 81, 83, 84, 85, 86, 85, 85,
83, 81, 79, 76, 72, 68, 64, 60, 56, 50, 45, 40, 35, 30, 25, 20, 15, 9, 5, 0, -6,
-11, -15, -20, -24, -28, -33, -36, -39, -43, -46, -49, -51, -54, -55, -58, -58,
-59, -60, -58, -59, -57, -55, -53, -49, -46, -41, -36, -31, -26, -19, -12, -6,
1, 8, 14, 20, 27, 33, 37, 42, 46, 49, 52, 55, 56, 58, 58, 58, 57, 57, 56, 53,
52, 49, 46, 43, 40, 36, 32, 29, 25, 21, 16, 12, 6, 2, -3, -8, -13, -18, -24,
-28, -34, -40, -43, -49, -54, -58, -63, -67, -72, -75, -79, -81, -83, -85, -85,
-87, -87, -87, -85, -84, -81, -79, -76, -73, -70, -66, -63, -59, -57, -55, -51,
-50, -48, -46, -45, -45, -45, -45, -45, -46, -48, -49, -51, -52, -54, -56, -58,
-61, -62, -64, -67, -69, -71, -74, -77, -79, -82, -84, -87, -89, -92, -94, -97,
-99, -102, -105, -107, -109, -111, -114, -115, -116, -117, -118, -119, -119,
-119, -119, -116, -115, -113, -110, -108, -104, -100, -97, -92, -88, -82, -78,
-74, -69, -65, -61, -58, -55, -52, -51, -50, -48, -47, -46, -47, -47, -47, -49,
-51, -52, -53, -56, -56, -59, -61, -63, -65, -66, -69, -71, -72, -74, -76, -79,
-80, -82, -83, -85, -87, -88, -89, -91, -92, -92, -94, -96, -96, -97, -96, -96,
-97, -96, -95, -94, -91, -89, -86, -83, -80, -76, -71, -67, -63, -57, -53, -49,
-44, -40, -37, -33, -31, -28, -27, -26, -25, -24, -25, -26, -27, -29, -31, -33,
-36, -39, -41, -46, -48, -51, -55, -59, -62, -66, -68, -71, -74, -78, -81, -83,
-85, -88, -90, -91, -93, -95, -97, -98, -98, -98, -99, -98, -98, -96, -95, -93,
-90, -87, -83, -79, -75, -69, -63, -55, -48, -40, -32, -23, -14, -5, };