#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0078

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 18, 34, 48, 62, 74, 86, 95, 104,
110, 115, 118, 119, 119, 117, 114, 110, 105, 99, 94, 87, 80, 73, 68, 62, 57, 52,
49, 45, 43, 42, 41, 41, 42, 42, 43, 44, 45, 46, 47, 47, 48, 47, 48, 48, 46, 46,
45, 43, 41, 40, 38, 38, 38, 37, 37, 38, 39, 40, 40, 42, 44, 46, 49, 50, 51, 52,
53, 54, 53, 52, 50, 48, 45, 42, 37, 34, 29, 25, 18, 14, 10, 6, 4, 1, 1, 0, 0, 1,
2, 5, 7, 10, 13, 18, 20, 26, 29, 32, 34, 36, 37, 37, 37, 35, 33, 29, 26, 21, 15,
10, 4, -2, -8, -14, -18, -22, -24, -26, -28, -27, -28, -26, -23, -19, -15, -11,
-5, 1, 6, 12, 17, 21, 24, 28, 29, 30, 29, 29, 27, 25, 21, 17, 11, 7, 0, -5, -9,
-14, -18, -20, -23, -23, -24, -24, -22, -20, -16, -13, -8, -4, 2, 7, 12, 16, 21,
25, 29, 31, 33, 34, 35, 36, 35, 32, 31, 28, 23, 20, 17, 13, 10, 7, 4, 3, 2, 2,
2, 2, 4, 5, 6, 9, 11, 14, 17, 18, 21, 21, 23, 24, 25, 25, 25, 24, 24, 23, 21,
18, 17, 15, 15, 12, 13, 13, 12, 12, 12, 12, 12, 13, 13, 14, 13, 12, 11, 9, 6, 3,
-2, -7, -13, -20, -26, -34, -42, -50, -57, -65, -73, -79, -85, -89, -92, -93,
-94, -92, -89, -84, -78, -70, -61, -51, -38, -25, -11, 3, 16, 30, 43, 53, 64,
74, 80, 87, 90, 93, 94, 94, 91, 89, 84, 77, 70, 62, 55, 48, 39, 32, 23, 17, 11,
4, -1, -4, -8, -11, -11, -13, -13, -14, -13, -13, -13, -13, -13, -13, -13, -14,
-13, -14, -16, -17, -18, -19, -22, -23, -24, -25, -26, -25, -25, -25, -23, -22,
-20, -18, -16, -13, -11, -9, -6, -3, -3, -2, -1, -2, -2, -4, -6, -8, -11, -14,
-18, -22, -25, -28, -31, -34, -35, -36, -36, -34, -32, -30, -27, -23, -20, -15,
-10, -5, -1, 5, 9, 14, 18, 20, 22, 24, 24, 23, 22, 19, 16, 13, 8, 2, -3, -8,
-13, -18, -22, -26, -27, -29, -30, -29, -28, -26, -24, -19, -16, -10, -5, 2, 7,
12, 17, 21, 24, 26, 28, 28, 28, 26, 24, 20, 15, 10, 6, 0, -6, -12, -18, -23,
-27, -32, -35, -36, -38, -38, -38, -36, -33, -30, -29, -24, -20, -16, -12, -10,
-7, -3, -3, -1, 0, 0, 0, -1, -4, -8, -11, -15, -21, -25, -30, -35, -40, -43,
-47, -48, -51, -52, -53, -53, -53, -53, -51, -50, -47, -45, -44, -42, -41, -39,
-39, -38, -37, -37, -37, -38, -39, -40, -41, -44, -44, -46, -47, -49, -48, -47,
-47, -47, -46, -45, -44, -44, -42, -42, -41, -41, -41, -42, -43, -46, -48, -54,
-58, -63, -69, -75, -82, -88, -94, -100, -106, -110, -114, -117, -117, -117,
-115, -112, -106, -99, -91, -80, -68, -57, -42, -27, -11, };