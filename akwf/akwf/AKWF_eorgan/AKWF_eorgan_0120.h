#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0120

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 9, 16, 23, 29, 36, 42, 47, 52, 57,
62, 67, 72, 76, 80, 84, 87, 91, 94, 96, 99, 102, 104, 106, 108, 110, 112, 114,
114, 115, 116, 117, 118, 118, 118, 119, 119, 119, 118, 119, 117, 118, 116, 115,
114, 113, 112, 110, 108, 108, 106, 104, 101, 98, 97, 94, 92, 89, 86, 83, 80, 77,
73, 70, 66, 63, 59, 56, 52, 49, 45, 42, 39, 36, 33, 30, 27, 25, 23, 20, 17, 15,
13, 10, 8, 6, 3, 1, 0, -3, -4, -6, -8, -9, -11, -12, -13, -15, -15, -17, -19,
-19, -20, -22, -22, -22, -23, -25, -25, -25, -26, -27, -26, -26, -26, -27, -27,
-26, -27, -27, -26, -25, -25, -24, -24, -23, -21, -20, -18, -18, -16, -16, -14,
-13, -12, -10, -10, -10, -8, -8, -7, -6, -5, -4, -3, -3, -1, -1, -1, 0, 1, 1, 2,
3, 3, 4, 4, 5, 6, 5, 6, 7, 8, 9, 8, 9, 10, 9, 10, 10, 11, 11, 11, 10, 11, 10,
10, 10, 9, 7, 6, 6, 4, 3, 2, -1, -2, -4, -7, -9, -11, -14, -17, -20, -22, -25,
-27, -31, -33, -35, -37, -39, -41, -43, -45, -47, -50, -52, -53, -54, -56, -57,
-59, -61, -61, -62, -63, -64, -65, -65, -66, -66, -67, -67, -68, -67, -68, -67,
-67, -67, -66, -65, -65, -64, -62, -61, -60, -59, -56, -55, -53, -51, -48, -47,
-43, -40, -37, -35, -31, -27, -24, -20, -16, -12, -7, -3, 2, 6, 11, 15, 19, 22,
26, 31, 34, 36, 40, 42, 46, 48, 50, 53, 55, 56, 58, 60, 61, 62, 64, 64, 66, 66,
67, 68, 68, 68, 68, 68, 68, 68, 67, 67, 66, 65, 65, 63, 63, 62, 60, 59, 58, 58,
56, 53, 52, 50, 49, 46, 45, 42, 40, 39, 35, 34, 32, 29, 26, 23, 20, 18, 16, 13,
10, 7, 5, 3, 1, -1, -3, -4, -5, -6, -8, -9, -10, -10, -10, -11, -10, -12, -11,
-11, -11, -10, -10, -10, -9, -9, -9, -8, -7, -7, -7, -7, -6, -5, -4, -3, -2, -2,
-2, -1, 0, 1, 1, 2, 2, 3, 4, 5, 5, 6, 6, 8, 8, 9, 10, 12, 12, 13, 15, 16, 17,
18, 19, 21, 22, 22, 23, 24, 25, 26, 26, 26, 26, 27, 26, 27, 26, 26, 26, 25, 25,
24, 23, 24, 23, 22, 21, 20, 20, 19, 17, 15, 14, 14, 13, 11, 9, 8, 6, 4, 2, 1,
-1, -3, -6, -8, -10, -11, -13, -17, -19, -21, -24, -27, -29, -32, -35, -38, -41,
-45, -48, -51, -55, -58, -61, -65, -69, -72, -76, -79, -81, -84, -88, -90, -93,
-96, -98, -100, -102, -105, -107, -108, -110, -111, -113, -113, -115, -116,
-116, -117, -118, -118, -119, -119, -119, -118, -118, -118, -116, -117, -116,
-114, -113, -112, -110, -108, -107, -105, -102, -101, -97, -94, -92, -88, -85,
-80, -77, -73, -69, -63, -58, -54, -49, -43, -37, -31, -25, -18, -11, -3, };