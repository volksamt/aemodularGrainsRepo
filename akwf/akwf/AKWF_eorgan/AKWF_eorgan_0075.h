#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0075

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 10, 19, 27, 35, 44, 51, 59, 66, 72,
78, 84, 90, 95, 99, 102, 107, 110, 113, 115, 116, 118, 119, 119, 118, 119, 117,
116, 114, 113, 110, 108, 104, 100, 97, 94, 90, 87, 83, 80, 76, 71, 68, 65, 62,
59, 54, 53, 51, 48, 45, 43, 42, 41, 39, 38, 39, 38, 37, 38, 37, 39, 38, 40, 40,
41, 43, 44, 45, 46, 47, 48, 49, 49, 50, 51, 51, 52, 51, 52, 51, 50, 50, 50, 49,
48, 47, 47, 44, 43, 41, 39, 37, 34, 32, 28, 26, 22, 20, 17, 15, 12, 9, 7, 5, 3,
1, -1, -3, -4, -5, -7, -8, -9, -9, -9, -10, -9, -10, -9, -9, -8, -7, -6, -6, -5,
-3, -2, 0, 2, 4, 5, 6, 7, 8, 10, 11, 11, 13, 13, 14, 15, 14, 15, 15, 15, 15, 15,
14, 13, 13, 12, 11, 11, 9, 9, 7, 6, 4, 4, 3, 2, 0, -1, -1, -2, -2, -2, -3, -1,
0, 1, 2, 3, 4, 5, 7, 8, 11, 13, 14, 15, 18, 21, 22, 25, 26, 29, 31, 34, 36, 38,
39, 42, 44, 45, 45, 46, 47, 47, 47, 46, 46, 44, 43, 42, 40, 38, 34, 32, 28, 25,
23, 19, 14, 9, 5, 1, -4, -9, -13, -18, -22, -26, -32, -35, -40, -44, -47, -51,
-54, -56, -59, -60, -62, -62, -63, -64, -63, -63, -62, -60, -59, -57, -54, -51,
-48, -44, -40, -36, -32, -26, -21, -16, -11, -5, 1, 6, 13, 18, 23, 29, 33, 37,
42, 46, 50, 53, 55, 58, 60, 62, 62, 63, 63, 63, 63, 62, 61, 60, 57, 55, 52, 49,
46, 42, 38, 33, 29, 24, 20, 15, 11, 6, 1, -3, -8, -12, -16, -20, -24, -28, -31,
-33, -36, -40, -41, -42, -44, -45, -47, -48, -47, -48, -47, -46, -46, -44, -43,
-41, -39, -37, -35, -33, -31, -28, -26, -25, -21, -19, -18, -16, -14, -11, -9,
-7, -7, -5, -3, -3, -1, 0, 0, 1, 1, 1, 2, 2, 0, 0, -1, -2, -3, -3, -5, -7, -7,
-9, -10, -11, -12, -13, -13, -14, -15, -15, -15, -15, -15, -14, -14, -15, -14,
-13, -13, -11, -11, -10, -8, -7, -6, -4, -3, -1, 0, 2, 3, 4, 5, 6, 8, 9, 9, 9,
10, 9, 10, 9, 8, 8, 8, 7, 4, 3, 1, -1, -1, -4, -6, -8, -11, -13, -16, -19, -22,
-25, -27, -31, -33, -36, -38, -40, -42, -44, -46, -47, -48, -48, -49, -50, -52,
-52, -51, -52, -51, -52, -50, -50, -50, -49, -48, -47, -47, -45, -44, -43, -42,
-41, -40, -39, -39, -38, -37, -37, -38, -38, -37, -39, -41, -41, -43, -45, -46,
-49, -50, -53, -56, -59, -62, -66, -70, -73, -76, -80, -84, -88, -90, -95, -99,
-101, -105, -107, -110, -112, -115, -116, -118, -117, -119, -118, -116, -116,
-114, -112, -110, -107, -104, -100, -96, -91, -86, -80, -74, -67, -61, -54, -46,
-39, -31, -23, -14, -5, };