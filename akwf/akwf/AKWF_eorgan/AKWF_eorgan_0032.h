#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0032

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 9, 18, 28, 38, 47, 56, 66, 74, 82,
89, 96, 101, 106, 111, 113, 117, 118, 120, 119, 118, 117, 114, 112, 108, 106,
102, 98, 94, 90, 87, 83, 81, 77, 75, 72, 70, 68, 67, 66, 65, 65, 65, 64, 65, 64,
65, 65, 65, 66, 65, 65, 65, 64, 63, 62, 60, 59, 57, 55, 54, 51, 49, 46, 44, 42,
39, 37, 34, 33, 30, 28, 26, 24, 23, 20, 19, 18, 16, 16, 14, 14, 13, 12, 12, 12,
12, 12, 12, 12, 11, 11, 9, 8, 4, 3, 0, -1, -2, -2, -2, -3, -3, -4, -5, -5, -7,
-8, -10, -10, -12, -14, -16, -17, -19, -23, -24, -25, -26, -27, -28, -28, -26,
-25, -23, -22, -20, -17, -12, -9, -4, 0, 4, 8, 14, 16, 21, 24, 27, 29, 30, 31,
31, 31, 30, 29, 25, 23, 19, 16, 11, 7, 2, -3, -8, -12, -18, -21, -25, -29, -30,
-33, -35, -36, -37, -37, -36, -36, -34, -32, -30, -28, -25, -22, -19, -15, -13,
-9, -7, -4, -2, -1, 1, 2, 2, 2, 1, -1, -1, -3, -4, -5, -6, -6, -8, -8, -8, -8,
-9, -9, -9, -9, -9, -9, -10, -11, -12, -12, -13, -13, -13, -14, -15, -15, -14,
-15, -14, -14, -14, -16, -17, -19, -23, -25, -27, -30, -31, -31, -31, -32, -32,
-33, -33, -34, -34, -36, -34, -35, -36, -36, -37, -37, -37, -37, -37, -37, -34,
-33, -31, -29, -25, -22, -17, -11, -5, 1, 7, 14, 22, 30, 37, 45, 52, 59, 66, 73,
78, 84, 87, 91, 93, 95, 95, 95, 94, 92, 90, 87, 83, 78, 74, 69, 64, 59, 54, 48,
44, 39, 35, 30, 26, 24, 20, 18, 16, 14, 12, 10, 11, 9, 9, 8, 8, 7, 8, 7, 7, 6,
5, 5, 4, 3, 2, 0, -2, -4, -5, -6, -9, -10, -12, -15, -16, -17, -19, -21, -23,
-24, -25, -26, -27, -28, -28, -29, -28, -29, -28, -29, -28, -26, -27, -25, -24,
-22, -21, -19, -19, -18, -18, -19, -20, -22, -22, -23, -22, -21, -19, -18, -18,
-17, -16, -17, -17, -16, -17, -18, -19, -20, -23, -24, -26, -28, -30, -31, -32,
-33, -34, -34, -33, -32, -30, -28, -26, -22, -19, -15, -9, -6, -1, 5, 9, 13, 17,
21, 25, 27, 28, 31, 30, 30, 30, 29, 27, 22, 19, 16, 11, 6, 1, -3, -9, -15, -19,
-23, -28, -32, -36, -38, -40, -43, -44, -44, -44, -44, -43, -43, -40, -39, -37,
-35, -33, -30, -28, -25, -24, -22, -20, -19, -19, -19, -20, -21, -23, -24, -27,
-29, -31, -33, -34, -37, -37, -39, -41, -41, -41, -43, -44, -45, -46, -47, -48,
-49, -50, -52, -53, -54, -55, -55, -56, -56, -57, -56, -57, -56, -57, -58, -59,
-61, -64, -66, -68, -69, -70, -69, -69, -69, -70, -69, -69, -68, -67, -68, -67,
-67, -66, -65, -65, -64, -62, -62, -61, -58, -56, -53, -50, -45, -40, -34, -28,
-21, -15, -6, };