#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0040

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 6, 9, 11, 13, 15, 17, 20, 23,
25, 27, 29, 29, 30, 29, 31, 32, 33, 34, 35, 36, 38, 39, 41, 43, 45, 47, 50, 51,
53, 54, 55, 57, 58, 58, 59, 61, 61, 61, 61, 61, 61, 61, 60, 59, 59, 59, 57, 56,
55, 53, 53, 51, 49, 48, 47, 44, 43, 41, 39, 37, 35, 33, 32, 29, 27, 24, 22, 21,
18, 16, 12, 6, -4, -18, -30, -37, -41, -41, -41, -45, -53, -59, -64, -68, -69,
-66, -64, -61, -59, -57, -55, -54, -56, -64, -73, -84, -89, -91, -89, -85, -81,
-77, -74, -73, -71, -71, -68, -65, -64, -60, -56, -53, -50, -48, -52, -59, -69,
-75, -78, -76, -71, -65, -60, -54, -48, -43, -38, -33, -29, -23, -18, -13, -9,
-4, 0, 4, 9, 10, 12, 13, 14, 16, 17, 19, 21, 23, 26, 27, 29, 31, 33, 34, 34, 35,
36, 36, 30, 18, -1, -18, -28, -29, -25, -16, -10, -4, 2, 7, 12, 16, 19, 23, 26,
29, 32, 34, 35, 36, 37, 37, 36, 32, 26, 17, 7, 0, -1, 1, 5, 9, 13, 17, 21, 23,
25, 27, 28, 30, 32, 35, 37, 39, 42, 44, 46, 47, 47, 47, 47, 47, 48, 49, 50, 51,
52, 53, 55, 56, 56, 56, 51, 40, 30, 20, 15, 15, 17, 21, 24, 27, 29, 30, 32, 33,
36, 35, 37, 37, 38, 38, 39, 37, 30, 18, 4, -6, -12, -14, -14, -11, -8, -6, -5,
-4, -2, -1, 1, 1, 4, 4, 5, 7, 7, 8, 8, 7, 6, 4, 2, 1, 0, 0, -1, -1, -2, -1, -1,
-1, -2, -2, -1, -2, -2, -7, -25, -51, -76, -104, -117, -118, -112, -103, -94,
-86, -79, -73, -68, -63, -58, -53, -48, -43, -39, -35, -31, -27, -25, -24, -26,
-30, -31, -34, -34, -34, -32, -30, -27, -25, -21, -19, -17, -13, -11, -8, -5,
-4, -3, -4, -9, -16, -22, -24, -22, -19, -13, -9, -5, -1, 2, 4, 7, 9, 10, 13,
14, 16, 19, 19, 16, 10, 4, -3, -8, -9, -7, -4, -2, 1, 3, 6, 7, 9, 9, 11, 13, 14,
17, 18, 19, 21, 22, 24, 23, 22, 21, 21, 20, 21, 21, 22, 22, 23, 23, 23, 24, 24,
20, 11, 2, -3, -7, -7, -5, -3, -2, -1, 1, 3, 5, 5, 7, 8, 9, 9, 11, 12, 12, 12,
14, 13, 11, 8, -2, -16, -39, -60, -70, -71, -66, -59, -52, -46, -42, -37, -33,
-28, -24, -20, -17, -13, -9, -6, -2, 0, 3, 3, 2, 0, -1, -2, -2, -1, -1, 1, 3, 4,
6, 8, 10, 12, 14, 15, 17, 18, 18, 15, 7, -2, -9, -12, -10, -7, -2, 2, 6, 8, 12,
13, 16, 17, 18, 19, 21, 21, 22, 22, 18, 13, 3, -5, -10, -12, -10, -7, -4, -1, 1,
3, 1, -4, -13, -21, -26, -26, -22, -16, -12, -10, -13, -22, -31, -37, -39, -36,
-31, -25, -19, -13, -9, -3, };