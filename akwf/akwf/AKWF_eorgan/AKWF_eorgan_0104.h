#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0104

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 10, 14, 17, 21, 26, 29, 32, 36,
39, 43, 45, 48, 51, 54, 57, 60, 62, 64, 67, 69, 71, 73, 75, 77, 78, 79, 81, 81,
83, 84, 85, 85, 86, 87, 86, 87, 88, 88, 86, 86, 86, 85, 85, 85, 83, 83, 81, 81,
79, 77, 76, 74, 72, 71, 69, 67, 65, 63, 61, 58, 56, 54, 50, 48, 45, 43, 40, 39,
37, 34, 32, 30, 28, 26, 24, 23, 21, 19, 18, 17, 16, 15, 14, 13, 11, 11, 11, 10,
9, 10, 9, 9, 10, 9, 9, 10, 11, 11, 11, 12, 13, 14, 15, 16, 18, 20, 21, 23, 23,
26, 28, 30, 32, 34, 36, 38, 41, 44, 46, 50, 51, 54, 57, 60, 63, 66, 69, 73, 75,
78, 81, 83, 86, 88, 91, 93, 96, 98, 101, 103, 104, 106, 108, 109, 110, 112, 114,
114, 116, 116, 117, 117, 118, 118, 119, 119, 119, 118, 119, 118, 118, 117, 116,
116, 114, 113, 112, 111, 109, 107, 106, 104, 102, 100, 97, 95, 93, 90, 88, 85,
82, 80, 77, 74, 70, 67, 63, 60, 58, 53, 49, 46, 43, 38, 36, 32, 28, 26, 22, 20,
15, 13, 9, 8, 5, 3, -1, -3, -5, -7, -9, -11, -13, -15, -17, -18, -19, -20, -22,
-23, -24, -24, -26, -27, -28, -29, -28, -29, -28, -29, -28, -28, -29, -28, -28,
-28, -27, -26, -25, -24, -22, -22, -21, -19, -19, -17, -15, -13, -12, -9, -8,
-6, -4, -2, 1, 2, 4, 7, 7, 9, 12, 14, 15, 16, 18, 19, 21, 22, 22, 23, 24, 25,
25, 27, 27, 27, 28, 28, 28, 28, 27, 27, 27, 26, 26, 26, 24, 23, 23, 22, 20, 19,
17, 16, 15, 13, 11, 8, 8, 4, 3, 0, -2, -5, -8, -10, -14, -15, -19, -22, -25,
-28, -31, -35, -38, -42, -45, -49, -52, -57, -60, -63, -67, -70, -73, -76, -79,
-83, -85, -88, -91, -93, -96, -98, -100, -102, -104, -106, -108, -109, -110,
-112, -114, -114, -116, -117, -117, -118, -119, -119, -118, -119, -119, -118,
-119, -119, -118, -118, -117, -116, -115, -113, -114, -112, -110, -109, -107,
-105, -104, -101, -99, -97, -95, -92, -89, -87, -84, -82, -79, -76, -73, -70,
-68, -64, -61, -58, -55, -53, -49, -47, -44, -41, -39, -37, -34, -32, -30, -28,
-26, -24, -22, -22, -19, -18, -16, -15, -14, -14, -12, -11, -11, -10, -10, -9,
-10, -8, -9, -10, -9, -9, -10, -10, -10, -12, -12, -13, -14, -14, -16, -17, -19,
-20, -21, -23, -25, -27, -29, -31, -33, -35, -38, -39, -43, -44, -46, -49, -52,
-54, -57, -59, -61, -64, -65, -68, -69, -72, -74, -76, -76, -78, -79, -81, -82,
-82, -84, -83, -85, -86, -86, -86, -85, -86, -86, -86, -86, -85, -84, -84, -83,
-82, -81, -80, -78, -78, -75, -74, -72, -70, -68, -67, -64, -62, -59, -57, -54,
-51, -48, -46, -42, -39, -36, -32, -29, -25, -21, -18, -13, -9, -5, -2, };