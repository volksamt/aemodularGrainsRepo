#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0038

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 6, 8, 11, 14, 17, 20, 22, 25,
26, 28, 31, 33, 35, 38, 40, 43, 46, 48, 52, 54, 58, 60, 63, 66, 69, 72, 73, 76,
79, 81, 84, 86, 88, 91, 93, 96, 97, 99, 101, 102, 104, 106, 107, 109, 110, 112,
113, 113, 115, 116, 116, 117, 118, 118, 119, 119, 119, 119, 119, 119, 119, 118,
118, 117, 116, 116, 115, 114, 114, 113, 112, 110, 108, 108, 107, 105, 104, 102,
101, 99, 98, 97, 95, 93, 92, 90, 89, 86, 85, 83, 81, 79, 78, 76, 74, 72, 69, 67,
65, 64, 62, 59, 58, 55, 53, 51, 49, 47, 44, 43, 41, 39, 38, 36, 34, 33, 31, 28,
27, 26, 25, 22, 20, 19, 17, 15, 15, 12, 10, 8, 7, 4, 3, 0, -1, -3, -5, -7, -9,
-11, -13, -15, -17, -18, -20, -22, -23, -24, -25, -26, -28, -29, -30, -32, -32,
-34, -35, -37, -38, -39, -41, -42, -45, -45, -47, -48, -50, -51, -52, -54, -55,
-57, -58, -61, -62, -64, -66, -67, -70, -71, -72, -75, -76, -78, -79, -82, -83,
-84, -87, -88, -91, -92, -94, -95, -96, -98, -99, -100, -102, -102, -103, -104,
-105, -105, -106, -107, -107, -107, -108, -107, -106, -107, -106, -106, -106,
-106, -105, -104, -104, -104, -103, -102, -102, -101, -99, -98, -97, -96, -94,
-94, -92, -91, -89, -86, -86, -83, -81, -79, -77, -74, -72, -69, -67, -64, -61,
-58, -54, -51, -48, -45, -41, -39, -35, -31, -29, -26, -21, -19, -16, -12, -9,
-6, -3, -1, 2, 5, 7, 10, 12, 13, 16, 17, 20, 21, 22, 23, 25, 26, 29, 31, 33, 36,
38, 39, 41, 42, 46, 47, 49, 51, 52, 55, 56, 58, 59, 60, 62, 65, 66, 67, 68, 70,
71, 71, 73, 73, 74, 75, 75, 77, 77, 77, 77, 78, 77, 77, 78, 78, 77, 77, 77, 77,
76, 75, 75, 73, 73, 73, 71, 71, 69, 69, 67, 66, 65, 64, 63, 62, 61, 60, 58, 58,
56, 55, 53, 52, 51, 49, 48, 47, 45, 42, 42, 41, 38, 38, 36, 35, 32, 30, 29, 28,
26, 25, 24, 22, 21, 19, 18, 17, 16, 14, 13, 12, 11, 10, 8, 7, 6, 6, 4, 3, 2, 0,
-1, -2, -4, -5, -6, -8, -8, -10, -10, -10, -11, -12, -14, -14, -16, -17, -18,
-20, -20, -23, -24, -26, -26, -28, -29, -29, -31, -32, -33, -35, -36, -36, -37,
-39, -40, -41, -42, -43, -44, -45, -47, -47, -48, -50, -51, -53, -54, -55, -56,
-58, -60, -61, -63, -65, -66, -68, -69, -72, -73, -74, -76, -78, -78, -79, -82,
-83, -84, -85, -85, -87, -87, -88, -88, -90, -90, -90, -90, -91, -91, -91, -91,
-90, -90, -90, -89, -89, -88, -87, -86, -85, -86, -84, -83, -82, -81, -79, -78,
-77, -75, -73, -72, -70, -68, -66, -65, -62, -60, -58, -55, -54, -50, -47, -44,
-41, -38, -36, -33, -29, -26, -22, -19, -15, -13, -8, -4, -1, };