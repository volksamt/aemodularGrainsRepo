#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0068

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 12, 17, 22, 27, 31, 35, 41, 46,
50, 54, 59, 62, 66, 71, 74, 78, 82, 85, 88, 91, 95, 97, 100, 102, 104, 107, 108,
111, 112, 113, 114, 116, 117, 117, 118, 119, 119, 118, 120, 119, 118, 118, 117,
117, 116, 116, 114, 114, 112, 111, 110, 109, 107, 106, 105, 103, 101, 99, 98,
97, 94, 93, 91, 90, 87, 87, 84, 82, 81, 79, 77, 76, 75, 73, 71, 70, 67, 67, 65,
64, 62, 60, 60, 58, 57, 55, 53, 53, 52, 51, 48, 47, 46, 45, 43, 42, 41, 40, 38,
38, 36, 35, 34, 33, 32, 30, 30, 29, 27, 26, 25, 24, 23, 22, 21, 21, 19, 18, 17,
17, 16, 15, 15, 14, 14, 13, 13, 13, 13, 12, 13, 12, 12, 12, 13, 13, 13, 14, 15,
16, 17, 17, 18, 20, 20, 22, 23, 24, 26, 27, 29, 30, 32, 35, 36, 38, 41, 43, 44,
47, 49, 51, 54, 56, 57, 60, 63, 64, 66, 69, 70, 73, 75, 77, 79, 81, 83, 83, 85,
87, 88, 89, 90, 92, 93, 93, 94, 94, 94, 95, 95, 95, 95, 94, 95, 95, 93, 92, 92,
91, 91, 89, 87, 86, 85, 83, 81, 81, 78, 77, 75, 73, 71, 69, 68, 65, 63, 61, 59,
56, 54, 53, 51, 48, 46, 44, 42, 41, 38, 36, 34, 32, 30, 29, 27, 25, 23, 22, 20,
19, 17, 16, 13, 13, 12, 10, 9, 8, 7, 5, 4, 2, 2, -1, -2, -3, -3, -4, -6, -7, -9,
-10, -11, -12, -13, -15, -16, -18, -19, -20, -22, -24, -26, -27, -29, -31, -33,
-34, -36, -38, -41, -42, -45, -46, -49, -51, -53, -54, -56, -59, -60, -63, -65,
-67, -69, -72, -73, -75, -77, -79, -81, -82, -84, -85, -86, -88, -89, -90, -92,
-92, -93, -94, -95, -95, -96, -96, -96, -96, -96, -96, -95, -94, -94, -93, -93,
-91, -91, -90, -89, -87, -85, -84, -82, -80, -78, -77, -74, -73, -71, -68, -66,
-63, -62, -59, -57, -55, -52, -50, -48, -46, -44, -42, -40, -37, -36, -34, -32,
-30, -29, -27, -25, -25, -23, -20, -20, -19, -18, -17, -16, -15, -15, -14, -13,
-13, -12, -12, -13, -12, -12, -13, -12, -12, -13, -13, -13, -14, -15, -15, -17,
-18, -17, -19, -20, -20, -22, -23, -24, -25, -25, -27, -29, -28, -30, -31, -33,
-33, -34, -36, -37, -38, -40, -41, -42, -42, -44, -46, -46, -49, -49, -51, -51,
-54, -54, -56, -57, -59, -60, -61, -63, -64, -65, -67, -69, -70, -73, -74, -75,
-77, -78, -79, -81, -83, -85, -86, -89, -90, -92, -93, -95, -97, -98, -100,
-100, -104, -104, -106, -106, -108, -110, -111, -112, -114, -114, -114, -116,
-116, -117, -117, -118, -118, -118, -118, -118, -117, -117, -116, -115, -113,
-112, -112, -110, -108, -107, -104, -102, -100, -97, -95, -92, -88, -85, -82,
-78, -75, -71, -67, -63, -59, -55, -50, -46, -41, -36, -32, -26, -21, -17, -12,
-8, -2, };