#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0057

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 11, 15, 20, 24, 28, 33, 36, 41,
45, 50, 54, 58, 62, 65, 70, 73, 76, 79, 83, 86, 88, 92, 94, 96, 100, 102, 104,
106, 108, 110, 111, 112, 114, 116, 117, 117, 118, 118, 119, 119, 119, 119, 119,
118, 117, 116, 117, 116, 114, 114, 112, 110, 108, 108, 105, 104, 101, 99, 97,
95, 92, 90, 88, 86, 83, 81, 77, 76, 73, 70, 68, 64, 61, 58, 56, 53, 50, 48, 45,
43, 39, 37, 34, 31, 29, 27, 25, 22, 20, 18, 16, 15, 12, 10, 9, 7, 6, 3, 3, 1, 0,
-1, -2, -3, -3, -5, -5, -6, -6, -6, -7, -7, -8, -8, -6, -6, -6, -6, -6, -5, -5,
-4, -4, -3, -2, -1, 0, 1, 2, 3, 4, 5, 7, 8, 8, 9, 11, 12, 13, 14, 16, 16, 18,
18, 19, 21, 22, 23, 23, 25, 25, 26, 27, 28, 28, 29, 30, 29, 31, 31, 32, 32, 31,
31, 32, 32, 32, 32, 32, 31, 31, 31, 31, 30, 29, 30, 28, 27, 28, 25, 25, 24, 24,
22, 22, 21, 19, 18, 17, 16, 15, 13, 12, 10, 10, 9, 7, 5, 5, 4, 2, 2, 0, -1, -2,
-2, -4, -5, -6, -7, -8, -8, -10, -11, -11, -12, -12, -12, -13, -14, -14, -14,
-16, -15, -16, -16, -16, -15, -15, -16, -16, -15, -14, -14, -14, -15, -14, -13,
-12, -12, -11, -11, -10, -9, -8, -8, -6, -6, -5, -4, -3, -3, -1, -1, 0, 1, 1, 3,
4, 5, 6, 7, 8, 8, 9, 9, 10, 11, 11, 12, 12, 13, 13, 13, 14, 14, 14, 15, 15, 15,
16, 14, 16, 15, 14, 15, 15, 13, 13, 14, 12, 12, 12, 11, 10, 9, 9, 7, 7, 6, 5, 4,
3, 2, 0, 0, -1, -3, -3, -5, -7, -7, -9, -10, -11, -12, -13, -15, -16, -17, -18,
-20, -20, -21, -23, -23, -25, -24, -26, -27, -27, -28, -29, -30, -30, -31, -31,
-32, -32, -32, -32, -32, -32, -32, -33, -32, -31, -32, -32, -31, -31, -30, -30,
-29, -29, -28, -28, -26, -25, -25, -23, -22, -22, -20, -20, -18, -17, -16, -14,
-14, -13, -12, -11, -10, -7, -8, -6, -5, -4, -3, -1, -1, 0, 1, 1, 2, 3, 4, 5, 5,
5, 7, 6, 6, 6, 6, 6, 7, 6, 7, 5, 5, 4, 3, 3, 2, 1, 0, -1, -2, -3, -5, -6, -8,
-10, -12, -14, -15, -17, -20, -22, -23, -27, -29, -31, -34, -36, -39, -41, -44,
-47, -49, -52, -54, -58, -60, -63, -66, -69, -71, -74, -77, -79, -82, -84, -87,
-89, -92, -94, -96, -99, -101, -102, -104, -106, -108, -110, -111, -113, -113,
-114, -115, -116, -116, -118, -117, -118, -119, -118, -118, -118, -118, -116,
-117, -116, -114, -113, -111, -109, -108, -106, -104, -101, -99, -97, -94, -92,
-89, -85, -83, -79, -76, -73, -70, -65, -62, -57, -55, -50, -46, -42, -38, -32,
-29, -24, -20, -16, -12, -7, -2, };