#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0055

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 13, 17, 20, 24, 27, 31, 35,
38, 42, 46, 49, 53, 56, 60, 63, 65, 69, 72, 75, 78, 80, 83, 86, 89, 91, 94, 96,
98, 100, 102, 104, 105, 107, 109, 111, 111, 113, 114, 115, 116, 116, 117, 118,
119, 119, 119, 119, 119, 120, 119, 118, 118, 117, 117, 116, 115, 115, 113, 113,
111, 111, 110, 108, 107, 104, 103, 101, 99, 97, 95, 93, 91, 90, 88, 86, 83, 81,
78, 76, 74, 72, 69, 67, 65, 62, 60, 58, 55, 52, 51, 48, 46, 44, 42, 39, 36, 35,
32, 31, 28, 26, 25, 22, 20, 19, 18, 16, 15, 13, 10, 10, 9, 7, 6, 5, 4, 3, 3, 2,
2, 1, 1, 0, 0, 1, 0, 1, 0, 0, 1, 1, 1, 3, 4, 4, 4, 6, 7, 8, 8, 11, 12, 13, 15,
16, 19, 19, 21, 23, 25, 27, 30, 31, 34, 36, 38, 39, 41, 45, 47, 48, 52, 54, 56,
58, 61, 64, 66, 69, 70, 73, 75, 78, 79, 82, 84, 87, 88, 90, 93, 94, 96, 98, 100,
101, 104, 105, 106, 108, 109, 110, 112, 113, 113, 115, 115, 116, 116, 116, 117,
118, 118, 118, 119, 118, 118, 118, 117, 116, 116, 115, 114, 113, 112, 110, 110,
108, 107, 104, 103, 102, 99, 97, 96, 93, 91, 88, 86, 83, 81, 78, 75, 72, 69, 66,
62, 60, 56, 52, 50, 46, 43, 39, 35, 32, 27, 24, 20, 17, 13, 10, 5, 2, -1, -6,
-10, -13, -17, -21, -24, -28, -33, -35, -38, -43, -46, -50, -53, -57, -60, -63,
-66, -69, -72, -75, -78, -80, -83, -86, -89, -91, -93, -96, -98, -100, -102,
-104, -105, -107, -109, -111, -112, -113, -114, -115, -116, -117, -117, -117,
-118, -118, -119, -119, -119, -119, -118, -119, -118, -117, -117, -117, -116,
-114, -114, -113, -111, -110, -109, -107, -106, -104, -103, -101, -99, -97, -95,
-94, -91, -90, -88, -85, -82, -81, -78, -76, -74, -72, -69, -67, -64, -62, -60,
-57, -54, -53, -50, -48, -46, -43, -42, -39, -36, -34, -31, -29, -28, -26, -24,
-22, -21, -19, -18, -15, -14, -12, -12, -10, -8, -7, -6, -6, -5, -3, -3, -1, -2,
0, -1, -1, 0, 1, 0, 0, -1, -1, -1, -2, -1, -3, -3, -4, -5, -6, -6, -8, -10, -11,
-12, -14, -15, -16, -18, -21, -22, -23, -25, -27, -29, -32, -33, -36, -38, -40,
-42, -45, -47, -49, -52, -54, -56, -59, -61, -64, -66, -68, -71, -73, -75, -78,
-80, -82, -84, -87, -88, -90, -93, -94, -96, -98, -100, -102, -104, -105, -106,
-108, -110, -110, -112, -113, -113, -115, -115, -116, -117, -117, -117, -118,
-118, -119, -118, -118, -118, -117, -117, -116, -115, -114, -114, -113, -111,
-111, -110, -108, -106, -105, -103, -101, -99, -97, -96, -92, -90, -88, -86,
-83, -80, -77, -75, -71, -68, -66, -62, -60, -57, -53, -49, -46, -42, -39, -35,
-31, -28, -24, -20, -16, -13, -9, -6, -1, };