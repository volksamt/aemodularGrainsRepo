#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0071

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 14, 18, 22, 25, 30, 33, 36,
40, 43, 47, 51, 55, 58, 61, 64, 68, 70, 73, 76, 79, 82, 85, 87, 90, 92, 94, 96,
98, 100, 102, 104, 105, 107, 109, 110, 111, 112, 114, 115, 115, 117, 117, 118,
118, 118, 120, 120, 119, 119, 119, 119, 118, 117, 117, 117, 116, 116, 115, 114,
113, 111, 110, 109, 107, 106, 104, 103, 100, 99, 98, 94, 93, 90, 89, 86, 85, 82,
79, 77, 74, 72, 69, 68, 64, 62, 59, 56, 53, 52, 50, 46, 44, 42, 39, 37, 35, 33,
30, 29, 27, 25, 23, 21, 19, 18, 16, 14, 13, 12, 10, 9, 8, 7, 6, 5, 3, 4, 3, 2,
1, 2, 1, 0, 0, 0, 0, 0, 0, 0, 1, 2, 2, 2, 4, 3, 5, 4, 5, 7, 8, 9, 11, 12, 14,
15, 17, 18, 20, 22, 24, 25, 28, 30, 31, 34, 35, 39, 40, 43, 45, 47, 51, 52, 56,
58, 59, 62, 66, 68, 70, 74, 75, 78, 80, 82, 85, 86, 90, 91, 93, 96, 98, 100,
101, 103, 104, 106, 107, 109, 110, 112, 112, 113, 114, 114, 116, 116, 117, 118,
118, 118, 119, 119, 118, 117, 118, 117, 117, 116, 115, 114, 114, 113, 112, 111,
109, 108, 107, 105, 103, 102, 100, 98, 95, 94, 91, 89, 88, 84, 82, 80, 76, 73,
71, 68, 65, 62, 57, 54, 50, 47, 44, 40, 37, 33, 30, 26, 22, 18, 14, 11, 6, 2,
-2, -6, -10, -14, -17, -23, -26, -30, -33, -37, -41, -44, -47, -52, -55, -58,
-61, -64, -67, -70, -74, -76, -80, -82, -85, -87, -90, -93, -94, -96, -99, -100,
-103, -104, -105, -108, -109, -110, -111, -113, -114, -115, -116, -116, -117,
-118, -118, -119, -118, -119, -120, -119, -118, -119, -118, -118, -117, -117,
-115, -115, -115, -113, -112, -111, -109, -109, -107, -106, -104, -102, -100,
-99, -96, -94, -93, -91, -88, -86, -84, -81, -79, -78, -74, -72, -69, -66, -64,
-60, -59, -56, -54, -52, -48, -46, -44, -41, -40, -36, -35, -32, -31, -28, -27,
-25, -22, -20, -19, -17, -16, -15, -13, -12, -10, -8, -8, -7, -6, -5, -4, -3,
-3, -1, -2, -1, -1, 0, 0, -1, 0, -1, 0, -1, -1, -1, -2, -3, -3, -4, -4, -6, -6,
-7, -8, -10, -11, -12, -14, -15, -17, -19, -20, -22, -25, -25, -28, -30, -32,
-33, -36, -39, -40, -43, -46, -48, -51, -53, -55, -58, -61, -63, -65, -69, -71,
-73, -76, -78, -80, -83, -85, -88, -90, -92, -93, -96, -97, -99, -101, -102,
-104, -105, -108, -109, -110, -112, -112, -114, -114, -114, -116, -116, -117,
-118, -117, -117, -119, -119, -118, -118, -118, -117, -117, -117, -116, -114,
-114, -113, -112, -111, -110, -108, -107, -105, -103, -102, -99, -98, -95, -94,
-92, -89, -86, -84, -81, -78, -76, -73, -70, -67, -63, -61, -58, -53, -50, -48,
-44, -40, -36, -32, -29, -26, -21, -18, -14, -10, -5, -3, };