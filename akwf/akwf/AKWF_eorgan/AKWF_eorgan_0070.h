#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0070

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 3, 4, 6, 9, 9, 12, 12, 15, 16,
17, 18, 21, 22, 23, 26, 26, 28, 29, 31, 32, 34, 35, 37, 39, 40, 41, 42, 44, 45,
47, 47, 50, 51, 52, 53, 55, 56, 57, 58, 60, 61, 63, 64, 65, 66, 68, 69, 71, 71,
73, 74, 74, 76, 77, 78, 79, 81, 81, 82, 83, 85, 86, 86, 87, 89, 90, 90, 91, 93,
93, 93, 95, 95, 96, 98, 98, 98, 99, 100, 102, 102, 103, 103, 104, 104, 105, 106,
107, 108, 108, 109, 109, 110, 110, 111, 111, 112, 113, 112, 114, 114, 113, 115,
115, 115, 115, 115, 116, 116, 117, 118, 117, 117, 118, 118, 118, 118, 118, 119,
118, 119, 119, 119, 119, 118, 118, 119, 120, 119, 119, 119, 118, 118, 118, 118,
118, 117, 118, 118, 117, 117, 117, 117, 116, 117, 116, 116, 115, 115, 115, 115,
114, 114, 113, 112, 112, 111, 111, 111, 110, 110, 108, 109, 108, 107, 107, 106,
106, 104, 105, 104, 102, 102, 101, 100, 100, 99, 98, 97, 96, 96, 95, 94, 94, 92,
91, 90, 89, 88, 87, 87, 85, 84, 83, 83, 81, 80, 80, 78, 77, 76, 74, 74, 72, 72,
70, 69, 68, 66, 65, 63, 62, 62, 60, 58, 56, 56, 55, 54, 52, 51, 49, 48, 46, 45,
44, 42, 41, 40, 38, 36, 35, 34, 32, 31, 29, 27, 27, 24, 24, 21, 21, 18, 17, 15,
14, 12, 10, 9, 8, 6, 5, 3, 1, 0, -1, -3, -5, -6, -8, -10, -11, -12, -14, -15,
-18, -18, -20, -22, -23, -25, -27, -28, -30, -31, -32, -33, -36, -36, -39, -39,
-41, -42, -43, -45, -47, -48, -50, -51, -52, -53, -55, -55, -57, -59, -59, -61,
-63, -63, -66, -67, -68, -69, -71, -71, -73, -73, -75, -76, -77, -78, -79, -80,
-82, -82, -83, -85, -86, -86, -88, -89, -89, -90, -91, -92, -93, -94, -95, -95,
-97, -97, -99, -99, -100, -101, -101, -102, -103, -103, -104, -105, -105, -106,
-107, -107, -107, -109, -109, -109, -110, -110, -111, -112, -112, -112, -113,
-113, -114, -114, -115, -115, -116, -116, -115, -117, -116, -117, -117, -118,
-118, -117, -119, -118, -118, -119, -118, -119, -118, -119, -118, -119, -119,
-118, -120, -119, -120, -119, -119, -119, -119, -118, -118, -119, -118, -117,
-118, -117, -117, -117, -116, -117, -116, -116, -115, -114, -115, -114, -114,
-114, -113, -112, -112, -111, -111, -110, -110, -110, -108, -108, -108, -108,
-107, -107, -105, -104, -104, -103, -103, -102, -100, -100, -99, -99, -98, -97,
-97, -95, -95, -93, -93, -93, -91, -90, -89, -88, -87, -86, -85, -84, -83, -82,
-82, -80, -79, -78, -77, -75, -74, -74, -72, -71, -70, -68, -67, -66, -65, -64,
-62, -61, -59, -58, -57, -56, -54, -53, -52, -51, -50, -48, -46, -45, -43, -43,
-40, -39, -37, -37, -35, -34, -32, -30, -30, -27, -25, -24, -23, -22, -20, -19,
-16, -16, -14, -13, -10, -9, -8, -6, -4, -3, -1, };