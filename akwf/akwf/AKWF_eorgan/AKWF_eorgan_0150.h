#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0150

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 8, 12, 14, 17, 20, 24, 28,
31, 35, 39, 43, 47, 51, 56, 59, 63, 67, 71, 75, 79, 82, 85, 89, 91, 94, 98, 101,
104, 106, 108, 109, 111, 113, 114, 116, 117, 117, 118, 118, 119, 118, 119, 119,
118, 118, 116, 116, 115, 113, 112, 110, 108, 106, 105, 103, 102, 98, 97, 94, 92,
90, 87, 85, 83, 80, 79, 77, 74, 73, 71, 69, 67, 65, 64, 63, 61, 59, 58, 57, 56,
55, 55, 54, 53, 53, 53, 53, 52, 52, 53, 53, 53, 54, 53, 54, 55, 55, 56, 57, 56,
57, 58, 58, 58, 59, 60, 60, 60, 60, 60, 59, 59, 60, 59, 59, 59, 58, 57, 57, 55,
54, 53, 52, 50, 49, 47, 45, 43, 41, 39, 37, 34, 32, 29, 28, 24, 21, 19, 16, 14,
11, 8, 6, 3, 1, -2, -4, -7, -9, -12, -13, -15, -17, -18, -21, -22, -23, -23,
-24, -25, -26, -25, -26, -26, -26, -25, -24, -23, -23, -22, -20, -18, -17, -14,
-12, -10, -8, -6, -3, -2, 2, 4, 6, 9, 12, 14, 17, 19, 22, 24, 27, 29, 31, 33,
36, 36, 38, 40, 40, 42, 42, 43, 45, 45, 45, 45, 45, 45, 44, 43, 43, 42, 41, 39,
38, 36, 34, 32, 30, 28, 26, 24, 20, 18, 15, 12, 9, 6, 4, 1, -2, -5, -8, -11,
-15, -18, -20, -23, -27, -30, -31, -34, -37, -39, -41, -43, -45, -47, -49, -50,
-51, -52, -53, -56, -56, -56, -57, -58, -57, -58, -58, -59, -59, -59, -59, -58,
-58, -58, -57, -57, -56, -57, -55, -55, -55, -55, -55, -55, -54, -54, -54, -54,
-54, -54, -54, -54, -55, -56, -57, -58, -59, -59, -60, -61, -63, -65, -66, -68,
-70, -72, -73, -74, -77, -80, -81, -83, -85, -88, -89, -91, -94, -96, -98, -100,
-101, -103, -105, -107, -108, -110, -111, -112, -114, -115, -116, -116, -116,
-116, -117, -116, -116, -115, -114, -114, -113, -112, -110, -108, -107, -105,
-103, -101, -98, -96, -93, -91, -87, -84, -81, -77, -74, -70, -67, -63, -59,
-55, -52, -48, -45, -41, -36, -33, -30, -27, -24, -20, -17, -15, -11, -9, -7,
-4, -3, 0, 1, 3, 4, 5, 6, 7, 8, 8, 8, 9, 8, 8, 7, 7, 6, 5, 4, 2, 1, 0, -2, -4,
-5, -6, -8, -10, -12, -13, -15, -17, -18, -20, -21, -23, -24, -26, -27, -27,
-29, -30, -31, -32, -33, -33, -33, -34, -33, -33, -33, -33, -32, -31, -31, -30,
-29, -29, -27, -26, -25, -23, -22, -21, -19, -18, -16, -15, -13, -12, -9, -7,
-7, -5, -3, -2, 0, 1, 3, 4, 5, 6, 7, 8, 9, 10, 10, 10, 10, 11, 11, 11, 10, 10,
10, 10, 9, 9, 8, 7, 5, 4, 3, 3, 1, -1, -1, -2, -4, -5, -6, -8, -9, -10, -11,
-12, -13, -13, -14, -15, -14, -15, -15, -15, -15, -16, -15, -14, -13, -13, -11,
-11, -9, -7, -6, -4, -1, };