#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0153

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 12, 16, 19, 23, 26, 31, 35,
38, 42, 45, 49, 53, 57, 60, 64, 67, 71, 74, 78, 81, 84, 87, 90, 92, 95, 98, 100,
102, 104, 106, 109, 111, 111, 114, 115, 116, 116, 117, 118, 118, 119, 119, 119,
119, 119, 119, 118, 118, 116, 116, 115, 114, 112, 111, 110, 108, 107, 105, 103,
101, 100, 96, 96, 92, 91, 89, 85, 84, 82, 79, 77, 74, 72, 70, 66, 65, 63, 60,
58, 56, 53, 52, 49, 47, 45, 43, 42, 40, 38, 36, 35, 33, 32, 31, 29, 28, 26, 25,
24, 23, 22, 22, 21, 20, 20, 20, 19, 18, 18, 18, 17, 17, 17, 17, 17, 17, 17, 17,
17, 18, 18, 18, 18, 19, 19, 20, 20, 20, 21, 21, 22, 22, 23, 22, 23, 24, 24, 25,
25, 26, 26, 27, 26, 27, 28, 28, 28, 29, 28, 29, 30, 29, 30, 30, 29, 30, 30, 30,
30, 30, 30, 29, 29, 28, 29, 29, 28, 27, 27, 26, 26, 25, 24, 23, 22, 22, 20, 19,
19, 17, 15, 14, 13, 10, 9, 8, 5, 4, 3, 0, -2, -4, -6, -8, -10, -13, -15, -18,
-20, -23, -25, -28, -30, -33, -36, -38, -41, -44, -47, -49, -52, -53, -56, -58,
-60, -63, -66, -67, -70, -71, -73, -75, -77, -78, -80, -81, -82, -84, -84, -85,
-86, -87, -87, -87, -88, -88, -87, -88, -87, -86, -85, -85, -85, -83, -82, -80,
-79, -78, -77, -74, -72, -71, -68, -66, -63, -61, -58, -56, -53, -49, -47, -44,
-41, -37, -35, -32, -29, -26, -24, -20, -17, -14, -11, -9, -7, -3, 0, 2, 4, 7,
9, 10, 12, 14, 15, 17, 20, 20, 22, 22, 24, 24, 25, 25, 26, 25, 25, 25, 25, 25,
25, 23, 23, 23, 21, 20, 20, 18, 16, 15, 14, 12, 9, 8, 5, 5, 2, 0, -3, -5, -7,
-10, -11, -14, -16, -19, -21, -24, -26, -28, -31, -33, -35, -37, -39, -42, -43,
-45, -47, -50, -51, -52, -54, -55, -56, -57, -59, -60, -61, -63, -64, -65, -64,
-65, -65, -67, -66, -66, -67, -67, -67, -66, -66, -66, -65, -65, -64, -64, -64,
-63, -62, -61, -61, -60, -59, -58, -57, -56, -55, -54, -53, -53, -51, -50, -48,
-47, -46, -45, -42, -42, -41, -39, -37, -36, -34, -33, -31, -31, -29, -27, -26,
-25, -23, -22, -21, -20, -18, -17, -15, -14, -13, -12, -11, -9, -8, -7, -7, -5,
-4, -4, -2, -3, -1, -1, 0, 1, 1, 1, 2, 2, 2, 2, 3, 2, 2, 3, 2, 2, 2, 2, 1, 0,
-1, -1, -1, -2, -3, -4, -5, -6, -7, -9, -10, -11, -12, -14, -14, -15, -18, -18,
-20, -22, -22, -24, -25, -25, -27, -28, -30, -31, -32, -33, -33, -34, -36, -37,
-37, -38, -38, -39, -39, -39, -39, -39, -39, -39, -39, -38, -37, -38, -36, -34,
-34, -33, -31, -30, -28, -27, -24, -23, -20, -19, -16, -13, -11, -9, -6, -3, 1,
};