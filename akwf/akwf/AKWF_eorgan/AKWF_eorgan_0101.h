#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0101

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 19, 28, 37, 45, 52, 60, 66, 73,
78, 83, 87, 91, 95, 97, 99, 101, 101, 103, 102, 103, 101, 100, 98, 96, 94, 91,
88, 86, 82, 78, 74, 71, 67, 64, 60, 57, 54, 51, 49, 46, 44, 41, 39, 37, 36, 35,
34, 34, 33, 33, 32, 33, 34, 35, 36, 38, 40, 41, 44, 46, 48, 51, 55, 58, 60, 63,
66, 70, 72, 75, 78, 80, 83, 85, 86, 88, 89, 91, 92, 93, 94, 95, 95, 95, 95, 95,
94, 93, 93, 91, 89, 87, 84, 83, 79, 76, 73, 70, 68, 65, 62, 59, 57, 55, 52, 50,
48, 46, 46, 45, 43, 43, 43, 45, 45, 47, 48, 50, 53, 55, 59, 63, 66, 71, 74, 78,
83, 87, 91, 96, 100, 103, 106, 110, 112, 115, 116, 117, 119, 119, 119, 118, 117,
117, 116, 114, 112, 108, 107, 104, 102, 98, 95, 91, 88, 84, 81, 77, 74, 70, 67,
64, 62, 59, 57, 55, 54, 52, 52, 50, 49, 49, 49, 48, 49, 49, 49, 50, 51, 51, 52,
54, 56, 56, 59, 60, 62, 63, 65, 67, 69, 70, 71, 73, 74, 75, 75, 75, 75, 74, 74,
73, 71, 70, 68, 66, 64, 61, 59, 55, 53, 48, 44, 41, 36, 31, 27, 22, 16, 11, 6,
0, -6, -11, -16, -21, -27, -32, -37, -40, -44, -48, -51, -55, -56, -58, -60,
-60, -61, -62, -61, -59, -57, -55, -52, -49, -44, -40, -36, -31, -25, -19, -12,
-7, 1, 7, 14, 20, 25, 31, 36, 41, 46, 49, 52, 54, 57, 59, 60, 61, 60, 59, 57,
57, 55, 51, 49, 45, 41, 37, 33, 28, 23, 18, 13, 8, 1, -4, -9, -15, -19, -25,
-29, -35, -39, -43, -48, -52, -55, -58, -61, -63, -67, -69, -71, -73, -74, -76,
-76, -76, -77, -76, -76, -76, -75, -74, -72, -71, -69, -67, -66, -63, -61, -60,
-58, -56, -55, -54, -54, -52, -51, -50, -51, -50, -50, -49, -49, -50, -50, -51,
-51, -53, -55, -57, -58, -62, -64, -67, -69, -73, -75, -80, -82, -87, -90, -93,
-96, -100, -102, -105, -108, -110, -112, -115, -116, -117, -118, -119, -120,
-119, -118, -117, -116, -113, -111, -108, -106, -102, -98, -95, -90, -86, -81,
-77, -72, -68, -64, -60, -57, -54, -52, -49, -48, -46, -44, -43, -44, -44, -44,
-45, -45, -48, -49, -50, -52, -54, -58, -60, -63, -66, -69, -71, -74, -76, -80,
-83, -85, -88, -89, -91, -92, -93, -93, -95, -95, -94, -95, -94, -94, -92, -91,
-90, -88, -87, -85, -83, -81, -79, -76, -73, -71, -68, -65, -62, -58, -55, -53,
-50, -47, -44, -42, -40, -38, -37, -34, -33, -33, -31, -33, -31, -32, -32, -33,
-35, -36, -37, -39, -40, -43, -45, -48, -50, -53, -57, -61, -63, -67, -71, -75,
-78, -82, -85, -88, -91, -93, -95, -97, -98, -100, -101, -101, -100, -99, -99,
-97, -94, -91, -88, -83, -79, -73, -67, -61, -54, -47, -39, -32, -22, -15, -5,
};