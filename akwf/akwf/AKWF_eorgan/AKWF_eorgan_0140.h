#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0140

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 11, 14, 17, 21, 24, 27, 32,
35, 38, 42, 45, 48, 53, 56, 59, 64, 66, 70, 73, 76, 79, 84, 85, 89, 92, 95, 97,
99, 102, 104, 106, 108, 110, 111, 113, 114, 115, 116, 118, 118, 118, 119, 119,
120, 119, 119, 118, 117, 117, 116, 115, 113, 112, 110, 109, 108, 105, 103, 101,
99, 96, 94, 91, 89, 85, 83, 80, 76, 74, 71, 68, 63, 61, 57, 54, 51, 47, 44, 40,
37, 34, 31, 27, 23, 20, 16, 13, 11, 8, 3, 0, -2, -5, -8, -11, -14, -15, -18,
-20, -23, -25, -28, -30, -32, -35, -37, -37, -40, -41, -43, -45, -46, -47, -49,
-51, -51, -52, -54, -54, -55, -56, -56, -56, -57, -58, -58, -59, -59, -60, -60,
-59, -61, -61, -61, -61, -61, -61, -61, -61, -61, -60, -60, -60, -60, -60, -59,
-60, -58, -59, -58, -58, -58, -58, -58, -58, -56, -57, -57, -56, -56, -55, -55,
-55, -55, -55, -55, -54, -55, -53, -54, -53, -54, -53, -54, -54, -53, -52, -53,
-53, -53, -52, -53, -54, -53, -54, -54, -54, -54, -53, -54, -55, -55, -55, -55,
-56, -56, -56, -57, -57, -57, -58, -58, -58, -59, -60, -59, -60, -61, -61, -61,
-61, -61, -61, -62, -62, -63, -62, -62, -63, -61, -61, -63, -62, -61, -61, -60,
-59, -59, -59, -59, -58, -57, -56, -55, -54, -52, -51, -50, -48, -46, -44, -43,
-40, -39, -37, -34, -32, -29, -28, -26, -23, -19, -18, -15, -11, -9, -6, -3, 0,
3, 7, 10, 12, 15, 20, 22, 25, 28, 31, 35, 38, 41, 45, 48, 51, 54, 56, 60, 62,
65, 68, 70, 72, 75, 76, 79, 81, 84, 85, 86, 88, 90, 91, 92, 93, 94, 94, 95, 96,
96, 96, 96, 95, 96, 96, 94, 94, 93, 92, 92, 90, 89, 87, 86, 84, 83, 81, 80, 77,
76, 74, 72, 70, 68, 65, 63, 62, 58, 56, 54, 51, 48, 46, 44, 41, 39, 37, 35, 32,
29, 28, 26, 24, 21, 20, 18, 15, 14, 11, 9, 8, 6, 4, 3, 1, 0, -2, -2, -5, -6, -6,
-6, -8, -8, -9, -11, -11, -12, -12, -13, -13, -13, -13, -14, -15, -15, -14, -16,
-16, -15, -16, -15, -15, -15, -16, -16, -15, -15, -15, -15, -15, -14, -15, -15,
-14, -15, -14, -14, -14, -14, -14, -14, -13, -13, -13, -14, -14, -13, -13, -14,
-14, -13, -13, -13, -14, -14, -15, -15, -15, -16, -16, -16, -17, -17, -17, -18,
-18, -20, -19, -21, -20, -22, -21, -22, -24, -25, -25, -25, -26, -27, -27, -28,
-29, -31, -31, -32, -33, -33, -35, -35, -36, -38, -38, -39, -40, -40, -42, -43,
-43, -45, -45, -46, -47, -48, -48, -49, -49, -50, -50, -51, -51, -51, -52, -52,
-52, -52, -52, -52, -52, -52, -52, -52, -51, -51, -50, -48, -48, -47, -46, -44,
-44, -41, -40, -39, -37, -35, -33, -30, -28, -27, -24, -21, -19, -16, -13, -12,
-8, -6, -2, };