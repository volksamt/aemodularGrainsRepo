#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 10, 14, 19, 22, 26, 31, 35, 38,
41, 45, 48, 51, 55, 58, 61, 64, 66, 69, 72, 74, 77, 79, 81, 83, 86, 88, 90, 92,
94, 96, 98, 100, 101, 103, 105, 105, 107, 109, 110, 111, 113, 113, 115, 115,
115, 117, 117, 117, 118, 119, 119, 119, 118, 119, 119, 119, 118, 118, 118, 118,
117, 116, 115, 115, 114, 113, 112, 111, 110, 109, 108, 107, 106, 105, 103, 103,
100, 100, 98, 96, 96, 94, 92, 90, 89, 88, 86, 85, 82, 82, 79, 78, 77, 74, 74,
72, 70, 68, 65, 64, 62, 61, 58, 57, 55, 54, 52, 50, 49, 47, 47, 44, 43, 42, 40,
39, 38, 36, 35, 34, 34, 33, 31, 30, 30, 28, 27, 26, 25, 25, 24, 23, 22, 22, 22,
21, 19, 19, 18, 17, 16, 15, 14, 13, 12, 11, 10, 9, 7, 6, 5, 4, 3, 2, 1, 0, -3,
-4, -4, -7, -7, -8, -9, -11, -13, -15, -17, -17, -19, -21, -21, -24, -25, -26,
-28, -30, -31, -33, -35, -36, -37, -39, -41, -43, -44, -46, -48, -49, -50, -53,
-55, -56, -57, -58, -60, -61, -63, -64, -65, -66, -67, -69, -69, -70, -70, -72,
-71, -72, -72, -73, -73, -74, -74, -74, -73, -73, -74, -73, -73, -73, -71, -71,
-70, -69, -69, -68, -66, -65, -64, -62, -60, -59, -57, -56, -53, -51, -49, -47,
-45, -43, -41, -39, -37, -34, -32, -30, -28, -24, -21, -19, -15, -13, -9, -6,
-2, 2, 5, 8, 12, 15, 18, 21, 24, 27, 29, 32, 34, 37, 39, 41, 44, 46, 47, 49, 50,
53, 54, 55, 57, 57, 60, 61, 62, 64, 64, 65, 67, 67, 69, 69, 70, 70, 71, 72, 72,
73, 73, 73, 74, 73, 74, 74, 73, 74, 72, 73, 72, 73, 71, 70, 70, 69, 67, 67, 66,
65, 65, 62, 62, 60, 59, 57, 56, 54, 53, 52, 49, 48, 47, 45, 43, 42, 40, 38, 36,
35, 32, 30, 29, 27, 25, 24, 21, 20, 17, 16, 14, 12, 10, 8, 7, 4, 2, 0, -2, -4,
-6, -9, -11, -13, -15, -17, -19, -21, -23, -24, -26, -29, -30, -31, -33, -35,
-36, -37, -38, -40, -40, -42, -44, -45, -45, -47, -48, -48, -49, -49, -50, -50,
-51, -52, -53, -53, -54, -55, -56, -57, -58, -58, -59, -60, -62, -62, -63, -64,
-65, -65, -65, -67, -68, -68, -69, -70, -71, -71, -73, -74, -74, -75, -77, -77,
-79, -79, -81, -82, -83, -84, -84, -85, -85, -87, -88, -89, -90, -92, -92, -93,
-94, -95, -97, -97, -99, -99, -101, -101, -102, -104, -104, -106, -106, -107,
-108, -108, -109, -110, -110, -111, -112, -111, -112, -111, -111, -111, -112,
-111, -112, -110, -110, -110, -108, -108, -107, -105, -105, -103, -102, -100,
-99, -98, -96, -94, -92, -90, -87, -86, -83, -82, -79, -76, -74, -71, -68, -64,
-62, -59, -55, -53, -50, -47, -43, -41, -38, -34, -32, -28, -24, -20, -16, -11,
-7, -3, };