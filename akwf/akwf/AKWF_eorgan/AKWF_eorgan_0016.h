#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 7, 10, 13, 16, 20, 23, 25, 28,
31, 34, 36, 39, 41, 44, 47, 49, 52, 54, 56, 59, 61, 63, 66, 68, 70, 72, 73, 75,
76, 79, 81, 82, 83, 84, 86, 88, 90, 92, 92, 93, 94, 96, 97, 98, 99, 99, 101,
101, 102, 103, 104, 105, 104, 106, 105, 106, 107, 107, 108, 108, 108, 108, 108,
109, 108, 109, 109, 109, 109, 109, 109, 109, 109, 109, 108, 109, 107, 108, 108,
108, 107, 108, 107, 106, 106, 106, 106, 105, 105, 104, 103, 104, 103, 102, 102,
102, 101, 101, 99, 100, 99, 98, 98, 98, 98, 96, 96, 96, 95, 95, 94, 94, 94, 93,
93, 92, 92, 92, 90, 91, 90, 91, 90, 89, 89, 89, 88, 88, 88, 88, 87, 87, 87, 86,
86, 86, 86, 86, 85, 85, 86, 86, 85, 85, 85, 85, 85, 85, 86, 85, 85, 86, 85, 86,
86, 86, 86, 86, 86, 86, 86, 86, 87, 86, 87, 87, 87, 88, 88, 88, 89, 87, 89, 89,
89, 89, 88, 90, 90, 91, 91, 90, 90, 90, 92, 91, 92, 92, 91, 92, 92, 92, 92, 93,
93, 92, 92, 93, 92, 93, 92, 92, 92, 92, 92, 92, 91, 90, 91, 91, 90, 90, 89, 89,
88, 87, 87, 87, 85, 85, 84, 84, 83, 82, 82, 81, 80, 79, 79, 77, 76, 74, 74, 72,
71, 70, 68, 67, 65, 64, 62, 61, 59, 58, 55, 54, 52, 50, 48, 46, 44, 41, 40, 38,
36, 34, 30, 29, 26, 24, 21, 18, 15, 14, 11, 8, 5, 3, -1, -3, -7, -9, -13, -16,
-19, -22, -25, -29, -31, -34, -37, -40, -43, -46, -48, -51, -55, -56, -59, -61,
-64, -67, -68, -71, -73, -75, -77, -79, -80, -82, -85, -86, -87, -88, -90, -91,
-93, -95, -96, -98, -99, -100, -102, -102, -103, -105, -106, -107, -108, -109,
-109, -110, -111, -113, -113, -113, -113, -114, -115, -115, -116, -116, -117,
-116, -117, -118, -117, -117, -118, -118, -119, -118, -119, -118, -119, -119,
-119, -119, -120, -119, -118, -119, -119, -119, -119, -119, -119, -119, -118,
-118, -118, -117, -119, -118, -117, -117, -117, -116, -116, -117, -116, -116,
-116, -115, -115, -115, -115, -115, -115, -114, -114, -113, -114, -113, -113,
-113, -112, -113, -112, -112, -112, -111, -111, -111, -112, -111, -111, -111,
-111, -111, -111, -111, -111, -110, -110, -110, -110, -111, -110, -109, -110,
-109, -110, -109, -110, -109, -108, -108, -109, -108, -108, -109, -108, -108,
-108, -108, -107, -107, -107, -107, -107, -107, -106, -106, -106, -106, -105,
-106, -105, -105, -105, -104, -104, -103, -103, -102, -102, -101, -101, -100,
-99, -100, -99, -99, -97, -97, -96, -95, -95, -94, -92, -92, -91, -90, -89, -89,
-88, -87, -86, -84, -83, -82, -81, -79, -78, -77, -75, -74, -72, -71, -69, -67,
-67, -64, -61, -61, -59, -57, -55, -52, -51, -49, -46, -43, -42, -40, -37, -35,
-32, -30, -27, -25, -22, -20, -17, -14, -11, -8, -6, -1, };