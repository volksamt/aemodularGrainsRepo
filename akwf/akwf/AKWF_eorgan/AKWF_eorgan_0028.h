#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0028

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 12, 17, 19, 22, 27, 29, 33,
37, 39, 43, 46, 48, 51, 55, 58, 60, 62, 65, 68, 70, 73, 75, 78, 79, 81, 83, 86,
88, 89, 92, 93, 94, 95, 98, 98, 100, 101, 102, 105, 105, 107, 108, 108, 109,
111, 111, 111, 112, 113, 113, 114, 114, 115, 114, 114, 115, 115, 115, 115, 115,
115, 115, 114, 114, 114, 114, 114, 113, 112, 111, 111, 111, 110, 109, 109, 108,
106, 106, 106, 105, 105, 104, 103, 101, 101, 100, 100, 99, 98, 97, 97, 97, 96,
95, 95, 94, 94, 93, 93, 92, 92, 92, 92, 92, 92, 91, 92, 92, 92, 93, 92, 91, 92,
93, 92, 92, 92, 93, 93, 92, 93, 93, 92, 93, 92, 92, 92, 93, 92, 92, 92, 91, 90,
90, 90, 90, 89, 88, 87, 87, 87, 86, 85, 84, 83, 81, 80, 79, 79, 78, 76, 75, 75,
73, 71, 69, 69, 67, 66, 65, 63, 62, 61, 59, 57, 56, 54, 52, 50, 49, 48, 46, 44,
42, 41, 39, 37, 35, 33, 32, 30, 28, 26, 25, 23, 21, 20, 18, 16, 15, 13, 10, 9,
7, 5, 4, 2, 0, -1, -3, -4, -6, -8, -9, -11, -12, -13, -14, -16, -17, -19, -19,
-19, -22, -22, -23, -23, -23, -24, -25, -25, -25, -25, -26, -25, -25, -25, -25,
-24, -23, -23, -23, -22, -21, -20, -20, -18, -17, -16, -14, -13, -12, -11, -10,
-8, -7, -5, -3, -2, -1, 0, 2, 3, 4, 6, 6, 8, 10, 11, 12, 13, 13, 15, 17, 17, 17,
19, 20, 20, 20, 20, 21, 21, 23, 22, 23, 23, 23, 23, 23, 23, 22, 22, 22, 21, 22,
21, 21, 20, 20, 19, 18, 18, 17, 16, 15, 14, 13, 12, 11, 9, 9, 7, 7, 6, 5, 2, 2,
0, -2, -3, -5, -6, -7, -8, -11, -12, -14, -15, -17, -19, -20, -22, -23, -26,
-28, -29, -32, -33, -35, -38, -39, -40, -43, -44, -46, -48, -50, -52, -53, -55,
-56, -58, -59, -61, -62, -64, -65, -67, -68, -70, -70, -71, -73, -73, -74, -74,
-76, -76, -77, -77, -77, -78, -79, -80, -80, -79, -80, -80, -81, -81, -81, -80,
-81, -82, -80, -81, -81, -82, -81, -83, -82, -82, -82, -82, -83, -84, -83, -83,
-84, -84, -85, -85, -85, -85, -87, -87, -87, -88, -89, -89, -89, -90, -91, -91,
-91, -93, -94, -94, -95, -95, -97, -97, -98, -99, -99, -100, -101, -101, -102,
-103, -105, -105, -105, -107, -107, -108, -108, -109, -109, -110, -111, -112,
-111, -113, -113, -114, -115, -115, -115, -116, -116, -117, -116, -117, -118,
-118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -118,
-118, -119, -118, -117, -117, -116, -115, -114, -113, -112, -112, -110, -110,
-107, -106, -104, -102, -102, -99, -97, -95, -93, -91, -88, -86, -84, -81, -78,
-75, -72, -69, -65, -62, -59, -57, -53, -49, -45, -42, -39, -35, -31, -27, -24,
-20, -15, -13, -8, -5, -1, };