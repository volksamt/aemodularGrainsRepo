#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0102

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 9, 15, 21, 26, 31, 37, 43, 48, 53,
58, 62, 66, 70, 74, 77, 81, 83, 86, 88, 90, 92, 92, 94, 96, 96, 96, 96, 96, 96,
95, 95, 95, 94, 93, 92, 91, 90, 89, 89, 87, 87, 85, 85, 84, 84, 83, 83, 82, 83,
82, 82, 81, 81, 81, 82, 83, 83, 84, 85, 85, 85, 86, 87, 88, 89, 89, 89, 90, 90,
91, 91, 90, 91, 90, 90, 90, 89, 89, 87, 87, 86, 85, 83, 81, 80, 78, 76, 75, 72,
70, 68, 66, 64, 62, 58, 56, 54, 52, 51, 49, 47, 45, 44, 44, 42, 42, 42, 42, 42,
41, 42, 43, 43, 46, 46, 48, 50, 53, 55, 58, 61, 62, 66, 69, 72, 76, 80, 83, 86,
90, 93, 96, 99, 101, 104, 107, 109, 111, 114, 114, 116, 117, 117, 118, 119, 118,
119, 118, 117, 116, 115, 113, 111, 110, 107, 106, 102, 100, 97, 95, 91, 88, 85,
82, 79, 76, 73, 71, 67, 65, 62, 60, 57, 54, 52, 50, 48, 46, 44, 43, 41, 39, 38,
37, 36, 35, 34, 33, 32, 32, 32, 31, 30, 29, 29, 28, 27, 27, 25, 24, 23, 22, 20,
19, 18, 16, 15, 13, 11, 8, 6, 5, 3, 0, -3, -6, -8, -10, -13, -17, -19, -21, -24,
-26, -30, -31, -33, -35, -38, -40, -41, -42, -43, -43, -45, -44, -44, -43, -44,
-42, -41, -40, -38, -36, -35, -33, -30, -27, -24, -21, -18, -14, -10, -7, -3, 0,
4, 8, 11, 15, 18, 21, 24, 27, 29, 32, 34, 37, 39, 40, 40, 41, 43, 43, 43, 43,
43, 42, 42, 40, 39, 38, 36, 33, 32, 30, 27, 24, 22, 19, 17, 14, 11, 8, 5, 2, 1,
-3, -4, -7, -9, -11, -14, -15, -17, -18, -21, -22, -23, -24, -25, -26, -27, -28,
-30, -30, -30, -32, -32, -32, -33, -34, -34, -35, -36, -37, -38, -39, -41, -41,
-43, -45, -47, -48, -50, -52, -54, -56, -59, -61, -64, -66, -69, -72, -75, -79,
-82, -84, -87, -90, -93, -97, -99, -102, -104, -107, -109, -111, -113, -114,
-116, -117, -118, -119, -119, -119, -119, -118, -118, -117, -116, -114, -112,
-110, -109, -105, -104, -101, -97, -95, -92, -87, -85, -82, -78, -75, -71, -68,
-65, -61, -59, -56, -54, -51, -49, -48, -46, -44, -44, -42, -42, -41, -41, -41,
-41, -42, -43, -43, -44, -46, -47, -49, -50, -53, -55, -58, -60, -63, -64, -67,
-69, -71, -73, -75, -77, -79, -81, -83, -83, -85, -85, -87, -88, -88, -89, -90,
-90, -91, -91, -91, -90, -90, -90, -90, -89, -88, -88, -87, -87, -85, -85, -84,
-83, -83, -82, -82, -81, -82, -81, -80, -80, -81, -81, -81, -82, -82, -83, -83,
-84, -84, -85, -86, -87, -88, -89, -90, -91, -91, -93, -93, -94, -94, -95, -95,
-94, -94, -94, -92, -91, -90, -89, -87, -86, -83, -80, -76, -74, -70, -66, -62,
-58, -53, -48, -43, -38, -33, -27, -21, -15, -9, -3, };