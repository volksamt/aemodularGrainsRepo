#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 3, 6, 7, 8, 10, 11, 12, 14,
16, 16, 17, 20, 20, 23, 24, 25, 27, 29, 30, 31, 32, 34, 35, 36, 37, 39, 40, 41,
42, 44, 45, 46, 48, 49, 50, 51, 53, 53, 54, 55, 56, 57, 58, 60, 60, 62, 62, 63,
65, 66, 66, 67, 68, 69, 70, 71, 70, 72, 73, 73, 73, 74, 75, 76, 76, 77, 78, 78,
78, 80, 80, 81, 81, 82, 82, 82, 83, 84, 85, 85, 85, 85, 87, 87, 88, 89, 89, 90,
91, 92, 93, 94, 94, 95, 96, 96, 97, 99, 99, 101, 100, 102, 103, 103, 104, 105,
106, 107, 107, 107, 108, 109, 110, 111, 111, 111, 112, 113, 113, 113, 113, 114,
114, 116, 115, 115, 116, 116, 117, 117, 118, 117, 118, 119, 118, 118, 119, 119,
119, 119, 118, 120, 119, 119, 119, 118, 118, 118, 119, 118, 119, 118, 117, 118,
116, 116, 116, 115, 115, 114, 114, 113, 112, 111, 110, 110, 109, 108, 108, 107,
106, 104, 104, 103, 102, 100, 99, 98, 98, 96, 96, 94, 93, 92, 90, 89, 89, 87,
86, 85, 83, 82, 81, 80, 78, 77, 75, 74, 73, 71, 70, 69, 67, 66, 65, 62, 61, 60,
59, 58, 55, 54, 53, 51, 49, 49, 47, 46, 44, 42, 41, 39, 38, 37, 35, 33, 33, 31,
30, 28, 26, 26, 24, 22, 21, 19, 18, 17, 15, 14, 13, 12, 9, 8, 7, 6, 4, 4, 2, 1,
-1, -2, -3, -5, -6, -8, -9, -10, -11, -14, -15, -16, -17, -19, -21, -22, -23,
-24, -26, -28, -28, -31, -32, -33, -34, -36, -37, -39, -39, -41, -42, -44, -45,
-47, -48, -50, -51, -52, -54, -55, -56, -58, -60, -61, -61, -63, -65, -66, -68,
-69, -69, -72, -73, -73, -75, -76, -77, -78, -80, -81, -82, -83, -84, -86, -86,
-88, -88, -90, -90, -92, -94, -94, -95, -96, -97, -98, -98, -100, -100, -102,
-102, -103, -104, -105, -105, -106, -107, -107, -107, -109, -108, -109, -110,
-111, -110, -111, -111, -113, -112, -113, -113, -113, -113, -113, -114, -114,
-114, -114, -114, -114, -115, -114, -115, -115, -114, -114, -115, -113, -114,
-114, -113, -113, -113, -113, -112, -112, -112, -112, -112, -112, -110, -110,
-111, -109, -109, -109, -108, -108, -108, -108, -106, -106, -106, -106, -104,
-104, -103, -102, -101, -101, -101, -100, -99, -99, -98, -97, -97, -96, -95,
-95, -94, -94, -92, -93, -91, -91, -90, -90, -89, -88, -88, -87, -85, -85, -84,
-83, -83, -83, -81, -80, -80, -79, -78, -77, -76, -76, -75, -74, -73, -72, -71,
-70, -69, -69, -68, -68, -66, -65, -65, -64, -63, -63, -62, -61, -60, -59, -59,
-58, -58, -57, -56, -55, -55, -54, -53, -53, -52, -50, -50, -49, -49, -48, -47,
-46, -45, -44, -43, -43, -41, -40, -38, -37, -36, -35, -33, -32, -30, -29, -28,
-27, -26, -24, -23, -21, -21, -18, -17, -17, -15, -13, -12, -10, -9, -8, -7, -6,
-4, -2, -1, };