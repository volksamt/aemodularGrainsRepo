#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0111

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 13, 16, 20, 23, 26, 30, 33,
37, 40, 44, 47, 50, 53, 57, 59, 62, 65, 68, 70, 73, 76, 78, 81, 82, 85, 87, 90,
92, 94, 96, 98, 99, 101, 103, 105, 106, 106, 108, 110, 110, 112, 112, 114, 114,
115, 116, 116, 117, 117, 118, 118, 118, 119, 119, 119, 118, 119, 119, 119, 120,
119, 119, 118, 118, 117, 117, 116, 117, 115, 114, 114, 114, 114, 112, 112, 112,
112, 111, 110, 110, 108, 108, 107, 107, 106, 106, 105, 105, 104, 103, 103, 103,
101, 102, 101, 100, 100, 100, 99, 99, 98, 98, 98, 98, 98, 97, 97, 97, 96, 97,
96, 95, 96, 95, 95, 95, 94, 94, 95, 94, 94, 93, 93, 94, 94, 94, 94, 93, 93, 93,
93, 93, 93, 93, 93, 92, 92, 92, 92, 91, 91, 91, 91, 90, 89, 89, 89, 88, 88, 87,
87, 87, 86, 85, 85, 84, 83, 82, 81, 81, 80, 79, 77, 77, 77, 75, 74, 73, 73, 71,
69, 69, 68, 67, 65, 64, 63, 62, 59, 59, 57, 56, 54, 54, 51, 51, 49, 48, 46, 45,
43, 42, 40, 39, 37, 35, 35, 33, 31, 30, 29, 27, 27, 25, 24, 23, 22, 21, 19, 18,
18, 16, 16, 14, 13, 13, 12, 11, 9, 9, 9, 8, 7, 6, 6, 5, 5, 4, 3, 3, 3, 3, 2, 2,
1, 1, 1, 1, 1, 0, 0, 1, 0, 0, 0, -1, -1, -1, 0, -1, 0, -1, -1, 0, -1, -1, -2,
-2, 0, -1, -1, -1, -1, -1, -1, -1, -2, -2, -2, -1, -3, -3, -2, -4, -3, -5, -5,
-5, -5, -6, -6, -7, -8, -8, -9, -10, -10, -11, -12, -12, -13, -13, -15, -16,
-16, -17, -19, -20, -21, -23, -23, -25, -26, -27, -29, -29, -32, -33, -34, -35,
-37, -38, -39, -42, -43, -44, -45, -47, -48, -50, -51, -53, -53, -55, -57, -57,
-60, -60, -62, -63, -65, -66, -67, -68, -69, -70, -71, -72, -74, -75, -76, -77,
-78, -78, -79, -81, -81, -83, -82, -83, -84, -85, -85, -86, -86, -88, -88, -89,
-88, -90, -90, -90, -90, -92, -90, -91, -92, -92, -92, -92, -93, -92, -93, -94,
-93, -93, -94, -93, -93, -94, -94, -95, -94, -95, -95, -95, -95, -95, -95, -95,
-95, -95, -95, -96, -96, -96, -97, -96, -96, -97, -97, -98, -97, -99, -99, -99,
-99, -99, -100, -100, -100, -101, -102, -101, -102, -103, -103, -103, -105,
-105, -105, -106, -107, -107, -107, -108, -109, -109, -109, -111, -111, -112,
-112, -113, -114, -113, -115, -114, -115, -115, -115, -116, -116, -117, -117,
-118, -118, -118, -117, -118, -118, -117, -117, -118, -117, -117, -116, -117,
-116, -116, -115, -113, -113, -112, -112, -111, -110, -108, -106, -106, -104,
-103, -101, -99, -98, -96, -94, -93, -91, -89, -87, -84, -83, -80, -77, -74,
-72, -69, -67, -64, -62, -58, -55, -52, -50, -46, -42, -39, -36, -33, -29, -26,
-22, -18, -15, -12, -8, -5, 0, };