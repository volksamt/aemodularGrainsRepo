#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0107

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 13, 22, 31, 40, 48, 55, 62, 68, 73,
77, 81, 86, 88, 91, 94, 97, 100, 102, 104, 107, 110, 112, 113, 116, 117, 118,
118, 119, 119, 118, 118, 116, 115, 114, 112, 111, 110, 110, 109, 109, 109, 110,
109, 111, 111, 111, 112, 113, 114, 114, 114, 114, 114, 113, 112, 112, 112, 111,
111, 110, 110, 110, 109, 109, 109, 109, 109, 108, 107, 107, 107, 106, 105, 104,
104, 103, 104, 103, 104, 104, 104, 104, 104, 105, 104, 104, 103, 102, 101, 100,
97, 95, 92, 89, 86, 83, 80, 77, 75, 72, 70, 68, 67, 65, 65, 62, 62, 60, 59, 58,
56, 55, 52, 51, 49, 48, 46, 44, 44, 43, 44, 45, 46, 47, 49, 52, 55, 57, 60, 63,
66, 68, 68, 70, 69, 68, 67, 65, 63, 60, 57, 54, 51, 49, 46, 43, 40, 36, 34, 30,
27, 24, 21, 18, 15, 11, 6, 2, -3, -6, -11, -16, -19, -23, -26, -30, -33, -36,
-37, -38, -39, -41, -41, -43, -43, -43, -45, -46, -46, -48, -49, -50, -51, -52,
-55, -55, -56, -58, -58, -60, -61, -61, -62, -63, -63, -64, -65, -67, -68, -69,
-69, -71, -71, -73, -73, -73, -73, -72, -72, -72, -72, -72, -72, -71, -72, -72,
-73, -73, -76, -77, -79, -80, -82, -84, -85, -87, -88, -89, -88, -88, -88, -87,
-85, -85, -82, -81, -79, -77, -76, -74, -72, -71, -68, -65, -63, -60, -56, -52,
-47, -42, -36, -29, -22, -14, -6, 2, 11, 19, 26, 32, 40, 46, 51, 55, 59, 62, 65,
67, 70, 72, 73, 76, 77, 79, 80, 83, 84, 85, 86, 87, 88, 88, 89, 89, 87, 87, 86,
82, 81, 80, 78, 76, 75, 74, 73, 72, 71, 72, 72, 71, 72, 72, 72, 72, 72, 72, 72,
72, 70, 69, 69, 68, 66, 66, 65, 63, 62, 62, 61, 60, 59, 58, 57, 56, 55, 54, 52,
51, 49, 48, 47, 46, 44, 43, 42, 42, 42, 41, 40, 39, 37, 36, 34, 33, 30, 27, 23,
20, 17, 12, 7, 3, -1, -6, -10, -14, -19, -21, -25, -28, -31, -34, -37, -39, -43,
-45, -48, -52, -55, -57, -61, -63, -65, -67, -69, -70, -71, -70, -69, -68, -66,
-65, -61, -58, -55, -52, -50, -48, -45, -45, -44, -44, -45, -46, -48, -48, -50,
-52, -54, -56, -57, -59, -60, -62, -62, -64, -65, -66, -67, -69, -71, -74, -76,
-79, -82, -85, -88, -91, -94, -97, -98, -100, -103, -103, -104, -105, -104,
-104, -104, -104, -104, -103, -104, -104, -105, -104, -104, -105, -105, -106,
-107, -107, -108, -108, -109, -109, -108, -109, -110, -109, -110, -111, -111,
-111, -111, -112, -113, -114, -113, -114, -114, -113, -113, -112, -112, -111,
-109, -109, -109, -108, -107, -107, -108, -108, -110, -110, -112, -113, -115,
-116, -117, -117, -118, -117, -117, -117, -115, -113, -111, -109, -106, -103,
-102, -99, -96, -93, -90, -88, -85, -81, -76, -72, -67, -62, -56, -49, -41, -33,
-24, -15, -5, };