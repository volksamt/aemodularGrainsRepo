#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0103

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 10, 16, 23, 29, 36, 42, 48, 54, 60,
65, 69, 74, 79, 84, 88, 91, 94, 97, 100, 103, 104, 106, 107, 108, 110, 110, 111,
111, 111, 111, 110, 110, 109, 108, 107, 106, 105, 105, 104, 103, 102, 101, 101,
101, 100, 98, 98, 98, 98, 98, 98, 98, 99, 99, 99, 100, 100, 101, 101, 101, 102,
103, 103, 104, 105, 106, 106, 106, 106, 107, 107, 108, 107, 107, 107, 105, 105,
104, 103, 103, 100, 99, 98, 95, 93, 91, 89, 88, 86, 83, 80, 78, 76, 73, 71, 67,
65, 63, 61, 58, 56, 55, 54, 53, 51, 50, 50, 49, 48, 50, 49, 50, 51, 52, 53, 55,
56, 58, 60, 63, 65, 68, 71, 74, 77, 80, 84, 86, 90, 93, 97, 99, 101, 105, 108,
110, 111, 114, 115, 116, 117, 118, 118, 119, 118, 118, 118, 117, 116, 114, 112,
110, 108, 107, 103, 100, 98, 95, 91, 88, 84, 80, 78, 74, 69, 67, 64, 60, 57, 53,
51, 47, 45, 42, 39, 37, 34, 32, 30, 28, 26, 25, 23, 21, 21, 19, 18, 18, 17, 15,
16, 13, 14, 13, 11, 11, 11, 10, 8, 7, 7, 5, 5, 3, 1, 0, -2, -4, -6, -8, -10,
-13, -14, -17, -18, -22, -24, -26, -29, -31, -34, -37, -39, -42, -43, -46, -48,
-50, -51, -52, -53, -54, -55, -55, -55, -55, -55, -54, -53, -52, -50, -48, -46,
-44, -41, -39, -35, -32, -28, -25, -21, -17, -12, -8, -4, 0, 5, 9, 14, 17, 21,
25, 30, 33, 35, 39, 42, 44, 47, 49, 50, 51, 52, 53, 54, 55, 55, 54, 54, 54, 52,
50, 49, 47, 46, 44, 41, 39, 37, 34, 32, 30, 27, 24, 21, 18, 17, 14, 12, 9, 7, 5,
3, 2, 0, -2, -3, -5, -6, -7, -9, -9, -10, -12, -13, -13, -14, -14, -16, -16,
-17, -18, -18, -20, -20, -22, -22, -24, -26, -27, -29, -30, -32, -34, -37, -40,
-41, -44, -48, -50, -53, -57, -59, -62, -66, -70, -72, -76, -79, -83, -87, -91,
-93, -97, -100, -102, -105, -109, -110, -112, -114, -115, -116, -117, -118,
-119, -118, -118, -119, -117, -118, -116, -114, -113, -111, -108, -107, -104,
-100, -99, -95, -91, -89, -85, -82, -79, -75, -73, -70, -67, -64, -62, -60, -57,
-56, -54, -53, -51, -50, -50, -49, -49, -49, -49, -49, -51, -52, -52, -54, -56,
-57, -60, -62, -63, -66, -69, -72, -75, -76, -79, -81, -84, -86, -88, -90, -93,
-95, -96, -98, -100, -100, -103, -104, -105, -105, -106, -107, -106, -108, -106,
-107, -106, -106, -105, -105, -105, -105, -104, -104, -102, -101, -101, -101,
-99, -99, -98, -99, -98, -97, -97, -97, -97, -98, -97, -98, -99, -99, -98, -100,
-101, -101, -102, -103, -104, -104, -105, -106, -107, -107, -108, -108, -109,
-108, -109, -109, -108, -107, -106, -105, -103, -101, -98, -96, -93, -89, -87,
-83, -79, -75, -69, -65, -60, -54, -48, -42, -36, -30, -24, -16, -10, -3, };