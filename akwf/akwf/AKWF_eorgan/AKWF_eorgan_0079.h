#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0079

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 15, 27, 38, 49, 60, 69, 79, 87, 94,
100, 106, 110, 114, 117, 119, 119, 119, 118, 118, 116, 115, 113, 110, 109, 106,
104, 102, 101, 99, 98, 96, 96, 95, 96, 96, 97, 96, 97, 98, 99, 100, 100, 102,
103, 103, 104, 105, 105, 106, 106, 106, 106, 105, 105, 105, 104, 103, 101, 101,
99, 97, 96, 93, 91, 89, 86, 82, 80, 76, 72, 68, 64, 60, 56, 52, 48, 44, 40, 37,
33, 30, 27, 25, 23, 22, 20, 19, 19, 18, 18, 18, 20, 20, 20, 20, 22, 22, 22, 22,
22, 22, 22, 20, 19, 18, 16, 14, 11, 8, 6, 3, 1, -1, -3, -5, -7, -8, -9, -10, -9,
-10, -9, -8, -7, -5, -4, -2, 0, 2, 5, 6, 8, 9, 11, 11, 12, 13, 13, 13, 12, 11,
10, 9, 8, 7, 6, 4, 3, 3, 2, 3, 2, 3, 4, 6, 8, 10, 11, 15, 16, 20, 23, 26, 29,
31, 33, 36, 39, 40, 42, 43, 44, 45, 44, 44, 43, 41, 40, 39, 37, 34, 32, 30, 28,
25, 24, 21, 20, 18, 17, 14, 13, 12, 12, 10, 10, 9, 8, 8, 7, 7, 8, 7, 7, 7, 8, 8,
7, 8, 8, 9, 9, 10, 9, 9, 10, 10, 9, 8, 8, 6, 4, 3, 1, -2, -4, -8, -11, -16, -19,
-24, -29, -33, -38, -43, -47, -51, -56, -59, -61, -63, -64, -64, -64, -63, -61,
-58, -54, -49, -43, -37, -30, -23, -16, -7, 2, 10, 18, 26, 33, 40, 45, 51, 56,
59, 62, 63, 64, 65, 64, 62, 61, 57, 54, 51, 46, 42, 36, 32, 27, 22, 18, 14, 9,
7, 3, 0, -2, -4, -6, -7, -9, -8, -10, -10, -10, -11, -10, -10, -10, -9, -9, -9,
-8, -8, -8, -9, -8, -8, -9, -8, -9, -9, -10, -10, -10, -12, -12, -13, -15, -15,
-18, -19, -21, -23, -25, -27, -29, -31, -33, -35, -37, -39, -40, -42, -43, -44,
-44, -44, -44, -42, -41, -39, -38, -35, -33, -31, -27, -25, -22, -18, -17, -14,
-12, -8, -7, -5, -4, -3, -3, -3, -2, -3, -4, -5, -7, -8, -9, -10, -11, -11, -12,
-13, -13, -13, -13, -11, -11, -9, -8, -5, -3, -1, 0, 3, 4, 6, 8, 8, 9, 10, 10,
10, 9, 8, 7, 4, 2, 0, -3, -6, -7, -10, -13, -15, -17, -19, -21, -22, -22, -23,
-23, -23, -23, -23, -22, -21, -20, -20, -19, -18, -19, -18, -19, -20, -21, -22,
-24, -25, -29, -31, -35, -39, -42, -46, -49, -53, -57, -62, -66, -71, -73, -77,
-81, -84, -87, -90, -92, -94, -97, -98, -100, -101, -102, -103, -104, -104,
-105, -106, -106, -105, -106, -105, -104, -104, -103, -103, -102, -100, -100,
-98, -98, -97, -96, -95, -95, -95, -94, -95, -95, -95, -97, -98, -99, -102,
-103, -105, -108, -110, -112, -113, -115, -116, -117, -117, -116, -114, -113,
-109, -106, -101, -96, -89, -81, -73, -64, -53, -43, -31, -19, -7, };