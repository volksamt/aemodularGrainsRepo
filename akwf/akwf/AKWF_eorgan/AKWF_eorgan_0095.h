#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0095

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 11, 15, 21, 25, 30, 33, 38, 42,
46, 50, 54, 57, 61, 64, 68, 71, 75, 78, 80, 84, 86, 89, 91, 93, 95, 97, 99, 102,
102, 105, 105, 108, 109, 110, 111, 111, 113, 113, 115, 115, 115, 116, 117, 117,
118, 119, 118, 118, 119, 119, 119, 118, 120, 119, 119, 120, 119, 118, 119, 119,
118, 118, 118, 118, 117, 118, 118, 117, 117, 116, 115, 115, 116, 115, 114, 114,
113, 113, 113, 112, 111, 111, 111, 109, 109, 108, 108, 107, 106, 105, 105, 104,
103, 102, 102, 100, 99, 99, 97, 96, 95, 93, 92, 91, 91, 89, 89, 86, 86, 84, 83,
81, 80, 79, 77, 76, 75, 74, 71, 70, 69, 67, 65, 64, 62, 61, 59, 58, 55, 54, 52,
51, 49, 48, 46, 45, 43, 41, 41, 40, 37, 37, 35, 35, 33, 33, 31, 29, 28, 27, 26,
25, 24, 23, 21, 21, 20, 19, 18, 16, 16, 14, 15, 14, 13, 12, 11, 11, 9, 8, 7, 7,
6, 5, 4, 5, 3, 2, 2, 1, 0, 0, -1, -3, -3, -4, -4, -6, -5, -6, -8, -9, -9, -11,
-11, -12, -12, -13, -15, -15, -17, -17, -18, -19, -21, -21, -22, -22, -24, -25,
-26, -27, -27, -27, -29, -29, -30, -31, -31, -32, -32, -33, -33, -34, -34, -33,
-33, -34, -34, -33, -33, -33, -32, -32, -30, -30, -29, -28, -26, -26, -24, -23,
-21, -20, -19, -17, -16, -14, -12, -10, -8, -6, -4, -1, 1, 3, 4, 7, 8, 10, 12,
14, 16, 17, 19, 21, 22, 23, 25, 26, 26, 28, 28, 30, 30, 31, 32, 32, 32, 33, 32,
33, 33, 33, 32, 32, 32, 32, 30, 31, 30, 30, 29, 29, 28, 27, 27, 25, 24, 23, 22,
22, 21, 20, 18, 18, 17, 16, 16, 14, 13, 13, 12, 10, 10, 9, 7, 6, 6, 6, 5, 3, 4,
2, 1, 1, -1, -1, -2, -3, -3, -4, -5, -4, -6, -7, -7, -8, -10, -10, -10, -11,
-12, -13, -14, -15, -15, -16, -17, -18, -19, -19, -21, -23, -23, -25, -25, -26,
-27, -28, -30, -31, -32, -33, -34, -36, -37, -39, -40, -41, -43, -44, -45, -47,
-48, -50, -51, -53, -54, -55, -58, -59, -60, -63, -64, -66, -67, -68, -70, -72,
-73, -75, -76, -77, -78, -81, -81, -83, -84, -86, -87, -88, -90, -90, -92, -92,
-94, -94, -96, -97, -98, -100, -100, -101, -102, -103, -104, -104, -105, -106,
-106, -107, -108, -109, -109, -110, -111, -111, -111, -113, -113, -113, -114,
-114, -115, -116, -116, -115, -116, -116, -116, -117, -116, -117, -117, -118,
-118, -118, -118, -118, -118, -118, -118, -119, -119, -118, -118, -119, -118,
-117, -117, -117, -117, -117, -116, -116, -115, -114, -113, -113, -113, -111,
-110, -109, -109, -108, -106, -104, -104, -102, -100, -98, -96, -94, -93, -90,
-87, -85, -82, -80, -77, -74, -71, -68, -64, -61, -57, -53, -50, -45, -42, -37,
-32, -29, -25, -21, -16, -10, -6, -2, };