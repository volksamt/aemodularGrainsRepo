#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0066

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 9, 18, 26, 33, 41, 47, 55, 61, 69,
75, 79, 86, 90, 95, 99, 102, 105, 108, 111, 113, 114, 116, 117, 118, 119, 119,
119, 119, 119, 118, 118, 118, 117, 117, 116, 115, 115, 114, 114, 113, 113, 113,
112, 113, 112, 112, 112, 112, 112, 112, 113, 113, 114, 113, 114, 115, 115, 115,
115, 116, 116, 115, 117, 116, 116, 116, 117, 116, 116, 116, 115, 116, 115, 116,
115, 115, 115, 114, 114, 114, 114, 113, 113, 113, 113, 112, 111, 111, 110, 110,
109, 107, 106, 105, 104, 103, 103, 101, 100, 99, 97, 95, 94, 93, 92, 90, 90, 88,
87, 85, 85, 84, 83, 82, 81, 81, 80, 81, 80, 80, 79, 79, 79, 79, 79, 80, 80, 80,
80, 81, 80, 80, 80, 80, 81, 80, 80, 80, 79, 79, 78, 77, 77, 76, 75, 73, 73, 71,
71, 69, 68, 66, 65, 64, 63, 62, 61, 59, 57, 57, 56, 55, 53, 52, 51, 50, 49, 49,
47, 46, 47, 46, 44, 43, 43, 42, 41, 41, 40, 40, 38, 39, 38, 37, 35, 35, 34, 34,
32, 32, 30, 30, 29, 28, 27, 26, 25, 24, 23, 22, 21, 20, 19, 17, 16, 14, 14, 12,
10, 8, 6, 5, 3, 0, -1, -4, -6, -10, -12, -15, -18, -20, -23, -26, -29, -32, -35,
-37, -39, -42, -45, -46, -48, -50, -51, -53, -52, -52, -53, -53, -51, -50, -47,
-46, -44, -40, -38, -34, -31, -26, -23, -18, -14, -9, -5, 1, 6, 10, 15, 20, 24,
28, 31, 36, 38, 42, 44, 46, 48, 50, 50, 52, 52, 53, 51, 50, 50, 48, 46, 45, 43,
41, 38, 35, 32, 29, 26, 24, 20, 18, 14, 12, 10, 7, 5, 2, -1, -2, -5, -7, -9,
-11, -12, -13, -16, -17, -18, -20, -21, -21, -23, -24, -25, -25, -27, -28, -29,
-29, -30, -31, -32, -33, -34, -34, -35, -37, -38, -38, -39, -40, -40, -42, -42,
-42, -43, -43, -44, -45, -46, -47, -48, -48, -49, -49, -51, -51, -53, -54, -55,
-56, -57, -58, -59, -60, -61, -63, -65, -66, -66, -68, -69, -71, -72, -73, -75,
-76, -76, -77, -79, -78, -80, -79, -80, -81, -81, -80, -81, -82, -81, -81, -81,
-81, -80, -80, -81, -80, -80, -80, -80, -80, -80, -80, -81, -80, -82, -82, -83,
-83, -85, -84, -86, -87, -88, -89, -90, -91, -92, -94, -95, -97, -97, -99, -101,
-102, -103, -104, -105, -106, -106, -109, -109, -109, -110, -110, -111, -112,
-112, -112, -113, -113, -114, -114, -115, -115, -115, -114, -114, -114, -115,
-116, -115, -115, -115, -115, -115, -115, -115, -115, -115, -115, -115, -114,
-114, -114, -113, -114, -113, -112, -112, -112, -111, -112, -111, -111, -111,
-110, -111, -111, -111, -111, -111, -112, -112, -112, -113, -113, -113, -114,
-115, -116, -116, -116, -116, -117, -117, -117, -115, -114, -114, -113, -112,
-110, -107, -104, -102, -98, -94, -89, -85, -80, -75, -69, -62, -56, -49, -43,
-34, -27, -19, -12, -3, };