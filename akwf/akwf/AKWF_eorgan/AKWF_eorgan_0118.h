#define DATA_LENGTH 512
#define DATA AKWF_eorgan_0118

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 12, 18, 23, 28, 32, 37, 41, 46,
50, 54, 59, 63, 66, 70, 74, 78, 81, 84, 87, 90, 92, 95, 97, 100, 103, 104, 105,
108, 109, 110, 112, 113, 115, 116, 117, 117, 118, 118, 119, 119, 119, 119, 119,
119, 118, 119, 118, 118, 117, 116, 116, 114, 114, 112, 111, 110, 109, 107, 106,
104, 103, 101, 99, 99, 96, 95, 93, 90, 88, 87, 84, 82, 80, 78, 75, 74, 71, 68,
67, 65, 62, 60, 57, 54, 52, 49, 47, 44, 42, 39, 38, 35, 32, 30, 27, 25, 23, 20,
19, 16, 14, 12, 9, 8, 5, 2, 1, -2, -4, -6, -7, -10, -11, -13, -15, -17, -18,
-20, -22, -25, -26, -27, -29, -30, -31, -33, -35, -36, -37, -38, -40, -41, -42,
-44, -43, -45, -44, -46, -47, -46, -48, -48, -47, -47, -48, -48, -48, -48, -47,
-47, -47, -47, -46, -46, -45, -44, -43, -43, -42, -41, -41, -40, -38, -37, -36,
-35, -35, -33, -31, -30, -29, -28, -27, -26, -24, -23, -23, -21, -21, -19, -20,
-18, -18, -17, -17, -16, -15, -16, -15, -15, -14, -14, -15, -14, -15, -14, -13,
-14, -14, -14, -14, -14, -14, -15, -14, -14, -15, -16, -15, -16, -17, -16, -16,
-17, -17, -17, -18, -17, -17, -17, -18, -18, -18, -17, -17, -17, -17, -17, -16,
-16, -15, -16, -15, -14, -14, -14, -14, -13, -13, -12, -11, -10, -9, -9, -9, -7,
-8, -5, -5, -4, -4, -2, -1, -1, 1, 2, 2, 4, 5, 5, 6, 7, 8, 9, 9, 10, 11, 12, 12,
12, 13, 14, 14, 15, 15, 16, 16, 16, 17, 17, 18, 18, 17, 17, 18, 18, 17, 17, 17,
18, 17, 17, 18, 17, 17, 17, 16, 17, 16, 15, 16, 15, 15, 15, 15, 14, 14, 15, 14,
14, 13, 14, 13, 14, 14, 15, 14, 14, 13, 14, 15, 15, 16, 16, 17, 17, 18, 19, 19,
20, 21, 21, 23, 23, 25, 26, 27, 28, 30, 30, 32, 33, 34, 35, 37, 38, 39, 40, 41,
40, 41, 42, 44, 45, 45, 45, 47, 46, 47, 47, 47, 47, 48, 47, 47, 47, 47, 47, 45,
45, 45, 45, 44, 43, 42, 42, 40, 40, 39, 37, 35, 34, 33, 32, 30, 28, 27, 25, 23,
23, 20, 19, 17, 15, 13, 11, 10, 8, 6, 3, 2, -1, -3, -5, -6, -9, -11, -13, -16,
-18, -20, -23, -25, -28, -29, -32, -34, -37, -39, -41, -44, -46, -49, -51, -53,
-56, -59, -61, -64, -67, -68, -70, -73, -75, -77, -79, -82, -83, -86, -88, -90,
-92, -93, -96, -97, -99, -100, -102, -104, -105, -107, -108, -109, -110, -112,
-112, -114, -115, -115, -116, -116, -118, -118, -118, -119, -118, -118, -119,
-118, -118, -118, -117, -117, -116, -115, -114, -113, -112, -111, -109, -108,
-106, -104, -102, -100, -97, -95, -92, -90, -87, -84, -80, -78, -75, -71, -68,
-63, -59, -55, -51, -47, -42, -38, -33, -29, -24, -19, -13, -8, -3, };