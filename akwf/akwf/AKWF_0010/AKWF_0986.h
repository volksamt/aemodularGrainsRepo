#define DATA_LENGTH 512
#define DATA AKWF_0986

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 11, 17, 22, 26, 31, 35, 41, 45,
50, 55, 59, 63, 68, 72, 76, 80, 85, 89, 93, 96, 99, 102, 105, 107, 111, 112,
114, 115, 117, 118, 119, 119, 118, 120, 119, 118, 116, 115, 114, 112, 110, 107,
104, 102, 98, 96, 91, 88, 84, 80, 76, 71, 66, 61, 56, 51, 46, 42, 36, 32, 27,
21, 16, 11, 7, 3, -2, -7, -12, -17, -20, -23, -27, -31, -34, -36, -40, -42, -45,
-47, -48, -49, -51, -51, -51, -53, -52, -52, -51, -51, -50, -49, -47, -46, -44,
-43, -39, -37, -34, -33, -29, -26, -23, -20, -17, -15, -11, -8, -5, -1, 2, 6, 8,
12, 15, 18, 22, 24, 26, 30, 32, 34, 36, 39, 40, 42, 43, 45, 46, 48, 48, 49, 48,
49, 49, 49, 48, 48, 47, 45, 45, 44, 43, 40, 39, 38, 36, 33, 32, 30, 28, 25, 23,
21, 18, 16, 14, 12, 10, 7, 4, 3, 0, -1, -3, -5, -7, -9, -10, -12, -13, -15, -15,
-17, -18, -19, -20, -20, -21, -21, -21, -22, -21, -21, -21, -21, -20, -20, -21,
-20, -20, -19, -19, -19, -17, -17, -16, -16, -15, -15, -14, -13, -14, -13, -13,
-14, -12, -12, -12, -11, -12, -12, -12, -11, -12, -12, -12, -13, -12, -12, -13,
-13, -14, -14, -14, -14, -13, -14, -14, -14, -13, -14, -13, -13, -13, -12, -12,
-10, -10, -10, -8, -6, -6, -4, -3, -1, 0, 2, 5, 6, 9, 12, 14, 17, 19, 22, 24,
27, 31, 34, 36, 39, 42, 45, 48, 50, 52, 56, 59, 61, 63, 65, 69, 71, 72, 74, 76,
77, 78, 79, 80, 80, 80, 80, 81, 79, 79, 78, 77, 75, 73, 71, 69, 66, 63, 62, 58,
54, 51, 47, 43, 39, 34, 30, 26, 21, 16, 11, 7, 2, -3, -8, -13, -18, -23, -29,
-33, -38, -42, -46, -51, -55, -60, -63, -67, -70, -74, -77, -79, -82, -85, -87,
-89, -90, -91, -92, -93, -93, -94, -94, -93, -92, -92, -90, -88, -87, -84, -82,
-79, -78, -75, -71, -67, -64, -60, -57, -53, -49, -45, -42, -37, -33, -29, -24,
-21, -16, -12, -9, -4, 0, 3, 8, 11, 14, 18, 22, 25, 28, 30, 32, 35, 37, 39, 41,
42, 43, 45, 45, 46, 47, 48, 47, 47, 47, 46, 45, 44, 44, 41, 41, 39, 36, 35, 33,
30, 28, 27, 24, 21, 18, 16, 13, 10, 6, 4, 2, -1, -5, -8, -9, -13, -16, -17, -21,
-24, -26, -29, -32, -34, -36, -39, -40, -42, -45, -46, -48, -50, -50, -52, -54,
-55, -56, -57, -58, -60, -60, -61, -62, -62, -63, -64, -64, -65, -65, -66, -66,
-66, -67, -67, -68, -69, -68, -69, -69, -70, -70, -71, -69, -70, -70, -70, -71,
-70, -72, -71, -71, -71, -71, -71, -70, -70, -69, -69, -68, -67, -65, -64, -64,
-63, -61, -60, -58, -56, -54, -52, -50, -47, -44, -41, -38, -35, -32, -28, -25,
-21, -18, -12, -9, -5, -2, };