#define DATA_LENGTH 512
#define DATA AKWF_0969

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 7, 8, 11, 13, 15, 17, 19, 21,
23, 25, 27, 30, 31, 32, 34, 36, 38, 41, 41, 43, 45, 47, 48, 51, 51, 53, 55, 56,
57, 59, 61, 62, 63, 65, 65, 67, 68, 68, 70, 71, 73, 73, 74, 75, 76, 77, 78, 78,
79, 79, 80, 80, 81, 82, 82, 82, 83, 83, 84, 83, 83, 84, 84, 85, 84, 84, 84, 84,
84, 84, 83, 82, 82, 83, 82, 81, 79, 79, 79, 77, 77, 76, 75, 73, 73, 72, 70, 68,
67, 66, 63, 63, 60, 59, 57, 55, 53, 50, 48, 46, 44, 41, 38, 35, 31, 28, 22, 19,
10, 3, 16, 20, 26, 29, 33, 36, 39, 41, 44, 47, 49, 52, 54, 57, 58, 60, 62, 64,
64, 67, 67, 69, 71, 72, 73, 74, 75, 77, 78, 78, 79, 80, 80, 81, 82, 82, 83, 82,
83, 84, 84, 84, 84, 84, 85, 84, 84, 84, 84, 84, 83, 83, 83, 82, 82, 81, 81, 81,
80, 79, 79, 78, 77, 76, 75, 75, 73, 72, 71, 71, 71, 69, 68, 66, 65, 64, 62, 61,
60, 58, 57, 56, 53, 52, 51, 49, 47, 46, 44, 43, 42, 40, 37, 36, 33, 31, 30, 29,
26, 25, 22, 21, 18, 17, 14, 12, 10, 8, 5, 4, 1, -1, -3, -5, -8, -9, -12, -14,
-15, -17, -19, -21, -23, -26, -27, -29, -31, -32, -34, -36, -37, -40, -41, -43,
-45, -46, -47, -49, -51, -52, -54, -55, -57, -57, -58, -61, -62, -63, -64, -65,
-66, -68, -68, -69, -70, -72, -72, -73, -74, -75, -75, -76, -78, -78, -79, -80,
-80, -80, -81, -81, -82, -83, -83, -83, -83, -84, -83, -84, -84, -84, -84, -83,
-84, -84, -84, -85, -84, -84, -83, -84, -83, -83, -82, -82, -81, -81, -80, -80,
-79, -79, -78, -78, -77, -76, -76, -75, -73, -72, -71, -71, -70, -69, -68, -67,
-66, -65, -64, -62, -62, -60, -59, -58, -56, -55, -53, -52, -51, -48, -47, -46,
-45, -44, -41, -40, -38, -37, -35, -33, -31, -30, -28, -26, -24, -22, -21, -19,
-16, -15, -13, -10, -8, -7, -4, -2, -1, -1, -3, -5, -8, -11, -12, -14, -16, -18,
-19, -21, -22, -25, -28, -28, -31, -33, -35, -36, -38, -39, -41, -42, -44, -45,
-46, -48, -50, -52, -54, -54, -56, -57, -58, -60, -62, -62, -63, -65, -65, -67,
-67, -69, -70, -71, -72, -72, -73, -74, -75, -76, -76, -78, -77, -79, -79, -79,
-81, -81, -82, -82, -82, -82, -83, -83, -84, -84, -84, -84, -84, -84, -84, -84,
-84, -84, -84, -84, -84, -84, -83, -83, -82, -82, -81, -82, -81, -80, -80, -79,
-79, -79, -78, -77, -76, -76, -74, -74, -73, -72, -71, -71, -69, -68, -67, -66,
-65, -64, -61, -61, -60, -59, -57, -56, -54, -53, -52, -50, -48, -48, -45, -44,
-41, -40, -39, -37, -35, -33, -31, -29, -28, -27, -25, -22, -20, -19, -17, -14,
-13, -10, -8, -5, -2, -1, 0, };