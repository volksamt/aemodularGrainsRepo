#define DATA_LENGTH 512
#define DATA AKWF_0990

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 9, 13, 15, 19, 23, 26, 28,
31, 33, 38, 40, 42, 44, 48, 49, 52, 54, 56, 59, 61, 62, 64, 66, 67, 70, 71, 73,
74, 76, 77, 79, 80, 80, 81, 82, 83, 84, 85, 86, 86, 87, 87, 87, 88, 88, 88, 88,
89, 88, 88, 89, 88, 89, 87, 87, 87, 87, 86, 85, 85, 84, 83, 83, 81, 81, 81, 79,
79, 77, 77, 76, 74, 73, 71, 70, 70, 68, 68, 66, 65, 63, 62, 61, 60, 58, 57, 56,
55, 53, 52, 50, 49, 47, 46, 44, 43, 41, 41, 39, 38, 37, 34, 34, 32, 31, 30, 28,
27, 26, 25, 24, 22, 21, 21, 18, 17, 16, 16, 14, 13, 12, 11, 10, 9, 8, 7, 6, 5,
4, 3, 2, 2, 1, 1, -1, -1, -2, -2, -3, -4, -4, -5, -6, -6, -7, -8, -8, -8, -8,
-9, -9, -10, -11, -10, -11, -11, -11, -11, -11, -12, -11, -10, -9, -7, -5, -3,
0, 3, 6, 9, 13, 17, 21, 25, 29, 34, 38, 43, 47, 52, 56, 61, 65, 68, 73, 76, 81,
85, 87, 91, 95, 97, 100, 103, 106, 108, 110, 112, 112, 114, 115, 117, 118, 118,
119, 119, 119, 119, 118, 118, 118, 118, 116, 115, 113, 113, 111, 109, 106, 105,
103, 101, 99, 96, 93, 90, 88, 85, 83, 79, 77, 74, 70, 67, 64, 61, 58, 55, 50,
48, 44, 40, 37, 33, 30, 26, 23, 19, 16, 12, 9, 6, 3, -1, -5, -7, -10, -13, -16,
-20, -23, -26, -29, -32, -35, -37, -39, -42, -45, -47, -49, -52, -55, -56, -59,
-60, -62, -64, -66, -68, -70, -71, -73, -75, -75, -76, -78, -80, -81, -82, -82,
-84, -84, -85, -86, -86, -86, -87, -87, -88, -88, -89, -88, -88, -89, -88, -88,
-88, -88, -87, -87, -86, -86, -86, -85, -84, -84, -83, -83, -81, -80, -80, -79,
-79, -78, -76, -75, -74, -73, -72, -70, -69, -68, -67, -66, -65, -63, -62, -61,
-60, -59, -57, -55, -54, -53, -51, -49, -48, -48, -46, -44, -43, -42, -40, -38,
-38, -37, -35, -33, -32, -31, -30, -27, -27, -26, -24, -23, -22, -21, -20, -19,
-18, -16, -16, -13, -13, -12, -11, -10, -9, -8, -7, -6, -5, -5, -4, -3, -1, 0,
0, 1, 1, 2, 3, 3, 4, 5, 5, 5, 6, 6, 7, 7, 8, 9, 9, 9, 9, 9, 10, 11, 11, 11, 11,
11, 11, 10, 9, 8, 7, 6, 2, 0, -3, -6, -10, -14, -18, -21, -26, -31, -35, -38,
-43, -48, -53, -56, -61, -66, -69, -73, -78, -81, -84, -88, -91, -94, -97, -100,
-103, -105, -107, -110, -111, -113, -114, -116, -118, -117, -118, -119, -119,
-120, -119, -119, -119, -118, -117, -116, -114, -114, -112, -111, -109, -107,
-105, -103, -101, -98, -96, -93, -91, -88, -85, -81, -79, -77, -74, -70, -68,
-64, -61, -57, -54, -50, -46, -44, -40, -36, -33, -29, -26, -23, -19, -16, -13,
-10, -6, -2, };