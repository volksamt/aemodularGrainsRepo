#define DATA_LENGTH 512
#define DATA AKWF_0957

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 3, 4, 6, 7, 8, 9, 12, 13, 14,
15, 16, 17, 18, 19, 21, 21, 23, 24, 26, 26, 27, 28, 29, 31, 31, 33, 33, 35, 36,
37, 38, 39, 39, 41, 42, 42, 43, 44, 45, 45, 47, 47, 48, 49, 50, 50, 50, 51, 52,
53, 54, 54, 55, 55, 56, 57, 57, 59, 59, 59, 59, 59, 60, 60, 61, 62, 63, 63, 63,
63, 63, 65, 65, 66, 65, 66, 66, 66, 67, 68, 68, 68, 69, 69, 69, 69, 70, 71, 71,
71, 71, 71, 71, 72, 72, 73, 72, 73, 74, 73, 74, 74, 74, 74, 75, 75, 75, 75, 75,
75, 75, 77, 76, 76, 76, 77, 77, 77, 77, 78, 77, 77, 78, 78, 78, 79, 78, 79, 79,
78, 79, 80, 79, 79, 79, 79, 79, 79, 79, 79, 79, 79, 79, 80, 79, 79, 79, 79, 80,
79, 80, 79, 80, 79, 79, 79, 78, 78, 79, 78, 79, 78, 79, 79, 79, 78, 79, 78, 77,
77, 77, 78, 77, 77, 77, 76, 76, 76, 76, 76, 75, 76, 75, 75, 75, 74, 74, 74, 73,
73, 73, 74, 72, 72, 72, 72, 71, 71, 70, 70, 69, 69, 68, 67, 66, 67, 66, 65, 65,
65, 64, 63, 63, 62, 62, 60, 59, 59, 58, 57, 57, 55, 55, 53, 53, 52, 50, 51, 49,
48, 47, 46, 46, 45, 43, 42, 41, 40, 39, 38, 36, 35, 34, 33, 31, 30, 30, 28, 27,
25, 23, 22, 22, 19, 18, 17, 15, 14, 13, 12, 11, 9, 8, 6, 4, 4, 2, 0, -1, -3, -5,
-5, -6, -8, -9, -11, -11, -14, -15, -16, -18, -19, -20, -21, -23, -24, -25, -27,
-28, -29, -30, -32, -32, -34, -34, -37, -37, -39, -39, -41, -42, -43, -43, -45,
-46, -47, -47, -48, -48, -50, -50, -52, -52, -54, -55, -55, -56, -57, -57, -59,
-60, -60, -62, -63, -62, -64, -65, -65, -66, -66, -67, -68, -68, -70, -71, -71,
-72, -72, -73, -73, -74, -75, -76, -76, -76, -78, -79, -79, -79, -80, -80, -81,
-81, -83, -82, -84, -83, -85, -85, -86, -87, -87, -88, -88, -88, -89, -89, -91,
-91, -91, -91, -91, -92, -92, -92, -94, -93, -95, -95, -95, -95, -96, -97, -96,
-96, -97, -98, -98, -98, -98, -99, -98, -98, -100, -100, -100, -100, -100, -100,
-101, -100, -101, -100, -100, -100, -100, -100, -100, -100, -100, -100, -100,
-98, -98, -98, -98, -98, -97, -97, -96, -96, -96, -95, -95, -94, -94, -93, -92,
-91, -91, -90, -89, -89, -88, -87, -87, -87, -85, -84, -84, -82, -81, -81, -80,
-79, -78, -77, -76, -75, -74, -72, -72, -70, -69, -69, -68, -66, -65, -63, -63,
-62, -61, -60, -57, -57, -56, -54, -53, -52, -51, -50, -48, -47, -45, -46, -44,
-43, -41, -40, -39, -37, -35, -35, -33, -33, -31, -29, -28, -26, -26, -24, -23,
-22, -19, -18, -17, -16, -16, -13, -11, -11, -10, -8, -8, -6, -4, -2, -1, 0, 0,
};