#define DATA_LENGTH 512
#define DATA AKWF_0993

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 6, 8, 9, 10, 12, 14, 16, 20, 24,
27, 28, 29, 30, 31, 32, 32, 35, 36, 38, 41, 43, 44, 45, 47, 49, 53, 59, 67, 77,
82, 80, 70, 54, 36, 24, 20, 23, 24, 26, 26, 24, 23, 22, 22, 24, 24, 25, 25, 26,
27, 28, 28, 28, 28, 28, 26, 25, 24, 21, 18, 15, 11, 7, 5, 2, 1, -1, 0, -1, -1,
-2, -2, -3, -3, -4, -6, -6, -6, -6, -8, -8, -9, -11, -11, -11, -13, -13, -14,
-15, -16, -17, -17, -17, -19, -19, -20, -21, -21, -23, -23, -24, -24, -25, -25,
-25, -26, -25, -22, -17, -13, -8, -5, -3, -3, -3, -3, -3, -2, -1, -2, 0, 0, 1,
1, 1, 3, 2, 3, 4, 5, 6, 6, 5, 6, 6, 8, 8, 9, 10, 11, 11, 12, 12, 11, 9, 7, 3, 2,
0, 0, 3, 5, 9, 13, 16, 19, 20, 20, 20, 18, 17, 14, 11, 10, 10, 10, 12, 13, 15,
18, 22, 26, 30, 31, 31, 30, 28, 25, 22, 19, 19, 20, 20, 23, 25, 26, 27, 27, 27,
26, 24, 21, 17, 13, 11, 10, 9, 9, 9, 10, 11, 13, 17, 20, 22, 21, 20, 17, 13, 8,
4, 0, -4, -7, -8, -9, -7, -4, -1, 4, 6, 5, 3, -1, -4, -7, -9, -8, -4, 0, 6, 12,
17, 18, 19, 18, 17, 19, 19, 20, 20, 19, 18, 16, 17, 19, 25, 32, 40, 43, 43, 39,
29, 20, 16, 16, 17, 19, 20, 20, 22, 22, 22, 20, 18, 15, 12, 8, 3, -1, -4, -5,
-6, -4, -4, -4, -5, -5, -4, -5, -4, -4, -3, -3, -3, -3, -3, -3, -2, -3, -2, -2,
-2, -2, -2, -1, -2, -2, -2, -2, -2, -2, -2, -2, -3, -3, -4, -5, -7, -9, -11,
-11, -12, -13, -12, -13, -12, -12, -12, -11, -10, -10, -9, -6, -7, -7, -5, -5,
-5, -5, -3, -3, -3, -3, -3, -2, -1, -1, 0, -1, 0, 1, 2, 2, 2, 3, 3, 3, 3, 3, 3,
5, 4, 5, 5, 4, 4, 4, 3, 3, 3, 3, 4, 5, 6, 7, 8, 8, 8, 9, 8, 9, 7, 8, 8, 8, 9, 8,
9, 10, 11, 13, 13, 15, 16, 16, 16, 17, 17, 17, 16, 16, 17, 18, 18, 19, 19, 21,
21, 22, 22, 21, 22, 21, 21, 20, 19, 21, 21, 21, 20, 22, 22, 23, 25, 24, 25, 25,
25, 23, 22, 20, 19, 18, 17, 17, 17, 17, 18, 19, 19, 20, 20, 19, 16, 14, 11, 12,
14, 17, 22, 28, 31, 34, 35, 36, 35, 36, 35, 35, 34, 33, 32, 30, 29, 28, 27, 26,
27, 28, 28, 28, 25, 20, 16, 10, 4, -2, -13, -30, -47, -65, -76, -78, -78, -75,
-72, -67, -68, -71, -75, -80, -86, -89, -93, -97, -100, -103, -107, -109, -111,
-113, -114, -115, -117, -119, -118, -118, -115, -112, -109, -107, -105, -102,
-97, -86, -71, -48, -27, -7, };