#define DATA_LENGTH 512
#define DATA AKWF_0933

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 8, 10, 14, 18, 22, 26, 29, 32,
36, 39, 42, 46, 49, 53, 56, 59, 62, 65, 68, 71, 74, 77, 79, 81, 84, 86, 89, 91,
93, 96, 98, 100, 101, 103, 105, 107, 108, 110, 110, 112, 113, 114, 115, 116,
116, 117, 118, 118, 118, 119, 119, 119, 120, 119, 119, 118, 119, 118, 118, 117,
117, 115, 115, 114, 114, 113, 112, 111, 109, 109, 109, 106, 106, 104, 102, 102,
100, 99, 97, 96, 94, 93, 92, 90, 88, 87, 85, 83, 82, 80, 77, 76, 75, 72, 72, 69,
68, 66, 63, 62, 60, 59, 57, 55, 54, 51, 50, 49, 47, 45, 43, 42, 40, 39, 37, 36,
34, 33, 32, 30, 29, 27, 26, 25, 24, 23, 22, 21, 20, 19, 18, 17, 16, 15, 15, 14,
13, 13, 12, 12, 10, 11, 10, 9, 9, 9, 9, 8, 8, 8, 9, 8, 8, 8, 7, 9, 9, 8, 8, 8,
9, 9, 9, 9, 9, 10, 10, 11, 11, 11, 11, 12, 11, 12, 13, 13, 13, 13, 14, 15, 14,
15, 15, 15, 16, 16, 16, 16, 16, 17, 17, 17, 17, 17, 17, 17, 18, 18, 18, 17, 18,
17, 17, 16, 17, 17, 17, 16, 16, 17, 16, 16, 15, 15, 15, 14, 15, 15, 15, 14, 14,
14, 13, 13, 12, 11, 11, 10, 10, 10, 10, 9, 9, 8, 8, 7, 7, 7, 6, 6, 5, 5, 4, 5,
3, 3, 3, 3, 3, 2, 1, 2, 1, 0, 1, -1, -1, -1, -2, -2, -3, -2, -3, -4, -4, -4, -5,
-5, -6, -7, -6, -8, -7, -7, -8, -9, -9, -9, -10, -10, -11, -11, -12, -11, -12,
-13, -13, -13, -14, -14, -14, -14, -15, -14, -16, -15, -16, -16, -16, -17, -16,
-17, -17, -17, -17, -18, -17, -17, -18, -17, -17, -17, -17, -17, -17, -17, -17,
-17, -17, -17, -16, -16, -15, -15, -15, -15, -15, -15, -15, -14, -14, -13, -13,
-13, -12, -13, -12, -11, -12, -12, -10, -10, -9, -10, -10, -9, -9, -9, -9, -9,
-9, -8, -8, -9, -8, -8, -8, -9, -8, -8, -8, -8, -9, -8, -9, -10, -10, -10, -11,
-11, -12, -13, -14, -14, -15, -15, -16, -16, -18, -19, -21, -21, -22, -23, -25,
-26, -27, -29, -29, -30, -33, -34, -34, -36, -37, -39, -41, -43, -45, -46, -47,
-49, -51, -52, -54, -56, -57, -59, -60, -63, -64, -66, -67, -70, -71, -73, -75,
-76, -79, -80, -82, -83, -85, -87, -88, -90, -92, -93, -95, -96, -97, -99, -100,
-101, -104, -105, -105, -106, -109, -109, -111, -111, -112, -112, -114, -115,
-115, -116, -117, -117, -118, -117, -119, -119, -119, -118, -119, -119, -118,
-118, -118, -118, -118, -117, -117, -115, -114, -114, -112, -112, -110, -109,
-108, -106, -105, -102, -101, -99, -97, -96, -93, -91, -88, -86, -84, -81, -79,
-76, -73, -71, -68, -65, -61, -59, -55, -52, -48, -46, -42, -39, -35, -32, -28,
-25, -20, -17, -13, -10, -6, -3, };