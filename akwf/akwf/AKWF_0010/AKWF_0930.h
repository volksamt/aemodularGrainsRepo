#define DATA_LENGTH 512
#define DATA AKWF_0930

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 12, 18, 23, 29, 36, 42, 46, 53,
57, 62, 67, 73, 77, 81, 86, 90, 93, 97, 100, 103, 105, 108, 111, 112, 114, 115,
117, 118, 118, 119, 119, 119, 119, 119, 117, 116, 116, 114, 113, 110, 109, 108,
105, 103, 101, 99, 95, 93, 91, 88, 85, 83, 80, 76, 75, 71, 69, 66, 63, 60, 59,
56, 53, 51, 48, 47, 45, 43, 40, 39, 37, 35, 35, 33, 31, 31, 30, 28, 27, 27, 26,
24, 25, 24, 23, 23, 22, 22, 20, 21, 21, 20, 19, 19, 18, 19, 18, 17, 17, 17, 16,
16, 15, 14, 14, 12, 12, 11, 10, 9, 9, 7, 6, 6, 4, 3, 3, 2, 1, -1, -1, -2, -3,
-4, -4, -6, -6, -6, -7, -8, -8, -8, -8, -8, -8, -8, -7, -7, -6, -6, -4, -3, -2,
-1, 0, 2, 3, 6, 8, 10, 12, 15, 18, 19, 22, 26, 28, 32, 34, 38, 41, 44, 47, 51,
53, 57, 60, 64, 67, 70, 73, 75, 78, 81, 85, 86, 88, 91, 94, 96, 97, 100, 100,
102, 103, 104, 105, 104, 105, 106, 106, 105, 104, 104, 103, 101, 100, 99, 97,
96, 93, 91, 89, 87, 84, 82, 79, 76, 73, 70, 67, 64, 62, 57, 55, 52, 48, 45, 42,
39, 36, 33, 30, 27, 26, 23, 20, 18, 16, 13, 12, 10, 7, 6, 5, 4, 3, 2, 1, 0, -1,
0, -1, -2, -2, -2, -1, -3, -2, -1, -1, 0, 0, 0, 1, 1, 1, 2, 1, 2, 1, 2, 2, 2, 2,
2, 1, 0, 1, -1, 0, -2, -3, -4, -5, -7, -8, -10, -12, -13, -16, -18, -21, -23,
-26, -29, -30, -34, -37, -40, -42, -46, -49, -52, -56, -59, -62, -65, -67, -71,
-74, -76, -79, -83, -84, -87, -90, -92, -93, -96, -97, -99, -101, -102, -104,
-103, -105, -105, -105, -106, -106, -105, -105, -104, -103, -102, -100, -99,
-98, -96, -93, -91, -88, -86, -83, -81, -77, -76, -73, -70, -66, -63, -59, -56,
-53, -50, -47, -43, -40, -37, -33, -30, -27, -25, -22, -19, -16, -14, -12, -9,
-7, -5, -2, -1, 1, 1, 3, 4, 5, 7, 7, 7, 8, 8, 8, 8, 8, 8, 8, 7, 7, 6, 6, 6, 5,
3, 3, 2, 1, 0, -1, -2, -3, -4, -5, -6, -6, -8, -9, -10, -10, -11, -12, -13, -14,
-15, -15, -15, -16, -17, -17, -17, -18, -18, -19, -19, -20, -20, -21, -21, -21,
-21, -22, -23, -24, -23, -24, -25, -26, -27, -27, -29, -29, -31, -31, -33, -35,
-37, -37, -39, -41, -43, -44, -47, -50, -52, -54, -56, -58, -61, -64, -67, -70,
-72, -75, -78, -80, -83, -86, -89, -91, -94, -96, -99, -101, -103, -106, -108,
-109, -112, -114, -115, -116, -117, -117, -118, -119, -119, -119, -119, -118,
-117, -116, -115, -114, -112, -109, -108, -105, -103, -100, -96, -92, -89, -84,
-81, -76, -71, -66, -62, -55, -51, -45, -40, -35, -29, -22, -17, -11, -4, };