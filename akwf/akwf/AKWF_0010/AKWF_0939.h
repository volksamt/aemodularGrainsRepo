#define DATA_LENGTH 512
#define DATA AKWF_0939

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 10, 15, 19, 24, 29, 33, 38, 43,
47, 52, 56, 60, 64, 68, 72, 75, 79, 83, 86, 89, 92, 95, 97, 100, 102, 104, 106,
108, 110, 111, 113, 114, 115, 116, 116, 117, 118, 119, 118, 119, 119, 119, 118,
119, 118, 117, 117, 116, 115, 114, 113, 112, 111, 109, 107, 107, 105, 104, 101,
100, 98, 97, 95, 92, 91, 88, 85, 83, 82, 78, 75, 73, 71, 69, 65, 63, 60, 57, 54,
51, 48, 45, 42, 39, 36, 33, 31, 27, 24, 21, 18, 16, 11, 9, 7, 4, 1, -3, -5, -8,
-10, -12, -15, -18, -19, -22, -24, -26, -27, -29, -32, -33, -34, -36, -37, -37,
-39, -40, -40, -41, -42, -42, -42, -42, -43, -42, -41, -42, -42, -40, -40, -40,
-40, -38, -37, -36, -36, -34, -33, -32, -30, -28, -27, -26, -24, -22, -21, -19,
-17, -16, -14, -12, -10, -8, -5, -3, -1, 0, 3, 5, 8, 10, 12, 14, 16, 19, 21, 23,
26, 27, 30, 33, 35, 37, 40, 42, 45, 47, 49, 51, 53, 55, 57, 60, 62, 63, 66, 66,
69, 70, 72, 73, 75, 75, 77, 78, 78, 79, 80, 81, 81, 81, 82, 82, 82, 82, 81, 81,
80, 80, 79, 78, 78, 76, 76, 74, 72, 71, 70, 69, 67, 64, 63, 61, 60, 58, 57, 53,
52, 50, 47, 46, 44, 42, 39, 38, 35, 33, 32, 29, 27, 25, 23, 21, 19, 17, 16, 13,
11, 10, 7, 5, 3, 2, 0, -3, -4, -6, -8, -10, -12, -14, -16, -18, -20, -22, -23,
-25, -27, -30, -32, -34, -36, -37, -40, -43, -45, -45, -49, -50, -52, -54, -56,
-59, -60, -63, -64, -65, -67, -69, -70, -71, -73, -74, -75, -76, -77, -78, -79,
-81, -81, -81, -82, -82, -82, -82, -82, -81, -81, -80, -80, -79, -78, -77, -77,
-75, -74, -72, -72, -70, -69, -66, -65, -64, -61, -59, -57, -55, -52, -51, -48,
-46, -43, -42, -39, -38, -35, -32, -30, -27, -24, -23, -20, -18, -16, -14, -10,
-9, -6, -4, -2, 0, 3, 4, 6, 9, 10, 12, 14, 17, 18, 20, 21, 24, 24, 26, 28, 30,
31, 32, 34, 34, 36, 36, 37, 38, 39, 40, 41, 42, 42, 42, 41, 42, 42, 42, 42, 41,
41, 41, 39, 39, 38, 38, 37, 35, 33, 32, 31, 29, 27, 25, 23, 22, 19, 16, 15, 12,
10, 7, 4, 2, -1, -4, -6, -9, -13, -16, -18, -22, -25, -28, -31, -35, -37, -40,
-43, -45, -49, -52, -54, -58, -61, -63, -65, -68, -71, -75, -76, -80, -81, -84,
-86, -88, -91, -93, -95, -96, -98, -101, -103, -103, -105, -107, -108, -109,
-110, -112, -114, -115, -115, -117, -116, -118, -119, -119, -119, -119, -118,
-120, -118, -119, -118, -118, -116, -116, -116, -113, -113, -110, -109, -108,
-105, -103, -102, -99, -96, -93, -91, -88, -85, -81, -78, -75, -71, -66, -63,
-60, -55, -50, -46, -42, -38, -33, -28, -24, -19, -13, -9, -4, };