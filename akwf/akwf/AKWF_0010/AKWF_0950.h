#define DATA_LENGTH 512
#define DATA AKWF_0950

const PROGMEM int8_t DATA[DATA_LENGTH] = {62, 76, 71, 74, 71, 74, 71, 74, 72,
73, 71, 74, 72, 74, 73, 73, 73, 73, 72, 73, 73, 73, 72, 72, 73, 73, 73, 72, 73,
73, 73, 73, 73, 72, 73, 72, 73, 73, 73, 73, 74, 72, 73, 73, 73, 73, 73, 73, 73,
73, 74, 73, 73, 74, 74, 74, 73, 73, 73, 73, 73, 73, 73, 73, 73, 73, 73, 74, 74,
74, 73, 74, 73, 73, 73, 73, 74, 74, 73, 74, 74, 74, 74, 73, 73, 73, 74, 73, 74,
74, 73, 73, 73, 74, 74, 73, 74, 73, 74, 73, 74, 73, 73, 74, 74, 74, 74, 74, 74,
74, 73, 74, 74, 73, 73, 74, 74, 74, 74, 74, 73, 73, 73, 73, 73, 74, 74, 73, 73,
73, 73, 73, 74, 73, 74, 74, 74, 73, 73, 74, 74, 73, 74, 73, 74, 74, 74, 74, 73,
73, 73, 75, 76, 77, 78, 78, 79, 79, 77, 76, 75, 75, 74, 74, 73, 73, 73, 73, 74,
73, 74, 74, 74, 73, 73, 73, 74, 73, 74, 73, 73, 73, 74, 73, 73, 73, 73, 74, 73,
73, 72, 73, 72, 75, 72, 75, 71, 75, 70, 76, 69, 76, 67, 82, 46, -59, -38, -46,
-42, -45, -44, -44, -44, -44, -45, -43, -45, -42, -45, -39, -109, -121, -117,
-120, -118, -119, -119, -119, -119, -118, -120, -117, -119, -117, -120, -117,
-119, -117, -12, 1, -7, 0, -6, -1, -5, -1, -4, -1, -4, -2, -4, -1, -4, -3, -3,
-2, -3, -3, -3, -3, -3, -3, -2, -4, -3, -3, -3, -3, -2, -3, -2, -3, -3, -2, -2,
-3, -2, -3, -2, -3, -2, -3, -3, -3, -3, -3, -3, -2, -2, -3, -3, -3, -2, -2, -3,
-2, -2, -2, -3, -2, -2, -3, -3, -3, -3, -3, -3, -3, -2, -2, -3, -3, -3, -3, -3,
-3, -3, -3, -2, -3, -3, -3, -3, -2, -2, -2, -3, -2, -3, -3, -2, -2, -3, -1, -7,
-5, -2, -3, -2, -3, -3, -3, -3, -3, -3, -3, -2, -2, -3, -3, -3, -3, -3, -2, -3,
-2, -3, -3, -2, -3, -2, -2, -4, -3, -3, -2, -3, -3, -3, -3, -2, -3, -4, -3, -2,
-3, -3, -2, -3, -2, -2, -2, -3, -3, -3, -2, -2, -3, -2, -3, -3, -2, -2, -2, -3,
-3, -3, -3, -3, -2, -2, -3, -3, -2, -3, -2, -4, -3, -3, -4, -3, -3, -2, -2, -2,
-3, -3, -2, -3, -3, -3, -3, -2, -3, -3, -3, -3, -3, -2, -3, -3, -3, -3, -2, -3,
-3, -3, -2, -4, -2, -4, -1, -5, -1, -4, -1, -4, -1, -5, -1, -6, 0, -6, -112,
-121, -116, -120, -116, -121, -117, -120, -117, -120, -117, -120, -118, -120,
-118, -120, -119, -119, -118, -119, -118, -118, -119, -118, -120, -118, -120,
-117, -121, -83, -42, -44, -43, -43, -43, -44, -44, -43, -44, -43, -45, -43,
-45, -43, -44, -43, -44, -43, -43, -44, -43, -45, -42, -45, -41, -50, -9, -36,
-47, };