#define DATA_LENGTH 512
#define DATA AKWF_0929

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 6, 12, 18, 25, 30, 37, 42, 48, 53,
60, 64, 70, 74, 78, 83, 88, 91, 96, 98, 102, 105, 108, 110, 112, 114, 115, 117,
117, 118, 119, 119, 119, 119, 119, 117, 116, 115, 113, 112, 110, 108, 106, 103,
102, 99, 96, 93, 90, 88, 85, 81, 80, 77, 73, 70, 68, 65, 62, 60, 57, 53, 52, 50,
47, 45, 43, 41, 39, 38, 36, 35, 33, 32, 31, 31, 30, 28, 29, 29, 28, 27, 27, 27,
27, 28, 27, 28, 27, 28, 29, 29, 29, 29, 29, 30, 30, 30, 30, 30, 31, 30, 31, 31,
31, 31, 30, 29, 29, 30, 29, 29, 28, 27, 26, 26, 24, 24, 23, 22, 21, 20, 19, 18,
18, 17, 16, 15, 14, 13, 12, 12, 12, 11, 12, 11, 10, 10, 11, 11, 12, 12, 12, 13,
15, 16, 16, 18, 20, 22, 23, 25, 27, 30, 32, 34, 37, 40, 42, 45, 48, 51, 54, 57,
59, 63, 65, 69, 72, 75, 77, 80, 84, 86, 89, 92, 94, 95, 98, 99, 101, 103, 105,
106, 107, 107, 109, 108, 109, 110, 108, 108, 106, 106, 105, 104, 103, 101, 99,
97, 95, 91, 89, 87, 84, 81, 77, 74, 71, 67, 64, 61, 57, 54, 50, 47, 43, 39, 35,
32, 28, 26, 22, 19, 15, 13, 10, 8, 5, 3, 0, -1, -3, -4, -6, -7, -8, -8, -9, -10,
-11, -11, -11, -11, -10, -10, -10, -9, -9, -7, -7, -6, -4, -3, -2, -2, 0, 1, 3,
4, 4, 6, 6, 8, 9, 9, 10, 11, 10, 11, 11, 11, 10, 9, 10, 8, 8, 7, 6, 4, 2, 1, -1,
-3, -6, -8, -11, -14, -17, -20, -23, -27, -29, -33, -37, -40, -43, -47, -51,
-54, -58, -61, -65, -68, -72, -75, -78, -82, -85, -88, -89, -93, -95, -98, -99,
-100, -104, -105, -106, -107, -108, -108, -109, -109, -108, -109, -108, -108,
-106, -105, -104, -102, -101, -100, -98, -95, -94, -90, -88, -86, -83, -79, -77,
-74, -71, -69, -65, -63, -59, -56, -53, -51, -47, -45, -41, -40, -36, -33, -31,
-29, -26, -25, -23, -21, -19, -18, -17, -15, -15, -14, -13, -12, -11, -11, -10,
-10, -10, -11, -11, -12, -11, -12, -13, -13, -15, -15, -16, -17, -18, -19, -20,
-20, -20, -23, -22, -23, -25, -26, -26, -27, -27, -28, -29, -29, -30, -30, -30,
-30, -30, -31, -31, -31, -31, -31, -31, -31, -30, -29, -29, -29, -29, -28, -29,
-28, -27, -28, -28, -27, -28, -28, -27, -28, -28, -28, -29, -29, -30, -31, -31,
-33, -35, -35, -37, -38, -39, -42, -44, -45, -48, -50, -52, -54, -57, -60, -62,
-66, -68, -71, -75, -77, -80, -83, -85, -88, -91, -94, -96, -99, -102, -104,
-107, -108, -110, -112, -114, -115, -116, -117, -118, -119, -119, -119, -119,
-118, -117, -116, -115, -114, -112, -109, -107, -104, -101, -98, -94, -91, -86,
-82, -78, -73, -68, -63, -58, -53, -47, -41, -36, -30, -24, -17, -10, -5, };