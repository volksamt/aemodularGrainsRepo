#define DATA_LENGTH 512
#define DATA AKWF_0916

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 10, 12, 15, 17, 20, 21, 24,
26, 28, 31, 33, 34, 36, 39, 40, 41, 43, 44, 46, 47, 47, 49, 50, 52, 52, 52, 55,
54, 56, 56, 57, 57, 58, 59, 59, 59, 60, 61, 62, 62, 62, 63, 64, 64, 65, 65, 65,
66, 66, 67, 68, 68, 69, 69, 70, 69, 70, 70, 71, 71, 72, 71, 71, 72, 71, 72, 72,
72, 72, 71, 72, 72, 71, 71, 72, 72, 71, 72, 71, 70, 70, 69, 70, 69, 69, 67, 67,
67, 67, 66, 65, 65, 63, 63, 64, 62, 61, 61, 61, 61, 60, 60, 59, 58, 59, 58, 58,
58, 56, 57, 57, 57, 56, 56, 55, 55, 55, 55, 55, 55, 55, 55, 54, 54, 55, 55, 54,
54, 53, 54, 54, 54, 53, 53, 53, 52, 53, 53, 52, 52, 52, 51, 51, 51, 51, 50, 50,
50, 48, 49, 48, 48, 48, 47, 47, 46, 46, 46, 45, 45, 44, 43, 44, 43, 43, 42, 42,
41, 42, 40, 40, 41, 39, 39, 39, 39, 38, 38, 38, 37, 38, 38, 36, 36, 37, 37, 37,
37, 36, 36, 36, 36, 36, 36, 36, 37, 36, 36, 37, 36, 36, 37, 37, 36, 36, 35, 37,
36, 36, 35, 35, 36, 35, 35, 35, 35, 34, 34, 35, 34, 33, 33, 33, 32, 32, 32, 32,
32, 30, 31, 30, 30, 28, 29, 28, 28, 27, 27, 26, 26, 25, 24, 25, 23, 24, 22, 23,
22, 21, 20, 21, 20, 19, 18, 18, 18, 18, 18, 17, 16, 17, 16, 16, 15, 15, 15, 15,
14, 15, 14, 14, 14, 13, 15, 14, 14, 14, 15, 14, 14, 14, 14, 15, 15, 15, 14, 14,
15, 15, 16, 16, 15, 15, 16, 16, 15, 15, 16, 16, 16, 16, 15, 16, 16, 15, 16, 16,
15, 15, 15, 14, 15, 14, 14, 13, 13, 12, 12, 11, 11, 11, 9, 9, 8, 7, 6, 6, 5, 4,
3, 1, 1, 0, -1, -3, -5, -5, -7, -8, -10, -11, -13, -13, -15, -17, -19, -20, -22,
-23, -25, -28, -29, -30, -33, -35, -37, -38, -40, -42, -44, -45, -47, -49, -51,
-53, -55, -56, -59, -61, -63, -64, -66, -68, -70, -73, -74, -76, -78, -79, -80,
-82, -84, -86, -87, -89, -91, -92, -94, -96, -97, -98, -99, -100, -102, -103,
-104, -106, -106, -107, -108, -109, -111, -111, -111, -113, -114, -114, -115,
-116, -116, -116, -117, -118, -118, -119, -119, -118, -120, -119, -118, -119,
-119, -118, -120, -119, -119, -118, -118, -118, -118, -118, -117, -116, -116,
-116, -115, -114, -114, -113, -112, -111, -110, -110, -109, -108, -107, -106,
-106, -105, -104, -103, -101, -100, -100, -99, -98, -96, -95, -95, -93, -92,
-90, -90, -88, -88, -87, -85, -84, -82, -81, -80, -78, -77, -76, -74, -73, -72,
-72, -70, -69, -68, -66, -64, -64, -62, -61, -60, -58, -55, -53, -51, -49, -46,
-43, -42, -39, -37, -34, -31, -27, -25, -23, -19, -16, -13, -10, -7, -5, -2, };