#define DATA_LENGTH 512
#define DATA AKWF_0971

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 8, 11, 13, 16, 19, 21, 24,
26, 28, 30, 33, 35, 38, 40, 43, 45, 46, 49, 51, 53, 56, 58, 59, 61, 64, 65, 67,
68, 70, 73, 73, 75, 77, 78, 79, 81, 82, 83, 85, 86, 86, 87, 88, 89, 90, 91, 91,
91, 93, 93, 92, 94, 94, 94, 94, 94, 93, 94, 94, 94, 93, 93, 93, 93, 91, 91, 91,
90, 88, 89, 88, 87, 86, 85, 84, 82, 81, 80, 79, 78, 77, 74, 74, 72, 70, 69, 68,
66, 66, 63, 62, 61, 60, 57, 56, 55, 54, 52, 50, 49, 48, 47, 45, 44, 42, 42, 40,
39, 38, 38, 36, 35, 35, 35, 33, 33, 32, 32, 31, 30, 30, 30, 30, 30, 30, 30, 31,
30, 30, 31, 31, 31, 32, 32, 34, 34, 35, 36, 37, 37, 38, 39, 41, 42, 43, 44, 46,
47, 49, 50, 52, 53, 54, 56, 57, 60, 60, 63, 65, 66, 68, 70, 72, 73, 74, 77, 79,
80, 82, 83, 84, 87, 88, 90, 92, 94, 95, 96, 97, 99, 100, 102, 103, 104, 105,
107, 108, 108, 110, 110, 111, 112, 113, 114, 114, 115, 115, 115, 117, 116, 117,
117, 117, 118, 117, 117, 117, 117, 117, 116, 115, 115, 115, 114, 113, 113, 113,
111, 110, 110, 109, 107, 106, 105, 104, 103, 101, 100, 98, 97, 95, 93, 93, 90,
88, 86, 84, 83, 81, 79, 77, 75, 73, 71, 69, 66, 63, 61, 59, 57, 55, 53, 49, 48,
45, 42, 40, 37, 35, 33, 30, 28, 24, 22, 20, 18, 15, 12, 10, 7, 4, 2, 0, -4, -6,
-8, -10, -13, -16, -19, -21, -24, -26, -29, -31, -34, -36, -38, -41, -43, -45,
-47, -50, -53, -55, -56, -59, -60, -63, -65, -67, -70, -71, -72, -74, -76, -78,
-80, -81, -82, -84, -85, -86, -87, -88, -90, -92, -92, -92, -93, -95, -95, -96,
-96, -97, -96, -97, -98, -99, -98, -99, -99, -98, -98, -98, -98, -98, -98, -98,
-97, -97, -97, -97, -96, -95, -94, -94, -93, -92, -93, -91, -92, -90, -90, -89,
-89, -88, -87, -88, -86, -85, -85, -86, -85, -84, -83, -83, -82, -82, -82, -82,
-81, -81, -81, -81, -81, -81, -81, -80, -80, -81, -81, -81, -82, -82, -83, -82,
-83, -83, -85, -85, -86, -87, -87, -88, -88, -89, -90, -91, -92, -93, -93, -95,
-96, -96, -97, -99, -99, -100, -101, -103, -105, -104, -105, -107, -107, -108,
-110, -110, -111, -112, -112, -112, -114, -114, -116, -116, -117, -117, -118,
-118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -117, -118, -116, -116, -115, -115, -114, -113, -113, -111, -111, -110,
-109, -108, -106, -104, -104, -102, -101, -100, -97, -96, -95, -93, -91, -89,
-88, -85, -84, -82, -80, -78, -76, -75, -72, -70, -68, -65, -63, -61, -59, -56,
-54, -52, -50, -46, -44, -41, -40, -37, -34, -31, -29, -27, -24, -21, -19, -17,
-14, -12, -9, -7, -4, -1, 0, };