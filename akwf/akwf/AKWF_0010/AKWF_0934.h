#define DATA_LENGTH 512
#define DATA AKWF_0934

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 6, 11, 17, 22, 27, 32, 37, 41, 45,
49, 54, 57, 60, 64, 67, 71, 74, 77, 80, 83, 85, 88, 90, 92, 94, 97, 98, 99, 102,
103, 104, 105, 107, 109, 109, 110, 111, 113, 113, 114, 114, 115, 116, 116, 117,
117, 118, 118, 119, 119, 119, 119, 119, 120, 120, 119, 119, 118, 119, 119, 117,
118, 118, 117, 117, 116, 116, 115, 115, 114, 112, 112, 112, 110, 110, 109, 109,
108, 106, 105, 104, 103, 102, 101, 100, 99, 98, 96, 95, 93, 92, 91, 90, 88, 86,
85, 84, 82, 80, 79, 77, 75, 74, 72, 70, 69, 67, 66, 64, 62, 60, 58, 57, 54, 53,
51, 50, 48, 46, 44, 43, 41, 39, 38, 37, 35, 33, 31, 30, 28, 28, 26, 25, 25, 23,
22, 21, 20, 19, 17, 17, 16, 16, 15, 15, 14, 14, 14, 13, 12, 12, 13, 12, 12, 12,
12, 12, 12, 13, 13, 13, 13, 14, 14, 14, 15, 15, 15, 15, 17, 18, 16, 17, 18, 19,
19, 19, 20, 21, 20, 21, 22, 23, 22, 23, 23, 24, 25, 24, 25, 25, 25, 24, 26, 25,
26, 26, 26, 26, 27, 25, 25, 26, 25, 26, 26, 26, 25, 25, 25, 24, 24, 24, 23, 23,
23, 22, 22, 22, 21, 21, 20, 19, 18, 18, 18, 18, 17, 16, 16, 16, 15, 13, 14, 13,
13, 12, 11, 11, 9, 9, 9, 8, 8, 6, 6, 5, 5, 5, 4, 3, 3, 1, 2, 0, -1, 0, -1, -2,
-3, -3, -4, -4, -4, -6, -7, -7, -8, -9, -9, -9, -10, -12, -12, -12, -12, -13,
-14, -15, -16, -15, -16, -16, -18, -17, -18, -19, -19, -20, -21, -21, -22, -22,
-23, -23, -23, -23, -24, -24, -24, -24, -25, -25, -25, -25, -25, -26, -26, -25,
-25, -25, -26, -26, -27, -26, -26, -25, -26, -26, -25, -25, -24, -24, -24, -23,
-23, -23, -22, -22, -21, -20, -21, -20, -20, -20, -19, -18, -18, -17, -17, -17,
-17, -16, -16, -15, -14, -14, -14, -14, -14, -14, -13, -12, -12, -12, -12, -13,
-12, -12, -13, -12, -13, -13, -13, -14, -14, -15, -15, -16, -16, -17, -18, -19,
-20, -21, -23, -23, -25, -26, -27, -28, -30, -31, -32, -34, -35, -36, -38, -39,
-41, -43, -45, -46, -48, -50, -52, -53, -54, -57, -58, -60, -62, -64, -66, -67,
-69, -71, -72, -74, -76, -78, -79, -80, -81, -84, -86, -88, -88, -90, -91, -93,
-94, -95, -97, -98, -99, -100, -101, -102, -103, -104, -105, -107, -107, -108,
-110, -111, -111, -112, -112, -113, -114, -115, -115, -115, -116, -117, -117,
-117, -118, -118, -118, -118, -119, -118, -119, -119, -119, -118, -119, -119,
-119, -118, -119, -118, -117, -117, -116, -116, -115, -114, -115, -112, -112,
-111, -110, -109, -107, -107, -106, -104, -103, -101, -99, -97, -96, -94, -91,
-88, -86, -85, -81, -80, -76, -73, -70, -67, -63, -60, -56, -52, -49, -45, -41,
-36, -31, -26, -21, -15, -11, -4, };