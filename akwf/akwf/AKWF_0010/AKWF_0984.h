#define DATA_LENGTH 512
#define DATA AKWF_0984

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 7, 9, 10, 11, 11, 12, 17, 18,
19, 21, 24, 24, 26, 26, 29, 28, 31, 30, 30, 33, 33, 35, 36, 37, 37, 39, 39, 41,
41, 41, 41, 41, 41, 42, 43, 43, 44, 45, 46, 47, 49, 50, 53, 52, 55, 56, 57, 56,
59, 60, 62, 62, 64, 65, 66, 68, 69, 72, 72, 72, 73, 74, 74, 75, 77, 78, 81, 84,
86, 87, 89, 91, 92, 94, 94, 95, 98, 99, 100, 101, 101, 102, 104, 105, 107, 108,
109, 110, 112, 112, 114, 115, 115, 115, 117, 117, 118, 118, 118, 120, 119, 119,
119, 119, 118, 118, 117, 116, 114, 114, 114, 112, 112, 111, 112, 112, 111, 110,
108, 106, 106, 103, 102, 100, 97, 96, 94, 93, 91, 89, 88, 86, 85, 87, 82, 78,
78, 76, 75, 73, 72, 69, 72, 72, 67, 66, 67, 64, 64, 63, 61, 62, 60, 58, 58, 58,
56, 55, 52, 52, 51, 50, 46, 44, 43, 41, 40, 38, 36, 36, 36, 37, 35, 35, 34, 33,
33, 32, 31, 29, 28, 26, 25, 25, 24, 24, 25, 19, 18, 16, 13, 11, 9, 6, 3, 1, -3,
-5, -7, -10, -11, -13, -13, -15, -18, -19, -18, -20, -20, -23, -23, -25, -26,
-27, -28, -28, -29, -30, -30, -31, -33, -33, -36, -37, -38, -38, -40, -42, -43,
-44, -44, -46, -47, -46, -47, -48, -49, -50, -50, -51, -52, -51, -50, -50, -50,
-49, -50, -49, -49, -49, -49, -49, -50, -49, -51, -52, -52, -52, -52, -53, -52,
-51, -51, -51, -51, -50, -49, -49, -48, -47, -47, -44, -44, -42, -40, -40, -38,
-36, -35, -35, -34, -33, -30, -29, -27, -26, -24, -23, -23, -22, -20, -20, -19,
-19, -18, -16, -17, -16, -15, -15, -13, -13, -12, -12, -11, -11, -10, -9, -7,
-6, -6, -6, -5, -3, -2, -1, 0, -3, 1, 1, 1, 0, 2, 0, -3, -3, -7, -10, -9, -13,
-15, -13, -16, -15, -15, -16, -17, -18, -19, -19, -19, -19, -18, -16, -21, -20,
-19, -20, -19, -20, -20, -21, -20, -22, -22, -25, -25, -27, -27, -28, -29, -30,
-31, -30, -31, -32, -32, -31, -33, -34, -33, -33, -32, -32, -33, -31, -30, -30,
-29, -29, -29, -30, -31, -33, -34, -33, -35, -36, -36, -38, -37, -38, -40, -41,
-40, -42, -43, -44, -44, -43, -44, -46, -46, -45, -46, -45, -47, -48, -47, -48,
-47, -48, -49, -50, -50, -50, -51, -51, -53, -53, -53, -53, -54, -55, -57, -58,
-60, -60, -61, -63, -65, -65, -66, -68, -71, -72, -74, -75, -76, -78, -79, -80,
-81, -82, -83, -85, -84, -86, -86, -88, -88, -90, -89, -91, -94, -94, -95, -96,
-97, -96, -96, -96, -98, -99, -100, -96, -95, -96, -94, -93, -89, -89, -87, -86,
-83, -81, -78, -75, -73, -70, -67, -67, -65, -64, -64, -62, -61, -60, -59, -53,
-50, -50, -47, -44, -42, -41, -39, -37, -33, -33, -27, -23, -22, -16, -14, -11,
-8, -6, -4, };