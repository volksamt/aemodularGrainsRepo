#define DATA_LENGTH 512
#define DATA AKWF_0976

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 11, 16, 19, 24, 28, 33, 38,
43, 48, 51, 57, 60, 65, 69, 73, 76, 80, 82, 85, 87, 89, 91, 93, 94, 95, 95, 95,
94, 94, 94, 93, 92, 90, 87, 86, 83, 80, 78, 76, 73, 70, 66, 63, 60, 58, 54, 51,
48, 45, 42, 40, 37, 34, 32, 30, 28, 26, 23, 22, 21, 20, 18, 18, 17, 16, 16, 15,
16, 15, 16, 16, 16, 17, 17, 18, 19, 21, 21, 22, 22, 24, 24, 24, 25, 26, 25, 26,
25, 27, 26, 25, 25, 24, 24, 23, 21, 21, 19, 18, 18, 16, 13, 13, 11, 11, 8, 7, 6,
4, 4, 2, 2, 1, -1, -1, -3, -3, -3, -4, -4, -5, -5, -5, -5, -5, -5, -4, -4, -5,
-4, -4, -3, -3, -3, -2, -1, -2, -1, -1, -1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, -1, 0,
0, -1, -1, -3, -3, -3, -3, -4, -5, -5, -6, -7, -7, -8, -8, -8, -9, -9, -10, -10,
-10, -10, -10, -10, -10, -9, -10, -9, -8, -9, -8, -9, -7, -7, -6, -6, -4, -4,
-3, -2, -1, 0, 1, 2, 4, 5, 5, 6, 8, 9, 11, 12, 12, 14, 15, 16, 17, 17, 18, 19,
18, 20, 19, 21, 20, 21, 21, 22, 22, 22, 21, 21, 22, 21, 21, 20, 19, 19, 19, 18,
19, 19, 17, 17, 16, 15, 14, 14, 13, 13, 13, 12, 12, 12, 10, 10, 10, 9, 8, 9, 9,
8, 8, 8, 7, 7, 7, 7, 6, 6, 6, 4, 5, 4, 4, 3, 4, 3, 3, 2, 2, 1, 1, 1, 1, 0, 0, 0,
0, 0, 0, -1, 0, 0, -1, -1, -1, 1, 0, 0, 1, 2, 2, 2, 2, 3, 3, 4, 4, 5, 5, 5, 6,
6, 7, 8, 8, 8, 7, 8, 9, 9, 8, 8, 9, 10, 8, 8, 7, 7, 6, 5, 3, 2, 1, 0, -2, -4,
-5, -8, -9, -12, -13, -15, -18, -20, -22, -25, -27, -31, -33, -36, -39, -41,
-44, -47, -49, -52, -54, -57, -60, -63, -65, -68, -71, -73, -76, -79, -82, -84,
-86, -89, -91, -93, -95, -97, -99, -100, -102, -103, -106, -106, -108, -108,
-109, -110, -111, -112, -113, -113, -113, -114, -115, -114, -115, -115, -115,
-116, -116, -115, -115, -116, -116, -116, -116, -117, -116, -117, -117, -117,
-118, -118, -117, -118, -119, -118, -118, -119, -118, -119, -119, -119, -119,
-118, -119, -119, -118, -117, -117, -116, -116, -115, -116, -114, -114, -112,
-113, -111, -111, -110, -108, -108, -106, -105, -104, -103, -102, -100, -99,
-96, -96, -94, -92, -90, -89, -88, -85, -84, -82, -81, -78, -76, -75, -73, -71,
-69, -67, -66, -65, -64, -62, -60, -58, -57, -57, -55, -53, -52, -51, -49, -48,
-47, -46, -44, -43, -43, -42, -40, -39, -38, -36, -36, -34, -33, -32, -30, -29,
-28, -26, -25, -23, -23, -22, -20, -18, -16, -16, -15, -14, -12, -11, -10, -9,
-8, -7, -4, -2, };