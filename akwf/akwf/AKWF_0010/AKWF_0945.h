#define DATA_LENGTH 512
#define DATA AKWF_0945

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 18, 22, 28, 33, 38, 43, 47,
52, 56, 60, 64, 68, 71, 75, 79, 81, 83, 87, 89, 92, 94, 95, 97, 99, 101, 102,
103, 103, 105, 106, 106, 107, 107, 108, 108, 109, 109, 109, 111, 110, 110, 111,
111, 111, 112, 111, 110, 111, 112, 111, 112, 112, 112, 113, 113, 113, 113, 113,
113, 115, 115, 116, 115, 116, 116, 117, 117, 117, 117, 118, 118, 119, 119, 119,
119, 119, 119, 119, 120, 119, 119, 119, 118, 117, 116, 116, 115, 114, 113, 112,
111, 109, 107, 106, 104, 102, 100, 98, 96, 94, 90, 87, 85, 82, 78, 75, 71, 68,
63, 61, 55, 52, 47, 42, 39, 33, 30, 22, 22, 10, 14, -6, 47, 114, 111, 122, 117,
118, 114, 114, 111, 112, 111, 111, 109, 108, 105, 103, 99, 94, 88, 78, 70, 60,
49, 35, 23, 9, -4, -18, -31, -44, -55, -64, -73, -80, -87, -90, -94, -96, -97,
-97, -96, -93, -90, -85, -82, -76, -71, -65, -60, -53, -47, -41, -35, -30, -24,
-19, -14, -10, -6, -3, 0, 1, 2, 3, 5, 5, 5, 5, 4, 4, 2, 2, 1, -2, -3, -4, -6,
-7, -9, -10, -11, -13, -14, -16, -17, -19, -19, -20, -21, -22, -23, -24, -25,
-25, -27, -27, -27, -28, -28, -28, -30, -31, -31, -32, -32, -32, -34, -33, -35,
-35, -36, -38, -38, -41, -41, -44, -45, -48, -50, -52, -55, -59, -61, -63, -67,
-70, -74, -76, -80, -83, -86, -89, -92, -95, -98, -101, -104, -105, -108, -109,
-110, -111, -113, -113, -114, -113, -113, -113, -111, -110, -108, -106, -104,
-102, -99, -95, -92, -89, -84, -80, -75, -69, -64, -59, -54, -48, -42, -36, -30,
-23, -18, -11, -4, -7, -14, -20, -27, -32, -38, -44, -50, -55, -61, -65, -71,
-76, -80, -84, -87, -92, -94, -98, -101, -104, -106, -107, -110, -111, -112,
-113, -112, -113, -114, -113, -112, -112, -111, -110, -109, -108, -106, -104,
-101, -99, -98, -94, -92, -89, -87, -84, -82, -78, -75, -73, -70, -68, -65, -62,
-59, -57, -55, -53, -51, -49, -47, -45, -44, -42, -41, -40, -39, -38, -36, -36,
-36, -34, -34, -34, -32, -33, -33, -32, -31, -31, -30, -30, -30, -29, -29, -27,
-28, -28, -27, -27, -26, -25, -25, -24, -24, -23, -23, -22, -22, -21, -20, -20,
-19, -18, -17, -16, -15, -14, -14, -12, -12, -11, -10, -9, -8, -7, -6, -5, -4,
-2, -2, -1, 0, 1, 1, 2, 3, 3, 4, 5, 5, 5, 5, 5, 5, 5, 5, 4, 4, 2, 1, 1, -1, -3,
-4, -6, -8, -10, -12, -14, -17, -20, -23, -26, -28, -32, -35, -39, -41, -45,
-48, -52, -54, -59, -61, -64, -67, -70, -73, -76, -78, -81, -84, -86, -88, -90,
-90, -92, -94, -94, -95, -97, -96, -96, -97, -96, -96, -95, -94, -93, -91, -89,
-86, -85, -81, -77, -76, -71, -68, -63, -59, -55, -50, -45, -40, -36, -30, -26,
-20, -15, -3, -5, -4, };