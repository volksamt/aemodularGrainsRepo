#define DATA_LENGTH 512
#define DATA AKWF_0972

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 4, 7, 8, 11, 12, 13, 15, 18, 19,
21, 23, 25, 27, 28, 30, 32, 33, 36, 37, 38, 39, 41, 43, 45, 46, 48, 49, 50, 52,
54, 56, 57, 59, 60, 60, 62, 64, 65, 67, 68, 69, 71, 71, 73, 74, 75, 76, 77, 78,
79, 81, 81, 83, 83, 84, 85, 86, 86, 88, 88, 88, 89, 89, 90, 90, 91, 92, 93, 92,
93, 94, 93, 93, 93, 93, 94, 94, 93, 94, 93, 93, 92, 92, 93, 92, 93, 91, 91, 92,
91, 91, 90, 89, 90, 89, 89, 88, 89, 88, 88, 87, 88, 88, 88, 88, 88, 88, 88, 88,
88, 88, 88, 89, 88, 88, 89, 89, 90, 90, 90, 92, 91, 92, 93, 93, 94, 94, 95, 95,
96, 96, 98, 98, 97, 99, 99, 101, 101, 101, 103, 103, 104, 104, 105, 105, 105,
106, 107, 106, 107, 108, 109, 110, 110, 110, 110, 111, 111, 111, 111, 111, 111,
112, 111, 112, 111, 112, 112, 111, 111, 111, 112, 111, 111, 111, 110, 111, 110,
109, 109, 109, 109, 107, 108, 107, 107, 105, 105, 104, 103, 102, 101, 101, 101,
99, 98, 97, 97, 96, 95, 93, 93, 92, 90, 89, 88, 87, 86, 85, 83, 81, 80, 79, 78,
76, 75, 73, 72, 71, 68, 67, 66, 65, 63, 61, 59, 59, 56, 55, 54, 52, 50, 47, 45,
44, 43, 41, 39, 37, 35, 34, 31, 30, 27, 26, 24, 22, 21, 19, 16, 14, 12, 10, 9,
7, 5, 3, 1, -2, -3, -6, -7, -8, -10, -13, -15, -16, -19, -21, -22, -25, -26,
-28, -30, -32, -34, -36, -38, -40, -42, -43, -45, -47, -48, -50, -53, -54, -55,
-57, -58, -61, -62, -64, -65, -68, -69, -71, -72, -74, -75, -77, -77, -79, -80,
-82, -83, -84, -86, -86, -88, -89, -90, -92, -92, -93, -94, -95, -95, -97, -97,
-97, -98, -99, -100, -100, -99, -100, -100, -100, -100, -100, -101, -101, -100,
-100, -101, -100, -100, -99, -99, -99, -98, -98, -98, -97, -96, -97, -96, -96,
-96, -94, -93, -94, -94, -93, -93, -93, -92, -92, -92, -92, -92, -93, -92, -92,
-92, -93, -93, -92, -93, -94, -94, -95, -95, -95, -95, -96, -97, -98, -98, -99,
-100, -100, -100, -101, -101, -104, -104, -104, -105, -105, -106, -107, -107,
-108, -109, -109, -111, -111, -111, -113, -113, -113, -114, -115, -116, -116,
-116, -117, -117, -118, -119, -118, -118, -118, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -118, -118, -118, -117, -117, -117, -116, -116, -115,
-115, -115, -114, -113, -112, -111, -111, -110, -109, -109, -107, -107, -105,
-104, -104, -103, -101, -100, -98, -97, -96, -95, -94, -92, -91, -90, -88, -86,
-85, -83, -83, -81, -80, -78, -75, -74, -72, -71, -69, -67, -66, -64, -62, -61,
-59, -57, -55, -54, -52, -50, -48, -46, -45, -43, -41, -39, -37, -35, -33, -31,
-29, -27, -25, -23, -22, -19, -17, -15, -15, -13, -11, -9, -7, -4, -2, 0, 1, };