#define DATA_LENGTH 512
#define DATA AKWF_0910

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 12, 17, 22, 27, 31, 36, 40, 44,
48, 52, 56, 61, 64, 68, 71, 75, 77, 79, 83, 85, 87, 89, 90, 92, 94, 94, 95, 97,
97, 97, 98, 98, 98, 97, 97, 97, 96, 95, 95, 93, 93, 91, 90, 88, 86, 85, 83, 81,
79, 77, 75, 73, 71, 69, 67, 65, 63, 61, 59, 57, 54, 53, 51, 49, 48, 46, 45, 43,
41, 39, 39, 36, 35, 34, 32, 31, 30, 29, 28, 27, 25, 25, 24, 23, 21, 21, 19, 19,
18, 17, 16, 16, 15, 14, 14, 14, 13, 12, 11, 10, 11, 9, 10, 9, 9, 8, 8, 7, 6, 6,
5, 5, 5, 5, 4, 3, 4, 4, 3, 3, 3, 2, 3, 1, 1, 1, 2, 1, 1, 0, -1, 0, 0, -1, -1,
-1, 0, -2, -1, -1, -1, -1, -2, -2, -3, -3, -4, -5, -6, -6, -7, -8, -9, -11, -11,
-13, -14, -16, -18, -19, -21, -23, -26, -28, -29, -33, -35, -38, -40, -42, -45,
-49, -51, -54, -57, -59, -63, -66, -70, -73, -77, -81, -85, -87, -91, -95, -99,
-102, -106, -110, -112, -115, -119, -119, -116, -112, -112, -112, -112, -111,
-110, -109, -106, -104, -102, -99, -96, -95, -95, -94, -91, -88, -85, -83, -80,
-77, -75, -72, -70, -66, -64, -60, -57, -54, -49, -47, -44, -39, -35, -31, -26,
-22, -18, -13, -8, -4, 0, 5, 10, 14, 18, 22, 26, 30, 33, 37, 41, 44, 46, 50, 52,
56, 58, 60, 63, 63, 66, 68, 69, 70, 71, 71, 72, 72, 74, 72, 74, 73, 72, 72, 72,
71, 70, 70, 69, 68, 68, 66, 64, 62, 61, 60, 58, 57, 55, 53, 52, 50, 48, 47, 46,
44, 42, 40, 39, 37, 36, 34, 33, 31, 30, 29, 27, 27, 26, 24, 24, 22, 21, 20, 19,
19, 18, 16, 16, 15, 15, 14, 13, 12, 11, 11, 10, 9, 9, 8, 8, 7, 6, 6, 6, 5, 4, 5,
4, 4, 3, 3, 2, 2, 2, 1, 2, 1, 0, 0, 0, 0, -1, -1, -1, -2, -2, -1, -2, -3, -2,
-3, -3, -3, -3, -3, -4, -4, -4, -4, -4, -4, -5, -4, -5, -5, -5, -5, -5, -5, -6,
-6, -6, -6, -6, -7, -6, -7, -7, -6, -6, -7, -7, -6, -7, -7, -7, -7, -6, -7, -7,
-8, -7, -7, -7, -8, -7, -8, -9, -8, -8, -8, -8, -8, -7, -8, -8, -9, -7, -8, -8,
-9, -9, -8, -9, -9, -9, -9, -9, -9, -10, -10, -10, -11, -12, -12, -12, -13, -14,
-14, -15, -16, -17, -19, -19, -21, -22, -23, -25, -27, -27, -29, -31, -33, -34,
-37, -39, -40, -42, -45, -46, -48, -50, -53, -55, -57, -60, -61, -63, -66, -68,
-70, -73, -75, -77, -79, -80, -78, -75, -74, -74, -74, -74, -72, -71, -70, -70,
-73, -71, -69, -67, -65, -63, -62, -60, -57, -55, -53, -51, -48, -46, -43, -40,
-38, -34, -31, -27, -25, -21, -16, -13, -9, -4, -1, };