#define DATA_LENGTH 512
#define DATA AKWF_0979

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 7, 8, 10, 12, 13, 15, 16, 17,
18, 19, 20, 20, 22, 22, 23, 24, 24, 25, 26, 26, 26, 26, 27, 27, 27, 28, 28, 28,
29, 29, 29, 29, 30, 30, 31, 31, 32, 33, 34, 34, 34, 36, 35, 37, 36, 37, 38, 39,
40, 40, 41, 43, 43, 44, 45, 46, 46, 47, 48, 48, 50, 51, 51, 52, 53, 54, 55, 56,
58, 58, 60, 61, 62, 64, 65, 65, 67, 68, 69, 71, 72, 73, 74, 76, 77, 78, 79, 80,
81, 83, 84, 85, 86, 87, 88, 90, 90, 91, 92, 93, 95, 96, 96, 97, 99, 99, 100,
102, 101, 104, 104, 105, 106, 106, 108, 108, 110, 111, 110, 111, 112, 113, 115,
115, 116, 116, 116, 116, 117, 118, 118, 118, 118, 118, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 118, 117, 118, 117, 117, 116, 116, 115, 115,
114, 114, 114, 112, 112, 111, 110, 109, 108, 107, 106, 105, 104, 103, 101, 100,
99, 98, 97, 95, 92, 91, 89, 87, 85, 83, 81, 79, 78, 76, 73, 70, 68, 66, 64, 61,
58, 56, 53, 51, 48, 46, 44, 41, 38, 35, 33, 30, 27, 25, 22, 19, 17, 14, 12, 9,
6, 3, 1, -1, -3, -6, -8, -11, -13, -15, -16, -19, -21, -23, -26, -27, -29, -30,
-32, -33, -35, -37, -39, -40, -41, -43, -44, -46, -48, -49, -50, -51, -52, -54,
-55, -56, -57, -59, -59, -61, -62, -63, -64, -65, -66, -67, -69, -70, -71, -71,
-73, -74, -75, -76, -77, -77, -79, -79, -80, -81, -82, -82, -83, -84, -84, -85,
-85, -87, -87, -88, -88, -88, -89, -90, -90, -91, -91, -91, -91, -93, -93, -93,
-93, -94, -94, -95, -96, -96, -96, -97, -96, -97, -98, -97, -97, -98, -97, -98,
-97, -98, -98, -99, -99, -98, -98, -98, -99, -98, -99, -98, -98, -98, -98, -98,
-98, -96, -96, -96, -96, -95, -95, -94, -93, -92, -91, -90, -89, -89, -89, -88,
-87, -86, -86, -85, -84, -82, -82, -82, -80, -79, -78, -77, -76, -75, -74, -73,
-72, -71, -70, -70, -70, -68, -67, -66, -64, -65, -64, -62, -61, -60, -59, -58,
-57, -57, -56, -54, -53, -53, -51, -51, -50, -49, -47, -47, -47, -45, -44, -44,
-44, -43, -42, -42, -41, -41, -40, -39, -39, -39, -39, -38, -37, -37, -36, -36,
-35, -35, -35, -34, -33, -33, -32, -32, -31, -31, -30, -29, -29, -29, -27, -27,
-28, -27, -26, -26, -26, -26, -25, -24, -25, -24, -24, -23, -23, -22, -22, -22,
-21, -20, -21, -20, -20, -20, -19, -19, -19, -18, -18, -17, -17, -17, -16, -16,
-16, -15, -15, -15, -15, -14, -14, -14, -14, -14, -14, -13, -14, -13, -13, -13,
-12, -13, -12, -13, -13, -12, -12, -12, -12, -12, -12, -12, -12, -11, -11, -11,
-10, -11, -11, -10, -11, -11, -10, -11, -10, -10, -10, -10, -10, -10, -9, -10,
-10, -10, -10, -9, -7, -6, -3, -1, };