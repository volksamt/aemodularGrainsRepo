#define DATA_LENGTH 512
#define DATA AKWF_0951

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 23, 30, 38, 46, 54, 62, 74, 78,
65, 78, 83, 82, 81, 87, 77, 50, 59, 50, 32, 20, 9, 1, -10, -22, -37, -47, -66,
-58, -50, -70, -71, -69, -72, -78, -78, -80, -90, -89, -88, -87, -88, -86, -85,
-82, -80, -78, -73, -69, -68, -66, -64, -62, -61, -59, -59, -57, -55, -53, -52,
-51, -48, -51, -55, -53, -54, -57, -60, -55, -51, -54, -52, -50, -48, -49, -43,
-38, -40, -35, -31, -28, -24, -22, -19, -14, -11, -7, -8, -8, -3, -3, -2, -1, 2,
4, 5, 4, 5, 7, 8, 7, 8, 7, 9, 8, 9, 8, 8, 9, 10, 10, 9, 16, 18, 18, 22, 26, 28,
30, 29, 27, 30, 30, 30, 30, 30, 33, 34, 36, 34, 38, 29, 12, 15, 9, -2, -9, -16,
-19, -27, -30, -43, -30, 11, 1, 1, 28, 26, -10, -14, 25, 35, 21, 35, 68, 55, 29,
48, 40, 23, 17, 13, 15, 12, 13, 6, 10, 18, 8, 6, 8, 6, 3, -1, -4, -8, -8, -10,
-7, -1, -3, 1, 5, 8, 11, 14, 11, 10, 15, 15, 15, 15, 18, 19, 21, 21, 23, 23, 23,
24, 21, 21, 23, 24, 22, 22, 23, 23, 24, 23, 24, 31, 33, 32, 38, 42, 44, 46, 48,
50, 54, 57, 58, 54, 56, 60, 58, 58, 60, 60, 54, 55, 54, 51, 48, 47, 52, 49, 48,
49, 48, 47, 46, 44, 43, 42, 41, 41, 42, 44, 43, 42, 42, 43, 43, 41, 42, 43, 42,
42, 42, 47, 49, 43, 45, 47, 46, 44, 46, 37, 5, 5, 2, -19, -31, -43, -51, -61,
-70, -84, -94, -111, -109, -94, -113, -116, -112, -113, -119, -108, -95, -102,
-93, -82, -71, -63, -55, -47, -35, -25, -11, -16, -19, -3, -2, 0, 2, 8, 14, 19,
22, 25, 26, 28, 27, 29, 25, 13, 13, 11, 4, -1, -4, -8, -12, -15, -19, -23, -28,
-34, -31, -28, -35, -34, -34, -34, -35, -38, -39, -39, -38, -35, -34, -33, -30,
-32, -30, -28, -28, -28, -32, -32, -30, -31, -33, -34, -34, -35, -34, -36, -38,
-38, -35, -35, -36, -35, -34, -35, -35, -35, -36, -30, -26, -26, -22, -20, -17,
-14, -16, -16, -13, -13, -13, -12, -9, -8, -6, -5, -3, -3, -2, -2, -5, -3, -2,
-1, -3, -1, -1, 1, 1, 1, 1, 1, 2, 2, 2, 3, 2, 4, 4, 4, 5, 6, 5, 3, 4, 5, 6, 5,
5, 6, 7, 7, 7, 8, 8, 9, 9, 9, 10, 15, 17, 17, 21, 24, 26, 27, 24, 25, 26, 25,
26, 27, 28, 29, 30, 26, 24, 26, 23, 20, 19, 18, 16, 15, 13, 12, 9, 12, 12, 9, 9,
9, 11, 13, 11, 12, 12, 11, 12, 13, 13, 13, 13, 13, 14, 16, 13, 2, 3, 1, -4, -9,
-13, -15, -18, -22, -25, -30, -33, -39, -36, -32, -39, -38, -37, -37, -38, -39,
-42, -41, -42, -41, -40, -39, -39, -32, -8, -1, 0, -1, };