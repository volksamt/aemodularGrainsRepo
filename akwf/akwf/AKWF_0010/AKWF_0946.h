#define DATA_LENGTH 512
#define DATA AKWF_0946

const PROGMEM int8_t DATA[DATA_LENGTH] = {15, 39, 56, 77, 89, 105, 110, 119,
117, 118, 100, 91, 57, 40, -18, -80, -2, 19, 18, -86, -87, 48, 91, 94, 67, 32,
6, -8, -21, -20, -16, -16, 47, 119, 101, 47, -27, -76, -95, -94, -89, -76, -55,
-31, -14, -4, 8, 15, 22, 21, 19, 16, 17, 0, -65, -114, -117, -93, -50, -2, 46,
78, 92, 96, 94, 90, 84, 70, 54, 36, 22, 11, 4, -5, -12, -17, -22, -22, -20, -18,
-17, -14, -14, 14, 72, 108, 119, 111, 87, 56, 17, -22, -56, -79, -92, -95, -95,
-94, -91, -85, -76, -65, -51, -36, -25, -14, -7, -1, 5, 10, 16, 19, 21, 22, 21,
18, 17, 16, 15, 14, -3, -48, -90, -113, -119, -111, -96, -72, -42, -9, 24, 52,
73, 87, 93, 96, 95, 93, 91, 87, 83, 75, 64, 51, 39, 28, 20, 12, 7, 1, -3, -8,
-13, -17, -20, -22, -21, -21, -19, -17, -16, -16, -16, -14, -10, -14, -15, -16,
-18, -18, -20, -21, -22, -22, -20, -18, -15, -10, -5, -1, 4, 10, 15, 22, 31, 39,
50, 61, 71, 79, 85, 89, 92, 93, 95, 96, 96, 91, 84, 71, 54, 31, 6, -21, -48,
-72, -91, -107, -115, -118, -114, -97, -71, -35, -1, 13, 14, 16, 15, 17, 18, 20,
20, 22, 22, 21, 19, 18, 14, 10, 5, 1, -3, -8, -13, -18, -25, -33, -42, -52, -62,
-69, -78, -84, -87, -90, -92, -94, -96, -96, -94, -91, -85, -74, -59, -41, -15,
-2, 19, 45, 67, 85, 100, 112, 117, 118, 110, 94, 67, 34, 2, -13, -14, -14, -16,
-16, -17, -18, -20, -21, -21, -21, -22, -20, -18, -14, -10, -8, -4, 0, 5, 8, 13,
19, 25, 33, 41, 49, 59, 67, 74, 81, 86, 89, 91, 93, 95, 96, 96, 96, 92, 86, 77,
65, 50, 29, 8, -14, -38, -60, -78, -94, -106, -115, -119, -117, -107, -91, -65,
-32, -3, 12, 14, 15, 16, 17, 18, 19, 19, 20, 21, 22, 22, 21, 19, 18, 14, 12, 7,
4, 0, -3, -7, -12, -16, -21, -27, -36, -43, -52, -60, -69, -75, -81, -85, -89,
-91, -93, -94, -95, -96, -95, -93, -89, -83, -73, -59, -42, -23, -2, 20, 42, 62,
80, 94, 107, 115, 118, 118, 110, 95, 73, 44, 12, -8, -14, -15, -16, -17, -17,
-17, -19, -19, -20, -21, -21, -21, -21, -20, -17, -15, -12, -9, -4, 0, 3, 6, 10,
15, 19, 25, 31, 39, 47, 56, 63, 70, 77, 82, 87, 89, 91, 93, 94, 95, 96, 95, 93,
90, 83, 75, 61, 45, 27, 7, -14, -35, -56, -73, -90, -103, -112, -118, -119,
-115, -105, -88, -63, -31, -5, 12, 14, 15, 16, 16, 16, 17, 19, 19, 21, 22, 21,
22, 21, 19, 18, 15, 12, 9, 5, 2, -1, -5, -8, -14, -18, -23, -29, -37, -44, -52,
-61, -69, -75, -80, -85, -88, -91, -92, -94, -94, -96, -95, -95, -92, -87, -79,
-70, -55, -39, -20, 0, };