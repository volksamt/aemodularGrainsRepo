#define DATA_LENGTH 512
#define DATA AKWF_0988

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 9, 11, 14, 17, 20, 24, 26, 29,
32, 35, 38, 40, 43, 45, 47, 50, 53, 54, 57, 58, 61, 62, 64, 66, 68, 69, 71, 73,
73, 76, 77, 78, 78, 80, 81, 82, 82, 84, 84, 85, 85, 85, 86, 86, 86, 87, 87, 87,
87, 87, 86, 87, 86, 86, 85, 85, 86, 84, 84, 83, 83, 82, 82, 80, 81, 79, 79, 77,
76, 76, 74, 72, 72, 71, 70, 68, 68, 66, 65, 64, 63, 61, 61, 58, 57, 56, 55, 53,
52, 51, 49, 49, 46, 45, 44, 43, 41, 40, 38, 38, 35, 35, 33, 32, 30, 29, 28, 27,
26, 24, 24, 22, 20, 20, 18, 18, 17, 15, 14, 13, 12, 11, 10, 9, 8, 7, 6, 6, 4, 4,
2, 2, 1, 0, 0, -1, -2, -3, -3, -4, -4, -5, -6, -6, -7, -7, -7, -8, -9, -8, -9,
-9, -9, -10, -11, -10, -11, -11, -12, -11, -11, -13, -12, -12, -12, -14, -12,
-13, -12, -13, -13, -13, -13, -12, -13, -12, -13, -12, -12, -12, -12, -12, -11,
-12, -12, -11, -12, -11, -11, -11, -10, -11, -10, -10, -10, -10, -9, -10, -9,
-9, -9, -8, -7, -8, -7, -7, -7, -7, -7, -6, -6, -5, -6, -6, -5, -5, -3, -4, -4,
-4, -3, -4, -3, -2, -2, -2, -1, -2, -2, -1, -1, 0, 0, 0, 0, -1, 0, 0, 1, 1, 0,
1, 2, 1, 3, 2, 2, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 4, 3, 4, 4, 4, 4, 4, 4, 4,
5, 4, 3, 4, 3, 4, 5, 4, 5, 4, 3, 4, 4, 5, 4, 4, 4, 4, 4, 5, 4, 4, 3, 4, 4, 5, 4,
4, 4, 4, 4, 3, 4, 4, 4, 4, 4, 3, 3, 3, 3, 3, 4, 3, 2, 3, 3, 3, 3, 3, 2, 2, 2, 2,
2, 2, 2, 2, 2, 1, 1, 2, 1, 1, 1, 2, 1, 2, 1, 1, 0, 0, 0, 1, 1, 1, 1, 1, 0, 0, 1,
0, 0, 0, 1, -1, 0, 0, 0, 0, -1, 1, 0, 0, -1, 0, 0, 0, 0, -1, -1, -1, -1, 0, 0,
-1, -1, -1, 0, 0, -2, -1, -1, -2, 0, -1, -1, 0, -1, -1, -1, -1, 0, -1, -1, 0,
-1, -2, -1, -1, -1, -2, -1, -1, -1, -1, -1, -1, -1, -1, 0, -1, -1, 0, -1, -1,
-1, -1, -2, -2, -3, -4, -5, -7, -10, -13, -15, -18, -20, -24, -28, -31, -35,
-40, -43, -47, -51, -56, -60, -63, -67, -71, -76, -79, -82, -86, -89, -92, -96,
-99, -101, -104, -106, -108, -110, -111, -113, -114, -116, -117, -117, -118,
-118, -118, -119, -120, -118, -118, -117, -117, -115, -114, -114, -112, -111,
-109, -107, -105, -103, -101, -98, -96, -94, -90, -88, -86, -83, -80, -77, -74,
-71, -67, -64, -61, -58, -55, -51, -48, -45, -41, -38, -34, -30, -27, -24, -21,
-18, -14, -10, -7, -4, 0, };