#define DATA_LENGTH 512
#define DATA AKWF_0962

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 7, 7, 9, 10, 11, 13, 14,
15, 16, 17, 20, 21, 22, 22, 24, 26, 26, 27, 29, 30, 30, 33, 33, 34, 35, 36, 37,
39, 39, 41, 42, 43, 43, 45, 45, 47, 47, 48, 50, 51, 52, 53, 53, 55, 57, 58, 58,
59, 61, 61, 63, 64, 64, 66, 67, 68, 70, 70, 72, 73, 75, 75, 78, 78, 80, 80, 81,
82, 82, 84, 85, 85, 87, 87, 88, 89, 90, 90, 92, 92, 93, 93, 94, 95, 95, 96, 97,
97, 98, 99, 99, 100, 100, 101, 100, 102, 102, 102, 103, 103, 104, 105, 104, 105,
106, 106, 106, 106, 107, 107, 108, 108, 109, 109, 109, 109, 109, 110, 110, 111,
111, 111, 111, 111, 113, 112, 113, 113, 113, 114, 113, 114, 112, 113, 113, 112,
112, 113, 112, 111, 111, 111, 111, 111, 110, 109, 109, 109, 108, 108, 106, 107,
105, 106, 104, 105, 104, 103, 102, 101, 101, 100, 100, 99, 98, 97, 97, 96, 95,
95, 94, 93, 92, 91, 91, 90, 90, 88, 87, 87, 86, 86, 85, 84, 83, 83, 82, 81, 80,
79, 78, 77, 76, 76, 75, 73, 72, 72, 69, 69, 68, 67, 66, 64, 63, 62, 60, 59, 57,
56, 55, 53, 52, 51, 49, 47, 46, 45, 43, 41, 40, 39, 37, 36, 34, 32, 31, 30, 28,
26, 25, 23, 22, 21, 19, 17, 16, 15, 12, 11, 10, 9, 6, 5, 4, 2, 0, -1, -2, -4,
-5, -7, -8, -9, -11, -12, -13, -15, -16, -18, -18, -20, -21, -22, -24, -25, -26,
-27, -29, -30, -30, -33, -34, -35, -36, -36, -38, -38, -40, -41, -41, -43, -44,
-46, -46, -47, -48, -49, -49, -52, -52, -53, -54, -56, -56, -57, -58, -60, -61,
-61, -63, -64, -65, -66, -67, -68, -69, -70, -72, -72, -74, -74, -76, -76, -78,
-79, -81, -82, -83, -84, -85, -86, -88, -89, -90, -91, -91, -92, -92, -94, -95,
-95, -95, -96, -98, -98, -98, -99, -101, -101, -101, -102, -103, -103, -104,
-104, -105, -106, -106, -106, -107, -107, -108, -109, -109, -110, -110, -110,
-110, -111, -110, -111, -112, -113, -113, -113, -114, -114, -114, -115, -114,
-115, -115, -116, -116, -116, -116, -117, -118, -118, -119, -118, -118, -119,
-119, -119, -119, -119, -119, -119, -118, -118, -119, -117, -118, -117, -117,
-117, -116, -116, -115, -115, -116, -115, -113, -113, -113, -112, -111, -111,
-110, -110, -109, -109, -109, -107, -106, -106, -105, -105, -103, -103, -103,
-101, -101, -100, -99, -100, -98, -97, -97, -96, -95, -95, -93, -93, -91, -91,
-91, -90, -88, -88, -86, -87, -85, -85, -85, -84, -82, -81, -80, -80, -78, -77,
-76, -74, -74, -73, -71, -70, -69, -67, -66, -64, -62, -61, -60, -58, -57, -56,
-55, -53, -51, -51, -48, -47, -45, -44, -42, -41, -39, -38, -37, -36, -34, -32,
-30, -29, -27, -25, -25, -23, -22, -20, -18, -17, -15, -14, -12, -10, -9, -8,
-7, -5, -4, -1, 0, 0, };