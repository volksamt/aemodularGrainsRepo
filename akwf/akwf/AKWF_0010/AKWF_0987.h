#define DATA_LENGTH 512
#define DATA AKWF_0987

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 20, 34, 45, 55, 64, 71, 78, 83, 87,
92, 95, 98, 101, 104, 106, 108, 110, 111, 111, 113, 113, 115, 115, 115, 115,
117, 117, 118, 117, 118, 119, 117, 118, 118, 118, 119, 119, 118, 118, 119, 119,
119, 119, 118, 119, 119, 118, 119, 118, 120, 118, 119, 119, 118, 118, 118, 118,
119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 120, 118,
119, 120, 119, 119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 120, 120,
119, 119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119, 118, 120, 120,
119, 120, 119, 120, 119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 120, 119,
120, 119, 119, 119, 120, 120, 119, 119, 119, 120, 120, 119, 119, 120, 119, 119,
119, 119, 119, 120, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119,
120, 119, 120, 119, 119, 119, 119, 120, 119, 118, 119, 118, 119, 119, 120, 119,
118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120, 119, 119, 119, 119,
119, 119, 119, 118, 119, 119, 119, 120, 118, 118, 119, 120, 120, 119, 119, 120,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119,
119, 109, 83, 56, 33, 11, -6, -21, -35, -46, -56, -64, -72, -78, -83, -89, -92,
-96, -99, -103, -105, -105, -108, -110, -111, -112, -113, -114, -115, -115,
-116, -116, -116, -117, -117, -118, -117, -118, -118, -118, -118, -119, -119,
-118, -119, -118, -118, -119, -119, -118, -120, -119, -120, -119, -119, -120,
-120, -119, -118, -119, -119, -119, -119, -119, -120, -119, -118, -119, -119,
-119, -119, -118, -119, -120, -118, -120, -118, -119, -119, -119, -120, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -120, -119, -119, -120, -119, -119, -120, -119, -119, -119, -119,
-118, -119, -120, -119, -119, -119, -119, -119, -119, -120, -118, -119, -119,
-120, -119, -118, -119, -119, -120, -120, -119, -118, -119, -119, -120, -119,
-118, -120, -119, -119, -120, -119, -119, -118, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -120, -119, -120, -119, -119, -119, -119, -119, -120,
-119, -118, -120, -119, -119, -119, -120, -119, -119, -119, -120, -119, -119,
-120, -119, -119, -118, -119, -120, -120, -119, -119, -119, -120, -119, -119,
-120, -119, -120, -119, -119, -119, -119, -119, -119, -120, -120, -119, -119,
-119, -118, -120, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -118, -118, -119, -119, -119, -119, -120, -119, -120, -119, -120, -118,
-119, -119, -120, -119, -119, -119, -120, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -107, -80, -53, -29, -9, };