#define DATA_LENGTH 512
#define DATA AKWF_0994

const PROGMEM int8_t DATA[DATA_LENGTH] = {30, 35, 32, 34, 33, 34, 33, 34, 33,
34, 33, 34, 33, 33, 33, 34, 33, 34, 34, 34, 33, 34, 33, 33, 33, 33, 34, 33, 33,
34, 33, 33, 33, 34, 34, 33, 33, 33, 34, 32, 33, 33, 34, 34, 34, 33, 33, 34, 34,
34, 34, 33, 33, 34, 34, 33, 33, 34, 34, 33, 33, 34, 34, 33, 33, 34, 33, 33, 34,
34, 33, 34, 33, 34, 34, 33, 34, 34, 33, 33, 34, 33, 34, 33, 34, 33, 34, 33, 34,
34, 34, 33, 33, 34, 34, 33, 34, 35, 34, 33, 34, 34, 33, 34, 33, 34, 33, 34, 34,
34, 33, 29, 29, 28, 30, 29, 29, 30, 29, 29, 29, 29, 29, 30, 29, 30, 30, 30, 30,
31, 30, 30, 30, 30, 30, 31, 30, 30, 30, 31, 30, 31, 31, 31, 31, 32, 32, 32, 32,
31, 31, 32, 32, 31, 32, 32, 32, 32, 32, 31, 32, 33, 32, 32, 32, 33, 33, 33, 33,
33, 33, 33, 34, 33, 33, 33, 34, 34, 34, 34, 33, 34, 33, 34, 34, 33, 34, 33, 34,
33, 33, 33, 33, 33, 33, 32, 33, 32, 33, 32, 31, 30, 31, 30, 28, 28, 29, 30, 29,
30, 31, 34, 34, 35, 34, 34, 34, 34, 34, 35, 34, 34, 33, 34, 34, 34, 33, 34, 33,
34, 33, 35, 34, 34, 34, 35, 35, 34, 35, 34, 34, 34, 34, 34, 34, 34, 34, 35, 34,
33, 35, 34, 34, 35, 34, 34, 34, 35, 34, 34, 34, 35, 34, 34, 34, 34, 34, 34, 34,
34, 34, 35, 34, 34, 35, 35, 34, 34, 34, 35, 35, 34, 34, 34, 35, 34, 34, 34, 34,
35, 34, 34, 35, 34, 35, 34, 34, 34, 34, 34, 35, 34, 34, 34, 34, 34, 34, 34, 34,
34, 34, 35, 34, 35, 34, 34, 33, 35, 33, 36, 31, 40, 9, -22, -13, -18, -15, -17,
-15, -16, -16, -16, -16, -16, -16, -16, -16, -15, -15, -15, -16, -15, -15, -15,
-16, -15, -15, -14, -15, -14, -14, -14, -15, -14, -14, -13, -15, -14, -13, -14,
-14, -14, -14, -13, -14, -13, -14, -13, -13, -13, -13, -14, -13, -13, -13, -13,
-12, -13, -13, -13, -13, -13, -13, -12, -12, -13, -12, -12, -12, -13, -12, -12,
-12, -12, -11, -13, -11, -12, -11, -11, -10, -12, -10, -12, -11, -11, -50, -59,
-54, -58, -52, -58, -49, -11, -9, -12, -9, -12, -7, -14, -3, -36, -58, -51, -54,
-54, -52, -54, -50, -56, -45, -7, -10, -10, -7, -12, -4, -24, -56, -49, -54,
-49, -55, -35, -3, -11, -5, -10, -7, -9, -8, -7, -44, -52, -47, -50, -47, -51,
-47, -50, -46, -53, -24, -2, -11, -4, -12, -1, -35, -50, -47, -45, -64, -92,
-84, -90, -83, -92, -69, -41, -47, -45, -46, -48, -42, -68, -90, -82, -87, -81,
-86, -58, -39, -49, -39, -52, -19, -26, -50, -38, -56, -84, -80, -80, -110,
-126, -107, -77, -82, -52, -37, -8, };