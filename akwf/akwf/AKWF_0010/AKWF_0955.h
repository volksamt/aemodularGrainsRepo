#define DATA_LENGTH 512
#define DATA AKWF_0955

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 10, 14, 18, 23, 28, 33, 38, 45,
49, 56, 62, 68, 74, 82, 89, 97, 103, 114, 115, 91, 98, 98, 86, 80, 75, 74, 71,
67, 63, 57, 51, 43, 36, 29, 21, 13, 5, -2, -10, -17, -23, -30, -36, -42, -48,
-54, -59, -64, -71, -74, -79, -71, -82, -81, -49, -56, -53, -38, -30, -20, -15,
-3, -31, -35, 8, -5, -14, -3, 3, 8, 9, 11, 10, 11, 11, 11, 11, 11, 9, 10, 9, 9,
7, 7, 6, 6, 5, 5, 4, 5, 5, 4, 5, 5, 6, 6, 7, 6, 7, 8, 8, 9, 10, 10, 11, 11, 11,
12, 12, 12, 13, 11, 12, 12, 12, 12, 12, 11, 10, 10, 10, 10, 8, 8, 8, 6, 6, 6, 5,
4, 3, 2, 2, 1, 1, -1, -1, 0, -1, -3, -3, -3, -3, -4, -4, -5, -5, -5, -5, -5, -4,
-5, -6, -5, -4, -6, -4, -4, -4, -4, -4, -2, -2, -1, -1, -1, 0, 1, 2, 2, 3, 4, 4,
5, 6, 6, 6, 7, 8, 8, 9, 10, 10, 10, 11, 11, 11, 12, 11, 12, 12, 11, 12, 11, 11,
11, 10, 10, 9, 8, 8, 6, 5, 4, 3, 2, 1, 0, -3, -5, -7, -8, -10, -12, -13, -14,
-15, -18, -19, -20, -21, -21, -23, -23, -23, -25, -25, -26, -25, -26, -26, -25,
-26, -25, -25, -24, -23, -23, -24, -23, -22, -22, -20, -20, -19, -18, -17, -17,
-15, -15, -14, -13, -12, -11, -10, -9, -8, -8, -6, -5, -5, -4, -4, -2, -2, -1,
-1, -1, 0, 0, 0, 2, 2, 2, 2, 3, 3, 5, 4, 4, 4, 4, 5, 4, 4, 4, 4, 4, 4, 4, 4, 4,
3, 4, 3, 1, 2, 2, 1, 1, 0, -1, -1, -1, -2, -1, -3, -3, -3, -4, -5, -5, -6, -7,
-7, -8, -8, -9, -9, -10, -11, -11, -11, -12, -12, -12, -13, -14, -15, -15, -15,
-16, -16, -16, -17, -17, -17, -17, -17, -17, -17, -17, -17, -18, -18, -18, -17,
-18, -17, -17, -17, -17, -16, -16, -16, -16, -16, -15, -15, -13, -14, -13, -12,
-12, -12, -11, -11, -9, -8, -9, -7, -7, -6, -6, -5, -4, -3, -2, -2, -1, 0, 1, 2,
2, 4, 3, 4, 5, 7, 7, 8, 9, 10, 10, 10, 11, 12, 14, 13, 15, 15, 15, 15, 16, 17,
17, 18, 18, 18, 18, 19, 19, 19, 19, 19, 20, 19, 19, 19, 20, 19, 19, 19, 18, 18,
18, 17, 17, 17, 15, 15, 14, 13, 12, 12, 11, 10, 10, 9, 6, 7, 5, 5, 3, 1, 0, -1,
-2, -3, -5, -6, -7, -8, -10, -11, -12, -13, -14, -17, -17, -19, -20, -22, -23,
-24, -25, -27, -28, -29, -30, -30, -32, -33, -34, -36, -36, -37, -37, -39, -39,
-39, -39, -40, -40, -40, -40, -40, -39, -38, -39, -38, -38, -36, -36, -34, -34,
-31, -31, -29, -27, -25, -22, -20, -17, -15, -12, -9, -2, -3, -2, };