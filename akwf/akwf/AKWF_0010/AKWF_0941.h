#define DATA_LENGTH 512
#define DATA AKWF_0941

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 10, 15, 19, 24, 29, 34, 38, 43,
48, 53, 56, 60, 65, 68, 72, 76, 80, 83, 87, 89, 92, 96, 98, 101, 103, 105, 106,
108, 111, 111, 114, 115, 116, 116, 117, 118, 119, 119, 119, 118, 119, 118, 118,
117, 117, 117, 115, 115, 113, 112, 111, 110, 108, 106, 105, 103, 100, 99, 98,
95, 93, 91, 88, 86, 83, 81, 78, 76, 74, 71, 68, 66, 63, 60, 58, 55, 52, 49, 47,
44, 41, 38, 35, 33, 29, 27, 24, 22, 19, 17, 14, 11, 8, 6, 4, 2, -1, -3, -4, -7,
-9, -11, -13, -14, -17, -18, -20, -21, -24, -24, -25, -27, -28, -29, -29, -29,
-31, -31, -32, -32, -32, -33, -32, -32, -32, -32, -32, -32, -32, -32, -31, -29,
-29, -28, -28, -27, -26, -24, -23, -23, -22, -20, -20, -19, -17, -16, -14, -14,
-12, -10, -9, -8, -6, -5, -4, -2, -1, 1, 3, 4, 5, 7, 8, 10, 11, 12, 14, 15, 16,
18, 20, 21, 22, 23, 25, 26, 27, 28, 29, 30, 31, 33, 33, 34, 35, 35, 36, 37, 37,
38, 37, 39, 39, 40, 40, 40, 39, 39, 38, 39, 38, 37, 37, 38, 37, 36, 36, 36, 34,
33, 32, 31, 30, 30, 29, 28, 26, 25, 24, 24, 22, 22, 20, 19, 19, 17, 15, 15, 14,
13, 13, 11, 11, 10, 9, 9, 8, 7, 6, 5, 6, 4, 3, 4, 3, 3, 3, 2, 2, 1, 1, 1, 0, 0,
0, -1, -1, -1, -1, -2, -2, -2, -3, -3, -3, -4, -4, -4, -5, -6, -7, -7, -8, -8,
-9, -9, -11, -12, -13, -13, -14, -16, -16, -17, -19, -19, -20, -22, -23, -24,
-25, -26, -27, -27, -29, -30, -31, -32, -32, -34, -34, -35, -36, -35, -37, -37,
-38, -38, -38, -38, -39, -39, -39, -39, -39, -40, -39, -38, -38, -37, -37, -36,
-36, -35, -35, -34, -33, -32, -32, -30, -29, -28, -27, -25, -24, -22, -22, -20,
-19, -18, -17, -15, -13, -12, -10, -9, -9, -7, -5, -4, -2, -1, 1, 2, 4, 5, 7, 7,
8, 10, 12, 13, 14, 16, 17, 19, 20, 21, 21, 22, 23, 24, 26, 26, 28, 28, 29, 29,
31, 31, 32, 32, 32, 32, 32, 33, 32, 32, 32, 32, 32, 31, 30, 29, 28, 28, 27, 26,
25, 24, 22, 21, 20, 18, 16, 15, 13, 11, 9, 7, 5, 3, -1, -2, -5, -8, -9, -12,
-14, -17, -19, -22, -25, -29, -30, -33, -37, -39, -42, -44, -48, -50, -53, -57,
-59, -62, -63, -66, -69, -71, -75, -77, -79, -82, -84, -87, -89, -91, -93, -95,
-97, -100, -102, -102, -106, -106, -109, -110, -112, -112, -114, -114, -116,
-116, -117, -118, -119, -118, -120, -119, -120, -119, -119, -118, -117, -117,
-115, -115, -113, -112, -110, -109, -107, -104, -102, -100, -98, -95, -92, -89,
-86, -82, -80, -76, -72, -68, -64, -60, -55, -51, -47, -42, -37, -33, -27, -24,
-18, -13, -8, -4, };