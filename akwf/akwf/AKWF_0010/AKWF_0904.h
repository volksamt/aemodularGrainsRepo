#define DATA_LENGTH 512
#define DATA AKWF_0904

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 8, 13, 13, 13, 10, 8, 7, 6, 5, 4,
5, 7, 10, 12, 16, 20, 25, 28, 33, 38, 42, 47, 52, 56, 62, 66, 70, 75, 79, 82,
85, 89, 92, 95, 97, 100, 103, 104, 106, 107, 110, 111, 112, 113, 114, 114, 115,
116, 116, 117, 116, 116, 116, 115, 115, 115, 115, 115, 114, 113, 113, 113, 112,
112, 112, 112, 112, 111, 111, 111, 111, 111, 111, 110, 111, 111, 111, 111, 111,
111, 112, 112, 111, 112, 112, 112, 113, 112, 113, 112, 113, 113, 113, 113, 113,
114, 113, 114, 113, 114, 114, 114, 115, 114, 115, 114, 115, 114, 115, 115, 116,
115, 115, 116, 116, 116, 116, 116, 117, 116, 116, 116, 116, 117, 116, 116, 117,
116, 116, 115, 116, 117, 116, 116, 117, 117, 116, 117, 116, 117, 117, 117, 117,
116, 117, 116, 116, 117, 117, 117, 116, 116, 116, 115, 116, 116, 117, 116, 116,
116, 115, 116, 115, 115, 115, 116, 115, 116, 115, 115, 115, 115, 115, 115, 115,
115, 115, 115, 115, 114, 115, 115, 115, 115, 114, 114, 114, 114, 114, 113, 114,
114, 114, 114, 114, 113, 114, 113, 113, 113, 113, 113, 113, 112, 114, 113, 113,
112, 111, 112, 111, 111, 111, 112, 111, 110, 109, 109, 109, 109, 107, 107, 106,
106, 105, 101, 95, 88, 81, 74, 69, 62, 58, 55, 53, 52, 52, 53, 55, 56, 57, 59,
61, 63, 65, 67, 69, 70, 71, 73, 73, 72, 73, 73, 71, 69, 67, 65, 61, 58, 55, 50,
45, 40, 35, 29, 22, 16, 8, 1, -7, -14, -23, -31, -39, -46, -47, -46, -44, -42,
-39, -37, -35, -34, -33, -33, -34, -35, -37, -40, -42, -45, -48, -52, -55, -59,
-64, -67, -71, -74, -78, -82, -86, -88, -91, -94, -97, -100, -102, -105, -106,
-108, -110, -112, -113, -114, -115, -116, -117, -118, -118, -118, -119, -119,
-119, -119, -118, -119, -118, -119, -119, -119, -118, -118, -118, -117, -117,
-117, -117, -116, -116, -116, -116, -115, -115, -115, -115, -115, -115, -115,
-114, -114, -113, -113, -115, -114, -114, -114, -113, -114, -114, -114, -115,
-114, -115, -114, -115, -114, -115, -115, -115, -115, -114, -115, -115, -114,
-116, -115, -115, -116, -115, -116, -116, -115, -115, -115, -116, -115, -115,
-116, -116, -116, -116, -116, -115, -115, -115, -116, -116, -116, -116, -115,
-116, -116, -116, -116, -115, -115, -116, -116, -115, -116, -115, -115, -116,
-115, -116, -115, -116, -115, -115, -115, -116, -116, -116, -115, -116, -115,
-115, -115, -115, -115, -115, -114, -114, -115, -114, -114, -114, -114, -113,
-114, -114, -114, -113, -113, -113, -112, -113, -112, -111, -111, -111, -110,
-111, -111, -111, -110, -111, -110, -110, -109, -110, -111, -110, -110, -110,
-110, -110, -109, -110, -109, -110, -109, -109, -109, -109, -109, -109, -109,
-109, -109, -108, -108, -107, -107, -107, -107, -107, -106, -107, -105, -106,
-106, -106, -104, -105, -104, -104, -103, -103, -100, -93, -83, -72, -61, -48,
-37, -25, -15, -6, };