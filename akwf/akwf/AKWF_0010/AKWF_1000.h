#define DATA_LENGTH 512
#define DATA AKWF_1000

const PROGMEM int8_t DATA[DATA_LENGTH] = {50, 60, 58, 62, 61, 65, 65, 69, 68,
72, 72, 74, 75, 75, 72, 71, 70, 69, 67, 67, 63, 65, 61, 63, 55, 65, 29, -7, 4,
-3, 1, -1, 1, 0, 0, 0, -1, 0, -2, 1, -2, 2, -8, -32, -30, -34, -33, -35, -36,
-38, -38, -37, -36, -34, -34, -30, -32, -7, 2, -2, 0, -2, 1, -1, 0, -1, -1, 0,
0, -1, 0, 0, 0, -1, 0, 0, -1, -1, -1, 0, 0, -1, -1, 0, 0, 0, -1, 0, -1, 0, 0,
-1, -1, -1, -1, 0, 0, 0, 0, -1, -1, -1, 0, -1, -1, 0, -1, 0, 0, -1, -1, -1, -1,
-1, -1, -1, -1, -1, -1, -1, -1, 0, 0, -1, 0, -1, -1, 0, 0, -1, -1, -1, 0, -1,
-1, -1, 0, -1, 0, 0, 0, -1, -1, 0, 0, 0, -1, -1, 0, 0, 0, -1, 0, 0, 0, -1, -1,
-1, 0, 0, -1, 0, 0, 0, -1, 0, 0, -1, -1, -1, -1, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0,
0, -1, 0, 0, 0, 0, -1, -1, 0, -1, -1, -1, 0, -1, -1, -1, 0, -1, 0, 0, 0, 0, 0,
-1, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, -1, -1, -1, 0, -1, 0, 0, 0, -1,
-1, 0, 0, 0, -1, 0, -1, -1, -1, -1, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1,
0, -1, -1, 0, -1, 0, 0, -1, 0, -1, -1, -1, 0, 0, 0, 0, -1, 0, -1, 0, -1, 0, -1,
0, -1, -1, -1, 0, 0, -1, -1, -1, 0, 0, -1, -1, 0, 0, 0, 0, -1, 0, -1, -1, -1,
-1, -1, -1, -1, -1, -1, -1, -1, 0, -1, -1, 0, 0, 0, 0, 0, -1, 0, 0, -1, -1, 0,
0, -1, 0, -1, 0, -1, 0, 0, 0, -1, -1, -1, -1, 0, -1, 0, -1, 0, -1, 0, 0, -1, 0,
-1, -1, -1, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, -1, -1, -1, -1, 0, -1, 0, 0, 1,
-1, 0, 0, 0, 0, -1, -1, -1, -1, 0, 0, -1, 0, -1, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0,
-1, 0, 0, -1, 0, -1, 0, -1, 0, 0, -1, -1, -1, 0, 0, -1, 0, -1, -1, -1, 0, -1,
-1, 0, -1, 0, 0, 0, -1, 0, -1, -1, -1, -1, 0, -1, 0, -1, 0, -1, 0, 0, 0, -1, -1,
0, 0, -1, -1, 0, 0, 0, -1, -1, 0, -1, 0, 0, 0, 0, -1, -1, -1, -1, 0, -1, 0, -1,
-1, -1, 0, 0, -1, -1, 0, 0, 0, -1, 0, -1, 0, -1, 0, -1, 0, 0, 0, -1, -1, 0, 0,
0, -1, 0, -2, 1, -2, 1, -3, 3, -5, 9, -40, -107, -102, -124, -111, -115, -103,
-108, -95, -103, -73, 7, -4, 1, -1, 0, -1, 0, 0, 0, 0, -1, };