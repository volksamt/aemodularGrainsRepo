#define DATA_LENGTH 512
#define DATA AKWF_0995

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 8, 11, 15, 17, 21, 24, 27, 30,
33, 36, 39, 41, 45, 47, 51, 53, 57, 60, 63, 66, 69, 73, 76, 79, 81, 85, 87, 91,
92, 97, 99, 104, 105, 109, 111, 116, 117, 119, 113, 113, 105, 107, 100, 102, 91,
3, -2, 2, -2, 1, -2, 1, -1, 1, -2, 1, -2, 0, -2, 0, -1, 0, -2, -1, -1, 0, -1,
-1, 0, -2, 0, -1, 0, 0, 0, -1, 0, -1, 0, 0, -1, 0, -1, 0, 0, -1, 0, -1, -1, -1,
0, 0, -1, -1, 0, 0, 0, -1, -1, -1, -1, -1, 0, -1, 0, 0, 0, 0, -1, -1, -1, -1,
-1, -1, -1, 0, 0, -1, -1, 0, -1, -1, 0, -1, -1, -1, -1, 0, -1, -2, -1, 0, -1,
-1, -1, -1, 0, -1, -1, -1, -1, -1, 0, -1, 0, -1, -1, -1, -1, -1, -1, 0, -1, -1,
-2, 0, -1, -1, -1, -1, -2, -1, -1, -1, -1, 0, -1, -1, -1, 0, 0, -1, 0, -1, -1,
-1, 0, -1, 0, -1, -1, -1, -1, -1, 0, -1, -1, -1, -1, -1, -1, 0, -1, -1, -1, -1,
-1, -1, -1, 0, 0, -1, 0, 0, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, 0, -1,
-1, 0, 0, -1, -1, -1, -1, -2, -1, -1, -1, -1, -1, 0, 0, -1, 0, 0, 0, -1, -1, -1,
-1, -1, -1, 0, -1, 0, 0, -1, -1, -1, -1, 0, 0, -1, -1, 0, -1, -1, -1, -1, 0, -1,
-1, -1, 0, 0, -1, -1, -1, 0, -1, -1, -1, -1, 0, -1, -1, 0, -1, -1, -1, -1, -1,
0, 0, 0, -1, 0, 0, -1, -2, 0, -1, -1, -1, 0, -1, -1, -1, -1, 0, 0, -1, -1, -1,
0, 0, 0, -1, 0, -1, -1, -1, -1, -1, -2, -1, -1, 0, -2, -1, -1, -1, -1, -1, -1,
-1, -1, -1, -1, -1, 0, -1, -1, -1, -1, -1, -2, 0, -1, -1, -1, -1, -1, -1, -1, 0,
-1, -1, 0, -1, 0, -1, -1, 0, -1, -1, -1, -1, 0, -1, 0, -2, -5, -8, -11, -14,
-17, -20, -23, -27, -29, -32, -35, -38, -41, -44, -48, -50, -53, -56, -60, -62,
-66, -68, -72, -75, -77, -80, -84, -86, -90, -93, -96, -99, -101, -106, -107,
-112, -111, -119, -116, -118, -108, -114, -101, -113, -66, 11, -6, 3, -2, 2, -1,
0, 0, -1, -1, -2, 0, -1, 0, -1, 0, 0, 0, -1, 1, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0,
0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, -1, -1, 0, 0, -1, 0, 0, 0, 0, 0, -1,
-1, 0, 0, 0, -1, -1, -1, 0, 0, -1, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0,
0, 0, 0, 0, 0, 0, -1, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, };