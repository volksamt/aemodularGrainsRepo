#define DATA_LENGTH 512
#define DATA AKWF_0959

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 3, 3, 4, 5, 6, 6, 7, 8, 8, 8,
9, 10, 10, 12, 12, 12, 12, 14, 15, 16, 16, 17, 18, 19, 21, 21, 22, 23, 24, 26,
26, 28, 28, 29, 31, 31, 32, 32, 34, 34, 36, 35, 37, 36, 37, 37, 38, 39, 39, 39,
40, 39, 40, 40, 39, 40, 39, 40, 40, 39, 39, 40, 40, 40, 41, 41, 40, 42, 41, 42,
43, 44, 43, 44, 44, 45, 45, 47, 46, 47, 47, 48, 49, 48, 50, 50, 51, 51, 52, 52,
52, 53, 53, 53, 53, 53, 54, 53, 54, 55, 54, 54, 54, 54, 53, 54, 54, 53, 53, 51,
52, 52, 51, 51, 50, 50, 50, 50, 50, 50, 49, 49, 48, 48, 49, 49, 49, 49, 48, 49,
48, 49, 48, 48, 49, 49, 50, 49, 49, 50, 51, 51, 51, 52, 52, 52, 52, 53, 54, 53,
53, 54, 55, 54, 55, 54, 54, 55, 54, 54, 55, 55, 56, 55, 54, 55, 55, 54, 54, 54,
54, 54, 53, 53, 53, 52, 52, 52, 51, 50, 50, 49, 49, 48, 48, 47, 46, 46, 45, 45,
44, 44, 43, 42, 42, 42, 41, 41, 41, 40, 40, 39, 39, 38, 39, 39, 38, 38, 37, 37,
38, 38, 38, 37, 37, 38, 38, 37, 38, 38, 38, 39, 39, 40, 40, 41, 41, 41, 42, 42,
42, 44, 45, 46, 45, 46, 47, 48, 48, 49, 50, 50, 51, 52, 52, 52, 53, 54, 54, 55,
56, 57, 57, 58, 58, 58, 59, 60, 60, 60, 61, 61, 61, 61, 62, 62, 62, 62, 63, 62,
61, 62, 62, 62, 61, 61, 60, 60, 60, 60, 58, 58, 57, 57, 56, 54, 54, 53, 51, 51,
49, 48, 46, 46, 44, 42, 41, 39, 38, 36, 35, 33, 31, 29, 27, 25, 23, 21, 19, 17,
15, 14, 11, 8, 5, 4, 1, -1, -3, -5, -8, -10, -12, -15, -18, -21, -23, -25, -28,
-30, -32, -34, -36, -40, -41, -45, -46, -49, -52, -54, -57, -59, -60, -63, -65,
-67, -70, -71, -74, -76, -78, -79, -83, -84, -85, -88, -89, -91, -92, -94, -95,
-97, -98, -99, -100, -102, -102, -103, -103, -105, -106, -106, -107, -107, -108,
-109, -109, -110, -111, -112, -113, -112, -113, -113, -115, -115, -115, -116,
-117, -117, -117, -118, -118, -120, -118, -119, -119, -118, -118, -118, -118,
-118, -118, -117, -116, -116, -114, -114, -113, -112, -111, -110, -110, -108,
-108, -106, -107, -105, -104, -103, -103, -101, -101, -100, -100, -99, -99, -97,
-97, -96, -96, -94, -94, -93, -93, -92, -91, -90, -89, -87, -87, -85, -84, -82,
-81, -80, -79, -77, -75, -74, -73, -70, -70, -68, -67, -64, -63, -62, -60, -58,
-58, -57, -55, -54, -53, -51, -50, -50, -48, -47, -46, -46, -44, -44, -43, -41,
-41, -40, -39, -38, -36, -36, -34, -32, -32, -30, -30, -28, -26, -26, -24, -22,
-21, -19, -18, -16, -15, -13, -12, -10, -9, -7, -7, -6, -5, -3, -3, -2, -1, };