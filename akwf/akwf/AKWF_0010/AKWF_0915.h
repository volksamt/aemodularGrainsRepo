#define DATA_LENGTH 512
#define DATA AKWF_0915

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 6, 7, 8, 10, 11, 12, 13, 15,
15, 17, 17, 19, 19, 20, 21, 22, 23, 24, 24, 25, 26, 26, 27, 28, 28, 28, 29, 30,
31, 31, 31, 32, 32, 33, 33, 33, 33, 34, 34, 35, 34, 35, 35, 35, 36, 36, 36, 36,
36, 36, 36, 36, 36, 36, 36, 36, 36, 35, 36, 35, 35, 35, 36, 35, 35, 34, 34, 33,
34, 34, 33, 33, 33, 34, 33, 34, 33, 33, 34, 34, 34, 34, 33, 34, 34, 34, 34, 33,
34, 34, 34, 35, 35, 35, 35, 35, 35, 35, 35, 36, 37, 36, 37, 37, 38, 38, 40, 39,
39, 40, 40, 41, 42, 42, 43, 44, 44, 45, 46, 46, 47, 49, 49, 49, 51, 51, 52, 53,
54, 55, 56, 57, 58, 59, 60, 60, 62, 63, 64, 66, 66, 67, 68, 70, 71, 72, 73, 74,
75, 76, 78, 79, 80, 81, 82, 84, 85, 87, 87, 89, 89, 91, 92, 93, 95, 95, 98, 98,
99, 100, 103, 103, 105, 106, 106, 108, 109, 110, 111, 111, 113, 112, 112, 112,
113, 112, 112, 112, 112, 112, 111, 111, 110, 110, 109, 109, 108, 108, 106, 105,
105, 102, 99, 99, 97, 95, 93, 91, 90, 87, 85, 83, 81, 79, 76, 73, 72, 68, 67,
63, 61, 59, 58, 55, 54, 51, 48, 46, 43, 41, 40, 37, 35, 33, 31, 29, 27, 25, 23,
21, 19, 17, 15, 12, 11, 10, 8, 5, 4, 3, 0, -1, -3, -5, -6, -7, -9, -10, -12,
-13, -14, -16, -16, -18, -19, -19, -21, -22, -22, -24, -25, -25, -26, -26, -27,
-27, -29, -29, -28, -29, -29, -29, -30, -31, -30, -30, -31, -31, -31, -31, -32,
-31, -32, -31, -31, -32, -31, -32, -31, -31, -30, -30, -30, -29, -30, -29, -29,
-29, -28, -28, -28, -27, -27, -27, -27, -26, -25, -25, -25, -25, -24, -24, -24,
-23, -23, -22, -21, -21, -22, -22, -22, -22, -21, -21, -22, -21, -22, -22, -22,
-22, -22, -22, -22, -23, -23, -23, -24, -24, -26, -26, -26, -27, -27, -28, -28,
-28, -29, -30, -30, -31, -32, -33, -34, -34, -35, -36, -36, -37, -39, -39, -41,
-41, -42, -43, -45, -45, -46, -48, -49, -50, -51, -53, -53, -55, -56, -57, -59,
-59, -61, -63, -63, -65, -65, -66, -68, -70, -70, -72, -73, -74, -76, -78, -77,
-80, -81, -82, -84, -84, -86, -88, -89, -91, -92, -93, -94, -96, -96, -97, -100,
-100, -102, -103, -103, -105, -106, -108, -108, -110, -110, -112, -113, -114,
-115, -116, -118, -119, -119, -118, -118, -118, -117, -119, -118, -118, -118,
-117, -118, -117, -116, -116, -115, -114, -113, -112, -112, -111, -110, -107,
-104, -104, -102, -100, -98, -96, -94, -92, -90, -88, -85, -84, -80, -77, -75,
-73, -70, -67, -65, -64, -61, -59, -57, -54, -52, -49, -47, -45, -43, -41, -39,
-36, -34, -32, -30, -29, -26, -24, -23, -21, -19, -17, -15, -12, -11, -9, -6,
-6, -4, -2, 0, };