#define DATA_LENGTH 512
#define DATA AKWF_0928

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 10, 14, 19, 25, 29, 34, 39, 43,
48, 53, 57, 61, 65, 69, 73, 77, 80, 84, 87, 90, 94, 96, 98, 101, 104, 107, 108,
109, 111, 113, 115, 116, 117, 117, 118, 119, 119, 119, 119, 119, 119, 118, 118,
117, 116, 116, 113, 113, 112, 110, 109, 107, 106, 104, 102, 101, 99, 97, 95, 93,
90, 89, 87, 85, 83, 81, 78, 76, 74, 73, 70, 68, 66, 65, 62, 61, 59, 57, 56, 53,
52, 51, 49, 48, 46, 45, 43, 43, 41, 40, 39, 38, 36, 36, 35, 33, 32, 32, 31, 30,
29, 29, 28, 29, 27, 27, 26, 26, 26, 26, 25, 25, 24, 24, 24, 24, 24, 24, 25, 24,
24, 24, 24, 24, 24, 24, 24, 24, 24, 26, 25, 26, 26, 26, 27, 27, 27, 28, 28, 29,
29, 29, 30, 30, 31, 32, 32, 33, 32, 33, 33, 34, 35, 35, 34, 35, 36, 35, 35, 36,
36, 36, 36, 36, 36, 36, 35, 35, 35, 35, 34, 33, 34, 32, 32, 30, 30, 29, 28, 28,
26, 24, 23, 22, 21, 20, 18, 17, 16, 13, 12, 9, 8, 7, 5, 3, 1, -1, -2, -5, -6,
-8, -11, -12, -14, -16, -18, -19, -21, -22, -24, -26, -27, -28, -29, -30, -32,
-32, -34, -34, -35, -35, -37, -37, -37, -37, -37, -37, -37, -36, -36, -36, -36,
-33, -33, -32, -32, -30, -29, -28, -26, -25, -23, -21, -20, -18, -16, -14, -12,
-11, -9, -6, -3, -1, 1, 2, 5, 6, 9, 11, 13, 14, 17, 19, 21, 22, 24, 26, 27, 28,
29, 31, 32, 33, 34, 34, 35, 35, 36, 36, 36, 37, 37, 37, 37, 36, 36, 35, 35, 34,
33, 33, 31, 30, 30, 28, 26, 25, 24, 22, 20, 18, 17, 15, 13, 12, 10, 8, 7, 4, 2,
1, -1, -3, -6, -7, -9, -10, -13, -14, -15, -16, -18, -20, -21, -22, -24, -25,
-26, -27, -29, -29, -29, -31, -31, -32, -33, -34, -34, -35, -35, -35, -35, -36,
-36, -36, -36, -37, -35, -35, -36, -35, -35, -35, -34, -34, -34, -34, -33, -33,
-32, -32, -31, -31, -31, -31, -30, -29, -29, -28, -28, -28, -27, -27, -27, -26,
-26, -25, -26, -25, -24, -24, -24, -24, -24, -25, -24, -24, -23, -23, -24, -24,
-24, -24, -24, -23, -24, -24, -24, -25, -26, -27, -27, -27, -27, -28, -28, -29,
-29, -31, -31, -32, -32, -33, -35, -36, -37, -38, -38, -41, -41, -42, -44, -45,
-46, -48, -49, -51, -52, -53, -55, -59, -60, -61, -63, -66, -67, -69, -71, -73,
-76, -77, -79, -81, -83, -86, -88, -90, -91, -94, -95, -97, -99, -101, -103,
-104, -106, -108, -110, -110, -112, -113, -115, -116, -117, -117, -118, -118,
-119, -118, -119, -119, -119, -119, -118, -117, -116, -115, -114, -113, -112,
-109, -108, -106, -103, -101, -98, -95, -93, -89, -86, -83, -80, -76, -73, -68,
-65, -60, -55, -51, -47, -42, -38, -33, -28, -24, -18, -14, -9, -4, };