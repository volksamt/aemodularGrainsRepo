#define DATA_LENGTH 512
#define DATA AKWF_0919

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 7, 10, 14, 17, 21, 23, 27, 31,
34, 38, 40, 44, 46, 51, 54, 55, 56, 59, 60, 63, 66, 68, 69, 72, 74, 75, 77, 78,
79, 81, 82, 84, 85, 86, 88, 90, 90, 91, 92, 94, 95, 95, 96, 96, 97, 99, 98, 99,
100, 100, 101, 101, 101, 101, 101, 101, 102, 102, 101, 102, 102, 102, 101, 101,
101, 100, 100, 99, 99, 99, 98, 97, 97, 96, 95, 95, 94, 94, 92, 92, 92, 91, 90,
89, 88, 88, 87, 86, 84, 83, 82, 81, 80, 78, 77, 76, 74, 71, 70, 69, 67, 66, 65,
62, 62, 60, 57, 53, 52, 50, 48, 46, 44, 42, 39, 37, 34, 32, 30, 28, 26, 24, 21,
18, 16, 14, 11, 9, 7, 4, 1, -1, -3, -7, -9, -12, -14, -17, -19, -22, -24, -27,
-29, -32, -35, -37, -40, -42, -45, -48, -50, -53, -56, -58, -61, -63, -65, -68,
-70, -73, -76, -78, -80, -83, -84, -88, -89, -92, -94, -97, -98, -101, -103,
-106, -107, -110, -112, -114, -116, -115, -115, -115, -115, -117, -118, -119,
-119, -118, -120, -119, -119, -119, -118, -117, -117, -117, -116, -115, -115,
-115, -114, -112, -111, -111, -110, -108, -107, -107, -105, -104, -102, -101,
-99, -99, -97, -94, -93, -92, -90, -88, -86, -84, -83, -81, -77, -76, -75, -71,
-70, -68, -65, -63, -61, -58, -57, -54, -52, -50, -47, -45, -42, -41, -38, -36,
-34, -29, -25, -21, -18, -15, -13, -10, -6, -3, 0, 4, 7, 9, 13, 17, 20, 23, 27,
30, 34, 37, 40, 43, 47, 50, 53, 55, 56, 57, 59, 62, 65, 66, 69, 71, 72, 74, 76,
77, 79, 80, 82, 84, 85, 86, 87, 88, 90, 91, 92, 93, 93, 95, 95, 96, 98, 97, 98,
99, 100, 99, 100, 100, 101, 101, 101, 101, 101, 102, 101, 101, 101, 101, 100,
100, 100, 100, 100, 99, 98, 97, 98, 97, 97, 96, 94, 95, 95, 93, 92, 92, 91, 90,
90, 89, 88, 87, 86, 84, 84, 83, 81, 80, 79, 78, 77, 75, 73, 71, 70, 69, 67, 67,
64, 63, 61, 59, 56, 54, 52, 49, 48, 45, 43, 41, 38, 36, 34, 32, 29, 27, 25, 22,
21, 18, 16, 14, 11, 8, 6, 4, 1, -2, -4, -7, -9, -11, -13, -16, -20, -22, -24,
-27, -30, -32, -35, -38, -41, -42, -46, -48, -51, -53, -56, -59, -61, -63, -66,
-68, -71, -74, -76, -79, -80, -84, -86, -88, -90, -92, -95, -97, -100, -101,
-104, -106, -108, -110, -111, -114, -115, -116, -114, -115, -116, -117, -118,
-118, -118, -119, -119, -119, -118, -118, -117, -118, -117, -117, -116, -116,
-115, -114, -113, -112, -111, -111, -109, -108, -107, -106, -104, -104, -102,
-101, -99, -97, -95, -94, -92, -90, -89, -86, -84, -83, -81, -79, -77, -75, -73,
-71, -68, -67, -64, -62, -60, -57, -55, -53, -51, -48, -46, -44, -42, -39, -37,
-35, -33, -28, -23, -21, -18, -15, -11, -9, -6, -2, };