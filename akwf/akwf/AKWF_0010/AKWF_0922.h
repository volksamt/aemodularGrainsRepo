#define DATA_LENGTH 512
#define DATA AKWF_0922

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 4, 4, 6, 7, 8, 10, 11, 11,
13, 14, 14, 15, 16, 16, 18, 18, 20, 20, 21, 22, 22, 23, 24, 25, 26, 26, 27, 28,
28, 29, 30, 31, 32, 33, 34, 34, 36, 38, 38, 39, 40, 42, 44, 46, 47, 49, 50, 53,
56, 57, 58, 61, 64, 66, 68, 70, 72, 75, 77, 80, 82, 85, 87, 89, 92, 94, 95, 98,
100, 102, 104, 105, 107, 109, 111, 112, 114, 114, 115, 115, 116, 117, 118, 119,
119, 119, 119, 118, 119, 119, 118, 118, 117, 117, 116, 115, 114, 114, 112, 112,
109, 109, 108, 107, 105, 105, 103, 103, 102, 100, 98, 97, 97, 96, 94, 93, 91,
91, 89, 89, 88, 87, 85, 85, 84, 83, 82, 81, 80, 80, 79, 78, 76, 76, 76, 74, 72,
71, 70, 69, 68, 67, 66, 65, 62, 61, 60, 59, 57, 56, 54, 52, 51, 49, 48, 46, 45,
43, 41, 40, 38, 36, 34, 33, 30, 29, 28, 26, 25, 23, 21, 20, 19, 18, 16, 14, 14,
13, 11, 10, 9, 8, 7, 6, 5, 5, 3, 3, 3, 1, 1, 0, -2, -3, -2, -3, -4, -5, -5, -6,
-7, -8, -9, -9, -11, -12, -13, -14, -15, -16, -16, -17, -18, -20, -20, -22, -23,
-24, -26, -26, -27, -28, -30, -31, -33, -33, -35, -35, -37, -37, -38, -40, -40,
-41, -41, -42, -43, -44, -44, -45, -46, -46, -47, -48, -47, -48, -49, -49, -50,
-50, -49, -49, -50, -50, -50, -50, -51, -51, -51, -51, -52, -52, -51, -53, -54,
-53, -53, -54, -54, -55, -56, -57, -58, -58, -59, -60, -60, -61, -61, -62, -62,
-63, -64, -64, -65, -66, -67, -66, -67, -68, -68, -68, -68, -68, -68, -69, -68,
-68, -68, -67, -67, -66, -66, -64, -64, -62, -62, -61, -60, -59, -57, -56, -55,
-54, -52, -50, -50, -48, -46, -44, -43, -43, -41, -39, -38, -37, -35, -35, -34,
-33, -31, -30, -30, -29, -29, -28, -27, -28, -27, -26, -27, -27, -28, -27, -28,
-28, -29, -28, -30, -30, -30, -32, -32, -32, -33, -34, -34, -35, -37, -37, -39,
-39, -40, -40, -40, -41, -42, -42, -42, -43, -43, -43, -44, -44, -44, -45, -44,
-44, -44, -44, -44, -44, -44, -43, -44, -42, -43, -42, -42, -42, -41, -41, -40,
-40, -40, -40, -40, -40, -39, -39, -40, -39, -39, -39, -39, -40, -39, -39, -39,
-39, -40, -39, -41, -40, -40, -41, -41, -41, -41, -41, -41, -42, -41, -41, -41,
-41, -41, -41, -40, -41, -40, -40, -41, -40, -39, -39, -38, -38, -38, -36, -37,
-36, -35, -34, -33, -32, -32, -31, -30, -30, -29, -29, -28, -28, -27, -26, -25,
-25, -24, -24, -23, -23, -22, -22, -22, -22, -21, -21, -21, -19, -20, -20, -19,
-19, -19, -20, -19, -18, -19, -19, -18, -19, -19, -19, -17, -17, -17, -16, -16,
-16, -15, -15, -15, -14, -13, -13, -12, -11, -10, -9, -8, -7, -6, -6, -4, -4,
-3, -2, -1, };