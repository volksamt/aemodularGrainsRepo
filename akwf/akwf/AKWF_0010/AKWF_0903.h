#define DATA_LENGTH 512
#define DATA AKWF_0903

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 6, 9, 10, 13, 16, 18, 19, 22,
25, 27, 29, 30, 32, 35, 36, 37, 39, 41, 43, 45, 46, 47, 49, 50, 51, 52, 53, 53,
54, 55, 56, 57, 58, 58, 59, 59, 60, 61, 60, 61, 62, 62, 63, 63, 64, 64, 64, 65,
66, 66, 66, 67, 68, 68, 69, 69, 71, 72, 72, 73, 74, 74, 75, 76, 77, 78, 80, 81,
81, 83, 84, 85, 86, 87, 88, 89, 90, 90, 92, 93, 93, 95, 95, 97, 96, 98, 99, 100,
100, 100, 101, 102, 103, 103, 104, 104, 105, 105, 107, 106, 107, 107, 107, 108,
107, 108, 108, 108, 108, 108, 109, 109, 108, 109, 109, 110, 110, 109, 110, 110,
109, 110, 110, 110, 110, 110, 110, 110, 110, 110, 110, 110, 110, 112, 111, 111,
111, 112, 112, 111, 112, 112, 112, 113, 114, 114, 114, 113, 115, 114, 114, 115,
114, 115, 115, 116, 116, 116, 116, 116, 117, 117, 117, 117, 117, 117, 117, 117,
118, 118, 118, 119, 118, 119, 119, 119, 118, 118, 118, 120, 119, 119, 119, 118,
118, 119, 119, 119, 119, 118, 118, 119, 118, 119, 119, 119, 119, 118, 119, 119,
119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120, 119, 119, 119, 118,
119, 119, 120, 104, 85, 96, 104, 98, 89, 83, 78, 74, 72, 70, 66, 65, 62, 58, 56,
52, 50, 47, 45, 42, 41, 38, 36, 35, 32, 31, 30, 28, 26, 25, 24, 22, 20, 18, 16,
15, 13, 10, 8, 6, 4, 2, -1, -2, -5, -7, -10, -12, -14, -17, -19, -21, -24, -26,
-27, -30, -32, -34, -35, -37, -39, -41, -42, -44, -46, -47, -47, -49, -51, -51,
-52, -53, -54, -55, -56, -56, -57, -58, -57, -59, -60, -60, -60, -61, -61, -62,
-62, -63, -64, -64, -64, -64, -65, -66, -67, -67, -68, -68, -69, -70, -70, -70,
-71, -72, -74, -74, -75, -76, -78, -78, -79, -80, -81, -82, -83, -84, -85, -86,
-88, -88, -89, -90, -91, -92, -94, -93, -94, -96, -96, -98, -98, -100, -100,
-100, -101, -103, -103, -104, -103, -105, -104, -105, -106, -106, -106, -107,
-107, -107, -107, -108, -108, -108, -108, -109, -109, -109, -109, -109, -109,
-109, -110, -110, -110, -109, -110, -111, -110, -109, -111, -110, -110, -111,
-111, -110, -111, -111, -111, -111, -111, -111, -111, -111, -111, -112, -112,
-112, -113, -112, -113, -113, -113, -113, -113, -114, -114, -115, -115, -115,
-115, -116, -116, -116, -116, -117, -116, -116, -117, -117, -117, -117, -117,
-117, -118, -118, -118, -118, -118, -119, -118, -118, -119, -119, -118, -119,
-118, -119, -119, -118, -119, -118, -119, -119, -119, -119, -119, -118, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -111, -89, -89, -103,
-100, -92, -84, -78, -74, -72, -69, -67, -64, -61, -59, -55, -52, -50, -47, -45,
-43, -40, -39, -36, -35, -34, -31, -30, -28, -27, -25, -23, -22, -20, -18, -17,
-14, -13, -11, -9, -7, -5, -2, 0, };