#define DATA_LENGTH 512
#define DATA AKWF_0917

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 12, 17, 23, 27, 33, 38, 42, 47,
52, 55, 59, 63, 66, 69, 71, 75, 76, 78, 80, 82, 82, 84, 85, 86, 88, 88, 89, 91,
91, 91, 92, 93, 92, 94, 93, 93, 94, 94, 93, 93, 92, 91, 90, 89, 89, 87, 85, 83,
82, 80, 78, 77, 75, 73, 73, 72, 72, 71, 72, 74, 75, 76, 80, 82, 86, 90, 94, 98,
101, 106, 109, 111, 114, 116, 118, 119, 119, 119, 118, 117, 116, 114, 111, 109,
105, 102, 98, 95, 91, 88, 84, 81, 79, 75, 73, 70, 68, 66, 65, 64, 62, 62, 62,
61, 61, 61, 62, 61, 62, 62, 63, 63, 63, 64, 65, 65, 65, 66, 67, 67, 67, 68, 67,
69, 69, 69, 69, 70, 70, 70, 71, 70, 71, 70, 71, 70, 70, 70, 70, 70, 70, 68, 68,
67, 67, 67, 65, 64, 63, 62, 61, 60, 58, 57, 56, 55, 54, 51, 51, 49, 48, 47, 45,
42, 36, 28, 22, 19, 15, 13, 10, 7, 4, 2, 0, -3, -5, -7, -10, -10, -12, -14, -14,
-16, -16, -17, -17, -18, -19, -19, -20, -21, -22, -22, -23, -25, -26, -26, -27,
-29, -30, -30, -32, -33, -35, -36, -37, -38, -40, -40, -40, -42, -42, -43, -43,
-44, -44, -45, -45, -45, -46, -46, -46, -45, -47, -47, -47, -47, -47, -47, -46,
-46, -46, -46, -46, -46, -45, -45, -46, -46, -45, -46, -44, -46, -44, -44, -44,
-45, -44, -43, -43, -43, -44, -43, -42, -42, -42, -42, -42, -42, -42, -42, -42,
-41, -41, -40, -40, -40, -40, -40, -40, -39, -40, -40, -39, -39, -40, -40, -39,
-39, -39, -39, -38, -39, -39, -39, -39, -38, -38, -38, -38, -39, -37, -38, -38,
-37, -38, -38, -38, -38, -37, -38, -37, -37, -38, -38, -37, -38, -38, -37, -38,
-37, -37, -37, -37, -36, -37, -37, -37, -37, -37, -37, -37, -37, -37, -36, -36,
-37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -38, -37, -37, -37, -37,
-37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -38, -38, -38, -38, -37,
-37, -37, -37, -37, -38, -37, -37, -37, -37, -37, -38, -37, -37, -38, -37, -38,
-37, -37, -38, -38, -37, -37, -38, -38, -38, -37, -38, -38, -38, -38, -38, -38,
-38, -38, -38, -38, -37, -38, -38, -38, -39, -38, -38, -38, -38, -39, -38, -38,
-38, -39, -38, -39, -38, -39, -39, -39, -39, -39, -39, -38, -39, -39, -39, -39,
-39, -38, -39, -39, -39, -39, -40, -38, -40, -39, -39, -40, -39, -39, -39, -40,
-39, -39, -39, -40, -39, -40, -40, -40, -40, -39, -40, -39, -40, -40, -39, -40,
-40, -39, -40, -40, -40, -39, -40, -39, -39, -40, -40, -40, -40, -41, -40, -41,
-41, -41, -41, -40, -40, -40, -40, -40, -40, -40, -40, -40, -41, -40, -41, -41,
-40, -40, -40, -41, -41, -41, -40, -41, -41, -41, -40, -41, -41, -41, -40, -34,
-27, -21, -17, -14, -10, -5, -1, };