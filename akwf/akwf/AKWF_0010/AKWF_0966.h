#define DATA_LENGTH 512
#define DATA AKWF_0966

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 6, 7, 10, 12, 15, 16, 18, 20,
23, 24, 27, 29, 31, 33, 36, 38, 41, 44, 46, 48, 51, 53, 55, 58, 62, 64, 66, 70,
72, 75, 77, 79, 82, 84, 85, 88, 89, 91, 92, 94, 94, 95, 97, 97, 97, 98, 98, 99,
98, 99, 97, 97, 96, 97, 96, 96, 94, 94, 93, 91, 91, 90, 89, 87, 87, 85, 83, 82,
81, 78, 78, 76, 74, 74, 72, 69, 68, 67, 66, 64, 61, 60, 59, 57, 55, 53, 52, 50,
48, 46, 45, 43, 41, 41, 39, 37, 35, 35, 33, 31, 31, 30, 29, 29, 28, 27, 27, 26,
26, 26, 25, 26, 25, 26, 27, 26, 27, 27, 28, 28, 29, 30, 31, 31, 33, 33, 34, 35,
37, 38, 39, 40, 42, 43, 46, 47, 49, 51, 53, 54, 56, 57, 60, 62, 64, 66, 68, 71,
73, 75, 78, 81, 83, 86, 89, 92, 94, 96, 98, 101, 102, 104, 107, 109, 111, 113,
114, 115, 116, 117, 118, 118, 118, 119, 119, 119, 119, 118, 119, 118, 118, 117,
117, 116, 116, 115, 114, 112, 112, 110, 110, 109, 107, 105, 104, 102, 101, 99,
98, 96, 95, 93, 92, 91, 88, 87, 86, 84, 82, 80, 78, 76, 74, 73, 70, 69, 68, 66,
64, 62, 60, 58, 57, 55, 53, 51, 50, 48, 46, 44, 42, 41, 39, 37, 35, 33, 32, 30,
29, 26, 24, 22, 21, 19, 17, 15, 14, 11, 9, 7, 5, 4, 2, -1, -2, -4, -6, -8, -9,
-12, -15, -16, -18, -20, -23, -25, -27, -29, -31, -34, -36, -39, -40, -44, -46,
-48, -52, -54, -56, -59, -61, -65, -67, -70, -72, -74, -76, -80, -82, -84, -86,
-88, -90, -91, -93, -94, -94, -95, -96, -97, -97, -98, -98, -98, -98, -99, -98,
-97, -97, -97, -96, -96, -94, -94, -93, -92, -92, -89, -88, -87, -86, -85, -83,
-82, -81, -79, -78, -76, -75, -74, -72, -70, -69, -66, -66, -64, -61, -60, -58,
-57, -55, -53, -51, -50, -48, -46, -44, -43, -41, -40, -37, -37, -35, -34, -32,
-31, -31, -30, -30, -29, -28, -27, -26, -27, -26, -27, -26, -26, -27, -27, -27,
-28, -27, -28, -29, -29, -31, -31, -31, -32, -34, -36, -36, -37, -38, -39, -41,
-43, -44, -45, -48, -49, -51, -52, -54, -55, -59, -60, -62, -64, -66, -68, -71,
-74, -75, -78, -80, -83, -86, -89, -91, -94, -96, -98, -100, -103, -104, -107,
-108, -110, -111, -114, -115, -115, -117, -118, -118, -118, -118, -119, -119,
-118, -119, -119, -118, -118, -117, -117, -116, -115, -115, -113, -112, -112,
-111, -109, -108, -107, -106, -105, -102, -101, -100, -98, -97, -95, -93, -92,
-91, -89, -87, -85, -84, -81, -80, -78, -77, -74, -73, -71, -69, -68, -65, -65,
-62, -60, -59, -56, -55, -53, -52, -49, -47, -46, -44, -42, -40, -39, -37, -35,
-34, -31, -30, -28, -26, -25, -22, -20, -19, -17, -15, -13, -11, -10, -7, -7,
-1, 0, -1, };