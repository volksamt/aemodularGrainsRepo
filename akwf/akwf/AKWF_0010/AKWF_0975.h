#define DATA_LENGTH 512
#define DATA AKWF_0975

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 10, 14, 17, 20, 24, 26, 29, 31,
33, 35, 37, 40, 40, 43, 44, 46, 46, 49, 50, 51, 53, 55, 56, 58, 59, 61, 64, 65,
67, 69, 71, 73, 75, 76, 78, 80, 80, 80, 82, 82, 82, 83, 83, 85, 83, 85, 86, 86,
86, 87, 87, 88, 89, 90, 90, 91, 92, 93, 95, 95, 96, 96, 97, 97, 97, 99, 99, 100,
100, 101, 102, 102, 102, 102, 102, 103, 101, 101, 101, 99, 98, 97, 96, 96, 96,
95, 95, 95, 96, 96, 97, 97, 97, 98, 99, 99, 99, 101, 102, 102, 103, 104, 105,
105, 106, 107, 107, 108, 108, 109, 109, 108, 108, 108, 109, 108, 107, 107, 105,
105, 104, 103, 103, 102, 101, 101, 100, 99, 98, 97, 97, 97, 96, 96, 93, 93, 90,
83, 74, 65, 55, 46, 37, 28, 21, 13, 6, 0, -6, -10, -15, -20, -25, -29, -33, -36,
-38, -41, -45, -47, -49, -52, -54, -55, -56, -59, -59, -61, -62, -63, -65, -66,
-67, -68, -69, -70, -70, -71, -72, -72, -73, -73, -73, -73, -73, -72, -72, -71,
-70, -70, -70, -69, -68, -68, -67, -67, -67, -68, -68, -68, -67, -68, -68, -69,
-69, -69, -69, -69, -69, -69, -69, -68, -70, -70, -69, -71, -72, -71, -72, -73,
-73, -74, -73, -74, -74, -74, -74, -74, -73, -72, -72, -71, -69, -68, -68, -68,
-68, -67, -66, -66, -66, -65, -66, -66, -66, -66, -66, -67, -68, -69, -70, -71,
-72, -72, -74, -73, -75, -76, -76, -77, -77, -78, -78, -78, -79, -79, -79, -78,
-78, -78, -77, -76, -76, -75, -74, -74, -73, -72, -71, -71, -70, -68, -67, -67,
-65, -64, -63, -62, -61, -59, -59, -58, -57, -57, -55, -53, -54, -52, -52, -51,
-49, -48, -48, -47, -47, -46, -47, -47, -47, -47, -48, -49, -51, -52, -53, -53,
-55, -56, -56, -57, -58, -58, -59, -59, -60, -61, -60, -61, -63, -63, -64, -66,
-66, -68, -70, -71, -71, -73, -75, -75, -76, -78, -79, -79, -80, -81, -82, -83,
-83, -83, -84, -85, -84, -85, -85, -86, -86, -86, -86, -86, -86, -87, -86, -86,
-85, -85, -85, -85, -86, -85, -84, -84, -84, -84, -83, -83, -82, -82, -83, -83,
-84, -83, -85, -85, -86, -88, -89, -90, -91, -92, -94, -96, -98, -100, -102,
-102, -104, -105, -105, -105, -105, -106, -107, -106, -106, -106, -107, -108,
-108, -107, -109, -109, -109, -110, -110, -111, -112, -113, -114, -115, -115,
-116, -116, -117, -118, -117, -117, -118, -118, -118, -119, -119, -119, -118,
-119, -119, -119, -119, -118, -118, -118, -117, -116, -116, -116, -115, -114,
-115, -116, -116, -116, -116, -117, -117, -116, -116, -115, -115, -115, -114,
-114, -112, -111, -111, -110, -109, -109, -108, -107, -106, -105, -104, -103,
-102, -100, -100, -99, -99, -98, -97, -96, -95, -95, -93, -92, -91, -91, -90,
-90, -90, -89, -88, -89, -89, -89, -88, -88, -87, -83, -76, -67, -59, -50, -42,
-34, -26, -20, -14, -7, -2, };