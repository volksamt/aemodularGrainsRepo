#define DATA_LENGTH 512
#define DATA AKWF_0940

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 9, 13, 18, 22, 27, 31, 36, 40,
45, 48, 53, 55, 60, 63, 68, 71, 75, 78, 81, 85, 88, 91, 93, 97, 98, 101, 104,
105, 107, 109, 111, 112, 114, 115, 115, 117, 117, 118, 119, 119, 118, 119, 119,
119, 118, 118, 117, 116, 116, 114, 113, 112, 111, 109, 109, 106, 104, 103, 101,
99, 97, 94, 92, 90, 87, 85, 83, 80, 78, 76, 73, 69, 67, 65, 62, 59, 56, 53, 50,
47, 45, 42, 39, 37, 33, 30, 28, 25, 22, 19, 16, 14, 11, 8, 5, 3, 1, -2, -4, -5,
-9, -10, -13, -14, -17, -19, -21, -23, -25, -26, -28, -30, -31, -32, -33, -35,
-35, -36, -37, -39, -39, -39, -40, -41, -41, -41, -41, -42, -40, -41, -41, -40,
-40, -39, -38, -38, -37, -37, -35, -33, -33, -31, -30, -29, -26, -26, -23, -21,
-19, -17, -16, -13, -12, -9, -7, -4, -2, -1, 2, 5, 7, 10, 12, 15, 18, 20, 23,
25, 27, 30, 32, 35, 37, 39, 42, 44, 46, 49, 51, 53, 55, 57, 58, 60, 62, 63, 64,
66, 68, 70, 70, 72, 73, 73, 74, 75, 76, 76, 77, 76, 77, 77, 78, 78, 78, 77, 77,
76, 76, 75, 75, 74, 73, 72, 71, 71, 70, 68, 68, 66, 65, 64, 62, 61, 60, 57, 56,
54, 52, 51, 49, 47, 45, 43, 42, 39, 37, 35, 34, 31, 29, 27, 25, 23, 22, 19, 17,
15, 13, 11, 9, 6, 4, 1, 0, -2, -5, -7, -8, -11, -13, -15, -17, -20, -21, -24,
-25, -27, -30, -32, -34, -35, -37, -40, -42, -44, -46, -48, -50, -51, -53, -55,
-56, -57, -60, -61, -63, -63, -65, -67, -68, -68, -70, -71, -72, -73, -73, -74,
-75, -76, -76, -77, -77, -76, -78, -77, -77, -78, -77, -78, -77, -77, -75, -74,
-73, -73, -72, -71, -70, -69, -67, -66, -65, -63, -61, -60, -58, -57, -55, -53,
-50, -49, -47, -44, -41, -38, -37, -35, -31, -29, -28, -25, -22, -19, -17, -14,
-12, -10, -7, -5, -2, 1, 3, 5, 7, 10, 12, 14, 16, 18, 20, 21, 24, 25, 27, 29,
29, 31, 33, 34, 35, 36, 37, 38, 39, 40, 40, 40, 40, 41, 42, 41, 41, 41, 41, 40,
39, 39, 39, 38, 37, 36, 35, 34, 33, 31, 30, 29, 28, 25, 24, 22, 20, 19, 17, 14,
12, 10, 8, 6, 3, 1, -2, -3, -7, -9, -12, -14, -17, -20, -23, -25, -28, -30, -34,
-37, -39, -42, -45, -48, -51, -54, -57, -59, -63, -65, -68, -71, -74, -76, -78,
-81, -84, -86, -88, -91, -93, -95, -97, -100, -101, -103, -105, -107, -108,
-110, -111, -113, -114, -115, -116, -117, -117, -118, -118, -118, -119, -119,
-118, -118, -118, -117, -117, -116, -115, -114, -112, -112, -109, -108, -107,
-105, -102, -100, -98, -95, -93, -89, -86, -84, -80, -78, -74, -70, -66, -63,
-60, -55, -51, -47, -43, -38, -34, -30, -26, -21, -17, -12, -9, -3, };