#define DATA_LENGTH 512
#define DATA AKWF_0938

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 19, 34, 47, 57, 66, 73, 79, 84, 88,
92, 94, 97, 98, 100, 101, 103, 103, 104, 105, 107, 108, 108, 109, 110, 111, 111,
112, 113, 114, 115, 114, 116, 117, 116, 118, 118, 118, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 118, 118, 118, 118, 117, 118, 117, 117, 117, 116, 116,
117, 116, 116, 116, 115, 115, 116, 115, 114, 115, 115, 114, 114, 113, 112, 112,
110, 110, 108, 107, 105, 105, 102, 101, 98, 97, 95, 92, 90, 89, 88, 86, 83, 83,
81, 81, 79, 79, 78, 76, 75, 73, 70, 68, 65, 62, 58, 53, 48, 42, 34, 27, 18, 9,
0, -9, -17, -23, -29, -35, -37, -41, -42, -44, -43, -44, -43, -41, -39, -38,
-36, -34, -32, -30, -29, -28, -27, -28, -29, -31, -33, -35, -39, -41, -45, -47,
-51, -53, -56, -59, -60, -62, -63, -64, -64, -62, -62, -60, -59, -56, -53, -51,
-48, -44, -40, -37, -33, -30, -28, -26, -24, -22, -22, -22, -23, -23, -25, -26,
-28, -30, -32, -33, -34, -35, -35, -35, -34, -34, -33, -32, -29, -27, -24, -22,
-19, -18, -16, -13, -13, -11, -11, -11, -12, -14, -16, -18, -21, -24, -27, -29,
-31, -35, -36, -38, -40, -40, -41, -41, -40, -39, -37, -35, -32, -30, -27, -23,
-21, -19, -16, -14, -12, -12, -11, -13, -13, -14, -18, -20, -23, -26, -29, -32,
-34, -37, -39, -40, -40, -41, -40, -39, -37, -34, -30, -25, -20, -13, -6, 1, 8,
14, 22, 26, 30, 35, 37, 40, 40, 40, 41, 40, 39, 37, 34, 31, 29, 26, 22, 20, 16,
14, 13, 11, 11, 12, 13, 14, 16, 19, 22, 25, 28, 30, 33, 36, 37, 39, 40, 40, 40,
41, 40, 39, 36, 34, 32, 29, 27, 23, 21, 18, 15, 13, 12, 12, 11, 12, 12, 14, 16,
18, 20, 22, 26, 27, 30, 32, 33, 34, 35, 35, 35, 34, 33, 32, 31, 29, 27, 26, 25,
24, 22, 22, 21, 23, 24, 26, 28, 31, 34, 37, 41, 45, 48, 51, 54, 57, 58, 61, 62,
63, 63, 63, 62, 62, 60, 58, 56, 53, 50, 47, 44, 41, 38, 35, 32, 31, 28, 28, 28,
28, 30, 30, 32, 34, 37, 38, 40, 42, 43, 44, 43, 43, 42, 39, 36, 33, 29, 22, 16,
7, -2, -12, -21, -29, -37, -43, -50, -54, -59, -62, -66, -70, -71, -73, -75,
-76, -77, -78, -80, -81, -82, -83, -84, -86, -87, -89, -91, -93, -95, -97, -99,
-101, -103, -104, -106, -107, -108, -109, -111, -112, -112, -113, -114, -114,
-114, -115, -115, -115, -115, -116, -116, -116, -117, -116, -116, -117, -116,
-117, -117, -118, -117, -117, -118, -118, -119, -118, -119, -120, -119, -119,
-120, -119, -118, -119, -119, -119, -118, -119, -117, -116, -117, -116, -115,
-114, -114, -113, -112, -111, -110, -109, -109, -108, -107, -106, -106, -104,
-103, -102, -102, -100, -98, -96, -93, -91, -88, -83, -78, -71, -64, -55, -43,
-31, -13, };