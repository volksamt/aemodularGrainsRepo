#define DATA_LENGTH 512
#define DATA AKWF_0936

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 12, 17, 22, 27, 33, 38, 41, 45,
49, 52, 55, 59, 61, 64, 65, 66, 69, 70, 72, 74, 75, 77, 79, 82, 85, 86, 89, 93,
95, 98, 100, 104, 107, 109, 111, 112, 114, 116, 117, 118, 119, 120, 119, 118,
118, 117, 116, 116, 113, 111, 111, 110, 108, 107, 106, 105, 104, 103, 102, 102,
102, 100, 99, 98, 98, 97, 96, 94, 93, 91, 90, 86, 85, 82, 79, 76, 73, 70, 67,
64, 60, 59, 55, 53, 50, 48, 46, 45, 43, 42, 41, 40, 39, 37, 36, 36, 35, 35, 33,
31, 30, 28, 26, 23, 20, 18, 15, 12, 8, 6, 2, -1, -3, -5, -8, -10, -12, -14, -15,
-15, -17, -16, -16, -15, -16, -14, -14, -13, -11, -10, -10, -10, -10, -9, -10,
-10, -11, -11, -13, -15, -14, -16, -17, -19, -21, -22, -24, -25, -26, -26, -26,
-27, -26, -25, -25, -23, -22, -21, -19, -18, -16, -14, -13, -11, -11, -9, -8,
-8, -8, -7, -7, -8, -8, -9, -10, -9, -11, -11, -11, -12, -12, -13, -12, -12,
-12, -11, -11, -9, -9, -8, -7, -6, -6, -5, -4, -4, -4, -4, -4, -4, -4, -5, -6,
-7, -8, -9, -9, -12, -12, -14, -14, -14, -14, -15, -15, -14, -13, -13, -12, -11,
-11, -9, -7, -7, -6, -6, -4, -3, -3, -4, -4, -4, -5, -5, -6, -8, -8, -10, -11,
-12, -12, -14, -15, -15, -15, -15, -14, -13, -11, -10, -9, -7, -4, -2, 0, 2, 5,
8, 9, 11, 12, 14, 14, 14, 15, 14, 14, 14, 13, 12, 11, 10, 9, 7, 6, 5, 4, 4, 3,
4, 4, 4, 5, 5, 6, 7, 8, 9, 11, 11, 12, 13, 14, 14, 15, 14, 15, 14, 13, 13, 12,
11, 10, 9, 8, 6, 6, 4, 4, 4, 4, 4, 3, 4, 4, 5, 6, 7, 7, 9, 9, 10, 11, 11, 12,
12, 13, 12, 12, 12, 11, 10, 10, 9, 8, 8, 8, 8, 8, 7, 8, 7, 9, 10, 12, 12, 13,
15, 16, 19, 19, 21, 23, 24, 24, 26, 26, 26, 26, 26, 26, 24, 23, 22, 21, 19, 17,
16, 15, 13, 12, 11, 10, 10, 9, 9, 9, 10, 11, 11, 11, 12, 14, 14, 15, 15, 16, 16,
15, 15, 15, 12, 11, 9, 7, 5, 2, -1, -4, -7, -10, -13, -16, -19, -22, -24, -26,
-28, -30, -31, -33, -34, -35, -36, -37, -39, -39, -40, -41, -42, -43, -46, -47,
-49, -51, -53, -56, -59, -62, -65, -68, -71, -74, -76, -80, -83, -86, -88, -89,
-92, -93, -95, -96, -97, -99, -100, -100, -101, -101, -102, -102, -103, -105,
-105, -106, -107, -108, -110, -111, -112, -114, -115, -116, -118, -118, -119,
-120, -120, -119, -118, -117, -116, -115, -112, -111, -109, -106, -103, -99,
-98, -95, -91, -89, -86, -84, -81, -79, -77, -75, -73, -72, -70, -68, -66, -64,
-63, -60, -58, -55, -53, -48, -44, -41, -36, -32, -27, -22, -16, -11, -4, };