#define DATA_LENGTH 512
#define DATA AKWF_0944

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 8, 10, 13, 16, 19, 23, 26,
29, 32, 36, 39, 42, 45, 48, 52, 54, 57, 61, 64, 67, 71, 73, 77, 79, 82, 85, 87,
91, 93, 95, 98, 101, 103, 105, 106, 109, 110, 111, 113, 115, 116, 117, 118, 118,
119, 119, 120, 120, 118, 118, 118, 118, 116, 116, 114, 114, 112, 111, 109, 108,
107, 105, 103, 101, 101, 98, 97, 95, 94, 93, 90, 90, 87, 87, 84, 83, 81, 79, 79,
76, 75, 73, 72, 71, 69, 67, 66, 64, 63, 62, 61, 60, 58, 55, 55, 53, 51, 50, 49,
48, 45, 45, 44, 42, 41, 40, 37, 36, 36, 34, 32, 32, 31, 29, 28, 27, 26, 25, 23,
22, 21, 21, 19, 18, 17, 15, 14, 14, 12, 12, 10, 9, 8, 8, 6, 6, 4, 4, 2, 2, 2, 0,
20, 35, 44, 54, 62, 69, 76, 84, 89, 98, 103, 110, 113, 117, 118, 119, 118, 114,
109, 105, 99, 92, 84, 77, 69, 60, 53, 44, 38, 30, 23, 15, 9, 2, -3, -10, -15,
-20, -25, -29, -34, -37, -41, -45, -47, -49, -51, -54, -56, -58, -59, -61, -62,
-64, -65, -65, -66, -67, -68, -68, -67, -67, -68, -68, -68, -69, -68, -67, -67,
-68, -68, -67, -67, -66, -65, -64, -64, -64, -63, -62, -62, -61, -61, -60, -60,
-59, -58, -58, -57, -57, -55, -56, -54, -55, -53, -53, -52, -52, -51, -50, -50,
-48, -48, -48, -48, -47, -46, -46, -46, -45, -44, -43, -42, -43, -42, -41, -40,
-40, -40, -39, -38, -38, -37, -36, -36, -36, -35, -34, -33, -33, -32, -31, -31,
-30, -30, -30, -30, -29, -27, -28, -27, -25, -25, -25, -23, -23, -23, -23, -21,
-21, -20, -19, -19, -17, -17, -16, -15, -15, -14, -12, -12, -11, -10, -9, -8,
-7, -7, -5, -4, -3, -2, -2, -1, -1, -3, -4, -5, -6, -7, -7, -8, -9, -11, -11,
-12, -13, -13, -14, -15, -16, -17, -17, -18, -18, -19, -20, -21, -21, -22, -23,
-23, -24, -25, -25, -27, -26, -27, -27, -28, -29, -29, -30, -30, -30, -31, -31,
-32, -32, -33, -33, -33, -35, -35, -36, -36, -37, -37, -37, -38, -39, -38, -39,
-40, -40, -40, -41, -42, -42, -41, -43, -43, -43, -44, -44, -45, -45, -46, -46,
-46, -46, -47, -48, -49, -49, -49, -51, -51, -51, -52, -52, -52, -53, -54, -54,
-54, -54, -55, -55, -56, -56, -57, -57, -58, -57, -59, -59, -60, -60, -61, -61,
-61, -62, -62, -62, -63, -63, -63, -63, -64, -64, -65, -65, -65, -66, -66, -67,
-67, -66, -67, -67, -68, -67, -67, -68, -68, -68, -69, -69, -68, -68, -68, -68,
-68, -68, -68, -68, -68, -67, -67, -67, -67, -66, -66, -65, -65, -64, -64, -63,
-63, -62, -61, -61, -60, -59, -59, -57, -57, -55, -55, -53, -52, -50, -49, -48,
-47, -45, -44, -42, -40, -39, -38, -35, -33, -32, -29, -27, -25, -23, -21, -18,
-16, -13, -11, -9, -6, -3, -1, };