#define DATA_LENGTH 512
#define DATA AKWF_0902

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 4, 5, 6, 7, 7, 9, 11, 11, 12,
13, 14, 15, 17, 17, 18, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 32, 32, 33,
35, 35, 37, 37, 39, 40, 40, 42, 42, 44, 45, 46, 46, 48, 49, 50, 51, 52, 53, 55,
55, 56, 58, 58, 60, 60, 62, 63, 63, 64, 66, 67, 68, 69, 70, 71, 71, 73, 75, 76,
77, 77, 78, 79, 82, 83, 82, 85, 85, 86, 87, 89, 90, 90, 92, 92, 94, 95, 95, 96,
99, 99, 100, 101, 102, 104, 104, 105, 106, 107, 108, 109, 110, 112, 113, 114,
114, 115, 115, 115, 116, 116, 116, 117, 117, 118, 118, 118, 119, 118, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 118, 117, 117, 118, 116, 116, 116, 116,
116, 116, 114, 114, 113, 113, 112, 111, 111, 111, 110, 109, 108, 107, 106, 105,
104, 103, 103, 102, 101, 100, 99, 98, 97, 96, 96, 94, 92, 92, 91, 90, 88, 88,
86, 85, 84, 83, 81, 80, 80, 79, 76, 76, 75, 74, 72, 71, 71, 69, 67, 67, 66, 65,
64, 62, 62, 61, 59, 58, 57, 56, 55, 54, 53, 52, 51, 50, 49, 48, 47, 46, 46, 44,
44, 42, 41, 41, 40, 38, 37, 36, 35, 34, 33, 32, 32, 30, 29, 28, 28, 27, 26, 24,
23, 22, 21, 20, 19, 17, 17, 16, 15, 13, 13, 12, 11, 10, 9, 7, 5, 4, 4, 2, 2, 1,
-1, -2, -2, -4, -5, -5, -7, -8, -9, -10, -11, -12, -13, -14, -16, -17, -18, -19,
-19, -20, -22, -23, -24, -25, -27, -27, -27, -29, -30, -31, -33, -34, -35, -37,
-37, -37, -39, -40, -41, -42, -43, -44, -45, -46, -47, -49, -49, -50, -51, -52,
-53, -55, -55, -57, -58, -59, -59, -61, -62, -63, -64, -64, -66, -67, -69, -69,
-71, -71, -72, -73, -74, -76, -77, -77, -78, -80, -81, -82, -82, -83, -86, -86,
-87, -88, -89, -90, -92, -93, -94, -94, -95, -97, -98, -99, -100, -101, -101,
-103, -104, -105, -107, -107, -109, -109, -111, -112, -113, -114, -114, -114,
-115, -115, -117, -117, -118, -117, -118, -118, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -118, -118, -117, -118, -117, -117,
-118, -117, -116, -115, -116, -115, -114, -114, -113, -113, -112, -112, -111,
-111, -109, -110, -108, -106, -107, -106, -105, -103, -102, -102, -101, -100,
-99, -98, -97, -96, -94, -94, -93, -92, -90, -90, -89, -87, -86, -85, -83, -83,
-82, -80, -79, -78, -76, -75, -74, -73, -72, -71, -70, -68, -68, -67, -65, -64,
-64, -62, -62, -60, -59, -59, -57, -56, -55, -53, -53, -53, -51, -50, -49, -48,
-47, -46, -45, -44, -44, -43, -41, -40, -40, -38, -38, -36, -35, -34, -33, -33,
-31, -30, -30, -28, -28, -26, -25, -23, -22, -21, -21, -20, -19, -18, -16, -16,
-14, -13, -12, -11, -10, -10, -8, -8, -6, -5, -4, -3, -1, 0, };