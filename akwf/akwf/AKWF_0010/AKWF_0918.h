#define DATA_LENGTH 512
#define DATA AKWF_0918

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 11, 14, 17, 20, 23, 26, 29,
32, 35, 37, 39, 43, 46, 48, 50, 53, 56, 58, 62, 64, 66, 68, 71, 73, 75, 77, 80,
82, 84, 86, 89, 90, 93, 94, 96, 98, 100, 101, 102, 104, 106, 107, 109, 109, 111,
111, 113, 114, 115, 115, 116, 116, 118, 119, 119, 119, 119, 118, 116, 117, 116,
117, 116, 115, 115, 115, 113, 113, 111, 110, 109, 109, 107, 105, 104, 101, 100,
98, 96, 95, 93, 91, 90, 87, 85, 83, 80, 79, 76, 74, 72, 68, 66, 64, 60, 59, 55,
52, 49, 46, 44, 40, 38, 34, 32, 29, 26, 22, 19, 18, 15, 12, 8, 6, 4, 1, -2, -5,
-7, -10, -13, -15, -18, -20, -23, -26, -27, -30, -32, -35, -36, -39, -41, -43,
-46, -48, -49, -52, -53, -55, -57, -59, -60, -62, -64, -65, -67, -68, -70, -71,
-73, -74, -74, -77, -77, -79, -79, -80, -81, -82, -84, -84, -85, -85, -86, -87,
-87, -88, -88, -89, -89, -90, -90, -90, -91, -91, -91, -91, -91, -92, -91, -91,
-91, -92, -91, -91, -92, -91, -91, -90, -90, -89, -89, -88, -88, -88, -87, -87,
-87, -86, -86, -85, -85, -83, -83, -83, -82, -81, -80, -79, -79, -78, -77, -76,
-76, -74, -74, -73, -72, -72, -70, -69, -68, -67, -66, -65, -64, -63, -62, -61,
-59, -59, -58, -56, -55, -54, -52, -52, -48, -43, -41, -36, -32, -28, -24, -22,
-20, -18, -15, -11, -8, -5, -1, 1, 5, 8, 11, 14, 18, 21, 23, 27, 29, 32, 35, 38,
40, 43, 46, 48, 51, 53, 56, 58, 61, 64, 65, 68, 71, 74, 76, 79, 80, 82, 85, 86,
88, 90, 93, 95, 96, 97, 100, 101, 103, 105, 106, 107, 108, 110, 111, 112, 113,
114, 115, 115, 116, 117, 117, 118, 119, 119, 119, 118, 117, 116, 117, 116, 116,
115, 115, 114, 113, 111, 112, 109, 109, 108, 107, 105, 103, 103, 101, 98, 97,
95, 93, 92, 90, 88, 86, 83, 81, 78, 77, 73, 71, 68, 66, 63, 60, 57, 54, 51, 49,
46, 43, 40, 37, 34, 31, 29, 26, 22, 20, 17, 14, 12, 9, 5, 2, 0, -3, -5, -8, -11,
-13, -16, -18, -20, -23, -25, -28, -30, -33, -35, -37, -40, -41, -44, -45, -47,
-49, -51, -54, -55, -57, -59, -61, -62, -64, -66, -67, -69, -70, -72, -72, -74,
-76, -76, -77, -79, -79, -81, -82, -83, -84, -84, -85, -85, -86, -88, -87, -88,
-88, -89, -89, -89, -90, -90, -91, -91, -90, -91, -91, -92, -92, -91, -91, -92,
-92, -92, -91, -90, -90, -90, -89, -89, -89, -89, -88, -88, -87, -87, -86, -86,
-85, -85, -84, -84, -83, -83, -82, -81, -80, -80, -78, -77, -77, -76, -75, -75,
-74, -73, -72, -70, -71, -69, -69, -67, -65, -65, -63, -63, -62, -61, -60, -59,
-57, -55, -55, -54, -53, -51, -48, -44, -40, -36, -31, -28, -24, -22, -20, -17,
-15, -11, -8, -5, -1, };