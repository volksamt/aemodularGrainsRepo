#define DATA_LENGTH 512
#define DATA AKWF_0991

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 6, 10, 13, 16, 20, 22, 25, 27,
30, 33, 36, 39, 42, 44, 47, 49, 52, 54, 56, 59, 60, 62, 64, 66, 67, 70, 72, 73,
75, 76, 77, 78, 80, 82, 83, 83, 85, 85, 86, 86, 87, 88, 89, 89, 90, 91, 90, 91,
91, 91, 92, 91, 92, 91, 91, 91, 91, 90, 90, 90, 89, 88, 89, 87, 87, 86, 85, 84,
85, 83, 83, 82, 82, 80, 79, 79, 78, 77, 75, 74, 73, 72, 71, 70, 70, 68, 68, 66,
65, 64, 62, 62, 61, 60, 58, 57, 56, 55, 55, 53, 52, 51, 51, 49, 48, 47, 46, 45,
45, 42, 42, 42, 41, 40, 38, 38, 36, 36, 36, 35, 34, 33, 33, 31, 31, 31, 29, 30,
28, 28, 28, 27, 26, 25, 25, 26, 24, 24, 24, 24, 23, 23, 23, 23, 22, 22, 22, 22,
22, 21, 22, 22, 21, 21, 20, 21, 20, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 22,
21, 22, 22, 21, 21, 21, 21, 22, 22, 22, 22, 22, 22, 22, 22, 23, 22, 22, 23, 23,
22, 23, 23, 23, 23, 23, 23, 23, 24, 23, 22, 23, 22, 23, 22, 22, 23, 22, 22, 22,
21, 22, 21, 20, 20, 20, 20, 19, 20, 19, 19, 18, 18, 17, 16, 16, 16, 15, 15, 14,
13, 13, 13, 12, 12, 10, 10, 10, 9, 9, 8, 7, 6, 6, 5, 4, 4, 3, 2, 2, 1, 0, -1,
-1, -2, -2, -3, -4, -5, -4, -6, -6, -7, -8, -9, -9, -10, -11, -12, -13, -13,
-14, -15, -15, -15, -15, -17, -18, -17, -19, -20, -19, -20, -21, -22, -21, -22,
-23, -23, -24, -24, -25, -26, -26, -26, -27, -27, -28, -28, -29, -28, -29, -30,
-29, -30, -31, -30, -30, -31, -32, -31, -31, -32, -33, -33, -33, -32, -32, -32,
-33, -33, -33, -33, -34, -33, -33, -34, -33, -33, -33, -34, -33, -33, -33, -33,
-33, -32, -32, -32, -32, -32, -32, -31, -32, -31, -31, -31, -31, -31, -31, -30,
-30, -29, -29, -29, -29, -29, -29, -28, -29, -27, -27, -28, -27, -27, -27, -27,
-26, -25, -25, -25, -25, -24, -24, -24, -23, -23, -22, -22, -22, -22, -21, -21,
-21, -20, -20, -19, -19, -19, -19, -18, -18, -18, -17, -17, -17, -17, -16, -16,
-16, -16, -15, -15, -15, -15, -15, -13, -14, -13, -12, -13, -12, -12, -12, -12,
-12, -11, -12, -11, -11, -12, -12, -13, -15, -17, -18, -21, -23, -25, -28, -31,
-34, -38, -42, -46, -50, -53, -58, -61, -65, -69, -72, -76, -79, -82, -87, -89,
-93, -96, -99, -101, -103, -106, -108, -110, -111, -113, -114, -116, -117, -117,
-118, -119, -119, -119, -119, -119, -118, -119, -117, -116, -115, -114, -112,
-111, -110, -108, -106, -104, -103, -100, -97, -95, -92, -90, -87, -85, -81,
-78, -75, -72, -69, -65, -62, -60, -56, -53, -49, -47, -44, -39, -36, -32, -29,
-26, -23, -19, -15, -12, -9, -6, -2, };