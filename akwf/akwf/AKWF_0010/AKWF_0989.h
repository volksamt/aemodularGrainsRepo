#define DATA_LENGTH 512
#define DATA AKWF_0989

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 8, 13, 16, 20, 23, 27, 31, 35,
39, 43, 46, 50, 54, 57, 62, 65, 69, 73, 75, 80, 83, 86, 89, 92, 95, 97, 100,
103, 105, 108, 110, 111, 113, 114, 116, 117, 117, 118, 118, 119, 119, 118, 119,
119, 118, 117, 116, 114, 112, 112, 109, 107, 105, 103, 101, 97, 94, 92, 88, 85,
81, 78, 74, 69, 66, 62, 59, 54, 50, 46, 41, 37, 33, 28, 24, 20, 14, 10, 7, 2,
-3, -6, -12, -15, -20, -23, -27, -31, -35, -39, -42, -46, -49, -52, -55, -58,
-61, -63, -66, -69, -71, -73, -75, -77, -79, -80, -81, -83, -83, -85, -85, -86,
-87, -87, -88, -87, -87, -87, -87, -87, -86, -85, -85, -84, -83, -82, -81, -80,
-79, -78, -76, -74, -74, -73, -70, -69, -68, -66, -65, -63, -61, -60, -59, -56,
-55, -54, -52, -50, -49, -47, -45, -44, -42, -41, -40, -39, -37, -35, -34, -33,
-33, -31, -29, -29, -28, -26, -26, -24, -24, -23, -22, -21, -21, -19, -19, -18,
-17, -16, -16, -15, -15, -14, -13, -12, -12, -11, -10, -9, -9, -8, -8, -7, -7,
-6, -5, -5, -3, -3, -2, -1, 0, 0, 1, 3, 3, 4, 5, 5, 6, 6, 9, 8, 10, 11, 12, 12,
13, 14, 15, 16, 17, 17, 18, 20, 20, 21, 21, 21, 23, 23, 24, 25, 25, 26, 26, 26,
27, 27, 26, 27, 27, 27, 28, 27, 28, 27, 27, 26, 26, 27, 26, 26, 26, 26, 25, 24,
23, 24, 22, 21, 21, 20, 19, 19, 18, 17, 16, 15, 14, 13, 13, 11, 11, 10, 9, 8, 7,
7, 6, 5, 4, 3, 3, 2, 1, 2, 1, -1, 0, -2, -2, -3, -2, -3, -2, -4, -4, -3, -5, -4,
-5, -4, -4, -4, -4, -4, -3, -4, -4, -3, -3, -4, -2, -2, -1, -2, -2, -1, -1, 0,
0, 0, 1, 1, 1, 2, 2, 3, 2, 3, 3, 4, 3, 4, 3, 4, 4, 4, 4, 4, 4, 3, 4, 3, 3, 3, 3,
2, 1, 2, 0, 0, 0, 0, -1, -1, -1, -2, -3, -4, -4, -5, -5, -6, -7, -6, -7, -8, -9,
-10, -10, -10, -11, -11, -12, -12, -12, -13, -14, -14, -13, -14, -15, -13, -14,
-13, -14, -14, -14, -14, -13, -12, -13, -13, -12, -12, -11, -9, -9, -8, -9, -8,
-7, -6, -5, -5, -5, -3, -3, -2, 0, 1, 1, 2, 3, 3, 5, 5, 6, 7, 7, 8, 9, 10, 9, 9,
11, 11, 11, 11, 11, 11, 10, 11, 11, 11, 10, 9, 9, 9, 8, 7, 6, 5, 4, 4, 2, 1, 0,
-1, -2, -3, -5, -6, -9, -10, -12, -13, -15, -16, -17, -19, -21, -23, -24, -26,
-28, -29, -30, -32, -33, -34, -36, -38, -39, -39, -40, -41, -43, -42, -43, -43,
-44, -44, -44, -44, -44, -43, -43, -42, -42, -41, -40, -38, -38, -36, -34, -32,
-30, -28, -27, -24, -21, -19, -16, -13, -10, -7, -4, -1, };