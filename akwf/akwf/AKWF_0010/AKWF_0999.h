#define DATA_LENGTH 512
#define DATA AKWF_0999

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 1, 1, 1, 3, 1, 2, 2, 2, 1, 2,
2, 1, 1, 2, 2, 1, 2, 1, 2, 1, 2, 0, 3, -1, 4, -2, 7, -8, 32, 98, 84, 91, 87, 91,
89, 90, 90, 90, 91, 90, 91, 91, 93, 91, 93, 91, 93, 93, 94, 93, 95, 94, 96, 94,
96, 95, 96, 96, 97, 96, 97, 97, 98, 98, 99, 98, 99, 99, 99, 100, 100, 101, 100,
101, 101, 102, 102, 102, 102, 103, 103, 103, 104, 104, 105, 104, 105, 105, 106,
106, 106, 107, 107, 108, 108, 108, 109, 109, 109, 110, 110, 111, 111, 111, 112,
111, 113, 113, 113, 113, 114, 115, 115, 115, 116, 116, 117, 116, 117, 117, 118,
118, 118, 119, 119, 115, 114, 115, 115, 115, 114, 114, 114, 114, 114, 113, 112,
113, 113, 113, 112, 112, 111, 110, 111, 111, 110, 110, 110, 110, 109, 110, 109,
109, 108, 108, 108, 107, 107, 108, 107, 107, 107, 106, 106, 106, 106, 105, 105,
105, 105, 104, 105, 104, 103, 104, 104, 103, 103, 103, 102, 102, 102, 102, 102,
101, 101, 101, 101, 100, 101, 100, 100, 99, 99, 99, 98, 98, 98, 99, 98, 98, 98,
97, 97, 96, 96, 96, 96, 96, 96, 95, 95, 95, 94, 94, 95, 93, 94, 93, 94, 93, 92,
92, 93, 92, 91, 91, 92, 91, 91, 91, 90, 90, 90, 89, 89, 91, 89, 89, 88, 90, 88,
89, 86, 89, 85, 89, 84, 89, 83, 90, 80, 0, -3, 0, -2, 0, -2, -1, -2, -1, -2, -1,
-2, -1, -1, -1, -2, -1, -2, -1, -1, -1, -2, -1, -2, 0, -3, 1, -3, 2, -7, 9, -42,
-99, -83, -92, -87, -92, -89, -91, -90, -91, -91, -91, -92, -91, -92, -92, -93,
-93, -94, -93, -95, -94, -95, -94, -95, -95, -96, -95, -97, -97, -96, -98, -97,
-97, -97, -99, -98, -98, -100, -99, -100, -100, -100, -100, -101, -101, -102,
-102, -102, -102, -101, -103, -103, -103, -103, -104, -104, -104, -104, -104,
-105, -105, -105, -106, -106, -106, -106, -107, -107, -108, -108, -108, -109,
-108, -109, -109, -109, -110, -110, -110, -111, -111, -111, -112, -112, -111,
-112, -112, -113, -113, -114, -114, -115, -114, -115, -115, -116, -115, -115,
-114, -114, -114, -114, -114, -113, -114, -113, -112, -112, -112, -112, -112,
-111, -111, -111, -111, -111, -110, -109, -110, -110, -109, -109, -109, -108,
-109, -109, -108, -108, -107, -107, -107, -107, -107, -106, -106, -106, -106,
-105, -105, -105, -105, -105, -104, -104, -104, -104, -103, -103, -104, -102,
-103, -102, -103, -102, -101, -101, -101, -101, -100, -101, -100, -100, -100,
-100, -99, -99, -99, -98, -98, -98, -98, -97, -97, -97, -97, -97, -97, -96, -96,
-96, -95, -95, -95, -95, -95, -94, -93, -94, -94, -93, -92, -93, -93, -93, -92,
-91, -91, -92, -91, -92, -91, -91, -90, -90, -90, -90, -90, -89, -89, -89, -89,
-88, -89, -87, -89, -86, -89, -85, -89, -84, -89, -83, -91, -72, };