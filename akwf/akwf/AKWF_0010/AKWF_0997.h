#define DATA_LENGTH 512
#define DATA AKWF_0997

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 0, 1, 0, 0, 2, 1, 1, 1, 1, 1,
1, 1, 2, 1, 0, 1, 1, 1, 1, 1, 0, 1, 1, 1, 2, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1,
1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 2, 1, 2, 2, 0, 1,
1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 2, 1, 2, 1, 1, 1, 1, 2,
1, 1, 1, 1, 2, 0, 1, 1, 2, 1, 1, 1, 2, 1, 0, 1, 2, 1, 2, 1, 1, 1, 1, 1, 1, 1, 2,
1, 1, 1, 1, 1, 1, 1, 2, 1, 2, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0,
0, 1, 1, 1, 1, 1, 3, 4, 5, 6, 8, 9, 11, 13, 14, 15, 16, 18, 20, 20, 22, 24, 24,
27, 27, 29, 30, 31, 33, 34, 36, 37, 38, 40, 40, 42, 44, 45, 46, 48, 49, 51, 52,
53, 54, 56, 58, 59, 60, 62, 63, 64, 65, 68, 68, 70, 72, 73, 74, 75, 77, 78, 80,
81, 82, 83, 85, 86, 88, 90, 91, 92, 93, 95, 96, 98, 99, 100, 101, 103, 104, 105,
107, 108, 110, 111, 112, 114, 115, 117, 118, 120, 117, 117, 114, 114, 111, 111,
109, 108, 106, 105, 104, 101, 101, 98, 98, 95, 98, 88, 103, 35, -10, 6, -4, 3,
-2, 1, -1, 2, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 0,
1, 0, 1, 0, 1, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 1, -1, 1, 0, 0, 0, 0, 0, 1, -1, 0,
1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0,
1, 1, -1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0,
0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, -1, 1, 0, 0, 1,
0, 0, 0, 1, 0, 0, 0, 0, 0, -1, -3, -4, -6, -7, -9, -10, -11, -13, -14, -15, -16,
-17, -20, -21, -22, -24, -26, -27, -28, -29, -31, -32, -34, -34, -36, -38, -39,
-40, -42, -42, -44, -45, -47, -49, -51, -51, -52, -53, -55, -56, -57, -59, -61,
-62, -63, -65, -65, -67, -69, -70, -72, -73, -74, -76, -78, -78, -80, -81, -82,
-84, -85, -86, -88, -90, -91, -92, -93, -95, -96, -97, -98, -100, -101, -103,
-104, -106, -107, -108, -110, -111, -113, -114, -116, -117, -117, -117, -115,
-113, -112, -110, -109, -108, -108, -104, -105, -102, -102, -98, -99, -96, -97,
-92, -95, -89, -94, -85, -93, -73, };