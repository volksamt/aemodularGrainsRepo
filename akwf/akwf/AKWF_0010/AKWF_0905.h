#define DATA_LENGTH 512
#define DATA AKWF_0905

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 62, 100, 115, 120, 117, 113, 106,
100, 94, 90, 86, 84, 82, 80, 78, 76, 72, 69, 65, 61, 56, 50, 44, 37, 31, 23, 17,
11, 3, -4, -10, -18, -22, -27, -31, -34, -37, -40, -41, -42, -44, -45, -46, -46,
-47, -47, -47, -48, -49, -49, -50, -50, -50, -51, -50, -51, -52, -52, -52, -52,
-52, -53, -53, -54, -54, -54, -54, -54, -55, -55, -56, -55, -56, -56, -56, -56,
-57, -57, -58, -57, -58, -57, -59, -59, -59, -59, -59, -59, -60, -60, -60, -60,
-61, -61, -61, -61, -61, -62, -62, -63, -62, -62, -64, -63, -63, -63, -64, -64,
-64, -64, -64, -65, -65, -66, -65, -66, -65, -65, -66, -66, -67, -66, -66, -66,
-68, -67, -67, -67, -68, -67, -68, -68, -67, -68, -68, -69, -68, -68, -69, -68,
-69, -68, -69, -69, -69, -69, -70, -70, -69, -70, -70, -70, -70, -70, -70, -69,
-70, -70, -70, -69, -71, -69, -70, -70, -70, -70, -70, -71, -71, -69, -69, -70,
-70, -70, -70, -69, -70, -70, -70, -69, -69, -69, -69, -68, -69, -69, -68, -68,
-68, -68, -67, -67, -66, -66, -66, -65, -65, -65, -64, -63, -63, -62, -62, -60,
-60, -60, -58, -58, -56, -56, -54, -54, -53, -51, -49, -48, -46, -44, -42, -40,
-38, -35, -32, -30, -26, -22, -18, -13, -8, -1, 4, 12, 20, 27, 34, 39, 44, 48,
52, 56, 58, 60, 62, 63, 65, 66, 67, 67, 67, 67, 66, 67, 65, 62, 48, -8, -68,
-102, -116, -120, -117, -112, -106, -99, -94, -89, -87, -84, -82, -80, -78, -75,
-72, -69, -64, -60, -55, -49, -43, -36, -30, -23, -17, -9, -3, 4, 11, 17, 23,
27, 32, 35, 38, 39, 41, 42, 44, 45, 45, 47, 47, 48, 48, 49, 49, 49, 50, 50, 50,
50, 51, 51, 51, 52, 51, 52, 53, 54, 53, 53, 53, 55, 55, 54, 55, 55, 56, 56, 57,
56, 57, 56, 57, 57, 58, 58, 58, 58, 58, 59, 59, 59, 60, 60, 60, 61, 61, 61, 61,
61, 61, 61, 61, 62, 62, 63, 62, 63, 63, 63, 64, 63, 63, 64, 64, 65, 65, 64, 65,
65, 65, 65, 65, 66, 66, 66, 67, 66, 66, 67, 67, 67, 67, 67, 67, 67, 68, 67, 68,
67, 68, 68, 69, 68, 69, 69, 69, 69, 69, 69, 68, 69, 70, 69, 69, 70, 70, 69, 70,
70, 70, 70, 70, 70, 70, 71, 70, 71, 71, 70, 70, 70, 70, 70, 70, 70, 70, 70, 69,
70, 70, 70, 69, 70, 69, 69, 69, 69, 69, 68, 69, 69, 68, 67, 68, 67, 67, 67, 66,
66, 66, 66, 65, 64, 64, 64, 63, 62, 62, 61, 61, 60, 59, 58, 57, 55, 54, 54, 52,
51, 49, 48, 45, 45, 42, 40, 37, 35, 33, 29, 26, 21, 18, 12, 6, 1, -6, -13, -21,
-28, -34, -40, -44, -49, -52, -55, -57, -61, -62, -64, -64, -67, -66, -68, -67,
-67, -65, -67, -63, -62, -40, };