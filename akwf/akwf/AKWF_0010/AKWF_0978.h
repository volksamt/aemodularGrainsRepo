#define DATA_LENGTH 512
#define DATA AKWF_0978

const PROGMEM int8_t DATA[DATA_LENGTH] = {46, 54, 49, 53, 51, 56, 56, 60, 59,
63, 60, 61, 60, 61, 59, 59, 58, 58, 57, 58, 56, 57, 56, 57, 60, 62, 65, 67, 67,
69, 72, 74, 77, 77, 77, 79, 79, 79, 81, 81, 81, 81, 82, 81, 80, 81, 80, 80, 79,
79, 80, 82, 84, 87, 89, 90, 90, 90, 89, 89, 89, 88, 87, 87, 90, 89, 90, 90, 90,
91, 89, 87, 88, 88, 90, 92, 94, 95, 95, 94, 94, 93, 92, 91, 90, 89, 89, 89, 89,
89, 88, 86, 84, 83, 83, 85, 87, 89, 90, 91, 95, 97, 99, 100, 101, 102, 103, 106,
109, 113, 115, 117, 118, 118, 118, 117, 115, 114, 113, 114, 115, 114, 112, 112,
111, 109, 108, 106, 106, 107, 106, 106, 108, 106, 107, 107, 108, 108, 108, 108,
107, 107, 105, 102, 98, 98, 96, 95, 95, 95, 95, 95, 95, 94, 94, 93, 92, 91, 90,
90, 88, 87, 85, 85, 85, 87, 88, 91, 92, 94, 94, 95, 96, 96, 97, 96, 96, 97, 99,
99, 101, 100, 102, 101, 101, 101, 100, 99, 98, 96, 96, 95, 95, 96, 95, 95, 95,
98, 96, 98, 97, 99, 99, 102, 100, 102, 99, 102, 100, 102, 99, 100, 100, 99, 101,
100, 106, 99, 120, 8, -44, -22, -35, -25, -34, -29, -35, -31, -35, -30, -32,
-30, -32, -30, -31, -32, -33, -35, -34, -36, -34, -35, -36, -36, -36, -35, -32,
-32, -33, -34, -34, -34, -33, -34, -33, -33, -33, -34, -35, -37, -39, -40, -41,
-41, -42, -40, -40, -39, -38, -36, -35, -34, -34, -34, -34, -34, -35, -36, -36,
-38, -36, -34, -34, -33, -33, -35, -35, -35, -35, -35, -35, -35, -35, -34, -37,
-42, -44, -47, -49, -50, -49, -50, -51, -51, -50, -49, -48, -46, -44, -42, -39,
-37, -34, -33, -33, -35, -39, -42, -46, -48, -51, -52, -55, -58, -62, -63, -64,
-66, -69, -71, -71, -72, -72, -72, -72, -72, -73, -75, -76, -76, -76, -76, -76,
-77, -77, -76, -76, -75, -74, -73, -70, -69, -67, -65, -64, -63, -63, -61, -60,
-60, -60, -60, -57, -55, -53, -52, -51, -49, -47, -46, -45, -43, -44, -42, -42,
-41, -42, -42, -42, -44, -45, -45, -46, -46, -46, -45, -46, -46, -45, -46, -47,
-47, -49, -50, -53, -55, -57, -56, -57, -59, -61, -62, -63, -65, -65, -68, -70,
-71, -72, -74, -73, -74, -75, -76, -76, -77, -78, -77, -78, -79, -80, -82, -85,
-86, -86, -85, -84, -84, -81, -81, -81, -79, -78, -78, -79, -79, -78, -79, -80,
-80, -81, -79, -80, -80, -81, -81, -80, -80, -81, -80, -79, -76, -77, -75, -74,
-73, -74, -76, -76, -77, -77, -77, -77, -79, -80, -82, -81, -82, -81, -82, -83,
-85, -86, -86, -86, -87, -86, -86, -86, -85, -85, -81, -80, -77, -78, -75, -79,
-73, -83, -61, -18, -26, -22, -24, -22, -24, -23, -24, -25, -25, -28, -28, -29,
-27, -30, -28, -30, -28, -30, -28, -32, -26, };