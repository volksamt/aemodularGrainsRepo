#define DATA_LENGTH 512
#define DATA AKWF_0932

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 10, 15, 20, 25, 30, 35, 40, 44,
49, 53, 58, 63, 67, 70, 75, 78, 83, 85, 88, 93, 95, 98, 101, 103, 105, 108, 109,
112, 113, 114, 116, 117, 117, 118, 118, 120, 119, 119, 118, 118, 118, 116, 117,
115, 114, 112, 111, 110, 108, 106, 105, 103, 100, 98, 96, 94, 91, 89, 86, 83,
80, 78, 75, 73, 69, 66, 64, 61, 58, 56, 52, 49, 48, 44, 41, 39, 36, 33, 31, 29,
26, 24, 21, 19, 16, 15, 13, 11, 9, 6, 5, 3, 1, -1, -2, -4, -5, -6, -8, -9, -9,
-11, -12, -13, -14, -14, -15, -15, -16, -17, -16, -18, -17, -17, -17, -18, -17,
-17, -17, -17, -16, -16, -15, -15, -14, -14, -13, -13, -13, -11, -10, -10, -9,
-8, -7, -6, -6, -5, -2, -2, -1, 1, 2, 2, 4, 5, 7, 8, 8, 10, 11, 12, 13, 15, 16,
17, 17, 19, 20, 21, 22, 22, 23, 25, 25, 25, 26, 26, 28, 27, 28, 29, 28, 28, 28,
28, 28, 28, 27, 27, 26, 26, 25, 25, 24, 23, 23, 21, 20, 19, 17, 17, 16, 15, 12,
12, 11, 9, 8, 6, 5, 3, 1, 0, -2, -2, -5, -5, -7, -8, -10, -11, -12, -14, -14,
-16, -17, -18, -19, -19, -20, -22, -21, -22, -23, -23, -24, -24, -24, -25, -24,
-24, -23, -23, -23, -22, -22, -20, -20, -18, -17, -17, -16, -15, -13, -13, -11,
-9, -8, -7, -6, -4, -3, -1, 0, 2, 3, 4, 6, 8, 9, 10, 12, 12, 14, 15, 16, 18, 17,
19, 20, 21, 21, 22, 22, 23, 23, 24, 24, 24, 24, 23, 24, 24, 23, 22, 22, 21, 21,
20, 19, 18, 17, 16, 15, 13, 12, 10, 10, 8, 7, 5, 5, 3, 1, 0, -2, -4, -5, -6, -8,
-9, -11, -12, -14, -15, -16, -17, -18, -19, -21, -22, -23, -23, -23, -24, -26,
-26, -26, -27, -27, -27, -28, -28, -28, -28, -28, -28, -28, -28, -28, -26, -26,
-25, -25, -24, -23, -23, -22, -21, -20, -18, -17, -16, -15, -15, -14, -12, -12,
-11, -9, -7, -7, -5, -3, -3, -1, 0, 1, 1, 3, 4, 6, 7, 7, 8, 10, 10, 11, 11, 13,
13, 14, 14, 14, 15, 16, 16, 17, 17, 17, 17, 18, 17, 17, 17, 17, 17, 17, 16, 16,
15, 14, 14, 13, 13, 12, 11, 10, 8, 7, 5, 5, 4, 1, 1, -2, -3, -5, -8, -9, -11,
-13, -15, -17, -20, -22, -24, -26, -29, -32, -33, -38, -40, -42, -44, -48, -51,
-53, -55, -59, -62, -65, -67, -70, -72, -76, -78, -81, -84, -86, -89, -91, -94,
-96, -98, -101, -103, -105, -107, -109, -109, -112, -113, -114, -116, -116,
-117, -118, -119, -119, -119, -118, -119, -118, -118, -117, -116, -116, -113,
-112, -111, -108, -106, -105, -103, -100, -97, -95, -91, -88, -85, -82, -77,
-73, -70, -66, -61, -58, -52, -49, -43, -38, -33, -29, -24, -18, -14, -9, -4, };