#define DATA_LENGTH 512
#define DATA AKWF_0926

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 8, 15, 22, 29, 37, 43, 50, 56, 62,
67, 74, 79, 83, 88, 92, 96, 100, 102, 106, 108, 111, 112, 115, 116, 117, 118,
118, 119, 120, 120, 119, 119, 118, 117, 118, 117, 116, 115, 114, 113, 112, 111,
109, 108, 107, 106, 105, 103, 102, 101, 98, 97, 96, 94, 93, 90, 89, 87, 86, 84,
82, 80, 78, 76, 75, 72, 71, 68, 67, 65, 63, 61, 59, 57, 54, 53, 51, 49, 48, 44,
43, 41, 40, 39, 36, 35, 34, 33, 31, 29, 28, 27, 25, 24, 24, 21, 21, 19, 18, 17,
16, 14, 13, 12, 11, 10, 8, 7, 7, 5, 4, 3, 2, 1, 1, -1, -2, -3, -3, -4, -4, -5,
-5, -7, -6, -7, -7, -8, -8, -7, -8, -8, -9, -9, -9, -9, -10, -10, -10, -10, -12,
-12, -11, -12, -13, -11, -12, -13, -14, -12, -14, -14, -14, -13, -14, -14, -14,
-14, -13, -14, -14, -13, -13, -13, -14, -14, -14, -14, -15, -15, -15, -14, -16,
-16, -16, -17, -17, -18, -19, -20, -20, -21, -22, -22, -24, -25, -26, -27, -28,
-29, -30, -31, -33, -33, -34, -36, -36, -38, -39, -40, -40, -42, -43, -44, -46,
-47, -49, -50, -52, -53, -55, -56, -58, -59, -60, -61, -62, -64, -66, -67, -69,
-70, -71, -73, -73, -74, -75, -76, -78, -78, -78, -78, -77, -76, -77, -76, -75,
-73, -71, -69, -67, -65, -61, -58, -54, -49, -46, -42, -37, -33, -26, -21, -16,
-10, -5, 0, 6, 12, 18, 23, 28, 33, 38, 42, 47, 51, 55, 58, 62, 65, 67, 70, 72,
73, 75, 76, 76, 77, 77, 77, 77, 77, 76, 77, 76, 75, 73, 72, 71, 70, 69, 67, 66,
64, 63, 61, 60, 58, 56, 55, 54, 53, 51, 50, 48, 47, 46, 45, 43, 42, 41, 39, 38,
38, 36, 35, 34, 32, 32, 31, 30, 29, 28, 27, 26, 24, 24, 23, 21, 21, 20, 20, 19,
17, 17, 17, 16, 15, 15, 15, 14, 14, 14, 13, 13, 14, 14, 13, 13, 14, 14, 14, 14,
15, 15, 14, 13, 14, 14, 14, 14, 13, 13, 13, 12, 12, 13, 11, 11, 10, 10, 10, 10,
10, 10, 9, 9, 9, 8, 9, 9, 8, 8, 7, 7, 7, 7, 7, 6, 4, 4, 4, 3, 2, 2, 1, -1, -1,
-2, -3, -4, -6, -6, -8, -9, -9, -11, -13, -14, -16, -15, -17, -19, -20, -21,
-21, -23, -25, -26, -27, -28, -30, -31, -33, -35, -35, -36, -39, -40, -42, -44,
-46, -47, -49, -51, -53, -55, -57, -59, -61, -63, -66, -68, -69, -71, -72, -75,
-78, -79, -81, -83, -84, -86, -88, -89, -91, -92, -94, -95, -97, -98, -100,
-102, -103, -104, -107, -108, -108, -109, -111, -112, -113, -113, -116, -116,
-116, -117, -118, -118, -119, -118, -119, -119, -119, -118, -117, -116, -115,
-114, -112, -110, -109, -105, -102, -100, -95, -91, -87, -83, -77, -72, -67,
-61, -55, -48, -42, -34, -28, -21, -13, -5, };