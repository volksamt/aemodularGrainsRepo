#define DATA_LENGTH 512
#define DATA AKWF_0949

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 10, 14, 18, 23, 27, 31, 34, 37,
40, 43, 46, 48, 51, 54, 55, 58, 60, 62, 63, 65, 67, 68, 70, 71, 72, 73, 75, 75,
77, 77, 79, 79, 80, 80, 81, 82, 82, 83, 83, 84, 84, 85, 86, 85, 86, 87, 87, 87,
87, 88, 88, 88, 89, 89, 88, 89, 89, 90, 89, 90, 91, 90, 90, 90, 91, 91, 90, 92,
91, 90, 91, 91, 91, 91, 91, 92, 91, 91, 92, 92, 92, 92, 92, 92, 92, 92, 93, 92,
92, 92, 92, 93, 92, 92, 92, 93, 92, 93, 93, 92, 92, 92, 93, 92, 92, 93, 93, 92,
92, 92, 92, 93, 92, 92, 92, 92, 93, 92, 93, 92, 92, 91, 91, 93, 92, 91, 91, 77,
74, 76, 67, 62, 58, 54, 51, 48, 45, 40, 37, 32, 27, 23, 18, 15, 10, 8, 2, -12,
-13, -19, -26, -32, -38, -41, -45, -49, -54, -58, -63, -67, -72, -76, -81, -84,
-89, -91, -96, -98, -102, -99, -87, -93, -92, -86, -84, -82, -81, -79, -79, -76,
-73, -70, -67, -63, -61, -58, -55, -52, -49, -46, -44, -42, -40, -37, -35, -34,
-31, -30, -29, -27, -26, -25, -23, -23, -21, -21, -19, -19, -18, -16, -16, -15,
-15, -14, -13, -12, -13, -11, -12, -11, -11, -10, -10, -9, -9, -9, -8, -8, -8,
-7, -7, -7, -6, -7, -6, -7, -6, -6, -5, -5, -6, -6, -5, -5, -5, -5, -4, -4, -5,
-4, -5, -5, -5, -5, -4, -5, -3, -4, -4, -4, -4, -4, -5, -4, -4, -3, -3, -4, -4,
-4, -4, -4, -3, -4, -3, -3, -3, -4, -3, -3, -3, -3, -4, -4, -4, -4, -4, -4, -4,
-4, -4, -3, -4, -5, -3, -4, -4, -4, -4, -3, -4, -3, -4, -4, -3, -4, -4, -4, -4,
-4, -5, -4, -4, -3, -3, -4, -4, -5, -4, -4, -3, -4, -4, -4, -4, -4, -4, -4, -4,
-3, -4, -4, -3, -4, -4, -3, -3, -4, -3, -4, -4, -3, -4, -3, -3, -3, -4, -4, -4,
-4, -3, -3, -3, -3, -3, -3, -3, -4, -4, -4, -3, -3, -3, -3, -4, -4, -4, -4, -4,
-3, -4, -4, -4, -3, -4, -3, -3, -3, -4, -4, -3, -3, -4, -3, -3, -4, -3, -4, -3,
-4, -3, -4, -4, -3, -4, -4, -4, -4, -3, -3, -3, -4, -4, -3, -4, -3, -3, -4, -4,
-3, -4, -3, -3, -4, -4, -3, -4, -3, -3, -4, -3, -3, -3, -3, -4, -3, -4, -3, -3,
-4, -4, -3, -4, -3, -4, -3, -10, -22, -19, -23, -30, -36, -39, -42, -46, -48,
-52, -56, -61, -66, -69, -73, -78, -82, -85, -90, -93, -96, -100, -103, -105,
-108, -110, -112, -115, -117, -119, -120, -114, -112, -113, -110, -108, -107,
-106, -106, -105, -103, -101, -100, -98, -95, -94, -91, -89, -87, -85, -84, -82,
-81, -79, -78, -77, -75, -72, -75, -63, -52, -54, -47, -39, -34, -30, -27, -23,
-20, -14, -10, -6, 0, };