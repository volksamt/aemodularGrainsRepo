#define DATA_LENGTH 512
#define DATA AKWF_0911

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 2, 6, 8, 11, 14, 16, 20, 23, 25,
27, 30, 34, 36, 39, 41, 45, 46, 50, 53, 54, 58, 60, 63, 66, 68, 71, 73, 76, 78,
81, 84, 86, 87, 89, 92, 94, 96, 97, 99, 100, 102, 103, 104, 106, 106, 107, 108,
109, 109, 110, 110, 110, 111, 111, 112, 112, 112, 111, 111, 112, 112, 111, 110,
110, 110, 109, 109, 108, 107, 107, 106, 106, 105, 104, 102, 102, 100, 99, 98,
97, 97, 94, 94, 92, 91, 88, 87, 85, 83, 82, 81, 80, 78, 77, 76, 75, 74, 71, 70,
69, 69, 68, 67, 67, 66, 66, 64, 64, 64, 63, 64, 64, 63, 64, 64, 64, 64, 65, 65,
66, 65, 67, 68, 68, 68, 70, 71, 72, 72, 73, 74, 75, 76, 78, 79, 81, 81, 83, 84,
85, 86, 88, 90, 91, 94, 95, 96, 97, 99, 101, 103, 105, 106, 107, 109, 109, 106,
103, 102, 102, 102, 100, 100, 97, 96, 95, 92, 90, 88, 85, 83, 79, 77, 75, 72,
69, 67, 64, 61, 60, 61, 61, 58, 57, 56, 55, 52, 52, 51, 49, 48, 48, 47, 45, 45,
44, 43, 42, 41, 39, 37, 37, 34, 33, 31, 29, 27, 26, 23, 21, 19, 17, 15, 12, 10,
7, 5, 3, -1, -4, -7, -10, -13, -15, -18, -21, -25, -28, -32, -35, -37, -40, -42,
-46, -49, -51, -53, -56, -59, -61, -63, -65, -67, -69, -70, -72, -73, -74, -76,
-78, -78, -80, -80, -81, -82, -82, -82, -83, -83, -84, -83, -84, -84, -84, -84,
-83, -83, -83, -83, -82, -82, -82, -81, -81, -79, -78, -78, -77, -76, -75, -74,
-74, -72, -72, -70, -69, -69, -67, -65, -65, -62, -61, -60, -59, -57, -56, -54,
-54, -51, -50, -48, -47, -46, -44, -42, -40, -39, -39, -37, -36, -35, -33, -32,
-31, -29, -29, -27, -26, -25, -25, -23, -23, -21, -20, -20, -19, -17, -18, -16,
-16, -15, -14, -14, -13, -12, -12, -12, -11, -10, -9, -9, -9, -9, -8, -7, -7,
-7, -6, -7, -6, -5, -4, -5, -4, -4, -4, -5, -4, -3, -3, -3, -5, -3, -5, -4, -5,
-5, -5, -6, -6, -7, -9, -8, -9, -10, -10, -12, -13, -15, -16, -15, -17, -19,
-19, -21, -21, -23, -24, -26, -28, -28, -30, -32, -34, -35, -36, -38, -39, -41,
-43, -44, -46, -48, -50, -51, -52, -54, -57, -58, -60, -63, -64, -66, -69, -71,
-72, -74, -76, -78, -80, -82, -84, -86, -88, -90, -92, -94, -96, -98, -100,
-101, -103, -105, -106, -107, -109, -110, -111, -113, -113, -114, -115, -116,
-117, -118, -118, -118, -118, -119, -119, -119, -119, -118, -118, -119, -118,
-119, -118, -118, -118, -116, -117, -116, -115, -114, -114, -112, -109, -105,
-103, -102, -100, -99, -97, -94, -92, -89, -88, -86, -85, -81, -79, -76, -75,
-72, -69, -67, -65, -61, -59, -58, -54, -52, -49, -46, -44, -42, -39, -35, -33,
-30, -28, -25, -23, -20, -17, -14, -11, -8, -6, -3, };