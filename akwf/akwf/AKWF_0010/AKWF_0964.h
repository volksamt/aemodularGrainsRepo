#define DATA_LENGTH 512
#define DATA AKWF_0964

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 5, 6, 8, 10, 11, 14, 14, 17,
18, 19, 21, 22, 23, 25, 26, 27, 29, 30, 31, 32, 33, 34, 36, 36, 37, 38, 40, 40,
41, 43, 43, 45, 45, 46, 47, 47, 48, 48, 50, 50, 51, 52, 53, 52, 53, 54, 54, 55,
56, 55, 56, 57, 57, 57, 58, 58, 59, 59, 59, 60, 61, 61, 60, 61, 61, 62, 62, 62,
63, 64, 64, 64, 64, 64, 65, 65, 65, 65, 66, 66, 66, 67, 67, 67, 67, 68, 69, 69,
69, 69, 70, 71, 71, 72, 72, 72, 72, 72, 74, 74, 74, 74, 75, 75, 77, 77, 78, 79,
78, 80, 80, 81, 81, 82, 82, 83, 84, 85, 86, 87, 87, 89, 89, 90, 90, 92, 92, 94,
94, 95, 96, 96, 98, 99, 100, 101, 102, 103, 105, 106, 107, 107, 109, 109, 110,
110, 111, 111, 111, 111, 111, 111, 111, 111, 111, 110, 111, 111, 111, 111, 110,
110, 110, 110, 110, 109, 109, 108, 107, 107, 107, 107, 105, 104, 104, 103, 102,
101, 100, 98, 98, 96, 95, 94, 94, 92, 91, 89, 88, 86, 85, 84, 82, 80, 78, 76,
75, 73, 72, 70, 68, 66, 65, 64, 61, 60, 58, 56, 55, 52, 50, 48, 47, 45, 43, 40,
40, 37, 35, 33, 32, 30, 28, 26, 24, 22, 20, 19, 17, 15, 13, 11, 10, 8, 6, 3, 3,
2, -1, -2, -4, -6, -7, -9, -11, -12, -13, -15, -16, -17, -19, -20, -21, -23,
-23, -26, -26, -27, -29, -30, -31, -32, -34, -35, -36, -36, -36, -38, -38, -39,
-40, -42, -42, -43, -44, -44, -45, -46, -46, -47, -47, -48, -48, -49, -50, -50,
-51, -50, -51, -51, -53, -53, -53, -53, -53, -54, -55, -55, -54, -55, -56, -56,
-56, -56, -57, -56, -58, -58, -57, -58, -58, -58, -58, -59, -59, -59, -59, -59,
-59, -59, -59, -60, -59, -60, -60, -60, -61, -61, -60, -61, -61, -62, -62, -62,
-63, -62, -64, -63, -63, -63, -63, -64, -65, -65, -65, -65, -66, -66, -66, -67,
-67, -68, -68, -68, -70, -70, -70, -70, -71, -72, -71, -72, -73, -73, -74, -75,
-76, -76, -77, -78, -78, -79, -80, -79, -80, -81, -82, -83, -83, -84, -86, -86,
-87, -87, -88, -88, -90, -91, -92, -93, -95, -94, -96, -97, -98, -99, -100,
-101, -102, -103, -105, -105, -106, -107, -108, -109, -111, -111, -113, -114,
-115, -116, -116, -117, -118, -118, -118, -118, -118, -119, -118, -119, -119,
-119, -120, -119, -119, -118, -119, -118, -119, -118, -118, -117, -117, -117,
-116, -115, -115, -114, -114, -113, -111, -111, -111, -109, -109, -107, -106,
-106, -104, -102, -101, -101, -100, -97, -96, -95, -93, -91, -91, -87, -87, -85,
-83, -82, -80, -78, -77, -74, -73, -71, -69, -67, -65, -63, -61, -59, -58, -55,
-53, -52, -49, -47, -46, -44, -41, -39, -37, -35, -33, -31, -30, -27, -25, -24,
-22, -20, -18, -17, -14, -12, -11, -9, -7, -6, -1, 0, -1, };