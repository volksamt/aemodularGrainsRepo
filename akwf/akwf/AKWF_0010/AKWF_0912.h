#define DATA_LENGTH 512
#define DATA AKWF_0912

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 12, 16, 20, 24, 29, 32, 36, 40,
43, 48, 50, 54, 57, 60, 63, 66, 69, 72, 73, 76, 79, 81, 83, 84, 86, 87, 89, 90,
90, 91, 92, 91, 91, 90, 89, 90, 88, 88, 87, 85, 82, 82, 80, 77, 76, 74, 71, 69,
66, 64, 62, 58, 56, 53, 51, 49, 45, 44, 41, 38, 36, 33, 31, 30, 27, 26, 24, 22,
21, 19, 17, 16, 15, 14, 13, 12, 12, 10, 10, 9, 9, 9, 9, 8, 8, 9, 8, 9, 9, 9, 9,
10, 10, 11, 11, 12, 13, 14, 14, 17, 17, 18, 20, 20, 22, 23, 24, 25, 27, 29, 30,
31, 33, 34, 36, 37, 38, 39, 40, 42, 42, 43, 44, 45, 45, 45, 46, 47, 46, 46, 46,
46, 46, 46, 44, 44, 44, 43, 41, 40, 39, 38, 36, 35, 33, 30, 28, 24, 21, 19, 15,
12, 9, 6, 2, -1, -5, -7, -11, -15, -18, -20, -24, -26, -29, -31, -34, -36, -37,
-39, -40, -41, -42, -43, -44, -45, -44, -46, -46, -46, -46, -46, -47, -47, -47,
-49, -49, -51, -53, -53, -55, -57, -59, -61, -64, -66, -69, -71, -75, -78, -81,
-85, -88, -91, -94, -97, -100, -103, -106, -108, -111, -113, -115, -117, -117,
-119, -118, -119, -119, -119, -119, -116, -116, -115, -113, -111, -108, -105,
-103, -101, -98, -94, -91, -87, -83, -79, -76, -71, -68, -64, -59, -54, -51,
-46, -42, -37, -33, -27, -23, -19, -15, -10, -6, 0, 4, 8, 13, 17, 21, 25, 29,
33, 37, 40, 44, 47, 51, 54, 58, 61, 64, 66, 70, 71, 75, 76, 78, 81, 83, 84, 86,
88, 89, 89, 90, 91, 91, 91, 91, 91, 90, 90, 89, 87, 86, 84, 83, 81, 80, 78, 75,
72, 70, 69, 66, 64, 61, 58, 56, 53, 50, 47, 46, 43, 40, 38, 35, 33, 31, 30, 28,
26, 24, 22, 21, 20, 17, 16, 15, 14, 13, 12, 12, 11, 10, 10, 10, 8, 8, 9, 8, 8,
8, 8, 8, 8, 10, 9, 11, 11, 11, 12, 13, 14, 14, 16, 16, 19, 19, 20, 22, 23, 25,
26, 28, 29, 30, 32, 33, 35, 37, 37, 38, 39, 40, 42, 42, 43, 44, 45, 45, 46, 46,
46, 46, 47, 47, 46, 46, 45, 45, 45, 44, 43, 42, 40, 40, 38, 36, 34, 32, 30, 27,
24, 22, 19, 16, 12, 8, 6, 2, -2, -6, -8, -12, -15, -18, -21, -24, -27, -29, -31,
-33, -35, -38, -40, -40, -41, -42, -43, -44, -45, -44, -45, -46, -46, -47, -46,
-47, -48, -48, -49, -50, -52, -53, -54, -55, -57, -59, -61, -64, -67, -70, -73,
-74, -79, -81, -84, -87, -91, -94, -98, -100, -103, -105, -109, -111, -114,
-114, -116, -118, -119, -119, -119, -120, -119, -118, -117, -116, -114, -112,
-110, -108, -105, -104, -100, -97, -93, -91, -86, -83, -79, -76, -71, -67, -63,
-58, -55, -50, -45, -41, -37, -31, -27, -23, -19, -14, -9, -5, 0, };