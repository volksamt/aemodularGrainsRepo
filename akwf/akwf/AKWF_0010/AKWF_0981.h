#define DATA_LENGTH 512
#define DATA AKWF_0981

const PROGMEM int8_t DATA[DATA_LENGTH] = {16, 43, 65, 83, 95, 100, 100, 93, 84,
73, 61, 49, 37, 23, 11, 0, -8, -14, -18, -21, -24, -24, -22, -20, -18, -14, -11,
-9, -7, -8, -9, -9, -9, -8, -7, -3, 0, 3, 7, 11, 13, 15, 14, 14, 13, 9, 7, 2,
-3, -6, -10, -10, -9, -9, -9, -9, -11, -9, -8, -8, -6, -4, -1, -3, -4, -7, -11,
-12, -12, -10, -7, -3, 1, 5, 11, 17, 20, 23, 26, 28, 27, 27, 27, 26, 20, 12, 2,
-10, -19, -27, -34, -38, -41, -42, -40, -38, -33, -29, -27, -22, -18, -11, -5,
2, 7, 13, 17, 20, 22, 24, 25, 26, 25, 25, 25, 26, 26, 25, 23, 22, 19, 18, 16,
16, 14, 12, 11, 10, 8, 8, 4, 1, -3, -4, -5, -5, -7, -7, -8, -8, -7, -8, -8, -8,
-8, -11, -12, -15, -17, -19, -21, -22, -22, -20, -17, -14, -13, -12, -11, -10,
-10, -9, -8, -9, -10, -11, -11, -10, -6, -3, 1, 5, 9, 14, 17, 19, 20, 18, 16,
14, 9, 6, 2, -3, -6, -9, -12, -13, -13, -10, -8, -7, -4, -3, 1, 6, 12, 17, 22,
26, 30, 31, 32, 30, 27, 19, 11, 4, -3, -9, -13, -15, -18, -18, -17, -17, -15,
-15, -12, -9, -5, 0, 3, 5, 5, 7, 6, 5, 5, 4, 2, 1, -1, -3, -6, -9, -12, -14,
-13, -13, -12, -12, -11, -9, -7, -3, 1, 6, 10, 14, 18, 22, 25, 26, 26, 25, 21,
16, 9, 3, -4, -9, -12, -16, -18, -20, -22, -23, -24, -23, -21, -17, -13, -8, -3,
2, 6, 8, 11, 12, 13, 12, 11, 6, 3, 1, 2, 2, 4, 6, 7, 10, 12, 12, 11, 10, 8, 6,
3, -2, -7, -11, -15, -17, -18, -16, -12, -3, 5, 15, 20, 26, 29, 32, 33, 32, 28,
23, 15, 9, 1, -5, -11, -16, -21, -25, -28, -30, -31, -29, -27, -24, -19, -13,
-4, 3, 8, 12, 12, 8, 5, 1, -3, -6, -9, -10, -9, -8, -5, -3, 0, 2, 5, 5, 7, 7, 6,
5, 3, 1, -1, -4, -6, -7, -10, -11, -12, -13, -12, -9, -6, -2, 2, 5, 7, 10, 12,
14, 15, 15, 14, 14, 15, 17, 19, 20, 22, 20, 19, 18, 19, 18, 19, 19, 16, 13, 8,
0, -9, -20, -29, -36, -40, -41, -41, -41, -39, -35, -30, -25, -18, -11, -3, 5,
11, 17, 21, 25, 28, 30, 29, 28, 24, 19, 11, 3, -5, -14, -19, -22, -24, -25, -23,
-22, -19, -17, -14, -10, -6, -2, -1, 0, 0, -2, -5, -5, -3, -2, 2, 7, 13, 17, 21,
22, 23, 22, 19, 13, 7, 2, 0, -2, -4, -6, -6, -5, -2, -2, -1, -1, -2, -6, -10,
-13, -16, -16, -17, -15, -15, -12, -9, -5, 0, 4, 8, 10, 14, 16, 17, 21, 24, 26,
26, 24, 22, 19, 15, 11, 8, 4, 1, -33, -90, -117, -119, -112, -102, -91, -76,
-56, -32, -6, };