#define DATA_LENGTH 512
#define DATA AKWF_0937

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 11, 21, 30, 40, 47, 53, 59, 65, 68,
72, 75, 78, 82, 84, 85, 86, 87, 90, 91, 93, 94, 96, 97, 97, 99, 100, 103, 104,
106, 108, 109, 111, 113, 114, 115, 115, 117, 117, 118, 118, 118, 119, 119, 119,
119, 119, 119, 118, 117, 117, 116, 115, 115, 114, 114, 114, 112, 112, 112, 112,
111, 111, 110, 109, 110, 109, 109, 108, 108, 107, 105, 104, 102, 101, 99, 98,
96, 93, 91, 89, 86, 84, 82, 78, 76, 73, 71, 70, 67, 66, 64, 62, 62, 60, 59, 58,
58, 56, 54, 53, 51, 49, 47, 43, 40, 36, 32, 27, 23, 17, 12, 5, -1, -5, -11, -16,
-18, -21, -24, -26, -27, -28, -28, -28, -28, -27, -26, -25, -23, -22, -21, -19,
-18, -18, -17, -18, -18, -20, -22, -23, -25, -27, -29, -31, -35, -37, -38, -40,
-42, -43, -44, -44, -44, -44, -44, -42, -40, -39, -36, -34, -32, -29, -27, -23,
-22, -19, -18, -16, -15, -14, -14, -14, -14, -14, -16, -16, -18, -19, -19, -21,
-22, -22, -22, -22, -23, -22, -20, -19, -19, -16, -16, -14, -12, -11, -10, -8,
-8, -7, -6, -7, -8, -8, -10, -11, -14, -15, -17, -18, -21, -23, -25, -25, -26,
-27, -27, -26, -25, -25, -24, -22, -21, -19, -17, -15, -13, -11, -10, -8, -7,
-8, -6, -7, -8, -10, -11, -12, -15, -17, -18, -21, -23, -24, -25, -26, -26, -27,
-26, -25, -24, -21, -19, -16, -12, -8, -4, 1, 5, 9, 13, 17, 20, 22, 24, 26, 26,
27, 26, 27, 25, 24, 22, 20, 18, 16, 14, 12, 11, 9, 8, 7, 6, 7, 8, 9, 11, 12, 13,
16, 17, 19, 21, 22, 24, 25, 25, 26, 27, 27, 25, 24, 23, 22, 20, 19, 17, 14, 13,
11, 9, 9, 8, 7, 7, 7, 7, 9, 9, 11, 12, 14, 15, 17, 19, 20, 21, 22, 22, 23, 22,
22, 21, 21, 20, 19, 17, 16, 16, 14, 14, 14, 13, 15, 15, 16, 18, 20, 21, 24, 27,
29, 32, 34, 36, 39, 40, 42, 44, 44, 44, 44, 44, 43, 42, 40, 38, 36, 34, 31, 29,
27, 25, 22, 21, 19, 19, 18, 17, 18, 18, 20, 21, 22, 24, 24, 26, 27, 29, 29, 29,
28, 28, 26, 24, 21, 18, 14, 9, 4, -2, -7, -14, -18, -24, -29, -33, -37, -42,
-44, -47, -49, -52, -53, -55, -56, -58, -59, -60, -61, -61, -63, -65, -66, -67,
-69, -71, -75, -76, -79, -81, -85, -87, -90, -91, -95, -96, -97, -100, -102,
-102, -104, -106, -106, -107, -107, -109, -109, -110, -110, -110, -111, -111,
-112, -112, -112, -112, -113, -114, -114, -115, -116, -116, -117, -118, -118,
-119, -118, -118, -119, -120, -119, -118, -119, -117, -117, -117, -115, -115,
-112, -112, -110, -109, -107, -106, -104, -102, -100, -99, -98, -97, -95, -94,
-92, -91, -89, -88, -86, -85, -83, -80, -78, -75, -72, -68, -63, -58, -51, -44,
-38, -28, -19, -8, };