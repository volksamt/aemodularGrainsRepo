#define DATA_LENGTH 512
#define DATA AKWF_0924

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 10, 13, 17, 20, 24, 28, 31, 35,
40, 44, 47, 50, 54, 58, 61, 66, 69, 72, 76, 79, 83, 85, 89, 92, 94, 96, 99, 102,
103, 106, 108, 110, 111, 113, 114, 115, 116, 117, 118, 119, 119, 118, 119, 119,
119, 118, 118, 117, 117, 115, 113, 114, 112, 110, 108, 106, 104, 102, 101, 98,
95, 93, 91, 88, 85, 83, 80, 79, 75, 73, 70, 67, 64, 61, 58, 56, 53, 50, 47, 45,
42, 39, 37, 34, 31, 29, 27, 24, 22, 20, 17, 15, 13, 11, 9, 7, 5, 3, 2, 1, -1,
-2, -3, -6, -7, -8, -9, -11, -11, -12, -13, -14, -15, -15, -17, -17, -18, -18,
-20, -20, -20, -20, -21, -21, -21, -22, -23, -23, -22, -24, -23, -24, -23, -24,
-24, -24, -24, -24, -24, -25, -25, -24, -25, -25, -24, -24, -25, -24, -25, -25,
-24, -25, -23, -23, -23, -24, -24, -24, -24, -24, -24, -23, -24, -24, -24, -24,
-24, -24, -23, -24, -24, -24, -24, -24, -23, -24, -24, -25, -25, -25, -25, -26,
-26, -27, -27, -27, -28, -28, -29, -29, -30, -31, -32, -33, -33, -35, -36, -36,
-38, -38, -39, -40, -42, -42, -43, -45, -45, -46, -47, -48, -50, -50, -52, -53,
-54, -55, -55, -56, -57, -57, -59, -59, -59, -60, -60, -60, -60, -61, -61, -61,
-61, -60, -60, -60, -59, -59, -58, -57, -56, -55, -54, -53, -52, -50, -47, -47,
-45, -42, -41, -38, -36, -35, -31, -30, -27, -24, -21, -19, -15, -13, -10, -7,
-4, -1, 1, 4, 7, 10, 13, 16, 19, 21, 24, 27, 29, 32, 34, 37, 39, 42, 44, 46, 48,
50, 51, 54, 55, 55, 58, 59, 59, 60, 60, 61, 62, 62, 62, 63, 62, 62, 62, 61, 61,
60, 59, 58, 57, 55, 54, 53, 52, 51, 49, 48, 46, 44, 41, 39, 39, 37, 35, 32, 31,
28, 26, 24, 22, 20, 18, 16, 14, 12, 10, 8, 6, 3, 2, 0, -1, -3, -5, -5, -7, -8,
-10, -11, -13, -14, -15, -16, -17, -18, -19, -20, -20, -21, -22, -22, -23, -23,
-24, -24, -24, -24, -24, -24, -25, -24, -24, -24, -24, -25, -23, -24, -24, -24,
-23, -24, -23, -23, -23, -22, -22, -22, -22, -21, -22, -21, -21, -21, -20, -20,
-20, -20, -19, -19, -19, -19, -19, -18, -18, -18, -18, -17, -18, -18, -17, -18,
-17, -17, -18, -18, -17, -18, -18, -18, -18, -17, -17, -17, -18, -18, -19, -18,
-18, -19, -19, -19, -19, -21, -20, -21, -21, -22, -22, -22, -24, -24, -25, -25,
-27, -27, -27, -28, -29, -29, -31, -30, -32, -33, -34, -35, -36, -36, -38, -39,
-40, -40, -41, -42, -43, -45, -45, -47, -47, -48, -49, -49, -50, -51, -52, -53,
-53, -53, -54, -53, -54, -54, -54, -54, -54, -54, -54, -52, -53, -52, -51, -50,
-49, -47, -47, -45, -44, -42, -40, -38, -36, -35, -32, -29, -27, -25, -21, -19,
-16, -14, -10, -7, -4, 0, };