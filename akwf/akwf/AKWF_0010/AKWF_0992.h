#define DATA_LENGTH 512
#define DATA AKWF_0992

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 115, 98, 96, 81, 79, 65, 61, 48,
43, 31, 26, 14, 10, 9, 13, 13, 14, 15, 18, 19, 20, 21, 22, 24, 25, 27, 28, 29,
30, 31, 32, 35, 36, 37, 38, 39, 41, 43, 43, 45, 46, 47, 49, 50, 52, 53, 55, 55,
57, 57, 59, 61, 63, 63, 65, 66, 67, 69, 70, 72, 72, 73, 75, 76, 77, 79, 80, 82,
83, 85, 85, 88, 88, 90, 91, 93, 93, 96, 96, 98, 98, 101, 101, 102, 104, 105,
107, 107, 111, 109, 114, 110, 119, 109, 127, 54, -14, 8, -4, 4, -3, 2, -2, 1, 0,
0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0,
0, 0, -1, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, -1, 0,
0, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, -1, 0, 0,
0, 1, -1, 0, 0, 0, 1, 0, 0, -1, 0, -1, 1, -1, -1, 0, -1, 0, 0, 0, 0, -1, 0, 0,
0, 0, 0, 0, 0, 1, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0,
-1, 1, 1, 0, -1, 0, 0, 1, -1, 0, 0, 1, 0, 0, -1, 0, -1, 1, 0, 0, 0, 0, 0, -1, 1,
-1, 2, -3, 3, -3, 4, -5, 5, -8, 12, -29, -63, 5, -13, -6, -13, -10, -13, -14,
-15, -16, -17, -20, -18, -23, -22, -25, -23, -27, -26, -29, -29, -32, -32, -34,
-34, -36, -37, -38, -40, -40, -42, -43, -45, -45, -46, -48, -49, -50, -51, -52,
-53, -54, -56, -57, -58, -59, -60, -62, -63, -64, -65, -67, -67, -69, -68, -73,
-71, -74, -74, -77, -77, -79, -79, -81, -81, -82, -88, -13, 5, -3, 2, -3, 2, -2,
2, -1, 1, -1, 1, -1, 0, -1, 1, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0,
0, 0, 1, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0,
-1, 0, -1, -1, 0, 1, 0, 0, 1, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, -1, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, -1, 0, 0, 0, 1, 1, 0, 1, 0, 0, 1, 0,
1, 0, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 1, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0,
-1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0,
1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, };