#define DATA_LENGTH 512
#define DATA AKWF_0956

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 3, 4, 6, 7, 9, 10, 11, 12, 14,
15, 16, 17, 19, 20, 22, 23, 24, 26, 27, 28, 30, 32, 33, 34, 35, 37, 38, 41, 43,
44, 44, 46, 49, 50, 52, 53, 54, 56, 57, 59, 62, 62, 64, 65, 67, 69, 70, 72, 74,
75, 77, 78, 79, 81, 82, 83, 84, 86, 87, 89, 90, 91, 92, 93, 94, 96, 96, 97, 98,
98, 99, 99, 101, 101, 102, 102, 103, 104, 103, 104, 104, 105, 105, 105, 105,
105, 106, 105, 105, 105, 105, 104, 105, 105, 105, 104, 104, 103, 104, 103, 103,
102, 102, 101, 102, 101, 101, 100, 100, 99, 98, 99, 99, 97, 97, 96, 96, 95, 94,
94, 93, 92, 92, 91, 91, 91, 90, 89, 88, 87, 86, 85, 84, 84, 82, 82, 80, 80, 79,
78, 76, 75, 74, 72, 70, 69, 68, 67, 66, 63, 62, 60, 59, 56, 56, 53, 52, 50, 49,
47, 46, 44, 42, 41, 38, 37, 35, 34, 31, 30, 28, 27, 25, 23, 21, 19, 18, 16, 15,
13, 11, 10, 9, 6, 4, 4, 2, 1, -2, -2, -4, -5, -7, -8, -10, -11, -12, -14, -15,
-16, -18, -19, -20, -21, -23, -23, -24, -25, -25, -27, -28, -29, -30, -30, -32,
-33, -33, -34, -34, -35, -36, -36, -37, -38, -38, -39, -40, -40, -40, -41, -42,
-43, -43, -43, -44, -44, -45, -45, -46, -46, -46, -47, -47, -47, -46, -47, -47,
-47, -48, -48, -49, -48, -48, -48, -49, -49, -48, -48, -49, -49, -49, -49, -49,
-49, -49, -49, -49, -49, -48, -49, -48, -48, -48, -49, -49, -49, -48, -48, -47,
-47, -48, -48, -47, -48, -47, -47, -48, -46, -47, -47, -47, -47, -47, -47, -46,
-46, -46, -46, -46, -45, -45, -44, -44, -44, -44, -44, -44, -43, -42, -42, -42,
-41, -41, -40, -40, -40, -39, -39, -39, -38, -38, -37, -37, -35, -36, -36, -36,
-35, -34, -33, -33, -32, -32, -32, -31, -31, -30, -29, -29, -30, -30, -29, -28,
-28, -28, -28, -27, -27, -27, -27, -27, -27, -27, -26, -27, -27, -27, -27, -27,
-28, -27, -27, -28, -28, -28, -29, -29, -29, -30, -30, -31, -32, -32, -32, -33,
-34, -35, -34, -35, -36, -37, -37, -38, -39, -39, -39, -40, -40, -41, -42, -41,
-42, -43, -42, -44, -44, -45, -45, -45, -45, -44, -45, -45, -46, -47, -46, -46,
-47, -47, -47, -48, -47, -48, -48, -48, -48, -48, -49, -49, -49, -49, -49, -49,
-49, -50, -49, -50, -50, -50, -51, -50, -51, -50, -51, -51, -51, -51, -52, -52,
-52, -52, -52, -53, -52, -53, -53, -53, -53, -53, -54, -53, -53, -54, -53, -52,
-53, -52, -52, -52, -52, -51, -51, -51, -51, -50, -50, -50, -49, -48, -47, -46,
-46, -46, -45, -44, -43, -42, -41, -39, -40, -38, -37, -35, -34, -33, -32, -31,
-29, -28, -27, -26, -25, -23, -22, -20, -19, -17, -16, -14, -13, -12, -11, -9,
-8, -6, -3, -1, -2, -1, 1, };