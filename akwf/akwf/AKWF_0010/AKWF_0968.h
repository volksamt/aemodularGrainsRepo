#define DATA_LENGTH 512
#define DATA AKWF_0968

const PROGMEM int8_t DATA[DATA_LENGTH] = {17, 20, 18, 19, 17, 17, 17, 17, 16,
16, 15, 15, 14, 14, 13, 13, 12, 13, 12, 12, 13, 13, 13, 13, 14, 13, 15, 15, 15,
15, 17, 17, 17, 18, 20, 20, 20, 21, 23, 23, 23, 24, 24, 26, 27, 27, 28, 28, 29,
29, 30, 30, 31, 31, 32, 31, 31, 31, 31, 32, 31, 32, 31, 31, 31, 31, 30, 29, 30,
29, 29, 29, 29, 29, 28, 29, 28, 27, 27, 28, 27, 26, 26, 26, 26, 26, 27, 26, 26,
26, 26, 26, 26, 27, 27, 26, 26, 27, 26, 27, 28, 26, 28, 28, 28, 28, 28, 27, 28,
28, 27, 28, 28, 27, 27, 26, 27, 27, 27, 27, 26, 26, 26, 26, 26, 26, 24, 25, 24,
24, 23, 24, 23, 22, 23, 22, 22, 21, 22, 21, 21, 21, 20, 20, 19, 19, 19, 19, 18,
17, 17, 16, 16, 15, 14, 14, 13, 13, 12, 11, 11, 10, 10, 9, 7, 7, 6, 6, 4, 3, 3,
1, 1, 0, 1, 2, 2, 4, 4, 5, 6, 6, 8, 9, 9, 9, 11, 12, 12, 13, 13, 14, 16, 15, 16,
17, 17, 17, 18, 18, 19, 19, 20, 21, 20, 20, 21, 20, 21, 21, 22, 23, 22, 22, 23,
23, 24, 23, 24, 24, 25, 25, 26, 26, 26, 27, 26, 26, 27, 27, 28, 28, 27, 27, 27,
28, 28, 28, 28, 27, 28, 27, 27, 28, 27, 27, 27, 27, 27, 27, 26, 26, 26, 27, 25,
26, 26, 26, 26, 25, 25, 25, 25, 26, 27, 26, 27, 27, 27, 27, 28, 28, 28, 28, 28,
29, 29, 30, 30, 30, 30, 31, 31, 31, 30, 31, 31, 31, 31, 31, 32, 31, 31, 31, 30,
30, 30, 29, 30, 29, 27, 28, 27, 26, 25, 25, 24, 23, 22, 21, 21, 20, 20, 18, 18,
17, 16, 16, 15, 15, 15, 14, 14, 14, 13, 13, 12, 13, 12, 13, 12, 14, 12, 14, 13,
15, 13, 16, 14, 17, 16, 17, 18, 18, 20, 16, 28, -64, -103, -103, -120, -115,
-122, -116, -118, -113, -112, -108, -107, -102, -101, -97, -94, -91, -88, -85,
-82, -79, -75, -73, -70, -68, -64, -63, -59, -57, -54, -52, -49, -48, -46, -44,
-41, -40, -37, -36, -34, -33, -31, -30, -29, -27, -25, -25, -24, -23, -22, -21,
-20, -19, -19, -18, -18, -17, -16, -17, -15, -15, -15, -13, -14, -12, -12, -11,
-11, -10, -9, -8, -9, -7, -7, -6, -6, -4, -5, -4, -2, -2, -1, 0, -1, -2, -3, -4,
-5, -5, -7, -7, -7, -7, -8, -10, -11, -11, -11, -12, -13, -12, -14, -14, -14,
-16, -16, -17, -16, -17, -18, -18, -20, -20, -22, -22, -23, -24, -24, -26, -27,
-29, -29, -30, -33, -34, -35, -38, -40, -41, -42, -46, -47, -49, -52, -54, -57,
-59, -61, -65, -67, -69, -72, -75, -78, -82, -84, -88, -90, -94, -95, -100,
-102, -106, -108, -112, -113, -117, -117, -119, -118, -116, -111, -83, -43, 2,
};