#define DATA_LENGTH 512
#define DATA AKWF_0980

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 12, 15, 18, 21, 25, 27, 30,
34, 36, 39, 41, 44, 46, 49, 51, 54, 57, 58, 60, 63, 64, 66, 67, 69, 71, 72, 73,
75, 75, 77, 77, 79, 80, 80, 81, 82, 82, 83, 84, 84, 84, 84, 84, 85, 86, 85, 85,
85, 85, 85, 83, 83, 83, 83, 82, 81, 81, 81, 80, 79, 80, 80, 79, 79, 79, 78, 77,
77, 77, 76, 76, 75, 75, 75, 75, 74, 74, 73, 72, 71, 70, 69, 69, 67, 67, 65, 64,
63, 60, 59, 58, 56, 53, 52, 50, 48, 45, 43, 40, 38, 35, 33, 30, 27, 25, 22, 18,
16, 13, 9, 7, 3, 1, -3, -6, -9, -12, -15, -18, -22, -24, -26, -30, -32, -35,
-37, -39, -42, -44, -46, -48, -49, -50, -53, -53, -54, -55, -55, -55, -56, -57,
-57, -59, -58, -59, -59, -59, -61, -60, -61, -62, -62, -62, -63, -62, -63, -63,
-64, -64, -63, -64, -64, -64, -64, -63, -63, -63, -63, -63, -63, -62, -62, -61,
-62, -61, -60, -60, -59, -59, -58, -57, -56, -57, -55, -55, -55, -54, -53, -52,
-51, -51, -50, -49, -48, -47, -46, -45, -45, -44, -44, -42, -42, -42, -40, -39,
-38, -38, -36, -36, -36, -34, -33, -32, -31, -30, -29, -28, -27, -26, -26, -24,
-23, -22, -21, -19, -18, -17, -16, -14, -13, -12, -10, -9, -7, -5, -3, -1, 0, 3,
5, 8, 9, 12, 13, 15, 18, 20, 23, 25, 28, 30, 32, 35, 37, 39, 41, 45, 46, 48, 50,
52, 55, 57, 58, 60, 62, 64, 65, 67, 68, 69, 71, 72, 73, 74, 74, 75, 75, 77, 77,
77, 77, 78, 79, 78, 78, 77, 77, 77, 77, 76, 75, 76, 74, 74, 75, 73, 73, 72, 71,
71, 70, 70, 69, 69, 67, 67, 66, 66, 65, 64, 64, 63, 63, 62, 61, 59, 60, 59, 58,
57, 56, 55, 54, 53, 52, 50, 50, 48, 47, 47, 45, 43, 41, 40, 39, 37, 35, 33, 31,
29, 26, 25, 23, 19, 18, 15, 12, 9, 6, 3, 1, -2, -6, -9, -12, -15, -19, -22, -24,
-29, -32, -35, -38, -41, -45, -48, -52, -55, -58, -61, -63, -67, -70, -73, -76,
-78, -82, -84, -87, -89, -90, -93, -95, -97, -99, -101, -102, -103, -104, -106,
-106, -108, -109, -109, -111, -110, -111, -111, -113, -113, -113, -115, -115,
-115, -115, -116, -116, -117, -118, -118, -118, -118, -118, -118, -119, -118,
-118, -118, -119, -119, -118, -119, -119, -119, -119, -118, -118, -118, -117,
-117, -117, -117, -116, -116, -115, -115, -115, -113, -113, -112, -112, -111,
-111, -110, -109, -109, -108, -108, -106, -106, -106, -105, -104, -103, -102,
-101, -100, -100, -99, -98, -97, -96, -96, -94, -94, -92, -91, -90, -88, -87,
-86, -85, -84, -81, -80, -79, -78, -76, -74, -73, -71, -70, -68, -65, -64, -62,
-60, -57, -56, -53, -50, -49, -45, -43, -40, -37, -35, -31, -29, -25, -23, -19,
-16, -13, -10, -6, -4, 0, };