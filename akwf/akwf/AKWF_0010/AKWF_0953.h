#define DATA_LENGTH 512
#define DATA AKWF_0953

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 8, 10, 14, 16, 18, 19, 22,
24, 27, 28, 31, 33, 36, 38, 41, 42, 44, 47, 48, 50, 52, 53, 55, 57, 59, 61, 62,
64, 64, 66, 67, 69, 70, 70, 72, 73, 73, 74, 74, 76, 76, 77, 79, 79, 79, 80, 79,
79, 80, 79, 80, 80, 80, 80, 79, 79, 79, 78, 78, 77, 77, 76, 76, 75, 74, 73, 73,
72, 71, 71, 70, 70, 69, 69, 68, 67, 67, 67, 68, 68, 67, 67, 67, 67, 68, 68, 68,
69, 70, 70, 70, 72, 72, 72, 73, 73, 74, 75, 76, 77, 79, 79, 81, 82, 82, 83, 85,
85, 87, 89, 89, 90, 91, 94, 93, 95, 96, 97, 99, 99, 101, 102, 103, 105, 106,
107, 108, 109, 110, 110, 112, 112, 113, 113, 115, 115, 115, 116, 117, 117, 118,
118, 119, 118, 119, 119, 119, 120, 119, 119, 119, 118, 119, 118, 117, 118, 117,
116, 115, 115, 115, 113, 113, 111, 111, 110, 109, 107, 107, 105, 104, 102, 102,
101, 100, 98, 96, 95, 93, 92, 90, 89, 87, 86, 84, 82, 80, 78, 77, 75, 73, 73,
71, 68, 66, 65, 63, 62, 59, 57, 55, 52, 51, 50, 48, 46, 44, 41, 39, 38, 35, 33,
31, 30, 28, 26, 24, 22, 21, 19, 16, 15, 12, 11, 9, 7, 6, 3, 2, 1, -2, -3, -4,
-6, -8, -9, -11, -13, -14, -16, -17, -19, -20, -22, -23, -23, -25, -26, -28,
-29, -30, -31, -32, -34, -35, -35, -37, -38, -39, -39, -41, -42, -42, -42, -44,
-45, -46, -46, -47, -48, -49, -49, -51, -51, -52, -52, -53, -53, -54, -55, -56,
-55, -56, -57, -57, -58, -59, -59, -60, -60, -61, -61, -62, -63, -63, -64, -63,
-63, -64, -64, -64, -65, -65, -66, -65, -66, -66, -67, -66, -67, -66, -66, -66,
-66, -66, -64, -64, -64, -63, -63, -62, -62, -61, -61, -60, -59, -59, -59, -58,
-58, -57, -58, -58, -58, -57, -58, -57, -57, -59, -58, -58, -59, -58, -60, -60,
-60, -59, -61, -61, -61, -61, -63, -63, -63, -63, -64, -64, -64, -65, -65, -66,
-66, -66, -66, -67, -67, -68, -68, -68, -67, -69, -68, -69, -69, -70, -70, -70,
-70, -71, -71, -71, -72, -72, -72, -72, -73, -73, -73, -74, -74, -75, -75, -75,
-76, -76, -76, -77, -77, -78, -77, -78, -78, -79, -79, -79, -81, -81, -81, -81,
-82, -82, -83, -83, -84, -84, -85, -85, -85, -86, -86, -86, -86, -87, -86, -87,
-88, -87, -88, -88, -88, -88, -89, -89, -88, -89, -89, -89, -89, -89, -89, -88,
-88, -89, -87, -87, -88, -87, -88, -86, -86, -87, -84, -84, -84, -84, -83, -82,
-81, -82, -80, -80, -79, -78, -77, -76, -75, -74, -73, -72, -71, -70, -68, -67,
-66, -65, -63, -62, -60, -59, -57, -56, -54, -53, -50, -49, -47, -46, -44, -42,
-39, -38, -35, -34, -31, -30, -28, -25, -23, -21, -20, -17, -14, -12, -10, -7,
-5, -2, -2, 0, };