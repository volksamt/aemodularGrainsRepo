#define DATA_LENGTH 512
#define DATA AKWF_0906

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 29, 42, 48, 50, 49, 47, 45, 43, 42,
40, 41, 41, 40, 40, 40, 40, 40, 40, 39, 38, 38, 38, 37, 37, 36, 37, 36, 37, 35,
35, 35, 36, 36, 36, 36, 36, 37, 37, 37, 37, 36, 37, 36, 36, 37, 37, 37, 37, 37,
38, 37, 38, 38, 38, 38, 39, 39, 38, 39, 38, 42, 50, 56, 59, 59, 60, 59, 58, 58,
58, 58, 58, 58, 58, 58, 58, 59, 59, 59, 59, 59, 59, 59, 59, 60, 60, 60, 60, 60,
60, 60, 59, 59, 60, 60, 60, 60, 60, 61, 61, 61, 61, 60, 61, 62, 62, 62, 62, 62,
62, 63, 63, 63, 62, 63, 63, 64, 63, 64, 64, 65, 65, 65, 65, 65, 65, 65, 66, 65,
66, 66, 66, 66, 66, 67, 67, 67, 67, 67, 67, 67, 68, 67, 69, 68, 68, 68, 68, 69,
69, 70, 70, 69, 69, 70, 70, 70, 71, 70, 70, 71, 72, 71, 70, 72, 72, 71, 72, 73,
72, 72, 72, 73, 72, 73, 72, 73, 74, 73, 74, 74, 74, 74, 74, 74, 75, 75, 75, 75,
75, 75, 75, 75, 75, 76, 75, 76, 77, 77, 77, 77, 77, 77, 77, 77, 77, 78, 77, 79,
36, -46, -91, -113, -119, -119, -116, -112, -108, -104, -101, -99, -96, -94,
-93, -91, -89, -87, -86, -84, -81, -81, -79, -78, -78, -76, -75, -75, -74, -73,
-72, -73, -73, -72, -72, -72, -72, -72, -72, -72, -72, -72, -73, -72, -72, -73,
-72, -73, -72, -73, -73, -73, -74, -73, -74, -74, -73, -74, -74, -74, -74, -75,
-74, -75, -75, -75, -75, -75, -76, -75, -76, -77, -77, -77, -76, -77, -77, -78,
-77, -77, -77, -78, -78, -78, -78, -79, -79, -78, -79, -79, -79, -79, -80, -80,
-80, -81, -80, -81, -81, -81, -81, -82, -82, -81, -81, -82, -82, -83, -82, -82,
-83, -83, -83, -83, -82, -83, -84, -83, -84, -84, -84, -84, -84, -85, -84, -85,
-86, -86, -86, -86, -86, -85, -86, -86, -85, -87, -87, -87, -85, -83, -80, -79,
-79, -79, -80, -81, -82, -82, -82, -83, -82, -83, -82, -82, -82, -82, -82, -83,
-82, -83, -82, -84, -83, -84, -83, -84, -85, -84, -84, -85, -85, -85, -84, -85,
-86, -86, -86, -86, -86, -87, -87, -86, -87, -86, -87, -87, -87, -87, -87, -87,
-87, -88, -88, -88, -88, -89, -88, -88, -89, -89, -89, -89, -89, -90, -89, -90,
-88, -82, -76, -73, -71, -73, -73, -74, -76, -76, -76, -75, -76, -75, -75, -74,
-75, -74, -74, -74, -75, -75, -75, -75, -76, -76, -76, -76, -77, -77, -77, -78,
-77, -77, -78, -78, -77, -78, -78, -79, -79, -72, -53, -34, -21, -17, -19, -23,
-26, -28, -30, -29, -28, -26, -23, -21, -19, -16, -15, -15, -16, -15, -15, -18,
-17, -18, -19, -20, -21, -22, -21, -22, -22, -23, -23, -23, -23, -22, -24, -23,
-24, -22, -24, -24, -24, -23, -23, -24, -24, -23, -25, -23, -24, -22, -25, -20,
};