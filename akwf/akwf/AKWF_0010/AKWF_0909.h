#define DATA_LENGTH 512
#define DATA AKWF_0909

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 11, 16, 19, 23, 28, 31, 36,
40, 44, 49, 55, 59, 63, 67, 71, 76, 79, 83, 87, 88, 90, 92, 93, 96, 96, 98, 99,
98, 99, 100, 98, 98, 97, 96, 95, 94, 91, 90, 88, 86, 85, 82, 80, 77, 74, 72, 69,
68, 64, 63, 59, 57, 54, 51, 48, 45, 42, 39, 37, 33, 30, 28, 26, 24, 21, 19, 17,
17, 14, 13, 11, 9, 8, 7, 7, 5, 5, 3, 3, 3, 2, 1, 1, 0, -1, -1, 0, -1, 0, -2, -1,
-2, -2, -2, -2, -3, -2, -2, -2, -3, -3, -2, -2, -3, -3, -3, -3, -3, -3, -3, -3,
-3, -2, -3, -2, -3, -3, -3, -3, -3, -4, -3, -3, -3, -4, -3, -3, -3, -3, -4, -3,
-3, -3, -3, -4, -3, -3, -3, -3, -3, -4, -3, -3, -4, -3, -4, -3, -3, -4, -3, -4,
-3, -4, -3, -3, -4, -6, -7, -8, -9, -10, -12, -12, -14, -16, -18, -20, -22, -24,
-26, -29, -30, -33, -35, -37, -41, -43, -46, -50, -51, -55, -58, -61, -64, -67,
-70, -73, -76, -79, -82, -86, -89, -92, -95, -98, -101, -105, -108, -110, -113,
-115, -116, -116, -117, -120, -112, -94, -87, -84, -83, -80, -77, -73, -68, -62,
-57, -50, -46, -39, -42, -47, -43, -38, -33, -29, -25, -21, -18, -16, -13, -10,
-7, -4, -1, 3, 6, 9, 12, 17, 21, 26, 29, 34, 38, 42, 46, 51, 54, 59, 63, 65, 68,
70, 73, 74, 77, 78, 79, 80, 81, 82, 81, 82, 81, 80, 80, 80, 79, 77, 75, 74, 73,
71, 69, 68, 65, 64, 61, 59, 57, 54, 53, 50, 47, 46, 43, 41, 38, 35, 33, 32, 29,
27, 23, 22, 20, 18, 16, 14, 13, 11, 9, 7, 6, 6, 5, 4, 4, 2, 1, 0, 0, 0, -1, -1,
-2, -2, -3, -3, -3, -3, -3, -4, -3, -4, -4, -4, -4, -4, -4, -5, -5, -5, -5, -5,
-5, -4, -5, -4, -5, -5, -5, -6, -5, -5, -5, -5, -5, -4, -5, -5, -5, -5, -5, -5,
-5, -4, -5, -5, -5, -5, -5, -5, -5, -5, -6, -5, -5, -5, -5, -4, -6, -6, -5, -4,
-5, -5, -5, -6, -5, -6, -6, -6, -5, -6, -5, -5, -5, -6, -5, -6, -5, -6, -6, -5,
-5, -5, -5, -6, -6, -6, -6, -5, -6, -6, -6, -7, -6, -6, -6, -6, -6, -6, -5, -5,
-6, -5, -6, -6, -5, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6,
-6, -7, -8, -8, -9, -9, -11, -12, -12, -14, -14, -15, -17, -18, -20, -20, -22,
-24, -25, -26, -29, -31, -32, -34, -36, -37, -39, -41, -44, -46, -47, -50, -52,
-54, -55, -57, -59, -61, -64, -66, -67, -70, -72, -74, -76, -76, -78, -78, -80,
-73, -61, -56, -55, -55, -52, -50, -46, -42, -41, -45, -46, -42, -38, -33, -30,
-26, -23, -20, -17, -14, -12, -8, -6, -2, };