#define DATA_LENGTH 512
#define DATA AKWF_0952

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 14, 17, 22, 27, 32, 39,
47, 80, 86, 83, 86, 84, 85, 83, 85, 83, 85, 84, 85, 83, 85, 84, 83, 83, 83, 82,
82, 83, 82, 82, 82, 82, 82, 82, 81, 82, 81, 81, 81, 80, 80, 80, 80, 78, 78, 78,
78, 78, 77, 77, 77, 75, 76, 75, 75, 75, 74, 74, 74, 72, 72, 72, 71, 70, 70, 69,
69, 68, 67, 67, 66, 66, 65, 64, 64, 63, 62, 62, 61, 60, 59, 58, 58, 57, 56, 55,
55, 53, 53, 52, 50, 50, 49, 47, 46, 45, 44, 43, 43, 41, 40, 40, 38, 36, 35, 34,
32, 31, 30, 28, 27, 25, 23, 21, 20, 18, 17, 15, 12, 11, 8, 6, 4, 1, 3, 5, 7, 10,
11, 14, 15, 18, 19, 22, 23, 25, 26, 28, 29, 31, 31, 33, 34, 37, 37, 39, 40, 40,
42, 44, 44, 45, 46, 48, 48, 50, 50, 51, 52, 52, 54, 55, 56, 57, 58, 58, 59, 61,
60, 62, 63, 63, 63, 64, 65, 65, 66, 66, 67, 68, 69, 69, 70, 70, 71, 71, 72, 72,
73, 73, 73, 74, 75, 76, 76, 76, 77, 76, 77, 77, 78, 78, 79, 79, 79, 79, 80, 79,
80, 81, 81, 81, 82, 81, 82, 82, 82, 82, 83, 82, 83, 84, 84, 84, 84, 83, 84, 83,
84, 83, 85, 83, 85, 84, 84, 84, 85, 84, 85, 84, 52, 40, 34, 27, 23, 18, 15, 10,
8, 4, 3, -1, -3, -6, -8, -11, -12, -15, -15, -18, -21, -21, -24, -25, -27, -28,
-29, -31, -32, -33, -34, -37, -38, -39, -40, -41, -43, -43, -44, -45, -47, -48,
-49, -50, -51, -51, -52, -53, -54, -55, -56, -56, -57, -58, -59, -60, -60, -61,
-62, -62, -64, -64, -65, -65, -66, -66, -67, -68, -68, -69, -70, -71, -71, -71,
-72, -72, -73, -74, -74, -74, -75, -75, -76, -76, -76, -77, -76, -78, -78, -79,
-78, -78, -80, -79, -80, -80, -80, -81, -80, -81, -81, -82, -82, -82, -82, -82,
-83, -83, -83, -83, -84, -83, -84, -84, -84, -83, -85, -83, -85, -83, -84, -84,
-84, -83, -84, -84, -85, -82, -50, -40, -33, -26, -22, -18, -15, -10, -7, -5,
-2, -1, -4, -8, -10, -14, -17, -21, -25, -31, -39, -48, -79, -86, -83, -85, -84,
-84, -84, -84, -84, -84, -84, -84, -83, -84, -84, -83, -83, -83, -82, -83, -83,
-83, -82, -82, -82, -81, -82, -81, -82, -80, -81, -80, -80, -80, -79, -79, -79,
-78, -78, -78, -78, -78, -77, -76, -76, -75, -76, -76, -75, -73, -74, -73, -73,
-72, -71, -71, -70, -70, -69, -69, -68, -67, -68, -66, -66, -66, -64, -63, -63,
-62, -61, -61, -59, -59, -58, -58, -56, -56, -55, -54, -54, -52, -51, -51, -49,
-48, -47, -47, -45, -44, -43, -43, -41, -40, -38, -37, -37, -35, -34, -32, -31,
-29, -28, -27, -25, -22, -21, -21, -18, -16, -15, -12, -11, -8, -6, -1, -2, -1,
};