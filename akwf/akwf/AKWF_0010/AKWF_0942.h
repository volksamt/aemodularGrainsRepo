#define DATA_LENGTH 512
#define DATA AKWF_0942

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 8, 13, 17, 21, 26, 30, 35, 39,
43, 47, 50, 54, 58, 62, 66, 69, 73, 75, 79, 82, 84, 88, 90, 93, 96, 97, 100,
103, 104, 107, 108, 110, 111, 112, 114, 115, 115, 116, 117, 118, 118, 118, 119,
119, 119, 119, 118, 118, 119, 117, 118, 116, 115, 114, 113, 112, 111, 110, 109,
107, 106, 105, 103, 102, 100, 97, 96, 93, 92, 90, 88, 86, 84, 82, 79, 77, 75,
73, 70, 68, 65, 63, 61, 59, 55, 53, 50, 48, 45, 42, 40, 37, 34, 32, 29, 26, 24,
21, 18, 16, 12, 11, 8, 5, 2, -1, -4, -6, -8, -11, -14, -16, -18, -21, -23, -25,
-27, -29, -31, -33, -36, -36, -40, -41, -43, -44, -46, -47, -48, -49, -51, -53,
-53, -54, -54, -54, -55, -56, -56, -55, -56, -56, -55, -56, -55, -55, -53, -52,
-52, -50, -49, -49, -47, -46, -44, -44, -42, -39, -38, -35, -33, -32, -29, -27,
-26, -22, -21, -19, -16, -14, -10, -9, -7, -4, -2, 1, 3, 5, 7, 9, 12, 14, 17,
19, 20, 22, 24, 27, 28, 30, 31, 33, 35, 37, 38, 39, 41, 40, 41, 43, 44, 45, 45,
46, 45, 46, 46, 47, 47, 46, 47, 46, 47, 46, 46, 45, 45, 45, 44, 43, 43, 42, 41,
40, 39, 38, 37, 36, 35, 33, 33, 32, 30, 29, 28, 27, 25, 24, 22, 21, 19, 19, 16,
16, 15, 12, 12, 9, 9, 7, 6, 4, 3, 1, 0, -1, -2, -5, -6, -7, -10, -11, -11, -13,
-14, -16, -17, -18, -20, -22, -23, -24, -25, -26, -28, -29, -31, -31, -32, -34,
-35, -36, -37, -38, -39, -40, -41, -42, -42, -44, -44, -45, -46, -46, -47, -47,
-47, -47, -48, -47, -47, -47, -47, -47, -46, -46, -45, -44, -44, -43, -41, -41,
-40, -38, -37, -36, -35, -34, -32, -30, -28, -26, -25, -22, -21, -19, -16, -13,
-12, -10, -7, -5, -3, 0, 2, 5, 7, 9, 12, 14, 17, 19, 21, 23, 26, 28, 30, 32, 34,
37, 38, 39, 42, 43, 45, 47, 47, 49, 50, 51, 51, 54, 53, 54, 55, 55, 55, 56, 56,
56, 56, 55, 55, 54, 54, 53, 52, 51, 50, 49, 48, 46, 45, 44, 42, 41, 39, 38, 35,
33, 31, 28, 27, 24, 22, 21, 17, 14, 13, 11, 8, 5, 2, 0, -3, -5, -9, -12, -14,
-16, -19, -21, -25, -28, -30, -33, -35, -38, -41, -43, -46, -48, -50, -53, -56,
-58, -61, -64, -66, -68, -71, -73, -76, -79, -80, -83, -84, -87, -89, -91, -92,
-94, -96, -98, -100, -101, -103, -104, -107, -108, -109, -110, -112, -112, -114,
-115, -115, -117, -117, -118, -117, -118, -118, -118, -119, -119, -119, -118,
-117, -119, -117, -116, -115, -114, -114, -112, -111, -109, -108, -106, -105,
-102, -100, -97, -94, -92, -90, -87, -85, -81, -77, -74, -71, -69, -64, -61,
-57, -53, -49, -46, -42, -37, -33, -29, -25, -20, -16, -12, -7, -3, };