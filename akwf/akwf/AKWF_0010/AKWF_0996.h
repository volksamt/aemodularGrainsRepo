#define DATA_LENGTH 512
#define DATA AKWF_0996

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1,
0, 1, 1, 1, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 0, 1, 1, 0, 1, 1, 1, 0, 0, 1, 1, 1,
2, 0, 0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 1,
0, 1, 0, 0, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 2, 4,
6, 7, 8, 10, 11, 12, 13, 15, 17, 19, 19, 20, 22, 24, 25, 26, 28, 29, 30, 31, 34,
35, 36, 37, 39, 40, 42, 43, 45, 45, 47, 48, 49, 51, 53, 53, 54, 56, 59, 60, 61,
62, 63, 65, 66, 67, 69, 70, 71, 73, 74, 76, 78, 78, 81, 82, 82, 85, 85, 87, 88,
89, 91, 92, 94, 94, 96, 98, 99, 100, 101, 102, 105, 106, 107, 109, 109, 112,
112, 114, 116, 117, 119, 119, 117, 116, 114, 114, 111, 110, 109, 107, 106, 104,
103, 102, 100, 99, 98, 97, 95, 94, 92, 91, 89, 87, 86, 85, 84, 82, 80, 80, 78,
77, 75, 74, 72, 71, 70, 68, 66, 65, 65, 63, 61, 60, 58, 57, 56, 55, 52, 52, 51,
49, 48, 46, 45, 44, 42, 40, 39, 38, 36, 34, 34, 33, 31, 30, 27, 27, 25, 22, 20,
19, 17, 16, 15, 14, 13, 11, 10, 9, 7, 6, 5, 2, 1, 0, -2, -2, -3, -2, -2, -3, -3,
-2, -3, -3, -3, -2, -3, -3, -3, -3, -3, -3, -3, -3, -2, -4, -3, -2, -3, -3, -3,
-4, -3, -3, -2, -3, -3, -3, -4, -3, -4, -2, -3, -3, -3, -2, -3, -3, -2, -2, -3,
-3, -2, -2, -2, -2, -3, -2, -3, -2, -2, -1, -2, -1, -2, -1, -2, -2, -2, -2, -1,
-1, -1, -2, -1, -1, 0, -1, -2, -1, -1, -1, -1, -3, -4, -6, -8, -8, -9, -11, -13,
-14, -15, -16, -18, -19, -20, -23, -23, -25, -26, -28, -29, -31, -32, -33, -34,
-35, -37, -39, -40, -42, -42, -45, -45, -47, -48, -49, -51, -52, -54, -55, -56,
-58, -59, -61, -61, -64, -65, -65, -67, -69, -70, -72, -73, -75, -76, -77, -79,
-79, -81, -83, -83, -85, -87, -88, -89, -91, -92, -93, -95, -97, -97, -99, -100,
-102, -103, -104, -106, -107, -109, -110, -112, -113, -114, -116, -117, -118,
-119, -117, -115, -115, -113, -112, -110, -109, -107, -105, -104, -103, -102,
-100, -99, -98, -97, -95, -93, -92, -91, -89, -88, -87, -85, -84, -82, -82, -80,
-78, -77, -76, -74, -73, -72, -70, -69, -67, -66, -65, -62, -62, -61, -59, -57,
-56, -55, -53, -52, -51, -49, -47, -46, -44, -43, -42, -40, -39, -38, -36, -35,
-34, -32, -31, -30, -29, -26, -25, -25, -22, -22, -20, -18, -17, -15, -15, -13,
-12, -10, -8, -8, -6, -5, -2, -2, 0, };