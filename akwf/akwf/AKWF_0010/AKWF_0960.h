#define DATA_LENGTH 512
#define DATA AKWF_0960

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 4, 5, 6, 6, 7, 8, 10, 11, 11,
12, 13, 14, 15, 16, 17, 18, 20, 20, 21, 23, 23, 24, 25, 26, 28, 28, 30, 30, 32,
34, 34, 35, 36, 38, 38, 40, 41, 42, 43, 44, 46, 48, 47, 50, 51, 52, 53, 54, 55,
58, 59, 60, 61, 62, 63, 65, 65, 67, 68, 70, 71, 72, 73, 74, 75, 76, 78, 79, 80,
81, 82, 84, 85, 86, 87, 88, 89, 90, 91, 92, 93, 94, 95, 96, 97, 98, 99, 100,
101, 102, 102, 102, 103, 104, 104, 106, 107, 107, 107, 108, 109, 109, 109, 109,
109, 110, 111, 112, 112, 112, 112, 112, 113, 113, 113, 113, 114, 113, 113, 113,
113, 113, 113, 113, 113, 112, 112, 112, 112, 112, 112, 112, 112, 111, 111, 111,
110, 110, 110, 109, 109, 108, 107, 107, 106, 106, 106, 104, 104, 103, 103, 103,
102, 101, 101, 100, 100, 99, 98, 97, 97, 96, 95, 95, 94, 93, 93, 92, 91, 90, 90,
88, 88, 88, 87, 86, 85, 84, 84, 82, 81, 81, 81, 80, 79, 78, 77, 76, 76, 74, 75,
73, 72, 71, 70, 70, 68, 69, 67, 66, 65, 64, 64, 63, 61, 61, 60, 59, 59, 58, 57,
56, 55, 54, 53, 53, 51, 51, 50, 49, 47, 46, 45, 44, 43, 42, 41, 40, 40, 37, 36,
36, 35, 33, 34, 32, 30, 29, 28, 27, 25, 24, 23, 22, 21, 20, 19, 18, 16, 16, 13,
12, 12, 10, 9, 7, 5, 5, 3, 1, 1, -2, -2, -4, -5, -7, -9, -10, -11, -12, -14,
-15, -17, -18, -20, -21, -23, -25, -27, -27, -30, -31, -33, -34, -36, -37, -39,
-40, -42, -44, -45, -47, -48, -49, -51, -52, -54, -56, -58, -58, -60, -62, -62,
-65, -66, -67, -69, -70, -72, -74, -74, -76, -78, -79, -80, -81, -82, -84, -85,
-87, -88, -88, -90, -90, -92, -93, -94, -95, -96, -98, -99, -99, -100, -101,
-102, -103, -103, -104, -106, -106, -106, -109, -109, -110, -110, -111, -112,
-111, -113, -114, -114, -114, -115, -115, -116, -116, -116, -116, -116, -118,
-118, -118, -118, -119, -119, -119, -119, -119, -119, -119, -118, -119, -120,
-120, -119, -119, -119, -119, -118, -119, -118, -118, -118, -117, -117, -117,
-116, -116, -115, -115, -115, -115, -114, -114, -113, -112, -112, -112, -110,
-110, -110, -110, -109, -108, -108, -107, -106, -105, -104, -104, -103, -102,
-102, -100, -100, -98, -98, -97, -96, -95, -95, -94, -92, -92, -91, -89, -89,
-88, -87, -86, -85, -83, -83, -82, -81, -80, -78, -77, -77, -75, -74, -74, -72,
-71, -70, -68, -68, -66, -65, -64, -63, -62, -60, -60, -58, -57, -56, -55, -53,
-53, -52, -50, -49, -48, -46, -46, -45, -43, -42, -41, -40, -38, -37, -36, -36,
-33, -33, -31, -30, -30, -28, -27, -26, -24, -24, -23, -22, -21, -19, -18, -17,
-17, -15, -14, -13, -12, -12, -11, -10, -9, -8, -7, -7, -5, -4, -4, -2, -1, 0,
};