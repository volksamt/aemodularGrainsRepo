#define DATA_LENGTH 512
#define DATA AKWF_0931

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 11, 15, 20, 26, 31, 35, 40, 45,
50, 54, 59, 63, 67, 71, 75, 78, 83, 86, 89, 92, 96, 97, 100, 103, 105, 108, 110,
110, 112, 114, 115, 116, 117, 119, 118, 119, 119, 119, 120, 119, 119, 118, 117,
116, 116, 115, 113, 112, 111, 110, 108, 107, 106, 103, 103, 100, 98, 97, 95, 93,
91, 89, 87, 86, 84, 82, 80, 79, 77, 75, 73, 71, 70, 68, 67, 64, 63, 62, 60, 59,
56, 54, 53, 51, 50, 47, 46, 46, 43, 42, 41, 38, 37, 36, 33, 33, 30, 29, 28, 26,
24, 22, 21, 20, 17, 15, 15, 12, 11, 8, 7, 5, 4, 2, 1, -2, -3, -5, -6, -8, -10,
-10, -13, -13, -15, -16, -18, -19, -20, -21, -21, -21, -23, -24, -23, -24, -23,
-25, -24, -24, -24, -23, -23, -23, -23, -22, -21, -20, -19, -17, -16, -14, -13,
-11, -10, -7, -5, -5, -2, 0, 3, 4, 6, 9, 11, 13, 16, 17, 20, 22, 24, 26, 29, 31,
32, 35, 36, 38, 40, 41, 43, 45, 47, 48, 49, 50, 52, 52, 53, 54, 54, 55, 55, 56,
55, 56, 55, 55, 54, 55, 53, 53, 52, 51, 50, 50, 48, 47, 46, 44, 43, 41, 40, 39,
38, 36, 35, 33, 31, 29, 28, 26, 25, 24, 22, 21, 19, 17, 17, 16, 15, 13, 12, 11,
10, 9, 8, 8, 6, 6, 5, 5, 4, 4, 2, 2, 3, 2, 2, 2, 0, 1, 0, 0, 0, 0, -1, 0, -1,
-2, -1, -3, -2, -2, -2, -4, -4, -4, -5, -7, -7, -8, -9, -9, -10, -10, -13, -14,
-14, -16, -17, -18, -20, -21, -22, -24, -25, -27, -28, -30, -32, -33, -34, -37,
-37, -39, -41, -43, -43, -45, -46, -47, -48, -49, -51, -51, -52, -53, -53, -55,
-55, -55, -55, -55, -55, -55, -55, -55, -54, -53, -53, -52, -50, -49, -49, -48,
-46, -45, -43, -42, -40, -38, -36, -34, -32, -30, -27, -26, -24, -22, -19, -17,
-14, -12, -10, -8, -6, -4, -1, 1, 3, 5, 7, 9, 10, 12, 13, 14, 16, 18, 18, 20,
21, 21, 23, 23, 24, 24, 24, 24, 25, 24, 24, 24, 24, 23, 23, 22, 21, 20, 20, 18,
18, 16, 14, 14, 12, 10, 9, 8, 6, 5, 2, 1, -1, -3, -4, -6, -7, -9, -10, -13, -14,
-15, -17, -19, -21, -23, -24, -26, -28, -30, -32, -33, -35, -36, -38, -39, -41,
-43, -44, -45, -48, -48, -50, -52, -53, -56, -57, -59, -60, -62, -63, -66, -66,
-69, -70, -71, -74, -76, -77, -78, -81, -82, -85, -86, -89, -90, -91, -94, -95,
-98, -100, -101, -102, -104, -106, -108, -109, -110, -112, -113, -114, -115,
-115, -116, -117, -118, -118, -118, -120, -119, -120, -119, -118, -119, -118,
-117, -115, -114, -112, -110, -110, -108, -105, -102, -101, -98, -96, -92, -88,
-85, -82, -78, -74, -70, -66, -62, -57, -54, -49, -44, -39, -34, -29, -25, -19,
-15, -9, -4, };