#define DATA_LENGTH 512
#define DATA AKWF_0923

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 3, 5, 6, 7, 9, 9, 11, 12, 14,
15, 16, 19, 21, 22, 23, 26, 27, 29, 31, 34, 36, 38, 40, 42, 44, 46, 49, 51, 54,
56, 59, 62, 63, 65, 68, 71, 73, 75, 77, 81, 83, 85, 87, 90, 92, 94, 95, 98, 99,
101, 103, 104, 106, 107, 109, 111, 112, 113, 115, 115, 116, 116, 118, 118, 119,
118, 118, 119, 119, 119, 119, 118, 117, 118, 117, 116, 116, 116, 115, 113, 113,
111, 110, 110, 109, 107, 106, 106, 103, 102, 100, 99, 99, 97, 96, 93, 93, 92,
90, 88, 86, 85, 84, 82, 80, 79, 78, 76, 75, 73, 72, 71, 69, 68, 67, 65, 64, 63,
62, 61, 59, 57, 56, 55, 54, 53, 52, 50, 49, 47, 45, 44, 43, 41, 39, 38, 37, 34,
34, 32, 30, 27, 27, 25, 23, 21, 18, 18, 16, 13, 12, 9, 7, 6, 3, 2, -1, -3, -4,
-7, -8, -11, -13, -15, -17, -18, -21, -22, -24, -26, -28, -29, -31, -33, -34,
-36, -37, -39, -40, -41, -42, -43, -45, -45, -47, -47, -47, -48, -49, -49, -50,
-50, -50, -51, -51, -50, -50, -51, -51, -50, -50, -48, -49, -49, -48, -48, -47,
-46, -45, -44, -43, -43, -43, -42, -40, -40, -39, -39, -38, -38, -37, -36, -36,
-35, -34, -34, -34, -33, -33, -32, -32, -33, -32, -31, -32, -32, -31, -31, -32,
-31, -32, -33, -32, -32, -33, -33, -34, -35, -35, -36, -35, -36, -37, -37, -38,
-38, -38, -39, -40, -40, -40, -41, -42, -42, -42, -43, -43, -44, -44, -44, -44,
-44, -44, -44, -44, -44, -44, -44, -43, -43, -42, -43, -43, -43, -42, -41, -41,
-41, -40, -39, -39, -38, -38, -37, -37, -36, -35, -35, -34, -34, -33, -33, -31,
-32, -31, -31, -30, -30, -29, -29, -28, -28, -29, -28, -27, -28, -27, -27, -28,
-27, -28, -27, -28, -27, -28, -29, -29, -29, -29, -29, -29, -31, -30, -30, -31,
-31, -32, -32, -32, -32, -33, -33, -34, -34, -34, -33, -34, -34, -35, -35, -34,
-35, -34, -35, -34, -34, -33, -33, -33, -33, -32, -31, -31, -31, -30, -29, -28,
-28, -27, -26, -25, -25, -24, -22, -22, -22, -21, -20, -19, -18, -16, -16, -15,
-13, -13, -13, -12, -11, -10, -10, -9, -8, -8, -7, -7, -7, -6, -7, -6, -7, -6,
-6, -7, -7, -7, -7, -8, -8, -9, -9, -10, -11, -11, -12, -13, -14, -14, -16, -16,
-18, -18, -19, -21, -22, -24, -24, -25, -26, -27, -28, -29, -30, -31, -33, -33,
-34, -34, -35, -35, -37, -37, -38, -38, -39, -40, -40, -40, -40, -41, -41, -40,
-41, -40, -41, -41, -40, -39, -40, -39, -39, -38, -38, -37, -37, -36, -35, -35,
-34, -34, -33, -31, -30, -29, -28, -29, -27, -26, -25, -24, -25, -23, -22, -21,
-21, -20, -19, -19, -18, -17, -16, -15, -14, -13, -13, -12, -11, -10, -10, -9,
-8, -8, -6, -6, -5, -4, -3, -2, -2, 0, };