#define DATA_LENGTH 512
#define DATA AKWF_0998

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 8, 11, 14, 17, 20, 23, 25,
28, 31, 33, 35, 39, 41, 44, 47, 49, 52, 54, 56, 59, 62, 64, 67, 68, 71, 74, 75,
77, 79, 82, 84, 86, 87, 89, 91, 93, 95, 97, 98, 99, 101, 102, 104, 105, 107,
107, 109, 109, 111, 112, 113, 114, 114, 116, 115, 117, 117, 117, 118, 118, 118,
118, 118, 118, 118, 118, 117, 117, 117, 117, 116, 116, 115, 114, 114, 113, 112,
112, 111, 109, 108, 107, 106, 105, 103, 102, 101, 99, 97, 96, 93, 92, 91, 88,
87, 85, 83, 80, 79, 77, 74, 71, 70, 67, 65, 63, 60, 58, 55, 52, 49, 48, 45, 42,
39, 36, 34, 31, 29, 26, 22, 20, 17, 14, 11, 9, 5, 3, 0, -3, -6, -9, -12, -14,
-17, -20, -23, -25, -29, -32, -34, -37, -39, -42, -45, -48, -50, -54, -56, -58,
-61, -63, -66, -68, -70, -72, -74, -77, -80, -81, -84, -86, -87, -89, -92, -92,
-94, -97, -98, -99, -101, -103, -103, -105, -106, -107, -109, -109, -111, -111,
-112, -114, -114, -115, -115, -115, -116, -116, -116, -118, -118, -118, -118,
-117, -117, -117, -116, -117, -116, -116, -115, -115, -114, -113, -113, -111,
-111, -110, -108, -107, -107, -105, -102, -101, -100, -100, -97, -96, -93, -91,
-90, -88, -86, -84, -82, -79, -77, -76, -73, -71, -69, -66, -64, -62, -59, -56,
-53, -51, -49, -45, -42, -40, -37, -35, -31, -29, -26, -23, -21, -17, -15, -12,
-8, -6, -1, 3, 10, 16, 21, 27, 32, 38, 44, 49, 55, 59, 64, 69, 74, 78, 83, 86,
91, 95, 98, 101, 103, 107, 108, 112, 113, 115, 116, 116, 117, 118, 118, 118,
118, 116, 116, 114, 113, 110, 108, 106, 103, 100, 96, 92, 89, 86, 81, 77, 74,
69, 63, 59, 53, 49, 43, 39, 32, 27, 22, 16, 11, 5, -1, -7, -12, -17, -24, -28,
-35, -40, -45, -50, -56, -59, -65, -70, -74, -79, -83, -87, -91, -94, -98, -100,
-103, -106, -109, -110, -113, -114, -115, -116, -118, -117, -118, -118, -117,
-116, -116, -115, -113, -110, -109, -106, -103, -101, -97, -93, -90, -86, -82,
-76, -73, -68, -62, -58, -52, -46, -40, -35, -29, -24, -17, -12, -5, 0, 2, 8,
13, 19, 26, 31, 37, 42, 48, 53, 58, 62, 68, 72, 78, 81, 86, 90, 93, 97, 100,
103, 106, 108, 110, 113, 115, 116, 117, 118, 118, 119, 119, 118, 118, 117, 115,
114, 112, 110, 109, 106, 103, 99, 96, 92, 89, 85, 82, 77, 72, 67, 63, 57, 52,
47, 41, 36, 30, 24, 19, 13, 7, 1, -5, -11, -16, -22, -27, -34, -39, -45, -50,
-55, -61, -65, -71, -75, -79, -84, -88, -91, -96, -98, -101, -106, -107, -110,
-112, -114, -115, -117, -118, -119, -119, -119, -120, -119, -118, -116, -116,
-114, -112, -110, -107, -105, -103, -99, -95, -91, -88, -84, -79, -75, -70, -65,
-61, -56, -50, -45, -39, -33, -28, -22, -16, -11, -3, };