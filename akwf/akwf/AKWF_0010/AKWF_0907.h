#define DATA_LENGTH 512
#define DATA AKWF_0907

const PROGMEM int8_t DATA[DATA_LENGTH] = {66, 71, 57, 56, 48, 46, 39, 39, 34,
33, 28, 29, 26, 27, 24, 25, 23, 23, 22, 22, 20, 21, 20, 20, 20, 20, 20, 20, 20,
19, 19, 20, 20, 19, 19, 20, 20, 19, 20, 20, 19, 21, 20, 20, 20, 19, 20, 20, 20,
20, 21, 21, 20, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 22, 22, 21,
22, 22, 21, 22, 22, 22, 21, 22, 22, 22, 22, 22, 22, 22, 23, 23, 23, 22, 22, 22,
23, 22, 23, 23, 22, 23, 22, 22, 24, 23, 23, 24, 23, 24, 23, 23, 23, 23, 24, 24,
24, 24, 24, 24, 24, 23, 25, 24, 23, 25, 24, 24, 24, 24, 25, 24, 24, 25, 24, 25,
24, 26, 24, 25, 25, 25, 25, 26, 26, 25, 25, 25, 25, 26, 25, 25, 26, 26, 26, 27,
27, 25, 26, 26, 26, 25, 26, 26, 26, 26, 26, 27, 27, 26, 26, 26, 27, 27, 27, 26,
26, 27, 27, 27, 27, 27, 28, 27, 27, 27, 27, 27, 27, 27, 27, 28, 28, 27, 28, 28,
27, 28, 28, 28, 28, 28, 28, 28, 28, 29, 28, 29, 28, 29, 28, 29, 28, 29, 28, 29,
29, 29, 29, 29, 29, 29, 30, 28, 30, 26, 50, 58, 52, 53, 50, 51, 49, 48, 46, 47,
46, 46, 46, 45, 45, 44, 45, 45, 44, 44, 43, 45, 43, 46, 43, 46, 42, 46, 41, 48,
41, 47, 41, 48, 39, 51, 34, -115, -107, -92, -87, -75, -73, -62, -62, -53, -54,
-47, -48, -42, -44, -39, -40, -37, -38, -35, -36, -34, -35, -34, -34, -34, -33,
-34, -32, -34, -33, -33, -32, -34, -32, -34, -31, -37, -17, -3, -10, -8, -13,
-13, -14, -15, -16, -16, -17, -17, -19, -19, -19, -19, -19, -19, -20, -20, -20,
-21, -21, -21, -21, -20, -20, -22, -21, -21, -22, -21, -22, -22, -22, -22, -22,
-23, -21, -22, -22, -23, -23, -22, -23, -22, -23, -22, -23, -23, -23, -22, -23,
-23, -23, -24, -23, -23, -23, -23, -24, -23, -23, -23, -24, -23, -23, -23, -24,
-24, -24, -24, -24, -24, -25, -24, -24, -24, -24, -24, -25, -24, -24, -24, -24,
-25, -25, -25, -24, -26, -24, -25, -25, -25, -25, -25, -25, -25, -25, -26, -26,
-26, -25, -26, -26, -26, -26, -26, -26, -26, -26, -25, -26, -26, -26, -26, -26,
-26, -26, -27, -27, -26, -27, -27, -26, -27, -27, -27, -27, -27, -28, -27, -27,
-27, -26, -27, -27, -27, -27, -27, -27, -27, -28, -28, -27, -28, -28, -28, -29,
-28, -28, -27, -28, -28, -29, -28, -29, -29, -28, -28, -29, -29, -28, -28, -28,
-29, -29, -28, -29, -29, -29, -28, -28, -29, -30, -29, -29, -28, -29, -29, -29,
-29, -29, -29, -30, -29, -30, -29, -29, -30, -30, -30, -30, -30, -29, -30, -30,
-29, -31, -30, -30, -31, -30, -30, -31, -31, -30, -31, -30, -31, -30, -31, -30,
-32, -30, -32, -29, -33, -26, };