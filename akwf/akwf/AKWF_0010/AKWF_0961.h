#define DATA_LENGTH 512
#define DATA AKWF_0961

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 8, 15, 23, 30, 37, 44, 50, 57, 62,
67, 71, 75, 80, 83, 86, 89, 92, 94, 97, 99, 100, 102, 103, 105, 106, 107, 109,
110, 110, 111, 112, 113, 113, 114, 114, 114, 115, 116, 117, 116, 117, 116, 117,
118, 118, 117, 118, 118, 119, 119, 118, 119, 119, 118, 119, 118, 119, 118, 119,
119, 119, 118, 120, 119, 120, 119, 119, 118, 119, 119, 119, 119, 119, 119, 118,
118, 119, 118, 119, 118, 118, 117, 118, 117, 117, 117, 116, 116, 116, 115, 115,
115, 115, 114, 113, 112, 112, 111, 110, 109, 109, 108, 107, 105, 104, 103, 100,
98, 96, 94, 91, 89, 86, 83, 79, 75, 71, 67, 61, 56, 50, 44, 37, 30, 22, 16, 6,
0, 9, 16, 24, 30, 37, 44, 51, 56, 62, 67, 71, 76, 80, 84, 87, 89, 92, 94, 97,
99, 101, 102, 104, 105, 106, 107, 108, 110, 110, 111, 111, 112, 113, 114, 114,
114, 114, 115, 116, 116, 116, 116, 116, 118, 117, 117, 118, 117, 118, 119, 118,
119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 118, 119,
119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 119, 118, 119, 117, 116,
118, 117, 117, 117, 116, 115, 115, 114, 115, 114, 113, 112, 112, 112, 111, 110,
109, 109, 108, 107, 105, 103, 103, 100, 98, 96, 94, 92, 89, 86, 82, 79, 75, 71,
66, 60, 56, 49, 43, 37, 30, 23, 15, 7, -1, -8, -17, -24, -32, -38, -45, -50,
-56, -61, -67, -72, -76, -80, -83, -87, -90, -92, -94, -97, -99, -100, -102,
-104, -105, -107, -108, -108, -110, -110, -111, -111, -112, -114, -114, -114,
-114, -115, -115, -115, -117, -116, -117, -117, -117, -117, -118, -117, -118,
-118, -118, -119, -118, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -120, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-118, -118, -118, -118, -118, -118, -117, -118, -117, -118, -116, -117, -116,
-117, -115, -115, -115, -115, -114, -113, -112, -112, -111, -111, -110, -110,
-107, -107, -106, -105, -103, -102, -100, -98, -96, -94, -91, -88, -85, -83,
-79, -76, -71, -66, -60, -55, -49, -43, -36, -30, -21, -14, -7, -7, -16, -23,
-30, -37, -44, -50, -57, -62, -67, -72, -76, -79, -83, -86, -89, -92, -94, -97,
-98, -100, -103, -103, -104, -106, -108, -109, -110, -110, -111, -112, -112,
-113, -113, -114, -115, -115, -116, -116, -115, -116, -117, -116, -117, -117,
-118, -118, -117, -118, -118, -118, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -120, -118, -119, -119,
-119, -119, -118, -118, -118, -118, -119, -118, -118, -117, -118, -117, -117,
-117, -117, -117, -116, -116, -116, -115, -114, -114, -114, -112, -112, -112,
-110, -110, -110, -108, -107, -105, -105, -104, -102, -100, -99, -97, -94, -91,
-89, -86, -83, -79, -76, -71, -67, -61, -55, -49, -43, -38, -29, -25, -4, -10,
-8, };