#define DATA_LENGTH 512
#define DATA AKWF_0954

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 12, 19, 24, 29, 35, 39, 44, 48, 51,
54, 57, 60, 63, 64, 66, 66, 64, 65, 67, 69, 68, 68, 65, 61, 53, 47, 52, 54, 53,
57, 62, 66, 68, 68, 69, 67, 65, 62, 61, 58, 56, 53, 51, 48, 45, 42, 39, 36, 33,
29, 28, 25, 24, 24, 23, 25, 27, 31, 36, 41, 43, 42, 44, 43, 42, 41, 40, 39, 39,
39, 40, 39, 39, 39, 38, 38, 36, 36, 35, 35, 33, 33, 33, 32, 31, 30, 30, 30, 29,
29, 28, 28, 26, 25, 24, 22, 20, 17, 14, 9, 5, -1, -8, -12, -12, -13, -15, -15,
-13, -11, -10, -8, -6, -4, -3, 0, 3, 7, 10, 14, 17, 22, 26, 29, 34, 37, 40, 43,
45, 48, 49, 51, 52, 53, 52, 51, 50, 49, 47, 45, 42, 40, 35, 32, 27, 24, 20, 15,
11, 6, 2, -4, -8, -13, -17, -22, -25, -29, -32, -35, -37, -39, -40, -43, -42,
-44, -48, -49, -51, -54, -57, -60, -63, -66, -69, -71, -73, -77, -79, -83, -86,
-89, -92, -96, -98, -101, -104, -107, -110, -112, -114, -115, -116, -117, -118,
-119, -119, -119, -118, -117, -115, -114, -111, -109, -106, -103, -99, -95, -90,
-86, -81, -76, -71, -65, -60, -55, -49, -43, -37, -32, -26, -21, -16, -10, -6,
-2, 2, 6, 9, 11, 13, 14, 14, 14, 13, 12, 8, 4, -2, -7, -10, -14, -18, -22, -24,
-27, -30, -32, -36, -38, -41, -43, -46, -48, -48, -51, -50, -50, -50, -51, -50,
-49, -48, -47, -47, -46, -43, -42, -42, -40, -39, -38, -38, -36, -35, -34, -35,
-34, -34, -34, -33, -33, -33, -34, -34, -35, -35, -36, -38, -39, -40, -42, -42,
-43, -44, -45, -47, -48, -48, -49, -49, -49, -49, -49, -48, -48, -47, -44, -42,
-40, -36, -33, -28, -24, -17, -10, -3, 5, 9, 15, 21, 25, 29, 32, 36, 39, 43, 45,
47, 49, 51, 51, 52, 50, 50, 49, 47, 45, 42, 38, 36, 32, 28, 24, 20, 15, 10, 6,
1, -4, -9, -13, -18, -23, -27, -32, -36, -39, -43, -47, -51, -55, -57, -59, -63,
-64, -67, -69, -69, -70, -72, -71, -71, -72, -71, -71, -69, -68, -66, -63, -60,
-59, -55, -52, -48, -44, -41, -36, -32, -28, -23, -17, -12, -8, -2, 3, 8, 13,
18, 23, 28, 32, 38, 42, 46, 51, 55, 58, 61, 65, 66, 68, 69, 71, 71, 69, 70, 67,
64, 62, 57, 52, 46, 39, 33, 29, 24, 20, 17, 12, 9, 4, 0, -3, -8, -10, -13, -16,
-18, -21, -21, -23, -24, -25, -25, -24, -25, -24, -23, -23, -23, -22, -21, -19,
-20, -18, -17, -15, -15, -14, -14, -12, -12, -11, -11, -10, -11, -11, -11, -10,
-11, -11, -12, -13, -14, -15, -15, -17, -17, -18, -20, -21, -23, -25, -26, -28,
-29, -30, -31, -33, -34, -35, -36, -37, -37, -37, -37, -38, -38, -36, -36, -33,
-32, -29, -25, -22, -17, -15, -3, -5, -2, };