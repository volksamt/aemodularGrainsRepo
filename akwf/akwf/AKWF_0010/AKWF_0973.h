#define DATA_LENGTH 512
#define DATA AKWF_0973

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 2, 2, 3, 4, 4, 4, 5, 5, 6, 7,
7, 7, 7, 9, 9, 10, 9, 10, 11, 12, 12, 12, 13, 14, 14, 14, 15, 15, 16, 16, 17,
17, 18, 19, 18, 19, 19, 21, 21, 21, 22, 22, 23, 23, 24, 24, 25, 25, 26, 26, 27,
27, 27, 28, 29, 29, 30, 31, 30, 31, 32, 33, 32, 33, 34, 34, 35, 35, 35, 36, 37,
37, 38, 38, 39, 39, 40, 40, 40, 42, 42, 42, 43, 43, 43, 44, 45, 45, 45, 46, 47,
47, 48, 49, 49, 49, 49, 50, 51, 51, 52, 52, 52, 53, 53, 54, 54, 56, 56, 57, 57,
57, 58, 58, 59, 59, 60, 60, 60, 61, 62, 62, 63, 63, 64, 64, 65, 66, 65, 66, 66,
66, 67, 68, 69, 69, 70, 69, 71, 72, 72, 73, 72, 74, 74, 74, 74, 76, 76, 76, 77,
78, 77, 78, 78, 79, 79, 80, 80, 81, 82, 83, 83, 83, 84, 84, 84, 85, 87, 86, 87,
88, 88, 88, 89, 89, 90, 91, 91, 91, 92, 92, 92, 93, 94, 95, 95, 95, 96, 96, 96,
97, 97, 98, 99, 99, 99, 100, 101, 102, 102, 102, 103, 103, 103, 105, 105, 105,
106, 107, 107, 107, 107, 108, 109, 109, 110, 110, 111, 111, 111, 112, 112, 113,
113, 115, 114, 115, 115, 116, 116, 118, 117, 118, 118, 120, 118, 111, 99, 85,
73, 60, 48, 37, 26, 16, 8, -1, -10, -16, -23, -29, -36, -40, -45, -50, -55, -59,
-62, -66, -70, -73, -76, -78, -80, -82, -85, -86, -89, -89, -91, -93, -93, -94,
-95, -97, -97, -98, -98, -98, -100, -101, -101, -101, -101, -101, -102, -101,
-102, -102, -102, -102, -101, -102, -102, -101, -101, -101, -101, -100, -100,
-100, -100, -98, -99, -98, -98, -98, -98, -98, -97, -97, -96, -96, -96, -94,
-94, -94, -94, -93, -93, -92, -93, -92, -90, -90, -90, -90, -89, -88, -89, -88,
-87, -87, -87, -86, -85, -85, -85, -84, -83, -83, -82, -82, -81, -80, -81, -79,
-80, -79, -79, -79, -78, -77, -76, -76, -76, -75, -75, -74, -74, -74, -72, -71,
-71, -71, -70, -70, -69, -69, -69, -68, -68, -67, -66, -66, -66, -65, -65, -64,
-64, -63, -63, -62, -61, -62, -61, -61, -60, -60, -59, -59, -57, -57, -57, -55,
-56, -55, -56, -54, -53, -53, -53, -52, -52, -52, -51, -50, -49, -49, -49, -48,
-49, -48, -47, -47, -46, -46, -45, -45, -44, -43, -42, -42, -42, -42, -40, -40,
-41, -40, -39, -38, -38, -38, -37, -37, -36, -36, -36, -34, -34, -33, -33, -33,
-32, -31, -31, -31, -30, -29, -28, -29, -28, -27, -26, -26, -26, -25, -25, -24,
-24, -24, -23, -23, -23, -21, -21, -20, -20, -19, -18, -18, -18, -18, -17, -17,
-16, -15, -15, -14, -14, -13, -13, -12, -11, -11, -11, -10, -9, -9, -9, -9, -8,
-7, -7, -7, -6, -6, -5, -4, -4, -3, -3, -2, -2, -2, -2, 0, 0, };