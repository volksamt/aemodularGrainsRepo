#define DATA_LENGTH 512
#define DATA AKWF_0985

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 5, 6, 8, 8, 10, 11, 13, 15,
16, 17, 18, 19, 21, 23, 23, 25, 26, 27, 28, 30, 31, 32, 34, 35, 35, 37, 38, 40,
41, 42, 44, 45, 46, 46, 49, 50, 51, 52, 54, 54, 56, 57, 59, 60, 61, 62, 63, 65,
65, 67, 68, 69, 70, 71, 72, 74, 75, 76, 77, 78, 79, 80, 80, 82, 83, 85, 86, 86,
87, 88, 89, 90, 91, 92, 93, 94, 94, 96, 97, 98, 99, 100, 100, 101, 101, 102,
104, 104, 106, 105, 106, 107, 108, 108, 109, 110, 111, 112, 112, 113, 113, 114,
114, 115, 114, 115, 115, 116, 116, 117, 117, 117, 117, 118, 118, 119, 118, 119,
119, 118, 119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 118, 118, 118,
118, 118, 117, 118, 117, 117, 116, 116, 115, 116, 115, 114, 115, 114, 113, 113,
112, 111, 112, 111, 111, 109, 108, 109, 108, 107, 106, 106, 105, 104, 104, 103,
102, 102, 100, 101, 100, 98, 98, 97, 96, 94, 94, 93, 93, 92, 90, 89, 89, 87, 87,
86, 84, 83, 83, 81, 80, 79, 77, 77, 76, 75, 73, 73, 72, 69, 69, 68, 67, 66, 64,
62, 62, 60, 59, 58, 57, 55, 54, 53, 52, 50, 49, 47, 46, 45, 44, 42, 41, 39, 38,
37, 36, 35, 33, 32, 30, 29, 27, 26, 25, 24, 22, 21, 20, 17, 17, 15, 14, 13, 11,
10, 9, 7, 5, 3, 2, 2, 1, -1, -2, -4, -5, -6, -7, -8, -11, -12, -13, -14, -15,
-17, -18, -19, -21, -22, -23, -25, -26, -27, -28, -30, -32, -32, -34, -35, -36,
-38, -39, -40, -42, -43, -43, -45, -46, -48, -49, -50, -51, -52, -54, -55, -56,
-58, -58, -59, -61, -62, -63, -64, -65, -67, -68, -69, -70, -71, -73, -73, -75,
-76, -78, -78, -79, -80, -81, -82, -83, -84, -86, -87, -87, -89, -89, -91, -92,
-92, -94, -94, -95, -96, -97, -98, -99, -99, -100, -101, -102, -103, -104, -104,
-105, -106, -106, -107, -108, -109, -109, -110, -110, -111, -111, -113, -113,
-114, -114, -115, -115, -116, -116, -116, -117, -117, -118, -117, -117, -118,
-118, -118, -119, -118, -119, -119, -119, -119, -119, -118, -118, -119, -118,
-119, -119, -118, -119, -119, -118, -118, -118, -118, -118, -117, -117, -117,
-117, -116, -117, -115, -115, -115, -113, -113, -112, -113, -112, -112, -111,
-111, -110, -109, -109, -109, -107, -107, -107, -105, -106, -105, -104, -102,
-102, -102, -101, -100, -99, -99, -97, -96, -96, -95, -94, -93, -92, -91, -90,
-89, -89, -88, -87, -85, -85, -83, -82, -82, -81, -79, -78, -77, -76, -74, -73,
-72, -71, -70, -68, -67, -66, -64, -64, -63, -61, -60, -58, -58, -57, -55, -53,
-52, -51, -51, -49, -47, -46, -45, -44, -42, -41, -39, -38, -37, -36, -34, -33,
-31, -30, -29, -28, -25, -24, -24, -22, -21, -19, -17, -17, -15, -14, -13, -11,
-10, -9, -7, -6, -3, -3, -1, 0, };