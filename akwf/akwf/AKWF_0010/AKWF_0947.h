#define DATA_LENGTH 512
#define DATA AKWF_0947

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 7, 8, 9, 11, 12, 14, 16,
18, 19, 22, 23, 25, 28, 30, 32, 34, 36, 37, 41, 43, 44, 47, 48, 50, 52, 54, 55,
58, 60, 60, 62, 63, 65, 66, 68, 68, 70, 70, 72, 73, 73, 74, 75, 75, 76, 77, 77,
78, 78, 79, 79, 80, 80, 81, 81, 81, 80, 80, 81, 82, 82, 82, 82, 82, 83, 83, 83,
84, 84, 84, 84, 84, 84, 84, 84, 84, 84, 85, 85, 86, 86, 86, 86, 86, 86, 86, 87,
86, 88, 88, 88, 88, 89, 90, 91, 92, 92, 92, 93, 94, 95, 96, 96, 98, 99, 99, 101,
102, 103, 104, 105, 105, 106, 107, 107, 108, 109, 108, 109, 108, 109, 110, 109,
109, 107, 105, 104, 104, 103, 101, 99, 97, 93, 91, 89, 87, 84, 81, 77, 72, 68,
66, 62, 58, 53, 47, 42, 38, 33, 31, 27, 20, 10, 1, -4, -4, 2, 14, 26, 39, 47,
54, 59, 66, 74, 81, 88, 92, 96, 99, 101, 104, 107, 108, 108, 108, 107, 107, 107,
107, 105, 104, 101, 99, 98, 96, 95, 95, 93, 92, 90, 88, 88, 88, 87, 86, 85, 85,
84, 83, 83, 84, 83, 82, 82, 82, 83, 82, 83, 82, 81, 80, 81, 80, 80, 79, 79, 78,
78, 78, 78, 75, 75, 75, 74, 72, 72, 71, 69, 68, 66, 64, 63, 62, 60, 56, 54, 52,
50, 47, 44, 42, 38, 36, 33, 29, 26, 24, 22, 18, 16, 14, 12, 9, 8, 6, 3, 1, 1,
-1, -3, -4, -5, -8, -8, -11, -11, -14, -15, -17, -19, -21, -23, -26, -28, -30,
-32, -35, -38, -41, -43, -46, -48, -52, -54, -57, -60, -62, -65, -67, -69, -72,
-74, -76, -77, -79, -79, -81, -83, -84, -85, -86, -86, -87, -88, -88, -89, -90,
-91, -90, -91, -90, -92, -92, -93, -92, -93, -92, -93, -94, -94, -95, -94, -94,
-94, -94, -95, -95, -95, -96, -96, -96, -97, -97, -99, -99, -100, -101, -102,
-104, -104, -106, -107, -109, -109, -111, -113, -114, -116, -117, -118, -117,
-119, -119, -119, -118, -117, -115, -114, -111, -109, -106, -102, -97, -91, -85,
-79, -74, -68, -60, -50, -40, -30, -25, -25, -28, -35, -45, -53, -61, -67, -73,
-80, -86, -92, -96, -101, -104, -107, -109, -113, -115, -117, -118, -117, -118,
-119, -118, -118, -117, -116, -114, -113, -111, -111, -109, -108, -106, -105,
-103, -102, -101, -100, -99, -98, -98, -97, -95, -96, -96, -95, -95, -94, -94,
-94, -93, -94, -93, -93, -92, -93, -93, -92, -93, -92, -91, -91, -91, -91, -90,
-89, -90, -90, -89, -88, -88, -87, -87, -87, -86, -86, -85, -85, -83, -83, -82,
-82, -80, -79, -78, -76, -75, -74, -73, -71, -69, -66, -64, -62, -61, -60, -57,
-55, -52, -50, -47, -46, -44, -41, -38, -35, -34, -31, -31, -29, -26, -24, -22,
-20, -18, -18, -17, -15, -11, -8, -5, -4, -4, -7, -8, -9, -8, -7, -4, -2, -2,
-1, 0, };