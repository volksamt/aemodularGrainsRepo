#define DATA_LENGTH 512
#define DATA AKWF_0974

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 6, 9, 9, 11, 13, 14, 16, 19,
20, 21, 23, 24, 26, 28, 30, 32, 33, 35, 37, 39, 40, 42, 44, 45, 47, 48, 51, 51,
55, 56, 58, 60, 61, 63, 65, 66, 69, 71, 72, 74, 76, 77, 80, 81, 83, 85, 87, 88,
90, 93, 95, 96, 98, 99, 101, 103, 105, 107, 109, 111, 113, 114, 116, 118, 119,
119, 119, 118, 116, 115, 113, 111, 109, 106, 105, 102, 100, 99, 96, 95, 92, 90,
88, 85, 84, 82, 81, 79, 77, 76, 74, 72, 71, 70, 68, 68, 66, 64, 63, 62, 61, 60,
59, 58, 57, 56, 55, 54, 54, 53, 52, 52, 51, 50, 50, 49, 49, 49, 47, 48, 47, 46,
47, 46, 46, 45, 45, 45, 45, 45, 46, 45, 45, 45, 45, 45, 45, 45, 46, 47, 46, 47,
46, 47, 47, 47, 49, 48, 49, 49, 50, 51, 51, 51, 52, 53, 53, 53, 55, 55, 55, 56,
57, 57, 58, 58, 60, 61, 61, 62, 63, 65, 65, 67, 67, 68, 69, 69, 70, 71, 72, 74,
74, 76, 77, 78, 78, 80, 81, 81, 83, 84, 84, 83, 82, 81, 78, 75, 73, 71, 69, 65,
62, 60, 57, 54, 52, 49, 46, 44, 41, 39, 37, 34, 32, 30, 27, 24, 24, 20, 19, 16,
15, 13, 12, 10, 8, 6, 5, 4, 2, 1, -1, -2, -3, -5, -6, -7, -8, -9, -10, -11, -12,
-12, -13, -15, -16, -16, -17, -17, -19, -18, -18, -19, -20, -21, -21, -22, -22,
-23, -22, -23, -23, -23, -24, -23, -23, -23, -24, -23, -23, -23, -23, -24, -23,
-23, -23, -23, -23, -22, -22, -22, -21, -21, -21, -20, -19, -20, -18, -18, -18,
-17, -17, -17, -15, -14, -14, -13, -13, -12, -11, -11, -10, -9, -9, -8, -6, -6,
-5, -5, -4, -2, -2, -1, 1, 1, 2, 3, 4, 5, 5, 4, 2, 0, -2, -4, -7, -10, -12, -16,
-19, -20, -23, -27, -30, -33, -35, -38, -41, -43, -46, -48, -50, -53, -54, -57,
-60, -62, -63, -65, -68, -69, -71, -73, -75, -76, -78, -80, -81, -82, -85, -85,
-87, -89, -90, -91, -92, -93, -94, -95, -96, -97, -99, -99, -100, -100, -101,
-102, -103, -103, -104, -105, -105, -105, -106, -107, -108, -108, -108, -108,
-108, -108, -110, -108, -109, -108, -109, -110, -109, -109, -108, -110, -108,
-110, -109, -108, -109, -108, -107, -107, -108, -107, -107, -107, -105, -106,
-106, -105, -104, -104, -103, -103, -103, -102, -101, -100, -100, -98, -99, -97,
-97, -96, -95, -94, -93, -93, -93, -92, -91, -90, -89, -88, -87, -86, -85, -84,
-82, -82, -81, -81, -80, -78, -76, -76, -75, -74, -72, -72, -71, -69, -68, -67,
-66, -64, -63, -61, -61, -60, -58, -57, -56, -55, -53, -51, -51, -50, -48, -46,
-45, -44, -42, -41, -39, -38, -37, -35, -33, -32, -30, -30, -28, -27, -25, -23,
-23, -21, -19, -17, -15, -14, -13, -12, -9, -8, -6, -5, -3, -2, 0, };