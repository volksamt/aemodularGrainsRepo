#define DATA_LENGTH 512
#define DATA AKWF_0977

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 13, 19, 25, 31, 36, 42, 49, 54,
59, 65, 70, 75, 79, 83, 88, 92, 95, 99, 102, 105, 108, 110, 113, 114, 116, 117,
118, 118, 119, 119, 118, 118, 118, 116, 115, 115, 112, 110, 108, 106, 103, 100,
97, 94, 91, 87, 84, 81, 78, 73, 70, 67, 63, 60, 57, 53, 49, 46, 43, 40, 36, 33,
30, 27, 25, 23, 21, 19, 17, 15, 14, 13, 11, 11, 10, 9, 8, 8, 7, 8, 8, 7, 8, 9,
9, 9, 10, 11, 12, 13, 13, 14, 15, 16, 17, 17, 18, 18, 19, 20, 20, 20, 20, 22,
20, 20, 20, 20, 19, 19, 18, 17, 15, 14, 13, 11, 10, 8, 6, 4, 2, 0, -2, -4, -7,
-10, -12, -15, -18, -20, -22, -25, -29, -30, -34, -35, -38, -41, -43, -45, -47,
-49, -51, -52, -54, -56, -57, -57, -59, -60, -60, -62, -61, -62, -61, -62, -61,
-61, -60, -59, -58, -57, -56, -54, -53, -51, -51, -49, -46, -44, -43, -41, -39,
-37, -35, -33, -32, -29, -27, -27, -24, -22, -21, -19, -18, -17, -15, -15, -13,
-13, -13, -12, -12, -11, -12, -13, -12, -13, -13, -14, -15, -15, -16, -18, -19,
-21, -22, -22, -25, -26, -28, -28, -31, -32, -34, -35, -37, -38, -40, -40, -41,
-43, -44, -44, -45, -45, -47, -46, -47, -47, -46, -45, -46, -44, -43, -42, -40,
-39, -37, -36, -32, -31, -29, -25, -22, -20, -17, -12, -10, -6, -3, 1, 5, 8, 12,
15, 20, 23, 26, 30, 34, 37, 41, 45, 47, 50, 53, 56, 59, 61, 64, 65, 68, 69, 70,
70, 72, 72, 74, 74, 73, 73, 72, 72, 71, 70, 68, 66, 65, 62, 60, 58, 55, 53, 49,
47, 44, 40, 37, 34, 31, 28, 24, 21, 17, 15, 11, 8, 4, 2, -1, -3, -6, -8, -11,
-12, -15, -17, -18, -19, -21, -22, -23, -22, -23, -22, -22, -22, -22, -20, -20,
-18, -16, -15, -13, -11, -9, -6, -4, -1, 2, 4, 7, 9, 13, 16, 19, 21, 25, 28, 31,
33, 37, 39, 41, 44, 46, 49, 50, 53, 55, 56, 57, 59, 59, 61, 61, 62, 62, 61, 62,
62, 61, 60, 59, 59, 58, 56, 54, 52, 51, 48, 46, 44, 41, 39, 37, 34, 31, 28, 26,
23, 20, 18, 15, 11, 9, 5, 3, 0, -2, -5, -7, -10, -11, -14, -17, -18, -20, -21,
-23, -25, -26, -27, -29, -29, -30, -31, -32, -33, -33, -33, -34, -34, -35, -36,
-36, -37, -37, -37, -36, -37, -38, -39, -38, -38, -38, -40, -41, -41, -42, -42,
-43, -43, -45, -47, -48, -49, -50, -51, -54, -55, -58, -59, -60, -62, -64, -66,
-69, -71, -74, -75, -77, -80, -81, -84, -87, -88, -90, -91, -94, -94, -96, -98,
-99, -100, -100, -101, -102, -102, -102, -102, -102, -102, -100, -99, -98, -96,
-95, -92, -90, -87, -84, -80, -77, -74, -69, -66, -62, -57, -52, -47, -43, -37,
-31, -27, -20, -14, -9, -2, };