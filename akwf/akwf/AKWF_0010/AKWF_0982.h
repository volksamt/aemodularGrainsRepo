#define DATA_LENGTH 512
#define DATA AKWF_0982

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 8, 12, 14, 17, 19, 22, 24,
25, 27, 29, 30, 31, 32, 33, 34, 36, 37, 38, 39, 41, 43, 45, 48, 51, 54, 57, 61,
64, 68, 73, 76, 81, 85, 90, 94, 98, 101, 105, 108, 109, 112, 114, 116, 118, 119,
119, 119, 119, 118, 118, 116, 116, 115, 114, 112, 111, 109, 108, 106, 105, 103,
101, 98, 96, 94, 91, 89, 87, 84, 80, 77, 73, 68, 64, 59, 54, 48, 43, 38, 31, 26,
19, 14, 9, 4, -2, -6, -10, -15, -18, -21, -25, -28, -31, -33, -34, -37, -39,
-40, -42, -45, -47, -49, -51, -54, -57, -60, -63, -66, -70, -72, -74, -78, -80,
-83, -85, -87, -88, -90, -91, -92, -92, -93, -94, -94, -94, -94, -95, -95, -95,
-95, -94, -96, -95, -94, -95, -94, -95, -93, -93, -92, -91, -90, -88, -86, -84,
-81, -79, -76, -74, -70, -66, -63, -59, -56, -53, -49, -45, -41, -37, -33, -30,
-26, -22, -18, -15, -11, -7, -4, -1, 2, 4, 6, 10, 11, 14, 15, 17, 18, 20, 22,
22, 23, 23, 25, 26, 26, 27, 27, 28, 28, 29, 29, 30, 29, 30, 30, 29, 29, 27, 27,
26, 25, 23, 22, 21, 19, 18, 16, 16, 15, 13, 12, 13, 12, 13, 13, 14, 14, 15, 15,
16, 17, 17, 16, 17, 16, 15, 15, 13, 12, 10, 8, 7, 5, 3, 2, 1, 0, -1, -2, -2, -2,
-2, -1, -1, 0, 0, 2, 2, 2, 2, 3, 4, 3, 3, 2, 3, 3, 3, 2, 2, 2, 2, 2, 3, 4, 4, 6,
6, 9, 11, 14, 16, 19, 23, 26, 29, 34, 38, 42, 46, 50, 55, 58, 61, 64, 68, 70,
71, 75, 76, 77, 78, 80, 80, 80, 81, 80, 80, 80, 79, 80, 79, 78, 77, 77, 76, 75,
74, 73, 73, 71, 69, 68, 66, 65, 63, 61, 59, 57, 54, 51, 49, 45, 42, 39, 36, 32,
28, 24, 20, 17, 14, 9, 6, 3, -1, -3, -5, -8, -10, -11, -13, -15, -17, -18, -20,
-20, -21, -22, -23, -24, -26, -28, -29, -31, -34, -36, -37, -39, -43, -46, -49,
-50, -55, -57, -59, -62, -64, -66, -67, -69, -70, -69, -72, -72, -72, -70, -70,
-70, -69, -68, -67, -67, -67, -66, -66, -66, -66, -67, -67, -68, -69, -70, -71,
-71, -71, -72, -73, -73, -73, -72, -71, -70, -69, -67, -66, -63, -61, -58, -55,
-53, -50, -48, -44, -42, -40, -38, -36, -33, -33, -31, -29, -28, -28, -27, -26,
-25, -24, -23, -22, -22, -21, -20, -18, -16, -16, -14, -13, -10, -9, -8, -7, -5,
-4, -3, -2, -2, -3, -2, -2, -2, -3, -3, -5, -5, -6, -7, -8, -9, -10, -11, -12,
-13, -15, -16, -17, -19, -20, -21, -22, -22, -22, -22, -24, -23, -22, -22, -21,
-21, -21, -19, -18, -17, -16, -16, -15, -14, -13, -14, -14, -14, -14, -14, -15,
-15, -16, -15, -16, -15, -15, -13, -13, -11, -10, -7, -4, -2, };