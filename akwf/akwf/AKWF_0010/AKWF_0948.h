#define DATA_LENGTH 512
#define DATA AKWF_0948

const PROGMEM int8_t DATA[DATA_LENGTH] = {16, 20, 19, 22, 21, 24, 23, 25, 25,
27, 28, 29, 30, 31, 31, 33, 33, 35, 36, 36, 38, 39, 40, 40, 42, 43, 43, 44, 46,
47, 48, 47, 55, 62, 61, 62, 62, 64, 65, 66, 67, 67, 69, 69, 70, 71, 72, 72, 73,
74, 74, 75, 75, 77, 78, 78, 79, 80, 81, 82, 82, 82, 83, 84, 84, 85, 87, 83, 72,
71, 72, 72, 73, 73, 74, 74, 75, 76, 76, 77, 76, 78, 78, 79, 78, 79, 81, 80, 80,
82, 83, 83, 84, 84, 85, 85, 85, 85, 86, 87, 87, 88, 88, 89, 89, 90, 90, 91, 92,
91, 93, 93, 93, 94, 94, 95, 96, 95, 96, 96, 96, 97, 97, 98, 98, 97, 103, 107,
114, 115, 115, 115, 115, 116, 115, 116, 115, 116, 116, 116, 116, 116, 116, 116,
116, 116, 116, 117, 116, 117, 116, 114, 114, 113, 114, 113, 113, 112, 111, 110,
110, 109, 109, 108, 109, 107, 108, 106, 106, 106, 105, 105, 103, 104, 103, 102,
102, 102, 100, 101, 99, 99, 98, 98, 97, 96, 96, 95, 95, 93, 94, 85, 82, 81, 80,
76, 63, 62, 61, 61, 60, 59, 58, 57, 56, 56, 56, 55, 54, 54, 52, 51, 51, 50, 50,
49, 49, 47, 48, 45, 46, 44, 45, 38, 32, 33, 32, 29, 19, 19, 18, 18, 18, 16, 9,
10, 8, 9, 6, 12, 28, 24, 25, 23, 24, 24, 23, 22, 22, 22, 21, 21, 21, 18, 24, 26,
23, 22, 22, 22, 20, 19, 19, 19, 18, 17, 15, 15, 14, 13, 12, 12, 11, 10, 10, 8,
7, 6, 5, 4, 3, 3, 2, 2, 0, -1, -2, 0, -22, -70, -85, -88, -89, -89, -88, -87,
-88, -86, -86, -86, -86, -85, -85, -85, -85, -85, -85, -85, -86, -85, -86, -86,
-86, -86, -86, -87, -87, -87, -87, -88, -88, -89, -87, -93, -105, -106, -106,
-107, -106, -108, -108, -108, -108, -109, -109, -109, -110, -109, -110, -110,
-110, -111, -112, -112, -112, -112, -112, -113, -113, -113, -113, -114, -114,
-114, -115, -114, -115, -116, -116, -115, -116, -117, -117, -117, -118, -118,
-118, -118, -118, -118, -118, -119, -118, -118, -119, -118, -120, -119, -118,
-120, -119, -120, -113, -110, -102, -102, -102, -102, -102, -102, -102, -101,
-101, -100, -100, -101, -99, -100, -100, -100, -99, -98, -98, -98, -97, -97,
-98, -97, -96, -96, -96, -96, -95, -94, -94, -94, -93, -93, -93, -92, -92, -90,
-91, -89, -90, -89, -88, -88, -88, -88, -87, -86, -86, -86, -84, -84, -83, -82,
-81, -81, -79, -79, -77, -77, -74, -74, -73, -63, -60, -61, -57, -64, -73, -74,
-71, -71, -69, -69, -67, -66, -65, -65, -64, -63, -61, -61, -60, -58, -56, -56,
-56, -54, -54, -52, -52, -50, -50, -48, -49, -41, -35, -36, -34, -34, -32, -32,
-30, -30, -27, -27, -26, -27, -25, -25, -21, -29, -43, -38, -40, -37, -37, -36,
-36, -35, -33, -33, -29, -22, -22, -21, -15, -11, };