#define DATA_LENGTH 512
#define DATA AKWF_0965

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 11, 15, 20, 23, 27, 30, 34, 38,
41, 44, 47, 51, 52, 56, 58, 61, 63, 66, 67, 70, 72, 74, 75, 77, 79, 81, 82, 83,
85, 85, 86, 88, 88, 89, 90, 91, 91, 91, 91, 92, 92, 93, 93, 93, 93, 93, 93, 93,
93, 93, 93, 91, 93, 92, 91, 91, 90, 90, 89, 88, 88, 87, 86, 85, 85, 84, 84, 82,
82, 81, 80, 79, 78, 77, 76, 75, 75, 74, 72, 72, 70, 70, 68, 68, 66, 66, 64, 63,
63, 61, 61, 59, 58, 57, 55, 55, 54, 52, 51, 50, 49, 47, 46, 45, 44, 42, 42, 41,
39, 39, 38, 37, 35, 35, 34, 32, 32, 32, 31, 30, 30, 30, 29, 29, 29, 29, 29, 28,
29, 28, 28, 29, 29, 30, 29, 29, 30, 30, 30, 31, 32, 32, 32, 34, 35, 35, 36, 36,
38, 38, 40, 40, 41, 42, 42, 44, 46, 46, 48, 49, 50, 51, 52, 53, 54, 56, 55, 58,
58, 60, 61, 63, 63, 65, 67, 68, 69, 70, 71, 73, 74, 76, 77, 78, 80, 82, 83, 83,
85, 86, 87, 89, 91, 91, 94, 94, 96, 97, 99, 99, 101, 102, 103, 106, 107, 108,
110, 110, 113, 112, 112, 112, 111, 109, 108, 105, 102, 99, 96, 92, 88, 84, 80,
76, 71, 67, 61, 57, 52, 48, 43, 38, 34, 29, 25, 20, 15, 10, 6, 1, -2, -7, -10,
-15, -20, -23, -26, -30, -33, -36, -41, -43, -47, -48, -51, -54, -57, -60, -62,
-64, -66, -68, -70, -72, -74, -75, -77, -78, -80, -81, -82, -83, -84, -86, -86,
-86, -88, -88, -88, -89, -88, -90, -91, -90, -90, -90, -90, -90, -90, -90, -89,
-89, -89, -88, -88, -88, -87, -87, -85, -85, -85, -84, -84, -83, -82, -81, -80,
-80, -78, -78, -77, -76, -76, -75, -74, -73, -72, -70, -70, -68, -67, -67, -65,
-64, -63, -61, -61, -60, -58, -57, -57, -56, -55, -53, -53, -51, -50, -48, -48,
-46, -45, -43, -43, -42, -40, -39, -38, -36, -36, -35, -34, -33, -33, -31, -31,
-30, -29, -29, -27, -27, -27, -25, -25, -24, -25, -24, -23, -24, -24, -22, -22,
-23, -23, -22, -22, -23, -23, -23, -23, -23, -24, -24, -24, -24, -24, -25, -26,
-27, -27, -28, -29, -29, -29, -30, -31, -31, -32, -33, -33, -34, -35, -36, -37,
-37, -38, -40, -40, -41, -41, -43, -44, -45, -46, -47, -48, -49, -50, -50, -52,
-52, -54, -54, -56, -57, -58, -59, -60, -62, -63, -63, -64, -66, -67, -68, -69,
-70, -71, -72, -74, -75, -76, -77, -78, -80, -80, -82, -83, -85, -85, -86, -88,
-89, -90, -90, -92, -94, -94, -96, -97, -97, -100, -101, -101, -103, -103, -105,
-106, -108, -108, -110, -111, -112, -114, -115, -116, -117, -118, -119, -119,
-119, -117, -116, -114, -112, -109, -106, -103, -99, -96, -91, -87, -83, -79,
-73, -69, -64, -59, -54, -49, -44, -40, -34, -30, -25, -20, -15, -11, -3, 1, -2,
};