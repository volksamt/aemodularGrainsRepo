#define DATA_LENGTH 512
#define DATA AKWF_0925

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 11, 15, 21, 26, 31, 37, 43, 49,
54, 59, 65, 69, 75, 80, 85, 90, 93, 97, 100, 105, 108, 110, 113, 114, 117, 117,
118, 119, 119, 119, 118, 117, 117, 116, 114, 113, 111, 110, 108, 106, 102, 101,
98, 95, 94, 91, 89, 87, 84, 82, 80, 77, 75, 73, 71, 69, 67, 64, 63, 61, 58, 56,
54, 52, 50, 48, 46, 44, 42, 40, 37, 36, 33, 31, 30, 27, 25, 23, 20, 18, 16, 14,
12, 10, 9, 6, 5, 2, 2, -1, -2, -3, -6, -7, -8, -10, -11, -12, -13, -14, -16,
-15, -17, -18, -19, -20, -20, -21, -22, -22, -23, -24, -25, -25, -26, -26, -27,
-28, -29, -29, -29, -30, -30, -31, -31, -33, -33, -33, -33, -33, -33, -34, -34,
-34, -34, -34, -33, -33, -34, -33, -33, -32, -31, -31, -32, -31, -31, -32, -31,
-30, -30, -30, -30, -30, -29, -29, -29, -29, -29, -29, -28, -29, -29, -29, -28,
-28, -27, -27, -26, -26, -26, -26, -25, -25, -24, -25, -24, -24, -23, -23, -23,
-22, -23, -22, -22, -23, -22, -23, -23, -23, -24, -25, -25, -24, -24, -26, -26,
-26, -27, -27, -28, -29, -29, -29, -29, -29, -31, -31, -32, -32, -32, -33, -33,
-33, -33, -35, -34, -35, -36, -35, -37, -37, -38, -38, -38, -38, -39, -40, -40,
-40, -40, -40, -41, -41, -42, -41, -42, -41, -41, -41, -40, -40, -39, -37, -36,
-35, -33, -31, -30, -27, -25, -22, -19, -16, -13, -9, -6, -2, 3, 7, 10, 15, 19,
24, 28, 32, 37, 41, 45, 49, 53, 56, 60, 64, 66, 68, 71, 73, 73, 76, 76, 76, 77,
77, 77, 76, 75, 74, 73, 71, 69, 68, 67, 65, 63, 60, 58, 56, 54, 51, 50, 47, 44,
43, 41, 39, 38, 36, 33, 32, 31, 29, 28, 26, 25, 23, 23, 22, 20, 19, 18, 17, 16,
14, 13, 12, 12, 9, 9, 9, 8, 7, 6, 5, 3, 2, 2, 1, 0, 0, -2, -3, -2, -4, -4, -4,
-5, -5, -5, -7, -6, -7, -6, -7, -7, -7, -7, -7, -7, -7, -6, -7, -6, -6, -6, -6,
-6, -6, -6, -6, -6, -6, -6, -6, -6, -7, -6, -7, -7, -7, -8, -8, -9, -9, -8, -9,
-10, -10, -9, -10, -10, -10, -11, -10, -11, -10, -10, -11, -12, -12, -11, -11,
-12, -12, -13, -13, -13, -15, -15, -16, -16, -17, -18, -18, -19, -20, -21, -22,
-23, -22, -24, -24, -24, -26, -26, -27, -28, -28, -28, -29, -29, -30, -30, -32,
-31, -32, -33, -34, -34, -35, -35, -36, -38, -38, -39, -40, -40, -41, -43, -43,
-45, -45, -46, -47, -48, -48, -48, -50, -51, -51, -52, -51, -53, -53, -54, -54,
-54, -53, -54, -54, -55, -54, -54, -54, -54, -54, -54, -54, -54, -54, -54, -53,
-54, -52, -52, -52, -51, -51, -50, -49, -48, -47, -47, -46, -43, -42, -41, -39,
-37, -35, -33, -31, -28, -24, -21, -18, -15, -11, -6, -2, };