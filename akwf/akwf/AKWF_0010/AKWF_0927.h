#define DATA_LENGTH 512
#define DATA AKWF_0927

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 11, 16, 21, 26, 31, 36, 41, 46,
51, 55, 59, 64, 68, 72, 77, 80, 83, 87, 92, 94, 97, 100, 102, 105, 107, 109,
111, 112, 114, 116, 116, 118, 118, 118, 119, 120, 119, 118, 118, 118, 118, 117,
115, 114, 113, 111, 109, 109, 107, 105, 103, 101, 100, 97, 95, 93, 90, 89, 86,
83, 82, 79, 77, 74, 71, 70, 68, 65, 64, 61, 59, 56, 54, 52, 50, 48, 46, 44, 41,
40, 38, 37, 35, 33, 32, 30, 29, 27, 25, 24, 23, 21, 20, 19, 17, 16, 15, 14, 14,
13, 12, 10, 9, 8, 8, 7, 7, 5, 4, 3, 3, 1, 2, 1, -1, -1, -1, -2, -3, -3, -4, -4,
-5, -6, -6, -7, -7, -9, -8, -9, -10, -10, -10, -9, -10, -10, -11, -10, -10, -11,
-11, -11, -12, -11, -11, -11, -11, -11, -11, -12, -11, -11, -11, -10, -10, -10,
-11, -11, -10, -11, -10, -10, -11, -11, -10, -10, -11, -11, -11, -12, -12, -12,
-13, -13, -13, -15, -15, -16, -18, -18, -19, -19, -21, -22, -24, -25, -27, -28,
-29, -31, -33, -33, -36, -38, -38, -40, -41, -44, -46, -48, -49, -51, -52, -53,
-56, -57, -59, -60, -61, -63, -64, -66, -66, -67, -68, -70, -70, -70, -71, -71,
-71, -71, -71, -70, -70, -71, -69, -69, -67, -66, -66, -64, -63, -60, -59, -57,
-55, -52, -50, -47, -44, -42, -39, -36, -33, -31, -27, -24, -21, -17, -13, -10,
-7, -3, 0, 4, 7, 10, 14, 17, 22, 25, 27, 31, 33, 37, 40, 42, 46, 48, 50, 53, 55,
57, 59, 61, 63, 64, 65, 66, 67, 68, 69, 70, 70, 72, 71, 71, 71, 71, 71, 70, 70,
68, 68, 67, 66, 66, 64, 63, 61, 61, 59, 56, 54, 54, 52, 50, 49, 46, 45, 44, 42,
40, 38, 37, 35, 33, 31, 31, 28, 28, 26, 25, 24, 22, 22, 20, 19, 18, 17, 16, 15,
15, 14, 14, 13, 13, 12, 11, 11, 10, 11, 11, 11, 11, 10, 10, 10, 10, 10, 10, 11,
10, 11, 11, 11, 10, 11, 11, 12, 11, 11, 11, 11, 12, 11, 11, 12, 11, 10, 10, 10,
11, 10, 9, 9, 10, 8, 8, 8, 7, 7, 8, 6, 6, 5, 4, 4, 4, 4, 3, 1, 1, 0, -1, -2, -2,
-4, -4, -4, -5, -6, -7, -8, -9, -9, -11, -11, -13, -14, -15, -16, -17, -18, -19,
-21, -22, -23, -25, -26, -27, -29, -29, -32, -34, -36, -36, -39, -41, -42, -44,
-46, -48, -51, -52, -55, -57, -59, -62, -63, -65, -68, -70, -72, -74, -77, -80,
-82, -84, -86, -89, -91, -93, -95, -98, -100, -102, -104, -106, -107, -109,
-111, -113, -114, -114, -116, -116, -117, -118, -119, -119, -119, -119, -119,
-119, -118, -117, -117, -115, -115, -112, -110, -108, -107, -104, -103, -99,
-96, -94, -90, -87, -83, -80, -76, -72, -67, -63, -59, -54, -49, -45, -40, -35,
-30, -25, -21, -14, -9, -3, };