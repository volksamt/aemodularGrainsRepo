#define DATA_LENGTH 512
#define DATA AKWF_0970

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 10, 11, 14, 17, 20, 23, 25,
27, 30, 33, 35, 38, 40, 42, 44, 46, 50, 51, 53, 56, 58, 60, 63, 64, 65, 68, 70,
72, 73, 75, 77, 79, 80, 81, 83, 84, 85, 86, 88, 89, 89, 91, 92, 92, 92, 94, 95,
95, 96, 97, 97, 97, 97, 97, 98, 97, 98, 98, 98, 98, 97, 97, 97, 96, 96, 95, 95,
94, 94, 93, 94, 92, 91, 91, 90, 90, 89, 88, 87, 87, 85, 85, 84, 83, 83, 82, 82,
80, 80, 79, 79, 79, 78, 77, 77, 77, 76, 76, 75, 75, 75, 75, 75, 75, 75, 74, 74,
75, 74, 75, 75, 76, 77, 77, 78, 78, 79, 79, 80, 80, 81, 82, 82, 84, 85, 86, 87,
88, 88, 90, 91, 92, 93, 94, 95, 95, 96, 98, 99, 100, 100, 102, 103, 104, 106,
106, 107, 108, 109, 110, 111, 111, 112, 113, 114, 114, 115, 116, 116, 117, 117,
118, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 118, 118, 118, 118, 117,
117, 115, 116, 114, 114, 113, 112, 111, 110, 109, 108, 107, 106, 104, 102, 101,
100, 98, 97, 95, 93, 92, 89, 89, 86, 83, 82, 80, 78, 76, 73, 71, 69, 67, 65, 62,
60, 57, 54, 52, 50, 48, 45, 43, 40, 37, 35, 32, 29, 26, 24, 21, 18, 16, 14, 11,
8, 5, 2, 0, -4, -5, -7, -10, -13, -15, -18, -20, -23, -26, -27, -31, -32, -35,
-38, -40, -42, -45, -46, -49, -51, -53, -54, -56, -58, -60, -63, -64, -66, -68,
-69, -71, -73, -74, -76, -77, -79, -80, -81, -83, -84, -84, -86, -86, -87, -88,
-90, -90, -91, -91, -92, -92, -92, -93, -93, -94, -95, -94, -95, -94, -94, -94,
-94, -93, -93, -93, -92, -93, -92, -90, -90, -89, -89, -88, -87, -86, -85, -84,
-84, -82, -81, -80, -79, -78, -76, -75, -74, -73, -71, -70, -68, -68, -66, -65,
-64, -61, -61, -59, -58, -57, -56, -54, -53, -52, -52, -50, -48, -47, -46, -46,
-44, -44, -43, -42, -42, -40, -41, -40, -39, -39, -39, -39, -38, -38, -39, -38,
-38, -39, -38, -39, -40, -40, -40, -41, -42, -42, -43, -44, -45, -46, -47, -47,
-48, -49, -51, -52, -53, -54, -56, -57, -58, -60, -62, -63, -64, -65, -68, -69,
-71, -73, -74, -75, -76, -78, -80, -81, -83, -84, -86, -87, -89, -90, -92, -93,
-95, -96, -97, -99, -99, -101, -102, -103, -105, -106, -107, -108, -109, -110,
-111, -112, -113, -113, -114, -114, -114, -116, -116, -116, -117, -118, -117,
-118, -118, -118, -117, -117, -117, -117, -117, -117, -115, -115, -115, -114,
-115, -113, -112, -111, -111, -109, -108, -107, -106, -105, -104, -102, -101,
-100, -99, -96, -95, -93, -91, -91, -88, -87, -84, -83, -81, -79, -77, -74, -72,
-71, -69, -65, -63, -61, -59, -56, -54, -52, -50, -47, -44, -41, -39, -37, -34,
-32, -29, -26, -23, -20, -18, -15, -12, -10, -5, -3, 0, 0, };