#define DATA_LENGTH 512
#define DATA AKWF_0935

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 8, 17, 25, 33, 39, 45, 50, 56, 59,
63, 67, 70, 72, 74, 76, 78, 80, 82, 84, 84, 86, 88, 89, 91, 93, 94, 97, 99, 101,
103, 106, 108, 110, 110, 112, 114, 116, 117, 118, 118, 119, 118, 119, 120, 119,
119, 118, 118, 117, 116, 115, 114, 113, 112, 112, 111, 110, 110, 109, 108, 108,
107, 107, 106, 106, 105, 105, 103, 102, 102, 100, 99, 97, 96, 93, 92, 88, 87,
83, 80, 78, 75, 72, 69, 66, 64, 62, 59, 58, 57, 56, 53, 53, 51, 51, 50, 49, 48,
46, 44, 43, 40, 38, 36, 33, 30, 26, 22, 19, 13, 9, 5, -1, -4, -7, -13, -14, -17,
-20, -21, -22, -23, -23, -23, -22, -22, -21, -19, -18, -17, -16, -16, -14, -14,
-13, -14, -15, -15, -17, -18, -19, -22, -24, -26, -28, -30, -31, -33, -34, -35,
-37, -37, -37, -36, -36, -34, -33, -32, -30, -28, -26, -23, -21, -19, -17, -15,
-13, -12, -12, -11, -11, -11, -11, -12, -13, -13, -14, -16, -16, -17, -17, -18,
-18, -18, -18, -17, -17, -15, -14, -14, -13, -11, -9, -8, -8, -7, -6, -6, -5,
-6, -6, -6, -7, -9, -10, -12, -13, -15, -17, -18, -20, -20, -21, -21, -21, -21,
-20, -20, -19, -17, -16, -15, -13, -11, -10, -8, -8, -6, -6, -6, -5, -6, -6, -7,
-8, -10, -11, -13, -15, -16, -18, -20, -21, -22, -22, -21, -21, -20, -20, -16,
-15, -13, -9, -6, -4, 1, 4, 7, 11, 13, 16, 18, 20, 20, 21, 22, 21, 21, 19, 19,
18, 16, 15, 13, 11, 9, 8, 6, 6, 5, 5, 5, 6, 7, 8, 8, 10, 11, 14, 15, 16, 18, 19,
19, 21, 21, 21, 21, 20, 19, 19, 17, 16, 14, 13, 11, 10, 8, 7, 6, 6, 5, 5, 5, 5,
7, 7, 9, 11, 12, 12, 13, 15, 16, 17, 17, 18, 19, 18, 17, 17, 16, 16, 15, 13, 13,
12, 11, 10, 11, 11, 11, 12, 12, 14, 16, 18, 20, 21, 24, 26, 28, 30, 32, 34, 35,
36, 37, 37, 36, 36, 35, 34, 33, 31, 29, 27, 25, 23, 22, 20, 18, 16, 15, 14, 14,
15, 15, 15, 16, 17, 18, 18, 20, 21, 22, 23, 23, 23, 23, 22, 21, 19, 17, 14, 12,
6, 3, -1, -5, -10, -14, -19, -22, -26, -30, -33, -36, -40, -40, -43, -45, -47,
-47, -49, -50, -51, -52, -53, -54, -55, -57, -59, -60, -63, -65, -67, -70, -73,
-75, -78, -80, -84, -86, -89, -92, -94, -95, -97, -99, -100, -102, -103, -104,
-105, -105, -107, -106, -107, -107, -108, -108, -109, -109, -110, -111, -111,
-113, -113, -114, -115, -116, -117, -118, -118, -119, -119, -120, -119, -119,
-118, -118, -117, -116, -115, -114, -113, -110, -109, -106, -105, -102, -100,
-98, -97, -94, -92, -91, -89, -87, -86, -84, -84, -82, -80, -78, -76, -74, -71,
-69, -65, -62, -58, -53, -49, -43, -37, -30, -23, -15, -6, };