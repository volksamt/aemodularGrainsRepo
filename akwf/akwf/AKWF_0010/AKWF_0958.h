#define DATA_LENGTH 512
#define DATA AKWF_0958

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 4, 5, 6, 6, 7, 10, 10, 11,
12, 13, 14, 15, 16, 18, 18, 19, 21, 21, 23, 24, 25, 26, 27, 28, 30, 32, 32, 34,
35, 36, 37, 38, 40, 41, 42, 43, 44, 46, 47, 48, 50, 51, 52, 54, 55, 55, 56, 58,
59, 60, 62, 63, 64, 65, 66, 67, 68, 69, 70, 71, 71, 72, 74, 75, 75, 76, 77, 78,
79, 79, 79, 80, 80, 81, 82, 83, 83, 84, 84, 85, 85, 85, 86, 87, 88, 88, 88, 89,
89, 89, 90, 91, 90, 91, 91, 91, 92, 91, 93, 92, 92, 92, 92, 92, 94, 93, 92, 92,
93, 93, 93, 93, 93, 94, 94, 94, 93, 93, 93, 93, 93, 93, 93, 93, 93, 93, 93, 93,
92, 93, 93, 93, 92, 92, 91, 92, 91, 92, 91, 91, 91, 91, 90, 90, 90, 90, 90, 89,
89, 90, 89, 89, 89, 88, 88, 88, 88, 88, 88, 88, 87, 87, 87, 87, 87, 87, 86, 86,
85, 86, 85, 85, 84, 84, 84, 83, 83, 82, 81, 81, 80, 80, 80, 80, 78, 78, 77, 77,
76, 75, 75, 74, 73, 72, 71, 71, 69, 68, 67, 67, 66, 65, 63, 63, 62, 61, 60, 60,
58, 57, 57, 55, 55, 53, 52, 51, 50, 49, 48, 46, 45, 44, 43, 42, 41, 40, 39, 37,
36, 35, 32, 31, 31, 29, 28, 26, 26, 24, 23, 22, 20, 19, 17, 17, 14, 13, 13, 11,
10, 8, 7, 6, 5, 4, 2, 1, 0, -2, -3, -5, -6, -8, -8, -10, -11, -12, -14, -15,
-16, -17, -19, -21, -21, -24, -24, -25, -27, -28, -30, -31, -32, -33, -34, -35,
-36, -38, -39, -41, -41, -42, -43, -44, -45, -46, -47, -49, -49, -50, -51, -53,
-54, -54, -55, -57, -58, -58, -59, -61, -62, -63, -63, -64, -65, -66, -67, -67,
-68, -69, -71, -71, -71, -72, -74, -74, -75, -75, -76, -76, -78, -78, -79, -79,
-80, -80, -81, -83, -82, -84, -84, -86, -86, -86, -86, -88, -88, -88, -90, -90,
-91, -91, -92, -93, -94, -93, -94, -95, -95, -97, -96, -97, -98, -98, -99, -100,
-100, -101, -100, -102, -102, -103, -103, -103, -103, -104, -104, -104, -104,
-105, -105, -105, -104, -106, -106, -106, -106, -105, -105, -106, -106, -107,
-106, -106, -106, -105, -105, -105, -105, -105, -104, -105, -104, -104, -104,
-104, -103, -102, -102, -102, -102, -100, -100, -100, -99, -99, -98, -97, -97,
-96, -96, -94, -95, -93, -92, -91, -90, -89, -88, -88, -87, -86, -86, -85, -83,
-83, -82, -80, -79, -79, -77, -77, -75, -74, -73, -72, -70, -70, -68, -67, -66,
-64, -63, -62, -61, -59, -57, -57, -55, -54, -52, -52, -51, -50, -48, -48, -45,
-44, -44, -42, -41, -40, -39, -39, -37, -36, -34, -33, -33, -32, -31, -30, -29,
-27, -27, -26, -24, -24, -23, -21, -21, -20, -19, -18, -16, -15, -15, -13, -12,
-12, -11, -10, -8, -7, -5, -6, -4, -3, -1, -1, 0, };