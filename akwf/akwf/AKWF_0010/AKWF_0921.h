#define DATA_LENGTH 512
#define DATA AKWF_0921

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 9, 11, 14, 17, 20, 24, 26,
30, 33, 36, 40, 43, 47, 51, 55, 57, 61, 65, 68, 72, 75, 78, 82, 84, 87, 91, 94,
97, 99, 101, 103, 106, 108, 109, 111, 113, 115, 116, 116, 118, 118, 118, 119,
119, 119, 120, 119, 118, 117, 116, 116, 116, 114, 113, 111, 111, 110, 108, 106,
104, 104, 102, 99, 98, 96, 94, 93, 91, 88, 88, 86, 84, 81, 79, 78, 75, 74, 72,
70, 67, 65, 63, 61, 59, 58, 55, 53, 51, 49, 46, 44, 42, 40, 38, 35, 32, 30, 28,
25, 22, 19, 16, 14, 12, 9, 6, 3, 0, -2, -5, -6, -9, -12, -14, -17, -18, -21,
-23, -25, -26, -28, -29, -31, -32, -34, -35, -36, -36, -37, -38, -38, -37, -37,
-38, -38, -38, -37, -37, -36, -35, -35, -34, -33, -32, -30, -30, -28, -27, -26,
-25, -23, -21, -20, -19, -18, -16, -15, -14, -13, -11, -11, -10, -9, -9, -7, -7,
-6, -6, -6, -5, -5, -5, -4, -5, -4, -4, -4, -5, -5, -5, -6, -6, -6, -7, -6, -7,
-6, -7, -7, -8, -8, -8, -8, -8, -9, -9, -9, -9, -9, -9, -8, -8, -8, -8, -8, -8,
-9, -8, -8, -8, -7, -8, -8, -8, -8, -8, -9, -8, -8, -8, -9, -10, -10, -10, -11,
-12, -12, -13, -14, -14, -15, -16, -17, -18, -19, -20, -22, -23, -24, -25, -27,
-27, -28, -30, -31, -31, -33, -34, -35, -36, -36, -37, -37, -37, -38, -39, -40,
-40, -40, -40, -39, -39, -39, -39, -39, -38, -38, -37, -37, -37, -36, -35, -34,
-34, -33, -33, -32, -31, -29, -30, -29, -27, -27, -27, -26, -27, -26, -26, -25,
-26, -26, -25, -26, -26, -26, -27, -28, -27, -28, -29, -29, -29, -31, -31, -32,
-33, -34, -34, -35, -36, -37, -39, -38, -40, -40, -40, -41, -42, -41, -42, -43,
-43, -43, -44, -42, -43, -42, -43, -42, -42, -42, -42, -41, -40, -39, -39, -38,
-37, -36, -35, -34, -34, -33, -33, -31, -30, -30, -29, -29, -27, -27, -26, -25,
-24, -23, -24, -23, -22, -22, -20, -20, -21, -20, -20, -19, -18, -18, -17, -18,
-17, -17, -17, -16, -16, -16, -14, -14, -12, -12, -12, -11, -10, -9, -8, -7, -7,
-6, -4, -3, -3, -1, 1, 2, 4, 5, 6, 7, 8, 9, 11, 12, 14, 15, 16, 17, 18, 19, 20,
20, 22, 22, 22, 23, 23, 23, 23, 23, 23, 22, 22, 22, 21, 20, 19, 18, 17, 15, 13,
13, 11, 9, 8, 6, 5, 3, 0, -1, -4, -5, -8, -9, -11, -14, -14, -17, -19, -20, -21,
-23, -25, -27, -28, -29, -30, -31, -32, -33, -34, -35, -35, -36, -36, -37, -37,
-38, -38, -38, -39, -39, -38, -39, -38, -38, -38, -37, -37, -37, -36, -35, -36,
-34, -35, -34, -34, -33, -33, -32, -31, -29, -29, -28, -27, -26, -26, -25, -23,
-22, -21, -20, -18, -16, -16, -13, -12, -11, -7, -5, -4, -1, };