#define DATA_LENGTH 512
#define DATA AKWF_0963

const PROGMEM int8_t DATA[DATA_LENGTH] = {103, 123, 112, 119, 112, 116, 111,
114, 110, 111, 108, 111, 107, 108, 105, 106, 104, 103, 103, 102, 101, 100, 100,
98, 97, 96, 96, 95, 94, 93, 93, 91, 91, 90, 89, 88, 88, 86, 86, 85, 84, 83, 83,
82, 80, 80, 78, 78, 76, 76, 75, 74, 74, 73, 72, 71, 70, 70, 68, 68, 66, 66, 65,
64, 64, 63, 63, 61, 59, 59, 59, 58, 57, 57, 55, 54, 53, 52, 52, 51, 50, 48, 48,
47, 46, 45, 44, 44, 43, 42, 41, 41, 40, 38, 38, 37, 36, 36, 34, 34, 33, 32, 31,
30, 30, 28, 27, 27, 27, 25, 24, 23, 22, 21, 21, 20, 18, 18, 17, 16, 16, 15, 14,
13, 12, 11, 10, 9, 9, 8, 7, 6, 5, 4, 4, 3, 2, 2, -1, 4, 8, 9, 11, 12, 15, 16,
18, 18, 20, 22, 23, 24, 26, 28, 28, 30, 31, 32, 33, 34, 35, 38, 39, 40, 41, 42,
43, 44, 46, 46, 47, 48, 50, 51, 51, 53, 54, 55, 55, 57, 58, 59, 60, 61, 61, 64,
65, 66, 67, 67, 68, 70, 70, 72, 72, 74, 74, 75, 76, 78, 79, 80, 80, 82, 82, 84,
85, 86, 86, 88, 88, 89, 90, 92, 92, 93, 94, 95, 96, 96, 99, 98, 102, 99, 103,
102, 106, 104, 108, 106, 109, 108, 111, 110, 113, 113, 113, 117, 112, 123, 106,
127, -45, -128, -103, -126, -107, -121, -108, -116, -108, -113, -108, -111,
-106, -108, -105, -105, -105, -103, -103, -101, -101, -99, -99, -97, -98, -95,
-96, -93, -94, -92, -92, -89, -90, -88, -88, -87, -86, -85, -84, -83, -82, -80,
-79, -79, -78, -78, -76, -76, -74, -75, -73, -72, -71, -70, -69, -69, -67, -67,
-65, -65, -64, -63, -62, -61, -61, -59, -58, -58, -56, -56, -54, -54, -54, -53,
-52, -51, -49, -49, -48, -48, -45, -45, -44, -43, -42, -41, -40, -40, -39, -38,
-37, -36, -35, -34, -34, -32, -31, -30, -30, -29, -27, -27, -26, -25, -24, -24,
-23, -22, -21, -20, -19, -18, -18, -17, -16, -15, -14, -13, -13, -12, -11, -10,
-8, -8, -6, -7, -5, -4, -3, -2, -1, 0, -1, -2, -3, -4, -4, -5, -6, -8, -8, -9,
-11, -10, -11, -13, -14, -15, -15, -16, -17, -17, -18, -19, -21, -21, -22, -23,
-24, -24, -26, -27, -28, -28, -29, -30, -31, -32, -32, -34, -35, -35, -37, -37,
-39, -39, -40, -40, -41, -43, -43, -45, -45, -45, -47, -47, -48, -50, -50, -51,
-52, -53, -54, -54, -55, -57, -58, -58, -59, -59, -60, -61, -62, -64, -64, -65,
-65, -67, -67, -68, -69, -70, -71, -71, -73, -74, -74, -75, -77, -78, -78, -79,
-79, -79, -82, -82, -83, -83, -85, -85, -86, -87, -88, -88, -90, -91, -92, -92,
-93, -94, -95, -97, -96, -98, -98, -101, -99, -102, -101, -105, -101, -106,
-103, -108, -105, -109, -107, -111, -110, -111, -113, -113, -115, -112, -119,
-108, -128, -25, -93, -93, };