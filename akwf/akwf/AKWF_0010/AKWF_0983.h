#define DATA_LENGTH 512
#define DATA AKWF_0983

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 9, 10, 12, 15, 17, 20, 21,
24, 25, 27, 30, 31, 34, 35, 37, 40, 41, 43, 45, 47, 49, 50, 52, 54, 55, 57, 57,
60, 61, 62, 64, 66, 67, 67, 69, 71, 72, 73, 75, 76, 77, 77, 79, 79, 81, 82, 83,
83, 84, 85, 84, 85, 85, 86, 86, 87, 86, 87, 87, 86, 86, 86, 85, 86, 85, 84, 84,
83, 82, 82, 81, 80, 80, 78, 77, 77, 76, 75, 73, 73, 71, 70, 70, 68, 66, 66, 65,
63, 63, 62, 61, 59, 58, 57, 56, 54, 54, 53, 52, 49, 49, 48, 46, 45, 44, 43, 41,
40, 39, 37, 35, 35, 33, 32, 30, 29, 27, 25, 24, 23, 21, 19, 18, 16, 14, 13, 10,
9, 7, 5, 3, 1, -2, -4, -5, -7, -9, -11, -14, -15, -18, -20, -22, -25, -26, -29,
-30, -33, -35, -37, -39, -41, -43, -46, -47, -49, -51, -53, -55, -57, -59, -60,
-63, -64, -67, -68, -70, -71, -74, -75, -77, -79, -80, -81, -84, -84, -87, -89,
-89, -91, -93, -94, -95, -97, -98, -100, -102, -103, -104, -106, -106, -108,
-109, -110, -111, -112, -113, -114, -114, -116, -115, -116, -117, -118, -118,
-118, -119, -119, -119, -119, -119, -119, -118, -118, -117, -117, -116, -116,
-114, -113, -112, -111, -110, -108, -108, -106, -104, -103, -101, -100, -97,
-95, -94, -91, -89, -87, -84, -83, -80, -78, -75, -73, -71, -69, -66, -63, -61,
-58, -56, -53, -51, -49, -46, -43, -41, -39, -36, -34, -32, -29, -27, -24, -23,
-20, -18, -16, -13, -11, -10, -7, -4, -2, -1, 1, 3, 5, 7, 8, 11, 12, 14, 16, 17,
19, 21, 23, 25, 26, 28, 29, 31, 33, 34, 36, 38, 39, 40, 42, 44, 45, 46, 47, 48,
50, 50, 52, 52, 53, 54, 55, 55, 57, 57, 58, 58, 59, 59, 59, 61, 61, 61, 61, 62,
62, 62, 62, 62, 62, 62, 62, 62, 62, 63, 63, 63, 63, 62, 62, 62, 62, 62, 62, 62,
63, 63, 62, 63, 63, 63, 63, 64, 62, 63, 63, 63, 64, 63, 63, 62, 63, 63, 62, 62,
62, 62, 62, 62, 61, 61, 61, 60, 60, 59, 59, 58, 58, 57, 56, 55, 54, 53, 52, 51,
50, 49, 48, 46, 45, 44, 42, 40, 39, 37, 36, 35, 33, 31, 30, 27, 27, 25, 23, 21,
20, 18, 16, 14, 13, 11, 9, 7, 6, 4, 3, 1, -1, -2, -5, -6, -8, -10, -11, -13,
-14, -16, -17, -19, -21, -23, -24, -26, -28, -28, -31, -32, -33, -35, -36, -38,
-39, -40, -42, -44, -45, -46, -47, -49, -50, -51, -52, -54, -55, -55, -57, -58,
-59, -59, -61, -61, -61, -62, -62, -63, -63, -64, -63, -64, -64, -64, -63, -62,
-62, -63, -61, -61, -60, -59, -58, -58, -56, -55, -54, -53, -52, -50, -49, -47,
-46, -44, -42, -40, -37, -35, -33, -32, -29, -27, -26, -22, -20, -18, -16, -14,
-12, -9, -7, -5, -2, 0, };