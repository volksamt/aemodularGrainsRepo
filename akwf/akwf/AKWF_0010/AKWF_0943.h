#define DATA_LENGTH 512
#define DATA AKWF_0943

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 9, 13, 19, 23, 28, 31, 36, 40,
43, 48, 52, 55, 59, 62, 64, 66, 68, 71, 72, 74, 76, 76, 78, 79, 80, 80, 81, 82,
83, 84, 85, 86, 87, 88, 89, 89, 90, 91, 92, 93, 92, 94, 94, 95, 94, 95, 95, 94,
95, 94, 94, 94, 95, 94, 95, 94, 94, 95, 93, 93, 94, 93, 93, 94, 93, 92, 92, 92,
91, 92, 92, 91, 90, 90, 90, 90, 89, 90, 89, 89, 88, 88, 87, 87, 87, 86, 85, 85,
85, 84, 83, 83, 82, 81, 81, 80, 79, 79, 78, 77, 76, 76, 74, 74, 73, 71, 69, 69,
68, 67, 66, 66, 64, 63, 62, 60, 59, 58, 57, 56, 55, 54, 53, 53, 51, 51, 50, 49,
48, 48, 48, 46, 46, 45, 45, 44, 44, 44, 44, 42, 42, 41, 41, 39, 38, 38, 38, 36,
35, 35, 32, 32, 31, 30, 28, 27, 25, 25, 22, 21, 20, 18, 16, 16, 13, 12, 9, 9, 7,
4, 2, 0, 30, 43, 45, 51, 56, 62, 67, 72, 75, 79, 81, 85, 86, 88, 89, 90, 91, 92,
92, 93, 94, 94, 94, 95, 95, 95, 94, 94, 93, 91, 90, 87, 85, 83, 81, 79, 77, 74,
71, 67, 61, 55, 48, 40, 32, 24, 15, 6, -3, -11, -19, -26, -34, -40, -47, -53,
-58, -63, -68, -72, -76, -79, -84, -87, -90, -92, -96, -98, -99, -101, -103,
-105, -106, -107, -109, -110, -111, -113, -113, -114, -115, -116, -116, -118,
-119, -118, -119, -118, -119, -119, -118, -119, -117, -116, -115, -114, -112,
-110, -109, -108, -107, -104, -103, -101, -99, -99, -97, -97, -95, -93, -93,
-91, -91, -89, -88, -88, -87, -86, -85, -85, -84, -84, -83, -83, -82, -81, -81,
-80, -79, -78, -76, -76, -74, -73, -72, -70, -69, -67, -65, -64, -63, -61, -60,
-59, -58, -55, -54, -53, -50, -49, -47, -45, -42, -40, -38, -35, -33, -31, -29,
-27, -25, -23, -21, -19, -17, -15, -13, -10, -9, -7, -5, -3, -1, -3, -5, -7, -9,
-11, -13, -16, -17, -18, -22, -23, -24, -27, -29, -31, -33, -35, -37, -40, -41,
-44, -45, -47, -49, -51, -52, -54, -56, -57, -58, -60, -61, -62, -63, -65, -65,
-67, -67, -69, -71, -71, -74, -74, -76, -77, -78, -79, -79, -81, -81, -81, -81,
-81, -82, -83, -84, -85, -86, -85, -86, -86, -87, -87, -88, -89, -90, -90, -91,
-92, -93, -94, -95, -96, -97, -98, -98, -99, -100, -102, -103, -105, -105, -107,
-107, -109, -110, -112, -113, -113, -114, -115, -116, -116, -117, -118, -119,
-118, -119, -119, -118, -119, -118, -119, -118, -118, -118, -117, -116, -116,
-115, -114, -114, -114, -113, -113, -112, -111, -110, -110, -109, -108, -108,
-106, -105, -104, -104, -102, -101, -99, -99, -97, -97, -94, -93, -91, -90, -88,
-86, -85, -83, -81, -79, -77, -74, -71, -68, -66, -63, -60, -58, -54, -51, -47,
-44, -41, -37, -33, -29, -26, -22, -17, -14, -3, -5, -5, };