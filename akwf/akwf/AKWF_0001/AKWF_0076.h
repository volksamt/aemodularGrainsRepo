#define DATA_LENGTH 512
#define DATA AKWF_0076

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -1, 0, 0, 0, -1, 1, 9, 7, 8, 8, 7,
9, 16, 15, 15, 15, 16, 15, 18, 25, 24, 24, 23, 24, 23, 29, 32, 31, 33, 33, 30,
35, 41, 39, 40, 39, 40, 39, 40, 46, 48, 47, 47, 48, 47, 48, 55, 56, 55, 56, 55,
56, 55, 59, 64, 63, 63, 63, 63, 64, 64, 63, 70, 72, 71, 72, 71, 72, 70, 72, 70,
75, 81, 79, 79, 79, 80, 78, 80, 79, 79, 79, 82, 88, 87, 88, 88, 88, 87, 88, 87,
87, 87, 87, 87, 87, 87, 87, 94, 96, 95, 95, 95, 96, 95, 96, 96, 95, 95, 96, 95,
96, 95, 96, 95, 96, 95, 95, 95, 95, 95, 95, 95, 95, 95, 95, 95, 96, 96, 95, 96,
95, 95, 95, 95, 95, 96, 95, 95, 95, 97, 91, 86, 88, 87, 88, 87, 88, 87, 87, 88,
87, 87, 87, 88, 87, 88, 85, 79, 80, 79, 80, 80, 78, 80, 79, 80, 79, 81, 76, 70,
72, 71, 70, 71, 71, 71, 72, 65, 62, 64, 63, 64, 62, 64, 62, 57, 55, 56, 55, 56,
55, 57, 53, 46, 48, 47, 49, 47, 48, 43, 39, 40, 39, 41, 39, 40, 34, 31, 32, 31,
33, 31, 33, 30, 25, 23, 24, 23, 25, 23, 15, 16, 16, 15, 16, 14, 7, 8, 8, 8, 7,
8, 5, -2, 1, -1, 1, 0, 1, -5, -9, -8, -8, -8, -8, -7, -13, -17, -15, -16, -16,
-17, -16, -23, -25, -24, -23, -24, -23, -25, -31, -32, -32, -31, -31, -33, -31,
-34, -40, -40, -39, -40, -39, -39, -40, -39, -47, -48, -47, -47, -47, -48, -48,
-47, -49, -57, -55, -56, -55, -56, -56, -56, -55, -55, -57, -63, -64, -64, -64,
-63, -63, -63, -63, -64, -64, -63, -71, -72, -71, -71, -72, -72, -71, -71, -72,
-71, -72, -71, -73, -79, -79, -79, -80, -79, -79, -80, -79, -80, -79, -79, -79,
-80, -79, -79, -79, -80, -78, -83, -89, -87, -88, -87, -88, -87, -87, -87, -87,
-86, -87, -88, -88, -87, -87, -88, -87, -88, -87, -87, -87, -87, -87, -88, -87,
-87, -87, -87, -87, -87, -87, -88, -86, -87, -88, -87, -88, -87, -87, -87, -87,
-87, -87, -88, -88, -87, -87, -87, -87, -87, -87, -87, -87, -88, -87, -88, -88,
-88, -87, -87, -87, -87, -87, -87, -87, -87, -86, -88, -84, -79, -80, -79, -79,
-80, -79, -80, -80, -80, -80, -80, -80, -79, -79, -80, -79, -79, -80, -75, -70,
-72, -72, -71, -71, -72, -71, -73, -71, -72, -71, -72, -71, -64, -63, -64, -63,
-64, -64, -64, -64, -64, -63, -64, -63, -57, -55, -55, -56, -56, -56, -56, -55,
-55, -55, -56, -49, -47, -48, -48, -48, -48, -47, -48, -47, -48, -42, -39, -40,
-40, -40, -40, -40, -40, -39, -31, -32, -31, -32, -32, -32, -32, -33, -27, -22,
-25, -24, -25, -23, -24, -18, -15, -16, -16, -16, -16, -16, -7, -8, -8, -8, -7,
-9, -7, };