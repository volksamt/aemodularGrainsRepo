#define DATA_LENGTH 512
#define DATA AKWF_0027

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 0, 0, 0, 0, -1, -4, -7, -7,
-27, -69, -53, 16, 66, 81, 64, 33, 0, -25, -37, -35, -22, -6, 10, 20, 22, 18, 8,
-1, -10, -13, -12, -6, -1, 7, 11, 10, 8, 1, -3, -10, -12, -11, -8, -3, 2, 5, 6,
7, 4, 0, -3, -5, -7, -5, -2, 0, 2, 3, 4, 2, 0, -1, -3, -3, -3, -2, -1, 1, 2, 3,
1, 1, 0, -1, -2, -1, -1, 0, 0, 0, 0, 1, 1, 1, 1, 1, 0, 0, -1, -1, -1, 0, 1, 1,
1, 1, 0, 0, 0, 0, 0, 0, 1, 6, 41, 61, 19, -34, -63, -61, -39, -12, 14, 26, 30,
23, 11, -3, -13, -18, -16, -11, -2, 5, 10, 10, 8, 3, -3, -7, -9, -7, -4, 1, 6,
8, 10, 7, 4, 0, -2, -5, -5, -4, -3, 3, -11, -71, -82, -7, 65, 95, 80, 45, 4,
-27, -43, -41, -28, -8, 10, 22, 26, 22, 11, -1, -10, -16, -15, -9, 0, 7, 13, 13,
10, 4, -4, -9, -13, -13, -10, -4, 1, 7, 8, 7, 5, 1, -4, -6, -7, -6, -4, -1, 2,
4, 4, 3, 2, -1, -3, -3, -3, -3, 0, 1, 2, 2, 2, 1, 0, -1, -2, -2, -2, 0, 0, 1, 1,
2, 1, 0, 0, -1, -2, -2, 0, 0, 0, 2, 1, 1, 0, 0, 0, -1, 0, 0, -1, 1, 1, 0, 0, 0,
0, 0, 0, -1, 0, 0, 0, 1, -1, 0, 0, 2, 4, 7, 8, 36, 73, 39, -30, -72, -78, -57,
-26, 6, 28, 37, 32, 19, 2, -13, -21, -22, -16, -6, 4, 11, 13, 11, 6, -3, -8,
-10, -10, -7, -1, 6, 10, 12, 11, 7, 2, -4, -6, -7, -6, -2, 1, 4, 6, 6, 5, 2, -1,
-3, -4, -4, -3, 0, 1, 2, 3, 2, 1, 0, -1, -2, -1, -1, -1, 0, 1, 3, 2, 1, 0, 0,
-1, -1, -1, -1, -2, -1, 0, 1, 2, 2, 1, 0, -1, -2, -1, -1, 0, 0, 1, 1, 0, 0, -1,
-7, -43, -61, -16, 36, 63, 60, 38, 10, -14, -27, -30, -23, -10, 4, 14, 18, 17,
10, 2, -5, -10, -11, -8, -3, 3, 7, 9, 8, 4, -1, -5, -9, -9, -8, -4, -1, 3, 5, 5,
8, 53, 92, 38, -46, -94, -94, -62, -20, 18, 41, 48, 37, 17, -4, -20, -29, -27,
-18, -5, 8, 16, 17, 14, 5, -4, -11, -14, -13, -8, 0, 7, 12, 14, 12, 8, 2, -5,
-8, -9, -7, -3, 1, 5, 7, 7, 5, 1, -1, -4, -5, -4, -3, 0, 2, 4, 4, 3, 1, 0, -2,
-2, -3, -2, 0, 1, 2, 2, 2, 2, 0, -1, -1, -1, -2, -1, 0, 1, 0, 1, 1, 1, 0, -1,
-1, -1, 0, 0, 0, 1, 1, 1, 1, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0,
0, 0, 0, 0, -1, -1, 0, };