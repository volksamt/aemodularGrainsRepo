#define DATA_LENGTH 512
#define DATA AKWF_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 26, 48, 69, 87, 99, 106, 110, 108,
101, 94, 82, 70, 56, 44, 31, 20, 10, 2, -4, -9, -13, -15, -17, -17, -17, -17,
-16, -16, -15, -15, -13, -13, -12, -13, -12, -12, -12, -13, -13, -13, -12, -12,
-12, -12, -12, -12, -11, -10, -10, -10, -8, -7, -6, -6, -5, -4, -4, -4, -2, -2,
0, 0, 0, 1, 1, 2, 2, 2, 2, 2, 3, 3, 3, 4, 3, 4, 4, 4, 3, 3, 3, 3, 2, 3, 3, 3, 3,
2, 2, 2, 1, 2, 2, 2, 1, 2, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, -1, 0, -1, 0, -1,
-1, 0, -1, -2, -1, 0, -2, -1, 0, -1, -1, -1, -1, -1, -1, -1, -1, -1, 0, 0, -1,
-1, -1, 0, -1, 0, -1, -1, 0, -1, 0, 1, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
1, 0, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, -1, 0, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0,
0, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 1, 1,
1, 2, 4, 6, 9, 13, 18, 25, 33, 41, 52, 60, 69, 75, 93, 104, 92, 73, 49, 21, -8,
-36, -62, -84, -101, -113, -118, -118, -114, -106, -95, -81, -67, -53, -39, -26,
-14, -6, 2, 8, 12, 16, 18, 18, 19, 18, 17, 17, 15, 15, 14, 13, 13, 13, 12, 13,
13, 13, 13, 13, 12, 13, 13, 13, 12, 12, 11, 11, 11, 11, 9, 8, 8, 6, 6, 5, 5, 3,
3, 2, 1, 0, 0, 0, -1, -2, -2, -1, -2, -3, -3, -4, -3, -3, -3, -4, -4, -3, -3,
-3, -4, -3, -3, -4, -4, -3, -3, -3, -3, -3, -2, -2, -2, -1, -1, -1, -1, -1, -1,
0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 2, 1, 1, 1, 0, 1, 2, 1, 1, 0, 0,
1, 1, 1, 0, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 1, -1, -1, 1, 0, 0, -1, 0,
0, 0, -1, 0, 0, -1, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 1,
-1, -1, -1, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, -1,
0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, -1, -1, -1, 0, 1, 0, -1, 0, -1, -1, 0,
0, 1, 0, 0, 0, 0, -1, 0, -1, -1, -1, -1, -3, -5, -7, -10, -15, -21, -28, -38,
-46, -57, -65, -74, -78, -80, -75, -68, -53, -37, -14, };