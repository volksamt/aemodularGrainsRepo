#define DATA_LENGTH 512
#define DATA AKWF_0072

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -1, -2, -3, -5, -7, -8, -10, -11,
-13, -15, -17, -19, -20, -22, -25, -27, -29, -31, -33, -35, -37, -40, -42, -44,
-47, -49, -52, -54, -57, -58, -60, -63, -64, -66, -68, -70, -71, -72, -72, -74,
-74, -75, -74, -75, -75, -75, -76, -76, -75, -75, -74, -74, -73, -72, -73, -72,
-71, -70, -70, -68, -68, -66, -65, -64, -62, -61, -61, -60, -58, -57, -56, -55,
-54, -53, -52, -51, -51, -49, -48, -47, -47, -45, -46, -43, -43, -43, -42, -42,
-41, -40, -41, -42, -42, -43, -43, -45, -46, -47, -47, -48, -48, -50, -49, -50,
-51, -51, -52, -52, -51, -52, -52, -52, -53, -53, -52, -53, -53, -53, -52, -54,
-53, -52, -52, -52, -52, -52, -51, -52, -52, -51, -50, -51, -50, -50, -50, -49,
-49, -48, -48, -47, -47, -46, -46, -46, -45, -45, -45, -45, -43, -43, -43, -43,
-42, -40, -41, -40, -40, -38, -38, -38, -36, -36, -35, -35, -34, -34, -33, -33,
-32, -31, -31, -30, -29, -30, -29, -28, -27, -26, -26, -26, -26, -24, -25, -24,
-23, -23, -23, -23, -21, -21, -21, -20, -21, -20, -20, -19, -19, -19, -18, -18,
-17, -17, -17, -16, -16, -16, -17, -16, -14, -15, -15, -14, -15, -14, -13, -13,
-12, -12, -11, -11, -10, -7, -5, -3, -1, 0, 3, 6, 8, 10, 13, 16, 19, 21, 25, 27,
29, 31, 33, 37, 38, 39, 41, 43, 46, 47, 49, 51, 52, 52, 54, 56, 57, 59, 60, 60,
62, 63, 64, 65, 65, 67, 67, 68, 68, 69, 69, 71, 71, 71, 72, 73, 74, 74, 75, 75,
76, 77, 77, 76, 76, 77, 78, 77, 78, 78, 78, 78, 78, 77, 78, 78, 78, 77, 77, 78,
77, 77, 77, 77, 76, 76, 76, 75, 76, 75, 76, 76, 75, 75, 75, 74, 74, 74, 74, 74,
73, 72, 72, 71, 72, 71, 70, 71, 71, 71, 70, 70, 69, 68, 67, 67, 67, 66, 67, 67,
65, 65, 65, 64, 64, 64, 64, 62, 62, 61, 61, 61, 61, 60, 60, 59, 60, 58, 59, 58,
57, 57, 56, 56, 55, 54, 53, 53, 52, 51, 51, 50, 49, 48, 47, 46, 46, 45, 44, 45,
43, 42, 42, 41, 40, 40, 38, 37, 37, 36, 37, 35, 34, 34, 33, 32, 32, 31, 30, 30,
29, 29, 29, 28, 27, 26, 26, 26, 25, 25, 24, 23, 23, 23, 22, 22, 21, 21, 20, 20,
20, 20, 19, 18, 19, 18, 18, 17, 17, 17, 16, 17, 16, 15, 14, 15, 14, 14, 14, 14,
13, 12, 13, 13, 12, 11, 12, 11, 11, 12, 11, 10, 10, 11, 10, 10, 10, 10, 9, 9, 9,
9, 8, 8, 8, 8, 8, 8, 7, 7, 7, 7, 7, 7, 6, 6, 7, 6, 5, 6, 6, 5, 5, 6, 5, 5, 5, 5,
5, 4, 5, 5, 5, 5, 4, 5, 4, 4, 4, 3, 4, 3, 4, 4, 3, 4, 3, 4, 3, 3, 3, 3, 2, 1, 0,
};