#define DATA_LENGTH 512
#define DATA AKWF_0043

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 6, 7, 10, 13, 15, 18, 21, 24,
26, 30, 31, 34, 37, 39, 42, 44, 47, 50, 52, 55, 57, 60, 63, 65, 67, 68, 71, 73,
76, 78, 80, 82, 84, 86, 88, 89, 91, 93, 95, 96, 98, 100, 101, 103, 104, 106,
106, 108, 109, 110, 111, 111, 112, 113, 113, 115, 115, 116, 116, 117, 117, 118,
118, 118, 118, 118, 118, 118, 118, 118, 118, 117, 117, 117, 117, 116, 116, 116,
115, 115, 114, 113, 113, 112, 112, 110, 109, 109, 108, 107, 106, 105, 105, 104,
102, 102, 102, 101, 99, 98, 97, 95, 95, 94, 93, 92, 91, 90, 89, 89, 88, 86, 85,
85, 83, 82, 82, 81, 80, 78, 78, 78, 76, 75, 75, 74, 73, 72, 72, 70, 70, 69, 68,
68, 67, 66, 66, 66, 64, 65, 63, 63, 63, 63, 62, 62, 61, 61, 60, 60, 60, 60, 59,
59, 59, 59, 59, 59, 59, 58, 58, 58, 58, 58, 58, 57, 58, 57, 58, 58, 58, 58, 59,
58, 59, 59, 59, 58, 59, 60, 60, 59, 60, 60, 61, 60, 61, 61, 62, 61, 62, 62, 62,
62, 63, 64, 63, 65, 64, 64, 64, 65, 65, 65, 66, 66, 66, 66, 67, 67, 67, 67, 68,
68, 69, 69, 68, 68, 68, 67, 67, 67, 67, 65, 65, 64, 64, 63, 63, 62, 61, 60, 59,
59, 57, 56, 55, 53, 52, 50, 50, 48, 46, 44, 42, 41, 39, 36, 35, 33, 31, 29, 26,
24, 22, 19, 17, 15, 12, 9, 7, 4, 2, -1, -3, -6, -9, -12, -14, -16, -20, -22,
-25, -28, -31, -34, -36, -39, -41, -44, -47, -49, -52, -54, -57, -60, -63, -64,
-67, -70, -71, -73, -76, -78, -81, -82, -84, -87, -88, -91, -91, -94, -96, -97,
-99, -101, -101, -104, -105, -105, -107, -108, -110, -111, -111, -113, -113,
-114, -115, -115, -116, -116, -118, -117, -118, -118, -118, -119, -119, -119,
-119, -120, -119, -119, -118, -119, -118, -118, -118, -117, -118, -116, -116,
-116, -115, -114, -114, -113, -112, -112, -111, -109, -109, -108, -107, -107,
-106, -104, -104, -102, -102, -101, -100, -99, -97, -96, -96, -95, -93, -93,
-92, -91, -90, -88, -88, -86, -86, -85, -83, -83, -81, -81, -79, -79, -78, -77,
-75, -76, -74, -74, -74, -72, -71, -70, -70, -69, -69, -68, -67, -67, -66, -66,
-65, -64, -64, -63, -62, -62, -61, -61, -62, -61, -60, -60, -60, -59, -59, -59,
-58, -58, -59, -58, -59, -57, -58, -57, -58, -57, -58, -58, -57, -57, -58, -57,
-57, -58, -57, -57, -58, -58, -59, -58, -59, -59, -59, -59, -60, -59, -61, -60,
-60, -61, -61, -62, -61, -62, -63, -62, -62, -63, -64, -64, -63, -63, -63, -63,
-63, -63, -63, -63, -62, -61, -61, -60, -60, -59, -59, -57, -57, -57, -54, -54,
-52, -52, -51, -50, -48, -47, -46, -44, -42, -41, -39, -38, -35, -33, -31, -30,
-28, -25, -24, -21, -18, -15, -14, -12, -9, -6, -4, -2, };