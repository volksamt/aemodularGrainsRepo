#define DATA_LENGTH 512
#define DATA AKWF_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 2, 2, 1, 3, 2, 3, 3, 2, 2,
4, 3, 3, 3, 4, 4, 4, 4, 3, 4, 5, 5, 4, 5, 5, 5, 5, 5, 7, 6, 7, 6, 7, 7, 8, 7, 8,
8, 8, 8, 9, 9, 8, 9, 10, 10, 9, 11, 11, 11, 12, 11, 12, 13, 12, 14, 14, 14, 14,
15, 16, 16, 16, 17, 18, 18, 19, 19, 19, 21, 20, 22, 22, 23, 24, 24, 25, 26, 27,
28, 30, 30, 31, 32, 33, 34, 35, 36, 38, 38, 40, 41, 42, 44, 46, 46, 49, 49, 51,
54, 55, 56, 59, 59, 61, 63, 66, 67, 69, 71, 72, 75, 77, 78, 81, 82, 84, 86, 88,
91, 92, 95, 96, 98, 100, 101, 103, 104, 106, 107, 109, 110, 111, 112, 113, 114,
116, 116, 117, 117, 117, 118, 119, 118, 119, 119, 119, 118, 118, 119, 118, 117,
117, 116, 116, 115, 115, 114, 113, 113, 111, 110, 109, 108, 107, 106, 105, 103,
102, 100, 99, 97, 96, 94, 93, 92, 91, 88, 86, 85, 83, 81, 80, 78, 77, 75, 73,
71, 69, 68, 66, 65, 63, 61, 60, 57, 56, 53, 53, 51, 50, 48, 46, 45, 43, 41, 39,
38, 37, 35, 33, 32, 31, 29, 28, 26, 26, 23, 23, 22, 19, 18, 18, 17, 16, 14, 13,
12, 11, 10, 9, 8, 6, 7, 6, 5, 3, 3, 1, 1, 1, 0, 0, 0, -1, -1, -2, -1, -3, -3,
-4, -5, -4, -5, -6, -6, -6, -7, -8, -7, -8, -8, -7, -7, -7, -8, -8, -7, -8, -7,
-8, -8, -8, -8, -7, -8, -7, -7, -8, -8, -8, -8, -7, -8, -8, -8, -7, -7, -8, -8,
-8, -8, -8, -9, -8, -9, -9, -8, -8, -8, -9, -9, -10, -9, -9, -10, -11, -10, -11,
-10, -10, -11, -12, -11, -11, -12, -12, -13, -13, -14, -13, -13, -14, -15, -14,
-16, -15, -16, -17, -16, -18, -17, -18, -19, -19, -20, -20, -20, -21, -22, -22,
-24, -23, -26, -26, -27, -27, -28, -28, -30, -30, -32, -32, -34, -36, -36, -37,
-38, -40, -41, -42, -44, -45, -47, -48, -49, -51, -52, -54, -55, -57, -59, -61,
-63, -65, -66, -69, -70, -72, -73, -76, -78, -80, -81, -84, -86, -87, -89, -91,
-93, -95, -96, -98, -101, -102, -104, -104, -106, -107, -109, -110, -110, -111,
-112, -113, -114, -115, -115, -116, -116, -116, -116, -117, -118, -117, -117,
-116, -117, -116, -115, -114, -115, -113, -113, -112, -111, -110, -110, -108,
-107, -107, -104, -104, -102, -101, -99, -99, -97, -96, -95, -93, -91, -89, -88,
-87, -84, -83, -82, -80, -78, -77, -75, -73, -71, -70, -68, -66, -65, -62, -62,
-60, -58, -56, -55, -53, -51, -49, -48, -47, -45, -43, -42, -40, -39, -36, -35,
-34, -33, -31, -29, -29, -26, -26, -24, -23, -22, -21, -19, -18, -17, -16, -14,
-13, -12, -11, -10, -9, -9, -7, -7, -6, -5, -4, -4, -3, -1, -1, 0, 0, };