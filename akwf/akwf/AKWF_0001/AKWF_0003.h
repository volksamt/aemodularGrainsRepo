#define DATA_LENGTH 512
#define DATA AKWF_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 18, 24, 30, 35, 40, 45, 50,
54, 60, 65, 69, 73, 78, 82, 86, 90, 93, 97, 101, 103, 105, 107, 110, 112, 115,
115, 117, 118, 119, 119, 119, 119, 119, 118, 117, 116, 115, 114, 111, 110, 107,
104, 103, 99, 96, 94, 90, 86, 83, 80, 76, 72, 68, 64, 60, 56, 52, 48, 43, 40,
35, 31, 27, 23, 18, 15, 11, 7, 3, -1, -4, -7, -11, -15, -17, -20, -23, -26, -29,
-32, -33, -36, -38, -40, -42, -43, -45, -47, -48, -50, -51, -51, -54, -53, -55,
-54, -55, -56, -56, -56, -57, -55, -56, -55, -56, -55, -54, -54, -53, -52, -52,
-50, -49, -48, -47, -46, -45, -43, -42, -40, -39, -37, -35, -34, -33, -30, -28,
-26, -24, -22, -19, -17, -14, -13, -10, -8, -4, -3, 0, 3, 5, 8, 10, 13, 14, 17,
21, 22, 24, 28, 30, 32, 35, 37, 39, 41, 44, 46, 48, 49, 52, 53, 54, 56, 57, 59,
59, 60, 61, 62, 62, 62, 62, 62, 62, 62, 61, 60, 60, 59, 58, 56, 54, 52, 50, 48,
46, 44, 41, 39, 36, 33, 30, 27, 23, 21, 17, 14, 11, 7, 3, 0, -3, -7, -10, -15,
-18, -20, -25, -27, -31, -34, -37, -41, -43, -46, -48, -50, -52, -55, -56, -58,
-60, -60, -62, -62, -63, -63, -64, -64, -64, -63, -62, -61, -61, -60, -58, -57,
-54, -53, -51, -49, -46, -44, -41, -38, -35, -32, -28, -26, -22, -19, -15, -12,
-9, -6, -1, 2, 5, 9, 12, 15, 18, 21, 24, 28, 29, 33, 35, 37, 40, 42, 44, 45, 47,
48, 50, 50, 52, 52, 52, 53, 52, 53, 51, 52, 50, 50, 49, 48, 46, 45, 43, 41, 40,
37, 35, 34, 31, 28, 27, 23, 20, 18, 14, 13, 9, 7, 4, 2, -2, -5, -8, -10, -13,
-16, -17, -21, -23, -25, -27, -29, -31, -34, -36, -38, -38, -40, -41, -44, -43,
-46, -46, -47, -48, -49, -49, -49, -50, -51, -50, -51, -51, -50, -51, -50, -50,
-49, -49, -48, -48, -48, -46, -46, -45, -45, -43, -43, -41, -40, -39, -38, -37,
-35, -34, -33, -31, -30, -28, -27, -25, -24, -22, -21, -19, -17, -15, -13, -11,
-10, -7, -6, -4, -2, 0, 2, 3, 5, 7, 10, 12, 14, 17, 19, 20, 23, 24, 27, 29, 29,
31, 34, 35, 38, 39, 41, 42, 43, 44, 45, 46, 48, 48, 49, 49, 50, 50, 51, 50, 49,
49, 49, 48, 47, 46, 45, 44, 43, 41, 39, 37, 35, 33, 31, 27, 26, 23, 19, 17, 14,
10, 8, 4, 1, -3, -6, -10, -14, -17, -22, -25, -28, -33, -37, -40, -45, -48, -52,
-55, -59, -62, -66, -69, -73, -74, -77, -81, -83, -85, -87, -89, -91, -94, -94,
-95, -96, -97, -97, -97, -97, -96, -96, -96, -94, -93, -91, -90, -87, -86, -83,
-80, -77, -74, -71, -66, -63, -60, -56, -51, -47, -42, -38, -33, -28, -22, -17,
-12, -7, -2, };