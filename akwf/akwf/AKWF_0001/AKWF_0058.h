#define DATA_LENGTH 512
#define DATA AKWF_0058

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 3, 2, 3, 4, 5, 6, 7, 9, 10, 10,
10, 12, 12, 14, 13, 15, 16, 15, 16, 17, 17, 18, 18, 18, 20, 19, 20, 21, 20, 21,
21, 21, 22, 22, 22, 21, 22, 22, 23, 22, 22, 23, 23, 23, 23, 22, 22, 23, 23, 23,
23, 23, 23, 23, 23, 23, 23, 22, 24, 23, 23, 24, 24, 23, 23, 24, 24, 23, 24, 24,
24, 23, 23, 23, 23, 23, 24, 23, 23, 23, 23, 24, 24, 24, 24, 24, 25, 24, 25, 25,
24, 25, 26, 26, 25, 26, 27, 27, 27, 28, 28, 29, 30, 29, 30, 30, 31, 31, 32, 33,
33, 34, 35, 34, 36, 36, 37, 37, 37, 38, 39, 39, 40, 40, 41, 42, 43, 43, 44, 44,
46, 46, 46, 47, 47, 48, 49, 49, 50, 51, 52, 52, 53, 53, 55, 57, 61, 64, 63, 64,
65, 66, 69, 70, 71, 73, 74, 76, 77, 78, 80, 81, 82, 83, 84, 87, 87, 87, 88, 89,
90, 89, 90, 91, 91, 93, 92, 93, 93, 92, 92, 93, 92, 91, 93, 92, 92, 90, 91, 90,
90, 89, 88, 88, 87, 86, 85, 84, 83, 82, 82, 81, 79, 78, 77, 75, 75, 73, 72, 70,
69, 67, 65, 65, 63, 61, 60, 57, 56, 54, 52, 51, 49, 46, 42, 37, 38, 36, 33, 30,
28, 26, 24, 22, 19, 18, 15, 14, 11, 9, 8, 7, 5, 3, 2, 1, 1, 0, -1, -1, -1, -3,
-4, -5, -5, -6, -7, -9, -8, -10, -10, -11, -11, -12, -13, -13, -14, -14, -14,
-14, -15, -14, -15, -14, -15, -15, -15, -14, -13, -13, -11, -8, -10, -10, -9,
-7, -7, -5, -5, -4, -3, -3, -2, -1, -1, 0, 0, 0, 3, 2, 3, 4, 5, 5, 6, 8, 7, 8,
9, 9, 10, 11, 11, 11, 12, 12, 12, 12, 12, 14, 13, 14, 14, 13, 14, 12, 13, 14,
13, 14, 13, 12, 12, 11, 10, 10, 10, 9, 8, 6, 6, 5, 4, 3, 2, -1, -3, -2, -2, -5,
-7, -8, -10, -12, -14, -16, -19, -21, -23, -26, -27, -30, -33, -35, -37, -39,
-42, -43, -46, -47, -50, -52, -54, -56, -58, -60, -61, -63, -65, -66, -69, -70,
-71, -73, -75, -75, -77, -78, -81, -81, -83, -83, -85, -87, -93, -95, -94, -96,
-97, -99, -100, -101, -103, -105, -107, -108, -109, -111, -111, -113, -114,
-115, -116, -115, -117, -117, -118, -118, -118, -120, -119, -120, -119, -119,
-120, -119, -119, -118, -118, -117, -116, -116, -115, -115, -114, -112, -111,
-111, -110, -108, -107, -106, -105, -104, -103, -101, -100, -99, -97, -95, -95,
-93, -91, -91, -89, -86, -85, -83, -81, -80, -79, -77, -75, -73, -72, -70, -69,
-67, -66, -64, -62, -60, -60, -57, -56, -55, -53, -50, -49, -48, -46, -45, -42,
-41, -39, -38, -36, -35, -33, -32, -30, -29, -28, -25, -19, -19, -18, -17, -15,
-13, -11, -10, -8, -6, -5, -4, -3, -2, 0, 0, };