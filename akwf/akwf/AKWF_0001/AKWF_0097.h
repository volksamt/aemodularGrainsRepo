#define DATA_LENGTH 512
#define DATA AKWF_0097

const PROGMEM int8_t DATA[DATA_LENGTH] = {-2, -8, -14, -18, -23, -28, -33, -36,
-41, -45, -48, -51, -55, -58, -62, -65, -68, -70, -72, -74, -77, -80, -82, -83,
-85, -88, -89, -91, -93, -94, -95, -96, -98, -99, -100, -101, -103, -103, -104,
-105, -106, -107, -107, -107, -108, -109, -109, -111, -110, -110, -112, -112,
-112, -113, -113, -113, -114, -114, -114, -114, -115, -115, -115, -116, -115,
-116, -116, -117, -116, -116, -116, -118, -117, -118, -117, -117, -118, -118,
-118, -117, -118, -119, -118, -118, -118, -119, -118, -118, -118, -118, -118,
-119, -118, -119, -118, -118, -119, -119, -118, -119, -119, -118, -119, -119,
-118, -118, -119, -119, -119, -118, -119, -119, -119, -118, -119, -118, -119,
-119, -118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -120, -119, -119, -120, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -120, -119, -120, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -118, -119, -119, -119,
-119, -120, -119, -120, -119, -119, -120, -119, -119, -120, -119, -119, -119,
-118, -119, -119, -119, -119, -119, -118, -120, -119, -119, -119, -120, -120,
-119, -120, -119, -119, -118, -117, -116, -117, -115, -113, -112, -109, -106,
-104, -101, -98, -94, -90, -87, -83, -78, -73, -69, -64, -59, -54, -48, -42,
-38, -32, -27, -22, -15, -10, -4, 2, 9, 14, 19, 23, 28, 32, 36, 41, 45, 49, 52,
55, 58, 62, 65, 68, 71, 73, 76, 78, 81, 82, 84, 86, 87, 89, 91, 92, 94, 94, 97,
98, 99, 101, 101, 102, 104, 104, 105, 106, 106, 107, 107, 108, 109, 109, 110,
110, 111, 112, 112, 112, 113, 114, 114, 114, 115, 114, 115, 115, 115, 115, 116,
116, 117, 116, 117, 117, 117, 116, 118, 117, 117, 118, 117, 117, 118, 117, 118,
118, 118, 118, 118, 117, 118, 118, 118, 118, 118, 118, 119, 119, 119, 118, 118,
118, 118, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119,
119, 120, 119, 119, 119, 119, 120, 119, 118, 119, 120, 118, 119, 119, 120, 119,
119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
120, 118, 119, 119, 119, 119, 119, 118, 118, 119, 118, 118, 119, 119, 119, 118,
120, 119, 119, 118, 120, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 119,
119, 118, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 118, 120, 119, 120, 119,
119, 119, 118, 117, 116, 114, 114, 111, 109, 107, 104, 101, 97, 95, 90, 87, 83,
77, 73, 69, 63, 58, 53, 48, 43, 37, 31, 27, 20, 15, 10, 3, };