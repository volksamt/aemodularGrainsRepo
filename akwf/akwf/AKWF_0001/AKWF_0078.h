#define DATA_LENGTH 512
#define DATA AKWF_0078

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 3, 4, 5, 6, 6, 6, 7, 8, 9, 9, 9,
9, 9, 10, 10, 10, 9, 9, 10, 9, 9, 9, 10, 10, 10, 11, 10, 11, 10, 12, 12, 12, 13,
13, 13, 14, 15, 16, 16, 16, 17, 17, 18, 17, 18, 19, 19, 19, 18, 19, 19, 19, 19,
19, 19, 20, 20, 20, 20, 20, 21, 21, 21, 22, 23, 24, 23, 24, 26, 25, 26, 26, 27,
28, 28, 29, 29, 29, 30, 30, 31, 30, 30, 31, 31, 31, 32, 31, 32, 32, 32, 33, 32,
33, 33, 33, 34, 34, 35, 35, 36, 36, 36, 37, 38, 38, 39, 38, 39, 39, 40, 40, 40,
40, 41, 42, 41, 42, 41, 41, 42, 42, 43, 43, 42, 43, 45, 44, 45, 45, 45, 45, 46,
47, 47, 47, 48, 48, 48, 49, 50, 50, 50, 51, 51, 51, 52, 53, 53, 52, 53, 53, 53,
54, 54, 54, 55, 55, 55, 55, 56, 56, 57, 57, 58, 57, 57, 59, 59, 59, 59, 59, 59,
60, 60, 60, 61, 62, 62, 62, 63, 63, 63, 64, 63, 64, 65, 65, 65, 65, 66, 65, 66,
66, 67, 68, 68, 68, 68, 68, 69, 69, 69, 70, 70, 71, 71, 71, 72, 72, 73, 73, 72,
74, 73, 74, 75, 75, 75, 75, 75, 76, 77, 77, 78, 78, 78, 78, 78, 78, 79, 79, 80,
80, 81, 81, 81, 81, 82, 82, 83, 83, 83, 83, 84, 84, 84, 79, 63, 45, 23, 2, -19,
-37, -51, -64, -74, -82, -89, -95, -100, -104, -109, -112, -115, -117, -119,
-119, -118, -115, -111, -106, -102, -95, -90, -85, -81, -76, -73, -72, -70, -71,
-73, -75, -78, -82, -86, -90, -95, -99, -103, -106, -109, -111, -112, -111,
-110, -109, -105, -101, -96, -91, -83, -77, -69, -62, -54, -47, -40, -34, -29,
-24, -21, -18, -16, -16, -17, -18, -20, -23, -27, -32, -36, -41, -46, -50, -56,
-60, -63, -67, -69, -71, -73, -74, -73, -72, -71, -69, -67, -65, -62, -60, -57,
-55, -53, -51, -49, -49, -49, -48, -48, -50, -50, -52, -53, -55, -57, -60, -61,
-63, -64, -66, -66, -67, -66, -65, -64, -63, -60, -58, -55, -52, -49, -45, -42,
-39, -35, -32, -30, -26, -25, -23, -22, -21, -20, -20, -21, -22, -23, -26, -27,
-29, -30, -32, -34, -35, -36, -39, -39, -40, -40, -40, -40, -40, -39, -38, -37,
-36, -35, -32, -33, -31, -29, -29, -27, -27, -27, -25, -26, -27, -26, -27, -28,
-28, -29, -30, -32, -31, -32, -32, -33, -34, -33, -33, -33, -31, -31, -29, -28,
-26, -25, -24, -22, -20, -19, -17, -15, -13, -12, -11, -11, -10, -10, -9, -9,
-9, -8, -10, -10, -11, -11, -12, -13, -13, -14, -13, -13, -14, -15, -15, -14,
-14, -13, -12, -13, -12, -10, -10, -9, -8, -7, -6, -6, -5, -5, -4, -4, -4, -4,
-4, -4, -4, -5, -5, -5, -5, -6, -5, -6, -6, -5, -4, -5, -4, -4, -4, -3, -1, -1,
0, };