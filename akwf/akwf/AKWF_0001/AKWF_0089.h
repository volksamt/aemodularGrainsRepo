#define DATA_LENGTH 512
#define DATA AKWF_0089

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 12, 19, 25, 31, 37, 42, 49, 55, 60,
64, 70, 75, 79, 83, 88, 92, 94, 99, 102, 104, 107, 108, 110, 112, 113, 116, 116,
117, 118, 118, 118, 119, 119, 118, 118, 117, 118, 116, 116, 116, 115, 115, 113,
112, 111, 109, 109, 108, 106, 106, 104, 104, 102, 101, 100, 99, 98, 96, 96, 95,
94, 93, 92, 91, 91, 90, 89, 88, 88, 87, 87, 86, 85, 85, 85, 85, 84, 84, 84, 84,
83, 83, 84, 83, 83, 82, 83, 83, 83, 84, 83, 83, 83, 83, 83, 83, 82, 83, 83, 84,
84, 83, 84, 84, 84, 84, 84, 84, 84, 84, 85, 84, 85, 84, 84, 84, 84, 84, 84, 85,
85, 84, 84, 84, 84, 84, 84, 84, 84, 84, 83, 85, 84, 85, 84, 84, 84, 84, 84, 83,
83, 83, 82, 83, 83, 83, 83, 83, 81, 82, 82, 82, 82, 82, 81, 81, 82, 81, 81, 81,
81, 81, 81, 80, 81, 80, 80, 81, 81, 81, 80, 80, 80, 79, 80, 80, 79, 80, 80, 79,
80, 80, 79, 79, 79, 79, 78, 79, 79, 79, 78, 79, 78, 78, 78, 78, 78, 79, 78, 78,
77, 77, 78, 77, 77, 78, 78, 77, 77, 77, 77, 77, 77, 77, 77, 77, 77, 76, 76, 76,
77, 76, 76, 77, 77, 76, 76, 75, 75, 76, 75, 75, 76, 75, 74, 75, 74, 76, 75, 74,
72, 70, 67, 63, 58, 54, 49, 44, 38, 32, 26, 20, 13, 6, 1, -7, -13, -20, -25,
-32, -38, -44, -50, -56, -61, -66, -72, -76, -81, -85, -88, -92, -95, -98, -102,
-104, -106, -109, -111, -112, -114, -115, -117, -117, -118, -119, -119, -119,
-119, -119, -119, -119, -117, -118, -116, -116, -115, -114, -113, -112, -112,
-110, -108, -108, -106, -106, -105, -104, -102, -101, -100, -99, -98, -97, -95,
-95, -94, -94, -93, -91, -91, -90, -90, -89, -88, -88, -87, -86, -86, -86, -86,
-85, -84, -85, -83, -85, -83, -84, -83, -83, -83, -82, -83, -83, -83, -83, -83,
-84, -84, -84, -84, -83, -84, -83, -83, -84, -84, -84, -85, -84, -84, -84, -85,
-83, -84, -84, -84, -85, -85, -85, -85, -84, -84, -85, -84, -84, -85, -85, -84,
-85, -85, -84, -84, -84, -85, -84, -84, -84, -84, -84, -84, -84, -84, -83, -84,
-83, -83, -83, -84, -84, -82, -83, -83, -84, -82, -83, -83, -82, -82, -82, -82,
-82, -81, -81, -82, -82, -81, -81, -82, -81, -80, -81, -81, -80, -81, -80, -81,
-80, -80, -81, -81, -80, -81, -79, -80, -80, -80, -80, -80, -80, -79, -79, -79,
-78, -79, -78, -78, -79, -78, -79, -79, -79, -78, -78, -78, -78, -78, -79, -77,
-77, -78, -78, -77, -77, -78, -78, -78, -77, -77, -77, -77, -76, -77, -77, -77,
-76, -76, -76, -76, -76, -77, -77, -76, -77, -75, -76, -75, -76, -76, -77, -76,
-75, -76, -76, -75, -74, -72, -70, -67, -63, -58, -54, -48, -43, -38, -32, -26,
-20, -13, -6, 0, };