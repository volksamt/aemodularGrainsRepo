#define DATA_LENGTH 512
#define DATA AKWF_0087

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 8, 10, 11, 13, 16, 16, 18,
19, 21, 22, 23, 25, 25, 27, 28, 30, 31, 32, 34, 35, 35, 36, 38, 39, 40, 41, 42,
42, 44, 44, 46, 47, 47, 48, 49, 49, 50, 51, 51, 53, 53, 53, 54, 55, 55, 56, 57,
57, 57, 58, 59, 60, 60, 61, 61, 62, 63, 63, 62, 64, 64, 64, 64, 65, 65, 65, 67,
66, 67, 67, 68, 68, 68, 68, 69, 70, 70, 70, 69, 70, 71, 70, 71, 70, 71, 71, 72,
72, 72, 72, 72, 73, 73, 74, 74, 73, 75, 74, 74, 75, 74, 75, 75, 75, 75, 75, 75,
75, 75, 75, 76, 76, 76, 76, 76, 76, 76, 76, 76, 75, 76, 76, 76, 76, 77, 75, 76,
76, 76, 75, 76, 76, 75, 75, 75, 75, 75, 74, 74, 75, 74, 74, 73, 72, 73, 73, 73,
72, 73, 72, 71, 71, 70, 71, 70, 70, 69, 69, 68, 67, 68, 68, 67, 67, 66, 64, 65,
63, 63, 63, 62, 62, 61, 60, 59, 60, 58, 57, 57, 57, 56, 55, 55, 54, 54, 53, 53,
51, 51, 51, 50, 49, 48, 48, 47, 46, 46, 45, 44, 44, 43, 43, 41, 40, 41, 39, 39,
37, 38, 36, 36, 36, 34, 34, 32, 32, 32, 32, 30, 30, 29, 29, 26, 26, 26, 24, 23,
23, 22, 20, 19, 18, 18, 16, 14, 14, 13, 12, 11, 10, 9, 7, 6, 5, 4, 2, 1, 0, -2,
-2, -3, -4, -6, -7, -8, -9, -9, -11, -12, -12, -13, -13, -14, -15, -15, -17,
-17, -17, -17, -18, -19, -19, -21, -21, -21, -22, -22, -23, -23, -24, -23, -24,
-24, -25, -25, -25, -27, -28, -28, -29, -31, -30, -31, -33, -33, -34, -35, -36,
-37, -37, -38, -39, -39, -40, -39, -42, -41, -42, -42, -42, -42, -44, -43, -44,
-44, -45, -45, -45, -46, -46, -46, -47, -47, -47, -47, -47, -47, -48, -48, -49,
-49, -48, -48, -49, -49, -49, -49, -49, -49, -50, -50, -49, -50, -49, -50, -49,
-50, -49, -49, -48, -51, -54, -51, -53, -55, -57, -58, -59, -61, -62, -63, -65,
-65, -66, -67, -68, -69, -70, -71, -71, -72, -73, -73, -73, -74, -74, -74, -74,
-75, -76, -75, -76, -76, -76, -78, -77, -77, -78, -78, -77, -78, -78, -78, -78,
-78, -78, -79, -78, -78, -78, -78, -78, -78, -78, -77, -77, -77, -77, -76, -76,
-76, -76, -75, -74, -75, -77, -75, -76, -77, -76, -77, -77, -78, -77, -78, -79,
-80, -79, -79, -78, -79, -79, -78, -78, -78, -77, -77, -77, -77, -77, -75, -76,
-75, -75, -75, -73, -73, -73, -72, -71, -71, -69, -69, -69, -68, -67, -66, -66,
-66, -64, -63, -63, -63, -61, -60, -60, -58, -58, -56, -55, -56, -54, -53, -51,
-52, -50, -48, -48, -47, -46, -44, -43, -42, -41, -40, -38, -37, -36, -34, -33,
-31, -30, -28, -27, -26, -25, -23, -22, -20, -18, -17, -15, -14, -13, -11, -7,
-6, -3, -1, };