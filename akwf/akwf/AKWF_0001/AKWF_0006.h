#define DATA_LENGTH 512
#define DATA AKWF_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 5, 8, 10, 12, 14, 16, 19, 20, 22,
24, 26, 27, 30, 31, 33, 35, 36, 39, 39, 41, 43, 44, 46, 47, 49, 50, 51, 53, 55,
56, 57, 58, 60, 62, 62, 64, 65, 66, 68, 68, 69, 70, 71, 73, 74, 75, 75, 77, 78,
79, 80, 80, 81, 82, 83, 83, 84, 86, 87, 87, 88, 88, 89, 90, 92, 92, 93, 94, 96,
96, 97, 98, 99, 99, 99, 101, 101, 101, 102, 103, 102, 102, 100, 98, 98, 97, 96,
95, 95, 94, 95, 93, 92, 93, 92, 92, 92, 91, 91, 91, 90, 90, 89, 88, 88, 87, 87,
86, 86, 85, 84, 83, 83, 82, 82, 80, 80, 79, 78, 78, 77, 77, 76, 75, 75, 74, 74,
73, 73, 73, 75, 74, 75, 75, 75, 76, 76, 76, 77, 76, 76, 77, 77, 76, 76, 76, 76,
77, 76, 76, 77, 77, 77, 77, 77, 78, 77, 78, 78, 78, 78, 77, 79, 78, 78, 79, 79,
79, 78, 79, 78, 79, 78, 78, 79, 79, 78, 79, 78, 78, 78, 78, 78, 78, 78, 78, 77,
77, 76, 77, 76, 76, 76, 75, 75, 74, 74, 74, 72, 72, 71, 71, 71, 70, 69, 69, 68,
67, 66, 66, 64, 64, 63, 62, 61, 60, 60, 58, 57, 56, 55, 54, 52, 52, 50, 49, 48,
46, 45, 45, 44, 41, 41, 39, 38, 36, 35, 33, 31, 31, 29, 28, 25, 24, 24, 22, 19,
19, 16, 14, 13, 10, 9, 6, 3, 1, -3, -6, -6, -9, -11, -13, -15, -17, -18, -20,
-22, -24, -25, -26, -28, -29, -31, -32, -34, -36, -37, -38, -39, -42, -43, -44,
-45, -47, -49, -49, -50, -52, -53, -55, -56, -57, -58, -58, -60, -61, -63, -64,
-65, -65, -67, -68, -69, -69, -70, -71, -73, -73, -74, -75, -76, -76, -78, -78,
-79, -80, -80, -82, -82, -83, -84, -84, -84, -86, -87, -86, -86, -86, -85, -85,
-84, -83, -83, -83, -82, -82, -81, -81, -81, -81, -80, -81, -80, -80, -80, -80,
-80, -79, -79, -78, -79, -78, -78, -78, -77, -77, -77, -77, -76, -76, -76, -76,
-75, -75, -75, -74, -74, -74, -74, -73, -73, -74, -73, -73, -73, -73, -74, -74,
-74, -76, -77, -78, -79, -79, -80, -80, -80, -80, -81, -82, -82, -83, -84, -83,
-84, -85, -84, -86, -86, -85, -86, -87, -88, -88, -88, -89, -88, -88, -90, -89,
-90, -90, -91, -91, -91, -91, -91, -92, -93, -93, -92, -92, -92, -93, -92, -93,
-92, -93, -92, -93, -93, -93, -94, -92, -93, -92, -92, -92, -91, -91, -90, -91,
-91, -91, -90, -89, -89, -89, -88, -87, -88, -86, -86, -85, -84, -83, -82, -82,
-81, -80, -80, -79, -79, -77, -77, -76, -74, -73, -72, -71, -69, -68, -67, -66,
-65, -63, -62, -60, -60, -58, -57, -56, -53, -53, -51, -50, -48, -46, -44, -43,
-41, -39, -38, -36, -34, -32, -31, -29, -28, -25, -24, -23, -20, -18, -15, -13,
-11, -8, -7, -3, 0, };