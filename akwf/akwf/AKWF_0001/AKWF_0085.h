#define DATA_LENGTH 512
#define DATA AKWF_0085

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 16, 17, 19, 21, 22, 25, 28, 32,
36, 40, 44, 48, 51, 53, 54, 56, 56, 57, 57, 59, 60, 61, 62, 64, 64, 65, 64, 66,
65, 66, 66, 67, 68, 70, 70, 71, 74, 75, 75, 76, 78, 79, 81, 82, 83, 84, 86, 88,
89, 90, 91, 93, 94, 95, 96, 97, 98, 98, 98, 100, 99, 101, 101, 101, 102, 103,
98, 87, 84, 85, 85, 85, 84, 86, 84, 85, 85, 84, 84, 83, 83, 83, 83, 82, 83, 82,
82, 81, 81, 81, 81, 81, 80, 80, 80, 79, 79, 79, 78, 77, 76, 76, 76, 76, 76, 75,
75, 73, 73, 72, 73, 72, 72, 71, 71, 71, 71, 70, 69, 69, 67, 68, 68, 68, 65, 71,
74, 81, 82, 81, 81, 81, 80, 79, 81, 79, 79, 79, 79, 78, 78, 77, 78, 78, 78, 77,
78, 78, 77, 78, 77, 77, 77, 78, 77, 77, 77, 77, 78, 77, 77, 78, 77, 78, 78, 78,
77, 79, 79, 78, 78, 78, 78, 78, 78, 79, 79, 78, 79, 78, 79, 79, 78, 78, 78, 78,
77, 78, 78, 79, 77, 78, 77, 78, 73, 62, 61, 60, 60, 60, 59, 59, 59, 58, 58, 58,
57, 57, 57, 57, 56, 55, 55, 55, 54, 54, 53, 52, 51, 50, 50, 49, 47, 47, 45, 44,
43, 42, 40, 39, 38, 36, 36, 33, 32, 30, 29, 27, 25, 23, 21, 19, 19, 16, 13, 11,
9, 7, 5, 3, 2, 0, -3, 2, 3, 8, 7, 4, 2, 0, -1, -4, -5, -8, -10, -12, -13, -16,
-18, -18, -20, -22, -24, -25, -26, -28, -30, -30, -32, -34, -35, -36, -36, -38,
-39, -41, -40, -53, -99, -115, -117, -119, -118, -117, -116, -115, -115, -113,
-112, -111, -110, -111, -109, -107, -106, -107, -105, -105, -104, -103, -102,
-101, -101, -99, -98, -98, -97, -95, -95, -94, -94, -91, -96, -107, -106, -105,
-104, -102, -102, -99, -99, -97, -96, -95, -95, -93, -92, -91, -89, -89, -88,
-87, -84, -84, -83, -81, -81, -80, -79, -77, -77, -76, -74, -73, -72, -72, -71,
-70, -69, -68, -67, -67, -65, -65, -64, -64, -63, -63, -62, -62, -61, -61, -60,
-61, -60, -59, -60, -59, -59, -60, -60, -54, -50, -43, -43, -44, -43, -45, -43,
-45, -45, -47, -46, -46, -47, -47, -48, -50, -50, -51, -51, -51, -53, -53, -53,
-54, -55, -56, -57, -57, -58, -59, -60, -60, -62, -62, -63, -62, -64, -65, -65,
-67, -67, -67, -69, -68, -70, -71, -71, -72, -73, -73, -73, -73, -75, -75, -75,
-75, -75, -76, -76, -76, -77, -77, -76, -77, -77, -76, -76, -75, -82, -92, -91,
-92, -91, -90, -90, -89, -90, -88, -88, -88, -86, -86, -85, -84, -83, -83, -82,
-80, -80, -79, -77, -76, -74, -74, -72, -71, -70, -68, -66, -65, -65, -62, -60,
-59, -56, -56, -54, -52, -50, -48, -46, -45, -42, -41, -38, -37, -35, -36, -37,
-39, -41, -43, -42, -39, -34, -28, -23, -9, -1, };