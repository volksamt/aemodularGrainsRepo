#define DATA_LENGTH 512
#define DATA AKWF_0062

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 4, 5, 7, 8, 10, 12, 12, 14, 16,
16, 18, 21, 21, 22, 25, 26, 28, 29, 30, 32, 33, 33, 36, 37, 37, 39, 41, 42, 43,
45, 45, 46, 47, 48, 49, 50, 51, 52, 53, 54, 56, 56, 58, 59, 61, 63, 64, 65, 67,
68, 68, 69, 70, 71, 73, 74, 74, 76, 77, 77, 78, 78, 80, 80, 81, 82, 83, 84, 85,
85, 85, 87, 88, 89, 89, 89, 90, 90, 91, 93, 93, 93, 93, 94, 94, 95, 95, 96, 96,
96, 97, 97, 98, 97, 98, 98, 98, 99, 98, 99, 99, 99, 99, 100, 100, 101, 100, 100,
101, 100, 100, 99, 100, 99, 100, 101, 100, 100, 100, 100, 100, 100, 98, 98, 99,
98, 98, 98, 98, 98, 97, 97, 97, 97, 96, 96, 95, 95, 95, 94, 94, 94, 94, 93, 92,
91, 92, 91, 91, 90, 90, 89, 89, 88, 87, 87, 86, 86, 86, 84, 84, 84, 82, 82, 82,
82, 80, 80, 80, 79, 78, 77, 76, 76, 76, 75, 74, 72, 73, 72, 71, 70, 69, 69, 68,
67, 67, 65, 65, 65, 64, 63, 62, 61, 60, 59, 59, 57, 57, 55, 55, 54, 53, 53, 51,
51, 50, 48, 48, 47, 46, 45, 44, 44, 42, 41, 40, 39, 37, 36, 35, 34, 34, 33, 33,
32, 30, 30, 28, 26, 26, 24, 23, 23, 22, 20, 20, 19, 17, 15, 15, 14, 12, 11, 9,
9, 9, 7, 6, 5, 3, 2, 0, -1, -2, -3, -5, -5, -6, -7, -9, -11, -12, -13, -14, -16,
-17, -18, -19, -20, -21, -23, -25, -26, -27, -28, -29, -31, -32, -33, -34, -35,
-36, -38, -38, -40, -41, -42, -43, -43, -44, -46, -46, -47, -47, -49, -49, -50,
-52, -53, -54, -55, -57, -58, -59, -60, -62, -62, -64, -65, -67, -67, -68, -69,
-70, -70, -71, -72, -73, -74, -75, -76, -77, -78, -79, -79, -80, -80, -81, -81,
-82, -83, -84, -85, -85, -87, -87, -87, -88, -89, -89, -89, -91, -91, -91, -91,
-93, -93, -93, -93, -94, -94, -95, -95, -96, -96, -96, -97, -96, -96, -97, -98,
-97, -98, -97, -99, -98, -98, -98, -98, -98, -98, -98, -99, -99, -99, -99, -99,
-98, -99, -98, -98, -98, -98, -98, -97, -99, -97, -98, -98, -97, -97, -97, -96,
-97, -96, -95, -94, -94, -95, -94, -93, -93, -93, -94, -92, -92, -92, -91, -90,
-90, -90, -90, -90, -89, -88, -88, -88, -87, -86, -86, -84, -84, -84, -83, -84,
-82, -82, -82, -81, -80, -79, -79, -78, -78, -78, -77, -76, -74, -74, -74, -74,
-72, -72, -71, -70, -70, -69, -68, -67, -66, -66, -65, -64, -63, -63, -62, -61,
-60, -59, -59, -57, -56, -56, -55, -52, -51, -51, -50, -48, -47, -45, -45, -45,
-45, -45, -44, -43, -40, -39, -37, -35, -34, -33, -33, -32, -31, -31, -29, -28,
-26, -24, -22, -22, -20, -19, -17, -17, -17, -15, -13, -11, -9, -8, -7, -6, -3,
-3, -1, 0, };