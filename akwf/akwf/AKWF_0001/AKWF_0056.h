#define DATA_LENGTH 512
#define DATA AKWF_0056

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, -2, -3, -4, -4, -6, -7, -7, -9,
-10, -10, -11, -12, -13, -14, -15, -15, -17, -17, -19, -19, -20, -21, -20, -21,
-22, -23, -24, -24, -25, -27, -27, -27, -28, -29, -30, -30, -31, -32, -33, -33,
-34, -35, -35, -36, -37, -37, -39, -39, -39, -40, -41, -41, -42, -42, -43, -44,
-44, -46, -47, -47, -48, -47, -49, -49, -49, -50, -52, -52, -52, -53, -54, -54,
-55, -55, -57, -57, -57, -58, -58, -59, -60, -61, -61, -61, -62, -62, -63, -64,
-65, -66, -66, -66, -67, -67, -68, -68, -68, -69, -70, -70, -71, -72, -71, -73,
-73, -72, -74, -74, -75, -75, -75, -75, -76, -77, -77, -77, -78, -78, -79, -79,
-79, -80, -80, -80, -81, -81, -81, -81, -81, -82, -82, -82, -83, -83, -83, -83,
-84, -84, -83, -85, -85, -84, -84, -84, -84, -85, -86, -85, -85, -85, -86, -85,
-85, -86, -86, -85, -86, -85, -85, -85, -85, -85, -85, -85, -85, -84, -84, -85,
-85, -85, -85, -84, -84, -83, -84, -83, -83, -83, -83, -82, -82, -82, -81, -81,
-81, -81, -80, -79, -78, -78, -78, -77, -77, -76, -76, -76, -75, -75, -73, -73,
-73, -72, -71, -70, -71, -69, -68, -68, -67, -66, -66, -65, -64, -63, -62, -61,
-60, -59, -59, -58, -57, -55, -55, -53, -52, -51, -50, -48, -48, -45, -45, -44,
-43, -41, -40, -38, -37, -35, -33, -32, -31, -29, -28, -25, -24, -22, -20, -17,
-16, -12, -9, -6, -4, -3, 0, 2, 4, 7, 7, 11, 12, 14, 17, 18, 20, 22, 24, 25, 28,
29, 30, 32, 34, 35, 36, 39, 39, 41, 42, 43, 46, 46, 47, 49, 50, 51, 53, 53, 54,
56, 56, 58, 58, 60, 61, 62, 63, 63, 64, 64, 66, 66, 67, 68, 69, 69, 70, 71, 71,
72, 73, 73, 73, 76, 75, 76, 76, 76, 77, 78, 78, 79, 79, 80, 80, 80, 80, 80, 81,
81, 82, 83, 83, 83, 83, 83, 83, 84, 83, 84, 84, 85, 84, 84, 84, 85, 85, 85, 85,
84, 85, 85, 86, 86, 86, 85, 86, 85, 84, 85, 85, 86, 85, 85, 85, 85, 84, 84, 84,
84, 84, 84, 84, 84, 83, 83, 83, 82, 83, 82, 82, 82, 81, 81, 81, 81, 80, 79, 79,
79, 79, 79, 79, 78, 78, 78, 77, 76, 76, 75, 75, 75, 75, 74, 73, 73, 72, 73, 71,
70, 70, 70, 69, 69, 68, 69, 67, 67, 67, 66, 65, 65, 65, 64, 63, 63, 61, 61, 61,
60, 60, 59, 58, 58, 57, 56, 56, 55, 55, 54, 53, 53, 52, 52, 51, 51, 49, 49, 49,
48, 47, 46, 46, 46, 44, 44, 43, 42, 42, 42, 41, 39, 40, 38, 38, 37, 36, 36, 35,
34, 33, 33, 32, 32, 32, 30, 30, 29, 28, 27, 27, 26, 26, 25, 24, 23, 22, 22, 22,
21, 20, 19, 18, 18, 16, 17, 15, 15, 13, 13, 12, 11, 11, 8, 8, 6, 5, 4, 2, 1, -1,
};