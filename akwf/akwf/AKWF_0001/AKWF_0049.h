#define DATA_LENGTH 512
#define DATA AKWF_0049

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 13, 18, 23, 28, 33, 39, 44, 49,
53, 58, 63, 67, 71, 74, 79, 81, 85, 89, 92, 94, 98, 99, 103, 104, 107, 108, 110,
111, 113, 113, 114, 115, 114, 114, 114, 114, 113, 112, 111, 109, 107, 105, 103,
100, 98, 95, 93, 89, 86, 83, 80, 75, 72, 68, 66, 63, 59, 54, 52, 48, 45, 41, 39,
36, 33, 29, 27, 24, 21, 18, 16, 14, 11, 9, 6, 5, 3, 1, -1, -3, -3, -5, -5, -6,
-6, -6, -5, -5, -4, -3, -1, 0, 3, 5, 8, 9, 12, 14, 17, 19, 22, 25, 28, 30, 33,
35, 37, 39, 41, 42, 44, 46, 46, 48, 49, 49, 49, 50, 50, 49, 48, 48, 47, 45, 44,
42, 40, 39, 36, 35, 33, 30, 27, 25, 21, 17, 14, 9, 5, 1, -3, -8, -14, -18, -22,
-27, -32, -37, -42, -47, -51, -57, -61, -64, -68, -72, -77, -81, -83, -87, -90,
-94, -96, -99, -102, -103, -107, -108, -110, -111, -113, -114, -116, -117, -118,
-118, -118, -119, -119, -119, -118, -119, -118, -116, -116, -114, -111, -110,
-107, -104, -101, -98, -95, -91, -86, -83, -78, -74, -70, -66, -61, -57, -53,
-48, -43, -39, -34, -30, -26, -21, -17, -14, -10, -6, -3, 1, 3, 7, 9, 10, 13,
15, 17, 19, 19, 19, 22, 21, 22, 24, 23, 24, 24, 23, 24, 22, 22, 22, 21, 20, 19,
19, 17, 17, 16, 14, 14, 12, 11, 11, 9, 9, 7, 5, 5, 4, 4, 3, 3, 1, 1, 2, 0, 0, 0,
1, 1, 2, 1, 2, 3, 2, 3, 5, 6, 6, 8, 9, 11, 12, 13, 15, 17, 18, 20, 23, 24, 27,
29, 32, 34, 38, 40, 42, 45, 48, 52, 55, 58, 61, 64, 66, 70, 72, 75, 78, 80, 82,
85, 88, 89, 91, 93, 95, 97, 98, 99, 101, 102, 103, 103, 104, 104, 104, 104, 104,
103, 103, 102, 101, 101, 99, 97, 96, 94, 92, 90, 87, 85, 83, 80, 77, 74, 71, 67,
64, 62, 58, 55, 51, 48, 45, 42, 37, 35, 33, 28, 25, 22, 18, 15, 12, 8, 5, 2, -1,
-4, -9, -11, -15, -17, -20, -24, -27, -29, -34, -36, -38, -41, -44, -47, -50,
-53, -55, -57, -59, -60, -64, -65, -67, -69, -69, -70, -71, -71, -72, -72, -73,
-72, -72, -71, -70, -71, -69, -68, -67, -67, -65, -65, -63, -62, -59, -60, -58,
-57, -55, -54, -53, -51, -49, -48, -48, -46, -44, -43, -43, -41, -40, -39, -38,
-38, -37, -36, -36, -34, -34, -34, -33, -33, -33, -32, -33, -32, -33, -34, -34,
-35, -37, -37, -37, -39, -40, -41, -43, -44, -45, -46, -48, -49, -52, -52, -53,
-55, -57, -57, -59, -61, -61, -63, -64, -65, -67, -68, -70, -71, -72, -72, -74,
-74, -74, -75, -75, -76, -76, -76, -75, -75, -74, -74, -73, -71, -70, -68, -66,
-63, -60, -58, -54, -51, -48, -45, -41, -36, -33, -28, -23, -18, -13, -8, -2, };