#define DATA_LENGTH 512
#define DATA AKWF_0080

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 4, 7, 9, 10, 13, 14, 16, 17, 19,
21, 23, 25, 26, 28, 30, 31, 33, 34, 37, 38, 40, 41, 43, 44, 46, 48, 49, 51, 53,
53, 54, 57, 57, 60, 61, 63, 64, 65, 66, 68, 69, 71, 72, 73, 74, 75, 77, 78, 79,
81, 82, 83, 84, 85, 86, 87, 89, 90, 90, 92, 92, 94, 95, 95, 97, 97, 98, 99, 100,
102, 102, 103, 103, 103, 105, 105, 107, 107, 107, 108, 109, 110, 110, 111, 111,
112, 112, 113, 113, 114, 114, 114, 114, 115, 115, 116, 117, 117, 117, 118, 117,
117, 118, 118, 118, 119, 118, 119, 120, 119, 119, 119, 119, 119, 119, 118, 119,
119, 119, 118, 118, 118, 118, 118, 118, 118, 117, 116, 117, 116, 117, 117, 116,
115, 115, 116, 115, 114, 113, 114, 114, 112, 113, 113, 111, 112, 111, 111, 111,
110, 110, 109, 108, 108, 109, 108, 107, 107, 106, 105, 105, 105, 105, 104, 103,
103, 103, 102, 102, 101, 101, 100, 100, 99, 98, 98, 97, 97, 96, 96, 95, 94, 94,
93, 93, 92, 90, 90, 89, 88, 88, 87, 86, 85, 84, 83, 83, 81, 81, 79, 78, 77, 76,
75, 73, 72, 71, 70, 70, 68, 67, 65, 65, 63, 62, 60, 59, 58, 56, 55, 53, 52, 51,
49, 47, 46, 45, 43, 42, 40, 39, 37, 37, 35, 33, 32, 29, 28, 26, 25, 23, 22, 20,
18, 17, 15, 13, 10, 9, 7, 6, 4, 2, 0, -2, -4, -5, -7, -9, -10, -12, -14, -17,
-17, -19, -21, -24, -24, -26, -28, -30, -31, -33, -35, -36, -39, -40, -42, -43,
-44, -45, -47, -50, -51, -52, -54, -55, -56, -58, -60, -61, -62, -64, -65, -67,
-68, -69, -70, -71, -74, -74, -76, -77, -78, -79, -81, -82, -83, -85, -85, -87,
-88, -89, -90, -91, -91, -93, -94, -95, -96, -97, -98, -99, -99, -100, -101,
-103, -103, -103, -105, -105, -106, -106, -107, -108, -109, -109, -109, -110,
-112, -111, -111, -112, -113, -113, -113, -114, -115, -115, -116, -116, -117,
-116, -117, -117, -117, -118, -118, -118, -118, -118, -118, -118, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -118, -118,
-118, -118, -118, -117, -116, -118, -116, -116, -116, -116, -115, -115, -115,
-115, -114, -114, -114, -113, -113, -114, -113, -113, -112, -111, -112, -111,
-110, -110, -110, -109, -109, -109, -107, -108, -107, -107, -106, -106, -105,
-104, -104, -104, -104, -102, -102, -102, -101, -101, -101, -99, -100, -99, -98,
-97, -97, -97, -96, -95, -95, -95, -93, -93, -91, -92, -91, -90, -90, -89, -88,
-86, -86, -86, -84, -84, -83, -81, -81, -79, -78, -77, -75, -75, -73, -72, -71,
-70, -69, -68, -67, -65, -64, -63, -61, -60, -58, -58, -56, -55, -53, -52, -50,
-49, -48, -46, -45, -43, -41, -40, -39, -37, -36, -34, -33, -31, -30, -28, -26,
-24, -23, -22, -19, -18, -16, -14, -12, -11, -9, -6, -6, -3, -2, -1, };