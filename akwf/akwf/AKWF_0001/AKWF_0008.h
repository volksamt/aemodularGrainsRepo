#define DATA_LENGTH 512
#define DATA AKWF_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, -2, -3, -4, -6, -7, -9, -10, -13,
-13, -16, -18, -19, -21, -23, -24, -26, -27, -29, -31, -32, -33, -35, -37, -39,
-40, -41, -43, -44, -46, -46, -49, -49, -51, -53, -54, -55, -56, -56, -58, -59,
-60, -61, -62, -62, -64, -65, -65, -67, -68, -68, -69, -69, -70, -71, -71, -71,
-72, -74, -74, -74, -74, -75, -75, -76, -76, -76, -78, -77, -77, -79, -78, -78,
-79, -80, -80, -80, -80, -79, -80, -81, -80, -81, -81, -81, -82, -81, -81, -81,
-81, -82, -81, -81, -81, -81, -82, -80, -80, -81, -81, -80, -81, -80, -81, -80,
-80, -80, -79, -80, -80, -79, -79, -78, -79, -78, -77, -78, -78, -77, -77, -76,
-77, -76, -76, -76, -75, -75, -74, -74, -74, -74, -72, -73, -72, -72, -71, -70,
-69, -69, -68, -68, -68, -67, -67, -66, -66, -66, -64, -64, -64, -63, -63, -62,
-62, -61, -60, -60, -59, -59, -59, -58, -57, -57, -56, -56, -56, -56, -55, -55,
-55, -53, -54, -54, -53, -53, -53, -53, -53, -52, -52, -53, -53, -53, -53, -52,
-52, -53, -54, -53, -54, -56, -57, -56, -59, -59, -61, -61, -63, -65, -66, -69,
-69, -72, -73, -76, -78, -79, -81, -83, -85, -86, -88, -91, -92, -94, -96, -96,
-98, -100, -101, -103, -102, -104, -105, -106, -107, -107, -108, -109, -109,
-109, -110, -110, -111, -110, -110, -111, -111, -111, -111, -111, -111, -111,
-111, -110, -109, -109, -109, -109, -108, -107, -107, -106, -106, -105, -104,
-104, -103, -102, -101, -100, -99, -98, -97, -96, -94, -93, -91, -91, -88, -87,
-85, -84, -82, -81, -79, -78, -75, -73, -72, -70, -68, -66, -64, -62, -60, -57,
-55, -54, -51, -49, -46, -44, -42, -40, -37, -35, -32, -31, -27, -25, -23, -20,
-18, -17, -13, -11, -9, -8, -6, -4, -2, 0, 1, 2, 4, 7, 8, 11, 13, 15, 18, 21,
23, 25, 28, 31, 34, 37, 39, 43, 45, 48, 51, 53, 57, 59, 62, 65, 68, 71, 74, 77,
80, 82, 85, 87, 91, 93, 96, 98, 101, 102, 104, 107, 108, 110, 112, 112, 114,
114, 116, 117, 118, 118, 118, 118, 119, 119, 119, 119, 118, 119, 118, 119, 118,
118, 118, 117, 117, 117, 116, 116, 115, 116, 114, 114, 114, 114, 114, 114, 113,
113, 113, 114, 113, 113, 113, 113, 113, 114, 113, 114, 113, 114, 114, 114, 114,
114, 115, 115, 115, 115, 115, 116, 116, 116, 117, 117, 117, 118, 118, 117, 118,
118, 118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 119,
118, 118, 117, 117, 118, 116, 116, 116, 116, 115, 114, 114, 111, 112, 110, 109,
108, 108, 106, 105, 104, 102, 101, 99, 98, 97, 95, 94, 91, 90, 88, 86, 84, 81,
79, 77, 75, 72, 70, 69, 66, 64, 61, 59, 56, 53, 51, 49, 48, 45, 42, 40, 37, 35,
32, 31, 27, 25, 23, 21, 19, 16, 14, 13, 11, 9, 6, 5, 4, 2, 1, 0, };