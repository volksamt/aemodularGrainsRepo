#define DATA_LENGTH 512
#define DATA AKWF_0099

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 5, 7, 6, 8, 8, 9, 11, 11,
12, 13, 13, 14, 14, 15, 16, 17, 17, 18, 19, 20, 20, 22, 22, 22, 23, 24, 24, 25,
26, 26, 26, 27, 28, 28, 29, 29, 31, 31, 31, 32, 32, 34, 34, 34, 36, 36, 37, 37,
38, 38, 39, 38, 40, 41, 41, 41, 42, 42, 43, 43, 44, 44, 45, 46, 46, 46, 47, 47,
48, 48, 49, 49, 49, 51, 50, 51, 51, 52, 52, 52, 54, 54, 54, 54, 54, 55, 56, 55,
56, 56, 57, 58, 58, 58, 58, 59, 59, 60, 60, 61, 61, 61, 62, 63, 62, 63, 62, 63,
64, 64, 64, 65, 65, 65, 65, 67, 67, 67, 66, 67, 68, 68, 68, 69, 70, 69, 69, 70,
71, 70, 72, 71, 72, 71, 72, 72, 73, 72, 73, 73, 73, 73, 74, 75, 74, 74, 75, 74,
76, 75, 75, 76, 76, 76, 77, 76, 76, 78, 77, 78, 77, 77, 78, 78, 79, 79, 78, 78,
79, 79, 78, 79, 79, 79, 80, 79, 80, 79, 79, 80, 80, 81, 80, 81, 80, 82, 81, 81,
81, 81, 81, 82, 81, 82, 82, 82, 83, 82, 82, 82, 83, 82, 83, 82, 83, 83, 82, 82,
83, 82, 83, 82, 83, 83, 83, 83, 83, 82, 83, 83, 82, 83, 83, 82, 82, 82, 82, 83,
82, 82, 82, 82, 83, 82, 82, 83, 82, 82, 82, 82, 82, 82, 82, 82, 82, 82, 82, 81,
81, 81, 81, 81, 81, 81, 80, 81, 81, 81, 80, 80, 80, 81, 80, 80, 81, 80, 79, 80,
80, 79, 79, 78, 80, 79, 78, 78, 77, 30, -36, -68, -87, -92, -93, -93, -96, -98,
-100, -104, -106, -109, -110, -113, -114, -115, -116, -117, -119, -118, -118,
-118, -119, -119, -118, -120, -118, -118, -118, -118, -118, -118, -117, -117,
-117, -116, -116, -115, -115, -114, -114, -113, -113, -113, -113, -113, -113,
-112, -111, -112, -111, -110, -110, -110, -109, -109, -108, -108, -107, -106,
-107, -107, -105, -105, -104, -104, -104, -103, -103, -103, -102, -102, -102,
-101, -100, -100, -99, -99, -99, -99, -98, -98, -97, -97, -96, -95, -95, -94,
-94, -93, -93, -92, -92, -91, -90, -91, -90, -89, -88, -88, -87, -87, -87, -86,
-85, -85, -85, -84, -83, -83, -82, -82, -81, -81, -80, -80, -79, -78, -78, -77,
-77, -77, -75, -75, -74, -74, -74, -72, -72, -71, -71, -70, -71, -70, -69, -67,
-68, -66, -66, -65, -65, -65, -63, -63, -63, -61, -61, -62, -60, -60, -59, -57,
-58, -57, -56, -56, -56, -54, -54, -53, -52, -52, -51, -51, -50, -49, -48, -48,
-47, -47, -46, -45, -45, -44, -44, -42, -42, -41, -40, -40, -39, -39, -37, -37,
-37, -35, -35, -35, -34, -33, -32, -32, -31, -31, -29, -28, -28, -28, -27, -25,
-26, -25, -24, -23, -23, -21, -21, -19, -19, -18, -18, -17, -16, -16, -14, -14,
-13, -12, -12, -10, -11, -9, -8, -7, -7, -5, -4, -3, -3, -1, };