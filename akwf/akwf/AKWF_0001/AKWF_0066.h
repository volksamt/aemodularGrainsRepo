#define DATA_LENGTH 512
#define DATA AKWF_0066

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 17, 22, 24, 26, 29, 30, 31, 32,
34, 35, 37, 37, 39, 39, 41, 42, 43, 44, 45, 45, 47, 47, 48, 48, 49, 50, 51, 52,
52, 53, 53, 54, 55, 56, 56, 57, 58, 58, 59, 60, 60, 61, 60, 62, 63, 62, 63, 63,
64, 64, 64, 64, 64, 63, 64, 64, 64, 64, 64, 63, 65, 64, 64, 64, 64, 63, 63, 63,
64, 64, 64, 64, 65, 64, 64, 64, 64, 64, 64, 64, 63, 64, 64, 64, 64, 64, 64, 65,
64, 64, 64, 64, 64, 64, 63, 64, 63, 64, 63, 64, 64, 64, 64, 64, 64, 64, 63, 64,
64, 64, 64, 63, 65, 63, 65, 64, 65, 63, 65, 63, 65, 62, 66, 62, 65, 48, -46,
-65, -63, -65, -63, -65, -63, -66, -63, -65, -62, -63, -62, -62, -61, -61, -60,
-60, -59, -58, -57, -57, -56, -57, -55, -55, -54, -53, -53, -52, -51, -50, -49,
-49, -49, -47, -47, -46, -44, -44, -43, -42, -41, -41, -39, -38, -36, -36, -35,
-33, -31, -30, -28, -27, -25, -22, -19, -12, -4, 3, 10, 17, 22, 24, 26, 29, 30,
32, 32, 34, 36, 37, 37, 39, 40, 41, 42, 43, 43, 45, 46, 46, 47, 48, 49, 49, 50,
51, 52, 52, 53, 54, 54, 55, 56, 56, 57, 57, 58, 58, 59, 60, 60, 61, 62, 62, 62,
64, 63, 64, 63, 64, 63, 65, 63, 64, 63, 65, 63, 65, 64, 65, 64, 64, 64, 63, 67,
-22, -66, -61, -66, -61, -66, -62, -65, -63, -65, -63, -65, -64, -65, -64, -64,
-64, -64, -64, -64, -63, -63, -63, -62, -62, -62, -61, -60, -59, -59, -58, -57,
-57, -56, -56, -55, -54, -53, -53, -52, -51, -52, -50, -50, -48, -48, -47, -46,
-46, -45, -43, -42, -42, -40, -39, -39, -38, -37, -36, -34, -34, -32, -29, -29,
-27, -25, -23, -20, -12, -5, 2, 9, 17, 21, 25, 26, 28, 29, 31, 33, 33, 35, 36,
38, 39, 40, 41, 42, 42, 44, 45, 45, 47, 48, 48, 48, 49, 50, 51, 52, 52, 53, 54,
54, 55, 55, 56, 57, 57, 58, 60, 59, 60, 59, 63, 60, 63, 61, 64, 62, 66, 62, 66,
61, 65, 62, 66, 63, -52, -68, -61, -67, -61, -67, -61, -67, -62, -65, -62, -64,
-62, -66, -63, -64, -63, -65, -64, -64, -64, -64, -64, -64, -65, -64, -64, -63,
-64, -64, -64, -63, -65, -63, -64, -63, -64, -64, -63, -63, -64, -64, -64, -64,
-63, -64, -64, -65, -64, -64, -64, -64, -64, -64, -63, -64, -63, -64, -64, -64,
-64, -64, -64, -64, -64, -64, -65, -64, -63, -64, -64, -64, -64, -64, -64, -64,
-64, -64, -64, -63, -63, -62, -62, -61, -61, -60, -59, -59, -58, -58, -58, -57,
-56, -56, -55, -55, -54, -54, -53, -52, -51, -51, -50, -48, -48, -48, -46, -47,
-45, -44, -44, -42, -41, -40, -39, -37, -37, -36, -34, -34, -31, -30, -29, -27,
-25, -22, -18, -11, -3, };