#define DATA_LENGTH 512
#define DATA AKWF_0028

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 13, 15, 19, 22, 24, 27, 30,
33, 36, 39, 42, 44, 47, 50, 51, 53, 56, 59, 61, 63, 64, 66, 68, 69, 70, 72, 74,
74, 75, 77, 78, 79, 80, 80, 82, 83, 83, 84, 84, 86, 85, 87, 87, 87, 87, 88, 88,
89, 89, 90, 91, 91, 92, 91, 90, 91, 92, 92, 93, 93, 93, 93, 93, 93, 93, 94, 93,
94, 93, 94, 94, 93, 94, 94, 95, 95, 94, 95, 94, 94, 94, 94, 96, 95, 94, 95, 95,
95, 94, 96, 95, 95, 96, 95, 95, 95, 95, 96, 95, 95, 95, 96, 96, 96, 96, 96, 96,
95, 95, 95, 96, 95, 95, 95, 95, 96, 95, 95, 95, 96, 96, 95, 96, 95, 96, 96, 96,
95, 96, 95, 95, 95, 95, 95, 95, 95, 95, 95, 96, 96, 96, 96, 95, 95, 95, 96, 95,
95, 96, 96, 96, 96, 96, 95, 96, 96, 96, 96, 95, 96, 95, 95, 96, 95, 95, 96, 95,
96, 95, 96, 95, 96, 95, 96, 95, 96, 96, 95, 96, 96, 96, 96, 96, 96, 95, 96, 95,
95, 95, 96, 96, 95, 96, 95, 95, 96, 96, 96, 95, 96, 94, 91, 89, 88, 87, 83, 82,
79, 78, 76, 73, 71, 69, 67, 65, 62, 60, 58, 55, 52, 51, 49, 47, 44, 42, 41, 39,
37, 36, 34, 33, 31, 29, 28, 26, 25, 24, 22, 23, 21, 20, 19, 18, 18, 17, 15, 15,
15, 14, 13, 11, 5, 1, -1, -6, -10, -14, -16, -19, -22, -24, -27, -31, -33, -36,
-39, -42, -44, -47, -49, -52, -54, -56, -59, -60, -62, -64, -66, -68, -70, -71,
-72, -74, -75, -76, -77, -78, -79, -81, -81, -82, -82, -83, -85, -84, -85, -86,
-86, -86, -88, -88, -88, -89, -89, -90, -91, -90, -91, -90, -92, -92, -92, -92,
-91, -92, -92, -93, -93, -93, -93, -93, -93, -94, -93, -94, -94, -94, -94, -94,
-95, -94, -95, -94, -95, -94, -95, -94, -94, -95, -95, -95, -94, -95, -94, -96,
-94, -95, -96, -95, -95, -95, -95, -95, -96, -95, -95, -95, -95, -95, -95, -95,
-96, -95, -95, -96, -95, -95, -96, -95, -95, -95, -96, -95, -96, -95, -95, -95,
-95, -96, -95, -95, -95, -95, -96, -95, -95, -96, -95, -96, -95, -96, -95, -96,
-96, -96, -96, -95, -96, -96, -95, -95, -95, -96, -95, -95, -95, -95, -95, -95,
-96, -96, -95, -95, -96, -95, -96, -96, -96, -95, -95, -96, -95, -95, -95, -96,
-96, -95, -95, -95, -96, -96, -95, -96, -95, -95, -96, -96, -95, -95, -96, -95,
-96, -95, -95, -95, -96, -96, -96, -96, -96, -95, -96, -95, -96, -95, -96, -94,
-90, -89, -88, -86, -83, -82, -80, -78, -76, -74, -71, -68, -67, -64, -62, -60,
-57, -55, -53, -50, -48, -46, -44, -42, -40, -38, -37, -35, -33, -31, -30, -29,
-27, -26, -25, -24, -23, -21, -21, -20, -19, -18, -18, -17, -16, -15, -14, -14,
-13, -12, -5, 0, };