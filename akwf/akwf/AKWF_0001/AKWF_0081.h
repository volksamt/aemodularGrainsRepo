#define DATA_LENGTH 512
#define DATA AKWF_0081

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 8, 9, 12, 15, 17, 19, 21, 24,
26, 29, 31, 32, 35, 37, 39, 42, 44, 46, 48, 50, 52, 54, 56, 59, 61, 62, 64, 66,
68, 69, 71, 74, 74, 77, 78, 79, 82, 83, 85, 86, 88, 89, 90, 91, 94, 95, 95, 97,
98, 99, 100, 100, 101, 103, 104, 104, 105, 106, 106, 107, 108, 108, 109, 109,
110, 110, 110, 110, 110, 110, 110, 110, 109, 110, 110, 110, 110, 109, 108, 107,
107, 107, 107, 106, 105, 104, 103, 102, 102, 101, 100, 99, 98, 97, 96, 95, 94,
92, 91, 90, 89, 86, 86, 85, 84, 83, 81, 80, 79, 77, 75, 75, 73, 72, 71, 69, 68,
67, 65, 64, 62, 61, 60, 58, 57, 55, 55, 53, 52, 50, 49, 48, 47, 45, 43, 42, 40,
39, 38, 37, 36, 34, 32, 31, 30, 29, 28, 27, 26, 24, 23, 21, 21, 19, 18, 17, 16,
15, 14, 13, 12, 11, 10, 9, 8, 6, 6, 5, 4, 3, 3, 2, 1, 0, -1, -2, -2, -3, -4, -4,
-6, -6, -6, -8, -7, -8, -9, -8, -10, -9, -10, -11, -11, -12, -11, -12, -12, -12,
-13, -13, -13, -13, -13, -13, -13, -12, -13, -13, -14, -13, -13, -13, -13, -13,
-13, -13, -12, -13, -12, -12, -12, -12, -12, -11, -11, -11, -11, -11, -10, -10,
-9, -9, -10, -9, -9, -9, -7, -8, -7, -7, -6, -5, -5, -5, -4, -3, -3, -3, -1, 0,
1, 1, 2, 3, 4, 5, 6, 7, 8, 10, 10, 11, 13, 13, 14, 15, 16, 17, 18, 18, 20, 21,
22, 22, 23, 24, 24, 24, 25, 25, 27, 27, 27, 28, 27, 29, 29, 28, 29, 29, 30, 28,
28, 29, 29, 29, 29, 28, 29, 28, 28, 27, 28, 27, 26, 26, 26, 25, 26, 24, 24, 23,
23, 23, 21, 21, 20, 19, 19, 17, 17, 16, 15, 14, 13, 12, 11, 10, 9, 8, 7, 6, 4,
4, 2, 1, -1, -2, -2, -4, -5, -7, -8, -10, -10, -12, -14, -15, -16, -18, -19,
-20, -22, -24, -25, -25, -27, -28, -30, -32, -34, -35, -36, -37, -39, -40, -42,
-43, -45, -45, -48, -49, -50, -52, -52, -53, -55, -57, -58, -60, -61, -63, -64,
-65, -67, -68, -69, -70, -71, -73, -75, -76, -77, -79, -80, -82, -82, -84, -85,
-86, -88, -89, -91, -92, -92, -94, -96, -96, -98, -99, -101, -101, -103, -104,
-104, -106, -107, -108, -109, -110, -111, -112, -113, -114, -115, -115, -115,
-116, -117, -117, -117, -117, -118, -119, -118, -118, -119, -119, -119, -119,
-118, -119, -119, -117, -118, -117, -117, -116, -116, -115, -114, -113, -112,
-111, -111, -109, -108, -107, -106, -105, -104, -103, -101, -98, -98, -95, -94,
-93, -91, -89, -87, -86, -83, -82, -80, -77, -75, -74, -71, -70, -67, -66, -63,
-61, -59, -56, -55, -51, -49, -47, -45, -43, -41, -39, -36, -33, -31, -28, -26,
-24, -21, -19, -17, -14, -12, -9, -6, -4, -2, };