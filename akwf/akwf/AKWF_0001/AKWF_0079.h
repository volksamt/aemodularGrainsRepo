#define DATA_LENGTH 512
#define DATA AKWF_0079

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 1, 1, 1, 1, 1, 1, 2, 2, 2, 1,
2, 2, 2, 1, 2, 3, 3, 3, 4, 4, 5, 5, 5, 6, 7, 7, 7, 8, 8, 8, 9, 8, 9, 9, 9, 10,
10, 10, 12, 11, 11, 12, 12, 13, 13, 13, 14, 14, 15, 16, 15, 16, 16, 16, 17, 17,
17, 17, 18, 18, 18, 19, 19, 19, 20, 19, 20, 21, 20, 21, 22, 21, 21, 21, 22, 22,
22, 22, 22, 22, 23, 23, 23, 23, 24, 25, 24, 25, 25, 25, 25, 26, 26, 26, 26, 27,
26, 27, 27, 28, 28, 28, 28, 29, 30, 29, 30, 29, 30, 31, 31, 32, 31, 32, 32, 32,
33, 33, 34, 33, 35, 35, 34, 35, 36, 35, 36, 36, 38, 38, 37, 38, 38, 38, 38, 39,
39, 39, 40, 40, 40, 40, 41, 41, 41, 41, 41, 41, 42, 42, 43, 43, 43, 44, 44, 43,
45, 44, 45, 45, 45, 46, 45, 46, 46, 46, 46, 47, 47, 48, 48, 49, 48, 49, 48, 49,
50, 49, 51, 51, 51, 50, 51, 52, 51, 52, 52, 53, 53, 53, 54, 54, 54, 54, 55, 55,
55, 55, 56, 56, 57, 57, 57, 57, 57, 57, 57, 58, 58, 59, 59, 59, 59, 61, 60, 60,
61, 61, 62, 62, 63, 62, 63, 63, 63, 63, 64, 64, 65, 64, 65, 65, 65, 66, 66, 66,
66, 67, 67, 68, 67, 68, 68, 69, 68, 69, 69, 69, 69, 70, 71, 71, 71, 60, 40, 13,
-18, -46, -70, -87, -96, -96, -90, -78, -65, -51, -40, -33, -29, -30, -34, -40,
-46, -52, -57, -60, -63, -64, -67, -70, -75, -81, -88, -96, -104, -112, -117,
-119, -117, -112, -104, -94, -83, -73, -63, -58, -55, -55, -59, -66, -72, -81,
-87, -93, -97, -96, -94, -90, -82, -75, -66, -57, -50, -45, -40, -37, -35, -35,
-34, -33, -35, -35, -36, -37, -38, -39, -40, -42, -42, -42, -42, -41, -40, -36,
-34, -30, -27, -24, -22, -21, -21, -22, -24, -28, -32, -37, -42, -45, -49, -50,
-52, -52, -52, -50, -49, -47, -45, -43, -43, -42, -42, -43, -43, -45, -46, -48,
-50, -51, -54, -54, -55, -56, -56, -55, -53, -52, -51, -49, -47, -44, -41, -41,
-38, -37, -36, -35, -35, -35, -35, -36, -36, -36, -37, -36, -35, -34, -33, -31,
-29, -27, -25, -24, -21, -20, -19, -19, -18, -18, -19, -19, -20, -21, -21, -22,
-22, -23, -22, -23, -22, -21, -20, -20, -19, -20, -18, -19, -18, -18, -19, -18,
-19, -21, -22, -23, -23, -23, -24, -24, -25, -24, -24, -24, -23, -23, -22, -22,
-20, -20, -19, -19, -20, -20, -19, -19, -19, -19, -20, -20, -19, -19, -19, -18,
-18, -17, -16, -15, -13, -13, -12, -11, -10, -10, -9, -8, -9, -8, -8, -8, -7,
-7, -7, -7, -6, -7, -5, -5, -3, -4, -3, -2, -2, -2, -1, -1, 0, -1, -1, -1, -1,
-1, -1, -1, -1, 0, -1, -1, 0, 0, 0, };