#define DATA_LENGTH 512
#define DATA AKWF_0035

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 7, 10, 12, 15, 17, 19, 22,
24, 26, 28, 31, 33, 35, 37, 40, 41, 44, 46, 48, 49, 52, 54, 56, 57, 59, 61, 62,
65, 66, 68, 69, 71, 72, 74, 75, 77, 78, 80, 81, 82, 82, 84, 85, 86, 88, 88, 89,
91, 92, 92, 93, 94, 94, 96, 96, 97, 98, 98, 99, 98, 99, 100, 100, 101, 101, 102,
102, 103, 103, 104, 104, 104, 105, 105, 106, 106, 106, 106, 107, 107, 108, 107,
107, 108, 108, 108, 109, 109, 109, 109, 109, 109, 109, 110, 110, 110, 110, 110,
111, 111, 112, 112, 112, 113, 112, 112, 113, 114, 113, 114, 114, 115, 116, 115,
115, 115, 117, 116, 116, 117, 117, 117, 118, 118, 118, 118, 118, 118, 118, 118,
119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 117,
117, 117, 117, 116, 115, 115, 115, 114, 112, 112, 112, 111, 110, 109, 108, 107,
106, 105, 104, 103, 101, 101, 99, 98, 96, 96, 95, 93, 91, 90, 88, 87, 86, 84,
83, 81, 80, 77, 77, 74, 73, 71, 70, 69, 66, 65, 63, 62, 60, 57, 57, 55, 53, 51,
50, 48, 48, 45, 44, 43, 41, 40, 38, 37, 35, 35, 33, 32, 30, 30, 28, 26, 25, 24,
22, 21, 20, 18, 17, 16, 15, 14, 14, 12, 11, 10, 9, 9, 8, 6, 5, 5, 4, 3, 2, 1, 1,
0, -1, -1, -1, -3, -3, -4, -5, -5, -7, -7, -8, -8, -8, -9, -9, -10, -10, -11,
-12, -12, -13, -14, -14, -15, -14, -16, -15, -17, -17, -17, -18, -18, -19, -21,
-21, -21, -22, -23, -24, -25, -25, -25, -27, -27, -29, -30, -31, -32, -33, -33,
-35, -35, -37, -37, -38, -39, -40, -41, -43, -44, -45, -46, -46, -48, -50, -50,
-52, -53, -53, -55, -57, -59, -59, -61, -63, -63, -64, -65, -66, -69, -70, -70,
-71, -72, -74, -75, -76, -77, -79, -81, -81, -83, -84, -83, -86, -87, -88, -89,
-90, -91, -92, -94, -95, -96, -97, -98, -100, -101, -103, -104, -105, -106,
-106, -107, -108, -109, -108, -109, -109, -110, -110, -111, -112, -111, -112,
-112, -112, -111, -111, -112, -112, -112, -112, -111, -112, -111, -112, -112,
-112, -112, -112, -113, -112, -113, -113, -113, -113, -112, -112, -113, -114,
-115, -114, -114, -114, -114, -115, -114, -114, -115, -116, -115, -116, -115,
-116, -116, -116, -116, -115, -115, -115, -115, -115, -115, -115, -115, -115,
-115, -115, -114, -114, -114, -114, -114, -113, -113, -112, -112, -112, -112,
-111, -111, -111, -110, -110, -109, -109, -108, -108, -107, -106, -106, -106,
-105, -104, -104, -103, -102, -101, -100, -99, -98, -97, -96, -95, -94, -92,
-91, -90, -90, -88, -86, -86, -84, -83, -81, -80, -78, -77, -76, -74, -74, -72,
-70, -69, -68, -65, -63, -62, -59, -58, -55, -54, -52, -49, -47, -45, -42, -40,
-38, -36, -33, -31, -28, -26, -24, -21, -19, -17, -14, -12, -9, -7, -5, -1, };