#define DATA_LENGTH 512
#define DATA AKWF_0098

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 7, 9, 10, 12, 13, 16, 17, 18,
21, 22, 24, 25, 27, 28, 31, 31, 33, 35, 35, 38, 39, 40, 41, 42, 44, 46, 47, 48,
49, 51, 53, 54, 55, 56, 58, 59, 60, 62, 63, 64, 65, 66, 67, 69, 69, 70, 71, 73,
74, 74, 76, 77, 77, 78, 80, 80, 81, 82, 83, 83, 85, 86, 87, 88, 88, 89, 90, 90,
91, 91, 93, 93, 94, 94, 96, 96, 97, 97, 98, 99, 99, 100, 100, 101, 102, 102,
102, 104, 104, 105, 104, 105, 106, 106, 106, 107, 107, 107, 108, 108, 108, 109,
110, 110, 110, 110, 111, 111, 112, 111, 112, 112, 112, 113, 113, 113, 114, 114,
114, 115, 114, 115, 114, 115, 116, 116, 116, 116, 116, 117, 116, 117, 116, 118,
118, 118, 118, 118, 118, 118, 118, 118, 119, 119, 118, 118, 118, 119, 119, 119,
118, 120, 119, 119, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119,
118, 118, 119, 118, 119, 119, 119, 118, 118, 119, 118, 119, 119, 119, 118, 118,
118, 118, 118, 118, 119, 118, 118, 118, 118, 117, 117, 117, 117, 117, 116, 117,
117, 117, 117, 117, 116, 117, 116, 116, 116, 116, 116, 115, 115, 115, 115, 115,
115, 115, 115, 114, 115, 113, 114, 113, 114, 113, 114, 113, 113, 113, 112, 112,
112, 112, 112, 111, 111, 110, 108, 107, 106, 104, 102, 100, 96, 93, 91, 86, 82,
77, 72, 67, 63, 58, 52, 46, 40, 34, 29, 22, 17, 11, 5, -3, -9, -14, -20, -25,
-31, -35, -40, -45, -48, -52, -56, -60, -63, -66, -69, -72, -76, -79, -80, -83,
-85, -88, -89, -90, -92, -95, -96, -97, -99, -99, -101, -102, -103, -104, -106,
-106, -107, -108, -109, -109, -110, -110, -111, -112, -112, -112, -114, -113,
-113, -114, -115, -115, -115, -115, -116, -115, -115, -117, -117, -116, -117,
-118, -117, -117, -117, -118, -119, -117, -117, -119, -118, -118, -118, -118,
-119, -118, -119, -119, -119, -118, -120, -119, -119, -118, -119, -119, -118,
-119, -119, -119, -119, -119, -118, -119, -118, -118, -119, -119, -119, -118,
-118, -118, -118, -119, -118, -118, -117, -117, -118, -117, -117, -117, -117,
-116, -118, -117, -116, -116, -116, -116, -116, -115, -116, -116, -115, -114,
-113, -114, -114, -114, -113, -113, -113, -112, -112, -112, -111, -111, -111,
-110, -110, -110, -109, -110, -108, -109, -107, -108, -108, -107, -106, -106,
-105, -104, -105, -104, -103, -102, -102, -101, -101, -101, -101, -100, -99,
-98, -98, -97, -97, -96, -95, -94, -93, -93, -92, -91, -90, -90, -89, -89, -88,
-87, -87, -85, -84, -84, -82, -81, -81, -80, -78, -78, -77, -76, -75, -74, -73,
-71, -71, -69, -68, -66, -66, -65, -64, -63, -61, -61, -58, -57, -56, -55, -54,
-52, -50, -50, -48, -47, -45, -45, -43, -42, -40, -39, -37, -35, -35, -32, -31,
-30, -28, -27, -25, -24, -21, -20, -19, -16, -15, -14, -12, -9, -9, -7, -5, -3,
0, };