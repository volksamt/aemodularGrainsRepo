#define DATA_LENGTH 512
#define DATA AKWF_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 10, 13, 15, 17, 19, 22, 23, 25,
27, 29, 31, 32, 34, 35, 36, 39, 40, 42, 43, 44, 45, 47, 49, 50, 51, 51, 54, 55,
56, 57, 57, 59, 61, 61, 62, 64, 64, 65, 66, 66, 68, 67, 69, 70, 71, 71, 72, 72,
73, 73, 74, 75, 75, 76, 76, 76, 76, 77, 78, 77, 77, 77, 81, 79, 79, 78, 79, 79,
79, 80, 80, 81, 82, 81, 82, 81, 82, 82, 82, 83, 83, 83, 83, 83, 83, 84, 84, 84,
84, 84, 85, 85, 85, 85, 85, 85, 86, 86, 86, 86, 87, 87, 88, 87, 87, 89, 88, 89,
89, 89, 89, 89, 90, 90, 90, 91, 91, 91, 91, 92, 92, 92, 92, 92, 94, 94, 94, 94,
94, 94, 95, 95, 96, 96, 96, 96, 96, 96, 97, 98, 98, 98, 99, 98, 99, 99, 100,
100, 100, 100, 100, 100, 101, 102, 101, 102, 103, 102, 102, 104, 104, 104, 104,
104, 104, 105, 105, 104, 104, 105, 105, 105, 105, 105, 104, 105, 105, 105, 105,
105, 105, 105, 105, 104, 104, 103, 103, 103, 102, 101, 101, 103, 102, 101, 99,
99, 98, 98, 97, 96, 94, 95, 89, 80, 87, 89, 89, 88, 85, 84, 83, 81, 78, 78, 77,
75, 74, 72, 71, 69, 68, 67, 65, 64, 63, 61, 59, 58, 57, 54, 52, 50, 50, 47, 46,
44, 43, 40, 37, 37, 34, 31, 30, 27, 26, 24, 22, 19, 17, 15, 13, 10, 7, 3, -4,
-8, -10, -13, -15, -18, -19, -22, -23, -25, -28, -29, -31, -33, -34, -36, -38,
-38, -40, -41, -43, -44, -46, -47, -48, -49, -51, -52, -54, -55, -55, -56, -58,
-60, -61, -62, -63, -63, -65, -66, -66, -66, -67, -68, -69, -70, -71, -72, -72,
-72, -73, -73, -74, -74, -75, -75, -76, -76, -76, -77, -78, -77, -77, -78, -80,
-79, -79, -79, -80, -80, -80, -81, -81, -81, -81, -81, -82, -82, -82, -82, -83,
-83, -83, -83, -83, -84, -84, -83, -84, -84, -84, -84, -85, -85, -85, -85, -85,
-86, -87, -87, -87, -87, -87, -87, -88, -88, -88, -89, -89, -89, -90, -90, -90,
-90, -90, -90, -91, -91, -91, -92, -92, -93, -92, -93, -93, -93, -94, -94, -94,
-95, -95, -95, -96, -95, -96, -96, -97, -97, -97, -98, -98, -98, -99, -99, -100,
-99, -100, -100, -100, -100, -101, -101, -101, -101, -101, -102, -102, -103,
-103, -103, -104, -103, -104, -105, -104, -105, -105, -106, -104, -105, -104,
-105, -105, -105, -105, -104, -105, -105, -105, -104, -105, -104, -104, -104,
-104, -103, -104, -104, -104, -102, -101, -100, -102, -101, -101, -100, -100,
-99, -98, -96, -97, -95, -96, -90, -80, -87, -89, -88, -88, -85, -84, -82, -80,
-79, -78, -76, -75, -74, -73, -71, -71, -68, -67, -66, -64, -62, -61, -60, -58,
-57, -54, -52, -51, -50, -48, -46, -44, -43, -41, -39, -36, -34, -32, -30, -28,
-26, -24, -23, -20, -17, -15, -13, -10, -7, -3, 2, };