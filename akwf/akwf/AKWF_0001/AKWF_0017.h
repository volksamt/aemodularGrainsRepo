#define DATA_LENGTH 512
#define DATA AKWF_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, -2, -4, -6, -7, -9, -10, -12, -14,
-15, -15, -17, -19, -19, -21, -21, -22, -24, -24, -24, -26, -26, -27, -28, -28,
-28, -29, -30, -30, -31, -30, -31, -32, -33, -33, -34, -34, -34, -34, -36, -36,
-37, -38, -38, -39, -39, -40, -41, -42, -42, -43, -44, -45, -46, -46, -48, -49,
-50, -50, -51, -53, -54, -55, -56, -57, -58, -59, -61, -61, -62, -64, -64, -66,
-68, -68, -69, -70, -71, -72, -74, -75, -76, -77, -78, -78, -80, -80, -82, -83,
-83, -85, -86, -86, -88, -89, -89, -90, -91, -92, -92, -93, -94, -94, -95, -96,
-96, -97, -97, -98, -98, -99, -99, -99, -100, -99, -99, -99, -100, -100, -101,
-100, -100, -101, -101, -101, -101, -101, -101, -101, -100, -100, -100, -100,
-100, -100, -99, -99, -99, -99, -98, -98, -97, -97, -96, -97, -96, -94, -95,
-94, -93, -94, -93, -92, -92, -91, -92, -90, -89, -89, -90, -88, -88, -88, -87,
-86, -86, -86, -86, -85, -85, -84, -84, -84, -84, -84, -83, -83, -83, -83, -82,
-82, -81, -81, -83, -82, -82, -82, -82, -83, -82, -83, -84, -83, -84, -83, -84,
-85, -85, -85, -85, -86, -86, -86, -86, -86, -86, -86, -85, -85, -85, -84, -84,
-83, -83, -81, -81, -80, -79, -78, -76, -74, -74, -71, -69, -69, -67, -65, -63,
-61, -58, -56, -54, -52, -50, -47, -44, -43, -40, -38, -35, -33, -31, -29, -27,
-25, -23, -21, -19, -18, -17, -16, -15, -14, -12, -11, -9, -8, -7, -5, -4, -2,
-1, 2, 2, 4, 6, 7, 9, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 22, 22, 24, 25,
25, 25, 28, 28, 28, 29, 29, 30, 31, 32, 32, 34, 34, 34, 35, 35, 37, 38, 38, 39,
39, 40, 41, 42, 43, 44, 45, 46, 46, 47, 48, 50, 50, 51, 53, 53, 54, 55, 57, 57,
58, 59, 60, 61, 62, 65, 65, 67, 67, 68, 70, 70, 72, 73, 74, 75, 76, 77, 78, 79,
80, 81, 82, 83, 84, 85, 86, 86, 88, 89, 90, 90, 90, 92, 92, 93, 93, 94, 95, 95,
96, 97, 97, 97, 98, 98, 99, 99, 99, 99, 100, 100, 100, 100, 100, 101, 100, 100,
100, 101, 101, 101, 100, 101, 100, 100, 100, 100, 100, 99, 99, 98, 98, 98, 98,
97, 96, 96, 97, 95, 95, 95, 94, 93, 93, 93, 93, 92, 91, 92, 90, 90, 90, 88, 88,
87, 87, 86, 86, 85, 85, 84, 83, 83, 83, 82, 82, 82, 81, 80, 79, 79, 78, 78, 77,
77, 77, 76, 75, 75, 75, 74, 74, 74, 75, 80, 84, 82, 81, 81, 81, 82, 84, 84, 85,
86, 86, 86, 87, 86, 86, 87, 87, 86, 86, 85, 85, 84, 84, 82, 81, 80, 80, 78, 76,
75, 73, 72, 69, 67, 64, 63, 61, 58, 55, 52, 50, 47, 43, 41, 38, 36, 33, 30, 27,
25, 22, 20, 18, 15, 14, 14, 12, 10, 8, 7, 5, 3, 2, 1, };