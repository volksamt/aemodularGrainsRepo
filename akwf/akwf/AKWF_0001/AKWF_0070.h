#define DATA_LENGTH 512
#define DATA AKWF_0070

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 3, 4, 6, 7, 8, 9, 11, 12, 14,
15, 15, 17, 19, 20, 21, 23, 25, 26, 28, 29, 31, 33, 35, 36, 38, 39, 41, 42, 44,
46, 46, 49, 49, 51, 52, 53, 55, 56, 57, 58, 59, 60, 61, 62, 63, 64, 65, 66, 67,
67, 69, 69, 69, 71, 72, 73, 73, 73, 74, 74, 74, 76, 76, 77, 77, 77, 77, 78, 78,
78, 78, 78, 78, 78, 78, 78, 77, 77, 77, 77, 76, 75, 75, 74, 75, 74, 73, 73, 72,
72, 71, 71, 70, 69, 68, 67, 67, 65, 65, 64, 63, 62, 60, 60, 59, 58, 57, 55, 56,
53, 53, 52, 51, 50, 50, 49, 48, 46, 47, 45, 44, 44, 44, 42, 41, 41, 39, 39, 39,
37, 37, 37, 36, 35, 35, 34, 34, 33, 33, 32, 31, 30, 30, 30, 29, 29, 29, 27, 27,
27, 27, 26, 25, 25, 25, 24, 24, 24, 22, 22, 22, 22, 21, 20, 21, 20, 19, 19, 19,
19, 18, 17, 18, 17, 17, 17, 16, 16, 16, 16, 15, 15, 14, 14, 15, 14, 14, 13, 14,
13, 13, 13, 12, 12, 12, 13, 12, 11, 11, 10, 11, 11, 10, 9, 10, 10, 10, 10, 8, 9,
9, 8, 8, 7, 8, 8, 8, 7, 7, 6, 5, 4, 3, 3, 1, 2, 1, 0, -1, -3, -4, -4, -6, -6,
-7, -9, -11, -11, -12, -15, -16, -17, -18, -20, -22, -22, -24, -26, -27, -29,
-31, -33, -34, -36, -37, -39, -42, -42, -45, -47, -48, -50, -52, -54, -57, -58,
-60, -62, -64, -66, -68, -69, -72, -73, -74, -76, -77, -79, -80, -82, -83, -84,
-86, -87, -88, -89, -91, -91, -93, -94, -94, -97, -97, -98, -99, -100, -100,
-101, -102, -103, -104, -105, -105, -106, -107, -107, -108, -109, -110, -110,
-110, -111, -111, -112, -112, -114, -114, -114, -113, -115, -114, -115, -115,
-116, -116, -115, -117, -116, -116, -115, -115, -116, -115, -115, -115, -115,
-115, -113, -114, -114, -113, -112, -111, -111, -111, -110, -109, -109, -108,
-107, -107, -106, -105, -104, -104, -103, -102, -100, -100, -98, -98, -96, -95,
-95, -94, -93, -92, -90, -89, -88, -87, -86, -85, -84, -82, -81, -80, -79, -77,
-76, -75, -73, -72, -71, -69, -69, -66, -65, -65, -63, -62, -61, -61, -59, -58,
-57, -56, -54, -54, -53, -52, -52, -50, -49, -49, -47, -47, -46, -45, -45, -44,
-43, -41, -41, -40, -41, -39, -38, -38, -37, -37, -36, -35, -34, -34, -34, -33,
-32, -32, -31, -31, -31, -30, -30, -29, -29, -27, -27, -26, -26, -25, -25, -25,
-25, -24, -24, -24, -23, -22, -21, -22, -20, -21, -20, -21, -20, -19, -19, -18,
-18, -18, -17, -18, -17, -17, -17, -16, -16, -16, -16, -15, -15, -15, -15, -13,
-14, -14, -13, -13, -12, -12, -12, -12, -12, -12, -12, -11, -11, -11, -11, -10,
-10, -10, -9, -9, -9, -9, -7, -7, -7, -7, -5, -6, -4, -4, -3, -2, -1, 0, };