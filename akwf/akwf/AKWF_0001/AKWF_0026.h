#define DATA_LENGTH 512
#define DATA AKWF_0026

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 7, 8, 9, 11, 12, 14, 15,
16, 16, 17, 17, 19, 19, 20, 21, 21, 21, 22, 23, 23, 22, 23, 23, 23, 23, 24, 23,
23, 23, 23, 22, 23, 23, 22, 22, 22, 22, 21, 21, 21, 20, 20, 20, 19, 19, 18, 18,
17, 17, 17, 16, 16, 15, 14, 15, 13, 12, 13, 12, 12, 12, 11, 10, 10, 9, 9, 8, 8,
8, 7, 7, 6, 5, 5, 6, 4, 4, 4, 4, 3, 3, 2, 3, 1, 2, 1, 1, 1, 0, 1, 1, 0, 0, -1,
-1, -1, -1, -1, -2, -2, -1, -2, -2, -2, -1, -2, -3, -3, -3, -2, -3, -2, -2, -2,
-3, -2, -3, -2, -3, -3, -2, -3, -3, -3, -3, -3, -3, -2, -3, -2, -3, 7, 21, 24,
24, 28, 32, 38, 44, 49, 51, 54, 56, 57, 59, 59, 59, 61, 62, 64, 65, 66, 67, 69,
71, 72, 74, 76, 78, 79, 82, 83, 85, 87, 89, 90, 91, 92, 95, 96, 97, 99, 100,
102, 103, 104, 105, 106, 106, 108, 108, 110, 110, 111, 111, 112, 112, 113, 113,
114, 114, 114, 115, 115, 115, 115, 116, 115, 115, 115, 115, 116, 115, 114, 114,
115, 114, 114, 113, 114, 114, 113, 113, 112, 113, 111, 111, 111, 111, 109, 96,
84, 83, 80, 76, 70, 63, 59, 55, 51, 49, 46, 44, 44, 41, 41, 40, 38, 36, 34, 32,
31, 28, 27, 25, 23, 20, 18, 16, 14, 12, 9, 8, 6, 5, 2, 1, -1, -2, -4, -6, -8,
-9, -11, -11, -12, -13, -14, -16, -17, -17, -18, -19, -20, -21, -21, -22, -22,
-23, -23, -23, -24, -24, -24, -25, -25, -24, -24, -24, -25, -24, -25, -25, -24,
-24, -24, -23, -23, -22, -22, -22, -21, -21, -21, -20, -20, -20, -19, -19, -18,
-17, -17, -17, -16, -16, -14, -14, -14, -13, -12, -13, -12, -11, -11, -11, -9,
-10, -10, -8, -9, -7, -7, -7, -6, -6, -5, -6, -5, -4, -3, -4, -3, -3, -2, -2,
-3, -1, -1, -1, -1, 0, 0, 0, 0, 0, 0, 1, 1, 2, 1, 2, 2, 2, 2, 3, 2, 2, 3, 3, 3,
3, 2, 3, 3, 3, 3, 4, 3, 3, 3, 3, 2, 3, 3, 2, 3, 3, 2, 3, 2, 3, 2, 3, 2, 3, -1,
-16, -24, -24, -26, -30, -36, -41, -47, -50, -53, -54, -56, -58, -59, -60, -61,
-62, -63, -64, -66, -67, -69, -70, -72, -73, -76, -77, -79, -81, -83, -84, -86,
-88, -89, -91, -92, -94, -96, -97, -98, -100, -101, -101, -103, -104, -105,
-106, -108, -108, -109, -110, -111, -110, -111, -113, -113, -113, -113, -114,
-114, -115, -115, -115, -114, -115, -115, -116, -115, -114, -115, -116, -107,
-93, -88, -89, -85, -80, -73, -68, -63, -60, -56, -55, -53, -51, -50, -49, -48,
-47, -45, -43, -42, -40, -37, -35, -33, -31, -28, -27, -25, -22, -20, -18, -15,
-13, -12, -9, -8, -6, -4, -2, 0, };