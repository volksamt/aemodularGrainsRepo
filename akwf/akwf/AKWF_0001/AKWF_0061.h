#define DATA_LENGTH 512
#define DATA AKWF_0061

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 10, 13, 18, 20, 24, 28, 29, 33, 35,
38, 40, 42, 45, 47, 49, 52, 53, 56, 59, 60, 62, 64, 66, 67, 70, 71, 72, 75, 76,
77, 78, 81, 82, 82, 84, 85, 86, 88, 89, 90, 91, 92, 93, 93, 94, 95, 95, 96, 97,
98, 98, 99, 99, 100, 101, 101, 100, 101, 101, 101, 101, 101, 100, 101, 101, 100,
101, 100, 101, 101, 101, 101, 101, 100, 101, 101, 101, 100, 101, 101, 100, 101,
100, 102, 100, 101, 101, 101, 101, 101, 101, 102, 100, 101, 101, 101, 101, 101,
101, 101, 101, 100, 100, 101, 101, 101, 101, 100, 101, 100, 101, 102, 101, 100,
101, 100, 101, 101, 100, 101, 101, 101, 101, 100, 101, 101, 101, 101, 101, 101,
101, 101, 101, 100, 100, 101, 101, 101, 101, 101, 100, 101, 101, 100, 102, 101,
101, 101, 101, 100, 101, 101, 102, 101, 101, 100, 101, 100, 101, 101, 101, 101,
101, 100, 101, 101, 101, 101, 101, 100, 101, 101, 100, 101, 101, 100, 101, 100,
100, 101, 101, 101, 101, 98, 98, 96, 94, 92, 90, 89, 87, 87, 85, 83, 82, 81, 79,
77, 76, 76, 75, 73, 71, 70, 70, 68, 67, 66, 65, 64, 63, 61, 61, 60, 59, 57, 57,
55, 55, 54, 54, 52, 51, 50, 50, 49, 49, 48, 48, 47, 45, 45, 45, 44, 43, 43, 42,
42, 42, 41, 41, 40, 40, 39, 39, 39, 38, 37, 37, 36, 36, 36, 34, 34, 35, 34, 33,
33, 33, 32, 31, 31, 30, 29, 29, 28, 28, 27, 26, 25, 24, 23, 23, 21, 20, 19, 17,
17, 14, 13, 12, 10, 8, 4, 1, -5, -7, -9, -11, -14, -16, -19, -21, -23, -25, -27,
-30, -32, -33, -35, -38, -40, -42, -44, -46, -49, -51, -53, -55, -58, -60, -62,
-65, -67, -68, -71, -73, -75, -77, -80, -82, -84, -85, -88, -90, -93, -95, -97,
-99, -101, -101, -101, -101, -100, -100, -101, -102, -101, -101, -100, -101,
-101, -101, -102, -101, -101, -101, -101, -101, -101, -101, -101, -101, -101,
-100, -100, -101, -100, -101, -101, -101, -101, -100, -101, -101, -101, -100,
-101, -100, -100, -101, -102, -101, -102, -101, -100, -101, -101, -100, -101,
-100, -101, -101, -101, -101, -100, -101, -101, -101, -100, -101, -101, -101,
-100, -101, -101, -101, -100, -101, -101, -101, -101, -100, -101, -101, -101,
-101, -101, -101, -101, -102, -101, -101, -101, -102, -101, -101, -101, -101,
-100, -101, -101, -100, -100, -101, -101, -101, -100, -101, -101, -100, -101,
-101, -101, -101, -101, -100, -100, -100, -100, -101, -100, -101, -101, -102,
-101, -101, -101, -100, -102, -101, -100, -101, -101, -101, -101, -101, -100,
-101, -101, -100, -101, -101, -101, -101, -100, -100, -101, -101, -100, -97,
-96, -94, -94, -92, -89, -88, -86, -84, -82, -81, -80, -78, -76, -74, -71, -70,
-68, -66, -63, -62, -59, -57, -54, -52, -50, -48, -44, -43, -39, -37, -35, -32,
-29, -25, -22, -19, -16, -11, -8, -2, };