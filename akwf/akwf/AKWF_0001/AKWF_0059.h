#define DATA_LENGTH 512
#define DATA AKWF_0059

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 7, 9, 12, 14, 17, 18, 22, 24,
27, 29, 32, 35, 38, 40, 43, 45, 48, 51, 54, 57, 61, 63, 65, 69, 72, 75, 77, 80,
83, 86, 88, 91, 94, 96, 99, 101, 103, 105, 107, 109, 110, 112, 113, 114, 115,
116, 116, 117, 118, 119, 119, 119, 119, 118, 119, 118, 117, 117, 116, 116, 114,
112, 111, 110, 108, 107, 106, 105, 103, 101, 100, 97, 95, 93, 90, 89, 88, 84,
83, 82, 80, 77, 76, 73, 71, 70, 68, 66, 64, 62, 60, 59, 56, 55, 53, 52, 50, 48,
46, 44, 42, 41, 38, 37, 34, 33, 30, 27, 26, 23, 22, 19, 16, 14, 12, 9, 7, 4, 0,
-1, -4, -7, -9, -13, -15, -19, -22, -25, -27, -31, -35, -37, -41, -44, -47, -50,
-53, -56, -59, -61, -65, -67, -70, -74, -75, -78, -80, -83, -85, -87, -90, -92,
-93, -95, -96, -98, -100, -100, -103, -103, -105, -105, -106, -106, -107, -108,
-107, -108, -108, -108, -108, -108, -107, -107, -107, -105, -105, -104, -103,
-102, -101, -100, -99, -98, -96, -95, -93, -92, -90, -88, -87, -85, -83, -82,
-80, -78, -76, -75, -73, -71, -69, -67, -65, -63, -61, -59, -57, -55, -53, -51,
-49, -47, -45, -42, -41, -38, -37, -35, -34, -32, -29, -28, -26, -25, -23, -21,
-19, -18, -16, -14, -13, -12, -9, -8, -7, -5, -3, -1, 0, 1, 1, 4, 4, 6, 7, 8,
11, 11, 12, 15, 15, 16, 18, 19, 21, 21, 23, 24, 25, 27, 28, 29, 30, 32, 32, 34,
35, 36, 37, 38, 39, 40, 41, 42, 43, 44, 45, 47, 47, 49, 51, 52, 53, 54, 55, 57,
58, 60, 61, 63, 63, 66, 67, 69, 70, 73, 74, 76, 77, 79, 81, 82, 84, 86, 88, 89,
91, 91, 93, 94, 95, 97, 97, 98, 99, 100, 101, 100, 100, 101, 100, 101, 100, 100,
100, 99, 98, 97, 97, 95, 94, 93, 91, 90, 88, 87, 85, 82, 80, 79, 76, 74, 73, 70,
67, 65, 63, 60, 58, 55, 53, 49, 47, 45, 42, 40, 37, 36, 34, 31, 28, 27, 25, 23,
21, 18, 17, 15, 13, 11, 11, 9, 7, 6, 4, 3, 1, 0, -1, -3, -4, -5, -7, -7, -9,
-11, -12, -13, -14, -17, -18, -20, -22, -23, -24, -26, -27, -29, -31, -33, -35,
-38, -39, -42, -44, -45, -47, -49, -52, -54, -55, -57, -60, -63, -64, -67, -69,
-72, -74, -76, -77, -80, -82, -84, -86, -87, -89, -91, -92, -94, -96, -97, -98,
-100, -102, -103, -104, -105, -106, -108, -108, -109, -110, -110, -110, -110,
-110, -111, -110, -110, -110, -110, -109, -109, -108, -107, -106, -105, -105,
-103, -102, -101, -99, -98, -96, -95, -93, -92, -90, -88, -86, -85, -82, -80,
-78, -75, -73, -71, -69, -67, -65, -63, -61, -58, -55, -53, -50, -48, -46, -44,
-41, -39, -37, -35, -33, -30, -28, -26, -23, -20, -20, -16, -14, -13, -10, -8,
-5, -3, -1, };