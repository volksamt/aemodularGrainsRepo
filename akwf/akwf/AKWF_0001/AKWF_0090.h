#define DATA_LENGTH 512
#define DATA AKWF_0090

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 8, 16, 22, 29, 35, 42, 49, 54, 60,
67, 71, 75, 81, 86, 89, 93, 97, 101, 103, 106, 109, 111, 113, 115, 115, 117,
118, 118, 119, 119, 119, 118, 119, 119, 118, 117, 116, 115, 114, 113, 111, 110,
108, 106, 106, 103, 102, 100, 99, 97, 96, 94, 93, 91, 89, 87, 86, 85, 84, 81,
80, 79, 77, 76, 75, 74, 73, 72, 71, 70, 68, 68, 67, 67, 65, 64, 64, 63, 63, 62,
61, 61, 60, 60, 60, 59, 59, 59, 58, 57, 57, 58, 56, 56, 56, 56, 56, 55, 54, 55,
54, 55, 55, 53, 53, 54, 53, 53, 53, 52, 52, 51, 51, 51, 50, 51, 50, 50, 50, 49,
49, 48, 49, 48, 47, 47, 46, 47, 45, 45, 46, 45, 45, 43, 44, 43, 43, 42, 42, 41,
42, 40, 40, 39, 40, 40, 38, 38, 37, 37, 36, 36, 35, 36, 34, 35, 34, 33, 33, 33,
31, 32, 31, 31, 30, 29, 30, 29, 28, 29, 28, 27, 27, 27, 25, 26, 26, 25, 25, 25,
24, 24, 23, 22, 22, 21, 22, 21, 20, 20, 20, 20, 18, 19, 18, 18, 18, 17, 16, 16,
15, 15, 16, 15, 15, 14, 14, 13, 13, 13, 12, 11, 11, 11, 10, 11, 9, 9, 9, 8, 9,
8, 7, 7, 6, 6, 6, 6, 5, 5, 5, 4, 3, 3, 4, 3, 3, 2, 1, 0, 1, 0, 0, 0, -1, -1, -1,
-2, -3, -3, -3, -4, -5, -4, -5, -6, -6, -6, -7, -7, -7, -8, -8, -9, -8, -9, -9,
-10, -10, -10, -11, -11, -12, -12, -12, -13, -12, -13, -13, -14, -15, -15, -15,
-16, -16, -16, -16, -17, -18, -18, -18, -19, -19, -19, -20, -20, -20, -21, -21,
-21, -23, -22, -22, -23, -23, -23, -25, -25, -25, -25, -25, -26, -26, -26, -27,
-27, -27, -29, -28, -29, -29, -29, -29, -29, -30, -31, -31, -31, -31, -32, -32,
-32, -33, -33, -34, -34, -34, -35, -36, -35, -36, -36, -37, -37, -37, -38, -38,
-38, -39, -39, -39, -39, -40, -41, -40, -41, -41, -41, -42, -43, -43, -43, -44,
-44, -44, -44, -44, -45, -45, -45, -46, -46, -47, -48, -47, -48, -49, -48, -49,
-49, -49, -50, -50, -51, -50, -50, -50, -52, -51, -51, -52, -53, -53, -53, -54,
-54, -54, -55, -55, -55, -56, -56, -56, -57, -57, -57, -58, -58, -59, -59, -59,
-59, -59, -60, -60, -61, -61, -62, -61, -62, -61, -62, -63, -63, -63, -64, -64,
-64, -65, -65, -66, -66, -65, -66, -67, -66, -67, -67, -67, -68, -69, -68, -69,
-69, -69, -70, -70, -70, -71, -71, -70, -72, -72, -73, -72, -73, -73, -74, -73,
-74, -74, -75, -75, -75, -76, -76, -76, -77, -77, -78, -78, -78, -78, -79, -79,
-79, -80, -80, -80, -81, -80, -82, -82, -81, -82, -82, -82, -84, -83, -83, -84,
-84, -84, -84, -84, -84, -82, -80, -76, -73, -68, -63, -58, -52, -46, -39, -33,
-26, -18, -11, -5, };