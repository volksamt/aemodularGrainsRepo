#define DATA_LENGTH 512
#define DATA AKWF_0055

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 3, 4, 4, 6, 7, 8, 9, 9, 9,
10, 12, 12, 12, 13, 15, 15, 17, 16, 17, 19, 19, 19, 21, 21, 22, 23, 24, 24, 24,
25, 26, 27, 27, 28, 28, 29, 29, 30, 32, 33, 33, 33, 34, 35, 35, 36, 37, 37, 38,
38, 40, 40, 40, 42, 42, 43, 43, 44, 45, 45, 45, 46, 47, 47, 48, 49, 48, 50, 50,
50, 50, 52, 52, 53, 53, 54, 55, 55, 56, 56, 57, 57, 58, 58, 59, 59, 60, 61, 62,
62, 62, 63, 63, 64, 64, 65, 65, 66, 66, 67, 68, 69, 69, 69, 70, 70, 70, 70, 71,
72, 72, 72, 74, 74, 74, 75, 76, 76, 76, 77, 77, 78, 78, 79, 79, 79, 80, 80, 81,
82, 82, 82, 83, 83, 84, 84, 85, 85, 86, 86, 86, 86, 88, 88, 89, 90, 90, 89, 90,
91, 91, 92, 92, 93, 94, 93, 94, 95, 95, 95, 96, 96, 96, 98, 98, 98, 99, 100,
100, 100, 101, 101, 101, 101, 102, 102, 104, 103, 104, 105, 105, 105, 106, 107,
106, 106, 107, 108, 108, 108, 109, 109, 110, 109, 110, 110, 111, 112, 112, 112,
114, 113, 114, 114, 114, 115, 115, 116, 117, 117, 118, 118, 117, 118, 119, 119,
119, 120, 119, 119, 118, 118, 118, 117, 116, 114, 112, 111, 108, 106, 103, 100,
97, 94, 89, 85, 80, 74, 66, 60, 52, 43, 35, 27, 18, 11, 4, -2, -8, -14, -19,
-23, -29, -33, -38, -42, -45, -51, -55, -58, -61, -65, -67, -71, -73, -77, -79,
-81, -84, -86, -88, -90, -90, -93, -93, -95, -95, -96, -96, -98, -98, -98, -98,
-99, -98, -100, -99, -98, -98, -98, -98, -98, -96, -96, -96, -96, -95, -95, -95,
-94, -93, -92, -92, -92, -93, -91, -91, -91, -91, -91, -91, -90, -91, -91, -90,
-90, -90, -90, -91, -91, -91, -92, -91, -92, -93, -93, -93, -92, -93, -94, -95,
-95, -94, -95, -95, -96, -95, -96, -96, -96, -96, -97, -96, -97, -96, -96, -96,
-96, -95, -96, -96, -96, -95, -95, -95, -94, -94, -93, -93, -93, -92, -91, -91,
-92, -91, -89, -89, -89, -88, -87, -87, -87, -87, -86, -85, -85, -84, -84, -82,
-83, -81, -81, -81, -80, -79, -79, -78, -78, -77, -76, -77, -76, -75, -75, -74,
-74, -72, -73, -72, -72, -71, -71, -71, -70, -70, -69, -68, -68, -68, -68, -67,
-66, -66, -64, -64, -65, -64, -63, -63, -62, -62, -62, -62, -60, -61, -60, -59,
-59, -57, -57, -57, -57, -56, -56, -56, -55, -54, -54, -53, -53, -51, -51, -50,
-50, -50, -49, -48, -48, -48, -47, -46, -46, -45, -44, -44, -43, -43, -42, -41,
-41, -39, -38, -38, -38, -38, -36, -35, -35, -35, -34, -32, -33, -33, -31, -30,
-29, -28, -29, -28, -27, -26, -24, -25, -23, -22, -21, -20, -20, -18, -17, -15,
-14, -13, -12, -11, -10, -9, -8, -6, -6, -5, -5, -4, -3, -2, -1, 0, 0, };