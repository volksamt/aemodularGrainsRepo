#define DATA_LENGTH 512
#define DATA AKWF_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 4, 7, 9, 13, 16, 19, 24, 27,
31, 36, 40, 44, 48, 52, 56, 60, 63, 67, 71, 75, 78, 82, 85, 87, 90, 92, 95, 97,
100, 101, 104, 106, 107, 108, 110, 111, 111, 113, 113, 114, 115, 115, 116, 116,
117, 116, 117, 118, 118, 118, 119, 118, 118, 119, 119, 119, 118, 119, 119, 119,
119, 118, 119, 120, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120,
119, 120, 119, 120, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 120, 120, 119, 119, 119, 119,
119, 119, 119, 118, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 119, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119,
120, 120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 119, 119, 118, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119,
118, 118, 119, 118, 119, 119, 118, 119, 118, 119, 118, 119, 118, 117, 117, 117,
117, 116, 116, 115, 114, 113, 112, 111, 110, 109, 107, 106, 105, 104, 101, 100,
98, 96, 94, 92, 89, 88, 84, 83, 80, 77, 74, 72, 68, 66, 62, 60, 57, 53, 49, 47,
45, 40, 37, 35, 32, 28, 26, 23, 20, 18, 15, 14, 11, 9, 6, 5, 4, 1, 1, 0, 1, -1,
-2, -3, -5, -6, -9, -10, -12, -14, -18, -20, -21, -25, -26, -30, -32, -35, -37,
-41, -43, -46, -48, -50, -54, -56, -59, -61, -63, -67, -68, -70, -73, -74, -77,
-79, -81, -84, -84, -86, -88, -89, -91, -92, -94, -95, -96, -97, -98, -100,
-101, -102, -102, -103, -104, -105, -105, -106, -107, -108, -108, -109, -109,
-110, -111, -111, -111, -112, -111, -113, -112, -113, -114, -113, -114, -113,
-114, -114, -114, -115, -115, -115, -114, -115, -115, -115, -116, -116, -116,
-116, -115, -116, -116, -116, -116, -116, -116, -116, -115, -117, -116, -116,
-116, -116, -116, -116, -116, -116, -117, -116, -116, -116, -116, -116, -116,
-116, -116, -115, -115, -115, -115, -116, -114, -114, -115, -115, -115, -114,
-114, -115, -114, -115, -114, -114, -115, -115, -116, -117, -117, -118, -118,
-119, -119, -118, -119, -118, -118, -119, -119, -119, -119, -119, -119, -118,
-120, -119, -119, -119, -118, -120, -119, -118, -118, -118, -117, -116, -117,
-116, -116, -116, -116, -115, -115, -115, -115, -114, -115, -115, -116, -115,
-117, -116, -117, -117, -117, -118, -118, -118, -119, -119, -118, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -118, -119,
-120, -118, -119, -119, -119, -119, -119, -118, -118, -118, -117, -117, -118,
-116, -116, -115, -115, -113, -113, -113, -111, -110, -109, -106, -105, -104,
-102, -99, -97, -95, -93, -91, -87, -84, -82, -79, -74, -71, -68, -64, -60, -57,
-53, -49, -44, -41, -38, -34, -29, -25, -22, -18, -15, -11, -8, -7, -4, -2, -1,
};