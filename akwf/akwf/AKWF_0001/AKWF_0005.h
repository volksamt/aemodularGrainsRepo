#define DATA_LENGTH 512
#define DATA AKWF_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 2, 2, 1, 3, 3, 4, 6, 7, 8, 9,
11, 11, 13, 15, 16, 17, 19, 20, 22, 24, 25, 27, 27, 29, 32, 33, 35, 35, 37, 38,
40, 41, 44, 45, 45, 49, 50, 50, 52, 54, 55, 56, 59, 59, 60, 61, 63, 64, 65, 66,
67, 68, 70, 71, 72, 73, 74, 75, 76, 77, 78, 79, 79, 81, 82, 83, 83, 84, 86, 86,
89, 93, 96, 96, 96, 97, 96, 97, 98, 99, 99, 99, 100, 100, 101, 101, 100, 91, 79,
78, 81, 82, 82, 82, 82, 82, 82, 82, 81, 81, 80, 79, 78, 78, 77, 76, 76, 76, 75,
73, 72, 72, 70, 70, 69, 67, 67, 66, 66, 63, 63, 62, 61, 61, 60, 59, 57, 57, 57,
56, 55, 55, 55, 56, 55, 58, 65, 69, 67, 65, 64, 62, 63, 63, 62, 62, 62, 62, 62,
62, 62, 63, 62, 63, 63, 63, 63, 64, 64, 63, 64, 63, 64, 65, 64, 65, 64, 65, 66,
65, 65, 66, 66, 66, 66, 66, 65, 65, 66, 65, 65, 65, 65, 65, 64, 64, 64, 64, 63,
63, 62, 61, 61, 61, 61, 60, 58, 59, 58, 57, 57, 56, 56, 55, 54, 52, 52, 50, 50,
49, 48, 46, 45, 44, 44, 43, 41, 40, 39, 38, 36, 35, 34, 33, 31, 31, 29, 28, 26,
25, 23, 23, 21, 20, 18, 17, 16, 15, 14, 12, 12, 10, 9, 9, 7, 7, 6, 5, 4, 2, 3,
2, 1, 0, 0, 0, 0, -1, -1, -2, -3, -3, -4, -4, -6, -7, -8, -8, -9, -11, -11, -14,
-14, -15, -16, -17, -19, -20, -21, -24, -25, -27, -27, -29, -31, -31, -33, -35,
-36, -37, -39, -39, -41, -43, -44, -44, -46, -47, -49, -50, -51, -53, -54, -55,
-56, -57, -58, -59, -61, -61, -63, -64, -65, -66, -67, -68, -68, -69, -71, -71,
-72, -73, -74, -75, -75, -76, -78, -78, -79, -81, -82, -82, -78, -71, -68, -67,
-67, -68, -66, -67, -67, -67, -67, -67, -67, -66, -65, -67, -65, -65, -65, -64,
-64, -64, -63, -63, -62, -63, -62, -62, -61, -61, -60, -60, -60, -59, -59, -58,
-58, -57, -59, -58, -58, -58, -57, -58, -57, -58, -58, -58, -58, -59, -60, -63,
-69, -74, -73, -71, -71, -71, -72, -71, -72, -72, -72, -73, -74, -74, -74, -74,
-76, -76, -76, -76, -78, -78, -78, -79, -80, -80, -81, -81, -82, -82, -82, -82,
-83, -83, -83, -84, -84, -84, -84, -84, -84, -84, -84, -85, -84, -84, -84, -84,
-85, -85, -85, -84, -84, -83, -82, -82, -82, -82, -81, -80, -80, -80, -80, -79,
-78, -77, -76, -75, -75, -74, -73, -73, -71, -70, -69, -68, -67, -66, -65, -64,
-63, -61, -60, -58, -57, -56, -54, -52, -52, -49, -49, -46, -45, -43, -42, -40,
-39, -37, -35, -33, -31, -30, -28, -27, -24, -24, -22, -20, -18, -17, -16, -14,
-13, -12, -10, -9, -8, -6, -6, -4, -4, -2, -1, -2, -1, 0, };