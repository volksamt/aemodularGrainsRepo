#define DATA_LENGTH 512
#define DATA AKWF_0082

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 8, 9, 11, 14, 16, 17, 19,
21, 22, 24, 26, 27, 30, 31, 33, 35, 38, 39, 41, 43, 44, 46, 48, 50, 51, 53, 54,
55, 57, 58, 60, 61, 63, 63, 64, 67, 66, 68, 69, 70, 71, 71, 72, 73, 73, 74, 75,
75, 76, 77, 76, 78, 78, 78, 78, 79, 79, 80, 80, 79, 81, 80, 81, 82, 82, 82, 81,
82, 82, 82, 83, 82, 83, 83, 84, 83, 83, 83, 83, 84, 84, 83, 83, 85, 84, 85, 84,
84, 84, 84, 85, 84, 85, 84, 85, 84, 84, 84, 85, 85, 85, 85, 85, 85, 85, 84, 85,
85, 85, 85, 85, 85, 84, 85, 85, 85, 85, 85, 85, 84, 84, 85, 85, 86, 85, 85, 85,
85, 85, 85, 85, 85, 86, 85, 85, 85, 86, 86, 85, 85, 85, 85, 85, 85, 85, 84, 85,
85, 85, 85, 85, 86, 85, 86, 85, 84, 85, 85, 85, 85, 85, 85, 85, 85, 86, 85, 85,
85, 85, 85, 85, 85, 85, 85, 84, 85, 85, 85, 85, 85, 85, 85, 84, 84, 84, 84, 83,
83, 83, 82, 82, 81, 81, 80, 79, 79, 78, 77, 76, 75, 75, 74, 74, 72, 72, 71, 70,
69, 67, 67, 65, 64, 63, 62, 60, 60, 59, 57, 56, 54, 53, 52, 51, 49, 47, 47, 46,
44, 42, 41, 39, 37, 34, 33, 32, 29, 27, 25, 24, 21, 20, 18, 16, 14, 11, 10, 8,
6, 3, 2, 0, -2, -4, -6, -7, -9, -12, -13, -14, -17, -18, -21, -22, -24, -25,
-27, -28, -30, -31, -33, -34, -37, -38, -39, -41, -41, -43, -45, -46, -49, -50,
-52, -52, -54, -55, -56, -57, -59, -60, -61, -62, -63, -64, -65, -67, -68, -68,
-69, -70, -71, -71, -73, -74, -75, -74, -76, -76, -76, -76, -78, -77, -78, -78,
-79, -79, -80, -80, -80, -80, -81, -81, -81, -82, -81, -81, -82, -83, -83, -83,
-83, -83, -82, -83, -83, -83, -84, -83, -84, -84, -84, -83, -84, -84, -85, -84,
-84, -85, -84, -84, -85, -85, -85, -84, -85, -85, -85, -85, -85, -84, -85, -85,
-84, -85, -85, -84, -85, -85, -85, -85, -85, -85, -85, -84, -85, -85, -84, -85,
-85, -85, -85, -84, -85, -85, -85, -85, -85, -85, -85, -85, -85, -85, -85, -85,
-85, -85, -85, -85, -85, -85, -85, -86, -85, -85, -85, -85, -85, -85, -85, -84,
-85, -85, -85, -85, -86, -85, -85, -86, -85, -85, -86, -85, -85, -85, -85, -85,
-85, -85, -85, -84, -85, -85, -85, -86, -85, -85, -85, -85, -85, -85, -85, -85,
-84, -85, -85, -84, -84, -83, -83, -82, -83, -82, -81, -80, -80, -78, -78, -78,
-76, -76, -75, -75, -73, -72, -71, -70, -69, -68, -67, -66, -65, -64, -63, -62,
-60, -59, -58, -56, -56, -53, -52, -50, -49, -48, -46, -46, -44, -42, -40, -38,
-37, -34, -33, -31, -29, -28, -25, -23, -22, -20, -17, -16, -13, -12, -9, -7,
-5, -4, -1, };