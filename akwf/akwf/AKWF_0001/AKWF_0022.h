#define DATA_LENGTH 512
#define DATA AKWF_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 6, 9, 10, 11, 13, 14, 16, 17,
19, 20, 23, 23, 25, 27, 28, 30, 32, 33, 34, 35, 37, 38, 39, 41, 43, 44, 45, 47,
47, 49, 50, 52, 53, 55, 57, 57, 59, 61, 62, 63, 65, 67, 68, 70, 72, 72, 74, 76,
77, 79, 80, 82, 84, 85, 87, 88, 89, 90, 91, 93, 93, 96, 97, 97, 99, 100, 102,
102, 103, 104, 104, 105, 105, 107, 107, 108, 109, 110, 110, 111, 112, 112, 112,
112, 112, 114, 113, 114, 115, 114, 115, 115, 116, 116, 116, 116, 116, 116, 117,
117, 117, 117, 118, 117, 118, 118, 118, 119, 119, 118, 119, 119, 119, 119, 119,
119, 118, 119, 118, 119, 119, 118, 119, 118, 119, 118, 118, 117, 117, 117, 116,
116, 115, 114, 115, 114, 113, 113, 113, 111, 111, 111, 110, 110, 110, 109, 108,
108, 108, 107, 107, 105, 105, 104, 104, 103, 103, 102, 101, 100, 100, 99, 98,
97, 97, 96, 95, 95, 94, 93, 92, 92, 92, 90, 90, 89, 88, 87, 86, 84, 84, 83, 82,
80, 80, 79, 77, 77, 75, 74, 73, 72, 71, 68, 68, 66, 66, 65, 62, 62, 60, 59, 57,
56, 54, 54, 52, 50, 49, 48, 46, 45, 43, 43, 40, 39, 38, 36, 34, 33, 31, 30, 29,
27, 26, 25, 22, 21, 19, 19, 17, 15, 14, 12, 10, 10, 8, 6, 4, 3, 2, 1, -2, -3,
-5, -6, -7, -9, -10, -12, -13, -16, -17, -18, -20, -21, -23, -24, -27, -27, -28,
-30, -32, -34, -34, -36, -37, -39, -41, -43, -44, -45, -47, -47, -48, -51, -51,
-53, -55, -55, -57, -58, -60, -60, -62, -63, -63, -66, -66, -68, -69, -70, -71,
-72, -74, -74, -75, -76, -77, -78, -79, -80, -81, -81, -82, -83, -83, -85, -86,
-86, -87, -89, -88, -89, -90, -90, -92, -92, -93, -93, -93, -95, -95, -95, -96,
-97, -97, -97, -98, -97, -99, -99, -99, -99, -100, -100, -100, -100, -101, -101,
-101, -102, -101, -102, -102, -101, -102, -101, -102, -102, -101, -101, -101,
-101, -101, -101, -100, -100, -100, -100, -99, -99, -98, -99, -98, -97, -98,
-97, -97, -95, -95, -94, -94, -94, -94, -92, -91, -91, -91, -91, -90, -90, -89,
-89, -88, -88, -88, -88, -88, -87, -87, -87, -88, -88, -87, -88, -88, -88, -89,
-89, -90, -89, -90, -91, -91, -91, -92, -92, -92, -92, -92, -92, -92, -93, -92,
-93, -92, -94, -93, -94, -93, -93, -92, -92, -92, -91, -91, -90, -90, -89, -88,
-88, -87, -87, -86, -84, -84, -84, -83, -82, -81, -80, -80, -78, -78, -77, -76,
-76, -74, -73, -73, -72, -72, -71, -70, -70, -69, -68, -67, -66, -66, -64, -65,
-64, -63, -62, -61, -61, -60, -59, -58, -57, -56, -56, -55, -52, -51, -52, -50,
-49, -48, -46, -45, -44, -42, -41, -40, -38, -36, -34, -34, -31, -30, -28, -26,
-25, -23, -21, -20, -18, -15, -13, -12, -10, -8, -6, -4, -3, -1, };