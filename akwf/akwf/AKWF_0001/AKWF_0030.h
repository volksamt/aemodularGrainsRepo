#define DATA_LENGTH 512
#define DATA AKWF_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 6, 7, 8, 10, 12, 14, 15,
16, 17, 18, 21, 22, 25, 26, 28, 30, 31, 33, 34, 37, 39, 40, 43, 43, 46, 47, 49,
52, 53, 56, 57, 59, 61, 63, 65, 67, 69, 71, 72, 74, 76, 78, 80, 81, 83, 85, 87,
88, 91, 91, 94, 95, 97, 99, 100, 100, 102, 103, 105, 107, 107, 108, 109, 111,
111, 113, 114, 114, 115, 116, 117, 118, 118, 118, 118, 119, 119, 119, 119, 119,
119, 119, 120, 118, 118, 117, 117, 117, 116, 116, 114, 113, 113, 112, 111, 110,
108, 108, 106, 105, 103, 101, 99, 98, 96, 94, 93, 91, 89, 87, 84, 83, 80, 78,
75, 73, 71, 68, 65, 63, 60, 58, 55, 52, 50, 47, 45, 41, 39, 36, 33, 30, 28, 24,
22, 19, 15, 13, 9, 6, 4, 1, -3, -6, -9, -11, -14, -18, -21, -23, -26, -29, -31,
-34, -37, -40, -43, -45, -46, -50, -52, -54, -56, -59, -61, -63, -65, -67, -70,
-71, -73, -75, -77, -79, -81, -82, -83, -85, -86, -87, -89, -90, -92, -92, -93,
-94, -95, -96, -97, -98, -98, -98, -99, -98, -100, -100, -99, -100, -100, -100,
-100, -100, -99, -98, -98, -97, -97, -97, -96, -95, -94, -93, -93, -92, -92,
-90, -89, -87, -86, -86, -84, -83, -82, -80, -79, -77, -77, -75, -73, -71, -70,
-68, -66, -65, -63, -61, -60, -58, -56, -54, -53, -52, -50, -47, -46, -45, -43,
-41, -40, -38, -36, -34, -32, -31, -30, -27, -26, -25, -23, -22, -21, -19, -17,
-15, -14, -12, -12, -10, -9, -7, -6, -5, -4, -2, -1, -1, 1, 1, 3, 4, 5, 5, 5, 7,
7, 9, 9, 10, 11, 11, 11, 12, 13, 12, 13, 13, 14, 14, 15, 14, 15, 15, 15, 15, 15,
15, 15, 15, 15, 15, 14, 14, 14, 14, 14, 14, 14, 13, 13, 12, 12, 11, 12, 11, 10,
10, 9, 9, 8, 8, 8, 7, 7, 6, 5, 5, 4, 4, 4, 3, 2, 2, 0, 0, -1, -1, -1, -2, -2,
-3, -3, -5, -5, -6, -5, -7, -7, -7, -8, -9, -9, -9, -10, -10, -11, -11, -11,
-13, -13, -12, -14, -15, -14, -15, -15, -16, -16, -16, -16, -17, -17, -17, -18,
-18, -19, -19, -19, -20, -20, -20, -20, -20, -20, -21, -21, -21, -21, -21, -21,
-22, -21, -22, -21, -22, -23, -22, -22, -23, -23, -23, -22, -22, -23, -22, -23,
-23, -24, -23, -24, -24, -23, -23, -23, -23, -24, -24, -25, -24, -25, -25, -25,
-25, -25, -24, -25, -25, -25, -25, -25, -25, -26, -26, -25, -26, -25, -26, -25,
-25, -26, -26, -26, -26, -27, -25, -26, -26, -26, -26, -26, -25, -26, -26, -25,
-25, -25, -26, -25, -25, -25, -25, -24, -24, -24, -23, -23, -23, -23, -23, -22,
-21, -21, -22, -20, -20, -19, -19, -18, -18, -17, -17, -17, -16, -15, -14, -13,
-13, -11, -11, -10, -8, -8, -7, -6, -5, -4, -2, -1, 0, };