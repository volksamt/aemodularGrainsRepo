#define DATA_LENGTH 512
#define DATA AKWF_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -1, -3, -4, -5, -7, -8, -10, -12,
-14, -15, -17, -19, -21, -22, -25, -26, -28, -30, -32, -34, -36, -37, -40, -40,
-43, -45, -46, -48, -51, -52, -54, -54, -56, -58, -60, -61, -63, -65, -66, -68,
-68, -71, -72, -72, -74, -75, -76, -77, -80, -80, -81, -82, -84, -84, -85, -86,
-87, -87, -89, -89, -90, -90, -92, -93, -93, -94, -95, -96, -96, -96, -97, -98,
-98, -99, -99, -99, -99, -99, -100, -100, -102, -100, -101, -101, -102, -102,
-102, -103, -103, -104, -104, -103, -103, -104, -104, -104, -104, -103, -104,
-103, -104, -104, -104, -104, -104, -104, -104, -104, -103, -103, -103, -103,
-103, -104, -104, -103, -103, -102, -103, -102, -102, -101, -101, -101, -101,
-101, -100, -99, -99, -99, -99, -100, -100, -101, -103, -103, -104, -105, -107,
-107, -109, -111, -112, -113, -114, -116, -116, -118, -118, -118, -119, -119,
-119, -119, -118, -118, -117, -116, -115, -113, -112, -111, -110, -108, -107,
-106, -105, -104, -103, -102, -102, -103, -101, -102, -101, -101, -102, -103,
-103, -103, -104, -105, -105, -107, -107, -108, -110, -110, -111, -112, -113,
-114, -115, -116, -117, -118, -118, -117, -118, -120, -119, -119, -119, -118,
-118, -118, -118, -117, -117, -116, -115, -114, -113, -112, -111, -110, -108,
-107, -106, -104, -103, -102, -100, -97, -96, -95, -93, -90, -89, -86, -85, -83,
-81, -78, -76, -73, -71, -69, -66, -64, -62, -59, -57, -53, -51, -48, -45, -43,
-40, -37, -34, -32, -29, -27, -24, -20, -17, -16, -13, -11, -8, -6, -4, -2, 0,
2, 2, 4, 7, 9, 12, 14, 17, 19, 23, 26, 28, 31, 33, 36, 39, 43, 45, 48, 51, 53,
57, 59, 62, 65, 67, 69, 72, 74, 77, 79, 80, 82, 85, 87, 89, 91, 92, 94, 96, 97,
99, 100, 101, 103, 104, 105, 106, 107, 108, 109, 110, 111, 112, 113, 113, 114,
113, 115, 115, 116, 116, 116, 116, 118, 118, 118, 118, 119, 119, 118, 118, 119,
119, 119, 119, 119, 119, 120, 119, 118, 119, 120, 119, 119, 119, 118, 119, 119,
119, 118, 119, 119, 119, 119, 119, 119, 120, 119, 119, 118, 118, 119, 118, 118,
118, 119, 118, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 118, 119, 119,
120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119,
119, 118, 118, 118, 117, 117, 116, 116, 115, 115, 114, 113, 114, 112, 111, 110,
110, 109, 108, 106, 106, 104, 103, 102, 100, 99, 97, 96, 94, 93, 91, 90, 87, 85,
84, 83, 80, 79, 76, 74, 72, 70, 69, 67, 64, 62, 60, 57, 55, 53, 51, 49, 47, 45,
43, 40, 37, 36, 34, 31, 29, 27, 24, 23, 21, 19, 18, 16, 14, 12, 9, 8, 6, 5, 4,
1, 1, };