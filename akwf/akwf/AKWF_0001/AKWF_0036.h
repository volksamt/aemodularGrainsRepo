#define DATA_LENGTH 512
#define DATA AKWF_0036

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 13, 17, 20, 24, 27, 31, 35,
39, 42, 46, 48, 53, 56, 60, 62, 66, 69, 72, 75, 79, 82, 85, 88, 91, 94, 97, 100,
101, 104, 106, 109, 110, 111, 113, 114, 115, 116, 118, 118, 118, 118, 119, 118,
120, 119, 118, 118, 117, 117, 115, 115, 114, 113, 111, 110, 109, 107, 105, 105,
103, 101, 100, 98, 95, 93, 91, 90, 88, 86, 83, 81, 79, 77, 74, 74, 72, 69, 68,
66, 64, 63, 60, 60, 58, 57, 56, 55, 54, 53, 53, 52, 51, 51, 50, 51, 50, 49, 49,
49, 50, 49, 50, 49, 51, 50, 51, 51, 51, 52, 52, 53, 54, 54, 55, 55, 57, 59, 58,
60, 62, 63, 64, 67, 68, 69, 71, 72, 74, 76, 77, 79, 81, 83, 85, 86, 88, 89, 91,
93, 94, 96, 98, 99, 102, 103, 105, 107, 107, 110, 110, 112, 113, 115, 115, 115,
116, 117, 118, 118, 118, 118, 118, 118, 116, 116, 115, 115, 113, 112, 110, 109,
108, 106, 103, 102, 100, 96, 95, 93, 89, 87, 85, 82, 80, 76, 73, 70, 67, 65, 61,
58, 55, 51, 48, 45, 41, 38, 35, 31, 28, 25, 21, 18, 14, 11, 7, 4, 1, -1, -4, -8,
-10, -13, -16, -17, -21, -23, -25, -28, -30, -31, -34, -36, -38, -40, -42, -44,
-45, -48, -49, -51, -53, -54, -57, -60, -60, -63, -64, -66, -66, -69, -70, -71,
-72, -73, -74, -75, -75, -75, -77, -77, -77, -77, -76, -76, -76, -76, -76, -76,
-76, -75, -74, -75, -75, -74, -73, -73, -72, -73, -73, -73, -72, -73, -72, -72,
-72, -72, -73, -72, -73, -73, -74, -74, -75, -75, -74, -76, -76, -77, -78, -78,
-77, -78, -79, -80, -81, -81, -82, -82, -83, -83, -84, -84, -84, -85, -85, -84,
-85, -85, -85, -85, -84, -85, -84, -84, -83, -83, -84, -83, -82, -82, -82, -81,
-82, -80, -80, -80, -80, -79, -79, -78, -77, -78, -76, -75, -75, -75, -74, -73,
-72, -71, -70, -70, -68, -67, -66, -65, -63, -63, -62, -60, -60, -59, -58, -57,
-56, -54, -54, -53, -53, -51, -51, -51, -50, -50, -49, -49, -48, -46, -45, -45,
-44, -43, -41, -40, -39, -37, -36, -35, -33, -32, -31, -29, -27, -27, -26, -25,
-24, -22, -23, -21, -21, -19, -18, -18, -17, -16, -17, -15, -15, -15, -14, -13,
-13, -12, -11, -12, -11, -12, -11, -10, -11, -11, -11, -11, -11, -12, -13, -14,
-14, -14, -16, -17, -18, -19, -20, -20, -23, -24, -24, -26, -27, -30, -31, -33,
-34, -35, -37, -39, -40, -41, -44, -46, -48, -50, -51, -52, -54, -57, -58, -59,
-62, -63, -66, -66, -68, -70, -72, -73, -74, -76, -77, -78, -79, -79, -80, -80,
-81, -80, -81, -81, -81, -80, -80, -80, -79, -78, -77, -77, -76, -74, -73, -71,
-70, -68, -67, -64, -63, -61, -59, -56, -54, -52, -49, -47, -44, -41, -38, -36,
-33, -29, -26, -22, -19, -15, -12, -8, -5, -1, };