#define DATA_LENGTH 512
#define DATA AKWF_0040

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 4, 6, 8, 9, 11, 11, 14, 15,
17, 18, 20, 21, 22, 23, 24, 26, 28, 29, 30, 30, 25, 21, 22, 23, 24, 24, 27, 27,
30, 31, 33, 34, 37, 38, 40, 42, 44, 46, 48, 50, 52, 55, 56, 58, 60, 62, 63, 65,
67, 69, 70, 72, 74, 76, 77, 78, 80, 82, 84, 85, 87, 88, 89, 90, 92, 93, 94, 95,
97, 97, 98, 100, 100, 101, 102, 103, 104, 105, 105, 106, 107, 108, 108, 109,
109, 110, 111, 111, 112, 112, 113, 113, 113, 113, 114, 115, 116, 116, 116, 116,
117, 117, 116, 118, 118, 118, 118, 118, 118, 118, 118, 119, 119, 119, 119, 119,
120, 119, 119, 119, 119, 119, 119, 120, 119, 119, 118, 118, 119, 118, 118, 118,
118, 118, 118, 117, 117, 117, 116, 116, 115, 115, 115, 114, 114, 114, 113, 113,
113, 112, 112, 111, 112, 111, 110, 109, 109, 108, 108, 107, 106, 105, 105, 105,
105, 103, 102, 102, 101, 100, 99, 99, 98, 97, 96, 95, 95, 94, 93, 92, 91, 91,
90, 89, 88, 87, 85, 85, 84, 83, 82, 81, 80, 79, 77, 77, 76, 75, 73, 72, 70, 69,
68, 68, 66, 65, 64, 63, 61, 60, 59, 58, 57, 55, 54, 52, 51, 50, 49, 48, 46, 44,
43, 41, 40, 39, 39, 36, 35, 34, 33, 31, 30, 29, 27, 26, 24, 22, 21, 20, 19, 16,
15, 14, 12, 11, 10, 8, 7, 5, 4, 2, 1, -1, -2, -3, -6, -6, -7, -9, -11, -12, -13,
-15, -16, -17, -19, -20, -22, -24, -25, -26, -28, -29, -31, -32, -33, -34, -36,
-38, -38, -40, -42, -43, -44, -46, -48, -49, -50, -51, -53, -53, -54, -56, -57,
-58, -59, -61, -62, -64, -65, -66, -66, -68, -70, -71, -72, -73, -75, -75, -76,
-77, -78, -79, -81, -82, -83, -84, -85, -85, -87, -88, -88, -90, -91, -92, -93,
-94, -95, -95, -96, -96, -97, -98, -100, -100, -100, -101, -102, -103, -103,
-104, -105, -105, -105, -106, -108, -108, -109, -109, -110, -111, -111, -111,
-111, -112, -113, -113, -114, -114, -114, -114, -114, -115, -115, -116, -116,
-116, -116, -116, -117, -117, -118, -117, -116, -118, -118, -117, -118, -117,
-118, -118, -118, -118, -118, -117, -117, -117, -118, -117, -117, -117, -116,
-116, -116, -115, -116, -115, -114, -114, -114, -114, -114, -113, -113, -113,
-112, -112, -110, -110, -110, -110, -109, -108, -108, -107, -107, -107, -105,
-104, -104, -103, -103, -102, -101, -101, -99, -100, -98, -98, -97, -95, -95,
-94, -93, -92, -92, -90, -89, -89, -87, -86, -85, -85, -83, -83, -81, -81, -79,
-79, -77, -76, -75, -74, -73, -71, -70, -70, -68, -67, -66, -64, -64, -62, -62,
-60, -58, -57, -56, -54, -54, -52, -51, -49, -48, -48, -45, -45, -44, -42, -40,
-39, -37, -36, -35, -34, -32, -30, -29, -28, -27, -25, -23, -22, -20, -19, -19,
-17, -15, -13, -12, -11, -8, -8, -6, -4, -4, -2, -1, };