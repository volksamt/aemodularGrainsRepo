#define DATA_LENGTH 512
#define DATA AKWF_0069

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 7, 9, 11, 12, 14, 15, 17,
20, 21, 22, 25, 27, 29, 30, 31, 34, 34, 37, 38, 40, 41, 42, 44, 46, 47, 48, 50,
50, 52, 53, 54, 55, 56, 57, 58, 59, 59, 61, 62, 62, 62, 63, 64, 65, 64, 65, 66,
66, 67, 66, 67, 67, 67, 67, 67, 67, 68, 67, 68, 67, 67, 68, 67, 68, 67, 67, 67,
67, 67, 67, 68, 67, 67, 67, 67, 67, 67, 68, 69, 68, 69, 69, 69, 69, 70, 70, 69,
70, 71, 71, 71, 72, 72, 73, 73, 74, 74, 75, 76, 76, 76, 77, 78, 79, 78, 79, 80,
81, 81, 82, 82, 83, 84, 83, 84, 85, 85, 85, 86, 86, 88, 87, 88, 87, 87, 89, 88,
88, 89, 89, 88, 89, 89, 89, 88, 88, 89, 88, 88, 87, 87, 86, 87, 86, 86, 85, 84,
84, 83, 83, 82, 83, 82, 81, 80, 79, 79, 78, 76, 76, 76, 75, 74, 72, 72, 71, 70,
70, 69, 68, 67, 66, 66, 65, 64, 63, 62, 61, 60, 59, 59, 58, 57, 56, 56, 55, 55,
54, 53, 52, 51, 51, 50, 49, 49, 48, 48, 48, 46, 46, 45, 45, 43, 44, 43, 42, 41,
41, 40, 39, 39, 38, 37, 38, 36, 36, 35, 35, 34, 33, 33, 32, 32, 30, 30, 29, 28,
28, 27, 26, 25, 24, 23, 23, 20, 21, 19, 18, 16, 15, 14, 14, 13, 12, 10, 9, 8, 7,
5, 3, 3, 0, -1, -3, -5, -6, -7, -9, -11, -12, -14, -16, -18, -19, -21, -23, -26,
-27, -28, -30, -31, -33, -35, -37, -38, -40, -41, -43, -43, -46, -47, -48, -49,
-51, -51, -53, -55, -55, -57, -58, -59, -59, -59, -61, -62, -62, -63, -63, -63,
-65, -64, -65, -66, -66, -66, -66, -66, -67, -66, -66, -67, -67, -67, -67, -67,
-67, -66, -67, -67, -68, -68, -67, -67, -67, -67, -67, -67, -67, -67, -67, -67,
-68, -68, -67, -67, -68, -68, -69, -69, -69, -69, -70, -69, -70, -71, -72, -72,
-72, -72, -73, -73, -74, -74, -75, -75, -76, -76, -78, -78, -79, -79, -80, -80,
-80, -81, -82, -81, -83, -84, -84, -84, -85, -85, -86, -86, -86, -86, -87, -87,
-88, -88, -88, -88, -88, -88, -89, -89, -88, -89, -89, -88, -88, -88, -88, -88,
-87, -87, -87, -87, -86, -86, -85, -85, -85, -84, -83, -82, -82, -81, -81, -80,
-78, -79, -78, -77, -76, -76, -75, -74, -72, -72, -70, -71, -69, -68, -68, -66,
-66, -66, -64, -63, -62, -63, -61, -61, -60, -59, -58, -56, -57, -56, -55, -54,
-54, -52, -52, -51, -51, -50, -50, -48, -48, -48, -47, -46, -45, -44, -44, -44,
-43, -43, -42, -42, -40, -41, -39, -40, -39, -38, -37, -36, -36, -35, -35, -34,
-34, -33, -32, -32, -31, -30, -29, -28, -27, -26, -26, -25, -23, -23, -23, -22,
-20, -19, -18, -17, -15, -15, -14, -13, -12, -10, -9, -8, -6, -4, -3, -2, -1, };