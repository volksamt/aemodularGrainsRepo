#define DATA_LENGTH 512
#define DATA AKWF_0073

const PROGMEM int8_t DATA[DATA_LENGTH] = {-3, -13, -22, -29, -37, -43, -50, -57,
-62, -67, -72, -75, -79, -83, -86, -89, -93, -96, -97, -100, -102, -105, -107,
-109, -110, -112, -112, -114, -115, -115, -115, -115, -114, -113, -112, -110,
-109, -107, -105, -103, -100, -98, -96, -93, -90, -87, -84, -81, -78, -74, -72,
-68, -66, -63, -60, -57, -55, -52, -50, -47, -44, -42, -39, -37, -35, -31, -30,
-28, -25, -22, -20, -18, -16, -15, -13, -12, -11, -11, -10, -11, -12, -13, -15,
-17, -18, -20, -22, -25, -27, -30, -32, -35, -38, -41, -44, -46, -48, -51, -52,
-54, -57, -60, -61, -63, -64, -65, -67, -68, -69, -70, -71, -72, -72, -73, -75,
-75, -76, -77, -78, -78, -79, -79, -78, -79, -78, -78, -78, -77, -76, -75, -73,
-72, -71, -70, -68, -66, -64, -62, -61, -58, -56, -55, -53, -50, -48, -47, -44,
-42, -41, -39, -37, -36, -34, -33, -31, -30, -28, -27, -25, -24, -22, -21, -20,
-17, -17, -15, -15, -14, -13, -14, -15, -17, -18, -21, -24, -27, -32, -35, -40,
-44, -50, -54, -59, -64, -70, -74, -80, -85, -90, -94, -98, -101, -105, -109,
-111, -113, -115, -117, -117, -118, -119, -118, -116, -115, -113, -111, -107,
-105, -102, -99, -96, -93, -91, -88, -85, -83, -82, -81, -81, -81, -81, -82,
-84, -85, -86, -88, -90, -92, -95, -96, -96, -96, -97, -98, -97, -95, -95, -93,
-92, -90, -87, -84, -83, -80, -77, -75, -72, -69, -67, -64, -61, -57, -52, -47,
-42, -35, -28, -21, -12, -3, 6, 14, 22, 31, 37, 44, 50, 56, 61, 65, 70, 73, 77,
81, 83, 86, 90, 92, 95, 97, 99, 101, 103, 104, 104, 106, 106, 105, 105, 105,
104, 102, 101, 99, 98, 95, 93, 90, 88, 85, 83, 79, 76, 74, 70, 67, 65, 62, 59,
56, 53, 52, 49, 46, 44, 43, 40, 37, 36, 33, 30, 28, 26, 24, 22, 21, 18, 18, 16,
15, 16, 16, 16, 17, 17, 20, 22, 22, 25, 27, 31, 33, 36, 39, 40, 43, 46, 49, 51,
53, 55, 57, 60, 61, 63, 65, 66, 67, 68, 70, 70, 71, 71, 72, 72, 74, 75, 75, 76,
76, 76, 76, 77, 76, 76, 75, 75, 74, 73, 72, 71, 69, 67, 66, 64, 63, 61, 58, 56,
54, 53, 51, 49, 47, 45, 44, 41, 40, 38, 37, 34, 33, 32, 30, 29, 27, 27, 24, 23,
22, 20, 18, 18, 18, 17, 18, 18, 20, 22, 25, 27, 30, 34, 38, 43, 47, 53, 59, 63,
69, 73, 79, 83, 89, 94, 97, 101, 104, 107, 111, 112, 115, 116, 118, 119, 119,
119, 118, 117, 115, 114, 110, 108, 106, 103, 99, 97, 94, 90, 88, 85, 82, 81, 79,
77, 77, 77, 77, 78, 79, 80, 81, 84, 86, 88, 90, 91, 92, 94, 94, 96, 96, 96, 97,
95, 94, 94, 91, 89, 88, 85, 83, 81, 78, 75, 72, 71, 67, 66, 63, 61, 59, 56, 53,
48, 43, 39, 32, 27, 19, 11, 2, };