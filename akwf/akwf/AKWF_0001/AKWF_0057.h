#define DATA_LENGTH 512
#define DATA AKWF_0057

const PROGMEM int8_t DATA[DATA_LENGTH] = {-3, -7, -9, -13, -15, -20, -23, -26,
-30, -32, -34, -36, -40, -42, -45, -46, -49, -50, -53, -54, -55, -56, -58, -59,
-61, -61, -62, -63, -64, -65, -65, -66, -67, -66, -67, -67, -68, -67, -68, -68,
-67, -68, -66, -66, -65, -65, -64, -62, -61, -60, -60, -58, -57, -55, -53, -51,
-48, -45, -41, -37, -36, -32, -30, -27, -23, -19, -18, -15, -12, -9, -6, -2, 1,
4, 8, 11, 13, 16, 18, 22, 24, 26, 29, 31, 33, 36, 37, 40, 42, 44, 45, 48, 50,
52, 52, 54, 56, 57, 59, 60, 61, 63, 64, 64, 66, 67, 68, 68, 69, 70, 70, 71, 71,
71, 72, 72, 72, 72, 72, 71, 71, 70, 71, 70, 70, 69, 69, 68, 66, 65, 65, 63, 62,
61, 60, 58, 57, 55, 53, 51, 49, 45, 42, 39, 37, 34, 31, 28, 25, 21, 18, 16, 13,
10, 6, 4, 0, -3, -7, -10, -12, -16, -19, -21, -24, -26, -30, -32, -34, -37, -40,
-43, -44, -47, -49, -51, -54, -56, -58, -60, -62, -64, -67, -69, -70, -71, -74,
-75, -77, -79, -80, -83, -84, -85, -87, -89, -89, -89, -92, -93, -93, -94, -95,
-96, -96, -97, -97, -98, -99, -99, -99, -99, -98, -99, -99, -98, -99, -98, -97,
-97, -96, -96, -95, -94, -93, -93, -90, -90, -89, -88, -86, -84, -82, -82, -79,
-76, -75, -73, -70, -67, -64, -59, -54, -48, -43, -39, -35, -33, -31, -27, -24,
-20, -15, -10, -5, 0, 3, 7, 10, 13, 17, 20, 24, 26, 29, 32, 35, 37, 40, 42, 44,
47, 49, 50, 52, 54, 55, 57, 58, 59, 61, 62, 63, 64, 64, 66, 66, 66, 66, 67, 67,
68, 68, 68, 67, 67, 67, 67, 66, 67, 65, 64, 64, 63, 62, 60, 59, 58, 56, 54, 53,
50, 47, 45, 40, 37, 36, 31, 29, 26, 23, 20, 17, 15, 11, 9, 5, 2, -2, -5, -8,
-10, -14, -17, -20, -22, -25, -27, -30, -32, -34, -36, -38, -41, -42, -45, -46,
-48, -50, -51, -53, -54, -57, -58, -59, -60, -62, -62, -64, -65, -67, -67, -67,
-69, -69, -70, -70, -71, -71, -71, -72, -72, -72, -71, -72, -71, -71, -71, -71,
-70, -70, -69, -67, -68, -67, -65, -64, -64, -62, -61, -59, -59, -57, -55, -53,
-51, -48, -45, -42, -39, -36, -34, -30, -27, -25, -21, -18, -16, -13, -10, -7,
-3, -1, 4, 7, 11, 13, 16, 18, 21, 24, 27, 29, 32, 34, 37, 40, 42, 44, 47, 49,
52, 55, 56, 58, 61, 63, 65, 67, 68, 71, 72, 74, 76, 77, 79, 81, 83, 84, 86, 87,
88, 89, 90, 92, 92, 93, 94, 95, 96, 97, 97, 98, 99, 98, 98, 99, 99, 98, 99, 99,
98, 98, 97, 97, 97, 96, 96, 95, 94, 94, 92, 90, 90, 89, 87, 86, 85, 82, 81, 79,
76, 75, 72, 69, 66, 63, 59, 53, 48, 43, 39, 35, 32, 30, 27, 24, 19, 14, 9, 4, 0,
};