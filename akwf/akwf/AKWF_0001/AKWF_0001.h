#define DATA_LENGTH 512
#define DATA AKWF_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 7, 13, 21, 27, 35, 42, 50, 57, 62,
66, 74, 83, 89, 96, 101, 107, 110, 114, 117, 118, 119, 119, 118, 117, 114, 112,
109, 106, 102, 99, 94, 90, 85, 80, 74, 69, 63, 56, 48, 41, 33, 24, 15, 7, -2,
-11, -18, -27, -33, -39, -43, -49, -55, -60, -65, -68, -72, -75, -79, -81, -82,
-83, -84, -83, -83, -82, -82, -80, -78, -75, -72, -70, -68, -63, -61, -56, -53,
-49, -44, -41, -36, -32, -29, -23, -20, -15, -11, -7, -4, 0, 4, 7, 10, 14, 16,
20, 22, 24, 27, 28, 30, 32, 33, 33, 36, 36, 37, 38, 39, 40, 41, 41, 41, 41, 42,
42, 42, 41, 42, 41, 42, 41, 40, 40, 39, 39, 38, 38, 37, 36, 35, 34, 34, 33, 33,
31, 30, 29, 29, 28, 27, 26, 24, 23, 22, 20, 19, 18, 15, 14, 13, 11, 9, 7, 5, 3,
1, 0, -3, -4, -6, -8, -10, -11, -14, -16, -18, -20, -22, -23, -25, -27, -28,
-31, -31, -34, -35, -36, -39, -39, -41, -41, -43, -44, -45, -46, -47, -48, -49,
-49, -50, -50, -50, -50, -50, -51, -50, -50, -50, -50, -49, -48, -47, -46, -45,
-44, -43, -41, -40, -39, -37, -36, -34, -32, -30, -28, -27, -25, -23, -22, -20,
-19, -18, -17, -15, -14, -13, -12, -10, -9, -9, -7, -6, -6, -5, -5, -5, -4, -4,
-3, -2, -3, -1, 0, 1, 2, 3, 5, 8, 10, 13, 16, 19, 23, 28, 33, 36, 40, 42, 47,
52, 58, 63, 69, 75, 80, 86, 90, 94, 97, 100, 102, 103, 103, 103, 102, 102, 100,
98, 95, 92, 89, 86, 83, 80, 76, 73, 69, 65, 61, 56, 50, 46, 41, 34, 26, 20, 13,
5, -2, -10, -18, -26, -33, -40, -46, -51, -56, -59, -63, -69, -73, -77, -80,
-83, -85, -89, -88, -90, -90, -91, -91, -91, -90, -89, -87, -86, -83, -80, -79,
-75, -74, -69, -66, -63, -60, -56, -53, -49, -45, -42, -39, -35, -31, -26, -23,
-20, -16, -12, -9, -6, -1, 1, 5, 8, 11, 13, 17, 19, 21, 24, 26, 29, 31, 34, 35,
37, 38, 39, 41, 42, 44, 45, 46, 47, 48, 49, 50, 50, 51, 52, 51, 53, 52, 52, 52,
52, 52, 53, 52, 52, 52, 51, 51, 50, 50, 49, 48, 47, 46, 45, 44, 42, 41, 39, 38,
36, 35, 32, 31, 29, 27, 25, 22, 20, 18, 16, 15, 12, 10, 8, 5, 4, 1, -1, -4, -5,
-7, -10, -12, -14, -16, -17, -19, -22, -24, -26, -28, -29, -31, -33, -35, -36,
-39, -40, -41, -43, -44, -46, -46, -47, -48, -49, -50, -50, -51, -52, -52, -52,
-51, -51, -52, -51, -50, -50, -49, -48, -47, -46, -46, -45, -43, -42, -42, -41,
-40, -40, -39, -38, -38, -39, -39, -39, -40, -41, -40, -41, -42, -43, -44, -43,
-45, -44, -44, -44, -45, -43, -43, -42, -40, -39, -37, -35, -33, -30, -27, -24,
-19, -14, -10, -4, };