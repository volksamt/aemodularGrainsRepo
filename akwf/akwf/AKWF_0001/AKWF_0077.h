#define DATA_LENGTH 512
#define DATA AKWF_0077

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 3, 6, 6, 8, 8, 10, 11, 12,
13, 14, 15, 15, 17, 18, 18, 19, 22, 22, 23, 25, 25, 26, 27, 28, 29, 30, 31, 32,
33, 34, 35, 36, 37, 38, 39, 40, 40, 42, 43, 44, 44, 45, 46, 46, 48, 48, 49, 51,
51, 52, 52, 53, 55, 55, 56, 57, 59, 58, 59, 60, 61, 62, 62, 64, 65, 65, 67, 67,
67, 68, 68, 70, 70, 71, 72, 73, 73, 74, 75, 75, 77, 77, 77, 78, 78, 79, 79, 81,
81, 82, 83, 84, 84, 84, 85, 86, 87, 87, 87, 88, 89, 89, 90, 90, 90, 92, 92, 92,
93, 93, 94, 95, 96, 96, 96, 96, 98, 98, 99, 99, 99, 100, 101, 102, 101, 102,
102, 103, 104, 104, 104, 105, 106, 105, 106, 107, 107, 108, 108, 108, 109, 109,
110, 111, 111, 110, 111, 111, 113, 113, 113, 113, 113, 114, 114, 115, 115, 116,
116, 117, 116, 117, 118, 117, 117, 118, 118, 118, 119, 119, 119, 119, 119, 119,
118, 118, 118, 118, 117, 116, 116, 115, 114, 113, 111, 111, 110, 108, 107, 106,
105, 103, 101, 100, 99, 96, 95, 92, 91, 89, 87, 85, 83, 82, 80, 77, 75, 73, 72,
70, 68, 66, 64, 62, 60, 59, 56, 55, 52, 50, 49, 47, 44, 44, 42, 40, 38, 36, 36,
33, 32, 30, 28, 27, 25, 24, 22, 21, 20, 18, 17, 15, 13, 13, 11, 10, 9, 8, 6, 5,
4, 3, 2, 0, -1, -2, -4, -5, -6, -6, -8, -8, -10, -11, -12, -13, -14, -14, -17,
-18, -18, -19, -20, -21, -22, -24, -24, -25, -26, -27, -28, -29, -30, -31, -33,
-33, -34, -34, -36, -37, -38, -39, -40, -40, -41, -42, -44, -44, -45, -45, -47,
-48, -48, -50, -50, -51, -53, -54, -54, -54, -56, -55, -57, -58, -59, -60, -61,
-62, -62, -62, -63, -65, -65, -65, -66, -67, -68, -68, -70, -70, -71, -72, -72,
-73, -74, -74, -76, -76, -77, -77, -78, -79, -79, -79, -80, -81, -82, -82, -83,
-83, -85, -85, -85, -87, -86, -87, -87, -88, -89, -90, -90, -91, -92, -92, -92,
-93, -93, -94, -95, -95, -96, -97, -97, -97, -97, -98, -98, -99, -99, -101,
-101, -101, -102, -102, -102, -103, -104, -104, -104, -105, -106, -106, -107,
-107, -107, -107, -109, -108, -109, -109, -109, -111, -111, -111, -111, -111,
-112, -111, -113, -113, -113, -114, -114, -114, -114, -116, -115, -116, -116,
-117, -117, -117, -117, -118, -117, -118, -118, -118, -118, -118, -118, -117,
-117, -116, -116, -115, -114, -114, -113, -112, -111, -109, -108, -107, -106,
-104, -103, -101, -100, -98, -97, -95, -93, -91, -89, -88, -86, -84, -81, -80,
-78, -76, -73, -71, -69, -68, -66, -64, -62, -60, -58, -56, -54, -52, -50, -49,
-47, -45, -43, -42, -40, -38, -36, -35, -33, -31, -30, -29, -28, -25, -24, -22,
-21, -20, -18, -17, -15, -14, -12, -11, -10, -8, -7, -6, -5, -4, -2, -1, -1, };