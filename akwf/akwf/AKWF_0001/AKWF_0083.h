#define DATA_LENGTH 512
#define DATA AKWF_0083

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 6, 9, 11, 13, 15, 16, 18, 20,
21, 22, 25, 27, 29, 29, 31, 33, 35, 35, 37, 38, 40, 41, 43, 44, 45, 46, 47, 49,
50, 51, 53, 54, 55, 56, 58, 59, 59, 61, 62, 63, 64, 66, 66, 67, 69, 69, 70, 71,
72, 74, 75, 76, 74, 72, 69, 67, 66, 65, 64, 64, 62, 62, 62, 60, 61, 61, 62, 61,
61, 62, 61, 62, 62, 63, 63, 63, 64, 65, 65, 66, 66, 68, 68, 69, 69, 70, 70, 70,
71, 72, 73, 74, 74, 74, 75, 75, 76, 77, 77, 78, 78, 79, 79, 81, 81, 81, 82, 82,
82, 83, 84, 85, 85, 86, 85, 86, 84, 82, 79, 78, 75, 73, 72, 70, 69, 68, 67, 66,
66, 65, 65, 64, 64, 63, 64, 64, 64, 63, 63, 63, 63, 63, 63, 64, 64, 63, 64, 64,
64, 65, 64, 64, 64, 65, 65, 66, 65, 65, 65, 66, 66, 66, 66, 66, 66, 66, 66, 66,
66, 67, 66, 68, 67, 66, 67, 68, 67, 68, 67, 67, 65, 61, 58, 55, 53, 51, 48, 46,
45, 43, 41, 40, 39, 39, 37, 36, 36, 35, 34, 34, 33, 33, 32, 31, 31, 30, 30, 29,
29, 29, 28, 28, 27, 27, 26, 26, 25, 26, 24, 24, 24, 24, 22, 22, 23, 22, 21, 21,
20, 20, 19, 19, 18, 17, 17, 16, 15, 14, 14, 12, 12, 12, 10, 9, 8, 8, 7, 6, 5, 4,
3, 2, 1, 0, -2, -2, -3, -4, -5, -7, -7, -9, -10, -10, -11, -11, -13, -13, -14,
-14, -15, -15, -16, -17, -17, -18, -19, -20, -20, -20, -21, -22, -21, -21, -23,
-23, -24, -23, -25, -25, -25, -24, -25, -26, -25, -26, -27, -27, -27, -27, -27,
-28, -28, -28, -28, -28, -28, -28, -32, -36, -39, -42, -45, -46, -50, -52, -53,
-54, -56, -57, -58, -59, -61, -61, -61, -62, -63, -64, -63, -64, -64, -65, -64,
-65, -65, -65, -66, -65, -66, -65, -66, -66, -65, -65, -66, -65, -65, -65, -64,
-65, -65, -65, -64, -64, -64, -63, -63, -63, -63, -62, -62, -62, -62, -62, -61,
-61, -61, -60, -60, -60, -59, -60, -62, -66, -68, -69, -71, -74, -75, -77, -78,
-79, -80, -80, -81, -81, -82, -82, -82, -81, -81, -82, -82, -82, -83, -82, -82,
-82, -80, -80, -81, -80, -80, -79, -79, -78, -77, -78, -77, -75, -75, -74, -74,
-74, -73, -72, -71, -70, -70, -70, -69, -68, -67, -67, -66, -66, -65, -64, -63,
-62, -62, -61, -60, -59, -59, -58, -60, -62, -64, -66, -67, -70, -70, -71, -72,
-73, -73, -72, -73, -73, -73, -73, -72, -72, -72, -70, -71, -69, -70, -69, -68,
-66, -67, -66, -65, -64, -62, -63, -61, -60, -60, -58, -57, -56, -55, -53, -53,
-51, -50, -50, -47, -46, -45, -43, -43, -40, -40, -38, -37, -35, -34, -32, -31,
-29, -27, -26, -24, -23, -21, -20, -17, -16, -14, -12, -11, -9, -6, -3, -1, };