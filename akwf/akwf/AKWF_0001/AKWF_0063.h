#define DATA_LENGTH 512
#define DATA AKWF_0063

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 4, 5, 5, 6, 7, 8, 8, 10,
11, 11, 12, 13, 14, 14, 15, 16, 17, 17, 17, 20, 19, 20, 21, 22, 23, 22, 24, 24,
25, 26, 27, 26, 27, 28, 30, 29, 30, 30, 30, 32, 32, 33, 33, 34, 34, 35, 36, 36,
36, 36, 37, 37, 37, 38, 39, 39, 40, 39, 39, 40, 40, 41, 40, 41, 41, 41, 41, 41,
42, 41, 42, 42, 42, 42, 42, 42, 42, 42, 42, 43, 42, 42, 42, 42, 41, 43, 43, 42,
42, 42, 42, 42, 41, 42, 42, 42, 42, 41, 42, 41, 41, 41, 41, 41, 42, 42, 41, 42,
42, 42, 41, 41, 41, 41, 41, 41, 41, 41, 41, 41, 41, 41, 41, 40, 41, 41, 41, 41,
41, 41, 41, 41, 41, 41, 41, 41, 42, 40, 41, 41, 41, 42, 41, 42, 41, 41, 41, 41,
41, 41, 41, 41, 41, 41, 40, 41, 40, 40, 41, 40, 41, 40, 40, 39, 39, 39, 40, 40,
39, 38, 38, 39, 38, 38, 37, 37, 37, 36, 36, 36, 37, 36, 35, 35, 35, 35, 34, 34,
33, 33, 33, 32, 32, 32, 31, 30, 30, 30, 30, 29, 28, 27, 28, 28, 26, 26, 25, 26,
24, 24, 24, 24, 23, 22, 22, 21, 21, 20, 20, 20, 18, 18, 17, 16, 16, 14, 14, 12,
12, 11, 10, 10, 9, 7, 6, 5, 4, 3, 2, 1, -1, -1, -3, -3, -5, -5, -8, -8, -9, -10,
-12, -13, -14, -15, -17, -18, -17, -20, -20, -21, -22, -23, -24, -25, -26, -26,
-28, -28, -29, -29, -30, -30, -32, -32, -33, -33, -34, -35, -36, -36, -37, -36,
-37, -38, -38, -38, -38, -39, -39, -39, -39, -40, -40, -40, -40, -40, -40, -41,
-41, -41, -41, -41, -41, -41, -41, -41, -41, -41, -41, -42, -41, -41, -41, -41,
-40, -41, -39, -40, -40, -39, -39, -39, -40, -39, -39, -39, -39, -39, -39, -38,
-39, -38, -38, -38, -38, -37, -38, -37, -38, -37, -37, -36, -36, -36, -36, -37,
-36, -36, -35, -36, -36, -35, -35, -35, -34, -35, -34, -34, -35, -34, -34, -34,
-34, -34, -33, -34, -34, -34, -33, -34, -34, -33, -34, -33, -34, -34, -34, -34,
-33, -33, -33, -33, -33, -34, -33, -33, -33, -33, -33, -33, -34, -33, -34, -33,
-34, -34, -33, -33, -34, -34, -34, -34, -34, -34, -34, -34, -34, -33, -33, -34,
-34, -34, -35, -33, -34, -34, -34, -34, -35, -34, -34, -34, -34, -34, -33, -33,
-34, -33, -33, -34, -33, -33, -33, -33, -32, -32, -32, -32, -31, -31, -32, -31,
-31, -30, -29, -30, -30, -29, -29, -28, -29, -28, -28, -28, -27, -27, -26, -27,
-26, -26, -25, -25, -25, -25, -24, -24, -23, -23, -23, -23, -22, -21, -21, -21,
-20, -20, -20, -19, -19, -19, -18, -18, -16, -17, -15, -15, -15, -14, -13, -13,
-12, -11, -11, -11, -10, -9, -8, -7, -7, -6, -5, -4, -3, -3, -2, -2, -1, 0, };