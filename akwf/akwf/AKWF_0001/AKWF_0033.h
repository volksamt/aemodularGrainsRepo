#define DATA_LENGTH 512
#define DATA AKWF_0033

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, -7, -14, -20, -25, -31, -36, -41,
-46, -51, -58, -62, -67, -72, -77, -80, -84, -87, -89, -92, -94, -96, -97, -97,
-97, -99, -98, -99, -99, -99, -99, -99, -99, -98, -98, -97, -97, -95, -94, -92,
-91, -89, -88, -85, -83, -81, -77, -74, -72, -70, -66, -63, -60, -57, -53, -51,
-47, -43, -40, -38, -35, -31, -27, -25, -21, -18, -16, -13, -11, -8, -6, -4, -2,
1, 3, 4, 6, 8, 9, 11, 13, 14, 16, 16, 17, 18, 19, 19, 20, 20, 20, 21, 21, 22,
20, 21, 20, 19, 20, 19, 19, 18, 17, 16, 16, 14, 13, 13, 11, 10, 9, 9, 8, 7, 5,
4, 4, 3, 2, 1, 1, 0, -2, -3, -4, -4, -5, -6, -7, -8, -9, -9, -9, -11, -10, -11,
-12, -13, -13, -14, -14, -14, -14, -15, -15, -15, -15, -15, -15, -14, -15, -15,
-15, -16, -15, -15, -15, -14, -14, -14, -14, -14, -13, -14, -14, -13, -14, -12,
-12, -12, -11, -12, -11, -12, -10, -10, -11, -11, -10, -10, -10, -9, -9, -9, -9,
-8, -7, -8, -8, -7, -7, -6, -7, -7, -6, -6, -6, -6, -6, -5, -5, -5, -5, -5, -4,
-5, -4, -4, -3, -3, -4, -4, -3, -3, -3, -2, -2, -2, -1, -1, -2, -1, 0, 0, -1, 0,
1, 0, 0, 2, 2, 1, 2, 3, 3, 3, 3, 3, 4, 5, 4, 5, 5, 5, 6, 7, 7, 8, 7, 9, 8, 9, 9,
9, 9, 9, 10, 10, 11, 11, 10, 11, 11, 11, 12, 11, 11, 12, 11, 12, 13, 12, 12, 12,
13, 13, 13, 12, 13, 12, 13, 12, 12, 12, 12, 13, 12, 11, 12, 11, 12, 11, 11, 11,
10, 11, 10, 10, 10, 10, 10, 10, 10, 9, 10, 9, 9, 9, 9, 8, 9, 9, 8, 8, 8, 8, 8,
8, 7, 7, 7, 7, 8, 8, 8, 7, 8, 7, 8, 8, 8, 8, 9, 9, 9, 9, 10, 8, 9, 9, 10, 10,
10, 10, 10, 10, 11, 11, 12, 12, 13, 12, 13, 13, 14, 14, 14, 15, 14, 14, 16, 15,
16, 16, 16, 17, 17, 17, 18, 17, 18, 19, 19, 20, 19, 19, 20, 20, 21, 21, 21, 22,
21, 21, 21, 22, 21, 23, 23, 23, 22, 23, 22, 23, 23, 24, 23, 23, 24, 24, 23, 23,
24, 23, 24, 25, 23, 24, 25, 24, 25, 24, 24, 24, 25, 24, 24, 24, 24, 25, 24, 24,
24, 24, 24, 24, 24, 24, 24, 25, 23, 24, 24, 24, 24, 24, 23, 23, 24, 24, 24, 24,
24, 25, 25, 24, 24, 24, 24, 25, 25, 24, 24, 25, 25, 25, 24, 25, 26, 25, 26, 26,
26, 26, 27, 27, 27, 26, 26, 27, 27, 27, 27, 27, 27, 27, 27, 28, 28, 29, 28, 28,
28, 28, 29, 29, 29, 29, 29, 30, 30, 30, 30, 30, 30, 31, 31, 31, 31, 32, 31, 31,
32, 32, 31, 31, 28, 24, 21, 16, 9, 3, };