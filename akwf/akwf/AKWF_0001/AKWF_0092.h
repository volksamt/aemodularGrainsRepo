#define DATA_LENGTH 512
#define DATA AKWF_0092

const PROGMEM int8_t DATA[DATA_LENGTH] = {24, 33, 33, 39, 45, 53, 54, 59, 62,
68, 71, 75, 76, 80, 84, 89, 90, 90, 93, 100, 103, 102, 102, 105, 111, 111, 111,
112, 115, 117, 117, 117, 118, 119, 118, 117, 117, 118, 116, 116, 114, 113, 114,
114, 112, 110, 110, 110, 109, 107, 106, 105, 105, 102, 99, 98, 98, 96, 93, 92,
91, 89, 86, 83, 81, 81, 80, 77, 73, 72, 71, 68, 64, 65, 63, 56, 52, 52, 52, 47,
40, 37, 36, 31, 22, -7, -22, -21, -26, -31, -39, -41, -41, -42, -47, -51, -51,
-52, -57, -60, -62, -63, -63, -69, -72, -73, -72, -73, -78, -81, -78, -78, -81,
-85, -84, -82, -84, -87, -88, -87, -87, -90, -92, -93, -93, -92, -93, -95, -95,
-95, -94, -94, -93, -93, -94, -92, -90, -90, -90, -91, -89, -88, -87, -89, -87,
-86, -86, -88, -89, -86, -86, -87, -91, -91, -89, -88, -90, -91, -90, -87, -85,
-86, -86, -84, -80, -80, -81, -78, -75, -75, -74, -72, -70, -71, -70, -67, -63,
-63, -62, -60, -58, -55, -53, -53, -50, -44, -39, -40, -37, -29, -18, 6, 11, 19,
32, 37, 40, 41, 46, 49, 52, 54, 55, 56, 59, 62, 64, 65, 66, 68, 69, 71, 73, 73,
72, 74, 77, 77, 77, 76, 77, 79, 80, 80, 78, 80, 83, 81, 80, 80, 83, 84, 83, 80,
80, 83, 84, 82, 80, 82, 82, 82, 81, 80, 79, 80, 80, 79, 78, 78, 79, 78, 76, 76,
75, 75, 74, 74, 73, 72, 72, 71, 70, 71, 70, 68, 68, 68, 66, 64, 63, 63, 62, 60,
57, 58, 59, 55, 51, 50, 52, 49, 44, 41, 44, 43, 38, 29, 30, 33, 30, 12, -20, 3,
23, -15, -31, -30, -29, -30, -36, -41, -44, -44, -46, -49, -53, -54, -54, -53,
-55, -58, -59, -57, -56, -59, -59, -56, -57, -60, -60, -56, -57, -61, -64, -60,
-57, -60, -64, -62, -58, -58, -61, -61, -60, -57, -58, -60, -60, -57, -56, -59,
-61, -59, -57, -57, -58, -59, -57, -54, -55, -57, -56, -54, -53, -55, -55, -55,
-52, -51, -51, -52, -51, -48, -46, -46, -45, -44, -42, -42, -40, -38, -39, -41,
-38, -35, -36, -37, -37, -37, -36, -36, -37, -37, -38, -40, -41, -39, -36, -36,
-40, -41, -38, -35, -35, -35, -28, -20, 3, 22, 28, 39, 44, 48, 49, 55, 63, 63,
62, 67, 73, 75, 74, 74, 76, 79, 80, 77, 76, 79, 81, 78, 75, 75, 78, 77, 73, 71,
73, 71, 70, 68, 65, 63, 62, 61, 55, 49, 46, 46, 41, 31, 22, 22, 16, -17, -36,
-39, -43, -43, -50, -56, -60, -61, -64, -66, -71, -75, -75, -75, -80, -85, -85,
-83, -85, -90, -94, -94, -92, -93, -98, -100, -98, -99, -102, -104, -103, -104,
-103, -105, -105, -104, -101, -101, -101, -100, -99, -97, -95, -94, -94, -91,
-89, -86, -84, -83, -81, -78, -74, -72, -72, -69, -62, -58, -57, -55, -51, -42,
-37, -37, -33, -12, };