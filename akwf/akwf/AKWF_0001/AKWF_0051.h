#define DATA_LENGTH 512
#define DATA AKWF_0051

const PROGMEM int8_t DATA[DATA_LENGTH] = {87, 103, 96, 102, 97, 101, 97, 100,
98, 100, 98, 100, 98, 99, 98, 99, 98, 99, 98, 99, 99, 99, 98, 99, 99, 99, 99,
98, 99, 99, 100, 98, 99, 99, 99, 99, 100, 99, 99, 99, 99, 99, 99, 99, 99, 99,
98, 99, 99, 98, 98, 99, 99, 99, 99, 99, 99, 98, 99, 98, 99, 99, 98, 99, 98, 99,
98, 99, 98, 98, 99, 99, 99, 98, 99, 98, 98, 99, 99, 99, 98, 99, 99, 99, 99, 98,
99, 99, 98, 99, 98, 99, 98, 98, 99, 98, 98, 99, 99, 99, 99, 98, 98, 98, 99, 98,
99, 98, 99, 99, 99, 98, 99, 98, 99, 99, 99, 99, 98, 99, 99, 99, 98, 100, 99, 99,
98, 99, 97, 100, 98, 100, 97, 100, 97, 100, 97, 99, 98, 100, 99, 99, 99, 97,
101, 95, 104, 89, 120, -32, -119, -86, -107, -92, -104, -94, -102, -96, -101,
-98, -100, -98, -99, -98, -100, -98, -99, -100, -98, -99, -98, -100, -98, -100,
-98, -99, -99, -99, -98, -100, -98, -99, -99, -99, -98, -99, -98, -98, -99, -99,
-99, -98, -99, -98, -99, -98, -99, -99, -99, -98, -99, -98, -98, -98, -99, -99,
-99, -99, -99, -99, -100, -98, -99, -100, -98, -99, -99, -99, -99, -99, -99,
-98, -99, -99, -99, -98, -99, -98, -99, -99, -99, -99, -98, -99, -99, -99, -99,
-99, -98, -99, -98, -98, -98, -99, -98, -99, -98, -99, -98, -99, -98, -99, -99,
-99, -98, -99, -99, -98, -99, -98, -98, -99, -99, -99, -99, -99, -98, -99, -99,
-98, -99, -98, -99, -98, -100, -97, -100, -97, -100, -98, -100, -98, -100, -98,
-99, -98, -99, -99, -97, -101, -95, -104, -89, -120, 32, 120, 86, 108, 92, 104,
94, 102, 96, 101, 96, 100, 98, 100, 98, 99, 98, 99, 99, 97, 99, 98, 100, 98, 99,
99, 100, 98, 99, 98, 98, 98, 99, 98, 100, 99, 99, 98, 99, 98, 98, 99, 99, 100,
98, 98, 99, 99, 99, 99, 98, 99, 98, 99, 99, 98, 99, 98, 100, 98, 99, 98, 100,
97, 100, 98, 99, 98, 99, 98, 98, 100, 98, 100, 96, 102, 94, 105, 87, 121, 7,
-123, -85, -108, -93, -104, -96, -100, -99, -96, -103, -90, -119, 37, 119, 88,
106, 93, 103, 96, 101, 97, 101, 98, 98, 98, 99, 99, 98, 100, 98, 100, 97, 100,
97, 99, 97, 99, 99, 99, 99, 99, 98, 99, 99, 98, 100, 97, 100, 97, 102, 96, 101,
96, 103, 96, 103, 94, 105, 92, 106, 83, -98, -100, -96, -102, -96, -102, -96,
-101, -96, -101, -96, -101, -97, -101, -97, -100, -98, -99, -98, -99, -98, -99,
-99, -99, -99, -98, -99, -98, -98, -98, -100, -98, -99, -98, -100, -98, -99,
-98, -99, -98, -99, -99, -98, -99, -99, -100, -98, -99, -98, -98, -98, -100,
-99, -99, -99, -99, -99, -98, -99, -98, -98, -98, -100, -98, -100, -98, -100,
-97, -100, -97, -101, -96, -102, -94, -104, -85, };