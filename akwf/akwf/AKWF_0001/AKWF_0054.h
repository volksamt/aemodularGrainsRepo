#define DATA_LENGTH 512
#define DATA AKWF_0054

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 1, 4, 5, 7, 7, 9, 9, 11, 11, 12,
12, 12, 12, 14, 14, 14, 14, 13, 12, 13, 12, 11, 12, 11, 10, 9, 9, 8, 8, 7, 6, 6,
4, 4, 4, 4, 3, 2, 2, 3, 2, 3, 2, 3, 2, 3, 4, 4, 5, 5, 7, 7, 6, 8, 8, 9, 10, 10,
11, 12, 12, 13, 13, 13, 14, 15, 16, 16, 16, 17, 19, 20, 21, 22, 23, 26, 26, 29,
30, 32, 34, 36, 38, 40, 41, 44, 45, 48, 51, 54, 55, 58, 61, 64, 67, 70, 73, 76,
78, 80, 83, 87, 88, 91, 93, 95, 97, 98, 99, 101, 102, 102, 103, 104, 104, 105,
104, 103, 104, 104, 103, 102, 100, 99, 98, 95, 95, 93, 90, 88, 85, 82, 80, 76,
73, 69, 65, 62, 58, 54, 50, 45, 41, 36, 33, 28, 23, 18, 14, 10, 5, 0, -5, -9,
-14, -20, -25, -30, -35, -40, -45, -50, -55, -60, -65, -68, -73, -78, -81, -84,
-88, -91, -95, -97, -100, -102, -105, -107, -109, -111, -113, -114, -115, -117,
-117, -118, -118, -120, -119, -119, -118, -119, -118, -117, -115, -114, -113,
-112, -111, -110, -108, -107, -105, -103, -102, -101, -99, -98, -95, -94, -93,
-91, -89, -87, -85, -84, -82, -80, -79, -76, -74, -73, -70, -68, -66, -64, -62,
-59, -57, -55, -53, -50, -47, -46, -42, -40, -37, -35, -32, -29, -26, -23, -21,
-17, -14, -12, -10, -6, -3, -1, 2, 6, 8, 9, 13, 14, 16, 19, 20, 23, 24, 26, 27,
29, 29, 31, 31, 33, 33, 33, 33, 33, 33, 33, 31, 31, 30, 30, 28, 27, 25, 24, 22,
22, 20, 18, 16, 14, 13, 11, 9, 8, 6, 5, 3, 1, -1, -2, -4, -6, -7, -8, -9, -10,
-11, -11, -11, -12, -12, -12, -11, -11, -11, -11, -10, -9, -9, -8, -8, -6, -5,
-3, -2, -1, 0, 2, 2, 5, 6, 7, 9, 10, 11, 14, 16, 18, 18, 21, 22, 24, 25, 27, 28,
31, 31, 33, 35, 37, 38, 39, 41, 42, 44, 46, 48, 50, 51, 53, 54, 56, 58, 59, 61,
62, 63, 64, 65, 67, 68, 69, 69, 70, 70, 71, 71, 70, 70, 71, 69, 70, 68, 67, 66,
65, 63, 62, 59, 58, 55, 52, 50, 48, 44, 42, 39, 36, 33, 32, 28, 26, 24, 22, 19,
17, 15, 13, 10, 9, 7, 5, 4, 3, 1, 0, -1, -1, -3, -3, -3, -2, -3, -3, -1, -2, -1,
0, 0, 1, 1, 1, 1, 1, 1, 1, -1, -1, -1, -2, -3, -4, -5, -7, -8, -10, -13, -15,
-17, -19, -21, -23, -26, -29, -32, -36, -38, -40, -44, -47, -49, -51, -54, -55,
-58, -59, -61, -64, -64, -65, -66, -67, -68, -68, -69, -69, -68, -69, -67, -66,
-67, -65, -64, -63, -61, -59, -58, -56, -54, -52, -50, -47, -45, -43, -41, -40,
-36, -35, -32, -30, -29, -26, -23, -22, -19, -17, -14, -13, -10, -8, -5, -3, -1,
};