#define DATA_LENGTH 512
#define DATA AKWF_0091

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 17, 30, 38, 42, 47, 51, 56, 59, 61,
68, 74, 76, 78, 83, 92, 99, 100, 96, 90, 85, 79, 70, 63, 59, 55, 48, 41, 39, 37,
33, 20, 4, -12, -25, -34, -41, -50, -60, -68, -75, -86, -98, -106, -109, -111,
-112, -111, -107, -104, -106, -112, -119, -118, -111, -100, -94, -89, -84, -76,
-68, -63, -55, -49, -45, -45, -47, -41, -31, -24, -21, -22, -23, -20, -17, -16,
-16, -18, -20, -24, -26, -27, -24, -24, -27, -31, -34, -32, -32, -33, -38, -43,
-47, -48, -49, -50, -48, -46, -41, -39, -39, -38, -37, -35, -36, -36, -33, -26,
-19, -15, -14, -11, -8, -7, -8, -4, 3, 11, 14, 13, 10, 11, 13, 20, 28, 37, 45,
48, 45, 41, 42, 49, 56, 57, 57, 60, 68, 75, 77, 75, 73, 72, 72, 73, 74, 75, 76,
76, 74, 72, 69, 63, 56, 54, 54, 54, 52, 48, 46, 46, 43, 38, 33, 29, 25, 21, 16,
11, 9, 8, 7, 6, 6, 5, 3, 2, 3, 6, 11, 13, 12, 10, 10, 14, 17, 23, 28, 32, 34,
39, 44, 45, 41, 40, 40, 43, 43, 46, 47, 51, 51, 52, 52, 54, 57, 59, 55, 47, 41,
38, 36, 35, 35, 34, 30, 21, 11, 5, 3, 0, -5, -12, -13, -13, -15, -20, -24, -25,
-29, -34, -37, -37, -33, -31, -33, -37, -42, -48, -54, -56, -53, -46, -37, -32,
-30, -31, -32, -29, -26, -24, -26, -24, -18, -12, -8, -4, -2, -1, -1, -2, -5,
-5, -8, -13, -21, -24, -24, -23, -26, -33, -38, -40, -39, -38, -39, -37, -36,
-39, -43, -48, -50, -53, -56, -56, -55, -53, -52, -50, -51, -56, -60, -62, -56,
-48, -41, -40, -40, -42, -43, -41, -36, -26, -14, -8, -7, -8, -8, -5, -4, -5,
-5, -3, 1, 7, 9, 11, 13, 14, 11, 5, 2, 4, 10, 17, 22, 23, 22, 20, 18, 16, 12, 8,
8, 9, 10, 8, 6, 7, 7, 5, 2, -2, -3, -4, -4, -5, -1, 5, 9, 4, -3, -8, -7, -2, 2,
6, 8, 9, 8, 6, 4, 3, 3, 5, 5, 7, 10, 15, 19, 22, 20, 20, 22, 25, 30, 32, 35, 36,
37, 40, 45, 45, 45, 43, 41, 37, 36, 38, 41, 44, 42, 38, 35, 33, 30, 28, 28, 28,
24, 20, 19, 19, 18, 12, 6, 3, 3, 1, -4, -5, -2, -2, -6, -12, -19, -22, -21, -24,
-27, -27, -27, -25, -22, -22, -18, -12, -7, -3, -4, -4, -5, -4, -1, 5, 9, 11,
13, 16, 19, 18, 14, 14, 18, 25, 28, 29, 31, 32, 31, 26, 22, 23, 26, 29, 25, 22,
20, 16, 10, 6, 3, 3, 1, -3, -6, -6, -5, -10, -17, -23, -26, -29, -30, -31, -26,
-20, -15, -15, -19, -23, -24, -22, -20, -19, -21, -20, -19, -15, -13, -12, -12,
-11, -10, -9, -9, -12, -13, -12, -11, -10, -9, -11, -13, -14, -9, -2, -1, -4,
-9, -12, -11, -5, };