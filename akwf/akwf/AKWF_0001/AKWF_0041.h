#define DATA_LENGTH 512
#define DATA AKWF_0041

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 6, 7, 9, 10, 11, 13, 14,
16, 17, 18, 19, 21, 22, 24, 26, 26, 27, 29, 30, 32, 33, 34, 36, 37, 39, 40, 41,
42, 44, 45, 46, 48, 49, 51, 51, 53, 55, 55, 56, 57, 59, 59, 61, 62, 63, 65, 65,
67, 69, 69, 71, 72, 73, 73, 75, 76, 77, 78, 80, 80, 81, 83, 83, 84, 85, 86, 88,
87, 89, 90, 91, 92, 92, 93, 94, 95, 95, 96, 96, 98, 98, 99, 101, 101, 101, 102,
103, 103, 104, 105, 105, 106, 106, 107, 108, 107, 108, 110, 110, 110, 110, 111,
110, 111, 111, 112, 112, 112, 112, 114, 114, 114, 113, 114, 115, 114, 114, 114,
115, 115, 115, 115, 116, 116, 114, 116, 116, 115, 115, 115, 114, 115, 114, 114,
115, 115, 115, 113, 114, 114, 113, 112, 113, 112, 111, 112, 111, 109, 104, 101,
101, 99, 98, 98, 98, 98, 97, 96, 97, 96, 95, 96, 95, 95, 94, 95, 95, 94, 93, 94,
93, 93, 93, 93, 92, 92, 91, 91, 90, 90, 90, 89, 88, 88, 87, 87, 85, 85, 84, 83,
82, 82, 80, 80, 79, 77, 77, 76, 74, 74, 73, 72, 71, 70, 69, 67, 67, 65, 63, 63,
61, 59, 59, 57, 56, 54, 53, 52, 50, 49, 48, 47, 44, 44, 43, 40, 39, 38, 36, 34,
33, 33, 31, 29, 27, 26, 25, 23, 21, 20, 19, 17, 16, 15, 14, 11, 10, 9, 6, 6, 4,
3, 1, 0, -2, -3, -6, -6, -8, -9, -10, -12, -14, -14, -16, -18, -19, -21, -22,
-23, -25, -26, -28, -30, -31, -34, -40, -44, -45, -47, -48, -50, -51, -53, -54,
-55, -56, -57, -58, -59, -59, -60, -61, -62, -62, -63, -65, -65, -65, -66, -67,
-69, -68, -69, -70, -71, -71, -72, -73, -73, -74, -75, -76, -77, -77, -78, -79,
-80, -81, -81, -82, -82, -84, -85, -85, -86, -86, -87, -88, -88, -90, -90, -92,
-92, -93, -93, -94, -96, -96, -96, -97, -98, -98, -99, -100, -101, -102, -102,
-102, -104, -104, -104, -105, -106, -106, -107, -108, -108, -108, -109, -110,
-110, -109, -111, -112, -111, -111, -111, -112, -112, -113, -113, -113, -113,
-113, -113, -115, -114, -114, -114, -114, -114, -114, -115, -114, -115, -114,
-114, -114, -113, -114, -114, -114, -113, -113, -113, -113, -113, -113, -112,
-112, -111, -111, -113, -117, -119, -119, -119, -118, -118, -117, -117, -116,
-115, -114, -113, -113, -111, -111, -110, -108, -107, -107, -105, -104, -103,
-102, -100, -99, -98, -97, -96, -95, -93, -92, -90, -90, -87, -86, -85, -84,
-82, -82, -81, -79, -77, -77, -74, -75, -73, -72, -71, -69, -68, -67, -66, -64,
-63, -63, -61, -60, -58, -58, -56, -55, -54, -53, -51, -51, -49, -47, -46, -45,
-45, -43, -42, -41, -40, -38, -38, -36, -35, -33, -32, -31, -29, -28, -27, -25,
-25, -24, -21, -21, -19, -18, -17, -16, -14, -12, -12, -11, -9, -7, -6, -4, -4,
-2, -1, };