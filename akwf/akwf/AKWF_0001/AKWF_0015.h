#define DATA_LENGTH 512
#define DATA AKWF_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 8, 10, 13, 15, 18, 22, 24,
27, 30, 33, 35, 38, 40, 43, 46, 48, 50, 52, 55, 57, 60, 61, 63, 64, 65, 67, 68,
70, 70, 72, 73, 73, 75, 75, 75, 76, 77, 77, 78, 77, 77, 78, 78, 78, 79, 79, 80,
79, 79, 79, 79, 80, 79, 79, 79, 79, 78, 79, 79, 79, 79, 79, 79, 78, 79, 78, 79,
79, 78, 79, 78, 79, 79, 79, 77, 78, 77, 77, 77, 77, 77, 77, 77, 76, 77, 77, 76,
75, 76, 75, 76, 76, 76, 76, 75, 75, 75, 75, 74, 75, 74, 74, 75, 74, 75, 75, 74,
74, 75, 74, 75, 74, 74, 75, 74, 74, 74, 74, 74, 74, 75, 75, 75, 74, 75, 74, 75,
75, 74, 74, 75, 75, 74, 75, 74, 74, 74, 74, 74, 74, 74, 74, 75, 74, 74, 74, 74,
74, 73, 74, 74, 73, 73, 73, 74, 73, 73, 73, 72, 74, 73, 73, 73, 73, 73, 73, 73,
73, 74, 73, 73, 73, 73, 73, 73, 73, 72, 72, 73, 73, 72, 72, 73, 71, 72, 72, 72,
71, 71, 71, 70, 70, 69, 68, 68, 67, 66, 65, 65, 63, 63, 61, 60, 59, 58, 56, 55,
53, 52, 51, 49, 47, 45, 44, 42, 40, 37, 35, 33, 31, 30, 26, 25, 23, 20, 18, 15,
14, 12, 10, 9, 5, 3, 2, -1, -3, -6, -8, -11, -13, -16, -17, -18, -21, -22, -23,
-24, -26, -28, -28, -28, -30, -30, -32, -33, -33, -33, -34, -35, -35, -36, -36,
-37, -37, -37, -38, -38, -39, -39, -39, -41, -40, -41, -42, -42, -42, -43, -44,
-45, -46, -47, -46, -47, -48, -50, -51, -51, -52, -54, -54, -55, -56, -57, -58,
-59, -59, -60, -61, -62, -62, -63, -64, -64, -65, -66, -67, -67, -69, -69, -69,
-71, -71, -72, -73, -74, -74, -75, -75, -76, -76, -77, -78, -78, -78, -79, -79,
-79, -78, -78, -80, -79, -79, -80, -80, -81, -80, -81, -81, -81, -81, -81, -82,
-81, -80, -82, -81, -81, -82, -81, -81, -81, -81, -81, -82, -82, -81, -82, -81,
-82, -81, -81, -81, -81, -81, -81, -81, -82, -81, -81, -81, -81, -80, -80, -81,
-80, -80, -79, -80, -80, -80, -79, -80, -79, -78, -78, -79, -78, -79, -77, -77,
-77, -77, -77, -76, -75, -75, -75, -75, -74, -73, -72, -72, -72, -71, -70, -70,
-70, -69, -68, -68, -67, -66, -66, -64, -65, -63, -62, -61, -60, -60, -59, -57,
-57, -56, -55, -54, -54, -52, -52, -51, -49, -50, -49, -48, -47, -46, -47, -44,
-45, -44, -43, -43, -43, -43, -43, -42, -42, -42, -42, -41, -41, -41, -42, -42,
-41, -42, -42, -42, -43, -42, -43, -44, -43, -43, -44, -44, -44, -45, -45, -45,
-45, -45, -45, -46, -45, -45, -45, -46, -44, -45, -44, -44, -44, -43, -42, -41,
-39, -37, -36, -35, -33, -31, -29, -28, -27, -25, -23, -22, -21, -18, -16, -15,
-13, -11, -10, -7, -6, -3, -1, };