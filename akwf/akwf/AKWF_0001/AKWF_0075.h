#define DATA_LENGTH 512
#define DATA AKWF_0075

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 5, 5, 6, 6, 8, 10, 12, 14, 15,
15, 17, 20, 19, 22, 22, 22, 24, 25, 25, 27, 27, 28, 29, 29, 29, 29, 29, 30, 31,
30, 32, 31, 32, 31, 32, 32, 31, 32, 32, 34, 37, 37, 37, 37, 39, 41, 43, 44, 45,
46, 47, 49, 51, 52, 52, 53, 54, 55, 56, 57, 57, 57, 58, 59, 60, 60, 60, 61, 60,
61, 62, 61, 61, 62, 62, 63, 63, 63, 63, 63, 63, 63, 63, 62, 63, 62, 63, 62, 62,
63, 63, 63, 62, 62, 62, 62, 63, 62, 62, 61, 62, 61, 62, 62, 62, 62, 62, 62, 62,
62, 62, 61, 62, 62, 62, 61, 61, 61, 62, 61, 61, 62, 61, 62, 62, 61, 61, 62, 62,
61, 62, 61, 61, 61, 62, 61, 60, 58, 56, 56, 57, 55, 53, 51, 49, 49, 48, 45, 45,
42, 42, 41, 40, 39, 38, 37, 36, 36, 35, 34, 34, 34, 33, 32, 31, 32, 32, 31, 31,
30, 30, 31, 30, 31, 29, 27, 25, 24, 24, 23, 21, 20, 17, 16, 16, 15, 13, 12, 10,
10, 9, 9, 8, 6, 5, 5, 4, 3, 3, 3, 2, 1, 2, 1, 0, 1, 0, -1, -3, -4, -6, -6, -7,
-9, -10, -13, -14, -14, -16, -17, -19, -20, -21, -21, -23, -24, -25, -25, -26,
-27, -28, -27, -28, -29, -30, -29, -30, -30, -31, -31, -31, -31, -31, -32, -33,
-35, -37, -38, -38, -38, -40, -41, -44, -46, -46, -46, -49, -50, -52, -52, -52,
-53, -54, -55, -56, -56, -57, -58, -59, -60, -60, -61, -60, -61, -61, -62, -62,
-62, -62, -62, -62, -62, -63, -62, -63, -62, -63, -62, -63, -63, -62, -62, -62,
-62, -62, -62, -62, -63, -62, -62, -62, -62, -62, -62, -61, -62, -64, -66, -68,
-67, -68, -70, -71, -74, -74, -75, -76, -77, -79, -81, -82, -82, -84, -84, -86,
-86, -87, -88, -88, -90, -89, -90, -91, -91, -91, -92, -92, -93, -93, -92, -93,
-93, -93, -94, -93, -94, -94, -93, -94, -93, -94, -94, -95, -94, -93, -94, -94,
-94, -94, -93, -93, -94, -93, -94, -94, -93, -92, -93, -93, -93, -92, -93, -92,
-93, -92, -90, -88, -88, -87, -87, -86, -83, -80, -80, -79, -77, -77, -74, -73,
-73, -71, -70, -70, -69, -68, -67, -65, -66, -64, -63, -63, -63, -63, -62, -63,
-62, -62, -61, -61, -61, -61, -61, -61, -61, -60, -60, -61, -60, -60, -61, -61,
-61, -61, -60, -61, -61, -61, -61, -61, -61, -61, -61, -61, -61, -61, -61, -61,
-61, -61, -61, -61, -59, -58, -56, -57, -55, -54, -52, -50, -49, -49, -47, -46,
-44, -43, -42, -41, -40, -39, -39, -38, -37, -35, -35, -34, -34, -33, -33, -32,
-32, -32, -32, -31, -30, -31, -30, -30, -30, -28, -26, -24, -24, -24, -22, -20,
-19, -17, -16, -15, -15, -13, -12, -11, -9, -9, -8, -7, -6, -5, -4, -5, -3, -2,
-2, -1, -1, -2, -1, -1, -1, };