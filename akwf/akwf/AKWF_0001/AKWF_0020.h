#define DATA_LENGTH 512
#define DATA AKWF_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 4, 5, 7, 9, 10, 12, 16, 17,
19, 21, 23, 25, 26, 28, 30, 32, 34, 35, 37, 40, 42, 43, 44, 47, 48, 50, 51, 53,
54, 56, 58, 57, 55, 55, 56, 57, 57, 58, 58, 58, 58, 58, 59, 58, 59, 58, 58, 58,
58, 58, 59, 59, 58, 58, 58, 58, 57, 58, 58, 57, 57, 58, 57, 57, 57, 56, 56, 56,
56, 56, 55, 55, 55, 55, 55, 56, 54, 54, 55, 54, 54, 53, 54, 53, 53, 53, 54, 53,
53, 53, 52, 52, 52, 52, 52, 52, 52, 52, 51, 51, 51, 50, 50, 50, 50, 50, 49, 49,
49, 49, 48, 48, 48, 48, 47, 48, 47, 47, 47, 47, 46, 46, 46, 45, 46, 45, 45, 45,
44, 44, 44, 43, 43, 44, 43, 42, 42, 42, 41, 42, 41, 40, 41, 39, 39, 39, 39, 39,
39, 38, 37, 38, 37, 37, 37, 36, 37, 36, 35, 35, 35, 34, 34, 33, 34, 32, 33, 32,
33, 31, 32, 32, 31, 31, 31, 30, 32, 32, 32, 34, 33, 33, 34, 34, 35, 35, 35, 35,
36, 35, 36, 36, 36, 37, 36, 36, 37, 37, 36, 36, 36, 37, 36, 36, 37, 36, 36, 37,
36, 36, 35, 36, 35, 36, 35, 35, 35, 34, 34, 34, 34, 33, 34, 33, 32, 32, 31, 31,
31, 31, 29, 29, 29, 28, 28, 27, 27, 26, 26, 25, 24, 24, 24, 23, 23, 22, 21, 21,
20, 19, 19, 18, 18, 16, 16, 15, 14, 14, 13, 13, 12, 11, 10, 10, 9, 8, 8, 7, 6,
4, 4, 4, 2, 3, 1, 1, 0, -1, -2, -3, -4, -4, -4, -6, -7, -7, -8, -9, -10, -11,
-12, -13, -14, -15, -17, -17, -18, -19, -20, -22, -22, -24, -25, -26, -28, -29,
-29, -31, -33, -34, -34, -37, -37, -40, -40, -42, -44, -45, -47, -50, -51, -53,
-55, -56, -58, -59, -60, -62, -64, -65, -66, -69, -70, -70, -71, -73, -74, -75,
-76, -75, -75, -76, -77, -77, -77, -78, -78, -78, -79, -78, -79, -79, -78, -79,
-79, -79, -79, -78, -78, -78, -79, -78, -79, -77, -78, -77, -77, -77, -76, -76,
-76, -75, -76, -75, -74, -73, -73, -73, -72, -72, -71, -70, -69, -69, -69, -67,
-68, -67, -66, -66, -64, -65, -64, -62, -61, -61, -60, -60, -59, -57, -57, -57,
-56, -55, -53, -53, -52, -51, -50, -50, -49, -47, -47, -47, -45, -44, -45, -44,
-43, -42, -41, -41, -40, -40, -39, -38, -38, -39, -41, -41, -42, -42, -42, -43,
-44, -43, -44, -45, -44, -45, -45, -45, -45, -45, -45, -46, -45, -45, -45, -45,
-45, -45, -46, -45, -45, -45, -44, -44, -44, -43, -43, -42, -42, -42, -41, -40,
-41, -39, -39, -39, -38, -37, -37, -37, -35, -34, -33, -33, -33, -32, -31, -30,
-28, -28, -28, -26, -26, -25, -24, -22, -21, -20, -20, -18, -18, -16, -15, -14,
-13, -11, -10, -10, -8, -7, -5, -4, -3, -2, -1, };