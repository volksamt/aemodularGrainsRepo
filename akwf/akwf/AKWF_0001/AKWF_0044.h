#define DATA_LENGTH 512
#define DATA AKWF_0044

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 12, 16, 19, 22, 25, 28, 32,
35, 38, 41, 43, 48, 51, 53, 57, 60, 63, 65, 68, 71, 73, 77, 78, 82, 84, 86, 89,
91, 94, 96, 97, 99, 102, 103, 105, 106, 107, 110, 110, 112, 113, 114, 115, 116,
117, 118, 118, 118, 119, 119, 119, 119, 119, 119, 119, 118, 118, 117, 117, 116,
115, 115, 113, 112, 111, 109, 108, 107, 106, 104, 103, 100, 99, 96, 94, 93, 90,
89, 86, 84, 81, 80, 77, 73, 71, 69, 65, 63, 60, 56, 54, 51, 49, 46, 43, 40, 36,
33, 30, 27, 24, 20, 18, 14, 12, 8, 5, 2, -1, -4, -9, -11, -14, -17, -19, -23,
-27, -29, -32, -35, -37, -40, -43, -46, -48, -51, -54, -56, -59, -61, -62, -64,
-65, -65, -67, -67, -69, -68, -68, -69, -69, -68, -67, -67, -66, -65, -64, -64,
-62, -60, -59, -56, -56, -54, -51, -50, -48, -46, -43, -42, -39, -38, -35, -32,
-30, -27, -25, -23, -20, -19, -16, -13, -11, -9, -6, -4, -1, 1, 3, 5, 7, 9, 12,
13, 15, 18, 20, 21, 23, 25, 27, 28, 30, 31, 32, 33, 35, 35, 36, 37, 39, 38, 39,
39, 41, 41, 41, 41, 41, 41, 41, 41, 41, 40, 39, 39, 39, 38, 37, 36, 36, 35, 33,
32, 31, 30, 29, 27, 26, 25, 23, 22, 20, 19, 17, 14, 12, 11, 9, 7, 5, 2, 1, -1,
-3, -4, -7, -10, -12, -14, -16, -18, -20, -23, -25, -27, -29, -30, -33, -35,
-37, -39, -42, -43, -45, -47, -49, -51, -53, -56, -57, -59, -60, -62, -64, -65,
-67, -67, -69, -71, -73, -74, -75, -76, -77, -79, -78, -79, -80, -81, -82, -82,
-83, -83, -84, -83, -85, -84, -85, -85, -85, -85, -84, -83, -84, -83, -83, -82,
-81, -81, -80, -79, -78, -78, -77, -76, -74, -73, -72, -71, -70, -68, -66, -66,
-63, -61, -60, -59, -56, -55, -52, -52, -49, -47, -46, -43, -42, -39, -37, -34,
-33, -30, -28, -25, -23, -21, -19, -16, -14, -13, -9, -8, -6, -3, -1, 2, 4, 6,
8, 11, 13, 15, 18, 20, 21, 24, 26, 29, 31, 32, 35, 36, 38, 40, 42, 43, 46, 48,
49, 51, 53, 54, 55, 57, 58, 60, 60, 61, 63, 65, 66, 66, 67, 68, 68, 69, 68, 67,
66, 67, 66, 65, 63, 62, 60, 58, 57, 54, 53, 51, 48, 46, 43, 41, 37, 35, 32, 29,
26, 22, 20, 18, 14, 10, 7, 4, 0, -2, -5, -9, -13, -16, -19, -21, -24, -28, -30,
-33, -36, -39, -42, -45, -47, -50, -53, -55, -57, -59, -61, -63, -66, -68, -68,
-71, -72, -74, -76, -76, -77, -78, -78, -79, -80, -81, -81, -81, -82, -81, -82,
-81, -82, -81, -79, -79, -79, -78, -77, -76, -75, -73, -71, -71, -68, -67, -66,
-63, -61, -59, -57, -55, -53, -50, -48, -45, -42, -39, -37, -33, -31, -28, -25,
-23, -18, -16, -13, -11, -7, -3, -1, };