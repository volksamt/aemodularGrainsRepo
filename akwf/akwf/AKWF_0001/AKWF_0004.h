#define DATA_LENGTH 512
#define DATA AKWF_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 26, 42, 53, 57, 61, 66, 69, 71,
73, 74, 76, 78, 79, 80, 81, 84, 86, 89, 91, 94, 98, 100, 103, 106, 109, 111,
113, 114, 115, 117, 118, 117, 118, 119, 119, 119, 119, 119, 119, 119, 118, 118,
117, 116, 116, 116, 116, 115, 114, 113, 113, 111, 110, 109, 107, 105, 104, 102,
100, 98, 96, 94, 91, 88, 84, 81, 77, 74, 72, 69, 65, 61, 57, 52, 42, 29, 15, 2,
-9, -20, -26, -32, -36, -38, -41, -44, -47, -50, -54, -58, -62, -66, -70, -74,
-78, -82, -84, -87, -89, -92, -94, -95, -96, -98, -99, -99, -101, -101, -102,
-103, -102, -103, -104, -104, -105, -105, -106, -105, -106, -106, -106, -106,
-107, -106, -106, -105, -105, -103, -104, -104, -102, -101, -99, -98, -97, -95,
-94, -92, -91, -89, -87, -85, -83, -81, -78, -75, -73, -71, -68, -65, -64, -62,
-61, -60, -59, -58, -56, -54, -52, -47, -41, -33, -25, -18, -10, -2, 6, 12, 18,
24, 28, 33, 36, 38, 40, 42, 43, 44, 44, 45, 45, 45, 46, 47, 48, 48, 47, 48, 46,
46, 43, 42, 39, 36, 32, 29, 26, 21, 16, 12, 6, 0, -9, -18, -28, -38, -47, -53,
-55, -55, -56, -56, -54, -52, -50, -48, -46, -44, -44, -47, -49, -52, -54, -56,
-58, -60, -61, -62, -64, -65, -66, -65, -65, -65, -64, -64, -63, -61, -59, -57,
-55, -53, -51, -47, -43, -39, -35, -30, -26, -20, -15, -8, -1, 6, 14, 22, 30,
39, 47, 53, 57, 62, 65, 69, 71, 74, 76, 76, 77, 76, 76, 75, 75, 75, 76, 77, 78,
78, 80, 81, 83, 84, 85, 86, 88, 89, 90, 92, 93, 92, 92, 94, 93, 92, 91, 91, 90,
89, 88, 86, 85, 84, 83, 82, 79, 78, 77, 74, 72, 72, 69, 67, 66, 64, 62, 59, 56,
53, 51, 46, 43, 39, 37, 35, 34, 34, 32, 30, 28, 24, 19, 14, 7, 1, -6, -14, -20,
-26, -33, -38, -43, -48, -50, -52, -53, -54, -56, -56, -56, -57, -58, -58, -59,
-59, -60, -60, -62, -61, -61, -61, -63, -64, -63, -62, -63, -64, -63, -62, -62,
-60, -61, -60, -58, -57, -56, -55, -53, -52, -48, -45, -41, -38, -35, -31, -28,
-23, -18, -11, -4, 3, 10, 17, 23, 29, 34, 37, 40, 41, 42, 44, 45, 46, 48, 49,
51, 52, 54, 57, 58, 60, 62, 64, 66, 67, 69, 69, 69, 69, 68, 68, 68, 67, 67, 67,
66, 66, 65, 65, 63, 63, 62, 60, 59, 56, 55, 52, 50, 46, 41, 35, 28, 22, 14, 5,
-5, -17, -29, -43, -53, -57, -61, -63, -66, -67, -68, -68, -68, -68, -69, -71,
-72, -73, -77, -78, -81, -84, -86, -88, -90, -92, -94, -96, -98, -99, -100,
-101, -101, -102, -102, -101, -101, -102, -101, -100, -100, -99, -99, -97, -98,
-96, -95, -95, -93, -92, -91, -90, -88, -86, -84, -82, -79, -76, -73, -69, -66,
-63, -57, -52, -40, -27, -12, };