#define DATA_LENGTH 512
#define DATA AKWF_0088

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -4, -7, -11, -14, -17, -20, -24,
-26, -30, -32, -37, -39, -42, -44, -47, -49, -52, -55, -57, -58, -62, -63, -66,
-68, -69, -71, -73, -75, -75, -77, -78, -80, -82, -82, -82, -84, -84, -85, -86,
-87, -86, -87, -87, -87, -87, -88, -88, -88, -89, -88, -89, -88, -88, -89, -88,
-89, -88, -88, -87, -88, -87, -88, -87, -86, -86, -87, -86, -85, -86, -85, -86,
-86, -86, -86, -86, -85, -86, -85, -85, -85, -85, -84, -84, -84, -85, -85, -84,
-85, -85, -85, -85, -84, -84, -85, -85, -84, -84, -84, -85, -84, -84, -84, -84,
-84, -84, -84, -83, -83, -82, -83, -82, -82, -81, -81, -80, -79, -79, -79, -78,
-78, -77, -77, -77, -75, -75, -74, -74, -72, -71, -72, -70, -70, -68, -68, -67,
-66, -65, -65, -63, -63, -62, -61, -60, -58, -58, -57, -56, -55, -54, -53, -52,
-51, -50, -49, -48, -46, -46, -44, -44, -43, -42, -40, -39, -39, -37, -36, -35,
-34, -32, -31, -31, -29, -27, -26, -25, -23, -20, -19, -17, -15, -14, -12, -9,
-7, -6, -3, -2, 1, 3, 5, 7, 9, 10, 12, 15, 17, 19, 21, 22, 25, 27, 29, 30, 31,
34, 35, 36, 39, 39, 42, 42, 43, 44, 45, 46, 47, 47, 48, 49, 49, 49, 50, 49, 50,
49, 49, 47, 47, 46, 45, 44, 42, 41, 41, 38, 37, 35, 32, 31, 29, 28, 25, 23, 22,
19, 17, 16, 13, 11, 10, 7, 5, 3, 1, -1, -2, -5, -6, -7, -9, -12, -12, -14, -16,
-17, -19, -20, -21, -22, -22, -24, -25, -25, -26, -27, -27, -28, -27, -28, -28,
-28, -28, -28, -27, -27, -27, -26, -25, -25, -24, -25, -23, -22, -22, -20, -20,
-19, -18, -17, -16, -14, -13, -12, -10, -9, -8, -7, -5, -5, -3, -2, -1, 1, 2, 2,
4, 6, 6, 8, 9, 10, 11, 12, 13, 13, 15, 16, 16, 17, 19, 19, 20, 20, 21, 22, 22,
24, 24, 24, 24, 25, 26, 26, 27, 27, 28, 28, 28, 29, 29, 29, 29, 29, 31, 31, 30,
31, 31, 32, 33, 33, 33, 33, 34, 34, 34, 35, 35, 36, 36, 36, 37, 37, 38, 38, 38,
39, 39, 40, 40, 41, 41, 43, 42, 43, 44, 44, 45, 46, 47, 47, 48, 49, 49, 49, 50,
51, 52, 52, 53, 53, 54, 54, 55, 57, 57, 57, 58, 59, 60, 61, 61, 62, 63, 63, 65,
65, 65, 66, 67, 68, 69, 70, 71, 72, 73, 74, 75, 76, 77, 79, 80, 81, 83, 83, 85,
86, 88, 90, 91, 92, 93, 95, 97, 97, 100, 100, 102, 102, 104, 105, 105, 106, 107,
108, 109, 109, 109, 110, 110, 110, 109, 109, 109, 109, 109, 109, 108, 107, 106,
105, 105, 103, 102, 101, 100, 98, 97, 95, 94, 91, 89, 87, 85, 83, 81, 78, 75,
73, 70, 67, 65, 61, 58, 55, 52, 49, 46, 43, 40, 36, 33, 30, 26, 22, 19, 16, 13,
10, 6, 2, };