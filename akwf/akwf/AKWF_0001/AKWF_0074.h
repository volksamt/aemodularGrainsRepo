#define DATA_LENGTH 512
#define DATA AKWF_0074

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -1, -1, 0, -1, 0, 0, 0, 0, 0, 1,
-1, 1, -2, 7, 20, 16, 18, 17, 18, 16, 18, 17, 17, 17, 16, 18, 16, 31, 36, 34,
34, 34, 34, 35, 34, 34, 34, 35, 34, 35, 32, 39, 53, 50, 51, 52, 51, 51, 51, 51,
51, 52, 50, 51, 50, 52, 50, 52, 67, 69, 68, 68, 68, 67, 68, 68, 68, 68, 68, 68,
68, 69, 68, 68, 68, 68, 68, 69, 67, 81, 87, 84, 87, 85, 85, 84, 85, 85, 86, 85,
85, 85, 85, 86, 85, 84, 84, 85, 85, 85, 85, 85, 85, 85, 85, 85, 85, 84, 85, 85,
85, 86, 85, 85, 85, 85, 85, 84, 86, 85, 85, 85, 85, 85, 85, 84, 85, 86, 85, 85,
85, 85, 85, 85, 85, 85, 85, 85, 86, 85, 85, 85, 85, 85, 84, 85, 84, 85, 85, 85,
85, 85, 85, 85, 85, 85, 85, 86, 86, 85, 85, 71, 67, 68, 67, 68, 67, 69, 68, 68,
68, 68, 68, 68, 68, 68, 69, 67, 69, 67, 70, 61, 49, 52, 51, 52, 50, 51, 51, 51,
51, 50, 51, 51, 51, 49, 52, 48, 33, 34, 34, 34, 35, 34, 33, 34, 35, 34, 33, 35,
34, 36, 22, 14, 18, 17, 19, 16, 18, 17, 18, 16, 17, 17, 18, 16, 0, -1, 1, 0, 0,
-1, 0, -1, 0, 0, 0, 1, -1, 2, -9, -19, -16, -17, -16, -17, -17, -17, -17, -17,
-17, -17, -18, -17, -18, -33, -34, -33, -34, -33, -34, -33, -34, -34, -34, -33,
-34, -34, -34, -34, -34, -49, -52, -51, -51, -51, -51, -50, -50, -51, -51, -51,
-50, -52, -51, -52, -51, -52, -50, -52, -68, -68, -68, -69, -67, -68, -67, -69,
-67, -68, -68, -68, -68, -69, -67, -68, -68, -68, -68, -69, -67, -69, -66, -71,
-86, -85, -84, -85, -85, -85, -84, -85, -85, -85, -85, -86, -85, -85, -85, -85,
-85, -85, -85, -86, -85, -84, -85, -84, -84, -85, -85, -86, -84, -84, -84, -85,
-85, -86, -85, -86, -86, -85, -85, -85, -85, -85, -85, -85, -85, -84, -86, -83,
-94, -105, -101, -102, -101, -102, -101, -102, -102, -103, -102, -102, -102,
-102, -102, -101, -103, -101, -103, -100, -103, -98, -83, -86, -84, -85, -85,
-85, -85, -85, -85, -85, -85, -85, -85, -85, -85, -85, -85, -85, -85, -85, -85,
-85, -85, -84, -85, -85, -85, -85, -85, -85, -85, -84, -85, -85, -84, -85, -85,
-85, -85, -85, -85, -85, -85, -85, -84, -86, -84, -87, -75, -65, -69, -67, -68,
-68, -68, -69, -68, -68, -68, -69, -69, -68, -68, -69, -68, -68, -68, -69, -68,
-69, -67, -68, -68, -69, -65, -50, -50, -52, -51, -51, -51, -51, -50, -51, -50,
-51, -50, -51, -50, -51, -51, -51, -51, -50, -52, -39, -33, -35, -33, -34, -34,
-35, -34, -34, -34, -34, -34, -34, -34, -35, -33, -36, -23, -16, -17, -17, -18,
-16, -18, -17, -17, -17, -17, -18, -16, -18, -15, };