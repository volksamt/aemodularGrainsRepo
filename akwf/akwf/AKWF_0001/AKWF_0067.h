#define DATA_LENGTH 512
#define DATA AKWF_0067

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 6, 8, 9, 11, 12, 15, 17, 18, 20,
20, 22, 23, 24, 25, 27, 28, 29, 30, 31, 30, 32, 32, 34, 35, 34, 36, 37, 36, 37,
37, 38, 39, 39, 39, 40, 40, 40, 40, 41, 41, 42, 42, 42, 42, 42, 43, 43, 43, 43,
43, 44, 44, 43, 44, 44, 44, 44, 44, 45, 44, 44, 44, 45, 45, 46, 45, 45, 45, 46,
45, 45, 45, 46, 46, 45, 46, 46, 46, 46, 45, 46, 46, 46, 46, 46, 46, 46, 46, 45,
46, 45, 47, 46, 47, 46, 47, 46, 46, 46, 45, 46, 45, 47, 46, 47, 47, 46, 46, 45,
46, 46, 46, 46, 47, 46, 46, 47, 47, 45, 46, 47, 46, 47, 46, 46, 47, 47, 47, 46,
47, 46, 46, 47, 47, 46, 46, 46, 46, 46, 46, 47, 47, 46, 47, 47, 47, 46, 46, 46,
46, 46, 46, 46, 46, 46, 46, 47, 47, 46, 46, 46, 46, 47, 47, 47, 47, 47, 46, 46,
46, 46, 47, 46, 46, 46, 46, 46, 46, 47, 46, 47, 47, 47, 46, 46, 47, 46, 46, 47,
46, 47, 47, 47, 46, 46, 47, 46, 47, 46, 46, 47, 47, 46, 46, 46, 46, 46, 46, 46,
47, 46, 46, 46, 46, 47, 47, 46, 46, 47, 47, 47, 47, 46, 46, 47, 46, 47, 46, 46,
46, 47, 46, 45, 47, 47, 46, 46, 46, 47, 47, 46, 44, 40, 36, 32, 28, 24, 19, 16,
13, 10, 7, 5, 2, -1, -3, -5, -7, -9, -11, -13, -15, -16, -19, -19, -21, -22,
-24, -25, -26, -27, -28, -29, -30, -31, -31, -32, -32, -33, -34, -35, -36, -36,
-37, -37, -37, -38, -39, -39, -39, -39, -40, -40, -41, -41, -41, -42, -41, -42,
-42, -42, -43, -43, -43, -44, -44, -44, -43, -44, -44, -44, -44, -44, -44, -45,
-45, -44, -45, -45, -45, -44, -45, -46, -45, -46, -46, -45, -45, -46, -45, -46,
-46, -47, -46, -46, -46, -46, -46, -46, -45, -46, -45, -45, -46, -46, -46, -46,
-46, -46, -46, -46, -47, -47, -46, -46, -46, -46, -46, -46, -45, -46, -47, -47,
-46, -47, -45, -46, -47, -46, -46, -45, -46, -46, -47, -47, -46, -46, -47, -46,
-46, -46, -47, -46, -46, -46, -47, -47, -46, -46, -47, -47, -47, -47, -47, -46,
-46, -46, -46, -46, -47, -46, -46, -46, -46, -46, -46, -46, -45, -46, -46, -47,
-47, -46, -46, -46, -46, -47, -47, -47, -47, -46, -46, -47, -47, -46, -46, -47,
-47, -45, -46, -46, -46, -47, -46, -46, -46, -46, -46, -47, -46, -46, -47, -46,
-47, -47, -46, -46, -47, -46, -46, -46, -46, -47, -46, -46, -46, -46, -46, -47,
-46, -47, -46, -46, -46, -46, -46, -46, -47, -46, -46, -46, -47, -46, -47, -47,
-47, -46, -46, -46, -46, -46, -47, -46, -47, -46, -46, -47, -46, -47, -47, -47,
-46, -46, -46, -46, -46, -46, -44, -40, -35, -31, -28, -22, -20, -16, -13, -10,
-8, -4, -2, };