#define DATA_LENGTH 512
#define DATA AKWF_0038

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 11, 14, 16, 18, 21, 22, 25,
25, 28, 29, 30, 31, 32, 32, 32, 32, 32, 32, 32, 30, 31, 29, 29, 28, 27, 26, 24,
23, 22, 22, 22, 20, 20, 19, 19, 19, 19, 19, 19, 19, 20, 22, 23, 24, 25, 27, 30,
32, 34, 36, 39, 41, 44, 47, 50, 53, 57, 59, 63, 65, 68, 71, 74, 76, 79, 82, 84,
86, 88, 90, 91, 92, 94, 95, 95, 96, 96, 95, 97, 96, 95, 94, 94, 93, 91, 90, 89,
88, 87, 85, 83, 81, 81, 78, 77, 76, 75, 74, 73, 72, 72, 71, 70, 71, 71, 72, 71,
72, 73, 75, 75, 77, 79, 80, 81, 84, 86, 88, 91, 92, 95, 98, 99, 101, 104, 106,
108, 110, 111, 113, 114, 115, 116, 118, 118, 118, 119, 119, 119, 119, 118, 117,
116, 114, 113, 111, 110, 107, 105, 103, 101, 99, 96, 94, 91, 89, 86, 84, 81, 80,
78, 75, 74, 71, 70, 69, 67, 67, 66, 65, 64, 65, 65, 64, 65, 66, 66, 67, 67, 68,
70, 71, 72, 74, 74, 76, 77, 79, 80, 81, 82, 83, 83, 84, 84, 85, 85, 85, 85, 85,
84, 83, 82, 80, 79, 77, 75, 73, 71, 69, 66, 63, 60, 57, 55, 51, 48, 45, 41, 38,
36, 32, 30, 26, 23, 21, 17, 16, 13, 12, 9, 7, 6, 5, 4, 3, 2, 1, 2, 1, 2, 1, 3,
2, 3, 4, 4, 5, 7, 7, 8, 9, 10, 11, 12, 12, 12, 13, 13, 13, 12, 12, 13, 12, 10,
9, 7, 6, 4, 3, 1, -2, -4, -7, -9, -13, -16, -19, -21, -25, -28, -31, -33, -38,
-40, -43, -47, -50, -52, -55, -58, -60, -62, -64, -65, -68, -68, -70, -70, -71,
-72, -72, -72, -72, -71, -71, -70, -70, -68, -68, -66, -66, -63, -63, -61, -60,
-59, -58, -56, -56, -55, -54, -54, -53, -54, -53, -53, -54, -53, -54, -55, -56,
-57, -58, -60, -62, -64, -66, -68, -70, -72, -74, -77, -79, -82, -85, -88, -91,
-92, -95, -97, -99, -102, -103, -105, -106, -108, -110, -111, -111, -112, -113,
-112, -113, -112, -112, -111, -110, -109, -108, -106, -105, -102, -101, -99,
-98, -96, -93, -91, -90, -88, -85, -84, -82, -80, -78, -77, -75, -74, -73, -73,
-72, -71, -71, -72, -72, -72, -72, -73, -74, -75, -76, -78, -80, -81, -83, -85,
-87, -88, -88, -91, -93, -94, -96, -97, -99, -100, -101, -102, -102, -103, -104,
-104, -104, -104, -102, -102, -101, -100, -99, -97, -96, -94, -92, -90, -88,
-84, -82, -79, -76, -75, -71, -68, -65, -63, -61, -58, -55, -53, -50, -48, -46,
-44, -43, -41, -40, -39, -38, -37, -37, -36, -36, -36, -35, -37, -37, -38, -38,
-40, -40, -41, -43, -44, -44, -46, -47, -48, -49, -50, -50, -51, -52, -52, -53,
-52, -52, -52, -51, -51, -50, -48, -48, -46, -44, -41, -39, -37, -34, -31, -28,
-25, -23, -20, -16, -14, -10, -7, -4, -1, };