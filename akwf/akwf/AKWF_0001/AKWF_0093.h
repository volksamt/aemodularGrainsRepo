#define DATA_LENGTH 512
#define DATA AKWF_0093

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 3, 6, 7, 9, 10, 11, 13, 15, 16,
18, 19, 21, 22, 23, 24, 26, 27, 29, 30, 31, 33, 34, 36, 37, 39, 40, 41, 42, 43,
45, 46, 47, 48, 50, 51, 52, 53, 54, 56, 56, 57, 58, 61, 61, 62, 63, 63, 65, 66,
67, 67, 68, 69, 71, 71, 72, 72, 73, 74, 75, 76, 76, 77, 78, 79, 78, 80, 80, 81,
81, 82, 82, 83, 83, 84, 84, 85, 85, 86, 86, 86, 87, 87, 87, 87, 89, 88, 88, 88,
89, 89, 89, 88, 89, 89, 89, 90, 89, 91, 91, 91, 92, 94, 95, 96, 95, 97, 98, 99,
100, 102, 102, 102, 105, 105, 106, 106, 107, 108, 108, 109, 110, 111, 111, 112,
113, 114, 114, 114, 114, 116, 116, 117, 117, 117, 117, 118, 118, 119, 119, 119,
119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 118, 118, 118, 119, 118, 118,
117, 117, 117, 116, 116, 115, 115, 114, 114, 112, 113, 112, 111, 111, 110, 110,
108, 108, 108, 106, 106, 104, 104, 103, 101, 102, 100, 99, 98, 97, 96, 95, 94,
92, 91, 90, 89, 87, 87, 85, 84, 84, 82, 80, 79, 78, 76, 76, 74, 73, 72, 70, 68,
66, 66, 65, 63, 62, 60, 58, 56, 54, 53, 52, 51, 50, 47, 46, 44, 43, 42, 39, 38,
37, 35, 34, 32, 31, 29, 26, 25, 24, 23, 20, 19, 18, 16, 15, 13, 11, 10, 8, 7, 5,
4, 3, 0, -1, -2, -5, -5, -7, -8, -11, -12, -14, -15, -16, -18, -19, -20, -22,
-24, -26, -26, -28, -30, -31, -32, -33, -35, -36, -37, -39, -40, -41, -43, -43,
-44, -47, -48, -49, -50, -51, -52, -54, -55, -56, -57, -58, -59, -60, -62, -62,
-64, -64, -65, -65, -67, -68, -68, -69, -70, -71, -72, -73, -74, -74, -75, -76,
-77, -77, -78, -79, -79, -80, -81, -81, -82, -82, -82, -83, -83, -84, -85, -84,
-86, -86, -87, -86, -87, -88, -87, -87, -88, -88, -88, -88, -89, -88, -89, -88,
-89, -89, -89, -89, -90, -90, -90, -92, -93, -94, -94, -96, -96, -98, -99, -99,
-101, -101, -102, -104, -104, -105, -107, -107, -108, -108, -110, -109, -111,
-111, -112, -113, -113, -114, -113, -114, -115, -115, -116, -116, -116, -117,
-117, -117, -118, -118, -118, -118, -119, -119, -118, -119, -118, -119, -119,
-120, -119, -119, -119, -118, -119, -118, -117, -118, -117, -117, -116, -117,
-115, -115, -114, -115, -114, -113, -112, -112, -111, -110, -110, -110, -108,
-108, -107, -106, -105, -104, -104, -103, -102, -101, -100, -99, -98, -97, -96,
-95, -93, -93, -91, -90, -90, -87, -86, -86, -84, -83, -82, -80, -79, -78, -76,
-76, -74, -72, -71, -70, -69, -67, -66, -64, -62, -61, -60, -58, -57, -55, -54,
-52, -50, -50, -47, -45, -44, -42, -42, -40, -38, -36, -35, -33, -32, -30, -29,
-27, -25, -24, -23, -21, -20, -18, -16, -14, -13, -11, -9, -8, -7, -5, -3, -2,
-1, };