#define DATA_LENGTH 512
#define DATA AKWF_0084

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 12, 16, 18, 21, 24, 27,
30, 32, 33, 35, 37, 39, 41, 42, 43, 44, 45, 46, 45, 46, 46, 46, 47, 46, 46, 46,
46, 45, 45, 46, 44, 44, 43, 44, 44, 44, 44, 45, 46, 47, 47, 48, 49, 50, 52, 54,
57, 60, 61, 64, 67, 70, 73, 76, 79, 82, 86, 88, 93, 96, 99, 102, 105, 108, 109,
112, 113, 116, 116, 117, 119, 117, 117, 118, 116, 115, 113, 112, 109, 106, 103,
100, 96, 92, 88, 83, 79, 74, 69, 64, 59, 54, 49, 44, 40, 34, 30, 26, 21, 17, 12,
9, 6, 3, 1, -1, -3, -4, -5, -5, -6, -7, -5, -5, -3, -3, -1, 1, 3, 5, 7, 9, 12,
14, 17, 19, 21, 24, 25, 28, 29, 31, 33, 33, 34, 36, 36, 36, 35, 36, 35, 32, 32,
30, 28, 25, 23, 19, 17, 14, 10, 8, 4, 1, -3, -6, -9, -12, -16, -18, -21, -23,
-26, -28, -30, -31, -33, -33, -36, -36, -35, -36, -36, -35, -35, -32, -32, -31,
-30, -27, -26, -25, -23, -21, -19, -16, -15, -13, -12, -10, -10, -9, -7, -6, -4,
-5, -5, -4, -5, -5, -6, -7, -7, -10, -11, -14, -15, -17, -20, -23, -27, -30,
-34, -36, -40, -44, -48, -51, -55, -59, -63, -66, -69, -73, -76, -79, -80, -84,
-86, -87, -88, -90, -90, -91, -92, -92, -91, -89, -89, -88, -86, -84, -82, -80,
-76, -75, -72, -70, -66, -63, -60, -57, -53, -50, -47, -44, -41, -37, -35, -33,
-30, -28, -26, -24, -22, -21, -19, -18, -16, -16, -15, -14, -14, -14, -14, -14,
-14, -14, -15, -16, -16, -16, -17, -17, -18, -19, -19, -19, -20, -20, -21, -20,
-20, -20, -19, -18, -17, -17, -15, -13, -12, -10, -9, -7, -4, -3, 0, 2, 4, 6, 9,
11, 14, 16, 18, 21, 24, 26, 27, 30, 31, 33, 34, 36, 37, 38, 38, 38, 39, 38, 38,
37, 37, 36, 35, 33, 32, 29, 28, 26, 23, 21, 19, 16, 12, 9, 6, 3, 0, -4, -7, -9,
-12, -16, -18, -20, -23, -26, -27, -29, -30, -31, -32, -33, -34, -34, -35, -35,
-34, -34, -34, -33, -32, -31, -29, -28, -26, -25, -22, -20, -19, -17, -15, -14,
-12, -10, -9, -8, -6, -5, -5, -4, -4, -4, -3, -4, -4, -5, -6, -7, -9, -10, -12,
-14, -16, -17, -21, -23, -26, -28, -31, -33, -36, -39, -41, -42, -45, -47, -49,
-51, -52, -53, -54, -55, -55, -56, -55, -55, -54, -52, -51, -49, -48, -44, -43,
-40, -37, -34, -31, -28, -25, -21, -17, -15, -11, -8, -5, -2, 1, 4, 6, 8, 10,
12, 15, 16, 17, 18, 18, 18, 18, 17, 17, 16, 15, 13, 12, 10, 7, 6, 4, 1, -2, -4,
-7, -9, -12, -15, -17, -19, -21, -23, -26, -28, -28, -30, -31, -32, -33, -33,
-34, -34, -33, -32, -31, -30, -28, -27, -26, -24, -20, -19, -16, -14, -11, -8,
-5, -2, };