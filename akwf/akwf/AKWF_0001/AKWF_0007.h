#define DATA_LENGTH 512
#define DATA AKWF_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 4, 6, 7, 8, 10, 11, 12,
14, 16, 18, 18, 20, 22, 24, 26, 28, 30, 32, 34, 36, 37, 39, 42, 44, 46, 48, 49,
52, 54, 56, 58, 59, 62, 64, 66, 67, 69, 70, 73, 75, 75, 78, 79, 80, 82, 83, 84,
86, 88, 89, 90, 91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 101, 102, 102, 103,
104, 104, 104, 105, 106, 106, 106, 107, 108, 108, 108, 108, 108, 109, 110, 109,
110, 111, 111, 111, 112, 111, 112, 111, 112, 113, 113, 112, 112, 112, 112, 113,
114, 113, 114, 113, 114, 113, 114, 113, 114, 113, 113, 114, 114, 115, 114, 114,
115, 113, 114, 114, 115, 114, 114, 115, 114, 114, 115, 115, 114, 115, 115, 115,
115, 115, 115, 115, 115, 116, 116, 115, 116, 116, 116, 117, 116, 116, 117, 116,
117, 117, 116, 116, 117, 117, 116, 116, 117, 115, 116, 115, 116, 115, 114, 114,
114, 114, 114, 113, 113, 112, 112, 112, 111, 110, 109, 109, 109, 108, 106, 106,
105, 104, 103, 102, 102, 100, 99, 98, 97, 96, 95, 92, 92, 90, 88, 88, 87, 85,
83, 82, 80, 80, 78, 76, 75, 72, 72, 70, 68, 67, 65, 63, 61, 60, 59, 57, 55, 54,
52, 51, 49, 48, 45, 44, 42, 41, 39, 37, 35, 34, 33, 30, 28, 27, 26, 24, 23, 22,
19, 19, 17, 16, 14, 12, 11, 9, 9, 8, 6, 5, 3, 4, 3, 1, -1, -1, -1, -2, -2, -4,
-5, -7, -8, -9, -11, -13, -15, -16, -17, -19, -21, -23, -25, -27, -29, -31, -32,
-35, -35, -38, -40, -42, -44, -45, -48, -50, -52, -54, -57, -58, -60, -62, -64,
-65, -68, -68, -70, -73, -75, -76, -78, -79, -80, -83, -84, -85, -87, -88, -88,
-90, -91, -93, -93, -94, -95, -97, -98, -98, -99, -100, -100, -102, -102, -103,
-103, -104, -105, -105, -106, -106, -106, -108, -107, -108, -109, -108, -109,
-109, -110, -110, -111, -110, -110, -112, -111, -111, -112, -112, -112, -112,
-111, -113, -113, -112, -112, -113, -113, -114, -113, -113, -113, -114, -113,
-113, -114, -114, -114, -114, -114, -114, -114, -113, -114, -114, -114, -114,
-114, -114, -114, -114, -114, -114, -114, -115, -114, -114, -115, -115, -115,
-115, -115, -115, -116, -116, -116, -116, -116, -116, -117, -116, -116, -116,
-117, -116, -117, -117, -117, -115, -117, -116, -116, -116, -116, -116, -115,
-115, -115, -116, -114, -114, -114, -114, -114, -114, -113, -112, -112, -112,
-111, -109, -110, -108, -108, -108, -107, -106, -104, -104, -103, -103, -101,
-100, -99, -98, -96, -95, -94, -93, -92, -90, -89, -87, -87, -85, -83, -81, -81,
-79, -77, -76, -75, -72, -72, -69, -68, -66, -64, -63, -62, -60, -58, -57, -56,
-54, -52, -50, -48, -46, -45, -43, -41, -40, -38, -37, -36, -33, -32, -30, -28,
-27, -26, -24, -22, -21, -20, -19, -17, -15, -15, -12, -11, -9, -8, -8, -6, -5,
-4, -3, -2, -1, 0, };