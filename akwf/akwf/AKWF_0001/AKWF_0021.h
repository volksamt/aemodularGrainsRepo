#define DATA_LENGTH 512
#define DATA AKWF_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, -3, -5, -7, -8, -11, -13, -15,
-17, -20, -22, -24, -26, -28, -30, -33, -36, -38, -40, -43, -46, -47, -50, -52,
-54, -57, -59, -62, -63, -65, -68, -69, -71, -73, -74, -77, -78, -79, -80, -82,
-84, -85, -86, -87, -88, -88, -89, -91, -91, -92, -93, -94, -95, -95, -96, -97,
-98, -98, -99, -100, -100, -102, -102, -103, -103, -103, -105, -105, -107, -107,
-108, -109, -110, -110, -111, -112, -113, -114, -114, -116, -115, -116, -117,
-117, -118, -118, -118, -119, -118, -119, -119, -120, -119, -118, -119, -119,
-119, -118, -118, -117, -116, -116, -115, -114, -113, -112, -111, -110, -109,
-108, -108, -106, -105, -104, -104, -103, -102, -100, -99, -99, -99, -97, -98,
-98, -96, -96, -96, -96, -96, -97, -97, -96, -97, -97, -98, -99, -99, -100,
-100, -100, -101, -102, -101, -102, -103, -103, -103, -104, -104, -104, -103,
-104, -104, -103, -103, -103, -103, -102, -101, -101, -100, -100, -99, -98, -97,
-96, -95, -93, -92, -90, -90, -89, -87, -86, -85, -83, -82, -80, -79, -77, -76,
-75, -73, -72, -71, -70, -68, -67, -66, -65, -64, -62, -61, -60, -60, -58, -56,
-56, -55, -54, -53, -53, -52, -50, -49, -48, -47, -46, -45, -44, -42, -41, -40,
-38, -36, -34, -32, -30, -28, -26, -24, -21, -18, -16, -13, -10, -7, -5, -1, 1,
5, 7, 10, 13, 17, 19, 22, 25, 27, 30, 32, 35, 38, 39, 42, 43, 45, 47, 48, 50,
51, 52, 53, 54, 54, 55, 55, 56, 57, 57, 57, 58, 59, 59, 59, 59, 59, 59, 61, 60,
61, 61, 61, 61, 61, 63, 62, 63, 64, 66, 66, 66, 68, 68, 69, 71, 72, 73, 75, 74,
76, 77, 79, 79, 81, 82, 84, 85, 86, 86, 88, 90, 90, 91, 91, 93, 93, 93, 94, 94,
95, 96, 96, 96, 95, 95, 96, 95, 95, 95, 94, 94, 92, 91, 91, 90, 90, 90, 90, 88,
87, 86, 87, 86, 85, 84, 84, 84, 82, 82, 82, 82, 82, 81, 80, 81, 81, 81, 81, 81,
81, 82, 82, 82, 82, 83, 82, 83, 83, 84, 84, 84, 85, 85, 85, 85, 85, 85, 86, 86,
85, 86, 85, 85, 86, 85, 84, 84, 83, 82, 82, 81, 81, 82, 80, 80, 79, 78, 78, 78,
78, 77, 76, 77, 76, 75, 75, 75, 75, 74, 74, 74, 74, 73, 74, 74, 73, 73, 73, 73,
73, 74, 73, 74, 74, 74, 75, 74, 75, 76, 75, 75, 76, 75, 76, 76, 76, 76, 76, 76,
75, 75, 76, 76, 75, 75, 74, 73, 74, 73, 72, 73, 71, 70, 70, 69, 68, 68, 67, 65,
65, 63, 63, 62, 60, 60, 59, 58, 57, 56, 55, 54, 53, 53, 50, 50, 49, 48, 48, 46,
46, 45, 44, 43, 42, 42, 41, 40, 39, 38, 38, 37, 36, 35, 34, 34, 33, 32, 31, 30,
30, 28, 28, 27, 26, 25, 24, 22, 22, 19, 19, 18, 16, 14, 13, 11, 10, 9, 6, 4, 3,
1, };