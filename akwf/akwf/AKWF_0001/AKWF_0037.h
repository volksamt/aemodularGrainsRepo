#define DATA_LENGTH 512
#define DATA AKWF_0037

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 10, 13, 15, 20, 21, 24, 27, 30,
33, 35, 36, 39, 42, 44, 45, 48, 49, 52, 52, 55, 56, 57, 59, 61, 60, 62, 62, 64,
64, 65, 64, 64, 64, 64, 62, 61, 61, 59, 58, 56, 55, 54, 51, 50, 47, 46, 45, 43,
41, 40, 38, 37, 34, 34, 32, 30, 28, 26, 25, 24, 23, 21, 20, 18, 17, 15, 13, 12,
10, 9, 8, 7, 6, 5, 3, 3, 2, 2, 2, 2, 1, 2, 2, 2, 4, 4, 6, 6, 9, 10, 11, 13, 15,
16, 18, 20, 22, 23, 25, 26, 29, 30, 32, 34, 36, 38, 40, 42, 44, 46, 48, 51, 54,
56, 59, 62, 64, 67, 69, 73, 76, 78, 81, 84, 86, 88, 91, 94, 96, 98, 99, 101,
104, 105, 106, 108, 109, 110, 112, 112, 113, 115, 115, 115, 116, 116, 118, 119,
118, 119, 119, 119, 119, 119, 119, 118, 117, 117, 115, 114, 113, 111, 110, 107,
105, 103, 100, 98, 96, 93, 90, 87, 84, 82, 79, 76, 74, 71, 68, 66, 63, 60, 58,
56, 52, 50, 48, 45, 43, 40, 37, 34, 32, 29, 25, 22, 19, 17, 14, 11, 8, 6, 2, 1,
-3, -4, -6, -9, -11, -13, -13, -16, -17, -18, -19, -19, -21, -21, -22, -22, -22,
-22, -23, -23, -23, -23, -23, -23, -24, -24, -24, -24, -24, -23, -23, -23, -22,
-22, -21, -19, -18, -18, -17, -15, -14, -12, -11, -9, -7, -6, -4, -3, 0, 1, 3,
3, 5, 6, 7, 9, 10, 10, 12, 11, 13, 13, 13, 14, 15, 14, 16, 15, 16, 16, 17, 16,
18, 17, 17, 18, 18, 16, 16, 17, 16, 16, 16, 14, 13, 13, 11, 11, 9, 7, 6, 4, 2,
0, -1, -3, -5, -6, -9, -10, -12, -13, -15, -17, -18, -20, -21, -22, -24, -25,
-26, -28, -29, -31, -33, -34, -35, -36, -38, -40, -41, -44, -44, -45, -47, -48,
-49, -51, -52, -53, -54, -54, -55, -54, -54, -54, -54, -54, -53, -52, -52, -52,
-51, -50, -50, -49, -49, -48, -48, -47, -46, -46, -46, -46, -45, -45, -45, -45,
-44, -42, -44, -42, -42, -41, -40, -39, -39, -38, -37, -35, -35, -34, -33, -31,
-31, -29, -29, -28, -27, -27, -27, -25, -25, -25, -25, -25, -24, -25, -24, -25,
-25, -25, -25, -26, -25, -26, -25, -26, -26, -26, -26, -26, -26, -26, -27, -27,
-28, -29, -29, -30, -31, -32, -33, -35, -36, -38, -39, -42, -43, -45, -47, -49,
-52, -54, -56, -58, -60, -61, -64, -66, -67, -69, -71, -73, -74, -76, -77, -79,
-81, -82, -83, -85, -86, -88, -90, -90, -93, -95, -96, -97, -98, -100, -101,
-102, -103, -104, -106, -106, -106, -107, -106, -107, -106, -105, -104, -103,
-103, -101, -101, -100, -98, -96, -94, -92, -90, -89, -87, -85, -83, -81, -79,
-77, -75, -73, -70, -68, -66, -63, -60, -58, -54, -51, -48, -44, -41, -38, -34,
-31, -27, -23, -19, -14, -11, -7, -3, 0, };