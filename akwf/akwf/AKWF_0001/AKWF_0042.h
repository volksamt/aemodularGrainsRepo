#define DATA_LENGTH 512
#define DATA AKWF_0042

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 0, 0, 1, 2, 2, 2, 2, 2, 2, 4, 3,
4, 5, 5, 5, 6, 5, 6, 6, 7, 7, 8, 8, 9, 9, 9, 9, 10, 10, 11, 11, 12, 12, 13, 14,
13, 13, 14, 14, 16, 15, 16, 16, 17, 17, 18, 18, 18, 20, 19, 20, 20, 21, 21, 21,
22, 23, 23, 23, 24, 24, 25, 25, 25, 26, 26, 27, 27, 28, 28, 29, 28, 29, 30, 30,
31, 31, 32, 32, 32, 32, 33, 34, 34, 35, 34, 34, 35, 36, 36, 36, 37, 37, 37, 38,
38, 38, 39, 39, 40, 40, 41, 41, 41, 41, 42, 42, 42, 43, 44, 44, 45, 45, 45, 45,
45, 47, 46, 47, 47, 46, 48, 48, 48, 48, 49, 49, 50, 50, 50, 50, 51, 51, 52, 51,
52, 52, 52, 53, 53, 54, 53, 54, 54, 55, 56, 56, 57, 56, 57, 57, 57, 58, 58, 59,
58, 59, 60, 59, 60, 60, 60, 61, 61, 62, 62, 62, 63, 63, 62, 63, 63, 65, 64, 65,
65, 65, 66, 66, 67, 67, 67, 68, 68, 68, 69, 70, 70, 70, 69, 70, 71, 71, 72, 72,
71, 72, 73, 73, 73, 73, 74, 75, 75, 75, 75, 76, 76, 76, 76, 77, 77, 78, 78, 78,
78, 78, 77, 77, 77, 77, 76, 76, 76, 75, 74, 73, 73, 73, 71, 70, 69, 68, 67, 66,
64, 63, 60, 59, 58, 57, 54, 53, 50, 48, 47, 45, 43, 41, 37, 35, 32, 30, 29, 25,
23, 20, 17, 14, 12, 9, 6, 3, -1, -2, -6, -9, -11, -14, -17, -21, -24, -27, -30,
-33, -36, -39, -41, -45, -47, -50, -54, -56, -59, -61, -63, -67, -69, -71, -74,
-78, -79, -82, -83, -86, -88, -91, -92, -93, -96, -98, -100, -102, -103, -104,
-106, -107, -109, -109, -110, -112, -113, -114, -115, -115, -116, -117, -118,
-118, -119, -118, -119, -119, -119, -119, -119, -119, -119, -118, -118, -118,
-117, -117, -117, -116, -114, -114, -114, -113, -111, -111, -110, -109, -108,
-106, -105, -105, -103, -101, -101, -100, -97, -97, -94, -94, -92, -91, -89,
-88, -85, -85, -83, -81, -80, -78, -77, -75, -73, -72, -70, -68, -67, -66, -64,
-63, -61, -60, -57, -55, -55, -54, -51, -50, -49, -47, -46, -44, -43, -42, -40,
-39, -37, -36, -35, -34, -33, -31, -31, -29, -29, -27, -26, -25, -24, -23, -22,
-21, -20, -20, -18, -18, -17, -16, -16, -14, -14, -14, -13, -13, -12, -11, -11,
-10, -10, -8, -8, -9, -8, -8, -8, -7, -7, -7, -6, -6, -6, -5, -5, -5, -4, -5,
-5, -4, -4, -4, -4, -4, -4, -4, -4, -3, -5, -4, -3, -3, -4, -5, -4, -4, -4, -4,
-4, -3, -3, -3, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -3, -3, -4, -4, -5,
-3, -4, -4, -4, -4, -4, -4, -4, -4, -3, -3, -4, -3, -3, -3, -2, -3, -2, -2, -2,
-2, -2, -1, -1, 0, 0, 0, -1, -1, };