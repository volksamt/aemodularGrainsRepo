#define DATA_LENGTH 512
#define DATA AKWF_0029

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 3, 3, 3, 3, 4, 4, 3, 4, 3, 3,
3, 2, 2, 2, 2, 2, 1, 1, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0, 1, 1, 0,
1, 0, 0, 1, 1, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, -1, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 1, -1, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0,
0, 0, -12, -35, 2, 31, 4, 1, 7, 11, 10, 8, 6, 4, 2, 0, -3, -5, -8, -10, -10,
-10, -9, -7, -4, -3, -1, 1, 3, 3, 5, 5, 5, 4, 5, 4, 3, 2, 1, 0, 0, -1, -1, -1,
-2, -2, -2, -1, -1, -1, -1, -1, 0, 0, -1, 0, 0, 0, 1, 0, 0, 1, 0, -1, 0, 0, 1,
0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 14, 19, 4, 5, 9, 6, 3, 3, 2, 2, 3, 3, 3,
3, 3, 2, 2, 1, 1, 0, 0, 0, 0, -2, -2, -1, -1, -3, -2, -2, -2, -2, -1, -3, -2,
-3, -1, -3, -2, -3, -1, -3, -2, -3, -1, -3, -1, -2, 0, -3, 44, 127, 3, -51, 18,
-2, -7, -19, -17, -16, -10, -9, -5, -3, 0, 3, 6, 8, 7, 7, 5, 3, 0, -2, -3, -5,
-8, -9, -10, -8, -10, -9, -8, -6, -7, -5, -4, -3, -2, -2, -1, -2, 0, -1, -1, -1,
-1, 0, 0, -1, -1, 0, 0, -2, -1, -1, -1, -1, -1, -2, -1, -1, -1, -1, -1, -1, 0,
0, -1, -1, -1, -1, -1, -1, -1, -1, 0, 0, 0, 0, 0, 0, -1, -1, -1, 0, 0, -1, 0, 0,
0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0,
0, -1, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, -15, -35, 9, 28, 1, 2, 6, 10, 10, 9, 6,
3, 2, 1, -3, -6, -8, -11, -10, -11, -9, -7, -5, -3, 0, 1, 3, 4, 5, 5, 5, 4, 5,
3, 3, 2, 2, 0, -1, -1, -1, -1, -2, -1, -2, -1, -1, -1, -1, -1, -1, -1, 0, 0, 0,
1, 1, 0, 0, 0, 0, 1, 0, 0, -1, 0, 1, 0, 0, 0, 0, -1, 1, 1, 0, 0, 0, -3, -16,
-16, -2, -6, -10, -5, -3, -3, -2, -3, -2, -3, -2, -2, -3, -2, -2, -2, -1, -1,
-1, 0, 1, 1, 1, 2, 1, 2, 2, 3, 3, 2, 2, 2, 2, 2, 2, 3, 1, 3, 2, 2, 2, 3, 2, 2,
2, 2, 1, 2, -3, -8, -18, -55, -48, -14, -6, -6, -4, -1, 2, 3, 4, 6, 8, 12, 12,
15, 15, 15, 12, 12, 9, 6, 4, 3, 1, 0, -1, -1, -1, -2, -1, 0, };