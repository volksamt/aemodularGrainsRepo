#define DATA_LENGTH 512
#define DATA AKWF_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 12, 19, 25, 31, 37, 44, 50, 56, 62,
66, 71, 76, 81, 86, 90, 93, 96, 99, 103, 106, 108, 110, 112, 113, 114, 116, 118,
119, 120, 119, 118, 118, 118, 118, 116, 116, 114, 112, 110, 106, 104, 101, 98,
94, 91, 88, 84, 78, 74, 69, 64, 58, 53, 48, 43, 37, 32, 25, 20, 13, 8, 2, -2,
-8, -13, -18, -23, -28, -33, -37, -41, -45, -49, -53, -57, -59, -62, -65, -66,
-69, -70, -73, -74, -76, -76, -78, -79, -80, -81, -81, -81, -83, -82, -82, -82,
-82, -83, -82, -80, -80, -80, -79, -77, -75, -73, -71, -69, -67, -65, -62, -60,
-57, -55, -51, -48, -46, -43, -39, -35, -32, -28, -24, -21, -18, -13, -10, -5,
-2, 1, 4, 7, 11, 13, 17, 20, 23, 25, 27, 30, 32, 34, 36, 37, 38, 39, 40, 41, 42,
43, 43, 44, 45, 44, 44, 44, 44, 44, 43, 43, 42, 42, 40, 39, 40, 39, 38, 37, 36,
34, 34, 32, 31, 29, 28, 27, 26, 24, 22, 21, 19, 18, 18, 17, 14, 13, 10, 9, 6, 5,
2, 0, 0, -2, -3, -4, -5, -6, -7, -10, -11, -12, -16, -16, -17, -17, -17, -17,
-18, -17, -18, -21, -22, -23, -23, -23, -23, -23, -21, -19, -18, -17, -16, -16,
-14, -15, -14, -14, -14, -14, -14, -13, -13, -12, -9, -8, -6, -4, -3, -3, -3,
-3, -3, -2, -1, -2, 0, 2, 3, 5, 7, 8, 10, 11, 12, 11, 10, 10, 8, 8, 7, 6, 5, 6,
5, 5, 6, 5, 6, 5, 4, 4, 4, 3, 4, 4, 4, 4, 4, 2, 1, 1, -1, -3, -4, -5, -5, -6,
-5, -4, -3, -1, 2, 5, 8, 10, 13, 14, 16, 17, 18, 18, 18, 17, 16, 14, 13, 11, 9,
7, 4, 2, -1, -3, -6, -9, -12, -14, -17, -18, -19, -20, -18, -17, -14, -12, -10,
-9, -7, -5, -3, -2, 0, 1, 4, 6, 8, 9, 12, 13, 14, 14, 13, 13, 13, 12, 10, 10, 8,
5, 2, -2, -6, -10, -16, -22, -29, -36, -43, -49, -56, -63, -68, -72, -75, -76,
-77, -76, -74, -71, -67, -62, -57, -51, -45, -37, -30, -20, -11, -2, 7, 16, 24,
30, 38, 43, 48, 52, 56, 58, 59, 61, 62, 62, 61, 59, 58, 56, 52, 49, 46, 42, 39,
36, 32, 30, 26, 25, 24, 23, 23, 22, 24, 24, 26, 27, 30, 34, 38, 43, 49, 53, 59,
65, 70, 75, 80, 85, 88, 90, 93, 92, 92, 90, 86, 81, 75, 68, 62, 53, 44, 36, 27,
17, 8, -2, -11, -20, -29, -37, -46, -54, -61, -69, -75, -80, -85, -89, -92, -95,
-97, -97, -98, -99, -97, -96, -96, -93, -92, -90, -88, -86, -85, -83, -81, -80,
-80, -79, -79, -79, -79, -79, -80, -80, -81, -81, -83, -83, -84, -84, -84, -84,
-84, -83, -81, -80, -79, -75, -73, -69, -65, -60, -55, -51, -46, -40, -34, -28,
-21, -15, -8, -2, };