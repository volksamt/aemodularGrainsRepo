#define DATA_LENGTH 512
#define DATA AKWF_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 11, 18, 25, 33, 39, 46, 53, 60,
66, 72, 77, 82, 88, 91, 95, 98, 101, 104, 106, 108, 110, 112, 113, 114, 114,
114, 114, 113, 113, 113, 111, 110, 107, 105, 102, 100, 97, 93, 90, 86, 82, 77,
74, 69, 64, 59, 55, 50, 44, 39, 34, 30, 25, 20, 17, 12, 8, 6, 2, 0, -3, -5, -7,
-10, -12, -14, -17, -19, -19, -21, -22, -23, -24, -24, -24, -24, -24, -24, -23,
-23, -21, -22, -19, -19, -17, -16, -14, -13, -12, -11, -10, -8, -6, -5, -5, -3,
-1, 0, 0, 0, 1, 2, 4, 4, 4, 5, 5, 5, 6, 6, 7, 7, 5, 5, 6, 6, 4, 5, 4, 3, 3, 2,
1, 0, 0, 0, 0, -2, -3, -3, -3, -4, -4, -6, -5, -6, -6, -8, -7, -8, -8, -7, -8,
-7, -7, -7, -6, -5, -5, -4, -4, -3, -2, -1, 1, 2, 2, 4, 6, 7, 9, 11, 13, 15, 17,
19, 21, 24, 26, 27, 30, 32, 33, 36, 36, 38, 39, 41, 41, 42, 43, 42, 43, 43, 43,
43, 42, 40, 39, 38, 36, 35, 32, 31, 27, 26, 24, 21, 17, 14, 12, 9, 6, 3, 1, -1,
-4, -8, -11, -14, -17, -20, -25, -28, -31, -36, -38, -41, -45, -47, -49, -52,
-54, -56, -58, -58, -60, -61, -61, -60, -61, -61, -60, -59, -58, -57, -54, -52,
-50, -48, -46, -43, -39, -36, -32, -28, -25, -22, -18, -14, -11, -8, -4, -1, 2,
5, 8, 12, 15, 20, 24, 27, 31, 33, 37, 40, 44, 47, 49, 51, 53, 55, 55, 57, 59,
59, 59, 59, 59, 58, 58, 56, 55, 54, 52, 49, 47, 45, 43, 40, 37, 34, 31, 28, 25,
21, 18, 15, 12, 9, 6, 3, 1, -1, -3, -6, -9, -11, -13, -16, -19, -21, -24, -26,
-28, -30, -32, -33, -34, -35, -36, -36, -37, -37, -37, -37, -36, -36, -35, -35,
-33, -31, -31, -29, -27, -26, -24, -22, -20, -19, -17, -16, -13, -12, -11, -8,
-7, -7, -5, -3, -2, -1, 0, 0, 0, 2, 2, 2, 3, 3, 3, 3, 3, 4, 4, 4, 3, 3, 3, 2, 2,
2, 2, 2, 0, 0, -1, -2, -2, -2, -4, -5, -4, -6, -6, -6, -7, -8, -8, -10, -9, -9,
-10, -10, -9, -9, -9, -8, -8, -8, -6, -6, -5, -4, -3, -2, -1, 1, 1, 3, 4, 6, 8,
9, 11, 13, 15, 17, 19, 21, 24, 25, 28, 28, 30, 32, 33, 34, 35, 36, 36, 36, 36,
36, 35, 35, 34, 32, 31, 29, 28, 25, 22, 21, 17, 14, 12, 8, 5, 1, -1, -4, -9,
-13, -18, -22, -29, -34, -39, -45, -51, -57, -63, -67, -72, -77, -82, -86, -90,
-95, -98, -101, -104, -106, -110, -112, -114, -115, -116, -118, -119, -119,
-120, -119, -119, -118, -118, -116, -115, -112, -111, -108, -105, -102, -98,
-94, -89, -84, -79, -73, -66, -61, -53, -46, -38, -32, -25, -17, -11, -4, };