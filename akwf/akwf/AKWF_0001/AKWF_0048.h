#define DATA_LENGTH 512
#define DATA AKWF_0048

const PROGMEM int8_t DATA[DATA_LENGTH] = {105, 124, 115, 122, 117, 121, 116,
121, 117, 121, 118, 120, 117, 120, 118, 120, 119, 120, 119, 119, 119, 119, 120,
119, 120, 119, 119, 119, 120, 118, 120, 120, 120, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 120, 119, 119, 120, 119, 119, 119, 120, 118,
119, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
119, 119, 119, 118, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119,
119, 119, 120, 119, 120, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119,
119, 118, 120, 117, 120, 118, 121, 118, 120, 118, 120, 119, 120, 118, 119, 119,
118, 119, 117, 122, 115, 127, 106, 127, -32, -128, -104, -128, -111, -126, -114,
-123, -116, -123, -117, -120, -117, -120, -118, -120, -118, -119, -120, -119,
-119, -119, -120, -118, -119, -120, -110, 47, 127, 115, 122, 117, 120, 118, 120,
118, 119, 118, 120, 119, 120, 118, 119, 118, 119, 119, 119, 118, 119, 120, 119,
119, 119, 119, 119, 119, 119, 120, 119, 120, 118, 119, 119, 120, 119, 120, 118,
120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 120, 118, 121,
118, 121, 116, 122, 115, 123, 115, 123, 114, 126, 111, 127, 94, -124, -119,
-118, -121, -116, -122, -116, -124, -115, -123, -115, -124, -114, -126, -112,
-127, -4, 120, 119, 118, 120, 118, 120, 118, 119, 119, 119, 121, 116, 125, 107,
127, -45, -128, -104, -128, -111, -125, -114, -123, -115, -122, -116, -121,
-119, -120, -119, -119, -119, -119, -120, -118, -120, -118, -120, -118, -120,
-118, -119, -119, -120, -118, -119, -118, -120, -118, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -120, -118, -119, -118, -119, -118, -119, -118,
-119, -119, -119, -119, -119, -120, -118, -120, -118, -121, -117, -120, -118,
-122, -117, -122, -113, -127, -57, 102, 123, 117, 120, 118, 121, 118, 120, 119,
119, 120, 118, 120, 117, 121, 117, 122, 115, 123, 114, 125, 113, 126, 109, 127,
83, -128, -116, -119, -120, -118, -122, -117, -122, -116, -121, -117, -122,
-117, -122, -116, -122, -118, -120, -118, -119, -118, -120, -119, -119, -119,
-119, -119, -118, -120, -119, -119, -119, -120, -119, -119, -119, -120, -119,
-119, -118, -120, -119, -118, -119, -119, -119, -119, -120, -119, -118, -120,
-118, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -120, -118, -119, -120,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -118, -119, -119, -119, -120, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -118, -120, -118, -119,
-118, -119, -119, -119, -120, -119, -119, -119, -120, -118, -120, -119, -121,
-119, -120, -117, -120, -118, -121, -118, -120, -118, -121, -117, -122, -117,
-122, -114, -5, };