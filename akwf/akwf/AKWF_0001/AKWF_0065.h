#define DATA_LENGTH 512
#define DATA AKWF_0065

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 4, 7, 8, 9, 12, 13, 15, 16, 17,
19, 19, 20, 20, 21, 21, 22, 22, 24, 25, 26, 26, 28, 28, 29, 30, 31, 32, 33, 34,
36, 37, 38, 40, 41, 42, 45, 46, 48, 49, 50, 53, 54, 55, 56, 58, 60, 62, 64, 65,
66, 68, 69, 70, 71, 70, 71, 72, 71, 71, 72, 70, 71, 71, 71, 70, 71, 71, 71, 71,
71, 70, 71, 70, 71, 71, 71, 71, 71, 71, 71, 71, 71, 71, 71, 71, 71, 72, 70, 71,
71, 71, 71, 72, 71, 71, 70, 71, 71, 71, 71, 71, 71, 70, 71, 72, 70, 71, 71, 70,
72, 71, 71, 71, 70, 70, 71, 70, 69, 69, 68, 67, 66, 65, 64, 64, 62, 61, 62, 60,
60, 58, 57, 57, 57, 56, 54, 54, 53, 53, 52, 51, 51, 50, 50, 49, 48, 48, 48, 46,
46, 46, 45, 44, 44, 44, 43, 42, 42, 42, 41, 41, 41, 39, 40, 39, 39, 39, 38, 38,
37, 37, 36, 36, 36, 34, 35, 33, 34, 34, 33, 33, 31, 31, 31, 30, 29, 28, 28, 27,
26, 25, 24, 23, 21, 20, 19, 18, 16, 11, 9, 6, 2, 0, -3, -7, -10, -12, -15, -17,
-19, -20, -21, -23, -24, -25, -26, -27, -28, -29, -29, -30, -30, -31, -31, -32,
-32, -32, -33, -33, -34, -35, -35, -35, -35, -35, -36, -37, -36, -36, -37, -37,
-37, -37, -37, -37, -37, -37, -36, -37, -37, -37, -37, -37, -36, -36, -36, -36,
-36, -36, -36, -36, -36, -35, -35, -35, -35, -34, -34, -35, -34, -35, -36, -36,
-36, -37, -38, -38, -39, -40, -41, -43, -43, -45, -46, -47, -48, -49, -49, -50,
-50, -51, -53, -53, -54, -54, -56, -56, -56, -56, -57, -56, -56, -58, -57, -57,
-57, -57, -56, -57, -57, -58, -57, -57, -58, -58, -58, -59, -58, -59, -60, -61,
-61, -62, -62, -62, -62, -63, -63, -64, -64, -64, -64, -65, -65, -66, -66, -66,
-66, -67, -67, -66, -67, -67, -67, -67, -67, -68, -68, -67, -67, -67, -66, -66,
-66, -66, -66, -66, -65, -65, -64, -64, -64, -63, -63, -62, -62, -63, -61, -61,
-60, -60, -59, -59, -59, -58, -58, -58, -57, -57, -56, -55, -55, -55, -54, -54,
-53, -54, -53, -52, -52, -52, -52, -52, -52, -51, -51, -51, -51, -51, -50, -50,
-50, -51, -50, -51, -51, -50, -51, -50, -50, -51, -51, -51, -51, -51, -51, -52,
-51, -51, -52, -52, -52, -52, -53, -53, -53, -52, -51, -53, -53, -53, -52, -52,
-53, -53, -52, -52, -52, -53, -52, -52, -51, -52, -51, -52, -51, -51, -51, -50,
-50, -49, -49, -49, -50, -48, -47, -48, -47, -46, -46, -46, -45, -45, -43, -44,
-44, -43, -42, -42, -41, -40, -40, -40, -38, -38, -37, -37, -36, -36, -35, -34,
-33, -33, -32, -31, -30, -30, -30, -28, -28, -27, -27, -25, -24, -23, -22, -22,
-21, -21, -20, -18, -17, -16, -13, -11, -8, -8, -5, -3, -1, };