#define DATA_LENGTH 512
#define DATA AKWF_0039

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 9, 12, 16, 19, 22, 25, 29,
32, 36, 38, 42, 45, 48, 51, 54, 56, 59, 61, 63, 64, 67, 66, 67, 69, 69, 69, 69,
69, 69, 68, 68, 67, 66, 65, 64, 63, 62, 60, 60, 59, 58, 57, 56, 55, 55, 54, 54,
54, 54, 54, 54, 54, 54, 55, 56, 58, 58, 60, 61, 63, 65, 67, 69, 71, 74, 76, 79,
82, 84, 88, 90, 93, 95, 98, 101, 105, 106, 109, 110, 113, 115, 115, 116, 117,
118, 119, 119, 119, 118, 119, 117, 117, 115, 114, 113, 112, 109, 108, 107, 105,
103, 101, 99, 97, 96, 95, 92, 90, 89, 88, 87, 85, 84, 84, 82, 82, 81, 80, 82,
81, 82, 83, 82, 83, 84, 85, 87, 88, 89, 91, 92, 94, 96, 98, 99, 101, 103, 105,
107, 108, 110, 111, 112, 112, 113, 114, 114, 113, 113, 113, 112, 111, 109, 108,
107, 104, 103, 100, 98, 95, 93, 90, 88, 85, 82, 79, 76, 73, 70, 68, 65, 62, 59,
58, 55, 53, 51, 50, 48, 46, 45, 44, 43, 42, 41, 41, 41, 40, 41, 41, 41, 41, 42,
43, 43, 45, 45, 47, 48, 49, 50, 51, 51, 52, 53, 54, 54, 54, 54, 54, 53, 52, 51,
50, 48, 47, 45, 43, 41, 39, 35, 33, 29, 27, 24, 20, 17, 14, 11, 8, 4, 1, -3, -6,
-8, -11, -14, -18, -19, -22, -24, -26, -28, -30, -31, -33, -34, -35, -37, -36,
-37, -38, -37, -38, -37, -37, -37, -36, -35, -35, -33, -33, -32, -31, -30, -29,
-28, -27, -26, -25, -25, -24, -24, -25, -25, -26, -26, -28, -29, -31, -32, -34,
-36, -39, -41, -43, -46, -49, -52, -54, -57, -60, -63, -67, -69, -72, -74, -77,
-80, -82, -85, -87, -90, -91, -93, -95, -97, -98, -98, -99, -101, -100, -101,
-101, -101, -100, -100, -100, -99, -98, -97, -96, -94, -93, -91, -90, -87, -86,
-84, -82, -80, -80, -78, -76, -75, -74, -73, -72, -72, -72, -73, -73, -73, -74,
-75, -77, -77, -78, -80, -81, -84, -87, -88, -90, -93, -95, -96, -98, -101,
-103, -104, -106, -109, -109, -111, -113, -114, -115, -116, -117, -117, -118,
-118, -119, -117, -117, -117, -116, -115, -114, -113, -111, -109, -108, -106,
-103, -101, -99, -97, -94, -91, -88, -86, -84, -81, -79, -76, -74, -72, -70,
-69, -68, -67, -66, -64, -64, -63, -63, -64, -64, -64, -64, -65, -66, -68, -68,
-69, -71, -72, -73, -75, -76, -77, -79, -80, -81, -82, -83, -83, -84, -85, -85,
-85, -85, -85, -84, -84, -84, -82, -81, -80, -79, -76, -74, -73, -70, -68, -66,
-63, -60, -57, -54, -51, -47, -45, -40, -37, -35, -32, -28, -26, -23, -21, -17,
-15, -13, -11, -9, -9, -7, -6, -6, -6, -6, -6, -6, -5, -6, -7, -7, -9, -9, -10,
-11, -11, -13, -13, -14, -15, -15, -16, -16, -17, -16, -16, -17, -17, -16, -16,
-16, -14, -13, -12, -11, -8, -7, -5, -3, -1, };