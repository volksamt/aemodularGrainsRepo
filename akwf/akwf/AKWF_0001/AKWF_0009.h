#define DATA_LENGTH 512
#define DATA AKWF_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {86, 103, 96, 101, 96, 101, 97, 101,
97, 100, 98, 100, 98, 99, 98, 100, 99, 99, 99, 99, 98, 98, 99, 98, 99, 98, 98,
99, 99, 98, 99, 98, 100, 99, 99, 98, 99, 99, 99, 99, 99, 99, 99, 99, 99, 99, 99,
99, 99, 99, 99, 99, 99, 99, 98, 98, 98, 99, 99, 99, 99, 99, 99, 98, 99, 99, 99,
98, 99, 100, 99, 98, 99, 98, 99, 99, 99, 99, 98, 99, 99, 99, 99, 100, 99, 99,
99, 99, 99, 99, 99, 99, 99, 99, 99, 98, 99, 98, 99, 98, 100, 98, 100, 97, 101,
94, 106, 78, 80, 105, 95, 101, 98, 100, 98, 99, 98, 99, 98, 99, 100, 98, 99, 97,
100, 97, 101, 98, 100, 97, 100, 98, 100, 98, 99, 99, 99, 100, 98, 100, 96, 101,
96, 103, 93, 107, 87, 121, -1, -125, -83, -111, -87, -115, -42, 9, -6, 3, -2, 2,
-1, 2, -1, 1, -1, 1, -1, 1, 0, 1, -1, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 1, 0,
0, 0, 0, 0, 0, 1, 0, -1, -1, 0, -1, 0, -1, 0, 0, 0, -1, 0, 0, 0, -1, -1, 0, 1,
1, -1, 0, -1, 0, -1, 1, -1, 0, -1, 1, -2, 2, -4, 14, 84, 100, 97, 100, 98, 99,
98, 99, 99, 100, 98, 99, 99, 99, 99, 98, 99, 99, 98, 98, 98, 99, 99, 99, 99, 99,
98, 99, 98, 99, 98, 99, 98, 99, 99, 99, 98, 100, 99, 99, 98, 100, 98, 99, 99,
99, 99, 99, 99, 98, 100, 98, 100, 97, 101, 97, 101, 96, 101, 96, 102, 95, 103,
94, 104, 92, 106, 82, -99, -101, -96, -102, -96, -101, -97, -101, -96, -101,
-96, -100, -97, -99, -98, -98, -99, -99, -99, -98, -99, -97, -100, -98, -100,
-97, -100, -98, -99, -99, -98, -100, -97, -102, -95, -104, -93, -107, -90, -112,
-81, -128, -5, 65, -23, 13, -9, 8, -5, 5, -4, 1, -104, -92, -106, -90, -110,
-85, -122, -28, 119, 90, 102, -79, -1, 2, -3, 3, -4, 4, -4, 5, -5, 4, -4, 4, -4,
4, -4, 3, -2, 3, -1, 2, -1, 1, -1, 0, 0, 0, 0, 0, 1, -1, 1, -1, 0, -1, 0, 0, 0,
-1, 1, 0, 0, -1, -1, 0, 0, 1, -1, 2, -2, 3, -3, 3, -3, 3, -4, 3, -5, -85, -114,
-58, 9, -2, 1, 0, -1, 1, -1, 0, -1, 1, -1, 2, -1, 1, -1, 1, -1, 1, 0, 0, 0, 1,
-1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 1, 0,
1, 0, -1, 1, 0, -1, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0, 0, -1, -1, 0, -1, 0, 0, 1,
0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 1, 0, 0, };