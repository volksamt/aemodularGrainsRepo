#define DATA_LENGTH 512
#define DATA AKWF_0052

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 7, 8, 11, 14, 17, 20, 22, 25,
28, 31, 32, 35, 37, 40, 43, 45, 47, 49, 51, 55, 57, 59, 61, 63, 66, 68, 71, 72,
75, 75, 78, 80, 81, 83, 84, 86, 86, 87, 89, 90, 90, 91, 92, 93, 95, 95, 97, 97,
98, 99, 100, 99, 101, 102, 102, 103, 103, 103, 102, 103, 104, 104, 104, 104,
104, 103, 104, 102, 102, 102, 101, 100, 100, 100, 99, 99, 99, 97, 97, 96, 94,
94, 93, 91, 90, 89, 87, 86, 85, 84, 83, 82, 81, 79, 79, 77, 77, 75, 74, 73, 72,
72, 71, 70, 68, 67, 66, 65, 64, 63, 62, 61, 60, 58, 59, 58, 56, 56, 55, 55, 55,
54, 54, 54, 53, 55, 54, 54, 55, 54, 56, 56, 56, 56, 57, 58, 58, 57, 58, 58, 59,
59, 60, 60, 61, 62, 62, 64, 63, 64, 65, 66, 66, 67, 68, 70, 69, 71, 72, 73, 74,
76, 77, 78, 78, 79, 80, 82, 82, 83, 85, 86, 86, 87, 88, 89, 90, 90, 92, 92, 92,
93, 94, 94, 94, 95, 95, 95, 96, 95, 95, 97, 96, 97, 97, 96, 96, 96, 96, 96, 95,
94, 95, 93, 93, 91, 91, 89, 88, 88, 86, 85, 84, 83, 82, 80, 79, 78, 76, 75, 73,
72, 70, 69, 68, 65, 64, 62, 60, 58, 57, 55, 53, 51, 48, 47, 44, 42, 40, 37, 35,
33, 31, 28, 25, 23, 20, 18, 15, 12, 9, 7, 5, 2, -1, -3, -7, -9, -12, -15, -17,
-20, -23, -25, -28, -30, -33, -36, -38, -40, -43, -45, -48, -50, -52, -54, -57,
-59, -62, -64, -65, -68, -71, -71, -75, -76, -79, -80, -81, -82, -84, -86, -86,
-87, -89, -90, -90, -92, -92, -93, -95, -96, -97, -98, -98, -99, -99, -100,
-101, -102, -102, -103, -102, -103, -104, -104, -103, -104, -104, -104, -104,
-104, -103, -103, -102, -102, -101, -100, -100, -100, -100, -98, -98, -98, -96,
-95, -94, -94, -92, -91, -90, -89, -87, -86, -85, -83, -83, -82, -80, -80, -78,
-78, -77, -76, -74, -73, -72, -72, -70, -69, -69, -68, -66, -65, -64, -63, -62,
-61, -59, -59, -58, -57, -56, -56, -55, -55, -55, -55, -54, -54, -54, -54, -54,
-53, -55, -55, -55, -55, -56, -57, -56, -57, -57, -57, -58, -58, -58, -59, -60,
-61, -61, -63, -63, -63, -64, -65, -65, -66, -67, -68, -67, -70, -70, -72, -73,
-74, -75, -75, -77, -77, -78, -80, -80, -82, -83, -83, -84, -86, -86, -87, -88,
-88, -89, -90, -91, -92, -92, -93, -94, -94, -94, -94, -95, -96, -96, -95, -96,
-96, -97, -96, -96, -97, -97, -96, -96, -95, -95, -95, -94, -93, -92, -92, -90,
-89, -89, -88, -87, -85, -84, -83, -81, -80, -80, -78, -76, -75, -74, -72, -70,
-69, -67, -65, -65, -62, -60, -58, -57, -54, -52, -51, -49, -46, -44, -42, -40,
-38, -35, -33, -30, -27, -26, -23, -20, -18, -15, -12, -9, -7, -4, -1, };