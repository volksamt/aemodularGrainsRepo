#define DATA_LENGTH 512
#define DATA AKWF_squ

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 120, 119, 118, 120, 118, 121, 118,
121, 117, 121, 118, 120, 118, 121, 119, 120, 118, 120, 119, 119, 119, 120, 119,
119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 120,
119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119,
119, 119, 120, 119, 119, 118, 119, 119, 119, 119, 120, 119, 118, 119, 120, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 120, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119,
118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 120, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 119, 119, 119, 119, 119, 118, 120, 119, 120, 119, 119, 119, 119,
118, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120, 119, 120, 119,
119, 120, 119, 119, 118, 119, 118, 118, 118, 119, 119, 120, 119, 119, 118, 119,
119, 120, 119, 119, 119, 119, 119, 119, 120, 120, 120, 119, 120, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 119, 119, 118, 120, 118,
119, 119, 119, 120, 119, 121, 118, 121, -19, -128, -114, -121, -117, -121, -118,
-119, -118, -119, -119, -118, -119, -119, -120, -119, -120, -119, -119, -118,
-119, -120, -119, -118, -119, -120, -119, -118, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -120, -120, -120, -119, -119, -120, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -119, -120, -119, -118, -118, -120, -119, -120, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -120, -119, -118, -119,
-119, -120, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -120, -119, -119,
-119, -120, -119, -119, -118, -120, -119, -119, -119, -119, -119, -119, -119,
-120, -120, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -118, -119, -119, -119, -119,
-119, -120, -120, -119, -119, -119, -119, -119, -119, -118, -118, -119, -119,
-120, -120, -119, -119, -120, -118, -119, -120, -118, -118, -120, -120, -119,
-119, -120, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -118, -120, -118, -118, -119, -119,
-119, -118, -119, -118, -119, -119, -119, -118, -119, -119, -120, -119, -119,
-119, -119, -119, -120, -118, -120, -119, -119, -119, -119, -119, -118, -119,
-119, -120, -117, -120, -118, -120, -118, -121, -116, -122, -116, -124, -114,
-127, -101, };