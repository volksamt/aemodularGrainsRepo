#define DATA_LENGTH 512
#define DATA AKWF_sin

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 5, 6, 8, 8, 10, 11, 13, 15,
15, 17, 19, 20, 21, 23, 25, 26, 28, 28, 30, 32, 33, 35, 36, 37, 39, 40, 41, 43,
45, 46, 47, 48, 50, 51, 52, 54, 55, 56, 58, 58, 60, 61, 62, 64, 65, 66, 67, 68,
70, 71, 72, 74, 74, 75, 77, 78, 79, 80, 81, 82, 83, 84, 85, 86, 87, 88, 89, 90,
91, 92, 93, 94, 95, 95, 97, 97, 99, 99, 100, 100, 101, 101, 103, 104, 104, 105,
105, 107, 107, 107, 108, 108, 109, 109, 110, 112, 112, 112, 113, 113, 113, 114,
114, 114, 115, 116, 116, 116, 116, 117, 116, 117, 118, 117, 117, 117, 119, 119,
118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 118, 118, 119,
118, 118, 117, 117, 118, 117, 117, 117, 116, 115, 117, 115, 115, 115, 114, 114,
113, 113, 112, 111, 111, 111, 110, 110, 109, 108, 108, 108, 107, 106, 105, 105,
104, 103, 102, 103, 101, 101, 100, 99, 98, 97, 96, 96, 95, 93, 93, 92, 91, 91,
89, 88, 87, 86, 85, 84, 83, 82, 82, 80, 79, 78, 77, 75, 74, 73, 72, 71, 69, 69,
67, 66, 65, 64, 63, 61, 61, 59, 58, 56, 54, 53, 53, 50, 49, 48, 46, 46, 44, 43,
41, 40, 39, 37, 36, 35, 32, 31, 30, 28, 27, 26, 24, 23, 22, 21, 19, 17, 16, 14,
12, 12, 10, 9, 7, 6, 3, 3, 1, 0, -2, -3, -5, -6, -8, -9, -11, -12, -14, -15,
-17, -18, -19, -21, -22, -23, -25, -27, -27, -29, -30, -32, -33, -35, -36, -37,
-39, -40, -42, -44, -45, -45, -47, -49, -50, -51, -52, -54, -55, -56, -57, -59,
-60, -62, -62, -64, -66, -67, -67, -69, -70, -71, -72, -74, -75, -76, -77, -78,
-78, -79, -81, -82, -83, -84, -86, -86, -87, -89, -89, -90, -92, -92, -93, -94,
-94, -96, -96, -98, -98, -99, -100, -101, -101, -102, -102, -103, -104, -105,
-106, -106, -107, -108, -108, -110, -110, -110, -111, -111, -112, -112, -113,
-113, -113, -114, -115, -115, -116, -116, -115, -116, -116, -116, -117, -118,
-117, -118, -119, -118, -118, -118, -119, -119, -119, -118, -119, -119, -119,
-119, -118, -119, -118, -119, -119, -118, -118, -118, -118, -118, -117, -118,
-118, -118, -117, -117, -117, -115, -115, -115, -115, -114, -115, -114, -113,
-113, -113, -111, -111, -111, -111, -109, -109, -109, -108, -108, -107, -105,
-106, -105, -105, -104, -104, -102, -101, -100, -100, -100, -98, -97, -97, -95,
-94, -94, -93, -92, -91, -89, -89, -87, -87, -86, -86, -84, -84, -82, -81, -79,
-78, -78, -77, -75, -74, -73, -72, -70, -70, -69, -67, -66, -64, -64, -62, -62,
-60, -58, -57, -56, -55, -53, -53, -51, -49, -48, -46, -45, -43, -43, -41, -40,
-38, -37, -35, -34, -33, -32, -30, -28, -28, -26, -25, -23, -21, -19, -19, -17,
-15, -14, -13, -12, -10, -8, -7, -5, -4, -2, -1, };