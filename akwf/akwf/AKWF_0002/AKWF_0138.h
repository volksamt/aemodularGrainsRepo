#define DATA_LENGTH 512
#define DATA AKWF_0138

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 11, 15, 19, 22, 26, 29, 32,
36, 38, 42, 46, 48, 51, 54, 57, 60, 63, 66, 67, 70, 72, 74, 77, 80, 82, 83, 86,
88, 89, 91, 93, 94, 96, 97, 99, 100, 100, 102, 104, 104, 106, 107, 108, 109,
109, 111, 111, 111, 113, 114, 114, 114, 115, 115, 116, 116, 116, 117, 116, 117,
117, 118, 118, 119, 119, 118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 118, 119, 119, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 117,
117, 117, 117, 117, 116, 116, 115, 115, 114, 113, 111, 109, 107, 107, 104, 102,
101, 100, 97, 95, 92, 90, 87, 85, 81, 79, 76, 73, 70, 66, 63, 59, 56, 53, 49,
46, 42, 39, 35, 31, 28, 24, 20, 17, 14, 9, 5, 2, -1, -5, -8, -12, -15, -19, -22,
-25, -28, -32, -35, -37, -40, -43, -46, -48, -50, -54, -56, -58, -61, -63, -65,
-67, -68, -70, -72, -73, -76, -77, -79, -81, -81, -83, -84, -85, -87, -88, -89,
-90, -91, -92, -93, -93, -95, -95, -96, -96, -97, -97, -98, -97, -97, -97, -96,
-96, -95, -94, -94, -92, -90, -89, -88, -86, -84, -82, -80, -77, -75, -73, -70,
-67, -64, -62, -59, -55, -52, -50, -46, -42, -39, -36, -32, -28, -25, -20, -17,
-14, -10, -7, -3, 0, 4, 7, 11, 13, 17, 21, 23, 27, 30, 33, 36, 39, 42, 44, 47,
49, 52, 56, 57, 60, 62, 64, 66, 68, 70, 72, 74, 76, 77, 79, 80, 82, 83, 85, 86,
87, 88, 89, 90, 91, 91, 93, 93, 94, 94, 96, 96, 97, 97, 97, 98, 99, 99, 99, 99,
99, 100, 100, 100, 101, 101, 100, 101, 101, 101, 101, 101, 100, 100, 100, 100,
100, 99, 99, 99, 98, 97, 94, 94, 92, 90, 90, 88, 86, 84, 82, 80, 78, 74, 72, 69,
66, 64, 61, 58, 54, 51, 47, 45, 41, 38, 35, 30, 26, 23, 19, 15, 12, 9, 5, 1, -2,
-6, -9, -14, -17, -21, -24, -27, -31, -34, -37, -40, -44, -46, -50, -53, -55,
-58, -61, -63, -66, -69, -71, -73, -76, -77, -79, -82, -84, -85, -88, -88, -90,
-93, -93, -94, -96, -98, -100, -100, -101, -102, -103, -105, -105, -106, -107,
-107, -108, -108, -109, -110, -110, -110, -111, -112, -112, -112, -112, -113,
-113, -113, -113, -114, -114, -113, -114, -114, -114, -113, -114, -113, -114,
-114, -113, -114, -114, -113, -113, -113, -113, -113, -112, -112, -113, -112,
-113, -112, -112, -112, -111, -110, -111, -110, -110, -110, -110, -110, -110,
-109, -109, -109, -109, -108, -108, -108, -108, -107, -107, -107, -106, -106,
-106, -106, -105, -106, -105, -105, -105, -104, -105, -105, -104, -104, -104,
-103, -103, -102, -101, -101, -100, -99, -97, -97, -95, -92, -91, -89, -87, -86,
-84, -82, -80, -76, -74, -71, -68, -66, -63, -58, -57, -53, -50, -47, -43, -39,
-36, -32, -29, -25, -21, -18, -14, -10, -6, -2, };