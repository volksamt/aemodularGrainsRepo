#define DATA_LENGTH 512
#define DATA AKWF_0176

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 4, 7, 7, 10, 11, 12, 14, 15,
16, 18, 19, 21, 20, 21, 22, 22, 23, 25, 25, 27, 26, 28, 28, 28, 30, 30, 31, 31,
33, 33, 33, 35, 35, 35, 36, 37, 38, 39, 40, 40, 42, 43, 45, 46, 47, 48, 49, 51,
53, 54, 55, 58, 59, 60, 61, 63, 64, 65, 66, 69, 70, 71, 73, 74, 75, 78, 79, 79,
80, 81, 82, 81, 82, 83, 84, 86, 86, 86, 88, 88, 89, 90, 89, 90, 91, 92, 92, 94,
94, 95, 96, 96, 98, 98, 99, 98, 100, 100, 99, 99, 99, 99, 99, 99, 98, 100, 99,
99, 99, 99, 99, 99, 99, 99, 99, 99, 100, 100, 99, 99, 99, 100, 99, 99, 100, 100,
99, 99, 99, 100, 100, 99, 99, 99, 99, 100, 99, 99, 99, 99, 98, 100, 99, 99, 99,
99, 99, 99, 99, 99, 100, 99, 98, 97, 96, 97, 95, 96, 95, 93, 92, 91, 91, 90, 89,
88, 89, 87, 87, 87, 86, 84, 85, 83, 83, 82, 81, 80, 80, 79, 78, 78, 77, 76, 76,
75, 74, 74, 72, 72, 72, 71, 70, 70, 68, 68, 67, 67, 66, 65, 65, 64, 62, 62, 62,
60, 59, 58, 57, 55, 53, 53, 50, 50, 48, 47, 45, 44, 42, 41, 40, 39, 37, 35, 34,
32, 31, 30, 29, 27, 26, 24, 22, 21, 19, 19, 18, 15, 15, 12, 12, 11, 9, 7, 7, 5,
2, 1, 0, -1, -2, -4, -5, -7, -9, -10, -11, -13, -14, -15, -17, -18, -19, -21,
-22, -23, -25, -27, -28, -29, -31, -32, -34, -35, -37, -39, -40, -41, -42, -44,
-44, -47, -48, -50, -51, -52, -53, -56, -57, -57, -59, -60, -62, -63, -65, -66,
-68, -68, -70, -73, -74, -75, -76, -78, -79, -80, -81, -83, -84, -85, -87, -89,
-90, -92, -93, -94, -95, -97, -99, -100, -100, -100, -101, -102, -103, -104,
-104, -106, -106, -107, -107, -108, -109, -110, -109, -110, -111, -113, -112,
-113, -114, -115, -116, -116, -117, -118, -119, -118, -118, -119, -119, -119,
-119, -120, -119, -120, -119, -119, -120, -118, -118, -120, -120, -118, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -118,
-120, -119, -118, -120, -119, -119, -118, -120, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -120, -118, -119, -119, -120, -120, -119, -119, -119,
-118, -117, -117, -116, -115, -115, -113, -113, -111, -111, -111, -110, -109,
-108, -108, -107, -107, -105, -105, -105, -104, -103, -103, -102, -101, -100,
-99, -98, -98, -98, -96, -96, -95, -94, -94, -93, -92, -92, -90, -90, -89, -89,
-88, -87, -87, -86, -86, -84, -84, -82, -82, -83, -81, -80, -78, -78, -76, -74,
-73, -71, -71, -68, -67, -67, -65, -63, -61, -61, -59, -58, -56, -55, -52, -51,
-50, -49, -47, -46, -44, -43, -42, -40, -39, -38, -37, -35, -33, -33, -30, -29,
-28, -27, -25, -25, -22, -21, -20, -18, -17, -16, -14, -13, -9, -2, -1, };