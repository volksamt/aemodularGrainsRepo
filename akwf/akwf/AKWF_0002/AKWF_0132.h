#define DATA_LENGTH 512
#define DATA AKWF_0132

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 12, 14, 18, 22, 25, 29, 33,
37, 40, 44, 48, 52, 55, 58, 61, 66, 68, 72, 76, 79, 81, 84, 86, 88, 90, 92, 94,
95, 96, 97, 98, 99, 99, 100, 100, 99, 99, 98, 97, 97, 96, 94, 92, 91, 88, 86,
84, 82, 78, 77, 73, 70, 67, 64, 60, 56, 53, 49, 45, 41, 36, 33, 30, 26, 20, 16,
12, 7, 2, -1, -5, -10, -14, -18, -23, -27, -31, -35, -40, -44, -48, -52, -56,
-59, -63, -67, -70, -74, -77, -81, -83, -87, -89, -91, -95, -96, -99, -100,
-102, -104, -105, -106, -107, -108, -109, -109, -109, -109, -109, -108, -108,
-107, -107, -105, -104, -103, -101, -99, -98, -95, -94, -91, -89, -87, -85, -82,
-79, -77, -74, -70, -68, -66, -62, -59, -56, -53, -51, -47, -43, -41, -38, -36,
-32, -29, -26, -23, -21, -18, -15, -14, -10, -8, -6, -3, -1, 1, 4, 5, 8, 10, 11,
13, 15, 16, 18, 19, 21, 21, 23, 24, 24, 25, 26, 25, 27, 27, 27, 26, 27, 28, 27,
27, 28, 26, 28, 27, 26, 25, 26, 26, 25, 25, 25, 24, 25, 24, 25, 25, 25, 25, 25,
25, 26, 27, 27, 27, 28, 28, 29, 30, 31, 32, 33, 34, 34, 35, 36, 37, 38, 40, 40,
41, 41, 43, 43, 44, 44, 45, 46, 46, 45, 45, 46, 46, 46, 45, 46, 45, 46, 45, 44,
43, 42, 42, 42, 41, 39, 38, 37, 36, 34, 33, 32, 30, 28, 26, 23, 22, 20, 17, 16,
13, 10, 9, 5, 4, 1, -2, -4, -6, -8, -11, -13, -14, -17, -19, -22, -23, -25, -27,
-29, -31, -32, -34, -35, -35, -38, -38, -39, -39, -41, -41, -41, -43, -42, -43,
-43, -43, -43, -42, -43, -42, -40, -40, -39, -39, -37, -37, -35, -33, -32, -30,
-28, -28, -26, -24, -22, -21, -19, -17, -15, -13, -11, -10, -8, -6, -4, -3, -2,
0, 2, 4, 4, 6, 7, 8, 9, 10, 10, 11, 12, 11, 11, 12, 11, 11, 11, 11, 10, 10, 8,
8, 8, 7, 6, 5, 5, 3, 4, 2, 1, 0, -1, -2, -2, -3, -4, -5, -5, -6, -7, -7, -8, -8,
-9, -9, -9, -10, -11, -9, -11, -10, -11, -11, -11, -10, -10, -9, -10, -9, -9,
-9, -8, -8, -6, -6, -5, -4, -4, -3, -3, -1, 0, 1, 2, 3, 4, 5, 6, 7, 8, 10, 11,
12, 13, 15, 16, 17, 17, 19, 19, 20, 21, 22, 22, 22, 23, 24, 23, 25, 24, 24, 24,
23, 23, 22, 21, 22, 20, 20, 18, 17, 16, 15, 14, 12, 11, 10, 8, 7, 6, 4, 3, 0, 0,
-2, -4, -5, -8, -9, -10, -12, -13, -15, -16, -18, -19, -20, -22, -23, -23, -25,
-26, -27, -27, -29, -29, -30, -30, -31, -31, -31, -31, -32, -30, -31, -31, -30,
-30, -29, -29, -28, -27, -27, -25, -24, -23, -22, -20, -18, -16, -15, -13, -12,
-9, -7, -5, -3, 0, };