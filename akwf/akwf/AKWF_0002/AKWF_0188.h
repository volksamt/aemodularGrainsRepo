#define DATA_LENGTH 512
#define DATA AKWF_0188

const PROGMEM int8_t DATA[DATA_LENGTH] = {34, 41, 39, 40, 38, 40, 40, 40, 40,
40, 40, 40, 39, 39, 40, 40, 39, 40, 40, 40, 40, 39, 40, 40, 40, 40, 40, 39, 41,
39, 40, 40, 40, 39, 40, 39, 39, 40, 40, 39, 39, 40, 39, 40, 39, 40, 39, 40, 39,
39, 39, 39, 40, 40, 40, 40, 40, 40, 39, 40, 40, 40, 40, 39, 40, 40, 40, 40, 40,
39, 40, 39, 40, 40, 40, 40, 40, 40, 40, 40, 40, 39, 39, 40, 40, 40, 40, 39, 39,
39, 40, 40, 40, 40, 39, 40, 39, 40, 39, 40, 40, 40, 40, 40, 40, 40, 40, 40, 39,
39, 40, 40, 40, 39, 39, 40, 39, 40, 39, 40, 40, 41, 40, 39, 40, 40, 40, 39, 39,
40, 39, 40, 40, 40, 39, 40, 40, 40, 40, 39, 40, 40, 40, 40, 40, 39, 40, 40, 40,
40, 40, 39, 39, 40, 39, 40, 40, 40, 40, 40, 39, 40, 40, 40, 40, 40, 39, 40, 40,
40, 40, 40, 41, 38, 40, 39, 41, 38, 40, 37, 43, 30, -3, 2, -1, 1, 0, 0, 0, 0, 1,
0, 1, 0, 1, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0,
0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, -1, 0, 0, 0, 1, 0, 1, 0,
0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0,
0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 1, 1, 0, -1, 0, 0, 0, 0, 0,
1, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, 1, 0, 2, -2, 4, -23, -44, -36, -42, -37, -42,
-38, -42, -36, -49, -82, -79, -80, -79, -79, -80, -79, -79, -79, -80, -79, -81,
-78, -80, -78, -83, -76, -91, -123, -118, -119, -118, -120, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -118, -118, -119, -119, -120, -119, -119, -120,
-118, -119, -120, -118, -118, -119, -119, -119, -119, -118, -119, -119, -118,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -120, -118, -120,
-119, -119, -120, -118, -119, -119, -119, -120, -120, -119, -119, -119, -119,
-119, -120, -119, -119, -120, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -118, -119, -119, -120, -119, -119, -120, -120, -119, -120,
-119, -120, -118, -120, -118, -120, -117, -121, -112, -77, -80, -80, -79, -80,
-80, -80, -78, -80, -79, -81, -79, -80, -78, -80, -79, -81, -78, -81, -77, -81,
-78, -83, -69, -36, -41, -38, -41, -38, -41, -38, -41, -38, -42, -32, 3, -1, 1,
-1, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, -1, };