#define DATA_LENGTH 512
#define DATA AKWF_0198

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 5, 6, 8, 9, 10, 11, 13, 14,
15, 16, 18, 19, 20, 21, 22, 23, 24, 26, 26, 27, 28, 29, 30, 32, 32, 33, 35, 36,
36, 37, 38, 39, 40, 41, 42, 43, 43, 44, 45, 46, 47, 47, 48, 49, 50, 52, 52, 52,
53, 55, 56, 57, 58, 58, 59, 61, 60, 62, 62, 63, 64, 65, 66, 66, 67, 68, 69, 70,
71, 71, 72, 74, 74, 74, 76, 76, 77, 78, 79, 80, 81, 81, 82, 83, 84, 85, 86, 86,
88, 88, 89, 90, 92, 92, 93, 94, 94, 96, 96, 98, 99, 99, 100, 101, 102, 102, 103,
103, 105, 106, 107, 107, 109, 109, 109, 110, 110, 112, 112, 113, 113, 113, 114,
115, 114, 115, 115, 116, 116, 117, 116, 117, 117, 118, 117, 117, 118, 118, 118,
119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 120,
119, 118, 119, 118, 118, 118, 119, 117, 118, 118, 117, 117, 117, 116, 116, 117,
115, 115, 115, 115, 115, 114, 114, 114, 113, 113, 113, 112, 112, 110, 110, 110,
109, 109, 108, 107, 107, 106, 106, 104, 104, 103, 102, 102, 102, 100, 100, 99,
98, 98, 97, 97, 95, 95, 94, 93, 92, 91, 90, 90, 89, 88, 88, 86, 86, 85, 84, 84,
82, 81, 80, 79, 79, 78, 77, 76, 74, 75, 73, 72, 72, 71, 70, 68, 67, 67, 66, 65,
64, 63, 61, 60, 59, 59, 57, 56, 55, 54, 53, 52, 50, 49, 48, 47, 46, 45, 44, 43,
40, 41, 39, 38, 36, 35, 34, 32, 31, 30, 29, 27, 26, 25, 23, 22, 20, 19, 17, 16,
14, 12, 11, 10, 8, 6, 5, 3, 0, -1, -2, -4, -6, -8, -10, -12, -12, -15, -17, -17,
-19, -21, -22, -24, -26, -27, -28, -30, -31, -33, -33, -36, -37, -38, -39, -41,
-42, -45, -45, -46, -48, -49, -51, -52, -54, -56, -56, -58, -59, -61, -61, -62,
-65, -66, -67, -68, -70, -71, -73, -74, -74, -76, -77, -77, -79, -80, -82, -83,
-84, -85, -86, -87, -88, -89, -90, -91, -92, -93, -94, -95, -96, -97, -98, -98,
-99, -100, -101, -102, -103, -102, -103, -105, -104, -106, -106, -106, -107,
-108, -108, -108, -109, -109, -110, -109, -111, -112, -111, -111, -112, -112,
-112, -112, -112, -113, -113, -112, -112, -112, -112, -111, -112, -111, -112,
-111, -111, -111, -111, -110, -110, -110, -109, -108, -108, -108, -107, -107,
-107, -105, -105, -104, -104, -104, -103, -101, -101, -100, -99, -99, -97, -97,
-96, -96, -94, -93, -93, -92, -90, -89, -89, -87, -86, -85, -85, -83, -82, -81,
-80, -79, -78, -77, -75, -74, -72, -72, -71, -70, -68, -67, -65, -64, -63, -61,
-61, -58, -58, -56, -55, -53, -52, -51, -50, -49, -46, -46, -45, -43, -42, -40,
-38, -38, -35, -34, -33, -32, -31, -29, -29, -26, -25, -23, -23, -21, -19, -18,
-17, -15, -15, -13, -11, -10, -9, -8, -5, -4, -3, -1, };