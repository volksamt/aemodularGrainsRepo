#define DATA_LENGTH 512
#define DATA AKWF_0170

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 1, 2, 1, 2, 2, 1, 1, 1, 1, 2,
1, 2, 2, 2, 1, 4, 16, 15, 15, 15, 15, 15, 14, 16, 15, 16, 14, 16, 13, 22, 30,
27, 28, 27, 29, 28, 30, 27, 30, 42, 41, 41, 41, 41, 41, 41, 42, 40, 40, 41, 41,
41, 41, 41, 42, 39, 44, 54, 53, 54, 54, 53, 54, 53, 53, 52, 54, 53, 54, 52, 60,
66, 64, 66, 64, 64, 64, 65, 64, 64, 65, 65, 64, 64, 73, 76, 74, 75, 75, 76, 74,
74, 75, 75, 75, 75, 74, 78, 85, 83, 84, 84, 84, 85, 84, 84, 84, 85, 84, 85, 84,
89, 94, 92, 93, 92, 93, 92, 92, 92, 93, 92, 93, 93, 92, 98, 99, 99, 99, 99, 100,
99, 99, 100, 100, 99, 99, 99, 100, 100, 99, 99, 99, 100, 106, 104, 106, 105,
106, 105, 105, 104, 105, 105, 105, 106, 106, 105, 106, 105, 105, 104, 105, 105,
105, 109, 110, 109, 110, 110, 110, 110, 109, 109, 109, 110, 109, 110, 109, 112,
114, 113, 114, 113, 113, 114, 116, 116, 116, 116, 116, 116, 116, 116, 116, 115,
116, 116, 116, 116, 116, 116, 116, 116, 117, 117, 115, 118, 117, 117, 117, 118,
117, 118, 118, 117, 118, 117, 117, 117, 119, 118, 119, 118, 119, 118, 119, 118,
119, 120, 119, 119, 118, 120, 118, 120, 118, 120, 117, 120, 118, 120, 118, 120,
117, 120, 118, 119, 118, 119, 119, 119, 120, 117, 121, 116, 125, 113, 127, 104,
127, -1, -128, -103, -127, -112, -124, -115, -122, -116, -120, -118, -119, -119,
-119, -120, -118, -120, -117, -120, -118, -120, -118, -120, -118, -121, -118,
-120, -118, -119, -118, -120, -118, -118, -118, -119, -118, -119, -118, -118,
-119, -119, -118, -118, -118, -117, -118, -118, -118, -117, -117, -117, -118,
-117, -118, -118, -117, -116, -116, -115, -117, -116, -115, -116, -116, -115,
-116, -116, -116, -115, -113, -114, -113, -114, -113, -114, -114, -114, -113,
-114, -113, -114, -114, -111, -109, -110, -110, -110, -109, -110, -110, -110,
-109, -110, -110, -110, -109, -106, -105, -106, -105, -105, -106, -105, -105,
-106, -105, -106, -106, -106, -105, -105, -105, -106, -105, -100, -100, -100,
-100, -100, -100, -99, -99, -100, -100, -100, -99, -100, -100, -99, -100, -100,
-99, -99, -101, -96, -92, -93, -93, -93, -93, -92, -92, -92, -92, -92, -93, -93,
-93, -93, -93, -90, -84, -85, -83, -85, -82, -75, -75, -75, -75, -75, -75, -76,
-75, -76, -76, -76, -75, -76, -76, -75, -75, -75, -76, -75, -76, -76, -66, -64,
-65, -65, -65, -64, -65, -65, -64, -66, -64, -66, -65, -67, -60, -53, -54, -54,
-53, -56, -49, -40, -43, -41, -43, -41, -42, -42, -42, -42, -41, -42, -42, -42,
-41, -42, -41, -42, -43, -41, -42, -40, -28, -30, -29, -29, -29, -29, -29, -29,
-30, -29, -30, -28, -30, -23, -14, -16, -15, -16, -15, -17, -15, -17, -16, -16,
-16, -16, -17, -5, -1, };