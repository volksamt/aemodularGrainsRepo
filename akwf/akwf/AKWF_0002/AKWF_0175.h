#define DATA_LENGTH 512
#define DATA AKWF_0175

const PROGMEM int8_t DATA[DATA_LENGTH] = {34, 41, 38, 41, 38, 41, 38, 40, 39,
41, 38, 40, 40, 40, 40, 40, 40, 40, 40, 40, 39, 40, 40, 39, 41, 39, 41, 40, 40,
39, 41, 39, 40, 39, 40, 39, 40, 39, 40, 39, 41, 79, 80, 79, 79, 79, 80, 79, 80,
79, 79, 80, 79, 80, 79, 79, 79, 79, 80, 79, 80, 79, 82, 76, 84, 72, 94, 15, -54,
-33, -46, -36, -43, -38, -42, -38, -41, -39, -40, -40, -40, -40, -39, -41, -39,
-40, -39, -40, -38, -41, -39, -40, -38, -41, -39, -40, -39, -40, -39, -40, -39,
-40, -40, -39, -40, -39, -40, -38, -43, -9, 4, -2, 2, -1, 1, -1, 1, 0, 1, -1, 0,
0, 0, 0, 0, -1, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 1, -1, 1, -1, 1, -2, 1, -1, 2, -3, 6, 42, 39, 39, 39, 40, 40,
40, 40, 40, 40, 40, 39, 40, 40, 39, 40, 40, 39, 40, 40, 40, 40, 40, 40, 39, 39,
39, 41, 39, 41, 38, 41, 38, 42, 37, 43, 36, 44, 33, 49, 15, -88, -76, -80, -79,
-80, -80, -78, -81, -78, -81, -78, -80, -79, -80, -79, -80, -79, -79, -79, -79,
-79, -80, -79, -79, -79, -79, -79, -80, -79, -79, -79, -80, -80, -80, -79, -80,
-78, -80, -77, -83, -69, -36, -41, -38, -40, -39, -40, -39, -40, -39, -40, -40,
-39, -41, -39, -40, -39, -41, -40, -40, -39, -41, -40, -41, -39, -39, -39, -39,
-40, -40, -41, -40, -40, -39, -41, -39, -41, -38, -42, -37, -44, -27, 5, -1, 1,
0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 1, -1, 0, -1, 0, -1,
1, 0, -1, 1, -1, 1, -2, 3, -4, 5, -7, 14, -45, -127, -112, -123, -117, -120,
-118, -119, -119, -119, -120, -119, -120, -118, -119, -117, -119, -118, -120,
-118, -120, -119, -119, -118, -118, -120, -119, -120, -119, -120, -118, -120,
-116, -122, -108, -76, -81, -78, -80, -79, -79, -79, -80, -79, -79, -80, -79,
-79, -78, -80, -80, -79, -80, -79, -79, -79, -80, -80, -80, -79, -80, -80, -79,
-79, -79, -79, -79, -80, -79, -80, -79, -80, -78, -81, -76, -84, -61, -35, -43,
-38, -40, -39, -41, -39, -40, -40, -40, -39, -40, -41, -40, -40, -39, -40, -40,
-40, -40, -40, -40, -40, -40, -40, -40, -40, -40, -39, -40, -40, -40, -39, -39,
-40, -40, -40, -39, -39, -39, -39, -40, -40, -39, -40, -40, -40, -39, -40, -39,
-39, -40, -41, -39, -40, -39, -40, -39, -39, -40, -4, 2, -1, 0, -1, 1, -1, 1,
-1, 1, 0, 0, -1, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, -1, 0, 0, 1,
1, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 1, 0, -1, 0, };