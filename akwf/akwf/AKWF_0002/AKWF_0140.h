#define DATA_LENGTH 512
#define DATA AKWF_0140

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 10, 14, 17, 20, 25, 28, 32, 34,
38, 41, 45, 48, 50, 54, 56, 59, 62, 65, 68, 70, 73, 75, 78, 79, 81, 84, 86, 88,
89, 90, 93, 94, 96, 97, 98, 100, 102, 103, 104, 105, 107, 107, 108, 110, 110,
111, 112, 113, 112, 113, 114, 115, 115, 116, 116, 116, 117, 117, 117, 117, 118,
118, 118, 118, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 118, 119, 119,
118, 119, 119, 119, 119, 118, 119, 118, 118, 118, 118, 118, 118, 118, 117, 117,
117, 117, 116, 116, 117, 116, 116, 115, 115, 114, 113, 112, 111, 109, 107, 106,
103, 103, 102, 100, 97, 95, 93, 90, 87, 85, 82, 80, 76, 73, 70, 65, 63, 60, 55,
53, 49, 45, 42, 38, 34, 29, 26, 22, 19, 15, 11, 7, 3, 0, -4, -8, -12, -15, -18,
-22, -25, -29, -32, -35, -39, -42, -45, -47, -50, -53, -56, -58, -61, -64, -66,
-68, -70, -72, -74, -76, -79, -81, -82, -83, -85, -87, -89, -90, -91, -93, -94,
-95, -97, -97, -98, -100, -100, -100, -102, -103, -103, -103, -105, -105, -106,
-106, -107, -108, -107, -108, -109, -109, -108, -109, -110, -110, -109, -111,
-110, -110, -110, -110, -109, -108, -108, -106, -105, -104, -103, -101, -99,
-98, -96, -94, -92, -89, -87, -84, -81, -79, -77, -72, -71, -67, -63, -60, -56,
-54, -50, -47, -43, -39, -35, -31, -27, -24, -20, -17, -12, -9, -5, -2, 2, 6, 9,
13, 17, 20, 22, 26, 30, 33, 36, 39, 42, 45, 48, 50, 53, 56, 59, 60, 63, 65, 67,
69, 71, 73, 75, 77, 79, 80, 81, 84, 85, 87, 88, 89, 89, 92, 93, 94, 95, 95, 96,
97, 98, 98, 99, 99, 100, 101, 102, 102, 102, 102, 103, 104, 104, 103, 104, 104,
105, 105, 105, 104, 104, 105, 104, 104, 104, 105, 104, 104, 104, 103, 102, 101,
100, 99, 97, 95, 93, 92, 90, 88, 86, 84, 82, 80, 76, 73, 71, 68, 65, 62, 58, 55,
52, 47, 44, 41, 38, 34, 30, 26, 23, 19, 15, 11, 7, 3, 0, -5, -8, -11, -15, -18,
-22, -25, -30, -33, -36, -39, -43, -46, -49, -51, -55, -57, -60, -62, -65, -68,
-70, -73, -76, -76, -80, -81, -83, -85, -86, -88, -90, -92, -94, -95, -96, -98,
-100, -100, -101, -102, -103, -104, -104, -106, -106, -108, -108, -109, -109,
-109, -111, -111, -111, -111, -112, -113, -112, -113, -112, -113, -113, -114,
-114, -114, -113, -114, -115, -114, -113, -114, -114, -114, -113, -114, -114,
-113, -113, -114, -112, -113, -113, -112, -112, -112, -112, -112, -112, -111,
-112, -112, -111, -111, -111, -110, -110, -109, -109, -109, -110, -109, -108,
-108, -108, -108, -107, -107, -108, -107, -106, -105, -104, -103, -102, -100,
-98, -96, -95, -93, -92, -90, -88, -85, -83, -80, -78, -75, -72, -69, -66, -62,
-59, -56, -53, -49, -46, -41, -39, -35, -31, -27, -23, -19, -16, -12, -9, -4,
-1, };