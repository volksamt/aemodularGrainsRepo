#define DATA_LENGTH 512
#define DATA AKWF_0135

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 10, 13, 15, 17, 18, 21, 23, 25,
27, 29, 31, 33, 35, 37, 38, 41, 42, 44, 46, 47, 49, 51, 52, 54, 56, 58, 59, 61,
62, 64, 65, 67, 69, 70, 71, 73, 75, 76, 77, 79, 80, 82, 82, 83, 86, 86, 88, 89,
90, 90, 93, 93, 95, 96, 96, 98, 100, 100, 101, 102, 103, 103, 105, 105, 106,
107, 107, 108, 109, 110, 110, 111, 111, 113, 112, 113, 113, 114, 115, 115, 115,
116, 116, 117, 117, 117, 117, 118, 118, 118, 118, 118, 119, 118, 119, 119, 120,
119, 119, 119, 119, 119, 118, 119, 118, 118, 118, 118, 117, 117, 117, 117, 117,
116, 116, 114, 115, 114, 114, 113, 112, 112, 111, 110, 109, 109, 109, 108, 108,
107, 106, 105, 105, 104, 104, 103, 102, 101, 100, 99, 98, 97, 96, 95, 95, 93,
93, 92, 90, 90, 88, 88, 86, 86, 84, 84, 83, 82, 83, 83, 83, 83, 82, 82, 82, 82,
82, 82, 81, 81, 82, 82, 82, 82, 82, 82, 81, 81, 80, 80, 79, 78, 77, 76, 74, 73,
71, 69, 67, 66, 64, 62, 61, 58, 57, 54, 52, 49, 46, 44, 42, 39, 37, 34, 32, 29,
27, 23, 22, 19, 15, 12, 9, 6, -1, -4, -8, -11, -14, -16, -20, -21, -23, -26,
-28, -30, -33, -34, -36, -37, -40, -41, -43, -45, -47, -48, -49, -51, -52, -53,
-53, -53, -54, -54, -53, -53, -54, -53, -54, -54, -54, -54, -53, -53, -53, -51,
-51, -50, -50, -50, -49, -49, -48, -48, -47, -48, -47, -47, -46, -47, -46, -46,
-46, -46, -46, -46, -45, -46, -45, -47, -47, -47, -47, -48, -49, -48, -49, -50,
-50, -50, -51, -51, -52, -53, -53, -55, -54, -56, -56, -57, -58, -58, -59, -59,
-60, -61, -60, -62, -63, -63, -64, -64, -65, -65, -66, -66, -67, -68, -69, -69,
-69, -71, -70, -71, -71, -72, -72, -74, -73, -74, -74, -75, -75, -76, -75, -77,
-76, -77, -77, -77, -77, -77, -78, -78, -78, -78, -78, -79, -78, -79, -79, -79,
-79, -79, -79, -80, -80, -79, -80, -79, -80, -80, -80, -80, -80, -81, -80, -81,
-80, -81, -80, -80, -80, -81, -80, -80, -81, -80, -80, -80, -80, -79, -81, -80,
-80, -80, -80, -80, -80, -80, -80, -79, -79, -79, -78, -78, -79, -78, -77, -78,
-78, -77, -77, -76, -77, -77, -76, -76, -75, -76, -74, -74, -73, -74, -74, -73,
-73, -73, -74, -75, -75, -76, -77, -78, -78, -78, -79, -79, -79, -79, -81, -82,
-83, -83, -84, -85, -86, -86, -87, -87, -87, -87, -88, -87, -87, -87, -87, -87,
-88, -87, -87, -87, -87, -87, -86, -85, -85, -85, -83, -83, -83, -82, -81, -80,
-80, -78, -78, -77, -76, -74, -73, -71, -71, -69, -68, -67, -65, -64, -63, -61,
-60, -58, -56, -56, -53, -52, -51, -49, -46, -45, -43, -42, -41, -38, -36, -34,
-33, -31, -28, -26, -24, -22, -19, -17, -15, -14, -10, -8, -4, 1, };