#define DATA_LENGTH 512
#define DATA AKWF_0148

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 1, 2, 3, 3, 4, 4, 5, 6, 8, 9,
10, 10, 12, 13, 14, 14, 15, 16, 17, 19, 20, 20, 21, 21, 23, 24, 24, 26, 26, 27,
29, 29, 31, 31, 31, 31, 31, 30, 29, 28, 27, 25, 25, 23, 22, 20, 18, 15, 13, 10,
8, 7, 6, 5, 5, 4, 3, 3, 3, 3, 2, 2, 3, 4, 5, 7, 8, 10, 12, 13, 14, 15, 16, 17,
17, 18, 17, 18, 19, 19, 21, 22, 22, 24, 24, 24, 26, 28, 29, 32, 34, 36, 39, 41,
43, 46, 49, 52, 54, 57, 60, 62, 65, 67, 70, 72, 73, 74, 75, 76, 76, 75, 75, 75,
75, 74, 73, 72, 69, 69, 66, 63, 62, 58, 56, 53, 50, 46, 43, 40, 38, 35, 30, 28,
25, 22, 19, 17, 14, 12, 11, 8, 6, 4, 2, 1, -2, -4, -5, -7, -9, -8, -7, -7, -5,
-5, -3, -2, 0, 1, 3, 4, 6, 8, 11, 12, 14, 16, 18, 21, 22, 23, 25, 26, 27, 29,
31, 34, 36, 39, 42, 47, 50, 54, 57, 62, 67, 71, 76, 81, 86, 92, 97, 103, 108,
112, 115, 116, 117, 119, 118, 119, 118, 117, 115, 112, 109, 104, 99, 91, 84, 75,
66, 57, 48, 39, 29, 19, 10, 0, -8, -17, -26, -33, -42, -50, -57, -64, -72, -80,
-85, -91, -96, -100, -102, -104, -105, -107, -108, -108, -109, -108, -107, -106,
-103, -102, -99, -97, -93, -90, -86, -81, -76, -73, -68, -63, -57, -52, -46,
-40, -34, -27, -20, -13, -6, 2, 8, 16, 23, 29, 35, 43, 50, 56, 64, 69, 74, 79,
83, 85, 87, 89, 90, 90, 90, 90, 89, 88, 87, 86, 84, 81, 79, 74, 70, 67, 62, 58,
53, 48, 43, 36, 30, 23, 14, 6, -2, -11, -18, -25, -32, -39, -45, -52, -58, -64,
-69, -74, -79, -84, -88, -92, -96, -99, -102, -103, -105, -106, -108, -108,
-109, -109, -107, -104, -102, -98, -93, -89, -84, -80, -74, -68, -62, -55, -49,
-43, -37, -32, -27, -22, -16, -11, -6, 0, 4, 8, 11, 15, 19, 22, 26, 28, 30, 31,
33, 34, 36, 37, 38, 39, 39, 38, 39, 39, 40, 40, 41, 42, 42, 43, 43, 44, 43, 43,
41, 40, 37, 36, 33, 31, 29, 26, 23, 19, 14, 9, 4, -1, -6, -11, -15, -20, -26,
-31, -36, -43, -47, -52, -58, -62, -67, -71, -76, -80, -85, -89, -92, -97, -100,
-104, -106, -109, -109, -110, -110, -109, -109, -109, -108, -107, -106, -105,
-103, -102, -101, -100, -97, -96, -95, -92, -91, -89, -88, -85, -82, -81, -80,
-78, -77, -75, -73, -71, -68, -66, -62, -59, -55, -52, -49, -45, -40, -36, -33,
-29, -25, -22, -20, -17, -15, -12, -10, -10, -8, -8, -7, -6, -5, -3, -2, -2, -1,
-1, 1, 1, 0, 0, 0, 0, -2, -1, 0, -1, 0, -1, 0, 0, -1, 0, 0, -1, 0, -1, 0, 0, -1,
0, 0, 0, 0, };