#define DATA_LENGTH 512
#define DATA AKWF_0186

const PROGMEM int8_t DATA[DATA_LENGTH] = {34, 41, 38, 41, 40, 40, 40, 40, 40,
39, 40, 40, 40, 39, 41, 39, 41, 37, 46, 81, 79, 79, 79, 79, 79, 79, 80, 79, 80,
79, 80, 79, 79, 79, 79, 78, 79, 79, 79, 79, 79, 79, 80, 79, 79, 79, 79, 79, 79,
80, 79, 80, 80, 79, 79, 79, 79, 79, 79, 79, 79, 80, 79, 80, 80, 80, 80, 79, 80,
79, 80, 79, 79, 80, 79, 79, 79, 79, 80, 80, 79, 78, 79, 79, 79, 80, 79, 80, 79,
79, 80, 80, 78, 80, 80, 79, 80, 79, 79, 79, 79, 79, 80, 79, 79, 80, 80, 80, 80,
80, 79, 80, 80, 79, 80, 79, 80, 79, 80, 79, 79, 79, 79, 79, 79, 79, 79, 80, 79,
80, 80, 79, 79, 79, 79, 80, 80, 80, 80, 79, 80, 80, 79, 80, 79, 79, 80, 80, 79,
80, 78, 79, 79, 80, 80, 80, 79, 79, 80, 80, 80, 79, 79, 79, 79, 79, 79, 80, 79,
79, 79, 79, 79, 79, 79, 79, 80, 80, 80, 79, 79, 79, 79, 79, 79, 79, 79, 80, 79,
79, 79, 79, 79, 80, 80, 79, 79, 79, 80, 79, 79, 79, 80, 79, 79, 80, 80, 80, 79,
79, 80, 80, 79, 79, 79, 80, 77, 84, 57, 34, 42, 38, 41, 38, 40, 39, 40, 40, 40,
39, 39, 41, 39, 41, 37, 44, 14, -4, 3, -2, 1, -1, 1, 0, 1, 1, -2, 3, -28, -44,
-37, -42, -37, -41, -39, -41, -39, -39, -41, -36, -70, -83, -78, -80, -78, -80,
-79, -80, -80, -80, -79, -80, -79, -80, -79, -81, -76, -107, -124, -117, -121,
-117, -120, -118, -120, -118, -119, -118, -119, -119, -119, -119, -119, -118,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -120, -119, -119, -118, -119, -119, -119, -120, -120,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -120, -119, -119, -120, -119, -119, -119,
-118, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -118, -120, -118, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -118, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -120, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -120, -119, -119, -120, -119, -119, -119, -119,
-119, -118, -120, -118, -119, -118, -119, -118, -120, -118, -120, -118, -121,
-114, -78, -80, -80, -79, -80, -78, -80, -78, -80, -79, -80, -78, -80, -78, -80,
-80, -44, -37, -42, -38, -42, -38, -43, -36, -45, -18, 5, -2, 2, -1, 1, -1, 0,
-1, 0, };