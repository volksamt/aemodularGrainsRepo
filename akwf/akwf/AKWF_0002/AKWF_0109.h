#define DATA_LENGTH 512
#define DATA AKWF_0109

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 4, 5, 7, 8, 8, 10, 11, 12,
14, 15, 16, 17, 18, 20, 20, 21, 23, 24, 24, 25, 26, 28, 29, 30, 31, 32, 32, 34,
36, 37, 37, 38, 39, 40, 42, 43, 44, 43, 45, 46, 46, 47, 49, 49, 50, 52, 53, 53,
55, 55, 56, 57, 58, 58, 59, 60, 60, 62, 62, 63, 65, 65, 66, 66, 67, 68, 69, 69,
71, 71, 71, 72, 73, 73, 74, 75, 76, 76, 77, 77, 79, 79, 80, 80, 80, 82, 82, 83,
83, 84, 85, 85, 85, 86, 86, 87, 87, 88, 88, 89, 89, 90, 91, 91, 92, 92, 92, 93,
93, 93, 94, 94, 94, 95, 95, 95, 96, 96, 97, 98, 97, 97, 97, 98, 98, 98, 99, 99,
99, 99, 99, 100, 100, 100, 101, 100, 101, 101, 100, 100, 100, 102, 101, 101,
100, 101, 101, 100, 99, 100, 100, 99, 99, 99, 99, 98, 97, 98, 97, 97, 97, 96,
94, 95, 95, 94, 93, 93, 92, 91, 90, 90, 89, 88, 87, 87, 87, 85, 85, 83, 83, 82,
81, 80, 79, 79, 77, 76, 76, 74, 74, 72, 71, 71, 70, 68, 67, 66, 65, 65, 63, 62,
61, 60, 59, 58, 56, 55, 54, 54, 52, 51, 50, 47, 47, 45, 44, 43, 42, 41, 39, 39,
38, 36, 34, 33, 33, 31, 30, 29, 27, 27, 25, 24, 23, 22, 20, 20, 18, 16, 15, 14,
12, 11, 11, 10, 8, 6, 6, 5, 4, 1, 0, -1, -2, -3, -3, -5, -6, -8, -9, -10, -11,
-12, -14, -14, -16, -17, -18, -19, -20, -20, -23, -24, -24, -26, -27, -27, -29,
-30, -31, -32, -33, -34, -35, -36, -37, -38, -39, -40, -41, -42, -42, -44, -45,
-45, -46, -48, -50, -49, -51, -51, -52, -53, -54, -55, -56, -57, -58, -58, -59,
-60, -60, -62, -63, -63, -65, -64, -66, -67, -67, -68, -68, -69, -70, -71, -72,
-72, -73, -73, -75, -76, -76, -76, -78, -78, -79, -79, -80, -81, -81, -81, -82,
-83, -83, -84, -84, -85, -86, -86, -86, -88, -88, -88, -88, -90, -89, -91, -91,
-91, -92, -92, -92, -93, -93, -94, -94, -95, -94, -94, -95, -95, -96, -97, -97,
-98, -97, -98, -98, -98, -99, -98, -99, -100, -99, -100, -99, -100, -100, -101,
-100, -101, -101, -100, -101, -101, -101, -101, -101, -100, -100, -101, -100,
-100, -99, -100, -101, -100, -100, -99, -99, -98, -98, -98, -96, -97, -96, -96,
-95, -95, -94, -93, -92, -92, -92, -91, -90, -89, -89, -89, -88, -87, -86, -85,
-85, -84, -83, -82, -81, -81, -79, -78, -77, -77, -76, -75, -73, -72, -72, -70,
-69, -69, -67, -67, -66, -64, -63, -62, -61, -60, -59, -58, -56, -55, -54, -53,
-52, -51, -48, -48, -47, -47, -45, -44, -42, -41, -40, -38, -37, -36, -34, -33,
-32, -31, -30, -29, -27, -26, -24, -24, -23, -20, -19, -19, -18, -16, -15, -13,
-13, -11, -10, -8, -8, -6, -5, -4, -2, -2, 0, };