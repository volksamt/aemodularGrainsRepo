#define DATA_LENGTH 512
#define DATA AKWF_0106

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 4, 6, 7, 8, 9, 12, 13, 14,
16, 18, 18, 20, 22, 23, 25, 26, 27, 29, 30, 31, 34, 34, 37, 39, 39, 41, 43, 43,
45, 47, 48, 49, 51, 53, 54, 56, 56, 58, 60, 61, 62, 63, 65, 67, 68, 70, 71, 72,
73, 75, 76, 77, 79, 80, 81, 83, 84, 85, 86, 87, 88, 89, 91, 92, 93, 94, 94, 96,
97, 99, 99, 100, 101, 102, 103, 103, 104, 106, 106, 107, 107, 108, 110, 109,
110, 111, 112, 112, 113, 114, 114, 114, 115, 116, 116, 117, 116, 117, 118, 117,
117, 118, 119, 118, 118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118,
118, 118, 118, 118, 118, 117, 117, 116, 116, 116, 116, 115, 115, 114, 114, 112,
112, 112, 111, 111, 109, 110, 109, 107, 107, 106, 105, 105, 104, 103, 102, 101,
100, 99, 98, 97, 97, 95, 94, 94, 92, 91, 90, 88, 87, 87, 85, 85, 83, 82, 81, 79,
78, 76, 74, 73, 72, 70, 70, 68, 67, 66, 64, 63, 62, 60, 59, 57, 56, 55, 53, 51,
50, 48, 48, 46, 44, 43, 41, 40, 38, 37, 34, 33, 32, 30, 28, 27, 26, 24, 23, 21,
19, 18, 17, 15, 14, 12, 11, 9, 8, 6, 5, 3, 2, 1, 0, -2, -4, -5, -7, -8, -9, -11,
-12, -14, -15, -16, -18, -19, -21, -22, -23, -24, -25, -27, -28, -29, -30, -32,
-33, -34, -35, -36, -37, -39, -39, -41, -42, -43, -44, -45, -47, -48, -48, -50,
-51, -51, -52, -53, -54, -54, -55, -57, -57, -59, -59, -60, -61, -62, -63, -63,
-65, -65, -65, -66, -66, -68, -68, -69, -70, -70, -71, -72, -72, -72, -73, -73,
-74, -75, -74, -76, -76, -75, -76, -77, -77, -77, -78, -78, -79, -79, -78, -79,
-79, -80, -79, -80, -80, -80, -81, -79, -80, -80, -80, -80, -80, -80, -80, -80,
-80, -80, -80, -79, -80, -80, -79, -80, -79, -80, -79, -79, -80, -79, -79, -79,
-78, -79, -78, -77, -78, -77, -77, -77, -78, -77, -76, -76, -76, -75, -75, -76,
-75, -75, -75, -75, -75, -74, -74, -74, -74, -74, -74, -74, -75, -73, -73, -73,
-73, -74, -73, -73, -73, -73, -73, -73, -73, -72, -73, -73, -72, -72, -72, -72,
-73, -72, -72, -73, -72, -71, -71, -72, -72, -72, -72, -71, -72, -71, -71, -71,
-70, -70, -70, -70, -70, -69, -70, -71, -70, -69, -69, -68, -69, -69, -69, -69,
-69, -68, -67, -67, -67, -67, -67, -66, -66, -66, -66, -65, -65, -64, -64, -63,
-64, -62, -62, -61, -61, -61, -61, -59, -60, -59, -59, -58, -57, -57, -56, -56,
-55, -55, -54, -53, -54, -53, -51, -51, -50, -49, -49, -48, -47, -47, -46, -45,
-44, -42, -43, -41, -41, -40, -39, -37, -37, -36, -34, -33, -32, -31, -30, -30,
-29, -27, -27, -25, -24, -23, -22, -21, -19, -18, -17, -15, -14, -13, -13, -10,
-9, -8, -6, -5, -4, -3, -2, };