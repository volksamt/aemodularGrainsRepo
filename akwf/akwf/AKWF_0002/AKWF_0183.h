#define DATA_LENGTH 512
#define DATA AKWF_0183

const PROGMEM int8_t DATA[DATA_LENGTH] = {35, 41, 40, 40, 40, 39, 41, 36, 54,
85, 77, 81, 78, 80, 79, 80, 79, 79, 79, 80, 79, 79, 80, 79, 80, 79, 80, 79, 80,
79, 80, 79, 80, 79, 80, 80, 79, 80, 78, 81, 46, 37, 41, 39, 40, 39, 41, 38, 41,
38, 41, 39, 42, 36, 44, 20, -6, 3, -1, 1, 0, 1, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0,
0, 0, 0, 1, 0, 0, -1, 0, 0, 1, -1, 1, -1, 1, -1, 3, -9, -43, -39, -39, -39, -40,
-40, -40, -40, -38, -41, -37, -43, -35, -63, -84, -77, -81, -79, -79, -78, -79,
-79, -80, -80, -79, -79, -79, -80, -79, -79, -79, -79, -79, -79, -79, -80, -79,
-79, -79, -80, -79, -80, -79, -81, -77, -40, -39, -41, -39, -40, -39, -40, -39,
-41, -39, -40, -39, -40, -40, -40, -38, -40, -39, -40, -38, -39, -39, -41, -39,
-40, -39, -41, -39, -41, -77, -81, -79, -80, -79, -80, -79, -80, -79, -80, -79,
-80, -79, -81, -79, -80, -79, -80, -80, -80, -80, -79, -79, -80, -79, -79, -79,
-79, -80, -79, -79, -79, -80, -79, -79, -79, -80, -79, -80, -79, -80, -79, -79,
-79, -79, -79, -79, -79, -80, -79, -80, -79, -79, -80, -79, -79, -78, -81, -78,
-82, -75, -103, -124, -116, -121, -118, -120, -117, -120, -118, -120, -119,
-120, -118, -119, -119, -119, -119, -118, -120, -119, -120, -117, -124, -97,
-74, -82, -77, -81, -79, -80, -79, -78, -80, -77, -84, -55, -35, -42, -40, -39,
-42, -15, 6, -4, 3, -3, 1, -1, 2, -2, 1, -1, 1, 0, 2, 39, 40, 40, 40, 40, 40,
41, 39, 41, 38, 41, 36, 0, -1, 0, 0, 0, -1, 0, 0, 1, 0, 1, 0, 0, 0, -1, 1, -1,
2, -3, 6, -25, -42, -40, -34, 4, -2, 1, 0, 0, 0, 0, 0, -1, 1, -1, 0, -1, 1, 0,
0, 0, 0, 0, -1, -1, 1, 0, -1, 0, -1, 1, 0, 1, -1, 2, 0, 1, -4, -39, -40, -38,
-41, -40, -40, -39, -40, -39, -40, -39, -40, -40, -41, -39, -40, -40, -40, -40,
-40, -41, -40, -40, -40, -40, -39, -40, -38, -40, -38, -40, -38, -41, -37, -43,
-30, 4, -1, 1, 0, 0, 0, 0, 1, 0, 2, -2, 2, -5, 24, 44, 37, 42, 39, 41, 39, 40,
40, 40, 40, 40, 40, 40, 40, 40, 39, 40, 40, 39, 40, 40, 40, 39, 41, 38, 2, 0, 0,
-1, 0, -1, 1, -1, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
-1, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 1, -1, -1, -1, 0, 0, 0, 1, 0, 0, -1,
0, -1, 0, -1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 1, 0, 0,
0, 0, 0, 0, 0, 1, -1, 0, 0, 0, };