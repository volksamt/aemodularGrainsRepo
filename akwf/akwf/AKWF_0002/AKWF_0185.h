#define DATA_LENGTH 512
#define DATA AKWF_0185

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 35, 34, 34, 33, 33, 34, 33, 35, 34,
33, 33, 34, 34, 34, 33, 34, 33, 34, 32, 35, 30, 59, 70, 66, 69, 66, 68, 67, 69,
67, 67, 67, 68, 67, 68, 67, 67, 67, 68, 67, 67, 67, 68, 67, 67, 67, 67, 67, 67,
68, 67, 68, 67, 68, 68, 67, 67, 67, 68, 67, 67, 67, 67, 68, 67, 67, 68, 67, 68,
67, 67, 66, 68, 67, 67, 67, 69, 66, 68, 65, 70, 61, 31, 35, 33, 34, 34, 33, 34,
33, 34, 33, 34, 33, 34, 33, 34, 33, 35, 32, 37, 15, -4, 2, -1, 1, 0, 1, 0, 0, 1,
-2, 4, -21, -38, -32, -35, -33, -35, -33, -35, -33, -34, -34, -34, -34, -34,
-34, -34, -34, -33, -34, -34, -34, -34, -34, -33, -33, -33, -34, -34, -34, -33,
-34, -34, -33, -34, -34, -34, -33, -33, -33, -34, -34, -34, -34, -34, -33, -34,
-33, -34, -34, -34, -34, -33, -33, -33, -33, -33, -33, -34, -34, -34, -33, -34,
-33, -34, -33, -33, -34, -34, -33, -35, -33, -33, -34, -34, -33, -34, -34, -33,
-34, -34, -33, -34, -34, -34, -34, -33, -33, -33, -34, -34, -34, -33, -33, -33,
-35, -33, -34, -34, -34, -33, -33, -33, -34, -33, -35, -33, -35, -67, -68, -67,
-67, -67, -69, -67, -67, -67, -68, -68, -68, -68, -68, -67, -67, -68, -68, -67,
-68, -67, -67, -67, -67, -67, -68, -67, -67, -67, -68, -67, -68, -67, -68, -66,
-67, -66, -68, -66, -69, -64, -33, -33, -34, -33, -34, -34, -34, -33, -34, -33,
-34, -33, -35, -33, -34, -33, -34, -33, -34, -34, -34, -34, -33, -35, -32, -38,
-13, 4, -2, 1, -1, 1, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 1, -1,
0, 0, 0, 0, 1, 0, 0, -1, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 1, 0, -1, 0, 1, -1, 0, 0, 0, 0, -1, 0, 0, 1, -2, 2, -2, 5, -18, -38, -32,
-35, -33, -34, -34, -33, -33, -34, -33, -34, -33, -34, -32, -34, -33, -34, -32,
-34, -31, -40, -70, -67, -67, -67, -68, -67, -67, -68, -67, -67, -67, -67, -67,
-68, -67, -68, -66, -67, -67, -67, -67, -67, -67, -67, -67, -67, -68, -67, -68,
-68, -68, -67, -68, -67, -68, -67, -69, -66, -70, -65, -76, -104, -101, -101,
-100, -101, -101, -102, -102, -101, -101, -100, -101, -100, -101, -102, -100,
-101, -99, -104, -80, -63, -69, -65, -69, -67, -69, -66, -67, -66, -68, -68,
-68, -67, -68, -68, -68, -67, -67, -68, -67, -68, -67, -68, -67, -68, -66, -68,
-67, -68, -67, -67, -68, -68, -67, -67, -67, -67, -68, -66, -71, -44, -30, -36,
-32, -35, -33, -35, -33, -35, -32, -34, -32, -36, -31, -37, -22, 4, -2, 1, -1,
0, 0, 0, 0, 0, 0, 0, -1, 0, 1, -1, -1, };