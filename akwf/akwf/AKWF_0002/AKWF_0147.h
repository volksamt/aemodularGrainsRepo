#define DATA_LENGTH 512
#define DATA AKWF_0147

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 16, 17, 24, 34, 38, 36, 24, 29, 28,
24, 32, 44, 55, 57, 54, 58, 63, 52, 44, 41, 25, 24, 24, 28, 42, 49, 63, 80, 88,
88, 107, 104, 77, 66, 64, 45, 12, -6, -8, -3, -15, -11, 23, 38, 57, 77, 90, 108,
111, 115, 120, 115, 107, 91, 83, 68, 45, 24, 11, -1, -12, -10, -16, -11, -2, -7,
-5, 6, 11, 19, 22, 24, 28, 21, 21, 13, -4, -4, 0, -4, -13, -14, -10, -3, 8, -6,
-16, -9, -9, -18, -26, -28, -22, -18, -21, -13, -16, -20, -7, -11, -20, -17,
-14, -20, -11, -1, -14, -19, -6, -3, 2, 0, -8, -5, -6, -12, -16, -15, -18, -7,
-1, 2, 15, 23, 32, 35, 44, 37, 26, 14, 5, -6, -27, -37, -42, -46, -53, -54, -45,
-26, -7, -1, 10, 34, 40, 35, 30, 12, 2, -20, -45, -58, -71, -80, -85, -73, -57,
-45, -26, -2, 27, 38, 37, 49, 57, 40, 34, 35, 26, 13, 6, 1, 14, 18, 1, 1, 10,
13, -4, -10, -22, -35, -31, -42, -49, -47, -31, -20, -18, -15, -11, 6, 8, -9,
-20, -29, -42, -65, -90, -99, -104, -103, -88, -70, -44, -14, 0, 18, 30, 35, 33,
8, -10, -26, -41, -63, -92, -92, -94, -105, -87, -75, -73, -53, -42, -33, -23,
-8, 3, 1, 9, 6, -2, 8, -2, -11, -6, -20, -31, -21, -10, -7, -1, -1, 13, 23, 18,
24, 30, 20, 11, 21, 25, 19, 6, -3, 0, 5, -11, -14, -4, 7, 7, 10, 15, 10, 13, 15,
27, 37, 40, 55, 70, 75, 86, 88, 76, 76, 62, 54, 53, 40, 32, 31, 20, 16, 31, 39,
40, 39, 52, 54, 48, 42, 30, 15, 6, 12, 6, 0, 1, 10, 20, 20, 30, 43, 48, 59, 57,
55, 53, 52, 45, 34, 23, 10, -2, -6, 3, 4, 11, 15, 15, 18, 17, 18, -4, -8, -14,
-37, -44, -59, -65, -71, -73, -66, -63, -53, -34, -8, 1, -1, 14, 17, 9, 2, -2,
-13, -26, -31, -47, -36, -32, -46, -26, -14, -9, 13, 18, 18, 31, 36, 39, 39, 32,
24, 10, 9, 4, -8, -1, 2, 16, 35, 37, 40, 56, 69, 77, 68, 54, 63, 65, 44, 50, 52,
38, 27, 32, 37, 28, 34, 28, 26, 26, 24, 26, 18, 1, -15, -18, -21, -39, -50, -61,
-66, -65, -61, -56, -53, -34, -9, 9, 27, 55, 68, 69, 63, 49, 44, 38, 7, -24,
-43, -40, -40, -57, -52, -33, -22, -16, -2, 2, 7, 15, 8, 4, -4, -5, -20, -40,
-51, -70, -70, -63, -65, -63, -62, -54, -38, -36, -47, -44, -42, -44, -40, -53,
-59, -50, -56, -69, -66, -59, -61, -57, -38, -29, -22, -21, -33, -37, -36, -43,
-50, -49, -45, -41, -37, -34, -26, -27, -28, -29, -38, -48, -51, -50, -59, -62,
-51, -43, -31, -28, -23, 4, 10, 5, 10, 9, -7, -23, -31, -45, -56, -54, -51, -49,
-37, -30, -25, -9, };