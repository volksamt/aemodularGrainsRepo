#define DATA_LENGTH 512
#define DATA AKWF_0165

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 6, 6, 7, 9, 10, 10, 12,
13, 15, 15, 17, 18, 20, 19, 21, 23, 24, 24, 27, 27, 28, 30, 31, 33, 33, 35, 36,
37, 38, 39, 40, 40, 41, 41, 41, 41, 41, 41, 39, 38, 38, 36, 36, 35, 35, 35, 34,
35, 34, 35, 35, 35, 36, 36, 37, 39, 39, 40, 41, 43, 43, 46, 47, 48, 51, 52, 53,
55, 58, 59, 62, 65, 66, 68, 70, 71, 74, 76, 78, 80, 81, 84, 84, 87, 89, 90, 92,
93, 95, 96, 97, 99, 100, 102, 104, 105, 105, 107, 107, 108, 110, 110, 111, 112,
113, 114, 115, 114, 115, 116, 116, 116, 116, 117, 117, 119, 118, 119, 118, 119,
119, 119, 119, 118, 120, 118, 119, 119, 119, 118, 118, 118, 118, 117, 116, 117,
117, 115, 115, 115, 114, 113, 113, 112, 112, 110, 110, 109, 109, 107, 107, 106,
106, 105, 104, 104, 103, 101, 100, 100, 98, 98, 97, 96, 95, 94, 94, 93, 92, 91,
91, 90, 89, 88, 86, 86, 85, 84, 83, 82, 81, 80, 78, 77, 76, 74, 73, 71, 70, 68,
67, 66, 63, 62, 60, 59, 57, 55, 54, 53, 50, 49, 48, 46, 44, 42, 41, 39, 37, 36,
34, 33, 30, 29, 27, 26, 24, 24, 21, 20, 19, 16, 15, 14, 11, 11, 9, 8, 6, 6, 3,
1, 1, -1, -2, -3, -4, -6, -7, -8, -9, -11, -11, -13, -14, -15, -17, -18, -19,
-19, -20, -21, -22, -24, -24, -25, -27, -28, -28, -29, -29, -31, -32, -34, -34,
-34, -35, -36, -37, -38, -38, -38, -40, -40, -41, -42, -42, -44, -44, -44, -44,
-45, -46, -47, -47, -48, -50, -50, -51, -52, -54, -55, -58, -60, -62, -65, -67,
-69, -71, -74, -75, -77, -78, -79, -81, -83, -83, -84, -85, -85, -85, -86, -86,
-87, -86, -86, -86, -85, -86, -84, -83, -82, -81, -80, -80, -78, -77, -77, -76,
-75, -75, -76, -77, -77, -78, -78, -81, -82, -83, -85, -87, -89, -91, -92, -95,
-95, -97, -99, -101, -101, -102, -103, -104, -104, -104, -103, -104, -103, -103,
-103, -103, -101, -101, -101, -100, -99, -98, -97, -96, -97, -94, -94, -93, -93,
-92, -91, -90, -90, -89, -88, -87, -87, -86, -85, -85, -84, -84, -83, -82, -83,
-81, -81, -80, -80, -79, -79, -79, -78, -78, -77, -77, -76, -76, -76, -75, -75,
-74, -74, -73, -73, -73, -71, -71, -71, -70, -70, -69, -68, -69, -67, -66, -65,
-65, -64, -63, -63, -62, -61, -60, -59, -58, -58, -57, -56, -55, -54, -54, -53,
-52, -51, -51, -50, -50, -49, -49, -49, -48, -47, -47, -47, -46, -46, -45, -45,
-44, -43, -43, -43, -41, -41, -41, -40, -40, -39, -39, -38, -37, -37, -36, -36,
-36, -35, -34, -33, -32, -31, -31, -30, -29, -28, -28, -26, -25, -25, -23, -23,
-22, -21, -21, -21, -19, -18, -16, -16, -15, -14, -12, -11, -11, -9, -9, -7, -7,
-5, -4, -2, -1, 0, };