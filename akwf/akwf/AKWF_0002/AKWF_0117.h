#define DATA_LENGTH 512
#define DATA AKWF_0117

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 13, 16, 19, 22, 25, 28,
31, 34, 36, 39, 42, 45, 47, 50, 52, 55, 57, 61, 63, 65, 67, 70, 72, 75, 77, 79,
81, 83, 84, 86, 88, 90, 92, 94, 95, 97, 99, 99, 101, 102, 103, 104, 105, 107,
107, 108, 109, 109, 110, 110, 111, 111, 112, 113, 113, 113, 114, 114, 114, 113,
114, 114, 114, 115, 114, 115, 114, 114, 115, 115, 115, 114, 114, 115, 114, 114,
115, 114, 115, 114, 115, 114, 115, 115, 115, 115, 115, 115, 115, 116, 115, 116,
116, 115, 115, 115, 116, 116, 116, 117, 117, 117, 117, 117, 117, 117, 117, 118,
118, 117, 117, 118, 118, 118, 118, 119, 118, 119, 119, 120, 119, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 118,
118, 118, 118, 117, 118, 118, 118, 117, 118, 117, 117, 117, 117, 117, 116, 117,
116, 116, 116, 116, 116, 116, 116, 116, 115, 115, 115, 115, 115, 115, 114, 114,
114, 114, 114, 114, 114, 113, 114, 114, 113, 113, 112, 112, 112, 111, 111, 110,
111, 111, 110, 109, 109, 109, 108, 108, 108, 107, 106, 106, 105, 105, 104, 103,
102, 102, 100, 99, 99, 97, 97, 96, 94, 93, 92, 91, 89, 89, 87, 85, 83, 82, 81,
78, 76, 75, 72, 70, 68, 65, 64, 60, 59, 55, 53, 50, 48, 45, 42, 39, 36, 33, 30,
27, 24, 21, 18, 15, 12, 8, 6, 2, -1, -4, -8, -11, -14, -17, -19, -22, -25, -28,
-31, -34, -36, -40, -42, -46, -48, -51, -53, -55, -59, -60, -63, -66, -67, -70,
-72, -75, -76, -78, -82, -82, -85, -87, -89, -91, -92, -93, -95, -97, -98, -100,
-101, -102, -104, -104, -106, -106, -107, -108, -108, -110, -110, -111, -111,
-112, -113, -113, -113, -113, -114, -114, -115, -114, -114, -114, -115, -115,
-115, -115, -115, -115, -114, -115, -115, -115, -115, -115, -114, -114, -114,
-115, -114, -115, -115, -115, -115, -115, -115, -114, -115, -115, -115, -115,
-115, -116, -114, -116, -116, -116, -116, -116, -117, -116, -116, -117, -117,
-117, -118, -117, -118, -118, -117, -118, -118, -118, -118, -118, -119, -118,
-118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -120,
-118, -119, -119, -120, -119, -120, -119, -118, -118, -118, -118, -118, -118,
-119, -118, -118, -118, -118, -118, -117, -117, -118, -117, -117, -116, -116,
-117, -117, -116, -117, -116, -116, -116, -115, -116, -115, -116, -116, -115,
-115, -115, -114, -114, -114, -114, -113, -114, -114, -113, -113, -113, -112,
-112, -112, -113, -112, -112, -111, -110, -110, -110, -109, -109, -109, -108,
-108, -108, -107, -107, -107, -106, -105, -104, -104, -103, -102, -102, -100,
-99, -99, -98, -97, -96, -95, -93, -92, -91, -90, -88, -86, -84, -83, -82, -79,
-78, -76, -74, -71, -70, -68, -65, -63, -61, -58, -55, -52, -50, -48, -44, -42,
-39, -36, -33, -30, -26, -24, -21, -17, -14, -11, -8, -5, -1, };