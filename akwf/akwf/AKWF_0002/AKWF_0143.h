#define DATA_LENGTH 512
#define DATA AKWF_0143

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 14, 17, 22, 24, 28, 30, 35,
38, 40, 43, 47, 50, 53, 56, 58, 61, 64, 66, 69, 71, 74, 76, 79, 81, 82, 85, 87,
89, 91, 93, 94, 96, 98, 99, 100, 101, 103, 104, 106, 106, 108, 109, 109, 110,
111, 112, 114, 113, 114, 114, 115, 116, 117, 117, 117, 117, 117, 118, 118, 118,
118, 118, 119, 119, 119, 120, 119, 119, 119, 118, 118, 119, 118, 118, 118, 118,
118, 118, 117, 118, 117, 117, 117, 116, 116, 115, 114, 115, 115, 114, 114, 113,
114, 113, 112, 113, 112, 111, 111, 111, 111, 110, 109, 110, 110, 109, 109, 109,
108, 108, 107, 107, 108, 107, 107, 106, 106, 105, 104, 105, 105, 104, 104, 103,
104, 103, 103, 102, 102, 102, 101, 102, 101, 101, 100, 101, 100, 100, 100, 99,
98, 98, 99, 98, 98, 98, 98, 97, 97, 97, 97, 97, 96, 96, 95, 96, 95, 95, 94, 95,
94, 94, 94, 94, 93, 93, 93, 93, 92, 92, 92, 91, 91, 91, 91, 91, 90, 90, 91, 89,
89, 89, 89, 88, 89, 88, 88, 88, 87, 87, 86, 87, 87, 87, 86, 85, 86, 84, 85, 84,
84, 83, 83, 83, 83, 83, 83, 82, 81, 81, 82, 81, 82, 81, 80, 79, 78, 77, 76, 75,
74, 73, 72, 71, 68, 67, 65, 64, 62, 60, 57, 54, 52, 49, 44, 40, 37, 33, 30, 27,
23, 19, 16, 13, 9, 5, 2, -2, -6, -10, -13, -16, -20, -24, -27, -30, -34, -37,
-40, -43, -47, -50, -51, -55, -58, -60, -63, -65, -68, -70, -72, -74, -77, -80,
-81, -83, -84, -87, -88, -90, -91, -93, -95, -97, -98, -99, -100, -102, -102,
-103, -104, -105, -107, -106, -108, -109, -109, -110, -110, -111, -112, -112,
-113, -113, -114, -114, -114, -114, -115, -115, -115, -115, -116, -115, -115,
-115, -115, -115, -114, -115, -115, -115, -114, -114, -114, -113, -114, -113,
-113, -113, -112, -113, -112, -112, -112, -111, -111, -110, -110, -111, -109,
-110, -110, -109, -109, -108, -108, -109, -108, -107, -108, -106, -106, -106,
-106, -105, -106, -105, -105, -104, -104, -104, -103, -103, -103, -102, -103,
-102, -102, -101, -101, -101, -101, -101, -100, -100, -99, -99, -100, -99, -98,
-98, -98, -98, -98, -97, -97, -97, -97, -96, -96, -95, -95, -95, -95, -95, -95,
-94, -95, -94, -94, -94, -94, -92, -93, -92, -92, -92, -92, -92, -91, -91, -91,
-91, -91, -91, -90, -90, -89, -90, -90, -89, -89, -88, -88, -88, -89, -88, -87,
-87, -87, -87, -87, -86, -87, -86, -85, -86, -85, -85, -84, -84, -85, -84, -84,
-83, -84, -83, -83, -83, -82, -82, -82, -81, -82, -81, -80, -80, -80, -79, -79,
-79, -78, -79, -78, -78, -77, -78, -77, -77, -76, -76, -76, -76, -76, -75, -75,
-74, -74, -73, -72, -71, -69, -69, -67, -66, -65, -64, -63, -60, -59, -57, -54,
-52, -49, -47, -42, -38, -35, -32, -28, -25, -22, -18, -15, -11, -8, -4, -1, };