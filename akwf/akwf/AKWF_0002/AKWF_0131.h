#define DATA_LENGTH 512
#define DATA AKWF_0131

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 3, 4, 5, 5, 7, 8, 9, 10, 12,
12, 13, 15, 16, 17, 17, 18, 19, 20, 21, 22, 23, 24, 24, 25, 27, 28, 28, 29, 30,
31, 32, 32, 34, 34, 35, 35, 37, 37, 38, 38, 39, 39, 40, 42, 42, 42, 44, 44, 45,
46, 46, 47, 47, 49, 49, 49, 50, 50, 52, 52, 52, 53, 53, 54, 55, 55, 56, 57, 57,
58, 58, 59, 59, 60, 60, 61, 61, 61, 62, 63, 63, 64, 64, 65, 66, 66, 65, 67, 67,
67, 68, 69, 69, 70, 71, 71, 70, 72, 72, 72, 73, 73, 74, 75, 75, 75, 76, 76, 76,
77, 77, 78, 78, 78, 79, 79, 80, 80, 81, 81, 82, 82, 83, 83, 83, 83, 84, 84, 85,
85, 86, 87, 87, 87, 87, 88, 88, 88, 89, 89, 90, 91, 89, 91, 91, 91, 92, 92, 93,
93, 93, 93, 94, 94, 95, 96, 96, 96, 96, 98, 97, 98, 97, 99, 99, 99, 100, 100,
100, 100, 101, 101, 102, 102, 103, 102, 103, 103, 104, 104, 105, 105, 105, 105,
105, 106, 106, 107, 108, 108, 109, 108, 109, 108, 109, 110, 110, 111, 112, 111,
111, 112, 113, 113, 113, 113, 113, 114, 115, 115, 116, 116, 116, 116, 116, 116,
117, 117, 119, 119, 118, 119, 119, 118, 115, 111, 107, 102, 95, 90, 82, 73, 64,
55, 47, 40, 34, 30, 24, 20, 15, 13, 10, 6, 4, 1, -2, -4, -7, -10, -12, -14, -17,
-20, -21, -25, -26, -29, -32, -34, -37, -39, -42, -44, -46, -49, -51, -53, -55,
-58, -60, -62, -63, -66, -67, -69, -70, -73, -74, -76, -77, -79, -80, -81, -83,
-84, -85, -86, -87, -88, -90, -90, -91, -92, -92, -93, -94, -95, -94, -95, -96,
-97, -97, -98, -98, -98, -99, -99, -100, -99, -100, -100, -100, -100, -101,
-100, -101, -100, -102, -101, -101, -101, -101, -101, -101, -101, -101, -101,
-101, -100, -101, -100, -100, -100, -100, -99, -100, -100, -99, -98, -99, -98,
-98, -98, -97, -98, -97, -98, -96, -96, -96, -96, -95, -95, -95, -95, -95, -94,
-94, -94, -93, -93, -92, -92, -91, -91, -91, -91, -91, -90, -90, -90, -89, -89,
-88, -89, -88, -88, -87, -86, -87, -86, -85, -86, -85, -85, -84, -83, -84, -83,
-83, -82, -82, -82, -81, -80, -80, -80, -79, -79, -78, -78, -77, -77, -77, -76,
-76, -76, -75, -75, -75, -73, -74, -73, -73, -72, -72, -71, -71, -70, -70, -69,
-69, -69, -69, -67, -67, -67, -66, -66, -66, -65, -65, -64, -64, -63, -62, -62,
-62, -61, -61, -60, -60, -59, -58, -58, -57, -57, -57, -55, -55, -55, -55, -54,
-54, -53, -52, -52, -51, -50, -50, -50, -49, -49, -48, -47, -47, -46, -44, -44,
-44, -44, -42, -42, -41, -40, -40, -39, -38, -37, -36, -35, -36, -34, -33, -32,
-32, -30, -30, -28, -26, -25, -20, -18, -18, -16, -14, -12, -11, -11, -9, -8,
-6, -6, -6, -4, -3, -2, 0, };