#define DATA_LENGTH 512
#define DATA AKWF_0126

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 6, 8, 11, 12, 14, 16, 17, 19,
20, 22, 24, 25, 26, 28, 30, 31, 32, 34, 35, 37, 37, 39, 40, 41, 41, 43, 44, 45,
46, 48, 48, 50, 50, 51, 53, 53, 54, 55, 57, 57, 58, 58, 60, 60, 62, 62, 62, 63,
64, 65, 66, 66, 67, 67, 68, 69, 70, 71, 71, 71, 71, 73, 73, 74, 75, 75, 75, 77,
77, 77, 78, 79, 80, 80, 80, 81, 81, 81, 82, 83, 84, 85, 84, 85, 86, 85, 86, 87,
87, 87, 87, 88, 89, 90, 90, 90, 91, 91, 92, 92, 92, 93, 93, 94, 94, 94, 95, 96,
96, 96, 97, 97, 97, 97, 98, 99, 99, 99, 100, 100, 101, 100, 102, 101, 102, 102,
103, 102, 104, 103, 104, 104, 105, 104, 105, 105, 105, 105, 106, 107, 108, 107,
108, 108, 108, 108, 109, 109, 110, 109, 110, 110, 111, 111, 111, 111, 111, 112,
111, 113, 113, 112, 113, 113, 114, 114, 113, 115, 114, 114, 115, 116, 115, 116,
116, 115, 116, 115, 116, 117, 117, 117, 117, 116, 117, 118, 117, 117, 117, 118,
118, 118, 118, 118, 118, 117, 119, 119, 118, 118, 118, 119, 119, 119, 118, 119,
119, 119, 119, 118, 119, 119, 118, 119, 119, 120, 119, 119, 119, 118, 118, 118,
116, 116, 115, 112, 110, 107, 105, 101, 98, 94, 90, 86, 82, 76, 71, 67, 60, 55,
50, 44, 37, 31, 26, 20, 14, 8, 3, -3, -9, -14, -19, -25, -29, -34, -38, -43,
-47, -50, -54, -58, -60, -63, -66, -70, -72, -75, -78, -80, -82, -84, -87, -88,
-90, -91, -93, -95, -97, -97, -99, -100, -101, -102, -103, -104, -105, -106,
-107, -107, -108, -109, -109, -109, -110, -111, -111, -112, -112, -112, -112,
-114, -114, -114, -115, -114, -115, -115, -115, -114, -115, -116, -115, -115,
-115, -116, -116, -116, -115, -117, -116, -115, -116, -116, -115, -115, -115,
-116, -116, -116, -115, -115, -115, -115, -115, -114, -115, -114, -113, -114,
-114, -113, -113, -113, -113, -112, -112, -113, -112, -111, -111, -111, -111,
-112, -111, -111, -110, -110, -109, -110, -109, -109, -109, -108, -108, -107,
-107, -106, -107, -106, -107, -106, -106, -106, -105, -104, -104, -104, -103,
-103, -103, -103, -102, -101, -101, -101, -101, -101, -100, -100, -100, -99,
-99, -99, -98, -97, -97, -97, -97, -96, -95, -95, -96, -95, -95, -94, -94, -93,
-92, -92, -92, -91, -91, -91, -90, -90, -89, -89, -88, -88, -88, -87, -87, -86,
-85, -85, -85, -84, -84, -83, -82, -83, -82, -81, -80, -81, -79, -79, -79, -78,
-77, -76, -77, -76, -76, -76, -75, -73, -73, -72, -72, -72, -70, -71, -70, -69,
-68, -68, -67, -65, -65, -64, -64, -63, -62, -62, -61, -60, -60, -59, -58, -57,
-55, -55, -54, -53, -52, -50, -49, -48, -47, -45, -44, -43, -41, -41, -39, -38,
-36, -35, -33, -32, -30, -28, -27, -25, -23, -21, -20, -17, -16, -14, -12, -9,
-8, -6, -3, -2, -1, };