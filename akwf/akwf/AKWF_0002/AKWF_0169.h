#define DATA_LENGTH 512
#define DATA AKWF_0169

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 12, 21, 28, 36, 43, 49, 57, 63, 69,
76, 79, 84, 90, 94, 98, 101, 103, 107, 110, 111, 114, 116, 116, 117, 118, 117,
118, 117, 116, 114, 112, 109, 106, 103, 97, 94, 87, 82, 77, 70, 64, 57, 51, 43,
36, 29, 21, 14, 6, -1, -9, -17, -24, -31, -38, -44, -49, -54, -56, -61, -64,
-67, -70, -72, -74, -77, -78, -80, -82, -82, -85, -86, -86, -88, -89, -90, -91,
-91, -90, -92, -91, -92, -91, -91, -89, -87, -85, -81, -78, -74, -70, -65, -60,
-55, -47, -42, -35, -28, -21, -14, -6, 1, 9, 17, 24, 31, 39, 46, 53, 59, 66, 72,
78, 83, 88, 93, 97, 101, 104, 108, 111, 112, 114, 116, 118, 119, 119, 119, 119,
117, 116, 115, 112, 109, 106, 102, 98, 93, 88, 83, 77, 72, 65, 58, 51, 45, 38,
31, 24, 18, 11, 5, -2, -7, -13, -18, -22, -25, -29, -31, -33, -34, -35, -35,
-35, -34, -33, -30, -27, -24, -20, -16, -11, -8, -3, 2, 7, 12, 17, 22, 27, 31,
35, 38, 43, 45, 47, 51, 53, 54, 54, 55, 55, 54, 52, 51, 49, 46, 43, 40, 37, 32,
28, 23, 19, 12, 7, 2, -4, -10, -16, -21, -27, -33, -37, -42, -46, -49, -53, -57,
-58, -61, -63, -65, -67, -68, -70, -72, -73, -73, -74, -76, -76, -76, -77, -77,
-76, -76, -74, -73, -70, -68, -64, -60, -55, -50, -45, -40, -34, -28, -22, -16,
-10, -3, 4, 11, 17, 24, 31, 38, 45, 52, 59, 64, 71, 76, 82, 88, 91, 96, 100,
104, 107, 108, 110, 112, 113, 113, 113, 112, 112, 111, 109, 107, 104, 102, 99,
95, 92, 89, 85, 81, 77, 73, 67, 62, 56, 51, 44, 38, 31, 25, 16, 9, 1, -6, -13,
-20, -26, -33, -38, -43, -47, -50, -54, -57, -60, -63, -65, -68, -70, -71, -74,
-76, -78, -79, -81, -83, -84, -85, -85, -87, -88, -88, -88, -89, -89, -89, -89,
-89, -89, -88, -87, -84, -82, -77, -72, -68, -61, -56, -49, -43, -36, -28, -21,
-14, -6, 1, 8, 15, 23, 30, 38, 45, 52, 58, 65, 71, 77, 82, 87, 92, 96, 100, 103,
105, 107, 109, 111, 112, 111, 111, 111, 109, 108, 106, 104, 102, 98, 95, 92, 89,
84, 80, 73, 68, 62, 54, 47, 41, 32, 23, 16, 6, -3, -12, -19, -26, -33, -38, -43,
-46, -50, -53, -55, -58, -60, -62, -63, -65, -66, -68, -68, -68, -68, -69, -68,
-67, -65, -63, -61, -58, -55, -52, -49, -45, -43, -39, -37, -34, -32, -29, -28,
-26, -24, -24, -23, -24, -24, -25, -25, -27, -29, -30, -33, -36, -38, -41, -46,
-49, -53, -56, -60, -65, -68, -74, -77, -80, -83, -86, -88, -90, -93, -94, -96,
-97, -99, -100, -101, -101, -103, -103, -104, -105, -105, -106, -106, -106,
-105, -105, -104, -101, -99, -97, -94, -92, -87, -82, -79, -73, -68, -63, -58,
-51, -44, -37, -30, -23, -16, -8, -2, };