#define DATA_LENGTH 512
#define DATA AKWF_0107

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, -2, -3, -4, -6, -7, -8, -10, -11,
-12, -13, -15, -17, -17, -18, -20, -21, -23, -24, -25, -26, -28, -29, -31, -32,
-33, -34, -35, -37, -38, -40, -40, -42, -42, -43, -45, -47, -47, -49, -50, -50,
-52, -53, -54, -55, -56, -57, -58, -59, -61, -62, -61, -62, -63, -65, -66, -66,
-68, -68, -69, -70, -71, -72, -73, -73, -74, -76, -76, -77, -77, -78, -79, -79,
-79, -81, -81, -82, -82, -83, -83, -84, -84, -85, -85, -85, -86, -86, -86, -87,
-87, -88, -87, -88, -89, -88, -89, -89, -90, -89, -89, -90, -90, -90, -90, -90,
-90, -90, -90, -90, -91, -89, -90, -90, -90, -90, -90, -90, -89, -89, -88, -88,
-87, -87, -88, -88, -93, -96, -97, -98, -100, -101, -102, -102, -102, -102,
-101, -101, -101, -100, -99, -98, -98, -98, -98, -97, -96, -96, -95, -95, -94,
-94, -93, -93, -93, -92, -92, -91, -91, -91, -90, -90, -89, -90, -89, -88, -89,
-88, -87, -87, -86, -86, -85, -85, -85, -84, -83, -82, -82, -81, -81, -80, -79,
-78, -78, -77, -77, -76, -76, -74, -73, -73, -71, -71, -71, -70, -69, -68, -66,
-66, -65, -64, -63, -62, -61, -60, -59, -59, -57, -57, -55, -54, -53, -53, -52,
-50, -49, -49, -47, -46, -45, -43, -42, -41, -40, -39, -38, -36, -36, -34, -33,
-33, -31, -29, -29, -28, -27, -25, -24, -22, -21, -20, -18, -18, -16, -16, -14,
-12, -12, -9, -8, -8, -7, -5, -5, -3, -1, -1, 1, 3, 3, 5, 5, 7, 9, 10, 12, 13,
14, 14, 16, 17, 19, 20, 21, 23, 24, 25, 26, 27, 28, 29, 31, 31, 33, 34, 36, 37,
38, 40, 40, 41, 43, 44, 45, 46, 47, 48, 50, 50, 51, 53, 53, 54, 55, 56, 57, 58,
59, 59, 61, 61, 63, 63, 64, 65, 65, 66, 68, 68, 69, 70, 70, 71, 73, 73, 74, 74,
74, 75, 76, 77, 77, 78, 78, 79, 80, 80, 80, 81, 81, 81, 83, 82, 83, 82, 83, 84,
84, 85, 86, 85, 85, 86, 86, 85, 86, 86, 87, 86, 87, 87, 87, 87, 87, 87, 87, 86,
86, 86, 87, 87, 86, 90, 96, 96, 97, 100, 101, 102, 103, 103, 102, 103, 103, 103,
101, 101, 101, 101, 100, 99, 99, 99, 99, 98, 98, 98, 99, 99, 97, 97, 97, 97, 96,
97, 97, 97, 96, 96, 95, 95, 94, 94, 94, 94, 94, 94, 93, 92, 92, 93, 92, 91, 90,
90, 90, 89, 89, 89, 88, 87, 87, 86, 85, 84, 84, 83, 83, 82, 80, 81, 80, 79, 78,
77, 76, 76, 75, 74, 73, 72, 71, 70, 69, 69, 68, 66, 65, 65, 64, 62, 62, 60, 59,
59, 57, 56, 55, 55, 53, 52, 51, 50, 48, 48, 46, 45, 44, 44, 42, 40, 40, 38, 38,
37, 34, 33, 31, 31, 30, 29, 27, 26, 25, 22, 22, 20, 19, 18, 17, 16, 15, 12, 11,
10, 9, 8, 6, 4, 3, 3, 1, };