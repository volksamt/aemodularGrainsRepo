#define DATA_LENGTH 512
#define DATA AKWF_0200

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 3, 4, 4, 6, 6, 6, 7, 8, 8,
10, 10, 11, 11, 12, 12, 13, 13, 14, 15, 15, 16, 17, 18, 17, 18, 18, 19, 20, 20,
20, 21, 21, 21, 22, 22, 22, 23, 23, 23, 24, 24, 26, 25, 25, 26, 26, 26, 26, 27,
28, 28, 28, 28, 28, 29, 28, 29, 29, 29, 29, 30, 30, 31, 30, 30, 31, 32, 31, 32,
32, 32, 33, 33, 33, 33, 34, 33, 34, 34, 34, 35, 35, 35, 35, 36, 36, 36, 37, 37,
38, 37, 39, 38, 38, 39, 39, 40, 41, 41, 41, 42, 42, 42, 43, 44, 43, 44, 45, 45,
46, 46, 46, 47, 47, 48, 48, 49, 50, 50, 51, 51, 53, 52, 53, 54, 54, 54, 56, 56,
57, 58, 59, 59, 59, 61, 61, 62, 63, 64, 64, 65, 64, 67, 67, 69, 68, 70, 70, 72,
71, 73, 74, 74, 75, 75, 78, 75, 79, 76, 82, 77, 84, 78, 87, 79, 88, 80, 91, 81,
92, 80, 98, 63, 40, 84, 29, 111, 36, 84, 57, 65, 87, 51, 89, 47, 82, 53, 72, 59,
65, 61, 62, 61, 59, 60, 58, 59, 56, 58, 55, 57, 53, 55, 50, 54, 50, 51, 49, 51,
47, 48, 46, 46, 45, 45, 43, 43, 42, 41, 40, 38, 36, 35, 34, 32, 30, 29, 28, 26,
26, 25, 24, 22, 21, 19, 18, 16, 15, 14, 12, 11, 9, 8, 7, 7, 6, 4, 4, 4, 3, 1, 0,
0, -1, -1, -2, -3, -4, -5, -6, -6, -8, -8, -9, -9, -9, -11, -11, -12, -13, -13,
-14, -15, -15, -16, -16, -17, -18, -19, -19, -20, -21, -21, -22, -22, -23, -23,
-24, -25, -24, -25, -25, -26, -27, -27, -27, -28, -28, -29, -30, -30, -31, -32,
-31, -33, -32, -33, -34, -34, -34, -34, -36, -37, -37, -36, -38, -38, -38, -38,
-39, -40, -39, -40, -41, -41, -41, -42, -42, -43, -43, -43, -44, -44, -44, -44,
-45, -45, -45, -46, -46, -47, -47, -48, -48, -48, -48, -49, -49, -49, -49, -49,
-50, -49, -50, -50, -51, -51, -51, -51, -51, -51, -51, -52, -51, -51, -52, -52,
-52, -52, -52, -52, -52, -52, -52, -52, -52, -52, -52, -52, -52, -52, -52, -52,
-53, -53, -53, -52, -52, -52, -51, -52, -52, -52, -51, -51, -53, -51, -51, -51,
-52, -52, -51, -51, -51, -51, -51, -51, -51, -50, -49, -50, -50, -50, -49, -49,
-49, -49, -49, -48, -48, -48, -49, -47, -48, -48, -47, -47, -46, -46, -45, -47,
-46, -46, -45, -46, -45, -45, -44, -45, -44, -44, -43, -43, -43, -42, -42, -41,
-42, -41, -41, -41, -41, -40, -40, -40, -39, -39, -39, -38, -38, -38, -38, -37,
-37, -36, -37, -36, -35, -35, -35, -34, -34, -33, -33, -33, -32, -32, -30, -30,
-28, -27, -26, -25, -24, -23, -22, -21, -20, -20, -19, -18, -17, -16, -15, -14,
-12, -12, -10, -8, -7, -6, -4, -3, -3, -3, -1, -2, 1, };