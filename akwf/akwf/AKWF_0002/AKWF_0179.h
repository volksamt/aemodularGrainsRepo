#define DATA_LENGTH 512
#define DATA AKWF_0179

const PROGMEM int8_t DATA[DATA_LENGTH] = {14, 25, 19, 23, 29, 35, 38, 41, 44,
46, 49, 51, 52, 53, 54, 55, 55, 55, 57, 57, 57, 58, 58, 58, 59, 59, 59, 60, 59,
60, 59, 60, 60, 59, 59, 60, 54, 1, -9, 2, -20, -32, -48, -56, -67, -75, -83,
-89, -94, -97, -100, -102, -105, -106, -109, -110, -111, -113, -114, -115, -116,
-117, -117, -117, -118, -119, -118, -119, -119, -119, -118, -119, -119, -120,
-110, -95, -100, -97, -90, -86, -82, -79, -75, -73, -71, -68, -67, -66, -66,
-65, -64, -64, -63, -62, -62, -62, -62, -60, -60, -60, -60, -60, -60, -59, -59,
-60, -59, -59, -60, -60, -60, -59, -59, -59, -59, -59, -59, -59, -60, -60, -60,
-59, -60, -59, -60, -60, -59, -60, -59, -60, -59, -60, -59, -60, -60, -59, -59,
-59, -60, -59, -59, -60, -60, -60, -59, -60, -60, -60, -59, -59, -60, -60, -60,
-60, -60, -59, -60, -60, -60, -60, -60, -60, -60, -59, -59, -59, -60, -59, -59,
-60, -60, -60, -59, -60, -60, -60, -60, -59, -60, -59, -59, -60, -60, -60, -59,
-59, -59, -60, -60, -60, -59, -60, -60, -60, -59, -59, -60, -60, -59, -59, -60,
-60, -59, -60, -60, -59, -59, -60, -60, -60, -59, -60, -60, -59, -60, -59, -59,
-60, -60, -60, -59, -60, -60, -59, -59, -59, -59, -59, -59, -59, -60, -60, -59,
-60, -60, -60, -60, -60, -59, -60, -59, -60, -60, -59, -60, -59, -60, -59, -59,
-59, -59, -60, -59, -59, -59, -60, -60, -60, -60, -59, -60, -60, -59, -60, -60,
-60, -60, -59, -59, -60, -59, -60, -60, -59, -59, -60, -59, -60, -60, -60, -60,
-59, -59, -59, -60, -60, -60, -59, -59, -60, -59, -61, -57, -39, -38, -40, -33,
-29, -23, -20, -17, -14, -12, -10, -8, -7, -7, -6, -4, -5, -4, -3, -3, -2, -2,
-1, -1, -1, -1, -1, 0, 0, -1, 0, 0, 1, 0, 0, -1, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0,
0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 1, 1, 0,
0, 0, 0, 0, 0, -1, 0, -1, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0,
0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 1, 1, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1,
-1, 0, 0, 1, 0, 0, 1, -1, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 1, 1, 0, 0, 0, 1,
0, -1, 0, 1, 0, -1, 1, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0,
0, 0, 1, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, };