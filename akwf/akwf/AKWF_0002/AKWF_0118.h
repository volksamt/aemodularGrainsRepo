#define DATA_LENGTH 512
#define DATA AKWF_0118

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 8, 13, 18, 21, 26, 29, 33, 36, 39,
42, 45, 47, 50, 52, 54, 57, 59, 61, 62, 64, 65, 68, 69, 70, 72, 74, 76, 77, 78,
79, 81, 82, 83, 85, 86, 87, 89, 89, 90, 92, 92, 93, 95, 95, 97, 97, 99, 100,
100, 100, 102, 102, 104, 104, 104, 105, 106, 106, 107, 107, 108, 108, 110, 110,
111, 111, 112, 112, 112, 113, 114, 113, 114, 114, 115, 115, 115, 115, 116, 116,
116, 116, 117, 117, 117, 118, 117, 117, 118, 118, 119, 118, 118, 118, 118, 118,
119, 118, 119, 118, 119, 120, 119, 119, 119, 119, 119, 120, 118, 119, 119, 120,
120, 119, 119, 119, 119, 119, 118, 118, 118, 118, 118, 118, 119, 117, 117, 117,
117, 117, 118, 117, 117, 116, 116, 116, 116, 116, 116, 116, 115, 115, 115, 115,
114, 114, 114, 114, 114, 113, 113, 113, 112, 112, 112, 112, 112, 111, 110, 111,
111, 110, 110, 109, 109, 109, 108, 108, 108, 109, 107, 107, 107, 107, 106, 106,
106, 106, 105, 105, 105, 105, 104, 103, 103, 102, 103, 103, 102, 102, 102, 101,
101, 101, 100, 100, 100, 100, 99, 100, 99, 98, 98, 98, 98, 97, 97, 97, 97, 96,
95, 95, 96, 95, 95, 95, 93, 94, 94, 94, 94, 93, 93, 92, 92, 92, 92, 91, 91, 91,
90, 90, 91, 90, 89, 90, 90, 89, 89, 88, 89, 89, 88, 87, 88, 88, 87, 87, 87, 87,
87, 86, 86, 86, 86, 86, 85, 84, 85, 85, 85, 84, 84, 84, 83, 83, 83, 83, 83, 82,
82, 83, 82, 82, 82, 82, 81, 81, 81, 82, 81, 80, 80, 80, 80, 80, 79, 80, 79, 79,
79, 78, 78, 78, 78, 78, 78, 77, 77, 77, 77, 77, 76, 77, 76, 76, 75, 75, 74, 75,
74, 75, 74, 74, 74, 73, 73, 73, 72, 70, 70, 68, 65, 65, 61, 59, 55, 51, 44, 37,
31, 24, 16, 8, 1, -6, -14, -22, -28, -35, -40, -46, -50, -54, -59, -63, -65,
-68, -71, -73, -76, -77, -80, -81, -82, -84, -85, -85, -87, -88, -90, -90, -91,
-92, -92, -93, -94, -94, -95, -95, -96, -96, -96, -97, -97, -97, -97, -98, -98,
-98, -99, -98, -98, -98, -98, -99, -99, -98, -98, -99, -99, -98, -98, -99, -98,
-99, -99, -99, -98, -99, -98, -98, -98, -98, -98, -97, -97, -98, -97, -97, -97,
-96, -96, -97, -96, -96, -96, -95, -96, -95, -95, -94, -94, -94, -94, -94, -93,
-93, -92, -92, -92, -92, -91, -91, -91, -91, -90, -90, -90, -89, -89, -89, -88,
-87, -87, -87, -86, -86, -86, -85, -84, -84, -83, -84, -82, -83, -82, -82, -81,
-81, -80, -80, -79, -79, -77, -78, -77, -77, -76, -75, -74, -74, -73, -73, -72,
-71, -70, -69, -69, -68, -67, -66, -65, -64, -62, -61, -61, -59, -59, -57, -56,
-55, -54, -52, -51, -50, -47, -46, -44, -41, -39, -37, -35, -31, -27, -22, -19,
-14, -10, -5, 0, };