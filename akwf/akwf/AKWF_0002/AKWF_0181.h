#define DATA_LENGTH 512
#define DATA AKWF_0181

const PROGMEM int8_t DATA[DATA_LENGTH] = {34, 43, 38, 41, 38, 40, 76, 82, 78,
81, 78, 81, 78, 80, 79, 81, 79, 79, 79, 80, 79, 80, 79, 80, 79, 79, 80, 79, 80,
79, 80, 79, 80, 78, 79, 79, 79, 79, 79, 79, 79, 80, 79, 79, 79, 80, 79, 79, 79,
80, 79, 80, 80, 79, 79, 80, 80, 80, 79, 80, 80, 79, 79, 79, 80, 80, 79, 79, 80,
79, 80, 80, 80, 79, 79, 79, 80, 80, 79, 79, 79, 79, 80, 80, 80, 80, 79, 80, 79,
79, 79, 79, 79, 79, 79, 79, 80, 79, 79, 79, 80, 79, 79, 79, 79, 80, 79, 79, 80,
79, 79, 79, 79, 79, 79, 80, 79, 80, 79, 80, 80, 80, 79, 79, 79, 79, 80, 80, 79,
80, 79, 79, 79, 79, 80, 79, 79, 79, 80, 80, 80, 79, 79, 80, 79, 80, 80, 79, 79,
79, 79, 79, 80, 79, 80, 80, 79, 79, 79, 80, 79, 80, 79, 79, 80, 79, 79, 79, 80,
79, 79, 79, 79, 80, 80, 79, 79, 79, 79, 80, 79, 80, 79, 80, 79, 80, 80, 79, 80,
79, 79, 79, 80, 79, 79, 79, 79, 79, 79, 80, 79, 79, 79, 79, 79, 79, 80, 79, 80,
80, 79, 80, 78, 79, 80, 79, 79, 79, 79, 80, 80, 79, 79, 80, 80, 79, 79, 79, 79,
79, 79, 79, 79, 79, 80, 79, 81, 78, 81, 78, 81, 78, 81, 77, 82, 70, 34, 45, 10,
-3, 1, 2, -15, -48, -34, -46, -77, -82, -76, -82, -76, -84, -118, -120, -117,
-120, -118, -120, -118, -120, -119, -119, -118, -120, -118, -120, -119, -118,
-118, -119, -119, -119, -120, -119, -119, -119, -119, -119, -118, -118, -119,
-119, -119, -118, -119, -120, -119, -119, -119, -119, -119, -119, -118, -118,
-120, -120, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -118,
-120, -119, -119, -119, -119, -119, -119, -120, -120, -120, -119, -118, -119,
-120, -120, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -120,
-118, -120, -119, -120, -118, -119, -120, -119, -119, -119, -120, -119, -119,
-119, -120, -119, -119, -118, -120, -119, -118, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-120, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -118, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -118, -119, -119, -119, -119, -119, -119,
-118, -120, -119, -120, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-118, -119, -119, -119, -118, -119, -119, -119, -119, -119, -120, -119, -120,
-119, -119, -119, -119, -119, -118, -118, -120, -119, -119, -119, -119, -119,
-118, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -120, -118, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-118, -122, -105, -73, -83, -75, -46, -28, 2, 0, 0, 0, 0, };