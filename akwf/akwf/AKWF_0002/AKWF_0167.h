#define DATA_LENGTH 512
#define DATA AKWF_0167

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 8, 10, 12, 14, 15, 17, 18,
20, 20, 21, 21, 21, 21, 20, 20, 19, 18, 16, 15, 13, 12, 10, 9, 8, 8, 6, 4, 4, 4,
3, 2, 2, 2, 1, 2, 2, 2, 1, 1, 3, 2, 3, 4, 4, 6, 7, 8, 11, 14, 17, 20, 25, 30,
34, 39, 45, 50, 55, 62, 67, 72, 77, 82, 87, 91, 95, 99, 102, 105, 107, 108, 108,
108, 107, 107, 104, 102, 99, 95, 91, 87, 82, 77, 71, 66, 60, 54, 47, 42, 35, 29,
21, 14, 7, 0, -8, -16, -24, -31, -38, -45, -52, -60, -66, -74, -78, -86, -90,
-95, -99, -103, -107, -109, -111, -113, -115, -116, -117, -118, -118, -118,
-119, -119, -119, -119, -118, -118, -117, -115, -115, -114, -113, -112, -111,
-111, -109, -108, -109, -109, -108, -109, -109, -110, -110, -111, -112, -112,
-113, -113, -113, -114, -113, -113, -113, -111, -109, -108, -106, -104, -102,
-99, -96, -93, -90, -87, -82, -79, -75, -71, -67, -62, -58, -53, -47, -42, -37,
-33, -27, -21, -18, -13, -7, -2, 3, 7, 11, 16, 22, 26, 32, 35, 41, 46, 50, 54,
57, 61, 65, 69, 70, 73, 76, 77, 79, 81, 82, 82, 84, 84, 86, 87, 88, 89, 90, 90,
90, 92, 92, 93, 92, 93, 92, 92, 91, 90, 90, 88, 87, 86, 85, 82, 81, 80, 78, 77,
75, 75, 73, 74, 73, 73, 73, 73, 72, 73, 72, 73, 72, 73, 73, 73, 74, 73, 73, 73,
72, 72, 71, 71, 70, 70, 68, 67, 66, 65, 63, 61, 59, 56, 53, 49, 47, 43, 40, 36,
33, 28, 25, 22, 19, 15, 12, 9, 6, 3, 1, -2, -5, -8, -12, -14, -17, -20, -24,
-27, -31, -35, -38, -42, -45, -49, -52, -54, -57, -60, -61, -62, -63, -63, -62,
-61, -61, -60, -58, -56, -53, -51, -47, -44, -42, -39, -35, -33, -30, -27, -25,
-22, -20, -18, -16, -14, -13, -13, -11, -11, -10, -10, -9, -8, -8, -8, -8, -7,
-7, -6, -6, -5, -5, -5, -5, -5, -5, -5, -4, -5, -5, -5, -5, -4, -4, -4, -2, -2,
0, 2, 5, 6, 10, 13, 15, 19, 22, 26, 29, 33, 38, 41, 45, 48, 52, 54, 58, 60, 64,
67, 69, 71, 72, 74, 74, 75, 75, 76, 75, 74, 73, 70, 68, 65, 62, 58, 54, 51, 46,
43, 39, 34, 30, 27, 22, 18, 15, 12, 9, 5, 2, -1, -3, -6, -9, -11, -14, -16, -18,
-19, -22, -23, -24, -26, -27, -28, -28, -29, -30, -30, -31, -32, -33, -33, -34,
-34, -34, -35, -35, -35, -34, -34, -34, -33, -33, -33, -31, -32, -32, -32, -32,
-31, -33, -34, -33, -35, -35, -36, -37, -37, -38, -37, -38, -38, -37, -38, -38,
-36, -37, -36, -36, -35, -36, -34, -36, -35, -36, -36, -37, -37, -36, -37, -38,
-36, -36, -36, -36, -35, -33, -31, -30, -28, -26, -23, -22, -19, -17, -15, -13,
-10, -8, -5, -3, -1, };