#define DATA_LENGTH 512
#define DATA AKWF_0163

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 11, 14, 17, 18, 22, 24, 27,
29, 31, 33, 34, 36, 38, 41, 42, 44, 45, 46, 48, 50, 51, 53, 54, 56, 57, 58, 60,
61, 63, 64, 66, 66, 68, 68, 70, 71, 73, 73, 75, 76, 77, 79, 80, 80, 82, 82, 84,
85, 86, 87, 88, 89, 89, 90, 91, 92, 93, 94, 96, 96, 97, 98, 98, 98, 100, 100,
101, 102, 102, 103, 104, 104, 105, 106, 106, 107, 108, 108, 108, 109, 109, 110,
110, 111, 112, 111, 113, 113, 113, 113, 114, 115, 114, 114, 115, 116, 116, 116,
116, 117, 118, 117, 117, 118, 118, 117, 118, 118, 118, 119, 119, 118, 118, 119,
118, 119, 119, 119, 120, 119, 119, 119, 118, 119, 118, 118, 119, 118, 118, 119,
118, 117, 117, 118, 117, 117, 116, 117, 117, 117, 116, 116, 116, 115, 115, 115,
114, 115, 113, 113, 113, 113, 112, 112, 111, 111, 110, 110, 109, 108, 109, 108,
108, 107, 106, 106, 106, 105, 105, 104, 103, 103, 102, 102, 101, 100, 100, 99,
99, 98, 97, 96, 96, 95, 95, 95, 93, 92, 92, 91, 90, 90, 89, 88, 88, 87, 86, 86,
84, 84, 83, 82, 81, 81, 81, 80, 79, 78, 78, 77, 76, 75, 74, 74, 72, 72, 72, 70,
70, 69, 69, 68, 67, 66, 65, 64, 64, 63, 62, 61, 61, 59, 59, 58, 57, 57, 55, 55,
55, 54, 53, 52, 52, 51, 49, 49, 48, 47, 47, 45, 45, 43, 44, 42, 42, 41, 40, 39,
38, 37, 37, 35, 35, 34, 32, 31, 31, 30, 30, 29, 28, 27, 26, 25, 24, 24, 24, 22,
21, 20, 20, 19, 18, 18, 17, 16, 15, 15, 13, 12, 12, 11, 11, 10, 10, 9, 7, 7, 6,
6, 5, 4, 3, 3, 2, 0, 1, 0, -1, -1, -2, -2, -3, -4, -5, -6, -7, -8, -10, -10,
-11, -14, -15, -17, -20, -22, -26, -29, -33, -36, -41, -45, -49, -53, -58, -62,
-66, -70, -73, -76, -78, -81, -84, -85, -87, -89, -91, -93, -93, -94, -96, -96,
-97, -99, -100, -100, -101, -102, -102, -103, -104, -104, -105, -105, -106,
-106, -107, -107, -107, -107, -107, -108, -108, -109, -109, -109, -108, -108,
-109, -108, -109, -109, -109, -109, -110, -109, -110, -110, -109, -109, -109,
-108, -109, -109, -108, -108, -108, -108, -108, -108, -107, -106, -106, -105,
-105, -105, -105, -105, -104, -104, -103, -103, -104, -102, -102, -101, -102,
-101, -100, -100, -99, -99, -98, -98, -97, -97, -97, -95, -95, -94, -94, -93,
-92, -92, -91, -90, -90, -90, -88, -88, -87, -86, -86, -85, -84, -83, -82, -82,
-81, -81, -81, -79, -78, -78, -76, -76, -75, -75, -73, -73, -72, -71, -71, -68,
-68, -67, -66, -65, -64, -63, -62, -61, -60, -59, -58, -57, -57, -55, -54, -53,
-51, -50, -50, -48, -46, -46, -45, -43, -42, -40, -39, -39, -37, -35, -34, -32,
-30, -29, -28, -26, -23, -21, -19, -15, -13, -10, -6, -4, -1, };