#define DATA_LENGTH 512
#define DATA AKWF_0189

const PROGMEM int8_t DATA[DATA_LENGTH] = {30, 35, 33, 35, 33, 34, 33, 34, 34,
34, 33, 34, 33, 34, 33, 34, 34, 33, 34, 34, 33, 34, 34, 34, 34, 34, 33, 34, 35,
34, 34, 33, 33, 33, 33, 34, 34, 34, 33, 33, 33, 34, 34, 35, 34, 34, 34, 33, 33,
34, 33, 34, 34, 34, 33, 34, 34, 33, 63, 69, 66, 69, 67, 68, 67, 68, 67, 67, 67,
68, 66, 68, 67, 67, 68, 67, 68, 68, 67, 67, 68, 67, 67, 67, 68, 67, 67, 67, 68,
67, 68, 68, 67, 67, 68, 68, 68, 68, 67, 68, 67, 67, 68, 68, 68, 68, 67, 67, 67,
68, 68, 68, 67, 68, 67, 68, 68, 68, 66, 67, 68, 67, 68, 68, 67, 68, 67, 67, 67,
67, 67, 68, 67, 68, 68, 67, 67, 68, 68, 68, 68, 67, 67, 67, 67, 67, 68, 68, 68,
67, 67, 67, 67, 68, 68, 66, 69, 65, 29, 46, 74, 40, 33, 34, 33, 33, 33, 32, 35,
32, 38, 18, -4, 2, -2, 1, -1, 2, 0, 1, 0, 1, -1, 0, -1, 1, -3, -35, -33, -35,
-33, -33, -34, -34, -34, -33, -34, -33, -34, -34, -34, -33, -35, -33, -35, -32,
-35, -32, -35, -31, -43, -70, -66, -68, -67, -68, -67, -67, -67, -67, -67, -67,
-67, -67, -67, -67, -68, -68, -67, -67, -68, -67, -68, -68, -67, -67, -67, -67,
-67, -68, -68, -67, -68, -68, -67, -67, -67, -68, -67, -68, -67, -67, -67, -68,
-67, -68, -66, -69, -63, -88, -105, -100, -102, -100, -102, -100, -102, -101,
-101, -101, -101, -100, -101, -101, -101, -101, -101, -101, -100, -101, -102,
-101, -102, -101, -100, -101, -100, -101, -101, -102, -100, -100, -101, -102,
-101, -101, -101, -102, -101, -101, -101, -101, -101, -101, -101, -101, -101,
-101, -100, -101, -100, -100, -101, -101, -101, -101, -101, -101, -101, -100,
-101, -101, -101, -102, -102, -101, -101, -100, -101, -101, -101, -100, -101,
-100, -101, -102, -101, -100, -101, -101, -101, -102, -101, -102, -101, -101,
-101, -101, -101, -101, -101, -101, -101, -102, -101, -100, -101, -100, -102,
-101, -101, -101, -101, -102, -101, -102, -101, -102, -101, -100, -102, -102,
-101, -101, -101, -101, -101, -101, -101, -101, -101, -101, -101, -101, -101,
-101, -101, -101, -101, -101, -101, -101, -101, -101, -101, -101, -102, -101,
-102, -101, -101, -101, -101, -101, -102, -100, -101, -100, -102, -99, -102,
-99, -104, -93, -65, -69, -67, -68, -68, -67, -68, -67, -68, -66, -68, -66, -67,
-67, -67, -67, -68, -67, -68, -67, -67, -67, -67, -68, -68, -67, -66, -68, -67,
-68, -67, -68, -67, -68, -67, -68, -67, -68, -66, -35, -32, -34, -33, -34, -34,
-35, -33, -34, -33, -33, -33, -34, -34, -34, -33, -34, -33, -33, -34, -33, -33,
-34, -33, -34, -33, -37, -10, 3, -2, 1, -1, 1, -1, 1, 0, 0, -1, 0, -1, -1, 0, 0,
0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 1, -1, 0, 0, };