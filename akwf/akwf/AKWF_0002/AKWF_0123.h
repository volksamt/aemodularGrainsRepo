#define DATA_LENGTH 512
#define DATA AKWF_0123

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 8, 11, 13, 16, 19, 21, 24, 26,
29, 31, 34, 36, 38, 40, 41, 44, 46, 48, 49, 51, 53, 55, 56, 57, 58, 60, 62, 64,
64, 65, 66, 69, 68, 70, 70, 72, 73, 74, 74, 75, 76, 77, 77, 77, 78, 79, 79, 80,
80, 81, 82, 82, 83, 83, 82, 83, 84, 84, 84, 84, 85, 85, 85, 85, 85, 85, 86, 86,
85, 86, 85, 85, 85, 85, 86, 85, 85, 85, 85, 86, 85, 85, 84, 85, 85, 84, 84, 84,
84, 83, 83, 83, 83, 83, 82, 82, 81, 81, 82, 80, 80, 81, 80, 80, 79, 79, 78, 78,
78, 78, 77, 77, 77, 76, 76, 76, 75, 75, 74, 74, 74, 73, 72, 72, 71, 72, 71, 71,
71, 71, 69, 69, 69, 68, 69, 68, 67, 67, 67, 66, 66, 66, 65, 65, 64, 64, 64, 63,
62, 62, 62, 62, 61, 61, 59, 59, 59, 58, 58, 58, 58, 56, 57, 56, 56, 56, 55, 54,
54, 54, 53, 53, 53, 52, 51, 51, 51, 51, 50, 50, 49, 50, 50, 49, 48, 47, 47, 47,
48, 47, 45, 45, 45, 45, 45, 45, 44, 44, 44, 42, 43, 42, 41, 41, 42, 40, 41, 40,
40, 40, 40, 40, 38, 38, 39, 39, 38, 38, 37, 37, 36, 36, 35, 35, 36, 35, 35, 34,
34, 34, 33, 33, 33, 33, 32, 33, 31, 32, 31, 31, 31, 31, 30, 30, 29, 30, 29, 29,
29, 28, 28, 28, 28, 27, 27, 27, 27, 27, 27, 26, 26, 26, 25, 25, 25, 24, 24, 25,
25, 24, 25, 23, 23, 23, 23, 22, 23, 22, 22, 21, 21, 21, 21, 22, 21, 21, 21, 20,
20, 20, 19, 19, 20, 20, 19, 18, 18, 19, 19, 18, 18, 18, 17, 18, 18, 17, 17, 17,
18, 16, 17, 17, 16, 17, 16, 16, 16, 16, 15, 15, 14, 13, 10, 6, 3, 0, -5, -9,
-14, -18, -21, -25, -28, -32, -35, -39, -42, -46, -49, -52, -55, -58, -61, -63,
-65, -69, -70, -73, -75, -78, -79, -81, -84, -85, -87, -89, -91, -92, -94, -95,
-97, -98, -99, -100, -102, -103, -103, -106, -106, -107, -109, -109, -109, -110,
-111, -112, -112, -113, -114, -114, -114, -116, -116, -116, -117, -117, -118,
-117, -117, -118, -118, -118, -118, -118, -119, -119, -119, -119, -119, -120,
-119, -118, -119, -119, -119, -118, -119, -119, -118, -118, -117, -117, -117,
-117, -117, -116, -116, -117, -115, -115, -114, -114, -114, -114, -113, -112,
-112, -112, -112, -111, -111, -110, -111, -109, -109, -109, -109, -108, -108,
-106, -107, -106, -105, -105, -104, -104, -102, -102, -103, -101, -101, -101,
-100, -100, -99, -99, -97, -97, -97, -96, -95, -95, -94, -94, -92, -92, -92,
-92, -91, -90, -90, -90, -88, -88, -87, -86, -86, -85, -85, -85, -85, -84, -83,
-82, -81, -80, -79, -78, -76, -74, -71, -69, -66, -62, -59, -55, -52, -47, -43,
-39, -35, -30, -26, -22, -19, -16, -12, -8, -4, -2, };