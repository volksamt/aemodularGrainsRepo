#define DATA_LENGTH 512
#define DATA AKWF_0119

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 13, 16, 19, 22, 24, 27,
29, 33, 34, 36, 39, 42, 44, 45, 48, 50, 52, 55, 57, 58, 61, 63, 64, 67, 68, 71,
73, 75, 76, 78, 81, 82, 84, 86, 88, 91, 92, 94, 96, 97, 98, 99, 102, 103, 105,
106, 108, 109, 110, 111, 113, 113, 114, 115, 116, 116, 117, 117, 118, 118, 119,
118, 120, 119, 118, 119, 119, 118, 118, 117, 117, 116, 116, 115, 116, 114, 113,
112, 111, 111, 109, 107, 107, 105, 104, 103, 102, 100, 99, 97, 95, 94, 91, 90,
88, 86, 84, 82, 80, 79, 77, 74, 72, 70, 67, 66, 63, 60, 59, 55, 54, 51, 48, 45,
41, 38, 35, 31, 26, 23, 19, 14, 11, 8, 4, 1, -3, -6, -9, -11, -13, -16, -18,
-20, -22, -23, -25, -25, -26, -28, -28, -29, -31, -30, -31, -31, -32, -32, -32,
-32, -32, -32, -32, -32, -32, -31, -31, -31, -31, -31, -30, -29, -29, -29, -28,
-28, -28, -27, -26, -26, -24, -24, -23, -23, -23, -21, -20, -21, -20, -19, -19,
-18, -16, -16, -16, -15, -14, -14, -13, -12, -12, -11, -11, -10, -10, -9, -8,
-9, -10, -9, -9, -9, -10, -9, -10, -10, -11, -11, -11, -13, -13, -14, -16, -15,
-17, -18, -19, -20, -21, -23, -24, -25, -27, -28, -29, -31, -32, -34, -35, -36,
-37, -40, -41, -43, -43, -46, -46, -48, -49, -49, -51, -52, -54, -54, -54, -55,
-56, -55, -57, -56, -57, -58, -57, -58, -57, -57, -57, -56, -56, -55, -55, -54,
-53, -53, -52, -51, -50, -50, -49, -48, -47, -46, -45, -45, -44, -43, -42, -40,
-40, -39, -37, -36, -35, -34, -32, -30, -29, -27, -26, -24, -22, -20, -18, -16,
-13, -11, -8, -5, -3, -1, 2, 4, 6, 7, 9, 12, 14, 15, 17, 18, 19, 20, 21, 22, 24,
25, 27, 28, 28, 28, 30, 30, 31, 32, 33, 33, 33, 34, 34, 35, 35, 34, 35, 35, 35,
35, 35, 35, 35, 35, 34, 34, 34, 33, 34, 34, 33, 32, 31, 31, 30, 29, 28, 29, 27,
26, 25, 24, 23, 22, 20, 19, 17, 15, 12, 10, 7, 5, 3, 0, -3, -4, -7, -9, -11,
-14, -16, -19, -21, -23, -25, -27, -29, -31, -33, -35, -36, -39, -41, -43, -44,
-46, -47, -50, -51, -52, -55, -56, -57, -59, -61, -62, -64, -64, -66, -66, -69,
-69, -70, -71, -72, -74, -74, -76, -76, -77, -78, -79, -80, -82, -82, -83, -83,
-84, -84, -84, -85, -86, -86, -86, -87, -88, -87, -88, -88, -89, -88, -89, -89,
-89, -88, -89, -89, -89, -89, -89, -88, -88, -88, -87, -87, -87, -87, -85, -85,
-84, -84, -84, -83, -83, -81, -81, -80, -79, -79, -78, -77, -76, -76, -74, -73,
-71, -70, -69, -68, -68, -66, -66, -64, -63, -61, -60, -59, -57, -56, -55, -53,
-51, -50, -48, -47, -45, -43, -41, -39, -37, -36, -33, -31, -29, -26, -22, -19,
-15, -12, -8, -5, -2, };