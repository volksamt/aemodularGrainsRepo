#define DATA_LENGTH 512
#define DATA AKWF_0182

const PROGMEM int8_t DATA[DATA_LENGTH] = {34, 42, 38, 41, 38, 40, 39, 40, 39,
40, 39, 40, 40, 40, 39, 39, 40, 39, 39, 40, 39, 39, 39, 40, 40, 39, 40, 39, 39,
39, 40, 39, 40, 39, 40, 39, 40, 40, 41, 39, 39, 39, 40, 39, 40, 40, 39, 40, 40,
40, 40, 39, 40, 40, 39, 41, 39, 41, 38, 42, 35, 60, 84, 77, 81, 79, 80, 78, 79,
79, 80, 79, 80, 79, 80, 80, 79, 80, 78, 79, 79, 79, 79, 79, 80, 79, 80, 80, 79,
79, 79, 79, 80, 80, 79, 80, 79, 80, 79, 79, 79, 80, 79, 80, 79, 79, 79, 79, 80,
80, 79, 80, 79, 80, 79, 80, 79, 79, 79, 79, 79, 79, 79, 79, 79, 79, 80, 79, 80,
79, 80, 79, 80, 79, 80, 79, 80, 79, 81, 77, 41, 39, 41, 39, 41, 39, 40, 39, 40,
39, 40, 39, 40, 39, 40, 39, 41, 40, 40, 39, 39, 40, 40, 40, 40, 40, 40, 40, 40,
40, 40, 40, 39, 40, 39, 40, 39, 40, 38, 41, 35, -1, 0, 0, 0, 0, -1, 0, -1, 0, 0,
1, -1, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, -1, 1, 0, 0, -1, 0, 0, -1, 1, 0, 1, -1, 2,
-3, 4, -23, -44, -37, -41, -39, -41, -39, -40, -39, -41, -40, -40, -40, -40,
-40, -40, -40, -40, -40, -39, -40, -39, -40, -39, -40, -39, -39, -41, -39, -39,
-40, -40, -40, -41, -39, -41, -38, -43, -35, -53, -83, -77, -81, -79, -79, -79,
-80, -79, -79, -80, -79, -79, -80, -80, -79, -79, -79, -80, -79, -79, -79, -80,
-79, -80, -79, -79, -79, -79, -79, -79, -80, -79, -79, -79, -79, -79, -80, -79,
-79, -79, -80, -79, -80, -79, -80, -79, -80, -79, -80, -79, -80, -78, -80, -78,
-82, -77, -87, -122, -118, -119, -119, -120, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -118, -119, -120, -120, -120, -119, -120,
-118, -119, -120, -119, -119, -119, -119, -118, -119, -119, -119, -120, -120,
-118, -118, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -118, -119, -119, -119, -118, -119, -118, -120,
-118, -120, -118, -121, -113, -78, -80, -79, -79, -80, -78, -80, -78, -80, -79,
-81, -79, -80, -79, -80, -79, -80, -80, -80, -79, -79, -80, -79, -80, -80, -79,
-79, -79, -79, -80, -78, -80, -79, -81, -79, -80, -78, -81, -77, -83, -72, -37,
-41, -39, -39, -40, -40, -40, -40, -40, -39, -40, -39, -39, -40, -40, -39, -41,
-40, -39, -39, -39, -40, -40, -40, -40, -39, -40, -40, -40, -39, -41, -38, -42,
-36, -44, -25, 4, -2, 2, -1, 1, 0, 0, -1, 1, 1, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, };