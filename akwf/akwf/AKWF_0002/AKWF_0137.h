#define DATA_LENGTH 512
#define DATA AKWF_0137

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 8, 10, 14, 16, 19, 22, 26, 29,
32, 34, 39, 41, 43, 46, 50, 52, 54, 57, 59, 62, 64, 66, 69, 71, 72, 75, 77, 77,
79, 82, 83, 84, 85, 87, 88, 89, 89, 90, 91, 93, 93, 94, 94, 95, 96, 96, 97, 98,
97, 97, 98, 98, 98, 98, 98, 98, 98, 97, 97, 98, 98, 97, 97, 97, 96, 96, 96, 95,
95, 94, 94, 93, 93, 92, 92, 92, 91, 91, 90, 89, 89, 89, 88, 87, 87, 87, 86, 86,
84, 85, 84, 83, 82, 82, 81, 81, 81, 80, 79, 79, 78, 77, 78, 77, 76, 76, 76, 75,
75, 74, 73, 73, 73, 72, 71, 71, 70, 69, 66, 64, 59, 56, 52, 49, 47, 45, 43, 41,
40, 37, 35, 30, 26, 23, 19, 16, 12, 9, 6, 2, -1, -4, -6, -11, -13, -16, -20,
-23, -26, -29, -32, -35, -37, -40, -42, -46, -47, -50, -53, -55, -57, -60, -62,
-63, -64, -66, -69, -71, -71, -73, -75, -76, -77, -78, -79, -80, -81, -82, -83,
-84, -84, -84, -85, -85, -86, -86, -87, -87, -87, -88, -88, -89, -89, -87, -88,
-89, -88, -88, -87, -87, -87, -87, -87, -86, -86, -86, -84, -85, -84, -84, -82,
-80, -77, -73, -69, -66, -63, -60, -58, -56, -54, -51, -48, -45, -43, -38, -35,
-30, -27, -23, -19, -16, -12, -9, -5, -2, 2, 5, 8, 12, 15, 19, 22, 25, 28, 31,
34, 37, 39, 42, 45, 47, 50, 52, 55, 57, 59, 60, 63, 66, 66, 68, 69, 71, 73, 74,
75, 76, 77, 78, 80, 81, 81, 82, 82, 83, 83, 84, 84, 86, 85, 85, 86, 85, 86, 86,
86, 85, 86, 86, 85, 85, 85, 84, 85, 84, 83, 83, 83, 82, 82, 81, 81, 81, 80, 79,
79, 77, 77, 77, 76, 76, 75, 75, 74, 74, 72, 73, 72, 71, 70, 70, 69, 68, 66, 64,
62, 58, 54, 51, 47, 44, 41, 40, 38, 36, 34, 30, 27, 24, 19, 15, 11, 8, 4, 2, -3,
-6, -9, -12, -15, -19, -23, -26, -28, -32, -35, -39, -41, -44, -47, -50, -53,
-55, -57, -60, -63, -64, -67, -69, -70, -72, -75, -75, -78, -79, -80, -82, -83,
-85, -86, -87, -87, -89, -90, -90, -92, -93, -93, -93, -94, -93, -94, -95, -95,
-95, -95, -95, -95, -95, -95, -95, -94, -96, -94, -94, -94, -93, -94, -93, -92,
-93, -92, -91, -91, -91, -90, -90, -89, -89, -87, -88, -87, -87, -85, -85, -84,
-84, -83, -83, -82, -81, -81, -80, -80, -79, -79, -78, -77, -77, -76, -75, -75,
-74, -73, -73, -73, -72, -71, -71, -71, -70, -69, -69, -68, -68, -67, -67, -67,
-66, -66, -65, -65, -65, -64, -63, -64, -63, -63, -63, -62, -62, -61, -61, -62,
-61, -61, -60, -60, -59, -59, -59, -58, -58, -58, -58, -57, -57, -57, -56, -54,
-52, -49, -47, -44, -41, -38, -35, -33, -31, -29, -27, -24, -22, -20, -16, -12,
-8, -5, -2, };