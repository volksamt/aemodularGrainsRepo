#define DATA_LENGTH 512
#define DATA AKWF_0145

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 9, 11, 13, 16, 19, 22, 26,
32, 37, 40, 43, 46, 49, 52, 55, 59, 62, 65, 68, 72, 75, 78, 81, 83, 87, 89, 91,
93, 95, 97, 98, 100, 101, 104, 104, 105, 106, 107, 107, 108, 109, 110, 110, 110,
110, 110, 110, 111, 110, 110, 109, 108, 108, 107, 108, 107, 107, 104, 104, 104,
103, 101, 100, 99, 98, 98, 96, 94, 93, 92, 91, 89, 87, 86, 85, 83, 82, 80, 78,
76, 75, 74, 72, 70, 69, 67, 65, 64, 61, 59, 58, 56, 54, 52, 51, 49, 47, 45, 42,
41, 39, 37, 35, 34, 31, 30, 28, 25, 24, 22, 20, 19, 16, 14, 12, 10, 8, 7, 5, 3,
1, -2, -5, -12, -17, -21, -26, -29, -33, -38, -41, -46, -50, -54, -59, -63, -66,
-71, -75, -79, -83, -87, -90, -93, -96, -99, -101, -104, -106, -108, -110, -112,
-114, -114, -116, -117, -117, -118, -118, -118, -119, -118, -119, -118, -118,
-117, -116, -116, -114, -112, -111, -109, -107, -105, -104, -101, -99, -97, -94,
-90, -88, -84, -80, -72, -64, -58, -54, -49, -45, -40, -35, -30, -25, -19, -14,
-9, -4, 1, 7, 12, 16, 21, 25, 29, 33, 37, 40, 45, 48, 50, 53, 56, 59, 61, 63,
66, 67, 69, 70, 72, 74, 75, 76, 77, 79, 79, 79, 80, 80, 81, 80, 81, 81, 81, 81,
80, 80, 79, 79, 78, 78, 77, 77, 75, 74, 72, 72, 70, 69, 68, 66, 65, 64, 62, 61,
59, 57, 56, 54, 52, 50, 48, 46, 45, 43, 40, 39, 37, 35, 33, 31, 29, 26, 25, 22,
20, 18, 16, 13, 11, 9, 7, 4, 2, -1, -3, -7, -10, -16, -21, -24, -28, -31, -34,
-36, -41, -43, -47, -51, -55, -57, -60, -64, -67, -71, -72, -75, -77, -79, -82,
-83, -86, -88, -89, -91, -92, -93, -94, -95, -97, -97, -97, -98, -98, -98, -99,
-99, -99, -99, -99, -98, -98, -98, -98, -98, -98, -96, -97, -95, -95, -94, -92,
-93, -90, -90, -87, -86, -85, -83, -81, -80, -78, -76, -73, -71, -68, -66, -59,
-51, -46, -42, -39, -36, -31, -27, -23, -18, -13, -8, -3, 1, 5, 9, 14, 18, 22,
26, 30, 33, 37, 41, 44, 47, 50, 52, 55, 58, 60, 62, 64, 66, 68, 70, 72, 74, 74,
75, 75, 76, 75, 75, 75, 74, 75, 74, 74, 72, 72, 70, 68, 66, 64, 62, 59, 54, 46,
40, 37, 34, 30, 25, 21, 18, 12, 8, 3, -1, -6, -10, -14, -19, -23, -27, -31, -35,
-37, -41, -44, -47, -49, -52, -55, -56, -59, -60, -62, -64, -65, -67, -68, -69,
-71, -72, -72, -72, -74, -74, -73, -73, -74, -74, -73, -73, -73, -73, -72, -71,
-71, -70, -69, -69, -68, -66, -65, -64, -62, -61, -60, -59, -57, -56, -54, -52,
-51, -49, -47, -45, -44, -42, -41, -37, -37, -34, -32, -30, -29, -26, -23, -23,
-21, -18, -16, -14, -12, -9, -7, -4, -3, 0, };