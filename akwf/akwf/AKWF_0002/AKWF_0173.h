#define DATA_LENGTH 512
#define DATA AKWF_0173

const PROGMEM int8_t DATA[DATA_LENGTH] = {35, 42, 38, 40, 38, 41, 39, 41, 40,
41, 39, 41, 39, 40, 39, 40, 40, 39, 40, 40, 39, 40, 39, 40, 40, 40, 40, 39, 40,
39, 40, 40, 40, 40, 40, 39, 40, 39, 40, 40, 39, 40, 40, 40, 40, 40, 39, 40, 39,
40, 40, 40, 40, 40, 40, 40, 40, 40, 39, 40, 40, 39, 39, 40, 40, 40, 40, 40, 39,
40, 40, 39, 40, 40, 40, 39, 40, 39, 40, 39, 40, 39, 41, 39, 40, 39, 40, 76, 81,
78, 80, 78, 80, 79, 80, 79, 80, 79, 80, 79, 79, 80, 79, 80, 80, 80, 80, 79, 80,
79, 79, 79, 79, 79, 80, 80, 79, 80, 80, 79, 80, 79, 80, 79, 80, 79, 79, 79, 79,
80, 79, 80, 79, 80, 79, 80, 79, 80, 79, 80, 79, 79, 79, 80, 80, 79, 80, 79, 80,
79, 80, 78, 81, 78, 81, 78, 81, 78, 81, 77, 82, 78, 81, 77, 81, 79, 79, 84, -96,
-128, -112, -125, -113, -123, -115, -123, -116, -122, -117, -121, -117, -120,
-118, -121, -118, -119, -118, -119, -119, -119, -119, -118, -120, -118, -120,
-119, -119, -119, -119, -118, -119, -118, -119, -119, -120, -120, -119, -120,
-119, -119, -119, -119, -118, -119, -118, -120, -118, -120, -119, -119, -118,
-120, -119, -119, -119, -120, -119, -119, -120, -118, -123, -88, -76, -82, -78,
-81, -78, -80, -78, -80, -78, -80, -79, -80, -79, -79, -80, -80, -79, -79, -79,
-79, -79, -79, -79, -80, -79, -79, -80, -78, -79, -80, -79, -79, -80, -79, -79,
-79, -80, -80, -79, -79, -79, -79, -79, -79, -80, -79, -80, -79, -79, -80, -79,
-79, -79, -79, -80, -79, -80, -79, -79, -79, -80, -79, -79, -80, -79, -80, -79,
-79, -79, -80, -79, -80, -79, -80, -78, -79, -79, -80, -78, -80, -79, -80, -79,
-80, -79, -79, -80, -43, -38, -41, -39, -41, -39, -41, -39, -40, -39, -39, -39,
-39, -39, -40, -39, -40, -40, -40, -41, -40, -40, -40, -39, -40, -40, -39, -40,
-40, -40, -40, -40, -40, -40, -39, -41, -39, -40, -40, -39, -39, -40, -39, -40,
-40, -39, -40, -40, -40, -39, -40, -39, -40, -39, -39, -39, -39, -39, -40, -40,
-39, -40, -40, -39, -40, -39, -40, -40, -40, -40, -40, -40, -39, -40, -40, -39,
-40, -40, -39, -40, -40, -39, -40, -39, -40, -40, -39, -40, -39, -40, -39, -40,
-40, -40, -40, -41, -38, -42, -37, -44, -29, 3, -2, 1, -1, 1, 0, 0, 0, 0, 0, -1,
0, 0, 0, -1, 0, 0, 1, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0,
0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
1, -1, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0,
1, 0, 0, 1, };