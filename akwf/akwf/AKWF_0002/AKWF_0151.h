#define DATA_LENGTH 512
#define DATA AKWF_0151

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 8, 13, 18, 21, 26, 29, 34, 38, 42,
45, 48, 51, 54, 58, 60, 63, 65, 67, 70, 72, 74, 76, 78, 80, 82, 83, 85, 86, 87,
89, 89, 91, 93, 94, 94, 96, 96, 97, 97, 99, 99, 100, 100, 100, 102, 102, 103,
104, 104, 104, 105, 106, 106, 107, 108, 109, 109, 110, 111, 112, 113, 114, 114,
115, 115, 116, 116, 117, 117, 118, 118, 119, 119, 120, 119, 119, 119, 119, 118,
119, 119, 119, 118, 118, 117, 116, 116, 115, 115, 114, 113, 113, 112, 111, 111,
110, 109, 109, 108, 107, 106, 105, 104, 104, 103, 101, 101, 100, 98, 98, 96, 95,
95, 92, 92, 91, 89, 88, 86, 85, 82, 81, 79, 78, 76, 75, 73, 70, 70, 67, 66, 63,
62, 61, 59, 57, 56, 55, 53, 52, 50, 49, 48, 47, 45, 44, 43, 42, 40, 39, 38, 38,
36, 34, 33, 32, 31, 29, 27, 26, 25, 22, 21, 20, 19, 18, 17, 15, 14, 13, 12, 11,
10, 9, 7, 7, 7, 6, 7, 6, 7, 7, 7, 8, 9, 10, 11, 12, 12, 13, 14, 14, 16, 16, 17,
18, 19, 20, 20, 21, 21, 21, 23, 23, 24, 24, 24, 24, 25, 24, 24, 25, 24, 24, 24,
24, 24, 23, 23, 23, 21, 19, 18, 17, 14, 13, 11, 9, 7, 5, 3, 0, -1, -3, -7, -8,
-10, -12, -14, -16, -18, -20, -21, -23, -22, -23, -23, -24, -24, -24, -23, -24,
-23, -21, -21, -20, -19, -19, -19, -17, -17, -17, -17, -17, -17, -17, -16, -17,
-18, -17, -18, -19, -20, -20, -21, -21, -22, -23, -24, -24, -26, -26, -28, -28,
-28, -29, -30, -31, -32, -33, -34, -35, -37, -36, -38, -38, -39, -40, -40, -42,
-42, -43, -44, -43, -44, -45, -45, -46, -45, -45, -45, -45, -44, -44, -44, -45,
-43, -43, -43, -42, -42, -42, -42, -42, -42, -42, -41, -41, -42, -41, -42, -42,
-41, -42, -42, -42, -42, -44, -44, -44, -44, -45, -46, -45, -46, -46, -46, -48,
-47, -48, -48, -49, -50, -50, -50, -50, -51, -52, -52, -53, -53, -54, -53, -55,
-55, -55, -56, -56, -57, -57, -58, -59, -60, -61, -61, -63, -63, -64, -65, -66,
-67, -69, -70, -71, -71, -72, -73, -75, -75, -76, -76, -77, -78, -79, -79, -79,
-80, -80, -81, -82, -81, -82, -82, -83, -83, -84, -84, -85, -85, -85, -87, -86,
-87, -88, -88, -88, -89, -89, -89, -90, -92, -92, -92, -92, -93, -94, -95, -94,
-96, -96, -96, -96, -97, -97, -98, -98, -98, -98, -97, -97, -98, -97, -96, -96,
-96, -96, -95, -94, -94, -94, -94, -92, -92, -91, -92, -91, -91, -90, -89, -89,
-89, -88, -87, -88, -87, -87, -86, -86, -86, -85, -84, -84, -83, -83, -84, -82,
-82, -82, -81, -80, -80, -80, -79, -78, -77, -76, -75, -74, -73, -73, -72, -70,
-68, -68, -65, -64, -61, -57, -54, -51, -47, -42, -38, -34, -29, -24, -19, -15,
-10, -4, 0, };