#define DATA_LENGTH 512
#define DATA AKWF_0141

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 25, 37, 48, 53, 56, 61, 68, 71,
73, 77, 81, 81, 82, 85, 87, 87, 86, 93, 95, 92, 93, 100, 101, 98, 104, 105, 110,
119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119,
120, 119, 119, 119, 119, 120, 119, 118, 119, 119, 120, 119, 119, 119, 120, 119,
119, 119, 119, 119, 119, 119, 118, 118, 111, 113, 120, 110, 112, 112, 108, 114,
110, 105, 106, 102, 102, 100, 95, 92, 91, 87, 81, 78, 73, 67, 60, 56, 45, 35, 4,
-34, -38, -56, -63, -67, -76, -87, -90, -92, -100, -103, -108, -112, -118, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -118, -119, -114, -108, -107, -99, -93, -87, -82, -78,
-74, -68, -63, -60, -53, -50, -51, -47, -39, -36, -39, -40, -30, -30, -30, -27,
-19, -13, -30, -24, 5, -18, -32, -32, -38, -40, -51, -52, -58, -65, -71, -74,
-81, -86, -87, -89, -91, -95, -93, -93, -92, -92, -87, -88, -89, -86, -83, -81,
-82, -79, -77, -74, -73, -72, -72, -70, -69, -71, -69, -65, -64, -68, -67, -59,
-62, -64, -60, -59, -59, -57, -56, -54, -56, -59, -55, -55, -59, -62, -66, -68,
-70, -75, -79, -81, -85, -94, -97, -95, -100, -107, -108, -105, -108, -112,
-113, -112, -109, -107, -111, -110, -103, -100, -98, -96, -89, -89, -81, -74,
-72, -64, -56, -54, -43, -36, -22, 19, 26, 29, 38, 41, 47, 44, 47, 45, 43, 45,
48, 48, 49, 49, 51, 59, 62, 66, 72, 74, 83, 88, 91, 99, 101, 102, 105, 107, 106,
109, 108, 106, 106, 106, 110, 111, 111, 107, 115, 116, 112, 118, 120, 119, 119,
119, 119, 120, 119, 119, 119, 114, 106, 110, 105, 100, 101, 100, 103, 100, 103,
111, 115, 114, 117, 119, 118, 120, 119, 118, 119, 119, 120, 119, 119, 119, 120,
119, 119, 119, 120, 118, 119, 118, 119, 119, 119, 119, 120, 119, 120, 119, 120,
120, 119, 119, 119, 119, 120, 119, 120, 119, 119, 119, 118, 120, 115, 102, 86,
78, 68, 61, 39, 30, 7, -44, -54, -62, -67, -74, -83, -91, -91, -94, -102, -106,
-106, -112, -121, -119, -119, -118, -120, -119, -119, -118, -119, -119, -119,
-118, -119, -119, -118, -119, -120, -119, -119, -119, -120, -120, -119, -120,
-119, -119, -118, -119, -119, -119, -119, -120, -119, -119, -118, -119, -119,
-118, -119, -120, -120, -119, -119, -119, -119, -119, -118, -119, -119, -110,
-105, -97, -93, -89, -83, -78, -73, -71, -66, -62, -62, -55, -52, -49, -40, -35,
-32, -4, 25, 26, 31, 38, 41, 41, 40, 42, 45, 43, 44, 39, 35, 36, 38, 30, 25, 27,
17, 22, -7, -22, -18, -20, -25, -18, -16, -10, 25, 32, 36, 36, 45, 46, 50, 51,
48, 53, 50, 45, 43, 41, 36, 23, -17, -25, -35, -45, -47, -53, -57, -59, -57,
-60, -58, -64, -60, -55, -52, -50, -45, -37, -16, };