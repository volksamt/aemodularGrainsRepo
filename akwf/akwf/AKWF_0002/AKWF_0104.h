#define DATA_LENGTH 512
#define DATA AKWF_0104

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 3, 4, 5, 7, 8, 9, 10, 12, 13,
14, 15, 17, 17, 19, 20, 21, 22, 23, 25, 25, 27, 27, 29, 31, 31, 33, 33, 35, 36,
38, 39, 40, 41, 42, 42, 43, 45, 46, 47, 48, 49, 50, 51, 52, 53, 55, 56, 56, 57,
59, 60, 61, 61, 62, 63, 63, 64, 66, 66, 67, 68, 69, 70, 70, 71, 73, 73, 74, 74,
75, 76, 76, 77, 78, 78, 79, 80, 80, 81, 81, 81, 82, 83, 83, 83, 84, 85, 85, 85,
86, 86, 87, 87, 88, 87, 88, 89, 88, 89, 89, 89, 89, 90, 89, 91, 90, 90, 90, 90,
90, 91, 90, 89, 90, 90, 90, 90, 90, 90, 89, 90, 88, 89, 89, 89, 89, 88, 88, 88,
87, 87, 86, 87, 86, 85, 84, 84, 84, 84, 84, 83, 82, 82, 81, 81, 80, 79, 79, 78,
78, 77, 77, 75, 76, 74, 73, 73, 72, 71, 72, 70, 70, 68, 67, 67, 67, 65, 65, 65,
63, 62, 61, 60, 60, 59, 58, 57, 56, 55, 55, 53, 52, 51, 51, 50, 48, 47, 46, 45,
44, 43, 42, 41, 41, 39, 38, 37, 36, 35, 33, 33, 31, 31, 29, 29, 28, 26, 26, 25,
23, 23, 21, 20, 19, 18, 16, 16, 14, 13, 12, 11, 11, 9, 8, 7, 6, 4, 4, 2, 2, 1,
0, -1, -3, -4, -5, -6, -6, -7, -9, -10, -10, -11, -13, -13, -14, -16, -17, -18,
-19, -19, -21, -21, -22, -24, -24, -24, -25, -26, -27, -29, -29, -30, -31, -32,
-32, -34, -34, -35, -35, -36, -37, -38, -38, -39, -39, -41, -41, -42, -42, -43,
-43, -45, -45, -46, -46, -47, -48, -47, -48, -49, -50, -49, -50, -50, -51, -51,
-52, -52, -53, -53, -53, -55, -55, -55, -54, -56, -55, -55, -56, -56, -57, -57,
-57, -57, -56, -58, -57, -57, -58, -58, -58, -58, -58, -57, -58, -58, -58, -58,
-57, -58, -57, -57, -57, -58, -57, -57, -58, -57, -57, -57, -57, -56, -56, -56,
-55, -55, -55, -54, -54, -55, -54, -54, -53, -53, -53, -53, -52, -51, -52, -50,
-50, -49, -58, -67, -64, -67, -71, -73, -73, -74, -74, -75, -75, -75, -74, -73,
-73, -72, -71, -71, -70, -70, -70, -68, -68, -68, -68, -68, -67, -69, -67, -68,
-67, -67, -67, -67, -67, -67, -68, -68, -67, -68, -68, -67, -67, -68, -68, -68,
-68, -67, -68, -68, -67, -67, -68, -68, -67, -67, -67, -66, -66, -66, -65, -65,
-65, -64, -64, -65, -63, -63, -63, -62, -61, -62, -62, -61, -60, -60, -59, -58,
-58, -59, -57, -57, -57, -56, -55, -55, -55, -54, -53, -53, -52, -52, -51, -50,
-50, -50, -48, -48, -46, -46, -45, -45, -44, -42, -42, -42, -41, -40, -39, -38,
-37, -36, -35, -35, -34, -32, -31, -31, -30, -30, -28, -28, -25, -25, -25, -23,
-22, -21, -20, -19, -18, -17, -16, -15, -14, -12, -11, -11, -9, -8, -8, -6, -4,
-4, -2, -1, 0, };