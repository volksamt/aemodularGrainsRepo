#define DATA_LENGTH 512
#define DATA AKWF_0115

const PROGMEM int8_t DATA[DATA_LENGTH] = {-2, -5, -8, -11, -14, -17, -19, -22,
-25, -29, -32, -35, -38, -41, -44, -47, -49, -51, -54, -57, -59, -61, -63, -65,
-67, -69, -69, -70, -72, -73, -73, -72, -72, -70, -70, -68, -67, -64, -63, -61,
-58, -55, -53, -50, -48, -46, -43, -41, -40, -37, -35, -34, -33, -31, -30, -29,
-28, -28, -27, -27, -27, -27, -28, -28, -29, -30, -30, -32, -33, -34, -35, -37,
-38, -40, -42, -43, -46, -48, -50, -52, -54, -57, -58, -61, -63, -65, -67, -69,
-71, -73, -75, -76, -78, -78, -81, -81, -82, -83, -83, -84, -84, -84, -83, -82,
-82, -80, -80, -78, -78, -77, -76, -76, -73, -73, -73, -72, -71, -71, -71, -70,
-72, -72, -71, -72, -73, -73, -74, -75, -76, -77, -78, -78, -77, -77, -78, -86,
-95, -103, -104, -98, -94, -94, -98, -104, -106, -107, -105, -104, -103, -104,
-102, -103, -102, -101, -99, -97, -94, -92, -90, -87, -84, -81, -77, -73, -68,
-64, -60, -56, -51, -47, -41, -37, -35, -33, -29, -15, 6, 21, 24, 21, 14, 14,
22, 32, 38, 40, 40, 39, 39, 41, 44, 46, 47, 48, 47, 47, 46, 46, 46, 46, 45, 45,
44, 42, 40, 39, 38, 37, 36, 32, 31, 29, 29, 30, 28, 22, 11, 2, 0, 3, 10, 13, 9,
2, -2, -2, -1, 2, 4, 4, 4, 4, 5, 5, 7, 9, 11, 12, 13, 13, 14, 14, 17, 17, 17,
17, 17, 16, 15, 14, 15, 13, 12, 10, 8, 8, 6, 3, 2, 1, 0, -2, -4, -5, -7, -9,
-10, -11, -13, -14, -15, -17, -18, -19, -20, -20, -21, -22, -22, -22, -22, -22,
-22, -21, -20, -20, -18, -17, -15, -13, -11, -9, -7, -4, -1, 2, 5, 8, 11, 15,
18, 22, 24, 28, 30, 35, 36, 40, 42, 45, 47, 49, 51, 52, 54, 56, 57, 58, 59, 59,
59, 60, 60, 59, 58, 57, 56, 56, 55, 53, 53, 51, 50, 47, 46, 44, 43, 40, 38, 37,
35, 32, 31, 29, 28, 26, 25, 24, 24, 22, 21, 21, 21, 20, 20, 20, 21, 22, 22, 23,
24, 25, 27, 27, 29, 29, 30, 31, 32, 33, 34, 35, 35, 36, 36, 35, 35, 36, 35, 34,
34, 34, 33, 31, 30, 30, 29, 28, 27, 25, 24, 23, 22, 20, 19, 19, 17, 16, 16, 14,
13, 13, 11, 11, 12, 11, 10, 10, 10, 11, 11, 12, 13, 14, 15, 17, 20, 22, 24, 26,
30, 33, 36, 39, 41, 45, 47, 49, 49, 48, 52, 69, 97, 113, 113, 105, 96, 95, 103,
113, 118, 119, 117, 114, 114, 115, 116, 117, 117, 115, 114, 112, 110, 109, 108,
106, 104, 102, 99, 97, 94, 92, 90, 87, 84, 81, 78, 74, 72, 69, 65, 63, 60, 57,
55, 51, 50, 48, 45, 43, 42, 40, 39, 38, 36, 35, 34, 33, 33, 32, 32, 32, 31, 30,
30, 28, 28, 26, 26, 25, 23, 21, 20, 19, 17, 15, 12, 11, 8, 6, 2, 1, };