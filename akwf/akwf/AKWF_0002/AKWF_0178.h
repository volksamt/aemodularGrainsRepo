#define DATA_LENGTH 512
#define DATA AKWF_0178

const PROGMEM int8_t DATA[DATA_LENGTH] = {-4, -8, -14, -18, -23, -28, -33, -36,
-40, -45, -49, -54, -59, -65, -69, -75, -79, -85, -89, -94, -97, -102, -106,
-111, -114, -117, -119, -119, -118, -118, -116, -115, -114, -113, -111, -110,
-110, -108, -106, -105, -102, -100, -97, -95, -93, -90, -88, -86, -84, -81, -79,
-77, -76, -72, -70, -68, -65, -63, -61, -58, -55, -54, -52, -50, -47, -45, -44,
-42, -40, -38, -35, -35, -33, -30, -29, -27, -26, -24, -22, -21, -19, -18, -16,
-15, -14, -12, -11, -10, -9, -8, -7, -5, -4, -3, -2, -1, -1, 0, 2, 2, 4, 4, 5,
7, 6, 7, 8, 9, 9, 10, 10, 12, 11, 11, 11, 11, 11, 12, 12, 12, 12, 12, 12, 12,
11, 12, 12, 12, 11, 11, 12, 12, 12, 12, 12, 11, 11, 11, 12, 11, 13, 12, 13, 14,
13, 13, 15, 15, 15, 15, 16, 16, 16, 17, 17, 17, 18, 19, 19, 19, 19, 19, 20, 19,
20, 20, 21, 21, 21, 21, 22, 21, 22, 22, 23, 24, 24, 23, 23, 24, 23, 25, 23, 24,
24, 24, 25, 25, 25, 25, 24, 26, 25, 26, 26, 25, 25, 24, 24, 23, 23, 23, 23, 23,
22, 21, 22, 20, 20, 21, 19, 20, 19, 18, 18, 18, 18, 18, 17, 17, 16, 15, 17, 16,
16, 17, 16, 16, 16, 16, 17, 17, 17, 17, 18, 17, 17, 17, 18, 18, 18, 18, 19, 19,
19, 19, 20, 19, 20, 20, 19, 19, 19, 20, 21, 20, 21, 20, 21, 21, 21, 21, 21, 21,
22, 21, 21, 21, 21, 23, 21, 23, 22, 23, 22, 22, 22, 21, 23, 22, 21, 21, 21, 20,
19, 20, 20, 18, 17, 18, 18, 17, 16, 16, 16, 15, 15, 14, 13, 13, 13, 13, 12, 12,
12, 11, 11, 11, 11, 12, 11, 11, 12, 12, 12, 12, 12, 12, 13, 13, 12, 13, 12, 13,
13, 14, 13, 14, 14, 14, 14, 15, 15, 15, 15, 16, 16, 16, 15, 17, 16, 16, 16, 17,
18, 17, 17, 17, 17, 18, 17, 17, 17, 18, 17, 17, 18, 18, 18, 18, 18, 18, 17, 17,
16, 16, 16, 15, 14, 15, 14, 14, 13, 13, 13, 12, 12, 12, 10, 10, 10, 10, 9, 8, 8,
9, 8, 7, 8, 7, 7, 7, 6, 7, 7, 7, 7, 8, 8, 7, 8, 7, 8, 9, 9, 8, 9, 10, 9, 10, 10,
9, 10, 10, 11, 11, 10, 10, 10, 10, 11, 9, 9, 9, 8, 9, 9, 8, 8, 7, 8, 7, 7, 8, 6,
6, 5, 5, 5, 4, 4, 5, 4, 3, 3, 4, 3, 3, 4, 4, 4, 4, 4, 4, 5, 5, 4, 5, 5, 6, 6, 6,
6, 6, 7, 7, 8, 7, 7, 8, 8, 7, 9, 8, 9, 9, 9, 10, 9, 9, 10, 10, 9, 10, 11, 11,
10, 11, 11, 11, 10, 11, 11, 11, 11, 12, 11, 12, 12, 11, 11, 9, 9, 7, 7, 5, 5, 3,
3, 2, 2, 7, };