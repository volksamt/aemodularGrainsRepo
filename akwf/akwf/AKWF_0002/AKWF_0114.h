#define DATA_LENGTH 512
#define DATA AKWF_0114

const PROGMEM int8_t DATA[DATA_LENGTH] = {-3, -9, -13, -18, -23, -26, -31, -34,
-37, -40, -43, -47, -48, -51, -53, -54, -56, -57, -58, -59, -59, -61, -60, -61,
-60, -61, -60, -60, -61, -59, -59, -59, -58, -57, -56, -56, -55, -53, -53, -51,
-50, -50, -49, -48, -46, -45, -43, -41, -41, -41, -40, -40, -40, -39, -40, -41,
-40, -40, -41, -42, -42, -43, -42, -43, -43, -43, -42, -42, -42, -42, -43, -42,
-42, -42, -41, -41, -40, -39, -38, -37, -37, -35, -35, -34, -32, -31, -31, -30,
-28, -27, -26, -25, -23, -22, -20, -18, -18, -17, -16, -13, -12, -11, -9, -8,
-6, -4, -4, -1, -1, 2, 3, 3, 3, 2, 0, -3, -7, -10, -14, -18, -22, -27, -33, -38,
-43, -46, -51, -56, -59, -64, -68, -72, -75, -78, -82, -84, -86, -90, -92, -93,
-96, -97, -98, -99, -100, -102, -101, -102, -103, -103, -103, -102, -102, -102,
-102, -101, -101, -100, -100, -99, -99, -97, -97, -96, -94, -94, -92, -91, -90,
-89, -87, -85, -85, -83, -83, -80, -80, -79, -79, -79, -79, -79, -78, -79, -79,
-79, -80, -81, -80, -81, -80, -82, -82, -81, -82, -81, -81, -82, -80, -81, -81,
-80, -80, -79, -78, -78, -76, -77, -74, -73, -73, -72, -71, -71, -69, -68, -67,
-65, -64, -62, -61, -60, -59, -57, -56, -54, -53, -52, -51, -48, -48, -46, -44,
-42, -42, -40, -38, -37, -35, -34, -32, -30, -28, -26, -26, -24, -22, -21, -19,
-18, -16, -15, -13, -11, -9, -8, -6, -4, -2, -1, 0, 1, 4, 4, 7, 8, 10, 11, 13,
15, 17, 19, 20, 22, 23, 25, 26, 28, 30, 32, 33, 34, 36, 37, 39, 42, 43, 44, 46,
48, 50, 51, 52, 54, 56, 57, 59, 61, 62, 63, 65, 68, 69, 70, 71, 72, 72, 73, 73,
73, 74, 74, 73, 73, 72, 73, 72, 72, 72, 72, 71, 72, 71, 72, 72, 72, 72, 73, 72,
73, 74, 75, 75, 76, 77, 78, 79, 79, 80, 81, 83, 83, 86, 86, 88, 88, 89, 91, 92,
94, 96, 96, 97, 99, 101, 102, 104, 105, 107, 108, 109, 111, 112, 114, 116, 117,
119, 119, 119, 117, 114, 112, 108, 104, 101, 97, 92, 88, 82, 78, 74, 69, 64, 59,
56, 51, 46, 44, 40, 36, 34, 31, 29, 26, 24, 21, 20, 18, 17, 17, 15, 15, 14, 14,
12, 12, 13, 13, 13, 13, 14, 14, 14, 15, 15, 16, 17, 18, 19, 21, 22, 22, 23, 24,
25, 26, 28, 30, 32, 33, 33, 35, 36, 36, 37, 36, 36, 36, 37, 36, 37, 36, 36, 35,
35, 35, 34, 34, 34, 34, 34, 34, 35, 34, 35, 35, 35, 35, 36, 37, 38, 37, 39, 40,
40, 41, 43, 43, 44, 46, 47, 48, 50, 50, 51, 53, 55, 56, 57, 58, 59, 62, 62, 64,
65, 67, 68, 69, 71, 73, 74, 76, 77, 79, 79, 80, 79, 76, 73, 70, 65, 60, 55, 49,
43, 37, 30, 25, 18, 13, 7, 2, };