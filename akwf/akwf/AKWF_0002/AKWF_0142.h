#define DATA_LENGTH 512
#define DATA AKWF_0142

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 11, 14, 17, 21, 23, 26, 29,
32, 35, 38, 40, 42, 46, 48, 51, 54, 55, 59, 60, 63, 65, 67, 69, 71, 73, 75, 77,
79, 81, 81, 84, 85, 86, 88, 90, 90, 92, 92, 94, 96, 96, 97, 99, 99, 100, 100,
102, 102, 104, 104, 104, 104, 105, 105, 107, 106, 106, 107, 108, 108, 108, 108,
110, 109, 109, 110, 109, 109, 110, 109, 110, 110, 109, 110, 110, 110, 110, 110,
110, 110, 111, 110, 110, 109, 110, 109, 109, 109, 109, 110, 109, 108, 109, 108,
109, 108, 108, 108, 108, 107, 107, 107, 107, 107, 107, 107, 107, 105, 106, 106,
105, 105, 104, 105, 105, 104, 104, 104, 104, 104, 103, 103, 103, 103, 102, 101,
101, 102, 101, 101, 101, 102, 101, 101, 100, 100, 100, 100, 99, 99, 98, 99, 98,
98, 98, 98, 97, 97, 97, 97, 96, 96, 95, 96, 96, 95, 96, 96, 95, 94, 94, 94, 93,
93, 93, 93, 93, 92, 92, 92, 91, 91, 91, 90, 90, 90, 90, 89, 89, 89, 89, 88, 87,
88, 87, 87, 87, 86, 86, 85, 86, 85, 84, 85, 84, 83, 84, 84, 82, 82, 83, 82, 81,
82, 81, 80, 80, 80, 80, 80, 79, 78, 78, 78, 78, 77, 76, 77, 76, 74, 74, 73, 72,
70, 68, 68, 67, 65, 63, 61, 59, 58, 55, 53, 51, 50, 47, 45, 42, 39, 36, 34, 31,
27, 25, 23, 20, 16, 14, 11, 7, 4, 2, -2, -5, -8, -12, -15, -18, -20, -24, -27,
-30, -32, -35, -38, -41, -44, -46, -49, -52, -53, -57, -58, -61, -62, -65, -68,
-70, -72, -74, -76, -77, -79, -81, -82, -84, -85, -87, -88, -90, -90, -92, -93,
-94, -96, -96, -98, -98, -99, -100, -100, -102, -103, -103, -103, -105, -105,
-105, -106, -107, -107, -107, -107, -108, -107, -108, -108, -109, -108, -109,
-110, -110, -109, -109, -111, -110, -110, -109, -110, -110, -110, -110, -110,
-110, -110, -110, -110, -109, -110, -109, -110, -109, -109, -109, -109, -109,
-109, -109, -109, -108, -109, -107, -108, -108, -107, -108, -107, -107, -107,
-107, -107, -105, -105, -106, -105, -105, -105, -105, -105, -104, -104, -104,
-104, -104, -103, -103, -103, -103, -103, -101, -103, -103, -102, -102, -101,
-102, -101, -101, -101, -100, -99, -100, -100, -99, -99, -99, -99, -98, -98,
-98, -97, -98, -97, -97, -96, -96, -96, -96, -96, -96, -96, -95, -95, -94, -95,
-94, -94, -94, -93, -93, -92, -92, -93, -91, -92, -91, -91, -91, -91, -90, -91,
-90, -90, -89, -88, -88, -88, -88, -88, -88, -86, -86, -86, -87, -86, -85, -86,
-85, -84, -84, -84, -83, -83, -83, -83, -83, -82, -81, -81, -81, -81, -80, -80,
-80, -79, -79, -79, -79, -78, -77, -77, -76, -76, -75, -74, -73, -72, -71, -70,
-68, -68, -66, -64, -63, -61, -59, -58, -56, -53, -51, -49, -47, -44, -41, -38,
-36, -33, -31, -28, -25, -22, -19, -16, -12, -10, -6, -4, 0, };