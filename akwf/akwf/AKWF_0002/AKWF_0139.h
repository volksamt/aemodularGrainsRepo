#define DATA_LENGTH 512
#define DATA AKWF_0139

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 8, 10, 14, 16, 21, 22, 26, 29,
31, 35, 38, 40, 43, 45, 47, 51, 54, 55, 58, 60, 62, 64, 66, 69, 70, 72, 74, 76,
77, 79, 80, 82, 83, 85, 85, 87, 87, 89, 90, 91, 92, 92, 93, 95, 95, 96, 97, 98,
98, 98, 100, 100, 101, 100, 101, 101, 102, 102, 103, 103, 103, 103, 104, 104,
104, 104, 104, 104, 104, 104, 105, 104, 104, 105, 105, 105, 105, 105, 104, 105,
105, 105, 104, 105, 104, 104, 104, 105, 105, 104, 104, 104, 104, 103, 103, 104,
102, 103, 103, 103, 103, 103, 103, 102, 102, 102, 102, 102, 101, 102, 101, 101,
101, 100, 99, 100, 98, 98, 97, 96, 96, 94, 92, 92, 90, 88, 86, 85, 84, 81, 79,
77, 75, 72, 71, 67, 65, 62, 59, 57, 55, 51, 48, 45, 41, 39, 36, 33, 28, 25, 23,
19, 16, 13, 10, 8, 5, 3, 1, -2, -4, -7, -8, -10, -11, -13, -14, -15, -17, -18,
-17, -19, -19, -19, -18, -18, -18, -17, -18, -16, -15, -14, -13, -12, -11, -9,
-8, -7, -5, -4, -2, 0, 2, 5, 6, 7, 10, 12, 14, 17, 18, 19, 21, 23, 26, 27, 29,
32, 33, 34, 38, 39, 40, 42, 44, 46, 46, 49, 49, 51, 53, 54, 56, 57, 58, 59, 60,
62, 63, 64, 65, 65, 66, 67, 68, 69, 70, 70, 71, 71, 71, 72, 72, 73, 74, 73, 74,
74, 75, 75, 75, 75, 75, 75, 74, 75, 75, 75, 75, 76, 74, 76, 75, 75, 75, 75, 75,
74, 74, 74, 75, 73, 74, 73, 73, 72, 72, 72, 70, 70, 69, 66, 65, 64, 62, 61, 59,
58, 56, 54, 51, 50, 47, 45, 41, 40, 36, 34, 30, 28, 24, 22, 18, 15, 13, 9, 6, 2,
-1, -5, -7, -10, -14, -17, -20, -24, -27, -30, -33, -37, -39, -43, -46, -48,
-52, -54, -57, -60, -62, -65, -67, -70, -72, -75, -78, -79, -81, -83, -86, -87,
-89, -91, -92, -94, -95, -97, -99, -100, -102, -102, -103, -104, -107, -107,
-107, -110, -110, -111, -111, -112, -112, -114, -115, -115, -115, -116, -117,
-117, -117, -117, -118, -118, -119, -118, -119, -119, -119, -118, -118, -118,
-119, -118, -119, -118, -119, -120, -120, -118, -119, -119, -118, -119, -118,
-118, -118, -118, -118, -118, -117, -117, -118, -117, -116, -117, -116, -116,
-116, -115, -114, -115, -115, -115, -115, -114, -113, -114, -113, -113, -112,
-113, -112, -113, -112, -112, -111, -111, -111, -110, -110, -110, -109, -109,
-109, -108, -108, -108, -108, -108, -108, -107, -107, -106, -107, -106, -107,
-106, -105, -105, -105, -104, -104, -104, -104, -105, -103, -103, -103, -103,
-102, -102, -102, -101, -102, -101, -101, -100, -100, -100, -99, -98, -99, -97,
-97, -96, -94, -92, -91, -90, -89, -86, -85, -85, -82, -80, -77, -76, -74, -72,
-68, -66, -63, -59, -57, -54, -51, -48, -45, -42, -39, -36, -32, -29, -25, -21,
-19, -15, -12, -9, -5, -2, };