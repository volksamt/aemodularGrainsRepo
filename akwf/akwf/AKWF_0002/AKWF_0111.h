#define DATA_LENGTH 512
#define DATA AKWF_0111

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, -13, -26, -37, -47, -57, -66, -71,
-79, -85, -88, -93, -97, -101, -103, -105, -108, -109, -111, -112, -113, -114,
-114, -115, -116, -116, -117, -116, -117, -117, -117, -118, -118, -118, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -118, -119, -119, -120, -119,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -118, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -120, -118, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -120, -118, -119, -119, -119, -119, -120, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -118, -118, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -120, -119, -117, -114, -107, -98, -86, -73, -58, -43, -27, -13, 2, 15,
27, 39, 49, 57, 66, 72, 80, 84, 90, 94, 97, 101, 103, 105, 107, 109, 111, 112,
112, 114, 116, 116, 116, 117, 117, 117, 117, 118, 118, 117, 118, 119, 119, 118,
118, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 120, 120, 120, 119, 119, 118, 119, 120, 119, 120, 119, 120,
119, 118, 119, 119, 119, 118, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119,
118, 118, 119, 119, 119, 119, 119, 118, 119, 120, 120, 119, 118, 119, 119, 119,
119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
119, 119, 119, 120, 118, 119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 118,
120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120,
119, 119, 118, 119, 119, 119, 118, 119, 119, 120, 118, 119, 119, 120, 119, 119,
119, 119, 118, 119, 120, 119, 119, 119, 119, 118, 119, 119, 118, 119, 119, 118,
119, 119, 119, 120, 119, 118, 119, 120, 118, 119, 119, 119, 119, 119, 120, 118,
119, 120, 119, 120, 119, 119, 119, 118, 119, 120, 119, 119, 119, 120, 118, 120,
119, 119, 119, 119, 119, 119, 120, 119, 118, 119, 120, 119, 118, 120, 119, 119,
120, 119, 118, 113, 107, 96, 85, 71, 57, 41, 26, 10, };