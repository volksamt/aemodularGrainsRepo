#define DATA_LENGTH 512
#define DATA AKWF_0124

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 12, 18, 22, 27, 31, 34, 39, 42,
46, 49, 53, 55, 58, 62, 64, 67, 69, 72, 74, 75, 77, 79, 81, 83, 85, 86, 88, 89,
91, 93, 93, 94, 95, 97, 98, 98, 100, 100, 101, 102, 103, 103, 105, 104, 106,
106, 107, 108, 108, 108, 109, 110, 110, 110, 111, 112, 111, 112, 112, 112, 113,
113, 114, 113, 113, 114, 114, 114, 115, 115, 115, 116, 115, 116, 116, 115, 116,
116, 117, 116, 117, 117, 117, 117, 116, 117, 117, 117, 117, 118, 117, 117, 117,
117, 118, 118, 118, 118, 118, 118, 117, 118, 118, 118, 118, 118, 118, 118, 119,
118, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119,
118, 119, 119, 119, 120, 119, 118, 119, 119, 119, 120, 118, 119, 119, 119, 119,
119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 118,
120, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 120, 119, 118, 120, 119,
119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 120, 118, 119, 119, 119,
119, 119, 119, 119, 118, 120, 119, 119, 119, 118, 120, 119, 119, 118, 120, 120,
120, 119, 120, 119, 119, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119,
118, 118, 117, 116, 114, 113, 110, 107, 102, 96, 90, 84, 77, 70, 62, 55, 48, 40,
33, 26, 20, 13, 7, 1, -4, -9, -14, -19, -24, -29, -33, -37, -41, -45, -47, -51,
-54, -57, -60, -63, -65, -68, -70, -73, -75, -77, -79, -81, -82, -84, -86, -88,
-89, -89, -91, -93, -94, -94, -96, -97, -99, -100, -100, -101, -101, -102, -104,
-104, -104, -106, -105, -107, -107, -107, -109, -109, -110, -110, -110, -111,
-111, -111, -111, -112, -112, -113, -113, -113, -114, -113, -114, -114, -114,
-115, -115, -115, -116, -115, -116, -116, -116, -117, -116, -117, -116, -117,
-117, -117, -117, -117, -117, -117, -118, -117, -117, -117, -117, -117, -118,
-118, -118, -118, -118, -118, -118, -118, -119, -118, -119, -118, -118, -118,
-119, -118, -119, -119, -118, -118, -118, -118, -118, -119, -118, -119, -118,
-119, -118, -119, -120, -119, -118, -118, -119, -119, -119, -118, -118, -118,
-119, -120, -119, -119, -119, -119, -120, -118, -120, -119, -119, -119, -119,
-120, -119, -118, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -120, -118, -119, -119, -119, -119,
-118, -120, -119, -119, -119, -118, -119, -118, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -118, -119, -119, -119,
-118, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -118, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -120, -119, -119, -119, -119, -120,
-119, -118, -119, -119, -118, -118, -116, -115, -113, -111, -108, -103, -98,
-91, -85, -78, -71, -65, -57, -50, -43, -35, -28, -21, -15, -9, -3, };