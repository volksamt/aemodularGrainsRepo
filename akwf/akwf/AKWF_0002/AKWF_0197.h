#define DATA_LENGTH 512
#define DATA AKWF_0197

const PROGMEM int8_t DATA[DATA_LENGTH] = {46, 22, 32, 36, 31, 43, 35, 45, 40,
48, 45, 51, 50, 55, 55, 58, 59, 61, 63, 64, 66, 68, 69, 71, 73, 74, 76, 76, 79,
80, 82, 83, 85, 85, 87, 88, 89, 90, 91, 92, 93, 95, 95, 95, 96, 97, 97, 98, 98,
99, 100, 100, 100, 101, 101, 101, 101, 101, 100, 102, 102, 101, 102, 101, 100,
100, 100, 100, 99, 99, 97, 98, 97, 96, 95, 95, 95, 94, 93, 92, 92, 90, 89, 89,
88, 88, 86, 86, 84, 83, 83, 81, 80, 80, 79, 78, 76, 75, 74, 73, 72, 70, 70, 68,
67, 66, 65, 66, 64, 63, 62, 60, 60, 60, 58, 57, 57, 56, 55, 54, 54, 52, 52, 51,
50, 49, 49, 48, 48, 47, 47, 47, 46, 46, 46, 45, 45, 44, 44, 45, 45, 45, 44, 45,
44, 45, 44, 45, 46, 46, 45, 46, 45, 46, 47, 47, 47, 48, 49, 49, 50, 50, 52, 51,
53, 54, 54, 55, 55, 56, 57, 59, 59, 61, 61, 62, 63, 65, 66, 68, 68, 70, 70, 71,
72, 74, 75, 76, 78, 79, 80, 81, 82, 84, 85, 86, 87, 88, 90, 91, 92, 92, 95, 95,
97, 98, 99, 100, 101, 102, 103, 105, 105, 105, 107, 109, 108, 110, 109, 113,
110, 113, 112, 115, 113, 117, 114, 118, 115, 119, 117, 119, 118, 119, 119, 118,
120, 117, 122, 116, 123, 114, 124, 111, 127, 108, 127, 104, 127, 95, 127, 38,
-77, 18, -75, -7, -55, -22, -37, -35, -32, -41, -30, -44, -30, -44, -32, -45,
-34, -44, -35, -44, -37, -44, -38, -43, -40, -42, -41, -41, -41, -40, -41, -39,
-41, -38, -41, -37, -39, -37, -40, -37, -38, -36, -38, -37, -36, -35, -35, -34,
-35, -34, -34, -34, -33, -33, -33, -32, -33, -32, -32, -32, -32, -31, -31, -30,
-31, -31, -30, -30, -31, -30, -30, -30, -30, -30, -30, -31, -30, -31, -31, -31,
-31, -32, -32, -32, -33, -34, -34, -35, -35, -36, -36, -37, -37, -37, -39, -39,
-40, -40, -42, -43, -43, -45, -45, -46, -46, -48, -49, -49, -51, -53, -54, -55,
-55, -57, -58, -59, -61, -61, -63, -65, -65, -66, -68, -70, -70, -72, -73, -75,
-76, -77, -79, -80, -81, -82, -84, -86, -86, -88, -89, -91, -92, -93, -93, -96,
-96, -98, -98, -100, -101, -101, -103, -104, -104, -105, -107, -107, -108, -109,
-110, -110, -111, -112, -113, -113, -114, -114, -115, -115, -116, -116, -116,
-117, -117, -117, -117, -117, -118, -117, -117, -116, -117, -117, -116, -116,
-117, -116, -115, -115, -115, -113, -113, -113, -113, -111, -110, -110, -110,
-109, -108, -107, -107, -106, -104, -103, -102, -102, -100, -99, -99, -97, -96,
-96, -95, -93, -92, -91, -90, -89, -87, -86, -84, -85, -82, -81, -79, -80, -77,
-78, -74, -76, -73, -72, -70, -70, -70, -68, -67, -65, -66, -62, -65, -59, -63,
-56, -62, -55, -60, -53, -59, -50, -59, -49, -57, -48, -57, -32, 58, -9, 61, 5,
};