#define DATA_LENGTH 512
#define DATA AKWF_0161

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 12, 16, 20, 24, 27, 31, 35, 38,
42, 43, 46, 49, 52, 54, 56, 58, 59, 61, 63, 64, 65, 67, 68, 69, 71, 71, 73, 74,
75, 75, 77, 79, 80, 80, 81, 82, 83, 84, 84, 85, 87, 88, 89, 89, 90, 92, 92, 93,
93, 94, 94, 95, 96, 97, 97, 98, 98, 99, 101, 101, 101, 102, 102, 103, 104, 104,
104, 105, 105, 106, 106, 107, 108, 108, 107, 108, 108, 109, 109, 110, 110, 110,
110, 110, 111, 112, 111, 112, 112, 112, 112, 112, 112, 112, 112, 112, 112, 112,
111, 111, 110, 109, 109, 108, 108, 105, 105, 105, 103, 102, 101, 100, 99, 98,
98, 96, 96, 95, 95, 94, 93, 92, 89, 87, 85, 81, 81, 79, 77, 75, 74, 73, 72, 70,
69, 68, 66, 67, 65, 63, 63, 62, 62, 61, 61, 59, 59, 59, 57, 57, 57, 56, 55, 55,
54, 54, 53, 53, 52, 51, 51, 50, 50, 50, 49, 49, 48, 48, 47, 46, 46, 46, 46, 44,
44, 43, 43, 43, 42, 42, 41, 40, 40, 39, 38, 38, 37, 36, 36, 36, 35, 33, 32, 32,
31, 31, 29, 29, 29, 28, 28, 27, 27, 26, 26, 25, 25, 23, 22, 22, 22, 20, 20, 19,
18, 17, 17, 16, 15, 14, 13, 13, 12, 11, 11, 10, 9, 8, 8, 8, 7, 7, 7, 7, 6, 7, 7,
7, 7, 7, 8, 9, 10, 11, 12, 12, 14, 14, 16, 18, 19, 22, 23, 24, 25, 28, 28, 29,
30, 32, 32, 34, 35, 35, 36, 37, 38, 37, 37, 38, 38, 37, 37, 37, 37, 35, 36, 36,
34, 33, 33, 33, 32, 32, 30, 31, 30, 30, 29, 29, 28, 27, 27, 26, 26, 26, 26, 24,
23, 23, 23, 22, 22, 21, 20, 21, 20, 19, 20, 19, 18, 18, 17, 16, 16, 15, 15, 14,
13, 11, 11, 8, 7, 5, 3, -1, -4, -8, -12, -15, -19, -23, -26, -30, -34, -36, -38,
-41, -44, -45, -48, -50, -52, -53, -55, -55, -57, -58, -59, -59, -61, -62, -63,
-65, -66, -67, -68, -69, -70, -72, -73, -75, -76, -77, -79, -80, -82, -82, -82,
-84, -85, -85, -87, -91, -91, -93, -96, -97, -100, -103, -104, -106, -108, -109,
-110, -112, -113, -113, -114, -115, -115, -116, -116, -117, -118, -117, -117,
-117, -117, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -118, -118, -118, -119, -118, -118, -118, -117, -117, -117, -116,
-116, -115, -116, -115, -115, -114, -115, -114, -113, -113, -113, -112, -111,
-111, -112, -110, -110, -109, -110, -109, -109, -108, -108, -108, -107, -107,
-106, -105, -105, -104, -103, -103, -102, -102, -102, -100, -100, -99, -99, -98,
-96, -96, -95, -95, -96, -94, -93, -93, -93, -92, -91, -90, -89, -89, -87, -86,
-86, -85, -83, -83, -81, -80, -80, -78, -77, -75, -73, -72, -70, -68, -66, -62,
-61, -58, -55, -52, -49, -44, -41, -36, -32, -27, -22, -16, -11, -7, -1, };