#define DATA_LENGTH 512
#define DATA AKWF_0195

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 3, 4, 4, 6, 6, 7, 8, 9, 11,
11, 12, 13, 13, 14, 15, 15, 16, 17, 18, 19, 19, 20, 20, 22, 22, 25, 25, 26, 27,
27, 28, 29, 31, 32, 47, 59, 57, 56, 59, 66, 70, 70, 71, 73, 76, 78, 80, 82, 83,
85, 87, 90, 92, 93, 94, 95, 96, 98, 99, 99, 100, 102, 103, 103, 104, 105, 106,
106, 106, 108, 109, 109, 109, 110, 110, 111, 111, 111, 111, 112, 114, 113, 113,
114, 113, 114, 115, 114, 115, 116, 116, 116, 115, 116, 116, 116, 116, 117, 117,
117, 117, 118, 117, 117, 117, 117, 117, 119, 118, 118, 118, 118, 117, 118, 118,
119, 119, 118, 118, 119, 118, 119, 118, 118, 119, 119, 119, 119, 118, 118, 119,
120, 119, 119, 119, 119, 119, 119, 118, 119, 118, 119, 119, 119, 119, 120, 119,
119, 119, 119, 120, 119, 118, 117, 116, 115, 115, 113, 113, 112, 111, 110, 109,
107, 107, 105, 105, 103, 102, 101, 100, 98, 97, 96, 94, 94, 92, 91, 89, 88, 87,
85, 85, 83, 82, 81, 79, 78, 77, 76, 74, 73, 72, 71, 69, 68, 67, 65, 64, 63, 62,
61, 60, 59, 57, 55, 54, 54, 53, 51, 50, 49, 48, 47, 45, 45, 44, 42, 41, 40, 39,
38, 37, 36, 35, 33, 32, 32, 30, 29, 28, 27, 26, 26, 24, 23, 22, 20, 20, 19, 17,
16, 15, 14, 13, 12, 10, 10, 9, 7, 6, 6, 4, 3, 2, 1, 0, 0, -2, -3, -4, -5, -7,
-8, -9, -9, -11, -13, -13, -15, -16, -18, -19, -19, -20, -21, -22, -23, -23,
-30, -47, -54, -49, -51, -56, -63, -67, -68, -68, -71, -73, -76, -78, -80, -82,
-85, -86, -88, -89, -91, -92, -93, -95, -96, -97, -99, -100, -100, -102, -102,
-104, -104, -105, -107, -107, -107, -108, -108, -108, -110, -110, -111, -111,
-111, -112, -113, -113, -112, -113, -113, -114, -115, -115, -114, -115, -115,
-115, -116, -115, -116, -115, -117, -116, -117, -117, -117, -117, -117, -117,
-117, -118, -117, -117, -118, -118, -117, -117, -118, -118, -118, -118, -118,
-119, -118, -118, -118, -118, -119, -118, -118, -118, -118, -119, -119, -119,
-118, -118, -118, -118, -119, -119, -119, -118, -119, -119, -119, -118, -120,
-119, -119, -119, -120, -119, -119, -120, -119, -119, -119, -119, -119, -118,
-117, -117, -115, -115, -114, -114, -112, -112, -111, -109, -108, -107, -105,
-105, -104, -103, -102, -100, -99, -98, -97, -96, -94, -94, -92, -91, -89, -87,
-87, -86, -84, -83, -82, -81, -79, -78, -77, -76, -74, -73, -72, -70, -69, -69,
-68, -66, -65, -64, -62, -61, -61, -59, -59, -56, -56, -55, -54, -53, -52, -51,
-49, -48, -47, -46, -46, -44, -43, -41, -41, -40, -38, -37, -36, -35, -34, -34,
-32, -31, -30, -29, -28, -27, -26, -26, -24, -23, -23, -22, -20, -19, -18, -16,
-15, -14, -13, -11, -12, -10, -8, -8, -8, -5, -5, -4, -4, -2, -1, 0, };