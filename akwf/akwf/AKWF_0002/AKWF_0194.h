#define DATA_LENGTH 512
#define DATA AKWF_0194

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, -8, -13, -16, -19, -24, -30, -34,
-38, -43, -46, -51, -53, -56, -61, -63, -66, -69, -71, -73, -76, -77, -80, -82,
-83, -86, -87, -90, -91, -91, -93, -94, -96, -97, -98, -99, -100, -100, -102,
-102, -104, -104, -104, -106, -106, -107, -107, -108, -108, -109, -109, -110,
-110, -110, -110, -110, -111, -111, -112, -112, -113, -113, -113, -113, -113,
-114, -114, -113, -114, -115, -115, -115, -115, -115, -115, -115, -115, -115,
-116, -116, -116, -116, -116, -116, -115, -116, -116, -117, -116, -116, -116,
-116, -116, -116, -115, -114, -115, -115, -113, -114, -119, -117, -116, -117,
-116, -117, -117, -116, -116, -117, -116, -117, -116, -117, -117, -117, -116,
-116, -117, -117, -117, -117, -117, -116, -117, -118, -117, -117, -117, -117,
-118, -117, -118, -117, -117, -117, -117, -117, -117, -117, -118, -116, -118,
-117, -117, -118, -117, -117, -117, -117, -117, -118, -117, -117, -118, -117,
-118, -117, -118, -117, -117, -118, -118, -117, -117, -118, -117, -117, -118,
-117, -118, -117, -117, -118, -118, -118, -117, -117, -118, -117, -118, -117,
-118, -117, -117, -118, -117, -117, -117, -117, -118, -117, -118, -118, -118,
-118, -117, -117, -117, -118, -117, -117, -117, -117, -118, -117, -118, -117,
-117, -118, -117, -117, -115, -114, -113, -113, -112, -112, -111, -110, -109,
-108, -106, -106, -105, -104, -103, -101, -101, -99, -98, -96, -95, -95, -94,
-92, -92, -90, -88, -88, -86, -85, -83, -83, -81, -80, -79, -79, -79, -78, -77,
-76, -75, -75, -73, -73, -72, -71, -72, -71, -69, -69, -68, -68, -68, -67, -66,
-65, -64, -64, -63, -62, -62, -61, -61, -59, -59, -58, -57, -56, -56, -55, -53,
-53, -52, -51, -50, -50, -48, -46, -46, -46, -44, -43, -41, -41, -39, -38, -38,
-35, -34, -34, -31, -31, -29, -28, -26, -25, -23, -21, -17, -15, -12, -8, -7,
-5, -3, -2, 0, 2, 4, 6, 8, 10, 13, 15, 16, 18, 20, 21, 23, 25, 26, 28, 30, 31,
32, 34, 35, 36, 38, 39, 41, 41, 44, 58, 76, 72, 68, 69, 71, 74, 75, 78, 80, 82,
84, 85, 87, 88, 91, 92, 94, 94, 96, 97, 98, 98, 100, 101, 101, 102, 103, 104,
104, 104, 106, 107, 107, 108, 108, 109, 109, 110, 110, 110, 110, 110, 112, 111,
112, 112, 112, 112, 114, 113, 113, 114, 114, 114, 115, 115, 115, 115, 115, 115,
115, 115, 115, 115, 115, 115, 116, 115, 115, 116, 116, 117, 117, 116, 116, 117,
116, 117, 116, 116, 116, 117, 116, 117, 117, 117, 117, 118, 118, 117, 117, 117,
117, 117, 117, 117, 118, 118, 117, 117, 117, 117, 117, 118, 117, 117, 117, 118,
117, 117, 117, 117, 117, 117, 118, 117, 117, 118, 117, 117, 118, 117, 117, 117,
117, 117, 117, 118, 118, 117, 117, 118, 117, 118, 118, 118, 117, 118, 116, 118,
118, 118, 117, 118, 118, 118, 117, 118, 117, 117, 117, 118, 117, 96, 85, 83, 78,
75, 65, 51, 45, 38, 29, 22, 13, 6, };