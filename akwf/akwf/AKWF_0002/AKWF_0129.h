#define DATA_LENGTH 512
#define DATA AKWF_0129

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 10, 12, 14, 18, 20, 23, 25,
28, 31, 33, 35, 38, 40, 43, 46, 47, 50, 52, 54, 57, 59, 61, 62, 65, 66, 69, 71,
73, 74, 77, 78, 80, 81, 82, 84, 86, 87, 88, 89, 90, 92, 92, 94, 94, 96, 97, 98,
99, 99, 100, 101, 102, 102, 103, 103, 105, 104, 106, 106, 107, 108, 108, 108,
108, 109, 109, 110, 111, 110, 112, 112, 111, 112, 112, 112, 113, 113, 113, 113,
113, 114, 115, 115, 115, 115, 116, 115, 116, 116, 116, 116, 116, 117, 117, 116,
117, 117, 117, 117, 118, 117, 117, 117, 117, 117, 118, 118, 118, 118, 118, 117,
118, 118, 117, 119, 118, 118, 119, 118, 119, 118, 119, 118, 118, 119, 118, 118,
118, 119, 119, 119, 118, 118, 118, 118, 118, 119, 118, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 120, 119, 119, 119, 120, 118, 119, 119, 118,
120, 119, 119, 118, 119, 119, 118, 118, 118, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 118, 118, 119, 118, 120, 119, 119, 119, 118, 119, 118, 120, 119,
119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119,
120, 120, 119, 119, 118, 118, 117, 113, 108, 105, 99, 94, 87, 80, 72, 62, 54,
48, 41, 35, 30, 26, 21, 18, 14, 12, 8, 5, 3, 0, -3, -5, -7, -11, -13, -15, -17,
-20, -22, -26, -28, -31, -33, -35, -38, -40, -43, -45, -47, -51, -53, -54, -57,
-59, -61, -63, -66, -67, -70, -71, -74, -75, -76, -77, -80, -81, -83, -84, -85,
-86, -88, -90, -91, -92, -93, -93, -94, -96, -97, -98, -99, -100, -101, -101,
-102, -102, -103, -104, -105, -105, -106, -106, -107, -108, -108, -108, -108,
-109, -110, -110, -110, -111, -111, -111, -111, -112, -112, -112, -113, -113,
-114, -114, -114, -114, -114, -115, -114, -116, -116, -115, -116, -115, -116,
-116, -116, -117, -116, -117, -116, -117, -116, -117, -117, -117, -117, -117,
-117, -118, -117, -117, -118, -118, -118, -118, -118, -117, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -119, -118,
-118, -119, -118, -118, -118, -119, -118, -119, -119, -118, -119, -119, -118,
-119, -119, -118, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -118, -118, -118, -119, -118, -119, -118, -119, -119, -119, -119,
-119, -119, -120, -118, -118, -119, -119, -118, -120, -120, -119, -120, -118,
-120, -119, -120, -119, -119, -119, -119, -120, -120, -119, -119, -119, -120,
-118, -119, -119, -119, -118, -119, -119, -119, -120, -119, -119, -118, -118,
-118, -118, -119, -120, -119, -120, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -115, -112, -109, -104,
-98, -93, -86, -79, -71, -62, -53, -46, -40, -35, -29, -25, -22, -18, -14, -11,
-8, -5, -3, -1, };