#define DATA_LENGTH 512
#define DATA AKWF_0174

const PROGMEM int8_t DATA[DATA_LENGTH] = {35, 41, 39, 41, 39, 40, 40, 40, 40,
39, 40, 39, 42, 35, 56, 84, 76, 82, 78, 80, 79, 80, 79, 79, 79, 79, 79, 80, 79,
79, 80, 79, 80, 79, 79, 79, 79, 79, 79, 79, 79, 80, 80, 78, 79, 79, 79, 79, 79,
80, 79, 80, 79, 79, 79, 80, 79, 80, 79, 79, 79, 79, 79, 79, 79, 79, 79, 80, 79,
79, 79, 80, 79, 79, 79, 79, 79, 79, 79, 79, 80, 79, 80, 80, 79, 79, 79, 79, 79,
79, 79, 80, 79, 79, 79, 80, 79, 79, 79, 79, 79, 79, 80, 80, 79, 79, 80, 80, 79,
79, 79, 79, 80, 80, 79, 79, 79, 79, 79, 80, 79, 79, 79, 80, 79, 79, 80, 79, 80,
79, 79, 79, 80, 79, 78, 79, 80, 79, 80, 80, 79, 79, 79, 80, 79, 80, 79, 80, 80,
79, 79, 80, 79, 80, 79, 79, 79, 79, 79, 80, 80, 79, 79, 79, 79, 79, 79, 79, 79,
79, 80, 79, 79, 80, 80, 79, 80, 80, 79, 80, 79, 80, 79, 80, 79, 80, 79, 79, 79,
80, 79, 79, 79, 79, 80, 79, 80, 78, 80, 79, 81, 78, 81, 76, 84, 64, 36, 41, 39,
40, 40, 40, 41, 39, 40, 38, 40, 38, 41, 39, 40, 39, 39, 39, 39, 40, 39, 42, 35,
48, -10, -48, -35, -44, -38, -42, -38, -41, -39, -40, -40, -40, -41, -38, -42,
-35, -56, -85, -77, -81, -78, -80, -79, -79, -80, -79, -80, -79, -81, -76, -111,
-122, -117, -121, -118, -120, -118, -120, -119, -120, -118, -120, -119, -119,
-119, -119, -118, -119, -119, -120, -120, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -120, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-120, -119, -120, -119, -120, -119, -119, -119, -119, -119, -119, -119, -118,
-118, -119, -120, -119, -119, -119, -119, -119, -119, -119, -120, -119, -118,
-119, -119, -120, -119, -119, -118, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -118, -119, -120, -119, -120,
-119, -118, -119, -119, -119, -119, -119, -119, -118, -119, -119, -118, -119,
-119, -119, -118, -119, -119, -119, -119, -120, -118, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -120, -119, -120, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -120, -119, -119, -118,
-121, -118, -121, -116, -125, -100, -75, -81, -78, -81, -78, -79, -79, -80, -79,
-80, -78, -80, -78, -80, -77, -84, -63, -35, -42, -38, -40, -39, -39, -40, -39,
-42, -37, -45, -21, 5, -3, 2, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, -1, 0, 0, 0,
0, 0, };