#define DATA_LENGTH 512
#define DATA AKWF_0128

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 32, 64, 85, 100, 104, 97, 84, 67,
47, 31, 19, 14, 17, 27, 42, 62, 79, 94, 103, 103, 95, 80, 58, 35, 12, -7, -18,
-20, -13, 1, 25, 51, 77, 98, 113, 119, 116, 103, 84, 59, 34, 12, -5, -14, -17,
-10, 3, 19, 36, 48, 55, 55, 46, 32, 12, -11, -31, -47, -56, -56, -45, -25, 1,
30, 59, 85, 104, 114, 114, 104, 88, 67, 45, 24, 9, 1, 1, 8, 20, 36, 51, 62, 69,
66, 55, 37, 13, -13, -38, -58, -70, -74, -68, -53, -32, -7, 17, 38, 53, 59, 54,
41, 20, -4, -28, -50, -67, -76, -77, -68, -54, -38, -21, -6, 2, 3, -4, -18, -36,
-56, -76, -89, -97, -93, -80, -58, -29, 2, 34, 61, 81, 94, 96, 89, 74, 54, 34,
15, 3, -3, -1, 8, 23, 40, 57, 70, 77, 75, 65, 48, 25, 1, -24, -43, -54, -57,
-52, -36, -15, 10, 36, 56, 69, 74, 69, 55, 34, 9, -16, -39, -57, -67, -69, -62,
-50, -34, -19, -7, 0, -1, -10, -26, -47, -69, -91, -105, -115, -114, -103, -83,
-56, -26, 2, 29, 47, 56, 56, 46, 29, 8, -14, -35, -49, -56, -55, -47, -32, -16,
-1, 11, 17, 15, 4, -15, -38, -62, -86, -105, -117, -119, -112, -97, -73, -48,
-21, 0, 15, 20, 18, 5, -14, -37, -61, -81, -96, -103, -102, -93, -78, -59, -40,
-26, -17, -14, -19, -32, -50, -69, -86, -98, -103, -98, -83, -60, -29, 4, 37,
66, 87, 100, 102, 97, 83, 65, 46, 30, 18, 14, 18, 29, 44, 64, 81, 96, 103, 102,
93, 77, 55, 32, 9, -9, -19, -21, -12, 5, 28, 53, 78, 100, 114, 119, 115, 102,
81, 57, 32, 10, -7, -16, -15, -9, 5, 21, 36, 48, 56, 55, 45, 30, 9, -13, -33,
-49, -56, -55, -44, -23, 4, 34, 62, 88, 106, 114, 114, 103, 86, 64, 42, 22, 8,
0, 0, 8, 22, 37, 53, 65, 69, 66, 54, 34, 11, -16, -39, -59, -71, -73, -67, -52,
-30, -6, 20, 40, 54, 58, 53, 40, 18, -5, -31, -52, -68, -75, -75, -68, -53, -36,
-19, -6, 2, 3, -5, -19, -39, -58, -77, -91, -96, -92, -78, -55, -27, 6, 37, 64,
83, 94, 96, 87, 72, 52, 31, 14, 2, -4, -1, 10, 24, 42, 59, 71, 76, 74, 64, 47,
23, -2, -26, -45, -56, -57, -50, -34, -12, 14, 37, 57, 70, 74, 68, 53, 32, 6,
-18, -41, -58, -67, -69, -62, -48, -32, -18, -6, 0, -2, -12, -29, -50, -72, -92,
-108, -115, -113, -101, -80, -53, -24, 6, 31, 48, 56, 55, 44, 27, 5, -16, -36,
-50, -56, -55, -45, -32, -15, 0, 11, 16, 14, 3, -16, -40, -65, -89, -107, -117,
-119, -110, -93, -70, -45, -19, 2, 16, 21, 16, 4, -17, -39, -64, -83, -98, -104,
-102, -92, -76, -57, -39, -24, -15, -14, -21, -35, -52, -71, -87, -99, -103,
-97, -80, -57, -24, };