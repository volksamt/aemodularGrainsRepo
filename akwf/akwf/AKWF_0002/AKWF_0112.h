#define DATA_LENGTH 512
#define DATA AKWF_0112

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 26, 36, 48, 57, 65, 73, 80, 85,
89, 94, 98, 100, 104, 105, 108, 110, 110, 113, 113, 114, 115, 115, 116, 117,
117, 117, 117, 118, 118, 118, 118, 118, 118, 118, 118, 119, 118, 118, 119, 118,
119, 118, 118, 118, 119, 118, 119, 119, 120, 118, 119, 119, 119, 119, 118, 119,
120, 119, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 120, 119, 120, 118,
119, 120, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 120, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 120, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 118,
119, 119, 119, 120, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 120, 119, 119, 119, 120, 119, 119, 118, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 118, 119,
120, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 119,
118, 119, 118, 119, 118, 119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 113,
100, 85, 71, 54, 36, 19, 2, -13, -26, -39, -50, -58, -67, -74, -80, -85, -90,
-95, -97, -100, -103, -107, -108, -109, -111, -112, -114, -114, -115, -115,
-116, -116, -117, -118, -117, -118, -118, -118, -118, -118, -119, -118, -118,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -118, -119, -119, -119,
-118, -119, -119, -120, -118, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -120, -119, -119, -120, -119,
-119, -119, -119, -120, -119, -120, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -120, -120, -119, -119, -118, -118, -119, -118, -119, -119,
-119, -120, -120, -119, -118, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -120, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -118, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -120, -119, -119, -118, -119, -120, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-120, -119, -119, -118, -113, -99, -84, -69, -52, -34, -17, -2, };