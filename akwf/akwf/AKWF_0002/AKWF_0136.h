#define DATA_LENGTH 512
#define DATA AKWF_0136

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 14, 17, 22, 25, 31, 35, 39,
43, 48, 52, 56, 60, 64, 68, 71, 75, 78, 82, 85, 88, 92, 95, 96, 99, 102, 104,
106, 109, 109, 112, 113, 114, 115, 116, 116, 117, 118, 119, 119, 119, 119, 118,
118, 118, 119, 117, 118, 117, 116, 115, 115, 113, 113, 111, 110, 109, 108, 107,
106, 104, 103, 103, 101, 100, 99, 98, 96, 95, 94, 93, 92, 90, 89, 89, 88, 86,
85, 85, 84, 83, 81, 81, 80, 78, 78, 77, 76, 74, 75, 73, 74, 72, 72, 71, 71, 69,
69, 68, 68, 68, 67, 66, 66, 66, 65, 65, 65, 64, 63, 63, 63, 63, 62, 62, 61, 62,
61, 60, 61, 59, 60, 61, 59, 59, 60, 59, 58, 59, 58, 58, 57, 57, 57, 57, 57, 57,
57, 57, 56, 56, 56, 56, 56, 56, 55, 55, 56, 56, 55, 55, 55, 55, 55, 54, 54, 53,
53, 54, 54, 54, 53, 53, 53, 52, 53, 51, 52, 53, 52, 52, 52, 51, 51, 51, 51, 49,
51, 50, 50, 49, 50, 49, 48, 49, 48, 48, 48, 49, 48, 48, 46, 47, 47, 47, 46, 46,
47, 46, 46, 46, 45, 45, 45, 45, 44, 44, 43, 44, 43, 43, 42, 43, 42, 42, 42, 42,
42, 40, 41, 41, 40, 40, 40, 40, 40, 39, 39, 39, 39, 38, 38, 38, 37, 37, 37, 37,
37, 36, 35, 34, 34, 32, 30, 28, 25, 23, 20, 17, 14, 10, 7, 5, 1, -2, -7, -9,
-13, -17, -22, -27, -30, -35, -40, -43, -47, -52, -56, -60, -64, -68, -72, -75,
-79, -83, -84, -89, -91, -95, -96, -99, -102, -104, -107, -108, -109, -112,
-113, -114, -115, -115, -117, -117, -119, -118, -119, -119, -120, -120, -119,
-118, -118, -117, -117, -116, -115, -115, -114, -113, -113, -111, -110, -109,
-108, -107, -106, -104, -104, -102, -101, -99, -98, -97, -96, -95, -94, -93,
-92, -91, -89, -89, -87, -86, -86, -83, -82, -83, -82, -80, -80, -78, -78, -77,
-76, -75, -74, -73, -74, -72, -71, -70, -70, -70, -69, -68, -68, -68, -67, -67,
-67, -65, -65, -65, -65, -63, -63, -63, -62, -62, -63, -61, -61, -61, -62, -61,
-61, -60, -60, -60, -59, -59, -58, -59, -58, -58, -59, -58, -58, -57, -58, -57,
-57, -57, -57, -57, -56, -56, -56, -56, -56, -56, -56, -56, -55, -54, -55, -54,
-55, -55, -54, -54, -54, -54, -53, -53, -54, -54, -53, -53, -53, -52, -53, -53,
-52, -52, -52, -52, -51, -51, -51, -51, -51, -50, -50, -50, -50, -50, -49, -50,
-49, -49, -48, -48, -48, -48, -47, -47, -47, -47, -47, -47, -47, -46, -46, -45,
-45, -46, -45, -45, -45, -44, -44, -45, -44, -43, -43, -43, -42, -42, -41, -42,
-42, -41, -41, -41, -40, -41, -40, -40, -40, -39, -40, -40, -38, -38, -38, -38,
-39, -38, -37, -37, -37, -36, -36, -37, -35, -35, -33, -31, -31, -27, -25, -23,
-20, -16, -14, -10, -8, -4, 0, };