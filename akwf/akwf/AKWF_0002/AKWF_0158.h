#define DATA_LENGTH 512
#define DATA AKWF_0158

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 7, 9, 11, 13, 14, 16, 18, 19,
20, 22, 24, 24, 25, 27, 27, 28, 29, 31, 31, 32, 32, 33, 34, 35, 36, 36, 37, 38,
39, 40, 40, 42, 42, 43, 44, 45, 46, 46, 47, 47, 48, 49, 50, 51, 51, 51, 52, 53,
54, 55, 54, 55, 56, 56, 56, 58, 59, 59, 59, 60, 60, 61, 61, 62, 62, 63, 63, 63,
64, 65, 65, 65, 66, 66, 66, 67, 67, 67, 68, 67, 68, 68, 68, 68, 69, 69, 70, 69,
68, 70, 70, 70, 70, 70, 71, 69, 70, 70, 70, 71, 71, 70, 71, 70, 71, 70, 70, 70,
70, 70, 69, 69, 74, 86, 82, 81, 90, 95, 98, 99, 101, 104, 105, 106, 106, 105,
105, 103, 101, 100, 98, 97, 95, 94, 94, 92, 91, 91, 90, 89, 89, 88, 87, 87, 86,
86, 85, 85, 84, 83, 83, 82, 81, 81, 80, 79, 79, 78, 77, 77, 76, 75, 73, 73, 73,
71, 71, 70, 69, 67, 66, 66, 64, 63, 63, 62, 61, 59, 58, 57, 56, 55, 54, 53, 52,
51, 49, 48, 47, 46, 44, 43, 42, 40, 39, 38, 37, 35, 33, 33, 31, 31, 29, 27, 26,
24, 23, 22, 21, 19, 18, 16, 15, 14, 12, 11, 10, 8, 7, 5, 4, 3, 2, 0, -1, -3, -3,
-5, -8, -8, -9, -12, -12, -14, -15, -17, -17, -20, -18, -6, -7, -12, -5, -1, 1,
3, 3, 5, 6, 6, 5, 3, 2, -1, -3, -6, -7, -9, -12, -14, -15, -16, -18, -19, -20,
-22, -23, -24, -26, -27, -27, -28, -29, -30, -31, -32, -32, -33, -34, -35, -36,
-37, -37, -38, -39, -40, -41, -41, -42, -43, -44, -44, -46, -46, -47, -48, -48,
-49, -50, -51, -51, -51, -53, -53, -54, -54, -55, -56, -56, -57, -56, -58, -58,
-59, -60, -59, -60, -61, -61, -62, -62, -62, -63, -64, -63, -64, -65, -65, -65,
-66, -66, -66, -66, -67, -67, -68, -68, -69, -68, -69, -70, -69, -69, -69, -70,
-69, -70, -70, -70, -70, -70, -69, -69, -70, -70, -71, -71, -71, -70, -70, -69,
-70, -70, -70, -70, -70, -69, -69, -76, -86, -81, -83, -91, -94, -98, -99, -102,
-104, -105, -106, -105, -106, -104, -103, -101, -100, -98, -97, -95, -95, -93,
-92, -92, -90, -91, -90, -89, -88, -87, -88, -86, -86, -85, -85, -83, -83, -82,
-82, -81, -81, -80, -80, -78, -78, -76, -77, -75, -75, -74, -73, -72, -71, -70,
-69, -68, -67, -66, -65, -65, -63, -62, -62, -60, -59, -58, -56, -55, -55, -54,
-53, -51, -50, -48, -48, -47, -46, -44, -43, -42, -41, -39, -37, -37, -35, -34,
-33, -31, -30, -28, -27, -26, -24, -23, -21, -20, -19, -18, -16, -15, -14, -13,
-11, -10, -8, -7, -6, -4, -3, -1, 0, 1, 3, 3, 5, 7, 8, 9, 11, 13, 14, 15, 16,
18, 19, 17, 5, 7, 13, 4, 0, -2, -3, -4, -5, -6, -5, -6, -4, -2, };