#define DATA_LENGTH 512
#define DATA AKWF_0155

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 13, 21, 31, 40, 49, 59, 67, 73, 78,
81, 84, 85, 84, 84, 82, 80, 78, 76, 76, 75, 74, 74, 75, 75, 76, 75, 74, 74, 74,
71, 70, 67, 65, 61, 59, 58, 57, 58, 60, 64, 68, 74, 81, 88, 95, 102, 109, 113,
117, 119, 119, 118, 114, 110, 103, 97, 89, 82, 75, 70, 64, 60, 59, 57, 58, 57,
58, 60, 62, 64, 64, 64, 63, 62, 59, 57, 53, 49, 46, 43, 41, 40, 39, 40, 41, 44,
47, 51, 54, 58, 61, 64, 66, 66, 66, 65, 64, 62, 61, 58, 57, 56, 57, 57, 59, 61,
65, 68, 71, 75, 77, 77, 78, 78, 75, 72, 67, 59, 54, 46, 40, 33, 28, 24, 21, 20,
20, 23, 27, 31, 36, 41, 46, 52, 56, 58, 58, 59, 58, 55, 50, 46, 41, 36, 30, 26,
21, 18, 14, 12, 10, 9, 7, 6, 3, 0, -1, -4, -7, -11, -15, -18, -20, -23, -23,
-22, -22, -17, -13, -8, -1, 6, 14, 21, 28, 35, 38, 41, 42, 41, 38, 35, 30, 24,
17, 11, 5, 0, -5, -8, -10, -12, -10, -10, -9, -7, -5, -3, -2, -2, -3, -5, -7,
-10, -14, -18, -21, -25, -28, -29, -30, -31, -30, -27, -25, -22, -20, -16, -14,
-11, -11, -10, -11, -12, -14, -16, -19, -20, -22, -23, -24, -23, -21, -19, -16,
-13, -9, -7, -3, -2, -1, -2, -3, -7, -12, -17, -23, -29, -35, -41, -46, -49,
-51, -50, -49, -47, -43, -37, -31, -25, -18, -13, -9, -4, -3, -3, -3, -6, -9,
-13, -17, -23, -28, -32, -37, -41, -44, -47, -49, -52, -53, -55, -58, -60, -64,
-67, -71, -75, -79, -84, -87, -91, -92, -93, -92, -90, -87, -82, -77, -70, -64,
-57, -51, -47, -42, -41, -40, -41, -44, -48, -54, -60, -66, -73, -79, -83, -88,
-91, -93, -93, -91, -89, -87, -83, -79, -76, -74, -72, -70, -69, -70, -71, -72,
-73, -74, -75, -75, -74, -72, -70, -65, -60, -54, -49, -43, -35, -29, -24, -19,
-15, -13, -10, -8, -7, -7, -6, -4, -1, 1, 4, 10, 14, 19, 25, 32, 37, 42, 46, 48,
49, 50, 48, 46, 42, 37, 31, 26, 22, 19, 16, 15, 16, 17, 21, 26, 31, 39, 45, 51,
58, 62, 66, 69, 70, 69, 67, 64, 60, 56, 51, 46, 41, 37, 34, 29, 27, 25, 24, 22,
20, 18, 16, 14, 11, 6, 3, -2, -5, -8, -10, -13, -12, -11, -10, -5, 0, 5, 11, 19,
25, 30, 36, 39, 42, 42, 40, 39, 33, 27, 21, 14, 7, -1, -7, -12, -16, -19, -20,
-20, -20, -18, -17, -15, -14, -13, -13, -14, -16, -18, -21, -25, -29, -33, -36,
-39, -40, -42, -41, -40, -38, -35, -32, -28, -24, -20, -17, -15, -13, -13, -13,
-13, -13, -15, -15, -16, -15, -14, -12, -10, -5, -1, 3, 8, 14, 18, 22, 23, 25,
26, 24, 21, 18, 14, 10, 5, 1, -1, -2, -3, -1, 1, };