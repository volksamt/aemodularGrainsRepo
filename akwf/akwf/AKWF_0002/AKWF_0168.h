#define DATA_LENGTH 512
#define DATA AKWF_0168

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 6, 8, 10, 12, 14, 17, 19, 21,
23, 26, 28, 31, 32, 35, 37, 39, 42, 44, 46, 48, 50, 51, 54, 54, 56, 56, 57, 59,
59, 60, 60, 60, 60, 62, 60, 60, 60, 58, 57, 57, 55, 53, 51, 48, 47, 44, 42, 40,
37, 34, 32, 29, 27, 23, 20, 17, 14, 11, 7, 5, 2, -1, -3, -6, -9, -12, -14, -16,
-19, -21, -24, -26, -28, -29, -30, -32, -33, -35, -35, -35, -36, -37, -36, -36,
-35, -35, -33, -31, -29, -28, -26, -24, -21, -18, -15, -12, -10, -5, -2, 1, 4,
8, 13, 17, 21, 26, 30, 34, 39, 44, 49, 54, 59, 64, 69, 72, 77, 82, 86, 90, 94,
96, 100, 104, 107, 110, 112, 113, 116, 117, 118, 119, 119, 119, 118, 119, 117,
115, 114, 112, 109, 107, 104, 100, 96, 93, 89, 84, 79, 74, 70, 65, 60, 54, 49,
42, 37, 31, 26, 20, 14, 8, 3, 2, 0, 1, 0, 2, 4, 7, 11, 15, 20, 24, 27, 31, 35,
39, 41, 43, 45, 47, 47, 48, 48, 48, 47, 46, 45, 42, 40, 37, 35, 31, 28, 24, 20,
17, 13, 8, 4, 1, -4, -8, -13, -18, -22, -26, -32, -37, -41, -47, -51, -56, -61,
-65, -69, -73, -78, -80, -85, -87, -90, -93, -96, -97, -99, -101, -101, -103,
-102, -103, -103, -103, -103, -101, -100, -98, -97, -95, -92, -90, -87, -85,
-81, -77, -74, -71, -66, -63, -59, -55, -50, -47, -43, -39, -35, -30, -27, -23,
-19, -15, -11, -9, -5, -2, 1, 4, 7, 9, 12, 15, 16, 19, 20, 22, 25, 25, 27, 28,
29, 30, 30, 30, 30, 29, 30, 28, 27, 26, 25, 24, 23, 22, 19, 18, 16, 13, 11, 9,
7, 5, 3, 0, -1, -3, -6, -8, -10, -13, -15, -17, -19, -21, -24, -27, -28, -30,
-33, -35, -37, -37, -39, -40, -41, -42, -45, -45, -45, -45, -45, -46, -47, -46,
-45, -45, -45, -44, -43, -42, -42, -40, -39, -37, -37, -36, -34, -33, -30, -29,
-27, -25, -24, -21, -20, -19, -17, -15, -14, -11, -10, -8, -7, -5, -4, -2, -2,
-1, 0, 0, 2, 3, 3, 4, 5, 5, 6, 7, 6, 7, 7, 8, 8, 8, 7, 8, 8, 7, 8, 7, 6, 6, 6,
6, 5, 5, 4, 3, 2, 3, 2, 1, 1, 1, 1, -1, -1, -1, -1, -1, -1, -1, -1, -2, -2, -2,
-1, -1, -2, -2, -2, -1, -1, -1, 0, 0, 1, 2, 1, 1, 2, 3, 3, 4, 5, 5, 5, 6, 6, 7,
6, 8, 8, 9, 8, 9, 9, 9, 10, 9, 9, 10, 10, 9, 9, 9, 9, 8, 8, 7, 7, 7, 6, 5, 4, 4,
3, 3, 1, 1, 0, -1, -2, -3, -4, -4, -4, -5, -6, -7, -8, -9, -10, -10, -11, -11,
-12, -12, -13, -14, -14, -13, -13, -13, -14, -12, -13, -12, -11, -10, -10, -9,
-7, -8, -6, -4, -3, -1, 0, };