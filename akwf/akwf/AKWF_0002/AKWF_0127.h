#define DATA_LENGTH 512
#define DATA AKWF_0127

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 6, 8, 11, 12, 14, 15, 17, 19,
21, 22, 24, 26, 27, 28, 30, 32, 34, 35, 36, 38, 39, 41, 42, 44, 45, 47, 48, 48,
51, 51, 52, 54, 56, 56, 57, 58, 60, 60, 62, 63, 64, 65, 66, 67, 67, 69, 69, 70,
71, 72, 72, 74, 73, 75, 75, 76, 76, 77, 78, 78, 78, 79, 79, 81, 80, 81, 82, 82,
82, 83, 83, 83, 84, 84, 84, 85, 84, 85, 85, 85, 86, 85, 86, 86, 85, 86, 87, 86,
86, 86, 87, 87, 88, 87, 88, 88, 88, 88, 88, 88, 89, 88, 89, 89, 89, 89, 89, 89,
90, 90, 91, 91, 91, 91, 92, 91, 91, 92, 92, 93, 93, 93, 93, 94, 94, 95, 95, 96,
96, 96, 97, 97, 97, 98, 98, 99, 100, 100, 100, 101, 102, 102, 103, 104, 104,
105, 106, 106, 107, 108, 108, 109, 110, 110, 112, 112, 113, 114, 114, 114, 115,
115, 116, 116, 117, 117, 119, 118, 119, 119, 119, 120, 119, 119, 119, 119, 119,
118, 119, 118, 117, 117, 117, 115, 115, 114, 113, 113, 112, 111, 110, 109, 108,
107, 105, 104, 102, 102, 99, 99, 98, 96, 95, 93, 92, 90, 88, 87, 84, 83, 81, 79,
78, 76, 74, 73, 70, 70, 67, 65, 64, 61, 59, 58, 54, 54, 51, 49, 46, 45, 44, 42,
40, 37, 36, 33, 32, 30, 27, 25, 23, 21, 19, 17, 16, 14, 12, 10, 7, 6, 5, 2, 0,
-1, -4, -5, -7, -9, -10, -13, -15, -16, -18, -20, -21, -22, -24, -26, -28, -30,
-31, -32, -34, -35, -36, -39, -39, -41, -42, -44, -45, -46, -47, -48, -50, -52,
-53, -53, -56, -56, -57, -59, -59, -61, -62, -62, -64, -65, -66, -66, -67, -69,
-70, -70, -71, -71, -72, -74, -74, -75, -74, -76, -77, -77, -78, -78, -78, -79,
-80, -80, -81, -82, -82, -81, -82, -83, -83, -83, -83, -83, -84, -84, -85, -85,
-85, -84, -85, -85, -86, -85, -86, -86, -87, -86, -87, -87, -87, -87, -88, -87,
-87, -87, -87, -88, -87, -89, -88, -88, -89, -88, -89, -89, -90, -90, -90, -90,
-90, -90, -91, -91, -92, -91, -92, -92, -92, -92, -94, -93, -94, -94, -94, -95,
-95, -95, -96, -96, -97, -96, -97, -98, -98, -99, -99, -100, -100, -101, -102,
-102, -103, -104, -104, -104, -105, -106, -107, -108, -108, -109, -109, -110,
-111, -112, -112, -113, -114, -115, -116, -116, -116, -117, -117, -117, -118,
-119, -118, -119, -119, -119, -120, -119, -119, -119, -119, -118, -119, -117,
-118, -116, -116, -116, -115, -114, -113, -112, -112, -110, -110, -108, -108,
-106, -105, -104, -103, -102, -99, -99, -97, -96, -94, -93, -91, -90, -88, -86,
-84, -83, -81, -79, -78, -76, -74, -72, -70, -69, -67, -64, -62, -60, -59, -58,
-55, -53, -51, -49, -47, -45, -42, -40, -39, -37, -35, -33, -31, -29, -26, -25,
-23, -22, -20, -17, -16, -13, -12, -9, -8, -6, -4, -2, -1, };