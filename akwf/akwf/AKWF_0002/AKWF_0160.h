#define DATA_LENGTH 512
#define DATA AKWF_0160

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 5, 6, 9, 11, 13, 16, 19, 22,
24, 27, 29, 33, 35, 38, 41, 44, 47, 50, 53, 55, 57, 60, 62, 65, 66, 68, 71, 72,
74, 76, 78, 79, 81, 82, 83, 85, 86, 86, 88, 89, 89, 91, 91, 92, 93, 95, 96, 95,
96, 97, 98, 98, 99, 100, 100, 101, 102, 102, 103, 103, 104, 104, 105, 105, 106,
105, 106, 107, 108, 108, 108, 108, 109, 109, 111, 110, 110, 111, 112, 112, 113,
113, 112, 112, 113, 113, 113, 114, 114, 115, 115, 115, 115, 116, 116, 116, 117,
117, 117, 117, 117, 118, 118, 118, 118, 118, 118, 118, 118, 119, 118, 119, 118,
118, 119, 118, 118, 118, 119, 119, 119, 119, 118, 120, 119, 119, 118, 119, 119,
119, 119, 119, 119, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 116, 116,
116, 116, 117, 116, 116, 115, 115, 114, 114, 115, 113, 114, 112, 113, 113, 113,
112, 111, 111, 111, 111, 110, 110, 110, 109, 109, 108, 108, 107, 107, 106, 106,
105, 105, 104, 103, 103, 102, 102, 102, 100, 101, 100, 98, 98, 97, 96, 96, 94,
94, 93, 92, 90, 88, 88, 87, 86, 84, 83, 82, 80, 79, 77, 75, 73, 72, 70, 68, 66,
63, 62, 59, 58, 55, 52, 51, 49, 45, 44, 41, 39, 36, 34, 33, 30, 27, 24, 23, 19,
19, 16, 14, 12, 10, 8, 6, 5, 4, 3, 1, -1, -1, -2, -4, -5, -7, -9, -12, -13, -15,
-18, -20, -21, -24, -26, -28, -29, -32, -33, -37, -38, -40, -42, -44, -47, -48,
-50, -52, -54, -56, -58, -60, -62, -64, -65, -67, -68, -70, -71, -73, -75, -76,
-77, -78, -79, -80, -81, -83, -83, -85, -85, -86, -87, -88, -89, -90, -90, -92,
-93, -93, -94, -94, -95, -96, -97, -96, -98, -98, -99, -99, -99, -100, -100,
-101, -101, -102, -102, -103, -103, -103, -103, -103, -105, -104, -104, -105,
-105, -106, -105, -106, -105, -107, -107, -106, -107, -107, -107, -107, -107,
-106, -107, -107, -107, -107, -107, -108, -108, -108, -108, -108, -107, -107,
-108, -107, -107, -108, -108, -107, -107, -106, -107, -107, -106, -106, -106,
-106, -106, -105, -105, -105, -108, -111, -110, -111, -112, -112, -114, -113,
-114, -114, -115, -114, -114, -114, -113, -113, -112, -112, -112, -111, -111,
-111, -112, -111, -112, -111, -110, -110, -110, -109, -110, -109, -109, -109,
-108, -108, -108, -108, -108, -107, -107, -107, -107, -106, -105, -105, -105,
-105, -105, -105, -105, -105, -104, -104, -104, -104, -104, -103, -103, -102,
-103, -102, -102, -102, -101, -101, -101, -100, -100, -100, -98, -98, -97, -97,
-97, -97, -96, -95, -95, -94, -94, -93, -93, -93, -92, -91, -90, -89, -89, -87,
-87, -86, -85, -84, -84, -82, -81, -80, -79, -77, -77, -75, -73, -72, -70, -67,
-67, -64, -63, -60, -58, -57, -54, -51, -48, -46, -44, -41, -38, -36, -32, -31,
-28, -24, -22, -20, -17, -14, -12, -9, -6, -4, -3, -1, };