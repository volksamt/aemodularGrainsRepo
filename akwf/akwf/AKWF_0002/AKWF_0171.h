#define DATA_LENGTH 512
#define DATA AKWF_0171

const PROGMEM int8_t DATA[DATA_LENGTH] = {35, 41, 39, 40, 39, 40, 39, 40, 40,
40, 40, 39, 40, 40, 39, 40, 39, 40, 40, 39, 40, 40, 40, 40, 40, 40, 40, 39, 39,
40, 40, 39, 39, 39, 39, 40, 39, 39, 40, 40, 40, 39, 40, 39, 40, 39, 40, 39, 39,
40, 40, 39, 40, 40, 40, 41, 38, 41, 38, 42, 34, 60, 85, 76, 81, 79, 80, 78, 79,
79, 79, 79, 80, 79, 80, 80, 79, 79, 79, 79, 78, 79, 79, 79, 80, 79, 80, 80, 79,
80, 78, 79, 79, 80, 79, 80, 80, 80, 79, 80, 79, 80, 79, 79, 80, 80, 79, 79, 79,
79, 80, 79, 80, 80, 79, 79, 80, 79, 80, 79, 80, 79, 79, 79, 79, 79, 80, 80, 79,
79, 79, 80, 79, 79, 80, 80, 80, 79, 79, 80, 79, 79, 80, 79, 80, 79, 79, 80, 80,
79, 79, 80, 80, 79, 79, 79, 80, 79, 80, 79, 79, 80, 79, 80, 79, 80, 79, 80, 80,
80, 79, 80, 79, 79, 79, 80, 79, 80, 79, 79, 79, 80, 79, 80, 79, 80, 80, 80, 79,
79, 80, 79, 80, 78, 80, 78, 80, 78, 82, 77, 82, 76, 82, 76, 84, 75, 85, 72, 89,
58, -123, -119, -118, -120, -116, -122, -117, -122, -116, -121, -117, -121,
-117, -120, -117, -120, -118, -120, -119, -120, -118, -120, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -118, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -118, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -118, -120, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -120, -120, -119, -119, -119, -119, -120, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -120, -119, -119, -119, -119, -120,
-119, -119, -120, -119, -119, -118, -119, -118, -120, -119, -120, -118, -120,
-119, -119, -119, -120, -118, -120, -119, -119, -119, -83, -77, -81, -79, -80,
-78, -80, -79, -80, -79, -79, -79, -79, -79, -80, -79, -79, -80, -80, -80, -79,
-79, -79, -79, -79, -80, -79, -80, -79, -80, -79, -80, -79, -79, -79, -80, -80,
-79, -79, -80, -78, -79, -80, -79, -79, -80, -79, -80, -79, -78, -80, -79, -80,
-79, -79, -79, -80, -79, -79, -80, -80, -80, -79, -80, -79, -80, -77, -83, -52,
-35, -42, -37, -42, -39, -41, -39, -41, -40, -40, -39, -41, -40, -40, -40, -40,
-39, -39, -40, -39, -40, -39, -40, -40, -40, -39, -40, -40, -40, -40, -40, -39,
-39, -40, -40, -39, -39, -40, -38, -44, -10, 3, -2, 1, -1, 1, -1, 1, 0, 0, -1,
1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 1, 0, 0, 0, -1, 0, 1, -1, 0, 0, 1, 0, 0, 0, 0, 0, };