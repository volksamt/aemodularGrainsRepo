#define DATA_LENGTH 512
#define DATA AKWF_0105

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 4, 4, 5, 7, 7, 9, 10, 11, 13,
14, 15, 16, 17, 18, 20, 21, 22, 23, 25, 26, 28, 28, 29, 30, 32, 34, 34, 36, 36,
38, 39, 40, 41, 41, 43, 44, 46, 47, 48, 49, 49, 51, 52, 52, 54, 55, 57, 58, 58,
60, 60, 61, 62, 63, 64, 65, 66, 66, 67, 68, 69, 70, 71, 71, 72, 74, 74, 75, 76,
77, 78, 78, 79, 81, 81, 81, 82, 82, 83, 84, 85, 85, 85, 86, 87, 87, 88, 88, 89,
90, 90, 90, 91, 92, 92, 93, 93, 93, 94, 94, 94, 95, 95, 95, 96, 95, 97, 97, 97,
97, 97, 98, 97, 98, 98, 98, 97, 99, 97, 98, 98, 98, 99, 99, 98, 98, 99, 99, 98,
97, 98, 97, 97, 97, 98, 97, 96, 96, 96, 96, 95, 96, 95, 95, 94, 94, 94, 93, 92,
91, 92, 92, 91, 91, 90, 89, 89, 89, 88, 87, 87, 86, 86, 85, 84, 84, 82, 82, 81,
81, 80, 79, 79, 78, 78, 76, 75, 75, 74, 73, 72, 71, 71, 69, 68, 67, 67, 66, 65,
64, 63, 62, 61, 60, 59, 58, 57, 56, 55, 54, 54, 52, 51, 50, 49, 47, 47, 45, 44,
42, 42, 41, 40, 39, 38, 36, 35, 34, 33, 31, 31, 29, 28, 27, 25, 25, 24, 22, 21,
20, 18, 17, 16, 14, 13, 13, 11, 10, 8, 8, 6, 6, 4, 3, 1, -1, -2, -3, -4, -5, -6,
-7, -8, -10, -10, -12, -14, -15, -16, -17, -18, -19, -20, -21, -22, -24, -25,
-25, -27, -29, -30, -30, -32, -32, -33, -35, -36, -37, -38, -39, -40, -41, -42,
-43, -44, -45, -46, -47, -48, -49, -51, -51, -51, -53, -54, -54, -56, -56, -57,
-58, -59, -59, -61, -61, -62, -63, -63, -65, -64, -66, -66, -67, -68, -69, -69,
-70, -70, -70, -72, -73, -72, -73, -73, -73, -74, -75, -76, -75, -76, -77, -76,
-77, -77, -78, -78, -78, -79, -79, -79, -79, -80, -79, -81, -80, -81, -81, -81,
-81, -81, -82, -81, -81, -81, -81, -81, -82, -81, -82, -82, -82, -81, -81, -81,
-81, -81, -81, -80, -81, -80, -80, -79, -80, -79, -80, -79, -84, -89, -86, -89,
-91, -92, -93, -92, -93, -93, -93, -92, -92, -92, -90, -90, -89, -89, -88, -88,
-87, -88, -87, -87, -87, -86, -86, -86, -85, -84, -84, -84, -83, -83, -84, -83,
-83, -82, -82, -81, -81, -81, -81, -80, -81, -79, -79, -79, -79, -78, -78, -77,
-77, -76, -76, -76, -75, -74, -74, -73, -73, -72, -70, -70, -69, -68, -68, -67,
-66, -66, -65, -65, -64, -63, -62, -62, -60, -59, -58, -58, -57, -57, -56, -55,
-54, -53, -53, -52, -50, -49, -49, -48, -46, -45, -45, -43, -43, -42, -41, -40,
-39, -38, -37, -36, -35, -34, -33, -32, -30, -30, -29, -28, -26, -25, -24, -23,
-22, -21, -19, -19, -17, -16, -15, -14, -13, -12, -10, -9, -7, -7, -5, -4, -3,
-2, -1, };