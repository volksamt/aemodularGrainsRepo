#define DATA_LENGTH 512
#define DATA AKWF_0149

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 7, 8, 9, 12, 13, 16, 17, 19,
20, 23, 24, 25, 28, 29, 30, 32, 34, 35, 37, 38, 40, 41, 43, 44, 46, 47, 48, 49,
50, 52, 53, 54, 55, 56, 58, 59, 60, 61, 61, 63, 64, 65, 66, 67, 68, 67, 69, 69,
71, 72, 72, 72, 74, 75, 74, 75, 75, 76, 77, 78, 78, 79, 79, 80, 80, 81, 80, 81,
81, 82, 82, 82, 82, 82, 83, 83, 84, 83, 84, 83, 84, 84, 84, 84, 84, 84, 84, 83,
84, 84, 84, 84, 84, 83, 84, 83, 84, 83, 82, 82, 82, 82, 82, 81, 80, 82, 80, 81,
80, 79, 78, 78, 78, 78, 77, 78, 77, 77, 76, 76, 76, 75, 74, 75, 74, 73, 73, 72,
72, 71, 71, 70, 70, 69, 69, 68, 68, 67, 67, 66, 66, 65, 65, 64, 64, 63, 63, 63,
62, 62, 61, 61, 62, 62, 62, 62, 63, 63, 62, 62, 63, 63, 63, 62, 64, 63, 63, 62,
62, 62, 63, 63, 63, 62, 62, 61, 60, 61, 60, 60, 59, 60, 58, 58, 57, 56, 57, 55,
55, 53, 53, 52, 51, 50, 50, 49, 48, 47, 46, 45, 43, 43, 43, 42, 40, 40, 38, 37,
36, 36, 35, 33, 33, 31, 30, 29, 28, 27, 26, 24, 24, 23, 22, 21, 20, 19, 18, 17,
16, 15, 13, 13, 12, 11, 10, 9, 8, 7, 6, 5, 4, 3, 2, 1, -1, -1, -1, -3, -3, -4,
-5, -6, -7, -8, -9, -9, -10, -10, -11, -13, -14, -14, -15, -16, -17, -17, -18,
-19, -20, -20, -21, -21, -22, -22, -24, -24, -24, -25, -26, -26, -27, -27, -28,
-28, -29, -29, -30, -30, -31, -32, -32, -32, -32, -33, -33, -34, -34, -35, -36,
-36, -36, -36, -36, -37, -37, -37, -38, -38, -38, -39, -39, -39, -40, -39, -39,
-40, -41, -40, -40, -40, -40, -41, -41, -41, -41, -40, -41, -41, -41, -42, -42,
-42, -41, -42, -43, -42, -41, -42, -41, -42, -42, -42, -41, -41, -42, -41, -42,
-41, -41, -41, -41, -41, -41, -41, -42, -41, -40, -40, -41, -40, -40, -40, -40,
-39, -39, -40, -39, -39, -39, -38, -38, -38, -38, -38, -37, -37, -36, -37, -36,
-36, -36, -36, -35, -35, -36, -35, -34, -34, -33, -33, -33, -34, -33, -33, -32,
-31, -32, -32, -32, -33, -34, -35, -37, -37, -39, -40, -43, -49, -54, -59, -63,
-66, -68, -72, -77, -80, -84, -89, -92, -97, -100, -103, -107, -111, -114, -116,
-117, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -118, -117, -116, -115, -113, -111, -109, -107, -106, -104, -101, -99,
-96, -95, -93, -90, -88, -85, -83, -81, -79, -76, -73, -72, -69, -68, -66, -63,
-60, -58, -55, -53, -51, -49, -46, -44, -41, -40, -37, -35, -32, -30, -28, -26,
-24, -22, -20, -17, -16, -13, -11, -9, -7, -5, -2, -1, };