#define DATA_LENGTH 512
#define DATA AKWF_0180

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 39, 41, 40, 40, 39, 41, 39, 40, 39,
41, 39, 40, 39, 40, 39, 39, 39, 40, 40, 39, 40, 39, 40, 39, 40, 39, 41, 38, 43,
35, 53, 84, 77, 81, 79, 80, 79, 79, 79, 79, 79, 78, 80, 79, 79, 79, 80, 79, 79,
78, 80, 79, 80, 79, 79, 79, 79, 79, 79, 79, 79, 80, 79, 79, 79, 79, 80, 79, 79,
79, 79, 80, 80, 79, 80, 79, 79, 80, 79, 79, 80, 79, 80, 79, 80, 78, 80, 79, 80,
79, 80, 78, 79, 79, 79, 78, 81, 78, 42, 39, 41, 38, 40, 39, 41, 39, 40, 40, 40,
40, 40, 39, 40, 40, 39, 40, 39, 40, 40, 40, 39, 39, 40, 40, 39, 40, 39, 40, 40,
40, 40, 39, 39, 39, 40, 40, 40, 39, 41, 39, 41, 38, 42, 38, 43, 32, -3, 1, 0, 0,
1, -1, 0, -1, 0, 0, 1, 1, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0,
1, 0, 0, -1, 1, 0, 0, 0, 1, 0, 0, 0, 0, -1, -1, 0, 0, 0, -1, 1, -1, 1, -1, 2,
-1, 2, -1, 3, -8, -42, -39, -41, -40, -40, -40, -40, -40, -40, -41, -39, -40,
-39, -40, -39, -40, -39, -40, -40, -40, -39, -40, -40, -39, -39, -40, -40, -39,
-40, -39, -40, -38, -41, -39, -40, -39, -41, -38, -42, -36, -50, -83, -78, -80,
-79, -80, -80, -79, -79, -79, -80, -79, -80, -79, -80, -78, -79, -79, -79, -79,
-80, -80, -79, -79, -79, -80, -79, -79, -80, -80, -79, -79, -79, -79, -79, -80,
-78, -79, -79, -79, -80, -80, -80, -80, -79, -79, -80, -79, -79, -79, -80, -79,
-79, -80, -79, -79, -79, -80, -79, -79, -79, -79, -79, -80, -79, -79, -79, -80,
-79, -80, -79, -80, -80, -79, -79, -79, -80, -79, -79, -78, -79, -79, -79, -80,
-80, -80, -79, -79, -79, -80, -79, -79, -79, -79, -79, -79, -79, -79, -79, -80,
-78, -80, -79, -80, -78, -81, -78, -81, -76, -85, -117, -124, -98, -76, -81,
-79, -79, -79, -80, -79, -79, -79, -79, -79, -79, -80, -79, -81, -79, -80, -78,
-80, -79, -80, -80, -80, -79, -79, -80, -80, -79, -79, -79, -79, -80, -80, -79,
-79, -80, -79, -79, -78, -80, -79, -79, -79, -79, -79, -79, -79, -79, -80, -80,
-79, -79, -79, -79, -79, -79, -79, -78, -79, -78, -81, -77, -84, -57, -35, -43,
-39, -41, -39, -40, -39, -39, -40, -40, -40, -40, -39, -40, -40, -40, -40, -39,
-40, -39, -40, -39, -40, -39, -40, -40, -40, -39, -41, -40, -40, -40, -40, -39,
-40, -39, -40, -40, -39, -39, -39, -41, -40, -40, -39, -40, -38, -41, -37, -45,
-24, 5, -2, 1, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0,
-1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, };