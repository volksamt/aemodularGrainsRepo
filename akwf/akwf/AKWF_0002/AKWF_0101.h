#define DATA_LENGTH 512
#define DATA AKWF_0101

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -1, -1, -2, -3, -3, -4, -4, -5, -5,
-7, -7, -7, -8, -9, -9, -10, -11, -11, -11, -12, -12, -13, -13, -15, -16, -15,
-17, -17, -17, -18, -19, -20, -22, -24, -26, -29, -31, -34, -37, -40, -42, -46,
-48, -51, -53, -56, -59, -62, -63, -65, -69, -71, -73, -74, -74, -75, -77, -76,
-76, -76, -75, -76, -76, -74, -74, -71, -71, -69, -69, -68, -66, -65, -64, -63,
-61, -60, -58, -58, -56, -55, -54, -53, -53, -51, -50, -49, -49, -49, -47, -47,
-46, -46, -45, -45, -46, -44, -45, -46, -46, -46, -47, -47, -48, -50, -50, -51,
-53, -54, -55, -57, -59, -60, -61, -62, -63, -65, -67, -69, -69, -70, -71, -72,
-74, -75, -76, -77, -78, -79, -80, -80, -82, -81, -82, -82, -84, -84, -84, -85,
-85, -85, -86, -85, -86, -87, -87, -86, -87, -87, -87, -87, -87, -87, -87, -87,
-87, -87, -87, -87, -87, -86, -87, -85, -85, -85, -85, -84, -84, -84, -83, -82,
-81, -82, -80, -79, -80, -78, -78, -77, -77, -76, -75, -74, -74, -73, -71, -72,
-70, -69, -69, -68, -67, -66, -66, -65, -63, -63, -62, -61, -60, -59, -58, -57,
-57, -57, -56, -54, -53, -52, -51, -51, -49, -48, -48, -47, -46, -46, -44, -43,
-42, -42, -41, -40, -39, -37, -38, -36, -35, -34, -33, -32, -31, -30, -30, -29,
-27, -26, -26, -25, -24, -24, -22, -21, -21, -20, -19, -18, -17, -16, -15, -14,
-14, -12, -12, -11, -10, -9, -9, -8, -7, -7, -5, -5, -4, -3, -3, -1, -1, -1, 0,
2, 2, 3, 3, 4, 5, 6, 6, 7, 8, 9, 9, 10, 10, 11, 12, 12, 13, 13, 14, 14, 16, 16,
17, 18, 19, 20, 23, 24, 25, 28, 30, 33, 35, 36, 38, 39, 41, 42, 45, 46, 47, 49,
51, 54, 55, 57, 59, 61, 62, 65, 66, 68, 68, 70, 71, 72, 74, 75, 76, 77, 78, 79,
81, 82, 83, 83, 85, 85, 87, 88, 88, 88, 89, 90, 91, 91, 93, 93, 94, 95, 95, 96,
96, 97, 97, 98, 98, 99, 100, 99, 100, 100, 100, 100, 101, 101, 102, 102, 101,
101, 102, 102, 102, 101, 101, 101, 100, 101, 100, 101, 100, 100, 100, 99, 98,
99, 98, 97, 97, 96, 96, 96, 95, 94, 94, 93, 93, 92, 92, 91, 90, 89, 89, 88, 88,
86, 85, 85, 85, 84, 83, 82, 81, 81, 79, 78, 77, 77, 76, 75, 74, 74, 73, 72, 71,
71, 69, 68, 68, 66, 66, 65, 63, 63, 62, 61, 59, 59, 58, 57, 56, 56, 54, 54, 53,
52, 51, 49, 49, 49, 46, 46, 44, 44, 43, 42, 41, 41, 40, 39, 38, 37, 36, 35, 34,
34, 32, 32, 32, 30, 29, 29, 28, 27, 27, 25, 25, 24, 23, 22, 22, 20, 20, 19, 17,
18, 17, 16, 15, 14, 14, 13, 12, 11, 10, 11, 10, 8, 9, 8, 6, 6, 6, 4, 4, 4, 3, 3,
1, 1, 0, };