#define DATA_LENGTH 512
#define DATA AKWF_0102

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 22, 35, 45, 56, 64, 70, 77, 81, 84,
87, 88, 90, 91, 92, 92, 93, 94, 94, 95, 95, 94, 95, 95, 95, 95, 96, 95, 95, 95,
95, 95, 96, 95, 95, 96, 96, 95, 95, 95, 95, 95, 96, 96, 96, 95, 96, 96, 96, 95,
96, 96, 96, 95, 95, 95, 95, 96, 95, 95, 96, 95, 96, 96, 95, 96, 96, 96, 96, 95,
95, 96, 95, 95, 95, 96, 96, 95, 96, 95, 96, 96, 96, 96, 96, 96, 96, 96, 96, 96,
95, 96, 95, 95, 95, 95, 95, 95, 96, 96, 95, 96, 96, 95, 96, 95, 95, 96, 96, 95,
95, 96, 95, 95, 95, 96, 96, 95, 95, 95, 96, 95, 96, 95, 96, 95, 95, 96, 96, 96,
96, 96, 96, 95, 95, 95, 96, 95, 95, 95, 96, 95, 95, 96, 96, 96, 96, 95, 96, 95,
95, 96, 96, 96, 96, 96, 95, 95, 95, 96, 95, 96, 95, 95, 96, 95, 95, 96, 95, 95,
95, 95, 95, 95, 95, 96, 96, 95, 95, 96, 95, 96, 95, 95, 95, 96, 96, 96, 96, 96,
96, 96, 96, 96, 95, 95, 96, 96, 95, 96, 95, 96, 95, 96, 96, 95, 96, 96, 95, 95,
96, 96, 96, 95, 96, 96, 95, 95, 95, 96, 96, 95, 95, 95, 95, 95, 95, 95, 96, 96,
96, 95, 95, 95, 96, 96, 96, 96, 96, 96, 96, 96, 96, 95, 96, 96, 95, 95, 94, 81,
69, 60, 47, 32, 17, 4, -10, -23, -35, -46, -57, -65, -71, -76, -81, -85, -86,
-89, -90, -90, -91, -93, -93, -93, -94, -94, -94, -95, -94, -95, -95, -95, -96,
-95, -95, -96, -95, -96, -95, -96, -96, -96, -96, -96, -96, -96, -95, -96, -96,
-95, -96, -96, -95, -95, -95, -96, -96, -96, -95, -95, -96, -95, -95, -96, -96,
-96, -95, -95, -96, -96, -95, -95, -95, -96, -96, -96, -96, -96, -96, -96, -95,
-95, -96, -96, -96, -96, -96, -96, -95, -95, -95, -96, -95, -96, -96, -95, -96,
-95, -96, -95, -95, -95, -95, -95, -95, -95, -96, -95, -95, -96, -95, -95, -95,
-96, -95, -96, -95, -95, -95, -95, -96, -95, -96, -95, -95, -95, -96, -95, -96,
-95, -95, -95, -95, -96, -96, -96, -95, -96, -96, -96, -95, -96, -95, -95, -95,
-95, -95, -96, -95, -95, -95, -95, -96, -96, -95, -96, -96, -95, -95, -95, -96,
-95, -96, -95, -95, -95, -96, -96, -96, -96, -96, -95, -96, -95, -95, -95, -96,
-96, -95, -95, -96, -96, -95, -95, -95, -95, -95, -95, -96, -95, -95, -96, -96,
-96, -96, -95, -95, -96, -96, -95, -96, -96, -96, -95, -96, -95, -96, -95, -96,
-96, -96, -95, -96, -96, -96, -96, -96, -96, -95, -96, -96, -95, -96, -95, -96,
-96, -95, -96, -96, -95, -95, -96, -96, -96, -96, -96, -95, -95, -96, -95, -96,
-96, -95, -96, -96, -95, -95, -96, -95, -96, -95, -95, -95, -96, -92, -80, -68,
-60, -46, -31, -16, -2, };