#define DATA_LENGTH 512
#define DATA AKWF_0121

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 10, 14, 18, 23, 27, 30, 34, 37,
41, 45, 48, 52, 54, 57, 60, 63, 66, 69, 71, 73, 76, 78, 80, 83, 85, 86, 88, 90,
92, 94, 95, 97, 97, 99, 100, 102, 102, 103, 104, 106, 105, 107, 108, 110, 110,
110, 111, 112, 112, 112, 113, 113, 114, 114, 115, 116, 115, 116, 117, 117, 116,
117, 118, 117, 117, 118, 118, 118, 118, 118, 118, 118, 118, 119, 118, 119, 118,
119, 119, 119, 120, 119, 119, 118, 119, 119, 120, 119, 119, 118, 120, 119, 119,
119, 118, 119, 117, 118, 117, 118, 117, 117, 116, 116, 116, 117, 117, 116, 115,
115, 115, 114, 114, 115, 113, 113, 114, 113, 113, 112, 111, 111, 111, 111, 109,
110, 109, 108, 107, 108, 106, 107, 106, 105, 104, 104, 103, 103, 103, 102, 102,
100, 100, 99, 99, 98, 97, 96, 96, 95, 95, 95, 94, 94, 94, 93, 94, 93, 93, 92,
92, 91, 91, 92, 92, 91, 91, 92, 91, 91, 92, 92, 92, 93, 93, 93, 94, 94, 94, 94,
95, 95, 95, 97, 97, 97, 98, 98, 99, 99, 99, 99, 100, 100, 100, 101, 101, 102,
101, 101, 101, 101, 102, 101, 101, 102, 101, 101, 100, 101, 100, 101, 99, 99,
99, 99, 98, 97, 96, 96, 95, 94, 93, 92, 91, 90, 88, 87, 84, 84, 81, 80, 78, 75,
73, 71, 67, 66, 63, 59, 57, 53, 49, 46, 43, 39, 35, 31, 28, 23, 20, 15, 11, 7,
2, -1, -5, -9, -13, -17, -21, -24, -29, -31, -35, -39, -42, -46, -49, -52, -55,
-58, -60, -63, -66, -68, -71, -73, -76, -78, -79, -82, -84, -86, -88, -90, -90,
-93, -94, -95, -97, -97, -100, -100, -101, -102, -104, -104, -105, -106, -107,
-108, -108, -109, -110, -110, -111, -112, -112, -112, -113, -113, -114, -114,
-115, -115, -115, -115, -117, -116, -117, -117, -116, -117, -118, -118, -117,
-117, -117, -118, -118, -118, -118, -118, -118, -117, -117, -117, -118, -119,
-118, -118, -118, -118, -118, -118, -118, -117, -117, -118, -117, -116, -117,
-117, -117, -117, -116, -116, -116, -115, -115, -115, -115, -114, -115, -115,
-114, -114, -113, -113, -113, -113, -113, -112, -113, -111, -111, -111, -110,
-110, -110, -110, -109, -109, -109, -108, -108, -107, -107, -107, -107, -106,
-105, -105, -105, -105, -104, -104, -104, -104, -104, -102, -103, -103, -102,
-102, -102, -102, -101, -101, -101, -100, -100, -100, -101, -100, -100, -100,
-101, -101, -101, -101, -102, -102, -102, -101, -102, -102, -103, -103, -104,
-104, -104, -104, -105, -105, -105, -106, -106, -106, -106, -106, -107, -107,
-108, -107, -107, -109, -107, -108, -108, -108, -109, -108, -108, -108, -108,
-109, -108, -108, -108, -108, -107, -108, -106, -107, -105, -105, -106, -105,
-104, -103, -102, -102, -100, -101, -99, -98, -97, -96, -94, -93, -93, -90, -88,
-87, -84, -83, -79, -78, -75, -72, -69, -66, -62, -59, -55, -51, -48, -44, -40,
-36, -32, -28, -23, -19, -15, -11, -6, -2, };