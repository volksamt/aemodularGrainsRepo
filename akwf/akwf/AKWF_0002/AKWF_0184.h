#define DATA_LENGTH 512
#define DATA AKWF_0184

const PROGMEM int8_t DATA[DATA_LENGTH] = {34, 41, 38, 41, 39, 40, 39, 41, 38,
41, 39, 40, 40, 40, 39, 40, 40, 39, 82, 69, 35, 42, 38, 40, 39, 40, 40, 39, 40,
41, 40, 39, 40, 40, 40, 39, 40, 39, 40, 39, 40, 39, 39, 39, 39, 39, 41, 40, 41,
39, 40, 40, 41, 40, 39, 40, 39, 40, 39, 40, 39, 40, 39, 40, 39, 41, 38, 41, 38,
43, 34, -1, 0, 1, -1, 3, -7, -41, -40, -39, -41, -37, -43, -34, -60, -83, -78,
-80, -79, -79, -80, -79, -79, -79, -81, -79, -81, -78, -80, -78, -80, -79, -80,
-80, -46, -37, -42, -37, -42, -38, -6, 4, -2, 3, -3, 3, -4, 9, 42, 39, 41, 40,
40, 40, 39, 40, 39, 39, 39, 40, 40, 40, 38, 74, 82, 78, 81, 78, 80, 79, 79, 79,
80, 79, 80, 79, 80, 79, 79, 78, 79, 80, 80, 79, 79, 79, 80, 79, 80, 79, 79, 80,
79, 79, 79, 80, 80, 80, 79, 80, 79, 80, 80, 79, 79, 80, 79, 79, 79, 80, 79, 79,
79, 80, 79, 80, 80, 80, 79, 80, 79, 79, 80, 79, 79, 79, 79, 80, 79, 80, 80, 79,
79, 80, 79, 79, 80, 80, 79, 79, 79, 79, 79, 79, 79, 80, 80, 79, 79, 79, 79, 79,
79, 79, 79, 79, 80, 80, 79, 80, 79, 80, 79, 79, 80, 79, 79, 80, 79, 79, 80, 79,
79, 80, 80, 80, 79, 79, 79, 79, 79, 79, 79, 79, 79, 80, 79, 80, 80, 80, 79, 79,
80, 79, 80, 79, 79, 79, 80, 80, 79, 80, 80, 80, 79, 79, 79, 80, 80, 80, 79, 80,
79, 80, 80, 79, 79, 80, 79, 80, 79, 79, 79, 79, 80, 80, 80, 80, 79, 79, 79, 80,
79, 79, 79, 79, 80, 79, 79, 80, 80, 78, 81, 77, 83, 66, 36, 42, 39, 41, 40, 38,
44, 14, -4, 2, -1, -1, 2, -26, -45, -37, -42, -38, -41, -38, -42, -77, -81, -78,
-80, -77, -81, -78, -81, -78, -81, -77, -81, -74, -94, -124, -117, -120, -119,
-120, -119, -119, -119, -119, -120, -120, -120, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -120, -118, -119, -120, -120, -119, -119,
-119, -119, -118, -119, -119, -119, -119, -119, -120, -118, -119, -118, -119,
-119, -119, -120, -119, -120, -119, -120, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -118, -119, -120, -119, -119, -120, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -118, -119,
-119, -119, -119, -118, -119, -119, -119, -118, -119, -119, -119, -119, -120,
-120, -119, -118, -120, -120, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -118, -119, -120, -119, -119,
-119, -119, -119, -120, -119, -118, -119, -119, -120, -119, -120, -118, -119,
-119, -120, -119, -120, -119, -121, -117, -121, -116, -124, -105, -75, -81, -80,
-77, -38, -41, -39, -40, -39, -2, 0, 0, 1, 0, 0, 0, };