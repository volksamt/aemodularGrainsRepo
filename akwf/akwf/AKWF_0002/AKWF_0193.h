#define DATA_LENGTH 512
#define DATA AKWF_0193

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 8, 9, 11, 13, 15, 17, 19, 21,
23, 24, 26, 28, 30, 32, 34, 36, 37, 39, 41, 41, 43, 45, 46, 48, 49, 51, 51, 53,
54, 55, 56, 57, 59, 60, 60, 60, 63, 63, 65, 65, 66, 67, 68, 69, 69, 70, 70, 71,
71, 72, 73, 74, 74, 90, 96, 90, 90, 90, 92, 93, 95, 96, 97, 98, 100, 100, 101,
102, 103, 104, 105, 105, 105, 107, 108, 108, 108, 109, 109, 110, 112, 111, 111,
112, 112, 114, 113, 113, 113, 114, 114, 114, 115, 115, 114, 115, 116, 116, 115,
116, 116, 116, 117, 116, 117, 117, 118, 117, 118, 117, 118, 118, 117, 118, 119,
117, 119, 118, 118, 119, 118, 118, 118, 119, 118, 119, 118, 118, 119, 119, 119,
119, 119, 119, 119, 118, 119, 118, 119, 119, 119, 118, 118, 118, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 118, 118, 118,
118, 120, 119, 120, 119, 119, 120, 119, 119, 119, 119, 118, 118, 119, 119, 120,
119, 119, 119, 119, 119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 118, 119,
119, 118, 117, 116, 114, 114, 114, 113, 111, 111, 110, 108, 107, 106, 104, 103,
102, 100, 99, 98, 97, 96, 94, 91, 90, 89, 88, 87, 84, 81, 78, 77, 75, 73, 72,
69, 68, 65, 63, 60, 57, 56, 54, 51, 48, 46, 42, 40, 36, 31, 28, 26, 24, 21, 19,
17, 13, 11, 9, 7, 4, 2, -1, -3, -5, -7, -9, -11, -13, -20, -41, -56, -53, -49,
-52, -54, -59, -61, -64, -67, -70, -73, -75, -77, -80, -81, -83, -85, -87, -89,
-90, -92, -93, -95, -96, -97, -99, -100, -100, -101, -103, -103, -105, -105,
-106, -106, -107, -107, -107, -108, -109, -110, -110, -111, -111, -111, -112,
-113, -112, -113, -113, -114, -113, -114, -114, -115, -115, -115, -115, -116,
-116, -116, -116, -116, -116, -116, -117, -117, -117, -118, -117, -117, -118,
-118, -118, -118, -118, -117, -118, -117, -118, -118, -118, -117, -118, -118,
-117, -119, -118, -118, -118, -119, -119, -119, -118, -119, -118, -119, -119,
-118, -119, -119, -119, -118, -119, -118, -119, -119, -119, -118, -119, -119,
-118, -119, -120, -118, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -120, -119, -119, -118, -118, -119, -120, -119, -119, -118,
-120, -119, -120, -120, -118, -119, -119, -119, -119, -119, -118, -119, -119,
-118, -118, -116, -115, -116, -114, -113, -113, -112, -111, -110, -109, -108,
-107, -106, -104, -103, -102, -100, -99, -98, -97, -96, -94, -93, -93, -90, -89,
-87, -87, -85, -85, -83, -82, -80, -79, -77, -76, -74, -73, -71, -70, -69, -66,
-65, -64, -63, -61, -60, -58, -57, -55, -53, -52, -50, -49, -47, -46, -45, -43,
-41, -39, -38, -36, -34, -32, -30, -28, -23, -21, -19, -18, -16, -13, -13, -10,
-8, -6, -4, -3, 0, };