#define DATA_LENGTH 512
#define DATA AKWF_0191

const PROGMEM int8_t DATA[DATA_LENGTH] = {-35, -41, -38, -41, -39, -41, -39,
-41, -39, -40, -39, -40, -39, -40, -39, -40, -39, -40, -40, -40, -39, -40, -40,
-39, -39, -40, -39, -40, -40, -40, -40, -39, -39, -40, -40, -39, -41, -40, -40,
-39, -40, -40, -40, -40, -39, -39, -39, -40, -39, -40, -40, -40, -40, -40, -39,
-40, -39, -40, -40, -40, -40, -40, -39, -39, -39, -40, -40, -40, -40, -40, -40,
-40, -40, -40, -39, -39, -39, -40, -39, -40, -39, -40, -40, -40, -39, -40, -39,
-39, -40, -40, -40, -39, -40, -40, -39, -39, -39, -40, -39, -40, -40, -40, -39,
-40, -40, -40, -39, -40, -39, -40, -40, -40, -40, -39, -39, -41, -39, -40, -40,
-40, -39, -39, -39, -41, -40, -40, -40, -39, -39, -40, -40, -39, -40, -40, -39,
-38, -41, -39, -41, -38, -41, -38, -41, -38, -42, -36, -48, -81, -79, -80, -79,
-116, -120, -118, -120, -118, -119, -118, -120, -119, -120, -118, -120, -118,
-120, -118, -119, -118, -120, -118, -119, -119, -120, -118, -120, -119, -119,
-119, -120, -119, -120, -118, -119, -118, -120, -118, -82, -79, -79, -78, -80,
-79, -80, -80, -80, -79, -80, -79, -80, -79, -80, -79, -80, -79, -81, -79, -80,
-78, -81, -76, -85, -64, -36, -42, -39, -40, -39, -40, -40, -40, -40, -39, -40,
-40, -39, -40, -40, -39, -39, -39, -40, -40, -40, -40, -40, -40, -39, -40, -39,
-40, -39, -41, -38, -42, -35, 1, 0, 0, 1, 0, 0, -1, 0, 0, 1, 0, 1, 0, 1, 0, 1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, -1, 1, 0, 0, -1, 0, 0, 0, 0, -2, 33, 42, 38, 41, 39, 40, 38, 40, 39,
40, 38, 40, 39, 39, 40, 40, 40, 39, 40, 40, 39, 39, 40, 39, 40, 39, 39, 39, 40,
40, 39, 39, 40, 40, 40, 39, 40, 39, 40, 40, 40, 40, 40, 39, 39, 40, 40, 39, 39,
39, 39, 40, 39, 39, 39, 39, 39, 40, 40, 39, 40, 40, 40, 40, 39, 40, 39, 40, 39,
40, 41, 40, 40, 40, 40, 40, 40, 40, 40, 40, 39, 40, 40, 39, 39, 39, 40, 40, 39,
40, 39, 40, 38, 41, 36, 44, 21, -5, 3, -2, 2, 0, 1, -1, 0, 0, 0, -1, 0, 1, -1,
1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0,
0, 0, 1, 0, 1, -1, 0, -1, 0, 0, -1, 1, 1, 0, 0, -1, 0, 0, 0, 0, -1, 1, 0, 0, -1,
0, 0, -1, 0, 1, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, 1, 0, 0, 0, 0, 0, 1, 0,
1, -1, 0, 0, 0, -1, 0, 1, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, -1, };