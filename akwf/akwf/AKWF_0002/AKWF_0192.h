#define DATA_LENGTH 512
#define DATA AKWF_0192

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 2, 3, 3, 4, 4, 5, 10, 19, 24,
28, 31, 34, 36, 38, 40, 42, 46, 49, 51, 51, 52, 53, 54, 54, 55, 56, 56, 56, 56,
56, 57, 57, 58, 58, 58, 57, 58, 58, 59, 58, 58, 58, 59, 59, 59, 59, 59, 61, 64,
66, 67, 69, 69, 70, 70, 71, 72, 72, 73, 74, 74, 75, 76, 76, 77, 78, 77, 78, 78,
79, 78, 79, 79, 79, 79, 80, 80, 80, 80, 79, 78, 79, 79, 79, 78, 78, 78, 77, 78,
77, 77, 76, 76, 76, 76, 75, 75, 74, 75, 75, 74, 74, 76, 78, 80, 80, 80, 80, 81,
81, 81, 82, 83, 83, 84, 84, 86, 85, 86, 86, 86, 86, 86, 86, 86, 86, 86, 86, 86,
86, 86, 86, 85, 85, 84, 84, 83, 83, 82, 82, 82, 82, 82, 81, 81, 80, 80, 79, 79,
79, 79, 78, 78, 77, 76, 75, 75, 74, 74, 74, 73, 73, 72, 73, 74, 75, 75, 75, 75,
75, 75, 75, 75, 76, 75, 75, 75, 75, 75, 74, 75, 75, 74, 75, 74, 74, 74, 75, 74,
73, 73, 73, 73, 72, 72, 72, 72, 71, 70, 70, 70, 69, 69, 69, 68, 67, 67, 67, 66,
66, 65, 65, 64, 63, 64, 63, 63, 63, 62, 62, 62, 61, 61, 60, 59, 60, 59, 58, 58,
57, 57, 57, 56, 56, 55, 55, 54, 55, 54, 54, 53, 53, 52, 52, 51, 50, 50, 48, 47,
45, 44, 42, 41, 40, 38, 37, 36, 34, 33, 32, 30, 29, 28, 28, 26, 25, 24, 22, 22,
21, 20, 18, 18, 17, 16, 14, 14, 13, 12, 10, 10, 8, 8, 7, 7, 5, 5, 4, 3, 1, 2, 1,
-1, -1, -2, -3, -4, -4, -5, -6, -7, -8, -8, -9, -9, -10, -10, -11, -11, -13,
-13, -31, -58, -65, -72, -75, -78, -79, -81, -84, -86, -88, -92, -94, -97, -100,
-102, -104, -106, -108, -110, -112, -112, -114, -114, -116, -117, -118, -117,
-118, -119, -118, -119, -119, -119, -119, -119, -118, -119, -118, -118, -118,
-116, -117, -116, -116, -115, -114, -114, -113, -112, -111, -111, -109, -109,
-108, -108, -106, -106, -105, -105, -104, -103, -102, -101, -101, -99, -99, -97,
-98, -96, -96, -95, -93, -93, -92, -91, -90, -91, -90, -88, -88, -87, -85, -86,
-84, -84, -83, -83, -82, -81, -81, -80, -79, -79, -78, -78, -77, -76, -76, -75,
-75, -74, -73, -72, -72, -72, -72, -71, -70, -70, -70, -68, -68, -68, -67, -66,
-66, -66, -65, -64, -64, -63, -64, -63, -63, -61, -62, -62, -61, -60, -60, -61,
-59, -59, -59, -58, -58, -58, -58, -56, -55, -55, -55, -53, -53, -53, -53, -52,
-51, -51, -48, -47, -45, -43, -42, -40, -38, -38, -35, -34, -33, -31, -30, -29,
-28, -27, -25, -24, -23, -22, -22, -21, -20, -19, -17, -16, -16, -15, -13, -13,
-12, -11, -11, -11, -9, -8, -7, -7, -6, -6, -5, -4, -4, -3, -2, -2, -1, 0, };