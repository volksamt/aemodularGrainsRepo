#define DATA_LENGTH 512
#define DATA AKWF_0152

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 8, 9, 11, 12, 13, 14, 15,
17, 19, 21, 22, 23, 24, 26, 27, 29, 30, 31, 32, 33, 35, 36, 37, 39, 40, 42, 42,
43, 44, 45, 46, 47, 49, 49, 50, 51, 52, 54, 54, 55, 56, 57, 58, 59, 60, 61, 61,
62, 63, 65, 65, 66, 67, 67, 67, 69, 69, 70, 70, 72, 72, 72, 74, 75, 75, 75, 76,
77, 78, 78, 79, 80, 80, 81, 81, 81, 83, 83, 83, 84, 84, 85, 86, 87, 86, 87, 89,
89, 89, 89, 90, 90, 90, 91, 92, 92, 93, 93, 93, 94, 94, 96, 96, 97, 96, 97, 97,
98, 99, 98, 99, 99, 100, 100, 100, 101, 101, 102, 102, 102, 104, 104, 104, 103,
105, 105, 105, 105, 105, 105, 106, 107, 107, 108, 107, 108, 108, 108, 108, 108,
109, 110, 109, 110, 111, 111, 111, 112, 112, 112, 113, 112, 113, 112, 113, 113,
114, 114, 115, 115, 115, 115, 115, 116, 116, 116, 117, 116, 117, 116, 117, 117,
118, 118, 118, 118, 118, 119, 119, 117, 104, 92, 93, 92, 90, 85, 85, 89, 89, 83,
75, 74, 73, 66, 60, 57, 54, 50, 46, 42, 38, 35, 31, 29, 26, 24, 22, 20, 17, 14,
12, 10, 7, 5, 2, -1, -2, -6, -7, -10, -12, -14, -16, -18, -20, -23, -25, -27,
-27, -30, -32, -33, -35, -37, -38, -41, -42, -44, -45, -46, -49, -50, -52, -53,
-53, -56, -57, -58, -60, -60, -61, -63, -63, -65, -66, -67, -68, -69, -71, -70,
-72, -72, -73, -74, -74, -75, -76, -77, -77, -78, -79, -80, -80, -81, -81, -82,
-82, -82, -84, -84, -85, -85, -85, -85, -87, -87, -87, -87, -88, -89, -89, -90,
-89, -90, -90, -91, -91, -91, -91, -93, -92, -93, -93, -93, -93, -93, -94, -94,
-94, -95, -94, -95, -95, -95, -96, -96, -96, -96, -96, -97, -97, -97, -97, -97,
-98, -98, -98, -98, -99, -98, -99, -99, -99, -100, -99, -100, -99, -99, -100,
-100, -101, -101, -100, -101, -100, -100, -101, -100, -100, -101, -101, -102,
-101, -101, -102, -102, -102, -101, -101, -102, -101, -102, -102, -102, -102,
-102, -102, -102, -102, -102, -101, -102, -102, -102, -101, -102, -103, -102,
-103, -101, -102, -101, -102, -102, -101, -102, -102, -102, -102, -101, -101,
-102, -100, -101, -100, -102, -101, -101, -100, -100, -100, -100, -100, -99,
-99, -99, -98, -99, -98, -99, -98, -98, -98, -97, -98, -97, -97, -96, -96, -96,
-96, -96, -95, -95, -95, -95, -94, -94, -93, -93, -93, -92, -91, -92, -91, -90,
-90, -90, -89, -88, -88, -87, -87, -87, -87, -86, -85, -84, -84, -82, -82, -81,
-81, -79, -78, -79, -78, -76, -76, -76, -74, -73, -72, -70, -70, -69, -68, -66,
-65, -64, -62, -61, -59, -58, -56, -54, -53, -50, -50, -48, -45, -44, -42, -41,
-38, -38, -35, -33, -31, -30, -28, -27, -25, -23, -21, -20, -18, -16, -14, -13,
-11, -10, -8, -6, -5, -3, -1, 0, };