#define DATA_LENGTH 512
#define DATA AKWF_0196

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 8, 11, 13, 16, 17, 19, 22,
26, 34, 37, 36, 40, 43, 45, 49, 53, 56, 58, 63, 71, 73, 72, 75, 76, 79, 80, 83,
85, 87, 88, 91, 91, 93, 94, 96, 97, 98, 99, 101, 102, 102, 102, 105, 105, 105,
106, 107, 107, 108, 110, 110, 110, 111, 111, 111, 112, 112, 112, 113, 113, 113,
114, 115, 115, 115, 115, 115, 116, 117, 116, 116, 116, 117, 117, 117, 117, 118,
118, 117, 118, 118, 118, 118, 117, 118, 118, 119, 118, 118, 119, 118, 118, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 117, 117, 116, 116, 114,
114, 113, 113, 111, 111, 110, 108, 108, 108, 106, 105, 104, 103, 102, 101, 100,
99, 97, 97, 96, 94, 93, 93, 91, 90, 89, 88, 87, 86, 84, 83, 82, 81, 80, 79, 78,
78, 75, 75, 74, 72, 72, 70, 70, 68, 68, 66, 66, 65, 64, 63, 62, 61, 60, 59, 59,
58, 57, 57, 55, 54, 54, 52, 52, 51, 49, 50, 48, 47, 47, 45, 45, 44, 45, 43, 43,
41, 41, 41, 40, 39, 38, 37, 36, 36, 35, 34, 33, 33, 32, 31, 31, 30, 30, 29, 28,
27, 28, 26, 26, 25, 25, 24, 23, 23, 23, 21, 22, 16, 6, 6, 8, 5, 4, 1, -3, -5,
-8, -9, -11, -14, -17, -18, -20, -22, -25, -27, -29, -30, -33, -34, -36, -38,
-40, -41, -43, -44, -45, -46, -48, -49, -49, -50, -51, -53, -53, -53, -55, -54,
-55, -56, -57, -57, -57, -57, -59, -59, -60, -59, -60, -59, -59, -59, -59, -59,
-60, -59, -59, -59, -60, -59, -59, -59, -58, -58, -58, -58, -58, -57, -57, -56,
-57, -55, -56, -56, -55, -55, -54, -54, -54, -54, -54, -54, -52, -52, -52, -52,
-51, -51, -51, -50, -50, -50, -50, -50, -49, -49, -49, -47, -47, -47, -47, -47,
-46, -46, -46, -45, -45, -45, -45, -44, -44, -44, -43, -44, -43, -42, -42, -43,
-42, -42, -41, -41, -41, -40, -40, -40, -40, -44, -49, -47, -47, -47, -49, -51,
-52, -54, -58, -66, -66, -66, -68, -71, -74, -78, -81, -83, -84, -86, -87, -89,
-90, -92, -94, -95, -97, -97, -98, -99, -101, -101, -102, -103, -104, -105,
-106, -106, -107, -108, -108, -109, -109, -110, -110, -112, -112, -111, -113,
-113, -113, -114, -114, -114, -114, -115, -115, -115, -115, -115, -117, -116,
-116, -116, -117, -117, -118, -118, -118, -118, -117, -117, -117, -118, -118,
-117, -118, -118, -118, -118, -118, -119, -119, -118, -116, -115, -114, -114,
-114, -113, -112, -111, -110, -109, -108, -107, -106, -105, -103, -102, -101,
-100, -98, -98, -97, -95, -93, -92, -91, -89, -89, -87, -86, -84, -83, -81, -79,
-79, -77, -77, -75, -74, -72, -72, -70, -68, -68, -66, -65, -64, -63, -61, -60,
-59, -57, -57, -55, -54, -54, -52, -52, -50, -49, -47, -47, -46, -45, -40, -33,
-30, -31, -28, -25, -22, -18, -15, -12, -9, -7, -4, -1, };