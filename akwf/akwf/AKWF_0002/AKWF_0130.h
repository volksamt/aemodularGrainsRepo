#define DATA_LENGTH 512
#define DATA AKWF_0130

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 6, 9, 11, 10, 11, 12, 9, 10,
12, 12, 12, 13, 13, 17, 20, 22, 26, 28, 32, 38, 39, 45, 46, 47, 49, 51, 50, 51,
51, 50, 50, 50, 51, 53, 52, 52, 52, 56, 53, 55, 58, 57, 61, 59, 59, 62, 59, 57,
56, 55, 51, 51, 51, 47, 47, 47, 48, 48, 46, 51, 55, 55, 55, 59, 63, 62, 62, 65,
67, 64, 65, 69, 69, 68, 68, 71, 70, 71, 72, 71, 76, 77, 75, 79, 84, 86, 85, 88,
89, 90, 92, 90, 93, 94, 88, 89, 91, 85, 83, 80, 78, 74, 66, 61, 57, 51, 41, 33,
27, 22, 13, 5, 2, -5, -15, -19, -23, -27, -32, -38, -40, -42, -45, -49, -50,
-51, -57, -60, -58, -60, -65, -69, -71, -73, -79, -83, -86, -95, -98, -100,
-108, -108, -110, -115, -116, -117, -118, -115, -120, -118, -114, -113, -113,
-111, -108, -107, -105, -104, -103, -98, -98, -94, -92, -92, -90, -89, -85, -84,
-84, -77, -76, -75, -69, -64, -61, -55, -50, -47, -43, -40, -35, -33, -29, -26,
-26, -22, -21, -18, -15, -14, -9, -7, -6, -1, 2, 3, 4, 6, 9, 9, 9, 9, 11, 10,
10, 9, 7, 6, 8, 6, 3, 4, 2, 1, 1, -2, -1, -1, -3, -2, 0, -1, 1, 4, 7, 6, 8, 12,
12, 14, 13, 14, 14, 11, 11, 9, 8, 4, -1, -2, -5, -10, -12, -13, -17, -19, -18,
-19, -18, -21, -21, -17, -15, -14, -12, -9, -3, 0, 3, 6, 11, 15, 16, 20, 24, 27,
27, 30, 33, 34, 34, 36, 38, 38, 38, 41, 43, 41, 41, 47, 47, 45, 47, 49, 52, 56,
56, 56, 60, 62, 62, 63, 64, 66, 67, 66, 67, 68, 70, 71, 71, 71, 73, 75, 72, 72,
74, 72, 73, 74, 71, 71, 70, 70, 69, 65, 65, 65, 65, 62, 60, 58, 57, 59, 59, 53,
53, 57, 53, 52, 55, 50, 54, 52, 49, 50, 49, 47, 47, 42, 41, 41, 39, 34, 32, 28,
23, 21, 16, 12, 7, 0, -5, -7, -16, -21, -23, -29, -37, -39, -40, -45, -48, -51,
-53, -56, -59, -59, -60, -61, -62, -65, -64, -63, -67, -67, -64, -69, -67, -65,
-67, -64, -62, -64, -61, -57, -55, -52, -51, -47, -41, -38, -34, -32, -29, -24,
-23, -19, -15, -14, -14, -12, -9, -6, -8, -9, -5, -4, -4, -3, -2, 0, -4, -4, 0,
0, -5, -5, -7, -8, -13, -15, -17, -22, -27, -28, -31, -37, -38, -40, -40, -42,
-43, -41, -41, -42, -38, -38, -39, -37, -36, -32, -34, -33, -31, -29, -28, -27,
-27, -25, -24, -25, -26, -23, -22, -24, -24, -19, -20, -21, -20, -18, -18, -18,
-17, -16, -16, -19, -17, -15, -18, -21, -23, -24, -25, -29, -32, -33, -35, -41,
-44, -43, -45, -51, -51, -50, -50, -52, -54, -54, -52, -50, -52, -52, -49, -46,
-46, -44, -39, -39, -34, -28, -28, -23, -17, -16, -11, -6, -4, };