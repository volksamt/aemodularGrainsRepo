#define DATA_LENGTH 512
#define DATA AKWF_0157

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 8, 10, 12, 14, 15, 16, 18,
18, 21, 22, 24, 24, 27, 28, 29, 30, 32, 34, 35, 36, 37, 39, 40, 41, 43, 44, 45,
47, 48, 49, 50, 52, 53, 54, 54, 57, 57, 58, 59, 61, 62, 62, 64, 65, 66, 67, 67,
69, 69, 71, 72, 73, 74, 75, 76, 76, 77, 78, 79, 80, 81, 81, 83, 83, 83, 84, 85,
86, 87, 88, 88, 89, 90, 90, 91, 92, 92, 92, 94, 94, 94, 95, 96, 97, 97, 97, 98,
98, 99, 100, 100, 100, 100, 100, 102, 102, 103, 103, 103, 103, 104, 104, 104,
105, 106, 106, 107, 107, 106, 107, 108, 108, 108, 108, 109, 109, 109, 110, 111,
110, 110, 110, 111, 111, 111, 111, 111, 112, 112, 113, 113, 113, 112, 113, 113,
114, 114, 114, 114, 114, 114, 114, 114, 114, 115, 115, 115, 115, 114, 115, 116,
115, 116, 115, 116, 116, 117, 116, 116, 116, 117, 117, 117, 117, 117, 117, 117,
117, 117, 117, 117, 118, 117, 118, 118, 118, 118, 119, 119, 118, 118, 118, 119,
118, 119, 118, 118, 119, 118, 118, 119, 118, 118, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 115, 110, 106, 103, 101,
99, 96, 92, 90, 87, 83, 80, 76, 73, 69, 65, 63, 60, 56, 53, 49, 47, 44, 41, 38,
35, 34, 30, 28, 26, 23, 20, 18, 17, 14, 13, 9, 7, 7, 5, 2, 0, -1, -3, -5, -6,
-8, -9, -11, -13, -14, -16, -17, -19, -20, -22, -24, -26, -26, -28, -29, -30,
-32, -34, -35, -36, -37, -39, -41, -41, -43, -44, -46, -47, -49, -50, -50, -51,
-53, -54, -55, -55, -56, -58, -60, -61, -62, -63, -64, -65, -66, -67, -68, -70,
-71, -70, -72, -73, -73, -75, -75, -76, -77, -78, -80, -81, -81, -82, -83, -84,
-84, -85, -86, -87, -87, -87, -89, -90, -89, -90, -92, -91, -92, -93, -93, -94,
-94, -95, -96, -97, -97, -98, -98, -99, -99, -100, -100, -101, -101, -102, -102,
-103, -102, -103, -104, -104, -105, -105, -105, -105, -106, -106, -106, -107,
-107, -107, -108, -108, -108, -108, -109, -109, -109, -109, -110, -111, -110,
-110, -111, -112, -111, -112, -112, -112, -113, -112, -112, -112, -113, -113,
-113, -113, -114, -114, -114, -114, -114, -114, -115, -115, -114, -115, -115,
-115, -115, -116, -115, -116, -116, -115, -115, -116, -116, -116, -116, -116,
-116, -116, -117, -116, -117, -116, -117, -116, -118, -117, -117, -118, -117,
-118, -117, -118, -118, -117, -117, -118, -118, -117, -118, -119, -118, -118,
-118, -118, -118, -119, -118, -118, -119, -118, -118, -119, -119, -119, -118,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -118, -118, -115, -110,
-106, -103, -100, -98, -95, -92, -89, -86, -83, -79, -76, -72, -69, -66, -62,
-59, -56, -52, -50, -47, -44, -41, -38, -36, -33, -30, -28, -25, -23, -20, -18,
-16, -14, -12, -10, -8, -6, -4, -3, 0, };