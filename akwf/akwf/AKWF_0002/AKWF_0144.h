#define DATA_LENGTH 512
#define DATA AKWF_0144

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 5, 6, 8, 8, 10, 10, 12,
12, 14, 14, 16, 17, 18, 19, 20, 21, 21, 23, 24, 24, 25, 25, 26, 28, 29, 29, 30,
31, 32, 33, 32, 33, 34, 35, 34, 36, 36, 37, 38, 37, 39, 39, 39, 40, 40, 41, 41,
42, 43, 43, 43, 44, 44, 45, 44, 45, 45, 46, 46, 46, 47, 47, 47, 48, 48, 48, 48,
49, 48, 49, 50, 49, 51, 50, 50, 50, 51, 51, 51, 51, 52, 52, 53, 52, 54, 54, 54,
54, 54, 55, 56, 56, 56, 56, 56, 57, 58, 57, 59, 59, 59, 59, 60, 60, 61, 61, 62,
62, 63, 64, 64, 64, 65, 65, 65, 66, 67, 67, 67, 68, 68, 69, 69, 70, 70, 71, 71,
71, 72, 72, 73, 73, 74, 75, 74, 75, 75, 76, 76, 76, 77, 78, 78, 78, 79, 80, 80,
81, 83, 86, 88, 89, 90, 90, 91, 92, 93, 95, 95, 96, 98, 99, 100, 100, 101, 101,
102, 103, 103, 104, 103, 104, 104, 104, 104, 104, 103, 103, 102, 102, 101, 100,
99, 99, 98, 97, 97, 95, 94, 93, 92, 91, 89, 88, 87, 86, 83, 82, 82, 80, 78, 77,
75, 74, 71, 71, 69, 68, 66, 65, 63, 61, 59, 58, 56, 54, 52, 51, 49, 48, 47, 45,
44, 41, 40, 38, 37, 35, 34, 32, 31, 29, 27, 26, 25, 23, 22, 20, 18, 17, 15, 15,
13, 12, 10, 8, 7, 5, 4, 3, 2, 1, -1, -2, -4, -4, -5, -6, -8, -8, -10, -11, -12,
-14, -14, -16, -16, -17, -19, -19, -21, -20, -23, -22, -24, -24, -25, -26, -27,
-28, -29, -29, -30, -31, -32, -32, -33, -34, -33, -34, -36, -36, -36, -37, -37,
-38, -39, -40, -40, -40, -41, -42, -42, -42, -43, -42, -43, -44, -44, -44, -44,
-44, -46, -45, -45, -46, -47, -47, -47, -47, -48, -47, -48, -48, -49, -49, -50,
-50, -49, -49, -51, -51, -50, -51, -52, -52, -52, -52, -53, -54, -53, -53, -55,
-54, -55, -55, -56, -56, -56, -56, -57, -57, -57, -59, -59, -59, -60, -60, -60,
-61, -61, -62, -62, -62, -63, -63, -63, -64, -65, -65, -66, -65, -67, -67, -68,
-68, -69, -68, -70, -70, -71, -70, -71, -72, -71, -72, -73, -73, -74, -74, -74,
-74, -76, -76, -76, -77, -77, -77, -78, -78, -79, -80, -81, -81, -83, -85, -88,
-88, -89, -90, -92, -92, -94, -95, -96, -97, -98, -98, -99, -100, -102, -102,
-102, -103, -104, -103, -105, -103, -104, -104, -104, -103, -103, -102, -102,
-102, -100, -101, -99, -98, -98, -97, -96, -95, -94, -93, -92, -89, -89, -88,
-86, -85, -84, -82, -81, -79, -77, -76, -75, -74, -72, -70, -68, -67, -66, -65,
-62, -61, -59, -58, -56, -54, -53, -51, -49, -48, -47, -45, -42, -41, -39, -38,
-37, -35, -34, -32, -30, -28, -28, -25, -24, -22, -22, -20, -19, -18, -16, -14,
-14, -10, -10, -9, -7, -6, -4, -4, -3, -1, };