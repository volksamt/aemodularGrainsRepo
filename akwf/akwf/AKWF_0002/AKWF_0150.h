#define DATA_LENGTH 512
#define DATA AKWF_0150

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 7, 9, 12, 15, 16, 18, 19, 20,
22, 23, 25, 26, 27, 28, 30, 31, 32, 34, 35, 37, 38, 38, 40, 42, 43, 44, 44, 46,
46, 47, 49, 50, 51, 52, 53, 54, 55, 57, 57, 58, 60, 60, 62, 63, 63, 65, 66, 66,
67, 67, 67, 68, 68, 69, 69, 69, 69, 69, 70, 70, 71, 72, 72, 73, 73, 74, 75, 76,
77, 77, 78, 79, 80, 82, 83, 84, 85, 86, 89, 90, 92, 93, 93, 95, 96, 97, 98, 100,
102, 104, 105, 106, 107, 107, 109, 109, 110, 112, 112, 113, 114, 114, 116, 117,
117, 117, 118, 119, 120, 119, 119, 116, 114, 112, 110, 107, 104, 101, 97, 93,
89, 84, 79, 75, 70, 66, 62, 57, 54, 50, 47, 44, 41, 38, 35, 34, 31, 29, 26, 25,
24, 23, 21, 20, 19, 18, 18, 17, 18, 18, 17, 16, 17, 17, 18, 19, 20, 20, 21, 22,
23, 23, 25, 26, 26, 27, 28, 30, 31, 33, 34, 35, 37, 37, 37, 39, 39, 40, 39, 41,
41, 41, 42, 42, 41, 41, 41, 41, 41, 41, 41, 41, 40, 41, 41, 41, 41, 41, 40, 41,
41, 40, 40, 41, 41, 40, 41, 40, 41, 41, 41, 42, 42, 43, 43, 43, 44, 44, 45, 46,
47, 48, 48, 48, 48, 49, 48, 49, 49, 49, 47, 47, 47, 46, 44, 43, 42, 41, 40, 39,
38, 36, 32, 28, 24, 20, 15, 10, 4, -2, -8, -13, -20, -25, -30, -35, -38, -42,
-44, -47, -49, -51, -52, -53, -54, -56, -56, -55, -56, -56, -56, -56, -56, -56,
-55, -56, -56, -55, -54, -54, -54, -53, -53, -53, -52, -51, -52, -51, -51, -50,
-51, -49, -48, -49, -48, -48, -48, -47, -46, -46, -45, -45, -45, -45, -45, -44,
-44, -44, -46, -45, -46, -45, -45, -46, -46, -46, -46, -45, -45, -45, -45, -44,
-44, -43, -42, -41, -42, -40, -40, -38, -37, -36, -35, -33, -33, -32, -31, -29,
-28, -26, -24, -24, -22, -21, -20, -19, -18, -16, -16, -14, -13, -12, -10, -10,
-9, -8, -7, -7, -4, -4, -4, -2, -2, 0, -1, -2, -3, -4, -7, -11, -14, -17, -22,
-25, -30, -33, -39, -43, -48, -52, -56, -62, -66, -70, -74, -77, -81, -84, -86,
-88, -92, -93, -96, -97, -99, -100, -101, -104, -104, -105, -106, -106, -107,
-106, -106, -107, -107, -106, -106, -105, -106, -105, -104, -104, -102, -101,
-101, -99, -98, -97, -96, -95, -93, -93, -92, -91, -90, -88, -87, -86, -84, -83,
-84, -81, -81, -81, -81, -79, -79, -79, -79, -79, -79, -79, -78, -78, -78, -77,
-78, -77, -77, -76, -76, -76, -76, -74, -75, -75, -74, -73, -73, -73, -72, -72,
-72, -72, -71, -70, -69, -67, -67, -65, -65, -63, -62, -61, -60, -58, -56, -55,
-53, -51, -49, -47, -46, -43, -41, -38, -36, -34, -32, -29, -27, -25, -23, -22,
-22, -21, -21, -22, -22, -21, -20, -19, -16, -14, -11, -7, -4, -1, };