#define DATA_LENGTH 512
#define DATA AKWF_0122

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 14, 17, 19, 24, 26, 28, 32,
34, 37, 39, 40, 44, 45, 48, 49, 51, 53, 54, 56, 57, 59, 60, 62, 62, 63, 65, 66,
67, 68, 68, 69, 70, 71, 71, 73, 73, 74, 73, 74, 75, 75, 76, 76, 78, 78, 77, 78,
78, 78, 78, 78, 78, 78, 79, 78, 79, 79, 79, 78, 78, 79, 77, 77, 77, 78, 77, 77,
77, 77, 76, 76, 75, 74, 75, 74, 74, 73, 73, 73, 72, 71, 72, 71, 70, 70, 69, 68,
69, 68, 67, 67, 65, 65, 64, 63, 63, 63, 62, 61, 61, 60, 60, 59, 59, 58, 57, 57,
56, 56, 54, 55, 55, 53, 53, 54, 54, 54, 54, 54, 54, 54, 55, 55, 57, 56, 58, 58,
59, 59, 60, 61, 62, 62, 63, 63, 65, 65, 66, 66, 67, 67, 68, 69, 71, 72, 72, 75,
76, 77, 78, 79, 82, 82, 85, 86, 88, 89, 91, 92, 94, 96, 97, 98, 100, 101, 103,
104, 105, 107, 107, 109, 110, 110, 112, 113, 114, 115, 115, 116, 116, 117, 117,
118, 118, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119, 118, 118, 118,
118, 117, 116, 117, 115, 115, 116, 115, 114, 112, 112, 112, 111, 111, 109, 109,
108, 107, 106, 105, 104, 102, 102, 100, 98, 97, 96, 94, 93, 91, 88, 86, 85, 82,
80, 79, 76, 74, 71, 68, 66, 64, 61, 58, 54, 49, 40, 32, 28, 25, 21, 18, 15, 10,
7, 3, -2, -6, -10, -13, -16, -21, -23, -26, -29, -32, -34, -38, -40, -41, -44,
-46, -48, -50, -52, -54, -56, -57, -59, -60, -61, -62, -64, -64, -66, -67, -68,
-70, -71, -71, -72, -73, -73, -75, -74, -75, -76, -77, -77, -77, -78, -77, -78,
-79, -79, -78, -80, -80, -80, -80, -80, -80, -80, -80, -80, -80, -79, -80, -80,
-79, -80, -79, -79, -78, -79, -78, -78, -77, -78, -77, -77, -76, -75, -75, -75,
-74, -74, -73, -73, -72, -72, -71, -71, -70, -70, -69, -68, -68, -67, -67, -66,
-65, -65, -64, -63, -64, -62, -62, -61, -61, -60, -59, -59, -58, -58, -56, -56,
-56, -55, -55, -55, -54, -55, -55, -55, -55, -56, -57, -56, -57, -57, -58, -58,
-59, -59, -61, -61, -62, -63, -64, -63, -64, -65, -67, -67, -67, -67, -69, -70,
-71, -71, -73, -74, -75, -77, -78, -79, -82, -83, -83, -86, -87, -89, -90, -92,
-93, -95, -96, -97, -98, -100, -101, -103, -104, -105, -106, -107, -109, -110,
-110, -111, -112, -112, -113, -114, -115, -115, -116, -116, -116, -117, -118,
-117, -117, -117, -118, -117, -117, -117, -118, -118, -118, -117, -116, -116,
-116, -116, -115, -115, -114, -113, -114, -112, -111, -112, -111, -110, -110,
-110, -108, -107, -107, -105, -104, -103, -102, -101, -100, -98, -97, -95, -93,
-93, -90, -89, -87, -84, -83, -80, -78, -76, -75, -71, -69, -66, -64, -61, -58,
-56, -51, -46, -38, -30, -26, -24, -20, -17, -14, -9, -5, -1, };