#define DATA_LENGTH 512
#define DATA AKWF_0134

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 15, 19, 23, 29, 32, 37, 41, 46,
50, 54, 58, 62, 66, 69, 73, 76, 80, 82, 85, 88, 91, 94, 96, 98, 99, 102, 103,
105, 107, 108, 109, 109, 111, 112, 112, 113, 113, 113, 112, 113, 113, 113, 112,
112, 112, 111, 110, 109, 108, 107, 106, 105, 104, 103, 101, 100, 98, 96, 95, 93,
91, 89, 88, 86, 84, 82, 80, 78, 75, 73, 71, 69, 66, 64, 62, 59, 58, 55, 53, 51,
47, 46, 43, 41, 39, 37, 34, 32, 30, 28, 26, 23, 20, 18, 16, 14, 12, 10, 8, 6, 5,
2, 0, -2, -4, -6, -7, -9, -10, -13, -13, -15, -16, -18, -21, -21, -23, -24, -25,
-26, -27, -28, -30, -31, -32, -33, -33, -35, -35, -36, -37, -37, -38, -38, -38,
-40, -40, -40, -41, -41, -41, -41, -42, -42, -42, -43, -42, -42, -42, -42, -42,
-41, -41, -42, -41, -39, -38, -36, -34, -32, -29, -27, -25, -22, -20, -19, -16,
-14, -11, -9, -5, -1, 3, 8, 13, 17, 21, 25, 28, 32, 36, 39, 42, 46, 49, 53, 55,
58, 62, 65, 68, 71, 74, 77, 79, 83, 84, 88, 91, 92, 94, 95, 98, 100, 100, 102,
103, 103, 102, 100, 96, 90, 84, 76, 69, 63, 57, 53, 48, 44, 41, 37, 33, 29, 25,
20, 14, 9, 4, -1, -6, -11, -17, -22, -26, -31, -36, -40, -45, -48, -53, -57,
-60, -65, -68, -70, -73, -77, -80, -82, -84, -87, -90, -92, -94, -95, -97, -98,
-100, -101, -102, -104, -105, -105, -106, -106, -107, -107, -106, -107, -107,
-106, -106, -106, -106, -105, -105, -104, -103, -102, -102, -100, -99, -97, -97,
-95, -93, -92, -90, -89, -88, -85, -83, -81, -80, -78, -77, -74, -73, -71, -69,
-66, -63, -62, -59, -58, -54, -53, -51, -48, -46, -43, -41, -39, -37, -35, -33,
-31, -29, -26, -25, -22, -20, -18, -16, -14, -13, -10, -9, -7, -4, -3, -1, 2, 2,
5, 6, 8, 10, 10, 12, 13, 16, 17, 18, 20, 21, 22, 24, 25, 26, 27, 27, 28, 30, 30,
31, 32, 33, 34, 34, 35, 36, 36, 37, 37, 38, 38, 39, 40, 38, 40, 39, 40, 39, 40,
40, 39, 40, 41, 41, 40, 40, 39, 39, 39, 40, 39, 38, 38, 38, 38, 37, 37, 36, 35,
36, 35, 35, 33, 33, 32, 32, 31, 31, 31, 29, 28, 28, 27, 27, 26, 26, 25, 24, 24,
23, 22, 20, 22, 20, 19, 19, 18, 17, 17, 16, 15, 15, 14, 13, 12, 11, 11, 10, 9,
9, 9, 8, 8, 6, 6, 5, 5, 4, 4, 3, 3, 1, -2, -6, -14, -25, -38, -49, -60, -68,
-75, -80, -84, -87, -90, -92, -95, -98, -100, -104, -107, -109, -112, -114,
-115, -118, -118, -118, -118, -119, -119, -118, -117, -117, -114, -113, -110,
-109, -106, -103, -101, -98, -94, -90, -87, -83, -78, -75, -70, -66, -62, -57,
-53, -47, -44, -39, -34, -28, -23, -18, -12, -6, -1, };