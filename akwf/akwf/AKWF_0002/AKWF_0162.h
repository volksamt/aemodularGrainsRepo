#define DATA_LENGTH 512
#define DATA AKWF_0162

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 3, 5, 6, 9, 9, 10, 12, 14, 16,
16, 18, 19, 21, 22, 23, 24, 26, 26, 27, 27, 27, 27, 27, 26, 24, 22, 20, 18, 15,
13, 11, 8, 7, 5, 3, 2, 0, -2, -3, -3, -5, -5, -5, -5, -5, -2, 1, 5, 9, 14, 20,
27, 32, 39, 46, 52, 58, 64, 69, 75, 80, 85, 90, 93, 97, 100, 104, 107, 108, 110,
113, 114, 115, 117, 117, 118, 120, 118, 119, 119, 119, 118, 118, 118, 117, 116,
115, 113, 113, 112, 111, 110, 108, 108, 106, 105, 103, 102, 101, 100, 98, 96,
96, 93, 92, 92, 90, 89, 87, 87, 85, 84, 82, 82, 80, 79, 78, 77, 76, 75, 74, 72,
72, 71, 69, 68, 68, 67, 66, 65, 65, 63, 63, 62, 61, 60, 59, 58, 57, 55, 54, 54,
53, 51, 50, 50, 48, 47, 45, 45, 44, 43, 43, 41, 39, 40, 38, 37, 36, 35, 34, 33,
32, 32, 30, 29, 29, 28, 26, 25, 25, 22, 20, 17, 13, 9, 4, -1, -6, -12, -18, -23,
-28, -33, -38, -41, -46, -49, -52, -55, -59, -62, -64, -66, -67, -69, -71, -72,
-73, -74, -75, -75, -75, -76, -75, -75, -76, -74, -74, -74, -73, -72, -71, -70,
-70, -69, -67, -66, -65, -64, -61, -61, -59, -57, -56, -55, -53, -52, -50, -49,
-47, -44, -43, -42, -39, -38, -35, -35, -32, -30, -29, -27, -26, -24, -23, -20,
-18, -16, -15, -14, -11, -11, -8, -6, -5, -4, -3, 0, 1, 3, 4, 6, 7, 9, 10, 11,
13, 15, 16, 18, 18, 19, 21, 22, 24, 25, 25, 27, 28, 29, 31, 32, 33, 34, 35, 35,
36, 36, 37, 37, 38, 37, 37, 38, 37, 38, 37, 37, 36, 34, 31, 26, 21, 16, 9, 2,
-6, -13, -21, -29, -36, -44, -51, -58, -64, -71, -76, -81, -86, -90, -94, -98,
-101, -103, -106, -109, -111, -112, -113, -115, -115, -117, -117, -116, -116,
-116, -116, -115, -115, -114, -112, -111, -108, -107, -106, -104, -103, -100,
-98, -96, -94, -91, -89, -87, -84, -82, -79, -77, -74, -72, -69, -67, -63, -62,
-59, -57, -54, -52, -48, -46, -43, -41, -39, -36, -34, -32, -29, -26, -24, -22,
-19, -17, -15, -13, -11, -9, -6, -5, -2, -1, 1, 3, 6, 7, 9, 11, 13, 14, 16, 16,
18, 20, 22, 23, 25, 26, 27, 29, 30, 31, 32, 33, 34, 36, 36, 37, 38, 39, 40, 40,
41, 40, 40, 40, 39, 39, 37, 35, 31, 28, 23, 18, 13, 7, 3, -4, -8, -12, -16, -20,
-24, -27, -29, -32, -34, -37, -39, -40, -42, -45, -46, -47, -47, -48, -48, -50,
-50, -50, -51, -52, -51, -52, -51, -52, -52, -51, -51, -51, -50, -50, -49, -49,
-49, -48, -47, -47, -45, -45, -44, -42, -41, -41, -40, -38, -36, -35, -34, -33,
-31, -31, -28, -28, -26, -24, -23, -21, -21, -18, -17, -15, -14, -12, -12, -9,
-7, -6, -5, -3, -2, -1, };