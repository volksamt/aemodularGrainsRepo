#define DATA_LENGTH 512
#define DATA AKWF_0154

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 2, 4, 4, 4, 4, 5, 6, 6, 7,
7, 8, 9, 9, 10, 10, 10, 11, 12, 13, 13, 13, 14, 14, 15, 15, 16, 17, 17, 18, 19,
20, 20, 22, 21, 22, 22, 23, 23, 25, 26, 26, 27, 27, 28, 29, 29, 30, 30, 31, 31,
33, 33, 33, 34, 35, 35, 37, 36, 37, 38, 39, 39, 40, 41, 41, 41, 43, 44, 45, 45,
46, 46, 47, 47, 48, 49, 50, 50, 51, 51, 52, 52, 53, 54, 55, 55, 55, 57, 57, 58,
59, 59, 59, 60, 62, 62, 62, 63, 63, 65, 66, 65, 67, 68, 68, 68, 68, 70, 70, 71,
72, 72, 73, 74, 75, 75, 76, 76, 76, 77, 78, 78, 80, 79, 81, 80, 81, 82, 83, 83,
84, 85, 85, 85, 86, 87, 87, 88, 88, 89, 89, 90, 90, 91, 92, 92, 92, 93, 94, 95,
94, 95, 95, 97, 97, 96, 98, 98, 98, 99, 99, 101, 100, 101, 101, 102, 102, 103,
103, 104, 104, 104, 104, 106, 106, 106, 107, 107, 107, 108, 109, 108, 109, 109,
110, 110, 110, 110, 111, 111, 112, 112, 113, 113, 113, 113, 114, 113, 115, 115,
115, 115, 116, 116, 116, 117, 117, 117, 117, 118, 117, 117, 118, 118, 119, 118,
120, 113, 96, 78, 66, 59, 55, 52, 49, 47, 44, 43, 42, 41, 41, 40, 40, 40, 38,
38, 36, 34, 32, 30, 27, 25, 22, 18, 16, 12, 9, 6, 1, -1, -5, -9, -12, -16, -19,
-22, -26, -30, -33, -37, -40, -42, -46, -48, -50, -55, -56, -60, -61, -64, -66,
-69, -70, -73, -76, -77, -79, -81, -82, -83, -85, -86, -88, -88, -90, -91, -93,
-94, -95, -95, -96, -97, -98, -98, -99, -100, -100, -100, -102, -101, -102,
-102, -102, -103, -103, -103, -104, -104, -104, -104, -104, -104, -104, -104,
-104, -105, -104, -104, -104, -104, -104, -103, -103, -103, -103, -102, -103,
-103, -102, -102, -102, -101, -101, -101, -101, -100, -100, -99, -99, -99, -99,
-98, -98, -98, -96, -97, -96, -95, -96, -95, -95, -93, -93, -92, -91, -93, -91,
-91, -90, -90, -89, -89, -88, -88, -87, -86, -86, -86, -85, -84, -85, -83, -83,
-83, -81, -81, -81, -81, -79, -79, -78, -77, -77, -77, -76, -76, -75, -75, -74,
-73, -72, -72, -71, -70, -69, -69, -68, -68, -67, -66, -66, -66, -64, -63, -63,
-63, -62, -61, -61, -60, -59, -59, -58, -57, -56, -56, -56, -55, -54, -54, -53,
-51, -52, -51, -50, -50, -49, -47, -48, -46, -46, -45, -44, -44, -43, -43, -42,
-41, -41, -40, -39, -40, -38, -38, -37, -36, -36, -34, -33, -34, -33, -33, -31,
-31, -30, -29, -29, -28, -27, -27, -26, -26, -26, -25, -23, -23, -23, -22, -21,
-21, -20, -20, -19, -19, -19, -18, -18, -17, -16, -15, -14, -15, -14, -13, -13,
-12, -11, -11, -11, -10, -9, -9, -8, -7, -8, -7, -6, -6, -5, -5, -4, -4, -3, -2,
-1, -1, -1, 0, };