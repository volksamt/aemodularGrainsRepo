#define DATA_LENGTH 512
#define DATA AKWF_0177

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 6, 7, 9, 10, 11, 13, 15,
16, 17, 19, 20, 21, 22, 23, 24, 24, 25, 26, 26, 27, 28, 29, 29, 30, 30, 31, 32,
33, 34, 34, 35, 36, 37, 37, 38, 39, 40, 39, 41, 41, 42, 43, 44, 45, 46, 45, 46,
46, 48, 49, 49, 50, 51, 52, 52, 54, 54, 54, 55, 56, 56, 58, 57, 58, 59, 60, 62,
63, 64, 66, 68, 69, 70, 72, 73, 74, 75, 77, 78, 81, 81, 83, 85, 85, 87, 89, 91,
92, 93, 94, 96, 97, 98, 99, 97, 93, 89, 84, 79, 74, 69, 63, 59, 54, 49, 44, 38,
34, 28, 23, 19, 13, 8, 3, -1, -7, -12, -17, -22, -28, -32, -37, -39, -39, -38,
-37, -37, -36, -36, -34, -33, -33, -33, -32, -31, -31, -29, -29, -29, -27, -27,
-25, -25, -24, -24, -22, -22, -21, -21, -20, -19, -17, -16, -14, -13, -12, -11,
-8, -7, -6, -4, -3, -2, -1, 2, 2, 4, 5, 7, 9, 10, 11, 12, 14, 16, 17, 19, 20,
20, 21, 22, 22, 23, 25, 25, 26, 26, 27, 28, 29, 30, 30, 31, 32, 32, 33, 34, 34,
36, 36, 36, 37, 38, 39, 40, 39, 40, 41, 42, 43, 44, 44, 45, 46, 46, 47, 48, 49,
50, 50, 50, 52, 53, 53, 53, 55, 56, 55, 56, 57, 58, 58, 59, 58, 54, 51, 47, 41,
38, 33, 30, 25, 20, 16, 11, 7, 4, -1, -6, -10, -14, -18, -23, -28, -31, -36,
-41, -45, -50, -53, -57, -58, -58, -59, -58, -58, -58, -56, -55, -54, -54, -53,
-53, -51, -51, -51, -49, -48, -48, -47, -46, -45, -45, -44, -43, -43, -42, -42,
-41, -40, -40, -39, -38, -38, -37, -36, -36, -34, -34, -32, -32, -32, -31, -30,
-29, -28, -28, -27, -26, -27, -25, -24, -23, -24, -22, -21, -21, -20, -20, -19,
-19, -18, -16, -16, -15, -15, -14, -13, -12, -12, -11, -10, -9, -9, -8, -7, -7,
-6, -5, -4, -4, -3, -3, -2, -2, -2, -4, -7, -12, -15, -20, -25, -29, -34, -38,
-42, -46, -50, -55, -59, -64, -68, -72, -76, -80, -85, -90, -94, -98, -102,
-108, -112, -116, -118, -119, -120, -118, -118, -117, -116, -115, -115, -114,
-114, -113, -112, -111, -111, -110, -109, -109, -108, -107, -106, -105, -105,
-103, -103, -103, -102, -101, -101, -98, -97, -96, -95, -93, -92, -90, -89, -87,
-86, -84, -83, -81, -81, -79, -77, -76, -74, -72, -71, -70, -69, -67, -66, -64,
-64, -62, -60, -60, -59, -58, -57, -57, -56, -55, -54, -54, -53, -52, -52, -51,
-50, -49, -48, -48, -47, -47, -46, -46, -45, -44, -43, -43, -41, -41, -40, -40,
-39, -38, -37, -37, -36, -35, -35, -34, -33, -33, -32, -31, -31, -30, -29, -27,
-28, -27, -27, -25, -25, -24, -23, -23, -22, -20, -19, -20, -18, -18, -17, -16,
-16, -15, -14, -13, -12, -12, -11, -11, -9, -9, -8, -8, -6, -4, -3, -1, 0, };