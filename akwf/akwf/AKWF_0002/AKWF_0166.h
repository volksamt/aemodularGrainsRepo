#define DATA_LENGTH 512
#define DATA AKWF_0166

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 10, 13, 17, 21, 25, 29, 34, 38,
42, 46, 51, 54, 59, 63, 66, 70, 73, 78, 79, 84, 86, 89, 92, 94, 97, 99, 101,
103, 105, 107, 108, 108, 110, 109, 110, 110, 111, 111, 109, 108, 108, 107, 105,
104, 103, 100, 100, 96, 95, 93, 91, 89, 87, 85, 82, 81, 79, 77, 75, 74, 72, 71,
69, 69, 67, 66, 65, 63, 63, 61, 60, 59, 57, 57, 56, 54, 53, 52, 51, 49, 48, 46,
45, 43, 41, 39, 37, 35, 33, 31, 28, 25, 23, 19, 17, 13, 11, 6, 4, 0, -3, -7,
-11, -15, -18, -21, -26, -28, -33, -36, -40, -44, -47, -51, -54, -57, -60, -64,
-67, -69, -73, -76, -79, -82, -85, -87, -90, -91, -94, -96, -98, -99, -100,
-102, -103, -104, -105, -106, -107, -107, -107, -109, -109, -109, -110, -109,
-111, -111, -110, -110, -111, -111, -111, -111, -112, -112, -112, -111, -112,
-112, -113, -113, -113, -113, -114, -113, -114, -116, -116, -116, -116, -117,
-117, -117, -117, -119, -118, -118, -119, -120, -120, -118, -119, -118, -117,
-116, -116, -114, -114, -113, -111, -109, -106, -105, -103, -101, -99, -96, -93,
-92, -90, -87, -84, -82, -80, -77, -75, -74, -72, -69, -68, -66, -64, -62, -61,
-59, -58, -58, -56, -56, -55, -54, -53, -53, -52, -52, -51, -49, -49, -48, -47,
-46, -44, -43, -42, -41, -39, -38, -36, -35, -33, -32, -30, -28, -26, -24, -23,
-21, -20, -19, -17, -16, -13, -11, -9, -8, -6, -4, -2, 0, 2, 4, 6, 8, 11, 12,
15, 17, 19, 20, 24, 25, 26, 28, 30, 32, 33, 35, 37, 37, 40, 41, 42, 43, 44, 45,
47, 47, 47, 48, 48, 49, 49, 50, 49, 49, 49, 49, 49, 48, 48, 47, 46, 48, 46, 46,
46, 46, 45, 45, 45, 46, 46, 47, 47, 48, 48, 49, 51, 52, 53, 56, 57, 58, 60, 61,
64, 65, 67, 68, 70, 73, 74, 75, 76, 79, 80, 82, 82, 83, 84, 85, 87, 86, 87, 87,
88, 88, 88, 87, 87, 86, 86, 84, 84, 82, 81, 79, 79, 77, 76, 74, 72, 71, 69, 67,
65, 64, 62, 59, 59, 56, 55, 53, 50, 48, 47, 45, 43, 42, 40, 38, 37, 35, 34, 33,
32, 31, 30, 29, 27, 28, 26, 26, 26, 25, 24, 24, 23, 23, 22, 22, 21, 21, 20, 19,
20, 19, 18, 17, 16, 16, 15, 14, 13, 12, 10, 10, 9, 7, 6, 5, 3, 1, 0, -3, -3, -6,
-7, -10, -11, -13, -14, -16, -18, -20, -21, -23, -23, -25, -27, -27, -27, -29,
-29, -29, -30, -29, -29, -29, -28, -28, -29, -28, -27, -27, -26, -25, -25, -25,
-25, -23, -24, -23, -22, -22, -23, -23, -22, -23, -23, -24, -25, -26, -27, -28,
-28, -30, -31, -32, -33, -33, -35, -36, -36, -36, -37, -37, -37, -37, -36, -36,
-35, -34, -33, -33, -31, -30, -28, -27, -25, -22, -20, -18, -15, -13, -9, -6,
-3, 0, };