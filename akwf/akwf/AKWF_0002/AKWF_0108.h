#define DATA_LENGTH 512
#define DATA AKWF_0108

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 5, 7, 8, 9, 11, 12, 14, 15,
16, 18, 20, 21, 22, 23, 25, 27, 28, 29, 31, 32, 33, 35, 36, 38, 39, 40, 42, 43,
44, 46, 47, 48, 49, 51, 52, 54, 54, 56, 58, 59, 60, 61, 63, 64, 66, 66, 67, 69,
69, 71, 73, 73, 74, 76, 76, 78, 79, 80, 82, 83, 83, 84, 85, 86, 87, 88, 90, 90,
91, 92, 93, 94, 95, 96, 97, 98, 98, 100, 100, 101, 102, 103, 104, 104, 105, 105,
106, 106, 107, 108, 109, 109, 110, 110, 111, 112, 113, 113, 113, 113, 114, 115,
115, 115, 115, 116, 116, 117, 117, 117, 117, 117, 118, 118, 119, 118, 119, 118,
118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 118, 119, 119, 118, 119, 118,
117, 117, 118, 118, 117, 117, 117, 116, 115, 116, 115, 114, 114, 113, 114, 113,
112, 112, 111, 110, 110, 110, 109, 109, 107, 107, 107, 106, 104, 104, 104, 103,
101, 101, 101, 99, 99, 98, 97, 96, 96, 94, 94, 93, 92, 90, 90, 89, 88, 86, 86,
85, 83, 83, 82, 81, 80, 79, 77, 76, 76, 74, 73, 72, 71, 69, 69, 67, 65, 65, 64,
63, 61, 60, 59, 57, 56, 55, 54, 53, 51, 50, 49, 47, 46, 46, 44, 42, 41, 39, 39,
37, 36, 35, 33, 31, 31, 29, 29, 27, 25, 25, 24, 22, 20, 19, 18, 17, 15, 14, 12,
11, 9, 8, 7, 5, 5, 2, 1, -1, -2, -4, -5, -7, -8, -10, -11, -12, -14, -15, -17,
-19, -20, -21, -22, -24, -26, -27, -28, -30, -31, -32, -33, -35, -36, -37, -39,
-40, -43, -44, -45, -46, -48, -49, -50, -52, -52, -53, -55, -56, -57, -58, -60,
-61, -62, -65, -65, -66, -68, -68, -71, -71, -72, -74, -75, -75, -77, -78, -80,
-80, -82, -82, -83, -84, -85, -87, -87, -88, -90, -91, -92, -92, -93, -94, -95,
-95, -97, -98, -98, -99, -100, -101, -102, -102, -103, -103, -105, -106, -106,
-107, -108, -108, -108, -110, -110, -111, -112, -111, -112, -113, -113, -114,
-114, -115, -115, -115, -116, -116, -116, -117, -118, -118, -118, -118, -118,
-117, -118, -119, -118, -119, -120, -119, -118, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -118, -117, -118, -117, -117,
-117, -117, -116, -115, -115, -115, -114, -114, -114, -113, -113, -112, -112,
-111, -110, -110, -110, -109, -108, -108, -107, -107, -106, -104, -104, -103,
-103, -102, -101, -101, -99, -98, -98, -96, -96, -95, -95, -94, -93, -91, -91,
-90, -88, -88, -87, -86, -85, -84, -83, -82, -81, -80, -78, -77, -76, -75, -75,
-73, -72, -70, -69, -68, -67, -66, -65, -64, -63, -61, -60, -59, -58, -56, -54,
-54, -52, -51, -50, -49, -48, -46, -45, -43, -42, -41, -40, -38, -37, -35, -34,
-33, -33, -30, -29, -28, -27, -25, -24, -23, -22, -20, -19, -18, -17, -14, -13,
-12, -11, -9, -8, -8, -6, -3, -2, 0, };