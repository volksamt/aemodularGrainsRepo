#define DATA_LENGTH 512
#define DATA AKWF_0190

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 40, 40, 40, 40, 40, 40, 39, 40, 39,
40, 39, 41, 39, 40, 39, 39, 39, 40, 39, 40, 40, 39, 40, 39, 40, 39, 40, 39, 40,
39, 41, 39, 40, 39, 40, 40, 40, 41, 38, 73, 81, 77, 81, 79, 79, 79, 80, 80, 78,
80, 77, 82, 72, 37, 41, 39, 40, 39, 40, 39, 39, 39, 40, 40, 40, 39, 39, 39, 40,
40, 40, 39, 41, 38, 42, 34, -3, 2, -1, 1, -3, 7, 43, 38, 41, 39, 40, 39, 40, 39,
40, 40, 40, 41, 39, 40, 39, 40, 40, 40, 39, 40, 39, 40, 39, 39, 39, 40, 40, 40,
40, 39, 41, 39, 42, 37, 44, 24, -5, 2, 0, 0, 0, -1, 1, -1, 2, -4, 10, 44, 38,
41, 39, 40, 39, 40, 40, 40, 37, 0, -1, 1, -1, 0, -1, 1, -1, 1, -2, 2, -3, 5,
-16, -43, -37, -41, -40, -40, -39, -39, -40, -40, -40, -41, -38, -44, -11, 3,
-2, 2, -1, 1, 0, 0, -1, 0, -1, -1, 0, 0, 0, 0, 0, 2, -32, -42, -38, -41, -38,
-41, -39, -41, -38, -41, -39, -40, -39, -40, -40, -40, -39, -39, -39, -40, -40,
-40, -39, -40, -40, -40, -39, -39, -40, -39, -39, -40, -40, -40, -40, -39, -40,
-39, -40, -40, -40, -39, -40, -39, -40, -40, -39, -39, -40, -39, -40, -40, -39,
-40, -40, -41, -39, -41, -38, -42, -35, -56, -83, -78, -80, -80, -78, -84, -56,
-35, -42, -37, -40, -39, -39, -39, -39, -40, -39, -41, -39, -41, -38, -40, -38,
-41, -39, -41, -77, -81, -78, -81, -79, -80, -79, -80, -79, -79, -80, -78, -82,
-75, -98, -124, -118, -119, -120, -117, -124, -93, -76, -82, -79, -80, -78, -81,
-46, -38, -40, -40, -38, -67, -84, -76, -82, -78, -81, -77, -82, -117, -119,
-119, -119, -119, -117, -78, -80, -78, -80, -79, -79, -79, -80, -79, -80, -80,
-79, -79, -79, -80, -79, -80, -79, -80, -78, -83, -51, -36, -43, -38, -42, -38,
-42, -39, -41, -38, -41, -38, -42, -35, 0, 0, -1, 1, -1, 1, -1, 1, -1, -1, 31,
44, 35, 46, 14, -3, 1, 0, -1, 0, 0, 0, 0, 1, 0, 1, -1, 0, 36, 41, 39, 41, 39,
40, 40, 40, 40, 39, 40, 38, 43, 28, -3, 2, -1, 0, 0, -1, 0, 0, 1, -1, 1, -2, 2,
-2, 2, -6, -39, -41, -38, -40, -38, -41, -39, -41, -39, -41, -37, -2, 2, -2, 1,
-1, 2, -1, 1, 0, 0, 1, -1, 1, -2, 5, -26, -44, -37, -42, -37, -40, -40, -41,
-40, -40, -40, -40, -40, -40, -39, -40, -40, -40, -40, -39, -40, -39, -40, -39,
-39, -39, -40, -40, -40, -39, -39, -40, -40, -40, -40, -40, -39, -40, -40, -40,
-40, -40, -39, -40, -40, -41, -38, -41, -38, -1, 0, 0, 1, -1, 0, 0, 1, 0, 0, -1,
0, -1, 1, -2, 4, -35, -39, -42, -25, 6, -3, 2, -2, };