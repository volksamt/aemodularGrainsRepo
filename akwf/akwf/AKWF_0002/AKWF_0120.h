#define DATA_LENGTH 512
#define DATA AKWF_0120

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 13, 16, 20, 23, 26, 29, 33,
36, 40, 43, 46, 49, 52, 55, 58, 61, 64, 66, 69, 71, 74, 77, 79, 81, 83, 86, 88,
89, 91, 93, 94, 95, 96, 97, 99, 100, 100, 101, 102, 103, 103, 104, 104, 104,
104, 104, 105, 105, 105, 105, 104, 104, 104, 104, 103, 103, 103, 102, 100, 101,
100, 99, 100, 98, 97, 96, 96, 95, 94, 93, 92, 91, 89, 89, 87, 87, 85, 84, 83,
81, 80, 79, 78, 77, 75, 74, 73, 72, 70, 68, 68, 66, 64, 62, 60, 60, 57, 55, 53,
52, 49, 48, 46, 44, 41, 40, 37, 35, 33, 30, 29, 26, 24, 22, 20, 17, 14, 12, 10,
8, 5, 3, 0, -3, -5, -8, -11, -13, -17, -18, -22, -25, -27, -31, -34, -36, -39,
-41, -44, -46, -48, -51, -54, -56, -59, -61, -63, -65, -67, -69, -72, -74, -75,
-78, -79, -80, -82, -84, -86, -88, -88, -91, -92, -93, -94, -95, -97, -98, -99,
-101, -101, -102, -102, -103, -102, -103, -104, -103, -104, -105, -104, -105,
-105, -105, -104, -104, -103, -102, -102, -102, -101, -101, -101, -99, -98, -98,
-97, -96, -95, -94, -93, -92, -90, -90, -89, -88, -87, -85, -84, -84, -81, -81,
-79, -78, -77, -76, -74, -73, -72, -70, -69, -68, -66, -64, -62, -62, -60, -58,
-56, -55, -52, -51, -49, -48, -46, -44, -41, -39, -37, -35, -33, -30, -27, -25,
-23, -21, -18, -15, -13, -10, -7, -4, -1, 2, 5, 7, 10, 14, 17, 20, 23, 27, 30,
33, 36, 38, 42, 46, 48, 52, 55, 56, 60, 63, 65, 68, 71, 74, 75, 78, 81, 82, 86,
87, 89, 90, 92, 94, 96, 97, 99, 100, 102, 103, 103, 105, 107, 108, 108, 109,
109, 109, 110, 110, 110, 111, 111, 110, 111, 111, 110, 110, 110, 109, 110, 109,
108, 107, 106, 106, 105, 105, 104, 103, 103, 101, 100, 99, 98, 97, 96, 95, 94,
93, 91, 90, 90, 87, 87, 85, 84, 81, 81, 79, 77, 76, 74, 72, 70, 69, 67, 64, 63,
61, 58, 57, 56, 54, 52, 49, 47, 45, 43, 40, 38, 37, 35, 31, 29, 28, 25, 22, 19,
18, 15, 13, 10, 8, 6, 2, 0, -2, -4, -6, -10, -11, -14, -17, -20, -23, -26, -28,
-31, -34, -37, -39, -42, -45, -47, -50, -53, -55, -59, -61, -63, -65, -67, -71,
-72, -75, -78, -79, -81, -83, -85, -86, -88, -91, -92, -94, -96, -97, -98, -100,
-101, -101, -103, -103, -104, -105, -106, -107, -107, -107, -107, -108, -107,
-108, -107, -108, -107, -108, -107, -107, -106, -106, -104, -105, -104, -103,
-103, -101, -101, -100, -99, -99, -97, -97, -96, -94, -95, -92, -91, -91, -89,
-87, -87, -86, -84, -83, -82, -80, -80, -78, -77, -75, -73, -73, -71, -69, -68,
-66, -64, -63, -60, -59, -57, -55, -52, -52, -49, -47, -45, -43, -40, -38, -35,
-33, -31, -27, -25, -22, -19, -16, -13, -10, -7, -5, -1, };