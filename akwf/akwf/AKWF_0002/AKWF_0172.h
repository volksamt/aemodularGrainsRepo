#define DATA_LENGTH 512
#define DATA AKWF_0172

const PROGMEM int8_t DATA[DATA_LENGTH] = {34, 41, 38, 41, 39, 41, 39, 40, 39,
40, 40, 41, 39, 40, 39, 40, 39, 40, 40, 40, 39, 40, 39, 39, 40, 39, 40, 39, 40,
40, 39, 40, 40, 39, 40, 38, 40, 39, 41, 37, 42, 36, 50, 84, 78, 80, 79, 79, 80,
80, 79, 79, 80, 79, 79, 79, 80, 78, 79, 79, 79, 80, 80, 79, 80, 79, 80, 79, 80,
79, 80, 79, 79, 79, 80, 79, 79, 80, 79, 79, 80, 80, 80, 78, 79, 80, 80, 79, 80,
79, 80, 80, 79, 80, 79, 80, 79, 79, 80, 79, 79, 80, 79, 80, 80, 79, 79, 79, 79,
79, 79, 79, 79, 79, 80, 80, 80, 80, 79, 79, 79, 80, 79, 79, 79, 79, 79, 79, 79,
79, 79, 79, 80, 79, 79, 80, 80, 79, 80, 79, 79, 80, 80, 79, 80, 79, 79, 79, 79,
80, 80, 79, 80, 79, 80, 78, 80, 78, 80, 78, 81, 78, 82, 73, 38, 40, 40, 39, 40,
39, 40, 39, 40, 39, 40, 38, 41, 39, 40, 39, 40, 40, 40, 40, 40, 40, 40, 40, 39,
40, 39, 40, 39, 40, 39, 40, 39, 41, 38, 41, 38, 42, 37, 43, 32, -3, 1, 0, 0, 0,
0, 0, 0, 1, 0, 1, 0, 0, 0, -1, 1, 0, 0, 0, 1, 0, 0, -1, 1, 0, 1, 0, -35, -41,
-38, -41, -39, -41, -39, -40, -39, -40, -38, -40, -39, -40, -40, -40, -40, -39,
-40, -39, -40, -39, -40, -39, -41, -40, -40, -39, -40, -39, -40, -38, -41, -39,
-41, -39, -40, -39, -40, -39, -41, -78, -81, -79, -81, -78, -80, -78, -80, -79,
-80, -79, -80, -78, -79, -79, -80, -80, -79, -79, -80, -80, -79, -80, -79, -80,
-78, -79, -79, -80, -80, -80, -78, -80, -79, -80, -78, -80, -79, -81, -79, -82,
-119, -119, -118, -120, -118, -119, -118, -119, -118, -120, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -118, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -120, -118, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-120, -120, -119, -119, -119, -119, -119, -119, -120, -118, -120, -117, -120,
-117, -123, -103, -75, -82, -78, -80, -79, -81, -78, -79, -80, -79, -79, -79,
-80, -80, -79, -79, -80, -80, -80, -79, -80, -79, -81, -79, -80, -78, -81, -76,
-83, -57, -35, -42, -37, -41, -39, -40, -39, -40, -40, -40, -39, -39, -40, -39,
-39, -40, -39, -40, -39, -40, -39, -39, -39, -39, -40, -40, -40, -40, -40, -39,
-40, -40, -40, -39, -40, -40, -40, -40, -40, -39, -41, -39, -40, -39, -40, -39,
-40, -39, -40, -39, -40, -40, -41, -39, -3, 1, -1, 0, -1, 1, -1, };