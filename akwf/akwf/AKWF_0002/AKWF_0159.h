#define DATA_LENGTH 512
#define DATA AKWF_0159

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 4, 4, 5, 5, 6, 8, 8, 8,
10, 10, 11, 11, 12, 13, 14, 15, 17, 17, 18, 18, 20, 20, 20, 21, 21, 18, 17, 16,
15, 12, 13, 14, 13, 13, 12, 11, 10, 10, 10, 9, 9, 9, 9, 8, 10, 10, 10, 11, 11,
11, 13, 14, 17, 23, 30, 38, 46, 54, 61, 68, 75, 81, 86, 90, 95, 99, 102, 104,
107, 109, 111, 112, 115, 115, 116, 117, 116, 118, 118, 118, 119, 119, 119, 118,
119, 118, 119, 119, 119, 119, 118, 119, 118, 118, 118, 117, 117, 117, 116, 116,
116, 115, 114, 115, 114, 114, 114, 112, 113, 112, 112, 110, 111, 111, 109, 110,
109, 108, 108, 108, 106, 106, 106, 105, 104, 104, 104, 103, 102, 102, 101, 100,
99, 99, 98, 98, 97, 96, 95, 94, 95, 93, 93, 92, 91, 90, 90, 90, 88, 88, 86, 85,
85, 84, 84, 83, 82, 80, 80, 79, 80, 78, 77, 76, 75, 75, 73, 72, 72, 72, 70, 70,
69, 69, 67, 66, 66, 64, 63, 62, 62, 61, 61, 59, 59, 57, 56, 56, 54, 55, 54, 52,
51, 51, 49, 48, 48, 46, 46, 44, 44, 44, 42, 41, 41, 39, 39, 38, 37, 36, 35, 34,
33, 32, 31, 30, 29, 28, 27, 26, 24, 24, 22, 21, 20, 18, 18, 17, 15, 13, 12, 10,
9, 9, 7, 5, 5, 3, 2, 0, -1, -2, -5, -6, -7, -8, -10, -11, -12, -13, -15, -16,
-18, -19, -20, -21, -22, -24, -26, -27, -28, -28, -30, -30, -32, -33, -34, -35,
-36, -37, -38, -39, -41, -41, -42, -43, -44, -45, -44, -45, -44, -43, -41, -40,
-38, -37, -36, -34, -33, -30, -26, -22, -20, -16, -14, -12, -10, -8, -7, -7, -6,
-6, -5, -4, -4, -5, -5, -6, -11, -17, -25, -32, -41, -48, -55, -62, -69, -74,
-79, -83, -87, -90, -94, -96, -98, -100, -102, -103, -105, -106, -107, -107,
-108, -108, -109, -109, -110, -109, -110, -110, -109, -110, -110, -110, -109,
-109, -110, -109, -109, -109, -108, -108, -107, -108, -107, -107, -107, -106,
-106, -106, -105, -105, -105, -105, -104, -104, -103, -102, -103, -102, -101,
-101, -101, -100, -99, -100, -98, -98, -97, -98, -97, -96, -95, -94, -95, -93,
-93, -93, -93, -92, -90, -90, -89, -90, -89, -87, -86, -87, -85, -84, -85, -84,
-83, -82, -82, -80, -79, -80, -79, -78, -78, -77, -76, -75, -74, -73, -73, -72,
-72, -71, -69, -68, -69, -68, -68, -66, -65, -64, -64, -63, -62, -61, -60, -59,
-59, -58, -57, -57, -56, -56, -53, -53, -53, -52, -51, -49, -49, -49, -47, -47,
-46, -46, -44, -43, -42, -42, -41, -41, -40, -38, -38, -37, -35, -34, -34, -34,
-32, -31, -30, -29, -28, -29, -28, -26, -26, -26, -24, -23, -23, -23, -21, -20,
-19, -19, -18, -17, -16, -15, -14, -14, -14, -12, -11, -11, -9, -9, -8, -8, -7,
-6, -5, -4, -4, -3, -3, -1, 0, 1, };