#define DATA_LENGTH 512
#define DATA AKWF_0116

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 16, 21, 27, 33, 37, 43, 46, 51,
55, 58, 61, 64, 67, 71, 72, 74, 77, 79, 81, 83, 84, 86, 87, 88, 89, 86, 84, 82,
85, 85, 85, 82, 77, 73, 71, 68, 66, 63, 62, 59, 57, 56, 55, 56, 57, 57, 58, 60,
62, 64, 65, 67, 68, 72, 72, 74, 76, 77, 79, 80, 81, 82, 83, 83, 82, 82, 79, 78,
74, 71, 66, 62, 57, 51, 44, 37, 31, 24, 16, 10, 3, -2, -9, -14, -20, -24, -30,
-35, -39, -43, -47, -50, -54, -56, -59, -61, -64, -67, -69, -71, -71, -71, -69,
-68, -64, -60, -55, -49, -43, -37, -30, -21, -14, -7, 0, 7, 14, 19, 24, 31, 35,
39, 45, 49, 52, 57, 60, 63, 67, 69, 72, 75, 78, 79, 82, 84, 85, 87, 89, 90, 92,
93, 95, 96, 96, 97, 98, 99, 100, 100, 101, 101, 102, 102, 102, 102, 102, 103,
102, 103, 103, 103, 104, 102, 103, 102, 103, 102, 103, 103, 102, 103, 103, 104,
103, 103, 104, 104, 104, 104, 105, 104, 105, 105, 105, 105, 106, 105, 106, 106,
107, 106, 106, 106, 107, 106, 107, 107, 106, 107, 106, 106, 106, 105, 105, 105,
105, 104, 104, 104, 103, 103, 103, 103, 102, 101, 102, 101, 100, 101, 101, 100,
101, 100, 100, 100, 99, 100, 100, 100, 101, 101, 101, 102, 102, 103, 103, 104,
104, 104, 105, 105, 107, 108, 108, 108, 109, 110, 111, 111, 111, 112, 114, 114,
114, 114, 115, 116, 116, 116, 117, 117, 116, 117, 117, 118, 118, 117, 118, 118,
118, 119, 118, 119, 118, 118, 119, 118, 118, 118, 117, 118, 118, 118, 118, 117,
116, 116, 116, 115, 115, 115, 114, 114, 115, 113, 114, 114, 112, 112, 112, 112,
111, 111, 111, 110, 110, 109, 110, 109, 109, 108, 109, 108, 107, 107, 106, 103,
101, 97, 93, 88, 81, 74, 68, 59, 51, 44, 36, 27, 19, 11, 4, -2, -10, -16, -21,
-27, -33, -38, -42, -47, -51, -55, -59, -63, -66, -68, -71, -74, -77, -79, -81,
-84, -85, -88, -89, -91, -93, -94, -95, -96, -98, -99, -99, -100, -102, -101,
-103, -103, -103, -104, -103, -105, -104, -104, -104, -104, -105, -105, -105,
-105, -105, -106, -105, -105, -105, -105, -106, -105, -105, -106, -106, -106,
-106, -107, -107, -107, -107, -107, -107, -108, -108, -108, -109, -109, -109,
-110, -110, -111, -110, -111, -111, -112, -113, -112, -112, -113, -113, -113,
-114, -114, -114, -114, -114, -115, -114, -115, -116, -115, -116, -115, -116,
-116, -116, -116, -116, -116, -116, -116, -116, -116, -115, -116, -115, -116,
-115, -116, -116, -116, -116, -116, -116, -116, -116, -116, -117, -116, -117,
-118, -116, -116, -117, -118, -118, -118, -118, -118, -118, -118, -118, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-118, -118, -118, -118, -118, -117, -118, -117, -116, -116, -114, -108, -101,
-93, -87, -81, -73, -64, -55, -45, -36, -27, -18, -11, -3, };