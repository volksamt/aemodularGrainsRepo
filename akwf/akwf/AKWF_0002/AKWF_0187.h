#define DATA_LENGTH 512
#define DATA AKWF_0187

const PROGMEM int8_t DATA[DATA_LENGTH] = {35, 41, 38, 41, 38, 40, 40, 41, 40,
40, 40, 40, 39, 39, 39, 39, 40, 39, 40, 40, 40, 39, 39, 39, 39, 39, 40, 40, 40,
39, 40, 39, 40, 40, 39, 39, 40, 40, 40, 39, 40, 40, 40, 40, 39, 40, 39, 39, 40,
39, 40, 40, 40, 39, 39, 40, 39, 40, 40, 39, 40, 39, 40, 40, 40, 39, 40, 40, 39,
40, 39, 39, 39, 40, 40, 40, 40, 40, 39, 40, 40, 40, 40, 39, 40, 40, 40, 39, 40,
39, 40, 40, 39, 39, 39, 40, 39, 39, 40, 40, 40, 40, 39, 39, 39, 40, 40, 40, 40,
39, 40, 39, 40, 40, 40, 40, 40, 40, 40, 40, 39, 40, 40, 39, 40, 39, 40, 39, 39,
39, 40, 39, 40, 40, 39, 40, 39, 40, 39, 41, 38, 42, 35, 65, 84, 77, 80, 78, 81,
79, 80, 79, 79, 79, 80, 79, 80, 79, 79, 79, 79, 79, 79, 80, 79, 80, 80, 79, 80,
80, 79, 80, 80, 80, 79, 80, 79, 79, 79, 80, 79, 80, 79, 79, 80, 79, 79, 79, 79,
80, 80, 80, 79, 79, 79, 79, 79, 79, 79, 80, 79, 80, 80, 79, 80, 79, 80, 79, 80,
78, 80, 78, 80, 79, 81, 78, 84, 63, 34, 43, 38, 41, 38, 41, 38, 40, 39, 41, 38,
41, 39, 41, 36, -1, 0, 1, 0, 0, 0, 1, 0, 0, 2, -32, -43, -37, -42, -37, -42,
-37, -41, -38, -41, -37, -42, -37, -47, -82, -79, -80, -79, -80, -80, -80, -79,
-79, -80, -79, -80, -78, -80, -80, -80, -79, -79, -80, -80, -79, -79, -79, -80,
-79, -79, -79, -79, -80, -79, -79, -79, -80, -79, -80, -79, -80, -79, -79, -79,
-80, -79, -79, -80, -80, -80, -79, -80, -79, -80, -80, -80, -79, -80, -79, -80,
-79, -80, -79, -80, -79, -79, -80, -80, -80, -80, -79, -80, -79, -80, -80, -80,
-79, -79, -80, -79, -80, -79, -79, -80, -79, -80, -79, -79, -79, -80, -80, -79,
-79, -79, -79, -80, -79, -79, -80, -79, -79, -79, -80, -80, -79, -80, -80, -79,
-80, -80, -80, -79, -79, -79, -79, -79, -79, -80, -79, -80, -79, -79, -80, -79,
-79, -80, -79, -79, -79, -79, -79, -80, -79, -80, -79, -80, -79, -79, -79, -79,
-79, -79, -80, -79, -81, -76, -109, -123, -117, -120, -118, -121, -119, -120,
-119, -119, -118, -120, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-118, -120, -119, -119, -119, -119, -119, -119, -120, -119, -119, -120, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -118, -118, -120, -119, -119, -119,
-120, -120, -118, -119, -118, -120, -118, -120, -117, -121, -116, -123, -110,
-76, -81, -79, -80, -80, -78, -80, -78, -81, -78, -81, -78, -80, -78, -82, -77,
-41, -39, -40, -40, -39, -41, -38, -44, -21, 5, -3, 2, -2, 1, -1, 0, 0, 0, 0, 0,
0, 0, 0, 0, };