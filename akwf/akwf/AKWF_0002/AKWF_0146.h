#define DATA_LENGTH 512
#define DATA AKWF_0146

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 5, 6, 8, 9, 11, 13, 15, 16, 18,
19, 20, 22, 23, 25, 26, 27, 29, 30, 31, 33, 34, 36, 36, 37, 39, 40, 41, 42, 43,
43, 45, 45, 47, 48, 50, 50, 51, 52, 52, 53, 54, 56, 56, 57, 58, 58, 59, 59, 60,
61, 62, 63, 63, 63, 65, 64, 65, 66, 68, 68, 69, 70, 72, 73, 74, 77, 78, 81, 83,
87, 91, 96, 101, 105, 107, 111, 114, 116, 118, 118, 119, 119, 118, 118, 119,
119, 119, 119, 118, 119, 119, 119, 119, 118, 119, 119, 118, 118, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 120, 118, 119, 118, 119, 119,
119, 119, 119, 119, 119, 118, 119, 118, 119, 119, 119, 120, 118, 119, 118, 119,
120, 118, 116, 115, 113, 111, 108, 105, 103, 102, 99, 96, 92, 90, 87, 84, 80,
76, 72, 67, 60, 54, 48, 42, 38, 32, 28, 22, 16, 11, 5, 0, -5, -11, -16, -22,
-27, -32, -37, -41, -45, -49, -53, -56, -59, -62, -65, -67, -69, -71, -72, -73,
-72, -71, -69, -67, -64, -64, -62, -61, -59, -56, -54, -53, -50, -46, -44, -40,
-39, -37, -34, -31, -29, -27, -24, -22, -20, -18, -17, -15, -14, -12, -11, -9,
-9, -7, -7, -6, -5, -5, -4, -4, -4, -4, -2, -1, -2, -3, -2, -2, -2, -3, -3, -3,
-3, -3, -4, -3, -5, -6, -6, -7, -6, -6, -8, -8, -8, -9, -9, -10, -10, -11, -12,
-13, -13, -13, -14, -14, -16, -16, -17, -17, -18, -18, -18, -19, -20, -21, -22,
-22, -22, -22, -23, -24, -25, -24, -25, -25, -27, -27, -28, -29, -29, -28, -30,
-30, -31, -32, -32, -32, -33, -33, -33, -34, -34, -35, -35, -36, -36, -37, -37,
-37, -37, -38, -38, -38, -38, -38, -38, -39, -39, -39, -39, -40, -39, -39, -39,
-39, -39, -39, -39, -39, -39, -38, -39, -39, -38, -38, -39, -37, -38, -38, -37,
-38, -37, -37, -36, -36, -36, -36, -36, -37, -36, -35, -35, -35, -35, -35, -35,
-35, -34, -34, -34, -34, -34, -33, -33, -33, -33, -33, -33, -33, -32, -33, -32,
-32, -31, -32, -32, -32, -31, -31, -30, -31, -31, -30, -31, -30, -31, -30, -30,
-30, -30, -29, -29, -29, -29, -29, -28, -29, -29, -29, -30, -30, -31, -31, -32,
-34, -36, -36, -37, -41, -45, -49, -53, -57, -59, -62, -65, -67, -71, -74, -77,
-80, -84, -87, -90, -93, -95, -98, -100, -103, -106, -106, -109, -111, -112,
-113, -114, -115, -116, -116, -116, -117, -117, -117, -117, -116, -116, -116,
-116, -115, -114, -113, -113, -112, -109, -108, -107, -107, -104, -103, -103,
-100, -99, -97, -96, -93, -91, -90, -89, -86, -84, -82, -81, -79, -76, -74, -73,
-71, -68, -66, -64, -62, -60, -58, -56, -55, -53, -50, -49, -46, -44, -42, -40,
-39, -37, -35, -33, -30, -29, -27, -25, -24, -22, -19, -18, -15, -15, -13, -11,
-9, -7, -5, -4, -1, 0, };