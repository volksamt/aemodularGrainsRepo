#define DATA_LENGTH 512
#define DATA AKWF_0133

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 12, 16, 19, 23, 26, 30, 33,
36, 39, 43, 46, 49, 52, 55, 57, 61, 64, 68, 69, 72, 75, 77, 80, 82, 86, 87, 89,
92, 94, 95, 97, 100, 101, 103, 104, 106, 107, 109, 110, 110, 112, 113, 115, 115,
116, 116, 117, 118, 119, 119, 118, 119, 118, 119, 119, 119, 118, 118, 118, 117,
117, 117, 115, 116, 114, 114, 113, 112, 110, 110, 108, 107, 106, 104, 104, 102,
101, 99, 97, 95, 94, 92, 91, 89, 87, 85, 83, 81, 79, 76, 75, 73, 71, 69, 67, 65,
62, 59, 58, 56, 53, 51, 49, 47, 45, 43, 39, 38, 36, 33, 31, 29, 27, 24, 22, 20,
19, 16, 14, 11, 9, 8, 5, 3, 2, -1, -3, -5, -6, -8, -10, -11, -13, -15, -16, -19,
-20, -23, -24, -25, -26, -27, -28, -30, -32, -33, -33, -35, -36, -37, -38, -40,
-39, -41, -42, -43, -43, -43, -45, -45, -46, -46, -48, -47, -47, -47, -47, -49,
-48, -48, -48, -47, -46, -47, -47, -45, -44, -44, -44, -44, -42, -42, -42, -40,
-40, -39, -38, -36, -35, -36, -34, -34, -33, -32, -31, -30, -29, -28, -27, -26,
-25, -24, -24, -22, -22, -21, -20, -19, -17, -17, -16, -16, -14, -14, -13, -12,
-11, -10, -9, -9, -8, -8, -6, -6, -5, -4, -4, -3, -3, -2, -1, 0, 1, 1, 1, 2, 3,
2, 3, 3, 4, 4, 5, 5, 6, 5, 6, 7, 7, 7, 7, 8, 8, 8, 7, 8, 9, 9, 9, 9, 8, 9, 10,
9, 9, 9, 9, 9, 10, 10, 10, 9, 9, 8, 9, 10, 9, 9, 8, 9, 8, 8, 8, 8, 8, 7, 7, 7,
7, 6, 7, 6, 6, 6, 6, 5, 5, 5, 4, 4, 4, 4, 3, 4, 3, 3, 2, 2, 2, 1, 1, 0, 0, 0, 1,
0, 0, 0, -1, -1, -2, -2, -2, -3, -3, -3, -3, -3, -3, -3, -4, -4, -4, -4, -5, -4,
-5, -5, -6, -6, -6, -7, -7, -7, -7, -7, -8, -8, -7, -8, -7, -7, -8, -9, -8, -8,
-8, -8, -8, -8, -8, -10, -9, -9, -8, -9, -8, -9, -9, -9, -9, -9, -8, -9, -9,
-10, -9, -9, -9, -10, -9, -9, -9, -9, -8, -10, -8, -9, -9, -9, -8, -8, -9, -8,
-8, -8, -8, -8, -8, -7, -7, -7, -7, -6, -6, -6, -7, -7, -7, -6, -6, -6, -6, -7,
-8, -8, -9, -10, -11, -13, -16, -18, -20, -23, -25, -29, -32, -34, -38, -41,
-45, -48, -52, -55, -59, -63, -65, -69, -72, -75, -78, -82, -84, -87, -89, -92,
-94, -95, -98, -100, -101, -103, -104, -105, -107, -108, -109, -108, -109, -110,
-110, -110, -110, -110, -110, -110, -108, -108, -107, -107, -105, -104, -103,
-102, -100, -99, -97, -94, -92, -90, -88, -86, -84, -80, -79, -76, -74, -71,
-68, -65, -62, -59, -56, -53, -50, -46, -44, -39, -37, -33, -29, -26, -22, -19,
-15, -12, -8, -4, -1, };