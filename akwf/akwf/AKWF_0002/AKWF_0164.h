#define DATA_LENGTH 512
#define DATA AKWF_0164

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 4, 5, 6, 7, 8, 9, 10, 10, 12,
12, 13, 14, 15, 16, 17, 18, 19, 19, 18, 18, 19, 18, 18, 18, 18, 17, 17, 16, 17,
17, 17, 18, 17, 18, 20, 21, 21, 22, 24, 24, 25, 27, 29, 30, 32, 34, 36, 38, 40,
42, 44, 46, 49, 51, 53, 55, 56, 58, 61, 62, 64, 65, 67, 69, 71, 73, 75, 78, 79,
81, 84, 86, 88, 90, 92, 93, 94, 97, 98, 99, 101, 102, 103, 105, 106, 107, 107,
109, 110, 111, 112, 112, 112, 113, 115, 114, 115, 116, 116, 117, 117, 117, 118,
118, 118, 118, 119, 118, 119, 119, 119, 119, 118, 120, 119, 119, 118, 118, 118,
118, 117, 117, 117, 116, 117, 115, 115, 115, 113, 113, 113, 112, 110, 111, 109,
108, 108, 108, 106, 106, 105, 104, 103, 102, 102, 102, 101, 100, 99, 99, 98, 98,
97, 97, 96, 95, 94, 94, 94, 93, 92, 91, 91, 90, 89, 87, 87, 86, 85, 83, 82, 80,
80, 78, 77, 76, 74, 72, 72, 70, 67, 66, 64, 61, 60, 58, 56, 53, 51, 48, 45, 42,
39, 37, 34, 31, 28, 24, 22, 19, 16, 14, 11, 8, 6, 3, 0, -2, -5, -7, -9, -12,
-13, -15, -17, -19, -20, -22, -23, -25, -26, -27, -29, -30, -31, -32, -33, -34,
-35, -36, -37, -37, -38, -39, -39, -40, -40, -42, -42, -43, -43, -43, -44, -44,
-45, -46, -46, -46, -47, -48, -47, -49, -50, -49, -50, -51, -51, -52, -53, -53,
-54, -55, -55, -56, -56, -57, -57, -58, -59, -60, -60, -61, -62, -63, -64, -66,
-67, -69, -70, -72, -75, -75, -77, -79, -80, -80, -82, -83, -84, -84, -84, -85,
-85, -85, -85, -85, -85, -84, -85, -84, -84, -84, -84, -83, -82, -82, -80, -80,
-79, -79, -78, -78, -77, -77, -77, -76, -76, -77, -77, -76, -77, -78, -79, -80,
-80, -81, -81, -81, -82, -83, -83, -82, -83, -83, -82, -82, -82, -81, -81, -80,
-80, -79, -79, -78, -77, -76, -76, -75, -74, -73, -73, -71, -70, -70, -68, -68,
-68, -67, -66, -65, -65, -63, -63, -62, -62, -61, -60, -59, -59, -58, -57, -58,
-56, -56, -56, -55, -54, -54, -54, -53, -53, -52, -53, -52, -52, -52, -52, -51,
-50, -50, -50, -50, -50, -49, -48, -48, -48, -47, -46, -45, -45, -44, -43, -43,
-43, -42, -41, -39, -39, -38, -37, -36, -34, -34, -33, -32, -31, -30, -30, -29,
-28, -27, -26, -26, -25, -25, -24, -22, -23, -23, -21, -21, -20, -21, -20, -19,
-20, -20, -19, -19, -19, -20, -21, -21, -21, -23, -23, -25, -26, -27, -27, -29,
-30, -32, -32, -33, -34, -34, -36, -36, -37, -37, -37, -39, -39, -38, -40, -39,
-39, -38, -39, -39, -38, -37, -38, -37, -36, -36, -34, -33, -33, -32, -31, -30,
-29, -28, -27, -26, -25, -23, -23, -21, -20, -19, -18, -17, -15, -14, -12, -12,
-10, -8, -7, -6, -5, -4, -3, -1, -1, };