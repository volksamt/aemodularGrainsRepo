#define DATA_LENGTH 512
#define DATA AKWF_vgame_0077

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 15, 15, 16, 17, 17, 17, 16, 16, 16,
16, 16, 16, 17, 14, 18, 30, 32, 29, 31, 30, 29, 29, 30, 30, 30, 29, 30, 29, 31,
31, 31, 43, 46, 43, 44, 45, 45, 44, 45, 44, 44, 45, 45, 44, 44, 45, 45, 57, 61,
59, 59, 59, 60, 59, 60, 60, 60, 59, 60, 59, 60, 59, 60, 70, 76, 73, 74, 75, 74,
74, 75, 75, 75, 75, 75, 74, 74, 75, 72, 83, 89, 88, 89, 89, 88, 87, 88, 87, 88,
87, 89, 87, 89, 88, 87, 98, 104, 102, 103, 103, 103, 103, 103, 103, 103, 103,
102, 102, 103, 103, 101, 109, 117, 117, 118, 117, 118, 117, 117, 117, 117, 117,
118, 117, 118, 117, 120, 112, 102, 103, 102, 102, 101, 103, 102, 102, 102, 102,
102, 102, 101, 105, 99, 87, 89, 88, 87, 87, 88, 87, 88, 88, 86, 87, 88, 88, 87,
90, 84, 73, 73, 74, 73, 74, 73, 74, 73, 74, 73, 74, 73, 74, 73, 74, 71, 59, 57,
58, 57, 58, 58, 58, 57, 59, 57, 59, 58, 58, 58, 60, 57, 45, 42, 44, 43, 43, 42,
43, 43, 43, 43, 44, 43, 43, 42, 43, 44, 32, 26, 29, 29, 27, 29, 27, 27, 28, 28,
28, 28, 29, 27, 29, 29, 17, 13, 14, 15, 15, 14, 15, 14, 14, 14, 15, 14, 15, 13,
13, 14, 4, -2, 0, -2, -1, -1, -1, -1, -1, 0, -1, -1, 0, -1, -2, -1, -8, -16,
-15, -15, -16, -16, -16, -16, -16, -16, -17, -16, -15, -16, -16, -14, -22, -32,
-29, -30, -31, -30, -31, -30, -30, -30, -31, -30, -30, -31, -28, -36, -46, -44,
-45, -44, -44, -45, -44, -44, -44, -45, -43, -45, -44, -46, -43, -48, -59, -61,
-59, -60, -59, -59, -59, -60, -58, -60, -60, -59, -59, -60, -59, -63, -74, -76,
-73, -75, -74, -74, -74, -75, -74, -74, -74, -75, -74, -74, -72, -76, -88, -88,
-89, -89, -88, -89, -88, -89, -88, -90, -89, -89, -88, -90, -87, -88, -100,
-103, -101, -103, -102, -102, -103, -103, -103, -102, -102, -103, -102, -102,
-102, -103, -114, -119, -117, -117, -117, -118, -117, -117, -117, -117, -117,
-118, -117, -118, -117, -119, -108, -100, -102, -101, -103, -102, -102, -102,
-101, -102, -102, -102, -102, -102, -102, -105, -94, -86, -88, -87, -88, -87,
-88, -88, -87, -88, -87, -88, -87, -87, -88, -79, -71, -74, -73, -73, -73, -74,
-73, -73, -73, -73, -73, -73, -73, -71, -74, -67, -57, -59, -58, -58, -59, -58,
-58, -58, -58, -58, -59, -58, -59, -57, -60, -54, -41, -44, -43, -42, -43, -42,
-43, -43, -43, -42, -43, -43, -44, -41, -44, -39, -29, -29, -30, -28, -28, -29,
-29, -29, -30, -28, -28, -29, -27, -28, -29, -25, -15, -13, -14, -15, -15, -14,
-15, -14, -14, -14, -14, -13, -14, -12, -14, -12, -1, 1, 1, 1, 1, 1, 1, 2, 1, 1,
1, 2, 1, 1, 1, 0, };