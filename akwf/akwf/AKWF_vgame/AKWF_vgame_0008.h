#define DATA_LENGTH 512
#define DATA AKWF_vgame_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 0, 0, 1, 1, -1, 0, 0, 1, 0,
0, 0, 0, 0, 1, 0, 0, 0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 0, 1, 0, 0, 0, 1, -1,
-1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0,
0, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0,
0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0,
0, 1, 0, 0, 1, 0, 0, 1, 0, 0, 1, 1, 0, -1, 0, 1, 0, 0, 1, 0, 0, -1, 1, 0, 0, 1,
18, 59, 94, 105, 110, 114, 118, 120, 119, 117, 116, 114, 114, 112, 111, 109,
108, 107, 105, 104, 103, 102, 101, 98, 80, 38, 2, -10, -15, -22, -26, -29, -30,
-30, -30, -29, -29, -28, -27, -27, -28, -27, -27, -27, -26, -26, -26, -26, -25,
-25, -25, -25, -23, -24, -23, -24, -23, -23, -23, -22, -23, -22, -21, -22, -21,
-21, -21, -22, -20, -20, -20, -20, -19, -19, -20, -19, -19, -19, -18, -19, -18,
-18, -17, -17, -17, -17, -17, -17, -16, -15, -16, -16, -15, -16, -15, -15, -15,
-15, -16, -14, -15, -14, -14, -13, -14, -14, -14, -13, -13, -12, -13, -13, -13,
-13, -12, -12, -13, -11, -12, -11, -12, -11, -11, -11, -11, -10, -10, -11, -11,
-11, -10, -10, -10, -10, -10, -9, -10, -10, -10, -10, -8, -9, -9, -9, -9, -9,
-9, -8, -8, -8, -9, -7, -9, -8, -8, -7, -7, -8, -7, -7, -7, -7, -6, -7, -7, -7,
-6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -5, -6, -6, -6, -6, -6, -6, -5, -5, -5,
-5, -4, -5, -4, -6, -5, -4, -5, -4, -4, -4, -5, -3, -5, -4, -4, -5, -5, -4, -4,
-4, -3, -4, -3, -4, -3, -3, -3, -4, -3, -3, -3, -2, -4, -4, -3, -4, -3, -3, -2,
-4, -3, -2, -2, -2, -3, -2, -3, -2, -2, -2, -2, -2, -3, -2, -2, -2, -2, -2, -1,
-2, -2, -2, -1, -2, -2, -2, -1, -2, -2, -2, -2, -2, -1, -2, -1, -1, -1, -2, -1,
-1, -1, -2, -1, -1, -1, -1, -1, -1, -1, -1, 0, -1, -1, -1, -1, 0, 0, -1, -1, -1,
-2, -1, -1, -1, -1, -1, 0, -1, 0, -1, -1, -1, 0, -1, -1, -1, -1, 0, 0, -2, 0,
-1, -1, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, -1, -1, -1, -1, 0, 0, 0,
0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0,
-1, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, };