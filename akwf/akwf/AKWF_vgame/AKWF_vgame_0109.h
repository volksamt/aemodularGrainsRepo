#define DATA_LENGTH 512
#define DATA AKWF_vgame_0109

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 0, 1, 0, -1, 0, -1, 0, 0, 0,
0, 1, 3, 3, 3, 3, 3, 3, 2, 3, 2, 3, 2, 2, 2, 3, 3, 3, 3, 3, 2, 2, 3, 2, 4, 5, 5,
5, 5, 6, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 4, 5, 4, 7, 3, 10, 19, 29,
37, 35, 38, 35, 36, 35, 37, 36, 37, 35, 37, 36, 37, 49, 51, 50, 51, 50, 51, 50,
52, 49, 52, 49, 54, 63, 71, 84, 82, 82, 82, 82, 82, 82, 82, 82, 81, 82, 82, 81,
93, 97, 96, 96, 96, 97, 96, 96, 96, 97, 96, 96, 112, 114, 116, 117, 116, 116,
115, 116, 115, 116, 115, 116, 115, 116, 115, 116, 115, 116, 114, 116, 114, 116,
116, 116, 116, 115, 115, 118, 115, 81, 80, 82, 80, 82, 81, 83, 81, 82, 80, 82,
80, 83, 74, 65, 68, 67, 66, 66, 67, 67, 68, 66, 68, 62, 53, 54, 44, 42, 43, 42,
43, 42, 42, 43, 43, 43, 43, 43, 42, 41, 39, 40, 40, 40, 40, 40, 40, 40, 40, 41,
40, 41, 40, 42, 42, 42, 42, 42, 42, 43, 42, 42, 42, 42, 42, 42, 42, 42, 43, 42,
42, 42, 42, 42, 42, 43, 42, 43, 45, 44, 44, 45, 45, 44, 44, 45, 44, 45, 44, 45,
45, 45, 44, 45, 45, 45, 45, 45, 45, 45, 44, 44, 44, 44, 45, 37, 39, 31, 21, 24,
22, 23, 22, 23, 22, 22, 23, 22, 23, 22, 24, 11, 8, 8, 8, 9, 7, 9, 7, 9, 7, 9,
-3, -3, -7, -20, -18, -20, -18, -18, -18, -19, -19, -18, -18, -18, -18, -17,
-27, -31, -30, -30, -29, -31, -30, -30, -31, -31, -29, -38, -43, -42, -48, -47,
-48, -47, -48, -47, -47, -48, -47, -47, -47, -47, -47, -46, -44, -45, -45, -45,
-45, -44, -45, -45, -45, -44, -44, -46, -45, -43, -42, -42, -42, -43, -42, -42,
-42, -43, -42, -42, -42, -42, -42, -42, -43, -43, -42, -42, -43, -42, -42, -42,
-43, -40, -40, -40, -40, -40, -40, -39, -40, -39, -40, -39, -39, -40, -39, -40,
-40, -41, -47, -47, -47, -47, -47, -47, -47, -47, -46, -49, -61, -62, -60, -70,
-75, -73, -74, -73, -74, -72, -74, -73, -74, -71, -76, -70, -78, -116, -118,
-120, -119, -118, -119, -119, -118, -119, -119, -115, -114, -114, -114, -114,
-115, -114, -114, -114, -114, -114, -114, -113, -114, -115, -114, -114, -112,
-111, -111, -111, -112, -112, -112, -112, -111, -111, -107, -102, -106, -98,
-86, -88, -87, -88, -87, -87, -88, -88, -87, -87, -87, -87, -88, -74, -68, -71,
-70, -70, -70, -70, -70, -70, -71, -63, -53, -58, -52, -40, -40, -41, -41, -41,
-41, -41, -40, -41, -40, -42, -40, -42, -31, -23, -25, -23, -24, -23, -24, -24,
-24, -25, -19, -8, -10, -8, -3, -2, -3, -2, -2, -2, -2, -3, -2, -3, -2, -2, -2,
-2, };