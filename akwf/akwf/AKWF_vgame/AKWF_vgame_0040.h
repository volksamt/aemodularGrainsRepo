#define DATA_LENGTH 512
#define DATA AKWF_vgame_0040

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 14, 16, 17, 19, 23, 26, 31,
33, 35, 39, 42, 45, 47, 52, 57, 57, 59, 61, 65, 65, 67, 67, 69, 70, 72, 74, 75,
79, 79, 80, 81, 82, 82, 85, 84, 84, 86, 87, 88, 88, 90, 92, 93, 92, 93, 93, 94,
95, 95, 96, 97, 96, 97, 97, 98, 99, 98, 99, 97, 98, 99, 101, 99, 100, 102, 104,
103, 103, 106, 107, 107, 108, 111, 112, 115, 116, 116, 116, 117, 118, 120, 119,
119, 119, 118, 116, 116, 113, 108, 108, 106, 105, 104, 100, 96, 95, 93, 89, 87,
85, 83, 79, 74, 74, 73, 71, 71, 68, 66, 67, 66, 65, 65, 62, 61, 59, 56, 56, 56,
55, 54, 50, 48, 48, 46, 45, 41, 38, 34, 26, 23, 22, 19, 17, 14, 7, 6, 6, 3, 0,
-2, -3, -7, -8, -8, -10, -11, -12, -11, -11, -11, -11, -11, -12, -13, -13, -14,
-15, -15, -17, -18, -20, -23, -26, -25, -28, -31, -34, -36, -40, -47, -49, -50,
-53, -55, -59, -65, -69, -68, -70, -75, -77, -81, -82, -84, -84, -84, -84, -84,
-84, -82, -82, -82, -82, -82, -82, -80, -81, -81, -79, -79, -78, -79, -77, -76,
-76, -76, -75, -76, -76, -77, -74, -73, -73, -72, -71, -69, -65, -64, -64, -61,
-59, -55, -48, -46, -45, -42, -38, -34, -32, -27, -18, -16, -15, -12, -10, -7,
-1, 1, 3, 5, 8, 10, 12, 14, 16, 17, 18, 19, 19, 23, 23, 24, 24, 25, 24, 26, 25,
25, 25, 26, 26, 26, 25, 26, 26, 26, 25, 25, 26, 26, 26, 26, 25, 25, 24, 24, 23,
21, 21, 20, 18, 18, 16, 12, 11, 10, 8, 5, 2, 1, 0, -2, -3, -3, -3, -3, -3, -3,
-4, -3, -2, -1, -2, -1, -3, -4, -3, -4, -3, -3, -6, -7, -6, -6, -9, -12, -12,
-16, -20, -21, -23, -26, -27, -29, -35, -36, -38, -40, -40, -42, -43, -43, -45,
-45, -44, -45, -47, -47, -46, -46, -46, -47, -48, -50, -50, -54, -54, -55, -57,
-57, -58, -60, -60, -59, -60, -60, -59, -59, -60, -58, -58, -58, -58, -60, -60,
-60, -59, -59, -59, -62, -61, -62, -61, -61, -61, -61, -61, -60, -60, -60, -59,
-60, -59, -58, -58, -59, -58, -58, -58, -58, -56, -56, -57, -57, -56, -54, -54,
-54, -55, -55, -55, -55, -53, -53, -53, -52, -51, -52, -50, -50, -48, -47, -45,
-43, -42, -41, -39, -37, -35, -33, -29, -29, -30, -27, -26, -25, -23, -23, -23,
-22, -21, -19, -19, -18, -18, -17, -17, -17, -18, -15, -16, -16, -16, -16, -16,
-17, -16, -16, -15, -16, -15, -16, -16, -17, -16, -17, -18, -18, -18, -18, -18,
-21, -21, -21, -21, -20, -22, -23, -23, -22, -22, -22, -23, -22, -22, -22, -23,
-23, -22, -23, -24, -24, -24, -24, -24, -25, -23, -23, -24, -24, -24, -24, -24,
-24, -24, -23, -23, -21, -21, -20, -17, -15, -16, -14, -12, -9, -9, -5, };