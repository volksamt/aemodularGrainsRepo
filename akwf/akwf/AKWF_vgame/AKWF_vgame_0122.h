#define DATA_LENGTH 512
#define DATA AKWF_vgame_0122

const PROGMEM int8_t DATA[DATA_LENGTH] = {19, 25, 24, 25, 24, 24, 25, 25, 24,
25, 25, 25, 24, 26, 23, 26, 20, 55, 74, 69, 71, 69, 71, 69, 71, 70, 70, 70, 71,
70, 70, 70, 71, 70, 71, 69, 70, 70, 69, 70, 70, 70, 70, 71, 70, 71, 70, 71, 69,
72, 65, 88, 119, 114, 116, 115, 116, 116, 116, 116, 115, 115, 115, 116, 116,
116, 115, 116, 115, 116, 115, 115, 116, 115, 116, 115, 116, 115, 115, 116, 115,
115, 115, 116, 115, 115, 115, 115, 115, 116, 115, 115, 115, 115, 115, 115, 115,
115, 115, 115, 114, 114, 116, 116, 114, 116, 114, 115, 115, 115, 114, 114, 116,
115, 114, 115, 114, 114, 114, 115, 115, 115, 114, 115, 114, 114, 115, 114, 114,
115, 115, 115, 115, 114, 115, 115, 114, 114, 114, 115, 114, 115, 114, 114, 114,
114, 114, 114, 114, 114, 114, 114, 115, 115, 114, 113, 114, 115, 114, 114, 114,
113, 114, 114, 113, 114, 114, 114, 114, 114, 113, 114, 113, 114, 114, 114, 114,
114, 113, 113, 114, 113, 114, 114, 114, 113, 113, 113, 114, 113, 113, 113, 114,
113, 114, 113, 114, 111, 116, 107, 69, 67, 68, 68, 68, 68, 69, 67, 68, 67, 68,
67, 69, 68, 68, 67, 68, 67, 68, 67, 68, 67, 67, 67, 67, 68, 68, 68, 67, 67, 67,
68, 67, 70, 33, 18, 24, 21, 23, 21, 23, 21, 23, 22, 22, 22, 22, 21, 22, 21, 25,
-7, -29, -21, -25, -22, -25, -23, -24, -23, -25, -23, -23, -23, -24, -24, -24,
-24, -23, -23, -25, -64, -73, -67, -70, -68, -71, -68, -70, -69, -69, -68, -69,
-68, -69, -69, -70, -69, -69, -69, -70, -69, -69, -69, -69, -70, -68, -69, -68,
-69, -68, -70, -68, -70, -68, -70, -68, -73, -113, -115, -114, -115, -114, -116,
-114, -115, -114, -115, -114, -114, -114, -115, -114, -115, -114, -115, -115,
-114, -114, -114, -114, -114, -114, -114, -115, -114, -114, -114, -114, -114,
-115, -114, -114, -114, -114, -114, -114, -115, -114, -114, -114, -114, -114,
-114, -115, -114, -114, -114, -114, -115, -114, -113, -114, -114, -114, -114,
-114, -114, -114, -114, -114, -114, -113, -114, -113, -114, -113, -114, -113,
-114, -114, -114, -114, -113, -113, -113, -113, -114, -114, -114, -114, -114,
-114, -114, -113, -113, -114, -113, -113, -114, -114, -113, -113, -113, -113,
-113, -113, -112, -113, -114, -113, -113, -113, -114, -112, -114, -113, -113,
-113, -113, -112, -113, -113, -113, -113, -113, -113, -114, -112, -114, -113,
-114, -113, -112, -113, -113, -113, -113, -113, -113, -112, -113, -113, -112,
-113, -113, -113, -112, -112, -111, -114, -112, -115, -110, -116, -86, -61, -70,
-66, -68, -66, -68, -66, -68, -66, -67, -67, -67, -68, -66, -68, -66, -67, -66,
-68, -66, -68, -67, -66, -67, -68, -66, -68, -66, -68, -65, -68, -65, -72, -52,
-17, -23, -20, -21, -21, -21, -21, -21, -22, -21, -22, -21, -21, -20, -22, -20,
-21, -20, -22, -19, -22, -20, };