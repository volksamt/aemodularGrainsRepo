#define DATA_LENGTH 512
#define DATA AKWF_vgame_0068

const PROGMEM int8_t DATA[DATA_LENGTH] = {23, 29, 26, 28, 26, 29, 27, 29, 27,
28, 27, 28, 39, 41, 40, 40, 40, 39, 41, 40, 40, 40, 40, 40, 40, 41, 39, 48, 57,
51, 60, 80, 80, 80, 80, 79, 80, 80, 79, 80, 80, 81, 78, 86, 94, 92, 93, 92, 92,
91, 93, 92, 92, 92, 92, 93, 91, 93, 92, 96, 107, 105, 105, 106, 71, 65, 68, 66,
67, 66, 67, 66, 67, 66, 67, 67, 79, 79, 79, 79, 80, 80, 79, 79, 79, 80, 79, 80,
79, 80, 77, 89, 93, 92, 94, 92, 92, 92, 91, 92, 91, 92, 91, 91, 92, 92, 94, 86,
78, 80, 78, 79, 78, 80, 79, 80, 79, 78, 78, 79, 79, 79, 80, 77, 65, 67, 65, 67,
102, 106, 105, 105, 104, 107, 106, 106, 105, 106, 105, 104, 91, 92, 92, 90, 92,
91, 92, 91, 91, 91, 92, 91, 91, 91, 90, 92, 81, 77, 79, 78, 79, 78, 78, 78, 79,
78, 78, 78, 78, 78, 80, 72, 64, 65, 64, 66, 66, 65, 66, 66, 66, 65, 67, 65, 67,
63, 67, 62, 52, 52, 52, 49, 15, 10, 13, 12, 14, 12, 13, 12, 14, 12, 12, 10, 0,
-1, -1, -1, -1, -1, -1, -1, -1, -1, 0, -1, -1, -2, 0, 0, -10, -16, -9, -26, -44,
-39, -41, -40, -41, -40, -41, -41, -40, -41, -39, -47, -54, -52, -54, -53, -53,
-54, -54, -53, -53, -53, -53, -53, -54, -53, -52, -56, -68, -64, -67, -63, -28,
-27, -28, -26, -28, -27, -27, -27, -27, -27, -27, -29, -41, -40, -40, -41, -40,
-41, -41, -41, -41, -40, -40, -41, -41, -41, -40, -40, -53, -52, -55, -41, -25,
-29, -26, -29, -26, -28, -27, -26, -27, -29, -26, -35, -41, -40, -41, -40, -41,
-41, -41, -40, -40, -41, -40, -41, -39, -41, -38, -45, -54, -53, -51, -57, -92,
-94, -91, -93, -91, -93, -92, -93, -91, -93, -90, -95, -106, -105, -105, -105,
-104, -105, -103, -106, -105, -105, -105, -105, -105, -105, -105, -106, -118,
-120, -118, -119, -119, -118, -119, -119, -119, -119, -119, -119, -118, -119,
-117, -120, -109, -104, -106, -105, -105, -105, -106, -103, -105, -104, -105,
-104, -106, -103, -106, -100, -90, -91, -92, -86, -52, -52, -53, -52, -53, -52,
-53, -52, -52, -51, -54, -50, -40, -39, -40, -39, -40, -40, -40, -39, -40, -39,
-40, -40, -39, -39, -40, -39, -28, -25, -27, -25, -27, -25, -27, -25, -25, -25,
-26, -26, -26, -27, -26, -26, -16, -11, -14, -11, -12, -12, -12, -12, -12, -12,
-12, -12, -12, -12, -14, -9, 2, -2, 3, -5, -39, -39, -38, -39, -38, -39, -39,
-39, -39, -39, -39, -37, -24, -27, -25, -25, -25, -27, -26, -25, -26, -23, -25,
-24, -27, -25, -25, -25, -13, -13, -10, -27, -43, -36, -40, -36, -39, -38, -39,
-39, -39, -39, -38, -39, -27, -24, -25, -25, -26, -25, -24, -25, -25, -25, -26,
-25, -25, -26, -25, -26, -18, -9, -14, -9, };