#define DATA_LENGTH 512
#define DATA AKWF_vgame_0089

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 0, 2, -1, 10, 11, 9, 11, 9, 19,
23, 22, 22, 20, 27, 31, 34, 34, 31, 35, 40, 44, 42, 43, 42, 50, 57, 55, 56, 55,
58, 66, 63, 65, 64, 67, 77, 77, 76, 77, 76, 79, 87, 85, 86, 85, 87, 98, 96, 98,
97, 97, 107, 107, 107, 107, 107, 115, 118, 118, 116, 118, 113, 106, 107, 107,
107, 105, 99, 95, 98, 96, 99, 90, 84, 86, 84, 88, 78, 75, 76, 76, 75, 76, 69,
62, 65, 62, 66, 58, 52, 56, 54, 57, 49, 42, 43, 42, 44, 40, 32, 34, 32, 30, 31,
23, 22, 21, 22, 19, 18, 7, 11, 6, 12, 0, -69, -64, -64, -64, -63, -71, -75, -77,
-76, -76, -74, -86, -85, -86, -85, -85, -96, -98, -94, -99, -94, -103, -108,
-105, -107, -105, -113, -115, -118, -119, -119, -115, -106, -107, -107, -106,
-105, -98, -97, -98, -96, -98, -92, -83, -85, -84, -85, -83, -76, -76, -75, -75,
-74, -70, -62, -65, -63, -64, -61, -51, -56, -54, -53, -52, -42, -42, -43, -42,
-42, -33, -33, -33, -33, -34, -24, -20, -21, -20, -22, -16, -11, -9, -11, -10,
-13, -2, 1, -1, 2, -1, 6, 9, 13, 9, 11, 13, 19, 23, 21, 23, 20, 29, 34, 29, 35,
32, 37, 45, 42, 45, 41, 47, 54, 52, 51, 57, 53, 44, 43, 45, 41, 46, 38, 33, 33,
37, 30, 37, 85, 84, 86, 86, 84, 79, 75, 74, 72, 74, 71, 65, 63, 65, 63, 64, 54,
54, 54, 52, 52, 45, 42, 44, 41, 44, 34, 33, 33, 31, 33, 31, 25, 20, 23, 20, 24,
14, 10, 12, 7, 13, 7, -2, 1, -1, 1, -3, -8, -10, -11, -9, -13, -18, -22, -21,
-22, -20, -27, -32, -30, -34, -32, -35, -43, -43, -42, -43, -42, -48, -55, -54,
-55, -52, -50, -43, -42, -43, -42, -42, -31, -32, -31, -31, -34, -22, -20, -21,
-21, -22, -14, -11, -12, -13, -10, -6, -1, 1, 0, 1, 0, 10, 11, 9, 11, 12, 17,
22, 21, 22, 20, 23, 30, 30, 30, 30, 32, 35, 46, 40, 45, 39, 48, 53, 54, 48, 59,
46, -6, 1, 0, -1, 1, 9, 12, 11, 13, 12, 18, 21, 23, 21, 22, 25, 35, 31, 32, 33,
32, 40, 44, 43, 43, 42, 48, 53, 53, 52, 52, 52, 44, 41, 44, 42, 44, 34, 29, 33,
33, 34, 27, 19, 23, 20, 23, 17, 11, 11, 8, 10, 7, 1, 0, 0, 0, 1, -4, -11, -10,
-13, -9, -13, -23, -21, -22, -21, -22, -28, -33, -33, -33, -34, -36, -43, -42,
-42, -42, -43, -55, -54, -54, -56, -53, -62, -64, -63, -65, -63, -72, -77, -76,
-77, -74, -80, -86, -86, -84, -85, -85, -92, -99, -96, -98, -95, -102, -107,
-106, -107, -104, -110, -115, -117, -119, -116, -116, -109, -106, -107, -105,
-107, -102, -93, -98, -95, -95, -87, -37, -21, -21, -21, -20, -10, -12, -12,
-11, -11, -10, };