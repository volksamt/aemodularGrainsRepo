#define DATA_LENGTH 512
#define DATA AKWF_vgame_0027

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 31, 41, 38, 38, 37, 39, 38, 39, 37,
38, 38, 40, 37, 41, 60, 62, 60, 62, 62, 61, 61, 61, 60, 70, 75, 73, 78, 84, 84,
83, 84, 83, 84, 84, 85, 83, 84, 84, 84, 88, 91, 95, 97, 95, 97, 96, 97, 96, 97,
96, 96, 96, 97, 96, 97, 99, 98, 99, 98, 97, 98, 97, 98, 102, 104, 102, 104, 103,
111, 113, 113, 112, 113, 113, 112, 112, 113, 113, 112, 117, 120, 116, 106, 108,
108, 108, 108, 108, 108, 108, 109, 107, 108, 107, 109, 93, 84, 88, 86, 88, 86,
87, 85, 71, 70, 72, 70, 72, 69, 61, 61, 62, 62, 62, 61, 62, 61, 62, 60, 51, 48,
52, 36, 26, 29, 27, 28, 27, 27, 28, 28, 28, 28, 27, 27, 6, -11, -9, -11, -9,
-10, -10, -10, -10, -10, -9, -9, -10, -9, -11, -13, -13, -13, -12, -13, -13,
-13, -13, -12, -15, -24, -21, -23, -43, -46, -44, -46, -45, -46, -44, -46, -43,
-47, -43, -49, -68, -74, -85, -83, -84, -83, -84, -84, -83, -84, -84, -84, -83,
-85, -83, -82, -81, -83, -80, -76, -77, -77, -77, -77, -77, -77, -77, -77, -77,
-76, -75, -76, -76, -76, -76, -76, -75, -76, -75, -77, -70, -65, -46, -33, -39,
-35, -37, -36, -39, -36, -38, -37, -38, -37, -38, -32, -8, -10, -10, -9, -10,
-10, -10, -10, 5, 15, 11, 14, 12, 19, 23, 22, 23, 23, 23, 23, 23, 22, 22, 23,
24, 26, 26, 25, 26, 25, 26, 26, 26, 25, 26, 25, 26, 26, 26, 26, 25, 24, 25, 23,
25, 23, 25, 24, 17, 14, 15, 14, 15, 14, 2, 0, 1, -1, 1, 0, 1, 0, 0, 0, -2, -3,
-2, -4, -3, -4, -3, -3, -4, -3, -3, -3, -3, -3, -3, -2, -6, -27, -32, -30, -31,
-30, -30, -30, -31, -30, -31, -29, -31, -29, -34, -44, -43, -44, -44, -44, -43,
-43, -43, -43, -46, -47, -47, -46, -52, -56, -54, -55, -55, -55, -54, -56, -55,
-55, -55, -55, -59, -60, -59, -59, -59, -60, -60, -59, -60, -60, -61, -62, -61,
-61, -61, -61, -61, -61, -61, -61, -61, -61, -61, -60, -60, -59, -59, -60, -60,
-58, -58, -58, -58, -57, -59, -58, -58, -58, -58, -57, -55, -55, -54, -53, -53,
-52, -53, -53, -53, -53, -53, -53, -53, -52, -54, -53, -48, -46, -46, -47, -47,
-47, -46, -48, -40, -30, -33, -31, -34, -29, -22, -23, -22, -23, -22, -22, -22,
-23, -22, -24, -21, -17, -18, -16, -15, -16, -16, -17, -16, -16, -16, -16, -16,
-16, -16, -16, -17, -19, -19, -19, -20, -19, -19, -20, -20, -20, -19, -19, -19,
-19, -21, -23, -22, -22, -22, -23, -23, -22, -22, -22, -22, -23, -23, -23, -25,
-24, -24, -24, -24, -24, -24, -24, -25, -24, -25, -25, -24, -21, -17, -19, -17,
-18, -18, -18, -17, -18, -18, -18, -18, -18, -17, -2, 1, -1, 1, 0, 0, -1, 0, 0,
};