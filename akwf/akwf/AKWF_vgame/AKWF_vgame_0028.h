#define DATA_LENGTH 512
#define DATA AKWF_vgame_0028

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 8, 4, 10, 28, 28, 27, 28, 28, 28,
27, 28, 28, 27, 46, 54, 49, 59, 68, 67, 67, 67, 67, 66, 66, 67, 67, 66, 70, 80,
78, 82, 86, 84, 85, 85, 85, 85, 86, 84, 86, 84, 89, 93, 92, 96, 97, 96, 96, 96,
97, 96, 96, 97, 97, 96, 97, 99, 101, 101, 102, 102, 101, 101, 101, 101, 101,
101, 102, 101, 101, 102, 114, 119, 118, 119, 119, 119, 119, 119, 120, 118, 118,
119, 119, 119, 108, 105, 106, 106, 106, 106, 106, 106, 107, 106, 107, 105, 107,
104, 85, 88, 86, 87, 85, 87, 83, 70, 73, 71, 73, 71, 72, 69, 63, 63, 63, 63, 64,
63, 64, 56, 53, 55, 54, 53, 55, 42, 37, 38, 37, 37, 38, 36, 38, 35, 12, 13, 12,
14, 12, -3, -5, -5, -5, -5, -4, -6, -4, -8, -11, -11, -12, -11, -12, -14, -14,
-14, -13, -13, -14, -13, -13, -13, -22, -25, -25, -23, -35, -46, -44, -45, -44,
-44, -44, -44, -45, -42, -49, -67, -65, -64, -81, -85, -84, -85, -85, -84, -85,
-85, -84, -85, -83, -83, -83, -82, -82, -81, -82, -81, -82, -81, -81, -82, -82,
-82, -80, -77, -76, -76, -75, -75, -75, -76, -72, -63, -64, -64, -63, -63, -64,
-63, -65, -47, -34, -40, -37, -39, -37, -39, -37, -37, -37, -37, -39, -21, -10,
4, 10, 6, 9, 7, 8, 8, 8, 8, 9, 8, 8, 8, 21, 26, 26, 26, 25, 27, 26, 27, 25, 26,
25, 27, 26, 26, 26, 26, 26, 27, 26, 27, 26, 26, 26, 27, 27, 27, 26, 26, 23, 22,
23, 23, 24, 22, 24, 21, 15, 14, 16, 14, 16, 13, 0, 1, 0, 0, 1, -1, 1, -2, -3,
-3, -3, -4, -4, -3, -2, -2, -2, -2, -1, -2, -2, -2, -5, -7, -6, -7, -5, -14,
-21, -19, -20, -19, -20, -19, -20, -17, -25, -36, -36, -36, -36, -44, -46, -45,
-45, -46, -46, -46, -46, -45, -46, -46, -48, -47, -50, -56, -55, -56, -56, -56,
-55, -55, -56, -55, -56, -60, -61, -60, -60, -58, -59, -58, -59, -59, -59, -58,
-59, -59, -59, -61, -61, -60, -62, -63, -62, -61, -63, -62, -62, -62, -62, -61,
-58, -59, -59, -59, -59, -59, -58, -59, -58, -59, -59, -59, -59, -59, -58, -59,
-55, -55, -54, -54, -53, -53, -54, -54, -54, -53, -54, -54, -55, -51, -50, -40,
-34, -37, -35, -37, -35, -35, -35, -36, -36, -36, -36, -37, -26, -19, -20, -19,
-20, -20, -19, -19, -20, -20, -20, -20, -19, -20, -18, -16, -16, -17, -16, -17,
-16, -15, -16, -17, -16, -17, -16, -17, -17, -16, -16, -16, -16, -16, -17, -16,
-19, -19, -19, -20, -20, -19, -23, -23, -23, -22, -22, -23, -23, -23, -22, -23,
-23, -24, -23, -23, -25, -24, -25, -24, -24, -24, -24, -25, -25, -25, -25, -25,
-25, -24, -23, -23, -23, -23, -22, -23, -22, -23, -23, -14, -12, -14, -14, -2,
};