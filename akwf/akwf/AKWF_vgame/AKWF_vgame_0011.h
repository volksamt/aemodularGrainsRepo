#define DATA_LENGTH 512
#define DATA AKWF_vgame_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 8, 5, 9, 31, 32, 31, 33, 32, 33,
32, 32, 31, 32, 31, 31, 32, 56, 73, 71, 72, 71, 72, 71, 71, 72, 71, 72, 71, 72,
70, 79, 88, 84, 86, 85, 87, 85, 86, 85, 87, 96, 95, 95, 96, 104, 106, 106, 107,
106, 107, 106, 107, 106, 107, 107, 105, 113, 115, 112, 114, 113, 112, 112, 113,
113, 112, 113, 112, 114, 113, 113, 113, 115, 114, 115, 114, 114, 114, 113, 115,
109, 106, 107, 106, 108, 101, 96, 98, 97, 97, 97, 97, 96, 98, 96, 98, 88, 77,
79, 66, 62, 64, 64, 64, 64, 63, 63, 64, 62, 65, 62, 64, 60, 46, 43, 45, 44, 45,
44, 46, 38, 29, 30, 30, 30, 32, 24, 13, 14, 15, 15, 15, 14, 15, 14, 16, 13, 0,
-1, 1, -4, -7, -6, -6, -6, -6, -8, -6, -7, -6, -9, -13, -12, -13, -11, -11, -11,
-11, -11, -12, -11, -12, -11, -11, -11, -12, -12, -11, -14, -14, -14, -15, -15,
-14, -14, -14, -15, -15, -13, -13, -13, -12, -12, -13, -13, -13, -13, -13, -13,
-13, -13, -12, -14, -9, -4, -1, 2, 0, 3, 2, 2, 1, 2, 1, 2, 2, 2, 2, 2, 10, 12,
10, 11, 11, 11, 11, 12, 9, 17, 22, 23, 21, 25, 36, 34, 36, 36, 35, 36, 35, 34,
35, 35, 34, 37, 44, 48, 53, 53, 53, 53, 53, 52, 52, 52, 53, 53, 52, 53, 53, 54,
54, 55, 54, 54, 54, 54, 54, 54, 52, 51, 52, 52, 52, 48, 47, 48, 47, 48, 48, 48,
47, 47, 48, 48, 44, 43, 41, 34, 36, 35, 34, 35, 34, 35, 35, 36, 34, 35, 34, 36,
32, 26, 27, 27, 27, 27, 27, 27, 23, 23, 22, 22, 22, 22, 21, 20, 20, 20, 20, 22,
21, 21, 21, 21, 17, 14, 15, 14, 12, 11, 11, 12, 11, 11, 11, 11, 11, 11, 12, 11,
11, 3, -4, -3, -3, -3, -3, -2, -3, -4, -4, -3, -2, -3, -2, -8, -13, -12, -13,
-12, -13, -11, -13, -11, -15, -24, -24, -24, -24, -30, -32, -32, -32, -31, -31,
-31, -32, -32, -33, -32, -32, -39, -42, -50, -51, -50, -51, -51, -51, -50, -52,
-50, -51, -50, -51, -51, -55, -64, -63, -64, -64, -64, -64, -64, -63, -69, -73,
-71, -72, -70, -78, -85, -84, -84, -84, -85, -84, -84, -84, -85, -83, -89, -98,
-96, -105, -106, -105, -107, -106, -106, -106, -106, -106, -106, -106, -107,
-106, -107, -113, -113, -112, -112, -112, -113, -113, -113, -115, -118, -117,
-118, -117, -119, -120, -119, -119, -119, -119, -119, -120, -120, -119, -119,
-118, -115, -117, -111, -107, -109, -108, -107, -109, -108, -108, -108, -108,
-108, -108, -110, -100, -85, -83, -84, -84, -84, -84, -85, -84, -85, -84, -85,
-83, -86, -81, -69, -68, -69, -68, -56, -51, -53, -52, -53, -51, -53, -52, -55,
-42, -27, -29, -29, -29, -29, -29, -29, -28, -28, -29, -28, -30, -18, };