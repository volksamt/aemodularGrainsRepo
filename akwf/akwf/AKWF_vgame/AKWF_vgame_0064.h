#define DATA_LENGTH 512
#define DATA AKWF_vgame_0064

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 23, 35, 43, 47, 49, 47, 44, 41, 38,
36, 34, 32, 32, 32, 32, 33, 33, 35, 36, 36, 38, 39, 38, 38, 38, 37, 35, 35, 35,
34, 35, 35, 35, 37, 36, 37, 37, 37, 36, 36, 35, 35, 35, 36, 35, 35, 36, 36, 37,
37, 37, 37, 36, 35, 35, 36, 35, 35, 35, 35, 35, 35, 35, 36, 35, 35, 35, 36, 35,
35, 35, 35, 35, 35, 35, 35, 35, 36, 35, 36, 35, 35, 35, 35, 35, 35, 35, 35, 36,
35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 36, 35, 35, 35, 35, 35, 35, 35,
35, 36, 35, 35, 35, 36, 35, 35, 35, 35, 36, 36, 35, 35, 36, 35, 36, 35, 34, 35,
35, 34, 35, 35, 35, 35, 36, 35, 34, 35, 34, 34, 35, 35, 35, 35, 35, 35, 34, 35,
35, 35, 35, 34, 35, 35, 35, 35, 36, 35, 35, 35, 35, 35, 35, 35, 36, 35, 35, 34,
35, 35, 35, 35, 34, 35, 35, 35, 35, 35, 34, 35, 35, 35, 35, 35, 35, 35, 35, 34,
35, 35, 35, 35, 35, 35, 34, 35, 34, 35, 34, 35, 34, 36, 35, 34, 34, 35, 35, 35,
34, 34, 35, 34, 35, 34, 34, 35, 34, 35, 35, 35, 35, 35, 34, 35, 35, 34, 35, 34,
34, 35, 34, 34, 35, 34, 34, 34, 35, 35, 35, 35, 34, 35, 35, 34, 34, 34, 34, 35,
35, 35, 35, 35, 34, 34, 35, 35, 35, 34, 34, 34, 35, 35, 34, 35, 34, 34, 35, 34,
34, 34, 35, 35, 34, 34, 35, 35, 34, 34, 34, 34, 34, 34, 34, 35, 34, 35, 34, 34,
34, 35, 34, 34, 34, 34, 35, 35, 35, 33, 35, 34, 34, 35, 35, 34, 34, 35, 34, 35,
33, 34, 35, 34, 34, 34, 34, 34, 35, 34, 35, 34, 34, 35, 34, 35, 34, 36, 35, 35,
35, 36, 35, 34, 34, 34, 34, 34, 35, 35, 35, 36, 37, 36, 35, 35, 35, 34, 32, 33,
33, 32, 33, 34, 36, 36, 37, 36, 36, 37, 36, 34, 34, 33, 32, 29, 30, 28, 29, 29,
33, 38, 43, 47, 51, 50, 48, 38, 26, 8, -12, -34, -57, -77, -92, -104, -112,
-115, -115, -114, -110, -108, -105, -101, -99, -99, -100, -101, -100, -100,
-101, -102, -103, -104, -105, -106, -105, -105, -105, -104, -102, -103, -102,
-103, -103, -103, -103, -105, -104, -104, -104, -103, -104, -103, -104, -103,
-102, -103, -102, -102, -103, -102, -104, -103, -103, -104, -103, -104, -103,
-103, -103, -103, -104, -103, -103, -102, -102, -102, -103, -103, -103, -104,
-103, -103, -103, -103, -103, -103, -103, -101, -101, -102, -102, -103, -103,
-103, -103, -102, -103, -103, -103, -102, -102, -103, -103, -103, -103, -103,
-103, -103, -102, -102, -103, -103, -103, -103, -103, -103, -103, -103, -104,
-103, -104, -104, -101, -99, -98, -95, -94, -95, -98, -102, -107, -114, -118,
-119, -117, -108, -95, -80, -50, -10, };