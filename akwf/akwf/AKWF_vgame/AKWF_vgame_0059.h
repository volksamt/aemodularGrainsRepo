#define DATA_LENGTH 512
#define DATA AKWF_vgame_0059

const PROGMEM int8_t DATA[DATA_LENGTH] = {102, 106, 99, 105, 100, 106, 100, 105,
101, 105, 102, 105, 101, 104, 101, 103, 102, 103, 102, 104, 103, 103, 107, 114,
114, 115, 115, 114, 115, 114, 114, 114, 115, 114, 115, 114, 115, 113, 116, 118,
120, 118, 120, 117, 120, 117, 120, 117, 122, 116, 121, 115, 123, 99, -69, -106,
-92, -99, -95, -98, -95, -97, -95, -98, -96, -97, -99, -87, -66, -71, -68, -70,
-69, -70, -69, -70, -69, -70, -71, -70, -71, -59, -55, -57, -56, -56, -56, -57,
-56, -56, -57, -56, -57, -56, -56, -54, -55, -55, -55, -54, -55, -54, -55, -47,
-42, -45, -43, -44, -42, -42, -42, -42, -42, -42, -41, -43, -42, -42, -38, -33,
-35, -33, -34, -33, -34, -34, -34, -34, -35, -34, -34, -35, -34, -34, -31, -27,
-27, -27, -27, -27, -27, -27, -27, -27, -27, -28, -27, -27, -28, -24, -21, -23,
-22, -23, -22, -23, -23, -23, -23, -22, -22, -22, -22, -19, -19, -20, -19, -19,
-20, -19, -19, -19, -19, -19, -20, -19, -14, -12, -14, -13, -14, -13, -13, -13,
-13, -13, -13, -13, -13, -13, -12, -11, -11, -12, -11, -11, -11, -12, -11, -10,
-10, -9, -10, -6, -3, -3, -3, -3, -3, -3, -4, -3, -3, -3, -3, -1, 0, 2, 1, 2, 2,
2, 2, 2, 2, 1, 2, 1, 2, 1, 5, 9, 8, 8, 8, 8, 8, 8, 8, 13, 14, 15, 15, 14, 20,
21, 21, 21, 20, 21, 21, 21, 21, 21, 20, 21, 21, 21, 21, 21, 21, 21, 20, 21, 21,
20, 20, 22, 21, 22, 21, 21, 21, 21, 20, 21, 21, 22, 21, 21, 21, 21, 21, 21, 21,
22, 21, 21, 21, 21, 21, 20, 20, 21, 21, 22, 23, 22, 22, 23, 22, 23, 22, 22, 23,
23, 22, 23, 22, 23, 23, 22, 23, 23, 23, 23, 22, 23, 23, 23, 22, 22, 23, 23, 22,
22, 23, 22, 23, 22, 23, 22, 22, 22, 22, 24, 24, 24, 24, 23, 24, 25, 25, 24, 24,
24, 25, 24, 24, 24, 25, 23, 22, 23, 22, 22, 22, 22, 22, 23, 23, 22, 23, 22, 22,
23, 19, 16, 16, 16, 16, 16, 16, 16, 15, 17, 17, 15, 16, 16, 13, 13, 13, 13, 13,
12, 12, 13, 12, 13, 13, 12, 13, 10, 8, 8, 8, 9, 9, 9, 8, 7, 8, 8, 8, 9, 7, 8, 8,
9, 8, 8, 9, 8, 9, 7, 4, 5, 5, 4, 5, 5, 5, 5, 5, 4, 4, 4, 5, 4, 6, 3, -2, -2, -2,
-2, -1, -2, -2, -1, -2, -2, -1, -2, -2, -1, -1, -2, -7, -7, -6, -7, -6, -7, -6,
-7, -5, -6, -6, -8, -4, -20, -35, -30, -34, -31, -33, -31, -34, -31, -31, -30,
-31, -31, -32, -79, -87, -82, -86, -82, -85, -83, -85, -83, -84, -83, -84, -83,
-80, -78, -79, -80, -79, -79, -78, -79, -78, -80, -77, -79, -78, -81, -78, -80,
-77, -80, -78, -79, -78, -78, -86, -18, };