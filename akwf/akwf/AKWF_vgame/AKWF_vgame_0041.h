#define DATA_LENGTH 512
#define DATA AKWF_vgame_0041

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 9, 10, 15, 20, 20, 23, 26,
29, 31, 35, 42, 47, 46, 48, 51, 54, 59, 61, 62, 63, 64, 66, 67, 71, 73, 72, 74,
77, 78, 79, 81, 82, 82, 83, 84, 84, 84, 86, 86, 88, 89, 89, 91, 93, 94, 92, 93,
95, 95, 94, 96, 97, 97, 96, 97, 98, 98, 98, 98, 98, 98, 98, 99, 100, 102, 104,
102, 103, 104, 104, 107, 109, 110, 111, 113, 115, 115, 117, 118, 119, 119, 119,
119, 119, 117, 115, 116, 114, 112, 109, 106, 104, 104, 101, 98, 96, 94, 91, 86,
84, 84, 81, 79, 75, 73, 72, 71, 69, 67, 67, 66, 64, 63, 62, 60, 61, 59, 55, 55,
54, 54, 52, 50, 48, 47, 43, 38, 38, 34, 31, 26, 20, 19, 17, 14, 12, 7, 6, 3, -1,
-3, -2, -6, -7, -8, -9, -10, -11, -11, -11, -11, -12, -11, -11, -13, -14, -15,
-15, -16, -18, -19, -20, -22, -24, -25, -29, -35, -36, -36, -39, -43, -47, -53,
-54, -56, -59, -61, -65, -68, -73, -78, -78, -78, -82, -82, -84, -83, -84, -84,
-84, -83, -82, -82, -83, -82, -82, -81, -80, -81, -80, -78, -79, -79, -77, -76,
-75, -75, -75, -76, -75, -75, -76, -74, -73, -72, -71, -69, -67, -65, -59, -57,
-58, -54, -51, -47, -45, -38, -33, -32, -29, -25, -23, -16, -10, -10, -9, -6,
-3, 0, 3, 9, 10, 12, 13, 14, 15, 19, 19, 19, 21, 23, 23, 24, 25, 25, 26, 25, 26,
26, 26, 26, 26, 25, 26, 25, 25, 26, 26, 25, 26, 26, 26, 26, 25, 24, 24, 23, 23,
22, 22, 20, 16, 16, 15, 12, 12, 9, 4, 2, 1, 1, 0, -1, -4, -3, -2, -3, -3, -4,
-4, -2, -2, -1, -1, -2, -2, -4, -3, -3, -4, -4, -6, -7, -7, -9, -13, -12, -14,
-18, -19, -25, -27, -27, -30, -32, -34, -35, -39, -43, -44, -44, -44, -44, -45,
-47, -47, -47, -47, -47, -46, -46, -48, -50, -49, -51, -54, -56, -55, -56, -56,
-58, -59, -60, -60, -60, -60, -59, -60, -60, -60, -59, -59, -60, -59, -60, -59,
-60, -60, -59, -62, -62, -61, -62, -61, -60, -59, -59, -59, -59, -59, -60, -59,
-57, -58, -58, -58, -58, -59, -59, -59, -56, -57, -56, -56, -56, -54, -55, -55,
-55, -55, -55, -53, -52, -53, -52, -52, -51, -52, -50, -49, -47, -46, -47, -44,
-42, -38, -37, -36, -35, -33, -31, -29, -27, -26, -24, -24, -24, -23, -21, -20,
-20, -20, -18, -18, -18, -18, -18, -17, -16, -16, -16, -16, -17, -16, -16, -17,
-17, -15, -16, -16, -16, -15, -16, -16, -16, -17, -19, -18, -18, -19, -19, -20,
-20, -21, -21, -23, -23, -23, -23, -23, -22, -23, -22, -23, -23, -23, -23, -23,
-22, -24, -24, -25, -23, -24, -24, -24, -25, -24, -25, -24, -24, -24, -24, -24,
-24, -22, -21, -21, -20, -19, -17, -16, -14, -10, -10, -8, -3, -4, 0, };