#define DATA_LENGTH 512
#define DATA AKWF_vgame_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 23, 20, 22, 21, 21, 20, 21, 20,
21, 19, 27, 36, 34, 48, 51, 50, 51, 50, 52, 51, 51, 49, 57, 66, 64, 75, 76, 75,
76, 76, 76, 76, 77, 75, 83, 88, 87, 88, 87, 87, 91, 94, 94, 94, 94, 93, 94, 100,
102, 102, 102, 101, 102, 110, 115, 114, 114, 114, 115, 114, 114, 114, 115, 114,
115, 112, 113, 113, 113, 112, 112, 112, 112, 113, 112, 112, 112, 111, 112, 111,
112, 104, 102, 103, 102, 103, 102, 104, 101, 96, 97, 97, 96, 98, 94, 84, 84, 85,
84, 85, 80, 70, 71, 72, 71, 73, 67, 62, 52, 45, 47, 46, 46, 47, 46, 46, 46, 48,
42, 34, 36, 33, 24, 23, 24, 24, 24, 23, 24, 23, 25, 14, 8, 10, 10, 6, -1, 1, -1,
1, 0, 0, 0, -3, -6, -4, -5, -5, -5, -10, -12, -10, -12, -11, -11, -12, -13, -12,
-13, -13, -13, -11, -12, -15, -13, -15, -14, -14, -14, -14, -14, -15, -14, -14,
-14, -14, -13, -13, -13, -13, -12, -12, -13, -12, -13, -15, -14, -14, -15, -14,
-8, -6, -1, -1, -2, -1, -2, -1, -1, -1, -2, -1, -3, 1, 3, 3, 3, 4, 2, 6, 13, 11,
11, 12, 10, 14, 19, 26, 30, 28, 29, 29, 29, 28, 29, 29, 28, 33, 38, 36, 38, 45,
45, 45, 44, 44, 44, 44, 44, 48, 50, 48, 50, 49, 51, 55, 54, 54, 54, 54, 54, 54,
54, 54, 54, 54, 53, 53, 50, 49, 49, 49, 49, 50, 49, 49, 49, 50, 49, 46, 45, 45,
41, 42, 41, 42, 41, 41, 42, 42, 42, 40, 34, 34, 35, 31, 29, 28, 29, 29, 29, 28,
29, 27, 24, 23, 24, 24, 23, 21, 23, 22, 23, 22, 23, 22, 20, 21, 21, 21, 21, 19,
13, 13, 13, 13, 13, 13, 13, 13, 12, 13, 13, 11, 10, 9, 5, 5, 5, 5, 5, 4, 6, 4,
5, 1, -3, -2, 0, -4, -8, -5, -6, -6, -7, -6, -6, -12, -15, -14, -14, -14, -14,
-20, -22, -22, -23, -22, -22, -29, -31, -30, -30, -30, -31, -31, -37, -43, -43,
-43, -43, -44, -43, -43, -43, -43, -43, -44, -52, -50, -56, -61, -60, -60, -61,
-61, -59, -61, -59, -62, -67, -66, -66, -67, -74, -75, -74, -76, -74, -75, -73,
-78, -84, -84, -83, -85, -83, -88, -93, -92, -92, -92, -91, -96, -103, -101,
-101, -102, -101, -105, -108, -111, -114, -112, -113, -113, -113, -113, -114,
-112, -113, -113, -115, -116, -116, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -117, -116, -116, -116, -116, -115, -116,
-115, -112, -110, -112, -110, -112, -110, -102, -100, -102, -101, -102, -101,
-95, -93, -94, -93, -94, -92, -86, -80, -72, -73, -73, -74, -73, -73, -73, -72,
-74, -71, -62, -61, -64, -51, -46, -48, -47, -48, -48, -47, -49, -44, -30, -32,
-31, -33, -28, -14, -14, -14, -15, -15, -13, -15, -8, };