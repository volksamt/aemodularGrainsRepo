#define DATA_LENGTH 512
#define DATA AKWF_vgame_0096

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 7, 8, 10, 11, 13, 14, 16,
18, 18, 20, 22, 22, 24, 26, 28, 29, 31, 32, 34, 35, 38, 38, 41, 41, 42, 44, 46,
47, 49, 51, 51, 53, 54, 55, 57, 59, 59, 61, 63, 64, 66, 66, 68, 68, 70, 73, 73,
74, 76, 78, 78, 80, 80, 82, 83, 84, 85, 87, 87, 88, 89, 90, 90, 91, 92, 93, 95,
95, 96, 98, 99, 99, 100, 101, 102, 102, 102, 103, 104, 104, 105, 106, 106, 107,
108, 109, 110, 110, 111, 110, 111, 111, 112, 113, 112, 114, 114, 114, 115, 115,
115, 117, 116, 117, 117, 118, 118, 118, 118, 118, 118, 119, 119, 118, 118, 119,
119, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 118, 118, 119,
118, 117, 117, 117, 117, 116, 117, 116, 117, 115, 116, 116, 114, 114, 114, 114,
114, 113, 113, 113, 112, 112, 111, 111, 110, 110, 109, 108, 108, 107, 106, 106,
105, 105, 104, 103, 103, 102, 102, 101, 101, 100, 100, 98, 97, 96, 96, 94, 94,
92, 92, 90, 91, 89, 88, 86, 87, 85, 84, 83, 81, 80, 79, 77, 77, 75, 74, 74, 72,
71, 70, 69, 67, 66, 64, 62, 62, 61, 59, 58, 57, 55, 55, 53, 51, 50, 48, 47, 45,
44, 43, 42, 40, 39, 37, 36, 34, 33, 31, 30, 28, 27, 26, 23, 22, 21, 19, 17, 16,
14, 13, 12, 9, 7, 5, 5, 3, 2, 0, -1, -4, -4, -6, -8, -9, -11, -13, -15, -16,
-18, -19, -20, -23, -24, -25, -27, -28, -30, -31, -32, -34, -36, -36, -38, -40,
-42, -42, -44, -46, -47, -48, -50, -52, -53, -54, -56, -57, -58, -60, -60, -62,
-64, -65, -67, -68, -70, -71, -71, -73, -74, -76, -77, -78, -79, -81, -82, -83,
-84, -85, -86, -87, -88, -89, -90, -90, -91, -92, -92, -93, -95, -95, -97, -97,
-97, -99, -99, -100, -101, -101, -102, -103, -103, -104, -105, -105, -106, -106,
-107, -107, -108, -109, -109, -110, -110, -111, -111, -111, -112, -112, -112,
-113, -114, -114, -113, -114, -115, -115, -115, -115, -116, -116, -117, -117,
-118, -117, -117, -116, -118, -117, -118, -118, -118, -118, -118, -117, -118,
-117, -117, -118, -117, -117, -117, -117, -117, -116, -116, -116, -116, -115,
-116, -115, -115, -115, -114, -114, -113, -114, -113, -113, -113, -112, -112,
-111, -110, -110, -109, -108, -109, -108, -108, -107, -107, -106, -106, -105,
-105, -104, -103, -103, -102, -101, -101, -101, -100, -99, -99, -97, -98, -96,
-95, -95, -93, -93, -92, -91, -90, -90, -88, -88, -86, -85, -85, -84, -83, -83,
-81, -80, -79, -78, -77, -75, -75, -73, -72, -71, -70, -68, -68, -66, -66, -64,
-62, -61, -61, -59, -57, -57, -55, -55, -54, -52, -51, -49, -48, -47, -46, -44,
-43, -41, -40, -38, -38, -35, -34, -33, -31, -30, -28, -27, -26, -23, -22, -21,
-20, -18, -16, -14, -13, -11, -9, -7, -6, -4, -3, -1, 0, };