#define DATA_LENGTH 512
#define DATA AKWF_vgame_0128

const PROGMEM int8_t DATA[DATA_LENGTH] = {22, 24, 23, 24, 22, 23, 22, 23, 22,
23, 22, 24, 22, 24, 23, 23, 23, 22, 22, 22, 23, 22, 25, 21, 25, 17, 41, 74, 66,
70, 67, 71, 68, 70, 68, 70, 68, 68, 69, 68, 110, 117, 114, 117, 114, 115, 114,
115, 114, 116, 114, 115, 116, 115, 115, 114, 115, 116, 115, 115, 115, 115, 115,
115, 115, 115, 115, 115, 114, 115, 115, 115, 115, 115, 114, 115, 114, 116, 113,
120, 90, 63, 71, 66, 70, 67, 69, 67, 70, 67, 70, 66, 70, 65, 23, 22, 22, 21, 23,
21, 23, 22, 22, 21, 22, 22, 22, 22, 22, 21, 22, 22, 22, 22, 21, 22, 21, 21, 22,
21, 22, 23, 22, 22, 23, 22, 21, 23, 21, 23, 21, 24, 17, 43, 72, 67, 69, 67, 69,
68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 69, 69, 68, 68, 68,
69, 68, 68, 68, 68, 68, 67, 68, 68, 68, 67, 68, 68, 68, 68, 68, 68, 68, 68, 67,
67, 68, 67, 68, 68, 68, 68, 68, 69, 34, 17, 24, 20, 22, 21, 22, 21, 22, 20, 22,
19, 26, 8, -27, -24, -26, -24, -26, -25, -26, -24, -25, -24, -25, -24, -22, -62,
-74, -71, -72, -70, -72, -71, -72, -70, -72, -71, -71, -71, -72, -70, -71, -71,
-71, -71, -71, -71, -72, -71, -71, -72, -71, -71, -71, -71, -71, -71, -72, -71,
-71, -70, -72, -70, -72, -70, -75, -52, -20, -26, -23, -26, -24, -25, -24, -25,
-24, -25, -24, -27, -23, 18, 23, 21, 23, 21, 22, 21, 22, 20, 23, 19, 25, 15, 45,
73, 66, 69, 67, 69, 68, 69, 67, 68, 67, 67, 68, 68, 68, 67, 68, 68, 68, 68, 68,
67, 68, 67, 68, 68, 68, 68, 67, 68, 67, 68, 67, 68, 67, 68, 66, 69, 66, 71, 62,
22, 20, 22, 21, 21, 21, 21, 21, 22, 20, 23, 20, 27, -8, -29, -22, -26, -24, -26,
-24, -26, -24, -26, -23, -27, -21, -33, -74, -70, -71, -71, -72, -72, -71, -72,
-71, -71, -71, -71, -71, -71, -70, -71, -71, -72, -71, -71, -71, -71, -71, -72,
-71, -72, -71, -71, -71, -71, -70, -71, -71, -71, -71, -70, -71, -71, -70, -71,
-72, -71, -71, -70, -71, -71, -71, -70, -72, -70, -72, -68, -76, -57, -22, -26,
-24, -25, -24, -26, -25, -24, -25, -25, -26, -24, -24, -24, -25, -24, -25, -24,
-25, -23, -26, -22, -25, -23, -27, -21, -40, -76, -69, -70, -71, -71, -71, -71,
-71, -70, -72, -71, -71, -70, -71, -70, -70, -70, -71, -70, -71, -71, -71, -72,
-69, -72, -66, -91, -118, -116, -117, -116, -117, -116, -117, -117, -117, -117,
-117, -116, -117, -116, -117, -117, -116, -116, -117, -116, -117, -116, -117,
-116, -117, -116, -117, -116, -118, -116, -117, -115, -118, -116, -117, -115,
-116, -116, -116, -111, -31, -19, -28, -21, -26, -23, -26, -23, -25, -23, -24,
-22, -27, -3, };