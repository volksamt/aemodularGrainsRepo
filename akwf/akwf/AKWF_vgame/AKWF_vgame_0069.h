#define DATA_LENGTH 512
#define DATA AKWF_vgame_0069

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 21, 40, 61, 80, 94, 108, 115, 118,
117, 114, 107, 100, 94, 92, 91, 93, 97, 101, 104, 106, 107, 107, 103, 102, 100,
98, 98, 99, 100, 101, 102, 103, 103, 102, 101, 101, 101, 100, 100, 99, 99, 100,
100, 100, 101, 103, 104, 105, 104, 103, 101, 99, 96, 95, 94, 95, 97, 101, 104,
108, 111, 112, 111, 106, 99, 89, 77, 62, 46, 27, 9, -8, -21, -31, -32, -32, -29,
-22, -14, -8, -5, -3, -6, -9, -16, -20, -22, -23, -21, -18, -15, -13, -11, -11,
-12, -15, -16, -17, -19, -19, -18, -16, -16, -14, -14, -13, -13, -15, -16, -17,
-17, -18, -18, -16, -15, -15, -14, -14, -15, -16, -16, -17, -17, -17, -17, -17,
-16, -16, -15, -15, -15, -16, -15, -17, -17, -16, -16, -16, -16, -15, -14, -15,
-15, -16, -16, -16, -17, -16, -16, -16, -15, -15, -15, -15, -15, -15, -16, -15,
-16, -17, -16, -16, -17, -16, -16, -16, -15, -15, -15, -15, -15, -16, -16, -15,
-15, -15, -15, -16, -16, -15, -15, -14, -15, -14, -16, -16, -15, -15, -16, -15,
-15, -16, -16, -15, -15, -15, -15, -15, -15, -15, -15, -14, -15, -15, -15, -14,
-15, -16, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -16, -15, -15, -15,
-15, -15, -15, -15, -15, -16, -15, -15, -16, -15, -15, -15, -14, -14, -15, -15,
-16, -17, -16, -15, -14, -15, -15, -16, -15, -15, -15, -16, -16, -16, -16, -17,
-16, -16, -15, -14, -14, -15, -15, -15, -15, -16, -15, -15, -16, -15, -16, -15,
-16, -15, -15, -14, -15, -15, -15, -15, -15, -15, -16, -16, -16, -15, -16, -15,
-14, -15, -15, -15, -15, -15, -16, -16, -16, -16, -15, -16, -16, -16, -16, -15,
-14, -15, -15, -15, -14, -14, -16, -16, -16, -16, -15, -16, -16, -15, -14, -15,
-15, -15, -15, -15, -15, -16, -16, -15, -15, -14, -15, -15, -15, -14, -15, -15,
-16, -16, -16, -16, -15, -16, -14, -15, -14, -15, -15, -15, -15, -15, -15, -15,
-14, -15, -15, -15, -14, -15, -14, -15, -15, -14, -14, -14, -15, -15, -14, -14,
-15, -15, -14, -15, -15, -15, -14, -15, -15, -15, -15, -14, -14, -14, -14, -15,
-15, -14, -14, -15, -15, -15, -15, -15, -15, -14, -15, -15, -14, -15, -15, -14,
-14, -14, -15, -14, -15, -15, -15, -14, -14, -15, -14, -15, -15, -15, -15, -14,
-15, -14, -15, -14, -15, -15, -16, -16, -15, -16, -16, -15, -14, -14, -15, -14,
-15, -15, -15, -16, -15, -15, -15, -15, -15, -15, -15, -15, -15, -16, -16, -16,
-16, -16, -16, -15, -13, -13, -14, -14, -15, -16, -17, -17, -16, -16, -15, -14,
-15, -14, -14, -14, -14, -15, -16, -17, -16, -16, -16, -14, -13, -12, -11, -13,
-14, -17, -17, -19, -19, -18, -15, -14, -11, -10, -10, -11, -14, -17, -21, -22,
-21, -20, -16, -11, -7, -4, -4, -7, -11, -17, -24, -29, -32, -30, -26, -18, -6,
};