#define DATA_LENGTH 512
#define DATA AKWF_vgame_0072

const PROGMEM int8_t DATA[DATA_LENGTH] = {43, 104, 117, 100, 95, 106, 104, 101,
102, 105, 101, 102, 104, 103, 101, 103, 103, 102, 102, 103, 101, 102, 103, 102,
102, 103, 103, 103, 102, 103, 103, 101, 103, 103, 103, 102, 102, 102, 102, 102,
103, 103, 102, 102, 103, 103, 103, 103, 102, 102, 102, 102, 103, 102, 103, 102,
103, 102, 102, 102, 102, 103, 102, 102, 102, 102, 102, 103, 102, 102, 102, 103,
102, 103, 102, 103, 102, 103, 102, 102, 103, 102, 102, 102, 101, 102, 103, 101,
102, 102, 102, 102, 103, 102, 102, 102, 102, 102, 101, 102, 101, 101, 101, 102,
101, 101, 103, 102, 101, 102, 102, 100, 100, 103, 101, 99, 102, 102, 98, 100,
105, 99, 98, 106, 102, 90, 107, 117, 82, 13, -44, -47, -25, -29, -42, -34, -29,
-37, -37, -33, -35, -36, -33, -33, -37, -34, -33, -35, -36, -34, -35, -37, -35,
-34, -36, -35, -35, -35, -34, -35, -34, -35, -35, -35, -34, -35, -34, -35, -34,
-35, -34, -35, -34, -34, -34, -34, -34, -34, -35, -35, -37, -34, -35, -36, -36,
-35, -35, -36, -36, -35, -34, -34, -35, -35, -35, -35, -35, -34, -35, -35, -35,
-35, -36, -36, -34, -35, -36, -35, -34, -36, -35, -34, -35, -35, -34, -35, -35,
-34, -34, -36, -35, -34, -34, -36, -34, -35, -35, -35, -35, -35, -35, -36, -35,
-34, -34, -35, -36, -34, -34, -35, -35, -34, -33, -35, -35, -34, -35, -35, -34,
-35, -36, -35, -34, -34, -35, -36, -35, -34, -34, -36, -34, -35, -35, -35, -34,
-34, -34, -35, -35, -35, -34, -36, -35, -33, -35, -36, -35, -34, -35, -34, -34,
-34, -35, -35, -34, -35, -35, -35, -34, -34, -35, -35, -34, -35, -36, -35, -34,
-34, -33, -34, -34, -36, -35, -35, -34, -35, -35, -34, -34, -35, -33, -33, -36,
-35, -34, -35, -35, -33, -35, -36, -35, -33, -35, -35, -34, -34, -34, -35, -34,
-33, -35, -35, -35, -34, -35, -34, -34, -33, -34, -35, -33, -34, -35, -34, -34,
-34, -34, -33, -35, -35, -34, -34, -34, -35, -35, -33, -35, -35, -34, -34, -35,
-35, -34, -34, -35, -34, -34, -35, -35, -34, -34, -34, -35, -35, -34, -34, -35,
-34, -33, -34, -35, -34, -34, -34, -35, -34, -34, -34, -36, -35, -33, -33, -35,
-36, -34, -34, -34, -34, -34, -34, -34, -33, -34, -35, -33, -33, -35, -35, -35,
-35, -33, -34, -35, -34, -33, -34, -35, -33, -34, -35, -34, -34, -35, -34, -34,
-33, -34, -34, -35, -35, -33, -33, -34, -35, -33, -33, -34, -35, -34, -34, -35,
-34, -34, -33, -33, -33, -35, -34, -33, -33, -34, -34, -34, -33, -35, -35, -34,
-33, -33, -35, -35, -34, -34, -34, -33, -33, -34, -34, -33, -34, -33, -33, -33,
-33, -34, -33, -33, -33, -34, -34, -33, -33, -34, -33, -33, -34, -33, -32, -34,
-33, -33, -33, -34, -34, -33, -33, -34, -34, -31, -34, -34, -32, -33, -35, -33,
-32, -38, -31, -24, -41, -46, -12, };