#define DATA_LENGTH 512
#define DATA AKWF_vgame_0042

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 17, 27, 34, 31, 33, 32, 32, 33, 32,
33, 32, 33, 32, 32, 32, 45, 48, 46, 47, 46, 47, 46, 47, 46, 47, 45, 59, 64, 64,
78, 77, 78, 78, 76, 78, 77, 78, 76, 77, 76, 79, 76, 84, 95, 93, 94, 93, 94, 92,
94, 93, 94, 92, 96, 107, 104, 112, 116, 115, 115, 116, 116, 116, 116, 116, 116,
116, 116, 116, 116, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 118, 116,
114, 114, 111, 111, 111, 111, 111, 110, 111, 111, 111, 110, 111, 111, 111, 110,
106, 106, 106, 107, 106, 105, 106, 106, 106, 105, 106, 101, 101, 99, 96, 97, 96,
96, 96, 96, 97, 96, 96, 96, 97, 96, 97, 92, 89, 90, 90, 91, 90, 90, 90, 90, 89,
91, 87, 85, 85, 80, 79, 79, 79, 78, 78, 79, 79, 78, 79, 78, 79, 79, 78, 72, 72,
72, 72, 72, 72, 72, 72, 72, 72, 72, 67, 67, 64, 58, 60, 59, 59, 60, 59, 60, 60,
60, 60, 59, 59, 60, 57, 53, 54, 52, 53, 52, 54, 54, 54, 53, 53, 50, 44, 46, 39,
36, 37, 36, 37, 37, 38, 37, 37, 37, 37, 36, 37, 37, 31, 30, 31, 30, 30, 30, 30,
30, 31, 30, 31, 24, 23, 21, 14, 16, 14, 15, 15, 15, 14, 14, 14, 15, 15, 14, 15,
12, 8, 9, 8, 7, 7, 9, 9, 8, 8, 8, 1, -1, 0, -4, -6, -6, -7, -6, -7, -6, -6, -7,
-6, -7, -6, -7, -6, -12, -16, -14, -15, -14, -15, -14, -15, -14, -13, -18, -24,
-21, -22, -28, -30, -29, -29, -29, -29, -29, -29, -29, -29, -28, -30, -28, -31,
-37, -37, -37, -36, -37, -37, -37, -36, -36, -37, -43, -44, -41, -47, -52, -51,
-52, -51, -52, -52, -52, -52, -52, -51, -51, -51, -51, -57, -60, -59, -60, -60,
-59, -60, -59, -60, -59, -62, -67, -65, -66, -71, -74, -71, -73, -72, -72, -73,
-73, -73, -73, -72, -72, -72, -73, -79, -79, -78, -79, -79, -79, -79, -78, -79,
-79, -84, -86, -85, -87, -91, -90, -90, -91, -90, -90, -91, -89, -94, -97, -97,
-97, -96, -97, -96, -96, -96, -96, -96, -97, -96, -96, -97, -98, -102, -101,
-101, -104, -106, -106, -106, -106, -106, -106, -106, -107, -107, -106, -107,
-106, -106, -110, -111, -111, -111, -110, -111, -111, -111, -110, -111, -114,
-116, -115, -117, -119, -119, -119, -120, -119, -118, -118, -119, -120, -119,
-120, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -120, -119,
-112, -110, -111, -112, -105, -98, -101, -99, -100, -100, -100, -100, -100,
-100, -100, -100, -100, -100, -88, -84, -86, -84, -85, -84, -86, -84, -87, -79,
-68, -69, -70, -68, -55, -54, -55, -55, -54, -55, -54, -54, -56, -55, -56, -54,
-57, -51, -38, -38, -38, -38, -39, -40, -39, -38, -40, -26, -22, -22, -24, -16,
-6, -9, -8, -9, -7, -9, -7, -9, -7, -8, -7, -9, -9, };