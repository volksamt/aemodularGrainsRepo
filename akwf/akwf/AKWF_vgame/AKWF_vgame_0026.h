#define DATA_LENGTH 512
#define DATA AKWF_vgame_0026

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 16, 14, 15, 14, 15, 13, 15, 12, 19,
41, 43, 40, 43, 61, 66, 64, 64, 63, 65, 63, 64, 64, 65, 63, 64, 62, 70, 78, 77,
78, 77, 78, 76, 78, 76, 78, 87, 87, 87, 86, 94, 95, 94, 95, 95, 95, 95, 94, 95,
96, 94, 96, 95, 96, 99, 98, 98, 98, 98, 98, 98, 98, 98, 102, 103, 103, 103, 112,
115, 114, 114, 114, 114, 113, 114, 114, 114, 114, 115, 113, 115, 119, 119, 119,
118, 119, 120, 118, 118, 105, 101, 103, 103, 104, 84, 78, 82, 80, 81, 81, 80,
80, 81, 79, 81, 80, 83, 75, 65, 66, 65, 66, 65, 65, 66, 66, 56, 55, 55, 54, 56,
37, 33, 35, 33, 34, 33, 34, 32, 35, 32, 35, 31, 37, 26, 2, 6, 5, 5, 4, 5, 4, 6,
-8, -12, -9, -11, -11, -13, -13, -13, -13, -13, -12, -13, -13, -13, -13, -13,
-13, -13, -34, -56, -52, -54, -53, -53, -53, -53, -53, -53, -53, -54, -54, -51,
-73, -83, -79, -81, -79, -81, -80, -81, -81, -80, -80, -81, -80, -81, -79, -78,
-79, -78, -79, -79, -79, -79, -79, -79, -78, -78, -80, -76, -76, -76, -75, -76,
-67, -63, -64, -65, -63, -65, -63, -66, -58, -31, -36, -32, -34, -34, -33, -34,
-34, -34, -33, -35, -33, -36, -11, 2, -3, -1, -3, -1, -2, -1, -1, -2, -1, -2, 0,
17, 27, 25, 26, 26, 26, 26, 26, 26, 26, 26, 25, 26, 26, 26, 26, 26, 25, 26, 26,
26, 26, 26, 26, 26, 25, 26, 24, 16, 16, 16, 16, 17, 16, 16, 17, 16, 16, 16, 16,
18, 5, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -2, -3, -3, -4, -3, -4, -3, -3, -4,
-3, -4, -3, -5, -1, -12, -19, -17, -19, -18, -18, -18, -18, -18, -18, -17, -18,
-18, -39, -48, -46, -47, -46, -47, -46, -48, -46, -47, -46, -47, -46, -46, -50,
-54, -53, -53, -53, -53, -53, -52, -54, -54, -53, -53, -58, -60, -58, -59, -60,
-59, -60, -60, -59, -60, -59, -59, -60, -59, -59, -61, -61, -61, -61, -61, -61,
-61, -61, -61, -61, -58, -58, -58, -58, -56, -56, -56, -56, -57, -57, -57, -57,
-56, -56, -56, -56, -56, -56, -55, -56, -55, -55, -55, -55, -55, -55, -55, -55,
-54, -52, -48, -35, -35, -36, -35, -36, -35, -35, -34, -37, -35, -36, -35, -37,
-28, -21, -23, -22, -23, -23, -23, -23, -22, -23, -22, -23, -19, -17, -16, -16,
-16, -17, -16, -16, -16, -16, -17, -16, -17, -16, -16, -16, -16, -16, -16, -15,
-16, -15, -16, -16, -17, -16, -16, -20, -21, -23, -23, -23, -22, -22, -23, -23,
-23, -22, -22, -22, -23, -22, -24, -24, -24, -24, -24, -24, -24, -24, -24, -24,
-24, -24, -24, -24, -18, -17, -18, -17, -18, -18, -18, -17, -18, -17, -19, -17,
-19, -9, 2, -1, 1, 0, 1, 0, 0, 0, 0, 0, -1, };