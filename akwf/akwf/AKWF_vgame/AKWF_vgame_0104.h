#define DATA_LENGTH 512
#define DATA AKWF_vgame_0104

const PROGMEM int8_t DATA[DATA_LENGTH] = {30, 63, 56, 58, 57, 59, 57, 59, 57,
60, 57, 61, 54, 66, 111, 107, 109, 108, 108, 109, 109, 109, 109, 108, 109, 109,
107, 115, 120, 119, 119, 119, 119, 119, 118, 120, 119, 121, 117, 121, 116, 122,
91, 57, 67, 62, 64, 63, 63, 62, 63, 62, 62, 63, 63, 63, 63, 62, 62, 63, 63, 62,
64, 62, 64, 59, 69, 44, -8, -3, -5, -2, -4, -3, -5, -3, -4, -4, -4, -4, -1, -26,
-32, -29, -31, -30, -31, -31, -30, -31, -31, -30, -31, -31, -29, -25, -26, -25,
-26, -25, -25, -26, -26, -26, -25, -26, -26, -26, -14, -11, -12, -11, -12, -12,
-12, -12, -11, -12, -13, -12, -12, -11, -12, -12, -12, -12, -11, -12, -12, -12,
-13, -12, -12, -12, -12, -24, -26, -25, -26, -26, -26, -24, -26, -24, -27, -24,
-28, -20, -44, -70, -62, -68, -64, -66, -64, -66, -65, -66, -64, -65, -64, -65,
-65, -65, -65, -66, -65, -64, -66, -65, -65, -64, -66, -65, -68, -46, -23, -29,
-27, -28, -28, -28, -28, -27, -28, -27, -28, -28, -29, -27, -28, -27, -28, -27,
-28, -28, -28, -27, -28, -28, -27, -31, -14, -5, -7, -7, -5, -18, -30, -26, -29,
-27, -28, -27, -28, -27, -28, -28, -28, -27, -27, -28, -28, -28, -27, -27, -28,
-29, -26, -34, -39, -38, -38, -39, -39, -39, -39, -39, -37, -38, -37, -40, -32,
-5, -6, -7, -6, -6, -6, -6, -6, -6, -6, -6, -6, -10, 23, 37, 33, 34, 33, 34, 33,
34, 32, 35, 33, 35, 32, 37, 45, 44, 44, 44, 44, 45, 45, 44, 44, 44, 44, 44, 46,
25, 18, 22, 19, 21, 19, 21, 20, 22, 20, 20, 20, 21, 20, 18, 18, 18, 17, 18, 18,
18, 18, 18, 18, 18, 18, 18, 33, 38, 36, 37, 35, 37, 36, 36, 37, 36, 36, 36, 37,
36, 36, 36, 37, 36, 37, 36, 37, 36, 37, 36, 36, 36, 36, 31, 30, 31, 31, 31, 31,
31, 30, 31, 30, 32, 30, 33, 23, 10, 14, 11, 13, 12, 12, 12, 13, 12, 13, 12, 12,
12, 18, 17, 17, 18, 17, 18, 17, 18, 16, 29, 35, 33, 34, 33, 34, 33, 34, 34, 34,
33, 34, 33, 35, 32, 35, 32, 35, 46, 46, 46, 48, 46, 46, 46, 46, 47, 46, 48, 43,
52, 19, -7, 2, -3, 1, -3, 0, -3, 0, -2, 0, -3, 1, -6, -39, -39, -37, -39, -38,
-39, -39, -38, -38, -39, -39, -39, -38, -42, -44, -44, -44, -44, -45, -45, -44,
-45, -44, -43, -44, -43, -46, -54, -55, -55, -54, -54, -55, -55, -55, -54, -55,
-55, -55, -54, -55, -54, -55, -55, -55, -55, -54, -55, -54, -55, -53, -55, -53,
-60, -80, -78, -79, -78, -78, -78, -78, -79, -78, -78, -78, -79, -78, -76, -74,
-77, -75, -76, -75, -76, -75, -77, -75, -76, -74, -81, -57, -15, -21, -19, -20,
-19, -20, -19, -20, -19, -20, -19, -21, -23, };