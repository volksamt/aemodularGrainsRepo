#define DATA_LENGTH 512
#define DATA AKWF_vgame_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 11, 9, 10, 17, 18, 21, 26, 24, 33,
34, 33, 37, 43, 41, 42, 49, 49, 53, 60, 58, 59, 64, 72, 71, 71, 72, 72, 75, 73,
79, 83, 82, 83, 86, 85, 87, 91, 90, 92, 94, 93, 96, 97, 97, 97, 102, 101, 105,
107, 109, 110, 110, 110, 111, 114, 113, 113, 115, 114, 115, 114, 113, 115, 113,
113, 113, 113, 113, 113, 113, 112, 114, 114, 114, 113, 113, 112, 111, 111, 112,
109, 105, 107, 103, 100, 102, 100, 97, 99, 94, 89, 90, 89, 89, 89, 82, 81, 81,
78, 75, 75, 69, 68, 67, 63, 64, 63, 63, 55, 56, 53, 48, 50, 48, 43, 43, 41, 32,
32, 31, 31, 32, 28, 23, 26, 24, 19, 19, 15, 13, 13, 8, 8, 8, 5, 2, 4, 3, 0, 0,
-2, -3, -3, -4, -7, -10, -9, -9, -10, -10, -12, -11, -13, -13, -13, -13, -13,
-13, -12, -11, -11, -11, -11, -10, -12, -14, -12, -13, -15, -14, -15, -15, -15,
-14, -15, -14, -14, -13, -14, -13, -12, -13, -14, -14, -14, -14, -12, -13, -10,
-9, -10, -9, -8, -9, -4, -2, -4, -2, -1, 1, 1, 2, 1, 4, 5, 5, 8, 8, 7, 9, 11,
11, 15, 20, 20, 20, 19, 20, 25, 26, 25, 28, 28, 29, 34, 33, 34, 37, 36, 37, 40,
42, 40, 43, 45, 45, 48, 48, 48, 49, 51, 52, 52, 53, 53, 54, 54, 54, 55, 54, 54,
53, 54, 53, 53, 53, 52, 53, 52, 52, 50, 51, 51, 50, 49, 49, 46, 46, 46, 46, 46,
46, 45, 43, 42, 41, 41, 41, 40, 39, 38, 36, 34, 35, 34, 33, 33, 29, 29, 29, 28,
27, 27, 25, 23, 23, 22, 22, 23, 22, 22, 23, 21, 21, 21, 21, 21, 21, 21, 19, 19,
16, 16, 16, 14, 15, 14, 12, 13, 12, 12, 11, 10, 10, 9, 10, 8, 8, 7, 4, 4, 5, 3,
3, 2, -3, -4, -3, -4, -3, -4, -7, -7, -7, -8, -10, -11, -14, -13, -17, -19, -19,
-20, -23, -23, -21, -25, -26, -26, -28, -28, -28, -32, -35, -35, -35, -35, -35,
-39, -38, -41, -44, -42, -43, -44, -44, -46, -52, -50, -51, -54, -54, -56, -61,
-61, -60, -64, -64, -65, -67, -68, -69, -69, -68, -70, -74, -73, -73, -76, -76,
-79, -83, -82, -83, -85, -85, -87, -92, -91, -91, -95, -95, -98, -101, -99,
-101, -103, -105, -108, -108, -108, -107, -109, -109, -112, -114, -113, -113,
-112, -113, -115, -118, -118, -117, -118, -119, -119, -119, -119, -120, -118,
-119, -119, -119, -119, -117, -117, -118, -117, -118, -117, -116, -113, -115,
-114, -113, -113, -111, -106, -105, -105, -105, -105, -103, -100, -100, -100,
-97, -96, -94, -89, -90, -88, -87, -89, -84, -79, -80, -79, -75, -74, -73, -69,
-71, -69, -64, -58, -58, -59, -59, -58, -52, -53, -48, -41, -44, -42, -37, -37,
-30, -24, -27, -24, -18, -18, -12, -6, -9, -6, -1, -2, };