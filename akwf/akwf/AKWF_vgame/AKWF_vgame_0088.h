#define DATA_LENGTH 512
#define DATA AKWF_vgame_0088

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 17, 18, 17, 18, 17, 18, 19, 17, 18,
18, 18, 18, 19, 16, 20, 35, 36, 34, 35, 34, 35, 35, 35, 35, 35, 35, 35, 34, 36,
33, 35, 49, 53, 51, 52, 51, 53, 51, 53, 51, 52, 51, 53, 51, 52, 51, 38, 47, 55,
50, 52, 50, 52, 51, 52, 51, 52, 51, 52, 51, 51, 67, 56, 60, 72, 67, 69, 68, 69,
68, 69, 68, 69, 69, 69, 68, 69, 67, 79, 87, 84, 87, 85, 87, 85, 85, 86, 85, 86,
85, 86, 85, 86, 83, 94, 104, 101, 102, 102, 102, 102, 103, 103, 103, 101, 103,
102, 102, 103, 102, 100, 107, 119, 118, 119, 119, 120, 119, 120, 119, 119, 119,
119, 119, 119, 119, 119, 116, 101, 102, 102, 102, 101, 102, 101, 102, 101, 101,
101, 102, 101, 103, 100, 85, 84, 85, 85, 84, 84, 85, 84, 85, 85, 84, 84, 85, 84,
86, 83, 68, 66, 67, 67, 67, 68, 68, 67, 67, 67, 67, 68, 67, 67, 67, 67, 68, 55,
50, 50, 50, 51, 50, 50, 50, 50, 49, 50, 50, 51, 49, 65, 57, 48, 51, 50, 51, 50,
50, 51, 51, 50, 49, 50, 50, 50, 52, 38, 32, 34, 33, 34, 33, 33, 32, 33, 33, 33,
33, 34, 33, 33, 34, 24, 14, 17, 16, 16, 15, 17, 16, 16, 16, 16, 16, 16, 16, 17,
16, 17, 10, -3, -1, -2, -1, -1, -1, -2, -1, -1, -1, -1, -2, 0, -2, 1, -5, -19,
-18, -18, -19, -18, -18, -19, -19, -19, -18, -18, -18, -18, -17, -21, -36, -34,
-34, -35, -35, -36, -35, -36, -35, -35, -35, -35, -35, -35, -35, -34, -36, -50,
-53, -52, -52, -52, -52, -52, -51, -53, -52, -52, -50, -53, -51, -37, -49, -54,
-51, -53, -51, -53, -51, -53, -51, -52, -51, -52, -51, -53, -67, -55, -63, -71,
-67, -69, -68, -70, -68, -69, -69, -69, -68, -69, -68, -68, -68, -81, -88, -85,
-86, -85, -85, -85, -86, -86, -86, -86, -85, -85, -86, -85, -86, -83, -95, -104,
-102, -103, -102, -102, -103, -103, -102, -102, -102, -103, -102, -102, -103,
-101, -109, -120, -119, -119, -119, -119, -118, -119, -119, -119, -118, -119,
-118, -120, -118, -120, -114, -101, -102, -101, -101, -101, -102, -102, -102,
-102, -102, -101, -102, -102, -103, -97, -84, -84, -84, -85, -85, -85, -85, -85,
-85, -84, -85, -84, -85, -85, -86, -82, -67, -67, -69, -67, -68, -67, -67, -67,
-67, -68, -68, -68, -68, -68, -67, -68, -68, -53, -50, -52, -50, -51, -50, -50,
-50, -49, -51, -50, -50, -49, -51, -66, -54, -48, -51, -50, -51, -49, -51, -49,
-51, -50, -50, -50, -50, -51, -51, -37, -32, -34, -33, -34, -34, -34, -33, -33,
-33, -34, -33, -33, -33, -33, -33, -35, -23, -14, -17, -16, -16, -15, -16, -16,
-16, -16, -17, -16, -16, -16, -16, -19, -8, 3, 0, 1, 1, 0, 1, 1, 1, 1, 1, 2, 1,
1, 1, -1, };