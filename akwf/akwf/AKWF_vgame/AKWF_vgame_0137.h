#define DATA_LENGTH 512
#define DATA AKWF_vgame_0137

const PROGMEM int8_t DATA[DATA_LENGTH] = {26, 21, 41, 78, 70, 75, 72, 73, 72,
73, 72, 73, 72, 72, 72, 72, 73, 72, 72, 72, 73, 72, 73, 72, 72, 71, 73, 72, 73,
72, 72, 72, 73, 73, 73, 73, 72, 73, 72, 73, 73, 72, 72, 72, 73, 73, 73, 72, 73,
72, 73, 71, 73, 71, 73, 71, 73, 70, 77, 119, 119, 118, 120, 118, 120, 118, 120,
118, 119, 118, 119, 118, 119, 118, 118, 119, 119, 118, 119, 118, 119, 119, 119,
118, 118, 119, 119, 118, 118, 119, 118, 119, 118, 118, 118, 119, 118, 118, 118,
119, 118, 118, 118, 118, 119, 118, 118, 119, 119, 118, 119, 119, 118, 118, 118,
119, 118, 118, 118, 118, 118, 118, 118, 119, 119, 118, 119, 118, 118, 118, 118,
118, 117, 118, 118, 118, 118, 118, 118, 118, 118, 118, 117, 117, 117, 118, 117,
118, 118, 117, 118, 118, 117, 118, 118, 118, 118, 117, 118, 117, 117, 118, 117,
117, 118, 118, 118, 117, 117, 117, 117, 118, 116, 118, 117, 117, 116, 117, 117,
117, 118, 116, 117, 117, 117, 118, 117, 117, 117, 117, 117, 116, 117, 117, 116,
117, 117, 117, 117, 116, 117, 117, 116, 117, 117, 116, 117, 117, 117, 117, 118,
116, 116, 116, 117, 117, 117, 116, 117, 116, 116, 116, 117, 116, 118, 116, 117,
115, 117, 116, 116, 116, 115, 117, 115, 118, 115, 118, 114, 118, 115, 119, 114,
119, 113, 119, 113, 119, 113, 118, 115, 118, 115, 114, 124, -88, -128, -108,
-124, -112, -123, -113, -122, -113, -121, -115, -120, -116, -120, -116, -119,
-116, -119, -117, -118, -118, -118, -118, -117, -118, -118, -118, -116, -118,
-118, -118, -117, -118, -117, -118, -117, -118, -118, -117, -117, -118, -118,
-117, -117, -117, -117, -117, -118, -118, -118, -118, -117, -118, -118, -117,
-117, -117, -117, -117, -118, -117, -117, -117, -118, -118, -117, -117, -118,
-118, -117, -117, -118, -117, -117, -118, -117, -118, -116, -117, -117, -117,
-116, -116, -118, -117, -117, -116, -117, -116, -116, -117, -116, -117, -117,
-118, -117, -117, -116, -116, -117, -116, -116, -117, -116, -116, -117, -117,
-117, -117, -116, -117, -116, -117, -117, -116, -117, -117, -117, -116, -117,
-117, -117, -116, -117, -116, -116, -116, -116, -117, -116, -117, -116, -115,
-116, -116, -116, -117, -116, -116, -116, -117, -116, -116, -116, -116, -117,
-117, -116, -116, -116, -115, -116, -116, -117, -116, -117, -116, -116, -116,
-116, -117, -115, -116, -116, -115, -116, -116, -116, -116, -116, -115, -116,
-115, -116, -116, -115, -116, -116, -116, -115, -115, -115, -116, -115, -115,
-115, -115, -116, -115, -116, -114, -116, -115, -115, -115, -116, -114, -117,
-113, -120, -95, -63, -71, -66, -69, -68, -69, -68, -68, -69, -68, -68, -69,
-69, -68, -68, -68, -69, -69, -68, -67, -68, -68, -69, -68, -68, -68, -68, -68,
-69, -68, -68, -69, -68, -67, -68, -68, -68, -68, -68, -67, -68, -67, -68, -68,
-69, -67, -69, -67, -70, -67, -70, -66, -70, -65, -72, -58, };