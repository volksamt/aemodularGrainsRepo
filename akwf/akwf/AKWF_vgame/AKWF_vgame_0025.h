#define DATA_LENGTH 512
#define DATA AKWF_vgame_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 9, 10, 12, 15, 17, 21, 25, 26, 28,
30, 33, 35, 36, 41, 46, 47, 49, 52, 54, 59, 62, 63, 63, 67, 70, 71, 73, 75, 76,
78, 81, 82, 83, 87, 87, 88, 90, 89, 92, 94, 94, 95, 95, 96, 98, 100, 101, 104,
106, 106, 107, 108, 110, 113, 113, 112, 113, 114, 114, 114, 115, 115, 113, 112,
113, 113, 113, 113, 113, 113, 113, 113, 114, 115, 113, 113, 112, 112, 111, 111,
108, 106, 105, 104, 103, 103, 101, 99, 97, 96, 96, 94, 90, 89, 85, 84, 83, 80,
78, 76, 75, 72, 69, 67, 66, 64, 63, 60, 54, 55, 54, 52, 50, 47, 44, 41, 39, 39,
37, 36, 33, 30, 28, 28, 26, 25, 20, 20, 17, 14, 12, 10, 8, 8, 6, 3, 2, 2, 1, 0,
-1, -3, -3, -3, -5, -5, -8, -8, -10, -11, -11, -10, -13, -12, -13, -13, -12,
-13, -12, -11, -11, -11, -11, -11, -13, -12, -12, -14, -15, -14, -14, -14, -15,
-14, -14, -15, -14, -14, -13, -13, -13, -12, -14, -14, -14, -14, -14, -13, -12,
-11, -10, -9, -8, -7, -6, -5, -3, -2, -1, -2, -1, 1, 1, 3, 6, 4, 6, 9, 9, 11,
11, 12, 14, 16, 17, 17, 19, 22, 23, 24, 26, 25, 29, 32, 32, 32, 33, 36, 36, 37,
41, 42, 42, 44, 44, 45, 46, 48, 47, 48, 50, 49, 52, 52, 52, 52, 54, 53, 54, 53,
54, 54, 53, 53, 53, 52, 52, 52, 53, 52, 50, 51, 51, 49, 49, 48, 47, 47, 48, 46,
44, 45, 45, 44, 43, 41, 42, 40, 39, 39, 38, 36, 36, 34, 33, 33, 32, 30, 30, 29,
27, 27, 26, 25, 25, 24, 24, 23, 22, 22, 22, 22, 20, 20, 21, 20, 21, 21, 20, 19,
18, 18, 17, 15, 15, 15, 15, 14, 12, 11, 12, 11, 11, 10, 10, 10, 8, 8, 9, 7, 7,
6, 4, 2, 2, 2, 0, -1, -4, -3, -2, -4, -5, -7, -10, -10, -11, -11, -14, -15, -16,
-19, -21, -21, -22, -24, -24, -26, -29, -28, -29, -30, -31, -32, -32, -34, -36,
-36, -37, -37, -38, -42, -44, -42, -44, -44, -46, -47, -50, -52, -53, -53, -56,
-58, -60, -63, -64, -64, -64, -65, -67, -67, -69, -69, -71, -72, -73, -74, -77,
-78, -79, -79, -82, -83, -84, -86, -89, -91, -90, -91, -93, -95, -98, -100,
-100, -100, -101, -104, -106, -106, -108, -108, -110, -111, -111, -111, -113,
-112, -113, -115, -114, -114, -115, -116, -118, -117, -118, -119, -119, -119,
-118, -119, -119, -119, -120, -119, -119, -117, -118, -118, -117, -118, -117,
-114, -114, -115, -112, -111, -110, -108, -107, -107, -105, -103, -102, -101,
-99, -97, -95, -95, -93, -92, -90, -86, -87, -85, -84, -82, -78, -76, -75, -72,
-72, -70, -69, -67, -63, -62, -61, -60, -57, -54, -53, -50, -43, -40, -40, -37,
-37, -33, -26, -24, -23, -20, -16, -15, -13, -8, -2, -2, -1, };