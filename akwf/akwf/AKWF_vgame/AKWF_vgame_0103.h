#define DATA_LENGTH 512
#define DATA AKWF_vgame_0103

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 6, 5, 5, 5, 5, 6, 5, 6, 6, 7, 5, 5,
29, 32, 32, 33, 32, 32, 32, 32, 31, 32, 31, 32, 32, 33, 31, 32, 31, 34, 29, 42,
54, 49, 52, 50, 51, 50, 51, 51, 51, 50, 51, 52, 51, 51, 50, 51, 50, 51, 49, 53,
38, 19, 23, 22, 22, 22, 22, 23, 22, 23, 21, 23, 21, 24, 40, 42, 40, 41, 41, 42,
41, 41, 41, 42, 40, 41, 40, 46, 51, 51, 51, 50, 51, 51, 51, 51, 51, 50, 51, 50,
51, 56, 55, 55, 56, 55, 55, 55, 55, 54, 56, 55, 55, 55, 56, 56, 55, 55, 56, 55,
55, 55, 55, 55, 56, 54, 55, 55, 53, 52, 52, 52, 53, 52, 53, 52, 53, 52, 53, 53,
53, 49, 47, 49, 48, 48, 48, 49, 49, 48, 47, 49, 47, 48, 46, 38, 38, 38, 38, 38,
39, 39, 39, 38, 38, 38, 38, 38, 39, 39, 38, 38, 39, 38, 38, 38, 39, 38, 39, 37,
39, 35, 28, 29, 28, 28, 28, 28, 28, 29, 29, 29, 29, 28, 29, 96, 121, 117, 120,
118, 120, 118, 120, 118, 120, 94, 81, 84, 83, 83, 84, 83, 83, 83, 84, 82, 83,
83, 83, 83, 83, 84, 55, 48, 51, 49, 50, 48, 50, 49, 51, 49, 51, 47, 53, 38, 18,
23, 21, 21, 21, 22, 20, 22, 20, 21, 22, 22, 20, -2, -6, -5, -6, -4, -6, -5, -6,
-5, -6, -5, -5, -7, 1, 11, 9, 9, 9, 10, 8, 9, 9, 9, 9, 9, 10, 9, 7, 6, 7, 7, 7,
6, 7, 7, 7, 6, 8, 5, 11, -10, -25, -20, -24, -20, -22, -22, -23, -21, -22, -21,
-22, -21, -24, -41, -41, -41, -42, -41, -42, -41, -42, -41, -41, -41, -41, -41,
-42, -40, -40, -41, -40, -41, -40, -41, -40, -41, -40, -42, -40, -45, -57, -58,
-58, -58, -58, -58, -58, -58, -57, -58, -58, -57, -59, -51, -47, -48, -48, -47,
-48, -48, -49, -48, -48, -47, -48, -47, -49, -56, -55, -56, -55, -55, -56, -55,
-55, -55, -55, -55, -55, -55, -57, -58, -58, -57, -57, -58, -57, -57, -58, -58,
-58, -57, -58, -57, -55, -55, -55, -55, -54, -56, -54, -55, -55, -55, -55, -54,
-55, -50, -50, -50, -50, -49, -50, -50, -50, -49, -52, -48, -54, -44, -66, -101,
-96, -99, -96, -98, -98, -97, -97, -97, -97, -97, -97, -98, -75, -69, -73, -69,
-72, -70, -73, -70, -72, -71, -72, -69, -74, -63, -44, -48, -47, -47, -48, -48,
-47, -47, -47, -46, -47, -47, -47, -47, -47, -47, -47, -47, -47, -47, -47, -47,
-46, -48, -46, -50, -36, -25, -26, -25, -25, -26, -26, -26, -25, -26, -25, -26,
-25, -26, -50, -52, -51, -53, -51, -53, -51, -52, -51, -53, -51, -52, -51, -52,
-51, -52, -52, -52, -52, -52, -51, -52, -51, -51, -51, -53, -49, -20, -17, -19,
-17, -19, -18, -19, -17, -18, -19, -19, -18, -20, -6, };