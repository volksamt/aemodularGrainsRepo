#define DATA_LENGTH 512
#define DATA AKWF_vgame_0131

const PROGMEM int8_t DATA[DATA_LENGTH] = {13, 81, 69, 72, 71, 70, 72, 70, 72,
71, 72, 70, 71, 70, 71, 70, 71, 70, 72, 71, 71, 70, 71, 70, 71, 71, 72, 71, 71,
71, 71, 71, 71, 72, 71, 71, 71, 71, 71, 71, 71, 71, 70, 71, 70, 71, 71, 72, 70,
70, 70, 71, 70, 71, 70, 70, 70, 71, 71, 70, 71, 71, 71, 71, 71, 70, 70, 70, 70,
70, 70, 71, 70, 71, 71, 70, 71, 70, 70, 70, 71, 71, 71, 70, 70, 70, 71, 70, 71,
70, 71, 70, 71, 71, 70, 71, 70, 70, 70, 71, 70, 70, 71, 71, 71, 70, 70, 72, 70,
71, 70, 71, 70, 72, 69, 72, 67, 76, 118, 116, 117, 116, 117, 117, 117, 117, 116,
118, 117, 117, 116, 117, 117, 117, 117, 117, 116, 117, 117, 117, 116, 116, 116,
116, 117, 116, 117, 116, 116, 116, 117, 117, 117, 116, 117, 116, 116, 117, 117,
117, 116, 116, 117, 116, 116, 116, 116, 116, 115, 116, 117, 116, 116, 116, 116,
116, 116, 116, 116, 116, 116, 116, 116, 116, 116, 116, 117, 116, 116, 115, 116,
116, 116, 116, 116, 116, 116, 116, 116, 116, 115, 115, 116, 116, 116, 116, 116,
116, 116, 116, 116, 115, 115, 116, 116, 116, 115, 116, 116, 115, 116, 115, 115,
114, 116, 116, 116, 115, 116, 115, 116, 115, 116, 115, 116, 115, 115, 116, 115,
116, 115, 116, 114, 117, 114, 117, 113, 119, 112, 119, 110, 121, 109, 123, 104,
127, 65, -128, -113, -122, -118, -119, -120, -118, -120, -117, -121, -117, -121,
-116, -120, -117, -121, -118, -120, -119, -120, -119, -119, -119, -119, -118,
-119, -119, -119, -118, -118, -119, -119, -119, -119, -119, -118, -119, -118,
-120, -118, -119, -118, -120, -118, -120, -119, -119, -119, -119, -119, -120,
-119, -119, -118, -118, -118, -119, -119, -118, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -118, -119, -118, -118, -119, -118, -118, -119, -118,
-118, -118, -118, -118, -118, -118, -119, -118, -118, -119, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -118, -118, -118, -119, -118, -118, -118,
-118, -117, -118, -119, -118, -118, -117, -118, -118, -117, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -117, -117, -118, -118, -118, -117, -118,
-117, -118, -116, -118, -116, -119, -116, -119, -109, -69, -71, -71, -70, -72,
-70, -71, -70, -71, -70, -71, -70, -71, -70, -70, -71, -71, -70, -71, -70, -71,
-70, -71, -70, -71, -71, -71, -70, -70, -70, -71, -70, -70, -71, -70, -70, -69,
-71, -70, -70, -70, -71, -71, -70, -71, -70, -71, -70, -70, -70, -70, -70, -70,
-69, -69, -70, -70, -71, -70, -69, -70, -70, -70, -70, -69, -70, -69, -70, -70,
-70, -70, -69, -69, -69, -70, -70, -70, -69, -69, -69, -70, -70, -70, -69, -70,
-70, -70, -69, -70, -69, -70, -70, -70, -69, -69, -70, -70, -69, -70, -70, -70,
-70, -69, -70, -68, -71, -68, -71, -69, -72, -68, -72, -67, -73, -66, -73, -69,
};