#define DATA_LENGTH 512
#define DATA AKWF_vgame_0062

const PROGMEM int8_t DATA[DATA_LENGTH] = {41, 120, 117, 119, 119, 119, 118, 119,
120, 118, 121, 118, 120, 114, 110, 102, 100, 101, 100, 101, 100, 100, 101, 100,
101, 101, 100, 100, 100, 99, 99, 99, 94, 93, 94, 93, 95, 94, 94, 94, 94, 94, 93,
94, 95, 93, 87, 88, 82, 76, 77, 76, 76, 75, 76, 75, 76, 75, 76, 75, 76, 75, 70,
69, 66, 61, 63, 61, 62, 62, 62, 62, 63, 63, 62, 63, 62, 62, 52, 47, 48, 43, 44,
43, 44, 44, 44, 44, 43, 44, 43, 44, 43, 45, 35, 24, 27, 25, 25, 25, 25, 25, 25,
25, 25, 26, 24, 26, 24, 26, 20, 7, 8, 9, 8, 8, 8, 8, 9, 9, 9, 9, 7, 10, 2, -2,
-2, -2, -1, -4, -6, -5, -5, -5, -5, -4, -5, -5, -4, -5, -4, -5, -10, -12, -11,
-12, -14, -13, -14, -14, -14, -13, -14, -13, -14, -14, -13, -13, -16, -19, -17,
-18, -18, -18, -18, -19, -19, -18, -19, -18, -19, -18, -19, -18, -20, -23, -24,
-24, -24, -23, -24, -23, -24, -24, -24, -24, -23, -23, -24, -24, -24, -27, -27,
-27, -27, -27, -26, -27, -26, -27, -27, -27, -26, -27, -26, -27, -30, -30, -30,
-30, -30, -30, -29, -30, -31, -30, -30, -30, -30, -31, -30, -31, -30, -33, -33,
-34, -34, -33, -34, -33, -33, -33, -34, -33, -34, -34, -33, -33, -33, -35, -37,
-36, -37, -37, -38, -36, -37, -37, -37, -37, -36, -38, -37, -37, -37, -37, -37,
-37, -36, -37, -37, -38, -37, -36, -37, -37, -36, -37, -37, -37, -37, -37, -37,
-36, -36, -37, -36, -37, -37, -37, -36, -37, -36, -37, -37, -36, -38, -37, -37,
-37, -37, -36, -37, -36, -37, -36, -37, -35, -37, -35, -40, -19, 29, 25, 26, 26,
23, 24, 23, 24, 23, 24, 23, 24, 23, 24, 24, 24, 24, 21, 17, 18, 18, 18, 18, 19,
19, 19, 18, 19, 19, 19, 19, 18, 17, 17, 14, 13, 13, 13, 13, 13, 13, 13, 13, 13,
14, 14, 13, 14, 14, 13, 12, 11, 12, 12, 13, 11, 11, 12, 12, 11, 12, 12, 10, 3,
3, 6, -24, -39, -35, -38, -36, -37, -36, -37, -37, -37, -37, -37, -37, -37, -37,
-37, -38, -37, -36, -37, -36, -36, -38, -36, -36, -37, -37, -36, -37, -36, -37,
-37, -36, -37, -38, -37, -36, -37, -37, -36, -37, -36, -37, -36, -37, -37, -37,
-37, -36, -37, -37, -37, -37, -38, -37, -37, -37, -37, -37, -37, -36, -37, -37,
-36, -37, -36, -37, -37, -37, -37, -37, -37, -37, -37, -38, -37, -37, -37, -37,
-37, -37, -37, -38, -37, -37, -37, -36, -37, -37, -36, -37, -36, -37, -37, -37,
-37, -36, -37, -37, -37, -36, -37, -37, -37, -37, -37, -37, -37, -36, -37, -37,
-36, -35, -36, -36, -35, -35, -35, -35, -35, -34, -35, -36, -35, -35, -35, -36,
-35, -35, -35, -36, -34, -36, -35, -36, -35, -35, -35, -36, -34, -38, -29, 2,
-3, };