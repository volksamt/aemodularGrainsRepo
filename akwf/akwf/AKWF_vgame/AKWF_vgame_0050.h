#define DATA_LENGTH 512
#define DATA AKWF_vgame_0050

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 7, 9, 8, 8, 12, 21, 22, 22,
22, 23, 22, 24, 29, 28, 28, 28, 34, 35, 36, 42, 40, 42, 40, 42, 49, 50, 48, 49,
55, 57, 55, 59, 62, 62, 61, 64, 70, 70, 70, 70, 74, 75, 74, 74, 80, 84, 89, 89,
89, 89, 88, 90, 93, 94, 93, 94, 98, 101, 99, 103, 107, 107, 107, 106, 109, 110,
109, 110, 114, 114, 114, 117, 117, 117, 117, 118, 117, 118, 118, 117, 116, 116,
117, 115, 114, 115, 114, 113, 113, 112, 113, 112, 111, 111, 111, 110, 109, 109,
110, 109, 106, 105, 105, 105, 105, 105, 106, 103, 103, 104, 104, 102, 101, 102,
98, 98, 98, 99, 99, 97, 96, 97, 98, 96, 95, 95, 95, 94, 92, 92, 92, 89, 89, 89,
89, 87, 87, 87, 87, 85, 84, 82, 82, 83, 83, 83, 83, 80, 79, 79, 79, 77, 75, 77,
74, 73, 72, 73, 73, 71, 72, 72, 72, 69, 68, 69, 67, 65, 64, 63, 64, 63, 63, 63,
63, 61, 60, 60, 59, 57, 57, 56, 54, 55, 54, 54, 54, 51, 50, 51, 49, 47, 47, 47,
47, 43, 41, 41, 42, 42, 42, 42, 40, 37, 38, 38, 36, 34, 36, 33, 32, 32, 31, 32,
30, 28, 29, 29, 27, 25, 25, 26, 24, 23, 22, 22, 20, 19, 19, 20, 18, 16, 16, 16,
15, 13, 9, 8, 8, 8, 8, 8, 6, 6, 6, 7, 5, 1, 2, 1, -1, -1, -1, -2, -3, -3, -3,
-3, -5, -9, -8, -9, -10, -13, -15, -14, -15, -14, -15, -14, -16, -19, -17, -19,
-20, -20, -21, -23, -24, -23, -24, -24, -26, -28, -26, -28, -30, -31, -30, -31,
-34, -36, -36, -37, -36, -38, -36, -37, -40, -39, -39, -40, -43, -43, -45, -47,
-46, -46, -45, -47, -49, -50, -49, -50, -53, -53, -52, -52, -55, -56, -55, -57,
-59, -59, -59, -60, -62, -62, -62, -62, -64, -65, -67, -66, -66, -67, -66, -69,
-70, -69, -70, -71, -73, -73, -73, -76, -76, -77, -76, -78, -78, -79, -77, -79,
-81, -81, -81, -83, -84, -86, -86, -85, -86, -86, -85, -86, -92, -92, -92, -92,
-92, -92, -93, -95, -93, -93, -93, -95, -96, -96, -96, -98, -98, -98, -98, -100,
-103, -103, -104, -103, -103, -103, -104, -104, -105, -105, -104, -106, -107,
-107, -111, -109, -111, -109, -110, -111, -110, -111, -112, -113, -113, -113,
-114, -114, -115, -113, -115, -116, -116, -116, -116, -117, -117, -117, -117,
-119, -118, -118, -118, -118, -118, -118, -116, -117, -116, -116, -115, -112,
-111, -112, -108, -106, -105, -107, -105, -101, -101, -102, -101, -96, -96, -97,
-91, -88, -84, -83, -84, -84, -85, -85, -82, -76, -77, -76, -71, -70, -70, -67,
-63, -64, -63, -64, -62, -57, -57, -56, -50, -48, -50, -49, -45, -37, -36, -36,
-36, -36, -36, -37, -30, -29, -29, -29, -25, -23, -23, -15, -15, -16, -17, -14,
-9, -8, -8, -8, -3, -3, -3, -4, 0, };