#define DATA_LENGTH 512
#define DATA AKWF_vgame_0061

const PROGMEM int8_t DATA[DATA_LENGTH] = {49, 121, 116, 120, 118, 119, 118, 119,
119, 119, 120, 118, 120, 118, 119, 103, 100, 101, 100, 100, 101, 101, 101, 100,
101, 100, 101, 101, 100, 99, 95, 95, 95, 96, 95, 96, 94, 93, 94, 94, 94, 94, 94,
93, 94, 94, 95, 94, 94, 93, 96, 81, 74, 77, 74, 76, 75, 76, 75, 77, 75, 76, 75,
76, 75, 65, 61, 63, 62, 62, 61, 62, 62, 62, 62, 61, 63, 61, 64, 57, 43, 44, 44,
43, 44, 44, 44, 44, 44, 44, 44, 44, 43, 45, 33, 25, 27, 27, 26, 25, 25, 24, 25,
25, 25, 26, 25, 25, 24, 25, 24, 27, 17, 6, 9, 7, 9, 8, 9, 9, 8, 9, 8, 9, 8, 9,
-1, -6, -4, -6, -5, -5, -5, -5, -5, -5, -4, -5, -5, -6, -12, -13, -13, -13, -13,
-13, -14, -13, -14, -13, -13, -13, -12, -14, -18, -19, -19, -18, -18, -19, -18,
-19, -18, -19, -19, -19, -18, -20, -21, -20, -20, -20, -20, -19, -20, -21, -20,
-21, -20, -20, -22, -24, -23, -24, -24, -24, -23, -24, -23, -23, -24, -23, -23,
-22, -26, -27, -27, -27, -26, -27, -26, -26, -26, -27, -27, -26, -27, -27, -26,
-30, -31, -31, -31, -30, -30, -30, -31, -30, -30, -30, -30, -30, -31, -34, -33,
-33, -34, -34, -33, -34, -33, -33, -33, -33, -34, -33, -33, -33, -33, -33, -34,
-33, -34, -34, -36, -36, -37, -37, -36, -36, -37, -37, -36, -37, -37, -37, -37,
-37, -36, -38, -36, -37, -36, -37, -37, -36, -36, -37, -37, -37, -37, -37, -37,
-38, -37, -37, -37, -37, -36, -37, -37, -37, -36, -37, -36, -37, -36, -37, -36,
-36, -37, -38, -38, -37, -37, -37, -37, -37, -38, -36, -38, -35, -36, -30, -41,
-3, 30, 19, 26, 22, 24, 22, 25, 23, 23, 23, 24, 23, 24, 20, 18, 18, 19, 19, 18,
18, 18, 19, 18, 19, 18, 19, 18, 14, 13, 13, 13, 14, 13, 13, 13, 13, 13, 14, 13,
14, 13, 11, 11, 11, 11, 12, 12, 13, 11, 12, 12, 12, 11, 12, 9, 2, 4, 3, 4, 3, 4,
3, 4, 2, 4, 2, 8, -14, -42, -35, -38, -36, -37, -37, -37, -37, -36, -37, -36,
-36, -37, -37, -37, -38, -37, -38, -37, -37, -36, -37, -37, -37, -37, -37, -36,
-37, -37, -37, -37, -37, -36, -37, -38, -36, -37, -36, -37, -37, -36, -38, -36,
-37, -36, -37, -37, -36, -37, -37, -37, -37, -37, -37, -36, -37, -36, -36, -37,
-37, -38, -36, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -36, -37,
-37, -37, -37, -37, -38, -37, -37, -37, -37, -37, -37, -37, -37, -37, -36, -37,
-37, -36, -37, -37, -36, -37, -37, -36, -37, -37, -37, -37, -38, -36, -37, -37,
-37, -37, -38, -36, -35, -35, -35, -35, -36, -35, -35, -35, -35, -36, -35, -35,
-36, -36, -35, -36, -35, -36, -35, -37, -34, -37, -33, -37, -32, -38, -41, };