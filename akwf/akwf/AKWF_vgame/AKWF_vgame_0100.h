#define DATA_LENGTH 512
#define DATA AKWF_vgame_0100

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 46, 40, 41, 40, 40, 41, 40, 41,
39, 41, 40, 42, 40, 41, 40, 40, 40, 41, 40, 41, 41, 40, 40, 40, 40, 40, 40, 40,
41, 40, 41, 40, 41, 40, 41, 40, 40, 40, 41, 41, 40, 41, 41, 40, 40, 40, 40, 40,
41, 40, 41, 41, 40, 40, 41, 40, 40, 40, 40, 41, 40, 40, 41, 40, 40, 41, 40, 40,
40, 40, 40, 40, 40, 39, 40, 40, 40, 40, 39, 40, 40, 40, 40, 40, 40, 40, 40, 40,
40, 40, 40, 40, 40, 40, 40, 40, 40, 39, 40, 39, 40, 40, 39, 40, 41, 40, 39, 40,
40, 40, 39, 40, 40, 39, 40, 39, 40, 39, 40, 40, 40, 39, 39, 39, 40, 40, 39, 39,
40, 39, 40, 40, 39, 39, 39, 39, 40, 40, 39, 39, 39, 39, 39, 39, 40, 39, 40, 39,
39, 38, 39, 39, 39, 40, 39, 39, 39, 38, 40, 39, 39, 39, 40, 39, 40, 39, 39, 39,
39, 39, 39, 39, 38, 38, 39, 39, 39, 39, 40, 39, 40, 39, 39, 38, 38, 38, 39, 39,
39, 38, 39, 38, 39, 39, 40, 38, 39, 38, 38, 37, 40, 40, 35, 89, 119, 114, 117,
115, 117, 116, 117, 116, 116, 116, 116, 117, 115, 116, 115, 117, 115, 116, 115,
117, 115, 117, 115, 116, 114, 117, 115, 116, 115, 116, 115, 114, 116, 113, 120,
107, 127, 15, -55, -32, -45, -36, -44, -38, -42, -38, -41, -38, -40, -39, -41,
-39, -39, -40, -40, -40, -41, -40, -40, -39, -41, -39, -42, -34, -78, -125,
-113, -121, -116, -119, -116, -118, -117, -118, -116, -117, -118, -118, -118,
-116, -117, -116, -119, -116, -118, -116, -119, -116, -119, -115, -121, -80,
-33, -42, -39, -40, -39, -40, -39, -40, -40, -38, -39, -38, -40, -39, -40, -40,
-39, -39, -40, -39, -39, -39, -40, -39, -39, -39, -40, -39, -40, -39, -38, -39,
-39, -39, -39, -39, -38, -39, -39, -39, -39, -39, -38, -40, -39, -39, -39, -38,
-39, -39, -38, -39, -39, -39, -39, -39, -39, -39, -39, -38, -39, -39, -39, -38,
-39, -39, -38, -39, -39, -39, -38, -38, -39, -39, -39, -39, -38, -38, -38, -38,
-39, -39, -38, -38, -38, -39, -39, -38, -38, -38, -38, -39, -38, -38, -38, -38,
-39, -39, -39, -38, -38, -38, -39, -38, -37, -38, -38, -38, -38, -38, -38, -38,
-39, -38, -38, -38, -39, -38, -38, -38, -38, -39, -39, -38, -38, -38, -38, -39,
-38, -38, -38, -38, -38, -38, -38, -37, -38, -39, -38, -38, -38, -38, -38, -38,
-37, -37, -39, -37, -37, -37, -39, -38, -38, -38, -39, -37, -37, -38, -38, -38,
-38, -37, -37, -38, -38, -37, -38, -38, -37, -37, -38, -38, -37, -37, -37, -38,
-37, -37, -38, -37, -37, -38, -38, -37, -38, -38, -37, -37, -38, -37, -37, -37,
-37, -37, -38, -37, -38, -37, -37, -38, -37, -37, -37, -38, -37, -38, -37, -38,
-36, -39, -36, -38, -35, -39, -37, };