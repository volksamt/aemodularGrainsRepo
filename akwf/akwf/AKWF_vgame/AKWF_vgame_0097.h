#define DATA_LENGTH 512
#define DATA AKWF_vgame_0097

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 8, 7, 6, 5, 4, 8, 11, 13, 14,
15, 14, 13, 13, 13, 16, 19, 21, 21, 22, 21, 21, 21, 22, 24, 27, 29, 29, 28, 27,
27, 29, 32, 34, 37, 38, 39, 37, 36, 37, 39, 40, 42, 44, 44, 44, 44, 45, 45, 47,
49, 49, 51, 52, 52, 53, 52, 54, 55, 58, 60, 59, 59, 59, 59, 58, 61, 63, 66, 67,
67, 66, 66, 67, 68, 70, 71, 73, 75, 74, 75, 74, 76, 77, 79, 81, 82, 83, 84, 81,
82, 82, 85, 86, 88, 90, 90, 90, 88, 88, 90, 93, 95, 97, 98, 98, 98, 97, 97, 99,
101, 104, 103, 104, 104, 103, 103, 104, 108, 109, 110, 112, 112, 113, 112, 113,
113, 115, 117, 118, 119, 117, 116, 114, 115, 113, 113, 113, 112, 110, 109, 107,
106, 105, 104, 105, 104, 103, 101, 99, 98, 96, 95, 95, 95, 94, 93, 91, 91, 89,
88, 87, 87, 86, 86, 84, 82, 80, 78, 78, 78, 78, 77, 77, 75, 73, 71, 71, 70, 68,
68, 66, 66, 64, 63, 61, 60, 61, 60, 60, 60, 58, 56, 55, 53, 53, 53, 53, 52, 50,
49, 47, 45, 44, 44, 45, 46, 44, 42, 40, 38, 38, 36, 36, 36, 36, 34, 32, 30, 29,
29, 27, 28, 27, 28, 27, 25, 23, 22, 21, 20, 20, 20, 20, 18, 15, 14, 13, 13, 12,
12, 12, 10, 9, 7, 6, 6, 5, 4, 3, 1, 1, -2, -3, -3, -4, -3, -3, -2, -4, -5, -6,
-8, -9, -10, -10, -9, -11, -13, -14, -16, -17, -17, -17, -17, -17, -18, -20,
-23, -25, -26, -25, -25, -26, -26, -27, -30, -31, -33, -33, -32, -33, -33, -34,
-35, -37, -39, -41, -41, -40, -40, -41, -43, -44, -46, -47, -48, -48, -47, -47,
-49, -51, -53, -54, -55, -54, -54, -56, -56, -57, -60, -61, -62, -63, -63, -62,
-62, -63, -65, -66, -68, -69, -70, -69, -70, -70, -71, -73, -75, -76, -78, -79,
-78, -78, -79, -81, -82, -82, -85, -85, -85, -85, -87, -88, -89, -90, -91, -92,
-93, -93, -93, -94, -94, -96, -98, -98, -99, -101, -101, -101, -102, -103, -105,
-106, -108, -108, -107, -109, -109, -110, -112, -112, -114, -114, -115, -116,
-116, -116, -115, -115, -114, -114, -114, -112, -111, -109, -109, -108, -106,
-106, -105, -104, -103, -101, -101, -100, -100, -99, -98, -96, -95, -94, -94,
-92, -91, -91, -89, -88, -87, -86, -85, -85, -84, -84, -82, -81, -79, -78, -78,
-77, -75, -75, -74, -73, -72, -71, -71, -70, -69, -68, -66, -66, -65, -63, -62,
-60, -60, -59, -59, -57, -56, -55, -53, -54, -52, -52, -51, -51, -49, -49, -47,
-46, -44, -44, -43, -41, -40, -40, -39, -38, -36, -35, -35, -35, -35, -32, -30,
-29, -27, -26, -25, -25, -26, -26, -25, -22, -20, -20, -19, -18, -19, -18, -17,
-16, -12, -10, -10, -10, -9, -9, -9, -8, -6, -4, -2, -1, -3, -4, -3, -1, };