#define DATA_LENGTH 512
#define DATA AKWF_vgame_0111

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 19, 23, 21, 22, 22, 22, 22, 22, 22,
22, 21, 33, 35, 38, 47, 46, 47, 46, 47, 47, 47, 46, 53, 55, 54, 55, 53, 61, 63,
62, 63, 62, 61, 69, 71, 70, 71, 71, 71, 75, 77, 82, 82, 81, 82, 82, 82, 81, 81,
82, 84, 85, 85, 85, 86, 88, 87, 87, 87, 88, 86, 90, 90, 89, 90, 89, 90, 90, 92,
92, 93, 93, 93, 93, 92, 93, 93, 92, 95, 96, 95, 95, 96, 95, 94, 96, 95, 95, 95,
97, 98, 97, 98, 98, 98, 98, 98, 98, 98, 98, 97, 101, 101, 100, 101, 100, 101,
100, 102, 103, 104, 103, 103, 103, 103, 103, 104, 103, 103, 103, 104, 106, 105,
106, 107, 106, 107, 105, 106, 109, 109, 108, 109, 109, 108, 109, 111, 111, 111,
111, 111, 111, 111, 112, 111, 110, 113, 113, 113, 115, 116, 116, 117, 116, 117,
116, 117, 116, 116, 115, 116, 116, 117, 119, 118, 119, 119, 119, 118, 118, 118,
119, 118, 118, 119, 118, 119, 118, 119, 119, 118, 119, 118, 118, 118, 115, 116,
116, 115, 115, 116, 116, 115, 116, 116, 116, 115, 109, 110, 110, 111, 108, 91,
92, 97, 96, 96, 96, 96, 96, 96, 96, 94, 86, 85, 86, 85, 81, 79, 80, 79, 80, 79,
81, 76, 69, 68, 69, 69, 68, 54, 46, 47, 47, 47, 46, 47, 46, 47, 46, 48, 43, 32,
34, 23, 18, 20, 19, 19, 20, 19, 21, 15, 1, 4, 2, 5, -3, -23, -22, -22, -23, -21,
-25, -32, -33, -33, -33, -31, -38, -43, -51, -55, -55, -56, -54, -55, -55, -55,
-54, -58, -60, -60, -60, -61, -69, -67, -74, -77, -76, -77, -76, -77, -77, -76,
-76, -77, -77, -83, -85, -85, -85, -85, -85, -85, -84, -85, -85, -86, -88, -88,
-88, -90, -91, -90, -90, -89, -90, -91, -90, -90, -90, -89, -90, -90, -91, -93,
-93, -93, -93, -93, -94, -96, -96, -96, -96, -96, -95, -95, -98, -98, -97, -99,
-99, -98, -99, -98, -98, -98, -98, -98, -98, -99, -100, -101, -101, -100, -101,
-101, -101, -100, -101, -101, -101, -100, -102, -106, -106, -106, -106, -107,
-107, -106, -106, -106, -106, -106, -106, -105, -107, -108, -109, -108, -109,
-108, -109, -108, -110, -111, -112, -111, -112, -112, -111, -112, -110, -111,
-110, -113, -114, -114, -115, -114, -113, -115, -116, -116, -117, -116, -116,
-117, -117, -117, -117, -116, -118, -120, -118, -120, -118, -119, -119, -118,
-119, -119, -119, -119, -119, -118, -120, -119, -118, -119, -118, -119, -119,
-118, -118, -119, -119, -118, -118, -118, -119, -117, -115, -116, -114, -110,
-111, -111, -110, -110, -111, -106, -104, -104, -105, -105, -105, -99, -89, -88,
-88, -88, -88, -89, -88, -88, -88, -88, -89, -81, -80, -77, -68, -69, -68, -68,
-69, -69, -68, -69, -60, -56, -58, -57, -59, -50, -46, -47, -47, -47, -47, -38,
-32, -33, -32, -34, -32, -25, -18, -3, -2, -2, -3, -3, -3, -3, -3, -4, };