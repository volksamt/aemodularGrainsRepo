#define DATA_LENGTH 512
#define DATA AKWF_vgame_0085

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 35, 52, 55, 52, 45, 39, 32, 28,
26, 27, 31, 36, 39, 40, 38, 36, 33, 33, 37, 39, 40, 39, 37, 34, 33, 33, 32, 33,
33, 33, 33, 33, 33, 33, 34, 33, 33, 33, 33, 33, 33, 34, 33, 33, 33, 34, 33, 33,
33, 33, 33, 34, 33, 33, 33, 34, 33, 34, 34, 33, 33, 33, 33, 32, 32, 34, 33, 33,
33, 33, 34, 33, 33, 33, 33, 33, 33, 33, 33, 33, 33, 34, 33, 34, 32, 33, 33, 32,
33, 32, 33, 33, 34, 33, 34, 32, 33, 34, 33, 33, 34, 33, 34, 33, 33, 32, 33, 33,
32, 32, 33, 33, 33, 32, 34, 33, 33, 33, 33, 33, 32, 33, 32, 33, 32, 33, 34, 33,
34, 32, 33, 33, 33, 33, 33, 32, 33, 32, 33, 33, 32, 33, 33, 32, 33, 32, 33, 33,
32, 32, 33, 33, 33, 32, 33, 33, 33, 33, 33, 33, 33, 32, 33, 32, 32, 33, 33, 33,
33, 33, 33, 33, 33, 33, 33, 33, 32, 32, 33, 33, 33, 33, 32, 33, 32, 32, 33, 33,
32, 33, 33, 32, 33, 33, 33, 32, 33, 33, 33, 32, 32, 33, 33, 33, 33, 33, 32, 32,
32, 33, 33, 33, 32, 33, 32, 32, 32, 32, 33, 32, 33, 32, 32, 32, 32, 33, 32, 33,
32, 33, 32, 33, 32, 32, 32, 32, 33, 33, 33, 32, 33, 32, 33, 33, 32, 31, 32, 32,
32, 32, 32, 32, 33, 32, 33, 32, 32, 32, 32, 32, 32, 32, 33, 33, 32, 32, 33, 33,
32, 32, 32, 33, 32, 33, 32, 33, 32, 32, 33, 32, 33, 32, 32, 32, 33, 32, 33, 33,
32, 32, 32, 32, 32, 32, 32, 32, 32, 32, 32, 33, 32, 32, 32, 33, 32, 31, 32, 32,
32, 32, 32, 32, 33, 32, 32, 32, 32, 31, 31, 32, 32, 32, 33, 32, 32, 32, 32, 33,
32, 32, 31, 33, 32, 32, 33, 32, 32, 33, 31, 32, 33, 32, 32, 32, 32, 33, 32, 32,
33, 32, 32, 32, 32, 31, 32, 32, 35, 37, 39, 38, 36, 34, 32, 33, 34, 37, 39, 39,
37, 34, 33, 30, 29, 29, 32, 39, 47, 51, 44, 25, -1, -31, -56, -78, -97, -109,
-115, -113, -107, -100, -96, -95, -97, -98, -100, -102, -105, -106, -105, -102,
-99, -99, -100, -102, -105, -105, -104, -102, -100, -99, -97, -98, -99, -99,
-98, -99, -99, -98, -98, -99, -98, -98, -98, -98, -98, -98, -98, -99, -98, -98,
-98, -98, -99, -98, -99, -99, -98, -98, -99, -98, -98, -98, -98, -98, -98, -99,
-98, -98, -98, -98, -98, -98, -98, -98, -98, -98, -98, -98, -98, -98, -98, -98,
-98, -98, -98, -98, -98, -98, -98, -97, -98, -97, -98, -97, -98, -98, -97, -97,
-97, -97, -98, -97, -98, -98, -97, -97, -98, -98, -98, -98, -98, -98, -97, -97,
-97, -99, -99, -97, -94, -91, -89, -90, -98, -110, -118, -118, -109, -93, -71,
-44, -14, };