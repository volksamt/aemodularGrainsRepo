#define DATA_LENGTH 512
#define DATA AKWF_vgame_0123

const PROGMEM int8_t DATA[DATA_LENGTH] = {20, 25, 23, 25, 23, 24, 23, 24, 23,
24, 23, 24, 23, 23, 23, 24, 24, 24, 23, 23, 24, 24, 23, 23, 23, 23, 23, 24, 23,
23, 24, 24, 24, 24, 24, 24, 24, 24, 25, 23, 24, 24, 23, 24, 24, 24, 24, 23, 24,
24, 24, 23, 24, 24, 24, 23, 23, 24, 24, 24, 23, 24, 23, 23, 24, 24, 23, 24, 23,
24, 22, 26, 20, 33, 69, 70, 69, 70, 70, 69, 69, 69, 69, 69, 69, 70, 69, 70, 70,
69, 69, 69, 69, 69, 69, 69, 70, 69, 69, 70, 70, 69, 70, 69, 69, 70, 69, 69, 69,
70, 68, 70, 68, 70, 68, 71, 65, 90, 120, 113, 115, 115, 114, 115, 113, 115, 114,
117, 114, 116, 113, 115, 115, 116, 116, 115, 115, 114, 116, 113, 117, 111, 119,
108, 124, 102, 127, 23, -128, -102, -122, -110, -117, -112, -116, -114, -115,
-115, -114, -115, -113, -116, -114, -115, -114, -115, -113, -116, -113, -115,
-114, -115, -113, -116, -112, -116, -112, -120, -86, -64, -72, -68, -70, -68,
-69, -68, -70, -68, -69, -68, -69, -69, -68, -68, -68, -68, -69, -69, -68, -69,
-68, -68, -69, -69, -68, -69, -68, -69, -68, -69, -68, -69, -68, -69, -69, -68,
-68, -69, -68, -67, -69, -68, -70, -66, -74, -47, -18, -24, -22, -23, -22, -23,
-23, -22, -22, -22, -22, -22, -22, -22, -23, -22, -22, -22, -22, -22, -22, -22,
-22, -23, -23, -22, -22, -22, -23, -22, -22, -22, -22, -22, -22, -22, -22, -22,
-22, -23, -22, -22, -22, -22, -22, -22, -22, -23, -22, -22, -22, -22, -22, -22,
-22, -22, -22, -23, -22, -22, -22, -22, -22, -22, -22, -21, -23, -21, -22, -21,
-23, -20, -26, 9, 29, 20, 26, 22, 25, 23, 25, 23, 24, 23, 24, 24, 24, 24, 24,
25, 24, 23, 24, 24, 24, 24, 24, 24, 24, 24, 23, 24, 23, 24, 24, 24, 23, 23, 24,
23, 23, 24, 23, 24, 24, 24, 24, 24, 24, 24, 24, 23, 24, 23, 23, 24, 24, 24, 24,
24, 23, 24, 24, 23, 24, 23, 24, 23, 24, 23, 23, 24, 23, 24, 24, 23, 23, 24, 24,
23, 24, 24, 23, 24, 23, 23, 23, 23, 23, 24, 23, 24, 23, 24, 23, 24, 23, 24, 23,
24, 23, 24, 23, 24, 22, 26, 21, -18, -24, -21, -22, -22, -24, -22, -22, -22,
-23, -23, -23, -22, -23, -22, -23, -22, -22, -22, -22, -22, -22, -23, -23, -22,
-22, -22, -23, -22, -22, -23, -22, -23, -22, -23, -22, -22, -22, -23, -22, -22,
-22, -22, -23, -23, -23, -23, -22, -22, -22, -22, -22, -23, -22, -22, -23, -22,
-23, -22, -23, -22, -23, -22, -22, -22, -22, -22, -22, -22, -23, -22, -22, -22,
-22, -22, -22, -23, -22, -22, -23, -22, -22, -22, -22, -22, -23, -21, -22, -22,
-22, -23, -23, -22, -22, -22, -23, -21, -23, -22, -23, -22, -23, -22, -23, -21,
-24, -21, -24, -19, };