#define DATA_LENGTH 512
#define DATA AKWF_vgame_0076

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 16, 27, 35, 42, 45, 46, 46, 46, 46,
45, 41, 39, 35, 31, 28, 26, 26, 27, 29, 32, 36, 39, 44, 46, 47, 46, 46, 45, 42,
40, 38, 37, 35, 35, 35, 35, 35, 35, 36, 35, 36, 36, 37, 36, 36, 36, 36, 36, 35,
36, 36, 36, 36, 36, 36, 37, 36, 36, 35, 36, 36, 36, 37, 36, 36, 36, 36, 36, 36,
35, 36, 36, 36, 37, 36, 36, 36, 36, 36, 36, 36, 36, 35, 36, 36, 36, 35, 36, 36,
36, 36, 35, 35, 35, 35, 36, 36, 37, 35, 36, 36, 36, 35, 36, 36, 35, 36, 36, 35,
36, 36, 36, 36, 35, 35, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 35, 35, 36, 35,
35, 36, 35, 35, 36, 36, 35, 35, 35, 35, 35, 35, 36, 36, 35, 35, 36, 36, 36, 35,
36, 36, 36, 36, 36, 35, 36, 35, 36, 35, 36, 36, 35, 36, 35, 35, 35, 36, 35, 35,
35, 35, 35, 36, 35, 35, 36, 35, 36, 36, 35, 36, 35, 35, 35, 35, 35, 35, 35, 35,
35, 35, 36, 36, 36, 36, 36, 36, 36, 35, 36, 36, 35, 35, 36, 35, 35, 35, 35, 35,
35, 36, 35, 36, 34, 35, 35, 36, 36, 36, 35, 35, 35, 35, 35, 35, 35, 36, 35, 35,
35, 36, 35, 35, 36, 35, 35, 35, 35, 35, 35, 35, 36, 35, 34, 35, 36, 35, 35, 35,
35, 35, 35, 35, 36, 35, 35, 35, 36, 35, 35, 35, 36, 35, 34, 35, 35, 35, 34, 35,
35, 35, 35, 34, 36, 36, 35, 35, 34, 34, 36, 35, 35, 35, 35, 35, 34, 35, 35, 35,
35, 35, 34, 35, 35, 34, 35, 35, 35, 35, 34, 35, 35, 35, 34, 35, 35, 34, 34, 35,
35, 34, 35, 35, 36, 35, 36, 35, 34, 35, 35, 35, 35, 35, 35, 34, 35, 35, 35, 34,
35, 35, 34, 35, 35, 35, 35, 35, 35, 35, 34, 35, 34, 35, 35, 34, 35, 35, 35, 35,
35, 35, 35, 35, 34, 35, 35, 35, 35, 34, 35, 34, 35, 35, 34, 34, 33, 33, 32, 33,
33, 35, 37, 43, 45, 44, 45, 45, 45, 43, 33, 18, -1, -22, -42, -61, -78, -92,
-102, -109, -114, -117, -118, -118, -119, -119, -118, -117, -116, -115, -112,
-111, -109, -108, -108, -107, -107, -107, -108, -108, -109, -109, -108, -109,
-109, -108, -109, -109, -108, -109, -109, -109, -109, -109, -109, -109, -109,
-109, -109, -108, -108, -108, -108, -108, -109, -108, -108, -108, -108, -109,
-109, -108, -108, -109, -108, -109, -108, -108, -108, -109, -108, -109, -108,
-109, -108, -108, -108, -108, -108, -108, -109, -108, -107, -108, -108, -108,
-109, -108, -108, -108, -108, -108, -109, -107, -107, -108, -108, -107, -107,
-108, -108, -108, -108, -107, -108, -108, -108, -108, -108, -108, -107, -107,
-106, -105, -104, -105, -106, -107, -111, -115, -119, -117, -118, -117, -118,
-116, -105, -89, -70, -51, -31, -10, };