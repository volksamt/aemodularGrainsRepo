#define DATA_LENGTH 512
#define DATA AKWF_vgame_0029

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 17, 14, 15, 15, 14, 14, 14, 14, 15,
15, 12, 26, 38, 53, 58, 56, 58, 56, 57, 56, 57, 56, 57, 56, 58, 67, 73, 78, 78,
79, 78, 80, 78, 78, 79, 79, 79, 81, 86, 85, 89, 91, 89, 91, 90, 90, 89, 91, 90,
90, 89, 94, 95, 95, 99, 98, 98, 98, 99, 98, 98, 98, 99, 98, 98, 99, 99, 104,
108, 105, 107, 105, 112, 116, 115, 116, 116, 116, 116, 115, 115, 119, 119, 119,
120, 120, 119, 120, 119, 119, 118, 110, 107, 111, 101, 94, 95, 95, 95, 95, 95,
96, 94, 96, 88, 73, 77, 75, 67, 65, 66, 66, 67, 66, 65, 66, 66, 66, 60, 56, 60,
54, 47, 48, 48, 48, 49, 48, 49, 47, 50, 43, 26, 27, 27, 10, 5, 8, 6, 7, 7, 7, 6,
8, 0, -7, -6, -6, -8, -12, -11, -11, -11, -12, -11, -11, -11, -12, -14, -15,
-14, -14, -22, -25, -24, -25, -24, -26, -23, -26, -20, -34, -43, -43, -42, -48,
-65, -63, -65, -64, -65, -64, -65, -63, -77, -84, -81, -82, -82, -84, -84, -84,
-84, -85, -83, -84, -84, -83, -81, -82, -82, -82, -81, -77, -77, -77, -77, -77,
-77, -77, -77, -76, -75, -76, -74, -77, -72, -67, -68, -67, -67, -67, -67, -68,
-66, -49, -48, -49, -48, -47, -26, -23, -25, -23, -25, -23, -27, -17, 0, 7, 15,
12, 13, 12, 13, 13, 13, 12, 13, 13, 12, 19, 23, 22, 22, 22, 22, 25, 26, 26, 26,
26, 26, 26, 25, 25, 25, 25, 26, 25, 26, 26, 26, 25, 26, 26, 25, 26, 24, 22, 23,
23, 22, 24, 16, 12, 13, 13, 13, 13, 13, 2, 2, 2, 2, 2, 2, 1, -4, -3, -3, -3, -3,
-4, -2, -2, -2, -1, -2, -2, -1, -3, -4, -5, -5, -5, -5, -4, -14, -15, -15, -14,
-14, -13, -17, -32, -32, -32, -32, -31, -33, -44, -43, -44, -44, -44, -45, -43,
-48, -49, -50, -50, -50, -50, -50, -50, -49, -49, -50, -50, -49, -56, -60, -58,
-60, -59, -60, -60, -59, -60, -60, -60, -59, -60, -59, -60, -60, -61, -61, -61,
-61, -61, -61, -61, -61, -61, -62, -61, -61, -58, -58, -59, -58, -58, -58, -58,
-59, -58, -58, -58, -57, -56, -55, -54, -54, -54, -54, -55, -54, -54, -55, -55,
-55, -55, -55, -52, -49, -48, -49, -48, -48, -48, -49, -48, -49, -47, -48, -48,
-38, -32, -26, -25, -25, -26, -26, -26, -26, -26, -26, -27, -24, -19, -20, -18,
-18, -18, -18, -18, -17, -18, -17, -18, -17, -18, -17, -16, -16, -16, -16, -16,
-17, -16, -16, -16, -16, -16, -17, -15, -18, -17, -19, -22, -21, -21, -21, -22,
-21, -21, -20, -21, -20, -22, -23, -22, -23, -22, -23, -23, -22, -22, -22, -23,
-23, -22, -23, -25, -24, -25, -24, -25, -24, -24, -24, -25, -24, -24, -24, -23,
-21, -21, -20, -12, -9, -10, -9, -10, -9, -10, -9, -11, -10, };