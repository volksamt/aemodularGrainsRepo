#define DATA_LENGTH 512
#define DATA AKWF_vgame_0066

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 36, 49, 52, 46, 37, 31, 28, 29,
33, 36, 37, 37, 35, 34, 34, 36, 36, 35, 36, 36, 35, 35, 35, 35, 35, 36, 35, 35,
35, 35, 35, 36, 36, 36, 35, 35, 35, 36, 36, 36, 35, 36, 36, 35, 35, 35, 36, 36,
35, 35, 35, 35, 36, 35, 35, 36, 35, 35, 36, 36, 36, 35, 36, 35, 35, 35, 36, 35,
36, 34, 34, 35, 35, 35, 35, 36, 35, 35, 35, 35, 35, 35, 35, 35, 35, 36, 35, 36,
35, 36, 35, 35, 36, 35, 36, 35, 35, 36, 36, 35, 35, 35, 36, 35, 36, 35, 36, 36,
36, 35, 36, 35, 35, 35, 35, 35, 36, 36, 35, 35, 34, 35, 34, 35, 36, 34, 35, 35,
35, 35, 36, 35, 35, 35, 35, 35, 35, 35, 36, 35, 35, 36, 35, 35, 35, 35, 34, 35,
35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 34, 35, 35, 35, 35, 36,
35, 35, 35, 34, 35, 35, 35, 36, 35, 35, 35, 35, 35, 35, 36, 35, 35, 35, 35, 35,
34, 35, 35, 34, 34, 35, 35, 34, 35, 35, 35, 34, 34, 35, 35, 35, 34, 35, 34, 35,
34, 35, 35, 35, 34, 35, 34, 35, 35, 34, 34, 34, 35, 35, 35, 35, 35, 34, 35, 35,
35, 34, 34, 35, 35, 35, 34, 34, 35, 35, 34, 35, 34, 34, 35, 35, 34, 34, 35, 35,
35, 35, 34, 35, 34, 34, 35, 34, 34, 34, 35, 34, 34, 34, 34, 35, 35, 35, 34, 35,
34, 34, 35, 34, 35, 34, 35, 35, 34, 34, 35, 34, 34, 35, 35, 35, 34, 35, 34, 35,
34, 35, 35, 35, 35, 34, 34, 34, 34, 34, 35, 35, 34, 34, 34, 35, 35, 35, 34, 34,
35, 33, 34, 34, 34, 34, 34, 35, 34, 34, 34, 34, 34, 34, 34, 34, 35, 33, 34, 34,
34, 34, 34, 34, 34, 32, 33, 34, 35, 34, 34, 34, 35, 34, 33, 33, 34, 34, 34, 34,
34, 34, 33, 32, 33, 34, 34, 34, 34, 34, 34, 32, 32, 33, 33, 35, 37, 35, 35, 33,
31, 29, 28, 29, 30, 33, 36, 42, 47, 46, 40, 22, -3, -34, -66, -92, -111, -118,
-117, -112, -107, -101, -99, -99, -101, -101, -102, -104, -105, -107, -106,
-106, -105, -104, -102, -103, -104, -105, -105, -105, -105, -105, -105, -104,
-104, -104, -105, -105, -105, -104, -104, -104, -104, -104, -105, -104, -104,
-104, -104, -105, -103, -102, -103, -104, -105, -104, -104, -104, -105, -105,
-104, -105, -104, -104, -105, -103, -104, -104, -105, -103, -105, -104, -105,
-104, -104, -103, -104, -104, -104, -104, -104, -104, -104, -103, -104, -104,
-104, -104, -105, -103, -104, -103, -104, -103, -104, -104, -103, -103, -104,
-104, -103, -103, -104, -104, -104, -104, -104, -104, -104, -102, -102, -102,
-103, -104, -103, -103, -104, -102, -102, -101, -101, -98, -98, -99, -103, -110,
-116, -117, -110, -92, -60, -36, -14, };