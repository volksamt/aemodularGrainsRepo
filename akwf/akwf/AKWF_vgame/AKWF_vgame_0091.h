#define DATA_LENGTH 512
#define DATA AKWF_vgame_0091

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 25, 37, 45, 48, 49, 45, 40, 34, 29,
25, 24, 27, 31, 34, 39, 41, 40, 38, 35, 33, 31, 31, 32, 34, 36, 36, 37, 37, 36,
34, 33, 32, 33, 34, 34, 36, 36, 36, 34, 34, 33, 32, 32, 33, 34, 34, 35, 35, 36,
34, 34, 34, 33, 32, 33, 34, 35, 36, 35, 35, 33, 34, 33, 32, 33, 34, 34, 34, 34,
35, 35, 35, 34, 34, 35, 34, 35, 34, 34, 33, 33, 34, 34, 34, 34, 34, 34, 34, 34,
33, 35, 34, 34, 34, 34, 35, 33, 34, 34, 34, 34, 34, 33, 34, 34, 34, 34, 35, 34,
34, 34, 34, 35, 34, 34, 34, 33, 34, 33, 34, 34, 34, 34, 33, 34, 34, 34, 34, 34,
34, 34, 33, 33, 33, 33, 34, 34, 33, 34, 34, 33, 34, 34, 33, 34, 33, 34, 34, 35,
35, 35, 35, 35, 35, 35, 34, 34, 33, 33, 35, 35, 34, 35, 35, 35, 35, 35, 35, 35,
34, 34, 34, 34, 35, 35, 35, 35, 34, 35, 35, 35, 34, 35, 35, 35, 35, 35, 34, 35,
35, 35, 35, 35, 35, 34, 35, 35, 35, 35, 35, 35, 35, 34, 34, 34, 35, 35, 35, 35,
34, 35, 34, 34, 33, 34, 33, 34, 35, 35, 34, 35, 35, 34, 33, 33, 34, 33, 34, 34,
35, 35, 33, 34, 34, 34, 34, 33, 33, 34, 33, 33, 33, 33, 34, 34, 33, 33, 33, 33,
34, 33, 33, 34, 34, 33, 33, 33, 33, 33, 33, 33, 34, 33, 34, 34, 33, 33, 34, 32,
33, 34, 33, 33, 33, 34, 33, 34, 33, 33, 32, 33, 33, 33, 32, 34, 33, 33, 33, 33,
34, 33, 33, 32, 34, 33, 32, 33, 33, 34, 34, 35, 33, 34, 32, 31, 32, 33, 33, 33,
35, 35, 35, 34, 33, 32, 31, 32, 32, 33, 35, 34, 34, 34, 34, 32, 32, 31, 31, 32,
33, 35, 34, 34, 34, 33, 33, 32, 31, 32, 32, 34, 34, 35, 35, 34, 33, 31, 30, 30,
31, 32, 34, 35, 37, 36, 33, 32, 31, 29, 30, 32, 34, 37, 40, 40, 37, 31, 27, 23,
23, 27, 34, 43, 50, 52, 49, 38, 18, -6, -31, -55, -76, -93, -104, -111, -113,
-112, -108, -104, -99, -95, -92, -91, -94, -98, -101, -105, -107, -106, -104,
-100, -97, -95, -96, -98, -100, -102, -103, -105, -103, -100, -99, -97, -96,
-98, -100, -101, -102, -103, -102, -101, -100, -97, -97, -98, -99, -99, -100,
-102, -103, -102, -100, -99, -98, -98, -98, -99, -99, -100, -101, -103, -102,
-101, -99, -98, -97, -98, -99, -100, -101, -101, -101, -102, -100, -99, -98,
-98, -99, -98, -100, -100, -101, -100, -101, -99, -98, -97, -97, -99, -99, -100,
-102, -102, -101, -100, -99, -97, -97, -96, -98, -100, -102, -103, -102, -100,
-98, -97, -95, -95, -96, -100, -103, -106, -105, -103, -97, -91, -88, -87, -90,
-99, -108, -116, -119, -117, -106, -84, -65, -54, -32, -9, };