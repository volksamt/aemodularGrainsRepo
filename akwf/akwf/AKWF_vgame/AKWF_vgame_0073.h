#define DATA_LENGTH 512
#define DATA AKWF_vgame_0073

const PROGMEM int8_t DATA[DATA_LENGTH] = {26, 51, 70, 100, 114, 118, 112, 107,
100, 96, 96, 103, 108, 109, 108, 104, 101, 100, 104, 105, 105, 105, 103, 102,
104, 105, 106, 106, 103, 102, 103, 102, 104, 104, 103, 102, 101, 102, 102, 103,
105, 104, 103, 102, 101, 103, 104, 105, 104, 102, 101, 102, 102, 104, 104, 104,
103, 102, 101, 102, 102, 104, 103, 103, 103, 102, 102, 103, 103, 102, 102, 102,
103, 102, 103, 103, 104, 103, 101, 101, 101, 102, 103, 103, 104, 103, 101, 102,
101, 102, 102, 104, 103, 102, 101, 102, 103, 103, 103, 104, 103, 102, 101, 102,
102, 105, 105, 101, 101, 102, 103, 104, 105, 104, 101, 101, 101, 103, 107, 105,
99, 94, 95, 104, 115, 120, 106, 74, 29, -10, -36, -46, -45, -40, -34, -30, -27,
-30, -35, -40, -40, -37, -33, -32, -32, -34, -37, -38, -35, -34, -34, -34, -35,
-36, -38, -36, -33, -33, -34, -35, -36, -36, -36, -33, -32, -35, -35, -35, -35,
-35, -35, -34, -35, -35, -34, -34, -35, -34, -35, -35, -35, -35, -34, -35, -34,
-35, -35, -34, -35, -35, -34, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35,
-34, -35, -34, -35, -34, -35, -34, -35, -35, -35, -35, -35, -35, -35, -35, -35,
-34, -34, -34, -35, -35, -35, -34, -35, -34, -35, -35, -34, -35, -35, -34, -36,
-36, -35, -35, -34, -34, -34, -34, -35, -34, -35, -35, -34, -34, -34, -34, -34,
-34, -35, -34, -35, -34, -35, -34, -34, -35, -34, -34, -35, -34, -35, -35, -34,
-35, -34, -34, -34, -35, -34, -35, -34, -35, -34, -35, -34, -35, -34, -35, -35,
-34, -35, -35, -35, -34, -34, -34, -34, -34, -35, -34, -35, -34, -34, -34, -34,
-35, -34, -34, -34, -34, -35, -34, -34, -34, -34, -34, -35, -34, -34, -35, -33,
-34, -35, -34, -34, -34, -34, -34, -34, -35, -34, -34, -34, -34, -35, -34, -34,
-34, -34, -36, -36, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34,
-34, -34, -34, -33, -34, -34, -33, -35, -34, -34, -34, -34, -34, -34, -34, -34,
-34, -34, -34, -34, -34, -34, -34, -34, -34, -33, -34, -35, -36, -35, -34, -33,
-34, -34, -34, -33, -34, -34, -34, -33, -34, -34, -35, -35, -35, -35, -34, -33,
-34, -33, -34, -34, -34, -34, -34, -34, -33, -34, -34, -34, -34, -34, -34, -33,
-34, -34, -34, -34, -33, -33, -33, -33, -33, -34, -34, -34, -35, -34, -33, -34,
-33, -33, -33, -34, -34, -34, -33, -34, -34, -33, -33, -33, -34, -33, -34, -34,
-34, -33, -33, -34, -34, -34, -34, -34, -33, -34, -33, -33, -34, -33, -33, -34,
-34, -34, -33, -34, -33, -34, -33, -34, -33, -34, -33, -33, -33, -33, -33, -33,
-33, -33, -34, -34, -33, -33, -33, -33, -33, -34, -33, -34, -33, -32, -33, -34,
-35, -34, -32, -32, -32, -33, -34, -34, -35, -33, -32, -32, -34, -36, -34, -30,
-27, -27, -35, -45, -50, -37, -6, };