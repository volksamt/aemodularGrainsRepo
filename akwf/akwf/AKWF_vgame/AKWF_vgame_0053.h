#define DATA_LENGTH 512
#define DATA AKWF_vgame_0053

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 5, 7, 8, 9, 13, 12, 12, 17, 17,
19, 23, 21, 26, 27, 28, 32, 32, 35, 37, 37, 41, 44, 44, 45, 45, 45, 49, 49, 53,
56, 56, 59, 58, 60, 68, 69, 68, 68, 69, 72, 72, 75, 77, 76, 78, 81, 80, 85, 91,
90, 90, 91, 93, 94, 95, 99, 98, 100, 102, 102, 104, 106, 108, 108, 108, 108,
112, 111, 113, 115, 114, 116, 116, 117, 117, 117, 117, 118, 117, 118, 118, 117,
115, 116, 116, 115, 115, 113, 113, 113, 113, 112, 112, 111, 111, 109, 109, 109,
109, 109, 109, 108, 107, 106, 106, 105, 105, 105, 104, 103, 103, 101, 102, 101,
100, 100, 100, 99, 98, 99, 98, 99, 95, 96, 94, 93, 94, 93, 92, 91, 91, 90, 89,
89, 89, 87, 87, 87, 86, 85, 86, 84, 85, 82, 82, 82, 80, 81, 80, 79, 79, 77, 78,
77, 76, 77, 76, 74, 73, 73, 72, 71, 70, 70, 69, 69, 69, 65, 65, 65, 63, 62, 62,
61, 62, 62, 60, 61, 57, 58, 57, 55, 56, 54, 52, 53, 52, 52, 51, 49, 49, 50, 47,
47, 46, 44, 45, 43, 41, 41, 41, 42, 39, 41, 38, 36, 37, 35, 35, 35, 35, 32, 29,
31, 30, 30, 27, 26, 25, 25, 25, 24, 24, 23, 21, 21, 20, 21, 21, 18, 18, 17, 14,
14, 14, 13, 12, 11, 11, 7, 8, 8, 7, 7, 6, 4, 5, 5, 2, 2, 1, 0, -2, -3, -3, -4,
-5, -5, -6, -6, -6, -9, -10, -11, -11, -12, -13, -13, -12, -15, -17, -16, -18,
-17, -19, -21, -20, -22, -22, -23, -25, -24, -26, -27, -27, -29, -29, -28, -32,
-33, -32, -34, -34, -34, -35, -36, -39, -37, -39, -40, -39, -41, -42, -41, -43,
-43, -43, -46, -46, -46, -47, -48, -51, -51, -51, -53, -52, -54, -55, -54, -58,
-59, -58, -59, -59, -59, -60, -60, -62, -62, -62, -65, -65, -66, -68, -69, -68,
-69, -70, -70, -70, -71, -72, -71, -73, -75, -74, -76, -77, -78, -78, -78, -79,
-80, -80, -81, -81, -83, -82, -83, -83, -86, -88, -87, -88, -87, -88, -88, -91,
-90, -91, -92, -92, -94, -94, -96, -95, -94, -95, -97, -97, -96, -99, -98, -99,
-100, -100, -101, -102, -104, -103, -103, -103, -104, -103, -104, -105, -104,
-106, -106, -107, -108, -109, -110, -109, -109, -112, -111, -113, -113, -113,
-113, -112, -113, -115, -115, -115, -116, -116, -117, -118, -118, -117, -117,
-118, -119, -119, -118, -119, -119, -119, -119, -119, -118, -118, -115, -115,
-115, -111, -111, -111, -109, -110, -105, -105, -104, -101, -102, -99, -98, -99,
-97, -93, -94, -90, -89, -88, -85, -86, -82, -81, -81, -76, -77, -74, -72, -73,
-68, -68, -69, -66, -63, -62, -57, -57, -56, -54, -54, -50, -49, -47, -44, -45,
-41, -37, -36, -37, -37, -37, -32, -32, -30, -25, -25, -23, -22, -22, -14, -12,
-12, -13, -11, -8, -7, -7, -4, -5, -3, 0, 0, };