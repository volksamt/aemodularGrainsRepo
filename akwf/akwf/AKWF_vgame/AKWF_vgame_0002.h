#define DATA_LENGTH 512
#define DATA AKWF_vgame_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 45, 93, 120, 119, 119, 119, 119,
119, 119, 119, 116, 117, 117, 118, 120, 119, 120, 119, 119, 119, 119, 119, 119,
119, 118, 119, 118, 119, 119, 118, 119, 119, 119, 119, 119, 119, 118, 119, 119,
119, 119, 118, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 119,
119, 120, 119, 119, 120, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119,
120, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 120, 118, 119, 118, 119,
118, 119, 119, 118, 118, 120, 119, 119, 119, 119, 119, 119, 119, 120, 118, 119,
118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 120, 120, 119, 119, 119, 119,
119, 118, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 120, 118, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119, 119, 119, 119,
119, 120, 120, 120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 118,
119, 119, 118, 119, 119, 120, 119, 119, 120, 119, 120, 118, 119, 118, 120, 118,
119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 120, 119, 118, 119, 118, 119,
119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 118, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 118, 119, 119, 120, 120, 119, 119, 119,
119, 119, 120, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 119, 119,
119, 119, 119, 120, 120, 119, 119, 119, 118, 119, 119, 120, 118, 118, 120, 119,
118, 118, 116, 117, 118, 119, 119, 119, 118, 120, 118, 120, 107, 63, 26, -14,
-52, -95, -121, -117, -119, -119, -120, -119, -119, -118, -117, -116, -118,
-118, -119, -119, -119, -119, -118, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -120, -120, -119, -119, -119, -118, -119,
-119, -119, -120, -119, -120, -119, -120, -120, -120, -119, -120, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -120, -120, -120,
-119, -120, -120, -119, -119, -118, -119, -120, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -118, -119, -119, -119, -118, -119, -119, -118, -118, -119, -118,
-120, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -118, -120, -119, -119,
-119, -118, -119, -119, -119, -118, -120, -120, -119, -120, -119, -118, -118,
-118, -119, -119, -119, -120, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -118, -117, -118, -119, -118, -119, -119, -120, -120, -118, -120, -106,
-86, -67, -72, -91, -115, -98, -58, -23, };