#define DATA_LENGTH 512
#define DATA AKWF_vgame_0067

const PROGMEM int8_t DATA[DATA_LENGTH] = {25, 89, 117, 115, 101, 95, 98, 104,
104, 102, 102, 100, 101, 102, 102, 102, 102, 102, 103, 102, 102, 101, 101, 101,
101, 102, 102, 102, 102, 101, 101, 101, 102, 102, 102, 102, 102, 101, 101, 102,
101, 101, 101, 101, 101, 102, 101, 101, 101, 101, 101, 101, 102, 102, 101, 101,
102, 101, 101, 100, 100, 100, 99, 100, 100, 101, 100, 99, 99, 101, 101, 102,
101, 101, 102, 102, 100, 100, 102, 102, 102, 101, 101, 100, 101, 101, 100, 100,
101, 102, 100, 100, 101, 101, 101, 101, 100, 100, 100, 101, 100, 99, 99, 101,
102, 101, 100, 99, 100, 102, 101, 98, 99, 100, 102, 100, 98, 97, 101, 104, 103,
96, 94, 97, 103, 111, 108, 84, 32, -20, -50, -48, -31, -26, -30, -38, -36, -32,
-31, -35, -36, -36, -33, -33, -34, -35, -35, -34, -33, -34, -36, -34, -34, -33,
-34, -34, -34, -34, -34, -34, -34, -34, -35, -34, -35, -34, -34, -35, -33, -34,
-35, -34, -35, -34, -34, -35, -35, -34, -34, -34, -35, -33, -35, -34, -34, -34,
-34, -34, -34, -34, -35, -34, -35, -34, -35, -35, -34, -35, -34, -35, -34, -34,
-35, -35, -35, -35, -34, -35, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34,
-35, -34, -34, -34, -34, -34, -34, -33, -34, -34, -35, -35, -35, -35, -34, -35,
-34, -34, -34, -34, -34, -34, -33, -34, -34, -34, -34, -35, -35, -34, -34, -34,
-33, -34, -33, -34, -34, -34, -34, -33, -33, -33, -34, -33, -34, -34, -34, -34,
-33, -34, -34, -33, -34, -33, -34, -33, -33, -34, -34, -34, -34, -34, -34, -34,
-34, -34, -34, -34, -34, -33, -35, -34, -34, -34, -34, -34, -35, -33, -34, -34,
-33, -33, -33, -34, -34, -34, -34, -34, -33, -34, -34, -33, -34, -34, -33, -35,
-36, -34, -33, -34, -34, -34, -34, -34, -34, -33, -34, -34, -33, -34, -34, -33,
-33, -34, -34, -33, -34, -34, -33, -33, -34, -34, -34, -33, -34, -34, -33, -33,
-34, -34, -33, -34, -34, -33, -35, -35, -33, -33, -33, -34, -34, -34, -33, -33,
-33, -33, -33, -34, -34, -33, -33, -33, -33, -34, -33, -33, -33, -34, -33, -34,
-34, -34, -33, -33, -33, -33, -34, -33, -33, -33, -33, -33, -34, -34, -34, -33,
-34, -33, -33, -33, -34, -34, -33, -33, -33, -33, -33, -34, -33, -33, -33, -34,
-33, -33, -33, -34, -34, -33, -34, -33, -33, -34, -34, -33, -33, -33, -33, -34,
-33, -33, -33, -34, -33, -34, -33, -33, -33, -33, -33, -33, -33, -33, -33, -33,
-33, -33, -33, -34, -33, -34, -33, -33, -33, -32, -34, -33, -33, -33, -33, -34,
-33, -33, -33, -33, -33, -33, -33, -32, -33, -33, -33, -33, -33, -34, -33, -33,
-33, -33, -33, -35, -34, -33, -32, -31, -32, -34, -34, -32, -32, -33, -34, -34,
-32, -31, -33, -34, -33, -31, -30, -33, -35, -33, -31, -29, -33, -37, -37, -29,
-25, -28, -37, -44, -46, -23, };