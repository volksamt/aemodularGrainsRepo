#define DATA_LENGTH 512
#define DATA AKWF_vgame_0078

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 6, 8, 11, 14, 16, 17, 18, 17,
15, 14, 13, 14, 15, 14, 13, 15, 16, 18, 21, 26, 28, 32, 33, 32, 32, 30, 29, 29,
29, 30, 33, 36, 40, 43, 45, 46, 46, 46, 45, 45, 44, 45, 45, 45, 45, 45, 45, 47,
48, 51, 54, 59, 60, 61, 61, 60, 60, 59, 59, 58, 58, 59, 58, 59, 60, 61, 65, 68,
71, 74, 75, 75, 76, 75, 74, 74, 74, 73, 74, 74, 72, 73, 74, 77, 80, 84, 88, 90,
92, 92, 89, 88, 87, 86, 88, 89, 91, 94, 98, 100, 102, 104, 104, 105, 104, 104,
103, 104, 103, 103, 102, 102, 103, 106, 108, 111, 114, 118, 119, 119, 119, 118,
118, 116, 117, 116, 116, 117, 118, 118, 117, 117, 113, 109, 105, 102, 100, 98,
98, 100, 102, 103, 103, 101, 100, 97, 95, 93, 90, 88, 87, 86, 85, 85, 86, 85,
86, 87, 87, 88, 87, 85, 84, 81, 78, 76, 74, 71, 69, 70, 70, 70, 70, 71, 71, 71,
72, 71, 71, 69, 68, 66, 63, 60, 57, 56, 55, 54, 54, 55, 53, 55, 54, 55, 55, 55,
55, 54, 51, 47, 43, 40, 38, 37, 37, 38, 40, 42, 41, 40, 38, 36, 35, 32, 31, 28,
27, 25, 24, 24, 23, 22, 24, 23, 25, 25, 24, 23, 22, 21, 19, 17, 15, 12, 11, 9,
8, 8, 7, 8, 8, 9, 9, 9, 9, 8, 6, 3, 0, -4, -6, -8, -9, -8, -9, -8, -7, -7, -6,
-6, -6, -7, -7, -8, -10, -14, -17, -20, -23, -24, -25, -24, -22, -22, -21, -22,
-23, -25, -27, -29, -30, -32, -33, -35, -36, -37, -38, -38, -38, -38, -37, -36,
-38, -38, -39, -40, -41, -43, -45, -47, -48, -50, -52, -54, -55, -55, -55, -53,
-52, -52, -52, -53, -55, -57, -60, -64, -67, -69, -69, -69, -68, -68, -68, -67,
-68, -69, -71, -72, -73, -75, -76, -77, -80, -82, -83, -84, -84, -84, -83, -82,
-83, -84, -84, -85, -85, -87, -89, -90, -93, -94, -96, -97, -98, -99, -100,
-100, -99, -99, -98, -98, -99, -100, -100, -103, -104, -106, -109, -110, -111,
-112, -113, -114, -114, -114, -115, -115, -115, -114, -114, -114, -113, -111,
-110, -109, -108, -108, -107, -108, -109, -108, -107, -107, -107, -106, -106,
-104, -103, -99, -97, -95, -93, -92, -91, -91, -92, -93, -93, -93, -92, -92,
-92, -91, -90, -88, -87, -85, -82, -78, -76, -76, -75, -76, -78, -79, -78, -78,
-76, -75, -71, -69, -65, -63, -61, -60, -60, -61, -61, -61, -62, -63, -63, -62,
-61, -60, -58, -56, -53, -50, -48, -45, -45, -44, -44, -45, -46, -46, -46, -46,
-47, -47, -46, -44, -43, -40, -37, -35, -32, -29, -28, -29, -28, -29, -31, -31,
-31, -31, -31, -31, -31, -29, -26, -23, -21, -17, -15, -14, -13, -15, -16, -17,
-17, -17, -15, -13, -9, -6, -4, -1, 1, 2, 1, 2, 1, 1, 2, 0, -1, -1, 0, -1, };