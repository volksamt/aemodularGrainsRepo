#define DATA_LENGTH 512
#define DATA AKWF_vgame_0116

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 1, 4, 4, 5, 5, 8, 8, 8, 10,
11, 12, 12, 13, 13, 15, 15, 17, 17, 18, 20, 21, 21, 22, 23, 25, 26, 26, 28, 28,
28, 29, 31, 33, 33, 33, 34, 38, 38, 39, 38, 40, 40, 41, 42, 43, 45, 45, 47, 47,
47, 50, 50, 50, 51, 52, 54, 54, 55, 56, 56, 58, 59, 60, 61, 63, 62, 64, 65, 66,
66, 68, 70, 68, 71, 70, 72, 73, 74, 76, 75, 77, 78, 79, 79, 81, 81, 83, 82, 84,
86, 85, 88, 87, 90, 89, 91, 91, 94, 93, 95, 95, 95, 97, 98, 101, 102, 101, 102,
104, 103, 106, 104, 108, 107, 110, 108, 110, 108, 116, 111, 117, 110, 120, 111,
127, 97, -45, -38, -37, -38, -35, -37, -31, -35, -30, -33, -30, -32, -28, -29,
-25, -27, -24, -25, -22, -23, -21, -22, -19, -19, -17, -17, -16, -15, -12, -12,
-12, -11, -10, -6, -8, -7, -8, -5, -6, -3, -3, -2, -1, 1, 2, 0, 5, 6, 6, 5, 7,
6, 8, 9, 12, 12, 12, 13, 14, 16, 17, 18, 18, 20, 19, 21, 21, 22, 24, 25, 27, 27,
28, 28, 30, 30, 31, 32, 33, 35, 35, 36, 36, 37, 38, 41, 40, 41, 42, 44, 44, 45,
46, 47, 49, 48, 50, 49, 51, 53, 54, 56, 56, 56, 57, 58, 60, 60, 61, 63, 63, 63,
64, 64, 69, 69, 70, 67, 71, 70, 74, 73, 75, 74, 76, 77, 77, 85, -36, -93, -72,
-80, -73, -77, -73, -74, -71, -72, -71, -70, -68, -68, -66, -67, -65, -64, -62,
-62, -61, -60, -59, -58, -58, -56, -56, -52, -52, -51, -52, -51, -51, -49, -47,
-48, -46, -44, -43, -44, -43, -40, -39, -40, -38, -39, -37, -36, -34, -33, -34,
-31, -31, -30, -29, -27, -28, -27, -25, -24, -23, -22, -22, -21, -18, -19, -17,
-17, -15, -15, -14, -12, -13, -11, -11, -8, -8, -8, -7, -6, -4, -3, -3, -2, 1,
-1, 2, 1, 2, 4, 5, 7, 6, 8, 9, 12, 11, 11, 12, 15, 13, 16, 15, 15, 17, 20, 20,
21, 22, 25, 25, 24, 26, 25, 29, 27, 30, 29, 32, 29, 35, 31, 39, 32, 43, 29, 52,
2, -128, -113, -119, -116, -115, -115, -113, -114, -110, -111, -109, -111, -107,
-107, -105, -106, -103, -102, -101, -101, -100, -100, -98, -97, -95, -96, -94,
-94, -92, -92, -90, -89, -89, -87, -88, -85, -84, -84, -83, -81, -82, -80, -80,
-78, -78, -77, -76, -75, -73, -72, -71, -72, -70, -69, -67, -67, -66, -66, -64,
-62, -63, -61, -61, -58, -59, -57, -58, -57, -55, -53, -52, -52, -50, -50, -48,
-48, -47, -47, -45, -44, -44, -43, -42, -40, -40, -38, -37, -37, -36, -33, -32,
-32, -32, -31, -30, -30, -27, -29, -27, -25, -24, -23, -23, -21, -19, -19, -19,
-18, -17, -15, -15, -15, -14, -12, -11, -10, -9, -8, -7, -7, -5, -5, -4, -3, -1,
-1, 0, };