#define DATA_LENGTH 512
#define DATA AKWF_vgame_0058

const PROGMEM int8_t DATA[DATA_LENGTH] = {102, 106, 99, 115, 112, 117, 112, 116,
112, 116, 112, 115, 114, 115, 113, 115, 114, 114, 115, 114, 115, 114, 115, 113,
115, 113, 115, 116, 121, 117, 120, 118, 120, 118, 120, 119, 118, 121, 117, 122,
113, 127, 107, 127, -3, -121, -83, -105, -91, -101, -93, -98, -95, -99, -95,
-97, -96, -98, -74, -66, -70, -67, -71, -68, -71, -68, -71, -68, -71, -68, -71,
-67, -58, -55, -57, -55, -56, -56, -57, -56, -57, -57, -57, -56, -58, -53, -43,
-44, -43, -44, -43, -43, -44, -43, -44, -44, -43, -43, -44, -44, -44, -44, -44,
-43, -43, -44, -44, -43, -45, -41, -34, -34, -34, -33, -33, -34, -35, -34, -33,
-34, -35, -33, -35, -33, -34, -34, -34, -28, -27, -27, -27, -27, -27, -28, -28,
-28, -26, -24, -24, -24, -24, -22, -23, -22, -22, -22, -23, -23, -22, -22, -22,
-22, -23, -23, -22, -19, -20, -19, -19, -19, -19, -19, -20, -20, -18, -19, -20,
-20, -15, -13, -14, -12, -12, -13, -13, -12, -13, -12, -12, -13, -13, -12, -13,
-13, -12, -13, -13, -13, -13, -12, -13, -11, -10, -9, -10, -8, -2, -3, -3, -3,
-3, -4, -3, -4, -3, -4, -3, -4, -4, -2, 0, 0, 1, 0, 0, -1, 0, -1, 0, 8, 10, 9,
10, 8, 9, 8, 8, 8, 8, 8, 8, 9, 8, 8, 8, 9, 8, 19, 22, 20, 21, 21, 22, 21, 21,
21, 21, 21, 20, 21, 21, 21, 21, 22, 21, 21, 21, 21, 21, 21, 20, 21, 21, 21, 21,
21, 21, 21, 22, 22, 21, 22, 21, 20, 21, 21, 20, 21, 21, 23, 22, 23, 22, 22, 23,
23, 23, 22, 22, 23, 23, 22, 23, 23, 22, 22, 22, 22, 23, 22, 22, 23, 22, 22, 23,
23, 23, 22, 23, 23, 23, 23, 23, 23, 23, 22, 23, 23, 22, 23, 23, 22, 22, 22, 22,
22, 23, 22, 23, 23, 23, 22, 22, 23, 24, 24, 24, 24, 24, 24, 24, 25, 25, 24, 24,
24, 25, 23, 23, 23, 22, 23, 22, 23, 22, 23, 23, 23, 22, 23, 22, 16, 16, 16, 16,
16, 16, 16, 17, 17, 16, 17, 17, 16, 15, 16, 16, 16, 16, 16, 15, 17, 16, 14, 13,
13, 13, 13, 13, 13, 12, 13, 12, 14, 12, 12, 13, 12, 13, 13, 13, 10, 5, 5, 5, 6,
4, 5, 4, 5, 6, 5, 5, 5, 5, 6, 5, 5, 5, 5, 5, 5, 5, 6, 5, 5, 6, 5, 4, -1, -2, -1,
-2, -1, -1, -2, -2, -1, -2, -1, -1, -2, -1, -4, -7, -6, -7, -6, -7, -6, -6, -6,
-6, -7, -6, -7, -4, -23, -33, -29, -32, -29, -31, -30, -31, -31, -31, -30, -30,
-31, -31, -42, -45, -43, -43, -43, -43, -43, -43, -43, -44, -41, -71, -84, -80,
-80, -78, -79, -78, -79, -79, -80, -78, -80, -78, -79, -78, -79, -77, -80, -77,
-81, -77, -80, -78, -80, -78, -80, -78, -78, -87, -10, };