#define DATA_LENGTH 512
#define DATA AKWF_vgame_0115

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 3, 4, 6, 6, 6, 8, 12, 13, 12,
13, 12, 12, 15, 17, 15, 18, 19, 19, 19, 23, 25, 25, 26, 25, 25, 25, 27, 29, 29,
29, 33, 33, 33, 36, 36, 35, 36, 39, 40, 39, 41, 43, 43, 42, 45, 45, 45, 48, 49,
48, 50, 52, 52, 52, 55, 55, 55, 56, 59, 57, 58, 61, 61, 61, 63, 65, 64, 66, 67,
67, 67, 69, 71, 70, 72, 74, 73, 74, 76, 77, 77, 79, 80, 80, 81, 83, 83, 83, 86,
87, 86, 87, 90, 89, 90, 92, 94, 92, 95, 96, 96, 96, 99, 99, 99, 99, 103, 103,
102, 105, 107, 107, 105, 110, 108, 112, 111, 114, 110, 115, 113, 119, 112, 122,
112, 127, 69, -53, -33, -37, -34, -34, -35, -32, -32, -31, -32, -28, -28, -27,
-27, -23, -25, -20, -22, -21, -22, -19, -19, -18, -17, -16, -16, -15, -12, -12,
-11, -9, -8, -9, -8, -6, -6, -6, -3, -2, -3, -2, 1, 0, 2, 4, 4, 5, 5, 7, 6, 8,
10, 11, 10, 9, 12, 14, 17, 18, 16, 17, 18, 20, 21, 21, 22, 24, 24, 25, 26, 28,
30, 29, 30, 32, 34, 33, 33, 33, 36, 37, 35, 39, 40, 43, 43, 43, 42, 42, 44, 46,
46, 46, 50, 49, 48, 52, 53, 55, 55, 55, 56, 55, 59, 58, 58, 59, 64, 60, 63, 64,
67, 67, 70, 67, 69, 68, 72, 71, 72, 75, 74, 77, 70, 92, -37, -92, -70, -85, -74,
-80, -71, -78, -73, -76, -70, -74, -71, -69, -64, -66, -65, -65, -66, -65, -62,
-62, -63, -60, -58, -59, -59, -53, -52, -52, -54, -51, -52, -51, -49, -48, -49,
-45, -46, -46, -44, -39, -39, -39, -39, -39, -39, -37, -36, -37, -35, -33, -33,
-33, -30, -26, -26, -26, -27, -26, -26, -24, -23, -24, -21, -19, -21, -20, -16,
-14, -14, -14, -14, -14, -12, -11, -10, -10, -7, -7, -8, -6, -1, -1, -1, -1, -1,
-1, -1, 2, 2, 1, 4, 7, 5, 8, 9, 10, 9, 12, 13, 13, 13, 17, 16, 16, 18, 20, 19,
21, 22, 22, 23, 25, 26, 24, 28, 30, 33, 30, 34, 30, 34, 31, 37, 32, 38, 35, 41,
39, -93, -122, -116, -119, -113, -118, -112, -113, -110, -114, -109, -110, -108,
-110, -104, -106, -104, -104, -101, -103, -101, -99, -99, -98, -97, -95, -96,
-94, -92, -92, -92, -90, -90, -89, -88, -86, -87, -86, -85, -82, -84, -82, -79,
-78, -79, -77, -76, -75, -73, -72, -73, -73, -69, -68, -70, -67, -66, -67, -66,
-62, -63, -61, -60, -60, -59, -60, -57, -56, -57, -54, -52, -53, -51, -49, -51,
-48, -46, -46, -46, -45, -42, -44, -43, -41, -39, -41, -38, -37, -37, -34, -34,
-34, -34, -32, -31, -31, -29, -27, -27, -27, -24, -25, -23, -21, -20, -21, -21,
-18, -18, -18, -16, -15, -15, -14, -12, -12, -9, -8, -8, -8, -8, -6, -3, -5, -4,
-1, -1, -1, };