#define DATA_LENGTH 512
#define DATA AKWF_vgame_0132

const PROGMEM int8_t DATA[DATA_LENGTH] = {17, 25, 22, 24, 24, 22, 61, 72, 68,
71, 68, 70, 70, 70, 69, 69, 71, 69, 71, 113, 116, 114, 116, 114, 115, 115, 115,
114, 116, 115, 116, 115, 115, 115, 115, 115, 115, 115, 115, 115, 115, 114, 115,
116, 114, 115, 115, 115, 115, 114, 114, 114, 115, 115, 115, 114, 116, 114, 116,
113, 119, 106, 69, 70, 69, 70, 69, 69, 69, 68, 69, 68, 70, 68, 70, 69, 70, 69,
70, 69, 70, 68, 71, 67, 30, 21, 25, 22, 24, 23, 23, 23, 23, 23, 23, 23, 22, 23,
23, 23, 24, 24, 23, 23, 23, 23, 23, 24, 22, 23, 23, 23, 23, 23, 23, 22, 24, 20,
52, 74, 67, 71, 67, 70, 68, 69, 68, 69, 68, 69, 69, 69, 68, 68, 69, 68, 68, 69,
69, 69, 69, 68, 68, 68, 69, 68, 69, 68, 68, 69, 68, 68, 68, 68, 69, 69, 68, 69,
68, 70, 67, 68, 68, 69, 67, 69, 67, 70, 66, 72, 48, 18, 25, 22, 24, 22, 24, 22,
24, 21, 25, 20, 27, -6, -29, -19, -25, -21, -24, -22, -24, -22, -24, -23, -24,
-21, -25, -21, -26, -17, -48, -74, -65, -72, -66, -69, -68, -69, -67, -69, -68,
-69, -69, -69, -69, -68, -69, -69, -69, -68, -68, -68, -68, -68, -68, -68, -69,
-68, -68, -68, -69, -68, -70, -67, -70, -67, -70, -67, -71, -60, -20, -23, -21,
-24, -23, -24, -22, -24, -21, -25, -19, -28, -8, 27, 20, 24, 21, 24, 22, 24, 23,
23, 22, 24, 23, 25, 21, 26, 19, 34, 71, 68, 69, 67, 69, 68, 69, 69, 68, 68, 68,
68, 68, 69, 69, 69, 68, 69, 68, 69, 68, 69, 68, 69, 67, 69, 67, 68, 68, 69, 68,
68, 68, 68, 67, 69, 68, 69, 69, 30, 20, 23, 22, 23, 23, 22, 23, 23, 23, 22, 25,
18, -20, -24, -22, -23, -23, -22, -23, -22, -23, -23, -23, -22, -22, -23, -23,
-22, -23, -62, -71, -67, -69, -68, -69, -68, -68, -68, -69, -68, -69, -68, -70,
-68, -69, -69, -69, -68, -68, -69, -69, -68, -68, -68, -69, -68, -68, -68, -68,
-68, -68, -69, -68, -68, -68, -68, -68, -68, -69, -69, -68, -68, -68, -68, -69,
-68, -70, -67, -69, -67, -72, -37, -18, -26, -21, -24, -23, -23, -22, -23, -23,
-22, -22, -24, -22, -23, -23, -23, -22, -23, -22, -23, -22, -23, -23, -23, -22,
-23, -23, -22, -23, -23, -62, -72, -66, -70, -67, -69, -68, -68, -67, -68, -68,
-68, -68, -68, -68, -68, -68, -68, -68, -67, -68, -67, -68, -67, -72, -110,
-115, -113, -114, -113, -115, -113, -114, -113, -114, -113, -114, -112, -114,
-114, -114, -113, -114, -113, -114, -113, -114, -113, -113, -113, -113, -113,
-113, -113, -113, -114, -113, -113, -113, -114, -112, -115, -112, -114, -112,
-116, -109, -119, -92, -62, -70, -67, -68, -67, -68, -66, -70, -28, -19, -23,
-21, -22, -21, -22, -21, -21, -21, -21, -23, -21, };