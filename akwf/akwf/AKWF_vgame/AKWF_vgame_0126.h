#define DATA_LENGTH 512
#define DATA AKWF_vgame_0126

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 24, 22, 22, 24, 22, 25, 19, 31, 72,
68, 71, 67, 76, 117, 116, 117, 117, 118, 117, 116, 117, 117, 117, 117, 116, 117,
118, 116, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 118,
116, 117, 117, 117, 117, 117, 117, 117, 118, 116, 117, 117, 117, 116, 117, 117,
117, 116, 117, 115, 118, 116, 117, 116, 118, 115, 120, 103, 65, 71, 68, 70, 69,
69, 70, 69, 69, 70, 69, 68, 70, 69, 69, 69, 69, 69, 69, 68, 70, 69, 69, 69, 70,
70, 69, 69, 69, 69, 69, 69, 69, 70, 68, 70, 69, 70, 69, 69, 69, 69, 69, 68, 69,
70, 69, 69, 69, 69, 69, 69, 68, 68, 68, 68, 68, 69, 69, 69, 69, 69, 69, 69, 69,
69, 70, 68, 69, 69, 69, 69, 68, 68, 68, 69, 69, 68, 69, 69, 69, 69, 69, 69, 69,
68, 68, 69, 69, 68, 69, 69, 69, 69, 68, 68, 68, 68, 68, 69, 68, 69, 68, 69, 68,
68, 68, 69, 68, 68, 68, 68, 68, 68, 69, 69, 68, 67, 69, 67, 70, 66, 74, 40, 15,
24, 19, 22, 21, 22, 21, 21, 22, 20, 21, 21, 21, 21, 22, 21, 22, 21, 21, 20, 21,
21, 21, 21, 21, 21, 22, 21, 21, 22, 22, 21, 20, 22, 21, 21, 21, 22, 20, 22, 21,
22, 20, 21, 21, 21, 20, 21, 20, 21, 21, 21, 21, 20, 25, -11, -29, -24, -27, -26,
-26, -27, -23, -32, -7, 25, 19, 22, 19, 22, 20, 21, 20, 21, 21, 21, 22, 22, 20,
22, 21, 21, 20, 21, 22, 21, 21, 20, 25, -17, -29, -24, -28, -25, -27, -25, -26,
-25, -27, -26, -26, -25, -27, -26, -26, -26, -27, -26, -26, -25, -26, -26, -26,
-26, -26, -27, -26, -26, -26, -26, -26, -26, -25, -27, -26, -27, -26, -27, -24,
-27, -22, -45, -80, -70, -74, -72, -73, -73, -73, -73, -73, -73, -73, -73, -73,
-73, -73, -73, -73, -74, -72, -74, -74, -73, -73, -73, -73, -72, -73, -73, -73,
-73, -72, -73, -73, -73, -73, -73, -73, -73, -73, -72, -73, -72, -73, -73, -73,
-72, -73, -73, -73, -73, -72, -72, -73, -72, -72, -72, -73, -73, -73, -73, -73,
-73, -73, -72, -72, -73, -72, -73, -73, -73, -72, -72, -72, -72, -73, -72, -72,
-73, -72, -72, -72, -72, -73, -73, -72, -73, -72, -73, -73, -72, -73, -73, -72,
-72, -72, -71, -73, -72, -73, -72, -72, -72, -73, -72, -73, -72, -72, -73, -72,
-73, -72, -73, -72, -73, -72, -72, -71, -73, -71, -74, -68, -90, -123, -117,
-120, -118, -119, -119, -119, -119, -119, -119, -119, -118, -118, -118, -118,
-120, -119, -120, -119, -119, -118, -118, -119, -120, -119, -119, -119, -119,
-119, -118, -118, -118, -118, -119, -119, -118, -119, -119, -118, -119, -119,
-119, -118, -118, -118, -119, -119, -119, -118, -118, -119, -119, -118, -118,
-118, -118, -118, -112, -76, -68, -76, -45, -20, };