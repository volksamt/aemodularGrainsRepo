#define DATA_LENGTH 512
#define DATA AKWF_vgame_0113

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 32, 51, 69, 93, 113, 118, 108, 82,
56, 35, 22, 16, 15, 16, 19, 24, 28, 31, 33, 34, 35, 37, 37, 38, 37, 36, 37, 36,
37, 37, 37, 37, 37, 36, 36, 36, 36, 36, 36, 35, 35, 34, 35, 35, 35, 35, 34, 34,
34, 34, 34, 34, 33, 33, 33, 34, 34, 33, 33, 32, 33, 32, 32, 34, 19, -9, -26,
-48, -77, -95, -96, -77, -47, -17, 2, 11, 16, 14, 11, 7, 3, -1, -5, -6, -8, -9,
-10, -10, -10, -10, -11, -11, -10, -10, -10, -10, -9, -10, -9, -10, -9, -9, -9,
-10, -9, -10, -10, -10, -9, -9, -10, -10, -9, -9, -9, -9, -9, -9, -9, -9, -9,
-8, -9, -8, -8, -8, -8, -8, -8, -9, -8, -8, -8, -8, -8, -8, -8, -8, -8, -7, -8,
-7, -8, -8, -8, -7, -7, -7, -7, -8, -8, -7, -7, -8, -7, -6, -8, -7, -6, -7, -6,
-6, -8, -7, -7, -7, -6, -6, -7, -6, -7, -7, -7, -6, -6, -6, -7, -6, -7, -6, -6,
-6, -6, -5, -7, -7, -6, -6, -6, -6, -6, -7, -7, -7, -6, -5, -7, -5, -6, -6, -6,
-7, -6, -6, -6, -5, -5, -6, -5, -5, -5, -5, -6, -6, -5, -5, -5, -5, -5, -6, -5,
-6, -5, -4, -5, -5, -5, -5, -6, -5, -4, -5, -5, -4, -5, -5, -5, -6, -5, -6, -5,
-5, -5, -5, -5, -4, -5, -5, -4, -5, -5, -4, -4, -4, -5, -4, -4, -5, -5, -5, -4,
-4, -4, -4, -5, -5, -5, -5, -4, -5, -5, -5, -4, -4, -4, -5, -4, -5, -4, -5, -4,
-5, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -5, -4, -4, -5, -4, -4,
-4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4,
-4, -4, -4, -4, -4, -4, -4, -3, -4, -4, -4, -4, -4, -4, -3, -4, -4, -3, -4, -4,
-3, -4, -4, -4, -4, -3, -3, -4, -4, -4, -4, -3, -4, -3, -4, -4, -4, -4, -4, -4,
-3, -4, -3, -4, -3, -4, -4, -4, -4, -3, -4, -3, -3, -4, -4, -4, -3, -4, -3, -4,
-3, -3, -4, -3, -3, -4, -3, -4, -4, -3, -3, -4, -3, -4, -4, -3, -3, -3, -3, -4,
-3, -4, -4, -4, -3, -4, -4, -4, -3, -4, -3, -3, -3, -3, -4, -4, -4, -3, -4, -3,
-3, -4, -4, -4, -3, -4, -3, -3, -3, -3, -3, -3, -4, -3, -3, -3, -3, -4, -3, -3,
-3, -4, -4, -4, -4, -3, -4, -4, -4, -3, -3, -4, -3, -4, -4, -4, -3, -3, -3, -3,
-3, -3, -3, -4, -3, -3, -3, -3, -3, -2, -4, -4, -4, -3, -3, -4, -3, -3, -3, -3,
-2, -3, -4, -3, -3, -4, -3, -3, -3, -3, -3, -3, -4, -4, -3, -4, -3, -4, -4, -3,
-3, -3, -3, -3, -4, -2, -5, 1, -2, -3, };