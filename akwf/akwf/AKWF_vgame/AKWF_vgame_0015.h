#define DATA_LENGTH 512
#define DATA AKWF_vgame_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 10, 19, 17, 18, 17, 18, 17, 18, 16,
22, 32, 33, 32, 33, 44, 47, 45, 47, 45, 48, 59, 62, 59, 61, 59, 62, 69, 76, 84,
82, 83, 83, 83, 83, 82, 83, 88, 89, 89, 90, 89, 94, 96, 95, 96, 95, 95, 101,
103, 104, 104, 102, 109, 112, 111, 115, 114, 114, 114, 114, 115, 113, 114, 114,
112, 112, 113, 113, 113, 113, 113, 112, 114, 112, 114, 114, 114, 114, 116, 111,
109, 110, 102, 101, 102, 101, 101, 102, 102, 102, 99, 94, 96, 95, 97, 91, 81,
84, 81, 84, 80, 72, 71, 72, 71, 73, 68, 60, 63, 52, 48, 49, 49, 49, 50, 49, 50,
46, 37, 38, 38, 39, 36, 27, 28, 26, 28, 26, 17, 16, 17, 16, 17, 15, 6, 7, 3, -1,
1, 0, 0, 0, 0, 0, -3, -5, -4, -5, -4, -5, -11, -11, -11, -12, -10, -13, -12,
-13, -13, -13, -11, -11, -11, -11, -13, -13, -12, -13, -12, -13, -13, -14, -15,
-14, -15, -15, -15, -13, -12, -13, -12, -13, -13, -13, -13, -13, -13, -11, -11,
-12, -10, -6, -6, -6, -6, -7, -6, -6, -4, -1, -2, -1, -2, 0, 8, 12, 11, 11, 11,
11, 11, 11, 12, 11, 14, 18, 17, 18, 25, 26, 25, 26, 26, 25, 26, 34, 33, 34, 33,
33, 34, 41, 46, 46, 46, 46, 46, 46, 47, 46, 46, 51, 51, 51, 50, 53, 55, 54, 54,
54, 53, 54, 54, 54, 54, 55, 55, 53, 51, 49, 49, 50, 49, 50, 49, 49, 49, 49, 46,
46, 46, 46, 45, 42, 43, 42, 43, 43, 43, 39, 38, 39, 38, 38, 35, 32, 28, 27, 26,
27, 27, 28, 27, 27, 27, 26, 23, 23, 24, 23, 21, 21, 21, 21, 21, 21, 21, 21, 21,
20, 20, 19, 18, 14, 12, 13, 13, 12, 13, 13, 13, 13, 10, 11, 12, 11, 11, 8, 8, 8,
8, 8, 7, 0, 2, 2, 2, 1, -4, -3, -7, -8, -8, -8, -8, -8, -9, -7, -9, -17, -17,
-18, -17, -18, -23, -24, -24, -24, -24, -24, -28, -28, -28, -29, -28, -35, -34,
-36, -41, -42, -41, -41, -41, -42, -42, -41, -46, -48, -48, -48, -47, -54, -58,
-57, -58, -56, -61, -63, -63, -63, -64, -63, -67, -69, -68, -77, -77, -76, -77,
-76, -76, -75, -80, -85, -84, -84, -85, -83, -88, -93, -92, -93, -90, -96, -103,
-101, -102, -101, -104, -108, -108, -108, -110, -112, -112, -111, -110, -112,
-111, -112, -114, -114, -114, -114, -115, -116, -118, -118, -117, -117, -118,
-119, -119, -119, -119, -119, -117, -117, -118, -117, -116, -116, -116, -117,
-116, -116, -115, -110, -109, -110, -109, -110, -102, -95, -96, -95, -96, -95,
-95, -95, -95, -95, -95, -88, -84, -87, -80, -73, -74, -74, -75, -75, -75, -75,
-68, -66, -68, -66, -68, -57, -41, -39, -40, -40, -40, -39, -39, -39, -40, -40,
-30, -24, -27, -20, -7, -7, -8, -8, -8, -8, -3, };