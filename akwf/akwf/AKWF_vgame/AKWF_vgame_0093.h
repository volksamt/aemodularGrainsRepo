#define DATA_LENGTH 512
#define DATA AKWF_vgame_0093

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 16, 23, 30, 38, 46, 53, 60, 66,
73, 79, 85, 92, 96, 101, 105, 108, 111, 113, 115, 115, 116, 115, 115, 113, 111,
108, 105, 102, 97, 92, 87, 81, 74, 68, 62, 57, 50, 44, 38, 33, 27, 23, 17, 11,
8, 5, 2, 0, -3, -4, -6, -6, -6, -5, -5, -3, -2, -1, 2, 4, 8, 11, 15, 19, 23, 28,
32, 37, 42, 47, 52, 56, 63, 68, 74, 78, 83, 87, 90, 94, 97, 99, 101, 102, 103,
104, 105, 104, 104, 102, 100, 98, 96, 92, 90, 86, 81, 77, 71, 66, 61, 57, 52,
46, 42, 38, 33, 28, 24, 21, 16, 14, 11, 7, 3, 1, -1, -4, -5, -5, -5, -5, -4, -2,
0, 4, 6, 11, 15, 19, 24, 29, 34, 40, 46, 52, 57, 62, 67, 71, 77, 80, 83, 87, 90,
93, 95, 98, 98, 101, 101, 102, 102, 101, 100, 99, 98, 96, 92, 89, 87, 83, 79,
76, 73, 68, 65, 59, 56, 51, 46, 43, 38, 34, 30, 28, 24, 22, 20, 19, 17, 17, 17,
18, 19, 19, 20, 22, 23, 25, 27, 29, 31, 35, 37, 39, 43, 46, 50, 53, 58, 61, 64,
69, 72, 74, 78, 81, 84, 88, 89, 92, 94, 96, 97, 98, 99, 99, 98, 97, 95, 94, 91,
88, 85, 82, 78, 75, 72, 67, 64, 61, 58, 55, 53, 52, 50, 48, 46, 44, 44, 42, 41,
40, 38, 37, 36, 35, 34, 33, 32, 31, 30, 28, 27, 26, 23, 21, 18, 15, 12, 9, 4,
-1, -6, -11, -17, -23, -29, -35, -42, -48, -55, -62, -68, -74, -81, -87, -93,
-98, -103, -108, -111, -115, -117, -118, -119, -119, -119, -118, -117, -114,
-112, -108, -105, -100, -96, -90, -85, -80, -73, -67, -63, -56, -51, -46, -41,
-36, -30, -26, -22, -18, -15, -11, -7, -5, -3, -1, 0, 1, 1, 1, 0, -2, -3, -7,
-9, -13, -18, -23, -28, -33, -38, -44, -50, -55, -60, -65, -69, -74, -79, -84,
-89, -93, -98, -102, -105, -108, -110, -111, -113, -113, -113, -112, -110, -108,
-106, -103, -100, -95, -90, -85, -80, -74, -68, -62, -55, -49, -44, -40, -33,
-29, -25, -21, -19, -16, -14, -13, -12, -12, -13, -14, -16, -19, -21, -24, -26,
-30, -32, -36, -39, -44, -47, -51, -54, -58, -62, -66, -70, -74, -77, -81, -84,
-88, -90, -93, -96, -97, -98, -99, -99, -99, -99, -98, -96, -94, -92, -90, -87,
-85, -81, -78, -75, -71, -67, -63, -60, -57, -53, -49, -45, -43, -40, -38, -35,
-34, -33, -31, -31, -30, -29, -30, -30, -29, -30, -31, -32, -32, -34, -36, -38,
-40, -43, -43, -46, -48, -51, -54, -55, -57, -60, -63, -65, -67, -69, -71, -72,
-73, -75, -75, -76, -77, -77, -77, -77, -76, -76, -74, -74, -74, -72, -70, -69,
-68, -67, -64, -64, -62, -60, -58, -57, -55, -52, -51, -49, -47, -46, -43, -42,
-40, -39, -37, -33, -30, -27, -24, -19, -14, -8, -2, };