#define DATA_LENGTH 512
#define DATA AKWF_vgame_0074

const PROGMEM int8_t DATA[DATA_LENGTH] = {15, 46, 73, 95, 110, 118, 119, 113,
103, 92, 85, 79, 76, 79, 83, 88, 93, 97, 100, 99, 97, 93, 90, 88, 87, 88, 90,
91, 93, 95, 97, 95, 94, 94, 93, 91, 89, 88, 89, 92, 92, 92, 94, 95, 94, 94, 93,
91, 92, 89, 89, 91, 92, 92, 91, 92, 94, 94, 93, 92, 91, 92, 92, 91, 91, 91, 91,
91, 91, 92, 91, 91, 91, 92, 91, 91, 91, 91, 91, 91, 90, 91, 92, 91, 91, 91, 92,
91, 90, 91, 91, 90, 91, 91, 91, 90, 91, 91, 90, 91, 91, 91, 91, 91, 91, 90, 91,
91, 91, 91, 91, 91, 91, 90, 92, 91, 91, 90, 90, 90, 91, 90, 90, 91, 91, 91, 91,
91, 91, 90, 90, 90, 90, 91, 90, 90, 91, 91, 90, 90, 91, 90, 90, 91, 90, 90, 91,
91, 91, 90, 91, 90, 91, 90, 90, 90, 90, 91, 90, 90, 90, 90, 90, 90, 90, 90, 89,
90, 89, 89, 90, 90, 91, 90, 91, 90, 90, 90, 90, 90, 90, 89, 90, 90, 90, 90, 90,
90, 89, 90, 90, 90, 89, 91, 90, 90, 89, 90, 89, 90, 90, 89, 89, 90, 91, 93, 92,
91, 89, 90, 88, 87, 90, 89, 89, 92, 92, 92, 93, 92, 89, 88, 87, 86, 87, 88, 89,
90, 92, 95, 96, 97, 95, 91, 86, 83, 81, 79, 78, 81, 87, 92, 97, 102, 106, 107,
105, 100, 93, 80, 65, 44, 17, -8, -36, -61, -84, -101, -111, -114, -111, -105,
-98, -89, -84, -81, -79, -81, -83, -87, -91, -93, -92, -92, -92, -92, -91, -89,
-90, -90, -90, -90, -90, -90, -90, -90, -90, -89, -90, -90, -90, -89, -89, -90,
-90, -89, -90, -89, -89, -90, -89, -89, -90, -90, -90, -90, -90, -90, -89, -89,
-89, -90, -90, -89, -89, -89, -89, -89, -90, -90, -89, -90, -89, -89, -90, -90,
-90, -90, -89, -89, -89, -89, -90, -89, -89, -90, -88, -89, -89, -88, -89, -90,
-89, -89, -89, -88, -89, -89, -88, -89, -89, -88, -90, -89, -89, -89, -89, -89,
-89, -89, -89, -90, -89, -89, -89, -90, -88, -89, -89, -88, -89, -89, -89, -88,
-89, -89, -88, -89, -88, -89, -88, -89, -89, -88, -89, -89, -89, -88, -89, -89,
-88, -89, -89, -88, -89, -89, -89, -89, -88, -89, -88, -88, -88, -88, -88, -88,
-88, -88, -89, -87, -88, -89, -89, -89, -89, -88, -88, -88, -88, -88, -88, -88,
-87, -88, -89, -88, -88, -88, -88, -88, -88, -88, -88, -88, -88, -89, -90, -91,
-91, -91, -89, -89, -89, -88, -88, -88, -88, -88, -90, -91, -90, -90, -90, -91,
-89, -88, -88, -87, -86, -88, -88, -88, -90, -90, -90, -91, -89, -88, -87, -86,
-85, -85, -86, -88, -88, -91, -92, -91, -91, -90, -86, -85, -84, -84, -85, -87,
-89, -90, -95, -95, -95, -93, -89, -84, -81, -79, -77, -80, -81, -85, -90, -94,
-98, -102, -102, -102, -99, -91, -76, -57, -35, -8, };