#define DATA_LENGTH 512
#define DATA AKWF_vgame_0079

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 27, 37, 44, 48, 52, 50, 47, 43,
40, 37, 34, 32, 31, 31, 31, 31, 30, 31, 33, 33, 35, 37, 39, 40, 39, 40, 40, 39,
38, 37, 35, 34, 33, 33, 32, 34, 35, 36, 37, 38, 38, 38, 39, 38, 36, 37, 35, 34,
35, 35, 35, 34, 36, 37, 35, 36, 36, 36, 35, 37, 36, 37, 35, 34, 35, 33, 35, 36,
36, 36, 36, 35, 37, 36, 35, 36, 36, 35, 34, 35, 34, 34, 34, 34, 36, 36, 36, 36,
35, 36, 36, 36, 37, 35, 34, 33, 34, 34, 34, 35, 34, 35, 36, 36, 36, 35, 36, 35,
36, 36, 35, 34, 34, 33, 35, 34, 34, 34, 34, 36, 36, 35, 36, 36, 33, 34, 34, 34,
34, 33, 34, 34, 36, 37, 36, 36, 36, 36, 36, 35, 36, 35, 34, 34, 34, 35, 34, 33,
33, 34, 36, 35, 35, 35, 35, 34, 33, 33, 33, 34, 34, 33, 33, 35, 34, 33, 33, 34,
33, 34, 34, 33, 34, 33, 34, 35, 33, 33, 33, 33, 33, 33, 33, 33, 34, 33, 33, 33,
33, 34, 33, 33, 33, 34, 34, 35, 33, 34, 34, 33, 34, 34, 34, 34, 33, 35, 35, 36,
36, 36, 35, 34, 33, 34, 33, 33, 33, 34, 34, 34, 33, 35, 35, 35, 35, 36, 35, 36,
34, 35, 34, 34, 32, 34, 33, 33, 33, 34, 33, 33, 33, 34, 35, 35, 35, 35, 34, 36,
35, 35, 36, 36, 34, 33, 33, 33, 33, 33, 33, 33, 34, 35, 35, 35, 35, 35, 34, 35,
35, 35, 33, 34, 33, 34, 33, 32, 33, 34, 35, 35, 35, 36, 35, 34, 35, 35, 35, 35,
35, 35, 35, 36, 34, 36, 35, 34, 35, 34, 36, 35, 35, 35, 35, 35, 35, 34, 35, 35,
34, 35, 35, 35, 34, 34, 34, 35, 34, 34, 34, 35, 35, 34, 35, 35, 34, 35, 35, 36,
35, 35, 35, 34, 35, 34, 33, 33, 33, 33, 35, 34, 34, 35, 35, 34, 35, 35, 35, 36,
35, 34, 35, 34, 32, 33, 34, 35, 34, 35, 36, 35, 35, 34, 33, 31, 28, 27, 28, 28,
30, 35, 39, 43, 46, 49, 51, 48, 42, 31, 15, -1, -21, -40, -59, -77, -93, -105,
-111, -117, -119, -118, -115, -112, -108, -106, -102, -102, -101, -100, -101,
-102, -102, -104, -104, -103, -104, -104, -106, -106, -105, -105, -106, -106,
-105, -106, -105, -105, -106, -105, -104, -103, -103, -103, -103, -104, -104,
-103, -103, -105, -105, -106, -105, -106, -104, -105, -105, -105, -105, -104,
-103, -103, -103, -103, -103, -104, -105, -105, -106, -105, -105, -104, -105,
-105, -105, -103, -103, -102, -103, -103, -103, -103, -106, -105, -105, -104,
-105, -105, -105, -104, -103, -103, -103, -102, -103, -104, -103, -104, -105,
-104, -106, -107, -107, -106, -107, -106, -104, -103, -103, -102, -100, -99,
-98, -100, -98, -98, -99, -102, -105, -108, -111, -115, -118, -119, -118, -115,
-108, -97, -84, -68, -47, -18, -1, };