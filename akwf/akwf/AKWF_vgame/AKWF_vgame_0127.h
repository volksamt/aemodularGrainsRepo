#define DATA_LENGTH 512
#define DATA AKWF_vgame_0127

const PROGMEM int8_t DATA[DATA_LENGTH] = {13, 27, 18, 39, 73, 68, 71, 68, 71,
68, 71, 69, 71, 111, 117, 114, 116, 115, 116, 115, 115, 115, 116, 115, 116, 115,
116, 115, 115, 116, 115, 116, 115, 116, 115, 115, 115, 115, 114, 116, 115, 116,
115, 116, 116, 115, 115, 116, 115, 115, 115, 116, 115, 116, 116, 115, 116, 116,
115, 115, 115, 115, 115, 116, 115, 115, 115, 115, 115, 114, 115, 114, 114, 115,
115, 115, 115, 115, 114, 116, 113, 116, 114, 77, 66, 71, 68, 70, 69, 70, 69, 69,
69, 69, 69, 69, 70, 69, 69, 69, 69, 69, 68, 69, 69, 68, 69, 69, 68, 68, 68, 68,
68, 69, 68, 68, 69, 69, 69, 69, 69, 68, 68, 68, 68, 68, 69, 68, 68, 69, 69, 68,
68, 69, 68, 69, 69, 68, 69, 68, 69, 67, 69, 67, 68, 69, 68, 69, 68, 68, 69, 68,
68, 69, 68, 67, 69, 68, 69, 68, 68, 67, 69, 68, 69, 68, 67, 68, 68, 71, 37, 18,
24, 21, 24, 21, 23, 22, 23, 21, 22, 23, 22, 23, 23, 23, 22, 22, 23, 23, 22, 23,
23, 24, -12, -28, -21, -24, -23, -24, -23, -24, -23, -23, -24, -24, -24, -24,
-23, -23, -24, -23, -24, -23, -24, -23, -25, -21, -27, -66, -72, -68, -70, -68,
-71, -68, -70, -68, -69, -69, -70, -70, -69, -69, -69, -68, -68, -69, -68, -69,
-68, -70, -68, -70, -68, -71, -67, -72, -62, -25, -20, -26, -21, -27, -15, 21,
25, 20, 25, 18, 31, 69, 70, 67, 69, 66, 70, 67, 69, 67, 68, 67, 68, 68, 69, 68,
68, 68, 67, 69, 68, 69, 67, 69, 66, 69, 66, 69, 66, 72, 57, 19, 23, 22, 22, 22,
21, 23, 22, 23, 21, 22, 22, 23, 23, 22, 22, 21, 23, 22, 24, 21, 25, 20, 27, 2,
-29, -21, -25, -22, -23, -24, -24, -23, -22, -24, -24, -23, -23, -24, -23, -24,
-23, -23, -24, -23, -24, -23, -25, -18, -54, -74, -66, -72, -68, -70, -69, -70,
-69, -69, -68, -70, -70, -69, -69, -69, -69, -69, -70, -69, -70, -68, -70, -69,
-69, -69, -68, -69, -70, -69, -69, -69, -70, -68, -69, -69, -69, -68, -68, -69,
-70, -69, -69, -69, -69, -68, -69, -69, -69, -68, -69, -69, -69, -69, -69, -69,
-69, -69, -69, -69, -69, -69, -68, -69, -68, -69, -69, -68, -68, -69, -69, -69,
-69, -68, -69, -68, -69, -69, -70, -68, -69, -67, -70, -67, -72, -62, -87, -119,
-112, -115, -113, -115, -113, -115, -114, -113, -114, -115, -114, -114, -115,
-113, -114, -114, -115, -114, -114, -114, -114, -113, -115, -115, -115, -114,
-114, -114, -114, -114, -114, -114, -114, -114, -114, -114, -114, -113, -114,
-114, -113, -114, -113, -114, -114, -113, -113, -113, -113, -114, -114, -114,
-113, -114, -113, -113, -114, -113, -113, -113, -113, -114, -113, -113, -113,
-115, -111, -117, -96, -63, -70, -65, -69, -66, -69, -66, -70, -65, -27, -20,
-24, -19, -24, -21, };