#define DATA_LENGTH 512
#define DATA AKWF_vgame_0037

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 11, 15, 15, 15, 16, 23, 22, 29, 33,
33, 42, 41, 45, 49, 55, 57, 55, 60, 64, 62, 65, 67, 65, 69, 71, 71, 74, 77, 78,
79, 79, 80, 82, 82, 83, 83, 85, 85, 85, 89, 88, 89, 90, 90, 91, 93, 93, 94, 96,
94, 97, 97, 96, 96, 97, 98, 98, 98, 98, 97, 99, 99, 98, 99, 102, 101, 102, 104,
103, 107, 106, 107, 110, 109, 114, 114, 115, 117, 116, 116, 119, 120, 119, 119,
120, 116, 116, 116, 110, 113, 107, 106, 106, 101, 102, 98, 89, 87, 88, 86, 88,
82, 78, 78, 73, 73, 71, 69, 70, 66, 64, 64, 64, 64, 63, 60, 63, 59, 56, 57, 55,
53, 53, 47, 44, 43, 43, 44, 34, 34, 30, 23, 25, 16, 16, 17, 13, 3, 0, 0, 1, -2,
-5, -5, -8, -8, -9, -12, -11, -11, -11, -11, -11, -11, -11, -12, -13, -13, -16,
-14, -17, -20, -19, -23, -26, -31, -30, -31, -35, -38, -36, -41, -46, -44, -55,
-56, -59, -65, -68, -74, -72, -73, -78, -79, -81, -84, -83, -83, -84, -83, -84,
-84, -82, -82, -82, -82, -82, -82, -81, -81, -80, -79, -79, -78, -77, -77, -76,
-75, -75, -76, -77, -75, -75, -74, -73, -73, -73, -67, -67, -65, -62, -63, -56,
-55, -52, -46, -48, -47, -38, -38, -33, -22, -24, -16, -14, -12, -6, -8, -3, 0,
1, 8, 7, 10, 14, 12, 13, 15, 16, 19, 21, 20, 24, 24, 24, 25, 25, 25, 26, 25, 26,
25, 26, 25, 26, 26, 26, 25, 25, 26, 25, 25, 26, 26, 25, 24, 24, 24, 23, 21, 21,
19, 20, 20, 18, 14, 15, 9, 1, 1, 2, 2, 0, -2, -2, -3, -3, -3, -3, -3, -3, -2,
-2, -1, -2, -2, -2, -1, -3, -3, -3, -5, -5, -5, -6, -9, -12, -11, -13, -18, -18,
-17, -23, -24, -26, -33, -31, -36, -39, -41, -43, -41, -43, -43, -43, -45, -45,
-45, -46, -47, -48, -46, -48, -50, -50, -49, -53, -53, -53, -57, -56, -57, -58,
-58, -60, -59, -60, -60, -59, -60, -60, -60, -59, -57, -59, -59, -60, -60, -60,
-59, -60, -62, -60, -62, -61, -62, -61, -62, -60, -59, -60, -60, -59, -59, -58,
-57, -58, -57, -58, -58, -58, -57, -57, -56, -56, -56, -57, -55, -54, -55, -55,
-56, -55, -53, -53, -53, -53, -53, -52, -51, -51, -47, -46, -47, -46, -48, -42,
-39, -40, -36, -37, -33, -30, -30, -27, -24, -24, -25, -24, -23, -22, -23, -21,
-19, -19, -18, -18, -18, -17, -16, -16, -16, -17, -16, -16, -16, -16, -16, -16,
-16, -17, -15, -15, -16, -16, -16, -17, -18, -17, -18, -18, -18, -19, -20, -21,
-21, -22, -23, -23, -23, -23, -23, -23, -23, -23, -22, -22, -22, -22, -23, -23,
-23, -23, -24, -25, -23, -24, -24, -24, -24, -24, -24, -24, -24, -24, -24, -23,
-22, -23, -22, -21, -21, -18, -18, -16, -12, -13, -8, -7, -9, -2, };