#define DATA_LENGTH 512
#define DATA AKWF_vgame_0060

const PROGMEM int8_t DATA[DATA_LENGTH] = {52, 121, 117, 120, 119, 119, 119, 119,
119, 118, 120, 118, 120, 118, 121, 111, 100, 100, 101, 100, 100, 100, 101, 100,
100, 101, 101, 100, 101, 94, 94, 94, 94, 94, 94, 93, 94, 94, 94, 94, 94, 94, 92,
86, 87, 87, 88, 86, 87, 87, 87, 87, 87, 88, 81, 75, 65, 60, 64, 61, 63, 62, 62,
62, 63, 62, 62, 62, 62, 62, 62, 62, 61, 62, 62, 62, 62, 62, 62, 61, 63, 55, 44,
45, 43, 44, 43, 44, 44, 44, 43, 44, 43, 44, 43, 46, 39, 24, 26, 25, 26, 25, 25,
24, 26, 26, 26, 26, 25, 27, 13, 7, 9, 8, 8, 8, 8, 8, 9, 7, 10, 8, 10, 5, -6, -4,
-5, -5, -4, -5, -6, -5, -5, -5, -5, -5, -5, -11, -14, -13, -14, -13, -14, -14,
-14, -13, -13, -13, -13, -14, -13, -13, -14, -13, -13, -14, -13, -14, -13, -13,
-13, -15, -19, -19, -19, -19, -18, -18, -18, -18, -18, -18, -18, -19, -18, -19,
-17, -20, -24, -23, -23, -24, -24, -24, -23, -23, -27, -26, -27, -26, -27, -26,
-27, -27, -27, -27, -26, -26, -27, -27, -27, -27, -27, -26, -28, -30, -30, -30,
-31, -30, -30, -30, -30, -30, -31, -30, -30, -29, -32, -34, -34, -33, -34, -34,
-34, -34, -33, -33, -33, -33, -33, -33, -34, -34, -33, -34, -33, -34, -34, -33,
-34, -33, -35, -36, -36, -37, -37, -37, -37, -37, -37, -36, -36, -37, -36, -37,
-37, -37, -37, -37, -37, -36, -36, -37, -37, -38, -37, -36, -36, -37, -37, -37,
-37, -37, -36, -38, -36, -37, -37, -38, -37, -38, -36, -37, -37, -37, -37, -37,
-36, -37, -37, -36, -38, -36, -38, -35, -40, -34, -43, -2, 31, 20, 26, 21, 25,
22, 24, 23, 24, 23, 24, 23, 24, 23, 23, 23, 23, 23, 23, 23, 24, 24, 24, 23, 18,
19, 16, 13, 13, 13, 14, 14, 13, 13, 13, 13, 13, 14, 14, 13, 13, 13, 14, 14, 13,
13, 13, 14, 13, 13, 11, 12, 12, 12, 10, 12, 12, 13, 11, 13, 11, 13, 11, 13, 11,
14, 9, -36, -37, -36, -38, -37, -37, -36, -37, -36, -37, -36, -37, -37, -37,
-37, -37, -36, -37, -36, -38, -37, -38, -37, -38, -37, -37, -37, -36, -37, -36,
-38, -36, -37, -37, -37, -36, -37, -37, -37, -36, -37, -37, -37, -37, -36, -37,
-36, -37, -36, -37, -37, -37, -37, -37, -37, -37, -38, -37, -36, -37, -37, -37,
-37, -37, -37, -38, -37, -37, -37, -37, -37, -37, -37, -37, -36, -38, -37, -37,
-36, -37, -37, -37, -36, -37, -36, -37, -37, -37, -37, -37, -37, -37, -36, -37,
-37, -36, -38, -37, -37, -36, -38, -37, -36, -36, -37, -37, -37, -37, -35, -35,
-35, -35, -36, -35, -35, -35, -36, -35, -35, -35, -35, -35, -36, -35, -34, -35,
-36, -34, -34, -36, -35, -36, -34, -36, -34, -36, -34, -36, -34, -37, -34, -37,
-33, -37, -42, };