#define DATA_LENGTH 512
#define DATA AKWF_vgame_0090

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 9, 14, 15, 15, 13, 10, 7, 5, 4, 1,
1, 2, 4, 6, 7, 8, 9, 10, 10, 8, 6, 4, 4, 3, 5, 6, 8, 9, 9, 7, 6, 7, 6, 4, 5, 6,
7, 7, 7, 6, 7, 6, 7, 7, 7, 7, 6, 6, 7, 7, 7, 7, 7, 6, 7, 7, 7, 7, 6, 6, 7, 6, 7,
7, 7, 7, 7, 6, 7, 7, 6, 7, 7, 6, 7, 6, 6, 7, 7, 6, 7, 7, 6, 7, 6, 6, 6, 7, 6, 6,
7, 7, 7, 7, 7, 7, 7, 7, 6, 7, 6, 6, 7, 7, 7, 7, 6, 6, 7, 6, 7, 6, 7, 7, 6, 7, 6,
6, 6, 7, 7, 7, 6, 7, 6, 6, 7, 7, 6, 6, 7, 7, 5, 4, 3, 4, 5, 7, 9, 11, 12, 12, 8,
4, -1, -5, -9, -5, 3, 13, 25, 45, 63, 81, 96, 107, 112, 115, 115, 113, 111, 107,
106, 107, 107, 106, 106, 106, 106, 105, 108, 109, 110, 110, 107, 106, 107, 106,
107, 106, 106, 106, 107, 107, 105, 106, 106, 106, 105, 106, 106, 105, 105, 105,
106, 106, 105, 105, 105, 105, 107, 105, 106, 106, 106, 106, 106, 106, 106, 106,
106, 105, 106, 106, 105, 106, 106, 105, 105, 106, 105, 106, 105, 105, 106, 105,
105, 106, 105, 106, 105, 106, 106, 105, 105, 105, 106, 105, 105, 106, 105, 105,
105, 105, 105, 105, 104, 105, 105, 106, 105, 105, 106, 105, 105, 104, 105, 106,
105, 105, 104, 105, 105, 105, 104, 105, 107, 107, 107, 104, 103, 102, 100, 100,
99, 104, 110, 116, 119, 119, 113, 104, 90, 71, 51, 31, 16, 6, 0, -4, -4, -1, 2,
5, 5, 6, 9, 8, 7, 5, 5, 5, 4, 2, 1, 2, 3, 4, 5, 5, 5, 5, 5, 5, 6, 5, 5, 5, 5, 5,
5, 4, 5, 4, 4, 5, 4, 5, 4, 6, 8, 7, 5, 3, 2, 1, -2, -1, 1, 6, 12, 17, 20, 17, 7,
-9, -27, -47, -67, -83, -95, -102, -105, -104, -101, -98, -96, -95, -95, -94,
-95, -94, -95, -96, -94, -95, -98, -98, -98, -98, -98, -97, -96, -95, -95, -95,
-94, -94, -95, -96, -98, -98, -97, -96, -95, -95, -95, -94, -95, -94, -94, -95,
-95, -95, -94, -95, -95, -95, -95, -94, -94, -94, -94, -94, -95, -94, -94, -95,
-95, -95, -95, -94, -95, -94, -94, -94, -95, -95, -94, -94, -94, -94, -94, -94,
-94, -94, -93, -93, -94, -93, -95, -94, -94, -94, -95, -93, -94, -95, -94, -93,
-94, -94, -93, -93, -95, -97, -97, -96, -97, -96, -95, -94, -93, -94, -93, -94,
-96, -96, -97, -97, -97, -97, -95, -93, -94, -94, -93, -95, -96, -96, -97, -96,
-97, -95, -94, -93, -94, -94, -94, -95, -97, -96, -97, -97, -95, -94, -93, -94,
-94, -96, -96, -96, -95, -93, -92, -90, -90, -91, -91, -93, -98, -102, -107,
-108, -102, -92, -77, -59, -40, -23, -7, };