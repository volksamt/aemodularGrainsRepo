#define DATA_LENGTH 512
#define DATA AKWF_vgame_0034

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 1, 9, 14, 11, 14, 13, 13, 22, 28,
24, 32, 39, 39, 38, 41, 48, 49, 48, 49, 58, 63, 60, 64, 68, 68, 67, 69, 72, 76,
80, 79, 79, 78, 79, 82, 85, 84, 84, 84, 85, 85, 87, 89, 91, 91, 91, 93, 94, 94,
94, 95, 95, 95, 95, 96, 98, 99, 98, 98, 98, 99, 98, 99, 99, 98, 99, 100, 104,
104, 105, 107, 106, 107, 105, 110, 111, 112, 112, 112, 117, 116, 117, 119, 117,
117, 119, 118, 118, 117, 119, 114, 110, 111, 110, 102, 104, 96, 91, 92, 92, 92,
93, 86, 79, 82, 79, 73, 73, 73, 73, 69, 67, 68, 69, 65, 62, 64, 61, 57, 57, 57,
56, 54, 51, 45, 45, 46, 44, 47, 39, 29, 31, 31, 29, 20, 18, 21, 9, 5, 6, 8, 2,
-4, -2, -2, -3, -8, -8, -9, -8, -11, -11, -11, -12, -11, -12, -11, -12, -14,
-15, -15, -15, -20, -20, -22, -29, -26, -29, -26, -32, -38, -37, -37, -40, -52,
-52, -50, -61, -75, -76, -76, -76, -75, -76, -75, -78, -84, -84, -84, -84, -84,
-83, -82, -82, -83, -83, -83, -83, -82, -82, -83, -79, -80, -80, -79, -77, -75,
-76, -76, -77, -77, -75, -76, -74, -74, -75, -74, -71, -67, -61, -59, -60, -60,
-60, -57, -47, -46, -47, -46, -36, -32, -37, -25, -17, -18, -18, -14, -4, -5,
-6, -5, 5, 16, 14, 15, 14, 19, 19, 20, 20, 19, 20, 20, 24, 24, 25, 24, 26, 26,
26, 26, 26, 26, 26, 26, 26, 26, 26, 26, 26, 26, 27, 25, 25, 24, 24, 24, 24, 24,
25, 23, 21, 19, 20, 15, 13, 12, 5, 5, 5, 5, 5, 4, -2, -2, -2, -3, -3, -3, -4,
-3, -3, -3, -3, -2, -2, -1, -1, -2, -4, -3, -3, -4, -6, -10, -12, -10, -11, -11,
-11, -19, -21, -20, -21, -26, -33, -29, -34, -41, -40, -41, -41, -44, -44, -44,
-44, -46, -48, -47, -47, -47, -49, -50, -50, -50, -51, -51, -50, -55, -54, -55,
-55, -58, -60, -59, -60, -59, -59, -60, -59, -60, -61, -60, -59, -59, -60, -61,
-59, -60, -61, -61, -62, -61, -61, -62, -62, -61, -61, -61, -62, -60, -60, -58,
-58, -58, -58, -58, -58, -58, -58, -58, -57, -57, -56, -57, -56, -55, -54, -54,
-55, -54, -55, -55, -54, -53, -53, -54, -53, -52, -49, -48, -49, -48, -49, -49,
-42, -40, -41, -41, -38, -33, -34, -33, -27, -28, -27, -27, -23, -22, -23, -23,
-20, -19, -20, -19, -19, -17, -16, -15, -16, -15, -16, -17, -15, -16, -16, -17,
-16, -16, -16, -16, -16, -16, -16, -16, -15, -16, -16, -15, -17, -18, -18, -18,
-21, -23, -23, -22, -23, -23, -22, -23, -23, -22, -22, -23, -22, -23, -22, -22,
-23, -23, -23, -23, -23, -25, -24, -24, -24, -24, -24, -24, -24, -25, -25, -24,
-24, -22, -23, -22, -19, -19, -19, -19, -16, -11, -5, -6, -7, -7, -6, -3, };