#define DATA_LENGTH 512
#define DATA AKWF_vgame_0039

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 5, 9, 13, 15, 17, 22, 23, 23,
27, 31, 36, 39, 43, 46, 48, 52, 55, 57, 60, 62, 64, 65, 66, 68, 70, 70, 73, 74,
76, 78, 79, 79, 80, 81, 83, 84, 84, 86, 84, 87, 87, 89, 89, 90, 91, 92, 92, 93,
94, 95, 96, 97, 96, 96, 97, 99, 98, 98, 98, 98, 98, 98, 99, 100, 99, 101, 103,
103, 103, 104, 105, 106, 108, 110, 111, 113, 114, 115, 116, 117, 118, 119, 119,
120, 119, 118, 117, 117, 114, 112, 110, 104, 105, 104, 101, 98, 96, 93, 90, 88,
86, 83, 81, 78, 74, 71, 72, 72, 71, 68, 66, 65, 64, 63, 62, 62, 60, 57, 58, 56,
56, 54, 52, 49, 48, 46, 43, 41, 37, 34, 29, 26, 21, 22, 17, 12, 10, 7, 6, 3, 0,
-2, -3, -6, -7, -9, -10, -10, -11, -11, -11, -11, -11, -12, -11, -13, -13, -13,
-14, -16, -16, -18, -21, -22, -24, -26, -29, -32, -35, -39, -40, -43, -46, -51,
-53, -56, -59, -62, -66, -69, -72, -72, -75, -78, -81, -83, -84, -83, -83, -84,
-84, -84, -82, -82, -83, -82, -82, -81, -81, -81, -78, -79, -79, -78, -76, -75,
-76, -75, -75, -75, -75, -75, -74, -73, -72, -72, -70, -69, -67, -65, -63, -60,
-57, -54, -50, -47, -44, -40, -36, -31, -31, -30, -24, -20, -12, -12, -7, -6,
-2, 0, 4, 10, 9, 11, 14, 15, 16, 16, 18, 19, 21, 22, 24, 23, 24, 26, 26, 25, 25,
25, 25, 26, 26, 26, 25, 25, 26, 26, 26, 26, 25, 25, 26, 25, 26, 24, 24, 23, 21,
20, 20, 19, 18, 17, 16, 12, 11, 8, 5, 3, 2, 1, -1, -1, -3, -3, -3, -3, -4, -3,
-3, -3, -1, -2, -2, -1, -1, -2, -4, -2, -3, -5, -6, -7, -7, -11, -10, -12, -14,
-17, -20, -23, -26, -27, -30, -33, -35, -36, -40, -42, -42, -42, -44, -44, -45,
-46, -47, -47, -47, -46, -46, -46, -47, -49, -49, -51, -53, -54, -55, -56, -58,
-58, -59, -60, -59, -60, -59, -60, -60, -60, -59, -59, -58, -59, -60, -59, -59,
-60, -59, -59, -61, -61, -62, -60, -60, -61, -61, -61, -59, -59, -59, -59, -60,
-58, -58, -58, -58, -58, -58, -58, -57, -56, -56, -56, -57, -55, -54, -55, -55,
-55, -54, -55, -53, -52, -53, -53, -54, -53, -52, -51, -50, -49, -48, -46, -45,
-42, -41, -39, -36, -34, -33, -31, -29, -28, -28, -26, -25, -24, -23, -22, -22,
-21, -20, -19, -18, -17, -18, -17, -18, -17, -16, -16, -17, -16, -16, -16, -16,
-16, -17, -16, -16, -16, -16, -17, -16, -17, -16, -17, -18, -17, -19, -19, -20,
-21, -21, -21, -23, -23, -22, -23, -22, -23, -22, -22, -23, -23, -23, -23, -23,
-23, -22, -23, -24, -24, -24, -24, -24, -24, -24, -24, -24, -24, -24, -24, -24,
-24, -22, -22, -21, -20, -18, -19, -16, -14, -12, -12, -10, -8, -4, };