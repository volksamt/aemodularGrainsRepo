#define DATA_LENGTH 512
#define DATA AKWF_vgame_0055

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 6, 7, 8, 9, 11, 13, 15, 17, 19,
21, 21, 25, 26, 25, 27, 31, 34, 33, 35, 37, 39, 41, 42, 44, 45, 48, 49, 51, 53,
56, 56, 57, 59, 60, 62, 65, 66, 66, 68, 70, 72, 73, 76, 78, 80, 81, 83, 84, 85,
87, 89, 91, 93, 94, 94, 97, 97, 98, 101, 102, 104, 103, 106, 107, 108, 111, 111,
113, 112, 114, 115, 116, 117, 116, 117, 118, 117, 118, 117, 117, 118, 116, 116,
115, 114, 115, 114, 115, 114, 113, 113, 112, 111, 111, 112, 111, 109, 109, 109,
108, 107, 108, 107, 106, 106, 106, 104, 106, 105, 103, 102, 102, 101, 102, 102,
100, 99, 98, 98, 99, 97, 96, 98, 97, 94, 93, 93, 94, 93, 93, 91, 90, 91, 90, 89,
89, 88, 87, 86, 85, 86, 84, 84, 83, 82, 82, 82, 81, 79, 79, 78, 78, 77, 77, 76,
75, 74, 73, 73, 73, 73, 72, 71, 71, 70, 67, 66, 66, 65, 65, 65, 63, 64, 62, 62,
60, 60, 60, 59, 58, 58, 57, 55, 55, 53, 52, 52, 53, 52, 50, 49, 49, 49, 48, 47,
46, 45, 44, 42, 43, 41, 41, 41, 40, 40, 38, 38, 35, 35, 34, 33, 33, 32, 31, 30,
30, 29, 27, 26, 26, 25, 26, 24, 24, 23, 22, 21, 20, 19, 18, 17, 15, 15, 14, 14,
15, 14, 13, 11, 9, 8, 8, 8, 7, 7, 6, 5, 4, 2, 1, 1, 0, -1, -2, -3, -3, -3, -4,
-5, -6, -7, -8, -8, -9, -9, -10, -12, -14, -14, -15, -15, -17, -17, -19, -21,
-21, -20, -22, -23, -21, -23, -23, -25, -26, -27, -26, -27, -29, -30, -31, -31,
-32, -34, -35, -35, -36, -37, -38, -39, -39, -39, -40, -41, -42, -43, -43, -45,
-45, -46, -47, -46, -48, -48, -51, -51, -52, -52, -52, -54, -55, -55, -56, -57,
-58, -59, -59, -60, -60, -61, -63, -63, -65, -64, -66, -65, -65, -68, -68, -69,
-69, -70, -71, -73, -73, -72, -73, -74, -75, -76, -77, -78, -77, -78, -80, -80,
-81, -80, -81, -83, -82, -84, -84, -86, -86, -87, -88, -87, -89, -89, -90, -91,
-91, -91, -92, -94, -93, -93, -95, -96, -97, -97, -97, -97, -99, -101, -100,
-100, -99, -100, -102, -102, -103, -103, -104, -105, -105, -104, -107, -107,
-106, -107, -108, -109, -110, -110, -110, -112, -111, -111, -113, -113, -112,
-113, -114, -115, -115, -115, -116, -116, -116, -117, -117, -117, -117, -119,
-119, -120, -120, -119, -120, -119, -118, -118, -117, -116, -116, -114, -114,
-113, -112, -111, -111, -109, -106, -106, -105, -103, -101, -100, -99, -97, -95,
-93, -93, -91, -89, -88, -86, -84, -84, -84, -82, -78, -76, -74, -72, -72, -70,
-68, -67, -65, -62, -61, -59, -58, -57, -54, -53, -51, -48, -48, -45, -43, -42,
-41, -41, -39, -37, -34, -32, -30, -29, -26, -25, -24, -23, -20, -19, -18, -16,
-14, -11, -10, -8, -7, -5, -4, -2, 0, 0, };