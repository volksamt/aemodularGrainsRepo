#define DATA_LENGTH 512
#define DATA AKWF_vgame_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 21, 19, 19, 20, 18, 28, 39, 50, 58,
56, 57, 56, 56, 56, 56, 56, 55, 61, 69, 67, 68, 76, 78, 77, 78, 78, 77, 77, 77,
79, 85, 83, 85, 84, 85, 89, 88, 89, 88, 89, 88, 89, 94, 93, 93, 94, 93, 94, 98,
98, 98, 97, 98, 98, 98, 98, 98, 98, 99, 99, 100, 99, 104, 106, 106, 106, 106,
105, 107, 107, 107, 105, 108, 117, 116, 115, 118, 120, 119, 119, 119, 119, 119,
113, 111, 111, 111, 111, 111, 110, 100, 97, 98, 99, 98, 99, 96, 84, 83, 84, 83,
84, 82, 69, 63, 65, 64, 64, 65, 65, 64, 65, 64, 64, 64, 56, 56, 53, 45, 48, 45,
47, 45, 46, 46, 47, 47, 28, 27, 27, 29, 15, 5, 9, 7, 9, 7, 9, 7, -3, -6, -4, -5,
-5, -5, -10, -12, -11, -12, -11, -11, -10, -12, -13, -14, -13, -14, -12, -20,
-32, -32, -33, -32, -32, -31, -33, -32, -32, -32, -32, -49, -51, -57, -71, -68,
-70, -68, -69, -69, -69, -70, -69, -81, -85, -83, -84, -84, -84, -83, -83, -83,
-84, -84, -84, -82, -81, -82, -82, -83, -82, -79, -76, -78, -77, -77, -77, -76,
-75, -76, -76, -76, -76, -74, -71, -60, -59, -61, -59, -60, -60, -59, -59, -61,
-59, -62, -44, -41, -35, -13, -16, -13, -16, -14, -15, -15, -13, -15, -2, 4, 3,
2, 9, 17, 16, 16, 16, 16, 16, 16, 20, 23, 22, 23, 26, 26, 26, 25, 26, 26, 26,
26, 26, 26, 26, 26, 26, 25, 26, 26, 24, 24, 25, 24, 24, 24, 24, 24, 24, 25, 22,
18, 20, 19, 8, 8, 9, 7, 8, 8, 8, 9, 4, -3, 0, -2, -1, -1, -3, -3, -3, -3, -3,
-3, -3, -2, -1, -1, -2, -2, -1, -3, -5, -5, -4, -6, -4, -9, -15, -14, -14, -15,
-12, -22, -31, -37, -42, -41, -42, -42, -42, -42, -42, -41, -41, -44, -46, -47,
-47, -46, -47, -47, -46, -47, -46, -47, -46, -49, -55, -55, -55, -54, -56, -60,
-59, -60, -60, -59, -60, -59, -59, -59, -60, -59, -60, -59, -59, -62, -61, -61,
-61, -61, -62, -62, -61, -61, -61, -61, -61, -60, -59, -57, -58, -58, -58, -58,
-57, -58, -57, -58, -58, -58, -57, -59, -55, -54, -55, -55, -55, -55, -54, -55,
-54, -53, -54, -54, -53, -53, -52, -52, -52, -52, -52, -52, -51, -44, -43, -44,
-43, -44, -42, -31, -24, -24, -24, -24, -25, -24, -24, -24, -24, -24, -24, -19,
-19, -19, -18, -19, -18, -17, -18, -18, -17, -17, -18, -16, -16, -17, -16, -16,
-16, -16, -16, -16, -16, -16, -16, -16, -18, -18, -18, -18, -18, -20, -22, -21,
-21, -21, -21, -20, -23, -22, -23, -22, -23, -22, -23, -25, -24, -24, -24, -24,
-24, -23, -23, -25, -24, -24, -24, -24, -24, -24, -24, -24, -24, -24, -24, -24,
-24, -24, -22, -21, -20, -21, -17, -10, -12, -10, -12, -10, -12, -11, };