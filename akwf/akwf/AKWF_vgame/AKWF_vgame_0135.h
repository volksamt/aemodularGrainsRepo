#define DATA_LENGTH 512
#define DATA AKWF_vgame_0135

const PROGMEM int8_t DATA[DATA_LENGTH] = {20, 25, 23, 24, 23, 24, 24, 24, 24,
24, 23, 24, 23, 24, 23, 24, 24, 23, 23, 23, 24, 23, 23, 24, 24, 24, 23, 23, 24,
23, 24, 24, 23, 24, 24, 23, 23, 23, 24, 24, 23, 24, 23, 23, 23, 24, 23, 23, 24,
23, 23, 23, 23, 23, 23, 24, 22, 24, 23, 23, 23, 23, 24, 24, 23, 24, 24, 23, 23,
23, 24, 23, 23, 24, 24, 23, 23, 23, 24, 23, 24, 23, 24, 23, 25, 22, 26, 20, 30,
69, 67, 69, 67, 68, 68, 67, 69, 67, 68, 68, 68, 68, 69, 67, 69, 68, 68, 67, 68,
67, 68, 67, 67, 68, 67, 67, 68, 68, 67, 67, 68, 68, 67, 67, 68, 68, 67, 67, 67,
68, 67, 68, 68, 67, 67, 68, 67, 68, 67, 67, 68, 67, 67, 67, 66, 67, 67, 68, 67,
68, 68, 68, 67, 67, 68, 67, 66, 67, 68, 67, 68, 67, 68, 67, 68, 66, 68, 67, 68,
66, 68, 67, 68, 67, 65, 103, 115, 109, 112, 110, 111, 110, 112, 110, 112, 111,
112, 111, 111, 111, 111, 110, 111, 111, 111, 111, 111, 111, 112, 111, 111, 111,
112, 111, 111, 112, 111, 111, 111, 111, 111, 112, 111, 111, 111, 111, 111, 112,
111, 111, 110, 110, 112, 110, 112, 110, 112, 109, 113, 107, 120, 74, 15, 25, 21,
23, 22, 22, 21, 22, 21, 22, 21, 21, 22, 22, 21, 21, 22, 22, 23, 21, 22, 22, 22,
21, 23, 21, 23, 20, 24, 20, 24, 16, 34, -11, -107, -110, -112, -111, -112, -112,
-112, -111, -111, -111, -111, -112, -111, -111, -111, -112, -112, -112, -111,
-112, -111, -112, -111, -111, -112, -112, -110, -112, -111, -111, -111, -112,
-111, -111, -112, -111, -111, -111, -112, -111, -111, -111, -111, -111, -111,
-111, -111, -111, -110, -110, -111, -111, -112, -111, -111, -110, -111, -110,
-111, -110, -111, -80, -61, -69, -65, -68, -66, -67, -66, -67, -66, -67, -66,
-66, -67, -67, -66, -66, -66, -66, -66, -67, -66, -66, -66, -66, -67, -66, -66,
-66, -66, -66, -65, -65, -66, -65, -65, -66, -66, -66, -66, -66, -66, -66, -66,
-66, -66, -66, -66, -66, -66, -66, -66, -66, -66, -66, -66, -66, -66, -66, -66,
-67, -66, -66, -66, -66, -66, -66, -66, -67, -66, -66, -66, -66, -65, -66, -65,
-66, -66, -67, -66, -65, -65, -66, -65, -66, -67, -66, -66, -66, -66, -65, -67,
-64, -69, -34, -16, -24, -19, -22, -20, -22, -20, -22, -21, -21, -21, -21, -21,
-21, -21, -21, -22, -22, -21, -21, -21, -21, -21, -20, -21, -20, -21, -22, -21,
-21, -21, -21, -21, -21, -21, -20, -22, -21, -21, -21, -21, -21, -21, -21, -21,
-20, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -20, -22,
-21, -20, -20, -21, -21, -21, -21, -21, -21, -21, -20, -21, -21, -21, -21, -21,
-21, -22, -21, -20, -21, -21, -21, -22, -21, -21, -20, -22, -17, };