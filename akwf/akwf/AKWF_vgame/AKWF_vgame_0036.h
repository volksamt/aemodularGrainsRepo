#define DATA_LENGTH 512
#define DATA AKWF_vgame_0036

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 12, 15, 15, 14, 19, 27, 26, 26,
32, 31, 36, 44, 44, 44, 51, 51, 55, 63, 61, 61, 64, 64, 67, 71, 71, 72, 74, 76,
79, 78, 79, 79, 82, 82, 84, 84, 83, 85, 87, 86, 89, 91, 91, 92, 91, 91, 92, 94,
95, 95, 97, 97, 97, 96, 97, 98, 98, 98, 99, 98, 98, 98, 100, 100, 100, 102, 104,
103, 106, 108, 108, 108, 107, 110, 115, 115, 115, 116, 115, 117, 120, 119, 119,
119, 118, 118, 115, 116, 116, 110, 109, 107, 103, 103, 103, 96, 87, 87, 87, 87,
87, 81, 81, 77, 71, 73, 72, 70, 69, 67, 65, 67, 65, 63, 63, 61, 57, 59, 57, 55,
56, 52, 49, 47, 44, 45, 45, 39, 33, 35, 32, 24, 25, 18, 11, 14, 12, 7, 7, 2, -2,
-1, -3, -6, -7, -8, -11, -9, -10, -11, -12, -12, -12, -11, -12, -14, -13, -14,
-15, -14, -16, -20, -19, -23, -33, -32, -32, -32, -32, -41, -45, -42, -46, -52,
-51, -59, -62, -62, -70, -69, -69, -76, -79, -78, -82, -84, -83, -84, -84, -84,
-84, -83, -82, -82, -82, -82, -82, -82, -82, -79, -78, -79, -77, -77, -78, -76,
-75, -76, -76, -74, -74, -74, -75, -74, -74, -72, -73, -72, -64, -57, -58, -57,
-59, -56, -47, -49, -42, -35, -39, -34, -27, -28, -20, -13, -16, -11, -6, -6,
-1, 5, 2, 6, 10, 9, 14, 17, 20, 19, 20, 20, 21, 23, 22, 23, 23, 24, 26, 26, 27,
25, 25, 26, 26, 26, 25, 26, 26, 26, 26, 25, 26, 25, 26, 25, 24, 23, 24, 24, 22,
23, 20, 19, 20, 17, 14, 14, 8, 1, 2, 1, 2, 2, -1, -2, -1, -2, -4, -3, -2, -3,
-2, -2, -2, -2, -1, -2, -2, -3, -3, -3, -4, -5, -5, -6, -11, -13, -12, -13, -12,
-18, -20, -20, -28, -28, -26, -32, -33, -34, -41, -40, -39, -43, -43, -43, -45,
-45, -45, -46, -47, -46, -46, -49, -50, -50, -50, -52, -54, -55, -55, -56, -56,
-57, -60, -60, -60, -60, -60, -60, -60, -59, -60, -59, -58, -58, -60, -59, -60,
-59, -60, -61, -61, -61, -60, -61, -61, -61, -59, -60, -60, -59, -59, -59, -58,
-58, -57, -58, -58, -58, -58, -59, -59, -56, -57, -56, -56, -56, -54, -55, -55,
-55, -54, -54, -54, -53, -53, -54, -52, -52, -51, -49, -46, -47, -47, -47, -46,
-41, -40, -40, -36, -36, -33, -29, -29, -27, -25, -26, -25, -22, -23, -23, -21,
-20, -20, -18, -18, -18, -17, -16, -16, -16, -17, -16, -16, -16, -16, -16, -16,
-17, -16, -16, -16, -16, -16, -16, -16, -15, -17, -17, -18, -17, -19, -19, -20,
-22, -22, -23, -23, -23, -23, -22, -22, -23, -23, -22, -23, -23, -23, -23, -23,
-22, -23, -24, -24, -24, -25, -24, -24, -23, -24, -24, -24, -24, -24, -25, -24,
-24, -22, -23, -21, -19, -19, -19, -16, -16, -13, -4, -3, -4, -4, -4, };