#define DATA_LENGTH 512
#define DATA AKWF_vgame_0094

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 2, 2, 3, 4, 5, 5, 4, 6, 6, 7,
6, 7, 8, 6, 6, 6, 9, 9, 10, 11, 11, 12, 12, 13, 12, 13, 12, 11, 12, 13, 12, 13,
14, 14, 14, 16, 17, 17, 18, 18, 19, 18, 16, 17, 16, 16, 17, 17, 18, 18, 18, 20,
20, 20, 20, 21, 20, 20, 19, 20, 20, 21, 22, 22, 22, 23, 24, 24, 23, 23, 24, 24,
23, 22, 22, 22, 24, 31, 42, 55, 68, 78, 88, 97, 105, 110, 115, 117, 117, 118,
118, 119, 118, 118, 117, 116, 117, 116, 115, 114, 113, 113, 111, 109, 107, 106,
104, 103, 102, 104, 102, 102, 102, 100, 100, 98, 96, 96, 96, 94, 91, 90, 90, 89,
88, 87, 87, 87, 84, 85, 84, 83, 83, 82, 79, 78, 77, 77, 74, 74, 73, 73, 72, 71,
71, 71, 69, 69, 69, 69, 66, 64, 63, 63, 61, 61, 60, 60, 58, 58, 58, 58, 57, 55,
54, 52, 51, 51, 50, 47, 47, 47, 46, 46, 46, 45, 44, 44, 44, 42, 42, 41, 39, 38,
38, 36, 36, 36, 36, 36, 34, 35, 34, 33, 33, 32, 31, 29, 28, 27, 26, 25, 25, 25,
23, 24, 24, 24, 23, 22, 23, 22, 20, 20, 18, 19, 17, 17, 16, 15, 15, 15, 15, 14,
14, 13, 12, 10, 10, 12, 11, 10, 10, 11, 10, 9, 10, 9, 8, 8, 6, 7, 6, 4, 4, 3, 2,
1, 1, 1, 1, 0, -1, -1, -1, -2, -2, -3, -4, -5, -5, -6, -8, -8, -8, -7, -7, -6,
-7, -8, -9, -8, -8, -8, -10, -11, -11, -12, -13, -12, -13, -13, -13, -13, -13,
-12, -13, -14, -13, -15, -16, -16, -17, -18, -18, -17, -17, -18, -16, -17, -17,
-17, -17, -17, -17, -19, -20, -20, -20, -21, -20, -20, -20, -21, -20, -20, -21,
-20, -21, -20, -22, -23, -23, -23, -24, -23, -23, -24, -24, -22, -23, -28, -35,
-46, -56, -69, -82, -92, -100, -106, -111, -115, -117, -119, -120, -119, -119,
-118, -117, -116, -116, -116, -116, -115, -113, -113, -111, -110, -110, -110,
-106, -106, -104, -104, -102, -102, -100, -101, -100, -99, -98, -98, -97, -94,
-94, -93, -92, -90, -89, -88, -87, -86, -85, -85, -84, -84, -83, -82, -80, -81,
-80, -77, -76, -75, -75, -74, -73, -71, -72, -71, -70, -69, -69, -67, -65, -65,
-63, -63, -61, -60, -60, -59, -58, -57, -58, -58, -57, -55, -56, -54, -53, -53,
-50, -49, -48, -48, -47, -46, -45, -45, -45, -44, -44, -43, -42, -41, -40, -39,
-39, -38, -38, -36, -36, -34, -35, -34, -34, -34, -33, -33, -32, -31, -30, -28,
-27, -26, -26, -25, -24, -24, -24, -23, -23, -24, -24, -22, -21, -21, -20, -20,
-18, -16, -16, -16, -15, -15, -16, -15, -13, -13, -13, -12, -11, -11, -10, -9,
-9, -8, -8, -8, -8, -8, -8, -7, -7, -8, -7, -5, -4, -4, -4, -3, -1, 0, 0, 0, 1,
0, 0, };