#define DATA_LENGTH 512
#define DATA AKWF_vgame_0101

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 45, 39, 40, 40, 40, 40, 40, 41, 39,
40, 39, 40, 40, 41, 39, 41, 39, 40, 40, 40, 40, 40, 40, 40, 39, 40, 40, 40, 41,
39, 41, 38, 42, 37, 45, 31, 69, 124, 113, 119, 115, 118, 115, 117, 115, 116,
117, 116, 116, 116, 116, 115, 117, 116, 117, 116, 116, 115, 116, 116, 117, 116,
117, 115, 116, 116, 116, 115, 115, 116, 116, 115, 116, 116, 116, 116, 116, 116,
115, 116, 115, 116, 116, 115, 115, 115, 115, 115, 115, 116, 115, 115, 114, 115,
116, 115, 115, 115, 116, 116, 115, 115, 115, 115, 115, 115, 115, 115, 115, 114,
115, 114, 115, 114, 114, 113, 114, 114, 114, 114, 115, 115, 113, 114, 114, 114,
114, 114, 114, 114, 114, 114, 114, 114, 115, 113, 113, 114, 114, 114, 114, 114,
113, 113, 113, 113, 113, 114, 114, 113, 112, 113, 113, 113, 113, 113, 113, 113,
113, 113, 113, 112, 112, 113, 113, 112, 113, 113, 113, 113, 112, 113, 113, 113,
113, 112, 113, 112, 112, 113, 112, 113, 113, 112, 113, 113, 113, 112, 111, 112,
112, 112, 112, 112, 112, 112, 112, 112, 112, 112, 112, 112, 112, 111, 111, 111,
113, 111, 112, 111, 112, 111, 113, 110, 113, 110, 113, 109, 114, 102, 34, 34,
36, 33, 36, 34, 35, 34, 35, 34, 35, 33, 35, 33, 36, 34, 35, 34, 35, 35, 35, 34,
34, 35, 34, 35, 32, 42, -10, -50, -40, -44, -41, -44, -42, -43, -43, -42, -43,
-43, -43, -43, -43, -42, -42, -43, -43, -42, -43, -43, -42, -43, -43, -42, -43,
-44, -42, -43, -42, -43, -43, -43, -43, -42, -43, -43, -43, -43, -43, -43, -42,
-42, -44, -42, -44, -41, -45, -41, -45, -40, -46, -37, -54, -120, -117, -119,
-119, -119, -119, -118, -120, -118, -119, -118, -120, -118, -119, -119, -119,
-118, -119, -118, -119, -119, -119, -119, -119, -118, -119, -119, -119, -118,
-119, -118, -119, -118, -119, -118, -119, -118, -118, -119, -118, -118, -118,
-119, -118, -118, -118, -118, -117, -118, -118, -118, -117, -117, -118, -118,
-118, -118, -118, -117, -118, -117, -118, -118, -118, -118, -117, -118, -117,
-117, -117, -117, -117, -118, -118, -116, -117, -118, -118, -117, -116, -116,
-116, -117, -117, -117, -118, -117, -117, -116, -117, -116, -116, -116, -116,
-116, -116, -117, -116, -116, -116, -117, -116, -117, -116, -117, -116, -116,
-116, -117, -117, -117, -117, -116, -115, -116, -116, -117, -116, -115, -116,
-115, -115, -116, -116, -116, -116, -116, -116, -116, -116, -115, -115, -115,
-115, -116, -115, -115, -115, -116, -115, -115, -114, -115, -115, -115, -115,
-115, -115, -115, -116, -115, -115, -115, -114, -114, -116, -113, -116, -113,
-115, -113, -116, -112, -116, -111, -120, -94, -31, -39, -36, -37, -38, -37,
-38, -37, -38, -37, -39, -37, -39, -36, -38, -37, -38, -38, -38, -36, -37, -37,
-37, -37, -37, -38, -37, -37, -37, -37, -36, -38, -35, -38, -36, -38, -35, -39,
-35, -39, -36, };