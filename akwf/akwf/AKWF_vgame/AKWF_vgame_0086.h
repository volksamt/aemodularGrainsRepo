#define DATA_LENGTH 512
#define DATA AKWF_vgame_0086

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 6, 11, 13, 15, 16, 16, 16,
17, 15, 16, 15, 14, 13, 14, 16, 17, 19, 24, 27, 29, 28, 30, 32, 31, 31, 30, 29,
27, 26, 28, 29, 32, 36, 37, 40, 44, 45, 43, 44, 44, 44, 44, 42, 41, 42, 42, 45,
45, 49, 52, 53, 56, 59, 60, 59, 59, 58, 59, 57, 57, 57, 57, 58, 59, 62, 65, 67,
69, 71, 72, 74, 74, 72, 72, 71, 71, 68, 71, 72, 74, 75, 78, 82, 84, 85, 86, 88,
89, 86, 86, 85, 84, 84, 85, 86, 87, 90, 94, 95, 97, 99, 101, 102, 102, 102, 102,
98, 99, 99, 99, 100, 102, 104, 107, 109, 110, 113, 117, 117, 115, 113, 112, 113,
115, 116, 116, 116, 115, 112, 108, 105, 103, 101, 99, 99, 99, 99, 97, 99, 100,
102, 101, 101, 100, 98, 95, 91, 88, 86, 85, 85, 84, 82, 84, 84, 86, 88, 89, 88,
86, 83, 78, 75, 73, 73, 70, 70, 71, 71, 70, 70, 70, 73, 74, 73, 72, 69, 66, 62,
59, 57, 56, 55, 55, 55, 56, 55, 57, 58, 57, 58, 57, 55, 52, 49, 45, 43, 42, 40,
39, 40, 42, 42, 42, 44, 45, 44, 43, 40, 37, 36, 32, 29, 27, 27, 27, 26, 27, 26,
29, 30, 30, 30, 29, 27, 23, 21, 19, 16, 13, 12, 12, 12, 12, 14, 14, 14, 14, 14,
14, 12, 10, 8, 6, 3, 0, -2, -4, -4, -2, -1, -1, 1, 1, -1, -2, -1, -3, -6, -11,
-14, -16, -16, -18, -17, -16, -14, -13, -15, -17, -21, -25, -28, -29, -29, -31,
-32, -32, -31, -30, -28, -29, -28, -26, -27, -31, -35, -38, -41, -44, -44, -43,
-44, -44, -45, -45, -44, -43, -42, -41, -43, -47, -50, -53, -54, -56, -58, -59,
-59, -59, -59, -59, -58, -57, -57, -56, -56, -59, -63, -67, -69, -70, -72, -73,
-74, -74, -75, -74, -72, -71, -71, -72, -73, -75, -76, -79, -83, -83, -85, -87,
-90, -88, -87, -87, -85, -83, -84, -85, -88, -88, -91, -93, -96, -99, -100,
-102, -101, -102, -102, -101, -99, -99, -99, -99, -101, -102, -104, -106, -108,
-112, -116, -117, -117, -117, -115, -111, -112, -112, -114, -118, -119, -116,
-111, -106, -104, -101, -101, -101, -100, -99, -99, -99, -99, -101, -101, -101,
-101, -100, -97, -93, -91, -87, -86, -87, -85, -83, -83, -85, -85, -86, -86,
-89, -86, -85, -83, -80, -77, -74, -71, -71, -70, -71, -71, -71, -70, -71, -73,
-74, -73, -72, -69, -67, -64, -60, -57, -56, -55, -55, -55, -55, -55, -58, -58,
-57, -59, -57, -55, -52, -49, -48, -43, -42, -42, -40, -39, -41, -42, -44, -45,
-46, -44, -43, -40, -38, -34, -31, -28, -27, -27, -27, -28, -26, -28, -30, -30,
-29, -29, -28, -26, -24, -22, -18, -15, -12, -11, -12, -11, -12, -14, -15, -14,
-14, -15, -14, -13, -9, -6, -5, -1, 1, 1, 3, 4, 1, 0, 0, -1, -3, -2, };