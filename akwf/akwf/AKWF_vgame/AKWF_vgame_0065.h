#define DATA_LENGTH 512
#define DATA AKWF_vgame_0065

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 6, 14, 17, 17, 15, 14, 16, 16, 16,
16, 17, 16, 16, 16, 15, 19, 26, 30, 31, 31, 30, 31, 32, 30, 30, 30, 30, 30, 29,
32, 31, 29, 32, 39, 44, 47, 46, 45, 45, 45, 45, 45, 45, 45, 47, 46, 44, 44, 49,
57, 62, 61, 60, 59, 60, 60, 59, 59, 60, 59, 58, 60, 61, 59, 59, 65, 71, 76, 76,
74, 74, 75, 76, 74, 73, 74, 75, 75, 74, 72, 76, 83, 89, 91, 89, 88, 89, 90, 89,
89, 88, 89, 90, 87, 87, 89, 95, 102, 105, 104, 103, 102, 104, 104, 103, 104,
104, 104, 102, 103, 104, 103, 101, 107, 116, 119, 120, 118, 117, 118, 119, 117,
117, 119, 118, 117, 118, 120, 116, 107, 102, 102, 103, 104, 104, 102, 103, 104,
103, 102, 102, 104, 104, 103, 96, 90, 87, 87, 89, 89, 88, 88, 88, 88, 88, 88,
87, 88, 87, 89, 88, 82, 76, 72, 73, 73, 74, 74, 73, 73, 74, 75, 73, 72, 76, 75,
71, 64, 58, 57, 58, 59, 58, 58, 59, 58, 59, 58, 58, 59, 60, 58, 50, 45, 42, 42,
45, 45, 43, 44, 43, 43, 44, 43, 44, 43, 43, 46, 44, 37, 30, 29, 28, 30, 30, 28,
28, 29, 30, 28, 29, 28, 30, 31, 26, 17, 13, 12, 13, 15, 14, 14, 13, 15, 14, 14,
12, 14, 15, 12, 4, 0, -2, -2, 0, 0, 0, 0, 0, 0, -1, 0, 0, -2, -2, 1, 0, -7, -14,
-16, -17, -15, -15, -16, -17, -15, -15, -16, -16, -15, -16, -15, -20, -27, -31,
-32, -31, -29, -31, -31, -32, -30, -30, -31, -31, -30, -28, -33, -40, -45, -46,
-44, -45, -45, -45, -46, -45, -45, -44, -46, -45, -47, -46, -43, -45, -53, -59,
-59, -60, -60, -60, -60, -60, -60, -60, -60, -60, -60, -59, -59, -64, -71, -77,
-76, -74, -73, -75, -75, -74, -73, -76, -75, -73, -74, -76, -73, -71, -77, -86,
-89, -91, -89, -89, -88, -88, -89, -89, -89, -88, -90, -89, -86, -90, -97, -104,
-104, -105, -104, -104, -104, -104, -103, -103, -104, -104, -104, -103, -102,
-109, -115, -119, -119, -117, -117, -117, -119, -118, -117, -117, -119, -118,
-117, -118, -119, -118, -114, -107, -102, -101, -103, -102, -103, -102, -103,
-103, -104, -103, -101, -104, -105, -100, -94, -89, -86, -87, -89, -89, -87,
-89, -88, -87, -87, -87, -88, -90, -88, -81, -75, -72, -73, -73, -75, -72, -73,
-74, -74, -72, -74, -74, -73, -73, -74, -74, -68, -62, -57, -57, -59, -59, -58,
-59, -59, -59, -59, -58, -57, -59, -60, -55, -49, -44, -42, -43, -45, -45, -43,
-43, -44, -44, -43, -43, -44, -45, -43, -37, -31, -28, -29, -29, -30, -29, -28,
-29, -29, -28, -29, -30, -27, -27, -30, -30, -23, -17, -12, -13, -14, -14, -14,
-14, -15, -14, -15, -14, -13, -15, -16, -11, -4, 2, 3, 1, 0, 0, 0, 1, 1, 1, 2,
2, 1, -1, };