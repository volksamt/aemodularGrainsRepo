#define DATA_LENGTH 512
#define DATA AKWF_vgame_0107

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 64, 55, 57, 56, 56, 56, 62, 68,
65, 66, 69, 80, 77, 86, 88, 88, 87, 88, 88, 87, 90, 100, 100, 100, 100, 109,
114, 118, 119, 119, 120, 120, 119, 119, 115, 111, 113, 111, 113, 111, 103, 100,
100, 100, 100, 99, 99, 99, 100, 96, 94, 95, 94, 95, 88, 87, 88, 88, 84, 82, 82,
82, 84, 79, 74, 76, 76, 72, 62, 62, 63, 63, 62, 53, 54, 53, 54, 53, 45, 43, 45,
38, 34, 34, 34, 33, 35, 29, 23, 24, 25, 20, 11, 12, 12, 15, 15, 14, 15, 14, 14,
16, 24, 24, 24, 24, 30, 31, 33, 40, 38, 40, 38, 39, 39, 41, 47, 45, 47, 46, 48,
50, 56, 61, 61, 60, 61, 60, 65, 68, 67, 68, 67, 68, 68, 74, 82, 82, 82, 82, 81,
82, 83, 81, 85, 90, 89, 90, 88, 91, 97, 96, 96, 97, 103, 103, 103, 103, 104,
106, 105, 106, 106, 98, 92, 95, 93, 94, 89, 86, 86, 88, 83, 73, 74, 74, 74, 68,
66, 68, 67, 68, 65, 55, 54, 56, 55, 47, 44, 46, 42, 37, 39, 37, 37, 38, 36, 33,
34, 33, 34, 32, 28, 30, -18, -41, -32, -37, -34, -35, -34, -42, -41, -42, -42,
-41, -45, -47, -52, -51, -51, -51, -52, -51, -52, -48, -41, -42, -41, -43, -37,
-33, -39, -36, -37, -36, -37, -37, -37, -37, -28, -27, -27, -28, -20, -4, -4,
-3, -3, -2, -5, -1, -9, 18, 72, 65, 68, 65, 70, 76, 79, 75, 82, 67, -21, -31,
-25, -29, -10, -5, -5, -7, 0, 7, 7, 7, 6, 11, 24, 19, 22, 20, 25, 34, 33, 32,
37, 39, 37, 38, 37, 38, 33, 33, 32, 38, -4, -34, -24, -30, -31, -33, -31, -32,
-32, -32, -34, -38, -37, -37, -37, -38, -42, -44, -47, -45, -47, -45, -47, -46,
-46, -53, -54, -54, -53, -59, -65, -71, -74, -73, -74, -72, -73, -73, -76, -83,
-82, -82, -83, -82, -94, -103, -101, -102, -102, -102, -102, -103, -101, -107,
-109, -109, -109, -110, -105, -101, -101, -102, -100, -93, -96, -94, -96, -92,
-87, -88, -87, -87, -79, -78, -78, -78, -78, -71, -71, -70, -70, -71, -65, -62,
-64, -60, -56, -56, -56, -55, -56, -53, -49, -49, -47, -49, -46, -38, -39, -33,
-31, -31, -32, -32, -31, -32, -25, -23, -24, -25, -20, -16, -17, -10, -10, -10,
-10, -10, -10, -11, -15, -14, -16, -14, -16, -21, -26, -32, -31, -32, -31, -31,
-32, -30, -40, -45, -43, -43, -43, -48, -60, -64, -63, -63, -63, -63, -62, -62,
-64, -71, -69, -70, -69, -71, -76, -77, -76, -76, -83, -85, -83, -85, -83, -89,
-89, -89, -89, -91, -96, -99, -98, -99, -98, -99, -99, -99, -97, -100, -106,
-107, -106, -105, -105, -105, -106, -106, -106, -97, -95, -96, -97, -88, -79,
-83, -79, -73, -71, -72, -71, -73, -68, -60, -59, -60, -59, -60, -49, -52, -43,
-38, -37, -39, -36, -40, -38, };