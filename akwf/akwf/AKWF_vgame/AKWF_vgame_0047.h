#define DATA_LENGTH 512
#define DATA AKWF_vgame_0047

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 8, 7, 8, 7, 11, 20, 19, 18, 20, 19,
19, 18, 24, 28, 26, 28, 28, 27, 32, 37, 36, 36, 35, 41, 47, 45, 47, 45, 49, 57,
55, 56, 63, 64, 63, 64, 64, 64, 62, 67, 74, 73, 73, 74, 73, 84, 91, 90, 90, 90,
91, 90, 90, 91, 90, 91, 98, 99, 98, 103, 107, 105, 107, 107, 106, 106, 106, 111,
111, 110, 111, 111, 114, 118, 117, 117, 118, 118, 117, 118, 118, 118, 118, 117,
116, 115, 115, 112, 112, 113, 112, 113, 113, 113, 112, 111, 112, 111, 111, 110,
106, 104, 104, 105, 105, 105, 105, 105, 105, 104, 104, 103, 103, 103, 101, 99,
100, 100, 100, 100, 99, 96, 97, 97, 97, 96, 95, 93, 90, 91, 90, 90, 90, 90, 90,
91, 91, 88, 88, 87, 88, 86, 83, 85, 83, 84, 84, 85, 80, 79, 80, 79, 79, 77, 76,
73, 73, 73, 72, 73, 73, 73, 73, 73, 70, 68, 68, 65, 65, 65, 65, 65, 65, 65, 65,
63, 60, 61, 60, 61, 59, 57, 54, 51, 53, 52, 52, 52, 53, 52, 52, 51, 48, 49, 50,
49, 45, 44, 44, 43, 45, 44, 41, 39, 40, 40, 40, 39, 37, 35, 31, 32, 32, 32, 32,
32, 31, 32, 28, 26, 27, 26, 28, 24, 22, 22, 22, 21, 23, 20, 17, 18, 17, 19, 15,
14, 15, 10, 10, 9, 10, 9, 10, 9, 10, 8, 4, 5, 4, 6, 4, 0, 0, 0, 1, 0, 0, -3, -2,
-4, -4, -4, -10, -9, -11, -13, -12, -13, -13, -12, -13, -12, -13, -18, -17, -17,
-17, -18, -22, -21, -22, -21, -21, -26, -27, -27, -27, -27, -26, -29, -30, -30,
-36, -35, -36, -35, -35, -35, -34, -38, -40, -40, -39, -40, -39, -41, -43, -42,
-43, -43, -46, -49, -47, -49, -47, -49, -52, -52, -52, -55, -56, -56, -55, -55,
-56, -56, -56, -61, -60, -61, -61, -61, -65, -68, -68, -68, -68, -68, -69, -69,
-68, -67, -69, -73, -73, -73, -74, -76, -77, -76, -77, -76, -77, -76, -79, -80,
-79, -79, -78, -84, -87, -87, -87, -87, -88, -88, -86, -87, -87, -87, -89, -91,
-90, -91, -94, -93, -94, -94, -95, -93, -95, -97, -97, -97, -97, -97, -98, -102,
-104, -102, -103, -103, -104, -103, -103, -103, -104, -106, -106, -107, -107,
-108, -108, -108, -108, -108, -108, -108, -111, -111, -111, -112, -111, -114,
-115, -116, -115, -117, -117, -116, -115, -116, -117, -116, -117, -118, -118,
-118, -118, -119, -119, -119, -118, -120, -119, -118, -116, -116, -116, -116,
-113, -111, -106, -104, -105, -104, -105, -104, -105, -105, -106, -101, -96,
-97, -97, -95, -87, -87, -88, -86, -88, -85, -79, -79, -80, -79, -81, -77, -72,
-65, -59, -60, -61, -60, -60, -60, -61, -60, -53, -52, -52, -52, -53, -45, -42,
-43, -42, -43, -42, -35, -32, -33, -33, -35, -26, -24, -23, -15, -16, -16, -17,
-16, -17, -12, -6, -7, -7, -6, -6, -7, -1, };