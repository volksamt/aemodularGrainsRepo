#define DATA_LENGTH 512
#define DATA AKWF_vgame_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 6, 6, 19, 22, 21, 21, 26, 30,
28, 28, 32, 41, 38, 40, 49, 51, 50, 51, 57, 63, 69, 70, 69, 70, 70, 71, 76, 76,
76, 76, 82, 85, 83, 87, 89, 89, 89, 91, 94, 94, 94, 94, 99, 99, 99, 98, 102,
111, 111, 110, 111, 111, 111, 112, 115, 114, 114, 114, 114, 115, 114, 112, 113,
113, 113, 113, 113, 113, 113, 112, 114, 114, 113, 114, 111, 109, 110, 109, 110,
109, 110, 110, 104, 103, 104, 101, 98, 98, 92, 92, 92, 92, 93, 91, 84, 82, 84,
77, 72, 73, 74, 70, 66, 67, 67, 66, 59, 58, 60, 52, 48, 50, 49, 46, 40, 37, 33,
33, 33, 33, 34, 28, 25, 26, 25, 21, 16, 19, 16, 9, 9, 9, 9, 4, 2, 3, 4, 1, 0, 1,
0, 0, -7, -10, -9, -10, -10, -10, -9, -11, -13, -12, -13, -12, -12, -13, -11,
-11, -11, -12, -11, -11, -11, -11, -10, -12, -14, -15, -14, -14, -14, -14, -14,
-15, -15, -14, -14, -14, -13, -12, -13, -14, -14, -14, -12, -12, -12, -13, -14,
-10, -7, -9, -7, -2, -3, -4, -2, -2, -1, -2, -2, 2, 5, 1, 6, 8, 8, 7, 9, 11, 15,
20, 18, 19, 18, 21, 25, 25, 25, 25, 26, 30, 30, 30, 35, 37, 37, 36, 39, 42, 42,
41, 43, 45, 44, 44, 45, 49, 53, 52, 52, 52, 52, 52, 53, 55, 54, 54, 53, 54, 54,
53, 53, 52, 52, 53, 52, 53, 52, 53, 52, 49, 49, 50, 48, 45, 43, 45, 45, 44, 44,
45, 43, 41, 41, 42, 39, 39, 37, 35, 35, 34, 35, 35, 33, 30, 30, 31, 27, 27, 27,
27, 25, 23, 24, 23, 24, 22, 22, 22, 21, 20, 21, 21, 21, 20, 18, 17, 18, 17, 17,
18, 15, 14, 14, 14, 13, 12, 13, 12, 12, 11, 11, 10, 8, 8, 7, 8, 5, 4, 5, 5, 4,
-2, -4, -3, -3, -3, -3, -3, -7, -6, -6, -6, -10, -14, -14, -19, -18, -19, -18,
-19, -21, -22, -22, -22, -26, -28, -26, -28, -33, -34, -35, -35, -35, -35, -34,
-35, -38, -40, -40, -42, -45, -45, -49, -51, -51, -51, -50, -51, -56, -58, -56,
-60, -63, -63, -64, -64, -66, -66, -66, -67, -71, -72, -71, -74, -77, -76, -76,
-78, -82, -86, -90, -88, -89, -90, -88, -92, -95, -95, -96, -97, -100, -99,
-100, -106, -106, -106, -106, -109, -110, -109, -109, -110, -113, -113, -113,
-112, -115, -117, -118, -117, -118, -118, -117, -118, -120, -120, -119, -119,
-119, -120, -119, -118, -119, -120, -119, -118, -117, -118, -117, -116, -114,
-115, -115, -109, -104, -105, -105, -105, -105, -104, -105, -102, -98, -99, -98,
-92, -92, -90, -86, -88, -87, -87, -88, -84, -77, -78, -76, -72, -71, -72, -72,
-66, -65, -65, -65, -61, -54, -57, -53, -46, -45, -47, -45, -39, -32, -22, -22,
-22, -22, -23, -20, -11, -11, -11, -11, -2, -1, -2, };