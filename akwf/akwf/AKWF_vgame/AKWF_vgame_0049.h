#define DATA_LENGTH 512
#define DATA AKWF_vgame_0049

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 6, 6, 9, 17, 16, 16, 16, 21, 23,
22, 23, 22, 28, 31, 30, 29, 36, 40, 40, 39, 41, 46, 46, 45, 46, 52, 55, 54, 54,
54, 59, 61, 61, 60, 65, 70, 70, 70, 70, 77, 76, 77, 76, 77, 83, 87, 93, 92, 92,
91, 92, 92, 95, 100, 97, 99, 97, 100, 103, 103, 103, 104, 109, 109, 109, 109,
113, 115, 113, 115, 114, 117, 117, 118, 117, 118, 117, 117, 117, 117, 116, 115,
117, 116, 114, 113, 113, 112, 112, 112, 113, 113, 113, 111, 110, 110, 109, 110,
108, 105, 105, 105, 104, 104, 104, 105, 105, 104, 103, 104, 103, 102, 99, 99,
98, 99, 98, 98, 98, 99, 98, 96, 96, 96, 95, 93, 91, 91, 91, 90, 90, 91, 91, 91,
90, 87, 87, 88, 88, 84, 81, 81, 81, 81, 81, 81, 81, 81, 80, 78, 78, 78, 77, 74,
72, 71, 71, 72, 71, 71, 72, 72, 69, 68, 68, 68, 67, 63, 62, 62, 61, 62, 62, 62,
62, 62, 59, 59, 59, 59, 56, 52, 53, 53, 52, 52, 52, 52, 52, 52, 49, 50, 49, 50,
43, 41, 41, 41, 42, 41, 41, 40, 42, 39, 37, 38, 38, 37, 32, 29, 30, 30, 30, 29,
27, 27, 27, 28, 27, 27, 28, 25, 20, 19, 19, 19, 20, 18, 19, 19, 17, 16, 16, 16,
17, 13, 8, 8, 8, 7, 8, 8, 8, 7, 4, 6, 4, 5, 4, 0, -4, -3, -3, -3, -3, -3, -3,
-5, -7, -6, -7, -6, -7, -13, -15, -14, -14, -15, -14, -14, -14, -17, -18, -17,
-17, -21, -23, -25, -26, -26, -26, -25, -26, -25, -26, -28, -29, -28, -29, -33,
-34, -36, -37, -37, -37, -36, -37, -36, -38, -40, -39, -39, -40, -43, -45, -46,
-47, -46, -45, -45, -46, -45, -49, -52, -51, -50, -53, -55, -56, -58, -57, -57,
-57, -58, -57, -58, -61, -62, -62, -62, -64, -65, -67, -67, -66, -67, -66, -67,
-66, -68, -70, -70, -70, -71, -74, -75, -77, -78, -77, -79, -78, -78, -77, -78,
-80, -79, -79, -81, -84, -85, -86, -86, -85, -86, -85, -86, -86, -89, -90, -89,
-89, -90, -92, -95, -96, -95, -95, -95, -95, -95, -96, -96, -98, -101, -101,
-100, -101, -103, -103, -103, -104, -103, -103, -103, -106, -105, -105, -105,
-105, -107, -108, -109, -109, -110, -109, -110, -109, -111, -111, -110, -111,
-111, -112, -114, -115, -116, -116, -116, -116, -115, -116, -117, -118, -117,
-118, -118, -118, -118, -117, -117, -117, -118, -118, -118, -117, -113, -115,
-114, -115, -114, -112, -109, -104, -105, -104, -105, -104, -106, -101, -99,
-98, -99, -98, -91, -93, -88, -85, -86, -86, -86, -85, -87, -78, -75, -76, -77,
-74, -69, -71, -62, -63, -62, -62, -62, -62, -61, -54, -54, -54, -54, -47, -46,
-46, -39, -40, -40, -39, -38, -41, -36, -30, -30, -30, -30, -24, -24, -20, -15,
-16, -16, -16, -16, -17, -11, -7, -8, -8, -5, 1, -1, };