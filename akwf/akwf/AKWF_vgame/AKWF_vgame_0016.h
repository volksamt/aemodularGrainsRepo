#define DATA_LENGTH 512
#define DATA AKWF_vgame_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 14, 12, 13, 14, 12, 18, 25, 23, 23,
27, 38, 37, 37, 47, 50, 49, 49, 49, 50, 60, 62, 61, 62, 62, 70, 71, 74, 82, 80,
81, 81, 81, 80, 84, 88, 88, 87, 89, 94, 93, 97, 99, 99, 99, 98, 99, 98, 106,
106, 106, 106, 106, 110, 112, 114, 114, 114, 114, 114, 115, 114, 114, 112, 113,
113, 113, 112, 114, 115, 114, 114, 114, 114, 115, 114, 112, 110, 111, 111, 111,
107, 100, 100, 100, 100, 100, 100, 100, 100, 98, 92, 95, 93, 96, 90, 82, 82, 83,
81, 72, 71, 71, 72, 72, 64, 63, 62, 64, 56, 51, 54, 51, 54, 46, 43, 43, 44, 40,
32, 33, 33, 32, 26, 26, 25, 25, 26, 15, 14, 14, 14, 15, 7, 6, 7, 3, -1, 0, 1,
-1, 1, -1, -3, -3, -2, -4, -10, -10, -10, -13, -13, -12, -13, -13, -13, -11,
-10, -11, -11, -11, -11, -11, -11, -13, -12, -13, -13, -13, -12, -14, -15, -15,
-15, -14, -13, -12, -13, -13, -14, -13, -12, -12, -13, -14, -14, -14, -14, -14,
-11, -9, -6, -4, -5, -5, -5, -5, -5, -4, -2, -2, -2, -1, 4, 7, 9, 9, 10, 9, 10,
9, 10, 13, 16, 16, 16, 15, 19, 30, 31, 30, 30, 30, 30, 30, 30, 33, 37, 37, 37,
37, 43, 47, 46, 46, 46, 46, 46, 46, 45, 49, 52, 50, 51, 50, 53, 54, 54, 54, 54,
54, 54, 54, 54, 54, 52, 53, 52, 53, 51, 51, 51, 51, 51, 48, 48, 48, 47, 47, 47,
45, 47, 43, 41, 42, 42, 42, 41, 40, 37, 38, 38, 38, 33, 33, 33, 30, 28, 29, 28,
30, 29, 27, 26, 25, 26, 26, 22, 22, 22, 20, 21, 20, 21, 20, 20, 20, 19, 19, 19,
18, 16, 15, 14, 13, 14, 12, 13, 12, 13, 12, 12, 10, 11, 11, 9, 8, 5, 5, 5, 4, 5,
5, 6, 2, 0, 0, 0, -1, -5, -6, -11, -10, -10, -9, -10, -10, -9, -16, -18, -17,
-18, -17, -21, -28, -28, -28, -29, -29, -28, -29, -28, -29, -32, -32, -32, -32,
-40, -42, -42, -42, -43, -43, -43, -43, -42, -49, -51, -50, -52, -49, -55, -58,
-57, -58, -59, -64, -64, -64, -63, -65, -69, -68, -68, -68, -74, -75, -74, -75,
-74, -82, -83, -82, -83, -83, -87, -90, -88, -93, -97, -97, -96, -97, -95, -99,
-103, -102, -101, -103, -109, -108, -107, -110, -111, -111, -111, -111, -111,
-114, -114, -114, -114, -114, -117, -117, -117, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -118, -117, -116, -113, -115, -114, -115,
-114, -115, -111, -109, -110, -109, -109, -105, -102, -97, -96, -97, -96, -98,
-97, -97, -95, -90, -91, -92, -89, -80, -77, -73, -73, -73, -72, -74, -73, -73,
-65, -63, -64, -63, -64, -58, -42, -39, -39, -40, -39, -39, -40, -41, -37, -28,
-29, -29, -28, -13, 0, -2, -1, -2, -1, -1, -1, -3, };