#define DATA_LENGTH 512
#define DATA AKWF_vgame_0098

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 25, 43, 63, 81, 98, 108, 115, 118,
118, 116, 115, 115, 115, 116, 116, 117, 117, 117, 117, 117, 116, 117, 116, 115,
116, 115, 116, 116, 116, 116, 117, 117, 118, 118, 119, 118, 118, 116, 115, 113,
113, 112, 113, 114, 115, 115, 116, 117, 117, 117, 115, 116, 114, 113, 114, 114,
114, 113, 114, 114, 115, 115, 116, 116, 117, 117, 116, 116, 115, 114, 115, 113,
112, 112, 113, 114, 114, 114, 114, 115, 115, 115, 116, 115, 115, 114, 114, 112,
112, 111, 110, 112, 112, 111, 113, 113, 114, 114, 115, 115, 116, 116, 116, 114,
113, 112, 111, 111, 111, 112, 112, 113, 114, 114, 114, 114, 113, 114, 113, 112,
112, 111, 111, 112, 111, 111, 112, 112, 112, 112, 113, 113, 113, 114, 114, 113,
112, 113, 112, 111, 111, 111, 110, 110, 111, 110, 112, 111, 113, 113, 112, 112,
112, 113, 112, 111, 111, 110, 108, 108, 107, 109, 111, 115, 118, 118, 119, 118,
112, 102, 89, 74, 58, 40, 22, 2, -17, -34, -48, -61, -68, -70, -67, -64, -61,
-58, -55, -56, -57, -58, -60, -62, -64, -64, -65, -65, -66, -65, -66, -63, -61,
-59, -58, -56, -57, -58, -60, -63, -64, -66, -65, -65, -64, -63, -61, -60, -59,
-59, -59, -59, -60, -60, -60, -60, -61, -61, -60, -62, -61, -60, -61, -61, -60,
-60, -60, -59, -59, -58, -58, -57, -58, -59, -59, -59, -60, -60, -61, -61, -60,
-60, -59, -59, -59, -58, -58, -58, -57, -57, -58, -59, -60, -61, -63, -63, -63,
-63, -60, -60, -58, -57, -57, -57, -57, -58, -59, -60, -61, -60, -61, -60, -61,
-60, -60, -59, -59, -58, -57, -57, -58, -57, -60, -60, -60, -62, -61, -61, -60,
-59, -59, -58, -57, -56, -57, -57, -58, -57, -58, -58, -58, -58, -57, -57, -59,
-59, -58, -59, -59, -60, -60, -59, -58, -58, -59, -58, -58, -59, -60, -61, -61,
-62, -63, -62, -62, -61, -61, -60, -59, -58, -58, -57, -57, -56, -57, -58, -61,
-62, -62, -63, -64, -64, -62, -60, -57, -57, -57, -56, -57, -58, -60, -60, -60,
-62, -62, -62, -61, -62, -60, -60, -59, -58, -57, -56, -56, -56, -57, -58, -58,
-60, -61, -61, -61, -61, -59, -59, -58, -58, -58, -58, -58, -58, -57, -59, -58,
-59, -60, -60, -60, -61, -61, -61, -60, -60, -60, -60, -58, -57, -56, -55, -55,
-57, -57, -58, -59, -60, -62, -61, -61, -61, -60, -58, -57, -57, -57, -56, -55,
-56, -57, -57, -58, -60, -62, -62, -63, -62, -60, -58, -56, -54, -53, -52, -53,
-55, -56, -57, -59, -59, -59, -59, -59, -59, -58, -58, -57, -57, -55, -55, -54,
-54, -54, -56, -55, -56, -57, -57, -57, -57, -58, -58, -57, -57, -56, -56, -56,
-55, -54, -55, -55, -54, -55, -55, -54, -56, -56, -59, -60, -60, -61, -60, -57,
-53, -50, -48, -48, -49, -51, -57, -61, -65, -67, -65, -61, -55, -48, -40, -34,
-29, -25, -21, -17, -10, -2, };