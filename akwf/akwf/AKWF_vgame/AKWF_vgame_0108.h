#define DATA_LENGTH 512
#define DATA AKWF_vgame_0108

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 8, 15, 16, 15, 15, 15, 16, 15,
15, 15, 15, 16, 16, 15, 16, 24, 23, 24, 22, 23, 22, 23, 22, 22, 23, 25, 70, 77,
74, 82, 78, 80, 78, 80, 79, 79, 78, 79, 78, 79, 80, 78, 83, 87, 85, 87, 86, 86,
85, 87, 85, 86, 85, 89, 95, 92, 101, 102, 101, 101, 100, 101, 101, 101, 100,
101, 100, 101, 100, 102, 108, 108, 108, 108, 108, 108, 108, 107, 109, 106, 110,
109, 120, 88, 42, 49, 45, 47, 46, 47, 46, 47, 46, 46, 47, 47, 46, 51, 55, 53,
55, 54, 55, 54, 54, 53, 55, 53, 57, 61, 61, 67, 69, 68, 69, 68, 69, 68, 69, 68,
69, 69, 69, 67, 69, 76, 76, 75, 77, 74, 76, 75, 76, 75, 77, 80, 84, 81, 86, 87,
88, 87, 87, 88, 87, 89, 86, 91, 83, 94, 77, 108, -10, -109, -77, -96, -84, -93,
-85, -91, -87, -90, -86, -81, -82, -81, -78, -76, -77, -76, -77, -75, -78, -76,
-78, -75, -78, -75, -78, -75, -69, -69, -69, -68, -69, -68, -69, -69, -69, -69,
-64, -61, -63, -59, -54, -54, -54, -54, -54, -55, -54, -55, -55, -54, -54, -54,
-54, -52, -46, -48, -45, -48, -46, -48, -46, -49, -42, -60, -112, -116, -115,
-109, -103, -106, -104, -107, -105, -106, -105, -107, -103, -97, -97, -98, -98,
-98, -97, -99, -98, -99, -98, -98, -98, -98, -98, -94, -92, -94, -91, -85, -85,
-85, -86, -86, -86, -86, -86, -85, -86, -86, -85, -87, -82, -76, -78, -78, -78,
-78, -79, -78, -77, -79, -77, -72, -69, -76, -34, -15, -21, -18, -20, -18, -20,
-18, -20, -18, -20, -19, -19, -18, -15, -14, -15, -14, -14, -15, -14, -14, -14,
-14, -10, -6, -8, -5, 1, 1, 1, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 3, 6, 6, 5, 6, 5,
5, 5, 6, 5, 7, 12, 14, 12, 18, 20, 21, 20, 21, 20, 20, 20, 21, 20, 21, 21, 19,
22, -32, -45, -39, -43, -40, -42, -40, -42, -40, -41, -38, -40, -39, -38, -31,
-31, -32, -31, -31, -31, -32, -31, -32, -31, -32, -30, -31, -29, -24, -23, -23,
-23, -24, -24, -24, -24, -25, -17, -16, -16, -16, -14, -11, -12, -12, -12, -11,
-12, -11, -12, -12, -11, -11, -12, -11, -6, -3, -5, -3, -4, -4, -5, -3, -5, -2,
4, 4, 2, 5, 11, 11, 10, 11, 11, 10, 10, 11, 10, 11, 10, 11, 11, 12, 16, 16, 16,
15, 15, 16, 15, 15, 15, 21, 24, 23, 22, 26, 32, 29, 31, 29, 30, 30, 30, 30, 30,
31, 30, 31, 29, 36, 38, 37, 36, 38, 36, 38, 37, 38, 37, 44, 40, 45, 38, -25,
-27, -25, -26, -25, -26, -26, -26, -26, -26, -27, -26, -27, -23, -13, -16, -13,
-15, -14, -15, -14, -15, -14, -10, -9, -8, -10, -5, -1, -2, -1, -1, -1, -2, -2,
-2, -2, -2, -1, -2, -3, };