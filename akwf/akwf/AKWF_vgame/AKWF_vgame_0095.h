#define DATA_LENGTH 512
#define DATA AKWF_vgame_0095

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 5, 6, 6, 8, 10, 12, 14, 15,
15, 17, 19, 20, 21, 24, 25, 26, 26, 28, 30, 30, 32, 32, 31, 34, 37, 40, 41, 43,
44, 45, 46, 48, 50, 51, 53, 54, 55, 57, 58, 59, 60, 61, 62, 65, 66, 66, 69, 70,
72, 73, 74, 77, 79, 81, 82, 83, 83, 84, 86, 87, 88, 89, 88, 90, 90, 92, 93, 94,
94, 94, 95, 97, 98, 99, 101, 102, 104, 105, 106, 107, 108, 109, 110, 111, 111,
111, 110, 111, 112, 112, 113, 113, 113, 114, 115, 115, 115, 116, 117, 117, 118,
118, 118, 118, 119, 118, 119, 119, 118, 119, 118, 117, 117, 117, 117, 117, 116,
116, 118, 118, 117, 117, 118, 117, 118, 119, 118, 118, 118, 117, 117, 116, 115,
114, 113, 113, 113, 112, 112, 112, 111, 111, 111, 110, 109, 110, 110, 111, 109,
108, 108, 107, 107, 107, 106, 105, 103, 102, 102, 101, 102, 102, 101, 100, 101,
100, 101, 100, 99, 98, 98, 97, 97, 97, 96, 94, 92, 91, 89, 88, 86, 84, 84, 81,
80, 80, 79, 78, 78, 76, 74, 74, 72, 72, 71, 70, 68, 67, 66, 65, 63, 62, 60, 59,
57, 56, 55, 54, 52, 51, 50, 50, 49, 48, 48, 47, 44, 44, 43, 42, 40, 39, 38, 36,
37, 35, 34, 32, 30, 29, 27, 26, 25, 23, 24, 22, 20, 19, 19, 17, 17, 15, 13, 12,
11, 10, 8, 7, 4, 3, 1, -2, -2, -4, -5, -7, -9, -10, -11, -12, -12, -14, -15,
-16, -17, -19, -20, -22, -23, -24, -26, -26, -29, -31, -34, -36, -36, -39, -40,
-42, -43, -43, -45, -47, -49, -50, -51, -52, -54, -56, -57, -59, -60, -61, -63,
-64, -66, -69, -71, -71, -74, -75, -77, -78, -79, -78, -79, -80, -81, -83, -84,
-85, -86, -88, -88, -90, -91, -92, -93, -96, -96, -97, -99, -100, -101, -103,
-103, -102, -103, -104, -105, -105, -106, -106, -107, -108, -108, -108, -109,
-110, -111, -111, -112, -113, -114, -114, -115, -115, -116, -116, -117, -118,
-117, -117, -116, -116, -117, -117, -117, -117, -117, -117, -116, -117, -117,
-117, -118, -117, -117, -117, -117, -116, -116, -117, -116, -115, -115, -115,
-115, -115, -115, -113, -113, -113, -113, -112, -112, -112, -113, -113, -111,
-111, -112, -111, -111, -111, -110, -109, -109, -108, -108, -107, -106, -106,
-104, -104, -102, -101, -101, -101, -99, -100, -99, -100, -99, -97, -96, -97,
-96, -94, -94, -94, -93, -93, -91, -89, -89, -88, -87, -87, -86, -84, -83, -82,
-82, -82, -81, -81, -80, -80, -80, -79, -77, -76, -75, -74, -73, -72, -70, -68,
-66, -65, -64, -63, -61, -61, -60, -59, -59, -58, -57, -56, -56, -54, -54, -52,
-51, -49, -49, -48, -46, -44, -42, -42, -40, -39, -38, -36, -35, -34, -33, -33,
-32, -31, -31, -29, -29, -29, -29, -25, -24, -23, -21, -21, -18, -18, -16, -15,
-13, -11, -10, -8, -7, -7, -5, -5, -4, -2, 0, };