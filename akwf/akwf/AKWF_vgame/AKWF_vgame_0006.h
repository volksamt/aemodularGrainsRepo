#define DATA_LENGTH 512
#define DATA AKWF_vgame_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 0, 0, 0, -1, 0, 0, 0, -1, 1, 1,
0, -1, -1, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0,
0, 0, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, -1, 1, 0, 0, 0,
0, 0, 0, 0, 1, 0, -1, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, -1, 0, 0, 0, -1, 0,
0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, -1, 1, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0,
0, 0, -1, 0, 0, -1, 1, -1, 0, -1, 1, 1, 0, 1, 0, 1, 0, 0, 0, 1, 0, 0, -1, 0, 0,
0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 8, 44, 85, 103, 109, 114, 117, 119, 111,
75, 32, 12, 7, -1, -6, -9, -11, -11, -11, -11, -10, -10, -10, -9, -11, -10, -10,
-10, -9, -10, -9, -10, -10, -9, -10, -9, -9, -9, -9, -9, -9, -9, -8, -8, -8, -8,
-8, -8, -8, -7, -8, -8, -7, -7, -8, -7, -7, -6, -7, -7, -7, -6, -6, -6, -7, -7,
-7, -7, -7, -7, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -5, -5, -6, -5, -5, -5,
-5, -5, -5, -5, -4, -6, -5, -6, -5, -5, -5, -4, -5, -4, -4, -4, -5, -4, -4, -3,
-4, -4, -4, -4, -4, -3, -4, -4, -3, -4, -4, -3, -3, -3, -4, -3, -3, -4, -3, -4,
-4, -3, -3, -4, -3, -3, -3, -4, -3, -3, -3, -3, -4, -3, -2, -3, -3, -3, -2, -3,
-2, -2, -3, -2, -3, -2, -2, -3, -2, -2, -2, -2, -2, -3, -3, -2, -2, -2, -2, -2,
-3, -2, -2, -2, -2, -2, -1, -1, -2, -1, -3, -1, -1, -2, -1, -2, -2, -1, -1, -1,
-1, -2, -1, -2, -2, -1, -1, -1, -1, -1, -1, -2, -1, -1, -1, -1, -1, -1, -2, -1,
-1, -1, -1, -1, -1, -2, 0, -1, -1, -2, -1, -1, -2, -1, -1, 0, -1, -2, 0, -2, -1,
-1, -1, -1, -1, 0, 0, -1, 0, -2, -1, -1, -1, -1, 0, 0, 0, -1, 0, 0, -1, 0, 0,
-1, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, -1, -1, 0, -1, 0, -1, -1, 0, -1, 0, -1, 0,
-1, 0, -1, -1, -1, 0, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, -1, 0, 1, 0,
-1, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0, -1, -1, 0, 0, -1, -1, 0, 0, 0, 0, 0,
1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, -1,
0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 1, -1, 0, 0, -1, 0, };