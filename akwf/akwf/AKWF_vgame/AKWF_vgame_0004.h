#define DATA_LENGTH 512
#define DATA AKWF_vgame_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 4, 6, 6, 8, 9, 11, 12, 13, 15,
16, 17, 20, 20, 23, 24, 25, 27, 29, 31, 33, 35, 36, 39, 42, 44, 46, 49, 52, 54,
56, 60, 62, 66, 68, 71, 73, 75, 79, 81, 83, 86, 88, 90, 92, 95, 96, 98, 100,
102, 103, 104, 105, 107, 108, 109, 111, 111, 112, 113, 113, 114, 115, 116, 116,
116, 117, 117, 118, 117, 118, 118, 119, 119, 119, 118, 118, 119, 119, 119, 119,
120, 119, 119, 119, 119, 118, 119, 118, 119, 118, 119, 119, 118, 118, 118, 118,
118, 118, 117, 118, 117, 117, 115, 115, 114, 114, 114, 113, 113, 112, 111, 111,
110, 109, 107, 107, 106, 105, 104, 104, 102, 102, 101, 100, 101, 100, 100, 99,
99, 97, 96, 97, 96, 96, 96, 95, 95, 95, 94, 94, 93, 93, 93, 93, 92, 92, 92, 92,
91, 91, 91, 90, 90, 90, 90, 91, 90, 89, 89, 89, 90, 88, 89, 88, 88, 88, 87, 87,
87, 87, 86, 86, 85, 85, 85, 84, 84, 84, 83, 83, 83, 81, 81, 81, 80, 80, 78, 79,
78, 77, 76, 75, 74, 75, 74, 72, 72, 71, 70, 70, 68, 67, 66, 66, 65, 64, 62, 61,
61, 60, 59, 57, 56, 54, 55, 53, 52, 50, 49, 48, 47, 46, 44, 43, 41, 41, 39, 38,
37, 34, 34, 33, 31, 30, 28, 26, 25, 23, 23, 21, 19, 18, 17, 14, 13, 12, 10, 9,
7, 6, 4, 3, 1, 1, -1, -3, -4, -5, -7, -8, -9, -11, -13, -13, -16, -17, -17, -20,
-20, -22, -23, -25, -27, -28, -31, -33, -35, -36, -39, -41, -44, -46, -49, -51,
-54, -57, -59, -63, -64, -68, -70, -73, -76, -78, -81, -84, -85, -87, -90, -92,
-94, -96, -98, -99, -101, -103, -104, -105, -107, -108, -109, -110, -111, -112,
-112, -114, -114, -115, -116, -117, -116, -117, -117, -117, -118, -117, -118,
-117, -119, -119, -118, -119, -119, -119, -119, -119, -120, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -118, -117,
-118, -117, -116, -117, -116, -116, -115, -116, -115, -114, -114, -113, -112,
-111, -110, -109, -109, -108, -107, -106, -104, -104, -103, -103, -103, -102,
-101, -100, -99, -99, -98, -99, -97, -97, -96, -96, -96, -96, -95, -94, -95,
-94, -94, -94, -93, -93, -92, -93, -93, -92, -92, -91, -92, -91, -90, -91, -91,
-90, -90, -90, -90, -90, -88, -90, -89, -88, -88, -89, -88, -88, -88, -88, -86,
-87, -86, -85, -86, -85, -85, -85, -84, -83, -83, -83, -82, -82, -81, -80, -79,
-79, -78, -78, -77, -76, -75, -75, -74, -73, -73, -72, -71, -70, -69, -69, -68,
-67, -66, -64, -63, -62, -62, -61, -59, -59, -57, -56, -56, -54, -53, -52, -51,
-50, -48, -47, -46, -44, -42, -42, -41, -39, -37, -35, -35, -34, -32, -31, -29,
-28, -27, -25, -25, -22, -21, -19, -18, -17, -15, -14, -13, -11, -9, -8, -6, -5,
-3, -2, 0, };