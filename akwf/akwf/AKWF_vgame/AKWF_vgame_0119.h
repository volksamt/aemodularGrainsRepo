#define DATA_LENGTH 512
#define DATA AKWF_vgame_0119

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 8, 8, 8, 7, 12, 16, 15, 15, 17,
24, 24, 23, 23, 25, 30, 31, 31, 31, 38, 39, 38, 40, 38, 45, 47, 45, 45, 49, 55,
54, 55, 56, 62, 62, 62, 62, 62, 70, 70, 70, 70, 71, 75, 78, 75, 81, 85, 86, 85,
87, 85, 89, 94, 92, 92, 94, 103, 100, 106, 41, 8, 22, 13, 19, 15, 25, 25, 25,
25, 25, 28, 33, 33, 42, 40, 41, 40, 40, 41, 43, 48, 48, 48, 47, 56, 56, 58, 64,
63, 63, 63, 63, 63, 67, 73, 70, 73, 71, 74, 78, 84, 88, 86, 88, 87, 87, 87, 88,
93, 94, 94, 95, 99, 105, 107, 113, 107, 113, 106, 113, 104, 117, 113, 124, 110,
127, 91, -72, -55, -58, -59, -56, -60, -55, -60, -50, -50, -48, -51, -47, -52,
-44, -43, -40, -43, -39, -33, -34, -34, -34, -33, -26, -27, -26, -27, -19, -17,
-19, -17, -20, -12, -11, -11, -13, -6, -3, -3, -4, -1, 4, 4, 5, 5, 5, 13, 13,
14, 11, 14, 19, 21, 20, 25, 31, 26, 31, 23, 40, -18, -64, -52, -59, -52, -48,
-47, -49, -41, -41, -40, -40, -40, -40, -33, -31, -32, -32, -33, -26, -26, -24,
-16, -16, -17, -16, -16, -17, -14, -9, -9, -9, -9, -1, -1, 3, 7, 6, 6, 6, 8, 5,
11, 15, 14, 16, 13, 19, 22, 28, 31, 30, 31, 31, 29, 31, 30, 38, 37, 39, 34, 49,
37, -42, -50, -45, -49, -46, -47, -47, -45, -37, -39, -38, -39, -37, -29, -22,
-24, -23, -22, -22, -23, -23, -22, -18, -15, -16, -16, -11, -1, 0, -1, 0, 0, 0,
-1, 0, -1, 2, 8, 8, 9, 9, 16, 18, 17, 18, 16, 23, 23, 24, 23, 29, 33, 33, 39,
40, 39, 40, 40, 39, 41, 48, 48, 47, 49, 47, 57, 53, 62, 7, -39, -23, -31, -26,
-30, -22, -22, -21, -21, -18, -12, -13, -12, -7, -5, -7, -4, -6, -5, 1, 4, 2, 4,
3, 8, 10, 12, 20, 18, 19, 17, 19, 17, 21, 26, 26, 26, 27, 34, 34, 38, 43, 40,
42, 41, 41, 41, 45, 53, 48, 52, 47, 56, 53, 67, 63, 69, 61, 70, 58, 73, 44,
-122, -119, -118, -121, -111, -112, -101, -105, -102, -105, -103, -104, -103,
-101, -92, -96, -93, -96, -94, -85, -79, -80, -79, -80, -80, -80, -79, -80, -74,
-72, -72, -72, -69, -58, -58, -55, -58, -55, -57, -56, -57, -55, -48, -48, -47,
-49, -47, -42, -41, -41, -42, -35, -32, -34, -32, -34, -26, -26, -24, -28, -20,
-18, -13, -21, -8, -37, -103, -98, -100, -100, -99, -92, -93, -94, -87, -85,
-84, -84, -84, -86, -79, -77, -77, -78, -73, -68, -69, -68, -62, -61, -62, -61,
-62, -61, -54, -53, -53, -53, -53, -47, -46, -44, -37, -38, -38, -38, -37, -39,
-34, -30, -30, -30, -29, -21, -22, -18, -14, -15, -15, -14, -14, -16, -8, -5,
-7, -6, -7, -3, };