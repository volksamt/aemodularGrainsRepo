#define DATA_LENGTH 512
#define DATA AKWF_vgame_0124

const PROGMEM int8_t DATA[DATA_LENGTH] = {56, 75, 69, 72, 71, 72, 71, 72, 72,
71, 72, 71, 75, 117, 119, 119, 119, 118, 119, 118, 118, 118, 119, 118, 119, 117,
119, 117, 119, 118, 119, 118, 118, 118, 118, 117, 119, 118, 118, 118, 118, 118,
118, 118, 118, 118, 117, 118, 117, 118, 118, 118, 118, 118, 118, 118, 117, 119,
118, 118, 117, 118, 118, 117, 117, 118, 117, 118, 118, 118, 118, 118, 117, 117,
117, 118, 118, 117, 117, 118, 118, 116, 118, 117, 119, 116, 119, 115, 122, 100,
65, 73, 69, 71, 69, 71, 71, 71, 71, 70, 70, 70, 71, 70, 71, 71, 71, 70, 71, 70,
71, 70, 71, 70, 71, 70, 71, 69, 72, 70, 71, 69, 71, 69, 72, 69, 72, 67, 80, 120,
115, 118, 116, 118, 114, 121, 93, 64, 74, 68, 72, 68, 72, 69, 70, 70, 71, 70,
70, 70, 70, 69, 70, 70, 70, 69, 70, 69, 70, 69, 72, 68, 74, 57, 19, 25, 22, 24,
23, 23, 23, 22, 23, 23, 22, 23, 23, 23, 23, 23, 24, 24, 23, 24, 23, 23, 23, 23,
22, 24, 20, -22, -25, -22, -25, -23, -25, -23, -24, -23, -24, -23, -24, -23,
-25, -24, -24, -23, -24, -23, -24, -24, -24, -24, -23, -24, -23, -25, -23, -25,
-22, -26, -20, -55, -75, -68, -72, -69, -71, -69, -71, -70, -71, -70, -71, -70,
-70, -70, -71, -70, -71, -70, -72, -69, -71, -70, -72, -69, -72, -69, -71, -69,
-73, -62, 18, 27, 20, 24, 57, 75, 66, 73, 68, 72, 69, 71, 69, 71, 70, 71, 70,
70, 71, 70, 70, 69, 71, 69, 71, 70, 69, 70, 70, 70, 68, 73, 39, 18, 25, 22, 25,
22, 24, 22, 23, 22, 23, 24, 23, 23, 23, 23, 23, 24, 23, 24, 24, 22, 24, 23, 24,
21, 28, 2, -28, -22, -23, -22, -24, -23, -23, -24, -24, -23, -23, -23, -24, -24,
-24, -23, -24, -24, -24, -23, -24, -24, -24, -23, -25, -20, -33, -71, -71, -71,
-70, -70, -71, -70, -70, -69, -70, -70, -71, -70, -70, -71, -70, -70, -70, -70,
-70, -71, -71, -71, -69, -71, -70, -70, -69, -71, -70, -71, -68, -73, -111,
-117, -118, -115, -119, -114, -121, -81, -20, -22, -25, -20, -34, -72, -70, -70,
-70, -70, -70, -70, -70, -70, -70, -70, -71, -69, -70, -70, -71, -69, -71, -70,
-70, -69, -70, -70, -70, -71, -69, -71, -69, -71, -69, -71, -67, -72, -64, -84,
-116, -115, -117, -116, -117, -116, -116, -116, -116, -116, -116, -116, -116,
-116, -116, -117, -116, -117, -116, -116, -116, -116, -116, -115, -116, -117,
-116, -116, -116, -116, -116, -116, -116, -116, -116, -116, -116, -116, -117,
-116, -116, -116, -116, -116, -116, -115, -116, -116, -116, -116, -116, -116,
-116, -115, -115, -116, -116, -115, -116, -116, -116, -116, -114, -116, -116,
-116, -116, -115, -116, -115, -116, -115, -116, -115, -116, -115, -116, -78,
-66, -70, -66, -74, -36, -18, -24, -20, -23, -19, -23, -23, };