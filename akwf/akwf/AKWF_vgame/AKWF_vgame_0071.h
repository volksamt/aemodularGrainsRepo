#define DATA_LENGTH 512
#define DATA AKWF_vgame_0071

const PROGMEM int8_t DATA[DATA_LENGTH] = {62, 123, 106, 102, 106, 110, 106, 106,
108, 106, 106, 107, 107, 107, 107, 106, 107, 106, 107, 106, 107, 106, 107, 107,
107, 106, 106, 107, 106, 107, 107, 107, 106, 107, 108, 107, 107, 108, 106, 107,
107, 108, 107, 108, 107, 107, 107, 107, 108, 108, 108, 107, 108, 108, 107, 107,
107, 107, 107, 107, 108, 107, 107, 107, 108, 107, 107, 107, 107, 108, 106, 107,
108, 106, 107, 107, 107, 107, 108, 107, 107, 107, 107, 107, 107, 107, 107, 108,
106, 105, 105, 105, 106, 105, 105, 105, 106, 106, 105, 106, 106, 106, 107, 105,
105, 107, 105, 107, 107, 105, 106, 106, 105, 106, 106, 104, 107, 107, 103, 108,
106, 102, 108, 105, 99, 107, 119, 71, -26, -47, -31, -35, -37, -36, -37, -34,
-36, -36, -35, -35, -37, -35, -35, -36, -37, -36, -35, -36, -36, -35, -35, -36,
-36, -35, -36, -35, -35, -36, -37, -35, -35, -37, -35, -35, -36, -35, -35, -35,
-36, -36, -37, -36, -36, -37, -37, -36, -36, -36, -36, -37, -37, -36, -35, -36,
-36, -36, -36, -36, -37, -36, -37, -36, -36, -37, -36, -36, -37, -35, -36, -36,
-36, -36, -36, -36, -36, -36, -36, -36, -36, -36, -35, -35, -36, -37, -36, -36,
-36, -36, -36, -36, -36, -35, -37, -36, -36, -36, -36, -36, -35, -35, -36, -36,
-36, -36, -35, -37, -36, -36, -36, -37, -36, -36, -35, -36, -35, -36, -36, -36,
-36, -35, -36, -36, -36, -36, -36, -35, -36, -36, -36, -36, -36, -36, -36, -36,
-36, -36, -35, -36, -35, -36, -36, -36, -36, -36, -36, -36, -35, -36, -36, -37,
-36, -36, -36, -36, -36, -35, -37, -36, -36, -36, -36, -36, -36, -36, -36, -36,
-36, -35, -36, -36, -36, -36, -35, -36, -36, -37, -36, -36, -36, -35, -36, -36,
-35, -35, -36, -35, -35, -36, -35, -35, -36, -35, -36, -35, -36, -36, -35, -35,
-35, -35, -36, -35, -35, -36, -35, -36, -35, -35, -36, -36, -35, -36, -35, -35,
-36, -35, -36, -35, -35, -36, -36, -35, -35, -35, -35, -36, -35, -35, -36, -36,
-35, -35, -35, -35, -36, -35, -35, -36, -36, -35, -35, -36, -36, -35, -35, -35,
-35, -36, -36, -36, -35, -35, -36, -35, -35, -35, -36, -35, -36, -35, -36, -35,
-35, -36, -36, -35, -36, -35, -35, -36, -34, -35, -36, -36, -35, -36, -35, -36,
-35, -35, -35, -34, -35, -35, -35, -35, -35, -36, -35, -35, -34, -35, -35, -34,
-35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -34, -35, -34, -35, -35, -36,
-35, -35, -34, -34, -35, -35, -35, -35, -36, -34, -35, -35, -35, -34, -35, -35,
-35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -34, -35, -35, -35, -35, -35,
-35, -35, -33, -33, -35, -35, -33, -35, -33, -32, -35, -35, -33, -36, -33, -34,
-35, -35, -32, -34, -35, -34, -34, -35, -35, -32, -34, -34, -34, -33, -35, -35,
-34, -33, -35, -33, -33, -29, -43, -35, };