#define DATA_LENGTH 512
#define DATA AKWF_vgame_0136

const PROGMEM int8_t DATA[DATA_LENGTH] = {15, 26, 25, 25, 24, 25, 24, 25, 24,
24, 25, 25, 24, 25, 25, 25, 25, 24, 24, 25, 24, 24, 24, 24, 24, 25, 25, 24, 24,
24, 24, 25, 25, 24, 24, 24, 25, 24, 25, 24, 25, 24, 24, 24, 25, 25, 24, 25, 24,
26, 24, 25, 23, 25, 23, 26, 22, 27, 21, 32, 74, 70, 72, 72, 71, 71, 71, 72, 71,
72, 72, 72, 71, 71, 71, 71, 71, 72, 71, 72, 71, 71, 71, 72, 71, 71, 72, 71, 72,
71, 71, 71, 71, 71, 71, 71, 71, 70, 72, 71, 71, 71, 71, 71, 71, 72, 71, 71, 70,
72, 71, 72, 70, 72, 69, 73, 67, 82, 123, 116, 119, 118, 118, 119, 116, 120, 115,
121, 112, 127, 74, 13, 29, 21, 26, 22, 25, 24, 24, 24, 23, 25, 23, 24, 22, 24,
23, 24, 23, 25, 22, 24, 22, 25, 22, 25, 23, 25, 23, 24, 23, 24, 24, 23, 25, 22,
28, -87, -126, -111, -122, -114, -120, -115, -120, -115, -119, -116, -118, -117,
-118, -117, -118, -117, -117, -117, -116, -119, -116, -118, -117, -117, -116,
-118, -116, -118, -112, -72, -69, -72, -69, -72, -69, -71, -69, -71, -69, -70,
-70, -71, -70, -71, -70, -70, -70, -70, -70, -70, -71, -70, -70, -71, -71, -70,
-70, -70, -70, -70, -70, -70, -70, -70, -70, -70, -70, -69, -70, -69, -70, -70,
-70, -69, -70, -69, -71, -70, -70, -69, -70, -69, -71, -69, -71, -67, -25, -20,
-24, -21, -23, -22, -24, -22, -23, -23, -24, -22, -23, -23, -22, -23, -23, -23,
-23, -23, -23, -23, -22, -23, -23, -23, -23, -23, -23, -22, -22, -23, -23, -23,
-23, -23, -22, -23, -23, -23, -23, -22, -23, -23, -23, -22, -22, -22, -23, -23,
-23, -22, -23, -22, -23, -22, -23, -22, -23, -22, -23, -21, -26, -14, 25, 25,
24, 26, 24, 25, 24, 25, 24, 25, 24, 25, 24, 25, 24, 25, 24, 25, 25, 25, 24, 25,
25, 25, 24, 25, 25, 24, 24, 25, 25, 24, 25, 25, 24, 24, 25, 25, 25, 25, 25, 24,
24, 25, 24, 24, 24, 25, 25, 24, 25, 24, 25, 23, 26, 23, 27, 19, 43, 75, 71, 72,
72, 72, 72, 71, 71, 71, 72, 72, 71, 72, 72, 72, 72, 71, 72, 72, 71, 72, 72, 71,
71, 72, 70, 72, 72, 72, 71, 71, 71, 72, 72, 71, 72, 70, 73, 68, 81, 21, -31,
-18, -25, -21, -25, -21, -23, -61, -74, -69, -70, -69, -71, -69, -70, -70, -69,
-69, -70, -70, -70, -71, -70, -71, -70, -69, -70, -69, -70, -69, -71, -67, -75,
-48, -18, -25, -22, -24, -22, -24, -22, -23, -23, -23, -23, -23, -22, -22, -23,
-23, -23, -23, -23, -23, -23, -22, -23, -22, -22, -23, -23, -23, -23, -22, -22,
-23, -23, -22, -23, -23, -23, -23, -23, -23, -23, -23, -22, -23, -22, -22, -22,
-23, -24, -23, -23, -22, -23, -22, -22, -22, -24, -21, -25, -22, };