#define DATA_LENGTH 512
#define DATA AKWF_vgame_0081

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 16, 24, 32, 37, 41, 44, 46, 48, 48,
47, 44, 43, 42, 38, 36, 32, 32, 30, 29, 27, 25, 26, 26, 25, 26, 26, 27, 29, 30,
31, 30, 31, 32, 32, 32, 32, 33, 33, 32, 32, 33, 33, 33, 32, 32, 32, 32, 32, 32,
32, 32, 32, 32, 33, 32, 32, 32, 33, 33, 33, 32, 31, 30, 30, 30, 31, 31, 30, 31,
30, 31, 31, 30, 30, 30, 31, 31, 31, 33, 32, 32, 33, 32, 32, 33, 33, 33, 33, 33,
32, 32, 32, 31, 31, 30, 30, 30, 30, 30, 30, 31, 30, 30, 31, 32, 33, 32, 32, 32,
32, 32, 32, 32, 32, 32, 32, 31, 31, 30, 31, 30, 31, 30, 30, 31, 31, 30, 30, 30,
31, 29, 30, 32, 32, 33, 32, 32, 32, 32, 32, 33, 31, 33, 32, 32, 32, 31, 32, 32,
32, 32, 32, 32, 33, 33, 31, 31, 32, 31, 32, 32, 32, 32, 33, 33, 32, 32, 32, 32,
32, 33, 32, 32, 32, 32, 31, 31, 32, 31, 31, 33, 32, 32, 32, 32, 32, 32, 32, 32,
32, 32, 31, 32, 31, 32, 31, 31, 32, 32, 32, 31, 32, 32, 31, 32, 32, 32, 32, 31,
31, 32, 32, 32, 32, 32, 31, 32, 31, 32, 32, 31, 31, 31, 31, 31, 32, 32, 32, 32,
32, 33, 32, 31, 31, 32, 31, 32, 32, 32, 31, 32, 32, 31, 31, 31, 31, 32, 32, 32,
32, 31, 32, 32, 31, 31, 31, 32, 31, 31, 31, 32, 31, 31, 30, 29, 29, 30, 29, 29,
30, 30, 30, 30, 30, 29, 30, 30, 31, 32, 32, 32, 31, 31, 31, 31, 31, 31, 31, 32,
30, 30, 30, 30, 29, 30, 30, 30, 29, 30, 29, 30, 30, 30, 31, 31, 32, 31, 30, 31,
31, 32, 31, 32, 31, 31, 32, 31, 29, 30, 30, 29, 29, 30, 30, 29, 30, 29, 29, 29,
30, 31, 32, 31, 30, 32, 32, 33, 33, 33, 33, 33, 33, 31, 30, 30, 29, 28, 27, 28,
28, 27, 26, 26, 26, 25, 26, 26, 27, 28, 27, 28, 28, 29, 31, 31, 33, 35, 37, 39,
40, 40, 42, 42, 43, 41, 39, 36, 33, 28, 22, 15, 5, -2, -12, -23, -34, -45, -56,
-67, -75, -85, -94, -102, -108, -113, -115, -117, -118, -119, -118, -116, -113,
-111, -107, -105, -101, -99, -97, -95, -93, -92, -93, -92, -94, -95, -96, -98,
-98, -99, -100, -101, -102, -103, -103, -103, -103, -102, -102, -102, -102,
-102, -101, -102, -101, -100, -100, -100, -99, -100, -99, -99, -99, -99, -100,
-100, -101, -102, -102, -101, -101, -101, -100, -101, -102, -102, -103, -103,
-103, -102, -101, -101, -101, -101, -99, -99, -100, -99, -98, -97, -97, -97,
-97, -97, -98, -97, -97, -97, -97, -96, -97, -97, -99, -99, -100, -101, -102,
-102, -104, -106, -107, -110, -110, -109, -110, -110, -110, -107, -104, -101,
-96, -91, -83, -76, -68, -58, -48, -38, -28, -21, -11, -2, };