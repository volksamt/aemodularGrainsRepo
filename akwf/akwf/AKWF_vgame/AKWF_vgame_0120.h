#define DATA_LENGTH 512
#define DATA AKWF_vgame_0120

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 2, 2, 2, 1, 2, 2, 2, 2, 1, 3, 1, 4,
8, 7, 8, 8, 7, 7, 8, 7, 7, 8, 7, 11, 15, 20, 22, 20, 21, 20, 22, 21, 21, 20, 21,
20, 23, 27, 31, 35, 34, 34, 33, 33, 38, 40, 39, 40, 39, 41, 40, 40, 46, 47, 46,
47, 47, 47, 47, 46, 46, 48, 45, 48, 52, 56, 61, 58, 59, 59, 59, 60, 59, 60, 59,
60, 59, 64, 68, 71, 72, 73, 73, 72, 73, 72, 73, 73, 73, 72, 74, 78, 82, 86, 85,
85, 85, 86, 85, 84, 86, 85, 85, 84, 90, 92, 98, 98, 98, 98, 98, 98, 97, 99, 97,
100, 96, 101, 103, 109, 110, 112, 109, 113, 109, 114, 109, 114, 108, 114, 106,
122, 103, -40, -40, -36, -41, -37, -41, -36, -41, -37, -41, -38, -39, -31, -30,
-24, -27, -25, -27, -26, -26, -25, -27, -25, -25, -26, -20, -18, -13, -13, -13,
-13, -12, -13, -13, -13, -12, -12, -14, -11, -6, -3, 1, 0, 1, 0, 0, 0, 0, 0, 1,
0, 1, 6, 8, 14, 12, 13, 14, 13, 14, 13, 13, 13, 14, 12, 16, 19, 24, 28, 26, 26,
27, 26, 26, 26, 26, 26, 29, 34, 32, 34, 40, 39, 39, 39, 39, 40, 40, 40, 39, 40,
38, 41, 46, 50, 53, 52, 53, 52, 52, 52, 52, 52, 53, 52, 52, 57, 60, 66, 65, 65,
66, 65, 66, 65, 66, 65, 67, 63, 69, 70, 78, 77, 80, 77, 80, 76, 80, 76, 80, 77,
77, 84, -57, -84, -66, -76, -68, -75, -68, -74, -70, -73, -70, -73, -70, -70,
-64, -62, -57, -60, -58, -59, -58, -59, -58, -58, -59, -58, -58, -53, -51, -45,
-46, -45, -46, -45, -45, -46, -45, -45, -45, -45, -44, -39, -35, -32, -32, -33,
-33, -32, -32, -32, -33, -32, -33, -32, -27, -24, -19, -20, -19, -19, -20, -20,
-19, -19, -19, -19, -20, -16, -13, -9, -6, -7, -6, -6, -6, -7, -6, -6, -6, -7,
-5, -1, 2, 7, 7, 6, 7, 6, 7, 6, 8, 7, 8, 7, 9, 14, 18, 20, 19, 19, 20, 20, 19,
21, 19, 21, 19, 20, 19, 29, 32, 34, 32, 35, 33, 35, 33, 36, 32, 35, 32, 34, 42,
-72, -121, -113, -119, -114, -118, -114, -117, -115, -117, -114, -117, -115,
-108, -103, -103, -102, -103, -102, -103, -103, -103, -103, -104, -102, -103,
-99, -91, -91, -90, -90, -89, -91, -90, -89, -90, -90, -90, -90, -89, -81, -76,
-77, -77, -76, -76, -76, -77, -77, -77, -76, -77, -76, -73, -64, -63, -63, -64,
-64, -64, -63, -64, -64, -64, -64, -63, -63, -55, -50, -51, -50, -51, -51, -51,
-50, -50, -51, -51, -50, -51, -46, -37, -37, -37, -37, -38, -37, -38, -37, -37,
-38, -37, -38, -37, -28, -24, -24, -24, -24, -24, -25, -24, -25, -24, -25, -24,
-25, -20, -11, -11, -11, -12, -11, -11, -12, -12, -11, -11, -11, -12, -10, -3,
};