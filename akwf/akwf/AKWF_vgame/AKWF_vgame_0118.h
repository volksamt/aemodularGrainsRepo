#define DATA_LENGTH 512
#define DATA AKWF_vgame_0118

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 11, 10, 11, 10, 13, 16, 15, 19,
20, 22, 25, 24, 28, 32, 34, 32, 33, 32, 37, 38, 40, 42, 42, 42, 46, 47, 48, 53,
52, 55, 58, 56, 58, 61, 61, 65, 68, 67, 72, 70, 73, 75, 76, 76, 80, 79, 83, 85,
85, 88, 89, 88, 92, 93, 98, 99, 98, 101, 104, 102, 29, 9, 20, 16, 24, 19, 27,
26, 32, 29, 31, 30, 35, 34, 36, 41, 40, 44, 44, 45, 49, 50, 53, 54, 53, 54, 59,
59, 61, 63, 62, 63, 68, 66, 71, 77, 77, 76, 76, 76, 80, 81, 81, 87, 85, 89, 90,
91, 94, 101, 97, 101, 97, 100, 103, 106, 104, 111, 107, 110, 111, 113, 115, 119,
112, -51, -79, -59, -70, -59, -68, -55, -62, -54, -55, -52, -52, -48, -51, -47,
-46, -46, -41, -39, -39, -35, -37, -32, -31, -31, -27, -27, -26, -22, -21, -22,
-17, -18, -17, -14, -12, -8, -8, -6, -2, -4, -2, 1, 1, 1, 4, 6, 6, 11, 11, 12,
17, 18, 21, 18, 20, 21, 27, 23, 31, 28, 31, 30, 37, 29, -49, -49, -46, -49, -47,
-46, -42, -45, -41, -40, -38, -34, -33, -33, -26, -25, -24, -26, -24, -23, -18,
-21, -15, -15, -14, -10, -11, -12, -7, -7, -6, 0, -2, 2, 3, 3, 4, 9, 6, 13, 12,
14, 17, 16, 20, 22, 21, 22, 26, 24, 29, 31, 31, 36, 35, 36, 42, 37, 44, 39, 58,
-5, -61, -44, -54, -42, -49, -40, -41, -37, -35, -37, -35, -31, -31, -32, -27,
-28, -25, -22, -22, -18, -17, -13, -12, -13, -14, -8, -8, -7, -2, -4, 1, 0, 1,
1, 9, 11, 11, 10, 11, 15, 15, 15, 19, 18, 21, 25, 24, 27, 33, 32, 34, 34, 33,
36, 38, 38, 44, 42, 45, 48, 45, 50, 48, 61, 0, -42, -29, -33, -29, -30, -24,
-27, -25, -22, -22, -19, -15, -13, -11, -12, -12, -10, -6, -8, -1, -2, 0, 4, 2,
6, 7, 7, 10, 13, 12, 16, 16, 18, 22, 21, 22, 24, 26, 32, 31, 31, 33, 36, 34, 37,
39, 39, 44, 45, 45, 50, 50, 55, 51, 55, 53, 59, 57, 63, 63, 63, 69, 62, 83, -51,
-125, -107, -118, -110, -114, -107, -111, -103, -106, -105, -104, -100, -101,
-94, -90, -90, -90, -91, -91, -87, -86, -84, -80, -81, -77, -77, -77, -75, -72,
-73, -68, -67, -65, -62, -63, -60, -58, -58, -57, -54, -54, -50, -49, -47, -44,
-43, -45, -41, -40, -38, -34, -35, -32, -30, -29, -26, -26, -26, -23, -22, -20,
-19, -7, -65, -111, -100, -103, -98, -97, -92, -93, -92, -89, -89, -87, -85,
-84, -84, -80, -80, -77, -75, -71, -70, -70, -70, -68, -66, -65, -61, -60, -59,
-55, -56, -56, -52, -45, -46, -46, -46, -42, -41, -40, -38, -38, -37, -34, -33,
-32, -25, -23, -24, -24, -23, -22, -16, -13, -14, -14, -12, -9, -10, -7, -2, -1,
0, -2, -1, };