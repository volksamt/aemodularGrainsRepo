#define DATA_LENGTH 512
#define DATA AKWF_vgame_0063

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 16, 32, 47, 62, 73, 85, 93, 103,
109, 116, 118, 119, 118, 116, 112, 108, 103, 98, 95, 93, 92, 91, 91, 94, 97,
100, 103, 106, 107, 108, 107, 106, 105, 104, 102, 99, 98, 98, 97, 96, 98, 99,
101, 103, 103, 103, 103, 103, 103, 104, 103, 102, 100, 99, 99, 99, 98, 98, 100,
101, 102, 103, 103, 103, 103, 103, 104, 103, 103, 102, 100, 99, 98, 99, 99, 99,
99, 100, 101, 103, 103, 104, 103, 103, 103, 103, 102, 101, 99, 99, 98, 98, 98,
98, 99, 100, 102, 102, 103, 103, 103, 102, 102, 103, 102, 100, 100, 99, 99, 99,
98, 98, 99, 100, 100, 102, 104, 105, 104, 103, 102, 101, 99, 98, 98, 98, 98, 98,
99, 100, 101, 101, 103, 106, 107, 107, 105, 103, 100, 98, 95, 92, 90, 89, 89,
93, 95, 98, 103, 107, 112, 117, 117, 117, 116, 113, 106, 99, 88, 77, 65, 49, 35,
21, 7, -8, -23, -35, -45, -54, -61, -67, -68, -68, -66, -63, -58, -52, -46, -41,
-37, -35, -34, -34, -37, -40, -44, -46, -51, -54, -56, -56, -55, -56, -53, -48,
-46, -44, -42, -42, -42, -43, -44, -45, -47, -49, -50, -50, -50, -52, -52, -51,
-50, -48, -47, -46, -45, -44, -44, -45, -46, -48, -48, -48, -48, -49, -51, -50,
-49, -48, -47, -47, -47, -46, -45, -45, -45, -46, -46, -47, -47, -47, -49, -50,
-50, -51, -49, -48, -48, -48, -46, -46, -45, -45, -45, -45, -46, -46, -46, -48,
-48, -48, -47, -47, -48, -48, -47, -46, -45, -45, -45, -45, -45, -45, -46, -47,
-48, -47, -47, -47, -47, -48, -47, -48, -48, -48, -46, -45, -45, -44, -46, -47,
-48, -48, -47, -47, -48, -48, -47, -48, -47, -47, -48, -47, -47, -47, -47, -47,
-47, -47, -47, -47, -47, -47, -47, -47, -47, -47, -48, -47, -47, -47, -47, -47,
-47, -47, -47, -46, -47, -48, -46, -47, -48, -47, -47, -48, -47, -47, -47, -47,
-47, -47, -47, -47, -47, -47, -47, -46, -47, -47, -48, -47, -47, -47, -47, -47,
-47, -47, -46, -47, -47, -47, -47, -48, -47, -46, -47, -47, -47, -47, -46, -47,
-48, -47, -47, -46, -47, -47, -47, -47, -46, -46, -46, -47, -47, -47, -46, -47,
-47, -47, -47, -47, -47, -47, -47, -46, -47, -46, -47, -47, -46, -46, -47, -47,
-47, -46, -47, -46, -47, -46, -46, -47, -46, -47, -46, -47, -46, -47, -46, -46,
-47, -46, -46, -46, -47, -46, -46, -46, -47, -47, -46, -46, -46, -47, -46, -46,
-46, -46, -45, -44, -44, -44, -44, -44, -45, -46, -46, -47, -46, -47, -46, -46,
-46, -46, -45, -44, -44, -44, -44, -45, -45, -44, -45, -47, -47, -47, -47, -48,
-48, -46, -46, -46, -45, -44, -43, -44, -44, -43, -44, -43, -44, -46, -47, -48,
-48, -48, -49, -49, -46, -44, -42, -42, -40, -40, -40, -41, -44, -46, -47, -50,
-52, -54, -55, -56, -53, -51, -47, -43, -35, -24, -10, };