#define DATA_LENGTH 512
#define DATA AKWF_vgame_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 1,
0, -1, 0, 0, 0, 1, -1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0,
0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, -1, 0, 1, 1, 0, 0, 0,
0, 1, 0, 0, 0, 1, 1, 1, 1, 1, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0,
0, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 1, 1, 1, 1, 15, 53,
90, 105, 109, 114, 117, 119, 119, 118, 116, 115, 113, 112, 112, 110, 109, 106,
105, 105, 103, 102, 101, 99, 99, 97, 96, 95, 80, 38, 1, -14, -20, -25, -31, -33,
-33, -34, -33, -33, -33, -32, -32, -32, -32, -31, -31, -29, -30, -29, -29, -30,
-29, -29, -29, -28, -28, -27, -27, -27, -27, -26, -26, -26, -26, -25, -25, -24,
-25, -25, -24, -23, -24, -24, -23, -22, -22, -22, -21, -22, -22, -21, -21, -21,
-21, -19, -20, -20, -20, -19, -19, -19, -19, -19, -18, -18, -18, -18, -18, -17,
-17, -17, -17, -16, -17, -17, -16, -16, -16, -16, -16, -15, -15, -16, -15, -15,
-14, -14, -14, -14, -13, -14, -13, -13, -13, -13, -12, -12, -13, -12, -12, -11,
-12, -12, -12, -11, -11, -12, -11, -11, -11, -11, -11, -11, -11, -10, -10, -9,
-9, -10, -9, -9, -9, -9, -9, -8, -9, -9, -9, -8, -8, -8, -8, -8, -8, -8, -8, -8,
-8, -7, -7, -7, -7, -7, -7, -7, -7, -7, -6, -7, -7, -6, -6, -6, -7, -6, -6, -6,
-6, -5, -6, -5, -6, -5, -5, -5, -6, -5, -6, -5, -5, -4, -5, -5, -5, -5, -5, -5,
-4, -4, -4, -4, -5, -4, -4, -4, -4, -4, -4, -3, -4, -4, -3, -3, -4, -3, -3, -3,
-3, -3, -3, -3, -2, -3, -3, -3, -4, -3, -3, -3, -3, -2, -2, -3, -2, -2, -3, -3,
-2, -2, -3, -3, -2, -3, -2, -2, -3, -3, -2, -2, -2, -2, -2, -2, -2, -2, -1, -1,
-1, -2, -2, -1, -1, -1, -1, -2, -2, -1, -1, -2, -1, -1, -1, -1, -1, -1, -1, -1,
-1, -1, 0, -1, -1, 0, -1, -1, -1, -1, -1, -1, 0, -1, 0, -1, -1, -1, -1, -1, 0,
-1, -1, -1, -1, 0, 0, 0, -1, -1, -2, -1, -1, -1, -1, 0, -1, -1, -1, 0, 0, 0, 0,
-1, -1, -1, 0, 0, -1, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, -1, 0,
1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, };