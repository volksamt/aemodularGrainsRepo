#define DATA_LENGTH 512
#define DATA AKWF_vgame_0105

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 14, 12, 14, 14, 13, 13, 13, 13, 14,
13, 14, 11, 16, 48, 48, 48, 48, 48, 49, 48, 49, 47, 50, 45, 52, 40, 87, 120,
109, 115, 111, 114, 112, 114, 112, 113, 112, 113, 112, 113, 113, 113, 113, 113,
112, 113, 113, 112, 113, 112, 113, 112, 114, 104, 96, 99, 97, 98, 97, 98, 97,
98, 96, 99, 94, 104, 82, 18, 21, 21, 21, 20, 21, 21, 20, 20, 19, 21, 18, 26,
-31, -54, -47, -51, -48, -51, -49, -49, -50, -50, -50, -49, -51, -45, -22, -25,
-24, -26, -25, -24, -25, -25, -25, -24, -25, -24, -26, -18, -17, -18, -17, -16,
-18, -17, -17, -17, -18, -16, -19, -13, -31, -69, -64, -65, -64, -65, -64, -65,
-64, -65, -64, -65, -64, -64, -108, -120, -118, -120, -118, -119, -119, -119,
-120, -118, -121, -115, -126, -85, -30, -41, -34, -39, -36, -38, -36, -37, -36,
-37, -37, -36, -38, 20, 32, 26, 29, 27, 28, 27, 28, 28, 29, 27, 28, 28, 28, 28,
28, 28, 28, 28, 27, 28, 27, 29, 27, 29, 26, 33, 82, 91, 86, 89, 87, 89, 87, 88,
88, 87, 88, 86, 90, 75, 60, 63, 62, 63, 62, 63, 62, 62, 62, 62, 62, 63, 62, 51,
51, 50, 49, 50, 50, 51, 50, 51, 49, 51, 49, 54, 34, 16, 22, 19, 21, 19, 20, 19,
20, 21, 20, 20, 21, 19, 7, 8, 8, 7, 8, 7, 7, 8, 8, 8, 8, 7, 13, -26, -53, -44,
-48, -46, -48, -46, -49, -46, -51, -55, -55, -54, -54, -54, -54, -55, -55, -55,
-55, -55, -55, -55, -53, -55, -52, -59, -34, -21, -27, -23, -26, -24, -25, -24,
-25, -24, -25, -24, -25, -24, -22, -22, -22, -22, -22, -22, -22, -22, -22, -22,
-21, -23, -20, -41, -52, -48, -50, -49, -50, -49, -50, -49, -49, -50, -49, -50,
-49, -50, -49, -50, -49, -49, -49, -50, -49, -50, -50, -50, -50, -50, -41, -39,
-40, -39, -40, -38, -41, -38, -41, -36, -44, -33, -49, -5, 69, 52, 61, 56, 60,
57, 58, 59, 58, 59, 57, 60, 55, 98, 108, 104, 106, 104, 106, 104, 106, 106, 104,
105, 103, 109, 91, 61, 67, 64, 66, 64, 67, 64, 66, 64, 67, 62, 68, 61, -7, -21,
-16, -18, -15, -17, -17, -17, -17, -17, -17, -16, -20, -8, 5, 2, 3, 2, 3, 2, 4,
2, 3, 3, 3, 4, 2, -3, -4, -4, -6, -5, -5, -4, -5, -4, -5, -4, -5, -4, -7, -10,
-8, -10, -10, -11, -10, -10, -9, -11, -8, -12, -6, -18, -69, -73, -71, -72, -71,
-72, -72, -72, -72, -72, -71, -71, -72, -72, -71, -71, -71, -72, -71, -71, -72,
-72, -71, -71, -72, -71, -72, -79, -79, -79, -80, -79, -79, -80, -79, -79, -79,
-78, -78, -80, -69, -58, -63, -60, -63, -60, -62, -60, -63, -60, -63, -60, -64,
-50, -5, -7, -7, -7, -8, -7, -7, -6, -7, -7, -7, -6, -8, };