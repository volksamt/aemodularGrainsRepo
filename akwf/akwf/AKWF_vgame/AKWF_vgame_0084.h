#define DATA_LENGTH 512
#define DATA AKWF_vgame_0084

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 2, -1, 4, -3, 12, 2, 20, 82, 69,
81, 85, 87, 87, 87, 88, 96, 97, 95, 97, 94, 102, 107, 107, 106, 107, 110, 116,
118, 118, 118, 118, 111, 104, 107, 105, 107, 103, 94, 98, 97, 98, 94, 84, 86,
85, 87, 85, 75, 76, 74, 76, 74, 67, 64, 64, 64, 65, 64, 53, 53, 53, 53, 55, 46,
44, 42, 42, 43, 38, 32, 31, 31, 32, 30, 21, 20, 21, 20, 21, 13, 9, 12, 9, 14, 4,
-2, 1, -1, 2, -6, -12, -11, -11, -11, -10, -17, -24, -20, -24, -20, -25, -34,
-31, -33, -29, -34, -41, -43, -42, -43, -44, -52, -53, -54, -52, -52, -48, -41,
-42, -42, -42, -40, -31, -32, -34, -31, -34, -19, -23, -20, -25, -19, -18, -3,
-30, -86, -69, -76, -62, -62, -65, -63, -67, -55, -53, -54, -53, -56, -48, -42,
-46, -40, -44, -39, -32, -32, -33, -31, -31, -23, -21, -22, -20, -21, -16, -8,
-12, -10, -13, -8, 1, 0, 1, 0, 1, 6, 13, 11, 12, 11, 14, 23, 22, 23, 21, 22, 32,
32, 32, 31, 30, 42, 43, 43, 41, 42, 50, 54, 53, 54, 53, 49, 43, 43, 42, 42, 41,
33, 30, 32, 34, 34, 27, 22, 23, 21, 21, 19, 13, 9, 12, 10, 10, 4, -2, 1, -2, 2,
-5, -14, -10, -13, -8, -13, -23, -19, -22, -19, -23, -32, -31, -32, -32, -32,
-40, -43, -43, -42, -42, -43, -54, -54, -53, -54, -54, -62, -62, -66, -62, -67,
-66, -83, -61, -14, -14, -11, -23, -21, -22, -22, -21, -30, -32, -32, -32, -31,
-39, -44, -40, -44, -40, -48, -53, -53, -53, -53, -50, -44, -42, -42, -41, -44,
-38, -31, -35, -32, -34, -29, -21, -22, -21, -21, -19, -13, -10, -12, -10, -10,
-5, 2, 0, 1, 0, 2, 12, 11, 12, 10, 11, 23, 21, 22, 21, 20, 30, 32, 32, 32, 31,
39, 43, 42, 43, 43, 43, 52, 54, 54, 54, 52, 61, 65, 63, 64, 64, 69, 75, 76, 76,
75, 77, 84, 87, 86, 88, 86, 93, 99, 96, 98, 95, 100, 110, 105, 107, 104, 109,
118, 117, 116, 119, 116, 107, 107, 107, 106, 107, 105, 95, 97, 96, 98, 95, 86,
86, 86, 85, 87, 74, 70, 34, 3, 12, 4, 1, -1, 1, -1, -1, -11, -12, -12, -12, -9,
-19, -23, -21, -21, -18, -28, -33, -31, -33, -34, -32, -40, -46, -41, -43, -41,
-50, -56, -52, -55, -52, -58, -65, -63, -65, -64, -67, -73, -74, -76, -75, -76,
-82, -86, -86, -87, -86, -90, -98, -97, -98, -96, -99, -109, -107, -105, -106,
-107, -112, -117, -118, -117, -118, -116, -106, -106, -106, -106, -108, -97,
-96, -97, -96, -98, -88, -85, -87, -86, -88, -79, -74, -75, -74, -75, -71, -65,
-65, -63, -63, -63, -56, -51, -54, -52, -54, -51, -43, -43, -42, -42, -42, -33,
-30, -31, -30, -31, -28, -19, -22, -21, -21, -17, -7, -10, -10, -11, -10, };