#define DATA_LENGTH 512
#define DATA AKWF_vgame_0129

const PROGMEM int8_t DATA[DATA_LENGTH] = {20, 27, 24, 25, 25, 25, 25, 26, 25,
25, 25, 25, 25, 25, 26, 25, 25, 25, 26, 26, 25, 25, 25, 25, 25, 25, 25, 26, 26,
25, 26, 26, 26, 25, 25, 25, 26, 25, 26, 25, 26, 25, 25, 26, 25, 25, 26, 25, 25,
25, 26, 25, 25, 25, 26, 24, 27, 24, 28, 21, 34, 73, 70, 72, 71, 71, 71, 71, 70,
71, 71, 71, 72, 70, 71, 71, 71, 71, 71, 71, 71, 71, 70, 71, 71, 70, 71, 71, 71,
71, 71, 70, 71, 71, 71, 71, 72, 71, 71, 71, 70, 71, 70, 71, 70, 71, 71, 71, 71,
72, 70, 70, 70, 71, 69, 71, 70, 71, 70, 71, 69, 72, 69, 73, 113, 118, 116, 117,
116, 117, 116, 117, 115, 116, 116, 116, 116, 117, 116, 117, 116, 116, 117, 116,
116, 117, 116, 116, 116, 116, 116, 116, 116, 115, 116, 117, 116, 116, 116, 117,
116, 116, 116, 116, 115, 115, 116, 116, 116, 115, 116, 116, 116, 115, 115, 116,
115, 115, 115, 116, 116, 115, 115, 116, 116, 116, 116, 116, 115, 116, 116, 116,
115, 116, 115, 116, 115, 116, 115, 115, 115, 115, 115, 115, 115, 115, 115, 115,
115, 116, 115, 115, 115, 115, 115, 117, 114, 116, 112, 119, 95, 65, 70, 68, 70,
69, 69, 69, 69, 70, 69, 69, 69, 68, 69, 69, 69, 69, 70, 69, 69, 70, 69, 69, 69,
69, 69, 69, 69, 69, 67, 70, 67, 71, 64, 82, 0, -84, -62, -71, -68, -69, -68,
-68, -68, -68, -69, -67, -70, -66, -73, -108, -116, -113, -116, -113, -116,
-114, -116, -113, -115, -114, -115, -114, -115, -114, -115, -114, -114, -114,
-114, -114, -115, -115, -114, -115, -114, -114, -114, -115, -115, -113, -115,
-114, -115, -114, -114, -115, -114, -115, -114, -114, -114, -114, -114, -114,
-114, -114, -114, -115, -114, -113, -114, -114, -113, -114, -113, -115, -114,
-114, -113, -115, -114, -113, -113, -114, -114, -114, -114, -114, -113, -113,
-114, -114, -114, -114, -113, -114, -114, -113, -113, -114, -113, -113, -113,
-114, -114, -114, -114, -113, -114, -113, -114, -113, -113, -113, -113, -113,
-114, -113, -113, -114, -114, -113, -113, -113, -113, -114, -112, -113, -113,
-114, -112, -114, -112, -117, -84, -61, -70, -65, -68, -66, -67, -67, -68, -67,
-67, -67, -67, -67, -67, -68, -67, -68, -67, -67, -67, -67, -67, -67, -66, -67,
-67, -67, -66, -67, -66, -67, -67, -68, -66, -67, -67, -67, -66, -67, -67, -66,
-67, -66, -67, -66, -67, -67, -67, -67, -66, -67, -67, -67, -66, -66, -66, -67,
-66, -67, -66, -69, -65, -72, -41, -15, -23, -18, -22, -20, -21, -20, -21, -20,
-21, -20, -21, -20, -20, -21, -21, -21, -21, -21, -21, -21, -20, -21, -21, -20,
-21, -21, -21, -20, -21, -20, -20, -21, -20, -21, -20, -21, -20, -21, -21, -20,
-21, -21, -20, -20, -21, -20, -20, -20, -21, -20, -20, -20, -21, -20, -21, -20,
-21, -20, -21, -19, };