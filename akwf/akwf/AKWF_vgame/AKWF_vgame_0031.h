#define DATA_LENGTH 512
#define DATA AKWF_vgame_0031

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 7, 7, 6, 6, 5, 17, 25, 22, 24,
20, 34, 43, 54, 57, 56, 57, 56, 57, 56, 57, 55, 62, 67, 66, 65, 70, 76, 75, 75,
76, 75, 79, 84, 81, 83, 82, 82, 83, 86, 90, 92, 91, 93, 91, 92, 92, 91, 92, 96,
94, 96, 95, 95, 97, 96, 96, 96, 97, 96, 99, 99, 98, 98, 99, 102, 101, 104, 106,
106, 107, 106, 106, 106, 105, 108, 115, 114, 115, 113, 115, 119, 119, 120, 119,
119, 118, 116, 116, 116, 116, 115, 104, 105, 98, 90, 92, 91, 92, 92, 92, 92, 90,
73, 67, 68, 67, 67, 68, 68, 67, 67, 67, 68, 63, 63, 63, 63, 62, 55, 55, 50, 47,
48, 46, 47, 46, 47, 47, 46, 32, 30, 32, 30, 31, 14, 10, 12, 12, 11, 1, -3, -1,
-3, -1, -2, -8, -10, -11, -12, -11, -11, -12, -12, -12, -11, -13, -15, -14, -15,
-15, -14, -19, -21, -21, -22, -20, -31, -36, -35, -36, -34, -45, -54, -49, -56,
-68, -68, -67, -67, -67, -68, -65, -76, -84, -81, -82, -81, -83, -82, -82, -82,
-82, -82, -83, -82, -81, -81, -82, -80, -78, -79, -78, -75, -75, -75, -75, -76,
-75, -76, -76, -75, -76, -76, -76, -74, -62, -57, -58, -58, -58, -58, -58, -58,
-57, -59, -51, -38, -41, -39, -19, -16, -18, -18, -17, -19, -15, -1, -2, -2, -1,
-2, 1, 15, 21, 19, 19, 19, 20, 19, 19, 20, 20, 25, 24, 25, 24, 26, 26, 26, 26,
25, 25, 25, 26, 26, 26, 26, 25, 27, 25, 23, 25, 24, 24, 24, 24, 24, 25, 24, 20,
20, 19, 20, 12, 9, 10, 9, 9, 10, 9, 0, 0, 0, 0, 0, -3, -3, -2, -1, -3, -2, -3,
-1, -2, -1, -2, -3, -4, -3, -3, -5, -7, -6, -6, -6, -6, -14, -19, -17, -18, -18,
-18, -27, -34, -41, -42, -41, -43, -41, -42, -42, -43, -43, -45, -44, -45, -44,
-46, -46, -47, -47, -47, -47, -50, -54, -52, -54, -52, -56, -59, -58, -59, -60,
-60, -60, -60, -60, -59, -59, -59, -58, -57, -58, -57, -59, -60, -59, -59, -59,
-59, -60, -61, -61, -61, -61, -60, -59, -60, -58, -58, -58, -57, -58, -58, -57,
-58, -58, -58, -57, -58, -58, -58, -55, -56, -56, -56, -57, -55, -54, -54, -54,
-55, -54, -54, -53, -49, -48, -48, -48, -48, -48, -47, -49, -46, -40, -41, -40,
-41, -37, -29, -29, -29, -29, -28, -25, -24, -24, -24, -25, -23, -19, -20, -19,
-18, -17, -18, -17, -16, -16, -16, -16, -17, -16, -16, -16, -16, -16, -15, -16,
-16, -15, -15, -16, -16, -16, -16, -17, -18, -17, -19, -21, -21, -20, -20, -21,
-21, -20, -22, -23, -23, -23, -22, -23, -24, -25, -25, -24, -24, -24, -24, -24,
-24, -24, -24, -24, -24, -25, -25, -24, -24, -25, -24, -25, -24, -23, -22, -23,
-22, -23, -17, -5, -3, -4, -4, -3, -3, -4, -3, -4, -4, };