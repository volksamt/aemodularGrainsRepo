#define DATA_LENGTH 512
#define DATA AKWF_vgame_0054

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 5, 6, 5, 7, 11, 14, 17, 16, 19,
20, 22, 22, 25, 25, 27, 30, 33, 35, 34, 38, 39, 43, 44, 45, 44, 45, 49, 51, 55,
54, 56, 55, 57, 61, 63, 67, 68, 68, 69, 72, 71, 74, 74, 75, 79, 81, 84, 83, 87,
90, 90, 89, 93, 94, 94, 96, 99, 100, 100, 103, 103, 105, 108, 110, 109, 110,
111, 111, 112, 113, 116, 116, 115, 116, 117, 117, 118, 118, 117, 118, 118, 116,
116, 116, 116, 115, 114, 114, 113, 112, 113, 113, 112, 111, 111, 111, 111, 110,
109, 108, 108, 108, 109, 107, 106, 106, 106, 105, 105, 104, 103, 101, 102, 102,
101, 101, 100, 99, 98, 98, 98, 97, 97, 96, 95, 95, 94, 94, 93, 92, 90, 91, 90,
90, 89, 87, 87, 87, 87, 86, 85, 86, 84, 85, 83, 83, 80, 81, 81, 79, 79, 77, 78,
77, 76, 76, 75, 73, 71, 72, 72, 72, 71, 70, 68, 68, 68, 66, 65, 64, 65, 63, 61,
62, 62, 61, 60, 60, 58, 59, 57, 56, 56, 55, 55, 53, 53, 53, 52, 51, 52, 50, 49,
47, 46, 45, 45, 45, 42, 42, 41, 42, 40, 40, 38, 38, 37, 36, 37, 36, 35, 32, 32,
32, 32, 29, 29, 29, 26, 26, 25, 26, 24, 24, 23, 22, 21, 21, 21, 17, 18, 17, 16,
15, 14, 14, 12, 13, 11, 11, 8, 8, 8, 8, 7, 4, 5, 4, 4, 2, 2, 0, 0, -1, -2, -2,
-3, -4, -7, -7, -7, -8, -8, -9, -11, -11, -11, -13, -13, -16, -15, -15, -16,
-16, -19, -19, -21, -20, -22, -23, -24, -25, -26, -25, -26, -27, -28, -30, -30,
-31, -32, -31, -33, -33, -35, -37, -36, -37, -38, -38, -39, -40, -40, -43, -43,
-45, -44, -45, -47, -47, -47, -48, -49, -49, -50, -51, -52, -53, -53, -54, -53,
-56, -59, -58, -58, -59, -59, -60, -62, -62, -63, -64, -66, -65, -67, -66, -67,
-66, -67, -69, -71, -72, -71, -72, -74, -74, -74, -74, -74, -77, -78, -78, -79,
-79, -80, -79, -80, -81, -82, -85, -83, -84, -84, -86, -85, -87, -88, -87, -89,
-90, -90, -91, -92, -93, -92, -93, -95, -96, -95, -96, -96, -97, -96, -97, -98,
-99, -100, -101, -102, -102, -102, -101, -103, -103, -104, -105, -105, -107,
-107, -106, -107, -108, -108, -109, -109, -110, -112, -111, -111, -112, -113,
-113, -113, -112, -113, -114, -115, -116, -116, -116, -115, -116, -117, -117,
-118, -118, -119, -119, -118, -119, -119, -118, -117, -118, -116, -117, -115,
-114, -115, -113, -111, -109, -109, -109, -105, -103, -103, -104, -100, -100,
-99, -96, -95, -93, -93, -91, -91, -87, -83, -82, -83, -82, -79, -76, -75, -74,
-73, -73, -70, -67, -65, -62, -61, -60, -59, -56, -58, -54, -54, -52, -49, -46,
-44, -44, -41, -39, -37, -38, -34, -33, -33, -30, -27, -25, -26, -24, -25, -22,
-19, -15, -15, -14, -10, -12, -9, -7, -4, -3, -2, 0, };