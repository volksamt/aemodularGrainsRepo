#define DATA_LENGTH 512
#define DATA AKWF_vgame_0083

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 24, 44, 61, 74, 88, 99, 104, 112,
117, 116, 114, 109, 106, 102, 99, 96, 95, 96, 96, 97, 101, 105, 106, 105, 107,
103, 100, 100, 101, 100, 100, 100, 100, 99, 102, 105, 107, 104, 101, 100, 100,
100, 101, 99, 100, 100, 100, 101, 99, 100, 100, 100, 100, 100, 101, 100, 101,
100, 100, 100, 100, 100, 99, 99, 100, 100, 100, 100, 100, 100, 100, 101, 100,
99, 100, 100, 99, 100, 100, 99, 100, 101, 100, 99, 100, 99, 100, 100, 100, 99,
100, 100, 99, 101, 104, 105, 105, 104, 102, 100, 99, 99, 99, 99, 99, 99, 99,
102, 105, 105, 105, 104, 101, 97, 94, 91, 88, 89, 91, 97, 103, 112, 117, 119,
118, 111, 101, 87, 73, 55, 39, 21, 1, -14, -27, -41, -49, -53, -53, -51, -47,
-44, -37, -32, -28, -24, -23, -27, -30, -33, -36, -40, -43, -44, -41, -38, -34,
-31, -33, -32, -33, -32, -36, -38, -38, -38, -38, -38, -38, -37, -32, -32, -33,
-33, -33, -33, -37, -39, -38, -37, -37, -39, -38, -36, -32, -32, -32, -33, -32,
-34, -38, -38, -38, -37, -38, -36, -32, -32, -33, -32, -32, -32, -33, -36, -39,
-38, -37, -38, -37, -38, -36, -33, -33, -33, -33, -32, -32, -32, -32, -33, -37,
-38, -37, -38, -39, -37, -33, -32, -32, -32, -32, -32, -32, -33, -32, -32, -32,
-32, -33, -32, -33, -32, -35, -37, -37, -37, -37, -38, -36, -32, -32, -32, -32,
-32, -32, -32, -32, -34, -37, -39, -37, -38, -38, -38, -38, -34, -32, -32, -32,
-32, -33, -32, -32, -32, -34, -37, -37, -38, -37, -34, -31, -32, -33, -32, -32,
-32, -33, -33, -32, -33, -32, -32, -33, -32, -32, -32, -31, -32, -32, -32, -33,
-32, -32, -32, -32, -32, -32, -32, -32, -33, -31, -32, -32, -31, -33, -32, -32,
-36, -38, -37, -38, -38, -38, -38, -36, -32, -32, -32, -32, -32, -32, -32, -31,
-33, -37, -37, -37, -37, -37, -36, -33, -32, -32, -32, -32, -32, -33, -32, -32,
-32, -34, -38, -37, -36, -37, -38, -35, -32, -31, -32, -32, -31, -32, -32, -32,
-31, -32, -31, -34, -36, -38, -37, -37, -34, -31, -32, -33, -32, -32, -33, -33,
-32, -31, -32, -36, -37, -37, -36, -37, -38, -38, -35, -32, -32, -31, -32, -31,
-32, -31, -32, -31, -32, -35, -37, -37, -33, -31, -31, -31, -32, -32, -32, -32,
-31, -32, -31, -32, -35, -38, -36, -38, -36, -32, -31, -32, -32, -32, -31, -32,
-32, -32, -32, -31, -32, -36, -37, -36, -36, -37, -37, -33, -31, -31, -31, -32,
-31, -31, -33, -36, -38, -37, -36, -36, -37, -36, -34, -31, -31, -31, -32, -31,
-34, -37, -37, -37, -36, -36, -37, -36, -32, -30, -32, -32, -32, -31, -36, -37,
-36, -36, -36, -37, -37, -34, -31, -31, -31, -32, -36, -36, -36, -40, -41, -37,
-37, -35, -32, -27, -26, -25, -29, -32, -36, -42, -48, -50, -52, -50, -43, -32,
-18, -5, };