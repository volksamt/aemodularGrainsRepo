#define DATA_LENGTH 512
#define DATA AKWF_vgame_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 8, 11, 13, 17, 22, 25, 24, 26,
31, 34, 34, 38, 43, 46, 45, 49, 50, 55, 61, 61, 62, 63, 66, 69, 70, 73, 75, 76,
76, 80, 81, 84, 86, 86, 87, 88, 90, 92, 93, 94, 96, 96, 97, 99, 99, 102, 103,
103, 105, 108, 109, 109, 111, 113, 113, 114, 114, 113, 114, 115, 114, 114, 113,
112, 113, 113, 113, 113, 112, 113, 113, 112, 114, 113, 112, 114, 112, 111, 111,
110, 106, 104, 104, 102, 102, 100, 99, 98, 97, 97, 94, 92, 90, 88, 83, 82, 82,
78, 76, 74, 70, 69, 68, 66, 65, 63, 59, 58, 56, 53, 52, 50, 49, 43, 42, 40, 39,
38, 36, 32, 30, 29, 28, 26, 24, 23, 21, 16, 14, 13, 11, 10, 7, 4, 3, 4, 3, 0, 0,
0, -1, -2, -4, -5, -5, -7, -7, -11, -11, -11, -12, -14, -13, -13, -13, -13, -12,
-11, -11, -11, -12, -11, -11, -11, -13, -13, -13, -14, -15, -14, -15, -14, -15,
-15, -14, -13, -14, -14, -13, -12, -12, -12, -15, -14, -13, -13, -13, -11, -10,
-9, -10, -8, -7, -6, -4, -3, -2, -2, -1, -1, 0, 2, 3, 4, 5, 7, 6, 9, 11, 11, 11,
14, 15, 16, 18, 20, 21, 22, 23, 26, 26, 29, 31, 31, 32, 33, 36, 37, 38, 39, 41,
41, 42, 43, 45, 46, 46, 47, 48, 50, 50, 51, 52, 53, 53, 54, 54, 54, 54, 54, 55,
54, 54, 53, 53, 52, 52, 52, 53, 51, 50, 52, 49, 49, 50, 48, 47, 47, 46, 46, 45,
44, 44, 43, 43, 41, 40, 39, 40, 38, 37, 36, 36, 34, 34, 32, 32, 31, 30, 28, 27,
27, 27, 26, 24, 23, 23, 22, 21, 23, 21, 21, 21, 20, 21, 21, 20, 20, 19, 18, 18,
18, 17, 16, 14, 14, 12, 12, 12, 11, 11, 12, 11, 9, 9, 9, 9, 7, 6, 5, 4, 4, 3, 3,
2, 1, -2, -3, -4, -3, -4, -6, -6, -8, -11, -11, -13, -14, -15, -17, -19, -20,
-20, -21, -22, -23, -24, -27, -29, -28, -29, -29, -31, -34, -35, -34, -35, -37,
-39, -40, -40, -43, -43, -44, -45, -46, -48, -50, -52, -52, -53, -55, -57, -59,
-60, -63, -64, -63, -65, -65, -66, -69, -70, -70, -71, -71, -75, -75, -77, -79,
-79, -81, -83, -85, -87, -90, -91, -90, -92, -93, -96, -98, -98, -99, -102,
-103, -103, -105, -107, -108, -109, -108, -110, -111, -113, -113, -113, -113,
-113, -114, -114, -116, -117, -117, -118, -117, -117, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -117, -117, -117, -117, -117, -115, -114, -114,
-113, -112, -112, -111, -109, -107, -104, -105, -104, -101, -100, -98, -97, -98,
-95, -94, -92, -90, -89, -85, -83, -84, -81, -80, -78, -74, -74, -73, -71, -70,
-67, -65, -62, -58, -59, -58, -55, -53, -49, -46, -44, -42, -39, -36, -33, -30,
-24, -20, -22, -18, -16, -12, -7, -5, -4, -1, };