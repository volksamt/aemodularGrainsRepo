#define DATA_LENGTH 512
#define DATA AKWF_vgame_0056

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 7, 7, 9, 11, 13, 13, 15, 17,
19, 21, 24, 26, 26, 27, 28, 31, 34, 35, 36, 39, 40, 40, 41, 44, 47, 48, 50, 51,
52, 55, 56, 57, 59, 61, 63, 65, 66, 70, 72, 72, 73, 74, 76, 79, 82, 82, 84, 84,
85, 87, 90, 92, 93, 93, 95, 97, 98, 102, 102, 104, 104, 106, 107, 108, 110, 111,
111, 111, 112, 113, 114, 116, 115, 116, 118, 117, 117, 117, 117, 118, 116, 115,
116, 115, 115, 114, 114, 114, 113, 113, 113, 112, 112, 111, 111, 110, 110, 109,
108, 108, 108, 108, 108, 106, 105, 104, 105, 104, 104, 104, 103, 102, 102, 103,
102, 100, 99, 98, 99, 98, 99, 97, 97, 95, 94, 94, 94, 94, 94, 92, 91, 90, 90,
89, 89, 89, 87, 87, 86, 86, 85, 84, 84, 85, 82, 81, 81, 81, 79, 79, 78, 78, 77,
76, 76, 76, 75, 75, 72, 72, 71, 71, 70, 69, 68, 68, 67, 66, 65, 65, 66, 63, 62,
62, 62, 61, 60, 59, 58, 57, 57, 56, 56, 54, 54, 53, 53, 51, 51, 50, 49, 49, 47,
45, 46, 45, 44, 44, 43, 41, 41, 42, 41, 40, 39, 37, 37, 36, 36, 35, 34, 33, 31,
30, 30, 30, 29, 29, 27, 24, 26, 26, 24, 24, 22, 21, 20, 19, 19, 19, 17, 17, 16,
15, 15, 13, 13, 13, 12, 11, 8, 8, 9, 8, 6, 6, 3, 1, 1, 2, 2, 1, 0, -1, -4, -3,
-4, -4, -5, -6, -9, -9, -9, -10, -9, -11, -11, -14, -15, -16, -16, -15, -16,
-19, -21, -20, -21, -23, -22, -22, -24, -26, -26, -27, -27, -27, -28, -30, -32,
-31, -33, -33, -34, -34, -35, -36, -37, -38, -37, -39, -40, -42, -43, -43, -43,
-43, -45, -46, -46, -47, -48, -47, -50, -50, -52, -53, -53, -53, -55, -54, -56,
-58, -58, -57, -60, -59, -60, -62, -63, -64, -63, -65, -65, -65, -67, -67, -66,
-68, -68, -70, -70, -72, -73, -73, -73, -75, -74, -75, -76, -77, -79, -77, -78,
-79, -80, -81, -82, -82, -83, -84, -84, -86, -86, -86, -86, -87, -88, -89, -89,
-91, -90, -91, -91, -92, -94, -94, -95, -96, -94, -96, -96, -97, -98, -100,
-100, -101, -100, -100, -101, -102, -103, -104, -103, -104, -105, -105, -107,
-107, -105, -107, -108, -108, -110, -109, -109, -110, -112, -112, -113, -113,
-113, -112, -112, -114, -114, -115, -116, -116, -116, -116, -116, -117, -117,
-118, -119, -119, -119, -119, -119, -119, -119, -117, -118, -117, -116, -115,
-114, -112, -111, -111, -110, -109, -108, -105, -105, -106, -103, -100, -100,
-96, -96, -94, -93, -93, -90, -89, -86, -85, -85, -84, -82, -80, -75, -74, -74,
-72, -73, -70, -68, -66, -62, -62, -61, -59, -57, -56, -53, -53, -50, -47, -48,
-45, -43, -41, -39, -40, -38, -36, -35, -31, -28, -27, -24, -24, -24, -21, -19,
-17, -17, -15, -13, -11, -10, -6, -6, -4, -1, -2, 0, };