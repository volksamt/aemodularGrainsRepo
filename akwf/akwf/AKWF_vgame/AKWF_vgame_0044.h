#define DATA_LENGTH 512
#define DATA AKWF_vgame_0044

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 6, 7, 16, 18, 17, 18, 17, 18, 18,
18, 18, 18, 17, 25, 29, 30, 42, 40, 42, 40, 41, 42, 42, 41, 42, 42, 42, 54, 53,
59, 66, 64, 65, 65, 65, 65, 66, 65, 64, 66, 63, 70, 79, 85, 90, 87, 89, 89, 89,
89, 89, 89, 89, 88, 90, 88, 97, 109, 109, 110, 109, 109, 109, 110, 109, 110,
109, 110, 108, 110, 116, 118, 117, 117, 118, 117, 118, 117, 118, 117, 117, 117,
117, 117, 116, 114, 115, 114, 115, 114, 115, 112, 111, 111, 112, 110, 111, 111,
109, 108, 109, 108, 108, 108, 108, 108, 105, 105, 105, 105, 105, 104, 102, 102,
102, 101, 102, 102, 101, 102, 100, 96, 97, 96, 97, 96, 91, 92, 92, 91, 92, 93,
92, 92, 90, 89, 89, 89, 90, 86, 83, 84, 84, 85, 84, 84, 84, 85, 83, 80, 80, 79,
79, 76, 74, 74, 74, 74, 74, 75, 74, 74, 74, 72, 68, 70, 69, 63, 63, 63, 63, 63,
64, 64, 63, 63, 64, 60, 58, 60, 57, 53, 54, 54, 54, 54, 54, 54, 54, 55, 55, 53,
47, 48, 45, 42, 43, 43, 43, 43, 44, 43, 43, 44, 43, 44, 39, 36, 33, 31, 32, 31,
32, 32, 33, 31, 32, 31, 31, 32, 27, 24, 21, 20, 21, 21, 21, 20, 22, 19, 14, 15,
14, 14, 15, 12, 8, 7, 8, 8, 8, 8, 8, 7, 8, 8, 7, 8, 9, 5, 1, 2, 2, 2, 1, 1, -2,
-3, -2, -3, -3, -3, -3, -8, -10, -9, -10, -9, -10, -9, -11, -16, -16, -15, -16,
-15, -17, -22, -23, -22, -22, -22, -23, -22, -25, -27, -28, -27, -28, -27, -30,
-34, -33, -33, -34, -34, -33, -33, -33, -37, -38, -38, -39, -37, -42, -45, -44,
-45, -44, -45, -44, -45, -44, -45, -50, -50, -49, -49, -55, -56, -55, -56, -55,
-55, -55, -56, -54, -58, -61, -60, -60, -61, -65, -66, -65, -66, -64, -66, -65,
-66, -66, -64, -70, -72, -70, -73, -77, -76, -76, -76, -77, -76, -76, -75, -77,
-75, -78, -81, -80, -84, -85, -86, -86, -86, -86, -85, -87, -86, -85, -85, -89,
-91, -90, -94, -93, -93, -93, -94, -94, -93, -93, -94, -94, -93, -94, -98, -100,
-103, -103, -103, -104, -104, -103, -104, -104, -103, -103, -103, -104, -106,
-108, -109, -109, -110, -110, -109, -110, -110, -109, -110, -110, -109, -109,
-111, -116, -116, -115, -116, -116, -116, -116, -116, -116, -116, -116, -116,
-115, -116, -118, -119, -119, -118, -119, -119, -119, -117, -117, -117, -117,
-117, -118, -115, -110, -111, -112, -111, -111, -111, -113, -107, -100, -101,
-101, -101, -103, -96, -88, -91, -90, -92, -89, -91, -90, -81, -78, -80, -79,
-79, -80, -71, -68, -69, -68, -68, -69, -68, -70, -65, -54, -56, -55, -56, -54,
-43, -42, -43, -44, -43, -43, -43, -43, -44, -36, -31, -32, -32, -27, -18, -20,
-18, -19, -18, -19, -18, -19, -19, -10, -7, -8, -8, -2, };