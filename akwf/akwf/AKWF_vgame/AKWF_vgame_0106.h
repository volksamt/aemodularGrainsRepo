#define DATA_LENGTH 512
#define DATA AKWF_vgame_0106

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 16, 13, 15, 12, 23, 35, 49, 57, 53,
57, 53, 56, 53, 57, 70, 72, 71, 71, 71, 88, 103, 103, 102, 102, 102, 102, 103,
101, 107, 109, 110, 109, 111, 118, 119, 119, 119, 119, 119, 118, 119, 118, 119,
119, 119, 119, 120, 115, 114, 115, 114, 114, 111, 109, 109, 110, 106, 98, 99,
100, 99, 91, 89, 90, 90, 90, 80, 77, 78, 77, 78, 71, 67, 69, 65, 58, 59, 59, 58,
60, 56, 49, 50, 49, 49, 49, 42, 42, 37, 34, 36, 35, 35, 35, 35, 33, 31, 32, 32,
32, 31, 30, 32, 33, 31, 33, 32, 33, 32, 32, 34, 35, 34, 35, 39, 41, 44, 45, 44,
44, 44, 52, 51, 52, 51, 51, 50, 51, 52, 60, 63, 63, 63, 62, 63, 63, 62, 63, 66,
65, 65, 66, 66, 69, 71, 71, 70, 70, 71, 70, 70, 71, 69, 67, 68, 68, 67, 63, 63,
63, 63, 62, 56, 56, 55, 56, 55, 49, 47, 50, 43, 35, 37, 36, 36, 38, 32, 23, 26,
24, 26, 20, 8, 12, -4, -7, -5, -7, -6, -7, -6, -17, -18, -19, -16, -28, -33,
-33, -45, -44, -45, -44, -46, -43, -48, -57, -56, -57, -56, -58, -63, -65, -69,
-68, -68, -68, -67, -68, -69, -70, -71, -71, -70, -71, -70, -64, -63, -63, -64,
-63, -64, -63, -64, -63, -55, -57, -56, -57, -57, -47, -46, -46, -48, -36, -31,
-33, -32, -35, -24, -20, -20, -22, -16, -3, -5, -3, -6, -2, 10, 10, 11, 9, 12,
26, 28, 25, 37, 43, 40, 42, 41, 40, 47, 52, 51, 50, 54, 61, 60, 62, 66, 68, 68,
68, 67, 67, 70, 70, 69, 70, 71, 70, 71, 69, 64, 65, 65, 65, 66, 65, 63, 57, 58,
57, 59, 56, 49, 42, 36, 38, 37, 37, 37, 36, 37, 28, 24, 26, 24, 26, 15, -4, -6,
-6, -6, -6, -6, -7, -6, -9, -19, -18, -18, -19, -34, -45, -44, -45, -44, -45,
-44, -45, -44, -44, -51, -56, -53, -54, -58, -66, -63, -65, -62, -65, -68, -67,
-68, -69, -70, -71, -71, -70, -71, -70, -71, -71, -72, -68, -68, -68, -68, -68,
-67, -66, -66, -65, -59, -59, -59, -58, -59, -58, -55, -53, -54, -54, -53, -47,
-46, -45, -42, -43, -42, -42, -42, -42, -40, -36, -38, -36, -37, -34, -32, -33,
-32, -32, -32, -32, -33, -32, -32, -32, -32, -32, -31, -34, -34, -39, -40, -39,
-39, -39, -40, -39, -39, -42, -48, -46, -46, -48, -59, -64, -63, -63, -63, -63,
-62, -63, -62, -72, -77, -74, -76, -73, -81, -85, -85, -84, -88, -98, -95, -98,
-96, -98, -103, -104, -103, -103, -110, -111, -110, -111, -110, -115, -115,
-116, -116, -115, -117, -117, -118, -117, -116, -115, -115, -116, -115, -114,
-109, -111, -111, -110, -110, -102, -105, -96, -88, -89, -88, -89, -87, -90,
-79, -77, -75, -80, -68, -57, -58, -44, -40, -42, -40, -42, -39, -44, -36, -18,
-16, -18, -17, };