#define DATA_LENGTH 512
#define DATA AKWF_vgame_0117

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 6, 10, 11, 10, 12, 14, 16, 18,
19, 21, 23, 25, 27, 28, 29, 31, 33, 34, 37, 36, 39, 40, 42, 45, 47, 48, 48, 51,
52, 56, 56, 57, 58, 60, 64, 65, 65, 67, 68, 70, 72, 74, 74, 77, 78, 82, 83, 83,
85, 86, 89, 90, 93, 93, 95, 95, 101, 100, 104, 100, 112, 78, 10, 21, 19, 23, 25,
25, 27, 28, 32, 32, 33, 35, 37, 40, 41, 43, 45, 45, 47, 47, 50, 50, 54, 55, 56,
58, 62, 62, 63, 64, 67, 68, 69, 70, 73, 76, 78, 79, 81, 81, 82, 85, 85, 87, 88,
92, 91, 95, 96, 101, 97, 102, 101, 105, 104, 109, 106, 112, 110, 117, 115, 119,
98, -64, -76, -61, -69, -60, -64, -55, -60, -55, -58, -52, -54, -49, -48, -45,
-48, -42, -41, -39, -40, -37, -35, -34, -31, -30, -28, -28, -25, -22, -21, -22,
-19, -18, -15, -14, -12, -11, -9, -7, -5, -4, -3, -2, 0, 2, 4, 5, 7, 9, 11, 14,
16, 16, 17, 19, 23, 21, 25, 23, 29, 27, 34, 31, 38, 22, -56, -53, -50, -50, -47,
-46, -41, -43, -39, -40, -36, -37, -34, -33, -30, -31, -27, -25, -23, -23, -21,
-20, -18, -16, -14, -12, -11, -9, -6, -6, -3, -1, -1, 1, 2, 4, 5, 7, 9, 13, 12,
14, 14, 17, 19, 21, 22, 25, 24, 27, 29, 32, 30, 35, 34, 38, 36, 42, 43, 43, 43,
47, 51, -40, -54, -43, -48, -40, -43, -38, -39, -32, -35, -32, -33, -29, -30,
-26, -26, -22, -23, -19, -17, -15, -15, -14, -11, -11, -8, -7, -5, -3, -2, 2, 2,
3, 5, 6, 8, 11, 11, 13, 15, 16, 20, 20, 22, 22, 25, 25, 28, 28, 32, 32, 35, 37,
39, 39, 41, 43, 44, 46, 47, 51, 46, 61, -8, -42, -29, -35, -27, -31, -25, -26,
-23, -22, -18, -19, -17, -15, -11, -13, -11, -10, -7, -7, -3, 0, -1, 1, 2, 4, 5,
8, 9, 11, 12, 14, 17, 17, 18, 21, 23, 24, 25, 27, 29, 32, 33, 36, 36, 37, 38,
41, 41, 45, 43, 48, 47, 51, 53, 57, 53, 58, 56, 62, 60, 64, 65, 64, 82, -74,
-125, -110, -120, -109, -115, -107, -112, -104, -107, -101, -103, -99, -100,
-96, -97, -94, -90, -89, -90, -85, -83, -83, -81, -81, -78, -78, -75, -74, -72,
-72, -68, -66, -64, -64, -63, -60, -59, -58, -56, -54, -54, -50, -48, -47, -46,
-44, -43, -41, -40, -38, -37, -34, -33, -29, -29, -28, -27, -21, -22, -21, -19,
-20, -9, -78, -110, -98, -103, -98, -98, -95, -95, -92, -92, -89, -87, -84, -83,
-82, -81, -79, -77, -76, -74, -73, -69, -68, -66, -67, -64, -62, -61, -59, -57,
-55, -55, -52, -49, -49, -46, -45, -44, -43, -41, -40, -38, -36, -34, -31, -31,
-29, -28, -26, -25, -23, -22, -19, -19, -16, -13, -13, -12, -10, -8, -6, -5, -2,
0, 0, };