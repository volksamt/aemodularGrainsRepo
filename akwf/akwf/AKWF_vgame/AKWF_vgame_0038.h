#define DATA_LENGTH 512
#define DATA AKWF_vgame_0038

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 5, 12, 15, 20, 18, 24, 26,
27, 31, 36, 43, 40, 46, 48, 55, 58, 59, 57, 59, 63, 65, 68, 67, 71, 71, 74, 74,
76, 80, 80, 80, 81, 82, 82, 83, 83, 85, 85, 86, 89, 88, 90, 92, 91, 91, 93, 93,
93, 95, 96, 97, 97, 96, 96, 97, 98, 99, 98, 98, 98, 99, 100, 99, 99, 100, 100,
103, 104, 105, 106, 107, 105, 109, 111, 112, 114, 114, 116, 117, 119, 118, 119,
119, 120, 119, 117, 115, 116, 112, 110, 106, 107, 104, 102, 102, 97, 94, 89, 90,
86, 85, 84, 79, 75, 72, 72, 71, 70, 66, 68, 66, 66, 66, 63, 62, 59, 59, 57, 56,
56, 55, 51, 49, 50, 47, 44, 39, 40, 34, 35, 31, 24, 20, 15, 16, 11, 12, 8, 5, 0,
-2, -2, -4, -6, -8, -7, -10, -9, -10, -12, -11, -11, -11, -11, -11, -13, -13,
-15, -14, -16, -18, -20, -23, -22, -27, -32, -33, -32, -38, -40, -42, -45, -49,
-53, -53, -60, -59, -62, -72, -76, -76, -77, -79, -79, -82, -84, -83, -84, -84,
-83, -82, -82, -82, -82, -83, -82, -82, -81, -80, -80, -79, -79, -77, -77, -76,
-75, -76, -75, -75, -75, -76, -75, -76, -74, -72, -70, -70, -69, -66, -62, -59,
-60, -53, -56, -51, -47, -39, -36, -36, -30, -31, -24, -20, -14, -13, -11, -5,
-3, 1, -1, 5, 4, 8, 11, 14, 16, 16, 19, 17, 20, 22, 24, 24, 24, 24, 25, 25, 25,
25, 25, 26, 25, 26, 26, 26, 25, 26, 26, 26, 26, 26, 26, 26, 24, 24, 24, 24, 24,
22, 20, 19, 20, 18, 15, 13, 10, 12, 6, 1, 2, 1, -1, -1, -2, -3, -3, -3, -3, -4,
-4, -3, -1, -2, -2, -2, -1, -2, -3, -3, -3, -3, -4, -4, -5, -8, -13, -13, -12,
-16, -18, -23, -24, -26, -27, -27, -32, -35, -40, -40, -42, -42, -42, -43, -44,
-45, -45, -47, -46, -47, -46, -47, -46, -49, -49, -50, -54, -53, -54, -55, -57,
-59, -58, -60, -59, -60, -60, -59, -59, -60, -59, -59, -57, -58, -60, -59, -60,
-59, -60, -60, -60, -62, -62, -60, -61, -62, -60, -61, -59, -60, -59, -60, -60,
-60, -59, -58, -58, -58, -58, -58, -58, -58, -57, -56, -56, -56, -56, -56, -55,
-56, -54, -54, -54, -54, -53, -54, -53, -53, -53, -52, -50, -47, -47, -47, -46,
-41, -42, -40, -39, -38, -34, -33, -29, -30, -28, -24, -24, -24, -23, -23, -23,
-21, -20, -19, -20, -18, -18, -17, -18, -17, -16, -17, -16, -16, -16, -16, -16,
-16, -16, -16, -16, -16, -16, -16, -17, -16, -16, -16, -18, -18, -18, -17, -19,
-19, -20, -21, -22, -23, -22, -23, -23, -23, -23, -23, -23, -23, -22, -23, -23,
-22, -22, -22, -24, -25, -24, -23, -24, -24, -24, -24, -25, -24, -25, -24, -24,
-23, -22, -21, -21, -22, -20, -20, -18, -16, -14, -10, -11, -8, -9, -4, };