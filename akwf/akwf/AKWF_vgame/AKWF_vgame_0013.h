#define DATA_LENGTH 512
#define DATA AKWF_vgame_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 23, 20, 21, 21, 20, 21, 21, 21, 21,
21, 20, 19, 32, 55, 58, 57, 57, 57, 58, 57, 57, 57, 57, 57, 56, 59, 78, 85, 84,
84, 84, 85, 84, 84, 84, 84, 85, 85, 83, 90, 101, 102, 101, 102, 101, 102, 101,
102, 102, 102, 101, 102, 109, 110, 114, 114, 114, 114, 114, 115, 114, 114, 114,
114, 114, 114, 112, 114, 114, 115, 114, 115, 115, 115, 115, 114, 115, 115, 114,
113, 109, 101, 102, 102, 102, 102, 102, 101, 101, 102, 102, 99, 90, 91, 81, 74,
77, 75, 77, 76, 77, 76, 78, 71, 62, 63, 65, 61, 49, 49, 49, 49, 50, 49, 50, 49,
48, 50, 47, 34, 36, 27, 22, 23, 21, 22, 22, 23, 22, 22, 22, 24, 12, 7, 7, 0, 0,
0, 0, 1, 0, 0, 0, 0, 0, -7, -9, -7, -11, -14, -13, -13, -13, -14, -12, -12, -12,
-13, -12, -10, -11, -10, -13, -13, -13, -13, -12, -13, -12, -13, -13, -12, -14,
-15, -14, -14, -12, -12, -12, -12, -12, -13, -13, -13, -13, -12, -13, -12, -12,
-7, -6, -6, -6, -7, -6, -6, -6, -7, -3, -1, -2, -2, 1, 7, 6, 7, 6, 7, 7, 7, 6,
8, 16, 16, 16, 15, 25, 26, 25, 26, 25, 25, 26, 25, 25, 32, 36, 35, 34, 38, 45,
43, 42, 42, 44, 43, 43, 43, 43, 49, 49, 49, 49, 54, 55, 54, 54, 54, 54, 53, 54,
54, 53, 54, 54, 54, 54, 50, 52, 51, 51, 51, 50, 51, 51, 48, 47, 48, 47, 49, 44,
42, 43, 42, 42, 43, 43, 43, 42, 37, 38, 38, 39, 37, 30, 30, 30, 30, 31, 30, 30,
27, 25, 26, 25, 25, 25, 24, 22, 22, 22, 23, 23, 22, 22, 21, 21, 20, 21, 21, 20,
17, 16, 16, 15, 17, 16, 17, 13, 10, 12, 11, 11, 11, 10, 8, 9, 8, 8, 8, 8, 7, 2,
2, 2, 1, 1, 1, -5, -4, -5, -4, -5, -4, -7, -13, -12, -13, -13, -14, -11, -18,
-23, -21, -23, -22, -22, -21, -28, -29, -29, -29, -29, -29, -29, -36, -36, -37,
-37, -36, -36, -38, -45, -44, -45, -44, -45, -43, -48, -55, -53, -54, -53, -54,
-54, -61, -64, -63, -64, -64, -63, -69, -80, -80, -79, -80, -79, -79, -80, -79,
-80, -80, -79, -79, -82, -95, -100, -99, -100, -100, -100, -100, -100, -100,
-100, -100, -100, -100, -106, -113, -113, -113, -113, -113, -112, -113, -113,
-112, -113, -113, -113, -113, -118, -120, -119, -119, -119, -119, -118, -120,
-119, -119, -119, -120, -118, -118, -115, -114, -115, -115, -115, -114, -115,
-114, -115, -114, -115, -113, -109, -104, -96, -98, -97, -96, -97, -96, -97,
-96, -97, -96, -98, -92, -85, -77, -72, -75, -72, -74, -73, -74, -72, -73, -73,
-74, -73, -63, -57, -41, -43, -42, -43, -43, -42, -43, -42, -43, -43, -40, -24,
-27, -14, -4, -7, -6, -7, -6, -7, -6, -6, -6, -7, };