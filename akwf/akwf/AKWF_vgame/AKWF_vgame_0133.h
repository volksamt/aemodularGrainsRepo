#define DATA_LENGTH 512
#define DATA AKWF_vgame_0133

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 25, 22, 22, 22, 23, 22, 22, 23, 22,
23, 22, 23, 22, 23, 23, 23, 23, 23, 22, 22, 22, 22, 23, 22, 22, 23, 23, 22, 22,
22, 23, 23, 22, 22, 22, 22, 22, 22, 23, 23, 22, 23, 22, 23, 22, 22, 22, 23, 23,
23, 21, 23, 23, 22, 22, 23, 22, 23, 23, 22, 22, 23, 22, 22, 22, 22, 22, 21, 24,
20, 25, 17, 43, 71, 63, 67, 65, 67, 65, 67, 65, 66, 66, 67, 65, 66, 66, 65, 66,
65, 66, 66, 65, 65, 66, 65, 66, 66, 66, 66, 66, 65, 66, 66, 66, 65, 66, 66, 65,
65, 67, 65, 65, 65, 66, 65, 66, 65, 66, 65, 66, 66, 66, 66, 66, 66, 66, 66, 65,
65, 65, 66, 66, 66, 65, 66, 65, 66, 65, 66, 65, 66, 65, 69, 108, 110, 108, 110,
108, 110, 108, 109, 108, 109, 109, 110, 109, 110, 109, 109, 108, 109, 109, 109,
109, 109, 108, 109, 109, 108, 109, 109, 109, 109, 108, 109, 109, 109, 108, 109,
109, 109, 108, 109, 109, 108, 109, 108, 109, 108, 110, 106, 111, 105, 112, 103,
125, 27, -86, -58, -70, -64, -68, -65, -66, -67, -66, -67, -66, -67, -66, -67,
-65, -67, -66, -67, -66, -67, -65, -67, -66, -66, -65, -67, -66, -67, -66, -67,
-67, -66, -67, -66, -65, -66, -66, -67, -66, -67, -67, -66, -65, -67, -66, -67,
-65, -28, -19, -23, -22, -24, -22, -23, -22, -23, -23, -23, -21, -23, -23, -23,
-23, -22, -22, -23, -22, -22, -23, -22, -23, -23, -23, -22, -22, -23, -22, -22,
-22, -22, -22, -22, -22, -22, -23, -22, -22, -22, -22, -22, -22, -22, -22, -22,
-22, -22, -22, -22, -22, -23, -21, -23, -23, -22, -22, -24, -22, -22, -22, -22,
-22, -23, -22, -23, -23, -22, -24, -20, -27, 7, 26, 19, 23, 21, 21, 21, 22, 20,
21, 21, 22, 21, 22, 20, 22, 21, 22, 20, 23, 19, 24, 19, 24, 19, 24, 19, 25, 18,
26, 15, -107, -111, -108, -110, -108, -111, -108, -110, -108, -110, -110, -108,
-113, -93, -59, -70, -62, -68, -64, -66, -65, -66, -66, -66, -66, -65, -66, -65,
-66, -64, -66, -65, -66, -65, -66, -65, -66, -65, -65, -66, -66, -66, -65, -66,
-66, -65, -65, -65, -66, -66, -66, -65, -65, -66, -65, -66, -65, -65, -65, -65,
-65, -65, -65, -66, -65, -65, -65, -66, -65, -65, -66, -65, -66, -64, -65, -65,
-65, -65, -65, -65, -65, -65, -65, -65, -65, -65, -65, -65, -66, -65, -28, -17,
-23, -20, -23, -21, -23, -21, -22, -20, -22, -21, -21, -21, -22, -21, -21, -22,
-22, -21, -21, -21, -21, -22, -22, -22, -22, -22, -22, -21, -20, -21, -21, -21,
-21, -22, -22, -21, -21, -21, -21, -21, -21, -21, -22, -21, -22, -22, -21, -22,
-21, -22, -21, -22, -21, -21, -21, -21, -21, -22, -21, -21, -21, -22, -21, -22,
-21, -22, -20, -22, -20, -22, -22, };