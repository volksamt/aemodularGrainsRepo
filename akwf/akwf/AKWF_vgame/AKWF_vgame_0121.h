#define DATA_LENGTH 512
#define DATA AKWF_vgame_0121

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 25, 22, 24, 23, 23, 23, 22, 23,
23, 23, 22, 23, 22, 23, 23, 23, 23, 24, 23, 24, 23, 24, 22, 24, 22, 25, 21, 25,
19, 31, 70, 67, 68, 68, 68, 68, 68, 68, 68, 68, 68, 69, 68, 68, 67, 68, 68, 68,
66, 69, 68, 69, 66, 68, 67, 68, 67, 68, 67, 68, 68, 70, 109, 115, 111, 115, 111,
114, 112, 114, 112, 113, 112, 112, 112, 113, 113, 113, 113, 113, 113, 112, 113,
112, 113, 113, 114, 112, 113, 111, 113, 111, 113, 110, 117, 102, 21, 35, 73, 65,
69, 66, 69, 67, 68, 67, 68, 67, 68, 67, 68, 67, 67, 68, 67, 67, 66, 68, 67, 68,
67, 68, 68, 67, 67, 67, 67, 67, 67, 67, 67, 67, 68, 67, 67, 66, 68, 66, 68, 67,
68, 66, 68, 65, 68, 65, 69, 66, 68, 66, 68, 67, 67, 67, 66, 68, 105, 119, 99,
127, -45, -128, -102, -119, -112, -92, -59, -75, -64, -71, -66, -71, -66, -69,
-67, -69, -68, -67, -69, -67, -69, -67, -68, -68, -69, -68, -69, -68, -69, -68,
-68, -67, -69, -68, -69, -69, -68, -68, -68, -68, -68, -68, -67, -69, -68, -68,
-68, -68, -67, -68, -69, -68, -68, -68, -68, -68, -68, -68, -68, -68, -68, -67,
-70, -64, -81, -112, -112, -113, -114, -113, -113, -113, -113, -113, -113, -112,
-113, -112, -113, -113, -113, -113, -113, -112, -113, -113, -113, -112, -113,
-112, -114, -112, -113, -112, -113, -113, -113, -113, -112, -114, -80, -65, -68,
-67, -68, -67, -67, -68, -67, -67, -67, -67, -68, -68, -67, -68, -67, -67, -67,
-67, -68, -67, -68, -66, -68, -66, -72, -41, -17, -25, -20, -24, -22, -24, -22,
-23, -22, -23, -22, -22, -22, -22, -22, -22, -21, -22, -22, -22, -23, -22, -21,
-22, -22, -23, -21, -23, -21, -25, -13, 26, 22, 23, 23, 23, 24, 23, 23, 23, 24,
22, 23, 22, 23, 23, 24, 23, 23, 23, 23, 23, 24, 23, 23, 23, 23, 23, 23, 24, 23,
24, 21, 27, 8, -25, -21, -22, -23, -23, -22, -23, -22, -22, -22, -22, -23, -21,
-22, -22, -22, -23, -22, -22, -22, -22, -22, -22, -22, -22, -22, -22, -21, -22,
-23, -22, -21, -22, -22, -22, -22, -22, -22, -22, -22, -22, -22, -22, -21, -22,
-22, -22, -22, -22, -22, -22, -22, -23, -21, -22, -22, -23, -20, -23, -21, -22,
-22, -23, -22, 19, 25, 22, 24, 22, 24, 22, 24, 23, 24, 23, 24, 23, 24, 23, 24,
23, 23, 24, 23, 23, 23, 23, 22, 23, 23, 23, 23, 23, 24, 23, 24, 23, 23, 23, 23,
23, 23, 23, 23, 24, 23, 23, 23, 24, 23, 24, 22, 23, 23, 24, 24, 23, 23, 23, 23,
23, 23, 22, 25, -11, -27, -20, -23, -21, -22, -22, -23, -22, -22, -22, -22, -22,
-23, -22, -22, -21, -21, -22, -21, -22, -21, -22, -22, -22, -22, -22, -21, -23,
-22, -23, -20, -24, -22, };