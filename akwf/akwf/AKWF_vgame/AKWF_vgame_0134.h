#define DATA_LENGTH 512
#define DATA AKWF_vgame_0134

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 23, 21, 20, 21, 20, 21, 20, 21, 21,
21, 20, 21, 20, 21, 21, 21, 22, 22, 20, 21, 21, 21, 21, 20, 21, 22, 20, 21, 21,
21, 21, 21, 21, 21, 21, 20, 21, 21, 21, 21, 21, 21, 21, 20, 20, 21, 22, 21, 21,
21, 21, 20, 22, 21, 21, 21, 21, 20, 21, 20, 21, 21, 20, 55, 64, 60, 61, 60, 63,
60, 63, 60, 62, 60, 62, 61, 62, 61, 61, 61, 61, 60, 61, 61, 61, 62, 61, 61, 61,
62, 61, 62, 61, 61, 61, 61, 61, 61, 61, 60, 62, 61, 61, 60, 61, 60, 61, 61, 61,
61, 62, 61, 62, 61, 61, 60, 61, 61, 60, 61, 61, 61, 61, 61, 60, 61, 60, 61, 59,
87, 106, 99, 103, 100, 102, 101, 101, 101, 101, 102, 102, 101, 100, 101, 102,
102, 100, 101, 100, 102, 100, 102, 100, 101, 100, 102, 101, 100, 101, 101, 101,
99, 101, 100, 102, 99, 102, 99, 104, 98, 104, 97, 106, 94, 112, 83, -76, -102,
-100, -103, -100, -103, -101, -102, -102, -75, -57, -64, -58, -62, -60, -62,
-60, -61, -61, -62, -61, -62, -61, -61, -61, -61, -61, -61, -61, -61, -61, -62,
-61, -61, -61, -60, -61, -61, -62, -61, -61, -61, -61, -60, -62, -60, -61, -61,
-60, -60, -61, -61, -61, -61, -61, -61, -61, -61, -61, -61, -61, -61, -60, -61,
-61, -61, -60, -62, -61, -61, -60, -61, -62, -60, -61, -59, -65, -31, -17, -22,
-18, -21, -19, -21, -20, -21, -20, -21, -20, -21, -19, -20, -20, -21, -21, -20,
-20, -20, -21, -20, -19, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -19,
-20, -20, -20, -20, -20, -21, -20, -20, -20, -21, -20, -20, -21, -20, -20, -20,
-20, -20, -20, -20, -20, -20, -21, -20, -20, -20, -21, -19, -23, -11, 22, 20,
20, 21, 21, 20, 21, 21, 20, 21, 19, 21, 20, 21, 20, 21, 21, 21, 20, 21, 19, 21,
20, 21, 20, 21, 21, 20, 20, 21, 21, 21, 20, 20, 20, 20, 21, 20, 21, 20, 20, 20,
21, 20, 21, 20, 21, 20, 21, 19, 22, 20, 21, 20, 21, 19, 22, 20, 22, 20, 21, 20,
19, 27, -42, -66, -58, -62, -58, -62, -59, -62, -59, -61, -59, -61, -60, -61,
-60, -61, -61, -60, -61, -60, -61, -61, -60, -61, -61, -60, -61, -61, -61, -61,
-60, -60, -61, -60, -60, -61, -61, -61, -59, -60, -61, -61, -60, -60, -60, -60,
-60, -60, -60, -60, -61, -60, -60, -60, -60, -60, -60, -59, -62, -58, -65, -35,
-15, -23, -18, -22, -19, -21, -20, -21, -19, -20, -20, -19, -20, -20, -19, -20,
-20, -20, -20, -20, -19, -19, -20, -20, -20, -20, -19, -20, -20, -20, -20, -19,
-19, -19, -19, -20, -20, -21, -20, -19, -21, -19, -19, -20, -20, -19, -20, -20,
-20, -20, -20, -19, -20, -20, -20, -20, -20, -20, -19, -20, -19, -20, -19, -20,
-19, -21, -19, };