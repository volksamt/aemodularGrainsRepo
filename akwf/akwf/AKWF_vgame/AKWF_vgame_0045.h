#define DATA_LENGTH 512
#define DATA AKWF_vgame_0045

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 5, 5, 5, 14, 17, 15, 17, 15, 16,
16, 15, 19, 29, 27, 28, 26, 29, 39, 38, 38, 38, 39, 38, 38, 37, 46, 51, 48, 51,
47, 55, 62, 60, 61, 60, 60, 60, 61, 61, 71, 72, 71, 72, 70, 82, 85, 84, 85, 84,
84, 85, 83, 86, 95, 93, 94, 94, 95, 103, 103, 103, 104, 103, 103, 103, 106, 112,
111, 112, 112, 111, 113, 116, 116, 117, 116, 116, 116, 116, 117, 118, 117, 117,
117, 117, 115, 114, 115, 114, 114, 114, 115, 114, 112, 111, 111, 111, 111, 110,
108, 107, 108, 107, 109, 108, 108, 107, 104, 105, 104, 104, 105, 104, 101, 102,
101, 101, 101, 101, 100, 98, 99, 99, 98, 98, 99, 96, 93, 93, 94, 94, 93, 94, 91,
89, 89, 88, 88, 89, 89, 87, 85, 81, 81, 81, 80, 81, 81, 81, 81, 81, 81, 82, 81,
76, 76, 76, 76, 77, 76, 72, 70, 72, 72, 72, 72, 70, 65, 62, 62, 62, 62, 61, 61,
62, 62, 62, 62, 62, 62, 61, 53, 53, 53, 52, 52, 53, 52, 51, 52, 52, 53, 52, 53,
47, 41, 41, 41, 41, 42, 42, 41, 41, 41, 41, 41, 41, 41, 35, 30, 30, 30, 30, 30,
31, 30, 30, 30, 30, 30, 28, 25, 24, 20, 21, 20, 21, 21, 20, 21, 20, 20, 20, 21,
17, 14, 9, 7, 9, 8, 9, 7, 8, 8, 8, 8, 8, 8, 5, 2, -3, -3, -3, -3, -3, -4, -3,
-3, -3, -3, -3, -7, -7, -10, -13, -12, -13, -13, -13, -13, -13, -13, -13, -12,
-14, -19, -18, -23, -24, -24, -24, -23, -23, -24, -24, -23, -25, -24, -28, -30,
-30, -35, -34, -35, -35, -36, -35, -35, -34, -35, -35, -34, -40, -41, -42, -46,
-46, -46, -47, -46, -47, -51, -51, -51, -51, -51, -51, -50, -53, -56, -56, -56,
-56, -56, -56, -55, -55, -55, -56, -61, -62, -62, -66, -68, -67, -66, -66, -67,
-67, -66, -67, -67, -69, -72, -72, -72, -76, -76, -76, -77, -76, -76, -76, -75,
-76, -77, -79, -82, -80, -82, -86, -86, -85, -85, -86, -86, -86, -86, -86, -88,
-89, -90, -89, -91, -94, -93, -95, -93, -94, -93, -94, -93, -95, -97, -97, -97,
-96, -102, -101, -102, -102, -102, -102, -102, -102, -101, -104, -105, -105,
-105, -106, -109, -108, -108, -107, -108, -108, -108, -109, -107, -111, -111,
-111, -111, -113, -114, -114, -114, -114, -114, -114, -115, -115, -117, -118,
-117, -117, -118, -119, -119, -119, -119, -119, -120, -118, -119, -119, -116,
-117, -116, -116, -116, -109, -110, -110, -110, -110, -110, -109, -111, -105,
-99, -101, -99, -102, -95, -89, -90, -89, -89, -89, -89, -89, -82, -77, -78,
-78, -78, -78, -72, -67, -69, -68, -68, -68, -69, -68, -59, -58, -53, -44, -45,
-44, -44, -44, -45, -44, -45, -44, -45, -41, -33, -33, -33, -33, -34, -31, -21,
-22, -22, -22, -23, -22, -23, -17, -9, -10, -9, -10, -10, -5, };