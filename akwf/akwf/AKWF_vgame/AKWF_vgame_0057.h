#define DATA_LENGTH 512
#define DATA AKWF_vgame_0057

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 5, 7, 9, 10, 12, 13, 14, 18,
21, 21, 22, 23, 24, 27, 31, 30, 32, 34, 36, 37, 39, 41, 44, 43, 45, 47, 49, 53,
54, 55, 56, 57, 59, 60, 62, 66, 67, 67, 69, 72, 72, 76, 77, 77, 79, 80, 83, 84,
86, 90, 90, 91, 92, 93, 96, 99, 98, 99, 101, 103, 103, 105, 107, 108, 109, 110,
111, 112, 113, 114, 113, 114, 116, 117, 117, 118, 118, 117, 117, 117, 117, 116,
116, 116, 115, 115, 114, 114, 114, 113, 113, 113, 113, 111, 111, 111, 109, 109,
109, 109, 107, 108, 107, 107, 106, 105, 105, 105, 104, 103, 103, 102, 102, 101,
100, 100, 100, 99, 98, 99, 98, 97, 96, 95, 95, 95, 95, 93, 93, 92, 92, 90, 91,
91, 89, 89, 87, 87, 86, 86, 85, 86, 84, 83, 83, 83, 82, 81, 79, 79, 78, 77, 78,
77, 77, 75, 73, 73, 74, 72, 71, 71, 72, 70, 68, 68, 68, 67, 67, 65, 64, 64, 64,
63, 62, 60, 61, 59, 59, 57, 56, 57, 57, 55, 54, 53, 52, 53, 51, 50, 50, 48, 48,
49, 47, 47, 44, 42, 42, 42, 42, 41, 40, 40, 38, 36, 36, 36, 35, 35, 33, 31, 32,
31, 30, 30, 28, 27, 27, 27, 26, 25, 24, 24, 22, 20, 20, 21, 19, 19, 16, 16, 15,
16, 15, 13, 12, 12, 9, 9, 10, 9, 8, 7, 5, 4, 4, 4, 3, 2, 1, 0, -2, -2, -2, -2,
-3, -6, -7, -6, -6, -7, -9, -10, -10, -12, -13, -12, -14, -14, -15, -17, -17,
-17, -18, -19, -20, -21, -22, -24, -24, -24, -25, -25, -27, -29, -28, -29, -30,
-30, -31, -33, -34, -35, -35, -34, -36, -38, -39, -40, -39, -39, -41, -41, -42,
-44, -46, -46, -46, -46, -47, -48, -50, -50, -50, -52, -52, -54, -53, -55, -55,
-56, -58, -58, -59, -59, -60, -62, -62, -62, -62, -64, -65, -65, -65, -66, -67,
-68, -69, -71, -70, -71, -73, -73, -74, -74, -75, -74, -75, -76, -77, -78, -79,
-79, -80, -81, -81, -81, -82, -84, -84, -85, -86, -86, -87, -88, -87, -90, -89,
-89, -90, -90, -92, -92, -93, -94, -93, -94, -95, -96, -97, -97, -99, -98, -98,
-99, -100, -100, -102, -102, -102, -102, -103, -103, -105, -105, -104, -105,
-107, -106, -108, -109, -108, -109, -109, -110, -110, -111, -111, -111, -113,
-112, -112, -114, -114, -114, -114, -115, -117, -116, -117, -117, -117, -117,
-119, -118, -119, -118, -119, -118, -119, -119, -119, -116, -116, -116, -116,
-114, -113, -112, -112, -109, -109, -108, -107, -105, -104, -100, -99, -101,
-99, -96, -95, -93, -92, -88, -89, -87, -87, -82, -81, -79, -79, -78, -76, -74,
-73, -72, -68, -67, -65, -64, -63, -60, -58, -57, -56, -54, -53, -51, -49, -47,
-43, -43, -42, -41, -40, -37, -34, -33, -32, -30, -28, -26, -25, -23, -21, -19,
-18, -17, -16, -12, -9, -10, -7, -7, -5, -4, -2, };