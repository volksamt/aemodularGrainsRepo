#define DATA_LENGTH 512
#define DATA AKWF_vgame_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {15, 98, 121, 118, 121, 118, 119, 117,
120, 118, 120, 119, 120, 119, 120, 118, 119, 118, 119, 119, 119, 118, 119, 120,
119, 119, 120, 119, 119, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119,
118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119,
119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 120, 119, 119, 119,
119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119, 119, 118,
119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 120, 119, 118, 118, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 120, 118, 119, 118, 119, 119, 120, 119, 120,
119, 119, 120, 119, 118, 119, 119, 119, 119, 119, 118, 120, 118, 119, 119, 119,
119, 120, 119, 118, 119, 119, 119, 119, 120, 119, 119, 119, 119, 120, 119, 119,
119, 119, 120, 119, 119, 119, 119, 119, 118, 119, 119, 120, 120, 119, 119, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 118, 119, 119, 118, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 118, 119, 118, 119, 119, 119, 119, 120, 118, 118, 119, 119, 119, 119, 119,
119, 118, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 118, 119, 119, 118, 119,
119, 119, 119, 119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119,
119, 120, 119, 118, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 119, 120, 119, 118, 118, 120, 119, 119, 119, 119, 119, 119, 118, 119,
119, 119, 120, 119, 119, 119, 120, 119, 119, 119, 118, 119, 119, 119, 119, 119,
118, 119, 119, 119, 119, 119, 120, 119, 120, 119, 119, 119, 119, 120, 118, 119,
119, 119, 118, 119, 119, 119, 119, 120, 119, 119, 120, 118, 118, 119, 119, 119,
119, 118, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 120, 119, 118, 119,
119, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 117, 118,
120, 119, 119, 119, 115, 66, 2, -62, -116, -119, -120, -119, -118, -117, -116,
-118, -119, -120, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -118, -118, -120,
-119, -119, -120, -119, -119, -119, -119, -118, -119, -119, -120, -118, -120,
-120, -119, -119, -119, -119, -119, -120, -118, -120, -116, -120, -118, -120,
-118, -121, -114, -93, -51, };