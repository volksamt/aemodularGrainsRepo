#define DATA_LENGTH 512
#define DATA AKWF_vgame_0035

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 1, 2, 11, 15, 12, 17, 23, 22, 31,
33, 31, 37, 44, 43, 44, 52, 51, 51, 58, 62, 60, 63, 66, 66, 66, 69, 71, 69, 73,
79, 77, 78, 79, 81, 80, 82, 84, 82, 85, 87, 87, 86, 90, 90, 90, 92, 94, 92, 94,
94, 96, 95, 96, 97, 96, 97, 98, 98, 99, 98, 98, 98, 100, 102, 102, 101, 101,
101, 102, 106, 104, 105, 107, 108, 107, 112, 118, 117, 118, 118, 118, 117, 119,
119, 120, 119, 118, 117, 117, 110, 105, 105, 105, 104, 106, 103, 96, 97, 97, 89,
87, 88, 84, 75, 72, 73, 72, 73, 69, 67, 67, 67, 65, 65, 62, 60, 61, 57, 55, 56,
56, 56, 52, 52, 51, 49, 44, 47, 43, 35, 30, 21, 21, 20, 22, 18, 11, 12, 11, 5,
3, 4, -1, -4, -8, -10, -10, -10, -10, -10, -10, -11, -11, -11, -12, -11, -12,
-13, -16, -16, -15, -16, -20, -21, -20, -23, -28, -28, -27, -38, -36, -42, -49,
-48, -48, -50, -60, -59, -59, -66, -71, -67, -73, -80, -78, -83, -84, -83, -83,
-84, -84, -84, -83, -82, -82, -82, -82, -82, -82, -81, -81, -81, -81, -78, -77,
-76, -75, -76, -75, -76, -76, -76, -75, -74, -74, -73, -71, -71, -70, -66, -64,
-66, -62, -54, -56, -55, -46, -42, -45, -37, -29, -32, -29, -18, -17, -19, -9,
-6, -8, -3, 4, 3, 3, 10, 12, 11, 14, 16, 16, 17, 21, 20, 20, 23, 24, 24, 25, 26,
25, 26, 26, 26, 26, 25, 26, 26, 25, 26, 25, 27, 26, 26, 25, 26, 25, 25, 25, 25,
25, 24, 19, 16, 16, 16, 16, 17, 13, 9, 11, 9, 1, 1, 2, -1, -3, -3, -4, -3, -4,
-3, -3, -3, -3, -3, -1, -2, -2, -4, -3, -4, -2, -3, -4, -7, -6, -7, -9, -12,
-11, -13, -19, -24, -29, -26, -28, -26, -31, -36, -35, -36, -40, -43, -42, -44,
-45, -47, -46, -46, -47, -46, -46, -47, -46, -49, -51, -49, -51, -54, -55, -58,
-58, -57, -58, -60, -59, -59, -59, -59, -60, -59, -60, -59, -59, -59, -60, -59,
-59, -60, -60, -60, -60, -61, -61, -61, -61, -61, -59, -60, -60, -59, -59, -59,
-60, -59, -58, -57, -58, -58, -58, -58, -58, -58, -58, -58, -56, -56, -56, -56,
-54, -54, -55, -54, -55, -53, -53, -53, -52, -51, -52, -52, -50, -50, -50, -47,
-45, -46, -43, -39, -39, -39, -34, -31, -33, -31, -27, -27, -28, -24, -24, -24,
-23, -21, -21, -20, -18, -18, -18, -18, -17, -18, -18, -16, -16, -15, -16, -16,
-17, -16, -17, -16, -17, -16, -16, -16, -15, -16, -16, -19, -20, -19, -19, -19,
-19, -19, -20, -20, -21, -22, -22, -23, -23, -22, -22, -22, -23, -23, -23, -22,
-22, -23, -22, -24, -24, -24, -24, -23, -25, -24, -24, -24, -24, -25, -24, -24,
-24, -24, -24, -23, -20, -17, -18, -18, -18, -16, -13, -13, -13, -8, -6, -7, -3,
};