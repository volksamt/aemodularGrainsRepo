#define DATA_LENGTH 512
#define DATA AKWF_vgame_0125

const PROGMEM int8_t DATA[DATA_LENGTH] = {13, 23, 21, 21, 21, 22, 23, 21, 23,
20, 23, 20, 23, 66, 69, 68, 69, 68, 69, 67, 69, 68, 68, 67, 68, 68, 69, 68, 69,
67, 69, 67, 70, 67, 69, 67, 69, 67, 70, 66, 71, 64, 76, 116, 114, 115, 114, 115,
115, 115, 114, 115, 114, 116, 112, 121, 89, 62, 71, 66, 69, 66, 69, 67, 69, 67,
68, 68, 68, 68, 68, 68, 67, 68, 67, 68, 67, 68, 68, 68, 67, 68, 67, 68, 67, 68,
68, 68, 68, 67, 67, 68, 68, 68, 67, 68, 68, 68, 67, 67, 67, 67, 67, 68, 67, 67,
68, 68, 67, 67, 68, 68, 67, 67, 68, 67, 68, 68, 66, 68, 67, 67, 67, 68, 67, 68,
67, 67, 67, 67, 67, 68, 68, 67, 67, 68, 67, 67, 68, 67, 67, 68, 67, 66, 68, 67,
67, 67, 68, 67, 68, 67, 67, 67, 66, 67, 67, 66, 67, 67, 67, 67, 67, 67, 67, 67,
67, 67, 67, 67, 66, 67, 66, 67, 67, 68, 67, 67, 67, 67, 67, 67, 67, 66, 68, 66,
68, 64, 71, 35, 14, 23, 19, 22, 19, 21, 20, 21, 20, 21, 20, 20, 20, 20, 20, 20,
19, 20, 20, 19, 21, 20, 21, 19, 20, 19, 21, 19, 21, 20, 21, 20, 21, 19, 22, 18,
24, 3, -31, -25, -28, -26, -27, -27, -26, -27, -26, -26, -26, -27, -26, -27,
-27, -27, -26, -27, -27, -26, -26, -27, -27, -27, -26, -27, -25, -27, -25, -29,
6, 25, 17, 22, 18, 21, 19, 21, 19, 20, 20, 20, 20, 20, 21, 20, 20, 20, 20, 20,
20, 20, 20, 20, 19, 20, 20, 20, 20, 20, 20, 21, 19, 21, 21, 20, 20, 21, 20, 20,
20, 20, 20, 20, 19, 19, 20, 20, 20, 19, 20, 18, 21, 18, 24, 2, -31, -25, -28,
-27, -26, -26, -27, -26, -26, -27, -27, -27, -27, -27, -27, -27, -26, -27, -27,
-26, -27, -27, -27, -27, -26, -26, -27, -26, -26, -27, -26, -27, -26, -26, -27,
-27, -27, -26, -27, -26, -27, -27, -27, -27, -26, -28, -26, -27, -26, -29, -22,
-45, -77, -72, -74, -73, -73, -74, -74, -74, -73, -73, -72, -73, -73, -73, -72,
-73, -73, -72, -73, -72, -73, -73, -73, -73, -73, -73, -73, -73, -74, -73, -72,
-73, -73, -73, -73, -73, -73, -73, -73, -73, -73, -72, -73, -74, -73, -73, -73,
-73, -73, -72, -72, -73, -72, -73, -73, -73, -73, -72, -73, -73, -73, -73, -73,
-72, -73, -73, -73, -72, -73, -72, -73, -72, -74, -72, -74, -71, -75, -112,
-120, -118, -120, -119, -119, -118, -120, -119, -119, -118, -119, -118, -120,
-119, -118, -119, -118, -118, -118, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -118, -118, -119, -119, -119, -118, -118, -118,
-119, -118, -118, -118, -120, -117, -120, -117, -121, -91, -69, -74, -71, -72,
-70, -73, -70, -73, -68, -78, -48, -22, -26, -24, -25, -26, -24, -26, -24, };