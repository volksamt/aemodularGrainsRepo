#define DATA_LENGTH 512
#define DATA AKWF_vgame_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 6, 13, 18, 17, 24, 23, 28, 35, 36,
37, 36, 40, 46, 44, 50, 52, 49, 53, 59, 59, 64, 72, 71, 72, 71, 74, 74, 75, 81,
81, 82, 86, 85, 88, 89, 92, 92, 92, 92, 95, 96, 96, 99, 98, 102, 101, 103, 107,
108, 110, 109, 110, 113, 114, 113, 114, 114, 114, 113, 115, 113, 113, 113, 112,
113, 113, 113, 113, 113, 113, 112, 114, 114, 114, 113, 112, 112, 111, 112, 108,
106, 106, 102, 104, 101, 100, 100, 97, 97, 95, 91, 92, 92, 85, 85, 81, 76, 78,
74, 73, 73, 68, 69, 64, 64, 63, 59, 58, 59, 54, 53, 52, 44, 45, 42, 39, 40, 35,
36, 33, 30, 31, 26, 26, 23, 18, 18, 19, 15, 14, 14, 8, 8, 5, 3, 3, 0, 0, -1, -2,
-2, -3, -4, -4, -8, -10, -9, -9, -9, -11, -13, -13, -13, -13, -13, -12, -13,
-12, -11, -11, -12, -11, -11, -13, -12, -13, -13, -13, -14, -14, -14, -14, -15,
-14, -14, -14, -13, -12, -13, -13, -13, -13, -15, -15, -15, -14, -10, -11, -11,
-10, -8, -7, -7, -4, -6, -3, -3, -3, -2, 0, 2, 2, 2, 2, 5, 5, 8, 8, 9, 12, 11,
14, 17, 18, 20, 19, 21, 22, 23, 25, 26, 25, 29, 30, 30, 35, 36, 39, 38, 37, 41,
41, 42, 44, 44, 45, 46, 46, 50, 49, 50, 51, 51, 50, 54, 54, 54, 54, 54, 54, 54,
53, 54, 54, 53, 53, 53, 52, 53, 53, 52, 51, 50, 49, 50, 48, 47, 47, 45, 46, 46,
44, 45, 43, 43, 43, 42, 41, 41, 39, 39, 38, 34, 35, 33, 34, 32, 30, 31, 28, 27,
27, 26, 25, 26, 24, 24, 24, 22, 22, 21, 21, 20, 21, 21, 21, 21, 21, 19, 17, 18,
17, 17, 17, 16, 14, 14, 13, 12, 12, 12, 11, 11, 10, 10, 9, 10, 8, 8, 7, 5, 5, 5,
3, 3, 2, -3, -3, -3, -3, -3, -5, -4, -7, -8, -9, -13, -13, -14, -16, -18, -19,
-19, -18, -21, -25, -25, -26, -25, -27, -29, -29, -31, -33, -34, -35, -34, -37,
-38, -38, -38, -40, -39, -42, -45, -45, -47, -49, -51, -51, -50, -55, -55, -56,
-60, -60, -62, -64, -63, -64, -65, -67, -69, -68, -70, -72, -71, -75, -77, -75,
-80, -79, -82, -84, -84, -87, -87, -86, -89, -90, -90, -97, -97, -97, -101,
-100, -103, -102, -103, -106, -106, -109, -110, -110, -112, -111, -111, -112,
-113, -112, -114, -114, -114, -116, -116, -117, -117, -118, -119, -119, -119,
-120, -119, -119, -119, -120, -119, -119, -119, -117, -118, -116, -116, -116,
-114, -115, -113, -110, -111, -107, -105, -105, -105, -105, -104, -100, -101,
-99, -96, -96, -93, -92, -93, -87, -84, -84, -84, -83, -78, -77, -79, -76, -75,
-74, -68, -69, -66, -60, -59, -59, -59, -56, -53, -53, -47, -46, -45, -38, -38,
-38, -33, -21, -21, -20, -21, -18, -14, -14, -7, -7, -1, };