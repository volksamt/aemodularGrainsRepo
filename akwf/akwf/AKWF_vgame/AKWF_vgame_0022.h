#define DATA_LENGTH 512
#define DATA AKWF_vgame_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 13, 14, 18, 17, 22, 25, 29,
33, 35, 35, 39, 43, 41, 46, 45, 49, 55, 59, 61, 61, 63, 67, 71, 69, 74, 73, 74,
76, 80, 83, 82, 86, 85, 88, 89, 92, 92, 92, 94, 96, 98, 96, 98, 98, 100, 102,
106, 106, 106, 108, 108, 111, 111, 114, 115, 115, 114, 114, 115, 115, 114, 114,
114, 113, 113, 113, 114, 113, 113, 112, 113, 114, 114, 114, 113, 112, 110, 109,
109, 110, 106, 104, 102, 101, 101, 101, 98, 96, 96, 92, 89, 88, 90, 84, 83, 81,
77, 79, 74, 72, 69, 68, 67, 62, 60, 61, 59, 55, 56, 53, 50, 45, 44, 43, 40, 41,
36, 32, 32, 32, 30, 28, 25, 24, 22, 19, 19, 16, 14, 11, 8, 5, 7, 6, 3, 3, 0, -1,
-2, -2, -3, -3, -5, -5, -7, -8, -9, -10, -11, -12, -14, -12, -12, -13, -13, -13,
-11, -10, -11, -11, -10, -11, -12, -12, -14, -14, -15, -15, -13, -14, -14, -15,
-14, -14, -13, -13, -13, -13, -13, -12, -13, -14, -14, -14, -14, -13, -13, -9,
-9, -9, -8, -8, -4, -5, -3, -3, -2, -1, -2, -1, 1, 3, 3, 5, 5, 8, 7, 10, 11, 11,
14, 15, 19, 19, 19, 19, 23, 24, 25, 25, 25, 29, 32, 34, 33, 35, 39, 40, 39, 41,
42, 43, 45, 45, 46, 46, 47, 48, 48, 50, 53, 52, 53, 53, 53, 54, 54, 54, 54, 54,
54, 53, 52, 52, 52, 53, 53, 52, 52, 51, 51, 49, 49, 49, 47, 47, 46, 46, 46, 46,
45, 45, 43, 43, 43, 41, 40, 38, 38, 37, 37, 35, 36, 34, 34, 33, 30, 29, 27, 27,
27, 27, 26, 24, 22, 22, 23, 23, 22, 20, 20, 21, 21, 21, 21, 19, 19, 19, 17, 18,
17, 15, 15, 14, 14, 14, 12, 11, 12, 11, 11, 10, 9, 9, 8, 9, 8, 9, 6, 4, 3, 3, 3,
2, 0, -3, -3, -4, -3, -4, -4, -7, -8, -9, -10, -12, -15, -14, -18, -20, -21,
-20, -22, -24, -24, -26, -26, -27, -29, -30, -30, -29, -34, -35, -34, -35, -37,
-38, -39, -40, -42, -43, -43, -45, -44, -47, -53, -52, -51, -53, -56, -58, -60,
-60, -62, -61, -64, -66, -66, -68, -68, -69, -68, -70, -71, -75, -76, -77, -78,
-81, -84, -83, -84, -85, -89, -88, -92, -92, -92, -95, -97, -98, -98, -101,
-101, -104, -105, -107, -108, -109, -110, -108, -111, -111, -112, -113, -114,
-112, -114, -115, -114, -116, -116, -117, -117, -118, -119, -119, -120, -118,
-119, -119, -119, -120, -119, -119, -118, -117, -118, -117, -117, -116, -114,
-113, -113, -113, -110, -111, -109, -107, -103, -103, -103, -102, -97, -97, -97,
-94, -95, -92, -90, -87, -84, -84, -85, -79, -77, -78, -74, -75, -73, -72, -68,
-67, -66, -61, -57, -60, -58, -52, -52, -50, -46, -42, -39, -39, -36, -38, -31,
-22, -20, -21, -18, -16, -16, -9, -6, -2, -1, };