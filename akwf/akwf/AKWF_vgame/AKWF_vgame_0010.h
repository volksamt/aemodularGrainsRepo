#define DATA_LENGTH 512
#define DATA AKWF_vgame_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 5, 4, 6, 5, 5, 4, 5, 5, 4, 6, 2,
22, 55, 57, 57, 57, 58, 58, 56, 57, 56, 58, 56, 59, 55, 64, 77, 74, 75, 74, 75,
75, 75, 74, 75, 75, 76, 73, 85, 101, 101, 102, 101, 102, 101, 101, 102, 101,
102, 101, 102, 100, 106, 114, 112, 113, 113, 112, 113, 113, 112, 113, 114, 113,
113, 113, 115, 115, 114, 115, 114, 115, 114, 113, 115, 115, 114, 113, 115, 110,
106, 107, 106, 107, 106, 106, 106, 107, 105, 107, 108, 98, 92, 76, 74, 75, 74,
75, 74, 75, 74, 74, 73, 75, 74, 77, 64, 53, 57, 55, 57, 55, 56, 56, 55, 55, 55,
56, 42, 33, 21, 18, 20, 19, 20, 18, 19, 19, 20, 19, 19, 19, 21, 9, 1, 4, 3, 4,
2, 4, 2, 4, 3, 4, 4, -3, -7, -12, -14, -13, -13, -13, -13, -13, -13, -12, -13,
-13, -13, -13, -12, -11, -11, -11, -11, -11, -11, -11, -12, -11, -11, -11, -13,
-14, -13, -13, -12, -13, -13, -13, -13, -13, -13, -12, -12, -13, -13, -10, -9,
-10, -9, -10, -9, -9, -10, -10, -8, -10, -8, -3, 2, 10, 9, 10, 10, 10, 9, 9, 9,
9, 9, 9, 9, 9, 18, 21, 21, 21, 20, 20, 20, 21, 20, 21, 19, 22, 33, 39, 48, 45,
45, 46, 46, 46, 46, 46, 46, 47, 46, 46, 45, 51, 53, 52, 53, 52, 53, 52, 53, 52,
52, 52, 52, 53, 51, 50, 51, 51, 51, 51, 51, 51, 51, 50, 50, 51, 51, 51, 44, 44,
45, 44, 44, 45, 44, 45, 45, 44, 44, 36, 38, 33, 27, 30, 29, 29, 29, 29, 29, 29,
29, 26, 21, 22, 22, 23, 22, 22, 23, 22, 22, 22, 22, 22, 22, 22, 19, 20, 16, 11,
13, 12, 13, 13, 13, 12, 12, 13, 13, 13, 13, 12, 8, 8, 7, 9, 7, 7, 8, 8, 8, 9, 7,
1, 3, -5, -8, -8, -9, -7, -8, -7, -8, -8, -9, -8, -8, -7, -9, -23, -22, -23,
-22, -22, -22, -22, -22, -22, -21, -24, -31, -29, -37, -42, -40, -42, -42, -43,
-41, -42, -41, -41, -41, -42, -41, -44, -54, -54, -54, -53, -54, -54, -54, -54,
-54, -52, -57, -66, -64, -73, -78, -76, -77, -76, -77, -76, -76, -76, -77, -76,
-77, -75, -81, -91, -90, -90, -91, -92, -90, -91, -90, -91, -89, -94, -104,
-101, -111, -114, -112, -113, -113, -113, -112, -114, -113, -113, -113, -113,
-112, -114, -118, -117, -118, -117, -118, -118, -117, -118, -118, -117, -117,
-119, -119, -115, -114, -115, -114, -114, -114, -115, -114, -114, -113, -115,
-114, -116, -110, -104, -105, -104, -104, -105, -104, -105, -104, -107, -101,
-89, -91, -90, -77, -74, -76, -74, -74, -74, -74, -74, -75, -74, -75, -73, -76,
-68, -58, -60, -59, -58, -59, -58, -59, -58, -61, -50, -30, -35, -32, -10, -7,
-9, -7, -9, -8, -9, -7, -8, -8, -8, -8, -8, -2, };