#define DATA_LENGTH 512
#define DATA AKWF_vgame_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -1, 0, -1, -1, -1, -1, 0, 0, 0, 0,
-1, 0, -1, 0, 0, 1, 1, 0, 0, 0, -1, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 1, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, -1, 1, 0, 0, 0, -1, 1, 1, 0, 1, 1, 0, 0,
1, 0, 0, 0, 0, 1, -1, 1, -1, -1, 1, 1, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 1, 1, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 1,
0, 1, 1, 0, 0, 0, 0, 0, 0, 1, -1, 1, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0,
0, -1, 0, -1, 0, 0, 0, 0, 0, 1, 17, 58, 93, 106, 109, 115, 117, 119, 120, 117,
116, 114, 96, 53, 17, 4, -1, -7, -11, -15, -16, -16, -16, -15, -15, -14, -15,
-14, -15, -14, -14, -14, -14, -14, -14, -13, -13, -13, -12, -14, -13, -12, -13,
-13, -12, -12, -12, -12, -12, -12, -12, -11, -11, -12, -11, -11, -11, -11, -10,
-10, -11, -10, -11, -10, -10, -10, -10, -9, -9, -10, -10, -9, -9, -9, -9, -9,
-9, -9, -9, -8, -8, -8, -8, -8, -9, -7, -7, -8, -8, -7, -8, -7, -7, -7, -7, -7,
-8, -7, -6, -7, -6, -7, -7, -7, -7, -6, -6, -7, -6, -6, -6, -6, -7, -6, -6, -5,
-6, -6, -5, -5, -5, -5, -5, -5, -5, -6, -5, -5, -5, -5, -5, -4, -5, -5, -5, -5,
-4, -5, -4, -4, -5, -4, -3, -4, -5, -4, -4, -4, -5, -4, -4, -4, -3, -4, -3, -3,
-4, -4, -4, -3, -4, -3, -4, -4, -3, -4, -3, -3, -3, -3, -3, -3, -3, -2, -3, -2,
-3, -3, -3, -3, -3, -2, -2, -3, -2, -2, -3, -2, -2, -2, -2, -3, -2, -3, -3, -2,
-1, -3, -2, -2, -2, -2, -2, -1, -2, -2, -2, -1, -3, -1, -2, -1, -1, -2, -2, -1,
-1, -1, -2, -1, -2, -2, -1, -1, -2, -1, -1, -1, -1, -1, -1, -1, 0, -2, -2, -1,
-1, -1, -1, -1, -1, 0, -1, -2, -1, -1, -1, -1, -1, 0, -1, -1, -1, -1, -1, -1, 0,
0, -1, -1, 0, -1, 0, 0, -1, -1, 0, 0, 0, -1, -1, -1, 0, -1, 0, 0, 0, -1, 0, -1,
0, -1, 0, 0, -1, -1, 0, 0, 0, -1, 0, -1, -1, 0, 0, 0, 0, -1, -1, -1, 0, -1, 0,
0, -1, -1, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, -1, 0, -1, 1, -1, 0, 0, -1, 1,
0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0,
-1, -1, 0, 0, 0, -1, 0, 0, 0, };