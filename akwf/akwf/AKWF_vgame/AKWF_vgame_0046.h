#define DATA_LENGTH 512
#define DATA AKWF_vgame_0046

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 7, 6, 7, 6, 6, 6, 7, 15, 16, 15,
17, 16, 24, 26, 25, 25, 26, 25, 27, 36, 36, 36, 36, 36, 37, 49, 56, 56, 56, 55,
55, 54, 56, 55, 57, 54, 59, 68, 66, 74, 77, 76, 77, 76, 76, 76, 77, 75, 81, 85,
86, 85, 87, 96, 95, 96, 95, 95, 95, 94, 99, 103, 103, 103, 104, 103, 108, 113,
111, 112, 111, 111, 111, 115, 116, 115, 116, 115, 116, 117, 115, 114, 115, 114,
114, 115, 114, 114, 115, 114, 114, 113, 113, 111, 109, 110, 109, 110, 109, 109,
109, 110, 108, 107, 106, 106, 106, 103, 103, 104, 103, 103, 104, 103, 102, 99,
100, 100, 100, 100, 99, 96, 96, 97, 96, 97, 95, 94, 94, 93, 94, 94, 92, 90, 87,
85, 86, 86, 87, 85, 86, 86, 86, 85, 84, 83, 83, 81, 77, 78, 78, 78, 77, 78, 78,
78, 78, 73, 73, 73, 74, 71, 70, 70, 70, 70, 69, 70, 69, 65, 65, 65, 65, 66, 64,
60, 60, 60, 60, 61, 59, 57, 58, 58, 56, 58, 56, 52, 49, 47, 48, 48, 47, 47, 48,
47, 48, 48, 46, 42, 44, 42, 38, 38, 38, 38, 35, 33, 34, 33, 33, 33, 33, 34, 35,
30, 28, 28, 28, 29, 29, 29, 29, 25, 23, 24, 23, 24, 24, 19, 17, 18, 16, 18, 17,
13, 13, 13, 12, 13, 12, 9, 6, 2, 3, 4, 4, 3, 3, 3, 3, 3, 3, -2, -1, -2, -6, -7,
-7, -7, -6, -6, -6, -6, -8, -11, -11, -12, -11, -12, -16, -15, -17, -16, -16,
-15, -20, -23, -21, -22, -22, -22, -25, -32, -31, -31, -32, -32, -33, -32, -32,
-31, -33, -31, -35, -36, -37, -42, -41, -41, -41, -41, -42, -41, -41, -41, -42,
-45, -46, -45, -49, -51, -51, -51, -51, -52, -51, -50, -52, -56, -55, -55, -56,
-56, -61, -60, -60, -59, -61, -60, -61, -66, -64, -65, -65, -65, -66, -71, -74,
-72, -73, -74, -73, -73, -74, -73, -73, -73, -76, -78, -77, -81, -81, -81, -81,
-81, -81, -80, -81, -81, -84, -87, -86, -86, -86, -90, -88, -89, -89, -88, -89,
-89, -91, -96, -97, -96, -97, -96, -97, -97, -96, -97, -98, -97, -98, -100,
-100, -100, -100, -100, -100, -104, -106, -107, -107, -106, -106, -106, -106,
-107, -107, -106, -108, -110, -109, -112, -113, -112, -113, -113, -113, -112,
-114, -113, -114, -114, -114, -115, -114, -118, -118, -118, -118, -117, -117,
-117, -119, -120, -119, -119, -119, -119, -118, -115, -117, -116, -117, -116,
-113, -110, -111, -110, -111, -112, -106, -102, -94, -93, -94, -93, -94, -93,
-94, -94, -94, -93, -93, -85, -87, -80, -71, -74, -72, -74, -73, -74, -72, -74,
-71, -63, -64, -64, -63, -55, -53, -55, -53, -55, -53, -55, -50, -42, -43, -43,
-43, -44, -40, -33, -34, -33, -33, -34, -29, -22, -24, -24, -23, -25, -18, -12,
-5, -2, -4, -2, -3, -3, -3, -3, -3, -3, };