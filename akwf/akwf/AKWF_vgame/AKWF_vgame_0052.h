#define DATA_LENGTH 512
#define DATA AKWF_vgame_0052

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 4, 5, 9, 6, 10, 15, 14, 18, 19,
18, 22, 25, 23, 24, 28, 27, 33, 36, 34, 36, 41, 45, 45, 44, 44, 45, 49, 49, 53,
56, 56, 56, 59, 58, 62, 66, 64, 66, 70, 70, 73, 75, 74, 76, 79, 79, 82, 86, 89,
89, 89, 89, 93, 94, 92, 95, 99, 98, 102, 103, 103, 104, 107, 106, 109, 113, 112,
113, 113, 113, 112, 116, 116, 117, 117, 117, 117, 118, 118, 117, 115, 115, 115,
116, 116, 115, 114, 115, 114, 112, 113, 112, 111, 112, 111, 111, 111, 111, 110,
110, 109, 109, 108, 106, 107, 107, 106, 105, 105, 104, 103, 103, 103, 101, 102,
101, 98, 98, 99, 99, 98, 98, 96, 97, 96, 95, 95, 93, 92, 92, 90, 91, 91, 89, 89,
89, 88, 87, 87, 86, 86, 86, 85, 83, 81, 81, 81, 81, 81, 79, 80, 78, 78, 79, 77,
76, 76, 73, 73, 74, 72, 71, 72, 69, 68, 68, 67, 67, 67, 66, 64, 64, 63, 64, 63,
61, 60, 60, 59, 59, 58, 56, 56, 55, 54, 55, 54, 51, 50, 51, 50, 50, 49, 46, 46,
46, 46, 45, 42, 41, 42, 42, 40, 39, 40, 36, 37, 37, 35, 34, 34, 31, 29, 31, 30,
31, 30, 27, 27, 27, 26, 25, 25, 22, 22, 21, 20, 21, 20, 17, 17, 18, 16, 12, 12,
13, 13, 12, 12, 8, 7, 7, 8, 7, 5, 4, 5, 5, 4, 4, 1, 0, 0, -1, -2, -2, -4, -6,
-5, -5, -6, -6, -9, -9, -10, -10, -13, -15, -14, -15, -15, -15, -16, -17, -18,
-19, -19, -20, -22, -23, -24, -24, -24, -26, -27, -27, -28, -28, -29, -31, -32,
-32, -33, -35, -36, -36, -37, -37, -38, -38, -38, -40, -41, -41, -43, -42, -43,
-45, -46, -46, -48, -47, -48, -49, -50, -51, -53, -52, -52, -53, -55, -57, -57,
-57, -57, -59, -59, -59, -62, -62, -62, -64, -64, -64, -67, -68, -68, -68, -69,
-69, -70, -70, -69, -72, -73, -73, -74, -75, -75, -76, -76, -77, -79, -80, -79,
-80, -81, -82, -82, -82, -83, -84, -88, -87, -87, -88, -87, -90, -89, -90, -91,
-91, -90, -92, -92, -93, -93, -94, -94, -96, -95, -96, -99, -99, -98, -100,
-100, -101, -101, -102, -104, -103, -103, -104, -105, -104, -105, -107, -106,
-107, -109, -109, -110, -109, -109, -110, -111, -111, -112, -113, -113, -112,
-113, -113, -113, -114, -115, -116, -115, -116, -116, -118, -117, -118, -117,
-117, -118, -119, -119, -119, -119, -119, -118, -117, -117, -117, -114, -114,
-114, -110, -111, -111, -110, -109, -104, -105, -106, -104, -100, -100, -98,
-95, -96, -95, -93, -92, -90, -84, -82, -83, -83, -83, -79, -75, -77, -76, -73,
-74, -70, -65, -67, -63, -62, -62, -60, -56, -57, -56, -53, -53, -49, -45, -46,
-45, -41, -37, -37, -36, -37, -35, -32, -32, -28, -25, -26, -25, -22, -22, -18,
-15, -17, -14, -12, -11, -8, -6, -7, -5, -2, -2, };