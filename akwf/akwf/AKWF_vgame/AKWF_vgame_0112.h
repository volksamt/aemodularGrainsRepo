#define DATA_LENGTH 512
#define DATA AKWF_vgame_0112

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 13, 17, 19, 19, 19, 17, 14, 13,
10, 9, 8, 8, 10, 12, 16, 19, 24, 28, 32, 34, 37, 38, 37, 36, 33, 29, 26, 25, 24,
25, 27, 29, 32, 37, 41, 46, 50, 52, 54, 52, 50, 47, 43, 39, 39, 40, 43, 49, 54,
60, 65, 66, 68, 66, 64, 61, 58, 55, 53, 52, 52, 52, 54, 57, 61, 65, 69, 74, 77,
79, 79, 77, 74, 69, 66, 62, 61, 60, 60, 62, 63, 67, 72, 76, 80, 85, 88, 88, 87,
83, 80, 75, 71, 69, 71, 74, 80, 86, 91, 95, 97, 95, 93, 90, 86, 82, 80, 79, 79,
81, 82, 83, 85, 89, 92, 96, 100, 102, 101, 100, 97, 93, 90, 86, 84, 83, 83, 84,
86, 88, 92, 96, 99, 102, 104, 105, 105, 103, 100, 95, 92, 90, 88, 88, 87, 89,
90, 93, 95, 100, 105, 109, 111, 112, 111, 106, 101, 96, 92, 92, 93, 96, 101,
106, 110, 114, 116, 114, 114, 111, 107, 104, 101, 99, 98, 97, 99, 101, 103, 107,
110, 115, 118, 120, 119, 116, 112, 108, 104, 101, 99, 98, 100, 101, 101, 101,
98, 95, 90, 83, 77, 74, 71, 71, 75, 78, 81, 82, 81, 76, 72, 66, 59, 54, 50, 46,
46, 46, 48, 48, 50, 51, 51, 51, 49, 47, 44, 39, 34, 30, 25, 21, 18, 17, 17, 18,
20, 22, 24, 25, 25, 25, 23, 20, 17, 14, 10, 4, -1, -4, -5, -7, -6, -5, -3, -1,
-1, 2, 2, 2, 0, -2, -5, -9, -15, -21, -25, -29, -30, -27, -25, -21, -18, -15,
-15, -17, -22, -25, -31, -36, -39, -41, -42, -42, -41, -40, -38, -37, -35, -34,
-34, -35, -36, -38, -41, -44, -48, -50, -53, -55, -56, -56, -56, -55, -52, -50,
-49, -47, -47, -47, -50, -52, -58, -63, -67, -71, -73, -73, -70, -68, -65, -61,
-58, -56, -56, -57, -59, -60, -65, -67, -72, -76, -80, -82, -83, -82, -79, -76,
-71, -68, -68, -68, -70, -73, -77, -80, -84, -85, -87, -87, -87, -87, -84, -82,
-81, -78, -77, -77, -77, -79, -81, -83, -85, -88, -90, -93, -94, -95, -94, -94,
-91, -91, -87, -85, -83, -82, -83, -86, -90, -95, -99, -104, -106, -105, -104,
-100, -96, -93, -90, -89, -91, -93, -95, -97, -100, -103, -104, -106, -106,
-106, -105, -104, -102, -100, -99, -97, -96, -96, -97, -98, -100, -102, -105,
-107, -110, -110, -110, -111, -110, -109, -106, -104, -101, -99, -97, -99, -99,
-101, -103, -105, -109, -111, -113, -113, -114, -113, -112, -109, -107, -105,
-103, -102, -102, -100, -99, -98, -96, -93, -93, -91, -90, -90, -91, -91, -92,
-91, -89, -87, -85, -81, -78, -74, -70, -66, -63, -60, -57, -58, -57, -59, -60,
-61, -61, -61, -59, -57, -55, -51, -48, -43, -40, -34, -31, -27, -27, -27, -29,
-32, -33, -35, -35, -32, -27, -21, -15, -10, -5, -3, -3, -4, -6, -8, -11, -12,
-12, -12, -10, -8, -4, 0, };