#define DATA_LENGTH 512
#define DATA AKWF_vgame_0130

const PROGMEM int8_t DATA[DATA_LENGTH] = {42, 74, 66, 70, 68, 69, 69, 69, 69,
69, 69, 68, 69, 69, 68, 71, 63, 97, 120, 113, 116, 115, 115, 114, 115, 115, 115,
114, 114, 114, 115, 116, 115, 115, 114, 115, 115, 114, 115, 116, 114, 115, 114,
115, 115, 115, 114, 114, 115, 114, 115, 114, 116, 112, 119, 101, 65, 69, 67, 68,
68, 69, 69, 68, 68, 68, 69, 67, 69, 67, 69, 67, 69, 67, 69, 67, 69, 67, 69, 67,
69, 69, 31, 18, 23, 21, 22, 21, 22, 21, 22, 21, 22, 21, 22, 22, 21, 21, 22, 21,
21, 21, 20, 22, 21, 22, 21, 21, 21, 22, 21, 22, 21, 21, 23, 17, 52, 71, 66, 68,
67, 68, 68, 67, 67, 68, 68, 68, 68, 68, 68, 67, 68, 68, 68, 68, 67, 68, 67, 68,
66, 70, 62, 85, 117, 112, 115, 113, 114, 114, 114, 114, 113, 114, 114, 114, 113,
115, 113, 114, 114, 114, 113, 115, 113, 115, 112, 115, 112, 117, 107, 68, 66,
68, 67, 67, 67, 67, 67, 67, 67, 66, 67, 66, 67, 66, 68, 66, 67, 66, 68, 65, 69,
62, 23, 20, 20, 20, 20, 21, 20, 21, 20, 22, 18, 25, 8, -29, -24, -27, -25, -27,
-26, -27, -25, -27, -25, -28, -21, -49, -78, -69, -75, -69, -79, -48, -22, -27,
-25, -27, -26, -27, -26, -27, -26, -26, -26, -26, -26, -26, -26, -26, -27, -26,
-26, -26, -26, -27, -24, -31, 11, 20, 27, 70, 65, 68, 65, 68, 65, 69, 64, 71,
63, -18, -29, -25, -28, -24, -29, -23, -32, -5, 24, 19, 21, 20, 20, 20, 21, 20,
21, 20, 21, 20, 21, 20, 20, 20, 20, 20, 22, 18, 25, 9, -28, -25, -27, -25, -26,
-26, -26, -26, -26, -26, -26, -26, -25, -26, -26, -27, -27, -26, -26, -26, -26,
-26, -25, -28, -21, -57, -76, -71, -74, -71, -73, -72, -73, -72, -73, -72, -73,
-72, -73, -72, -73, -71, -74, -70, -75, -67, -89, -120, -117, -119, -118, -119,
-118, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -120, -119, -118, -118, -84, -70, -73, -70, -72, -72, -73,
-71, -73, -72, -72, -73, -71, -73, -72, -73, -71, -72, -72, -73, -71, -71, -75,
-37, -22, -27, -24, -27, -25, -27, -25, -26, -25, -26, -25, -26, -25, -26, -24,
-25, -25, -26, -26, -26, -25, -26, -25, -25, -25, -25, -26, -25, -26, -25, -26,
-25, -25, -25, -26, -25, -26, -26, -25, -25, -26, -25, -24, -26, -21, -56, -75,
-69, -73, -71, -72, -71, -72, -71, -72, -70, -72, -71, -71, -71, -72, -71, -71,
-72, -70, -75, -66, -94, -120, -116, -120, -118, -118, -117, -118, -118, -118,
-117, -118, -117, -118, -118, -118, -117, -117, -118, -117, -118, -116, -119,
-117, -119, -115, -120, -105, -71, -71, -70, -71, -71, -71, -72, -71, -71, -71,
-70, -70, -71, -71, -71, -71, -72, -70, -75, -45, -20, -27, -22, -27, -23, -26,
-27, };