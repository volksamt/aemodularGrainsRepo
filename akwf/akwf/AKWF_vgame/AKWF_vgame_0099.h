#define DATA_LENGTH 512
#define DATA AKWF_vgame_0099

const PROGMEM int8_t DATA[DATA_LENGTH] = {39, 46, 42, 45, 43, 45, 43, 45, 43,
44, 43, 44, 44, 45, 43, 45, 44, 44, 44, 44, 44, 44, 45, 44, 44, 45, 45, 45, 43,
45, 45, 44, 43, 44, 44, 44, 44, 44, 45, 44, 44, 44, 44, 44, 44, 44, 44, 44, 44,
44, 44, 44, 44, 43, 44, 43, 44, 44, 44, 44, 43, 44, 43, 44, 44, 44, 44, 44, 43,
45, 44, 44, 44, 44, 44, 44, 44, 44, 44, 43, 44, 44, 44, 44, 44, 44, 43, 44, 43,
43, 43, 44, 44, 44, 44, 44, 43, 44, 43, 43, 43, 43, 44, 44, 43, 43, 43, 43, 43,
43, 43, 43, 43, 44, 44, 43, 43, 43, 43, 43, 43, 43, 43, 43, 43, 43, 43, 43, 43,
42, 42, 42, 43, 43, 43, 43, 43, 43, 43, 43, 43, 43, 42, 43, 43, 43, 44, 42, 43,
43, 43, 43, 43, 43, 43, 43, 43, 43, 43, 43, 42, 42, 43, 42, 43, 43, 43, 43, 43,
42, 42, 42, 43, 43, 42, 42, 43, 42, 42, 43, 43, 43, 43, 42, 42, 42, 43, 42, 43,
42, 43, 43, 42, 43, 43, 42, 42, 42, 43, 42, 42, 42, 42, 42, 43, 43, 42, 42, 42,
42, 43, 43, 42, 42, 41, 42, 42, 43, 42, 43, 41, 42, 42, 42, 42, 42, 42, 43, 42,
41, 41, 42, 42, 42, 43, 42, 42, 41, 43, 41, 43, 41, 43, 40, 42, 40, 43, 41, 43,
41, 43, 40, 44, 39, 44, 38, -39, -41, -38, -42, -39, -41, -38, -42, -38, -41,
-38, -41, -39, -41, -39, -40, -40, -40, -39, -40, -39, -39, -40, -40, -39, -40,
-40, -39, -40, -40, -40, -39, -40, -39, -40, -39, -40, -40, -40, -39, -40, -40,
-40, -39, -39, -40, -40, -40, -39, -40, -40, -40, -39, -39, -39, -40, -39, -40,
-39, -40, -40, -40, -39, -40, -40, -40, -39, -40, -39, -39, -40, -40, -39, -40,
-39, -40, -39, -40, -39, -39, -38, -40, -39, -40, -39, -40, -39, -40, -39, -39,
-40, -39, -39, -39, -39, -39, -39, -39, -40, -39, -39, -39, -39, -39, -39, -40,
-39, -38, -39, -40, -39, -39, -39, -40, -39, -38, -39, -39, -38, -39, -39, -39,
-38, -40, -39, -39, -38, -38, -39, -39, -39, -39, -39, -39, -38, -39, -38, -39,
-39, -39, -39, -39, -39, -38, -39, -39, -39, -39, -38, -38, -38, -39, -39, -39,
-38, -38, -39, -39, -39, -38, -38, -38, -39, -38, -38, -38, -39, -39, -38, -39,
-38, -38, -38, -38, -38, -39, -39, -38, -38, -38, -39, -38, -38, -39, -39, -38,
-38, -38, -38, -38, -38, -38, -38, -38, -38, -39, -37, -38, -39, -38, -38, -38,
-38, -39, -38, -38, -38, -38, -38, -39, -38, -38, -38, -38, -38, -38, -38, -37,
-38, -37, -39, -38, -39, -36, -40, -36, -42, -32, -50, -112, -119, -119, -119,
-118, -119, -118, -120, -119, -118, -120, -117, -123, -66, -30, -40, -34, -39,
-35, -39, -35, -39, -35, -39, -35, -40, -34, };