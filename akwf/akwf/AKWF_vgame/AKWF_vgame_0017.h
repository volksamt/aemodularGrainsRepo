#define DATA_LENGTH 512
#define DATA AKWF_vgame_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 5, 4, 6, 17, 19, 18, 18, 26, 30,
27, 30, 28, 38, 41, 42, 40, 46, 56, 53, 54, 56, 64, 64, 64, 62, 64, 75, 75, 74,
74, 81, 83, 82, 82, 85, 90, 88, 88, 88, 92, 94, 95, 93, 95, 100, 100, 100, 101,
105, 107, 106, 107, 106, 110, 111, 111, 111, 113, 115, 114, 115, 114, 113, 112,
113, 113, 113, 113, 113, 113, 112, 115, 114, 114, 114, 113, 112, 113, 113, 113,
110, 103, 101, 103, 102, 101, 102, 102, 101, 95, 96, 95, 95, 95, 89, 87, 87, 88,
81, 73, 76, 75, 72, 66, 67, 66, 66, 59, 58, 58, 59, 59, 50, 49, 49, 50, 43, 38,
39, 38, 35, 28, 31, 30, 32, 27, 23, 21, 23, 20, 11, 9, 10, 10, 5, 2, 4, 2, 3, 2,
1, 0, 0, -2, -5, -5, -4, -5, -11, -11, -12, -11, -11, -13, -13, -13, -13, -11,
-12, -11, -10, -11, -11, -12, -10, -11, -12, -13, -12, -13, -13, -14, -14, -15,
-15, -14, -13, -13, -12, -12, -12, -12, -13, -13, -13, -12, -13, -13, -12, -9,
-9, -10, -10, -5, -4, -5, -5, -5, -2, -2, -2, -2, 1, 4, 3, 3, 4, 8, 8, 9, 7, 8,
15, 14, 14, 14, 19, 21, 21, 20, 24, 28, 28, 27, 29, 37, 40, 39, 39, 40, 40, 40,
39, 40, 44, 45, 44, 45, 47, 51, 53, 52, 53, 52, 52, 53, 51, 53, 54, 54, 53, 54,
53, 53, 52, 52, 52, 52, 52, 52, 52, 51, 51, 50, 51, 49, 45, 44, 44, 45, 44, 44,
44, 45, 44, 41, 41, 42, 42, 40, 35, 33, 34, 33, 33, 34, 34, 34, 32, 28, 29, 29,
28, 25, 22, 23, 21, 22, 22, 21, 23, 22, 21, 20, 21, 21, 20, 18, 18, 17, 17, 18,
18, 18, 18, 17, 14, 14, 15, 13, 12, 10, 9, 9, 10, 9, 10, 10, 9, 8, 6, 6, 7, 6,
0, -4, -2, -4, -3, -2, -3, -3, -6, -9, -8, -9, -8, -10, -18, -21, -20, -22, -20,
-21, -21, -22, -25, -25, -25, -26, -25, -30, -35, -35, -34, -36, -34, -35, -34,
-37, -40, -39, -40, -39, -40, -47, -52, -52, -52, -52, -52, -52, -52, -57, -61,
-60, -61, -60, -62, -69, -70, -70, -70, -69, -70, -70, -71, -75, -76, -76, -76,
-80, -84, -87, -90, -88, -90, -88, -89, -88, -92, -97, -97, -97, -98, -101,
-105, -108, -108, -108, -108, -108, -108, -108, -110, -112, -111, -111, -113,
-115, -115, -116, -115, -116, -116, -116, -116, -116, -119, -119, -119, -118,
-119, -119, -117, -117, -118, -118, -117, -117, -117, -117, -116, -116, -116,
-115, -111, -110, -106, -106, -106, -107, -107, -107, -106, -101, -99, -100,
-101, -96, -91, -88, -85, -85, -85, -86, -84, -86, -84, -78, -78, -78, -78, -71,
-66, -61, -60, -61, -60, -60, -60, -62, -55, -50, -50, -52, -48, -38, -29, -21,
-23, -22, -22, -23, -22, -22, -13, -11, -11, -11, -4, };