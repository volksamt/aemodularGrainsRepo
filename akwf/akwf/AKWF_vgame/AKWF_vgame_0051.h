#define DATA_LENGTH 512
#define DATA AKWF_vgame_0051

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 6, 7, 12, 11, 11, 15, 18, 17,
19, 22, 21, 22, 28, 29, 28, 31, 36, 35, 36, 40, 40, 39, 44, 48, 46, 49, 52, 52,
52, 57, 57, 60, 64, 63, 63, 69, 70, 70, 71, 73, 73, 74, 80, 79, 79, 84, 90, 91,
91, 91, 90, 91, 95, 95, 94, 97, 101, 100, 101, 106, 110, 109, 109, 110, 109,
111, 113, 112, 113, 115, 115, 115, 116, 118, 118, 118, 118, 118, 118, 116, 116,
116, 114, 115, 114, 115, 113, 113, 112, 113, 113, 113, 111, 111, 111, 110, 109,
109, 109, 108, 107, 106, 106, 106, 107, 106, 104, 105, 104, 102, 101, 102, 101,
99, 99, 98, 99, 98, 98, 97, 98, 97, 96, 95, 96, 95, 92, 91, 90, 91, 90, 89, 89,
89, 89, 87, 87, 87, 86, 84, 85, 83, 82, 83, 83, 82, 79, 80, 79, 78, 78, 78, 77,
76, 76, 74, 72, 73, 73, 72, 72, 72, 69, 68, 69, 68, 65, 65, 65, 64, 64, 63, 63,
60, 60, 60, 59, 59, 58, 55, 56, 56, 54, 54, 54, 53, 50, 51, 50, 49, 49, 50, 46,
45, 46, 45, 42, 43, 44, 41, 41, 41, 40, 38, 39, 38, 35, 35, 35, 32, 32, 32, 31,
30, 30, 30, 28, 27, 28, 26, 24, 24, 23, 21, 20, 21, 20, 18, 18, 16, 16, 15, 15,
14, 14, 13, 9, 8, 8, 8, 8, 9, 7, 5, 5, 4, 2, 1, 2, 0, -3, -3, -4, -3, -3, -3,
-5, -6, -6, -8, -10, -10, -9, -13, -15, -14, -14, -15, -14, -15, -18, -17, -17,
-20, -21, -21, -21, -24, -26, -25, -26, -25, -26, -28, -26, -28, -31, -30, -30,
-33, -34, -36, -37, -36, -36, -36, -38, -38, -38, -40, -42, -41, -42, -45, -45,
-46, -45, -46, -45, -47, -49, -48, -49, -52, -53, -53, -53, -54, -57, -57, -57,
-57, -57, -59, -61, -61, -62, -62, -62, -65, -65, -66, -66, -67, -67, -66, -70,
-70, -70, -71, -72, -71, -72, -75, -74, -76, -76, -77, -75, -78, -79, -79, -80,
-80, -81, -81, -83, -85, -84, -86, -86, -85, -85, -87, -87, -87, -89, -90, -90,
-90, -92, -92, -92, -93, -93, -93, -97, -96, -96, -98, -99, -98, -99, -101,
-100, -100, -102, -102, -102, -103, -103, -103, -104, -105, -105, -105, -105,
-106, -106, -107, -110, -109, -110, -111, -111, -111, -111, -113, -113, -113,
-114, -114, -114, -114, -114, -114, -115, -116, -115, -116, -117, -117, -118,
-119, -119, -119, -119, -117, -118, -118, -117, -118, -117, -115, -114, -114,
-112, -111, -112, -111, -106, -103, -103, -103, -103, -103, -102, -98, -99, -98,
-95, -93, -95, -90, -83, -83, -83, -82, -83, -83, -77, -76, -77, -74, -70, -71,
-71, -64, -59, -59, -59, -59, -58, -54, -54, -54, -51, -49, -50, -47, -43, -40,
-37, -38, -38, -39, -35, -31, -32, -30, -26, -26, -26, -22, -20, -15, -14, -14,
-14, -14, -8, -7, -9, -6, -2, -3, -2, 0, 0, -1, };