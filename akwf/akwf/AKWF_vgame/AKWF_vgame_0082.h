#define DATA_LENGTH 512
#define DATA AKWF_vgame_0082

const PROGMEM int8_t DATA[DATA_LENGTH] = {35, 96, 110, 95, 107, 115, 111, 114,
113, 113, 112, 114, 112, 113, 113, 113, 113, 113, 113, 113, 113, 112, 113, 112,
112, 112, 112, 112, 113, 113, 113, 113, 112, 113, 112, 112, 113, 112, 112, 112,
113, 113, 113, 112, 113, 112, 112, 112, 112, 113, 112, 112, 112, 113, 112, 113,
112, 113, 113, 113, 112, 112, 112, 113, 116, 56, -29, -14, -1, -21, -14, -17,
-15, -17, -16, -17, -16, -17, -17, -16, -17, -17, -17, -16, -17, -16, -16, -16,
-17, -17, -17, -17, -16, -17, -17, -16, -16, -17, -17, -17, -17, -17, -17, -17,
-18, -17, -17, -17, -17, -16, -17, -17, -17, -17, -16, -18, -17, -17, -17, -17,
-18, -16, -17, -16, -17, -17, -17, -16, -17, -17, -17, -16, -16, -17, -16, -17,
-16, -17, -17, -17, -17, -17, -17, -16, -17, -17, -17, -17, -16, -16, -16, -16,
-16, -17, -17, -17, -17, -17, -16, -16, -16, -16, -17, -16, -16, -16, -16, -16,
-16, -17, -16, -16, -17, -17, -17, -17, -17, -16, -17, -17, -17, -17, -17, -16,
-17, -16, -17, -16, -16, -17, -16, -17, -16, -16, -17, -16, -17, -17, -16, -16,
-17, -16, -17, -16, -17, -17, -17, -16, -17, -16, -17, -17, -16, -16, -17, -17,
-17, -17, -17, -17, -17, -16, -17, -16, -16, -16, -17, -17, -16, -17, -16, -17,
-16, -16, -16, -17, -16, -16, -16, -16, -16, -17, -16, -17, -17, -17, -17, -16,
-16, -17, -17, -17, -17, -16, -16, -16, -16, -17, -16, -16, -16, -16, -17, -16,
-16, -16, -17, -16, -16, -16, -17, -17, -16, -16, -17, -16, -17, -16, -17, -16,
-16, -17, -16, -16, -16, -16, -17, -16, -16, -16, -16, -16, -17, -16, -16, -16,
-17, -16, -17, -16, -16, -16, -16, -17, -16, -16, -17, -17, -17, -17, -16, -17,
-16, -16, -16, -16, -16, -16, -16, -16, -16, -16, -16, -16, -16, -16, -16, -16,
-16, -16, -17, -17, -16, -17, -16, -16, -16, -17, -17, -17, -17, -16, -17, -16,
-17, -16, -17, -17, -16, -16, -16, -17, -16, -16, -16, -16, -16, -17, -17, -16,
-16, -16, -16, -16, -16, -17, -17, -17, -16, -16, -17, -16, -16, -16, -16, -16,
-16, -16, -16, -16, -16, -16, -16, -16, -15, -16, -16, -16, -16, -16, -16, -16,
-15, -16, -16, -16, -16, -17, -16, -16, -16, -16, -16, -17, -16, -16, -17, -16,
-16, -16, -16, -16, -17, -16, -17, -15, -17, -15, -16, -16, -16, -17, -16, -16,
-16, -16, -16, -16, -15, -16, -15, -17, -16, -16, -16, -16, -16, -16, -16, -16,
-16, -16, -16, -15, -16, -16, -16, -16, -16, -16, -16, -16, -15, -17, -16, -16,
-16, -16, -16, -16, -16, -16, -16, -15, -17, -15, -16, -16, -16, -16, -16, -16,
-16, -16, -16, -16, -16, -16, -16, -16, -16, -16, -15, -15, -15, -17, -15, -16,
-16, -17, -15, -16, -15, -16, -15, -17, -15, -16, -16, -16, -16, -17, -16, -16,
-17, -15, -17, -14, -20, 2, -17, -25, };