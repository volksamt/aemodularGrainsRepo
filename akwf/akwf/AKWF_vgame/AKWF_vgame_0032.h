#define DATA_LENGTH 512
#define DATA AKWF_vgame_0032

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 7, 5, 11, 22, 29, 36, 34, 35,
35, 35, 35, 35, 48, 52, 50, 52, 51, 60, 71, 71, 70, 71, 71, 70, 71, 71, 72, 78,
77, 77, 77, 83, 86, 85, 85, 85, 85, 86, 86, 85, 89, 92, 89, 90, 89, 92, 96, 95,
95, 96, 97, 96, 96, 97, 96, 98, 98, 98, 98, 98, 98, 98, 98, 98, 101, 103, 103,
103, 104, 107, 106, 106, 107, 115, 115, 114, 114, 114, 118, 120, 119, 119, 119,
120, 119, 120, 114, 108, 109, 109, 109, 110, 105, 101, 101, 103, 98, 87, 87, 87,
77, 75, 76, 76, 76, 76, 76, 69, 67, 67, 68, 64, 62, 63, 55, 57, 57, 56, 56, 56,
55, 49, 50, 49, 51, 47, 42, 31, 19, 21, 21, 21, 21, 20, 22, 10, 7, 8, 8, 4, -5,
-7, -11, -9, -10, -10, -11, -9, -10, -12, -11, -12, -12, -11, -14, -18, -17,
-18, -18, -18, -18, -18, -17, -23, -27, -25, -26, -29, -47, -53, -53, -54, -52,
-53, -53, -53, -53, -67, -71, -69, -70, -67, -78, -81, -81, -81, -81, -84, -83,
-84, -83, -82, -82, -82, -81, -82, -81, -81, -81, -79, -79, -79, -78, -79, -79,
-77, -75, -77, -75, -76, -75, -76, -75, -77, -73, -68, -69, -69, -70, -68, -58,
-60, -60, -47, -42, -44, -43, -43, -45, -30, -26, -28, -28, -19, -6, -13, -8, 2,
4, 2, 4, 2, 5, 15, 14, 14, 15, 14, 20, 18, 22, 25, 24, 24, 24, 24, 24, 25, 26,
26, 25, 26, 25, 26, 25, 25, 26, 25, 26, 25, 26, 26, 26, 25, 26, 26, 24, 22, 18,
17, 18, 17, 18, 17, 18, 14, 7, 9, 8, 9, 6, -2, -3, -4, -3, -4, -3, -3, -3, -3,
-2, -2, -2, -2, -2, -2, -3, -3, -3, -3, -4, -3, -4, -4, -11, -9, -10, -9, -11,
-19, -18, -19, -18, -30, -34, -31, -33, -31, -38, -41, -40, -40, -42, -46, -44,
-46, -44, -45, -47, -47, -47, -47, -50, -50, -49, -50, -54, -56, -54, -54, -55,
-58, -60, -60, -59, -59, -59, -60, -59, -59, -57, -57, -57, -57, -57, -58, -59,
-60, -62, -61, -61, -60, -61, -62, -61, -61, -60, -61, -62, -60, -59, -60, -59,
-60, -59, -58, -58, -58, -57, -58, -58, -58, -59, -58, -56, -56, -57, -56, -56,
-55, -55, -53, -53, -53, -53, -53, -54, -52, -50, -50, -49, -50, -49, -47, -41,
-35, -36, -35, -35, -35, -36, -35, -31, -26, -28, -27, -27, -24, -20, -20, -20,
-20, -19, -20, -18, -19, -19, -17, -17, -17, -18, -16, -16, -16, -16, -17, -16,
-16, -16, -16, -17, -16, -16, -15, -15, -17, -18, -18, -18, -19, -19, -20, -20,
-20, -19, -21, -21, -21, -21, -21, -23, -23, -23, -22, -23, -23, -23, -22, -22,
-23, -23, -23, -23, -23, -24, -24, -25, -25, -25, -25, -25, -24, -24, -24, -24,
-25, -23, -21, -21, -22, -20, -22, -18, -14, -14, -15, -12, -4, -3, -4, };