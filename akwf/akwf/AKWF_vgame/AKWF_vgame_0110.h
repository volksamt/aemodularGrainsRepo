#define DATA_LENGTH 512
#define DATA AKWF_vgame_0110

const PROGMEM int8_t DATA[DATA_LENGTH] = {53, 53, 49, 53, 50, 53, 50, 52, 49,
52, 51, 52, 51, 52, 50, 51, 50, 52, 52, 51, 51, 50, 51, 51, 52, 50, 51, 50, 51,
51, 51, 50, 52, 51, 51, 51, 51, 51, 52, 52, 50, 52, 51, 51, 51, 51, 51, 51, 52,
51, 51, 50, 50, 51, 50, 51, 51, 51, 51, 51, 50, 51, 51, 51, 51, 51, 50, 51, 51,
50, 51, 50, 50, 50, 51, 50, 51, 50, 50, 51, 51, 50, 51, 50, 50, 50, 50, 50, 51,
50, 50, 50, 50, 50, 50, 50, 51, 50, 51, 51, 50, 51, 50, 50, 50, 50, 50, 51, 50,
50, 50, 50, 50, 50, 50, 50, 50, 50, 50, 50, 49, 50, 50, 49, 50, 49, 49, 50, 50,
50, 50, 50, 49, 50, 50, 49, 50, 49, 50, 50, 50, 50, 50, 50, 50, 50, 49, 50, 50,
49, 50, 50, 50, 49, 50, 49, 49, 49, 49, 49, 49, 49, 50, 50, 49, 50, 49, 50, 50,
49, 50, 50, 49, 49, 49, 48, 49, 49, 49, 50, 49, 49, 49, 49, 49, 49, 49, 48, 49,
49, 49, 49, 49, 49, 50, 49, 49, 49, 49, 48, 48, 49, 49, 49, 49, 49, 49, 49, 49,
48, 49, 48, 48, 48, 49, 48, 48, 49, 49, 48, 48, 49, 48, 49, 48, 48, 49, 49, 49,
49, 49, 48, 48, 48, 47, 49, 47, 49, 47, 49, 48, 48, 48, 48, 48, 48, 48, 48, 48,
48, 48, 48, 49, 45, 58, 1, -44, -33, -38, -35, -37, -36, -36, -35, -38, -36,
-37, -37, -36, -37, -36, -37, -37, -37, -37, -37, -36, -37, -36, -37, -35, -37,
-37, -36, -36, -37, -36, -37, -36, -37, -36, -36, -37, -36, -35, -37, -36, -37,
-36, -36, -37, -36, -35, -36, -35, -37, -36, -36, -36, -36, -36, -37, -37, -36,
-36, -35, -36, -36, -36, -37, -36, -36, -36, -36, -36, -35, -36, -36, -36, -35,
-37, -36, -36, -36, -35, -36, -36, -36, -36, -36, -36, -35, -36, -36, -36, -36,
-35, -36, -36, -36, -36, -35, -35, -35, -36, -36, -36, -36, -35, -35, -36, -36,
-35, -36, -36, -36, -36, -35, -36, -36, -36, -36, -35, -35, -35, -35, -35, -36,
-36, -36, -35, -36, -35, -35, -35, -35, -35, -35, -35, -36, -35, -35, -35, -35,
-35, -35, -35, -35, -35, -36, -36, -36, -36, -35, -35, -35, -36, -35, -35, -34,
-35, -35, -35, -35, -35, -35, -35, -35, -35, -36, -35, -36, -35, -36, -35, -35,
-35, -36, -36, -35, -35, -35, -35, -35, -36, -35, -34, -34, -36, -34, -35, -35,
-35, -34, -35, -34, -35, -35, -35, -35, -35, -35, -35, -34, -35, -35, -34, -35,
-34, -36, -33, -36, -32, -38, -32, -40, -24, -72, -128, -114, -123, -116, -120,
-118, -120, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -120, -119, -119, -118, -119, -118, -119, -118, -119, -118, -119, -117,
-120, -117, -119, -117, -120, -117, -120, -117, -120, -117, -118, -115, -17, };