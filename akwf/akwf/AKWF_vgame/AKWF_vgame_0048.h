#define DATA_LENGTH 512
#define DATA AKWF_vgame_0048

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 6, 7, 5, 8, 14, 14, 14, 15, 21, 23,
22, 23, 21, 28, 30, 31, 29, 33, 41, 38, 40, 38, 42, 47, 46, 46, 47, 55, 56, 55,
56, 60, 63, 61, 63, 62, 62, 68, 72, 71, 71, 73, 81, 78, 80, 84, 86, 85, 86, 86,
86, 92, 95, 93, 95, 93, 99, 100, 101, 109, 107, 109, 108, 108, 108, 109, 111,
111, 111, 112, 116, 116, 117, 117, 118, 117, 117, 118, 118, 117, 115, 117, 115,
116, 115, 115, 113, 113, 112, 114, 113, 112, 113, 113, 112, 108, 108, 107, 108,
107, 107, 105, 106, 106, 106, 106, 107, 105, 103, 103, 103, 103, 103, 100, 98,
99, 98, 98, 99, 98, 98, 98, 96, 96, 95, 95, 94, 91, 90, 90, 91, 90, 91, 90, 90,
91, 88, 87, 87, 88, 87, 85, 84, 85, 84, 83, 81, 81, 80, 82, 80, 78, 77, 78, 78,
75, 75, 74, 75, 75, 72, 71, 71, 72, 70, 68, 68, 68, 68, 65, 66, 65, 66, 65, 60,
61, 60, 61, 60, 57, 57, 58, 55, 54, 55, 54, 54, 54, 52, 50, 52, 51, 51, 49, 46,
46, 43, 44, 43, 43, 43, 43, 42, 40, 40, 40, 40, 37, 35, 35, 31, 32, 31, 32, 32,
32, 30, 26, 28, 27, 27, 27, 24, 22, 20, 20, 21, 21, 21, 20, 21, 18, 16, 16, 16,
14, 12, 9, 7, 8, 8, 9, 8, 9, 8, 5, 5, 5, 5, 5, 3, -3, -3, -3, -3, -4, -4, -4,
-3, -5, -6, -7, -6, -7, -11, -15, -15, -15, -14, -14, -15, -14, -14, -17, -19,
-18, -19, -18, -20, -23, -22, -22, -22, -26, -27, -27, -27, -26, -30, -31, -30,
-30, -32, -34, -33, -33, -32, -36, -38, -38, -38, -39, -42, -41, -41, -41, -44,
-45, -44, -45, -45, -48, -49, -49, -49, -49, -51, -53, -52, -53, -56, -56, -55,
-56, -55, -57, -59, -59, -59, -58, -63, -64, -63, -65, -67, -66, -67, -66, -67,
-68, -70, -69, -70, -69, -70, -74, -73, -76, -76, -75, -76, -76, -77, -75, -79,
-80, -79, -79, -79, -81, -83, -86, -85, -86, -86, -85, -87, -85, -87, -89, -90,
-89, -90, -91, -93, -95, -95, -95, -96, -95, -96, -95, -96, -99, -98, -98, -98,
-99, -102, -104, -103, -104, -102, -104, -103, -104, -103, -105, -105, -104,
-105, -107, -109, -109, -110, -109, -109, -109, -110, -109, -110, -113, -113,
-112, -113, -113, -114, -114, -115, -115, -115, -116, -116, -116, -116, -116,
-118, -118, -117, -118, -119, -119, -119, -117, -117, -118, -117, -117, -118,
-114, -112, -114, -113, -111, -107, -109, -106, -109, -105, -99, -101, -99,
-101, -98, -94, -94, -94, -88, -85, -86, -85, -85, -86, -81, -79, -80, -80, -76,
-71, -73, -70, -64, -63, -64, -63, -64, -62, -55, -55, -56, -56, -56, -48, -48,
-46, -39, -40, -39, -41, -39, -41, -36, -31, -31, -33, -31, -24, -25, -19, -15,
-16, -15, -17, -15, -17, -16, -9, -6, -8, -8, -1, };