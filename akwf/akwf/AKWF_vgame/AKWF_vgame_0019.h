#define DATA_LENGTH 512
#define DATA AKWF_vgame_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 11, 9, 11, 20, 22, 19, 26, 35, 37,
36, 37, 37, 37, 43, 47, 45, 50, 61, 65, 63, 64, 70, 72, 71, 72, 71, 72, 76, 77,
75, 81, 86, 84, 86, 90, 95, 93, 94, 94, 94, 97, 97, 96, 99, 100, 100, 102, 105,
108, 110, 109, 110, 109, 110, 113, 112, 113, 114, 114, 115, 114, 114, 112, 112,
113, 113, 113, 112, 112, 113, 113, 114, 114, 114, 113, 113, 111, 111, 111, 111,
110, 104, 105, 104, 103, 101, 103, 100, 97, 93, 89, 91, 91, 90, 83, 85, 83, 78,
75, 77, 72, 70, 70, 64, 63, 63, 65, 59, 54, 57, 54, 49, 48, 50, 43, 42, 40, 35,
35, 35, 36, 29, 28, 30, 25, 21, 23, 22, 15, 16, 11, 8, 8, 9, 6, 3, 4, 3, 0, 0,
-1, -4, -3, -4, -5, -7, -5, -8, -12, -11, -11, -13, -13, -13, -13, -12, -13,
-12, -11, -11, -11, -11, -12, -11, -12, -13, -13, -13, -14, -14, -13, -15, -14,
-15, -14, -13, -12, -12, -13, -13, -12, -13, -15, -14, -14, -13, -10, -9, -10,
-9, -9, -8, -7, -8, -7, -3, -4, -3, -1, 1, 2, 1, 1, 1, 3, 7, 6, 6, 9, 12, 12,
12, 18, 19, 20, 19, 19, 18, 22, 26, 25, 26, 29, 31, 30, 32, 39, 40, 39, 40, 39,
39, 41, 44, 42, 43, 46, 46, 48, 49, 53, 52, 52, 53, 52, 53, 54, 54, 54, 54, 55,
53, 54, 54, 52, 53, 53, 52, 52, 50, 50, 50, 50, 49, 49, 48, 47, 47, 45, 46, 46,
46, 44, 42, 43, 42, 41, 41, 41, 40, 38, 36, 35, 35, 35, 33, 29, 30, 29, 28, 28,
29, 27, 26, 25, 23, 24, 23, 23, 22, 23, 22, 21, 20, 20, 21, 20, 21, 19, 17, 18,
17, 16, 16, 15, 16, 14, 12, 13, 12, 11, 11, 10, 10, 10, 10, 9, 8, 8, 8, 5, 5, 6,
3, 2, 1, -2, -2, -2, -3, -3, -3, -4, -8, -9, -8, -12, -13, -12, -15, -18, -17,
-17, -22, -23, -26, -26, -26, -26, -25, -28, -28, -28, -31, -32, -31, -33, -37,
-36, -37, -40, -41, -39, -42, -45, -45, -45, -48, -50, -49, -52, -55, -53, -56,
-61, -60, -62, -65, -63, -64, -68, -70, -70, -70, -71, -69, -72, -75, -74, -75,
-79, -80, -79, -82, -88, -91, -91, -91, -90, -90, -94, -96, -94, -96, -100,
-100, -99, -104, -108, -108, -108, -108, -109, -108, -111, -110, -111, -112,
-113, -113, -112, -115, -118, -117, -117, -117, -118, -119, -119, -119, -119,
-119, -119, -119, -118, -118, -118, -117, -118, -117, -117, -118, -118, -118,
-114, -115, -115, -112, -110, -107, -106, -107, -106, -107, -103, -101, -102,
-100, -96, -97, -96, -92, -90, -85, -86, -85, -86, -85, -78, -78, -79, -74, -73,
-72, -67, -67, -64, -62, -61, -63, -60, -53, -54, -54, -48, -44, -47, -42, -36,
-37, -28, -25, -25, -26, -21, -15, -17, -15, -7, -7, -7, };