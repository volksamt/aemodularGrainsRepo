#define DATA_LENGTH 512
#define DATA AKWF_vgame_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 11, 14, 16, 20, 23, 24, 27,
31, 33, 34, 38, 41, 43, 47, 48, 51, 54, 55, 60, 61, 63, 65, 70, 71, 73, 74, 75,
76, 79, 84, 84, 84, 86, 88, 90, 90, 91, 93, 94, 93, 94, 95, 98, 100, 101, 102,
104, 106, 108, 109, 109, 110, 111, 113, 113, 115, 114, 115, 114, 114, 115, 114,
113, 112, 113, 113, 113, 112, 113, 112, 115, 115, 114, 113, 113, 112, 111, 111,
109, 107, 105, 104, 103, 101, 100, 100, 100, 97, 95, 95, 94, 92, 89, 86, 83, 81,
78, 76, 74, 72, 71, 69, 66, 64, 63, 62, 59, 57, 54, 53, 50, 47, 45, 43, 43, 41,
38, 36, 33, 32, 29, 28, 26, 25, 21, 18, 17, 15, 14, 10, 8, 8, 6, 4, 3, 1, 0, 0,
-1, -2, -2, -2, -5, -6, -7, -7, -9, -11, -11, -11, -13, -13, -12, -13, -13, -11,
-11, -11, -11, -11, -12, -11, -13, -13, -12, -14, -14, -14, -15, -15, -15, -15,
-14, -15, -15, -14, -14, -13, -13, -12, -12, -13, -14, -15, -14, -13, -12, -12,
-10, -9, -10, -9, -7, -5, -4, -4, -2, -1, 1, 1, 2, 2, 4, 4, 5, 8, 8, 10, 11, 12,
14, 14, 16, 18, 19, 19, 20, 23, 25, 26, 29, 31, 31, 31, 33, 36, 36, 38, 39, 40,
41, 42, 42, 44, 46, 46, 47, 48, 49, 49, 49, 52, 51, 54, 54, 54, 54, 54, 54, 54,
55, 54, 54, 53, 53, 52, 53, 53, 51, 51, 51, 50, 50, 50, 49, 48, 47, 46, 45, 45,
45, 44, 44, 43, 41, 39, 39, 38, 38, 36, 37, 35, 34, 33, 32, 31, 30, 29, 27, 26,
27, 26, 26, 24, 23, 23, 22, 22, 22, 22, 21, 21, 21, 21, 21, 20, 18, 19, 19, 18,
16, 16, 14, 14, 14, 14, 12, 13, 12, 11, 11, 10, 9, 10, 10, 9, 7, 7, 6, 3, 3, 3,
2, 1, 1, 0, -2, -2, -4, -4, -5, -7, -9, -9, -11, -12, -13, -15, -17, -19, -19,
-20, -22, -23, -24, -25, -25, -26, -28, -29, -29, -30, -32, -31, -34, -36, -38,
-39, -39, -40, -42, -43, -43, -43, -45, -48, -49, -52, -51, -54, -55, -58, -59,
-61, -64, -63, -65, -65, -66, -67, -67, -69, -69, -71, -72, -73, -76, -77, -78,
-79, -82, -83, -85, -85, -87, -90, -90, -91, -93, -96, -98, -98, -99, -101,
-101, -103, -103, -105, -107, -108, -109, -110, -111, -111, -112, -113, -112,
-114, -115, -114, -115, -116, -117, -117, -117, -117, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -118, -117, -118, -117, -118, -116, -116, -115,
-113, -113, -112, -111, -109, -108, -107, -105, -103, -102, -101, -101, -99,
-95, -95, -93, -91, -91, -90, -87, -86, -84, -81, -79, -78, -77, -72, -72, -71,
-69, -68, -65, -64, -61, -58, -58, -57, -54, -50, -46, -45, -41, -39, -36, -33,
-30, -28, -24, -20, -17, -16, -13, -9, -7, -4, -1, };