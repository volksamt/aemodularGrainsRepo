#define DATA_LENGTH 512
#define DATA AKWF_vgame_0043

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 16, 15, 14, 17, 27, 28, 26, 28, 26,
27, 27, 28, 26, 29, 26, 30, 38, 47, 57, 56, 56, 56, 56, 57, 56, 58, 56, 56, 56,
58, 55, 64, 70, 68, 70, 69, 69, 69, 69, 69, 83, 84, 83, 84, 83, 93, 95, 95, 95,
95, 95, 95, 95, 94, 96, 93, 104, 109, 109, 117, 115, 116, 116, 116, 116, 116,
116, 116, 116, 116, 117, 114, 117, 119, 119, 120, 119, 119, 119, 119, 117, 116,
116, 116, 115, 117, 114, 113, 113, 112, 112, 113, 113, 113, 112, 113, 112, 110,
110, 109, 106, 104, 105, 104, 105, 105, 104, 104, 105, 104, 104, 105, 105, 100,
95, 94, 94, 95, 95, 95, 95, 94, 96, 95, 95, 94, 95, 95, 90, 91, 90, 90, 90, 90,
90, 89, 90, 86, 85, 85, 85, 82, 79, 80, 80, 81, 81, 80, 81, 80, 81, 80, 81, 78,
73, 71, 69, 70, 69, 69, 69, 69, 68, 69, 69, 70, 69, 70, 69, 63, 63, 63, 63, 63,
62, 63, 63, 64, 59, 56, 57, 57, 55, 49, 50, 50, 50, 50, 49, 50, 50, 51, 50, 51,
49, 43, 40, 36, 37, 37, 37, 37, 37, 37, 38, 38, 37, 37, 37, 37, 32, 29, 31, 30,
31, 31, 30, 31, 30, 24, 24, 24, 25, 24, 19, 17, 18, 17, 18, 18, 18, 18, 18, 17,
18, 13, 11, 11, 3, 3, 3, 3, 3, 3, 3, 3, 4, 3, 4, 2, 4, 1, -4, -3, -3, -3, -2,
-4, -3, -8, -10, -9, -10, -10, -10, -14, -17, -15, -17, -17, -16, -16, -16, -17,
-15, -19, -23, -22, -23, -27, -30, -28, -29, -28, -30, -29, -29, -29, -29, -28,
-29, -29, -36, -43, -44, -44, -43, -44, -43, -43, -43, -43, -44, -43, -44, -43,
-45, -48, -48, -48, -49, -49, -48, -48, -49, -48, -54, -55, -54, -54, -58, -62,
-61, -61, -61, -61, -62, -62, -61, -62, -61, -61, -64, -67, -73, -75, -74, -75,
-73, -74, -73, -74, -73, -74, -74, -74, -74, -75, -78, -79, -79, -79, -78, -79,
-85, -85, -86, -85, -86, -86, -84, -87, -90, -89, -91, -90, -90, -91, -90, -90,
-90, -90, -91, -95, -95, -97, -100, -100, -100, -100, -100, -99, -100, -100,
-100, -100, -100, -99, -99, -104, -105, -104, -105, -105, -104, -104, -105,
-105, -108, -108, -108, -107, -108, -113, -112, -112, -113, -113, -112, -113,
-113, -112, -112, -115, -117, -116, -116, -119, -119, -118, -120, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -116, -111, -112, -112, -114, -113,
-113, -112, -113, -112, -113, -113, -112, -113, -104, -101, -103, -101, -101,
-101, -102, -101, -101, -102, -97, -88, -91, -88, -76, -75, -76, -75, -75, -76,
-76, -75, -76, -76, -75, -75, -75, -58, -48, -49, -48, -48, -48, -49, -48, -48,
-48, -48, -48, -48, -50, -42, -33, -36, -34, -36, -36, -35, -36, -37, -34, -23,
-22, -22, -23, -12, -6, -9, -8, -9, -7, -8, -8, -8, -7, -8, -8, };