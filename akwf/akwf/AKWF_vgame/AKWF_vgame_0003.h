#define DATA_LENGTH 512
#define DATA AKWF_vgame_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 3, 4, 5, 5, 6, 7, 8, 9, 10,
11, 11, 12, 13, 14, 14, 16, 16, 17, 17, 19, 20, 21, 21, 22, 22, 23, 24, 25, 27,
27, 28, 29, 30, 31, 31, 32, 33, 33, 35, 35, 36, 38, 39, 39, 40, 41, 41, 42, 43,
43, 45, 45, 46, 47, 48, 49, 50, 51, 51, 52, 53, 54, 54, 56, 56, 57, 58, 59, 59,
61, 61, 62, 64, 63, 64, 66, 66, 67, 68, 70, 70, 71, 71, 72, 73, 74, 75, 75, 76,
78, 78, 79, 79, 80, 81, 82, 82, 84, 84, 85, 87, 88, 88, 89, 90, 91, 92, 91, 93,
94, 95, 96, 96, 97, 98, 99, 100, 100, 102, 102, 104, 104, 105, 106, 106, 107,
108, 109, 109, 111, 111, 112, 113, 114, 114, 116, 116, 117, 118, 119, 119, 119,
118, 118, 118, 117, 117, 115, 114, 114, 112, 111, 110, 109, 106, 105, 103, 101,
99, 98, 96, 94, 92, 90, 88, 87, 84, 82, 80, 78, 77, 75, 73, 71, 70, 68, 66, 66,
64, 63, 60, 60, 59, 58, 56, 56, 55, 54, 53, 51, 51, 50, 49, 49, 47, 47, 46, 44,
45, 44, 43, 42, 41, 41, 41, 41, 39, 38, 38, 37, 36, 35, 35, 35, 34, 32, 32, 30,
30, 29, 29, 28, 27, 27, 25, 25, 23, 22, 21, 21, 21, 19, 19, 18, 17, 16, 15, 14,
13, 12, 11, 11, 9, 9, 8, 6, 6, 5, 4, 3, 2, 2, 1, -1, -1, -2, -2, -4, -5, -5, -6,
-7, -7, -9, -10, -10, -12, -12, -12, -13, -15, -15, -17, -18, -18, -19, -20,
-20, -22, -23, -23, -24, -24, -25, -26, -27, -28, -29, -29, -31, -31, -33, -33,
-34, -35, -36, -36, -37, -39, -40, -40, -40, -41, -41, -44, -44, -45, -46, -46,
-47, -48, -48, -49, -51, -52, -53, -53, -54, -54, -55, -56, -58, -59, -59, -59,
-60, -62, -62, -63, -64, -65, -66, -67, -68, -69, -68, -70, -71, -71, -72, -72,
-74, -74, -75, -77, -77, -78, -79, -80, -81, -81, -82, -82, -84, -85, -86, -87,
-87, -89, -88, -90, -91, -92, -92, -92, -94, -95, -95, -97, -97, -98, -98, -100,
-100, -101, -103, -103, -104, -105, -105, -106, -107, -109, -109, -110, -111,
-111, -112, -113, -115, -115, -116, -116, -117, -118, -118, -119, -118, -119,
-117, -117, -117, -116, -116, -115, -113, -113, -112, -110, -109, -107, -104,
-103, -102, -100, -97, -96, -94, -92, -91, -87, -86, -84, -82, -80, -78, -76,
-75, -73, -72, -70, -69, -67, -66, -64, -62, -61, -60, -59, -58, -57, -56, -54,
-54, -53, -52, -50, -49, -49, -48, -47, -47, -46, -46, -44, -44, -44, -42, -41,
-42, -40, -40, -39, -38, -38, -37, -37, -36, -35, -34, -33, -33, -31, -31, -30,
-29, -29, -28, -27, -27, -25, -24, -24, -23, -22, -21, -20, -20, -18, -18, -16,
-15, -14, -14, -13, -12, -12, -10, -9, -8, -8, -6, -6, -5, -4, -4, -2, -1, -1,
};