#define DATA_LENGTH 512
#define DATA AKWF_vgame_0070

const PROGMEM int8_t DATA[DATA_LENGTH] = {37, 116, 113, 103, 113, 110, 108, 111,
108, 110, 110, 108, 111, 109, 111, 108, 109, 110, 108, 110, 110, 109, 109, 110,
110, 109, 110, 109, 109, 110, 110, 109, 110, 110, 109, 110, 109, 110, 109, 109,
109, 109, 110, 110, 109, 109, 109, 109, 109, 109, 109, 109, 109, 110, 108, 109,
109, 109, 109, 109, 109, 110, 110, 109, 109, 109, 110, 109, 109, 109, 109, 109,
108, 109, 109, 108, 109, 110, 109, 109, 110, 108, 109, 108, 108, 109, 109, 109,
109, 109, 109, 109, 109, 109, 109, 109, 109, 108, 109, 109, 108, 109, 108, 108,
109, 109, 109, 108, 109, 108, 108, 108, 109, 108, 109, 109, 108, 109, 109, 108,
108, 108, 109, 107, 110, 102, 113, 111, -5, -50, -31, -37, -37, -36, -36, -38,
-36, -37, -36, -38, -36, -37, -36, -36, -36, -37, -36, -37, -37, -36, -36, -36,
-37, -36, -37, -36, -37, -37, -37, -36, -37, -37, -38, -37, -37, -38, -37, -38,
-37, -37, -37, -38, -37, -38, -38, -37, -37, -38, -37, -38, -38, -37, -37, -38,
-35, -37, -36, -36, -37, -38, -36, -37, -38, -38, -37, -37, -38, -38, -37, -38,
-37, -36, -37, -37, -37, -38, -37, -37, -38, -36, -37, -37, -36, -37, -37, -36,
-37, -36, -37, -37, -37, -37, -37, -38, -36, -38, -37, -37, -37, -37, -38, -36,
-37, -37, -37, -36, -37, -37, -37, -37, -36, -36, -37, -37, -37, -37, -37, -37,
-37, -36, -37, -36, -38, -37, -36, -37, -37, -36, -38, -37, -36, -38, -38, -35,
-37, -37, -36, -38, -37, -36, -37, -38, -36, -37, -38, -35, -37, -36, -35, -38,
-36, -36, -37, -36, -37, -36, -37, -37, -36, -36, -36, -35, -38, -37, -36, -37,
-37, -36, -35, -36, -36, -38, -36, -37, -36, -36, -37, -37, -36, -38, -36, -37,
-38, -35, -37, -37, -36, -36, -36, -36, -36, -37, -37, -36, -37, -38, -35, -38,
-36, -37, -37, -36, -38, -37, -37, -37, -36, -36, -38, -36, -36, -36, -37, -35,
-36, -37, -35, -37, -37, -35, -37, -36, -35, -37, -36, -36, -37, -36, -35, -37,
-36, -36, -38, -36, -37, -36, -36, -37, -36, -35, -37, -36, -36, -37, -36, -36,
-36, -35, -36, -37, -35, -36, -36, -37, -36, -36, -37, -35, -37, -37, -35, -37,
-36, -35, -36, -36, -35, -36, -36, -35, -37, -36, -36, -36, -35, -36, -36, -36,
-37, -37, -35, -37, -36, -36, -36, -35, -36, -36, -36, -36, -36, -36, -35, -37,
-36, -36, -35, -37, -36, -35, -37, -37, -36, -35, -36, -36, -36, -37, -35, -36,
-37, -34, -35, -36, -37, -34, -37, -36, -35, -37, -36, -35, -36, -36, -35, -37,
-36, -36, -36, -36, -35, -36, -35, -36, -36, -35, -36, -35, -36, -35, -36, -36,
-36, -35, -36, -36, -34, -35, -36, -35, -35, -35, -35, -35, -35, -35, -35, -35,
-35, -35, -35, -36, -35, -35, -34, -35, -35, -36, -35, -35, -35, -35, -35, -35,
-35, -35, -35, -35, -37, -27, -46, -24, };