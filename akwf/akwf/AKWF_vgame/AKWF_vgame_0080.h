#define DATA_LENGTH 512
#define DATA AKWF_vgame_0080

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 14, 26, 35, 42, 46, 47, 48, 47, 45,
43, 40, 37, 36, 34, 33, 32, 32, 32, 32, 32, 31, 32, 32, 34, 36, 36, 37, 38, 37,
37, 38, 37, 37, 36, 35, 34, 34, 33, 34, 34, 34, 35, 35, 35, 35, 36, 36, 38, 38,
36, 35, 36, 35, 35, 35, 34, 34, 34, 33, 35, 36, 35, 35, 36, 36, 35, 36, 36, 35,
35, 35, 36, 35, 34, 34, 34, 34, 34, 36, 35, 35, 36, 35, 35, 35, 35, 36, 35, 35,
36, 36, 34, 34, 34, 35, 35, 35, 36, 35, 36, 35, 35, 36, 36, 35, 35, 35, 36, 35,
34, 33, 35, 36, 35, 35, 35, 35, 35, 36, 36, 36, 35, 35, 35, 34, 34, 32, 33, 33,
33, 33, 33, 33, 33, 33, 35, 36, 35, 35, 35, 35, 34, 33, 33, 34, 34, 34, 33, 33,
34, 34, 33, 33, 34, 33, 34, 33, 33, 33, 33, 33, 33, 33, 34, 34, 33, 33, 33, 33,
33, 33, 33, 33, 33, 33, 32, 33, 33, 34, 33, 33, 32, 32, 33, 33, 33, 33, 32, 33,
33, 33, 33, 34, 33, 33, 32, 32, 33, 33, 33, 33, 33, 33, 32, 32, 32, 33, 33, 34,
33, 32, 33, 32, 33, 33, 33, 33, 33, 33, 33, 32, 33, 33, 33, 33, 33, 33, 32, 34,
35, 34, 34, 33, 33, 33, 32, 33, 33, 33, 32, 32, 33, 32, 33, 32, 33, 33, 33, 33,
34, 35, 34, 34, 35, 35, 35, 35, 35, 35, 35, 35, 35, 34, 34, 34, 34, 34, 35, 34,
34, 34, 34, 34, 34, 34, 34, 35, 34, 34, 35, 34, 34, 35, 35, 34, 33, 34, 35, 35,
34, 34, 34, 34, 34, 35, 34, 34, 34, 34, 34, 34, 34, 34, 34, 34, 34, 35, 35, 34,
34, 32, 33, 32, 32, 32, 34, 34, 35, 35, 34, 34, 35, 34, 35, 35, 34, 33, 34, 34,
35, 34, 33, 32, 33, 34, 35, 34, 34, 35, 34, 34, 34, 34, 33, 34, 34, 34, 35, 35,
34, 34, 35, 34, 34, 34, 35, 33, 32, 33, 32, 31, 28, 28, 29, 29, 30, 32, 34, 36,
40, 44, 47, 48, 48, 46, 42, 36, 27, 15, 2, -13, -27, -43, -57, -70, -83, -93,
-103, -108, -113, -114, -117, -117, -115, -113, -109, -108, -105, -104, -101,
-98, -98, -96, -95, -94, -95, -97, -99, -102, -104, -105, -105, -107, -109,
-110, -108, -106, -105, -104, -102, -99, -101, -99, -98, -100, -100, -102, -103,
-104, -106, -105, -105, -106, -106, -105, -103, -103, -102, -100, -100, -100,
-100, -102, -102, -102, -103, -103, -105, -106, -106, -105, -106, -106, -103,
-102, -101, -101, -100, -100, -100, -100, -99, -101, -102, -103, -104, -105,
-104, -105, -104, -106, -104, -102, -102, -101, -99, -99, -99, -99, -101, -102,
-102, -105, -106, -107, -107, -106, -105, -102, -100, -98, -96, -93, -93, -95,
-96, -101, -105, -110, -114, -118, -119, -120, -117, -111, -102, -90, -77, -61,
-37, -10, };