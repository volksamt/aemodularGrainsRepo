#define DATA_LENGTH 512
#define DATA AKWF_vgame_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 1, 3, 4, 5, 6, 7, 7, 9, 9,
11, 11, 12, 14, 15, 15, 16, 17, 18, 20, 20, 21, 22, 22, 24, 25, 25, 27, 28, 29,
29, 31, 31, 32, 33, 34, 35, 35, 37, 38, 39, 40, 40, 42, 42, 43, 44, 46, 46, 47,
48, 49, 50, 51, 52, 53, 54, 54, 56, 56, 57, 58, 59, 60, 61, 62, 63, 64, 65, 65,
67, 68, 69, 70, 70, 71, 73, 73, 74, 75, 76, 78, 78, 79, 80, 80, 81, 83, 83, 84,
86, 86, 87, 88, 89, 91, 91, 93, 93, 93, 95, 95, 97, 98, 98, 100, 101, 101, 103,
104, 104, 105, 106, 107, 108, 109, 110, 112, 112, 112, 113, 115, 115, 116, 117,
118, 119, 118, 117, 116, 116, 114, 114, 113, 112, 111, 109, 108, 108, 107, 106,
105, 104, 103, 102, 102, 101, 100, 99, 98, 98, 96, 95, 94, 94, 92, 91, 90, 89,
89, 88, 86, 86, 84, 84, 82, 82, 82, 79, 79, 78, 77, 76, 75, 75, 73, 73, 72, 70,
69, 69, 68, 67, 66, 66, 65, 63, 62, 62, 60, 59, 58, 57, 56, 56, 54, 54, 54, 53,
51, 49, 49, 49, 47, 46, 45, 45, 44, 43, 42, 41, 40, 39, 38, 37, 37, 36, 34, 34,
32, 32, 31, 30, 29, 28, 27, 26, 24, 24, 23, 23, 21, 20, 19, 18, 17, 16, 16, 15,
14, 12, 12, 11, 9, 9, 8, 7, 6, 5, 4, 4, 2, 2, 0, 0, -1, -2, -3, -3, -6, -6, -6,
-8, -8, -11, -11, -12, -12, -13, -15, -15, -16, -17, -18, -18, -20, -21, -22,
-23, -24, -24, -26, -27, -27, -28, -30, -30, -31, -32, -33, -35, -35, -36, -36,
-38, -39, -40, -41, -42, -43, -44, -44, -46, -46, -48, -47, -49, -50, -51, -52,
-53, -53, -55, -55, -56, -57, -58, -59, -60, -60, -61, -63, -64, -65, -66, -67,
-67, -68, -70, -71, -71, -73, -73, -75, -75, -76, -77, -78, -78, -81, -80, -82,
-83, -84, -84, -85, -86, -88, -89, -89, -91, -92, -92, -93, -94, -95, -96, -97,
-98, -99, -100, -100, -102, -102, -103, -104, -105, -105, -107, -108, -109,
-109, -111, -111, -112, -114, -115, -116, -116, -117, -118, -119, -118, -117,
-116, -116, -115, -114, -113, -112, -111, -109, -109, -108, -106, -106, -105,
-103, -103, -103, -102, -100, -100, -98, -98, -97, -96, -95, -94, -93, -92, -91,
-90, -90, -89, -87, -87, -87, -85, -84, -83, -82, -81, -80, -79, -79, -77, -76,
-75, -74, -74, -72, -72, -71, -69, -68, -68, -67, -66, -66, -64, -63, -62, -61,
-61, -60, -59, -58, -56, -55, -55, -54, -53, -52, -51, -50, -49, -48, -48, -47,
-46, -45, -44, -42, -41, -41, -40, -39, -37, -36, -36, -35, -34, -34, -32, -32,
-30, -30, -29, -28, -27, -26, -25, -25, -23, -22, -21, -20, -19, -18, -17, -17,
-16, -15, -13, -13, -12, -11, -10, -9, -9, -7, -6, -5, -5, -4, -3, -2, -1, };