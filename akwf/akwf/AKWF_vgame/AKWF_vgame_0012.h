#define DATA_LENGTH 512
#define DATA AKWF_vgame_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 16, 14, 29, 35, 31, 34, 32, 35, 33,
34, 33, 34, 33, 33, 48, 57, 68, 71, 69, 70, 69, 70, 70, 70, 69, 70, 69, 70, 71,
86, 94, 93, 94, 94, 94, 93, 94, 93, 94, 94, 94, 93, 97, 108, 111, 112, 111, 110,
111, 110, 111, 112, 112, 111, 111, 112, 111, 113, 114, 113, 114, 113, 115, 114,
112, 112, 113, 113, 113, 113, 112, 114, 115, 114, 114, 114, 113, 115, 111, 106,
107, 107, 106, 107, 104, 98, 99, 99, 98, 99, 98, 98, 100, 90, 83, 85, 83, 86,
77, 67, 69, 68, 69, 68, 68, 69, 68, 56, 52, 55, 54, 54, 44, 39, 40, 38, 41, 39,
40, 39, 41, 35, 25, 26, 25, 25, 10, 9, 10, 9, 10, 10, 10, 9, 10, 10, 4, -2, 1,
-2, -6, -7, -6, -6, -6, -6, -6, -7, -6, -6, -12, -13, -13, -12, -11, -11, -11,
-10, -11, -11, -11, -11, -11, -11, -11, -13, -12, -13, -15, -14, -14, -14, -14,
-13, -14, -15, -14, -15, -14, -14, -13, -11, -11, -11, -11, -12, -11, -11, -12,
-12, -11, -11, -11, -6, -2, 1, 2, 2, 2, 1, 2, 1, 1, 2, 1, 2, 2, 3, 14, 20, 19,
19, 19, 19, 19, 19, 20, 19, 19, 19, 19, 17, 26, 32, 29, 31, 30, 31, 29, 37, 40,
39, 40, 40, 41, 39, 46, 47, 47, 47, 47, 47, 47, 49, 52, 52, 52, 53, 51, 53, 54,
55, 54, 54, 55, 54, 54, 53, 51, 53, 52, 53, 52, 47, 48, 48, 48, 47, 47, 48, 48,
48, 44, 43, 43, 43, 43, 40, 37, 39, 38, 38, 38, 39, 38, 38, 37, 30, 30, 30, 30,
25, 23, 24, 24, 24, 24, 24, 23, 24, 23, 21, 21, 21, 20, 19, 19, 19, 20, 20, 19,
19, 20, 20, 19, 15, 14, 14, 14, 12, 11, 11, 11, 11, 11, 11, 11, 11, 11, 11, 6,
7, 2, -3, 0, -3, -1, -2, -2, -2, -1, -2, -1, -4, -8, -6, -17, -20, -19, -19,
-18, -19, -18, -19, -18, -19, -19, -18, -25, -28, -35, -36, -35, -35, -35, -35,
-35, -35, -35, -36, -34, -35, -35, -45, -53, -52, -53, -52, -52, -53, -52, -52,
-52, -53, -53, -52, -56, -67, -70, -70, -70, -70, -70, -70, -70, -69, -69, -69,
-70, -70, -69, -77, -83, -80, -81, -80, -81, -81, -89, -91, -91, -91, -90, -90,
-90, -101, -103, -101, -102, -101, -102, -101, -104, -111, -110, -110, -109,
-110, -110, -114, -115, -114, -117, -117, -117, -118, -117, -117, -117, -117,
-118, -117, -118, -119, -118, -120, -119, -119, -119, -118, -119, -118, -117,
-118, -116, -118, -113, -111, -112, -110, -111, -111, -112, -110, -112, -109,
-101, -102, -101, -102, -92, -91, -91, -90, -90, -90, -91, -90, -92, -84, -77,
-77, -79, -76, -65, -65, -65, -65, -65, -64, -66, -64, -66, -65, -51, -46, -49,
-40, -27, -29, -28, -29, -28, -29, -28, -29, -28, -30, -24, -8, -7, };