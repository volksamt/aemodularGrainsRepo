#define DATA_LENGTH 512
#define DATA AKWF_vgame_0087

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 47, 82, 106, 118, 116, 112, 105,
96, 93, 93, 96, 100, 103, 104, 104, 102, 98, 96, 98, 102, 104, 105, 103, 100,
100, 99, 101, 101, 103, 104, 103, 102, 101, 100, 100, 99, 100, 101, 100, 101,
101, 101, 99, 99, 100, 100, 100, 100, 100, 100, 100, 100, 100, 100, 100, 100,
101, 100, 100, 100, 101, 100, 100, 100, 100, 100, 99, 100, 100, 99, 100, 99, 99,
99, 100, 100, 100, 100, 100, 100, 100, 100, 100, 100, 100, 100, 100, 99, 99, 99,
100, 99, 99, 99, 100, 99, 100, 100, 99, 99, 99, 99, 100, 99, 99, 99, 99, 100,
99, 99, 99, 99, 102, 102, 102, 100, 100, 99, 99, 99, 100, 102, 103, 104, 104,
104, 102, 100, 100, 100, 100, 102, 102, 103, 103, 103, 101, 99, 99, 99, 102,
102, 104, 103, 102, 101, 99, 99, 98, 99, 99, 98, 99, 99, 99, 99, 99, 98, 98, 99,
99, 99, 98, 98, 99, 99, 99, 99, 98, 99, 98, 98, 99, 98, 98, 99, 99, 99, 98, 98,
99, 98, 99, 98, 98, 99, 98, 99, 97, 97, 99, 98, 99, 98, 98, 98, 98, 98, 98, 98,
98, 98, 98, 98, 97, 98, 98, 98, 97, 98, 97, 99, 98, 97, 98, 98, 98, 97, 98, 97,
100, 102, 102, 101, 99, 98, 98, 100, 100, 100, 100, 99, 98, 98, 97, 98, 101,
101, 101, 101, 99, 98, 98, 98, 100, 104, 103, 97, 89, 88, 95, 106, 116, 115,
107, 83, 38, -15, -60, -90, -110, -117, -118, -112, -104, -99, -95, -95, -98,
-103, -107, -107, -105, -104, -101, -99, -98, -101, -104, -106, -104, -102,
-101, -101, -102, -103, -103, -103, -104, -102, -102, -102, -102, -105, -105,
-104, -103, -101, -100, -101, -102, -103, -104, -105, -104, -102, -100, -101,
-102, -103, -102, -103, -104, -103, -100, -101, -101, -102, -103, -104, -104,
-103, -103, -101, -100, -100, -103, -103, -102, -102, -101, -101, -100, -100,
-101, -102, -103, -103, -101, -101, -100, -101, -101, -101, -100, -100, -101,
-101, -100, -99, -100, -101, -100, -100, -100, -100, -101, -100, -99, -100,
-100, -100, -100, -100, -100, -100, -101, -101, -102, -103, -104, -104, -104,
-103, -104, -104, -104, -104, -103, -104, -104, -104, -104, -104, -104, -104,
-104, -104, -104, -103, -103, -103, -104, -104, -104, -104, -104, -102, -101,
-100, -100, -100, -101, -100, -100, -100, -99, -99, -100, -100, -99, -99, -100,
-99, -100, -99, -99, -100, -99, -99, -99, -100, -101, -102, -103, -102, -100,
-99, -98, -98, -100, -101, -102, -102, -102, -100, -100, -99, -99, -100, -102,
-103, -103, -102, -100, -99, -99, -99, -99, -98, -99, -98, -99, -99, -100, -99,
-99, -99, -99, -99, -99, -99, -99, -99, -99, -98, -98, -99, -99, -99, -101,
-102, -102, -101, -99, -98, -98, -98, -99, -100, -102, -103, -101, -100, -98,
-98, -99, -99, -98, -99, -99, -99, -98, -98, -100, -101, -103, -104, -104, -101,
-96, -91, -89, -95, -100, -111, -118, -119, -112, -79, -29, };