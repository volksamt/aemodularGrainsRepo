#define DATA_LENGTH 512
#define DATA AKWF_vgame_0033

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 9, 9, 11, 8, 18, 28, 24, 29,
39, 39, 38, 39, 49, 53, 50, 52, 51, 52, 62, 65, 63, 65, 68, 72, 70, 73, 78, 78,
77, 78, 76, 78, 82, 83, 82, 82, 86, 86, 84, 88, 90, 89, 91, 90, 90, 93, 96, 94,
95, 95, 97, 96, 97, 98, 97, 98, 98, 98, 98, 99, 98, 98, 98, 100, 102, 101, 103,
104, 104, 105, 105, 103, 107, 111, 111, 111, 113, 117, 118, 117, 118, 119, 119,
119, 118, 120, 116, 116, 116, 117, 111, 103, 106, 102, 96, 95, 96, 93, 96, 93,
84, 83, 85, 83, 74, 72, 73, 69, 65, 66, 66, 66, 64, 60, 62, 60, 62, 59, 56, 56,
56, 50, 48, 48, 47, 50, 39, 36, 37, 37, 38, 27, 19, 23, 17, 6, 6, 6, 6, 5, -3,
-3, -3, -2, -4, -9, -10, -9, -11, -11, -10, -11, -11, -12, -13, -13, -13, -13,
-14, -16, -16, -16, -25, -25, -25, -26, -25, -36, -36, -37, -35, -46, -53, -52,
-51, -55, -67, -63, -66, -62, -69, -80, -79, -78, -79, -84, -84, -84, -84, -83,
-83, -84, -84, -85, -82, -82, -82, -83, -81, -79, -79, -79, -78, -76, -76, -76,
-76, -75, -75, -76, -76, -76, -73, -73, -73, -74, -70, -65, -68, -65, -69, -60,
-50, -51, -52, -50, -37, -38, -37, -38, -23, -20, -22, -19, -23, -9, -6, -5, -9,
1, 9, 7, 9, 9, 17, 16, 17, 15, 17, 22, 21, 21, 21, 24, 24, 24, 24, 25, 26, 26,
26, 26, 25, 26, 26, 27, 26, 26, 26, 26, 26, 25, 26, 26, 26, 26, 23, 23, 22, 23,
19, 17, 17, 18, 15, 9, 10, 9, 10, 1, 3, 1, 2, 2, -3, -3, -3, -2, -3, -4, -3, -4,
-3, -2, -2, -2, -1, -2, -4, -3, -3, -3, -7, -6, -6, -6, -12, -16, -13, -16, -12,
-23, -26, -26, -24, -32, -40, -38, -38, -40, -44, -43, -43, -43, -44, -46, -47,
-47, -47, -47, -47, -47, -49, -52, -51, -52, -50, -53, -57, -56, -57, -57, -57,
-61, -59, -59, -60, -60, -60, -59, -59, -59, -59, -59, -59, -60, -60, -60, -60,
-59, -60, -61, -61, -61, -61, -59, -60, -60, -59, -60, -59, -59, -59, -60, -59,
-57, -58, -58, -58, -58, -58, -58, -58, -57, -56, -57, -56, -56, -55, -55, -55,
-55, -53, -52, -53, -53, -52, -48, -47, -47, -47, -47, -47, -46, -47, -44, -36,
-37, -37, -37, -29, -23, -25, -24, -25, -24, -24, -24, -24, -21, -18, -20, -19,
-19, -17, -16, -16, -16, -17, -16, -15, -16, -15, -16, -16, -16, -16, -16, -17,
-16, -16, -16, -16, -16, -16, -16, -17, -18, -17, -18, -18, -22, -24, -22, -23,
-22, -22, -23, -22, -22, -23, -22, -23, -22, -23, -24, -24, -24, -24, -23, -23,
-24, -24, -23, -24, -25, -24, -24, -24, -24, -25, -24, -24, -24, -25, -24, -25,
-22, -21, -20, -22, -20, -9, -3, -4, -3, -3, -2, -3, -4, };