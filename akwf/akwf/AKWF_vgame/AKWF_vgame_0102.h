#define DATA_LENGTH 512
#define DATA AKWF_vgame_0102

const PROGMEM int8_t DATA[DATA_LENGTH] = {14, 44, 38, 40, 39, 41, 38, 41, 37,
41, 36, 43, 34, 52, 117, 112, 116, 115, 116, 114, 115, 116, 115, 115, 115, 115,
114, 116, 114, 115, 114, 116, 114, 115, 115, 115, 113, 115, 115, 116, 115, 115,
115, 115, 114, 115, 114, 114, 114, 114, 115, 114, 113, 114, 114, 114, 115, 115,
114, 114, 115, 114, 115, 114, 115, 113, 114, 114, 114, 114, 114, 113, 114, 114,
114, 114, 113, 114, 114, 114, 114, 113, 113, 114, 113, 113, 114, 113, 114, 114,
114, 114, 113, 114, 113, 113, 113, 113, 114, 112, 113, 112, 113, 113, 113, 113,
113, 113, 113, 113, 113, 112, 113, 112, 113, 113, 112, 113, 113, 113, 113, 112,
112, 112, 113, 112, 111, 112, 113, 113, 112, 112, 111, 112, 112, 112, 112, 111,
112, 112, 112, 112, 111, 112, 112, 112, 112, 111, 112, 112, 112, 111, 112, 112,
111, 111, 112, 111, 112, 112, 111, 111, 111, 112, 111, 111, 111, 110, 111, 110,
111, 111, 112, 110, 111, 111, 111, 110, 110, 111, 111, 111, 111, 111, 110, 110,
110, 110, 110, 110, 111, 111, 110, 110, 110, 110, 110, 110, 110, 110, 110, 110,
111, 110, 110, 110, 110, 110, 110, 110, 109, 110, 111, 109, 109, 109, 109, 109,
109, 109, 109, 109, 110, 109, 109, 109, 108, 109, 108, 109, 109, 109, 108, 110,
108, 109, 108, 109, 108, 110, 107, 112, 93, 31, 33, 34, 32, 33, 32, 33, 32, 34,
32, 33, 30, 38, -22, -49, -41, -45, -42, -44, -43, -44, -42, -44, -41, -44, -43,
-45, -42, -45, -41, -45, -41, -46, -40, -46, -39, -54, -123, -117, -120, -118,
-119, -120, -118, -120, -119, -120, -118, -119, -118, -120, -119, -120, -119,
-120, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -118, -118,
-118, -118, -119, -119, -119, -118, -118, -118, -118, -119, -118, -118, -119,
-118, -118, -118, -118, -119, -118, -117, -118, -118, -118, -117, -118, -118,
-118, -118, -118, -118, -118, -118, -117, -118, -118, -117, -118, -118, -117,
-117, -117, -118, -118, -118, -117, -118, -118, -117, -117, -117, -117, -117,
-117, -116, -117, -116, -117, -117, -117, -118, -116, -117, -116, -117, -117,
-117, -117, -116, -117, -116, -117, -117, -116, -116, -117, -116, -116, -116,
-116, -117, -116, -116, -117, -116, -116, -115, -116, -116, -116, -116, -115,
-116, -116, -116, -115, -115, -116, -115, -116, -116, -116, -116, -115, -116,
-115, -115, -116, -115, -115, -116, -115, -115, -115, -115, -115, -115, -115,
-115, -115, -114, -115, -115, -114, -115, -115, -115, -115, -115, -114, -115,
-115, -114, -114, -114, -114, -114, -115, -115, -115, -114, -114, -114, -114,
-114, -114, -115, -114, -113, -114, -114, -114, -115, -114, -114, -114, -114,
-114, -113, -113, -114, -113, -113, -113, -113, -114, -113, -113, -114, -114,
-114, -113, -114, -112, -114, -113, -113, -113, -114, -112, -115, -112, -115,
-111, -119, -76, -28, -41, -35, -38, -36, -38, -36, -38, -36, -38, -35, -38,
-35, -38, -35, -39, -38, };