#define DATA_LENGTH 512
#define DATA AKWF_vgame_0114

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 39, 61, 77, 87, 90, 86, 77, 61,
43, 24, 6, -7, -16, -19, -16, -9, 2, 13, 22, 28, 30, 27, 23, 17, 14, 10, 11, 14,
17, 21, 22, 22, 20, 18, 16, 15, 14, 14, 16, 19, 19, 20, 19, 17, 15, 14, 14, 14,
16, 17, 17, 18, 18, 17, 16, 16, 14, 14, 14, 15, 16, 15, 17, 17, 16, 15, 14, 14,
13, 14, 14, 14, 15, 15, 16, 15, 14, 14, 14, 13, 13, 13, 14, 13, 13, 14, 13, 13,
13, 13, 13, 14, 13, 13, 13, 13, 13, 13, 13, 13, 12, 12, 13, 12, 12, 12, 13, 12,
12, 11, 12, 12, 12, 12, 12, 11, 13, 13, 11, 12, 11, 12, 11, 11, 12, 12, 11, 11,
11, 11, 11, 11, 12, 11, 10, 11, 11, 10, 11, 11, 11, 11, 10, 11, 11, 10, 10, 10,
11, 10, 11, 11, 10, 11, 11, 11, 11, 10, 10, 10, 9, 10, 9, 10, 10, 11, 11, 12,
11, 10, 10, 9, 10, 10, 10, 9, 9, 10, 9, 10, 10, 10, 10, 9, 9, 9, 9, 9, 10, 10,
9, 9, 9, 9, 9, 9, 10, 10, 9, 9, 10, 9, 10, 9, 8, 8, 9, 8, 8, 8, 9, 9, 9, 10, 9,
9, 8, 8, 7, 8, 8, 9, 9, 9, 10, 9, 8, 8, 7, 7, 7, 7, 9, 8, 9, 9, 9, 8, 8, 7, 8,
8, 9, 8, 8, 8, 8, 9, 8, 8, 8, 7, 9, 8, 8, 8, 7, 9, 8, 8, 8, 8, 8, 8, 8, 8, 7, 7,
8, 8, 8, 8, 7, 7, 8, 8, 7, 8, 8, 8, 8, 7, 8, 7, 7, 7, 8, 8, 7, 7, 8, 7, 7, 8, 7,
8, 7, 7, 7, 8, 7, 8, 9, 9, 8, 8, 7, 7, 6, 6, 7, 7, 7, 9, 8, 8, 8, 8, 6, 5, 5, 6,
7, 7, 8, 10, 9, 8, 7, 6, 6, 5, 6, 7, 8, 8, 9, 9, 8, 7, 6, 5, 5, 6, 8, 9, 9, 9,
8, 6, 6, 4, 4, 5, 6, 9, 10, 11, 11, 9, 7, 4, 3, 3, 5, 7, 11, 13, 13, 11, 6, 1,
-3, -3, 0, 8, 18, 24, 27, 20, 5, -19, -47, -75, -98, -114, -119, -114, -100,
-81, -58, -38, -20, -8, 0, 1, -4, -12, -22, -32, -40, -45, -47, -44, -39, -34,
-29, -28, -30, -33, -36, -40, -41, -41, -38, -34, -31, -30, -31, -31, -34, -37,
-38, -38, -36, -35, -32, -30, -30, -31, -32, -33, -35, -36, -36, -34, -32, -31,
-29, -28, -29, -31, -33, -34, -33, -34, -32, -32, -30, -29, -28, -28, -30, -31,
-32, -32, -31, -31, -30, -28, -27, -27, -28, -29, -31, -31, -31, -30, -29, -27,
-27, -25, -27, -28, -30, -31, -31, -30, -29, -27, -25, -24, -25, -25, -27, -30,
-30, -31, -29, -27, -25, -23, -23, -24, -26, -30, -32, -33, -30, -25, -19, -16,
-15, -18, -26, -36, -44, -47, -40, -28, -9, };