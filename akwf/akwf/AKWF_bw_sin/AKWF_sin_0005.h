#define DATA_LENGTH 512
#define DATA AKWF_sin_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 7, 9, 10, 11, 12, 14, 15,
17, 18, 19, 21, 22, 23, 25, 26, 28, 29, 31, 32, 32, 35, 36, 38, 39, 39, 42, 43,
44, 46, 47, 48, 50, 51, 52, 54, 54, 56, 57, 59, 59, 61, 62, 63, 65, 66, 66, 68,
69, 70, 72, 72, 74, 75, 76, 77, 78, 78, 80, 81, 81, 82, 83, 84, 86, 86, 87, 88,
89, 90, 90, 92, 93, 94, 95, 95, 96, 97, 98, 98, 98, 99, 101, 101, 102, 102, 103,
104, 104, 106, 106, 106, 107, 107, 108, 109, 109, 109, 111, 111, 111, 112, 112,
113, 113, 114, 114, 114, 114, 116, 115, 116, 117, 117, 117, 118, 118, 117, 118,
117, 118, 119, 118, 119, 118, 119, 119, 118, 119, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 119, 118, 118, 118, 118, 117, 117, 117, 117, 116, 116, 116,
115, 115, 115, 114, 113, 113, 112, 113, 112, 112, 111, 111, 109, 109, 108, 108,
107, 106, 106, 105, 104, 104, 103, 101, 100, 99, 98, 98, 97, 96, 94, 93, 93, 91,
90, 89, 87, 87, 85, 85, 83, 82, 80, 78, 77, 77, 75, 73, 72, 71, 69, 68, 67, 66,
66, 65, 65, 64, 63, 61, 60, 61, 59, 58, 57, 55, 54, 53, 51, 50, 49, 47, 45, 44,
44, 42, 40, 38, 36, 35, 33, 32, 30, 29, 27, 25, 24, 22, 21, 19, 17, 15, 14, 12,
11, 9, 8, 7, 5, 3, 2, 1, -1, -3, -4, -4, -6, -8, -9, -11, -12, -14, -16, -16,
-18, -20, -20, -22, -23, -25, -26, -28, -29, -31, -32, -33, -34, -36, -38, -39,
-40, -42, -42, -44, -46, -47, -48, -49, -51, -52, -53, -55, -56, -58, -58, -60,
-61, -62, -64, -64, -65, -67, -67, -69, -70, -71, -72, -73, -74, -75, -77, -77,
-79, -79, -81, -81, -83, -84, -84, -86, -87, -88, -88, -89, -91, -91, -92, -93,
-93, -95, -95, -96, -98, -97, -99, -99, -100, -100, -101, -103, -103, -104,
-104, -105, -105, -106, -107, -108, -108, -108, -110, -109, -109, -110, -111,
-111, -112, -113, -113, -113, -114, -114, -114, -115, -116, -116, -116, -116,
-117, -117, -117, -116, -118, -118, -117, -117, -118, -118, -118, -118, -119,
-119, -120, -119, -119, -119, -118, -119, -119, -119, -118, -119, -119, -119,
-119, -118, -118, -118, -118, -117, -118, -117, -117, -116, -116, -115, -115,
-115, -114, -114, -113, -113, -113, -112, -112, -111, -110, -110, -109, -110,
-108, -107, -106, -106, -105, -104, -104, -103, -102, -101, -100, -99, -99, -97,
-96, -95, -94, -93, -92, -92, -90, -89, -87, -86, -86, -84, -82, -82, -80, -79,
-77, -76, -74, -74, -72, -70, -69, -69, -67, -67, -66, -65, -64, -63, -62, -62,
-61, -59, -59, -57, -56, -54, -54, -53, -52, -50, -48, -47, -47, -45, -43, -41,
-40, -39, -37, -35, -33, -32, -30, -28, -27, -24, -23, -22, -20, -19, -17, -16,
-14, -11, -11, -10, -7, -7, -5, -4, -2, -1, };