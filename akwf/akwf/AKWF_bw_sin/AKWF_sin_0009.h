#define DATA_LENGTH 512
#define DATA AKWF_sin_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 7, 7, 9, 10, 11, 14, 15,
16, 18, 19, 21, 21, 24, 25, 27, 28, 29, 30, 33, 34, 35, 36, 38, 39, 40, 42, 44,
45, 46, 48, 49, 50, 51, 53, 54, 55, 57, 58, 59, 61, 62, 63, 65, 65, 67, 69, 69,
71, 72, 72, 74, 75, 77, 77, 79, 80, 81, 82, 83, 85, 85, 87, 87, 89, 89, 90, 91,
93, 93, 93, 95, 96, 97, 97, 98, 99, 100, 101, 102, 103, 104, 105, 106, 106, 106,
107, 108, 109, 109, 109, 110, 111, 112, 111, 112, 112, 113, 113, 114, 114, 114,
114, 116, 115, 116, 117, 117, 117, 117, 118, 118, 117, 118, 118, 119, 118, 119,
118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119,
119, 118, 119, 118, 118, 118, 117, 117, 117, 116, 116, 116, 115, 116, 115, 115,
115, 114, 113, 113, 113, 112, 112, 111, 111, 109, 110, 110, 107, 107, 107, 106,
105, 105, 104, 103, 103, 102, 101, 100, 99, 98, 98, 97, 96, 95, 94, 93, 92, 91,
90, 89, 88, 87, 86, 85, 83, 83, 82, 80, 79, 78, 77, 77, 75, 74, 73, 72, 71, 69,
67, 66, 65, 64, 63, 62, 60, 59, 57, 56, 55, 54, 53, 51, 50, 49, 47, 45, 44, 44,
42, 40, 39, 37, 36, 34, 33, 32, 31, 29, 28, 26, 24, 23, 22, 21, 19, 17, 16, 14,
13, 12, 10, 8, 7, 6, 4, 3, 2, 0, -2, -3, -5, -6, -7, -9, -11, -11, -13, -15,
-16, -18, -20, -20, -22, -24, -26, -27, -28, -29, -32, -32, -34, -35, -37, -38,
-39, -41, -42, -44, -44, -46, -47, -49, -50, -52, -53, -55, -57, -57, -58, -60,
-61, -61, -64, -65, -66, -67, -69, -70, -71, -72, -72, -75, -76, -76, -78, -78,
-80, -82, -83, -84, -85, -85, -86, -87, -89, -89, -90, -91, -92, -93, -95, -95,
-97, -97, -98, -99, -100, -100, -102, -102, -103, -103, -104, -105, -106, -106,
-106, -108, -108, -109, -109, -109, -111, -111, -112, -112, -112, -113, -114,
-115, -114, -115, -115, -116, -116, -116, -116, -117, -117, -117, -117, -117,
-117, -118, -118, -119, -119, -118, -119, -119, -119, -119, -119, -120, -119,
-120, -119, -119, -119, -119, -119, -118, -119, -119, -118, -118, -118, -117,
-117, -117, -117, -117, -117, -116, -116, -116, -115, -115, -115, -114, -114,
-113, -113, -113, -113, -112, -112, -112, -111, -110, -109, -109, -108, -108,
-107, -106, -105, -105, -104, -103, -103, -101, -100, -100, -99, -99, -97, -97,
-95, -95, -94, -92, -92, -91, -90, -89, -87, -87, -86, -84, -84, -84, -82, -81,
-79, -79, -77, -76, -75, -74, -72, -72, -71, -69, -67, -67, -65, -64, -62, -62,
-61, -60, -59, -57, -55, -54, -53, -51, -50, -48, -47, -46, -45, -43, -42, -40,
-39, -38, -37, -34, -33, -32, -30, -28, -28, -26, -25, -24, -22, -21, -19, -17,
-15, -15, -13, -12, -9, -8, -7, -5, -3, -2, -1, };