#define DATA_LENGTH 512
#define DATA AKWF_sin_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 1, 2, 7, 8, 10, 11, 12, 14, 16, 17,
19, 20, 22, 24, 25, 26, 28, 30, 31, 32, 33, 36, 37, 39, 40, 41, 43, 44, 46, 48,
48, 50, 51, 52, 54, 55, 56, 57, 60, 60, 63, 64, 65, 66, 68, 69, 70, 71, 71, 73,
74, 76, 77, 78, 79, 80, 81, 82, 84, 85, 85, 87, 87, 89, 90, 90, 91, 92, 93, 94,
95, 96, 96, 98, 98, 100, 100, 100, 102, 102, 103, 103, 104, 105, 106, 107, 107,
107, 108, 109, 110, 110, 111, 111, 111, 112, 112, 112, 113, 114, 115, 115, 115,
115, 116, 115, 117, 117, 116, 117, 118, 118, 117, 118, 118, 118, 118, 119, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 118, 118,
118, 119, 117, 117, 117, 117, 117, 117, 116, 116, 115, 116, 114, 115, 114, 114,
113, 114, 113, 112, 111, 112, 111, 111, 110, 109, 109, 108, 108, 108, 106, 105,
105, 104, 104, 103, 102, 101, 101, 100, 100, 98, 98, 97, 96, 96, 94, 93, 93, 92,
91, 91, 90, 88, 87, 86, 85, 84, 84, 81, 81, 81, 79, 78, 77, 77, 74, 74, 72, 71,
70, 69, 68, 67, 66, 64, 63, 61, 60, 59, 57, 56, 55, 54, 53, 51, 50, 48, 47, 46,
44, 43, 41, 40, 39, 37, 36, 35, 33, 32, 31, 28, 28, 26, 24, 23, 21, 20, 18, 17,
15, 14, 13, 10, 9, 7, 6, 4, 3, 1, -4, 0, -3, -8, -8, -10, -10, -12, -13, -16,
-17, -19, -21, -22, -23, -26, -26, -28, -29, -31, -32, -34, -35, -37, -38, -41,
-41, -43, -44, -45, -48, -49, -49, -51, -53, -54, -56, -57, -58, -59, -60, -62,
-63, -65, -66, -68, -68, -70, -71, -72, -74, -74, -76, -77, -79, -79, -81, -82,
-82, -84, -85, -85, -87, -88, -89, -90, -91, -91, -92, -94, -94, -96, -97, -97,
-98, -98, -99, -100, -101, -101, -102, -102, -103, -104, -105, -106, -106, -107,
-107, -108, -109, -109, -110, -110, -112, -112, -112, -112, -113, -114, -114,
-115, -114, -114, -115, -116, -117, -116, -117, -117, -118, -118, -117, -118,
-118, -118, -118, -119, -119, -119, -119, -119, -119, -119, -118, -119, -118,
-118, -120, -119, -119, -118, -119, -119, -119, -118, -118, -118, -118, -118,
-118, -117, -117, -116, -116, -116, -116, -115, -115, -114, -114, -114, -114,
-113, -112, -112, -111, -111, -111, -110, -110, -110, -108, -108, -107, -106,
-107, -105, -105, -104, -103, -103, -103, -102, -101, -99, -99, -99, -98, -97,
-96, -96, -94, -94, -93, -92, -91, -89, -89, -88, -87, -86, -86, -85, -83, -82,
-81, -80, -79, -78, -77, -75, -75, -73, -72, -71, -70, -69, -67, -67, -65, -65,
-62, -61, -60, -59, -57, -56, -55, -54, -53, -51, -50, -49, -46, -45, -45, -43,
-42, -40, -38, -37, -36, -34, -33, -31, -30, -29, -27, -26, -24, -22, -20, -20,
-18, -17, -15, -13, -12, -10, -8, -7, -6, -4, -2, 0, };