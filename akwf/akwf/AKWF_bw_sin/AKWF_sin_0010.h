#define DATA_LENGTH 512
#define DATA AKWF_sin_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 8, 9, 11, 13, 14, 17, 18, 21,
22, 25, 26, 28, 30, 32, 34, 36, 37, 39, 41, 43, 44, 46, 49, 50, 52, 53, 55, 56,
57, 59, 61, 62, 63, 65, 67, 68, 69, 70, 72, 73, 75, 76, 77, 78, 79, 80, 82, 82,
83, 85, 85, 86, 87, 88, 90, 91, 91, 92, 93, 94, 95, 96, 96, 97, 99, 99, 100,
100, 101, 101, 102, 103, 103, 104, 104, 106, 106, 106, 107, 108, 108, 109, 109,
109, 109, 110, 110, 111, 111, 112, 113, 113, 113, 114, 114, 114, 116, 115, 115,
116, 117, 115, 116, 117, 118, 117, 117, 117, 117, 118, 118, 118, 118, 119, 119,
119, 118, 119, 118, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118,
119, 119, 118, 118, 119, 117, 118, 118, 118, 117, 117, 117, 117, 116, 117, 117,
117, 116, 115, 115, 115, 115, 114, 115, 114, 114, 113, 113, 113, 113, 111, 112,
111, 110, 109, 109, 108, 108, 108, 108, 107, 107, 105, 105, 104, 104, 103, 102,
101, 101, 100, 100, 99, 98, 98, 97, 96, 95, 94, 93, 93, 92, 91, 90, 89, 87, 87,
86, 85, 83, 82, 82, 80, 80, 79, 76, 76, 74, 73, 72, 71, 69, 69, 67, 65, 64, 62,
60, 60, 58, 57, 55, 54, 52, 50, 49, 47, 45, 43, 42, 39, 38, 37, 34, 32, 30, 29,
26, 26, 23, 21, 19, 17, 16, 13, 12, 9, 7, 6, 4, 2, 1, -2, -4, -5, -8, -10, -11,
-13, -15, -18, -19, -21, -23, -25, -26, -28, -31, -33, -34, -36, -38, -39, -42,
-43, -45, -47, -48, -50, -52, -53, -55, -57, -58, -59, -62, -63, -63, -65, -66,
-68, -69, -71, -72, -73, -74, -75, -77, -79, -80, -80, -82, -83, -84, -84, -85,
-87, -87, -88, -89, -91, -91, -92, -93, -93, -96, -96, -97, -97, -99, -99, -100,
-100, -100, -102, -102, -103, -103, -104, -104, -105, -106, -107, -107, -108,
-108, -109, -109, -110, -110, -111, -111, -111, -112, -113, -113, -114, -114,
-114, -115, -115, -115, -115, -115, -115, -116, -116, -116, -116, -117, -117,
-117, -117, -118, -118, -118, -118, -118, -118, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -118, -118, -118, -119, -119, -118, -118, -118, -118, -117, -117, -117,
-117, -116, -115, -116, -116, -115, -115, -114, -115, -115, -114, -114, -113,
-112, -113, -112, -112, -112, -111, -110, -109, -109, -109, -108, -108, -107,
-107, -106, -106, -104, -105, -104, -103, -102, -102, -102, -100, -100, -99,
-98, -97, -96, -96, -95, -94, -93, -92, -92, -91, -89, -89, -87, -86, -85, -85,
-84, -82, -81, -80, -79, -78, -77, -75, -74, -73, -72, -71, -69, -68, -67, -65,
-64, -62, -61, -60, -58, -56, -54, -53, -51, -49, -48, -46, -45, -43, -41, -40,
-38, -35, -35, -32, -30, -28, -27, -24, -23, -20, -19, -17, -15, -13, -12, -9,
-8, -5, -3, -2, 0, };