#define DATA_LENGTH 512
#define DATA AKWF_sin_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 6, 8, 9, 11, 13, 14, 16, 18,
19, 20, 22, 23, 25, 27, 28, 29, 31, 32, 35, 37, 38, 40, 41, 43, 44, 46, 47, 48,
50, 51, 53, 54, 55, 57, 58, 60, 61, 63, 64, 66, 68, 68, 70, 71, 72, 73, 75, 76,
77, 79, 81, 81, 83, 84, 85, 86, 87, 89, 89, 91, 90, 93, 93, 94, 95, 96, 96, 98,
98, 99, 100, 100, 101, 101, 102, 104, 104, 105, 106, 106, 107, 107, 107, 108,
109, 110, 109, 110, 111, 111, 112, 112, 113, 113, 114, 114, 114, 114, 116, 115,
116, 115, 116, 117, 117, 117, 118, 117, 118, 118, 118, 118, 118, 118, 119, 118,
118, 118, 118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 118, 119,
119, 119, 119, 118, 118, 118, 117, 118, 117, 118, 118, 118, 116, 117, 116, 115,
116, 115, 115, 115, 114, 114, 114, 114, 113, 112, 112, 111, 111, 110, 110, 109,
109, 108, 108, 108, 106, 106, 106, 106, 104, 103, 103, 101, 102, 101, 100, 98,
99, 98, 96, 95, 95, 94, 93, 92, 91, 90, 89, 89, 87, 86, 85, 83, 83, 81, 81, 80,
77, 77, 74, 73, 73, 72, 69, 69, 66, 66, 64, 63, 61, 60, 59, 57, 56, 55, 53, 52,
50, 49, 48, 46, 44, 42, 41, 40, 38, 36, 35, 33, 31, 30, 30, 26, 26, 24, 22, 20,
19, 18, 16, 15, 13, 10, 10, 8, 6, 5, 3, 2, 0, -1, -2, -4, -6, -8, -9, -11, -13,
-15, -16, -18, -19, -21, -22, -24, -25, -27, -28, -29, -32, -33, -35, -36, -38,
-39, -41, -42, -44, -45, -47, -48, -50, -51, -53, -54, -57, -58, -59, -60, -62,
-63, -64, -66, -68, -69, -71, -71, -72, -74, -76, -77, -78, -79, -80, -81, -83,
-84, -84, -86, -87, -87, -90, -90, -91, -92, -93, -94, -95, -96, -97, -98, -98,
-99, -100, -101, -101, -103, -103, -104, -105, -105, -106, -106, -107, -107,
-109, -109, -109, -110, -110, -110, -111, -111, -112, -112, -113, -113, -113,
-113, -114, -114, -115, -116, -116, -116, -116, -116, -116, -117, -117, -117,
-118, -117, -118, -118, -118, -118, -118, -118, -119, -119, -119, -119, -119,
-118, -119, -119, -118, -119, -119, -119, -119, -120, -119, -119, -118, -118,
-119, -118, -119, -117, -118, -118, -117, -117, -117, -117, -116, -116, -116,
-116, -115, -115, -115, -114, -115, -114, -114, -113, -112, -112, -111, -112,
-111, -110, -111, -109, -109, -108, -108, -107, -107, -106, -106, -105, -104,
-104, -103, -102, -102, -101, -100, -99, -98, -97, -97, -95, -94, -94, -92, -91,
-91, -90, -89, -89, -88, -86, -85, -84, -82, -81, -80, -78, -78, -76, -75, -74,
-73, -71, -69, -68, -67, -65, -64, -63, -61, -61, -58, -57, -56, -54, -53, -52,
-50, -49, -47, -45, -45, -42, -41, -40, -38, -37, -36, -33, -31, -30, -29, -27,
-25, -24, -22, -21, -19, -18, -16, -15, -13, -11, -9, -8, -7, -5, -3, -1, 0, };