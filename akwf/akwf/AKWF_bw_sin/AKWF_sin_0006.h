#define DATA_LENGTH 512
#define DATA AKWF_sin_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 3, 5, 6, 8, 10, 11, 13, 15, 15,
19, 20, 20, 23, 25, 26, 28, 29, 31, 32, 34, 36, 36, 39, 40, 41, 43, 45, 47, 48,
50, 51, 53, 54, 56, 57, 59, 60, 62, 64, 64, 66, 67, 68, 70, 72, 73, 75, 76, 77,
78, 79, 80, 83, 83, 84, 86, 87, 88, 89, 91, 91, 92, 94, 95, 96, 97, 98, 98, 99,
100, 102, 102, 103, 104, 105, 105, 107, 107, 108, 108, 109, 110, 110, 111, 111,
112, 113, 114, 114, 114, 115, 114, 116, 117, 117, 116, 117, 117, 117, 118, 118,
118, 118, 119, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 118,
119, 118, 119, 118, 118, 118, 118, 117, 118, 117, 116, 117, 116, 116, 116, 115,
115, 114, 114, 114, 113, 113, 113, 112, 112, 112, 111, 110, 110, 109, 108, 108,
108, 107, 106, 106, 105, 105, 104, 103, 104, 102, 103, 101, 101, 100, 99, 99,
98, 97, 97, 96, 95, 95, 94, 94, 93, 92, 91, 90, 89, 88, 88, 87, 86, 86, 85, 84,
84, 82, 81, 80, 80, 79, 79, 77, 76, 75, 75, 74, 72, 72, 71, 69, 68, 67, 67, 66,
64, 63, 62, 62, 61, 59, 58, 56, 56, 55, 54, 52, 52, 49, 48, 47, 46, 45, 44, 42,
41, 40, 39, 37, 37, 35, 33, 32, 31, 28, 27, 27, 26, 24, 22, 20, 20, 17, 16, 15,
13, 12, 9, 8, 7, 5, 4, 2, 1, -1, -2, -4, -5, -7, -9, -11, -12, -13, -16, -16,
-18, -20, -21, -23, -25, -26, -28, -29, -30, -32, -35, -36, -37, -39, -40, -41,
-45, -46, -47, -48, -50, -52, -53, -54, -56, -58, -58, -60, -61, -64, -64, -67,
-68, -68, -70, -71, -72, -75, -76, -77, -79, -80, -82, -82, -83, -85, -86, -88,
-88, -89, -91, -92, -92, -95, -94, -96, -97, -98, -98, -100, -101, -101, -102,
-103, -104, -105, -105, -107, -107, -108, -109, -110, -111, -110, -111, -112,
-113, -112, -113, -114, -114, -114, -115, -115, -116, -116, -117, -117, -117,
-118, -118, -118, -118, -118, -119, -119, -119, -119, -119, -119, -119, -118,
-118, -119, -118, -119, -119, -119, -119, -119, -118, -119, -118, -118, -118,
-118, -117, -117, -117, -116, -116, -116, -115, -114, -115, -115, -113, -114,
-114, -113, -112, -112, -111, -112, -111, -109, -109, -109, -109, -107, -108,
-107, -107, -106, -106, -105, -104, -104, -103, -102, -102, -101, -100, -100,
-99, -98, -98, -97, -97, -96, -96, -94, -94, -93, -92, -91, -91, -90, -90, -88,
-88, -87, -86, -85, -85, -84, -83, -81, -81, -81, -79, -79, -78, -77, -76, -75,
-74, -73, -72, -71, -70, -69, -68, -67, -67, -66, -64, -64, -62, -60, -60, -59,
-58, -57, -55, -55, -54, -53, -51, -50, -48, -47, -46, -45, -44, -42, -41, -39,
-38, -36, -35, -34, -33, -31, -30, -30, -27, -26, -25, -24, -22, -20, -18, -18,
-16, -14, -13, -12, -9, -8, -7, -6, -4, -2, -1, };