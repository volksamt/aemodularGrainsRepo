#define DATA_LENGTH 512
#define DATA AKWF_sin_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 7, 10, 11, 12, 14, 15, 17,
18, 21, 22, 24, 24, 27, 28, 30, 31, 33, 34, 35, 38, 38, 41, 42, 43, 45, 47, 47,
49, 51, 52, 54, 55, 57, 58, 59, 60, 62, 63, 64, 66, 68, 68, 69, 71, 72, 74, 74,
75, 77, 79, 79, 80, 81, 82, 83, 84, 86, 87, 88, 89, 91, 91, 92, 92, 94, 95, 95,
97, 97, 97, 99, 100, 101, 101, 102, 103, 104, 104, 105, 106, 106, 107, 107, 107,
110, 110, 110, 111, 111, 111, 112, 113, 114, 113, 114, 114, 115, 115, 115, 116,
117, 117, 117, 117, 117, 118, 119, 119, 117, 119, 119, 119, 119, 118, 119, 118,
119, 119, 118, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 120, 118, 119, 118, 119, 118, 118, 118, 118, 118, 118, 117, 117, 116, 116,
116, 116, 115, 115, 115, 113, 114, 113, 113, 111, 112, 110, 111, 109, 109, 108,
108, 108, 107, 106, 105, 105, 104, 103, 103, 102, 100, 100, 100, 99, 98, 98, 96,
96, 94, 93, 92, 91, 90, 89, 88, 88, 87, 86, 85, 84, 82, 82, 80, 79, 78, 77, 76,
74, 73, 72, 70, 69, 67, 67, 64, 64, 63, 60, 60, 59, 58, 56, 54, 53, 52, 50, 49,
47, 46, 45, 43, 42, 40, 38, 37, 36, 34, 32, 31, 29, 28, 26, 25, 23, 21, 19, 17,
16, 15, 13, 12, 10, 8, 6, 5, 4, 2, 0, -1, -3, -4, -7, -8, -10, -10, -13, -14,
-15, -17, -20, -21, -22, -24, -25, -27, -29, -30, -32, -33, -35, -37, -39, -40,
-41, -42, -43, -46, -47, -48, -49, -52, -53, -54, -56, -58, -59, -59, -61, -63,
-64, -65, -67, -68, -69, -70, -72, -72, -74, -76, -76, -77, -78, -80, -80, -82,
-83, -84, -85, -87, -88, -88, -90, -90, -91, -92, -93, -93, -95, -96, -97, -97,
-98, -99, -99, -102, -102, -102, -102, -103, -104, -105, -106, -106, -107, -108,
-109, -110, -109, -110, -111, -111, -112, -112, -113, -113, -114, -114, -114,
-114, -116, -116, -116, -117, -117, -118, -118, -118, -117, -117, -118, -119,
-118, -118, -119, -118, -118, -118, -119, -119, -119, -120, -118, -119, -119,
-119, -119, -119, -119, -120, -120, -118, -119, -119, -119, -119, -119, -119,
-119, -120, -120, -119, -119, -118, -118, -117, -117, -117, -117, -117, -116,
-117, -116, -115, -116, -114, -115, -113, -113, -113, -113, -112, -111, -111,
-110, -109, -109, -109, -107, -107, -106, -106, -105, -105, -103, -103, -102,
-102, -101, -99, -99, -98, -97, -96, -96, -95, -94, -93, -91, -90, -89, -88,
-88, -87, -86, -84, -83, -82, -81, -80, -79, -77, -76, -76, -74, -73, -71, -71,
-69, -68, -67, -65, -64, -63, -62, -60, -59, -58, -56, -54, -53, -52, -50, -50,
-47, -47, -45, -44, -42, -39, -39, -37, -36, -34, -32, -31, -30, -28, -26, -25,
-23, -21, -20, -18, -17, -16, -13, -12, -10, -8, -7, -5, -4, -2, -1, };