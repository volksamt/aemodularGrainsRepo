#define DATA_LENGTH 512
#define DATA AKWF_sin_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 5, 7, 9, 10, 12, 14, 15, 17, 20,
21, 23, 23, 26, 27, 30, 31, 32, 35, 37, 37, 39, 40, 43, 44, 46, 48, 49, 52, 53,
54, 56, 56, 59, 61, 61, 63, 64, 66, 68, 68, 70, 72, 73, 74, 76, 76, 76, 78, 80,
81, 81, 83, 84, 85, 86, 87, 89, 89, 90, 91, 92, 93, 94, 95, 95, 97, 97, 97, 98,
99, 100, 101, 102, 101, 103, 104, 104, 105, 106, 106, 106, 108, 107, 108, 109,
109, 110, 110, 110, 111, 112, 112, 112, 112, 114, 113, 114, 115, 115, 115, 115,
116, 116, 116, 117, 117, 117, 118, 118, 118, 117, 118, 118, 118, 119, 118, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119,
119, 118, 118, 118, 118, 118, 117, 118, 118, 117, 117, 117, 117, 116, 116, 116,
115, 115, 115, 115, 114, 114, 114, 113, 114, 112, 112, 112, 111, 111, 110, 111,
110, 108, 108, 107, 107, 106, 106, 105, 105, 104, 104, 102, 102, 102, 101, 100,
99, 98, 98, 97, 97, 96, 95, 94, 92, 92, 91, 90, 89, 88, 88, 87, 86, 84, 83, 82,
82, 79, 79, 78, 76, 75, 73, 74, 72, 70, 69, 67, 66, 64, 63, 62, 61, 60, 58, 56,
54, 53, 52, 50, 48, 46, 45, 42, 42, 40, 38, 37, 34, 33, 31, 30, 28, 27, 24, 23,
21, 19, 18, 15, 14, 13, 10, 9, 6, 5, 3, 2, 0, -2, -4, -5, -7, -9, -11, -12, -14,
-16, -17, -19, -20, -22, -25, -26, -28, -30, -31, -33, -34, -35, -38, -40, -41,
-43, -45, -46, -47, -50, -51, -53, -54, -56, -58, -59, -60, -62, -63, -65, -66,
-68, -69, -70, -71, -72, -74, -76, -77, -77, -78, -80, -81, -82, -83, -84, -86,
-87, -87, -88, -90, -90, -91, -92, -93, -94, -96, -95, -96, -98, -97, -98, -99,
-100, -101, -102, -102, -103, -104, -105, -105, -106, -106, -106, -107, -107,
-108, -108, -109, -110, -110, -112, -111, -112, -111, -112, -113, -114, -114,
-114, -115, -115, -115, -116, -116, -116, -116, -116, -117, -117, -117, -117,
-118, -118, -118, -117, -118, -119, -119, -119, -119, -118, -119, -118, -118,
-119, -120, -119, -119, -119, -120, -119, -118, -119, -118, -118, -119, -119,
-119, -118, -118, -119, -118, -118, -117, -117, -117, -117, -117, -117, -116,
-117, -115, -116, -116, -115, -114, -114, -114, -114, -113, -112, -112, -112,
-111, -111, -110, -109, -109, -109, -109, -108, -108, -107, -106, -105, -105,
-104, -104, -104, -102, -101, -100, -100, -100, -98, -98, -98, -96, -96, -94,
-94, -93, -92, -92, -91, -89, -88, -87, -86, -86, -84, -84, -82, -81, -80, -79,
-78, -77, -75, -75, -73, -71, -70, -69, -67, -67, -64, -63, -62, -60, -59, -57,
-56, -55, -52, -51, -50, -47, -46, -44, -42, -41, -39, -38, -36, -35, -33, -31,
-30, -28, -26, -24, -23, -20, -19, -17, -16, -14, -12, -10, -9, -7, -5, -4, -2,
0, };