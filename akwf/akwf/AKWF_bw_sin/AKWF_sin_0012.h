#define DATA_LENGTH 512
#define DATA AKWF_sin_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 5, 7, 8, 10, 11, 13, 14, 16,
18, 19, 21, 22, 23, 25, 27, 29, 30, 32, 33, 34, 35, 37, 39, 41, 42, 43, 44, 46,
47, 49, 50, 52, 54, 54, 55, 57, 58, 59, 61, 62, 64, 65, 66, 67, 69, 69, 71, 72,
73, 75, 75, 78, 79, 79, 80, 81, 83, 83, 84, 86, 87, 87, 89, 89, 90, 92, 92, 93,
94, 95, 97, 97, 97, 99, 100, 100, 100, 101, 102, 103, 104, 104, 106, 106, 106,
107, 108, 109, 109, 110, 110, 111, 111, 112, 112, 112, 113, 114, 114, 115, 114,
116, 115, 115, 116, 116, 117, 117, 117, 118, 118, 118, 118, 119, 119, 118, 118,
119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 118, 118,
118, 118, 118, 119, 118, 117, 117, 117, 117, 117, 116, 116, 115, 116, 115, 115,
114, 113, 113, 114, 112, 112, 111, 111, 110, 110, 109, 109, 109, 108, 106, 106,
106, 105, 104, 103, 103, 102, 102, 101, 101, 100, 99, 98, 98, 96, 96, 95, 94,
93, 91, 90, 90, 89, 88, 87, 87, 85, 84, 83, 82, 80, 80, 79, 78, 77, 75, 74, 74,
72, 71, 68, 68, 67, 66, 64, 63, 62, 60, 59, 58, 57, 56, 54, 52, 52, 50, 49, 47,
45, 45, 42, 42, 40, 39, 37, 36, 35, 32, 31, 29, 29, 27, 26, 23, 22, 21, 19, 17,
17, 15, 13, 11, 9, 8, 8, 5, 4, 3, 1, -1, -3, -4, -5, -7, -9, -11, -11, -13, -14,
-16, -17, -20, -21, -22, -25, -25, -28, -28, -30, -32, -33, -35, -36, -38, -38,
-40, -42, -44, -44, -46, -47, -49, -50, -52, -53, -54, -55, -57, -58, -60, -61,
-62, -64, -66, -66, -67, -69, -70, -72, -73, -74, -75, -76, -77, -78, -80, -81,
-82, -83, -83, -85, -85, -86, -88, -89, -89, -91, -92, -93, -94, -95, -95, -96,
-97, -98, -99, -99, -100, -101, -102, -103, -103, -103, -105, -106, -106, -107,
-107, -108, -109, -109, -109, -110, -111, -111, -112, -112, -112, -113, -113,
-113, -114, -115, -115, -116, -116, -117, -116, -117, -116, -117, -118, -118,
-117, -118, -118, -118, -118, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -118, -118, -118, -118,
-118, -118, -117, -117, -117, -116, -116, -116, -115, -116, -114, -115, -114,
-114, -113, -113, -112, -113, -111, -110, -110, -110, -109, -108, -108, -108,
-108, -107, -106, -105, -105, -104, -104, -102, -102, -101, -100, -99, -99, -98,
-98, -97, -95, -95, -93, -92, -92, -90, -90, -88, -88, -87, -86, -85, -84, -83,
-82, -81, -80, -78, -77, -76, -76, -74, -73, -72, -71, -69, -69, -67, -66, -65,
-63, -62, -61, -59, -58, -56, -55, -54, -53, -51, -50, -48, -47, -46, -43, -42,
-42, -40, -39, -37, -36, -35, -32, -32, -30, -28, -26, -25, -24, -23, -21, -19,
-18, -17, -15, -13, -11, -10, -9, -7, -5, -3, -2, -1, };