#define DATA_LENGTH 512
#define DATA AKWF_sin_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 3, 5, 7, 8, 10, 11, 13, 14, 15,
17, 19, 19, 21, 23, 24, 25, 27, 29, 29, 32, 33, 34, 35, 36, 38, 40, 40, 43, 44,
45, 47, 48, 49, 50, 52, 53, 54, 56, 57, 58, 60, 60, 61, 63, 64, 65, 68, 68, 69,
70, 72, 73, 74, 75, 76, 77, 78, 80, 81, 82, 82, 83, 85, 86, 87, 88, 88, 90, 91,
91, 93, 93, 94, 95, 96, 97, 98, 98, 100, 100, 100, 102, 103, 104, 104, 105, 105,
107, 107, 108, 109, 109, 109, 110, 110, 110, 112, 112, 112, 113, 113, 113, 115,
115, 115, 115, 116, 116, 117, 117, 117, 117, 118, 117, 118, 117, 118, 118, 118,
118, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 118, 119, 119, 118,
118, 118, 117, 117, 117, 117, 117, 116, 117, 117, 115, 115, 115, 115, 114, 114,
114, 113, 112, 111, 111, 111, 111, 111, 108, 109, 107, 107, 107, 106, 105, 105,
104, 103, 103, 102, 101, 101, 99, 99, 98, 97, 95, 95, 95, 94, 92, 92, 91, 89,
89, 88, 87, 86, 84, 84, 82, 81, 81, 80, 78, 78, 76, 75, 73, 73, 72, 70, 69, 68,
67, 65, 64, 62, 62, 61, 59, 58, 57, 56, 54, 53, 51, 50, 48, 48, 46, 45, 44, 42,
41, 39, 39, 36, 35, 34, 33, 31, 30, 28, 26, 25, 24, 23, 21, 20, 18, 16, 15, 15,
13, 10, 9, 8, 6, 5, 3, 2, 0, -1, -2, -4, -5, -6, -8, -9, -11, -12, -14, -15,
-18, -18, -20, -21, -23, -24, -26, -27, -28, -29, -31, -32, -34, -36, -37, -37,
-40, -41, -42, -44, -45, -46, -47, -48, -51, -51, -53, -54, -56, -57, -58, -59,
-60, -62, -64, -65, -66, -66, -67, -69, -70, -72, -73, -73, -75, -76, -77, -78,
-80, -81, -82, -82, -84, -85, -85, -87, -88, -89, -90, -90, -92, -92, -94, -95,
-95, -96, -97, -98, -99, -100, -100, -101, -103, -103, -104, -103, -104, -106,
-107, -107, -107, -108, -109, -109, -109, -110, -110, -111, -112, -112, -113,
-113, -114, -114, -114, -115, -115, -116, -116, -117, -116, -117, -117, -118,
-118, -117, -118, -118, -118, -118, -119, -118, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -118, -119, -118, -118, -119, -119, -118, -118, -118,
-117, -117, -117, -116, -117, -115, -116, -116, -115, -114, -114, -114, -113,
-113, -112, -112, -112, -111, -110, -109, -109, -108, -108, -107, -107, -106,
-106, -104, -104, -104, -103, -102, -101, -100, -100, -98, -98, -98, -96, -95,
-94, -93, -92, -91, -90, -90, -88, -88, -86, -87, -85, -83, -83, -82, -80, -80,
-79, -78, -76, -75, -75, -73, -71, -70, -70, -68, -67, -66, -65, -63, -62, -61,
-60, -58, -56, -57, -54, -53, -52, -51, -49, -47, -47, -45, -45, -42, -41, -40,
-38, -36, -36, -35, -33, -31, -30, -28, -27, -25, -25, -23, -22, -20, -19, -17,
-16, -13, -13, -11, -9, -9, -7, -5, -4, -3, 0, };