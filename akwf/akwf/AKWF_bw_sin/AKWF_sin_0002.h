#define DATA_LENGTH 512
#define DATA AKWF_sin_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 8, 9, 10, 11, 12, 15, 16,
17, 19, 20, 22, 24, 25, 26, 28, 29, 31, 32, 34, 36, 37, 39, 40, 42, 43, 45, 46,
47, 49, 51, 52, 53, 54, 56, 58, 59, 60, 61, 63, 64, 66, 67, 68, 69, 71, 73, 73,
75, 75, 76, 78, 79, 80, 82, 82, 84, 85, 86, 87, 89, 90, 90, 92, 92, 93, 94, 95,
95, 97, 98, 99, 99, 100, 101, 102, 103, 104, 105, 105, 105, 106, 107, 109, 108,
108, 109, 110, 111, 111, 111, 112, 113, 113, 113, 114, 115, 115, 116, 115, 115,
117, 116, 116, 117, 117, 117, 117, 118, 118, 118, 118, 119, 119, 119, 119, 119,
118, 120, 119, 119, 120, 118, 119, 119, 119, 119, 118, 119, 119, 119, 118, 118,
119, 118, 118, 118, 118, 117, 117, 117, 116, 116, 116, 115, 116, 115, 115, 114,
113, 114, 113, 113, 113, 112, 112, 110, 110, 111, 109, 109, 108, 107, 107, 106,
106, 105, 104, 103, 102, 102, 101, 100, 99, 98, 98, 97, 95, 94, 94, 93, 92, 91,
90, 89, 88, 86, 86, 85, 83, 83, 81, 80, 80, 79, 77, 76, 74, 73, 72, 70, 70, 69,
67, 66, 65, 63, 63, 62, 59, 59, 57, 56, 55, 53, 52, 51, 49, 48, 48, 45, 44, 42,
42, 40, 39, 38, 36, 35, 34, 32, 30, 29, 27, 26, 25, 24, 22, 20, 19, 18, 16, 15,
13, 12, 11, 9, 8, 7, 5, 3, 2, 0, -1, -3, -4, -6, -7, -9, -10, -11, -13, -15,
-16, -17, -19, -21, -22, -24, -26, -27, -28, -29, -31, -33, -34, -36, -38, -38,
-40, -41, -43, -44, -46, -47, -49, -50, -52, -53, -54, -56, -56, -58, -60, -61,
-63, -64, -66, -67, -68, -68, -71, -72, -73, -75, -76, -78, -78, -79, -80, -81,
-82, -84, -86, -87, -87, -88, -89, -91, -91, -92, -93, -94, -94, -96, -96, -98,
-99, -99, -100, -102, -103, -103, -103, -104, -105, -106, -107, -106, -108,
-109, -109, -109, -110, -111, -111, -111, -112, -112, -113, -114, -114, -114,
-114, -116, -115, -116, -117, -116, -117, -116, -117, -117, -118, -118, -117,
-118, -119, -119, -119, -118, -118, -118, -119, -120, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -118, -118, -118, -119, -118, -117,
-118, -118, -117, -116, -116, -117, -116, -117, -116, -115, -115, -114, -115,
-113, -114, -113, -113, -113, -112, -112, -110, -110, -110, -110, -109, -107,
-107, -108, -106, -106, -104, -104, -103, -103, -101, -101, -100, -100, -98,
-97, -96, -95, -95, -94, -93, -91, -91, -89, -89, -88, -86, -86, -85, -83, -83,
-81, -80, -79, -78, -77, -75, -75, -73, -73, -71, -70, -69, -67, -66, -65, -64,
-63, -61, -60, -59, -58, -56, -54, -53, -52, -51, -49, -48, -47, -45, -44, -42,
-42, -40, -39, -37, -37, -35, -33, -32, -30, -29, -28, -27, -25, -23, -23, -21,
-20, -17, -17, -15, -13, -12, -11, -9, -8, -7, -4, -3, -2, -1, };