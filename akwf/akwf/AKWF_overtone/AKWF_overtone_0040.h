#define DATA_LENGTH 512
#define DATA AKWF_overtone_0040

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 7, 8, 9, 9, 8, 7, 7, 6, 6, 5, 7,
10, 12, 17, 21, 26, 31, 35, 39, 42, 44, 46, 47, 48, 48, 49, 49, 47, 47, 46, 45,
45, 44, 41, 42, 43, 45, 48, 51, 54, 57, 61, 64, 65, 66, 66, 64, 63, 60, 57, 54,
50, 46, 43, 41, 40, 37, 38, 30, 23, 22, 18, 14, 10, 7, 2, -2, -7, -11, -17, -22,
-27, -31, -35, -39, -43, -46, -50, -54, -57, -61, -64, -68, -70, -72, -74, -77,
-77, -78, -76, -76, -73, -71, -68, -66, -64, -59, -53, -50, -46, -44, -41, -35,
-30, -26, -23, -21, -20, -19, -18, -16, -15, -13, -10, -8, -5, -1, 1, 4, 7, 9,
10, 12, 11, 12, 12, 12, 12, 11, 11, 11, 12, 14, 16, 19, 21, 26, 30, 34, 38, 41,
43, 45, 46, 47, 49, 49, 50, 51, 50, 51, 51, 51, 51, 51, 51, 51, 51, 52, 53, 52,
50, 49, 48, 49, 49, 49, 49, 49, 47, 46, 44, 42, 39, 38, 35, 31, 29, 26, 24, 20,
17, 14, 12, 8, 6, 2, 0, -4, -2, -2, -3, -5, -3, -9, -37, -40, -41, -45, -48,
-53, -55, -59, -63, -66, -69, -72, -72, -74, -73, -73, -72, -71, -69, -68, -64,
-63, -59, -58, -54, -7, 1, 0, 3, 0, -1, -4, -4, -6, -5, -7, -6, -7, -6, -6, -5,
-4, -2, -1, 1, 2, 3, 5, 5, 6, 5, 6, 3, 3, 0, -2, -3, -4, -2, -1, 0, 1, 2, 3, 4,
7, 8, 10, 11, 11, 14, 15, 16, 18, 19, 20, 22, 23, 24, 24, 26, 26, 26, 27, 27,
28, 28, 30, 31, 32, 34, 37, 38, 40, 39, 39, 40, 40, 40, 40, 39, 38, 36, 35, 33,
30, 28, 25, 21, 17, 15, 11, 9, 5, 3, 1, -1, -2, -3, -11, -16, -15, -21, -23,
-26, -28, -31, -34, -38, -41, -44, -47, -48, -52, -53, -54, -53, -53, -53, -51,
-51, -49, -48, -46, -44, -43, -41, -39, -39, -37, -36, -37, -35, -34, -34, -32,
-32, -30, -26, -23, -21, -19, -14, -7, -1, 3, 6, 9, 11, 14, 14, 15, 17, 17, 17,
17, 15, 15, 13, 11, 11, 10, 10, 9, 9, 8, 11, 13, 16, 17, 19, 21, 25, 28, 30, 33,
36, 39, 40, 42, 45, 47, 48, 49, 49, 48, 47, 47, 45, 43, 44, 44, 43, 43, 43, 43,
44, 42, 43, 42, 41, 39, 34, 32, 31, 30, 29, 28, 28, 29, 31, 33, 36, 40, 44, 48,
52, 55, 56, 57, 56, 55, 52, 48, 42, 35, 30, 22, 17, 12, 14, 13, 15, 15, 20, 13,
-11, -11, -13, -16, -21, -28, -34, -43, -51, -61, -69, -79, -86, -96, -101,
-106, -109, -113, -114, -117, -116, -119, -117, -119, -110, -62, -56, -56, -52,
-54, -53, -55, -56, -58, -57, -59, -59, -58, -57, -56, -54, -51, -49, -45, -42,
-39, -36, -32, -31, -28, -28, -26, -24, -22, -20, -16, -12, -8, -2, };