#define DATA_LENGTH 512
#define DATA AKWF_overtone_0028

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 11, 15, 17, 14, 14, 13, 16, 22, 32,
40, 50, 58, 66, 73, 79, 86, 89, 93, 94, 91, 88, 84, 79, 73, 68, 63, 57, 53, 50,
49, 51, 53, 53, 54, 51, 47, 42, 36, 30, 23, 16, 8, 0, -7, -13, -18, -22, -24,
-24, -24, -22, -20, -19, -16, -17, -17, -17, -18, -21, -23, -26, -29, -29, -29,
-28, -26, -22, -17, -13, -8, -1, 3, 10, 13, 15, 17, 18, 18, 18, 18, 18, 19, 20,
22, 26, 29, 35, 39, 43, 47, 49, 48, 49, 46, 45, 42, 38, 36, 33, 31, 30, 28, 26,
26, 26, 26, 26, 25, 24, 22, 19, 16, 13, 10, 8, 4, 2, -2, -3, -6, -8, -10, -11,
-12, -12, -12, -11, -11, -10, -12, -12, -14, -16, -17, -19, -20, -21, -20, -18,
-16, -14, -11, -10, -6, -5, -3, -1, -1, 1, 2, 3, 4, 4, 3, 3, 3, 4, 5, 8, 10, 13,
16, 17, 18, 19, 19, 18, 18, 16, 15, 15, 15, 15, 14, 13, 11, 10, 9, 9, 10, 10,
10, 8, 5, 1, -2, -5, -7, -7, -7, -7, -6, -7, -8, -8, -9, -9, -9, -8, -8, -8, -9,
-9, -11, -15, -16, -18, -17, -17, -17, -17, -15, -13, -11, -11, -9, -10, -9, -8,
-8, -6, -5, -5, -6, -7, -10, -11, -10, -10, -6, -3, -1, 1, 1, 3, 2, 3, 4, 4, 5,
6, 6, 7, 6, 5, 5, 4, 2, 2, 1, 2, 5, 6, 7, 7, 6, 5, 4, 4, 3, 3, 3, 1, -1, -2, -3,
-4, -4, -5, -6, -7, -7, -7, -5, -4, -4, -5, -6, -5, -6, -7, -7, -9, -8, -10, -9,
-9, -8, -7, -7, -7, -7, -7, -6, -4, -3, -2, -1, 0, 0, 0, 0, 1, 2, 3, 4, 4, 5, 6,
7, 6, 8, 10, 11, 13, 13, 12, 12, 13, 13, 13, 14, 14, 14, 14, 14, 15, 14, 14, 15,
15, 14, 14, 13, 14, 14, 14, 14, 14, 14, 13, 11, 9, 6, 5, 4, 3, 4, 4, 6, 6, 6, 6,
7, 7, 6, 5, 3, 3, 2, 4, 4, 4, 5, 5, 4, 4, 4, 3, 6, 6, 5, 6, 5, 5, 5, 6, 7, 6, 7,
7, 7, 7, 8, 9, 11, 13, 13, 14, 13, 13, 14, 14, 15, 17, 18, 18, 18, 17, 17, 18,
20, 20, 21, 20, 20, 19, 20, 22, 24, 26, 26, 25, 24, 22, 21, 21, 19, 21, 21, 20,
19, 17, 15, 14, 12, 12, 13, 14, 13, 12, 9, 6, 4, 2, 1, -1, -3, -5, -6, -6, -6,
-6, -6, -7, -10, -12, -15, -17, -17, -17, -17, -18, -19, -20, -21, -20, -21,
-21, -23, -27, -31, -34, -37, -36, -34, -32, -30, -29, -28, -23, -17, -12, -9,
-15, -30, -51, -75, -94, -108, -114, -116, -114, -117, -118, -119, -116, -108,
-99, -89, -82, -80, -82, -86, -91, -97, -101, -108, -112, -113, -112, -105, -94,
-80, -66, -52, -42, -34, -25, -14, -4, };