#define DATA_LENGTH 512
#define DATA AKWF_overtone_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 6, 7, 6, 7, 7, 7, 8, 9, 9,
10, 10, 12, 12, 13, 15, 15, 16, 17, 17, 19, 19, 22, 22, 23, 25, 27, 27, 28, 30,
32, 33, 35, 36, 37, 40, 41, 42, 44, 46, 47, 49, 51, 52, 55, 56, 58, 59, 61, 64,
66, 67, 70, 71, 75, 76, 79, 81, 83, 85, 88, 89, 91, 92, 96, 98, 99, 99, 100,
101, 102, 103, 104, 105, 106, 106, 106, 107, 107, 107, 107, 109, 110, 112, 112,
113, 115, 116, 116, 117, 119, 118, 119, 117, 118, 115, 115, 110, 107, 100, 97,
85, 77, 39, -32, -42, -51, -57, -62, -66, -68, -70, -71, -74, -74, -76, -76,
-78, -77, -78, -78, -79, -78, -79, -79, -79, -78, -79, -78, -78, -78, -79, -78,
-78, -77, -77, -77, -76, -76, -76, -76, -76, -76, -76, -75, -75, -75, -75, -75,
-75, -76, -75, -75, -75, -76, -76, -76, -76, -76, -77, -78, -78, -80, -80, -81,
-83, -85, -86, -82, -79, -76, -72, -69, -66, -63, -60, -56, -54, -52, -48, -46,
-44, -41, -37, -36, -34, -31, -28, -26, -24, -23, -20, -19, -16, -14, -13, -10,
-9, -7, -6, -4, -3, -1, -1, 1, 2, 3, 5, 5, 7, 7, 8, 9, 9, 9, 11, 11, 11, 11, 12,
12, 12, 13, 13, 12, 12, 12, 12, 11, 11, 10, 10, 10, 9, 8, 8, 7, 6, 5, 4, 3, 1,
1, -1, -2, -3, -4, -5, -6, -2, 0, 4, 7, 9, 10, 11, 14, 15, 17, 18, 19, 20, 21,
23, 23, 25, 25, 26, 28, 27, 28, 29, 29, 29, 30, 30, 30, 30, 31, 31, 31, 32, 30,
31, 30, 30, 30, 30, 29, 30, 28, 28, 28, 28, 26, 26, 26, 25, 25, 23, 23, 22, 21,
20, 20, 19, 18, 17, 15, 15, 14, 13, 12, 11, 10, 9, 8, 8, 7, 5, 4, 3, 4, 2, 1, 0,
0, -1, 0, -1, 0, -1, 0, 0, 1, 4, 5, 12, 16, 64, 87, 87, 91, 90, 91, 90, 91, 88,
86, 84, 82, 79, 77, 74, 71, 68, 65, 61, 58, 54, 50, 47, 44, 41, 36, 33, 30, 28,
24, 23, 21, 19, 18, 18, 16, 16, 16, 15, 14, 13, 13, 13, 12, 10, 8, 7, 4, 2, 0,
-1, -4, -7, -8, -10, -13, -15, -18, -20, -21, -24, -26, -28, -30, -31, -33, -36,
-37, -39, -41, -42, -44, -45, -46, -48, -49, -49, -51, -52, -53, -54, -55, -56,
-57, -56, -58, -58, -59, -60, -60, -61, -61, -61, -62, -62, -62, -61, -62, -63,
-62, -61, -62, -62, -61, -61, -61, -61, -60, -60, -60, -59, -59, -59, -58, -57,
-56, -55, -54, -54, -52, -53, -50, -50, -49, -48, -47, -45, -44, -43, -42, -41,
-38, -37, -36, -33, -32, -31, -31, -31, -31, -31, -31, -30, -31, -31, -30, -29,
-28, -28, -29, -28, -26, -26, -25, -24, -23, -22, -21, -19, -18, -17, -16, -15,
-13, -12, -10, -9, -8, -5, -3, -1, };