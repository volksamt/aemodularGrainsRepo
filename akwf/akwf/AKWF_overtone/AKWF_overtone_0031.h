#define DATA_LENGTH 512
#define DATA AKWF_overtone_0031

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 13, 23, 31, 36, 40, 41, 42, 40, 38,
36, 33, 30, 27, 24, 21, 19, 17, 15, 14, 13, 12, 13, 11, 12, 11, 11, 12, 11, 12,
13, 12, 11, 12, 11, 11, 11, 10, 9, 10, 9, 9, 9, 8, 9, 8, 8, 7, 8, 7, 6, 7, 6, 6,
7, 6, 6, 6, 5, 5, 5, 5, 5, 4, 4, 4, 5, 5, 4, 3, 4, 4, 4, 4, 4, 3, 3, 4, 3, 3, 3,
2, 3, 2, 3, 3, 3, 2, 3, 3, 3, 3, 2, 2, 2, 3, 3, 1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2,
2, 1, 1, 1, 1, 2, 2, 2, 2, 1, 2, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 2,
1, 1, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 0, 0,
1, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, 1, -1, 1, 0, 0, 0, 1, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0,
-1, 0, 0, 0, 1, 0, 0, 0, -1, -1, 1, 0, 0, -1, 0, 0, 0, 0, -1, -1, 0, 0, 0, -1,
1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0,
0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 0, 0, 1, 1, 1, 1, 0, 1, 0, 0, 1, 0,
1, 1, 0, 1, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 0, 0, 0, 0, 1, 1, 1, 0, 1, 1, 0, 0, 1,
1, 1, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 0, 2, 1, 0, 0, 1, 0, 0, 0, 1, 0, 1, 0, 1, 1,
1, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 1, 1, 1, 2, 0, 0, 1, 0, 0, 1, 1, 0, 1, 1, 1,
1, 1, 1, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 0, 1, 1, 1, 0, 1,
1, 0, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 0, 0, 1, 1, 1, 1, 0, 1, 1, 1, 1, 0,
0, 0, 0, 0, 0, 1, -1, 1, 0, 0, 0, 1, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0,
1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, -1, -1, 0, 0, 0, -1, -1,
0, 0, 0, 0, 0, 0, 0, 0, -1, -1, -1, 0, 0, 0, 0, 0, 0, -1, -3, -10, -25, -47,
-69, -88, -103, -114, -119, -118, -112, -103, -89, -74, -58, -41, -25, -10, };