#define DATA_LENGTH 512
#define DATA AKWF_overtone_0026

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 11, 14, 16, 18, 20, 22, 23, 24,
25, 25, 26, 25, 26, 26, 25, 26, 25, 24, 25, 25, 24, 23, 23, 23, 21, 21, 21, 21,
20, 20, 20, 19, 20, 19, 18, 18, 18, 18, 17, 19, 25, 30, 33, 35, 38, 40, 42, 44,
45, 47, 48, 49, 51, 52, 54, 55, 56, 57, 58, 59, 60, 61, 61, 62, 63, 64, 64, 65,
65, 66, 66, 67, 68, 69, 69, 69, 69, 69, 70, 70, 71, 70, 71, 71, 71, 71, 72, 72,
72, 72, 72, 72, 72, 72, 72, 71, 72, 71, 71, 71, 71, 71, 71, 71, 70, 70, 70, 69,
69, 69, 67, 59, 54, 49, 45, 43, 39, 37, 35, 32, 29, 27, 25, 23, 21, 19, 17, 15,
13, 12, 11, 8, 8, 6, 5, 3, 2, 0, -1, -2, -3, -3, -5, -6, -7, -7, -9, -9, -11,
-11, -13, -13, -13, -13, -14, -15, -16, -16, -17, -16, -17, -17, -18, -18, -18,
-18, -18, -18, -9, -6, 0, -1, 5, 3, 10, 6, 15, 7, 23, -9, -99, -87, -95, -94,
-96, -97, -97, -100, -99, -102, -101, -105, -103, -106, -105, -108, -107, -110,
-108, -111, -110, -112, -111, -113, -112, -114, -114, -115, -115, -116, -116,
-116, -118, -117, -119, -115, -120, -116, -120, -116, -121, -116, -121, -116,
-122, -116, -121, -118, -119, -121, 45, 71, 56, 68, 58, 67, 59, 67, 58, 56, 46,
46, 40, 39, 35, 35, 30, 30, 26, 25, 23, 21, 20, 18, 16, 15, 14, 12, 11, 10, 9,
7, 6, 4, 4, 3, 3, 1, 1, 0, 0, -1, -2, -2, -3, -3, -4, -4, -5, -5, -5, -6, -6,
-6, -7, -7, -7, -8, -8, -7, -7, -7, -8, -7, -7, -4, 4, 7, 10, 14, 17, 19, 21,
22, 25, 27, 29, 30, 32, 33, 36, 38, 38, 39, 41, 42, 43, 46, 46, 47, 48, 50, 51,
52, 53, 54, 55, 55, 57, 57, 59, 59, 60, 60, 62, 62, 63, 64, 65, 65, 66, 66, 67,
67, 68, 69, 69, 69, 70, 70, 70, 71, 72, 72, 73, 72, 73, 74, 73, 74, 73, 73, 74,
74, 74, 75, 72, 64, 59, 56, 53, 50, 47, 45, 43, 40, 40, 37, 36, 34, 32, 31, 29,
28, 26, 25, 25, 23, 22, 21, 20, 19, 18, 17, 16, 16, 14, 13, 13, 12, 12, 12, 10,
10, 9, 9, 9, 9, 8, 8, 8, 8, 6, 8, 6, 9, 5, 11, -6, -30, -23, -28, -24, -28, -36,
-39, -42, -45, -47, -48, -51, -52, -54, -56, -58, -58, -60, -61, -62, -63, -64,
-66, -67, -68, -69, -69, -70, -71, -73, -73, -73, -75, -75, -76, -77, -77, -78,
-78, -78, -80, -81, -81, -81, -81, -82, -82, -83, -82, -83, -83, -84, -84, -84,
-85, -85, -85, -85, -85, -85, -86, -85, -86, -86, -85, -86, -87, -86, -87, -86,
-86, -86, -86, -85, -85, -82, -75, -70, -67, -62, -60, -57, -54, -52, -51, -46,
-34, -24, -16, -8, -2, };