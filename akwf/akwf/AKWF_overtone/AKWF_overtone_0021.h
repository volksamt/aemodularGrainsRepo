#define DATA_LENGTH 512
#define DATA AKWF_overtone_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {24, 30, 27, 29, 26, 28, 73, 79, 74,
78, 72, 76, 71, 75, 70, 74, 67, 74, 63, 84, 123, 115, 119, 115, 117, 113, 115,
111, 115, 108, 116, 92, 52, 61, 55, 56, 55, 54, 55, 53, 53, 51, 50, 48, 50, 47,
48, 46, 46, 46, 44, 45, -4, -9, -14, 12, 47, 34, 41, 34, 37, 33, 35, 32, 32, 32,
31, 30, 29, 29, 27, 28, 25, 26, 23, 25, 23, 22, 20, 20, 20, 18, 18, 16, 18, 14,
16, 10, 19, -6, -45, -37, -43, -40, -43, -42, -44, -45, -46, -46, -46, -48, -47,
-48, -49, -51, -50, -52, -51, -53, -53, -53, -54, -55, -55, -56, -57, -58, -58,
-57, -59, -59, -61, -58, -67, -34, -5, -16, -9, -15, -12, -16, -14, -16, -15,
-18, -16, -18, -19, 26, 35, 29, 32, 29, 31, 28, 29, 27, 28, 25, 26, 25, 24, 25,
24, 24, 22, 24, 21, 23, 20, 23, 17, 26, 5, -36, -30, -33, -31, -32, -33, -33,
-33, -34, -34, -34, -35, -34, -34, -34, -36, -35, -35, -35, -35, -35, -37, -37,
-37, -37, -37, -37, -37, -37, -37, -37, -36, -37, -37, -37, -37, -36, -37, -37,
-36, -36, -36, -37, -36, -37, -36, -36, -36, -35, -35, -36, -36, -35, -35, -35,
-34, -35, -34, -34, -33, -34, -33, -33, -33, -33, -32, -33, -32, -31, -31, -30,
-30, -30, -31, -29, -29, -29, -28, -28, -27, -29, -25, -28, -25, -28, -22, -32,
-1, 33, 25, 29, 27, 29, 29, 29, 29, 77, 85, 79, 84, 81, 84, 82, 85, 83, 85, 84,
85, 85, 87, 86, 87, 87, 88, 88, 88, 89, 89, 90, 90, 92, 90, 93, 91, 95, 90, 99,
77, 37, 47, 43, 47, 45, 47, 47, 48, 47, 50, 49, 51, 50, 53, 50, 3, 2, 4, 4, 6,
5, 7, 5, 8, 8, 9, 9, 10, 11, 11, 12, 13, 15, 15, 16, 16, 18, 17, 18, 19, 20, 21,
21, 22, 22, 25, 23, 29, -12, -30, -21, -26, -20, -24, -19, -22, -17, -20, -15,
-20, -14, -21, -66, -65, -63, -64, -61, -62, -60, -61, -58, -59, -57, -57, -55,
-56, -54, -53, -52, -52, -50, -50, -49, -49, -47, -46, -46, -45, -46, -43, -45,
-40, -49, -14, 17, 8, 13, 10, 14, 11, 15, 14, 16, 15, 16, 16, 17, 18, 18, 19,
19, 20, 19, 21, 20, 22, 22, 24, 22, 25, 21, 31, -3, -32, -22, -27, -23, -24,
-23, -24, -22, -23, -22, -21, -21, -20, -20, -20, -20, -20, -19, -18, -19, -19,
-18, -18, -17, -18, -18, -16, -16, -16, -16, -16, -16, -15, -15, -15, -16, -15,
-15, -15, -15, -15, -14, -14, -14, -14, -13, -14, -13, -15, -13, -15, -13, -15,
-13, -15, -14, -16, -13, -16, -11, -22, -67, -66, -66, -66, -65, -66, -65, -67,
-65, -67, -65, -68, -65, -68, -66, -69, -66, -69, -66, -69, -65, -71, -63, -17,
-18, -19, -18, -20, -18, -20, -20, -22, -19, -23, -18, };