#define DATA_LENGTH 512
#define DATA AKWF_overtone_0027

const PROGMEM int8_t DATA[DATA_LENGTH] = {33, 84, 107, 108, 90, 70, 51, 43, 37,
36, 35, 34, 35, 37, 40, 45, 50, 53, 53, 54, 52, 52, 52, 52, 52, 53, 53, 53, 54,
55, 55, 56, 56, 57, 56, 57, 57, 58, 58, 57, 57, 58, 57, 57, 56, 57, 56, 56, 56,
55, 56, 54, 55, 53, 54, 54, 53, 52, 52, 52, 50, 50, 49, 48, 48, 47, 46, 46, 45,
45, 43, 43, 42, 42, 41, 39, 39, 37, 37, 36, 35, 34, 34, 33, 32, 31, 31, 29, 28,
27, 27, 26, 24, 23, 23, 22, 21, 21, 19, 18, 17, 16, 16, 15, 14, 13, 12, 12, 10,
9, 8, 7, 7, 5, 6, 4, 4, 2, 2, 1, 0, 0, -1, -2, -3, -3, -4, -5, -6, -7, -8, -7,
-9, -9, -10, -11, -12, -12, -13, -13, -14, -14, -14, -15, -16, -16, -17, -17,
-19, -19, -20, -20, -20, -21, -22, -21, -22, -23, -23, -23, -23, -24, -24, -25,
-24, -26, -26, -26, -26, -26, -26, -26, -26, -27, -27, -27, -27, -27, -28, -28,
-28, -28, -28, -28, -28, -28, -28, -28, -28, -29, -28, -29, -28, -28, -29, -29,
-28, -28, -28, -28, -27, -27, -28, -28, -27, -26, -27, -27, -26, -26, -26, -25,
-25, -25, -25, -24, -25, -24, -23, -24, -22, -23, -22, -22, -21, -21, -20, -20,
-20, -19, -18, -18, -18, -19, -18, -17, -16, -17, -16, -15, -15, -14, -14, -14,
-13, -12, -12, -11, -11, -11, -10, -9, -9, -9, -9, -8, -7, -6, -6, -5, -6, -4,
-4, -3, -2, -2, -1, -1, -1, 0, 1, 1, 2, 2, 3, 3, 4, 4, 5, 6, 5, 7, 7, 7, 8, 8,
9, 10, 11, 11, 10, 11, 13, 12, 14, 13, 14, 15, 15, 15, 17, 16, 17, 18, 17, 18,
18, 19, 20, 20, 20, 20, 21, 21, 22, 22, 22, 24, 23, 23, 24, 25, 24, 24, 24, 25,
25, 26, 26, 26, 27, 27, 28, 27, 27, 27, 29, 28, 28, 29, 29, 29, 28, 29, 29, 29,
29, 29, 29, 29, 29, 29, 30, 29, 29, 29, 29, 30, 30, 29, 29, 29, 30, 29, 29, 28,
28, 28, 29, 28, 27, 27, 27, 27, 26, 26, 26, 25, 25, 25, 25, 25, 24, 23, 23, 23,
22, 22, 21, 21, 21, 20, 20, 19, 18, 18, 17, 16, 16, 16, 15, 14, 14, 12, 12, 12,
10, 11, 10, 9, 8, 8, 6, 5, 5, 4, 3, 2, 1, 0, 0, 0, -3, -3, -4, -5, -5, -7, -8,
-8, -10, -11, -12, -13, -14, -15, -16, -17, -19, -19, -21, -22, -24, -24, -25,
-26, -28, -28, -30, -32, -33, -33, -35, -36, -38, -39, -41, -41, -44, -44, -46,
-47, -48, -50, -51, -52, -54, -55, -57, -58, -60, -61, -62, -64, -66, -67, -69,
-70, -72, -73, -74, -76, -78, -79, -81, -82, -85, -86, -87, -89, -90, -92, -93,
-96, -97, -99, -101, -102, -103, -105, -107, -109, -109, -111, -114, -115, -116,
-118, -118, -108, -70, -16, };