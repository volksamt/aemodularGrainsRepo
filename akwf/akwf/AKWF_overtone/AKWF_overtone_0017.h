#define DATA_LENGTH 512
#define DATA AKWF_overtone_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 13, 18, 24, 29, 34, 38, 43, 46,
50, 54, 57, 59, 63, 65, 67, 69, 70, 72, 72, 73, 75, 74, 74, 75, 73, 73, 72, 71,
69, 67, 66, 64, 62, 59, 58, 55, 52, 50, 47, 43, 40, 37, 35, 31, 28, 24, 21, 18,
14, 11, 8, 5, 2, -1, -4, -7, -10, -13, -15, -17, -20, -23, -25, -27, -29, -30,
-31, -33, -34, -36, -38, -38, -39, -40, -41, -41, -40, -41, -41, -41, -40, -40,
-40, -40, -39, -37, -37, -35, -35, -34, -32, -31, -31, -28, -27, -25, -23, -23,
-20, -19, -17, -15, -14, -11, -12, -9, -7, -6, -4, -3, 0, 0, 2, 3, 5, 6, 7, 8,
10, 11, 12, 12, 13, 14, 15, 15, 16, 16, 16, 17, 17, 18, 17, 18, 18, 17, 18, 18,
18, 18, 17, 17, 16, 15, 15, 14, 14, 13, 12, 12, 10, 10, 9, 9, 8, 7, 6, 5, 4, 4,
2, 1, 1, 0, -1, -1, -2, -3, -3, -4, -5, -5, -7, -7, -8, -8, -8, -8, -10, -10,
-10, -10, -10, -10, -11, -11, -11, -11, -12, -11, -11, -11, -11, -11, -11, -11,
-10, -11, -10, -10, -9, -9, -8, -9, -8, -7, -7, -7, -6, -5, -5, -5, -4, -4, -3,
-3, -3, -2, -1, -1, 0, -1, 1, 1, 1, 1, 2, 2, 3, 3, 3, 4, 4, 4, 4, 5, 5, 5, 5, 5,
5, 5, 6, 5, 5, 6, 6, 6, 6, 6, 6, 5, 5, 5, 6, 5, 4, 5, 5, 4, 5, 4, 4, 4, 4, 4, 3,
3, 3, 3, 2, 3, 2, 2, 2, 1, 2, 0, 1, 2, 1, 1, 0, 1, 1, -1, 0, 0, -1, -1, -1, 0,
-2, 0, -1, -2, -2, -1, -1, -1, -1, -1, -1, -2, -1, 0, -1, -2, -1, -1, -1, -1,
-1, 0, -1, -1, 0, 0, -1, 0, 0, 1, 0, 0, 1, 1, 2, 2, 1, 2, 1, 2, 1, 2, 2, 2, 2,
2, 2, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 4, 2, 3, 4, 3, 3, 3, 3, 3, 3, 4, 3, 3, 3, 3,
3, 3, 4, 2, 3, 3, 2, 3, 2, 3, 3, 3, 2, 3, 3, 2, 2, 2, 2, 2, 3, 2, 2, 2, 2, 1, 2,
2, 2, 2, 1, 1, 1, 1, 1, 0, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 0,
1, 0, 1, 1, 0, 0, 0, 1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 2, 1, 1, 1, 1, 1, 1, 1, 0, 0,
0, 1, 1, 1, 1, 1, 2, 2, 1, 1, 2, 1, 0, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1,
1, 1, 1, 0, 0, 0, 0, 1, 0, 1, 0, 0, -8, -52, -101, -120, -115, -106, -105, -110,
-114, -108, -96, -84, -75, -73, -71, -67, -61, -51, -42, -36, -31, -27, -22,
-14, -7, -1, };