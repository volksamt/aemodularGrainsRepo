#define DATA_LENGTH 512
#define DATA AKWF_overtone_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {13, 40, 63, 83, 99, 111, 117, 118,
117, 110, 102, 95, 87, 81, 78, 77, 78, 80, 83, 85, 88, 88, 87, 85, 82, 77, 73,
69, 67, 64, 65, 65, 66, 66, 67, 68, 67, 65, 63, 60, 57, 54, 53, 50, 50, 49, 49,
50, 51, 50, 50, 48, 47, 44, 41, 39, 37, 36, 34, 34, 34, 34, 34, 34, 33, 33, 31,
30, 28, 25, 23, 22, 21, 21, 20, 20, 20, 19, 19, 18, 17, 17, 14, 13, 11, 10, 9,
8, 8, 7, 7, 7, 7, 7, 6, 4, 3, 2, 0, 0, 0, -1, -2, -1, -2, -2, -3, -3, -3, -4,
-6, -7, -6, -8, -9, -9, -9, -9, -10, -10, -10, -10, -11, -11, -11, -12, -13,
-13, -13, -14, -14, -15, -14, -14, -14, -14, -14, -14, -15, -16, -16, -15, -16,
-16, -17, -16, -16, -16, -15, -16, -15, -16, -16, -16, -16, -16, -16, -15, -15,
-15, -15, -15, -15, -16, -15, -14, -14, -14, -13, -13, -13, -13, -12, -12, -12,
-12, -11, -11, -11, -10, -10, -9, -9, -8, -7, -7, -6, -6, -5, -5, -5, -6, -5,
-4, -3, -3, -2, 0, 1, 1, 2, 2, 2, 3, 4, 4, 4, 4, 5, 7, 7, 8, 10, 11, 11, 13, 13,
14, 14, 13, 14, 15, 16, 17, 18, 19, 21, 23, 23, 25, 25, 25, 25, 25, 25, 26, 28,
29, 30, 32, 34, 36, 37, 37, 39, 39, 39, 38, 38, 39, 39, 41, 43, 46, 48, 50, 51,
52, 53, 53, 53, 52, 51, 52, 53, 54, 56, 59, 62, 65, 68, 69, 69, 68, 67, 65, 64,
64, 64, 67, 69, 73, 76, 79, 83, 86, 85, 85, 83, 79, 76, 74, 73, 74, 79, 84, 91,
99, 106, 112, 114, 111, 103, 91, 74, 52, 31, 7, -16, -34, -49, -60, -64, -65,
-61, -54, -46, -39, -33, -27, -24, -25, -26, -28, -31, -34, -36, -36, -34, -32,
-29, -25, -22, -19, -16, -15, -15, -17, -18, -18, -20, -18, -18, -18, -15, -12,
-10, -8, -6, -6, -5, -5, -6, -6, -6, -6, -6, -6, -4, -2, -1, 2, 3, 4, 4, 4, 4,
4, 3, 3, 3, 4, 5, 7, 7, 8, 9, 9, 11, 11, 10, 10, 11, 10, 11, 10, 12, 12, 13, 14,
13, 14, 15, 15, 15, 15, 14, 15, 16, 15, 15, 15, 16, 15, 16, 16, 16, 16, 16, 16,
15, 16, 16, 16, 17, 16, 16, 16, 16, 15, 14, 15, 14, 15, 15, 14, 15, 14, 14, 14,
14, 13, 13, 11, 12, 11, 11, 11, 11, 11, 11, 10, 10, 10, 10, 8, 7, 5, 5, 5, 5, 4,
4, 5, 5, 4, 4, 4, 2, 1, -1, -2, -3, -4, -5, -5, -4, -3, -3, -4, -4, -4, -7, -9,
-11, -14, -15, -16, -16, -16, -15, -14, -12, -12, -13, -13, -15, -19, -23, -25,
-29, -31, -32, -31, -29, -26, -23, -21, -20, -21, -23, -28, -35, -43, -50, -55,
-58, -57, -50, -39, -23, -4, };