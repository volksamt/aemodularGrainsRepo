#define DATA_LENGTH 512
#define DATA AKWF_overtone_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 11, 18, 27, 36, 44, 52, 61, 69, 76,
83, 88, 95, 100, 105, 108, 113, 115, 116, 119, 119, 119, 119, 117, 116, 113,
110, 107, 102, 97, 93, 88, 82, 75, 68, 62, 54, 48, 40, 33, 25, 17, 10, 2, -6,
-13, -20, -27, -34, -41, -47, -55, -59, -65, -71, -75, -80, -84, -89, -91, -94,
-98, -99, -101, -104, -104, -104, -105, -105, -103, -103, -101, -100, -98, -96,
-93, -90, -87, -83, -81, -76, -72, -68, -64, -59, -55, -51, -46, -42, -37, -32,
-27, -23, -17, -13, -9, -4, 0, 5, 9, 12, 16, 19, 23, 26, 30, 33, 35, 38, 41, 42,
43, 46, 48, 48, 48, 50, 51, 51, 51, 50, 51, 51, 50, 49, 49, 47, 47, 44, 43, 41,
40, 38, 37, 34, 32, 30, 28, 25, 24, 21, 19, 17, 15, 13, 10, 9, 6, 5, 3, 1, -2,
-3, -5, -6, -7, -10, -11, -11, -13, -14, -14, -16, -16, -16, -17, -18, -17, -18,
-17, -18, -17, -17, -16, -15, -15, -14, -14, -13, -12, -11, -11, -8, -8, -7, -5,
-5, -3, -1, -1, 1, 2, 3, 5, 6, 7, 9, 10, 11, 12, 13, 15, 15, 17, 18, 19, 21, 21,
22, 23, 24, 24, 25, 25, 26, 26, 27, 27, 27, 27, 27, 28, 28, 27, 28, 27, 27, 27,
27, 27, 26, 26, 26, 25, 25, 25, 24, 23, 23, 21, 21, 20, 20, 19, 18, 19, 17, 16,
16, 15, 15, 15, 14, 12, 10, 4, -4, -12, -19, -28, -36, -45, -54, -61, -69, -77,
-83, -89, -96, -101, -105, -108, -112, -115, -117, -119, -119, -118, -118, -116,
-115, -113, -110, -106, -102, -97, -92, -87, -80, -74, -68, -61, -53, -47, -39,
-31, -24, -17, -9, -1, 6, 13, 20, 28, 35, 42, 49, 54, 60, 66, 71, 76, 81, 84,
88, 92, 95, 98, 100, 102, 103, 103, 105, 105, 104, 104, 103, 102, 99, 98, 95,
93, 90, 87, 83, 80, 76, 71, 68, 64, 60, 55, 51, 45, 41, 36, 31, 27, 21, 18, 13,
9, 4, 0, -5, -9, -13, -17, -20, -25, -27, -31, -33, -36, -38, -40, -42, -44,
-46, -47, -49, -50, -50, -50, -51, -52, -51, -50, -50, -50, -48, -47, -47, -46,
-44, -43, -42, -39, -38, -36, -34, -32, -30, -29, -26, -23, -21, -19, -17, -15,
-13, -11, -8, -7, -4, -2, 0, 1, 2, 5, 7, 8, 9, 11, 12, 12, 14, 15, 16, 16, 16,
17, 18, 17, 18, 17, 17, 18, 16, 17, 15, 15, 15, 14, 13, 12, 11, 10, 10, 8, 7, 6,
4, 2, 2, 0, -1, -3, -3, -5, -6, -8, -8, -10, -11, -12, -14, -15, -16, -17, -19,
-20, -21, -21, -21, -23, -24, -25, -24, -25, -26, -26, -27, -26, -27, -28, -27,
-28, -28, -28, -28, -27, -27, -27, -27, -26, -26, -25, -25, -24, -25, -24, -23,
-23, -22, -22, -22, -21, -20, -20, -18, -19, -17, -17, -16, -15, -15, -14, -14,
-13, -10, -3, };