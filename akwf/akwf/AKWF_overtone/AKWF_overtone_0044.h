#define DATA_LENGTH 512
#define DATA AKWF_overtone_0044

const PROGMEM int8_t DATA[DATA_LENGTH] = {23, 28, 26, 27, 25, 28, 25, 26, 24,
18, 13, 11, 9, 6, 3, 1, 1, 3, 3, 3, 3, 4, 9, 12, 14, 15, 16, 16, 16, 15, 14, 14,
13, 11, 10, 10, 8, 8, 7, 6, 5, 4, 4, 4, 3, 5, 6, 7, 8, 9, 10, 10, 11, 10, 11,
12, 12, 12, 13, 14, 13, 15, 14, 15, 14, 17, 24, 27, 29, 32, 34, 36, 38, 39, 40,
42, 44, 45, 46, 47, 47, 45, 44, 44, 42, 42, 43, 43, 42, 42, 42, 42, 42, 42, 42,
43, 42, 42, 43, 44, 44, 44, 44, 44, 45, 46, 45, 47, 46, 50, 52, 55, 56, 59, 57,
32, 27, 29, 27, 28, 26, 28, 27, 27, 25, 27, 25, 27, 25, 27, 24, 26, 25, 27, 25,
26, 23, 17, 15, 9, 50, 62, 54, 56, 51, 48, 42, 40, 36, 35, 32, 30, 28, 27, 25,
23, 21, 20, 18, 17, 16, 14, 14, 12, 11, 11, 10, 9, 9, 8, 7, 6, 7, 10, 11, 12,
14, 14, 15, 17, 16, 17, 17, 19, 18, 20, 19, 24, 10, -8, -2, -5, -2, -4, -10,
-13, -14, -16, -18, -19, -21, -21, -23, -24, -26, -26, -27, -28, -31, -35, -36,
-40, -42, -43, -45, -47, -49, -51, -51, -53, -54, -55, -56, -57, -58, -58, -60,
-60, -61, -61, -63, -63, -64, -63, -70, -75, -74, -77, -79, -81, -83, -84, -84,
-85, -87, -86, -88, -90, -89, -90, -90, -91, -91, -92, -92, -92, -93, -93, -93,
-94, -93, -94, -92, -94, -91, -85, -82, -78, -76, -74, -70, -70, -65, -59, -55,
-43, -34, -25, -13, -4, 4, 9, 14, 17, 20, 22, 24, 25, 26, 27, 27, 27, 28, 27,
28, 26, 26, 27, 25, 25, 25, 27, 29, 30, 30, 31, 32, 32, 33, 33, 33, 33, 34, 33,
34, 34, 33, 35, 35, 34, 34, 37, 42, 46, 49, 49, 52, 54, 55, 57, 58, 59, 60, 61,
61, 63, 61, 59, 58, 58, 56, 56, 56, 54, 54, 54, 54, 54, 53, 52, 52, 52, 52, 52,
52, 52, 51, 51, 51, 52, 51, 51, 52, 52, 51, 55, 56, 60, 59, 62, 59, 32, 31, 30,
28, 30, 28, 28, 27, 26, 25, 26, 24, 25, 23, 25, 22, 23, 21, 22, 20, 22, 18, 12,
7, 6, 48, 53, 48, 48, 42, 38, 34, 31, 28, 26, 23, 21, 17, 17, 13, 12, 9, 9, 6,
4, 3, 2, 1, -1, -1, -3, -4, -6, -6, -7, -8, -8, -9, -7, -6, -4, -4, -2, -2, -2,
-2, -1, 0, 0, -1, 0, 1, 2, 2, 2, 2, 3, 3, 6, 13, 15, 19, 21, 24, 24, 29, 25, 34,
26, 43, -5, -62, -47, -59, -58, -64, -63, -67, -69, -71, -73, -73, -76, -77,
-79, -80, -82, -81, -84, -84, -86, -85, -88, -86, -88, -88, -90, -90, -90, -97,
-102, -101, -105, -106, -108, -111, -110, -113, -111, -115, -113, -116, -114,
-119, -114, -120, -114, -122, -114, -127, -101, };