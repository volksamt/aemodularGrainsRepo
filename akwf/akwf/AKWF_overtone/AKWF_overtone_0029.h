#define DATA_LENGTH 512
#define DATA AKWF_overtone_0029

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 5, 7, 9, 10, 12, 13, 13, 15, 14,
13, 11, 10, 8, 7, 7, 6, 5, 4, 4, 4, 4, 5, 6, 7, 10, 13, 16, 19, 23, 25, 29, 31,
33, 36, 38, 41, 41, 42, 41, 39, 38, 36, 34, 32, 32, 32, 32, 32, 32, 32, 32, 32,
31, 29, 29, 29, 28, 28, 28, 29, 30, 32, 34, 36, 42, 47, 54, 61, 67, 74, 79, 82,
84, 85, 84, 81, 77, 69, 62, 53, 43, 35, 27, 21, 18, 17, 18, 20, 21, 23, 23, 22,
19, 13, 6, -1, -12, -24, -37, -49, -62, -74, -85, -93, -101, -107, -110, -114,
-116, -118, -119, -119, -118, -116, -113, -109, -105, -102, -99, -97, -95, -94,
-95, -94, -93, -92, -90, -87, -85, -82, -77, -73, -68, -62, -57, -52, -48, -44,
-40, -38, -36, -32, -30, -26, -21, -16, -11, -7, -3, 0, 1, 2, 0, 0, -3, -6, -8,
-10, -10, -11, -10, -9, -5, -1, 5, 11, 17, 22, 28, 32, 35, 37, 39, 39, 41, 40,
39, 37, 37, 35, 34, 32, 33, 34, 38, 41, 46, 52, 57, 64, 69, 75, 79, 84, 86, 87,
86, 84, 81, 77, 73, 68, 64, 59, 55, 52, 52, 49, 48, 45, 43, 40, 39, 35, 31, 27,
21, 16, 10, 3, -3, -9, -13, -19, -25, -29, -34, -38, -43, -48, -53, -57, -61,
-65, -69, -72, -74, -75, -75, -74, -72, -70, -66, -63, -59, -56, -52, -49, -46,
-44, -42, -41, -40, -40, -39, -38, -37, -37, -37, -35, -34, -32, -30, -25, -22,
-17, -13, -9, -3, 1, 4, 6, 8, 9, 9, 6, 5, 1, -2, -2, -4, -4, -3, -2, 2, 5, 10,
16, 20, 25, 29, 32, 36, 37, 39, 40, 41, 42, 42, 41, 42, 43, 42, 43, 44, 44, 44,
44, 45, 46, 48, 50, 52, 54, 55, 58, 60, 62, 61, 63, 62, 60, 58, 57, 54, 51, 49,
45, 42, 39, 34, 32, 27, 23, 19, 15, 10, 8, 4, 0, -3, -5, -8, -11, -13, -14, -17,
-20, -23, -26, -30, -35, -39, -44, -48, -52, -54, -57, -58, -59, -57, -55, -53,
-50, -46, -44, -39, -36, -33, -31, -29, -27, -25, -23, -23, -23, -20, -20, -20,
-20, -19, -18, -17, -15, -14, -12, -9, -6, -4, -1, 2, 5, 8, 9, 11, 10, 10, 8, 6,
4, 2, -1, -2, -5, -6, -6, -7, -7, -8, -6, -6, -5, -5, -3, -2, -1, 0, 1, 3, 4, 5,
6, 7, 9, 9, 9, 10, 9, 9, 10, 10, 10, 12, 13, 16, 19, 21, 24, 28, 31, 34, 37, 40,
40, 42, 42, 42, 41, 40, 38, 35, 33, 28, 24, 20, 16, 12, 8, 5, 1, -1, -4, -6, -8,
-9, -10, -11, -13, -14, -17, -19, -21, -24, -27, -32, -36, -39, -41, -43, -44,
-46, -46, -44, -43, -40, -40, -37, -34, -31, -29, -26, -24, -21, -20, -18, -17,
-17, -15, -13, -12, -12, -11, -9, -10, -7, -6, -5, -3, -2, -1, };