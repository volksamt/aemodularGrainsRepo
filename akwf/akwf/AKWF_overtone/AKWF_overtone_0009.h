#define DATA_LENGTH 512
#define DATA AKWF_overtone_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 10, 14, 16, 21, 24, 27, 29, 32,
35, 37, 38, 39, 40, 42, 44, 45, 47, 48, 50, 50, 53, 53, 54, 55, 55, 55, 55, 57,
57, 58, 59, 59, 60, 62, 63, 64, 64, 64, 65, 65, 66, 65, 65, 65, 66, 66, 67, 66,
66, 66, 65, 65, 66, 67, 68, 69, 70, 71, 71, 73, 74, 76, 77, 79, 81, 84, 86, 86,
87, 88, 88, 89, 90, 89, 88, 87, 86, 82, 79, 77, 74, 71, 69, 67, 64, 60, 56, 52,
49, 46, 43, 39, 36, 34, 32, 29, 29, 26, 24, 23, 23, 22, 21, 20, 19, 16, 15, 13,
13, 12, 11, 10, 7, 5, 4, 0, -2, -5, -10, -14, -19, -24, -26, -31, -34, -38, -41,
-43, -45, -47, -49, -52, -53, -56, -56, -56, -58, -57, -58, -58, -57, -56, -55,
-53, -54, -54, -54, -53, -54, -55, -56, -58, -59, -61, -63, -66, -69, -70, -74,
-78, -80, -84, -87, -90, -93, -95, -99, -103, -106, -108, -111, -115, -116,
-119, -119, -119, -117, -118, -116, -114, -114, -111, -110, -109, -108, -106,
-105, -104, -102, -100, -98, -97, -94, -92, -90, -89, -88, -87, -85, -85, -82,
-82, -79, -78, -76, -73, -69, -67, -63, -60, -56, -51, -45, -40, -34, -30, -23,
-18, -12, -6, -1, 4, 9, 14, 20, 25, 31, 34, 39, 44, 48, 52, 55, 60, 61, 64, 66,
68, 71, 73, 75, 76, 78, 80, 81, 81, 82, 83, 85, 85, 84, 85, 86, 86, 86, 86, 87,
88, 88, 88, 89, 89, 90, 90, 90, 89, 87, 87, 87, 85, 84, 83, 82, 80, 77, 74, 72,
69, 66, 65, 63, 61, 60, 58, 57, 57, 58, 57, 58, 59, 60, 60, 60, 61, 61, 60, 60,
60, 60, 59, 59, 58, 56, 55, 53, 51, 49, 46, 42, 39, 36, 33, 29, 26, 22, 19, 16,
13, 11, 9, 8, 6, 4, 4, 2, 2, 2, 2, 2, 1, 2, 0, -2, -3, -5, -7, -10, -10, -13,
-14, -16, -17, -18, -19, -19, -20, -20, -20, -20, -20, -20, -20, -21, -21, -21,
-22, -22, -23, -24, -25, -26, -26, -27, -27, -27, -27, -27, -27, -27, -28, -27,
-28, -27, -27, -28, -28, -29, -28, -29, -30, -30, -30, -30, -30, -30, -30, -30,
-30, -31, -32, -32, -32, -32, -32, -32, -32, -33, -32, -32, -32, -31, -30, -29,
-27, -25, -24, -23, -21, -19, -17, -15, -13, -12, -11, -11, -9, -10, -9, -8, -7,
-7, -6, -7, -6, -7, -7, -7, -8, -8, -9, -9, -10, -11, -11, -12, -13, -14, -14,
-14, -15, -16, -17, -17, -19, -20, -21, -22, -23, -25, -25, -27, -29, -30, -32,
-33, -34, -36, -37, -38, -39, -39, -41, -40, -42, -42, -43, -44, -44, -45, -46,
-48, -48, -50, -50, -52, -52, -53, -54, -54, -55, -56, -57, -56, -56, -56, -58,
-56, -56, -56, -54, -54, -53, -52, -50, -49, -47, -43, -42, -37, -34, -31, -27,
-24, -20, -17, -14, -9, -6, -3, -1, };