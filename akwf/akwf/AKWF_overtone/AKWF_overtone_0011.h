#define DATA_LENGTH 512
#define DATA AKWF_overtone_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 10, 14, 19, 23, 28, 33, 36, 39,
44, 44, 47, 50, 51, 53, 54, 56, 56, 56, 58, 59, 59, 61, 60, 61, 63, 63, 64, 67,
68, 70, 74, 79, 81, 84, 87, 87, 91, 93, 93, 94, 96, 98, 98, 100, 102, 106, 109,
109, 113, 113, 113, 114, 112, 112, 110, 109, 109, 108, 105, 104, 102, 100, 98,
98, 99, 96, 96, 95, 93, 91, 91, 91, 89, 91, 91, 92, 94, 93, 91, 94, 93, 92, 92,
91, 89, 87, 85, 83, 79, 73, 68, 63, 58, 54, 47, 43, 39, 32, 30, 24, 20, 17, 14,
11, 6, 3, 0, -3, -7, -8, -10, -13, -14, -15, -18, -20, -20, -21, -22, -23, -23,
-27, -29, -30, -30, -33, -36, -36, -37, -37, -40, -43, -43, -47, -47, -48, -50,
-51, -51, -52, -53, -54, -57, -57, -58, -58, -60, -62, -63, -66, -68, -72, -74,
-78, -80, -82, -86, -87, -89, -91, -92, -90, -91, -92, -90, -89, -89, -86, -85,
-82, -82, -80, -78, -78, -76, -77, -75, -74, -75, -76, -74, -74, -74, -74, -74,
-73, -73, -72, -71, -70, -68, -66, -65, -63, -58, -56, -54, -51, -48, -47, -48,
-48, -46, -45, -44, -43, -44, -43, -41, -40, -37, -36, -34, -33, -31, -29, -26,
-22, -22, -21, -23, -19, -15, -16, -17, -19, -22, -21, -21, -21, -21, -23, -24,
-26, -26, -26, -25, -23, -21, -18, -16, -16, -17, -17, -20, -19, -16, -14, -13,
-12, -12, -12, -8, -3, 2, 5, 8, 8, 6, 8, 8, 8, 11, 11, 13, 13, 18, 22, 26, 29,
31, 34, 38, 43, 45, 46, 45, 46, 47, 47, 48, 49, 47, 45, 45, 44, 43, 44, 44, 43,
44, 45, 47, 47, 46, 49, 50, 48, 48, 48, 50, 50, 48, 45, 43, 45, 43, 42, 42, 47,
49, 49, 53, 57, 61, 64, 67, 71, 76, 80, 85, 89, 89, 91, 92, 96, 98, 99, 97, 95,
92, 91, 87, 84, 81, 77, 73, 71, 70, 68, 65, 65, 65, 65, 68, 72, 76, 80, 81, 85,
87, 91, 93, 94, 95, 94, 91, 88, 87, 83, 81, 78, 75, 71, 69, 67, 63, 59, 55, 53,
51, 50, 46, 41, 34, 27, 22, 16, 10, 3, -3, -11, -16, -19, -25, -29, -28, -32,
-34, -36, -36, -37, -38, -40, -40, -43, -45, -46, -47, -48, -49, -49, -50, -50,
-50, -49, -50, -50, -51, -52, -53, -56, -60, -63, -67, -70, -75, -80, -84, -89,
-94, -99, -103, -108, -111, -113, -116, -118, -119, -118, -117, -114, -112,
-108, -103, -98, -95, -91, -86, -86, -84, -81, -82, -82, -82, -81, -83, -84,
-86, -88, -88, -90, -90, -90, -90, -91, -89, -88, -87, -85, -82, -80, -77, -76,
-73, -72, -72, -69, -70, -68, -68, -67, -67, -68, -69, -67, -64, -63, -60, -58,
-57, -54, -51, -49, -47, -45, -42, -40, -38, -37, -38, -37, -35, -34, -34, -34,
-32, -29, -30, -28, -26, -24, -23, -21, -18, -15, -11, -9, -5, 0, };