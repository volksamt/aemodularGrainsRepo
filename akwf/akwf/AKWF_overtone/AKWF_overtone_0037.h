#define DATA_LENGTH 512
#define DATA AKWF_overtone_0037

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 0, 2, 2, 2, 2, 3, 3, 3, 3, 3, 3,
3, 4, 3, 3, 3, 4, 4, 4, 4, 4, 3, 3, 4, 4, 3, 3, 3, 3, 3, 3, 3, 4, 3, 3, 3, 4, 3,
3, 3, 4, 4, 3, 4, 3, 3, 3, 3, 4, 3, 4, 4, 3, 4, 2, 3, 3, 3, 3, 2, 2, 3, 2, 3, 3,
3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 3, 2, 2, 3, 3, 3, 3, 2, 2, 3, 3, 3, 2, 3, 3, 3, 3,
2, 2, 3, 3, 3, 2, 2, 3, 3, 2, 3, 3, 2, 2, 3, 3, 3, 2, 3, 2, 2, 3, 2, 3, 3, 2, 2,
3, 2, 1, 2, 3, 2, 2, 2, 2, 1, 1, 2, 2, 2, 2, 2, 2, 1, 2, 2, 2, 2, 2, 3, 2, 1, 1,
2, 2, 2, 1, 1, 2, 2, 2, 2, 2, 2, 1, 1, 2, 2, 2, 2, 1, 2, 2, 2, 1, 1, 2, 2, 2, 1,
2, 1, 2, 1, 2, 1, 1, 1, 1, 2, 1, 1, 1, 1, 1, 2, 1, 2, 2, 1, 2, 2, 1, 1, 2, 1, 2,
2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 2, 2, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 2, 2,
1, 1, 1, 2, 2, 1, 1, 1, 2, 2, 1, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 2, 1, 1, 1, 0, 1,
1, 2, 0, 1, 1, 2, 2, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 2, 1, 2, 1, 1, 0, 1, 1, 1, 1,
1, 0, 1, 0, 0, 1, 1, 1, 1, 1, 0, 0, 2, 1, 1, 1, 1, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0,
1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 0, 1, 1, 1, 1, 0, 0, 12, 61, 111, 114,
96, 82, 69, 59, 49, 41, 35, 29, 24, 19, 16, 13, 11, 8, 6, 5, 3, 2, 0, 0, -1, -2,
-2, -3, -4, -3, -4, -4, -5, -4, -5, -5, -5, -5, -5, -5, -6, -5, -5, -6, -5, -6,
-5, -5, -5, -5, -5, -6, -6, -5, -4, -6, -6, -5, -5, -4, -5, -6, -5, -5, -5, -5,
-4, -5, -5, -5, -5, -5, -5, -5, -5, -4, -5, -5, -5, -5, -5, -4, -4, -5, -5, -5,
-4, -4, -5, -4, -5, -4, -5, -5, -5, -4, -5, -4, -5, -3, -4, -4, -5, -4, -5, -3,
-4, -4, -3, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -3, -4, -4, -4,
-4, -4, -4, -3, -3, -4, -4, -3, -3, -3, -4, -4, -4, -3, -3, -3, -3, -3, -4, -4,
-3, -3, -3, -3, -3, -3, -3, -4, -3, -3, -16, -65, -114, -116, -96, -83, -72,
-61, -51, -44, -37, -31, -27, -23, -19, -15, -12, -11, -8, -7, -5, -3, -3, -2,
-1, 0, };