#define DATA_LENGTH 512
#define DATA AKWF_overtone_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {15, 120, 118, 114, 113, 109, 110, 105,
106, 102, 103, 98, 98, 94, 95, 91, 90, 86, 86, 83, 82, 79, 78, 75, 74, 73, 70,
69, 67, 65, 63, 61, 59, 58, 56, 55, 52, 51, 49, 48, 45, 44, 43, 40, 38, 37, 35,
35, 33, 31, 29, 28, 27, 25, 23, 22, 20, 18, 17, 17, 15, 13, 12, 11, 10, 9, 7, 6,
5, 3, 2, 1, 0, -2, -2, -3, -4, -6, -7, -8, -9, -11, -11, -11, -12, -13, -15,
-16, -16, -17, -17, -19, -19, -20, -20, -22, -22, -23, -23, -24, -24, -25, -25,
-27, -27, -27, -28, -28, -28, -29, -29, -30, -29, -30, -30, -31, -32, -31, -32,
-31, -31, -32, -32, -31, -33, -31, -32, -33, -32, -32, -31, -31, -32, -31, -31,
-31, -31, -30, -30, -29, -29, -29, -29, -28, -29, -28, -27, -26, -26, -26, -25,
-24, -24, -23, -23, -22, -22, -21, -21, -19, -18, -18, -17, -17, -16, -15, -14,
-14, -12, -11, -11, -10, -9, -8, -6, -5, -5, -4, -3, -2, -1, 0, 2, 2, 4, 5, 7,
7, 9, 10, 11, 12, 14, 14, 16, 17, 18, 20, 21, 23, 24, 25, 27, 28, 30, 31, 33,
33, 35, 36, 38, 39, 41, 42, 44, 46, 47, 50, 50, 52, 54, 55, 57, 58, 60, 61, 63,
65, 66, 67, 69, 70, 73, 74, 77, 77, 79, 80, 82, 83, 86, 87, 90, 90, 92, 93, 95,
97, 98, 100, 102, 104, 104, 108, 107, 111, -24, -127, -112, -117, -110, -112,
-107, -107, -104, -104, -101, -98, -97, -95, -94, -91, -90, -86, -86, -83, -82,
-80, -78, -75, -75, -72, -71, -68, -67, -64, -63, -61, -60, -57, -55, -54, -52,
-50, -49, -47, -46, -45, -42, -40, -39, -38, -36, -33, -32, -31, -29, -27, -26,
-24, -23, -22, -20, -19, -17, -17, -14, -14, -12, -11, -9, -8, -6, -5, -4, -3,
-2, -2, 0, 1, 3, 4, 5, 5, 8, 8, 9, 10, 11, 12, 13, 14, 14, 16, 16, 17, 18, 19,
19, 20, 21, 21, 23, 23, 23, 24, 25, 26, 25, 25, 27, 27, 28, 28, 29, 28, 30, 29,
30, 31, 31, 31, 31, 32, 32, 31, 32, 32, 32, 32, 32, 33, 31, 32, 32, 31, 32, 32,
31, 31, 31, 31, 30, 30, 31, 29, 30, 30, 28, 29, 28, 28, 27, 26, 26, 25, 25, 25,
24, 23, 23, 22, 22, 21, 20, 19, 18, 18, 16, 17, 15, 15, 14, 14, 13, 11, 10, 9,
9, 7, 7, 6, 5, 4, 2, 1, 0, -1, -1, -3, -4, -5, -5, -8, -9, -10, -12, -13, -14,
-15, -16, -18, -18, -20, -21, -22, -24, -25, -27, -28, -29, -31, -33, -33, -36,
-37, -39, -40, -41, -43, -44, -46, -47, -49, -51, -52, -54, -55, -57, -59, -60,
-61, -63, -65, -65, -67, -68, -70, -71, -75, -76, -77, -79, -80, -83, -83, -86,
-87, -90, -90, -93, -93, -97, -95, -101, -98, -104, -101, -109, -102, -115, -94,
};