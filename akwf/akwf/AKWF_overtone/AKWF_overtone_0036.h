#define DATA_LENGTH 512
#define DATA AKWF_overtone_0036

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 1, 1,
1, 1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 0, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 0, 0, 1,
0, 1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 1, 0, 1, 1, 0, 1, 0, 0,
0, 1, 1, 1, 1, 0, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, 1, 0, 1, 1, 1, 1, 1, 1, 1, 0, 0,
2, 1, 0, 0, 0, 0, 1, 0, 1, 1, 1, 0, 1, 0, 1, 1, 0, 1, 1, 0, 1, 1, 0, 1, 0, 1, 1,
0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, 0, 1, 1, 1, 1, 1, 1, 0, 0, 0, 1,
0, 0, 0, 1, 1, 1, 0, 2, 0, 1, -1, 2, 0, 1, 0, 1, 0, 1, 1, 0, 1, 0, 2, -1, 2, -3,
4, -4, 8, -15, 63, 124, 86, 85, 65, 63, 49, 45, 37, 33, 27, 24, 21, 17, 15, 12,
11, 8, 9, 6, 6, 4, 5, 3, 3, 2, 3, 1, 2, 1, 1, 1, 1, 0, 0, -1, 0, -1, 0, 0, -1,
0, -1, 0, 0, 0, -1, -1, 0, 0, 0, -1, -1, 0, -1, -1, -1, 0, 0, -1, -1, -1, -1,
-1, -1, -1, -1, -1, -1, -1, -1, 0, -1, 0, -1, -1, -1, -1, -1, -1, -1, -1, -1, 0,
-1, -1, 0, -1, -1, 0, 0, 0, -1, -1, -1, 0, -1, -1, 0, -1, -1, -1, 0, -1, 0, -1,
-1, -1, -1, 0, 0, -1, 0, 0, 0, 0, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, 0,
-1, 0, -1, 0, -1, -1, 0, -1, -1, 0, -1, -1, -1, -1, 0, -1, 0, -1, 0, 0, 0, 0, 0,
0, 0, 0, -1, -1, -1, 0, -1, -1, 0, -1, -1, -1, 0, -1, -1, 0, -1, 0, -1, -1, -1,
0, -1, 0, -1, 0, -1, -1, -1, -1, 0, -1, 0, -1, 0, -2, 0, -1, 0, -1, 0, -2, 1,
-2, 1, -2, 1, -2, 1, -2, 1, -2, 1, -1, -108, -107, -84, -78, -62, -58, -46, -43,
-33, -33, -24, -24, -19, -17, -14, -12, -10, -9, -7, -6, -5, -5, -3, -4, -2, -2,
-3, -1, -1, -1, 0, -1, 0, -1, 0, 0, 1, 0, 0, 1, 0, 2, -1, 2, -1, 2, -3, 5, -4,
70, 119, 86, 84, 65, 60, 49, 44, 36, 32, 28, 23, 21, 17, 16, 12, 11, 9, 9, 6, 6,
4, 5, 4, 3, 2, 2, 1, 1, 2, 0, 1, 0, 2, -1, 1, -2, 2, -2, 3, -4, 4, -5, 7, -17,
-120, -98, -85, -74, -62, -55, -46, -42, -33, -31, -25, -23, -17, -17, -13, -12,
-9, -10, -7, -6, -5, -4, -3, -3, -2, -3, -2, -1, -1, -1, 0, -1, 0, 0, 0, };