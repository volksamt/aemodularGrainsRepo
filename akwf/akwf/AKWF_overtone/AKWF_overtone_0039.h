#define DATA_LENGTH 512
#define DATA AKWF_overtone_0039

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 7, 8, 6, 12, 29, 29, 28, 27,
28, 26, 26, 23, 39, 49, 45, 47, 44, 45, 44, 43, 43, 43, 42, 41, 41, 40, 40, 40,
39, 39, 39, 37, 37, 37, 36, 36, 37, 35, 36, 36, 34, 35, 35, 34, 36, 35, 35, 35,
35, 35, 36, 36, 35, 36, 35, 36, 37, 36, 37, 37, 37, 39, 38, 39, 40, 40, 41, 41,
43, 42, 43, 43, 45, 46, 47, 47, 49, 49, 51, 51, 52, 54, 55, 56, 57, 58, 58, 62,
59, 65, 63, 68, 65, 72, 67, 74, 69, 78, 72, 81, 74, 85, 74, -109, -123, -111,
-118, -108, -113, -104, -108, -101, -103, -96, -99, -93, -94, -88, -89, -85,
-84, -81, -80, -76, -75, -72, -70, -68, -66, -65, -61, -59, -57, -55, -52, -50,
-48, -47, -43, -42, -39, -38, -34, -34, -31, -29, -26, -25, -22, -20, -19, -16,
-14, -12, -9, -8, -6, -5, -3, -1, 2, 3, 5, 7, 8, 10, 11, 13, -6, -6, -5, -1, -7,
-24, -20, -20, -18, -18, -14, -15, -10, -18, -34, -30, -30, -28, -27, -25, -23,
-22, -22, -21, -19, -18, -18, -15, -15, -14, -13, -12, -12, -11, -10, -9, -8,
-7, -8, -7, -7, -5, -5, -5, -4, -3, -4, -3, -4, -2, -3, -3, -2, -2, -3, -2, -3,
-2, -2, -3, -3, -3, -4, -3, -4, -4, -5, -5, -6, -7, -7, -7, -7, -9, 9, 15, 12,
14, 11, 11, 10, 10, 8, 8, 7, 6, 22, 29, 25, 27, 22, 30, 47, 44, 43, 42, 40, 40,
38, 35, 53, 59, 55, 56, 53, 53, 50, 50, 48, 47, 45, 44, 44, 43, 41, 39, 38, 37,
35, 34, 33, 32, 31, 29, 28, 27, 27, 24, 23, 22, 21, 20, 20, 18, 17, 15, 15, 14,
13, 12, 12, 10, 9, 8, 8, 7, 6, 5, 4, 4, 3, 2, 2, 1, 0, 0, -1, -1, -2, -2, -2,
-3, -3, -3, -4, -4, -6, -4, -6, -6, -6, -6, -6, -5, -6, -6, -6, -5, -6, -6, -6,
-6, -5, -5, -6, -5, -5, -5, -4, -4, -4, -23, -28, -26, -26, -24, -25, -24, -23,
-22, -22, -21, -21, -20, -20, -19, -19, -17, -17, -15, -15, -14, -14, -13, -13,
-11, -12, -10, -9, -9, -7, -6, -5, -5, -4, -3, -3, -3, 0, 0, 1, 1, 3, 4, 5, 5,
6, 6, 7, 8, 10, 10, 10, 11, 12, 13, 14, 15, 16, 15, 17, 18, 18, 19, 20, 19, -2,
0, 0, 3, -8, -23, -19, -21, -19, -20, -17, -18, -14, -27, -40, -36, -37, -36,
-36, -35, -34, -33, -33, -32, -32, -32, -32, -32, -30, -30, -31, -29, -29, -29,
-28, -28, -28, -29, -27, -27, -26, -26, -27, -27, -27, -26, -26, -26, -26, -27,
-26, -27, -26, -27, -26, -27, -27, -27, -27, -28, -27, -28, -28, -28, -28, -28,
-29, -28, -30, -29, -30, -30, -30, -31, -11, -7, -9, -9, -11, -9, -11, -10, -13,
-12, -13, -11, };