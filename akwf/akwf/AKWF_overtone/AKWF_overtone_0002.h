#define DATA_LENGTH 512
#define DATA AKWF_overtone_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 2, 3, 4, 4, 5, 6, 7, 8, 9,
10, 10, 10, 12, 13, 14, 15, 15, 16, 17, 17, 19, 19, 20, 21, 22, 23, 24, 25, 26,
27, 28, 29, 29, 31, 32, 33, 34, 35, 35, 37, 37, 38, 40, 41, 41, 42, 43, 44, 46,
47, 48, 49, 50, 50, 51, 54, 54, 55, 56, 57, 58, 59, 60, 63, 63, 65, 66, 67, 66,
69, 70, 71, 72, 73, 74, 75, 76, 78, 79, 80, 81, 82, 84, 84, 87, 85, 89, 88, 93,
89, 95, 91, 98, 93, 100, 95, 104, 97, 106, 98, 111, 95, -111, -122, -112, -119,
-108, -116, -106, -111, -104, -109, -101, -105, -98, -101, -96, -98, -94, -94,
-91, -91, -89, -89, -86, -85, -84, -82, -81, -80, -78, -76, -75, -74, -73, -70,
-70, -68, -68, -65, -64, -63, -63, -59, -59, -58, -57, -56, -54, -53, -51, -49,
-48, -47, -46, -45, -44, -42, -41, -40, -38, -38, -36, -35, -34, -32, -32, -30,
-29, -28, -27, -26, -25, -25, -23, -22, -21, -20, -18, -17, -18, -17, -15, -14,
-13, -12, -11, -11, -9, -9, -8, -6, -7, -5, -4, -3, -3, -1, 0, 0, 0, 1, 3, 3, 3,
5, 5, 6, 5, 7, 8, 8, 9, 9, 11, 11, 11, 12, 13, 13, 13, 14, 15, 15, 15, 16, 16,
17, 17, 17, 18, 18, 19, 19, 19, 20, 21, 20, 21, 21, 21, 22, 22, 22, 22, 23, 23,
23, 24, 23, 24, 24, 24, 24, 25, 24, 24, 25, 24, 24, 24, 25, 26, 25, 24, 25, 25,
25, 25, 26, 25, 25, 25, 24, 25, 25, 24, 25, 25, 25, 24, 24, 24, 23, 24, 23, 23,
24, 24, 22, 23, 23, 23, 23, 22, 21, 21, 20, 21, 20, 20, 20, 19, 20, 19, 18, 18,
18, 19, 18, 18, 17, 16, 16, 15, 15, 14, 15, 15, 14, 14, 13, 13, 12, 12, 12, 11,
11, 10, 10, 9, 10, 9, 9, 8, 7, 7, 7, 6, 5, 6, 4, 4, 4, 3, 3, 2, 3, 2, 1, 0, 0,
0, -1, -2, -2, -2, -3, -2, -3, -3, -4, -4, -5, -6, -5, -6, -6, -6, -8, -8, -8,
-8, -9, -10, -10, -10, -11, -11, -12, -12, -12, -13, -12, -13, -14, -14, -14,
-14, -15, -16, -15, -16, -15, -16, -17, -17, -18, -18, -18, -19, -19, -19, -19,
-20, -20, -19, -21, -20, -21, -20, -22, -22, -21, -22, -21, -22, -22, -22, -22,
-23, -22, -23, -23, -24, -23, -24, -23, -24, -24, -24, -24, -24, -25, -24, -23,
-24, -23, -25, -24, -25, -24, -25, -24, -23, -24, -24, -24, -24, -23, -23, -23,
-23, -22, -24, -22, -23, -22, -22, -23, -21, -21, -22, -21, -20, -20, -21, -19,
-19, -19, -19, -19, -19, -18, -18, -18, -17, -17, -16, -15, -16, -15, -15, -14,
-14, -14, -12, -11, -13, -12, -11, -11, -10, -10, -8, -8, -8, -7, -6, -5, -5,
-5, -4, -2, -3, -2, -1, -1, 0, };