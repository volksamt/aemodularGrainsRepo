#define DATA_LENGTH 512
#define DATA AKWF_overtone_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {25, 27, 24, 23, 21, 20, 17, 17, 13,
15, 6, 69, 82, 73, 76, 72, 71, 68, 68, 64, 64, 61, 61, 57, 57, 52, 54, 44, 103,
122, 112, 116, 108, 112, 105, 107, 102, 102, 99, 98, 95, 93, 91, 90, 88, 86, 84,
82, 80, 79, 77, 75, 73, 70, 70, 67, 65, 63, 62, 60, 59, 57, 55, 53, 52, 50, 48,
47, 46, 43, 41, 39, 38, 37, 34, 33, 32, 30, 29, 27, 25, 24, 22, 20, 20, 19, 17,
16, 14, 13, 11, 11, 9, 6, 6, 5, 4, 2, 1, 0, -1, -3, -4, -5, -6, -7, -8, -9, -11,
-11, -12, -12, -14, -15, -16, -16, -18, -19, -19, -21, -21, -21, -22, -23, -24,
-24, -26, -26, -27, -27, -28, -28, -29, -28, -29, -30, -31, -31, -31, -32, -31,
-32, -32, -33, -33, -33, -34, -33, -34, -34, -34, -34, -34, -35, -35, -35, -34,
-35, -34, -34, -35, -35, -34, -34, -34, -33, -34, -33, -33, -33, -32, -32, -32,
-31, -31, -30, -30, -30, -29, -28, -28, -27, -27, -27, -26, -25, -25, -24, -24,
-23, -22, -21, -20, -20, -18, -19, -17, -17, -15, -15, -13, -14, -10, -12, -9,
-11, -6, -10, -3, -13, -75, -73, -71, -71, -69, -69, -67, -68, -64, -65, -61,
-61, -59, -59, -56, -56, -54, -53, -51, -51, -48, -47, -46, -44, -43, -40, -40,
-37, -37, -35, -33, -32, -31, -29, -27, -26, -24, -23, -22, -20, -17, -16, -14,
-14, -11, -10, -8, -7, -4, -4, -2, 0, 2, 4, 5, 6, 9, 10, 12, 13, 15, 16, 19, 20,
22, 24, 26, 27, 29, 30, 31, 34, 35, 36, 39, 39, 42, 43, 46, 48, 48, 50, 52, 53,
56, 57, 58, 59, 61, 62, 64, 66, 68, 70, 71, 72, 74, 75, 77, 78, 79, 81, 84, 84,
86, 88, 88, 90, 92, 94, 95, 96, 98, 99, 100, 102, 103, 104, 106, 107, 109, 109,
112, 111, 115, 114, 118, 113, 126, 89, 41, 56, 49, 57, 52, 58, 54, 62, 55, -9,
-9, -5, -6, -2, -4, 0, -2, 2, 0, 5, 2, 6, 3, 10, 4, 14, -1, -62, -57, -58, -56,
-55, -55, -53, -54, -51, -51, -49, -49, -47, -48, -46, -46, -45, -45, -43, -42,
-42, -42, -41, -40, -39, -40, -39, -39, -38, -38, -37, -36, -36, -36, -35, -35,
-35, -34, -34, -34, -33, -33, -33, -33, -32, -32, -32, -33, -32, -32, -32, -32,
-32, -32, -32, -32, -31, -32, -32, -32, -32, -33, -32, -33, -33, -34, -34, -34,
-34, -35, -35, -36, -36, -37, -38, -38, -39, -39, -39, -40, -40, -41, -41, -41,
-43, -44, -44, -44, -46, -46, -48, -48, -48, -50, -50, -52, -52, -53, -53, -55,
-55, -56, -58, -58, -59, -61, -61, -63, -63, -65, -65, -67, -66, -70, -68, -72,
-71, -74, -73, -78, -73, -9, -8, -12, -11, -15, -13, -18, -17, -20, -18, -23,
-21, -25, -24, -29, -28, -32, -31, -35, -33, -38, -36, -43, -35, };