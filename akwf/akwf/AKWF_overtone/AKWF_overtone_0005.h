#define DATA_LENGTH 512
#define DATA AKWF_overtone_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 16, 22, 28, 34, 40, 46, 50, 55,
60, 64, 68, 71, 76, 79, 82, 86, 89, 91, 93, 95, 99, 100, 101, 102, 103, 104,
105, 106, 106, 106, 106, 105, 104, 103, 102, 100, 100, 97, 96, 93, 91, 89, 85,
82, 79, 75, 71, 67, 63, 59, 55, 50, 44, 40, 35, 29, 23, 16, 11, 5, -2, -8, -15,
-23, -29, -38, -44, -52, -60, -69, -77, -85, -94, -103, -108, -113, -116, -118,
-119, -118, -118, -116, -114, -110, -107, -103, -99, -94, -90, -85, -80, -75,
-70, -65, -60, -55, -50, -45, -41, -36, -31, -26, -22, -18, -15, -11, -7, -4, 0,
3, 5, 10, 11, 14, 16, 19, 21, 23, 24, 25, 26, 28, 28, 30, 30, 31, 32, 32, 31,
32, 32, 31, 32, 31, 31, 30, 30, 29, 27, 27, 26, 25, 24, 22, 20, 19, 18, 17, 15,
14, 13, 11, 8, 7, 6, 4, 1, 0, -1, -4, -5, -7, -9, -10, -11, -13, -15, -15, -18,
-19, -20, -21, -22, -25, -25, -26, -27, -27, -28, -29, -29, -30, -30, -30, -30,
-31, -30, -30, -30, -29, -28, -28, -26, -26, -24, -23, -21, -20, -18, -16, -14,
-11, -8, -7, -4, 0, 3, 6, 10, 13, 17, 20, 24, 29, 33, 38, 41, 47, 52, 57, 61,
66, 71, 75, 80, 85, 89, 94, 98, 102, 105, 108, 111, 114, 115, 116, 116, 115,
112, 109, 104, 98, 89, 82, 72, 64, 55, 47, 40, 31, 25, 17, 10, 3, -4, -10, -18,
-24, -30, -35, -40, -45, -51, -56, -60, -64, -68, -73, -76, -81, -83, -86, -89,
-91, -93, -96, -98, -99, -102, -102, -103, -105, -106, -105, -105, -106, -105,
-105, -104, -103, -102, -101, -99, -97, -95, -93, -91, -88, -85, -82, -79, -75,
-71, -67, -63, -59, -54, -49, -45, -39, -34, -28, -22, -17, -11, -4, 2, 9, 16,
23, 31, 38, 45, 53, 61, 70, 78, 87, 95, 103, 109, 113, 117, 118, 118, 118, 118,
115, 112, 110, 106, 103, 98, 94, 90, 84, 80, 75, 70, 64, 60, 54, 49, 44, 40, 35,
30, 27, 23, 18, 14, 10, 7, 3, 0, -3, -6, -9, -12, -14, -16, -19, -20, -23, -25,
-25, -27, -27, -29, -30, -31, -32, -32, -32, -32, -32, -32, -32, -32, -31, -31,
-31, -30, -28, -28, -27, -25, -25, -24, -22, -21, -19, -17, -17, -16, -13, -12,
-10, -8, -7, -5, -3, -1, 0, 2, 4, 5, 7, 8, 10, 11, 13, 15, 16, 17, 18, 20, 22,
23, 23, 24, 26, 28, 28, 28, 29, 29, 30, 30, 30, 30, 30, 31, 30, 30, 29, 29, 27,
27, 26, 24, 23, 20, 19, 17, 16, 14, 11, 8, 6, 2, 0, -3, -7, -10, -13, -17, -21,
-26, -29, -34, -38, -42, -47, -52, -57, -62, -66, -71, -76, -80, -86, -90, -94,
-98, -102, -105, -109, -111, -114, -115, -115, -116, -114, -112, -108, -104,
-97, -90, -80, -71, -63, -55, -47, -39, -31, -23, -16, -8, -2, };