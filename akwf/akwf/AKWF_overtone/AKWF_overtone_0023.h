#define DATA_LENGTH 512
#define DATA AKWF_overtone_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 21, 5, 2, 4, 5, 7, 9, 12, 13, 15,
15, 16, 17, 19, 18, 21, 21, 22, 21, 22, 22, 23, 23, 24, 23, 24, 22, 23, 22, 23,
22, 22, 22, 23, 22, 22, 21, 21, 20, 20, 21, 20, 20, 20, 19, 19, 19, 18, 19, 18,
18, 18, 17, 18, 17, 17, 16, 17, 17, 16, 16, 17, 16, 17, 16, 16, 17, 17, 17, 17,
17, 17, 17, 19, 18, 19, 18, 20, 20, 20, 21, 21, 22, 22, 23, 24, 24, 24, 25, 25,
27, 27, 27, 29, 29, 30, 32, 32, 34, 35, 35, 36, 37, 39, 40, 41, 43, 43, 45, 46,
48, 49, 49, 51, 52, 53, 55, 57, 58, 60, 61, 63, 64, 65, 67, 68, 70, 71, 73, 76,
78, 79, 82, 82, 84, 86, 88, 90, 91, 94, 95, 98, 100, 102, 103, 106, 106, 110,
110, 114, 114, 120, 106, 75, 69, 65, 62, 53, 33, 18, 13, 2, -9, -20, -30, -41,
-52, -60, -61, -65, -71, -76, -81, -86, -91, -94, -98, -102, -104, -106, -109,
-111, -112, -115, -116, -117, -118, -118, -119, -120, -119, -119, -119, -118,
-118, -117, -117, -116, -115, -114, -113, -111, -110, -108, -108, -106, -104,
-102, -101, -100, -97, -96, -94, -91, -90, -88, -86, -84, -82, -81, -78, -76,
-74, -71, -69, -68, -66, -62, -61, -58, -56, -54, -52, -50, -48, -46, -43, -41,
-38, -37, -35, -32, -31, -29, -27, -25, -22, -21, -19, -16, -14, -13, -10, -8,
-6, -4, -3, -1, 3, 4, 8, 10, 12, 14, 17, 11, 13, 17, 18, 21, 21, 24, 25, 26, 28,
29, 30, 32, 33, 34, 35, 36, 38, 39, 40, 40, 41, 43, 44, 44, 45, 47, 47, 48, 49,
49, 50, 50, 52, 52, 52, 53, 54, 54, 55, 55, 55, 55, 56, 57, 57, 57, 57, 58, 58,
57, 57, 58, 58, 57, 58, 58, 57, 57, 56, 56, 57, 56, 55, 55, 55, 55, 55, 54, 53,
54, 52, 51, 51, 51, 50, 49, 48, 48, 46, 46, 45, 44, 43, 42, 42, 40, 39, 38, 37,
36, 34, 34, 32, 31, 29, 29, 28, 25, 25, 23, 21, 20, 19, 17, 16, 14, 13, 11, 9,
8, 8, 8, 8, 7, 7, 6, 5, 6, 5, 4, 5, 4, 4, 3, 3, 3, 3, 2, 2, 2, 2, 2, 1, 2, 1, 1,
1, 1, 0, 1, 0, 0, 0, -1, 0, -1, -2, -5, -8, -7, -9, -9, -11, -12, -13, -14, -15,
-17, -18, -20, -21, -22, -24, -25, -27, -29, -30, -31, -33, -34, -35, -37, -39,
-39, -40, -43, -43, -45, -46, -47, -47, -49, -50, -51, -53, -53, -54, -55, -55,
-56, -57, -58, -59, -60, -60, -61, -60, -61, -62, -63, -63, -63, -64, -64, -63,
-64, -63, -63, -62, -58, -58, -56, -51, -50, -49, -50, -49, -48, -47, -46, -45,
-44, -43, -42, -40, -40, -39, -39, -38, -36, -36, -36, -35, -35, -34, -34, -33,
-34, -33, -33, -32, -33, -32, -34, -18, };