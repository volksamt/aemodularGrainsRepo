#define DATA_LENGTH 512
#define DATA AKWF_overtone_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 12, 18, 25, 31, 38, 46, 53, 59, 66,
73, 80, 85, 91, 95, 100, 104, 108, 111, 114, 117, 118, 119, 119, 119, 118, 116,
115, 112, 109, 106, 102, 97, 93, 89, 83, 79, 73, 67, 61, 56, 51, 45, 39, 33, 27,
22, 17, 11, 6, 0, -4, -9, -14, -19, -25, -29, -34, -39, -43, -48, -52, -56, -61,
-65, -69, -72, -76, -78, -82, -85, -88, -90, -92, -93, -95, -95, -96, -96, -96,
-96, -96, -95, -95, -94, -94, -92, -91, -90, -89, -87, -86, -85, -82, -80, -79,
-76, -74, -72, -68, -66, -62, -59, -56, -52, -48, -43, -39, -35, -30, -25, -22,
-16, -11, -7, -2, 3, 8, 13, 17, 21, 25, 28, 33, 35, 38, 42, 44, 46, 49, 50, 52,
55, 56, 59, 59, 60, 62, 64, 65, 67, 67, 69, 69, 69, 70, 70, 71, 71, 70, 70, 70,
70, 70, 70, 69, 69, 68, 67, 67, 66, 66, 65, 65, 64, 64, 63, 62, 62, 60, 59, 58,
55, 54, 51, 48, 46, 43, 39, 35, 32, 27, 23, 18, 14, 10, 6, 1, -3, -7, -12, -16,
-19, -23, -25, -28, -30, -33, -34, -35, -36, -36, -37, -37, -36, -36, -35, -34,
-33, -32, -31, -31, -32, -31, -30, -29, -30, -29, -30, -30, -30, -31, -31, -31,
-31, -30, -31, -32, -33, -33, -32, -33, -33, -36, -37, -37, -36, -36, -36, -36,
-36, -36, -37, -37, -35, -35, -35, -35, -34, -35, -35, -36, -36, -34, -34, -33,
-32, -33, -32, -32, -30, -29, -29, -29, -28, -26, -26, -24, -21, -19, -17, -15,
-12, -10, -6, -3, 1, 7, 10, 16, 21, 27, 33, 39, 46, 53, 60, 64, 68, 72, 77, 80,
83, 85, 88, 91, 92, 94, 95, 95, 95, 94, 92, 89, 86, 82, 78, 74, 69, 63, 58, 52,
46, 39, 32, 25, 17, 10, 4, -4, -10, -18, -23, -32, -37, -44, -49, -56, -61, -67,
-72, -77, -82, -85, -89, -93, -95, -98, -101, -102, -104, -106, -108, -107,
-108, -108, -107, -105, -103, -102, -99, -96, -93, -89, -85, -80, -75, -69, -64,
-56, -50, -43, -37, -29, -23, -18, -12, -6, -1, 4, 10, 14, 18, 22, 25, 28, 32,
34, 36, 38, 41, 41, 44, 45, 47, 49, 51, 53, 56, 58, 60, 62, 65, 67, 69, 72, 76,
79, 82, 86, 87, 90, 92, 96, 97, 99, 99, 100, 101, 101, 101, 101, 100, 98, 97,
94, 93, 91, 87, 83, 79, 75, 69, 64, 59, 54, 48, 40, 34, 26, 19, 11, 3, -2, -10,
-17, -23, -28, -35, -40, -45, -49, -54, -57, -59, -62, -63, -65, -67, -67, -67,
-67, -66, -67, -66, -67, -66, -65, -66, -64, -63, -62, -61, -60, -59, -58, -57,
-56, -55, -54, -53, -52, -51, -51, -49, -48, -47, -46, -45, -45, -44, -42, -42,
-42, -43, -42, -42, -43, -43, -44, -45, -45, -45, -45, -46, -46, -45, -45, -43,
-43, -42, -40, -38, -35, -32, -29, -26, -21, -16, -11, -6, 0, };