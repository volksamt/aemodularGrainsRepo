#define DATA_LENGTH 512
#define DATA AKWF_overtone_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 6, 8, 8, 11, 11, 12, 13, 14,
13, 14, 14, 14, 14, 14, 13, 15, 24, 28, 32, 33, 36, 40, 44, 48, 52, 59, 63, 70,
75, 83, 89, 99, 104, 116, 114, 100, 103, 104, 107, 109, 109, 108, 107, 105, 102,
99, 95, 91, 86, 82, 77, 72, 64, 67, 70, 66, 64, 61, 60, 56, 55, 54, 54, 53, 53,
52, 52, 52, 53, 52, 53, 53, 53, 52, 51, 51, 50, 49, 48, 46, 45, 43, 41, 39, 37,
34, 31, 28, 26, 23, 19, 16, 12, 8, 5, 2, -2, -6, -9, -13, -17, -19, -23, -26,
-29, -32, -34, -37, -40, -43, -44, -46, -48, -49, -50, -51, -53, -53, -54, -55,
-55, -55, -54, -54, -53, -53, -52, -51, -51, -49, -48, -46, -44, -44, -41, -40,
-38, -37, -35, -34, -32, -30, -29, -27, -26, -25, -23, -21, -21, -20, -20, -18,
-17, -17, -16, -15, -15, -15, -15, -15, -15, -14, -14, -14, -14, -15, -16, -16,
-16, -16, -17, -18, -18, -19, -19, -19, -20, -22, -22, -22, -22, -23, -24, -24,
-25, -25, -25, -26, -25, -25, -25, -24, -25, -25, -24, -24, -24, -24, -24, -23,
-23, -22, -22, -21, -20, -20, -19, -18, -17, -17, -16, -15, -15, -14, -13, -11,
-12, -11, -10, -9, -7, -7, -6, -6, -6, -4, -4, -4, -3, -3, -1, -2, -1, 0, 0, 1,
0, 1, 2, 2, 1, 2, 3, 2, 2, 3, 2, 2, 3, 3, 3, 3, 3, 3, 4, 4, 3, 4, 4, 4, 4, 4, 5,
5, 5, 5, 5, 6, 6, 6, 6, 7, 7, 7, 7, 8, 7, 8, 9, 10, 10, 10, 10, 10, 11, 12, 12,
12, 12, 13, 14, 14, 14, 14, 15, 15, 16, 15, 17, 17, 18, 18, 18, 18, 19, 19, 18,
19, 20, 20, 20, 21, 21, 21, 21, 21, 20, 21, 21, 21, 21, 21, 22, 22, 23, 22, 22,
21, 23, 22, 22, 22, 23, 23, 22, 22, 22, 22, 23, 23, 23, 23, 23, 23, 23, 23, 23,
23, 23, 23, 23, 24, 22, 23, 24, 23, 24, 24, 24, 24, 23, 23, 24, 24, 24, 24, 24,
24, 24, 23, 25, 24, 24, 25, 24, 25, 23, 24, 24, 24, 24, 24, 24, 24, 24, 23, 23,
23, 23, 23, 23, 23, 22, 23, 23, 23, 22, 22, 23, 21, 22, 22, 22, 21, 21, 21, 21,
20, 20, 20, 20, 20, 20, 19, 19, 19, 20, 19, 18, 20, 10, 3, 0, -4, -6, -11, -16,
-20, -25, -33, -39, -46, -52, -59, -67, -76, -83, -93, -99, -89, -88, -92, -94,
-98, -99, -101, -100, -99, -98, -97, -94, -91, -89, -84, -80, -76, -70, -70,
-74, -73, -70, -69, -66, -65, -63, -62, -61, -61, -60, -60, -60, -60, -60, -59,
-59, -59, -59, -58, -59, -58, -57, -57, -55, -54, -54, -52, -51, -48, -47, -45,
-43, -41, -39, -37, -35, -32, -29, -27, -24, -22, -19, -17, -13, -11, -10, -6,
-4, -2, 0, };