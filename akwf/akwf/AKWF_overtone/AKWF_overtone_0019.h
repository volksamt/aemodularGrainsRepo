#define DATA_LENGTH 512
#define DATA AKWF_overtone_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 17, 24, 31, 38, 44, 51, 57, 65,
70, 76, 81, 86, 91, 96, 100, 104, 108, 110, 114, 114, 117, 118, 118, 119, 119,
118, 118, 116, 113, 111, 109, 105, 102, 98, 93, 89, 83, 79, 73, 68, 62, 56, 50,
44, 38, 32, 25, 19, 13, 6, 0, -6, -11, -17, -24, -29, -34, -39, -44, -48, -53,
-57, -61, -64, -67, -70, -73, -74, -77, -78, -80, -82, -82, -82, -83, -82, -82,
-82, -81, -80, -78, -77, -74, -73, -71, -68, -66, -63, -60, -57, -54, -50, -47,
-44, -41, -37, -33, -30, -27, -24, -20, -17, -14, -11, -7, -4, -1, 2, 4, 8, 10,
12, 14, 17, 19, 20, 23, 23, 25, 26, 27, 28, 29, 29, 30, 30, 29, 30, 30, 29, 29,
28, 28, 27, 26, 24, 24, 22, 21, 20, 18, 17, 15, 14, 12, 12, 9, 8, 6, 4, 3, 2,
-1, -2, -3, -5, -6, -8, -9, -10, -12, -13, -14, -15, -16, -17, -17, -18, -18,
-19, -19, -20, -20, -20, -19, -20, -19, -19, -19, -19, -17, -17, -16, -15, -15,
-14, -12, -11, -10, -9, -7, -6, -4, -3, -1, 1, 2, 4, 5, 8, 9, 11, 14, 16, 18,
19, 22, 24, 27, 29, 30, 34, 36, 38, 40, 43, 45, 47, 50, 51, 54, 57, 59, 60, 62,
64, 65, 66, 69, 69, 71, 71, 72, 72, 72, 72, 71, 70, 69, 67, 64, 61, 59, 55, 50,
48, 43, 38, 31, 26, 21, 15, 9, 2, -4, -12, -18, -24, -32, -38, -44, -51, -58,
-64, -70, -76, -82, -87, -92, -97, -101, -104, -108, -111, -113, -115, -117,
-118, -118, -119, -118, -119, -118, -116, -114, -111, -109, -105, -101, -97,
-93, -88, -83, -78, -73, -67, -61, -56, -49, -43, -38, -31, -25, -19, -12, -6,
0, 6, 12, 18, 24, 30, 35, 39, 44, 49, 53, 56, 60, 65, 67, 71, 73, 74, 77, 79,
81, 81, 82, 83, 83, 83, 82, 81, 81, 80, 78, 77, 75, 73, 71, 68, 65, 62, 60, 57,
54, 50, 47, 44, 40, 37, 33, 30, 27, 23, 19, 16, 13, 9, 6, 3, 1, -2, -6, -8, -10,
-13, -15, -16, -19, -20, -22, -24, -26, -26, -27, -29, -28, -30, -30, -31, -30,
-30, -29, -30, -29, -28, -28, -27, -26, -25, -24, -22, -22, -21, -18, -17, -16,
-15, -12, -10, -10, -8, -6, -4, -3, -1, 1, 2, 4, 6, 6, 8, 9, 10, 11, 13, 13, 15,
16, 16, 18, 18, 19, 19, 19, 19, 20, 20, 19, 20, 19, 19, 18, 18, 17, 17, 16, 15,
14, 13, 12, 11, 9, 8, 7, 5, 4, 2, 1, -1, -2, -4, -5, -8, -9, -12, -13, -16, -18,
-20, -23, -24, -27, -29, -31, -33, -36, -37, -41, -42, -45, -47, -50, -53, -54,
-57, -58, -61, -62, -65, -66, -68, -69, -70, -71, -72, -72, -72, -72, -72, -71,
-69, -69, -65, -64, -61, -58, -54, -50, -46, -42, -36, -32, -26, -20, -15, -8,
-2, };