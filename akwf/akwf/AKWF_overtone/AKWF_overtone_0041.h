#define DATA_LENGTH 512
#define DATA AKWF_overtone_0041

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 15, 20, 23, 28, 31, 34, 36, 41,
45, 45, 49, 52, 49, 52, 61, 63, 62, 64, 68, 73, 75, 79, 84, 86, 87, 89, 93, 95,
98, 103, 106, 103, 106, 110, 111, 114, 119, 117, 113, 114, 114, 113, 112, 116,
119, 115, 113, 115, 117, 117, 112, 110, 111, 110, 108, 104, 102, 100, 97, 92,
91, 90, 88, 84, 80, 78, 76, 74, 72, 71, 73, 72, 69, 68, 65, 64, 62, 61, 57, 58,
57, 50, 42, 46, 47, 46, 43, 44, 45, 14, 0, -1, -3, -1, -8, -9, -13, -13, -19,
-23, -28, -27, -30, -34, -40, -39, -43, -43, -43, -46, -53, -57, -54, -62, -18,
3, -7, -4, -11, -17, -23, -21, -24, -26, -31, -36, -39, -38, -41, -43, -43, -41,
-42, -46, -50, -54, -54, -51, -48, -50, -52, -53, -53, -55, -53, -52, -52, -52,
-48, -42, -41, -41, -36, -36, -36, -34, -32, -32, -31, -29, -30, -26, -23, -21,
-21, -22, -19, -19, -17, -13, -11, -11, -13, -14, -12, -9, -7, -9, -8, -6, -4,
-2, -6, -9, -12, -12, -9, -8, -10, -15, -19, -18, -17, -19, -17, -17, -21, -25,
-25, -19, -20, -23, -22, -22, -25, -24, -23, -22, -30, -40, -37, -40, -43, -44,
-44, -47, -50, -52, -52, -53, -55, -56, -60, -63, -59, -58, -62, -58, -57, -61,
-58, -56, -63, -65, -62, -61, -64, -67, -65, -63, -65, -63, -61, -57, -55, -53,
-51, -47, -46, -44, -41, -37, -28, -22, -19, -14, -9, -8, -5, -3, -4, -2, 3, 5,
6, 8, 6, 6, 14, 13, 7, 11, 15, 15, 18, 24, 25, 33, 39, 36, 37, 42, 45, 50, 55,
58, 60, 66, 67, 64, 66, 69, 72, 75, 75, 74, 76, 78, 80, 80, 80, 83, 84, 85, 84,
85, 88, 90, 90, 91, 87, 82, 85, 81, 75, 78, 80, 81, 80, 76, 72, 71, 71, 69, 69,
67, 68, 67, 62, 59, 58, 61, 60, 56, 56, 55, 50, 50, 45, 44, 45, 45, 41, 45, 44,
12, 4, 1, -6, -9, -12, -14, -18, -16, -15, -13, -17, -16, -18, -17, -22, -24,
-24, -22, -24, -22, -24, -27, -25, -26, 22, 35, 28, 32, 31, 31, 23, 20, 17, 22,
24, 21, 15, 10, 12, 15, 12, 14, 14, 7, 4, 4, 5, 3, 3, -2, -3, 0, -1, -3, -2, -3,
-2, -1, 1, 3, 0, -2, -3, -3, -1, -1, -1, -2, -6, -6, -3, -5, -8, -10, -11, -10,
-12, -11, -10, -14, -17, -16, -14, -15, -20, -23, -24, -22, -23, -26, -33, -35,
-35, -40, -43, -47, -51, -54, -59, -63, -65, -70, -70, -69, -74, -76, -72, -79,
-84, -80, -82, -86, -84, -85, -88, -89, -88, -86, -95, -103, -100, -107, -108,
-108, -108, -112, -113, -112, -108, -106, -108, -108, -109, -108, -105, -103,
-102, -101, -100, -101, -101, -99, -95, -90, -87, -87, -87, -85, -80, -77, -74,
-68, -64, -60, -60, -59, -51, -42, -37, -33, -29, -19, -10, -3, };