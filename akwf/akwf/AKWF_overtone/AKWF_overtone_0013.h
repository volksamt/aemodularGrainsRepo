#define DATA_LENGTH 512
#define DATA AKWF_overtone_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 5, 7, 7, 8, 6, 6, 5, 4, 4, 4,
6, 9, 11, 12, 15, 18, 19, 21, 23, 25, 26, 27, 29, 31, 33, 33, 34, 35, 36, 35,
34, 33, 32, 31, 30, 28, 29, 27, 26, 26, 25, 24, 23, 21, 19, 17, 16, 15, 13, 11,
9, 6, 4, 2, 0, 1, 1, 4, 6, 8, 10, 9, 9, 12, 14, 18, 22, 28, 35, 40, 44, 45, 46,
46, 46, 48, 51, 53, 56, 59, 60, 60, 61, 61, 64, 67, 67, 67, 71, 78, 83, 82, 79,
76, 75, 79, 81, 82, 81, 82, 85, 85, 85, 86, 89, 91, 91, 90, 90, 89, 91, 91, 88,
85, 81, 77, 72, 67, 62, 57, 51, 46, 42, 37, 30, 22, 13, 5, -2, -6, -7, -9, -11,
-14, -19, -24, -27, -29, -28, -27, -26, -24, -21, -17, -13, -12, -13, -16, -18,
-20, -22, -26, -28, -31, -35, -40, -44, -44, -46, -48, -50, -56, -62, -68, -75,
-82, -90, -100, -108, -115, -119, -119, -117, -115, -115, -114, -114, -114,
-114, -113, -113, -113, -111, -111, -109, -108, -106, -103, -99, -94, -89, -83,
-76, -72, -71, -68, -66, -66, -67, -66, -62, -56, -47, -36, -23, -11, -1, 7, 11,
16, 20, 25, 30, 35, 37, 40, 44, 48, 53, 56, 57, 57, 55, 51, 46, 41, 36, 32, 25,
19, 13, 7, 0, -4, -9, -13, -15, -18, -19, -20, -21, -22, -24, -26, -27, -27,
-25, -21, -16, -13, -7, -1, 2, 5, 7, 9, 10, 12, 12, 14, 16, 17, 17, 17, 17, 18,
19, 19, 18, 19, 18, 18, 17, 14, 10, 5, 2, -1, -2, -5, -8, -11, -13, -15, -16,
-19, -19, -19, -18, -15, -14, -12, -10, -6, -1, 3, 7, 11, 13, 16, 20, 23, 26,
29, 30, 30, 31, 33, 33, 35, 35, 36, 37, 41, 45, 49, 52, 55, 56, 58, 60, 62, 64,
65, 66, 67, 68, 69, 67, 67, 65, 62, 59, 55, 50, 45, 38, 31, 26, 21, 16, 12, 7,
4, 0, -3, -8, -14, -18, -24, -26, -29, -32, -34, -35, -37, -37, -37, -36, -35,
-32, -29, -24, -21, -17, -13, -10, -7, -2, 2, 6, 12, 17, 22, 28, 35, 42, 48, 53,
58, 59, 61, 61, 60, 61, 61, 61, 60, 62, 59, 57, 53, 48, 42, 36, 29, 25, 20, 15,
10, 8, 4, 0, -5, -10, -12, -16, -18, -19, -20, -19, -17, -17, -15, -12, -10, -6,
-2, 2, 5, 7, 11, 13, 16, 19, 21, 22, 22, 25, 26, 27, 26, 27, 25, 25, 22, 20, 17,
14, 10, 5, 1, -4, -9, -15, -20, -26, -31, -38, -44, -48, -53, -58, -62, -67,
-70, -73, -74, -77, -79, -80, -80, -80, -81, -80, -80, -80, -81, -82, -83, -83,
-84, -85, -84, -84, -85, -85, -86, -85, -86, -86, -86, -86, -85, -83, -81, -79,
-76, -74, -72, -68, -66, -63, -59, -54, -49, -45, -39, -34, -29, -25, -21, -17,
-14, -10, -7, -5, -2, 0, };