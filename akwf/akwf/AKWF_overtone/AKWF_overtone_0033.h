#define DATA_LENGTH 512
#define DATA AKWF_overtone_0033

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 16, 24, 31, 34, 37, 38, 37, 36, 34,
31, 28, 26, 23, 20, 17, 16, 14, 13, 13, 12, 11, 11, 10, 10, 10, 11, 11, 12, 11,
11, 11, 12, 11, 11, 11, 11, 10, 10, 9, 9, 9, 9, 9, 8, 7, 8, 7, 8, 7, 7, 7, 7, 7,
7, 6, 6, 7, 6, 6, 6, 6, 5, 6, 6, 5, 4, 5, 5, 5, 5, 4, 5, 5, 4, 5, 4, 4, 4, 4, 4,
4, 4, 3, 4, 3, 3, 4, 4, 4, 3, 3, 3, 4, 3, 2, 3, 2, 3, 3, 4, 4, 2, 2, 4, 2, 2, 2,
3, 3, 2, 3, 3, 3, 2, 3, 3, 3, 3, 2, 2, 2, 2, 3, 2, 2, 2, 3, 2, 2, 2, 1, 2, 2, 2,
1, 2, 2, 2, 1, 1, 2, 3, 2, 2, 2, 2, 2, 2, 1, 2, 1, 1, 2, 1, 1, 1, 2, 1, 2, 2, 1,
1, 1, 2, 2, 1, 2, 1, 2, 1, 1, 1, 1, 1, 1, 1, 2, 2, 1, 1, 2, 1, 1, 2, 1, 1, 1, 2,
1, 0, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1, 2, 1, 1, 2, 1, 1, 1, 1, 2, 1, 1, 2, 1, 2, 1,
1, 1, 2, 0, 2, 1, 1, 2, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 2, 1, 0, 2, 2, 2,
1, 1, 2, 2, 1, 1, 1, 2, 1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 1,
1, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, -1, 0, -1, 0, 0, -1, 0, 0, -1,
-1, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0,
-1, -1, -1, -1, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, -1, 0, 0, 0,
-1, 0, -1, 0, -1, 0, -1, -1, 0, 0, 0, 0, 0, 0, -1, -1, -1, 0, -1, 0, -1, 0, -1,
0, 0, 0, 0, -1, 0, -1, 0, -1, 0, 0, 0, -1, -1, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0,
-1, -1, -1, 0, 0, 0, 0, -1, -1, 0, 0, 0, -1, -1, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0,
-1, 0, -1, -1, -1, 0, -1, -1, 0, -1, -1, 0, -1, -1, -1, -1, -1, 0, 0, -1, 0, -1,
0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, -1, -1, -1, -1, 0, 0, -1, -1, -1,
-1, 0, 0, -1, 0, -1, 0, -4, -20, -41, -62, -82, -98, -111, -118, -119, -116,
-107, -95, -81, -64, -48, -33, -18, -4, };