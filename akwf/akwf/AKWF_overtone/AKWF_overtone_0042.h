#define DATA_LENGTH 512
#define DATA AKWF_overtone_0042

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 4, 5, 6, 7, 8, 8, 10, 11,
12, 13, 13, 15, 16, 16, 18, 19, 19, 21, 22, 23, 24, 25, 27, 27, 28, 29, 30, 32,
33, 33, 35, 36, 37, 38, 39, 40, 42, 44, 44, 45, 46, 47, 48, 50, 51, 53, 54, 55,
56, 58, 57, 60, 61, 62, 63, 64, 65, 66, 69, 69, 70, 71, 73, 73, 75, 74, 79, 77,
81, 79, 84, 82, 86, 84, 88, 87, 90, 88, 20, 2, 10, 8, 12, 12, 14, 16, 14, 20,
15, 26, 13, 61, 113, 112, 110, 116, 112, 119, 112, 123, 108, -97, -107, -97,
-105, -94, -102, -92, -99, -90, -95, -86, -92, -86, -90, -83, -86, -82, -83,
-80, -80, -77, -77, -75, -74, -73, -72, -71, -69, -69, -67, -66, -64, -65, -62,
-62, -60, -59, -58, -58, -56, -55, -53, -53, -52, -51, -50, -49, -48, -46, -45,
-44, -45, -43, -42, -40, -40, -38, -38, -36, -37, -35, -35, -33, -32, -31, -30,
-29, -29, -28, -27, -26, -25, -24, -23, -22, -22, -20, -20, -19, -18, -17, -17,
-16, -15, -14, -13, -13, -12, -11, -10, -10, -9, -8, -7, -6, -5, -5, -5, -5, -4,
-3, -2, -1, 0, 0, 1, 2, 3, 2, 4, 5, 5, 5, 6, 7, 7, 8, 8, 10, 10, 11, 11, 11, 12,
12, 13, 13, 14, 15, 15, 16, 15, 17, 17, 18, 17, 18, 18, 20, 20, 20, 20, 21, 22,
21, 21, 22, 22, 23, 23, 24, 23, 24, 24, 25, 26, 25, 26, 26, 26, 27, 27, 27, 27,
27, 28, 28, 28, 28, 29, 28, 28, 29, 28, 29, 30, 29, 29, 29, 30, 29, 29, 29, 30,
30, 29, 30, 29, 30, 29, 29, 29, 29, 29, 30, 29, 29, 29, 30, 29, 29, 29, 28, 28,
28, 27, 27, 27, 27, 26, 26, 27, 27, 25, 26, 26, 24, 25, 25, 25, 23, 24, 23, 24,
21, 24, 21, 23, 20, 23, 19, 23, 13, -59, -70, -66, -68, -66, -68, -67, -68, -68,
-68, -70, -66, -75, -27, 23, 12, 17, 13, 16, 13, 14, 13, 12, 11, 11, 11, 10, 9,
8, 8, 7, 6, 5, 6, 4, 5, 4, 3, 2, 2, 1, 1, 0, 0, -1, -1, -2, -3, -2, -4, -4, -5,
-5, -6, -6, -7, -8, -8, -9, -10, -11, -11, -11, -11, -13, -13, -13, -14, -15,
-15, -16, -17, -17, -16, -17, -18, -18, -19, -20, -19, -20, -20, -20, -21, -21,
-22, -22, -23, -23, -23, -24, -24, -24, -25, -25, -24, -25, -25, -26, -25, -26,
-26, -27, -26, -26, -26, -27, -27, -28, -27, -27, -27, -27, -27, -27, -27, -28,
-27, -27, -27, -26, -27, -27, -26, -26, -26, -26, -25, -25, -25, -25, -25, -24,
-24, -23, -23, -23, -22, -22, -21, -21, -21, -20, -20, -20, -19, -20, -18, -18,
-17, -17, -17, -15, -15, -15, -14, -13, -12, -12, -11, -10, -10, -10, -8, -7,
-7, -6, -5, -4, -3, -2, -3, 0, 0, };