#define DATA_LENGTH 512
#define DATA AKWF_overtone_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 13, 21, 28, 35, 43, 50, 56, 63, 68,
73, 78, 83, 87, 91, 93, 95, 98, 99, 100, 101, 101, 101, 100, 99, 98, 97, 94, 92,
88, 86, 82, 79, 75, 70, 67, 62, 59, 53, 48, 43, 39, 34, 29, 24, 20, 15, 10, 5,
0, -5, -8, -13, -18, -21, -25, -29, -33, -36, -39, -42, -44, -47, -50, -51, -53,
-54, -56, -58, -58, -59, -59, -60, -59, -60, -60, -58, -58, -57, -56, -55, -54,
-53, -51, -49, -47, -45, -43, -41, -38, -37, -35, -32, -30, -27, -24, -22, -19,
-17, -14, -12, -9, -8, -6, -2, -1, 1, 4, 7, 9, 10, 12, 14, 16, 17, 18, 21, 22,
23, 24, 24, 25, 26, 27, 28, 27, 28, 28, 28, 28, 28, 28, 28, 27, 27, 27, 26, 26,
24, 24, 23, 22, 21, 19, 18, 18, 16, 15, 14, 12, 11, 11, 9, 8, 6, 5, 4, 3, 1, 0,
-1, -2, -3, -4, -5, -6, -7, -9, -9, -9, -11, -12, -12, -13, -13, -14, -14, -14,
-15, -15, -16, -15, -16, -15, -15, -16, -15, -16, -15, -16, -16, -15, -14, -14,
-13, -13, -13, -12, -12, -11, -10, -10, -9, -8, -9, -8, -7, -6, -5, -5, -3, -3,
-3, -3, -1, -1, 0, 0, 1, 2, 2, 3, 4, 3, 4, 5, 5, 5, 7, 6, 6, 7, 7, 8, 7, 8, 8,
9, 8, 8, 8, 8, 8, 8, 9, 8, 7, 8, 8, 8, 7, 7, 7, 6, 6, 7, 5, 6, 5, 5, 4, 4, 3, 4,
4, 3, 3, 2, 2, 2, 1, 1, 1, 1, 0, 0, -1, 0, -1, -1, -1, -2, -2, -2, -1, -3, -2,
-2, -3, -2, -3, -2, -3, -3, -3, -3, -2, -3, -3, -2, -3, -2, -2, -2, -2, -2, -1,
-2, -1, -2, -1, -2, -2, -1, 0, -1, -1, 0, 0, 1, 0, 0, 1, 1, 1, 2, 1, 2, 2, 2, 3,
2, 1, 2, 3, 3, 2, 3, 3, 3, 4, 4, 3, 3, 4, 3, 4, 3, 3, 4, 4, 4, 3, 3, 3, 4, 3, 4,
3, 4, 4, 3, 3, 3, 3, 4, 3, 3, 3, 2, 2, 2, 2, 3, 2, 2, 2, 2, 2, 2, 1, 2, 0, 2, 2,
1, 1, 1, 1, 1, 1, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 0, -1, 0, 0, 1, -1, -1, -1, 0,
0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 1, 0,
1, 0, 0, 0, 1, 1, 0, 0, 1, 1, 1, 2, 1, 0, 1, 1, 0, 1, 2, 0, 1, 1, 1, 1, 1, 1, 1,
1, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, -6, -41,
-82, -103, -106, -103, -108, -115, -119, -117, -110, -102, -95, -92, -89, -85,
-77, -68, -58, -50, -43, -37, -28, -20, -10, -2, };