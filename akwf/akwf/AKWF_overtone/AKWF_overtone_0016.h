#define DATA_LENGTH 512
#define DATA AKWF_overtone_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 12, 17, 22, 26, 30, 34, 38, 41,
45, 48, 51, 54, 56, 58, 60, 62, 62, 64, 65, 66, 66, 66, 66, 66, 66, 65, 64, 63,
62, 61, 59, 57, 55, 53, 51, 49, 47, 44, 41, 39, 36, 34, 31, 27, 25, 22, 18, 16,
13, 11, 7, 4, 1, -1, -4, -6, -9, -12, -13, -16, -18, -20, -23, -24, -25, -27,
-29, -30, -31, -32, -34, -34, -35, -35, -36, -37, -36, -38, -36, -37, -37, -37,
-36, -35, -34, -34, -33, -32, -32, -30, -29, -28, -26, -25, -24, -22, -21, -20,
-19, -17, -15, -14, -13, -10, -10, -8, -6, -5, -4, -2, -1, 0, 2, 3, 5, 6, 7, 7,
9, 10, 10, 12, 11, 13, 14, 14, 14, 14, 15, 16, 16, 16, 15, 16, 17, 17, 16, 15,
15, 16, 14, 14, 14, 14, 13, 12, 13, 11, 11, 11, 10, 9, 9, 8, 6, 7, 5, 5, 4, 4,
2, 2, 1, 1, -2, -1, -2, -2, -3, -3, -5, -4, -6, -6, -7, -7, -7, -8, -8, -9, -9,
-9, -10, -9, -10, -9, -10, -10, -10, -11, -10, -10, -10, -10, -9, -10, -9, -9,
-9, -8, -9, -8, -8, -7, -6, -6, -6, -6, -6, -5, -4, -4, -3, -3, -3, -3, -1, -2,
-1, -1, 0, 0, 0, 1, 1, 2, 2, 2, 2, 2, 3, 3, 4, 4, 3, 4, 5, 5, 5, 5, 4, 5, 5, 6,
5, 4, 5, 5, 5, 4, 5, 5, 4, 5, 4, 4, 5, 5, 4, 5, 5, 3, 4, 4, 3, 3, 3, 3, 2, 3, 2,
2, 2, 1, 1, 2, 1, 1, 0, 0, 0, 0, 0, 0, 1, -1, -1, -1, -1, 0, -1, -1, -1, -1, -1,
-2, -1, -1, -1, -2, -2, -1, -1, -1, -1, -2, 0, -1, -1, -1, -1, -1, 0, -1, 0, 0,
0, 0, 0, 0, -1, 1, 1, 0, 1, 1, 1, 2, 1, 1, 1, 2, 2, 2, 2, 3, 2, 2, 2, 2, 2, 2,
3, 3, 3, 3, 2, 3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 4, 4, 3, 2, 3, 2, 3, 3, 3, 3, 3, 2,
2, 2, 2, 2, 2, 2, 3, 2, 2, 2, 2, 3, 1, 2, 2, 2, 2, 2, 1, 1, 1, 2, 1, 1, 1, 2, 1,
1, 0, 1, 0, 1, 1, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 1, 1, 0,
0, 1, 1, 0, 0, 0, 0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 1, 0, 1, 1, 0,
1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0,
0, 0, 1, 0, 0, 0, 0, -12, -64, -104, -92, -75, -87, -114, -119, -98, -77, -72,
-80, -82, -72, -58, -52, -50, -49, -42, -32, -26, -22, -18, -14, -6, -1, };