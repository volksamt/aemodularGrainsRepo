#define DATA_LENGTH 512
#define DATA AKWF_overtone_0038

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 0, 0, 1, 1, 1, 1, 0, 1, 0, 0, 0,
1, 1, 1, 0, 0, 1, 0, 0, 0, 1, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0,
0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 0, 1, 1, 1, 1, 0, 0, 1, 1, 1, 1, 0, 0, 1, 1, 1,
1, 2, 1, 0, 1, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 1, 0, 1, 1, 0, 0,
0, 0, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, 0, 1, 1, 1, 1, 0, 1, 0, 0,
1, 0, 0, 1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 0, 1,
0, 1, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 1, 1, 1, 1, 0, 0, 0, 0, 0, 1, 1, 1, 1,
0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0, 0, 0, 1, 0, 1,
-1, 1, 0, 1, -1, 1, 0, 2, -1, 1, 0, 1, 0, 2, 0, 0, 1, -1, 55, 61, 46, 45, 36,
35, 28, 27, 22, 23, 19, 18, 15, 15, 12, 13, 11, 10, 10, 9, 9, 8, 8, 8, 7, 7, 7,
6, 7, 6, 6, 6, 6, 6, 5, 5, 6, 6, 5, 5, 5, 5, 5, 5, 5, 6, 5, 5, 6, 5, 6, 6, 5, 5,
5, 6, 5, 5, 5, 6, 5, 5, 6, 4, 5, 5, 5, 5, 4, 5, 5, 6, 5, 5, 6, 4, 4, 5, 3, 3, 3,
3, 2, 2, 1, 1, 1, 1, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, -1, 0, -2, 0, -1, -1,
-1, -1, -1, -1, -1, -1, 0, 0, 0, -2, -1, 0, -1, -2, -1, -1, 0, -1, -1, -1, 0, 0,
-2, 0, 0, 0, 0, 0, -1, -1, -1, -1, -1, 0, -1, 0, -1, 0, -1, -1, -1, -1, -1, 0,
-1, -1, 0, -1, -1, -1, -1, -1, -1, -1, 0, -1, -1, 0, -1, 0, 0, -1, 0, -1, 0, -1,
-1, -1, -1, -1, -2, -1, 0, -1, -1, -1, 0, -1, -1, -1, -1, 0, -1, -1, 0, -1, 0,
0, -1, -1, 0, -1, -1, 0, -1, -1, -1, 0, 0, -1, -1, 0, -1, -1, -1, -1, 0, 0, 0,
-1, -2, -1, 0, 0, 0, -1, -1, -1, -1, -1, 0, 0, -1, -1, -1, 0, 0, -1, -1, -1, -1,
-1, -1, -2, 0, 0, 0, -1, -1, 0, -1, -1, 0, -1, -1, 0, -1, 1, -2, 2, -68, -120,
-97, -87, -73, -64, -55, -47, -41, -35, -29, -25, -21, -19, -16, -14, -12, -10,
-9, -7, -6, -5, -4, -3, -3, -2, -2, -2, -1, -1, 0, -1, 0, 0, -1, 0, };