#define DATA_LENGTH 512
#define DATA AKWF_overtone_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 7, 10, 11, 13, 15, 15, 16,
18, 19, 20, 20, 21, 22, 22, 22, 24, 23, 23, 24, 23, 23, 24, 24, 24, 24, 23, 23,
22, 22, 22, 22, 21, 20, 20, 20, 19, 19, 19, 18, 18, 17, 17, 16, 15, 15, 14, 14,
13, 12, 13, 12, 11, 11, 11, 9, 9, 9, 8, 8, 8, 7, 7, 7, 7, 5, 5, 5, 4, 4, 5, 3,
3, 2, 2, 3, 1, 2, 1, 2, 1, 1, 0, 0, 0, 0, 0, -1, -2, 0, -1, -1, -2, -2, -2, -2,
-2, -2, -1, -2, -2, -3, -2, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3,
-4, -4, -4, -4, -3, -4, -3, -3, -4, -4, -3, -4, -4, -3, -4, -4, -4, -3, -3, -4,
-4, -4, -4, -3, -4, -3, -4, -3, -4, -4, -3, -4, -3, -4, -3, -3, -3, -4, -3, -3,
-3, -3, -3, -4, -4, -4, -3, -3, -3, -3, -3, -3, -3, -2, -4, -3, -2, -2, -3, -3,
-3, -2, -2, -2, -3, -2, -3, -2, -3, -2, -3, -2, -3, -2, -2, -3, -2, -3, -3, -1,
-2, -2, -1, -2, -3, -2, -2, -2, -2, -2, -1, -2, -1, -1, -2, -1, -2, -1, -2, -1,
-1, -1, -1, -2, -1, -1, -1, -1, -1, -1, -2, -2, -1, -2, -1, -1, -1, -1, -1, -1,
-1, -2, -1, 0, -1, -1, 0, 0, -1, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0,
0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 1, 0, 1, 1, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1,
1, 1, 2, 1, 1, 2, 1, 2, 2, 2, 1, 1, 1, 2, 2, 1, 1, 2, 1, 2, 2, 1, 2, 1, 1, 1, 2,
1, 2, 2, 2, 2, 2, 2, 2, 3, 2, 1, 2, 2, 2, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 2, 2,
3, 3, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 3, 3, 2, 2, 3, 3, 3, 3, 2, 2, 3, 3, 3, 2, 3,
2, 3, 2, 3, 3, 2, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 2, 2, 2, 2, 2, 2, 3, 3, 2,
3, 2, 3, 3, 3, 3, 3, 2, 3, 2, 3, 2, 3, 2, 2, 2, 2, 3, 2, 3, 3, 2, 3, 2, 2, 1, 1,
3, 2, 1, 2, 2, 2, 2, 3, 2, 2, 2, 2, 2, 2, 2, 3, 2, 2, 2, 2, 2, 1, 2, 1, 2, 2, 2,
2, 2, 2, 3, 2, 2, 1, 2, 2, 2, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 2, 0, 2, 1, 2, 0, 2,
-1, 3, 0, 4, -2, 4, -3, 6, -5, 10, -21, -123, -106, -102, -93, -85, -79, -70,
-66, -58, -54, -47, -44, -36, -35, -28, -26, -20, -18, -13, -10, -6, -4, -1, };