#define DATA_LENGTH 512
#define DATA AKWF_overtone_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 6, 7, 9, 10, 11, 12, 13, 14,
14, 16, 16, 17, 18, 19, 19, 19, 20, 21, 20, 21, 21, 22, 22, 22, 22, 23, 23, 22,
23, 22, 23, 23, 23, 23, 23, 22, 22, 21, 22, 22, 22, 22, 21, 21, 21, 20, 21, 20,
19, 20, 19, 19, 18, 18, 18, 18, 17, 17, 16, 16, 16, 14, 15, 15, 13, 14, 13, 13,
13, 12, 11, 12, 11, 10, 10, 9, 9, 9, 9, 9, 8, 8, 8, 7, 6, 6, 6, 6, 5, 5, 4, 4,
3, 4, 3, 3, 3, 2, 2, 2, 2, 1, 1, 0, 0, 0, 0, -1, -1, -1, 0, -2, -2, -2, -2, -3,
-2, -2, -3, -3, -3, -4, -3, -4, -3, -4, -4, -4, -4, -5, -5, -5, -5, -4, -6, -5,
-5, -5, -6, -6, -6, -6, -5, -5, -7, -6, -6, -6, -6, -7, -6, -7, -7, -7, -6, -6,
-7, -6, -7, -6, -7, -7, -6, -7, -7, -7, -7, -7, -7, -6, -7, -7, -7, -7, -7, -6,
-7, -7, -7, -6, -7, -7, -7, -6, -6, -6, -7, -6, -6, -6, -7, -6, -6, -6, -5, -6,
-6, -5, -6, -5, -6, -6, -5, -5, -5, -5, -6, -6, -4, -5, -5, -5, -5, -4, -4, -4,
-4, -4, -4, -4, -4, -5, -3, -4, -3, -3, -4, -4, -3, -3, -4, -3, -3, -3, -4, -3,
-3, -3, -2, -2, -3, -2, -3, -2, -2, -2, -2, -1, -2, -2, -1, -2, -1, -1, -1, -1,
-1, -1, -1, -1, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 1, 1, 1, 1, 1, 0, 0,
1, 1, 1, 1, 1, 2, 2, 2, 2, 2, 2, 3, 2, 2, 2, 3, 2, 3, 3, 3, 2, 3, 3, 2, 2, 3, 3,
4, 3, 3, 4, 4, 3, 3, 4, 3, 4, 4, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 5, 4, 4, 5, 5, 4,
5, 5, 4, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 6, 6, 5, 5, 6, 5, 6, 6, 6, 5,
6, 7, 6, 7, 6, 6, 6, 6, 6, 6, 6, 5, 6, 6, 6, 5, 6, 6, 5, 5, 6, 5, 6, 6, 5, 6, 6,
6, 5, 6, 5, 5, 6, 6, 6, 6, 6, 6, 7, 6, 6, 6, 6, 7, 6, 6, 5, 6, 6, 6, 6, 6, 5, 6,
6, 6, 5, 6, 6, 6, 6, 6, 5, 5, 5, 6, 4, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 6, 5, 5, 4,
5, 4, 5, 4, 5, 4, 5, 4, 4, 4, 4, 5, 4, 4, 3, 5, 3, 4, 2, 4, 2, 6, 1, 6, 2, 6, 0,
7, -2, 10, -12, -122, -112, -107, -102, -95, -92, -86, -83, -76, -73, -66, -65,
-58, -58, -51, -50, -44, -43, -38, -36, -32, -30, -26, -24, -21, -18, -16, -13,
-12, -9, -8, -5, -4, -2, 0, };