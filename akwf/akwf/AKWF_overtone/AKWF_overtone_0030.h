#define DATA_LENGTH 512
#define DATA AKWF_overtone_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 22, 41, 61, 77, 89, 93, 88, 76, 58,
38, 14, -12, -39, -60, -78, -87, -89, -85, -77, -66, -53, -37, -20, -1, 18, 33,
41, 44, 43, 35, 24, 9, -7, -25, -45, -65, -83, -99, -110, -118, -120, -116,
-108, -96, -80, -61, -44, -25, -10, 0, 4, 3, -3, -10, -19, -29, -38, -44, -50,
-54, -57, -58, -57, -55, -51, -46, -43, -39, -35, -32, -29, -25, -21, -17, -11,
-7, 0, 5, 11, 16, 19, 21, 21, 21, 20, 18, 17, 17, 15, 13, 9, 6, 3, 0, -2, -3,
-4, -2, 3, 10, 21, 31, 44, 56, 67, 75, 80, 83, 81, 77, 68, 56, 42, 26, 14, 2,
-8, -13, -15, -13, -9, -2, 6, 15, 25, 36, 45, 51, 55, 56, 56, 53, 48, 40, 30,
17, 5, -8, -21, -32, -40, -47, -50, -51, -48, -41, -33, -25, -15, -8, 1, 5, 7,
6, 4, -1, -8, -13, -20, -27, -32, -37, -40, -43, -43, -44, -44, -43, -41, -39,
-37, -35, -31, -28, -24, -19, -15, -10, -6, -2, 0, 2, 4, 4, 3, 3, 1, 0, -2, -2,
-3, -3, -4, -5, -5, -5, -5, -4, -1, 2, 6, 12, 20, 26, 34, 40, 47, 51, 55, 56,
55, 51, 45, 39, 32, 24, 16, 11, 7, 6, 6, 8, 11, 16, 22, 28, 34, 40, 44, 48, 51,
53, 52, 49, 46, 40, 33, 26, 18, 9, 2, -6, -10, -16, -18, -18, -15, -11, -7, -2,
4, 8, 13, 15, 15, 15, 13, 10, 6, 1, -5, -12, -17, -23, -28, -32, -35, -38, -40,
-40, -41, -40, -36, -34, -28, -25, -20, -18, -15, -13, -13, -11, -13, -16, -19,
-23, -26, -27, -28, -28, -29, -28, -27, -25, -25, -23, -21, -19, -18, -16, -13,
-10, -8, -6, -4, -1, 3, 5, 7, 8, 8, 8, 8, 7, 7, 6, 7, 7, 8, 8, 11, 13, 14, 17,
19, 21, 23, 25, 27, 29, 31, 33, 35, 36, 36, 35, 35, 32, 28, 26, 21, 17, 13, 10,
8, 7, 7, 7, 9, 12, 17, 20, 24, 26, 27, 28, 26, 24, 20, 16, 10, 4, -2, -7, -13,
-18, -21, -22, -22, -23, -22, -20, -16, -13, -8, -4, 1, 4, 6, 6, 4, 2, -2, -6,
-12, -19, -27, -34, -40, -45, -47, -49, -49, -49, -47, -44, -39, -34, -30, -25,
-22, -18, -15, -14, -11, -10, -10, -10, -13, -16, -18, -21, -24, -29, -32, -34,
-35, -36, -35, -31, -28, -23, -19, -12, -6, 2, 9, 15, 20, 24, 26, 26, 27, 26,
24, 22, 18, 13, 10, 7, 4, 2, 2, 3, 4, 7, 11, 16, 23, 29, 35, 41, 46, 49, 51, 53,
54, 53, 49, 46, 41, 34, 29, 23, 19, 15, 12, 10, 10, 10, 9, 9, 9, 9, 10, 11, 13,
14, 14, 12, 11, 10, 11, 11, 12, 11, 12, 11, 12, 13, 16, 21, 24, 28, 31, 32, 33,
31, 31, 29, 24, 17, 9, -1, -9, -16, -19, -20, -18, -13, -5, };