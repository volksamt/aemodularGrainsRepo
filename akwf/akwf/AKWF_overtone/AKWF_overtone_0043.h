#define DATA_LENGTH 512
#define DATA AKWF_overtone_0043

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 14, 23, 33, 43, 53, 62, 71, 78, 86,
93, 99, 105, 109, 112, 116, 117, 119, 119, 119, 117, 116, 114, 111, 108, 104,
100, 97, 92, 87, 82, 78, 73, 68, 64, 59, 54, 50, 46, 42, 37, 33, 29, 26, 23, 18,
16, 12, 9, 6, 3, -1, -4, -6, -10, -13, -16, -20, -22, -26, -29, -32, -36, -39,
-41, -45, -48, -51, -53, -56, -59, -61, -62, -65, -66, -68, -69, -69, -71, -71,
-71, -70, -71, -70, -69, -67, -66, -64, -62, -59, -56, -54, -50, -46, -44, -40,
-37, -33, -29, -25, -21, -16, -13, -9, -5, -1, 4, 7, 12, 15, 19, 23, 26, 29, 32,
35, 38, 39, 40, 41, 42, 42, 41, 39, 37, 34, 31, 27, 24, 20, 16, 11, 6, 2, -2,
-6, -9, -12, -14, -16, -19, -19, -20, -20, -19, -19, -18, -16, -15, -12, -10,
-7, -5, -2, 0, 2, 4, 5, 8, 9, 11, 12, 12, 13, 12, 12, 11, 11, 10, 9, 7, 6, 3, 2,
-1, -3, -4, -7, -8, -10, -12, -14, -15, -15, -17, -18, -17, -18, -18, -18, -16,
-16, -16, -15, -12, -11, -9, -6, -4, -2, 0, 2, 5, 7, 10, 14, 16, 19, 21, 24, 26,
29, 32, 33, 36, 38, 39, 42, 44, 45, 46, 49, 50, 51, 52, 51, 53, 54, 54, 53, 54,
54, 53, 52, 52, 50, 49, 47, 44, 42, 41, 37, 34, 32, 27, 24, 21, 18, 14, 12, 9,
7, 5, 3, 2, 0, -2, -4, -5, -7, -9, -11, -13, -15, -18, -22, -25, -29, -33, -37,
-42, -47, -52, -57, -63, -68, -73, -80, -84, -88, -93, -97, -100, -104, -106,
-108, -109, -110, -109, -109, -108, -105, -102, -99, -95, -91, -86, -80, -74,
-67, -61, -55, -48, -41, -33, -25, -18, -11, -4, 4, 10, 16, 23, 28, 35, 40, 45,
49, 54, 58, 61, 63, 66, 67, 70, 71, 72, 72, 72, 72, 73, 71, 70, 69, 68, 66, 65,
64, 62, 60, 58, 56, 53, 51, 50, 47, 45, 42, 41, 39, 35, 34, 31, 30, 28, 26, 24,
22, 21, 19, 18, 17, 15, 14, 12, 12, 11, 9, 9, 9, 7, 7, 5, 3, 3, 1, 0, -3, -6,
-9, -11, -15, -20, -23, -28, -31, -35, -39, -43, -47, -48, -51, -52, -55, -55,
-55, -54, -53, -51, -48, -46, -42, -38, -34, -29, -25, -20, -14, -9, -3, 1, 5,
11, 15, 19, 23, 26, 30, 32, 34, 37, 38, 38, 39, 39, 38, 38, 37, 36, 34, 33, 31,
29, 26, 24, 22, 19, 18, 15, 12, 10, 8, 7, 4, 2, 0, -1, -2, -3, -4, -5, -6, -7,
-7, -8, -9, -10, -10, -11, -12, -12, -12, -14, -14, -15, -17, -18, -19, -21,
-22, -24, -26, -28, -29, -33, -35, -38, -40, -42, -45, -47, -50, -53, -55, -57,
-60, -62, -65, -66, -69, -70, -71, -73, -74, -75, -75, -76, -74, -74, -73, -70,
-68, -65, -60, -55, -50, -43, -37, -28, -22, -12, -3, };