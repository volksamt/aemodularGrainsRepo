#define DATA_LENGTH 512
#define DATA AKWF_overtone_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 14, 20, 27, 33, 41, 47, 54, 60, 65,
71, 77, 82, 86, 91, 95, 99, 102, 106, 108, 110, 112, 114, 116, 117, 119, 119,
119, 119, 118, 118, 118, 117, 116, 116, 114, 113, 111, 109, 108, 105, 104, 101,
99, 96, 94, 92, 88, 86, 83, 80, 77, 75, 71, 68, 66, 63, 59, 56, 53, 50, 47, 43,
41, 37, 35, 32, 29, 26, 22, 19, 17, 13, 11, 8, 5, 2, 0, -3, -6, -8, -11, -14,
-17, -19, -21, -23, -26, -28, -30, -33, -35, -37, -39, -41, -42, -45, -47, -49,
-50, -52, -54, -55, -56, -58, -60, -61, -62, -63, -64, -65, -65, -68, -68, -69,
-70, -69, -70, -72, -72, -73, -72, -72, -72, -73, -73, -73, -73, -73, -73, -72,
-72, -71, -72, -71, -70, -70, -69, -69, -68, -67, -67, -65, -64, -63, -63, -61,
-59, -59, -57, -55, -55, -52, -51, -49, -48, -46, -43, -41, -40, -38, -36, -34,
-32, -30, -27, -25, -23, -20, -19, -16, -14, -11, -8, -6, -3, 0, 1, 5, 8, 9, 13,
16, 18, 21, 24, 27, 31, 33, 35, 39, 42, 45, 47, 50, 53, 56, 59, 62, 65, 67, 70,
73, 76, 79, 82, 83, 87, 90, 92, 93, 95, 98, 100, 102, 103, 105, 108, 109, 110,
111, 112, 113, 114, 114, 115, 115, 116, 115, 114, 113, 112, 111, 109, 107, 105,
102, 99, 96, 92, 89, 85, 81, 75, 70, 65, 60, 54, 48, 41, 35, 28, 21, 15, 8, 1,
-7, -13, -21, -27, -35, -41, -48, -55, -60, -66, -71, -77, -82, -86, -90, -95,
-99, -102, -105, -109, -111, -112, -115, -116, -118, -118, -118, -119, -119,
-119, -119, -118, -118, -117, -115, -114, -111, -111, -109, -107, -105, -103,
-100, -98, -96, -94, -91, -88, -85, -83, -80, -77, -74, -71, -68, -65, -63, -60,
-55, -53, -50, -46, -44, -40, -38, -35, -31, -28, -25, -22, -19, -16, -14, -11,
-8, -4, -2, 1, 3, 6, 10, 11, 14, 17, 19, 22, 24, 26, 29, 31, 32, 35, 37, 40, 41,
43, 45, 47, 49, 50, 52, 53, 55, 56, 57, 59, 61, 62, 62, 64, 66, 65, 66, 68, 69,
69, 70, 70, 72, 71, 71, 73, 72, 73, 72, 73, 73, 73, 73, 73, 73, 73, 71, 72, 71,
71, 71, 69, 69, 68, 66, 67, 65, 64, 63, 61, 61, 59, 58, 57, 55, 53, 53, 50, 49,
47, 46, 44, 42, 39, 37, 36, 34, 32, 30, 27, 26, 23, 21, 18, 16, 13, 12, 8, 6, 3,
0, -2, -5, -8, -10, -14, -16, -19, -22, -25, -28, -30, -33, -37, -39, -42, -45,
-48, -51, -54, -56, -60, -62, -65, -68, -70, -73, -76, -79, -81, -84, -87, -89,
-91, -94, -95, -98, -101, -102, -104, -106, -107, -109, -110, -112, -112, -113,
-114, -115, -114, -115, -114, -115, -113, -112, -111, -111, -109, -107, -104,
-102, -100, -96, -93, -88, -84, -80, -75, -70, -65, -59, -53, -47, -41, -35,
-28, -21, -14, -7, 0, };