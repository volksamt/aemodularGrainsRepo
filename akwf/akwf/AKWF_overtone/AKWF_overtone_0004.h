#define DATA_LENGTH 512
#define DATA AKWF_overtone_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {23, 66, 98, 110, 114, 117, 119, 119,
119, 118, 117, 116, 115, 114, 112, 111, 110, 107, 106, 105, 103, 101, 100, 98,
96, 95, 93, 91, 89, 88, 87, 85, 84, 82, 80, 78, 77, 75, 74, 73, 71, 69, 67, 65,
65, 63, 61, 60, 59, 58, 56, 54, 52, 51, 51, 49, 47, 46, 45, 44, 42, 41, 39, 38,
36, 35, 34, 33, 31, 30, 29, 27, 26, 25, 24, 23, 22, 21, 20, 18, 17, 15, 15, 13,
13, 12, 11, 9, 9, 7, 7, 6, 5, 4, 3, 2, 1, 1, -1, -1, -2, -4, -4, -5, -6, -7, -7,
-8, -8, -10, -10, -11, -11, -12, -13, -14, -15, -15, -16, -16, -17, -17, -18,
-19, -18, -19, -19, -21, -21, -22, -22, -22, -22, -24, -23, -24, -24, -24, -25,
-25, -26, -26, -26, -26, -27, -27, -27, -27, -27, -27, -28, -28, -28, -28, -29,
-29, -29, -29, -29, -29, -30, -29, -29, -29, -29, -29, -30, -29, -29, -29, -29,
-29, -28, -28, -28, -28, -28, -28, -29, -27, -28, -27, -27, -27, -26, -27, -26,
-27, -26, -26, -26, -25, -25, -25, -25, -24, -24, -24, -23, -23, -23, -22, -22,
-21, -22, -21, -21, -21, -19, -19, -19, -19, -19, -18, -18, -18, -16, -17, -16,
-15, -15, -14, -14, -14, -13, -13, -12, -12, -11, -12, -10, -10, -9, -9, -9, -8,
-7, -7, -7, -6, -5, -6, -4, -4, -3, -3, -3, -2, -1, -1, -1, 0, 1, 1, 2, 2, 2, 3,
4, 4, 5, 5, 6, 6, 8, 7, 7, 8, 10, 9, 9, 10, 11, 11, 12, 12, 12, 13, 13, 13, 15,
15, 15, 15, 16, 16, 17, 17, 17, 18, 18, 19, 19, 19, 20, 20, 21, 20, 21, 21, 21,
22, 22, 23, 23, 24, 24, 24, 23, 24, 24, 25, 24, 24, 25, 25, 25, 26, 26, 27, 26,
26, 26, 26, 27, 28, 26, 28, 27, 27, 27, 27, 28, 28, 27, 28, 27, 28, 28, 28, 27,
27, 27, 27, 27, 27, 26, 26, 27, 26, 26, 26, 26, 25, 26, 26, 25, 26, 25, 25, 23,
23, 24, 24, 23, 23, 22, 22, 22, 22, 21, 20, 19, 20, 19, 19, 19, 18, 18, 16, 17,
16, 15, 15, 15, 14, 13, 13, 12, 12, 12, 11, 10, 9, 8, 9, 7, 6, 6, 5, 4, 4, 3, 1,
2, 0, 0, -1, -2, -3, -4, -3, -5, -5, -6, -7, -8, -9, -11, -11, -12, -12, -14,
-15, -15, -17, -18, -19, -19, -20, -21, -22, -24, -24, -26, -27, -28, -29, -30,
-31, -33, -34, -34, -35, -37, -38, -39, -39, -41, -42, -43, -44, -46, -47, -48,
-49, -50, -51, -54, -54, -55, -57, -58, -58, -60, -62, -63, -64, -65, -67, -68,
-69, -71, -71, -73, -74, -76, -77, -78, -79, -81, -83, -84, -85, -86, -87, -89,
-89, -91, -93, -94, -95, -97, -98, -99, -100, -101, -102, -104, -105, -106,
-107, -107, -107, -107, -106, -104, -101, -97, -84, -47, -8, };