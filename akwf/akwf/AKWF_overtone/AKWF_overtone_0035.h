#define DATA_LENGTH 512
#define DATA AKWF_overtone_0035

const PROGMEM int8_t DATA[DATA_LENGTH] = {22, 108, 111, 90, 80, 65, 60, 48, 43,
35, 32, 25, 22, 17, 16, 12, 11, 9, 8, 6, 4, 3, 3, 2, 1, 0, 0, -1, 0, -1, -2, -1,
-2, -2, -2, -2, -2, -2, -2, -2, -3, -3, -3, -2, -3, -3, -2, -4, -3, -3, -3, -3,
-3, -3, -3, -3, -3, -3, -3, -3, -3, -2, -2, -2, -3, -2, -3, -3, -3, -3, -3, -3,
-2, -3, -3, -2, -3, -3, -3, -3, -3, -3, -2, -3, -3, -2, -3, -2, -2, -3, -3, -2,
-2, -2, -3, -2, -2, -2, -2, -2, -3, -3, -2, -2, -2, -2, -3, -3, -3, -2, -2, -2,
-2, -3, -2, -3, -3, -3, -2, -3, -2, -2, -2, -2, -3, -3, -2, -3, -3, -3, -2, -2,
-3, -3, -2, -2, -2, -3, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -3, -2,
-2, -3, -2, -2, -2, -2, -2, -2, -2, -3, -2, -2, -2, -2, -2, -3, -2, -2, -2, -3,
-2, -2, -2, -3, -2, -1, -3, -3, -2, -3, -2, -2, -2, -3, -2, -2, -2, -2, -3, -3,
-2, -2, -2, -2, -2, -2, -3, -2, -1, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2,
-2, -2, -2, -2, -1, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -1, -2, -2, -2, -2,
-2, -1, -1, -1, -2, -2, -1, -2, -2, -2, -1, -2, -2, -3, -2, -2, -2, -1, -1, -2,
-1, -2, -2, -1, -2, -2, -1, -2, -2, -2, -2, -2, -1, -2, -1, -2, -2, -1, -2, -2,
-1, -2, -1, -1, -1, -1, -2, -2, -1, -2, -2, -2, -1, -1, -2, -1, -1, -1, -2, -2,
-2, -2, -1, -1, -1, -2, -2, -2, -1, -1, -1, -1, -2, -1, -2, -2, -2, -2, -1, -2,
-1, -1, -2, -1, -1, -2, -2, -2, -1, -1, -2, -2, -1, -1, -1, -2, -2, -2, -1, -1,
-2, -2, -2, -1, -1, -1, -1, -1, -1, -1, -2, -2, -1, -1, -2, -1, -1, -1, -1, -1,
-1, -1, -1, -2, -2, -1, -1, -2, -1, -1, -1, -1, -2, -2, -1, -1, -1, -1, -2, -2,
-1, -1, 0, -2, -2, -2, -2, -1, -1, -2, -1, -1, -1, -2, -1, -1, -1, -1, -1, -1,
-1, -1, -1, -1, -1, -1, 0, -1, -2, -1, -1, -1, -2, -1, -1, -1, -1, -1, -1, -1,
-2, -1, -2, -1, -2, -2, -2, -1, -1, -1, -1, 0, -1, -2, -1, -1, -1, -2, -1, -1,
-1, 0, -1, -1, -2, -1, -1, -1, -2, -1, -1, -1, -1, -1, -1, -1, 0, 0, -2, 0, -1,
-1, -1, -1, -1, -2, -1, -1, -1, -1, -1, -1, -1, -1, -1, -2, -1, -1, 0, -1, -1,
-1, -1, -1, -1, -1, 0, -1, 0, 0, -1, -1, 0, -1, 0, -1, -1, -1, -2, -2, -1, -1,
-1, -1, -1, -1, 0, 0, -1, -1, -1, 0, -1, -1, -1, -1, 0, -1, 1, -5, };