#define DATA_LENGTH 512
#define DATA AKWF_overtone_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 15, 19, 24, 29, 32, 34, 39,
44, 47, 51, 55, 53, 56, 68, 70, 69, 73, 78, 81, 80, 83, 88, 88, 87, 89, 93, 95,
97, 103, 106, 102, 104, 109, 111, 114, 120, 116, 111, 113, 113, 110, 110, 113,
118, 113, 110, 113, 116, 114, 109, 108, 109, 109, 107, 107, 108, 107, 105, 102,
102, 104, 102, 98, 95, 92, 92, 92, 90, 90, 93, 93, 89, 88, 88, 85, 82, 80, 78,
78, 80, 68, 60, 60, 59, 55, 52, 50, 49, 46, 40, 37, 40, 39, 33, 31, 30, 27, 23,
15, 13, 11, 11, 4, -1, -1, -3, -5, -4, -8, -16, -19, -21, -23, -27, -29, -30,
-32, -38, -44, -44, -41, -43, -45, -48, -53, -55, -52, -55, -58, -56, -54, -53,
-58, -64, -66, -65, -63, -58, -60, -63, -62, -64, -65, -61, -61, -61, -64, -63,
-59, -59, -60, -57, -57, -60, -58, -58, -58, -56, -57, -59, -55, -50, -50, -51,
-52, -49, -48, -48, -45, -42, -43, -44, -45, -45, -42, -39, -40, -39, -38, -34,
-34, -36, -37, -36, -34, -29, -26, -26, -31, -36, -34, -31, -32, -30, -29, -31,
-36, -36, -28, -29, -33, -30, -31, -35, -33, -30, -31, -33, -37, -36, -34, -35,
-35, -35, -36, -39, -39, -39, -39, -40, -41, -45, -48, -43, -41, -45, -40, -38,
-43, -39, -36, -44, -46, -44, -41, -43, -48, -45, -42, -45, -44, -39, -36, -33,
-31, -29, -30, -30, -30, -30, -28, -25, -23, -24, -21, -19, -18, -16, -13, -15,
-13, -6, -4, -3, 0, -1, -1, 8, 8, 0, 6, 11, 11, 15, 18, 17, 24, 31, 26, 26, 30,
34, 38, 44, 46, 50, 56, 55, 52, 55, 58, 61, 64, 65, 64, 65, 68, 69, 71, 70, 73,
75, 76, 75, 76, 79, 82, 83, 84, 81, 80, 86, 86, 79, 84, 90, 93, 92, 89, 86, 85,
86, 87, 86, 85, 87, 86, 82, 78, 78, 81, 79, 77, 77, 74, 70, 69, 65, 59, 57, 54,
49, 49, 51, 49, 46, 41, 34, 30, 29, 25, 23, 26, 27, 28, 26, 25, 26, 26, 22, 16,
19, 22, 20, 21, 20, 16, 17, 19, 17, 12, 10, 13, 15, 18, 13, 10, 10, 15, 20, 18,
11, 6, 10, 14, 13, 16, 16, 9, 5, 6, 6, 6, 4, 0, -1, 2, 2, 0, 0, 0, -1, -3, -4,
-4, -9, -13, -16, -17, -16, -18, -18, -20, -27, -27, -24, -29, -33, -36, -36,
-38, -41, -41, -39, -45, -49, -49, -45, -48, -54, -58, -59, -58, -59, -64, -72,
-75, -73, -73, -75, -77, -80, -83, -87, -91, -92, -97, -97, -95, -100, -100,
-96, -104, -109, -105, -107, -110, -108, -109, -113, -112, -112, -111, -113,
-115, -116, -117, -117, -114, -114, -116, -117, -113, -107, -106, -107, -105,
-106, -105, -100, -97, -96, -94, -92, -91, -91, -89, -84, -77, -73, -74, -74,
-71, -65, -60, -56, -50, -44, -39, -40, -39, -30, -24, -19, -18, -14, -7, -4,
-1, };