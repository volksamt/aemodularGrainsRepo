#define DATA_LENGTH 512
#define DATA AKWF_overtone_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 1, 1, 1, 0, 1, 2, 1, 2, 2, 2,
2, 2, 2, 2, 3, 3, 3, 3, 4, 4, 3, 4, 4, 5, 4, 4, 5, 4, 5, 5, 4, 6, 5, 5, 6, 6, 7,
6, 6, 6, 7, 7, 7, 7, 8, 7, 7, 8, 8, 9, 8, 9, 9, 9, 9, 9, 9, 9, 9, 10, 10, 10,
10, 11, 11, 10, 11, 11, 11, 11, 11, 12, 11, 12, 12, 13, 12, 13, 12, 13, 13, 13,
14, 13, 14, 14, 14, 14, 14, 14, 14, 14, 15, 15, 15, 15, 15, 16, 16, 15, 16, 15,
16, 16, 16, 15, 16, 16, 17, 16, 16, 17, 16, 16, 17, 17, 16, 17, 17, 17, 17, 17,
18, 17, 18, 18, 18, 17, 18, 18, 18, 17, 19, 18, 19, 18, 18, 19, 19, 18, 19, 19,
18, 18, 18, 19, 18, 19, 18, 19, 18, 20, 18, 21, 17, 21, 16, 23, 14, 26, -17,
-126, -116, -119, -118, -118, -118, -116, -118, -116, -118, -116, -118, -115,
-116, -114, -117, -115, -117, -115, -116, -114, -117, -113, -116, -111, -119,
-67, 20, 24, 25, 24, 25, 24, 23, 23, 23, 23, 24, 24, 23, 24, 23, 24, 24, 23, 22,
23, 23, 23, 22, 22, 23, 22, 22, 22, 22, 22, 21, 21, 21, 21, 21, 22, 21, 21, 21,
20, 20, 20, 21, 20, 20, 20, 20, 19, 19, 19, 19, 19, 18, 18, 19, 18, 18, 18, 18,
17, 16, 17, 16, 17, 16, 16, 16, 16, 15, 15, 15, 15, 15, 15, 14, 14, 14, 15, 14,
14, 13, 14, 12, 14, 13, 12, 12, 12, 11, 12, 11, 11, 11, 10, 10, 11, 10, 10, 10,
10, 9, 9, 9, 8, 9, 8, 8, 8, 7, 8, 7, 7, 7, 7, 6, 7, 7, 6, 6, 5, 5, 5, 5, 5, 5,
5, 5, 4, 4, 4, 3, 4, 3, 3, 3, 2, 2, 2, 2, 1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 0, 0,
-1, 0, -1, 0, -1, -1, -1, -1, -1, -2, -1, -2, -2, -2, -2, -3, -3, -3, -3, -2,
-3, -4, -3, -4, -3, -3, -4, -4, -4, -4, -4, -5, -4, -4, -4, -5, -5, -6, -5, -5,
-6, -5, -5, -6, -5, -5, -5, -6, -6, -5, -6, -6, -6, -7, -7, -6, -7, -7, -7, -6,
-7, -7, -7, -7, -7, -7, -8, -6, -7, -7, -8, -7, -7, -7, -7, -8, -8, -8, -7, -8,
-8, -7, -7, -8, -7, -7, -8, -8, -7, -7, -7, -7, -7, -7, -8, -7, -7, -7, -7, -7,
-7, -7, -6, -6, -7, -7, -7, -6, -7, -6, -7, -6, -7, -6, -7, -6, -7, -6, -6, -6,
-5, -6, -5, -5, -5, -5, -6, -6, -5, -4, -5, -4, -4, -5, -4, -5, -4, -4, -5, -4,
-4, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -2, -3, -2, -2, -2, -2, -2, -1, -1,
-1, -1, -1, -1, -1, -1, -1, 0, -1, 0, };