#define DATA_LENGTH 512
#define DATA AKWF_c604_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {59, 122, 117, 121, 118, 120, 119, 119,
119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119,
119, 119, 119, 120, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 119, 118, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 118, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 119, 120, 119,
119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 119, 119, 120, 120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 120,
120, 118, 118, 119, 119, 119, 119, 118, 118, 119, 120, 119, 119, 119, 118, 120,
119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119,
119, 119, 119, 119, 120, 119, 120, 119, 120, 118, 119, 119, 119, 120, 119, 119,
119, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 120, 120, 119, 119,
119, 119, 118, 119, 120, 119, 119, 119, 119, 120, 119, 118, 119, 120, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119,
120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119,
119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
120, 120, 119, 120, 119, 119, 120, 119, 119, 119, 119, 120, 119, 119, 118, 119,
119, 119, 119, 119, 120, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 120, 120, 118, 119, 119, 120, 119, 119, 119, 119, 120, 119, 119, 119,
119, 119, 118, 119, 119, 119, 120, 119, 120, 119, 119, 120, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 120, 119, 120, 119, 120, 119, 119, 118, 119, 119,
119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 118, 119, 119, 119, 119, 119, 119, 120, 120, 118, 119, 119, 119, 118,
119, 118, 119, 119, 118, 119, 119, 119, 118, 120, 118, 119, 119, 120, 118, 120,
118, 119, 118, 120, 118, 120, 118, 119, 118, 119, 119, 119, 119, 118, 120, 117,
121, 116, 122, 115, 124, 113, 127, 107, 127, 38, -128, -111, -124, -115, -121,
-117, -120, -119, -118, -120, -119, -120, -119, -120, -118, -120, -118, -120,
-118, -121, -118, -120, -118, -120, -118, -120, -118, -120, -119, -119, -119,
-120, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-120, -119, -120, -118, -119, -118, -120, -118, -121, -117, -121, -117, -122,
-115, -123, -114, -127, -102, };