#define DATA_LENGTH 512
#define DATA AKWF_c604_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {105, 124, 116, 122, 116, 122, 117,
121, 117, 121, 117, 121, 117, 121, 119, 119, 119, 119, 119, 120, 120, 119, 118,
119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 120, 119,
119, 118, 119, 120, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 120,
119, 119, 118, 119, 120, 120, 118, 119, 120, 118, 119, 119, 118, 119, 119, 120,
119, 119, 120, 119, 118, 119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119,
120, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 118, 119,
119, 119, 119, 119, 120, 119, 119, 119, 118, 119, 120, 118, 120, 119, 119, 119,
119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120,
118, 120, 119, 119, 119, 118, 119, 120, 118, 119, 120, 119, 119, 119, 119, 119,
119, 118, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119,
119, 118, 118, 119, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 120, 120, 119, 118, 119, 118, 119, 120, 119, 119, 119, 119,
120, 119, 119, 119, 118, 119, 119, 119, 119, 118, 120, 119, 119, 119, 120, 119,
119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 120, 119, 118, 119, 119, 120, 119, 119, 119, 120, 119, 119, 119, 119,
119, 119, 118, 118, 118, 120, 118, 119, 120, 120, 118, 119, 119, 119, 119, 119,
120, 119, 119, 120, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 118, 119,
119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 119, 119, 120, 119, 119, 119, 118, 120, 119, 119, 119, 118, 119, 118,
119, 120, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
119, 119, 119, 118, 120, 119, 120, 119, 120, 119, 120, 119, 119, 119, 119, 120,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 120, 118, 119, 119, 120, 119, 120, 120, 118, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 119, 120, 119, 120,
119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 119, 118, 119, 118, 118, 119,
119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 120, 119, 118, 119, 119, 120, 119, 120, 119, 119, 118, 120,
119, 119, 120, 119, 119, 119, 119, 119, 120, 118, 119, 119, 120, 119, 120, 119,
120, 118, 119, 118, 120, 119, 119, 119, 119, 120, 118, 120, 117, 122, 115, 124,
113, 127, -1, -127, -112, -123, -116, -120, -119, -119, -120, -118, -121, -117,
-121, -117, -122, -117, -122, -116, -122, -116, -122, -114, -6, };