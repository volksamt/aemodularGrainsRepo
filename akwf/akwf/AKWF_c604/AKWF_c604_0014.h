#define DATA_LENGTH 512
#define DATA AKWF_c604_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 1, 1, 2, 3, 4, 5, 6, 7, 7, 9, 9,
10, 12, 12, 14, 15, 15, 16, 17, 17, 19, 19, 21, 23, 24, 24, 25, 26, 27, 27, 28,
29, 31, 31, 32, 34, 35, 35, 36, 37, 38, 38, 40, 41, 43, 44, 44, 45, 46, 46, 48,
48, 49, 51, 52, 53, 54, 55, 55, 56, 56, 57, 59, 60, 61, 62, 63, 64, 64, 65, 67,
66, 68, 68, 71, 71, 72, 74, 75, 75, 75, 77, 78, 78, 79, 80, 81, 81, 83, 84, 86,
86, 88, 87, 89, 90, 91, 93, 93, 95, 95, 95, 96, 98, 98, 100, 100, 101, 102, 103,
104, 105, 107, 107, 108, 110, 109, 111, 113, 113, 115, 115, 115, 117, 118, 118,
119, 118, 118, 116, 115, 115, 115, 114, 113, 112, 109, 110, 107, 107, 106, 106,
104, 103, 102, 101, 100, 99, 98, 98, 96, 96, 95, 95, 94, 93, 91, 90, 88, 88, 87,
86, 86, 85, 84, 82, 81, 80, 79, 79, 78, 77, 76, 76, 74, 73, 73, 72, 70, 69, 68,
67, 66, 65, 65, 65, 63, 62, 61, 60, 59, 58, 56, 56, 55, 55, 54, 53, 51, 51, 49,
48, 47, 47, 45, 45, 44, 44, 42, 42, 40, 38, 38, 37, 36, 36, 35, 35, 34, 31, 30,
29, 28, 27, 27, 25, 25, 25, 24, 23, 21, 20, 18, 17, 16, 16, 16, 14, 15, 13, 13,
11, 9, 8, 7, 7, 5, 5, 4, 4, 3, 1, 0, 0, 0, -1, 0, -2, -4, -4, -6, -7, -7, -9,
-8, -10, -11, -13, -14, -15, -16, -16, -17, -17, -19, -19, -20, -21, -22, -22,
-23, -25, -26, -27, -28, -29, -29, -30, -32, -33, -34, -35, -35, -37, -38, -39,
-39, -41, -42, -41, -42, -43, -43, -46, -47, -48, -48, -50, -51, -51, -52, -54,
-55, -56, -56, -57, -58, -60, -61, -61, -61, -62, -63, -64, -65, -67, -68, -69,
-69, -70, -72, -72, -73, -75, -76, -77, -78, -78, -78, -80, -81, -82, -82, -83,
-84, -85, -87, -88, -89, -89, -90, -91, -92, -94, -94, -96, -96, -98, -98, -99,
-100, -101, -101, -101, -103, -104, -104, -106, -108, -109, -110, -110, -111,
-112, -113, -114, -116, -116, -117, -119, -119, -119, -119, -119, -119, -118,
-117, -116, -116, -115, -113, -112, -111, -110, -109, -108, -108, -106, -105,
-104, -103, -102, -102, -100, -100, -98, -99, -97, -97, -95, -94, -94, -91, -92,
-90, -89, -88, -88, -87, -85, -84, -83, -83, -81, -81, -80, -79, -78, -77, -77,
-76, -74, -73, -73, -71, -69, -69, -68, -68, -67, -66, -63, -63, -62, -61, -61,
-59, -59, -58, -57, -57, -55, -55, -54, -53, -51, -49, -50, -49, -48, -46, -46,
-43, -43, -43, -42, -41, -41, -39, -38, -37, -36, -35, -35, -33, -33, -31, -30,
-29, -28, -28, -27, -26, -23, -23, -21, -21, -22, -21, -19, -18, -18, -17, -16,
-15, -15, -14, -12, -10, -11, -9, -7, -8, -6, -6, -4, -3, -3, -1, -1, 0, };