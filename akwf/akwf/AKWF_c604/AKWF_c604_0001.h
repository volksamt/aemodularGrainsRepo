#define DATA_LENGTH 512
#define DATA AKWF_c604_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {97, 103, 99, 103, 99, 103, 99, 103,
99, 103, 100, 101, 99, 102, 100, 102, 100, 102, 100, 101, 100, 102, 101, 101,
100, 101, 101, 101, 101, 101, 101, 100, 101, 100, 102, 101, 101, 100, 101, 101,
100, 100, 101, 101, 101, 100, 100, 101, 100, 101, 101, 101, 101, 101, 100, 101,
101, 101, 101, 101, 101, 101, 100, 101, 101, 100, 100, 100, 101, 100, 101, 100,
101, 101, 101, 100, 101, 101, 101, 100, 100, 101, 101, 101, 101, 100, 100, 101,
101, 101, 100, 101, 101, 100, 101, 100, 102, 101, 100, 100, 101, 101, 100, 100,
100, 100, 101, 101, 100, 101, 101, 101, 101, 101, 101, 101, 101, 101, 100, 100,
101, 101, 102, 101, 101, 101, 101, 100, 101, 101, 101, 101, 100, 101, 100, 102,
101, 101, 101, 101, 101, 100, 101, 101, 100, 100, 101, 101, 101, 101, 101, 100,
101, 101, 101, 101, 101, 101, 100, 101, 101, 102, 101, 102, 101, 101, 101, 100,
101, 101, 102, 100, 100, 101, 101, 101, 101, 101, 101, 101, 100, 101, 101, 101,
101, 102, 101, 101, 101, 101, 100, 100, 101, 100, 101, 101, 101, 101, 100, 101,
102, 101, 101, 101, 100, 101, 101, 101, 101, 101, 101, 101, 101, 101, 101, 101,
101, 101, 101, 101, 101, 101, 101, 101, 101, 101, 100, 101, 101, 101, 100, 101,
101, 101, 101, 101, 101, 101, 101, 102, 101, 101, 101, 101, 102, 101, 100, 101,
101, 101, 101, 101, 100, 102, 100, 101, 101, 101, 101, 101, 102, 101, 101, 100,
101, 100, 100, 101, 101, 101, 100, 101, 101, 101, 100, 100, 100, 100, 102, 101,
101, 101, 102, 101, 101, 100, 101, 101, 101, 101, 100, 101, 101, 100, 101, 101,
101, 101, 101, 100, 101, 101, 101, 100, 101, 102, 102, 101, 101, 101, 101, 101,
100, 101, 101, 100, 101, 101, 101, 100, 101, 101, 101, 101, 100, 101, 102, 101,
101, 100, 101, 101, 101, 100, 101, 100, 101, 100, 101, 100, 102, 100, 102, 101,
101, 101, 102, 100, 101, 101, 100, 100, 101, 101, 100, 102, 99, 102, 99, 103,
98, 104, 96, 107, 95, 109, 90, 119, 46, -119, -95, -106, -100, -103, -102, -102,
-103, -101, -103, -101, -103, -101, -103, -101, -104, -101, -103, -100, -103,
-101, -103, -101, -102, -101, -102, -102, -103, -102, -102, -103, -102, -102,
-101, -103, -101, -102, -102, -103, -102, -102, -102, -102, -101, -102, -102,
-102, -102, -102, -102, -102, -102, -102, -102, -102, -102, -102, -102, -101,
-103, -102, -102, -101, -102, -102, -102, -103, -102, -103, -102, -101, -102,
-102, -103, -102, -103, -102, -102, -102, -101, -102, -102, -102, -102, -102,
-102, -102, -103, -102, -102, -102, -103, -102, -101, -102, -102, -102, -102,
-102, -102, -102, -102, -102, -102, -102, -103, -102, -102, -102, -103, -102,
-103, -102, -103, -102, -102, -102, -101, -103, -101, -102, -101, -102, -102,
-103, -101, -103, -101, -103, -101, -103, -102, -102, -102, -101, -103, -102,
-103, -101, -105, -97, -113, -50, };