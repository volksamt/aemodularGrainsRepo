#define DATA_LENGTH 512
#define DATA AKWF_c604_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 1, 2, 1, 2, 2, 3, 4, 4, 5, 5, 6,
6, 8, 9, 10, 12, 12, 13, 15, 16, 17, 18, 19, 20, 22, 22, 23, 23, 25, 25, 26, 28,
28, 29, 31, 31, 32, 33, 34, 35, 35, 36, 37, 38, 39, 40, 41, 42, 42, 43, 44, 46,
46, 47, 49, 49, 51, 52, 52, 54, 56, 55, 58, 58, 59, 60, 60, 61, 61, 63, 64, 65,
65, 67, 67, 69, 70, 70, 71, 72, 73, 74, 76, 75, 76, 78, 78, 79, 80, 81, 82, 82,
84, 84, 86, 86, 87, 88, 90, 91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 100, 102,
102, 103, 104, 105, 105, 107, 108, 109, 110, 111, 112, 112, 113, 113, 115, 115,
115, 115, 115, 115, 115, 114, 114, 112, 112, 111, 110, 109, 108, 107, 106, 105,
104, 103, 102, 101, 100, 100, 100, 98, 98, 96, 94, 93, 93, 92, 90, 90, 88, 87,
87, 86, 84, 83, 82, 82, 81, 80, 80, 79, 78, 77, 77, 74, 74, 73, 72, 71, 70, 68,
69, 67, 67, 65, 64, 63, 62, 63, 61, 60, 60, 59, 57, 57, 56, 55, 54, 53, 52, 50,
49, 48, 47, 46, 45, 44, 44, 42, 42, 40, 40, 39, 38, 38, 36, 36, 35, 33, 33, 32,
31, 30, 29, 28, 27, 26, 25, 24, 24, 23, 22, 21, 20, 19, 18, 16, 16, 15, 14, 13,
11, 10, 10, 8, 7, 7, 5, 5, 3, 4, 3, 2, 2, 2, 1, 1, 0, -1, -1, -3, -5, -5, -6,
-7, -7, -9, -9, -10, -11, -12, -13, -14, -15, -16, -16, -18, -19, -19, -21, -21,
-22, -24, -25, -26, -27, -27, -29, -30, -31, -32, -33, -34, -33, -35, -36, -37,
-37, -39, -39, -40, -42, -43, -44, -45, -46, -46, -47, -49, -50, -51, -52, -52,
-54, -55, -55, -56, -57, -58, -60, -59, -60, -62, -62, -63, -65, -65, -66, -68,
-68, -69, -70, -71, -72, -73, -75, -76, -77, -78, -79, -80, -80, -81, -81, -82,
-83, -83, -83, -83, -84, -86, -86, -87, -89, -90, -91, -93, -94, -94, -96, -97,
-97, -99, -100, -100, -101, -102, -102, -103, -104, -104, -104, -106, -107,
-108, -110, -111, -113, -114, -116, -117, -118, -119, -119, -120, -118, -118,
-117, -116, -116, -113, -112, -111, -110, -108, -107, -106, -105, -104, -104,
-102, -102, -102, -101, -101, -99, -98, -98, -96, -96, -95, -93, -92, -90, -89,
-88, -87, -86, -86, -84, -84, -83, -82, -81, -80, -80, -79, -78, -78, -77, -76,
-75, -74, -74, -72, -72, -70, -70, -68, -67, -67, -66, -65, -64, -62, -62, -60,
-59, -58, -57, -56, -55, -54, -53, -51, -51, -50, -48, -48, -47, -46, -45, -44,
-44, -43, -41, -41, -40, -39, -39, -38, -37, -36, -35, -33, -33, -32, -30, -29,
-29, -27, -25, -25, -24, -23, -22, -21, -20, -19, -19, -17, -17, -16, -15, -14,
-14, -12, -12, -11, -9, -9, -8, -6, -5, -5, -3, -2, -1, -1, 0, };