#define DATA_LENGTH 512
#define DATA AKWF_c604_0026

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 1, 2, 4, 4, 4, 5, 6, 7, 8, 9, 10,
11, 12, 13, 14, 15, 16, 17, 18, 19, 19, 20, 22, 23, 24, 24, 25, 26, 27, 28, 28,
30, 30, 31, 33, 33, 34, 36, 36, 37, 39, 39, 41, 41, 42, 43, 43, 44, 47, 47, 47,
48, 50, 50, 51, 53, 53, 53, 56, 56, 58, 58, 59, 59, 60, 61, 63, 63, 65, 65, 66,
66, 68, 69, 70, 71, 71, 73, 73, 74, 75, 76, 78, 79, 79, 80, 81, 82, 83, 84, 85,
86, 87, 87, 89, 90, 90, 91, 93, 94, 94, 96, 97, 98, 98, 99, 101, 101, 101, 102,
103, 104, 105, 107, 107, 108, 109, 111, 111, 112, 113, 114, 115, 115, 116, 117,
118, 119, 118, 117, 116, 116, 115, 114, 113, 112, 111, 109, 108, 108, 107, 106,
105, 104, 104, 103, 102, 100, 99, 98, 98, 97, 96, 95, 94, 93, 91, 91, 90, 89,
88, 87, 86, 86, 84, 84, 83, 81, 81, 80, 79, 78, 77, 77, 75, 74, 74, 72, 72, 71,
70, 69, 68, 67, 66, 65, 64, 63, 62, 61, 61, 60, 59, 57, 56, 56, 54, 54, 54, 52,
51, 51, 49, 48, 47, 46, 46, 45, 44, 43, 42, 41, 39, 38, 38, 37, 37, 34, 35, 33,
32, 31, 30, 30, 29, 28, 26, 25, 25, 24, 23, 22, 21, 21, 19, 18, 17, 16, 16, 15,
14, 13, 12, 11, 10, 9, 8, 8, 6, 5, 4, 4, 3, 2, 1, -1, -1, -2, -3, -4, -5, -5,
-7, -7, -8, -9, -11, -12, -12, -13, -15, -15, -15, -18, -18, -18, -19, -22, -22,
-23, -24, -25, -26, -26, -27, -28, -29, -30, -31, -31, -33, -34, -35, -36, -36,
-38, -39, -39, -41, -42, -42, -43, -44, -45, -46, -47, -48, -49, -50, -50, -52,
-53, -54, -54, -56, -57, -57, -58, -59, -59, -61, -62, -62, -63, -65, -66, -67,
-67, -69, -70, -71, -71, -72, -73, -75, -75, -76, -76, -78, -78, -80, -80, -81,
-82, -83, -85, -85, -86, -88, -88, -88, -90, -90, -91, -92, -94, -94, -96, -96,
-97, -98, -99, -100, -101, -101, -102, -104, -104, -106, -107, -108, -108, -109,
-110, -111, -113, -113, -114, -115, -116, -117, -118, -119, -119, -118, -118,
-117, -114, -114, -113, -113, -111, -110, -109, -109, -108, -107, -106, -105,
-104, -102, -102, -102, -100, -100, -98, -98, -97, -95, -94, -94, -93, -92, -90,
-90, -89, -89, -87, -87, -86, -85, -84, -83, -82, -81, -79, -79, -78, -77, -77,
-76, -74, -73, -73, -71, -70, -70, -69, -68, -67, -66, -64, -64, -63, -63, -62,
-60, -60, -58, -57, -57, -55, -54, -54, -53, -52, -51, -50, -49, -48, -47, -46,
-45, -44, -44, -42, -41, -41, -40, -39, -38, -37, -36, -36, -33, -33, -32, -32,
-30, -29, -29, -27, -26, -25, -25, -25, -22, -22, -21, -21, -18, -18, -17, -17,
-16, -14, -13, -13, -12, -11, -11, -8, -7, -7, -6, -6, -4, -3, -2, -2, -1, };