#define DATA_LENGTH 512
#define DATA AKWF_c604_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 103, 114, 79, 86, 102, 95, 83, 95,
97, 89, 89, 98, 92, 88, 94, 96, 90, 92, 96, 92, 89, 94, 95, 90, 91, 95, 93, 90,
93, 94, 90, 91, 94, 91, 91, 93, 93, 90, 92, 95, 92, 91, 93, 94, 91, 92, 94, 93,
91, 93, 93, 91, 92, 94, 93, 91, 94, 92, 91, 92, 95, 92, 92, 93, 93, 91, 93, 94,
92, 92, 93, 93, 92, 92, 93, 92, 93, 94, 93, 92, 93, 93, 92, 91, 94, 93, 91, 93,
94, 92, 91, 93, 93, 92, 92, 93, 92, 92, 94, 93, 91, 93, 93, 92, 92, 92, 93, 91,
93, 93, 91, 93, 92, 92, 92, 93, 93, 92, 93, 93, 92, 92, 93, 93, 92, 92, 93, 92,
92, 93, 93, 92, 92, 93, 93, 92, 93, 93, 93, 93, 93, 93, 93, 93, 92, 92, 93, 94,
92, 91, 92, 93, 92, 93, 93, 92, 92, 92, 93, 92, 92, 93, 92, 92, 93, 93, 93, 92,
93, 92, 92, 94, 93, 92, 92, 93, 92, 92, 93, 92, 92, 93, 93, 92, 92, 92, 93, 92,
92, 93, 92, 92, 93, 92, 92, 93, 93, 92, 92, 92, 93, 93, 92, 93, 93, 92, 92, 92,
92, 93, 93, 92, 93, 93, 93, 92, 93, 93, 93, 92, 92, 93, 93, 92, 92, 92, 92, 93,
93, 92, 92, 93, 92, 93, 93, 93, 92, 92, 92, 93, 92, 93, 93, 92, 92, 92, 93, 93,
92, 93, 92, 93, 92, 92, 93, 92, 93, 92, 92, 92, 93, 93, 93, 93, 93, 92, 92, 93,
92, 93, 93, 93, 92, 93, 93, 93, 93, 93, 92, 92, 92, 93, 92, 93, 92, 93, 92, 93,
92, 92, 93, 93, 92, 92, 92, 92, 92, 92, 92, 93, 93, 92, 92, 93, 92, 92, 93, 92,
93, 92, 93, 93, 93, 92, 92, 92, 93, 93, 92, 93, 92, 93, 93, 93, 92, 92, 93, 93,
92, 93, 93, 93, 93, 93, 92, 92, 93, 94, 91, 92, 93, 93, 92, 93, 93, 91, 93, 93,
93, 92, 93, 93, 92, 93, 93, 93, 92, 93, 93, 93, 92, 94, 92, 92, 93, 93, 92, 92,
93, 93, 91, 93, 92, 93, 93, 94, 92, 91, 92, 91, 91, 91, 92, 92, 90, 92, 92, 91,
91, 92, 90, 91, 93, 93, 90, 91, 92, 91, 91, 92, 92, 90, 91, 93, 91, 91, 92, 91,
91, 92, 92, 91, 91, 93, 91, 91, 92, 93, 90, 91, 93, 91, 90, 91, 93, 90, 91, 93,
91, 90, 92, 93, 91, 91, 93, 92, 89, 93, 93, 90, 91, 94, 91, 89, 92, 93, 89, 91,
93, 92, 89, 93, 93, 89, 91, 95, 90, 89, 94, 94, 88, 90, 95, 91, 87, 95, 95, 86,
90, 98, 89, 84, 98, 98, 78, 89, 119, 74, -42, -113, -102, -80, -92, -99, -91,
-89, -96, -94, -90, -93, -94, -92, -92, -93, -92, -93, -91, -91, -93, -94, -90,
-92, -95, -93, -86, -98, -97, -85, -86, -120, -77, };