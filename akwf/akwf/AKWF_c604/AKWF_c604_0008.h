#define DATA_LENGTH 512
#define DATA AKWF_c604_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 40, 67, 88, 104, 112, 116, 116,
115, 111, 106, 102, 97, 93, 90, 88, 87, 87, 86, 88, 88, 89, 89, 90, 90, 90, 91,
91, 92, 91, 91, 92, 91, 90, 91, 91, 90, 90, 90, 90, 90, 90, 90, 89, 90, 90, 90,
91, 91, 92, 91, 90, 91, 91, 91, 91, 91, 90, 89, 90, 90, 90, 89, 89, 90, 90, 89,
90, 89, 91, 91, 92, 91, 90, 91, 91, 91, 91, 91, 89, 89, 90, 90, 91, 89, 90, 90,
90, 90, 89, 90, 90, 90, 90, 91, 90, 90, 90, 90, 90, 90, 90, 90, 90, 90, 91, 89,
89, 89, 90, 90, 89, 90, 90, 90, 90, 90, 90, 89, 89, 90, 90, 90, 89, 90, 90, 91,
89, 90, 90, 89, 90, 89, 90, 90, 90, 90, 90, 90, 90, 89, 90, 89, 90, 90, 90, 90,
90, 90, 90, 90, 90, 90, 90, 90, 90, 91, 90, 89, 90, 90, 90, 91, 90, 90, 89, 90,
90, 90, 91, 91, 90, 90, 90, 90, 90, 90, 90, 90, 91, 90, 90, 89, 91, 90, 90, 91,
91, 90, 90, 90, 90, 90, 90, 89, 89, 90, 89, 90, 89, 90, 90, 90, 90, 89, 90, 90,
89, 90, 90, 90, 89, 90, 89, 91, 89, 89, 90, 90, 90, 90, 89, 89, 90, 90, 90, 90,
90, 91, 90, 90, 90, 90, 90, 90, 90, 90, 90, 90, 90, 89, 91, 90, 91, 91, 90, 90,
91, 90, 90, 90, 90, 89, 90, 90, 90, 89, 90, 90, 90, 90, 90, 90, 90, 91, 90, 90,
89, 90, 90, 89, 89, 90, 90, 89, 90, 90, 89, 90, 91, 90, 90, 90, 90, 89, 90, 90,
90, 90, 90, 89, 90, 91, 90, 90, 90, 90, 90, 90, 89, 90, 90, 90, 89, 90, 89, 90,
89, 90, 91, 90, 90, 90, 91, 90, 90, 90, 89, 90, 90, 91, 90, 90, 90, 90, 89, 90,
90, 90, 90, 89, 90, 90, 90, 90, 90, 90, 90, 90, 90, 89, 90, 90, 90, 90, 90, 90,
90, 90, 90, 90, 91, 90, 90, 90, 91, 91, 89, 90, 90, 89, 90, 91, 90, 90, 90, 90,
90, 90, 87, 73, 50, 21, -8, -35, -61, -82, -97, -109, -116, -119, -119, -116,
-112, -108, -104, -101, -96, -93, -91, -89, -88, -88, -88, -88, -89, -89, -90,
-90, -91, -90, -92, -93, -92, -92, -92, -92, -92, -92, -92, -92, -92, -92, -92,
-90, -91, -92, -91, -91, -91, -91, -92, -91, -91, -91, -91, -91, -92, -91, -92,
-92, -92, -92, -92, -93, -93, -92, -92, -91, -90, -91, -91, -91, -91, -91, -91,
-91, -91, -91, -92, -93, -91, -91, -93, -92, -92, -92, -92, -93, -92, -91, -92,
-92, -91, -92, -91, -91, -91, -91, -92, -92, -91, -91, -91, -91, -91, -91, -91,
-91, -92, -91, -91, -91, -91, -91, -91, -91, -91, -91, -91, -90, -91, -91, -91,
-91, -91, -90, -91, -91, -91, -92, -91, -91, -91, -90, -90, -91, -91, -87, -69,
-45, -16, };