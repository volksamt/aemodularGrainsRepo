#define DATA_LENGTH 512
#define DATA AKWF_c604_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {81, 123, 117, 122, 117, 121, 119, 119,
118, 119, 119, 119, 118, 119, 118, 119, 120, 119, 119, 119, 120, 120, 119, 119,
119, 119, 119, 120, 119, 119, 120, 119, 120, 119, 119, 119, 120, 118, 118, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 120, 120, 120, 119, 119,
118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 118, 119, 120, 119, 119, 119, 118, 119, 119, 120, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 119, 118, 119, 119, 120, 119, 119, 120,
119, 119, 119, 119, 118, 120, 119, 119, 120, 119, 119, 118, 119, 120, 119, 119,
119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120,
119, 118, 118, 118, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 118,
119, 119, 118, 119, 120, 119, 119, 119, 119, 119, 118, 119, 119, 119, 120, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119,
119, 119, 119, 119, 118, 119, 120, 119, 119, 120, 119, 118, 119, 119, 119, 119,
119, 119, 118, 119, 119, 119, 120, 118, 119, 118, 120, 119, 119, 119, 118, 119,
119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120,
118, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 120, 119, 119, 119, 119,
119, 118, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 120,
118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 118, 118, 119, 119, 119, 120, 119, 119, 120, 118,
119, 119, 118, 118, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 120, 120, 119, 119, 119, 118, 119, 119, 120, 118, 119, 120, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 118, 119, 119, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 119, 118, 119, 119, 118, 120, 120, 119,
118, 119, 119, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 120, 119, 119,
119, 119, 120, 120, 119, 119, 119, 118, 119, 119, 119, 119, 119, 120, 118, 119,
119, 119, 119, 119, 119, 118, 119, 118, 119, 120, 118, 119, 119, 119, 119, 120,
119, 119, 119, 120, 119, 120, 119, 120, 119, 120, 120, 119, 120, 118, 120, 118,
120, 118, 122, 115, 122, -12, -128, -113, -122, -117, -121, -118, -120, -119,
-118, -119, -119, -119, -118, -120, -118, -119, -119, -120, -119, -120, -119,
-120, -119, -119, -119, -118, -120, -118, -120, -117, -121, -117, -124, -77, };