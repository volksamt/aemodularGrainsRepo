#define DATA_LENGTH 512
#define DATA AKWF_c604_0032

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 0, 0, 1, -1, -1, 0, -1, 0, 1, 0,
0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 3, 2, 0, 1, 0, 1,
0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 1, 0, -1, 0, 0, -1,
1, 4, 0, 0, 1, 0, -1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 5, 1, 0, 0, 0, -1, 0, 0, 2, 5,
-2, 0, 5, 1, 2, 8, 26, 10, -5, 3, -2, 1, -1, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1,
0, 0, 1, -1, 0, -1, 1, -1, 1, -1, 0, -1, 1, -1, 2, 8, -1, 0, -1, 1, 0, 0, 0, 0,
-1, 0, 0, 1, 0, 0, 8, 2, -1, 1, 0, 1, 0, 0, 3, 8, -2, 0, 8, 2, 1, 19, 45, 13,
-6, 2, -2, 1, -1, 1, -1, 0, 0, 1, 0, 0, 0, -2, 5, 7, -2, 1, -1, 1, 1, -1, 9, 3,
-1, -2, 11, 15, 1, 21, 42, 10, -4, 3, -1, 2, -1, 0, 6, 9, -3, 2, 1, 12, 1, 26,
70, 13, -9, 7, 2, 13, 6, 48, 61, 24, 14, 61, 82, 60, 89, 115, 78, -90, -128,
-113, -124, -115, -122, -116, -123, -116, -120, -117, -121, -117, -121, -118,
-120, -118, -120, -119, -119, -119, -118, -119, -119, -120, -118, -119, -118,
-120, -118, -120, -119, -119, -119, -120, -118, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -120, -119, -119, -120, -119, -119,
-118, -119, -119, -119, -119, -120, -119, -120, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -120, -119, -119,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -120, -118, -119, -119, -118, -119, -119, -118, -119,
-118, -119, -119, -119, -119, -119, -119, -120, -120, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -120, -119, -119, -118, -119, -119, -119,
-119, -119, -118, -119, -118, -120, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -118, -120, -119, -118, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -118, -119, -119, -118, -119, -119, -119, -118, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -120, -119, -120, -119, -119, -120, -118, -119, -119, -119,
-119, -119, -120, -118, -119, -119, -119, -120, -120, -119, -119, -119, -119,
-120, -119, -120, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -118, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -120, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -118, -120, -120, -120, -118, -119, -118,
-119, -119, -120, -117, -121, -118, -120, -116, -122, -116, -123, -77, };