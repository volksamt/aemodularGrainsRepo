#define DATA_LENGTH 512
#define DATA AKWF_c604_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {24, 52, 74, 92, 105, 113, 117, 119,
117, 115, 111, 107, 103, 98, 95, 92, 91, 89, 88, 89, 88, 90, 90, 91, 91, 91, 92,
93, 93, 93, 93, 92, 94, 93, 93, 92, 93, 93, 93, 93, 92, 93, 92, 93, 91, 92, 92,
92, 91, 92, 92, 92, 93, 93, 93, 93, 92, 93, 93, 93, 94, 93, 93, 93, 92, 92, 92,
92, 91, 91, 92, 92, 92, 91, 91, 92, 93, 93, 93, 93, 93, 93, 93, 93, 93, 93, 93,
93, 91, 92, 92, 92, 92, 91, 92, 91, 92, 92, 91, 91, 91, 92, 91, 92, 92, 91, 92,
92, 93, 92, 93, 92, 92, 92, 92, 92, 91, 92, 92, 92, 92, 92, 93, 91, 91, 92, 92,
92, 92, 92, 92, 91, 92, 92, 91, 91, 91, 93, 92, 91, 92, 92, 92, 92, 93, 92, 93,
92, 91, 91, 92, 92, 92, 91, 91, 92, 92, 91, 91, 91, 92, 92, 92, 92, 92, 92, 92,
92, 91, 91, 91, 92, 91, 92, 93, 92, 92, 92, 92, 92, 92, 92, 92, 92, 92, 91, 92,
92, 92, 92, 91, 92, 92, 92, 92, 92, 92, 92, 93, 92, 91, 91, 92, 92, 92, 92, 92,
92, 91, 92, 92, 92, 92, 91, 92, 92, 92, 92, 92, 91, 92, 91, 92, 91, 92, 92, 92,
92, 92, 91, 92, 92, 92, 92, 92, 91, 92, 93, 92, 92, 93, 91, 92, 92, 92, 91, 91,
92, 92, 92, 92, 92, 92, 92, 91, 92, 91, 92, 92, 92, 92, 91, 92, 92, 92, 92, 91,
92, 92, 92, 91, 92, 92, 92, 92, 92, 92, 92, 92, 92, 91, 93, 92, 91, 92, 92, 92,
93, 92, 92, 92, 92, 92, 92, 92, 92, 92, 92, 92, 92, 92, 91, 92, 92, 91, 91, 91,
92, 92, 92, 92, 92, 92, 91, 92, 92, 91, 92, 92, 92, 92, 91, 92, 91, 92, 92, 92,
91, 91, 92, 92, 92, 91, 92, 93, 93, 92, 93, 91, 91, 92, 92, 92, 92, 91, 92, 92,
92, 92, 92, 92, 92, 92, 92, 92, 92, 91, 91, 79, 56, 27, -2, -29, -55, -77, -94,
-105, -113, -118, -119, -118, -115, -112, -107, -102, -98, -95, -93, -91, -90,
-88, -88, -88, -89, -90, -90, -90, -90, -92, -92, -93, -92, -94, -92, -93, -93,
-93, -93, -93, -92, -93, -93, -92, -92, -91, -92, -92, -92, -92, -92, -92, -92,
-92, -91, -92, -92, -93, -93, -93, -92, -92, -93, -94, -93, -93, -93, -94, -93,
-92, -92, -92, -92, -92, -92, -91, -91, -92, -92, -91, -92, -94, -93, -93, -93,
-93, -93, -93, -93, -93, -94, -93, -93, -93, -91, -92, -92, -92, -92, -92, -91,
-92, -92, -92, -91, -92, -92, -92, -92, -92, -92, -92, -92, -92, -91, -92, -91,
-92, -92, -92, -92, -92, -92, -92, -92, -91, -92, -92, -91, -92, -92, -92, -93,
-91, -93, -92, -92, -91, -91, -91, -91, -91, -92, -91, -92, -90, -91, -91, -91,
-89, -74, -52, -11, };