#define DATA_LENGTH 512
#define DATA AKWF_c604_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 115, 122, 116, 122, 116,
121, 117, 121, 117, 120, 118, 120, 118, 120, 119, 120, 119, 120, 118, 119, 119,
119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 119,
118, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 120, 119, 119,
119, 119, 119, 119, 120, 118, 119, 119, 119, 119, 120, 120, 119, 118, 118, 119,
119, 120, 119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 118, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 118, 120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119,
119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120, 119, 120, 119, 119, 118,
119, 119, 120, 119, 119, 118, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119,
118, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 120, 118, 120, 120,
119, 119, 120, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 118, 119, 119,
119, 119, 120, 119, 119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119,
118, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 119, 119,
119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 120, 120,
118, 120, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 118, 120, 118,
118, 119, 120, 120, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119, 120, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119,
118, 119, 119, 120, 119, 119, 119, 119, 119, 120, 119, 119, 119, 118, 120, 119,
119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119,
119, 119, 120, 118, 119, 119, 119, 119, 118, 119, 118, 119, 119, 120, 118, 119,
119, 119, 119, 119, 119, 120, 120, 120, 119, 119, 119, 119, 119, 119, 119, 118,
120, 119, 118, 118, 118, 118, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119,
118, 120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 119, 119, 118, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 120, 119, 119, 119, 118, 119,
119, 119, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119,
118, 120, 118, 120, 118, 120, 119, 120, 119, 119, 118, 121, 119, 119, 118, 120,
119, 119, 120, 119, 121, 117, 121, 117, 124, 114, 126, 108, 127, -4, -128, -107,
-126, -114, -122, -116, -121, -118, -120, -119, -120, -118, -120, -119, -120,
-118, -120, -117, -120, -118, -121, -118, -120, -118, -122, -115, -4, };