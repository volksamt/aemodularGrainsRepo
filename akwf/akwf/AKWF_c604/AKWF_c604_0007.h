#define DATA_LENGTH 512
#define DATA AKWF_c604_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {75, 117, 103, 111, 106, 111, 106, 109,
107, 109, 107, 108, 107, 107, 108, 109, 109, 108, 107, 107, 108, 108, 108, 108,
108, 108, 108, 107, 108, 108, 108, 108, 108, 107, 108, 107, 108, 108, 107, 109,
108, 108, 108, 109, 108, 108, 107, 109, 107, 108, 108, 109, 108, 108, 107, 107,
107, 108, 108, 108, 107, 107, 107, 108, 107, 108, 107, 108, 108, 108, 109, 108,
107, 108, 108, 108, 108, 107, 109, 107, 108, 109, 109, 108, 107, 107, 108, 108,
107, 108, 108, 108, 108, 108, 108, 107, 109, 108, 108, 108, 108, 107, 107, 108,
107, 107, 108, 108, 108, 108, 107, 108, 107, 107, 107, 108, 108, 108, 108, 108,
109, 108, 107, 108, 107, 108, 108, 108, 108, 108, 107, 108, 108, 108, 108, 108,
108, 107, 108, 109, 108, 108, 108, 108, 108, 109, 108, 108, 108, 108, 108, 108,
107, 108, 108, 108, 108, 108, 107, 107, 108, 108, 108, 109, 107, 108, 108, 108,
107, 108, 107, 108, 108, 108, 108, 108, 109, 108, 107, 108, 107, 108, 108, 108,
108, 108, 108, 108, 108, 108, 107, 108, 108, 108, 107, 108, 108, 108, 107, 108,
108, 108, 108, 108, 108, 108, 107, 109, 108, 108, 108, 107, 109, 108, 108, 108,
108, 107, 108, 107, 108, 107, 107, 108, 108, 107, 108, 107, 107, 108, 108, 109,
108, 108, 108, 108, 108, 108, 108, 109, 108, 108, 108, 108, 108, 107, 108, 107,
107, 108, 108, 108, 108, 108, 108, 108, 108, 107, 107, 109, 108, 108, 107, 106,
107, 107, 107, 106, 107, 107, 107, 107, 107, 106, 107, 107, 107, 106, 107, 107,
106, 106, 107, 106, 107, 106, 107, 106, 107, 107, 106, 107, 106, 107, 106, 108,
105, 107, 105, 108, 105, 107, 104, 108, 105, 107, 105, 107, 106, 106, 107, 106,
108, 104, 112, 97, 127, -40, -128, -96, -116, -101, -113, -103, -111, -105,
-110, -106, -109, -107, -109, -108, -108, -108, -108, -108, -107, -108, -107,
-108, -107, -109, -107, -109, -108, -108, -107, -108, -107, -109, -108, -108,
-107, -108, -107, -107, -108, -108, -108, -108, -108, -108, -108, -108, -108,
-108, -108, -107, -107, -109, -108, -108, -108, -107, -108, -107, -107, -107,
-107, -107, -107, -109, -108, -109, -107, -107, -108, -108, -108, -108, -108,
-108, -108, -108, -108, -108, -108, -108, -108, -108, -108, -108, -107, -108,
-109, -107, -108, -108, -108, -107, -108, -108, -108, -108, -108, -109, -108,
-108, -108, -108, -108, -108, -107, -107, -108, -108, -107, -107, -108, -107,
-108, -107, -107, -108, -108, -107, -107, -108, -107, -108, -108, -108, -108,
-107, -108, -107, -108, -107, -107, -108, -108, -108, -108, -107, -108, -108,
-107, -107, -107, -107, -108, -108, -107, -108, -107, -108, -108, -108, -108,
-107, -107, -108, -108, -108, -108, -109, -107, -108, -108, -108, -108, -108,
-107, -108, -107, -107, -107, -108, -108, -107, -108, -108, -108, -107, -109,
-107, -107, -107, -108, -107, -109, -107, -109, -106, -110, -106, -110, -105,
-111, -103, -116, -86, };