#define DATA_LENGTH 512
#define DATA AKWF_c604_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 39, 66, 87, 105, 114, 119, 118,
112, 103, 95, 87, 80, 77, 76, 78, 82, 88, 94, 98, 102, 102, 102, 98, 95, 91, 88,
84, 83, 83, 85, 88, 92, 94, 98, 98, 99, 97, 95, 93, 90, 86, 85, 85, 86, 88, 90,
93, 95, 96, 97, 97, 94, 94, 91, 88, 87, 86, 87, 87, 89, 92, 94, 95, 96, 96, 96,
94, 92, 89, 89, 88, 87, 88, 88, 91, 93, 95, 96, 96, 95, 94, 92, 90, 89, 87, 88,
88, 88, 90, 92, 93, 94, 95, 95, 94, 94, 91, 90, 89, 88, 88, 89, 90, 90, 93, 93,
95, 95, 95, 93, 92, 90, 89, 88, 88, 89, 90, 90, 92, 93, 94, 94, 94, 94, 92, 91,
89, 88, 89, 88, 89, 91, 91, 93, 94, 94, 94, 95, 93, 91, 90, 90, 89, 89, 89, 90,
92, 92, 94, 94, 95, 94, 94, 92, 91, 90, 89, 88, 89, 89, 90, 91, 93, 94, 94, 94,
94, 93, 92, 91, 89, 88, 89, 88, 90, 91, 92, 94, 94, 94, 94, 94, 92, 90, 90, 89,
88, 89, 89, 90, 92, 94, 94, 94, 94, 93, 93, 91, 91, 90, 89, 89, 89, 90, 91, 92,
93, 94, 95, 94, 93, 91, 91, 90, 88, 90, 89, 90, 90, 92, 94, 95, 95, 94, 93, 93,
92, 89, 89, 88, 88, 89, 91, 91, 93, 93, 95, 95, 93, 93, 92, 90, 90, 89, 89, 89,
90, 90, 92, 94, 95, 94, 95, 93, 92, 91, 89, 88, 89, 89, 89, 90, 92, 93, 94, 95,
95, 94, 92, 91, 90, 89, 88, 89, 89, 90, 92, 93, 94, 95, 95, 94, 94, 93, 90, 89,
88, 89, 88, 90, 91, 92, 94, 94, 95, 95, 94, 92, 91, 90, 88, 87, 88, 89, 89, 92,
93, 95, 95, 95, 95, 94, 92, 90, 88, 87, 87, 88, 89, 91, 93, 94, 96, 96, 96, 94,
93, 90, 89, 87, 87, 87, 88, 90, 92, 95, 96, 97, 97, 96, 95, 91, 88, 87, 85, 85,
86, 88, 90, 93, 96, 98, 99, 98, 96, 93, 89, 86, 84, 83, 83, 85, 89, 94, 97, 101,
102, 103, 101, 95, 90, 85, 80, 77, 76, 78, 84, 91, 100, 109, 115, 119, 118, 110,
96, 76, 52, 23, -5, -35, -61, -83, -99, -110, -114, -115, -110, -104, -96, -89,
-84, -80, -80, -80, -84, -87, -92, -95, -97, -99, -98, -97, -94, -92, -90, -88,
-87, -87, -88, -88, -91, -92, -94, -95, -95, -95, -93, -92, -91, -90, -89, -89,
-90, -90, -91, -91, -92, -93, -93, -93, -93, -92, -91, -92, -91, -91, -91, -91,
-91, -91, -91, -91, -92, -91, -92, -92, -92, -91, -92, -92, -92, -93, -92, -92,
-92, -91, -90, -90, -89, -90, -90, -92, -94, -94, -94, -95, -94, -93, -92, -89,
-89, -87, -86, -87, -89, -91, -94, -96, -98, -98, -99, -96, -94, -89, -85, -82,
-80, -79, -82, -88, -94, -102, -109, -114, -116, -112, -103, -88, -68, -43, -15,
};