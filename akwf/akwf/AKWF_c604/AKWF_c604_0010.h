#define DATA_LENGTH 512
#define DATA AKWF_c604_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 26, 41, 58, 71, 83, 93, 102, 108,
114, 117, 119, 119, 120, 119, 116, 115, 112, 109, 106, 104, 101, 98, 95, 94, 92,
91, 89, 88, 88, 88, 87, 87, 87, 87, 88, 88, 88, 88, 89, 89, 90, 91, 91, 90, 91,
92, 92, 92, 92, 92, 92, 92, 92, 92, 91, 92, 91, 92, 91, 92, 91, 92, 92, 92, 92,
90, 91, 90, 91, 90, 91, 90, 91, 90, 90, 91, 91, 91, 91, 91, 90, 90, 91, 90, 91,
92, 92, 92, 93, 92, 92, 92, 92, 92, 91, 92, 92, 92, 92, 92, 92, 93, 92, 92, 92,
90, 90, 91, 91, 90, 91, 91, 90, 90, 90, 91, 91, 91, 91, 91, 91, 91, 91, 90, 92,
92, 91, 92, 92, 91, 91, 92, 92, 93, 92, 92, 92, 92, 91, 92, 92, 92, 92, 92, 92,
91, 91, 91, 91, 91, 91, 91, 91, 91, 91, 90, 91, 91, 92, 91, 91, 91, 91, 91, 91,
91, 90, 90, 91, 91, 92, 91, 90, 91, 91, 90, 91, 91, 91, 91, 91, 91, 91, 90, 90,
90, 91, 90, 90, 91, 91, 91, 91, 90, 91, 91, 91, 90, 91, 91, 91, 90, 91, 90, 91,
91, 90, 90, 90, 91, 91, 91, 91, 91, 91, 90, 90, 91, 91, 91, 91, 91, 90, 90, 90,
91, 90, 91, 91, 90, 90, 91, 90, 90, 91, 90, 91, 91, 91, 91, 90, 91, 91, 91, 91,
90, 91, 90, 90, 91, 90, 91, 91, 91, 91, 91, 91, 91, 91, 90, 90, 91, 91, 91, 91,
90, 90, 91, 91, 91, 90, 91, 91, 91, 91, 91, 90, 91, 91, 90, 91, 91, 91, 91, 91,
90, 90, 90, 91, 91, 90, 91, 91, 90, 90, 91, 91, 90, 91, 91, 91, 91, 90, 91, 91,
90, 90, 91, 91, 90, 91, 91, 91, 91, 91, 90, 91, 92, 91, 91, 91, 90, 91, 91, 91,
91, 91, 91, 91, 90, 91, 91, 91, 90, 91, 91, 90, 91, 90, 91, 91, 90, 91, 91, 85,
76, 61, 46, 28, 10, -7, -25, -42, -56, -70, -82, -92, -101, -108, -113, -116,
-118, -119, -119, -118, -117, -115, -112, -109, -106, -104, -101, -98, -96, -94,
-92, -90, -89, -89, -88, -87, -87, -86, -88, -87, -88, -87, -89, -89, -89, -90,
-89, -91, -91, -90, -91, -91, -92, -91, -92, -92, -93, -92, -92, -92, -92, -91,
-92, -91, -92, -92, -91, -92, -92, -92, -92, -90, -90, -91, -91, -90, -91, -90,
-91, -90, -91, -91, -91, -91, -91, -91, -91, -90, -90, -90, -92, -92, -92, -92,
-92, -92, -91, -93, -92, -92, -92, -92, -92, -92, -92, -91, -92, -92, -92, -92,
-92, -91, -91, -91, -91, -90, -90, -90, -91, -91, -91, -91, -90, -91, -90, -91,
-91, -90, -91, -91, -91, -92, -92, -92, -92, -92, -92, -92, -92, -91, -92, -91,
-91, -92, -91, -92, -91, -92, -92, -92, -92, -90, -90, -91, -91, -91, -91, -90,
-91, -90, -84, -73, -60, -44, -26, -7, };