#define DATA_LENGTH 512
#define DATA AKWF_c604_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 28, 44, 59, 71, 83, 93, 101, 108,
112, 116, 118, 117, 117, 116, 115, 112, 110, 108, 105, 102, 99, 98, 94, 93, 91,
89, 89, 88, 86, 86, 86, 86, 87, 87, 86, 87, 87, 87, 88, 89, 89, 89, 90, 90, 90,
91, 90, 91, 90, 90, 91, 91, 90, 91, 91, 91, 90, 91, 90, 91, 91, 91, 90, 91, 91,
89, 89, 90, 90, 89, 90, 89, 90, 89, 90, 90, 90, 89, 90, 90, 90, 90, 90, 89, 91,
91, 91, 91, 90, 90, 91, 91, 91, 91, 92, 91, 91, 90, 91, 91, 90, 90, 91, 91, 90,
89, 91, 90, 90, 90, 90, 89, 90, 89, 90, 90, 89, 90, 90, 90, 90, 90, 90, 90, 91,
91, 91, 91, 91, 91, 91, 91, 91, 92, 91, 91, 91, 91, 91, 91, 90, 91, 91, 91, 90,
90, 90, 90, 89, 90, 90, 90, 90, 89, 90, 90, 90, 89, 90, 90, 89, 90, 89, 90, 90,
89, 89, 90, 89, 90, 89, 90, 90, 89, 90, 90, 90, 90, 90, 89, 90, 91, 90, 90, 89,
90, 90, 90, 90, 89, 90, 90, 90, 90, 90, 90, 90, 90, 89, 90, 89, 91, 90, 90, 90,
90, 89, 90, 89, 90, 89, 90, 89, 90, 90, 90, 90, 90, 90, 90, 90, 89, 90, 90, 89,
90, 89, 90, 89, 90, 90, 89, 90, 89, 90, 90, 90, 89, 90, 90, 91, 89, 90, 90, 90,
90, 90, 90, 89, 90, 90, 89, 89, 90, 89, 90, 90, 90, 90, 90, 90, 90, 90, 89, 90,
89, 90, 89, 89, 89, 90, 90, 89, 89, 90, 90, 89, 90, 90, 89, 90, 90, 90, 90, 90,
90, 90, 90, 89, 90, 90, 90, 90, 89, 90, 91, 90, 89, 90, 89, 89, 90, 90, 90, 89,
90, 90, 90, 90, 90, 90, 89, 89, 90, 89, 89, 90, 89, 90, 89, 90, 90, 90, 90, 89,
90, 89, 90, 90, 89, 90, 90, 89, 89, 90, 90, 90, 89, 89, 89, 90, 89, 90, 90, 91,
89, 90, 90, 90, 89, 90, 90, 90, 90, 90, 90, 89, 89, 90, 90, 90, 90, 90, 89, 90,
89, 90, 90, 90, 90, 90, 90, 90, 90, 90, 90, 90, 90, 90, 90, 90, 89, 84, 78, 67,
56, 43, 30, 16, 2, -11, -24, -37, -49, -61, -71, -80, -88, -96, -102, -108,
-111, -114, -117, -117, -119, -119, -118, -116, -116, -114, -111, -110, -108,
-105, -104, -102, -100, -98, -96, -94, -93, -91, -90, -88, -88, -88, -86, -85,
-87, -86, -87, -86, -86, -86, -86, -85, -87, -87, -87, -88, -89, -89, -89, -89,
-90, -90, -90, -90, -91, -91, -90, -90, -90, -91, -91, -91, -90, -91, -90, -92,
-91, -90, -91, -91, -91, -91, -90, -91, -92, -92, -91, -91, -91, -90, -90, -90,
-89, -89, -91, -89, -90, -90, -89, -89, -90, -90, -89, -90, -89, -90, -90, -90,
-90, -89, -89, -89, -90, -90, -90, -91, -91, -90, -85, -78, -67, -56, -44, -30,
-17, -3, };