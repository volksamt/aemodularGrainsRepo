#define DATA_LENGTH 512
#define DATA AKWF_c604_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {96, 114, 106, 112, 108, 112, 108, 112,
108, 111, 109, 110, 109, 111, 109, 110, 109, 109, 109, 110, 109, 109, 110, 110,
110, 110, 110, 110, 110, 109, 110, 110, 110, 110, 110, 110, 110, 110, 110, 110,
110, 110, 110, 110, 110, 110, 110, 110, 110, 110, 110, 110, 110, 110, 109, 110,
110, 109, 110, 110, 110, 109, 110, 109, 110, 110, 109, 110, 110, 110, 110, 109,
111, 110, 110, 110, 109, 110, 109, 110, 110, 110, 109, 109, 109, 110, 110, 110,
109, 110, 110, 109, 109, 110, 110, 109, 110, 109, 109, 110, 110, 110, 109, 110,
110, 109, 110, 109, 110, 109, 110, 110, 110, 110, 110, 109, 110, 109, 110, 109,
110, 109, 110, 110, 110, 109, 110, 110, 110, 110, 110, 110, 109, 110, 110, 109,
109, 110, 110, 110, 110, 110, 110, 110, 110, 111, 110, 109, 110, 110, 110, 110,
110, 110, 110, 110, 110, 110, 110, 110, 109, 109, 110, 110, 109, 110, 110, 110,
110, 110, 110, 110, 110, 110, 110, 110, 109, 109, 109, 109, 110, 110, 110, 110,
110, 110, 110, 110, 109, 109, 109, 110, 110, 110, 110, 110, 110, 110, 110, 110,
109, 110, 110, 111, 110, 109, 110, 110, 110, 110, 110, 109, 110, 110, 110, 111,
110, 110, 110, 110, 109, 110, 109, 110, 110, 110, 110, 110, 109, 110, 110, 110,
110, 110, 110, 110, 110, 110, 109, 109, 110, 110, 110, 110, 110, 110, 110, 109,
111, 110, 109, 109, 110, 109, 109, 109, 108, 109, 108, 109, 109, 109, 109, 109,
108, 109, 108, 109, 108, 108, 109, 109, 108, 109, 109, 109, 108, 109, 109, 108,
109, 108, 109, 107, 109, 107, 109, 108, 109, 108, 109, 108, 109, 109, 108, 109,
108, 109, 108, 110, 107, 110, 106, 112, 104, 114, 102, 116, 96, 127, 36, -128,
-101, -116, -107, -112, -109, -111, -110, -109, -111, -108, -111, -108, -111,
-108, -111, -109, -111, -109, -111, -109, -111, -109, -110, -110, -110, -109,
-110, -110, -110, -110, -110, -109, -110, -110, -110, -110, -109, -111, -110,
-111, -109, -111, -110, -110, -110, -110, -110, -111, -110, -111, -110, -109,
-110, -110, -110, -109, -110, -110, -110, -111, -111, -110, -109, -110, -111,
-110, -109, -110, -110, -110, -109, -110, -109, -110, -110, -109, -110, -110,
-109, -110, -110, -109, -110, -110, -109, -109, -110, -110, -109, -111, -110,
-110, -109, -110, -110, -109, -110, -109, -110, -109, -110, -110, -110, -109,
-110, -110, -110, -109, -109, -109, -109, -109, -110, -110, -110, -110, -109,
-108, -108, -108, -108, -109, -108, -108, -109, -108, -109, -108, -109, -109,
-108, -109, -109, -108, -108, -109, -108, -108, -109, -108, -108, -109, -109,
-108, -108, -109, -108, -108, -108, -108, -108, -108, -109, -109, -109, -109,
-108, -109, -109, -109, -109, -109, -108, -109, -108, -108, -108, -109, -109,
-108, -109, -109, -109, -109, -109, -108, -108, -109, -108, -109, -109, -109,
-109, -109, -109, -108, -109, -108, -109, -107, -109, -108, -110, -107, -110,
-106, -111, -104, -117, -76, };