#define DATA_LENGTH 512
#define DATA AKWF_c604_0027

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 2, 3, 3, 3, 4, 5, 6, 6, 5,
6, 7, 7, 8, 8, 8, 9, 10, 9, 11, 11, 11, 12, 12, 14, 13, 13, 14, 15, 15, 16, 16,
16, 17, 17, 18, 19, 18, 19, 20, 19, 21, 21, 22, 23, 23, 23, 24, 24, 25, 25, 25,
26, 26, 26, 27, 28, 28, 28, 29, 29, 30, 30, 30, 31, 33, 32, 33, 33, 35, 34, 34,
35, 36, 36, 37, 36, 38, 39, 39, 39, 39, 39, 40, 41, 42, 42, 43, 42, 43, 43, 45,
44, 45, 46, 46, 47, 47, 47, 48, 48, 49, 49, 50, 50, 50, 51, 51, 52, 53, 53, 53,
54, 55, 55, 55, 56, 56, 57, 56, 58, 59, 59, 59, 60, 60, 61, 61, 61, 62, 63, 63,
63, 64, 64, 65, 66, 66, 66, 67, 67, 67, 68, 68, 69, 69, 69, 70, 71, 71, 71, 72,
73, 73, 74, 74, 75, 76, 75, 75, 76, 76, 77, 78, 78, 79, 79, 80, 80, 80, 81, 81,
82, 82, 83, 83, 84, 84, 85, 85, 86, 86, 86, 87, 88, 88, 89, 90, 90, 90, 90, 90,
91, 92, 92, 93, 92, 94, 95, 94, 95, 95, 96, 96, 97, 98, 98, 99, 99, 99, 100,
101, 100, 101, 102, 102, 103, 103, 104, 104, 104, 105, 105, 105, 107, 107, 107,
107, 108, 109, 109, 110, 110, 110, 111, 111, 112, 112, 114, 113, 113, 115, 115,
115, 116, 117, 116, 118, 116, 120, 115, 127, 7, -123, -116, -119, -116, -118,
-116, -116, -116, -115, -115, -115, -114, -113, -112, -112, -112, -111, -111,
-110, -110, -110, -109, -109, -109, -107, -108, -107, -106, -106, -105, -105,
-104, -103, -104, -103, -103, -103, -102, -102, -101, -101, -100, -100, -100,
-98, -98, -98, -98, -97, -96, -97, -95, -95, -94, -94, -93, -93, -93, -92, -92,
-91, -90, -90, -89, -88, -89, -88, -88, -88, -86, -86, -86, -85, -85, -84, -84,
-84, -83, -82, -83, -82, -81, -81, -79, -80, -79, -79, -78, -78, -77, -77, -76,
-76, -76, -76, -74, -74, -74, -73, -74, -72, -72, -71, -72, -71, -70, -69, -70,
-68, -68, -68, -67, -66, -66, -66, -65, -65, -64, -64, -63, -63, -62, -62, -62,
-61, -60, -60, -60, -60, -58, -58, -58, -58, -57, -57, -57, -55, -55, -55, -55,
-53, -53, -52, -53, -51, -51, -51, -50, -50, -49, -49, -49, -48, -48, -47, -46,
-46, -45, -46, -45, -44, -44, -44, -43, -42, -42, -42, -40, -41, -39, -40, -39,
-39, -38, -38, -38, -37, -36, -36, -36, -36, -35, -34, -33, -33, -33, -32, -32,
-31, -30, -31, -29, -29, -29, -29, -28, -28, -28, -26, -26, -26, -25, -24, -24,
-23, -24, -23, -23, -21, -21, -21, -21, -20, -20, -19, -18, -18, -18, -18, -17,
-17, -16, -16, -15, -14, -14, -13, -12, -13, -13, -11, -11, -10, -10, -9, -9,
-8, -9, -8, -7, -8, -7, -6, -6, -5, -5, -4, -4, -4, -3, -2, -2, -1, -2, -1, 0,
};