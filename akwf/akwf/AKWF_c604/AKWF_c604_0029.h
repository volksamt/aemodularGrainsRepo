#define DATA_LENGTH 512
#define DATA AKWF_c604_0029

const PROGMEM int8_t DATA[DATA_LENGTH] = {62, 111, 105, 108, 108, 118, 112, 123,
52, -8, 4, -2, 2, -1, 1, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 1, 0, 0, 1, 0,
0, -1, 0, -1, 1, 0, 2, 2, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0, -1, 0, 0, 0, 1, 1, 0,
0, 0, 0, -1, 0, 0, 0, -1, 1, 1, -1, 1, 0, 8, 6, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0,
1, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 1, 1, 0, -1, 0, 0, 2, 2, 0, 1, 0, 0,
0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 1,
18, 28, 10, -3, 1, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0,
0, 0, 0, 0, 0, -1, 0, -1, 2, 1, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0,
1, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 9, 5, -1, 0, -1, 0, -1, 0, 0, 0,
-1, 1, 0, 1, 0, 0, 1, 1, 0, -1, 0, -1, 1, 1, 1, 0, 0, 0, -1, 0, 0, -1, 2, 2, 0,
1, 0, -1, 0, 0, 0, 0, 1, 0, 0, -1, 0, -1, 1, 0, 0, -1, 0, -1, 0, 0, 0, 1, -1, 1,
-4, 42, 58, 53, 57, 14, -2, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1,
0, 1, 1, 0, -1, 0, 1, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0,
-1, 0, 0, 1, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 1, 1, 0, 1, 9, 4, -1, 0, 0, 1, 0,
0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 2,
1, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1,
-1, 1, -1, 2, 23, 26, 6, -1, 0, -1, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0, 0, 0, 1, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, -1, 2, 1, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0,
-1, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 1, -1, 2, 11, 4, -1, 1, -1, 0,
-1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
3, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, };