#define DATA_LENGTH 512
#define DATA AKWF_c604_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {81, 98, 92, 97, 93, 96, 93, 96, 94,
96, 93, 96, 94, 95, 94, 94, 94, 95, 94, 95, 94, 95, 95, 94, 94, 95, 95, 95, 95,
94, 94, 95, 95, 95, 95, 94, 94, 94, 95, 95, 94, 95, 95, 94, 94, 94, 95, 95, 95,
95, 95, 94, 95, 94, 95, 95, 95, 94, 94, 94, 94, 95, 95, 95, 94, 95, 94, 94, 95,
94, 95, 95, 95, 94, 94, 94, 95, 94, 95, 94, 94, 95, 95, 95, 94, 94, 94, 95, 95,
94, 94, 95, 95, 95, 95, 94, 95, 94, 94, 95, 95, 94, 95, 95, 95, 95, 95, 94, 94,
94, 95, 94, 94, 94, 95, 94, 95, 95, 94, 95, 95, 94, 95, 95, 95, 95, 94, 94, 95,
94, 94, 95, 94, 94, 94, 95, 95, 95, 94, 95, 95, 94, 94, 94, 95, 94, 94, 94, 95,
94, 94, 94, 94, 95, 95, 95, 95, 94, 95, 94, 95, 95, 95, 95, 95, 95, 95, 94, 95,
94, 94, 94, 95, 94, 95, 95, 94, 94, 95, 94, 95, 94, 95, 94, 95, 94, 94, 94, 94,
95, 95, 94, 94, 95, 94, 94, 94, 95, 95, 95, 94, 94, 94, 94, 95, 95, 94, 95, 94,
94, 95, 95, 95, 95, 95, 94, 94, 94, 94, 94, 94, 95, 95, 94, 95, 95, 94, 95, 95,
95, 95, 94, 95, 94, 95, 95, 94, 95, 95, 94, 95, 95, 95, 95, 95, 95, 95, 95, 94,
95, 94, 94, 95, 95, 94, 95, 95, 95, 95, 95, 95, 95, 94, 94, 95, 94, 94, 95, 95,
94, 95, 94, 95, 94, 95, 94, 94, 95, 94, 95, 94, 95, 94, 95, 94, 94, 94, 94, 95,
96, 94, 95, 94, 95, 95, 94, 96, 94, 96, 93, 96, 92, 97, 92, 98, 91, 100, 89,
102, 84, 110, 50, -108, -89, -97, -93, -94, -95, -93, -96, -92, -96, -93, -96,
-93, -96, -94, -95, -93, -96, -93, -96, -94, -95, -94, -96, -94, -95, -94, -94,
-95, -95, -95, -94, -95, -94, -95, -94, -94, -95, -95, -95, -95, -94, -95, -94,
-95, -94, -95, -95, -94, -94, -94, -94, -94, -95, -95, -94, -95, -95, -95, -95,
-95, -94, -94, -94, -95, -94, -94, -94, -95, -94, -94, -95, -95, -94, -95, -94,
-94, -94, -95, -95, -95, -94, -94, -94, -94, -94, -95, -95, -95, -94, -94, -94,
-94, -95, -95, -95, -95, -95, -95, -95, -94, -95, -94, -94, -95, -95, -94, -95,
-94, -95, -95, -95, -94, -95, -95, -95, -95, -95, -95, -95, -95, -95, -95, -94,
-95, -95, -95, -94, -94, -95, -94, -95, -94, -95, -95, -94, -95, -95, -95, -95,
-94, -94, -95, -94, -95, -94, -94, -94, -95, -94, -94, -95, -95, -95, -94, -94,
-94, -94, -94, -95, -94, -95, -95, -95, -95, -95, -95, -95, -94, -94, -94, -94,
-95, -95, -94, -95, -94, -95, -95, -95, -94, -95, -95, -94, -94, -94, -95, -94,
-95, -93, -96, -93, -97, -93, -97, -92, -97, -90, -100, -80, };