#define DATA_LENGTH 512
#define DATA AKWF_c604_0028

const PROGMEM int8_t DATA[DATA_LENGTH] = {57, 121, 117, 121, 118, 120, 119, 119,
120, 120, 119, 119, 119, 119, 118, 118, 119, 119, 119, 118, 119, 119, 120, 119,
120, 119, 120, 119, 119, 119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 120,
119, 119, 120, 120, 119, 120, 119, 119, 119, 119, 118, 119, 119, 118, 119, 119,
119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119,
118, 120, 120, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 119, 119, 119, 118, 118, 119, 119, 120, 119, 119, 119, 118, 119, 119,
119, 119, 119, 119, 118, 119, 119, 119, 118, 119, 120, 119, 119, 119, 119, 119,
119, 118, 119, 119, 120, 119, 119, 119, 119, 118, 118, 119, 119, 119, 120, 120,
119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119,
119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119,
119, 118, 119, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119,
119, 119, 119, 120, 117, 120, 117, 120, 118, 120, 117, 121, 117, 120, 118, 121,
117, 119, 119, 120, 120, 118, 122, 115, 120, -70, -127, -109, -127, -113, -124,
-115, -123, -116, -121, -117, -120, -118, -121, -118, -119, -119, -119, -120,
-118, -119, -119, -119, -119, -120, -119, -120, -118, -119, -118, -119, -119,
-119, -118, -119, -120, -119, -119, -119, -119, -120, -119, -120, -120, -118,
-119, -118, -118, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -118, -119, -118, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -120, -118, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -120,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -120, -119, -119, -119, -119, -119, -120, -120, -120, -120, -119,
-119, -119, -119, -120, -119, -119, -118, -119, -119, -119, -120, -120, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-118, -118, -119, -119, -118, -119, -119, -119, -120, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -118, -118, -119, -120, -120, -119,
-120, -119, -120, -119, -120, -119, -120, -119, -118, -118, -119, -119, -119,
-120, -119, -119, -118, -120, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -118, -118, -119, -118, -119,
-118, -120, -119, -119, -120, -120, -118, -119, -120, -119, -119, -118, -119,
-118, -119, -119, -119, -119, -119, -119, -120, -119, -120, -119, -119, -118,
-120, -119, -119, -119, -119, -119, -119, -120, -117, -120, -118, -121, -117,
-121, -117, -122, -116, -123, -114, -126, -101, };