#define DATA_LENGTH 512
#define DATA AKWF_c604_0031

const PROGMEM int8_t DATA[DATA_LENGTH] = {-58, -123, -117, -120, -118, -120,
-119, -119, -119, -119, -119, -120, -119, -118, -120, -119, -119, -119, -119,
-119, -120, -120, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -118, -119, -119, -120,
-119, -119, -119, -119, -118, -119, -119, -119, -120, -119, -119, -119, -118,
-120, -119, -119, -119, -119, -120, -120, -119, -119, -119, -119, -119, -118,
-120, -120, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -118, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -120,
-119, -119, -119, -119, -118, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -120, -119,
-119, -119, -120, -119, -120, -119, -118, -119, -119, -119, -119, -119, -120,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -118, -118, -119, -119, -120, -119, -119, -119, -120, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -120,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -118,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -118, -118,
-118, -120, -119, -119, -120, -119, -120, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -118, -119, -119,
-120, -118, -120, -118, -120, -118, -121, -107, -25, 4, -2, 2, -1, 0, 0, 1, 0,
1, -1, 1, 0, 0, 0, 1, -1, 1, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 1, 0, 1, 0, 0, -1, 1, 0, 0, -1, 0, 0, 0, 1, 1, 1, -1, 1, 0, 0, 0, 0, 0, 0, 1,
0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0,
0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 3, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0,
-1, -1, -1, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0,
-1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 1, 0, 0, 0,
0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0,
1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, -1, 1, 0, 0, -1, 1, -1, 0, -1,
1, -1, 1, -1, 1, -1, 1, -2, 3, 22, };