#define DATA_LENGTH 512
#define DATA AKWF_c604_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {35, 121, 119, 119, 119, 119, 119, 118,
120, 118, 120, 118, 119, 118, 120, 119, 120, 118, 119, 119, 119, 119, 119, 119,
119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 118, 119, 119, 118,
118, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 120, 119, 119, 119,
119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119,
118, 119, 119, 119, 119, 119, 119, 118, 118, 119, 120, 118, 119, 119, 119, 120,
120, 118, 119, 119, 119, 119, 118, 120, 119, 119, 120, 119, 119, 119, 118, 120,
119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 119,
119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 120, 119, 119, 119, 119, 120, 120, 120, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 120, 119,
119, 119, 119, 120, 119, 119, 118, 119, 119, 118, 119, 119, 119, 119, 118, 119,
118, 119, 119, 119, 119, 119, 119, 119, 120, 118, 119, 119, 118, 119, 120, 119,
119, 120, 120, 118, 120, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119,
119, 119, 120, 119, 119, 119, 119, 119, 118, 119, 120, 119, 119, 119, 119, 119,
119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 119, 118,
118, 119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 118, 118, 119, 119,
119, 119, 118, 120, 118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119,
119, 118, 119, 118, 120, 119, 119, 119, 119, 120, 119, 119, 119, 118, 119, 119,
119, 119, 119, 118, 119, 119, 119, 118, 120, 119, 119, 118, 119, 119, 119, 119,
119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 120, 120, 119, 119, 118, 120, 119, 119, 120,
119, 119, 119, 118, 120, 119, 119, 119, 118, 119, 120, 119, 119, 120, 119, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 120,
120, 119, 119, 119, 119, 118, 119, 119, 119, 118, 120, 119, 119, 119, 120, 119,
119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 120, 119, 119, 118, 120,
118, 121, 117, 121, 117, 122, 116, 124, 113, 127, 35, -128, -115, -120, -118,
-119, -119, -119, -120, -118, -120, -118, -121, -117, -121, -118, -121, -117,
-121, -116, -122, -116, -122, -117, -123, -115, -122, -114, -127, -101, };