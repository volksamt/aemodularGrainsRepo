#define DATA_LENGTH 512
#define DATA AKWF_c604_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 125, 115, 122, 117, 121, 116,
122, 117, 121, 117, 121, 118, 121, 118, 120, 118, 119, 119, 119, 119, 119, 119,
120, 119, 119, 119, 119, 119, 118, 120, 118, 120, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 119, 118, 120, 119, 118, 119, 119, 119, 118, 119, 118, 119, 119, 119,
119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 118, 119, 119, 119, 120, 120,
119, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119,
118, 119, 119, 119, 119, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 120,
120, 119, 118, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 120, 118, 119, 119, 118, 119, 118, 119, 119, 119, 118, 119,
119, 119, 119, 118, 119, 119, 120, 119, 119, 118, 119, 119, 119, 119, 119, 118,
120, 120, 119, 119, 119, 119, 120, 119, 120, 119, 118, 119, 119, 119, 119, 119,
119, 119, 119, 118, 119, 119, 118, 119, 118, 120, 119, 119, 119, 119, 119, 119,
119, 118, 118, 119, 118, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119, 120, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 118, 119, 120,
118, 119, 118, 119, 119, 119, 120, 120, 118, 119, 119, 118, 119, 119, 118, 119,
119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 120, 119, 119, 119, 118,
119, 120, 118, 119, 118, 119, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119,
119, 120, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 119, 119, 120, 119, 119, 119,
119, 119, 119, 120, 118, 119, 119, 119, 120, 119, 120, 120, 119, 118, 120, 119,
119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 119, 119, 120, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119,
119, 118, 119, 120, 120, 119, 119, 119, 119, 119, 120, 119, 120, 120, 119, 118,
119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 120, 119, 119, 119,
119, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 119, 119, 120, 119, 118, 119,
119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 120,
119, 119, 119, 119, 118, 120, 118, 120, 117, 122, 116, 124, -1, -126, -114,
-122, -117, -122, -117, -121, -117, -122, -116, -124, -77, };