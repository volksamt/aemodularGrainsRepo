#define DATA_LENGTH 512
#define DATA AKWF_c604_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {43, 109, 89, 38, 40, 42, 6, -4, 23,
40, -1, 9, 3, 3, -1, -3, 40, 30, 4, 1, 3, 7, -2, 1, 10, 6, 0, -2, 3, -5, 8, -13,
49, 85, 49, 30, 13, 33, 7, 1, 29, 25, 4, 5, 7, 1, 4, -7, 21, 42, -4, 2, -1, 0,
0, -1, 1, -1, 1, -1, 2, -2, 1, -2, 24, 15, -1, 1, 0, 0, -1, 0, 0, 0, -1, 1, -1,
0, -1, 1, -1, 1, -1, 1, 0, 1, -1, 1, 0, 0, 0, -1, 1, -1, 4, -7, 33, 50, 20, 4,
10, 11, -3, 2, 6, 2, -1, 1, 0, 0, 0, -1, 3, 5, -2, 1, 0, 0, 0, 0, 0, 1, 0, 1, 0,
0, 0, 0, 7, -1, 0, 0, -1, 0, 0, -1, 0, 1, -1, 0, -1, 1, 0, 0, -1, -1, 0, -1, 0,
1, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 3, 2, -1, 0, -1, 0, 0, 0, -1, 1, 0, -1, -1, 0,
0, 0, 0, 1, -1, 0, 0, 0, -1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, -1, 1, 0, 0,
1, 0, 0, 1, 0, -1, -1, 0, 1, 0, 0, 0, 1, 0, -1, 0, -1, 0, 0, 0, 1, -1, 2, -4, 6,
-33, -79, -75, -79, -76, -78, -77, -79, -77, -78, -78, -77, -78, -77, -77, -78,
-78, -77, -77, -77, -78, -77, -78, -77, -78, -77, -77, -78, -77, -78, -78, -77,
-77, -77, -78, -77, -77, -78, -78, -78, -78, -78, -78, -77, -77, -78, -78, -78,
-78, -77, -77, -78, -78, -78, -77, -78, -77, -78, -77, -77, -77, -77, -78, -77,
-78, -77, -77, -77, -78, -78, -77, -78, -78, -78, -77, -77, -77, -77, -78, -77,
-78, -78, -77, -77, -77, -78, -77, -78, -78, -78, -78, -78, -78, -78, -78, -78,
-78, -78, -77, -77, -77, -77, -77, -77, -77, -77, -78, -77, -78, -78, -77, -77,
-78, -78, -77, -77, -78, -78, -77, -78, -77, -78, -77, -78, -77, -77, -78, -77,
-78, -78, -77, -78, -78, -78, -77, -78, -77, -78, -77, -77, -78, -77, -77, -77,
-77, -78, -78, -78, -78, -78, -78, -77, -78, -77, -77, -77, -78, -78, -78, -78,
-78, -78, -78, -78, -78, -78, -78, -78, -78, -78, -77, -78, -77, -78, -77, -77,
-77, -78, -77, -77, -78, -77, -77, -77, -78, -77, -77, -78, -77, -78, -78, -77,
-78, -78, -78, -77, -77, -78, -77, -78, -78, -78, -77, -78, -78, -77, -78, -78,
-77, -78, -77, -77, -78, -77, -78, -77, -77, -78, -78, -78, -78, -78, -77, -77,
-78, -77, -78, -77, -77, -77, -77, -77, -78, -78, -78, -77, -77, -77, -77, -78,
-77, -77, -77, -77, -78, -77, -78, -78, -77, -77, -77, -78, -78, -78, -78, -78,
-77, -78, -77, -78, -78, -78, -77, -78, -78, -77, -77, -77, -77, -78, -78, -78,
-77, -78, -77, -78, -78, -79, -77, -78, -78, -78, -77, -78, -78, -77, -78, -27,
};