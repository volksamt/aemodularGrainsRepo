#define DATA_LENGTH 512
#define DATA AKWF_c604_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {32, 109, 90, 99, 95, 97, 96, 96, 96,
95, 98, 95, 97, 95, 96, 95, 96, 95, 96, 95, 97, 96, 96, 96, 96, 95, 96, 95, 96,
96, 96, 96, 96, 96, 95, 95, 96, 96, 96, 97, 96, 96, 96, 96, 96, 96, 96, 95, 97,
97, 96, 96, 95, 96, 96, 96, 96, 96, 96, 96, 96, 96, 96, 96, 95, 96, 97, 97, 96,
95, 96, 97, 96, 96, 96, 96, 96, 96, 97, 96, 96, 96, 95, 96, 96, 97, 96, 96, 95,
96, 97, 96, 96, 97, 96, 96, 96, 97, 96, 96, 96, 96, 96, 96, 96, 96, 95, 96, 96,
96, 96, 96, 96, 96, 95, 97, 97, 96, 97, 96, 96, 97, 96, 96, 96, 96, 97, 96, 96,
96, 96, 95, 96, 96, 96, 96, 96, 96, 96, 96, 96, 96, 96, 96, 96, 96, 96, 95, 96,
97, 95, 96, 96, 96, 96, 96, 96, 97, 96, 95, 96, 96, 97, 96, 96, 96, 96, 96, 96,
96, 96, 96, 96, 95, 96, 96, 96, 96, 96, 97, 96, 96, 96, 96, 96, 96, 96, 95, 96,
96, 96, 96, 96, 96, 96, 96, 96, 96, 96, 96, 96, 97, 96, 97, 97, 97, 96, 96, 96,
96, 97, 97, 96, 96, 96, 97, 96, 96, 96, 96, 97, 96, 96, 96, 96, 96, 96, 96, 97,
96, 96, 96, 96, 95, 96, 97, 96, 96, 96, 96, 96, 96, 96, 96, 96, 96, 96, 96, 96,
95, 96, 96, 96, 96, 96, 96, 96, 96, 96, 97, 96, 96, 96, 96, 95, 96, 95, 96, 96,
97, 97, 96, 95, 97, 96, 96, 96, 96, 96, 97, 96, 96, 96, 96, 97, 96, 96, 96, 96,
96, 95, 97, 96, 96, 96, 96, 95, 96, 96, 96, 96, 96, 96, 96, 96, 96, 96, 96, 96,
96, 95, 96, 96, 96, 96, 96, 97, 96, 96, 96, 97, 96, 96, 96, 96, 96, 96, 95, 96,
97, 96, 96, 96, 96, 97, 95, 96, 95, 97, 96, 96, 95, 97, 97, 96, 97, 95, 97, 95,
97, 95, 97, 95, 98, 94, 98, 94, 98, 94, 98, 94, 98, 95, 97, 95, 96, 98, 92, 107,
-59, -111, -88, -104, -92, -102, -93, -101, -94, -100, -95, -99, -97, -99, -97,
-97, -96, -98, -97, -97, -97, -97, -97, -97, -98, -96, -97, -96, -98, -97, -98,
-96, -97, -97, -97, -97, -97, -98, -97, -97, -98, -97, -97, -97, -97, -97, -96,
-97, -98, -97, -97, -98, -98, -97, -97, -98, -97, -98, -96, -98, -98, -97, -98,
-98, -98, -97, -97, -97, -98, -97, -97, -97, -97, -96, -98, -97, -97, -97, -97,
-98, -97, -97, -97, -98, -97, -97, -98, -98, -97, -97, -97, -97, -96, -98, -97,
-97, -97, -97, -97, -97, -97, -98, -97, -97, -98, -96, -97, -96, -97, -97, -98,
-97, -98, -97, -98, -97, -98, -96, -97, -97, -97, -98, -97, -97, -96, -98, -96,
-99, -96, -98, -96, -99, -95, -100, -95, -99, -94, -100, -94, -100, -95, -99,
-97, };