#define DATA_LENGTH 512
#define DATA AKWF_c604_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 37, 65, 87, 105, 114, 119, 117,
113, 105, 96, 88, 82, 79, 78, 81, 85, 90, 95, 100, 101, 102, 101, 98, 95, 91,
87, 87, 86, 86, 88, 91, 94, 96, 98, 98, 98, 97, 95, 92, 91, 88, 88, 88, 89, 91,
93, 94, 96, 97, 97, 96, 95, 93, 91, 90, 90, 89, 90, 91, 92, 94, 95, 95, 95, 95,
94, 93, 92, 91, 90, 91, 91, 91, 92, 94, 94, 95, 95, 95, 94, 93, 92, 91, 91, 91,
91, 91, 93, 93, 94, 94, 95, 94, 93, 93, 93, 92, 92, 91, 92, 92, 93, 92, 93, 94,
94, 94, 94, 93, 94, 93, 91, 91, 92, 91, 92, 93, 93, 93, 93, 93, 94, 93, 92, 92,
92, 91, 91, 92, 92, 92, 93, 94, 93, 93, 93, 93, 93, 92, 92, 93, 92, 92, 93, 93,
93, 93, 92, 92, 93, 92, 93, 93, 92, 93, 94, 92, 93, 92, 92, 92, 93, 93, 92, 92,
93, 93, 93, 92, 93, 93, 94, 93, 93, 93, 92, 93, 92, 92, 93, 92, 93, 94, 94, 94,
93, 94, 93, 92, 93, 92, 93, 92, 92, 93, 93, 93, 94, 94, 94, 94, 93, 92, 92, 91,
91, 91, 92, 93, 93, 94, 94, 95, 94, 94, 94, 93, 91, 91, 90, 91, 92, 92, 93, 93,
95, 95, 95, 94, 93, 93, 92, 90, 91, 90, 90, 92, 94, 94, 95, 95, 96, 95, 95, 93,
91, 90, 89, 90, 90, 91, 92, 94, 95, 97, 97, 96, 95, 94, 91, 90, 88, 87, 89, 91,
92, 94, 96, 98, 99, 98, 97, 95, 90, 88, 86, 85, 86, 88, 91, 94, 98, 101, 103,
102, 101, 96, 91, 86, 81, 78, 79, 82, 88, 94, 103, 111, 118, 120, 116, 107, 90,
69, 42, 13, -17, -47, -72, -93, -108, -116, -119, -116, -110, -102, -94, -86,
-82, -79, -80, -82, -86, -91, -97, -100, -102, -101, -100, -98, -94, -90, -88,
-86, -86, -87, -89, -92, -93, -96, -98, -98, -97, -96, -94, -92, -90, -90, -88,
-89, -90, -92, -94, -94, -95, -96, -96, -95, -94, -93, -92, -91, -90, -90, -91,
-92, -93, -94, -95, -95, -94, -95, -93, -93, -92, -92, -92, -91, -92, -92, -93,
-94, -94, -94, -94, -93, -93, -92, -92, -92, -92, -92, -92, -92, -93, -93, -93,
-93, -93, -94, -94, -94, -93, -92, -92, -93, -93, -93, -93, -93, -93, -93, -93,
-92, -93, -93, -93, -94, -93, -93, -93, -93, -93, -93, -92, -92, -92, -92, -92,
-93, -93, -93, -94, -94, -93, -95, -94, -92, -92, -92, -91, -91, -92, -92, -92,
-93, -95, -95, -95, -95, -93, -93, -92, -90, -90, -90, -90, -91, -92, -93, -95,
-96, -95, -96, -95, -93, -91, -90, -89, -89, -89, -90, -92, -95, -96, -97, -98,
-97, -96, -94, -92, -90, -87, -86, -86, -89, -90, -94, -97, -99, -101, -101,
-100, -97, -92, -88, -82, -80, -80, -81, -86, -93, -102, -110, -116, -118, -116,
-108, -94, -74, -49, -18, };