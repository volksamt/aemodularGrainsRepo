#define DATA_LENGTH 512
#define DATA AKWF_c604_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {105, 124, 116, 123, 117, 121, 117,
121, 117, 120, 117, 120, 118, 120, 118, 119, 119, 120, 119, 119, 120, 120, 119,
119, 118, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 118, 119,
120, 119, 120, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 120, 119, 120, 119,
120, 119, 119, 119, 119, 120, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119,
119, 120, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 118, 119, 119, 120, 119,
119, 118, 119, 118, 119, 118, 120, 119, 118, 119, 120, 119, 119, 119, 119, 118,
119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119,
119, 120, 119, 119, 119, 119, 119, 120, 119, 119, 118, 119, 118, 118, 119, 118,
119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119,
119, 119, 119, 119, 119, 119, 118, 119, 120, 119, 119, 119, 118, 119, 120, 119,
118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 120, 120,
119, 119, 120, 120, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120, 118, 119, 119, 118, 120,
119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 118, 119, 120, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 120, 118, 119, 118, 119, 119, 119, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119,
120, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 118, 118, 118, 119, 119, 118, 119, 119, 119,
119, 120, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 120, 120, 119, 119,
120, 118, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 119, 119,
119, 119, 118, 120, 119, 119, 119, 120, 119, 119, 119, 118, 119, 120, 119, 119,
118, 120, 119, 120, 119, 120, 119, 120, 118, 120, 119, 120, 118, 120, 118, 121,
105, -54, -128, -115, -122, -117, -120, -117, -121, -118, -120, -119, -119,
-119, -120, -119, -120, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -118, -119, -119, -119, -120, -119, -120, -118,
-121, -52, };