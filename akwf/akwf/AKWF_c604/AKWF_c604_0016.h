#define DATA_LENGTH 512
#define DATA AKWF_c604_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {81, 124, 116, 121, 117, 120, 118, 120,
118, 119, 118, 120, 119, 119, 118, 120, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 119, 119, 119, 118, 118, 119, 119, 119, 120, 119, 119, 119, 119, 118,
119, 119, 119, 119, 118, 119, 120, 120, 119, 119, 119, 119, 119, 119, 118, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 118, 118, 118, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 119,
119, 119, 119, 118, 120, 119, 119, 118, 120, 119, 119, 119, 119, 118, 118, 119,
119, 119, 119, 119, 119, 119, 119, 120, 119, 120, 119, 119, 118, 120, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 119, 120, 119, 119,
120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119,
119, 119, 118, 119, 119, 119, 118, 119, 119, 118, 119, 119, 119, 119, 118, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 119, 119, 118, 119,
119, 118, 119, 119, 118, 119, 118, 120, 120, 119, 118, 119, 119, 119, 119, 119,
118, 119, 118, 119, 119, 118, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119,
120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 119,
120, 119, 120, 119, 120, 119, 120, 119, 119, 119, 119, 119, 120, 119, 119, 119,
118, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 119, 118, 120, 119, 119, 119, 120, 119, 119,
120, 118, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 120, 118, 118, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119,
120, 119, 119, 119, 119, 118, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119,
120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119,
119, 119, 118, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 120, 119, 120, 119, 118, 119, 120, 119, 119, 120, 119, 119, 119, 118, 120,
119, 120, 119, 119, 119, 119, 118, 119, 120, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 120, 118, 120, 118, 120, 119,
119, 118, 120, 120, 119, 120, 118, 120, 119, 121, 116, 122, 115, 124, 112, 127,
17, -118, -121, -117, -122, -115, -126, -101, };