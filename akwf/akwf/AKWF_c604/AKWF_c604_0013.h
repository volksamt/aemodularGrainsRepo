#define DATA_LENGTH 512
#define DATA AKWF_c604_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 1, 2, 3, 3, 5, 6, 7, 9, 10,
11, 13, 15, 16, 17, 18, 19, 20, 21, 22, 23, 25, 26, 25, 25, 27, 27, 28, 28, 29,
29, 31, 32, 33, 33, 34, 35, 36, 38, 39, 41, 42, 43, 44, 45, 47, 47, 48, 50, 50,
52, 52, 52, 53, 54, 55, 55, 57, 56, 57, 58, 59, 60, 60, 62, 63, 65, 65, 67, 68,
68, 69, 72, 73, 73, 75, 76, 77, 79, 80, 81, 83, 83, 85, 85, 87, 88, 89, 89, 90,
91, 92, 93, 93, 94, 95, 95, 97, 96, 98, 98, 99, 100, 101, 103, 103, 104, 106,
107, 109, 109, 111, 112, 113, 115, 116, 116, 117, 116, 118, 118, 118, 118, 118,
117, 116, 114, 114, 114, 112, 111, 110, 107, 107, 105, 105, 103, 102, 101, 100,
99, 99, 98, 98, 96, 96, 95, 95, 94, 93, 92, 92, 91, 89, 89, 87, 87, 85, 83, 83,
82, 80, 79, 78, 77, 76, 75, 73, 73, 72, 71, 71, 70, 69, 69, 69, 67, 66, 66, 65,
64, 63, 62, 61, 61, 59, 57, 57, 56, 55, 53, 51, 50, 49, 48, 46, 45, 45, 42, 42,
40, 40, 38, 37, 36, 35, 34, 33, 33, 32, 32, 29, 30, 29, 29, 28, 27, 26, 26, 25,
24, 24, 22, 21, 20, 19, 18, 17, 15, 14, 12, 11, 9, 8, 8, 7, 5, 5, 3, 2, 1, 1, 0,
0, 1, 0, 0, 0, 0, -1, 0, 0, -1, -2, -1, -2, -3, -4, -4, -6, -7, -8, -9, -10,
-12, -14, -14, -16, -17, -18, -19, -19, -20, -21, -22, -23, -23, -23, -25, -25,
-26, -26, -27, -28, -29, -31, -31, -33, -33, -34, -36, -37, -39, -40, -41, -42,
-44, -45, -45, -45, -47, -48, -48, -49, -50, -49, -51, -51, -52, -53, -55, -55,
-56, -57, -58, -59, -59, -61, -62, -64, -65, -67, -67, -68, -70, -71, -72, -73,
-74, -75, -75, -76, -76, -77, -77, -77, -78, -80, -81, -81, -82, -83, -84, -85,
-87, -88, -89, -90, -92, -92, -93, -95, -97, -98, -99, -101, -101, -102, -103,
-104, -105, -107, -108, -109, -111, -110, -112, -113, -114, -115, -115, -117,
-117, -118, -119, -118, -118, -120, -119, -119, -118, -118, -117, -117, -116,
-115, -114, -112, -111, -110, -108, -107, -106, -104, -104, -103, -101, -100,
-98, -98, -97, -96, -95, -94, -93, -91, -91, -90, -89, -87, -87, -86, -84, -83,
-82, -80, -79, -78, -76, -75, -74, -72, -71, -71, -69, -68, -68, -66, -65, -64,
-63, -62, -62, -62, -60, -60, -58, -58, -57, -56, -56, -55, -54, -54, -53, -52,
-52, -52, -51, -49, -49, -48, -48, -47, -46, -44, -44, -43, -41, -41, -40, -39,
-37, -36, -35, -33, -32, -32, -31, -29, -28, -27, -25, -24, -23, -22, -21, -20,
-19, -17, -17, -15, -14, -13, -11, -9, -9, -8, -6, -5, -4, -3, -2, -1, 0, 0, 0,
1, 2, 1, 1, 2, 2, 1, 1, 1, 1, 0, -1, 0, };