#define DATA_LENGTH 512
#define DATA AKWF_c604_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 115, 122, 116, 122, 117,
122, 117, 121, 117, 121, 118, 119, 119, 119, 119, 119, 118, 119, 119, 120, 120,
119, 119, 119, 120, 118, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 120, 120, 119, 120, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118,
119, 119, 118, 119, 118, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
120, 119, 119, 119, 119, 119, 119, 119, 118, 118, 119, 120, 118, 119, 119, 119,
119, 119, 118, 119, 118, 119, 119, 120, 118, 119, 118, 119, 118, 118, 119, 119,
119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119,
118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 118, 119,
119, 120, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 120, 119,
119, 120, 119, 119, 119, 119, 119, 118, 119, 119, 118, 119, 119, 118, 119, 119,
119, 119, 120, 119, 118, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 119,
119, 120, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 120, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 120, 120, 118,
119, 119, 120, 118, 120, 118, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 118, 119,
119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119,
119, 119, 120, 119, 119, 119, 119, 120, 120, 119, 119, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 120, 119, 119, 120, 119, 119,
119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 120, 119,
119, 119, 119, 120, 120, 119, 119, 118, 119, 119, 118, 119, 120, 118, 119, 119,
119, 119, 119, 119, 118, 118, 120, 120, 118, 119, 118, 120, 119, 119, 119, 119,
119, 120, 120, 120, 118, 118, 119, 119, 119, 118, 119, 119, 119, 118, 119, 118,
120, 119, 120, 119, 120, 119, 120, 118, 119, 118, 119, 118, 120, 118, 121, 118,
120, 119, 120, 117, -42, -127, -115, -123, -117, -121, -118, -121, -118, -120,
-119, -121, -118, -120, -119, -120, -120, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -120, -119, -120, -119, -120, -119,
-120, -118, -120, -118, -121, -118, -121, -117, -121, -117, -121, -117, -121,
-116, -122, -114, -5, };