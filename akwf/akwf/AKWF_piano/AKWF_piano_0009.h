#define DATA_LENGTH 512
#define DATA AKWF_piano_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 12, 23, 33, 43, 53, 61, 67, 75, 80,
86, 91, 95, 100, 103, 106, 109, 110, 112, 115, 117, 118, 119, 119, 119, 118,
117, 115, 112, 109, 105, 101, 96, 91, 85, 79, 73, 65, 59, 51, 46, 42, 39, 38,
37, 36, 35, 34, 32, 28, 23, 17, 12, 5, -1, -6, -10, -13, -15, -17, -18, -16,
-14, -12, -9, -7, -5, -3, -1, -1, 0, 1, 2, 2, 3, 3, 5, 6, 7, 7, 7, 7, 7, 8, 10,
13, 16, 21, 27, 33, 38, 42, 45, 47, 46, 43, 38, 34, 29, 24, 20, 17, 15, 14, 16,
19, 22, 28, 32, 37, 41, 46, 48, 48, 49, 47, 45, 43, 40, 38, 35, 30, 25, 21, 16,
11, 7, 2, -2, -7, -10, -12, -15, -16, -16, -16, -14, -12, -10, -8, -6, -5, -3,
-3, -3, -2, -1, -1, -1, -1, 0, 0, 2, 3, 4, 5, 5, 3, 3, 0, -3, -7, -12, -17, -24,
-30, -38, -44, -51, -55, -61, -64, -66, -65, -64, -60, -56, -50, -44, -39, -33,
-30, -26, -23, -21, -19, -14, -12, -6, -1, 4, 8, 12, 16, 17, 18, 18, 15, 10, 3,
-3, -11, -19, -27, -34, -40, -45, -50, -53, -54, -54, -55, -54, -52, -51, -50,
-49, -48, -48, -46, -44, -42, -39, -37, -35, -36, -37, -38, -42, -46, -49, -53,
-56, -56, -56, -55, -52, -47, -42, -37, -30, -22, -15, -7, 0, 7, 13, 19, 26, 31,
37, 41, 45, 48, 52, 55, 56, 57, 56, 54, 50, 47, 43, 39, 36, 34, 32, 30, 28, 27,
26, 24, 22, 19, 17, 15, 13, 13, 14, 16, 18, 20, 24, 29, 34, 39, 44, 48, 52, 54,
58, 60, 61, 61, 62, 61, 60, 59, 57, 55, 53, 51, 48, 44, 39, 33, 27, 22, 16, 10,
8, 5, 4, 4, 5, 5, 7, 7, 10, 11, 12, 13, 14, 15, 15, 16, 16, 16, 16, 15, 14, 13,
12, 9, 6, 2, -3, -7, -12, -14, -17, -18, -16, -15, -8, -2, 7, 16, 24, 30, 36,
41, 43, 45, 45, 46, 45, 43, 42, 41, 39, 37, 35, 33, 31, 30, 29, 29, 28, 27, 28,
28, 28, 28, 28, 28, 26, 24, 22, 21, 21, 20, 19, 18, 17, 17, 17, 16, 17, 18, 19,
20, 22, 23, 21, 21, 17, 12, 6, -1, -10, -19, -28, -36, -43, -51, -56, -62, -66,
-70, -76, -81, -85, -88, -90, -91, -91, -92, -91, -90, -89, -90, -90, -90, -92,
-93, -93, -93, -91, -89, -86, -84, -81, -77, -74, -72, -68, -66, -65, -63, -64,
-65, -68, -70, -72, -75, -76, -77, -75, -72, -67, -62, -56, -49, -44, -39, -36,
-33, -33, -34, -35, -38, -40, -43, -44, -47, -50, -53, -56, -59, -61, -62, -63,
-63, -61, -58, -56, -51, -48, -44, -40, -37, -34, -32, -30, -30, -32, -34, -39,
-43, -47, -49, -51, -51, -49, -47, -44, -39, -36, -31, -28, -26, -25, -22, -21,
-21, -20, -17, -14, -11, -4, 0, };