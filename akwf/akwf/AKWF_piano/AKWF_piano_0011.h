#define DATA_LENGTH 512
#define DATA AKWF_piano_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 8, 11, 14, 17, 18, 20, 20, 21,
21, 20, 20, 20, 19, 19, 19, 19, 21, 23, 24, 25, 27, 28, 30, 31, 32, 33, 32, 33,
32, 33, 33, 33, 34, 35, 37, 40, 44, 47, 50, 54, 59, 64, 68, 72, 76, 82, 85, 90,
92, 95, 97, 99, 101, 102, 102, 102, 101, 101, 102, 102, 102, 104, 106, 108, 110,
114, 117, 117, 119, 119, 118, 116, 114, 110, 107, 101, 98, 95, 91, 88, 85, 84,
82, 80, 79, 75, 72, 68, 62, 55, 48, 41, 33, 25, 19, 12, 5, 1, -4, -8, -10, -13,
-14, -16, -16, -16, -15, -15, -14, -13, -11, -9, -7, -5, -3, -3, -1, 0, 2, 4, 6,
9, 12, 15, 19, 23, 29, 32, 37, 41, 44, 47, 50, 51, 52, 52, 51, 50, 50, 48, 47,
46, 45, 45, 45, 46, 47, 47, 48, 50, 50, 52, 53, 54, 55, 55, 55, 55, 54, 52, 50,
47, 42, 39, 35, 30, 27, 25, 22, 22, 21, 22, 23, 23, 22, 22, 20, 18, 16, 12, 7,
2, -2, -6, -9, -12, -14, -15, -15, -17, -16, -16, -16, -16, -16, -17, -19, -20,
-22, -24, -28, -30, -34, -37, -39, -42, -45, -47, -50, -53, -56, -59, -62, -66,
-69, -72, -74, -78, -81, -83, -86, -88, -90, -93, -94, -97, -100, -102, -104,
-105, -109, -111, -113, -115, -116, -117, -117, -117, -116, -116, -113, -111,
-109, -107, -104, -103, -102, -100, -99, -99, -97, -97, -96, -95, -95, -95, -93,
-93, -91, -90, -89, -87, -85, -84, -83, -82, -80, -78, -76, -74, -71, -67, -64,
-59, -55, -51, -46, -40, -36, -31, -27, -23, -19, -15, -12, -9, -7, -5, -2, -1,
1, 2, 3, 6, 8, 9, 11, 12, 14, 14, 16, 16, 18, 18, 18, 19, 18, 18, 18, 18, 18,
18, 18, 18, 17, 18, 19, 20, 21, 22, 25, 26, 29, 30, 32, 33, 35, 35, 36, 38, 38,
39, 37, 38, 37, 37, 35, 33, 32, 31, 30, 30, 30, 30, 31, 33, 34, 36, 38, 40, 42,
42, 43, 43, 41, 39, 37, 35, 32, 28, 25, 22, 18, 16, 11, 9, 6, 3, 1, -3, -4, -8,
-9, -13, -15, -17, -19, -21, -22, -25, -26, -27, -28, -28, -28, -28, -27, -27,
-25, -22, -19, -17, -13, -10, -8, -4, -1, 2, 3, 6, 8, 9, 11, 12, 13, 14, 15, 16,
17, 17, 17, 19, 19, 19, 19, 20, 21, 21, 20, 21, 20, 20, 19, 17, 15, 15, 12, 10,
7, 5, 1, -2, -6, -9, -11, -15, -17, -20, -23, -25, -28, -30, -33, -36, -39, -42,
-45, -48, -50, -52, -55, -56, -57, -58, -60, -60, -59, -60, -60, -61, -62, -63,
-64, -65, -66, -66, -66, -64, -64, -63, -62, -58, -56, -55, -53, -51, -50, -49,
-49, -50, -50, -51, -51, -52, -51, -50, -49, -47, -45, -42, -41, -38, -36, -33,
-30, -27, -24, -22, -18, -16, -14, -11, -9, -7, -6, -4, -3, -2, -2, -1, };