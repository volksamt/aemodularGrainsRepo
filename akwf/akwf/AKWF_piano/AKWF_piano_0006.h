#define DATA_LENGTH 512
#define DATA AKWF_piano_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 7, 10, 12, 15, 16, 18, 20,
23, 26, 28, 31, 34, 36, 39, 42, 46, 48, 51, 55, 57, 60, 65, 67, 71, 74, 78, 81,
83, 88, 89, 93, 96, 99, 101, 104, 106, 108, 111, 112, 113, 115, 116, 117, 118,
118, 119, 120, 119, 118, 118, 117, 116, 114, 113, 112, 111, 108, 107, 105, 102,
101, 99, 96, 94, 92, 90, 88, 86, 84, 82, 81, 79, 77, 77, 75, 74, 73, 73, 71, 71,
70, 70, 69, 69, 68, 67, 67, 67, 67, 65, 65, 65, 64, 63, 62, 62, 60, 58, 57, 56,
54, 52, 49, 48, 46, 42, 41, 38, 36, 33, 29, 27, 23, 20, 16, 12, 9, 5, 2, -3, -6,
-11, -14, -18, -22, -25, -29, -33, -36, -40, -43, -46, -48, -52, -55, -57, -60,
-63, -65, -66, -68, -69, -70, -72, -72, -73, -73, -73, -73, -72, -72, -72, -70,
-70, -69, -67, -66, -64, -63, -61, -59, -58, -56, -55, -53, -51, -49, -48, -47,
-45, -45, -43, -43, -40, -40, -40, -39, -39, -39, -37, -38, -38, -38, -39, -39,
-39, -39, -40, -40, -41, -41, -42, -43, -43, -44, -45, -46, -46, -47, -48, -48,
-49, -49, -49, -49, -49, -49, -50, -48, -48, -47, -46, -45, -45, -43, -43, -40,
-40, -37, -35, -35, -31, -29, -27, -26, -23, -21, -18, -17, -14, -12, -9, -7,
-4, -3, 0, 1, 5, 6, 8, 10, 12, 14, 16, 17, 18, 19, 20, 22, 24, 24, 25, 26, 27,
28, 29, 30, 30, 32, 33, 34, 36, 36, 36, 38, 39, 41, 41, 42, 44, 46, 47, 49, 49,
52, 54, 55, 57, 59, 59, 61, 62, 64, 65, 67, 68, 69, 71, 72, 73, 74, 75, 75, 76,
75, 76, 77, 77, 78, 76, 76, 77, 75, 75, 75, 75, 74, 73, 73, 72, 70, 70, 69, 68,
66, 66, 65, 64, 63, 61, 60, 59, 58, 57, 56, 55, 54, 52, 51, 49, 48, 46, 45, 44,
42, 41, 40, 38, 37, 35, 35, 33, 32, 30, 28, 27, 26, 24, 22, 20, 19, 17, 15, 13,
11, 10, 7, 5, 2, 0, -3, -5, -9, -12, -14, -17, -21, -23, -27, -30, -33, -36,
-40, -42, -45, -47, -50, -53, -56, -59, -60, -63, -64, -67, -68, -69, -72, -72,
-73, -75, -76, -76, -76, -77, -77, -77, -77, -76, -77, -77, -77, -75, -75, -74,
-73, -74, -71, -71, -71, -71, -68, -68, -67, -66, -65, -65, -65, -64, -62, -62,
-62, -61, -60, -60, -61, -60, -60, -59, -59, -60, -60, -61, -60, -61, -60, -62,
-62, -63, -63, -64, -64, -64, -66, -66, -66, -66, -67, -66, -67, -66, -66, -66,
-66, -65, -65, -65, -64, -64, -63, -62, -61, -60, -58, -57, -56, -54, -53, -52,
-51, -49, -47, -46, -44, -42, -42, -40, -38, -37, -35, -34, -32, -32, -31, -29,
-28, -27, -26, -24, -23, -22, -22, -21, -19, -18, -18, -17, -15, -15, -14, -13,
-10, -9, -7, -5, -4, -2, -1, 0, };