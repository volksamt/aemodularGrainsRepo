#define DATA_LENGTH 512
#define DATA AKWF_piano_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 6, 8, 10, 11, 11, 11, 12, 11,
11, 11, 12, 11, 11, 12, 13, 14, 16, 20, 23, 26, 30, 33, 36, 40, 42, 44, 48, 49,
52, 55, 57, 58, 60, 62, 64, 66, 69, 73, 76, 80, 84, 88, 93, 97, 101, 106, 109,
112, 114, 117, 118, 119, 119, 119, 118, 119, 118, 117, 115, 115, 113, 112, 110,
108, 106, 103, 98, 94, 91, 85, 79, 75, 69, 63, 58, 52, 47, 42, 36, 32, 27, 24,
19, 17, 13, 11, 10, 8, 6, 6, 6, 7, 7, 7, 7, 9, 9, 9, 10, 11, 12, 12, 12, 11, 13,
13, 13, 15, 16, 17, 18, 20, 20, 22, 23, 24, 26, 27, 28, 30, 32, 34, 37, 39, 41,
43, 45, 46, 48, 50, 50, 52, 52, 52, 52, 52, 52, 53, 51, 51, 51, 50, 50, 49, 50,
48, 47, 46, 45, 44, 43, 40, 38, 35, 33, 31, 30, 26, 24, 23, 20, 19, 17, 15, 15,
16, 15, 16, 17, 19, 21, 21, 22, 23, 21, 20, 18, 15, 12, 10, 6, 1, -2, -6, -10,
-13, -15, -18, -21, -24, -26, -29, -32, -35, -37, -40, -42, -45, -49, -52, -56,
-58, -60, -65, -68, -71, -74, -78, -80, -83, -85, -86, -87, -87, -86, -85, -83,
-82, -81, -81, -82, -82, -84, -87, -90, -93, -96, -99, -101, -104, -105, -105,
-106, -107, -107, -107, -107, -107, -106, -107, -106, -105, -104, -102, -100,
-98, -95, -91, -87, -84, -79, -76, -72, -68, -66, -62, -61, -57, -55, -52, -48,
-45, -42, -39, -37, -34, -32, -30, -29, -27, -27, -25, -24, -23, -21, -18, -16,
-13, -10, -8, -5, -2, 1, 3, 4, 6, 7, 7, 10, 10, 12, 13, 14, 16, 17, 19, 20, 21,
22, 22, 22, 23, 23, 22, 22, 21, 20, 21, 21, 23, 22, 24, 25, 28, 30, 33, 36, 39,
42, 45, 48, 50, 52, 52, 53, 53, 52, 50, 48, 48, 46, 44, 43, 42, 42, 42, 43, 44,
44, 43, 42, 40, 36, 34, 29, 24, 19, 14, 7, 2, -2, -7, -10, -12, -13, -14, -14,
-15, -15, -15, -14, -14, -14, -14, -14, -15, -14, -15, -16, -16, -15, -16, -16,
-14, -14, -14, -12, -12, -11, -8, -6, -5, -2, 0, 3, 4, 7, 8, 11, 12, 13, 14, 15,
14, 12, 12, 12, 12, 12, 13, 14, 16, 17, 19, 19, 20, 20, 21, 18, 16, 14, 10, 5,
1, -4, -8, -13, -15, -19, -20, -22, -23, -25, -26, -26, -26, -28, -30, -31, -34,
-36, -39, -42, -44, -48, -49, -51, -53, -54, -55, -55, -55, -54, -54, -53, -53,
-52, -52, -52, -53, -54, -56, -58, -60, -63, -65, -67, -69, -70, -69, -70, -68,
-67, -66, -63, -60, -56, -53, -49, -46, -42, -39, -37, -34, -34, -32, -31, -30,
-29, -28, -29, -28, -27, -26, -25, -23, -23, -21, -18, -15, -13, -10, -8, -5,
-3, -2, -1, 0, 0, -1, -2, -2, -3, -3, -4, -3, -2, 0, 0, };