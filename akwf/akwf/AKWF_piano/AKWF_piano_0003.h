#define DATA_LENGTH 512
#define DATA AKWF_piano_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 9, 13, 16, 19, 21, 25, 29,
31, 34, 37, 39, 41, 42, 45, 45, 47, 49, 51, 53, 57, 61, 64, 70, 74, 79, 87, 92,
97, 104, 109, 113, 115, 117, 119, 118, 119, 118, 116, 113, 112, 110, 108, 107,
104, 105, 104, 103, 104, 105, 106, 108, 108, 110, 111, 111, 110, 109, 107, 105,
102, 98, 93, 90, 85, 80, 78, 73, 71, 66, 65, 63, 62, 60, 60, 58, 58, 58, 57, 55,
54, 51, 49, 46, 43, 39, 34, 30, 26, 23, 19, 16, 13, 11, 9, 8, 6, 6, 4, 4, 3, 3,
3, 2, 3, 1, 0, 1, 0, 0, -1, -2, -1, -3, -4, -5, -6, -7, -8, -10, -13, -15, -18,
-20, -24, -27, -30, -32, -34, -35, -37, -38, -38, -38, -38, -38, -38, -37, -37,
-36, -36, -36, -35, -35, -36, -36, -36, -37, -37, -38, -38, -40, -41, -43, -46,
-47, -51, -54, -56, -58, -59, -61, -61, -61, -62, -60, -58, -55, -53, -50, -48,
-45, -43, -42, -41, -41, -42, -44, -47, -50, -52, -56, -59, -61, -63, -64, -65,
-63, -62, -60, -59, -56, -52, -50, -47, -42, -40, -38, -36, -35, -34, -33, -34,
-33, -34, -36, -35, -35, -36, -35, -34, -32, -30, -28, -24, -21, -17, -13, -10,
-7, -4, -1, -1, 0, -1, -3, -5, -7, -9, -13, -15, -17, -20, -20, -20, -21, -19,
-17, -14, -12, -8, -5, -1, 2, 3, 5, 6, 7, 7, 7, 7, 6, 5, 4, 3, 0, -1, -4, -5,
-8, -10, -13, -17, -20, -23, -25, -28, -30, -33, -34, -34, -35, -34, -33, -32,
-32, -30, -28, -28, -28, -27, -28, -29, -29, -30, -32, -33, -34, -35, -35, -35,
-35, -34, -32, -31, -29, -26, -24, -22, -20, -19, -17, -17, -16, -15, -14, -13,
-11, -10, -9, -7, -4, -2, 1, 4, 8, 12, 15, 18, 22, 26, 28, 32, 34, 36, 38, 39,
41, 43, 43, 46, 48, 50, 52, 54, 57, 60, 63, 66, 70, 72, 75, 77, 78, 78, 77, 76,
73, 70, 67, 64, 62, 59, 57, 55, 55, 55, 57, 59, 63, 68, 72, 78, 83, 88, 91, 95,
97, 98, 98, 97, 94, 91, 86, 83, 78, 75, 71, 67, 65, 63, 62, 63, 64, 64, 65, 65,
65, 65, 64, 63, 61, 58, 54, 51, 47, 43, 39, 34, 32, 28, 26, 23, 21, 20, 18, 18,
17, 17, 16, 15, 14, 13, 11, 9, 7, 5, 0, -3, -8, -13, -18, -25, -30, -37, -44,
-50, -56, -60, -66, -69, -72, -74, -76, -77, -77, -76, -76, -75, -74, -72, -72,
-71, -70, -70, -70, -71, -73, -73, -75, -76, -78, -80, -81, -83, -84, -86, -87,
-88, -89, -90, -90, -91, -91, -92, -93, -95, -96, -96, -99, -100, -103, -103,
-105, -105, -106, -105, -104, -103, -99, -97, -93, -89, -85, -81, -77, -73, -69,
-66, -62, -59, -57, -54, -53, -50, -47, -46, -42, -40, -36, -34, -30, -27, -22,
-17, -13, -10, -6, -3, -1, };