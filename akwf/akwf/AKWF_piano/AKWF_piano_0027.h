#define DATA_LENGTH 512
#define DATA AKWF_piano_0027

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 6, 10, 14, 19, 24, 30, 36, 43,
51, 59, 66, 73, 80, 86, 92, 96, 99, 99, 100, 98, 97, 94, 91, 88, 84, 80, 77, 73,
70, 67, 62, 59, 56, 53, 49, 47, 45, 44, 42, 42, 40, 39, 40, 40, 39, 40, 39, 38,
37, 35, 31, 29, 25, 20, 17, 12, 7, 2, -3, -8, -14, -18, -22, -25, -28, -30, -30,
-31, -29, -27, -26, -24, -21, -18, -14, -12, -9, -7, -6, -4, -3, -1, -2, -1, 0,
0, 1, 1, 1, 2, 2, 3, 2, 0, 0, -3, -6, -9, -14, -18, -23, -27, -32, -35, -39,
-40, -41, -40, -39, -38, -35, -33, -30, -28, -26, -24, -22, -21, -21, -21, -23,
-24, -28, -31, -35, -40, -45, -48, -52, -54, -56, -58, -59, -58, -56, -53, -50,
-45, -39, -32, -26, -19, -12, -5, 3, 9, 14, 21, 27, 32, 37, 41, 46, 50, 52, 56,
58, 60, 62, 62, 62, 61, 59, 57, 54, 51, 47, 43, 39, 35, 32, 30, 28, 27, 26, 26,
28, 29, 33, 36, 40, 45, 49, 55, 59, 64, 67, 68, 69, 69, 69, 66, 65, 61, 56, 52,
48, 44, 39, 36, 31, 29, 26, 22, 21, 19, 16, 14, 12, 11, 10, 8, 6, 5, 3, 2, 2, 1,
1, 1, 2, 4, 5, 8, 10, 14, 17, 21, 25, 29, 33, 37, 40, 44, 47, 50, 53, 56, 59,
61, 63, 65, 68, 70, 72, 72, 74, 74, 76, 76, 76, 77, 76, 75, 73, 71, 69, 65, 61,
56, 52, 47, 42, 36, 31, 26, 20, 15, 12, 10, 7, 5, 4, 3, 3, 1, 1, 0, -1, -2, -3,
-4, -5, -7, -10, -12, -13, -15, -19, -21, -23, -25, -28, -32, -36, -38, -43,
-45, -47, -50, -53, -55, -57, -59, -61, -60, -62, -62, -62, -62, -60, -59, -56,
-52, -50, -47, -43, -39, -34, -31, -27, -22, -19, -16, -14, -10, -10, -9, -8,
-8, -8, -8, -7, -5, -4, -2, -1, 1, 3, 3, 5, 5, 6, 6, 5, 5, 5, 3, 3, 3, 3, 4, 5,
6, 7, 9, 9, 10, 10, 10, 10, 10, 11, 10, 10, 10, 9, 9, 8, 7, 6, 6, 7, 7, 6, 8, 9,
10, 11, 13, 14, 16, 17, 18, 20, 21, 22, 22, 22, 21, 19, 18, 16, 12, 10, 7, 4, 2,
-2, -5, -7, -9, -11, -15, -16, -17, -19, -19, -20, -20, -20, -19, -17, -17, -17,
-15, -15, -14, -14, -14, -16, -17, -18, -21, -24, -26, -31, -33, -37, -41, -43,
-47, -49, -51, -52, -53, -53, -52, -51, -49, -47, -46, -43, -42, -41, -40, -40,
-39, -39, -39, -39, -39, -39, -40, -40, -43, -43, -45, -49, -52, -56, -60, -67,
-72, -79, -84, -90, -96, -101, -105, -110, -113, -115, -118, -119, -119, -118,
-117, -116, -114, -110, -106, -102, -96, -90, -85, -78, -71, -64, -57, -52, -47,
-43, -40, -37, -36, -34, -34, -33, -32, -31, -31, -28, -27, -24, -19, -16, -11,
-6, -1, };