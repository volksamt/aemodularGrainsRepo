#define DATA_LENGTH 512
#define DATA AKWF_piano_0028

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 10, 11, 15, 18, 22, 24, 27,
31, 34, 37, 41, 44, 47, 50, 52, 54, 56, 59, 62, 64, 67, 68, 71, 73, 74, 76, 78,
79, 80, 81, 83, 84, 85, 86, 87, 86, 88, 89, 89, 89, 90, 90, 89, 90, 89, 90, 90,
89, 90, 89, 89, 90, 89, 88, 89, 89, 88, 88, 89, 89, 89, 91, 91, 92, 93, 95, 96,
98, 99, 101, 102, 104, 106, 108, 109, 110, 111, 113, 114, 116, 117, 118, 117,
118, 118, 119, 118, 119, 119, 119, 118, 117, 117, 117, 115, 113, 112, 110, 109,
107, 106, 103, 102, 100, 99, 97, 97, 95, 94, 95, 94, 95, 96, 96, 97, 97, 98, 98,
99, 101, 101, 101, 101, 102, 102, 101, 101, 100, 99, 97, 96, 93, 91, 88, 85, 81,
77, 71, 67, 61, 55, 49, 44, 36, 29, 22, 15, 8, 0, -6, -13, -20, -28, -33, -40,
-45, -51, -56, -60, -64, -68, -71, -73, -75, -78, -79, -80, -82, -82, -83, -84,
-85, -85, -86, -87, -88, -88, -89, -91, -91, -93, -94, -96, -96, -97, -98, -100,
-101, -102, -104, -104, -106, -107, -108, -108, -108, -109, -109, -110, -109,
-109, -109, -109, -108, -109, -108, -107, -107, -106, -105, -105, -105, -103,
-103, -101, -101, -99, -98, -96, -95, -93, -91, -89, -87, -85, -82, -79, -75,
-73, -70, -66, -64, -60, -56, -53, -49, -47, -44, -41, -40, -37, -35, -34, -33,
-31, -31, -31, -30, -30, -30, -30, -31, -31, -32, -32, -34, -35, -37, -38, -39,
-41, -42, -42, -44, -44, -45, -46, -46, -46, -45, -44, -43, -42, -40, -40, -37,
-36, -34, -32, -29, -27, -24, -23, -21, -18, -16, -14, -13, -10, -9, -7, -5, -4,
-3, -2, -2, -1, -1, 0, 0, 0, 0, 0, -1, 0, 0, -1, -2, -2, -2, -3, -4, -4, -3, -4,
-4, -4, -4, -4, -2, -2, -1, 0, 1, 2, 2, 3, 3, 5, 5, 5, 5, 5, 6, 5, 5, 4, 4, 4,
4, 4, 3, 3, 3, 4, 3, 4, 4, 3, 5, 4, 5, 6, 5, 5, 6, 5, 5, 7, 7, 6, 6, 6, 6, 5, 4,
4, 3, 3, 3, 2, 0, 0, -2, -2, -3, -5, -6, -9, -10, -11, -14, -15, -16, -18, -20,
-21, -21, -23, -23, -22, -23, -23, -22, -23, -21, -21, -20, -20, -19, -18, -18,
-17, -16, -15, -15, -14, -13, -13, -12, -11, -11, -9, -9, -8, -7, -6, -6, -4,
-5, -5, -4, -3, -3, -2, -3, -3, -3, -3, -4, -4, -5, -4, -6, -6, -6, -8, -9, -10,
-11, -12, -13, -15, -17, -18, -20, -22, -24, -26, -28, -31, -33, -35, -38, -41,
-43, -45, -47, -49, -51, -53, -54, -56, -56, -57, -59, -58, -58, -59, -58, -58,
-58, -57, -57, -56, -55, -54, -53, -52, -50, -50, -49, -48, -46, -45, -43, -43,
-41, -39, -39, -37, -36, -34, -34, -32, -30, -29, -27, -26, -23, -21, -20, -17,
-15, -12, -10, -7, -4, -1, };