#define DATA_LENGTH 512
#define DATA AKWF_piano_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 14, 19, 22, 24, 28, 31, 34,
35, 38, 40, 41, 42, 44, 46, 49, 50, 52, 55, 58, 61, 63, 66, 69, 71, 72, 72, 72,
74, 74, 73, 73, 74, 74, 73, 74, 75, 75, 76, 77, 79, 80, 82, 85, 88, 91, 94, 98,
100, 105, 108, 110, 113, 115, 118, 119, 119, 119, 118, 116, 114, 110, 106, 101,
96, 89, 83, 77, 70, 63, 57, 51, 44, 39, 35, 30, 26, 22, 18, 15, 13, 11, 8, 6, 5,
3, 1, -1, -3, -5, -7, -10, -13, -15, -17, -19, -21, -23, -24, -24, -25, -26,
-27, -27, -28, -28, -28, -28, -27, -27, -24, -23, -22, -20, -18, -17, -14, -13,
-12, -11, -11, -10, -10, -12, -12, -12, -13, -14, -15, -15, -15, -15, -15, -14,
-15, -14, -14, -13, -12, -11, -11, -12, -11, -11, -12, -13, -13, -14, -13, -15,
-17, -17, -19, -21, -22, -24, -27, -29, -31, -33, -35, -36, -37, -38, -37, -38,
-36, -35, -34, -32, -30, -29, -28, -27, -26, -26, -25, -24, -23, -23, -22, -22,
-21, -21, -21, -19, -18, -18, -16, -15, -14, -13, -11, -9, -8, -7, -5, -4, -2,
-2, 0, 1, 1, 3, 4, 5, 6, 7, 9, 8, 10, 10, 10, 10, 11, 10, 11, 10, 10, 10, 10,
11, 11, 11, 12, 14, 14, 16, 19, 20, 21, 24, 25, 27, 29, 29, 30, 30, 30, 30, 31,
30, 31, 32, 34, 35, 38, 40, 43, 46, 49, 52, 56, 58, 60, 61, 61, 62, 62, 61, 60,
56, 53, 50, 47, 42, 37, 32, 29, 23, 19, 14, 11, 7, 2, -1, -4, -6, -9, -12, -13,
-14, -15, -16, -15, -15, -15, -14, -13, -11, -10, -8, -7, -5, -2, 1, 3, 5, 8,
12, 13, 15, 18, 19, 19, 20, 20, 20, 19, 20, 18, 18, 17, 17, 16, 16, 14, 14, 12,
11, 10, 8, 6, 3, 1, -2, -4, -7, -10, -12, -15, -17, -19, -21, -21, -23, -24,
-24, -23, -23, -22, -21, -20, -20, -19, -19, -19, -18, -19, -21, -21, -22, -23,
-23, -24, -24, -24, -24, -24, -22, -22, -20, -20, -19, -19, -17, -17, -16, -16,
-16, -18, -19, -19, -21, -22, -22, -23, -23, -22, -21, -20, -19, -18, -15, -14,
-13, -12, -11, -12, -13, -14, -13, -15, -18, -20, -22, -25, -28, -31, -35, -39,
-41, -45, -48, -51, -53, -56, -58, -60, -62, -63, -64, -64, -63, -64, -61, -60,
-59, -56, -53, -50, -48, -45, -42, -40, -37, -34, -31, -27, -25, -22, -18, -16,
-13, -10, -7, -4, -1, 0, 2, 3, 4, 4, 4, 5, 6, 7, 8, 8, 8, 9, 9, 8, 8, 7, 8, 5,
3, 2, -1, -4, -7, -10, -14, -17, -20, -23, -25, -26, -29, -30, -30, -33, -32,
-34, -36, -37, -39, -42, -45, -47, -50, -53, -56, -58, -61, -62, -64, -64, -65,
-63, -63, -61, -59, -56, -54, -50, -47, -44, -40, -37, -33, -29, -27, -23, -18,
-14, -11, -5, -1, };