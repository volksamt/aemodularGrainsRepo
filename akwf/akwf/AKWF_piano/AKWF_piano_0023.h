#define DATA_LENGTH 512
#define DATA AKWF_piano_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 3, 5, 8, 10, 11, 15, 18, 20,
23, 26, 30, 33, 35, 38, 40, 45, 46, 48, 51, 53, 55, 57, 59, 63, 63, 66, 69, 72,
74, 77, 80, 82, 85, 88, 91, 94, 96, 98, 103, 104, 106, 110, 112, 114, 115, 117,
118, 119, 119, 118, 118, 116, 115, 112, 111, 107, 104, 101, 98, 96, 92, 89, 84,
80, 77, 73, 69, 65, 61, 58, 55, 51, 48, 44, 42, 39, 35, 33, 29, 27, 24, 21, 19,
16, 12, 9, 7, 5, 1, -1, -3, -5, -6, -8, -10, -10, -13, -13, -13, -15, -15, -15,
-16, -15, -15, -17, -16, -16, -16, -15, -16, -16, -16, -15, -16, -17, -18, -19,
-20, -22, -24, -27, -30, -33, -36, -38, -41, -44, -47, -51, -53, -56, -59, -61,
-64, -65, -68, -68, -70, -71, -72, -72, -71, -72, -72, -71, -70, -69, -68, -68,
-67, -65, -64, -63, -61, -59, -58, -56, -54, -53, -51, -50, -49, -48, -48, -48,
-47, -48, -48, -50, -51, -51, -54, -54, -56, -57, -59, -61, -62, -64, -66, -67,
-69, -70, -73, -73, -74, -76, -76, -78, -79, -80, -82, -82, -83, -84, -85, -85,
-87, -88, -89, -90, -91, -92, -94, -94, -93, -94, -94, -93, -93, -92, -92, -90,
-88, -86, -84, -81, -78, -75, -72, -70, -66, -63, -60, -57, -52, -50, -47, -44,
-40, -36, -32, -30, -26, -23, -20, -17, -13, -11, -7, -3, 1, 4, 8, 12, 17, 20,
25, 30, 34, 38, 42, 46, 49, 53, 56, 59, 62, 64, 67, 68, 72, 72, 73, 74, 74, 74,
74, 73, 72, 71, 70, 68, 67, 66, 64, 63, 61, 60, 57, 56, 54, 52, 51, 49, 48, 46,
44, 43, 41, 40, 38, 37, 36, 35, 34, 32, 31, 29, 29, 28, 27, 27, 27, 26, 26, 26,
27, 27, 28, 30, 31, 33, 33, 37, 37, 39, 42, 43, 45, 45, 47, 48, 48, 50, 51, 52,
52, 52, 53, 53, 54, 55, 54, 55, 55, 55, 55, 55, 55, 56, 56, 56, 56, 57, 57, 58,
59, 60, 60, 61, 60, 61, 61, 61, 60, 61, 60, 60, 59, 59, 57, 57, 55, 54, 53, 52,
51, 51, 49, 49, 49, 49, 48, 47, 48, 47, 47, 47, 46, 45, 44, 41, 39, 37, 35, 31,
28, 24, 20, 17, 14, 9, 6, 2, -1, -6, -10, -12, -15, -19, -21, -22, -24, -25,
-26, -25, -25, -25, -23, -22, -20, -18, -17, -16, -15, -13, -12, -12, -11, -11,
-12, -12, -13, -16, -18, -21, -24, -28, -31, -36, -40, -45, -49, -53, -57, -61,
-65, -68, -70, -73, -76, -77, -79, -80, -81, -82, -81, -83, -82, -83, -83, -83,
-84, -84, -84, -85, -85, -85, -85, -84, -84, -83, -83, -83, -82, -81, -80, -79,
-78, -76, -73, -71, -68, -66, -63, -58, -55, -52, -50, -46, -43, -40, -38, -35,
-32, -30, -28, -26, -25, -24, -21, -20, -18, -16, -16, -14, -14, -12, -11, -10,
-9, -9, -7, -6, -5, -2, -1, };