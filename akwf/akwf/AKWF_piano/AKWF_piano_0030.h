#define DATA_LENGTH 512
#define DATA AKWF_piano_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 2, 3, 3, 4, 5, 5, 6, 7, 8, 9,
11, 10, 11, 12, 14, 15, 15, 16, 17, 18, 19, 21, 22, 23, 24, 24, 26, 27, 29, 30,
30, 32, 32, 34, 36, 38, 39, 40, 41, 42, 44, 45, 47, 47, 49, 51, 52, 54, 55, 56,
58, 59, 61, 62, 64, 65, 66, 67, 68, 71, 71, 73, 74, 76, 76, 77, 80, 81, 82, 83,
84, 86, 87, 88, 90, 90, 92, 92, 94, 95, 96, 97, 98, 99, 99, 101, 102, 102, 103,
104, 105, 106, 106, 108, 108, 109, 110, 110, 111, 112, 112, 112, 112, 114, 114,
115, 115, 116, 115, 117, 117, 116, 117, 118, 118, 117, 118, 119, 118, 118, 119,
119, 120, 119, 119, 120, 120, 119, 118, 118, 118, 118, 119, 117, 118, 117, 117,
116, 116, 116, 115, 114, 114, 113, 113, 112, 112, 110, 110, 109, 108, 108, 108,
106, 105, 104, 103, 102, 101, 100, 99, 97, 97, 96, 94, 93, 92, 91, 89, 88, 87,
86, 84, 83, 81, 79, 78, 76, 76, 73, 72, 71, 69, 67, 66, 65, 62, 62, 60, 59, 57,
54, 53, 51, 49, 48, 47, 45, 42, 42, 40, 38, 36, 35, 33, 31, 29, 28, 26, 26, 23,
22, 20, 18, 17, 15, 14, 12, 11, 9, 8, 7, 4, 3, 1, 1, 0, -3, -4, -5, -6, -9, -10,
-11, -12, -14, -15, -16, -17, -19, -19, -22, -23, -23, -25, -26, -27, -29, -31,
-31, -32, -34, -34, -34, -36, -38, -38, -39, -41, -41, -42, -43, -44, -45, -46,
-47, -48, -48, -50, -50, -51, -52, -52, -53, -54, -55, -56, -56, -57, -58, -58,
-58, -60, -60, -61, -61, -62, -63, -63, -64, -65, -65, -66, -66, -67, -68, -68,
-69, -69, -71, -70, -71, -71, -73, -73, -73, -74, -74, -74, -75, -76, -77, -76,
-78, -78, -80, -80, -79, -80, -82, -82, -82, -83, -83, -83, -84, -84, -85, -85,
-85, -86, -87, -86, -88, -88, -88, -89, -89, -90, -90, -91, -91, -91, -92, -92,
-92, -92, -93, -93, -93, -93, -94, -95, -95, -94, -95, -95, -96, -95, -95, -95,
-95, -96, -95, -95, -95, -95, -96, -94, -95, -94, -94, -94, -94, -93, -94, -93,
-93, -93, -92, -92, -91, -91, -91, -91, -90, -89, -89, -89, -87, -88, -87, -86,
-86, -86, -85, -85, -85, -83, -83, -82, -81, -81, -80, -80, -79, -79, -78, -76,
-75, -76, -74, -74, -74, -72, -71, -72, -71, -69, -68, -68, -67, -66, -66, -65,
-64, -63, -62, -61, -60, -60, -59, -58, -57, -56, -55, -56, -54, -53, -52, -50,
-50, -49, -48, -48, -47, -46, -45, -45, -43, -43, -42, -41, -40, -39, -39, -37,
-38, -37, -35, -35, -34, -33, -32, -32, -31, -29, -30, -28, -28, -28, -26, -25,
-25, -24, -24, -23, -22, -22, -21, -21, -20, -20, -18, -17, -17, -17, -15, -15,
-15, -14, -14, -12, -12, -11, -11, -10, -9, -8, -8, -7, -7, -5, -5, -4, -2, -2,
-1, -1, };