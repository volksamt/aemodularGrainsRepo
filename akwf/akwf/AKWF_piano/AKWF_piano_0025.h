#define DATA_LENGTH 512
#define DATA AKWF_piano_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 6, 8, 9, 11, 12, 12, 13,
14, 15, 16, 17, 19, 19, 21, 21, 22, 23, 24, 25, 27, 28, 29, 29, 31, 32, 33, 34,
34, 36, 37, 38, 39, 40, 40, 42, 42, 43, 44, 45, 46, 47, 49, 49, 50, 51, 52, 53,
55, 55, 56, 57, 58, 59, 59, 60, 61, 63, 64, 65, 65, 66, 68, 69, 70, 70, 71, 72,
73, 74, 75, 76, 77, 78, 79, 80, 81, 81, 82, 84, 84, 85, 86, 86, 88, 89, 90, 91,
91, 91, 92, 94, 94, 96, 96, 97, 98, 98, 99, 99, 100, 101, 101, 102, 104, 104,
105, 106, 107, 107, 107, 107, 109, 109, 109, 110, 111, 111, 112, 112, 112, 112,
113, 113, 114, 115, 115, 116, 115, 116, 116, 116, 116, 117, 116, 117, 117, 117,
117, 118, 118, 118, 118, 118, 117, 117, 117, 117, 117, 117, 116, 117, 116, 116,
116, 116, 115, 115, 114, 114, 115, 114, 113, 112, 111, 112, 111, 110, 110, 109,
109, 107, 107, 107, 106, 106, 104, 105, 103, 103, 102, 101, 100, 100, 99, 98,
97, 96, 95, 95, 93, 92, 92, 90, 89, 88, 87, 85, 84, 84, 83, 82, 81, 79, 77, 76,
75, 74, 74, 72, 70, 69, 68, 66, 66, 63, 62, 60, 60, 57, 57, 56, 54, 52, 51, 50,
48, 46, 45, 44, 42, 41, 39, 37, 36, 35, 32, 31, 29, 27, 26, 24, 22, 21, 19, 18,
16, 14, 13, 12, 10, 8, 7, 4, 4, 1, 0, -2, -4, -6, -8, -9, -10, -13, -13, -16,
-18, -19, -21, -23, -25, -26, -27, -29, -30, -32, -34, -36, -37, -39, -41, -43,
-44, -45, -46, -48, -50, -52, -54, -55, -57, -57, -60, -61, -62, -64, -65, -67,
-68, -69, -71, -72, -74, -75, -76, -78, -79, -80, -81, -83, -83, -86, -86, -88,
-89, -90, -90, -92, -94, -93, -95, -96, -97, -98, -99, -100, -101, -101, -103,
-103, -104, -105, -105, -106, -106, -107, -109, -108, -109, -110, -111, -111,
-112, -112, -113, -113, -114, -114, -115, -115, -115, -116, -116, -116, -117,
-117, -118, -117, -118, -118, -118, -118, -119, -118, -119, -119, -119, -118,
-118, -119, -119, -119, -119, -120, -120, -119, -119, -118, -119, -119, -118,
-117, -119, -117, -117, -117, -116, -117, -116, -116, -116, -116, -114, -115,
-114, -114, -113, -113, -112, -112, -111, -111, -110, -109, -110, -108, -107,
-107, -107, -106, -105, -104, -104, -103, -103, -103, -100, -101, -99, -99, -98,
-97, -97, -95, -95, -94, -93, -92, -92, -90, -89, -88, -87, -87, -85, -85, -84,
-83, -81, -80, -80, -79, -78, -76, -76, -74, -73, -73, -71, -70, -69, -67, -67,
-66, -65, -64, -63, -61, -61, -60, -58, -57, -56, -54, -53, -52, -51, -50, -48,
-48, -47, -45, -44, -42, -42, -41, -39, -38, -38, -35, -35, -34, -32, -32, -29,
-29, -28, -26, -24, -24, -22, -21, -20, -20, -19, -17, -16, -15, -14, -13, -11,
-9, -9, -8, -6, -6, -3, -1, -1, };