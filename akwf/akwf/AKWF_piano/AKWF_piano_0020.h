#define DATA_LENGTH 512
#define DATA AKWF_piano_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 1, 3, 4, 5, 6, 6, 8, 8, 10, 10,
12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 24, 25, 26, 27, 28, 29, 31, 31, 32,
34, 36, 37, 37, 39, 40, 40, 42, 43, 44, 45, 46, 47, 48, 49, 50, 50, 52, 53, 53,
54, 55, 56, 57, 58, 59, 59, 59, 60, 62, 61, 61, 63, 64, 63, 65, 65, 65, 66, 65,
67, 67, 68, 68, 68, 68, 69, 69, 69, 70, 69, 70, 71, 71, 71, 71, 71, 72, 72, 71,
72, 72, 71, 72, 73, 73, 72, 73, 73, 72, 74, 73, 74, 73, 74, 74, 74, 74, 74, 74,
75, 74, 75, 75, 75, 75, 76, 76, 75, 76, 75, 76, 76, 77, 77, 77, 77, 78, 78, 77,
79, 78, 78, 79, 79, 79, 80, 80, 81, 82, 82, 82, 82, 83, 84, 84, 84, 85, 85, 86,
87, 86, 87, 87, 88, 89, 88, 89, 90, 90, 90, 90, 91, 92, 92, 92, 92, 93, 93, 92,
94, 93, 94, 93, 94, 94, 94, 94, 94, 95, 94, 94, 94, 94, 93, 93, 93, 92, 93, 93,
91, 91, 91, 91, 90, 90, 89, 89, 88, 87, 87, 86, 85, 85, 84, 83, 83, 82, 82, 81,
80, 79, 79, 78, 76, 76, 76, 75, 73, 73, 72, 71, 69, 69, 68, 68, 67, 66, 64, 64,
62, 61, 61, 60, 58, 58, 57, 56, 55, 54, 52, 52, 50, 50, 48, 47, 46, 44, 44, 43,
41, 40, 39, 37, 36, 34, 33, 31, 31, 29, 27, 25, 25, 23, 21, 20, 18, 17, 15, 13,
12, 10, 9, 7, 5, 4, 3, 1, 0, -3, -3, -6, -7, -9, -10, -11, -13, -15, -16, -18,
-19, -21, -23, -24, -25, -26, -28, -29, -31, -31, -34, -33, -35, -36, -38, -39,
-39, -41, -42, -43, -44, -45, -46, -46, -48, -49, -50, -51, -52, -52, -53, -55,
-54, -56, -57, -58, -59, -60, -61, -63, -64, -64, -66, -66, -68, -68, -70, -70,
-72, -72, -73, -75, -75, -77, -78, -79, -80, -81, -83, -83, -85, -86, -87, -89,
-89, -91, -92, -93, -94, -96, -97, -97, -99, -100, -101, -102, -103, -104, -105,
-107, -108, -107, -109, -110, -111, -111, -113, -114, -114, -114, -115, -115,
-115, -116, -117, -117, -118, -118, -118, -118, -118, -118, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -118, -118, -118, -117, -117, -116, -116,
-115, -115, -114, -113, -113, -111, -111, -110, -110, -109, -107, -107, -106,
-104, -104, -103, -101, -100, -99, -98, -98, -97, -94, -93, -93, -91, -90, -89,
-87, -86, -84, -82, -82, -79, -79, -77, -76, -75, -73, -72, -71, -69, -68, -65,
-64, -63, -62, -60, -59, -57, -56, -55, -54, -53, -51, -50, -49, -48, -46, -44,
-44, -42, -41, -40, -38, -37, -37, -35, -35, -33, -33, -31, -31, -30, -28, -27,
-26, -25, -24, -23, -22, -22, -21, -20, -19, -19, -17, -17, -16, -14, -14, -13,
-12, -11, -10, -8, -8, -7, -6, -4, -3, -3, -1, };