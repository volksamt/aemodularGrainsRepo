#define DATA_LENGTH 512
#define DATA AKWF_piano_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 9, 13, 16, 20, 25, 28, 33,
37, 41, 45, 49, 53, 56, 60, 63, 67, 71, 73, 76, 80, 83, 86, 88, 91, 93, 97, 99,
102, 105, 107, 110, 112, 114, 117, 118, 118, 119, 118, 118, 118, 116, 114, 112,
110, 108, 105, 104, 102, 99, 97, 95, 94, 93, 92, 92, 92, 92, 92, 92, 92, 92, 92,
91, 90, 87, 84, 81, 78, 74, 71, 68, 63, 61, 59, 56, 54, 52, 51, 49, 47, 45, 44,
42, 39, 37, 34, 31, 27, 23, 20, 16, 11, 6, 2, -2, -7, -10, -14, -16, -19, -22,
-23, -25, -25, -26, -26, -26, -25, -24, -24, -22, -21, -20, -18, -17, -15, -12,
-12, -10, -9, -7, -5, -5, -4, -3, -2, -2, -1, -1, -1, -2, -3, -4, -7, -9, -12,
-15, -17, -21, -25, -28, -33, -34, -39, -42, -46, -48, -52, -55, -58, -61, -64,
-67, -70, -73, -74, -76, -78, -80, -81, -82, -84, -85, -87, -86, -88, -90, -91,
-91, -92, -93, -93, -93, -93, -94, -94, -94, -93, -93, -93, -93, -93, -93, -94,
-94, -94, -94, -95, -96, -94, -95, -95, -95, -94, -93, -91, -88, -85, -82, -77,
-72, -68, -63, -57, -51, -46, -40, -36, -31, -27, -24, -19, -15, -12, -9, -4,
-2, 2, 5, 9, 12, 15, 18, 20, 22, 23, 25, 27, 27, 28, 30, 30, 31, 32, 33, 33, 34,
34, 35, 35, 36, 38, 40, 41, 42, 44, 45, 47, 49, 51, 52, 54, 55, 56, 58, 59, 60,
62, 62, 63, 64, 63, 63, 62, 61, 59, 57, 55, 50, 47, 44, 40, 36, 31, 27, 23, 19,
14, 10, 5, 1, -3, -8, -12, -16, -19, -24, -28, -31, -35, -38, -42, -46, -50,
-52, -56, -58, -61, -63, -64, -66, -66, -67, -67, -66, -66, -66, -65, -64, -63,
-63, -62, -60, -59, -58, -56, -54, -52, -50, -46, -43, -40, -38, -35, -32, -29,
-26, -26, -24, -23, -22, -21, -22, -22, -22, -22, -22, -20, -19, -18, -16, -13,
-10, -6, -1, 2, 8, 12, 16, 20, 24, 27, 30, 32, 32, 33, 33, 31, 30, 28, 26, 24,
22, 18, 15, 12, 9, 5, 3, 1, -2, -3, -5, -7, -9, -10, -11, -11, -10, -12, -10,
-10, -11, -11, -10, -11, -11, -12, -13, -14, -15, -16, -19, -21, -22, -24, -25,
-26, -27, -26, -27, -26, -25, -22, -22, -20, -19, -17, -16, -13, -12, -11, -9,
-8, -8, -6, -5, -3, -2, -2, -1, -1, -1, -1, -2, -4, -4, -5, -7, -8, -10, -11,
-12, -14, -14, -14, -16, -14, -16, -15, -14, -13, -13, -11, -10, -7, -7, -5, -4,
-2, -2, -2, -2, -2, -2, -4, -4, -5, -5, -6, -7, -7, -7, -6, -6, -4, -4, -3, -2,
-1, 0, 1, 1, 1, 1, 0, -1, -2, -5, -8, -11, -15, -19, -24, -27, -32, -35, -38,
-41, -44, -45, -46, -47, -46, -47, -46, -44, -42, -41, -38, -36, -33, -30, -25,
-20, -17, -12, -7, -2, };