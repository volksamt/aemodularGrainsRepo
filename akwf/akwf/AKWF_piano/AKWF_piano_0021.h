#define DATA_LENGTH 512
#define DATA AKWF_piano_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 2, 2, 3, 3, 3, 4, 5, 6, 6, 8, 7,
8, 8, 9, 10, 11, 11, 12, 13, 14, 15, 15, 16, 17, 19, 19, 21, 21, 23, 24, 24, 26,
26, 27, 29, 30, 30, 31, 33, 34, 35, 36, 37, 38, 40, 41, 43, 44, 44, 47, 47, 48,
49, 51, 52, 53, 54, 55, 56, 58, 60, 60, 61, 62, 64, 64, 65, 66, 68, 68, 70, 71,
71, 72, 73, 74, 76, 76, 78, 79, 80, 80, 81, 82, 82, 83, 84, 85, 85, 87, 87, 88,
89, 89, 90, 91, 91, 92, 94, 93, 95, 95, 96, 97, 97, 98, 98, 99, 99, 101, 100,
102, 103, 103, 103, 103, 104, 105, 105, 106, 107, 107, 108, 107, 109, 109, 110,
110, 111, 111, 111, 112, 113, 112, 113, 114, 114, 115, 115, 116, 116, 115, 116,
117, 117, 116, 117, 117, 117, 119, 119, 118, 118, 118, 119, 119, 119, 118, 118,
119, 119, 119, 118, 120, 119, 118, 119, 119, 119, 119, 118, 119, 117, 117, 117,
118, 117, 117, 116, 117, 116, 116, 115, 116, 115, 115, 113, 113, 113, 113, 112,
113, 111, 111, 111, 111, 109, 109, 108, 108, 108, 107, 106, 105, 104, 103, 103,
102, 101, 102, 101, 100, 99, 99, 98, 97, 97, 96, 95, 94, 93, 93, 91, 90, 89, 89,
88, 87, 86, 86, 85, 83, 82, 82, 80, 80, 79, 78, 77, 76, 75, 74, 74, 72, 71, 70,
69, 68, 66, 66, 63, 64, 61, 61, 59, 58, 58, 57, 55, 54, 52, 52, 50, 49, 48, 47,
46, 44, 44, 42, 41, 40, 40, 38, 37, 35, 35, 33, 32, 31, 29, 28, 27, 26, 26, 24,
23, 22, 20, 19, 18, 17, 15, 14, 14, 12, 12, 10, 10, 8, 7, 6, 4, 4, 2, 1, 0, -1,
-2, -2, -5, -6, -7, -8, -9, -10, -11, -12, -13, -14, -15, -16, -17, -18, -19,
-20, -21, -22, -23, -23, -25, -25, -27, -28, -29, -29, -30, -31, -32, -32, -33,
-34, -35, -35, -36, -37, -38, -39, -39, -40, -41, -41, -41, -43, -43, -43, -44,
-44, -46, -46, -46, -47, -48, -47, -48, -49, -49, -50, -50, -50, -50, -51, -51,
-52, -52, -52, -53, -53, -53, -54, -53, -54, -54, -55, -54, -55, -55, -55, -56,
-56, -56, -56, -56, -57, -57, -57, -57, -57, -57, -57, -56, -57, -57, -57, -56,
-57, -57, -57, -56, -56, -57, -57, -56, -57, -57, -56, -56, -56, -55, -55, -55,
-55, -55, -55, -54, -53, -54, -53, -53, -52, -52, -51, -51, -50, -50, -50, -49,
-47, -48, -47, -47, -46, -45, -44, -44, -43, -42, -41, -41, -41, -39, -38, -38,
-37, -36, -36, -35, -34, -33, -32, -31, -30, -29, -29, -28, -26, -26, -26, -24,
-25, -23, -22, -22, -21, -20, -20, -19, -18, -18, -16, -16, -15, -15, -14, -14,
-13, -11, -11, -11, -10, -10, -9, -8, -7, -7, -8, -6, -6, -5, -5, -5, -4, -3,
-3, -3, -2, -1, -1, 0, 0, };