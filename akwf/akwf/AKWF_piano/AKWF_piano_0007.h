#define DATA_LENGTH 512
#define DATA AKWF_piano_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 7, 9, 13, 15, 17, 20, 22, 25,
28, 31, 36, 39, 43, 46, 49, 52, 54, 56, 56, 56, 56, 56, 56, 55, 56, 58, 61, 63,
67, 73, 78, 84, 91, 98, 103, 110, 114, 117, 118, 118, 118, 114, 110, 104, 98,
92, 85, 77, 71, 64, 56, 48, 40, 34, 27, 22, 18, 15, 12, 10, 9, 8, 7, 6, 6, 5, 6,
7, 8, 10, 11, 14, 14, 15, 15, 14, 12, 8, 3, -2, -7, -12, -16, -21, -23, -26,
-28, -30, -30, -31, -30, -29, -26, -23, -16, -10, -3, 5, 13, 21, 30, 36, 42, 48,
53, 55, 58, 59, 60, 62, 63, 65, 67, 69, 70, 71, 72, 73, 73, 72, 69, 66, 63, 58,
52, 45, 39, 32, 27, 22, 18, 14, 12, 11, 10, 9, 8, 8, 7, 6, 6, 5, 5, 6, 7, 8, 9,
9, 7, 4, -1, -6, -12, -19, -23, -28, -31, -32, -32, -29, -28, -25, -21, -19,
-16, -16, -16, -15, -15, -16, -16, -15, -15, -15, -15, -13, -13, -13, -14, -15,
-17, -19, -22, -26, -29, -32, -36, -39, -42, -44, -45, -46, -45, -44, -41, -38,
-34, -30, -27, -22, -19, -14, -11, -9, -7, -5, -6, -6, -7, -9, -11, -13, -15,
-18, -20, -22, -24, -26, -28, -30, -31, -33, -34, -36, -37, -37, -37, -35, -35,
-32, -28, -26, -25, -24, -22, -21, -21, -21, -22, -23, -22, -22, -20, -17, -14,
-11, -8, -6, -2, -1, -2, -3, -5, -8, -13, -17, -21, -24, -26, -26, -26, -23,
-19, -15, -10, -5, -1, 3, 7, 11, 13, 16, 18, 22, 25, 29, 33, 38, 44, 48, 51, 55,
57, 59, 59, 59, 57, 56, 55, 54, 52, 50, 49, 46, 45, 45, 44, 42, 42, 41, 41, 40,
40, 38, 37, 36, 35, 32, 29, 25, 21, 17, 11, 5, -1, -6, -10, -16, -20, -25, -30,
-32, -36, -36, -37, -35, -32, -26, -20, -13, -4, 3, 11, 18, 23, 27, 30, 32, 31,
30, 29, 27, 27, 25, 24, 24, 25, 26, 27, 28, 27, 27, 25, 22, 18, 13, 6, 0, -7,
-16, -21, -26, -28, -26, -24, -20, -14, -8, 0, 5, 11, 16, 19, 23, 26, 28, 31,
33, 33, 35, 36, 35, 34, 33, 30, 29, 28, 26, 25, 24, 24, 23, 21, 19, 16, 13, 11,
7, 4, 0, -4, -7, -10, -15, -18, -22, -27, -29, -32, -33, -35, -34, -33, -33,
-33, -34, -35, -38, -42, -48, -54, -60, -68, -75, -83, -91, -98, -104, -108,
-110, -110, -109, -107, -103, -99, -94, -88, -84, -79, -74, -69, -65, -63, -60,
-58, -58, -56, -56, -55, -56, -55, -57, -58, -61, -63, -67, -71, -74, -78, -81,
-82, -84, -83, -81, -77, -72, -67, -60, -52, -43, -35, -29, -23, -19, -16, -13,
-11, -9, -8, -7, -7, -5, -4, -3, -2, 0, 0, 0, -1, -2, -4, -6, -9, -13, -16, -20,
-25, -30, -34, -37, -40, -41, -41, -39, -34, -30, -24, -17, -10, -4, };