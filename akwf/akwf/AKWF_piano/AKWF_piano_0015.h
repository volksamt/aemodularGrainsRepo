#define DATA_LENGTH 512
#define DATA AKWF_piano_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 4, 5, 6, 6, 7, 7, 8, 8,
10, 9, 11, 11, 11, 12, 13, 12, 13, 14, 13, 14, 14, 14, 15, 16, 15, 15, 15, 16,
16, 16, 16, 15, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 15, 16, 16, 16, 16,
16, 15, 16, 16, 15, 16, 15, 16, 15, 16, 15, 15, 16, 16, 16, 15, 17, 17, 17, 16,
18, 17, 17, 18, 19, 18, 19, 20, 20, 21, 20, 22, 22, 23, 24, 24, 25, 26, 27, 27,
28, 29, 29, 31, 32, 33, 34, 34, 36, 37, 37, 38, 40, 41, 41, 42, 43, 45, 45, 47,
47, 47, 49, 51, 51, 51, 52, 53, 54, 54, 55, 55, 55, 57, 57, 56, 57, 57, 58, 59,
58, 59, 59, 59, 60, 60, 59, 60, 60, 60, 59, 60, 60, 60, 60, 60, 60, 60, 60, 61,
61, 62, 62, 62, 63, 63, 64, 64, 65, 65, 66, 66, 67, 69, 69, 70, 70, 72, 73, 74,
75, 77, 78, 79, 80, 82, 83, 84, 86, 86, 88, 89, 91, 93, 94, 95, 96, 98, 99, 100,
101, 102, 104, 105, 106, 106, 108, 109, 109, 109, 110, 112, 111, 112, 113, 113,
113, 113, 114, 113, 114, 113, 113, 113, 113, 112, 112, 111, 112, 110, 110, 109,
109, 108, 107, 106, 105, 105, 104, 104, 102, 101, 101, 100, 98, 98, 96, 95, 94,
93, 91, 91, 90, 88, 87, 87, 86, 84, 84, 82, 81, 80, 79, 77, 76, 75, 73, 72, 70,
69, 68, 66, 65, 64, 62, 61, 59, 57, 55, 54, 53, 51, 48, 46, 45, 43, 40, 39, 37,
35, 33, 30, 29, 27, 25, 22, 20, 18, 15, 13, 11, 9, 6, 4, 2, -1, -3, -5, -8, -10,
-12, -15, -18, -19, -22, -24, -27, -30, -32, -33, -36, -39, -41, -43, -45, -47,
-49, -52, -53, -56, -57, -59, -62, -63, -65, -67, -69, -71, -73, -75, -76, -78,
-80, -82, -84, -85, -86, -88, -89, -92, -93, -94, -96, -97, -99, -100, -101,
-103, -104, -105, -105, -106, -108, -109, -110, -110, -111, -112, -113, -114,
-114, -115, -115, -116, -116, -118, -117, -118, -118, -119, -118, -119, -119,
-118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -118, -117, -118,
-118, -116, -117, -116, -117, -116, -115, -115, -115, -114, -113, -113, -112,
-111, -110, -111, -110, -110, -108, -107, -106, -105, -105, -104, -104, -102,
-102, -101, -99, -98, -97, -96, -95, -95, -93, -92, -91, -90, -89, -87, -87,
-85, -84, -83, -82, -80, -80, -78, -77, -76, -74, -73, -72, -70, -70, -68, -67,
-66, -65, -63, -63, -61, -60, -59, -58, -57, -57, -55, -54, -54, -52, -51, -50,
-50, -49, -48, -47, -46, -45, -44, -44, -43, -41, -41, -40, -39, -38, -37, -36,
-35, -35, -33, -32, -32, -31, -30, -29, -27, -27, -26, -25, -23, -22, -22, -21,
-19, -18, -17, -16, -15, -14, -14, -12, -11, -10, -8, -8, -7, -6, -5, -4, -3,
-2, 0, };