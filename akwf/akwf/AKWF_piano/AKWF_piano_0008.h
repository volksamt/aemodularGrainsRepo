#define DATA_LENGTH 512
#define DATA AKWF_piano_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 12, 18, 27, 35, 41, 48, 55, 59, 65,
68, 68, 68, 67, 66, 63, 61, 58, 57, 58, 59, 62, 65, 69, 75, 80, 85, 91, 96, 102,
105, 109, 112, 115, 117, 118, 119, 119, 119, 118, 116, 113, 110, 106, 101, 95,
89, 82, 73, 66, 57, 51, 44, 39, 34, 29, 27, 24, 21, 20, 16, 13, 8, 3, -1, -4,
-8, -10, -11, -14, -16, -17, -19, -20, -22, -24, -27, -28, -30, -31, -31, -31,
-29, -27, -22, -17, -9, -2, 6, 12, 19, 25, 28, 31, 32, 32, 32, 32, 32, 35, 38,
42, 46, 51, 54, 57, 60, 61, 61, 62, 61, 60, 59, 59, 57, 55, 51, 46, 41, 35, 29,
23, 19, 16, 15, 14, 15, 18, 21, 23, 26, 28, 29, 30, 30, 29, 27, 24, 20, 15, 11,
6, 3, 1, -1, -1, 0, 0, 1, 0, -3, -7, -13, -19, -22, -27, -30, -31, -31, -30,
-25, -22, -19, -15, -13, -14, -14, -16, -18, -19, -21, -21, -21, -22, -21, -21,
-22, -24, -24, -26, -28, -31, -33, -34, -36, -37, -37, -38, -36, -35, -33, -31,
-29, -28, -26, -25, -22, -21, -21, -20, -20, -20, -19, -19, -18, -18, -18, -19,
-21, -22, -25, -29, -32, -37, -40, -43, -44, -44, -42, -40, -36, -32, -28, -24,
-20, -17, -15, -12, -10, -8, -7, -7, -8, -8, -12, -16, -20, -25, -30, -33, -37,
-40, -41, -42, -41, -39, -36, -34, -33, -32, -34, -34, -34, -36, -37, -38, -38,
-36, -34, -30, -24, -16, -8, 2, 12, 23, 33, 42, 52, 59, 66, 72, 78, 84, 89, 91,
93, 94, 93, 90, 85, 79, 73, 64, 56, 47, 39, 32, 28, 24, 25, 23, 25, 26, 27, 26,
25, 23, 19, 16, 12, 11, 9, 8, 10, 12, 16, 21, 25, 31, 36, 41, 42, 43, 42, 38,
34, 29, 23, 17, 11, 6, 4, 2, 1, 1, 2, 4, 7, 10, 15, 16, 20, 21, 24, 25, 26, 24,
24, 21, 18, 15, 12, 9, 6, 3, -1, -3, -5, -6, -7, -7, -8, -7, -7, -7, -6, -5, -3,
-2, -2, -2, -1, 0, 1, 2, 4, 8, 12, 18, 24, 31, 38, 44, 51, 56, 62, 68, 72, 74,
74, 73, 69, 62, 56, 45, 34, 22, 11, 0, -9, -16, -21, -23, -25, -24, -21, -17,
-13, -9, -6, -4, -2, 0, 0, -2, -5, -8, -11, -16, -21, -26, -30, -34, -38, -42,
-46, -50, -54, -60, -66, -72, -78, -84, -89, -94, -97, -99, -102, -104, -105,
-104, -104, -102, -101, -99, -97, -96, -93, -91, -88, -87, -85, -84, -82, -82,
-82, -82, -82, -83, -85, -86, -87, -87, -87, -88, -87, -87, -87, -85, -82, -78,
-73, -67, -62, -56, -51, -46, -41, -40, -36, -35, -34, -32, -30, -29, -25, -21,
-18, -15, -11, -9, -7, -6, -8, -10, -13, -17, -23, -28, -34, -41, -48, -55, -60,
-65, -66, -66, -66, -64, -61, -57, -52, -48, -43, -38, -33, -27, -20, -14, -6,
0, };