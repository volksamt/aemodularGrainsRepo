#define DATA_LENGTH 512
#define DATA AKWF_piano_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 13, 19, 24, 30, 36, 41, 46, 51,
54, 59, 62, 65, 69, 72, 75, 78, 82, 86, 91, 95, 98, 102, 105, 108, 111, 114,
116, 116, 118, 119, 118, 119, 120, 119, 119, 119, 119, 118, 118, 118, 117, 116,
114, 112, 109, 107, 103, 99, 94, 89, 84, 79, 73, 67, 62, 55, 49, 43, 37, 32, 27,
21, 17, 12, 8, 4, 1, -1, -5, -8, -11, -13, -17, -21, -24, -28, -32, -36, -41,
-44, -48, -49, -52, -53, -54, -54, -54, -53, -51, -51, -50, -50, -49, -47, -45,
-45, -44, -43, -41, -40, -38, -36, -34, -30, -27, -22, -19, -15, -10, -4, 0, 6,
11, 16, 23, 28, 33, 38, 44, 50, 55, 59, 63, 68, 70, 74, 76, 78, 80, 81, 82, 80,
80, 77, 76, 74, 69, 66, 61, 58, 54, 50, 47, 43, 41, 38, 35, 33, 31, 30, 28, 27,
28, 27, 26, 26, 26, 25, 25, 23, 23, 22, 21, 19, 19, 19, 18, 18, 20, 21, 23, 26,
28, 31, 34, 37, 39, 43, 45, 47, 49, 49, 49, 49, 49, 47, 46, 45, 42, 40, 37, 33,
30, 25, 21, 16, 12, 6, 1, -4, -9, -14, -21, -26, -32, -39, -44, -50, -56, -61,
-66, -71, -77, -80, -85, -88, -91, -93, -94, -94, -94, -94, -91, -90, -87, -84,
-81, -77, -73, -69, -65, -60, -56, -52, -47, -45, -41, -37, -34, -31, -28, -26,
-23, -20, -17, -15, -13, -10, -9, -8, -8, -7, -9, -11, -13, -16, -19, -23, -27,
-31, -34, -37, -41, -43, -46, -48, -50, -52, -55, -57, -59, -60, -62, -62, -64,
-65, -65, -66, -66, -65, -65, -65, -66, -64, -64, -64, -64, -63, -63, -62, -62,
-60, -60, -58, -56, -57, -55, -54, -53, -52, -50, -49, -47, -45, -43, -41, -38,
-35, -33, -30, -26, -24, -22, -20, -18, -16, -16, -15, -15, -15, -15, -15, -16,
-17, -16, -18, -18, -17, -19, -19, -20, -19, -19, -20, -20, -20, -19, -19, -19,
-18, -17, -17, -16, -16, -16, -16, -15, -16, -17, -17, -18, -20, -20, -23, -25,
-27, -30, -32, -34, -37, -41, -43, -46, -48, -49, -51, -51, -51, -51, -49, -47,
-43, -40, -36, -33, -27, -23, -18, -14, -9, -5, 0, 4, 7, 11, 15, 19, 22, 25, 28,
31, 33, 36, 37, 39, 40, 40, 40, 41, 39, 39, 37, 36, 33, 31, 29, 26, 24, 20, 16,
13, 9, 5, 1, -3, -7, -10, -13, -16, -19, -22, -25, -28, -30, -31, -33, -34, -34,
-34, -34, -32, -30, -28, -25, -21, -17, -13, -7, -2, 4, 8, 14, 20, 24, 28, 31,
36, 39, 40, 42, 44, 45, 47, 48, 48, 48, 48, 47, 46, 44, 41, 39, 36, 34, 29, 25,
21, 16, 13, 9, 6, 3, 0, -3, -5, -7, -9, -11, -13, -15, -16, -19, -21, -24, -26,
-29, -31, -32, -35, -36, -37, -39, -38, -38, -38, -36, -36, -34, -32, -30, -28,
-26, -25, -23, -19, -16, -13, -10, -6, -2, };