#define DATA_LENGTH 512
#define DATA AKWF_piano_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 9, 12, 17, 21, 25, 27, 30,
32, 34, 35, 35, 35, 34, 34, 34, 35, 36, 38, 41, 44, 47, 51, 55, 59, 64, 68, 71,
75, 78, 81, 84, 87, 89, 91, 92, 94, 95, 97, 100, 102, 104, 105, 107, 109, 110,
112, 114, 116, 117, 117, 119, 119, 118, 118, 116, 114, 111, 107, 102, 97, 93,
88, 82, 77, 71, 67, 61, 56, 52, 48, 44, 40, 36, 32, 28, 25, 22, 18, 14, 11, 8,
5, 1, -1, -2, -3, -5, -5, -6, -4, -3, -1, 1, 3, 6, 8, 10, 12, 14, 17, 19, 19,
21, 21, 21, 22, 22, 23, 24, 24, 25, 26, 27, 28, 29, 31, 32, 34, 36, 36, 39, 40,
42, 44, 46, 48, 50, 51, 52, 54, 54, 55, 55, 55, 54, 54, 52, 50, 49, 48, 46, 46,
44, 43, 42, 40, 39, 37, 36, 34, 32, 31, 29, 26, 24, 23, 21, 20, 18, 17, 16, 15,
14, 13, 12, 12, 11, 9, 8, 7, 7, 5, 4, 3, 2, 1, 0, 0, -1, -2, -3, -5, -6, -10,
-13, -16, -20, -25, -28, -33, -37, -42, -46, -50, -53, -56, -60, -62, -65, -68,
-69, -71, -73, -74, -75, -77, -78, -80, -81, -83, -86, -87, -89, -91, -93, -95,
-96, -97, -98, -98, -99, -99, -98, -98, -97, -97, -96, -96, -96, -95, -96, -97,
-97, -99, -100, -102, -103, -104, -105, -106, -105, -105, -105, -104, -102,
-100, -99, -95, -92, -89, -85, -80, -76, -71, -66, -62, -56, -51, -48, -44, -41,
-38, -37, -36, -35, -33, -32, -31, -28, -27, -25, -21, -19, -17, -14, -12, -10,
-9, -7, -6, -5, -5, -4, -3, -2, 0, 2, 4, 7, 9, 11, 14, 16, 18, 19, 19, 20, 20,
20, 20, 20, 21, 21, 22, 22, 25, 26, 26, 27, 27, 26, 26, 26, 26, 26, 27, 28, 29,
31, 32, 34, 36, 38, 39, 41, 42, 43, 44, 45, 46, 46, 47, 48, 48, 48, 48, 49, 49,
46, 45, 43, 41, 37, 33, 29, 25, 21, 17, 14, 11, 8, 7, 5, 3, 2, 0, -2, -4, -6,
-8, -11, -14, -15, -19, -21, -23, -25, -27, -28, -28, -27, -26, -25, -22, -20,
-17, -14, -10, -7, -4, -1, 1, 3, 2, 3, 3, 1, 1, -1, -1, -2, -2, -2, 0, 2, 5, 8,
11, 15, 17, 20, 22, 23, 24, 24, 23, 22, 20, 19, 16, 14, 12, 10, 9, 7, 6, 4, 3,
2, -1, -2, -3, -6, -9, -12, -14, -17, -20, -24, -27, -29, -33, -36, -39, -41,
-43, -45, -47, -48, -50, -51, -51, -52, -51, -51, -51, -50, -50, -50, -49, -50,
-50, -53, -55, -56, -59, -61, -63, -63, -65, -66, -66, -64, -63, -60, -60, -57,
-56, -54, -52, -51, -51, -51, -51, -51, -52, -53, -53, -52, -52, -48, -46, -41,
-38, -34, -29, -24, -20, -16, -14, -11, -9, -8, -8, -7, -7, -7, -8, -9, -9, -10,
-9, -10, -8, -8, -6, -5, -3, -2, };