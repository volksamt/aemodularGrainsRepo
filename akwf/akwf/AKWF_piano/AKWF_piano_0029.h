#define DATA_LENGTH 512
#define DATA AKWF_piano_0029

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 5, 6, 6, 9, 9, 11, 11, 13,
13, 14, 16, 16, 17, 18, 18, 18, 19, 20, 20, 21, 20, 21, 21, 21, 21, 23, 22, 22,
22, 22, 22, 22, 22, 22, 21, 21, 20, 21, 20, 19, 18, 18, 17, 17, 16, 16, 15, 14,
13, 13, 12, 12, 11, 9, 9, 10, 8, 7, 7, 7, 5, 5, 5, 5, 4, 3, 3, 3, 2, 2, 1, 2, 1,
0, 1, 0, -1, -1, -1, -2, -1, -2, -1, -2, -1, -1, 0, 0, 0, 1, 1, 3, 4, 5, 6, 7,
8, 9, 11, 11, 14, 15, 17, 18, 20, 21, 23, 24, 25, 27, 29, 31, 32, 33, 34, 35,
37, 38, 40, 41, 42, 44, 44, 45, 47, 47, 47, 49, 49, 49, 50, 50, 51, 50, 51, 51,
52, 52, 50, 51, 50, 50, 50, 49, 49, 49, 49, 48, 47, 47, 48, 46, 46, 45, 46, 45,
45, 45, 44, 45, 44, 44, 44, 44, 45, 45, 45, 46, 46, 46, 46, 47, 47, 48, 49, 49,
49, 51, 51, 50, 52, 52, 52, 52, 53, 54, 55, 55, 56, 55, 56, 57, 56, 58, 58, 59,
59, 58, 59, 59, 59, 60, 60, 60, 60, 60, 60, 61, 61, 61, 61, 62, 61, 61, 62, 61,
61, 62, 61, 60, 61, 62, 62, 60, 61, 60, 60, 59, 60, 60, 60, 59, 59, 59, 58, 58,
58, 57, 57, 57, 57, 57, 56, 56, 57, 56, 55, 55, 54, 54, 54, 54, 52, 52, 53, 51,
51, 50, 49, 49, 47, 46, 46, 44, 43, 42, 41, 40, 39, 37, 36, 36, 35, 33, 32, 31,
30, 29, 28, 28, 27, 26, 26, 25, 25, 24, 25, 24, 23, 22, 23, 22, 21, 21, 20, 20,
19, 18, 17, 16, 16, 14, 14, 13, 13, 12, 11, 9, 9, 8, 7, 5, 5, 5, 3, 3, 1, 2, 0,
0, 0, -1, -2, -1, -2, -3, -2, -3, -3, -3, -3, -4, -3, -4, -4, -5, -5, -5, -6,
-6, -6, -7, -7, -7, -8, -8, -9, -10, -11, -10, -11, -12, -13, -13, -13, -14,
-16, -17, -17, -17, -18, -18, -20, -21, -21, -22, -23, -24, -24, -25, -26, -27,
-28, -29, -30, -31, -33, -34, -34, -37, -38, -39, -41, -42, -44, -45, -48, -49,
-51, -53, -54, -56, -59, -61, -62, -65, -67, -68, -71, -73, -75, -77, -80, -81,
-84, -85, -87, -89, -91, -94, -96, -97, -100, -101, -103, -104, -107, -108,
-110, -110, -112, -114, -115, -115, -117, -116, -117, -118, -119, -118, -119,
-118, -119, -119, -119, -119, -118, -117, -117, -117, -115, -114, -114, -113,
-112, -110, -109, -109, -107, -106, -105, -104, -102, -101, -100, -99, -98, -96,
-95, -94, -92, -91, -89, -87, -86, -85, -82, -82, -79, -77, -76, -72, -71, -70,
-67, -65, -63, -61, -59, -56, -55, -52, -50, -48, -46, -44, -41, -39, -37, -35,
-34, -32, -28, -27, -25, -22, -21, -20, -17, -16, -14, -12, -10, -8, -6, -5, -3,
-1, -1, };