#define DATA_LENGTH 512
#define DATA AKWF_piano_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 18, 30, 40, 50, 60, 68, 74, 80, 84,
88, 92, 95, 99, 100, 103, 103, 102, 99, 94, 86, 77, 68, 61, 54, 51, 50, 52, 54,
57, 63, 66, 70, 74, 78, 82, 85, 91, 95, 100, 105, 111, 116, 118, 119, 118, 113,
107, 98, 88, 79, 69, 61, 54, 45, 38, 30, 23, 17, 12, 8, 6, 4, 3, 3, 3, 3, 1, 0,
-2, -3, -4, -3, -3, -3, -1, 0, 1, 3, 5, 6, 5, 2, -4, -11, -20, -31, -43, -57,
-69, -80, -89, -95, -98, -99, -99, -99, -98, -97, -96, -95, -91, -89, -85, -79,
-74, -69, -64, -59, -55, -53, -53, -53, -56, -60, -64, -68, -72, -76, -78, -78,
-79, -78, -78, -78, -78, -76, -75, -72, -69, -63, -60, -55, -48, -44, -38, -33,
-29, -24, -20, -17, -14, -13, -12, -13, -14, -15, -14, -13, -11, -9, -7, -5, 0,
3, 7, 10, 15, 19, 22, 27, 30, 33, 36, 39, 40, 43, 45, 48, 51, 54, 56, 58, 59,
59, 59, 59, 61, 63, 65, 68, 71, 73, 72, 70, 65, 57, 48, 38, 28, 18, 10, 3, -1,
-4, -5, -5, -4, -2, -2, -4, -7, -11, -17, -22, -25, -29, -31, -31, -31, -31,
-29, -28, -28, -28, -30, -32, -34, -34, -35, -33, -31, -26, -23, -19, -16, -13,
-14, -16, -20, -25, -31, -35, -37, -37, -31, -24, -15, -4, 7, 14, 19, 22, 20,
17, 12, 7, 1, -3, -9, -12, -16, -17, -17, -14, -12, -7, -3, 2, 7, 13, 19, 24,
29, 34, 36, 36, 37, 36, 35, 33, 30, 29, 27, 26, 25, 23, 21, 18, 15, 13, 14, 15,
19, 22, 26, 28, 27, 22, 14, 2, -13, -28, -42, -55, -62, -66, -66, -62, -55, -48,
-41, -33, -27, -23, -19, -16, -14, -13, -11, -12, -13, -15, -18, -21, -23, -24,
-22, -21, -18, -13, -9, -2, 4, 13, 19, 27, 32, 38, 43, 48, 52, 55, 55, 55, 52,
48, 44, 39, 36, 36, 36, 41, 46, 52, 61, 65, 70, 74, 76, 78, 80, 79, 80, 80, 78,
77, 73, 69, 65, 59, 55, 52, 50, 49, 49, 49, 49, 47, 45, 40, 34, 26, 17, 8, -2,
-10, -16, -22, -25, -28, -31, -34, -37, -41, -44, -47, -47, -48, -47, -46, -47,
-49, -51, -57, -64, -73, -82, -92, -100, -108, -113, -114, -113, -110, -105,
-100, -96, -91, -89, -89, -89, -92, -96, -96, -96, -94, -91, -87, -82, -79, -76,
-74, -73, -71, -70, -66, -62, -56, -48, -40, -32, -22, -14, -6, 2, 8, 15, 19,
23, 24, 26, 27, 28, 28, 28, 27, 26, 26, 28, 30, 33, 37, 41, 46, 48, 50, 49, 46,
40, 33, 24, 15, 7, 0, -7, -11, -15, -18, -17, -16, -12, -6, 0, 5, 10, 14, 19,
24, 29, 33, 38, 42, 46, 48, 46, 43, 37, 28, 18, 8, -2, -11, -19, -26, -33, -40,
-46, -53, -58, -63, -66, -67, -64, -60, -54, -46, -38, -29, -20, -11, -3, };