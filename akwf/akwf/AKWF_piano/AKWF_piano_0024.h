#define DATA_LENGTH 512
#define DATA AKWF_piano_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 13, 17, 23, 29, 32, 33, 36, 36, 36,
36, 35, 34, 34, 34, 33, 35, 37, 38, 41, 44, 47, 51, 55, 59, 62, 66, 68, 72, 73,
75, 77, 79, 78, 81, 81, 83, 85, 87, 90, 94, 98, 102, 106, 110, 112, 115, 116,
119, 118, 119, 118, 117, 114, 112, 109, 106, 103, 100, 97, 94, 92, 90, 88, 86,
84, 82, 81, 79, 78, 76, 74, 72, 70, 69, 67, 65, 63, 61, 59, 57, 54, 51, 48, 46,
43, 39, 37, 32, 30, 28, 25, 22, 19, 17, 16, 15, 13, 12, 10, 9, 7, 6, 4, 2, 1,
-1, -3, -5, -6, -8, -8, -9, -10, -9, -9, -9, -8, -7, -7, -6, -6, -8, -9, -11,
-14, -16, -19, -22, -24, -26, -29, -30, -32, -32, -33, -32, -32, -30, -30, -28,
-28, -27, -26, -27, -27, -29, -29, -31, -33, -36, -38, -41, -43, -47, -48, -49,
-51, -51, -52, -51, -50, -48, -46, -45, -43, -40, -39, -38, -36, -36, -37, -38,
-39, -40, -43, -45, -47, -49, -51, -51, -52, -53, -52, -52, -52, -51, -51, -50,
-49, -49, -49, -49, -48, -49, -48, -48, -48, -46, -47, -45, -43, -41, -40, -37,
-36, -34, -33, -31, -30, -28, -26, -26, -25, -25, -25, -25, -24, -24, -24, -24,
-24, -22, -21, -19, -18, -16, -14, -11, -10, -6, -3, -1, 1, 2, 4, 3, 2, 2, 1,
-1, -2, -4, -5, -8, -9, -11, -11, -12, -12, -13, -12, -11, -9, -9, -8, -8, -7,
-5, -5, -5, -6, -6, -7, -9, -10, -11, -14, -16, -17, -19, -20, -22, -23, -24,
-25, -26, -26, -26, -26, -25, -26, -26, -26, -26, -26, -27, -27, -29, -31, -34,
-36, -39, -42, -44, -47, -48, -48, -46, -45, -42, -38, -33, -27, -21, -14, -8,
-2, 2, 7, 11, 12, 13, 14, 13, 12, 11, 9, 7, 7, 6, 7, 7, 9, 11, 14, 17, 21, 26,
29, 33, 37, 41, 44, 47, 50, 52, 55, 57, 60, 60, 62, 63, 66, 67, 68, 70, 71, 72,
72, 73, 74, 74, 75, 75, 75, 76, 74, 75, 74, 74, 73, 71, 71, 70, 70, 69, 68, 68,
67, 68, 69, 69, 69, 69, 70, 70, 70, 70, 69, 69, 69, 70, 69, 69, 69, 68, 68, 67,
68, 66, 65, 64, 63, 60, 58, 53, 50, 45, 41, 36, 30, 26, 22, 18, 14, 11, 8, 7, 5,
4, 3, 1, 0, -2, -3, -5, -7, -10, -11, -14, -16, -17, -18, -20, -22, -23, -25,
-27, -30, -32, -36, -41, -46, -52, -57, -63, -69, -73, -78, -83, -86, -88, -89,
-90, -90, -89, -87, -84, -81, -80, -78, -77, -76, -76, -77, -78, -80, -82, -85,
-87, -89, -90, -92, -94, -94, -93, -92, -91, -88, -85, -82, -79, -76, -73, -69,
-68, -67, -68, -69, -72, -74, -77, -81, -83, -86, -89, -90, -91, -90, -88, -86,
-82, -76, -70, -63, -56, -48, -41, -34, -29, -24, -18, -16, -13, -10, -9, -8,
-6, -4, -2, 0, };