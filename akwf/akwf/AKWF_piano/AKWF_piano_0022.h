#define DATA_LENGTH 512
#define DATA AKWF_piano_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 6, 8, 9, 11, 14, 17, 21, 27, 32,
38, 43, 49, 54, 58, 64, 70, 76, 83, 87, 92, 93, 93, 90, 83, 73, 60, 46, 32, 17,
5, -6, -15, -23, -28, -32, -33, -33, -33, -31, -29, -24, -21, -16, -12, -11,
-10, -13, -17, -22, -26, -30, -33, -34, -34, -34, -33, -31, -31, -32, -36, -41,
-47, -55, -61, -65, -68, -70, -68, -63, -57, -50, -42, -35, -29, -24, -18, -14,
-9, -4, 1, 5, 12, 17, 23, 26, 29, 30, 31, 30, 28, 25, 22, 19, 16, 15, 14, 16,
17, 19, 23, 26, 31, 36, 41, 45, 50, 54, 57, 58, 58, 59, 57, 56, 56, 56, 57, 58,
59, 59, 58, 55, 51, 45, 37, 28, 19, 9, -1, -10, -19, -26, -32, -38, -41, -42,
-40, -37, -32, -25, -21, -14, -9, -5, -2, -1, -2, -4, -7, -9, -12, -15, -16,
-17, -17, -18, -17, -17, -18, -18, -21, -24, -28, -33, -37, -39, -42, -42, -40,
-37, -31, -23, -15, -5, 6, 19, 32, 45, 58, 70, 80, 88, 92, 96, 95, 93, 89, 84,
78, 71, 63, 56, 47, 40, 33, 26, 20, 15, 11, 6, 2, -3, -8, -12, -16, -18, -21,
-24, -25, -28, -29, -29, -30, -32, -31, -31, -31, -31, -33, -36, -41, -49, -59,
-68, -78, -88, -96, -104, -110, -114, -118, -119, -119, -116, -111, -104, -92,
-78, -62, -44, -25, -6, 11, 27, 41, 52, 58, 61, 59, 55, 48, 39, 28, 19, 10, 4,
0, 1, 3, 7, 12, 15, 19, 20, 19, 17, 14, 11, 8, 8, 8, 10, 13, 18, 23, 28, 31, 34,
35, 34, 32, 29, 27, 28, 29, 34, 37, 42, 46, 45, 42, 36, 25, 11, -3, -21, -35,
-47, -55, -62, -63, -62, -58, -50, -41, -28, -18, -7, 2, 10, 15, 19, 20, 22, 21,
21, 21, 21, 23, 23, 24, 24, 23, 23, 22, 19, 18, 15, 13, 10, 8, 7, 4, 2, 0, -1,
-3, -4, -5, -7, -8, -9, -11, -11, -13, -12, -13, -10, -10, -8, -6, -2, -1, -1,
-1, -4, -9, -14, -21, -31, -41, -51, -60, -66, -70, -71, -69, -65, -60, -54,
-48, -41, -34, -28, -22, -16, -10, -6, 0, 4, 8, 11, 12, 14, 15, 15, 16, 18, 19,
21, 24, 26, 27, 27, 25, 20, 14, 7, -1, -9, -16, -22, -27, -28, -28, -28, -27,
-25, -22, -16, -10, -2, 7, 16, 26, 35, 44, 50, 54, 55, 53, 50, 44, 37, 29, 24,
18, 14, 11, 8, 5, 2, -1, -6, -9, -13, -17, -20, -20, -20, -19, -16, -12, -8, -3,
2, 8, 15, 22, 28, 36, 43, 51, 56, 60, 61, 59, 55, 49, 41, 31, 21, 13, 4, -4,
-10, -16, -22, -28, -31, -33, -34, -35, -34, -33, -32, -30, -27, -26, -24, -25,
-26, -26, -27, -25, -24, -21, -16, -9, -2, 5, 11, 16, 18, 16, 10, 3, -6, -16,
-27, -35, -41, -45, -46, -44, -41, -36, -28, -22, -13, -6, };