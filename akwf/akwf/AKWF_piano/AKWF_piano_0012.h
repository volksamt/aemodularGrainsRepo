#define DATA_LENGTH 512
#define DATA AKWF_piano_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 4, 7, 10, 14, 17, 21, 23, 25,
27, 27, 26, 24, 22, 19, 16, 12, 11, 10, 10, 11, 12, 15, 18, 22, 26, 30, 35, 37,
40, 43, 45, 48, 49, 51, 53, 55, 56, 59, 61, 64, 68, 72, 74, 79, 82, 86, 89, 93,
96, 98, 100, 103, 104, 106, 105, 107, 107, 107, 107, 107, 107, 109, 109, 111,
112, 114, 116, 117, 118, 120, 119, 118, 115, 113, 109, 104, 99, 93, 89, 81, 77,
71, 66, 60, 54, 49, 44, 39, 33, 30, 25, 21, 17, 14, 11, 7, 5, 2, -1, -5, -7,
-10, -13, -16, -18, -20, -20, -20, -18, -15, -13, -7, -3, 2, 7, 13, 19, 22, 25,
27, 28, 29, 28, 29, 28, 28, 28, 29, 30, 32, 35, 37, 40, 41, 45, 47, 50, 51, 52,
53, 52, 52, 52, 51, 50, 50, 50, 49, 50, 50, 50, 51, 51, 51, 52, 50, 51, 49, 49,
47, 47, 45, 43, 41, 40, 37, 36, 32, 30, 28, 24, 21, 17, 14, 11, 8, 7, 4, 2, 1,
2, 2, 1, 0, 1, 0, 0, -1, -3, -3, -6, -8, -11, -14, -16, -18, -21, -24, -25, -28,
-29, -32, -34, -35, -38, -40, -44, -46, -48, -52, -55, -58, -62, -66, -69, -73,
-76, -80, -82, -86, -89, -92, -94, -97, -100, -102, -104, -106, -107, -108,
-110, -110, -110, -110, -110, -109, -108, -106, -105, -104, -103, -101, -100,
-99, -99, -98, -98, -99, -100, -100, -100, -101, -100, -101, -101, -100, -99,
-98, -96, -94, -92, -90, -88, -86, -83, -80, -78, -74, -72, -68, -65, -61, -57,
-53, -48, -44, -39, -37, -33, -29, -26, -23, -19, -16, -13, -10, -7, -4, -1, 3,
6, 7, 10, 11, 12, 13, 13, 13, 13, 11, 11, 10, 9, 9, 10, 9, 11, 12, 15, 17, 18,
21, 24, 27, 29, 31, 33, 34, 35, 35, 35, 34, 34, 34, 34, 33, 32, 31, 31, 31, 31,
33, 33, 34, 35, 36, 36, 38, 39, 39, 41, 42, 43, 43, 43, 43, 44, 43, 44, 43, 43,
43, 42, 42, 41, 39, 38, 37, 35, 32, 30, 27, 25, 21, 18, 14, 10, 5, 2, -2, -6,
-9, -12, -15, -18, -20, -22, -25, -26, -26, -27, -27, -26, -26, -23, -22, -20,
-19, -17, -16, -15, -13, -12, -10, -9, -7, -4, -3, -1, 2, 4, 7, 9, 11, 13, 14,
14, 15, 15, 15, 16, 16, 17, 18, 19, 20, 20, 22, 22, 23, 23, 22, 22, 19, 17, 14,
11, 8, 5, 3, 1, -2, -3, -5, -6, -8, -9, -12, -14, -18, -21, -25, -28, -32, -35,
-38, -41, -44, -46, -49, -53, -54, -58, -60, -62, -64, -66, -65, -65, -65, -64,
-62, -60, -58, -56, -55, -54, -54, -55, -56, -57, -60, -62, -65, -66, -67, -68,
-67, -66, -64, -62, -57, -54, -51, -47, -46, -43, -42, -42, -41, -41, -42, -42,
-41, -41, -39, -38, -36, -34, -31, -29, -25, -22, -17, -14, -10, -5, -2, -1, };