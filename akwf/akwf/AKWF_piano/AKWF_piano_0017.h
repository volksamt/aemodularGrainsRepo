#define DATA_LENGTH 512
#define DATA AKWF_piano_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 14, 20, 25, 32, 38, 44, 48, 54,
60, 66, 70, 75, 78, 82, 85, 88, 90, 92, 94, 96, 98, 101, 102, 106, 108, 110,
112, 115, 116, 117, 118, 119, 119, 119, 117, 114, 112, 109, 106, 102, 99, 94,
91, 88, 84, 79, 76, 72, 70, 66, 63, 60, 58, 56, 53, 51, 48, 45, 44, 41, 38, 36,
34, 33, 32, 32, 32, 31, 33, 33, 34, 34, 35, 36, 36, 37, 36, 38, 36, 36, 35, 35,
33, 31, 30, 28, 26, 24, 22, 18, 15, 12, 7, 3, -3, -8, -13, -19, -24, -30, -36,
-41, -46, -51, -55, -59, -63, -65, -67, -69, -70, -71, -71, -71, -71, -71, -70,
-69, -68, -69, -68, -66, -66, -65, -64, -64, -64, -62, -62, -60, -58, -57, -55,
-53, -51, -49, -48, -46, -44, -43, -41, -39, -38, -36, -34, -32, -31, -30, -28,
-26, -25, -23, -21, -19, -16, -14, -12, -9, -6, -4, -3, -1, 2, 3, 4, 6, 6, 7, 7,
7, 7, 6, 5, 5, 5, 4, 3, 3, 4, 3, 3, 4, 3, 3, 4, 5, 5, 5, 7, 8, 8, 9, 11, 11, 13,
13, 15, 15, 16, 17, 17, 17, 18, 17, 17, 16, 16, 17, 17, 18, 19, 20, 21, 22, 25,
26, 29, 31, 34, 37, 39, 42, 45, 47, 49, 49, 50, 51, 52, 52, 52, 52, 51, 51, 50,
48, 47, 46, 45, 44, 43, 42, 42, 42, 42, 41, 41, 41, 40, 39, 39, 38, 37, 35, 34,
31, 29, 26, 23, 19, 15, 12, 7, 2, -2, -6, -11, -15, -18, -22, -25, -28, -30,
-31, -32, -32, -33, -34, -34, -34, -36, -36, -38, -39, -40, -42, -42, -44, -46,
-45, -46, -45, -45, -45, -42, -41, -37, -35, -32, -29, -26, -22, -18, -14, -9,
-5, -2, 2, 6, 10, 14, 16, 20, 21, 24, 26, 27, 28, 29, 28, 26, 25, 22, 19, 16,
12, 8, 4, 1, -2, -5, -7, -9, -11, -12, -13, -13, -14, -13, -12, -11, -10, -9,
-8, -8, -7, -7, -7, -6, -5, -5, -3, -1, 1, 2, 4, 6, 8, 9, 12, 15, 16, 18, 21,
24, 26, 29, 32, 34, 36, 38, 41, 42, 44, 46, 48, 50, 50, 52, 53, 53, 54, 54, 55,
54, 54, 52, 52, 50, 49, 47, 44, 42, 38, 37, 33, 31, 29, 27, 26, 22, 21, 18, 17,
14, 11, 10, 7, 5, 4, 3, 1, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, -3, -5, -8, -12, -15,
-18, -22, -27, -31, -34, -37, -40, -43, -45, -48, -49, -49, -50, -51, -52, -51,
-52, -52, -54, -55, -56, -58, -62, -66, -68, -72, -75, -79, -83, -87, -89, -93,
-94, -96, -97, -97, -97, -97, -97, -96, -96, -96, -96, -96, -97, -96, -96, -97,
-98, -97, -97, -98, -98, -97, -98, -98, -98, -97, -97, -97, -96, -96, -95, -93,
-91, -90, -87, -84, -80, -77, -71, -66, -60, -55, -48, -43, -36, -29, -22, -16,
-9, -4, -1, };