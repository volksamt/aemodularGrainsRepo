#define DATA_LENGTH 512
#define DATA AKWF_piano_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 14, 18, 25, 28, 33, 37, 41, 44,
48, 52, 55, 58, 61, 65, 68, 72, 76, 79, 83, 87, 90, 93, 97, 101, 103, 107, 109,
112, 114, 117, 117, 118, 119, 120, 119, 117, 117, 114, 112, 110, 107, 104, 101,
98, 95, 93, 92, 91, 91, 92, 92, 94, 95, 97, 99, 99, 101, 102, 103, 103, 103,
103, 100, 99, 96, 93, 90, 87, 83, 79, 74, 71, 67, 65, 62, 61, 60, 59, 59, 59,
59, 60, 61, 61, 60, 59, 56, 55, 50, 46, 41, 37, 30, 25, 20, 16, 12, 10, 8, 8, 7,
8, 10, 11, 12, 15, 15, 14, 13, 11, 9, 7, 2, -1, -6, -10, -15, -19, -23, -27,
-30, -33, -36, -38, -40, -43, -45, -46, -48, -49, -51, -51, -52, -54, -55, -56,
-56, -56, -56, -56, -56, -55, -54, -54, -55, -55, -55, -56, -58, -59, -62, -64,
-68, -71, -74, -76, -79, -80, -82, -82, -83, -83, -81, -80, -78, -75, -73, -71,
-68, -65, -63, -61, -59, -58, -56, -54, -54, -53, -53, -52, -52, -51, -51, -51,
-50, -50, -50, -51, -49, -51, -51, -51, -51, -51, -50, -48, -47, -47, -45, -44,
-42, -40, -39, -38, -38, -36, -36, -35, -36, -36, -35, -35, -35, -34, -33, -30,
-29, -24, -20, -17, -11, -5, 1, 6, 12, 18, 23, 27, 31, 31, 33, 32, 30, 26, 22,
17, 11, 4, -2, -8, -14, -20, -23, -26, -28, -28, -27, -25, -23, -19, -15, -12,
-8, -7, -5, -3, -3, -5, -7, -9, -13, -17, -21, -25, -29, -33, -35, -37, -38,
-39, -39, -38, -36, -36, -33, -31, -30, -30, -28, -28, -26, -26, -26, -26, -25,
-25, -23, -22, -21, -20, -18, -15, -13, -11, -8, -6, -3, -1, 3, 5, 6, 9, 10, 12,
14, 15, 17, 18, 18, 19, 20, 21, 20, 20, 21, 21, 21, 23, 22, 23, 24, 25, 25, 27,
28, 30, 31, 31, 32, 34, 33, 35, 35, 35, 37, 37, 38, 40, 42, 44, 47, 50, 54, 58,
62, 65, 70, 74, 77, 80, 82, 83, 85, 86, 86, 85, 84, 84, 82, 82, 80, 81, 81, 82,
82, 82, 83, 84, 84, 86, 87, 87, 87, 85, 83, 80, 77, 72, 69, 64, 59, 54, 51, 46,
44, 42, 41, 42, 42, 44, 47, 52, 55, 59, 62, 66, 67, 68, 67, 65, 62, 56, 48, 41,
31, 23, 13, 4, -3, -11, -17, -20, -23, -25, -24, -24, -21, -19, -16, -12, -11,
-9, -9, -10, -10, -13, -17, -21, -27, -33, -39, -45, -51, -57, -64, -68, -74,
-78, -82, -86, -88, -90, -91, -92, -92, -92, -93, -91, -92, -90, -89, -89, -90,
-90, -90, -92, -93, -95, -98, -99, -103, -105, -107, -108, -111, -112, -113,
-114, -114, -114, -112, -111, -109, -107, -104, -102, -99, -95, -94, -91, -89,
-87, -86, -85, -84, -81, -80, -79, -77, -77, -75, -73, -71, -70, -67, -63, -62,
-58, -54, -51, -47, -42, -38, -33, -29, -23, -18, -12, -7, -3, };