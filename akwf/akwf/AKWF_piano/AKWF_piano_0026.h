#define DATA_LENGTH 512
#define DATA AKWF_piano_0026

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 11, 17, 23, 27, 33, 38, 44, 49,
54, 59, 64, 67, 72, 75, 78, 80, 82, 83, 83, 84, 82, 81, 80, 77, 76, 74, 72, 70,
68, 67, 66, 65, 65, 65, 66, 68, 70, 73, 74, 77, 79, 79, 79, 80, 80, 79, 77, 75,
73, 70, 68, 66, 63, 61, 58, 57, 56, 55, 55, 54, 55, 55, 56, 57, 58, 59, 61, 61,
63, 63, 64, 64, 64, 62, 63, 61, 60, 58, 56, 55, 53, 51, 50, 48, 44, 43, 41, 40,
38, 38, 37, 36, 36, 35, 35, 35, 35, 35, 36, 36, 36, 36, 38, 38, 38, 38, 38, 37,
38, 37, 36, 34, 33, 31, 30, 28, 25, 22, 20, 18, 15, 11, 10, 7, 5, 3, 0, -2, -4,
-6, -7, -8, -10, -11, -14, -15, -17, -19, -22, -24, -28, -32, -35, -39, -44,
-47, -52, -56, -59, -63, -66, -68, -70, -73, -74, -75, -76, -77, -78, -78, -80,
-80, -82, -83, -85, -87, -90, -92, -95, -98, -101, -105, -107, -111, -113, -115,
-116, -119, -119, -119, -119, -118, -117, -115, -112, -109, -107, -104, -100,
-97, -93, -88, -83, -79, -73, -68, -62, -56, -50, -43, -37, -31, -25, -18, -13,
-6, -2, 4, 9, 14, 18, 21, 23, 25, 27, 28, 30, 30, 30, 31, 30, 30, 30, 29, 28,
28, 27, 27, 25, 24, 23, 21, 20, 19, 17, 16, 16, 14, 13, 13, 12, 13, 11, 12, 12,
13, 13, 15, 15, 17, 18, 19, 21, 23, 24, 26, 27, 28, 29, 28, 30, 29, 29, 30, 28,
28, 26, 26, 24, 23, 20, 19, 15, 13, 11, 8, 4, 0, -4, -6, -10, -14, -16, -20,
-22, -25, -28, -31, -33, -36, -37, -40, -41, -42, -43, -43, -44, -45, -45, -46,
-45, -45, -44, -43, -42, -42, -41, -39, -39, -38, -36, -35, -34, -33, -32, -29,
-29, -28, -25, -24, -22, -20, -17, -15, -13, -11, -8, -6, -4, -1, -1, 1, 3, 3,
4, 4, 6, 6, 6, 7, 6, 6, 7, 6, 5, 6, 5, 4, 3, 4, 2, 2, 1, 0, 0, -2, -2, -3, -5,
-6, -7, -8, -9, -10, -11, -12, -12, -13, -13, -13, -13, -13, -13, -13, -13, -13,
-12, -12, -12, -11, -11, -10, -11, -11, -11, -12, -12, -12, -13, -13, -14, -14,
-15, -15, -16, -16, -17, -17, -17, -18, -18, -18, -18, -18, -17, -17, -16, -15,
-14, -14, -12, -10, -9, -6, -5, -2, 0, 2, 6, 7, 9, 12, 14, 15, 17, 17, 18, 18,
18, 17, 17, 16, 15, 14, 14, 11, 11, 9, 9, 8, 7, 7, 5, 5, 3, 2, 0, -2, -4, -6,
-10, -12, -16, -19, -23, -26, -30, -33, -36, -38, -40, -41, -43, -43, -43, -44,
-43, -42, -41, -41, -40, -40, -40, -40, -40, -40, -41, -42, -42, -43, -44, -46,
-48, -49, -51, -53, -54, -55, -57, -57, -57, -57, -56, -55, -55, -53, -51, -48,
-47, -44, -41, -38, -35, -31, -26, -22, -17, -13, -7, -2, };