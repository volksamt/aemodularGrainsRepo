#define DATA_LENGTH 512
#define DATA AKWF_piano_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 5, 7, 8, 9, 10, 12, 13,
15, 16, 17, 19, 19, 21, 23, 23, 25, 26, 27, 28, 30, 32, 33, 35, 36, 37, 38, 40,
41, 43, 44, 45, 46, 48, 49, 50, 52, 53, 53, 55, 56, 57, 58, 60, 61, 63, 63, 64,
65, 67, 67, 69, 70, 71, 73, 73, 73, 75, 76, 77, 79, 80, 81, 81, 83, 83, 85, 85,
86, 88, 88, 89, 90, 90, 92, 92, 94, 94, 95, 96, 96, 97, 97, 99, 100, 100, 101,
101, 102, 103, 104, 105, 104, 106, 106, 108, 107, 108, 109, 109, 110, 110, 111,
111, 111, 111, 113, 114, 114, 115, 115, 115, 115, 115, 116, 116, 117, 117, 117,
118, 118, 118, 119, 118, 118, 118, 119, 119, 119, 120, 119, 119, 120, 120, 119,
119, 119, 119, 119, 118, 118, 119, 118, 118, 118, 118, 117, 117, 117, 117, 116,
116, 115, 116, 115, 114, 115, 113, 113, 113, 112, 111, 111, 111, 109, 110, 108,
107, 107, 106, 106, 105, 104, 102, 102, 101, 100, 99, 99, 98, 96, 96, 95, 94,
93, 92, 92, 90, 89, 88, 87, 86, 85, 84, 83, 82, 81, 79, 77, 77, 75, 75, 73, 72,
71, 69, 68, 67, 66, 65, 63, 62, 60, 59, 58, 56, 54, 54, 52, 51, 49, 47, 46, 44,
43, 42, 41, 39, 38, 36, 35, 33, 32, 30, 28, 28, 26, 25, 23, 22, 20, 18, 18, 16,
15, 13, 12, 11, 9, 7, 5, 4, 3, 1, 0, -2, -4, -4, -6, -7, -8, -11, -11, -13, -14,
-15, -17, -18, -20, -21, -22, -24, -25, -27, -28, -29, -31, -31, -32, -35, -35,
-38, -38, -39, -41, -42, -44, -45, -45, -47, -47, -49, -50, -52, -54, -54, -56,
-56, -58, -58, -59, -61, -61, -64, -63, -65, -66, -67, -68, -68, -70, -71, -71,
-73, -74, -74, -75, -76, -77, -78, -78, -80, -80, -81, -82, -83, -84, -85, -85,
-86, -86, -87, -88, -89, -89, -90, -90, -91, -91, -92, -92, -93, -93, -94, -95,
-95, -96, -96, -97, -97, -97, -98, -97, -98, -98, -100, -99, -100, -100, -100,
-100, -101, -100, -101, -102, -102, -102, -102, -102, -103, -103, -103, -102,
-103, -102, -103, -103, -103, -103, -103, -104, -104, -103, -103, -102, -103,
-103, -103, -103, -102, -103, -103, -102, -102, -102, -101, -101, -101, -101,
-101, -100, -100, -99, -100, -99, -99, -99, -98, -97, -98, -96, -97, -96, -96,
-95, -94, -94, -94, -93, -93, -92, -91, -91, -90, -90, -89, -88, -87, -88, -87,
-86, -86, -85, -84, -84, -82, -81, -80, -80, -79, -78, -78, -77, -76, -75, -74,
-73, -73, -72, -70, -70, -68, -68, -66, -66, -65, -64, -62, -62, -61, -60, -58,
-57, -57, -55, -54, -53, -52, -50, -50, -48, -48, -46, -45, -43, -43, -41, -40,
-39, -38, -36, -34, -33, -32, -31, -30, -28, -27, -25, -24, -24, -22, -20, -19,
-18, -17, -16, -14, -13, -12, -11, -9, -8, -7, -5, -4, -3, -2, -1, };