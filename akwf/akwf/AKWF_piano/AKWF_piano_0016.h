#define DATA_LENGTH 512
#define DATA AKWF_piano_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 6, 7, 9, 12, 14, 15, 18, 20,
22, 25, 27, 30, 31, 34, 36, 38, 40, 43, 46, 48, 51, 53, 55, 58, 61, 63, 65, 67,
69, 71, 73, 75, 76, 77, 79, 80, 81, 82, 83, 83, 84, 84, 85, 85, 85, 85, 85, 85,
86, 86, 86, 85, 86, 86, 86, 87, 87, 86, 87, 89, 88, 90, 91, 91, 93, 93, 95, 96,
98, 99, 102, 103, 104, 106, 108, 109, 111, 112, 114, 115, 116, 116, 117, 118,
118, 119, 119, 119, 119, 119, 118, 117, 116, 114, 113, 111, 110, 108, 106, 104,
102, 99, 96, 93, 91, 89, 86, 83, 81, 79, 76, 74, 71, 70, 66, 64, 63, 60, 59, 57,
55, 54, 53, 51, 50, 49, 48, 47, 47, 46, 44, 44, 43, 43, 42, 41, 40, 40, 39, 38,
37, 35, 34, 32, 32, 30, 29, 26, 24, 22, 20, 18, 17, 15, 12, 10, 9, 7, 5, 3, 1,
-1, -3, -4, -5, -7, -7, -8, -11, -11, -12, -14, -14, -15, -15, -15, -16, -16,
-17, -17, -18, -18, -18, -18, -18, -18, -18, -18, -19, -19, -18, -18, -18, -17,
-18, -18, -17, -17, -16, -17, -17, -17, -18, -18, -18, -18, -20, -21, -22, -23,
-24, -25, -27, -29, -31, -32, -33, -34, -37, -39, -41, -42, -45, -46, -47, -50,
-51, -52, -53, -55, -57, -57, -59, -59, -60, -61, -60, -61, -62, -61, -62, -61,
-61, -61, -61, -60, -60, -59, -59, -58, -57, -57, -56, -56, -55, -54, -53, -53,
-52, -50, -50, -48, -47, -46, -45, -44, -43, -42, -40, -39, -39, -37, -37, -35,
-35, -34, -33, -32, -31, -32, -31, -32, -31, -31, -31, -32, -33, -32, -33, -34,
-36, -37, -39, -41, -43, -45, -46, -50, -51, -53, -56, -59, -62, -64, -67, -68,
-70, -72, -74, -75, -77, -78, -79, -80, -80, -80, -81, -79, -79, -78, -77, -75,
-74, -71, -70, -68, -66, -62, -60, -57, -55, -52, -48, -46, -43, -41, -39, -36,
-34, -32, -31, -29, -28, -25, -25, -24, -23, -23, -23, -22, -23, -22, -23, -22,
-23, -24, -23, -23, -24, -25, -25, -25, -26, -25, -26, -26, -25, -25, -24, -25,
-24, -24, -24, -24, -23, -22, -23, -23, -22, -22, -22, -23, -23, -22, -22, -24,
-23, -23, -25, -25, -25, -27, -28, -28, -29, -30, -31, -32, -34, -34, -36, -36,
-38, -38, -39, -41, -42, -44, -45, -46, -46, -48, -48, -48, -49, -50, -51, -51,
-52, -52, -52, -52, -52, -52, -51, -52, -51, -52, -50, -50, -48, -47, -47, -45,
-43, -42, -40, -38, -35, -34, -32, -29, -26, -24, -21, -19, -15, -12, -10, -6,
-5, -2, 0, 3, 6, 9, 11, 13, 15, 17, 18, 20, 20, 22, 22, 23, 24, 23, 23, 22, 21,
22, 21, 19, 18, 16, 16, 15, 13, 13, 10, 9, 8, 5, 5, 4, 2, 2, 0, -1, -1, -3, -4,
-4, -5, -6, -6, -6, -7, -6, -7, -7, -6, -5, -5, -4, -4, -4, -1, };