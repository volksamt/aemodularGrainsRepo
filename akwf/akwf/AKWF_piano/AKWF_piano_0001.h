#define DATA_LENGTH 512
#define DATA AKWF_piano_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 8, 11, 16, 20, 23, 26, 29, 30,
30, 31, 31, 29, 28, 29, 28, 29, 31, 32, 33, 37, 38, 39, 41, 43, 45, 46, 45, 46,
45, 43, 40, 38, 36, 34, 32, 29, 28, 29, 31, 34, 39, 46, 54, 63, 72, 82, 91, 98,
105, 111, 115, 117, 117, 114, 112, 107, 100, 93, 88, 81, 73, 66, 61, 55, 51, 46,
42, 39, 35, 31, 27, 21, 15, 9, 3, -1, -4, -6, -6, -4, 1, 6, 15, 24, 33, 42, 51,
58, 65, 70, 74, 77, 78, 79, 77, 75, 71, 66, 61, 54, 48, 41, 34, 27, 22, 16, 11,
6, 1, -5, -11, -17, -23, -29, -36, -42, -49, -56, -62, -67, -71, -76, -79, -83,
-85, -86, -86, -85, -84, -83, -80, -79, -76, -75, -72, -71, -68, -66, -64, -62,
-60, -58, -55, -52, -49, -45, -41, -34, -26, -19, -9, -1, 10, 19, 26, 35, 41,
45, 49, 51, 53, 52, 50, 48, 45, 43, 40, 39, 36, 35, 34, 35, 35, 36, 37, 39, 41,
43, 45, 47, 49, 51, 54, 59, 64, 69, 74, 81, 86, 90, 93, 94, 94, 94, 90, 87, 82,
77, 70, 64, 56, 50, 43, 38, 33, 30, 26, 25, 24, 22, 23, 24, 25, 28, 30, 33, 35,
38, 40, 42, 44, 45, 46, 46, 45, 43, 41, 39, 36, 32, 29, 27, 23, 20, 17, 14, 11,
8, 5, 3, 1, -1, -3, -5, -7, -9, -10, -11, -11, -12, -11, -10, -8, -7, -6, -5,
-5, -5, -6, -5, -6, -8, -8, -11, -14, -19, -24, -31, -39, -46, -54, -61, -66,
-71, -74, -76, -76, -75, -74, -71, -68, -65, -64, -62, -60, -60, -58, -56, -56,
-54, -53, -51, -51, -50, -51, -52, -53, -55, -56, -59, -61, -63, -64, -63, -61,
-57, -52, -45, -37, -28, -20, -12, -5, 2, 8, 12, 16, 19, 21, 22, 23, 22, 22, 20,
19, 15, 11, 5, -1, -9, -16, -23, -30, -37, -41, -45, -46, -46, -44, -41, -39,
-33, -28, -22, -17, -10, -3, 4, 12, 21, 29, 38, 46, 54, 60, 67, 72, 74, 76, 74,
71, 69, 63, 58, 54, 49, 47, 45, 43, 43, 44, 44, 44, 46, 49, 49, 50, 52, 53, 56,
58, 62, 66, 70, 73, 76, 78, 79, 78, 77, 73, 70, 65, 61, 56, 51, 45, 39, 33, 28,
22, 16, 10, 3, -3, -8, -12, -17, -20, -22, -24, -25, -27, -28, -29, -31, -33,
-34, -38, -42, -46, -52, -57, -63, -69, -75, -80, -86, -89, -93, -96, -99, -102,
-104, -107, -110, -114, -116, -118, -118, -119, -118, -116, -111, -105, -99,
-90, -81, -71, -61, -53, -45, -37, -32, -27, -25, -25, -25, -28, -33, -37, -45,
-51, -59, -66, -73, -80, -84, -90, -92, -94, -94, -94, -93, -92, -91, -90, -88,
-87, -87, -85, -83, -83, -81, -79, -76, -73, -70, -67, -62, -57, -52, -46, -39,
-35, -28, -23, -18, -15, -12, -11, -12, -11, -13, -13, -13, -12, -10, -6, -2, };