#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0031

const PROGMEM int8_t DATA[DATA_LENGTH] = {19, -65, 0, 104, 81, 93, 88, 87, 94,
52, 9, 24, 15, 22, 17, 21, 19, 19, 19, 19, 20, 19, 20, 18, 20, 17, 20, 18, 20,
18, 20, 19, 20, 18, 20, 19, 20, 19, 20, 19, 20, 20, 19, 19, 19, 19, 19, 19, 19,
20, 19, 20, 18, 21, 19, 20, 19, 21, 17, 20, 18, 21, 18, 20, 19, 20, 18, 21, 18,
20, 19, 19, 19, 18, 21, 17, 22, 16, 24, 14, 25, 12, 28, 10, 29, 11, -18, -19,
-9, -23, -5, -27, -1, 23, -65, -14, -14, -16, -15, -14, -20, -2, -69, 12, 9,
-27, -10, -16, -19, -7, -29, 16, 4, -67, -2, -22, -13, -15, -16, -14, -14, -68,
32, -10, -19, -15, -13, -21, -3, -50, -28, 36, -35, -5, -20, -14, -13, -21, -6,
23, -43, 27, 17, 19, 21, 17, 22, 15, 24, 15, 23, 15, 24, 15, 23, 16, 23, 17, 23,
17, 21, 18, 20, 18, 20, 19, 19, 19, 20, 20, 19, 20, 18, 19, 18, 19, 18, 20, 19,
19, 19, 20, 19, 19, 18, 20, 19, 20, 19, 20, 19, 19, 19, 19, 20, 19, 19, 19, 20,
19, 19, 19, 20, 20, 20, 19, 19, 20, 19, 19, 18, 19, 19, 19, 20, 19, 19, 19, 19,
18, 20, 20, 20, 19, 19, 20, 19, 19, 19, 19, 18, 20, 20, 19, 19, 19, 19, 19, 19,
19, 19, 20, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 18,
18, 19, 19, 18, 19, 19, 19, 19, 18, 20, 19, 19, 19, 19, 19, 19, 18, 19, 19, 19,
19, 19, 19, 19, 18, 19, 19, 19, 19, 19, 19, 20, 18, 19, 19, 18, 19, 19, 19, 18,
19, 19, 19, 19, 19, 19, 19, 19, 18, 19, 18, 18, 18, 19, 18, 19, 20, 19, 18, 19,
19, 18, 19, 18, 19, 18, 19, 18, 18, 19, 20, 18, 18, 18, 19, 19, 20, 18, 19, 18,
19, 19, 19, 20, 17, 20, 18, 20, 17, 20, 18, 21, 16, 21, 16, 21, 17, 21, 17, 20,
17, 19, 19, 17, 20, 15, 22, 13, 26, 10, 29, 4, 38, -13, -14, -21, -7, -28, 6,
16, -70, -6, -21, -13, -18, -12, -21, -4, -73, 24, -2, -22, -14, -14, -22, -4,
-42, -42, 38, -30, -8, -20, -14, -17, -16, -21, 37, -59, -26, -9, -21, -12, -17,
-19, -5, -56, -19, 32, -39, 0, -27, -8, -21, -14, -14, -27, -73, -5, -19, -59,
-45, -55, -48, -54, -47, -54, -48, -53, -48, -52, -49, -52, -49, -51, -49, -51,
-49, -51, -50, -50, -51, -49, -51, -50, -50, -49, -51, -50, -50, -50, -50, -51,
-51, -49, -50, -50, -50, -50, -50, -50, -50, -50, -50, -50, -50, -49, -50, -50,
-51, -50, -50, -50, -50, -49, -51, -50, -51, -49, -50, -50, -50, -50, -51, -50,
-51, -50, -50, -50, -50, -50, -49, -51, -48, -54, -44, -109, -122, -119, -119,
-122, -116, -124, -102, };