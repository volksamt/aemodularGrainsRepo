#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {17, 18, 25, 41, 38, 41, 58, 60, 59,
60, 60, 60, 60, 59, 60, 59, 59, 58, 62, 54, 38, 40, 39, 40, 40, 39, 39, 41, 24,
19, 21, 19, 21, 18, 20, 17, 23, 12, -3, 1, 0, 0, -1, 0, 0, 1, 0, 2, -5, -21,
-19, -20, -20, -20, -20, -19, -21, -19, -20, -19, -21, -19, -21, -19, -20, -20,
-20, -20, -20, -37, -41, -39, -41, -39, -40, -38, -40, -39, -40, -39, -40, -40,
-40, -40, -40, -39, -41, -40, -40, -39, -39, -40, -40, -39, -40, -40, -40, -40,
-40, -40, -39, -40, -39, -41, -39, -41, -38, -41, -28, -18, -21, -18, -20, -20,
-20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -21, -4, 1, -1, 1,
0, 1, 0, 1, -1, 1, -2, 15, 22, 18, 21, 19, 22, 18, 22, 39, 40, 39, 41, 39, 42,
38, 47, 61, 58, 61, 59, 59, 59, 59, 60, 59, 59, 59, 62, 48, 37, 42, 35, 21, 11,
-2, -12, -44, -56, -67, -81, -78, -95, -102, -118, -120, -118, -120, -118, -119,
-118, -120, -119, -120, -118, -121, -113, -97, -100, -98, -101, -96, -78, -80,
-79, -80, -77, -60, -59, -60, -59, -60, -40, -40, -40, -41, -39, -40, -37, -18,
-20, -19, -21, -19, -1, 1, -1, 0, -2, 18, 20, 20, 19, 32, 42, 37, 42, 37, 50,
62, 58, 60, 60, 60, 60, 59, 60, 39, 42, 31, 19, 8, -20, -41, -59, -65, -95,
-100, -100, -119, -119, -119, -119, -119, -118, -119, -118, -119, -119, -120,
-117, -99, -100, -99, -99, -99, -80, -80, -80, -79, -80, -63, -59, -60, -60,
-60, -60, -58, -40, -39, -40, -40, -41, -39, -41, -33, -18, -20, -20, -19, -21,
-19, -22, -6, 2, -1, 0, -1, 0, -1, 1, 20, 20, 19, 19, 20, 19, 22, 40, 39, 41,
39, 40, 39, 39, 40, 38, 54, 61, 59, 60, 60, 59, 60, 60, 59, 59, 60, 60, 60, 58,
59, 60, 60, 59, 60, 59, 60, 59, 60, 60, 42, 38, 40, 39, 40, 40, 39, 40, 40, 40,
39, 41, 39, 43, 32, 18, 21, 19, 20, 19, 20, 20, 20, 19, 19, 20, 21, 19, 20, 19,
22, 18, 30, 42, 39, 41, 39, 40, 40, 39, 40, 40, 40, 39, 40, 39, 40, 59, 60, 59,
59, 59, 60, 59, 59, 59, 61, 60, 61, 58, 60, 59, 60, 60, 60, 59, 60, 59, 61, 59,
61, 54, 38, 40, 40, 40, 40, 40, 40, 38, 41, 37, 20, 19, 21, 19, 22, 18, 22, 13,
-2, 1, 0, 0, 0, 0, 0, 0, -15, -22, -18, -21, -18, -21, -18, -22, -17, -29, -42,
-39, -40, -40, -40, -40, -41, -40, -58, -60, -59, -60, -60, -59, -60, -57, -68,
-82, -78, -79, -80, -78, -87, -101, -98, -100, -99, -97, -108, -122, -118, -120,
-118, -120, -119, -119, -120, -119, -119, -119, -120, -120, -119, -120, -116,
-95, -104, -83, -80, -77, -61, -53, -40, -28, 0, 0, };