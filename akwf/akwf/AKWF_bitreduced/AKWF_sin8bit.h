#define DATA_LENGTH 512
#define DATA AKWF_sin8bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 2, 3, 7, 7, 10, 11, 11, 14, 15,
16, 17, 20, 20, 21, 23, 24, 26, 28, 29, 29, 31, 34, 34, 36, 37, 39, 40, 41, 41,
45, 45, 47, 48, 50, 51, 52, 54, 55, 56, 57, 58, 59, 62, 62, 64, 65, 65, 66, 68,
69, 72, 72, 73, 75, 76, 77, 77, 79, 80, 82, 82, 83, 84, 84, 85, 86, 89, 88, 91,
91, 91, 94, 93, 95, 95, 96, 98, 97, 98, 100, 100, 101, 103, 102, 102, 105, 105,
104, 107, 108, 108, 107, 108, 109, 110, 110, 112, 112, 113, 113, 113, 113, 113,
115, 115, 115, 114, 116, 118, 117, 116, 116, 117, 116, 117, 117, 119, 118, 119,
119, 120, 119, 119, 119, 119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 118,
119, 119, 119, 119, 116, 116, 116, 117, 117, 116, 117, 116, 116, 115, 114, 114,
114, 115, 112, 112, 111, 111, 112, 110, 108, 108, 109, 106, 106, 106, 107, 107,
105, 104, 103, 101, 102, 101, 99, 100, 98, 96, 97, 96, 93, 94, 92, 90, 92, 91,
89, 88, 87, 87, 85, 83, 82, 82, 82, 80, 79, 77, 76, 74, 75, 73, 72, 70, 70, 69,
68, 66, 65, 63, 63, 63, 60, 59, 57, 56, 54, 52, 52, 51, 49, 48, 46, 46, 44, 43,
42, 39, 38, 37, 35, 37, 33, 31, 31, 29, 28, 26, 24, 23, 22, 21, 18, 18, 16, 14,
13, 12, 10, 10, 9, 6, 5, 4, 2, 0, 0, -4, -6, -6, -8, -9, -11, -11, -13, -14,
-17, -17, -17, -20, -22, -23, -25, -26, -27, -30, -31, -32, -33, -34, -36, -38,
-39, -40, -41, -44, -43, -44, -47, -48, -50, -52, -53, -54, -55, -56, -57, -58,
-60, -61, -63, -64, -64, -66, -67, -68, -69, -72, -71, -73, -75, -76, -77, -76,
-78, -81, -82, -82, -84, -83, -85, -86, -88, -89, -88, -92, -91, -92, -93, -93,
-95, -95, -97, -98, -98, -98, -100, -101, -101, -104, -103, -103, -104, -105,
-105, -106, -108, -107, -106, -108, -110, -110, -109, -112, -111, -112, -112,
-113, -115, -115, -114, -114, -114, -114, -116, -117, -118, -117, -116, -117,
-116, -117, -117, -119, -119, -119, -118, -119, -119, -120, -119, -118, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-116, -116, -117, -117, -116, -116, -116, -116, -115, -114, -114, -114, -113,
-114, -112, -111, -112, -111, -112, -110, -109, -109, -108, -107, -107, -106,
-106, -105, -104, -104, -103, -101, -101, -101, -99, -99, -98, -96, -96, -96,
-95, -94, -92, -91, -92, -90, -90, -88, -87, -87, -85, -85, -81, -82, -81, -80,
-79, -77, -76, -75, -75, -73, -71, -70, -71, -69, -67, -66, -64, -63, -62, -61,
-60, -59, -56, -56, -54, -53, -53, -51, -49, -48, -49, -46, -44, -43, -41, -41,
-39, -37, -35, -34, -32, -31, -29, -28, -27, -26, -25, -23, -20, -21, -20, -17,
-16, -15, -13, -11, -11, -9, -7, -6, -5, -3, -2, };