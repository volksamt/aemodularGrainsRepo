#define DATA_LENGTH 512
#define DATA AKWF_sin2bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 123, 114, 121, 115, 121, 115,
120, 116, 119, 117, 119, 117, 119, 117, 119, 117, 119, 118, 118, 118, 117, 118,
117, 118, 118, 117, 118, 119, 118, 118, 117, 118, 118, 118, 118, 118, 117, 118,
117, 118, 118, 118, 118, 118, 117, 117, 118, 117, 118, 118, 118, 118, 118, 118,
118, 118, 118, 117, 117, 118, 117, 117, 117, 117, 117, 118, 117, 117, 118, 118,
117, 117, 118, 117, 118, 117, 117, 118, 117, 117, 117, 116, 117, 117, 118, 117,
117, 118, 117, 117, 117, 116, 117, 117, 116, 117, 117, 117, 117, 117, 117, 116,
117, 116, 116, 117, 117, 117, 116, 117, 117, 117, 117, 117, 116, 117, 117, 117,
117, 117, 116, 117, 116, 116, 116, 116, 116, 117, 117, 116, 116, 116, 116, 116,
116, 115, 116, 116, 116, 116, 116, 116, 116, 115, 116, 116, 116, 116, 116, 116,
116, 116, 116, 117, 117, 115, 116, 116, 116, 116, 116, 116, 116, 115, 115, 116,
117, 115, 116, 115, 115, 115, 116, 116, 115, 115, 116, 116, 116, 116, 116, 116,
116, 116, 116, 116, 115, 115, 115, 116, 116, 115, 116, 116, 115, 115, 115, 115,
115, 115, 115, 116, 116, 114, 115, 116, 116, 115, 115, 115, 115, 115, 115, 115,
115, 115, 114, 115, 115, 115, 115, 115, 115, 116, 115, 116, 114, 116, 114, 115,
114, 116, 114, 115, 115, 115, 114, 115, 115, 115, 116, 114, 116, 113, 117, 112,
118, 111, 119, 110, 120, 107, 124, 102, 127, 72, -128, -114, -121, -119, -118,
-120, -118, -121, -117, -121, -117, -121, -116, -122, -118, -121, -118, -120,
-118, -121, -118, -120, -119, -119, -119, -120, -119, -119, -119, -118, -119,
-118, -120, -119, -119, -118, -119, -119, -120, -118, -119, -118, -119, -119,
-119, -118, -119, -119, -119, -118, -119, -118, -118, -118, -118, -119, -119,
-119, -118, -118, -118, -118, -119, -118, -119, -119, -119, -118, -119, -119,
-119, -119, -118, -119, -118, -119, -118, -119, -119, -119, -118, -119, -119,
-118, -119, -118, -118, -118, -118, -118, -119, -118, -118, -118, -118, -118,
-119, -119, -118, -118, -118, -117, -118, -117, -118, -118, -118, -118, -118,
-118, -117, -119, -118, -118, -118, -117, -118, -117, -118, -118, -119, -118,
-117, -118, -118, -117, -118, -117, -118, -118, -117, -117, -117, -117, -117,
-117, -118, -118, -118, -118, -117, -118, -117, -117, -117, -116, -117, -118,
-117, -117, -118, -117, -118, -118, -118, -117, -116, -118, -117, -117, -117,
-117, -117, -117, -117, -117, -117, -117, -118, -117, -117, -117, -117, -116,
-117, -117, -117, -118, -117, -117, -117, -117, -116, -117, -117, -116, -117,
-117, -117, -117, -117, -116, -117, -116, -117, -116, -117, -116, -116, -117,
-116, -116, -116, -116, -116, -116, -117, -116, -116, -116, -116, -116, -116,
-115, -116, -116, -116, -116, -116, -116, -117, -116, -116, -116, -116, -115,
-117, -115, -116, -115, -116, -116, -115, -116, -116, -117, -116, -116, -115,
-117, -115, -117, -115, -117, -114, -118, -114, -118, -114, -118, -112, -120,
-111, -123, -97, };