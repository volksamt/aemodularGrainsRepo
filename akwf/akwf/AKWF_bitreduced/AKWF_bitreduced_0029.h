#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0029

const PROGMEM int8_t DATA[DATA_LENGTH] = {31, 38, 35, 37, 35, 37, 35, 38, 36,
37, 36, 37, 35, 37, 36, 36, 36, 36, 36, 36, 37, 36, 37, 37, 36, 36, 36, 36, 37,
36, 37, 36, 36, 37, 36, 37, 36, 36, 36, 37, 36, 37, 37, 36, 36, 36, 36, 35, 37,
36, 36, 36, 36, 36, 36, 37, 36, 36, 35, 36, 37, 36, 37, 36, 37, 36, 36, 36, 36,
35, 36, 36, 36, 36, 36, 35, 36, 36, 36, 36, 37, 36, 36, 36, 36, 36, 36, 36, 36,
36, 36, 36, 36, 36, 37, 36, 36, 37, 35, 37, 36, 37, 35, 36, 35, 37, 36, 36, 36,
36, 37, 35, 37, 34, 42, -29, -54, -41, -50, -43, -50, -43, -50, -44, -50, -43,
-51, -41, -55, -25, 44, 33, 37, 35, 37, 36, 36, 36, 35, 36, 36, 36, 35, 36, 36,
35, 36, 36, 37, 36, 36, 35, 36, 35, 37, 35, 37, 36, 36, 36, 34, 40, -35, -53,
-43, -50, -44, -49, -44, -49, -45, -48, -45, -48, -45, -48, -45, -48, -46, -48,
-47, -47, -47, -45, -50, 21, 41, 31, 39, 34, 38, 35, 38, 35, 38, 35, 37, 35, 37,
36, 36, 37, 36, 36, 36, 37, 35, 37, 34, 38, 34, 38, 33, 39, 31, 45, 14, -54,
-44, -48, -45, -47, -47, -47, -48, -46, -47, -46, -47, -47, -48, -47, -48, -46,
-48, -46, -46, -47, -47, -47, -47, -47, -47, -46, -47, -47, -47, -46, -47, -47,
-46, -47, -47, -47, -47, -47, -48, -47, -47, -46, -47, -47, -47, -46, -46, -46,
-47, -47, -47, -47, -47, -47, -47, -47, -46, -47, -45, -48, -46, -48, -46, -48,
-45, -49, -45, -48, -45, -49, -43, -51, -39, 37, 37, 36, 37, 35, 37, 34, 38, 35,
37, 35, 36, 36, 36, 36, 37, 37, 36, 37, 35, 37, 35, 37, 35, 38, 34, 39, 33, 43,
118, 121, 118, 121, 116, 121, 116, 121, 117, 121, 118, 121, 117, 121, 118, 119,
119, 119, 120, 116, 126, 57, 28, 41, 33, 39, 34, 38, 35, 37, 35, 37, 36, 36, 36,
35, 36, 36, 36, 36, 36, 36, 35, 36, 35, 36, 35, 36, 35, 36, 34, 37, 34, 38, 34,
39, 31, 42, 19, -53, -45, -48, -47, -47, -48, -46, -48, -46, -47, -46, -48, -47,
-49, -46, -47, -46, -48, -47, -48, -46, -47, -47, -47, -46, -47, -46, -47, -48,
-47, -48, -47, -47, -47, -47, -47, -47, -47, -47, -46, -47, -47, -47, -47, -47,
-47, -47, -47, -47, -47, -46, -47, -47, -47, -46, -47, -48, -48, -47, -47, -46,
-46, -47, -47, -47, -47, -47, -46, -46, -47, -47, -47, -47, -47, -47, -47, -46,
-47, -47, -47, -46, -48, -46, -47, -47, -47, -46, -47, -46, -47, -46, -47, -46,
-47, -47, -47, -47, -46, -47, -46, -46, -47, -47, -47, -46, -46, -47, -46, -47,
-46, -47, -46, -47, -46, -47, -46, -47, -47, -46, -47, -46, -47, -47, -47, -45,
-48, -46, -47, -45, -48, -45, -49, -40, };