#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0027

const PROGMEM int8_t DATA[DATA_LENGTH] = {36, 43, 39, 42, 40, 41, 40, 41, 40,
41, 41, 41, 40, 41, 41, 41, 41, 40, 41, 40, 40, 41, 41, 40, 41, 40, 41, 41, 41,
41, 41, 40, 41, 41, 40, 40, 41, 40, 40, 41, 41, 41, 40, 40, 42, 40, 41, 40, 40,
41, 42, 41, 40, 40, 40, 42, 40, 40, 41, 41, 41, 41, 40, 41, 41, 40, 40, 41, 40,
41, 41, 41, 40, 41, 41, 41, 40, 40, 41, 41, 40, 40, 40, 41, 41, 41, 40, 40, 41,
40, 41, 41, 41, 40, 41, 40, 40, 40, 41, 41, 40, 40, 40, 41, 40, 41, 39, 41, 40,
41, 39, 42, 38, 43, 37, 44, 34, 58, 125, 118, 120, 118, 118, 120, 118, 120, 118,
121, 117, 121, 118, 121, 118, 121, 118, 119, 118, 119, 120, 50, 35, 43, 37, 42,
38, 42, 38, 42, 39, 41, 39, 40, 40, 41, 40, 41, 40, 40, 40, 40, 40, 40, 40, 40,
39, 40, 41, 39, 40, 40, 40, 39, 40, 39, 40, 40, 40, 39, 40, 39, 39, 41, 39, 39,
40, 40, 40, 39, 40, 40, 40, 40, 39, 40, 40, 40, 39, 41, 40, 41, 40, 40, 40, 40,
39, 40, 40, 40, 40, 40, 40, 39, 40, 40, 40, 40, 40, 39, 39, 39, 40, 39, 40, 39,
40, 40, 40, 40, 40, 39, 39, 40, 40, 40, 40, 40, 39, 39, 39, 40, 39, 41, 38, 41,
39, 40, 39, 41, 39, 40, 39, 40, 40, 39, 42, -30, -44, -37, -41, -37, -41, -38,
-41, -38, -41, -38, -40, -38, -39, -39, -40, -39, -40, -39, -39, -39, -39, -40,
-39, -40, -39, -40, -39, -40, -38, -40, -39, -39, -39, -39, -39, -39, -39, -38,
-39, -40, -39, -39, -39, -39, -39, -39, -39, -40, -39, -39, -38, -39, -39, -39,
-39, -39, -39, -39, -39, -38, -39, -38, -39, -38, -39, -39, -40, -38, -39, -40,
-39, -38, -38, -39, -39, -39, -39, -39, -38, -39, -39, -39, -39, -39, -39, -40,
-39, -40, -40, -39, -39, -39, -39, -40, -39, -39, -39, -39, -40, -38, -39, -38,
-40, -38, -40, -39, -40, -38, -41, -39, -40, -38, -39, -39, -37, -107, -122,
-114, -120, -115, -119, -116, -119, -116, -118, -116, -118, -118, -118, -117,
-116, -118, -116, -118, -116, -120, -114, -121, -113, -125, -94, -31, -41, -37,
-40, -38, -39, -39, -38, -39, -38, -38, -38, -38, -37, -39, -37, -39, -38, -39,
-38, -39, -38, -39, -38, -38, -38, -38, -38, -39, -38, -38, -38, -38, -38, -38,
-38, -39, -38, -37, -38, -38, -38, -38, -38, -39, -39, -38, -38, -38, -38, -37,
-37, -39, -38, -38, -38, -38, -39, -39, -38, -38, -37, -38, -38, -39, -39, -38,
-38, -38, -38, -38, -38, -38, -38, -39, -38, -38, -37, -38, -38, -38, -38, -38,
-38, -38, -38, -38, -38, -38, -39, -38, -38, -37, -37, -38, -38, -39, -38, -38,
-38, -38, -39, -38, -38, -37, -38, -37, -38, -37, -39, -37, -39, -36, -41, -33,
};