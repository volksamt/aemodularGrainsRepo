#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {52, 63, 58, 61, 58, 61, 58, 60, 59,
61, 58, 60, 58, 60, 58, 61, 58, 61, 59, 60, 59, 60, 59, 60, 61, 59, 62, 55, 105,
124, 116, 121, 117, 120, 117, 119, 119, 119, 119, 119, 119, 119, 120, 119, 120,
119, 119, 119, 119, 119, 119, 120, 66, 56, 62, 57, 63, 56, 65, 52, 74, -1, -75,
-51, -66, -54, -64, -56, -62, -57, -4, 2, 0, 0, 1, -1, 3, -6, 12, -71, -127,
-111, -125, -115, -122, -117, -121, -117, -121, -118, -120, -118, -119, -118,
-119, -119, -117, -123, -68, -56, -62, -58, -60, -59, -60, -59, -60, -58, -60,
-59, -60, -59, -61, -59, -59, -59, -60, -60, -59, -61, -60, -60, -59, -60, -60,
-59, -60, -59, -60, -60, -60, -60, -59, -59, -60, -60, -60, -59, -59, -60, -60,
-60, -60, -59, -60, -60, -60, -59, -59, -59, -60, -60, -60, -60, -60, -60, -60,
-60, -59, -61, -58, -61, -57, -63, -52, -87, -127, -115, -121, -118, -120, -118,
-120, -118, -120, -118, -119, -118, -119, -120, -119, -119, -119, -119, -119,
-120, -120, -119, -119, -120, -119, -120, -119, -120, -118, -121, -117, -121,
-115, -126, -90, -52, -63, -58, -62, -59, -60, -60, -59, -60, -60, -60, -59,
-61, -59, -61, -59, -60, -59, -59, -59, -60, -60, -58, -64, -15, 5, -3, 2, -1,
0, 0, -1, 4, -7, 31, 66, 56, 63, 57, 61, 58, 61, 58, 60, 59, 61, 59, 61, 57, 64,
54, 85, 127, 115, 122, 117, 122, 117, 120, 117, 121, 117, 121, 117, 121, 115,
125, 105, 54, 62, 59, 61, 60, 60, 59, 59, 59, 59, 60, 59, 60, 59, 60, 59, 59,
60, 58, 60, 58, 62, 56, 66, 30, -8, 3, -3, 2, -1, 1, 0, 1, -1, 1, -1, 0, 0, 0,
0, 0, 0, -1, 0, 0, 0, 0, 1, -1, 1, -1, 2, -3, 7, -39, -65, -56, -62, -57, -61,
-58, -61, -58, -60, -59, -60, -60, -59, -59, -59, -60, -59, -60, -59, -59, -60,
-60, -59, -60, -60, -60, -60, -60, -60, -59, -59, -60, -59, -60, -59, -60, -60,
-60, -59, -59, -59, -60, -59, -59, -60, -60, -60, -60, -60, -60, -59, -59, -59,
-60, -59, -59, -59, -59, -59, -59, -59, -59, -60, -60, -59, -60, -59, -59, -60,
-60, -60, -59, -60, -60, -59, -59, -59, -59, -59, -60, -60, -60, -60, -60, -59,
-59, -59, -60, -59, -60, -59, -59, -58, -60, -59, -59, -59, -60, -59, -60, -59,
-60, -59, -60, -59, -59, -60, -58, -61, -54, -105, -123, -116, -121, -117, -121,
-118, -120, -118, -120, -119, -120, -119, -119, -119, -118, -120, -119, -119,
-118, -120, -118, -119, -121, -68, -56, -62, -57, -61, -59, -60, -59, -61, -59,
-60, -59, -60, -59, -60, -60, -60, -59, -59, -59, -60, -59, -60, -58, -62, -56,
-66, -25, 8, -4, 3, -1, 2, -1, 1, -1, 0, 0, 0, -1, 0, 0, -1, 0, 1, 0, 0, 0, -1,
0, -1, 0, -1, 0, };