#define DATA_LENGTH 512
#define DATA AKWF_sin5bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 12, 12, 12, 12, 13, 12, 11, 12,
12, 13, 11, 13, 9, 21, 37, 32, 34, 33, 34, 32, 34, 33, 33, 33, 34, 33, 35, 33,
35, 54, 55, 55, 56, 55, 55, 55, 54, 55, 55, 55, 54, 57, 52, 67, 79, 74, 78, 76,
77, 75, 77, 76, 77, 75, 77, 76, 77, 75, 78, 74, 87, 100, 96, 98, 98, 98, 98, 98,
98, 98, 98, 97, 97, 97, 97, 97, 97, 98, 97, 97, 98, 97, 98, 94, 111, 121, 118,
120, 119, 119, 118, 119, 118, 119, 118, 118, 119, 119, 118, 119, 119, 118, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 118, 119, 119, 118, 119,
118, 119, 119, 118, 118, 118, 118, 119, 118, 118, 118, 118, 118, 119, 118, 118,
119, 118, 117, 118, 118, 119, 118, 119, 119, 118, 118, 118, 119, 118, 118, 118,
118, 117, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 117, 117,
117, 119, 116, 120, 103, 94, 98, 95, 96, 96, 96, 96, 97, 96, 95, 96, 96, 96, 97,
97, 96, 96, 96, 96, 97, 95, 98, 83, 71, 76, 73, 75, 73, 74, 74, 75, 74, 74, 74,
75, 74, 74, 75, 73, 76, 59, 50, 53, 51, 53, 52, 52, 53, 53, 53, 52, 53, 51, 54,
48, 30, 32, 31, 31, 31, 31, 31, 30, 31, 31, 31, 31, 30, 33, 16, 7, 11, 9, 11,
10, 9, 9, 10, 10, 9, 10, 9, 11, 6, -14, -12, -12, -12, -11, -13, -11, -13, -11,
-13, -12, -14, -10, -23, -36, -32, -34, -33, -34, -34, -34, -34, -33, -34, -33,
-34, -33, -35, -54, -55, -55, -56, -55, -56, -55, -55, -55, -56, -54, -55, -54,
-56, -52, -70, -78, -76, -76, -76, -77, -75, -77, -76, -77, -76, -77, -76, -77,
-75, -78, -75, -90, -100, -96, -99, -98, -99, -98, -98, -98, -98, -98, -98, -98,
-97, -97, -98, -98, -98, -97, -98, -98, -98, -96, -109, -121, -118, -120, -119,
-119, -119, -120, -118, -119, -118, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -118, -119,
-118, -119, -119, -118, -118, -119, -118, -119, -118, -118, -118, -119, -118,
-118, -119, -119, -119, -119, -118, -118, -119, -118, -118, -119, -117, -118,
-119, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -118, -118, -118, -117, -118, -117, -118,
-118, -118, -118, -117, -120, -102, -95, -97, -95, -97, -96, -97, -95, -96, -96,
-97, -96, -96, -96, -96, -96, -96, -96, -96, -97, -96, -96, -95, -97, -78, -73,
-75, -74, -75, -73, -75, -74, -75, -74, -75, -74, -74, -75, -73, -76, -60, -50,
-54, -51, -54, -52, -53, -53, -54, -53, -53, -52, -54, -51, -55, -46, -29, -32,
-31, -31, -31, -31, -31, -31, -31, -31, -32, -32, -31, -33, -14, -8, -11, -8,
-11, -9, -10, -9, -10, -9, -10, -9, -10, -9, };