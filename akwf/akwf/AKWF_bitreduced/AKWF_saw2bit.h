#define DATA_LENGTH 512
#define DATA AKWF_saw2bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 115, 122, 116, 120, 116,
121, 117, 120, 118, 120, 118, 120, 118, 119, 118, 119, 118, 119, 118, 118, 119,
119, 119, 118, 118, 118, 119, 118, 119, 118, 119, 119, 119, 119, 120, 118, 119,
118, 118, 118, 118, 118, 118, 119, 118, 119, 119, 118, 118, 118, 119, 118, 119,
118, 119, 119, 118, 119, 118, 119, 119, 119, 118, 117, 119, 119, 118, 118, 117,
118, 118, 118, 119, 117, 118, 117, 118, 118, 118, 118, 118, 117, 118, 118, 118,
118, 118, 118, 117, 118, 117, 118, 117, 117, 118, 118, 119, 117, 117, 117, 118,
118, 117, 117, 117, 117, 117, 118, 117, 117, 117, 117, 118, 118, 118, 117, 118,
117, 118, 118, 118, 116, 117, 117, 118, 118, 117, 116, 118, 117, 117, 117, 117,
117, 117, 117, 117, 117, 118, 117, 118, 117, 117, 116, 117, 117, 117, 117, 117,
117, 117, 116, 117, 117, 117, 117, 116, 117, 117, 116, 118, 116, 116, 117, 116,
116, 117, 117, 116, 117, 116, 116, 116, 117, 117, 117, 116, 116, 116, 116, 116,
117, 117, 117, 117, 116, 116, 117, 117, 116, 117, 117, 116, 117, 116, 116, 116,
116, 117, 116, 116, 116, 115, 117, 116, 116, 116, 116, 116, 115, 116, 116, 115,
116, 116, 115, 116, 116, 116, 116, 116, 115, 116, 115, 116, 114, 116, 116, 116,
114, 116, 116, 116, 115, 116, 115, 115, 116, 115, 116, 114, 117, 113, 119, 113,
119, 111, 119, 110, 121, 108, 123, 105, 127, 73, -128, -114, -120, -119, -118,
-121, -116, -121, -117, -121, -117, -121, -116, -121, -116, -121, -118, -120,
-117, -120, -118, -120, -119, -119, -119, -119, -120, -119, -119, -119, -120,
-119, -119, -119, -119, -118, -119, -118, -120, -119, -119, -118, -119, -119,
-120, -119, -118, -118, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -118, -119, -119, -118, -118, -119, -119, -119, -118, -118, -119,
-118, -119, -118, -118, -119, -119, -118, -118, -118, -119, -118, -119, -118,
-118, -118, -118, -118, -118, -119, -118, -118, -118, -118, -118, -118, -118,
-118, -118, -118, -117, -118, -117, -117, -118, -118, -118, -118, -118, -118,
-117, -117, -118, -117, -118, -118, -118, -118, -117, -118, -119, -117, -118,
-117, -118, -117, -117, -118, -117, -118, -118, -117, -117, -117, -117, -117,
-117, -118, -118, -117, -118, -118, -117, -118, -117, -117, -118, -117, -118,
-117, -117, -117, -117, -118, -117, -117, -116, -117, -117, -118, -116, -118,
-117, -117, -117, -117, -117, -117, -117, -116, -117, -117, -117, -117, -117,
-117, -117, -117, -117, -116, -117, -117, -117, -116, -117, -117, -117, -117,
-116, -117, -116, -117, -117, -117, -116, -117, -117, -116, -116, -116, -116,
-116, -117, -116, -116, -116, -117, -117, -116, -116, -116, -116, -116, -116,
-116, -117, -116, -116, -116, -117, -116, -116, -115, -116, -116, -116, -116,
-117, -116, -117, -116, -117, -115, -116, -116, -116, -116, -115, -116, -116,
-116, -115, -117, -114, -117, -113, -117, -114, -118, -113, -119, -112, -120,
-111, -123, -99, };