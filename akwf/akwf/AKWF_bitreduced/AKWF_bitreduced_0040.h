#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0040

const PROGMEM int8_t DATA[DATA_LENGTH] = {32, 38, 35, 39, 36, 37, 37, 39, 36,
37, 37, 37, 37, 37, 37, 37, 37, 37, 37, 38, 37, 37, 37, 38, 37, 37, 37, 37, 37,
37, 37, 36, 36, 37, 37, 37, 37, 37, 37, 38, 37, 36, 37, 37, 37, 37, 37, 37, 37,
37, 37, 37, 37, 37, 36, 37, 37, 36, 37, 37, 37, 37, 37, 37, 37, 36, 37, 38, 37,
37, 37, 37, 37, 37, 37, 37, 37, 38, 36, 37, 36, 37, 37, 38, 37, 37, 37, 37, 37,
37, 37, 37, 37, 36, 37, 36, 37, 36, 38, 35, 39, 34, 38, 34, 42, 24, -45, -40,
-42, -41, -41, -41, -40, -42, -41, -41, -40, -41, -40, -42, -40, -42, -41, -41,
-41, -42, -40, -41, -41, -41, -41, -41, -41, -41, -41, -41, -42, -41, -41, -40,
-41, -40, -41, -41, -42, -41, -42, -41, -41, -41, -41, -40, -41, -41, -41, -41,
-41, -40, -40, -41, -41, -42, -41, -42, -41, -41, -41, -41, -41, -41, -40, -41,
-40, -41, -40, -41, -40, -41, -40, -41, -40, -42, -40, -42, -40, -41, -41, -41,
-41, -40, -42, -38, -43, -36, -50, 6, 46, 32, 40, 34, 39, 35, 39, 36, 38, 37,
37, 38, 37, 37, 37, 37, 36, 38, 37, 37, 37, 38, 36, 37, 37, 38, 37, 37, 37, 37,
37, 38, 36, 36, 37, 37, 37, 38, 38, 38, 36, 36, 37, 37, 37, 37, 37, 37, 37, 37,
37, 37, 37, 36, 36, 37, 37, 38, 36, 37, 36, 37, 38, 37, 37, 36, 37, 37, 36, 37,
37, 37, 36, 37, 37, 38, 36, 37, 37, 37, 37, 37, 36, 36, 37, 36, 37, 37, 36, 37,
37, 37, 37, 37, 37, 37, 37, 36, 36, 37, 36, 36, 37, 36, 37, 37, 37, 36, 36, 36,
38, 36, 37, 37, 37, 37, 36, 37, 38, 36, 37, 36, 37, 37, 37, 36, 37, 36, 36, 37,
37, 36, 37, 37, 36, 36, 36, 37, 35, 38, 36, 37, 36, 38, 36, 36, 37, 36, 36, 36,
37, 37, 37, 36, 37, 35, 38, 35, 38, 34, 38, 33, 41, 32, 42, 20, -73, -128, -55,
-44, -107, -37, -42, -42, -41, -43, -40, -43, -40, -43, -39, -43, -39, -43, -40,
-43, -40, -42, -40, -42, -41, -41, -41, -42, -42, -42, -41, -41, -41, -41, -41,
-41, -41, -41, -42, -41, -41, -42, -42, -41, -41, -41, -42, -41, -41, -41, -41,
-40, -41, -41, -41, -42, -41, -41, -41, -41, -41, -40, -41, -42, -41, -41, -41,
-42, -41, -42, -42, -42, -41, -41, -41, -42, -42, -41, -41, -41, -41, -41, -41,
-41, -41, -41, -41, -41, -41, -41, -41, -41, -40, -40, -41, -41, -41, -42, -41,
-41, -41, -40, -41, -41, -41, -41, -41, -41, -41, -41, -42, -41, -41, -41, -41,
-41, -41, -41, -40, -41, -40, -41, -40, -40, -40, -41, -40, -41, -41, -41, -40,
-41, -40, -41, -41, -40, -41, -41, -41, -40, -41, -40, -42, -40, -42, -40, -42,
-38, -43, -35, };