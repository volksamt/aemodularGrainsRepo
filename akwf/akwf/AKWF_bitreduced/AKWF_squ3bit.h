#define DATA_LENGTH 512
#define DATA AKWF_squ3bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 125, 115, 122, 116, 121, 116,
120, 117, 121, 117, 120, 117, 120, 119, 120, 119, 119, 118, 118, 119, 120, 119,
119, 119, 118, 119, 119, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 118, 119, 119, 119, 119, 118, 119, 118, 119, 118, 118, 118, 118,
118, 118, 119, 118, 118, 118, 119, 119, 119, 118, 118, 119, 119, 119, 118, 118,
118, 118, 119, 118, 119, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118,
118, 119, 117, 118, 118, 118, 118, 118, 118, 119, 118, 118, 118, 118, 118, 118,
118, 118, 118, 118, 117, 118, 117, 117, 117, 118, 117, 118, 117, 119, 118, 118,
117, 117, 117, 118, 118, 118, 117, 117, 118, 117, 117, 118, 117, 118, 118, 117,
117, 117, 117, 118, 118, 117, 118, 117, 117, 117, 117, 117, 117, 117, 117, 117,
116, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 118, 117, 117,
117, 117, 117, 117, 117, 117, 117, 117, 116, 117, 117, 116, 116, 116, 116, 116,
116, 116, 116, 117, 117, 116, 117, 117, 116, 116, 117, 117, 117, 117, 117, 117,
116, 116, 116, 116, 116, 117, 116, 116, 116, 116, 117, 116, 116, 116, 116, 116,
115, 116, 116, 116, 116, 116, 116, 116, 115, 116, 115, 117, 115, 116, 115, 116,
116, 116, 115, 116, 115, 115, 116, 115, 116, 115, 117, 115, 118, 114, 118, 113,
119, 112, 119, 111, 120, 111, 121, 110, 64, 6, -126, -118, -118, -121, -117,
-121, -116, -121, -117, -121, -117, -121, -118, -121, -117, -121, -118, -121,
-117, -120, -118, -120, -119, -119, -120, -119, -119, -118, -119, -119, -120,
-119, -119, -119, -120, -118, -118, -119, -119, -119, -119, -119, -119, -118,
-118, -119, -118, -119, -118, -119, -118, -119, -118, -118, -118, -118, -118,
-118, -118, -118, -118, -119, -119, -119, -119, -119, -118, -119, -118, -119,
-118, -118, -118, -118, -119, -119, -118, -118, -119, -118, -118, -118, -119,
-118, -119, -118, -119, -118, -118, -119, -118, -118, -119, -119, -118, -118,
-119, -117, -119, -117, -118, -118, -118, -118, -118, -118, -118, -118, -118,
-117, -118, -119, -118, -117, -117, -117, -118, -118, -118, -118, -117, -118,
-118, -117, -117, -118, -118, -117, -117, -118, -117, -117, -117, -117, -117,
-117, -118, -118, -118, -117, -117, -117, -117, -117, -117, -116, -118, -118,
-117, -117, -118, -117, -117, -117, -117, -118, -117, -117, -117, -117, -117,
-117, -117, -117, -117, -117, -117, -118, -117, -117, -116, -116, -118, -117,
-118, -117, -116, -117, -117, -117, -117, -117, -116, -116, -117, -117, -117,
-117, -117, -116, -117, -117, -116, -116, -116, -117, -117, -116, -117, -116,
-117, -116, -117, -117, -117, -116, -116, -116, -116, -116, -116, -117, -116,
-116, -115, -116, -117, -116, -116, -116, -116, -116, -116, -117, -115, -115,
-117, -116, -116, -116, -117, -115, -116, -116, -117, -115, -116, -116, -116,
-115, -116, -115, -116, -116, -117, -116, -116, -116, -117, -116, -117, -116,
-116, -115, -35, };