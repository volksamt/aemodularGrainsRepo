#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0033

const PROGMEM int8_t DATA[DATA_LENGTH] = {35, 42, 38, 42, 39, 41, 39, 41, 39,
41, 39, 41, 40, 41, 41, 40, 40, 40, 40, 40, 40, 40, 40, 40, 41, 40, 40, 40, 41,
40, 40, 40, 40, 40, 40, 40, 41, 40, 40, 40, 41, 41, 40, 40, 39, 40, 40, 40, 40,
40, 40, 40, 40, 39, 41, 41, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40,
40, 41, 40, 40, 41, 39, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 39, 40, 40, 40,
40, 40, 39, 40, 41, 40, 40, 40, 40, 39, 40, 39, 40, 40, 40, 39, 40, 40, 40, 40,
40, 40, 41, 40, 40, 40, 40, 40, 41, 39, 39, 39, 39, 39, 40, 39, 39, 39, 40, 40,
41, 39, 40, 40, 40, 39, 40, 40, 40, 40, 40, 40, 40, 39, 40, 40, 39, 40, 38, 40,
38, 41, 36, 44, 31, 82, 127, 112, 123, 115, 122, 116, 122, 116, 121, 117, 120,
117, 120, 113, 41, 39, 40, 38, 40, 39, 40, 38, 41, 38, 39, 38, 40, 39, 39, 38,
39, 39, 40, 39, 39, 39, 39, 39, 39, 40, 39, 38, 39, 39, 40, 39, 39, 39, 39, 39,
39, 39, 38, 40, 39, 39, 38, 39, 39, 39, 39, 39, 40, 39, 40, 39, 38, 40, 39, 38,
39, 38, 40, 38, 39, 38, 39, 40, 38, 39, 38, 39, 39, 39, 39, 40, 38, 39, 38, 39,
38, 41, 38, 40, 38, 41, 38, 41, 37, 41, 33, -40, -41, -40, -42, -39, -42, -39,
-41, -39, -41, -39, -41, -40, -41, -40, -41, -39, -41, -39, -40, -39, -41, -40,
-40, -41, -40, -41, -40, -41, -41, -40, -40, -40, -40, -40, -41, -40, -40, -40,
-40, -41, -40, -40, -40, -40, -40, -40, -40, -40, -40, -40, -40, -40, -40, -40,
-41, -40, -41, -40, -40, -40, -40, -40, -40, -40, -41, -40, -41, -40, -41, -41,
-40, -40, -39, -40, -41, -40, -41, -39, -40, -39, -41, -38, -42, -38, -43, -35,
-54, -124, -117, -120, -119, -119, -119, -118, -120, -117, -120, -116, -121,
-114, -128, -65, -32, -43, -37, -42, -37, -42, -39, -41, -38, -40, -40, -40,
-40, -40, -40, -40, -39, -39, -40, -39, -40, -39, -41, -39, -39, -39, -40, -39,
-39, -39, -39, -40, -40, -39, -40, -39, -40, -39, -39, -39, -40, -39, -39, -39,
-40, -40, -39, -39, -40, -40, -40, -39, -39, -39, -40, -39, -39, -40, -39, -39,
-39, -39, -39, -39, -39, -39, -40, -40, -40, -40, -39, -40, -39, -38, -39, -39,
-39, -39, -39, -39, -39, -40, -39, -39, -39, -39, -39, -39, -39, -39, -39, -40,
-39, -40, -39, -40, -40, -39, -39, -40, -39, -40, -40, -39, -39, -39, -39, -39,
-39, -39, -39, -39, -39, -39, -39, -39, -40, -39, -39, -39, -39, -39, -40, -39,
-39, -39, -39, -39, -39, -38, -39, -39, -39, -39, -39, -38, -39, -39, -39, -39,
-39, -39, -39, -40, -38, -40, -39, -40, -38, -40, -37, -42, -33, };