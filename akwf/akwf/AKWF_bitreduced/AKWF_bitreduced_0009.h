#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {17, 20, 20, 20, 21, 19, 22, 40, 39,
39, 40, 38, 41, 37, 48, 61, 58, 60, 60, 60, 59, 60, 59, 77, 80, 79, 79, 79, 81,
78, 81, 79, 81, 78, 96, 101, 99, 99, 99, 100, 99, 100, 99, 100, 99, 99, 99, 99,
99, 99, 99, 100, 99, 99, 99, 99, 99, 99, 99, 99, 99, 100, 99, 99, 99, 99, 99,
99, 100, 99, 99, 100, 100, 99, 98, 99, 99, 98, 100, 99, 99, 99, 99, 99, 98, 98,
99, 99, 99, 99, 99, 99, 100, 100, 99, 99, 100, 99, 99, 99, 99, 99, 99, 100, 99,
99, 100, 98, 99, 99, 99, 99, 99, 99, 100, 99, 99, 99, 99, 99, 100, 99, 100, 99,
99, 98, 99, 99, 99, 99, 99, 100, 99, 99, 99, 99, 99, 100, 100, 99, 99, 100, 99,
100, 99, 99, 99, 99, 99, 99, 99, 99, 100, 99, 98, 100, 99, 99, 99, 99, 100, 99,
101, 97, 103, 90, 78, 80, 79, 79, 79, 78, 80, 78, 81, 76, 59, 59, 61, 59, 60,
58, 63, 49, 37, 40, 39, 40, 39, 42, 25, 18, 20, 19, 20, 19, 21, 2, -1, 2, -1, 1,
-1, 2, -4, -20, -19, -20, -21, -18, -21, -17, -30, -41, -39, -40, -39, -40, -39,
-40, -39, -40, -38, -47, -62, -58, -61, -59, -60, -59, -60, -59, -60, -60, -59,
-60, -60, -60, -59, -61, -57, -70, -82, -78, -80, -78, -79, -79, -80, -80, -79,
-79, -79, -80, -79, -80, -79, -79, -79, -80, -80, -80, -79, -79, -79, -79, -80,
-79, -79, -79, -80, -79, -80, -79, -81, -71, -57, -61, -58, -60, -59, -60, -59,
-59, -60, -60, -59, -60, -60, -60, -58, -60, -57, -69, -82, -79, -80, -79, -80,
-79, -80, -79, -79, -79, -79, -80, -79, -79, -79, -79, -79, -80, -79, -81, -78,
-81, -77, -92, -101, -98, -100, -99, -99, -99, -100, -99, -99, -99, -98, -100,
-98, -101, -117, -119, -119, -119, -120, -120, -119, -119, -119, -119, -119,
-120, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -120, -119, -120, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -122, -107, -97, -101, -99, -100, -98, -100, -99,
-100, -99, -100, -99, -100, -98, -81, -79, -80, -79, -80, -79, -80, -78, -79,
-78, -80, -79, -80, -78, -80, -78, -80, -78, -60, -60, -59, -59, -60, -60, -60,
-60, -59, -60, -60, -59, -59, -59, -59, -60, -60, -59, -60, -60, -60, -60, -60,
-60, -59, -59, -60, -60, -60, -59, -59, -60, -59, -60, -59, -59, -60, -59, -59,
-59, -60, -60, -59, -60, -59, -60, -59, -59, -59, -60, -60, -59, -60, -59, -59,
-60, -59, -59, -60, -60, -59, -59, -60, -60, -60, -59, -60, -59, -60, -59, -59,
-59, -60, -60, -60, -59, -61, -51, -37, -41, -39, -40, -40, -40, -39, -40, -40,
-39, -43, -30, -17, -21, -18, -20, -20, -19, -21, -3, 1, 0, 0, -1, 1, 0, 1, };