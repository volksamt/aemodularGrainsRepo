#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {21, 24, 24, 25, 22, 24, 23, 24, 23,
24, 23, 24, 24, 24, 24, 23, 24, 24, 24, 24, 24, 22, 42, 50, 45, 49, 46, 50, 46,
50, 44, 57, 74, 71, 72, 71, 72, 71, 72, 71, 71, 72, 71, 71, 72, 71, 92, 96, 94,
96, 95, 95, 94, 95, 94, 96, 95, 95, 94, 96, 94, 96, 94, 95, 93, 97, 92, 108,
122, 118, 120, 118, 120, 119, 120, 119, 120, 118, 119, 119, 119, 118, 119, 119,
120, 120, 119, 120, 119, 119, 120, 120, 119, 119, 118, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 120, 120, 120,
119, 120, 119, 120, 119, 120, 116, 94, 96, 96, 95, 96, 95, 96, 95, 96, 95, 96,
95, 97, 94, 97, 95, 97, 90, 70, 72, 71, 71, 72, 71, 72, 71, 71, 71, 71, 71, 71,
72, 71, 71, 72, 71, 72, 72, 72, 71, 73, 71, 74, 59, 45, 49, 47, 48, 48, 49, 47,
48, 48, 47, 49, 47, 50, 45, 51, 38, 21, 25, 23, 24, 23, 25, 23, 23, 24, 24, 24,
23, 24, 24, 24, 24, 24, 24, 23, 25, 22, 26, 15, -3, 1, -1, 1, 0, 0, -1, 0, 0, 0,
0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0,
0, 1, -1, 0, 0, 0, 0, 0, 1, -1, 0, -1, 1, 0, 0, 0, 0, 1, 0, 0, 1, -1, 0, 0, 0,
0, 1, 0, 1, 0, 1, -23, -24, -24, -24, -24, -24, 1, -2, 2, -14, -27, -22, -25,
-23, -25, -23, -25, -23, -25, -23, -24, -24, -25, -24, -23, -24, -24, -24, -24,
-24, -23, -25, -21, -41, -49, -46, -48, -47, -49, -47, -49, -47, -50, -45, -63,
-74, -70, -73, -70, -72, -71, -72, -70, -72, -72, -71, -71, -71, -71, -71, -71,
-72, -72, -72, -71, -72, -71, -70, -72, -71, -72, -71, -72, -71, -72, -71, -71,
-72, -72, -71, -72, -93, -96, -94, -97, -93, -97, -94, -96, -95, -96, -94, -97,
-94, -97, -94, -96, -95, -76, -93, -97, -93, -96, -94, -96, -95, -96, -94, -96,
-95, -96, -94, -96, -95, -96, -94, -95, -96, -94, -95, -94, -96, -95, -96, -94,
-96, -93, -97, -93, -103, -121, -119, -120, -119, -119, -118, -120, -119, -118,
-120, -118, -119, -119, -118, -119, -119, -119, -119, -118, -120, -119, -119,
-119, -120, -118, -118, -119, -120, -119, -119, -119, -119, -118, -119, -119,
-120, -119, -120, -117, -96, -96, -95, -95, -95, -95, -96, -95, -95, -94, -96,
-95, -97, -95, -95, -95, -96, -94, -98, -84, -69, -73, -70, -72, -69, -75, -56,
-46, -49, -48, -48, -47, -48, -48, -47, -49, -39, -21, -25, -23, -24, -23, -24,
-24, -24, -24, -24, -24, -24, -24, -24, -25, -24, -25, -23, -26, -4, 1, -2, 0,
-1, 1, 0, 1, -1, 0, 0, 1, -1, 0, };