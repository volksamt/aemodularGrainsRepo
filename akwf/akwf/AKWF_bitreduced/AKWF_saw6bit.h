#define DATA_LENGTH 512
#define DATA AKWF_saw6bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 6, 6, 6, 5, 5, 6, 5, 6, 6, 5, 6, 5,
6, 6, 6, 5, 5, 4, 6, 4, 11, 16, 15, 16, 14, 16, 14, 15, 15, 15, 15, 15, 15, 15,
15, 16, 15, 16, 15, 16, 14, 18, 25, 24, 25, 24, 25, 24, 25, 23, 25, 25, 24, 24,
24, 24, 24, 24, 24, 24, 25, 24, 24, 33, 34, 34, 34, 34, 34, 34, 34, 35, 34, 34,
34, 33, 34, 34, 34, 34, 34, 34, 34, 32, 39, 44, 43, 44, 43, 44, 44, 44, 43, 44,
43, 43, 43, 44, 43, 43, 43, 44, 43, 43, 43, 46, 53, 52, 53, 52, 52, 53, 52, 52,
53, 52, 53, 53, 52, 53, 53, 52, 53, 53, 52, 53, 53, 61, 62, 62, 62, 62, 62, 61,
62, 62, 62, 61, 62, 63, 62, 61, 62, 62, 62, 62, 61, 66, 73, 70, 71, 72, 71, 71,
71, 71, 72, 71, 71, 71, 72, 71, 70, 71, 71, 72, 70, 72, 70, 74, 82, 80, 81, 81,
80, 81, 80, 80, 80, 81, 80, 80, 80, 80, 80, 80, 80, 81, 81, 80, 89, 91, 90, 91,
89, 90, 89, 90, 89, 89, 90, 90, 90, 90, 89, 89, 89, 90, 89, 90, 88, 95, 100, 98,
100, 98, 99, 99, 99, 98, 100, 99, 99, 99, 99, 99, 99, 98, 99, 99, 98, 100, 97,
102, 109, 108, 108, 109, 107, 110, 106, 110, 106, 111, 105, 111, 104, 112, 104,
112, 103, 113, 102, 116, 101, -115, -120, -105, -114, -106, -113, -106, -114,
-107, -113, -107, -113, -108, -111, -108, -111, -108, -110, -109, -110, -109,
-110, -109, -101, -100, -100, -100, -100, -101, -99, -101, -99, -100, -100,
-100, -99, -101, -99, -100, -101, -101, -100, -100, -101, -94, -90, -91, -90,
-91, -90, -90, -90, -91, -91, -90, -91, -91, -91, -91, -91, -91, -90, -91, -90,
-91, -88, -79, -81, -80, -80, -81, -81, -80, -81, -81, -80, -81, -81, -81, -81,
-81, -81, -80, -82, -80, -80, -80, -71, -71, -71, -72, -71, -70, -71, -72, -70,
-72, -71, -70, -72, -71, -71, -71, -71, -71, -71, -71, -72, -65, -60, -61, -61,
-62, -61, -61, -62, -62, -62, -62, -61, -61, -62, -61, -61, -61, -61, -61, -62,
-60, -51, -53, -52, -51, -52, -52, -51, -52, -52, -52, -52, -51, -51, -52, -52,
-52, -52, -52, -52, -52, -52, -44, -42, -43, -42, -42, -43, -42, -42, -42, -42,
-42, -43, -42, -43, -43, -42, -42, -42, -43, -41, -44, -36, -32, -33, -32, -33,
-32, -32, -33, -33, -32, -33, -33, -33, -33, -33, -33, -33, -32, -32, -31, -33,
-30, -23, -23, -22, -23, -23, -24, -23, -22, -23, -23, -23, -23, -23, -24, -23,
-23, -22, -24, -23, -23, -23, -14, -13, -14, -13, -13, -14, -14, -12, -13, -13,
-14, -13, -14, -13, -14, -13, -14, -13, -14, -13, -15, -8, -3, -4, -3, -5, -4,
-4, -3, -4, -4, -3, -4, -4, -4, -4, -4, -3, -4, -3, -4, -4, };