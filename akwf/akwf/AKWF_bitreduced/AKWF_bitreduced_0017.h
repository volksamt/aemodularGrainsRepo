#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {39, 46, 42, 45, 43, 45, 43, 44, 43,
45, 43, 45, 43, 45, 43, 44, 43, 43, 44, 43, 44, 44, 44, 43, 44, 43, 43, 43, 44,
44, 43, 43, 43, 44, 43, 44, 43, 44, 44, 43, 44, 44, 44, 43, 44, 43, 44, 43, 43,
43, 44, 42, 44, 42, 45, 43, 45, 42, 45, 41, 46, 42, 47, 40, 52, 121, 118, 119,
119, 119, 120, 118, 118, 118, 118, 120, 116, 126, 88, 32, 51, 37, 48, 38, 47,
39, 48, 35, -33, -33, -32, -33, -32, -32, -34, -29, -40, 21, 50, 39, 46, 42, 43,
45, 41, 49, 21, -41, -28, -35, -32, -33, -33, -33, -33, -32, -33, -31, -34, -31,
-34, -31, -34, -32, -33, -32, -33, -31, -33, -33, -32, -32, -33, -32, -33, -33,
-33, -32, -33, -32, -32, -33, -33, -32, -32, -33, -33, -32, -32, -33, -32, -33,
-32, -33, -32, -32, -32, -33, -33, -32, -32, -32, -32, -32, -32, -32, -32, -32,
-33, -33, -33, -32, -32, -32, -32, -32, -32, -33, -32, -32, -33, -32, -33, -32,
-32, -32, -32, -32, -32, -32, -32, -32, -32, -32, -32, -32, -32, -33, -32, -32,
-32, -32, -32, -32, -32, -33, -33, -33, -32, -33, -33, -32, -32, -32, -32, -32,
-32, -32, -32, -32, -33, -31, -33, -32, -32, -31, -32, -32, -32, -31, -33, -32,
-32, -32, -32, -33, -32, -33, -31, -33, -31, -33, -30, -34, -30, -33, -30, -35,
-29, -37, -20, 48, 42, 44, 43, 44, 44, 43, 44, 43, 45, 43, 45, 43, 44, 43, 45,
43, 45, 43, 44, 42, 44, 42, 44, 42, 45, 41, 46, 111, 121, 117, 122, 115, 123,
113, 127, 83, 35, 47, 41, 44, 43, 44, 43, 43, 43, 43, 44, 43, 44, 43, 43, 43,
43, 43, 44, 43, 44, 43, 43, 44, 43, 43, 43, 43, 43, 44, 43, 43, 43, 43, 43, 44,
43, 43, 43, 44, 44, 43, 43, 44, 43, 42, 43, 42, 44, 42, 44, 43, 45, 41, 44, 41,
45, 41, 46, 39, 50, 28, -38, -30, -33, -32, -32, -33, -32, -33, -31, -33, -32,
-33, -32, -33, -32, -34, -31, -32, -32, -33, -32, -33, -33, -32, -32, -32, -32,
-32, -32, -32, -33, -33, -32, -32, -32, -33, -33, -33, -32, -32, -33, -32, -32,
-32, -33, -32, -33, -33, -32, -33, -33, -32, -33, -32, -32, -32, -33, -32, -33,
-33, -32, -32, -32, -33, -32, -33, -32, -33, -32, -33, -33, -32, -33, -32, -32,
-32, -32, -32, -33, -32, -32, -32, -33, -33, -33, -32, -33, -33, -33, -32, -32,
-32, -32, -32, -33, -32, -32, -32, -33, -32, -33, -33, -32, -33, -32, -32, -32,
-31, -32, -33, -32, -32, -32, -32, -32, -31, -33, -32, -32, -31, -32, -31, -32,
-32, -32, -32, -31, -32, -32, -32, -32, -33, -32, -32, -32, -32, -32, -32, -32,
-32, -33, -32, -33, -31, -32, -32, -31, -32, -33, -31, -32, -32, -33, -31, -33,
-31, -33, -31, -34, -31, -34, -27, };