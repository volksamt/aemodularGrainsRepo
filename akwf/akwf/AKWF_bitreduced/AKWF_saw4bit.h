#define DATA_LENGTH 512
#define DATA AKWF_saw4bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {21, 25, 23, 25, 24, 24, 23, 25, 24,
24, 24, 24, 24, 25, 24, 25, 25, 25, 24, 25, 25, 24, 25, 25, 25, 24, 24, 24, 24,
24, 25, 24, 25, 25, 24, 24, 25, 25, 24, 24, 24, 25, 25, 24, 25, 24, 25, 25, 25,
24, 24, 25, 24, 25, 24, 24, 25, 25, 24, 24, 24, 24, 24, 25, 25, 25, 25, 24, 24,
24, 24, 24, 25, 24, 24, 25, 24, 24, 23, 24, 24, 24, 23, 25, 24, 25, 24, 25, 24,
25, 23, 26, 22, 30, 72, 71, 72, 72, 71, 72, 71, 72, 71, 72, 70, 72, 70, 72, 72,
71, 72, 72, 71, 72, 71, 72, 72, 71, 72, 71, 72, 71, 71, 71, 71, 71, 71, 71, 72,
72, 71, 72, 70, 71, 71, 71, 71, 70, 72, 72, 72, 71, 72, 71, 71, 70, 71, 71, 70,
71, 71, 72, 71, 72, 71, 71, 71, 71, 71, 70, 71, 71, 70, 72, 70, 71, 70, 70, 71,
71, 71, 71, 71, 71, 71, 71, 71, 71, 71, 70, 71, 70, 71, 70, 72, 68, 74, 65, 91,
124, 115, 120, 117, 119, 118, 117, 118, 118, 118, 118, 118, 118, 117, 118, 118,
117, 118, 117, 118, 118, 118, 118, 118, 117, 117, 118, 117, 117, 117, 117, 117,
118, 117, 117, 117, 117, 118, 117, 118, 116, 118, 117, 118, 117, 118, 117, 117,
117, 117, 117, 116, 117, 116, 118, 115, 120, 115, 121, 113, 121, 112, 123, 111,
125, 106, 127, 74, -128, -114, -120, -118, -119, -120, -117, -120, -118, -121,
-117, -122, -117, -122, -118, -121, -118, -120, -118, -120, -118, -119, -118,
-120, -118, -119, -118, -119, -120, -119, -119, -118, -119, -119, -119, -119,
-120, -119, -119, -119, -120, -119, -118, -119, -119, -119, -118, -120, -119,
-119, -118, -119, -119, -119, -118, -118, -118, -119, -118, -119, -119, -119,
-118, -118, -119, -117, -121, -81, -67, -74, -70, -72, -70, -72, -70, -72, -71,
-72, -71, -71, -70, -71, -70, -71, -71, -71, -71, -71, -71, -70, -72, -70, -71,
-70, -72, -70, -71, -70, -72, -71, -71, -72, -71, -71, -71, -71, -71, -71, -70,
-71, -71, -71, -70, -70, -71, -71, -70, -70, -71, -71, -71, -70, -70, -71, -70,
-70, -71, -72, -71, -72, -71, -70, -70, -71, -70, -70, -71, -71, -71, -70, -71,
-71, -71, -70, -70, -70, -70, -70, -70, -70, -71, -70, -71, -69, -71, -70, -72,
-69, -72, -68, -73, -64, -22, -24, -23, -23, -23, -23, -24, -22, -24, -23, -24,
-22, -23, -22, -24, -23, -23, -23, -24, -23, -23, -23, -23, -24, -23, -24, -22,
-22, -23, -23, -24, -23, -23, -22, -23, -23, -23, -22, -22, -23, -23, -24, -23,
-23, -23, -23, -23, -23, -23, -23, -23, -22, -23, -23, -22, -22, -24, -22, -23,
-23, -23, -23, -23, -22, -22, -23, -23, -23, -23, -23, -23, -23, -22, -23, -23,
-22, -23, -23, -22, -24, -23, -23, -22, -22, -22, -23, -23, -24, -23, -24, -21,
-24, -20, };