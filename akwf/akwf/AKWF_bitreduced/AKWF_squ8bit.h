#define DATA_LENGTH 512
#define DATA AKWF_squ8bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 120, 120, 118, 120, 117, 120, 118,
120, 118, 120, 118, 121, 118, 120, 119, 120, 118, 119, 119, 119, 118, 119, 119,
119, 119, 118, 119, 118, 119, 119, 119, 118, 119, 118, 118, 119, 120, 118, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 119, 119, 119, 118, 118, 119, 118, 119, 118, 119, 118, 119, 118, 119,
118, 118, 118, 119, 118, 118, 118, 118, 118, 119, 119, 119, 118, 118, 118, 118,
119, 118, 119, 118, 118, 118, 119, 118, 118, 119, 118, 118, 118, 118, 117, 118,
118, 119, 118, 118, 118, 118, 118, 118, 117, 117, 118, 118, 117, 118, 118, 117,
117, 117, 118, 118, 118, 117, 118, 117, 118, 117, 118, 118, 118, 117, 117, 117,
117, 117, 118, 117, 118, 117, 117, 117, 117, 118, 117, 118, 118, 117, 117, 116,
117, 117, 116, 117, 118, 117, 117, 117, 116, 117, 117, 117, 117, 117, 117, 117,
117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 118, 117, 117, 117, 116, 117,
117, 117, 116, 117, 116, 117, 117, 117, 116, 117, 116, 116, 116, 117, 117, 116,
117, 116, 116, 116, 116, 116, 116, 117, 116, 116, 117, 117, 116, 117, 117, 117,
116, 116, 117, 116, 116, 116, 116, 116, 116, 115, 116, 116, 117, 115, 117, 115,
117, 115, 116, 116, 117, 116, 116, 116, 116, 116, 116, 115, 115, 115, 116, 116,
115, 116, 115, 116, 115, 117, 114, 116, -20, -128, -114, -122, -117, -120, -118,
-120, -118, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -118, -119, -119, -120, -118, -120,
-119, -119, -119, -119, -119, -119, -119, -118, -118, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -118, -118,
-119, -118, -119, -119, -119, -119, -119, -119, -118, -118, -118, -118, -119,
-118, -118, -119, -119, -118, -118, -118, -118, -117, -118, -118, -118, -118,
-119, -119, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118,
-118, -118, -117, -117, -118, -118, -118, -118, -117, -117, -118, -118, -117,
-118, -118, -118, -117, -118, -118, -118, -118, -117, -118, -117, -118, -118,
-118, -117, -118, -118, -118, -117, -118, -118, -117, -118, -117, -118, -118,
-117, -117, -117, -117, -117, -118, -117, -117, -117, -117, -117, -117, -117,
-117, -117, -117, -117, -117, -117, -116, -118, -118, -116, -116, -117, -117,
-117, -118, -117, -117, -117, -116, -116, -117, -117, -116, -117, -117, -116,
-117, -117, -117, -117, -116, -118, -116, -117, -116, -117, -117, -117, -116,
-117, -117, -117, -116, -117, -117, -116, -116, -117, -117, -117, -116, -116,
-117, -116, -116, -117, -117, -116, -117, -116, -116, -116, -116, -117, -116,
-116, -115, -116, -116, -116, -116, -117, -116, -116, -116, -116, -116, -116,
-116, -115, -115, -117, -116, -116, -116, -116, -117, -116, -116, -116, -117,
-115, -116, -114, -117, -114, -117, -114, -118, -114, -118, -113, -120, -111,
-124, -99, };