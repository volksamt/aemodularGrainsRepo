#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0035

const PROGMEM int8_t DATA[DATA_LENGTH] = {35, 42, 39, 41, 40, 41, 40, 41, 41,
40, 40, 41, 40, 40, 40, 40, 40, 40, 40, 40, 41, 40, 41, 40, 41, 40, 40, 41, 40,
41, 39, 41, 40, 40, 39, 41, 39, 42, 39, 41, 39, 41, 40, 40, 40, 41, 40, 39, 41,
40, 41, 39, 43, 36, 46, 33, 50, 27, 63, 87, 78, 79, 84, 71, 26, 50, 34, 44, 37,
43, 38, 40, 40, 39, 41, 39, 40, 39, 41, 39, 41, 38, 42, 39, 41, 38, 41, 40, 40,
39, 40, 40, 40, 40, 39, 40, 40, 39, 40, 40, 40, 41, 39, 40, 40, 40, 40, 40, 40,
40, 40, 39, 39, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 39, 40, 39, 40, 40,
39, 40, 40, 40, 39, 40, 40, 40, 40, 39, 40, 38, 40, 39, 41, 39, 41, 40, 40, 39,
39, 39, 39, 40, 39, 41, 37, 41, 36, 45, 30, 85, 127, 113, 122, 117, 120, 117,
120, 118, 119, 117, 119, 117, 119, 117, 119, 118, 119, 118, 119, 119, 119, 117,
118, 118, 119, 118, 119, 118, 116, 122, 51, 35, 42, 36, 42, 37, 41, 37, 40, 38,
40, 38, 40, 39, 40, 39, 39, 39, 39, 39, 40, 39, 39, 40, 38, 39, 39, 39, 38, 40,
38, 39, 38, 39, 40, 39, 38, 39, 38, 38, 39, 39, 39, 39, 39, 38, 39, 38, 39, 38,
39, 38, 39, 38, 40, 38, 39, 37, 39, 39, 40, 39, 38, 41, -31, -45, -37, -43, -37,
-42, -39, -42, -39, -41, -39, -41, -39, -40, -40, -40, -40, -41, -41, -40, -40,
-41, -40, -40, -40, -41, -40, -41, -41, -40, -40, -40, -40, -40, -40, -40, -40,
-39, -40, -39, -40, -40, -41, -40, -40, -40, -40, -39, -40, -39, -40, -39, -41,
-40, -42, -39, -41, -38, -41, -38, -42, -38, -42, -37, -46, -119, -120, -118,
-120, -118, -120, -118, -121, -117, -120, -117, -121, -118, -120, -118, -120,
-118, -119, -118, -118, -119, -119, -119, -118, -119, -117, -120, -117, -121,
-114, -128, -78, -30, -44, -37, -42, -38, -41, -39, -40, -40, -39, -40, -39,
-40, -39, -40, -40, -40, -39, -39, -39, -40, -39, -40, -39, -40, -39, -40, -39,
-39, -40, -39, -39, -39, -39, -39, -39, -38, -39, -39, -40, -39, -40, -39, -39,
-39, -40, -38, -40, -39, -40, -38, -39, -40, -39, -39, -39, -40, -39, -39, -38,
-39, -39, -39, -39, -40, -39, -40, -39, -40, -38, -40, -38, -41, -38, -41, -38,
-40, -38, -39, -38, -39, -39, -39, -39, -39, -41, -38, -42, -35, -44, -34, -46,
-30, -51, -23, -66, -82, -78, -77, -81, -128, -32, -43, -36, -40, -39, -39, -40,
-38, -41, -37, -41, -36, -41, -36, -41, -36, -41, -37, -40, -37, -40, -38, -40,
-38, -39, -38, -39, -38, -39, -39, -38, -39, -38, -39, -38, -39, -38, -40, -39,
-40, -39, -40, -39, -40, -38, -39, -38, -40, -38, -39, -38, -40, -38, -39, -37,
-40, -37, -41, -33, };