#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {17, 20, 19, 21, 18, 37, 41, 40, 40,
40, 40, 39, 39, 41, 38, 51, 62, 59, 61, 59, 61, 59, 60, 58, 61, 57, 68, 83, 78,
80, 79, 79, 80, 78, 95, 101, 98, 100, 98, 99, 99, 99, 98, 100, 99, 99, 100, 100,
100, 99, 99, 99, 99, 99, 99, 100, 99, 99, 100, 99, 100, 100, 100, 99, 99, 99,
99, 99, 99, 99, 98, 99, 99, 99, 100, 98, 99, 99, 99, 99, 99, 100, 99, 100, 99,
99, 98, 99, 99, 99, 99, 98, 100, 99, 99, 99, 99, 99, 99, 99, 100, 100, 99, 99,
100, 99, 100, 99, 99, 99, 99, 99, 99, 99, 99, 99, 100, 100, 99, 99, 99, 100,
100, 98, 98, 99, 100, 99, 100, 99, 99, 100, 99, 100, 99, 99, 99, 98, 99, 100,
99, 99, 99, 99, 99, 100, 99, 99, 99, 99, 100, 99, 99, 99, 100, 99, 99, 98, 99,
99, 100, 99, 99, 99, 99, 98, 99, 99, 81, 78, 80, 78, 80, 79, 61, 59, 60, 58, 61,
58, 61, 58, 62, 48, 38, 41, 38, 41, 40, 41, 40, 40, 40, 38, 41, 28, 16, 22, 18,
24, 9, -1, 0, 1, -4, -21, -19, -20, -35, -42, -37, -48, -62, -59, -60, -79, -79,
-80, -78, -94, -101, -98, -100, -99, -99, -100, -98, -102, -119, -118, -120,
-119, -118, -119, -119, -119, -120, -103, -97, -101, -99, -100, -99, -99, -98,
-99, -101, -89, -77, -81, -78, -81, -78, -81, -78, -80, -76, -59, -60, -59, -59,
-60, -59, -60, -59, -61, -58, -62, -57, -68, -82, -78, -80, -78, -80, -79, -80,
-80, -79, -79, -79, -80, -79, -79, -79, -80, -80, -78, -80, -64, -58, -61, -59,
-60, -59, -60, -40, -40, -39, -40, -39, -40, -37, -19, -20, -19, -21, -19, -20,
-20, -20, -20, -20, -20, -20, -20, -19, -20, -19, -38, -40, -39, -41, -38, -55,
-62, -56, -68, -82, -78, -79, -96, -100, -99, -100, -98, -116, -120, -118, -119,
-118, -119, -118, -119, -119, -120, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -118, -119,
-118, -119, -119, -118, -119, -119, -120, -118, -122, -108, -96, -100, -98,
-100, -100, -88, -75, -83, -73, -59, -59, -60, -59, -41, -39, -40, -42, -25,
-18, -21, -19, -20, -18, -21, -20, -19, -19, -20, -19, -20, -19, -20, -20, -20,
-19, -20, -18, -24, -39, -40, -40, -42, -38, -45, -62, -59, -60, -60, -58, -60,
-58, -60, -58, -60, -57, -66, -81, -78, -80, -62, -59, -61, -59, -60, -59, -60,
-59, -60, -60, -60, -59, -60, -58, -60, -59, -60, -60, -60, -59, -60, -58, -60,
-59, -61, -58, -69, -82, -77, -80, -78, -80, -78, -81, -78, -82, -100, -99, -99,
-100, -99, -100, -99, -100, -98, -100, -99, -99, -99, -100, -98, -100, -99, -99,
-100, -98, -101, -84, -77, -79, -79, -79, -81, -63, -59, -57, -37, -41, -39,
-24, -16, -24, -11, 1, -1, 0, 0, };