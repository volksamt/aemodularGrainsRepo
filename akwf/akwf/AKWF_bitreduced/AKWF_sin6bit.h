#define DATA_LENGTH 512
#define DATA AKWF_sin6bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 6, 6, 6, 6, 5, 6, 16, 15, 16, 15,
16, 14, 17, 26, 24, 26, 24, 25, 24, 29, 35, 33, 35, 34, 34, 35, 34, 42, 45, 43,
43, 44, 44, 44, 53, 54, 53, 54, 53, 54, 53, 57, 63, 62, 63, 63, 62, 63, 64, 62,
70, 74, 72, 73, 72, 72, 72, 72, 74, 82, 81, 82, 82, 81, 81, 82, 82, 80, 89, 91,
91, 92, 91, 92, 91, 92, 91, 91, 90, 98, 102, 100, 101, 100, 101, 100, 101, 100,
101, 100, 101, 100, 101, 111, 110, 109, 110, 110, 110, 110, 109, 110, 110, 109,
110, 110, 110, 110, 110, 109, 109, 109, 109, 110, 110, 109, 110, 108, 114, 121,
118, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119, 118, 118, 119, 119, 120,
113, 108, 110, 109, 110, 109, 109, 110, 109, 109, 109, 110, 109, 108, 109, 109,
109, 109, 110, 109, 110, 109, 108, 109, 109, 109, 99, 99, 100, 99, 99, 99, 99,
98, 100, 99, 100, 98, 100, 97, 90, 90, 90, 89, 90, 90, 90, 90, 88, 90, 87, 79,
80, 79, 81, 80, 80, 80, 79, 80, 72, 70, 71, 70, 72, 71, 71, 70, 71, 66, 60, 62,
60, 62, 61, 61, 61, 61, 52, 51, 51, 51, 51, 51, 50, 41, 42, 41, 42, 41, 44, 39,
31, 32, 32, 32, 32, 32, 33, 26, 22, 23, 22, 23, 23, 23, 15, 13, 14, 13, 14, 12,
13, 4, 3, 4, 4, 3, 4, 2, -6, -6, -6, -6, -5, -8, -16, -15, -16, -16, -16, -16,
-14, -21, -26, -25, -25, -25, -24, -30, -35, -34, -35, -34, -35, -35, -34, -43,
-45, -44, -43, -44, -44, -45, -54, -54, -53, -53, -54, -55, -53, -57, -64, -63,
-63, -63, -63, -63, -62, -62, -70, -74, -72, -73, -71, -72, -72, -73, -70, -77,
-83, -81, -82, -82, -82, -82, -82, -81, -90, -91, -91, -92, -91, -91, -92, -92,
-91, -91, -91, -100, -101, -100, -102, -100, -101, -100, -100, -100, -101, -100,
-101, -99, -102, -111, -110, -110, -110, -110, -110, -110, -110, -109, -110,
-111, -110, -111, -110, -110, -111, -110, -110, -110, -109, -110, -110, -110,
-110, -108, -116, -120, -119, -119, -118, -119, -119, -119, -118, -119, -119,
-119, -119, -118, -119, -119, -118, -119, -112, -108, -110, -109, -109, -109,
-110, -109, -109, -109, -110, -109, -110, -110, -110, -108, -108, -110, -109,
-109, -109, -109, -109, -109, -110, -108, -99, -100, -100, -99, -100, -99, -100,
-99, -99, -99, -99, -98, -101, -95, -89, -90, -89, -89, -90, -90, -89, -89, -90,
-89, -91, -85, -79, -81, -79, -81, -79, -80, -79, -80, -78, -70, -71, -70, -70,
-71, -69, -71, -66, -61, -61, -61, -61, -60, -61, -61, -61, -52, -50, -53, -51,
-52, -51, -53, -48, -41, -43, -42, -42, -41, -42, -38, -31, -33, -32, -32, -32,
-32, -32, -25, -21, -24, -22, -23, -21, -24, -21, -14, -12, -14, -13, -15, -12,
-4, -3, -4, -4, -3, -3, };