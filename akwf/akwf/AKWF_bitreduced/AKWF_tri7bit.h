#define DATA_LENGTH 512
#define DATA AKWF_tri7bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 3, 3, 4, 3, 4, 8, 8, 8, 8, 8, 9,
13, 14, 13, 14, 16, 19, 18, 18, 17, 21, 23, 22, 23, 23, 25, 29, 28, 28, 28, 29,
33, 33, 32, 32, 33, 37, 37, 38, 37, 38, 43, 41, 42, 42, 42, 46, 47, 47, 47, 46,
47, 52, 51, 51, 52, 52, 56, 57, 57, 57, 56, 61, 62, 61, 62, 61, 64, 67, 66, 67,
65, 69, 72, 71, 71, 71, 73, 76, 75, 76, 75, 77, 81, 81, 80, 80, 83, 86, 86, 86,
86, 85, 86, 90, 90, 91, 90, 90, 95, 95, 95, 94, 95, 99, 99, 100, 100, 100, 104,
105, 105, 106, 104, 108, 110, 109, 109, 109, 112, 115, 113, 115, 114, 117, 120,
118, 120, 118, 119, 116, 113, 115, 113, 114, 112, 109, 109, 108, 109, 108, 104,
104, 104, 104, 103, 99, 100, 99, 99, 99, 94, 95, 94, 94, 94, 90, 90, 90, 89, 90,
85, 84, 84, 84, 85, 85, 80, 80, 80, 79, 80, 76, 74, 75, 75, 75, 72, 69, 70, 69,
71, 67, 64, 65, 64, 66, 63, 59, 60, 60, 60, 59, 55, 55, 54, 56, 54, 50, 51, 50,
50, 51, 50, 45, 46, 45, 45, 45, 40, 40, 40, 41, 40, 36, 36, 35, 36, 36, 31, 30,
31, 31, 31, 26, 25, 27, 26, 26, 23, 20, 22, 21, 22, 18, 16, 16, 17, 15, 16, 13,
11, 12, 12, 10, 6, 7, 6, 6, 6, 1, 2, 2, 1, 2, -4, -4, -3, -3, -3, -4, -9, -9,
-8, -9, -9, -13, -13, -13, -13, -12, -17, -18, -18, -17, -18, -17, -22, -23,
-23, -22, -25, -28, -27, -28, -28, -30, -34, -32, -33, -32, -34, -38, -38, -37,
-37, -37, -43, -42, -43, -42, -43, -47, -47, -46, -48, -46, -48, -51, -51, -52,
-52, -51, -52, -57, -56, -57, -56, -60, -62, -61, -62, -61, -65, -66, -66, -66,
-65, -70, -72, -70, -72, -70, -74, -77, -76, -77, -75, -78, -82, -80, -82, -80,
-83, -86, -85, -85, -85, -86, -84, -87, -91, -91, -90, -91, -95, -95, -96, -94,
-95, -100, -100, -100, -99, -100, -105, -105, -105, -105, -105, -108, -109,
-110, -109, -109, -113, -114, -114, -115, -114, -117, -120, -119, -119, -119,
-119, -119, -115, -113, -114, -114, -112, -109, -110, -108, -109, -107, -104,
-104, -104, -105, -103, -99, -100, -99, -100, -98, -94, -95, -94, -95, -94, -90,
-90, -89, -90, -90, -85, -85, -85, -85, -85, -85, -84, -79, -80, -80, -79, -75,
-74, -75, -75, -76, -72, -69, -70, -70, -71, -66, -64, -66, -64, -66, -62, -60,
-61, -60, -61, -58, -55, -55, -55, -55, -54, -49, -51, -49, -50, -50, -46, -45,
-45, -45, -45, -44, -41, -41, -40, -40, -40, -35, -36, -35, -36, -35, -31, -30,
-31, -31, -31, -27, -25, -26, -25, -26, -22, -21, -21, -20, -22, -18, -15, -16,
-16, -17, -15, -10, -12, -11, -11, -9, -6, -7, -6, -6, -7, -5, -1, -1, -2, -2,
};