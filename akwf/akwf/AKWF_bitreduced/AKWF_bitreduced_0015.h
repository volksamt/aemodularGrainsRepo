#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {-35, -42, -38, -41, -38, -41, -38,
-40, -39, -41, -39, -40, -39, -40, -39, -40, -39, -40, -40, -39, -40, -39, -40,
-39, -40, -40, -40, -40, -40, -40, -40, -40, -40, -39, -40, -40, -40, -39, -40,
-40, -40, -40, -39, -40, -40, -40, -40, -40, -40, -40, -40, -40, -40, -40, -40,
-40, -39, -39, -40, -41, -39, -40, -39, -40, -40, -40, -40, -40, -39, -40, -40,
-40, -40, -40, -39, -39, -40, -40, -40, -39, -40, -40, -40, -40, -39, -40, -39,
-39, -39, -40, -39, -39, -40, -40, -39, -39, -40, -39, -40, -40, -40, -40, -40,
-39, -39, -40, -40, -39, -40, -40, -39, -40, -40, -39, -40, -39, -39, -39, -39,
-40, -40, -40, -39, -40, -40, -39, -40, -39, -39, -40, -40, -40, -40, -40, -40,
-40, -39, -40, -40, -40, -39, -39, -40, -40, -40, -40, -40, -39, -39, -40, -39,
-39, -40, -39, -39, -40, -39, -39, -40, -38, -43, -11, 4, -3, 2, -1, 1, -1, 0,
-1, 0, 0, 0, 0, 0, -1, 0, 1, 1, 0, 1, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, -1, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1,
0, 0, 0, 0, 0, -1, 0, 1, 0, -1, 1, 0, 0, 0, 1, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0,
0, 0, 0, 1, 0, -1, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0,
-1, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 1, 0, 0,
0, 0, -1, 0, 0, 0, -1, 0, 0, -1, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, -1, 0, 0, 0,
0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, -1, 1, -2, 3, -4, 4, -6, 10, -30, -123, -117,
-120, -120, -117, -124, -100, -75, -80, -79, -79, -80, -78, -81, -77, -83, -69,
-37, -40, -40, -40, -40, -39, -41, -39, -41, -38, -41, -38, -41, -37, -42, -36,
-45, -27, 4, -3, 1, -1, 0, 0, 1, -1, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, -1, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, -1, 0, 0, 1, 0,
0, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, -1, 1, 0, 0, 1, 0, -1, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, };