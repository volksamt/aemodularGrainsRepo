#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {35, 42, 38, 41, 39, 41, 40, 40, 40,
41, 39, 41, 40, 40, 40, 41, 40, 40, 40, 40, 40, 39, 40, 40, 40, 40, 40, 40, 40,
40, 41, 40, 40, 39, 41, 39, 40, 39, 40, 40, 40, 39, 40, 39, 40, 39, 39, 41, 37,
43, 34, 99, 125, 113, 121, 115, 120, 115, 119, 116, 119, 117, 118, 118, 118,
117, 117, 118, 117, 117, 118, 117, 117, 119, 117, 118, 118, 118, 117, 117, 118,
117, 117, 118, 117, 118, 117, 117, 117, 118, 118, 117, 117, 118, 117, 117, 118,
118, 118, 117, 118, 118, 118, 117, 117, 117, 118, 117, 117, 117, 117, 117, 118,
117, 118, 118, 116, 117, 117, 117, 118, 117, 117, 117, 118, 117, 117, 116, 116,
117, 117, 117, 117, 116, 116, 117, 118, 116, 116, 117, 116, 117, 117, 116, 116,
117, 116, 117, 117, 117, 117, 116, 116, 117, 116, 117, 117, 116, 117, 116, 117,
117, 117, 116, 116, 116, 116, 116, 116, 116, 116, 116, 115, 117, 117, 116, 116,
116, 116, 117, 116, 116, 116, 116, 116, 116, 116, 117, 116, 117, 116, 116, 116,
116, 115, 116, 116, 116, 116, 116, 116, 116, 117, 114, 118, 111, 124, 65, 30,
42, 34, 40, 35, 39, 37, 39, 37, 38, 37, 37, 37, 37, 38, 38, 38, 37, 37, 37, 37,
37, 37, 36, 38, 37, 38, 37, 38, 38, 37, 36, 37, 37, 38, 36, 37, 37, 37, 37, 38,
36, 38, 37, 38, 37, 38, 37, 36, 38, 35, 43, -24, -48, -36, -44, -38, -44, -39,
-42, -41, -42, -40, -43, -41, -42, -40, -41, -40, -41, -40, -42, -41, -41, -41,
-41, -41, -42, -40, -41, -41, -41, -41, -42, -41, -41, -42, -40, -43, -39, -45,
-33, -95, -127, -114, -123, -117, -121, -116, -121, -117, -121, -119, -120,
-119, -119, -119, -119, -119, -118, -119, -118, -119, -119, -120, -118, -119,
-118, -119, -119, -119, -118, -119, -119, -119, -119, -118, -118, -119, -118,
-118, -118, -118, -119, -119, -119, -119, -118, -118, -119, -118, -118, -118,
-119, -118, -118, -118, -118, -119, -118, -118, -119, -118, -118, -117, -118,
-119, -119, -118, -118, -118, -119, -119, -119, -118, -118, -118, -118, -119,
-118, -118, -118, -118, -118, -117, -117, -118, -118, -118, -119, -118, -118,
-118, -117, -118, -118, -117, -117, -118, -118, -117, -117, -118, -117, -117,
-117, -118, -117, -118, -118, -117, -117, -117, -118, -118, -118, -118, -118,
-118, -117, -118, -117, -117, -117, -117, -117, -118, -117, -117, -117, -117,
-117, -116, -117, -117, -117, -117, -117, -117, -117, -117, -118, -117, -117,
-116, -117, -116, -117, -117, -118, -117, -117, -116, -118, -117, -116, -118,
-114, -124, -59, -32, -44, -35, -41, -37, -41, -37, -40, -38, -40, -38, -39,
-38, -39, -38, -39, -38, -38, -39, -39, -39, -39, -39, -39, -39, -38, -39, -38,
-38, -38, -38, -39, -38, -38, -38, -39, -38, -38, -38, -38, -39, -38, -38, -39,
-39, -37, -38, -37, -39, -37, -40, -36, -41, -33, };