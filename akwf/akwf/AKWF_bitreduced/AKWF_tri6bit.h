#define DATA_LENGTH 512
#define DATA AKWF_tri6bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 6, 5, 5, 6, 6, 6, 6, 5, 6, 5, 6,
15, 15, 15, 16, 14, 16, 14, 16, 14, 21, 25, 24, 26, 24, 24, 25, 25, 25, 26, 24,
30, 36, 34, 34, 34, 34, 35, 34, 34, 34, 36, 45, 43, 44, 44, 44, 44, 44, 43, 45,
42, 45, 54, 53, 54, 54, 52, 53, 53, 53, 53, 54, 61, 63, 62, 63, 62, 63, 63, 62,
63, 61, 70, 72, 71, 73, 72, 73, 71, 72, 71, 73, 71, 79, 82, 81, 82, 82, 81, 81,
81, 81, 81, 85, 92, 90, 91, 90, 92, 91, 92, 90, 92, 89, 93, 102, 100, 100, 100,
99, 100, 101, 100, 100, 101, 111, 109, 109, 109, 110, 110, 109, 109, 110, 110,
109, 118, 109, 110, 110, 109, 110, 109, 109, 109, 109, 108, 110, 107, 99, 100,
100, 100, 100, 100, 100, 99, 100, 92, 90, 90, 90, 90, 91, 90, 90, 90, 89, 91,
83, 80, 81, 81, 80, 81, 81, 81, 81, 82, 76, 70, 71, 70, 72, 71, 71, 71, 71, 70,
71, 67, 61, 62, 61, 62, 62, 62, 62, 60, 62, 60, 52, 52, 52, 51, 52, 51, 52, 51,
51, 51, 43, 41, 43, 41, 43, 42, 42, 42, 42, 41, 42, 33, 32, 32, 32, 33, 32, 32,
33, 31, 34, 27, 22, 24, 22, 23, 23, 23, 22, 23, 22, 24, 18, 13, 13, 13, 13, 13,
14, 13, 13, 14, 10, 3, 4, 4, 4, 3, 4, 4, 3, 4, 3, -5, -6, -6, -5, -6, -6, -5,
-6, -5, -6, -6, -15, -15, -15, -15, -15, -14, -15, -15, -15, -15, -15, -24, -26,
-25, -24, -25, -25, -25, -25, -25, -24, -31, -36, -34, -35, -34, -34, -34, -34,
-34, -33, -37, -46, -43, -44, -43, -44, -43, -45, -43, -44, -42, -46, -53, -53,
-53, -53, -52, -53, -53, -54, -53, -54, -62, -62, -62, -63, -62, -64, -63, -63,
-63, -62, -71, -73, -72, -72, -72, -73, -71, -73, -71, -73, -71, -79, -83, -81,
-81, -82, -82, -81, -81, -83, -81, -86, -92, -90, -91, -90, -91, -91, -91, -90,
-92, -90, -94, -100, -100, -101, -100, -100, -100, -101, -100, -100, -102, -111,
-109, -109, -109, -110, -109, -109, -110, -110, -110, -112, -117, -109, -110,
-110, -110, -109, -110, -109, -110, -110, -109, -108, -100, -100, -100, -101,
-100, -100, -99, -100, -99, -100, -99, -90, -90, -91, -90, -90, -90, -90, -90,
-90, -90, -82, -81, -80, -81, -80, -81, -81, -81, -80, -81, -74, -69, -72, -71,
-71, -71, -71, -70, -71, -71, -72, -66, -60, -61, -60, -62, -61, -61, -61, -61,
-62, -58, -51, -52, -51, -52, -52, -51, -52, -51, -53, -51, -43, -42, -42, -42,
-43, -41, -42, -41, -43, -42, -42, -41, -33, -32, -33, -32, -33, -33, -33, -32,
-34, -26, -22, -23, -22, -24, -23, -23, -22, -24, -22, -24, -17, -13, -14, -12,
-14, -14, -13, -14, -13, -14, -10, -2, -4, -4, -4, -4, -4, -4, -3, -4, -3, };