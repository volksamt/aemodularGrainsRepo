#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {36, 43, 40, 43, 40, 43, 41, 42, 41,
42, 40, 42, 42, 41, 42, 41, 41, 41, 41, 40, 42, 39, 42, 40, 43, 39, 43, 38, 46,
35, 57, 125, 116, 120, 119, 119, 119, 119, 119, 119, 119, 117, 120, 118, 119,
118, 120, 119, 119, 118, 119, 118, 119, 118, 119, 119, 119, 119, 119, 118, 118,
119, 119, 119, 119, 118, 118, 119, 118, 118, 118, 118, 118, 119, 119, 118, 119,
118, 119, 118, 119, 118, 119, 118, 119, 119, 119, 119, 118, 118, 118, 118, 118,
118, 118, 119, 118, 119, 119, 117, 118, 119, 118, 119, 118, 118, 118, 118, 118,
119, 118, 118, 117, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 119, 118,
118, 118, 118, 118, 118, 118, 117, 118, 117, 118, 118, 117, 117, 117, 117, 117,
117, 118, 117, 118, 117, 118, 117, 118, 118, 117, 117, 117, 116, 117, 118, 118,
118, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 118, 118, 117, 117,
118, 117, 117, 117, 117, 116, 117, 117, 117, 118, 117, 117, 117, 117, 117, 118,
116, 117, 116, 116, 117, 116, 117, 116, 117, 117, 117, 116, 117, 116, 117, 116,
118, 116, 118, 115, 117, 115, 118, 115, 118, 115, 43, 37, 40, 36, 40, 37, 40,
38, 40, 37, 40, 37, 39, 38, 38, 38, 39, 38, 39, 39, 38, 37, 39, 38, 40, 38, 39,
37, 39, 37, 40, 38, 39, 38, 38, 37, 38, 38, 37, 41, -30, -43, -38, -42, -37,
-41, -39, -41, -39, -41, -39, -41, -39, -40, -39, -40, -39, -40, -40, -40, -39,
-40, -40, -40, -39, -41, -39, -40, -39, -41, -39, -41, -38, -41, -37, -46, -118,
-118, -116, -119, -117, -119, -117, -119, -116, -119, -116, -118, -116, -117,
-117, -118, -117, -118, -117, -118, -117, -118, -118, -118, -117, -118, -117,
-116, -118, -117, -117, -116, -118, -117, -117, -118, -117, -117, -118, -117,
-117, -117, -117, -117, -116, -118, -117, -117, -117, -117, -116, -117, -117,
-117, -118, -117, -116, -117, -116, -116, -117, -117, -117, -117, -118, -117,
-117, -117, -117, -116, -117, -117, -117, -116, -117, -117, -116, -117, -116,
-117, -117, -117, -117, -117, -116, -117, -117, -116, -117, -116, -117, -117,
-116, -116, -117, -116, -117, -116, -116, -116, -117, -116, -115, -116, -116,
-116, -116, -117, -117, -117, -116, -116, -116, -116, -116, -115, -116, -116,
-117, -116, -116, -116, -116, -115, -115, -117, -115, -116, -116, -115, -115,
-116, -116, -116, -116, -116, -116, -115, -115, -116, -115, -116, -116, -115,
-115, -115, -115, -115, -116, -115, -116, -116, -116, -115, -116, -116, -116,
-115, -116, -115, -116, -115, -116, -115, -115, -115, -115, -115, -115, -114,
-116, -114, -116, -116, -115, -115, -115, -116, -115, -115, -114, -116, -114,
-117, -113, -118, -110, -124, -72, -28, -42, -33, -40, -35, -38, -36, -38, -37,
-37, -37, -37, -38, -37, -37, -36, -37, -36, -37, -37, -37, -36, -37, -35, -38,
-36, -38, -35, -38, -35, -39, -31, };