#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0038

const PROGMEM int8_t DATA[DATA_LENGTH] = {37, 43, 40, 42, 41, 42, 40, 42, 40,
41, 40, 41, 41, 41, 40, 41, 40, 40, 41, 40, 41, 41, 41, 41, 41, 41, 41, 41, 42,
41, 42, 41, 41, 40, 41, 41, 41, 41, 41, 41, 41, 41, 41, 41, 41, 41, 41, 41, 41,
41, 41, 41, 41, 41, 41, 40, 41, 40, 40, 42, 41, 40, 40, 40, 41, 41, 41, 41, 41,
41, 41, 42, 41, 40, 40, 41, 41, 41, 40, 40, 41, 41, 40, 40, 41, 40, 41, 41, 41,
41, 42, 40, 40, 40, 40, 40, 41, 40, 41, 40, 41, 41, 41, 40, 41, 41, 41, 40, 40,
40, 40, 41, 41, 41, 40, 41, 41, 41, 41, 41, 40, 40, 41, 40, 40, 41, 40, 40, 41,
40, 41, 40, 40, 41, 41, 40, 41, 41, 40, 41, 40, 40, 40, 40, 40, 40, 40, 41, 40,
41, 41, 40, 41, 40, 40, 41, 40, 40, 41, 40, 40, 40, 40, 40, 40, 40, 40, 40, 41,
40, 40, 41, 40, 40, 41, 40, 41, 41, 41, 39, 40, 40, 41, 40, 40, 39, 40, 40, 40,
40, 41, 39, 41, 41, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 41, 40, 41, 41,
40, 39, 40, 39, 41, 39, 41, 39, 41, 39, 41, 39, 41, 39, 41, 40, 38, 109, 125,
115, 123, 116, 121, 117, 121, 117, 121, 118, 120, 119, 119, 120, 117, 123, 114,
125, 109, 127, 28, -58, -29, -46, -35, -44, -37, -42, -38, -41, -38, -40, -38,
-41, -39, -40, -38, -41, -38, -43, -33, -57, -126, -116, -120, -118, -118, -119,
-118, -119, -117, -120, -116, -121, -115, -122, -114, -125, -103, -35, -41, -40,
-39, -40, -39, -40, -39, -40, -39, -40, -38, -40, -39, -40, -39, -39, -39, -40,
-39, -40, -39, -40, -39, -38, -39, -39, -39, -39, -39, -39, -40, -39, -39, -39,
-40, -39, -40, -39, -39, -40, -39, -39, -40, -39, -39, -39, -40, -39, -39, -39,
-38, -39, -39, -39, -38, -39, -39, -39, -38, -39, -39, -39, -40, -39, -39, -39,
-39, -38, -39, -39, -40, -40, -39, -39, -40, -39, -39, -38, -40, -39, -40, -39,
-38, -40, -40, -39, -38, -39, -40, -39, -39, -38, -39, -39, -39, -39, -39, -39,
-39, -38, -39, -39, -38, -39, -39, -40, -38, -39, -38, -39, -38, -38, -39, -39,
-39, -38, -39, -39, -39, -39, -39, -39, -39, -39, -39, -39, -39, -39, -39, -39,
-38, -38, -39, -38, -38, -39, -39, -39, -39, -39, -38, -39, -39, -39, -38, -38,
-39, -38, -38, -38, -38, -39, -38, -38, -38, -38, -39, -38, -38, -38, -39, -38,
-38, -39, -38, -38, -39, -39, -39, -39, -39, -39, -39, -38, -39, -38, -38, -38,
-38, -39, -38, -39, -39, -38, -39, -38, -38, -38, -39, -38, -38, -39, -38, -39,
-38, -38, -39, -38, -39, -38, -38, -38, -38, -38, -39, -37, -39, -38, -38, -39,
-38, -38, -38, -39, -38, -39, -38, -39, -38, -39, -36, -39, -37, -41, -32, };