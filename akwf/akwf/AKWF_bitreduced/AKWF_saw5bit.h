#define DATA_LENGTH 512
#define DATA AKWF_saw5bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 12, 11, 12, 11, 12, 12, 12, 11,
11, 11, 12, 12, 11, 11, 11, 12, 12, 11, 11, 11, 11, 12, 11, 11, 11, 11, 11, 11,
12, 11, 12, 12, 12, 11, 12, 11, 12, 12, 12, 12, 11, 13, 9, 23, 35, 31, 34, 32,
33, 32, 33, 33, 33, 33, 33, 33, 33, 32, 33, 33, 32, 34, 33, 32, 33, 32, 32, 33,
32, 33, 32, 33, 33, 32, 34, 33, 33, 32, 33, 33, 33, 32, 34, 32, 34, 32, 35, 55,
54, 53, 54, 53, 54, 54, 54, 54, 54, 53, 55, 54, 54, 54, 55, 54, 54, 54, 54, 54,
54, 53, 54, 54, 55, 54, 54, 53, 55, 54, 54, 54, 54, 54, 53, 54, 54, 54, 53, 55,
53, 55, 52, 69, 77, 74, 76, 75, 76, 75, 76, 76, 76, 75, 76, 76, 76, 75, 75, 75,
75, 76, 75, 76, 75, 76, 76, 75, 75, 75, 75, 75, 74, 75, 76, 75, 75, 74, 75, 75,
75, 74, 75, 75, 75, 73, 78, 96, 96, 97, 96, 96, 96, 96, 97, 96, 96, 96, 96, 95,
97, 95, 97, 96, 97, 96, 96, 96, 96, 96, 96, 96, 96, 95, 96, 95, 96, 96, 96, 97,
95, 96, 96, 96, 96, 96, 97, 94, 97, 94, 112, 119, 116, 118, 117, 117, 117, 117,
117, 117, 117, 117, 118, 117, 116, 118, 117, 117, 116, 118, 116, 118, 116, 119,
114, 120, 114, 120, 114, 121, 112, 122, 112, 123, 110, 125, 102, -115, -122,
-115, -123, -116, -123, -115, -122, -116, -122, -116, -122, -117, -121, -117,
-120, -118, -120, -118, -120, -119, -120, -119, -119, -119, -119, -119, -119,
-120, -118, -120, -118, -120, -117, -120, -117, -121, -108, -95, -98, -97, -98,
-97, -98, -97, -97, -97, -97, -97, -97, -98, -97, -98, -97, -97, -97, -97, -97,
-98, -97, -97, -97, -97, -97, -97, -97, -97, -97, -96, -97, -97, -98, -96, -97,
-96, -97, -96, -98, -96, -97, -95, -76, -75, -75, -75, -76, -75, -75, -75, -76,
-75, -76, -76, -75, -76, -76, -75, -76, -76, -75, -76, -75, -75, -75, -74, -75,
-76, -75, -76, -75, -75, -75, -75, -76, -75, -75, -75, -75, -75, -76, -74, -76,
-73, -78, -64, -51, -55, -53, -54, -53, -54, -53, -54, -54, -54, -53, -54, -53,
-54, -54, -53, -54, -53, -54, -53, -54, -53, -54, -53, -53, -53, -53, -53, -53,
-53, -53, -52, -53, -53, -54, -53, -54, -53, -53, -53, -54, -52, -55, -51, -31,
-32, -31, -32, -32, -31, -32, -31, -31, -32, -31, -32, -33, -31, -33, -31, -31,
-32, -32, -31, -32, -31, -31, -32, -32, -32, -31, -31, -32, -32, -31, -31, -31,
-31, -32, -32, -31, -31, -31, -31, -32, -31, -33, -18, -7, -12, -9, -12, -10,
-11, -10, -10, -10, -10, -11, -11, -10, -11, -10, -11, -10, -10, -10, -10, -10,
-10, -9, -10, -11, -10, -10, -10, -9, -10, -10, -10, -10, -10, -10, -11, -10,
-10, -10, -11, -10, -10, -9, };