#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0037

const PROGMEM int8_t DATA[DATA_LENGTH] = {43, 121, 117, 119, 119, 119, 119, 118,
120, 119, 120, 118, 119, 118, 119, 119, 119, 118, 119, 119, 119, 118, 119, 118,
119, 119, 119, 119, 119, 119, 118, 119, 119, 120, 119, 118, 119, 118, 118, 119,
119, 118, 119, 119, 119, 119, 118, 118, 119, 119, 118, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 118, 118, 118, 119, 118, 118, 118, 119, 118,
119, 118, 118, 117, 119, 118, 119, 117, 119, 117, 118, 117, 119, 117, 119, 118,
117, 119, 116, 123, 54, 33, 43, 37, 42, 38, 42, 38, 41, 38, 39, 38, 39, 39, 40,
39, 39, 39, 39, 39, 40, 40, 39, 40, 38, 39, 39, 40, 39, 39, 38, 39, 39, 40, 39,
39, 39, 39, 38, 39, 39, 39, 39, 39, 39, 39, 39, 38, 38, 39, 38, 39, 39, 39, 39,
39, 40, 39, 39, 39, 39, 39, 39, 39, 39, 38, 39, 39, 38, 39, 39, 38, 39, 40, 39,
39, 40, 39, 38, 39, 39, 39, 39, 39, 38, 39, 39, 39, 38, 39, 39, 39, 39, 39, 39,
39, 39, 38, 39, 39, 38, 39, 38, 39, 39, 39, 39, 39, 39, 39, 38, 39, 39, 39, 38,
39, 38, 38, 39, 38, 39, 39, 38, 39, 38, 39, 39, 38, 38, 39, 38, 39, 39, 39, 39,
39, 38, 38, 39, 38, 38, 38, 39, 39, 39, 38, 39, 38, 39, 38, 38, 38, 39, 38, 38,
38, 38, 38, 38, 38, 38, 39, 37, 39, -53, -124, -117, -121, -117, -120, -119,
-119, -118, -119, -118, -119, -119, -120, -119, -119, -119, -119, -120, -118,
-120, -119, -119, -119, -119, -118, -119, -118, -119, -118, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -120, -118, -119, -119, -119,
-119, -118, -119, -118, -119, -119, -119, -119, -119, -119, -118, -119, -118,
-119, -118, -119, -118, -119, -118, -119, -118, -118, -118, -118, -118, -119,
-119, -118, -119, -118, -119, -118, -118, -117, -119, -117, -119, -117, -119,
-117, -119, -118, -119, -117, -118, -119, -47, -36, -42, -37, -41, -38, -40,
-38, -40, -39, -40, -39, -40, -39, -40, -39, -40, -38, -39, -39, -39, -40, -39,
-39, -39, -39, -38, -39, -39, -38, -39, -39, -39, -39, -39, -39, -39, -38, -39,
-39, -39, -38, -39, -39, -39, -39, -38, -39, -39, -39, -39, -39, -39, -39, -39,
-40, -39, -39, -38, -39, -39, -38, -40, -39, -39, -39, -39, -38, -39, -39, -39,
-39, -39, -38, -40, -39, -38, -39, -39, -38, -38, -39, -39, -39, -39, -39, -39,
-39, -39, -38, -38, -38, -39, -39, -39, -39, -39, -38, -39, -39, -39, -38, -39,
-39, -38, -39, -38, -39, -38, -39, -39, -38, -39, -38, -39, -39, -38, -38, -39,
-38, -39, -38, -38, -39, -38, -38, -38, -38, -38, -38, -38, -39, -38, -38, -38,
-39, -38, -38, -38, -39, -39, -39, -38, -39, -38, -39, -39, -38, -38, -38, -39,
-38, -40, -39, -39, -38, -39, -37, -39, -37, -39, -37, -40, -32, };