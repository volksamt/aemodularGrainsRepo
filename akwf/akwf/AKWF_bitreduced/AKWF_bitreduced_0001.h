#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {21, 24, 25, 21, 38, 49, 47, 46, 55,
76, 69, 74, 92, 97, 92, 110, 121, 119, 120, 119, 119, 119, 120, 119, 119, 119,
118, 120, 117, 121, 114, 94, 95, 95, 93, 74, 68, 75, 57, 46, 46, 49, 41, 22, 24,
25, 2, -1, -1, 2, -12, -27, -22, -26, -20, -36, -50, -46, -48, -49, -46, -60,
-75, -70, -72, -72, -70, -84, -98, -93, -97, -94, -96, -95, -96, -95, -95, -96,
-95, -96, -95, -96, -94, -95, -94, -96, -94, -98, -89, -70, -71, -73, -69, -74,
-65, -46, -47, -48, -46, -49, -41, -22, -25, -23, -23, -24, -23, -25, -24, -24,
-23, -25, -22, -24, -23, -24, -24, -24, -24, -24, -23, -24, -46, -48, -47, -48,
-47, -48, -48, -47, -47, -47, -49, -46, -51, -73, -71, -72, -72, -72, -72, -71,
-71, -72, -72, -71, -71, -71, -72, -71, -71, -51, -47, -48, -47, -48, -47, -48,
-47, -48, -47, -47, -47, -47, -47, -48, -47, -48, -46, -50, -44, -59, -75, -70,
-73, -71, -71, -72, -71, -71, -71, -73, -69, -84, -98, -94, -96, -94, -95, -95,
-96, -95, -96, -95, -95, -95, -95, -95, -96, -94, -95, -95, -96, -94, -95, -95,
-96, -95, -96, -95, -96, -96, -95, -96, -94, -96, -94, -99, -82, -70, -73, -71,
-71, -74, -58, -46, -48, -49, -41, -21, -26, -23, -25, -20, 1, -1, 1, -2, 3, 24,
24, 23, 24, 23, 24, 24, 24, 24, 24, 23, 24, 24, 24, 24, 24, 24, 23, 24, 23, 24,
24, 24, 24, 24, 24, 23, 25, 23, 24, 24, 24, 24, 24, 46, 48, 47, 48, 47, 48, 47,
49, 47, 48, 47, 49, 47, 48, 47, 48, 47, 50, 44, 56, 73, 71, 70, 73, 66, 45, 49,
48, 49, 48, 47, 47, 47, 48, 48, 48, 46, 50, 34, 21, 26, 21, 27, 13, -1, 1, 1,
-3, -27, -22, -25, -22, -26, -47, -47, -47, -47, -47, -48, -48, -48, -47, -48,
-48, -48, -48, -48, -49, -30, -22, -25, -23, -25, -26, -6, 3, -2, 1, -1, 1, 0,
0, 0, 1, -1, 0, 0, -1, 0, -1, 2, -17, -26, -22, -25, -23, -26, -23, -26, -21,
-32, -49, -49, -29, -22, -24, -22, -24, -24, -23, -25, -18, 2, -2, 2, -2, 1, -3,
10, 27, 22, 25, 23, 24, 24, 25, 23, 25, 22, 24, 23, 25, 23, 26, 18, -1, 0, 0,
-1, 1, -2, 9, 26, 23, 25, 23, 24, 23, 25, 23, 25, 47, 48, 47, 48, 47, 48, 47,
47, 47, 49, 46, 49, 47, 48, 47, 49, 46, 50, 42, 22, 24, 23, 23, 23, 23, 24, 23,
24, 23, 0, -1, 0, 0, 0, -1, 1, -1, 1, -2, 18, 25, 23, 24, 23, 24, 23, 24, 23,
24, 23, 25, 24, 25, 24, 24, 24, 25, 23, 25, 23, 25, 23, 25, 22, 1, 0, 0, 0, 0,
0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, };