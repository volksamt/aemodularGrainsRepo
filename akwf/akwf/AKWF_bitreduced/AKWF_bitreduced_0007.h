#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {21, 25, 23, 24, 23, 25, 23, 25, 23,
24, 23, 24, 24, 24, 23, 25, 23, 24, 47, 49, 48, 48, 48, 47, 47, 48, 46, 48, 46,
49, 45, 56, 74, 70, 72, 72, 71, 72, 70, 73, 71, 73, 68, 82, 97, 94, 96, 95, 94,
96, 94, 96, 94, 100, 121, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119,
119, 119, 119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119, 120, 102, 92,
98, 93, 99, 79, 69, 73, 45, 53, 32, 24, 4, 0, -6, -25, -36, -51, -46, -72, -72,
-71, -83, -97, -93, -95, -94, -96, -96, -95, -116, -121, -118, -120, -118, -120,
-117, -121, -110, -92, -97, -95, -96, -94, -95, -95, -96, -94, -96, -94, -98,
-82, -69, -74, -70, -73, -71, -72, -72, -53, -46, -49, -46, -49, -47, -49, -45,
-50, -36, -22, -25, -22, -25, -23, -24, -23, -25, -22, -27, -14, 2, -1, 1, -1,
1, 1, 0, 1, -1, 2, -2, 12, 26, 23, 25, 23, 23, 24, 23, 24, 24, 24, 25, 21, 41,
50, 46, 49, 46, 49, 47, 48, 47, 48, 49, 46, 66, 75, 70, 73, 70, 73, 70, 73, 68,
81, 98, 94, 96, 95, 96, 95, 95, 96, 94, 97, 93, 105, 122, 118, 120, 119, 119,
120, 120, 118, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120, 119,
119, 118, 119, 119, 119, 119, 119, 118, 120, 118, 121, 115, 94, 96, 94, 95, 94,
97, 88, 67, 74, 68, 75, 65, 47, 47, 48, 46, 26, 23, 25, 25, 9, -4, 5, -9, -24,
-25, -22, -26, -45, -49, -46, -48, -46, -50, -71, -72, -71, -71, -72, -71, -72,
-69, -83, -98, -94, -96, -95, -96, -94, -96, -95, -95, -95, -95, -96, -95, -95,
-94, -96, -95, -96, -94, -114, -120, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -118, -119, -119,
-119, -119, -119, -118, -119, -119, -120, -118, -120, -118, -122, -104, -92,
-96, -94, -96, -94, -96, -95, -95, -96, -96, -95, -95, -95, -96, -96, -95, -95,
-95, -95, -95, -95, -95, -95, -95, -96, -95, -95, -95, -95, -95, -95, -95, -95,
-95, -95, -96, -95, -95, -96, -95, -95, -95, -95, -96, -95, -95, -95, -95, -95,
-96, -95, -96, -94, -96, -94, -98, -83, -69, -72, -71, -72, -72, -72, -71, -72,
-71, -72, -71, -72, -71, -71, -71, -70, -71, -72, -72, -71, -72, -71, -71, -72,
-71, -71, -72, -71, -71, -70, -71, -71, -73, -71, -75, -56, -44, -49, -47, -48,
-47, -48, -47, -48, -48, -48, -47, -48, -47, -47, -47, -49, -47, -48, -47, -48,
-48, -48, -46, -48, -45, -50, -39, -21, -25, -23, -24, -24, -24, -24, -24, -24,
-24, -24, -24, -24, -23, -24, -24, -24, -24, -23, -25, -22, -26, -16, 3, -2, 1,
-1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 1, };