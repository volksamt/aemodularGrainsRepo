#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0039

const PROGMEM int8_t DATA[DATA_LENGTH] = {37, 44, 40, 43, 41, 43, 41, 42, 41,
43, 41, 42, 41, 42, 41, 41, 42, 42, 42, 42, 42, 42, 42, 42, 42, 41, 42, 42, 41,
42, 42, 42, 41, 42, 42, 41, 42, 42, 42, 41, 42, 42, 42, 42, 42, 41, 42, 42, 42,
41, 41, 41, 42, 41, 41, 42, 41, 42, 41, 42, 42, 42, 41, 42, 41, 42, 42, 41, 42,
41, 41, 42, 42, 42, 42, 41, 42, 42, 42, 42, 41, 42, 41, 42, 42, 42, 41, 42, 42,
42, 41, 42, 41, 42, 41, 41, 41, 42, 41, 41, 41, 41, 41, 41, 41, 41, 41, 42, 41,
41, 42, 41, 42, 41, 42, 42, 41, 41, 42, 41, 42, 41, 41, 41, 42, 42, 42, 41, 42,
42, 40, 42, 40, 42, 40, 43, 39, 45, 37, 46, 36, 48, 34, 51, 28, 61, 92, 69, 97,
-24, -38, -36, -38, -35, -38, -35, -39, -34, -39, -34, -39, -35, -39, -34, -39,
-35, -38, -35, -37, -36, -37, -36, -37, -36, -37, -36, -37, -36, -36, -37, -36,
-38, -37, -38, -36, -37, -37, -38, -37, -37, -36, -36, -36, -37, -37, -36, -37,
-36, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -36, -37, -37, -36,
-36, -37, -37, -37, -36, -37, -37, -37, -36, -37, -37, -36, -36, -37, -37, -36,
-37, -36, -37, -36, -37, -36, -37, -37, -36, -37, -37, -37, -36, -37, -37, -36,
-37, -36, -36, -36, -36, -36, -37, -37, -36, -37, -37, -36, -36, -37, -36, -36,
-37, -37, -36, -36, -37, -37, -36, -37, -37, -36, -36, -36, -37, -36, -36, -36,
-36, -36, -37, -36, -36, -37, -37, -36, -36, -36, -36, -37, -36, -37, -36, -36,
-36, -37, -36, -36, -36, -36, -36, -37, -36, -36, -36, -36, -36, -37, -36, -35,
-37, -34, -37, -34, -39, -31, -45, 0, 51, 37, 45, 40, 43, 40, 43, 41, 41, 42,
42, 42, 42, 42, 41, 42, 41, 43, 41, 42, 42, 42, 41, 43, 41, 42, 42, 42, 41, 42,
42, 41, 42, 42, 42, 41, 41, 42, 41, 42, 41, 42, 42, 42, 42, 42, 41, 41, 41, 41,
42, 42, 42, 42, 42, 42, 42, 41, 41, 43, 41, 42, 42, 42, 41, 43, 41, 42, 41, 42,
42, 42, 41, 42, 42, 42, 41, 41, 41, 41, 41, 41, 42, 40, 45, 37, 50, -6, -45,
-31, -40, -34, -39, -35, -38, -36, -37, -35, -37, -36, -37, -36, -36, -37, -36,
-36, -36, -37, -36, -37, -36, -36, -37, -37, -36, -37, -36, -37, -36, -37, -37,
-36, -36, -36, -37, -35, -36, -36, -37, -36, -36, -36, -36, -36, -37, -37, -36,
-36, -36, -36, -36, -36, -37, -37, -37, -37, -36, -36, -36, -35, -36, -36, -37,
-36, -36, -37, -37, -36, -37, -36, -36, -36, -36, -36, -36, -36, -36, -36, -36,
-36, -36, -36, -36, -35, -37, -36, -36, -36, -35, -36, -35, -36, -35, -36, -36,
-37, -35, -37, -36, -36, -35, -37, -35, -39, -30, };