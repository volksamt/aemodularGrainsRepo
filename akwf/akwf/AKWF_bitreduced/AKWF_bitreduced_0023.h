#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {37, 45, 41, 44, 41, 43, 42, 43, 42,
44, 42, 44, 43, 43, 43, 42, 42, 44, 42, 42, 42, 44, 43, 43, 43, 42, 43, 43, 43,
42, 44, 43, 43, 42, 43, 42, 43, 43, 43, 42, 44, 42, 43, 42, 43, 42, 43, 42, 43,
43, 42, 43, 42, 43, 42, 43, 41, 45, 39, 48, 34, 82, 127, 115, 123, 117, 121,
117, 120, 118, 120, 118, 120, 119, 120, 118, 119, 119, 119, 119, 119, 120, 118,
121, 116, 125, 59, 37, 46, 40, 44, 40, 44, 40, 44, 42, 43, 42, 43, 43, 42, 42,
42, 42, 43, 42, 42, 43, 42, 42, 42, 43, 42, 42, 42, 42, 42, 42, 42, 42, 42, 42,
42, 43, 42, 42, 42, 42, 42, 42, 42, 42, 42, 41, 42, 42, 42, 42, 42, 42, 42, 42,
43, 42, 42, 42, 42, 42, 41, 42, 42, 41, 42, 41, 42, 42, 42, 42, 42, 42, 41, 42,
42, 42, 41, 42, 42, 42, 42, 42, 42, 42, 42, 42, 41, 42, 41, 42, 41, 42, 42, 42,
42, 42, 41, 42, 43, 41, 43, 41, 42, 41, 43, 40, 43, 40, 43, 41, 42, 39, 44, 39,
45, 34, -34, -35, -34, -35, -34, -35, -34, -36, -34, -36, -34, -35, -34, -35,
-35, -35, -34, -36, -35, -35, -36, -35, -35, -34, -34, -34, -35, -35, -35, -34,
-34, -34, -35, -34, -35, -35, -35, -35, -35, -34, -35, -35, -34, -34, -35, -35,
-34, -35, -35, -35, -35, -35, -35, -34, -34, -35, -34, -35, -34, -35, -35, -36,
-35, -36, -35, -34, -35, -35, -35, -35, -35, -35, -34, -35, -35, -34, -35, -34,
-35, -35, -35, -35, -34, -35, -35, -35, -35, -35, -34, -35, -36, -35, -35, -34,
-35, -35, -35, -35, -35, -35, -35, -35, -35, -34, -35, -34, -34, -35, -35, -34,
-35, -35, -34, -34, -34, -35, -35, -34, -34, -35, -34, -34, -34, -35, -34, -34,
-35, -34, -35, -35, -33, -35, -35, -34, -34, -35, -34, -34, -34, -34, -34, -34,
-35, -35, -34, -34, -35, -35, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34,
-34, -34, -34, -35, -35, -34, -34, -34, -33, -35, -33, -34, -34, -35, -34, -35,
-33, -34, -34, -35, -34, -34, -34, -34, -34, -34, -35, -34, -35, -33, -34, -34,
-34, -34, -34, -34, -34, -35, -34, -34, -34, -34, -34, -34, -34, -34, -33, -33,
-34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -35, -33, -34,
-34, -34, -33, -34, -33, -34, -34, -34, -34, -34, -33, -34, -33, -34, -34, -34,
-34, -34, -34, -34, -34, -34, -33, -34, -34, -33, -34, -34, -34, -34, -33, -34,
-34, -34, -34, -35, -33, -34, -34, -33, -34, -34, -33, -34, -34, -35, -33, -34,
-34, -33, -34, -34, -34, -35, -34, -34, -34, -34, -33, -34, -33, -34, -33, -34,
-34, -34, -33, -34, -34, -33, -33, -33, -34, -33, -34, -33, -35, -33, -34, -33,
-35, -33, -35, -32, -35, -29, };