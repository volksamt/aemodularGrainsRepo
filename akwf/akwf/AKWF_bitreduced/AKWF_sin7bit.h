#define DATA_LENGTH 512
#define DATA AKWF_sin7bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 4, 3, 6, 10, 9, 9, 13, 13, 13, 17,
19, 17, 20, 23, 23, 22, 23, 28, 27, 29, 33, 32, 34, 37, 38, 37, 41, 43, 41, 43,
48, 47, 48, 46, 48, 53, 51, 54, 58, 56, 58, 61, 62, 61, 61, 66, 67, 65, 69, 71,
71, 72, 71, 73, 77, 76, 76, 80, 82, 80, 81, 81, 81, 86, 87, 85, 89, 91, 91, 91,
89, 92, 96, 95, 96, 95, 97, 101, 100, 100, 99, 101, 99, 103, 105, 105, 105, 105,
105, 105, 108, 110, 110, 110, 110, 110, 109, 110, 114, 115, 114, 114, 114, 114,
114, 115, 115, 115, 114, 115, 118, 120, 119, 119, 119, 118, 119, 119, 120, 119,
119, 119, 119, 118, 119, 118, 120, 119, 118, 119, 119, 119, 119, 118, 119, 119,
118, 119, 119, 119, 118, 118, 119, 118, 117, 114, 113, 114, 113, 113, 114, 114,
114, 114, 114, 113, 113, 109, 108, 108, 108, 109, 108, 109, 106, 104, 104, 103,
104, 103, 104, 101, 98, 98, 99, 99, 98, 99, 95, 93, 94, 93, 95, 90, 88, 89, 88,
90, 86, 84, 84, 84, 83, 79, 79, 78, 80, 77, 74, 75, 74, 75, 70, 70, 69, 69, 66,
63, 65, 63, 60, 59, 59, 59, 55, 54, 55, 52, 49, 50, 49, 44, 45, 45, 45, 40, 39,
41, 37, 35, 36, 34, 30, 31, 31, 27, 25, 26, 24, 20, 21, 21, 16, 16, 16, 16, 13,
10, 10, 6, 6, 7, 3, 0, 2, 1, -4, -3, -6, -9, -8, -10, -14, -13, -13, -17, -19,
-17, -20, -24, -23, -24, -27, -29, -28, -31, -33, -32, -34, -38, -38, -38, -37,
-42, -42, -43, -48, -47, -47, -48, -53, -52, -52, -56, -58, -56, -59, -61, -62,
-62, -62, -66, -67, -66, -69, -72, -70, -70, -73, -76, -76, -76, -76, -82, -81,
-81, -80, -81, -86, -87, -87, -84, -89, -91, -91, -90, -90, -92, -96, -94, -96,
-94, -97, -101, -99, -101, -100, -100, -100, -103, -105, -105, -105, -105, -105,
-104, -104, -109, -110, -110, -109, -110, -110, -110, -115, -115, -115, -115,
-114, -115, -115, -115, -114, -114, -114, -116, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -120, -119, -119, -118, -118, -119, -119, -119, -118,
-118, -118, -119, -119, -119, -119, -119, -118, -118, -119, -118, -118, -119,
-119, -119, -119, -118, -113, -114, -113, -113, -114, -113, -114, -114, -113,
-113, -113, -112, -108, -108, -109, -109, -109, -108, -109, -107, -102, -103,
-103, -104, -103, -105, -100, -98, -99, -98, -99, -98, -99, -94, -94, -94, -93,
-94, -90, -89, -89, -89, -90, -86, -84, -85, -83, -83, -78, -80, -78, -80, -77,
-74, -74, -74, -74, -70, -69, -69, -69, -66, -64, -64, -64, -63, -58, -60, -59,
-55, -54, -54, -52, -49, -50, -49, -44, -45, -45, -45, -40, -40, -41, -38, -35,
-36, -34, -29, -30, -30, -27, -24, -26, -24, -20, -21, -21, -16, -16, -17, -13,
-10, -11, -10, -6, -7, -7, -2, -1, -1, };