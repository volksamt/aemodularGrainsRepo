#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {23, 21, 33, 50, 46, 47, 49, 73, 69,
75, 54, 46, 47, 50, 38, 21, 25, 23, 23, 25, 21, 39, 50, 49, 70, 78, 98, 93, 115,
121, 118, 120, 118, 121, 116, 124, 111, 98, 81, 71, 51, 48, 42, 21, 25, 24, 4,
-2, 2, -1, 0, -1, 1, 0, 0, 0, 1, 0, 1, 0, 0, 0, 1, -1, 2, -3, 10, 27, 23, 24,
24, 24, 24, 24, 25, 23, 0, 0, -2, 3, -19, -23, -27, -48, -57, -77, -67, -96,
-92, -104, -122, -118, -120, -118, -120, -118, -120, -118, -120, -116, -96, -94,
-97, -77, -69, -48, -50, -37, -20, -26, -22, 0, -2, 11, 27, 21, 27, 21, 27, 11,
-3, 1, -3, -25, -22, -36, -51, -63, -77, -66, -84, -96, -96, -94, -100, -121,
-112, -91, -99, -92, -101, -84, -74, -55, -47, -46, -27, -14, 1, 15, 27, 23, 50,
43, 59, 73, 70, 72, 72, 71, 72, 71, 52, 45, 51, 36, 22, 24, 4, -5, -25, -22,
-37, -52, -43, -55, -71, -72, -70, -73, -70, -73, -69, -73, -72, -54, -44, -52,
-38, -21, -27, -4, -2, 6, 27, 22, 24, 44, 49, 47, 48, 47, 47, 48, 48, 50, 36,
19, 27, 21, 28, 13, -2, 0, 1, -3, -24, -24, -23, -25, -22, -28, -48, -48, -47,
-49, -46, -25, -23, -25, -23, -25, -22, -26, -21, -27, -7, 1, -1, 0, 0, 0, -1,
19, 26, 22, 25, 22, 25, 23, 2, -1, 2, -1, 0, -1, 0, 0, -1, 1, -18, -25, -23,
-25, -23, -24, -23, -24, -23, -23, -24, -25, -24, -24, -24, -24, -23, -24, -23,
-25, -22, -26, -10, 3, -2, 1, -1, 1, -1, 1, 0, 1, 0, 0, 1, 1, 0, -1, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, -1, 0, 0, -2, 2, -8, -27, -23, -26,
-21, 1, -1, 2, -14, -25, -22, -25, -23, -24, -23, -24, -23, -24, -23, -25, -23,
-24, -23, -25, -23, -25, -22, -26, -48, -48, -48, -48, -47, -47, -48, -47, -48,
-49, -28, -22, -26, -21, -27, -5, 1, -1, 0, 1, -1, 0, -1, -24, -24, -25, -22,
-42, -51, -42, -22, -24, -25, -5, 2, -4, 9, 26, 22, 25, 23, 24, 23, 25, 8, -2,
1, -1, 0, 0, 0, 0, -1, 1, -3, 16, 25, 24, 23, 31, 52, 46, 50, 46, 48, 47, 49,
46, 49, 45, 23, 23, 25, 8, -3, 2, -2, 1, -1, 1, -1, 1, 0, 0, 0, -1, 22, 25, 24,
23, 24, 22, 26, 17, 1, -12, -26, -40, -52, -72, -71, -83, -99, -92, -99, -91,
-101, -79, -71, -70, -50, -45, -52, -32, -22, -23, -28, -50, -47, -48, -48, -68,
-77, -97, -92, -112, -122, -117, -121, -118, -120, -118, -120, -94, -99, -85,
-68, -74, -69, -48, -47, -48, -47, -49, -48, -49, -46, -48, -47, -49, -47, -48,
-46, -49, -46, -49, -45, -24, -23, -26, -7, 2, -2, };