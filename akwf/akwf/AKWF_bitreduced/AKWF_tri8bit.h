#define DATA_LENGTH 512
#define DATA AKWF_tri8bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 2, 3, 5, 4, 4, 7, 8, 10, 9, 12,
12, 12, 15, 14, 17, 17, 17, 19, 19, 20, 22, 21, 22, 24, 25, 26, 25, 28, 29, 29,
32, 30, 34, 34, 34, 36, 36, 37, 38, 39, 41, 40, 42, 43, 44, 45, 45, 47, 48, 47,
49, 49, 52, 53, 52, 55, 56, 55, 58, 56, 59, 60, 60, 62, 62, 63, 65, 64, 64, 66,
68, 70, 69, 72, 71, 72, 74, 74, 75, 77, 76, 77, 79, 78, 80, 82, 80, 82, 84, 85,
86, 86, 89, 88, 90, 91, 90, 93, 92, 94, 96, 95, 98, 98, 97, 99, 100, 102, 103,
102, 105, 104, 106, 107, 108, 110, 110, 110, 112, 112, 114, 114, 116, 116, 117,
119, 119, 118, 116, 117, 115, 115, 114, 111, 112, 110, 109, 109, 107, 107, 106,
104, 104, 101, 102, 100, 100, 100, 97, 97, 98, 96, 95, 94, 91, 92, 89, 90, 89,
88, 87, 85, 85, 83, 83, 83, 80, 80, 81, 78, 77, 76, 75, 76, 74, 73, 73, 71, 69,
71, 67, 68, 66, 65, 66, 63, 63, 63, 62, 60, 59, 59, 57, 55, 56, 53, 54, 52, 51,
51, 49, 49, 49, 45, 47, 47, 45, 43, 42, 41, 40, 38, 39, 36, 37, 36, 34, 34, 32,
32, 31, 29, 30, 28, 27, 27, 24, 25, 23, 22, 22, 20, 19, 20, 18, 17, 15, 15, 14,
12, 12, 11, 10, 9, 8, 7, 6, 5, 5, 2, 3, 2, 1, 0, -2, -2, -2, -4, -5, -5, -6, -7,
-9, -10, -9, -13, -12, -13, -14, -14, -15, -16, -18, -19, -18, -20, -21, -22,
-24, -23, -25, -26, -26, -28, -29, -29, -32, -31, -31, -33, -34, -36, -36, -38,
-38, -38, -41, -40, -42, -43, -43, -46, -44, -47, -48, -47, -50, -50, -52, -53,
-52, -55, -55, -56, -58, -57, -57, -60, -60, -62, -62, -64, -64, -64, -66, -66,
-69, -69, -69, -72, -71, -72, -74, -73, -74, -76, -76, -78, -80, -79, -81, -82,
-82, -83, -84, -86, -85, -86, -89, -88, -90, -91, -90, -92, -92, -94, -96, -96,
-97, -97, -99, -100, -100, -103, -102, -103, -105, -104, -106, -108, -107, -108,
-110, -111, -112, -112, -114, -114, -115, -116, -116, -119, -120, -119, -116,
-117, -114, -114, -113, -111, -112, -110, -109, -109, -106, -108, -106, -104,
-105, -102, -102, -101, -98, -99, -97, -97, -96, -94, -96, -93, -92, -91, -90,
-90, -88, -87, -88, -86, -84, -84, -82, -83, -81, -81, -79, -77, -78, -75, -75,
-75, -74, -73, -73, -70, -71, -70, -68, -69, -66, -65, -66, -63, -63, -61, -61,
-61, -58, -58, -57, -56, -56, -53, -53, -54, -51, -50, -49, -49, -48, -45, -46,
-44, -44, -43, -40, -42, -39, -39, -39, -37, -36, -37, -34, -34, -32, -32, -31,
-29, -30, -26, -27, -26, -24, -24, -23, -21, -22, -20, -19, -18, -17, -17, -14,
-15, -13, -12, -12, -10, -10, -10, -8, -7, -5, -5, -4, -3, -3, -2, 0, 0, };