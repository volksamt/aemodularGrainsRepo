#define DATA_LENGTH 512
#define DATA AKWF_sin4bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {21, 26, 24, 25, 24, 26, 24, 24, 25,
25, 24, 25, 25, 25, 25, 25, 25, 25, 25, 24, 25, 24, 25, 25, 25, 24, 26, 23, 26,
22, 33, 72, 72, 72, 71, 72, 72, 71, 72, 71, 73, 72, 72, 71, 73, 71, 72, 71, 72,
71, 71, 71, 73, 71, 72, 72, 72, 71, 72, 72, 71, 73, 70, 73, 71, 74, 67, 94, 122,
117, 121, 119, 120, 118, 119, 118, 119, 118, 119, 119, 118, 119, 118, 119, 118,
119, 118, 118, 118, 119, 119, 119, 119, 118, 118, 119, 118, 119, 119, 119, 118,
118, 118, 119, 118, 119, 118, 119, 119, 118, 119, 117, 119, 119, 118, 118, 118,
118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 117, 118,
118, 118, 117, 119, 118, 118, 117, 117, 117, 118, 117, 118, 118, 118, 118, 118,
118, 118, 117, 118, 117, 117, 117, 117, 118, 117, 117, 117, 117, 117, 117, 118,
118, 117, 118, 117, 118, 117, 118, 117, 118, 117, 117, 116, 117, 118, 117, 117,
117, 118, 117, 118, 116, 119, 114, 122, 90, 64, 73, 68, 71, 68, 70, 68, 71, 69,
70, 70, 70, 70, 70, 70, 69, 70, 70, 70, 70, 70, 69, 70, 69, 70, 69, 70, 69, 71,
69, 70, 68, 70, 70, 69, 70, 28, 19, 24, 20, 24, 21, 24, 21, 23, 22, 23, 22, 22,
22, 21, 22, 22, 22, 22, 23, 21, 24, 21, 23, 21, 24, 21, 24, 19, 26, 13, -28,
-24, -26, -25, -25, -25, -24, -25, -25, -26, -25, -25, -25, -26, -25, -26, -25,
-25, -24, -26, -24, -26, -24, -26, -23, -26, -23, -27, -20, -40, -77, -69, -73,
-71, -73, -71, -72, -71, -72, -72, -72, -72, -71, -73, -72, -72, -71, -73, -71,
-73, -71, -73, -72, -73, -72, -73, -71, -72, -72, -72, -73, -71, -72, -70, -74,
-67, -102, -124, -116, -121, -118, -120, -118, -120, -119, -120, -119, -119,
-119, -118, -119, -118, -119, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -118, -118, -118, -119, -119,
-119, -119, -118, -118, -118, -118, -118, -118, -119, -119, -118, -119, -118,
-119, -119, -118, -118, -119, -118, -118, -118, -119, -118, -119, -119, -118,
-118, -118, -118, -118, -119, -118, -118, -118, -117, -118, -118, -118, -119,
-118, -118, -118, -117, -118, -118, -118, -117, -118, -117, -118, -118, -117,
-117, -117, -118, -117, -118, -118, -118, -117, -118, -118, -118, -118, -118,
-117, -118, -118, -117, -117, -118, -117, -118, -117, -117, -118, -117, -117,
-117, -118, -116, -118, -116, -123, -85, -65, -73, -68, -72, -69, -71, -69, -71,
-69, -71, -70, -70, -70, -69, -70, -69, -70, -70, -70, -69, -70, -70, -71, -69,
-71, -68, -70, -70, -71, -69, -71, -68, -71, -69, -71, -68, -25, -22, -23, -21,
-24, -22, -23, -23, -23, -22, -23, -22, -23, -22, -23, -22, -22, -22, -23, -22,
-23, -21, -23, -22, -23, -22, -23, -21, -23, -19, };