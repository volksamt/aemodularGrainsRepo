#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0026

const PROGMEM int8_t DATA[DATA_LENGTH] = {31, 37, 34, 36, 34, 35, 35, 35, 34,
35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 35, 34, 35, 35, 36, 34, 35, 35, 35,
35, 35, 35, 35, 34, 34, 35, 35, 35, 35, 35, 34, 34, 34, 34, 35, 34, 35, 34, 34,
35, 34, 34, 35, 35, 34, 35, 35, 35, 34, 35, 35, 35, 34, 35, 35, 35, 35, 35, 34,
34, 35, 35, 35, 34, 35, 34, 34, 34, 35, 34, 35, 34, 35, 33, 35, 33, 36, 32, 37,
32, 36, 31, 38, 26, -43, -42, -42, -42, -41, -42, -41, -43, -41, -43, -42, -43,
-41, -43, -41, -43, -42, -43, -42, -42, -42, -42, -42, -41, -42, -42, -41, -42,
-42, -42, -42, -42, -42, -41, -43, -42, -42, -42, -43, -42, -43, -43, -42, -42,
-42, -42, -42, -42, -42, -42, -42, -41, -42, -42, -42, -41, -42, -41, -43, -42,
-42, -41, -43, -41, -42, -41, -43, -41, -42, -41, -42, -42, -41, -44, 25, 39,
32, 37, 33, 37, 34, 36, 34, 36, 33, 36, 34, 35, 34, 35, 34, 35, 35, 35, 35, 34,
34, 34, 34, 35, 35, 35, 35, 34, 35, 35, 35, 34, 35, 35, 35, 35, 35, 34, 36, 35,
34, 34, 34, 34, 34, 35, 35, 35, 35, 35, 35, 34, 35, 35, 35, 35, 34, 35, 34, 35,
35, 35, 35, 34, 34, 35, 35, 34, 34, 35, 34, 35, 34, 34, 35, 35, 34, 35, 35, 35,
34, 35, 35, 34, 35, 35, 35, 34, 35, 35, 34, 34, 35, 35, 35, 34, 35, 35, 34, 34,
34, 35, 35, 34, 34, 34, 34, 34, 34, 35, 35, 35, 34, 35, 34, 34, 35, 34, 35, 34,
34, 34, 35, 35, 35, 35, 35, 34, 34, 34, 34, 34, 34, 35, 34, 35, 35, 34, 34, 35,
34, 34, 34, 34, 34, 35, 35, 34, 34, 34, 35, 34, 35, 34, 35, 34, 34, 33, 34, 34,
35, 33, 35, 34, 35, 33, 35, 34, 34, 34, 34, 37, -33, -47, -39, -45, -40, -45,
-40, -45, -40, -44, -41, -44, -41, -43, -41, -43, -42, -43, -42, -43, -43, -41,
-43, -42, -44, -41, -45, -40, -46, -39, -48, -32, -80, -128, -114, -123, -116,
-122, -117, -121, -116, -122, -114, -128, -78, -33, -48, -38, -45, -40, -45,
-41, -43, -41, -43, -42, -43, -42, -43, -43, -43, -43, -42, -42, -42, -43, -43,
-43, -42, -42, -41, -42, -42, -42, -42, -42, -43, -42, -42, -42, -42, -42, -43,
-42, -43, -42, -43, -42, -42, -42, -42, -42, -42, -43, -42, -42, -42, -42, -41,
-42, -41, -43, -40, -44, -38, -48, -22, 41, 31, 36, 34, 35, 35, 35, 36, 33, 36,
34, 35, 33, 36, 33, 36, 33, 36, 33, 36, 33, 37, 33, 36, 33, 36, 33, -37, -44,
-40, -43, -41, -43, -41, -43, -41, -43, -41, -43, -41, -42, -41, -42, -42, -42,
-41, -42, -42, -42, -42, -42, -43, -41, -43, -40, -43, -41, -43, -40, -43, -40,
-45, -35, };