#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {18, 20, 19, 20, 20, 21, 19, 20, 19,
20, 20, 21, 19, 21, 19, 20, 19, 20, 19, 21, 19, 21, 19, 21, 17, 27, 42, 39, 40,
39, 40, 39, 41, 38, 56, 61, 59, 60, 59, 60, 58, 60, 59, 60, 59, 59, 60, 60, 58,
60, 59, 60, 58, 60, 59, 60, 59, 61, 58, 63, 80, 78, 79, 79, 79, 79, 78, 79, 79,
79, 79, 80, 80, 80, 79, 79, 78, 80, 80, 80, 80, 80, 79, 79, 79, 79, 79, 80, 79,
79, 79, 79, 80, 78, 79, 79, 80, 79, 80, 78, 85, 101, 98, 99, 99, 98, 99, 99,
100, 99, 99, 99, 99, 99, 99, 99, 100, 99, 100, 98, 99, 100, 99, 99, 100, 99,
100, 99, 99, 99, 99, 99, 100, 100, 99, 100, 98, 101, 85, 78, 79, 80, 80, 80, 79,
80, 75, 58, 60, 60, 59, 60, 59, 61, 49, 38, 41, 39, 40, 39, 39, 40, 40, 40, 40,
40, 40, 40, 39, 40, 40, 40, 39, 40, 39, 40, 40, 40, 39, 39, 40, 40, 40, 40, 39,
41, 39, 41, 33, 18, 21, 20, 20, 18, 22, 9, -3, 1, -1, 0, -1, 0, 0, 0, 0, 0, -1,
0, 0, -1, -1, 0, 0, -1, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 1, -1, 0,
-1, 2, -6, -20, -18, -21, -19, -20, -20, -21, -19, -21, -18, -25, -42, -39, -41,
-39, -40, -39, -39, -40, -40, -39, -40, -39, -39, -39, -39, -39, -39, -40, -40,
-40, -40, -40, -40, -40, -39, -40, -39, -40, -40, -39, -41, -39, -40, -38, -44,
-60, -59, -60, -59, -60, -59, -59, -60, -60, -60, -60, -59, -59, -60, -59, -60,
-59, -60, -59, -60, -60, -59, -60, -59, -60, -59, -59, -59, -60, -59, -60, -59,
-60, -59, -60, -59, -60, -59, -62, -79, -79, -79, -79, -79, -80, -79, -79, -80,
-78, -95, -101, -98, -100, -98, -100, -98, -100, -98, -100, -98, -100, -99, -99,
-99, -99, -99, -98, -117, -120, -119, -119, -119, -119, -119, -119, -120, -118,
-119, -118, -100, -99, -100, -98, -100, -99, -100, -99, -100, -99, -99, -98,
-99, -99, -99, -99, -100, -100, -99, -99, -100, -99, -100, -99, -100, -99, -99,
-99, -100, -99, -99, -98, -99, -99, -99, -99, -99, -100, -100, -99, -100, -99,
-99, -99, -99, -100, -98, -101, -93, -78, -80, -78, -80, -79, -79, -80, -79,
-80, -80, -79, -78, -79, -79, -80, -79, -79, -79, -79, -78, -80, -79, -79, -79,
-79, -80, -80, -80, -78, -82, -67, -58, -61, -59, -61, -59, -60, -59, -59, -60,
-59, -61, -45, -38, -42, -39, -41, -39, -40, -39, -40, -39, -40, -40, -41, -39,
-41, -33, -18, -22, -19, -20, -19, -20, -20, -20, -20, -20, -20, -19, -20, -19,
-21, -19, -22, -11, 3, -1, 1, -1, 0, 0, 1, -1, 0, -1, 1, 0, 0, 0, 0, 0, 1, -1,
1, -2, 5, 15, -2, 0, 0, 0, 0, };