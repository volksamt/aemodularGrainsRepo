#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {43, 49, 48, 48, 49, 47, 51, 41, 75,
127, 115, 122, 117, 121, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 118, 119, 118, 119,
119, 119, 119, 118, 118, 119, 118, 118, 118, 119, 118, 118, 119, 118, 119, 118,
119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 119, 118, 117, 119,
119, 119, 118, 118, 118, 119, 118, 119, 118, 118, 118, 118, 118, 119, 117, 120,
118, 119, 116, 121, 110, 45, 48, 47, 46, 48, 46, 50, 44, 55, -5, -29, -20, -24,
-23, -24, -25, -21, -27, -15, -57, -102, -90, -97, -92, -96, -93, -96, -94, -95,
-94, -94, -95, -94, -95, -93, -94, -93, -94, -94, -94, -93, -95, -94, -94, -93,
-94, -94, -94, -94, -94, -93, -95, -93, -95, -93, -95, -93, -95, -93, -96, -91,
-97, -90, -100, -75, -17, -26, -22, -24, -23, -22, -23, -23, -24, -22, -24, -22,
-23, -23, -24, -22, -24, -23, -23, -22, -23, -24, -22, -23, -23, -23, -23, -24,
-23, -24, -23, -23, -23, -24, -23, -23, -23, -22, -23, -22, -24, -22, -25, -20,
-27, -17, -33, 14, 55, 44, 50, 46, 49, 47, 49, 46, 48, 46, 51, 40, 99, 126, 114,
122, 116, 121, 116, 120, 117, 119, 117, 119, 117, 119, 118, 119, 118, 117, 118,
118, 119, 118, 119, 117, 119, 117, 118, 118, 118, 118, 118, 119, 118, 118, 118,
118, 118, 118, 118, 119, 118, 118, 118, 118, 118, 118, 117, 118, 117, 118, 118,
117, 118, 118, 118, 117, 117, 118, 117, 118, 117, 119, 117, 117, 117, 118, 118,
118, 118, 118, 118, 117, 118, 117, 119, 116, 120, 114, 125, 92, 37, 52, 43, 49,
44, 49, 45, 48, 44, -23, -25, -24, -23, -26, -22, -28, -16, -57, -103, -90, -98,
-93, -96, -94, -95, -95, -95, -95, -95, -95, -94, -94, -94, -96, -95, -95, -95,
-95, -94, -96, -95, -95, -95, -95, -94, -95, -94, -95, -95, -95, -95, -95, -95,
-94, -95, -94, -95, -93, -94, -95, -94, -94, -95, -94, -94, -94, -95, -94, -94,
-94, -94, -94, -94, -94, -95, -95, -93, -94, -94, -94, -94, -95, -94, -95, -95,
-95, -94, -95, -94, -94, -93, -94, -94, -94, -94, -95, -94, -94, -95, -93, -98,
-32, -20, -25, -22, -24, -23, -24, -22, -26, -20, -30, 34, 51, 45, 47, 53, 2,
-34, -15, -32, -11, -65, -100, -91, -95, -93, -95, -93, -94, -93, -95, -94, -94,
-94, -94, -94, -93, -94, -94, -94, -94, -93, -94, -93, -93, -94, -94, -93, -94,
-94, -94, -94, -93, -94, -93, -93, -94, -93, -94, -93, -94, -94, -94, -94, -93,
-93, -93, -92, -94, -94, -93, -93, -94, -94, -93, -93, -93, -93, -93, -94, -92,
-94, -94, -93, -92, -93, -93, -94, -92, -94, -93, -93, -93, -93, -93, -93, -93,
-93, -94, -91, -95, -89, -101, -45, -16, -26, -20, -25, -21, -22, -22, -20, };