#define DATA_LENGTH 512
#define DATA AKWF_tri3bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {35, 43, 39, 42, 40, 41, 40, 41, 39,
40, 39, 41, 40, 40, 40, 40, 40, 40, 41, 40, 41, 40, 39, 40, 39, 41, 41, 40, 41,
41, 40, 40, 41, 41, 41, 41, 41, 41, 40, 40, 41, 40, 40, 41, 41, 40, 40, 40, 40,
40, 40, 41, 40, 41, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40,
41, 40, 40, 40, 40, 40, 40, 41, 40, 40, 40, 40, 40, 40, 40, 40, 39, 40, 41, 40,
40, 40, 40, 39, 41, 40, 40, 39, 40, 39, 41, 39, 41, 39, 41, 40, 40, 39, 40, 41,
38, 110, 122, 116, 121, 117, 120, 117, 121, 118, 120, 118, 120, 118, 119, 118,
119, 118, 119, 118, 119, 119, 118, 119, 119, 118, 119, 118, 120, 118, 120, 117,
120, 116, 121, 115, 125, 102, 33, 42, 39, 40, 39, 39, 40, 39, 39, 39, 40, 38,
40, 39, 39, 39, 41, 39, 39, 39, 39, 39, 39, 39, 40, 40, 39, 38, 39, 40, 40, 40,
39, 40, 39, 39, 39, 40, 39, 38, 38, 39, 39, 40, 40, 39, 39, 39, 39, 39, 39, 39,
38, 39, 39, 39, 38, 39, 39, 39, 39, 38, 38, 38, 39, 39, 39, 38, 39, 39, 39, 39,
39, 39, 39, 39, 39, 39, 39, 39, 39, 39, 39, 38, 39, 40, 38, 39, 38, 39, 39, 39,
39, 39, 38, 40, 38, 40, 37, 40, 37, 41, 38, 40, 37, 40, 37, 41, 34, -33, -41,
-40, -42, -40, -42, -39, -41, -39, -41, -40, -42, -40, -41, -39, -42, -40, -40,
-39, -40, -40, -41, -40, -40, -41, -40, -41, -40, -40, -40, -41, -39, -40, -40,
-40, -41, -40, -40, -40, -41, -41, -40, -41, -41, -39, -40, -40, -40, -41, -40,
-41, -40, -40, -41, -40, -41, -41, -40, -41, -40, -41, -40, -40, -41, -40, -41,
-40, -40, -40, -40, -41, -40, -40, -41, -41, -40, -41, -40, -40, -40, -40, -40,
-40, -41, -40, -40, -40, -40, -40, -40, -40, -41, -40, -41, -40, -41, -39, -40,
-39, -40, -39, -42, -39, -41, -39, -41, -39, -42, -38, -42, -110, -121, -118,
-120, -117, -120, -118, -120, -118, -119, -118, -120, -118, -120, -119, -119,
-118, -119, -119, -119, -118, -119, -119, -119, -119, -118, -119, -120, -118,
-120, -118, -120, -116, -121, -115, -126, -97, -35, -42, -38, -41, -39, -40,
-40, -40, -40, -39, -39, -39, -40, -39, -40, -39, -39, -39, -40, -39, -40, -38,
-39, -39, -39, -39, -39, -40, -39, -39, -40, -39, -40, -39, -39, -39, -39, -40,
-40, -39, -39, -39, -39, -39, -39, -40, -39, -39, -39, -39, -39, -39, -39, -38,
-39, -39, -40, -38, -39, -39, -39, -39, -39, -40, -38, -38, -39, -39, -39, -38,
-40, -39, -39, -39, -39, -40, -38, -39, -40, -38, -39, -40, -39, -39, -39, -39,
-39, -38, -39, -39, -39, -39, -39, -40, -39, -39, -38, -40, -38, -40, -39, -40,
-38, -39, -37, -40, -37, -41, -33, };