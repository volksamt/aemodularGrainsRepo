#define DATA_LENGTH 512
#define DATA AKWF_tri4bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {22, 26, 23, 25, 24, 25, 24, 25, 24,
26, 24, 25, 24, 24, 24, 25, 25, 25, 25, 25, 25, 24, 25, 25, 25, 24, 25, 25, 25,
24, 25, 24, 26, 24, 25, 24, 25, 24, 26, 24, 26, 24, 25, 23, 26, 23, 26, 66, 73,
71, 73, 72, 73, 72, 73, 71, 73, 72, 73, 71, 72, 71, 72, 72, 72, 73, 72, 72, 72,
73, 72, 72, 72, 73, 72, 72, 72, 72, 72, 71, 72, 72, 72, 72, 72, 71, 72, 71, 73,
71, 73, 70, 74, 68, 83, 123, 118, 119, 119, 120, 119, 119, 119, 118, 119, 118,
119, 118, 119, 119, 120, 118, 119, 118, 118, 118, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 118, 119, 118, 118, 118, 118,
119, 118, 119, 118, 119, 118, 118, 118, 119, 118, 119, 117, 119, 117, 118, 118,
119, 117, 118, 118, 118, 119, 118, 119, 77, 68, 72, 70, 72, 69, 72, 69, 72, 71,
72, 70, 71, 71, 71, 70, 70, 70, 70, 70, 71, 70, 70, 71, 70, 70, 71, 70, 71, 71,
70, 70, 71, 70, 70, 71, 71, 70, 71, 69, 71, 69, 72, 68, 72, 68, 72, 65, 22, 23,
23, 22, 23, 23, 23, 23, 23, 22, 23, 21, 24, 22, 23, 22, 22, 22, 23, 23, 23, 23,
22, 23, 23, 22, 23, 23, 22, 22, 24, 22, 23, 23, 23, 22, 23, 23, 23, 22, 23, 21,
24, 21, 24, 19, -25, -26, -24, -25, -24, -26, -24, -25, -24, -26, -24, -26, -24,
-25, -24, -25, -25, -25, -24, -26, -25, -25, -25, -25, -24, -25, -25, -25, -25,
-24, -25, -25, -25, -24, -25, -24, -25, -24, -26, -25, -26, -24, -25, -23, -27,
-22, -31, -74, -71, -72, -72, -72, -72, -72, -72, -72, -72, -71, -73, -71, -72,
-72, -73, -71, -72, -72, -72, -71, -72, -71, -72, -72, -72, -72, -72, -72, -71,
-72, -72, -72, -72, -72, -71, -71, -71, -73, -71, -73, -71, -72, -70, -73, -69,
-75, -66, -95, -125, -116, -122, -118, -119, -118, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -118, -119, -118, -118,
-119, -119, -119, -119, -119, -119, -118, -119, -118, -119, -119, -118, -119,
-118, -119, -118, -118, -119, -118, -119, -118, -118, -119, -118, -118, -117,
-119, -118, -118, -118, -119, -118, -119, -118, -119, -118, -118, -117, -120,
-117, -120, -118, -73, -68, -72, -70, -71, -69, -72, -70, -72, -70, -71, -71,
-70, -71, -71, -70, -70, -71, -70, -70, -71, -70, -71, -71, -70, -70, -70, -71,
-71, -70, -71, -70, -70, -70, -70, -70, -70, -70, -71, -70, -72, -69, -72, -69,
-73, -68, -74, -60, -19, -24, -22, -23, -23, -23, -23, -22, -23, -23, -23, -22,
-23, -22, -24, -23, -23, -22, -24, -23, -23, -22, -23, -23, -22, -23, -23, -23,
-23, -23, -23, -22, -22, -22, -23, -23, -23, -23, -23, -21, -23, -22, -23, -21,
-24, -19, };