#define DATA_LENGTH 512
#define DATA AKWF_squ2bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 115, 122, 115, 121, 117,
120, 118, 120, 117, 120, 118, 120, 119, 119, 118, 120, 119, 120, 118, 119, 118,
119, 119, 119, 120, 118, 119, 119, 119, 118, 119, 118, 119, 119, 119, 118, 119,
118, 119, 118, 119, 119, 118, 118, 119, 118, 118, 118, 118, 119, 118, 118, 119,
118, 119, 118, 119, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118,
118, 118, 118, 118, 119, 118, 118, 118, 118, 118, 117, 118, 118, 118, 119, 118,
118, 118, 118, 118, 117, 118, 119, 119, 118, 118, 118, 117, 118, 118, 117, 118,
117, 117, 117, 118, 118, 118, 118, 118, 118, 117, 118, 117, 117, 118, 118, 117,
118, 118, 118, 118, 117, 117, 118, 117, 117, 117, 116, 117, 117, 118, 117, 117,
117, 117, 117, 117, 117, 117, 117, 117, 118, 117, 117, 117, 116, 117, 117, 117,
117, 117, 117, 118, 116, 116, 117, 117, 118, 117, 116, 116, 117, 116, 117, 117,
116, 116, 117, 116, 117, 117, 116, 116, 117, 116, 116, 117, 116, 117, 117, 116,
116, 116, 117, 117, 117, 117, 117, 116, 117, 117, 116, 116, 116, 117, 116, 116,
116, 116, 116, 117, 116, 116, 116, 116, 116, 116, 117, 116, 117, 116, 116, 116,
116, 116, 117, 115, 116, 116, 116, 116, 116, 115, 117, 115, 116, 115, 116, 116,
116, 116, 115, 116, 115, 116, 115, 117, 114, 117, 114, 117, 114, 118, 113, 119,
112, 120, 111, 120, 111, 121, 109, 123, 100, -115, -122, -116, -123, -115, -123,
-116, -123, -115, -122, -116, -122, -116, -121, -117, -121, -119, -121, -118,
-120, -119, -120, -119, -119, -119, -120, -120, -118, -120, -119, -119, -119,
-120, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -118, -118, -119, -118, -118, -119, -119, -119,
-118, -119, -119, -119, -118, -119, -119, -118, -119, -118, -119, -118, -118,
-118, -118, -119, -119, -118, -119, -118, -119, -118, -119, -118, -118, -118,
-119, -119, -119, -118, -118, -118, -118, -118, -118, -118, -118, -117, -118,
-118, -119, -119, -117, -117, -118, -118, -118, -117, -118, -118, -119, -118,
-118, -119, -118, -118, -117, -118, -118, -118, -117, -118, -118, -117, -117,
-118, -117, -118, -118, -117, -117, -118, -117, -118, -117, -117, -117, -118,
-117, -117, -117, -117, -118, -117, -118, -117, -117, -117, -117, -117, -117,
-117, -118, -117, -117, -118, -117, -118, -117, -117, -117, -118, -117, -117,
-117, -117, -118, -116, -117, -117, -117, -117, -117, -116, -117, -117, -117,
-117, -117, -116, -117, -117, -117, -117, -117, -117, -117, -116, -117, -117,
-117, -116, -117, -117, -117, -116, -117, -116, -116, -117, -116, -117, -116,
-116, -116, -117, -117, -116, -116, -116, -116, -116, -117, -116, -116, -116,
-116, -116, -116, -116, -116, -117, -116, -116, -117, -116, -115, -116, -115,
-116, -115, -116, -116, -117, -115, -117, -116, -116, -116, -116, -117, -115,
-116, -115, -117, -115, -117, -115, -118, -113, -119, -113, -119, -112, -120,
-111, -123, -99, };