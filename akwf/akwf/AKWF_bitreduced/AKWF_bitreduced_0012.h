#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {17, 21, 19, 21, 19, 19, 20, 20, 21,
18, 34, 42, 38, 41, 40, 39, 41, 39, 43, 61, 59, 60, 60, 59, 59, 59, 61, 58, 76,
80, 79, 80, 79, 80, 78, 80, 77, 87, 102, 98, 100, 99, 99, 99, 99, 100, 99, 99,
99, 99, 99, 99, 99, 100, 99, 100, 99, 99, 99, 100, 99, 99, 99, 99, 99, 99, 99,
99, 100, 99, 99, 99, 99, 99, 99, 99, 99, 99, 100, 100, 99, 99, 100, 99, 99, 99,
100, 98, 99, 99, 100, 99, 100, 99, 99, 99, 99, 99, 98, 99, 99, 99, 99, 99, 99,
100, 99, 99, 100, 99, 99, 99, 100, 99, 99, 100, 99, 99, 99, 99, 100, 99, 99,
100, 100, 99, 99, 99, 99, 99, 99, 99, 99, 100, 99, 99, 99, 99, 99, 99, 99, 98,
99, 99, 100, 99, 100, 99, 100, 99, 99, 99, 99, 99, 99, 100, 98, 100, 99, 99, 99,
100, 99, 100, 99, 99, 100, 100, 99, 99, 98, 100, 99, 100, 98, 101, 93, 77, 80,
79, 79, 79, 80, 78, 81, 62, 59, 58, 61, 48, 37, 41, 40, 36, 15, 24, 2, 1, -4,
-20, -20, -18, -36, -40, -43, -61, -58, -60, -59, -79, -80, -79, -77, -92, -102,
-96, -100, -97, -100, -98, -100, -118, -120, -118, -120, -118, -119, -118, -120,
-119, -118, -118, -119, -119, -120, -120, -119, -118, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -118, -119, -119, -119, -120, -118, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -120, -119, -120, -118, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -118, -118, -119, -119, -119, -119, -118, -119, -119,
-119, -118, -118, -120, -119, -119, -120, -119, -119, -120, -119, -120, -120,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -118, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -120, -119, -120, -119, -119, -119,
-119, -119, -120, -118, -119, -118, -119, -120, -119, -119, -119, -119, -119,
-119, -100, -99, -100, -99, -100, -99, -99, -99, -100, -98, -100, -82, -79, -80,
-79, -79, -81, -78, -81, -73, -57, -61, -59, -60, -59, -60, -59, -61, -43, -40,
-41, -39, -40, -41, -39, -41, -35, -17, -21, -19, -20, -19, -20, -20, -20, -19,
-21, -16, 2, -1, 1, 0, -1, 0, 1, 0, -1, 0, -1, -1, 0, 1, -1, 0, 0, 0, 0, 0, -1,
1, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 1, 1, 0, 1, -1, 0, 1, 0, 0, 0, -1, 0, 0,
0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, -1, 2, -13, -22, -18, -21, -19, -20, -20,
-20, -20, -21, -20, -20, -19, -20, -20, -20, -20, -20, -20, -20, -19, -21, -19,
-20, -19, -20, -19, -22, -10, 3, -1, 1, -1, 1, 0, 0, 0, -1, 0, 0, 0, -1, -1, 0,
};