#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {17, 21, 17, 30, 43, 38, 41, 38, 47,
62, 58, 61, 58, 61, 60, 60, 59, 60, 60, 59, 59, 60, 58, 61, 57, 65, 82, 78, 80,
78, 80, 77, 88, 100, 98, 100, 99, 99, 99, 99, 99, 99, 99, 100, 99, 99, 99, 99,
99, 99, 100, 99, 100, 97, 101, 90, 76, 82, 77, 82, 74, 59, 60, 59, 60, 59, 60,
60, 60, 59, 59, 59, 60, 59, 59, 59, 40, 40, 39, 42, 25, 19, 19, -4, 4, -14, -21,
-21, -18, -27, -42, -39, -41, -40, -41, -40, -40, -40, -40, -39, -42, -38, -51,
-62, -58, -60, -60, -58, -70, -82, -78, -80, -78, -79, -79, -80, -78, -79, -79,
-79, -80, -79, -79, -79, -80, -78, -82, -62, -59, -61, -60, -59, -60, -59, -61,
-54, -37, -43, -23, -20, -19, -21, -12, 3, -2, 2, -1, 1, -2, 1, -1, 1, -3, 8,
22, 19, 19, 20, 18, 27, 43, 37, 43, 57, 61, 56, 72, 80, 79, 80, 79, 80, 79, 78,
79, 79, 80, 78, 79, 77, 82, 99, 99, 99, 99, 98, 99, 99, 100, 98, 101, 98, 100,
98, 100, 99, 100, 99, 81, 78, 79, 79, 79, 78, 80, 79, 80, 78, 80, 79, 80, 79,
80, 80, 62, 58, 59, 60, 50, 36, 43, 35, 20, 19, 22, 19, 22, 14, 0, -2, 13, 23,
18, 21, 20, 22, 7, -4, 3, -3, 3, -13, -21, -20, -18, -24, -42, -36, -55, -61,
-58, -60, -59, -60, -60, -60, -59, -59, -60, -59, -59, -59, -60, -60, -59, -59,
-60, -77, -80, -79, -80, -78, -80, -98, -100, -98, -100, -99, -100, -99, -99,
-99, -99, -99, -99, -100, -99, -99, -99, -99, -100, -99, -99, -100, -98, -99,
-118, -119, -118, -119, -119, -119, -118, -119, -119, -119, -119, -120, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-118, -119, -119, -118, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -118, -120, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -118, -119, -120, -119, -118, -119, -119, -119, -119, -118, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -117, -121, -106, -97, -100,
-98, -99, -99, -99, -116, -120, -118, -119, -118, -120, -118, -121, -118, -120,
-118, -119, -118, -122, -113, -97, -100, -99, -99, -99, -99, -99, -100, -99,
-100, -100, -99, -99, -99, -99, -99, -99, -98, -99, -99, -100, -99, -100, -99,
-99, -100, -81, -78, -81, -78, -82, -64, -58, -61, -59, -60, -59, -59, -59, -59,
-59, -60, -59, -60, -59, -60, -60, -59, -60, -59, -59, -59, -62, -49, -36, -43,
-34, -19, -20, -20, -20, -21, -16, 2, -1, 1, 0, -18, -21, -19, -21, -19, -21,
-18, 1, 0, -1, 1, -1, 0, };