#define DATA_LENGTH 512
#define DATA AKWF_squ7bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {105, 124, 115, 122, 116, 122, 116,
121, 116, 120, 118, 120, 118, 120, 119, 119, 118, 120, 119, 120, 119, 119, 119,
118, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119,
119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 119, 119, 119, 118, 118, 119,
118, 119, 119, 119, 119, 118, 118, 118, 119, 119, 118, 118, 119, 119, 118, 119,
118, 118, 119, 119, 118, 118, 118, 119, 118, 118, 119, 119, 119, 118, 118, 119,
118, 118, 118, 119, 118, 118, 117, 118, 118, 118, 118, 118, 118, 118, 118, 118,
118, 117, 118, 117, 117, 118, 118, 117, 117, 118, 118, 118, 118, 118, 118, 118,
118, 118, 118, 118, 117, 118, 117, 118, 117, 117, 117, 118, 117, 118, 117, 117,
117, 117, 117, 118, 117, 117, 117, 117, 118, 118, 117, 118, 117, 117, 117, 117,
117, 116, 117, 118, 117, 117, 117, 117, 116, 117, 116, 117, 117, 117, 117, 116,
117, 117, 116, 117, 117, 117, 117, 117, 117, 117, 117, 117, 116, 117, 117, 117,
116, 117, 117, 116, 117, 117, 117, 117, 116, 116, 117, 117, 116, 117, 116, 117,
116, 116, 117, 117, 117, 117, 116, 116, 116, 116, 116, 117, 115, 116, 116, 116,
117, 116, 116, 116, 115, 116, 117, 116, 116, 116, 116, 117, 116, 116, 115, 116,
116, 116, 117, 115, 116, 115, 117, 116, 116, 115, 116, 116, 116, 116, 115, 116,
115, 116, 114, 117, 113, 119, 112, 123, 8, -123, -116, -121, -118, -120, -118,
-120, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -120, -119,
-119, -118, -119, -119, -119, -119, -120, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -118, -119, -118,
-118, -118, -119, -118, -119, -119, -119, -118, -119, -119, -118, -118, -119,
-119, -118, -118, -118, -117, -119, -118, -119, -118, -118, -119, -119, -118,
-118, -118, -118, -119, -118, -118, -118, -117, -118, -118, -118, -118, -118,
-118, -118, -118, -119, -119, -119, -119, -118, -117, -118, -118, -117, -118,
-117, -118, -118, -119, -118, -118, -117, -118, -117, -118, -117, -118, -117,
-117, -117, -117, -117, -117, -118, -117, -117, -118, -117, -117, -118, -118,
-118, -118, -118, -117, -117, -118, -118, -118, -117, -117, -117, -118, -117,
-118, -117, -117, -117, -117, -117, -117, -118, -117, -117, -117, -117, -117,
-118, -117, -117, -117, -117, -117, -117, -117, -117, -117, -118, -117, -117,
-116, -117, -117, -116, -117, -116, -117, -117, -116, -117, -117, -117, -117,
-117, -116, -116, -116, -117, -116, -116, -117, -116, -117, -117, -117, -117,
-117, -116, -116, -116, -116, -116, -116, -116, -116, -116, -116, -116, -117,
-117, -116, -116, -116, -116, -116, -116, -116, -116, -116, -116, -115, -115,
-116, -116, -116, -116, -117, -116, -116, -116, -116, -115, -116, -115, -116,
-114, -116, -114, -117, -114, -117, -113, -117, -113, -118, -114, -117, -113,
-118, -111, -5, };