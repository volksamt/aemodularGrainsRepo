#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {18, 45, 61, 59, 59, 75, 62, 59, 61,
58, 61, 59, 79, 81, 77, 90, 102, 98, 79, 81, 70, 57, 60, 60, 58, 66, 81, 79, 79,
79, 58, 63, 41, 3, 0, -19, -20, -19, -21, -20, -20, -20, -19, -21, -9, 5, -3, 5,
18, 28, 40, 53, 80, 78, 86, 102, 97, 101, 80, 82, 73, 50, 24, 4, -4, -18, -29,
-41, -39, -39, -40, -39, -40, -40, -39, -56, -61, -59, -61, -59, -60, -77, -82,
-78, -81, -78, -80, -79, -79, -79, -80, -80, -65, -57, -61, -57, -62, -44, -38,
-41, -39, -39, -40, -40, -40, -58, -60, -60, -59, -60, -58, -63, -81, -79, -80,
-80, -61, -59, -59, -59, -61, -60, -57, -40, -40, -39, -41, -39, -42, -34, -18,
-20, -20, -19, -21, -14, 2, -1, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 1, -1, 0, -1,
0, -1, 1, 0, 0, 0, 0, 0, -1, 17, 19, -4, 10, 22, 19, 20, 19, 21, 19, 20, 20, 20,
19, 19, 19, 19, 19, 20, 20, 19, 19, 20, 19, 21, 19, 22, 8, -2, 1, -1, 0, -1, 0,
0, 0, 1, -1, 1, 0, 0, -2, -19, -20, -20, -20, -19, -21, -19, -20, -20, -20, -19,
-21, -19, -20, -19, -20, -19, 0, 0, 0, 0, 1, -1, 2, -7, -22, -19, -21, -20, -21,
-19, -20, -20, -20, -20, -19, -20, -20, -20, -20, -20, -22, -12, 2, -1, -16,
-21, -19, -20, -20, -20, -20, -20, -19, -19, -20, -19, -21, -16, 2, 0, 0, -1, 0,
1, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, -1, 2, -9, -22, -18, -2, 2,
-2, 1, -1, 1, -1, 0, 2, -10, -22, -18, -21, -19, -21, -20, -9, 3, -4, -21, -20,
-19, -20, -21, -20, -20, -19, -20, -19, -20, -19, -23, -10, 2, -1, -1, 2, -6,
-23, -18, -20, -20, -21, -19, -20, -19, -21, -17, 0, -1, -1, 1, -2, 2, -6, -22,
-19, -20, -20, -19, -21, -11, 3, -1, 1, -1, 2, -10, -22, -17, -22, -15, 0, 1,
-2, 17, 21, 16, -11, -19, -32, -41, -39, -40, -40, -28, -17, -4, 2, -2, 2, -2,
3, -3, 4, -9, -20, -21, -18, -22, -14, -1, 10, 23, 18, 21, 18, 22, 10, -1, -16,
-24, -42, -31, -17, -22, -1, -1, 3, 33, 41, 41, 37, 22, 12, -1, 0, 1, -22, -40,
-41, -38, -54, -61, -59, -59, -61, -48, -37, -41, -16, 4, 32, 39, 54, 78, 78,
81, 70, 57, 47, 33, 24, 11, 2, -13, -37, -44, -60, -60, -58, -61, -58, -62, -57,
-68, -81, -80, -79, -60, -60, -60, -60, -60, -59, -60, -60, -60, -59, -61, -58,
-61, -58, -62, -57, -62, -57, -64, -49, -41, -25, -6, 8, 38, 48, 60, 59, 58, 42,
33, 20, 19, 21, 17, 2, -5, -29, -53, -76, -96, -102, -123, -117, -121, -117,
-102, -93, -73, -47, -41, -22, 0, };