#define DATA_LENGTH 512
#define DATA AKWF_saw3bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {29, 42, 39, 41, 39, 41, 40, 40, 39,
41, 40, 41, 39, 40, 40, 39, 41, 40, 40, 40, 40, 40, 40, 40, 40, 41, 40, 40, 40,
40, 41, 40, 39, 40, 40, 40, 40, 41, 40, 40, 40, 40, 40, 40, 40, 41, 40, 39, 40,
40, 40, 40, 39, 40, 41, 40, 40, 40, 40, 40, 40, 39, 40, 40, 40, 40, 40, 40, 39,
40, 39, 40, 40, 40, 39, 40, 40, 40, 40, 40, 40, 40, 40, 39, 40, 40, 40, 39, 40,
40, 39, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 39,
39, 39, 40, 40, 39, 40, 39, 40, 39, 40, 40, 39, 40, 39, 40, 39, 40, 40, 39, 40,
40, 40, 40, 39, 40, 39, 39, 39, 39, 39, 39, 40, 40, 39, 40, 39, 39, 40, 39, 40,
39, 39, 40, 39, 39, 39, 40, 39, 39, 39, 40, 39, 40, 39, 39, 39, 40, 39, 40, 40,
39, 39, 40, 39, 39, 39, 40, 39, 39, 39, 39, 39, 40, 39, 39, 39, 40, 39, 39, 39,
39, 40, 40, 40, 40, 40, 39, 39, 38, 40, 39, 40, 39, 40, 39, 40, 38, 40, 39, 40,
38, 39, 39, 39, 40, 39, 40, 37, 43, 31, 96, 124, 114, 121, 115, 120, 117, 119,
117, 118, 118, 118, 118, 118, 117, 118, 117, 118, 117, 118, 117, 119, 117, 119,
115, 120, 115, 120, 115, 122, 113, 121, 113, 123, 112, 126, 103, -115, -123,
-116, -123, -116, -123, -116, -122, -116, -123, -116, -122, -117, -121, -117,
-122, -117, -121, -117, -120, -118, -120, -118, -119, -119, -119, -119, -119,
-119, -118, -121, -117, -120, -116, -122, -115, -128, -83, -34, -44, -39, -41,
-39, -40, -40, -40, -39, -40, -40, -40, -40, -40, -40, -40, -40, -39, -40, -39,
-40, -40, -40, -40, -40, -40, -40, -40, -40, -40, -40, -39, -39, -39, -41, -39,
-40, -40, -40, -40, -40, -39, -40, -40, -40, -40, -40, -40, -40, -40, -39, -40,
-40, -39, -40, -40, -39, -40, -40, -40, -40, -40, -39, -39, -40, -40, -40, -39,
-39, -39, -39, -39, -40, -39, -40, -39, -40, -39, -39, -40, -40, -40, -40, -39,
-39, -40, -40, -40, -40, -39, -40, -40, -39, -40, -39, -40, -39, -39, -40, -40,
-39, -39, -39, -40, -39, -39, -39, -39, -39, -40, -39, -40, -39, -40, -39, -40,
-39, -39, -40, -40, -39, -40, -39, -40, -40, -39, -39, -39, -40, -39, -39, -40,
-40, -40, -40, -40, -39, -40, -40, -39, -39, -40, -39, -40, -39, -39, -39, -39,
-39, -39, -39, -39, -40, -39, -39, -39, -39, -38, -38, -39, -39, -39, -39, -40,
-39, -39, -39, -39, -39, -39, -40, -39, -39, -39, -40, -38, -39, -39, -39, -40,
-39, -39, -39, -39, -39, -38, -39, -39, -39, -39, -39, -39, -39, -38, -39, -39,
-39, -39, -39, -38, -39, -39, -39, -39, -40, -39, -40, -38, -40, -38, -39, -38,
-40, -38, -39, -37, -41, -33, };