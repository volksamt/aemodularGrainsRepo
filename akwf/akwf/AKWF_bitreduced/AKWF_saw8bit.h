#define DATA_LENGTH 512
#define DATA AKWF_saw8bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 2, 3, 2, 2, 2, 4, 4, 4, 5, 4, 6, 7,
7, 7, 7, 9, 9, 9, 9, 8, 11, 12, 12, 12, 12, 13, 15, 14, 14, 13, 14, 17, 16, 16,
16, 17, 18, 19, 18, 18, 19, 22, 22, 21, 21, 22, 24, 23, 24, 24, 23, 26, 26, 26,
26, 26, 28, 28, 28, 28, 28, 30, 31, 31, 31, 30, 32, 33, 34, 33, 34, 32, 35, 35,
36, 36, 36, 38, 37, 37, 38, 38, 38, 41, 40, 40, 40, 41, 43, 42, 42, 43, 43, 45,
45, 45, 46, 45, 47, 47, 48, 47, 47, 49, 49, 49, 50, 49, 50, 51, 51, 51, 52, 54,
55, 54, 54, 53, 55, 57, 56, 57, 56, 57, 60, 59, 59, 58, 60, 62, 61, 62, 61, 62,
64, 63, 64, 64, 64, 66, 66, 65, 66, 66, 68, 69, 68, 68, 67, 70, 71, 70, 71, 71,
70, 72, 73, 73, 73, 75, 76, 76, 76, 75, 76, 76, 78, 77, 78, 77, 79, 80, 80, 80,
79, 81, 82, 83, 83, 82, 84, 85, 85, 85, 84, 85, 87, 88, 88, 87, 87, 87, 89, 90,
90, 90, 91, 92, 91, 91, 91, 93, 94, 94, 94, 94, 96, 97, 96, 97, 96, 97, 99, 98,
98, 98, 100, 102, 101, 102, 101, 102, 103, 103, 103, 104, 102, 106, 104, 107,
105, 107, 107, 109, 107, 108, 107, 108, 111, 110, 111, 109, 114, 111, 115, 111,
116, 109, 119, 110, 121, 108, 123, 105, 127, 74, -128, -114, -118, -116, -116,
-119, -115, -116, -112, -117, -112, -117, -111, -114, -109, -114, -110, -114,
-110, -111, -109, -110, -108, -108, -106, -106, -108, -107, -105, -104, -104,
-105, -104, -102, -102, -101, -102, -102, -100, -99, -100, -99, -100, -99, -97,
-98, -97, -98, -96, -95, -96, -95, -95, -94, -92, -92, -92, -93, -92, -90, -90,
-91, -90, -90, -89, -87, -88, -88, -88, -85, -85, -85, -85, -85, -83, -83, -83,
-83, -83, -81, -80, -80, -80, -80, -78, -78, -77, -78, -78, -77, -75, -75, -75,
-76, -76, -74, -72, -73, -73, -73, -73, -72, -70, -70, -70, -69, -67, -68, -68,
-68, -68, -65, -66, -65, -66, -65, -63, -63, -63, -63, -63, -61, -61, -60, -61,
-61, -58, -59, -58, -58, -58, -56, -55, -56, -56, -56, -55, -53, -53, -53, -54,
-52, -51, -51, -51, -51, -51, -49, -48, -49, -48, -48, -46, -46, -46, -46, -46,
-43, -43, -44, -44, -43, -42, -41, -41, -41, -41, -39, -39, -39, -39, -39, -37,
-36, -37, -36, -37, -36, -35, -34, -35, -33, -34, -34, -32, -32, -33, -31, -30,
-29, -30, -29, -29, -27, -26, -27, -26, -27, -26, -24, -25, -24, -24, -23, -22,
-22, -22, -22, -22, -20, -19, -19, -19, -19, -17, -17, -17, -17, -18, -16, -15,
-15, -14, -15, -13, -12, -13, -12, -13, -10, -10, -10, -9, -11, -9, -8, -8, -7,
-8, -6, -5, -5, -5, -6, -4, -2, -3, -2, -2, -2, 0, 0, -1, 0, -1, };