#define DATA_LENGTH 512
#define DATA AKWF_saw7bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 3, 4, 3, 3, 3, 3, 4, 4, 3, 3, 7, 8,
8, 8, 8, 8, 8, 8, 8, 8, 11, 13, 12, 13, 13, 13, 12, 13, 13, 12, 13, 15, 18, 17,
18, 17, 19, 17, 17, 18, 18, 23, 22, 23, 22, 23, 23, 23, 22, 23, 22, 22, 27, 28,
28, 27, 27, 27, 28, 28, 27, 27, 31, 33, 31, 32, 31, 33, 32, 32, 33, 32, 35, 37,
36, 36, 37, 37, 37, 37, 37, 36, 38, 42, 42, 41, 42, 41, 42, 41, 42, 42, 42, 47,
47, 46, 47, 46, 47, 46, 47, 45, 46, 46, 47, 52, 51, 51, 51, 51, 52, 52, 51, 51,
55, 57, 56, 57, 56, 56, 55, 55, 56, 55, 58, 62, 60, 61, 61, 61, 61, 61, 62, 60,
62, 66, 66, 66, 65, 65, 66, 65, 64, 65, 65, 66, 71, 70, 71, 70, 70, 70, 70, 71,
70, 70, 74, 75, 75, 76, 74, 75, 75, 75, 75, 74, 79, 80, 79, 80, 80, 80, 80, 80,
80, 79, 81, 84, 84, 85, 84, 84, 85, 85, 84, 85, 83, 87, 90, 89, 89, 89, 89, 88,
88, 89, 89, 90, 94, 93, 94, 94, 93, 94, 94, 95, 93, 94, 99, 99, 98, 99, 98, 98,
98, 98, 99, 97, 102, 104, 104, 103, 104, 103, 104, 102, 104, 102, 105, 108, 108,
108, 108, 107, 107, 108, 107, 109, 107, 111, 112, 114, 111, 115, 110, 116, 108,
116, 108, 117, 112, 123, 111, 126, 102, -115, -122, -116, -123, -116, -122,
-111, -118, -112, -117, -112, -116, -113, -116, -112, -116, -109, -109, -109,
-110, -109, -109, -109, -110, -109, -109, -110, -105, -105, -104, -105, -104,
-105, -104, -105, -104, -106, -102, -99, -100, -100, -99, -100, -100, -99, -99,
-100, -98, -94, -94, -95, -94, -95, -95, -95, -95, -95, -94, -91, -89, -90, -89,
-89, -90, -90, -90, -90, -90, -86, -85, -86, -84, -85, -85, -84, -84, -84, -85,
-86, -81, -79, -80, -79, -80, -81, -80, -79, -80, -80, -77, -74, -75, -74, -75,
-74, -75, -75, -74, -76, -73, -70, -70, -70, -70, -71, -69, -70, -69, -70, -70,
-65, -65, -66, -65, -64, -65, -65, -65, -65, -65, -65, -61, -60, -61, -60, -59,
-60, -60, -60, -60, -60, -57, -55, -56, -56, -56, -55, -55, -56, -54, -56, -53,
-51, -50, -50, -50, -50, -51, -51, -50, -51, -51, -49, -45, -45, -45, -45, -45,
-45, -45, -45, -46, -45, -40, -40, -41, -40, -41, -40, -40, -41, -41, -41, -36,
-35, -36, -36, -36, -35, -36, -37, -35, -35, -33, -31, -32, -30, -31, -31, -31,
-31, -30, -31, -29, -26, -26, -25, -26, -26, -25, -26, -26, -26, -26, -21, -22,
-22, -20, -21, -21, -21, -21, -22, -21, -20, -17, -16, -17, -16, -16, -16, -16,
-16, -16, -17, -16, -12, -12, -11, -11, -12, -11, -12, -11, -12, -8, -6, -6, -5,
-7, -6, -7, -6, -6, -8, -5, -1, -2, -2, -1, -1, -2, -2, -2, -1, -2, };