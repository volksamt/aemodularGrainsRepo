#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {18, 20, 20, 21, 19, 20, 19, 20, 20,
20, 19, 20, 20, 21, 20, 20, 20, 20, 19, 20, 17, 31, 42, 39, 41, 40, 41, 39, 40,
40, 40, 39, 39, 40, 39, 39, 39, 39, 40, 38, 57, 61, 59, 60, 59, 60, 59, 60, 59,
60, 59, 61, 58, 60, 58, 61, 58, 60, 77, 81, 78, 81, 78, 82, 78, 81, 78, 81, 78,
80, 80, 79, 80, 78, 82, 75, 106, 87, 125, -33, -128, -104, -128, -112, -124,
-114, -123, -116, -122, -117, -122, -106, -97, -100, -98, -100, -98, -100, -98,
-100, -98, -101, -98, -101, -97, -81, -79, -81, -79, -80, -79, -79, -79, -80,
-78, -80, -79, -80, -79, -81, -68, -58, -61, -59, -61, -59, -60, -59, -60, -60,
-60, -60, -59, -60, -59, -61, -51, -38, -40, -39, -41, -39, -40, -40, -39, -40,
-40, -40, -39, -40, -39, -41, -38, -42, -28, -18, -21, -19, -20, -20, -21, -19,
-20, -21, -20, -20, -19, -20, -19, -19, -21, -19, -20, -18, -21, -19, -23, -10,
3, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 18, 21, 19, 20, 20, 21, 19, 20, 20, 20, 20, 20,
20, 20, 20, 19, 20, 20, 20, 20, 20, 20, 20, 20, 20, 19, 20, 20, 19, 20, 20, 20,
19, 19, 21, 20, 20, 20, 19, 19, 20, 19, 20, 20, 20, 20, 19, 19, 19, 20, 19, 21,
19, 20, 20, 21, 19, 19, 20, 20, 20, 20, 20, 3, -1, 1, -1, 0, -1, 0, 0, 0, 0, 0,
-1, 1, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 1, -1, -1, 0, 0, 0, 0, 0, 0, -1, 1, 0,
0, 0, -1, 0, 0, -1, 1, -1, 0, 0, 0, -1, 0, 0, 0, 1, -17, -21, -19, -20, -19,
-20, -19, -20, -20, -20, -20, -20, -19, -20, -20, -20, -20, -20, -20, -20, -20,
-20, -19, -21, -20, -21, -19, -19, -20, -20, -19, -20, -20, -20, -19, -19, -20,
-20, -19, -20, -19, -20, -20, -20, -20, -20, -20, -20, -21, -19, -21, -19, -21,
-18, -24, -41, -40, -40, -40, -40, -40, -39, -40, -40, -40, -39, -40, -39, -40,
-40, -40, -40, -40, -39, -40, -40, -41, -40, -40, -40, -40, -39, -39, -41, -40,
-40, -39, -40, -40, -40, -40, -39, -40, -40, -39, -39, -39, -40, -40, -39, -40,
-40, -40, -39, -39, -40, -40, -39, -41, -39, -40, -38, -41, -32, -18, -21, -19,
-20, -20, -21, -19, -20, -20, -20, -19, -21, -20, -20, -20, -19, -20, -19, -21,
-20, -20, -21, -20, -20, -20, -20, -20, -20, -20, -20, -20, -19, -20, -20, -20,
-20, -21, -20, -20, -21, -20, -21, -5, 2, -2, 1, -1, 1, 0, 1, -1, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, };