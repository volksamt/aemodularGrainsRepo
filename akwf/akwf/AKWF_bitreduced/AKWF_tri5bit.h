#define DATA_LENGTH 512
#define DATA AKWF_tri5bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 13, 11, 12, 12, 13, 11, 11, 11,
12, 11, 12, 13, 12, 12, 12, 13, 11, 12, 12, 12, 11, 12, 31, 34, 32, 34, 33, 33,
33, 34, 32, 33, 33, 33, 33, 34, 33, 33, 33, 34, 32, 34, 31, 46, 58, 53, 56, 54,
55, 54, 56, 54, 55, 55, 54, 55, 55, 55, 54, 55, 54, 56, 54, 56, 52, 63, 79, 76,
78, 75, 77, 76, 76, 76, 77, 76, 76, 75, 76, 76, 76, 76, 76, 76, 77, 76, 78, 98,
98, 97, 98, 98, 98, 97, 98, 96, 98, 97, 98, 96, 98, 97, 98, 98, 98, 97, 98, 98,
97, 117, 120, 118, 120, 118, 120, 118, 120, 119, 119, 119, 119, 119, 119, 119,
118, 119, 119, 118, 119, 118, 119, 118, 118, 118, 119, 118, 119, 118, 119, 118,
120, 117, 120, 117, 120, 114, 95, 98, 96, 97, 97, 97, 98, 97, 97, 96, 97, 96,
97, 96, 97, 97, 97, 96, 97, 96, 97, 96, 78, 74, 75, 74, 75, 75, 75, 75, 75, 74,
75, 76, 75, 75, 75, 74, 75, 74, 75, 74, 77, 59, 51, 54, 51, 55, 53, 54, 53, 53,
53, 54, 53, 53, 53, 53, 53, 54, 53, 52, 53, 52, 56, 41, 28, 33, 30, 32, 31, 32,
31, 32, 32, 32, 32, 31, 31, 31, 32, 31, 32, 30, 33, 30, 34, 23, 8, 10, 9, 10, 9,
9, 10, 10, 9, 10, 9, 9, 9, 10, 10, 10, 8, 10, 9, 11, 8, -12, -12, -11, -12, -12,
-13, -11, -12, -11, -12, -11, -12, -11, -12, -12, -12, -12, -12, -12, -12, -12,
-11, -30, -35, -32, -34, -33, -34, -33, -34, -33, -33, -33, -34, -33, -33, -33,
-34, -33, -33, -34, -34, -34, -31, -48, -57, -53, -56, -54, -55, -54, -55, -54,
-56, -54, -55, -55, -55, -55, -55, -55, -55, -56, -55, -57, -52, -66, -79, -75,
-78, -76, -77, -76, -77, -76, -77, -77, -76, -77, -76, -77, -75, -77, -76, -77,
-76, -78, -74, -83, -100, -97, -99, -98, -98, -98, -98, -97, -98, -97, -98, -97,
-97, -97, -98, -98, -98, -97, -97, -97, -97, -119, -120, -118, -120, -119, -120,
-119, -119, -118, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -120, -120, -119, -118, -118, -120, -118, -119, -119, -119, -119, -119,
-118, -119, -117, -121, -112, -94, -98, -96, -97, -96, -96, -97, -97, -97, -96,
-97, -96, -98, -96, -97, -96, -97, -96, -97, -96, -98, -94, -75, -75, -75, -75,
-76, -75, -76, -75, -76, -74, -75, -74, -75, -74, -75, -75, -75, -74, -75, -74,
-76, -56, -51, -54, -53, -55, -52, -54, -52, -53, -53, -54, -53, -53, -52, -53,
-54, -53, -53, -52, -54, -52, -56, -39, -29, -33, -31, -32, -31, -32, -31, -31,
-32, -31, -31, -31, -31, -31, -31, -32, -31, -31, -31, -32, -31, -34, -18, -7,
-11, -9, -11, -9, -10, -9, -11, -10, -9, -10, -10, -10, -10, -11, -9, -10, -10,
-11, -8, };