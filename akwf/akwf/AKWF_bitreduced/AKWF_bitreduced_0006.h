#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {16, 21, 20, 20, 19, 20, 20, 20, 20,
19, 20, 19, 21, 17, 28, 42, 38, 41, 39, 41, 40, 40, 39, 40, 60, 59, 60, 60, 59,
60, 59, 61, 57, 73, 80, 79, 79, 79, 79, 81, 79, 82, 101, 99, 99, 100, 99, 99,
98, 100, 99, 100, 99, 99, 99, 100, 98, 100, 100, 99, 101, 89, 76, 81, 77, 59,
61, 49, 37, 41, 19, -6, -19, -30, -42, -55, -64, -77, -81, -77, -95, -101, -98,
-100, -97, -112, -121, -117, -120, -118, -121, -105, -98, -100, -98, -99, -99,
-99, -100, -98, -79, -80, -79, -80, -78, -81, -74, -57, -61, -57, -62, -55, -39,
-39, -41, -38, -42, -35, -18, -20, -20, -19, -21, -18, -23, -8, 2, 0, 0, 0, 0,
0, 0, 2, 19, 20, 19, 22, 18, 23, 38, 42, 38, 42, 37, 42, 58, 61, 57, 61, 58, 62,
78, 80, 79, 81, 78, 83, 100, 100, 99, 99, 99, 99, 100, 99, 99, 98, 100, 99, 100,
98, 100, 98, 82, 77, 83, 69, 59, 60, 41, 38, 10, 1, -13, -23, -38, -40, -43,
-73, -80, -79, -82, -100, -99, -99, -100, -98, -102, -120, -118, -119, -120,
-118, -120, -118, -122, -105, -98, -100, -99, -99, -99, -99, -100, -98, -101,
-91, -77, -81, -79, -80, -79, -80, -79, -80, -79, -60, -59, -59, -59, -60, -60,
-60, -60, -60, -60, -59, -41, -39, -40, -39, -40, -40, -41, -39, -41, -39, -40,
-39, -41, -39, -42, -28, -18, -20, -19, -21, -20, -20, -20, -21, -20, -20, -20,
-19, -20, -19, -20, -19, -20, -20, -20, -19, -20, -20, -20, -21, -18, -21, -14,
2, -1, 1, -1, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1,
0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, -1, 1, 0, -1, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 1, -1, 1, -1, 1, 0, 1, 0, 0, -1, 1,
-1, 2, -3, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -19, -20,
-19, -20, -20, -21, -19, -21, -20, -19, -19, -19, -19, -20, -20, -21, -20, -20,
-20, -20, -20, -20, -20, -20, -20, -20, -21, -20, -19, -20, -20, -21, -20, -20,
-20, -20, -20, -20, -20, -20, -20, -20, -20, -21, -20, -19, -19, -19, -20, -19,
-36, -41, -38, -41, -39, -41, -39, -41, -40, -39, -39, -40, -39, -40, -39, -40,
-39, -40, -39, -39, -40, -40, -40, -40, -40, -39, -40, -39, -40, -39, -40, -39,
-40, -39, -41, -38, -42, -34, -18, -21, -20, -20, -20, -20, -20, -20, -20, -20,
-20, -19, -19, -19, -20, -20, -20, -20, -19, -20, -20, -20, -20, -19, -21, -20,
-20, -20, -21, -19, -21, -19, -22, -16, 2, -1, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0,
-1, 0, 0, 0, };