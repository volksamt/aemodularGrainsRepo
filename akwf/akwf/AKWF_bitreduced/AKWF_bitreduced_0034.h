#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0034

const PROGMEM int8_t DATA[DATA_LENGTH] = {43, 112, 21, 86, 127, 56, 103, 42, 39,
42, 38, 42, 38, 42, 38, 42, 39, 41, 38, 41, 39, 41, 39, 41, 40, 41, 39, 40, 40,
40, 40, 39, 41, 40, 40, 39, 40, 40, 41, 40, 40, 40, 40, 40, 40, 39, 41, 41, 40,
41, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 39, 40, 40, 39, 39,
40, 39, 40, 41, 40, 40, 39, 39, 41, 40, 39, 40, 40, 39, 40, 41, 40, 40, 40, 39,
40, 39, 39, 40, 40, 39, 40, 40, 40, 40, 40, 39, 40, 39, 39, 40, 40, 40, 39, 40,
39, 41, 39, 40, 39, 40, 39, 41, 39, 40, 39, 41, 38, 41, 38, 41, 38, 41, 37, -35,
-42, -38, -41, -39, -42, -38, -41, -37, -41, -38, -40, -39, -40, -39, -40, -40,
-40, -39, -40, -39, -39, -40, -39, -39, -39, -40, -40, -39, -39, -40, -39, -39,
-39, -39, -38, -39, -38, -40, -39, -40, -40, -39, -39, -40, -39, -40, -39, -40,
-39, -39, -40, -39, -40, -39, -40, -38, -39, -39, -39, -39, -40, -39, -38, -39,
-39, -39, -39, -39, -40, -39, -39, -38, -39, -39, -39, -39, -39, -39, -39, -39,
-39, -39, -39, -39, -39, -38, -39, -39, -39, -39, -39, -38, -40, -38, -40, -39,
-40, -39, -39, -39, -39, -39, -39, -39, -39, -40, -39, -40, -38, -40, -37, -41,
-37, -41, -36, -42, -35, -45, -28, -100, -58, -34, -128, -64, -89, -66, -96,
-38, 55, 31, 48, 35, 44, 35, 44, 37, 42, 38, 42, 39, 40, 41, 41, 40, 40, 40, 40,
40, 39, 40, 39, 41, 40, 41, 39, 42, 39, 41, 40, 41, 40, 40, 39, 40, 40, 40, 41,
41, 40, 41, 40, 40, 40, 40, 40, 39, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40,
40, 40, 40, 40, 40, 41, 40, 40, 41, 40, 40, 40, 40, 40, 39, 40, 39, 40, 39, 41,
39, 40, 40, 40, 40, 40, 39, 39, 39, 40, 40, 39, 40, 40, 40, 40, 40, 40, 40, 40,
40, 40, 40, 40, 41, 40, 40, 40, 39, 40, 39, 40, 39, 41, 39, 40, 39, 41, 38, 41,
39, 40, 39, 40, 39, 40, 40, -34, -42, -37, -41, -38, -41, -37, -41, -38, -40,
-38, -41, -38, -40, -38, -40, -38, -40, -39, -40, -40, -40, -40, -40, -40, -39,
-40, -39, -40, -39, -39, -38, -40, -39, -39, -39, -40, -40, -40, -40, -40, -39,
-38, -39, -39, -40, -39, -40, -39, -40, -40, -39, -39, -39, -39, -39, -39, -39,
-39, -40, -40, -40, -39, -39, -39, -40, -39, -39, -39, -39, -39, -40, -39, -39,
-39, -39, -39, -40, -39, -39, -39, -39, -39, -39, -38, -39, -39, -40, -40, -40,
-39, -39, -39, -39, -40, -39, -39, -39, -39, -39, -39, -39, -39, -38, -39, -39,
-39, -39, -40, -39, -39, -39, -38, -39, -38, -39, -38, -39, -38, -39, -38, -40,
-38, -40, -37, -40, -36, -41, -33, };