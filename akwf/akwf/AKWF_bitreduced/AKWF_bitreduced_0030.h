#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {31, -59, 11, 127, 99, 115, 104, 111,
107, 110, 107, 110, 107, 110, 105, 116, 54, 25, 37, 28, 36, 30, 36, 31, 35, 30,
35, 32, 34, 32, 34, 32, 33, 32, 32, 33, 33, 32, 33, 32, 33, 32, 33, 33, 33, 33,
32, 33, 33, 32, 33, 33, 32, 32, 33, 33, 33, 32, 33, 33, 33, 32, 33, 33, 33, 33,
33, 32, 32, 32, 33, 33, 32, 32, 33, 33, 33, 33, 32, 33, 33, 33, 32, 32, 33, 33,
32, 33, 33, 32, 33, 33, 32, 32, 32, 32, 33, 32, 32, 33, 33, 33, 32, 32, 33, 33,
31, 32, 32, 32, 33, 32, 33, 32, 31, 32, 32, 33, 32, 32, 32, 32, 33, 32, 32, 32,
33, 32, 33, 32, 33, 31, 33, 31, 33, 32, 33, 32, 33, 33, 33, 32, 32, 33, 31, 34,
30, 35, 29, 36, 28, 38, 27, 37, 26, 38, 25, 39, 25, 39, 24, 41, 20, -22, 11,
-28, 61, -44, -25, 0, -7, -9, 1, -18, 13, -44, -22, 48, -21, 1, -9, -5, -6, -6,
-8, 53, -62, -7, -6, -3, -10, 3, -23, 37, 2, -58, 14, -16, 0, -8, -6, -4, -11,
-57, 53, -10, -5, -5, -6, -7, -2, -17, 45, -23, -47, 22, -34, 47, 23, 39, 26,
36, 29, 34, 31, 33, 31, 31, 33, 31, 33, 30, 34, 30, 35, 30, 34, 31, 34, 31, 33,
30, 33, 32, 33, 31, 33, 31, 33, 31, 32, 31, 33, 32, 33, 33, 32, 32, 31, 32, 33,
32, 32, 32, 32, 32, 32, 32, 32, 32, 31, 33, 31, 33, 30, 34, 29, 34, 29, 35, 30,
35, 29, 35, 29, 34, 29, 34, 31, 33, 32, 31, 34, 28, 39, 22, 50, -5, -4, -11, 3,
-20, 16, -51, -14, 43, -20, -1, -6, -9, -1, -13, 1, 45, -61, -7, -3, -8, -5, -4,
-12, 9, -60, 12, 30, -24, 4, -12, -2, -7, -10, 2, -33, -58, 7, -13, 0, -11, 1,
-20, 53, -36, -34, 9, -15, -1, -8, -10, 6, -39, -22, 13, -66, -29, -54, -36,
-50, -39, -47, -42, -44, -43, -43, -45, -43, -46, -43, -47, -41, -47, -41, -47,
-42, -45, -42, -46, -42, -45, -43, -45, -44, -45, -44, -44, -44, -43, -45, -44,
-44, -44, -44, -44, -45, -44, -44, -44, -43, -44, -44, -43, -44, -44, -45, -44,
-43, -44, -44, -44, -44, -44, -44, -44, -43, -44, -44, -44, -44, -44, -44, -44,
-43, -44, -44, -43, -43, -44, -44, -44, -44, -43, -44, -44, -43, -44, -44, -44,
-43, -44, -43, -43, -44, -44, -43, -43, -43, -43, -43, -43, -44, -44, -44, -44,
-43, -43, -44, -43, -44, -44, -43, -44, -45, -44, -44, -43, -44, -43, -43, -43,
-43, -44, -43, -44, -43, -43, -43, -44, -42, -44, -44, -44, -42, -44, -43, -44,
-43, -45, -42, -44, -43, -45, -43, -44, -43, -43, -44, -42, -46, -38, -104,
-124, -116, -120, -118, -119, -119, -118, -120, -117, -123, -114, -126, -102, };