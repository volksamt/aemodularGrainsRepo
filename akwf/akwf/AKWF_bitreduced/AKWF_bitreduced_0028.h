#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0028

const PROGMEM int8_t DATA[DATA_LENGTH] = {33, 40, 36, 39, 37, 39, 37, 38, 37,
39, 37, 38, 38, 39, 38, 38, 38, 38, 38, 39, 38, 38, 39, 38, 38, 39, 38, 39, 38,
38, 38, 39, 36, 39, 37, 40, 36, 40, 36, 41, 33, 49, 121, 118, 119, 119, 119,
120, 118, 119, 118, 119, 119, 119, 119, 119, 119, 118, 119, 118, 119, 118, 120,
118, 121, 118, 120, 117, 120, 116, 42, 35, 40, 36, 40, 35, 40, 36, 39, 36, 38,
37, 39, 37, 39, 37, 38, 38, 37, 37, 37, 37, 38, 37, 37, 37, 37, 37, 38, 37, 36,
38, 36, 38, 37, 38, 36, 38, 35, 39, 37, 40, 35, 39, 35, 40, 29, -44, -45, -43,
-45, -43, -45, -43, -45, -42, -45, -42, -45, -43, -45, -43, -44, -44, -44, -43,
-44, -44, -43, -44, -43, -44, -44, -44, -44, -44, -44, -44, -43, -44, -43, -44,
-44, -44, -44, -44, -44, -44, -43, -44, -44, -43, -43, -44, -44, -44, -44, -44,
-44, -44, -44, -44, -43, -44, -44, -43, -43, -44, -44, -44, -44, -44, -44, -43,
-44, -43, -43, -44, -43, -43, -44, -44, -44, -44, -43, -44, -43, -44, -44, -43,
-44, -43, -44, -43, -43, -43, -43, -44, -43, -44, -43, -43, -44, -43, -44, -43,
-43, -43, -43, -43, -43, -43, -43, -44, -44, -43, -43, -43, -43, -44, -43, -44,
-43, -44, -43, -43, -43, -44, -43, -43, -43, -42, -44, -41, -45, -41, -45, -41,
-47, -39, -51, -20, 46, 34, 40, 36, 39, 38, 38, 38, 37, 38, 38, 38, 38, 39, 37,
38, 37, 38, 37, 38, 38, 38, 38, 38, 38, 38, 38, 38, 37, 37, 39, 38, 38, 37, 38,
38, 38, 38, 38, 38, 37, 37, 37, 38, 38, 38, 39, 37, 38, 37, 39, 38, 37, 38, 38,
38, 38, 37, 38, 38, 38, 38, 38, 38, 37, 38, 38, 38, 39, 38, 38, 39, 37, 38, 37,
38, 38, 38, 37, 38, 38, 38, 38, 37, 38, 37, 38, 37, 37, 38, 38, 38, 37, 38, 37,
38, 37, 37, 38, 38, 38, 38, 38, 37, 38, 37, 38, 38, 38, 37, 38, 37, 37, 38, 38,
37, 37, 38, 37, 37, 37, 38, 36, 39, 35, 40, 32, 47, -3, -54, -38, -47, -41, -45,
-42, -44, -43, -44, -43, -43, -43, -43, -44, -43, -44, -43, -44, -43, -44, -44,
-44, -43, -44, -43, -44, -44, -44, -44, -44, -43, -44, -44, -43, -44, -44, -44,
-43, -43, -44, -43, -43, -43, -43, -44, -43, -44, -44, -44, -44, -43, -43, -43,
-44, -44, -44, -44, -43, -44, -44, -43, -43, -43, -43, -43, -44, -43, -43, -44,
-44, -43, -43, -43, -43, -43, -43, -43, -43, -43, -43, -44, -43, -44, -43, -44,
-43, -44, -44, -44, -43, -42, -44, -43, -43, -43, -44, -43, -43, -43, -43, -44,
-43, -44, -43, -43, -43, -43, -43, -43, -43, -43, -43, -43, -43, -43, -43, -42,
-43, -43, -44, -43, -44, -42, -44, -42, -44, -42, -44, -41, -46, -37, };