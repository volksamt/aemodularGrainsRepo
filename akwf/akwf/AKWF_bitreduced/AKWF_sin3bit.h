#define DATA_LENGTH 512
#define DATA AKWF_sin3bit

const PROGMEM int8_t DATA[DATA_LENGTH] = {35, 43, 39, 41, 40, 41, 39, 41, 39,
41, 40, 40, 40, 40, 41, 41, 41, 41, 41, 41, 40, 40, 40, 41, 40, 40, 41, 40, 40,
40, 40, 40, 40, 41, 40, 39, 41, 40, 41, 40, 41, 39, 40, 40, 41, 40, 40, 40, 40,
40, 40, 41, 40, 40, 40, 41, 39, 41, 40, 41, 40, 41, 40, 41, 40, 40, 41, 41, 39,
40, 39, 40, 41, 40, 41, 40, 41, 39, 41, 38, 42, 37, 45, 30, 78, 127, 114, 122,
117, 121, 118, 119, 118, 119, 118, 118, 118, 118, 119, 119, 118, 118, 119, 118,
119, 118, 120, 119, 120, 118, 118, 118, 119, 118, 119, 119, 118, 117, 119, 118,
119, 119, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 119, 117, 118,
118, 119, 118, 118, 117, 118, 119, 118, 118, 118, 118, 118, 119, 118, 118, 118,
118, 117, 118, 117, 118, 117, 119, 117, 118, 118, 118, 117, 117, 118, 117, 118,
116, 120, 113, 127, 68, 30, 44, 36, 42, 36, 40, 38, 40, 38, 39, 38, 39, 39, 39,
39, 38, 39, 39, 39, 38, 39, 38, 38, 38, 38, 38, 40, 37, 39, 38, 39, 38, 39, 38,
38, 38, 38, 38, 39, 38, 38, 39, 38, 38, 38, 38, 38, 39, 38, 39, 38, 39, 38, 39,
37, 39, 38, 38, 38, 39, 38, 39, 38, 38, 38, 38, 39, 39, 39, 38, 39, 38, 39, 37,
39, 36, 39, 37, 40, 36, 41, 35, 43, 24, -45, -39, -41, -40, -40, -42, -40, -41,
-39, -42, -40, -41, -40, -41, -41, -42, -40, -41, -40, -41, -40, -40, -40, -41,
-40, -40, -41, -41, -41, -40, -40, -40, -41, -41, -41, -41, -40, -40, -41, -40,
-41, -40, -41, -41, -41, -40, -41, -40, -40, -40, -40, -40, -40, -40, -41, -40,
-41, -40, -41, -40, -41, -40, -41, -40, -41, -39, -40, -41, -40, -40, -40, -40,
-41, -41, -40, -41, -39, -41, -40, -42, -38, -45, -31, -82, -125, -115, -121,
-117, -121, -118, -120, -118, -120, -118, -119, -118, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -118, -120, -118, -119, -119, -118, -119,
-119, -119, -119, -119, -118, -118, -119, -118, -119, -118, -118, -119, -118,
-119, -119, -119, -118, -119, -118, -119, -119, -118, -118, -118, -118, -119,
-117, -119, -118, -118, -118, -119, -119, -118, -118, -118, -119, -118, -119,
-118, -119, -118, -119, -118, -119, -117, -119, -118, -118, -118, -119, -117,
-118, -118, -118, -120, -114, -126, -60, -32, -43, -36, -42, -37, -41, -38, -40,
-38, -39, -38, -39, -38, -39, -39, -39, -38, -39, -39, -40, -39, -38, -39, -38,
-39, -38, -39, -38, -39, -39, -40, -38, -39, -38, -39, -39, -39, -39, -39, -38,
-38, -39, -39, -39, -39, -39, -39, -39, -39, -39, -39, -40, -38, -39, -39, -39,
-39, -39, -39, -39, -39, -39, -38, -39, -39, -38, -39, -39, -38, -39, -38, -40,
-38, -39, -37, -40, -38, -39, -37, -40, -37, -41, -33, };