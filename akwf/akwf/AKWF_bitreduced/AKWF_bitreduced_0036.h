#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0036

const PROGMEM int8_t DATA[DATA_LENGTH] = {47, 55, 52, 55, 51, 55, 53, 55, 53,
55, 53, 54, 54, 55, 53, 54, 54, 53, 54, 54, 53, 53, 53, 53, 54, 53, 54, 54, 53,
54, 53, 53, 54, 53, 54, 53, 54, 54, 54, 54, 54, 53, 54, 53, 53, 53, 53, 53, 53,
53, 53, 53, 53, 53, 53, 53, 54, 53, 53, 53, 53, 53, 54, 54, 52, 53, 53, 53, 53,
53, 53, 54, 53, 54, 53, 54, 53, 53, 54, 53, 53, 53, 53, 53, 53, 53, 53, 53, 53,
52, 54, 53, 54, 53, 53, 53, 53, 54, 52, 54, 53, 52, 53, 53, 53, 53, 53, 53, 53,
53, 53, 53, 53, 53, 53, 53, 53, 53, 53, 53, 53, 53, 53, 53, 53, 53, 52, 53, 53,
53, 53, 53, 52, 53, 53, 52, 53, 53, 53, 53, 53, 53, 53, 53, 53, 53, 52, 53, 52,
53, 52, 52, 53, 53, 53, 53, 52, 53, 53, 53, 53, 53, 53, 53, 52, 52, 52, 53, 53,
53, 52, 53, 53, 52, 53, 52, 52, 52, 52, 53, 53, 52, 53, 53, 53, 52, 53, 52, 52,
53, 52, 53, 52, 52, 53, 53, 53, 51, 53, 53, 52, 53, 53, 52, 52, 52, 52, 52, 53,
53, 53, 53, 53, 52, 52, 52, 51, 52, 53, 52, 53, 53, 52, 52, 52, 52, 52, 52, 52,
53, 52, 52, 52, 52, 52, 52, 52, 52, 52, 52, 53, 52, 53, 51, 53, 51, 53, 51, 53,
51, 53, 51, 53, 49, 54, 47, -32, -35, -34, -35, -33, -35, -32, -35, -33, -35,
-33, -35, -33, -35, -33, -34, -33, -34, -33, -34, -34, -34, -34, -34, -33, -34,
-34, -34, -34, -34, -33, -34, -34, -34, -35, -34, -33, -33, -34, -34, -35, -33,
-34, -34, -34, -34, -34, -34, -34, -33, -34, -34, -34, -34, -34, -33, -33, -33,
-35, -34, -34, -34, -34, -33, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34,
-34, -34, -33, -33, -34, -33, -34, -34, -34, -34, -34, -33, -34, -33, -34, -34,
-33, -33, -34, -34, -34, -34, -34, -33, -33, -34, -34, -34, -33, -34, -34, -34,
-34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -33, -34, -33, -33, -34, -33,
-34, -34, -34, -33, -33, -33, -34, -34, -33, -33, -34, -34, -33, -34, -33, -33,
-34, -34, -33, -34, -34, -33, -33, -33, -34, -34, -33, -34, -33, -33, -33, -33,
-33, -33, -33, -33, -33, -34, -33, -34, -33, -32, -35, -32, -35, -32, -35, -31,
-35, -30, -37, -28, -49, -124, -117, -119, -119, -119, -120, -118, -119, -118,
-120, -118, -119, -118, -120, -118, -120, -119, -120, -119, -119, -119, -119,
-119, -119, -118, -118, -118, -119, -118, -119, -119, -118, -119, -118, -119,
-119, -119, -118, -120, -118, -119, -118, -119, -118, -119, -119, -118, -119,
-118, -120, -118, -120, -117, -120, -116, -122, -113, -127, -92, -24, -37, -30,
-34, -32, -33, -33, -32, -33, -32, -33, -31, -34, -31, -34, -31, -34, -31, -34,
-31, -35, -28, };