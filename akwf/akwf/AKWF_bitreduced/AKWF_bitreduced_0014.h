#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {-35, -41, -38, -40, -39, -41, -39,
-40, -39, -40, -39, -40, -39, -40, -39, -41, -39, -40, -40, -39, -40, -39, -40,
-39, -40, -39, -40, -40, -40, -40, -40, -39, -39, -39, -40, -40, -40, -39, -40,
-40, -39, -40, -39, -40, -40, -39, -39, -39, -40, -39, -39, -40, -39, -40, -39,
-39, -39, -39, -39, -40, -40, -39, -40, -40, -39, -40, -40, -39, -40, -40, -40,
-39, -39, -39, -40, -40, -40, -40, -39, -40, -39, -40, -39, -40, -40, -39, -39,
-39, -41, -40, -40, -40, -40, -41, -40, -40, -39, -39, -40, -40, -40, -39, -39,
-39, -40, -39, -39, -39, -41, -40, -39, -40, -40, -39, -39, -40, -40, -39, -40,
-39, -40, -40, -40, -40, -40, -40, -39, -40, -41, -40, -40, -40, -40, -40, -39,
-39, -40, -39, -39, -40, -40, -40, -40, -40, -40, -40, -40, -40, -39, -40, -39,
-40, -39, -40, -40, -39, -39, -40, -41, -39, -40, -40, -40, -39, -40, -40, -40,
-40, -40, -39, -40, -39, -40, -40, -3, 1, -1, 1, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0,
0, 1, -1, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1,
-1, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 1, -1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0,
0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, -1, 0, 1, -1, -1, 0, -1, 0, -1,
0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 1,
0, 0, 0, 0, 1, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0,
-1, -1, 1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, -1, 0, -1, -1, 0, -1, 0, 1, 1, 0, 1,
0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, -1, 0, 0, -1, 0, -1, 0, -1, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, -1, 1, -1, 0, 0, 1, 0, 0, 0,
0, -1, 0, 0, -2, 1, -1, 2, -3, 4, -4, 6, -9, 15, -56, -128, -112, -121, -76,
-83, -76, -81, -77, -83, -71, -37, -41, -39, -40, -39, -39, -39, -39, -41, -37,
-43, -29, 4, -2, 1, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
1, 0, 1, 0, 0, -1, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0,
0, 0, 1, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0,
0, 0, -1, 0, 0, 0, 0, 1, 1, 0, 0, 0, -1, };