#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {34, 22, 30, 27, 26, 30, 79, 102, 59,
56, 59, 57, 59, 57, 58, 58, 57, 58, 58, 58, 57, 57, 58, 57, 59, 56, 60, 56, 60,
54, 64, 36, -11, 0, -6, -1, -5, -2, -3, -4, -4, -3, -3, -4, -3, -4, -3, -4, -3,
-4, -3, -4, -4, -4, -3, -4, -4, -5, -4, -4, -3, -3, -4, -4, -4, -4, -5, -4, -3,
-4, -4, -4, -3, -4, -3, -4, -4, -4, -4, -4, -4, -3, -4, -5, -4, -4, -4, -3, -4,
-3, -3, -4, -4, -4, -4, -4, -3, -4, -4, -5, -4, -4, -3, -4, -4, -3, -3, -4, -4,
-3, -3, -4, -3, -3, -4, -4, -4, -4, -4, -4, -4, -3, -4, -4, -4, -3, -4, -3, -4,
-3, -4, -3, -3, -4, -3, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -3,
-3, -4, -3, -3, -4, -3, -4, -4, -3, -4, -3, -3, -4, -4, -4, -3, -4, -4, -4, -4,
-4, -3, -3, -4, -4, -4, -4, -3, -4, -3, -4, -4, -3, -3, -4, -4, -3, -4, -3, -3,
-4, -4, -4, -4, -3, -4, -3, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -3,
-3, -4, -3, -4, -3, -4, -4, -3, -3, -4, -4, -4, -4, -3, -4, -4, -4, -4, -3, -4,
-4, -4, -3, -4, -4, -4, -3, -4, -4, -3, -4, -4, -3, -4, -3, -4, -3, -4, -4, -4,
-4, -4, -4, -4, -4, -4, -4, -3, -4, -4, -3, -3, -4, -3, -4, -4, -3, -3, -4, -4,
-4, -4, -3, -3, -3, -3, -3, -4, -3, -4, -4, -4, -4, -4, -4, -4, -3, -3, -4, -3,
-4, -4, -3, -4, -3, -4, -4, -4, -3, -3, -3, -4, -3, -4, -4, -4, -4, -4, -3, -3,
-3, -4, -4, -3, -4, -4, -4, -4, -3, -3, -4, -3, -4, -4, -4, -4, -3, -4, -4, -3,
-4, -4, -4, -4, -4, -4, -3, -3, -4, -4, -3, -3, -3, -3, -3, -3, -4, -3, -4, -4,
-4, -4, -4, -4, -3, -4, -3, -4, -4, -4, -3, -4, -3, -4, -4, -4, -3, -3, -4, -4,
-4, -4, -4, -3, -4, -4, -3, -4, -4, -3, -3, -3, -3, -3, -4, -3, -4, -3, -4, -4,
-3, -4, -3, -3, -3, -3, -3, -3, -3, -4, -3, -3, -3, -4, -3, -3, -4, -4, -3, -4,
-3, -3, -3, -4, -3, -3, -4, -3, -4, -4, -4, -3, -4, -3, -3, -3, -3, -3, -3, -4,
-3, -4, -4, -4, -3, -3, -4, -3, -3, -3, -4, -4, -4, -3, -4, -3, -3, -4, -4, -4,
-4, -4, -3, -4, -4, -4, -3, -3, -4, -4, -3, -4, -3, -3, -4, -4, -4, -4, -3, -4,
-3, -4, -3, -3, -4, -4, -3, -4, -4, -4, -3, -3, -4, -4, -3, -3, -3, -3, -4, -3,
-3, -3, -4, -3, -3, -4, -3, -3, -4, -3, -4, -4, -4, -3, -3, -3, -3, -4, -3, -4,
-3, -3, -4, };