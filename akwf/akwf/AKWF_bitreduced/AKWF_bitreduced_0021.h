#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {22, 26, 24, 27, 24, 26, 24, 26, 25,
25, 25, 24, 25, 24, 25, 24, 27, 23, 27, 19, 45, 78, 69, 74, 71, 73, 72, 72, 73,
72, 72, 71, 72, 71, 73, 72, 73, 71, 73, 71, 72, 71, 73, 71, 73, 71, 75, 114,
121, 118, 119, 118, 119, 118, 119, 119, 120, 118, 119, 118, 120, 119, 119, 119,
119, 119, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119, 118,
119, 118, 118, 118, 118, 118, 119, 118, 119, 119, 119, 118, 118, 118, 119, 118,
118, 119, 118, 118, 118, 118, 119, 118, 118, 119, 118, 118, 118, 119, 118, 118,
118, 118, 118, 119, 118, 119, 119, 118, 119, 119, 118, 118, 117, 118, 118, 118,
118, 118, 118, 118, 117, 117, 117, 118, 117, 118, 118, 118, 118, 117, 117, 118,
117, 118, 118, 118, 117, 118, 117, 118, 118, 118, 117, 117, 118, 117, 118, 118,
118, 117, 117, 117, 118, 116, 118, 117, 117, 116, 118, 116, 119, 117, 118, 117,
118, 117, 117, 116, 74, 67, 71, 69, 71, 68, 71, 69, 70, 69, 70, 69, 70, 69, 71,
69, 71, 70, 71, 69, 70, 69, 70, 70, 70, 70, 68, 73, 32, 19, 25, 21, 24, 22, 23,
21, 23, 22, 23, 23, 23, 23, 22, 22, 23, 23, 23, 22, 23, 22, 23, 23, 22, 22, 22,
23, 22, 23, 23, 23, 21, 24, 22, 24, 19, 27, 2, -30, -23, -27, -24, -25, -25,
-24, -25, -24, -25, -25, -25, -25, -25, -24, -26, -25, -26, -25, -24, -25, -25,
-24, -26, -25, -25, -24, -25, -25, -26, -25, -25, -25, -25, -25, -24, -25, -25,
-25, -25, -25, -25, -24, -25, -24, -25, -24, -25, -24, -25, -24, -25, -23, -26,
-24, -25, -25, -25, -25, -22, -66, -74, -70, -73, -71, -72, -71, -72, -71, -72,
-71, -72, -72, -72, -71, -71, -71, -72, -71, -72, -71, -72, -72, -72, -71, -72,
-71, -72, -71, -72, -71, -73, -70, -72, -70, -74, -118, -119, -117, -119, -118,
-119, -118, -119, -118, -119, -118, -119, -118, -119, -118, -119, -118, -119,
-118, -118, -117, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118,
-118, -118, -118, -118, -118, -119, -118, -118, -118, -118, -118, -118, -118,
-119, -117, -118, -118, -118, -118, -118, -118, -117, -118, -117, -118, -119,
-118, -118, -117, -118, -118, -118, -118, -117, -118, -118, -118, -117, -118,
-118, -117, -118, -117, -118, -118, -117, -117, -118, -117, -118, -117, -118,
-117, -117, -117, -117, -117, -118, -117, -117, -117, -117, -118, -118, -116,
-117, -117, -117, -118, -117, -118, -116, -117, -116, -117, -117, -117, -116,
-117, -117, -117, -117, -117, -117, -117, -117, -116, -117, -117, -117, -116,
-117, -115, -122, -89, -66, -72, -67, -71, -68, -71, -70, -71, -69, -70, -69,
-70, -69, -70, -69, -70, -69, -70, -69, -70, -69, -71, -68, -70, -66, -22, -22,
-23, -22, -23, -22, -23, -21, -23, -21, -24, -22, -23, -21, -24, -21, -24, -19,
};