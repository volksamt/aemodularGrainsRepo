#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {21, 24, 23, 24, 23, 25, 23, 25, 23,
24, 23, 24, 23, 24, 23, 23, 24, 24, 23, 23, 24, 23, 24, 24, 24, 24, 24, 24, 24,
23, 24, 24, 24, 24, 24, 24, 24, 24, 24, 23, 24, 23, 24, 24, 24, 24, 24, 24, 23,
24, 23, 24, 24, 23, 23, 24, 23, 24, 23, 23, 24, 24, 24, 24, 23, 24, 23, 24, 24,
23, 24, 24, 23, 24, 23, 23, 24, 24, 24, 24, 23, 23, 23, 23, 23, 24, 23, 24, 23,
23, 23, 24, 24, 23, 23, 23, 23, 24, 24, 23, 24, 23, 24, 23, 24, 23, 24, 24, 23,
23, 23, 23, 23, 24, 24, 23, 23, 23, 24, 24, 24, 23, 23, 24, 23, 23, 23, 23, 24,
24, 23, 23, 24, 24, 23, 23, 23, 24, 24, 24, 23, 23, 23, 23, 23, 23, 24, 24, 24,
23, 24, 23, 23, 22, 23, 23, 23, 24, 24, 23, 24, 23, 23, 24, 24, 23, 24, 23, 23,
24, 23, 24, 24, 23, 23, 23, 24, 23, 24, 23, 23, 24, 24, 23, 23, 23, 23, 23, 23,
24, 24, 23, 23, 24, 24, 23, 23, 24, 24, 24, 23, 23, 23, 23, 23, 23, 23, 23, 23,
24, 23, 22, 24, 23, 22, 22, 24, 23, 23, 23, 23, 24, 23, 23, 23, 23, 23, 23, 22,
23, 24, 24, 23, 23, 23, 23, 23, 23, 22, 23, 23, 23, 23, 23, 22, 22, 23, 23, 23,
23, 23, 23, 23, 23, 22, 23, 23, 23, 23, 23, 23, 23, 23, 23, 23, 23, 24, 23, 23,
22, 23, 23, 23, 23, 23, 23, 22, 23, 23, 23, 22, 23, 22, 24, 20, 27, 8, -29, -22,
-26, -25, -23, -27, -18, -56, -76, -70, -73, -71, -71, -73, -71, -75, -66, -91,
-125, -117, -120, -118, -119, -120, -119, -119, -119, -120, -118, -120, -118,
-120, -119, -120, -118, -119, -119, -119, -118, -119, -119, -118, -122, -80,
-68, -74, -69, -73, -69, -74, -69, -73, -69, -73, -69, -76, -63, -22, -25, -24,
-24, -25, -22, -25, -23, -25, -23, -26, -23, -25, -23, -25, -23, 20, 25, 22, 25,
22, 23, 23, 24, 23, 24, 23, 24, 23, 24, 22, 23, 24, 23, 24, 23, 23, 24, 24, 24,
23, 23, 23, 23, 24, 23, 23, 24, 23, 24, 23, 23, 23, 24, 22, 24, 22, 25, 22, 24,
22, 26, 19, -23, -24, -23, -25, -23, -24, -23, -24, -23, -25, -24, -25, -23,
-24, -23, -24, -24, -24, -24, -24, -24, -24, -24, -24, -24, -24, -24, -25, -24,
-24, -24, -24, -24, -24, -24, -24, -23, -24, -24, -23, -24, -24, -24, -24, -24,
-23, -24, -24, -24, -23, -24, -24, -25, -24, -24, -24, -25, -24, -23, -23, -23,
-24, -23, -24, -24, -24, -24, -24, -25, -25, -24, -25, -25, -23, -24, -24, -24,
-23, -25, -24, -25, -24, -24, -24, -24, -24, -24, -24, -23, -24, -24, -24, -23,
-24, -24, -24, -23, -24, -23, -24, -23, -24, -23, -24, -20, };