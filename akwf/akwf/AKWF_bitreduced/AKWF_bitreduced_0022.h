#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {52, 62, 58, 61, 58, 60, 58, 60, 59,
60, 59, 60, 59, 60, 59, 60, 59, 60, 59, 59, 59, 59, 60, 60, 60, 59, 59, 59, 59,
59, 59, 59, 59, 59, 60, 60, 60, 60, 60, 59, 60, 60, 59, 59, 59, 60, 59, 60, 59,
60, 59, 59, 59, 60, 59, 60, 60, 59, 59, 59, 59, 60, 60, 60, 60, 59, 59, 60, 59,
60, 60, 60, 59, 60, 59, 60, 59, 60, 58, 60, 59, 60, 59, 60, 59, 60, 59, 60, 59,
60, 59, 59, 59, 59, 60, 59, 60, 59, 61, 58, 61, 58, 61, 57, 61, 58, 61, 58, 62,
58, 62, 57, 61, 59, 60, 62, -102, -127, -113, -124, -115, -123, -116, -122,
-116, -121, -118, -121, -118, -121, -118, -120, -118, -119, -119, -120, -119,
-119, -120, -118, -119, -118, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -118,
-119, -118, -119, -119, -119, -119, -120, -119, -119, -118, -118, -119, -119,
-119, -119, -119, -119, -119, -118, -120, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -118, -119, -118, -120, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -120, -119, -118, -119, -119,
-119, -117, -124, -74, -55, -63, -57, -62, -58, -61, -59, -61, -59, -60, -59,
-60, -59, -60, -60, -59, -59, -60, -60, -60, -60, -59, -60, -59, -60, -59, -60,
-59, -59, -59, -60, -60, -59, -61, -58, -60, -58, -60, -58, -61, -58, -5, 3, -3,
3, -3, 3, -3, 4, -5, 6, -7, 9, -23, -126, -116, -120, -120, -118, -120, -118,
-120, -118, -120, -117, -120, -117, -121, -118, -121, -118, -120, -118, -119,
-119, -120, -119, -119, -118, -120, -119, -118, -120, -119, -120, -119, -120,
-118, -120, -118, -120, -117, -122, -115, -126, -97, -53, -63, -57, -60, -59,
-60, -59, -59, -59, -60, -60, -59, -61, -59, -59, -59, -59, -59, -60, -59, -60,
-60, -60, -59, -60, -59, -59, -60, -59, -60, -60, -61, -59, -61, -58, -60, -59,
-60, -59, -60, -59, -59, -61, -7, 3, -2, 2, -1, 1, -1, 1, -2, 1, -1, 0, -1, 0,
0, 0, 1, 0, 0, 0, 0, -1, 0, -1, 1, 0, 1, -1, 0, 0, 0, 0, -1, 0, 0, 1, -1, 1, -1,
1, -2, 4, -6, 22, 67, 56, 61, 58, 61, 60, 59, 59, 59, 60, 60, 60, 60, 60, 59,
60, 59, 60, 59, 61, 59, 61, 59, 61, 59, 60, 59, 61, 58, 60, 59, 60, 60, 59, 60,
59, 61, 57, 63, 53, 73, -11, -73, -52, -66, -55, -62, -57, -61, -58, -60, -60,
-58, -64, -13, 4, -3, 3, -2, 1, -1, 1, 0, 0, 0, 1, -1, -1, 0, 0, 1, 0, -1, 0, 1,
-1, 0, 0, 0, -1, 0, 0, 1, -1, 0, 0, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 0, };