#define DATA_LENGTH 512
#define DATA AKWF_bitreduced_0032

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, -69, -6, 90, 74, 28, 4, 16, 7, 15,
8, 14, 10, 13, 9, 14, 10, 14, 9, 14, 10, 14, 8, 15, 8, 16, 7, 15, 7, 17, 6, 16,
7, 16, 5, -38, -5, -43, 36, -50, -41, -15, -22, -23, -16, -30, -6, -50, -42, 27,
-34, -17, -23, -21, -20, -21, -24, 29, -64, -29, -17, -23, -21, -18, -28, -7,
-63, -17, 18, -37, -11, -27, -17, -22, -20, -71, 30, -23, -21, -21, -22, -23,
-17, -32, 21, -29, -62, 6, -47, 23, 5, 17, 7, 14, 10, 13, 11, 12, 12, 11, 13,
10, 13, 9, 13, 10, 14, 10, 14, 10, 13, 10, 13, 11, 13, 12, 12, 11, 12, 11, 11,
12, 11, 12, 11, 12, 12, 11, 11, 11, 11, 12, 11, 11, 12, 11, 12, 11, 11, 12, 11,
12, 12, 11, 11, 12, 12, 12, 12, 12, 11, 12, 12, 12, 12, 11, 12, 11, 12, 12, 12,
12, 11, 12, 12, 11, 11, 12, 12, 11, 11, 11, 12, 11, 11, 11, 11, 12, 11, 12, 12,
11, 11, 11, 12, 11, 11, 12, 11, 11, 11, 11, 12, 12, 11, 12, 11, 12, 11, 11, 12,
11, 11, 12, 11, 12, 12, 11, 11, 12, 11, 11, 12, 11, 11, 11, 12, 11, 12, 11, 11,
11, 11, 11, 11, 12, 12, 11, 11, 12, 11, 11, 11, 12, 11, 12, 11, 11, 11, 12, 11,
11, 12, 12, 11, 12, 11, 12, 12, 11, 11, 11, 11, 11, 11, 12, 11, 11, 12, 12, 12,
12, 11, 11, 11, 12, 12, 11, 11, 12, 12, 12, 11, 10, 11, 12, 12, 12, 12, 12, 11,
11, 11, 12, 12, 11, 12, 12, 11, 11, 11, 12, 12, 12, 11, 11, 11, 12, 11, 11, 12,
12, 12, 12, 11, 12, 11, 12, 11, 12, 11, 11, 11, 11, 11, 11, 11, 11, 10, 11, 11,
11, 11, 11, 11, 12, 11, 11, 11, 11, 11, 11, 11, 11, 11, 11, 11, 11, 12, 11, 11,
11, 12, 11, 12, 11, 11, 12, 12, 11, 11, 12, 10, 11, 11, 11, 11, 11, 12, 11, 11,
11, 12, 10, 11, 11, 11, 11, 11, 12, 11, 10, 11, 11, 11, 11, 11, 12, 12, 11, 12,
12, 11, 11, 12, 10, 12, 11, 12, 11, 11, 10, 11, 11, 11, 10, 12, 11, 11, 10, 12,
11, 12, 11, 11, 12, 11, 12, 10, 12, 10, 12, 9, 14, 8, 14, 8, 14, 9, 14, 9, 13,
10, 10, -51, -62, -20, -21, -23, -21, -18, -27, -9, -74, 11, -4, -29, -19, -21,
-26, -13, -37, 11, -8, -68, -6, -29, -17, -24, -20, -23, -18, -77, -26, -20,
-20, -24, -17, -31, -6, -61, -26, 21, -37, -13, -25, -21, -19, -26, -13, 20,
-71, -19, -20, -25, -19, -24, -19, -19, -56, -57, -49, -59, -48, -59, -50, -58,
-50, -58, -52, -56, -51, -56, -53, -55, -53, -55, -54, -55, -53, -55, -53, -56,
-52, -57, -50, -60, -44, -94, -122, -122, -105, };