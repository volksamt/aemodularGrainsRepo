#define DATA_LENGTH 512
#define DATA AKWF_epiano_0039

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 12, 18, 24, 30, 37, 43, 49, 55,
61, 66, 72, 76, 82, 86, 91, 94, 96, 100, 103, 106, 107, 110, 112, 113, 114, 116,
116, 118, 118, 118, 118, 119, 119, 118, 118, 119, 119, 118, 118, 117, 117, 117,
116, 115, 114, 114, 113, 112, 111, 110, 110, 108, 108, 106, 105, 104, 103, 102,
100, 99, 98, 97, 95, 93, 93, 92, 90, 88, 87, 85, 84, 82, 80, 79, 78, 77, 75, 73,
71, 69, 67, 66, 64, 63, 61, 59, 58, 56, 54, 54, 51, 50, 48, 46, 45, 43, 41, 39,
37, 37, 35, 33, 31, 30, 28, 27, 25, 23, 21, 21, 19, 18, 16, 15, 12, 11, 10, 8,
7, 6, 5, 2, 1, 0, -1, -3, -4, -5, -7, -8, -9, -11, -11, -12, -14, -15, -16, -17,
-18, -19, -20, -20, -21, -22, -23, -23, -25, -26, -26, -26, -28, -27, -28, -29,
-29, -30, -30, -31, -31, -32, -32, -33, -32, -32, -32, -32, -32, -32, -31, -31,
-31, -30, -30, -27, -28, -25, -26, -24, -24, -23, -22, -21, -20, -19, -20, -19,
-18, -19, -18, -17, -17, -17, -16, -17, -16, -16, -17, -16, -16, -16, -16, -16,
-17, -16, -16, -16, -15, -17, -16, -16, -15, -15, -16, -16, -15, -16, -15, -16,
-14, -14, -15, -15, -14, -14, -14, -13, -14, -13, -14, -12, -12, -13, -13, -12,
-11, -11, -11, -12, -11, -10, -10, -10, -9, -9, -9, -9, -10, -8, -9, -9, -9, -8,
-9, -8, -8, -8, -8, -8, -8, -8, -8, -10, -9, -10, -9, -10, -10, -10, -10, -11,
-11, -12, -11, -12, -13, -13, -14, -14, -15, -15, -15, -16, -17, -18, -18, -19,
-18, -19, -20, -20, -22, -21, -23, -22, -24, -24, -25, -26, -26, -27, -28, -28,
-28, -30, -29, -30, -31, -31, -32, -33, -33, -33, -34, -35, -36, -36, -37, -38,
-38, -38, -40, -39, -41, -41, -41, -41, -42, -42, -42, -42, -42, -42, -42, -42,
-41, -41, -41, -39, -38, -36, -34, -34, -31, -28, -26, -23, -21, -18, -16, -13,
-11, -7, -5, -3, 0, 2, 4, 6, 7, 9, 10, 11, 12, 14, 15, 16, 15, 17, 17, 16, 16,
16, 17, 16, 17, 16, 15, 15, 15, 15, 14, 13, 14, 12, 11, 11, 9, 9, 8, 7, 6, 4, 3,
2, 1, 0, -1, -3, -4, -6, -7, -8, -9, -11, -12, -14, -14, -16, -18, -19, -21,
-21, -24, -25, -26, -28, -29, -31, -32, -33, -34, -35, -36, -38, -39, -40, -42,
-42, -44, -44, -46, -47, -47, -47, -49, -49, -50, -51, -51, -53, -52, -52, -54,
-53, -54, -55, -55, -54, -56, -55, -56, -55, -55, -56, -56, -56, -56, -56, -55,
-56, -56, -56, -55, -56, -56, -56, -56, -55, -54, -55, -55, -55, -54, -53, -53,
-54, -53, -53, -52, -52, -52, -52, -51, -51, -50, -50, -49, -49, -48, -48, -47,
-47, -46, -46, -45, -44, -42, -41, -40, -38, -36, -33, -31, -28, -25, -21, -18,
-13, -8, -4, };