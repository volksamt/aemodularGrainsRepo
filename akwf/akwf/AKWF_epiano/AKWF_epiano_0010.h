#define DATA_LENGTH 512
#define DATA AKWF_epiano_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 5, 8, 8, 10, 12, 13, 16, 18,
20, 22, 24, 26, 28, 29, 31, 34, 35, 37, 41, 43, 45, 47, 50, 52, 54, 56, 58, 61,
62, 65, 67, 69, 71, 73, 76, 77, 80, 81, 84, 86, 87, 89, 91, 93, 95, 96, 97, 100,
101, 102, 104, 105, 106, 108, 110, 110, 111, 112, 112, 114, 114, 115, 115, 117,
117, 118, 118, 117, 118, 119, 119, 119, 119, 118, 119, 118, 119, 119, 118, 117,
118, 117, 117, 117, 116, 116, 115, 114, 114, 112, 112, 111, 110, 109, 108, 108,
106, 106, 104, 103, 102, 101, 100, 98, 98, 97, 96, 94, 93, 91, 91, 89, 87, 86,
85, 83, 83, 81, 79, 78, 77, 75, 74, 73, 71, 69, 68, 67, 64, 64, 62, 60, 59, 57,
56, 54, 52, 52, 50, 49, 46, 45, 43, 42, 40, 39, 38, 36, 35, 34, 32, 30, 28, 27,
26, 24, 22, 21, 20, 19, 17, 14, 14, 12, 10, 9, 8, 6, 4, 4, 1, 0, -1, -3, -5, -6,
-7, -8, -10, -12, -13, -15, -15, -17, -18, -20, -22, -23, -24, -25, -27, -28,
-29, -31, -32, -33, -36, -36, -38, -40, -40, -42, -43, -44, -46, -46, -48, -50,
-51, -51, -54, -54, -54, -57, -58, -59, -60, -61, -63, -64, -64, -66, -67, -68,
-69, -70, -71, -73, -75, -75, -75, -77, -78, -79, -79, -82, -82, -83, -84, -86,
-87, -87, -88, -89, -90, -90, -92, -93, -94, -95, -95, -96, -97, -98, -99, -99,
-101, -101, -101, -102, -102, -103, -103, -105, -106, -106, -107, -108, -108,
-109, -109, -109, -110, -110, -111, -111, -111, -112, -111, -112, -112, -113,
-113, -113, -113, -113, -113, -112, -114, -113, -113, -112, -113, -111, -112,
-112, -111, -110, -110, -110, -110, -109, -108, -107, -107, -107, -106, -104,
-104, -103, -102, -101, -99, -98, -98, -96, -94, -93, -92, -90, -89, -87, -86,
-84, -83, -81, -79, -77, -75, -73, -72, -69, -67, -65, -63, -61, -59, -56, -55,
-52, -50, -48, -45, -44, -41, -38, -36, -33, -32, -30, -28, -25, -22, -20, -18,
-15, -14, -11, -9, -7, -5, -2, -1, 1, 1, 2, 3, 5, 8, 10, 12, 13, 15, 17, 17, 20,
21, 23, 25, 26, 26, 27, 29, 30, 31, 31, 32, 33, 34, 35, 35, 37, 37, 37, 37, 37,
37, 39, 39, 38, 38, 38, 38, 39, 38, 37, 37, 37, 37, 36, 35, 35, 35, 34, 33, 32,
32, 32, 31, 29, 29, 28, 27, 26, 25, 24, 23, 22, 21, 21, 19, 19, 17, 16, 15, 14,
13, 12, 11, 9, 8, 8, 6, 6, 4, 4, 1, 1, 0, -1, -2, -2, -4, -4, -6, -6, -8, -9,
-10, -11, -11, -12, -13, -13, -14, -14, -15, -16, -17, -17, -18, -19, -18, -19,
-19, -20, -19, -20, -19, -20, -20, -20, -20, -20, -19, -20, -20, -19, -19, -18,
-17, -17, -17, -16, -16, -15, -15, -13, -12, -11, -10, -10, -8, -7, -5, -5, -4,
-2, 0, };