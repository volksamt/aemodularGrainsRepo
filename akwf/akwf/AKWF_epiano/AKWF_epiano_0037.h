#define DATA_LENGTH 512
#define DATA AKWF_epiano_0037

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 12, 16, 20, 25, 29, 34, 38, 41,
46, 50, 54, 59, 62, 66, 69, 73, 77, 80, 84, 86, 90, 92, 95, 98, 100, 103, 104,
106, 108, 109, 112, 113, 114, 114, 115, 116, 117, 118, 119, 119, 119, 119, 119,
119, 118, 119, 118, 118, 117, 117, 115, 115, 114, 114, 112, 111, 110, 109, 107,
106, 104, 104, 102, 101, 99, 98, 96, 94, 92, 90, 89, 87, 85, 84, 81, 79, 78, 76,
73, 73, 70, 69, 66, 65, 62, 60, 58, 57, 54, 52, 50, 48, 46, 45, 43, 40, 39, 37,
35, 34, 32, 30, 28, 26, 25, 24, 22, 21, 19, 17, 15, 13, 12, 10, 10, 9, 6, 6, 5,
3, 2, 2, -1, -1, -2, -3, -4, -4, -5, -6, -7, -7, -7, -9, -9, -9, -10, -10, -10,
-10, -11, -10, -10, -10, -10, -10, -9, -9, -9, -9, -7, -7, -6, -5, -4, -3, -3,
-2, -1, 1, 1, 3, 4, 7, 7, 8, 10, 12, 13, 15, 16, 18, 21, 22, 24, 26, 27, 29, 31,
33, 35, 36, 38, 39, 42, 42, 44, 46, 47, 48, 50, 51, 53, 53, 54, 55, 56, 57, 58,
58, 61, 61, 61, 62, 62, 62, 64, 64, 64, 64, 65, 65, 65, 66, 67, 67, 66, 66, 66,
66, 68, 67, 68, 68, 68, 68, 68, 67, 68, 67, 68, 67, 68, 68, 68, 67, 67, 67, 67,
67, 66, 67, 65, 66, 65, 65, 66, 64, 64, 64, 63, 63, 62, 61, 61, 61, 60, 59, 58,
57, 57, 56, 55, 54, 54, 52, 51, 51, 49, 48, 47, 45, 45, 44, 42, 41, 40, 38, 37,
36, 34, 33, 31, 29, 28, 27, 25, 23, 22, 20, 18, 15, 15, 12, 10, 9, 6, 5, 3, 1,
-1, -4, -5, -7, -10, -12, -14, -15, -19, -19, -22, -24, -26, -28, -30, -33, -35,
-36, -39, -41, -43, -45, -47, -49, -50, -51, -53, -55, -57, -59, -60, -61, -63,
-62, -64, -66, -66, -67, -68, -68, -70, -69, -70, -70, -70, -71, -71, -71, -72,
-71, -72, -71, -72, -71, -72, -71, -72, -72, -71, -71, -71, -71, -72, -71, -71,
-71, -72, -72, -71, -72, -72, -72, -71, -72, -72, -72, -73, -74, -74, -73, -73,
-74, -75, -76, -75, -75, -76, -77, -78, -78, -78, -78, -78, -79, -79, -80, -80,
-82, -82, -81, -83, -84, -84, -84, -85, -86, -86, -87, -87, -88, -88, -89, -89,
-91, -91, -91, -92, -92, -93, -94, -93, -94, -96, -95, -95, -97, -96, -97, -97,
-97, -98, -98, -98, -99, -99, -99, -100, -99, -99, -100, -100, -100, -100, -100,
-99, -100, -99, -99, -99, -98, -99, -99, -98, -98, -98, -98, -98, -96, -97, -95,
-96, -95, -95, -93, -93, -93, -92, -92, -92, -90, -90, -89, -89, -87, -87, -86,
-85, -84, -82, -81, -79, -78, -77, -77, -74, -73, -70, -70, -67, -66, -63, -61,
-59, -56, -54, -50, -48, -45, -41, -38, -35, -32, -28, -24, -21, -16, -13, -8,
-4, -1, };