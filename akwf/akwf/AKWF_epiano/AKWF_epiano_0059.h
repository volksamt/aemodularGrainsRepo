#define DATA_LENGTH 512
#define DATA AKWF_epiano_0059

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 12, 16, 20, 24, 28, 31, 35,
39, 43, 47, 50, 53, 57, 60, 64, 67, 71, 74, 77, 80, 82, 85, 87, 90, 93, 95, 97,
99, 101, 103, 106, 107, 109, 110, 112, 112, 114, 115, 115, 117, 117, 118, 118,
119, 119, 120, 119, 118, 119, 118, 118, 118, 118, 116, 116, 116, 114, 114, 112,
111, 110, 109, 107, 107, 105, 104, 102, 99, 98, 97, 95, 93, 92, 89, 88, 86, 84,
81, 80, 78, 75, 74, 71, 69, 67, 65, 62, 60, 58, 56, 54, 52, 50, 47, 45, 43, 40,
39, 36, 35, 32, 30, 29, 27, 23, 22, 20, 17, 16, 14, 12, 10, 9, 7, 5, 3, 2, 0,
-1, -2, -4, -5, -7, -8, -9, -10, -11, -12, -12, -13, -15, -16, -16, -17, -17,
-17, -18, -18, -18, -18, -18, -18, -17, -17, -17, -16, -16, -14, -15, -14, -12,
-12, -11, -9, -9, -8, -7, -6, -4, -2, -2, -1, 1, 3, 4, 6, 7, 9, 10, 12, 13, 15,
16, 18, 20, 22, 23, 25, 25, 27, 28, 31, 31, 33, 35, 36, 37, 39, 40, 41, 43, 44,
45, 47, 49, 48, 50, 52, 54, 54, 55, 56, 57, 58, 59, 60, 61, 62, 63, 64, 65, 67,
67, 68, 69, 70, 71, 70, 72, 72, 73, 74, 75, 75, 75, 77, 78, 78, 79, 79, 79, 81,
81, 81, 81, 82, 82, 82, 82, 83, 83, 83, 83, 84, 84, 84, 84, 84, 84, 84, 84, 83,
82, 83, 83, 82, 82, 81, 80, 80, 80, 79, 78, 77, 76, 76, 75, 74, 73, 72, 71, 70,
69, 67, 67, 64, 63, 61, 60, 59, 56, 55, 53, 51, 50, 48, 45, 43, 42, 38, 37, 35,
31, 30, 27, 25, 22, 20, 17, 15, 12, 8, 7, 3, 1, -3, -5, -7, -11, -13, -15, -18,
-21, -24, -27, -30, -32, -34, -37, -40, -41, -43, -47, -49, -50, -52, -53, -55,
-58, -59, -61, -63, -64, -66, -67, -68, -70, -71, -71, -73, -74, -75, -75, -77,
-77, -78, -79, -80, -79, -81, -81, -81, -81, -82, -83, -84, -83, -83, -83, -84,
-85, -84, -84, -85, -85, -84, -85, -85, -85, -85, -85, -85, -85, -85, -85, -85,
-86, -86, -86, -85, -86, -87, -87, -87, -87, -86, -88, -88, -88, -87, -89, -88,
-89, -89, -88, -89, -90, -90, -91, -91, -91, -91, -92, -92, -92, -93, -93, -94,
-94, -94, -95, -96, -97, -96, -96, -97, -97, -97, -98, -99, -99, -99, -99, -99,
-100, -100, -101, -101, -102, -101, -102, -103, -103, -102, -102, -104, -103,
-103, -104, -103, -104, -103, -104, -104, -104, -104, -105, -104, -104, -105,
-103, -104, -104, -104, -103, -103, -103, -103, -103, -102, -103, -102, -102,
-100, -101, -101, -100, -99, -99, -97, -97, -96, -95, -95, -93, -92, -91, -90,
-88, -87, -86, -83, -82, -80, -78, -77, -73, -72, -70, -66, -63, -62, -58, -55,
-53, -50, -46, -43, -40, -36, -33, -29, -25, -21, -18, -14, -11, -6, -3, };