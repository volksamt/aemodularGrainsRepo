#define DATA_LENGTH 512
#define DATA AKWF_epiano_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 14, 18, 21, 27, 30, 34, 39,
43, 47, 52, 55, 60, 63, 67, 70, 74, 78, 80, 83, 87, 90, 93, 94, 97, 100, 102,
103, 106, 107, 109, 110, 111, 112, 114, 114, 115, 116, 117, 118, 119, 119, 118,
119, 118, 119, 119, 119, 119, 118, 118, 118, 118, 117, 116, 116, 116, 116, 114,
113, 114, 113, 112, 111, 109, 110, 108, 108, 107, 105, 105, 104, 103, 102, 101,
100, 99, 97, 96, 95, 94, 94, 93, 91, 90, 89, 89, 88, 86, 86, 84, 83, 82, 81, 79,
79, 78, 77, 76, 74, 74, 73, 71, 69, 68, 67, 67, 65, 64, 63, 61, 61, 58, 58, 58,
55, 55, 53, 53, 50, 49, 48, 47, 46, 44, 44, 42, 41, 39, 38, 37, 35, 35, 34, 32,
31, 30, 30, 28, 27, 26, 25, 24, 23, 22, 22, 20, 19, 18, 18, 16, 16, 16, 15, 14,
13, 13, 12, 12, 11, 11, 10, 10, 10, 9, 9, 9, 8, 7, 8, 8, 7, 7, 6, 6, 5, 5, 4, 4,
3, 3, 2, 1, 2, 1, 0, 0, -1, -1, -2, -2, -2, -3, -3, -4, -4, -4, -5, -5, -5, -6,
-5, -5, -6, -7, -6, -5, -6, -6, -6, -6, -6, -6, -6, -6, -6, -5, -5, -5, -5, -4,
-3, -4, -4, -3, -3, -3, -2, -2, -2, -1, -1, -1, 0, 1, 1, 1, 2, 2, 2, 2, 3, 3, 4,
4, 4, 4, 4, 5, 5, 5, 6, 6, 5, 6, 6, 6, 6, 7, 6, 7, 6, 6, 6, 6, 6, 7, 6, 6, 6, 5,
6, 5, 4, 5, 3, 3, 3, 2, 1, 1, 1, 0, -1, -1, -2, -3, -4, -4, -6, -7, -7, -8, -9,
-10, -12, -13, -13, -16, -16, -18, -19, -20, -21, -23, -24, -26, -27, -29, -30,
-32, -33, -36, -37, -39, -40, -43, -45, -46, -48, -49, -51, -53, -55, -57, -59,
-60, -62, -63, -64, -66, -67, -69, -70, -71, -73, -73, -75, -75, -76, -76, -77,
-77, -78, -77, -77, -77, -77, -77, -75, -75, -74, -73, -73, -72, -70, -70, -68,
-68, -66, -65, -64, -62, -61, -60, -58, -57, -56, -55, -53, -53, -52, -51, -50,
-48, -47, -47, -47, -45, -45, -45, -44, -43, -43, -42, -43, -42, -42, -43, -42,
-42, -43, -42, -42, -43, -43, -43, -43, -44, -44, -44, -45, -45, -46, -47, -48,
-48, -49, -49, -50, -50, -52, -53, -52, -54, -55, -55, -55, -57, -58, -59, -60,
-61, -61, -62, -63, -64, -64, -65, -66, -66, -67, -68, -68, -69, -70, -70, -70,
-71, -72, -73, -73, -73, -73, -73, -73, -74, -74, -74, -74, -73, -74, -74, -74,
-74, -73, -74, -73, -73, -73, -73, -73, -72, -71, -71, -70, -70, -69, -69, -68,
-67, -67, -67, -66, -65, -64, -63, -62, -62, -61, -60, -60, -58, -57, -56, -55,
-55, -53, -52, -51, -49, -48, -47, -45, -43, -41, -40, -37, -35, -32, -31, -28,
-25, -21, -19, -15, -12, -8, -5, -2, };