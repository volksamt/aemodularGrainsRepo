#define DATA_LENGTH 512
#define DATA AKWF_epiano_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 13, 17, 21, 25, 30, 34, 38,
42, 47, 51, 55, 60, 64, 68, 71, 76, 80, 83, 86, 90, 93, 96, 99, 101, 105, 106,
109, 110, 112, 114, 115, 115, 117, 117, 119, 119, 119, 119, 119, 119, 117, 118,
116, 117, 115, 115, 113, 113, 111, 110, 109, 107, 105, 104, 103, 101, 100, 98,
96, 95, 93, 92, 90, 88, 87, 85, 84, 82, 80, 79, 78, 75, 74, 73, 71, 70, 70, 67,
66, 64, 64, 62, 60, 59, 58, 57, 56, 54, 54, 52, 51, 50, 49, 48, 46, 45, 44, 43,
43, 41, 40, 40, 38, 38, 38, 36, 35, 34, 33, 32, 32, 30, 30, 29, 29, 27, 26, 25,
24, 24, 24, 23, 22, 21, 21, 19, 19, 18, 18, 16, 15, 14, 15, 13, 11, 12, 10, 10,
9, 7, 7, 7, 5, 5, 4, 3, 2, 2, 0, 0, -1, -2, -3, -3, -4, -5, -6, -7, -8, -8, -9,
-10, -12, -12, -13, -14, -15, -15, -17, -17, -18, -19, -19, -20, -21, -22, -23,
-24, -24, -24, -27, -27, -29, -29, -29, -31, -31, -32, -33, -33, -35, -35, -36,
-36, -38, -39, -39, -40, -41, -42, -43, -43, -45, -45, -46, -47, -49, -49, -49,
-50, -52, -52, -54, -54, -55, -55, -57, -58, -58, -59, -61, -60, -61, -63, -64,
-65, -65, -67, -67, -67, -68, -69, -70, -72, -71, -73, -74, -74, -75, -76, -77,
-78, -78, -78, -80, -80, -81, -82, -82, -83, -83, -84, -85, -86, -86, -86, -87,
-87, -89, -88, -89, -89, -89, -89, -90, -90, -91, -90, -91, -90, -91, -91, -91,
-90, -90, -90, -89, -89, -89, -87, -87, -88, -86, -86, -84, -83, -81, -81, -80,
-78, -77, -75, -72, -71, -68, -66, -64, -62, -59, -56, -53, -50, -47, -43, -40,
-37, -33, -29, -25, -20, -17, -13, -9, -4, 0, 4, 9, 13, 17, 20, 25, 29, 33, 36,
40, 43, 47, 50, 53, 56, 58, 61, 63, 65, 67, 69, 70, 73, 72, 74, 76, 75, 76, 76,
76, 76, 76, 75, 75, 74, 73, 72, 71, 70, 68, 67, 66, 65, 63, 61, 60, 58, 56, 55,
53, 51, 48, 48, 45, 45, 42, 39, 39, 36, 34, 33, 32, 29, 27, 26, 24, 22, 21, 19,
18, 15, 14, 12, 12, 10, 9, 7, 6, 4, 3, 2, 0, -1, -2, -4, -5, -5, -7, -8, -9,
-10, -10, -11, -13, -15, -15, -16, -17, -19, -19, -20, -20, -21, -23, -22, -24,
-25, -25, -26, -27, -28, -29, -29, -30, -31, -32, -32, -33, -34, -36, -36, -36,
-36, -38, -39, -39, -40, -41, -41, -41, -42, -44, -45, -44, -46, -46, -47, -47,
-49, -49, -49, -50, -50, -51, -52, -52, -53, -54, -54, -54, -55, -55, -56, -56,
-56, -57, -57, -57, -58, -58, -56, -57, -57, -56, -56, -56, -56, -55, -54, -53,
-53, -51, -51, -49, -49, -47, -46, -44, -42, -41, -40, -37, -36, -32, -29, -28,
-25, -22, -20, -16, -12, -9, -5, -2, };