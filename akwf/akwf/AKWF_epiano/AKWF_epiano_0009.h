#define DATA_LENGTH 512
#define DATA AKWF_epiano_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 11, 16, 21, 26, 30, 34, 40, 43,
48, 52, 56, 61, 65, 69, 72, 76, 80, 84, 86, 90, 93, 95, 99, 101, 103, 105, 107,
109, 110, 112, 114, 116, 116, 117, 117, 118, 118, 119, 119, 119, 119, 119, 119,
118, 117, 117, 116, 115, 114, 114, 113, 113, 111, 110, 108, 108, 106, 106, 104,
104, 102, 100, 100, 98, 97, 96, 94, 93, 91, 90, 89, 88, 87, 85, 84, 83, 82, 80,
79, 78, 76, 76, 74, 73, 73, 71, 70, 69, 67, 66, 65, 64, 63, 61, 61, 60, 59, 58,
57, 55, 55, 54, 53, 51, 50, 49, 48, 47, 46, 44, 44, 43, 41, 40, 40, 38, 37, 36,
35, 33, 33, 31, 32, 29, 29, 27, 26, 25, 24, 24, 23, 21, 20, 19, 19, 17, 16, 15,
13, 13, 12, 10, 10, 9, 9, 7, 5, 5, 4, 3, 1, 0, 0, -2, -3, -4, -4, -6, -7, -8,
-8, -9, -11, -11, -13, -13, -15, -16, -16, -18, -18, -20, -21, -22, -23, -24,
-25, -26, -27, -29, -29, -30, -32, -33, -34, -34, -36, -38, -38, -40, -41, -41,
-43, -44, -46, -47, -47, -49, -49, -51, -52, -54, -54, -56, -57, -58, -59, -61,
-61, -63, -64, -65, -67, -68, -70, -69, -71, -72, -73, -75, -76, -78, -78, -80,
-81, -82, -83, -86, -86, -88, -88, -89, -90, -92, -93, -94, -96, -97, -98, -99,
-99, -101, -102, -103, -104, -104, -105, -106, -106, -107, -108, -109, -110,
-111, -112, -112, -112, -113, -113, -113, -113, -113, -114, -113, -113, -113,
-113, -112, -112, -111, -110, -108, -107, -107, -105, -104, -103, -101, -99,
-97, -95, -92, -90, -88, -85, -82, -80, -76, -73, -69, -66, -62, -58, -54, -50,
-46, -42, -37, -33, -28, -23, -18, -14, -9, -5, 1, 5, 10, 13, 18, 23, 27, 31,
36, 40, 43, 47, 50, 54, 57, 61, 64, 66, 69, 71, 73, 76, 77, 80, 81, 82, 84, 84,
85, 86, 87, 87, 88, 87, 87, 87, 86, 86, 86, 85, 84, 83, 83, 82, 81, 79, 78, 78,
76, 74, 73, 72, 71, 68, 67, 65, 64, 62, 61, 60, 57, 56, 54, 52, 51, 50, 47, 46,
44, 42, 41, 39, 38, 35, 35, 33, 31, 30, 28, 27, 25, 24, 22, 20, 19, 17, 16, 14,
13, 11, 10, 8, 7, 5, 4, 2, 1, 0, -2, -4, -5, -6, -8, -9, -11, -12, -14, -15,
-16, -18, -19, -20, -22, -24, -25, -26, -28, -29, -30, -31, -32, -34, -35, -37,
-38, -38, -40, -42, -43, -44, -45, -46, -47, -50, -50, -52, -52, -54, -55, -56,
-56, -58, -60, -61, -62, -62, -64, -65, -65, -66, -67, -68, -69, -70, -70, -71,
-72, -73, -74, -73, -75, -75, -75, -76, -77, -76, -77, -77, -77, -77, -77, -77,
-76, -76, -76, -75, -75, -74, -72, -72, -70, -69, -67, -66, -64, -62, -61, -58,
-55, -54, -51, -48, -45, -42, -39, -35, -31, -28, -24, -19, -16, -11, -8, -4,
-1, };