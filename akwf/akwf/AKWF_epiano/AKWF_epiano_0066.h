#define DATA_LENGTH 512
#define DATA AKWF_epiano_0066

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 11, 14, 17, 19, 22, 24, 27,
30, 32, 34, 38, 40, 42, 45, 47, 50, 52, 54, 57, 59, 60, 63, 65, 68, 70, 71, 74,
75, 77, 79, 81, 82, 85, 86, 87, 89, 91, 93, 94, 95, 97, 99, 99, 101, 102, 103,
104, 106, 106, 107, 108, 109, 110, 111, 112, 112, 113, 114, 114, 115, 115, 115,
117, 117, 117, 118, 118, 118, 118, 118, 119, 119, 119, 119, 119, 120, 119, 119,
119, 118, 118, 119, 118, 117, 118, 117, 117, 117, 116, 116, 116, 114, 114, 113,
113, 113, 111, 111, 111, 110, 109, 109, 109, 108, 106, 106, 105, 104, 104, 103,
101, 101, 100, 99, 99, 98, 97, 96, 94, 93, 93, 92, 91, 90, 89, 88, 87, 86, 85,
83, 83, 82, 81, 80, 79, 78, 76, 75, 74, 73, 71, 71, 69, 69, 66, 65, 64, 63, 62,
60, 60, 59, 57, 56, 55, 54, 52, 51, 50, 49, 48, 48, 46, 45, 43, 43, 42, 40, 40,
38, 38, 37, 35, 35, 34, 33, 32, 31, 29, 30, 28, 27, 26, 26, 25, 24, 24, 24, 22,
22, 22, 20, 20, 21, 20, 18, 19, 18, 18, 18, 16, 17, 16, 16, 15, 16, 15, 14, 14,
15, 14, 14, 13, 15, 13, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14,
15, 14, 14, 14, 15, 14, 14, 15, 14, 14, 15, 15, 14, 15, 16, 16, 16, 15, 16, 15,
15, 16, 16, 15, 15, 15, 15, 15, 14, 14, 13, 14, 13, 12, 12, 11, 11, 11, 11, 10,
9, 8, 7, 7, 6, 5, 5, 4, 3, 1, 1, -1, -2, -2, -3, -5, -6, -8, -8, -10, -11, -12,
-14, -15, -17, -18, -19, -21, -22, -24, -25, -26, -29, -30, -32, -32, -34, -36,
-37, -39, -40, -40, -43, -44, -45, -47, -48, -49, -50, -52, -54, -54, -55, -57,
-58, -59, -59, -61, -62, -62, -63, -65, -65, -67, -67, -67, -68, -69, -69, -69,
-71, -71, -72, -72, -73, -74, -74, -74, -74, -74, -75, -75, -75, -76, -77, -77,
-77, -77, -78, -78, -79, -79, -79, -79, -79, -80, -80, -81, -80, -82, -81, -81,
-81, -82, -82, -83, -84, -83, -83, -84, -85, -84, -85, -85, -86, -86, -87, -87,
-87, -87, -88, -88, -89, -89, -89, -90, -91, -91, -92, -92, -92, -93, -93, -94,
-94, -95, -96, -96, -96, -96, -97, -98, -99, -99, -99, -99, -100, -100, -101,
-101, -101, -102, -102, -102, -103, -103, -104, -104, -104, -104, -105, -105,
-104, -105, -105, -106, -106, -106, -107, -106, -106, -106, -106, -107, -107,
-106, -107, -107, -107, -105, -107, -107, -106, -105, -105, -105, -104, -104,
-103, -103, -102, -101, -101, -100, -99, -99, -97, -97, -95, -95, -93, -91, -90,
-89, -87, -85, -83, -82, -80, -77, -75, -73, -71, -70, -67, -65, -62, -60, -58,
-55, -54, -50, -48, -45, -43, -40, -36, -34, -31, -29, -25, -23, -21, -17, -14,
-12, -9, -6, -2, 0, };