#define DATA_LENGTH 512
#define DATA AKWF_epiano_0027

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 11, 15, 19, 25, 29, 35, 39, 43,
49, 52, 57, 62, 66, 69, 73, 77, 81, 84, 87, 90, 94, 97, 98, 101, 104, 106, 107,
109, 110, 113, 114, 115, 116, 117, 117, 118, 118, 119, 119, 119, 119, 120, 118,
119, 118, 118, 117, 116, 115, 114, 113, 111, 111, 110, 109, 107, 106, 104, 103,
101, 100, 97, 95, 94, 93, 90, 88, 86, 84, 82, 80, 78, 76, 74, 71, 69, 66, 65,
62, 61, 58, 56, 54, 51, 49, 48, 45, 43, 41, 39, 37, 34, 33, 31, 28, 27, 25, 23,
21, 20, 18, 16, 14, 12, 10, 8, 7, 6, 4, 3, 2, 0, -2, -4, -4, -6, -8, -9, -10,
-11, -12, -13, -15, -16, -16, -18, -18, -20, -20, -22, -22, -23, -24, -24, -24,
-26, -26, -26, -26, -26, -26, -27, -25, -25, -26, -25, -25, -25, -24, -23, -23,
-21, -21, -19, -19, -18, -16, -14, -14, -12, -11, -9, -7, -5, -4, -2, 1, 2, 4,
7, 10, 12, 14, 17, 19, 21, 24, 25, 28, 29, 32, 34, 37, 38, 40, 41, 43, 44, 45,
47, 48, 50, 51, 51, 53, 53, 54, 55, 56, 56, 58, 58, 58, 59, 61, 61, 61, 62, 62,
63, 63, 63, 63, 65, 65, 65, 65, 66, 66, 66, 67, 67, 67, 68, 69, 69, 69, 70, 70,
71, 70, 71, 71, 72, 72, 72, 72, 73, 73, 72, 73, 73, 73, 73, 74, 73, 73, 73, 73,
74, 73, 73, 72, 72, 72, 71, 71, 71, 70, 70, 69, 69, 68, 68, 67, 67, 66, 64, 63,
62, 61, 61, 59, 58, 57, 56, 55, 53, 52, 50, 49, 47, 46, 44, 42, 41, 39, 37, 35,
33, 32, 29, 27, 25, 23, 21, 19, 17, 14, 12, 9, 7, 5, 2, -1, -4, -6, -9, -11,
-14, -17, -21, -23, -26, -29, -33, -34, -38, -41, -43, -47, -50, -53, -56, -57,
-60, -62, -65, -67, -70, -71, -72, -74, -75, -76, -77, -78, -79, -79, -80, -80,
-80, -80, -80, -80, -78, -79, -79, -78, -78, -77, -77, -76, -75, -75, -74, -74,
-73, -73, -72, -72, -72, -71, -71, -70, -70, -69, -69, -69, -68, -69, -68, -67,
-68, -68, -68, -67, -67, -67, -67, -67, -67, -67, -67, -67, -68, -67, -68, -68,
-68, -69, -68, -68, -69, -70, -70, -71, -71, -71, -72, -72, -73, -74, -74, -74,
-76, -76, -76, -77, -77, -77, -78, -79, -80, -80, -81, -82, -82, -82, -84, -83,
-84, -85, -85, -86, -87, -87, -88, -88, -88, -88, -88, -89, -88, -89, -89, -89,
-90, -91, -89, -90, -90, -90, -90, -89, -91, -89, -90, -90, -89, -89, -88, -89,
-89, -87, -88, -88, -87, -87, -87, -86, -87, -86, -85, -85, -85, -84, -84, -84,
-83, -82, -82, -81, -81, -81, -81, -79, -79, -78, -77, -77, -76, -74, -74, -73,
-72, -70, -69, -67, -66, -65, -63, -60, -59, -56, -53, -51, -48, -45, -43, -38,
-34, -31, -28, -24, -19, -16, -11, -7, -2, };