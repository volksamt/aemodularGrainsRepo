#define DATA_LENGTH 512
#define DATA AKWF_epiano_0029

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 12, 15, 20, 24, 29, 32, 37, 40,
44, 49, 54, 56, 60, 64, 68, 71, 75, 77, 81, 84, 86, 90, 91, 95, 96, 99, 102,
103, 105, 107, 109, 111, 111, 112, 115, 115, 116, 117, 117, 118, 119, 118, 118,
119, 119, 120, 118, 119, 118, 117, 117, 117, 117, 116, 115, 113, 112, 112, 111,
111, 109, 108, 106, 105, 104, 103, 101, 99, 99, 97, 96, 93, 91, 90, 88, 88, 85,
83, 82, 79, 78, 75, 74, 73, 71, 69, 67, 65, 64, 62, 60, 57, 56, 54, 52, 51, 49,
47, 46, 44, 43, 40, 38, 37, 35, 33, 32, 30, 28, 28, 26, 25, 23, 22, 20, 19, 18,
16, 15, 13, 12, 11, 9, 9, 8, 7, 6, 6, 5, 3, 2, 2, 1, 1, 1, -1, -1, -1, -1, -3,
-2, -2, -2, -2, -3, -2, -2, -2, -1, -2, -1, -1, 0, 1, 1, 1, 2, 2, 4, 5, 5, 6, 7,
8, 10, 10, 12, 12, 14, 16, 17, 18, 20, 21, 23, 25, 26, 27, 28, 30, 31, 33, 35,
37, 37, 39, 40, 42, 43, 45, 46, 47, 49, 49, 50, 51, 51, 52, 54, 54, 56, 56, 57,
58, 57, 58, 59, 59, 60, 60, 60, 60, 60, 61, 60, 61, 61, 60, 61, 61, 61, 61, 61,
60, 60, 60, 61, 60, 60, 60, 60, 60, 59, 59, 59, 58, 57, 58, 58, 58, 56, 57, 56,
56, 55, 55, 54, 54, 54, 53, 53, 52, 52, 51, 51, 50, 49, 48, 47, 47, 46, 46, 44,
43, 43, 42, 41, 40, 39, 38, 37, 37, 35, 34, 32, 32, 30, 29, 27, 27, 26, 24, 23,
22, 20, 18, 18, 16, 15, 13, 11, 10, 8, 6, 5, 3, 2, 1, -2, -3, -5, -7, -7, -10,
-11, -12, -15, -17, -17, -19, -21, -24, -25, -26, -28, -29, -31, -32, -35, -36,
-37, -39, -40, -42, -42, -44, -46, -47, -47, -49, -50, -51, -52, -53, -54, -55,
-56, -56, -57, -58, -58, -59, -59, -61, -61, -61, -62, -62, -62, -62, -63, -62,
-63, -64, -64, -64, -65, -65, -66, -65, -65, -66, -65, -66, -66, -67, -67, -67,
-67, -67, -68, -68, -68, -70, -70, -70, -71, -71, -71, -72, -73, -73, -73, -74,
-74, -76, -75, -75, -77, -78, -77, -79, -80, -80, -81, -82, -82, -83, -84, -85,
-85, -86, -86, -87, -88, -88, -89, -90, -91, -91, -92, -93, -93, -93, -94, -95,
-96, -96, -97, -98, -97, -99, -99, -100, -100, -100, -101, -101, -102, -102,
-102, -102, -104, -104, -104, -103, -104, -105, -104, -104, -105, -105, -105,
-105, -105, -105, -106, -104, -105, -105, -104, -104, -104, -103, -103, -103,
-103, -103, -101, -101, -101, -100, -100, -100, -99, -98, -98, -97, -97, -95,
-95, -94, -92, -91, -90, -89, -88, -87, -85, -85, -82, -81, -80, -78, -76, -74,
-72, -70, -68, -66, -63, -61, -58, -55, -53, -50, -47, -43, -40, -38, -33, -31,
-27, -23, -20, -16, -12, -8, -3, 0, };