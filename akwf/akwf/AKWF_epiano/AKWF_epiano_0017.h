#define DATA_LENGTH 512
#define DATA AKWF_epiano_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 16, 22, 28, 35, 41, 47, 53, 58,
63, 67, 70, 72, 74, 75, 76, 76, 74, 73, 72, 71, 70, 69, 69, 70, 69, 70, 71, 72,
74, 75, 76, 77, 79, 80, 80, 79, 80, 79, 80, 80, 79, 79, 78, 78, 79, 78, 78, 77,
77, 76, 75, 74, 73, 70, 68, 64, 61, 57, 54, 50, 45, 42, 38, 35, 31, 29, 26, 24,
22, 20, 17, 14, 12, 9, 5, 1, -3, -10, -15, -21, -27, -34, -41, -48, -55, -62,
-66, -73, -79, -83, -88, -93, -97, -101, -104, -107, -109, -112, -114, -115,
-117, -117, -116, -116, -114, -112, -110, -107, -102, -100, -96, -92, -88, -84,
-82, -79, -78, -76, -74, -75, -75, -75, -77, -79, -81, -85, -87, -90, -93, -95,
-97, -99, -100, -101, -101, -100, -99, -97, -94, -91, -87, -82, -77, -71, -64,
-56, -49, -41, -32, -22, -15, -5, 2, 11, 19, 27, 35, 41, 47, 52, 55, 58, 61, 61,
61, 61, 59, 56, 53, 49, 45, 40, 36, 31, 26, 23, 19, 16, 15, 12, 11, 12, 12, 14,
17, 21, 25, 30, 36, 42, 49, 57, 64, 71, 78, 85, 91, 97, 102, 104, 108, 111, 113,
113, 114, 113, 111, 110, 106, 103, 99, 93, 88, 82, 78, 71, 65, 58, 54, 48, 44,
41, 38, 35, 35, 34, 35, 38, 41, 44, 49, 54, 59, 65, 70, 75, 81, 85, 90, 93, 96,
99, 99, 100, 101, 103, 102, 101, 100, 99, 99, 96, 93, 90, 88, 84, 81, 76, 72,
68, 64, 59, 55, 53, 51, 48, 47, 47, 46, 48, 49, 51, 53, 57, 60, 61, 65, 69, 70,
72, 74, 74, 74, 74, 74, 73, 73, 72, 71, 70, 69, 69, 68, 67, 67, 66, 64, 64, 63,
61, 59, 58, 56, 53, 50, 48, 46, 43, 42, 41, 40, 38, 38, 38, 37, 37, 35, 35, 34,
34, 32, 28, 26, 23, 20, 15, 13, 9, 6, 3, 0, -2, -4, -4, -5, -4, -5, -3, -3, -2,
-1, 1, 1, 3, 3, 3, 3, 1, 1, 0, 0, -3, -3, -5, -7, -10, -12, -14, -18, -21, -25,
-30, -35, -40, -45, -50, -56, -61, -67, -72, -76, -80, -82, -83, -85, -86, -85,
-84, -82, -79, -75, -72, -68, -63, -59, -56, -51, -47, -44, -41, -38, -37, -35,
-34, -35, -35, -35, -38, -40, -44, -48, -51, -57, -62, -68, -75, -80, -87, -92,
-98, -103, -108, -111, -114, -117, -118, -118, -119, -118, -115, -112, -108,
-103, -99, -93, -86, -80, -75, -67, -61, -55, -51, -44, -42, -38, -35, -33, -33,
-33, -34, -37, -39, -42, -47, -52, -57, -63, -69, -75, -80, -86, -91, -95, -98,
-102, -104, -105, -107, -106, -105, -105, -103, -99, -96, -92, -86, -81, -74,
-68, -61, -55, -47, -40, -34, -28, -23, -18, -14, -10, -9, -6, -5, -6, -8, -9,
-11, -14, -19, -22, -25, -29, -32, -34, -37, -38, -38, -39, -39, -38, -37, -34,
-32, -30, -27, -24, -20, -15, -11, -7, -1, };