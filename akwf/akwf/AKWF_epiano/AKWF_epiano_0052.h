#define DATA_LENGTH 512
#define DATA AKWF_epiano_0052

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 15, 18, 23, 28, 32, 37, 41,
45, 50, 53, 58, 62, 65, 70, 73, 77, 81, 84, 87, 90, 93, 96, 98, 101, 103, 105,
107, 109, 110, 112, 114, 114, 116, 116, 116, 118, 119, 119, 118, 119, 118, 118,
120, 118, 118, 118, 117, 116, 116, 115, 114, 113, 112, 111, 109, 108, 107, 105,
104, 102, 100, 99, 96, 96, 93, 90, 89, 87, 85, 84, 81, 78, 77, 75, 73, 70, 68,
66, 64, 62, 60, 57, 55, 54, 50, 49, 46, 44, 43, 40, 38, 36, 34, 32, 29, 28, 26,
24, 22, 20, 19, 17, 16, 13, 11, 9, 7, 7, 5, 4, 3, 1, -1, -3, -4, -5, -7, -8, -9,
-10, -11, -12, -14, -14, -16, -17, -17, -18, -19, -19, -20, -20, -20, -20, -21,
-21, -21, -21, -21, -22, -21, -21, -20, -20, -20, -19, -18, -18, -17, -17, -15,
-14, -13, -12, -12, -11, -9, -7, -6, -4, -3, -2, 1, 3, 4, 7, 9, 10, 12, 15, 17,
20, 22, 23, 25, 28, 29, 31, 33, 35, 38, 39, 40, 43, 43, 45, 46, 47, 49, 50, 51,
52, 54, 54, 56, 56, 57, 57, 58, 59, 60, 61, 62, 62, 62, 63, 63, 64, 64, 65, 66,
65, 67, 67, 68, 68, 68, 69, 70, 69, 69, 70, 71, 71, 71, 72, 72, 72, 73, 73, 73,
73, 74, 75, 75, 74, 75, 75, 76, 76, 76, 76, 76, 76, 76, 76, 76, 76, 76, 76, 75,
75, 75, 75, 74, 73, 73, 72, 72, 71, 71, 70, 69, 68, 68, 66, 65, 65, 63, 62, 62,
60, 58, 57, 57, 55, 53, 52, 50, 49, 47, 45, 44, 41, 39, 37, 36, 34, 31, 30, 27,
25, 24, 20, 19, 16, 13, 11, 9, 6, 3, 1, -2, -6, -8, -11, -14, -17, -20, -23,
-25, -29, -32, -36, -38, -41, -45, -49, -52, -54, -57, -60, -63, -66, -68, -71,
-74, -75, -77, -79, -81, -83, -84, -86, -87, -87, -88, -89, -89, -89, -89, -90,
-89, -88, -88, -89, -87, -87, -87, -85, -85, -84, -83, -83, -82, -82, -81, -80,
-79, -79, -78, -78, -77, -75, -75, -74, -74, -73, -73, -73, -73, -72, -71, -71,
-72, -71, -71, -71, -70, -70, -70, -69, -69, -70, -70, -69, -70, -70, -70, -70,
-70, -71, -70, -71, -72, -72, -72, -72, -73, -73, -74, -75, -75, -76, -76, -76,
-77, -77, -78, -79, -79, -79, -80, -80, -81, -82, -82, -83, -84, -84, -84, -86,
-85, -87, -87, -87, -88, -89, -89, -89, -89, -89, -89, -90, -90, -90, -91, -90,
-91, -91, -91, -90, -91, -90, -91, -91, -89, -90, -90, -90, -90, -90, -89, -89,
-89, -88, -88, -88, -87, -87, -86, -86, -86, -86, -85, -85, -85, -84, -83, -83,
-83, -82, -81, -81, -80, -80, -79, -79, -77, -76, -75, -74, -73, -71, -70, -69,
-67, -65, -64, -62, -60, -58, -55, -52, -50, -48, -44, -43, -39, -37, -33, -29,
-25, -22, -18, -15, -10, -6, -2, };