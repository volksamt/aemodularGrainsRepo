#define DATA_LENGTH 512
#define DATA AKWF_epiano_0036

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 10, 14, 19, 24, 27, 33, 37, 42,
47, 51, 55, 60, 65, 68, 72, 76, 79, 83, 87, 90, 92, 96, 98, 101, 103, 105, 107,
109, 111, 112, 113, 114, 116, 117, 118, 118, 119, 119, 119, 118, 119, 119, 119,
118, 117, 117, 117, 116, 115, 114, 113, 112, 111, 110, 108, 107, 106, 104, 102,
100, 100, 97, 95, 94, 91, 89, 88, 85, 83, 81, 79, 77, 74, 72, 70, 67, 64, 63,
60, 58, 55, 53, 51, 49, 47, 43, 41, 39, 37, 35, 33, 31, 29, 27, 25, 22, 21, 18,
17, 15, 13, 11, 10, 8, 6, 5, 2, 1, 0, -3, -4, -5, -6, -8, -10, -10, -12, -13,
-14, -15, -17, -18, -19, -20, -21, -22, -23, -24, -24, -25, -27, -27, -27, -27,
-28, -28, -29, -29, -29, -29, -29, -28, -28, -27, -27, -26, -26, -25, -24, -22,
-22, -21, -20, -18, -16, -15, -14, -13, -9, -7, -6, -5, -2, 0, 2, 5, 6, 9, 11,
14, 16, 18, 22, 23, 26, 28, 29, 31, 34, 36, 38, 39, 41, 43, 44, 45, 46, 48, 48,
50, 50, 52, 52, 52, 54, 54, 56, 55, 56, 57, 57, 58, 59, 59, 60, 59, 61, 61, 61,
62, 62, 62, 64, 64, 64, 64, 66, 66, 67, 67, 67, 68, 69, 69, 69, 69, 71, 71, 72,
73, 73, 73, 73, 74, 75, 75, 76, 76, 77, 77, 78, 78, 78, 78, 78, 79, 78, 79, 80,
80, 79, 79, 80, 80, 80, 79, 80, 79, 78, 79, 78, 77, 77, 76, 75, 75, 74, 74, 73,
71, 71, 70, 68, 67, 66, 66, 63, 62, 60, 60, 58, 57, 55, 53, 51, 50, 47, 46, 43,
41, 39, 37, 35, 33, 29, 28, 26, 23, 20, 17, 15, 12, 9, 6, 3, -1, -3, -6, -10,
-14, -17, -21, -25, -28, -33, -36, -39, -44, -47, -51, -55, -58, -62, -65, -68,
-72, -75, -78, -81, -83, -86, -87, -90, -91, -92, -94, -95, -96, -96, -97, -97,
-96, -97, -97, -95, -95, -95, -93, -92, -92, -90, -90, -89, -88, -87, -85, -85,
-84, -83, -81, -81, -80, -79, -78, -77, -76, -75, -74, -73, -73, -72, -72, -71,
-70, -70, -70, -70, -68, -68, -67, -67, -67, -67, -67, -67, -66, -66, -66, -67,
-66, -66, -66, -67, -66, -67, -67, -67, -68, -68, -68, -68, -69, -69, -70, -70,
-71, -72, -72, -72, -73, -74, -75, -75, -75, -77, -77, -78, -78, -78, -80, -80,
-81, -81, -82, -82, -83, -83, -84, -85, -85, -86, -86, -86, -87, -87, -88, -88,
-88, -88, -88, -88, -88, -88, -88, -88, -88, -88, -88, -88, -88, -88, -88, -87,
-87, -86, -86, -86, -86, -86, -85, -84, -84, -84, -84, -83, -84, -83, -83, -82,
-82, -81, -82, -80, -80, -80, -79, -79, -78, -78, -78, -77, -75, -75, -73, -73,
-71, -70, -69, -67, -66, -64, -61, -60, -57, -55, -53, -50, -47, -44, -40, -38,
-34, -31, -27, -24, -20, -16, -12, -7, -2, };