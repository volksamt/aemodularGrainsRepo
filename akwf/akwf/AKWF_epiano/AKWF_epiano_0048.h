#define DATA_LENGTH 512
#define DATA AKWF_epiano_0048

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 13, 17, 23, 26, 31, 37, 42, 46,
51, 55, 60, 64, 70, 73, 78, 82, 86, 90, 93, 95, 98, 102, 104, 107, 108, 110,
112, 113, 115, 116, 117, 118, 118, 118, 118, 119, 119, 119, 119, 118, 119, 118,
117, 117, 116, 115, 115, 115, 114, 113, 112, 111, 110, 109, 108, 106, 106, 105,
104, 103, 101, 101, 100, 99, 97, 95, 94, 93, 91, 91, 89, 88, 86, 85, 84, 82, 81,
79, 77, 76, 75, 73, 73, 71, 69, 67, 65, 64, 63, 61, 60, 58, 57, 55, 54, 52, 51,
49, 47, 46, 45, 42, 41, 40, 38, 36, 34, 34, 31, 31, 30, 27, 26, 25, 23, 22, 21,
19, 17, 17, 15, 14, 12, 12, 9, 9, 7, 7, 5, 4, 3, 2, 1, -1, -1, -3, -3, -5, -6,
-6, -7, -8, -9, -10, -11, -11, -12, -13, -14, -14, -16, -16, -15, -16, -17, -18,
-18, -18, -20, -19, -21, -21, -21, -20, -21, -21, -22, -22, -22, -21, -21, -20,
-20, -20, -20, -19, -19, -19, -18, -17, -17, -17, -15, -15, -14, -14, -13, -13,
-12, -12, -11, -11, -10, -10, -10, -10, -10, -11, -9, -10, -10, -11, -10, -11,
-11, -11, -12, -12, -11, -12, -12, -12, -13, -14, -13, -13, -14, -14, -14, -14,
-14, -15, -15, -15, -16, -17, -17, -17, -17, -18, -18, -18, -18, -18, -19, -19,
-19, -20, -20, -20, -20, -21, -22, -22, -22, -23, -22, -23, -24, -24, -25, -24,
-24, -25, -25, -26, -27, -27, -27, -27, -28, -28, -28, -28, -29, -30, -30, -31,
-30, -30, -32, -33, -33, -32, -33, -33, -33, -34, -35, -34, -35, -35, -35, -35,
-37, -37, -36, -37, -38, -37, -38, -38, -38, -39, -39, -40, -40, -40, -40, -40,
-41, -41, -40, -41, -41, -41, -42, -42, -42, -43, -43, -41, -42, -42, -42, -42,
-43, -42, -42, -42, -41, -42, -42, -41, -41, -40, -40, -39, -38, -38, -37, -35,
-35, -35, -33, -31, -30, -29, -28, -25, -24, -22, -20, -19, -16, -15, -13, -11,
-10, -8, -6, -4, -2, 0, 1, 3, 4, 6, 7, 8, 10, 10, 12, 13, 13, 14, 15, 15, 16,
15, 15, 16, 15, 15, 16, 16, 14, 15, 14, 14, 13, 12, 12, 11, 10, 9, 9, 8, 7, 5,
4, 4, 2, 1, 0, -1, -2, -4, -5, -5, -8, -8, -9, -11, -12, -14, -15, -16, -18,
-18, -19, -21, -22, -24, -24, -26, -27, -28, -30, -30, -31, -32, -34, -35, -36,
-37, -38, -39, -40, -41, -42, -43, -43, -44, -45, -47, -47, -47, -48, -50, -49,
-50, -51, -51, -52, -53, -54, -53, -54, -55, -55, -56, -57, -57, -57, -57, -58,
-59, -58, -58, -59, -59, -59, -59, -59, -60, -60, -59, -60, -59, -60, -60, -59,
-59, -60, -59, -58, -58, -58, -57, -57, -57, -57, -55, -55, -54, -53, -52, -51,
-50, -50, -49, -46, -45, -43, -42, -40, -38, -35, -33, -31, -28, -25, -22, -18,
-15, -11, -8, -4, -1, };