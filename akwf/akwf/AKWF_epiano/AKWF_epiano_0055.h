#define DATA_LENGTH 512
#define DATA AKWF_epiano_0055

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 12, 17, 23, 29, 35, 41, 48, 54,
59, 65, 70, 75, 80, 84, 88, 92, 96, 99, 102, 105, 107, 109, 110, 112, 113, 115,
115, 117, 118, 118, 119, 118, 118, 119, 119, 119, 119, 119, 118, 117, 117, 117,
116, 115, 115, 114, 114, 113, 111, 111, 110, 108, 108, 106, 106, 105, 103, 103,
101, 100, 99, 97, 96, 95, 93, 92, 91, 89, 88, 87, 85, 83, 82, 80, 78, 76, 76,
74, 72, 71, 69, 67, 65, 64, 62, 60, 59, 57, 55, 53, 52, 51, 49, 47, 45, 44, 42,
40, 39, 36, 35, 34, 31, 30, 29, 27, 24, 24, 22, 21, 19, 18, 15, 14, 13, 12, 10,
9, 7, 6, 4, 3, 1, 0, -2, -3, -5, -5, -6, -8, -9, -9, -11, -12, -13, -14, -15,
-17, -17, -19, -19, -19, -21, -22, -22, -23, -24, -25, -26, -26, -26, -27, -27,
-28, -28, -29, -30, -29, -30, -30, -29, -30, -30, -30, -31, -30, -31, -29, -29,
-29, -28, -28, -27, -26, -25, -24, -24, -23, -23, -22, -21, -21, -20, -20, -19,
-19, -18, -17, -17, -17, -17, -16, -17, -17, -16, -17, -16, -16, -16, -16, -16,
-17, -16, -17, -16, -16, -16, -17, -16, -16, -16, -16, -16, -16, -17, -16, -16,
-16, -15, -15, -16, -15, -15, -15, -15, -14, -15, -14, -13, -14, -14, -14, -13,
-13, -12, -12, -13, -12, -11, -11, -11, -11, -10, -11, -11, -10, -10, -10, -10,
-10, -10, -10, -10, -10, -10, -10, -10, -10, -11, -10, -10, -10, -11, -10, -11,
-12, -11, -12, -13, -12, -13, -13, -13, -14, -15, -14, -15, -15, -17, -17, -17,
-18, -18, -18, -20, -20, -21, -20, -21, -22, -23, -23, -24, -25, -25, -25, -26,
-27, -27, -28, -28, -29, -29, -31, -30, -32, -31, -32, -32, -33, -34, -34, -35,
-36, -36, -37, -38, -39, -38, -38, -40, -40, -41, -41, -41, -42, -43, -43, -43,
-43, -43, -42, -42, -42, -41, -41, -40, -38, -37, -36, -34, -32, -29, -27, -25,
-22, -19, -17, -14, -12, -10, -7, -4, -3, -1, 2, 4, 5, 8, 10, 11, 11, 12, 14,
14, 15, 16, 16, 17, 17, 18, 17, 18, 17, 17, 17, 16, 16, 15, 14, 14, 13, 13, 12,
11, 10, 10, 9, 7, 7, 5, 3, 3, 2, 1, -1, -2, -4, -5, -7, -7, -9, -10, -11, -13,
-15, -16, -17, -18, -20, -21, -22, -24, -25, -26, -28, -28, -31, -32, -33, -34,
-36, -37, -37, -38, -40, -41, -42, -43, -44, -45, -45, -46, -47, -47, -48, -49,
-49, -51, -50, -51, -51, -52, -53, -53, -53, -54, -54, -54, -54, -55, -55, -54,
-55, -55, -55, -55, -56, -56, -56, -55, -55, -54, -55, -55, -54, -54, -54, -54,
-54, -54, -54, -53, -54, -53, -53, -52, -52, -52, -52, -51, -51, -51, -51, -50,
-50, -49, -49, -48, -48, -47, -47, -47, -45, -43, -44, -43, -40, -40, -38, -36,
-32, -31, -28, -24, -22, -17, -12, -9, -3, };