#define DATA_LENGTH 512
#define DATA AKWF_epiano_0049

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 15, 21, 27, 33, 38, 44, 50, 56,
61, 66, 70, 75, 80, 83, 88, 91, 94, 97, 100, 104, 105, 107, 109, 112, 113, 114,
115, 116, 117, 117, 118, 118, 119, 119, 119, 119, 118, 119, 118, 117, 117, 117,
116, 115, 115, 113, 113, 112, 111, 108, 108, 106, 105, 104, 103, 100, 100, 97,
96, 95, 93, 91, 90, 88, 86, 85, 83, 81, 80, 78, 77, 75, 73, 72, 70, 69, 68, 66,
65, 63, 62, 60, 59, 58, 56, 56, 54, 53, 52, 51, 50, 49, 49, 48, 47, 47, 46, 45,
44, 43, 43, 42, 42, 41, 39, 39, 39, 39, 38, 36, 37, 35, 36, 36, 34, 34, 34, 34,
33, 32, 31, 31, 31, 30, 31, 29, 29, 29, 29, 29, 28, 28, 28, 27, 27, 28, 27, 27,
26, 27, 26, 26, 26, 27, 26, 27, 27, 27, 27, 27, 26, 26, 25, 25, 25, 24, 24, 22,
21, 20, 18, 17, 16, 14, 12, 10, 9, 7, 4, 3, 0, -1, -4, -6, -9, -11, -13, -15,
-17, -18, -20, -23, -24, -25, -26, -27, -29, -30, -30, -31, -32, -32, -33, -33,
-33, -33, -33, -33, -32, -32, -31, -30, -30, -28, -28, -26, -26, -24, -23, -21,
-20, -19, -17, -15, -14, -12, -11, -10, -8, -6, -4, -3, 0, 0, 3, 5, 7, 9, 10,
12, 13, 15, 17, 18, 20, 22, 24, 25, 27, 28, 30, 31, 32, 35, 36, 38, 38, 40, 41,
43, 44, 45, 46, 47, 48, 50, 51, 51, 53, 54, 54, 56, 56, 57, 58, 59, 59, 61, 61,
61, 63, 62, 63, 64, 63, 64, 64, 64, 63, 64, 63, 63, 63, 62, 62, 61, 59, 59, 58,
57, 56, 55, 53, 51, 50, 47, 44, 42, 39, 36, 34, 31, 27, 24, 20, 17, 13, 10, 6,
1, -3, -6, -11, -15, -20, -24, -28, -33, -37, -41, -46, -50, -53, -58, -62, -66,
-71, -74, -78, -82, -85, -88, -91, -95, -97, -100, -103, -104, -107, -109, -110,
-111, -113, -113, -115, -115, -114, -113, -114, -112, -111, -110, -108, -106,
-103, -101, -99, -96, -93, -91, -88, -84, -82, -78, -75, -72, -70, -67, -64,
-61, -59, -55, -53, -51, -49, -46, -44, -42, -41, -39, -38, -37, -36, -35, -33,
-32, -33, -31, -30, -30, -30, -30, -30, -29, -30, -29, -30, -30, -30, -30, -31,
-32, -32, -33, -34, -35, -36, -38, -39, -40, -40, -43, -44, -46, -48, -49, -50,
-52, -53, -55, -57, -58, -60, -62, -63, -65, -67, -68, -70, -71, -72, -74, -75,
-76, -78, -79, -80, -81, -81, -82, -83, -84, -84, -85, -85, -85, -85, -86, -85,
-84, -85, -85, -84, -84, -84, -83, -82, -82, -80, -81, -80, -79, -78, -78, -77,
-77, -75, -75, -75, -74, -73, -73, -73, -72, -72, -72, -72, -71, -71, -71, -72,
-71, -71, -70, -71, -70, -70, -70, -68, -68, -67, -66, -64, -64, -62, -60, -57,
-54, -53, -49, -45, -41, -37, -34, -28, -24, -18, -12, -8, -2, };