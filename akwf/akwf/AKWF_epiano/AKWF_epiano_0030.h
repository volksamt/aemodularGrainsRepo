#define DATA_LENGTH 512
#define DATA AKWF_epiano_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 16, 24, 30, 37, 44, 50, 56, 63,
69, 74, 80, 85, 89, 93, 97, 100, 103, 106, 108, 110, 112, 114, 115, 115, 116,
118, 117, 119, 119, 119, 119, 119, 120, 119, 119, 118, 117, 118, 117, 116, 116,
116, 115, 114, 113, 112, 112, 111, 109, 108, 108, 107, 105, 105, 103, 102, 101,
100, 99, 97, 96, 95, 93, 91, 90, 89, 88, 86, 85, 83, 82, 80, 78, 76, 75, 73, 73,
70, 68, 68, 66, 64, 61, 60, 59, 57, 56, 54, 52, 51, 49, 47, 45, 45, 43, 41, 39,
37, 37, 34, 32, 31, 29, 28, 26, 25, 22, 22, 19, 18, 16, 15, 13, 12, 11, 9, 8, 7,
5, 3, 2, 1, -1, -2, -3, -4, -6, -7, -9, -9, -11, -12, -14, -14, -16, -16, -17,
-18, -19, -20, -22, -22, -23, -24, -25, -26, -26, -27, -28, -28, -29, -29, -30,
-31, -32, -32, -33, -32, -34, -34, -34, -34, -35, -35, -34, -34, -34, -34, -33,
-32, -31, -31, -29, -28, -27, -26, -26, -24, -24, -22, -22, -20, -21, -20, -19,
-18, -18, -19, -18, -18, -17, -17, -17, -17, -17, -18, -17, -17, -17, -17, -17,
-17, -17, -18, -17, -17, -18, -16, -16, -16, -17, -17, -16, -17, -17, -16, -16,
-15, -16, -15, -16, -15, -15, -15, -14, -14, -14, -13, -13, -12, -13, -12, -11,
-11, -11, -10, -10, -10, -10, -10, -9, -9, -9, -8, -8, -7, -8, -7, -7, -7, -7,
-7, -6, -7, -7, -7, -7, -7, -6, -7, -7, -8, -7, -7, -8, -7, -8, -9, -8, -9, -10,
-10, -10, -11, -11, -12, -12, -12, -13, -13, -14, -14, -15, -15, -17, -17, -18,
-18, -19, -19, -19, -21, -22, -22, -22, -24, -24, -24, -25, -26, -27, -28, -28,
-29, -29, -30, -30, -31, -32, -33, -33, -33, -34, -35, -35, -35, -37, -37, -39,
-38, -39, -40, -41, -41, -41, -42, -43, -42, -43, -43, -42, -43, -42, -41, -40,
-39, -38, -37, -35, -33, -30, -28, -25, -23, -20, -17, -14, -11, -8, -5, -3, -1,
2, 4, 6, 8, 10, 11, 13, 14, 16, 16, 17, 17, 17, 18, 19, 18, 19, 19, 19, 19, 18,
18, 18, 18, 17, 16, 15, 15, 15, 13, 13, 12, 11, 11, 10, 8, 7, 7, 4, 3, 2, 1, -1,
-2, -3, -4, -6, -7, -8, -10, -12, -13, -15, -16, -17, -19, -20, -21, -23, -24,
-27, -28, -29, -31, -32, -34, -35, -36, -38, -39, -39, -40, -42, -44, -45, -45,
-46, -47, -48, -49, -49, -50, -50, -52, -52, -53, -54, -53, -54, -55, -55, -55,
-56, -56, -56, -57, -57, -57, -57, -57, -57, -57, -57, -57, -57, -56, -57, -57,
-57, -56, -57, -57, -55, -55, -55, -54, -54, -55, -54, -54, -54, -53, -53, -52,
-53, -53, -52, -53, -52, -51, -51, -51, -51, -50, -49, -49, -49, -49, -49, -47,
-47, -46, -46, -45, -44, -43, -41, -39, -38, -35, -32, -29, -25, -20, -17, -13,
-7, -1, };