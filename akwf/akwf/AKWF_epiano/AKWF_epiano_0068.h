#define DATA_LENGTH 512
#define DATA AKWF_epiano_0068

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 12, 16, 20, 24, 29, 33, 36,
40, 44, 48, 51, 55, 59, 63, 66, 69, 73, 76, 79, 82, 85, 88, 90, 94, 95, 98, 100,
102, 104, 106, 107, 110, 110, 112, 114, 116, 115, 116, 118, 118, 118, 119, 119,
119, 119, 118, 118, 117, 118, 116, 116, 115, 114, 112, 111, 110, 108, 107, 105,
103, 101, 99, 97, 95, 92, 89, 88, 85, 83, 80, 77, 75, 72, 69, 66, 63, 60, 58,
56, 53, 50, 47, 44, 42, 38, 35, 34, 30, 27, 25, 23, 20, 17, 14, 12, 10, 7, 5, 2,
0, -3, -4, -7, -9, -11, -14, -16, -18, -20, -22, -23, -26, -28, -29, -31, -33,
-34, -36, -37, -39, -40, -41, -42, -43, -44, -45, -46, -47, -47, -47, -48, -49,
-48, -49, -48, -48, -48, -47, -47, -46, -46, -45, -44, -43, -42, -41, -40, -38,
-36, -35, -34, -32, -30, -29, -27, -25, -23, -21, -21, -18, -16, -15, -13, -11,
-9, -7, -6, -5, -2, -1, 1, 3, 4, 7, 8, 9, 11, 12, 15, 16, 18, 20, 21, 22, 24,
25, 28, 28, 30, 31, 34, 35, 36, 37, 38, 40, 41, 43, 44, 46, 48, 49, 51, 52, 53,
54, 56, 58, 59, 61, 63, 64, 65, 67, 69, 70, 71, 73, 75, 76, 77, 79, 81, 81, 83,
86, 87, 88, 90, 90, 92, 94, 94, 96, 97, 99, 101, 102, 103, 103, 106, 107, 107,
109, 110, 111, 111, 113, 113, 114, 114, 115, 116, 117, 117, 117, 118, 119, 119,
118, 119, 120, 119, 119, 119, 119, 118, 117, 118, 116, 115, 116, 113, 114, 113,
110, 109, 108, 106, 104, 103, 101, 99, 97, 93, 91, 88, 86, 83, 80, 76, 72, 69,
65, 61, 57, 53, 48, 44, 40, 34, 29, 25, 19, 15, 10, 4, -1, -6, -11, -16, -21,
-26, -30, -35, -41, -45, -48, -54, -57, -62, -67, -69, -73, -76, -79, -82, -86,
-89, -91, -93, -95, -97, -100, -101, -102, -104, -105, -106, -108, -109, -109,
-110, -111, -111, -111, -111, -111, -111, -111, -110, -111, -110, -110, -108,
-108, -107, -107, -105, -106, -104, -104, -102, -102, -101, -99, -98, -96, -96,
-94, -93, -93, -91, -90, -89, -87, -87, -85, -85, -83, -82, -81, -80, -79, -78,
-76, -76, -74, -74, -73, -73, -72, -71, -70, -70, -70, -69, -68, -69, -68, -68,
-68, -67, -68, -68, -67, -67, -68, -67, -68, -68, -68, -68, -68, -69, -68, -70,
-70, -70, -70, -70, -71, -71, -71, -72, -72, -74, -74, -74, -74, -75, -75, -75,
-75, -77, -77, -77, -78, -78, -78, -79, -79, -80, -79, -80, -82, -80, -81, -82,
-82, -83, -83, -83, -84, -85, -84, -85, -86, -85, -87, -86, -86, -86, -87, -87,
-88, -88, -86, -87, -86, -86, -87, -86, -85, -84, -83, -82, -81, -81, -80, -79,
-77, -76, -74, -72, -71, -69, -67, -65, -63, -61, -58, -56, -53, -51, -48, -45,
-42, -39, -36, -33, -29, -26, -21, -18, -14, -11, -6, -3, };