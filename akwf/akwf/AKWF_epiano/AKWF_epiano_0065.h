#define DATA_LENGTH 512
#define DATA AKWF_epiano_0065

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 13, 16, 18, 21, 23, 27,
30, 32, 35, 37, 39, 42, 45, 47, 49, 51, 53, 54, 57, 58, 60, 62, 63, 65, 67, 69,
70, 71, 73, 74, 76, 76, 78, 79, 80, 81, 81, 83, 83, 84, 84, 85, 86, 86, 86, 87,
88, 88, 88, 88, 88, 89, 89, 90, 90, 90, 90, 90, 90, 90, 89, 89, 89, 89, 88, 89,
88, 87, 88, 87, 87, 87, 87, 86, 85, 86, 84, 83, 84, 83, 82, 83, 82, 81, 80, 80,
80, 78, 78, 78, 78, 77, 76, 76, 76, 75, 74, 75, 73, 73, 72, 72, 73, 71, 71, 70,
71, 70, 70, 69, 68, 68, 68, 66, 66, 66, 64, 64, 63, 62, 62, 61, 59, 59, 57, 57,
55, 54, 53, 52, 51, 49, 49, 47, 46, 45, 44, 41, 40, 39, 37, 36, 34, 34, 32, 30,
29, 27, 27, 26, 23, 23, 21, 20, 18, 18, 16, 15, 14, 12, 12, 10, 10, 8, 7, 6, 6,
5, 4, 4, 2, 2, 2, 1, 0, 0, 0, -1, -1, 0, 0, -2, -1, -1, -1, -1, -1, 0, 0, 1, 1,
1, 2, 2, 3, 3, 3, 5, 5, 6, 7, 8, 9, 10, 10, 12, 13, 14, 16, 17, 18, 19, 20, 22,
23, 24, 25, 27, 28, 30, 32, 33, 34, 35, 37, 39, 40, 41, 43, 44, 46, 48, 49, 51,
52, 54, 55, 57, 59, 60, 60, 63, 63, 66, 67, 68, 69, 70, 71, 72, 73, 75, 75, 77,
78, 79, 79, 80, 80, 80, 81, 80, 82, 81, 81, 81, 81, 81, 80, 80, 80, 79, 79, 77,
76, 74, 74, 72, 71, 70, 68, 66, 65, 62, 60, 59, 56, 55, 51, 49, 47, 44, 41, 40,
37, 33, 32, 28, 26, 23, 21, 17, 15, 11, 9, 6, 3, 0, -3, -5, -8, -10, -13, -15,
-18, -20, -22, -24, -27, -30, -32, -33, -35, -37, -39, -41, -42, -45, -45, -47,
-48, -50, -51, -53, -54, -55, -56, -58, -59, -60, -60, -61, -62, -63, -63, -64,
-65, -65, -67, -67, -67, -68, -69, -70, -69, -70, -70, -70, -72, -71, -72, -72,
-73, -74, -74, -74, -75, -74, -75, -76, -76, -77, -77, -78, -78, -78, -78, -79,
-81, -81, -81, -82, -82, -83, -84, -85, -85, -86, -86, -87, -88, -89, -89, -91,
-90, -91, -92, -93, -94, -94, -96, -96, -97, -97, -98, -99, -99, -100, -101,
-101, -102, -102, -102, -104, -104, -104, -105, -106, -106, -107, -108, -107,
-108, -109, -109, -110, -111, -110, -110, -112, -112, -111, -113, -113, -113,
-114, -115, -115, -115, -115, -117, -117, -117, -118, -118, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -118, -117, -116, -116,
-115, -113, -112, -111, -110, -108, -108, -106, -104, -102, -101, -99, -97, -95,
-92, -90, -88, -86, -83, -81, -78, -75, -72, -70, -67, -64, -61, -58, -55, -52,
-49, -47, -44, -40, -37, -34, -31, -28, -25, -22, -19, -16, -12, -10, -7, -4,
-1, };