#define DATA_LENGTH 512
#define DATA AKWF_epiano_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 3, 4, 4, 6, 6, 7, 9, 10, 10,
11, 12, 13, 15, 15, 15, 17, 18, 19, 19, 21, 21, 23, 23, 24, 25, 26, 27, 28, 29,
29, 30, 31, 32, 34, 34, 36, 36, 36, 38, 39, 39, 41, 41, 43, 43, 44, 45, 47, 47,
47, 48, 50, 51, 51, 53, 53, 54, 56, 55, 58, 57, 59, 59, 61, 61, 62, 63, 64, 65,
65, 67, 67, 69, 69, 70, 71, 72, 73, 73, 74, 75, 75, 77, 77, 78, 80, 81, 81, 82,
83, 82, 84, 85, 86, 87, 87, 87, 88, 89, 89, 90, 91, 92, 91, 94, 93, 94, 95, 96,
96, 95, 97, 98, 99, 99, 99, 100, 100, 100, 102, 101, 102, 102, 102, 102, 103,
103, 104, 103, 104, 104, 104, 104, 104, 104, 103, 104, 103, 103, 103, 103, 103,
103, 102, 102, 103, 102, 101, 100, 99, 100, 99, 98, 98, 97, 96, 95, 94, 94, 93,
92, 91, 89, 89, 87, 86, 85, 83, 81, 80, 79, 78, 75, 74, 73, 71, 70, 68, 65, 64,
62, 60, 58, 56, 55, 52, 50, 47, 45, 43, 42, 40, 38, 36, 34, 31, 29, 28, 26, 24,
21, 20, 17, 16, 14, 11, 10, 9, 6, 5, 4, 3, 1, 0, -2, -3, -4, -6, -6, -7, -8, -9,
-10, -11, -11, -11, -12, -13, -13, -14, -14, -13, -15, -13, -14, -14, -14, -14,
-13, -14, -13, -13, -12, -11, -11, -11, -11, -10, -9, -9, -7, -7, -7, -6, -6,
-5, -3, -3, -2, -2, -2, 0, 1, 1, 2, 2, 4, 4, 4, 6, 6, 6, 7, 8, 9, 9, 9, 9, 10,
10, 10, 11, 11, 10, 11, 10, 12, 11, 11, 10, 10, 10, 10, 8, 8, 8, 7, 6, 7, 5, 4,
3, 2, 1, 0, -2, -3, -4, -6, -7, -9, -10, -11, -14, -15, -17, -20, -21, -22, -25,
-27, -29, -31, -33, -36, -38, -40, -42, -44, -47, -49, -51, -54, -56, -58, -61,
-62, -65, -67, -70, -72, -74, -76, -78, -80, -83, -84, -87, -88, -91, -92, -94,
-95, -98, -99, -101, -103, -104, -106, -107, -108, -109, -110, -111, -112, -113,
-113, -115, -116, -117, -117, -117, -118, -119, -118, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -118, -117, -116, -117, -117, -116,
-115, -114, -114, -113, -112, -111, -111, -110, -109, -108, -107, -106, -105,
-104, -104, -102, -101, -101, -100, -99, -97, -97, -95, -95, -93, -92, -91, -90,
-90, -88, -87, -85, -85, -84, -83, -82, -80, -79, -79, -78, -76, -75, -74, -74,
-72, -70, -70, -69, -67, -65, -65, -64, -63, -63, -61, -60, -58, -58, -56, -55,
-54, -53, -53, -51, -50, -49, -47, -47, -46, -45, -44, -42, -42, -41, -41, -39,
-38, -36, -36, -35, -34, -32, -31, -31, -31, -29, -28, -27, -26, -25, -24, -23,
-23, -22, -20, -19, -19, -18, -17, -17, -15, -14, -13, -12, -11, -10, -9, -9,
-9, -7, -6, -5, -4, -3, -2, -1, 0, };