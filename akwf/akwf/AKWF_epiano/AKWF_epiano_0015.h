#define DATA_LENGTH 512
#define DATA AKWF_epiano_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 2, 4, 4, 5, 5, 5, 6, 6, 7, 7,
7, 8, 9, 10, 12, 13, 14, 16, 18, 20, 22, 22, 23, 25, 26, 28, 27, 27, 28, 28, 29,
29, 29, 30, 30, 31, 31, 32, 33, 34, 37, 39, 41, 43, 43, 46, 48, 48, 49, 50, 52,
52, 51, 52, 52, 53, 53, 53, 54, 54, 55, 57, 58, 58, 61, 63, 64, 67, 68, 71, 71,
73, 73, 75, 76, 76, 77, 76, 77, 77, 77, 77, 76, 77, 78, 80, 81, 82, 83, 86, 87,
88, 90, 92, 93, 95, 95, 97, 97, 96, 97, 97, 97, 97, 98, 97, 97, 98, 98, 99, 100,
100, 101, 105, 105, 107, 108, 109, 111, 111, 112, 113, 113, 113, 113, 113, 112,
112, 112, 111, 110, 111, 110, 111, 112, 112, 112, 114, 115, 116, 116, 118, 118,
119, 119, 119, 119, 117, 116, 117, 115, 115, 114, 112, 112, 110, 111, 111, 110,
110, 110, 110, 111, 112, 112, 111, 112, 112, 112, 111, 110, 109, 107, 106, 104,
102, 101, 98, 97, 96, 95, 94, 93, 93, 92, 92, 92, 91, 90, 90, 90, 88, 87, 86,
85, 82, 80, 79, 76, 75, 72, 70, 67, 65, 64, 62, 59, 59, 57, 57, 56, 55, 54, 53,
51, 50, 48, 46, 44, 42, 39, 36, 33, 31, 27, 25, 22, 20, 17, 16, 14, 11, 10, 9,
7, 6, 5, 3, 2, 1, -1, -2, -5, -7, -10, -12, -15, -18, -21, -23, -26, -28, -30,
-32, -34, -36, -36, -38, -38, -40, -42, -41, -43, -44, -44, -47, -48, -50, -52,
-54, -56, -57, -60, -61, -64, -64, -66, -67, -69, -69, -70, -71, -70, -71, -72,
-72, -72, -73, -73, -74, -75, -75, -76, -77, -78, -79, -80, -82, -82, -83, -84,
-85, -85, -86, -86, -85, -86, -87, -86, -86, -85, -85, -86, -86, -86, -86, -85,
-85, -86, -87, -87, -87, -87, -88, -89, -89, -89, -89, -89, -89, -90, -90, -89,
-89, -89, -88, -88, -88, -87, -86, -86, -86, -87, -86, -87, -87, -87, -87, -88,
-88, -88, -87, -87, -87, -87, -87, -87, -86, -86, -85, -85, -84, -85, -84, -83,
-82, -84, -83, -83, -83, -82, -83, -82, -83, -82, -82, -81, -81, -82, -81, -80,
-79, -79, -78, -78, -78, -77, -77, -77, -77, -76, -76, -76, -76, -76, -76, -75,
-76, -76, -76, -76, -75, -75, -75, -74, -74, -74, -73, -72, -72, -72, -72, -71,
-71, -71, -70, -70, -70, -70, -70, -70, -70, -70, -69, -70, -69, -69, -69, -69,
-68, -67, -67, -66, -65, -64, -64, -62, -62, -62, -61, -61, -61, -61, -61, -61,
-60, -60, -59, -59, -59, -58, -57, -56, -55, -54, -53, -52, -52, -50, -49, -48,
-46, -47, -45, -44, -44, -44, -43, -43, -43, -43, -42, -41, -40, -40, -39, -38,
-37, -35, -34, -32, -31, -29, -28, -27, -25, -25, -23, -23, -22, -21, -20, -20,
-19, -19, -18, -18, -17, -17, -15, -13, -13, -11, -10, -9, -6, -4, -2, -1, };