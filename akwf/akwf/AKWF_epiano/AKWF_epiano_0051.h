#define DATA_LENGTH 512
#define DATA AKWF_epiano_0051

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 10, 14, 18, 22, 27, 32, 37, 42,
47, 51, 56, 61, 65, 69, 73, 76, 79, 83, 86, 89, 91, 94, 96, 98, 99, 102, 103,
104, 105, 106, 106, 107, 107, 107, 107, 108, 107, 107, 107, 106, 106, 105, 104,
104, 103, 101, 100, 100, 98, 96, 94, 93, 91, 89, 88, 85, 84, 82, 79, 76, 74, 72,
70, 67, 65, 61, 59, 56, 53, 51, 48, 44, 42, 38, 35, 32, 29, 27, 23, 20, 17, 14,
12, 9, 6, 3, 1, -1, -4, -6, -8, -10, -13, -14, -17, -17, -20, -21, -22, -24,
-24, -26, -26, -28, -29, -30, -31, -32, -32, -33, -34, -34, -35, -35, -37, -37,
-37, -38, -39, -40, -41, -42, -42, -43, -43, -44, -45, -46, -46, -46, -47, -47,
-48, -48, -48, -48, -48, -49, -48, -47, -47, -47, -46, -45, -45, -42, -41, -41,
-39, -37, -36, -33, -31, -28, -26, -24, -21, -18, -14, -12, -10, -6, -4, -1, 3,
5, 8, 11, 13, 15, 17, 18, 20, 22, 23, 24, 26, 26, 28, 28, 29, 29, 30, 30, 32,
31, 32, 32, 33, 33, 33, 33, 35, 34, 35, 36, 35, 36, 36, 37, 39, 39, 39, 40, 40,
42, 42, 43, 44, 44, 46, 46, 47, 47, 49, 49, 50, 52, 53, 54, 54, 56, 57, 58, 60,
60, 62, 64, 64, 65, 66, 68, 69, 71, 72, 73, 74, 75, 77, 78, 80, 80, 81, 81, 83,
84, 85, 86, 87, 88, 89, 89, 89, 90, 91, 91, 91, 92, 92, 92, 92, 93, 93, 93, 92,
92, 92, 91, 90, 91, 90, 90, 89, 89, 87, 88, 86, 85, 84, 83, 82, 81, 79, 78, 77,
74, 73, 71, 70, 68, 66, 63, 61, 58, 55, 53, 50, 47, 44, 39, 35, 32, 27, 23, 20,
14, 10, 5, -1, -5, -11, -17, -22, -29, -33, -40, -46, -53, -58, -65, -71, -76,
-81, -86, -91, -97, -100, -105, -108, -111, -114, -116, -117, -119, -119, -119,
-119, -119, -117, -117, -115, -113, -112, -109, -107, -104, -102, -98, -96, -94,
-92, -89, -86, -84, -83, -80, -78, -75, -75, -72, -69, -68, -67, -64, -64, -63,
-61, -59, -58, -56, -55, -54, -52, -52, -50, -48, -48, -47, -46, -44, -44, -42,
-42, -41, -40, -39, -39, -38, -37, -37, -36, -35, -35, -35, -34, -34, -34, -34,
-34, -33, -34, -33, -33, -34, -35, -35, -36, -36, -36, -37, -38, -38, -39, -39,
-41, -42, -42, -44, -45, -45, -46, -48, -47, -49, -49, -50, -51, -51, -53, -53,
-54, -54, -55, -55, -56, -56, -56, -56, -56, -57, -57, -57, -58, -58, -58, -58,
-58, -58, -58, -58, -59, -58, -58, -58, -58, -58, -59, -58, -59, -58, -59, -59,
-59, -60, -60, -61, -61, -61, -62, -62, -64, -63, -63, -64, -65, -66, -66, -67,
-67, -67, -66, -67, -68, -67, -66, -65, -65, -63, -62, -60, -58, -56, -54, -51,
-48, -47, -43, -41, -37, -35, -32, -28, -25, -22, -19, -16, -12, -9, -5, -2, };