#define DATA_LENGTH 512
#define DATA AKWF_epiano_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 10, 16, 17, 19, 21, 21, 23, 22,
22, 22, 23, 23, 23, 24, 26, 27, 29, 31, 34, 37, 40, 45, 49, 54, 60, 65, 70, 75,
79, 84, 86, 88, 89, 89, 89, 88, 88, 86, 86, 88, 88, 89, 91, 92, 96, 97, 100,
101, 101, 102, 102, 102, 101, 100, 99, 98, 95, 94, 92, 89, 84, 80, 76, 71, 66,
60, 54, 47, 41, 35, 28, 21, 15, 9, 1, -4, -10, -18, -23, -28, -31, -35, -40,
-42, -44, -45, -47, -48, -49, -51, -53, -53, -55, -57, -59, -59, -58, -59, -59,
-58, -55, -53, -52, -49, -50, -49, -49, -50, -55, -60, -65, -71, -79, -88, -97,
-104, -108, -113, -118, -119, -117, -115, -114, -110, -105, -101, -96, -92, -89,
-87, -85, -81, -80, -79, -76, -73, -71, -67, -63, -59, -55, -52, -49, -45, -45,
-44, -45, -45, -45, -44, -44, -43, -39, -33, -28, -22, -16, -10, -4, 1, 3, 4, 6,
7, 7, 5, 4, 2, 2, 1, -1, -2, -1, 0, 1, 3, 5, 8, 12, 14, 15, 13, 12, 9, 6, -1,
-9, -17, -22, -27, -30, -34, -37, -35, -33, -30, -28, -24, -19, -14, -10, -5, 0,
5, 10, 15, 18, 22, 24, 26, 23, 21, 19, 16, 10, 4, -1, -7, -12, -17, -22, -29,
-35, -41, -46, -52, -57, -63, -69, -73, -75, -78, -81, -81, -78, -77, -74, -68,
-59, -50, -41, -31, -22, -13, -3, 5, 8, 10, 13, 14, 10, 6, 3, 0, -5, -9, -12,
-16, -18, -17, -17, -15, -10, -5, 2, 9, 18, 27, 36, 44, 50, 54, 59, 62, 61, 59,
57, 55, 52, 50, 46, 42, 40, 38, 36, 34, 31, 29, 26, 24, 21, 17, 13, 10, 6, 2,
-1, -5, -8, -10, -12, -15, -17, -19, -21, -23, -26, -28, -31, -32, -35, -36,
-36, -37, -37, -36, -33, -31, -28, -24, -20, -16, -12, -8, -3, 1, 6, 8, 9, 13,
14, 14, 10, 8, 7, 4, 2, 2, -1, 1, 5, 9, 11, 14, 19, 23, 28, 28, 26, 26, 24, 20,
14, 7, 0, -6, -10, -16, -20, -23, -21, -20, -19, -16, -9, -3, 2, 10, 16, 20, 25,
30, 31, 31, 32, 32, 27, 22, 18, 13, 8, 0, -7, -14, -21, -27, -34, -41, -44, -45,
-48, -50, -48, -44, -41, -38, -34, -30, -26, -23, -21, -21, -21, -20, -21, -20,
-21, -21, -18, -14, -11, -7, 0, 8, 16, 25, 32, 40, 48, 56, 61, 64, 66, 67, 69,
65, 61, 59, 56, 52, 49, 45, 43, 42, 41, 41, 40, 40, 42, 42, 43, 43, 44, 44, 44,
44, 43, 43, 43, 41, 38, 35, 32, 26, 19, 12, 5, -2, -11, -20, -29, -36, -42, -49,
-57, -61, -63, -66, -69, -69, -65, -62, -59, -52, -43, -33, -24, -13, 1, 13, 26,
38, 46, 55, 63, 70, 70, 70, 72, 70, 64, 57, 51, 45, 36, 27, 18, 11, 4, -2, -9,
-13, -16, -16, -19, -18, -15, -11, -7, -3, };