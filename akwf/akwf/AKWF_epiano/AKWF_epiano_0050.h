#define DATA_LENGTH 512
#define DATA AKWF_epiano_0050

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 8, 11, 15, 19, 24, 26, 30, 34,
38, 41, 45, 49, 52, 57, 60, 63, 67, 70, 73, 77, 79, 83, 85, 87, 90, 93, 95, 98,
99, 101, 103, 106, 108, 109, 110, 111, 112, 113, 114, 115, 117, 116, 118, 118,
118, 118, 119, 119, 119, 120, 119, 119, 118, 119, 118, 118, 118, 117, 117, 117,
115, 114, 114, 114, 114, 112, 112, 111, 110, 110, 108, 108, 107, 106, 105, 104,
103, 102, 101, 100, 99, 98, 97, 96, 95, 94, 93, 92, 91, 90, 89, 87, 86, 85, 85,
83, 82, 81, 80, 78, 77, 76, 75, 74, 72, 72, 70, 70, 68, 66, 66, 64, 62, 61, 60,
59, 58, 56, 56, 54, 53, 51, 50, 49, 48, 47, 45, 43, 42, 41, 40, 39, 38, 37, 36,
33, 32, 31, 30, 28, 28, 26, 25, 25, 23, 22, 21, 20, 19, 18, 17, 16, 16, 16, 14,
13, 12, 12, 12, 11, 10, 10, 10, 9, 8, 8, 7, 7, 8, 7, 6, 6, 5, 5, 6, 4, 5, 4, 4,
4, 4, 3, 2, 3, 2, 2, 1, 2, 1, 1, 1, 0, -1, 0, -1, 0, -1, -1, -2, -2, -1, -2, -3,
-3, -3, -3, -3, -4, -3, -4, -4, -3, -3, -3, -4, -3, -4, -4, -3, -4, -4, -4, -4,
-3, -3, -3, -4, -3, -3, -3, -3, -2, -2, -1, -2, -2, -1, -1, -1, 0, -1, -1, 0,
-1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 0, 0, 1, 0, 0, -1, 0, 0, 0,
-1, -1, -2, -3, -2, -3, -3, -4, -4, -5, -4, -5, -6, -7, -7, -8, -9, -9, -10,
-11, -11, -13, -13, -14, -15, -16, -17, -17, -19, -20, -21, -23, -22, -24, -25,
-26, -28, -30, -30, -32, -33, -34, -36, -37, -38, -40, -40, -43, -44, -45, -47,
-47, -50, -51, -52, -53, -55, -56, -58, -59, -60, -62, -63, -63, -64, -66, -66,
-67, -68, -69, -70, -69, -70, -71, -71, -71, -71, -71, -71, -71, -71, -70, -69,
-69, -68, -67, -67, -65, -65, -65, -63, -63, -62, -61, -60, -59, -58, -57, -56,
-55, -54, -53, -52, -51, -50, -49, -49, -47, -47, -47, -46, -45, -45, -44, -44,
-44, -43, -42, -43, -43, -43, -43, -42, -43, -42, -43, -43, -42, -44, -43, -45,
-44, -44, -44, -45, -46, -46, -46, -47, -47, -49, -50, -50, -51, -51, -53, -53,
-54, -54, -54, -56, -57, -57, -58, -59, -59, -60, -61, -62, -62, -63, -64, -64,
-64, -66, -67, -67, -68, -68, -69, -69, -70, -70, -70, -70, -71, -71, -73, -73,
-72, -72, -73, -73, -73, -73, -73, -73, -73, -73, -73, -73, -73, -72, -73, -72,
-72, -71, -71, -71, -70, -70, -69, -69, -69, -67, -67, -66, -66, -65, -63, -63,
-62, -61, -60, -59, -58, -57, -56, -55, -53, -52, -50, -49, -48, -45, -44, -42,
-40, -37, -36, -34, -31, -28, -26, -24, -21, -18, -15, -11, -9, -4, -2, };