#define DATA_LENGTH 512
#define DATA AKWF_epiano_0046

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 16, 23, 30, 37, 44, 50, 58, 63,
71, 76, 81, 85, 90, 95, 99, 101, 104, 107, 110, 111, 113, 115, 116, 116, 118,
118, 119, 119, 119, 119, 120, 118, 119, 119, 119, 119, 117, 117, 116, 116, 115,
115, 114, 113, 112, 112, 111, 110, 110, 107, 106, 106, 104, 104, 102, 102, 100,
99, 97, 96, 95, 93, 92, 90, 89, 87, 86, 84, 82, 81, 79, 78, 75, 74, 72, 71, 70,
68, 65, 64, 63, 61, 59, 57, 55, 54, 52, 51, 49, 47, 46, 44, 43, 40, 39, 37, 36,
34, 32, 31, 29, 28, 27, 24, 23, 21, 19, 19, 17, 15, 14, 12, 11, 10, 7, 6, 4, 3,
1, 0, 0, -2, -4, -5, -6, -7, -8, -9, -11, -13, -13, -14, -15, -17, -18, -19,
-21, -21, -23, -23, -23, -25, -26, -27, -27, -29, -29, -30, -31, -31, -32, -34,
-34, -34, -36, -37, -39, -40, -41, -43, -43, -46, -46, -47, -48, -49, -49, -49,
-49, -49, -49, -47, -46, -45, -42, -41, -39, -37, -35, -34, -32, -31, -29, -27,
-27, -26, -25, -24, -24, -23, -22, -22, -23, -22, -22, -21, -21, -20, -21, -21,
-20, -21, -19, -19, -20, -19, -19, -19, -19, -19, -18, -19, -19, -18, -18, -17,
-18, -17, -17, -16, -16, -15, -15, -15, -14, -14, -13, -13, -11, -12, -11, -10,
-9, -9, -8, -8, -7, -7, -7, -5, -6, -5, -4, -5, -3, -4, -3, -3, -2, -1, -1, -1,
-1, -2, -1, -1, 0, -1, -1, 0, 0, -1, -1, -1, -2, -1, -1, -1, -3, -3, -3, -4, -3,
-4, -4, -5, -5, -6, -7, -7, -8, -9, -10, -10, -11, -12, -12, -13, -14, -14, -14,
-16, -17, -18, -18, -19, -20, -20, -21, -22, -23, -23, -24, -25, -25, -26, -28,
-29, -28, -30, -30, -31, -32, -33, -34, -35, -35, -36, -36, -38, -38, -38, -40,
-39, -39, -40, -40, -40, -40, -40, -39, -39, -37, -36, -35, -34, -33, -31, -29,
-26, -24, -22, -18, -15, -13, -9, -6, -4, -1, 1, 4, 6, 8, 10, 13, 14, 15, 16,
17, 18, 19, 20, 21, 22, 22, 22, 23, 23, 23, 23, 22, 22, 22, 22, 22, 21, 21, 21,
20, 20, 19, 18, 18, 16, 16, 15, 15, 13, 13, 12, 10, 9, 8, 7, 6, 4, 4, 2, 0, -2,
-3, -5, -6, -7, -9, -12, -12, -14, -16, -18, -19, -22, -23, -24, -26, -28, -30,
-32, -33, -35, -36, -38, -40, -41, -42, -43, -44, -46, -47, -48, -49, -50, -50,
-52, -54, -54, -55, -56, -55, -56, -57, -58, -57, -58, -59, -58, -58, -58, -59,
-58, -59, -58, -59, -59, -58, -58, -58, -58, -57, -57, -56, -57, -57, -56, -56,
-55, -55, -55, -55, -54, -54, -53, -53, -52, -52, -52, -52, -51, -52, -52, -52,
-51, -51, -51, -50, -50, -50, -50, -51, -51, -51, -50, -51, -51, -50, -49, -48,
-47, -46, -45, -43, -40, -36, -33, -29, -25, -19, -14, -8, -2, };