#define DATA_LENGTH 512
#define DATA AKWF_epiano_0044

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 11, 15, 19, 24, 29, 32, 37, 40,
45, 49, 54, 58, 61, 65, 69, 72, 75, 80, 83, 85, 89, 91, 93, 96, 98, 101, 104,
105, 107, 109, 109, 111, 113, 114, 115, 116, 117, 118, 118, 118, 119, 119, 119,
119, 119, 119, 119, 118, 118, 117, 117, 116, 115, 114, 114, 112, 112, 110, 108,
107, 106, 105, 102, 102, 100, 99, 97, 95, 93, 93, 91, 88, 87, 85, 83, 81, 79,
77, 76, 74, 72, 70, 67, 65, 63, 62, 60, 58, 56, 54, 52, 51, 48, 47, 44, 43, 41,
39, 38, 35, 34, 32, 30, 28, 26, 24, 23, 22, 19, 18, 17, 16, 13, 13, 10, 9, 8, 7,
6, 4, 4, 2, 2, 1, -1, -2, -2, -4, -4, -4, -6, -6, -8, -7, -8, -9, -8, -9, -9,
-9, -10, -9, -10, -10, -10, -9, -9, -9, -9, -8, -8, -7, -6, -5, -5, -4, -3, -2,
-1, -1, 1, 2, 3, 5, 6, 7, 8, 10, 13, 14, 16, 17, 20, 21, 23, 24, 26, 28, 30, 31,
33, 36, 37, 39, 41, 42, 44, 45, 47, 48, 49, 50, 52, 53, 54, 56, 56, 57, 58, 59,
59, 60, 61, 62, 63, 62, 63, 64, 65, 64, 65, 65, 66, 65, 67, 67, 66, 67, 66, 67,
67, 67, 67, 68, 67, 68, 68, 69, 68, 68, 68, 67, 67, 68, 67, 68, 67, 66, 67, 66,
66, 66, 65, 66, 66, 65, 64, 64, 64, 63, 64, 63, 63, 61, 61, 60, 59, 59, 58, 57,
56, 56, 55, 55, 53, 51, 51, 51, 49, 48, 47, 46, 44, 43, 43, 41, 39, 39, 36, 35,
34, 32, 30, 29, 28, 26, 24, 22, 21, 19, 18, 17, 14, 12, 10, 8, 6, 5, 3, 0, -1,
-4, -6, -7, -8, -11, -14, -16, -18, -19, -22, -23, -26, -28, -30, -32, -34, -37,
-39, -41, -43, -45, -46, -49, -49, -51, -54, -55, -57, -58, -60, -61, -62, -63,
-64, -65, -67, -68, -68, -70, -70, -70, -71, -71, -71, -72, -72, -72, -72, -72,
-73, -72, -72, -72, -73, -73, -72, -72, -72, -73, -72, -72, -71, -71, -72, -71,
-73, -72, -72, -72, -72, -72, -72, -72, -73, -73, -73, -74, -73, -74, -74, -74,
-74, -75, -75, -76, -76, -76, -77, -76, -77, -78, -78, -79, -79, -80, -80, -81,
-81, -82, -82, -83, -83, -84, -85, -85, -85, -86, -87, -89, -89, -89, -89, -90,
-91, -91, -92, -93, -93, -94, -94, -95, -95, -96, -96, -96, -96, -97, -98, -97,
-98, -99, -99, -99, -99, -99, -99, -100, -100, -99, -99, -99, -100, -100, -99,
-100, -100, -100, -100, -99, -99, -99, -99, -99, -99, -98, -97, -96, -97, -97,
-96, -95, -95, -95, -94, -94, -92, -93, -92, -92, -90, -89, -89, -88, -87, -86,
-84, -84, -82, -82, -81, -78, -78, -76, -74, -72, -70, -69, -67, -65, -63, -60,
-59, -55, -52, -50, -47, -44, -41, -38, -36, -32, -28, -24, -21, -16, -13, -8,
-5, -1, };