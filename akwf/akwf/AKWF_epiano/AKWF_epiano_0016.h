#define DATA_LENGTH 512
#define DATA AKWF_epiano_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 14, 21, 28, 34, 40, 46, 51, 57,
62, 66, 70, 72, 74, 75, 76, 76, 75, 74, 73, 73, 72, 70, 70, 70, 70, 70, 72, 72,
74, 75, 77, 79, 79, 80, 80, 80, 81, 80, 81, 81, 81, 79, 79, 79, 79, 78, 78, 78,
77, 77, 77, 76, 74, 71, 69, 66, 62, 58, 55, 50, 46, 42, 39, 36, 32, 30, 27, 24,
23, 20, 18, 16, 12, 10, 5, 1, -3, -9, -13, -19, -27, -33, -40, -46, -53, -61,
-67, -73, -79, -83, -88, -94, -97, -102, -104, -108, -110, -113, -115, -117,
-118, -118, -118, -117, -116, -113, -112, -108, -104, -101, -97, -94, -90, -87,
-83, -81, -78, -76, -76, -75, -76, -77, -79, -80, -82, -84, -88, -91, -93, -95,
-99, -100, -100, -102, -102, -101, -99, -97, -95, -92, -88, -84, -78, -73, -66,
-58, -51, -42, -34, -25, -17, -7, 1, 9, 17, 27, 33, 39, 45, 51, 55, 58, 60, 61,
61, 60, 59, 57, 54, 49, 46, 41, 37, 31, 27, 24, 20, 17, 14, 13, 12, 11, 12, 13,
16, 20, 24, 30, 35, 43, 48, 56, 63, 70, 78, 84, 90, 96, 101, 105, 107, 110, 112,
113, 113, 113, 112, 110, 107, 104, 99, 94, 90, 83, 78, 72, 66, 59, 55, 50, 46,
41, 38, 35, 35, 35, 35, 38, 41, 45, 49, 53, 58, 64, 70, 76, 80, 85, 89, 92, 95,
98, 99, 101, 102, 103, 102, 101, 101, 99, 98, 96, 94, 92, 88, 85, 81, 77, 73,
69, 65, 60, 56, 54, 50, 48, 46, 46, 46, 48, 49, 51, 53, 55, 59, 62, 65, 68, 71,
72, 73, 74, 75, 75, 75, 74, 74, 73, 72, 70, 70, 70, 69, 68, 67, 66, 65, 64, 63,
62, 60, 58, 56, 53, 52, 49, 47, 44, 42, 41, 40, 39, 39, 37, 38, 37, 36, 36, 35,
33, 32, 30, 26, 23, 20, 16, 13, 10, 6, 3, 0, -2, -3, -5, -4, -5, -5, -4, -3, -2,
0, 1, 2, 3, 3, 3, 2, 2, 1, 1, -1, -2, -4, -5, -7, -9, -11, -14, -18, -21, -24,
-29, -34, -39, -45, -51, -55, -60, -67, -71, -75, -79, -82, -83, -85, -86, -86,
-83, -83, -79, -76, -73, -69, -64, -60, -56, -51, -48, -45, -41, -38, -37, -36,
-33, -34, -35, -35, -38, -40, -43, -47, -51, -56, -60, -68, -73, -80, -86, -92,
-97, -103, -108, -110, -114, -117, -118, -119, -118, -117, -115, -113, -109,
-104, -99, -94, -88, -81, -76, -68, -62, -57, -51, -45, -42, -39, -36, -35, -33,
-33, -33, -37, -38, -41, -46, -51, -56, -62, -68, -74, -79, -85, -89, -94, -98,
-102, -103, -105, -106, -106, -106, -105, -103, -99, -96, -92, -86, -81, -75,
-69, -62, -55, -49, -42, -36, -29, -24, -20, -14, -11, -8, -7, -6, -6, -8, -8,
-11, -14, -17, -22, -25, -29, -31, -34, -36, -39, -39, -39, -39, -38, -37, -35,
-33, -31, -28, -24, -21, -16, -12, -6, -2, };