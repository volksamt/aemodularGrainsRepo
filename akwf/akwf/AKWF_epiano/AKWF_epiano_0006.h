#define DATA_LENGTH 512
#define DATA AKWF_epiano_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 8, 18, 28, 36, 46, 55, 63, 72, 79,
87, 93, 98, 104, 109, 112, 114, 117, 118, 119, 120, 118, 118, 117, 114, 112,
110, 108, 105, 102, 99, 96, 93, 90, 88, 84, 82, 80, 76, 75, 72, 69, 67, 65, 63,
62, 59, 57, 55, 53, 51, 50, 49, 47, 45, 45, 43, 42, 41, 39, 39, 37, 36, 36, 34,
34, 33, 33, 32, 31, 31, 31, 29, 30, 28, 28, 28, 28, 27, 28, 27, 26, 27, 26, 26,
26, 26, 25, 24, 24, 25, 25, 24, 24, 24, 24, 23, 23, 23, 22, 22, 21, 22, 21, 21,
22, 20, 20, 20, 20, 19, 20, 19, 18, 19, 18, 18, 17, 18, 17, 17, 17, 17, 16, 16,
15, 16, 15, 14, 15, 15, 13, 13, 13, 13, 13, 13, 13, 13, 12, 11, 11, 12, 12, 11,
11, 11, 11, 10, 10, 10, 9, 9, 9, 9, 9, 9, 9, 8, 8, 8, 8, 8, 8, 8, 7, 7, 8, 7, 7,
7, 7, 7, 6, 7, 7, 7, 7, 6, 6, 7, 5, 6, 6, 5, 5, 5, 5, 5, 5, 5, 5, 4, 6, 5, 5, 4,
5, 5, 5, 5, 4, 4, 5, 4, 3, 4, 4, 3, 3, 3, 4, 4, 3, 2, 2, 3, 2, 3, 3, 2, 1, 2, 1,
1, 1, 0, 0, 1, 1, -1, 0, 0, 0, -1, -1, -1, -1, -2, -2, -1, -3, -2, -2, -3, -3,
-3, -4, -4, -3, -4, -4, -4, -5, -4, -5, -5, -5, -5, -6, -6, -5, -6, -6, -7, -7,
-7, -7, -7, -7, -7, -8, -9, -9, -9, -9, -9, -10, -10, -10, -10, -11, -10, -10,
-10, -11, -11, -11, -11, -11, -12, -11, -12, -12, -12, -12, -13, -12, -13, -12,
-12, -13, -13, -13, -13, -13, -14, -14, -14, -13, -14, -14, -13, -14, -14, -14,
-14, -14, -14, -15, -14, -14, -15, -14, -15, -15, -15, -15, -15, -15, -14, -16,
-15, -15, -15, -15, -15, -15, -15, -16, -15, -15, -16, -15, -16, -16, -15, -16,
-16, -15, -16, -16, -16, -17, -16, -16, -16, -16, -17, -16, -16, -17, -17, -17,
-17, -17, -17, -17, -17, -17, -17, -18, -17, -18, -18, -18, -18, -18, -18, -19,
-18, -19, -19, -20, -19, -20, -20, -19, -20, -21, -21, -20, -21, -21, -22, -21,
-22, -22, -22, -22, -24, -23, -23, -24, -24, -25, -25, -25, -26, -26, -26, -27,
-28, -28, -27, -29, -28, -29, -29, -30, -30, -30, -32, -32, -33, -33, -34, -35,
-35, -36, -36, -37, -38, -38, -39, -40, -40, -42, -42, -42, -43, -44, -45, -46,
-47, -49, -48, -50, -51, -52, -53, -54, -54, -56, -57, -57, -58, -59, -60, -61,
-62, -62, -64, -64, -65, -66, -67, -67, -68, -69, -70, -71, -72, -72, -73, -74,
-74, -74, -76, -75, -76, -77, -77, -79, -79, -78, -80, -80, -80, -81, -80, -79,
-80, -80, -79, -77, -77, -76, -73, -72, -68, -64, -61, -56, -52, -46, -40, -34,
-27, -19, -10, -3, };