#define DATA_LENGTH 512
#define DATA AKWF_epiano_0060

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 13, 17, 20, 24, 28, 31, 34,
39, 42, 45, 48, 51, 55, 59, 61, 65, 67, 70, 74, 76, 79, 82, 84, 87, 89, 91, 93,
96, 98, 100, 101, 103, 105, 106, 108, 110, 111, 112, 113, 115, 115, 115, 117,
118, 117, 118, 118, 119, 119, 120, 120, 119, 119, 118, 118, 118, 118, 117, 116,
116, 116, 115, 113, 112, 111, 110, 109, 108, 107, 106, 105, 104, 102, 100, 99,
98, 96, 94, 94, 90, 90, 88, 86, 84, 83, 81, 79, 76, 76, 74, 72, 70, 68, 66, 65,
63, 61, 59, 57, 55, 53, 52, 50, 48, 46, 44, 43, 41, 40, 38, 37, 35, 32, 32, 30,
28, 28, 25, 25, 23, 21, 20, 20, 18, 17, 16, 15, 13, 13, 12, 11, 10, 10, 9, 9, 8,
7, 7, 7, 5, 6, 5, 5, 5, 6, 5, 6, 6, 6, 6, 7, 7, 7, 8, 9, 10, 10, 11, 10, 12, 12,
14, 15, 15, 16, 18, 19, 20, 21, 22, 24, 24, 26, 26, 28, 29, 31, 31, 33, 35, 35,
37, 38, 39, 40, 41, 43, 43, 45, 46, 46, 49, 49, 50, 51, 52, 54, 54, 54, 55, 56,
57, 58, 59, 60, 61, 61, 62, 63, 64, 65, 65, 66, 67, 67, 67, 68, 68, 68, 69, 69,
70, 70, 70, 70, 70, 71, 70, 71, 71, 71, 70, 70, 71, 70, 71, 71, 70, 70, 71, 70,
70, 70, 68, 69, 69, 68, 68, 66, 65, 65, 65, 65, 64, 63, 63, 62, 61, 60, 59, 58,
57, 56, 56, 54, 53, 52, 50, 50, 48, 47, 47, 46, 44, 43, 41, 40, 39, 36, 35, 34,
32, 31, 29, 27, 26, 24, 22, 21, 19, 17, 15, 14, 13, 10, 8, 7, 5, 3, 0, -1, -3,
-4, -7, -8, -10, -12, -14, -15, -18, -19, -21, -23, -24, -26, -28, -29, -31,
-33, -35, -37, -38, -40, -42, -43, -44, -45, -47, -48, -51, -51, -52, -54, -55,
-56, -57, -58, -59, -60, -62, -62, -63, -64, -66, -67, -66, -68, -69, -70, -71,
-71, -72, -73, -73, -75, -75, -76, -77, -77, -78, -78, -79, -79, -80, -80, -81,
-82, -82, -82, -84, -85, -86, -85, -87, -86, -88, -89, -88, -90, -90, -91, -91,
-92, -92, -93, -93, -94, -94, -95, -95, -97, -97, -98, -99, -99, -99, -100,
-101, -102, -102, -103, -103, -104, -105, -104, -106, -107, -106, -107, -108,
-108, -109, -110, -109, -111, -112, -112, -112, -112, -113, -114, -114, -115,
-115, -115, -116, -116, -116, -116, -117, -118, -118, -117, -118, -118, -119,
-119, -119, -119, -118, -119, -119, -119, -118, -119, -118, -119, -118, -119,
-117, -118, -117, -117, -117, -116, -115, -115, -115, -115, -114, -113, -112,
-111, -110, -110, -109, -108, -106, -106, -104, -103, -101, -101, -99, -97, -96,
-94, -92, -90, -88, -87, -85, -82, -79, -78, -75, -73, -70, -67, -65, -62, -59,
-56, -52, -49, -47, -43, -40, -37, -33, -29, -25, -22, -20, -16, -13, -9, -5,
-1, };