#define DATA_LENGTH 512
#define DATA AKWF_epiano_0054

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 24, 37, 52, 64, 75, 84, 91, 98,
103, 106, 109, 110, 112, 114, 114, 114, 115, 115, 115, 116, 117, 116, 117, 117,
117, 118, 118, 120, 119, 119, 120, 119, 118, 119, 118, 119, 118, 118, 118, 116,
116, 116, 115, 115, 114, 113, 113, 112, 112, 111, 110, 110, 108, 107, 107, 105,
104, 104, 102, 100, 99, 99, 97, 95, 93, 92, 89, 87, 86, 83, 81, 79, 76, 74, 72,
68, 66, 64, 61, 58, 56, 54, 51, 49, 46, 44, 41, 39, 37, 35, 33, 31, 29, 27, 26,
24, 23, 22, 19, 19, 18, 17, 16, 15, 13, 13, 11, 10, 9, 8, 7, 6, 4, 2, 1, 0, -2,
-4, -5, -7, -9, -11, -13, -14, -17, -19, -21, -23, -25, -27, -30, -32, -34, -36,
-39, -41, -43, -45, -47, -50, -52, -53, -56, -57, -58, -61, -62, -63, -65, -66,
-68, -68, -69, -70, -71, -71, -72, -73, -74, -74, -75, -74, -74, -75, -73, -72,
-71, -68, -66, -63, -60, -58, -57, -55, -53, -52, -52, -50, -49, -48, -48, -49,
-48, -47, -47, -47, -45, -45, -44, -43, -43, -42, -41, -40, -39, -39, -38, -37,
-36, -36, -35, -35, -34, -33, -31, -31, -31, -30, -29, -28, -28, -27, -26, -26,
-25, -24, -23, -23, -22, -20, -20, -19, -18, -16, -16, -14, -13, -12, -10, -9,
-8, -6, -5, -3, -1, 0, 3, 3, 5, 8, 10, 12, 14, 16, 18, 20, 22, 24, 26, 29, 29,
32, 33, 36, 37, 38, 39, 42, 42, 44, 45, 47, 48, 48, 49, 49, 50, 50, 50, 50, 50,
51, 49, 50, 49, 48, 47, 48, 46, 45, 44, 43, 42, 40, 38, 38, 36, 35, 34, 32, 30,
27, 26, 24, 22, 20, 18, 16, 12, 11, 8, 6, 4, 2, -2, -4, -6, -9, -11, -15, -16,
-19, -22, -25, -27, -30, -34, -37, -39, -43, -46, -49, -53, -55, -59, -62, -66,
-68, -71, -74, -76, -80, -81, -83, -84, -84, -82, -79, -75, -69, -62, -54, -45,
-37, -29, -22, -15, -8, -3, 0, 3, 7, 8, 10, 11, 12, 13, 13, 13, 14, 14, 14, 15,
15, 15, 15, 16, 16, 16, 16, 17, 17, 17, 18, 18, 18, 18, 19, 19, 19, 20, 19, 20,
20, 22, 21, 22, 21, 21, 22, 22, 22, 21, 21, 21, 20, 21, 19, 19, 18, 17, 16, 15,
13, 11, 10, 8, 6, 4, 2, 0, -4, -7, -9, -11, -16, -18, -21, -24, -27, -31, -35,
-38, -41, -44, -46, -49, -52, -54, -57, -58, -61, -63, -64, -65, -67, -68, -69,
-69, -70, -71, -70, -71, -71, -71, -70, -70, -70, -69, -69, -68, -67, -65, -65,
-64, -63, -62, -62, -60, -59, -58, -56, -55, -54, -54, -52, -52, -50, -50, -49,
-48, -48, -47, -46, -46, -46, -46, -45, -45, -45, -45, -46, -46, -46, -48, -48,
-50, -51, -53, -54, -56, -59, -60, -63, -65, -68, -70, -71, -74, -76, -75, -75,
-74, -71, -67, -60, -53, -43, -31, -18, -4, };