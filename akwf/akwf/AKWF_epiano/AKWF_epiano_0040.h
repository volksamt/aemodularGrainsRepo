#define DATA_LENGTH 512
#define DATA AKWF_epiano_0040

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 13, 17, 21, 26, 29, 34, 37,
40, 45, 49, 53, 57, 61, 63, 68, 71, 75, 77, 81, 83, 87, 89, 91, 94, 97, 100,
100, 102, 104, 106, 108, 109, 111, 113, 113, 114, 115, 116, 117, 117, 117, 118,
118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 118, 118, 116, 116, 115,
115, 115, 113, 112, 113, 111, 110, 109, 108, 108, 108, 106, 105, 105, 103, 103,
101, 100, 100, 98, 97, 96, 95, 94, 93, 93, 91, 90, 89, 87, 86, 86, 85, 83, 82,
82, 81, 79, 78, 76, 76, 75, 74, 72, 71, 71, 69, 67, 67, 65, 64, 62, 62, 61, 59,
58, 57, 56, 54, 53, 53, 51, 49, 48, 48, 46, 44, 43, 43, 41, 39, 39, 37, 36, 35,
33, 33, 32, 30, 29, 28, 27, 26, 25, 24, 23, 22, 22, 20, 19, 17, 18, 17, 16, 15,
13, 13, 13, 12, 12, 11, 11, 10, 9, 9, 8, 8, 7, 7, 6, 7, 6, 5, 5, 4, 4, 4, 3, 3,
2, 2, 2, 0, 1, 0, 0, 0, -1, -2, -2, -3, -3, -4, -4, -4, -4, -4, -5, -5, -6, -5,
-6, -7, -6, -6, -7, -7, -7, -7, -7, -7, -8, -7, -6, -7, -7, -6, -6, -6, -6, -5,
-6, -5, -5, -5, -5, -5, -4, -4, -2, -3, -3, -2, -2, -2, 0, 0, 0, 0, 1, 0, 1, 1,
2, 3, 3, 3, 2, 3, 4, 4, 5, 5, 4, 5, 6, 6, 5, 6, 5, 6, 6, 6, 5, 6, 6, 5, 6, 5, 6,
5, 5, 5, 5, 4, 4, 4, 4, 3, 2, 2, 2, 1, 1, 0, -1, -1, -2, -3, -4, -4, -5, -6, -8,
-7, -9, -10, -11, -12, -14, -15, -15, -16, -19, -20, -21, -22, -24, -25, -27,
-28, -30, -31, -34, -35, -36, -38, -40, -42, -44, -44, -47, -49, -50, -52, -54,
-55, -57, -59, -60, -61, -63, -65, -66, -67, -69, -70, -70, -72, -73, -74, -74,
-75, -75, -76, -76, -77, -77, -77, -77, -76, -76, -75, -74, -74, -73, -73, -72,
-72, -71, -69, -68, -67, -66, -65, -64, -62, -62, -60, -59, -58, -57, -55, -54,
-54, -53, -51, -50, -50, -49, -48, -47, -47, -46, -45, -45, -44, -44, -44, -43,
-43, -43, -43, -43, -43, -43, -42, -43, -42, -43, -43, -43, -43, -44, -44, -45,
-45, -47, -47, -47, -48, -48, -50, -50, -51, -52, -53, -52, -53, -54, -55, -56,
-57, -58, -59, -60, -61, -61, -62, -63, -63, -64, -65, -66, -66, -68, -67, -68,
-69, -70, -70, -71, -71, -72, -72, -72, -73, -73, -73, -74, -74, -73, -75, -74,
-74, -74, -73, -74, -75, -74, -74, -73, -73, -73, -73, -72, -72, -71, -71, -70,
-69, -68, -68, -68, -68, -67, -65, -65, -65, -64, -63, -62, -61, -60, -59, -58,
-57, -56, -55, -52, -51, -50, -49, -47, -46, -44, -41, -40, -37, -35, -32, -30,
-28, -24, -21, -18, -15, -12, -9, -5, -1, };