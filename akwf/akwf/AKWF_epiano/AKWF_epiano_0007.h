#define DATA_LENGTH 512
#define DATA AKWF_epiano_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 2, 3, 3, 5, 6, 7, 8, 9, 11,
12, 13, 14, 16, 17, 20, 21, 23, 25, 25, 27, 30, 31, 33, 33, 35, 36, 38, 39, 41,
42, 42, 44, 45, 46, 47, 49, 50, 51, 52, 53, 54, 55, 57, 59, 59, 61, 62, 63, 65,
65, 67, 68, 69, 71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 81, 82, 83, 84, 85, 86,
87, 88, 88, 90, 90, 92, 92, 93, 94, 96, 95, 96, 98, 98, 99, 101, 100, 102, 102,
103, 103, 105, 105, 106, 106, 106, 106, 107, 108, 108, 109, 110, 110, 110, 111,
112, 112, 112, 113, 113, 113, 113, 114, 114, 115, 115, 115, 116, 116, 116, 116,
116, 117, 117, 117, 117, 116, 118, 117, 117, 117, 117, 116, 117, 117, 117, 116,
116, 116, 116, 116, 116, 115, 115, 115, 115, 114, 115, 114, 114, 114, 113, 113,
112, 112, 111, 112, 111, 111, 110, 109, 108, 108, 107, 107, 107, 106, 105, 104,
104, 103, 102, 102, 101, 100, 99, 99, 97, 96, 96, 95, 94, 94, 93, 92, 90, 90,
89, 88, 87, 86, 85, 84, 82, 82, 80, 79, 79, 78, 75, 75, 73, 73, 71, 69, 69, 68,
66, 66, 64, 63, 61, 60, 60, 58, 56, 55, 55, 53, 51, 50, 48, 47, 45, 44, 43, 41,
40, 38, 37, 36, 35, 33, 31, 30, 28, 27, 25, 24, 22, 21, 19, 17, 16, 15, 13, 12,
10, 9, 7, 5, 3, 2, 1, 0, -2, -4, -6, -7, -8, -9, -11, -13, -14, -16, -17, -18,
-20, -23, -23, -25, -26, -28, -29, -30, -32, -34, -35, -37, -38, -40, -41, -42,
-44, -46, -47, -48, -49, -51, -52, -54, -54, -56, -58, -59, -60, -62, -63, -64,
-66, -68, -69, -69, -71, -72, -73, -75, -76, -77, -77, -78, -80, -81, -83, -84,
-85, -85, -87, -88, -88, -90, -91, -92, -93, -94, -94, -96, -97, -97, -98, -99,
-100, -101, -101, -102, -103, -103, -104, -106, -106, -107, -107, -108, -108,
-110, -110, -110, -111, -112, -113, -113, -114, -114, -114, -114, -115, -115,
-116, -116, -115, -117, -116, -117, -118, -117, -117, -118, -118, -119, -118,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -118, -118, -117, -117, -117, -116, -117, -116, -115, -116,
-115, -114, -114, -114, -113, -114, -112, -113, -111, -111, -111, -110, -110,
-109, -108, -107, -107, -107, -106, -105, -104, -104, -103, -102, -101, -100,
-100, -98, -97, -97, -96, -95, -94, -93, -92, -91, -91, -89, -89, -88, -86, -86,
-85, -84, -83, -82, -81, -81, -78, -78, -77, -75, -74, -72, -72, -71, -69, -67,
-67, -65, -64, -62, -62, -60, -60, -58, -57, -56, -55, -53, -52, -51, -50, -49,
-48, -46, -45, -43, -42, -41, -40, -38, -37, -36, -34, -33, -31, -29, -27, -25,
-24, -22, -21, -19, -18, -16, -16, -14, -13, -11, -9, -8, -7, -7, -6, -5, -5,
-4, -3, -3, -1, -1, -2, -1, };