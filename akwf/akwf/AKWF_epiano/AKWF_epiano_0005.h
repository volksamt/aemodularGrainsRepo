#define DATA_LENGTH 512
#define DATA AKWF_epiano_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 2, 3, 3, 4, 5, 5, 6, 7, 7, 9, 9,
9, 10, 11, 11, 12, 12, 13, 13, 15, 15, 15, 16, 16, 17, 18, 19, 18, 18, 18, 19,
20, 19, 21, 20, 21, 21, 22, 22, 22, 22, 23, 22, 22, 23, 22, 23, 23, 23, 23, 23,
23, 23, 23, 23, 23, 23, 24, 23, 24, 24, 24, 25, 24, 25, 24, 24, 24, 25, 25, 25,
25, 25, 25, 26, 26, 26, 26, 26, 26, 27, 27, 27, 27, 28, 29, 29, 29, 29, 30, 30,
31, 32, 32, 32, 33, 34, 34, 34, 35, 36, 36, 36, 38, 38, 38, 40, 40, 42, 42, 42,
44, 44, 46, 47, 47, 48, 49, 51, 52, 53, 54, 56, 57, 57, 59, 60, 62, 63, 65, 66,
68, 69, 71, 72, 74, 75, 77, 78, 79, 82, 83, 84, 85, 87, 88, 90, 91, 91, 92, 93,
94, 95, 95, 97, 97, 98, 98, 99, 98, 99, 99, 99, 96, 95, 92, 88, 83, 79, 71, 63,
53, 42, 29, 16, 3, -11, -26, -39, -52, -65, -76, -85, -94, -99, -103, -107,
-108, -108, -108, -106, -103, -100, -96, -91, -88, -84, -81, -77, -74, -70, -68,
-65, -64, -60, -60, -59, -58, -57, -56, -55, -56, -55, -55, -55, -54, -55, -54,
-54, -53, -53, -53, -53, -53, -52, -52, -51, -50, -50, -50, -48, -48, -48, -46,
-47, -45, -45, -44, -43, -43, -42, -41, -41, -41, -40, -38, -39, -39, -38, -37,
-37, -36, -35, -35, -34, -35, -34, -33, -33, -33, -32, -32, -32, -30, -31, -29,
-29, -29, -29, -28, -28, -28, -26, -26, -26, -25, -23, -23, -23, -22, -21, -21,
-19, -18, -18, -17, -16, -15, -15, -14, -13, -12, -11, -10, -9, -8, -7, -6, -6,
-4, -3, -2, -1, 0, 0, 2, 3, 4, 4, 6, 7, 8, 9, 9, 11, 12, 12, 14, 15, 15, 17, 17,
18, 18, 20, 20, 22, 22, 24, 23, 25, 26, 26, 28, 29, 30, 31, 31, 32, 34, 34, 36,
37, 38, 38, 39, 41, 42, 43, 44, 45, 47, 47, 49, 49, 51, 53, 54, 54, 56, 57, 58,
60, 61, 63, 64, 65, 66, 68, 69, 70, 72, 72, 74, 75, 76, 77, 78, 78, 78, 78, 77,
75, 74, 70, 65, 59, 52, 43, 34, 24, 11, -2, -15, -28, -43, -55, -68, -79, -89,
-97, -105, -111, -115, -118, -119, -120, -118, -116, -112, -109, -105, -101,
-97, -94, -90, -87, -84, -80, -78, -75, -73, -72, -69, -68, -67, -65, -65, -62,
-62, -60, -60, -59, -58, -57, -56, -55, -54, -52, -51, -51, -50, -48, -47, -47,
-45, -44, -42, -41, -41, -39, -38, -37, -36, -35, -34, -34, -33, -32, -31, -30,
-29, -29, -28, -28, -26, -26, -26, -24, -24, -22, -22, -22, -21, -20, -20, -19,
-18, -19, -17, -17, -17, -17, -16, -15, -16, -14, -14, -14, -13, -13, -13, -11,
-11, -10, -10, -9, -9, -8, -7, -6, -6, -6, -5, -4, -3, -3, -3, -1, -1, };