#define DATA_LENGTH 512
#define DATA AKWF_epiano_0069

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 5, 10, 14, 17, 23, 25, 30, 34,
37, 41, 45, 48, 52, 56, 59, 62, 65, 68, 72, 75, 78, 81, 84, 86, 88, 91, 94, 96,
98, 100, 103, 104, 105, 108, 109, 111, 112, 113, 114, 114, 115, 117, 118, 118,
118, 118, 119, 120, 118, 119, 120, 118, 119, 118, 117, 117, 116, 115, 115, 112,
112, 111, 110, 108, 107, 106, 104, 103, 101, 100, 97, 95, 94, 92, 90, 88, 86,
85, 82, 81, 78, 76, 74, 72, 70, 68, 65, 63, 61, 59, 56, 54, 52, 50, 48, 45, 42,
41, 39, 36, 34, 32, 30, 28, 26, 24, 22, 20, 18, 16, 13, 12, 10, 9, 7, 5, 4, 2,
0, 0, -2, -3, -6, -7, -8, -9, -10, -11, -11, -13, -13, -14, -15, -15, -16, -16,
-16, -17, -17, -17, -16, -16, -16, -17, -16, -15, -15, -15, -14, -13, -12, -11,
-11, -10, -8, -6, -6, -5, -3, -3, 0, 0, 1, 3, 4, 7, 8, 9, 12, 14, 15, 16, 18,
19, 21, 22, 24, 25, 27, 29, 30, 31, 33, 35, 36, 37, 39, 41, 41, 44, 45, 47, 48,
48, 50, 51, 53, 54, 56, 57, 58, 59, 60, 62, 63, 64, 65, 65, 67, 68, 69, 70, 71,
72, 73, 74, 75, 77, 76, 77, 79, 79, 80, 82, 82, 83, 83, 83, 84, 84, 85, 86, 87,
87, 88, 88, 89, 89, 90, 90, 91, 91, 91, 91, 92, 91, 91, 92, 92, 92, 92, 91, 91,
92, 91, 91, 90, 90, 89, 88, 88, 88, 88, 86, 86, 84, 84, 83, 82, 81, 80, 79, 77,
77, 75, 74, 72, 70, 69, 67, 65, 63, 62, 60, 58, 55, 54, 52, 48, 46, 44, 41, 39,
35, 33, 30, 27, 25, 21, 19, 15, 13, 9, 7, 3, 0, -3, -6, -9, -12, -15, -19, -22,
-25, -28, -31, -34, -38, -40, -43, -45, -48, -50, -54, -56, -58, -61, -62, -65,
-67, -69, -70, -73, -73, -75, -78, -78, -80, -81, -82, -83, -84, -85, -86, -86,
-87, -87, -89, -89, -90, -91, -91, -91, -91, -91, -93, -93, -93, -93, -93, -94,
-93, -93, -93, -93, -92, -93, -92, -92, -93, -93, -93, -92, -93, -92, -92, -93,
-92, -92, -92, -93, -92, -92, -92, -91, -92, -92, -92, -92, -93, -92, -92, -92,
-93, -93, -93, -94, -93, -94, -94, -95, -94, -94, -95, -95, -95, -96, -97, -96,
-97, -97, -98, -98, -99, -99, -99, -100, -100, -101, -101, -101, -101, -102,
-102, -103, -103, -103, -103, -103, -104, -104, -105, -105, -104, -105, -104,
-105, -104, -105, -106, -105, -106, -106, -106, -107, -106, -106, -106, -106,
-106, -105, -105, -105, -105, -106, -105, -105, -105, -104, -104, -103, -103,
-103, -103, -102, -102, -100, -100, -100, -99, -98, -98, -96, -96, -94, -93,
-91, -90, -89, -88, -86, -84, -82, -80, -78, -76, -74, -72, -70, -67, -64, -62,
-59, -56, -54, -50, -47, -44, -41, -37, -34, -30, -27, -23, -20, -16, -12, -8,
-4, 0, };