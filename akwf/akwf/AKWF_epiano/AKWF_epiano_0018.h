#define DATA_LENGTH 512
#define DATA AKWF_epiano_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 10, 14, 19, 24, 28, 32, 37, 41,
46, 50, 55, 58, 62, 66, 70, 74, 77, 81, 85, 87, 91, 94, 96, 99, 101, 104, 105,
108, 109, 111, 112, 113, 115, 115, 117, 118, 118, 118, 119, 119, 119, 119, 119,
119, 119, 118, 117, 117, 116, 115, 114, 114, 113, 113, 112, 110, 109, 109, 107,
107, 105, 103, 102, 101, 100, 99, 98, 95, 95, 93, 93, 91, 89, 88, 86, 86, 84,
82, 81, 80, 79, 77, 76, 74, 73, 72, 71, 70, 69, 67, 66, 64, 63, 62, 61, 59, 58,
57, 56, 54, 53, 52, 50, 50, 48, 47, 46, 44, 43, 43, 41, 39, 38, 37, 36, 35, 34,
33, 32, 31, 30, 29, 27, 27, 25, 24, 24, 23, 22, 20, 19, 18, 18, 17, 16, 15, 14,
12, 12, 11, 11, 9, 7, 7, 6, 5, 4, 3, 3, 2, 0, 0, -1, -3, -4, -4, -6, -6, -8, -8,
-10, -11, -12, -13, -13, -14, -15, -16, -17, -19, -20, -21, -23, -23, -24, -26,
-27, -28, -28, -29, -31, -31, -33, -34, -35, -36, -37, -39, -39, -40, -42, -43,
-44, -45, -46, -47, -48, -49, -50, -52, -52, -55, -56, -56, -57, -59, -60, -61,
-62, -63, -65, -66, -68, -69, -69, -71, -72, -72, -74, -75, -77, -78, -79, -81,
-81, -83, -85, -85, -87, -88, -89, -91, -92, -92, -94, -95, -97, -99, -100,
-100, -102, -103, -104, -106, -105, -107, -109, -109, -110, -111, -112, -113,
-114, -114, -115, -115, -116, -117, -117, -117, -117, -117, -118, -117, -116,
-116, -116, -116, -115, -115, -113, -112, -111, -110, -109, -107, -106, -103,
-102, -100, -97, -95, -93, -90, -88, -84, -81, -78, -75, -72, -68, -64, -60,
-57, -52, -49, -44, -40, -36, -31, -27, -23, -18, -13, -9, -4, 0, 6, 10, 13, 18,
22, 26, 31, 34, 38, 42, 45, 49, 52, 55, 57, 61, 64, 66, 68, 70, 73, 74, 76, 77,
79, 80, 81, 81, 83, 83, 84, 83, 84, 84, 84, 84, 83, 83, 82, 82, 82, 81, 80, 80,
78, 77, 76, 75, 74, 72, 72, 70, 69, 67, 67, 65, 64, 63, 62, 59, 57, 56, 55, 54,
52, 50, 49, 48, 46, 45, 43, 41, 40, 39, 37, 36, 35, 33, 31, 30, 28, 27, 26, 23,
22, 21, 18, 17, 16, 14, 13, 11, 10, 8, 7, 5, 4, 2, 0, -1, -2, -3, -6, -7, -8,
-9, -11, -12, -14, -15, -17, -18, -20, -21, -23, -23, -25, -26, -28, -29, -31,
-32, -33, -34, -36, -36, -38, -39, -41, -41, -43, -44, -45, -47, -48, -48, -50,
-51, -52, -54, -54, -55, -56, -57, -59, -60, -61, -60, -62, -64, -64, -65, -67,
-66, -68, -68, -69, -70, -70, -70, -72, -72, -73, -73, -74, -74, -74, -74, -74,
-74, -74, -74, -74, -72, -72, -72, -70, -69, -69, -67, -66, -65, -63, -61, -60,
-58, -55, -54, -51, -48, -45, -42, -40, -36, -33, -29, -26, -23, -19, -14, -10,
-8, -3, };