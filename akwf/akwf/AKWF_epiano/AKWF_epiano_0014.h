#define DATA_LENGTH 512
#define DATA AKWF_epiano_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 3, 4, 6, 8, 10, 13, 15, 17, 20,
22, 25, 28, 30, 31, 34, 34, 36, 37, 39, 38, 40, 41, 42, 43, 43, 45, 45, 47, 49,
51, 52, 55, 57, 59, 62, 64, 66, 67, 69, 70, 71, 71, 72, 72, 72, 72, 72, 73, 74,
73, 73, 75, 76, 76, 79, 80, 81, 83, 85, 86, 88, 89, 91, 90, 92, 92, 91, 92, 91,
91, 90, 90, 90, 90, 91, 91, 92, 93, 94, 95, 97, 99, 100, 101, 102, 104, 105,
106, 106, 108, 107, 108, 107, 107, 106, 106, 107, 106, 106, 106, 107, 108, 109,
110, 112, 113, 114, 115, 117, 117, 118, 119, 118, 118, 118, 117, 117, 117, 115,
114, 114, 113, 112, 112, 112, 112, 112, 113, 114, 114, 115, 115, 117, 117, 116,
116, 116, 116, 114, 114, 112, 111, 110, 108, 107, 105, 104, 103, 101, 101, 101,
99, 100, 100, 100, 100, 100, 99, 99, 99, 97, 95, 94, 92, 90, 87, 86, 84, 82, 79,
77, 75, 73, 72, 70, 69, 68, 67, 66, 66, 65, 64, 63, 63, 60, 58, 57, 54, 51, 48,
45, 43, 41, 37, 34, 32, 30, 27, 25, 24, 22, 21, 20, 19, 17, 17, 15, 14, 12, 10,
8, 5, 3, 1, -3, -6, -9, -13, -15, -18, -20, -23, -26, -27, -28, -31, -31, -33,
-34, -36, -37, -39, -40, -43, -45, -47, -50, -52, -55, -59, -62, -65, -69, -71,
-74, -76, -78, -80, -81, -83, -84, -85, -86, -86, -88, -89, -90, -91, -92, -94,
-96, -98, -100, -102, -104, -107, -109, -111, -111, -114, -115, -114, -116,
-115, -115, -115, -115, -115, -114, -114, -114, -114, -112, -113, -114, -114,
-114, -114, -114, -115, -115, -115, -115, -115, -113, -112, -112, -110, -108,
-107, -105, -102, -101, -98, -97, -95, -94, -92, -91, -88, -88, -86, -85, -84,
-83, -81, -78, -78, -76, -73, -71, -69, -68, -64, -61, -59, -57, -54, -52, -50,
-48, -45, -44, -41, -40, -38, -37, -35, -34, -32, -31, -29, -28, -26, -25, -22,
-22, -20, -18, -15, -14, -13, -11, -10, -10, -8, -7, -7, -6, -5, -6, -5, -6, -6,
-5, -5, -5, -5, -5, -4, -5, -4, -4, -5, -4, -4, -5, -5, -6, -6, -8, -9, -9, -10,
-11, -12, -13, -15, -17, -17, -18, -20, -21, -22, -23, -24, -26, -27, -28, -30,
-31, -32, -33, -35, -37, -38, -39, -42, -43, -45, -46, -47, -48, -50, -51, -53,
-54, -55, -57, -57, -59, -60, -61, -62, -62, -63, -65, -65, -66, -66, -68, -69,
-70, -71, -72, -72, -73, -74, -75, -74, -76, -76, -75, -76, -76, -76, -76, -76,
-75, -75, -75, -75, -76, -75, -74, -75, -75, -75, -74, -75, -75, -74, -74, -73,
-72, -71, -70, -70, -68, -66, -65, -64, -61, -60, -59, -57, -56, -54, -53, -52,
-51, -49, -48, -47, -46, -44, -44, -41, -40, -39, -37, -34, -33, -30, -28, -25,
-22, -20, -19, -16, -14, -12, -10, -8, -7, -5, -4, -2, -1, -1, };