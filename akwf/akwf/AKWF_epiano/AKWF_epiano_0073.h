#define DATA_LENGTH 512
#define DATA AKWF_epiano_0073

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 8, 13, 17, 21, 26, 31, 35, 40,
44, 47, 52, 56, 61, 65, 68, 72, 76, 80, 83, 86, 89, 92, 95, 97, 100, 102, 103,
107, 109, 109, 111, 112, 113, 115, 116, 116, 117, 119, 119, 119, 119, 119, 120,
119, 119, 119, 118, 118, 117, 117, 116, 115, 114, 114, 113, 112, 111, 110, 108,
108, 106, 106, 104, 103, 101, 101, 98, 97, 96, 94, 93, 91, 91, 88, 87, 86, 84,
82, 80, 79, 77, 75, 74, 72, 70, 69, 66, 65, 64, 61, 60, 58, 57, 55, 53, 51, 50,
47, 46, 44, 42, 41, 39, 38, 36, 35, 32, 31, 29, 27, 26, 25, 23, 21, 20, 18, 17,
15, 14, 13, 11, 9, 9, 6, 5, 4, 2, 2, 1, -1, -2, -4, -5, -6, -7, -8, -9, -10,
-11, -11, -14, -14, -15, -16, -17, -17, -18, -19, -19, -19, -21, -21, -22, -22,
-23, -23, -23, -24, -25, -25, -26, -25, -25, -25, -26, -25, -25, -26, -26, -26,
-26, -25, -25, -24, -24, -24, -24, -22, -23, -22, -22, -21, -21, -21, -21, -20,
-21, -19, -19, -19, -19, -18, -18, -17, -17, -18, -17, -18, -17, -16, -16, -16,
-16, -16, -15, -15, -16, -15, -15, -16, -15, -15, -15, -16, -16, -15, -16, -15,
-15, -14, -14, -15, -16, -15, -15, -16, -14, -15, -16, -16, -15, -14, -16, -15,
-16, -16, -16, -15, -16, -16, -16, -16, -15, -17, -16, -16, -16, -16, -16, -16,
-17, -16, -17, -17, -17, -17, -17, -18, -17, -18, -18, -19, -19, -19, -19, -19,
-20, -20, -20, -20, -20, -21, -21, -21, -22, -23, -24, -24, -23, -25, -24, -25,
-26, -27, -26, -27, -28, -28, -29, -28, -29, -29, -30, -30, -31, -31, -31, -32,
-32, -34, -33, -33, -34, -35, -35, -36, -37, -36, -37, -37, -37, -38, -38, -39,
-39, -39, -40, -40, -40, -41, -41, -41, -40, -41, -41, -41, -40, -40, -40, -40,
-39, -38, -37, -36, -36, -35, -33, -32, -31, -30, -29, -28, -26, -24, -23, -21,
-20, -18, -16, -14, -13, -11, -9, -7, -6, -5, -3, -2, 0, 1, 3, 3, 5, 6, 7, 8, 8,
10, 10, 10, 11, 12, 12, 13, 13, 13, 13, 13, 12, 12, 12, 13, 11, 12, 11, 10, 10,
9, 7, 8, 6, 5, 5, 4, 3, 1, 1, -1, -1, -2, -4, -5, -7, -8, -8, -10, -11, -12,
-14, -15, -15, -18, -19, -20, -22, -22, -23, -25, -26, -28, -28, -30, -31, -32,
-33, -35, -35, -36, -38, -39, -39, -40, -41, -42, -44, -44, -45, -45, -46, -47,
-48, -48, -49, -50, -50, -52, -52, -53, -53, -53, -54, -54, -55, -54, -55, -56,
-55, -55, -55, -56, -57, -56, -56, -57, -56, -57, -57, -57, -56, -58, -57, -56,
-57, -57, -56, -57, -56, -55, -56, -54, -55, -54, -53, -53, -52, -53, -52, -51,
-51, -49, -48, -47, -46, -44, -42, -42, -39, -37, -36, -34, -31, -29, -26, -23,
-20, -17, -14, -9, -6, -2, };