#define DATA_LENGTH 512
#define DATA AKWF_epiano_0057

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 9, 11, 14, 15, 18, 21, 23,
25, 28, 31, 33, 35, 37, 40, 42, 44, 47, 49, 51, 53, 55, 57, 59, 61, 63, 66, 68,
69, 71, 73, 75, 77, 78, 80, 82, 83, 85, 88, 89, 91, 92, 93, 95, 96, 97, 98, 101,
101, 102, 103, 104, 106, 106, 108, 109, 110, 110, 111, 112, 112, 114, 114, 115,
115, 115, 116, 117, 118, 118, 118, 118, 118, 118, 118, 119, 119, 119, 119, 119,
118, 119, 119, 119, 119, 119, 118, 118, 118, 117, 117, 117, 116, 116, 115, 115,
114, 113, 113, 113, 112, 111, 110, 110, 109, 108, 108, 107, 105, 105, 104, 104,
102, 101, 100, 99, 99, 98, 96, 97, 95, 93, 94, 92, 91, 90, 89, 88, 87, 85, 85,
84, 83, 81, 81, 79, 79, 78, 76, 76, 74, 74, 73, 72, 71, 69, 68, 68, 66, 65, 65,
64, 62, 61, 60, 59, 59, 58, 56, 56, 55, 53, 52, 51, 51, 50, 48, 48, 48, 46, 45,
43, 42, 42, 41, 41, 39, 38, 38, 37, 36, 35, 34, 34, 32, 32, 31, 31, 29, 28, 28,
28, 26, 25, 25, 24, 24, 23, 22, 21, 21, 20, 19, 19, 19, 18, 17, 17, 15, 15, 14,
15, 12, 12, 12, 12, 10, 10, 10, 9, 9, 9, 6, 7, 6, 6, 5, 5, 4, 3, 3, 2, 2, 2, 1,
0, -1, 0, -1, -2, -2, -3, -3, -4, -4, -4, -5, -6, -6, -7, -7, -9, -8, -9, -9,
-10, -11, -11, -12, -13, -13, -14, -15, -15, -15, -16, -17, -18, -18, -19, -20,
-21, -21, -22, -23, -24, -25, -25, -26, -27, -28, -28, -29, -30, -31, -32, -33,
-34, -34, -36, -36, -37, -38, -39, -40, -40, -40, -41, -43, -45, -45, -46, -47,
-46, -48, -49, -50, -51, -51, -51, -53, -53, -54, -54, -55, -56, -56, -57, -57,
-59, -58, -59, -60, -60, -60, -62, -62, -62, -62, -63, -63, -64, -64, -65, -64,
-65, -66, -66, -65, -66, -67, -67, -67, -67, -67, -67, -68, -68, -68, -69, -68,
-69, -69, -69, -69, -69, -70, -69, -70, -70, -70, -70, -69, -69, -70, -71, -71,
-71, -72, -71, -72, -71, -72, -73, -72, -72, -73, -73, -72, -73, -73, -74, -74,
-74, -74, -74, -75, -75, -76, -76, -76, -77, -77, -77, -77, -78, -77, -78, -78,
-79, -79, -79, -80, -80, -80, -81, -81, -82, -82, -82, -83, -83, -83, -84, -85,
-84, -85, -85, -85, -86, -86, -87, -87, -87, -88, -88, -88, -89, -88, -89, -90,
-90, -89, -90, -91, -90, -91, -91, -91, -90, -91, -90, -92, -91, -91, -90, -92,
-91, -90, -91, -90, -90, -90, -90, -89, -89, -88, -88, -88, -87, -87, -86, -84,
-83, -83, -83, -82, -81, -79, -79, -78, -76, -76, -74, -73, -71, -70, -69, -67,
-66, -63, -63, -60, -58, -56, -54, -53, -52, -49, -47, -45, -43, -40, -39, -37,
-34, -31, -30, -28, -25, -23, -21, -18, -16, -13, -11, -8, -6, -3, -1, };