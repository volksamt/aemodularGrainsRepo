#define DATA_LENGTH 512
#define DATA AKWF_epiano_0070

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 12, 16, 19, 23, 26, 30, 34, 38,
42, 44, 48, 52, 55, 58, 61, 65, 68, 70, 74, 77, 80, 82, 85, 87, 90, 93, 95, 97,
98, 100, 102, 104, 106, 107, 109, 111, 112, 113, 114, 114, 115, 116, 117, 117,
118, 118, 119, 118, 119, 119, 119, 119, 118, 118, 118, 117, 118, 116, 116, 115,
114, 113, 112, 111, 111, 109, 107, 107, 105, 104, 103, 101, 99, 97, 96, 94, 93,
91, 89, 87, 86, 84, 82, 80, 78, 75, 74, 73, 70, 69, 67, 64, 63, 60, 59, 57, 55,
53, 51, 49, 46, 45, 44, 41, 40, 38, 36, 34, 32, 31, 29, 27, 25, 24, 23, 21, 19,
18, 17, 15, 14, 13, 12, 11, 9, 8, 7, 7, 7, 5, 4, 4, 3, 1, 1, 2, 1, 1, -1, 0, 0,
0, 1, 0, 0, 0, 0, 1, 1, 1, 2, 4, 4, 4, 5, 7, 8, 8, 9, 10, 11, 12, 13, 14, 16,
17, 18, 20, 20, 22, 24, 25, 26, 27, 28, 30, 31, 33, 34, 36, 37, 39, 40, 41, 43,
44, 46, 47, 48, 49, 50, 51, 53, 54, 55, 57, 58, 58, 59, 61, 62, 62, 64, 64, 66,
66, 67, 67, 69, 69, 70, 71, 72, 72, 72, 74, 74, 75, 74, 75, 75, 77, 77, 77, 77,
78, 78, 78, 79, 79, 79, 79, 80, 80, 79, 79, 79, 80, 79, 79, 79, 79, 79, 78, 78,
78, 78, 78, 77, 76, 76, 75, 75, 74, 74, 73, 72, 71, 70, 69, 69, 67, 67, 66, 64,
63, 63, 61, 60, 59, 58, 57, 55, 54, 51, 50, 49, 48, 46, 44, 43, 41, 38, 37, 36,
34, 32, 30, 28, 27, 24, 23, 21, 18, 16, 14, 11, 9, 8, 5, 2, 0, -2, -4, -6, -8,
-10, -13, -16, -18, -20, -22, -23, -26, -28, -30, -32, -34, -36, -38, -40, -42,
-45, -46, -47, -48, -51, -52, -54, -55, -57, -59, -59, -61, -62, -64, -65, -67,
-67, -69, -71, -71, -72, -73, -74, -75, -75, -76, -77, -78, -79, -80, -80, -80,
-82, -81, -83, -83, -83, -85, -85, -85, -85, -87, -86, -87, -88, -88, -89, -89,
-89, -90, -90, -90, -91, -92, -92, -92, -92, -93, -94, -95, -95, -95, -96, -95,
-96, -97, -98, -98, -99, -98, -100, -99, -100, -100, -101, -101, -102, -102,
-104, -103, -104, -104, -105, -105, -105, -107, -108, -107, -108, -108, -109,
-109, -111, -111, -110, -111, -111, -112, -112, -113, -113, -114, -113, -114,
-114, -115, -114, -115, -115, -115, -116, -116, -116, -116, -115, -116, -116,
-115, -116, -116, -116, -116, -115, -116, -117, -115, -115, -115, -114, -115,
-115, -114, -114, -114, -113, -112, -111, -111, -111, -110, -109, -109, -108,
-107, -106, -106, -104, -103, -102, -102, -100, -98, -97, -95, -94, -92, -91,
-89, -87, -85, -84, -82, -78, -77, -74, -71, -68, -66, -63, -60, -58, -56, -52,
-49, -45, -42, -40, -37, -33, -29, -26, -22, -18, -15, -11, -7, -4, -1, };