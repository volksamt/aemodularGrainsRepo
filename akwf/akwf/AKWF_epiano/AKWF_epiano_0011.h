#define DATA_LENGTH 512
#define DATA AKWF_epiano_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 3, 4, 5, 5, 7, 8, 8, 8, 9, 10,
10, 10, 10, 11, 11, 11, 12, 13, 13, 13, 14, 14, 14, 13, 13, 14, 14, 13, 14, 14,
14, 14, 15, 15, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 15, 14, 14, 14, 15, 14,
14, 15, 14, 15, 16, 15, 15, 15, 16, 16, 16, 16, 16, 16, 16, 17, 17, 17, 17, 18,
18, 18, 18, 20, 20, 21, 20, 22, 22, 23, 23, 23, 24, 25, 26, 26, 28, 28, 29, 29,
31, 32, 32, 34, 35, 35, 36, 38, 38, 40, 42, 41, 43, 44, 45, 47, 48, 49, 51, 52,
53, 55, 56, 58, 59, 60, 61, 63, 64, 66, 67, 68, 70, 71, 73, 74, 76, 77, 78, 80,
81, 82, 83, 85, 87, 88, 90, 91, 92, 93, 95, 96, 97, 99, 100, 101, 102, 103, 104,
105, 105, 107, 108, 108, 109, 110, 112, 112, 113, 113, 114, 114, 116, 115, 116,
117, 117, 117, 117, 118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 118, 118, 117, 117, 118, 117, 116, 115, 115, 114, 114, 113, 113, 113,
111, 110, 111, 110, 108, 108, 106, 106, 105, 104, 104, 102, 102, 100, 99, 98,
97, 96, 95, 94, 92, 92, 90, 89, 88, 86, 85, 84, 83, 81, 80, 80, 79, 77, 76, 74,
72, 71, 70, 68, 68, 66, 64, 64, 62, 61, 59, 58, 56, 55, 53, 52, 49, 49, 47, 46,
45, 44, 41, 41, 38, 37, 35, 34, 32, 32, 29, 28, 27, 26, 24, 22, 21, 20, 18, 17,
15, 14, 12, 10, 9, 8, 6, 5, 3, 2, 0, -1, -2, -4, -6, -7, -9, -11, -11, -12, -14,
-16, -17, -19, -20, -21, -23, -25, -25, -28, -28, -30, -31, -32, -33, -36, -36,
-38, -39, -40, -41, -43, -44, -45, -47, -49, -50, -51, -52, -53, -54, -55, -57,
-57, -59, -61, -62, -63, -64, -65, -67, -68, -69, -70, -71, -73, -73, -75, -76,
-76, -78, -79, -80, -81, -83, -83, -84, -85, -86, -88, -88, -90, -89, -92, -91,
-93, -94, -95, -95, -96, -97, -98, -99, -100, -100, -101, -102, -103, -104,
-105, -105, -106, -106, -107, -108, -109, -109, -110, -111, -111, -111, -112,
-113, -113, -113, -113, -114, -114, -115, -116, -116, -117, -117, -117, -117,
-116, -117, -117, -118, -118, -118, -118, -117, -118, -118, -118, -118, -118,
-118, -118, -117, -116, -117, -116, -116, -116, -115, -115, -114, -114, -113,
-113, -112, -111, -111, -110, -110, -109, -107, -106, -107, -105, -105, -103,
-102, -101, -99, -100, -98, -96, -96, -94, -93, -92, -90, -90, -88, -87, -85,
-83, -82, -81, -79, -78, -76, -74, -73, -71, -69, -67, -67, -65, -63, -61, -60,
-59, -56, -55, -53, -51, -50, -48, -47, -45, -43, -42, -40, -39, -37, -36, -34,
-32, -31, -29, -27, -26, -25, -24, -22, -21, -19, -19, -17, -16, -14, -12, -12,
-10, -8, -7, -7, -6, -4, -4, -3, -2, -1, };