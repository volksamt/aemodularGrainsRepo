#define DATA_LENGTH 512
#define DATA AKWF_epiano_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 11, 14, 18, 22, 25, 29, 33,
37, 41, 45, 49, 54, 59, 62, 67, 72, 75, 79, 83, 86, 90, 94, 97, 100, 103, 106,
108, 110, 112, 113, 115, 117, 118, 118, 117, 118, 118, 119, 119, 118, 118, 118,
117, 117, 115, 115, 114, 113, 112, 110, 109, 108, 107, 106, 105, 104, 102, 102,
101, 98, 98, 97, 96, 94, 93, 91, 90, 89, 88, 87, 87, 85, 83, 82, 82, 81, 79, 78,
78, 76, 76, 73, 72, 72, 71, 70, 69, 68, 66, 66, 64, 64, 63, 62, 61, 60, 58, 58,
57, 57, 55, 54, 53, 52, 51, 51, 50, 49, 48, 47, 46, 45, 45, 44, 43, 42, 42, 40,
39, 39, 38, 38, 37, 37, 35, 35, 34, 33, 32, 32, 31, 31, 29, 29, 29, 28, 28, 27,
26, 25, 24, 24, 23, 22, 22, 22, 21, 21, 20, 19, 19, 17, 17, 17, 16, 16, 14, 14,
14, 13, 12, 11, 11, 10, 9, 10, 8, 8, 7, 7, 6, 6, 4, 5, 3, 2, 2, 2, 0, 1, 0, -1,
-2, -2, -3, -4, -5, -5, -7, -7, -8, -8, -9, -10, -10, -11, -12, -12, -14, -14,
-15, -15, -16, -18, -19, -18, -20, -20, -21, -23, -24, -24, -26, -26, -27, -28,
-29, -30, -32, -32, -33, -34, -35, -36, -37, -38, -39, -40, -40, -41, -42, -44,
-45, -46, -47, -48, -50, -50, -51, -52, -54, -54, -55, -57, -58, -59, -60, -61,
-61, -64, -65, -65, -67, -67, -69, -70, -71, -72, -74, -74, -75, -77, -78, -79,
-79, -82, -82, -82, -84, -85, -87, -88, -89, -90, -90, -92, -94, -95, -95, -96,
-97, -97, -99, -100, -101, -101, -102, -103, -104, -105, -107, -107, -107, -108,
-109, -110, -109, -110, -111, -112, -111, -112, -112, -114, -113, -113, -114,
-114, -113, -113, -114, -113, -113, -112, -112, -112, -112, -111, -111, -110,
-108, -108, -107, -106, -105, -104, -102, -101, -99, -98, -96, -94, -92, -89,
-88, -85, -82, -79, -76, -72, -70, -66, -62, -58, -56, -52, -47, -43, -39, -34,
-29, -25, -20, -15, -10, -6, -2, 4, 8, 12, 16, 20, 23, 27, 31, 33, 36, 39, 40,
43, 44, 46, 47, 48, 49, 49, 50, 49, 50, 50, 50, 49, 48, 48, 46, 45, 45, 44, 43,
42, 39, 38, 37, 36, 34, 34, 32, 30, 30, 29, 27, 26, 25, 23, 23, 20, 20, 19, 18,
17, 16, 15, 14, 14, 12, 11, 11, 10, 10, 8, 8, 8, 7, 6, 5, 4, 4, 3, 2, 2, 1, 0,
0, 0, -1, -2, -3, -4, -3, -4, -5, -5, -6, -6, -7, -9, -9, -9, -11, -10, -11,
-13, -12, -13, -14, -13, -15, -15, -16, -17, -18, -17, -18, -19, -20, -20, -21,
-21, -22, -23, -23, -23, -23, -23, -24, -24, -25, -26, -26, -26, -26, -27, -26,
-26, -27, -26, -27, -26, -26, -26, -25, -26, -25, -23, -23, -22, -23, -20, -20,
-18, -17, -16, -13, -13, -10, -8, -6, -3, -1, };