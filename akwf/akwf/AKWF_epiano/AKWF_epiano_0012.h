#define DATA_LENGTH 512
#define DATA AKWF_epiano_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 13, 16, 21, 26, 29, 33, 38, 41,
45, 49, 52, 56, 60, 63, 67, 70, 73, 76, 79, 81, 84, 86, 90, 91, 94, 97, 98, 100,
102, 103, 105, 107, 108, 110, 111, 111, 113, 113, 115, 115, 116, 117, 117, 118,
118, 118, 119, 119, 119, 120, 119, 119, 119, 119, 118, 118, 118, 117, 118, 117,
116, 116, 115, 114, 113, 113, 113, 111, 110, 109, 108, 108, 107, 107, 106, 104,
104, 103, 103, 102, 101, 100, 99, 98, 97, 96, 95, 94, 94, 92, 93, 92, 90, 90,
89, 88, 88, 86, 85, 85, 84, 83, 81, 81, 81, 79, 79, 78, 76, 76, 74, 74, 73, 73,
72, 71, 69, 69, 68, 67, 66, 66, 65, 64, 63, 62, 62, 61, 59, 59, 58, 58, 56, 55,
56, 54, 54, 54, 52, 52, 52, 50, 50, 50, 49, 48, 47, 47, 46, 46, 45, 44, 43, 43,
42, 42, 40, 41, 39, 40, 38, 39, 38, 37, 36, 36, 35, 35, 34, 34, 32, 32, 31, 31,
31, 30, 29, 28, 28, 27, 26, 26, 25, 25, 25, 24, 23, 23, 23, 22, 22, 22, 21, 21,
20, 20, 20, 19, 19, 19, 17, 17, 17, 16, 17, 16, 15, 15, 15, 14, 14, 12, 12, 12,
11, 12, 11, 10, 10, 10, 9, 9, 8, 8, 7, 8, 7, 6, 5, 5, 4, 4, 4, 3, 3, 3, 2, 2, 1,
2, 1, 0, -1, 0, -1, -2, -1, -2, -2, -3, -3, -4, -5, -4, -5, -6, -6, -6, -7, -7,
-7, -7, -7, -8, -8, -9, -9, -10, -10, -11, -11, -12, -11, -12, -12, -14, -13,
-14, -14, -15, -16, -16, -16, -16, -17, -17, -17, -19, -19, -19, -20, -20, -19,
-20, -21, -21, -21, -22, -22, -23, -23, -23, -24, -25, -25, -25, -26, -26, -26,
-26, -28, -27, -28, -27, -29, -29, -30, -30, -31, -31, -32, -32, -32, -34, -33,
-34, -35, -35, -36, -37, -36, -37, -38, -38, -38, -39, -40, -40, -40, -41, -42,
-42, -42, -43, -44, -43, -44, -46, -46, -45, -47, -46, -48, -48, -49, -49, -50,
-50, -50, -51, -52, -52, -52, -53, -54, -54, -55, -55, -56, -57, -57, -58, -59,
-60, -60, -61, -62, -62, -62, -63, -63, -64, -66, -65, -66, -67, -68, -69, -69,
-70, -70, -71, -71, -72, -73, -74, -75, -76, -75, -77, -77, -78, -78, -78, -79,
-81, -81, -82, -82, -82, -83, -83, -84, -84, -86, -87, -86, -87, -89, -90, -89,
-91, -91, -92, -92, -92, -93, -94, -95, -95, -97, -96, -97, -97, -98, -99, -99,
-100, -100, -101, -101, -101, -101, -102, -102, -102, -103, -103, -103, -103,
-104, -103, -103, -104, -104, -104, -103, -103, -103, -102, -103, -102, -102,
-101, -101, -101, -101, -100, -99, -98, -98, -96, -96, -95, -94, -94, -92, -91,
-89, -88, -87, -85, -83, -82, -81, -79, -76, -75, -73, -70, -67, -65, -63, -60,
-57, -55, -52, -48, -44, -42, -38, -35, -31, -28, -24, -20, -17, -12, -9, -3, };