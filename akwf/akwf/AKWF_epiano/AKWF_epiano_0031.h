#define DATA_LENGTH 512
#define DATA AKWF_epiano_0031

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 17, 23, 29, 35, 40, 46, 52,
57, 63, 68, 72, 77, 82, 86, 90, 94, 98, 100, 103, 104, 107, 109, 111, 113, 114,
115, 116, 117, 118, 118, 118, 119, 119, 119, 119, 119, 119, 118, 118, 117, 117,
117, 115, 116, 114, 114, 112, 113, 112, 111, 108, 108, 107, 106, 104, 103, 102,
102, 100, 99, 97, 97, 94, 93, 92, 91, 89, 88, 86, 85, 84, 82, 80, 78, 77, 75,
73, 72, 71, 69, 67, 66, 63, 63, 61, 59, 57, 55, 54, 51, 51, 49, 46, 45, 44, 42,
39, 38, 37, 35, 33, 31, 30, 28, 27, 26, 24, 21, 21, 19, 17, 16, 15, 13, 12, 9,
8, 7, 5, 5, 3, 2, 0, -1, -2, -4, -5, -6, -7, -8, -10, -10, -12, -12, -13, -15,
-16, -16, -17, -18, -19, -19, -19, -20, -22, -22, -22, -24, -23, -24, -25, -25,
-26, -26, -28, -27, -27, -28, -29, -28, -29, -29, -29, -28, -29, -29, -29, -29,
-27, -27, -26, -27, -26, -25, -24, -24, -23, -23, -21, -22, -20, -20, -19, -19,
-18, -18, -18, -17, -17, -16, -17, -15, -15, -15, -15, -16, -15, -15, -15, -15,
-16, -16, -16, -15, -15, -16, -15, -16, -15, -15, -15, -15, -15, -15, -16, -15,
-15, -15, -15, -15, -15, -16, -14, -14, -14, -15, -15, -14, -14, -15, -14, -14,
-14, -14, -14, -14, -13, -14, -13, -13, -13, -13, -13, -12, -13, -13, -13, -14,
-14, -13, -14, -14, -13, -13, -14, -13, -14, -14, -13, -14, -15, -14, -16, -15,
-16, -15, -16, -17, -16, -17, -17, -18, -18, -18, -18, -20, -20, -20, -20, -21,
-22, -22, -23, -23, -24, -24, -24, -24, -26, -27, -26, -27, -28, -28, -29, -29,
-30, -30, -30, -30, -32, -32, -33, -33, -34, -33, -35, -35, -35, -35, -36, -37,
-37, -37, -38, -39, -40, -40, -40, -41, -40, -40, -41, -42, -42, -42, -42, -41,
-42, -41, -40, -40, -39, -39, -38, -37, -35, -34, -32, -30, -28, -27, -24, -22,
-20, -17, -15, -13, -10, -8, -6, -3, -1, 1, 2, 5, 6, 8, 9, 11, 12, 12, 14, 15,
16, 16, 16, 17, 17, 18, 17, 17, 17, 16, 17, 16, 16, 16, 15, 15, 14, 12, 12, 11,
11, 10, 8, 8, 7, 6, 5, 3, 2, 2, 1, -1, -2, -3, -4, -5, -7, -8, -10, -11, -13,
-14, -15, -17, -17, -19, -20, -22, -22, -24, -26, -27, -27, -29, -31, -32, -33,
-34, -36, -36, -37, -39, -40, -40, -41, -42, -44, -44, -44, -45, -46, -47, -47,
-48, -49, -49, -50, -50, -50, -51, -52, -52, -53, -53, -53, -53, -53, -53, -54,
-54, -55, -54, -55, -54, -55, -54, -56, -55, -54, -55, -55, -54, -55, -55, -55,
-54, -54, -53, -54, -54, -53, -54, -53, -53, -52, -52, -51, -51, -51, -50, -50,
-49, -49, -48, -48, -47, -46, -45, -45, -43, -43, -41, -40, -38, -36, -34, -31,
-29, -26, -23, -20, -16, -11, -7, -3, };