#define DATA_LENGTH 512
#define DATA AKWF_epiano_0067

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 12, 14, 17, 19, 22, 24,
27, 29, 31, 35, 37, 39, 41, 43, 46, 48, 50, 53, 55, 57, 60, 62, 64, 65, 68, 70,
72, 74, 76, 78, 79, 80, 82, 84, 86, 88, 89, 91, 92, 93, 95, 96, 97, 99, 100,
102, 103, 104, 105, 107, 106, 108, 109, 109, 111, 111, 112, 113, 113, 114, 115,
115, 116, 116, 117, 118, 117, 118, 118, 118, 118, 119, 119, 119, 120, 120, 119,
120, 118, 119, 118, 118, 119, 118, 117, 117, 116, 116, 116, 116, 115, 115, 114,
113, 112, 112, 111, 111, 110, 109, 108, 108, 108, 106, 105, 104, 105, 103, 102,
101, 100, 99, 98, 97, 96, 95, 94, 93, 92, 91, 91, 89, 88, 87, 86, 85, 84, 83,
82, 81, 80, 78, 77, 77, 76, 74, 74, 72, 71, 70, 69, 67, 67, 66, 64, 64, 62, 61,
60, 60, 58, 57, 57, 55, 54, 53, 52, 51, 51, 49, 48, 47, 46, 45, 44, 44, 43, 43,
41, 40, 40, 38, 37, 37, 36, 35, 34, 34, 32, 32, 31, 30, 29, 29, 28, 27, 27, 26,
25, 25, 24, 23, 23, 23, 22, 20, 20, 19, 20, 18, 19, 18, 17, 17, 17, 15, 15, 15,
14, 13, 13, 12, 12, 12, 12, 11, 10, 11, 10, 10, 9, 10, 9, 8, 8, 8, 7, 7, 7, 6,
6, 6, 5, 5, 4, 3, 4, 3, 3, 3, 3, 2, 2, 1, 0, 1, -1, -1, -1, -2, -2, -3, -2, -3,
-4, -4, -5, -6, -6, -7, -8, -8, -8, -9, -9, -10, -10, -11, -12, -13, -14, -15,
-15, -16, -17, -18, -19, -19, -19, -21, -22, -24, -24, -24, -26, -27, -27, -29,
-30, -31, -31, -33, -33, -34, -36, -36, -37, -39, -39, -41, -41, -43, -44, -43,
-45, -46, -46, -47, -48, -49, -49, -51, -52, -52, -54, -54, -55, -55, -56, -57,
-58, -58, -59, -60, -60, -60, -62, -61, -62, -62, -63, -64, -64, -65, -66, -65,
-66, -66, -66, -66, -68, -68, -67, -68, -68, -68, -69, -69, -70, -70, -70, -70,
-71, -70, -71, -71, -71, -71, -71, -72, -72, -73, -72, -73, -73, -73, -73, -74,
-74, -74, -74, -75, -75, -75, -76, -76, -76, -77, -77, -76, -76, -77, -78, -78,
-78, -79, -79, -80, -79, -80, -80, -81, -81, -81, -82, -82, -83, -83, -84, -84,
-84, -85, -85, -86, -85, -86, -86, -87, -87, -88, -88, -88, -88, -89, -89, -89,
-89, -90, -91, -91, -90, -92, -91, -92, -92, -92, -93, -93, -92, -94, -93, -93,
-94, -94, -94, -94, -94, -94, -95, -95, -95, -94, -94, -93, -94, -94, -94, -93,
-93, -92, -92, -92, -92, -91, -90, -90, -90, -89, -88, -87, -87, -86, -85, -84,
-83, -83, -82, -80, -79, -78, -77, -76, -74, -72, -71, -69, -68, -66, -65, -63,
-60, -59, -57, -56, -53, -51, -49, -48, -46, -43, -42, -39, -36, -34, -32, -30,
-28, -24, -23, -20, -17, -16, -13, -10, -9, -5, -3, 0, };