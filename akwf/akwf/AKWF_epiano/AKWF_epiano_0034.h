#define DATA_LENGTH 512
#define DATA AKWF_epiano_0034

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 5, 6, 7, 8, 9, 10, 10, 11,
12, 13, 14, 15, 16, 16, 17, 18, 18, 19, 19, 20, 20, 20, 21, 21, 22, 22, 23, 25,
25, 25, 26, 26, 27, 28, 29, 29, 30, 32, 32, 32, 33, 34, 36, 36, 37, 38, 39, 40,
40, 41, 42, 43, 44, 45, 46, 47, 47, 48, 49, 50, 51, 52, 53, 54, 54, 56, 56, 57,
57, 59, 60, 61, 61, 63, 64, 65, 65, 65, 67, 68, 69, 70, 70, 71, 73, 73, 74, 75,
76, 78, 78, 80, 80, 82, 82, 84, 84, 86, 87, 88, 90, 90, 92, 93, 94, 96, 96, 98,
99, 100, 101, 102, 103, 105, 105, 107, 108, 109, 110, 111, 112, 112, 113, 113,
115, 115, 116, 116, 117, 117, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119,
119, 117, 118, 116, 116, 115, 114, 113, 112, 110, 108, 106, 104, 102, 100, 98,
95, 91, 88, 85, 80, 77, 73, 68, 64, 60, 55, 49, 44, 38, 33, 28, 22, 17, 11, 5,
0, -5, -9, -14, -19, -24, -28, -31, -35, -38, -41, -43, -46, -48, -50, -51, -53,
-55, -56, -57, -58, -59, -59, -61, -61, -62, -62, -63, -64, -64, -65, -65, -67,
-66, -67, -68, -68, -69, -70, -70, -71, -72, -72, -73, -74, -74, -75, -77, -77,
-77, -78, -79, -80, -79, -80, -80, -81, -81, -82, -82, -82, -82, -83, -82, -82,
-82, -81, -81, -81, -81, -80, -79, -79, -79, -78, -77, -77, -76, -75, -74, -73,
-71, -70, -69, -69, -68, -66, -64, -63, -62, -61, -59, -58, -57, -56, -54, -54,
-52, -51, -49, -49, -48, -47, -46, -45, -44, -43, -43, -42, -41, -40, -40, -38,
-38, -39, -38, -38, -38, -38, -38, -37, -39, -38, -39, -38, -39, -39, -40, -41,
-42, -42, -42, -45, -45, -47, -48, -49, -50, -52, -54, -56, -59, -60, -61, -64,
-65, -68, -70, -72, -75, -76, -79, -81, -84, -85, -87, -89, -90, -92, -93, -94,
-95, -95, -96, -96, -96, -96, -95, -95, -94, -93, -92, -92, -89, -88, -86, -84,
-84, -80, -79, -76, -74, -71, -69, -66, -64, -61, -59, -56, -54, -50, -47, -45,
-42, -39, -37, -33, -30, -27, -26, -22, -20, -16, -14, -12, -9, -7, -4, -2, 0,
2, 5, 7, 8, 10, 12, 13, 14, 16, 18, 19, 20, 20, 22, 23, 24, 25, 25, 25, 26, 26,
28, 28, 29, 29, 28, 29, 28, 29, 29, 29, 29, 28, 28, 29, 27, 28, 28, 27, 28, 27,
26, 25, 25, 25, 24, 24, 23, 22, 22, 21, 20, 20, 19, 19, 18, 17, 16, 15, 14, 13,
12, 12, 11, 10, 9, 9, 8, 6, 5, 4, 3, 2, 1, 1, -1, -2, -3, -4, -5, -5, -5, -7,
-8, -9, -10, -11, -11, -12, -13, -13, -14, -14, -14, -14, -16, -16, -15, -16,
-15, -17, -17, -16, -16, -16, -15, -14, -14, -13, -13, -12, -12, -12, -10, -9,
-8, -7, -6, -5, -4, -2, -2, 0, };