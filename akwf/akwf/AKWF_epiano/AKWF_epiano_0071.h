#define DATA_LENGTH 512
#define DATA AKWF_epiano_0071

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 8, 14, 20, 26, 33, 38, 44, 49, 55,
59, 65, 70, 74, 79, 82, 85, 89, 92, 95, 97, 101, 103, 105, 106, 108, 110, 112,
113, 114, 116, 117, 116, 118, 118, 119, 118, 118, 119, 120, 119, 119, 119, 118,
118, 117, 118, 117, 116, 116, 114, 113, 113, 112, 111, 110, 109, 108, 107, 105,
105, 102, 101, 99, 98, 97, 95, 93, 91, 89, 88, 86, 84, 82, 80, 77, 76, 74, 71,
70, 67, 65, 63, 61, 58, 57, 55, 54, 51, 49, 48, 46, 44, 41, 41, 39, 37, 35, 35,
32, 31, 30, 28, 26, 26, 24, 22, 21, 19, 18, 16, 16, 15, 13, 12, 10, 9, 7, 5, 4,
3, 2, -1, -1, -3, -6, -7, -9, -10, -12, -14, -16, -18, -19, -22, -23, -25, -27,
-29, -31, -33, -35, -36, -39, -40, -42, -43, -45, -47, -49, -50, -51, -54, -55,
-56, -57, -59, -59, -60, -60, -61, -62, -62, -62, -62, -62, -62, -61, -61, -60,
-60, -59, -59, -58, -59, -57, -56, -56, -56, -54, -54, -53, -52, -52, -51, -50,
-50, -49, -48, -48, -47, -47, -45, -45, -44, -43, -43, -42, -41, -41, -41, -40,
-39, -39, -38, -37, -37, -35, -35, -34, -33, -33, -32, -32, -30, -29, -28, -29,
-27, -26, -26, -25, -24, -22, -21, -21, -20, -18, -17, -16, -15, -13, -12, -10,
-10, -8, -6, -4, -3, -1, -1, 1, 3, 5, 7, 9, 10, 12, 13, 15, 17, 18, 20, 22, 22,
24, 27, 27, 28, 29, 31, 32, 33, 34, 35, 36, 37, 37, 38, 38, 39, 40, 40, 40, 40,
41, 40, 40, 40, 39, 40, 39, 38, 39, 37, 36, 36, 34, 33, 33, 31, 30, 29, 27, 26,
24, 24, 20, 19, 18, 15, 14, 12, 10, 8, 7, 4, 2, 0, -3, -4, -8, -9, -12, -14,
-16, -20, -22, -25, -28, -30, -33, -36, -38, -41, -45, -46, -50, -51, -53, -54,
-56, -57, -58, -59, -58, -57, -57, -57, -54, -53, -51, -49, -46, -44, -42, -38,
-35, -32, -30, -27, -25, -22, -19, -17, -14, -12, -10, -8, -5, -3, -2, 0, 1, 3,
4, 6, 7, 8, 9, 10, 12, 13, 13, 14, 14, 15, 16, 16, 16, 17, 17, 18, 17, 19, 18,
18, 18, 19, 19, 19, 18, 19, 18, 18, 16, 16, 15, 15, 15, 13, 12, 12, 10, 9, 8, 5,
4, 3, 1, -1, -3, -5, -7, -10, -12, -14, -16, -18, -21, -23, -25, -29, -30, -33,
-36, -37, -40, -41, -44, -46, -49, -49, -52, -53, -55, -57, -57, -59, -61, -61,
-63, -63, -64, -64, -65, -65, -66, -67, -66, -66, -67, -67, -67, -66, -66, -66,
-66, -65, -63, -63, -63, -63, -61, -61, -60, -59, -59, -59, -57, -57, -56, -56,
-55, -55, -54, -54, -54, -53, -53, -54, -53, -54, -54, -54, -54, -55, -55, -56,
-56, -57, -57, -58, -59, -59, -59, -59, -59, -58, -56, -54, -52, -49, -46, -43,
-37, -33, -27, -22, -15, -10, -4, };