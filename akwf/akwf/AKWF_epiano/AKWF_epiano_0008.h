#define DATA_LENGTH 512
#define DATA AKWF_epiano_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 22, 38, 55, 70, 83, 96, 106, 112,
116, 119, 117, 112, 109, 100, 92, 82, 72, 60, 50, 39, 29, 20, 13, 8, 3, 1, 1, 1,
4, 9, 14, 19, 27, 34, 39, 43, 48, 51, 53, 55, 56, 57, 56, 56, 56, 56, 56, 57,
57, 58, 59, 59, 61, 63, 65, 67, 70, 73, 77, 80, 84, 88, 90, 92, 93, 92, 89, 87,
84, 79, 75, 71, 68, 65, 62, 62, 61, 61, 61, 63, 61, 62, 61, 61, 60, 59, 57, 55,
53, 52, 50, 48, 45, 42, 41, 37, 32, 28, 23, 18, 12, 6, 0, -6, -11, -16, -22,
-28, -33, -39, -44, -49, -53, -58, -60, -63, -65, -66, -66, -66, -64, -63, -61,
-60, -58, -56, -55, -53, -50, -48, -44, -41, -35, -30, -24, -20, -14, -9, -6,
-5, -3, -6, -11, -15, -21, -29, -38, -46, -55, -63, -69, -71, -75, -75, -70,
-65, -59, -51, -44, -37, -35, -31, -31, -36, -40, -46, -55, -64, -72, -77, -83,
-86, -84, -82, -78, -74, -68, -64, -59, -54, -50, -46, -42, -38, -35, -34, -32,
-33, -32, -32, -33, -35, -36, -39, -41, -44, -45, -46, -48, -48, -47, -47, -47,
-45, -44, -41, -37, -31, -26, -19, -13, -8, -6, -4, -4, -6, -9, -14, -21, -27,
-34, -42, -50, -56, -57, -61, -62, -59, -56, -53, -47, -41, -34, -27, -19, -10,
-4, 6, 12, 17, 22, 25, 28, 31, 31, 29, 29, 24, 19, 13, 6, -2, -8, -16, -23, -29,
-36, -43, -50, -55, -62, -68, -74, -80, -87, -92, -95, -98, -99, -95, -93, -88,
-78, -69, -59, -49, -38, -28, -20, -13, -7, -3, -2, 0, -3, -7, -9, -15, -20,
-25, -29, -31, -35, -34, -31, -28, -22, -13, -4, 8, 20, 32, 44, 54, 66, 73, 78,
84, 87, 87, 87, 86, 83, 81, 78, 77, 74, 72, 72, 70, 70, 67, 66, 63, 60, 56, 51,
46, 39, 33, 29, 24, 18, 13, 9, 5, 0, -5, -9, -15, -20, -27, -33, -39, -44, -50,
-54, -59, -60, -61, -64, -63, -63, -62, -61, -59, -57, -54, -51, -48, -45, -43,
-42, -42, -43, -44, -47, -51, -55, -59, -61, -64, -64, -61, -59, -55, -46, -39,
-32, -25, -18, -12, -12, -9, -9, -11, -14, -18, -23, -26, -30, -31, -32, -30,
-26, -20, -14, -4, 8, 20, 32, 45, 59, 69, 79, 89, 95, 99, 103, 104, 102, 102,
98, 94, 89, 83, 76, 69, 61, 53, 45, 38, 33, 26, 22, 21, 20, 21, 24, 27, 29, 30,
31, 31, 27, 24, 22, 15, 10, 6, 3, -1, -3, -4, -4, -2, 2, 7, 12, 18, 26, 33, 39,
45, 51, 53, 53, 53, 48, 43, 38, 31, 25, 18, 15, 11, 7, 6, 5, 3, 3, 3, 3, 4, 4,
5, 6, 8, 9, 10, 11, 12, 12, 12, 11, 8, 3, 1, -4, -11, -18, -25, -32, -40, -47,
-54, -60, -65, -69, -73, -76, -75, -75, -72, -67, -62, -55, -44, -34, -23, -6,
};