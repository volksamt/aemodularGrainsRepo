#define DATA_LENGTH 512
#define DATA AKWF_epiano_0063

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 13, 17, 22, 27, 31, 36, 41,
45, 49, 54, 57, 61, 66, 70, 74, 77, 80, 84, 87, 90, 93, 95, 98, 101, 103, 104,
106, 110, 111, 112, 114, 114, 116, 116, 116, 117, 118, 119, 119, 118, 119, 120,
119, 118, 118, 118, 117, 117, 117, 116, 115, 115, 113, 112, 112, 110, 110, 108,
108, 106, 105, 104, 102, 101, 100, 99, 97, 95, 94, 92, 91, 90, 88, 87, 84, 83,
81, 79, 78, 76, 74, 73, 71, 70, 67, 66, 64, 63, 61, 59, 58, 56, 54, 52, 50, 48,
47, 44, 43, 42, 40, 38, 36, 34, 33, 31, 30, 28, 27, 24, 23, 22, 20, 18, 17, 14,
14, 12, 11, 10, 8, 6, 5, 4, 2, 1, -1, -1, -3, -4, -5, -7, -7, -9, -10, -11, -12,
-13, -14, -15, -16, -17, -17, -18, -19, -21, -21, -22, -22, -22, -23, -24, -24,
-25, -26, -26, -26, -26, -27, -27, -27, -27, -28, -28, -27, -28, -28, -28, -27,
-27, -26, -26, -26, -26, -25, -26, -24, -24, -23, -23, -23, -23, -22, -22, -21,
-21, -21, -21, -20, -20, -20, -18, -19, -19, -18, -19, -17, -18, -17, -17, -17,
-17, -17, -17, -17, -17, -16, -16, -17, -17, -16, -15, -16, -16, -16, -16, -16,
-15, -16, -15, -15, -15, -16, -15, -15, -15, -16, -15, -15, -15, -15, -15, -15,
-14, -14, -14, -15, -14, -14, -14, -14, -15, -15, -14, -14, -14, -14, -14, -14,
-14, -15, -14, -14, -14, -15, -15, -15, -15, -16, -16, -16, -16, -16, -17, -17,
-17, -16, -17, -17, -18, -18, -19, -19, -19, -20, -20, -21, -20, -21, -22, -21,
-22, -22, -23, -24, -24, -25, -25, -25, -27, -27, -27, -27, -28, -29, -30, -29,
-31, -31, -31, -31, -32, -32, -33, -34, -34, -35, -35, -36, -36, -36, -37, -37,
-38, -38, -38, -39, -39, -39, -40, -40, -40, -41, -41, -40, -40, -40, -41, -40,
-39, -38, -38, -37, -36, -36, -35, -35, -33, -31, -30, -29, -27, -26, -25, -22,
-21, -19, -17, -16, -13, -12, -10, -9, -7, -5, -4, -2, -1, 1, 3, 4, 5, 6, 7, 8,
9, 9, 10, 12, 12, 11, 13, 12, 13, 13, 14, 13, 13, 12, 12, 12, 11, 11, 11, 10,
10, 9, 8, 7, 7, 6, 5, 4, 3, 2, 1, -1, -1, -3, -4, -5, -6, -8, -8, -10, -10, -13,
-14, -14, -16, -17, -19, -20, -21, -23, -24, -26, -27, -27, -30, -31, -31, -32,
-34, -34, -36, -37, -38, -39, -40, -40, -42, -43, -43, -45, -46, -46, -46, -48,
-49, -48, -50, -51, -51, -51, -52, -53, -52, -53, -53, -54, -54, -55, -55, -55,
-55, -56, -55, -56, -56, -57, -56, -56, -56, -57, -57, -57, -56, -56, -57, -55,
-57, -56, -56, -55, -55, -55, -54, -54, -54, -54, -54, -53, -53, -52, -51, -50,
-51, -49, -48, -47, -46, -45, -43, -42, -40, -39, -36, -34, -32, -29, -26, -24,
-20, -17, -15, -10, -6, -3, };