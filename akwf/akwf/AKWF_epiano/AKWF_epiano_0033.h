#define DATA_LENGTH 512
#define DATA AKWF_epiano_0033

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 16, 22, 29, 36, 44, 50, 56, 62,
67, 72, 78, 82, 87, 90, 93, 97, 100, 103, 106, 107, 109, 111, 112, 114, 115,
116, 117, 117, 118, 118, 119, 119, 119, 119, 119, 118, 119, 118, 117, 117, 117,
116, 115, 115, 113, 113, 112, 111, 110, 108, 108, 106, 104, 103, 102, 100, 99,
98, 96, 94, 92, 91, 88, 88, 86, 85, 82, 81, 79, 77, 76, 74, 73, 71, 69, 69, 67,
66, 64, 62, 62, 61, 60, 58, 57, 55, 55, 54, 53, 51, 51, 51, 50, 49, 49, 49, 47,
46, 46, 46, 44, 44, 43, 43, 42, 42, 41, 40, 39, 39, 38, 38, 38, 37, 37, 37, 36,
36, 34, 34, 33, 34, 32, 33, 33, 33, 31, 30, 31, 30, 30, 29, 29, 28, 28, 27, 27,
27, 27, 27, 27, 26, 27, 27, 27, 27, 27, 27, 27, 28, 28, 27, 28, 28, 27, 27, 27,
26, 25, 24, 22, 22, 20, 18, 16, 14, 13, 10, 7, 6, 3, 0, -2, -4, -8, -9, -11,
-14, -16, -18, -19, -22, -23, -25, -26, -27, -29, -30, -31, -31, -31, -32, -32,
-33, -33, -33, -32, -32, -32, -31, -30, -29, -29, -28, -27, -25, -24, -24, -23,
-21, -19, -18, -16, -14, -14, -13, -10, -9, -7, -5, -4, -3, -1, 0, 3, 4, 6, 7,
9, 11, 13, 14, 16, 17, 20, 21, 22, 23, 25, 27, 28, 30, 31, 32, 34, 35, 36, 37,
39, 39, 40, 42, 43, 44, 45, 46, 48, 48, 50, 50, 51, 51, 52, 54, 54, 55, 56, 57,
58, 58, 58, 59, 59, 60, 59, 59, 60, 60, 60, 60, 60, 60, 59, 59, 58, 57, 57, 55,
55, 54, 53, 51, 50, 48, 47, 45, 43, 40, 38, 35, 33, 29, 26, 22, 20, 16, 12, 7,
4, 0, -5, -8, -13, -18, -22, -25, -31, -35, -39, -43, -48, -52, -55, -61, -64,
-69, -71, -75, -79, -83, -85, -89, -92, -95, -97, -100, -104, -106, -108, -110,
-112, -113, -115, -116, -116, -116, -117, -116, -116, -116, -114, -112, -111,
-108, -106, -103, -100, -96, -93, -89, -87, -83, -80, -76, -74, -70, -66, -64,
-61, -59, -55, -53, -50, -48, -46, -44, -43, -40, -39, -38, -37, -36, -35, -34,
-32, -32, -32, -31, -30, -29, -29, -30, -30, -30, -31, -30, -30, -30, -31, -31,
-32, -33, -34, -35, -35, -36, -38, -38, -39, -40, -42, -43, -44, -46, -46, -49,
-50, -52, -54, -56, -57, -58, -60, -63, -64, -65, -67, -69, -70, -72, -73, -75,
-76, -77, -78, -79, -80, -81, -82, -82, -84, -84, -84, -84, -85, -84, -86, -85,
-86, -85, -85, -85, -84, -84, -84, -83, -83, -82, -80, -80, -79, -78, -78, -76,
-76, -75, -75, -74, -74, -73, -71, -71, -70, -70, -70, -69, -69, -70, -70, -69,
-69, -69, -69, -69, -69, -69, -69, -68, -68, -68, -68, -67, -66, -64, -64, -61,
-60, -57, -55, -52, -49, -45, -42, -38, -32, -27, -21, -16, -9, -3, };