#define DATA_LENGTH 512
#define DATA AKWF_epiano_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 11, 16, 20, 24, 28, 32, 36, 41,
44, 48, 53, 56, 59, 63, 66, 70, 72, 75, 79, 82, 84, 88, 91, 94, 96, 98, 102,
103, 105, 107, 109, 112, 113, 114, 115, 116, 117, 118, 118, 119, 118, 118, 117,
118, 116, 115, 115, 114, 113, 111, 109, 107, 106, 104, 101, 100, 98, 95, 92, 91,
89, 87, 85, 82, 80, 77, 75, 72, 71, 69, 66, 64, 62, 59, 56, 54, 53, 50, 49, 46,
44, 42, 40, 37, 36, 34, 32, 29, 27, 25, 23, 21, 19, 18, 16, 14, 12, 12, 11, 10,
8, 7, 7, 6, 4, 4, 3, 3, 3, 2, 2, 1, 1, 1, 1, 1, 2, 1, 2, 3, 2, 4, 5, 4, 5, 5, 6,
6, 7, 8, 9, 10, 11, 11, 12, 13, 13, 14, 15, 16, 17, 17, 18, 19, 19, 19, 21, 21,
21, 22, 22, 22, 23, 23, 23, 23, 22, 23, 23, 23, 23, 22, 22, 22, 21, 21, 20, 20,
19, 19, 19, 18, 17, 17, 17, 16, 15, 14, 13, 12, 11, 10, 10, 8, 7, 6, 5, 3, 2, 0,
-2, -4, -5, -8, -9, -11, -13, -14, -17, -19, -21, -23, -26, -27, -28, -31, -33,
-35, -37, -38, -40, -42, -44, -45, -46, -47, -49, -50, -51, -52, -53, -54, -55,
-57, -57, -58, -58, -59, -59, -61, -62, -62, -64, -64, -64, -66, -66, -68, -68,
-69, -70, -71, -71, -72, -72, -73, -73, -74, -73, -73, -74, -73, -74, -73, -72,
-73, -71, -71, -69, -70, -68, -68, -67, -65, -65, -63, -62, -60, -59, -58, -58,
-56, -55, -54, -54, -52, -52, -50, -49, -49, -48, -46, -47, -46, -44, -43, -43,
-43, -42, -40, -40, -40, -40, -37, -37, -36, -35, -34, -33, -32, -30, -30, -28,
-27, -26, -25, -23, -22, -21, -20, -18, -17, -16, -15, -14, -13, -11, -11, -10,
-9, -8, -7, -6, -6, -5, -5, -2, -3, -1, 0, -1, 0, 2, 3, 3, 4, 5, 6, 7, 7, 10,
11, 12, 13, 15, 16, 17, 19, 20, 21, 23, 24, 26, 27, 29, 31, 33, 33, 35, 37, 39,
40, 41, 43, 45, 45, 46, 49, 49, 52, 53, 53, 54, 55, 58, 59, 59, 61, 62, 62, 64,
64, 65, 66, 67, 68, 67, 68, 68, 69, 68, 69, 70, 69, 68, 69, 68, 68, 66, 66, 65,
65, 64, 62, 61, 60, 58, 57, 56, 54, 51, 50, 48, 45, 43, 41, 39, 36, 33, 30, 27,
24, 21, 17, 13, 10, 6, 1, -2, -6, -10, -13, -18, -22, -26, -29, -34, -38, -42,
-47, -50, -55, -58, -63, -66, -69, -73, -77, -79, -83, -87, -89, -91, -94, -97,
-99, -101, -103, -105, -107, -110, -111, -112, -113, -114, -116, -116, -117,
-118, -119, -118, -119, -119, -118, -119, -118, -118, -117, -116, -115, -114,
-113, -110, -109, -106, -104, -100, -98, -95, -92, -89, -85, -82, -77, -73, -69,
-64, -60, -56, -51, -46, -41, -37, -31, -27, -21, -16, -11, -7, -2, };