#define DATA_LENGTH 512
#define DATA AKWF_epiano_0061

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 12, 15, 18, 22, 26, 29, 32,
36, 39, 42, 45, 49, 52, 55, 58, 61, 64, 67, 69, 71, 74, 77, 79, 81, 84, 86, 89,
90, 92, 93, 96, 98, 100, 102, 102, 104, 105, 106, 108, 108, 110, 110, 111, 112,
113, 113, 113, 113, 114, 114, 114, 114, 114, 114, 114, 114, 114, 114, 112, 113,
112, 111, 110, 109, 110, 109, 107, 106, 106, 105, 103, 102, 101, 100, 98, 97,
96, 94, 93, 93, 89, 89, 87, 86, 84, 83, 81, 79, 79, 77, 75, 73, 71, 70, 69, 67,
65, 63, 62, 60, 59, 56, 56, 54, 51, 51, 49, 48, 46, 45, 43, 42, 40, 39, 37, 36,
35, 33, 32, 31, 30, 29, 27, 26, 25, 24, 22, 23, 22, 20, 20, 19, 19, 18, 17, 17,
16, 16, 16, 15, 14, 14, 15, 14, 14, 14, 13, 14, 14, 14, 15, 14, 15, 15, 16, 16,
17, 17, 17, 19, 18, 20, 20, 21, 22, 22, 23, 23, 24, 25, 26, 27, 28, 29, 30, 31,
32, 34, 34, 34, 36, 37, 37, 39, 39, 40, 41, 42, 43, 44, 44, 45, 46, 46, 48, 48,
48, 50, 51, 51, 52, 53, 53, 53, 54, 55, 55, 56, 56, 56, 56, 57, 57, 58, 57, 58,
58, 59, 59, 59, 59, 59, 59, 60, 59, 60, 60, 59, 60, 59, 59, 58, 58, 59, 59, 58,
59, 58, 57, 57, 56, 56, 56, 55, 55, 55, 54, 53, 53, 53, 52, 51, 51, 50, 49, 49,
49, 48, 47, 46, 46, 45, 43, 42, 42, 41, 39, 38, 38, 36, 36, 34, 34, 32, 31, 30,
29, 28, 26, 25, 24, 23, 21, 20, 19, 18, 16, 14, 14, 13, 11, 9, 8, 6, 5, 3, 1, 1,
-2, -3, -4, -5, -7, -8, -10, -10, -12, -14, -15, -17, -18, -19, -20, -22, -24,
-25, -26, -27, -29, -30, -31, -33, -34, -35, -36, -38, -39, -40, -41, -42, -42,
-43, -45, -46, -47, -48, -49, -50, -51, -52, -53, -53, -54, -56, -55, -57, -57,
-59, -58, -60, -60, -62, -61, -63, -64, -65, -65, -66, -67, -68, -68, -69, -69,
-70, -72, -71, -72, -73, -74, -74, -76, -76, -76, -78, -78, -79, -80, -80, -82,
-82, -84, -84, -84, -85, -87, -87, -88, -89, -89, -90, -90, -91, -91, -93, -94,
-95, -96, -96, -98, -98, -99, -99, -101, -101, -101, -103, -103, -104, -105,
-106, -107, -107, -107, -109, -108, -110, -111, -110, -111, -112, -112, -112,
-113, -113, -114, -116, -115, -115, -116, -117, -116, -116, -117, -118, -118,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -120, -119, -119,
-119, -118, -118, -118, -118, -116, -116, -116, -115, -115, -114, -113, -113,
-111, -112, -111, -110, -109, -108, -107, -105, -103, -102, -102, -99, -98, -97,
-95, -93, -91, -89, -88, -85, -83, -81, -79, -76, -73, -71, -68, -66, -63, -60,
-57, -54, -52, -48, -45, -43, -39, -35, -32, -29, -26, -21, -19, -15, -11, -8,
-4, -2, };