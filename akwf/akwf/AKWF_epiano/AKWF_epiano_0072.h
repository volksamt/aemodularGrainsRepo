#define DATA_LENGTH 512
#define DATA AKWF_epiano_0072

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 12, 16, 22, 26, 31, 37, 40, 46,
51, 55, 60, 64, 68, 72, 77, 80, 83, 87, 91, 92, 96, 98, 101, 103, 105, 107, 108,
110, 112, 113, 115, 115, 117, 117, 117, 118, 119, 118, 119, 120, 119, 119, 119,
118, 118, 119, 118, 117, 116, 115, 115, 114, 113, 112, 112, 110, 109, 109, 107,
105, 104, 104, 101, 100, 99, 98, 97, 95, 93, 91, 90, 88, 87, 85, 84, 83, 81, 79,
78, 76, 73, 72, 70, 68, 66, 65, 64, 62, 59, 57, 55, 53, 53, 50, 49, 46, 45, 43,
41, 40, 38, 37, 35, 33, 31, 30, 28, 26, 24, 22, 20, 20, 17, 15, 14, 12, 11, 9,
7, 5, 4, 3, 1, 0, -1, -4, -5, -6, -7, -8, -11, -11, -13, -14, -16, -16, -18,
-18, -21, -21, -23, -23, -24, -25, -27, -27, -28, -30, -30, -31, -32, -33, -34,
-33, -35, -35, -36, -36, -36, -36, -37, -37, -37, -37, -38, -37, -36, -36, -36,
-35, -35, -35, -35, -35, -34, -33, -33, -33, -31, -31, -30, -30, -29, -29, -28,
-28, -28, -28, -27, -26, -26, -25, -25, -25, -24, -25, -25, -23, -24, -23, -23,
-23, -22, -22, -22, -22, -22, -21, -21, -20, -20, -20, -20, -20, -20, -18, -19,
-18, -19, -18, -18, -17, -16, -16, -16, -16, -15, -14, -14, -14, -14, -13, -12,
-12, -12, -11, -10, -10, -10, -10, -9, -9, -8, -7, -8, -7, -7, -6, -6, -6, -5,
-5, -5, -4, -4, -4, -5, -5, -4, -4, -4, -4, -3, -4, -4, -3, -4, -5, -5, -5, -5,
-6, -6, -6, -7, -7, -7, -8, -7, -9, -9, -9, -11, -11, -12, -12, -14, -13, -15,
-15, -15, -16, -16, -17, -18, -20, -20, -20, -22, -22, -23, -24, -25, -26, -27,
-27, -28, -30, -30, -30, -31, -32, -33, -33, -35, -35, -35, -37, -38, -38, -39,
-40, -40, -41, -41, -42, -42, -43, -43, -42, -42, -42, -41, -41, -40, -40, -38,
-37, -36, -35, -33, -31, -30, -27, -27, -24, -22, -21, -18, -16, -14, -12, -11,
-8, -7, -5, -3, -2, 0, 3, 3, 5, 7, 7, 8, 10, 11, 12, 12, 14, 14, 14, 15, 15, 17,
17, 16, 17, 17, 17, 16, 16, 16, 16, 16, 15, 14, 14, 13, 12, 11, 10, 9, 9, 8, 7,
5, 5, 4, 2, 1, 0, -1, -2, -4, -6, -7, -8, -10, -11, -13, -14, -16, -18, -20,
-21, -22, -24, -25, -27, -29, -30, -31, -33, -35, -35, -37, -39, -40, -41, -42,
-43, -43, -45, -47, -47, -49, -48, -49, -50, -51, -51, -53, -53, -54, -55, -56,
-55, -56, -56, -57, -56, -57, -57, -58, -57, -59, -58, -58, -59, -58, -57, -57,
-58, -58, -58, -58, -58, -57, -57, -57, -58, -57, -56, -56, -56, -55, -56, -55,
-56, -55, -55, -55, -54, -54, -52, -53, -53, -52, -51, -51, -49, -49, -48, -47,
-45, -43, -42, -40, -37, -35, -32, -29, -26, -22, -19, -14, -11, -7, -2, };