#define DATA_LENGTH 512
#define DATA AKWF_epiano_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 5, 6, 6, 8, 9, 11, 12, 12,
13, 14, 16, 16, 17, 18, 19, 20, 21, 22, 23, 22, 24, 24, 25, 26, 26, 27, 28, 28,
29, 29, 30, 30, 31, 31, 30, 32, 32, 32, 32, 34, 34, 33, 34, 35, 33, 34, 35, 35,
36, 36, 36, 36, 36, 36, 37, 37, 37, 37, 39, 38, 39, 38, 40, 40, 40, 40, 41, 41,
42, 42, 42, 43, 43, 44, 44, 45, 45, 47, 46, 47, 48, 48, 49, 49, 51, 51, 52, 52,
53, 55, 55, 56, 57, 58, 59, 61, 61, 63, 63, 64, 65, 66, 67, 68, 70, 71, 72, 73,
74, 75, 76, 77, 79, 80, 82, 82, 84, 85, 85, 87, 88, 89, 91, 92, 92, 94, 95, 96,
97, 98, 100, 101, 102, 103, 104, 105, 105, 106, 107, 108, 109, 110, 111, 111,
112, 112, 113, 114, 114, 116, 116, 116, 117, 117, 117, 117, 118, 118, 119, 118,
118, 119, 119, 119, 120, 119, 119, 119, 118, 118, 118, 117, 118, 117, 118, 116,
116, 115, 115, 115, 114, 114, 113, 112, 111, 110, 110, 109, 108, 108, 107, 106,
105, 104, 102, 103, 101, 100, 99, 99, 97, 96, 94, 93, 93, 91, 90, 89, 87, 86,
85, 83, 82, 82, 81, 78, 77, 75, 74, 73, 72, 71, 69, 67, 66, 64, 63, 63, 61, 59,
58, 56, 55, 53, 52, 50, 49, 47, 46, 44, 43, 41, 41, 38, 38, 36, 35, 33, 31, 30,
29, 27, 26, 24, 22, 20, 20, 18, 16, 16, 13, 12, 10, 9, 8, 7, 5, 3, 2, 1, -1, -2,
-4, -6, -6, -8, -9, -11, -13, -14, -15, -17, -19, -20, -21, -22, -23, -25, -26,
-27, -29, -30, -31, -33, -34, -36, -36, -38, -39, -41, -41, -42, -45, -44, -46,
-47, -48, -50, -52, -52, -53, -55, -56, -57, -58, -60, -60, -61, -62, -64, -65,
-65, -67, -68, -68, -70, -70, -71, -72, -73, -74, -75, -77, -77, -78, -79, -80,
-81, -82, -83, -84, -84, -85, -86, -86, -88, -88, -89, -90, -90, -91, -92, -93,
-94, -95, -95, -96, -98, -97, -98, -99, -100, -100, -100, -101, -101, -102,
-103, -103, -103, -105, -106, -106, -106, -106, -106, -108, -107, -109, -109,
-109, -109, -110, -110, -110, -110, -111, -111, -112, -112, -112, -112, -112,
-112, -113, -112, -113, -113, -114, -113, -113, -113, -114, -113, -114, -114,
-114, -113, -113, -113, -113, -113, -112, -113, -113, -112, -112, -112, -111,
-111, -110, -110, -110, -109, -109, -108, -109, -108, -107, -106, -105, -105,
-105, -104, -102, -102, -102, -101, -100, -99, -98, -98, -96, -96, -95, -93,
-93, -91, -91, -90, -88, -87, -86, -85, -83, -82, -81, -80, -78, -77, -76, -74,
-73, -72, -70, -69, -66, -65, -64, -62, -61, -59, -58, -56, -54, -54, -51, -50,
-47, -46, -44, -43, -42, -39, -38, -35, -35, -33, -31, -30, -27, -25, -24, -22,
-21, -19, -18, -16, -16, -13, -12, -11, -8, -8, -6, -4, -2, -3, 0, };