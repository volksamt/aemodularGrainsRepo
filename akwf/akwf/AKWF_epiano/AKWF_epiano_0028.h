#define DATA_LENGTH 512
#define DATA AKWF_epiano_0028

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 11, 16, 19, 25, 28, 33, 37, 41,
46, 50, 53, 57, 62, 66, 69, 72, 77, 80, 84, 86, 89, 92, 95, 98, 100, 102, 104,
106, 108, 109, 111, 113, 113, 115, 116, 116, 117, 118, 118, 118, 118, 118, 120,
119, 119, 118, 118, 118, 118, 117, 116, 115, 115, 114, 113, 112, 111, 109, 108,
107, 106, 104, 103, 101, 99, 97, 96, 95, 93, 91, 89, 88, 86, 85, 82, 80, 77, 76,
75, 72, 71, 69, 67, 64, 64, 60, 59, 57, 56, 53, 51, 49, 48, 45, 44, 41, 39, 38,
36, 34, 32, 30, 29, 27, 25, 24, 22, 20, 19, 18, 16, 14, 12, 11, 10, 8, 8, 6, 4,
4, 2, 1, 0, -1, -2, -2, -4, -4, -6, -6, -7, -7, -8, -9, -9, -10, -10, -11, -11,
-11, -12, -12, -12, -11, -11, -11, -10, -12, -11, -10, -10, -9, -8, -9, -7, -7,
-6, -4, -4, -2, -2, 0, 0, 2, 3, 4, 7, 7, 10, 11, 13, 15, 16, 18, 19, 22, 24, 26,
28, 30, 32, 33, 36, 36, 39, 40, 42, 43, 44, 47, 48, 49, 51, 51, 53, 54, 55, 56,
57, 57, 59, 59, 60, 61, 61, 62, 63, 62, 63, 64, 65, 64, 65, 65, 66, 65, 66, 66,
67, 66, 66, 67, 67, 67, 68, 67, 66, 67, 67, 67, 67, 68, 68, 68, 67, 68, 67, 67,
67, 67, 67, 66, 65, 66, 65, 64, 64, 64, 63, 63, 63, 62, 62, 62, 61, 60, 59, 58,
58, 57, 57, 56, 54, 54, 53, 53, 51, 51, 50, 49, 47, 46, 45, 43, 42, 41, 40, 38,
37, 36, 33, 32, 31, 30, 28, 27, 24, 23, 22, 19, 17, 16, 14, 13, 11, 10, 8, 6, 3,
1, 0, -3, -4, -6, -9, -11, -12, -15, -17, -19, -21, -23, -25, -26, -30, -32,
-34, -35, -38, -40, -41, -44, -45, -47, -49, -51, -53, -54, -56, -57, -59, -60,
-61, -62, -63, -65, -65, -66, -67, -68, -68, -69, -69, -70, -69, -71, -70, -71,
-71, -71, -71, -71, -71, -71, -71, -71, -70, -71, -71, -70, -71, -70, -71, -71,
-70, -70, -70, -70, -71, -71, -70, -71, -72, -72, -71, -71, -72, -72, -73, -73,
-72, -72, -72, -74, -74, -74, -75, -75, -76, -77, -76, -77, -78, -77, -79, -79,
-80, -80, -80, -81, -82, -82, -83, -83, -85, -85, -86, -85, -87, -87, -87, -89,
-88, -89, -90, -91, -91, -91, -92, -92, -93, -93, -95, -95, -95, -95, -96, -97,
-96, -96, -97, -98, -98, -98, -98, -98, -98, -99, -99, -99, -99, -99, -99, -99,
-99, -99, -99, -99, -99, -98, -99, -98, -98, -97, -97, -97, -97, -96, -96, -95,
-95, -94, -94, -93, -93, -92, -91, -91, -91, -90, -89, -89, -88, -87, -86, -85,
-85, -84, -82, -81, -80, -78, -77, -76, -75, -72, -72, -68, -67, -65, -63, -61,
-59, -57, -53, -51, -47, -44, -41, -39, -35, -32, -28, -25, -21, -17, -13, -9,
-5, -1, };