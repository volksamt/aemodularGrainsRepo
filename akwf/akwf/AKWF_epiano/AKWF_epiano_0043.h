#define DATA_LENGTH 512
#define DATA AKWF_epiano_0043

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 9, 14, 19, 23, 28, 32, 37, 41,
45, 51, 56, 59, 63, 67, 72, 75, 79, 82, 86, 89, 92, 94, 98, 100, 103, 104, 107,
108, 110, 111, 113, 114, 115, 117, 117, 118, 118, 118, 118, 119, 120, 119, 119,
119, 118, 118, 117, 117, 115, 115, 114, 112, 112, 111, 109, 108, 108, 105, 104,
103, 101, 100, 97, 95, 94, 92, 90, 88, 86, 83, 82, 80, 77, 75, 74, 71, 68, 67,
65, 62, 60, 58, 56, 52, 50, 49, 46, 44, 43, 40, 38, 35, 33, 31, 29, 28, 26, 23,
22, 20, 18, 16, 15, 13, 11, 9, 7, 5, 5, 3, 1, 0, -2, -4, -5, -6, -7, -9, -10,
-12, -13, -14, -15, -16, -17, -18, -20, -20, -21, -22, -23, -23, -25, -24, -25,
-25, -25, -26, -26, -26, -26, -26, -26, -26, -26, -25, -24, -24, -23, -23, -22,
-22, -21, -21, -19, -17, -17, -15, -14, -12, -11, -10, -7, -6, -3, -2, 0, 2, 5,
7, 9, 10, 13, 15, 17, 19, 22, 23, 25, 28, 30, 31, 34, 34, 37, 38, 40, 41, 43,
44, 46, 47, 48, 49, 50, 50, 51, 52, 54, 54, 54, 56, 56, 57, 57, 58, 58, 59, 59,
60, 60, 61, 60, 61, 62, 62, 62, 63, 63, 64, 64, 64, 65, 66, 65, 66, 66, 67, 66,
67, 68, 68, 68, 69, 69, 69, 69, 70, 70, 70, 70, 71, 71, 71, 71, 71, 71, 71, 71,
70, 72, 70, 70, 70, 69, 70, 69, 69, 68, 69, 68, 67, 66, 65, 64, 64, 64, 62, 62,
61, 61, 59, 57, 57, 55, 54, 52, 52, 50, 49, 48, 46, 44, 42, 41, 39, 38, 36, 34,
31, 30, 28, 26, 24, 21, 20, 17, 15, 13, 11, 8, 6, 3, 0, -2, -4, -8, -10, -14,
-16, -19, -23, -25, -28, -31, -33, -38, -39, -43, -45, -49, -51, -55, -57, -60,
-63, -65, -66, -69, -71, -72, -74, -75, -77, -78, -79, -80, -80, -80, -81, -81,
-82, -82, -81, -81, -81, -79, -79, -79, -78, -78, -77, -76, -76, -75, -74, -73,
-73, -72, -72, -71, -70, -70, -69, -69, -68, -68, -67, -68, -66, -66, -67, -65,
-65, -66, -65, -64, -65, -64, -65, -64, -64, -65, -64, -65, -65, -65, -65, -65,
-66, -66, -65, -67, -66, -67, -67, -67, -68, -68, -69, -68, -69, -70, -71, -71,
-72, -73, -73, -74, -74, -74, -75, -76, -76, -78, -77, -78, -79, -80, -80, -81,
-81, -81, -83, -83, -83, -84, -85, -84, -85, -86, -85, -86, -86, -87, -86, -87,
-87, -87, -87, -88, -88, -87, -88, -87, -88, -88, -88, -88, -87, -87, -87, -87,
-87, -87, -86, -86, -86, -85, -84, -85, -84, -84, -84, -82, -82, -82, -82, -81,
-80, -80, -81, -80, -79, -78, -78, -78, -77, -76, -75, -75, -74, -74, -73, -71,
-69, -69, -67, -66, -64, -62, -60, -58, -56, -54, -52, -49, -46, -44, -40, -38,
-33, -31, -27, -24, -20, -16, -11, -7, -2, };