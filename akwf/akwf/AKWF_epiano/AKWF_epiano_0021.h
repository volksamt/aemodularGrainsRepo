#define DATA_LENGTH 512
#define DATA AKWF_epiano_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 3, 4, 4, 6, 6, 7, 7, 8, 8, 9,
10, 11, 12, 12, 13, 13, 13, 14, 15, 16, 16, 17, 17, 18, 19, 20, 20, 20, 21, 22,
22, 23, 23, 24, 24, 25, 26, 26, 27, 28, 28, 28, 29, 30, 30, 31, 32, 33, 34, 34,
35, 35, 35, 37, 37, 38, 39, 39, 41, 41, 41, 42, 43, 44, 46, 46, 48, 49, 49, 50,
50, 52, 53, 54, 55, 56, 58, 59, 61, 62, 63, 64, 65, 67, 68, 69, 71, 72, 75, 75,
77, 78, 81, 81, 84, 85, 87, 88, 91, 92, 94, 96, 97, 98, 100, 102, 103, 105, 107,
109, 110, 112, 112, 115, 115, 117, 118, 118, 119, 119, 119, 118, 117, 116, 115,
112, 109, 106, 102, 99, 95, 91, 86, 81, 77, 71, 68, 63, 59, 54, 49, 45, 42, 37,
35, 30, 28, 24, 22, 19, 17, 14, 11, 10, 8, 5, 3, 0, -1, -3, -5, -6, -7, -9, -12,
-13, -14, -16, -18, -19, -21, -22, -23, -25, -27, -27, -29, -29, -31, -32, -33,
-33, -36, -37, -37, -38, -39, -39, -40, -41, -42, -43, -43, -45, -44, -45, -45,
-46, -47, -47, -47, -48, -49, -49, -49, -50, -50, -50, -50, -51, -51, -50, -51,
-51, -52, -52, -52, -53, -52, -53, -52, -53, -52, -53, -53, -52, -52, -52, -53,
-53, -52, -52, -52, -51, -50, -50, -51, -50, -50, -49, -49, -49, -48, -48, -47,
-46, -47, -45, -45, -44, -44, -43, -42, -42, -41, -40, -39, -38, -38, -38, -35,
-35, -34, -33, -33, -31, -31, -30, -30, -28, -27, -26, -25, -23, -23, -22, -20,
-19, -18, -17, -16, -14, -14, -12, -11, -10, -8, -8, -6, -4, -4, -2, -1, 0, 1,
2, 4, 6, 7, 9, 10, 12, 13, 13, 15, 17, 18, 21, 21, 23, 24, 27, 29, 29, 32, 33,
35, 37, 39, 40, 42, 44, 45, 47, 50, 51, 52, 54, 56, 58, 59, 61, 63, 64, 65, 65,
67, 67, 67, 68, 66, 66, 64, 61, 59, 57, 53, 50, 46, 42, 38, 33, 28, 25, 21, 16,
12, 7, 5, 0, -3, -6, -9, -13, -15, -17, -21, -23, -25, -27, -29, -31, -33, -35,
-36, -38, -40, -40, -43, -44, -45, -46, -48, -48, -50, -51, -51, -52, -53, -54,
-55, -55, -57, -57, -58, -58, -58, -59, -60, -60, -60, -61, -61, -61, -61, -61,
-61, -62, -61, -61, -61, -61, -62, -61, -61, -61, -61, -61, -60, -60, -59, -60,
-59, -60, -60, -59, -59, -58, -57, -58, -57, -57, -56, -56, -55, -54, -56, -55,
-54, -54, -52, -52, -52, -51, -51, -51, -50, -49, -48, -49, -48, -47, -46, -46,
-45, -45, -45, -43, -43, -42, -41, -41, -40, -39, -39, -37, -37, -35, -36, -35,
-33, -33, -32, -31, -30, -29, -28, -27, -26, -25, -24, -23, -23, -21, -21, -19,
-19, -19, -17, -17, -15, -14, -14, -13, -12, -10, -9, -10, -8, -7, -7, -5, -5,
-4, -2, -2, -2, -1, 0, };