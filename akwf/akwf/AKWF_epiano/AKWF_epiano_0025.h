#define DATA_LENGTH 512
#define DATA AKWF_epiano_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 7, 10, 14, 17, 21, 24, 28, 31,
35, 39, 42, 46, 50, 53, 57, 60, 64, 67, 71, 74, 77, 79, 82, 84, 88, 89, 92, 94,
96, 98, 101, 103, 104, 107, 107, 109, 110, 112, 112, 114, 114, 115, 116, 117,
117, 118, 119, 119, 118, 119, 119, 119, 118, 119, 118, 119, 119, 118, 118, 117,
117, 116, 116, 116, 115, 114, 114, 113, 113, 112, 111, 110, 109, 109, 108, 108,
107, 106, 104, 104, 102, 101, 100, 100, 98, 97, 96, 95, 94, 93, 93, 92, 91, 90,
88, 87, 85, 85, 83, 82, 81, 80, 79, 78, 77, 75, 74, 72, 71, 70, 69, 67, 66, 65,
64, 62, 61, 59, 59, 57, 56, 53, 52, 52, 50, 49, 48, 46, 44, 44, 42, 40, 40, 38,
38, 36, 34, 33, 32, 31, 29, 28, 27, 27, 25, 23, 22, 22, 21, 19, 19, 17, 17, 16,
15, 15, 13, 14, 12, 12, 12, 10, 10, 10, 10, 9, 8, 9, 9, 9, 8, 8, 7, 8, 7, 7, 7,
6, 5, 6, 6, 5, 5, 6, 5, 4, 5, 4, 4, 4, 3, 3, 3, 2, 2, 2, 2, 2, 1, 1, 0, 1, 1,
-1, -1, -1, -2, -2, -1, -2, -2, -2, -2, -3, -3, -3, -4, -4, -5, -4, -4, -5, -5,
-4, -5, -4, -5, -5, -5, -5, -5, -5, -5, -6, -6, -6, -6, -7, -6, -6, -7, -7, -7,
-6, -6, -7, -7, -7, -8, -7, -8, -8, -8, -7, -8, -8, -8, -9, -8, -8, -9, -9, -10,
-10, -10, -11, -11, -12, -12, -13, -13, -13, -14, -13, -14, -15, -15, -15, -17,
-17, -17, -17, -18, -19, -20, -20, -21, -22, -22, -23, -24, -24, -25, -25, -27,
-27, -28, -29, -30, -31, -32, -33, -33, -35, -36, -36, -37, -39, -39, -41, -41,
-43, -44, -45, -46, -46, -47, -49, -50, -50, -52, -53, -54, -55, -56, -57, -58,
-59, -60, -60, -61, -62, -62, -63, -64, -64, -64, -64, -65, -65, -65, -65, -64,
-64, -63, -64, -64, -63, -62, -61, -61, -60, -60, -59, -59, -58, -57, -55, -54,
-53, -52, -52, -51, -51, -49, -49, -48, -47, -46, -45, -45, -44, -44, -42, -42,
-42, -41, -40, -40, -40, -40, -39, -40, -40, -39, -39, -38, -40, -40, -39, -39,
-39, -39, -39, -40, -40, -41, -41, -41, -42, -42, -42, -44, -43, -44, -45, -45,
-46, -48, -47, -49, -49, -50, -50, -52, -52, -53, -53, -54, -55, -56, -57, -57,
-57, -60, -58, -61, -61, -62, -62, -63, -64, -65, -64, -65, -65, -66, -67, -68,
-68, -69, -69, -69, -70, -70, -71, -71, -71, -71, -72, -72, -73, -73, -72, -72,
-73, -72, -72, -73, -72, -73, -72, -72, -71, -71, -72, -70, -71, -70, -70, -69,
-68, -68, -67, -66, -66, -65, -64, -63, -63, -61, -61, -59, -58, -57, -56, -55,
-53, -52, -50, -48, -46, -45, -44, -41, -39, -37, -35, -33, -31, -28, -26, -23,
-20, -17, -15, -11, -8, -6, -2, };