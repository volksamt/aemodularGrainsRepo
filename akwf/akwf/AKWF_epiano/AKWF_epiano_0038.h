#define DATA_LENGTH 512
#define DATA AKWF_epiano_0038

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 18, 32, 46, 59, 71, 81, 89, 96,
101, 106, 110, 112, 113, 115, 116, 116, 116, 117, 117, 117, 117, 118, 119, 117,
119, 119, 119, 118, 119, 119, 119, 118, 119, 119, 118, 118, 117, 117, 117, 116,
117, 116, 115, 115, 114, 113, 113, 111, 111, 111, 110, 109, 108, 107, 105, 104,
103, 101, 101, 99, 97, 96, 94, 93, 92, 90, 87, 85, 84, 81, 79, 77, 75, 73, 70,
68, 66, 64, 60, 58, 55, 53, 51, 49, 46, 44, 43, 40, 39, 37, 36, 34, 32, 30, 30,
29, 27, 26, 25, 23, 22, 22, 20, 20, 18, 18, 16, 16, 14, 13, 13, 11, 10, 9, 7, 7,
5, 3, 2, 1, -2, -4, -5, -7, -9, -11, -12, -14, -16, -18, -21, -22, -24, -27,
-28, -30, -32, -35, -36, -39, -41, -42, -45, -47, -48, -51, -51, -53, -54, -57,
-58, -60, -60, -63, -63, -64, -65, -66, -67, -69, -70, -71, -71, -70, -70, -70,
-69, -67, -65, -61, -59, -57, -54, -53, -51, -49, -48, -47, -47, -46, -46, -46,
-45, -45, -46, -44, -45, -45, -43, -44, -44, -42, -41, -40, -41, -39, -38, -39,
-38, -38, -37, -37, -35, -35, -35, -33, -33, -32, -32, -30, -30, -30, -29, -28,
-27, -28, -26, -25, -25, -24, -23, -21, -21, -19, -19, -18, -17, -15, -13, -13,
-11, -10, -9, -7, -5, -4, -1, 0, 1, 4, 6, 6, 8, 11, 13, 15, 16, 19, 21, 22, 24,
26, 28, 29, 30, 31, 33, 35, 36, 37, 37, 39, 40, 41, 42, 42, 42, 43, 44, 43, 43,
44, 43, 43, 44, 44, 44, 43, 41, 42, 41, 39, 38, 37, 36, 35, 34, 33, 32, 29, 29,
26, 25, 23, 21, 20, 18, 17, 13, 12, 10, 8, 6, 4, 1, -1, -3, -6, -8, -10, -13,
-15, -18, -21, -23, -25, -28, -31, -34, -36, -38, -42, -45, -47, -50, -54, -56,
-59, -63, -64, -68, -70, -73, -76, -79, -81, -82, -83, -81, -77, -73, -67, -61,
-53, -45, -37, -28, -22, -15, -10, -4, 0, 4, 6, 9, 10, 11, 12, 12, 14, 14, 15,
15, 15, 15, 16, 16, 17, 17, 16, 17, 17, 18, 18, 18, 17, 19, 18, 19, 18, 19, 19,
19, 20, 19, 20, 19, 20, 19, 19, 19, 19, 19, 18, 18, 17, 18, 17, 16, 15, 14, 13,
11, 9, 9, 7, 5, 3, 0, -1, -3, -7, -9, -11, -15, -16, -21, -23, -26, -28, -32,
-35, -38, -41, -44, -46, -49, -52, -55, -56, -59, -61, -62, -64, -65, -67, -68,
-70, -70, -71, -72, -72, -71, -72, -73, -72, -72, -71, -71, -70, -69, -68, -68,
-68, -66, -65, -64, -62, -62, -61, -59, -60, -59, -56, -56, -55, -54, -53, -52,
-51, -50, -49, -50, -48, -48, -47, -47, -47, -47, -47, -47, -47, -47, -48, -48,
-49, -50, -51, -53, -53, -55, -57, -58, -60, -62, -64, -66, -67, -70, -70, -71,
-71, -69, -67, -64, -58, -52, -42, -33, -20, -7, };