#define DATA_LENGTH 512
#define DATA AKWF_epiano_0032

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 11, 18, 25, 32, 38, 44, 50, 56, 61,
66, 71, 75, 79, 82, 85, 88, 91, 94, 95, 98, 98, 100, 101, 102, 103, 104, 104,
104, 105, 105, 106, 105, 106, 105, 105, 106, 105, 105, 104, 104, 103, 102, 102,
102, 100, 99, 98, 98, 96, 95, 94, 93, 91, 90, 89, 88, 86, 84, 82, 80, 78, 77,
75, 74, 71, 70, 69, 66, 64, 63, 61, 59, 57, 55, 54, 52, 51, 49, 47, 46, 45, 43,
42, 41, 40, 38, 37, 36, 36, 34, 33, 33, 32, 31, 30, 29, 28, 28, 27, 27, 26, 25,
25, 24, 24, 24, 22, 22, 21, 20, 20, 20, 20, 20, 19, 18, 19, 19, 18, 19, 19, 19,
18, 19, 18, 19, 19, 19, 20, 19, 19, 19, 19, 19, 19, 20, 20, 20, 21, 21, 21, 22,
23, 23, 24, 26, 26, 27, 27, 28, 28, 29, 29, 29, 30, 29, 28, 28, 27, 25, 24, 22,
20, 19, 15, 13, 10, 7, 5, 1, -2, -5, -8, -10, -14, -17, -20, -22, -24, -27, -29,
-31, -33, -34, -35, -36, -37, -38, -39, -40, -39, -40, -40, -40, -39, -39, -38,
-38, -36, -35, -34, -33, -32, -31, -29, -29, -27, -25, -23, -22, -20, -18, -16,
-15, -14, -11, -9, -7, -6, -4, -1, 0, 2, 4, 6, 9, 11, 12, 15, 16, 18, 20, 22,
23, 26, 28, 29, 31, 33, 35, 37, 38, 40, 42, 43, 44, 46, 47, 49, 51, 51, 53, 53,
55, 57, 58, 59, 60, 61, 62, 63, 65, 65, 65, 67, 68, 69, 69, 70, 71, 72, 72, 72,
73, 73, 74, 74, 74, 74, 73, 74, 73, 74, 72, 73, 72, 71, 70, 70, 69, 68, 67, 65,
65, 63, 61, 58, 56, 54, 51, 48, 46, 41, 38, 35, 31, 28, 23, 19, 15, 11, 7, 2,
-2, -7, -11, -16, -20, -25, -29, -34, -39, -43, -47, -53, -57, -62, -65, -70,
-74, -78, -82, -86, -89, -93, -95, -99, -102, -104, -107, -109, -112, -113,
-115, -117, -117, -119, -120, -119, -119, -119, -118, -116, -113, -111, -109,
-106, -104, -100, -97, -92, -89, -85, -82, -78, -73, -70, -67, -63, -60, -57,
-54, -51, -49, -46, -43, -41, -40, -38, -36, -34, -33, -32, -30, -30, -28, -27,
-26, -25, -25, -24, -24, -23, -23, -22, -22, -21, -21, -21, -23, -22, -21, -22,
-23, -24, -24, -25, -26, -27, -28, -29, -31, -32, -33, -34, -37, -38, -40, -41,
-43, -45, -47, -48, -51, -53, -54, -56, -57, -59, -61, -63, -65, -65, -66, -68,
-70, -71, -72, -72, -72, -74, -74, -75, -76, -75, -76, -76, -76, -75, -75, -75,
-75, -74, -73, -73, -72, -71, -70, -70, -68, -68, -66, -66, -65, -64, -62, -62,
-61, -61, -60, -60, -60, -60, -60, -59, -61, -60, -61, -62, -61, -62, -64, -64,
-65, -66, -66, -67, -68, -69, -68, -68, -68, -68, -68, -67, -65, -65, -62, -60,
-58, -54, -51, -48, -44, -39, -33, -28, -22, -16, -9, -2, };