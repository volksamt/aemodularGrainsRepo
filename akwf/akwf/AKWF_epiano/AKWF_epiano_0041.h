#define DATA_LENGTH 512
#define DATA AKWF_epiano_0041

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 8, 10, 14, 17, 21, 23, 27, 30,
34, 37, 40, 44, 47, 50, 54, 57, 60, 63, 66, 70, 73, 75, 78, 81, 84, 86, 88, 90,
92, 94, 96, 99, 101, 102, 104, 106, 107, 108, 110, 112, 111, 113, 114, 115, 115,
116, 116, 118, 118, 118, 118, 118, 119, 119, 119, 119, 119, 119, 118, 118, 118,
118, 118, 117, 117, 117, 116, 116, 115, 114, 113, 113, 112, 112, 110, 110, 110,
108, 107, 107, 105, 104, 104, 103, 103, 101, 100, 99, 98, 97, 96, 95, 94, 93,
92, 91, 89, 88, 86, 86, 84, 83, 83, 81, 80, 78, 78, 76, 75, 73, 72, 72, 69, 68,
67, 66, 64, 63, 62, 60, 60, 58, 56, 55, 54, 52, 51, 50, 48, 47, 45, 45, 43, 41,
41, 39, 38, 36, 35, 34, 33, 31, 30, 29, 29, 27, 27, 24, 23, 23, 21, 21, 21, 19,
18, 18, 17, 16, 15, 14, 14, 12, 12, 12, 12, 11, 11, 11, 9, 9, 10, 9, 9, 9, 8, 8,
7, 7, 7, 7, 6, 6, 6, 5, 6, 5, 5, 5, 5, 5, 4, 4, 3, 3, 3, 3, 2, 3, 2, 1, 1, 2, 0,
1, 0, 0, -1, -1, -1, -2, -1, -2, -2, -2, -3, -3, -3, -3, -3, -5, -4, -5, -5, -5,
-5, -5, -5, -5, -6, -6, -6, -6, -6, -7, -7, -7, -8, -7, -8, -8, -8, -8, -9, -8,
-8, -9, -10, -10, -9, -10, -10, -10, -10, -11, -11, -11, -12, -11, -11, -13,
-13, -13, -13, -13, -14, -14, -15, -15, -15, -15, -15, -16, -17, -17, -18, -18,
-19, -19, -19, -20, -21, -22, -22, -21, -23, -23, -23, -24, -25, -25, -26, -27,
-27, -28, -29, -31, -30, -31, -32, -33, -34, -35, -35, -36, -36, -37, -39, -39,
-40, -42, -42, -43, -44, -45, -45, -46, -47, -48, -49, -50, -51, -52, -52, -54,
-54, -55, -56, -56, -58, -58, -58, -60, -60, -60, -61, -61, -61, -62, -62, -61,
-62, -63, -62, -62, -62, -62, -63, -62, -61, -61, -60, -60, -59, -59, -58, -58,
-57, -56, -55, -55, -55, -54, -53, -52, -51, -51, -50, -50, -49, -48, -47, -47,
-46, -46, -45, -44, -44, -43, -43, -42, -42, -41, -41, -42, -41, -41, -40, -41,
-40, -41, -41, -40, -41, -40, -40, -42, -41, -42, -41, -42, -43, -43, -43, -44,
-45, -45, -45, -47, -47, -48, -48, -48, -49, -50, -50, -52, -52, -52, -53, -55,
-54, -55, -56, -58, -58, -59, -59, -60, -61, -61, -63, -63, -64, -64, -65, -66,
-66, -66, -67, -68, -68, -68, -70, -70, -70, -71, -72, -72, -72, -71, -73, -73,
-73, -73, -74, -74, -74, -74, -73, -74, -73, -73, -73, -73, -73, -73, -72, -72,
-72, -72, -71, -71, -70, -68, -68, -68, -67, -66, -65, -64, -64, -62, -61, -59,
-58, -57, -55, -54, -53, -51, -48, -47, -45, -43, -41, -39, -37, -35, -33, -30,
-27, -25, -22, -20, -17, -14, -11, -8, -5, -2, };