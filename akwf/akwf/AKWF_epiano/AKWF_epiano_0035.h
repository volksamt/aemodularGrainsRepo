#define DATA_LENGTH 512
#define DATA AKWF_epiano_0035

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 9, 10, 11, 13, 14, 15, 15,
17, 17, 18, 17, 19, 18, 19, 19, 20, 20, 20, 21, 21, 22, 23, 23, 23, 24, 26, 26,
28, 28, 28, 30, 30, 32, 33, 34, 35, 36, 36, 37, 39, 40, 40, 42, 43, 44, 45, 46,
47, 48, 49, 50, 50, 52, 53, 54, 55, 57, 58, 60, 61, 63, 63, 64, 65, 67, 67, 69,
70, 71, 72, 73, 75, 75, 77, 77, 79, 79, 81, 81, 82, 83, 83, 84, 84, 85, 85, 85,
86, 85, 86, 86, 87, 86, 87, 86, 86, 87, 86, 86, 85, 86, 85, 85, 84, 84, 83, 82,
82, 81, 80, 79, 78, 77, 76, 76, 74, 73, 71, 70, 69, 68, 65, 64, 62, 59, 57, 54,
51, 48, 44, 41, 37, 34, 29, 25, 20, 15, 10, 3, -2, -8, -14, -20, -26, -33, -39,
-46, -53, -59, -66, -72, -77, -84, -89, -95, -100, -103, -107, -111, -113, -116,
-117, -119, -119, -119, -118, -118, -117, -114, -112, -108, -106, -103, -101,
-97, -94, -91, -88, -85, -83, -80, -78, -75, -73, -70, -68, -66, -65, -62, -61,
-60, -57, -55, -55, -53, -51, -49, -48, -47, -45, -45, -43, -43, -41, -39, -37,
-36, -35, -34, -33, -31, -30, -28, -27, -26, -24, -23, -22, -21, -20, -18, -18,
-17, -16, -15, -13, -12, -12, -12, -11, -11, -11, -11, -11, -11, -11, -12, -12,
-12, -14, -14, -14, -15, -16, -17, -18, -19, -19, -21, -22, -23, -24, -25, -27,
-27, -28, -30, -31, -31, -33, -33, -34, -35, -35, -36, -36, -37, -37, -37, -38,
-39, -38, -38, -39, -39, -38, -39, -39, -38, -39, -39, -40, -40, -40, -40, -40,
-39, -40, -39, -40, -40, -40, -40, -41, -41, -41, -42, -43, -44, -44, -45, -46,
-46, -47, -48, -49, -49, -51, -52, -53, -54, -54, -55, -55, -55, -55, -55, -55,
-55, -54, -53, -51, -50, -48, -46, -44, -42, -39, -37, -35, -31, -29, -26, -24,
-22, -21, -19, -17, -15, -13, -10, -7, -4, -2, 2, 6, 10, 15, 20, 24, 29, 33, 39,
43, 48, 52, 57, 60, 65, 68, 71, 74, 77, 79, 83, 85, 86, 87, 88, 89, 91, 91, 92,
93, 92, 92, 93, 92, 93, 92, 92, 91, 91, 91, 89, 89, 89, 88, 87, 86, 84, 84, 82,
80, 79, 78, 77, 74, 73, 71, 69, 68, 65, 63, 61, 58, 56, 54, 51, 49, 46, 43, 41,
38, 36, 31, 29, 26, 22, 20, 16, 13, 11, 6, 3, 1, -2, -5, -8, -10, -13, -16, -19,
-20, -23, -25, -26, -28, -30, -32, -33, -34, -35, -37, -38, -39, -39, -40, -42,
-42, -42, -44, -43, -44, -45, -45, -45, -46, -46, -46, -47, -47, -48, -48, -49,
-49, -50, -50, -51, -51, -52, -52, -52, -53, -53, -53, -54, -54, -53, -53, -54,
-54, -53, -53, -53, -52, -52, -52, -51, -50, -48, -48, -45, -44, -42, -40, -37,
-35, -31, -28, -25, -22, -19, -16, -13, -9, -7, -3, -1, };