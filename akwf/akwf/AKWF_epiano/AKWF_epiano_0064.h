#define DATA_LENGTH 512
#define DATA AKWF_epiano_0064

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 14, 18, 23, 27, 31, 36, 41,
44, 49, 52, 57, 61, 65, 69, 73, 76, 79, 84, 86, 90, 92, 95, 98, 100, 102, 105,
107, 108, 110, 112, 113, 114, 116, 116, 117, 117, 118, 118, 119, 119, 119, 119,
119, 118, 118, 118, 118, 117, 117, 116, 116, 114, 114, 113, 111, 111, 110, 109,
108, 106, 105, 103, 103, 101, 100, 99, 97, 95, 94, 92, 92, 91, 88, 87, 85, 84,
82, 80, 78, 77, 75, 74, 73, 71, 70, 67, 65, 64, 62, 60, 60, 57, 56, 54, 53, 50,
48, 48, 46, 45, 42, 41, 39, 38, 36, 35, 33, 31, 30, 28, 27, 25, 23, 22, 21, 19,
18, 16, 14, 13, 12, 10, 9, 7, 7, 5, 4, 3, 1, 0, -1, -2, -4, -5, -5, -6, -7, -9,
-9, -10, -12, -12, -13, -14, -15, -16, -16, -17, -17, -18, -19, -20, -20, -21,
-22, -22, -22, -23, -23, -23, -24, -23, -24, -23, -24, -23, -24, -23, -23, -23,
-24, -23, -23, -22, -22, -21, -22, -21, -20, -20, -20, -19, -19, -18, -17, -17,
-17, -16, -16, -16, -16, -16, -15, -15, -15, -15, -14, -14, -14, -14, -14, -14,
-13, -14, -13, -13, -13, -13, -12, -13, -14, -13, -13, -13, -13, -13, -14, -13,
-13, -14, -14, -14, -15, -15, -15, -14, -14, -14, -15, -15, -15, -15, -15, -15,
-16, -16, -16, -15, -16, -17, -16, -17, -17, -17, -17, -18, -18, -18, -18, -18,
-19, -19, -19, -19, -19, -20, -20, -20, -21, -20, -21, -22, -22, -22, -23, -23,
-23, -24, -23, -24, -25, -25, -26, -26, -26, -27, -27, -27, -28, -28, -28, -29,
-28, -29, -30, -31, -31, -32, -31, -32, -32, -32, -33, -34, -34, -35, -35, -35,
-36, -36, -35, -36, -37, -37, -38, -38, -39, -38, -38, -39, -39, -39, -40, -40,
-40, -41, -39, -40, -41, -40, -40, -40, -41, -39, -40, -39, -39, -39, -39, -37,
-37, -36, -35, -35, -33, -33, -31, -30, -29, -28, -25, -24, -23, -22, -20, -18,
-16, -16, -14, -12, -10, -9, -7, -5, -5, -3, -2, -1, 1, 2, 3, 5, 6, 7, 7, 8, 10,
10, 10, 10, 11, 11, 12, 11, 11, 11, 11, 12, 11, 12, 11, 10, 9, 10, 9, 9, 7, 6,
5, 4, 4, 3, 1, 1, 0, -2, -2, -3, -5, -6, -7, -8, -10, -10, -12, -13, -14, -16,
-17, -18, -19, -21, -21, -24, -24, -26, -26, -29, -29, -31, -32, -33, -33, -35,
-36, -37, -38, -39, -40, -40, -42, -43, -44, -45, -45, -47, -47, -47, -48, -50,
-50, -50, -51, -52, -53, -53, -53, -54, -54, -55, -55, -55, -56, -56, -57, -57,
-57, -58, -58, -58, -57, -58, -58, -58, -58, -58, -59, -58, -59, -58, -58, -59,
-58, -59, -57, -57, -57, -56, -57, -56, -56, -55, -54, -54, -53, -52, -51, -51,
-49, -49, -48, -46, -44, -43, -40, -39, -36, -35, -33, -30, -28, -25, -21, -18,
-15, -12, -8, -5, -1, };