#define DATA_LENGTH 512
#define DATA AKWF_epiano_0045

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 14, 19, 23, 27, 31, 35, 39,
43, 47, 51, 55, 59, 63, 66, 69, 74, 77, 80, 82, 85, 88, 92, 94, 96, 98, 100,
102, 105, 107, 108, 109, 111, 112, 114, 114, 115, 116, 118, 118, 118, 119, 118,
118, 120, 119, 119, 119, 119, 118, 117, 117, 117, 116, 115, 115, 114, 113, 112,
111, 110, 109, 107, 107, 105, 104, 103, 101, 100, 98, 97, 96, 94, 93, 91, 89,
88, 86, 84, 83, 81, 79, 77, 75, 73, 73, 71, 69, 67, 64, 63, 62, 59, 58, 56, 55,
52, 51, 49, 48, 46, 44, 42, 40, 39, 38, 36, 35, 32, 30, 30, 28, 27, 25, 24, 22,
22, 20, 19, 18, 17, 15, 14, 13, 12, 11, 9, 9, 8, 8, 7, 7, 5, 4, 4, 3, 4, 3, 2,
2, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 3, 2, 3, 4, 3, 5, 6, 6, 6, 7, 8, 9, 10, 12,
13, 15, 15, 17, 18, 18, 20, 22, 23, 25, 25, 27, 29, 29, 32, 33, 35, 35, 37, 38,
40, 41, 43, 44, 45, 46, 48, 48, 49, 51, 52, 53, 53, 55, 55, 55, 56, 57, 57, 58,
58, 59, 59, 60, 60, 60, 60, 60, 60, 60, 61, 60, 61, 60, 60, 61, 59, 60, 60, 59,
60, 58, 59, 58, 59, 58, 58, 58, 57, 57, 56, 57, 56, 56, 56, 55, 55, 54, 54, 53,
53, 53, 51, 51, 50, 50, 50, 49, 48, 48, 48, 46, 46, 45, 44, 44, 42, 42, 41, 40,
39, 38, 37, 36, 35, 34, 33, 33, 32, 30, 29, 28, 27, 26, 24, 23, 21, 20, 19, 19,
17, 15, 14, 13, 12, 10, 8, 7, 6, 5, 2, 1, -1, -2, -4, -5, -7, -8, -10, -11, -12,
-14, -15, -16, -18, -20, -21, -23, -25, -25, -27, -29, -30, -30, -32, -34, -34,
-36, -37, -38, -40, -41, -42, -43, -43, -45, -45, -47, -48, -48, -50, -50, -50,
-52, -51, -53, -53, -53, -54, -55, -55, -56, -57, -57, -57, -57, -58, -59, -59,
-60, -60, -61, -60, -61, -61, -62, -62, -62, -62, -63, -64, -65, -64, -66, -66,
-67, -67, -67, -68, -69, -70, -69, -71, -71, -72, -72, -73, -73, -74, -75, -76,
-77, -77, -78, -79, -80, -81, -82, -81, -83, -83, -84, -85, -86, -87, -88, -89,
-89, -90, -91, -91, -93, -93, -93, -95, -96, -96, -97, -98, -98, -99, -100,
-100, -100, -101, -102, -102, -103, -104, -105, -106, -105, -106, -106, -107,
-107, -108, -108, -108, -109, -108, -109, -110, -110, -109, -110, -110, -110,
-110, -109, -110, -109, -110, -110, -110, -110, -109, -109, -109, -108, -107,
-107, -107, -108, -106, -106, -105, -105, -105, -104, -103, -103, -102, -101,
-100, -99, -97, -97, -95, -94, -93, -92, -90, -89, -87, -86, -84, -83, -81, -79,
-76, -74, -72, -70, -67, -65, -63, -60, -57, -54, -51, -49, -45, -42, -38, -35,
-32, -28, -24, -20, -17, -13, -9, -6, -1, };