#define DATA_LENGTH 512
#define DATA AKWF_epiano_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 10, 17, 26, 33, 40, 48, 57, 63, 69,
76, 81, 87, 92, 97, 101, 105, 107, 111, 113, 115, 117, 118, 119, 119, 119, 118,
117, 116, 114, 111, 109, 106, 103, 98, 95, 90, 86, 82, 77, 72, 68, 64, 58, 55,
50, 45, 42, 38, 32, 29, 25, 22, 18, 14, 10, 6, 3, -1, -4, -7, -11, -14, -16,
-19, -22, -24, -26, -27, -29, -31, -32, -33, -34, -36, -35, -35, -36, -37, -37,
-37, -37, -38, -38, -39, -38, -39, -39, -40, -41, -41, -41, -43, -44, -44, -45,
-46, -46, -47, -46, -46, -45, -45, -43, -41, -39, -36, -32, -30, -24, -20, -15,
-9, -5, 0, 6, 11, 17, 22, 28, 33, 38, 42, 48, 51, 55, 58, 62, 64, 67, 69, 72,
73, 75, 76, 77, 78, 78, 79, 81, 81, 81, 81, 81, 80, 80, 81, 80, 78, 78, 77, 76,
75, 74, 73, 72, 70, 70, 68, 68, 66, 65, 65, 64, 63, 63, 62, 61, 61, 60, 60, 59,
59, 58, 57, 57, 57, 56, 55, 55, 54, 53, 54, 53, 53, 52, 52, 51, 51, 51, 50, 49,
48, 47, 47, 46, 46, 45, 44, 41, 41, 39, 37, 36, 34, 32, 30, 28, 25, 23, 20, 17,
13, 10, 7, 3, 0, -5, -9, -13, -17, -20, -25, -29, -33, -38, -41, -45, -49, -53,
-56, -59, -63, -65, -68, -70, -71, -73, -75, -75, -76, -76, -76, -76, -76, -76,
-75, -75, -73, -72, -71, -71, -70, -68, -69, -67, -66, -64, -64, -62, -61, -60,
-57, -56, -55, -52, -50, -50, -47, -47, -45, -44, -43, -42, -41, -41, -40, -40,
-40, -39, -39, -38, -38, -38, -38, -37, -36, -36, -35, -35, -34, -33, -33, -33,
-32, -32, -31, -31, -30, -30, -30, -30, -30, -29, -29, -30, -30, -29, -29, -29,
-28, -28, -28, -27, -27, -26, -25, -24, -23, -23, -23, -22, -21, -21, -21, -21,
-21, -21, -21, -22, -22, -23, -23, -24, -24, -24, -24, -24, -23, -23, -22, -22,
-22, -20, -19, -18, -16, -15, -13, -12, -10, -8, -7, -5, -4, -3, -2, -2, -1, 0,
0, 1, -1, -2, -2, -2, -5, -6, -8, -10, -12, -15, -18, -20, -23, -26, -29, -31,
-33, -35, -38, -40, -41, -43, -43, -45, -46, -47, -46, -47, -48, -48, -48, -49,
-48, -48, -48, -47, -47, -46, -46, -43, -42, -40, -38, -35, -32, -28, -24, -20,
-16, -12, -7, -2, 2, 8, 13, 18, 23, 28, 34, 40, 45, 50, 54, 59, 64, 68, 72, 76,
79, 82, 85, 86, 88, 90, 90, 92, 91, 91, 91, 89, 87, 85, 84, 79, 77, 73, 68, 64,
60, 55, 49, 43, 37, 31, 25, 19, 12, 5, -2, -7, -14, -20, -27, -32, -38, -44,
-50, -55, -60, -65, -71, -76, -80, -84, -87, -91, -95, -97, -99, -102, -103,
-104, -105, -104, -104, -104, -104, -103, -101, -99, -98, -95, -94, -90, -87,
-85, -81, -77, -73, -68, -64, -58, -53, -46, -40, -33, -26, -18, -12, -4, };