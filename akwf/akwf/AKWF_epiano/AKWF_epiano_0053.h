#define DATA_LENGTH 512
#define DATA AKWF_epiano_0053

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 11, 16, 19, 25, 28, 33, 37, 41,
45, 49, 53, 57, 61, 65, 68, 73, 76, 79, 82, 85, 88, 91, 94, 96, 98, 100, 102,
105, 107, 109, 110, 111, 112, 114, 114, 116, 116, 117, 118, 119, 119, 119, 119,
119, 119, 119, 119, 118, 117, 117, 116, 116, 115, 114, 113, 113, 111, 110, 109,
108, 106, 106, 104, 102, 101, 99, 97, 96, 94, 93, 92, 90, 88, 86, 84, 83, 80,
79, 77, 75, 73, 72, 69, 67, 65, 63, 62, 60, 57, 56, 54, 52, 51, 49, 47, 44, 42,
41, 39, 37, 36, 34, 32, 30, 28, 28, 25, 23, 22, 21, 19, 18, 16, 15, 13, 12, 10,
9, 9, 7, 5, 4, 3, 3, 1, 0, -1, 0, -1, -3, -4, -4, -4, -5, -5, -6, -6, -6, -7,
-7, -7, -7, -7, -7, -7, -6, -6, -6, -6, -6, -5, -4, -4, -3, -3, -1, -2, 0, 2, 2,
3, 4, 5, 7, 8, 10, 11, 13, 15, 15, 17, 19, 21, 22, 23, 25, 27, 29, 30, 33, 35,
35, 37, 38, 40, 42, 43, 45, 46, 47, 49, 49, 52, 52, 53, 54, 56, 56, 57, 58, 58,
59, 60, 60, 61, 61, 62, 62, 62, 63, 64, 64, 64, 64, 64, 64, 64, 64, 65, 66, 65,
65, 66, 66, 65, 66, 65, 65, 66, 65, 64, 66, 66, 64, 64, 64, 64, 64, 63, 64, 64,
63, 62, 62, 62, 62, 61, 61, 61, 60, 59, 59, 59, 58, 57, 57, 57, 56, 55, 54, 53,
53, 52, 51, 50, 49, 48, 47, 47, 45, 44, 42, 41, 41, 39, 38, 37, 36, 34, 33, 31,
30, 29, 27, 26, 24, 22, 21, 19, 18, 16, 14, 13, 11, 9, 7, 6, 4, 2, 0, -1, -4,
-6, -7, -10, -11, -13, -15, -16, -19, -21, -22, -25, -27, -28, -31, -33, -33,
-36, -37, -39, -41, -43, -44, -46, -47, -49, -51, -52, -54, -55, -56, -57, -58,
-59, -60, -62, -62, -63, -64, -64, -65, -65, -66, -66, -66, -67, -67, -67, -67,
-68, -68, -68, -69, -69, -69, -68, -68, -70, -69, -69, -69, -69, -70, -70, -70,
-70, -70, -71, -71, -71, -71, -72, -72, -71, -72, -73, -72, -73, -73, -74, -74,
-75, -75, -76, -76, -77, -77, -78, -78, -79, -80, -81, -80, -80, -82, -82, -83,
-83, -84, -85, -86, -86, -87, -88, -88, -88, -88, -90, -90, -91, -92, -92, -93,
-93, -94, -95, -95, -95, -96, -97, -96, -97, -97, -98, -99, -99, -100, -99,
-100, -100, -101, -102, -101, -102, -102, -101, -102, -102, -102, -103, -102,
-102, -102, -102, -102, -103, -101, -101, -102, -101, -101, -101, -100, -101,
-100, -101, -100, -99, -98, -98, -98, -97, -97, -97, -95, -95, -95, -94, -92,
-92, -90, -91, -90, -88, -87, -87, -85, -84, -83, -81, -80, -78, -76, -75, -73,
-72, -70, -67, -65, -63, -61, -59, -56, -53, -50, -47, -45, -42, -38, -35, -32,
-27, -24, -20, -17, -12, -9, -5, 0, };