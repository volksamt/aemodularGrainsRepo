#define DATA_LENGTH 512
#define DATA AKWF_epiano_0047

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 10, 15, 20, 26, 31, 37, 42, 47,
51, 58, 62, 69, 73, 77, 82, 85, 89, 93, 96, 99, 102, 104, 106, 109, 111, 112,
113, 115, 116, 117, 118, 119, 119, 119, 119, 119, 118, 119, 119, 117, 118, 117,
117, 117, 116, 115, 115, 113, 113, 113, 110, 110, 109, 108, 107, 106, 104, 104,
102, 101, 99, 99, 97, 96, 95, 93, 92, 90, 89, 88, 86, 85, 84, 81, 81, 78, 77,
75, 73, 72, 70, 69, 68, 66, 64, 63, 61, 58, 57, 55, 54, 52, 50, 50, 47, 45, 44,
43, 41, 39, 38, 35, 34, 32, 31, 29, 28, 25, 24, 23, 21, 20, 18, 17, 15, 13, 12,
11, 9, 7, 6, 5, 5, 3, 2, 0, 0, -2, -4, -5, -5, -7, -7, -9, -9, -10, -11, -13,
-13, -14, -14, -16, -17, -18, -18, -19, -20, -20, -21, -21, -22, -23, -23, -23,
-24, -24, -24, -25, -25, -26, -26, -26, -26, -27, -27, -27, -26, -26, -26, -26,
-25, -25, -25, -24, -24, -24, -23, -22, -21, -21, -20, -19, -19, -18, -17, -18,
-17, -16, -15, -15, -15, -14, -14, -15, -15, -14, -15, -14, -14, -14, -14, -14,
-14, -13, -14, -15, -15, -15, -14, -15, -15, -15, -15, -14, -14, -15, -14, -14,
-15, -15, -15, -14, -15, -16, -15, -15, -16, -15, -14, -16, -15, -16, -15, -16,
-15, -15, -15, -15, -15, -16, -16, -15, -15, -15, -16, -16, -16, -15, -16, -16,
-16, -17, -16, -16, -16, -17, -16, -17, -17, -18, -17, -19, -18, -19, -18, -19,
-20, -20, -20, -21, -21, -21, -21, -22, -21, -23, -23, -23, -24, -24, -25, -25,
-26, -26, -26, -27, -28, -28, -28, -28, -29, -30, -30, -31, -31, -31, -31, -31,
-32, -33, -34, -34, -34, -35, -34, -35, -36, -36, -36, -36, -38, -38, -38, -38,
-38, -39, -39, -40, -40, -40, -40, -41, -41, -41, -40, -41, -40, -41, -40, -40,
-39, -39, -39, -38, -36, -36, -35, -34, -32, -31, -29, -27, -26, -24, -21, -19,
-17, -16, -13, -10, -8, -6, -4, -2, 1, 2, 4, 5, 7, 9, 10, 11, 11, 12, 13, 15,
15, 15, 16, 17, 16, 16, 16, 17, 17, 17, 15, 16, 15, 15, 14, 13, 13, 12, 12, 10,
9, 9, 7, 7, 6, 5, 4, 2, 1, 0, -1, -2, -4, -5, -6, -7, -9, -10, -11, -12, -13,
-15, -16, -18, -18, -20, -22, -23, -24, -25, -26, -28, -29, -29, -32, -32, -33,
-34, -35, -36, -37, -38, -39, -40, -41, -42, -43, -43, -44, -45, -46, -46, -47,
-47, -49, -49, -49, -50, -50, -50, -51, -53, -52, -52, -53, -53, -53, -54, -54,
-54, -55, -54, -54, -55, -55, -56, -55, -55, -55, -55, -55, -55, -55, -55, -55,
-54, -54, -55, -55, -55, -54, -53, -53, -54, -52, -52, -52, -51, -51, -51, -50,
-50, -49, -48, -47, -46, -46, -45, -43, -42, -41, -39, -37, -35, -33, -30, -28,
-25, -23, -19, -15, -12, -8, -3, };