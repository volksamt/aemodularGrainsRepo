#define DATA_LENGTH 512
#define DATA AKWF_epiano_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 4, 3, 5, 6, 6, 8, 9, 10, 10,
12, 12, 13, 14, 16, 17, 18, 19, 19, 21, 22, 22, 23, 24, 26, 26, 27, 29, 29, 30,
32, 32, 33, 35, 35, 37, 38, 39, 40, 41, 43, 44, 44, 46, 47, 48, 50, 50, 52, 53,
55, 56, 57, 58, 60, 61, 62, 63, 64, 66, 67, 69, 69, 71, 72, 73, 75, 75, 77, 77,
79, 80, 82, 82, 83, 85, 86, 87, 88, 89, 90, 92, 93, 94, 95, 95, 95, 97, 98, 99,
100, 100, 101, 102, 103, 104, 104, 105, 107, 107, 108, 107, 109, 109, 110, 111,
111, 111, 112, 112, 113, 114, 114, 114, 115, 116, 116, 117, 117, 116, 117, 117,
118, 118, 118, 119, 119, 119, 119, 119, 120, 120, 118, 120, 119, 120, 119, 119,
118, 119, 118, 118, 117, 117, 117, 117, 116, 116, 116, 116, 115, 114, 114, 113,
113, 112, 112, 111, 110, 109, 108, 107, 107, 106, 106, 105, 104, 103, 102, 102,
100, 100, 99, 98, 96, 95, 95, 93, 92, 91, 91, 89, 88, 87, 86, 85, 84, 83, 82,
80, 80, 79, 77, 76, 76, 73, 73, 72, 70, 69, 68, 67, 65, 65, 63, 61, 61, 59, 58,
57, 55, 53, 52, 52, 50, 49, 47, 45, 44, 43, 42, 40, 39, 37, 36, 33, 33, 32, 30,
28, 27, 26, 24, 22, 20, 19, 18, 16, 14, 13, 12, 11, 8, 7, 6, 4, 2, 1, -1, -2,
-3, -5, -6, -7, -9, -11, -12, -14, -15, -17, -17, -19, -21, -22, -24, -26, -26,
-28, -29, -30, -32, -33, -35, -35, -38, -38, -39, -41, -42, -44, -45, -46, -47,
-48, -50, -51, -52, -54, -56, -57, -59, -59, -60, -62, -62, -64, -66, -66, -68,
-69, -70, -72, -73, -74, -75, -76, -77, -79, -79, -81, -83, -84, -85, -86, -86,
-88, -90, -91, -92, -92, -93, -94, -96, -96, -97, -98, -99, -100, -101, -101,
-101, -102, -104, -105, -105, -106, -106, -108, -108, -108, -108, -109, -110,
-110, -111, -111, -113, -112, -113, -113, -114, -113, -115, -114, -115, -115,
-116, -115, -116, -115, -116, -117, -117, -117, -118, -116, -117, -116, -116,
-117, -117, -116, -116, -117, -116, -116, -116, -116, -115, -116, -114, -114,
-114, -113, -113, -113, -112, -112, -111, -111, -110, -110, -109, -109, -108,
-108, -106, -106, -105, -105, -104, -103, -103, -101, -101, -99, -98, -98, -96,
-95, -95, -94, -93, -92, -91, -89, -88, -88, -86, -86, -84, -84, -83, -81, -80,
-79, -77, -77, -76, -75, -73, -73, -71, -70, -69, -68, -68, -66, -65, -63, -63,
-61, -61, -60, -58, -58, -56, -54, -54, -53, -51, -50, -49, -48, -48, -46, -45,
-45, -43, -42, -41, -40, -39, -37, -37, -36, -35, -34, -34, -32, -32, -30, -29,
-28, -27, -27, -26, -25, -24, -23, -22, -21, -21, -19, -18, -18, -17, -17, -16,
-15, -15, -13, -13, -12, -12, -11, -9, -9, -9, -7, -8, -7, -5, -5, -4, -4, -3,
-2, -1, 0, };