#define DATA_LENGTH 512
#define DATA AKWF_1239

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 2, 5, 6, 8, 10, 11, 14, 14, 15, 16,
19, 19, 20, 20, 22, 21, 22, 22, 23, 23, 23, 23, 22, 23, 22, 22, 22, 22, 22, 21,
22, 22, 21, 21, 21, 21, 22, 22, 22, 22, 23, 24, 24, 24, 25, 26, 26, 27, 28, 30,
31, 31, 33, 33, 35, 36, 37, 38, 39, 40, 41, 43, 44, 44, 47, 47, 48, 50, 49, 51,
52, 52, 54, 55, 55, 56, 57, 58, 59, 59, 60, 61, 62, 63, 63, 66, 66, 66, 68, 69,
69, 71, 71, 74, 74, 75, 76, 78, 78, 80, 80, 82, 82, 85, 85, 86, 87, 88, 89, 90,
91, 91, 92, 92, 94, 93, 96, 94, 97, 93, 100, 93, 102, 90, 117, 43, -86, -59,
-64, -59, -57, -56, -53, -53, -49, -50, -46, -45, -41, -43, -37, -38, -34, -34,
-29, -28, -25, -23, -20, -17, -14, -12, -9, -7, -4, 0, 2, 6, 7, 11, 14, 18, 20,
23, 25, 30, 31, 35, 37, 40, 40, 38, 35, 33, 30, 28, 27, 25, 22, 20, 18, 16, 16,
12, 14, 8, 13, 3, 29, 22, -39, -30, -35, -36, -37, -39, -39, -40, -42, -43, -42,
-44, -43, -45, -44, -45, -45, -45, -45, -46, -45, -47, -46, -46, -48, -48, -48,
-49, -47, -48, -48, -48, -48, -49, -48, -47, -47, -46, -45, -45, -45, -44, -43,
-42, -40, -39, -39, -37, -36, -34, -34, -33, -30, -29, -28, -27, -26, -24, -23,
-22, -21, -20, -19, -17, -16, -15, -14, -14, -13, -13, -11, -11, -11, -9, -9,
-8, -8, -8, -7, -5, -6, -5, -4, -4, -4, -3, -2, -1, 0, 0, 1, 2, 3, 4, 5, 6, 8,
9, 10, 11, 12, 13, 16, 17, 19, 19, 21, 23, 24, 26, 27, 27, 30, 30, 31, 32, 34,
35, 36, 36, 37, 38, 39, 40, 40, 41, 42, 42, 43, 43, 43, 45, 44, 44, 45, 46, 46,
47, 47, 47, 48, 48, 49, 50, 52, 51, 53, 54, 56, 55, 58, 57, 64, 23, -52, -65,
-78, -89, -93, -99, -99, -103, -102, -104, -103, -103, -102, -103, -100, -100,
-98, -97, -94, -93, -90, -88, -86, -84, -81, -78, -75, -73, -70, -66, -65, -60,
-59, -54, -53, -47, -58, -62, -42, -43, -38, -36, -32, -29, -26, -24, -22, -18,
-16, -14, -12, -10, -9, -8, -7, -7, -7, -7, -6, -8, -8, -9, -10, -12, -13, -14,
-16, -17, -20, -20, -23, -24, -26, -28, -30, -30, -34, -34, -36, -36, -38, -38,
-41, -40, -42, -42, -41, -41, -42, -41, -40, -41, -39, -40, -36, -39, -32, -38,
-26, -42, 25, -9, -117, -85, -96, -86, -88, -84, -82, -80, -77, -75, -72, -72,
-68, -68, -64, -66, -61, -62, -59, -59, -56, -56, -54, -54, -53, -53, -52, -52,
-50, -49, -49, -49, -48, -47, -48, -46, -46, -45, -45, -44, -44, -43, -41, -40,
-40, -39, -38, -37, -35, -34, -32, -31, -29, -29, -26, -26, -22, -23, -19, -20,
-14, -21, 21, 32, -10, };