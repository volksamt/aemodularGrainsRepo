#define DATA_LENGTH 512
#define DATA AKWF_1238

const PROGMEM int8_t DATA[DATA_LENGTH] = {23, 49, 46, 48, 47, 47, 47, 47, 46,
47, 47, 46, 47, 46, 47, 46, 46, 46, 45, 45, 45, 45, 45, 45, 44, 44, 44, 45, 44,
44, 43, 44, 43, 43, 43, 43, 42, 42, 41, 42, 42, 40, 41, 40, 41, 40, 41, 39, 41,
38, 39, 37, 41, 34, 43, 11, -37, -1, -5, -5, -4, -6, -4, -7, 18, 35, 34, 33, 33,
32, 33, 31, 32, 31, 31, 30, 30, 29, 30, 29, 29, 28, 28, 27, 28, 27, 26, 25, 26,
25, 25, 25, 24, 24, 23, 23, 22, 22, 22, 22, 21, 21, 20, 19, 19, 18, 19, 18, 17,
16, 17, 16, 16, 16, 15, 14, 14, 14, 13, 13, 13, 11, 11, 11, 11, 11, 11, 11, 9,
8, 7, 7, 7, 7, 6, 6, 5, 4, 5, 4, 3, -5, -8, -7, -8, -8, -7, -7, -8, -8, -8, -8,
-8, -8, -8, -9, -8, -8, -8, -8, -9, -8, -8, -9, -9, -10, -10, -10, -10, -9, -9,
-8, -8, -8, -7, -8, -7, -7, -7, -5, -6, -6, -6, -6, -5, -5, -4, -4, -4, -3, -4,
-3, -3, -3, -2, -1, -2, -2, -2, -1, -1, 0, 0, 0, 0, 1, 1, 1, 2, 7, 12, 11, 12,
12, 13, 14, 13, 14, 14, 15, 14, 15, 16, 17, 17, 17, 16, 17, 17, 18, 18, 18, 19,
18, 19, 19, 19, 18, 19, 19, 19, 19, 19, 18, 20, 18, 20, 10, -8, -6, -6, -8, -7,
-7, -6, -7, 8, 18, 16, 18, 18, 18, 18, 19, 19, 19, 20, 21, 21, 21, 22, 22, 22,
23, 23, 24, 24, 25, 26, 25, 26, 26, 26, 28, 28, 28, 28, 29, 28, 29, 29, 30, 30,
31, 31, 31, 32, 31, 32, 32, 34, 33, 34, 33, 36, 33, 37, 33, 38, 32, 43, 3, -37,
1, -7, -4, -4, -5, -4, -5, 24, 42, 39, 40, 40, 40, 40, 40, 42, 40, 42, 42, 43,
42, 43, 42, 43, 42, 43, 43, 44, 43, 44, 44, 44, 45, 45, 45, 45, 45, 45, 45, 45,
45, 46, 46, 46, 45, 46, 46, 46, 45, 47, 46, 46, 46, 47, 46, 47, 45, 47, 46, 47,
45, 49, 31, 5, 15, 13, 13, 15, 17, 17, 17, 17, 16, 17, 17, 17, 17, 18, 18, 19,
19, 19, 21, 18, -3, -8, -6, -7, -7, -7, -6, -7, -7, -9, -9, -9, -9, -9, -8, -9,
-9, -9, -8, -9, -8, -9, -8, -15, -41, -47, -45, -46, -46, -47, -46, -48, -47,
-48, -47, -48, -49, -49, -50, -50, -49, -51, -51, -51, -52, -52, -52, -52, -52,
-52, -53, -53, -53, -53, -54, -54, -54, -55, -55, -54, -54, -57, -60, -60, -59,
-60, -61, -60, -91, -111, -107, -109, -109, -109, -110, -110, -111, -111, -111,
-111, -115, -117, -116, -118, -117, -117, -116, -117, -118, -118, -118, -118,
-119, -118, -118, -119, -118, -118, -119, -119, -119, -118, -120, -117, -116,
-114, -110, -40, 5, -8, -1, -5, -3, -5, -4, };