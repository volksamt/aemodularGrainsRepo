#define DATA_LENGTH 512
#define DATA AKWF_1250

const PROGMEM int8_t DATA[DATA_LENGTH] = {100, 120, 111, 118, 113, 117, 112,
117, 114, 116, 113, 116, 114, 116, 114, 115, 114, 115, 119, 119, 113, 115, 115,
115, 115, 115, 115, 115, 116, 115, 116, 115, 114, 115, 116, 114, 116, 114, 115,
114, 115, 114, 115, 114, 115, 115, 115, 114, 115, 115, 115, 114, 115, 115, 114,
116, 115, 117, 114, 116, 112, 117, 112, 117, 112, 118, 110, 120, 109, 123, 97,
-2, -2, 3, -5, 9, -20, -120, -114, -114, -116, -112, -117, -112, -119, -117,
-120, -117, -120, -117, -120, -117, -121, -118, -120, -117, -120, -117, -120,
-118, -120, -117, -120, -117, -118, -114, -116, -114, -115, -116, -15, 8, -7, 7,
-8, 8, -11, 27, 122, 113, 114, 115, 114, 116, 113, 116, 113, 116, 114, 116, 114,
116, 114, 118, 119, 120, 118, 119, 119, 118, 119, 119, 119, 118, 119, 118, 120,
118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119,
120, 119, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 120,
119, 118, 119, 118, 119, 119, 119, 119, 118, 119, 119, 118, 119, 118, 118, 119,
119, 119, 119, 119, 118, 119, 118, 119, 118, 119, 118, 119, 120, 119, 119, 118,
119, 119, 119, 119, 119, 118, 119, 119, 119, 120, 118, 119, 119, 120, 119, 118,
119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 120, 119,
119, 119, 120, 118, 119, 119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119,
119, 119, 119, 118, 119, 118, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119,
118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 119, 118, 119,
118, 119, 119, 119, 119, 118, 119, 118, 120, 118, 119, 119, 120, 118, 119, 118,
120, 118, 120, 117, 119, 118, 120, 118, 118, 114, 115, 115, 113, 118, 109, 127,
39, -12, 4, -2, -2, 10, -76, -128, -107, -121, -110, -119, -112, -116, -117,
-120, -118, -119, -118, -119, -120, -118, -119, -118, -120, -118, -120, -118,
-120, -119, -119, -119, -120, -118, -119, -119, -120, -119, -119, -118, -120,
-120, -119, -119, -119, -119, -120, -120, -119, -119, -119, -119, -118, -120,
-119, -119, -118, -119, -119, -119, -119, -119, -120, -120, -119, -119, -119,
-118, -119, -120, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -118,
-119, -119, -120, -120, -118, -118, -119, -119, -120, -119, -119, -120, -118,
-119, -119, -120, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -120, -120,
-120, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -118,
-119, -118, -120, -118, -119, -118, -120, -119, -120, -119, -120, -117, -121,
-117, -121, -117, -120, -117, -120, -113, -117, -113, -117, -113, -7, 4, -3, 3,
-3, 2, -3, };