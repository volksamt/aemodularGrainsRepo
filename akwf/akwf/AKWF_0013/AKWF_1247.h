#define DATA_LENGTH 512
#define DATA AKWF_1247

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 21, 26, 31, 35, 40, 43, 45, 47,
51, 52, 55, 57, 59, 61, 62, 65, 65, 67, 68, 70, 71, 72, 73, 75, 76, 78, 79, 80,
82, 84, 85, 86, 88, 90, 90, 92, 93, 95, 95, 97, 98, 99, 99, 101, 101, 102, 104,
104, 105, 105, 106, 107, 107, 108, 108, 109, 110, 110, 111, 111, 112, 112, 113,
114, 113, 113, 113, 114, 114, 114, 114, 115, 115, 115, 116, 116, 115, 115, 115,
116, 115, 116, 116, 116, 116, 117, 117, 116, 118, 117, 118, 118, 118, 118, 118,
118, 118, 118, 118, 118, 119, 118, 118, 119, 119, 118, 118, 119, 120, 118, 119,
119, 119, 118, 119, 118, 119, 119, 119, 118, 118, 118, 119, 119, 120, 119, 118,
119, 119, 119, 118, 118, 118, 119, 118, 118, 119, 118, 119, 118, 118, 118, 119,
118, 118, 119, 118, 118, 119, 118, 119, 118, 119, 118, 118, 118, 118, 117, 117,
117, 117, 117, 117, 117, 116, 117, 116, 116, 116, 116, 116, 116, 116, 115, 115,
116, 115, 115, 114, 115, 115, 114, 114, 114, 113, 112, 113, 112, 113, 113, 112,
111, 112, 111, 111, 111, 110, 109, 109, 109, 109, 109, 108, 107, 107, 106, 105,
105, 105, 105, 104, 103, 102, 102, 101, 100, 100, 99, 98, 97, 97, 96, 96, 94,
93, 92, 91, 91, 89, 89, 87, 86, 85, 83, 82, 81, 80, 78, 76, 76, 74, 72, 70, 68,
66, 64, 61, 60, 56, 54, 52, 49, 45, 42, 37, 32, 28, 21, 14, -4, -18, -24, -30,
-33, -37, -41, -45, -47, -50, -53, -57, -60, -63, -65, -68, -70, -73, -75, -77,
-79, -81, -83, -85, -87, -89, -90, -92, -93, -95, -96, -97, -98, -99, -101,
-101, -102, -104, -104, -105, -106, -106, -107, -108, -109, -109, -110, -111,
-110, -112, -112, -112, -113, -113, -113, -113, -113, -114, -115, -114, -115,
-115, -114, -115, -114, -114, -115, -115, -116, -116, -116, -116, -116, -117,
-117, -117, -116, -117, -117, -118, -118, -117, -118, -119, -118, -118, -118,
-119, -118, -118, -119, -119, -118, -119, -119, -119, -119, -119, -118, -119,
-119, -120, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -119, -119, -119, -120, -119, -119, -118, -119, -120, -119,
-119, -119, -118, -119, -119, -119, -118, -119, -118, -118, -119, -118, -119,
-118, -118, -119, -118, -118, -118, -118, -118, -118, -117, -118, -117, -118,
-117, -117, -117, -117, -117, -116, -117, -117, -116, -116, -116, -116, -116,
-116, -115, -115, -115, -115, -114, -115, -114, -114, -113, -114, -112, -114,
-113, -112, -112, -112, -111, -111, -110, -110, -111, -110, -110, -109, -110,
-108, -108, -108, -107, -107, -106, -105, -105, -105, -104, -104, -103, -102,
-102, -102, -100, -100, -99, -98, -97, -96, -95, -96, -94, -94, -93, -92, -91,
-91, -90, -88, -87, -85, -84, -84, -82, -80, -79, -78, -76, -75, -72, -71, -70,
-67, -66, -64, -62, -60, -57, -54, -52, -48, -46, -42, -39, -34, -29, -23, -17,
-6, };