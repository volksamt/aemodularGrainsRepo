#define DATA_LENGTH 512
#define DATA AKWF_1209

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 13, 25, 36, 49, 60, 71, 80, 90, 97,
104, 110, 114, 117, 119, 119, 118, 116, 112, 107, 102, 96, 88, 80, 71, 62, 52,
43, 33, 23, 13, 4, -4, -12, -19, -24, -29, -32, -35, -37, -38, -38, -37, -37,
-35, -34, -32, -32, -30, -29, -28, -27, -27, -27, -26, -25, -24, -24, -22, -22,
-21, -19, -18, -16, -15, -13, -11, -8, -6, -4, -1, 2, 5, 8, 11, 13, 17, 19, 22,
25, 28, 29, 30, 31, 33, 31, 31, 28, 26, 23, 20, 15, 10, 5, 0, -6, -11, -15, -20,
-24, -28, -30, -31, -34, -35, -35, -34, -32, -31, -27, -23, -20, -16, -11, -7,
-3, 1, 3, 6, 8, 9, 10, 11, 10, 10, 8, 7, 6, 5, 4, 2, 1, 0, 0, -2, -2, -1, -2,
-2, 0, 2, 3, 5, 8, 10, 12, 14, 16, 17, 18, 18, 18, 16, 14, 11, 8, 3, -2, -7,
-13, -19, -26, -32, -39, -45, -49, -55, -59, -62, -65, -66, -67, -66, -65, -62,
-58, -54, -49, -43, -36, -29, -23, -16, -9, -1, 6, 12, 18, 23, 28, 33, 37, 40,
43, 46, 49, 50, 52, 53, 53, 52, 53, 51, 51, 50, 48, 45, 43, 41, 38, 36, 35, 31,
29, 28, 26, 24, 21, 20, 17, 15, 13, 10, 9, 5, 3, 0, -2, -6, -9, -11, -14, -17,
-20, -21, -23, -24, -24, -25, -25, -24, -23, -21, -20, -19, -16, -14, -12, -11,
-9, -7, -5, -5, -3, -2, -1, -1, 1, 1, 1, 2, 3, 3, 4, 4, 3, 3, 4, 3, 2, 1, 0, -1,
-2, -4, -5, -6, -6, -7, -7, -7, -8, -8, -7, -7, -7, -8, -9, -9, -11, -12, -13,
-15, -16, -16, -16, -16, -16, -16, -14, -13, -11, -9, -7, -4, -1, 2, 7, 11, 16,
20, 25, 30, 36, 40, 45, 50, 55, 57, 60, 62, 64, 64, 63, 60, 59, 55, 50, 45, 40,
34, 26, 18, 11, 3, -5, -13, -20, -28, -36, -43, -50, -56, -62, -66, -71, -75,
-79, -81, -84, -85, -85, -85, -84, -82, -80, -78, -75, -70, -66, -62, -58, -53,
-47, -42, -36, -31, -26, -21, -15, -11, -5, -1, 3, 8, 13, 19, 24, 28, 33, 38,
42, 46, 50, 52, 55, 57, 59, 61, 62, 63, 64, 65, 64, 64, 65, 64, 64, 62, 62, 60,
58, 57, 54, 52, 50, 47, 44, 40, 38, 33, 29, 25, 20, 15, 12, 8, 4, 1, -3, -6, -8,
-10, -13, -15, -16, -17, -17, -19, -20, -23, -25, -28, -31, -33, -36, -40, -43,
-46, -48, -50, -50, -50, -49, -48, -47, -44, -40, -37, -34, -30, -26, -21, -16,
-11, -4, 1, 8, 14, 20, 27, 32, 37, 41, 45, 47, 47, 48, 48, 45, 42, 38, 33, 28,
23, 17, 11, 5, -1, -6, -13, -18, -24, -31, -36, -42, -48, -54, -61, -66, -71,
-76, -80, -84, -87, -89, -90, -91, -90, -89, -87, -85, -82, -76, -72, -65, -57,
-48, -40, -29, -19, -8, };