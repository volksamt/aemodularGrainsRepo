#define DATA_LENGTH 512
#define DATA AKWF_1207

const PROGMEM int8_t DATA[DATA_LENGTH] = {-104, -108, -84, -79, -62, -57, -44,
-43, -32, -31, -24, -22, -17, -17, -12, -12, -8, -8, -5, -6, -3, -3, -2, -1, -1,
-1, 0, 0, 0, 0, 1, 1, 1, 1, 1, 3, 2, 1, 2, 1, 2, 2, 3, 2, 2, 2, 2, 2, 2, 2, 3,
2, 2, 3, 2, 2, 2, 2, 3, 3, 2, 1, 2, 2, 2, 3, 3, 3, 2, 2, 3, 2, 2, 2, 2, 2, 2, 2,
1, 2, 2, 1, 3, 2, 3, 2, 2, 1, 2, 2, 1, 2, 2, 2, 2, 2, 3, 2, 1, 2, 2, 3, 2, 2, 2,
2, 2, 2, 3, 2, 2, 2, 2, 2, 1, 2, 3, 2, 2, 1, 3, 2, 2, 2, 2, 2, 2, 2, 1, 2, 2, 2,
2, 3, 2, 2, 2, 2, 2, 1, 2, 3, 2, 2, 2, 2, 2, 2, 2, 1, 2, 2, 2, 1, 1, 2, 2, 2, 3,
2, 2, 2, 2, 2, 2, 2, 2, 3, 2, 2, 2, 2, 2, 2, 3, 2, 1, 2, 1, 1, 3, 2, 2, 2, 2, 2,
2, 2, 2, 3, 2, 2, 2, 2, 2, 1, 2, 1, 2, 1, 3, 2, 2, 2, 1, 2, 2, 3, 3, 2, 2, 1, 2,
2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 1, 2, 2, 1, 2, 1, 2, 2, 2, 2, 2, 2, 2, 3, 1, 2, 1,
2, 1, 1, 2, 1, 1, 1, 2, 1, 2, 2, 1, 2, 1, 2, 2, 2, 2, 1, 1, 2, 2, 2, 2, 2, 2, 2,
2, 2, 1, 2, 1, 2, 2, 2, 1, 1, 2, 2, 2, 1, 1, 1, 1, 1, 2, 1, 2, 2, 2, 2, 2, 2, 2,
2, 2, 2, 2, 2, 1, 2, 2, 2, 2, 2, 1, 2, 1, 2, 2, 1, 1, 2, 2, 2, 1, 1, 1, 2, 1, 2,
2, 2, 2, 1, 1, 1, 1, 2, 2, 2, 1, 2, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1, 2, 1, 2,
1, 2, 1, 2, 2, 2, 2, 2, 1, 1, 1, 1, 2, 1, 1, 2, 1, 2, 1, 1, 2, 2, 2, 2, 1, 1, 2,
2, 1, 1, 2, 1, 1, 1, 2, 2, 2, 2, 1, 1, 1, 1, 2, 1, 2, 1, 1, 1, 2, 2, 1, 1, 1, 2,
1, 1, 1, 2, 1, 2, 1, 1, 2, 1, 1, 2, 1, 2, 1, 2, 2, 2, 1, 2, 1, 1, 2, 1, 1, 2, 1,
1, 2, 1, 0, 1, 2, 2, 2, 2, 1, 1, 1, 2, 2, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 2, 1, 1,
1, 2, 1, 2, 2, 2, 1, 1, 1, 1, 1, 1, 2, 2, 1, 1, 2, 1, 2, 0, 1, 0, 1, 1, 2, 1, 1,
2, 1, 2, 1, 1, 1, 1, 1, 2, 1, 2, 1, 1, 1, 0, 2, 2, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1,
2, 1, };