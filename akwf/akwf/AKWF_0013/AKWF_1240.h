#define DATA_LENGTH 512
#define DATA AKWF_1240

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 4, 4, 5, 6, 6, 7, 8, 8, 9,
9, 10, 7, 24, 34, 21, 23, 20, 20, 19, 17, 17, 16, 14, 14, 13, 12, 12, 10, 10,
10, 9, 8, 7, 7, 7, 7, 7, 6, 6, 6, 6, 5, 6, 6, 7, 7, 7, 7, 8, 8, 8, 8, 8, 9, 10,
10, 11, 12, 13, 13, 14, 14, 15, 16, 17, 18, 17, 19, 20, 21, 22, 22, 23, 23, 25,
25, 26, 27, 28, 28, 30, 31, 31, 32, 32, 33, 34, 34, 35, 36, 37, 38, 37, 38, 39,
39, 40, 40, 41, 41, 41, 41, 42, 42, 42, 42, 42, 43, 43, 43, 43, 43, 43, 43, 42,
42, 42, 44, 42, 43, 42, 42, 42, 42, 41, 42, 41, 42, 42, 42, 41, 41, 42, 42, 42,
41, 42, 41, 44, 40, 49, 14, -13, -4, -9, -6, -7, -7, -8, -8, -9, -10, -9, -10,
-11, -12, -12, -14, -14, -15, -16, -17, -17, -19, -19, -20, -21, -22, -23, -23,
-24, -25, -27, -27, -28, -29, -30, -31, -31, -31, -33, -33, -34, -34, -36, -34,
-37, -36, -37, -36, -38, -37, -38, -38, -38, -38, -38, -38, -36, -39, -36, -40,
-32, -44, 18, -36, -118, -88, -103, -93, -98, -95, -96, -94, -95, -94, -93, -92,
-90, -90, -88, -88, -86, -86, -82, -83, -81, -80, -78, -77, -74, -74, -71, -70,
-67, -66, -63, -62, -60, -58, -56, -54, -52, -50, -48, -46, -44, -42, -40, -39,
-36, -33, -32, -29, -27, -26, -23, -21, -19, -17, -16, -13, -12, -9, -8, -6, -5,
-2, 0, 2, 3, 5, 7, 8, 10, 11, 13, 14, 16, 17, 18, 20, 21, 22, 23, 24, 25, 27,
28, 28, 30, 30, 31, 32, 33, 34, 34, 35, 36, 36, 36, 37, 37, 37, 36, 37, 38, 38,
38, 38, 38, 38, 38, 37, 37, 37, 37, 36, 35, 35, 35, 35, 33, 34, 33, 32, 32, 30,
31, 30, 28, 28, 27, 26, 26, 25, 23, 23, 22, 22, 21, 20, 18, 17, 16, 16, 15, 13,
13, 12, 12, 11, 10, 9, 8, 7, 7, 6, 5, 5, 4, 3, 2, 2, 0, 0, 0, -2, -1, -2, -3,
-4, -3, -4, -4, -5, -5, -7, -6, -8, -8, -9, -8, -10, -10, -10, -12, -12, -13,
-13, -14, -14, -16, -16, -19, -16, -34, 2, 28, 14, 17, 11, 11, 6, 6, 1, 1, -3,
-4, -7, -8, -10, -12, -14, -16, -18, -19, -21, -22, -24, -26, -27, -28, -29,
-30, -31, -32, -32, -34, -34, -35, -36, -36, -36, -37, -37, -38, -38, -38, -37,
-38, -36, -37, -36, -38, -36, -36, -35, -35, -34, -34, -33, -33, -31, -30, -31,
-28, -30, -24, -30, 24, -37, -91, -65, -77, -66, -71, -66, -68, -63, -64, -60,
-60, -57, -55, -53, -52, -50, -48, -46, -43, -43, -40, -39, -37, -36, -32, -31,
-29, -27, -25, -24, -22, -21, -18, -16, -15, -13, -11, -10, -9, -7, -7, -4, -4,
-2, -1, 0, };