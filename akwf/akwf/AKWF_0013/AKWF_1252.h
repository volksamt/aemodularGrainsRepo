#define DATA_LENGTH 512
#define DATA AKWF_1252

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 7, 9, 11, 12, 15, 16, 18, 20,
22, 24, 26, 27, 29, 31, 32, 34, 36, 37, 38, 39, 42, 42, 44, 46, 46, 48, 48, 50,
52, 53, 54, 56, 57, 58, 59, 60, 60, 62, 63, 65, 65, 66, 67, 68, 69, 70, 71, 72,
73, 73, 75, 75, 76, 77, 78, 78, 80, 81, 80, 81, 83, 83, 84, 84, 85, 86, 86, 87,
87, 89, 89, 89, 90, 91, 91, 91, 93, 92, 93, 94, 94, 95, 96, 95, 96, 97, 97, 97,
99, 99, 100, 99, 99, 100, 101, 101, 101, 102, 102, 103, 102, 103, 104, 104, 104,
104, 104, 105, 105, 106, 105, 106, 107, 107, 107, 107, 107, 108, 108, 109, 109,
109, 110, 109, 110, 110, 110, 111, 111, 111, 111, 112, 111, 112, 113, 112, 112,
112, 113, 113, 113, 112, 113, 114, 114, 113, 114, 113, 114, 113, 113, 114, 114,
114, 114, 115, 114, 114, 114, 114, 114, 114, 114, 113, 113, 112, 113, 112, 111,
112, 112, 110, 110, 109, 109, 109, 108, 108, 106, 105, 105, 104, 102, 102, 100,
100, 99, 98, 97, 95, 94, 93, 91, 90, 89, 89, 87, 86, 85, 83, 81, 81, 79, 78, 77,
75, 75, 73, 72, 70, 69, 68, 68, 67, 66, 64, 63, 61, 61, 59, 58, 57, 56, 55, 54,
54, 52, 51, 50, 50, 49, 48, 47, 46, 45, 44, 42, 42, 41, 39, 37, 38, 36, 35, 33,
33, 31, 29, 28, 27, 25, 24, 22, 22, 20, 18, 16, 14, 12, 11, 9, 7, 7, 4, 2, 1,
-1, -2, -5, -6, -8, -10, -12, -13, -15, -17, -18, -20, -22, -23, -25, -27, -28,
-30, -31, -33, -34, -35, -37, -38, -40, -42, -43, -44, -45, -47, -48, -50, -50,
-52, -54, -55, -56, -57, -58, -59, -61, -62, -63, -64, -65, -65, -66, -68, -68,
-69, -70, -71, -72, -73, -74, -75, -75, -76, -78, -77, -78, -79, -80, -81, -81,
-83, -82, -84, -85, -85, -86, -86, -87, -88, -89, -89, -89, -90, -90, -92, -92,
-92, -93, -93, -94, -95, -95, -95, -96, -96, -97, -97, -98, -98, -98, -98, -99,
-99, -100, -101, -102, -101, -101, -102, -103, -103, -103, -103, -104, -105,
-105, -105, -106, -106, -106, -106, -107, -107, -107, -107, -108, -108, -108,
-109, -109, -108, -109, -110, -109, -109, -110, -110, -110, -111, -110, -111,
-112, -111, -112, -112, -112, -112, -112, -113, -113, -113, -113, -113, -114,
-114, -114, -114, -114, -114, -115, -115, -114, -115, -115, -114, -115, -115,
-115, -115, -116, -116, -116, -116, -117, -116, -117, -117, -116, -117, -117,
-117, -117, -117, -117, -118, -117, -118, -118, -118, -118, -118, -119, -118,
-118, -119, -118, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-120, -119, -117, -115, -113, -109, -106, -102, -99, -94, -91, -87, -84, -80,
-76, -73, -69, -66, -64, -61, -57, -53, -50, -47, -45, -41, -39, -36, -33, -31,
-28, -25, -22, -20, -18, -15, -13, -10, -8, -6, -4, -1, };