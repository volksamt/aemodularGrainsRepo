#define DATA_LENGTH 512
#define DATA AKWF_1223

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 6, 8, 10, 12, 13, 16, 17, 19,
21, 23, 25, 27, 28, 30, 31, 33, 36, 38, 39, 41, 42, 44, 47, 48, 50, 52, 54, 55,
58, 60, 61, 62, 65, 66, 69, 70, 71, 72, 75, 76, 78, 79, 81, 82, 83, 85, 86, 87,
89, 91, 93, 93, 94, 96, 97, 99, 99, 100, 101, 103, 104, 105, 105, 107, 108, 108,
108, 110, 111, 111, 113, 114, 114, 114, 115, 115, 116, 117, 117, 117, 117, 118,
119, 118, 118, 119, 119, 118, 119, 120, 119, 119, 118, 118, 117, 117, 117, 117,
116, 115, 115, 115, 114, 113, 113, 111, 111, 110, 109, 108, 108, 106, 104, 104,
103, 101, 100, 99, 97, 96, 94, 94, 92, 90, 89, 87, 86, 84, 81, 80, 79, 76, 75,
73, 72, 69, 67, 66, 63, 62, 60, 57, 55, 53, 51, 50, 47, 45, 42, 40, 38, 35, 33,
31, 29, 26, 24, 21, 18, 16, 13, 11, 9, 6, 4, 1, -1, -4, -7, -9, -12, -14, -16,
-20, -21, -23, -26, -28, -31, -34, -36, -38, -41, -43, -45, -47, -49, -52, -53,
-55, -57, -59, -61, -64, -65, -66, -69, -70, -72, -73, -75, -77, -78, -80, -82,
-83, -84, -86, -86, -89, -88, -90, -92, -92, -93, -94, -96, -96, -97, -98, -98,
-100, -100, -100, -101, -102, -103, -103, -103, -104, -105, -105, -105, -105,
-106, -105, -106, -106, -105, -105, -106, -106, -105, -106, -105, -106, -105,
-104, -104, -104, -104, -104, -103, -103, -102, -102, -102, -100, -100, -100,
-99, -99, -98, -97, -97, -96, -97, -95, -94, -94, -93, -92, -91, -90, -90, -88,
-87, -87, -87, -85, -85, -83, -82, -80, -80, -79, -78, -75, -75, -73, -72, -71,
-70, -68, -66, -65, -64, -62, -60, -59, -57, -56, -54, -52, -52, -50, -47, -47,
-45, -43, -43, -41, -39, -37, -36, -35, -33, -31, -29, -28, -28, -26, -25, -23,
-21, -20, -19, -18, -17, -15, -15, -13, -11, -11, -9, -8, -7, -6, -5, -4, -3,
-2, -1, -1, 1, 1, 2, 4, 4, 5, 6, 6, 8, 8, 9, 10, 10, 11, 11, 12, 13, 14, 14, 15,
15, 16, 16, 17, 17, 18, 18, 18, 18, 19, 19, 20, 20, 20, 20, 20, 20, 21, 21, 22,
21, 22, 21, 22, 21, 21, 21, 22, 21, 22, 21, 20, 20, 20, 20, 20, 20, 19, 19, 19,
18, 18, 20, 18, 19, 19, 20, 21, 22, 22, 23, 23, 26, 26, 27, 28, 29, 32, 32, 34,
34, 36, 36, 38, 38, 38, 39, 39, 39, 38, 37, 36, 34, 32, 30, 28, 25, 22, 19, 15,
11, 6, 2, -3, -8, -12, -19, -24, -28, -33, -38, -44, -49, -54, -59, -62, -67,
-70, -73, -76, -78, -79, -81, -82, -82, -83, -83, -82, -82, -80, -79, -79, -78,
-75, -74, -72, -69, -67, -65, -62, -60, -58, -54, -52, -50, -47, -44, -41, -39,
-36, -34, -32, -29, -27, -24, -22, -19, -17, -15, -13, -11, -8, -6, -4, -2, 0,
};