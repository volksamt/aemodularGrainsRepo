#define DATA_LENGTH 512
#define DATA AKWF_1271

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 10, 14, 17, 22, 24, 30, 33, 38,
41, 46, 50, 54, 58, 62, 66, 70, 73, 76, 81, 84, 87, 91, 93, 97, 100, 103, 104,
107, 108, 110, 111, 113, 112, 113, 113, 112, 108, 104, 81, 45, 39, 50, 56, 59,
60, 59, 58, 57, 56, 54, 52, 51, 49, 47, 45, 42, 40, 38, 36, 33, 31, 29, 25, 23,
21, 20, 17, 14, 11, 10, 7, 4, 3, -1, -3, -5, -7, -10, -12, -14, -16, -18, -20,
-21, -23, -26, -28, -30, -31, -34, -35, -37, -38, -40, -42, -44, -44, -46, -47,
-49, -49, -50, -52, -52, -54, -54, -54, -54, -56, -56, -55, -57, -56, -56, -56,
-55, -55, -54, -54, -54, -53, -51, -51, -50, -49, -46, -45, -44, -42, -41, -40,
-38, -36, -35, -32, -30, -29, -26, -25, -24, -20, -19, -17, -15, -14, -12, -11,
-10, -8, -7, -6, -5, -5, -4, -4, -4, -5, -5, -6, -7, -9, -11, -13, -16, -20,
-24, -27, -29, -32, -32, -32, -33, -32, -31, -31, -30, -28, -26, -24, -22, -19,
-16, -13, -10, -8, -4, -2, 2, 5, 7, 11, 15, 18, 21, 24, 27, 30, 33, 36, 39, 42,
45, 46, 48, 51, 53, 56, 57, 59, 61, 62, 64, 65, 66, 68, 68, 69, 69, 69, 71, 71,
71, 71, 71, 72, 72, 71, 71, 71, 70, 70, 70, 70, 71, 71, 71, 74, 85, 102, 103,
98, 94, 91, 88, 87, 86, 84, 84, 82, 80, 80, 78, 75, 43, -29, -52, -39, -32, -28,
-30, -32, -34, -36, -40, -41, -46, -48, -50, -54, -57, -61, -63, -67, -70, -74,
-76, -80, -83, -87, -90, -93, -95, -99, -101, -104, -106, -108, -111, -113,
-114, -116, -117, -118, -119, -119, -119, -119, -118, -115, -113, -109, -99,
-66, -37, -40, -49, -52, -52, -51, -50, -48, -46, -44, -41, -38, -35, -32, -29,
-26, -23, -20, -17, -14, -12, -8, -4, -2, 3, 5, 7, 11, 14, 16, 18, 21, 23, 26,
29, 30, 32, 34, 36, 37, 40, 41, 43, 43, 45, 47, 48, 49, 49, 50, 50, 51, 52, 51,
52, 52, 52, 52, 51, 52, 52, 51, 50, 49, 50, 49, 48, 48, 47, 46, 44, 43, 43, 41,
39, 39, 37, 37, 35, 33, 32, 30, 30, 28, 26, 24, 23, 22, 20, 18, 17, 16, 15, 14,
12, 12, 10, 9, 9, 8, 7, 6, 6, 5, 4, 5, 5, 5, 5, 6, 6, 8, 10, 10, 12, 15, 16, 19,
22, 27, 29, 31, 33, 33, 35, 35, 35, 34, 33, 32, 32, 30, 28, 26, 24, 21, 19, 15,
13, 10, 7, 4, 1, -3, -6, -9, -13, -17, -21, -24, -28, -31, -35, -39, -42, -46,
-48, -52, -55, -57, -61, -64, -67, -70, -73, -75, -78, -80, -83, -85, -87, -89,
-90, -92, -94, -95, -97, -98, -99, -101, -102, -102, -104, -105, -105, -105,
-106, -106, -107, -107, -108, -109, -110, -110, -108, -92, -58, -33, -24, -21,
-19, -16, -14, -11, -7, -3, -1, };