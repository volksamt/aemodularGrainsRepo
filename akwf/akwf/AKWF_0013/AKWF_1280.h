#define DATA_LENGTH 512
#define DATA AKWF_1280

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 3, 4, 6, 8, 10, 10, 12, 13, 14,
16, 18, 17, 20, 21, 22, 22, 24, 26, 27, 28, 30, 29, 31, 32, 33, 33, 34, 35, 35,
37, 37, 39, 38, 39, 39, 40, 41, 41, 42, 42, 43, 43, 43, 44, 44, 45, 45, 46, 45,
45, 46, 45, 46, 45, 45, 46, 46, 46, 46, 46, 45, 45, 46, 46, 46, 46, 46, 45, 45,
47, 45, 46, 46, 45, 45, 44, 45, 45, 45, 45, 45, 44, 46, 46, 45, 45, 46, 46, 45,
45, 45, 46, 45, 45, 46, 46, 47, 46, 46, 47, 47, 48, 47, 48, 47, 48, 48, 49, 49,
50, 50, 50, 51, 50, 52, 52, 52, 52, 53, 53, 53, 54, 54, 55, 55, 55, 56, 56, 56,
57, 57, 57, 58, 58, 59, 60, 59, 60, 60, 60, 60, 60, 62, 61, 61, 61, 62, 62, 62,
62, 62, 63, 62, 63, 63, 63, 63, 62, 63, 63, 63, 62, 63, 63, 62, 62, 62, 61, 62,
61, 61, 60, 61, 61, 61, 60, 60, 58, 58, 58, 58, 57, 57, 56, 56, 55, 54, 53, 54,
53, 52, 52, 51, 51, 49, 49, 48, 48, 48, 46, 46, 45, 45, 45, 43, 43, 42, 42, 41,
39, 39, 39, 38, 37, 36, 36, 36, 35, 33, 33, 33, 31, 32, 30, 30, 28, 28, 28, 27,
26, 26, 25, 25, 24, 23, 22, 22, 21, 21, 21, 20, 19, 19, 18, 17, 18, 16, 16, 15,
15, 14, 14, 13, 13, 12, 11, 12, 11, 10, 10, 9, 8, 8, 8, 8, 7, 6, 5, 6, 6, 3, 4,
2, 0, -4, -7, -12, -15, -20, -25, -30, -37, -41, -48, -52, -63, 8, 64, 53, 56,
52, 58, 61, 69, 73, 79, 81, 79, 74, 66, 54, 41, 27, 15, 5, -3, -9, -12, -13,
-15, -14, -16, -19, -23, -29, -35, -43, -50, -56, -63, -69, -72, -75, -77, -78,
-79, -80, -83, -83, -88, -90, -94, -98, -101, -105, -107, -109, -110, -111,
-111, -111, -111, -112, -112, -113, -114, -114, -116, -117, -118, -119, -119,
-119, -119, -118, -117, -117, -117, -115, -115, -115, -115, -114, -115, -115,
-114, -113, -113, -112, -110, -109, -107, -105, -104, -100, -98, -95, -93, -90,
-88, -84, -83, -80, -77, -74, -70, -68, -66, -64, -60, -58, -57, -55, -52, -51,
-49, -48, -46, -45, -44, -42, -41, -40, -39, -38, -38, -36, -35, -36, -35, -34,
-34, -33, -34, -33, -32, -33, -32, -33, -32, -32, -32, -32, -32, -33, -32, -32,
-33, -34, -33, -33, -34, -34, -35, -35, -36, -36, -36, -37, -37, -38, -39, -39,
-39, -40, -40, -41, -41, -42, -42, -42, -42, -42, -43, -43, -43, -44, -44, -43,
-44, -44, -43, -44, -44, -43, -44, -43, -43, -43, -43, -42, -41, -41, -41, -40,
-39, -38, -38, -38, -36, -36, -35, -34, -34, -33, -32, -31, -29, -28, -27, -27,
-25, -24, -23, -21, -20, -18, -17, -17, -15, -13, -12, -11, -9, -7, -7, -4, -3,
-2, -1, };