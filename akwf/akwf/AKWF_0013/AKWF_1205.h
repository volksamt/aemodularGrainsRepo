#define DATA_LENGTH 512
#define DATA AKWF_1205

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 7, 11, 13, 17, 20, 24, 26, 30,
32, 37, 35, 9, 15, 17, 20, 23, 27, 29, 33, 35, 38, 42, 46, 47, 52, 54, 58, 61,
65, 66, 71, 73, 76, 81, 81, 90, 69, 61, -11, -32, -16, -22, -12, -15, -6, -7,
-1, 0, 5, 5, 10, 12, 17, 19, 23, 25, 29, 32, 34, 38, 41, 44, 47, 51, 52, 57, 59,
65, 65, 70, 71, 77, 76, 84, 83, 91, 89, 97, 94, 106, 87, 9, 22, 20, 26, 26, 34,
23, 2, 11, 10, 16, 16, 22, 24, 29, 30, 35, 35, 41, 43, 47, 49, 53, 55, 60, 61,
65, 68, 71, 75, 76, 83, 59, 53, 60, 62, 65, 68, 70, 77, 74, 90, 35, -16, 6, -4,
10, 5, 14, 11, 20, 19, 26, 25, 30, 34, -52, -73, -89, -89, -83, -83, -77, -77,
-71, -71, -65, -64, -59, -57, -53, -52, -47, -45, -41, -37, -34, -32, -29, -26,
-22, -19, -16, -13, -10, -7, -4, -1, 2, 5, 8, 12, 15, 18, 21, 26, 27, 31, 33,
38, 39, 44, 45, 50, 52, 56, 57, 63, 64, 38, 39, 43, 46, 49, 53, 55, 59, 61, 66,
67, 72, 73, 80, 79, 87, 83, 98, 72, -4, 13, 8, 17, 15, 25, 11, -9, 1, 0, 6, 6,
13, 13, 19, 18, 25, 25, 31, 32, 37, 39, 43, 45, 50, 51, 55, 57, 61, 64, 67, 72,
48, 43, 49, 51, 55, 58, 61, 66, 63, 80, 20, -27, -4, -13, -1, -7, 4, 1, 10, 9,
15, 14, 21, 23, -69, -77, -68, -69, -61, -62, -56, -56, -51, -48, -44, -42, -39,
-36, -33, -29, -27, -23, -22, -16, -16, -10, -9, -4, -2, 1, 7, -12, -24, -99,
-110, -99, -103, -93, -95, -88, -89, -81, -82, -75, -76, -70, -69, -63, -63,
-58, -56, -52, -50, -46, -43, -38, -39, -66, -62, -58, -55, -52, -49, -46, -43,
-40, -37, -34, -31, -27, -24, -21, -19, -15, -13, -8, -6, -2, 0, 5, 5, 14, -2,
-18, -10, -10, -5, -3, 1, 4, 7, 10, 14, 16, 19, 23, 26, 29, 32, 35, 38, 41, 45,
47, 51, 54, 57, 60, 63, 67, 69, 74, 75, 80, 81, 87, 84, 100, 35, -5, 17, 7, 20,
13, 26, 21, 32, 27, 38, 33, 45, 37, -49, -64, -81, -78, -74, -72, -67, -66, -61,
-59, -55, -53, -49, -46, -44, -39, -37, -34, -31, -27, -25, -21, -19, -14, -13,
-8, -5, -23, -37, -113, -120, -109, -113, -103, -106, -98, -100, -92, -93, -86,
-86, -80, -80, -74, -74, -67, -67, -62, -61, -55, -55, -49, -52, -76, -71, -69,
-66, -63, -59, -57, -53, -51, -47, -45, -39, -39, -32, -35, -24, -30, -12, -50,
-117, -99, -104, -96, -96, -91, -88, -86, -82, -79, -76, -73, -70, -67, -63,
-61, -57, -55, -50, -49, -43, -43, -38, -36, -31, -30, -26, -23, -19, -17, -13,
-10, -35, -37, -31, -29, -25, -24, -19, -17, -13, -11, -8, -4, -1, };