#define DATA_LENGTH 512
#define DATA AKWF_1242

const PROGMEM int8_t DATA[DATA_LENGTH] = {53, 86, 74, 80, 74, 77, 74, 75, 72,
73, 71, 70, 69, 68, 66, 64, 62, 60, 58, 57, 56, 55, 53, 51, 49, 47, 46, 44, 42,
40, 39, 37, 35, 32, 30, 29, 28, 25, 23, 22, 21, 19, 17, 15, 13, 11, 9, 7, 5, 4,
2, 0, 0, -2, -3, -5, -6, -6, -7, -9, -9, -12, -12, -13, -13, -15, -14, -15, -17,
-17, -18, -18, -17, -25, -36, -26, -19, -14, -7, -1, 4, 7, 11, 15, 19, 21, 25,
28, 31, 33, 36, 38, 41, 42, 45, 47, 49, 51, 53, 55, 58, 59, 61, 63, 65, 66, 67,
71, 71, 72, 73, 75, 76, 77, 78, 79, 80, 81, 81, 83, 83, 83, 83, 83, 83, 83, 83,
82, 82, 82, 82, 80, 81, 79, 79, 78, 68, -24, -78, -39, -23, -5, 7, 18, 26, 31,
38, 40, 42, 44, 44, 45, 45, 45, 45, 44, 42, 40, 38, 37, 36, 34, 32, 30, 28, 26,
25, 23, 22, 19, 18, 16, 14, 11, 10, 8, 7, 4, 2, 2, -1, -2, -3, -4, -5, -6, -8,
-8, -10, -12, -13, -13, -14, -15, -15, -17, -16, -18, -18, -19, -15, 5, 14, 13,
16, 16, 19, 20, 22, 23, 25, 26, 28, 30, 32, 34, 36, 38, 39, 41, 42, 46, 46, 49,
49, 53, 53, 58, 55, 65, 19, -89, -103, -102, -105, -105, -109, -108, -110, -110,
-112, -112, -114, -114, -116, -115, -118, -117, -119, -118, -120, -119, -121,
-117, -121, -57, 67, 87, 78, 82, 80, 80, 79, 78, 77, 77, 75, 74, 72, 71, 69, 68,
67, 65, 62, 61, 59, 57, 56, 54, 52, 50, 49, 47, 45, 42, 41, 39, 37, 34, 33, 31,
30, 27, 25, 24, 22, 20, 18, 16, 14, 11, 10, 7, 6, 4, 3, 1, 0, -1, -3, -4, -5,
-6, -8, -10, -10, -11, -13, -13, -14, -15, -16, -17, -17, -18, -17, -18, -19,
-17, -17, -18, -18, -19, -19, -20, -21, -23, -23, -24, -24, -25, -24, -25, -25,
-26, -26, -26, -27, -28, -28, -29, -29, -28, -29, -29, -29, -28, -29, -29, -28,
-29, -28, -27, -28, -28, -27, -28, -29, -28, -27, -26, -27, -27, -26, -26, -26,
-26, -25, -25, -26, -24, -24, -24, -25, -24, -24, -24, -24, -23, -23, -22, -21,
-17, -16, -17, -18, -19, -19, -19, -20, -20, -19, -20, -20, -19, -20, -20, -20,
-19, -19, -19, -19, -19, -20, -19, -18, -18, -19, -19, -19, -18, -17, -17, -16,
-16, -17, -16, -16, -16, -15, -15, -15, -14, -13, -12, -11, -10, -9, -10, -8,
-8, -6, -6, -5, -4, -2, -1, 0, 0, 2, 4, 6, 7, 8, 9, 12, 13, 14, 15, 17, 18, 19,
22, 23, 24, 26, 27, 29, 31, 32, 34, 35, 37, 39, 41, 42, 44, 45, 48, 49, 52, 51,
56, 53, 64, 7, -94, -100, -101, -102, -103, -105, -106, -107, -108, -108, -110,
-111, -111, -112, -113, -114, -114, -115, -115, -115, -115, -116, -113, -115,
-46, };