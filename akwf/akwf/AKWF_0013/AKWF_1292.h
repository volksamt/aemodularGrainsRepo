#define DATA_LENGTH 512
#define DATA AKWF_1292

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 6, 12, 17, 22, 27, 32, 36, 41, 45,
49, 54, 58, 62, 62, 61, 60, 60, 59, 58, 58, 57, 56, 56, 56, 56, 55, 54, 54, 53,
53, 52, 51, 51, 51, 51, 50, 50, 48, 48, 48, 47, 46, 47, 46, 46, 45, 44, 45, 44,
44, 43, 43, 42, 42, 41, 41, 41, 40, 39, 40, 39, 39, 38, 38, 38, 38, 38, 36, 36,
36, 35, 35, 35, 34, 34, 34, 34, 34, 33, 32, 32, 32, 32, 32, 30, 32, 30, 30, 30,
30, 29, 29, 28, 28, 29, 28, 28, 28, 27, 27, 26, 26, 26, 25, 25, 25, 26, 24, 25,
25, 23, 24, 24, 23, 24, 23, 24, 22, 22, 23, 22, 22, 22, 21, 21, 21, 21, 20, 19,
20, 20, 20, 18, 19, 18, 19, 19, 19, 19, 18, 19, 18, 18, 18, 17, 17, 18, 16, 19,
15, 19, 14, 17, 14, 17, 14, 17, 14, 16, 12, 11, 5, 3, -3, -8, -14, -26, -23,
-69, 14, 22, 10, 22, 10, 21, 11, 19, 12, 18, 12, 17, 12, 16, 12, 16, 14, 14, 13,
13, 13, 13, 13, 12, 14, 12, 14, 11, 13, 11, 13, 11, 12, 12, 12, 11, 12, 11, 11,
10, 12, 11, 11, 11, 12, 10, 10, 10, 10, 11, 10, 10, 10, 10, 9, 10, 9, 9, 10, 10,
9, 9, 9, 9, 8, 9, 9, 8, 8, 8, 9, 7, 8, 9, 8, 8, 8, 8, 8, 8, 8, 7, 7, 7, 7, 7, 7,
7, 6, 7, 7, 6, 7, 7, 6, 7, 6, 7, 7, 5, 6, 6, 6, 6, 6, 6, 6, 6, 5, 6, 6, 5, 6, 6,
5, 4, 5, 5, 5, 5, 5, 5, 5, 5, 4, 5, 4, 4, 4, 5, 5, 5, 5, 5, 4, 4, 5, 4, 5, 5, 5,
4, 4, 4, 4, 4, 4, 4, 3, 4, 4, 3, 4, 3, 4, 3, 4, 3, 3, 3, 3, 3, 3, 3, 4, 3, 3, 3,
3, 3, 3, 2, 4, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 2, 3, 3, 2, 3, 2, 2, 2, 2, 2, 2,
3, 3, 3, 2, 3, 3, 2, 3, 2, 2, 2, 2, 2, 2, 3, 2, 2, 1, 2, 2, 2, 2, 3, 2, 2, 2, 2,
2, 2, 3, 2, 2, 2, 2, 1, 3, 2, 3, 1, 3, 1, 3, 1, 2, 2, 2, 2, 1, 2, 1, 1, 1, 2, 1,
3, 0, 4, -3, 7, -6, 16, -52, -128, -110, -121, -112, -116, -111, -113, -111,
-110, -109, -108, -107, -106, -106, -103, -103, -101, -101, -98, -99, -98, -98,
-95, -96, -94, -94, -93, -92, -90, -89, -89, -89, -88, -87, -85, -84, -85, -83,
-82, -82, -81, -80, -79, -79, -77, -77, -77, -75, -75, -74, -74, -73, -71, -72,
-70, -69, -69, -69, -68, -67, -66, -66, -65, -64, -64, -64, -64, -63, -62, -61,
-61, -60, -59, -58, -58, -59, -57, -51, -43, -37, -30, -23, -16, -10, -4, };