#define DATA_LENGTH 512
#define DATA AKWF_1269

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 2, 3, 4, 4, 5, 4, 6, 7, 7, 8,
8, 9, 9, 10, 11, 11, 12, 13, 13, 14, 15, 14, 14, 16, 17, 17, 17, 18, 18, 19, 19,
20, 20, 20, 21, 21, 22, 22, 23, 24, 24, 24, 24, 27, 26, 26, 27, 28, 28, 28, 28,
28, 29, 30, 30, 31, 32, 31, 32, 33, 32, 33, 34, 34, 35, 35, 35, 35, 36, 36, 36,
37, 38, 38, 38, 38, 39, 38, 39, 40, 40, 40, 40, 41, 41, 41, 41, 42, 42, 42, 43,
43, 43, 43, 44, 44, 44, 44, 45, 45, 45, 45, 45, 46, 46, 45, 46, 46, 46, 46, 47,
47, 46, 47, 46, 47, 47, 47, 47, 47, 47, 47, 47, 48, 48, 47, 47, 48, 47, 47, 47,
47, 47, 48, 48, 47, 47, 23, -22, -53, -76, -91, -102, -108, -112, -116, -118,
-118, -119, -118, -118, -118, -118, -117, -116, -115, -114, -113, -111, -110,
-109, -106, -106, -103, -101, -100, -97, -95, -93, -92, -90, -87, -86, -83, -80,
-78, -76, -74, -72, -69, -67, -65, -62, -61, -58, -56, -53, -52, -49, -46, -44,
-42, -39, -37, -35, -33, -31, -29, -27, -24, -23, -21, -18, -16, -14, -12, -11,
-8, -7, -4, -3, -1, -1, 1, 3, 4, 6, 7, 9, 10, 12, 13, 13, 15, 16, 17, 17, 18,
18, 19, 19, 20, 21, 20, 20, 20, 20, 20, 20, 21, 21, 21, 21, 22, 22, 22, 23, 23,
25, 24, 24, 26, 26, 27, 27, 27, 28, 28, 27, 29, 29, 29, 30, 30, 30, 31, 30, 31,
32, 31, 31, 32, 32, 33, 32, 32, 33, 32, 33, 33, 33, 33, 33, 32, 33, 32, 33, 33,
32, 32, 33, 32, 31, 32, 32, 32, 31, 31, 31, 31, 30, 30, 31, 29, 30, 29, 28, 28,
28, 27, 27, 26, 27, 26, 26, 25, 25, 24, 24, 24, 23, 22, 22, 22, 21, 21, 20, 19,
19, 18, 18, 17, 16, 16, 16, 16, 15, 14, 14, 13, 12, 12, 11, 11, 10, 9, 10, 9, 8,
8, 8, 6, 6, 5, 5, 4, 3, 3, 3, 2, 1, 1, 0, -1, -2, -1, -3, -2, -3, -3, -4, -4,
-6, -6, -6, -6, -7, -8, -8, -9, -10, -9, -10, -12, -12, -12, -12, -13, -13, -14,
-15, -15, -15, -15, -17, -16, -16, -18, -17, -18, -18, -18, -19, -20, -20, -20,
-20, -21, -21, -21, -22, -22, -22, -22, -23, -22, -23, -24, -24, -24, -24, -25,
-25, -24, -25, -25, -25, -25, -25, -25, -25, -26, -26, -26, -25, -26, -26, -27,
-26, -27, -26, -25, -26, -26, -26, -26, -26, -26, -26, -26, -26, -26, -25, -25,
-25, -25, -25, -24, -25, -24, -24, -24, -24, -24, -23, -23, -22, -22, -23, -21,
-21, -20, -21, -20, -21, -19, -19, -18, -18, -18, -17, -18, -17, -15, -16, -15,
-14, -14, -13, -13, -13, -12, -11, -11, -10, -10, -8, -8, -8, -6, -6, -5, -4,
-4, -2, -2, -2, -1, 0, };