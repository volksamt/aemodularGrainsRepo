#define DATA_LENGTH 512
#define DATA AKWF_1264

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 2, 2, 3, 3, 4, 5, 5, 5, 7, 7,
7, 9, 9, 9, 10, 10, 11, 11, 12, 14, 14, 14, 15, 16, 16, 17, 18, 18, 19, 20, 20,
21, 21, 22, 22, 23, 24, 24, 24, 26, 26, 28, 28, 28, 30, 30, 31, 32, 32, 33, 34,
34, 34, 35, 37, 38, 38, 38, 39, 40, 41, 41, 43, 43, 44, 44, 45, 45, 46, 47, 47,
48, 49, 50, 51, 52, 51, 52, 53, 53, 54, 55, 55, 57, 57, 58, 59, 60, 61, 60, 61,
62, 63, 64, 64, 64, 65, 65, 67, 67, 69, 68, 69, 69, 70, 70, 72, 71, 72, 73, 74,
74, 72, 24, -76, -120, -115, -114, -113, -110, -108, -107, -105, -103, -101,
-100, -98, -96, -94, -93, -90, -90, -87, -85, -84, -83, -81, -79, -78, -76, -74,
-73, -72, -70, -69, -66, -65, -64, -62, -61, -59, -58, -57, -55, -53, -52, -51,
-50, -48, -46, -45, -43, -43, -42, -40, -39, -37, -37, -34, -34, -31, -31, -30,
-29, -27, -26, -26, -24, -23, -22, -21, -20, -19, -18, -17, -16, -15, -13, -12,
-11, -11, -10, -9, -9, -8, -7, -6, -5, -5, -3, -2, -1, 0, 0, 1, 2, 2, 4, 3, 5,
5, 6, 7, 6, 8, 8, 9, 10, 10, 10, 12, 13, 12, 13, 13, 14, 15, 15, 15, 16, 16, 16,
17, 17, 17, 18, 19, 18, 19, 19, 20, 20, 20, 20, 21, 21, 21, 21, 22, 22, 22, 21,
22, 23, 22, 23, 22, 23, 22, 23, 23, 22, 23, 23, 23, 22, 23, 23, 23, 23, 23, 23,
23, 23, 23, 23, 23, 23, 22, 22, 23, 22, 22, 22, 22, 22, 21, 21, 21, 22, 21, 21,
19, 20, 21, 20, 19, 20, 18, 19, 18, 18, 18, 18, 17, 16, 17, 17, 17, 16, 16, 15,
16, 15, 14, 14, 13, 14, 13, 13, 13, 12, 12, 12, 11, 10, 10, 10, 9, 10, 9, 9, 8,
9, 7, 8, 7, 6, 6, 6, 5, 5, 5, 4, 3, 4, 3, 3, 1, 2, 1, 1, 0, 0, -1, -1, -1, -2,
-2, -3, -3, -3, -3, -4, -4, -5, -5, -4, -5, -5, -6, -7, -7, -8, -7, -8, -9, -9,
-9, -10, -9, -10, -10, -10, -11, -11, -12, -12, -11, -12, -12, -13, -14, -14,
-14, -14, -14, -14, -16, -16, -15, -16, -16, -15, -15, -17, -17, -16, -16, -17,
-17, -18, -18, -18, -18, -18, -18, -18, -19, -18, -19, -20, -18, -19, -19, -20,
-19, -20, -19, -19, -19, -20, -19, -19, -19, -19, -19, -19, -20, -19, -19, -20,
-19, -19, -19, -19, -19, -19, -19, -18, -18, -19, -19, -19, -18, -18, -17, -18,
-17, -17, -18, -16, -17, -17, -16, -15, -16, -16, -15, -15, -16, -15, -14, -13,
-13, -14, -14, -13, -13, -12, -13, -12, -11, -11, -11, -11, -10, -10, -10, -9,
-8, -9, -8, -6, -6, -6, -6, -6, -5, -4, -4, -4, -3, -3, -2, -1, -1, -1, -1, };