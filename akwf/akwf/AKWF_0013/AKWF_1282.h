#define DATA_LENGTH 512
#define DATA AKWF_1282

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 8, 10, 11, 14, 16, 17, 20,
20, 22, 23, 25, 27, 29, 30, 31, 32, 33, 35, 36, 38, 39, 41, 41, 43, 45, 45, 47,
48, 49, 50, 51, 53, 55, 55, 57, 58, 59, 61, 60, 62, 64, 64, 65, 67, 68, 69, 70,
71, 72, 73, 74, 75, 77, 78, 77, 78, 79, 79, 80, 80, 81, 81, 82, 82, 81, 82, 80,
80, 80, 78, 76, 75, 73, 70, 69, 67, 66, 64, 62, 61, 60, 59, 57, 57, 58, 57, 56,
57, 56, 56, 56, 58, 58, 58, 58, 58, 59, 60, 60, 60, 61, 62, 62, 62, 63, 64, 64,
65, 65, 65, 65, 66, 67, 67, 67, 68, 68, 68, 69, 68, 70, 69, 70, 70, 71, 71, 71,
71, 71, 72, 72, 73, 73, 72, 72, 73, 73, 74, 74, 75, 75, 75, 76, 76, 76, 77, 77,
78, 79, 80, 81, 83, 84, 86, 87, 89, 92, 94, 97, 99, 101, 105, 107, 108, 110,
112, 114, 115, 117, 117, 117, 118, 119, 118, 119, 120, 119, 119, 119, 119, 118,
118, 117, 118, 117, 116, 115, 114, 114, 114, 112, 112, 112, 111, 110, 109, 109,
108, 107, 107, 106, 105, 104, 102, 102, 101, 100, 99, 98, 98, 97, 95, 94, 93,
93, 92, 90, 89, 88, 87, 86, 84, 83, 81, 80, 79, 78, 76, 74, 73, 72, 70, 68, 66,
63, 61, 58, 56, 54, 50, 47, 43, 39, 35, 31, 26, 23, 19, 15, 12, 8, 4, 3, -1, -4,
-6, -7, -10, -12, -14, -16, -17, -19, -21, -22, -23, -25, -27, -28, -29, -30,
-32, -34, -34, -36, -38, -40, -40, -42, -43, -44, -45, -47, -48, -50, -51, -52,
-53, -54, -55, -57, -58, -60, -60, -62, -63, -64, -65, -65, -68, -67, -69, -70,
-71, -73, -73, -74, -75, -75, -78, -77, -78, -78, -80, -81, -81, -80, -81, -82,
-81, -81, -81, -81, -80, -79, -78, -77, -75, -74, -71, -69, -67, -65, -64, -61,
-61, -59, -58, -58, -58, -57, -56, -56, -56, -57, -57, -57, -57, -58, -58, -58,
-59, -58, -59, -61, -60, -60, -61, -61, -63, -62, -63, -64, -65, -65, -65, -66,
-66, -67, -66, -67, -67, -67, -68, -68, -69, -70, -69, -70, -70, -70, -71, -71,
-72, -72, -73, -72, -72, -73, -73, -73, -73, -74, -73, -75, -74, -75, -75, -76,
-76, -77, -77, -78, -78, -80, -81, -81, -82, -84, -85, -88, -90, -91, -94, -96,
-100, -103, -104, -107, -109, -111, -113, -114, -115, -116, -117, -118, -118,
-119, -119, -119, -120, -119, -119, -118, -117, -117, -118, -118, -116, -116,
-116, -116, -115, -114, -114, -113, -113, -111, -111, -110, -109, -109, -108,
-107, -106, -106, -105, -104, -102, -102, -102, -100, -99, -98, -98, -96, -95,
-94, -93, -92, -92, -89, -89, -88, -86, -85, -84, -83, -82, -81, -79, -78, -77,
-75, -73, -71, -69, -67, -66, -63, -61, -59, -56, -53, -50, -46, -42, -39, -35,
-30, -26, -22, -18, -15, -11, -7, -5, -2, };