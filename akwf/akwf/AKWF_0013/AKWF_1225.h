#define DATA_LENGTH 512
#define DATA AKWF_1225

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 11, 15, 20, 24, 29, 34, 37, 42,
45, 49, 54, 56, 59, 63, 65, 68, 70, 72, 73, 76, 78, 78, 79, 79, 80, 80, 80, 79,
78, 75, 72, 70, 66, 62, 56, 50, 44, 38, 33, 24, 17, 11, 3, -3, -9, -14, -21,
-25, -30, -35, -38, -40, -41, -42, -42, -40, -37, -33, -29, -25, -20, -16, -11,
-7, -2, 1, 4, 8, 10, 13, 15, 16, 16, 17, 17, 17, 16, 16, 15, 14, 13, 13, 11, 10,
9, 8, 7, 6, 6, 5, 3, 2, 1, -1, -2, -3, -4, -6, -8, -9, -11, -13, -14, -16, -18,
-21, -23, -26, -29, -32, -34, -38, -42, -45, -49, -52, -56, -60, -64, -67, -71,
-75, -79, -83, -85, -89, -93, -96, -100, -102, -105, -107, -110, -112, -113,
-115, -116, -117, -117, -119, -119, -119, -119, -119, -119, -118, -118, -117,
-116, -115, -114, -113, -112, -110, -108, -107, -104, -103, -100, -97, -94, -91,
-88, -84, -79, -74, -69, -64, -60, -53, -47, -41, -35, -29, -23, -16, -9, -3, 3,
9, 14, 21, 25, 29, 34, 37, 39, 43, 45, 46, 47, 48, 51, 51, 51, 51, 51, 49, 48,
44, 43, 42, 39, 37, 34, 32, 30, 28, 26, 25, 22, 21, 21, 19, 18, 17, 15, 14, 13,
12, 11, 10, 10, 9, 8, 8, 8, 7, 7, 7, 7, 7, 7, 7, 9, 9, 9, 11, 11, 13, 14, 17,
18, 20, 21, 24, 27, 29, 32, 34, 37, 40, 42, 44, 47, 49, 52, 53, 55, 56, 58, 60,
61, 63, 64, 65, 64, 66, 67, 66, 67, 66, 66, 67, 67, 67, 67, 66, 67, 67, 67, 66,
67, 66, 65, 65, 65, 63, 63, 62, 61, 59, 58, 55, 53, 52, 48, 44, 42, 39, 35, 31,
27, 22, 18, 12, 7, 1, -4, -10, -15, -21, -26, -32, -38, -44, -49, -55, -59, -65,
-69, -73, -78, -82, -85, -88, -91, -93, -96, -97, -99, -100, -101, -102, -102,
-103, -104, -104, -104, -105, -105, -105, -104, -105, -105, -105, -104, -104,
-104, -104, -103, -103, -102, -102, -101, -101, -100, -101, -99, -98, -98, -96,
-95, -94, -93, -92, -91, -88, -88, -86, -83, -83, -80, -79, -77, -74, -72, -70,
-67, -65, -63, -61, -58, -56, -53, -50, -48, -45, -43, -39, -37, -33, -31, -28,
-24, -21, -18, -16, -13, -10, -6, -3, 0, 3, 7, 9, 12, 15, 18, 20, 23, 26, 29,
31, 34, 36, 38, 41, 42, 44, 47, 48, 50, 52, 53, 54, 55, 56, 56, 58, 58, 59, 59,
58, 58, 58, 57, 57, 56, 55, 54, 52, 50, 48, 45, 42, 39, 35, 32, 29, 25, 21, 16,
11, 9, 7, 6, 6, 5, 7, 7, 8, 8, 7, 5, 2, 0, -4, -7, -10, -14, -17, -22, -26, -29,
-32, -36, -38, -42, -44, -47, -47, -49, -52, -52, -53, -52, -53, -53, -53, -52,
-52, -51, -49, -49, -46, -45, -43, -40, -37, -35, -32, -29, -25, -21, -19, -14,
-10, -6, -1, };