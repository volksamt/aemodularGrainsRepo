#define DATA_LENGTH 512
#define DATA AKWF_1210

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 9, 15, 21, 27, 30, 32, 31, 30, 27,
25, 22, 20, 19, 22, 23, 27, 32, 36, 39, 42, 44, 45, 45, 44, 46, 46, 48, 51, 55,
59, 65, 71, 77, 84, 92, 97, 103, 107, 110, 113, 115, 115, 114, 115, 114, 114,
114, 115, 115, 115, 116, 117, 118, 119, 119, 119, 118, 117, 114, 111, 108, 105,
103, 101, 100, 99, 99, 96, 95, 94, 92, 90, 87, 83, 80, 75, 71, 68, 65, 62, 59,
57, 55, 52, 51, 46, 41, 36, 31, 23, 17, 10, 4, -2, -7, -13, -17, -23, -28, -33,
-39, -42, -46, -49, -49, -50, -50, -49, -48, -47, -45, -43, -43, -44, -46, -49,
-52, -57, -62, -66, -71, -73, -76, -79, -81, -82, -82, -83, -85, -86, -87, -90,
-93, -95, -96, -98, -98, -96, -94, -93, -89, -86, -81, -76, -71, -65, -62, -59,
-56, -54, -53, -52, -52, -51, -53, -56, -58, -60, -62, -64, -64, -63, -59, -55,
-51, -46, -40, -33, -28, -23, -18, -15, -12, -12, -12, -11, -12, -13, -14, -13,
-12, -12, -10, -7, -4, 0, 4, 7, 12, 16, 19, 22, 24, 25, 26, 26, 26, 26, 26, 27,
27, 28, 29, 30, 33, 35, 37, 39, 41, 41, 42, 42, 42, 42, 41, 41, 41, 40, 41, 42,
42, 45, 46, 50, 52, 55, 57, 60, 61, 62, 63, 62, 63, 63, 61, 59, 57, 54, 51, 48,
47, 45, 45, 45, 45, 45, 44, 45, 44, 43, 42, 41, 39, 37, 35, 34, 32, 31, 29, 29,
28, 27, 27, 27, 25, 24, 23, 21, 18, 16, 13, 9, 7, 3, 1, -2, -4, -5, -6, -6, -7,
-7, -7, -7, -7, -6, -7, -9, -10, -13, -15, -18, -20, -23, -26, -27, -28, -29,
-29, -29, -28, -27, -26, -25, -24, -23, -22, -21, -21, -20, -19, -18, -17, -15,
-13, -10, -8, -6, -3, 1, 5, 10, 14, 17, 20, 23, 24, 26, 26, 28, 28, 27, 29, 30,
32, 34, 38, 40, 43, 46, 49, 51, 51, 50, 49, 47, 46, 44, 43, 43, 43, 44, 48, 49,
52, 53, 54, 54, 54, 52, 50, 48, 47, 44, 43, 42, 40, 40, 40, 40, 40, 38, 36, 34,
30, 28, 24, 19, 16, 12, 9, 6, 4, 3, 0, -1, -2, -2, -2, -2, -2, -3, -3, -4, -6,
-7, -8, -10, -9, -11, -12, -13, -16, -18, -21, -25, -28, -32, -36, -40, -46,
-52, -57, -61, -65, -68, -69, -69, -69, -70, -70, -70, -71, -71, -73, -74, -76,
-76, -78, -77, -75, -75, -73, -71, -71, -69, -68, -69, -68, -71, -75, -78, -81,
-82, -83, -84, -84, -86, -87, -87, -90, -92, -94, -98, -102, -105, -106, -108,
-108, -105, -102, -97, -91, -85, -80, -75, -70, -68, -65, -63, -61, -60, -58,
-56, -54, -50, -48, -45, -41, -39, -38, -36, -36, -38, -39, -40, -42, -44, -46,
-47, -47, -47, -46, -44, -43, -40, -38, -35, -33, -31, -28, -26, -25, -24, -23,
-22, -21, -18, -15, -10, -4, };