#define DATA_LENGTH 512
#define DATA AKWF_1241

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 17, 26, 32, 39, 43, 47, 51, 53, 56,
59, 61, 63, 64, 66, 68, 68, 70, 71, 73, 73, 74, 75, 77, 77, 77, 79, 80, 81, 82,
81, 82, 83, 84, 85, 86, 85, 87, 87, 88, 89, 90, 91, 91, 92, 93, 94, 93, 87, 78,
72, 64, 57, 49, 43, 33, 30, 8, 0, 12, 9, 12, 11, 13, 13, 14, 14, 16, 16, 17, 18,
18, 18, 19, 20, 22, 22, 22, 23, 24, 25, 25, 27, 26, 29, 26, 32, -35, -106, -101,
-105, -104, -106, -106, -107, -107, -109, -109, -109, -111, -111, -112, -113,
-113, -114, -115, -115, -117, -116, -119, -118, -117, -35, 51, 50, 50, 51, 52,
53, 54, 55, 55, 56, 56, 57, 58, 58, 59, 60, 60, 62, 62, 63, 63, 65, 65, 66, 66,
67, 67, 69, 69, 71, 71, 72, 72, 73, 74, 74, 75, 76, 77, 77, 78, 79, 79, 79, 81,
82, 82, 83, 84, 84, 86, 86, 87, 87, 88, 88, 90, 91, 91, 92, 93, 94, 92, 86, 78,
72, 63, 57, 48, 43, 33, 31, -20, -71, -54, -44, -34, -27, -21, -16, -12, -9, -6,
-4, -3, 0, 0, 2, 2, 0, -6, -11, -16, -22, -28, -32, -40, -45, -51, -56, -63,
-68, -75, -81, -86, -88, -83, -80, -76, -71, -68, -64, -60, -55, -52, -48, -44,
-39, -35, -32, -27, -23, -18, -15, -11, -6, -3, 2, 4, 7, 7, 7, 7, 6, 6, 7, -10,
-55, -57, -42, -35, -26, -22, -16, -13, -8, -7, -4, -3, 0, 1, 2, 3, 3, 5, 4, 4,
5, 5, 6, 6, 6, 6, 7, 6, 7, 6, 7, 7, 6, 7, 7, 7, 7, 6, 7, 7, 7, 6, 7, 6, 7, 6, 7,
6, 7, 6, 7, 7, 7, 7, 7, 7, 6, 6, 7, 7, 7, 7, 8, 7, 7, 6, 7, 6, 6, 8, 7, 7, 7, 7,
7, 7, 6, 7, 6, 7, 7, 7, 7, 7, 7, 6, 7, 6, 7, 6, 8, 6, 7, -42, -82, -77, -80,
-79, -80, -78, -79, -79, -79, -79, -78, -79, -79, -79, -79, -78, -79, -80, -79,
-80, -78, -79, -78, -75, -30, 10, 7, 7, 7, 7, 8, 6, 7, 7, 7, 7, 7, 7, 6, 7, 7,
7, 7, 7, 6, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 8, 7, 6, 6, 7, 7, 7, 7, 7, 7, 7,
7, 7, 8, 7, 7, 8, 7, 7, 8, 6, 7, 7, 7, 6, 7, 7, 7, 7, 8, 7, 7, 7, 7, 7, 8, 7, 7,
7, 8, -26, -66, -54, -43, -34, -26, -19, -13, -9, -4, 0, 3, 6, 9, 11, 13, 15,
16, 17, 20, 20, 22, 23, 23, 24, 26, 27, 27, 28, 29, 30, 30, 31, 32, 33, 34, 34,
35, 36, 37, 37, 38, 39, 40, 40, 41, 42, 43, 43, 43, 44, 46, 46, 47, 47, 49, 48,
50, 50, 52, 51, 53, 52, 56, 8, -86, -78, -46, -32, -14, -4, };