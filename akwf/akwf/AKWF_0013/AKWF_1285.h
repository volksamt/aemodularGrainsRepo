#define DATA_LENGTH 512
#define DATA AKWF_1285

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 9, 10, 12, 13, 16, 17, 19,
21, 23, 24, 26, 27, 29, 31, 32, 34, 35, 37, 39, 40, 41, 43, 44, 45, 47, 47, 50,
50, 52, 53, 54, 56, 57, 58, 59, 60, 61, 62, 63, 65, 64, 66, 67, 68, 69, 69, 71,
72, 72, 73, 74, 75, 75, 76, 77, 78, 77, 78, 79, 79, 80, 80, 81, 82, 81, 83, 82,
82, 83, 83, 83, 84, 84, 84, 85, 85, 86, 85, 85, 86, 86, 86, 86, 85, 85, 85, 85,
87, 86, 86, 86, 85, 85, 86, 85, 85, 85, 85, 85, 84, 83, 83, 83, 83, 82, 82, 82,
81, 82, 81, 81, 80, 79, 79, 79, 79, 78, 77, 76, 76, 76, 75, 75, 75, 74, 73, 72,
71, 72, 70, 70, 69, 69, 68, 68, 67, 66, 65, 65, 64, 63, 63, 62, 62, 61, 61, 60,
59, 58, 57, 56, 56, 55, 54, 53, 53, 52, 51, 50, 50, 49, 49, 48, 46, 46, 46, 45,
43, 44, 42, 42, 41, 40, 40, 39, 39, 38, 37, 36, 36, 34, 34, 33, 33, 32, 32, 31,
31, 30, 29, 28, 28, 28, 27, 25, 23, 21, 19, 17, 14, 13, 10, 8, 7, 4, 3, 0, -1,
-3, -5, -7, -10, -10, -13, -14, -17, -19, -21, -22, -24, -26, -27, -30, -32,
-33, -35, -37, -38, -40, -41, -44, -44, -47, -47, -50, -51, -52, -54, -55, -57,
-58, -60, -61, -62, -63, -66, -67, -68, -68, -71, -72, -73, -74, -74, -76, -77,
-78, -80, -81, -81, -82, -84, -85, -85, -87, -87, -89, -89, -89, -91, -92, -93,
-93, -94, -94, -95, -96, -96, -97, -98, -98, -98, -99, -100, -100, -100, -101,
-101, -101, -102, -102, -102, -103, -103, -103, -103, -104, -103, -104, -105,
-104, -104, -104, -104, -104, -104, -104, -104, -105, -104, -104, -104, -103,
-103, -102, -102, -103, -102, -102, -102, -101, -101, -101, -100, -99, -99, -99,
-98, -97, -97, -96, -96, -95, -95, -95, -93, -92, -92, -91, -90, -90, -90, -88,
-86, -87, -85, -85, -83, -82, -82, -82, -79, -79, -79, -77, -76, -75, -74, -72,
-71, -71, -69, -68, -67, -66, -65, -64, -63, -61, -61, -60, -57, -56, -55, -53,
-52, -52, -50, -49, -47, -46, -45, -43, -41, -41, -40, -38, -36, -34, -34, -31,
-30, -29, -27, -26, -24, -23, -22, -21, -19, -17, -16, -14, -14, -11, -9, -8,
-6, -5, -4, -3, -1, 1, 3, 4, 5, 6, 9, 10, 11, 13, 15, 15, 18, 19, 20, 22, 23,
25, 27, 28, 29, 31, 32, 33, 35, 38, 38, 39, 41, 43, 44, 45, 47, 49, 49, 52, 51,
53, 55, 58, 61, 64, 67, 69, 73, 74, 79, 79, 85, 84, 91, 89, 98, 94, 103, 99,
111, 103, 117, 106, 127, 93, -86, -76, -74, -73, -68, -69, -63, -64, -57, -59,
-53, -54, -48, -49, -43, -43, -39, -39, -34, -33, -30, -29, -25, -24, -21, -20,
-18, -15, -13, -11, -9, -6, -6, -3, -2, };