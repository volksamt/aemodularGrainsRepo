#define DATA_LENGTH 512
#define DATA AKWF_1278

const PROGMEM int8_t DATA[DATA_LENGTH] = {83, 97, 89, 94, 87, 91, 86, 88, 83,
84, 82, 81, 79, 78, 78, 76, 76, 72, 74, 69, 71, 66, 71, 16, -78, -77, -79, -80,
-81, -82, -84, -84, -87, -86, -89, -89, -92, -90, -95, -92, -97, -95, -99, -86,
-76, -88, 41, 67, 52, 61, 52, 58, 50, 55, 49, 52, 48, 49, 47, 46, 45, 44, 44,
40, 43, 37, 42, 34, 43, 4, -104, -109, -106, -112, -107, -113, -109, -115, -111,
-116, -114, -117, -117, -117, -122, -104, -95, -96, -101, -92, -116, -18, 53,
31, 45, 34, 40, 35, 38, 34, 36, 33, 34, 32, 32, 31, 30, 29, 28, 29, 26, 28, 26,
26, 24, 25, 24, 23, 23, 21, 22, 21, 21, 18, 22, 15, 23, 11, 8, 51, 46, 47, 46,
45, 46, 44, 46, 43, 45, 43, 43, 41, 43, 41, 43, 41, 40, 40, 39, 40, 39, 40, 36,
40, 36, 41, 33, 41, -35, -116, -101, -108, -104, -107, -105, -107, -107, -106,
-107, -107, -108, -106, -108, -107, -108, -107, -109, -108, -109, -109, -108,
-108, -108, -108, -109, -109, -109, -109, -108, -109, -109, -110, -109, -110,
-109, -109, -109, -110, -109, -110, -110, -109, -109, -108, -110, -109, -109,
-108, -109, -108, -109, -108, -109, -107, -89, -88, -89, -87, -88, -88, -87,
-88, -88, -88, -87, -87, -87, -87, -87, -87, -87, -87, -86, -87, -86, -86, -87,
-86, -86, -86, -85, -84, -85, -84, -85, -83, -84, -83, -84, -83, -85, -81, -85,
-81, -85, -79, -29, -26, -28, -26, -28, -25, -18, -14, -13, -10, -12, -8, -8,
-10, -11, -10, -12, -9, -8, -9, -8, -8, -8, -9, -8, -8, -6, -6, -6, -6, -6, -6,
-5, -6, -5, -6, -6, -6, -6, -6, -6, -6, -7, 8, 15, 12, 13, 13, 14, 13, 13, 13,
14, 13, 14, 14, 15, 14, 15, 14, 14, 15, 15, 14, 15, 15, 15, 14, 14, 14, 14, 15,
15, 15, 14, 14, 13, 12, 13, 13, 12, 12, 13, 12, 11, 11, 12, 12, 12, 11, 12, 11,
11, 12, 10, 11, 11, 10, 10, 11, 9, 10, 9, 9, 8, 9, 8, 8, 7, 7, 7, 6, 5, 5, 5, 4,
3, 3, 4, 1, 3, 1, 3, 0, 4, -4, 5, -11, -7, 36, 26, 30, 27, 28, 28, 28, 26, 25,
25, 23, 25, 23, 23, 22, 21, 21, 21, 19, 20, 18, 18, 17, 16, 16, 15, 14, 13, 12,
12, 11, 11, 10, 10, 9, 9, 7, 6, 4, 6, 1, 13, 28, 24, 26, 23, 23, 22, 22, 20, 19,
19, 17, 16, 15, 15, 14, 13, 11, 12, 10, 10, 8, 7, 6, 5, 3, 3, 1, 1, 0, -1, -2,
-3, -4, -6, -6, -8, -8, -11, -11, -13, -12, -16, -12, 4, 3, 2, -1, -2, -3, -3,
-4, -6, -7, -8, -10, -11, -11, -14, -13, -16, -17, -18, -19, -20, -21, -23, -24,
-25, -27, -29, -30, -34, -33, -35, -37, -38, -39, -41, -40, -42, -40, -44, -42,
-48, -39, };