#define DATA_LENGTH 512
#define DATA AKWF_1246

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 10, 15, 17, 20, 22, 24, 28,
30, 33, 36, 38, 40, 42, 45, 47, 50, 52, 55, 57, 58, 60, 62, 64, 66, 68, 70, 71,
72, 74, 76, 77, 79, 80, 82, 82, 84, 85, 87, 88, 90, 90, 91, 92, 94, 94, 96, 96,
98, 98, 99, 100, 101, 103, 103, 104, 105, 105, 106, 108, 107, 108, 109, 109,
111, 111, 111, 112, 113, 112, 114, 114, 115, 114, 116, 115, 117, 115, 118, 116,
118, 117, 119, 118, 119, 118, 118, 118, 120, 120, 119, 115, -36, -91, -63, -76,
-65, -72, -65, -68, -62, -64, -60, -60, -56, -55, -53, -51, -48, -46, -43, -40,
-39, -35, -34, -30, -28, -25, -22, -18, -16, -13, -10, -6, -5, -1, 2, 5, 8, 11,
13, 16, 19, 22, 25, 27, 30, 32, 36, 37, 40, 42, 45, 47, 49, 51, 53, 55, 57, 60,
62, 63, 65, 67, 68, 69, 71, 73, 75, 77, 77, 80, 81, 82, 83, 85, 86, 87, 88, 89,
91, 92, 93, 94, 95, 95, 96, 98, 98, 99, 101, 101, 102, 103, 104, 104, 105, 106,
107, 108, 108, 109, 110, 111, 111, 111, 112, 112, 113, 113, 114, 115, 114, 115,
115, 115, 116, 116, 116, 117, 117, 117, 117, 118, 118, 118, 118, 118, 118, 118,
119, 118, 119, 117, 118, 118, 118, 117, 118, 118, 116, 117, 117, 115, 116, 115,
114, 115, 113, 112, 112, 111, 111, 110, 108, 108, 107, 105, 104, 104, 101, 101,
98, 97, 94, 93, 91, 89, 87, 84, 82, 79, 76, 74, 71, 68, 65, 62, 59, 54, 51, 49,
45, 40, 37, 32, 28, 24, 20, 16, 13, 8, 4, 0, -4, -10, -14, -17, -22, -25, -30,
-34, -38, -41, -45, -49, -52, -56, -59, -63, -66, -69, -72, -75, -76, -79, -81,
-83, -87, -88, -90, -92, -94, -96, -98, -99, -100, -102, -101, -103, -104, -105,
-106, -105, -105, -107, -106, -107, -106, -106, -107, -107, -106, -106, -106,
-105, -104, -104, -104, -103, -102, -101, -101, -99, -98, -98, -96, -95, -94,
-94, -92, -91, -91, -89, -89, -87, -86, -85, -84, -83, -82, -81, -81, -79, -79,
-77, -76, -75, -74, -73, -71, -71, -69, -69, -68, -67, -66, -66, -65, -63, -63,
-62, -62, -60, -59, -58, -58, -56, -56, -56, -54, -53, -52, -51, -50, -49, -47,
-47, -47, -45, -44, -43, -41, -40, -39, -38, -36, -34, -34, -32, -30, -29, -27,
-26, -24, -23, -20, -19, -17, -15, -13, -11, -9, -7, -6, -4, -2, 1, 3, 5, 6, 8,
11, 14, 14, 17, 18, 20, 22, 24, 25, 27, 28, 31, 31, 32, 34, 35, 36, 37, 38, 38,
40, 40, 41, 40, 41, 41, 42, 41, 41, 40, 41, 39, 40, 38, 38, 37, 36, 34, 34, 32,
32, 29, 29, 21, -45, -77, -71, -73, -69, -70, -68, -66, -64, -63, -61, -60, -57,
-55, -53, -51, -48, -45, -43, -41, -39, -36, -33, -31, -28, -24, -21, -19, -16,
-14, -10, -8, -5, -1, };