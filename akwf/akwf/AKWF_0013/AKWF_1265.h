#define DATA_LENGTH 512
#define DATA AKWF_1265

const PROGMEM int8_t DATA[DATA_LENGTH] = {34, 63, 59, 66, 69, 79, 87, 97, 105,
114, 118, 120, 117, 111, 104, 95, 84, 77, 71, 67, 66, 65, 66, 68, 70, 70, 69,
67, 64, 60, 54, 50, 45, 41, 38, 36, 36, 35, 37, 37, 37, 36, 34, 33, 31, 29, 25,
22, 21, 19, 19, 18, 18, 17, 18, 17, 17, 16, 15, 14, 13, 12, 10, 8, 8, 6, 6, 6,
6, 6, 6, 5, 5, 4, 4, 3, 2, 1, 0, 0, -2, -1, -1, -2, -3, -3, -2, -3, -3, -4, -5,
-4, -4, -6, -6, -6, -7, -7, -8, -7, -7, -8, -8, -9, -8, -9, -9, -10, -11, -10,
-10, -10, -11, -11, -11, -11, -11, -11, -11, -13, -13, -13, -12, -12, -13, -14,
-13, -13, -13, -14, -13, -13, -13, -14, -14, -14, -14, -14, -15, -14, -14, -15,
-15, -14, -15, -15, -14, -14, -15, -14, -15, -14, -14, -14, -14, -15, -15, -14,
-14, -14, -14, -14, -14, -15, -14, -14, -14, -14, -13, -14, -13, -13, -13, -13,
-13, -12, -13, -12, -13, -13, -12, -12, -12, -12, -12, -11, -12, -12, -11, -11,
-10, -11, -10, -10, -10, -10, -11, -9, -9, -9, -9, -9, -9, -8, -8, -8, -8, -8,
-7, -7, -7, -7, -7, -6, -6, -6, -6, -5, -5, -5, -5, -5, -5, -3, -4, -3, -4, -3,
-3, -2, -1, -2, -1, -2, -2, -1, -1, 0, -1, 0, 0, 0, 2, 1, 2, 2, 2, 2, 2, 2, 2,
3, 3, 3, 4, 4, 4, 4, 5, 4, 5, 6, 6, 6, 6, 7, 6, 7, 7, 7, 8, 8, 8, 8, 8, 8, 8, 8,
9, 9, 9, 9, 9, 10, 10, 10, 9, 10, 10, 10, 11, 11, 11, 12, 11, 11, 12, 11, 12,
12, 12, 12, 12, 13, 12, 12, 12, 12, 13, 13, 13, 13, 12, 13, 13, 13, 13, 13, 13,
13, 14, 13, 14, 13, 13, 13, 14, 14, 14, 13, 14, 14, 12, 13, 14, 13, 14, 13, 12,
13, 13, 13, 12, 13, 12, 12, 12, 11, 12, 12, 12, 11, 12, 11, 11, 11, 10, 11, 11,
10, 10, 10, 9, 10, 9, 8, 9, 9, 8, 9, 8, 7, 8, 7, 7, 7, 7, 6, 6, 6, 6, 5, 5, 5,
4, 4, 4, 3, 3, 2, 2, 3, 1, 1, 1, 1, 1, -1, -1, -2, -1, -1, -1, -2, -2, -4, -4,
-4, -4, -4, -5, -6, -6, -7, -7, -7, -8, -9, -9, -10, -10, -10, -10, -11, -11,
-13, -12, -13, -14, -14, -14, -15, -15, -15, -16, -16, -18, -18, -18, -19, -20,
-20, -20, -21, -22, -22, -22, -22, -24, -25, -25, -26, -25, -26, -28, -28, -28,
-29, -30, -30, -31, -30, -31, -32, -33, -34, -34, -34, -35, -35, -37, -37, -37,
-38, -38, -40, -40, -40, -41, -42, -43, -43, -43, -44, -44, -45, -45, -46, -46,
-47, -48, -49, -49, -50, -50, -52, -52, -53, -53, -53, -53, -54, -55, -56, -57,
-56, -58, -56, -60, -56, -64, -37, };