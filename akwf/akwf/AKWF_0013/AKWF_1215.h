#define DATA_LENGTH 512
#define DATA AKWF_1215

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 3, 4, 6, 8, 9, 10, 13, 16,
19, 22, 26, 30, 35, 40, 45, 50, 55, 61, 69, 74, 76, 80, 88, 93, 99, 103, 109,
112, 115, 117, 118, 119, 118, 116, 114, 111, 108, 102, 98, 91, 84, 78, 70, 62,
54, 46, 38, 30, 23, 15, 8, 1, -6, -13, -18, -25, -30, -36, -40, -45, -49, -52,
-56, -59, -61, -63, -66, -67, -70, -71, -72, -73, -74, -75, -75, -76, -75, -75,
-75, -75, -74, -73, -72, -71, -70, -69, -67, -67, -64, -63, -61, -60, -58, -56,
-54, -52, -50, -48, -47, -45, -43, -41, -39, -38, -35, -33, -32, -30, -29, -26,
-25, -23, -22, -20, -18, -18, -16, -14, -12, -11, -11, -9, -8, -7, -6, -5, -3,
-2, -2, -1, 1, 2, 2, 2, 3, 4, 5, 5, 7, 6, 7, 8, 8, 9, 8, 8, 9, 10, 9, 10, 10,
10, 10, 10, 11, 11, 10, 11, 11, 12, 11, 11, 11, 11, 11, 11, 11, 11, 11, 11, 12,
12, 12, 12, 11, 12, 11, 11, 11, 11, 10, 11, 11, 10, 10, 10, 9, 9, 9, 9, 8, 9, 9,
9, 8, 7, 7, 8, 8, 7, 7, 6, 6, 6, 6, 6, 5, 5, 5, 5, 6, 5, 4, 5, 4, 4, 4, 3, 4, 4,
4, 3, 3, 3, 3, 2, 2, 3, 2, 2, 1, 2, 1, 1, 1, 1, 1, 0, 0, 1, 0, 1, 0, 0, 0, -1,
-1, 0, 0, -1, -1, -2, -2, -1, -1, -1, -2, -1, -1, -1, -2, -2, -2, -1, -3, -3,
-2, -3, -2, -2, -3, -2, -3, -2, -2, -3, -2, -3, -3, -3, -2, -3, -3, -2, -3, -3,
-2, -2, -3, -3, -2, -2, -3, -2, -2, -2, -2, -1, -2, -2, -2, -1, -1, -1, -2, -2,
-2, -1, -1, 0, -2, -1, -1, 0, 0, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, 0, 2, 0, 1, 1, 1,
1, 2, 1, 2, 2, 2, 2, 1, 1, 2, 1, 2, 2, 1, 2, 2, 2, 3, 1, 2, 2, 2, 3, 2, 2, 1, 2,
2, 2, 3, 2, 1, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 1, 1, 1, 1, 1, 1,
1, 1, 0, 0, 0, 1, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, -1, 0, -1, -1,
-2, -1, 0, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -3, -3, -3, -3, -3, -4,
-3, -3, -4, -4, -4, -4, -5, -5, -4, -4, -5, -5, -5, -5, -6, -6, -6, -6, -6, -6,
-6, -6, -6, -6, -7, -7, -7, -8, -7, -8, -8, -9, -8, -9, -9, -9, -9, -9, -8, -10,
-9, -10, -10, -10, -10, -10, -10, -10, -10, -9, -10, -9, -9, -10, -10, -10, -8,
-8, -9, -8, -8, -7, -7, -7, -6, -6, -5, -6, -4, -4, -4, -4, -2, -3, -2, -1, -1,
-1, -1, };