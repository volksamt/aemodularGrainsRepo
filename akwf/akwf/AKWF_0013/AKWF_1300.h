#define DATA_LENGTH 512
#define DATA AKWF_1300

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 24, 25, 26, 28, 28, 30, 30, 33, 32,
37, 39, 43, 45, 49, 51, 56, 59, 62, 64, 68, 71, 75, 79, 82, 83, 88, 108, 111,
108, 108, 105, 104, 101, 100, 97, 97, 94, 93, 91, 90, 87, 87, 84, 83, 80, 79,
76, 77, 62, 15, 6, 12, 10, 13, 13, 16, 16, 19, 19, 21, 23, 24, 26, 27, 28, 30,
32, 32, 35, 35, 37, 38, 40, 41, 42, 43, 46, 46, 48, 49, 51, 53, 53, 56, 56, 58,
60, 61, 63, 64, 65, 66, 68, 69, 70, 72, 74, 75, 77, 77, 80, 78, 100, 109, 103,
106, 101, 102, 101, 100, 99, 98, 96, 96, 95, 93, 92, 91, 90, 89, 87, 86, 85, 85,
84, 83, 81, 79, 77, 75, 74, 72, 71, 68, 67, 64, 63, 62, 58, 59, 56, 55, 51, 51,
48, 50, 37, 17, 19, 16, 16, 14, 13, 11, 9, 9, 8, 6, 5, 5, 4, 4, 5, 5, 5, 4, 4,
4, 5, 5, 4, 5, 4, 5, 4, 5, 5, 5, 5, 5, 4, 5, 4, 4, 4, 4, 5, 5, 5, 5, 5, 4, 4, 5,
5, 5, 4, 4, 5, 4, 4, 5, 4, 4, 4, 4, 4, 4, 4, 5, 4, 5, 4, 5, 4, 4, 4, 5, 4, 5, 5,
5, 5, 5, 5, 4, 5, 4, 4, 4, 3, 1, 0, -1, -2, -3, -4, -5, -7, -7, -10, -10, -11,
-12, -13, -14, -17, -18, -19, -19, -22, -22, -23, -24, -25, -27, -27, -29, -30,
-32, -32, -34, -34, -36, -37, -39, -38, -40, -41, -43, -43, -46, -45, -48, -48,
-51, -50, -53, -82, -86, -86, -87, -89, -91, -92, -94, -94, -97, -99, -100,
-101, -103, -104, -107, -107, -109, -110, -109, -109, -108, -107, -106, -104,
-102, -100, -99, -97, -96, -94, -92, -91, -89, -87, -85, -84, -81, -84, -57,
-46, -50, -46, -47, -45, -44, -42, -43, -40, -40, -39, -38, -37, -36, -35, -34,
-33, -32, -31, -30, -29, -28, -28, -26, -26, -23, -24, -22, -24, -20, -21, -17,
-20, -14, -20, -10, -30, -86, -78, -81, -67, -63, -66, -66, -70, -69, -73, -72,
-75, -74, -77, -77, -79, -80, -83, -84, -85, -85, -87, -88, -90, -91, -92, -93,
-96, -97, -98, -98, -100, -102, -102, -103, -105, -106, -108, -108, -110, -112,
-112, -114, -115, -116, -117, -118, -119, -120, -119, -119, -117, -118, -118,
-118, -117, -117, -117, -117, -116, -115, -117, -115, -116, -114, -115, -114,
-117, -113, -114, -35, 18, 3, 11, 8, 12, 10, 12, 12, 13, 13, 14, 15, 16, 16, 17,
18, 17, 18, 19, 21, 20, 22, 21, 23, 23, 23, 24, 25, 25, 26, 26, 27, 27, 28, 29,
29, 30, 30, 31, 32, 32, 33, 34, 34, 34, 35, 36, 36, 36, 37, 37, 39, 43, 14, -26,
-30, -26, -24, -23, -23, -22, -21, -19, -19, -18, -16, -16, -15, -14, -14, -13,
-11, -10, -10, -9, -8, -7, -7, -6, -5, -4, -3, -1, -1, 0, };