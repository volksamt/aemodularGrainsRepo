#define DATA_LENGTH 512
#define DATA AKWF_1261

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 7, 10, 12, 15, 17, 20, 22, 24,
26, 28, 31, 33, 35, 37, 39, 42, 44, 46, 48, 50, 53, 56, 60, 62, 66, 69, 75, 84,
94, 98, 99, 101, 103, 102, 103, 104, 105, 105, 105, 106, 108, 108, 107, 109,
108, 109, 110, 110, 110, 111, 112, 113, 113, 113, 114, 115, 115, 115, 116, 116,
117, 116, 117, 117, 117, 117, 118, 118, 118, 118, 118, 118, 118, 119, 118, 118,
119, 118, 118, 119, 118, 119, 118, 119, 118, 119, 119, 118, 118, 118, 118, 119,
118, 119, 118, 118, 118, 119, 118, 119, 118, 118, 117, 117, 118, 117, 117, 118,
117, 117, 117, 116, 116, 114, 114, 114, 113, 112, 112, 111, 111, 110, 109, 109,
109, 109, 108, 108, 107, 106, 104, 104, 104, 103, 101, 98, 96, 92, 92, 93, 96,
99, 101, 104, 103, 102, 99, 97, 95, 94, 92, 91, 92, 90, 91, 91, 89, 90, 89, 89,
89, 89, 88, 88, 88, 88, 88, 87, 86, 87, 86, 87, 86, 85, 85, 85, 85, 84, 85, 84,
83, 83, 83, 82, 83, 81, 82, 81, 80, 80, 79, 79, 78, 78, 78, 77, 76, 76, 75, 75,
73, 74, 73, 72, 72, 71, 70, 69, 68, 68, 67, 66, 64, 64, 63, 63, 61, 60, 59, 58,
57, 56, 54, 53, 52, 51, 49, 48, 47, 45, 45, 43, 42, 40, 38, 37, 35, 33, 32, 29,
28, 25, 24, 21, 19, 17, 16, 13, 11, 8, 6, 3, 1, -2, -3, -6, -9, -12, -14, -15,
-18, -20, -23, -24, -26, -29, -30, -32, -34, -37, -38, -40, -42, -44, -46, -48,
-49, -51, -54, -57, -60, -66, -77, -88, -92, -95, -96, -96, -98, -98, -98, -100,
-100, -101, -102, -103, -104, -103, -104, -104, -105, -106, -106, -107, -106,
-107, -109, -109, -109, -109, -111, -111, -111, -112, -113, -112, -113, -114,
-113, -114, -114, -115, -115, -115, -115, -116, -116, -116, -117, -116, -116,
-117, -117, -117, -117, -117, -118, -118, -118, -118, -118, -118, -118, -119,
-119, -119, -119, -119, -119, -118, -119, -118, -119, -119, -119, -119, -118,
-118, -118, -118, -119, -118, -118, -118, -117, -117, -118, -116, -117, -115,
-115, -114, -113, -113, -113, -112, -111, -110, -111, -109, -109, -109, -107,
-108, -107, -107, -106, -105, -104, -104, -104, -104, -106, -108, -108, -107,
-106, -102, -98, -94, -92, -93, -96, -97, -98, -99, -98, -98, -98, -96, -97,
-96, -95, -94, -94, -93, -92, -92, -92, -91, -91, -90, -91, -90, -90, -90, -89,
-89, -89, -89, -88, -89, -88, -87, -87, -87, -86, -86, -86, -86, -86, -85, -85,
-85, -84, -84, -83, -82, -82, -81, -82, -81, -80, -80, -80, -78, -78, -78, -77,
-76, -76, -76, -75, -74, -73, -72, -71, -70, -70, -69, -67, -66, -66, -65, -64,
-63, -62, -62, -60, -58, -57, -56, -55, -53, -51, -51, -49, -47, -46, -44, -42,
-41, -40, -38, -35, -34, -32, -30, -27, -26, -23, -21, -18, -16, -13, -12, -8,
-6, -2, 0, };