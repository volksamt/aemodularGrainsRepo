#define DATA_LENGTH 512
#define DATA AKWF_1232

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 3, 6, 5, 5, 6, 4, 9, 11, 10, 10,
10, 12, 16, 15, 16, 15, 16, 16, 16, 15, 17, 16, 19, 22, 22, 22, 22, 22, 22, 22,
22, 22, 24, 28, 27, 28, 28, 28, 28, 28, 28, 29, 28, 29, 29, 29, 30, 33, 36, 35,
34, 36, 36, 36, 37, 35, 36, 36, 36, 36, 36, 36, 39, 42, 44, 44, 44, 43, 43, 44,
43, 45, 44, 44, 45, 45, 45, 44, 45, 45, 46, 45, 46, 45, 46, 45, 47, 46, 51, 53,
53, 53, 54, 54, 53, 55, 54, 54, 53, 55, 55, 55, 55, 55, 56, 55, 55, 55, 55, 56,
57, 57, 57, 56, 56, 57, 57, 57, 59, 56, 59, 56, 60, 58, 74, 22, -19, 11, 2, 6,
5, 5, 5, 5, 8, 10, 11, 10, 11, 13, 17, 15, 16, 16, 16, 16, 16, 16, 16, 15, 20,
22, 23, 22, 21, 22, 22, 22, 22, 22, 24, 28, 28, 28, 28, 28, 29, 28, 29, 28, 28,
29, 29, 29, 29, 33, 35, 36, 36, 35, 35, 36, 36, 36, 36, 36, 37, 36, 36, 36, 40,
43, 42, 44, 43, 43, 44, 43, 44, 44, 44, 44, 44, 45, 44, 44, 44, 45, 45, 45, 45,
46, 46, 47, 45, 46, 51, 53, 52, 53, 54, 54, 54, 54, 54, 54, 54, 54, 54, 54, 55,
55, 55, 56, 55, 56, 55, 56, 56, 56, 56, 56, 56, 57, 58, 57, 57, 58, 58, 58, 58,
63, 66, 65, 65, 66, 66, 67, 67, 66, 66, 67, 67, 68, 67, 67, 68, 67, 68, 69, 68,
69, 69, 69, 68, 69, 69, 69, 70, 70, 70, 70, 71, 71, 71, 71, 70, 71, 71, 72, 71,
72, 72, 72, 72, 72, 72, 73, 73, 74, 73, 73, 73, 74, 74, 74, 74, 74, 80, 84, 83,
84, 84, 83, 85, 84, 85, 85, 84, 85, 85, 85, 85, 85, 85, 86, 86, 86, 87, 87, 86,
87, 87, 88, 88, 89, 88, 88, 89, 88, 89, 89, 89, 89, 89, 91, 90, 90, 90, 91, 91,
91, 91, 91, 91, 92, 91, 92, 92, 92, 92, 92, 93, 92, 94, 93, 94, 93, 95, 93, 97,
69, 46, 39, -8, -35, -56, -59, -63, -70, -75, -82, -87, -88, -87, -96, -97, -98,
-97, -98, -105, -108, -107, -109, -109, -109, -109, -109, -109, -109, -110,
-110, -110, -111, -110, -112, -111, -111, -112, -112, -113, -112, -112, -112,
-112, -113, -113, -113, -114, -114, -114, -114, -114, -114, -115, -115, -115,
-115, -116, -116, -116, -116, -116, -117, -116, -117, -118, -117, -118, -118,
-118, -118, -118, -118, -119, -115, -108, -108, -109, -109, -109, -109, -109,
-110, -109, -110, -111, -110, -111, -111, -110, -111, -111, -111, -112, -112,
-112, -112, -112, -112, -112, -113, -113, -114, -113, -114, -114, -114, -115,
-114, -115, -115, -115, -116, -116, -116, -116, -115, -116, -116, -116, -117,
-116, -116, -118, -117, -118, -118, -118, -118, -119, -118, -119, -118, -114,
-106, -108, -107, -109, -92, -21, };