#define DATA_LENGTH 512
#define DATA AKWF_1254

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 7, 9, 11, 13, 15, 17, 19, 21,
22, 24, 25, 28, 28, 31, 32, 33, 35, 37, 39, 39, 41, 42, 45, 45, 46, 48, 49, 50,
51, 53, 54, 56, 56, 57, 58, 60, 61, 62, 63, 64, 65, 66, 67, 67, 68, 70, 71, 72,
72, 72, 74, 75, 76, 77, 77, 78, 78, 79, 81, 81, 82, 82, 83, 84, 85, 85, 86, 86,
87, 87, 88, 88, 88, 89, 90, 90, 91, 91, 92, 92, 93, 93, 94, 94, 95, 96, 96, 97,
97, 97, 98, 99, 99, 99, 100, 100, 100, 101, 101, 102, 102, 103, 102, 102, 103,
103, 104, 105, 104, 104, 105, 106, 106, 106, 106, 106, 106, 107, 107, 107, 108,
108, 108, 109, 109, 109, 110, 110, 110, 109, 111, 111, 110, 111, 111, 111, 112,
111, 112, 113, 112, 112, 112, 112, 112, 113, 113, 113, 113, 114, 113, 113, 114,
114, 115, 114, 115, 115, 115, 115, 115, 115, 115, 115, 115, 116, 115, 117, 116,
116, 117, 116, 117, 117, 117, 117, 117, 118, 117, 117, 118, 118, 118, 118, 117,
118, 117, 117, 119, 119, 118, 118, 118, 119, 119, 118, 119, 118, 118, 118, 118,
120, 119, 119, 119, 118, 119, 119, 119, 118, 119, 118, 115, 112, 108, 104, 99,
96, 92, 89, 85, 81, 78, 74, 71, 68, 65, 61, 57, 55, 53, 49, 46, 43, 40, 37, 35,
32, 30, 26, 24, 21, 19, 17, 13, 11, 10, 7, 5, 3, 1, -2, -4, -6, -7, -10, -12,
-14, -16, -17, -19, -21, -24, -25, -26, -27, -30, -31, -33, -34, -36, -38, -39,
-41, -42, -42, -44, -46, -47, -48, -49, -51, -53, -53, -54, -56, -56, -58, -59,
-60, -61, -63, -63, -65, -65, -67, -67, -68, -69, -70, -71, -72, -73, -74, -75,
-75, -76, -78, -78, -78, -79, -80, -81, -81, -83, -83, -84, -85, -86, -85, -86,
-87, -87, -88, -89, -89, -90, -90, -91, -91, -93, -92, -93, -93, -95, -95, -95,
-95, -96, -96, -97, -97, -98, -98, -98, -99, -100, -100, -100, -100, -101, -102,
-101, -101, -102, -103, -103, -103, -103, -104, -104, -105, -105, -104, -105,
-105, -106, -107, -106, -107, -106, -107, -107, -108, -108, -108, -108, -108,
-109, -109, -110, -109, -110, -109, -110, -110, -110, -110, -111, -111, -112,
-111, -111, -111, -112, -112, -112, -112, -113, -113, -113, -113, -114, -114,
-114, -114, -114, -114, -115, -113, -114, -115, -114, -115, -115, -115, -115,
-116, -116, -115, -115, -116, -116, -115, -115, -115, -116, -117, -116, -116,
-116, -116, -117, -116, -117, -117, -116, -117, -117, -117, -117, -116, -116,
-116, -116, -115, -116, -115, -116, -115, -115, -114, -115, -113, -114, -113,
-113, -113, -112, -111, -110, -110, -109, -107, -107, -105, -103, -102, -100,
-98, -97, -94, -92, -89, -86, -84, -82, -79, -77, -74, -71, -67, -66, -62, -60,
-57, -54, -51, -48, -46, -43, -41, -38, -36, -32, -31, -28, -26, -23, -21, -19,
-16, -14, -11, -8, -7, -5, -3, 0, };