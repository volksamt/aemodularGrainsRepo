#define DATA_LENGTH 512
#define DATA AKWF_1283

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 1, 1,
1, 2, 1, 2, 2, 2, 2, 2, 3, 3, 4, 3, 3, 4, 5, 5, 5, 5, 6, 6, 6, 7, 8, 8, 8, 9, 9,
10, 9, 10, 11, 12, 12, 12, 13, 13, 14, 15, 15, 16, 17, 17, 17, 18, 18, 19, 20,
20, 21, 21, 22, 23, 24, 24, 25, 27, 27, 28, 28, 28, 29, 30, 32, 32, 33, 33, 34,
35, 36, 37, 37, 39, 39, 40, 41, 42, 43, 43, 44, 44, 46, 47, 48, 49, 49, 50, 50,
52, 52, 54, 54, 56, 57, 57, 58, 59, 60, 61, 62, 63, 64, 65, 65, 68, 67, 69, 70,
70, 72, 73, 73, 74, 75, 76, 77, 78, 79, 80, 80, 81, 82, 83, 84, 86, 87, 87, 89,
90, 90, 91, 92, 93, 94, 95, 96, 97, 97, 98, 100, 100, 102, 101, 104, 104, 105,
105, 107, 107, 108, 109, 109, 111, 111, 113, 113, 114, 115, 116, 116, 118, 118,
119, 26, -40, -30, -34, -29, -32, -29, -29, -28, -28, -26, -26, -26, -25, -24,
-23, -22, -23, -22, -21, -20, -19, -19, -18, -18, -17, -16, -16, -15, -14, -14,
-14, -14, -12, -12, -12, -11, -11, -10, -9, -9, -8, -8, -8, -8, -7, -7, -6, -6,
-6, -5, -5, -5, -4, -4, -4, -3, -3, -3, -3, -3, -3, -2, -1, -1, -2, -1, -1, -1,
-1, -1, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, -1, -1, -1, 0,
-1, -2, -1, -1, -1, -2, -2, -3, -3, -3, -3, -3, -3, -4, -4, -5, -6, -6, -6, -5,
-7, -7, -7, -8, -8, -8, -9, -9, -9, -10, -10, -11, -11, -12, -12, -13, -13, -14,
-14, -16, -15, -17, -16, -18, -18, -18, -19, -19, -21, -22, -22, -23, -23, -24,
-25, -25, -26, -26, -27, -28, -29, -29, -31, -32, -32, -33, -33, -34, -35, -35,
-36, -37, -38, -39, -40, -41, -41, -42, -43, -44, -45, -46, -47, -48, -48, -49,
-50, -51, -52, -53, -54, -55, -56, -56, -57, -59, -59, -61, -61, -62, -64, -64,
-64, -66, -66, -68, -68, -70, -71, -71, -72, -73, -75, -75, -76, -77, -78, -79,
-80, -82, -82, -83, -83, -85, -86, -87, -87, -88, -89, -90, -91, -92, -93, -94,
-95, -97, -97, -97, -99, -99, -100, -101, -102, -104, -104, -105, -106, -107,
-107, -109, -109, -111, -111, -112, -112, -114, -114, -115, -115, -118, -118,
-119, -113, -13, 40, 30, 34, 29, 31, 28, 30, 28, 28, 26, 26, 25, 24, 23, 23, 23,
22, 21, 20, 20, 18, 19, 18, 17, 17, 16, 16, 16, 15, 14, 14, 13, 12, 11, 12, 11,
11, 10, 10, 9, 9, 7, 8, 8, 6, 6, 6, 6, 6, 4, 5, 5, 4, 4, 4, 4, 3, 4, 2, 2, 2, 2,
2, 1, 1, 1, 0, 1, 1, 1, 1, 0, 1, 0, 0, 0, -1, 0, -1, -1, };