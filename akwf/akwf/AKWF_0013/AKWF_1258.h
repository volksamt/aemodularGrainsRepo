#define DATA_LENGTH 512
#define DATA AKWF_1258

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 9, 12, 16, 18, 20, 22, 25, 25,
26, 28, 27, 29, 29, 30, 30, 31, 32, 32, 33, 33, 34, 35, 36, 36, 36, 36, 38, 39,
39, 40, 41, 40, 41, 42, 43, 43, 43, 43, 43, 44, 43, 43, 44, 44, 44, 45, 45, 45,
46, 46, 46, 47, 47, 48, 48, 49, 50, 50, 50, 50, 51, 52, 52, 52, 54, 54, 54, 55,
55, 56, 56, 56, 56, 57, 58, 58, 58, 58, 59, 59, 59, 61, 61, 62, 61, 62, 62, 63,
63, 63, 65, 65, 65, 65, 65, 66, 66, 68, 67, 68, 69, 69, 69, 69, 69, 70, 70, 71,
71, 72, 72, 73, 73, 73, 74, 75, 75, 75, 75, 75, 76, 76, 76, 77, 77, 78, 79, 79,
79, 79, 80, 80, 80, 81, 82, 83, 83, 82, 83, 84, 84, 84, 84, 84, 85, 85, 87, 86,
87, 87, 87, 87, 89, 89, 89, 90, 90, 91, 91, 91, 91, 92, 92, 92, 92, 93, 94, 94,
95, 95, 95, 96, 96, 96, 96, 97, 97, 98, 98, 99, 99, 99, 99, 100, 101, 101, 101,
101, 102, 103, 102, 103, 103, 103, 104, 105, 104, 105, 106, 106, 106, 107, 107,
107, 108, 109, 109, 110, 110, 110, 110, 112, 111, 112, 112, 113, 113, 114, 114,
114, 114, 115, 115, 115, 115, 116, 116, 116, 116, 117, 117, 118, 117, 117, 118,
117, 118, 119, 118, 119, 118, 119, 119, 119, 118, 120, 116, 115, 106, 73, 60,
51, 38, 27, 16, 7, -2, -9, -17, -23, -29, -34, -37, -41, -45, -48, -51, -53,
-57, -59, -61, -63, -66, -67, -70, -71, -73, -73, -75, -77, -77, -79, -80, -81,
-82, -84, -85, -86, -88, -89, -90, -91, -92, -93, -93, -94, -94, -95, -94, -95,
-95, -96, -96, -96, -96, -97, -95, -96, -97, -96, -96, -96, -96, -97, -97, -96,
-97, -96, -96, -96, -96, -97, -96, -97, -97, -97, -97, -97, -96, -96, -97, -96,
-96, -97, -97, -96, -97, -96, -96, -96, -96, -96, -96, -96, -95, -96, -96, -96,
-96, -95, -96, -95, -95, -95, -95, -95, -95, -95, -94, -94, -94, -92, -92, -92,
-92, -90, -91, -91, -90, -90, -89, -89, -89, -88, -88, -89, -89, -88, -88, -87,
-88, -87, -87, -88, -88, -87, -87, -86, -87, -86, -86, -86, -87, -86, -86, -86,
-86, -86, -85, -85, -85, -85, -84, -84, -84, -84, -84, -84, -84, -83, -83, -83,
-83, -82, -82, -82, -81, -81, -81, -81, -81, -80, -80, -80, -79, -80, -80, -79,
-79, -78, -78, -79, -79, -78, -78, -78, -77, -76, -76, -76, -75, -75, -74, -74,
-73, -73, -72, -71, -70, -70, -69, -68, -68, -68, -67, -67, -67, -66, -66, -66,
-65, -65, -65, -65, -64, -64, -64, -62, -62, -62, -62, -61, -60, -59, -57, -56,
-55, -55, -52, -53, -52, -51, -51, -50, -50, -49, -48, -48, -48, -47, -48, -47,
-46, -45, -45, -45, -45, -45, -45, -45, -44, -43, -41, -37, -32, -27, -20, -12,
-8, -3, };