#define DATA_LENGTH 512
#define DATA AKWF_1260

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 15, 20, 25, 30, 34, 39, 44, 47,
50, 52, 55, 58, 60, 62, 64, 66, 69, 72, 73, 75, 76, 77, 78, 80, 83, 84, 86, 88,
88, 89, 91, 91, 91, 93, 93, 93, 94, 95, 96, 96, 96, 97, 97, 97, 98, 98, 99, 100,
100, 101, 101, 102, 102, 102, 102, 103, 103, 103, 104, 104, 104, 105, 105, 106,
106, 106, 107, 107, 107, 107, 107, 108, 108, 108, 108, 109, 109, 110, 109, 110,
110, 110, 110, 110, 110, 110, 110, 110, 110, 110, 112, 112, 112, 112, 111, 112,
113, 113, 113, 113, 113, 114, 113, 113, 114, 113, 114, 115, 114, 115, 115, 115,
115, 116, 115, 115, 116, 116, 117, 116, 117, 116, 116, 117, 117, 117, 117, 117,
118, 117, 117, 118, 118, 118, 117, 118, 118, 118, 118, 118, 118, 118, 118, 118,
118, 119, 118, 118, 118, 118, 118, 118, 119, 119, 118, 118, 118, 119, 119, 119,
119, 119, 118, 118, 119, 119, 119, 118, 119, 118, 120, 119, 119, 118, 119, 118,
118, 118, 118, 118, 119, 117, 118, 117, 118, 118, 117, 116, 116, 116, 115, 115,
114, 114, 113, 113, 112, 113, 111, 111, 110, 110, 109, 109, 108, 107, 106, 106,
104, 104, 103, 103, 102, 101, 99, 96, 98, 87, 74, 70, 70, 70, 69, 69, 57, 58,
55, 44, 36, 27, 22, 12, 3, -4, -7, -10, -14, -17, -21, -28, -31, -34, -38, -40,
-42, -47, -52, -54, -57, -58, -60, -61, -63, -66, -68, -70, -71, -73, -74, -75,
-76, -78, -81, -82, -83, -85, -86, -87, -88, -89, -91, -92, -93, -94, -95, -95,
-96, -98, -97, -99, -99, -100, -99, -100, -101, -101, -102, -102, -101, -102,
-102, -103, -104, -104, -104, -105, -105, -105, -105, -106, -105, -105, -107,
-107, -107, -107, -108, -108, -108, -108, -108, -108, -109, -108, -108, -109,
-110, -110, -110, -110, -110, -111, -111, -111, -111, -112, -112, -112, -113,
-112, -112, -112, -113, -113, -113, -114, -113, -114, -114, -114, -115, -114,
-114, -114, -115, -114, -115, -114, -114, -114, -115, -115, -114, -115, -115,
-115, -115, -115, -115, -115, -115, -116, -116, -116, -117, -116, -116, -116,
-117, -116, -116, -117, -117, -117, -117, -117, -117, -117, -117, -117, -117,
-118, -118, -118, -117, -118, -118, -118, -118, -119, -118, -118, -118, -119,
-119, -119, -119, -119, -118, -118, -119, -118, -119, -118, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -118, -119, -120, -119, -119, -119, -120,
-119, -118, -120, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -118, -118, -118, -119,
-119, -119, -118, -118, -118, -117, -119, -118, -118, -118, -118, -118, -117,
-116, -116, -116, -115, -115, -116, -114, -114, -113, -114, -113, -112, -112,
-112, -111, -111, -109, -109, -109, -109, -107, -107, -106, -105, -104, -104,
-103, -102, -102, -99, -97, -95, -95, -93, -95, -89, -87, -87, -81, -77, -70,
-69, -51, -26, -17, -15, -14, -12, -10, -7, -3, };