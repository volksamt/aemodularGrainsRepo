#define DATA_LENGTH 512
#define DATA AKWF_1233

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 0,
0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, -1,
0, 0, 0, -1, 0, -1, 0, 0, -1, 0, 1, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, -1, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0,
0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
1, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 2, 7, 19, 34, 44,
49, 50, 51, 54, 57, 60, 65, 69, 71, 74, 77, 79, 82, 84, 85, 88, 89, 91, 92, 93,
93, 95, 96, 95, 96, 96, 97, 97, 98, 98, 98, 98, 97, 97, 97, 96, 97, 97, 95, 96,
95, 95, 94, 95, 76, 37, 29, 32, 30, 32, 31, 32, 31, 31, 31, 31, 31, 31, 30, 31,
30, 30, 29, 30, 30, 30, 30, 30, 30, 30, 29, 29, 29, 29, 29, 29, 29, 30, 30, 29,
30, 30, 30, 30, 31, 29, 30, 30, 31, 29, 32, 30, 33, 28, 47, 93, 90, 91, 92, 92,
93, 92, 94, 94, 96, 95, 97, 97, 99, 99, 100, 101, 102, 102, 103, 104, 105, 107,
108, 109, 110, 112, 113, 114, 115, 115, 111, 85, 29, -35, -70, -68, -50, -41,
-54, -78, -95, -98, -95, -94, -98, -103, -107, -112, -114, -116, -117, -118,
-118, -119, -119, -119, -119, -118, -117, -116, -115, -114, -114, -112, -112,
-110, -109, -108, -106, -104, -103, -102, -101, -99, -98, -97, -95, -94, -93,
-93, -92, -91, -91, -89, -89, -89, -88, -87, -86, -87, -86, -86, -85, -85, -85,
-85, -85, -85, -85, -85, -86, -86, -85, -85, -85, -85, -85, -86, -86, -86, -86,
-86, -87, -87, -87, -88, -88, -88, -88, -88, -89, -88, -89, -89, -90, -89, -89,
-90, -90, -90, -89, -90, -90, -90, -90, -90, -90, -89, -87, -90, -87, -89, -85,
-91, -55, 5, -2, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 1, 0, 1, 0, 1, 0, 0,
0, 0, 1, -1, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0,
-1, 0, 0, -1, 0, 1, 0, -1, 0, -1, 0, -1, -1, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0,
0, 0, 0, -1, 1, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, -1, -1, 0, 0,
0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0,
-1, 0, 0, 0, 0, 1, 0, 0, };