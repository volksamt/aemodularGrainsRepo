#define DATA_LENGTH 512
#define DATA AKWF_1222

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 3, 3, 4, 4, 5, 5, 6, 6, 7, 6,
7, 8, 8, 9, 9, 9, 10, 10, 11, 10, 12, 12, 12, 13, 14, 14, 15, 16, 17, 16, 17,
18, 19, 19, 20, 21, 21, 22, 24, 24, 24, 25, 26, 27, 27, 28, 30, 31, 32, 32, 35,
35, 36, 37, 39, 40, 41, 44, 44, 45, 47, 48, 50, 51, 52, 54, 56, 56, 58, 60, 61,
63, 65, 66, 67, 68, 71, 72, 74, 75, 76, 78, 80, 81, 82, 84, 85, 87, 88, 90, 91,
92, 93, 94, 96, 96, 97, 99, 100, 102, 103, 104, 104, 106, 107, 108, 108, 109,
111, 111, 112, 112, 112, 114, 114, 115, 115, 115, 116, 116, 117, 117, 117, 118,
118, 119, 118, 118, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 118, 118,
118, 117, 117, 117, 116, 117, 115, 116, 114, 114, 113, 112, 113, 111, 110, 111,
109, 109, 108, 107, 106, 105, 104, 103, 102, 101, 101, 100, 98, 98, 97, 95, 94,
93, 93, 90, 89, 88, 86, 86, 84, 83, 82, 80, 79, 77, 76, 74, 72, 71, 69, 68, 67,
66, 63, 63, 61, 59, 58, 56, 55, 53, 51, 50, 48, 46, 45, 43, 42, 41, 38, 37, 36,
35, 33, 32, 30, 30, 28, 28, 26, 25, 23, 22, 21, 20, 18, 17, 16, 16, 14, 13, 13,
11, 10, 9, 9, 8, 7, 7, 7, 7, 6, 6, 6, 6, 4, 4, 3, 2, 2, 1, 1, 0, -1, -2, -3, -4,
-4, -4, -5, -6, -6, -6, -7, -7, -7, -7, -8, -9, -9, -9, -10, -10, -11, -12, -12,
-12, -12, -13, -14, -15, -15, -15, -16, -17, -17, -18, -18, -19, -20, -20, -22,
-22, -23, -23, -25, -25, -26, -27, -28, -30, -30, -30, -32, -33, -35, -36, -37,
-38, -40, -40, -42, -43, -44, -46, -47, -49, -50, -51, -53, -55, -55, -58, -58,
-60, -61, -63, -64, -67, -68, -69, -71, -73, -74, -76, -77, -79, -79, -81, -83,
-84, -85, -87, -88, -90, -91, -92, -93, -95, -96, -97, -98, -100, -100, -102,
-102, -104, -104, -107, -106, -107, -109, -110, -110, -111, -112, -112, -113,
-113, -115, -114, -115, -116, -116, -117, -118, -118, -118, -117, -118, -119,
-119, -119, -119, -119, -118, -118, -120, -119, -119, -119, -119, -118, -118,
-118, -117, -118, -117, -117, -116, -116, -116, -115, -114, -114, -113, -112,
-112, -111, -110, -110, -109, -109, -109, -107, -106, -106, -104, -103, -103,
-101, -100, -99, -98, -97, -96, -94, -93, -92, -91, -90, -90, -88, -87, -86,
-84, -83, -81, -80, -79, -78, -76, -74, -73, -71, -70, -68, -67, -65, -64, -62,
-61, -59, -58, -55, -54, -53, -51, -50, -47, -47, -45, -43, -41, -41, -38, -37,
-37, -35, -33, -32, -31, -29, -28, -27, -26, -25, -24, -23, -21, -20, -19, -18,
-17, -14, -15, -13, -12, -10, -10, -9, -9, -8, -8, -6, -7, -7, -7, -7, -6, -5,
-4, -3, -2, -3, -1, -1, 0, };