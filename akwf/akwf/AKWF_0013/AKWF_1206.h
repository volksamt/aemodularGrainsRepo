#define DATA_LENGTH 512
#define DATA AKWF_1206

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 4, 5, 6, 8, 9, 11, 13, 16,
19, 22, 25, 29, 33, 38, 42, 46, 49, 52, 54, 57, 58, 61, 62, 64, 65, 66, 67, 70,
71, 72, 73, 74, 75, 75, 77, 78, 79, 79, 81, 81, 82, 83, 84, 85, 87, 87, 88, 89,
90, 90, 92, 93, 94, 93, 94, 95, 95, 94, 95, 93, 93, 91, 89, 86, 84, 82, 80, 78,
77, 77, 77, 76, 76, 77, 77, 78, 78, 80, 80, 82, 81, 82, 83, 85, 85, 86, 87, 88,
88, 90, 91, 91, 94, 93, 96, 93, 101, 92, 114, 27, -42, -16, -31, -18, -26, -16,
-22, -13, -17, -10, -10, -6, -3, -108, -120, -107, -109, -100, -101, -94, -94,
-89, -89, -86, -86, -83, -82, -81, -79, -78, -77, -76, -74, -74, -73, -72, -70,
-70, -68, -68, -66, -65, -64, -64, -62, -62, -60, -60, -59, -59, -56, -56, -55,
-55, -54, -54, -53, -52, -52, -53, -52, -53, -54, -56, -57, -60, -62, -63, -66,
-68, -70, -70, -71, -71, -71, -71, -70, -70, -68, -68, -67, -67, -65, -65, -64,
-63, -63, -61, -60, -59, -58, -57, -57, -55, -54, -52, -52, -51, -51, -49, -49,
-48, -46, -45, -44, -43, -42, -40, -38, -37, -35, -32, -30, -26, -24, -20, -16,
-12, -7, -3, 1, 4, 6, 9, 12, 13, 15, 16, 18, 20, 21, 22, 23, 24, 26, 28, 27, 29,
30, 31, 31, 34, 33, 34, 36, 36, 38, 39, 40, 40, 41, 42, 44, 44, 46, 45, 48, 46,
49, 46, 49, 47, 49, 45, 49, 44, 47, 40, 41, 35, -85, -99, -92, -100, -95, -101,
-96, -99, -96, -99, -95, -98, -94, -96, -92, -93, -90, -91, -90, -89, -87, -86,
-85, -85, -84, -83, -82, -80, -80, -78, -78, -77, -77, -75, -73, -72, -71, -69,
-68, -66, -66, -64, -62, -59, -58, -55, -52, -48, -44, -40, -36, -32, -28, -24,
-22, -18, -17, -15, -12, -11, -9, -8, -7, -5, -4, -3, -3, -1, 0, 1, 2, 3, 4, 5,
6, 7, 9, 10, 10, 11, 12, 14, 14, 15, 16, 16, 16, 19, 19, 20, 20, 21, 22, 21, 21,
21, 20, 19, 18, 16, 14, 11, 8, 6, 5, 4, 3, 3, 3, 3, 3, 3, 4, 4, 6, 6, 7, 8, 9,
9, 11, 11, 12, 14, 13, 15, 16, 17, 18, 20, 20, 22, 23, 23, 24, 26, 27, 28, 29,
30, 32, 32, 35, 35, 38, 40, 43, 43, 48, 50, 55, 58, 64, 66, 71, 75, 78, 82, 83,
86, 87, 91, 89, 95, 90, 98, 92, 102, 90, 114, 52, -41, -18, -29, -20, -24, -20,
-21, -19, -18, -17, -16, -16, -13, -14, -12, -13, -9, -11, -8, -10, -7, -7, -5,
-7, -6, -7, -6, -7, -8, -9, -12, -12, -16, -18, -20, -22, -22, -23, -25, -24,
-24, -24, -24, -23, -23, -21, -21, -20, -19, -18, -18, -17, -16, -14, -14, -13,
-12, -12, -10, -9, -8, -7, -6, -5, -4, -2, -2, -1, };