#define DATA_LENGTH 512
#define DATA AKWF_1266

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 1, 2, 2, 4, 4, 4, 5, 5, 6, 7, 8,
9, 9, 10, 9, 11, 10, 11, 12, 13, 15, 14, 15, 16, 17, 18, 19, 20, 19, 21, 23, 23,
23, 25, 25, 26, 27, 28, 28, 29, 29, 31, 31, 32, 33, 33, 35, 36, 36, 37, 37, 39,
39, 41, 42, 43, 44, 44, 45, 47, 48, 48, 49, 51, 52, 52, 53, 55, 55, 56, 58, 58,
59, 61, 62, 63, 63, 63, 65, 66, 67, 67, 69, 70, 70, 71, 72, 74, 75, 76, 77, 78,
79, 80, 80, 82, 83, 84, 85, 86, 86, 89, 82, 67, 47, 23, 1, -21, -41, -56, -68,
-78, -86, -93, -98, -102, -107, -111, -113, -117, -118, -119, -118, -116, -112,
-107, -101, -95, -88, -81, -74, -69, -64, -60, -57, -55, -55, -57, -58, -61,
-64, -67, -71, -76, -80, -83, -86, -89, -90, -90, -89, -87, -84, -80, -75, -68,
-61, -53, -45, -37, -28, -20, -11, -3, 4, 11, 16, 20, 24, 26, 27, 27, 26, 24,
21, 18, 13, 8, 3, -2, -6, -11, -16, -20, -23, -25, -25, -27, -27, -27, -26, -23,
-21, -19, -16, -13, -9, -7, -4, -1, 1, 2, 4, 5, 5, 4, 4, 3, 2, 0, -2, -4, -6,
-9, -9, -11, -12, -12, -13, -12, -11, -10, -8, -7, -4, 0, 4, 8, 11, 15, 19, 22,
25, 29, 31, 34, 36, 36, 37, 38, 37, 36, 36, 34, 32, 31, 28, 26, 23, 21, 20, 18,
17, 15, 14, 13, 13, 12, 13, 14, 15, 15, 16, 18, 19, 20, 21, 22, 22, 23, 23, 24,
24, 23, 22, 22, 21, 20, 18, 17, 15, 15, 13, 13, 11, 11, 10, 9, 9, 9, 9, 11, 11,
11, 13, 14, 16, 17, 18, 19, 21, 22, 22, 23, 23, 24, 25, 25, 24, 23, 23, 22, 21,
20, 19, 17, 16, 15, 13, 13, 12, 10, 9, 8, 8, 8, 8, 8, 7, 8, 7, 7, 8, 8, 9, 8, 8,
8, 8, 7, 7, 6, 6, 6, 5, 4, 3, 2, 2, 0, -1, -1, -2, -3, -3, -4, -5, -5, -5, -5,
-6, -5, -5, -5, -4, -4, -4, -3, -4, -3, -4, -3, -3, -4, -3, -3, -4, -4, -4, -5,
-6, -6, -7, -8, -9, -9, -10, -11, -11, -12, -12, -13, -14, -13, -14, -15, -14,
-14, -15, -15, -15, -14, -14, -14, -14, -15, -15, -15, -15, -15, -15, -15, -17,
-17, -17, -18, -18, -19, -18, -19, -19, -20, -20, -21, -21, -20, -21, -21, -21,
-22, -21, -21, -21, -20, -20, -20, -20, -19, -19, -19, -19, -19, -18, -18, -18,
-18, -18, -18, -18, -18, -19, -19, -18, -18, -19, -19, -19, -18, -18, -20, -19,
-18, -18, -18, -17, -18, -17, -17, -17, -16, -16, -15, -15, -15, -14, -14, -14,
-14, -13, -13, -13, -13, -12, -12, -12, -12, -12, -12, -11, -11, -11, -10, -10,
-9, -9, -8, -8, -7, -6, -6, -6, -4, -4, -4, -3, -2, -2, -1, -1, 0, };