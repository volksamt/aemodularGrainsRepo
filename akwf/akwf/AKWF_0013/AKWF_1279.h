#define DATA_LENGTH 512
#define DATA AKWF_1279

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 7, 10, 13, 16, 19, 20, 24,
26, 28, 31, 31, 33, 34, 35, 36, 36, 35, 36, 35, 35, 33, 32, 31, 30, 28, 27, 26,
23, 22, 21, 20, 19, 18, 18, 17, 18, 17, 18, 18, 17, 19, 20, 22, 21, 23, 25, 26,
28, 30, 31, 34, 35, 36, 37, 39, 40, 41, 42, 42, 43, 44, 45, 45, 45, 45, 45, 44,
46, 46, 45, 45, 45, 45, 46, 46, 47, 48, 48, 50, 51, 52, 55, 55, 58, 59, 61, 63,
65, 67, 69, 72, 73, 76, 78, 79, 81, 84, 87, 88, 91, 92, 93, 95, 96, 98, 98, 99,
99, 99, 99, 99, 98, 97, 96, 95, 94, 93, 92, 90, 89, 88, 85, 85, 83, 81, 80, 78,
75, 74, 72, 70, 68, 64, 63, 60, 57, 55, 52, 49, 46, 43, 41, 39, 37, 34, 32, 28,
27, 24, 22, 20, 17, 15, 12, 9, 6, 4, 1, -1, -4, -6, -10, -12, -13, -16, -18,
-21, -22, -23, -25, -26, -26, -27, -27, -28, -28, -28, -28, -28, -29, -28, -28,
-29, -29, -29, -28, -29, -28, -27, -26, -25, -24, -22, -22, -20, -19, -18, -15,
-16, -13, -12, -11, -10, -9, -8, -6, -5, -4, -1, 0, 2, 4, 8, 9, 12, 15, 17, 19,
22, 24, 26, 28, 31, 32, 34, 36, 36, 38, 39, 39, 41, 42, 43, 44, 45, 46, 47, 48,
48, 50, 50, 50, 52, 51, 52, 51, 51, 50, 49, 48, 47, 46, 44, 42, 40, 39, 36, 34,
32, 30, 28, 25, 23, 20, 18, 16, 14, 11, 7, 4, 2, -3, -6, -9, -13, -17, -22, -26,
-29, -33, -37, -41, -45, -49, -53, -56, -60, -62, -66, -69, -73, -76, -79, -82,
-86, -89, -92, -95, -98, -101, -103, -106, -108, -110, -112, -115, -116, -117,
-117, -119, -118, -119, -120, -119, -118, -118, -118, -117, -115, -115, -115,
-113, -112, -112, -111, -110, -109, -108, -107, -107, -105, -105, -104, -102,
-101, -101, -99, -98, -97, -95, -94, -93, -90, -89, -88, -85, -83, -80, -79,
-76, -75, -71, -70, -67, -65, -63, -61, -59, -56, -54, -52, -51, -48, -47, -46,
-45, -43, -41, -40, -39, -38, -38, -37, -36, -35, -35, -33, -32, -31, -30, -29,
-28, -27, -24, -23, -22, -20, -17, -16, -13, -12, -10, -9, -6, -4, -2, 0, 1, 2,
4, 5, 6, 6, 7, 7, 8, 8, 8, 7, 6, 5, 5, 4, 3, 2, 1, 1, 0, 0, -1, -2, 0, -1, -1,
-1, 0, 1, 2, 2, 4, 6, 6, 7, 8, 9, 10, 11, 11, 12, 12, 11, 11, 11, 10, 10, 7, 5,
4, 2, 0, -2, -5, -7, -10, -13, -15, -17, -19, -20, -22, -23, -24, -24, -24, -23,
-22, -22, -20, -19, -18, -16, -14, -13, -10, -8, -7, -4, -2, -2, 1, 1, 2, 3, 3,
3, 3, 3, 2, 1, 1, 0, -1, -2, -4, -4, -5, -7, -8, -8, -9, -8, -8, -8, -7, -7, -5,
-4, -2, 0, };