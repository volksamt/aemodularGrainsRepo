#define DATA_LENGTH 512
#define DATA AKWF_1274

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 16, 32, 48, 57, 60, 62, 65, 69, 77,
86, 95, 103, 111, 117, 119, 105, 69, 31, 11, 21, 53, 88, 102, 94, 76, 56, 39,
22, 9, -4, -14, -24, -33, -40, -47, -53, -60, -66, -70, -75, -79, -82, -85, -87,
-89, -91, -92, -92, -91, -91, -91, -89, -88, -87, -85, -83, -81, -79, -76, -73,
-71, -68, -64, -62, -58, -55, -52, -48, -45, -42, -39, -36, -33, -28, -26, -23,
-19, -16, -13, -10, -6, -3, -1, 2, 6, 7, 10, 13, 15, 19, 21, 23, 25, 26, 30, 31,
33, 35, 37, 38, 40, 41, 43, 44, 45, 46, 47, 48, 49, 50, 51, 50, 51, 52, 52, 52,
52, 53, 53, 52, 52, 53, 52, 52, 51, 51, 50, 49, 48, 48, 46, 46, 45, 43, 44, 42,
41, 40, 38, 38, 36, 34, 33, 31, 29, 28, 27, 26, 23, 21, 19, 18, 17, 14, 13, 11,
9, 8, 6, 4, 2, -1, -2, -4, -7, -9, -10, -12, -15, -17, -19, -21, -22, -25, -27,
-29, -31, -34, -34, -37, -39, -41, -42, -44, -46, -48, -49, -51, -53, -55, -56,
-56, -57, -59, -60, -60, -62, -62, -62, -62, -62, -61, -61, -60, -58, -55, -54,
-52, -48, -45, -41, -36, -31, -24, -16, -7, 2, 13, 25, 40, 54, 64, 56, 31, 2,
-7, 10, 47, 85, 106, 111, 106, 98, 88, 77, 67, 59, 52, 49, 47, 43, 35, 20, 4,
-6, -9, -17, -34, -42, -19, 13, 27, 21, 9, 2, -6, -18, -33, -48, -56, -60, -62,
-65, -71, -78, -87, -95, -104, -112, -118, -118, -101, -65, -27, -11, -23, -57,
-91, -101, -91, -73, -53, -36, -20, -7, 6, 15, 25, 34, 41, 48, 55, 61, 66, 71,
75, 79, 82, 86, 87, 90, 91, 91, 91, 92, 92, 90, 90, 88, 87, 84, 83, 81, 79, 75,
73, 70, 68, 64, 61, 58, 55, 52, 49, 45, 43, 39, 34, 32, 29, 26, 23, 19, 16, 12,
10, 7, 4, 1, -2, -5, -7, -11, -14, -16, -18, -20, -23, -25, -28, -30, -31, -33,
-35, -37, -39, -39, -41, -42, -44, -45, -46, -46, -48, -49, -49, -50, -50, -51,
-51, -51, -53, -53, -52, -52, -52, -52, -52, -52, -50, -50, -50, -49, -49, -47,
-46, -46, -46, -45, -44, -42, -42, -40, -39, -38, -37, -36, -33, -33, -30, -29,
-28, -26, -26, -23, -22, -19, -18, -17, -15, -12, -10, -9, -7, -4, -3, 0, 1, 3,
5, 7, 9, 11, 13, 15, 17, 19, 21, 24, 26, 28, 30, 32, 34, 35, 38, 39, 42, 43, 45,
47, 48, 50, 51, 54, 55, 56, 57, 58, 59, 60, 61, 61, 61, 62, 62, 62, 61, 61, 59,
58, 56, 54, 51, 48, 45, 40, 35, 29, 22, 15, 7, -3, -14, -26, -41, -55, -63, -55,
-27, 0, 7, -12, -52, -88, -107, -110, -105, -96, -86, -76, -66, -57, -52, -49,
-46, -43, -33, -18, -3, 6, 11, 20, 37, 41, 17, -16, -26, -20, -9, -1, };