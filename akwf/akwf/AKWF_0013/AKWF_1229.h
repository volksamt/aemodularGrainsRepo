#define DATA_LENGTH 512
#define DATA AKWF_1229

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 6, 9, 12, 15, 18, 20, 23, 25,
28, 30, 33, 36, 38, 39, 42, 44, 46, 49, 50, 51, 54, 56, 57, 58, 60, 62, 63, 64,
65, 67, 67, 68, 70, 71, 71, 73, 74, 74, 75, 75, 76, 76, 78, 77, 78, 79, 79, 79,
80, 80, 81, 80, 81, 81, 80, 81, 80, 81, 81, 81, 81, 81, 80, 80, 80, 80, 81, 79,
80, 80, 79, 79, 80, 79, 78, 78, 77, 77, 77, 76, 77, 77, 77, 76, 76, 76, 76, 75,
75, 74, 75, 74, 74, 74, 73, 74, 73, 73, 72, 72, 72, 72, 72, 72, 72, 71, 72, 72,
72, 70, 71, 70, 72, 71, 70, 71, 71, 70, 71, 70, 70, 71, 70, 71, 71, 70, 70, 70,
70, 70, 70, 69, 70, 70, 70, 70, 70, 70, 70, 69, 69, 68, 69, 68, 68, 68, 67, 66,
66, 66, 65, 65, 65, 64, 63, 63, 62, 61, 61, 60, 60, 59, 58, 57, 57, 57, 55, 54,
53, 52, 52, 52, 49, 49, 49, 48, 47, 45, 44, 43, 43, 41, 41, 39, 38, 37, 36, 36,
34, 33, 32, 31, 31, 30, 28, 28, 26, 26, 24, 23, 22, 22, 21, 20, 19, 18, 17, 17,
16, 16, 14, 13, 12, 12, 12, 11, 10, 9, 10, 10, 8, 8, 8, 7, 8, 7, 7, 6, 6, 7, 6,
6, 7, 7, 6, 6, 7, 6, 6, 6, 7, 7, 7, 8, 8, 8, 9, 9, 8, 9, 9, 10, 9, 10, 11, 9,
11, 10, 11, 11, 11, 11, 12, 11, 11, 11, 12, 11, 11, 11, 11, 11, 11, 11, 9, 10,
9, 9, 10, 8, 8, 8, 8, 6, 6, 6, 6, 4, 5, 4, 3, 2, 2, 0, 0, -1, -2, -3, -3, -4,
-5, -6, -8, -8, -9, -9, -11, -12, -13, -14, -15, -16, -17, -19, -19, -20, -22,
-22, -24, -25, -26, -26, -28, -28, -30, -31, -32, -33, -34, -35, -36, -37, -38,
-39, -41, -41, -42, -43, -44, -45, -45, -47, -47, -48, -49, -49, -50, -51, -52,
-52, -52, -53, -53, -54, -56, -55, -56, -56, -57, -57, -58, -57, -58, -58, -58,
-58, -58, -59, -58, -59, -59, -59, -59, -59, -59, -59, -59, -59, -58, -57, -58,
-58, -57, -58, -57, -56, -56, -56, -56, -55, -56, -55, -56, -56, -56, -56, -56,
-56, -56, -57, -57, -58, -60, -60, -61, -61, -62, -64, -65, -66, -68, -69, -70,
-72, -74, -76, -77, -79, -81, -83, -84, -87, -88, -91, -92, -93, -96, -97, -99,
-100, -101, -103, -105, -107, -108, -108, -110, -111, -113, -114, -115, -115,
-116, -117, -117, -118, -118, -118, -119, -119, -120, -119, -119, -119, -118,
-117, -118, -117, -116, -116, -114, -113, -112, -111, -110, -109, -108, -105,
-104, -102, -101, -99, -97, -94, -93, -92, -89, -87, -84, -82, -80, -78, -76,
-73, -71, -68, -66, -63, -60, -58, -55, -53, -49, -47, -44, -41, -39, -35, -32,
-30, -26, -24, -20, -17, -16, -12, -9, -6, -4, -1, };