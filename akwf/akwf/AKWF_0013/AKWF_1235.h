#define DATA_LENGTH 512
#define DATA AKWF_1235

const PROGMEM int8_t DATA[DATA_LENGTH] = {29, 25, 26, 26, 25, 27, 26, 26, 25,
27, 25, 26, 25, 27, 26, 26, 26, 26, 26, 26, 25, 26, 25, 26, 25, 25, 26, 26, 26,
25, 25, 25, 26, 25, 26, 26, 26, 25, 26, 26, 26, 25, 27, 26, 25, 25, 26, 26, 26,
26, 25, 26, 25, 26, 25, 27, 24, 27, 8, -3, -1, 0, -9, -12, 2, -2, -1, -1, 0, -1,
-1, 0, -1, 0, -1, 0, -1, -1, -2, -1, -2, -1, -1, 0, -2, -2, -1, -1, -2, -1, -1,
-1, -1, -1, -1, -1, -1, -1, -2, -1, -2, -1, -1, -2, -1, -1, -2, 0, 17, 26, 24,
26, 25, 25, 26, 26, 26, 25, 26, 26, 26, 25, 26, 25, 25, 25, 25, 25, 25, 26, 25,
25, 25, 26, 25, 26, 26, 25, 26, 26, 25, 25, 25, 25, 25, 25, 24, 25, 24, 25, 25,
25, 25, 25, 25, 25, 25, 25, 25, 24, 25, 25, 24, 25, 24, 25, 25, 25, 25, 25, 25,
24, 25, 25, 25, 25, 25, 25, 25, 24, 24, 25, 24, 25, 25, 24, 24, 25, 24, 24, 24,
24, 24, 24, 24, 24, 24, 25, 24, 25, 23, 26, 24, 25, 23, 28, 9, -43, -47, -46,
-46, -45, -47, -46, -46, -46, -46, -46, -46, -46, -47, -45, -46, -45, -46, -46,
-47, -46, -47, -45, -47, -46, -46, -46, -47, -45, -46, -46, -47, -45, -56, -107,
-118, -115, -117, -116, -116, -116, -116, -117, -116, -117, -115, -119, -84, -9,
5, 5, 7, 8, 11, 12, 13, 14, 16, 15, 18, 18, 19, 20, 20, 20, 22, 21, 22, 22, 22,
23, 24, 23, 23, 24, 24, 25, 23, 24, 25, 25, 24, 25, 25, 24, 26, 25, 25, 25, 25,
24, 26, 25, 25, 25, 25, 24, 26, 26, 26, 26, 25, 26, 25, 26, 25, 26, 24, 27, 23,
29, -5, 1, 33, 22, 27, 24, 26, 26, 26, 26, 26, 26, 25, 26, 25, 25, 25, 26, 26,
25, 26, 26, 26, 26, 25, 26, 25, 25, 25, 26, 25, 26, 26, 25, 25, 25, 26, 26, 25,
26, 25, 25, 25, 26, 25, 25, 26, 25, 25, 25, 25, 26, 25, 26, 25, 25, 25, 25, 25,
25, 25, 25, 24, 25, 20, 5, 1, 5, 6, 8, 9, 12, 12, 14, 14, 15, 16, 17, 18, 19,
19, 20, 20, 21, 21, 21, 21, 22, 21, 22, 23, 23, 23, 23, 23, 22, 24, 24, 23, 23,
24, 24, 24, 24, 23, 24, 24, 24, 24, 24, 24, 24, 24, 24, 24, 24, 24, 23, 24, 24,
24, 24, 24, 24, 24, 24, 24, 24, 25, 25, 23, 24, 23, 24, 25, 25, 23, 24, 24, 24,
23, 25, 23, 27, 3, -46, -46, -46, -46, -46, -46, -46, -46, -46, -47, -46, -47,
-45, -46, -47, -47, -47, -47, -45, -47, -46, -46, -45, -47, -46, -47, -45, -47,
-46, -47, -45, -47, -44, -61, -112, -117, -117, -116, -117, -116, -117, -115,
-117, -115, -117, -115, -119, -87, -2, };