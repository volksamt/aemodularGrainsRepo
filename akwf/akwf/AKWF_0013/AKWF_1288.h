#define DATA_LENGTH 512
#define DATA AKWF_1288

const PROGMEM int8_t DATA[DATA_LENGTH] = {22, 29, 29, 32, 32, 35, 36, 39, 40,
42, 43, 45, 47, 49, 50, 53, 54, 56, 58, 60, 61, 63, 64, 65, 67, 68, 71, 72, 73,
75, 76, 78, 79, 80, 81, 84, 84, 85, 87, 88, 89, 90, 92, 92, 93, 94, 95, 97, 98,
99, 100, 100, 100, 103, 103, 104, 104, 105, 106, 107, 108, 108, 109, 110, 110,
110, 112, 111, 112, 113, 113, 113, 113, 114, 115, 115, 115, 116, 117, 117, 117,
117, 118, 118, 117, 118, 118, 118, 118, 118, 119, 119, 118, 118, 119, 120, 119,
119, 118, 119, 120, 119, 119, 118, 119, 118, 120, 114, 114, 120, 116, 117, 116,
118, 116, 116, 115, 116, 116, 115, 115, 114, 115, 114, 115, 113, 113, 112, 112,
112, 112, 111, 112, 110, 110, 110, 109, 109, 108, 109, 107, 108, 105, 107, 105,
107, 102, 110, 78, 47, 57, 49, 56, 49, 65, 78, 74, 75, 74, 74, 72, 73, 72, 71,
70, 70, 70, 70, 68, 68, 67, 67, 66, 66, 65, 65, 64, 63, 63, 62, 62, 61, 61, 60,
60, 59, 58, 58, 56, 56, 55, 55, 55, 55, 54, 52, 52, 52, 51, 50, 49, 49, 48, 48,
47, 46, 46, 44, 44, 43, 43, 42, 40, 40, 40, 39, 38, 37, 37, 35, 36, 33, 37, 53,
56, 54, 54, 53, 52, 51, 50, 49, 49, 47, 47, 45, 45, 43, 43, 41, 40, 39, 38, 37,
36, 34, 34, 32, 32, 30, 29, 29, 27, 26, 26, 24, 23, 22, 21, 20, 19, 18, 17, 16,
15, 14, 13, 11, 11, 10, 9, 8, 6, 6, 5, 3, 2, 2, -1, 0, -3, -2, -4, -3, -6, -5,
-8, -6, -10, -8, -14, -60, -62, -62, -64, -63, -65, -64, -67, -66, -68, -68,
-70, -69, -71, -71, -71, -71, -73, -74, -74, -75, -75, -76, -76, -78, -78, -79,
-79, -80, -80, -82, -82, -81, -83, -82, -85, -84, -86, -83, -89, -83, -95, -64,
-48, -70, -62, -68, -64, -67, -66, -68, -68, -95, -92, -96, -92, -98, -92, -101,
-79, -44, -51, -49, -93, -75, -75, -77, -75, -78, -76, -79, -78, -80, -78, -82,
-79, -82, -80, -82, -82, -83, -83, -84, -84, -85, -84, -85, -85, -86, -86, -87,
-88, -86, -89, -88, -89, -89, -90, -89, -90, -90, -91, -91, -91, -91, -92, -92,
-92, -93, -92, -93, -93, -94, -93, -93, -93, -95, -92, -95, -93, -95, -115,
-122, -108, -92, -95, -94, -94, -94, -94, -94, -93, -94, -93, -94, -93, -92,
-92, -92, -92, -92, -91, -92, -91, -91, -91, -90, -89, -89, -89, -88, -88, -86,
-86, -86, -86, -85, -84, -84, -83, -82, -81, -81, -80, -79, -79, -78, -77, -76,
-75, -74, -73, -72, -71, -70, -69, -68, -67, -67, -65, -63, -62, -61, -61, -59,
-58, -55, -55, -53, -52, -51, -50, -47, -47, -44, -44, -42, -40, -39, -37, -34,
-33, -33, -30, -28, -27, -24, -23, -22, -20, -18, -16, -15, -14, -11, -9, -8,
-6, -4, -1, -1, };