#define DATA_LENGTH 512
#define DATA AKWF_1228

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 11, 14, 19, 23, 29, 33, 38, 43,
47, 51, 57, 61, 64, 69, 74, 78, 81, 85, 89, 92, 95, 98, 101, 103, 105, 106, 108,
110, 111, 110, 111, 111, 110, 109, 108, 107, 106, 104, 101, 100, 97, 94, 92, 89,
88, 85, 82, 80, 77, 75, 72, 71, 68, 66, 65, 62, 59, 58, 57, 53, 52, 50, 49, 47,
44, 43, 42, 39, 38, 36, 35, 33, 31, 29, 28, 27, 25, 23, 21, 20, 18, 17, 15, 13,
10, 8, 6, 3, 0, -4, -8, -11, -14, -18, -23, -27, -31, -37, -41, -46, -51, -56,
-60, -65, -70, -75, -79, -83, -88, -92, -96, -98, -102, -105, -108, -110, -112,
-113, -115, -116, -117, -118, -119, -119, -120, -118, -118, -117, -117, -115,
-113, -112, -111, -108, -105, -102, -100, -97, -94, -90, -85, -82, -79, -75,
-70, -66, -61, -58, -53, -49, -45, -41, -36, -32, -29, -24, -20, -16, -13, -9,
-6, -2, 1, 5, 9, 11, 15, 18, 22, 25, 28, 31, 35, 39, 42, 45, 48, 51, 55, 58, 61,
64, 66, 69, 72, 75, 77, 79, 82, 83, 85, 87, 89, 91, 93, 93, 95, 96, 97, 98, 97,
99, 98, 99, 99, 99, 98, 98, 98, 97, 96, 95, 93, 92, 90, 88, 86, 84, 81, 78, 75,
72, 68, 65, 59, 56, 52, 47, 43, 39, 34, 29, 25, 20, 15, 10, 6, 1, -4, -8, -12,
-16, -20, -24, -27, -29, -33, -36, -38, -41, -43, -46, -48, -50, -52, -54, -56,
-57, -57, -59, -61, -60, -62, -62, -63, -63, -63, -64, -63, -64, -63, -63, -63,
-64, -63, -62, -63, -62, -63, -62, -63, -63, -63, -63, -63, -64, -64, -65, -65,
-66, -67, -68, -69, -70, -71, -71, -71, -72, -72, -73, -72, -72, -71, -70, -68,
-68, -67, -64, -62, -60, -58, -55, -51, -48, -45, -42, -39, -34, -30, -27, -22,
-18, -14, -10, -6, 0, 4, 8, 13, 18, 23, 28, 32, 38, 41, 47, 52, 56, 61, 64, 68,
71, 75, 78, 80, 84, 86, 87, 90, 90, 91, 90, 91, 91, 91, 90, 89, 89, 87, 85, 84,
82, 81, 79, 77, 76, 74, 72, 70, 69, 67, 66, 63, 62, 60, 59, 58, 57, 56, 53, 52,
51, 48, 48, 47, 46, 43, 42, 42, 39, 38, 37, 36, 36, 34, 33, 33, 31, 30, 28, 27,
25, 24, 23, 21, 20, 19, 17, 15, 13, 11, 8, 5, 3, 0, -1, -5, -7, -10, -14, -16,
-19, -22, -25, -28, -31, -34, -36, -39, -42, -43, -46, -48, -51, -52, -55, -56,
-58, -60, -61, -63, -64, -67, -67, -68, -70, -70, -71, -72, -73, -74, -75, -75,
-76, -76, -76, -77, -77, -77, -77, -76, -77, -76, -75, -76, -75, -74, -73, -73,
-72, -71, -71, -70, -69, -68, -67, -66, -65, -65, -65, -63, -63, -62, -62, -61,
-61, -59, -59, -58, -57, -57, -55, -53, -52, -51, -48, -46, -44, -41, -39, -36,
-33, -30, -27, -23, -18, -15, -11, -6, -3, };