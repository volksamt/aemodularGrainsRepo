#define DATA_LENGTH 512
#define DATA AKWF_1281

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 13, 16, 20, 24, 28, 32, 36,
39, 43, 47, 51, 55, 59, 62, 66, 68, 72, 74, 77, 79, 82, 85, 86, 88, 90, 91, 91,
93, 93, 94, 95, 95, 94, 95, 95, 95, 94, 93, 94, 93, 91, 91, 91, 90, 88, 87, 85,
84, 82, 80, 79, 77, 74, 73, 70, 67, 64, 62, 59, 57, 54, 50, 47, 43, 39, 36, 33,
28, 25, 21, 17, 14, 11, 7, 5, 1, -1, -4, -5, -8, -11, -14, -16, -19, -23, -25,
-29, -31, -34, -37, -39, -42, -44, -48, -49, -52, -54, -55, -57, -59, -60, -61,
-62, -62, -63, -64, -65, -64, -65, -64, -65, -63, -64, -63, -61, -60, -59, -57,
-56, -54, -54, -51, -49, -45, -43, -40, -37, -33, -30, -26, -23, -20, -16, -12,
-9, -6, -1, 1, 4, 5, 9, 9, 10, 13, 17, 17, 21, 27, 33, 33, 39, 41, 44, 42, 45,
48, 52, 52, 60, 68, 67, 71, 73, 85, 9, 2, 26, 20, 27, 20, 23, 19, 20, 16, 18,
15, 17, 15, 16, 15, 15, 15, 15, 14, 13, 12, 11, 11, 8, 8, 6, 5, 2, 2, -1, -2,
-5, -8, -10, -11, -14, -16, -19, -20, -24, -25, -29, -30, -35, -36, -42, -47,
-52, -58, -64, -69, -73, -80, -82, -89, -90, -99, -99, -110, -106, -127, -81,
-44, -68, -58, -66, -62, -68, -66, -69, -70, -72, -74, -75, -77, -78, -79, -80,
-82, -82, -84, -85, -87, -85, -88, -87, -88, -88, -89, -89, -89, -87, -87, -86,
-87, -86, -85, -84, -82, -81, -79, -78, -75, -74, -71, -68, -64, -62, -58, -56,
-51, -48, -44, -41, -37, -34, -31, -27, -24, -21, -17, -15, -10, -7, -4, 0, 3,
7, 10, 14, 17, 21, 24, 28, 31, 35, 38, 41, 44, 45, 49, 51, 53, 55, 57, 59, 60,
62, 62, 63, 63, 64, 64, 64, 65, 65, 66, 64, 64, 64, 63, 63, 62, 61, 59, 57, 56,
54, 51, 49, 46, 44, 40, 38, 35, 32, 29, 26, 23, 20, 16, 12, 10, 6, 2, -1, -4,
-7, -10, -13, -15, -17, -19, -21, -23, -24, -25, -27, -28, -29, -29, -29, -30,
-29, -29, -28, -27, -26, -24, -22, -19, -17, -14, -11, -8, -6, -4, -1, 2, 5, 8,
11, 16, 19, 23, 26, 30, 35, 39, 44, 47, 53, 57, 60, 64, 68, 71, 75, 78, 80, 81,
84, 85, 86, 88, 89, 89, 90, 90, 90, 91, 90, 89, 88, 86, 76, 64, 55, 52, 48, 49,
48, 47, 47, 45, 44, 43, 41, 38, 37, 34, 32, 29, 27, 24, 22, 18, 16, 12, 10, 8,
5, 3, 1, -1, -2, -4, -6, -8, -10, -11, -14, -17, -20, -22, -24, -28, -30, -33,
-36, -38, -41, -43, -45, -48, -50, -51, -53, -56, -57, -58, -59, -59, -60, -60,
-61, -62, -61, -61, -61, -60, -60, -59, -59, -57, -56, -54, -51, -50, -49, -46,
-43, -40, -37, -33, -30, -27, -22, -18, -16, -11, -8, -4, -1, };