#define DATA_LENGTH 512
#define DATA AKWF_1270

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 9, 14, 18, 18, 24, 42, 71, 93, 97,
92, 82, 80, 90, 103, 111, 114, 114, 112, 111, 113, 115, 118, 119, 119, 117, 116,
114, 113, 113, 111, 110, 108, 105, 102, 99, 96, 94, 91, 88, 83, 79, 77, 74, 74,
72, 63, 48, 33, 28, 33, 40, 41, 37, 27, 19, 18, 19, 22, 23, 23, 22, 21, 20, 22,
23, 24, 25, 26, 26, 26, 27, 27, 27, 27, 26, 25, 24, 22, 20, 19, 17, 14, 12, 8,
6, 2, -1, -4, -7, -11, -15, -17, -21, -23, -27, -30, -33, -36, -39, -42, -44,
-47, -49, -51, -54, -55, -57, -59, -60, -62, -62, -63, -63, -63, -64, -63, -62,
-61, -60, -58, -56, -53, -50, -48, -44, -41, -37, -34, -29, -26, -22, -17, -14,
-10, -6, -3, 1, 4, 6, 9, 12, 14, 17, 19, 20, 22, 23, 23, 24, 23, 23, 23, 22, 21,
19, 17, 16, 15, 13, 10, 8, 4, 2, -1, -4, -6, -10, -12, -15, -18, -21, -25, -27,
-30, -33, -34, -37, -38, -41, -42, -44, -44, -45, -46, -46, -46, -46, -45, -45,
-44, -43, -41, -40, -39, -37, -36, -34, -33, -32, -30, -29, -28, -27, -27, -27,
-27, -27, -27, -27, -29, -29, -29, -31, -31, -34, -34, -36, -38, -39, -40, -42,
-43, -45, -45, -47, -48, -49, -51, -52, -53, -54, -55, -55, -56, -56, -57, -56,
-56, -55, -55, -53, -52, -51, -49, -46, -43, -40, -37, -32, -29, -24, -18, -15,
-9, -5, 1, 5, 8, 9, 9, 14, 35, 75, 100, 103, 93, 80, 78, 90, 105, 113, 115, 112,
109, 109, 110, 114, 116, 116, 116, 113, 110, 109, 108, 107, 106, 105, 101, 97,
96, 92, 90, 87, 84, 80, 76, 74, 70, 67, 64, 61, 57, 54, 50, 48, 44, 42, 39, 37,
36, 34, 32, 30, 30, 30, 29, 28, 28, 28, 28, 29, 29, 28, 30, 28, 28, 29, 28, 27,
27, 27, 24, 24, 23, 21, 18, 16, 14, 12, 9, 7, 3, 1, -2, -6, -9, -12, -15, -18,
-21, -25, -28, -32, -34, -38, -41, -44, -47, -51, -53, -56, -58, -60, -62, -65,
-66, -67, -69, -70, -70, -71, -70, -70, -68, -66, -64, -62, -58, -56, -52, -48,
-43, -39, -35, -31, -26, -22, -19, -14, -10, -7, -3, 0, 2, 5, 8, 10, 12, 14, 16,
17, 17, 18, 18, 19, 19, 18, 18, 17, 16, 16, 14, 13, 11, 10, 8, 6, 4, 1, 0, -3,
-6, -8, -11, -14, -16, -19, -22, -25, -27, -30, -31, -33, -35, -37, -38, -40,
-41, -42, -42, -42, -42, -41, -42, -41, -39, -39, -37, -35, -34, -32, -31, -30,
-28, -26, -25, -24, -23, -22, -21, -21, -21, -22, -22, -22, -23, -23, -24, -25,
-27, -28, -30, -32, -31, -31, -29, -33, -42, -57, -68, -67, -60, -53, -55, -63,
-70, -73, -73, -72, -70, -68, -69, -70, -70, -69, -68, -65, -62, -59, -56, -53,
-50, -47, -41, -36, -31, -26, -20, -14, -8, -2, };