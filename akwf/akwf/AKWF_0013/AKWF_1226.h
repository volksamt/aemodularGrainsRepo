#define DATA_LENGTH 512
#define DATA AKWF_1226

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 19, 32, 44, 55, 65, 74, 83, 90, 96,
103, 106, 111, 113, 115, 117, 118, 119, 119, 119, 118, 118, 118, 117, 116, 115,
115, 113, 112, 112, 111, 110, 109, 108, 107, 107, 105, 105, 103, 103, 102, 102,
100, 99, 98, 96, 94, 93, 92, 89, 86, 82, 76, 70, 62, 56, 48, 40, 33, 26, 18, 11,
5, -1, -6, -12, -17, -20, -24, -28, -32, -34, -36, -39, -41, -42, -44, -45, -46,
-48, -50, -50, -51, -51, -52, -53, -53, -54, -54, -54, -55, -55, -56, -55, -56,
-54, -55, -54, -54, -53, -53, -52, -51, -50, -49, -48, -47, -46, -44, -42, -40,
-39, -37, -35, -34, -31, -29, -27, -26, -23, -21, -19, -16, -14, -13, -10, -8,
-6, -4, -1, 0, 3, 5, 8, 10, 11, 12, 14, 17, 18, 20, 22, 24, 25, 26, 28, 29, 31,
31, 33, 33, 34, 35, 36, 36, 37, 37, 38, 38, 38, 38, 38, 39, 38, 38, 38, 38, 37,
37, 36, 34, 34, 33, 33, 32, 31, 30, 29, 27, 26, 25, 24, 22, 22, 20, 18, 17, 15,
15, 13, 11, 11, 13, 15, 20, 25, 31, 38, 43, 49, 56, 61, 67, 73, 77, 81, 85, 88,
89, 91, 92, 93, 94, 95, 95, 94, 94, 93, 92, 91, 90, 90, 89, 88, 87, 85, 84, 84,
84, 82, 83, 83, 82, 81, 82, 81, 81, 80, 80, 81, 81, 81, 81, 81, 80, 80, 81, 80,
79, 73, 67, 56, 45, 32, 19, 7, -7, -21, -33, -45, -56, -66, -75, -84, -91, -97,
-103, -106, -111, -113, -117, -117, -118, -119, -119, -119, -119, -118, -117,
-117, -116, -115, -114, -113, -112, -112, -111, -109, -108, -108, -107, -106,
-106, -105, -103, -103, -102, -100, -99, -98, -97, -96, -95, -92, -91, -89, -86,
-80, -75, -70, -62, -55, -48, -39, -32, -25, -18, -11, -4, 1, 6, 12, 17, 21, 24,
28, 31, 35, 36, 38, 41, 42, 45, 45, 47, 48, 48, 50, 51, 52, 53, 53, 54, 54, 54,
55, 56, 55, 56, 56, 55, 55, 54, 54, 54, 54, 52, 51, 51, 50, 50, 47, 46, 45, 43,
42, 41, 39, 37, 35, 33, 31, 29, 27, 25, 23, 20, 19, 16, 14, 13, 9, 8, 5, 3, 1,
-1, -4, -5, -7, -10, -11, -13, -15, -17, -19, -21, -22, -23, -26, -27, -28, -29,
-30, -31, -32, -33, -34, -35, -36, -37, -37, -37, -37, -37, -38, -38, -38, -38,
-38, -37, -38, -37, -37, -36, -35, -35, -34, -33, -32, -31, -30, -30, -29, -27,
-27, -25, -24, -22, -21, -20, -18, -17, -16, -14, -12, -11, -11, -12, -16, -21,
-26, -32, -38, -44, -50, -56, -62, -68, -72, -77, -81, -85, -87, -90, -91, -93,
-94, -94, -94, -94, -93, -93, -93, -92, -91, -90, -89, -88, -87, -87, -86, -85,
-85, -84, -83, -83, -82, -82, -81, -82, -81, -81, -80, -80, -81, -80, -81, -81,
-81, -81, -80, -80, -81, -79, -72, -65, -55, -44, -31, -18, -5, };