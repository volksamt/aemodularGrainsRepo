#define DATA_LENGTH 512
#define DATA AKWF_1217

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 14, 18, 22, 26, 29, 34, 37,
42, 46, 50, 54, 58, 62, 66, 69, 73, 76, 79, 82, 85, 87, 89, 91, 94, 95, 98, 99,
101, 103, 104, 106, 106, 107, 108, 108, 107, 107, 107, 106, 105, 102, 100, 99,
96, 94, 91, 89, 85, 82, 78, 75, 72, 68, 64, 60, 55, 50, 44, 38, 33, 28, 22, 15,
10, 5, -1, -6, -11, -16, -20, -24, -27, -32, -33, -37, -37, -40, -40, -42, -43,
-43, -43, -43, -43, -44, -44, -44, -44, -44, -45, -46, -45, -46, -47, -48, -49,
-50, -52, -54, -56, -57, -58, -60, -62, -63, -63, -65, -66, -66, -65, -65, -63,
-61, -59, -56, -53, -49, -46, -42, -38, -34, -29, -25, -20, -16, -12, -9, -5,
-1, 3, 6, 10, 12, 16, 20, 23, 27, 30, 34, 38, 41, 44, 47, 51, 54, 57, 59, 62,
63, 64, 64, 65, 65, 65, 64, 64, 63, 62, 59, 57, 54, 51, 47, 44, 40, 36, 31, 27,
22, 17, 12, 6, 1, -4, -9, -14, -19, -24, -30, -34, -38, -43, -47, -50, -54, -57,
-59, -61, -63, -65, -66, -67, -65, -65, -64, -63, -61, -58, -56, -53, -49, -47,
-42, -38, -35, -32, -28, -24, -21, -17, -13, -10, -5, -2, 2, 6, 10, 13, 16, 19,
22, 25, 26, 28, 29, 31, 31, 31, 31, 29, 29, 28, 27, 26, 25, 24, 24, 22, 21, 20,
20, 20, 19, 20, 19, 19, 18, 18, 17, 16, 15, 13, 12, 10, 8, 5, 3, 1, -2, -4, -8,
-11, -13, -16, -18, -20, -22, -23, -25, -26, -28, -28, -29, -29, -30, -30, -30,
-29, -29, -27, -26, -25, -23, -20, -17, -14, -11, -7, -3, 2, 6, 10, 15, 19, 24,
29, 32, 36, 39, 43, 45, 48, 51, 53, 54, 55, 56, 56, 56, 57, 55, 55, 55, 53, 51,
49, 46, 45, 42, 39, 36, 34, 29, 26, 21, 18, 12, 8, 2, -3, -9, -15, -21, -27,
-33, -39, -46, -51, -56, -61, -66, -72, -74, -78, -81, -82, -84, -84, -84, -82,
-79, -76, -72, -68, -63, -57, -51, -45, -38, -32, -26, -19, -13, -7, -1, 4, 8,
13, 17, 20, 23, 25, 27, 29, 30, 31, 32, 31, 31, 31, 32, 31, 31, 30, 29, 30, 28,
27, 26, 25, 24, 24, 23, 21, 21, 20, 19, 19, 18, 18, 17, 17, 17, 17, 17, 17, 19,
19, 20, 21, 23, 24, 25, 27, 29, 29, 31, 32, 33, 34, 34, 35, 36, 37, 38, 38, 38,
37, 38, 38, 37, 37, 36, 36, 35, 34, 32, 31, 28, 26, 25, 22, 19, 17, 13, 10, 5,
1, -2, -7, -11, -17, -21, -27, -32, -38, -43, -49, -54, -60, -65, -71, -76, -82,
-86, -92, -96, -100, -104, -107, -110, -113, -115, -116, -118, -119, -120, -119,
-118, -118, -116, -114, -111, -108, -104, -101, -97, -91, -87, -83, -77, -73,
-67, -63, -58, -54, -49, -44, -41, -36, -32, -29, -25, -21, -17, -13, -9, -5,
-1, };