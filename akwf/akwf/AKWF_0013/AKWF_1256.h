#define DATA_LENGTH 512
#define DATA AKWF_1256

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 14, 17, 21, 23, 26, 30, 33,
36, 39, 43, 45, 49, 52, 55, 57, 60, 63, 66, 68, 71, 74, 76, 78, 80, 83, 85, 88,
89, 93, 94, 96, 98, 100, 102, 104, 106, 108, 110, 111, 113, 114, 115, 116, 118,
118, 119, 119, 118, 117, 115, 110, 108, 104, 99, 94, 89, 83, 78, 74, 68, 64, 59,
54, 50, 45, 41, 36, 31, 28, 23, 19, 15, 11, 7, 3, -1, -4, -9, -12, -15, -18,
-22, -25, -29, -31, -34, -38, -40, -43, -47, -48, -51, -54, -56, -58, -60, -62,
-63, -63, -64, -65, -67, -66, -66, -66, -65, -64, -62, -61, -59, -57, -55, -52,
-50, -47, -43, -40, -37, -32, -28, -24, -20, -16, -13, -8, -5, 0, 3, 6, 10, 14,
17, 20, 23, 27, 30, 34, 36, 39, 42, 46, 49, 52, 54, 56, 59, 63, 64, 67, 69, 72,
74, 76, 77, 80, 81, 84, 85, 86, 87, 87, 88, 87, 85, 82, 79, 76, 72, 68, 64, 59,
54, 50, 45, 41, 37, 33, 28, 24, 20, 15, 12, 8, 4, 0, -4, -7, -11, -15, -18, -22,
-25, -28, -32, -36, -38, -41, -44, -47, -51, -53, -56, -59, -61, -64, -67, -69,
-72, -75, -77, -79, -81, -83, -87, -88, -90, -92, -95, -96, -98, -101, -102,
-104, -105, -105, -106, -106, -105, -104, -101, -98, -93, -88, -84, -79, -74,
-69, -65, -60, -55, -51, -46, -42, -37, -33, -28, -24, -19, -15, -12, -8, -4,
-1, 5, 8, 11, 15, 18, 22, 25, 29, 32, 35, 38, 41, 44, 46, 51, 53, 56, 58, 61,
64, 67, 69, 72, 75, 77, 79, 81, 85, 87, 89, 91, 93, 95, 97, 98, 102, 103, 105,
106, 108, 109, 111, 114, 115, 116, 116, 118, 119, 119, 119, 118, 116, 114, 110,
106, 102, 98, 93, 87, 82, 77, 72, 68, 62, 58, 54, 50, 44, 39, 35, 31, 27, 23,
18, 14, 10, 7, 3, -1, -5, -8, -11, -16, -19, -22, -26, -29, -32, -35, -39, -41,
-44, -47, -49, -52, -55, -58, -61, -63, -65, -67, -69, -72, -74, -75, -77, -79,
-80, -82, -83, -84, -85, -86, -86, -87, -88, -87, -86, -84, -83, -80, -78, -73,
-70, -66, -62, -57, -53, -48, -44, -39, -36, -32, -27, -23, -19, -15, -11, -7,
-4, 1, 3, 8, 11, 15, 18, 21, 26, 28, 31, 35, 37, 41, 43, 46, 49, 52, 54, 58, 60,
62, 64, 67, 68, 69, 71, 72, 71, 71, 68, 66, 63, 58, 55, 50, 45, 42, 37, 33, 28,
24, 20, 17, 12, 8, 4, 1, -4, -7, -11, -15, -18, -22, -25, -29, -31, -35, -38,
-42, -44, -47, -49, -52, -56, -58, -61, -64, -66, -68, -72, -75, -77, -79, -82,
-84, -86, -88, -91, -92, -95, -97, -99, -100, -102, -103, -105, -106, -107,
-108, -107, -106, -106, -102, -99, -95, -90, -86, -81, -77, -71, -66, -61, -57,
-53, -47, -43, -38, -34, -30, -25, -21, -17, -13, -9, -5, -1, };