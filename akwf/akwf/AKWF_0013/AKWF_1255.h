#define DATA_LENGTH 512
#define DATA AKWF_1255

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 8, 11, 15, 17, 20, 22, 26, 29,
31, 34, 36, 39, 41, 43, 45, 49, 50, 53, 54, 57, 59, 62, 64, 65, 68, 69, 71, 73,
74, 76, 77, 79, 80, 82, 84, 84, 85, 85, 86, 86, 85, 85, 84, 81, 79, 77, 74, 72,
69, 67, 64, 62, 60, 57, 56, 54, 52, 50, 47, 45, 44, 41, 40, 38, 36, 34, 33, 30,
30, 27, 26, 24, 23, 21, 20, 18, 17, 14, 14, 13, 11, 10, 8, 7, 5, 4, 4, 2, 1, 0,
-2, -3, -5, -5, -6, -8, -8, -9, -10, -11, -12, -13, -14, -14, -16, -17, -17,
-18, -20, -19, -21, -21, -23, -23, -24, -25, -26, -26, -26, -28, -28, -29, -29,
-29, -31, -32, -32, -33, -33, -34, -34, -35, -36, -36, -37, -38, -38, -38, -39,
-40, -41, -43, -44, -47, -48, -51, -52, -54, -57, -58, -59, -62, -64, -66, -68,
-71, -72, -74, -75, -78, -79, -80, -83, -85, -86, -88, -90, -91, -93, -94, -95,
-97, -98, -100, -101, -102, -103, -105, -106, -107, -109, -110, -111, -112,
-114, -115, -116, -117, -118, -118, -116, -113, -111, -108, -105, -101, -98,
-93, -90, -85, -82, -77, -74, -75, -76, -78, -79, -79, -79, -78, -78, -74, -71,
-68, -63, -60, -57, -52, -48, -45, -42, -37, -34, -30, -26, -22, -19, -16, -13,
-9, -6, -3, 1, 4, 6, 10, 13, 16, 19, 22, 23, 27, 29, 31, 35, 37, 39, 42, 45, 46,
49, 51, 53, 56, 58, 59, 62, 63, 65, 68, 69, 70, 73, 74, 75, 76, 77, 79, 79, 80,
81, 81, 81, 80, 79, 78, 75, 73, 71, 68, 66, 64, 62, 60, 57, 56, 53, 51, 50, 48,
46, 44, 42, 40, 38, 36, 35, 33, 31, 30, 28, 26, 24, 22, 22, 21, 18, 17, 16, 14,
13, 11, 11, 8, 8, 6, 4, 3, 3, 1, 1, -1, -2, -2, -4, -5, -7, -8, -8, -9, -10,
-11, -12, -13, -13, -14, -16, -16, -17, -18, -19, -20, -21, -21, -22, -23, -24,
-24, -25, -26, -26, -27, -27, -29, -29, -30, -31, -31, -31, -32, -32, -33, -34,
-34, -34, -35, -36, -37, -36, -37, -38, -38, -38, -38, -40, -41, -40, -41, -41,
-41, -42, -42, -43, -44, -44, -44, -44, -44, -44, -45, -45, -46, -46, -46, -47,
-48, -48, -47, -48, -48, -49, -49, -49, -49, -50, -49, -50, -49, -51, -51, -51,
-51, -52, -51, -52, -52, -52, -53, -52, -53, -54, -55, -56, -57, -58, -59, -60,
-62, -64, -66, -67, -69, -71, -72, -74, -75, -77, -79, -80, -82, -83, -85, -87,
-88, -90, -91, -93, -94, -96, -97, -99, -100, -101, -103, -104, -105, -107,
-108, -109, -110, -112, -113, -114, -115, -117, -117, -119, -119, -118, -117,
-115, -112, -108, -105, -100, -97, -92, -91, -91, -93, -93, -94, -93, -92, -91,
-87, -85, -82, -77, -74, -70, -65, -62, -58, -53, -50, -45, -41, -38, -34, -30,
-27, -23, -21, -16, -13, -9, -7, -3, 0, };