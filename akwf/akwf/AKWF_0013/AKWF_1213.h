#define DATA_LENGTH 512
#define DATA AKWF_1213

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 12, 17, 22, 27, 33, 37, 43, 47,
51, 57, 60, 64, 67, 71, 74, 76, 80, 82, 84, 87, 89, 91, 94, 96, 98, 100, 103,
106, 106, 109, 110, 111, 113, 112, 113, 113, 112, 111, 111, 108, 106, 104, 102,
99, 96, 93, 89, 87, 83, 81, 77, 74, 71, 68, 65, 61, 56, 53, 47, 44, 38, 33, 28,
22, 17, 11, 5, -1, -7, -13, -18, -25, -29, -35, -40, -43, -49, -53, -58, -62,
-67, -72, -75, -81, -85, -89, -93, -97, -100, -104, -108, -111, -112, -115,
-117, -118, -119, -119, -119, -118, -118, -117, -115, -113, -111, -109, -107,
-105, -102, -99, -98, -95, -93, -90, -89, -86, -85, -82, -80, -77, -75, -73,
-71, -68, -67, -63, -60, -58, -55, -53, -49, -46, -42, -39, -36, -32, -28, -24,
-20, -17, -12, -9, -5, 0, 2, 6, 10, 14, 18, 19, 23, 25, 28, 30, 32, 34, 34, 36,
37, 37, 39, 39, 40, 41, 42, 42, 43, 43, 44, 46, 47, 49, 50, 53, 55, 58, 60, 61,
64, 67, 69, 71, 74, 76, 77, 79, 80, 81, 82, 83, 83, 83, 82, 82, 79, 77, 76, 73,
71, 67, 63, 61, 58, 55, 52, 49, 46, 43, 42, 39, 39, 38, 36, 35, 36, 35, 36, 37,
37, 39, 40, 40, 41, 41, 41, 41, 41, 40, 38, 38, 35, 33, 30, 27, 24, 19, 15, 11,
6, 1, -4, -9, -14, -19, -23, -27, -31, -35, -37, -40, -41, -42, -43, -42, -41,
-41, -40, -37, -35, -32, -29, -26, -23, -20, -16, -14, -12, -8, -7, -5, -4, -4,
-3, -3, -5, -6, -7, -9, -12, -13, -17, -19, -22, -25, -27, -28, -31, -32, -34,
-34, -35, -35, -35, -33, -32, -29, -27, -24, -22, -18, -15, -10, -6, -3, 1, 4,
9, 11, 14, 17, 19, 21, 22, 22, 23, 22, 21, 19, 18, 14, 11, 8, 4, 0, -5, -9, -13,
-16, -21, -25, -29, -32, -35, -37, -40, -42, -44, -45, -47, -48, -47, -47, -47,
-46, -45, -43, -42, -41, -39, -37, -35, -34, -32, -30, -30, -28, -27, -27, -26,
-25, -25, -25, -26, -26, -27, -26, -28, -28, -29, -30, -30, -31, -31, -30, -31,
-30, -29, -28, -26, -26, -23, -20, -17, -15, -12, -7, -5, 0, 3, 7, 11, 15, 20,
24, 28, 32, 37, 41, 44, 47, 51, 55, 58, 62, 63, 66, 67, 69, 70, 70, 71, 70, 70,
69, 68, 67, 65, 63, 63, 61, 58, 57, 55, 53, 51, 49, 48, 45, 42, 40, 37, 33, 31,
27, 24, 21, 16, 13, 10, 7, 3, -1, -4, -8, -11, -14, -16, -20, -22, -26, -28,
-31, -34, -36, -41, -43, -47, -50, -53, -56, -60, -63, -66, -69, -72, -74, -77,
-78, -79, -80, -82, -81, -81, -82, -80, -80, -79, -78, -77, -76, -75, -75, -73,
-71, -70, -68, -66, -65, -63, -60, -57, -54, -51, -49, -46, -43, -40, -38, -36,
-32, -30, -27, -25, -22, -19, -17, -12, -9, -5, -1, };