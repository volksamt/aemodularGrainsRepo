#define DATA_LENGTH 512
#define DATA AKWF_1297

const PROGMEM int8_t DATA[DATA_LENGTH] = {59, 71, 64, 67, 64, 66, 62, 65, 61,
64, 61, 62, 60, 60, 59, 59, 58, 58, 57, 56, 56, 55, 55, 55, 54, 53, 52, 53, 53,
50, 51, 50, 50, 49, 50, 48, 48, 48, 47, 47, 46, 46, 46, 45, 45, 45, 43, 43, 43,
43, 42, 42, 41, 41, 40, 40, 40, 39, 38, 38, 38, 37, 37, 37, 37, 37, 37, 36, 35,
34, 34, 34, 33, 34, 34, 33, 33, 32, 33, 31, 32, 31, 31, 30, 30, 30, 30, 30, 29,
29, 29, 29, 28, 28, 28, 27, 27, 26, 27, 27, 26, 26, 26, 25, 25, 24, 25, 24, 23,
24, 24, 23, 22, 22, 23, 22, 22, 22, 22, 22, 22, 21, 21, 20, 20, 20, 20, 20, 20,
20, 19, 20, 19, 19, 19, 19, 18, 18, 18, 18, 17, 17, 18, 17, 17, 17, 16, 17, 17,
16, 16, 16, 16, 16, 15, 16, 16, 15, 15, 15, 15, 15, 15, 13, 14, 14, 15, 13, 14,
13, 14, 13, 13, 13, 13, 13, 13, 13, 11, 13, 11, 14, 9, 15, 7, 17, 3, 27, -43,
-127, -109, -121, -112, -116, -112, -112, -110, -110, -109, -108, -107, -105,
-105, -102, -103, -101, -102, -98, -99, -97, -97, -95, -95, -93, -93, -91, -92,
-90, -90, -89, -88, -88, -86, -86, -84, -84, -82, -83, -81, -80, -80, -80, -78,
-78, -76, -76, -76, -74, -75, -73, -73, -71, -72, -69, -71, -67, -71, -67, -69,
-65, -69, -62, -68, -60, -69, -55, 67, 69, 64, 67, 63, 66, 62, 65, 60, 64, 60,
63, 59, 61, 59, 59, 58, 58, 57, 56, 56, 56, 54, 54, 55, 53, 53, 52, 52, 51, 51,
50, 50, 49, 48, 48, 49, 48, 47, 46, 46, 45, 46, 45, 45, 44, 44, 43, 42, 43, 41,
41, 41, 41, 40, 40, 40, 40, 39, 38, 39, 37, 38, 38, 36, 36, 37, 35, 35, 35, 35,
35, 34, 33, 33, 33, 33, 32, 31, 32, 32, 31, 31, 30, 31, 30, 30, 30, 29, 29, 29,
29, 27, 28, 28, 27, 27, 27, 27, 26, 26, 25, 26, 25, 24, 25, 25, 24, 23, 24, 23,
23, 23, 24, 23, 22, 23, 22, 22, 22, 22, 21, 20, 21, 21, 21, 20, 19, 20, 20, 19,
19, 19, 20, 19, 19, 18, 18, 18, 18, 18, 18, 17, 17, 17, 17, 16, 17, 17, 16, 16,
16, 16, 16, 16, 15, 15, 15, 16, 15, 15, 14, 15, 14, 15, 14, 15, 13, 14, 12, 14,
12, 14, 12, 13, 12, 12, 13, 12, 12, 11, 13, 9, 14, 7, 17, 3, 27, -57, -127,
-108, -121, -111, -116, -110, -113, -110, -110, -108, -109, -107, -106, -104,
-103, -103, -100, -100, -100, -100, -97, -98, -96, -96, -94, -94, -92, -91, -91,
-90, -89, -89, -88, -87, -86, -85, -84, -82, -82, -81, -81, -80, -79, -78, -78,
-76, -76, -75, -75, -74, -73, -72, -72, -72, -70, -71, -69, -70, -67, -68, -66,
-67, -64, -67, -61, -67, -54, };