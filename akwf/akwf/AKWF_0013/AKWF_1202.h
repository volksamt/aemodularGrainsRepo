#define DATA_LENGTH 512
#define DATA AKWF_1202

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 10, 16, 23, 29, 34, 39, 46, 50, 55,
61, 66, 70, 75, 79, 84, 88, 91, 96, 99, 102, 104, 108, 109, 111, 114, 116, 117,
118, 118, 119, 119, 119, 120, 118, 118, 116, 115, 114, 112, 110, 108, 106, 103,
100, 99, 96, 92, 91, 86, 84, 80, 76, 74, 70, 66, 62, 58, 55, 52, 48, 45, 42, 37,
35, 32, 29, 26, 22, 20, 18, 16, 14, 11, 10, 8, 6, 5, 3, 3, 2, 1, 0, 0, 0, -1, 0,
1, 1, 2, 3, 4, 5, 6, 7, 8, 10, 11, 13, 15, 17, 18, 20, 22, 24, 26, 28, 30, 32,
34, 36, 37, 40, 41, 42, 44, 45, 46, 48, 49, 49, 51, 52, 52, 53, 53, 54, 53, 54,
53, 53, 53, 52, 52, 50, 49, 48, 47, 46, 44, 43, 41, 40, 37, 36, 34, 32, 30, 29,
26, 25, 22, 21, 19, 16, 16, 14, 11, 10, 9, 8, 6, 5, 4, 2, 1, 1, 1, 0, 0, 0, -1,
1, 1, 2, 3, 4, 5, 5, 7, 9, 10, 13, 16, 18, 20, 22, 26, 29, 31, 35, 37, 41, 45,
47, 51, 54, 58, 61, 65, 68, 72, 75, 79, 83, 86, 89, 93, 95, 98, 101, 103, 106,
108, 110, 112, 114, 115, 117, 118, 118, 118, 120, 119, 119, 118, 118, 117, 116,
113, 112, 110, 107, 105, 102, 99, 97, 92, 89, 85, 80, 76, 71, 67, 62, 57, 52,
46, 40, 35, 29, 24, 18, 12, 6, 0, -5, -11, -18, -23, -30, -35, -40, -46, -52,
-56, -61, -66, -71, -75, -81, -84, -88, -92, -95, -99, -102, -106, -107, -110,
-112, -114, -115, -116, -117, -118, -119, -119, -119, -120, -118, -117, -117,
-116, -115, -112, -110, -108, -105, -103, -101, -98, -95, -92, -89, -85, -83,
-79, -76, -73, -69, -66, -62, -59, -55, -51, -47, -44, -41, -38, -35, -31, -28,
-26, -23, -20, -17, -15, -13, -11, -9, -7, -5, -5, -3, -3, -1, 0, 0, 0, 0, 0, 0,
0, -1, -2, -2, -3, -5, -5, -7, -8, -9, -12, -13, -15, -17, -19, -20, -22, -25,
-27, -29, -31, -32, -34, -36, -37, -39, -41, -43, -44, -46, -47, -48, -50, -50,
-51, -51, -52, -53, -53, -53, -53, -53, -54, -52, -52, -52, -51, -50, -49, -48,
-47, -46, -43, -43, -41, -39, -38, -35, -34, -31, -30, -28, -26, -24, -22, -21,
-18, -17, -14, -14, -12, -10, -8, -8, -5, -5, -4, -3, -1, -1, -1, -1, -1, 0, -1,
-1, -1, -2, -3, -3, -5, -6, -7, -9, -11, -13, -16, -18, -20, -23, -26, -29, -32,
-35, -38, -41, -44, -48, -51, -55, -58, -61, -66, -69, -72, -76, -80, -83, -87,
-90, -93, -96, -98, -102, -104, -106, -108, -111, -113, -114, -115, -117, -117,
-118, -118, -118, -120, -119, -119, -118, -117, -115, -114, -112, -110, -108,
-105, -102, -99, -95, -92, -88, -84, -80, -76, -70, -66, -61, -56, -51, -46,
-40, -34, -29, -24, -17, -11, -5, 1, };