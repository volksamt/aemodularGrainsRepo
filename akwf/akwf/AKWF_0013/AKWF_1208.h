#define DATA_LENGTH 512
#define DATA AKWF_1208

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 11, 13, 15, 17, 21, 23, 26,
28, 29, 31, 35, 35, 37, 40, 41, 43, 44, 45, 46, 47, 48, 49, 50, 51, 50, 52, 52,
52, 52, 52, 52, 52, 52, 51, 51, 50, 50, 49, 48, 48, 46, 45, 45, 43, 42, 40, 40,
38, 36, 34, 34, 32, 31, 29, 27, 26, 23, 22, 21, 18, 16, 15, 13, 12, 9, 7, 6, 4,
3, 2, 0, -2, -3, -5, -7, -8, -10, -11, -12, -13, -14, -15, -16, -17, -19, -20,
-22, -21, -23, -23, -25, -25, -26, -26, -26, -26, -27, -27, -27, -28, -28, -28,
-27, -28, -27, -27, -27, -27, -26, -26, -26, -25, -25, -24, -24, -23, -23, -21,
-21, -20, -20, -18, -17, -17, -16, -15, -14, -12, -12, -11, -10, -9, -8, -6, -6,
-4, -3, -2, -1, 0, 0, 1, 2, 4, 5, 5, 6, 8, 8, 10, 11, 11, 12, 12, 12, 14, 15,
15, 16, 16, 16, 17, 18, 18, 18, 19, 19, 19, 19, 20, 20, 20, 20, 21, 20, 21, 21,
20, 20, 20, 20, 20, 20, 19, 19, 19, 18, 18, 18, 18, 17, 17, 16, 16, 16, 14, 13,
14, 13, 12, 13, 10, 10, 10, 9, 9, 8, 8, 6, 6, 6, 5, 4, 4, 3, 3, 2, 1, 0, 0, -1,
-1, -1, -2, -3, -4, -4, -4, -6, -6, -7, -7, -7, -8, -8, -9, -9, -9, -10, -10,
-10, -11, -12, -12, -12, -12, -12, -12, -13, -12, -12, -13, -13, -13, -13, -13,
-13, -12, -13, -13, -13, -13, -12, -13, -13, -13, -12, -12, -12, -12, -11, -11,
-11, -11, -11, -10, -11, -9, -9, -8, -9, -8, -7, -7, -8, -7, -6, -6, -6, -7, -5,
-5, -5, -4, -4, -4, -3, -4, -3, -2, -2, -2, -2, -2, -1, -1, -1, 0, 0, 0, 1, 0,
1, 1, 1, 2, 2, 2, 3, 3, 3, 3, 4, 3, 3, 3, 4, 3, 4, 4, 4, 3, 4, 4, 4, 4, 3, 4, 3,
4, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 2, 2, 2, 2, 2, 1, 2, 1, 1, 1, 1, 1, 1, 1, 0,
0, -1, 0, 0, 0, -1, -1, -1, -2, -2, -2, -1, -2, -2, -1, -2, -2, -3, -3, -3, -2,
-3, -4, -3, -3, -3, -3, -4, -3, -3, -4, -3, -4, -3, -3, -3, -4, -3, -3, -3, -4,
-3, -3, -4, -3, -3, -3, -3, -3, -3, -2, -3, -3, -3, -2, -2, -3, -3, -2, -1, -2,
-1, -2, -2, -2, -1, -2, -2, -1, -1, -2, -1, -2, 0, -1, -1, -1, -1, -1, -1, -1,
0, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 1, 0, 1, 0, 1, 1, 0, 1, 1, 1, 2, 1, 2, 2, 1, 2,
1, 1, -5, -54, -111, -118, -92, -68, -60, -63, -68, -71, -69, -65, -61, -56,
-53, -50, -49, -46, -44, -40, -37, -34, -31, -27, -24, -21, -18, -16, -13, -10,
-6, -3, -1, };