#define DATA_LENGTH 512
#define DATA AKWF_1214

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 6, 8, 10, 12, 16, 17, 20, 23,
25, 29, 30, 33, 37, 39, 42, 45, 47, 50, 53, 55, 59, 61, 63, 67, 68, 71, 74, 77,
79, 81, 83, 85, 88, 90, 92, 94, 96, 98, 100, 102, 102, 104, 105, 107, 109, 110,
111, 113, 113, 114, 116, 116, 116, 117, 118, 118, 119, 118, 119, 119, 119, 119,
119, 118, 119, 118, 119, 118, 117, 116, 116, 116, 115, 114, 113, 112, 111, 110,
109, 108, 107, 106, 105, 104, 103, 101, 99, 99, 97, 96, 94, 93, 90, 90, 88, 86,
84, 82, 81, 79, 77, 76, 73, 72, 70, 69, 66, 65, 63, 62, 60, 58, 56, 55, 52, 51,
49, 47, 46, 45, 42, 41, 38, 36, 35, 33, 31, 28, 28, 25, 24, 22, 20, 19, 17, 15,
14, 12, 10, 9, 8, 6, 3, 1, 1, -2, -3, -4, -6, -7, -9, -11, -12, -14, -15, -16,
-17, -18, -21, -22, -23, -24, -25, -27, -27, -29, -30, -31, -33, -34, -36, -36,
-39, -38, -40, -41, -43, -44, -46, -47, -48, -49, -50, -51, -53, -53, -55, -55,
-57, -57, -58, -59, -61, -62, -62, -63, -64, -66, -66, -67, -68, -69, -70, -71,
-72, -74, -75, -75, -76, -77, -78, -80, -80, -80, -82, -83, -84, -84, -84, -85,
-86, -87, -87, -89, -89, -89, -90, -91, -91, -93, -93, -93, -94, -94, -96, -96,
-96, -97, -98, -97, -98, -99, -99, -100, -99, -100, -100, -100, -100, -101,
-100, -101, -100, -101, -100, -100, -100, -100, -99, -100, -99, -99, -99, -99,
-98, -98, -97, -98, -97, -96, -96, -96, -96, -95, -94, -93, -93, -93, -91, -90,
-90, -89, -88, -87, -87, -86, -85, -83, -83, -83, -82, -80, -79, -79, -78, -77,
-76, -74, -74, -73, -71, -70, -68, -68, -66, -65, -63, -61, -61, -59, -58, -56,
-56, -53, -52, -51, -50, -49, -48, -46, -45, -43, -43, -42, -41, -39, -39, -37,
-36, -35, -34, -32, -32, -31, -29, -28, -26, -26, -24, -24, -23, -21, -20, -18,
-18, -16, -16, -14, -13, -11, -10, -10, -7, -6, -5, -3, -3, -1, -1, 1, 3, 3, 6,
6, 7, 9, 10, 11, 12, 13, 15, 15, 18, 18, 18, 21, 21, 21, 23, 23, 25, 26, 27, 28,
29, 30, 31, 32, 34, 35, 36, 37, 38, 40, 40, 41, 43, 44, 44, 46, 46, 48, 49, 50,
51, 53, 54, 54, 55, 55, 56, 57, 57, 57, 58, 59, 58, 58, 59, 58, 58, 57, 57, 57,
56, 56, 55, 54, 53, 52, 51, 51, 50, 49, 48, 46, 45, 44, 42, 41, 40, 40, 37, 36,
34, 32, 30, 29, 28, 25, 24, 22, 20, 18, 15, 14, 12, 10, 9, 6, 4, 2, 0, -3, -4,
-6, -8, -10, -12, -14, -15, -18, -19, -20, -23, -23, -24, -25, -27, -28, -29,
-29, -30, -31, -31, -32, -32, -31, -31, -31, -31, -30, -29, -28, -27, -26, -25,
-24, -22, -21, -19, -17, -16, -15, -12, -10, -8, -6, -4, -1, };