#define DATA_LENGTH 512
#define DATA AKWF_1251

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -1, 1, -2, 1, -2, 2, -2, 1, -1, 1,
-1, 1, -1, 0, 1, -5, 97, 119, 108, 116, 109, 115, 110, 115, 111, 114, 111, 113,
111, 114, 111, 113, 111, 113, 112, 112, 112, 115, 120, 118, 119, 118, 119, 118,
119, 118, 118, 119, 119, 118, 119, 118, 119, 118, 119, 119, 118, 119, 119, 119,
118, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119, 118, 119, 118, 119, 119,
119, 118, 119, 119, 118, 118, 119, 118, 118, 119, 119, 119, 119, 118, 118, 120,
119, 119, 119, 119, 118, 119, 112, 112, 112, 112, 112, 112, 112, 113, 112, 111,
114, 111, 114, 110, 114, 109, 117, 106, 124, 72, -12, 6, -2, 1, 0, -1, 3, -3, 6,
-8, 14, -47, -125, -106, -115, -110, -113, -112, -112, -112, -112, -112, -112,
-114, -111, -113, -112, -113, -111, -113, -112, -113, -111, -112, -113, -113,
-112, -113, -112, -112, -112, -111, -112, -112, -112, -112, -112, -112, -112,
-112, -113, -112, -112, -111, -112, -112, -111, -112, -112, -112, -112, -112,
-113, -112, -112, -112, -112, -111, -112, -111, -113, -112, -112, -112, -113,
-112, -112, -112, -112, -112, -112, -112, -113, -112, -112, -112, -112, -112,
-112, -112, -112, -111, -112, -112, -112, -112, -112, -112, -113, -112, -112,
-112, -111, -112, -113, -113, -113, -112, -113, -112, -112, -112, -113, -112,
-113, -112, -112, -111, -117, -119, -118, -119, -118, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -119, -118, -118, -119, -118, -118, -119, -119, -118, -118,
-119, -118, -119, -118, -119, -119, -114, -111, -113, -111, -113, -112, -113,
-111, -112, -112, -112, -111, -113, -113, -112, -112, -112, -113, -110, -113,
-109, -115, -109, -117, -105, -125, -66, 13, -7, 4, -2, 2, -2, 0, -1, 0, 0, 0,
1, 0, 0, -1, 0, -2, 1, -1, 1, 0, 0, -1, 0, 0, 1, -1, 1, 0, -1, -1, 0, 0, 0, 0,
0, 0, 0, 0, 0, 1, -1, 1, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, -1, 1,
-1, 2, -2, 3, -4, 5, -7, 12, -36, -124, -106, -116, -111, -113, -111, -112,
-112, -112, -113, -112, -113, -112, -113, -111, -112, -111, -113, -111, -113,
-112, -120, -119, -120, -119, -119, -118, -119, -118, -119, -118, -118, -119,
-119, -119, -118, -119, -119, -119, -118, -120, -118, -119, -119, -119, -119,
-118, -119, -118, -119, -119, -118, -118, -120, -119, -119, -118, -119, -119,
-118, -119, -119, -119, -119, -119, -119, -118, -118, -120, -119, -118, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -118, -118, -118, -119, -118, -118, -118, -119, -118, -119,
-118, -118, -119, -118, -119, -119, -119, -119, -118, -119, -118, -120, -119,
-119, -119, -118, -118, -119, -118, -119, -119, -119, -119, -119, -115, -111,
-114, -111, -114, -111, -114, -110, -114, -110, -115, -108, -115, -107, -119,
-96, };