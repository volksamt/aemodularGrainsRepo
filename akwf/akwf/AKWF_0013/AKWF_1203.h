#define DATA_LENGTH 512
#define DATA AKWF_1203

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 13, 17, 22, 26, 30, 35, 38,
44, 48, 52, 56, 59, 64, 69, 72, 77, 80, 83, 87, 90, 94, 96, 100, 103, 105, 107,
109, 112, 114, 115, 116, 117, 117, 119, 119, 118, 119, 119, 119, 117, 117, 115,
115, 112, 111, 108, 107, 104, 101, 99, 96, 93, 90, 87, 83, 81, 77, 72, 69, 65,
62, 58, 53, 50, 46, 42, 38, 34, 30, 27, 23, 20, 17, 13, 9, 6, 3, 0, -3, -6, -8,
-11, -13, -16, -18, -19, -22, -22, -24, -25, -26, -28, -29, -28, -30, -31, -31,
-31, -31, -30, -31, -30, -30, -29, -29, -28, -28, -27, -26, -25, -24, -23, -22,
-22, -22, -20, -19, -19, -17, -16, -16, -16, -15, -14, -14, -13, -13, -13, -13,
-13, -13, -14, -14, -14, -15, -15, -17, -16, -18, -19, -20, -22, -23, -25, -25,
-28, -30, -31, -32, -35, -37, -39, -41, -43, -45, -47, -49, -51, -53, -55, -56,
-59, -61, -64, -65, -67, -68, -69, -71, -71, -73, -74, -76, -77, -76, -77, -77,
-78, -77, -77, -77, -76, -75, -75, -75, -72, -71, -70, -69, -66, -65, -63, -60,
-58, -55, -52, -51, -48, -45, -42, -38, -35, -32, -29, -25, -22, -18, -15, -11,
-8, -5, -2, 2, 5, 9, 11, 13, 17, 19, 21, 25, 26, 29, 32, 33, 35, 37, 37, 38, 39,
40, 40, 40, 41, 40, 40, 39, 39, 38, 36, 34, 33, 31, 29, 26, 24, 21, 18, 16, 12,
8, 5, 2, -1, -6, -10, -14, -17, -22, -27, -31, -35, -39, -44, -48, -52, -57,
-61, -65, -69, -73, -76, -81, -85, -88, -91, -93, -97, -100, -103, -105, -107,
-110, -112, -114, -115, -116, -117, -118, -119, -118, -119, -119, -119, -118,
-118, -117, -115, -113, -112, -110, -108, -106, -103, -100, -98, -96, -93, -89,
-87, -83, -80, -77, -72, -68, -65, -62, -57, -53, -49, -46, -42, -39, -34, -30,
-27, -23, -19, -15, -12, -9, -6, -3, 1, 3, 6, 9, 11, 13, 15, 17, 20, 21, 23, 24,
25, 27, 28, 29, 30, 30, 31, 31, 30, 31, 31, 30, 30, 30, 29, 30, 29, 28, 27, 25,
25, 24, 23, 23, 22, 21, 20, 19, 19, 17, 16, 16, 15, 15, 15, 14, 13, 14, 12, 13,
14, 14, 13, 14, 15, 15, 15, 16, 17, 17, 20, 21, 22, 23, 24, 26, 28, 29, 31, 33,
35, 38, 39, 41, 43, 45, 47, 49, 52, 53, 55, 58, 59, 61, 63, 64, 66, 68, 69, 71,
72, 74, 75, 75, 77, 77, 77, 77, 77, 77, 77, 78, 76, 75, 75, 74, 73, 71, 70, 69,
67, 64, 62, 60, 58, 55, 53, 49, 47, 45, 42, 38, 34, 31, 29, 25, 21, 18, 15, 11,
8, 4, 1, -2, -5, -8, -11, -14, -17, -20, -23, -25, -27, -30, -32, -33, -35, -37,
-37, -38, -40, -40, -40, -41, -40, -40, -40, -40, -38, -38, -36, -34, -33, -31,
-29, -27, -24, -22, -18, -15, -11, -8, -5, -1, };