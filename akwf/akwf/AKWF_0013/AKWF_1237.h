#define DATA_LENGTH 512
#define DATA AKWF_1237

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 16, 28, 35, 39, 37, 34, 29, 25, 24,
21, 19, 17, 13, 9, 5, 2, 1, 2, 5, 12, 18, 23, 28, 33, 34, 35, 33, 33, 31, 30,
28, 27, 25, 25, 24, 23, 25, 26, 29, 34, 37, 39, 40, 38, 36, 38, 36, 35, 31, 27,
24, 24, 21, 19, 16, 16, 14, 14, 14, 15, 15, 15, 16, 16, 19, 20, 20, 22, 23, 24,
27, 27, 28, 31, 35, 39, 40, 42, 44, 46, 47, 48, 49, 48, 50, 49, 47, 45, 43, 52,
70, 85, 90, 89, 78, 64, 47, 32, 19, 10, 3, -1, -3, -4, -5, -3, -7, -38, -73,
-103, -119, -114, -110, -95, -85, -81, -72, -77, -74, -63, -44, -35, -33, -45,
-66, -80, -75, -60, -41, -16, -5, -9, -24, -29, -38, -48, -47, -37, -42, -43,
-49, -68, -77, -74, -64, -58, -59, -60, -65, -54, -55, -45, -40, -34, 12, 19,
19, 21, 14, 10, 4, 1, -3, -4, -4, -4, -8, -11, -14, -10, -9, -12, -20, -27, -31,
-32, -28, -23, -15, -8, -3, 2, 6, 8, 11, 12, 13, 9, 1, -5, -6, 1, 9, 15, 20, 21,
20, 18, 16, 13, 13, 11, 9, 8, 6, 4, 2, 0, -2, -1, 1, 6, 9, 14, 16, 20, 13, -4,
15, 24, 26, 26, 19, 13, 6, 3, -2, -3, -4, -4, -9, -13, -14, -12, -9, -14, -23,
-32, -37, -38, -33, -26, -17, -10, -2, 4, 8, 11, 14, 17, 17, 12, 2, -5, -4, 2,
11, 20, 25, 27, 26, 23, 20, 18, 16, 14, 13, 12, 8, 4, 2, 0, 0, 0, 4, 7, 13, 17,
21, 23, 29, 31, 13, 14, 13, 12, 12, 10, 11, 10, 10, 9, 10, 11, 14, 15, 17, 17,
19, 17, 17, 17, 17, 15, 14, 12, 11, 9, 8, 8, 6, 6, 5, 5, 6, 5, 6, 6, 7, 6, 7, 8,
9, 10, 11, 11, 12, 13, 13, 16, 18, 20, 20, 21, 22, 24, 24, 24, 25, 24, 25, 25,
24, 23, 22, 27, 37, 47, 49, 47, 41, 33, 23, 15, 8, 3, -1, -3, -5, -5, -5, -3,
-8, -27, -47, -64, -71, -68, -65, -56, -52, -48, -44, -48, -45, -37, -27, -22,
-22, -30, -42, -50, -47, -36, -24, -9, -5, -9, -17, -20, -25, -30, -30, -24,
-26, -27, -32, -44, -48, -46, -40, -37, -38, -39, -40, -35, -34, -29, -26, -15,
22, 30, 33, 31, 24, 16, 8, 4, -1, -3, -4, -4, -9, -14, -17, -12, -11, -16, -28,
-37, -43, -44, -37, -29, -19, -9, 0, 5, 11, 15, 19, 21, 21, 14, 3, -7, -3, 5,
15, 25, 30, 32, 31, 28, 24, 21, 19, 17, 15, 13, 10, 7, 2, 2, 0, 2, 5, 11, 14,
22, 23, 31, 15, -4, 26, 36, 39, 37, 28, 20, 10, 5, 0, -2, -2, -4, -10, -16, -18,
-14, -11, -17, -32, -42, -49, -48, -43, -32, -21, -10, 0, 7, 14, 18, 22, 25, 25,
17, 2, -7, -4, };