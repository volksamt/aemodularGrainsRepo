#define DATA_LENGTH 512
#define DATA AKWF_1275

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 11, 15, 17, 19, 20, 22, 23, 25,
27, 29, 30, 31, 32, 32, 35, 34, 36, 36, 37, 38, 39, 40, 40, 42, 43, 43, 45, 45,
46, 47, 48, 49, 51, 51, 53, 54, 54, 55, 56, 57, 58, 60, 60, 62, 63, 64, 64, 65,
66, 68, 69, 70, 71, 72, 73, 73, 74, 76, 77, 78, 79, 80, 80, 81, 82, 83, 85, 85,
86, 87, 87, 88, 89, 90, 90, 91, 92, 93, 93, 94, 95, 95, 96, 96, 97, 97, 97, 99,
99, 99, 101, 99, 103, 100, 105, 77, 13, 0, 8, 17, 24, 26, 25, 20, 13, 6, -1, -9,
-14, -19, -23, -25, -26, -29, -30, -31, -32, -34, -35, -37, -38, -39, -40, -41,
-41, -41, -43, -43, -44, -45, -45, -45, -46, -47, -48, -49, -49, -50, -51, -52,
-53, -53, -54, -55, -55, -57, -58, -58, -60, -61, -62, -63, -64, -64, -66, -66,
-68, -68, -69, -70, -72, -72, -73, -75, -75, -76, -77, -78, -78, -80, -79, -84,
-42, 16, 18, 10, -1, -5, -7, -5, -1, 5, 13, 19, 26, 30, 35, 39, 40, 42, 43, 43,
44, 46, 47, 48, 49, 50, 51, 51, 52, 52, 53, 53, 53, 53, 54, 55, 54, 55, 55, 56,
57, 57, 59, 60, 59, 61, 60, 61, 62, 62, 63, 63, 65, 65, 66, 67, 69, 69, 70, 71,
71, 72, 72, 74, 75, 75, 76, 77, 77, 79, 80, 81, 81, 82, 83, 83, 84, 85, 86, 87,
87, 88, 89, 90, 90, 91, 91, 92, 92, 94, 94, 95, 95, 96, 97, 98, 97, 101, 65, 4,
-3, 6, 15, 22, 23, 21, 15, 9, 1, -5, -13, -17, -22, -25, -28, -30, -31, -32,
-34, -35, -37, -37, -38, -41, -41, -42, -42, -44, -44, -45, -44, -46, -46, -48,
-48, -49, -49, -49, -51, -50, -51, -52, -54, -54, -55, -56, -56, -58, -58, -59,
-59, -61, -62, -62, -64, -66, -65, -66, -68, -69, -70, -70, -71, -72, -73, -74,
-75, -76, -76, -77, -79, -80, -81, -81, -82, -83, -84, -85, -86, -86, -87, -87,
-89, -89, -90, -91, -91, -92, -92, -94, -94, -95, -96, -96, -96, -98, -98, -97,
-99, -99, -100, -100, -101, -101, -103, -102, -103, -103, -104, -104, -104,
-104, -105, -106, -106, -107, -107, -107, -107, -108, -109, -108, -109, -109,
-110, -109, -110, -111, -109, -110, -111, -111, -112, -112, -112, -113, -112,
-113, -113, -113, -113, -113, -114, -114, -113, -113, -115, -114, -114, -114,
-115, -115, -115, -115, -115, -115, -115, -115, -116, -116, -115, -116, -116,
-116, -116, -117, -117, -117, -117, -117, -117, -117, -117, -118, -117, -117,
-117, -118, -118, -117, -117, -118, -117, -118, -118, -118, -118, -118, -117,
-118, -118, -118, -118, -118, -118, -119, -118, -119, -119, -119, -118, -119,
-118, -118, -119, -119, -118, -118, -118, -119, -119, -119, -119, -118, -119,
-118, -118, -119, -119, -119, -119, -119, -120, -118, -122, -78, -19, -18, -25,
-34, -39, -40, -38, -32, -25, -16, -8, -2, };