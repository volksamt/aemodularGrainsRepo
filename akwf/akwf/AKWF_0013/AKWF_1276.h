#define DATA_LENGTH 512
#define DATA AKWF_1276

const PROGMEM int8_t DATA[DATA_LENGTH] = {52, 63, 58, 62, 59, 62, 59, 62, 60,
61, 61, 62, 62, 63, 64, 65, 66, 66, 68, 67, 70, 67, 73, 41, -19, -15, -15, -14,
-13, -13, -13, -10, -10, -8, -10, -7, -8, -5, -7, -4, -5, -3, -4, -3, -1, -5,
76, 95, 86, 93, 88, 93, 90, 93, 91, 94, 93, 94, 95, 95, 95, 95, 97, 96, 98, 96,
99, 96, 102, 76, 2, -6, -6, -10, -8, -12, -9, -13, -10, -12, -10, -12, -10, -10,
-9, -9, -10, -7, -10, -3, -19, 44, 91, 78, 86, 81, 86, 82, 85, 83, 89, 97, 105,
110, 113, 115, 117, 118, 118, 120, 119, 120, 119, 119, 118, 118, 118, 118, 117,
116, 115, 115, 114, 113, 114, 113, 111, 111, 112, 110, 110, 109, 109, 108, 108,
107, 107, 105, 106, 105, 104, 104, 104, 103, 102, 102, 102, 101, 101, 100, 99,
100, 99, 100, 96, 98, 94, 99, 51, -1, 8, 3, 6, 3, 4, 3, 3, 2, 2, 2, 0, 1, 0, -1,
-2, -1, -3, -3, -3, -3, -4, -5, -5, -6, -7, -7, -7, -8, -9, -8, -10, -10, -10,
-12, -12, -12, -12, -12, -23, -38, -49, -58, -61, -65, -67, -69, -71, -72, -72,
-73, -73, -73, -74, -73, -73, -74, -73, -74, -73, -73, -73, -72, -73, -72, -72,
-71, -72, -72, -71, -72, -71, -71, -72, -72, -72, -72, -72, -72, -73, -73, -73,
-73, -73, -73, -74, -74, -73, -74, -75, -75, -75, -75, -75, -75, -75, -76, -76,
-76, -77, -77, -77, -78, -78, -78, -77, -78, -78, -78, -78, -79, -79, -79, -79,
-78, -79, -80, -80, -79, -81, -80, -80, -80, -80, -80, -80, -81, -81, -81, -81,
-82, -80, -81, -81, -80, -82, -82, -81, -81, -81, -81, -82, -80, -81, -81, -80,
-82, -81, -81, -82, -81, -80, -81, -80, -81, -79, -70, -63, -57, -52, -50, -49,
-48, -47, -46, -46, -45, -45, -45, -46, -45, -46, -45, -47, -46, -47, -47, -47,
-47, -47, -47, -48, -47, -47, -48, -48, -48, -48, -48, -48, -48, -48, -48, -49,
-47, -48, -48, -48, -48, -47, -47, -48, -47, -46, -50, -56, -61, -64, -66, -67,
-67, -67, -68, -68, -68, -69, -68, -68, -67, -66, -66, -65, -65, -64, -63, -63,
-63, -63, -62, -61, -61, -60, -59, -60, -59, -58, -58, -57, -56, -57, -56, -55,
-55, -55, -55, -55, -54, -53, -53, -53, -52, -52, -52, -52, -51, -50, -51, -51,
-50, -51, -50, -49, -49, -49, -49, -48, -47, -47, -47, -47, -46, -46, -46, -46,
-46, -45, -45, -45, -44, -45, -44, -44, -44, -43, -43, -42, -43, -43, -43, -43,
-41, -41, -41, -41, -40, -40, -40, -39, -39, -39, -39, -39, -39, -39, -38, -38,
-38, -38, -38, -37, -37, -36, -36, -37, -36, -36, -36, -35, -36, -36, -35, -35,
-34, -35, -34, -34, -34, -33, -33, -33, -33, -33, -33, -32, -33, -33, -33, -34,
-33, -34, -33, -34, -33, -33, -32, -32, -32, -31, -30, -32, -29, -31, -25, };