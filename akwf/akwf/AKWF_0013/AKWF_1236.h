#define DATA_LENGTH 512
#define DATA AKWF_1236

const PROGMEM int8_t DATA[DATA_LENGTH] = {66, 58, 59, 61, 58, 62, 58, 62, 58,
61, 57, 61, 58, 60, 58, 59, 58, 59, 58, 59, 58, 58, 59, 59, 59, 58, 59, 57, 57,
56, 58, 57, 57, 56, 57, 56, 57, 55, 56, 54, 56, 55, 55, 54, 55, 54, 55, 53, 53,
54, 53, 53, 51, 54, 51, 54, 50, 54, 47, 54, 45, 60, 0, -9, 65, 44, 53, 49, 50,
48, 49, 48, 47, 48, 47, 49, 46, 47, 45, 46, 45, 47, 45, 45, 44, 44, 42, 44, 43,
43, 42, 43, 42, 41, 41, 41, 40, 40, 39, 38, 39, 38, 38, 38, 36, 36, 36, 35, 35,
34, 35, 35, 34, 33, 34, 33, 33, 32, 32, 32, 31, 31, 30, 29, 29, 29, 28, 28, 27,
27, 28, 26, 27, 26, 25, 25, 24, 25, 25, 24, 23, 23, 23, 22, 22, 21, 21, 21, 20,
19, 20, 20, 19, 19, 18, 17, 18, 17, 18, 16, 16, 17, 15, 15, 15, 15, 15, 13, 14,
13, 13, 12, 12, 12, 12, 12, 10, 11, 11, 10, 10, 10, 10, 9, 9, 7, 8, -22, -70,
-72, -69, -70, -69, -70, -69, -69, -68, -69, -68, -67, -68, -67, -67, -67, -66,
-67, -66, -65, -66, -66, -65, -65, -65, -65, -66, -65, -65, -64, -64, -64, -64,
-64, -63, -63, -64, -63, -63, -63, -62, -63, -63, -63, -61, -62, -62, -62, -62,
-62, -61, -62, -61, -62, -61, -62, -62, -61, -61, -61, -62, -60, -61, -60, -62,
-57, -70, -10, 41, 26, 34, 30, 33, 30, 33, 32, 33, 34, 34, 34, 34, 35, 34, 35,
36, 36, 36, 37, 37, 39, 38, 38, 38, 39, 39, 40, 40, 39, 40, 41, 41, 42, 41, 42,
42, 42, 44, 43, 44, 43, 45, 44, 45, 44, 45, 45, 46, 45, 47, 46, 47, 47, 47, 49,
46, 50, 46, 52, 44, 58, -9, 0, 67, 44, 56, 49, 53, 51, 52, 51, 52, 53, 53, 54,
53, 54, 53, 55, 54, 55, 53, 55, 54, 55, 54, 56, 55, 57, 56, 56, 56, 55, 56, 56,
57, 56, 56, 56, 56, 56, 57, 56, 57, 56, 58, 57, 57, 57, 57, 57, 57, 57, 58, 58,
58, 58, 57, 58, 57, 58, 56, 58, 57, 60, 38, 22, 31, 29, 30, 30, 31, 31, 32, 31,
32, 32, 32, 32, 33, 33, 33, 34, 33, 34, 34, 35, 35, 36, 36, 36, 37, 37, 36, 38,
38, 39, 38, 39, 39, 39, 40, 40, 40, 41, 41, 41, 41, 43, 42, 42, 43, 43, 44, 43,
45, 43, 44, 45, 45, 44, 46, 45, 46, 46, 45, -26, -113, -109, -110, -111, -110,
-111, -111, -112, -111, -112, -112, -112, -112, -113, -113, -114, -113, -113,
-113, -114, -114, -114, -115, -115, -114, -115, -115, -115, -115, -115, -116,
-115, -116, -115, -116, -115, -116, -115, -117, -116, -116, -116, -116, -115,
-116, -117, -117, -117, -116, -118, -117, -118, -116, -117, -116, -118, -115,
-118, -114, -118, -115, -120, -115, -119, -114, -120, -110, -7, };