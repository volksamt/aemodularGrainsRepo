#define DATA_LENGTH 512
#define DATA AKWF_1253

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 7, 9, 12, 14, 17, 19, 21, 24,
25, 28, 29, 31, 34, 35, 37, 39, 41, 42, 44, 46, 48, 49, 51, 53, 55, 57, 58, 59,
60, 62, 63, 64, 67, 67, 69, 71, 71, 73, 73, 75, 77, 78, 79, 80, 81, 82, 83, 85,
85, 87, 88, 89, 89, 91, 92, 92, 93, 94, 95, 95, 97, 97, 98, 99, 100, 101, 101,
102, 104, 103, 105, 105, 105, 106, 107, 107, 108, 108, 110, 109, 110, 111, 113,
112, 114, 114, 114, 114, 115, 116, 117, 116, 117, 118, 118, 118, 119, 119, 115,
110, 105, 102, 96, 93, 89, 85, 80, 77, 74, 69, 65, 61, 58, 55, 51, 49, 45, 41,
38, 35, 32, 29, 26, 22, 20, 17, 15, 11, 8, 6, 3, 0, -2, -4, -6, -9, -12, -14,
-16, -18, -21, -22, -24, -27, -29, -31, -33, -35, -36, -38, -40, -42, -44, -45,
-47, -49, -50, -53, -54, -55, -56, -58, -60, -62, -63, -64, -67, -68, -69, -70,
-71, -73, -74, -75, -76, -77, -79, -80, -81, -82, -83, -83, -85, -86, -87, -89,
-90, -90, -90, -92, -93, -94, -94, -96, -96, -97, -98, -99, -100, -100, -102,
-102, -102, -103, -104, -105, -106, -106, -106, -107, -108, -108, -110, -110,
-109, -106, -101, -97, -93, -88, -85, -80, -76, -73, -68, -64, -62, -59, -54,
-51, -49, -44, -41, -38, -35, -31, -29, -26, -22, -21, -17, -14, -10, -8, -6,
-3, 0, 2, 5, 6, 8, 11, 14, 17, 18, 20, 22, 25, 26, 29, 31, 33, 35, 37, 38, 41,
43, 44, 46, 47, 49, 51, 52, 54, 56, 56, 54, 52, 47, 44, 42, 39, 34, 31, 29, 25,
23, 20, 17, 15, 12, 8, 6, 3, 0, -1, -4, -7, -9, -11, -13, -16, -18, -21, -23,
-25, -27, -28, -31, -32, -35, -37, -39, -41, -42, -44, -45, -47, -49, -51, -52,
-54, -55, -58, -58, -60, -62, -63, -64, -66, -67, -69, -70, -70, -68, -65, -61,
-58, -54, -51, -47, -44, -40, -37, -34, -31, -28, -26, -22, -19, -16, -14, -11,
-9, -6, -3, 0, 2, 5, 6, 10, 12, 14, 16, 18, 21, 23, 24, 27, 30, 30, 32, 35, 37,
40, 40, 42, 44, 46, 47, 50, 51, 52, 54, 56, 57, 58, 61, 62, 64, 65, 66, 67, 69,
70, 71, 73, 74, 75, 77, 78, 79, 79, 81, 83, 83, 84, 85, 86, 88, 88, 89, 90, 90,
92, 93, 95, 95, 95, 96, 97, 98, 99, 99, 101, 102, 102, 103, 103, 102, 99, 94,
90, 86, 82, 78, 75, 71, 67, 63, 60, 56, 52, 49, 46, 42, 39, 37, 33, 30, 27, 24,
21, 18, 15, 13, 10, 6, 4, 2, -1, -3, -6, -8, -10, -13, -15, -18, -20, -22, -23,
-26, -28, -30, -32, -33, -36, -38, -40, -41, -43, -45, -47, -49, -50, -52, -53,
-55, -56, -58, -56, -53, -49, -46, -43, -39, -36, -33, -30, -27, -24, -21, -19,
-15, -13, -10, -7, -5, -2, };