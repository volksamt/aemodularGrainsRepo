#define DATA_LENGTH 512
#define DATA AKWF_1220

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 11, 16, 20, 24, 27, 30, 32, 33,
32, 31, 30, 29, 26, 24, 21, 18, 16, 15, 14, 14, 15, 16, 19, 20, 23, 26, 28, 31,
34, 37, 40, 43, 46, 48, 51, 54, 56, 58, 61, 63, 66, 69, 72, 75, 79, 82, 87, 90,
93, 97, 102, 106, 109, 112, 112, 114, 114, 111, 110, 108, 104, 102, 99, 96, 95,
94, 93, 94, 95, 95, 97, 99, 101, 104, 104, 105, 106, 104, 103, 101, 99, 96, 93,
90, 87, 82, 78, 73, 69, 65, 58, 54, 49, 44, 38, 33, 28, 21, 16, 11, 6, 1, -3,
-8, -11, -14, -15, -15, -16, -14, -12, -11, -9, -6, -4, -2, 0, 0, 1, 1, 0, -1,
-3, -4, -8, -10, -13, -17, -19, -22, -24, -26, -28, -30, -31, -32, -32, -32,
-34, -33, -34, -34, -34, -33, -34, -35, -35, -37, -39, -41, -43, -46, -50, -53,
-56, -59, -62, -65, -67, -67, -67, -68, -66, -63, -61, -59, -56, -53, -51, -50,
-50, -50, -51, -53, -55, -58, -60, -62, -64, -65, -67, -67, -67, -68, -66, -64,
-63, -62, -59, -57, -53, -50, -46, -44, -39, -35, -31, -28, -23, -19, -16, -12,
-9, -7, -5, -4, -3, -4, -3, -5, -7, -9, -12, -14, -18, -20, -22, -22, -23, -22,
-22, -20, -17, -15, -13, -9, -7, -5, -1, 0, 2, 3, 4, 4, 5, 3, 3, 2, 0, -2, -2,
-5, -7, -9, -12, -14, -18, -19, -21, -23, -23, -25, -26, -25, -24, -23, -20,
-18, -14, -11, -9, -6, -4, -2, -1, -2, -3, -4, -6, -10, -11, -13, -15, -16, -16,
-16, -14, -13, -9, -7, -5, -1, 1, 5, 7, 9, 11, 12, 13, 14, 14, 13, 14, 12, 13,
11, 10, 9, 7, 7, 5, 4, 4, 4, 4, 4, 6, 7, 9, 12, 14, 18, 21, 25, 27, 30, 32, 34,
35, 35, 34, 32, 30, 29, 24, 21, 19, 16, 14, 12, 12, 11, 11, 12, 13, 14, 16, 17,
21, 24, 26, 30, 33, 37, 41, 45, 49, 55, 58, 62, 66, 70, 75, 78, 82, 84, 86, 86,
87, 86, 83, 82, 79, 77, 74, 72, 69, 67, 66, 65, 65, 67, 68, 71, 73, 74, 76, 77,
76, 76, 75, 73, 71, 67, 65, 61, 57, 54, 50, 47, 44, 40, 37, 35, 32, 31, 27, 26,
24, 22, 19, 17, 16, 13, 11, 8, 4, 0, -3, -8, -12, -16, -20, -24, -28, -31, -33,
-35, -36, -37, -37, -35, -33, -30, -27, -26, -23, -21, -18, -18, -17, -16, -18,
-19, -19, -21, -24, -27, -30, -33, -36, -40, -43, -47, -51, -54, -59, -62, -67,
-71, -76, -80, -85, -89, -94, -98, -103, -107, -111, -113, -116, -119, -119,
-119, -118, -117, -115, -111, -108, -105, -103, -100, -99, -98, -99, -100, -101,
-103, -104, -105, -107, -109, -109, -108, -108, -107, -104, -102, -99, -95, -92,
-87, -83, -80, -76, -70, -66, -62, -58, -54, -48, -44, -39, -35, -30, -24, -19,
-15, -10, -4, };