#define DATA_LENGTH 512
#define DATA AKWF_1212

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 9, 14, 18, 23, 28, 32, 37, 42,
46, 51, 56, 59, 63, 67, 72, 75, 78, 82, 85, 89, 92, 96, 101, 104, 107, 109, 112,
115, 116, 116, 117, 117, 118, 118, 118, 119, 120, 120, 119, 118, 118, 116, 115,
112, 110, 106, 104, 100, 97, 94, 91, 88, 85, 81, 78, 74, 69, 66, 61, 56, 51, 47,
42, 38, 35, 30, 26, 21, 17, 13, 9, 5, 0, -3, -7, -10, -15, -18, -22, -26, -30,
-34, -39, -43, -46, -50, -54, -57, -60, -63, -65, -68, -69, -70, -71, -72, -72,
-74, -75, -75, -77, -79, -81, -83, -84, -86, -87, -89, -88, -88, -87, -86, -84,
-82, -79, -77, -74, -73, -71, -69, -65, -63, -60, -59, -57, -56, -53, -52, -51,
-49, -48, -47, -45, -43, -41, -39, -36, -34, -30, -26, -22, -20, -17, -13, -10,
-7, -5, -5, -3, -1, 1, 2, 4, 5, 5, 6, 6, 7, 7, 7, 7, 7, 8, 9, 11, 13, 15, 18,
20, 23, 25, 28, 29, 30, 30, 30, 29, 27, 25, 23, 21, 19, 16, 14, 12, 10, 9, 8, 7,
6, 7, 8, 9, 10, 11, 13, 14, 15, 16, 16, 15, 15, 14, 12, 11, 10, 8, 6, 5, 3, 2,
1, 0, -2, -2, -2, -2, -3, -4, -3, -3, -3, -3, -3, -4, -5, -4, -5, -6, -6, -6,
-8, -8, -9, -9, -8, -8, -7, -6, -5, -3, 1, 3, 5, 9, 12, 15, 18, 20, 22, 24, 24,
24, 22, 22, 19, 18, 15, 11, 8, 5, 1, -3, -4, -6, -9, -11, -11, -12, -12, -11,
-10, -9, -8, -7, -4, -3, 0, 1, 4, 6, 8, 10, 13, 16, 17, 19, 21, 23, 25, 26, 27,
27, 27, 26, 25, 25, 22, 20, 16, 14, 11, 6, 2, -2, -7, -10, -14, -18, -21, -24,
-27, -28, -29, -29, -29, -28, -26, -24, -22, -19, -15, -11, -7, -2, 2, 7, 11,
16, 20, 22, 26, 29, 31, 33, 34, 33, 33, 32, 30, 27, 25, 21, 17, 14, 9, 4, -1,
-6, -11, -16, -20, -25, -29, -32, -34, -37, -38, -39, -39, -38, -37, -36, -33,
-31, -28, -24, -20, -16, -12, -8, -3, 0, 5, 9, 13, 15, 18, 20, 22, 23, 24, 25,
25, 25, 24, 23, 22, 20, 18, 16, 14, 12, 10, 8, 7, 5, 4, 3, 2, 2, 2, 3, 4, 5, 6,
9, 10, 13, 15, 18, 20, 24, 26, 29, 32, 34, 36, 39, 40, 42, 43, 43, 44, 43, 42,
42, 41, 39, 38, 36, 32, 29, 27, 23, 21, 18, 13, 10, 6, 3, -1, -5, -9, -12, -16,
-19, -23, -26, -29, -32, -35, -39, -41, -44, -46, -48, -51, -53, -54, -56, -57,
-59, -61, -63, -64, -65, -66, -68, -70, -72, -73, -74, -76, -77, -77, -77, -78,
-78, -79, -79, -79, -79, -79, -79, -78, -77, -77, -76, -74, -71, -70, -66, -64,
-60, -57, -54, -51, -47, -44, -41, -37, -34, -30, -26, -21, -16, -13, -8, -3, };