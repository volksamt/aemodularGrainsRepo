#define DATA_LENGTH 512
#define DATA AKWF_1287

const PROGMEM int8_t DATA[DATA_LENGTH] = {57, 84, 93, 107, 115, 119, 118, 113,
105, 96, 88, 83, 83, 87, 99, 107, 39, 34, 49, 47, 48, 39, 31, 18, 8, -2, -7, -8,
-7, -2, 1, 9, 91, 103, 92, 88, 77, 70, 61, 55, 51, 46, 45, 41, 36, 30, 26, 14,
-75, -93, -92, -94, -93, -90, -87, -84, -82, -83, -84, -88, -93, -95, -97, -91,
-4, 14, 16, 24, 25, 28, 24, 20, 14, 9, 7, 11, 20, 35, 55, 71, 11, 19, 39, 45,
49, 43, 36, 24, 13, 3, -4, -8, -8, -5, -4, 6, 89, 101, 94, 93, 87, 84, 82, 80,
80, 80, 80, 77, 76, 68, 62, 46, -47, -67, -72, -79, -83, -84, -83, -82, -82,
-81, -81, -78, -78, -72, -67, -49, 46, 68, 79, 92, 99, 103, 101, 95, 86, 76, 67,
61, 62, 64, 75, 77, 6, 5, 16, 14, 12, 2, -9, -22, -33, -42, -47, -48, -47, -40,
-38, -24, 60, 71, 63, 62, 55, 51, 46, 45, 44, 45, 48, 47, 50, 47, 48, 37, -48,
-57, -53, -52, -47, -42, -38, -33, -31, -29, -32, -36, -42, -45, -50, -41, 42,
52, 52, 54, 52, 47, 40, 30, 19, 9, 3, 1, 6, 14, 32, 39, -24, -16, -3, 1, 2, -6,
-16, -29, -41, -52, -58, -60, -61, -55, -55, -38, 46, 56, 52, 52, 50, 49, 49,
50, 51, 54, 57, 55, 55, 47, 44, 24, -68, -85, -91, -98, -101, -102, -104, -104,
-104, -105, -105, -106, -107, -101, -100, -79, 16, 33, 44, 56, 62, 66, 64, 58,
49, 40, 33, 29, 30, 35, 49, 50, -18, -12, -2, 0, 0, -8, -16, -27, -37, -43, -47,
-46, -43, -35, -35, -15, 68, 72, 66, 61, 54, 47, 41, 36, 34, 30, 30, 26, 25, 18,
18, -2, -89, -97, -98, -98, -96, -92, -89, -85, -83, -84, -87, -88, -94, -94,
-99, -83, 3, 12, 17, 22, 25, 25, 21, 15, 9, 4, 3, 5, 16, 27, 51, 57, -3, 11, 26,
32, 35, 29, 18, 7, -5, -15, -24, -27, -30, -24, -28, -8, 74, 76, 72, 68, 63, 59,
57, 54, 55, 55, 56, 53, 52, 42, 41, 15, -77, -88, -95, -99, -104, -103, -102,
-100, -99, -96, -96, -92, -91, -82, -80, -52, 44, 59, 74, 85, 94, 97, 96, 90,
82, 72, 64, 59, 60, 63, 77, 70, 1, 8, 14, 15, 10, 1, -10, -23, -36, -44, -50,
-50, -51, -43, -45, -23, 60, 59, 55, 50, 43, 37, 32, 28, 28, 25, 28, 25, 27, 20,
25, 1, -83, -87, -88, -86, -84, -79, -77, -73, -73, -73, -79, -81, -90, -92,
-102, -85, -3, -2, 1, 0, -2, -7, -15, -25, -36, -46, -50, -53, -45, -38, -15,
-16, -80, -62, -50, -45, -44, -49, -59, -69, -81, -88, -94, -92, -91, -81, -83,
-54, 31, 35, 37, 38, 40, 40, 44, 46, 53, 55, 62, 62, 66, 58, 63, 33, -54, -61,
-66, -70, -71, -71, -69, -67, -66, -65, -64, -62, -60, -55, -51, -29, };