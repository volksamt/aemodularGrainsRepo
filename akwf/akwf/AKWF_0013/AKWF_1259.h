#define DATA_LENGTH 512
#define DATA AKWF_1259

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 14, 23, 31, 39, 43, 47, 48, 51, 51,
51, 52, 54, 55, 56, 59, 60, 62, 64, 66, 67, 69, 71, 73, 73, 75, 77, 78, 79, 80,
81, 82, 84, 85, 86, 87, 89, 89, 90, 92, 93, 94, 96, 95, 96, 97, 98, 100, 100,
102, 102, 104, 104, 104, 106, 105, 107, 107, 108, 109, 109, 110, 111, 111, 112,
113, 113, 113, 114, 115, 116, 115, 116, 116, 116, 116, 117, 116, 117, 117, 118,
117, 118, 118, 118, 118, 118, 119, 119, 119, 118, 118, 119, 119, 119, 119, 118,
119, 118, 118, 118, 118, 117, 118, 117, 117, 116, 116, 116, 115, 115, 114, 114,
114, 113, 114, 113, 111, 112, 111, 111, 109, 109, 108, 107, 107, 106, 106, 104,
103, 103, 102, 101, 100, 99, 99, 97, 96, 94, 91, 86, 80, 74, 68, 58, 47, 40, 35,
33, 30, 25, 17, 6, -6, -14, -21, -28, -33, -36, -41, -43, -46, -49, -50, -53,
-55, -58, -60, -62, -65, -68, -70, -72, -74, -76, -77, -79, -80, -81, -82, -84,
-85, -87, -87, -89, -89, -90, -91, -93, -92, -95, -95, -95, -96, -96, -98, -98,
-100, -101, -102, -102, -105, -104, -105, -107, -107, -108, -109, -109, -109,
-110, -110, -110, -111, -110, -111, -111, -111, -111, -112, -112, -112, -113,
-113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -114, -113,
-114, -113, -113, -113, -113, -113, -113, -114, -114, -113, -112, -113, -112,
-113, -113, -112, -113, -112, -112, -113, -113, -112, -112, -111, -112, -111,
-111, -110, -110, -110, -110, -109, -110, -110, -109, -109, -108, -108, -107,
-107, -107, -106, -105, -104, -103, -104, -103, -103, -102, -102, -102, -101,
-100, -100, -100, -100, -99, -98, -97, -96, -95, -95, -94, -93, -93, -92, -91,
-91, -89, -89, -89, -87, -87, -87, -86, -85, -84, -84, -83, -83, -82, -81, -81,
-80, -80, -78, -77, -77, -75, -74, -73, -71, -70, -67, -63, -60, -56, -51, -45,
-38, -29, -19, -10, -2, 6, 13, 19, 25, 30, 35, 39, 41, 44, 47, 48, 50, 51, 51,
52, 53, 54, 55, 56, 56, 56, 57, 58, 59, 60, 60, 61, 62, 62, 63, 64, 65, 65, 66,
66, 68, 68, 69, 69, 69, 70, 71, 72, 71, 72, 72, 72, 73, 73, 74, 74, 74, 74, 74,
74, 76, 75, 75, 75, 75, 75, 74, 74, 73, 73, 72, 72, 72, 71, 71, 72, 72, 71, 72,
71, 70, 71, 71, 70, 70, 69, 69, 68, 68, 67, 67, 66, 65, 63, 61, 59, 57, 55, 52,
51, 48, 46, 44, 41, 38, 34, 26, 17, 8, 0, -7, -13, -17, -21, -25, -27, -29, -32,
-35, -38, -40, -43, -45, -48, -50, -52, -53, -55, -57, -58, -59, -60, -61, -62,
-63, -63, -64, -65, -65, -65, -66, -66, -67, -67, -67, -68, -67, -67, -67, -67,
-67, -68, -67, -67, -68, -67, -67, -66, -67, -66, -66, -66, -66, -66, -66, -66,
-66, -65, -64, -63, -59, -56, -50, -42, -30, -17, -5, };