#define DATA_LENGTH 512
#define DATA AKWF_1221

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 8, 11, 15, 19, 23, 27, 31, 35, 39,
43, 46, 48, 51, 53, 55, 56, 56, 57, 56, 55, 53, 51, 49, 46, 43, 41, 39, 38, 36,
36, 35, 36, 37, 38, 40, 41, 43, 44, 46, 46, 47, 47, 45, 45, 43, 41, 39, 37, 34,
31, 29, 28, 25, 22, 22, 21, 21, 20, 22, 22, 24, 25, 26, 29, 31, 34, 36, 38, 42,
44, 47, 50, 53, 57, 60, 63, 66, 69, 73, 76, 79, 83, 87, 90, 93, 97, 101, 104,
106, 110, 112, 115, 117, 118, 118, 119, 118, 118, 116, 114, 111, 108, 106, 103,
101, 99, 96, 94, 95, 94, 95, 95, 96, 97, 98, 99, 100, 100, 99, 97, 95, 93, 90,
86, 84, 82, 79, 79, 78, 76, 78, 78, 79, 81, 82, 84, 84, 85, 86, 86, 85, 84, 83,
80, 77, 75, 72, 70, 66, 64, 60, 57, 54, 52, 49, 46, 44, 43, 41, 39, 38, 37, 35,
35, 34, 33, 32, 32, 31, 30, 30, 29, 28, 27, 26, 24, 22, 21, 18, 15, 13, 9, 6, 3,
0, -3, -7, -9, -11, -13, -15, -16, -16, -16, -15, -14, -11, -10, -7, -5, -4, -2,
-1, -1, -1, -2, -2, -3, -5, -7, -8, -11, -13, -14, -14, -16, -16, -16, -15, -13,
-11, -9, -7, -5, -3, 0, 2, 5, 6, 8, 10, 10, 11, 12, 12, 12, 11, 10, 10, 8, 7, 5,
3, 1, -2, -5, -6, -8, -12, -14, -17, -20, -21, -25, -27, -28, -30, -31, -33,
-33, -34, -33, -32, -31, -30, -28, -25, -23, -20, -18, -14, -13, -11, -9, -9,
-8, -9, -10, -11, -12, -14, -16, -18, -18, -18, -19, -18, -17, -15, -14, -11,
-9, -7, -6, -4, -4, -5, -7, -7, -10, -12, -13, -15, -16, -16, -18, -18, -17,
-16, -15, -13, -12, -9, -6, -4, -2, 0, 2, 3, 5, 6, 6, 7, 6, 5, 5, 3, 3, 1, 0,
-3, -5, -9, -10, -14, -17, -20, -22, -26, -29, -32, -35, -39, -41, -45, -47,
-49, -52, -54, -55, -56, -56, -56, -56, -55, -53, -52, -50, -47, -43, -40, -38,
-35, -33, -31, -30, -29, -30, -30, -30, -31, -32, -34, -36, -38, -39, -40, -40,
-41, -40, -38, -37, -35, -33, -30, -27, -27, -24, -22, -20, -19, -19, -19, -19,
-21, -21, -22, -24, -27, -28, -31, -33, -36, -39, -40, -43, -45, -47, -48, -51,
-52, -53, -54, -56, -56, -58, -58, -59, -60, -61, -61, -63, -62, -64, -65, -67,
-67, -70, -72, -75, -77, -79, -83, -85, -88, -90, -93, -95, -96, -98, -98, -98,
-98, -96, -95, -92, -90, -88, -85, -82, -81, -79, -79, -78, -79, -79, -80, -81,
-84, -84, -85, -85, -84, -84, -82, -79, -77, -74, -72, -69, -66, -65, -64, -63,
-63, -64, -65, -66, -68, -70, -71, -73, -74, -75, -75, -75, -74, -74, -72, -71,
-70, -66, -63, -60, -58, -55, -51, -48, -45, -41, -37, -34, -30, -27, -23, -19,
-15, -12, -8, -3, 0, };