#define DATA_LENGTH 512
#define DATA AKWF_1201

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 10, 15, 18, 22, 26, 29, 33, 37,
41, 44, 47, 51, 54, 57, 61, 64, 67, 70, 74, 76, 80, 82, 84, 87, 90, 92, 95, 97,
99, 100, 103, 105, 106, 108, 110, 111, 112, 114, 114, 115, 116, 117, 118, 118,
118, 119, 119, 119, 119, 119, 119, 119, 117, 117, 117, 116, 115, 114, 113, 112,
111, 110, 108, 107, 105, 104, 101, 100, 98, 96, 94, 93, 90, 89, 87, 84, 82, 79,
77, 76, 73, 71, 67, 65, 64, 61, 58, 56, 54, 52, 50, 47, 44, 42, 40, 38, 36, 34,
32, 29, 26, 25, 24, 21, 20, 18, 16, 15, 13, 12, 11, 9, 7, 6, 5, 5, 4, 3, 2, 2,
1, 1, 0, 0, -1, -1, 0, 0, 1, 0, 1, 2, 3, 3, 4, 5, 5, 7, 7, 8, 10, 11, 13, 15,
16, 17, 19, 22, 23, 25, 27, 28, 31, 33, 35, 37, 39, 41, 44, 47, 48, 52, 54, 56,
57, 60, 62, 65, 67, 70, 72, 75, 78, 79, 82, 84, 86, 89, 91, 92, 94, 97, 98, 100,
102, 104, 104, 106, 108, 109, 111, 112, 112, 114, 115, 116, 117, 118, 118, 118,
118, 119, 118, 119, 119, 119, 118, 118, 118, 117, 117, 116, 114, 113, 113, 112,
110, 107, 106, 105, 103, 100, 99, 97, 95, 92, 90, 88, 85, 82, 80, 77, 73, 70,
68, 64, 61, 59, 55, 51, 47, 45, 41, 38, 34, 30, 26, 23, 19, 16, 12, 8, 4, 1, -4,
-8, -11, -15, -18, -23, -27, -30, -34, -37, -40, -44, -47, -51, -55, -58, -61,
-64, -68, -70, -74, -77, -79, -82, -85, -88, -90, -92, -95, -97, -99, -101,
-103, -104, -106, -108, -110, -111, -112, -114, -115, -116, -116, -117, -118,
-119, -119, -118, -119, -119, -120, -119, -118, -117, -118, -117, -117, -116,
-114, -114, -113, -111, -110, -109, -109, -107, -106, -103, -101, -100, -98,
-96, -95, -92, -90, -88, -86, -84, -81, -80, -77, -74, -73, -70, -69, -65, -63,
-61, -57, -55, -53, -51, -50, -47, -44, -42, -39, -38, -35, -33, -30, -29, -27,
-24, -23, -22, -20, -17, -15, -14, -13, -11, -11, -10, -8, -6, -6, -5, -3, -3,
-2, -2, -1, 0, 1, 0, -1, 1, 0, -1, 0, -1, -2, -2, -2, -3, -4, -5, -5, -6, -7,
-9, -11, -11, -14, -14, -16, -17, -20, -21, -24, -24, -28, -29, -31, -33, -35,
-37, -39, -42, -45, -46, -48, -51, -53, -56, -59, -60, -63, -65, -68, -70, -72,
-75, -77, -80, -82, -84, -86, -89, -90, -92, -94, -96, -99, -101, -102, -103,
-105, -106, -108, -110, -111, -111, -114, -115, -115, -116, -117, -117, -118,
-119, -119, -119, -119, -119, -119, -118, -119, -118, -118, -117, -116, -115,
-115, -113, -113, -110, -109, -108, -106, -105, -103, -101, -99, -96, -94, -92,
-90, -87, -85, -83, -79, -77, -74, -70, -68, -64, -61, -59, -55, -51, -47, -44,
-41, -37, -34, -30, -27, -22, -19, -14, -11, -8, -4, 0, };