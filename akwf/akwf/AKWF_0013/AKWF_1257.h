#define DATA_LENGTH 512
#define DATA AKWF_1257

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 8, 11, 11, 14, 16, 18, 20,
22, 23, 26, 28, 29, 30, 32, 34, 35, 37, 37, 39, 40, 41, 43, 44, 45, 45, 46, 48,
49, 50, 50, 51, 51, 52, 52, 53, 54, 55, 55, 55, 55, 56, 56, 57, 57, 58, 59, 59,
60, 61, 61, 62, 62, 63, 63, 64, 65, 65, 66, 66, 67, 68, 67, 68, 69, 68, 68, 68,
69, 69, 69, 70, 71, 71, 72, 72, 74, 74, 75, 77, 78, 78, 79, 81, 81, 82, 82, 84,
84, 84, 86, 85, 87, 88, 88, 89, 89, 90, 91, 91, 91, 93, 93, 94, 94, 95, 95, 97,
96, 97, 97, 99, 98, 99, 99, 100, 100, 100, 102, 103, 103, 102, 103, 104, 104,
105, 105, 106, 106, 106, 106, 107, 107, 107, 109, 109, 109, 109, 109, 110, 110,
110, 111, 110, 111, 112, 112, 112, 112, 113, 113, 114, 113, 114, 114, 115, 114,
115, 114, 115, 115, 116, 116, 116, 116, 116, 116, 116, 116, 117, 118, 118, 118,
117, 118, 118, 118, 119, 118, 119, 118, 118, 119, 119, 118, 115, 112, 107, 103,
100, 95, 92, 88, 85, 80, 76, 73, 70, 66, 63, 60, 57, 53, 50, 47, 44, 42, 38, 35,
32, 30, 26, 24, 22, 19, 17, 14, 11, 9, 7, 5, 3, -1, -2, -4, -6, -9, -11, -12,
-15, -16, -18, -20, -22, -23, -25, -26, -28, -30, -31, -33, -34, -34, -35, -36,
-36, -37, -38, -38, -37, -36, -36, -35, -34, -33, -32, -29, -28, -26, -24, -22,
-22, -22, -21, -22, -24, -25, -26, -28, -29, -31, -32, -34, -36, -37, -39, -40,
-42, -44, -44, -46, -48, -49, -50, -52, -53, -54, -56, -56, -59, -59, -61, -62,
-63, -64, -64, -66, -67, -69, -70, -71, -72, -72, -73, -74, -76, -76, -77, -78,
-78, -80, -80, -81, -82, -83, -84, -85, -85, -87, -87, -87, -89, -89, -89, -89,
-91, -92, -91, -93, -93, -94, -94, -94, -95, -96, -97, -97, -97, -98, -98, -99,
-99, -100, -100, -100, -102, -102, -102, -103, -102, -103, -103, -104, -105,
-105, -105, -106, -106, -106, -106, -106, -107, -108, -107, -107, -108, -108,
-108, -108, -108, -109, -108, -108, -108, -107, -106, -106, -105, -103, -101,
-98, -97, -94, -91, -88, -85, -82, -78, -74, -72, -70, -67, -66, -65, -63, -64,
-63, -63, -62, -62, -63, -63, -64, -63, -63, -64, -65, -65, -66, -66, -66, -67,
-66, -67, -67, -68, -68, -69, -69, -71, -72, -73, -74, -74, -75, -76, -76, -77,
-79, -78, -81, -81, -81, -81, -83, -83, -84, -86, -85, -86, -87, -87, -88, -89,
-90, -91, -92, -91, -93, -93, -93, -94, -95, -95, -96, -97, -97, -98, -98, -99,
-99, -99, -99, -100, -98, -98, -98, -98, -97, -97, -96, -96, -94, -93, -91, -90,
-89, -87, -85, -82, -80, -78, -74, -71, -69, -66, -63, -59, -57, -53, -50, -47,
-44, -41, -39, -36, -33, -30, -27, -25, -22, -20, -17, -14, -12, -10, -7, -5,
-3, -1, };