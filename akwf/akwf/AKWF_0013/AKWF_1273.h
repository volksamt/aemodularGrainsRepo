#define DATA_LENGTH 512
#define DATA AKWF_1273

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 6, 15, 24, 35, 43, 52, 58, 64, 70,
73, 77, 80, 84, 86, 89, 91, 92, 94, 95, 97, 99, 100, 102, 103, 101, 94, 84, 62,
33, 3, -23, -44, -60, -72, -83, -91, -98, -103, -108, -112, -115, -117, -119,
-119, -119, -118, -116, -114, -111, -109, -106, -103, -97, -87, -75, -64, -58,
-52, -49, -45, -42, -38, -33, -27, -19, -11, -1, 7, 15, 21, 25, 30, 32, 33, 34,
34, 32, 31, 29, 27, 25, 22, 19, 17, 16, 15, 15, 13, 11, 10, 5, 2, -4, -8, -14,
-21, -28, -35, -44, -52, -62, -68, -74, -76, -77, -76, -74, -71, -69, -68, -65,
-63, -62, -59, -58, -56, -53, -51, -49, -47, -45, -43, -40, -39, -36, -33, -31,
-27, -23, -18, -14, -9, -5, 0, 5, 10, 14, 18, 23, 28, 32, 37, 41, 47, 50, 54,
60, 64, 68, 73, 78, 82, 85, 85, 80, 69, 49, 22, -6, -30, -45, -57, -65, -71,
-73, -75, -74, -73, -71, -68, -63, -60, -54, -49, -43, -37, -33, -27, -21, -17,
-12, -7, -3, 1, 4, 8, 11, 14, 16, 18, 21, 22, 24, 26, 27, 27, 29, 29, 31, 30,
32, 31, 30, 29, 28, 27, 25, 24, 23, 21, 19, 17, 16, 16, 15, 15, 15, 13, 12, 7,
4, -2, -7, -13, -19, -26, -32, -39, -44, -49, -54, -58, -60, -63, -64, -66, -67,
-67, -68, -69, -68, -68, -67, -67, -67, -67, -66, -66, -67, -67, -68, -69, -70,
-70, -70, -69, -67, -63, -60, -54, -50, -43, -37, -30, -24, -19, -11, -4, 1, 9,
17, 26, 33, 40, 46, 54, 62, 72, 79, 84, 83, 74, 56, 31, 7, -12, -27, -40, -51,
-59, -65, -71, -77, -80, -84, -87, -89, -90, -91, -92, -91, -90, -88, -86, -84,
-81, -77, -72, -66, -51, -36, -20, -9, 1, 8, 15, 21, 30, 37, 45, 51, 58, 63, 67,
71, 73, 75, 76, 75, 74, 72, 70, 67, 64, 61, 58, 54, 50, 45, 42, 40, 37, 34, 31,
27, 24, 20, 14, 10, 4, -1, -7, -13, -19, -26, -33, -40, -46, -49, -52, -54, -56,
-56, -56, -55, -55, -54, -54, -53, -52, -51, -50, -48, -47, -46, -45, -44, -42,
-40, -39, -37, -36, -33, -30, -27, -24, -20, -16, -11, -7, -4, 0, 4, 8, 13, 16,
20, 23, 28, 32, 36, 40, 44, 47, 51, 56, 59, 63, 65, 65, 59, 48, 27, 0, -28, -51,
-70, -82, -91, -98, -102, -104, -103, -103, -102, -99, -97, -92, -87, -83, -78,
-73, -67, -62, -57, -53, -49, -44, -40, -36, -33, -30, -27, -25, -21, -19, -17,
-15, -14, -10, -10, -7, -6, -4, -3, -1, 0, 1, 1, 1, 2, 2, 2, 2, 1, 0, 1, 1, 3,
6, 11, 18, 22, 28, 28, 26, 21, 14, 6, -3, -13, -22, -32, -41, -48, -56, -59,
-63, -65, -66, -65, -63, -61, -59, -55, -50, -45, -38, -31, -25, -17, -11, -5,
-1, -1, -1, -2, -4, -5, -5, -3, };