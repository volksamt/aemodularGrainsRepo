#define DATA_LENGTH 512
#define DATA AKWF_1218

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 7, 7, 8, 10, 11, 13, 14,
15, 18, 18, 21, 22, 24, 26, 27, 29, 32, 34, 36, 39, 40, 43, 45, 48, 49, 52, 53,
56, 59, 60, 63, 65, 67, 69, 72, 74, 76, 78, 81, 83, 85, 87, 89, 91, 94, 95, 97,
100, 102, 102, 104, 105, 106, 107, 109, 110, 110, 110, 112, 112, 114, 114, 114,
113, 114, 114, 114, 114, 113, 112, 111, 110, 109, 108, 107, 105, 102, 101, 98,
97, 95, 92, 90, 87, 85, 81, 79, 75, 73, 68, 66, 62, 58, 54, 51, 47, 42, 39, 34,
30, 25, 21, 16, 12, 7, 3, -1, -6, -10, -16, -20, -25, -29, -33, -37, -42, -46,
-50, -54, -58, -62, -67, -70, -73, -77, -81, -84, -87, -91, -93, -96, -98, -102,
-104, -106, -108, -109, -112, -112, -114, -114, -117, -117, -118, -119, -119,
-119, -119, -119, -119, -118, -118, -117, -116, -115, -113, -112, -110, -108,
-106, -104, -101, -99, -96, -94, -91, -88, -84, -82, -79, -74, -72, -67, -65,
-61, -57, -53, -49, -46, -41, -38, -34, -30, -26, -21, -18, -13, -10, -5, -1, 2,
6, 11, 14, 18, 21, 24, 29, 32, 35, 38, 41, 44, 47, 49, 53, 56, 59, 62, 64, 68,
70, 73, 74, 77, 79, 81, 82, 85, 86, 88, 90, 91, 92, 94, 95, 95, 96, 97, 97, 98,
99, 99, 99, 100, 100, 101, 100, 99, 100, 100, 99, 98, 97, 96, 94, 93, 92, 91,
89, 87, 86, 84, 82, 80, 78, 76, 73, 72, 69, 68, 65, 64, 60, 57, 56, 52, 51, 48,
45, 43, 40, 37, 35, 31, 29, 26, 23, 21, 18, 16, 14, 11, 8, 6, 5, 2, 0, -2, -4,
-6, -9, -10, -12, -14, -17, -18, -21, -22, -24, -27, -29, -30, -32, -33, -35,
-36, -38, -38, -39, -41, -42, -42, -43, -44, -45, -46, -47, -48, -48, -49, -49,
-49, -51, -51, -52, -52, -51, -53, -53, -52, -52, -51, -50, -50, -49, -48, -47,
-46, -45, -45, -43, -42, -42, -41, -40, -40, -39, -38, -37, -36, -35, -34, -32,
-32, -30, -29, -27, -26, -25, -24, -23, -21, -21, -20, -19, -18, -18, -18, -17,
-17, -17, -17, -17, -17, -16, -17, -16, -16, -17, -16, -17, -16, -17, -17, -17,
-17, -16, -17, -18, -19, -19, -20, -21, -22, -22, -24, -24, -25, -25, -27, -28,
-28, -28, -29, -30, -30, -30, -32, -32, -33, -34, -34, -35, -35, -36, -37, -37,
-39, -40, -41, -42, -42, -43, -44, -44, -45, -45, -46, -46, -46, -46, -47, -47,
-47, -47, -47, -47, -47, -48, -47, -48, -48, -48, -49, -49, -49, -49, -49, -49,
-49, -49, -47, -47, -47, -46, -46, -45, -44, -43, -43, -41, -41, -40, -40, -40,
-39, -37, -37, -36, -36, -35, -34, -34, -33, -33, -31, -30, -30, -28, -28, -27,
-25, -24, -22, -21, -20, -20, -18, -18, -17, -16, -15, -15, -14, -14, -12, -12,
-12, -10, -9, -8, -7, -6, -4, -3, -3, 0, };