#define DATA_LENGTH 512
#define DATA AKWF_1272

const PROGMEM int8_t DATA[DATA_LENGTH] = {100, 55, 49, 51, 48, 47, 48, 41, 50,
8, -33, -19, -30, -21, -32, -20, -40, 93, 96, 113, 34, -15, 47, 15, 35, 19, 29,
18, 26, 19, 23, 18, 21, 18, 18, 17, 15, 17, 15, 16, 14, 15, 13, 16, 12, 15, 13,
16, 15, 16, 15, 17, 16, 17, 18, 19, 19, 19, 21, 22, 23, 23, 25, 26, 27, 27, 29,
29, 32, 31, 33, 35, 35, 37, 37, 41, 36, 48, 12, -30, -18, 37, 54, 46, 52, 49,
53, 50, 55, 52, 55, 54, 56, 55, 56, 56, 56, 57, 57, 57, 56, 57, 56, 56, 56, 55,
54, 54, 53, 52, 52, 51, 50, 49, 48, 47, 46, 45, 43, 41, 41, 39, 38, 36, 35, 33,
31, 29, 27, 26, 24, 22, 21, 19, 16, 14, 13, 12, 9, 7, 5, 4, 1, -1, -3, -5, -6,
-9, -10, -11, -13, -15, -17, -18, -20, -21, -23, -24, -25, -26, -28, -28, -31,
-30, -32, -33, -35, -35, -36, -35, -37, -38, -37, -39, -38, -40, -36, -47, 4,
33, 20, 28, 22, 25, 21, 23, 21, 22, 21, 21, 21, 22, 21, 21, 21, 21, 22, 22, 23,
22, 23, 23, 24, 24, 24, 25, 27, 27, 28, 27, 28, 28, 29, 30, 31, 31, 32, 32, 33,
34, 35, 36, 36, 36, 37, 37, 38, 39, 39, 40, 40, 40, 41, 41, 42, 41, 43, 42, 42,
43, 43, 43, 43, 43, 43, 43, 43, 43, 42, 43, 43, 42, 43, 42, 42, 41, 40, 40, 39,
39, 38, 38, 38, 38, 38, 36, 36, 35, 34, 34, 34, 34, 33, 32, 32, 31, 31, 29, 30,
27, 30, 27, 29, 25, 30, 19, 7, 29, 23, 26, 24, 24, 24, 24, 24, 23, 24, 23, 24,
23, 25, 23, 25, 22, 24, 23, 24, 25, 25, 26, 26, 26, 26, 28, 26, 29, 27, 30, 28,
33, 29, 34, 29, 38, 28, 44, 6, -108, -86, -95, -82, -93, -66, -9, -18, -10, -14,
-9, -10, -7, -7, -4, -4, -2, -1, 0, 1, 3, 4, 5, 5, 6, 7, 8, 10, 10, 10, 11, 12,
12, 14, 14, 14, 15, 15, 15, 15, 16, 16, 16, 16, 15, 16, 15, 15, 16, 16, 15, 15,
14, 13, 14, 13, 12, 12, 12, 11, 10, 11, 9, 9, 8, 8, 7, 7, 6, 5, 4, 5, 4, 3, 47,
69, 65, 66, 63, 63, 61, 60, 58, 58, 56, 55, 55, 54, 53, 52, 51, 51, 49, 49, 48,
48, 47, 47, 46, 46, 46, 46, 45, 45, 46, 45, 45, 45, 46, 46, 46, 46, 46, 48, 47,
48, 49, 48, 51, 50, 52, 51, 54, 52, 54, 54, 57, 55, 59, 57, 60, 59, 63, 62, 65,
64, 66, 67, 67, 70, 66, 79, -32, -67, -48, -59, -47, -52, -44, -47, -41, -42,
-38, -38, -33, -34, -30, -30, -28, -26, -25, -24, -22, -20, -19, -18, -17, -16,
-16, -14, -14, -13, -14, -12, -12, -12, -11, -12, -12, -11, -11, -11, -10, -12,
-11, };