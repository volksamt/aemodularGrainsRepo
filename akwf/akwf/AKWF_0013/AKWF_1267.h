#define DATA_LENGTH 512
#define DATA AKWF_1267

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 1, 3, 3, 3, 4, 4, 4, 6, 6, 6,
7, 7, 9, 10, 9, 10, 10, 12, 12, 13, 13, 14, 14, 16, 16, 16, 17, 18, 18, 19, 21,
21, 21, 22, 23, 25, 24, 26, 27, 27, 28, 29, 29, 30, 31, 32, 33, 33, 34, 35, 36,
36, 38, 39, 39, 40, 41, 42, 42, 43, 44, 45, 46, 46, 48, 48, 50, 50, 51, 52, 53,
53, 54, 55, 56, 57, 57, 58, 60, 61, 62, 62, 63, 64, 65, 66, 67, 67, 69, 69, 70,
71, 72, 73, 73, 75, 75, 76, 78, 77, 79, 71, 50, 19, -16, -49, -78, -99, -110,
-111, -103, -91, -73, -58, -43, -34, -28, -27, -31, -37, -43, -50, -55, -58,
-61, -63, -64, -66, -70, -77, -85, -95, -103, -111, -117, -119, -117, -112,
-101, -89, -75, -62, -51, -42, -38, -37, -40, -47, -55, -63, -72, -79, -81, -82,
-78, -72, -64, -55, -44, -34, -25, -18, -11, -7, -4, -2, 0, 0, 0, -1, -1, -2,
-3, -3, -4, -6, -6, -7, -5, -4, -1, 2, 6, 11, 15, 18, 21, 24, 23, 23, 20, 16,
12, 7, 3, -3, -6, -9, -10, -10, -10, -8, -6, -3, -1, 0, 2, 3, 3, 4, 2, 2, 0, -2,
-5, -6, -8, -10, -10, -11, -11, -10, -9, -7, -6, -3, -1, 3, 5, 8, 10, 11, 13,
12, 14, 13, 12, 12, 11, 11, 11, 11, 12, 13, 14, 16, 19, 22, 23, 25, 28, 29, 29,
30, 30, 30, 29, 29, 28, 27, 26, 25, 24, 23, 22, 23, 23, 24, 24, 23, 24, 25, 24,
24, 25, 23, 24, 23, 21, 20, 18, 18, 16, 14, 14, 12, 13, 11, 12, 11, 12, 12, 12,
12, 12, 13, 12, 13, 12, 12, 12, 11, 10, 9, 10, 9, 8, 8, 8, 8, 9, 9, 10, 9, 10,
11, 11, 11, 11, 12, 13, 12, 12, 11, 10, 11, 11, 10, 9, 9, 9, 9, 9, 9, 9, 10, 10,
9, 9, 10, 9, 8, 7, 7, 7, 6, 6, 5, 4, 3, 3, 2, 1, 1, 1, 0, 0, 0, -1, -1, -2, -3,
-2, -4, -4, -4, -5, -5, -6, -7, -7, -8, -9, -9, -8, -9, -10, -10, -10, -10, -11,
-10, -10, -10, -11, -10, -11, -11, -11, -12, -12, -12, -13, -13, -13, -13, -13,
-14, -13, -13, -13, -13, -13, -14, -13, -13, -14, -14, -13, -13, -14, -15, -15,
-14, -15, -15, -15, -16, -16, -15, -16, -16, -15, -16, -15, -17, -16, -16, -17,
-16, -16, -17, -17, -17, -18, -17, -18, -17, -18, -18, -18, -18, -18, -19, -19,
-19, -18, -18, -18, -18, -18, -18, -18, -18, -18, -18, -17, -18, -18, -17, -18,
-17, -16, -16, -16, -16, -16, -15, -16, -15, -15, -15, -14, -14, -14, -13, -13,
-13, -12, -12, -12, -12, -11, -10, -11, -11, -10, -9, -8, -8, -7, -8, -7, -6,
-5, -5, -5, -5, -5, -3, -4, -3, -3, -3, -3, -1, 0, 0, 0, };