#define DATA_LENGTH 512
#define DATA AKWF_1262

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 19, 26, 23, 19, 16, 15, 15, 17, 20,
23, 26, 29, 31, 35, 36, 39, 40, 42, 44, 47, 48, 49, 52, 54, 55, 56, 58, 59, 61,
63, 63, 66, 66, 68, 69, 70, 72, 73, 75, 75, 77, 78, 79, 80, 82, 83, 84, 85, 86,
87, 88, 90, 90, 91, 92, 93, 94, 94, 96, 96, 97, 97, 99, 100, 100, 102, 102, 103,
102, 104, 104, 105, 106, 106, 107, 107, 108, 108, 109, 110, 109, 111, 111, 111,
112, 113, 113, 113, 113, 114, 114, 115, 115, 115, 116, 116, 116, 116, 117, 118,
118, 118, 117, 118, 119, 119, 118, 119, 119, 118, 118, 115, 113, 112, 111, 112,
112, 112, 112, 113, 112, 113, 114, 113, 114, 114, 114, 114, 114, 115, 115, 114,
115, 115, 115, 116, 115, 116, 116, 115, 116, 115, 116, 116, 116, 116, 116, 117,
117, 117, 116, 117, 117, 117, 117, 117, 117, 117, 116, 117, 116, 116, 116, 116,
116, 115, 115, 115, 114, 114, 115, 114, 113, 113, 113, 113, 113, 112, 112, 111,
110, 110, 110, 109, 109, 109, 108, 108, 107, 107, 106, 105, 104, 103, 102, 101,
98, 97, 94, 92, 90, 87, 86, 83, 81, 78, 76, 74, 72, 70, 67, 65, 62, 60, 57, 56,
52, 50, 47, 44, 41, 38, 35, 31, 29, 26, 22, 18, 15, 10, 7, 2, -2, -5, -8, -10,
-12, -13, -16, -17, -19, -22, -24, -25, -27, -30, -32, -34, -36, -38, -40, -42,
-45, -46, -48, -50, -52, -53, -55, -57, -58, -59, -61, -62, -64, -66, -67, -68,
-69, -71, -71, -73, -75, -75, -75, -77, -77, -78, -79, -82, -86, -92, -96, -96,
-94, -91, -87, -82, -80, -83, -87, -92, -94, -95, -97, -97, -98, -98, -100, -99,
-100, -101, -101, -101, -103, -102, -102, -103, -104, -105, -105, -105, -105,
-106, -107, -107, -107, -108, -107, -109, -109, -109, -109, -109, -110, -110,
-111, -110, -111, -111, -112, -113, -112, -112, -113, -112, -113, -113, -113,
-114, -114, -114, -115, -115, -115, -115, -115, -115, -116, -116, -116, -116,
-116, -116, -116, -117, -116, -116, -117, -117, -117, -117, -117, -117, -117,
-118, -118, -118, -117, -118, -118, -117, -118, -118, -117, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -120, -119, -119, -119,
-119, -118, -119, -119, -118, -118, -117, -114, -111, -109, -109, -108, -108,
-109, -108, -108, -108, -109, -108, -110, -109, -109, -110, -109, -109, -108,
-108, -108, -108, -107, -106, -107, -106, -106, -106, -107, -106, -106, -106,
-107, -107, -107, -107, -107, -107, -108, -107, -108, -108, -107, -107, -107,
-106, -107, -107, -107, -106, -106, -106, -106, -107, -106, -106, -105, -105,
-104, -104, -105, -103, -104, -102, -102, -102, -102, -102, -101, -101, -99,
-99, -99, -98, -98, -97, -96, -96, -95, -95, -94, -93, -92, -90, -89, -85, -83,
-81, -76, -74, -72, -68, -66, -63, -62, -59, -57, -55, -53, -50, -48, -45, -41,
-39, -36, -34, -34, -40, -47, -48, -41, -32, -15, };