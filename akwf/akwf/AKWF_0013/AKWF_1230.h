#define DATA_LENGTH 512
#define DATA AKWF_1230

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 11, 14, 19, 22, 27, 31, 35, 40,
44, 47, 52, 58, 61, 66, 69, 73, 76, 80, 83, 86, 89, 92, 94, 95, 98, 98, 100,
101, 101, 102, 102, 102, 102, 101, 101, 100, 99, 97, 96, 93, 92, 89, 86, 83, 81,
77, 72, 68, 65, 60, 55, 49, 44, 38, 34, 28, 24, 20, 15, 10, 6, 1, -4, -9, -14,
-18, -25, -30, -35, -40, -45, -50, -55, -59, -65, -70, -73, -78, -82, -85, -88,
-91, -95, -96, -99, -102, -103, -105, -105, -107, -108, -108, -109, -109, -109,
-109, -108, -108, -108, -106, -106, -104, -104, -102, -100, -99, -98, -96, -94,
-91, -89, -86, -83, -80, -77, -73, -69, -66, -62, -57, -52, -49, -44, -39, -33,
-28, -22, -16, -12, -5, 0, 5, 11, 14, 19, 24, 27, 31, 34, 38, 43, 46, 51, 54,
58, 62, 67, 70, 74, 78, 82, 86, 89, 92, 96, 98, 101, 104, 106, 107, 110, 111,
113, 114, 115, 115, 116, 115, 115, 116, 114, 113, 114, 112, 111, 109, 108, 105,
104, 101, 98, 95, 92, 88, 84, 81, 76, 72, 67, 62, 57, 51, 46, 40, 35, 30, 25,
19, 15, 10, 6, 0, -4, -9, -14, -20, -24, -30, -35, -40, -45, -50, -56, -60, -66,
-70, -75, -78, -83, -87, -90, -93, -96, -99, -102, -104, -106, -108, -109, -111,
-111, -112, -113, -113, -113, -114, -113, -113, -112, -113, -111, -111, -109,
-109, -108, -107, -105, -103, -101, -99, -97, -94, -92, -89, -87, -83, -80, -76,
-73, -70, -65, -62, -57, -53, -48, -42, -37, -32, -27, -21, -17, -10, -5, 1, 6,
12, 17, 22, 25, 30, 33, 37, 40, 44, 47, 52, 55, 60, 63, 67, 72, 75, 79, 83, 87,
90, 93, 97, 101, 104, 106, 109, 110, 112, 114, 115, 117, 117, 119, 119, 120,
119, 119, 119, 118, 118, 116, 115, 114, 114, 112, 109, 108, 105, 103, 100, 96,
93, 88, 85, 81, 77, 72, 67, 62, 57, 51, 45, 40, 34, 30, 24, 20, 14, 9, 4, 1, -5,
-9, -14, -20, -25, -30, -35, -41, -46, -52, -56, -61, -66, -70, -74, -79, -83,
-88, -90, -94, -97, -100, -103, -106, -107, -108, -111, -112, -113, -113, -115,
-115, -115, -116, -115, -115, -115, -113, -113, -112, -112, -110, -108, -106,
-103, -101, -98, -94, -90, -86, -82, -78, -75, -70, -66, -62, -58, -53, -49,
-43, -39, -34, -29, -24, -20, -15, -12, -8, -3, 0, 3, 5, 8, 11, 13, 15, 17, 18,
20, 20, 21, 21, 21, 19, 19, 17, 16, 14, 12, 8, 5, 2, -1, -4, -8, -12, -14, -17,
-21, -25, -29, -32, -38, -41, -46, -51, -55, -59, -64, -69, -72, -76, -80, -84,
-87, -90, -93, -96, -98, -100, -102, -104, -105, -106, -107, -108, -109, -108,
-109, -109, -108, -109, -108, -106, -107, -105, -104, -103, -101, -100, -97,
-94, -92, -89, -86, -84, -80, -76, -72, -68, -63, -58, -55, -50, -44, -39, -33,
-28, -23, -17, -12, -7, -2, };