#define DATA_LENGTH 512
#define DATA AKWF_1227

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 12, 16, 20, 24, 28, 33, 36, 40,
44, 48, 51, 54, 57, 61, 63, 66, 69, 71, 74, 77, 79, 81, 83, 85, 88, 90, 92, 94,
96, 97, 100, 100, 103, 104, 106, 107, 109, 110, 110, 112, 113, 114, 115, 115,
116, 117, 117, 117, 117, 118, 119, 119, 120, 119, 118, 119, 119, 118, 119, 117,
117, 117, 116, 115, 115, 115, 114, 113, 112, 111, 111, 110, 109, 108, 107, 107,
106, 104, 103, 102, 101, 100, 98, 95, 93, 91, 89, 86, 83, 80, 77, 75, 72, 68,
65, 63, 59, 57, 55, 52, 50, 46, 44, 42, 40, 38, 37, 35, 33, 32, 30, 28, 27, 26,
25, 24, 23, 23, 21, 20, 19, 19, 18, 19, 17, 17, 17, 16, 16, 16, 16, 16, 15, 15,
15, 16, 16, 16, 16, 15, 15, 16, 16, 17, 16, 18, 18, 18, 19, 20, 20, 20, 20, 21,
21, 22, 23, 23, 22, 23, 24, 25, 24, 25, 26, 25, 26, 26, 26, 27, 27, 27, 27, 28,
27, 27, 28, 28, 27, 27, 28, 27, 26, 27, 26, 26, 25, 25, 25, 25, 24, 24, 24, 22,
21, 21, 20, 20, 19, 18, 17, 16, 15, 15, 14, 13, 12, 11, 10, 9, 8, 7, 6, 5, 4, 4,
2, 1, -1, -1, -3, -4, -5, -6, -8, -8, -9, -11, -11, -12, -13, -14, -15, -17,
-17, -18, -19, -19, -20, -21, -23, -23, -25, -24, -25, -26, -26, -27, -27, -28,
-29, -28, -29, -30, -30, -30, -32, -32, -32, -32, -32, -33, -34, -32, -33, -34,
-34, -34, -34, -34, -34, -34, -34, -33, -33, -34, -34, -33, -32, -33, -33, -33,
-33, -32, -32, -32, -33, -32, -32, -32, -31, -31, -30, -30, -31, -30, -30, -30,
-29, -29, -30, -30, -29, -28, -28, -28, -29, -29, -29, -29, -28, -29, -29, -29,
-29, -29, -29, -29, -29, -30, -29, -30, -30, -31, -30, -30, -30, -31, -32, -31,
-32, -33, -32, -33, -33, -32, -34, -34, -35, -35, -36, -36, -36, -37, -36, -37,
-39, -39, -39, -39, -40, -41, -40, -41, -42, -42, -43, -43, -43, -44, -45, -45,
-45, -46, -46, -47, -47, -48, -49, -49, -48, -49, -50, -50, -51, -51, -51, -52,
-52, -52, -53, -53, -53, -54, -54, -54, -54, -54, -55, -55, -54, -55, -55, -56,
-56, -56, -55, -56, -56, -56, -56, -56, -56, -56, -56, -56, -56, -57, -56, -55,
-55, -55, -56, -55, -56, -56, -55, -56, -56, -55, -54, -55, -55, -54, -54, -54,
-55, -54, -53, -53, -54, -54, -53, -53, -53, -53, -53, -53, -53, -53, -52, -53,
-52, -53, -52, -52, -51, -51, -52, -52, -52, -52, -52, -52, -52, -52, -52, -52,
-52, -51, -51, -52, -52, -52, -52, -51, -52, -52, -51, -52, -52, -52, -52, -53,
-52, -53, -52, -53, -53, -53, -53, -54, -53, -54, -53, -54, -55, -54, -54, -54,
-55, -55, -56, -55, -54, -54, -53, -51, -49, -46, -43, -40, -36, -32, -27, -22,
-18, -13, -8, -3, };