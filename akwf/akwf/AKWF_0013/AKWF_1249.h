#define DATA_LENGTH 512
#define DATA AKWF_1249

const PROGMEM int8_t DATA[DATA_LENGTH] = {17, 41, 58, 71, 80, 88, 94, 99, 101,
104, 106, 107, 108, 109, 109, 111, 111, 111, 111, 112, 111, 111, 110, 109, 109,
108, 107, 106, 106, 103, 103, 101, 99, 99, 97, 96, 96, 95, 95, 95, 94, 95, 96,
98, 100, 102, 104, 105, 107, 108, 111, 112, 113, 114, 115, 116, 117, 117, 118,
118, 118, 119, 118, 119, 118, 119, 118, 119, 119, 118, 119, 119, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 120, 119, 119, 119, 119, 118, 119, 120, 118, 118, 119, 119, 118, 118,
118, 119, 119, 119, 118, 120, 118, 119, 118, 119, 119, 119, 120, 119, 119, 119,
119, 119, 119, 119, 119, 120, 118, 119, 119, 119, 120, 119, 119, 119, 120, 119,
119, 119, 118, 120, 119, 120, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119,
120, 119, 119, 119, 119, 119, 120, 119, 119, 118, 118, 119, 119, 118, 119, 119,
119, 119, 119, 118, 118, 118, 118, 118, 119, 119, 119, 119, 119, 118, 119, 118,
119, 119, 119, 119, 119, 119, 120, 119, 120, 119, 120, 119, 119, 119, 119, 118,
119, 119, 119, 120, 118, 119, 119, 119, 118, 119, 119, 119, 118, 118, 118, 117,
117, 117, 115, 114, 113, 111, 109, 106, 102, 98, 93, 87, 80, 73, 65, 56, 48, 40,
33, 26, 21, 17, 16, 14, 14, 16, 19, 24, 29, 34, 39, 45, 49, 54, 59, 63, 67, 70,
73, 76, 77, 78, 80, 80, 78, 78, 75, 73, 70, 64, 58, 50, 39, 25, 6, -15, -35,
-51, -65, -77, -87, -93, -99, -105, -108, -111, -112, -114, -115, -116, -116,
-117, -118, -118, -119, -118, -119, -118, -118, -119, -119, -118, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-118, -118, -118, -118, -118, -118, -118, -118, -118, -117, -118, -117, -118,
-118, -117, -117, -118, -118, -118, -118, -119, -118, -118, -118, -118, -119,
-119, -119, -119, -119, -118, -118, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -120, -118, -119, -118, -119, -119, -119, -120, -119, -119,
-119, -120, -119, -119, -119, -119, -118, -120, -119, -118, -119, -118, -118,
-118, -119, -120, -119, -119, -118, -119, -119, -119, -119, -119, -119, -118,
-118, -119, -119, -118, -118, -118, -118, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -118, -119, -118, -119, -119,
-119, -120, -118, -119, -119, -120, -119, -119, -119, -119, -119, -118, -119,
-119, -118, -118, -118, -118, -118, -117, -117, -116, -117, -115, -115, -115,
-114, -114, -114, -114, -113, -113, -113, -114, -114, -114, -114, -115, -115,
-115, -115, -116, -117, -117, -117, -117, -117, -117, -117, -117, -118, -118,
-118, -117, -117, -118, -117, -117, -117, -118, -116, -117, -116, -117, -116,
-115, -113, -112, -110, -108, -106, -102, -96, -89, -80, -68, -52, -32, -7, };