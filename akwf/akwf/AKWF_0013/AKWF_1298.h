#define DATA_LENGTH 512
#define DATA AKWF_1298

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 6, 8, 10, 12, 13, 16, 18, 20,
22, 24, 27, 29, 31, 34, 35, 37, 40, 42, 45, 47, 49, 52, 54, 56, 58, 61, 64, 66,
68, 70, 73, 75, 77, 79, 81, 83, 85, 89, 91, 92, 94, 96, 98, 100, 101, 104, 105,
106, 108, 109, 111, 112, 113, 115, 115, 116, 117, 117, 117, 117, 118, 119, 119,
119, 119, 119, 119, 119, 118, 118, 117, 117, 116, 115, 113, 112, 112, 110, 109,
108, 107, 106, 103, 102, 101, 99, 97, 95, 94, 92, 90, 88, 86, 84, 82, 80, 77,
75, 73, 71, 69, 66, 63, 61, 59, 57, 55, 53, 50, 49, 46, 44, 42, 40, 37, 36, 33,
32, 29, 28, 25, 23, 22, 19, 17, 15, 14, 12, 10, 9, 6, 4, 3, 0, -1, -2, -5, -7,
-8, -11, -12, -14, -16, -17, -19, -21, -23, -25, -26, -28, -29, -31, -32, -34,
-37, -37, -40, -41, -42, -44, -46, -47, -48, -49, -51, -52, -54, -55, -56, -57,
-59, -60, -60, -62, -63, -64, -66, -66, -66, -67, -67, -68, -69, -70, -69, -70,
-71, -71, -71, -71, -71, -71, -71, -72, -71, -71, -71, -70, -70, -69, -69, -69,
-69, -68, -68, -67, -66, -65, -65, -64, -62, -62, -61, -61, -61, -59, -59, -59,
-56, -56, -55, -55, -53, -53, -52, -52, -50, -50, -49, -49, -48, -47, -46, -45,
-46, -44, -44, -43, -42, -41, -38, -37, -35, -34, -31, -29, -28, -27, -26, -25,
-24, -22, -20, -19, -18, -16, -15, -14, -12, -11, -11, -8, -7, -6, -5, -3, -3,
-1, 0, 2, 2, 4, 5, 6, 7, 9, 10, 12, 13, 14, 15, 17, 18, 19, 20, 23, 23, 25, 26,
28, 29, 29, 31, 32, 32, 34, 35, 36, 36, 38, 39, 40, 40, 41, 42, 43, 43, 43, 44,
45, 45, 46, 46, 46, 46, 45, 45, 46, 46, 45, 45, 44, 44, 43, 43, 43, 42, 41, 40,
39, 38, 37, 36, 35, 35, 34, 33, 30, 30, 29, 27, 27, 25, 24, 23, 21, 19, 19, 17,
15, 15, 14, 12, 10, 9, 8, 6, 4, 3, 2, 1, -1, -1, -3, -4, -4, -6, -8, -8, -10,
-10, -12, -12, -14, -14, -16, -16, -17, -18, -18, -20, -20, -21, -21, -23, -23,
-25, -26, -25, -27, -27, -28, -29, -29, -30, -31, -32, -33, -33, -34, -35, -35,
-36, -37, -38, -39, -40, -41, -42, -42, -44, -45, -45, -47, -47, -48, -50, -50,
-51, -52, -52, -54, -54, -55, -56, -57, -57, -58, -59, -60, -60, -60, -62, -62,
-63, -63, -64, -64, -64, -65, -65, -66, -66, -66, -67, -66, -66, -66, -66, -66,
-66, -66, -66, -66, -65, -65, -64, -64, -64, -64, -63, -62, -62, -60, -61, -59,
-59, -57, -56, -56, -56, -55, -54, -53, -51, -51, -50, -49, -48, -47, -46, -45,
-45, -43, -42, -41, -40, -39, -38, -38, -37, -36, -35, -34, -33, -31, -27, -26,
-23, -21, -19, -16, -14, -13, -12, -9, -8, -4, -3, 0, };