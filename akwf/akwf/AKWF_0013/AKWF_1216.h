#define DATA_LENGTH 512
#define DATA AKWF_1216

const PROGMEM int8_t DATA[DATA_LENGTH] = {-5, -18, -28, -39, -51, -62, -73, -83,
-92, -101, -107, -112, -116, -119, -119, -117, -116, -112, -106, -98, -90, -81,
-69, -58, -45, -32, -20, -6, 7, 19, 31, 42, 55, 64, 73, 80, 87, 91, 95, 97, 98,
97, 94, 92, 87, 82, 75, 68, 60, 51, 42, 32, 22, 12, 3, -7, -15, -24, -32, -41,
-47, -52, -56, -61, -63, -66, -66, -65, -64, -62, -59, -56, -51, -45, -40, -34,
-27, -21, -13, -6, 0, 7, 13, 20, 25, 31, 36, 40, 43, 46, 47, 48, 49, 49, 48, 45,
44, 41, 38, 34, 29, 24, 19, 15, 9, 4, -1, -6, -11, -15, -20, -23, -26, -29, -32,
-34, -35, -36, -36, -36, -35, -34, -32, -30, -28, -24, -20, -18, -14, -9, -6,
-2, 2, 5, 9, 13, 15, 18, 21, 23, 25, 26, 27, 27, 28, 28, 27, 25, 24, 22, 21, 18,
16, 13, 10, 7, 5, 1, -1, -4, -6, -9, -11, -13, -15, -17, -19, -20, -19, -20,
-20, -19, -19, -19, -18, -16, -15, -14, -12, -10, -7, -6, -3, 0, 2, 4, 5, 7, 9,
10, 11, 13, 13, 13, 15, 15, 14, 14, 15, 14, 12, 11, 10, 9, 8, 7, 5, 3, 2, 0, -1,
-3, -4, -6, -7, -8, -9, -10, -10, -11, -11, -10, -11, -11, -11, -10, -10, -9,
-7, -7, -6, -5, -4, -3, -1, 0, 2, 2, 3, 5, 5, 6, 7, 7, 7, 8, 7, 8, 8, 8, 7, 8,
7, 7, 6, 5, 5, 3, 3, 2, 1, 0, 0, -1, -3, -3, -4, -4, -5, -5, -5, -5, -6, -6, -5,
-6, -5, -5, -5, -4, -4, -3, -3, -1, -1, -1, -1, 0, 2, 2, 2, 2, 3, 3, 3, 4, 4, 4,
4, 4, 5, 4, 4, 4, 4, 4, 3, 3, 2, 2, 2, 1, 0, 0, 0, -1, 0, -1, -3, -3, -3, -3,
-2, -3, -3, -3, -3, -3, -4, -3, -3, -2, -3, -3, -2, -2, -1, -1, -1, 0, 1, 0, 1,
0, 1, 1, 1, 2, 2, 2, 1, 2, 2, 1, 2, 2, 2, 1, 1, 1, 0, 0, 0, 1, 0, 0, -1, -1, -1,
0, -1, -2, -1, -2, -2, -2, -2, -2, -2, -3, -3, -3, -2, -2, -2, -2, -2, -1, -2,
-1, -1, -1, 0, -1, -1, 0, -1, 0, 1, 1, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0,
-1, 0, -1, -1, -2, -2, -2, -2, -2, -2, -2, -2, -2, -3, -3, -3, -3, -2, -3, -4,
-3, -3, -3, -2, -2, -1, -2, -1, -1, -1, 0, 0, 0, 0, 1, 1, 1, 1, 2, 2, 3, 3, 3,
3, 3, 4, 4, 4, 3, 4, 4, 4, 3, 4, 3, 2, 2, 2, 2, 3, 2, 2, 3, 3, 3, 4, 5, 6, 7, 8,
10, 13, 16, 18, 21, 25, 28, 32, 37, 40, 44, 48, 52, 50, 49, 52, 54, 55, 54, 53,
51, 47, 43, 36, 29, 22, 12, 2, };