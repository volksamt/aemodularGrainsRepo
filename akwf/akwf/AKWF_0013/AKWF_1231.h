#define DATA_LENGTH 512
#define DATA AKWF_1231

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 20, 32, 44, 51, 55, 57, 60, 64, 68,
73, 77, 80, 82, 84, 86, 89, 90, 93, 94, 97, 97, 98, 100, 100, 102, 103, 104,
104, 105, 106, 106, 108, 107, 108, 109, 109, 110, 110, 110, 111, 111, 113, 112,
113, 113, 114, 113, 113, 114, 114, 113, 114, 114, 115, 114, 114, 115, 115, 115,
115, 115, 116, 116, 117, 117, 117, 117, 116, 116, 116, 117, 117, 117, 117, 117,
116, 117, 117, 118, 117, 117, 118, 117, 118, 118, 117, 117, 118, 117, 118, 117,
118, 118, 118, 118, 118, 119, 119, 118, 119, 119, 119, 118, 119, 118, 118, 119,
118, 118, 118, 118, 118, 118, 119, 119, 118, 119, 118, 119, 119, 119, 118, 118,
118, 119, 119, 119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 118, 119, 119,
119, 119, 118, 118, 119, 120, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119,
119, 118, 119, 119, 119, 119, 118, 118, 120, 118, 119, 119, 119, 119, 119, 119,
118, 118, 119, 118, 118, 119, 118, 119, 119, 119, 119, 117, 118, 118, 118, 117,
117, 117, 117, 116, 115, 115, 115, 114, 113, 113, 112, 111, 111, 109, 108, 106,
106, 103, 102, 99, 98, 95, 92, 89, 86, 82, 77, 73, 68, 62, 58, 51, 44, 37, 29,
21, 12, 2, -8, -20, -33, -44, -50, -53, -55, -59, -63, -68, -72, -76, -78, -81,
-83, -86, -88, -90, -92, -92, -95, -97, -98, -99, -100, -101, -101, -103, -104,
-104, -104, -106, -107, -107, -108, -108, -109, -109, -110, -110, -111, -111,
-111, -111, -112, -112, -113, -113, -113, -113, -113, -113, -114, -114, -114,
-114, -115, -115, -115, -115, -115, -116, -116, -116, -115, -116, -116, -117,
-116, -117, -116, -117, -117, -116, -117, -117, -117, -117, -116, -117, -117,
-117, -117, -118, -118, -117, -117, -117, -117, -118, -117, -118, -118, -117,
-118, -117, -118, -118, -118, -118, -119, -119, -118, -118, -118, -118, -118,
-119, -118, -119, -118, -118, -118, -118, -119, -118, -118, -119, -118, -119,
-119, -118, -119, -119, -119, -118, -118, -119, -119, -119, -119, -118, -118,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -118, -119, -119, -119, -118, -120, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -120, -119, -119, -119, -119, -120,
-119, -119, -119, -118, -120, -119, -119, -118, -119, -119, -119, -118, -118,
-119, -119, -120, -120, -118, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -118, -118, -117, -117, -118,
-117, -116, -116, -116, -116, -115, -114, -113, -112, -113, -111, -111, -109,
-109, -106, -105, -104, -102, -99, -96, -93, -91, -87, -84, -79, -75, -70, -64,
-59, -53, -45, -38, -29, -22, -11, -2, };