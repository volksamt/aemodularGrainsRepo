#define DATA_LENGTH 512
#define DATA AKWF_1263

const PROGMEM int8_t DATA[DATA_LENGTH] = {69, 116, 103, 109, 102, 104, 100, 102,
98, 98, 96, 95, 93, 92, 91, 89, 88, 86, 85, 84, 84, 81, 80, 78, 78, 76, 75, 74,
72, 70, 70, 69, 67, 66, 65, 64, 62, 60, 60, 58, 57, 55, 54, 53, 52, 51, 49, 48,
47, 45, 45, 44, 42, 42, 40, 39, 38, 37, 35, 35, 34, 33, 32, 31, 29, 29, 27, 26,
26, 24, 23, 23, 21, 21, 20, 19, 18, 17, 15, 15, 14, 13, 12, 11, 11, 10, 8, 9, 7,
6, 6, 6, 4, 4, 3, 2, 0, 0, 0, -1, -2, -2, -3, -4, -4, -4, -5, -7, -6, -8, -7,
-8, -9, -9, -10, -11, -11, -11, -12, -12, -13, -13, -14, -14, -14, -15, -16,
-15, -16, -17, -17, -17, -18, -18, -17, -19, -19, -19, -20, -19, -20, -21, -20,
-20, -20, -21, -21, -21, -22, -21, -22, -22, -22, -22, -22, -23, -22, -23, -23,
-23, -23, -22, -22, -23, -23, -22, -23, -23, -23, -22, -22, -23, -22, -22, -22,
-23, -23, -22, -22, -22, -21, -22, -22, -21, -21, -21, -21, -20, -20, -20, -20,
-19, -19, -20, -19, -19, -19, -19, -18, -18, -18, -17, -17, -17, -17, -16, -16,
-16, -15, -15, -15, -14, -15, -14, -13, -13, -13, -13, -13, -11, -12, -11, -11,
-10, -11, -10, -10, -8, -9, -9, -9, -7, -7, -7, -6, -7, -5, -5, -5, -5, -4, -4,
-3, -2, -3, -2, -2, -2, -1, 0, -1, 0, 0, 1, 1, 2, 2, 3, 3, 3, 4, 4, 5, 5, 6, 7,
7, 6, 7, 8, 7, 9, 9, 8, 9, 10, 10, 11, 11, 11, 11, 12, 13, 11, 13, 13, 13, 14,
14, 14, 14, 14, 15, 15, 16, 15, 16, 15, 17, 16, 17, 18, 17, 18, 18, 18, 18, 19,
19, 19, 19, 19, 20, 20, 20, 20, 21, 20, 20, 21, 21, 21, 21, 20, 21, 21, 21, 22,
21, 21, 22, 22, 21, 22, 22, 22, 22, 21, 21, 22, 22, 21, 21, 21, 22, 21, 21, 21,
21, 21, 20, 20, 20, 21, 20, 20, 19, 20, 19, 19, 19, 18, 19, 18, 17, 17, 18, 16,
16, 17, 16, 16, 15, 15, 15, 15, 14, 14, 13, 13, 12, 12, 11, 11, 11, 10, 9, 9,
10, 9, 8, 7, 7, 7, 6, 6, 5, 5, 3, 3, 3, 2, 2, 2, 0, 0, -1, -1, -2, -3, -4, -4,
-5, -5, -6, -7, -7, -8, -9, -10, -11, -11, -13, -12, -13, -14, -15, -16, -17,
-17, -17, -19, -20, -21, -22, -22, -22, -24, -24, -26, -26, -27, -27, -28, -29,
-31, -32, -32, -34, -34, -35, -37, -37, -37, -39, -39, -40, -42, -42, -43, -45,
-45, -46, -47, -49, -49, -51, -52, -52, -53, -54, -55, -57, -56, -58, -60, -60,
-62, -62, -63, -64, -66, -66, -67, -68, -69, -70, -71, -72, -74, -74, -75, -76,
-78, -78, -80, -80, -81, -82, -84, -85, -85, -88, -87, -90, -89, -93, -90, -96,
-90, -103, -56, };