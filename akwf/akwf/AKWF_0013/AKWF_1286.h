#define DATA_LENGTH 512
#define DATA AKWF_1286

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 14, 21, 27, 35, 42, 48, 56, 61,
67, 72, 75, 78, 78, 79, 79, 78, 77, 75, 73, 71, 69, 67, 67, 66, 66, 66, 69, 71,
74, 79, 83, 88, 93, 98, 104, 109, 113, 116, 118, 120, 118, 118, 114, 110, 105,
99, 91, 81, 72, 63, 53, 42, 32, 22, 14, 6, -1, -7, -12, -14, -17, -17, -18, -16,
-13, -11, -8, -4, -2, 2, 5, 7, 8, 9, 10, 9, 7, 4, 1, -3, -8, -13, -17, -21, -26,
-30, -33, -37, -38, -39, -40, -38, -35, -33, -30, -25, -21, -16, -12, -7, -4,
-1, 2, 3, 4, 3, 2, -2, -6, -12, -18, -26, -33, -41, -48, -58, -65, -72, -78,
-84, -87, -91, -93, -93, -92, -89, -86, -82, -76, -70, -64, -57, -51, -44, -38,
-31, -27, -23, -19, -17, -15, -16, -15, -16, -18, -20, -21, -23, -25, -26, -28,
-27, -27, -25, -22, -20, -16, -11, -6, -1, 5, 11, 16, 22, 27, 31, 34, 36, 37,
36, 33, 30, 26, 21, 14, 6, -1, -11, -20, -29, -38, -46, -54, -60, -66, -69, -73,
-75, -75, -74, -73, -71, -66, -62, -58, -53, -48, -43, -39, -34, -31, -30, -28,
-27, -27, -28, -31, -32, -36, -38, -41, -45, -47, -49, -52, -53, -54, -52, -50,
-48, -44, -40, -35, -29, -23, -17, -11, -5, 0, 5, 9, 12, 13, 13, 12, 11, 7, 4,
-2, -8, -14, -21, -27, -34, -42, -47, -52, -56, -60, -62, -62, -62, -60, -56,
-52, -47, -40, -34, -26, -19, -12, -4, 2, 9, 14, 19, 22, 25, 27, 27, 28, 27, 26,
24, 23, 21, 19, 18, 17, 17, 18, 19, 21, 25, 28, 33, 38, 43, 50, 54, 61, 64, 69,
74, 76, 77, 77, 76, 73, 70, 64, 58, 51, 43, 35, 25, 15, 6, -4, -13, -22, -29,
-34, -40, -43, -46, -48, -47, -46, -45, -41, -38, -35, -31, -27, -23, -19, -16,
-15, -14, -13, -13, -14, -16, -19, -22, -27, -30, -34, -39, -42, -46, -48, -51,
-51, -51, -50, -49, -46, -42, -38, -32, -28, -22, -17, -12, -7, -4, -1, 1, 3, 2,
0, -2, -6, -11, -16, -22, -30, -37, -45, -52, -59, -65, -71, -75, -79, -80, -82,
-81, -79, -76, -72, -66, -60, -53, -47, -39, -32, -24, -18, -11, -6, 0, 3, 5, 7,
8, 9, 8, 7, 7, 5, 3, 3, 2, 2, 3, 3, 6, 8, 12, 17, 23, 28, 34, 41, 47, 53, 59,
65, 69, 72, 74, 76, 76, 74, 71, 67, 62, 54, 48, 40, 31, 24, 14, 7, -2, -8, -14,
-19, -22, -26, -27, -27, -26, -23, -20, -17, -12, -6, -1, 3, 9, 14, 18, 21, 24,
25, 27, 26, 25, 23, 22, 18, 16, 13, 9, 7, 4, 4, 3, 3, 3, 6, 8, 13, 16, 22, 28,
33, 40, 47, 52, 58, 62, 65, 69, 70, 71, 70, 68, 64, 59, 55, 48, 43, 35, 29, 22,
14, 8, 3, -1, -3, -6, -7, -6, -4, 0, };