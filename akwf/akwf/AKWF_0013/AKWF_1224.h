#define DATA_LENGTH 512
#define DATA AKWF_1224

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 12, 22, 31, 40, 48, 57, 65, 73, 80,
86, 91, 96, 100, 104, 108, 110, 112, 114, 115, 118, 118, 119, 118, 119, 119,
119, 119, 118, 119, 119, 118, 117, 117, 116, 116, 116, 115, 113, 113, 112, 112,
111, 110, 108, 108, 106, 105, 104, 102, 101, 99, 98, 95, 93, 92, 90, 88, 86, 84,
82, 80, 78, 75, 72, 67, 60, 53, 43, 34, 25, 15, 5, -5, -14, -23, -31, -38, -46,
-52, -58, -63, -67, -71, -74, -78, -80, -82, -83, -85, -85, -86, -87, -88, -88,
-87, -88, -88, -87, -87, -86, -86, -85, -84, -83, -83, -83, -81, -80, -79, -78,
-77, -76, -74, -73, -71, -69, -67, -66, -63, -61, -59, -56, -55, -53, -50, -49,
-48, -49, -51, -54, -56, -60, -62, -65, -69, -71, -74, -77, -78, -80, -81, -81,
-81, -80, -81, -80, -80, -78, -77, -75, -74, -72, -70, -69, -66, -66, -64, -62,
-60, -59, -58, -56, -56, -55, -54, -54, -53, -52, -53, -52, -53, -53, -52, -52,
-52, -52, -53, -53, -53, -54, -54, -54, -55, -56, -57, -56, -57, -58, -59, -59,
-61, -62, -61, -63, -63, -65, -65, -66, -67, -69, -69, -69, -71, -72, -73, -74,
-74, -75, -76, -77, -78, -79, -80, -81, -82, -83, -85, -84, -85, -86, -88, -87,
-88, -88, -89, -90, -91, -91, -91, -92, -92, -93, -93, -93, -94, -93, -94, -94,
-93, -91, -86, -80, -73, -63, -55, -46, -36, -27, -18, -10, -2, 5, 12, 17, 22,
27, 30, 34, 37, 40, 42, 45, 47, 49, 52, 55, 56, 57, 59, 61, 64, 65, 68, 71, 74,
76, 78, 80, 82, 84, 85, 87, 88, 90, 90, 91, 91, 91, 91, 92, 91, 90, 90, 89, 90,
88, 88, 87, 85, 84, 83, 82, 80, 80, 78, 77, 75, 73, 72, 70, 70, 67, 65, 64, 61,
61, 59, 56, 55, 54, 52, 50, 49, 46, 45, 42, 39, 34, 30, 24, 19, 14, 9, 3, -1,
-6, -10, -16, -19, -23, -26, -29, -32, -34, -35, -37, -38, -39, -40, -41, -42,
-42, -41, -42, -42, -42, -41, -41, -42, -43, -44, -46, -49, -53, -55, -58, -61,
-65, -66, -68, -71, -72, -74, -74, -75, -77, -80, -83, -87, -90, -94, -97, -100,
-104, -107, -109, -112, -114, -115, -116, -116, -117, -118, -117, -116, -116,
-115, -114, -112, -111, -109, -107, -106, -104, -102, -101, -98, -97, -95, -94,
-92, -91, -89, -87, -85, -85, -83, -82, -80, -79, -78, -76, -75, -75, -74, -72,
-72, -70, -70, -69, -68, -67, -67, -66, -66, -65, -65, -64, -64, -63, -63, -63,
-62, -62, -62, -63, -62, -63, -62, -63, -64, -66, -66, -68, -71, -72, -75, -77,
-80, -81, -84, -86, -87, -88, -90, -92, -95, -95, -97, -98, -99, -99, -102,
-103, -104, -104, -105, -106, -107, -107, -108, -108, -109, -109, -110, -109,
-110, -110, -110, -110, -110, -111, -111, -110, -110, -111, -110, -108, -101,
-95, -87, -78, -69, -60, -51, -43, -34, -26, -18, -11, -4, };