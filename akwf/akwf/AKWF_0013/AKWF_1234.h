#define DATA_LENGTH 512
#define DATA AKWF_1234

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 13, 17, 21, 26, 29, 32, 35, 38,
39, 41, 43, 45, 45, 46, 47, 48, 48, 50, 51, 51, 52, 53, 54, 55, 56, 59, 60, 61,
63, 64, 65, 67, 68, 68, 71, 70, 72, 72, 72, 73, 72, 72, 71, 70, 68, 69, 67, 67,
64, 66, 62, 63, 58, 64, 35, -8, -3, -4, -14, -38, -28, -24, -24, -19, -19, -15,
-15, -13, -13, -11, -11, -9, -9, -8, -8, -7, -7, -6, -6, -6, -5, -5, -5, -5, -4,
-4, -3, -3, -3, -1, -2, -2, -1, 0, 1, 0, 1, 1, 2, 1, 3, 2, 3, 3, 36, 72, 71, 70,
70, 68, 67, 66, 64, 64, 63, 61, 60, 59, 57, 57, 55, 50, 42, 36, 32, 28, 27, 24,
22, 21, 20, 19, 19, 18, 18, 18, 18, 18, 18, 17, 17, 17, 17, 18, 18, 16, 16, 15,
15, 14, 14, 13, 13, 12, 12, 11, 10, 9, 9, 8, 8, 6, 6, 6, 4, 4, 3, 2, 1, 1, 0, 0,
-1, -2, -3, -3, -4, -5, -4, -6, -6, -7, -6, -1, 5, 8, 10, 4, -10, -23, -30, -36,
-41, -45, -48, -50, -51, -52, -54, -54, -54, -54, -53, -54, -53, -53, -52, -52,
-51, -50, -49, -49, -47, -47, -46, -46, -46, -44, -43, -43, -42, -41, -41, -40,
-40, -38, -38, -38, -38, -38, -38, -38, -37, -38, -39, -39, -41, -42, -43, -44,
-46, -46, -49, -49, -51, -52, -57, -55, -62, -64, -83, -72, -23, -21, -15, -10,
-6, 0, 4, 10, 12, 17, 20, 24, 27, 29, 31, 34, 35, 37, 39, 40, 41, 43, 44, 46,
47, 49, 51, 52, 54, 56, 57, 58, 60, 61, 63, 65, 66, 66, 68, 70, 70, 70, 70, 71,
71, 71, 70, 70, 68, 68, 66, 66, 64, 64, 61, 62, 58, 60, 55, 58, 51, 55, 15, -49,
-15, -7, -1, 9, 12, 19, 21, 27, 28, 33, 34, 38, 39, 42, 42, 44, 45, 46, 47, 48,
48, 50, 51, 51, 52, 53, 53, 55, 57, 58, 59, 61, 63, 64, 66, 66, 67, 68, 69, 70,
71, 71, 71, 72, 71, 71, 71, 69, 68, 68, 68, 66, 64, 62, 62, 60, 60, 58, 58, 56,
54, 48, 39, 8, -8, -3, -3, 0, 0, 2, 2, 3, 4, 6, 6, 7, 8, 8, 10, 10, 12, 11, 12,
12, 12, 12, 12, 12, 12, 12, 11, 11, 11, 10, 10, 9, 9, 8, 7, 6, 6, 5, 5, 5, 3, 3,
2, 2, 0, 1, -1, -2, -1, -3, -4, -4, -4, -4, -5, -6, -6, -6, -6, -1, 4, 8, 10, 2,
-13, -24, -32, -37, -43, -46, -48, -50, -53, -53, -54, -54, -54, -55, -53, -54,
-53, -53, -52, -52, -51, -50, -50, -49, -48, -48, -48, -46, -45, -45, -44, -43,
-42, -42, -40, -41, -39, -40, -39, -39, -38, -38, -38, -38, -39, -39, -39, -40,
-41, -41, -44, -44, -47, -46, -50, -49, -54, -52, -58, -55, -66, -61, -104, -93,
-4, -10, };