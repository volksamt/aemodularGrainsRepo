#define DATA_LENGTH 512
#define DATA AKWF_1219

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 8, 10, 11, 14, 15, 17, 18,
21, 23, 24, 26, 29, 29, 31, 31, 33, 33, 34, 33, 34, 34, 34, 34, 33, 33, 32, 32,
30, 30, 30, 29, 29, 29, 29, 29, 28, 29, 30, 29, 31, 31, 32, 33, 34, 36, 37, 38,
40, 41, 42, 43, 45, 47, 48, 50, 51, 53, 54, 57, 59, 59, 62, 63, 65, 67, 69, 71,
73, 75, 77, 79, 81, 84, 86, 89, 90, 93, 96, 98, 101, 103, 105, 106, 108, 110,
111, 114, 115, 116, 117, 117, 118, 119, 119, 119, 120, 118, 118, 118, 117, 116,
115, 114, 113, 112, 111, 110, 107, 107, 106, 103, 102, 101, 99, 97, 97, 95, 93,
92, 91, 89, 88, 87, 85, 83, 82, 80, 78, 76, 73, 72, 69, 67, 65, 63, 59, 57, 54,
52, 49, 45, 43, 39, 36, 34, 31, 28, 26, 24, 20, 19, 17, 14, 13, 12, 10, 10, 8,
8, 7, 8, 7, 7, 7, 7, 6, 7, 8, 7, 8, 9, 8, 8, 7, 7, 8, 8, 7, 7, 7, 6, 6, 6, 4, 3,
3, 1, 1, 0, 0, -1, -2, -3, -4, -5, -5, -7, -8, -8, -9, -10, -9, -9, -10, -10,
-10, -10, -10, -9, -9, -8, -7, -5, -4, -4, -2, 0, 1, 3, 4, 6, 6, 9, 10, 10, 11,
13, 13, 14, 15, 16, 16, 16, 16, 17, 16, 16, 15, 15, 14, 13, 13, 11, 11, 9, 9, 8,
6, 4, 3, 2, 0, -2, -3, -5, -7, -10, -11, -12, -15, -17, -17, -21, -22, -24, -25,
-27, -28, -30, -30, -31, -32, -34, -33, -33, -33, -33, -34, -32, -32, -31, -31,
-30, -29, -30, -28, -28, -27, -27, -28, -27, -27, -28, -28, -29, -29, -29, -31,
-32, -33, -33, -34, -35, -38, -39, -41, -43, -44, -45, -45, -48, -50, -51, -53,
-54, -56, -58, -59, -61, -63, -65, -67, -68, -71, -72, -75, -76, -79, -81, -83,
-85, -88, -90, -93, -95, -97, -99, -102, -104, -105, -108, -110, -111, -112,
-113, -114, -116, -116, -116, -117, -117, -116, -116, -116, -115, -114, -114,
-113, -111, -110, -110, -109, -107, -106, -104, -102, -102, -100, -99, -98, -97,
-94, -94, -93, -91, -90, -88, -86, -85, -84, -82, -81, -78, -77, -75, -73, -71,
-69, -67, -66, -62, -60, -58, -55, -52, -49, -46, -44, -40, -38, -34, -31, -29,
-26, -24, -21, -19, -17, -15, -14, -13, -11, -10, -10, -8, -9, -9, -8, -8, -7,
-8, -8, -8, -9, -8, -9, -9, -9, -9, -9, -9, -9, -8, -9, -8, -7, -8, -6, -7, -6,
-5, -4, -3, -3, -2, -1, -1, 1, 2, 2, 3, 3, 5, 5, 5, 6, 8, 7, 8, 8, 8, 8, 8, 7,
7, 6, 6, 5, 4, 2, 1, -1, -1, -3, -4, -5, -7, -9, -11, -12, -13, -14, -15, -15,
-17, -17, -18, -18, -18, -18, -17, -18, -17, -17, -17, -16, -16, -14, -13, -12,
-12, -11, -9, -7, -6, -5, -3, 0, };