#define DATA_LENGTH 512
#define DATA AKWF_1268

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 14, 19, 22, 25, 29, 33, 37,
42, 44, 49, 51, 56, 58, 62, 64, 68, 71, 73, 75, 78, 81, 83, 85, 87, 88, 90, 93,
94, 95, 97, 98, 99, 100, 101, 100, 102, 101, 102, 103, 103, 102, 101, 101, 101,
100, 99, 99, 98, 97, 94, 95, 93, 91, 89, 89, 86, 85, 83, 81, 79, 77, 74, 73, 70,
68, 66, 63, 62, 59, 57, 54, 52, 50, 47, 44, 42, 39, 38, 35, 33, 31, 27, 26, 24,
22, 19, 18, 15, 13, 11, 9, 8, 5, 3, 2, 0, -1, -3, -5, -6, -8, -9, -10, -11, -12,
-13, -14, -16, -17, -17, -18, -20, -20, -20, -21, -20, -21, -22, -23, -23, -23,
-23, -24, -24, -24, -23, -25, -25, -25, -24, -25, -25, -24, -24, -24, -25, -25,
-25, -24, -24, -23, -24, -24, -23, -24, -23, -24, -24, -24, -23, -24, -23, -23,
-23, -24, -23, -23, -24, -24, -23, -24, -25, -25, -25, -25, -26, -25, -26, -26,
-26, -26, -26, -27, -28, -27, -28, -29, -29, -29, -30, -30, -30, -31, -31, -31,
-32, -32, -32, -32, -33, -34, -34, -33, -34, -35, -35, -35, -34, -35, -35, -34,
-35, -35, -35, -34, -35, -35, -35, -35, -34, -34, -34, -33, -32, -33, -32, -31,
-31, -30, -30, -28, -28, -28, -26, -26, -25, -24, -23, -22, -22, -21, -20, -19,
-18, -16, -16, -15, -14, -13, -12, -11, -9, -8, -8, -6, -5, -4, -2, -3, -1, 0,
1, 2, 3, 4, 4, 6, 6, 8, 8, 9, 10, 12, 11, 12, 13, 13, 14, 15, 14, 16, 16, 16,
17, 17, 17, 18, 18, 17, 18, 18, 17, 18, 19, 18, 18, 18, 18, 19, 17, 18, 17, 17,
17, 16, 17, 16, 15, 16, 15, 15, 15, 15, 15, 14, 14, 13, 14, 13, 13, 14, 13, 13,
13, 13, 12, 13, 13, 13, 13, 12, 13, 13, 13, 14, 14, 15, 15, 15, 15, 16, 17, 18,
18, 19, 19, 20, 21, 22, 22, 24, 24, 26, 26, 28, 29, 30, 31, 32, 33, 35, 35, 37,
37, 39, 40, 41, 42, 44, 45, 45, 46, 47, 49, 50, 50, 52, 52, 53, 54, 54, 56, 56,
56, 57, 57, 58, 58, 59, 58, 59, 58, 59, 57, 58, 57, 56, 56, 55, 55, 53, 53, 52,
51, 50, 47, 46, 44, 44, 42, 40, 37, 36, 34, 31, 29, 27, 24, 21, 19, 17, 13, 11,
8, 5, 2, -2, -5, -9, -11, -14, -17, -21, -24, -28, -31, -35, -38, -41, -45, -48,
-52, -55, -58, -61, -65, -68, -70, -74, -78, -80, -83, -86, -88, -91, -93, -97,
-98, -101, -102, -106, -107, -108, -110, -112, -112, -114, -115, -116, -117,
-118, -119, -118, -119, -119, -118, -118, -118, -117, -116, -116, -116, -114,
-114, -111, -111, -109, -107, -105, -102, -101, -98, -95, -93, -90, -87, -84,
-81, -78, -76, -71, -68, -65, -61, -58, -54, -50, -45, -42, -38, -34, -29, -26,
-22, -18, -13, -9, -6, -2, };