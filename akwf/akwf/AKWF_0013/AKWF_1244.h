#define DATA_LENGTH 512
#define DATA AKWF_1244

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 11, 16, 24, 31, 38, 45, 53, 60, 67,
73, 79, 84, 88, 92, 96, 97, 100, 101, 100, 99, 98, 95, 93, 89, 86, 82, 78, 74,
69, 65, 61, 57, 54, 50, 47, 45, 43, 41, 41, 40, 39, 41, 42, 44, 45, 49, 52, 55,
58, 62, 67, 70, 75, 77, 81, 83, 85, 85, 85, 83, 80, 75, 69, 61, 50, 39, 27, 12,
-2, -17, -31, -47, -61, -74, -87, -97, -106, -113, -117, -119, -119, -116, -111,
-104, -97, -88, -79, -69, -58, -47, -36, -26, -17, -8, 1, 8, 14, 20, 25, 29, 32,
35, 37, 38, 38, 39, 40, 39, 39, 38, 36, 35, 34, 34, 32, 31, 30, 29, 27, 27, 24,
23, 21, 19, 17, 15, 14, 12, 9, 6, 3, 1, -2, -4, -8, -11, -13, -16, -18, -21,
-24, -25, -26, -27, -28, -30, -31, -30, -31, -31, -31, -30, -29, -29, -28, -26,
-26, -24, -23, -22, -21, -19, -18, -16, -16, -14, -13, -12, -11, -10, -8, -7,
-6, -5, -3, -3, -2, -2, -1, 0, -1, -2, -2, -3, -5, -7, -9, -13, -16, -18, -19,
-22, -26, -31, -35, -39, -44, -50, -53, -58, -61, -63, -65, -66, -66, -65, -60,
-57, -51, -44, -37, -29, -21, -12, -3, 6, 14, 21, 28, 33, 39, 41, 44, 45, 44,
43, 41, 38, 35, 31, 26, 22, 17, 11, 8, 3, -2, -5, -10, -13, -17, -18, -22, -23,
-24, -26, -26, -26, -26, -26, -25, -23, -21, -19, -16, -14, -10, -6, -3, 3, 5,
11, 16, 21, 25, 31, 35, 41, 35, -7, -19, -13, -13, -9, -7, -3, -2, 2, 4, 7, 9,
12, 14, 17, 18, 20, 22, 23, 24, 26, 27, 29, 30, 31, 32, 33, 34, 36, 37, 37, 39,
40, 41, 42, 43, 42, 42, 43, 41, 41, 38, 35, 32, 27, 20, 14, 5, -3, -13, -24,
-35, -46, -58, -70, -82, -92, -101, -108, -115, -117, -118, -118, -113, -107,
-99, -88, -75, -62, -46, -32, -16, 1, 15, 29, 43, 55, 64, 72, 79, 83, 84, 85,
84, 80, 77, 71, 65, 57, 49, 42, 33, 26, 19, 11, 5, -1, -7, -11, -14, -19, -21,
-24, -25, -25, -25, -24, -23, -21, -19, -14, -11, -6, -1, 6, 10, 18, 24, 33, 38,
48, 52, 62, 65, 76, 77, 90, 64, -22, -18, -13, -14, -8, -7, -3, -2, 2, 4, 7, 10,
12, 15, 16, 17, 20, 21, 24, 25, 26, 27, 29, 29, 31, 32, 33, 34, 35, 38, 38, 39,
40, 41, 41, 42, 44, 43, 42, 42, 41, 38, 35, 31, 26, 20, 13, 5, -4, -14, -24,
-35, -47, -59, -71, -82, -93, -101, -109, -114, -117, -118, -118, -113, -107,
-97, -86, -74, -60, -46, -31, -14, 1, 17, 30, 43, 55, 66, 72, 79, 83, 85, 84,
83, 80, 75, 70, 64, 56, 49, 41, 33, 26, 18, 11, 4, -2, -7, -12, -16, -19, -22,
-23, -24, -25, -25, -24, -22, -20, -18, -14, -10, -5, -1, };