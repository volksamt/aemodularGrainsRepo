#define DATA_LENGTH 512
#define DATA AKWF_1277

const PROGMEM int8_t DATA[DATA_LENGTH] = {52, 64, 59, 64, 62, 64, 64, 67, 66,
67, 67, 69, 69, 70, 71, 72, 72, 72, 74, 73, 77, 74, 80, 46, -12, -10, -11, -8,
-8, -7, -7, -6, -5, -4, -4, -3, -3, -1, -1, 0, 0, 2, 4, -6, -10, -12, 69, 88,
80, 86, 82, 87, 84, 88, 86, 88, 88, 89, 89, 90, 90, 91, 93, 91, 94, 93, 96, 94,
99, 76, 10, 6, 10, 7, 11, 8, 13, 10, 13, 11, 15, 13, 15, 13, 17, 6, 0, 4, -1, 8,
-8, 56, 102, 89, 97, 93, 97, 94, 98, 96, 98, 96, 98, 98, 99, 99, 100, 100, 100,
101, 101, 102, 102, 104, 102, 105, 102, 106, 103, 106, 104, 106, 104, 107, 105,
108, 105, 111, 114, 86, 90, 88, 90, 89, 90, 90, 91, 90, 91, 91, 91, 92, 91, 92,
92, 92, 92, 93, 93, 94, 93, 94, 93, 96, 93, 96, 93, 97, 50, -2, 9, 4, 7, 6, 6,
6, 7, 7, 7, 7, 7, 8, 7, 7, 7, 8, 7, 8, 8, 8, 7, 8, 8, 7, 8, 8, 8, 8, 8, 8, 8, 8,
8, 8, 9, 8, 9, 8, 9, 8, 8, 9, 8, 8, 8, 8, 8, 8, 8, 7, 9, 8, 8, 7, -4, -5, -5,
-5, -5, -5, -5, -5, -5, -5, -6, -6, -5, -6, -6, -6, -6, -6, -6, -5, -6, -6, -6,
-6, -7, -6, -7, -7, -6, -7, -7, -8, -7, -8, -7, -9, -7, -8, -7, -9, -7, -11,
-42, -44, -42, -44, -43, -44, -47, -51, -52, -53, -53, -56, -55, -55, -53, -53,
-53, -54, -54, -55, -55, -54, -55, -55, -55, -55, -56, -56, -56, -55, -56, -56,
-57, -57, -57, -56, -56, -57, -56, -57, -56, -57, -56, -65, -69, -68, -69, -68,
-68, -68, -67, -69, -68, -68, -68, -68, -69, -69, -69, -69, -69, -69, -69, -69,
-69, -69, -69, -69, -70, -69, -69, -69, -69, -68, -69, -68, -68, -67, -68, -68,
-68, -67, -68, -66, -67, -66, -67, -67, -66, -66, -66, -66, -67, -66, -66, -66,
-65, -66, -65, -66, -65, -66, -65, -64, -64, -65, -65, -64, -64, -64, -63, -63,
-63, -63, -62, -61, -63, -61, -62, -60, -61, -60, -61, -59, -61, -57, -62, -53,
-56, -82, -76, -78, -77, -78, -77, -77, -76, -76, -76, -75, -75, -74, -74, -74,
-74, -72, -72, -71, -71, -71, -70, -70, -69, -69, -69, -68, -69, -67, -67, -66,
-66, -65, -65, -65, -64, -63, -63, -61, -62, -59, -68, -78, -75, -75, -73, -73,
-73, -72, -71, -70, -71, -70, -69, -69, -69, -68, -67, -66, -66, -65, -65, -64,
-64, -63, -62, -61, -61, -60, -59, -59, -57, -57, -56, -56, -55, -55, -53, -54,
-53, -53, -52, -51, -49, -52, -62, -60, -60, -59, -58, -58, -57, -57, -56, -55,
-54, -53, -52, -52, -51, -50, -49, -49, -47, -47, -46, -46, -45, -45, -43, -43,
-43, -42, -42, -41, -41, -40, -39, -38, -38, -36, -36, -32, -34, -31, -32, -26,
};