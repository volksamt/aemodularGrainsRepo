#define DATA_LENGTH 512
#define DATA AKWF_1248

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 2, 3, 3, 4, 4, 5, 5, 6, 6,
6, 6, 7, 7, 8, 9, 9, 9, 9, 10, 10, 10, 11, 12, 12, 13, 13, 15, 15, 15, 16, 17,
18, 18, 19, 20, 20, 22, 22, 23, 24, 25, 26, 26, 28, 28, 29, 31, 31, 32, 33, 34,
35, 35, 37, 37, 37, 39, 40, 40, 41, 42, 44, 43, 43, 45, 45, 45, 47, 48, 47, 48,
50, 50, 51, 51, 51, 51, 51, 53, 54, 53, 54, 54, 55, 55, 56, 56, 57, 57, 57, 58,
58, 59, 59, 59, 60, 59, 61, 61, 62, 62, 62, 63, 63, 64, 65, 64, 65, 65, 65, 66,
66, 67, 67, 67, 68, 69, 68, 69, 69, 70, 70, 71, 71, 72, 72, 72, 73, 73, 73, 73,
74, 75, 74, 76, 75, 76, 76, 77, 77, 77, 77, 78, 79, 79, 80, 79, 80, 80, 80, 80,
81, 82, 81, 82, 83, 82, 84, 84, 83, 84, 84, 84, 85, 85, 86, 85, 86, 86, 86, 87,
87, 88, 88, 87, 88, 88, 88, 89, 89, 88, 90, 90, 89, 90, 91, 90, 91, 91, 91, 92,
92, 92, 93, 92, 92, 93, 93, 93, 93, 94, 93, 93, 94, 94, 95, 95, 95, 95, 95, 96,
96, 96, 96, 96, 97, 97, 97, 98, 97, 97, 98, 98, 98, 98, 99, 98, 99, 99, 99, 99,
100, 100, 99, 100, 100, 99, 100, 100, 101, 101, 100, 101, 102, 102, 101, 102,
101, 101, 101, 101, 100, 100, 100, 99, 99, 97, 95, 94, 93, 91, 88, 84, 80, 74,
69, 61, 53, 41, 28, 12, -8, -27, -43, -56, -68, -76, -85, -91, -97, -100, -104,
-107, -110, -112, -113, -114, -115, -116, -117, -118, -118, -118, -118, -119,
-119, -119, -119, -119, -119, -120, -120, -118, -118, -119, -118, -118, -117,
-117, -115, -115, -114, -113, -111, -109, -107, -105, -102, -99, -95, -91, -86,
-82, -76, -71, -64, -57, -51, -45, -37, -31, -25, -21, -16, -12, -9, -8, -7, -7,
-8, -11, -14, -18, -21, -25, -30, -36, -41, -45, -50, -55, -59, -64, -68, -71,
-75, -77, -80, -83, -85, -88, -89, -91, -92, -94, -95, -95, -96, -98, -98, -99,
-98, -99, -99, -100, -99, -98, -98, -99, -98, -97, -96, -96, -95, -94, -94, -92,
-91, -89, -88, -88, -86, -85, -83, -81, -79, -78, -75, -74, -71, -70, -68, -66,
-65, -63, -62, -59, -57, -56, -55, -53, -52, -51, -50, -48, -47, -47, -46, -46,
-46, -45, -44, -45, -45, -45, -45, -45, -45, -45, -46, -46, -47, -47, -48, -48,
-49, -49, -50, -50, -50, -50, -51, -52, -53, -53, -53, -53, -54, -53, -54, -54,
-54, -55, -54, -54, -54, -53, -53, -54, -52, -53, -51, -51, -50, -49, -49, -48,
-48, -47, -46, -45, -44, -43, -41, -40, -40, -38, -36, -35, -34, -33, -32, -30,
-29, -27, -26, -25, -23, -21, -20, -18, -17, -15, -15, -13, -13, -11, -10, -8,
-7, -6, -5, -4, -4, -2, -1, 0, 0, };