#define DATA_LENGTH 512
#define DATA AKWF_1211

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 12, 19, 25, 32, 38, 45, 51, 56, 60,
65, 70, 73, 77, 80, 82, 85, 87, 88, 91, 92, 92, 92, 92, 92, 91, 91, 89, 88, 87,
84, 82, 80, 78, 75, 73, 69, 65, 63, 59, 56, 52, 49, 45, 42, 39, 35, 31, 27, 24,
20, 17, 14, 10, 8, 4, 1, -2, -5, -7, -11, -12, -14, -16, -20, -20, -23, -24,
-26, -27, -28, -29, -30, -31, -31, -32, -32, -32, -33, -33, -33, -32, -31, -32,
-31, -30, -30, -29, -28, -28, -26, -25, -24, -23, -22, -21, -19, -18, -17, -16,
-15, -13, -12, -10, -9, -8, -6, -5, -4, -4, -1, -1, 1, 2, 4, 4, 5, 6, 6, 7, 8,
8, 9, 10, 10, 10, 11, 12, 12, 11, 13, 13, 12, 13, 14, 13, 12, 12, 13, 13, 12,
12, 11, 11, 11, 11, 11, 11, 9, 10, 9, 9, 8, 7, 7, 6, 6, 6, 4, 4, 3, 3, 3, 2, 2,
1, 1, 0, 1, -1, -1, -1, -1, -2, -3, -3, -3, -4, -3, -4, -3, -4, -4, -4, -5, -5,
-4, -5, -4, -4, -5, -4, -4, -4, -5, -4, -4, -4, -5, -4, -4, -3, -4, -3, -3, -4,
-3, -3, -3, -2, -3, -3, -2, -2, -2, -1, -2, -1, -2, -1, -1, -1, 0, 0, 0, 1, 1,
1, 0, 1, 1, 1, 2, 2, 1, 1, 2, 1, 1, 1, 1, 1, 2, 3, 2, 2, 1, 2, 1, 2, 1, 1, 2, 2,
1, 2, 2, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 2, 0, 1, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0,
-1, -1, -1, -1, 0, 0, 0, 0, -1, 0, -1, 0, -1, -1, 0, -1, 0, -1, -1, -1, 0, -1,
-1, 0, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, 0, -2, -1, 0, -1, -1, -1,
-1, -1, -1, -1, -1, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0,
0, -1, 0, 0, -1, 0, -1, -1, 0, 0, -1, 0, 0, -1, 0, -1, 0, -1, 0, 0, -1, -1, -1,
0, 0, 0, -1, -1, 0, -1, -1, 0, -1, -1, -1, -1, -2, -1, -1, 0, -1, 0, -1, 0, -1,
-1, -1, -1, -2, -1, -1, -1, -2, -1, -2, -2, -1, -1, -2, -2, -1, -2, -2, -2, -2,
-2, -2, -1, -1, -2, -2, -2, -2, -2, -3, -3, -3, -2, -2, -3, -2, -2, -3, -3, -2,
-2, -3, -3, -4, -3, -4, -3, -4, -3, -3, -4, -4, -4, -4, -4, -4, -4, -5, -5, -5,
-4, -5, -4, -5, -6, -6, -6, -7, -7, -7, -7, -7, -8, -8, -9, -9, -10, -10, -12,
-12, -12, -14, -15, -16, -16, -18, -19, -21, -23, -25, -28, -30, -33, -37, -42,
-47, -54, -60, -68, -78, -88, -97, -107, -114, -119, -119, -114, -107, -99, -90,
-80, -71, -63, -53, -45, -36, -27, -18, -10, -3, };