#define DATA_LENGTH 512
#define DATA AKWF_1291

const PROGMEM int8_t DATA[DATA_LENGTH] = {19, 57, 55, 54, 54, 53, 54, 52, 52,
52, 51, 50, 50, 49, 50, 48, 49, 48, 47, 47, 46, 46, 46, 45, 45, 44, 44, 44, 44,
43, 43, 42, 42, 41, 41, 40, 40, 40, 40, 39, 39, 39, 37, 37, 37, 36, 36, 36, 35,
36, 34, 35, 34, 33, 33, 33, 33, 32, 33, 33, 31, 32, 30, 30, 30, 30, 30, 29, 29,
29, 29, 28, 28, 28, 27, 27, 26, 26, 26, 27, 26, 26, 25, 26, 25, 26, 25, 24, 25,
25, 23, 23, 23, 24, 23, 22, 23, 22, 22, 22, 22, 21, 21, 21, 20, 20, 14, 2, -4,
-11, 4, 22, 20, 21, 19, 20, 19, 19, 19, 19, 19, 18, 18, 18, 17, 18, 18, 17, 17,
17, 17, 18, 17, 17, 17, 17, 16, 15, 16, 15, 16, 15, 15, 15, 15, 14, 15, 14, 15,
14, 14, 15, 14, 13, 14, 13, 13, 14, 12, 12, 13, 12, 12, 12, 12, 12, 12, 12, 11,
11, 12, 12, 12, 12, 11, 11, 11, 11, 11, 10, 10, 11, 10, 11, 9, 9, 10, 9, 10, 10,
10, 10, 9, 9, 10, 9, 10, 9, 9, 9, 8, 9, 8, 9, 8, 8, 8, 8, 8, 8, 8, 8, 8, 8, 8,
8, 7, 8, 8, 7, 7, 7, 7, 7, 7, 7, 6, 7, 7, 7, 7, 6, 7, 6, 6, 7, 6, 6, 6, 6, 6, 6,
5, 6, 5, 5, 6, 6, 6, 5, 5, 5, 6, 5, 6, 5, 5, 5, 5, 5, 5, 5, 5, 6, 5, 5, 4, 5, 4,
5, 5, 5, 4, 4, 4, 4, 4, 4, 3, 4, 3, 4, 4, 4, 4, 3, 3, 4, 3, 4, 3, 4, 3, 3, 4, 3,
4, 4, 3, 3, 4, 3, 3, 3, 4, 2, 3, 4, 3, 2, 2, 3, 3, 3, 3, 3, 3, 3, 2, 3, 2, 3, 3,
3, 3, 3, 3, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 2, 2, 3, 2, 2, 2, 3, 2, 2,
3, 2, 2, 2, 2, 2, 1, 2, 1, 2, 1, 3, -1, -8, -14, -17, -1, 3, 1, 3, 1, 3, 1, 3,
2, 3, 2, 2, 2, 2, 1, 2, 2, 2, 1, 2, 2, 2, 1, 1, 2, 2, 1, 2, 1, 1, 2, 2, 2, 2, 2,
2, 2, 2, 1, 2, 1, 2, 2, 1, 2, 1, 2, 1, 2, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 2, 1, 2,
1, 1, 2, 1, 1, 1, 0, 1, 0, 2, 1, 1, 1, 1, 0, 0, 1, 1, 1, -18, -49, -74, -96,
-115, -119, -118, -117, -116, -115, -114, -113, -112, -111, -109, -108, -108,
-106, -106, -104, -103, -103, -101, -100, -99, -98, -98, -97, -96, -95, -94,
-92, -91, -91, -90, -89, -89, -88, -87, -86, -85, -84, -83, -82, -82, -80, -81,
-79, -79, -78, -78, -76, -77, -75, -75, -74, -74, -72, -72, -71, -70, -70, -69,
-65, -21, };