#define DATA_LENGTH 512
#define DATA AKWF_1294

const PROGMEM int8_t DATA[DATA_LENGTH] = {47, 56, 51, 54, 52, 53, 50, 52, 49,
51, 49, 49, 48, 48, 47, 47, 46, 46, 45, 46, 44, 44, 44, 44, 43, 43, 43, 41, 42,
41, 41, 40, 41, 40, 39, 39, 39, 38, 38, 38, 37, 36, 37, 36, 35, 36, 34, 35, 35,
34, 33, 33, 33, 33, 32, 32, 31, 31, 31, 31, 30, 30, 30, 29, 30, 29, 29, 28, 28,
28, 28, 27, 26, 27, 27, 27, 26, 27, 25, 25, 25, 24, 24, 25, 24, 24, 23, 24, 23,
24, 22, 23, 22, 22, 22, 22, 22, 21, 22, 21, 21, 21, 20, 20, 20, 19, 19, 20, 19,
20, 19, 19, 19, 18, 18, 18, 17, 17, 18, 17, 17, 17, 17, 16, 17, 17, 16, 15, 15,
16, 15, 16, 15, 15, 15, 15, 15, 15, 14, 14, 14, 14, 14, 14, 13, 13, 13, 13, 13,
13, 13, 13, 13, 12, 12, 12, 12, 13, 12, 12, 12, 11, 12, 11, 12, 11, 11, 11, 11,
11, 11, 11, 10, 10, 10, 10, 10, 10, 11, 9, 10, 10, 10, 9, 9, 9, 9, 9, 9, 9, 9,
8, 9, 9, 8, 9, 9, 8, 8, 8, 7, 9, 8, 7, 7, 8, 7, 8, 7, 7, 7, 7, 7, 7, 7, 7, 7, 6,
7, 6, 7, 6, 6, 6, 7, 6, 6, 7, 6, 6, 7, 7, 6, 6, 6, 6, 6, 5, 5, 5, 5, 5, 5, 6, 5,
6, 5, 5, 5, 5, 5, 5, 5, 4, 5, 5, 4, 5, 5, 5, 4, 5, 5, 4, 4, 4, 4, 4, 4, 5, 5, 4,
4, 3, 4, 4, 4, 4, 4, 4, 3, 4, 3, 4, 4, 4, 3, 3, 4, 3, 3, 3, 3, 3, 3, 3, 3, 4, 3,
3, 3, 3, 4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 3, 2, 2, 2, 2, 2, 3, 2,
2, 3, 2, 2, 2, 3, 2, 2, 2, 2, 3, 2, 2, 2, 2, 2, 2, 1, 2, 3, 2, 2, 2, 2, 3, 2, 1,
2, 2, 2, 2, 2, 2, 1, 2, 2, 1, 2, 1, 1, 2, 1, 2, 1, 2, 2, 1, 2, 2, 1, 1, 2, 2, 2,
2, 1, 2, 2, 1, 1, 2, 1, 2, 1, 1, 1, 1, 1, 2, 1, 2, 1, 1, 1, 2, 2, 1, 2, 1, 1, 1,
1, 1, 0, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 1, 0, 2, 1, 1, 1, 1,
0, 1, 0, 0, 1, 0, 2, 0, 3, -1, 3, -4, 6, -7, 15, -47, -128, -111, -120, -111,
-116, -111, -113, -111, -110, -109, -107, -107, -105, -105, -103, -103, -101,
-101, -98, -100, -97, -98, -96, -95, -94, -94, -92, -92, -91, -90, -89, -88,
-87, -87, -85, -85, -85, -83, -82, -81, -81, -79, -79, -79, -78, -76, -77, -74,
-76, -74, -74, -72, -73, -71, -72, -69, -71, -66, -70, -65, -71, -56, };