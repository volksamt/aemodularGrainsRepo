#define DATA_LENGTH 512
#define DATA AKWF_1204

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 9, 20, 29, 40, 50, 59, 68, 76, 82,
89, 93, 97, 101, 104, 106, 109, 110, 112, 113, 114, 115, 115, 117, 117, 118,
118, 118, 118, 119, 119, 118, 119, 119, 119, 118, 119, 118, 119, 118, 119, 117,
117, 116, 115, 114, 112, 111, 109, 105, 102, 98, 93, 87, 80, 73, 66, 61, 55, 51,
47, 44, 41, 40, 37, 36, 35, 34, 32, 31, 30, 29, 27, 27, 25, 24, 23, 21, 20, 17,
15, 13, 10, 8, 4, 1, -3, -7, -11, -15, -21, -24, -30, -34, -38, -42, -45, -48,
-51, -51, -52, -52, -51, -49, -45, -42, -36, -33, -28, -25, -22, -19, -19, -17,
-17, -17, -18, -18, -19, -20, -20, -20, -22, -22, -23, -24, -25, -26, -26, -27,
-27, -28, -28, -29, -30, -31, -31, -31, -31, -33, -32, -33, -33, -35, -36, -36,
-38, -38, -39, -41, -42, -46, -49, -52, -56, -62, -68, -75, -81, -85, -91, -95,
-98, -100, -101, -102, -102, -102, -100, -99, -97, -95, -92, -89, -85, -82, -78,
-74, -70, -67, -64, -62, -58, -56, -54, -52, -50, -49, -47, -46, -45, -44, -43,
-43, -42, -41, -40, -40, -37, -37, -34, -33, -31, -28, -24, -19, -13, -7, 0, 6,
13, 18, 21, 25, 29, 31, 34, 34, 36, 37, 38, 38, 39, 39, 39, 40, 40, 39, 39, 40,
39, 40, 39, 39, 39, 39, 40, 38, 39, 38, 38, 37, 36, 36, 35, 34, 34, 32, 30, 28,
26, 24, 20, 15, 10, 5, -3, -11, -20, -30, -41, -51, -61, -70, -77, -84, -90,
-94, -98, -102, -104, -107, -109, -111, -112, -114, -114, -115, -116, -117,
-117, -118, -118, -118, -119, -119, -119, -119, -119, -120, -118, -119, -119,
-119, -118, -118, -118, -116, -117, -116, -114, -114, -113, -111, -108, -106,
-103, -98, -92, -86, -80, -74, -65, -60, -55, -50, -47, -44, -41, -39, -38, -35,
-34, -32, -33, -31, -29, -29, -27, -27, -25, -24, -22, -21, -19, -17, -16, -13,
-11, -7, -4, 0, 4, 8, 11, 17, 21, 26, 30, 35, 39, 42, 45, 48, 51, 52, 52, 52,
51, 47, 45, 41, 37, 32, 28, 25, 22, 19, 18, 17, 18, 18, 18, 19, 19, 20, 20, 20,
21, 22, 23, 24, 24, 25, 27, 27, 27, 28, 28, 29, 29, 30, 31, 31, 31, 32, 34, 33,
34, 35, 35, 36, 36, 38, 40, 40, 43, 46, 49, 53, 58, 63, 68, 75, 81, 86, 91, 95,
98, 101, 101, 103, 102, 101, 100, 99, 97, 94, 92, 88, 85, 81, 77, 73, 71, 67,
64, 60, 58, 56, 53, 51, 50, 48, 47, 46, 46, 44, 44, 42, 42, 41, 39, 39, 38, 37,
34, 33, 31, 26, 23, 19, 13, 7, 0, -6, -13, -18, -22, -26, -29, -32, -33, -35,
-36, -37, -38, -39, -39, -40, -39, -39, -40, -40, -40, -39, -40, -40, -39, -39,
-40, -39, -39, -39, -39, -38, -38, -37, -37, -37, -36, -34, -34, -31, -30, -28,
-26, -23, -20, -15, -10, -4, };