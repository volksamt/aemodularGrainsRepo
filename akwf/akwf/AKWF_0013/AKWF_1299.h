#define DATA_LENGTH 512
#define DATA AKWF_1299

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 12, 12, 15, 16, 19, 20, 23, 24, 27,
29, 29, 31, 34, 36, 37, 39, 40, 42, 44, 45, 46, 48, 51, 51, 54, 54, 56, 58, 59,
61, 62, 63, 65, 67, 67, 68, 69, 71, 72, 73, 74, 75, 76, 77, 77, 79, 79, 80, 80,
81, 82, 82, 83, 82, 84, 83, 85, 83, 84, 84, 82, 83, 82, 83, 83, 82, 81, 80, 81,
80, 80, 78, 78, 77, 77, 76, 75, 73, 73, 71, 70, 69, 68, 67, 64, 81, 86, 83, 83,
81, 80, 79, 78, 77, 75, 73, 72, 71, 69, 66, 66, 65, 62, 62, 58, 57, 56, 55, 52,
51, 49, 48, 45, 43, 40, 38, 37, 34, 32, 30, 29, 26, 24, 22, 20, 19, 18, 14, 13,
11, 11, 7, 8, 2, -20, -19, -22, -22, -23, -25, -26, -27, -29, -30, -31, -32,
-33, -34, -35, -37, -37, -38, -38, -40, -39, -41, -42, -43, -43, -44, -45, -45,
-46, -46, -47, -47, -47, -48, -48, -50, -49, -50, -49, -50, -51, -51, -51, -50,
-51, -50, -52, -51, -51, -50, -53, -50, -53, -41, -24, -28, -25, -26, -24, -25,
-23, -23, -23, -22, -21, -20, -21, -19, -19, -17, -17, -16, -16, -15, -13, -13,
-12, -12, -12, -12, -12, -12, -11, -11, -12, -11, -10, -11, -10, -10, -9, -10,
-8, -9, -8, -10, -7, -10, -30, -30, -28, -28, -28, -27, -25, -25, -22, -21, -17,
-15, -13, -11, -7, -6, -4, -3, 0, 1, 3, 5, 7, 9, 11, 13, 15, 18, 19, 22, 24, 25,
27, 29, 31, 33, 34, 36, 38, 39, 41, 43, 44, 46, 48, 49, 50, 52, 54, 56, 56, 59,
60, 62, 63, 65, 65, 67, 69, 69, 70, 72, 73, 74, 74, 75, 76, 77, 78, 79, 80, 80,
81, 81, 82, 83, 83, 84, 84, 83, 84, 84, 85, 84, 83, 83, 83, 82, 83, 82, 82, 82,
81, 80, 79, 80, 78, 77, 77, 76, 75, 74, 73, 72, 71, 69, 68, 68, 66, 65, 63, 62,
60, 58, 58, 57, 54, 52, 50, 50, 46, 45, 43, 42, 39, 38, 36, 34, 33, 29, 31, 6,
-7, -5, -10, -10, -15, -15, -18, -19, -23, -24, -28, -28, -31, -33, -36, -37,
-39, -41, -43, -45, -47, -49, -49, -51, -51, -53, -53, -54, -55, -56, -56, -58,
-57, -59, -58, -61, -58, -65, -48, -31, -36, -35, -38, -37, -38, -39, -41, -41,
-42, -42, -43, -44, -44, -45, -46, -46, -46, -47, -47, -48, -47, -49, -48, -49,
-49, -51, -48, -51, -49, -51, -50, -51, -49, -52, -50, -51, -110, -117, -113,
-118, -114, -118, -116, -118, -116, -118, -117, -119, -117, -118, -118, -120,
-118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-118, -119, -118, -119, -119, -119, -118, -118, -118, -118, -118, -118, -117,
-117, -116, -116, -116, -116, -115, -114, -112, -110, -109, -107, -106, -104,
-103, -98, -96, -92, -89, -85, -82, -78, -77, -73, -73, -67, -68, -61, -62, -48,
};