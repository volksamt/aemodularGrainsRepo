#define DATA_LENGTH 512
#define DATA AKWF_1295

const PROGMEM int8_t DATA[DATA_LENGTH] = {92, 109, 100, 105, 99, 102, 97, 99,
95, 98, 94, 96, 93, 93, 91, 91, 90, 89, 88, 87, 87, 86, 85, 84, 83, 83, 83, 81,
80, 80, 79, 77, 78, 76, 77, 75, 75, 73, 74, 72, 72, 70, 71, 69, 68, 68, 67, 66,
66, 65, 65, 65, 64, 63, 62, 62, 62, 61, 59, 59, 59, 59, 58, 57, 57, 57, 56, 55,
54, 54, 53, 53, 53, 51, 51, 51, 51, 50, 50, 50, 49, 48, 48, 47, 47, 47, 46, 46,
46, 44, 45, 44, 44, 43, 42, 43, 41, 42, 41, 40, 41, 39, 39, 40, 38, 38, 37, 38,
37, 37, 36, 37, 36, 36, 35, 35, 35, 34, 33, 34, 33, 34, 32, 33, 33, 32, 31, 31,
31, 30, 31, 30, 30, 30, 28, 29, 28, 28, 28, 27, 27, 26, 27, 26, 26, 26, 26, 25,
25, 25, 25, 24, 24, 24, 24, 24, 23, 24, 24, 23, 23, 22, 22, 21, 22, 21, 22, 22,
21, 20, 21, 20, 20, 21, 20, 19, 19, 20, 19, 18, 18, 18, 18, 18, 18, 17, 17, 18,
18, 17, 17, 17, 17, 17, 16, 16, 16, 15, 15, 16, 15, 15, 15, 16, 14, 14, 15, 14,
14, 14, 13, 14, 13, 14, 14, 13, 13, 13, 13, 13, 13, 12, 12, 12, 13, 12, 12, 12,
12, 11, 11, 12, 11, 11, 11, 12, 11, 10, 11, 11, 10, 11, 10, 10, 10, 10, 9, 10,
10, 10, 9, 9, 10, 10, 9, 10, 10, 9, 9, 8, 9, 8, 8, 8, 9, 8, 8, 8, 8, 8, 9, 7, 8,
7, 7, 8, 8, 7, 8, 7, 7, 8, 7, 7, 8, 6, 6, 7, 7, 7, 6, 7, 6, 6, 6, 6, 6, 6, 6, 6,
6, 6, 6, 7, 6, 6, 5, 6, 5, 5, 5, 5, 6, 5, 5, 6, 5, 6, 5, 5, 6, 5, 5, 5, 6, 5, 4,
4, 4, 4, 5, 4, 4, 5, 4, 4, 4, 5, 4, 4, 4, 5, 1, -7, -15, -23, -32, -39, -48,
-55, -63, -71, -78, -86, -93, -101, -107, -116, -119, -118, -117, -115, -115,
-114, -113, -112, -111, -109, -109, -108, -106, -106, -104, -103, -102, -102,
-101, -100, -99, -97, -97, -95, -95, -94, -93, -92, -91, -91, -89, -89, -87,
-87, -86, -85, -85, -83, -83, -82, -82, -81, -80, -79, -78, -77, -77, -76, -75,
-75, -73, -73, -72, -72, -71, -71, -70, -68, -68, -67, -67, -67, -66, -65, -64,
-64, -64, -62, -62, -62, -61, -61, -60, -60, -59, -58, -57, -56, -57, -55, -56,
-55, -55, -54, -53, -52, -52, -53, -51, -51, -51, -50, -49, -48, -49, -48, -48,
-47, -47, -47, -46, -45, -45, -44, -45, -43, -43, -43, -42, -43, -41, -41, -41,
-40, -40, -40, -38, -39, -39, -39, -37, -37, -37, -37, -36, -36, -36, -36, -35,
-35, -34, -35, -33, -34, -32, -32, -33, -32, -32, -31, -32, -30, -31, -30, -30,
-29, -30, -29, -29, -29, -29, -27, -29, -24, };