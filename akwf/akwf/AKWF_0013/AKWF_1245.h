#define DATA_LENGTH 512
#define DATA AKWF_1245

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 20, 31, 43, 51, 60, 67, 74, 79, 83,
86, 89, 91, 93, 94, 94, 95, 94, 95, 94, 94, 93, 92, 91, 90, 89, 87, 84, 81, 78,
74, 68, 63, 55, 48, 39, 29, 18, 8, -4, -16, -28, -41, -51, -63, -71, -80, -86,
-91, -92, -94, -92, -88, -82, -75, -67, -56, -47, -37, -24, -11, 3, 13, 22, 30,
38, 44, 48, 52, 55, 57, 57, 58, 56, 55, 55, 53, 50, 48, 46, 44, 42, 40, 39, 38,
36, 35, 34, 33, 33, 32, 32, 33, 33, 32, 31, 31, 32, 31, 30, 29, 27, 25, 24, 21,
19, 16, 13, 11, 7, 3, 0, -2, -6, -8, -12, -13, -15, -16, -17, -18, -18, -19,
-18, -17, -17, -16, -16, -14, -13, -12, -10, -9, -8, -7, -7, -6, -6, -6, -5, -5,
-5, -6, -4, -4, -5, -4, -5, -4, -4, -4, -2, -1, -1, 1, 3, 4, 6, 9, 11, 13, 16,
17, 20, 22, 23, 24, 26, 26, 25, 24, 23, 20, 17, 12, 8, 2, -3, -9, -16, -22, -29,
-36, -40, -46, -51, -54, -57, -58, -58, -58, -57, -55, -51, -46, -41, -36, -30,
-24, -19, -13, -7, -1, 4, 8, 12, 15, 19, 22, 25, 27, 28, 30, 31, 31, 31, 31, 30,
29, 28, 26, 25, 21, 17, 14, 10, 5, -1, -7, -12, -20, -27, -34, -41, -46, -54,
-59, -66, -69, -75, -73, -82, -42, 9, -6, 2, 4, 8, 12, 14, 18, 20, 23, 24, 26,
27, 28, 27, 27, 26, 26, 24, 22, 21, 18, 16, 15, 13, 11, 10, 8, 8, 6, 6, 5, 5, 6,
7, 7, 9, 11, 14, 17, 20, 24, 27, 32, 37, 41, 45, 51, 55, 58, 63, 65, 68, 68, 68,
65, 62, 57, 49, 40, 30, 19, 5, -7, -21, -34, -48, -60, -72, -81, -89, -95, -99,
-101, -99, -97, -93, -87, -81, -74, -65, -56, -47, -37, -27, -18, -9, 0, 8, 15,
21, 27, 34, 38, 42, 45, 48, 50, 52, 52, 53, 53, 51, 49, 48, 45, 42, 36, 33, 26,
19, 12, 4, -4, -13, -23, -34, -43, -55, -64, -76, -84, -95, -100, -110, -110,
-124, -66, 6, -6, 3, 4, 9, 11, 15, 18, 21, 24, 25, 26, 26, 28, 27, 27, 25, 25,
23, 22, 21, 19, 16, 15, 13, 12, 9, 8, 7, 6, 6, 6, 5, 6, 6, 7, 8, 11, 13, 16, 19,
24, 28, 33, 36, 41, 46, 51, 56, 59, 62, 66, 67, 68, 68, 65, 62, 56, 49, 40, 30,
18, 6, -8, -22, -36, -49, -62, -72, -81, -89, -95, -98, -100, -99, -97, -93,
-88, -80, -73, -64, -56, -46, -36, -26, -17, -9, 0, 9, 16, 23, 29, 34, 38, 42,
46, 49, 51, 51, 53, 53, 52, 51, 50, 47, 44, 41, 36, 32, 26, 19, 12, 4, -4, -14,
-24, -34, -44, -55, -65, -75, -85, -93, -102, -107, -113, -117, -119, -119,
-117, -113, -107, -100, -91, -80, -68, -56, -42, -28, -15, -2, };