#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_07

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 6, 10, 12, 15, 17, 19, 23, 25,
28, 31, 33, 36, 40, 41, 45, 48, 51, 54, 56, 59, 62, 66, 68, 72, 74, 77, 79, 84,
85, 89, 91, 93, 96, 97, 98, 98, 99, 99, 101, 100, 100, 102, 102, 103, 103, 104,
103, 105, 105, 106, 106, 107, 106, 107, 108, 107, 108, 108, 110, 110, 110, 110,
110, 111, 111, 111, 111, 112, 112, 112, 113, 113, 113, 114, 114, 113, 114, 114,
115, 115, 115, 115, 115, 115, 115, 116, 116, 116, 116, 116, 116, 116, 117, 117,
117, 117, 117, 117, 118, 118, 118, 117, 118, 118, 118, 118, 119, 118, 119, 119,
118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 120, 119, 119, 120, 120, 119, 119, 119, 118, 118, 119, 118, 119, 118,
118, 119, 119, 119, 119, 118, 118, 117, 118, 119, 118, 118, 118, 117, 117, 117,
117, 117, 117, 116, 116, 117, 116, 117, 116, 116, 115, 115, 115, 115, 115, 115,
114, 113, 115, 113, 113, 114, 113, 112, 112, 112, 112, 111, 111, 111, 110, 110,
110, 109, 109, 109, 109, 108, 107, 107, 108, 107, 106, 105, 105, 104, 104, 104,
103, 103, 102, 102, 102, 102, 100, 99, 100, 99, 99, 97, 96, 96, 93, 91, 89, 86,
83, 80, 78, 75, 71, 69, 65, 62, 60, 56, 53, 51, 48, 45, 42, 40, 36, 33, 30, 28,
26, 23, 21, 17, 15, 11, 9, 6, 4, 1, -1, -3, -7, -10, -12, -14, -17, -20, -22,
-27, -29, -31, -34, -37, -40, -43, -46, -48, -51, -55, -57, -60, -63, -65, -68,
-72, -75, -77, -81, -84, -86, -89, -91, -94, -95, -97, -98, -98, -99, -99, -101,
-100, -101, -102, -102, -103, -103, -103, -104, -104, -105, -105, -105, -107,
-107, -108, -108, -108, -108, -108, -109, -109, -109, -111, -110, -111, -111,
-111, -111, -112, -113, -111, -113, -112, -113, -114, -114, -113, -114, -115,
-115, -115, -115, -115, -116, -116, -115, -115, -116, -116, -117, -116, -117,
-117, -117, -117, -118, -118, -118, -117, -117, -117, -118, -118, -118, -117,
-118, -118, -118, -119, -118, -118, -118, -119, -118, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -118, -119, -120, -119, -118, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -118, -118, -119,
-118, -118, -118, -118, -118, -119, -118, -118, -118, -117, -118, -117, -117,
-117, -117, -117, -116, -116, -116, -117, -116, -116, -115, -115, -116, -115,
-115, -116, -115, -114, -114, -114, -115, -114, -113, -113, -113, -113, -112,
-113, -112, -112, -112, -111, -110, -111, -110, -110, -110, -109, -109, -109,
-109, -108, -107, -107, -107, -106, -106, -106, -105, -104, -103, -104, -103,
-103, -102, -101, -101, -100, -99, -99, -98, -98, -98, -97, -95, -94, -91, -88,
-85, -83, -81, -77, -74, -71, -68, -65, -62, -59, -56, -54, -51, -48, -45, -42,
-39, -36, -33, -30, -28, -26, -22, -20, -17, -14, -11, -9, -6, -3, 0, };