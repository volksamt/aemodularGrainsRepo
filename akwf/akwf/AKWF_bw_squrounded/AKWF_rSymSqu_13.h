#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_13

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 12, 21, 29, 38, 48, 57, 66, 75, 84,
89, 92, 95, 95, 98, 99, 101, 102, 103, 104, 105, 106, 107, 108, 108, 109, 109,
110, 112, 111, 112, 113, 114, 113, 114, 114, 114, 115, 115, 115, 116, 115, 115,
116, 117, 117, 117, 116, 117, 118, 117, 117, 117, 118, 118, 119, 118, 118, 118,
119, 118, 118, 119, 119, 118, 118, 118, 119, 118, 119, 118, 118, 119, 120, 118,
119, 119, 119, 118, 118, 119, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119,
119, 118, 119, 120, 119, 119, 119, 120, 119, 120, 119, 118, 119, 119, 119, 119,
119, 119, 119, 118, 119, 118, 118, 119, 119, 119, 119, 119, 119, 120, 119, 120,
119, 119, 119, 119, 120, 118, 119, 119, 119, 120, 119, 120, 119, 118, 119, 119,
118, 119, 119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 118, 119, 118, 119, 118, 119,
118, 119, 119, 118, 119, 119, 119, 119, 120, 120, 119, 119, 119, 119, 118, 119,
118, 118, 118, 118, 118, 119, 118, 118, 119, 118, 119, 118, 117, 119, 117, 118,
117, 118, 118, 117, 117, 117, 116, 116, 117, 117, 116, 116, 115, 116, 115, 116,
115, 114, 114, 114, 113, 112, 112, 112, 111, 111, 109, 109, 109, 107, 107, 106,
106, 105, 104, 101, 100, 99, 98, 95, 95, 93, 89, 84, 76, 66, 57, 48, 39, 30, 21,
12, 5, -5, -14, -22, -30, -40, -48, -57, -67, -76, -85, -90, -93, -94, -96, -97,
-99, -101, -102, -103, -104, -104, -107, -108, -107, -108, -109, -110, -111,
-111, -111, -112, -112, -113, -113, -114, -114, -115, -114, -116, -116, -116,
-116, -117, -117, -116, -116, -117, -117, -118, -117, -117, -118, -118, -118,
-117, -117, -119, -118, -118, -118, -118, -119, -119, -118, -119, -119, -119,
-118, -118, -119, -119, -119, -119, -118, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -120, -118, -119, -118,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -120, -118,
-119, -119, -119, -118, -119, -119, -119, -119, -120, -119, -120, -118, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -120, -119, -120, -119, -119, -119, -119, -119, -120, -118, -118,
-119, -119, -120, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-118, -120, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -118, -118, -119, -118, -118, -118, -119,
-118, -119, -119, -119, -119, -118, -119, -118, -118, -119, -118, -119, -119,
-118, -118, -118, -118, -118, -118, -117, -118, -117, -117, -118, -118, -117,
-117, -116, -116, -116, -115, -115, -116, -115, -116, -114, -114, -114, -113,
-113, -112, -112, -112, -111, -110, -110, -108, -108, -108, -106, -106, -105,
-104, -104, -102, -101, -99, -97, -96, -94, -92, -89, -84, -74, -65, -56, -47,
-38, -30, -20, -12, -3, };