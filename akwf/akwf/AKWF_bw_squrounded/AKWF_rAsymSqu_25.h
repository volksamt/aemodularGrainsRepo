#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_25

const PROGMEM int8_t DATA[DATA_LENGTH] = {53, 97, 108, 116, 116, 119, 118, 120,
119, 119, 118, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 120, 120, 119, 119, 119, 119,
119, 119, 119, 119, 118, 119, 119, 118, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119,
118, 119, 119, 119, 119, 120, 119, 119, 119, 118, 118, 119, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 118, 120, 120, 120, 119, 119, 120, 120, 119, 118, 118, 119, 119, 120, 119,
119, 119, 119, 118, 119, 119, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 118, 118, 119, 119, 119, 120,
119, 118, 119, 120, 119, 119, 119, 118, 119, 119, 118, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 120, 119, 119, 120, 119, 119, 119, 120, 119, 120, 119, 119, 119, 119,
119, 119, 118, 120, 120, 119, 120, 119, 119, 119, 118, 119, 119, 118, 119, 119,
119, 119, 118, 119, 119, 120, 119, 119, 118, 120, 119, 119, 119, 119, 120, 120,
119, 120, 119, 120, 119, 120, 102, 19, -64, -96, -111, -115, -118, -118, -119,
-119, -118, -120, -119, -120, -120, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -118, -119, -120, -120, -119, -120, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -120, -119, -118, -119, -118, -120, -119, -119, -118, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -120, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -120, -119, -118, -119, -120, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -118, -119, -118, -120, -119, -119, -119, -119, -118,
-120, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-120, -120, -119, -119, -120, -119, -119, -120, -119, -118, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -120, -120, -119, -120, -119,
-120, -119, -119, -119, -119, -120, -118, -119, -119, -119, -119, -120, -119,
-119, -119, -120, -119, -119, -119, -120, -118, -119, -119, -119, -118, -119,
-119, -119, -120, -119, -120, -119, -120, -118, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -120, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -120, -118, -120, -118, -120, -118, -121,
-94, -15, };