#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_25

const PROGMEM int8_t DATA[DATA_LENGTH] = {35, 98, 115, 117, 118, 119, 120, 119,
119, 118, 119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 120, 119, 119, 119, 118, 119, 119, 118, 119, 119, 119, 119, 119, 119, 120,
119, 119, 120, 119, 120, 119, 119, 118, 120, 119, 120, 119, 119, 119, 119, 118,
119, 119, 119, 119, 120, 119, 120, 120, 120, 119, 119, 119, 119, 119, 119, 119,
118, 120, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119, 119, 119,
120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 120, 119, 119, 119,
119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 119, 118, 119,
118, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 118,
119, 120, 119, 119, 120, 119, 118, 119, 119, 119, 119, 120, 119, 119, 119, 119,
119, 119, 120, 119, 119, 120, 120, 119, 119, 120, 120, 119, 120, 118, 119, 120,
119, 118, 119, 119, 120, 119, 119, 120, 120, 118, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 120, 120, 119, 119, 119, 119, 119, 118, 119,
119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119,
118, 119, 119, 118, 119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 118, 119,
119, 119, 119, 119, 117, 115, 100, 39, -45, -102, -115, -117, -118, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -120,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -120, -119,
-118, -119, -119, -119, -119, -119, -118, -119, -119, -118, -119, -120, -119,
-120, -120, -119, -119, -120, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -120, -120, -119, -118, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -120, -120, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -118, -119, -118, -119, -119, -119, -119,
-119, -119, -120, -119, -120, -118, -119, -119, -119, -119, -118, -119, -119,
-119, -118, -119, -120, -119, -119, -120, -119, -119, -119, -118, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -120, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -118, -119, -119, -119, -119, -119, -118, -119, -120, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-118, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -120, -119, -119, -120, -118, -120, -120, -119, -119,
-119, -119, -120, -119, -119, -120, -120, -119, -118, -119, -118, -117, -114,
-95, -33, };