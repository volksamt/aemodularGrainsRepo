#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_04

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 5, 7, 8, 10, 10, 11, 13, 14,
16, 17, 19, 19, 21, 23, 23, 24, 25, 27, 27, 29, 30, 31, 32, 34, 34, 35, 37, 37,
39, 40, 40, 42, 42, 44, 45, 45, 46, 48, 48, 49, 50, 50, 52, 53, 54, 54, 56, 56,
57, 58, 59, 59, 61, 61, 62, 63, 63, 64, 65, 65, 66, 66, 68, 69, 69, 71, 71, 72,
72, 73, 74, 74, 75, 75, 77, 77, 77, 79, 79, 79, 80, 81, 81, 81, 82, 83, 84, 85,
85, 85, 86, 87, 88, 87, 88, 88, 89, 90, 91, 91, 91, 91, 92, 92, 92, 94, 94, 95,
95, 96, 96, 96, 97, 97, 98, 98, 98, 99, 100, 100, 100, 100, 101, 101, 102, 102,
102, 103, 104, 104, 104, 104, 105, 105, 105, 106, 106, 107, 106, 106, 107, 108,
108, 108, 109, 108, 110, 110, 110, 111, 111, 111, 112, 111, 112, 112, 112, 113,
112, 113, 113, 114, 114, 114, 114, 114, 115, 116, 116, 115, 117, 116, 116, 117,
118, 117, 117, 118, 118, 118, 118, 119, 119, 119, 119, 119, 118, 118, 117, 114,
113, 112, 110, 109, 106, 105, 102, 100, 98, 96, 94, 92, 90, 89, 86, 84, 82, 80,
77, 76, 73, 71, 69, 67, 66, 63, 60, 59, 58, 55, 53, 51, 49, 47, 46, 44, 41, 40,
38, 36, 34, 33, 31, 30, 28, 27, 25, 23, 21, 20, 18, 16, 15, 13, 12, 10, 9, 7, 6,
5, 3, 1, 0, -1, -3, -3, -6, -7, -8, -9, -10, -12, -13, -15, -16, -17, -18, -20,
-21, -22, -23, -24, -26, -27, -28, -30, -30, -32, -32, -33, -34, -36, -36, -37,
-38, -40, -40, -42, -43, -44, -44, -45, -46, -47, -48, -49, -51, -51, -52, -52,
-53, -54, -55, -56, -57, -58, -58, -59, -61, -61, -62, -63, -63, -64, -65, -65,
-67, -67, -68, -69, -69, -70, -71, -72, -73, -73, -73, -74, -75, -76, -76, -77,
-78, -78, -78, -79, -80, -80, -81, -81, -82, -83, -84, -84, -85, -86, -85, -86,
-87, -87, -87, -88, -89, -89, -90, -91, -91, -92, -92, -92, -93, -94, -94, -95,
-94, -95, -96, -96, -96, -96, -97, -98, -98, -99, -99, -100, -100, -101, -101,
-101, -102, -102, -102, -103, -104, -103, -104, -104, -105, -105, -105, -106,
-106, -106, -106, -107, -108, -107, -108, -108, -109, -109, -109, -109, -109,
-110, -111, -111, -111, -111, -111, -112, -112, -113, -113, -113, -113, -113,
-113, -114, -114, -115, -116, -116, -116, -115, -116, -116, -116, -116, -117,
-117, -117, -118, -118, -118, -119, -119, -119, -120, -119, -119, -119, -118,
-116, -114, -113, -112, -109, -108, -106, -104, -103, -100, -99, -97, -94, -92,
-90, -87, -86, -84, -82, -79, -77, -74, -73, -71, -69, -67, -65, -62, -61, -59,
-56, -55, -52, -51, -49, -48, -45, -43, -42, -40, -39, -37, -34, -33, -31, -29,
-28, -27, -24, -22, -22, -19, -18, -16, -14, -13, -12, -10, -9, -7, -5, -4, -3,
-1, 0, };