#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_08

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 8, 11, 14, 17, 19, 22, 25, 27,
29, 32, 34, 36, 38, 41, 43, 45, 47, 48, 51, 52, 55, 57, 58, 59, 61, 62, 63, 65,
67, 68, 69, 71, 71, 72, 74, 75, 76, 78, 78, 79, 81, 82, 82, 84, 84, 86, 86, 87,
88, 89, 90, 91, 92, 92, 93, 93, 94, 95, 96, 96, 97, 97, 98, 99, 99, 99, 100,
100, 101, 102, 102, 102, 102, 103, 103, 105, 104, 104, 105, 105, 106, 106, 106,
107, 107, 107, 107, 108, 108, 108, 109, 109, 109, 110, 111, 110, 110, 110, 110,
111, 111, 111, 111, 111, 112, 112, 113, 113, 112, 113, 113, 113, 114, 114, 115,
114, 115, 114, 114, 114, 114, 115, 115, 115, 115, 116, 115, 116, 116, 116, 116,
116, 116, 116, 116, 116, 116, 117, 116, 116, 117, 116, 117, 117, 117, 117, 116,
117, 117, 117, 118, 117, 117, 117, 117, 118, 117, 118, 118, 118, 118, 117, 117,
118, 118, 118, 119, 118, 117, 118, 117, 118, 118, 118, 119, 119, 118, 118, 118,
118, 118, 119, 119, 119, 118, 118, 119, 119, 118, 119, 119, 119, 119, 119, 118,
119, 118, 119, 119, 119, 119, 119, 119, 119, 118, 118, 119, 118, 119, 119, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 115,
111, 108, 102, 98, 93, 88, 83, 78, 73, 68, 63, 59, 54, 50, 45, 41, 37, 32, 28,
25, 21, 17, 14, 10, 7, 4, 0, -2, -6, -9, -12, -15, -17, -20, -23, -25, -28, -30,
-32, -35, -37, -38, -41, -43, -45, -47, -48, -51, -52, -54, -56, -57, -59, -61,
-62, -63, -65, -66, -67, -69, -71, -72, -72, -75, -75, -77, -78, -78, -80, -81,
-82, -82, -83, -84, -85, -87, -87, -88, -88, -90, -91, -92, -92, -92, -94, -94,
-94, -96, -96, -97, -97, -97, -99, -98, -99, -100, -101, -101, -102, -101, -103,
-103, -103, -103, -105, -104, -105, -106, -106, -105, -107, -107, -107, -107,
-108, -108, -108, -109, -109, -109, -109, -110, -109, -110, -110, -111, -111,
-111, -111, -111, -112, -111, -112, -112, -113, -112, -113, -113, -113, -113,
-114, -114, -113, -114, -114, -114, -114, -114, -114, -115, -115, -115, -115,
-115, -115, -116, -115, -116, -116, -116, -115, -116, -116, -116, -116, -116,
-116, -116, -116, -116, -117, -117, -116, -117, -117, -117, -117, -118, -117,
-117, -117, -117, -117, -117, -118, -118, -118, -118, -117, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -118, -119, -118, -118, -118, -118, -118,
-118, -119, -119, -119, -118, -118, -118, -119, -118, -119, -118, -118, -118,
-119, -118, -118, -119, -119, -118, -119, -119, -119, -119, -119, -119, -118,
-119, -118, -118, -119, -118, -119, -118, -119, -119, -118, -119, -119, -119,
-120, -119, -118, -119, -120, -119, -118, -119, -119, -119, -117, -115, -112,
-108, -103, -97, -92, -87, -82, -76, -73, -67, -63, -57, -52, -49, -45, -40,
-36, -31, -27, -24, -19, -17, -14, -10, -6, -4, 0, };