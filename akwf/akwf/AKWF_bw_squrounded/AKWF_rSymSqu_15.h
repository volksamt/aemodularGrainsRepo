#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_15

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 18, 30, 44, 57, 71, 83, 91, 93, 97,
98, 100, 102, 104, 106, 107, 108, 109, 110, 111, 112, 112, 113, 114, 114, 115,
115, 116, 115, 116, 117, 116, 117, 117, 117, 118, 118, 118, 119, 118, 118, 118,
118, 118, 119, 118, 119, 118, 119, 119, 119, 118, 118, 118, 119, 118, 120, 119,
119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119,
119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119,
120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 118, 119, 119, 118, 119, 119, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
118, 119, 119, 118, 118, 119, 118, 119, 118, 118, 118, 118, 119, 118, 117, 118,
117, 118, 118, 117, 117, 117, 116, 117, 117, 116, 116, 115, 115, 113, 113, 112,
113, 112, 111, 110, 109, 108, 106, 105, 104, 102, 100, 98, 96, 94, 91, 84, 72,
58, 44, 31, 19, 6, -6, -19, -33, -45, -59, -72, -84, -91, -94, -96, -99, -101,
-102, -104, -106, -107, -108, -109, -110, -111, -113, -113, -113, -114, -114,
-116, -115, -115, -117, -117, -116, -117, -117, -116, -118, -117, -118, -118,
-118, -118, -118, -118, -118, -119, -119, -118, -119, -118, -119, -118, -119,
-119, -118, -119, -119, -120, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -120, -120, -119, -119, -119, -120, -119, -119, -120, -119, -119,
-119, -120, -119, -118, -119, -118, -120, -119, -119, -118, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -118, -119, -119, -118,
-119, -120, -119, -120, -119, -119, -119, -118, -120, -119, -119, -120, -120,
-119, -119, -119, -119, -118, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -118, -120, -119, -119, -119, -119, -119, -118, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -118, -119, -118, -119, -118,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -118, -120, -118, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -120, -119, -119, -119, -119,
-120, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -118, -119, -119, -119, -118, -117, -118, -118, -117, -118, -118,
-117, -118, -118, -117, -117, -116, -116, -115, -116, -115, -115, -114, -113,
-113, -112, -112, -111, -110, -109, -108, -107, -105, -104, -102, -100, -98,
-97, -93, -91, -82, -70, -56, -43, -30, -17, -4, };