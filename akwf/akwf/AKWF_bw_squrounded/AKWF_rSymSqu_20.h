#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_20

const PROGMEM int8_t DATA[DATA_LENGTH] = {13, 46, 76, 95, 101, 105, 109, 111,
113, 114, 116, 116, 117, 118, 118, 119, 118, 118, 119, 118, 119, 119, 120, 119,
118, 119, 119, 119, 119, 118, 119, 120, 120, 119, 119, 119, 119, 120, 118, 118,
119, 120, 119, 119, 119, 119, 119, 120, 119, 118, 119, 118, 120, 119, 119, 120,
119, 119, 119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 119, 120, 119, 120, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 118, 119, 120, 119, 119, 118, 119, 119, 119,
120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120,
120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 120,
119, 119, 119, 119, 120, 119, 119, 120, 120, 118, 119, 119, 119, 118, 118, 119,
119, 119, 119, 119, 118, 119, 118, 119, 119, 119, 120, 119, 120, 119, 120, 119,
119, 120, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 119,
118, 120, 119, 119, 118, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 120,
120, 118, 119, 119, 119, 119, 118, 118, 118, 118, 117, 117, 116, 115, 114, 113,
111, 109, 106, 101, 95, 79, 47, 14, -16, -50, -80, -95, -102, -106, -109, -111,
-113, -115, -115, -117, -117, -117, -118, -118, -119, -119, -118, -118, -119,
-118, -120, -119, -119, -118, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -120, -120, -119, -119, -120, -119, -118, -120, -120,
-119, -119, -120, -118, -119, -119, -119, -118, -118, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -120, -120, -119, -119,
-119, -118, -119, -118, -120, -119, -120, -119, -119, -119, -120, -119, -120,
-120, -119, -118, -119, -119, -119, -119, -118, -119, -119, -119, -120, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -118, -118, -119, -119, -119, -119, -120, -120, -119, -120,
-120, -119, -120, -119, -120, -119, -119, -119, -119, -119, -119, -118, -120,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -118, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -118, -118, -119, -119, -119, -119, -120, -119, -119, -119, -118,
-119, -120, -119, -120, -119, -119, -119, -120, -119, -119, -119, -120, -119,
-119, -119, -119, -120, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -120, -120, -119, -120, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -118, -119, -119, -119, -119,
-118, -120, -118, -119, -119, -119, -120, -118, -118, -118, -118, -118, -117,
-117, -117, -116, -115, -114, -112, -111, -108, -105, -101, -94, -76, -44, -11,
};