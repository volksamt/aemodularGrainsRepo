#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_23

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 52, 79, 95, 104, 110, 114, 116,
117, 117, 119, 119, 119, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118,
119, 119, 119, 120, 119, 119, 119, 119, 119, 118, 119, 119, 119, 120, 119, 119,
119, 118, 118, 119, 118, 120, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 120,
119, 118, 119, 119, 119, 120, 118, 119, 119, 119, 119, 120, 119, 119, 119, 119,
119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 119, 118, 119, 119, 119, 119, 120, 119,
119, 119, 119, 119, 119, 120, 119, 120, 119, 118, 119, 118, 119, 119, 119, 120,
119, 119, 119, 118, 118, 119, 119, 120, 118, 119, 118, 119, 120, 120, 119, 118,
120, 119, 119, 119, 120, 119, 118, 119, 119, 118, 119, 118, 119, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 118, 118, 120,
119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 119, 120,
119, 119, 120, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120, 119, 120,
119, 120, 119, 119, 119, 119, 118, 119, 119, 120, 120, 120, 119, 119, 120, 119,
119, 119, 118, 119, 119, 119, 109, 56, -13, -55, -80, -96, -105, -110, -113,
-116, -117, -118, -118, -119, -118, -119, -120, -120, -119, -119, -119, -120,
-119, -120, -118, -120, -118, -119, -119, -119, -120, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -120, -120, -118, -119, -120, -119, -119, -119,
-119, -119, -119, -118, -118, -119, -119, -120, -119, -119, -119, -119, -118,
-120, -119, -119, -119, -119, -119, -120, -119, -119, -118, -119, -120, -120,
-119, -119, -120, -120, -120, -120, -119, -118, -119, -119, -120, -119, -118,
-120, -118, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -120, -120, -118, -119, -119, -120, -118, -120, -119, -120,
-119, -119, -119, -119, -119, -119, -118, -120, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -118,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -118, -118, -119, -119, -119, -119, -120, -119, -120, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -120, -119, -119, -119, -118,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -118, -119, -118, -118,
-120, -118, -120, -119, -119, -119, -119, -119, -119, -120, -119, -120, -119,
-119, -119, -120, -119, -120, -119, -119, -120, -119, -119, -118, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -118, -120, -119,
-108, -47, };