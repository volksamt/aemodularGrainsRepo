#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_14

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 14, 23, 31, 37, 44, 50, 56, 61, 66,
70, 75, 78, 82, 85, 87, 90, 92, 95, 96, 98, 100, 102, 104, 105, 106, 107, 107,
109, 109, 110, 111, 112, 113, 113, 113, 115, 114, 115, 115, 115, 116, 116, 116,
117, 116, 117, 118, 117, 117, 117, 117, 117, 118, 118, 118, 119, 118, 117, 118,
118, 119, 119, 119, 118, 118, 118, 119, 119, 118, 119, 118, 119, 118, 118, 119,
119, 119, 119, 118, 119, 119, 119, 118, 119, 119, 120, 120, 120, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 120, 120, 119, 119, 119,
120, 120, 119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 119, 119, 119, 120,
119, 118, 120, 119, 119, 119, 119, 119, 120, 119, 120, 119, 119, 119, 119, 119,
119, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 119, 118, 119, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 120, 119, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 115, 103, 87, 70, 55, 41,
28, 16, 4, -5, -16, -23, -32, -39, -45, -51, -57, -62, -67, -71, -76, -78, -83,
-85, -88, -91, -92, -95, -97, -98, -101, -101, -103, -104, -106, -107, -108,
-109, -109, -111, -111, -112, -112, -113, -113, -114, -115, -114, -116, -115,
-115, -116, -116, -116, -117, -116, -116, -117, -117, -118, -118, -117, -118,
-117, -119, -118, -118, -118, -118, -118, -118, -118, -118, -119, -118, -119,
-119, -119, -119, -118, -119, -119, -119, -118, -119, -119, -118, -119, -118,
-118, -119, -119, -118, -119, -119, -119, -119, -119, -119, -118, -120, -118,
-119, -118, -119, -119, -119, -119, -120, -120, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -118, -120, -119, -119, -120, -119, -119, -118, -119,
-119, -119, -119, -118, -119, -120, -118, -119, -120, -119, -120, -119, -119,
-118, -119, -119, -120, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-120, -119, -119, -119, -118, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -120, -120, -119,
-119, -119, -119, -120, -119, -119, -120, -119, -120, -119, -119, -119, -118,
-120, -119, -119, -118, -118, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -120, -119, -119, -118, -119, -118, -119, -119, -120, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -118,
-118, -118, -120, -120, -120, -119, -119, -119, -120, -118, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -118, -114, -102,
-86, -69, -53, -39, -26, -15, -4, };