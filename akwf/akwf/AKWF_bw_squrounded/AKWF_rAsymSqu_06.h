#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_06

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 6, 10, 10, 13, 15, 15, 19,
19, 21, 23, 24, 26, 27, 30, 30, 32, 34, 36, 37, 39, 40, 41, 43, 44, 45, 46, 49,
49, 50, 52, 52, 54, 55, 56, 57, 58, 59, 60, 61, 63, 63, 65, 65, 66, 67, 69, 69,
70, 71, 72, 73, 74, 74, 74, 76, 76, 77, 78, 79, 80, 80, 81, 82, 82, 84, 83, 84,
85, 86, 86, 87, 87, 88, 88, 89, 90, 91, 91, 91, 92, 92, 93, 94, 93, 94, 95, 95,
95, 96, 97, 97, 98, 98, 99, 99, 99, 100, 100, 101, 101, 101, 101, 102, 102, 102,
103, 104, 103, 104, 105, 104, 104, 105, 106, 106, 105, 105, 107, 107, 107, 106,
108, 108, 108, 108, 108, 108, 109, 109, 109, 110, 110, 110, 111, 111, 110, 110,
112, 112, 111, 112, 112, 112, 112, 112, 113, 113, 113, 113, 113, 113, 114, 113,
114, 114, 114, 115, 114, 114, 114, 115, 115, 115, 115, 116, 116, 116, 115, 116,
116, 116, 117, 116, 116, 117, 117, 116, 116, 116, 117, 117, 117, 117, 118, 118,
117, 118, 117, 118, 118, 118, 118, 118, 118, 119, 119, 118, 119, 119, 119, 119,
119, 118, 118, 118, 119, 118, 119, 119, 118, 118, 115, 113, 110, 108, 104, 101,
98, 95, 91, 88, 85, 81, 77, 75, 72, 68, 66, 63, 59, 56, 53, 50, 47, 45, 42, 40,
36, 34, 31, 29, 26, 24, 21, 19, 17, 15, 11, 10, 7, 5, 2, 1, -1, -3, -6, -7, -8,
-11, -13, -15, -16, -18, -20, -21, -23, -26, -27, -28, -30, -31, -33, -34, -36,
-37, -38, -41, -41, -43, -44, -46, -47, -48, -50, -50, -52, -52, -54, -55, -56,
-58, -58, -60, -60, -61, -62, -64, -64, -66, -66, -68, -69, -70, -70, -70, -72,
-72, -74, -75, -75, -76, -76, -77, -79, -79, -80, -80, -82, -82, -82, -83, -84,
-85, -86, -86, -85, -87, -88, -88, -89, -90, -89, -90, -91, -91, -91, -92, -92,
-93, -94, -94, -94, -95, -96, -96, -97, -96, -98, -98, -99, -98, -99, -99, -100,
-101, -101, -101, -102, -102, -102, -102, -103, -103, -103, -104, -104, -104,
-104, -105, -105, -105, -106, -106, -106, -107, -107, -107, -108, -107, -108,
-108, -108, -109, -109, -109, -110, -109, -110, -109, -110, -110, -111, -111,
-111, -112, -111, -111, -111, -112, -113, -113, -113, -113, -113, -114, -113,
-113, -113, -114, -114, -113, -115, -114, -115, -114, -114, -115, -116, -116,
-115, -115, -115, -115, -115, -117, -116, -115, -116, -116, -117, -117, -117,
-116, -116, -117, -117, -117, -117, -118, -117, -117, -117, -118, -118, -118,
-117, -118, -118, -118, -118, -118, -119, -118, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -118, -118, -119, -117, -115, -113, -110, -107,
-104, -101, -97, -94, -90, -88, -85, -81, -78, -75, -71, -69, -65, -62, -59,
-56, -53, -50, -48, -44, -41, -39, -36, -33, -30, -28, -26, -23, -21, -19, -16,
-15, -12, -9, -7, -5, -3, -1, };