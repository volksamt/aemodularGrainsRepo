#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_13

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 11, 18, 25, 32, 38, 43, 48, 54, 58,
62, 66, 69, 72, 76, 79, 82, 84, 87, 89, 90, 94, 94, 97, 98, 99, 101, 102, 103,
103, 105, 106, 107, 108, 108, 110, 111, 111, 111, 111, 112, 112, 114, 114, 114,
114, 115, 115, 115, 116, 117, 116, 116, 116, 117, 116, 117, 117, 117, 117, 118,
118, 117, 117, 117, 118, 118, 119, 118, 118, 118, 118, 118, 119, 118, 119, 118,
119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 118, 119, 118, 119,
119, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 118, 119, 119, 118, 119, 118,
119, 119, 118, 119, 120, 119, 119, 118, 119, 120, 120, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 119, 120, 119, 118, 118, 119, 119, 119, 119, 120, 120, 119, 119, 119,
120, 119, 120, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 120, 119,
119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 118,
119, 119, 120, 120, 119, 119, 118, 119, 118, 119, 119, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 119, 118, 111, 98, 84, 72, 58, 46, 34, 24,
14, 5, -4, -11, -19, -25, -32, -39, -44, -50, -54, -59, -63, -67, -70, -73, -76,
-80, -82, -85, -87, -89, -92, -93, -94, -97, -98, -100, -102, -102, -103, -105,
-106, -106, -107, -107, -109, -110, -111, -111, -111, -112, -113, -113, -113,
-114, -114, -114, -114, -115, -115, -116, -115, -116, -117, -117, -117, -117,
-118, -117, -117, -118, -117, -118, -117, -117, -118, -118, -118, -119, -118,
-117, -118, -118, -118, -119, -118, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -118, -119, -119, -120, -119, -118, -119,
-119, -119, -119, -118, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -120, -119,
-120, -119, -119, -120, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -118, -119,
-119, -119, -120, -119, -119, -119, -118, -119, -119, -119, -119, -118, -119,
-118, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -118, -119,
-120, -119, -119, -120, -120, -120, -120, -119, -119, -119, -119, -119, -118,
-118, -120, -119, -119, -119, -119, -119, -119, -120, -119, -119, -118, -119,
-120, -119, -119, -119, -118, -119, -119, -117, -109, -97, -83, -69, -56, -44,
-34, -23, -13, -4, };