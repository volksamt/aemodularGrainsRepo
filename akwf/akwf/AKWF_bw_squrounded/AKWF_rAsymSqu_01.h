#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_01

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 4, 6, 6, 9, 10, 10, 12,
12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 25, 26, 27, 28, 28, 28, 31, 31,
32, 33, 34, 36, 36, 37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 47, 47, 49, 50, 51,
52, 52, 53, 54, 55, 56, 56, 57, 58, 59, 61, 61, 61, 63, 64, 65, 65, 67, 68, 68,
69, 69, 71, 71, 72, 73, 74, 75, 75, 77, 78, 77, 79, 80, 81, 82, 82, 83, 84, 85,
85, 86, 87, 88, 89, 90, 91, 92, 91, 93, 94, 94, 94, 96, 97, 97, 98, 99, 99, 100,
101, 102, 102, 103, 105, 105, 105, 107, 107, 108, 109, 109, 110, 110, 112, 112,
113, 114, 114, 115, 116, 116, 117, 118, 118, 118, 119, 119, 119, 120, 119, 120,
118, 118, 118, 118, 118, 117, 116, 116, 116, 115, 114, 114, 113, 113, 111, 111,
110, 109, 108, 107, 106, 106, 104, 103, 103, 102, 100, 99, 98, 98, 96, 95, 94,
93, 91, 90, 89, 88, 87, 86, 85, 84, 83, 82, 80, 79, 78, 77, 76, 74, 72, 72, 71,
70, 68, 67, 66, 64, 63, 62, 60, 60, 59, 57, 55, 55, 53, 53, 51, 50, 49, 47, 46,
45, 44, 43, 41, 41, 39, 39, 37, 36, 34, 34, 32, 30, 30, 28, 27, 26, 25, 24, 23,
21, 21, 19, 17, 17, 15, 15, 15, 13, 12, 11, 9, 8, 7, 6, 5, 3, 3, 1, 1, -1, -2,
-3, -3, -5, -5, -7, -8, -9, -11, -12, -12, -14, -15, -15, -16, -17, -18, -20,
-20, -22, -23, -24, -25, -26, -26, -27, -29, -30, -31, -32, -32, -33, -34, -35,
-36, -38, -38, -40, -40, -42, -42, -43, -44, -44, -46, -47, -48, -49, -50, -51,
-51, -52, -53, -54, -55, -56, -57, -58, -58, -59, -61, -62, -63, -62, -63, -65,
-65, -67, -67, -69, -69, -70, -71, -72, -73, -74, -74, -75, -76, -77, -78, -78,
-79, -79, -81, -82, -82, -82, -84, -84, -86, -86, -87, -88, -88, -90, -90, -91,
-92, -92, -94, -94, -95, -96, -96, -98, -98, -99, -100, -101, -101, -102, -103,
-103, -104, -105, -106, -106, -107, -108, -108, -109, -110, -111, -111, -113,
-113, -114, -115, -114, -115, -116, -117, -117, -118, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -118, -118, -117, -118, -116, -117, -116, -115,
-114, -113, -113, -113, -112, -110, -110, -109, -108, -108, -106, -106, -104,
-103, -102, -101, -101, -99, -98, -98, -96, -95, -93, -93, -92, -90, -89, -88,
-87, -86, -85, -83, -83, -81, -79, -78, -77, -77, -75, -74, -73, -72, -71, -69,
-68, -66, -65, -64, -63, -62, -61, -60, -58, -57, -56, -55, -53, -52, -51, -50,
-49, -47, -46, -45, -44, -43, -42, -40, -39, -38, -36, -36, -34, -32, -32, -31,
-30, -29, -27, -26, -25, -24, -23, -22, -20, -19, -19, -17, -15, -15, -14, -13,
-11, -10, -9, -8, -7, -6, -5, -4, -2, -1, 0, };