#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_11

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 14, 18, 23, 27, 32, 36, 40, 44,
47, 50, 54, 57, 60, 63, 65, 68, 71, 73, 75, 77, 79, 81, 82, 84, 86, 87, 88, 91,
91, 93, 95, 95, 96, 98, 98, 100, 100, 102, 102, 103, 103, 105, 105, 106, 106,
107, 108, 108, 109, 109, 109, 110, 110, 111, 111, 112, 112, 112, 112, 113, 114,
113, 113, 113, 115, 115, 115, 115, 115, 116, 116, 116, 115, 116, 117, 116, 117,
116, 117, 117, 117, 117, 117, 117, 118, 117, 118, 117, 118, 117, 118, 118, 118,
118, 118, 117, 118, 118, 118, 118, 118, 118, 118, 119, 118, 118, 119, 118, 119,
119, 118, 119, 118, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118,
119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 120, 119,
118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 119, 119, 119,
118, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 118, 119, 119, 119, 118, 119, 119, 120, 119, 119, 120, 119, 119,
119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119,
120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119,
118, 118, 114, 106, 97, 87, 79, 69, 60, 52, 44, 36, 29, 22, 15, 9, 3, -2, -9,
-14, -19, -24, -28, -32, -36, -41, -44, -48, -51, -54, -57, -60, -63, -66, -68,
-70, -73, -75, -77, -79, -80, -83, -85, -87, -87, -89, -91, -92, -93, -94, -96,
-97, -98, -98, -100, -100, -102, -102, -103, -104, -104, -105, -106, -106, -107,
-108, -109, -109, -109, -109, -111, -110, -112, -111, -111, -112, -113, -113,
-113, -114, -115, -113, -115, -114, -115, -114, -114, -115, -115, -115, -116,
-116, -116, -116, -116, -116, -117, -117, -117, -117, -117, -117, -117, -118,
-117, -117, -117, -117, -118, -117, -118, -118, -118, -118, -117, -118, -118,
-118, -118, -118, -118, -118, -119, -118, -118, -118, -118, -119, -118, -118,
-119, -118, -118, -119, -119, -118, -119, -118, -118, -119, -119, -120, -118,
-119, -118, -119, -119, -119, -120, -119, -118, -118, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -118, -119, -119, -118, -120, -119, -119, -120, -119, -119, -119, -118,
-119, -118, -119, -119, -119, -119, -118, -118, -120, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -120, -120, -120, -118, -119, -119, -120, -119,
-118, -118, -120, -120, -119, -119, -119, -119, -120, -119, -119, -119, -120,
-119, -119, -120, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-120, -120, -120, -119, -119, -119, -119, -120, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -117, -113, -105,
-97, -86, -77, -69, -60, -52, -42, -35, -29, -21, -15, -8, -2, };