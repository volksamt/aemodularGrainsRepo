#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_24

const PROGMEM int8_t DATA[DATA_LENGTH] = {28, 74, 95, 107, 113, 116, 118, 119,
119, 119, 120, 119, 119, 119, 120, 119, 120, 118, 119, 119, 120, 119, 119, 119,
119, 119, 120, 118, 119, 118, 120, 120, 119, 119, 119, 118, 119, 119, 120, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 120,
119, 120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 120, 119, 120, 119, 119, 119, 119, 119, 118, 120, 119, 119, 120, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 119,
119, 119, 118, 120, 119, 119, 118, 119, 119, 120, 119, 119, 118, 119, 120, 120,
119, 119, 119, 119, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 118,
119, 119, 118, 119, 119, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 120, 119, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 118, 120, 120, 120, 118, 119, 118, 119, 119, 120, 120,
119, 119, 120, 119, 120, 119, 119, 118, 119, 119, 118, 119, 119, 119, 118, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 120, 120,
119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 120, 119, 118, 118, 120, 106, 41, -36, -76, -97, -107, -114, -116, -118,
-118, -119, -118, -119, -119, -120, -119, -119, -119, -118, -119, -119, -120,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -118, -119, -119,
-118, -119, -120, -118, -119, -119, -119, -120, -118, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -120, -120, -119, -120, -119, -118, -119, -119, -119, -119, -120,
-118, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -120, -120,
-119, -119, -119, -119, -119, -118, -120, -119, -119, -118, -119, -118, -119,
-119, -119, -119, -119, -120, -120, -120, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -120, -120, -120, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -120, -119, -120, -120, -119, -119, -119, -118, -118, -120, -119, -119,
-118, -119, -119, -118, -118, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -120, -119, -118, -118, -119, -119, -119, -119, -119, -119,
-120, -120, -120, -119, -118, -120, -118, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -120, -119, -119, -120, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -120, -118,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -120,
-102, -33, };