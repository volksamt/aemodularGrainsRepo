#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_01

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 5, 6, 8, 8, 10, 11, 11,
13, 14, 15, 17, 18, 18, 21, 21, 22, 24, 24, 25, 27, 27, 30, 30, 32, 32, 33, 35,
35, 36, 37, 39, 41, 42, 42, 43, 45, 46, 47, 49, 49, 50, 51, 53, 54, 55, 56, 57,
58, 59, 60, 62, 63, 64, 66, 66, 68, 68, 69, 70, 72, 73, 74, 75, 76, 77, 79, 79,
80, 82, 82, 84, 84, 85, 87, 87, 89, 89, 90, 92, 93, 94, 95, 96, 96, 98, 99, 100,
100, 101, 103, 103, 104, 105, 106, 107, 108, 108, 110, 109, 110, 111, 112, 112,
113, 114, 115, 115, 115, 116, 117, 116, 117, 117, 118, 119, 118, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 119, 119, 119, 118, 119, 118,
118, 117, 118, 117, 116, 116, 115, 114, 114, 113, 113, 112, 111, 111, 110, 110,
108, 107, 107, 106, 105, 105, 103, 101, 101, 100, 100, 99, 97, 97, 96, 95, 94,
92, 92, 90, 90, 89, 87, 87, 85, 85, 83, 82, 81, 80, 79, 78, 77, 76, 75, 74, 73,
72, 70, 69, 69, 66, 66, 64, 64, 62, 62, 60, 60, 59, 58, 56, 55, 54, 53, 51, 51,
49, 49, 47, 46, 44, 43, 43, 41, 40, 39, 39, 37, 35, 34, 33, 32, 32, 30, 29, 28,
27, 25, 25, 24, 23, 20, 20, 19, 17, 17, 15, 14, 14, 12, 11, 10, 8, 8, 7, 5, 4,
2, 2, 0, -1, -1, -4, -5, -6, -6, -8, -9, -9, -10, -12, -14, -15, -16, -17, -17,
-19, -20, -21, -22, -23, -25, -26, -27, -28, -29, -30, -31, -33, -33, -34, -36,
-36, -38, -39, -41, -42, -43, -44, -45, -46, -47, -49, -49, -51, -52, -53, -53,
-54, -56, -57, -58, -60, -60, -61, -63, -64, -65, -66, -67, -69, -70, -71, -72,
-73, -73, -76, -77, -77, -79, -79, -80, -81, -83, -84, -84, -86, -87, -87, -89,
-90, -91, -91, -93, -94, -95, -96, -97, -97, -98, -99, -100, -102, -102, -103,
-104, -105, -106, -107, -107, -107, -109, -110, -111, -111, -112, -112, -113,
-114, -115, -115, -115, -116, -117, -117, -117, -117, -118, -118, -118, -119,
-118, -118, -119, -119, -118, -119, -120, -118, -119, -120, -119, -119, -120,
-118, -119, -118, -119, -118, -118, -117, -117, -116, -116, -115, -115, -115,
-113, -113, -112, -112, -111, -110, -109, -109, -109, -108, -106, -106, -105,
-105, -103, -102, -101, -101, -100, -98, -98, -96, -96, -94, -94, -93, -92, -90,
-89, -88, -87, -87, -85, -84, -83, -82, -81, -80, -79, -78, -76, -76, -75, -74,
-73, -71, -70, -69, -68, -67, -66, -65, -64, -63, -61, -60, -59, -58, -57, -55,
-55, -54, -52, -51, -50, -49, -48, -47, -46, -44, -44, -43, -41, -40, -39, -38,
-37, -35, -35, -33, -32, -32, -30, -28, -27, -26, -26, -24, -23, -22, -21, -20,
-18, -17, -16, -15, -14, -13, -12, -11, -10, -9, -8, -6, -5, -4, -2, -1, -1, };