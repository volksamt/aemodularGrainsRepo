#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_14

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 14, 25, 36, 46, 57, 68, 80, 89, 93,
96, 97, 98, 101, 101, 103, 104, 106, 107, 108, 108, 110, 110, 111, 112, 112,
113, 114, 113, 114, 115, 115, 115, 115, 115, 116, 116, 118, 118, 118, 117, 117,
118, 117, 117, 117, 118, 118, 118, 118, 118, 119, 118, 118, 119, 119, 118, 119,
119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 118, 119, 119, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 118, 119, 120, 120, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 119,
120, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 119, 119,
118, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 119, 119, 119,
119, 118, 119, 119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 119, 120, 118,
120, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 118, 119, 119, 119,
119, 119, 119, 118, 119, 120, 119, 119, 119, 119, 118, 119, 118, 118, 119, 118,
118, 118, 119, 118, 118, 118, 119, 117, 119, 117, 118, 118, 118, 117, 116, 116,
117, 117, 116, 117, 116, 116, 116, 115, 114, 113, 113, 113, 113, 112, 111, 110,
109, 109, 109, 106, 106, 104, 103, 102, 101, 98, 97, 94, 93, 88, 79, 70, 58, 47,
36, 25, 15, 6, -6, -15, -26, -37, -47, -58, -69, -81, -89, -92, -95, -97, -99,
-100, -102, -104, -104, -107, -106, -107, -109, -110, -110, -111, -112, -113,
-113, -114, -114, -114, -115, -115, -115, -115, -116, -116, -117, -117, -116,
-117, -118, -118, -117, -118, -118, -119, -117, -119, -119, -118, -118, -118,
-118, -118, -119, -119, -119, -119, -119, -119, -119, -118, -118, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -120,
-120, -119, -119, -120, -119, -119, -119, -119, -118, -118, -118, -119, -119,
-118, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -120, -119,
-119, -119, -120, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -120, -119, -119, -119, -119, -119, -120, -118, -119, -119, -119,
-120, -119, -119, -119, -119, -118, -119, -119, -119, -119, -118, -119, -119,
-120, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -120, -120, -118, -119, -119, -120, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -118, -118, -119, -118, -118, -118, -118,
-118, -117, -118, -118, -117, -118, -118, -117, -116, -116, -116, -116, -116,
-115, -115, -115, -115, -114, -115, -114, -114, -113, -113, -111, -111, -110,
-109, -109, -108, -108, -106, -104, -103, -102, -100, -99, -97, -95, -93, -88,
-79, -68, -57, -45, -34, -25, -14, -3, };