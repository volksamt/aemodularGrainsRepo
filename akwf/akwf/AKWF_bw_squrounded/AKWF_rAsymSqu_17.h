#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_17

const PROGMEM int8_t DATA[DATA_LENGTH] = {13, 29, 41, 52, 61, 69, 76, 82, 87,
92, 95, 99, 102, 104, 106, 108, 109, 111, 112, 113, 113, 114, 115, 116, 117,
117, 116, 117, 117, 118, 118, 117, 118, 118, 119, 118, 119, 118, 118, 118, 118,
119, 119, 119, 118, 119, 119, 119, 119, 118, 119, 120, 120, 119, 119, 119, 119,
119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 119, 120, 119, 120, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119,
118, 120, 120, 119, 119, 119, 119, 120, 119, 119, 118, 118, 118, 119, 119, 119,
119, 119, 119, 118, 119, 119, 119, 118, 119, 119, 119, 119, 120, 119, 119, 119,
119, 119, 119, 118, 120, 119, 120, 120, 118, 119, 120, 119, 119, 119, 120, 119,
119, 119, 119, 118, 119, 120, 119, 119, 119, 119, 119, 120, 120, 120, 119, 119,
119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 119, 119, 120, 120, 120, 119, 119, 119, 118, 118, 119, 119, 119,
119, 119, 120, 119, 119, 119, 119, 118, 118, 119, 119, 118, 119, 120, 119, 119,
119, 119, 119, 119, 118, 119, 119, 119, 118, 119, 120, 119, 119, 120, 119, 119,
118, 119, 118, 119, 119, 119, 118, 120, 119, 119, 118, 119, 119, 119, 120, 119,
120, 115, 97, 69, 44, 20, 1, -15, -30, -43, -53, -62, -70, -77, -83, -89, -92,
-96, -100, -102, -105, -106, -108, -110, -111, -112, -113, -114, -114, -115,
-116, -116, -116, -116, -118, -118, -117, -119, -118, -119, -118, -119, -118,
-118, -119, -118, -119, -119, -119, -119, -119, -119, -119, -118, -120, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -120, -119, -119,
-119, -119, -120, -119, -118, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -120,
-120, -120, -118, -120, -119, -120, -120, -119, -119, -119, -119, -118, -118,
-119, -119, -119, -119, -118, -119, -119, -120, -119, -119, -119, -120, -119,
-119, -119, -120, -119, -119, -119, -118, -120, -119, -119, -119, -120, -120,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -118, -120, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -118, -119, -119, -120,
-119, -119, -119, -119, -120, -118, -119, -119, -118, -119, -119, -119, -120,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -118, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -120, -119, -120, -120, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -118, -119, -120, -120, -119, -119, -119,
-119, -119, -119, -119, -118, -118, -113, -95, -66, -41, -18, -1, };