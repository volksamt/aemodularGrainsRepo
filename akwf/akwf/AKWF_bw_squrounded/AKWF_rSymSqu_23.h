#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_23

const PROGMEM int8_t DATA[DATA_LENGTH] = {29, 80, 99, 106, 111, 115, 116, 117,
118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 118, 120, 119, 119, 119,
119, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 120, 119, 119, 119, 119,
119, 119, 118, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 119, 119, 119, 120, 120, 119, 120, 118, 119, 119, 119, 119, 119, 120,
119, 119, 120, 119, 119, 119, 119, 120, 119, 120, 118, 120, 119, 119, 119, 120,
120, 120, 119, 119, 120, 119, 120, 120, 120, 120, 119, 119, 119, 119, 119, 119,
120, 119, 118, 119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 120, 119, 119,
119, 119, 119, 119, 120, 118, 118, 119, 120, 119, 119, 120, 119, 119, 119, 118,
119, 120, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 120, 119, 120, 120, 119, 120, 119, 120, 118, 120, 119, 119, 119, 119,
119, 119, 119, 119, 120, 119, 119, 118, 119, 118, 119, 119, 119, 119, 119, 120,
120, 119, 119, 119, 119, 120, 118, 119, 120, 119, 120, 119, 119, 120, 119, 119,
120, 119, 119, 119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 118, 118, 118,
117, 116, 114, 112, 107, 99, 81, 33, -37, -83, -100, -107, -112, -115, -117,
-117, -117, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -120, -119, -119, -118, -119, -118, -118, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -120, -120, -119, -118, -119, -118,
-119, -119, -120, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -120, -120, -119, -120, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-120, -119, -119, -119, -119, -119, -118, -119, -118, -119, -119, -120, -119,
-120, -120, -119, -119, -118, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -118, -119, -120, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-120, -120, -119, -119, -119, -120, -118, -118, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -120, -118, -120, -118, -119, -120, -118,
-120, -119, -119, -119, -119, -119, -118, -118, -116, -115, -112, -107, -98,
-78, -25, };