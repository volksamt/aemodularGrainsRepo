#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_10

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 11, 16, 22, 27, 31, 36, 41, 46,
52, 57, 62, 67, 72, 77, 82, 86, 90, 92, 94, 94, 95, 96, 97, 98, 98, 100, 100,
101, 101, 103, 103, 104, 105, 104, 106, 106, 107, 108, 107, 108, 109, 109, 110,
110, 110, 111, 111, 111, 112, 112, 113, 113, 113, 113, 113, 113, 115, 114, 114,
115, 114, 115, 115, 116, 116, 115, 116, 116, 116, 116, 117, 117, 117, 117, 117,
116, 117, 117, 117, 117, 118, 117, 118, 118, 118, 118, 117, 117, 118, 119, 118,
119, 118, 118, 118, 119, 118, 118, 118, 118, 118, 118, 119, 118, 118, 119, 119,
118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 120, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 119, 118, 119, 119,
118, 119, 118, 119, 118, 119, 118, 119, 117, 119, 118, 117, 117, 119, 118, 118,
118, 117, 117, 117, 117, 117, 117, 117, 116, 117, 116, 117, 116, 116, 116, 115,
115, 115, 114, 114, 115, 115, 115, 114, 113, 113, 113, 113, 113, 113, 113, 112,
112, 111, 110, 110, 111, 110, 109, 110, 109, 108, 107, 108, 107, 107, 106, 105,
105, 104, 103, 102, 102, 101, 101, 99, 99, 98, 97, 96, 96, 93, 93, 92, 90, 86,
83, 77, 72, 66, 62, 56, 51, 47, 41, 36, 31, 26, 22, 16, 11, 6, 3, -2, -8, -13,
-17, -22, -26, -31, -36, -42, -47, -51, -57, -62, -67, -73, -77, -83, -88, -90,
-92, -93, -94, -95, -96, -97, -98, -99, -100, -101, -101, -102, -103, -103,
-104, -105, -105, -106, -106, -107, -107, -108, -108, -109, -109, -110, -110,
-110, -111, -111, -112, -112, -112, -112, -113, -112, -113, -113, -114, -114,
-114, -114, -115, -115, -115, -116, -116, -115, -115, -115, -115, -116, -115,
-116, -116, -117, -116, -117, -118, -117, -117, -118, -118, -117, -117, -117,
-117, -118, -118, -117, -118, -118, -119, -119, -118, -118, -118, -119, -119,
-119, -118, -119, -118, -118, -120, -119, -118, -118, -120, -119, -119, -119,
-120, -119, -119, -119, -119, -118, -119, -119, -119, -118, -120, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -118, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -118, -118, -119, -119, -118, -119, -118, -118,
-118, -118, -117, -118, -118, -118, -117, -117, -117, -118, -118, -117, -117,
-117, -117, -117, -117, -117, -116, -117, -116, -117, -116, -115, -116, -116,
-115, -115, -115, -115, -115, -114, -114, -114, -113, -114, -113, -114, -113,
-113, -112, -112, -111, -112, -111, -111, -110, -110, -110, -109, -109, -108,
-108, -107, -107, -106, -106, -104, -104, -103, -104, -103, -102, -100, -100,
-100, -99, -98, -97, -96, -95, -94, -93, -92, -90, -86, -82, -76, -71, -67, -61,
-57, -51, -46, -40, -36, -31, -26, -21, -16, -11, -7, -1, };