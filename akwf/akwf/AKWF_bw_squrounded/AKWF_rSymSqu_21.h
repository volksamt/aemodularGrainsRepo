#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_21

const PROGMEM int8_t DATA[DATA_LENGTH] = {18, 61, 87, 98, 104, 107, 111, 113,
115, 116, 117, 118, 118, 118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118,
119, 120, 119, 120, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118,
119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 120, 120, 119,
119, 119, 120, 119, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 120, 118, 119, 119, 118, 119, 120, 119, 120,
119, 119, 119, 119, 119, 118, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 120, 119, 119, 118, 119, 119, 119, 120, 120,
119, 120, 118, 120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 119, 119, 119, 118, 119, 120, 118, 118, 120, 120, 119, 119, 118, 119,
120, 119, 119, 119, 119, 119, 119, 119, 120, 119, 118, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 120,
118, 119, 119, 119, 120, 119, 120, 119, 120, 119, 120, 120, 119, 118, 119, 118,
118, 120, 119, 119, 120, 119, 118, 119, 119, 119, 119, 117, 118, 117, 116, 115,
114, 111, 108, 104, 98, 88, 61, 20, -23, -65, -89, -98, -104, -108, -112, -113,
-115, -117, -117, -118, -118, -118, -119, -118, -118, -119, -119, -119, -119,
-120, -119, -118, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -120, -119,
-119, -119, -118, -120, -119, -119, -119, -119, -118, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -120, -119,
-119, -120, -119, -120, -120, -119, -119, -120, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -118, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -120, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -120, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -118, -120, -118, -119, -119, -119, -120, -119, -119,
-118, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -118, -119, -118, -118,
-118, -118, -117, -117, -116, -115, -113, -111, -108, -102, -98, -86, -58, -16,
};