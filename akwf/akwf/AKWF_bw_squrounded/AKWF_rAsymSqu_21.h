#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_21

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 37, 59, 76, 88, 97, 103, 107, 110,
113, 115, 115, 117, 118, 118, 118, 118, 119, 119, 118, 119, 119, 118, 120, 119,
119, 119, 119, 118, 119, 119, 120, 118, 120, 119, 118, 119, 119, 119, 119, 120,
119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 120, 120, 119, 120, 119, 118,
120, 118, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 120, 120, 119, 119,
119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119,
119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119,
120, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118,
120, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 118, 120, 120, 118, 119,
119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 120, 120, 119, 119, 119, 119,
120, 119, 119, 119, 118, 119, 119, 119, 118, 119, 119, 119, 120, 119, 119, 119,
120, 119, 120, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119,
119, 119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 120, 120, 120, 118, 119,
119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 120, 118, 119, 119, 118, 119,
118, 119, 119, 119, 115, 86, 34, -9, -39, -61, -77, -89, -97, -104, -107, -112,
-113, -115, -116, -117, -118, -117, -118, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -120, -120, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -120, -120, -120, -119, -119, -119, -120,
-119, -120, -119, -118, -120, -119, -120, -119, -120, -118, -119, -119, -120,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -120, -119,
-119, -120, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -118, -119, -120, -118, -119,
-119, -119, -119, -118, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -120, -119, -118,
-120, -118, -119, -118, -119, -119, -120, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -120, -119, -118, -119, -119, -120, -118,
-118, -118, -119, -119, -119, -119, -118, -119, -120, -119, -119, -119, -119,
-119, -119, -118, -120, -119, -119, -119, -120, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -120, -120, -119, -119, -119, -119, -118,
-119, -119, -120, -119, -118, -119, -119, -119, -119, -118, -119, -119, -118,
-119, -120, -119, -120, -118, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -118, -120, -118, -119, -120, -119, -119, -119, -113, -81, -26, };