#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_16

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 20, 36, 51, 66, 82, 92, 96, 99,
101, 103, 106, 107, 109, 109, 110, 112, 113, 113, 115, 115, 116, 116, 116, 116,
117, 117, 118, 117, 118, 118, 117, 118, 118, 119, 118, 118, 118, 118, 118, 119,
119, 119, 119, 120, 119, 118, 119, 120, 118, 118, 119, 119, 119, 119, 120, 119,
119, 119, 119, 119, 120, 118, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 119, 118, 119, 119, 118, 119, 118, 118, 119, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 120, 118,
119, 119, 119, 118, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119,
119, 120, 119, 118, 119, 118, 120, 119, 120, 120, 119, 119, 119, 119, 119, 119,
119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119,
119, 120, 119, 119, 119, 119, 119, 118, 119, 120, 119, 119, 119, 119, 119, 120,
119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119,
119, 120, 119, 120, 119, 119, 118, 120, 119, 120, 118, 119, 119, 119, 120, 119,
118, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 118, 118, 118, 118, 118, 118, 118, 117, 117, 117, 117, 117, 116,
116, 115, 114, 114, 114, 113, 112, 110, 110, 109, 107, 105, 103, 101, 99, 96,
92, 83, 67, 51, 35, 21, 6, -8, -22, -37, -52, -68, -84, -93, -96, -99, -102,
-103, -105, -107, -109, -109, -110, -112, -112, -114, -114, -115, -115, -115,
-116, -116, -117, -117, -117, -117, -117, -117, -117, -117, -118, -119, -119,
-119, -119, -118, -118, -118, -119, -119, -119, -119, -118, -118, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -118, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -118, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -120, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -120, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -118, -119, -119, -119, -119, -118, -119, -119,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -118, -119, -120, -118, -119, -120, -119,
-119, -119, -119, -119, -120, -120, -119, -119, -119, -118, -120, -120, -118,
-119, -120, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -120, -120, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -118, -118, -118, -118, -119, -119, -118,
-119, -119, -118, -118, -118, -118, -117, -117, -117, -118, -117, -117, -116,
-117, -117, -116, -115, -114, -114, -113, -112, -111, -110, -109, -108, -107,
-105, -103, -101, -99, -96, -91, -81, -67, -49, -35, -19, -5, };