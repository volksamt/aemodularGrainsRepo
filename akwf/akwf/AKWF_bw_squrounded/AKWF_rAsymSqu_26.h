#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_26

const PROGMEM int8_t DATA[DATA_LENGTH] = {20, 97, 115, 118, 119, 118, 120, 119,
120, 118, 120, 118, 120, 118, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 120, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119,
119, 120, 119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119, 118, 119, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 118, 118, 119, 119,
119, 119, 119, 118, 120, 119, 120, 119, 119, 119, 119, 119, 119, 120, 120, 119,
119, 119, 118, 119, 119, 119, 118, 119, 119, 119, 118, 119, 120, 119, 119, 119,
119, 119, 119, 118, 119, 119, 118, 118, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 118, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 120, 119,
119, 119, 119, 119, 118, 119, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119,
118, 119, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 120, 120,
120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 120, 119, 121, 83, -29, -102, -114, -119, -118, -120, -118,
-120, -119, -119, -120, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-118, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -120, -120, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -120, -119, -118, -120, -118, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -118, -119, -119, -118, -119, -118, -120, -119, -119, -118,
-119, -119, -118, -120, -119, -120, -119, -120, -120, -119, -119, -119, -119,
-120, -119, -118, -118, -120, -119, -119, -119, -120, -119, -119, -119, -119,
-118, -119, -120, -119, -119, -119, -119, -118, -119, -119, -119, -119, -118,
-119, -120, -120, -119, -119, -118, -118, -120, -119, -119, -119, -119, -118,
-119, -119, -119, -120, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -119, -120, -119, -119, -118, -119, -119,
-119, -120, -119, -120, -119, -119, -120, -119, -118, -119, -120, -119, -119,
-119, -119, -120, -118, -119, -118, -119, -119, -120, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -118, -119, -120, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -118, -119, -119, -119, -119, -120, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -118,
-118, -119, -118, -119, -119, -119, -119, -119, -119, -120, -117, -121, -116,
-122, -69, };