#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_17

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 24, 41, 61, 79, 92, 98, 101, 103,
106, 107, 109, 111, 111, 113, 113, 115, 115, 115, 116, 116, 116, 117, 118, 118,
117, 119, 118, 117, 119, 118, 118, 118, 118, 119, 119, 119, 119, 119, 119, 119,
119, 118, 120, 119, 119, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
118, 118, 119, 118, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119,
119, 119, 118, 119, 120, 119, 118, 119, 119, 119, 118, 119, 119, 119, 118, 119,
119, 119, 119, 119, 119, 119, 119, 119, 118, 120, 120, 119, 118, 119, 119, 119,
120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 120, 119, 119, 119, 118,
119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119, 119, 119, 120, 118, 120,
120, 118, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 118, 119, 118, 118, 119, 118, 119, 118, 119, 119, 118, 118, 118,
119, 119, 119, 119, 119, 120, 118, 119, 119, 120, 119, 120, 118, 119, 119, 119,
119, 119, 119, 119, 119, 118, 118, 118, 119, 119, 118, 118, 118, 118, 117, 117,
117, 116, 116, 116, 115, 115, 115, 113, 112, 111, 110, 109, 108, 106, 103, 101,
98, 92, 79, 61, 43, 25, 8, -9, -26, -44, -63, -80, -93, -98, -101, -104, -105,
-108, -110, -111, -112, -113, -114, -114, -115, -115, -115, -116, -117, -117,
-117, -118, -118, -119, -119, -119, -118, -119, -118, -119, -118, -119, -119,
-119, -119, -118, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -118, -119, -119, -119, -119, -119, -120,
-120, -119, -119, -119, -119, -120, -119, -120, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -118, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -118, -118, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -120, -118,
-119, -120, -119, -118, -119, -118, -119, -118, -119, -119, -119, -119, -119,
-118, -119, -120, -119, -119, -119, -118, -118, -119, -118, -119, -119, -119,
-120, -119, -119, -119, -120, -120, -119, -119, -119, -120, -120, -119, -118,
-119, -119, -119, -119, -119, -119, -118, -120, -119, -120, -120, -119, -119,
-119, -119, -119, -119, -120, -120, -119, -120, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -118, -119, -120, -118, -119, -119, -119, -119, -120,
-119, -118, -119, -118, -119, -119, -118, -119, -118, -118, -118, -118, -118,
-117, -117, -118, -116, -117, -116, -116, -114, -115, -113, -112, -112, -110,
-109, -107, -105, -103, -100, -97, -90, -77, -58, -40, -23, -7, };