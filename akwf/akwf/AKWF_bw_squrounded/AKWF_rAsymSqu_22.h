#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_22

const PROGMEM int8_t DATA[DATA_LENGTH] = {23, 57, 77, 92, 99, 107, 111, 113,
115, 117, 118, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 118,
119, 119, 120, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
119, 118, 119, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 120,
119, 119, 118, 118, 119, 118, 119, 120, 119, 119, 119, 119, 118, 120, 120, 119,
119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120, 118, 120,
119, 119, 119, 120, 119, 119, 119, 119, 119, 118, 120, 119, 119, 120, 119, 120,
119, 120, 119, 119, 119, 119, 119, 120, 119, 119, 118, 120, 119, 120, 119, 119,
119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119, 120, 119, 120,
119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 120, 119, 120, 119,
119, 119, 119, 119, 119, 119, 118, 119, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 120, 120, 118, 119, 119, 119, 119, 119, 119, 119, 120, 120, 119,
119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 120, 119, 119, 119,
120, 120, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
118, 119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 118, 119, 120, 119, 119,
119, 119, 119, 119, 119, 115, 78, 16, -29, -59, -79, -92, -101, -106, -110,
-114, -115, -117, -117, -118, -118, -118, -119, -119, -119, -119, -120, -118,
-119, -119, -119, -118, -119, -118, -119, -119, -118, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -120, -118, -118, -119, -119, -118, -119,
-119, -119, -119, -118, -119, -118, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -120, -119, -119, -118, -119, -119, -120, -119,
-118, -118, -118, -120, -119, -119, -119, -120, -120, -120, -119, -120, -119,
-119, -119, -119, -119, -118, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -120, -119, -119, -119, -118, -119, -119,
-120, -119, -120, -119, -119, -118, -119, -119, -119, -118, -119, -118, -119,
-120, -120, -119, -119, -120, -118, -119, -120, -120, -119, -118, -119, -118,
-120, -119, -119, -119, -119, -120, -118, -118, -118, -119, -119, -119, -120,
-119, -119, -118, -119, -120, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -120, -119, -119, -118, -119, -119, -119, -118, -119, -120, -119, -119,
-118, -119, -120, -119, -119, -119, -119, -118, -119, -118, -120, -119, -119,
-119, -119, -119, -120, -120, -118, -120, -120, -119, -120, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -120, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -120, -119, -118, -119, -120,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -118, -119, -119, -113,
-71, -12, };