#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_02

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 3, 4, 6, 7, 8, 9, 11, 12, 13,
15, 16, 17, 18, 20, 21, 22, 23, 25, 26, 27, 29, 30, 31, 33, 34, 36, 37, 37, 40,
40, 42, 42, 44, 46, 47, 48, 49, 50, 52, 53, 54, 56, 57, 58, 59, 61, 63, 64, 65,
66, 67, 69, 70, 72, 73, 74, 76, 76, 78, 78, 80, 81, 83, 84, 86, 87, 87, 89, 90,
92, 93, 94, 95, 97, 97, 99, 99, 100, 102, 103, 105, 105, 106, 108, 108, 110,
110, 112, 112, 113, 114, 115, 114, 116, 117, 117, 117, 117, 118, 118, 118, 117,
118, 118, 118, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 120, 118, 120,
119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 118, 119, 119, 119, 119, 118, 118, 118, 119, 119, 118, 118, 118, 118, 118,
119, 118, 119, 118, 117, 117, 117, 115, 116, 115, 115, 114, 113, 112, 111, 111,
109, 108, 108, 106, 106, 104, 103, 102, 100, 100, 98, 98, 96, 96, 94, 93, 91,
90, 89, 87, 86, 85, 84, 82, 81, 80, 79, 78, 76, 75, 74, 73, 72, 71, 69, 67, 66,
65, 64, 63, 60, 59, 59, 57, 56, 54, 53, 52, 50, 49, 48, 47, 45, 44, 43, 41, 41,
39, 39, 37, 36, 34, 32, 31, 30, 29, 28, 26, 26, 24, 23, 21, 20, 18, 17, 16, 15,
14, 13, 11, 10, 8, 6, 5, 4, 3, 1, 1, 0, -2, -4, -4, -6, -7, -9, -10, -11, -13,
-13, -15, -16, -18, -19, -20, -21, -23, -24, -25, -26, -27, -29, -29, -32, -33,
-34, -35, -36, -38, -38, -40, -42, -43, -45, -45, -47, -48, -49, -50, -52, -53,
-55, -56, -58, -58, -60, -61, -62, -63, -65, -66, -68, -68, -70, -72, -72, -74,
-75, -77, -78, -80, -81, -82, -82, -84, -86, -87, -88, -90, -91, -92, -92, -94,
-95, -96, -98, -98, -101, -101, -102, -103, -104, -105, -106, -107, -108, -109,
-110, -111, -112, -112, -114, -114, -115, -115, -116, -117, -117, -117, -118,
-118, -117, -117, -118, -119, -118, -119, -119, -119, -118, -118, -119, -119,
-119, -118, -120, -118, -120, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -118, -120, -120, -119, -118, -119, -119, -119, -119, -119, -118,
-118, -118, -118, -118, -119, -118, -119, -118, -118, -118, -117, -118, -118,
-117, -117, -118, -117, -117, -117, -116, -115, -115, -114, -113, -112, -113,
-111, -110, -110, -108, -107, -106, -105, -104, -103, -101, -101, -100, -98,
-97, -96, -95, -93, -93, -91, -90, -89, -88, -87, -85, -84, -82, -82, -80, -79,
-78, -77, -76, -74, -72, -71, -71, -69, -67, -66, -64, -63, -62, -60, -60, -58,
-57, -55, -54, -52, -53, -50, -49, -47, -47, -46, -44, -43, -41, -39, -39, -37,
-36, -35, -34, -32, -32, -30, -29, -27, -26, -25, -24, -22, -21, -19, -18, -17,
-16, -15, -12, -12, -11, -10, -8, -7, -5, -4, -3, -2, -1, };