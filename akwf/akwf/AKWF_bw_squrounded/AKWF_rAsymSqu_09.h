#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_09

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 12, 15, 19, 22, 25, 28, 32,
33, 36, 39, 42, 45, 47, 50, 52, 54, 55, 58, 60, 62, 63, 64, 66, 69, 70, 71, 73,
75, 75, 78, 79, 80, 82, 82, 84, 84, 86, 87, 87, 90, 90, 91, 91, 92, 93, 95, 95,
96, 97, 97, 99, 99, 99, 100, 100, 101, 102, 102, 103, 104, 105, 105, 105, 106,
106, 106, 107, 107, 108, 108, 108, 108, 109, 109, 109, 110, 110, 110, 110, 110,
111, 111, 112, 112, 112, 112, 113, 112, 113, 113, 113, 114, 114, 113, 114, 114,
115, 114, 114, 115, 115, 116, 115, 116, 116, 116, 116, 116, 116, 116, 116, 116,
117, 116, 117, 117, 117, 117, 117, 118, 117, 117, 117, 117, 118, 117, 117, 118,
117, 117, 118, 118, 118, 118, 118, 118, 119, 118, 119, 118, 118, 118, 118, 118,
118, 118, 118, 119, 118, 118, 119, 119, 119, 118, 118, 118, 118, 119, 119, 118,
118, 119, 119, 118, 119, 118, 119, 118, 119, 118, 118, 119, 118, 118, 119, 119,
120, 119, 118, 119, 119, 119, 118, 119, 119, 118, 119, 119, 119, 119, 119, 119,
118, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 113, 109, 102, 97, 91, 84, 78, 72, 66, 59,
54, 49, 44, 39, 32, 29, 23, 19, 15, 10, 6, 3, -2, -6, -9, -12, -16, -19, -22,
-26, -28, -32, -34, -37, -40, -42, -44, -47, -50, -52, -53, -56, -57, -60, -61,
-64, -66, -67, -69, -70, -72, -73, -75, -76, -77, -79, -81, -82, -82, -85, -84,
-86, -87, -89, -89, -90, -91, -92, -93, -94, -95, -96, -97, -97, -97, -98, -98,
-100, -100, -100, -101, -102, -103, -103, -104, -105, -104, -105, -105, -106,
-106, -107, -107, -108, -108, -109, -108, -109, -110, -110, -109, -110, -111,
-111, -111, -111, -112, -111, -112, -112, -112, -112, -113, -113, -114, -114,
-114, -114, -114, -114, -114, -115, -115, -115, -115, -115, -116, -115, -115,
-115, -116, -116, -116, -116, -116, -116, -116, -116, -116, -117, -117, -117,
-117, -117, -117, -117, -117, -117, -117, -118, -117, -117, -118, -118, -118,
-117, -118, -118, -117, -117, -117, -118, -118, -118, -118, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -118, -118, -119, -118, -118, -118, -118,
-118, -119, -119, -118, -119, -118, -119, -119, -119, -119, -118, -119, -119,
-118, -118, -119, -119, -118, -118, -119, -119, -119, -120, -119, -118, -119,
-119, -119, -119, -118, -119, -119, -120, -119, -119, -118, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -117, -113, -108, -102,
-96, -89, -83, -77, -71, -66, -60, -53, -48, -43, -37, -33, -28, -23, -18, -15,
-9, -6, -1, };