#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_15

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 15, 25, 34, 43, 51, 57, 63, 68, 74,
79, 82, 86, 89, 93, 95, 97, 99, 101, 103, 104, 105, 108, 108, 110, 110, 111,
112, 113, 113, 115, 114, 115, 114, 116, 116, 117, 117, 117, 116, 118, 117, 117,
118, 118, 119, 119, 118, 118, 118, 118, 119, 119, 119, 119, 118, 119, 118, 119,
118, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 120, 119, 119, 119, 119, 118, 118, 119, 119, 119, 119, 119, 119, 119,
118, 119, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119,
119, 119, 119, 120, 120, 118, 119, 119, 118, 119, 119, 119, 119, 119, 119, 120,
118, 119, 119, 119, 119, 119, 119, 119, 120, 119, 120, 119, 119, 119, 120, 119,
118, 120, 120, 120, 119, 119, 118, 119, 120, 119, 118, 120, 119, 119, 119, 119,
119, 119, 120, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119,
118, 119, 119, 119, 118, 119, 120, 119, 118, 120, 119, 119, 119, 119, 119, 118,
119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119,
119, 119, 120, 120, 119, 119, 119, 119, 120, 118, 119, 119, 119, 118, 109, 93,
72, 55, 38, 22, 9, -4, -16, -26, -35, -43, -51, -58, -63, -69, -73, -78, -83,
-86, -88, -92, -95, -98, -99, -101, -102, -104, -106, -107, -108, -110, -111,
-111, -112, -113, -113, -114, -114, -115, -116, -116, -116, -116, -117, -117,
-118, -117, -118, -117, -118, -118, -118, -117, -118, -118, -118, -118, -119,
-119, -119, -118, -119, -118, -118, -119, -119, -119, -118, -119, -118, -119,
-118, -119, -120, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -118, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -118, -119, -119, -119, -120, -120, -119, -120, -119, -118, -119,
-119, -120, -119, -119, -119, -120, -118, -119, -119, -118, -119, -119, -119,
-120, -119, -118, -120, -120, -119, -119, -119, -119, -120, -119, -120, -119,
-120, -119, -118, -119, -118, -119, -119, -120, -119, -119, -118, -119, -120,
-120, -118, -119, -119, -119, -120, -120, -119, -120, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -118, -119, -118, -119, -119, -120, -119, -119, -119, -119,
-118, -119, -119, -118, -119, -119, -120, -119, -120, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -118, -109, -91, -71, -53, -36, -21, -6, };