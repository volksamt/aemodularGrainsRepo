#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_12

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 16, 25, 32, 38, 45, 54, 60, 69,
77, 83, 89, 92, 94, 96, 96, 99, 100, 100, 101, 103, 103, 104, 105, 105, 107,
108, 109, 108, 109, 110, 110, 112, 112, 112, 112, 112, 113, 113, 113, 114, 114,
114, 115, 115, 116, 116, 116, 116, 116, 116, 116, 117, 116, 116, 117, 117, 117,
118, 117, 117, 117, 118, 117, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118,
118, 118, 118, 119, 119, 118, 118, 119, 118, 118, 119, 119, 119, 118, 119, 119,
118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 120, 119, 119,
119, 120, 119, 119, 119, 119, 119, 120, 119, 120, 119, 118, 119, 119, 119, 119,
119, 120, 119, 119, 119, 119, 118, 119, 118, 120, 120, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 118, 118, 118, 118, 119, 119, 118, 118, 119, 119, 119, 118, 119, 118, 118,
118, 118, 118, 118, 117, 117, 118, 117, 117, 117, 117, 117, 117, 117, 117, 116,
116, 117, 116, 116, 116, 115, 115, 115, 115, 115, 114, 113, 114, 114, 113, 112,
112, 112, 112, 111, 110, 109, 109, 109, 108, 108, 106, 107, 105, 104, 104, 102,
101, 100, 100, 98, 97, 96, 93, 93, 89, 84, 76, 69, 61, 53, 46, 38, 31, 24, 17,
10, 4, -3, -11, -17, -25, -32, -39, -47, -54, -61, -69, -77, -83, -90, -93, -94,
-95, -97, -98, -99, -100, -101, -103, -103, -105, -105, -105, -106, -108, -108,
-109, -110, -110, -110, -111, -111, -112, -112, -112, -113, -113, -114, -114,
-115, -115, -115, -115, -116, -115, -116, -116, -117, -117, -117, -117, -117,
-117, -117, -117, -117, -117, -117, -117, -118, -117, -117, -118, -118, -118,
-117, -118, -118, -119, -119, -118, -119, -118, -119, -118, -119, -119, -119,
-119, -118, -119, -118, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -118, -119, -119, -120, -118, -118, -119, -119, -119,
-119, -119, -119, -120, -120, -119, -119, -119, -119, -119, -120, -119, -119,
-118, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -120, -119, -119, -119, -118, -119, -118,
-119, -119, -119, -118, -118, -119, -119, -118, -118, -118, -118, -118, -118,
-118, -118, -119, -118, -119, -118, -118, -119, -119, -118, -118, -118, -118,
-118, -117, -118, -118, -117, -118, -117, -117, -117, -118, -118, -117, -117,
-117, -116, -118, -116, -117, -117, -116, -117, -116, -115, -115, -115, -115,
-115, -115, -114, -115, -114, -113, -112, -113, -113, -112, -111, -111, -110,
-109, -109, -108, -108, -107, -107, -106, -105, -105, -104, -103, -102, -100,
-99, -98, -97, -95, -94, -92, -88, -83, -75, -67, -60, -53, -45, -37, -30, -24,
-16, -8, -2, };