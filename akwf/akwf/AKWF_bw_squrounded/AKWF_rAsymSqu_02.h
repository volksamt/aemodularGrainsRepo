#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_02

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 4, 6, 7, 7, 8, 10, 11, 11,
13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 24, 24, 26, 26, 27, 28, 29, 30, 31, 32,
33, 34, 35, 36, 36, 38, 38, 39, 40, 41, 42, 43, 44, 45, 45, 47, 48, 48, 49, 50,
51, 51, 53, 53, 54, 56, 56, 57, 57, 58, 60, 59, 61, 61, 62, 63, 64, 65, 65, 66,
67, 68, 69, 69, 70, 71, 72, 72, 73, 74, 75, 75, 75, 76, 78, 78, 80, 80, 80, 82,
82, 83, 83, 84, 84, 85, 85, 86, 87, 88, 89, 88, 90, 90, 91, 92, 92, 92, 94, 94,
95, 96, 96, 97, 98, 97, 98, 99, 101, 100, 100, 102, 102, 103, 103, 104, 104,
105, 106, 106, 107, 107, 108, 109, 109, 109, 110, 111, 111, 112, 112, 113, 114,
114, 114, 115, 116, 116, 116, 117, 118, 118, 118, 118, 118, 119, 119, 119, 119,
118, 117, 117, 116, 116, 116, 114, 113, 112, 111, 111, 109, 108, 107, 105, 105,
103, 102, 101, 99, 98, 97, 96, 94, 93, 91, 89, 88, 87, 86, 84, 83, 81, 80, 78,
77, 75, 75, 73, 72, 71, 69, 68, 66, 64, 63, 61, 60, 59, 58, 56, 54, 53, 51, 50,
49, 48, 46, 45, 45, 43, 41, 40, 39, 37, 36, 35, 33, 32, 31, 29, 29, 27, 25, 24,
23, 22, 21, 20, 19, 17, 16, 15, 14, 13, 11, 11, 9, 8, 7, 6, 4, 3, 1, 1, 1, -1,
-2, -3, -4, -6, -7, -8, -10, -10, -11, -13, -13, -14, -15, -16, -18, -19, -19,
-20, -21, -22, -24, -24, -25, -26, -27, -28, -29, -29, -32, -32, -33, -33, -35,
-36, -37, -38, -38, -39, -41, -41, -42, -43, -43, -45, -46, -46, -47, -48, -49,
-50, -51, -52, -53, -53, -54, -56, -56, -56, -58, -59, -59, -60, -61, -62, -63,
-64, -64, -65, -66, -66, -67, -68, -68, -70, -70, -71, -72, -73, -73, -74, -75,
-76, -76, -76, -77, -79, -80, -80, -80, -81, -81, -82, -84, -84, -85, -85, -86,
-87, -88, -87, -89, -89, -89, -90, -92, -91, -93, -92, -93, -95, -95, -96, -96,
-97, -97, -98, -99, -99, -99, -100, -100, -101, -102, -102, -103, -104, -104,
-104, -106, -106, -107, -107, -107, -109, -109, -110, -110, -111, -111, -112,
-112, -112, -114, -115, -114, -115, -115, -116, -116, -117, -118, -118, -118,
-119, -119, -119, -119, -119, -119, -118, -118, -117, -117, -115, -115, -114,
-113, -112, -111, -110, -109, -108, -107, -106, -104, -104, -102, -100, -99,
-98, -97, -95, -93, -93, -91, -89, -89, -87, -85, -84, -83, -81, -80, -78, -77,
-76, -74, -73, -72, -70, -69, -67, -66, -64, -62, -61, -61, -58, -57, -56, -54,
-54, -52, -51, -49, -47, -46, -45, -44, -42, -41, -40, -38, -36, -36, -35, -34,
-32, -30, -30, -28, -27, -25, -25, -24, -22, -20, -20, -18, -17, -16, -15, -13,
-13, -11, -9, -9, -7, -6, -5, -4, -3, -2, 0, };