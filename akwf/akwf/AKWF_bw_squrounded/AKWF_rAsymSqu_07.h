#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_07

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 8, 11, 14, 16, 18, 20, 22,
24, 26, 28, 30, 32, 34, 36, 37, 39, 41, 43, 45, 45, 47, 48, 50, 53, 53, 55, 56,
58, 59, 60, 62, 63, 64, 65, 67, 67, 68, 69, 70, 72, 73, 73, 75, 76, 76, 77, 78,
80, 80, 82, 82, 82, 83, 85, 85, 86, 86, 87, 88, 88, 90, 90, 91, 91, 92, 92, 93,
93, 93, 95, 96, 95, 95, 97, 97, 97, 98, 98, 99, 99, 100, 99, 101, 101, 102, 101,
102, 103, 102, 103, 104, 104, 105, 105, 105, 105, 105, 106, 106, 107, 106, 106,
108, 108, 109, 108, 109, 109, 108, 109, 110, 109, 110, 110, 111, 111, 111, 111,
111, 111, 112, 112, 112, 112, 112, 112, 113, 113, 113, 113, 113, 114, 113, 114,
113, 113, 114, 114, 115, 114, 115, 115, 115, 115, 115, 115, 115, 115, 115, 116,
116, 115, 116, 116, 115, 116, 117, 117, 117, 116, 116, 116, 116, 117, 116, 116,
118, 117, 118, 117, 117, 118, 118, 118, 117, 117, 117, 118, 118, 118, 118, 118,
117, 118, 118, 118, 118, 118, 118, 119, 118, 119, 119, 118, 118, 119, 118, 119,
118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 119, 119,
119, 119, 119, 118, 116, 114, 111, 108, 104, 101, 97, 92, 88, 84, 80, 76, 72,
68, 64, 60, 57, 53, 49, 45, 42, 38, 36, 32, 29, 26, 23, 20, 17, 14, 11, 8, 5, 4,
1, -2, -5, -7, -9, -12, -14, -16, -19, -21, -23, -25, -27, -28, -30, -32, -35,
-36, -38, -39, -41, -43, -44, -46, -47, -49, -50, -52, -54, -55, -57, -58, -59,
-60, -62, -63, -63, -64, -66, -67, -69, -70, -71, -71, -73, -74, -74, -75, -76,
-77, -79, -79, -79, -81, -82, -82, -84, -84, -85, -86, -86, -88, -87, -88, -89,
-89, -90, -91, -92, -93, -93, -93, -95, -94, -96, -95, -96, -97, -98, -97, -99,
-98, -99, -100, -99, -100, -101, -101, -102, -101, -102, -103, -103, -103, -103,
-104, -104, -104, -105, -106, -105, -106, -106, -107, -106, -107, -107, -108,
-107, -108, -109, -109, -109, -109, -109, -110, -110, -110, -110, -111, -111,
-111, -111, -111, -111, -112, -111, -112, -112, -112, -113, -113, -113, -112,
-113, -113, -114, -113, -114, -115, -114, -114, -114, -115, -114, -114, -114,
-114, -115, -115, -116, -115, -115, -116, -115, -117, -116, -115, -116, -116,
-116, -116, -117, -116, -116, -116, -117, -117, -116, -117, -116, -118, -116,
-118, -118, -117, -117, -117, -117, -117, -118, -118, -118, -118, -117, -118,
-117, -118, -118, -118, -118, -118, -118, -118, -119, -118, -118, -118, -119,
-119, -118, -118, -118, -118, -119, -118, -118, -119, -118, -119, -119, -119,
-118, -120, -119, -118, -118, -119, -119, -119, -119, -118, -117, -114, -111,
-107, -104, -100, -96, -92, -88, -84, -79, -76, -72, -68, -63, -60, -56, -52,
-49, -45, -41, -38, -36, -32, -29, -26, -23, -19, -17, -14, -10, -8, -5, -3, 0,
};