#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_26

const PROGMEM int8_t DATA[DATA_LENGTH] = {47, 110, 116, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 118, 120, 119, 119, 119,
119, 119, 119, 120, 118, 119, 119, 118, 119, 119, 118, 118, 119, 119, 119, 119,
119, 119, 119, 118, 119, 119, 120, 119, 119, 118, 119, 119, 118, 119, 119, 120,
119, 120, 119, 120, 119, 119, 119, 119, 119, 120, 118, 119, 119, 120, 118, 118,
119, 119, 119, 119, 119, 119, 119, 120, 119, 120, 119, 119, 119, 118, 119, 119,
119, 120, 119, 119, 119, 120, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119,
119, 120, 119, 120, 119, 119, 120, 119, 119, 119, 119, 119, 120, 119, 119, 119,
119, 120, 119, 119, 118, 119, 119, 119, 118, 119, 119, 120, 119, 119, 119, 119,
119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
118, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119, 120, 120, 119, 120, 119,
119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 120, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120, 118, 119,
119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 119, 118, 119, 116, 110, 53, -59, -112, -117, -119, -118, -119, -119,
-120, -119, -120, -119, -119, -119, -119, -118, -120, -118, -119, -119, -119,
-120, -119, -119, -120, -119, -119, -119, -119, -118, -118, -118, -118, -119,
-119, -118, -118, -119, -119, -118, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -120, -119,
-119, -119, -118, -119, -120, -119, -119, -118, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -120, -119, -120, -120, -120, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -118, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -120, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -118, -120, -119, -119,
-119, -119, -120, -119, -119, -120, -119, -119, -120, -118, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -120, -118, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -118, -118, -118, -120, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -118, -119, -120, -119, -120, -119, -118, -119, -119, -120, -120, -119,
-119, -118, -120, -119, -119, -120, -119, -120, -119, -120, -119, -119, -119,
-120, -119, -120, -119, -120, -119, -119, -119, -119, -119, -118, -119, -116,
-108, -42, };