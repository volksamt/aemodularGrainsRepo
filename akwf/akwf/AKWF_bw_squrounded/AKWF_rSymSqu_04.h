#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_04

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 7, 9, 10, 13, 13, 15, 17,
19, 20, 23, 24, 25, 28, 29, 31, 33, 34, 36, 37, 39, 41, 41, 44, 45, 47, 49, 51,
52, 54, 56, 58, 59, 60, 63, 64, 66, 68, 70, 72, 73, 75, 77, 78, 80, 82, 83, 85,
87, 88, 91, 93, 93, 95, 97, 99, 100, 102, 103, 105, 106, 107, 109, 109, 110,
110, 111, 111, 111, 112, 112, 112, 112, 112, 113, 113, 114, 114, 114, 114, 115,
115, 115, 115, 115, 115, 116, 116, 117, 116, 117, 117, 117, 117, 117, 117, 117,
117, 118, 118, 117, 119, 118, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119,
119, 119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 118, 118, 118, 118, 118,
117, 119, 118, 118, 118, 117, 117, 118, 118, 117, 117, 116, 117, 117, 116, 116,
116, 117, 116, 116, 115, 115, 115, 115, 115, 114, 114, 113, 113, 113, 113, 113,
112, 112, 113, 112, 112, 111, 111, 111, 110, 109, 108, 107, 106, 104, 104, 102,
101, 99, 97, 96, 94, 93, 91, 89, 88, 85, 84, 83, 80, 79, 76, 76, 74, 72, 70, 68,
66, 64, 62, 61, 60, 58, 56, 55, 52, 51, 49, 47, 45, 43, 43, 40, 39, 37, 35, 33,
33, 30, 28, 28, 25, 24, 21, 21, 19, 17, 15, 14, 12, 10, 9, 7, 6, 4, 3, 1, -1,
-3, -4, -6, -7, -9, -11, -12, -14, -16, -17, -19, -21, -22, -24, -25, -27, -29,
-31, -32, -34, -36, -38, -39, -41, -42, -44, -46, -48, -49, -51, -52, -55, -56,
-58, -59, -62, -62, -65, -67, -68, -70, -72, -74, -75, -77, -79, -80, -82, -83,
-85, -88, -89, -91, -93, -94, -96, -97, -99, -100, -102, -104, -105, -105, -107,
-108, -109, -110, -110, -111, -112, -112, -111, -111, -112, -112, -113, -114,
-114, -113, -114, -114, -115, -115, -115, -115, -114, -116, -116, -117, -115,
-117, -116, -116, -117, -117, -117, -117, -117, -118, -117, -117, -117, -117,
-118, -118, -118, -119, -118, -118, -118, -118, -118, -119, -119, -119, -118,
-119, -119, -120, -118, -119, -120, -119, -120, -119, -119, -120, -120, -119,
-120, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -118, -118,
-118, -118, -119, -118, -118, -118, -118, -118, -118, -118, -117, -118, -118,
-118, -118, -117, -117, -117, -116, -117, -116, -116, -115, -116, -116, -116,
-116, -115, -115, -114, -115, -114, -114, -114, -113, -114, -113, -112, -112,
-113, -112, -111, -111, -111, -110, -110, -109, -108, -107, -106, -104, -103,
-102, -101, -98, -96, -95, -93, -92, -90, -89, -87, -85, -84, -82, -80, -79,
-76, -75, -74, -72, -70, -68, -66, -65, -62, -61, -59, -58, -55, -53, -53, -51,
-49, -48, -45, -43, -42, -40, -38, -38, -35, -34, -32, -29, -29, -26, -26, -23,
-22, -21, -19, -17, -15, -14, -12, -11, -9, -7, -6, -3, -2, -1, };