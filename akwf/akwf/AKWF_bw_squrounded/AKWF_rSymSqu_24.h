#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_24

const PROGMEM int8_t DATA[DATA_LENGTH] = {33, 90, 108, 113, 116, 117, 118, 119,
119, 119, 119, 119, 119, 118, 120, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 120, 119, 119, 118, 120, 119, 120, 119, 118,
119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 120, 119, 120, 118, 120, 119, 119, 118, 118, 119, 119, 118,
119, 119, 119, 119, 120, 119, 120, 120, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 120, 118, 119, 119,
119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 120, 120,
119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 118,
119, 119, 119, 119, 118, 119, 119, 118, 118, 120, 119, 119, 119, 119, 119, 118,
118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
120, 118, 119, 119, 120, 120, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119,
119, 118, 120, 119, 119, 119, 119, 119, 120, 118, 119, 119, 120, 120, 119, 120,
120, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118,
119, 119, 119, 120, 119, 118, 118, 119, 118, 119, 120, 119, 119, 119, 118, 119,
119, 119, 118, 116, 114, 108, 90, 37, -42, -93, -108, -113, -116, -118, -119,
-118, -119, -119, -119, -118, -119, -119, -119, -119, -120, -118, -119, -119,
-119, -120, -118, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -120, -118, -119, -119, -118, -119, -120, -119, -119,
-119, -119, -119, -120, -119, -120, -120, -119, -120, -119, -119, -119, -120,
-119, -119, -119, -118, -119, -119, -119, -118, -119, -119, -119, -119, -120,
-119, -118, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -118, -119, -118, -119, -120, -119, -119, -118, -119, -119, -119, -119,
-119, -118, -119, -119, -120, -119, -118, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -120, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -118, -119, -119, -119,
-120, -120, -120, -119, -119, -119, -119, -119, -120, -120, -119, -119, -119,
-119, -120, -119, -120, -119, -119, -118, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -120, -120, -118,
-118, -119, -119, -119, -119, -119, -119, -118, -119, -120, -118, -119, -119,
-119, -119, -118, -120, -119, -119, -120, -119, -119, -119, -119, -119, -118,
-119, -120, -119, -119, -120, -120, -119, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -120, -118, -119, -118, -118, -118, -116, -113, -107,
-87, -29, };