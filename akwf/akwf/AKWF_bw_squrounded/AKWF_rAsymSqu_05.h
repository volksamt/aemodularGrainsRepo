#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_05

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 5, 7, 9, 11, 13, 13, 16, 17,
18, 19, 21, 22, 24, 25, 27, 28, 29, 30, 31, 32, 34, 36, 36, 37, 39, 40, 41, 43,
43, 45, 45, 47, 48, 50, 50, 50, 52, 53, 53, 55, 56, 56, 58, 59, 60, 60, 61, 62,
63, 63, 65, 65, 66, 67, 68, 69, 70, 71, 71, 71, 72, 73, 74, 75, 76, 75, 77, 78,
79, 79, 79, 80, 81, 81, 82, 83, 83, 84, 85, 85, 85, 86, 86, 87, 88, 88, 88, 88,
90, 90, 91, 91, 93, 92, 93, 93, 94, 94, 94, 95, 95, 95, 96, 97, 98, 98, 98, 99,
98, 99, 99, 99, 101, 100, 101, 101, 102, 102, 102, 103, 103, 103, 104, 103, 105,
104, 105, 105, 106, 105, 106, 106, 107, 108, 108, 107, 108, 108, 109, 109, 109,
110, 109, 109, 110, 111, 110, 110, 110, 111, 111, 111, 112, 112, 112, 113, 113,
112, 113, 113, 113, 114, 114, 114, 113, 115, 115, 115, 115, 115, 115, 116, 116,
116, 116, 116, 116, 116, 117, 116, 116, 117, 117, 117, 118, 118, 118, 118, 118,
118, 118, 119, 119, 118, 119, 119, 119, 118, 118, 118, 116, 115, 113, 111, 109,
106, 105, 102, 100, 97, 94, 91, 89, 86, 84, 80, 78, 75, 73, 70, 68, 65, 62, 61,
58, 56, 53, 51, 49, 47, 44, 42, 40, 37, 34, 33, 31, 29, 26, 25, 23, 21, 19, 16,
15, 13, 11, 9, 7, 6, 4, 3, 1, -1, -2, -4, -6, -7, -9, -11, -13, -14, -15, -16,
-18, -19, -21, -23, -24, -25, -27, -28, -29, -30, -32, -33, -34, -36, -36, -38,
-39, -40, -41, -43, -44, -45, -47, -47, -49, -49, -51, -50, -52, -53, -54, -54,
-56, -57, -58, -59, -59, -60, -61, -63, -63, -64, -66, -66, -67, -66, -68, -69,
-70, -70, -72, -73, -72, -74, -74, -74, -76, -76, -77, -78, -78, -78, -80, -80,
-80, -81, -82, -82, -83, -83, -84, -85, -86, -86, -87, -87, -88, -88, -90, -89,
-89, -89, -90, -92, -91, -92, -93, -93, -94, -94, -94, -94, -95, -96, -96, -97,
-97, -97, -98, -98, -99, -99, -99, -99, -99, -101, -101, -102, -102, -102, -103,
-102, -104, -103, -103, -104, -104, -104, -106, -106, -105, -106, -107, -106,
-106, -107, -108, -108, -107, -108, -108, -109, -109, -109, -110, -110, -110,
-110, -110, -111, -110, -111, -110, -112, -111, -112, -112, -112, -112, -113,
-113, -112, -113, -113, -113, -114, -114, -115, -114, -115, -115, -116, -115,
-115, -115, -115, -115, -115, -116, -116, -117, -116, -116, -118, -117, -117,
-118, -117, -117, -118, -118, -118, -119, -119, -118, -119, -119, -119, -118,
-119, -118, -118, -117, -114, -113, -110, -109, -107, -103, -101, -99, -97, -93,
-91, -88, -85, -82, -81, -78, -75, -73, -70, -68, -65, -62, -60, -57, -55, -53,
-51, -48, -46, -43, -41, -39, -37, -35, -33, -30, -28, -27, -25, -23, -21, -19,
-17, -15, -14, -12, -8, -8, -6, -4, -2, -1, };