#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_12

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 17, 22, 28, 33, 39, 43, 47, 51,
55, 59, 63, 65, 69, 72, 75, 78, 79, 82, 84, 86, 87, 89, 91, 93, 95, 96, 98, 98,
99, 100, 102, 102, 103, 105, 106, 106, 106, 107, 108, 110, 110, 110, 110, 110,
111, 112, 112, 113, 113, 113, 114, 114, 114, 114, 115, 115, 115, 115, 116, 116,
117, 116, 116, 117, 117, 117, 117, 117, 117, 117, 117, 118, 118, 118, 118, 118,
118, 118, 118, 118, 118, 118, 119, 118, 119, 118, 119, 119, 119, 118, 118, 118,
119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 118,
119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 119, 119, 118, 118, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119,
119, 120, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119, 119, 120,
118, 119, 120, 119, 119, 119, 119, 119, 118, 120, 118, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 119, 118, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119,
120, 119, 120, 119, 118, 116, 107, 97, 85, 74, 63, 53, 44, 34, 26, 16, 9, 3, -6,
-11, -18, -24, -29, -33, -39, -44, -48, -52, -56, -59, -63, -66, -69, -71, -74,
-77, -79, -82, -84, -87, -88, -90, -91, -93, -94, -97, -97, -98, -100, -100,
-102, -102, -104, -104, -106, -105, -108, -108, -108, -108, -110, -110, -110,
-111, -112, -111, -112, -113, -113, -114, -114, -114, -114, -115, -115, -115,
-116, -116, -116, -116, -116, -116, -116, -116, -116, -118, -117, -117, -117,
-117, -117, -117, -118, -118, -118, -118, -119, -117, -117, -119, -118, -118,
-117, -118, -118, -119, -119, -118, -119, -118, -119, -119, -118, -118, -118,
-119, -119, -119, -119, -118, -119, -119, -119, -118, -119, -118, -119, -119,
-118, -119, -119, -119, -119, -119, -118, -119, -120, -120, -118, -119, -119,
-119, -118, -119, -119, -119, -118, -119, -120, -118, -118, -120, -119, -119,
-119, -120, -118, -119, -119, -118, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -120, -119, -119, -118, -118, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -118, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -120, -119, -119, -118, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -115, -106, -96, -85, -73, -62, -52, -43, -33, -25, -16, -9,
-2, };