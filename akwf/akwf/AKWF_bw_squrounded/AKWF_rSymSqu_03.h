#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_03

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 6, 8, 9, 11, 12, 14, 15,
16, 18, 19, 21, 22, 24, 25, 26, 29, 29, 31, 33, 34, 35, 37, 38, 39, 41, 42, 44,
46, 48, 49, 50, 52, 53, 54, 56, 57, 59, 60, 62, 64, 65, 67, 68, 69, 70, 72, 74,
75, 77, 78, 80, 81, 82, 84, 85, 87, 88, 90, 91, 93, 94, 96, 97, 98, 101, 100,
103, 104, 105, 106, 107, 109, 110, 110, 111, 113, 113, 114, 115, 114, 115, 115,
115, 116, 116, 116, 116, 116, 116, 116, 117, 116, 118, 117, 117, 118, 117, 118,
118, 117, 118, 118, 118, 119, 118, 118, 118, 118, 119, 119, 119, 119, 118, 120,
118, 119, 119, 118, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 118, 119, 119, 119, 118, 119, 119, 119, 118, 119, 119, 118, 119, 119, 119,
118, 118, 119, 117, 118, 118, 117, 118, 117, 116, 117, 117, 117, 117, 117, 116,
116, 115, 116, 116, 115, 116, 115, 114, 114, 113, 112, 111, 111, 110, 108, 107,
106, 104, 104, 102, 101, 100, 99, 97, 96, 94, 92, 91, 89, 89, 87, 86, 83, 83,
81, 79, 79, 77, 75, 73, 72, 71, 69, 68, 66, 65, 63, 61, 60, 58, 57, 56, 55, 53,
52, 49, 48, 46, 46, 45, 42, 42, 40, 38, 37, 35, 34, 32, 32, 29, 27, 27, 25, 24,
23, 21, 20, 17, 16, 14, 13, 12, 10, 9, 8, 7, 5, 4, 2, 1, -1, -2, -4, -5, -6, -8,
-9, -11, -12, -13, -14, -17, -19, -19, -20, -22, -24, -25, -26, -28, -30, -31,
-32, -34, -36, -37, -38, -40, -41, -42, -44, -45, -47, -49, -50, -51, -53, -55,
-56, -57, -58, -60, -62, -63, -65, -66, -68, -69, -71, -72, -73, -75, -77, -77,
-80, -82, -82, -84, -86, -88, -88, -90, -92, -93, -94, -95, -97, -98, -100,
-102, -102, -104, -105, -107, -107, -109, -110, -110, -112, -112, -114, -114,
-114, -114, -115, -115, -115, -116, -115, -116, -116, -116, -117, -117, -117,
-117, -117, -117, -117, -117, -118, -117, -118, -118, -118, -118, -118, -118,
-118, -118, -119, -119, -118, -119, -118, -119, -118, -119, -119, -119, -119,
-119, -118, -119, -118, -119, -118, -119, -119, -119, -119, -119, -119, -118,
-118, -118, -118, -119, -119, -118, -119, -119, -118, -119, -118, -119, -118,
-118, -117, -119, -118, -118, -117, -118, -117, -118, -118, -118, -118, -118,
-117, -117, -117, -116, -116, -116, -115, -115, -116, -115, -115, -115, -114,
-114, -115, -113, -112, -112, -110, -109, -108, -107, -106, -105, -104, -102,
-101, -100, -99, -97, -96, -94, -93, -91, -90, -88, -87, -85, -84, -83, -81,
-79, -79, -76, -75, -73, -73, -71, -69, -68, -66, -64, -62, -62, -60, -59, -57,
-55, -54, -53, -52, -49, -48, -47, -45, -44, -42, -41, -40, -38, -37, -35, -33,
-32, -31, -30, -28, -27, -25, -23, -23, -20, -20, -17, -17, -15, -14, -13, -10,
-9, -8, -7, -5, -4, -2, 0, };