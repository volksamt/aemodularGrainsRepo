#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_19

const PROGMEM int8_t DATA[DATA_LENGTH] = {-17, -38, -53, -66, -76, -86, -91,
-96, -102, -105, -107, -109, -112, -114, -115, -115, -116, -117, -117, -117,
-118, -118, -118, -118, -119, -118, -118, -119, -119, -118, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -120, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-118, -119, -119, -118, -119, -120, -120, -119, -119, -118, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -120, -119, -118, -119, -118, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -120, -118, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -120, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -118, -120, -119, -119, -118, -120, -119, -119, -119, -119, -119,
-119, -118, -119, -118, -119, -119, -119, -119, -118, -119, -120, -120, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -118, -120, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -118, -119, -119, -119, -119, -118, -120, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -118, -119, -119, -119, -120, -120, -120, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -120, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -120, -118, -106, -73,
-35, -5, 20, 39, 55, 68, 77, 86, 92, 97, 101, 105, 109, 110, 112, 112, 115, 116,
116, 116, 117, 118, 117, 118, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119,
118, 118, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118,
119, 120, 119, 119, 119, 118, 119, 119, 119, 119, 120, 119, 120, 118, 119, 119,
119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 120, 119, 119, 118, 120, 120,
120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 118, 120,
119, 119, 119, 118, 119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 119, 119,
119, 119, 118, 119, 119, 119, 119, 118, 118, 119, 119, 119, 119, 120, 120, 119,
119, 119, 119, 119, 120, 118, 119, 118, 119, 119, 119, 119, 119, 120, 119, 119,
119, 120, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 118, 120, 118, 119, 118, 119, 120, 118, 119, 119, 119, 119, 118, 119, 119,
119, 118, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 118, 119, 119, 119,
119, 120, 119, 119, 119, 120, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 118, 104, 69, 31, 4, };