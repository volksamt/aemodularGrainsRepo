#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_16

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 22, 33, 43, 52, 60, 67, 73, 78, 83,
87, 91, 94, 98, 100, 102, 105, 106, 106, 109, 110, 112, 112, 113, 113, 114, 115,
115, 116, 116, 116, 117, 117, 117, 117, 118, 118, 118, 118, 117, 118, 119, 119,
118, 119, 118, 118, 119, 119, 119, 119, 118, 119, 118, 119, 118, 119, 119, 118,
118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 118, 118, 119,
119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 118, 119, 118, 119, 119,
119, 119, 119, 120, 119, 118, 119, 119, 119, 118, 119, 118, 118, 119, 119, 119,
119, 119, 119, 119, 120, 118, 120, 119, 119, 119, 118, 119, 119, 119, 119, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 118, 119, 120, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119,
119, 119, 119, 120, 120, 120, 119, 119, 120, 119, 119, 119, 119, 120, 119, 118,
119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120, 120, 118, 119, 120,
118, 119, 118, 119, 119, 120, 118, 119, 119, 120, 119, 119, 120, 118, 118, 120,
119, 120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 117, 104,
82, 59, 39, 20, 3, -10, -23, -35, -44, -53, -61, -68, -73, -79, -83, -88, -92,
-95, -98, -100, -102, -105, -106, -107, -109, -110, -111, -112, -113, -113,
-114, -115, -115, -116, -116, -116, -117, -117, -117, -117, -118, -118, -118,
-118, -119, -118, -118, -118, -118, -118, -119, -118, -119, -118, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -118, -119, -119, -120, -119, -120, -120,
-119, -120, -119, -119, -119, -119, -120, -119, -119, -119, -120, -118, -120,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -120, -119, -119, -119, -119, -119, -119, -120, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -120, -120, -119, -119, -119, -119, -119,
-118, -119, -118, -118, -120, -118, -120, -119, -119, -119, -119, -119, -120,
-119, -120, -119, -118, -120, -119, -119, -119, -119, -119, -119, -118, -119,
-120, -119, -119, -120, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -118, -118, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -120, -120,
-119, -120, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -118, -119, -120, -119, -119, -119, -120, -119,
-119, -119, -119, -117, -102, -80, -58, -37, -18, -3, };