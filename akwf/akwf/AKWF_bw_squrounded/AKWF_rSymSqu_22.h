#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_22

const PROGMEM int8_t DATA[DATA_LENGTH] = {19, 66, 95, 105, 109, 113, 115, 116,
117, 118, 118, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 119,
119, 118, 120, 120, 118, 118, 119, 120, 119, 120, 119, 120, 119, 120, 119, 119,
120, 119, 119, 120, 118, 118, 119, 120, 118, 120, 119, 119, 119, 119, 119, 119,
119, 118, 119, 118, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 118, 119, 119, 118, 119, 119, 119, 120, 119, 119, 119, 119,
119, 118, 120, 119, 120, 119, 118, 120, 119, 119, 119, 120, 119, 119, 120, 119,
119, 119, 119, 119, 118, 119, 119, 119, 120, 119, 119, 118, 119, 120, 119, 118,
119, 120, 118, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 119, 120, 118, 119, 118, 120, 119, 119, 119, 119, 119, 119, 118,
119, 120, 120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 120, 119, 120, 119, 118, 119, 120, 119, 119, 119, 120, 120, 119, 119,
120, 119, 118, 120, 119, 118, 119, 118, 120, 118, 119, 119, 120, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 118, 119, 118, 119, 119, 119, 118, 119, 120, 119, 119, 118, 119, 119, 119,
119, 119, 119, 118, 119, 119, 119, 119, 118, 119, 119, 118, 119, 118, 118, 117,
117, 115, 113, 110, 105, 96, 67, 21, -25, -70, -97, -106, -110, -113, -115,
-116, -117, -118, -119, -118, -119, -119, -119, -119, -119, -118, -119, -120,
-119, -119, -118, -119, -119, -118, -119, -118, -119, -120, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -120, -119, -119, -120, -119,
-120, -119, -119, -119, -119, -119, -119, -118, -118, -120, -119, -119, -119,
-119, -119, -118, -119, -118, -118, -118, -119, -120, -119, -119, -120, -119,
-120, -119, -119, -119, -119, -120, -119, -118, -119, -119, -119, -120, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -118, -119, -119, -119, -120, -119, -119,
-119, -118, -120, -120, -119, -119, -120, -120, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -120, -120, -118,
-119, -120, -118, -119, -119, -118, -119, -119, -119, -119, -120, -119, -119,
-118, -119, -119, -118, -119, -119, -119, -119, -119, -119, -118, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -118, -119, -118, -118, -118, -117, -116, -115, -112, -109, -104, -94,
-63, -17, };