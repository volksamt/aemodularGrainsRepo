#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_10

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 11, 14, 20, 23, 27, 30, 34, 37,
40, 43, 46, 49, 52, 54, 57, 60, 62, 64, 66, 69, 71, 72, 74, 76, 77, 79, 81, 82,
83, 85, 86, 88, 89, 90, 91, 92, 93, 95, 95, 96, 98, 97, 98, 100, 100, 100, 101,
103, 103, 104, 105, 105, 105, 106, 107, 107, 107, 108, 108, 109, 109, 109, 110,
110, 111, 111, 112, 112, 112, 112, 112, 113, 113, 113, 114, 114, 114, 115, 114,
115, 114, 114, 115, 115, 116, 116, 116, 116, 116, 115, 116, 116, 117, 117, 117,
116, 117, 117, 116, 117, 117, 117, 116, 118, 117, 118, 118, 117, 118, 117, 117,
118, 119, 118, 118, 118, 117, 118, 117, 118, 118, 119, 119, 119, 118, 119, 118,
118, 118, 119, 118, 119, 118, 119, 119, 119, 118, 119, 118, 119, 118, 119, 118,
119, 119, 119, 118, 119, 118, 119, 120, 119, 118, 118, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119,
119, 119, 119, 119, 118, 119, 118, 119, 119, 120, 119, 118, 119, 119, 119, 120,
119, 119, 119, 119, 119, 120, 119, 119, 119, 118, 119, 120, 117, 113, 107, 100,
92, 84, 76, 69, 62, 55, 48, 41, 35, 29, 23, 18, 12, 7, 2, -3, -6, -11, -16, -20,
-24, -27, -31, -35, -37, -41, -43, -47, -50, -52, -55, -57, -60, -62, -64, -66,
-68, -70, -72, -74, -75, -78, -80, -81, -82, -84, -85, -87, -88, -88, -90, -91,
-91, -93, -94, -95, -95, -97, -98, -99, -100, -101, -101, -102, -103, -103,
-103, -105, -105, -105, -106, -107, -107, -108, -108, -108, -109, -110, -110,
-110, -111, -110, -110, -111, -111, -112, -113, -112, -112, -113, -113, -113,
-113, -114, -114, -114, -114, -114, -115, -115, -115, -115, -115, -116, -115,
-115, -116, -117, -116, -117, -117, -117, -117, -117, -116, -117, -118, -117,
-117, -117, -116, -117, -117, -118, -118, -118, -117, -117, -118, -119, -118,
-119, -118, -117, -118, -117, -118, -118, -118, -118, -118, -118, -118, -118,
-118, -119, -118, -118, -119, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -118, -118, -119, -119, -119, -119, -118, -119, -118, -119, -119, -119,
-119, -119, -118, -119, -118, -119, -119, -119, -119, -119, -119, -118, -119,
-118, -118, -118, -119, -119, -119, -119, -119, -119, -119, -120, -119, -118,
-119, -119, -119, -118, -119, -120, -119, -120, -119, -118, -119, -119, -118,
-119, -119, -119, -120, -119, -120, -119, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -118, -113, -106, -98, -92, -83, -76, -68, -61, -54,
-47, -41, -35, -28, -22, -17, -12, -6, -2, };