#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_18

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 28, 50, 72, 90, 98, 102, 105, 107,
108, 111, 112, 113, 114, 115, 116, 116, 116, 117, 117, 118, 117, 118, 118, 118,
119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119,
119, 119, 119, 118, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 120, 118,
119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119,
119, 119, 118, 119, 119, 119, 119, 119, 119, 118, 119, 119, 118, 119, 120, 119,
119, 119, 120, 119, 119, 119, 119, 118, 118, 119, 120, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119, 120, 119, 119, 119,
119, 120, 119, 119, 118, 119, 119, 119, 120, 119, 119, 118, 120, 119, 118, 119,
119, 119, 119, 120, 119, 120, 120, 119, 119, 118, 119, 119, 119, 118, 119, 119,
119, 119, 119, 120, 119, 119, 119, 120, 119, 120, 119, 118, 119, 120, 120, 119,
119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 120, 119, 118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118,
119, 119, 120, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 119, 120, 119, 119, 118, 119, 119, 119, 119, 119, 118, 118, 118, 118,
118, 118, 117, 117, 117, 117, 116, 115, 115, 114, 114, 111, 111, 109, 107, 104,
102, 98, 91, 74, 51, 30, 10, -10, -31, -52, -74, -92, -99, -102, -105, -107,
-109, -111, -113, -113, -114, -114, -116, -116, -116, -118, -118, -118, -118,
-118, -118, -118, -119, -118, -119, -119, -119, -119, -119, -120, -119, -118,
-119, -119, -119, -119, -118, -119, -120, -118, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -118, -120, -120, -118, -119,
-118, -119, -119, -119, -119, -120, -119, -118, -119, -118, -119, -120, -119,
-119, -118, -119, -118, -120, -118, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -118, -119, -118, -119, -119, -118, -120, -119, -120, -118, -119, -119,
-118, -119, -119, -118, -120, -119, -119, -119, -119, -118, -119, -118, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -120, -119, -118, -119, -119, -119, -118, -120,
-120, -119, -119, -119, -119, -119, -119, -119, -118, -119, -118, -120, -119,
-118, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -118, -119, -118, -118, -118, -118, -119, -118, -119, -119, -119, -118,
-118, -119, -119, -118, -118, -117, -116, -117, -117, -117, -115, -115, -114,
-113, -112, -111, -109, -107, -104, -101, -98, -90, -71, -49, -27, -8, };