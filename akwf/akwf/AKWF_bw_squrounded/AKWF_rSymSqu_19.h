#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_19

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 35, 62, 85, 97, 102, 105, 108,
110, 112, 113, 114, 116, 116, 117, 117, 118, 118, 118, 118, 119, 119, 118, 119,
119, 119, 120, 119, 119, 119, 118, 118, 119, 119, 120, 118, 119, 119, 120, 119,
119, 120, 120, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119,
119, 119, 118, 119, 120, 119, 119, 120, 119, 118, 119, 119, 119, 120, 118, 120,
119, 119, 118, 118, 119, 118, 120, 119, 119, 120, 119, 118, 119, 119, 120, 119,
119, 119, 119, 119, 119, 119, 119, 120, 118, 120, 118, 119, 119, 119, 119, 119,
120, 120, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118,
118, 118, 119, 119, 119, 119, 119, 118, 119, 118, 119, 119, 120, 118, 119, 119,
119, 120, 119, 119, 119, 120, 119, 120, 119, 119, 119, 118, 119, 120, 119, 119,
119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 120, 120, 119, 119,
119, 119, 119, 120, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 120, 119,
118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 118,
118, 119, 119, 118, 118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 120, 118, 120, 119, 118, 118,
119, 118, 119, 119, 119, 118, 118, 118, 117, 117, 116, 115, 115, 114, 112, 110,
108, 106, 102, 98, 86, 64, 36, 11, -13, -38, -65, -87, -98, -103, -106, -108,
-111, -113, -114, -115, -116, -116, -117, -117, -118, -118, -118, -118, -118,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -120, -119, -119,
-120, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -118, -119, -119, -119, -118, -120, -119,
-119, -120, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -120, -119, -119, -119, -120, -119, -119, -119, -118, -119,
-118, -119, -120, -119, -119, -118, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -120, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -118, -120, -119, -119, -120, -120, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -120, -120, -119, -119, -118,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -118,
-119, -119, -118, -119, -119, -119, -119, -119, -120, -118, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -119, -118, -119, -119, -119, -120, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -118, -119, -119, -120, -119,
-120, -119, -119, -119, -118, -119, -118, -119, -118, -118, -118, -118, -117,
-117, -116, -115, -114, -111, -110, -107, -106, -102, -97, -84, -60, -34, -9, };