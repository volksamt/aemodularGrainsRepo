#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_18

const PROGMEM int8_t DATA[DATA_LENGTH] = {15, 34, 47, 60, 69, 78, 84, 90, 94,
99, 103, 106, 108, 109, 110, 112, 113, 114, 115, 116, 117, 117, 117, 117, 118,
118, 118, 118, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119,
120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 118, 120, 119, 119,
118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119,
120, 119, 119, 119, 119, 119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119,
119, 120, 119, 120, 119, 119, 120, 119, 119, 120, 119, 119, 120, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119,
120, 119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119, 119, 119,
119, 119, 119, 118, 119, 118, 118, 119, 119, 118, 120, 119, 119, 119, 120, 119,
119, 119, 119, 120, 120, 120, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 119, 118, 119, 119, 119,
120, 119, 119, 119, 118, 119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119,
119, 119, 112, 87, 54, 25, 0, -20, -35, -50, -61, -70, -79, -85, -91, -96, -100,
-103, -106, -107, -110, -111, -113, -114, -114, -115, -115, -117, -116, -117,
-117, -118, -118, -118, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -119, -119, -118, -118, -118, -119, -119, -119, -119, -119,
-119, -118, -118, -118, -119, -119, -119, -118, -120, -119, -119, -119, -120,
-119, -119, -120, -119, -120, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -118, -119, -119, -120, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -118, -120, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -118, -120, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-120, -118, -119, -119, -119, -119, -119, -118, -120, -119, -118, -119, -118,
-119, -119, -119, -118, -119, -119, -118, -119, -120, -119, -119, -118, -118,
-120, -120, -118, -119, -119, -119, -120, -120, -119, -118, -119, -118, -120,
-118, -118, -119, -119, -119, -119, -118, -119, -119, -119, -120, -119, -118,
-119, -119, -119, -119, -119, -119, -120, -119, -120, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -118, -120, -120, -119, -119, -118, -119, -119,
-118, -120, -119, -119, -120, -119, -119, -110, -83, -50, -21, -1, };