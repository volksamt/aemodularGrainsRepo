#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_09

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 10, 13, 18, 22, 25, 30, 33, 37,
42, 45, 50, 54, 59, 63, 68, 72, 76, 81, 84, 88, 90, 92, 93, 94, 95, 96, 97, 98,
99, 99, 100, 101, 101, 102, 102, 103, 104, 104, 104, 105, 105, 106, 106, 107,
107, 108, 108, 108, 110, 109, 110, 111, 110, 111, 111, 112, 112, 112, 113, 113,
114, 113, 113, 113, 114, 114, 114, 114, 115, 115, 116, 115, 115, 115, 115, 116,
116, 116, 116, 117, 117, 116, 117, 117, 118, 117, 118, 117, 117, 117, 118, 118,
118, 117, 118, 118, 119, 118, 119, 119, 119, 118, 118, 118, 118, 119, 118, 119,
120, 119, 118, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 118,
119, 119, 119, 119, 119, 119, 119, 120, 118, 119, 119, 119, 119, 118, 119, 119,
119, 118, 118, 119, 118, 119, 118, 119, 118, 118, 118, 118, 118, 118, 118, 119,
118, 118, 118, 118, 118, 118, 118, 117, 117, 117, 117, 117, 118, 117, 117, 117,
117, 117, 117, 116, 115, 116, 116, 115, 115, 116, 115, 115, 114, 114, 114, 114,
113, 113, 113, 113, 113, 113, 111, 111, 112, 111, 110, 111, 110, 109, 110, 109,
108, 109, 108, 107, 107, 107, 107, 106, 106, 105, 104, 104, 103, 103, 101, 101,
101, 100, 99, 98, 97, 97, 96, 95, 95, 93, 92, 91, 88, 84, 81, 76, 72, 68, 64,
59, 54, 50, 46, 42, 38, 35, 29, 26, 22, 17, 14, 10, 5, 2, -2, -6, -10, -13, -18,
-22, -26, -30, -34, -39, -43, -47, -50, -56, -59, -63, -68, -73, -77, -80, -85,
-88, -91, -92, -94, -94, -95, -95, -97, -98, -98, -100, -100, -100, -102, -102,
-102, -103, -104, -104, -104, -106, -106, -106, -107, -107, -108, -108, -109,
-109, -109, -109, -109, -110, -110, -111, -111, -112, -111, -111, -113, -112,
-112, -113, -114, -114, -113, -114, -115, -114, -114, -115, -115, -115, -116,
-115, -116, -116, -116, -117, -117, -117, -117, -117, -117, -117, -117, -116,
-117, -117, -117, -118, -117, -118, -118, -118, -117, -119, -119, -118, -118,
-118, -118, -119, -118, -118, -118, -119, -119, -119, -119, -119, -118, -120,
-118, -119, -119, -120, -119, -118, -119, -120, -119, -120, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -120, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -118, -119, -119, -119, -119, -118, -118,
-119, -117, -118, -118, -118, -117, -117, -118, -118, -118, -117, -118, -118,
-117, -117, -117, -118, -117, -117, -117, -117, -116, -117, -116, -116, -116,
-115, -116, -115, -115, -115, -114, -115, -114, -114, -115, -114, -114, -113,
-113, -114, -112, -113, -112, -112, -111, -111, -111, -111, -110, -110, -110,
-109, -109, -108, -107, -107, -107, -106, -106, -106, -106, -105, -104, -103,
-103, -102, -103, -101, -100, -100, -99, -99, -98, -97, -96, -95, -94, -94, -93,
-90, -88, -84, -80, -76, -72, -67, -63, -58, -54, -51, -46, -41, -38, -33, -30,
-25, -21, -18, -13, -9, -5, -1, };