#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_06

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 8, 10, 12, 14, 17, 20, 21,
24, 26, 29, 30, 33, 36, 38, 40, 42, 45, 47, 49, 52, 54, 57, 58, 61, 65, 67, 69,
72, 75, 76, 79, 82, 84, 85, 88, 91, 93, 96, 97, 98, 101, 100, 102, 102, 102,
104, 103, 103, 104, 105, 105, 105, 106, 106, 107, 107, 107, 107, 108, 108, 109,
109, 109, 110, 110, 111, 111, 111, 111, 112, 113, 112, 113, 112, 113, 113, 113,
114, 114, 114, 114, 115, 114, 115, 115, 116, 116, 115, 116, 116, 116, 116, 116,
116, 116, 117, 118, 118, 117, 117, 119, 118, 117, 118, 118, 118, 118, 119, 118,
119, 119, 118, 119, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119,
119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 118, 119, 119,
119, 118, 118, 118, 118, 118, 118, 117, 118, 117, 117, 117, 118, 117, 118, 117,
117, 117, 116, 116, 116, 116, 115, 115, 116, 115, 115, 114, 115, 115, 114, 114,
114, 113, 113, 112, 113, 112, 112, 111, 111, 111, 111, 110, 111, 110, 110, 110,
109, 108, 108, 108, 107, 107, 107, 105, 106, 106, 105, 105, 104, 104, 103, 102,
103, 101, 101, 101, 100, 99, 96, 95, 93, 91, 89, 87, 84, 81, 79, 76, 75, 72, 69,
66, 64, 62, 59, 57, 54, 51, 49, 47, 45, 43, 41, 38, 36, 33, 30, 28, 26, 24, 21,
19, 17, 15, 12, 10, 8, 6, 4, 1, -1, -4, -6, -7, -11, -12, -15, -16, -19, -21,
-23, -26, -28, -31, -33, -35, -38, -41, -43, -45, -47, -50, -52, -55, -57, -60,
-62, -65, -67, -70, -72, -74, -77, -80, -81, -84, -86, -89, -91, -94, -96, -97,
-99, -100, -101, -102, -101, -103, -103, -103, -104, -104, -104, -105, -105,
-106, -105, -107, -107, -107, -108, -109, -109, -108, -110, -109, -110, -110,
-110, -111, -111, -111, -112, -112, -112, -113, -113, -112, -114, -114, -114,
-114, -114, -115, -115, -116, -116, -115, -116, -115, -116, -116, -116, -116,
-116, -117, -116, -117, -117, -117, -118, -117, -118, -118, -118, -118, -118,
-119, -118, -119, -119, -118, -118, -119, -119, -119, -118, -119, -119, -118,
-118, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -118, -119, -119, -119, -119, -119, -118, -118,
-119, -118, -118, -118, -118, -118, -118, -117, -118, -117, -118, -117, -117,
-117, -117, -117, -117, -116, -116, -115, -116, -116, -115, -115, -115, -115,
-115, -115, -114, -114, -114, -114, -113, -113, -113, -112, -112, -111, -111,
-112, -111, -111, -110, -110, -110, -109, -108, -109, -109, -107, -107, -107,
-106, -106, -106, -106, -105, -104, -104, -104, -103, -102, -102, -102, -101,
-101, -100, -98, -97, -95, -93, -91, -88, -86, -84, -82, -79, -76, -73, -72,
-69, -66, -65, -61, -59, -57, -54, -52, -49, -47, -45, -42, -40, -37, -35, -33,
-30, -28, -26, -24, -21, -19, -17, -14, -13, -11, -7, -6, -3, -1, };