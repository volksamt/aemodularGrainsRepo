#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_08

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 8, 10, 14, 17, 21, 24, 28, 31,
34, 37, 40, 43, 48, 50, 54, 57, 61, 65, 69, 73, 76, 79, 82, 85, 89, 91, 94, 94,
95, 96, 97, 97, 99, 99, 101, 101, 101, 101, 102, 103, 103, 104, 104, 104, 104,
106, 106, 106, 107, 107, 107, 109, 108, 109, 108, 109, 110, 111, 110, 111, 111,
111, 111, 112, 112, 112, 113, 113, 113, 113, 114, 113, 115, 114, 115, 115, 114,
114, 115, 116, 116, 116, 116, 117, 116, 116, 117, 117, 117, 118, 117, 117, 117,
118, 118, 118, 118, 117, 117, 117, 118, 118, 119, 118, 118, 119, 118, 118, 119,
118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 120, 119, 119, 119,
120, 119, 119, 120, 119, 118, 119, 120, 118, 119, 119, 119, 119, 118, 119, 119,
119, 119, 119, 118, 119, 118, 118, 118, 118, 118, 119, 118, 118, 118, 117, 117,
118, 118, 118, 117, 118, 117, 116, 116, 117, 116, 116, 116, 116, 116, 116, 115,
115, 115, 115, 115, 115, 115, 114, 114, 113, 113, 114, 112, 112, 113, 112, 112,
112, 112, 112, 111, 110, 110, 110, 109, 109, 108, 108, 108, 108, 107, 107, 106,
106, 105, 105, 104, 103, 104, 103, 103, 101, 102, 100, 100, 100, 99, 98, 97, 98,
97, 96, 94, 94, 91, 90, 86, 83, 79, 77, 72, 68, 65, 61, 58, 55, 51, 48, 44, 41,
37, 34, 31, 28, 24, 21, 17, 14, 11, 8, 5, 1, -2, -5, -8, -11, -15, -18, -22,
-24, -28, -30, -34, -38, -41, -44, -47, -52, -55, -58, -63, -65, -69, -72, -76,
-80, -83, -86, -89, -92, -93, -96, -96, -97, -98, -99, -98, -100, -100, -101,
-101, -102, -102, -102, -103, -104, -105, -105, -105, -105, -107, -106, -107,
-108, -108, -109, -108, -109, -109, -109, -110, -110, -111, -111, -112, -112,
-111, -112, -113, -113, -113, -113, -113, -114, -113, -115, -115, -114, -115,
-115, -115, -115, -115, -116, -116, -116, -116, -116, -116, -116, -116, -117,
-117, -117, -117, -118, -118, -117, -118, -117, -118, -118, -118, -119, -119,
-118, -118, -118, -118, -118, -119, -119, -119, -119, -119, -118, -120, -118,
-119, -119, -119, -119, -118, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -118, -119, -118, -119, -118, -118,
-118, -118, -118, -117, -118, -117, -118, -118, -117, -116, -117, -117, -116,
-116, -116, -116, -115, -115, -115, -116, -116, -115, -116, -114, -115, -114,
-114, -114, -114, -114, -114, -113, -112, -113, -111, -112, -111, -112, -111,
-111, -110, -110, -110, -110, -109, -109, -109, -108, -108, -107, -107, -106,
-106, -106, -105, -104, -104, -104, -103, -103, -102, -101, -101, -100, -99,
-99, -98, -98, -96, -97, -96, -95, -94, -91, -89, -86, -83, -79, -76, -71, -68,
-65, -62, -58, -54, -51, -47, -44, -40, -36, -33, -31, -28, -25, -21, -18, -14,
-10, -8, -5, -2, };