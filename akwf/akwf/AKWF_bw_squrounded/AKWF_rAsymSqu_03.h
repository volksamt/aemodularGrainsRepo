#define DATA_LENGTH 512
#define DATA AKWF_rAsymSqu_03

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 4, 6, 6, 7, 10, 11, 11, 13,
14, 15, 16, 17, 19, 19, 20, 21, 22, 23, 24, 26, 26, 27, 29, 29, 30, 32, 32, 34,
34, 36, 36, 38, 39, 39, 41, 41, 43, 43, 44, 44, 45, 47, 47, 48, 49, 50, 51, 52,
53, 53, 54, 55, 56, 57, 58, 59, 59, 60, 61, 61, 63, 63, 64, 64, 65, 65, 67, 67,
68, 69, 69, 70, 71, 72, 72, 73, 75, 74, 75, 76, 76, 77, 78, 79, 79, 80, 81, 81,
81, 82, 83, 83, 84, 85, 85, 86, 86, 87, 87, 87, 89, 90, 89, 90, 91, 92, 92, 92,
93, 93, 94, 95, 96, 96, 96, 98, 97, 97, 98, 99, 99, 99, 101, 100, 101, 102, 102,
103, 103, 104, 104, 105, 104, 106, 106, 106, 106, 106, 108, 108, 108, 108, 109,
110, 110, 111, 111, 111, 111, 112, 113, 113, 113, 113, 114, 114, 115, 114, 115,
116, 116, 117, 117, 117, 117, 118, 118, 118, 119, 119, 119, 118, 119, 118, 117,
115, 116, 114, 112, 111, 110, 108, 108, 106, 103, 103, 100, 99, 98, 96, 94, 93,
91, 89, 88, 86, 84, 82, 81, 78, 77, 75, 74, 73, 70, 69, 67, 65, 64, 62, 61, 58,
57, 55, 54, 52, 50, 48, 48, 46, 44, 43, 41, 40, 39, 36, 35, 34, 33, 31, 30, 29,
27, 25, 24, 22, 21, 19, 18, 16, 15, 14, 13, 11, 10, 9, 8, 7, 5, 5, 3, 2, 0, 0,
-2, -4, -4, -6, -7, -8, -10, -10, -12, -13, -13, -15, -17, -18, -18, -19, -20,
-22, -22, -24, -25, -26, -26, -27, -30, -29, -31, -31, -32, -34, -35, -36, -37,
-37, -39, -39, -41, -41, -42, -43, -44, -45, -46, -47, -48, -49, -50, -50, -52,
-52, -52, -53, -54, -55, -56, -57, -57, -58, -59, -61, -60, -62, -62, -64, -63,
-65, -66, -66, -67, -68, -68, -68, -69, -70, -71, -72, -73, -73, -74, -73, -74,
-75, -77, -78, -77, -78, -79, -79, -81, -81, -81, -82, -82, -83, -84, -84, -86,
-86, -87, -87, -88, -88, -89, -89, -90, -91, -91, -91, -91, -92, -93, -93, -94,
-94, -95, -96, -97, -97, -98, -98, -98, -99, -99, -100, -100, -101, -101, -102,
-102, -103, -103, -103, -104, -104, -105, -106, -106, -106, -107, -107, -107,
-108, -108, -109, -110, -110, -110, -110, -110, -111, -112, -112, -112, -113,
-113, -114, -114, -114, -115, -115, -116, -116, -117, -117, -117, -117, -118,
-117, -119, -119, -119, -120, -119, -119, -118, -118, -116, -116, -115, -114,
-113, -111, -110, -108, -107, -106, -104, -102, -102, -99, -97, -96, -94, -92,
-91, -90, -87, -85, -84, -82, -81, -79, -77, -76, -73, -72, -70, -69, -66, -64,
-63, -62, -60, -59, -57, -56, -53, -53, -50, -49, -48, -46, -44, -43, -41, -39,
-38, -37, -35, -34, -32, -30, -29, -29, -27, -25, -24, -22, -22, -19, -19, -17,
-16, -14, -13, -12, -10, -8, -8, -7, -5, -5, -3, -2, 0, };