#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_11

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 14, 19, 26, 32, 38, 44, 50, 56,
63, 69, 75, 82, 87, 90, 92, 93, 95, 96, 97, 98, 99, 101, 101, 101, 102, 103,
104, 105, 106, 106, 107, 108, 108, 108, 109, 110, 110, 111, 111, 111, 111, 111,
112, 113, 114, 113, 113, 113, 114, 114, 114, 115, 115, 115, 115, 116, 116, 116,
116, 116, 117, 117, 116, 116, 117, 117, 116, 117, 118, 117, 118, 118, 117, 119,
118, 118, 119, 117, 119, 118, 118, 118, 118, 119, 119, 119, 118, 118, 119, 119,
118, 119, 118, 118, 118, 119, 119, 119, 118, 119, 118, 118, 119, 119, 119, 119,
119, 119, 120, 119, 119, 120, 119, 119, 119, 120, 120, 120, 119, 119, 118, 119,
119, 119, 119, 119, 119, 118, 120, 119, 120, 119, 120, 120, 120, 119, 119, 120,
119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 120, 119, 119, 119, 118,
118, 119, 119, 119, 118, 118, 119, 119, 118, 119, 119, 119, 118, 118, 118, 118,
118, 118, 118, 118, 118, 118, 118, 117, 118, 118, 118, 118, 118, 118, 117, 116,
117, 117, 117, 116, 117, 116, 116, 117, 115, 115, 116, 115, 115, 115, 115, 115,
114, 114, 114, 114, 113, 114, 113, 112, 112, 112, 111, 112, 111, 110, 110, 109,
109, 108, 108, 107, 107, 106, 104, 104, 103, 102, 102, 102, 100, 100, 99, 98,
96, 96, 94, 92, 90, 87, 82, 75, 69, 62, 56, 50, 44, 38, 32, 27, 19, 15, 8, 2,
-3, -9, -15, -21, -27, -32, -39, -44, -51, -57, -63, -70, -76, -82, -88, -91,
-93, -94, -95, -96, -98, -99, -99, -100, -101, -102, -102, -103, -105, -104,
-107, -106, -107, -107, -108, -108, -109, -109, -110, -111, -111, -112, -112,
-112, -112, -113, -114, -114, -113, -114, -115, -114, -114, -115, -116, -116,
-115, -116, -116, -116, -117, -117, -116, -117, -117, -117, -117, -116, -117,
-117, -117, -118, -117, -118, -117, -118, -118, -118, -118, -118, -118, -118,
-118, -118, -118, -118, -119, -118, -118, -118, -119, -118, -119, -118, -119,
-118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -118,
-119, -119, -119, -119, -118, -118, -119, -118, -119, -118, -119, -119, -119,
-119, -120, -119, -119, -119, -120, -119, -119, -118, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -118, -118, -119, -119, -118, -118, -119, -118, -119, -118,
-118, -118, -118, -118, -118, -118, -119, -118, -118, -118, -118, -118, -117,
-117, -117, -117, -117, -118, -117, -117, -117, -116, -116, -115, -115, -115,
-116, -115, -115, -115, -115, -114, -115, -113, -114, -113, -114, -113, -112,
-113, -112, -111, -111, -110, -110, -109, -110, -108, -108, -107, -106, -107,
-106, -105, -104, -104, -103, -102, -100, -100, -100, -99, -97, -96, -95, -94,
-92, -91, -87, -81, -74, -69, -62, -55, -50, -43, -37, -32, -26, -19, -14, -8,
-2, };