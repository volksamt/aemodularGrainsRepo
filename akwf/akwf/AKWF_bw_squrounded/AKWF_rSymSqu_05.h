#define DATA_LENGTH 512
#define DATA AKWF_rSymSqu_05

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 2, 5, 6, 9, 10, 13, 14, 16, 19, 20,
22, 24, 26, 28, 29, 31, 34, 37, 38, 40, 41, 43, 46, 48, 50, 51, 54, 55, 58, 60,
61, 65, 66, 68, 70, 73, 74, 76, 79, 81, 83, 85, 87, 89, 91, 93, 95, 96, 98, 100,
101, 102, 105, 105, 106, 106, 107, 108, 107, 107, 108, 108, 108, 108, 110, 109,
110, 110, 110, 111, 111, 111, 112, 112, 112, 113, 113, 113, 114, 113, 114, 114,
114, 115, 114, 115, 115, 115, 115, 116, 116, 116, 116, 116, 117, 117, 116, 117,
118, 117, 118, 117, 118, 118, 117, 118, 118, 118, 118, 118, 118, 118, 119, 119,
118, 119, 119, 119, 119, 119, 119, 118, 118, 119, 120, 120, 120, 119, 119, 119,
120, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 118, 119, 118, 119, 118,
118, 118, 118, 118, 117, 117, 117, 118, 117, 117, 117, 117, 117, 117, 117, 117,
116, 116, 116, 115, 115, 115, 115, 115, 114, 114, 115, 114, 114, 114, 112, 113,
112, 112, 112, 111, 112, 111, 111, 111, 110, 110, 110, 110, 109, 109, 108, 108,
107, 108, 107, 107, 107, 106, 105, 104, 102, 102, 100, 99, 96, 94, 92, 91, 89,
87, 85, 83, 81, 79, 77, 74, 72, 70, 69, 66, 64, 62, 60, 57, 56, 53, 52, 49, 47,
46, 44, 42, 40, 37, 35, 33, 32, 29, 27, 26, 24, 23, 20, 18, 17, 14, 13, 11, 9,
6, 4, 3, 1, -2, -3, -5, -6, -8, -11, -13, -15, -17, -19, -21, -22, -24, -27,
-28, -30, -33, -34, -36, -38, -40, -42, -44, -46, -48, -50, -52, -53, -57, -59,
-59, -62, -64, -66, -69, -70, -73, -74, -77, -79, -81, -83, -85, -87, -89, -91,
-93, -95, -97, -99, -100, -102, -103, -104, -105, -106, -106, -106, -107, -107,
-107, -107, -108, -109, -109, -110, -110, -110, -110, -111, -111, -112, -112,
-112, -112, -113, -112, -113, -113, -114, -113, -114, -114, -114, -115, -115,
-116, -115, -115, -116, -115, -115, -116, -116, -116, -116, -117, -117, -118,
-117, -117, -117, -118, -117, -117, -118, -118, -118, -118, -117, -118, -118,
-118, -118, -119, -119, -118, -119, -119, -119, -118, -118, -119, -119, -119,
-119, -120, -118, -119, -118, -119, -118, -120, -118, -119, -119, -118, -119,
-119, -118, -119, -118, -118, -118, -117, -119, -119, -118, -118, -118, -118,
-118, -117, -117, -117, -118, -117, -118, -117, -117, -117, -117, -117, -116,
-116, -115, -115, -116, -114, -114, -114, -115, -115, -114, -114, -114, -113,
-112, -113, -112, -112, -113, -112, -111, -110, -112, -111, -110, -110, -109,
-109, -109, -109, -108, -108, -107, -108, -106, -107, -107, -106, -105, -104,
-102, -101, -100, -98, -97, -95, -94, -90, -89, -86, -84, -82, -81, -78, -77,
-74, -72, -70, -69, -67, -64, -62, -59, -57, -55, -53, -52, -49, -47, -46, -44,
-41, -39, -37, -35, -33, -31, -30, -27, -26, -25, -22, -20, -18, -15, -15, -12,
-10, -8, -6, -4, -3, -2, };