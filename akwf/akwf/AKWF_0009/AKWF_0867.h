#define DATA_LENGTH 512
#define DATA AKWF_0867

const PROGMEM int8_t DATA[DATA_LENGTH] = {103, 123, 109, 116, 104, 110, 98, 105,
95, 97, 97, -14, -44, 6, -19, -53, -50, -51, -53, -51, -54, -53, -55, -55, -57,
-57, -58, -58, -59, -60, -60, -62, -62, -63, -64, -65, -64, -67, -66, -68, -68,
-68, -68, -69, -69, -70, -70, -68, -70, -65, -69, -59, -65, -46, -65, 24, 109,
82, 93, 82, 86, 78, 80, 75, 74, 72, 69, 67, 64, 63, 59, 58, 55, 53, 50, 49, 46,
45, 42, 41, 39, 37, 35, 34, 31, 30, 28, 26, 25, 23, 22, 20, 18, 17, 16, 14, 14,
12, 11, 9, 8, 8, 6, 5, 4, 3, 2, 0, -1, -1, -2, -2, -3, -4, -5, -6, -7, -6, -8,
-8, -8, -10, -10, -11, -11, -12, -12, -12, -12, -13, -13, -14, -13, -14, -14,
-14, -15, -15, -15, -15, -15, -15, -16, -15, -15, -14, -14, -15, -15, -15, -14,
-15, -14, -14, -14, -14, -14, -14, -13, -12, -12, -12, -12, -11, -11, -12, -11,
-11, -11, -10, -10, -10, -9, -9, -8, -8, -8, -7, -8, -7, -7, -5, -6, -5, -5, -5,
-3, -3, -4, -3, -2, -2, -2, -1, -1, 0, 0, 0, 1, 1, 1, 1, 1, 2, 2, 3, 3, 3, 4, 3,
3, 4, 5, 4, 5, 5, 5, 6, 6, 6, 6, 7, 7, 7, 7, 6, 7, 7, 8, 7, 8, 8, 8, 8, 8, 8, 8,
8, 8, 8, 8, 9, 8, 8, 8, 8, 8, 7, 8, 9, 8, 7, 8, 8, 7, 7, 7, 7, 7, 7, 7, 7, 6, 6,
5, 5, 6, 5, 6, 5, 5, 5, 4, 5, 5, 4, 4, 3, 3, 3, 4, 3, 3, 2, 2, 2, 1, 0, 1, 0, 1,
0, 0, 0, 0, -1, -1, -1, -1, -1, -1, -2, -2, -2, -3, -3, -2, -3, -3, -3, -4, -4,
-3, -4, -5, -4, -4, -4, -5, -4, -6, -5, -6, -5, -5, -6, -5, -6, -6, -6, -7, -6,
-6, -6, -6, -6, -7, -6, -6, -7, -6, -7, -7, -7, -7, -6, -6, -6, -7, -6, -6, -6,
-6, -6, -6, -5, -6, -5, -6, -5, -5, -6, -5, -5, -5, -5, -5, -4, -4, -4, -4, -3,
-3, -3, -3, -3, -3, -3, -2, -3, -3, -2, -1, -2, -1, 0, -1, -1, 0, 0, 0, 0, 1, 1,
0, 1, 2, 1, 2, 2, 2, 2, 3, 3, 4, 4, 4, 3, 4, 4, 3, 4, 4, 4, 5, 4, 5, 5, 5, 6, 6,
6, 6, 6, 6, 7, 6, 6, 6, 7, 6, 7, 6, 7, 6, 7, 7, 7, 6, 7, 7, 7, 6, 7, 7, 7, 6, 6,
7, 6, 6, 6, 5, 5, 5, 5, 5, 4, 5, 4, 4, 4, 4, 5, 3, 3, 2, 3, 3, 1, 2, 1, 1, 1, 0,
-1, 0, -1, -2, -2, -2, -3, -3, -4, -4, -6, -6, -6, -7, -8, -8, -8, -8, -9, -10,
-10, -11, -11, -13, -13, -13, -14, -15, -15, -16, -17, -19, -18, -21, -20, -23,
-19, };