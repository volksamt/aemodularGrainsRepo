#define DATA_LENGTH 512
#define DATA AKWF_0871

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 8, 10, 13, 17, 20, 23, 27, 30,
32, 35, 38, 41, 44, 47, 49, 52, 55, 58, 60, 63, 66, 68, 70, 73, 76, 78, 80, 83,
85, 87, 91, 92, 94, 96, 99, 100, 104, 106, 107, 107, 106, 106, 104, 104, 103,
103, 101, 101, 101, 101, 99, 98, 99, 97, 92, 88, 84, 81, 76, 73, 69, 65, 62, 58,
54, 51, 48, 44, 41, 38, 34, 31, 27, 24, 21, 18, 14, 11, 8, 6, 3, 0, -2, -5, -8,
-11, -13, -17, -19, -22, -24, -27, -29, -31, -34, -36, -39, -40, -43, -45, -48,
-49, -51, -50, -51, -52, -53, -55, -55, -56, -57, -57, -58, -58, -60, -60, -62,
-61, -62, -63, -63, -64, -64, -65, -66, -66, -68, -68, -69, -70, -70, -70, -71,
-71, -72, -73, -74, -74, -74, -74, -76, -75, -76, -77, -77, -78, -78, -78, -79,
-78, -74, -69, -65, -60, -57, -52, -48, -43, -40, -36, -31, -29, -24, -20, -17,
-13, -10, -6, -2, 1, 5, 8, 11, 15, 18, 21, 25, 26, 30, 33, 36, 38, 42, 44, 47,
49, 53, 54, 57, 60, 62, 64, 67, 69, 71, 73, 75, 77, 77, 76, 75, 74, 73, 73, 71,
70, 69, 70, 69, 68, 67, 66, 65, 65, 64, 62, 62, 61, 61, 59, 58, 58, 57, 56, 56,
55, 54, 54, 51, 52, 51, 46, 40, 36, 33, 27, 23, 20, 16, 12, 7, 2, -1, -6, -9,
-13, -17, -21, -25, -29, -32, -37, -39, -43, -47, -51, -54, -56, -60, -64, -68,
-71, -74, -77, -81, -84, -86, -90, -94, -96, -99, -102, -106, -108, -111, -113,
-116, -119, -117, -112, -106, -102, -96, -92, -87, -82, -77, -72, -68, -64, -60,
-54, -50, -47, -42, -38, -34, -30, -26, -21, -18, -15, -11, -7, -3, 1, 4, 8, 11,
15, 19, 21, 25, 29, 31, 34, 37, 40, 44, 47, 50, 52, 55, 58, 61, 63, 60, 59, 58,
56, 54, 53, 51, 50, 50, 50, 50, 51, 51, 52, 53, 53, 52, 53, 53, 54, 55, 55, 54,
55, 55, 56, 55, 56, 57, 57, 57, 57, 58, 58, 58, 58, 58, 59, 59, 59, 59, 60, 59,
60, 60, 61, 60, 61, 61, 62, 62, 62, 62, 62, 63, 62, 61, 60, 58, 56, 54, 53, 52,
51, 48, 44, 40, 37, 32, 28, 25, 22, 19, 14, 11, 8, 5, 2, -3, -5, -8, -11, -15,
-16, -20, -22, -25, -29, -32, -33, -37, -39, -42, -44, -46, -49, -51, -54, -56,
-58, -60, -63, -64, -67, -69, -71, -73, -74, -76, -78, -80, -82, -82, -80, -80,
-79, -79, -78, -77, -76, -75, -74, -73, -73, -72, -70, -70, -70, -68, -68, -66,
-66, -65, -63, -64, -63, -61, -60, -60, -59, -57, -57, -56, -55, -54, -53, -52,
-51, -50, -49, -49, -48, -47, -46, -45, -44, -44, -43, -41, -41, -40, -39, -38,
-38, -37, -36, -34, -33, -33, -32, -31, -30, -30, -29, -27, -28, -26, -22, -19,
-16, -12, -8, -6, -2, };