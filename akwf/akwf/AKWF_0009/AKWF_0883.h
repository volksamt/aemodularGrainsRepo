#define DATA_LENGTH 512
#define DATA AKWF_0883

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 11, 18, 25, 31, 38, 44, 50, 56, 62,
68, 73, 78, 83, 87, 91, 95, 98, 100, 103, 106, 107, 109, 111, 111, 113, 113,
114, 115, 115, 116, 116, 117, 117, 117, 117, 117, 118, 118, 118, 118, 118, 118,
119, 119, 119, 119, 119, 118, 119, 119, 118, 118, 119, 119, 119, 119, 119, 119,
119, 119, 119, 118, 119, 120, 118, 119, 119, 119, 119, 119, 118, 119, 117, 116,
115, 114, 112, 109, 106, 105, 102, 99, 96, 93, 90, 87, 83, 81, 77, 74, 72, 69,
66, 63, 60, 57, 54, 52, 49, 44, 41, 37, 34, 29, 24, 20, 16, 11, 6, 3, -1, -5,
-7, -9, -11, -12, -13, -14, -13, -12, -10, -9, -7, -4, -1, 0, 3, 5, 7, 9, 11,
14, 15, 17, 18, 21, 22, 25, 27, 28, 30, 32, 34, 35, 37, 38, 40, 41, 43, 44, 46,
48, 49, 50, 52, 53, 54, 56, 56, 57, 58, 60, 59, 60, 60, 61, 61, 62, 62, 62, 63,
63, 64, 63, 64, 64, 64, 64, 64, 63, 63, 62, 61, 61, 59, 57, 56, 53, 49, 44, 39,
32, 26, 19, 11, 4, -4, -12, -18, -25, -32, -38, -45, -51, -56, -61, -67, -72,
-77, -82, -86, -90, -93, -97, -100, -102, -105, -107, -109, -109, -111, -113,
-113, -114, -114, -115, -115, -116, -117, -117, -118, -118, -118, -118, -117,
-118, -118, -119, -118, -119, -120, -118, -118, -117, -117, -117, -116, -116,
-114, -111, -110, -108, -105, -103, -101, -98, -95, -92, -90, -85, -83, -79,
-75, -70, -65, -59, -53, -45, -37, -30, -21, -13, -6, 3, 10, 17, 24, 31, 36, 42,
48, 52, 58, 62, 67, 71, 74, 78, 81, 84, 88, 91, 93, 96, 97, 100, 102, 104, 105,
107, 108, 111, 111, 112, 113, 114, 115, 114, 115, 113, 113, 112, 111, 110, 108,
106, 104, 102, 98, 96, 92, 89, 85, 79, 74, 68, 61, 53, 45, 36, 28, 19, 10, 2,
-6, -13, -22, -28, -34, -40, -46, -52, -58, -63, -67, -70, -75, -78, -82, -85,
-89, -92, -95, -98, -100, -102, -104, -106, -108, -110, -111, -112, -113, -114,
-115, -115, -116, -116, -116, -118, -118, -118, -118, -118, -118, -119, -118,
-118, -118, -118, -119, -119, -119, -120, -119, -118, -119, -119, -118, -119,
-118, -117, -116, -116, -115, -114, -112, -111, -110, -107, -107, -105, -104,
-101, -100, -98, -96, -95, -92, -91, -89, -88, -86, -84, -83, -81, -80, -78,
-77, -75, -74, -71, -69, -69, -67, -66, -64, -62, -62, -59, -58, -56, -56, -54,
-52, -52, -49, -48, -47, -46, -46, -45, -46, -45, -46, -46, -47, -49, -50, -51,
-53, -55, -58, -60, -62, -65, -67, -70, -72, -74, -77, -79, -82, -84, -86, -88,
-90, -91, -93, -95, -96, -98, -98, -99, -100, -100, -101, -102, -101, -102,
-102, -102, -102, -101, -101, -100, -100, -99, -97, -96, -94, -93, -92, -90,
-87, -86, -83, -81, -78, -75, -71, -66, -62, -56, -49, -43, -36, -27, -19, -11,
-3, };