#define DATA_LENGTH 512
#define DATA AKWF_0852

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 5, 6, 8, 7, 9, 8, 9, 8, 11,
6, 20, 55, 58, 64, 68, 71, 75, 76, 79, 81, 82, 84, 87, 87, 89, 90, 92, 92, 94,
95, 96, 96, 97, 98, 100, 100, 101, 102, 103, 103, 104, 104, 105, 105, 106, 107,
107, 108, 109, 109, 109, 110, 110, 111, 110, 112, 112, 113, 113, 113, 113, 115,
114, 115, 115, 115, 116, 115, 116, 117, 117, 117, 117, 117, 117, 118, 118, 118,
118, 118, 118, 118, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 120, 118,
122, 89, 74, 72, 66, 65, 61, 59, 57, 56, 53, 52, 50, 49, 47, 47, 45, 44, 43, 41,
41, 40, 39, 38, 38, 37, 36, 34, 35, 33, 33, 33, 31, 30, 30, 29, 29, 28, 28, 27,
27, 26, 26, 26, 24, 25, 23, 23, 23, 23, 22, 22, 20, 20, 20, 20, 20, 18, 19, 18,
18, 17, 17, 17, 17, 16, 16, 16, 16, 15, 15, 15, 15, 14, 14, 13, 13, 14, 13, 13,
12, 12, 12, 12, 12, 12, 12, 11, 11, 11, 11, 11, 10, 10, 9, 10, 10, 9, 9, 9, 9,
9, 9, 9, 10, 9, 9, 9, 9, 9, 8, 8, 8, 8, 9, 8, 8, 8, 7, 8, 8, 8, 8, 9, 8, 9, 8,
8, 8, 9, 7, 8, 8, 9, 8, 7, 9, 7, 10, -3, -14, -12, -16, -16, -18, -19, -20, -21,
-22, -23, -23, -23, -25, -25, -26, -27, -26, -27, -28, -28, -28, -30, -29, -30,
-30, -31, -31, -31, -31, -32, -33, -32, -33, -33, -33, -33, -34, -34, -35, -35,
-35, -36, -36, -35, -36, -36, -37, -37, -37, -37, -37, -37, -38, -38, -38, -38,
-39, -39, -39, -39, -39, -40, -39, -40, -40, -40, -41, -40, -40, -40, -40, -41,
-41, -41, -41, -42, -42, -42, -42, -42, -43, -43, -43, -43, -42, -43, -43, -43,
-43, -43, -44, -44, -43, -44, -43, -44, -44, -44, -44, -44, -44, -45, -45, -44,
-45, -46, -45, -45, -45, -45, -45, -46, -46, -47, -46, -46, -47, -45, -46, -46,
-46, -47, -46, -46, -47, -47, -48, -48, -46, -47, -48, -47, -48, -48, -48, -48,
-48, -48, -48, -48, -48, -48, -48, -48, -48, -48, -48, -49, -48, -49, -49, -49,
-49, -49, -49, -49, -49, -49, -50, -49, -49, -49, -50, -50, -50, -49, -49, -50,
-50, -50, -50, -50, -51, -50, -50, -50, -51, -50, -51, -50, -51, -51, -50, -50,
-51, -51, -50, -50, -50, -50, -51, -50, -51, -51, -50, -50, -51, -51, -51, -51,
-52, -50, -51, -51, -51, -51, -51, -51, -52, -51, -51, -51, -52, -51, -51, -51,
-51, -51, -51, -52, -51, -51, -51, -52, -51, -52, -52, -52, -51, -51, -51, -51,
-52, -52, -52, -51, -52, -52, -52, -52, -52, -51, -51, -52, -51, -52, -52, -52,
-52, -52, -52, -53, -52, -52, -52, -52, -52, -52, -52, -52, -52, -52, -51, -52,
-51, -52, -51, -53, -49, -18, -12, -8, -4, -4, 0, };