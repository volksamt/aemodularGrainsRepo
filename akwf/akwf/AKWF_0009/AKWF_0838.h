#define DATA_LENGTH 512
#define DATA AKWF_0838

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 11, 13, 17, 23, 26, 30, 34, 38,
42, 47, 50, 53, 57, 61, 64, 67, 71, 75, 77, 80, 82, 87, 88, 92, 93, 96, 98, 100,
103, 104, 106, 108, 109, 110, 112, 114, 114, 116, 115, 117, 117, 118, 119, 119,
118, 119, 119, 119, 118, 119, 119, 118, 118, 118, 117, 117, 117, 116, 115, 115,
114, 113, 113, 112, 112, 111, 111, 110, 109, 108, 107, 106, 106, 106, 105, 104,
103, 102, 102, 101, 100, 101, 100, 100, 99, 98, 98, 98, 98, 97, 96, 96, 96, 96,
96, 95, 95, 95, 94, 93, 94, 94, 93, 94, 94, 93, 93, 93, 92, 93, 93, 93, 93, 93,
92, 92, 92, 92, 91, 91, 91, 92, 92, 91, 92, 90, 92, 90, 90, 91, 90, 91, 90, 89,
90, 89, 90, 89, 89, 89, 89, 88, 88, 88, 88, 88, 88, 87, 87, 87, 87, 87, 87, 86,
86, 85, 85, 84, 84, 85, 84, 84, 83, 82, 83, 83, 81, 81, 80, 80, 79, 79, 78, 79,
77, 77, 76, 75, 74, 74, 73, 73, 72, 71, 70, 69, 69, 67, 67, 65, 65, 63, 63, 61,
60, 59, 58, 57, 55, 55, 54, 52, 52, 49, 49, 47, 46, 45, 44, 42, 41, 39, 38, 37,
36, 34, 33, 33, 31, 30, 28, 28, 27, 25, 24, 22, 22, 21, 19, 18, 18, 16, 16, 15,
14, 14, 12, 11, 10, 10, 9, 8, 7, 6, 6, 5, 4, 4, 3, 3, 1, 0, 0, -1, -1, -2, -2,
-4, -4, -5, -5, -6, -6, -7, -8, -8, -10, -10, -11, -11, -12, -13, -14, -16, -16,
-18, -18, -19, -20, -21, -21, -23, -23, -25, -26, -28, -29, -30, -30, -32, -33,
-34, -35, -37, -38, -39, -40, -42, -43, -44, -45, -46, -48, -50, -50, -52, -53,
-54, -56, -56, -57, -58, -61, -61, -62, -64, -64, -65, -67, -67, -68, -69, -70,
-71, -72, -73, -73, -74, -75, -76, -77, -77, -78, -78, -78, -80, -80, -80, -80,
-81, -82, -83, -82, -83, -84, -84, -84, -85, -85, -85, -86, -85, -86, -86, -86,
-86, -87, -87, -88, -87, -87, -88, -88, -89, -89, -89, -89, -89, -90, -89, -89,
-90, -89, -90, -91, -90, -91, -91, -90, -91, -91, -91, -91, -91, -91, -92, -92,
-92, -93, -92, -91, -92, -92, -92, -92, -93, -92, -93, -93, -93, -93, -94, -93,
-93, -93, -94, -93, -94, -94, -94, -94, -93, -94, -95, -95, -95, -95, -96, -96,
-97, -97, -97, -97, -98, -98, -99, -99, -99, -100, -100, -101, -101, -102, -103,
-104, -104, -105, -106, -107, -106, -108, -109, -108, -110, -110, -111, -112,
-113, -113, -113, -114, -114, -115, -115, -116, -117, -117, -117, -117, -117,
-117, -117, -117, -116, -117, -116, -116, -116, -115, -115, -113, -113, -112,
-110, -110, -108, -105, -104, -102, -102, -99, -98, -95, -93, -91, -88, -85,
-82, -80, -77, -74, -71, -68, -64, -61, -57, -54, -49, -46, -43, -39, -35, -30,
-27, -23, -19, -15, -10, -7, -1, };