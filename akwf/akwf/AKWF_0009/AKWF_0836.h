#define DATA_LENGTH 512
#define DATA AKWF_0836

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 14, 17, 20, 23, 26, 29,
32, 35, 38, 40, 43, 47, 48, 51, 53, 56, 59, 62, 63, 66, 68, 71, 73, 74, 76, 79,
80, 83, 85, 87, 89, 91, 92, 94, 95, 97, 100, 101, 102, 104, 106, 107, 108, 109,
110, 112, 113, 116, 116, 117, 118, 119, 118, 119, 119, 119, 119, 120, 119, 120,
118, 119, 118, 118, 118, 118, 118, 117, 117, 117, 117, 117, 116, 116, 116, 116,
115, 115, 115, 114, 114, 114, 113, 113, 113, 113, 112, 111, 111, 111, 111, 111,
110, 110, 109, 109, 108, 108, 108, 108, 107, 108, 106, 107, 106, 106, 106, 105,
105, 104, 104, 104, 104, 102, 102, 103, 102, 102, 102, 101, 101, 101, 100, 99,
98, 95, 92, 91, 89, 87, 86, 83, 82, 80, 79, 77, 76, 74, 71, 70, 68, 67, 66, 64,
63, 62, 60, 59, 58, 57, 56, 55, 52, 52, 51, 50, 48, 47, 46, 45, 43, 42, 40, 39,
38, 36, 35, 34, 32, 32, 30, 29, 28, 27, 26, 24, 24, 23, 21, 21, 19, 19, 17, 16,
14, 14, 13, 12, 11, 10, 10, 9, 8, 7, 6, 6, 4, 4, 3, 3, 1, 1, 0, 0, -1, -2, -3,
-2, -3, -4, -5, -6, -6, -6, -7, -7, -8, -8, -9, -9, -10, -10, -11, -11, -12,
-13, -13, -14, -16, -16, -16, -17, -18, -18, -19, -19, -20, -21, -22, -23, -23,
-24, -24, -25, -25, -26, -26, -27, -27, -28, -29, -29, -30, -30, -31, -32, -32,
-32, -33, -33, -33, -34, -35, -35, -35, -36, -36, -38, -38, -38, -37, -38, -39,
-38, -40, -39, -40, -40, -41, -41, -41, -42, -42, -42, -42, -43, -44, -44, -44,
-44, -44, -44, -44, -45, -46, -46, -46, -47, -47, -47, -47, -47, -48, -48, -48,
-48, -49, -49, -49, -49, -49, -49, -50, -50, -50, -51, -51, -50, -51, -51, -51,
-52, -51, -52, -51, -52, -52, -52, -52, -53, -52, -53, -53, -53, -53, -53, -53,
-54, -54, -54, -54, -54, -54, -54, -54, -54, -55, -54, -55, -54, -54, -55, -55,
-56, -55, -55, -56, -55, -56, -55, -56, -56, -57, -56, -56, -56, -56, -57, -56,
-57, -57, -57, -57, -57, -56, -58, -57, -56, -57, -57, -58, -58, -57, -58, -57,
-58, -57, -57, -58, -57, -58, -58, -58, -58, -58, -58, -58, -59, -58, -58, -57,
-57, -59, -58, -58, -58, -58, -58, -59, -58, -58, -57, -57, -58, -58, -57, -57,
-57, -56, -56, -56, -56, -56, -56, -57, -57, -58, -59, -60, -60, -61, -62, -63,
-63, -64, -65, -66, -66, -68, -69, -69, -70, -71, -71, -73, -73, -74, -74, -75,
-76, -76, -78, -78, -79, -79, -80, -81, -82, -83, -83, -83, -84, -85, -85, -85,
-87, -86, -87, -87, -89, -90, -89, -90, -91, -91, -91, -92, -93, -93, -93, -94,
-94, -94, -95, -94, -91, -87, -82, -79, -75, -70, -65, -61, -57, -53, -49, -44,
-40, -36, -33, -29, -25, -21, -17, -14, -10, -6, -2, };