#define DATA_LENGTH 512
#define DATA AKWF_0865

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 6, 8, 10, 12, 13, 16, 18, 20,
22, 24, 26, 28, 31, 35, 37, 41, 44, 47, 50, 53, 58, 61, 66, 69, 73, 77, 81, 84,
87, 89, 89, 89, 89, 90, 88, 88, 86, 85, 82, 79, 74, 71, 67, 63, 60, 57, 52, 48,
44, 40, 36, 32, 28, 22, 18, 13, 9, 5, -1, -5, -10, -15, -21, -25, -29, -33, -39,
-43, -48, -52, -57, -61, -64, -68, -71, -76, -79, -82, -85, -88, -91, -93, -96,
-99, -101, -103, -105, -107, -109, -111, -112, -113, -114, -115, -117, -117,
-118, -118, -118, -119, -120, -119, -119, -119, -118, -117, -117, -115, -115,
-114, -112, -112, -110, -108, -107, -105, -103, -101, -99, -97, -95, -92, -90,
-87, -85, -82, -79, -75, -73, -69, -66, -61, -57, -53, -48, -42, -37, -33, -27,
-23, -17, -12, -8, -2, 1, 6, 10, 15, 19, 22, 26, 29, 33, 36, 39, 41, 44, 46, 49,
51, 54, 56, 58, 59, 61, 63, 63, 65, 66, 66, 67, 68, 69, 68, 68, 69, 69, 68, 66,
66, 66, 65, 64, 63, 62, 60, 58, 58, 56, 54, 53, 51, 50, 47, 45, 43, 41, 38, 37,
34, 31, 30, 27, 25, 21, 18, 16, 13, 9, 6, 2, -1, -3, -6, -10, -13, -16, -19,
-23, -26, -28, -31, -35, -38, -39, -42, -44, -47, -49, -52, -54, -56, -59, -60,
-62, -64, -65, -66, -68, -69, -71, -72, -74, -75, -77, -77, -79, -80, -79, -80,
-82, -82, -83, -84, -84, -85, -85, -85, -85, -86, -86, -85, -86, -84, -84, -84,
-83, -82, -82, -81, -80, -79, -78, -76, -75, -74, -72, -70, -69, -67, -65, -63,
-61, -58, -57, -54, -51, -49, -48, -45, -43, -40, -38, -37, -35, -34, -31, -29,
-27, -25, -23, -21, -19, -17, -15, -13, -12, -10, -8, -6, -5, -2, -2, 0, 1, 2,
3, 3, 2, 3, 3, 3, 3, 3, 2, 2, 2, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 2, 2, 2, 2, 2, 3,
3, 3, 4, 4, 5, 6, 5, 6, 6, 7, 6, 7, 7, 8, 8, 8, 8, 8, 8, 9, 9, 9, 10, 9, 10, 10,
10, 10, 10, 10, 10, 10, 10, 10, 9, 9, 9, 9, 8, 8, 8, 7, 7, 6, 6, 6, 5, 6, 4, 4,
4, 3, 3, 3, 1, 0, -1, -2, -3, -4, -5, -7, -8, -10, -11, -13, -15, -16, -17, -19,
-21, -22, -24, -25, -27, -29, -31, -33, -34, -35, -37, -40, -41, -43, -44, -47,
-47, -50, -52, -52, -54, -56, -58, -59, -60, -61, -64, -64, -66, -67, -68, -69,
-71, -72, -74, -73, -74, -75, -76, -78, -77, -78, -78, -79, -79, -79, -80, -79,
-80, -80, -79, -79, -80, -79, -78, -77, -76, -75, -74, -72, -72, -70, -68, -67,
-64, -63, -60, -58, -55, -53, -51, -48, -46, -42, -40, -36, -35, -33, -32, -30,
-30, -28, -28, -26, -24, -23, -21, -19, -18, -16, -13, -12, -9, -8, -5, -2, 1,
};