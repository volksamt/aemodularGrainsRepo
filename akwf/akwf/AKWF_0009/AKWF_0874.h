#define DATA_LENGTH 512
#define DATA AKWF_0874

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 6, 7, 9, 9, 11, 13, 15,
16, 17, 19, 21, 22, 23, 25, 27, 29, 30, 32, 33, 34, 37, 39, 40, 42, 44, 46, 47,
49, 52, 53, 55, 57, 60, 61, 64, 64, 67, 69, 71, 74, 76, 77, 79, 82, 83, 85, 87,
90, 91, 93, 95, 97, 99, 100, 103, 103, 105, 107, 108, 109, 111, 112, 113, 114,
115, 116, 117, 118, 118, 119, 119, 119, 119, 119, 119, 120, 118, 118, 118, 117,
117, 116, 115, 114, 112, 111, 110, 108, 106, 105, 103, 102, 100, 98, 95, 94, 91,
89, 87, 84, 82, 79, 77, 74, 71, 69, 65, 62, 60, 57, 53, 51, 48, 45, 42, 38, 36,
33, 30, 28, 24, 21, 18, 14, 12, 9, 6, 3, 1, -2, -4, -7, -10, -12, -15, -18, -19,
-22, -25, -27, -28, -31, -34, -35, -36, -38, -40, -43, -43, -45, -46, -48, -50,
-50, -51, -52, -53, -54, -54, -56, -56, -57, -58, -59, -58, -60, -58, -60, -59,
-59, -59, -59, -60, -59, -59, -59, -58, -58, -58, -56, -57, -56, -55, -55, -54,
-53, -52, -52, -51, -51, -49, -48, -48, -47, -45, -45, -43, -42, -42, -41, -39,
-39, -38, -37, -37, -36, -34, -33, -32, -31, -31, -30, -29, -27, -27, -25, -26,
-24, -23, -23, -22, -22, -21, -20, -19, -19, -18, -17, -17, -16, -16, -15, -14,
-14, -13, -13, -13, -12, -12, -12, -11, -11, -10, -9, -10, -10, -9, -9, -9, -8,
-9, -9, -9, -9, -9, -8, -8, -9, -8, -8, -8, -7, -8, -8, -9, -8, -8, -8, -8, -7,
-8, -8, -8, -8, -8, -8, -8, -9, -9, -8, -9, -9, -8, -8, -8, -8, -8, -8, -8, -8,
-8, -8, -8, -8, -8, -8, -8, -7, -7, -7, -7, -8, -7, -7, -8, -7, -7, -6, -7, -6,
-6, -6, -6, -6, -6, -6, -6, -5, -5, -5, -5, -4, -5, -5, -4, -4, -5, -4, -4, -3,
-4, -4, -4, -4, -3, -3, -3, -3, -3, -3, -3, -2, -3, -3, -4, -3, -3, -2, -3, -3,
-3, -4, -4, -4, -4, -4, -4, -4, -5, -6, -5, -6, -6, -6, -6, -7, -7, -7, -8, -8,
-8, -9, -10, -10, -11, -11, -12, -12, -13, -13, -14, -14, -14, -16, -16, -16,
-17, -17, -18, -18, -19, -20, -21, -21, -22, -22, -23, -24, -23, -25, -25, -26,
-27, -27, -28, -29, -30, -30, -30, -32, -31, -32, -32, -34, -34, -35, -35, -36,
-36, -37, -38, -39, -39, -39, -40, -40, -40, -41, -40, -41, -41, -42, -42, -43,
-42, -43, -44, -43, -44, -44, -44, -43, -44, -45, -44, -45, -44, -44, -45, -44,
-44, -44, -45, -44, -43, -44, -43, -43, -42, -42, -41, -42, -41, -40, -40, -39,
-39, -39, -37, -37, -37, -37, -36, -35, -35, -33, -32, -32, -31, -31, -30, -29,
-28, -26, -26, -25, -24, -23, -22, -22, -20, -19, -18, -17, -16, -15, -14, -12,
-12, -11, -9, -9, -6, -6, -5, -3, -3, 0, };