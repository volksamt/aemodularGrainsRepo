#define DATA_LENGTH 512
#define DATA AKWF_0849

const PROGMEM int8_t DATA[DATA_LENGTH] = {64, 77, 71, 76, 72, 75, 72, 74, 73,
74, 73, 74, 73, 74, 73, 74, 74, 74, 73, 73, 74, 73, 73, 74, 73, 74, 74, 74, 74,
73, 74, 73, 74, 73, 74, 74, 73, 74, 74, 73, 73, 73, 72, 73, 73, 73, 73, 74, 73,
73, 73, 73, 73, 73, 73, 74, 73, 73, 74, 74, 73, 74, 74, 73, 73, 73, 73, 73, 74,
73, 73, 73, 73, 73, 73, 73, 73, 73, 73, 73, 73, 73, 72, 73, 73, 73, 72, 73, 72,
74, 73, 73, 72, 73, 72, 73, 72, 73, 73, 73, 72, 73, 72, 72, 73, 73, 73, 73, 73,
73, 73, 72, 74, 72, 74, 71, 74, 71, 74, 71, 75, 70, 75, 70, 74, 71, 75, 69, -38,
-46, -41, -46, -41, -45, -41, -45, -41, -46, -42, -45, -43, -45, -42, -45, -42,
-44, -43, -44, -43, -43, -44, -43, -44, -43, -44, -43, -45, -44, -44, -43, -44,
-43, -45, -43, -45, -43, -45, -42, -45, -42, -46, -42, -45, -41, -50, -119,
-119, -119, -120, -118, -120, -118, -120, -118, -120, -118, -119, -118, -120,
-119, -120, -118, -119, -118, -119, -119, -118, -119, -119, -119, -118, -119,
-118, -119, -118, -120, -118, -119, -119, -120, -118, -119, -119, -120, -118,
-119, -118, -118, -119, -117, -120, -117, -120, -117, -121, -114, -123, -112,
-128, -64, 11, -10, 2, -6, -1, -4, -2, -4, -2, -4, -2, -3, -3, -3, -4, -2, -3,
-2, -4, -3, -3, -2, -4, -3, -4, -2, -3, -2, -3, -3, -3, -2, -3, -4, -3, -3, -4,
-3, -3, -3, -3, -3, -2, -4, -3, -3, -3, -3, -2, -3, -3, -3, -3, -3, -3, -3, -3,
-2, -2, -4, -3, -3, -3, -3, -3, -3, -2, -4, -3, -2, -3, -3, -2, -3, -2, -3, -3,
-3, -3, -3, -4, -2, -2, -3, -2, -2, -3, -3, -2, -3, -3, -2, -3, -3, -2, -3, -2,
-3, -3, -3, -2, -3, -2, -2, -3, -2, -3, -3, -3, -3, -2, -3, -3, -3, -3, -3, -3,
-3, -2, -2, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -2, -3, -2, -3, -3, -3, -3,
-3, -3, -3, -3, -3, -2, -2, -3, -2, -3, -3, -3, -3, -3, -3, -3, -3, -2, -3, -3,
-3, -3, -3, -2, -3, -2, -3, -2, -3, -3, -3, -2, -2, -3, -2, -3, -3, -3, -2, -2,
-2, -3, -3, -2, -2, -3, -2, -3, -2, -3, -2, -3, -3, -4, -2, -2, -2, -3, -3, -4,
-3, -3, -3, -2, -3, -2, -3, -3, -2, -3, -3, -3, -3, -3, -3, -2, -3, -3, -3, -3,
-2, -2, -2, -2, -2, -2, -2, -3, -2, -3, -2, -3, -3, -3, -3, -3, -2, -2, -3, -3,
-3, -2, -3, -3, -3, -2, -4, -2, -2, -2, -3, -2, -3, -2, -4, -3, -2, -2, -3, -3,
-3, -3, -2, -3, -3, -3, -2, -3, -2, -3, -2, -3, -1, -3, -1, -4, -1, -5, 0, -5,
0, -6, 1, -8, -48, };