#define DATA_LENGTH 512
#define DATA AKWF_0885

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 7, 10, 13, 16, 18, 22, 24, 28,
30, 33, 35, 38, 41, 44, 46, 48, 51, 54, 55, 57, 60, 62, 64, 66, 68, 70, 72, 73,
75, 77, 78, 80, 81, 83, 85, 86, 87, 88, 89, 90, 92, 92, 94, 94, 95, 97, 98, 99,
99, 101, 100, 101, 102, 103, 103, 103, 104, 105, 105, 106, 106, 106, 107, 107,
107, 108, 108, 109, 109, 108, 109, 109, 109, 109, 109, 111, 110, 110, 110, 110,
110, 110, 110, 110, 110, 110, 110, 111, 110, 110, 109, 109, 109, 110, 109, 109,
110, 108, 109, 108, 107, 108, 108, 107, 107, 105, 105, 105, 104, 104, 103, 101,
100, 100, 99, 97, 96, 95, 93, 92, 90, 88, 86, 85, 84, 81, 80, 78, 75, 72, 71,
68, 65, 62, 60, 57, 54, 52, 49, 45, 42, 39, 37, 33, 30, 27, 24, 21, 17, 15, 10,
7, 4, 1, -3, -5, -8, -11, -14, -17, -20, -23, -26, -29, -32, -35, -37, -39, -42,
-45, -47, -49, -52, -53, -57, -59, -60, -63, -65, -67, -69, -71, -72, -74, -76,
-77, -79, -81, -82, -83, -85, -87, -88, -89, -90, -91, -93, -94, -95, -95, -97,
-98, -99, -100, -100, -102, -102, -103, -103, -103, -104, -105, -106, -106,
-108, -107, -108, -108, -109, -109, -109, -111, -111, -111, -111, -111, -112,
-111, -113, -113, -113, -113, -114, -114, -114, -113, -114, -114, -115, -115,
-115, -115, -115, -115, -115, -114, -116, -115, -115, -116, -116, -116, -116,
-115, -116, -116, -115, -116, -116, -116, -116, -117, -116, -116, -116, -117,
-116, -115, -115, -116, -116, -116, -116, -116, -117, -116, -117, -116, -116,
-116, -116, -116, -116, -117, -116, -117, -116, -117, -117, -117, -117, -116,
-116, -117, -116, -118, -118, -117, -117, -117, -118, -117, -118, -117, -117,
-117, -118, -118, -117, -116, -117, -117, -118, -118, -117, -118, -118, -117,
-118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118,
-118, -118, -118, -119, -118, -118, -118, -118, -118, -118, -118, -118, -119,
-118, -119, -118, -119, -119, -119, -119, -119, -119, -118, -119, -119, -118,
-119, -119, -119, -119, -120, -119, -119, -120, -119, -120, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -118, -119, -118, -118, -119,
-119, -119, -119, -118, -119, -118, -118, -118, -118, -119, -118, -118, -117,
-118, -117, -117, -118, -117, -117, -117, -117, -117, -116, -117, -116, -116,
-116, -117, -116, -116, -116, -116, -115, -115, -115, -115, -115, -114, -114,
-114, -114, -114, -115, -114, -115, -114, -113, -112, -113, -112, -113, -113,
-112, -112, -111, -111, -112, -111, -111, -111, -111, -111, -111, -110, -109,
-110, -109, -109, -109, -108, -109, -108, -108, -108, -108, -107, -107, -106,
-105, -105, -105, -104, -103, -103, -102, -101, -100, -99, -98, -96, -95, -94,
-92, -90, -88, -87, -85, -84, -82, -80, -78, -75, -74, -70, -68, -66, -63, -61,
-58, -55, -53, -50, -47, -43, -40, -37, -34, -31, -27, -24, -20, -18, -16, -11,
-8, -5, -2, };