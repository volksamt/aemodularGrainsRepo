#define DATA_LENGTH 512
#define DATA AKWF_0837

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 6, 8, 10, 11, 14, 16, 18, 20,
22, 23, 25, 28, 29, 31, 33, 35, 37, 40, 42, 43, 45, 47, 48, 50, 52, 53, 56, 58,
59, 61, 63, 65, 67, 69, 70, 72, 74, 75, 77, 79, 81, 82, 83, 85, 87, 89, 90, 92,
93, 95, 97, 97, 99, 99, 101, 102, 103, 104, 105, 107, 107, 108, 109, 110, 111,
112, 112, 113, 113, 115, 114, 116, 115, 116, 117, 117, 117, 118, 118, 119, 118,
119, 118, 119, 119, 120, 120, 120, 119, 119, 119, 118, 118, 119, 119, 118, 118,
118, 118, 117, 118, 117, 117, 116, 116, 116, 115, 115, 115, 115, 113, 113, 113,
112, 112, 111, 111, 111, 110, 110, 109, 108, 108, 107, 107, 106, 105, 104, 104,
103, 102, 101, 102, 101, 100, 99, 98, 98, 96, 96, 95, 95, 93, 93, 92, 91, 90,
90, 89, 87, 87, 86, 85, 84, 83, 82, 81, 81, 80, 78, 77, 77, 76, 74, 74, 73, 70,
70, 69, 68, 67, 66, 65, 64, 62, 61, 61, 60, 59, 57, 57, 55, 54, 53, 53, 52, 50,
50, 48, 48, 47, 46, 45, 45, 44, 42, 42, 40, 40, 39, 38, 37, 37, 35, 36, 35, 33,
33, 32, 31, 32, 31, 30, 29, 28, 28, 27, 27, 26, 25, 25, 24, 23, 22, 23, 21, 21,
20, 20, 19, 18, 17, 16, 16, 15, 14, 14, 14, 12, 12, 12, 10, 10, 8, 8, 7, 5, 6,
4, 3, 2, 2, 1, -1, -2, -3, -5, -6, -7, -8, -10, -11, -12, -13, -14, -15, -17,
-18, -20, -22, -22, -24, -26, -27, -28, -29, -31, -32, -34, -35, -36, -38, -39,
-41, -42, -44, -44, -47, -48, -49, -51, -52, -52, -55, -55, -58, -59, -60, -61,
-62, -64, -65, -66, -67, -68, -70, -70, -71, -72, -73, -74, -76, -75, -76, -77,
-78, -78, -78, -79, -80, -80, -80, -81, -80, -81, -82, -83, -82, -81, -82, -83,
-82, -82, -81, -82, -81, -81, -81, -81, -81, -81, -81, -80, -79, -80, -79, -79,
-79, -78, -78, -78, -77, -76, -76, -76, -75, -75, -75, -73, -73, -72, -73, -71,
-71, -71, -71, -71, -70, -70, -70, -70, -70, -69, -69, -69, -69, -69, -70, -69,
-69, -69, -69, -71, -70, -71, -72, -71, -73, -73, -73, -74, -75, -76, -76, -76,
-77, -79, -79, -80, -81, -82, -83, -84, -85, -85, -86, -88, -88, -89, -91, -91,
-92, -94, -95, -95, -96, -98, -99, -99, -100, -102, -102, -103, -105, -105,
-105, -106, -107, -109, -109, -110, -110, -111, -111, -112, -112, -113, -113,
-113, -113, -113, -114, -112, -112, -113, -113, -112, -111, -111, -110, -109,
-109, -107, -107, -105, -104, -104, -103, -101, -99, -99, -96, -96, -94, -93,
-91, -89, -87, -86, -84, -82, -80, -79, -76, -74, -72, -71, -68, -66, -64, -62,
-60, -58, -55, -54, -52, -49, -47, -45, -43, -41, -39, -37, -34, -33, -30, -28,
-26, -24, -21, -19, -18, -15, -13, -11, -8, -6, -5, -2, 0, };