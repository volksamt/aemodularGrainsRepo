#define DATA_LENGTH 512
#define DATA AKWF_0869

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 6, 12, 17, 23, 29, 35, 40, 45, 49,
56, 60, 67, 70, 78, 80, 88, 88, 99, 98, 108, 106, 118, 111, 9, 1, 1, -6, -6,
-11, -13, -17, -22, 4, 25, 11, 16, 7, 8, 3, 2, -1, -5, -5, -12, -9, -19, -9,
-33, 31, 99, 64, 63, 43, 36, 20, 10, -3, -14, -24, -36, -47, -57, -59, -62, -63,
-65, -65, -68, -69, -72, -71, -74, -75, -76, -78, -80, -81, -82, -83, -85, -87,
-88, -89, -91, -92, -94, -95, -96, -99, -97, -89, -82, -76, -69, -63, -57, -52,
-45, -40, -35, -29, -23, -19, -14, -9, -3, 1, 6, 10, 14, 18, 22, 26, 30, 33, 37,
40, 44, 46, 50, 53, 56, 58, 61, 63, 65, 67, 70, 71, 74, 76, 78, 80, 81, 82, 84,
85, 86, 87, 88, 89, 91, 92, 93, 92, 94, 93, 90, 85, 82, 79, 75, 71, 68, 65, 61,
58, 54, 50, 46, 43, 40, 36, 33, 30, 27, 23, 21, 17, 14, 11, 8, 5, 2, -1, -3, -7,
-9, -13, -15, -18, -20, -23, -27, -29, -31, -33, -36, -39, -40, -43, -45, -48,
-49, -51, -54, -55, -58, -59, -61, -63, -64, -66, -68, -70, -70, -72, -73, -74,
-76, -78, -78, -80, -80, -82, -82, -82, -77, -74, -69, -67, -61, -59, -54, -50,
-83, -86, -78, -77, -70, -69, -63, -61, -55, -53, -47, -44, -39, -36, -32, -28,
-24, -21, -16, -13, -9, -4, -2, 2, 6, 10, 14, 17, 21, 25, 27, 31, 35, 39, 42,
46, 49, 53, 56, 60, 63, 67, 70, 73, 77, 80, 83, 86, 90, 93, 97, 100, 103, 106,
109, 112, 117, 113, 106, 101, 95, 91, 85, 80, 74, 70, 64, 59, 55, 50, 45, 41,
37, 33, 29, 25, 21, 17, 14, 10, 7, 3, 1, -3, -6, -10, -12, -14, -18, -20, -23,
-26, -28, -30, -33, -36, -38, -40, -42, -44, -47, -49, -51, -53, -54, -56, -59,
-60, -62, -64, -64, -66, -68, -70, -69, -66, -63, -60, -58, -54, -52, -49, -46,
-44, -42, -39, -36, -34, -31, -30, -27, -24, -23, -20, -19, -17, -15, -13, -11,
-8, -7, -6, -4, -2, -1, 0, 1, 3, 5, 5, 7, 7, 8, 10, 10, 12, 12, 13, 14, 15, 16,
16, 16, 18, 18, 19, 18, 19, 20, 20, 19, 20, 19, 20, 19, 20, 20, 20, 20, 20, 20,
20, 19, 20, 19, 18, 19, 18, 18, 17, 18, 17, 17, 16, 15, 15, 14, 14, 14, 12, 12,
11, 11, 11, 10, 9, 8, 8, 7, 7, 6, 6, 4, 5, 4, 3, 2, 1, 2, 1, 0, 0, 0, -2, -1,
-3, -2, -3, -4, -5, -4, -6, -6, -6, -7, -7, -8, -7, -8, -7, -8, -9, -10, -8,
-10, -10, -16, -19, -26, -28, -35, -37, -45, -46, -53, -54, -13, -12, -19, -19,
-27, -29, -35, -35, -42, -42, -47, -51, -53, -58, -56, -68, -4, 20, 19, 21, 9,
21, 21, 29, 30, 37, 38, 49, -1, -8, };