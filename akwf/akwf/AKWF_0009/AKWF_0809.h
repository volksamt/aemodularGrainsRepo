#define DATA_LENGTH 512
#define DATA AKWF_0809

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 11, 14, 17, 22, 25, 29, 31, 35,
37, 39, 42, 44, 45, 47, 47, 49, 50, 51, 52, 52, 54, 53, 54, 53, 53, 52, 51, 52,
50, 49, 48, 47, 47, 46, 47, 46, 45, 45, 45, 44, 44, 44, 44, 43, 42, 42, 42, 41,
41, 40, 41, 41, 42, 42, 43, 43, 45, 45, 47, 48, 48, 49, 50, 51, 51, 53, 53, 52,
53, 54, 55, 55, 56, 56, 56, 56, 55, 55, 55, 55, 54, 54, 53, 52, 52, 51, 49, 49,
47, 47, 45, 44, 42, 40, 39, 37, 36, 33, 32, 30, 28, 27, 24, 23, 20, 18, 17, 15,
12, 11, 8, 6, 4, 2, 1, -2, -4, -7, -9, -11, -13, -15, -17, -19, -21, -23, -25,
-26, -28, -29, -30, -31, -32, -32, -34, -34, -34, -34, -35, -34, -34, -34, -33,
-34, -33, -33, -33, -32, -33, -33, -34, -33, -34, -33, -34, -34, -34, -35, -35,
-35, -36, -37, -37, -37, -39, -39, -40, -41, -41, -42, -41, -43, -43, -42, -44,
-43, -44, -44, -44, -44, -45, -45, -44, -44, -44, -44, -42, -43, -43, -41, -41,
-40, -39, -39, -38, -36, -36, -34, -34, -32, -30, -29, -28, -27, -25, -24, -22,
-22, -20, -18, -16, -14, -12, -11, -8, -7, -6, -3, -2, 0, 2, 3, 4, 6, 8, 9, 11,
12, 14, 15, 16, 18, 19, 20, 21, 23, 24, 24, 27, 28, 29, 29, 30, 32, 32, 34, 34,
34, 35, 36, 37, 37, 38, 38, 39, 39, 40, 40, 40, 41, 41, 41, 42, 42, 41, 42, 43,
42, 42, 43, 42, 44, 43, 44, 43, 43, 43, 43, 43, 43, 43, 43, 43, 43, 43, 43, 42,
43, 42, 43, 43, 43, 43, 43, 43, 43, 43, 42, 43, 42, 42, 43, 43, 43, 42, 43, 43,
43, 43, 43, 43, 43, 42, 43, 43, 44, 43, 43, 43, 43, 43, 43, 43, 43, 43, 43, 43,
43, 42, 42, 42, 42, 42, 42, 41, 41, 40, 40, 40, 40, 40, 40, 40, 38, 38, 38, 37,
36, 35, 35, 35, 34, 34, 33, 33, 32, 31, 30, 30, 29, 29, 27, 27, 25, 25, 24, 24,
22, 21, 20, 19, 18, 16, 16, 15, 13, 13, 12, 10, 9, 7, 7, 6, 5, 3, 2, 0, 0, -2,
-4, -5, -6, -8, -8, -10, -12, -12, -13, -15, -16, -18, -19, -19, -21, -22, -24,
-25, -26, -27, -29, -29, -31, -32, -34, -34, -35, -36, -38, -38, -39, -40, -41,
-42, -43, -44, -44, -45, -46, -47, -49, -49, -50, -51, -51, -52, -53, -54, -54,
-55, -56, -56, -56, -56, -57, -57, -59, -59, -59, -59, -60, -60, -62, -62, -64,
-66, -68, -71, -76, -78, -83, -87, -91, -95, -99, -102, -106, -109, -110, -113,
-114, -116, -117, -118, -119, -118, -120, -120, -118, -117, -117, -115, -114,
-111, -109, -107, -104, -101, -98, -95, -93, -89, -86, -82, -79, -73, -69, -65,
-59, -55, -49, -43, -38, -33, -27, -23, -18, -14, -9, -5, -1, };