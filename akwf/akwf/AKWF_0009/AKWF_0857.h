#define DATA_LENGTH 512
#define DATA AKWF_0857

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 2, 3, 4, 5, 6, 7, 7, 8, 9, 9,
9, 11, 11, 11, 12, 13, 13, 14, 14, 15, 16, 16, 16, 17, 17, 17, 18, 18, 18, 18,
19, 19, 19, 20, 20, 21, 21, 21, 21, 22, 21, 22, 22, 22, 22, 22, 23, 22, 23, 22,
22, 23, 22, 22, 23, 22, 23, 22, 23, 22, 22, 23, 22, 22, 23, 22, 22, 22, 22, 22,
21, 21, 22, 20, 21, 21, 20, 20, 19, 19, 20, 19, 20, 19, 18, 18, 18, 18, 17, 17,
17, 17, 16, 15, 15, 16, 15, 14, 15, 13, 13, 13, 13, 13, 12, 12, 12, 12, 12, 10,
10, 10, 10, 9, 9, 9, 8, 9, 7, 7, 7, 7, 6, 5, 5, 5, 5, 4, 3, 4, 3, 3, 2, 2, 2, 2,
1, 1, 0, 0, 0, -1, 0, -1, -1, -2, -2, -2, -3, -3, -4, -3, -4, -4, -5, -5, -6,
-6, -5, -7, -6, -7, -7, -7, -7, -8, -7, -9, -9, -9, -8, -10, -9, -10, -10, -10,
-10, -10, -10, -11, -11, -11, -12, -11, -12, -12, -13, -12, -12, -13, -13, -13,
-13, -13, -13, -13, -13, -14, -14, -14, -14, -15, -14, -14, -15, -14, -14, -15,
-14, -14, -15, -14, -14, -14, -15, -15, -14, -15, -15, -14, -15, -15, -15, -15,
-15, -15, -15, -15, -15, -15, -14, -14, -14, -14, -14, -15, -13, -14, -14, -14,
-14, -13, -14, -13, -13, -14, -13, -12, -12, -12, -12, -12, -12, -12, -12, -11,
-11, -11, -11, -12, -10, -10, -10, -11, -11, -9, -9, -10, -9, -9, -9, -8, -8,
-9, -7, -8, -6, -7, -6, -7, -6, -5, -6, -5, -5, -5, -5, -3, -3, -4, -3, -2, -3,
-2, -2, -1, -1, -1, -1, 0, 0, 1, 0, 1, 1, 2, 3, 3, 2, 3, 3, 4, 3, 5, 4, 6, 4, 6,
6, 6, 7, 7, 8, 8, 7, 8, 9, 9, 10, 10, 10, 11, 11, 11, 12, 12, 12, 13, 14, 14,
14, 15, 15, 15, 15, 16, 16, 16, 17, 18, 17, 18, 18, 18, 19, 19, 20, 20, 22, 21,
21, 22, 22, 23, 23, 23, 24, 24, 24, 25, 26, 26, 26, 27, 27, 27, 27, 28, 29, 29,
29, 30, 30, 30, 31, 32, 31, 32, 32, 33, 33, 34, 33, 34, 34, 34, 34, 35, 37, 36,
37, 36, 37, 38, 39, 37, 39, 38, 40, 39, 40, 40, 42, 41, 41, 41, 42, 43, 43, 44,
43, 43, 44, 46, 44, 47, 43, 49, 43, 51, 41, 55, 37, 66, -10, -128, -107, -119,
-109, -111, -105, -104, -102, -100, -99, -95, -95, -91, -90, -87, -87, -82, -83,
-79, -79, -74, -75, -71, -71, -68, -66, -63, -63, -61, -58, -57, -56, -54, -52,
-51, -48, -47, -45, -44, -42, -41, -39, -38, -36, -35, -32, -32, -30, -29, -28,
-26, -24, -23, -22, -21, -20, -18, -18, -17, -14, -14, -13, -12, -10, -9, -9,
-7, -6, -6, -4, -3, -3, -1, -1, };