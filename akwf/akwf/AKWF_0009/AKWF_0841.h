#define DATA_LENGTH 512
#define DATA AKWF_0841

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 3,
2, 3, 3, 4, 3, 5, 5, 6, 7, 7, 8, 8, 9, 9, 10, 11, 13, 13, 14, 15, 17, 17, 18,
19, 20, 20, 22, 24, 24, 26, 27, 28, 30, 31, 32, 34, 35, 36, 37, 39, 40, 43, 43,
45, 46, 48, 49, 51, 53, 54, 55, 57, 59, 61, 62, 63, 64, 66, 68, 69, 70, 72, 73,
75, 77, 78, 80, 80, 83, 83, 85, 86, 88, 89, 91, 92, 93, 95, 96, 96, 98, 99, 100,
102, 103, 104, 105, 106, 107, 107, 109, 109, 110, 111, 112, 112, 113, 114, 115,
115, 116, 116, 117, 117, 117, 117, 118, 117, 119, 119, 119, 118, 119, 119, 119,
118, 119, 119, 118, 118, 118, 117, 117, 117, 116, 115, 114, 114, 112, 112, 111,
110, 108, 107, 105, 104, 103, 102, 100, 98, 97, 95, 94, 92, 90, 87, 86, 83, 81,
79, 77, 75, 73, 70, 68, 66, 64, 62, 60, 57, 54, 53, 51, 48, 45, 44, 42, 40, 37,
35, 33, 31, 29, 27, 25, 23, 21, 20, 18, 15, 14, 13, 12, 11, 8, 8, 7, 6, 5, 4, 3,
3, 2, 2, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, -2, -3, -3, -5, -5, -6,
-8, -8, -10, -11, -12, -15, -16, -17, -20, -22, -24, -26, -28, -30, -33, -35,
-37, -39, -42, -44, -46, -48, -49, -52, -53, -56, -57, -59, -61, -62, -63, -65,
-66, -67, -68, -68, -69, -70, -70, -70, -70, -70, -70, -70, -70, -71, -70, -71,
-71, -70, -70, -71, -71, -70, -69, -69, -70, -70, -70, -69, -69, -69, -70, -69,
-69, -69, -68, -68, -69, -69, -68, -69, -68, -68, -68, -67, -68, -67, -68, -66,
-66, -67, -67, -65, -66, -66, -65, -65, -65, -65, -65, -65, -65, -64, -63, -64,
-63, -63, -62, -62, -62, -61, -61, -62, -61, -60, -60, -60, -59, -59, -59, -59,
-58, -57, -57, -56, -56, -56, -56, -56, -55, -55, -54, -53, -53, -53, -53, -52,
-52, -52, -50, -50, -51, -49, -49, -49, -49, -48, -47, -47, -47, -46, -46, -46,
-45, -45, -43, -44, -43, -43, -42, -41, -41, -41, -40, -40, -39, -40, -39, -38,
-38, -37, -37, -36, -36, -35, -34, -34, -34, -33, -32, -32, -31, -32, -31, -30,
-30, -30, -29, -29, -28, -27, -28, -27, -25, -26, -26, -24, -24, -24, -23, -23,
-23, -22, -22, -21, -21, -20, -20, -20, -19, -19, -18, -18, -17, -16, -17, -15,
-16, -16, -15, -15, -14, -13, -14, -13, -12, -13, -12, -11, -12, -11, -10, -10,
-9, -9, -9, -8, -8, -9, -8, -8, -7, -7, -7, -6, -6, -6, -6, -4, -5, -5, -5, -4,
-4, -3, -3, -3, -3, -3, -3, -2, -3, -2, -1, -2, -2, -2, -1, -2, -1, 0, -1, 0,
-1, -1, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, };