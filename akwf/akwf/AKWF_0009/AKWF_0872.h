#define DATA_LENGTH 512
#define DATA AKWF_0872

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 3, 4, 5, 7, 10, 11, 13, 14, 17,
19, 21, 23, 26, 27, 30, 32, 35, 37, 40, 42, 45, 48, 50, 53, 56, 58, 61, 64, 66,
69, 71, 74, 76, 80, 82, 84, 87, 89, 91, 94, 95, 98, 99, 101, 103, 104, 105, 107,
108, 110, 110, 111, 113, 113, 115, 115, 115, 116, 117, 118, 118, 118, 119, 119,
120, 119, 120, 119, 119, 118, 118, 118, 117, 116, 115, 115, 115, 113, 112, 110,
110, 107, 106, 106, 103, 101, 99, 97, 95, 93, 91, 89, 86, 84, 81, 79, 76, 73,
70, 67, 65, 62, 58, 55, 52, 50, 46, 42, 39, 36, 32, 30, 27, 24, 21, 17, 14, 10,
8, 5, 1, -2, -4, -8, -10, -13, -15, -19, -22, -23, -26, -28, -31, -33, -35, -36,
-38, -40, -42, -43, -44, -46, -46, -48, -49, -49, -50, -51, -52, -53, -53, -53,
-53, -53, -53, -53, -52, -52, -52, -51, -50, -50, -49, -48, -47, -45, -45, -43,
-43, -40, -39, -37, -36, -36, -34, -32, -30, -29, -27, -25, -24, -21, -20, -19,
-16, -14, -12, -11, -9, -7, -6, -3, -2, 0, 1, 3, 4, 7, 7, 9, 11, 13, 13, 15, 16,
17, 19, 19, 21, 21, 22, 24, 24, 25, 25, 25, 27, 27, 27, 27, 27, 28, 27, 28, 27,
27, 26, 26, 25, 24, 23, 22, 21, 20, 18, 17, 16, 14, 13, 11, 9, 8, 6, 3, 1, -1,
-4, -5, -8, -11, -13, -16, -18, -21, -23, -27, -29, -33, -35, -38, -41, -43,
-47, -49, -52, -55, -58, -61, -64, -66, -69, -71, -74, -77, -78, -82, -84, -85,
-88, -90, -92, -93, -95, -96, -98, -100, -100, -102, -103, -103, -103, -103,
-105, -105, -104, -104, -104, -105, -104, -105, -104, -104, -102, -102, -101,
-100, -99, -98, -97, -96, -95, -93, -92, -91, -89, -89, -86, -86, -84, -82, -81,
-79, -78, -76, -74, -72, -71, -69, -67, -65, -63, -62, -59, -57, -56, -53, -52,
-50, -48, -46, -44, -42, -40, -39, -36, -34, -32, -30, -28, -27, -25, -24, -21,
-19, -18, -16, -14, -13, -12, -9, -8, -7, -6, -4, -3, -2, 0, 1, 3, 4, 5, 5, 7,
8, 9, 10, 11, 12, 12, 13, 13, 15, 14, 16, 16, 17, 17, 17, 18, 19, 18, 19, 19,
18, 19, 19, 18, 19, 19, 19, 19, 19, 20, 19, 18, 18, 18, 18, 17, 17, 17, 17, 17,
16, 16, 16, 15, 15, 15, 14, 14, 12, 13, 12, 11, 10, 10, 9, 7, 6, 5, 5, 2, 2, 0,
-1, -4, -5, -7, -8, -9, -10, -12, -12, -13, -15, -15, -16, -17, -17, -19, -17,
-19, -19, -18, -18, -18, -18, -17, -17, -16, -16, -16, -16, -15, -14, -13, -13,
-14, -14, -13, -13, -12, -12, -11, -11, -11, -10, -11, -12, -11, -11, -12, -11,
-11, -11, -11, -11, -11, -12, -11, -11, -11, -10, -11, -11, -11, -10, -10, -9,
-9, -8, -8, -7, -6, -5, -4, -3, -2, -1, };