#define DATA_LENGTH 512
#define DATA AKWF_0846

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 8, 10, 12, 14, 17, 19, 22,
24, 26, 29, 31, 33, 36, 38, 40, 42, 44, 46, 49, 51, 53, 55, 58, 60, 61, 63, 66,
67, 69, 71, 73, 75, 77, 78, 80, 82, 83, 86, 86, 89, 91, 91, 93, 95, 96, 98, 98,
100, 101, 102, 104, 105, 105, 107, 108, 109, 109, 111, 111, 112, 113, 113, 114,
115, 116, 117, 116, 116, 117, 118, 118, 118, 119, 119, 119, 119, 119, 119, 117,
117, 117, 117, 116, 115, 114, 113, 112, 110, 110, 108, 106, 105, 105, 103, 102,
99, 99, 98, 95, 95, 93, 92, 90, 88, 86, 85, 84, 81, 80, 79, 77, 75, 73, 72, 69,
68, 66, 65, 63, 61, 60, 58, 56, 55, 52, 50, 48, 47, 45, 44, 41, 40, 37, 35, 35,
33, 31, 29, 27, 25, 24, 22, 21, 19, 18, 15, 13, 12, 10, 9, 7, 6, 4, 2, 1, -1,
-2, -3, -5, -6, -9, -10, -11, -13, -13, -15, -17, -17, -20, -20, -21, -23, -24,
-26, -26, -27, -29, -29, -31, -32, -33, -33, -35, -36, -37, -38, -39, -39, -40,
-40, -41, -43, -43, -43, -44, -45, -45, -45, -46, -46, -48, -47, -48, -48, -48,
-49, -49, -50, -49, -50, -51, -51, -50, -50, -50, -50, -49, -49, -48, -48, -47,
-46, -46, -45, -44, -44, -42, -42, -41, -40, -40, -38, -36, -36, -35, -33, -33,
-32, -31, -29, -29, -28, -26, -25, -24, -23, -22, -21, -20, -19, -17, -17, -16,
-14, -13, -13, -11, -11, -9, -9, -8, -7, -5, -5, -4, -2, -2, -1, 0, 1, 1, 2, 3,
5, 5, 6, 6, 8, 8, 9, 10, 9, 10, 11, 12, 11, 13, 12, 14, 14, 14, 14, 14, 15, 15,
15, 16, 16, 16, 16, 16, 17, 16, 17, 16, 16, 15, 15, 15, 14, 14, 13, 13, 12, 12,
11, 10, 9, 9, 8, 8, 7, 7, 6, 5, 4, 4, 2, 2, 2, 1, 0, -2, -2, -3, -3, -4, -6, -6,
-7, -8, -9, -10, -11, -12, -13, -13, -14, -15, -16, -16, -18, -19, -19, -20,
-22, -22, -23, -25, -25, -26, -28, -28, -30, -29, -31, -32, -32, -34, -35, -35,
-37, -37, -38, -39, -40, -41, -42, -42, -43, -44, -45, -46, -48, -48, -48, -50,
-50, -52, -52, -52, -54, -55, -56, -57, -58, -57, -59, -59, -61, -61, -62, -62,
-64, -65, -65, -65, -66, -67, -68, -68, -69, -70, -70, -71, -71, -72, -72, -73,
-74, -74, -75, -76, -76, -76, -77, -77, -79, -78, -79, -80, -80, -81, -81, -81,
-82, -81, -82, -83, -83, -83, -84, -83, -84, -84, -85, -85, -85, -86, -85, -86,
-87, -86, -87, -86, -86, -86, -86, -86, -87, -86, -87, -86, -86, -87, -85, -84,
-84, -82, -81, -80, -78, -77, -74, -74, -73, -70, -68, -68, -65, -63, -61, -60,
-58, -55, -54, -51, -48, -47, -44, -43, -40, -39, -36, -34, -32, -29, -28, -24,
-22, -20, -17, -16, -13, -11, -8, -6, -4, -1, };