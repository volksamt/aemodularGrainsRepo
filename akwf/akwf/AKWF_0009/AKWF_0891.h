#define DATA_LENGTH 512
#define DATA AKWF_0891

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 7, 8, 9, 10, 11, 13, 13, 14,
14, 14, 15, 14, 15, 14, 23, 29, 31, 34, 37, 41, 44, 49, 53, 59, 63, 69, 76, 83,
89, 96, 103, 112, 118, 105, 104, 107, 109, 111, 112, 112, 112, 111, 109, 107,
103, 100, 97, 93, 88, 85, 79, 78, 82, 80, 79, 76, 75, 73, 71, 72, 71, 69, 70,
70, 70, 71, 71, 71, 72, 72, 73, 72, 72, 71, 71, 70, 70, 69, 68, 67, 65, 63, 61,
59, 57, 54, 53, 49, 47, 43, 41, 38, 35, 32, 28, 25, 22, 18, 16, 12, 9, 6, 4, 2,
-2, -4, -7, -9, -11, -13, -14, -16, -16, -18, -18, -20, -20, -20, -21, -21, -21,
-21, -20, -20, -19, -19, -18, -16, -15, -15, -13, -12, -12, -11, -8, -7, -6, -4,
-3, -2, -1, 0, 2, 4, 3, 6, 6, 7, 7, 8, 9, 9, 9, 10, 10, 10, 10, 10, 11, 10, 10,
9, 10, 9, 8, 7, 8, 6, 6, 5, 4, 3, 3, 2, 2, 1, 0, -1, -2, -3, -3, -4, -5, -5, -6,
-5, -7, -6, -6, -7, -7, -8, -7, -8, -8, -8, -8, -8, -8, -8, -8, -8, -8, -7, -6,
-7, -6, -5, -5, -5, -4, -3, -4, -3, -3, -2, -2, -1, -1, -1, 0, 0, 0, 1, 1, 1, 1,
1, 1, 1, 1, 2, 1, 1, 2, 2, 2, 1, 1, 2, 1, 1, 1, 0, 0, 1, 0, 0, 0, -1, -1, -1,
-1, 0, -1, -2, -2, -2, -2, -3, -3, -3, -3, -3, -3, -3, -4, -3, -4, -4, -3, -4,
-3, -4, -3, -3, -3, -4, -3, -3, -3, -4, -4, -3, -3, -2, -2, -2, -2, -2, -2, -2,
-2, -2, -2, -2, -1, -1, -1, -1, -1, -1, 0, 0, -1, -1, -1, -1, -1, 0, 0, 0, -1,
-1, -1, 0, 0, -1, -1, -1, 0, -1, -1, -1, -1, -1, -1, -1, -1, -2, -2, -2, -1, -2,
-2, -2, -1, -2, -2, -2, -2, -1, -3, -2, -2, -3, -2, -1, -2, -2, -2, -2, -2, -1,
-2, -2, -2, -2, -3, -2, -2, -2, -2, -3, -2, -2, -2, -2, -1, -1, -2, -2, -1, -2,
-1, -2, -1, -1, -2, -1, -1, -1, -2, -1, -1, -1, -1, -1, -2, -1, -1, -2, -1, -2,
-1, -2, -2, -1, -2, -2, -1, -1, -2, -2, -2, -2, -1, -1, -2, -1, -2, -2, -2, -1,
-2, -2, -1, -1, -6, -14, -17, -21, -23, -26, -30, -34, -40, -44, -50, -56, -62,
-69, -76, -83, -91, -98, -107, -100, -95, -98, -101, -104, -106, -107, -107,
-107, -105, -105, -101, -100, -96, -93, -89, -85, -81, -78, -81, -81, -78, -77,
-74, -73, -71, -69, -69, -68, -67, -67, -67, -67, -66, -65, -66, -65, -65, -64,
-64, -63, -63, -62, -60, -59, -59, -57, -55, -54, -52, -50, -48, -47, -44, -42,
-40, -36, -33, -31, -29, -26, -23, -21, -18, -16, -13, -12, -9, -6, -3, -1, 0,
};