#define DATA_LENGTH 512
#define DATA AKWF_0825

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 6, 9, 11, 14, 17, 20, 22, 25,
28, 32, 34, 37, 40, 44, 46, 49, 52, 56, 57, 61, 64, 66, 68, 71, 74, 76, 79, 81,
83, 85, 86, 88, 91, 93, 95, 96, 98, 100, 101, 103, 104, 105, 106, 108, 108, 110,
110, 111, 112, 114, 114, 115, 115, 115, 115, 116, 116, 117, 118, 118, 118, 119,
118, 119, 118, 119, 119, 119, 119, 119, 120, 119, 119, 119, 118, 118, 117, 118,
118, 118, 117, 116, 116, 116, 115, 115, 115, 115, 114, 113, 114, 112, 113, 112,
112, 111, 110, 110, 110, 108, 109, 108, 107, 106, 107, 106, 106, 105, 105, 105,
105, 105, 104, 105, 105, 104, 104, 104, 104, 105, 104, 104, 104, 102, 100, 98,
97, 95, 95, 93, 92, 91, 90, 88, 86, 85, 82, 80, 78, 75, 74, 71, 69, 67, 65, 62,
61, 58, 56, 53, 52, 49, 48, 46, 44, 42, 40, 38, 36, 34, 33, 30, 28, 26, 25, 22,
19, 17, 15, 12, 9, 9, 6, 3, 1, -1, -4, -6, -8, -10, -13, -16, -17, -19, -22,
-24, -26, -28, -29, -32, -33, -36, -38, -39, -41, -43, -45, -47, -48, -50, -53,
-52, -54, -56, -57, -59, -60, -62, -63, -64, -65, -66, -67, -68, -69, -71, -72,
-73, -72, -74, -75, -74, -76, -76, -77, -77, -77, -77, -78, -78, -78, -78, -78,
-77, -77, -77, -76, -74, -74, -74, -73, -72, -70, -69, -69, -67, -66, -65, -64,
-62, -62, -61, -59, -58, -57, -56, -56, -55, -54, -52, -52, -50, -49, -49, -47,
-47, -45, -45, -45, -43, -41, -41, -41, -40, -39, -38, -38, -38, -36, -35, -35,
-35, -34, -33, -33, -33, -33, -32, -32, -31, -32, -31, -32, -32, -32, -32, -33,
-33, -34, -33, -34, -34, -34, -35, -35, -36, -35, -36, -36, -38, -37, -37, -38,
-38, -39, -39, -38, -39, -40, -41, -40, -42, -41, -41, -42, -42, -42, -43, -42,
-43, -42, -43, -44, -44, -45, -45, -45, -45, -45, -45, -45, -45, -45, -45, -45,
-46, -45, -46, -46, -46, -45, -45, -46, -46, -45, -45, -45, -45, -45, -44, -44,
-45, -43, -44, -43, -43, -44, -43, -42, -43, -42, -42, -42, -42, -42, -42, -42,
-41, -42, -41, -41, -41, -41, -40, -40, -40, -40, -40, -40, -40, -39, -39, -39,
-39, -38, -38, -38, -38, -38, -38, -37, -36, -37, -37, -36, -35, -35, -34, -34,
-35, -33, -34, -33, -33, -32, -32, -31, -32, -31, -31, -32, -32, -32, -31, -33,
-34, -34, -35, -34, -35, -36, -36, -36, -37, -37, -38, -39, -39, -41, -40, -41,
-41, -42, -43, -43, -44, -44, -45, -46, -46, -47, -47, -47, -47, -48, -48, -49,
-49, -50, -50, -50, -50, -51, -50, -50, -50, -50, -51, -50, -49, -49, -50, -50,
-50, -49, -48, -47, -47, -47, -46, -46, -46, -44, -43, -43, -41, -42, -40, -40,
-38, -37, -36, -33, -32, -31, -29, -27, -25, -24, -23, -20, -19, -17, -16, -14,
-12, -9, -6, -3, 1, };