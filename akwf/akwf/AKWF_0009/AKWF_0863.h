#define DATA_LENGTH 512
#define DATA AKWF_0863

const PROGMEM int8_t DATA[DATA_LENGTH] = {103, 118, 104, 107, 96, 96, 87, 87,
78, 78, 70, 68, 62, 60, 54, 52, 48, 45, 40, 38, 34, 31, 28, 24, 21, 18, 15, 13,
11, 7, 5, 3, 1, -2, -5, -6, -8, -11, -12, -14, -15, -16, -18, -20, -21, -21,
-22, -24, -24, -25, -26, -26, -26, -26, -27, -28, -28, -28, -29, -28, -28, -27,
-27, -27, -25, -25, -24, -25, -24, -23, -22, -21, -20, -18, -18, -16, -16, -14,
-13, -12, -9, -8, -6, -5, -4, -1, -1, 2, 3, 5, 7, 9, 11, 13, 14, 17, 18, 21, 22,
25, 26, 29, 31, 33, 36, 37, 40, 40, 44, 45, 48, 48, 52, 52, 57, 56, 62, 59, 66,
63, 71, 66, 75, 69, 79, 74, 83, 76, -107, -119, -104, -108, -95, -98, -86, -89,
-78, -79, -70, -71, -62, -62, -54, -54, -47, -46, -40, -39, -34, -31, -27, -24,
-21, -19, -16, -12, -11, -8, -6, -2, -1, 2, 3, 5, 8, 10, 11, 14, 14, 16, 18, 19,
20, 22, 22, 22, 23, 25, 25, 26, 27, 27, 26, 26, 28, 27, 27, 27, 28, 27, 26, 26,
25, 25, 24, 24, 23, 22, 21, 21, 20, 18, 18, 17, 14, 14, 12, 11, 9, 8, 7, 4, 3,
2, 0, -2, -3, -6, -7, -10, -10, -13, -15, -17, -18, -21, -22, -25, -26, -29,
-31, -34, -35, -37, -39, -41, -43, -45, -48, -49, -52, -52, -58, -55, -61, -59,
-66, -62, -71, -65, -75, -69, -80, -72, -85, -67, 115, 116, 106, 107, 96, 98,
88, 89, 79, 80, 71, 71, 62, 62, 55, 54, 49, 46, 41, 39, 35, 32, 28, 26, 23, 19,
17, 14, 11, 8, 7, 3, 2, 0, -3, -6, -7, -9, -10, -12, -14, -16, -16, -18, -19,
-21, -20, -22, -23, -24, -24, -24, -25, -25, -25, -26, -27, -26, -27, -26, -26,
-25, -25, -25, -25, -23, -23, -22, -22, -20, -20, -19, -18, -17, -17, -15, -13,
-12, -11, -10, -8, -7, -5, -4, -1, -1, 2, 4, 6, 6, 9, 11, 13, 14, 15, 18, 20,
22, 24, 26, 27, 31, 32, 35, 36, 39, 39, 44, 44, 48, 49, 53, 52, 55, 57, 60, 61,
64, 66, 66, 71, 68, 79, 65, 96, -40, -128, -103, -117, -99, -103, -91, -93, -84,
-82, -75, -72, -67, -63, -60, -56, -53, -47, -45, -41, -38, -33, -31, -26, -24,
-20, -18, -14, -13, -8, -7, -4, -2, 2, 4, 6, 8, 9, 12, 13, 14, 17, 19, 20, 21,
22, 24, 25, 25, 26, 27, 28, 29, 29, 30, 30, 31, 31, 31, 31, 31, 30, 30, 30, 30,
29, 29, 28, 28, 27, 25, 24, 24, 23, 22, 21, 20, 19, 18, 17, 15, 13, 12, 10, 9,
8, 6, 4, 2, 1, -2, -3, -6, -6, -9, -11, -13, -14, -17, -18, -21, -23, -25, -27,
-30, -31, -34, -36, -38, -40, -41, -44, -46, -49, -50, -52, -55, -57, -58, -61,
-62, -66, -66, -70, -68, -74, -72, -79, -75, -86, -69, };