#define DATA_LENGTH 512
#define DATA AKWF_0839

const PROGMEM int8_t DATA[DATA_LENGTH] = {105, 125, 116, 122, 116, 121, 117,
121, 117, 120, 117, 121, 118, 121, 118, 119, 119, 120, 118, 120, 119, 120, 120,
119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 120, 120, 119, 119, 119, 119, 119, 120, 119, 120, 119, 118, 119, 120, 119,
119, 119, 119, 119, 119, 119, 120, 119, 120, 118, 119, 119, 119, 119, 119, 119,
120, 120, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119,
119, 119, 118, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 120, 119, 118,
119, 118, 120, 119, 119, 119, 118, 119, 119, 119, 119, 118, 120, 119, 119, 119,
120, 118, 119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 120, 119, 120, 118,
118, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 118, 119, 119, 118, 119, 118, 119, 119, 120, 119, 120, 118,
120, 118, 120, 118, 121, 118, 121, 117, 121, 117, 120, 118, 120, 119, 118, 120,
116, 124, 111, 127, -22, -96, -65, -85, -70, -82, -73, -79, -74, -79, -75, -78,
-76, -78, -76, -77, -77, -78, -78, -77, -78, -77, -78, -77, -77, -76, -78, -78,
-77, -77, -78, -78, -78, -77, -78, -78, -79, -77, -79, -78, -78, -78, -79, -78,
-78, -78, -78, -78, -78, -78, -79, -78, -79, -79, -78, -78, -78, -76, -77, -77,
-78, -76, -77, -77, -77, -77, -77, -77, -77, -77, -77, -77, -77, -77, -76, -76,
-77, -77, -77, -76, -77, -76, -77, -77, -78, -77, -78, -77, -77, -77, -77, -77,
-77, -77, -77, -77, -77, -76, -76, -77, -77, -76, -77, -77, -77, -76, -77, -77,
-77, -77, -76, -77, -77, -77, -77, -77, -77, -77, -76, -77, -76, -77, -77, -77,
-78, -77, -77, -78, -78, -77, -77, -76, -77, -77, -77, -76, -77, -77, -77, -77,
-77, -76, -77, -77, -77, -77, -77, -77, -77, -76, -77, -77, -77, -77, -77, -77,
-77, -77, -77, -77, -77, -76, -77, -77, -77, -77, -77, -77, -77, -77, -77, -77,
-77, -76, -77, -77, -78, -77, -77, -77, -77, -77, -78, -77, -77, -77, -76, -78,
-77, -77, -76, -76, -77, -76, -77, -77, -77, -78, -77, -77, -77, -76, -77, -76,
-77, -77, -77, -77, -77, -77, -76, -77, -77, -77, -77, -77, -76, -77, -76, -77,
-78, -77, -77, -76, -77, -77, -77, -76, -77, -77, -77, -78, -77, -76, -77, -76,
-78, -76, -77, -77, -77, -76, -77, -76, -78, -77, -77, -76, -77, -76, -77, -76,
-77, -77, -76, -77, -77, -77, -77, -77, -76, -78, -75, -78, -75, -79, -75, -80,
-73, -85, -53, 7, -4, 2, -2, 1, -1, 0, 1, 0, 0, -1, 1, 0, 1, -1, 1, -1, 0, -1,
1, -1, 0, };