#define DATA_LENGTH 512
#define DATA AKWF_0819

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 15, 19, 25, 28, 32, 36, 38, 40,
41, 42, 42, 42, 43, 42, 41, 40, 39, 38, 36, 35, 32, 30, 29, 26, 24, 21, 20, 17,
15, 13, 11, 9, 8, 6, 4, 2, 2, 0, -1, -4, -5, -5, -6, -6, -7, -9, -7, -8, -9,
-10, -9, -10, -10, -10, -9, -9, -8, -8, -8, -8, -8, -7, -7, -7, -7, -5, -5, -5,
-4, -4, -5, -4, -4, -4, -3, -3, -2, -2, -1, 0, -1, 0, 0, 0, 0, -1, 0, 1, 1, 0,
1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1,
0, 0, 0, 0, 1, 0, 0, -1, 0, -1, 0, 0, 1, 1, 0, 0, -1, 1, -12, -67, -106, -114,
-106, -94, -85, -76, -65, -51, -32, -10, 13, 34, 55, 72, 85, 95, 101, 104, 106,
104, 100, 96, 90, 83, 74, 67, 59, 51, 42, 35, 27, 18, 12, 5, -1, -7, -13, -21,
-30, -38, -43, -46, -49, -51, -52, -53, -52, -51, -49, -46, -42, -39, -35, -31,
-26, -22, -19, -15, -13, -9, -6, -5, -1, -10, -40, -56, -55, -48, -38, -32, -25,
-17, -8, 4, 16, 28, 40, 50, 58, 63, 67, 67, 68, 65, 62, 59, 53, 48, 43, 37, 31,
26, 20, 14, 9, 4, -1, -6, -9, -13, -16, -19, -21, -23, -25, -26, -27, -28, -29,
-29, -29, -28, -27, -27, -26, -25, -23, -22, -22, -19, -19, -16, -15, -14, -12,
-11, -9, -8, -6, -5, -4, -3, -1, 0, 1, 2, 3, 3, 3, 4, 5, 5, 6, 6, 7, 8, 7, 7, 7,
6, 7, 7, 7, 7, 7, 6, 7, 5, 6, 5, 6, 5, 5, 5, 4, 4, 3, 3, 3, 2, 2, 3, 1, 2, 2, 1,
2, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, -1, 0, -1, -1, -1, 0, 0, 0, -1,
-1, -1, 0, 0, -1, -1, -1, -1, 0, 0, 0, 0, 0, -1, 0, 0, 28, 72, 90, 87, 77, 68,
60, 51, 41, 28, 11, -8, -26, -43, -57, -69, -77, -83, -86, -86, -86, -82, -78,
-72, -67, -61, -54, -47, -40, -33, -26, -19, -12, -7, -1, 5, 11, 15, 19, 17, 6,
3, 5, 10, 15, 18, 23, 27, 39, 51, 57, 61, 62, 62, 61, 61, 57, 52, 47, 40, 34,
27, 21, 16, 11, 6, 3, -1, -3, -6, -8, -10, -11, -12, -13, -13, -14, -14, -16,
-17, -16, -17, -15, -14, -12, -11, -11, -10, -10, -8, -6, -7, -6, -8, -7, -8,
-9, -9, -9, -10, -10, -11, -10, -10, -8, -6, -4, -2, -2, -1, 1, 1, 3, 3, 5, 4,
5, 4, 3, 1, 1, 1, 38, 96, 118, 115, 102, 91, 80, 70, 57, 41, 19, -5, -29, -50,
-69, -85, -96, -103, -108, -109, -109, -106, -100, -94, -87, -79, -70, -62, -52,
-44, -35, -27, -18, -10, -4, };