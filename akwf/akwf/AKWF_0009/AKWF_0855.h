#define DATA_LENGTH 512
#define DATA AKWF_0855

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 13, 18, 23, 28, 33, 37, 41, 46,
50, 54, 57, 60, 65, 67, 70, 72, 74, 78, 79, 80, 81, 84, 84, 84, 85, 85, 85, 84,
83, 80, 79, 77, 75, 73, 70, 68, 64, 62, 60, 56, 53, 51, 47, 45, 42, 40, 36, 34,
31, 28, 26, 24, 20, 18, 17, 14, 11, 10, 8, 7, 6, 5, 4, 3, 1, 1, 0, 0, -1, -1, 0,
0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 1, 1, 0, 0, -1, 1, 0, 0, -1, 0, 0, 0, 0, -1,
0, 1, 1, 0, 1, 0, 1, 0, 1, 1, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0,
-1, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 1, 0, 1, 0, 1, 0, 1,
0, 0, -1, 0, 0, 0, 1, 0, 1, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 2,
4, 5, 7, 10, 12, 14, 16, 19, 22, 25, 28, 31, 34, 37, 40, 44, 47, 50, 54, 57, 59,
63, 66, 69, 72, 75, 78, 81, 84, 87, 89, 92, 94, 97, 100, 101, 103, 106, 108,
109, 111, 112, 113, 116, 116, 117, 117, 118, 118, 119, 119, 119, 117, 115, 113,
109, 106, 102, 98, 95, 89, 85, 80, 76, 72, 65, 60, 55, 50, 44, 40, 33, 29, 23,
18, 12, 6, 1, -4, -9, -13, -19, -25, -29, -33, -38, -42, -46, -50, -54, -57,
-61, -64, -67, -70, -73, -75, -77, -79, -81, -82, -83, -84, -85, -85, -85, -85,
-84, -82, -80, -80, -78, -74, -72, -70, -68, -65, -62, -59, -56, -53, -50, -47,
-44, -42, -39, -35, -34, -30, -28, -25, -23, -21, -18, -16, -14, -12, -10, -8,
-7, -6, -4, -3, -3, -2, -2, 0, 0, -1, -1, 0, 1, 0, -1, -1, 0, -1, -1, 0, 1, 0,
1, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, -1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, -1, -1, 0,
-1, 0, 0, -1, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1,
-1, 0, 0, -1, -1, 0, -1, 0, 0, 0, -1, -1, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, -3, -3, -5, -7,
-10, -12, -15, -17, -20, -22, -25, -28, -31, -35, -37, -41, -44, -47, -51, -53,
-57, -60, -63, -66, -69, -72, -76, -79, -81, -85, -87, -90, -93, -95, -97, -99,
-102, -103, -106, -108, -110, -111, -113, -114, -115, -116, -117, -118, -118,
-118, -119, -119, -118, -117, -115, -112, -109, -106, -103, -98, -94, -90, -85,
-80, -75, -70, -65, -60, -55, -49, -44, -39, -34, -28, -22, -17, -12, -6, -1, };