#define DATA_LENGTH 512
#define DATA AKWF_0900

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 2, 3, 3, 4, 4, 5, 5, 6, 5, 7,
7, 7, 8, 7, 8, 7, 8, 8, 9, 9, 9, 10, 9, 10, 9, 10, 10, 10, 10, 11, 10, 10, 11,
11, 11, 11, 12, 12, 12, 13, 12, 13, 13, 13, 14, 14, 14, 15, 16, 16, 16, 17, 17,
18, 18, 20, 20, 21, 20, 21, 22, 23, 23, 23, 24, 25, 25, 26, 27, 26, 28, 28, 29,
29, 30, 31, 32, 31, 32, 33, 33, 33, 34, 35, 35, 36, 36, 36, 37, 37, 37, 38, 38,
39, 39, 39, 40, 40, 40, 41, 41, 41, 41, 41, 42, 42, 43, 43, 44, 43, 45, 45, 45,
45, 45, 46, 46, 47, 47, 48, 48, 49, 49, 48, 50, 50, 50, 51, 51, 52, 52, 52, 53,
53, 54, 53, 54, 55, 56, 55, 56, 57, 57, 58, 59, 59, 60, 59, 61, 61, 61, 61, 62,
62, 64, 63, 64, 65, 64, 66, 66, 66, 66, 68, 67, 68, 69, 69, 70, 69, 69, 70, 71,
71, 72, 72, 73, 73, 73, 73, 74, 75, 75, 75, 76, 76, 76, 77, 77, 78, 78, 79, 79,
79, 80, 80, 80, 80, 81, 81, 82, 83, 83, 83, 83, 84, 84, 85, 85, 86, 86, 86, 87,
88, 88, 89, 89, 88, 89, 89, 90, 90, 91, 91, 91, 92, 93, 93, 94, 93, 93, 93, 92,
93, 93, 93, 91, 91, 91, 89, 87, 86, 84, 82, 81, 78, 76, 72, 70, 67, 63, 60, 55,
51, 48, 42, 38, 33, 27, 22, 17, 12, 6, 0, -7, -13, -17, -23, -29, -36, -41, -46,
-52, -57, -62, -67, -71, -77, -82, -85, -90, -93, -96, -100, -102, -105, -108,
-110, -112, -113, -115, -116, -118, -118, -118, -119, -119, -119, -119, -118,
-117, -118, -116, -115, -115, -113, -111, -111, -110, -108, -107, -105, -103,
-103, -101, -100, -98, -97, -95, -94, -91, -90, -89, -87, -85, -85, -83, -81,
-80, -77, -76, -75, -74, -72, -70, -69, -67, -66, -65, -64, -63, -61, -60, -59,
-58, -56, -56, -54, -53, -53, -52, -51, -50, -49, -50, -49, -48, -49, -49, -48,
-48, -48, -48, -49, -48, -49, -49, -50, -50, -51, -52, -52, -54, -54, -56, -56,
-57, -58, -58, -59, -60, -61, -61, -63, -63, -63, -64, -66, -65, -66, -66, -67,
-66, -67, -66, -67, -66, -66, -65, -64, -64, -64, -62, -62, -61, -60, -58, -58,
-57, -55, -54, -53, -50, -49, -48, -46, -45, -44, -43, -41, -38, -38, -36, -34,
-33, -33, -32, -30, -29, -27, -26, -26, -25, -24, -23, -23, -22, -22, -21, -21,
-20, -20, -20, -20, -20, -20, -20, -20, -20, -21, -21, -21, -22, -22, -22, -23,
-22, -24, -23, -24, -24, -25, -25, -25, -25, -24, -25, -25, -25, -25, -26, -25,
-25, -24, -24, -24, -24, -24, -24, -24, -23, -22, -20, -20, -19, -19, -19, -18,
-17, -16, -16, -14, -14, -13, -11, -12, -9, -9, -8, -7, -7, -5, -4, -4, -3, -3,
-2, -1, 0, };