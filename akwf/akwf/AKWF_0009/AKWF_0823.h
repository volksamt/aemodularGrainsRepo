#define DATA_LENGTH 512
#define DATA AKWF_0823

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 6, 10, 11, 13, 15, 18, 20,
22, 25, 27, 30, 32, 35, 38, 40, 44, 46, 48, 51, 54, 57, 59, 62, 65, 67, 70, 73,
76, 78, 81, 83, 85, 88, 90, 92, 95, 97, 99, 100, 102, 104, 105, 106, 108, 108,
110, 111, 113, 114, 114, 115, 116, 116, 118, 117, 117, 118, 118, 119, 119, 119,
118, 119, 119, 119, 119, 119, 119, 119, 118, 117, 117, 117, 116, 117, 116, 115,
115, 113, 113, 112, 112, 112, 111, 111, 110, 109, 108, 108, 107, 106, 106, 105,
104, 104, 103, 102, 101, 100, 99, 97, 97, 96, 96, 95, 93, 92, 91, 90, 89, 88,
86, 86, 84, 82, 82, 81, 78, 77, 75, 74, 72, 70, 68, 67, 65, 64, 62, 60, 57, 56,
53, 52, 50, 48, 46, 44, 42, 40, 38, 37, 34, 32, 29, 27, 26, 24, 21, 19, 17, 16,
14, 12, 10, 8, 5, 4, 2, -1, -2, -5, -6, -7, -9, -12, -13, -14, -16, -19, -19,
-22, -23, -24, -26, -28, -29, -31, -32, -33, -34, -36, -37, -38, -39, -40, -42,
-43, -43, -45, -46, -46, -46, -48, -49, -50, -50, -50, -50, -50, -51, -51, -50,
-50, -49, -50, -48, -48, -47, -47, -46, -45, -44, -44, -42, -42, -40, -40, -37,
-37, -35, -34, -33, -31, -30, -29, -28, -27, -25, -24, -23, -22, -21, -20, -19,
-17, -16, -14, -14, -13, -12, -10, -10, -9, -7, -7, -6, -5, -4, -4, -3, -2, -2,
-1, 0, 1, 1, 1, 2, 2, 3, 4, 5, 5, 5, 6, 7, 7, 8, 8, 9, 9, 9, 10, 11, 11, 12, 13,
13, 14, 15, 15, 15, 15, 16, 16, 17, 16, 16, 17, 17, 16, 16, 16, 15, 15, 14, 15,
14, 13, 13, 12, 11, 10, 9, 8, 8, 8, 6, 4, 4, 3, 2, 1, 0, -2, -2, -4, -4, -6, -7,
-7, -9, -10, -10, -12, -13, -14, -14, -15, -17, -17, -18, -20, -20, -21, -22,
-22, -24, -25, -25, -26, -26, -27, -28, -28, -29, -30, -30, -30, -31, -32, -32,
-33, -33, -33, -34, -35, -35, -36, -37, -37, -37, -38, -37, -38, -38, -39, -39,
-40, -40, -41, -42, -41, -42, -44, -43, -44, -45, -46, -46, -46, -47, -49, -49,
-50, -50, -51, -52, -53, -53, -54, -55, -55, -56, -58, -59, -59, -59, -60, -62,
-62, -63, -63, -63, -65, -66, -66, -66, -67, -69, -69, -70, -70, -71, -71, -72,
-74, -73, -73, -74, -76, -76, -76, -76, -77, -77, -78, -79, -79, -80, -80, -81,
-81, -81, -82, -83, -83, -84, -84, -84, -84, -86, -86, -86, -87, -86, -87, -86,
-86, -87, -87, -87, -86, -87, -86, -84, -85, -84, -83, -83, -82, -81, -80, -78,
-78, -77, -75, -75, -72, -72, -70, -68, -68, -66, -64, -63, -61, -59, -57, -56,
-54, -53, -51, -49, -47, -46, -43, -41, -39, -38, -36, -35, -32, -31, -29, -27,
-25, -22, -21, -19, -16, -16, -13, -11, -9, -6, -5, -3, -2, };