#define DATA_LENGTH 512
#define DATA AKWF_0889

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 19, 24, 28, 33, 37, 42, 50, 55,
62, 69, 76, 82, 88, 94, 99, 104, 108, 111, 114, 116, 118, 119, 119, 119, 118,
117, 115, 113, 112, 108, 106, 102, 98, 94, 90, 86, 82, 78, 74, 70, 65, 61, 56,
52, 48, 43, 39, 35, 31, 26, 22, 18, 13, 9, 4, 1, -5, -8, -11, -15, -17, -19,
-21, -22, -21, -20, -18, -15, -11, -6, -1, 6, 14, 21, 29, 35, 43, 50, 56, 62,
67, 72, 76, 78, 80, 80, 79, 79, 77, 73, 69, 66, 61, 57, 51, 45, 39, 32, 27, 21,
15, 11, 4, 0, -4, -7, -10, -14, -15, -17, -17, -18, -19, -18, -18, -16, -15,
-14, -11, -9, -8, -5, -3, -1, 2, 4, 7, 9, 12, 14, 16, 19, 21, 23, 25, 27, 29,
30, 32, 34, 36, 36, 37, 37, 37, 37, 37, 37, 36, 37, 35, 34, 33, 31, 29, 28, 26,
24, 21, 19, 17, 15, 12, 10, 6, 4, 1, 0, -2, -6, -7, -9, -15, -39, -49, -48, -52,
-52, -55, -57, -61, -63, -65, -66, -69, -70, -70, -70, -69, -69, -67, -66, -65,
-62, -59, -57, -54, -52, -49, -48, -44, -43, -40, -38, -36, -34, -33, -31, -30,
-29, -27, -26, -26, -25, -25, -23, -23, -22, -22, -21, -20, -20, -20, -19, -18,
-17, -17, -16, -16, -16, -15, -15, -15, -15, -15, -15, -15, -14, -15, -14, -13,
-13, -13, -13, -13, -14, -13, -13, -14, -14, -14, -14, -14, -13, -13, -14, -14,
-13, -13, -13, -14, -14, -13, -13, -14, -13, -14, -13, -14, -13, -13, -13, -13,
-14, -13, -13, -13, -13, -13, -14, -14, -13, -13, -13, -13, -13, -13, -13, -13,
-13, -13, -13, -13, -13, -13, -13, -14, -14, -13, -14, -13, -13, -13, -13, -13,
-13, -13, -14, -13, -14, -13, -14, -13, -13, -14, -14, -13, -13, -13, -13, -13,
-14, -13, -13, -13, -13, -14, -14, -14, -13, -13, -13, -13, -13, -13, -13, -13,
-13, -13, -14, -14, -14, -13, -13, -13, -13, -13, -13, -14, -13, -14, -13, -13,
-13, -13, -14, -14, -13, -13, -13, -13, -13, -13, -13, -13, -13, -14, -13, -13,
-13, -13, -13, -13, -14, -14, -13, -13, -13, -13, -12, -13, -13, -13, -13, -13,
-13, -13, -13, -13, -13, -13, -14, -13, -13, -13, -13, -13, -13, -13, -14, -13,
-13, -13, -13, -13, -13, -14, -13, -13, -13, -13, -13, -13, -13, -14, -13, -13,
-13, -13, -13, -12, -13, -13, -12, -14, -13, -13, -13, -12, -13, -13, -13, -12,
-12, -13, -13, -13, -13, -13, -13, -12, -13, -13, -14, -13, -13, -13, -13, -13,
-13, -13, -13, -13, -13, -13, -13, -12, -12, -13, -13, -12, -14, -13, -13, -13,
-13, -14, -14, -13, -13, -12, -13, -13, -13, -13, -13, -12, -14, -13, -13, -13,
-12, -13, -13, -13, -13, -14, -13, -13, -12, -13, -13, -13, -12, -12, -14, -13,
-13, -14, -13, -13, -12, -12, -12, -13, -14, -13, -13, -13, -13, -7, };