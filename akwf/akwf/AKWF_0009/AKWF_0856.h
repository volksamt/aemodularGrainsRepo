#define DATA_LENGTH 512
#define DATA AKWF_0856

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 3, 5, 6, 7, 9, 10, 10, 13,
14, 15, 16, 17, 20, 20, 22, 24, 25, 27, 28, 30, 31, 33, 34, 36, 37, 39, 40, 41,
43, 44, 46, 47, 49, 51, 52, 54, 56, 57, 59, 61, 63, 64, 69, 71, 72, 73, 73, 74,
75, 76, 76, 77, 77, 78, 78, 79, 79, 79, 80, 81, 82, 84, 85, 86, 87, 88, 91, 91,
94, 95, 97, 98, 100, 101, 103, 104, 106, 106, 107, 107, 107, 108, 108, 108, 109,
109, 111, 112, 113, 114, 114, 115, 116, 116, 117, 117, 117, 117, 119, 118, 119,
119, 118, 118, 119, 119, 119, 119, 119, 118, 118, 118, 118, 118, 118, 117, 116,
117, 116, 116, 115, 115, 114, 114, 113, 113, 112, 111, 110, 110, 109, 108, 106,
107, 106, 104, 104, 103, 102, 101, 100, 99, 98, 97, 95, 95, 93, 92, 92, 91, 90,
88, 87, 87, 85, 85, 82, 82, 80, 79, 78, 77, 76, 76, 74, 72, 71, 71, 68, 68, 67,
67, 64, 61, 59, 57, 56, 54, 52, 50, 49, 47, 45, 44, 42, 41, 39, 36, 35, 33, 32,
31, 29, 27, 25, 24, 23, 22, 21, 19, 18, 17, 17, 16, 15, 14, 12, 12, 9, 8, 7, 5,
3, 2, 0, 0, -1, -1, -2, -4, -4, -5, -6, -8, -8, -9, -10, -11, -12, -12, -14,
-14, -16, -16, -18, -18, -20, -22, -25, -28, -29, -30, -31, -33, -33, -34, -34,
-35, -35, -37, -38, -39, -39, -39, -41, -42, -42, -44, -44, -45, -46, -46, -48,
-47, -49, -50, -50, -51, -52, -53, -54, -54, -55, -56, -57, -57, -58, -58, -60,
-61, -62, -62, -63, -63, -64, -64, -66, -67, -68, -67, -68, -68, -69, -69, -68,
-68, -68, -68, -66, -64, -65, -65, -66, -67, -66, -67, -68, -68, -69, -71, -71,
-72, -72, -74, -74, -75, -75, -76, -76, -76, -76, -76, -76, -77, -76, -77, -76,
-75, -75, -74, -74, -73, -73, -73, -73, -74, -74, -74, -74, -74, -75, -75, -73,
-73, -72, -72, -72, -71, -71, -70, -71, -70, -69, -69, -70, -70, -68, -68, -68,
-68, -67, -67, -67, -66, -66, -66, -66, -65, -65, -65, -65, -64, -64, -64, -64,
-64, -64, -63, -63, -63, -63, -63, -62, -63, -63, -62, -63, -61, -62, -61, -62,
-61, -61, -61, -61, -60, -60, -60, -60, -60, -59, -60, -59, -58, -58, -59, -58,
-58, -57, -57, -57, -56, -57, -57, -56, -56, -56, -55, -54, -55, -54, -55, -54,
-54, -53, -54, -52, -51, -53, -55, -55, -55, -55, -56, -56, -56, -56, -57, -58,
-57, -57, -58, -58, -58, -58, -57, -57, -57, -58, -58, -58, -57, -57, -57, -57,
-57, -56, -54, -54, -53, -52, -52, -51, -51, -51, -52, -51, -51, -51, -50, -50,
-50, -48, -47, -46, -45, -45, -44, -43, -41, -41, -40, -39, -38, -37, -35, -33,
-31, -30, -28, -23, -21, -19, -18, -16, -15, -14, -12, -10, -10, -9, -8, -6, -5,
-4, -3, -2, 0, 1, };