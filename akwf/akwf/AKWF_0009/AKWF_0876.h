#define DATA_LENGTH 512
#define DATA AKWF_0876

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 4, 5, 6, 8, 10, 11, 13, 13, 14,
15, 16, 16, 18, 19, 19, 21, 21, 22, 23, 24, 26, 27, 30, 31, 33, 34, 35, 38, 39,
40, 41, 43, 45, 47, 49, 51, 53, 55, 57, 58, 61, 62, 65, 67, 69, 72, 73, 75, 77,
79, 81, 84, 85, 86, 89, 91, 93, 94, 97, 98, 100, 101, 102, 104, 106, 108, 109,
110, 112, 113, 113, 116, 117, 117, 118, 119, 119, 119, 118, 118, 118, 117, 117,
116, 115, 114, 114, 112, 112, 110, 108, 107, 105, 103, 100, 99, 97, 94, 92, 89,
86, 84, 80, 78, 75, 71, 69, 65, 61, 59, 56, 52, 48, 45, 41, 38, 34, 31, 27, 24,
20, 17, 12, 8, 5, 1, -1, -5, -7, -10, -13, -15, -17, -21, -22, -25, -26, -29,
-30, -32, -35, -36, -39, -38, -40, -40, -40, -40, -40, -40, -40, -41, -42, -41,
-41, -42, -41, -41, -41, -40, -39, -39, -38, -38, -37, -36, -35, -34, -34, -33,
-32, -31, -33, -32, -33, -33, -32, -33, -32, -32, -33, -33, -33, -34, -34, -34,
-35, -35, -35, -36, -38, -39, -39, -41, -42, -43, -43, -44, -45, -46, -48, -48,
-50, -51, -52, -53, -54, -55, -56, -56, -59, -59, -60, -60, -60, -60, -59, -60,
-60, -60, -61, -62, -62, -63, -65, -64, -65, -66, -65, -66, -66, -65, -66, -65,
-66, -65, -67, -66, -67, -67, -65, -65, -65, -64, -63, -61, -60, -59, -59, -58,
-58, -57, -56, -57, -56, -55, -54, -54, -53, -52, -51, -50, -49, -48, -47, -46,
-44, -43, -41, -39, -37, -35, -34, -32, -30, -28, -25, -24, -22, -21, -17, -16,
-14, -11, -9, -5, -4, -1, 1, 5, 7, 10, 12, 16, 18, 21, 24, 27, 29, 32, 36, 37,
40, 43, 47, 48, 52, 53, 56, 60, 62, 64, 67, 69, 71, 74, 76, 79, 81, 82, 84, 85,
87, 88, 89, 89, 89, 91, 90, 91, 92, 93, 92, 92, 92, 92, 91, 90, 90, 89, 88, 88,
86, 85, 83, 81, 80, 78, 77, 74, 72, 71, 68, 66, 64, 62, 60, 57, 56, 54, 52, 50,
48, 48, 46, 45, 43, 42, 39, 38, 37, 35, 35, 33, 32, 31, 30, 29, 27, 27, 25, 24,
23, 21, 20, 17, 16, 14, 12, 11, 9, 9, 7, 5, 4, 1, 0, -2, -3, -6, -8, -9, -12,
-14, -16, -19, -21, -22, -25, -27, -29, -31, -33, -35, -38, -41, -42, -43, -46,
-48, -50, -52, -54, -56, -59, -60, -63, -64, -67, -69, -72, -74, -77, -80, -83,
-85, -88, -90, -93, -94, -96, -98, -100, -101, -104, -105, -107, -108, -109,
-112, -113, -113, -114, -114, -114, -115, -114, -113, -114, -113, -112, -111,
-111, -110, -108, -106, -105, -103, -102, -100, -96, -94, -92, -89, -87, -84,
-81, -78, -74, -71, -68, -66, -62, -59, -57, -54, -52, -50, -46, -45, -41, -38,
-36, -33, -30, -28, -26, -23, -21, -18, -16, -15, -12, -10, -8, -6, -5, -3, -2,
0, };