#define DATA_LENGTH 512
#define DATA AKWF_0848

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 125, 115, 122, 116, 121, 116,
121, 117, 121, 118, 121, 118, 120, 119, 120, 118, 120, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119, 118, 119, 119,
119, 120, 119, 119, 119, 119, 119, 119, 119, 120, 119, 120, 119, 119, 119, 119,
119, 120, 120, 120, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 118, 120, 119, 119,
118, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 118, 120, 119, 119, 120, 118, 118, 118, 119, 119, 119, 119, 119, 119, 120,
120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 119,
118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 120,
119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 120, 118, 119, 118, 120, 119, 119, 118, 119, 119, 120, 119, 119, 118,
120, 119, 120, 119, 119, 119, 119, 120, 117, 121, 116, 124, 112, 127, 62, -15,
7, -5, 2, -1, 0, 0, -1, 2, -3, 3, -4, 5, -7, 11, -29, -114, -102, -107, -105,
-105, -107, -105, -106, -104, -106, -104, -106, -104, -106, -105, -106, -106,
-106, -106, -106, -106, -105, -106, -105, -106, -105, -107, -104, -108, -104,
-106, -104, -107, -105, -106, -106, -105, -109, -12, 6, -3, 3, -2, 3, -3, 1, -1,
1, -1, 1, 0, 2, -1, 1, -1, 0, 0, 0, 1, 0, 1, 1, 1, -1, 1, -1, 0, 0, 0, 0, 0, -1,
1, 0, 0, 0, -1, 1, -1, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0,
0, 0, 0, 1, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, -1, 0, 0, 0, 0,
0, 1, 0, -1, 0, 1, 0, -1, 1, 1, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0,
0, -1, 0, 0, 0, 0, 1, 0, 0, -1, -1, -1, 0, 0, 0, 0, 0, 1, -1, 0, 0, -1, 0, 0, 0,
0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, -1, 0, 1, 0,
-1, 1, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, -1, 0, 0, 0, 1,
0, 0, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, -1,
1, 0, 0, 0, 0, 0, -1, 0, 0, 1, 1, 0, 0, 0, 0, 1, 0, 0, };