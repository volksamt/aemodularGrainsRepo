#define DATA_LENGTH 512
#define DATA AKWF_0803

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 15, 29, 41, 53, 64, 74, 82, 90, 96,
102, 107, 110, 113, 116, 117, 118, 118, 118, 117, 116, 113, 111, 109, 106, 102,
99, 96, 92, 88, 84, 80, 75, 71, 68, 63, 58, 54, 49, 46, 41, 37, 32, 28, 25, 20,
16, 12, 9, 7, 3, 0, -4, -7, -9, -12, -14, -17, -19, -21, -24, -25, -27, -30,
-31, -32, -33, -36, -35, -38, -38, -38, -40, -40, -41, -41, -41, -42, -42, -41,
-42, -42, -41, -42, -41, -41, -40, -40, -39, -38, -38, -37, -37, -36, -35, -34,
-33, -33, -31, -31, -30, -29, -27, -27, -26, -25, -23, -22, -22, -21, -20, -19,
-17, -17, -16, -16, -14, -14, -13, -12, -11, -9, -9, -9, -8, -6, -6, -6, -5, -4,
-3, -2, -1, -2, -1, 0, 1, 1, 2, 2, 3, 3, 2, 3, 4, 5, 5, 5, 5, 5, 5, 6, 6, 6, 6,
6, 7, 6, 7, 7, 7, 7, 6, 7, 7, 7, 7, 7, 7, 6, 8, 7, 7, 7, 7, 7, 6, 6, 6, 7, 5, 6,
6, 6, 5, 6, 5, 5, 5, 4, 4, 4, 4, 4, 4, 4, 3, 3, 3, 3, 4, 3, 3, 2, 2, 3, 2, 3, 2,
2, 2, 2, 1, 1, 2, 2, 1, 0, 1, 0, 1, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, -1, 0, -1,
0, -2, -1, -1, -2, -2, -2, -1, -1, -2, -2, -2, -2, -2, -2, -1, -1, -2, -1, 0,
-1, 0, 1, 0, 1, 1, 1, 1, 1, 2, 2, 2, 2, 3, 3, 2, 2, 2, 3, 3, 2, 3, 3, 3, 2, 2,
2, 3, 3, 3, 3, 3, 2, 3, 3, 2, 2, 2, 2, 2, 1, 1, 1, 2, 1, 2, 1, 1, 1, 1, 1, 1, 2,
1, 0, 1, 1, 0, 0, 1, 0, -1, 0, -1, 0, 0, -1, 0, 0, -1, -1, -1, -1, -1, -1, -1,
-1, -1, -1, -1, -1, 0, 0, -1, -1, -1, -1, -2, -1, -1, -2, -1, -2, -1, -1, -2,
-1, -2, -1, -1, -1, -1, -1, -1, -2, -2, -2, -1, -1, -2, 0, -1, -1, -1, -2, -1,
-1, 0, -1, 0, -2, -1, 0, -1, -2, 0, 0, 0, -1, 0, 0, -1, -1, -1, -1, 0, -1, 0, 0,
0, -1, 0, -1, -1, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, -1, 0, 1, -1, 1, 0,
0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 1, 0, 0,
0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0, -1, 1, 0, 0, -3, -17, -47, -73, -87, -90,
-92, -97, -102, -108, -111, -114, -117, -119, -118, -115, -107, -99, -86, -72,
-58, -43, -27, -12, };