#define DATA_LENGTH 512
#define DATA AKWF_0810

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 11, 14, 16, 17, 16, 14, 12, 10,
9, 10, 11, 12, 13, 14, 13, 14, 14, 14, 15, 14, 15, 16, 18, 24, 30, 39, 49, 61,
72, 83, 93, 102, 109, 115, 117, 119, 116, 113, 109, 104, 98, 93, 88, 82, 73, 65,
56, 46, 35, 25, 13, 1, -11, -22, -32, -40, -45, -48, -47, -48, -45, -44, -44,
-43, -43, -43, -45, -48, -52, -58, -63, -67, -70, -73, -74, -75, -76, -76, -78,
-78, -79, -80, -79, -79, -80, -78, -76, -69, -62, -52, -39, -25, -12, 0, 12, 23,
34, 41, 48, 51, 53, 52, 52, 51, 49, 48, 47, 45, 41, 37, 32, 26, 21, 14, 6, -1,
-8, -15, -20, -24, -24, -24, -19, -14, -9, -5, 0, 5, 9, 12, 13, 13, 11, 9, 6, 4,
3, 3, 3, 4, 5, 5, 4, 4, 4, 4, 4, 4, 3, 4, 6, 10, 17, 26, 36, 47, 58, 69, 78, 86,
93, 98, 101, 101, 100, 95, 91, 85, 80, 75, 69, 62, 54, 47, 37, 27, 16, 4, -7,
-19, -31, -44, -53, -61, -66, -68, -69, -68, -67, -65, -64, -63, -64, -64, -65,
-70, -73, -78, -84, -87, -91, -93, -93, -93, -94, -95, -97, -97, -98, -97, -97,
-97, -96, -94, -92, -86, -77, -66, -54, -40, -27, -14, -1, 10, 21, 30, 35, 40,
41, 41, 41, 40, 39, 38, 38, 37, 34, 29, 25, 20, 13, 8, 1, -6, -13, -19, -24,
-26, -27, -24, -20, -15, -9, -4, 2, 8, 11, 14, 16, 16, 15, 13, 12, 10, 9, 10,
11, 11, 12, 13, 14, 14, 14, 15, 14, 14, 15, 16, 19, 24, 32, 40, 51, 63, 74, 85,
94, 103, 110, 115, 118, 119, 117, 114, 108, 104, 98, 93, 88, 82, 74, 66, 57, 46,
35, 25, 13, 1, -11, -22, -32, -40, -44, -47, -47, -46, -45, -44, -43, -42, -42,
-42, -44, -48, -51, -56, -63, -67, -69, -72, -73, -73, -74, -75, -76, -78, -77,
-78, -79, -78, -78, -76, -73, -67, -59, -49, -35, -23, -10, 3, 15, 26, 36, 45,
50, 54, 55, 56, 53, 52, 51, 49, 47, 46, 42, 38, 34, 28, 21, 15, 8, 1, -7, -14,
-19, -22, -22, -21, -17, -12, -7, -2, 3, 7, 11, 14, 15, 15, 13, 11, 8, 5, 5, 5,
6, 6, 7, 6, 6, 6, 6, 6, 5, 5, 6, 6, 8, 12, 20, 29, 39, 50, 62, 72, 81, 90, 96,
101, 103, 104, 102, 96, 91, 86, 81, 75, 69, 63, 55, 47, 37, 27, 16, 5, -7, -19,
-32, -42, -52, -59, -64, -67, -67, -67, -65, -64, -63, -62, -62, -63, -65, -68,
-73, -78, -82, -87, -89, -91, -93, -93, -94, -95, -95, -96, -96, -96, -95, -97,
-95, -94, -89, -84, -74, -64, -51, -38, -25, -11, 1, 13, 23, 31, 37, 41, 43, 43,
41, 41, 40, 39, 39, 37, 33, 30, 25, 19, 14, 8, 1, -6, -13, -19, -24, -27, -26,
-23, -19, -14, -8, -2, };