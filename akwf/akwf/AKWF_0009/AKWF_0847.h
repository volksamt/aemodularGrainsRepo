#define DATA_LENGTH 512
#define DATA AKWF_0847

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 116, 122, 117, 122, 117,
121, 117, 120, 118, 120, 118, 119, 118, 120, 118, 120, 119, 119, 119, 119, 119,
119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119,
119, 119, 118, 119, 119, 120, 118, 120, 118, 119, 118, 120, 118, 120, 118, 121,
117, 121, 118, 121, 117, 121, 118, 121, 117, 8, -4, 4, -3, 3, -2, 1, -2, 1, -1,
2, -1, 1, -1, 1, 0, 0, 0, 0, -1, 0, 1, 1, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0,
0, -1, 1, 0, -1, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0,
0, 0, 0, 1, 0, -1, -1, 0, 0, 0, 0, 0, 0, 1, -1, 1, -1, -1, 0, 0, -1, 0, -1, 0,
0, 1, -1, 1, -1, 0, 0, 0, 1, 0, 1, -2, 6, -36, -54, -48, -53, -48, -51, -49,
-52, -50, -51, -50, -51, -50, -50, -50, -50, -51, -50, -51, -51, -51, -50, -50,
-49, -51, -50, -51, -49, -50, -50, -51, -50, -51, -50, -50, -50, -50, -52, -47,
-56, -19, 5, -3, 2, -1, 1, -1, 1, 0, 0, -1, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0,
0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0,
0, 1, 0, 0, 0, 1, 0, 1, 0, 1, -1, 1, 16, 17, 17, 17, 16, 16, 16, 17, 17, 17, 17,
16, 16, 17, 17, 17, 17, 16, 17, 16, 17, 16, 16, 16, 16, 16, 16, 17, 2, -1, 0, 0,
0, 0, 0, 0, 1, -1, 1, -1, 1, -1, 0, -1, 1, -1, 1, -1, 1, 0, 0, 0, -1, 2, -3, 6,
-67, -94, -82, -90, -84, -89, -85, -89, -85, -88, -86, -87, -86, -87, -86, -86,
-87, -86, -87, -87, -87, -86, -87, -86, -87, -86, -86, -86, -87, -87, -87, -86,
-87, -87, -86, -87, -87, -86, -86, -87, -87, -86, -87, -86, -86, -87, -86, -87,
-86, -87, -87, -87, -87, -87, -87, -87, -87, -88, -86, -86, -86, -87, -86, -87,
-87, -87, -87, -87, -86, -87, -86, -86, -87, -86, -87, -87, -86, -87, -86, -87,
-87, -87, -86, -87, -87, -87, -87, -87, -87, -87, -86, -87, -87, -87, -86, -87,
-86, -87, -86, -86, -86, -87, -87, -87, -86, -86, -87, -87, -86, -87, -88, -86,
-87, -86, -87, -86, -87, -86, -87, -86, -87, -87, -87, -87, -86, -87, -86, -87,
-84, -90, -81, -98, -38, 10, -6, 4, -3, 2, -2, 1, -1, 1, -1, 0, 0, 0, 1, 0, 0,
-1, 0, -1, -1, 0, 0, -1, 1, 0, 0, -1, 0, -1, 0, -1, 1, -1, 0, -1, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, };