#define DATA_LENGTH 512
#define DATA AKWF_0873

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 14, 16, 19, 22, 26, 29,
33, 36, 39, 42, 45, 49, 52, 56, 58, 62, 65, 68, 70, 73, 76, 79, 83, 85, 87, 90,
93, 96, 97, 100, 102, 105, 106, 108, 109, 111, 112, 114, 115, 116, 117, 118,
117, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 117, 117, 117,
116, 115, 115, 114, 113, 113, 113, 111, 110, 109, 108, 107, 107, 106, 105, 103,
102, 101, 101, 99, 97, 96, 94, 92, 91, 89, 87, 85, 83, 81, 78, 77, 74, 72, 69,
67, 64, 61, 58, 55, 52, 49, 46, 42, 40, 36, 33, 30, 26, 22, 18, 16, 12, 10, 5,
1, -1, -4, -8, -11, -13, -17, -20, -23, -25, -29, -30, -32, -35, -38, -40, -42,
-44, -46, -46, -48, -50, -51, -52, -53, -54, -54, -55, -55, -56, -57, -57, -56,
-56, -56, -55, -54, -54, -53, -52, -52, -51, -49, -49, -47, -47, -45, -43, -41,
-41, -39, -37, -35, -34, -32, -30, -29, -27, -26, -23, -21, -20, -19, -17, -16,
-15, -13, -12, -10, -8, -8, -6, -6, -4, -3, -3, -2, -2, -2, -1, -1, -2, -2, -1,
-2, -2, -2, -3, -4, -5, -6, -7, -8, -9, -10, -12, -14, -15, -17, -18, -20, -22,
-24, -26, -28, -30, -32, -35, -37, -39, -41, -45, -46, -48, -51, -53, -56, -58,
-60, -62, -64, -66, -68, -70, -70, -72, -74, -75, -77, -77, -79, -80, -81, -82,
-83, -84, -84, -84, -85, -85, -86, -87, -86, -87, -87, -87, -87, -87, -86, -86,
-85, -86, -84, -84, -83, -82, -82, -82, -80, -79, -78, -77, -76, -74, -72, -71,
-70, -68, -67, -65, -62, -61, -59, -58, -56, -54, -52, -50, -48, -46, -44, -41,
-39, -38, -35, -34, -31, -29, -26, -25, -23, -20, -17, -16, -14, -12, -10, -9,
-7, -4, -2, 0, 1, 3, 5, 6, 8, 11, 11, 13, 15, 17, 17, 19, 19, 21, 22, 24, 25,
25, 25, 27, 27, 28, 29, 28, 30, 30, 30, 31, 31, 31, 32, 32, 33, 32, 33, 32, 32,
32, 31, 32, 31, 30, 31, 29, 30, 29, 29, 29, 27, 27, 27, 26, 26, 25, 24, 23, 24,
22, 21, 21, 21, 21, 19, 18, 18, 18, 16, 16, 16, 15, 14, 14, 13, 12, 13, 12, 12,
11, 10, 9, 9, 8, 8, 8, 8, 7, 7, 6, 7, 7, 6, 6, 6, 5, 4, 4, 5, 4, 4, 3, 4, 3, 4,
2, 2, 1, 2, 2, 1, 1, 0, 1, 0, -2, -1, -3, -2, -3, -5, -5, -6, -8, -8, -9, -10,
-13, -13, -15, -16, -18, -20, -21, -23, -25, -27, -28, -30, -32, -33, -36, -37,
-39, -40, -42, -43, -44, -45, -47, -48, -50, -50, -51, -53, -53, -54, -55, -56,
-55, -56, -56, -56, -55, -56, -56, -54, -55, -53, -53, -52, -50, -49, -49, -48,
-47, -44, -43, -40, -39, -37, -35, -33, -30, -29, -26, -24, -21, -18, -15, -14,
-10, -7, -4, -2, };