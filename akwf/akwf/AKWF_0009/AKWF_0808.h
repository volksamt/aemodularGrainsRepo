#define DATA_LENGTH 512
#define DATA AKWF_0808

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 4, 4, 6, 7, 8, 10, 11, 12,
14, 16, 17, 18, 20, 21, 23, 26, 29, 31, 33, 35, 37, 39, 40, 42, 43, 44, 46, 47,
49, 50, 51, 51, 52, 53, 53, 53, 53, 54, 53, 52, 52, 51, 51, 51, 51, 50, 49, 49,
47, 47, 46, 45, 44, 45, 50, 59, 68, 76, 82, 85, 86, 84, 81, 79, 74, 70, 66, 62,
59, 54, 49, 45, 39, 34, 27, 21, 15, 7, 0, -6, -13, -19, -25, -31, -36, -42, -45,
-50, -53, -57, -60, -62, -65, -67, -68, -69, -71, -72, -71, -72, -72, -72, -71,
-70, -70, -69, -68, -66, -64, -63, -60, -56, -53, -49, -45, -40, -37, -33, -28,
-24, -20, -16, -13, -10, -7, -4, -2, 0, 3, 4, 5, 6, 6, 7, 7, 7, 7, 6, 5, 5, 5,
3, 3, 2, 0, -1, -2, -4, -4, -6, -7, -8, -9, -10, -12, -12, -13, -14, -16, -16,
-17, -18, -19, -20, -20, -20, -22, -22, -22, -22, -19, -16, -15, -13, -12, -11,
-10, -9, -9, -9, -10, -11, -11, -12, -13, -15, -15, -16, -18, -18, -19, -20,
-20, -21, -21, -21, -20, -21, -21, -21, -20, -19, -19, -17, -17, -15, -14, -13,
-11, -9, -9, -7, -6, -4, -2, -1, 1, 3, 6, 7, 9, 11, 14, 15, 17, 19, 20, 22, 23,
25, 28, 29, 30, 32, 34, 36, 37, 38, 39, 41, 42, 42, 43, 45, 47, 50, 51, 55, 56,
58, 60, 60, 62, 63, 64, 64, 62, 63, 62, 61, 60, 58, 56, 55, 53, 50, 48, 46, 42,
40, 38, 36, 32, 29, 27, 25, 22, 19, 15, 13, 10, 8, 7, 5, 5, 4, 4, 3, 3, 4, 4, 3,
4, 5, 5, 4, 5, 4, 4, 4, 3, 2, 1, 0, 0, -1, -2, -3, -4, -6, -7, -8, -10, -11,
-12, -14, -14, -17, -21, -29, -38, -49, -60, -70, -79, -87, -95, -100, -106,
-111, -113, -117, -119, -119, -118, -118, -117, -114, -111, -108, -104, -99,
-93, -85, -79, -70, -63, -53, -46, -37, -30, -21, -14, -7, 0, 6, 11, 17, 22, 27,
30, 35, 38, 41, 43, 45, 47, 49, 50, 51, 52, 53, 53, 53, 53, 52, 53, 52, 51, 50,
49, 49, 48, 46, 45, 43, 42, 41, 40, 41, 41, 42, 42, 44, 46, 47, 47, 48, 49, 49,
49, 49, 50, 49, 48, 47, 48, 46, 45, 43, 42, 39, 37, 36, 33, 32, 28, 27, 24, 21,
19, 16, 14, 11, 7, 5, 2, -1, -4, -6, -9, -11, -14, -16, -20, -22, -24, -26, -28,
-31, -33, -35, -37, -39, -42, -45, -49, -51, -56, -59, -62, -64, -68, -69, -71,
-71, -73, -74, -74, -73, -73, -73, -71, -70, -69, -66, -64, -63, -60, -58, -55,
-52, -49, -46, -44, -41, -38, -35, -32, -28, -26, -22, -19, -16, -14, -10, -8,
-7, -5, -4, -4, -4, -3, -4, -4, -4, -4, -4, -4, -5, -4, -4, -4, -3, -3, -3, -1,
-1, 0, };