#define DATA_LENGTH 512
#define DATA AKWF_0822

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 7, 9, 11, 13, 16, 18, 20, 22,
24, 25, 27, 29, 30, 31, 33, 34, 35, 36, 37, 37, 39, 39, 40, 40, 40, 42, 43, 42,
44, 45, 45, 46, 47, 47, 48, 49, 51, 52, 52, 53, 54, 55, 57, 57, 58, 59, 60, 61,
62, 62, 63, 65, 66, 66, 68, 69, 69, 70, 71, 72, 73, 73, 75, 76, 78, 78, 79, 80,
81, 82, 83, 85, 86, 86, 87, 87, 88, 89, 90, 91, 92, 93, 93, 93, 95, 96, 96, 96,
96, 97, 98, 98, 99, 100, 99, 101, 101, 101, 103, 103, 103, 104, 104, 105, 106,
105, 105, 107, 107, 107, 107, 108, 108, 109, 108, 108, 107, 108, 107, 106, 106,
106, 105, 104, 103, 101, 101, 99, 98, 96, 96, 94, 92, 90, 89, 85, 84, 82, 79,
77, 74, 72, 70, 67, 63, 60, 58, 55, 52, 48, 46, 42, 40, 37, 34, 31, 28, 25, 22,
20, 17, 15, 13, 10, 8, 5, 3, 1, -1, -3, -5, -7, -9, -11, -12, -14, -16, -19,
-20, -22, -24, -26, -28, -29, -31, -33, -33, -36, -36, -37, -39, -40, -41, -42,
-44, -44, -45, -46, -47, -48, -49, -49, -50, -52, -53, -54, -54, -55, -57, -57,
-58, -58, -58, -59, -59, -60, -60, -61, -61, -60, -61, -61, -60, -60, -59, -59,
-58, -57, -57, -55, -53, -53, -51, -50, -48, -46, -45, -43, -42, -39, -38, -36,
-34, -33, -30, -29, -27, -25, -22, -21, -20, -19, -16, -15, -14, -12, -12, -10,
-10, -8, -8, -6, -7, -6, -6, -6, -6, -6, -7, -5, -7, -7, -7, -8, -8, -9, -9,
-11, -12, -12, -13, -14, -15, -15, -16, -17, -17, -18, -18, -18, -19, -19, -20,
-20, -20, -20, -20, -20, -20, -21, -20, -21, -21, -21, -22, -22, -22, -22, -21,
-21, -22, -21, -22, -21, -21, -21, -21, -21, -21, -20, -20, -20, -20, -20, -20,
-19, -19, -18, -18, -18, -18, -17, -17, -17, -17, -17, -16, -16, -16, -15, -16,
-15, -16, -15, -15, -15, -15, -16, -15, -15, -15, -14, -14, -14, -15, -14, -14,
-13, -13, -13, -13, -13, -13, -13, -13, -12, -12, -12, -12, -13, -13, -14, -13,
-14, -14, -15, -15, -16, -16, -17, -19, -19, -20, -21, -23, -23, -25, -26, -27,
-29, -32, -33, -35, -37, -39, -40, -43, -46, -47, -50, -53, -55, -58, -61, -63,
-66, -69, -71, -75, -77, -79, -81, -85, -86, -88, -91, -93, -95, -96, -98, -99,
-101, -102, -104, -105, -106, -108, -108, -109, -110, -112, -113, -112, -114,
-116, -116, -116, -117, -117, -118, -118, -118, -118, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -118, -117, -117, -116, -116, -115, -116, -115,
-114, -114, -113, -112, -112, -111, -111, -110, -109, -108, -107, -106, -105,
-103, -102, -101, -100, -97, -96, -94, -92, -90, -87, -85, -81, -80, -76, -74,
-70, -68, -65, -61, -58, -55, -52, -48, -45, -41, -38, -35, -31, -28, -24, -21,
-18, -15, -11, -8, -5, -2, };