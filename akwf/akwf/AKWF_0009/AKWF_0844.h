#define DATA_LENGTH 512
#define DATA AKWF_0844

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 26, 38, 52, 61, 71, 78, 85, 91,
94, 95, 94, 90, 86, 82, 77, 70, 65, 59, 53, 46, 40, 34, 28, 21, 16, 11, 5, -1,
-5, -9, -13, -16, -19, -22, -22, -23, -24, -25, -23, -21, -20, -18, -17, -14,
-13, -11, -9, -6, -4, -4, -1, 0, 1, 3, 3, 5, 5, 6, 5, 4, 5, 4, 3, 2, 1, 1, 0,
-2, -3, -4, -4, -5, -5, -6, -7, -8, -8, -9, -8, -9, -10, -10, -9, -11, -10, -9,
-9, -9, -9, -8, -8, -8, -7, -7, -7, -6, -5, -5, -4, -4, -3, -3, -4, -3, -3, -2,
-2, -2, 0, -1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 0, 0, 0, -1, 0, 0,
0, -1, 0, -1, 0, 0, -1, -1, -1, -1, 0, -1, -1, 0, -1, -1, -1, -1, -1, -1, -2,
-1, -2, -1, -1, -2, -2, -1, -1, 0, -1, -1, -1, -1, -1, -2, -2, 0, -1, -1, 0, -1,
-1, 0, 0, -1, -1, 0, -1, -1, 0, -1, 0, 0, -1, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0,
1, -1, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 0, 1, 1,
1, 1, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, -1, -1, -1, -1, -2, -2, -2, -2, -3, -3, -4,
-4, -5, -5, -6, -6, -6, -7, -6, -7, -8, -8, -9, -10, -10, -10, -10, -11, -11,
-11, -12, -13, -13, -14, -14, -15, -16, -16, -17, -17, -17, -18, -18, -20, -20,
-20, -21, -22, -21, -23, -23, -24, -24, -24, -26, -26, -27, -28, -29, -28, -29,
-29, -30, -31, -32, -32, -34, -34, -34, -35, -35, -35, -37, -37, -38, -39, -40,
-40, -40, -41, -41, -42, -44, -43, -44, -45, -46, -46, -46, -47, -48, -48, -50,
-50, -50, -52, -51, -52, -53, -53, -54, -55, -55, -56, -57, -58, -58, -59, -60,
-60, -60, -61, -62, -62, -64, -64, -65, -65, -66, -67, -67, -67, -68, -69, -69,
-70, -70, -71, -72, -72, -74, -74, -73, -75, -75, -76, -77, -77, -78, -77, -79,
-80, -80, -80, -81, -82, -82, -83, -84, -84, -84, -85, -86, -85, -86, -87, -87,
-88, -89, -89, -90, -91, -91, -92, -91, -93, -93, -93, -94, -94, -94, -96, -96,
-96, -97, -98, -98, -98, -98, -99, -100, -100, -100, -100, -101, -102, -103,
-102, -103, -103, -104, -104, -104, -104, -105, -106, -107, -106, -106, -106,
-107, -107, -108, -108, -108, -109, -109, -110, -110, -111, -110, -111, -111,
-111, -112, -112, -112, -113, -113, -113, -113, -114, -114, -114, -114, -114,
-115, -115, -115, -115, -116, -116, -116, -115, -116, -117, -117, -117, -117,
-117, -117, -117, -117, -118, -118, -118, -118, -118, -119, -118, -118, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -117, -110, -99, -86, -73, -60, -44, -29, -14, 0, };