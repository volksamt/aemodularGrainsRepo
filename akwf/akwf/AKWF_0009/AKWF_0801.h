#define DATA_LENGTH 512
#define DATA AKWF_0801

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 3, 4, 6, 7, 9, 12, 13, 15,
17, 20, 21, 23, 26, 27, 29, 31, 33, 36, 38, 40, 41, 43, 45, 48, 48, 51, 53, 55,
57, 58, 60, 62, 64, 66, 68, 68, 71, 72, 74, 77, 77, 80, 81, 83, 85, 87, 87, 90,
90, 93, 94, 95, 96, 98, 99, 100, 101, 102, 104, 105, 106, 107, 109, 109, 110,
111, 112, 113, 114, 114, 115, 115, 117, 117, 117, 119, 117, 118, 119, 119, 119,
119, 119, 118, 118, 119, 118, 119, 118, 117, 117, 116, 115, 115, 114, 112, 112,
111, 110, 108, 107, 105, 104, 102, 101, 100, 98, 96, 94, 91, 90, 88, 85, 83, 82,
79, 76, 74, 71, 68, 65, 63, 60, 57, 54, 50, 48, 46, 42, 39, 36, 33, 29, 26, 23,
20, 16, 13, 10, 7, 4, 1, -1, -5, -7, -9, -12, -15, -17, -20, -22, -25, -26, -28,
-31, -33, -34, -36, -38, -39, -41, -42, -43, -45, -45, -47, -48, -49, -49, -50,
-51, -51, -52, -53, -54, -54, -54, -53, -54, -54, -55, -54, -54, -55, -54, -54,
-53, -53, -54, -53, -53, -53, -52, -52, -52, -51, -51, -51, -51, -50, -50, -50,
-48, -49, -48, -48, -48, -47, -48, -46, -46, -46, -45, -44, -44, -44, -42, -42,
-42, -41, -41, -39, -39, -38, -37, -36, -35, -34, -35, -34, -33, -34, -33, -35,
-36, -35, -36, -37, -37, -38, -38, -38, -39, -39, -38, -39, -40, -40, -39, -39,
-39, -39, -38, -39, -38, -39, -38, -38, -39, -38, -38, -37, -38, -37, -38, -37,
-37, -37, -35, -36, -35, -35, -35, -34, -33, -34, -32, -32, -31, -31, -31, -30,
-28, -28, -29, -28, -27, -26, -25, -24, -24, -23, -22, -22, -21, -21, -20, -19,
-18, -17, -17, -16, -15, -15, -14, -13, -13, -12, -11, -10, -9, -9, -8, -8, -7,
-7, -6, -6, -5, -4, -3, -3, -2, -1, 0, -1, 0, 1, 3, 4, 4, 4, 5, 6, 7, 7, 8, 9,
9, 10, 11, 11, 11, 12, 12, 12, 14, 12, 13, 13, 13, 13, 14, 13, 13, 13, 13, 12,
12, 12, 11, 10, 10, 9, 8, 8, 7, 6, 5, 5, 3, 3, 1, 0, -2, -3, -5, -6, -7, -9,
-10, -12, -13, -15, -17, -19, -20, -22, -24, -25, -27, -29, -31, -33, -35, -36,
-38, -39, -42, -44, -46, -47, -48, -50, -51, -53, -55, -56, -58, -59, -61, -62,
-62, -64, -66, -67, -68, -69, -70, -70, -71, -72, -73, -74, -74, -74, -74, -74,
-74, -75, -74, -75, -75, -75, -74, -73, -73, -72, -72, -71, -69, -69, -68, -68,
-66, -64, -64, -61, -60, -59, -57, -56, -54, -52, -50, -49, -47, -44, -43, -41,
-39, -36, -34, -32, -30, -29, -26, -24, -22, -20, -18, -15, -13, -13, -11, -10,
-8, -6, -6, -5, -4, -3, -2, -1, -1, -1, 0, 0, 0, 1, 1, 2, 2, 2, 2, 2, 2, 3, 3,
2, 2, 1, 1, 1, 1, 0, 0, -1, 0, };