#define DATA_LENGTH 512
#define DATA AKWF_0884

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 22, 36, 48, 58, 68, 75, 82, 88, 92,
98, 101, 105, 108, 110, 113, 114, 115, 117, 118, 119, 118, 115, 110, 103, 93,
79, 65, 50, 33, 17, 1, -13, -27, -40, -51, -61, -69, -77, -84, -89, -94, -98,
-103, -106, -108, -111, -113, -115, -117, -118, -118, -119, -118, -117, -112,
-105, -95, -84, -70, -55, -39, -22, -5, 10, 23, 36, 48, 58, 67, 75, 82, 88, 93,
98, 101, 105, 107, 110, 113, 114, 116, 117, 118, 118, 117, 115, 109, 101, 92,
79, 64, 49, 32, 16, 0, -14, -29, -40, -51, -62, -70, -77, -84, -89, -95, -98,
-102, -106, -108, -111, -112, -115, -116, -117, -119, -119, -118, -116, -112,
-105, -95, -83, -68, -54, -38, -21, -5, 10, 24, 37, 48, 59, 67, 75, 81, 87, 93,
98, 102, 105, 108, 111, 113, 114, 116, 117, 118, 118, 118, 114, 110, 102, 91,
79, 64, 49, 32, 16, 0, -15, -28, -41, -51, -60, -71, -78, -83, -90, -95, -99,
-103, -106, -109, -110, -113, -115, -116, -118, -119, -120, -119, -116, -111,
-104, -95, -83, -69, -54, -38, -21, -5, 10, 24, 37, 49, 59, 67, 76, 82, 88, 93,
97, 101, 105, 108, 111, 113, 114, 116, 117, 118, 118, 117, 115, 109, 101, 91,
78, 64, 49, 32, 15, 0, -16, -30, -41, -52, -62, -70, -77, -84, -90, -95, -99,
-104, -106, -108, -111, -114, -114, -116, -117, -118, -119, -119, -116, -110,
-104, -93, -81, -67, -51, -34, -18, -2, 13, 27, 39, 50, 59, 69, 77, 84, 90, 95,
98, 103, 106, 108, 111, 113, 114, 116, 118, 118, 119, 117, 114, 109, 102, 91,
77, 63, 48, 32, 15, -1, -15, -30, -41, -52, -62, -70, -79, -84, -90, -95, -100,
-102, -106, -109, -110, -113, -115, -116, -117, -120, -120, -118, -116, -111,
-105, -95, -83, -68, -53, -37, -19, -5, 11, 25, 38, 49, 60, 68, 76, 82, 89, 94,
98, 102, 105, 108, 110, 112, 114, 116, 117, 119, 119, 118, 115, 109, 101, 91,
78, 65, 49, 33, 17, 0, -15, -29, -40, -52, -61, -70, -77, -84, -89, -95, -99,
-102, -106, -108, -111, -113, -115, -116, -118, -118, -118, -118, -116, -111,
-102, -93, -80, -66, -50, -33, -17, -1, 14, 27, 40, 50, 60, 69, 77, 83, 89, 95,
98, 102, 105, 109, 111, 113, 115, 117, 117, 118, 119, 118, 114, 109, 101, 91,
78, 63, 47, 31, 15, -2, -16, -30, -42, -52, -62, -71, -78, -84, -90, -95, -99,
-103, -106, -109, -112, -114, -115, -116, -117, -118, -119, -118, -116, -111,
-104, -94, -82, -68, -52, -36, -19, -4, 12, 26, 38, 49, 60, 69, 76, 83, 88, 94,
99, 101, 105, 108, 110, 112, 114, 116, 118, 118, 119, 117, 114, 109, 101, 91,
79, 63, 48, 32, 16, 0, -15, -28, -41, -51, -61, -70, -77, -84, -90, -94, -98,
-103, -106, -108, -111, -113, -115, -117, -118, -119, -119, -118, -115, -110,
-102, -93, -79, -66, -51, -36, -19, -4, };