#define DATA_LENGTH 512
#define DATA AKWF_0896

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 12, 15, 18, 22, 23, 27, 29,
31, 35, 38, 40, 43, 44, 47, 50, 52, 55, 58, 60, 63, 65, 66, 68, 70, 71, 72, 73,
73, 74, 74, 74, 76, 77, 79, 80, 83, 86, 89, 92, 96, 99, 103, 106, 109, 111, 114,
116, 116, 118, 119, 119, 119, 120, 119, 118, 117, 117, 118, 117, 116, 117, 115,
115, 115, 115, 113, 113, 112, 110, 109, 108, 106, 104, 102, 101, 98, 97, 96, 97,
96, 96, 95, 95, 95, 96, 96, 96, 96, 95, 94, 93, 94, 93, 92, 91, 90, 89, 90, 89,
90, 90, 91, 91, 92, 94, 94, 94, 94, 94, 92, 91, 90, 89, 87, 85, 83, 80, 78, 77,
74, 73, 73, 72, 72, 72, 72, 72, 72, 73, 73, 74, 74, 74, 74, 73, 73, 71, 70, 69,
68, 67, 66, 65, 65, 63, 61, 61, 59, 58, 56, 55, 52, 49, 47, 44, 42, 38, 35, 33,
31, 29, 27, 26, 25, 25, 25, 26, 26, 28, 28, 30, 30, 30, 30, 31, 31, 30, 28, 27,
25, 24, 22, 20, 18, 17, 16, 14, 14, 12, 11, 10, 10, 9, 7, 5, 4, 2, 0, -1, -3,
-5, -7, -8, -10, -10, -11, -12, -13, -13, -12, -12, -12, -12, -12, -11, -12,
-11, -13, -13, -13, -13, -14, -14, -15, -15, -16, -16, -14, -15, -14, -13, -12,
-12, -11, -12, -11, -11, -12, -13, -14, -16, -18, -20, -22, -25, -26, -28, -31,
-32, -32, -33, -33, -33, -34, -33, -33, -32, -32, -31, -30, -31, -30, -30, -31,
-32, -32, -34, -34, -35, -36, -37, -39, -39, -40, -41, -42, -43, -46, -46, -49,
-51, -54, -56, -58, -63, -65, -67, -69, -71, -73, -73, -75, -75, -75, -75, -74,
-73, -72, -71, -71, -71, -71, -72, -72, -74, -73, -75, -78, -80, -82, -83, -86,
-87, -89, -90, -91, -92, -93, -95, -95, -95, -97, -97, -98, -100, -101, -103,
-105, -105, -106, -106, -107, -107, -107, -107, -106, -104, -103, -101, -99,
-97, -94, -92, -90, -89, -86, -84, -82, -80, -77, -75, -72, -71, -67, -64, -61,
-58, -53, -50, -45, -41, -37, -34, -30, -27, -23, -21, -19, -17, -16, -14, -13,
-12, -11, -8, -7, -4, -2, 0, 3, 6, 10, 14, 18, 21, 24, 28, 30, 33, 36, 38, 39,
41, 42, 44, 45, 46, 47, 49, 49, 50, 51, 51, 51, 52, 52, 51, 51, 50, 48, 46, 44,
43, 41, 39, 38, 36, 36, 36, 35, 35, 36, 36, 37, 38, 39, 41, 41, 42, 41, 41, 40,
39, 38, 37, 35, 31, 31, 28, 25, 23, 22, 19, 18, 16, 15, 14, 12, 10, 8, 6, 4, 2,
-1, -3, -6, -8, -10, -12, -15, -16, -18, -19, -20, -20, -21, -21, -20, -21, -21,
-20, -21, -21, -20, -21, -21, -21, -22, -23, -21, -22, -21, -21, -19, -18, -17,
-15, -13, -13, -10, -8, -8, -6, -6, -6, -6, -6, -6, -7, -8, -8, -8, -7, -8, -8,
-7, -5, -3, -2, };