#define DATA_LENGTH 512
#define DATA AKWF_0879

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 20, 24, 27, 30, 31, 34, 37, 37,
39, 41, 42, 45, 45, 46, 48, 48, 50, 51, 53, 54, 55, 56, 56, 58, 58, 60, 60, 60,
62, 63, 64, 64, 66, 66, 67, 68, 69, 70, 70, 71, 72, 73, 73, 75, 74, 76, 76, 78,
78, 78, 80, 80, 81, 81, 83, 83, 84, 85, 85, 85, 85, 87, 87, 87, 87, 86, 87, 88,
87, 87, 87, 87, 87, 88, 87, 88, 88, 89, 89, 89, 90, 90, 91, 91, 90, 91, 91, 92,
92, 93, 94, 93, 94, 94, 95, 95, 95, 96, 96, 96, 96, 97, 97, 96, 97, 96, 96, 95,
95, 95, 94, 93, 94, 92, 92, 93, 92, 92, 92, 91, 91, 91, 90, 90, 90, 90, 90, 90,
90, 89, 89, 89, 90, 89, 89, 89, 89, 89, 89, 88, 88, 88, 88, 87, 86, 86, 86, 86,
84, 83, 83, 82, 80, 80, 79, 78, 77, 77, 76, 75, 74, 74, 72, 72, 71, 71, 69, 69,
69, 69, 67, 67, 67, 66, 65, 64, 64, 63, 63, 62, 62, 60, 60, 60, 60, 58, 58, 58,
57, 56, 56, 55, 55, 55, 54, 54, 53, 53, 52, 52, 52, 52, 51, 50, 50, 51, 50, 49,
50, 50, 50, 50, 50, 50, 50, 50, 50, 51, 51, 52, 52, 53, 52, 53, 54, 53, 55, 55,
55, 56, 56, 56, 57, 57, 57, 57, 56, 57, 56, 57, 56, 56, 57, 57, 57, 57, 57, 58,
59, 60, 60, 61, 61, 62, 63, 64, 64, 65, 66, 66, 67, 68, 69, 70, 71, 72, 72, 73,
74, 75, 76, 75, 75, 76, 75, 75, 75, 74, 72, 70, 70, 69, 66, 65, 64, 63, 61, 60,
59, 58, 58, 57, 56, 57, 56, 55, 54, 54, 53, 53, 52, 51, 51, 50, 49, 48, 47, 45,
44, 43, 43, 41, 39, 37, 36, 33, 30, 25, 21, 5, -22, -26, -32, -35, -39, -42,
-45, -48, -50, -53, -55, -57, -59, -61, -63, -64, -66, -68, -69, -70, -72, -73,
-75, -77, -78, -79, -81, -81, -83, -84, -86, -87, -88, -89, -90, -92, -93, -94,
-95, -95, -98, -98, -99, -100, -102, -101, -103, -104, -105, -105, -106, -107,
-108, -108, -109, -109, -111, -111, -112, -112, -112, -113, -113, -114, -114,
-115, -116, -116, -116, -117, -117, -117, -116, -117, -117, -116, -116, -118,
-116, -117, -117, -117, -117, -117, -117, -119, -118, -118, -118, -119, -119,
-119, -119, -119, -119, -119, -118, -118, -118, -118, -117, -118, -117, -116,
-116, -115, -114, -113, -113, -112, -112, -111, -111, -109, -108, -107, -106,
-105, -105, -105, -103, -102, -101, -101, -100, -99, -98, -98, -97, -97, -97,
-96, -95, -94, -94, -93, -93, -92, -91, -89, -90, -89, -88, -86, -85, -84, -82,
-81, -80, -80, -79, -77, -76, -74, -73, -72, -70, -69, -67, -65, -64, -62, -61,
-60, -58, -57, -56, -53, -53, -52, -50, -49, -48, -48, -47, -45, -45, -43, -43,
-41, -40, -39, -36, -35, -32, -31, -28, -26, -22, -17, -8, };