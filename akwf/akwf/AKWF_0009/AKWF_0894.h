#define DATA_LENGTH 512
#define DATA AKWF_0894

const PROGMEM int8_t DATA[DATA_LENGTH] = {26, 13, 6, 9, 8, 13, 12, 16, 17, 20,
20, 22, 23, 25, 25, 26, 26, 28, 29, 29, 31, 30, 31, 32, 33, 32, 34, 33, 35, 35,
37, 35, 37, 36, 38, 37, 39, 38, 40, 38, 41, 72, 55, 50, 52, 53, 56, 57, 60, 62,
63, 65, 67, 68, 69, 70, 73, 73, 74, 74, 78, 76, 81, 76, 85, 73, 97, 20, 4, 63,
50, 60, 47, 49, 40, 40, 34, 33, 27, 26, 24, 22, 20, 18, 17, 14, 13, 11, 11, 7,
8, 4, 5, 1, 2, -2, -1, -4, -4, -7, -8, -11, -12, -15, -16, -17, -20, -20, -26,
3, -6, -22, -19, -23, -21, -23, -21, -23, -22, -24, -24, -25, -25, -24, -26,
-26, -25, -26, -26, -27, -27, -26, -27, -25, -26, -25, -25, -24, -23, -23, -22,
-22, -21, -19, -18, -17, -16, -15, -15, -12, -12, -10, -9, -8, -8, -5, -5, -2,
-3, 0, -2, 3, -1, 9, 36, 15, 15, 15, 17, 20, 21, 23, 25, 26, 27, 29, 30, 31, 32,
31, 33, 33, 34, 34, 34, 34, 34, 34, 35, 35, 34, 35, 34, 36, 34, 37, 32, 38, 33,
40, 31, 42, 29, 47, 10, -58, 8, 8, 11, 5, 1, -3, -8, -10, -16, -17, -22, -22,
-26, -27, -30, -30, -33, -33, -35, -36, -39, -40, -41, -41, -43, -45, -47, -47,
-50, -51, -53, -54, -57, -58, -61, -61, -66, -64, -71, -58, -40, -65, -65, -68,
-68, -69, -69, -69, -70, -70, -71, -71, -72, -72, -73, -73, -74, -74, -75, -74,
-76, -75, -76, -75, -75, -75, -75, -75, -74, -73, -72, -73, -71, -72, -69, -70,
-66, -69, -62, -70, -49, -31, -51, -48, -49, -44, -42, -39, -37, -33, -32, -29,
-28, -25, -23, -22, -21, -19, -17, -15, -16, -14, -13, -12, -11, -10, -11, -9,
-9, -8, -7, -8, -6, -8, -5, -9, -2, -10, 0, -15, 9, -52, -94, -29, -38, -30,
-41, -43, -50, -53, -58, -62, -65, -68, -70, -75, -76, -79, -80, -83, -84, -87,
-88, -91, -91, -93, -95, -97, -99, -99, -104, -102, -107, -104, -112, -99, -81,
-104, -105, -108, -107, -108, -108, -108, -109, -109, -111, -110, -111, -111,
-113, -113, -114, -114, -116, -116, -117, -117, -118, -118, -118, -118, -119,
-119, -119, -119, -120, -118, -118, -117, -117, -117, -117, -115, -117, -112,
-118, -94, -83, -103, -98, -100, -95, -94, -90, -88, -86, -83, -81, -79, -76,
-75, -74, -72, -71, -69, -68, -67, -66, -64, -63, -62, -61, -60, -60, -59, -59,
-58, -56, -56, -56, -56, -55, -55, -54, -54, -54, -54, -54, -53, -54, -52, -53,
-52, -53, -51, -53, -51, -53, -51, -53, -51, -54, -51, -53, -51, -52, -52, -22,
-36, -44, -41, -42, -39, -38, -35, -35, -32, -32, -30, -30, -28, -27, -26, -26,
-24, -24, -23, -23, -21, -21, -20, -19, -20, -18, -17, -16, -16, -16, -15, -13,
-13, -13, -12, -11, -11, -10, -8, -8, -8, -7, -7, -5, -5, -5, -4, };