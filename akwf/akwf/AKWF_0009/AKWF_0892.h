#define DATA_LENGTH 512
#define DATA AKWF_0892

const PROGMEM int8_t DATA[DATA_LENGTH] = {-80, -112, -30, 0, 6, -5, -12, -20,
-23, -25, -26, -26, -24, -24, -22, -20, -20, -18, -17, -16, -15, -14, -14, -13,
-13, -13, -13, -11, -12, -12, -12, -12, -12, -11, -12, -12, -13, -12, -12, -13,
-13, -12, -12, -12, -12, -12, -12, -12, -12, -11, -11, -11, -10, -9, -10, -9,
-8, -8, -7, -7, -5, -5, -4, -4, -3, -3, -2, -2, -1, -1, 0, 1, 1, 2, 3, 3, 4, 3,
4, 4, 5, 6, 5, 7, 6, 5, 6, 6, 6, 7, 7, 6, 6, 6, 5, 6, 5, 5, 5, 5, 5, 4, 4, 4, 3,
4, 3, 3, 2, 2, 2, 1, 1, 1, 0, 2, 1, 1, 1, 0, -1, 0, 0, 0, -1, -1, -1, 0, -1, 0,
-1, 0, 0, 0, 0, -1, 1, 1, 1, 0, 2, 1, 2, 1, 2, 2, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3,
3, 3, 4, 4, 3, 3, 3, 4, 4, 3, 4, 3, 4, 4, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 2,
3, 2, 2, 2, 2, 2, 2, 2, 3, 2, 2, 1, 1, 1, 1, 2, 2, 2, 1, 2, 1, 2, 2, 2, 2, 1, 1,
2, 2, 1, 2, 2, 2, 1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 3, 2, 2, 3, 3, 2, 2, 3, 2, 2,
2, 3, 2, 3, 3, 2, 2, 3, 3, 2, 3, 2, 3, 2, 3, 3, 2, 3, 2, 2, 2, 3, 2, 2, 2, 2, 3,
2, 2, 2, 2, 3, 1, 1, 2, 2, 2, 2, 3, 1, 2, 3, 1, 2, 2, 1, 2, 2, 2, 1, 3, 1, 2, 2,
2, 2, 3, 2, 2, 2, 2, 3, 1, 3, 3, 2, 3, 2, 2, 2, 2, 2, 3, 3, 3, 2, 1, 3, 3, 2, 2,
2, 3, 2, 2, 2, 2, 3, 2, 3, 3, 2, 2, 3, 2, 2, 3, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 2,
2, 2, 2, 2, 3, 2, 2, 3, 2, 2, 2, 3, 2, 2, 3, 2, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1,
2, 2, 2, 2, 2, 3, 2, 2, 2, 2, 2, 2, 2, 3, 3, 2, 1, 2, 2, 3, 2, 3, 3, 3, 2, 2, 3,
2, 2, 2, 2, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 2, 2, 2, 3, 2, 2, 2, 2, 2, 2,
2, 2, 2, 2, 2, 3, 2, 3, 2, 2, 2, 2, 3, 2, 2, 2, 2, 2, 2, 3, 2, 2, 2, 2, 2, 2, 2,
1, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 1, 2, 2, 2, 2, 2, 2, 2, 2,
2, 3, 3, 2, 2, 2, 2, 3, 2, 2, 2, 2, 3, 2, 2, 3, 2, 2, 2, 2, 2, 3, 3, 2, 2, 1, 2,
2, 3, 2, 2, 2, };