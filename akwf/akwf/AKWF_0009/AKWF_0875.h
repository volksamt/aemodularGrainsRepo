#define DATA_LENGTH 512
#define DATA AKWF_0875

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 5, 6, 7, 10, 11, 14, 16,
19, 21, 23, 25, 27, 30, 33, 36, 39, 43, 45, 49, 53, 56, 59, 60, 62, 64, 64, 66,
67, 69, 70, 73, 74, 76, 78, 81, 82, 84, 86, 87, 88, 89, 90, 92, 93, 94, 96, 97,
97, 97, 97, 97, 95, 94, 94, 94, 95, 96, 97, 99, 102, 104, 107, 108, 110, 112,
114, 115, 115, 118, 118, 119, 119, 119, 119, 119, 117, 115, 114, 113, 110, 107,
105, 101, 97, 94, 91, 88, 85, 81, 78, 75, 72, 71, 68, 65, 62, 60, 56, 54, 50,
48, 46, 42, 40, 37, 35, 32, 29, 27, 24, 22, 19, 17, 13, 12, 9, 6, 3, 1, -2, -5,
-8, -10, -13, -16, -18, -22, -25, -28, -31, -35, -39, -42, -47, -50, -53, -56,
-59, -60, -63, -66, -68, -69, -72, -73, -76, -77, -78, -82, -83, -84, -87, -88,
-90, -92, -93, -93, -94, -94, -93, -93, -93, -92, -91, -89, -89, -88, -87, -85,
-84, -84, -83, -82, -82, -80, -80, -78, -78, -77, -76, -74, -72, -71, -70, -70,
-68, -67, -66, -65, -64, -64, -63, -62, -61, -61, -59, -59, -58, -57, -56, -54,
-52, -51, -50, -48, -46, -45, -42, -41, -41, -39, -37, -36, -34, -33, -32, -30,
-29, -27, -26, -23, -22, -20, -20, -17, -17, -15, -12, -10, -8, -6, -5, -3, -1,
1, 2, 3, 4, 4, 6, 7, 9, 9, 10, 12, 13, 14, 16, 17, 18, 20, 21, 22, 23, 24, 24,
26, 27, 27, 28, 29, 30, 31, 31, 32, 34, 35, 37, 38, 42, 43, 45, 45, 46, 46, 48,
47, 47, 49, 48, 50, 51, 50, 51, 52, 53, 54, 54, 55, 57, 57, 58, 60, 61, 62, 63,
64, 65, 66, 65, 65, 65, 63, 62, 60, 58, 56, 53, 51, 48, 47, 44, 40, 38, 33, 30,
27, 23, 19, 16, 13, 10, 8, 5, 3, 1, -2, -3, -5, -6, -9, -10, -12, -13, -16, -16,
-17, -17, -17, -18, -18, -17, -18, -19, -18, -18, -20, -19, -21, -20, -20, -21,
-22, -22, -22, -24, -24, -24, -24, -24, -24, -25, -25, -26, -25, -26, -27, -28,
-29, -30, -30, -32, -34, -34, -36, -37, -38, -39, -40, -42, -42, -42, -45, -45,
-45, -47, -48, -48, -50, -51, -52, -52, -53, -54, -54, -56, -56, -57, -57, -57,
-58, -59, -59, -60, -59, -59, -60, -60, -61, -61, -61, -62, -62, -62, -60, -61,
-59, -58, -57, -57, -55, -54, -53, -52, -51, -50, -49, -48, -47, -46, -46, -45,
-45, -43, -43, -41, -41, -40, -39, -37, -37, -36, -34, -34, -33, -31, -30, -29,
-28, -26, -24, -23, -21, -19, -17, -16, -15, -13, -12, -11, -10, -9, -9, -9, -9,
-9, -8, -8, -8, -8, -7, -7, -7, -6, -6, -6, -6, -6, -6, -7, -8, -8, -9, -9, -10,
-9, -10, -8, -8, -7, -7, -8, -7, -8, -8, -8, -8, -9, -8, -8, -8, -8, -6, -5, -4,
-2, -2, 0, };