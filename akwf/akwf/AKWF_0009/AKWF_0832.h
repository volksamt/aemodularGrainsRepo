#define DATA_LENGTH 512
#define DATA AKWF_0832

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 2, 2, 4, 4, 5, 5, 7, 7, 8, 9,
8, 9, 10, 11, 11, 12, 12, 13, 14, 14, 14, 14, 15, 16, 16, 16, 17, 17, 18, 20,
20, 20, 20, 21, 21, 22, 22, 23, 23, 24, 25, 25, 26, 26, 28, 28, 28, 29, 30, 31,
32, 32, 33, 34, 35, 36, 36, 37, 38, 39, 40, 40, 42, 42, 43, 45, 46, 47, 48, 49,
50, 51, 52, 52, 53, 55, 55, 56, 57, 58, 58, 59, 60, 61, 62, 63, 64, 65, 65, 66,
67, 68, 68, 69, 70, 71, 72, 73, 74, 75, 76, 76, 77, 77, 78, 80, 80, 80, 81, 82,
83, 84, 84, 85, 86, 87, 88, 89, 89, 90, 91, 92, 91, 92, 94, 94, 95, 97, 98, 98,
98, 99, 100, 100, 101, 103, 103, 104, 104, 105, 106, 108, 108, 109, 110, 110,
112, 112, 112, 114, 114, 115, 116, 117, 117, 118, 118, 119, 120, 119, 119, 119,
119, 119, 119, 119, 118, 118, 118, 117, 116, 114, 113, 113, 111, 110, 110, 108,
106, 105, 102, 101, 100, 99, 96, 94, 93, 91, 89, 87, 84, 82, 81, 78, 77, 74, 73,
71, 68, 66, 65, 62, 60, 59, 56, 55, 53, 51, 49, 47, 44, 43, 41, 39, 37, 35, 33,
31, 30, 27, 27, 24, 23, 21, 19, 17, 15, 15, 13, 11, 9, 7, 6, 4, 2, 1, -1, -1,
-3, -5, -5, -7, -9, -10, -12, -13, -14, -16, -17, -18, -20, -21, -22, -24, -25,
-26, -27, -29, -30, -31, -33, -35, -36, -37, -38, -39, -41, -42, -43, -45, -45,
-47, -48, -49, -50, -51, -53, -53, -55, -56, -56, -57, -59, -59, -60, -61, -61,
-63, -64, -64, -64, -65, -66, -66, -68, -68, -68, -69, -68, -69, -70, -70, -70,
-70, -71, -71, -71, -71, -71, -72, -71, -73, -73, -72, -73, -72, -73, -73, -73,
-73, -73, -73, -73, -73, -74, -74, -74, -74, -74, -74, -74, -74, -74, -75, -75,
-75, -74, -75, -74, -75, -76, -75, -75, -75, -76, -75, -76, -75, -76, -76, -76,
-75, -76, -76, -75, -76, -76, -76, -76, -76, -76, -75, -76, -75, -76, -76, -76,
-75, -75, -75, -75, -76, -76, -75, -75, -75, -74, -74, -74, -74, -74, -74, -74,
-74, -74, -74, -73, -74, -73, -73, -73, -74, -73, -73, -73, -73, -73, -73, -73,
-73, -73, -73, -72, -72, -72, -73, -73, -72, -73, -73, -73, -72, -73, -72, -73,
-72, -72, -71, -71, -71, -70, -70, -69, -69, -69, -68, -67, -66, -65, -65, -64,
-63, -62, -61, -60, -60, -59, -58, -57, -56, -55, -54, -53, -52, -50, -49, -50,
-48, -48, -47, -45, -44, -43, -43, -41, -41, -40, -40, -39, -38, -37, -37, -36,
-34, -33, -33, -32, -32, -31, -30, -29, -29, -28, -27, -26, -26, -25, -24, -23,
-22, -22, -21, -20, -19, -19, -18, -17, -17, -15, -15, -14, -14, -13, -12, -11,
-10, -9, -8, -8, -7, -7, -7, -5, -4, -3, -3, -2, -1, 0, };