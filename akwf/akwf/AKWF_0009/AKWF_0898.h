#define DATA_LENGTH 512
#define DATA AKWF_0898

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 11, 17, 23, 27, 32, 37, 42, 47,
53, 58, 63, 68, 73, 77, 81, 85, 89, 94, 96, 100, 102, 103, 105, 107, 107, 108,
108, 108, 107, 108, 107, 107, 105, 105, 104, 103, 102, 101, 101, 100, 100, 100,
100, 99, 98, 98, 96, 96, 95, 94, 93, 91, 89, 88, 87, 86, 83, 81, 79, 78, 76, 73,
71, 71, 69, 67, 67, 65, 63, 63, 62, 60, 58, 58, 57, 55, 53, 50, 48, 47, 44, 40,
36, 32, 28, 24, 19, 13, 8, 2, -4, -9, -15, -20, -25, -31, -36, -41, -46, -51,
-55, -59, -64, -68, -71, -76, -78, -82, -85, -88, -90, -93, -96, -100, -102,
-105, -107, -109, -111, -114, -115, -117, -118, -119, -118, -119, -119, -119,
-118, -116, -115, -113, -113, -110, -108, -106, -103, -100, -96, -94, -90, -88,
-85, -81, -78, -76, -73, -70, -66, -64, -62, -58, -55, -51, -49, -46, -42, -39,
-35, -32, -27, -24, -19, -16, -12, -8, -3, 1, 4, 9, 12, 16, 20, 23, 26, 30, 34,
36, 39, 42, 44, 47, 49, 50, 53, 55, 56, 59, 60, 61, 63, 66, 67, 69, 70, 73, 74,
75, 76, 77, 80, 80, 81, 82, 84, 84, 85, 86, 85, 85, 85, 84, 83, 83, 81, 80, 79,
77, 75, 73, 70, 68, 65, 63, 60, 57, 55, 51, 49, 46, 44, 41, 39, 37, 35, 33, 30,
28, 26, 24, 23, 20, 18, 16, 14, 12, 9, 7, 5, 3, 1, -1, -4, -5, -8, -9, -12, -14,
-15, -18, -18, -20, -22, -23, -24, -25, -27, -27, -29, -29, -31, -33, -35, -36,
-38, -41, -43, -45, -48, -51, -55, -57, -61, -64, -67, -70, -73, -76, -79, -82,
-83, -85, -87, -88, -89, -91, -91, -90, -90, -91, -89, -89, -88, -86, -85, -84,
-82, -80, -79, -76, -75, -73, -71, -69, -67, -64, -61, -59, -55, -52, -48, -45,
-40, -36, -31, -26, -20, -16, -10, -6, 0, 6, 11, 16, 21, 25, 30, 33, 36, 40, 41,
44, 47, 47, 50, 51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 61, 61, 63, 65, 65, 66,
68, 69, 71, 72, 72, 73, 74, 74, 75, 76, 75, 75, 75, 74, 74, 73, 72, 73, 72, 72,
72, 71, 71, 70, 71, 71, 71, 71, 70, 70, 70, 70, 70, 70, 70, 69, 69, 67, 67, 65,
63, 61, 59, 57, 55, 52, 50, 47, 45, 41, 39, 36, 33, 30, 27, 24, 21, 17, 14, 12,
8, 6, 2, -1, -4, -7, -9, -14, -17, -20, -24, -27, -31, -35, -38, -42, -46, -50,
-54, -57, -61, -64, -69, -72, -75, -78, -81, -84, -87, -89, -91, -94, -95, -97,
-99, -99, -100, -102, -102, -103, -104, -104, -104, -106, -106, -106, -106,
-106, -106, -107, -106, -108, -107, -107, -107, -106, -106, -106, -106, -105,
-104, -102, -101, -100, -98, -97, -94, -92, -89, -87, -83, -80, -76, -73, -69,
-64, -60, -56, -51, -46, -41, -37, -31, -27, -22, -16, -12, -8, -2, };