#define DATA_LENGTH 512
#define DATA AKWF_0880

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 20, 26, 30, 34, 37, 39, 41, 44, 47,
49, 51, 52, 54, 56, 57, 59, 60, 62, 64, 64, 66, 67, 67, 68, 70, 72, 72, 72, 75,
74, 75, 77, 77, 78, 79, 80, 81, 80, 82, 82, 83, 84, 85, 85, 86, 86, 87, 87, 87,
88, 89, 89, 89, 89, 90, 90, 91, 90, 91, 91, 92, 91, 91, 92, 91, 92, 91, 93, 91,
93, 92, 93, 92, 92, 93, 92, 92, 92, 92, 92, 92, 92, 91, 91, 91, 90, 91, 90, 90,
89, 90, 89, 88, 88, 88, 87, 87, 87, 86, 86, 85, 85, 84, 85, 84, 83, 82, 83, 82,
81, 80, 80, 80, 78, 79, 78, 77, 77, 76, 75, 75, 74, 74, 73, 72, 71, 71, 70, 69,
69, 68, 67, 67, 65, 64, 64, 63, 62, 62, 61, 61, 59, 58, 58, 57, 57, 56, 54, 53,
53, 51, 50, 49, 49, 47, 46, 46, 45, 43, 44, 42, 41, 40, 39, 38, 36, 36, 34, 33,
31, 31, 29, 29, 27, 26, 24, 23, 21, 19, 17, 15, 13, 1, -11, -12, -15, -17, -18,
-19, -20, -20, -22, -22, -23, -23, -23, -23, -24, -24, -24, -24, -25, -24, -25,
-24, -24, -23, -23, -21, -21, -20, -19, -19, -16, -16, -13, -11, 3, 14, 15, 18,
19, 22, 23, 25, 27, 28, 29, 30, 31, 33, 35, 35, 36, 37, 39, 39, 40, 43, 43, 45,
45, 46, 47, 48, 50, 51, 51, 52, 53, 55, 55, 57, 58, 59, 60, 61, 61, 62, 64, 64,
66, 67, 68, 68, 69, 70, 71, 72, 73, 74, 74, 75, 76, 77, 78, 79, 80, 81, 82, 82,
84, 84, 85, 86, 87, 88, 88, 89, 90, 91, 91, 92, 94, 94, 94, 94, 94, 94, 94, 92,
91, 91, 89, 89, 86, 85, 83, 82, 80, 79, 78, 77, 75, 74, 74, 73, 73, 71, 70, 70,
69, 68, 68, 66, 65, 65, 63, 61, 60, 59, 57, 56, 54, 53, 51, 50, 46, 44, 42, 41,
37, 33, 30, 24, 16, -13, -26, -30, -35, -37, -41, -44, -47, -49, -53, -55, -57,
-60, -62, -63, -65, -68, -69, -70, -72, -75, -76, -77, -79, -80, -82, -83, -85,
-86, -87, -88, -90, -91, -92, -94, -95, -96, -97, -99, -100, -100, -101, -102,
-102, -104, -105, -106, -107, -107, -108, -108, -110, -110, -112, -111, -112,
-113, -114, -113, -115, -115, -115, -117, -117, -116, -117, -117, -118, -118,
-118, -118, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -118, -119, -119, -118, -118, -118, -118, -118, -117, -117, -117, -115,
-115, -114, -115, -115, -113, -113, -113, -113, -111, -111, -111, -109, -108,
-108, -107, -106, -106, -104, -105, -104, -103, -102, -101, -100, -100, -98,
-97, -96, -96, -95, -93, -92, -92, -91, -89, -88, -87, -85, -84, -84, -82, -81,
-80, -78, -76, -75, -74, -72, -70, -69, -68, -66, -64, -62, -62, -59, -57, -55,
-54, -51, -50, -47, -45, -41, -40, -36, -34, -29, -25, -16, };