#define DATA_LENGTH 512
#define DATA AKWF_0842

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 7, 10, 12, 16, 19, 23, 26, 29,
33, 37, 40, 45, 48, 51, 55, 59, 63, 67, 70, 74, 77, 81, 83, 86, 89, 92, 95, 97,
99, 101, 102, 103, 104, 105, 105, 106, 105, 106, 106, 106, 107, 106, 106, 106,
105, 105, 104, 105, 104, 104, 104, 104, 103, 102, 102, 102, 101, 99, 99, 97, 96,
95, 94, 92, 91, 90, 88, 87, 85, 83, 81, 79, 77, 75, 73, 71, 69, 66, 63, 62, 59,
57, 54, 50, 48, 46, 43, 40, 37, 34, 31, 28, 25, 22, 20, 15, 13, 9, 7, 3, 0, -2,
-6, -9, -11, -14, -17, -20, -23, -25, -28, -31, -33, -35, -37, -40, -42, -44,
-45, -48, -50, -52, -53, -54, -55, -57, -59, -59, -61, -61, -62, -62, -62, -64,
-63, -64, -63, -63, -64, -63, -63, -63, -63, -64, -63, -62, -63, -63, -63, -62,
-62, -62, -62, -61, -61, -60, -61, -60, -60, -59, -59, -58, -58, -56, -56, -56,
-54, -54, -53, -52, -52, -50, -49, -48, -46, -47, -45, -44, -42, -41, -41, -40,
-37, -36, -35, -34, -32, -30, -29, -27, -27, -25, -24, -22, -20, -19, -18, -16,
-15, -13, -12, -10, -8, -7, -5, -4, -2, 0, 1, 1, 2, 4, 6, 7, 8, 9, 10, 12, 12,
14, 15, 16, 16, 17, 17, 18, 19, 20, 20, 21, 22, 22, 22, 22, 22, 23, 23, 23, 23,
23, 23, 22, 21, 20, 19, 18, 15, 13, 10, 7, 4, 0, -6, -11, -15, -20, -26, -32,
-39, -45, -52, -58, -63, -71, -77, -82, -88, -94, -99, -103, -107, -111, -114,
-116, -118, -118, -118, -119, -119, -120, -119, -119, -119, -118, -119, -118,
-118, -118, -118, -117, -117, -116, -116, -114, -115, -114, -113, -112, -111,
-111, -109, -107, -107, -104, -104, -102, -100, -98, -97, -96, -93, -90, -89,
-86, -84, -82, -79, -76, -74, -72, -69, -66, -63, -60, -56, -54, -50, -47, -45,
-41, -37, -35, -31, -28, -24, -20, -17, -13, -10, -7, -4, 1, 3, 7, 9, 13, 16,
20, 23, 26, 29, 31, 35, 38, 41, 44, 46, 48, 51, 53, 55, 58, 60, 62, 64, 65, 67,
68, 69, 71, 72, 73, 74, 74, 75, 75, 76, 76, 76, 76, 75, 75, 75, 75, 75, 76, 75,
75, 75, 75, 75, 75, 74, 75, 74, 73, 75, 73, 74, 74, 72, 71, 72, 71, 70, 70, 69,
68, 68, 67, 67, 66, 65, 65, 64, 62, 62, 61, 60, 60, 59, 57, 56, 55, 54, 53, 51,
51, 49, 48, 46, 44, 43, 42, 41, 40, 38, 37, 35, 34, 33, 30, 29, 28, 26, 25, 23,
22, 20, 19, 17, 15, 14, 14, 11, 10, 9, 7, 6, 5, 3, 2, 1, 0, -2, -3, -4, -5, -6,
-7, -8, -9, -10, -10, -11, -12, -13, -14, -14, -15, -15, -16, -16, -17, -17,
-18, -17, -17, -17, -17, -17, -18, -17, -18, -17, -18, -17, -17, -15, -16, -15,
-14, -13, -11, -10, -8, -7, -4, -3, 0, };