#define DATA_LENGTH 512
#define DATA AKWF_0890

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 12, 18, 23, 29, 35, 39, 44, 47, 52,
56, 60, 63, 67, 70, 73, 74, 78, 80, 82, 84, 86, 88, 90, 91, 93, 94, 96, 98, 99,
100, 101, 102, 103, 104, 105, 106, 106, 107, 108, 109, 109, 109, 110, 111, 111,
112, 113, 113, 113, 113, 113, 114, 114, 114, 115, 115, 114, 115, 116, 116, 116,
116, 116, 117, 117, 117, 117, 117, 117, 117, 117, 118, 117, 117, 117, 119, 118,
117, 118, 118, 118, 118, 118, 119, 118, 119, 118, 118, 118, 119, 119, 119, 119,
119, 119, 119, 118, 118, 119, 119, 118, 118, 119, 119, 118, 119, 120, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 118, 119, 119,
119, 119, 119, 120, 119, 120, 118, 120, 118, 121, 115, 123, 55, -2, 52, 66, 63,
54, 45, 35, 27, 19, 11, 4, -4, -10, -17, -22, -29, -33, -38, -43, -47, -51, -56,
-60, -62, -65, -69, -72, -74, -77, -80, -82, -84, -86, -88, -90, -92, -93, -95,
-95, -97, -99, -100, -101, -102, -103, -104, -105, -105, -107, -107, -107, -108,
-109, -110, -110, -110, -112, -112, -112, -112, -113, -114, -113, -114, -114,
-114, -114, -115, -115, -116, -116, -116, -116, -116, -116, -117, -117, -117,
-117, -117, -117, -117, -118, -117, -117, -117, -117, -117, -118, -118, -118,
-118, -118, -118, -119, -119, -118, -118, -118, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -118, -118, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -120, -120, -119, -119, -119, -119, -119, -118, -118, -119, -120,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -120, -119, -120, -119, -119, -118,
-119, -118, -119, -120, -120, -119, -119, -119, -120, -118, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -118, -120, -120, -118, -118, -120, -118, -120, -119, -119, -118,
-119, -119, -118, -119, -119, -120, -119, -118, -119, -119, -119, -120, -119,
-120, -119, -120, -118, -119, -119, -119, -120, -119, -119, -118, -120, -119,
-120, -119, -119, -119, -119, -119, -120, -120, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -118, -119, -119,
-119, -120, -119, -120, -119, -119, -119, -119, -118, -120, -119, -119, -119,
-119, -120, -119, -118, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -118, -120, -119,
-119, -119, -119, -120, -118, -120, -118, -119, -119, -119, -118, -120, -118,
-119, -119, -119, -118, -120, -120, -118, -119, -118, -117, -17, -9, -66, -62,
-62, -50, -44, -31, -25, -14, -9, 0, };