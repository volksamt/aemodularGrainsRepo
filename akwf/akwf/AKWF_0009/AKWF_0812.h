#define DATA_LENGTH 512
#define DATA AKWF_0812

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 15, 26, 35, 44, 52, 59, 65, 69, 73,
76, 78, 79, 81, 81, 80, 80, 78, 78, 75, 73, 70, 67, 64, 61, 58, 55, 52, 48, 44,
42, 38, 33, 30, 28, 24, 21, 18, 15, 12, 9, 5, 3, 0, -2, -3, -6, -8, -10, -12,
-13, -15, -17, -18, -20, -21, -22, -22, -23, -23, -25, -26, -26, -27, -26, -26,
-26, -27, -27, -27, -27, -27, -26, -27, -26, -26, -26, -25, -25, -25, -24, -23,
-23, -22, -22, -21, -20, -20, -19, -18, -18, -17, -16, -16, -14, -14, -13, -12,
-12, -11, -11, -9, -9, -9, -8, -8, -6, -6, -6, -5, -4, -5, -3, -3, -2, -2, -1,
-2, 0, 0, 1, 1, 2, 1, 1, 3, 2, 3, 3, 3, 3, 4, 4, 4, 4, 5, 5, 5, 5, 6, 5, 6, 6,
5, 5, 6, 6, 6, 5, 6, 5, 6, 5, 5, 5, 6, 5, 5, 5, 5, 5, 5, 5, 5, 4, 4, 4, 5, 4, 4,
4, 4, 4, 4, 4, 3, 4, 3, 3, 3, 2, 4, 2, 3, 2, 3, 2, 3, 2, 2, 2, 1, 2, 1, 1, 2, 1,
1, 1, 2, 1, 1, 1, 0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 0, 0, 0, 1, 0, 0, 0, -1, 0,
0, 0, 0, -1, -1, -1, 0, -1, -1, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, -1, -1, -1,
0, -1, -1, 0, 0, 0, 0, 0, -1, 0, -1, -1, -1, -1, 0, 0, 0, 0, 0, -1, 0, -1, -1,
0, 0, 0, 0, -1, -1, -1, -1, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1,
0, -1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, -1, -1, 0, 0, 1,
-1, 1, 0, 0, 0, 0, 1, 0, 1, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 1, 1, 0,
-1, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0,
0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 1, 0, -1, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0,
0, 0, -1, 0, 0, -1, 1, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, -1, 1, 0,
0, 1, 0, 0, 0, 1, 0, 1, 0, 1, 1, 0, 0, 1, -1, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0,
-1, 1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, -1, -1, 0, 0, 0, 0, 1, 1, 0, -1, -1, -20,
-54, -82, -103, -115, -119, -118, -111, -102, -90, -78, -63, -49, -35, -21, -6,
};