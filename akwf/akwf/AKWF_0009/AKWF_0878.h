#define DATA_LENGTH 512
#define DATA AKWF_0878

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 14, 16, 18, 20, 22, 22, 24, 25, 26,
27, 28, 29, 30, 31, 31, 32, 32, 34, 34, 34, 34, 34, 35, 36, 36, 37, 38, 39, 39,
39, 41, 42, 44, 44, 46, 47, 49, 50, 51, 53, 53, 55, 56, 57, 58, 58, 60, 61, 61,
62, 63, 63, 64, 64, 65, 65, 67, 67, 68, 68, 69, 69, 71, 71, 71, 72, 73, 73, 74,
75, 76, 76, 77, 77, 78, 80, 80, 80, 82, 83, 82, 84, 85, 84, 85, 86, 87, 87, 89,
89, 90, 91, 92, 91, 94, 94, 93, 95, 96, 96, 97, 98, 99, 99, 100, 100, 101, 101,
103, 104, 104, 104, 105, 105, 107, 107, 108, 109, 109, 109, 111, 111, 111, 112,
113, 114, 113, 115, 115, 115, 116, 117, 118, 118, 119, 119, 119, 118, 119, 120,
118, 119, 119, 119, 120, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 118, 117, 116, 116, 115, 114, 115, 113, 114, 112, 113, 111, 111,
110, 110, 109, 109, 107, 107, 107, 106, 105, 105, 104, 104, 104, 102, 102, 101,
100, 100, 98, 98, 98, 97, 97, 96, 95, 95, 94, 93, 92, 92, 92, 91, 89, 89, 89,
88, 87, 86, 85, 85, 85, 84, 83, 83, 82, 81, 80, 80, 78, 78, 76, 77, 75, 73, 73,
72, 71, 68, 68, 66, 66, 64, 63, 61, 60, 59, 58, 57, 56, 54, 53, 51, 50, 49, 49,
47, 45, 44, 42, 40, 37, 35, 32, 29, 26, 20, 16, -5, -21, -23, -28, -30, -34,
-35, -38, -40, -43, -44, -46, -48, -49, -52, -53, -54, -57, -57, -60, -61, -63,
-65, -65, -67, -68, -70, -71, -72, -74, -76, -77, -78, -79, -81, -82, -83, -84,
-85, -88, -88, -89, -91, -92, -93, -94, -95, -97, -98, -100, -101, -102, -103,
-104, -106, -107, -108, -110, -110, -112, -114, -116, -117, -119, -120, -119,
-120, -119, -119, -120, -119, -119, -119, -120, -119, -118, -119, -119, -119,
-119, -120, -118, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -119, -120, -119, -119, -118, -119, -119,
-119, -119, -120, -119, -118, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -120, -119, -120, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -118,
-119, -118, -116, -115, -113, -112, -111, -111, -109, -109, -106, -105, -105,
-104, -102, -101, -101, -99, -99, -98, -96, -95, -93, -92, -92, -91, -90, -89,
-88, -87, -85, -84, -85, -83, -82, -81, -80, -79, -78, -77, -75, -75, -73, -73,
-72, -71, -69, -68, -68, -66, -65, -65, -63, -63, -62, -60, -59, -59, -57, -57,
-55, -54, -53, -52, -51, -49, -48, -47, -46, -45, -45, -43, -42, -41, -39, -38,
-37, -36, -34, -33, -32, -30, -29, -28, -26, -24, -22, -20, -18, -16, -13, -7,
};