#define DATA_LENGTH 512
#define DATA AKWF_0864

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 12, 16, 20, 25, 28, 33, 36, 41,
45, 47, 51, 54, 58, 59, 62, 64, 67, 68, 70, 71, 73, 74, 74, 76, 76, 76, 75, 75,
75, 74, 74, 73, 73, 72, 70, 71, 70, 69, 69, 68, 68, 66, 66, 65, 65, 63, 63, 63,
62, 61, 61, 61, 60, 58, 58, 58, 56, 55, 55, 54, 53, 53, 52, 51, 50, 50, 49, 48,
47, 47, 46, 45, 45, 44, 43, 42, 42, 41, 40, 39, 39, 37, 36, 37, 36, 35, 34, 33,
32, 31, 32, 30, 30, 29, 29, 27, 26, 26, 26, 24, 24, 23, 23, 22, 22, 20, 20, 19,
19, 17, 17, 16, 15, 16, 15, 14, 13, 13, 12, 10, 11, 10, 9, 6, 4, 1, -2, -4, -8,
-11, -14, -19, -21, -26, -30, -33, -37, -41, -45, -49, -53, -57, -62, -65, -69,
-73, -76, -80, -82, -86, -90, -93, -95, -98, -101, -104, -106, -108, -109, -111,
-114, -114, -116, -116, -117, -118, -119, -119, -120, -119, -119, -118, -117,
-117, -115, -112, -107, -105, -100, -96, -92, -86, -81, -76, -72, -67, -61, -55,
-51, -45, -40, -35, -30, -25, -20, -16, -10, -7, -2, 1, 5, 9, 11, 15, 17, 18,
21, 23, 23, 25, 27, 27, 26, 27, 26, 25, 25, 24, 23, 23, 21, 21, 20, 19, 18, 18,
17, 15, 16, 15, 13, 13, 12, 12, 11, 11, 10, 10, 10, 12, 14, 16, 18, 20, 23, 25,
28, 31, 34, 38, 42, 44, 48, 51, 55, 58, 61, 64, 68, 71, 74, 77, 81, 82, 86, 88,
91, 93, 96, 97, 99, 100, 101, 103, 103, 105, 106, 106, 106, 106, 105, 105, 104,
104, 102, 101, 99, 97, 94, 90, 87, 84, 80, 76, 71, 67, 63, 59, 54, 50, 45, 41,
36, 30, 26, 21, 17, 11, 8, 3, -2, -7, -10, -15, -19, -23, -26, -30, -34, -37,
-41, -45, -47, -50, -54, -56, -59, -60, -63, -65, -68, -69, -70, -72, -73, -73,
-74, -75, -75, -76, -75, -75, -74, -74, -74, -71, -71, -70, -69, -68, -67, -66,
-65, -65, -64, -62, -62, -60, -60, -58, -57, -54, -51, -49, -46, -43, -39, -35,
-31, -28, -24, -20, -15, -12, -7, -4, 1, 5, 10, 14, 18, 22, 26, 30, 34, 38, 43,
45, 49, 53, 57, 61, 63, 67, 68, 73, 74, 78, 79, 83, 83, 87, 86, 91, 90, 93, 91,
96, 94, 97, 95, 96, 96, 92, 103, -27, -62, -43, -53, -43, -49, -42, -46, -42,
-42, -39, -39, -38, -37, -37, -34, -34, -30, -32, -36, -49, -58, -69, -70, 20,
23, -1, -9, -21, -16, -19, -13, -17, -13, -15, -11, -13, -8, -10, -8, -8, -6,
-5, -4, -3, -3, -3, -6, -9, -13, -18, -24, -30, -37, -43, -50, -56, -63, -69,
-76, -81, -88, -92, -97, -101, -104, -106, -109, -109, -109, -109, -108, -106,
-103, -100, -96, -93, -88, -83, -79, -74, -68, -64, -58, -53, -49, -43, -37,
-33, -27, -21, -17, -11, -8, -3, };