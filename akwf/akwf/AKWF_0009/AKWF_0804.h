#define DATA_LENGTH 512
#define DATA AKWF_0804

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 13, 16, 20, 23, 26, 30, 33,
36, 38, 41, 44, 47, 48, 50, 52, 49, 45, 37, 27, 18, 11, 5, 5, 8, 11, 16, 20, 21,
21, 17, 14, 11, 9, 7, 7, 7, 9, 12, 15, 18, 20, 23, 26, 27, 30, 33, 36, 39, 43,
46, 48, 53, 56, 59, 62, 65, 68, 72, 74, 77, 79, 81, 83, 86, 87, 89, 90, 92, 93,
94, 94, 95, 95, 94, 94, 94, 93, 92, 90, 89, 87, 86, 84, 82, 79, 77, 74, 72, 69,
66, 63, 60, 57, 52, 49, 46, 43, 39, 36, 31, 28, 24, 21, 17, 14, 9, 7, 2, 0, -4,
-7, -11, -14, -17, -21, -24, -26, -29, -32, -34, -37, -39, -41, -44, -46, -47,
-49, -51, -52, -54, -56, -57, -58, -59, -60, -61, -61, -61, -63, -62, -62, -63,
-63, -62, -63, -63, -63, -63, -62, -61, -60, -58, -57, -57, -57, -55, -54, -53,
-52, -51, -49, -48, -47, -44, -44, -43, -41, -40, -37, -36, -35, -33, -31, -30,
-28, -27, -26, -23, -21, -18, -14, -6, 1, 11, 21, 30, 38, 44, 47, 49, 48, 47,
46, 47, 49, 53, 56, 59, 62, 63, 64, 64, 62, 60, 57, 54, 52, 49, 45, 43, 40, 36,
32, 28, 24, 18, 15, 10, 5, 2, -3, -8, -13, -17, -22, -26, -30, -34, -37, -41,
-44, -49, -51, -54, -58, -60, -62, -64, -66, -67, -68, -70, -70, -71, -71, -71,
-72, -71, -71, -70, -69, -68, -66, -66, -64, -63, -60, -59, -56, -54, -51, -50,
-47, -45, -41, -39, -36, -34, -30, -28, -24, -22, -18, -15, -13, -11, -6, -5,
-1, 2, 5, 7, 10, 13, 15, 17, 19, 22, 24, 26, 29, 31, 33, 34, 37, 38, 39, 41, 42,
43, 45, 45, 47, 47, 48, 49, 49, 50, 49, 50, 50, 50, 50, 50, 50, 50, 50, 49, 48,
46, 40, 31, 18, 5, -7, -15, -18, -18, -14, -11, -7, -6, -9, -13, -18, -23, -27,
-30, -32, -32, -30, -28, -26, -23, -21, -18, -17, -15, -12, -10, -7, -4, 0, 4,
7, 11, 15, 19, 22, 26, 29, 33, 36, 40, 43, 46, 49, 53, 56, 59, 61, 63, 65, 66,
69, 69, 71, 72, 72, 72, 72, 73, 73, 72, 72, 71, 70, 69, 69, 66, 64, 63, 61, 59,
57, 54, 52, 50, 47, 44, 41, 39, 36, 33, 30, 27, 24, 21, 17, 14, 12, 10, 9, 11,
15, 22, 30, 36, 41, 43, 40, 36, 30, 24, 20, 18, 16, 18, 19, 19, 20, 19, 16, 13,
9, 5, 0, -5, -10, -13, -18, -23, -28, -32, -36, -41, -45, -50, -56, -60, -65,
-70, -74, -80, -83, -88, -91, -95, -97, -101, -105, -107, -109, -112, -113,
-115, -117, -117, -118, -119, -119, -119, -118, -118, -118, -116, -114, -113,
-112, -110, -107, -105, -102, -100, -97, -94, -90, -87, -84, -80, -75, -72, -68,
-63, -60, -55, -52, -47, -42, -39, -35, -30, -26, -22, -18, -13, -9, -5, -1, };