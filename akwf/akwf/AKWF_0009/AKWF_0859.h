#define DATA_LENGTH 512
#define DATA AKWF_0859

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 8, 9, 11, 13, 15, 16, 18, 19,
20, 22, 24, 25, 26, 27, 28, 29, 29, 30, 30, 32, 33, 33, 33, 34, 34, 36, 35, 35,
36, 35, 35, 36, 36, 36, 36, 37, 37, 36, 37, 37, 38, 37, 38, 38, 37, 38, 38, 39,
38, 38, 39, 38, 38, 38, 39, 38, 37, 38, 37, 25, 5, -10, -19, -20, -21, -20, -18,
-17, -15, -14, -13, -11, -10, -9, -9, -7, -6, -4, -4, -3, -3, -1, -2, -1, 0, 0,
0, 1, 1, 1, 2, 2, 2, 3, 4, 4, 4, 5, 5, 6, 6, 6, 7, 8, 8, 8, 9, 8, 9, 9, 9, 10,
10, 9, 10, 11, 11, 11, 11, 12, 11, 11, 12, 11, 12, 12, 12, 12, 12, 13, 13, 13,
13, 12, 13, 12, 13, 13, 13, 12, 14, 13, 13, 12, 5, -17, -35, -43, -46, -46, -45,
-44, -42, -41, -39, -38, -37, -35, -35, -33, -32, -31, -29, -29, -29, -27, -27,
-26, -25, -24, -23, -22, -21, -20, -19, -19, -18, -16, -15, -15, -14, -13, -12,
-11, -11, -10, -8, -8, -7, -7, -6, -5, -5, -4, -2, -2, -2, -2, 0, 0, 1, 1, 2, 3,
3, 3, 4, 5, 5, 6, 6, 6, 7, 7, 8, 8, 9, 10, 9, 10, 10, 11, 10, 12, 11, 12, 12,
12, 12, 9, -10, -30, -39, -43, -43, -43, -41, -40, -38, -36, -34, -33, -32, -29,
-28, -26, -25, -24, -23, -21, -20, -20, -19, -18, -16, -15, -14, -13, -11, -10,
-9, -8, -7, -5, -4, -4, -2, -1, -1, 1, 2, 3, 3, 5, 6, 6, 7, 9, 9, 10, 11, 11,
12, 12, 13, 15, 15, 16, 17, 17, 18, 18, 19, 20, 21, 21, 21, 21, 23, 22, 24, 24,
24, 25, 25, 25, 26, 26, 26, 27, 28, 27, 27, 29, 27, 12, -9, -21, -26, -28, -28,
-25, -24, -22, -21, -18, -17, -16, -14, -12, -11, -9, -8, -7, -6, -4, -4, -3,
-1, -1, 1, 2, 3, 3, 5, 5, 7, 8, 9, 10, 11, 10, 12, 13, 14, 15, 17, 17, 17, 18,
19, 20, 20, 21, 21, 23, 23, 23, 24, 24, 26, 26, 27, 27, 28, 28, 29, 30, 29, 29,
31, 31, 31, 31, 31, 32, 33, 32, 33, 33, 33, 33, 34, 34, 35, 35, 35, 35, 35, 35,
26, 4, -12, -20, -21, -21, -20, -18, -16, -15, -14, -12, -10, -9, -8, -6, -5,
-2, -2, -1, 0, 2, 3, 4, 4, 6, 6, 7, 7, 9, 8, 9, 10, 11, 12, 14, 13, 14, 14, 17,
14, 20, -14, -105, -121, -112, -111, -104, -103, -97, -94, -89, -86, -82, -79,
-74, -72, -67, -65, -60, -56, -54, -51, -47, -43, -40, -38, -34, -31, -28, -26,
-22, -20, -18, -14, -13, -10, -7, -5, -3, 0, 1, 4, 5, 8, 4, -16, -39, -50, -51,
-50, -48, -45, -42, -39, -35, -33, -29, -26, -24, -21, -18, -16, -13, -11, -7,
-5, -4, -2, };