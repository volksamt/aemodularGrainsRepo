#define DATA_LENGTH 512
#define DATA AKWF_0802

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 10, 14, 18, 20, 24, 25, 27, 29,
30, 32, 33, 33, 33, 34, 32, 33, 33, 33, 32, 31, 31, 30, 28, 28, 27, 25, 24, 23,
22, 21, 19, 18, 16, 15, 15, 13, 12, 11, 9, 8, 8, 7, 6, 5, 3, 3, 2, 1, 0, -1, -1,
-2, -2, -4, -4, -5, -5, -7, -6, -7, -8, -9, -8, -9, -9, -9, -9, -10, -9, -10,
-10, -10, -10, -10, -11, -11, -11, -11, -11, -10, -9, -10, -10, -9, -10, -10,
-10, -9, -10, -10, -9, -8, -9, -8, -8, -8, -7, -8, -7, -8, -7, -7, -6, -6, -5,
-6, -5, -5, -4, -4, -4, -4, -4, -3, -3, -2, -3, -3, -2, -2, -2, -2, -1, -2, -1,
-1, -1, -1, -1, 0, 0, 0, 0, 0, 1, 0, 1, 1, 1, 0, 2, 1, 1, 1, 2, 1, 1, 2, 2, 1,
1, 1, 2, 2, 2, 2, 2, 2, 1, 2, 2, 1, 2, 2, 1, 1, 2, 2, 2, 2, 2, 2, 1, 2, 2, 1, 2,
2, 1, 2, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 0, 1, 1, 0, 1, 0, 0, 1, 1, 0,
0, 0, 0, 0, 1, 1, 1, 1, 0, 0, 1, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 1, 1, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0,
0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 1, -1, 0, 0, -1, 0, 0, 0,
-1, 0, 0, 0, -1, 0, 0, 1, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0,
0, 0, -1, -1, 1, 0, -1, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0,
0, 0, 0, 1, 0, 0, 0, 1, 0, -1, 0, 0, 0, 1, 0, 0, 0, 1, -1, 1, 0, 0, 0, 0, 0, 0,
0, 0, 1, -1, 0, 0, 0, 0, 1, 0, 1, 1, -1, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0,
0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, -1, -1, 1, 0,
0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, -1, 1, 0, -1, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0,
-1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0,
0, 0, 0, 0, 1, 0, -1, 1, -1, 0, 1, 1, -1, 0, -1, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0,
-1, 1, -1, 2, -2, 2, -2, 3, -4, 4, -4, 5, -7, 11, -28, -124, -94, -84, -68, -57,
-47, -34, -28, -18, -12, -3, };