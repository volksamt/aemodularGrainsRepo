#define DATA_LENGTH 512
#define DATA AKWF_0893

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 15, 25, 35, 42, 50, 56, 63, 67, 71,
75, 77, 80, 81, 82, 82, 81, 79, 78, 75, 73, 70, 66, 63, 59, 56, 53, 50, 46, 43,
40, 37, 35, 34, 30, 30, 28, 28, 26, 26, 26, 25, 26, 26, 26, 27, 28, 28, 29, 31,
31, 32, 33, 34, 34, 35, 34, 35, 36, 34, 35, 34, 32, 32, 31, 28, 28, 25, 24, 22,
18, 17, 14, 12, 9, 6, 3, 1, -2, -5, -7, -10, -12, -14, -17, -18, -21, -22, -23,
-24, -25, -26, -26, -26, -27, -25, -25, -25, -24, -22, -21, -19, -17, -15, -13,
-11, -8, -6, -3, -1, 1, 4, 7, 9, 12, 14, 16, 19, 20, 22, 24, 26, 28, 29, 30, 30,
31, 32, 32, 33, 33, 32, 32, 31, 30, 29, 28, 26, 25, 23, 21, 20, 17, 15, 12, 11,
8, 6, 3, 1, -2, -3, -6, -9, -11, -13, -14, -17, -19, -20, -22, -23, -25, -26,
-28, -28, -28, -30, -30, -30, -31, -31, -31, -30, -30, -30, -29, -28, -27, -26,
-27, -25, -24, -22, -21, -21, -18, -17, -16, -15, -13, -12, -10, -9, -8, -6, -5,
-4, -3, -3, -1, -1, 0, 1, 1, 2, 3, 3, 3, 4, 3, 3, 4, 4, 3, 4, 4, 3, 2, 2, 2, 1,
1, 0, 0, -1, -1, -2, -4, -3, -3, -4, -5, -5, -6, -6, -6, -7, -8, -7, -8, -8, -9,
-8, -8, -9, -9, -9, -9, -9, -8, -7, -8, -7, -8, -6, -6, -6, -6, -5, -5, -4, -5,
-4, -4, -3, -2, -2, -1, -1, 0, 0, 0, 1, 1, 1, 2, 2, 2, 2, 3, 3, 3, 3, 3, 4, 4,
4, 5, 3, 4, 4, 4, 4, 5, 3, 4, 4, 4, 3, 3, 3, 3, 3, 2, 2, 2, 2, 2, 2, 1, 2, 1, 0,
0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 1, -1, 1, 0, 1, -1, 1, 0, 0, 1, 0, 0, 0, 1, 1, 1,
1, 1, 2, 1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 2, 2, 2, 3, 3, 3, 3, 3, 2, 2, 3, 2, 2,
3, 2, 2, 2, 2, 3, 3, 2, 3, 3, 2, 1, 2, 2, 1, 2, 2, 2, 1, 1, 2, 0, 1, 1, 1, 1, 1,
1, 1, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 1, 1, 1, 0,
0, 1, 0, 1, 1, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0,
0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, -1,
0, 0, 0, 0, -1, -1, -1, -7, -25, -57, -78, -82, -77, -76, -81, -91, -102, -109,
-116, -118, -119, -119, -119, -118, -118, -114, -111, -103, -102, -78, -66, -70,
-58, -50, -38, -27, -15, -4, 4, };