#define DATA_LENGTH 512
#define DATA AKWF_0882

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 23, 36, 48, 57, 66, 72, 79, 85,
89, 93, 97, 100, 103, 105, 107, 108, 108, 108, 107, 106, 104, 102, 100, 98, 97,
96, 96, 97, 98, 98, 100, 102, 103, 103, 102, 102, 101, 99, 97, 95, 93, 91, 90,
90, 87, 87, 84, 83, 80, 77, 74, 68, 63, 58, 52, 47, 44, 42, 42, 42, 44, 46, 49,
50, 51, 51, 51, 48, 44, 41, 36, 32, 30, 26, 24, 20, 18, 15, 10, 6, 1, -4, -10,
-16, -23, -29, -33, -36, -37, -37, -37, -34, -32, -30, -29, -30, -31, -32, -34,
-37, -41, -45, -48, -52, -56, -58, -61, -63, -65, -68, -71, -73, -76, -79, -81,
-86, -88, -90, -90, -87, -82, -74, -64, -51, -36, -22, -8, 6, 18, 29, 38, 45,
52, 56, 61, 64, 66, 69, 71, 72, 73, 73, 75, 73, 72, 71, 68, 64, 59, 54, 50, 45,
42, 41, 41, 41, 43, 45, 47, 48, 50, 51, 50, 49, 45, 42, 37, 33, 29, 26, 23, 20,
18, 14, 11, 7, 2, -4, -9, -15, -21, -26, -30, -31, -29, -26, -19, -10, 0, 10,
21, 32, 41, 47, 54, 60, 64, 67, 69, 71, 74, 74, 75, 77, 77, 77, 76, 76, 75, 73,
69, 65, 60, 54, 50, 47, 42, 42, 40, 41, 44, 46, 47, 49, 51, 50, 51, 49, 46, 41,
37, 34, 30, 26, 23, 20, 18, 15, 11, 7, 3, -4, -9, -15, -23, -27, -30, -31, -29,
-26, -19, -10, -1, 10, 21, 31, 41, 48, 55, 60, 63, 68, 70, 72, 73, 74, 75, 77,
77, 77, 77, 76, 74, 72, 70, 65, 61, 55, 50, 46, 43, 41, 40, 42, 42, 46, 48, 48,
50, 51, 50, 48, 46, 42, 38, 33, 29, 26, 23, 20, 17, 14, 11, 7, 2, -4, -10, -15,
-22, -28, -33, -36, -36, -37, -37, -34, -32, -31, -30, -29, -30, -32, -35, -37,
-41, -45, -49, -52, -56, -59, -61, -63, -65, -67, -70, -73, -76, -78, -82, -85,
-88, -92, -95, -96, -96, -97, -96, -95, -94, -93, -93, -93, -93, -93, -95, -97,
-99, -100, -102, -104, -105, -106, -109, -109, -111, -112, -113, -115, -115,
-116, -118, -117, -118, -119, -116, -113, -106, -97, -86, -73, -60, -47, -35,
-23, -13, -4, 2, 5, 8, 9, 9, 9, 9, 9, 8, 8, 7, 5, 2, -1, -5, -10, -16, -21, -27,
-31, -36, -38, -39, -38, -37, -35, -33, -32, -30, -30, -32, -32, -36, -38, -42,
-46, -49, -53, -57, -59, -61, -65, -66, -68, -70, -73, -77, -79, -82, -85, -89,
-91, -90, -89, -85, -78, -68, -59, -47, -35, -24, -14, -5, 2, 7, 11, 12, 13, 12,
12, 11, 11, 9, 8, 8, 6, 3, 0, -4, -9, -15, -20, -26, -32, -35, -38, -40, -38,
-37, -34, -33, -32, -30, -31, -32, -34, -35, -39, -42, -46, -50, -53, -57, -59,
-61, -64, -67, -68, -71, -73, -76, -80, -82, -86, -88, -90, -89, -86, -80, -71,
-60, -46, -30, -16, -2, };