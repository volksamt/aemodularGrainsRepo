#define DATA_LENGTH 512
#define DATA AKWF_0870

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 17, 24, 29, 34, 39, 45, 50,
54, 59, 64, 69, 73, 77, 83, 87, 91, 95, 100, 104, 108, 112, 117, 118, 109, 101,
93, 85, 78, 70, 63, 56, 50, 43, 35, 28, 22, 16, 10, 3, -3, -8, -14, -19, -25,
-30, -36, -41, -47, -51, -57, -61, -65, -63, -62, -61, -59, -59, -56, -55, -54,
-53, -51, -50, -48, -48, -46, -44, -43, -42, -41, -40, -38, -37, -35, -34, -33,
-32, -30, -30, -29, -27, -26, -25, -24, -23, -22, -21, -18, -18, -17, -15, -15,
-14, -13, -12, -11, -10, -9, -8, -8, -6, -6, -4, -4, -3, -2, -2, 0, 1, 1, 2, 2,
3, 3, 4, 6, 6, 5, 7, 8, 8, 9, 8, 10, 9, 10, 11, 10, 12, 12, 12, 12, 12, 13, 13,
13, 13, 14, 13, 14, 14, 14, 13, 14, 14, 14, 15, 14, 15, 15, 15, 14, 15, 14, 15,
14, 14, 14, 14, 14, 14, 13, 13, 13, 13, 12, 13, 13, 12, 12, 11, 12, 11, 11, 11,
10, 10, 10, 9, 9, 9, 8, 8, 8, 7, 7, 6, 6, 6, 6, 6, 5, 4, 4, 4, 4, 4, 3, 2, 3, 2,
2, 1, 1, 1, -1, 0, -1, -1, -2, -2, -2, -3, -3, -3, -3, -4, -4, -5, -5, -4, -5,
-6, -6, -6, -7, -5, -7, -6, -7, -6, -8, -7, -7, -8, -8, -9, -8, -8, -8, -8, -9,
-9, -9, -9, -9, -9, -9, -10, -10, -10, -10, -9, -9, -9, -9, -9, -10, -9, -9, -9,
-9, -8, -9, -9, -9, -9, -8, -8, -8, -8, -8, -8, -7, -8, -7, -8, -7, -6, -7, -6,
-6, -6, -6, -5, -6, -4, -5, -4, -4, -4, -4, -4, -3, -4, -3, -3, -2, -2, -2, -2,
-2, -1, -1, -1, -1, 0, 1, 1, 1, 1, 2, 2, 1, 2, 3, 2, 3, 4, 3, 3, 4, 3, 5, 5, 5,
4, 6, 6, 5, 6, 6, 6, 6, 7, 8, 8, 7, 8, 7, 8, 8, 8, 8, 9, 9, 9, 9, 8, 10, 9, 8,
9, 10, 9, 9, 10, 9, 10, 9, 10, 10, 9, 9, 8, 8, 9, 9, 9, 9, 9, 9, 9, 8, 9, 8, 8,
8, 8, 8, 8, 8, 7, 7, 7, 7, 7, 6, 7, 6, 6, 5, 4, 5, 6, 5, 4, 4, 4, 4, 3, 3, 2, 3,
1, 2, 1, 1, 0, 0, 0, 0, -1, -1, -1, -1, -1, -2, -3, -3, -3, -4, -4, -5, -5, -5,
-5, -5, -6, -6, -8, -8, -8, -9, -9, -9, -9, -9, -9, -10, -10, -11, -11, -11,
-12, -12, -14, -13, -13, -14, -14, -14, -16, -15, -15, -16, -16, -16, -16, -17,
-17, -18, -18, -18, -18, -18, -19, -19, -19, -20, -19, -20, -20, -21, -20, -20,
-21, -21, -21, -21, -22, -22, -22, -22, -22, -22, -22, -23, -23, -22, -23, -23,
-23, -23, -22, -23, -23, -23, -23, -23, -23, -20, -12, -8, 3, -9, -18, -8, -4,
};