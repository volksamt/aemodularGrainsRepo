#define DATA_LENGTH 512
#define DATA AKWF_0820

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 20, 61, 94, 102, 94, 75, 40, -7,
-55, -96, -117, -118, -104, -81, -54, -26, -2, 16, 28, 35, 38, 39, 38, 34, 32,
28, 23, 20, 15, 12, 9, 6, 3, 1, -1, -2, -3, -4, -4, -5, -6, -6, -6, -6, -6, -6,
-6, -5, -6, -6, -7, -7, -8, -8, -9, -9, -9, -11, -11, -12, -12, -12, -14, -14,
-13, -14, -13, -12, -13, -11, -9, -8, -5, -1, 1, 3, 5, 7, 8, 6, 6, 5, 3, 2, -2,
-4, -7, -9, -10, -11, -9, -7, -4, -1, 4, 11, 19, 26, 34, 42, 50, 57, 61, 62, 60,
56, 52, 47, 43, 41, 40, 39, 38, 35, 28, 15, -4, -26, -50, -71, -89, -100, -105,
-105, -102, -94, -83, -73, -61, -50, -38, -27, -18, -9, -1, 5, 12, 16, 21, 23,
27, 27, 29, 29, 29, 28, 27, 26, 24, 23, 21, 19, 16, 15, 12, 10, 9, 8, 5, 5, 2,
1, 1, 1, 0, -1, -1, 0, -1, 0, 0, 1, 2, 1, 3, 3, 4, 4, 5, 6, 6, 7, 8, 8, 8, 9, 8,
8, 8, 8, 8, 7, 7, 5, 3, 1, -1, -4, -6, -9, -11, -13, -13, -13, -15, -14, -14,
-13, -12, -10, -9, -7, -5, -2, -1, 1, 2, 5, 5, 6, 7, 7, 8, 7, 5, 3, 2, 0, -3,
-6, -8, -12, -14, -18, -19, -22, -24, -28, -28, -30, -29, -29, -28, -28, -24,
-18, -12, -10, -6, 29, 33, 44, 25, -4, 1, -4, -1, 4, 19, 30, 40, 43, 46, 45, 42,
38, 34, 29, 25, 19, 14, 10, 7, 3, 0, -3, -6, -7, -9, -9, -11, -10, -11, -11,
-11, -10, -10, -10, -9, -10, -8, -8, -7, -8, -7, -8, -7, -7, -7, -8, -8, -7, -8,
-8, -9, -9, -9, -10, -10, -10, -11, -11, -12, -12, -11, -11, -10, -11, -9, -7,
-6, -5, -1, 1, 4, 7, 9, 12, 13, 14, 16, 16, 16, 16, 15, 14, 14, 11, 10, 9, 7, 6,
3, 2, 0, -1, -2, -4, -5, -6, -7, -7, -8, -8, -8, -8, -7, -7, -5, -4, -3, -1, 0,
1, 4, 6, 7, 9, 11, 13, 15, 17, 17, 18, 19, 20, 21, 22, 21, 21, 20, 18, 15, 12,
8, 4, -1, -5, -10, -13, -16, -19, -21, -21, -22, -23, -23, -22, -22, -21, -19,
-18, -17, -15, -13, -11, -9, -7, -6, -4, -2, -1, 0, 1, 3, 3, 5, 5, 6, 7, 7, 7,
7, 7, 7, 6, 8, 6, 7, 6, 6, 6, 5, 5, 4, 4, 2, 3, 3, 2, 2, 2, 1, 0, 1, 0, -1, -1,
-1, -1, -1, -2, -1, -2, -3, -2, -3, -3, -4, -3, -3, -2, -3, -3, -4, -4, -4, -4,
-4, -3, -4, -4, -3, -3, -4, -3, -3, -3, -3, -2, -3, -2, -1, -1, 0, -1, 0, 0, 0,
-1, 1, 0, 1, 0, 2, 1, 2, 1, -1, -6, -9, -16, -18, -20, -13, 22, 23, 37, 14, -11,
-2, };