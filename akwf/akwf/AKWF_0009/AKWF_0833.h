#define DATA_LENGTH 512
#define DATA AKWF_0833

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 8, 12, 16, 20, 25, 28, 32, 35, 39,
41, 45, 48, 50, 53, 56, 58, 59, 61, 63, 64, 66, 67, 69, 70, 71, 71, 72, 73, 74,
75, 75, 75, 75, 76, 76, 76, 76, 76, 76, 76, 76, 77, 75, 76, 75, 75, 75, 74, 74,
74, 74, 75, 74, 74, 74, 72, 73, 72, 72, 72, 71, 71, 70, 71, 70, 71, 69, 70, 69,
69, 68, 68, 69, 67, 67, 68, 66, 66, 66, 66, 65, 65, 65, 64, 64, 64, 62, 64, 63,
62, 62, 61, 61, 60, 60, 59, 60, 59, 59, 58, 58, 57, 57, 56, 56, 56, 55, 55, 54,
54, 54, 53, 53, 52, 51, 51, 51, 50, 50, 49, 49, 48, 48, 48, 47, 47, 46, 46, 45,
44, 44, 44, 43, 43, 42, 43, 42, 41, 41, 40, 40, 39, 39, 38, 38, 38, 37, 36, 36,
35, 36, 35, 35, 34, 34, 33, 33, 33, 32, 33, 31, 31, 30, 31, 30, 30, 29, 29, 29,
28, 28, 28, 27, 27, 26, 26, 26, 25, 25, 25, 24, 24, 23, 23, 23, 22, 22, 22, 22,
21, 21, 20, 21, 21, 20, 19, 19, 19, 19, 19, 18, 18, 17, 17, 17, 18, 17, 16, 16,
15, 15, 16, 14, 15, 14, 14, 15, 14, 14, 14, 13, 12, 13, 13, 12, 12, 12, 11, 12,
11, 10, 11, 11, 10, 10, 10, 9, 10, 9, 9, 9, 8, 8, 9, 8, 8, 8, 8, 7, 7, 7, 7, 7,
7, 7, 7, 6, 6, 7, 6, 6, 6, 6, 6, 6, 6, 5, 5, 5, 4, 4, 5, 4, 4, 3, 3, 3, 3, 3, 3,
3, 3, 2, 3, 3, 3, 2, 3, 2, 3, 2, 1, 2, 1, 1, 1, 2, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1,
0, 1, 1, 1, 0, -1, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, -1, -2, -1, -2, -1, -1, -2,
-2, -2, -2, -1, -2, -2, -2, -1, -2, -2, -2, -2, -2, -2, -2, -3, -2, -3, -2, -3,
-3, -2, -2, -3, -3, -3, -2, -3, -3, -3, -4, -3, -3, -3, -2, -3, -3, -3, -4, -4,
-3, -4, -4, -4, -4, -5, -6, -6, -7, -7, -8, -10, -11, -13, -15, -16, -19, -20,
-22, -26, -29, -31, -35, -37, -40, -43, -47, -50, -54, -57, -61, -64, -68, -71,
-75, -78, -81, -84, -87, -90, -93, -96, -98, -100, -103, -104, -106, -108, -109,
-111, -112, -114, -114, -115, -117, -117, -117, -118, -119, -118, -119, -119,
-119, -118, -119, -118, -119, -118, -118, -118, -117, -117, -116, -116, -115,
-115, -114, -114, -114, -113, -112, -111, -110, -110, -109, -109, -108, -107,
-107, -106, -105, -105, -104, -104, -103, -102, -102, -101, -100, -100, -99,
-99, -98, -97, -96, -97, -95, -94, -93, -94, -92, -91, -90, -89, -87, -87, -85,
-83, -82, -80, -78, -75, -73, -70, -67, -64, -60, -57, -52, -48, -45, -40, -36,
-32, -27, -23, -18, -14, -9, -3, 0, };