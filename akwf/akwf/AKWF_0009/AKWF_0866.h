#define DATA_LENGTH 512
#define DATA AKWF_0866

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 14, 19, 25, 31, 36, 43, 48, 55,
61, 69, 75, 83, 89, 98, 103, 113, 119, 108, 100, 91, 82, 74, 67, 59, 52, 46, 39,
34, 29, 24, 18, 14, 10, 5, 2, -2, -5, -9, -11, -13, -15, -17, -19, -20, -21,
-22, -24, -25, -25, -26, -26, -25, -25, -25, -25, -24, -24, -24, -23, -21, -21,
-20, -18, -18, -17, -15, -14, -13, -12, -10, -9, -8, -7, -4, -4, -2, -1, 1, 2,
2, 4, 5, 6, 6, 7, 8, 8, 8, 9, 10, 9, 10, 10, 9, 9, 9, 9, 7, 7, 6, 4, 4, 2, 0,
-2, -3, -6, -7, -10, -13, -15, -18, -21, -25, -28, -31, -36, -39, -43, -48, -52,
-56, -60, -66, -71, -76, -81, -88, -93, -100, -95, -83, -73, -62, -52, -43, -34,
-25, -18, -9, -2, 5, 11, 17, 23, 28, 33, 38, 42, 46, 50, 53, 56, 59, 62, 64, 65,
68, 68, 70, 70, 71, 71, 71, 71, 71, 71, 69, 68, 67, 66, 65, 62, 61, 59, 56, 54,
53, 50, 48, 44, 41, 39, 35, 32, 31, 27, 23, 20, 17, 14, 10, 8, 4, 1, -2, -6, -9,
-12, -15, -19, -21, -23, -28, -29, -32, -35, -38, -40, -43, -46, -47, -49, -51,
-53, -55, -56, -59, -59, -60, -62, -62, -64, -64, -64, -65, -64, -64, -64, -64,
-63, -63, -61, -61, -60, -57, -56, -54, -52, -50, -48, -46, -43, -39, -37, -34,
-30, -26, -22, -18, -14, -10, -5, 0, 4, 9, 14, 20, 26, 31, 37, 44, 49, 56, 63,
69, 76, 83, 90, 99, 105, 113, 117, 107, 99, 90, 82, 74, 66, 58, 52, 45, 39, 34,
27, 23, 18, 13, 9, 5, 1, -3, -5, -9, -11, -13, -15, -17, -19, -21, -21, -23,
-24, -24, -24, -25, -25, -26, -26, -25, -25, -25, -24, -23, -22, -21, -20, -19,
-18, -17, -16, -15, -14, -12, -11, -10, -8, -7, -6, -4, -4, -2, -1, 1, 1, 3, 4,
4, 5, 6, 7, 8, 9, 9, 9, 9, 9, 10, 10, 9, 9, 9, 9, 7, 6, 6, 4, 4, 2, 1, -2, -3,
-5, -9, -11, -13, -16, -18, -21, -25, -28, -31, -36, -40, -43, -48, -52, -56,
-62, -67, -71, -77, -82, -88, -94, -101, -94, -80, -71, -60, -52, -41, -33, -24,
-17, -9, -2, 5, 11, 17, 23, 29, 33, 38, 42, 47, 49, 53, 57, 59, 62, 64, 66, 67,
68, 70, 70, 71, 71, 71, 71, 71, 70, 69, 68, 67, 65, 63, 62, 61, 59, 56, 54, 52,
49, 46, 44, 41, 39, 35, 33, 30, 26, 23, 20, 17, 13, 10, 7, 4, 0, -3, -6, -9,
-12, -16, -18, -22, -25, -27, -30, -33, -35, -37, -41, -43, -46, -48, -49, -51,
-53, -55, -56, -58, -60, -61, -61, -62, -63, -64, -64, -65, -64, -65, -64, -64,
-63, -62, -62, -60, -60, -59, -55, -54, -52, -50, -48, -46, -42, -40, -37, -33,
-29, -26, -22, -18, -13, -9, -5, 0, };