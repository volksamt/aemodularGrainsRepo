#define DATA_LENGTH 512
#define DATA AKWF_0821

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 3, 5, 7, 8, 9, 11, 13, 15, 16,
17, 19, 20, 21, 22, 23, 25, 26, 27, 29, 29, 31, 31, 32, 33, 34, 35, 36, 37, 37,
38, 39, 40, 40, 41, 41, 42, 43, 43, 44, 45, 45, 45, 46, 47, 47, 47, 48, 48, 49,
49, 49, 50, 50, 51, 51, 51, 52, 52, 53, 52, 54, 54, 54, 55, 55, 56, 56, 56, 57,
58, 58, 58, 58, 59, 59, 60, 60, 61, 62, 62, 61, 63, 63, 64, 64, 63, 65, 65, 65,
66, 67, 67, 68, 68, 68, 69, 69, 69, 69, 69, 70, 70, 71, 71, 71, 72, 71, 72, 72,
73, 73, 74, 73, 74, 74, 74, 75, 74, 76, 75, 75, 76, 76, 76, 76, 76, 76, 76, 76,
76, 76, 77, 76, 76, 77, 76, 76, 77, 77, 76, 77, 77, 76, 77, 77, 76, 76, 76, 76,
77, 76, 76, 76, 76, 77, 76, 76, 76, 76, 75, 75, 75, 75, 75, 75, 74, 74, 73, 74,
72, 72, 71, 71, 71, 71, 71, 70, 69, 69, 69, 68, 68, 67, 67, 66, 65, 65, 65, 65,
63, 64, 63, 63, 62, 61, 62, 61, 61, 60, 60, 59, 59, 59, 58, 57, 57, 56, 57, 55,
56, 55, 55, 54, 54, 54, 52, 53, 52, 52, 52, 51, 51, 50, 50, 49, 49, 48, 48, 48,
46, 46, 46, 45, 45, 44, 43, 43, 42, 42, 41, 40, 41, 39, 39, 38, 37, 36, 37, 34,
33, 34, 32, 32, 31, 30, 28, 27, 27, 25, 24, 23, 22, 21, 20, 18, 17, 16, 14, 14,
12, 11, 9, 7, 6, 5, 3, 2, 1, -1, -3, -4, -6, -7, -9, -11, -12, -14, -16, -17,
-19, -21, -22, -24, -26, -28, -29, -31, -32, -34, -36, -38, -39, -41, -42, -44,
-46, -48, -49, -51, -52, -55, -56, -57, -59, -60, -62, -62, -65, -66, -67, -68,
-69, -70, -72, -74, -75, -76, -76, -78, -78, -80, -80, -82, -83, -84, -85, -86,
-87, -88, -89, -89, -90, -91, -92, -94, -94, -95, -96, -96, -97, -97, -98, -99,
-99, -101, -101, -101, -101, -104, -103, -105, -105, -106, -106, -106, -107,
-108, -108, -109, -109, -110, -110, -110, -111, -112, -111, -112, -112, -113,
-114, -113, -114, -114, -114, -115, -115, -115, -116, -115, -116, -116, -116,
-117, -117, -117, -117, -118, -118, -119, -118, -118, -118, -118, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -118, -118, -118, -118, -118, -118, -117, -116, -116, -117, -116,
-115, -116, -115, -115, -113, -113, -113, -112, -112, -111, -110, -109, -108,
-108, -108, -106, -105, -104, -103, -103, -101, -100, -99, -97, -97, -94, -94,
-93, -90, -90, -88, -86, -85, -83, -82, -80, -80, -78, -76, -75, -73, -71, -69,
-67, -65, -64, -62, -60, -58, -57, -54, -52, -51, -48, -47, -45, -43, -40, -38,
-38, -35, -32, -31, -29, -26, -25, -24, -21, -20, -17, -15, -14, -12, -9, -7,
-7, -5, -2, -2, };