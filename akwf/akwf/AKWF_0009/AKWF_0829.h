#define DATA_LENGTH 512
#define DATA AKWF_0829

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 3, 3, 3, 4, 4, 5, 6, 6, 7, 7,
8, 9, 9, 10, 10, 10, 11, 12, 13, 13, 14, 14, 15, 16, 16, 17, 17, 19, 18, 19, 20,
20, 21, 21, 22, 23, 23, 23, 24, 24, 26, 26, 27, 28, 28, 28, 29, 29, 30, 31, 32,
32, 32, 32, 34, 34, 34, 35, 35, 37, 37, 38, 38, 38, 39, 40, 40, 41, 41, 43, 43,
43, 44, 44, 45, 46, 46, 46, 47, 48, 48, 49, 50, 49, 50, 52, 52, 52, 53, 54, 54,
55, 56, 56, 56, 57, 58, 58, 60, 59, 61, 61, 61, 62, 62, 63, 63, 65, 65, 65, 66,
65, 66, 67, 68, 69, 68, 69, 69, 71, 72, 72, 72, 73, 74, 74, 75, 76, 76, 77, 77,
78, 78, 79, 80, 80, 80, 81, 82, 82, 83, 83, 85, 84, 86, 86, 85, 86, 88, 88, 88,
89, 91, 90, 91, 91, 92, 92, 93, 93, 94, 94, 96, 96, 97, 97, 97, 98, 98, 99, 100,
100, 102, 102, 102, 103, 103, 104, 105, 105, 105, 107, 107, 108, 109, 108, 110,
109, 110, 111, 112, 112, 113, 114, 114, 114, 115, 115, 116, 117, 117, 119, 118,
120, 120, 119, 118, 116, 116, 113, 112, 109, 106, 104, 101, 98, 95, 91, 88, 85,
80, 78, 73, 70, 67, 63, 59, 55, 52, 49, 44, 41, 37, 33, 30, 26, 23, 20, 16, 13,
10, 7, 3, 0, -3, -5, -8, -11, -15, -17, -19, -23, -25, -27, -30, -32, -35, -36,
-39, -41, -43, -45, -47, -50, -50, -53, -55, -57, -58, -60, -61, -63, -64, -65,
-67, -68, -70, -71, -72, -73, -75, -75, -76, -78, -79, -80, -81, -81, -82, -84,
-84, -85, -85, -85, -86, -87, -88, -88, -89, -90, -89, -89, -91, -90, -92, -92,
-92, -92, -93, -93, -93, -93, -93, -94, -94, -94, -93, -94, -94, -95, -94, -94,
-94, -94, -94, -94, -95, -93, -94, -93, -94, -93, -93, -93, -93, -92, -92, -92,
-92, -92, -91, -91, -91, -90, -90, -89, -89, -88, -89, -89, -88, -87, -87, -87,
-86, -86, -86, -85, -85, -84, -83, -84, -83, -82, -82, -82, -82, -81, -80, -81,
-80, -79, -79, -78, -77, -78, -77, -76, -75, -75, -74, -74, -74, -74, -72, -72,
-71, -71, -71, -70, -69, -69, -69, -68, -67, -67, -66, -65, -64, -64, -64, -62,
-63, -62, -62, -61, -60, -60, -59, -59, -57, -57, -57, -57, -55, -55, -54, -54,
-53, -53, -52, -51, -51, -50, -50, -49, -49, -48, -47, -47, -46, -45, -45, -45,
-43, -42, -43, -41, -42, -40, -40, -39, -39, -39, -37, -38, -37, -37, -35, -35,
-34, -34, -34, -32, -31, -32, -31, -31, -29, -29, -29, -28, -27, -26, -26, -26,
-25, -24, -24, -23, -22, -22, -22, -20, -20, -19, -19, -18, -17, -18, -16, -17,
-15, -15, -14, -13, -13, -12, -12, -10, -10, -10, -9, -9, -8, -8, -7, -6, -5,
-5, -5, -4, -4, -3, -3, -2, -2, -1, 0, };