#define DATA_LENGTH 512
#define DATA AKWF_0815

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 14, 21, 27, 33, 37, 42, 48, 52,
57, 61, 65, 68, 72, 75, 78, 81, 83, 85, 87, 89, 89, 91, 93, 92, 93, 93, 93, 94,
93, 93, 92, 91, 90, 89, 88, 86, 85, 84, 82, 79, 78, 76, 73, 72, 70, 68, 65, 63,
60, 59, 56, 54, 51, 49, 47, 44, 42, 39, 38, 35, 32, 29, 27, 25, 23, 21, 19, 16,
15, 12, 9, 9, 6, 4, 3, 2, 0, -2, 1, 7, 15, 23, 34, 45, 54, 64, 72, 80, 87, 92,
97, 100, 102, 103, 103, 103, 101, 99, 95, 91, 87, 81, 76, 70, 64, 56, 50, 44,
35, 28, 21, 14, 7, -1, -8, -15, -21, -28, -34, -41, -47, -52, -57, -63, -68,
-73, -77, -82, -84, -89, -92, -95, -98, -100, -103, -104, -106, -108, -109,
-109, -110, -110, -110, -110, -110, -110, -109, -108, -107, -106, -104, -103,
-102, -99, -98, -96, -94, -91, -90, -88, -85, -82, -80, -77, -75, -72, -69, -66,
-63, -62, -58, -56, -53, -50, -47, -45, -42, -38, -37, -34, -32, -30, -26, -25,
-22, -19, -17, -15, -13, -10, -8, -6, -5, -3, -1, 1, 3, 4, 5, 6, 7, 8, 9, 10,
10, 11, 12, 13, 13, 14, 15, 16, 17, 17, 17, 18, 19, 19, 20, 20, 21, 22, 22, 22,
23, 23, 23, 24, 23, 24, 25, 24, 23, 24, 24, 25, 25, 24, 24, 24, 24, 24, 23, 24,
23, 23, 22, 23, 22, 21, 21, 22, 21, 21, 20, 19, 19, 18, 18, 18, 17, 18, 17, 16,
15, 15, 14, 14, 14, 14, 13, 12, 12, 11, 11, 11, 10, 10, 9, 9, 8, 8, 8, 8, 6, 6,
6, 5, 6, 4, 4, 4, 3, 4, 3, 4, 2, 2, 2, 2, 2, 2, 1, 1, 1, 0, 0, 1, 0, 0, -1, 0,
-1, -1, 0, -1, -1, -1, -1, -1, -1, -1, -1, -1, -2, 0, -2, -1, -2, -1, -2, -2,
-2, -1, -1, -1, -1, -2, -2, -1, -1, -1, -1, -1, -1, -2, -2, -1, -2, -1, -1, -1,
-1, -1, -1, -1, -1, -1, 0, 0, -1, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0,
-1, 0, 0, 0, 1, 1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 1, 0, 0, 1, 2, 2,
0, 1, 0, 1, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 1, 1, 1, 0, 1, 1, 1, 0, 1, 1, 0, 1, 1,
0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 0, 1, 0, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 0, 0, 1, 1,
0, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, -2, -10, -18, -29, -39, -50,
-60, -72, -81, -89, -97, -104, -109, -113, -116, -118, -120, -120, -118, -116,
-114, -110, -106, -101, -97, -92, -86, -80, -73, -66, -60, -52, -45, -38, -31,
-24, -17, -10, -3, };