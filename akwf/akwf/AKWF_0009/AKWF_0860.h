#define DATA_LENGTH 512
#define DATA AKWF_0860

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 5, 6, 7, 8, 9, 10, 11, 12,
12, 13, 13, 14, 15, 15, 16, 16, 16, 16, 18, 19, 19, 21, 21, 22, 24, 25, 26, 29,
29, 32, 34, 37, 38, 41, 43, 45, 48, 51, 52, 55, 57, 58, 61, 62, 64, 66, 67, 69,
69, 70, 71, 72, 72, 72, 73, 73, 72, 72, 72, 72, 72, 70, 70, 70, 70, 68, 67, 66,
65, 64, 64, 63, 62, 61, 59, 58, 57, 57, 55, 55, 53, 52, 51, 50, 49, 47, 46, 46,
45, 44, 43, 42, 40, 40, 40, 39, 38, 37, 36, 36, 35, 35, 35, 34, 33, 33, 33, 33,
33, 33, 34, 34, 34, 33, 33, 34, 35, 35, 36, 36, 36, 37, 37, 37, 38, 38, 37, 38,
37, 38, 38, 38, 38, 36, 37, 37, 36, 35, 35, 34, 33, 33, 31, 31, 30, 29, 28, 27,
26, 24, 22, 21, 20, 18, 15, 10, 3, -3, -9, -15, -20, -25, -30, -35, -40, -45,
-49, -52, -56, -61, -64, -67, -70, -74, -76, -79, -82, -84, -87, -89, -92, -94,
-96, -97, -99, -101, -103, -104, -106, -108, -109, -110, -111, -112, -113, -114,
-115, -116, -117, -117, -119, -119, -119, -118, -119, -118, -119, -119, -118,
-117, -115, -114, -112, -110, -108, -105, -103, -100, -97, -93, -90, -86, -82,
-79, -75, -70, -66, -62, -58, -54, -49, -46, -42, -37, -34, -30, -26, -23, -18,
-16, -13, -10, -6, -3, 0, 2, 5, 8, 10, 12, 15, 18, 20, 22, 24, 26, 28, 30, 32,
34, 37, 39, 40, 42, 44, 46, 47, 50, 51, 53, 55, 57, 58, 60, 62, 62, 64, 66, 68,
69, 70, 72, 73, 70, 67, 66, 64, 62, 61, 59, 59, 57, 56, 55, 53, 53, 53, 51, 50,
49, 49, 48, 47, 46, 46, 46, 45, 44, 44, 43, 43, 43, 42, 40, 40, 40, 39, 39, 37,
37, 36, 35, 34, 34, 32, 32, 31, 30, 29, 27, 27, 26, 25, 24, 21, 21, 19, 18, 17,
17, 16, 15, 15, 14, 13, 13, 13, 13, 14, 14, 16, 16, 18, 19, 21, 22, 24, 25, 27,
29, 30, 32, 34, 36, 38, 39, 40, 42, 42, 44, 45, 46, 47, 48, 49, 49, 49, 50, 50,
49, 49, 49, 49, 49, 48, 47, 46, 46, 46, 46, 45, 44, 43, 43, 43, 41, 40, 39, 39,
38, 37, 37, 36, 34, 34, 35, 33, 32, 32, 32, 30, 26, 22, 18, 12, 6, 2, -3, -8,
-13, -18, -23, -28, -32, -36, -41, -45, -50, -54, -58, -61, -64, -68, -72, -75,
-79, -83, -84, -88, -91, -94, -96, -98, -100, -103, -104, -106, -107, -109,
-109, -111, -111, -112, -112, -113, -112, -112, -112, -112, -110, -109, -108,
-107, -106, -104, -103, -101, -99, -97, -95, -93, -91, -88, -86, -85, -81, -80,
-76, -73, -71, -69, -66, -64, -61, -58, -55, -52, -50, -47, -44, -41, -39, -36,
-34, -31, -29, -26, -24, -22, -20, -17, -15, -13, -10, -8, -7, -5, -3, -2, };