#define DATA_LENGTH 512
#define DATA AKWF_0899

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 7, 9, 10, 12, 14, 15, 17, 18,
20, 20, 21, 21, 22, 23, 22, 22, 23, 23, 23, 22, 21, 21, 20, 19, 19, 17, 17, 16,
15, 13, 11, 9, 9, 8, 6, 4, 3, 1, 0, -1, -3, -5, -6, -7, -8, -10, -11, -13, -13,
-14, -15, -16, -17, -18, -19, -20, -21, -21, -22, -22, -23, -23, -23, -24, -24,
-24, -24, -25, -24, -24, -23, -23, -23, -24, -23, -23, -23, -22, -22, -22, -21,
-21, -20, -19, -19, -19, -18, -18, -17, -17, -17, -17, -15, -16, -15, -14, -15,
-14, -14, -14, -12, -12, -12, -12, -11, -10, -11, -10, -11, -10, -10, -8, -8,
-9, -8, -9, -8, -8, -7, -7, -6, -7, -6, -6, -6, -6, -5, -5, -4, -4, -4, -3, -4,
-3, -3, -2, -2, -1, -1, -1, 0, 0, 1, 1, 2, 2, 3, 3, 3, 3, 5, 4, 5, 6, 7, 7, 8,
8, 8, 9, 10, 10, 11, 11, 12, 12, 12, 13, 13, 14, 14, 14, 14, 16, 16, 16, 16, 16,
16, 16, 17, 17, 18, 18, 18, 17, 18, 18, 18, 18, 18, 19, 18, 19, 19, 19, 18, 18,
19, 18, 18, 19, 18, 18, 18, 18, 18, 18, 18, 17, 18, 17, 17, 17, 17, 17, 16, 17,
16, 16, 16, 16, 16, 16, 15, 15, 16, 16, 15, 16, 15, 16, 15, 15, 15, 16, 15, 15,
15, 15, 14, 15, 16, 16, 16, 16, 16, 16, 17, 16, 16, 17, 16, 18, 17, 18, 18, 18,
19, 19, 20, 19, 20, 21, 20, 22, 21, 22, 22, 23, 24, 24, 23, 24, 24, 25, 25, 26,
27, 26, 27, 28, 28, 29, 29, 29, 30, 31, 31, 31, 32, 32, 32, 33, 33, 34, 33, 34,
35, 35, 35, 35, 36, 37, 36, 36, 37, 37, 38, 38, 37, 38, 38, 38, 38, 38, 39, 39,
39, 39, 39, 39, 40, 39, 40, 40, 41, 41, 40, 40, 41, 40, 41, 41, 41, 40, 40, 41,
41, 40, 41, 40, 41, 41, 42, 41, 41, 41, 41, 41, 41, 42, 41, 41, 41, 41, 42, 42,
42, 41, 42, 41, 42, 42, 42, 42, 43, 43, 43, 44, 43, 43, 44, 44, 43, 44, 44, 45,
45, 45, 45, 45, 44, 45, 46, 46, 45, 46, 46, 47, 47, 47, 48, 48, 48, 48, 48, 48,
49, 49, 50, 50, 50, 48, 45, 43, 42, 39, 35, 33, 31, 28, 25, 22, 19, 15, 10, 7,
1, -3, -7, -12, -16, -20, -25, -29, -34, -38, -41, -45, -50, -54, -56, -60, -64,
-67, -70, -74, -77, -80, -83, -86, -89, -91, -93, -96, -99, -101, -104, -106,
-107, -109, -111, -112, -114, -115, -116, -116, -118, -118, -119, -119, -119,
-119, -119, -118, -118, -117, -116, -115, -114, -113, -111, -110, -108, -106,
-104, -101, -99, -96, -94, -92, -88, -86, -82, -79, -76, -73, -70, -67, -63,
-59, -55, -52, -49, -45, -42, -39, -35, -31, -28, -24, -22, -17, -15, -11, -9,
-6, -4, 0, };