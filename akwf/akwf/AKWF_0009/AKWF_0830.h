#define DATA_LENGTH 512
#define DATA AKWF_0830

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 3, 4, 5, 6, 6, 7, 8, 8, 9,
10, 11, 11, 12, 12, 13, 13, 14, 15, 15, 16, 17, 17, 16, 17, 17, 18, 18, 18, 18,
19, 19, 19, 19, 20, 20, 20, 19, 20, 20, 20, 20, 21, 20, 20, 21, 20, 21, 21, 21,
20, 21, 21, 20, 20, 20, 21, 21, 21, 21, 21, 21, 21, 20, 21, 21, 21, 21, 22, 22,
22, 22, 22, 22, 22, 23, 23, 24, 24, 24, 25, 25, 26, 26, 27, 26, 27, 28, 28, 28,
29, 30, 30, 31, 32, 32, 33, 34, 35, 36, 36, 37, 39, 39, 40, 41, 42, 43, 44, 45,
46, 47, 48, 49, 50, 51, 53, 54, 55, 56, 57, 59, 59, 61, 62, 63, 64, 66, 68, 68,
69, 70, 72, 74, 74, 76, 78, 79, 79, 81, 82, 84, 84, 86, 87, 89, 90, 91, 93, 94,
95, 96, 96, 98, 100, 101, 102, 102, 103, 105, 106, 107, 108, 108, 109, 110, 111,
113, 112, 112, 114, 114, 115, 116, 117, 117, 117, 118, 118, 118, 119, 119, 119,
119, 118, 119, 120, 119, 118, 118, 119, 117, 117, 116, 115, 115, 114, 113, 112,
112, 111, 109, 108, 107, 105, 104, 103, 101, 100, 98, 97, 95, 92, 91, 89, 87,
85, 83, 81, 78, 77, 73, 72, 68, 66, 63, 61, 59, 56, 53, 50, 48, 46, 42, 40, 37,
35, 32, 29, 26, 24, 20, 18, 15, 12, 9, 7, 4, 1, 0, -4, -6, -9, -10, -14, -16,
-18, -21, -23, -25, -27, -29, -31, -34, -35, -38, -39, -41, -43, -46, -46, -49,
-50, -51, -52, -54, -56, -57, -59, -60, -61, -62, -63, -64, -65, -66, -67, -67,
-68, -70, -70, -71, -71, -71, -73, -74, -74, -74, -74, -74, -75, -75, -75, -76,
-75, -75, -76, -76, -75, -75, -75, -75, -75, -75, -74, -74, -74, -73, -73, -72,
-72, -72, -71, -71, -71, -70, -70, -69, -68, -68, -68, -66, -66, -66, -65, -65,
-64, -64, -63, -63, -62, -61, -60, -60, -59, -59, -59, -58, -58, -58, -57, -56,
-56, -56, -55, -55, -55, -54, -53, -54, -53, -53, -53, -53, -52, -52, -52, -52,
-53, -52, -53, -52, -53, -52, -53, -53, -52, -53, -53, -54, -54, -53, -54, -54,
-54, -54, -55, -56, -56, -56, -56, -56, -57, -57, -57, -58, -59, -59, -60, -60,
-60, -61, -61, -61, -62, -63, -63, -64, -64, -63, -63, -65, -65, -65, -65, -66,
-66, -67, -67, -66, -67, -67, -68, -67, -68, -68, -68, -68, -68, -68, -68, -68,
-68, -67, -67, -68, -68, -67, -66, -67, -67, -66, -65, -65, -65, -64, -64, -64,
-63, -62, -62, -61, -60, -60, -59, -58, -58, -57, -56, -55, -55, -53, -53, -52,
-51, -49, -48, -48, -47, -46, -45, -44, -43, -42, -40, -39, -38, -37, -36, -35,
-33, -32, -31, -30, -29, -27, -26, -25, -23, -23, -22, -20, -18, -18, -17, -16,
-14, -13, -12, -11, -9, -9, -7, -7, -5, -5, -3, -3, -1, 1, };