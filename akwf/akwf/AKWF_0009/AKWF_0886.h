#define DATA_LENGTH 512
#define DATA AKWF_0886

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 8, 11, 14, 17, 20, 22, 24,
27, 30, 33, 36, 39, 41, 45, 47, 49, 52, 55, 58, 60, 62, 64, 67, 69, 72, 73, 75,
77, 80, 81, 84, 86, 88, 89, 91, 92, 95, 96, 97, 99, 100, 101, 103, 103, 106,
106, 108, 108, 110, 111, 112, 113, 114, 114, 115, 116, 117, 117, 117, 117, 119,
119, 119, 120, 119, 120, 118, 119, 117, 117, 117, 116, 115, 114, 114, 112, 110,
109, 107, 105, 103, 102, 100, 97, 95, 92, 89, 88, 84, 82, 78, 76, 72, 69, 65,
63, 59, 56, 52, 48, 45, 40, 36, 33, 29, 25, 21, 17, 13, 10, 5, 2, -2, -7, -10,
-14, -18, -21, -25, -28, -32, -35, -38, -42, -44, -48, -51, -54, -57, -61, -63,
-66, -69, -72, -74, -76, -78, -80, -82, -84, -87, -89, -90, -92, -93, -96, -97,
-97, -98, -100, -100, -101, -100, -102, -102, -102, -101, -101, -101, -99, -99,
-97, -98, -95, -94, -93, -91, -89, -88, -86, -83, -81, -79, -76, -73, -70, -68,
-65, -61, -58, -55, -52, -49, -45, -41, -38, -34, -30, -26, -22, -19, -14, -11,
-8, -4, 1, 4, 8, 11, 15, 19, 22, 25, 29, 32, 36, 39, 41, 46, 48, 52, 54, 57, 59,
63, 65, 68, 71, 73, 76, 78, 80, 82, 84, 87, 88, 90, 92, 94, 96, 98, 99, 100,
103, 104, 105, 107, 107, 109, 110, 111, 113, 113, 113, 114, 116, 116, 116, 117,
116, 117, 117, 118, 117, 117, 116, 116, 116, 115, 114, 113, 111, 111, 108, 107,
105, 103, 101, 100, 98, 96, 92, 90, 87, 84, 82, 78, 77, 73, 69, 66, 64, 59, 56,
53, 49, 45, 41, 38, 33, 30, 26, 21, 18, 14, 11, 7, 3, 0, -4, -8, -12, -15, -18,
-22, -25, -28, -29, -33, -35, -38, -40, -42, -43, -46, -47, -48, -49, -51, -51,
-52, -52, -53, -53, -54, -54, -54, -55, -54, -54, -54, -54, -53, -53, -53, -52,
-51, -51, -51, -50, -51, -49, -49, -50, -49, -50, -50, -50, -49, -50, -50, -51,
-51, -53, -52, -53, -55, -55, -57, -57, -58, -60, -60, -61, -63, -64, -65, -67,
-67, -69, -71, -72, -73, -74, -76, -78, -78, -81, -82, -84, -84, -86, -87, -89,
-90, -91, -92, -93, -95, -96, -97, -98, -100, -100, -102, -101, -103, -103,
-104, -106, -106, -107, -107, -108, -107, -107, -108, -108, -108, -107, -107,
-108, -106, -105, -104, -103, -103, -101, -100, -99, -97, -95, -94, -91, -89,
-88, -85, -83, -81, -78, -77, -74, -71, -69, -66, -65, -62, -59, -57, -56, -53,
-51, -49, -48, -46, -45, -42, -41, -39, -38, -37, -36, -35, -33, -34, -34, -33,
-33, -32, -33, -32, -33, -33, -33, -33, -34, -34, -34, -35, -35, -35, -36, -37,
-37, -37, -38, -39, -38, -40, -39, -38, -39, -40, -39, -39, -39, -37, -37, -36,
-36, -36, -35, -33, -31, -30, -28, -27, -26, -25, -22, -21, -18, -17, -14, -12,
-9, -7, -4, -3, };