#define DATA_LENGTH 512
#define DATA AKWF_0854

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 6, 7, 9, 10, 12, 14, 15,
17, 17, 19, 20, 21, 23, 23, 26, 26, 27, 29, 29, 31, 32, 33, 35, 36, 37, 39, 39,
40, 43, 43, 45, 45, 47, 48, 50, 50, 51, 53, 54, 55, 57, 58, 58, 59, 61, 62, 64,
64, 65, 66, 68, 69, 69, 70, 71, 73, 74, 74, 75, 76, 77, 78, 79, 81, 82, 81, 83,
83, 85, 86, 87, 87, 88, 90, 90, 91, 92, 93, 94, 93, 94, 95, 96, 97, 98, 98, 99,
99, 101, 101, 102, 102, 103, 104, 105, 104, 106, 106, 107, 107, 108, 108, 108,
109, 109, 110, 111, 111, 112, 112, 112, 113, 113, 113, 114, 114, 115, 115, 116,
115, 115, 115, 117, 116, 117, 117, 118, 117, 118, 118, 118, 118, 119, 118, 118,
119, 119, 119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 118, 118, 118, 117,
117, 115, 114, 114, 113, 113, 112, 111, 111, 110, 110, 109, 108, 106, 106, 106,
104, 103, 103, 101, 100, 100, 98, 97, 97, 95, 95, 93, 92, 91, 90, 90, 89, 87,
85, 84, 84, 82, 81, 79, 78, 78, 76, 75, 74, 73, 71, 71, 69, 68, 67, 65, 65, 62,
62, 60, 59, 58, 57, 55, 54, 52, 51, 50, 48, 47, 46, 44, 44, 42, 40, 39, 38, 37,
36, 35, 33, 31, 30, 28, 27, 26, 25, 23, 22, 20, 19, 18, 16, 15, 14, 12, 11, 10,
9, 7, 6, 4, 3, 2, 0, -1, -2, -4, -5, -6, -8, -9, -10, -12, -13, -15, -16, -18,
-18, -19, -21, -22, -24, -25, -26, -28, -29, -30, -31, -32, -33, -35, -36, -37,
-39, -40, -41, -42, -44, -44, -46, -48, -49, -49, -51, -52, -53, -55, -55, -57,
-58, -59, -59, -60, -61, -63, -64, -65, -66, -68, -68, -69, -71, -71, -72, -74,
-74, -75, -77, -77, -78, -79, -80, -81, -82, -83, -84, -85, -85, -86, -87, -88,
-89, -90, -90, -92, -93, -93, -94, -94, -95, -97, -97, -97, -98, -99, -99, -100,
-101, -101, -103, -103, -104, -104, -104, -106, -106, -107, -107, -108, -108,
-109, -110, -109, -110, -111, -111, -111, -112, -112, -113, -113, -114, -114,
-114, -115, -115, -115, -115, -116, -116, -117, -117, -117, -117, -117, -118,
-118, -117, -118, -118, -118, -119, -119, -119, -120, -118, -119, -119, -119,
-119, -120, -119, -119, -119, -118, -118, -117, -117, -117, -116, -115, -115,
-113, -113, -113, -112, -111, -110, -110, -109, -108, -107, -106, -105, -105,
-104, -103, -102, -102, -100, -99, -98, -97, -95, -95, -95, -93, -92, -91, -90,
-88, -88, -87, -86, -84, -84, -82, -81, -80, -78, -77, -76, -75, -74, -73, -72,
-70, -69, -67, -67, -65, -65, -63, -62, -61, -59, -57, -57, -55, -54, -53, -51,
-50, -48, -47, -46, -44, -43, -41, -40, -40, -39, -37, -35, -34, -32, -32, -29,
-28, -27, -26, -25, -23, -22, -20, -19, -18, -16, -14, -14, -12, -10, -10, -9,
-7, -5, -4, -2, -1, -1, };