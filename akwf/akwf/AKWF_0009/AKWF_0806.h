#define DATA_LENGTH 512
#define DATA AKWF_0806

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 15, 20, 24, 28, 31, 34, 35, 38,
40, 40, 41, 42, 41, 41, 41, 40, 40, 39, 37, 36, 35, 34, 33, 32, 30, 29, 28, 26,
24, 22, 20, 20, 18, 17, 15, 14, 12, 9, 8, 7, 7, 5, 3, 2, 1, 0, -2, -2, -3, -4,
-6, -6, -6, -8, -9, -9, -9, -10, -10, -12, -11, -11, -13, -13, -13, -14, -14,
-14, -14, -14, -14, -14, -14, -14, -14, -14, -14, -14, -14, -14, -14, -13, -14,
-13, -13, -13, -13, -13, -12, -12, -11, -11, -11, -11, -10, -10, -9, -9, -9, -8,
-8, -8, -7, -7, -6, -7, -5, -7, -6, -6, -5, -5, -5, -4, -4, -3, -3, -3, -2, -1,
-2, -1, 0, 0, 0, 0, 1, 0, 2, 1, 1, 1, 0, 1, 2, 1, 2, 3, 3, 3, 3, 4, 4, 4, 4, 4,
4, 3, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 4, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3,
3, 3, 4, 4, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 2, 3, 3, 2, 2, 3, 2, 2, 2, 1, 1, 1,
1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 1, 0, 1, 1, -1, 0, 0, -1, 0, -1, 0, 0, -1, 0,
0, 0, -1, -1, -1, -1, 0, -1, 0, -1, -1, -1, -1, 0, -1, -1, 0, -1, -1, 0, -1, 0,
-1, -1, 0, -1, -1, 0, -1, -1, -1, -1, 0, -1, 0, -1, 0, 0, 0, 0, -1, -1, -1, -1,
-1, -2, -2, -6, -26, -69, -112, -119, -99, -75, -60, -50, -41, -32, -22, -14,
-7, -1, 4, 10, 14, 18, 22, 25, 28, 30, 32, 33, 35, 36, 36, 37, 38, 37, 37, 38,
37, 36, 35, 35, 34, 34, 32, 32, 31, 29, 27, 27, 25, 23, 23, 22, 21, 19, 18, 16,
16, 15, 13, 11, 11, 9, 8, 7, 7, 5, 4, 3, 3, 1, 1, 0, -2, -2, -2, -3, -3, -4, -5,
-6, -7, -7, -7, -8, -7, -7, -8, -9, -9, -10, -10, -10, -9, -11, -10, -10, -11,
-11, -10, -11, -10, -10, -10, -11, -10, -11, -10, -10, -10, -9, -9, -9, -9, -9,
-9, -7, -4, -2, -6, -9, -9, -8, -7, -8, -7, -7, -7, -7, -6, -5, -5, -5, -5, -4,
-4, -4, -5, -4, -3, -3, -3, -3, -3, -2, -2, -2, -2, -2, -1, -1, -1, -1, 0, 0,
-1, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 2, 2, 1, 1, 1, 1, 2, 1, 2, 2, 1, 2, 2, 2,
2, 3, 3, 2, 2, 1, 2, 2, 2, 2, 1, 1, 2, 2, 2, 1, 1, 1, 2, 2, 2, 1, 1, 2, 1, 1, 1,
1, 1, 2, 1, 2, 1, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 0, -1, -1, -2, -9, -37, -77,
-105, -105, -88, -68, -50, -39, -30, -20, -11, -2, };