#define DATA_LENGTH 512
#define DATA AKWF_0850

const PROGMEM int8_t DATA[DATA_LENGTH] = {-39, -73, 7, 127, 108, 127, 112, 124,
113, 125, 112, 127, 95, -73, -60, -65, -63, -64, -64, -63, -64, -63, -65, -63,
-65, -64, -64, -64, -65, -64, -64, -65, -63, -64, -64, -1, 5, 2, 5, 2, 5, 2, 4,
3, 4, 3, 4, 3, 4, 3, 4, 4, 4, 4, 3, 4, 2, 4, 2, 8, 28, 25, 26, 25, 26, 27, 25,
27, 25, 26, 26, 27, 24, 28, 9, 1, 5, 3, 5, 2, 4, 4, 3, 3, 4, 3, 4, 3, 4, 3, 3,
4, 4, 4, 4, 3, 3, 4, 3, 5, 4, 5, -2, -6, -5, -5, -6, -2, 5, 3, 4, 4, 4, 3, 3, 4,
4, 4, 3, 4, 3, 5, 1, 10, 33, 30, 31, 30, 30, 31, 30, 30, 30, 31, 30, 31, 31, 31,
31, 30, 30, 31, 30, 30, 30, 29, 32, 21, 0, 5, 2, 4, 3, 4, 4, 3, 4, 3, 5, 1, 6,
-14, -23, -20, -21, -20, -20, -20, -20, -20, -21, -20, -23, -2, 6, 2, 5, 3, 4,
3, 4, 4, 3, 2, 4, 3, 4, 3, 4, 4, 4, 3, 3, 3, 3, 4, 4, 3, 5, 14, 12, 13, 12, 13,
11, 2, 4, 3, 3, 3, 4, 3, 4, 4, 4, 3, 3, 3, 4, 3, 4, 3, 3, 4, 1, 18, 22, 21, 17,
0, 5, 1, 4, 3, 4, 3, 3, 4, 1, 7, -2, 16, -77, -123, -106, -117, -108, -116,
-110, -115, -109, -113, -111, -113, -111, -113, -111, -113, -111, -114, -111,
-113, -111, -113, -110, -112, -112, -6, 8, 0, 7, 1, 8, 0, 7, 0, 8, -1, 10, -6,
29, 91, 83, 86, 85, 84, 85, 85, 85, 85, 86, 84, 85, 85, 84, 85, 84, 85, 83, 87,
82, 88, 80, 94, 51, -6, 9, 1, 5, 2, 4, 3, 4, 3, 3, 3, 4, 4, 3, 4, 3, 4, 3, 4, 4,
3, 3, 3, 3, 3, 3, 4, 4, 4, 2, 6, -31, -39, -34, -38, -36, -37, -36, -38, -36,
-38, -36, -38, -36, -37, -37, -38, -36, -37, -36, -37, -36, -38, -36, -38, -34,
-41, -21, 9, 1, 5, 3, 4, 3, 3, 3, 4, 3, 3, 3, 3, 4, 3, 4, 3, 4, 3, 3, 13, 14,
14, 15, 14, 14, 14, 14, 16, 9, 2, 4, 3, 4, 4, 3, 4, 2, 6, -2, -18, -15, -15,
-15, -16, -15, -15, -16, -16, -15, -15, -15, -15, -16, -14, -16, -15, -16, -15,
-16, -13, -17, -10, 5, 3, 4, 4, 4, 3, 3, 4, 3, 4, 3, 3, 4, 3, 4, 2, 4, 2, 14,
25, 22, 23, 22, 24, 22, 23, 22, 23, 22, 23, 21, 23, 22, 4, 3, 4, 4, 4, 3, 3, 4,
4, 3, 4, 4, 3, 3, 3, 3, 3, 4, 4, 4, 4, 4, 4, 3, 3, 4, 4, -3, -5, -5, -5, -7, 0,
4, 3, 4, 3, 3, 4, 4, 4, 4, 4, 3, 4, 4, 4, 4, 3, 4, 3, 3, 4, };