#define DATA_LENGTH 512
#define DATA AKWF_0818

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 27, 39, 52, 65, 77, 87, 95, 102,
107, 109, 110, 109, 106, 102, 97, 88, 78, 66, 54, 42, 30, 19, 7, -4, -13, -22,
-30, -36, -41, -46, -50, -52, -54, -54, -54, -54, -54, -53, -52, -50, -48, -46,
-45, -43, -41, -39, -36, -34, -32, -31, -28, -26, -24, -22, -20, -18, -17, -15,
-14, -12, -11, -8, -8, -7, -6, -4, -3, -3, -1, 0, 1, 2, 3, 3, 4, 5, 5, 6, 6, 7,
7, 7, 8, 9, 9, 12, 18, 24, 30, 36, 41, 47, 52, 56, 59, 62, 64, 64, 63, 61, 59,
57, 52, 47, 35, 19, 2, -14, -30, -46, -60, -74, -87, -98, -107, -113, -117,
-120, -119, -117, -113, -109, -102, -90, -77, -64, -51, -37, -25, -11, 1, 12,
22, 33, 40, 47, 52, 56, 59, 61, 63, 63, 63, 62, 61, 59, 58, 56, 54, 51, 49, 48,
45, 42, 40, 36, 34, 32, 30, 28, 25, 23, 21, 18, 17, 15, 13, 11, 9, 7, 6, 5, 3,
3, 1, -1, -1, -2, -3, -4, -5, -5, -7, -7, -7, -9, -8, -9, -10, -10, -11, -10,
-10, -11, -11, -11, -11, -12, -12, -12, -12, -12, -12, -12, -11, -11, -12, -11,
-11, -11, -11, -11, -10, -9, -9, -9, -9, -8, -8, -9, -7, -8, -7, -7, -7, -6, -6,
-6, -5, -6, -5, -5, -5, -4, -3, -4, -3, -3, -3, -3, -2, -2, -2, -2, -2, -2, -2,
-2, 0, 0, -1, 0, 0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 2, 2, 2, 1, 2, 2, 2,
2, 2, 2, 2, 1, 2, 2, 2, 3, 3, 2, 2, 2, 2, 2, 1, 3, 2, 1, 2, 2, 1, 1, 2, 1, 2, 1,
1, 1, 2, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 0,
0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 1, 0, -1, 0, 0, 0,
-1, 0, 0, -1, -1, 0, 0, 0, 0, 0, -1, -1, -1, 0, 0, 0, 0, 0, 0, -1, 0, -1, -1, 1,
0, 1, 0, 0, 0, -1, -1, 0, 0, -1, -1, 0, 0, 0, -1, 0, -1, 0, 1, 0, 0, -1, 0, 0,
1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
0, 0, 0, 0, 0, 0, 1, 1, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0,
0, -1, 1, 0, -1, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, -1, 0, -1, 0, 0, 0, 0, 0,
0, -1, 1, -1, 0, 0, 0, 0, 0, -1, 1, -2, -6, -12, -17, -21, -26, -32, -36, -39,
-43, -46, -47, -47, -48, -46, -45, -42, -41, -35, -27, -14, -1, };