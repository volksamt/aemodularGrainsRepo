#define DATA_LENGTH 512
#define DATA AKWF_0843

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 12, 16, 19, 23, 25, 30, 32,
35, 39, 42, 46, 49, 51, 54, 58, 60, 62, 67, 68, 71, 74, 76, 79, 81, 84, 86, 87,
89, 92, 95, 95, 98, 100, 102, 104, 105, 106, 108, 109, 110, 111, 112, 113, 114,
115, 116, 117, 118, 118, 118, 119, 118, 119, 120, 119, 118, 116, 115, 114, 112,
110, 109, 107, 105, 102, 99, 98, 95, 92, 89, 87, 84, 82, 79, 76, 74, 71, 68, 65,
62, 59, 56, 53, 50, 47, 44, 40, 37, 35, 31, 28, 25, 22, 19, 16, 12, 9, 6, 4, -1,
-3, -7, -8, -11, -15, -19, -21, -24, -27, -30, -33, -35, -37, -40, -43, -46,
-48, -50, -53, -56, -58, -60, -63, -64, -66, -69, -72, -73, -75, -78, -79, -80,
-82, -84, -86, -87, -89, -89, -91, -92, -93, -95, -95, -96, -97, -98, -99, -99,
-100, -100, -100, -101, -101, -102, -102, -102, -102, -102, -100, -99, -98, -96,
-95, -93, -91, -89, -87, -85, -83, -80, -77, -76, -73, -70, -68, -66, -63, -60,
-58, -55, -52, -50, -47, -44, -41, -39, -35, -33, -31, -28, -26, -22, -19, -18,
-14, -12, -9, -6, -4, -1, 1, 4, 5, 8, 10, 12, 15, 17, 20, 21, 24, 25, 27, 30,
30, 33, 34, 35, 37, 39, 40, 41, 43, 44, 45, 46, 48, 48, 49, 49, 50, 51, 51, 51,
52, 53, 52, 53, 53, 51, 50, 48, 47, 45, 44, 42, 40, 38, 36, 34, 32, 29, 27, 24,
23, 20, 17, 16, 13, 10, 8, 5, 4, 1, -2, -4, -6, -9, -11, -13, -15, -17, -19,
-21, -23, -25, -26, -28, -30, -32, -33, -34, -35, -36, -37, -38, -38, -40, -40,
-41, -42, -42, -41, -42, -42, -41, -41, -40, -38, -36, -34, -33, -31, -28, -27,
-24, -23, -20, -17, -15, -12, -9, -8, -6, -2, 0, 3, 5, 8, 11, 15, 16, 19, 22,
25, 29, 31, 34, 37, 38, 41, 44, 47, 49, 53, 55, 57, 60, 62, 65, 67, 70, 72, 75,
76, 78, 80, 82, 84, 87, 88, 90, 92, 93, 95, 96, 98, 99, 100, 101, 103, 104, 105,
105, 107, 108, 108, 109, 108, 110, 110, 110, 110, 110, 110, 109, 107, 106, 104,
102, 100, 97, 95, 93, 91, 88, 85, 83, 80, 76, 74, 71, 68, 65, 61, 59, 55, 51,
49, 45, 41, 38, 35, 32, 27, 25, 21, 18, 15, 11, 7, 4, 0, -3, -6, -10, -13, -16,
-20, -23, -26, -29, -33, -36, -39, -41, -46, -48, -51, -55, -57, -60, -62, -65,
-68, -71, -72, -76, -78, -80, -82, -85, -88, -89, -91, -93, -94, -97, -98, -100,
-101, -104, -104, -106, -107, -108, -109, -110, -111, -112, -112, -113, -114,
-115, -115, -114, -115, -116, -115, -114, -113, -112, -109, -108, -107, -105,
-102, -100, -97, -94, -91, -90, -87, -83, -81, -78, -75, -71, -69, -65, -63,
-59, -55, -52, -50, -46, -42, -39, -36, -31, -28, -25, -22, -19, -14, -10, -8,
-4, -1, };