#define DATA_LENGTH 512
#define DATA AKWF_0862

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 12, 15, 19, 22, 24, 26, 29, 32,
35, 38, 40, 43, 45, 47, 48, 50, 51, 52, 54, 53, 54, 55, 56, 57, 58, 57, 57, 58,
57, 53, 33, 15, 9, 8, 10, 9, 9, 9, 11, 13, 15, 15, 17, 19, 21, 23, 26, 28, 31,
34, 37, 40, 44, 48, 52, 53, 54, 56, 58, 59, 61, 63, 65, 67, 69, 71, 74, 76, 79,
83, 85, 87, 79, 58, 46, 45, 47, 49, 50, 51, 53, 56, 53, 26, 11, 14, 5, -5, -13,
-18, -25, -32, -39, -48, -53, -54, -62, -67, -71, -75, -78, -81, -83, -84, -85,
-86, -87, -85, -85, -85, -84, -82, -80, -79, -78, -92, -111, -118, -118, -115,
-113, -111, -109, -106, -101, -98, -93, -90, -85, -82, -77, -82, -88, -80, -80,
-79, -77, -76, -74, -71, -69, -67, -64, -62, -60, -57, -54, -52, -48, -47, -44,
-43, -40, -39, -36, -35, -34, -37, -56, -72, -76, -73, -72, -71, -69, -67, -63,
-61, -57, -50, -46, -43, -39, -34, -30, -25, -21, -17, -12, -7, -3, 2, 6, 9, 10,
12, 15, 17, 18, 21, 24, 26, 28, 32, 34, 36, 38, 41, 43, 45, 37, 16, 4, 2, 4, 6,
7, 8, 10, 11, 14, 15, 18, 19, 21, 23, 25, 27, 29, 32, 34, 38, 43, 47, 50, 54,
55, 57, 59, 61, 63, 63, 65, 66, 68, 68, 69, 70, 70, 70, 71, 71, 70, 54, 33, 25,
22, 24, 22, 20, 20, 22, 23, 23, 24, 25, 25, 26, 26, 27, 27, 27, 29, 29, 30, 32,
32, 32, 33, 33, 33, 33, 31, 31, 31, 29, 29, 27, 25, 24, 23, 22, 20, 19, 16, 9,
-15, -33, -41, -43, -43, -45, -47, -49, -48, -48, -48, -49, -49, -50, -50, -49,
-49, -48, -48, -46, -45, -43, -42, -40, -39, -38, -39, -39, -41, -41, -41, -41,
-40, -41, -40, -39, -39, -38, -38, -37, -36, -35, -49, -71, -83, -87, -85, -84,
-85, -86, -84, -82, -79, -78, -75, -73, -67, -62, -57, -48, -40, -31, -23, -13,
-3, 7, 14, 22, 28, 34, 37, 42, 45, 48, 51, 53, 56, 56, 57, 58, 59, 60, 60, 59,
57, 39, 19, 10, 7, 9, 7, 4, 4, 4, 3, 4, 4, 4, 5, 4, 3, 7, 9, 9, 10, 11, 14, 16,
16, 17, 17, 18, 17, 18, 16, 15, 15, 14, 13, 12, 11, 9, 7, 6, 5, 3, 1, -8, -31,
-49, -55, -56, -57, -59, -61, -61, -61, -61, -60, -61, -60, -60, -60, -59, -57,
-56, -55, -53, -51, -49, -46, -44, -41, -40, -39, -40, -40, -39, -38, -37, -36,
-35, -33, -32, -30, -29, -28, -24, -23, -22, -34, -55, -66, -68, -65, -64, -64,
-63, -61, -59, -57, -56, -53, -52, -49, -46, -45, -42, -40, -37, -34, -30, -24,
-20, -16, -11, -9, -6, -4, -2, 1, 4, 6, 9, 11, 12, 14, 16, 18, 20, 21, 24, 23,
6, -13, -18, -19, -17, -15, -15, -15, -11, -10, -5, };