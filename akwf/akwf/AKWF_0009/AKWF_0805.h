#define DATA_LENGTH 512
#define DATA AKWF_0805

const PROGMEM int8_t DATA[DATA_LENGTH] = {13, 31, 46, 59, 70, 81, 90, 98, 103,
108, 112, 115, 117, 119, 119, 119, 119, 118, 116, 114, 112, 108, 106, 103, 100,
100, 102, 105, 108, 109, 110, 111, 110, 109, 108, 105, 102, 100, 97, 91, 88, 82,
78, 73, 68, 62, 56, 51, 45, 39, 33, 28, 22, 16, 10, 5, -1, -6, -10, -16, -21,
-25, -30, -34, -39, -43, -46, -50, -54, -57, -60, -63, -66, -68, -71, -73, -75,
-77, -78, -79, -81, -82, -83, -84, -84, -84, -85, -84, -85, -84, -84, -83, -82,
-81, -81, -80, -79, -77, -76, -74, -73, -72, -70, -69, -66, -65, -63, -61, -59,
-58, -54, -53, -50, -48, -47, -44, -42, -41, -38, -36, -34, -32, -30, -28, -25,
-23, -22, -19, -18, -16, -14, -11, -11, -9, -7, -6, -4, -2, -1, 1, 2, 4, 5, 6,
8, 9, 11, 11, 13, 14, 15, 16, 17, 18, 19, 20, 20, 21, 22, 22, 23, 23, 24, 23,
24, 25, 25, 25, 26, 26, 26, 26, 26, 27, 26, 27, 27, 26, 26, 26, 26, 26, 27, 25,
26, 25, 25, 25, 24, 25, 24, 24, 24, 23, 23, 22, 22, 22, 21, 22, 21, 20, 20, 20,
19, 20, 18, 18, 18, 17, 17, 16, 17, 16, 16, 16, 15, 15, 15, 15, 14, 15, 14, 14,
14, 12, 13, 12, 13, 12, 12, 12, 13, 14, 13, 16, 20, 22, 24, 24, 23, 23, 22, 22,
21, 21, 20, 20, 19, 18, 17, 16, 14, 12, 11, 8, 7, 5, 2, 1, -2, -5, -7, -9, -10,
-12, -14, -16, -18, -19, -20, -21, -23, -24, -24, -26, -26, -27, -26, -27, -27,
-27, -28, -27, -26, -27, -26, -26, -25, -24, -23, -23, -22, -21, -20, -19, -18,
-17, -16, -15, -13, -12, -11, -10, -9, -8, -7, -6, -4, -4, -3, -1, -1, 1, 2, 3,
4, 5, 6, 7, 7, 8, 9, 9, 10, 11, 12, 11, 12, 13, 13, 14, 14, 14, 16, 16, 15, 15,
16, 16, 16, 16, 16, 17, 16, 17, 16, 16, 16, 16, 16, 16, 15, 15, 14, 14, 14, 14,
14, 13, 12, 12, 13, 12, 11, 11, 11, 10, 10, 10, 9, 8, 8, 7, 6, 7, 6, 6, 5, 5, 4,
4, 3, 3, 2, 2, 2, 1, 1, 1, 0, 0, -2, -1, -1, -3, -2, -3, -2, -4, -3, -4, -4, -4,
-5, -5, -5, -5, -5, -6, -7, -6, -6, -6, -7, -6, -7, -7, -7, -7, -7, -8, -7, -8,
-7, -7, -8, -8, -8, -8, -8, -8, -8, -8, -7, -8, -8, -8, -7, -8, -7, -8, -7, -8,
-8, -7, -7, -7, -7, -7, -7, -7, -7, -8, -7, -7, -7, -7, -7, -6, -6, -6, -6, -7,
-6, -7, -5, -6, -5, -5, -5, -6, -5, -6, -5, -4, -5, -4, -5, -5, -7, -11, -16,
-20, -24, -26, -30, -34, -40, -51, -71, -91, -102, -106, -107, -108, -107, -108,
-107, -106, -105, -103, -100, -95, -90, -83, -74, -66, -55, -39, -20, -2, };