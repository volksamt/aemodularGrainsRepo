#define DATA_LENGTH 512
#define DATA AKWF_0807

const PROGMEM int8_t DATA[DATA_LENGTH] = {19, 52, 77, 97, 109, 117, 119, 117,
111, 102, 91, 79, 65, 50, 35, 22, 8, -4, -16, -27, -37, -45, -52, -58, -62, -66,
-68, -70, -69, -69, -68, -68, -68, -68, -66, -64, -59, -55, -52, -47, -42, -38,
-33, -29, -25, -21, -17, -13, -9, -7, -3, -1, 1, 4, 6, 8, 9, 10, 11, 11, 13, 14,
14, 17, 19, 21, 23, 23, 24, 23, 22, 22, 20, 19, 18, 17, 15, 14, 13, 12, 12, 9,
9, 8, 6, 5, 4, 4, 3, 3, 2, 2, 1, 1, 0, -2, -4, -7, -8, -9, -10, -9, -10, -8, -7,
-6, -6, -5, -4, -3, -2, -2, 0, 0, 1, 2, 3, 4, 4, 4, 5, 6, 6, 6, 7, 7, 7, 10, 12,
15, 16, 15, 17, 16, 16, 15, 14, 20, 24, 26, 27, 27, 27, 25, 24, 22, 19, 17, 14,
11, 8, 5, 3, 1, -1, -3, -5, -7, -8, -13, -16, -19, -21, -23, -24, -25, -26, -24,
-24, -24, -24, -23, -21, -20, -19, -18, -17, -15, -15, -14, -12, -12, -10, -9,
-8, -7, -6, -5, -6, -5, -3, 0, 2, 5, 7, 8, 8, 9, 9, 9, 9, 8, 8, 7, 6, 6, 5, 5,
4, 3, 4, 2, 2, 1, 1, 0, 1, 0, 1, 7, 13, 17, 19, 18, 15, 13, 10, 9, 6, 5, 3, 2,
0, -1, -3, -3, -5, -5, -5, -6, -7, -7, -7, -8, -8, -8, -8, -8, -8, -8, -7, -8,
-7, -8, -6, -20, -56, -83, -101, -112, -118, -118, -115, -110, -101, -91, -81,
-69, -58, -47, -36, -25, -15, -5, 4, 13, 21, 28, 34, 41, 46, 51, 55, 59, 62, 65,
68, 67, 65, 65, 65, 64, 65, 70, 77, 80, 83, 84, 83, 83, 81, 78, 76, 72, 70, 66,
63, 58, 55, 51, 46, 43, 39, 35, 32, 29, 24, 22, 19, 18, 18, 16, 16, 13, 11, 7,
5, 2, 0, -2, -6, -9, -11, -13, -15, -17, -19, -21, -22, -24, -26, -27, -28, -29,
-30, -31, -31, -32, -33, -32, -34, -35, -39, -40, -41, -42, -42, -41, -40, -39,
-38, -36, -36, -33, -32, -31, -29, -28, -27, -24, -23, -22, -20, -15, -7, -3, 2,
4, 6, 7, 7, 7, 7, 10, 10, 11, 11, 10, 9, 8, 7, 5, 3, 1, 0, -1, -3, -5, -6, -7,
-8, -10, -10, -11, -11, -12, -13, -13, -12, -13, -14, -14, -13, -13, -13, -15,
-17, -19, -19, -19, -19, -19, -17, -17, -15, -14, -12, -10, -9, -8, -6, -5, -4,
-3, -1, 0, 1, 3, 3, 4, 5, 6, 6, 8, 8, 8, 10, 13, 15, 18, 18, 19, 21, 20, 19, 18,
19, 18, 17, 16, 14, 14, 13, 11, 11, 10, 9, 8, 7, 6, 6, 5, 4, 3, 4, 3, 2, 1, 1,
-2, -5, -7, -8, -8, -9, -9, -10, -9, -8, -8, -7, -6, -5, -4, -3, -2, -2, -1, 0,
0, 1, 1, 3, 2, 2, 3, -21, -53, -59, -54, -36, -9, };