#define DATA_LENGTH 512
#define DATA AKWF_0835

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 10, 13, 17, 21, 23, 27, 30, 34,
35, 39, 42, 45, 47, 50, 53, 56, 59, 61, 64, 67, 69, 72, 74, 76, 79, 80, 83, 85,
88, 90, 92, 94, 96, 97, 99, 101, 102, 104, 106, 108, 109, 111, 113, 114, 116,
117, 119, 120, 119, 120, 119, 119, 118, 117, 117, 116, 116, 116, 116, 114, 113,
113, 112, 112, 111, 110, 110, 109, 108, 107, 107, 106, 105, 104, 103, 103, 102,
101, 100, 100, 99, 98, 97, 96, 95, 95, 94, 93, 92, 92, 91, 90, 90, 89, 88, 88,
87, 86, 86, 84, 84, 83, 83, 82, 81, 80, 80, 79, 78, 78, 77, 77, 76, 75, 75, 75,
74, 73, 73, 72, 72, 71, 70, 69, 70, 69, 68, 68, 67, 67, 67, 65, 65, 65, 64, 64,
63, 63, 62, 62, 62, 62, 61, 60, 61, 60, 60, 59, 59, 58, 58, 58, 58, 57, 56, 55,
54, 53, 53, 51, 51, 50, 49, 48, 47, 46, 45, 44, 43, 42, 41, 40, 39, 39, 37, 37,
35, 35, 33, 33, 32, 31, 31, 29, 29, 28, 27, 27, 26, 25, 24, 24, 23, 22, 22, 21,
20, 20, 19, 19, 18, 18, 17, 16, 15, 15, 15, 14, 13, 12, 13, 12, 11, 12, 11, 11,
9, 9, 9, 9, 7, 7, 6, 4, 4, 4, 2, 1, 1, -1, 0, -2, -2, -3, -4, -5, -5, -7, -8,
-9, -9, -10, -11, -11, -12, -13, -14, -14, -15, -16, -17, -17, -18, -18, -19,
-20, -20, -22, -22, -23, -22, -23, -24, -25, -25, -26, -27, -27, -27, -27, -28,
-29, -29, -29, -30, -30, -31, -31, -32, -32, -33, -33, -33, -34, -34, -35, -35,
-36, -36, -36, -36, -37, -38, -37, -38, -38, -39, -39, -39, -39, -40, -40, -40,
-41, -41, -41, -42, -41, -42, -42, -43, -43, -43, -44, -43, -44, -44, -45, -45,
-45, -45, -46, -46, -45, -46, -46, -46, -47, -47, -47, -48, -48, -47, -48, -48,
-48, -48, -48, -49, -49, -50, -49, -49, -50, -50, -49, -50, -51, -51, -50, -50,
-50, -51, -51, -51, -51, -51, -52, -51, -51, -51, -52, -52, -52, -51, -53, -52,
-52, -52, -52, -52, -53, -53, -53, -53, -53, -53, -53, -54, -54, -53, -54, -54,
-53, -54, -54, -54, -54, -54, -54, -55, -55, -54, -55, -54, -55, -55, -54, -55,
-55, -55, -55, -54, -55, -54, -55, -54, -55, -54, -54, -54, -54, -53, -54, -52,
-53, -53, -52, -51, -53, -52, -53, -54, -55, -57, -57, -59, -60, -61, -62, -63,
-65, -66, -67, -69, -71, -71, -72, -74, -75, -77, -78, -79, -80, -82, -82, -84,
-85, -86, -88, -88, -90, -91, -91, -93, -94, -95, -96, -97, -99, -99, -101,
-100, -102, -103, -103, -105, -105, -106, -107, -108, -108, -109, -110, -111,
-112, -113, -112, -114, -115, -114, -113, -110, -106, -103, -99, -94, -90, -86,
-82, -77, -73, -68, -64, -60, -56, -51, -47, -43, -39, -34, -30, -27, -23, -18,
-15, -11, -6, -3, 0, };