#define DATA_LENGTH 512
#define DATA AKWF_0834

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 6, 7, 10, 11, 14, 14, 17, 19,
20, 22, 25, 27, 29, 30, 32, 34, 36, 38, 41, 42, 44, 46, 47, 49, 51, 53, 55, 56,
59, 60, 61, 63, 64, 67, 69, 70, 71, 74, 75, 77, 79, 79, 81, 83, 85, 85, 87, 89,
90, 91, 92, 93, 95, 96, 98, 99, 99, 101, 103, 103, 104, 105, 105, 107, 108, 108,
110, 110, 110, 111, 112, 113, 113, 114, 115, 115, 116, 116, 116, 116, 117, 118,
118, 118, 118, 117, 118, 119, 118, 119, 118, 118, 119, 118, 117, 117, 117, 117,
116, 116, 115, 115, 115, 115, 114, 113, 112, 112, 111, 110, 109, 108, 108, 108,
106, 105, 104, 102, 101, 100, 100, 98, 97, 96, 95, 93, 92, 90, 90, 88, 87, 84,
83, 81, 80, 78, 77, 75, 73, 71, 69, 68, 66, 63, 62, 60, 58, 56, 54, 53, 50, 49,
47, 45, 43, 40, 39, 37, 35, 32, 30, 28, 27, 24, 22, 20, 18, 16, 13, 12, 10, 8,
5, 3, 1, -1, -4, -6, -7, -9, -11, -13, -16, -17, -20, -21, -23, -25, -27, -29,
-31, -33, -35, -37, -39, -41, -43, -45, -47, -49, -49, -52, -53, -55, -57, -58,
-60, -62, -64, -64, -67, -69, -70, -71, -73, -74, -75, -77, -78, -80, -82, -83,
-84, -85, -87, -88, -90, -90, -92, -93, -94, -95, -96, -98, -98, -99, -100,
-101, -102, -103, -105, -106, -106, -107, -108, -108, -109, -109, -111, -110,
-111, -113, -113, -113, -114, -115, -115, -116, -116, -116, -117, -117, -117,
-117, -117, -118, -119, -118, -119, -119, -118, -119, -119, -119, -118, -119,
-120, -119, -118, -118, -119, -117, -118, -117, -118, -116, -116, -116, -115,
-115, -115, -114, -113, -113, -112, -111, -111, -110, -109, -108, -107, -107,
-106, -105, -104, -103, -102, -101, -99, -99, -98, -97, -95, -94, -93, -92, -90,
-89, -88, -86, -84, -83, -81, -79, -79, -77, -75, -73, -71, -70, -69, -66, -64,
-63, -61, -59, -58, -53, -50, -46, -41, -37, -32, -26, -22, -16, -11, -6, -2, 2,
7, 10, 15, 20, 23, 27, 31, 35, 38, 41, 45, 47, 50, 53, 55, 57, 59, 61, 64, 65,
66, 67, 68, 69, 71, 70, 72, 72, 72, 72, 73, 72, 72, 71, 71, 70, 69, 69, 68, 66,
65, 64, 62, 61, 59, 58, 55, 54, 53, 51, 49, 47, 45, 44, 40, 39, 37, 35, 32, 31,
29, 27, 24, 22, 20, 18, 16, 13, 12, 10, 7, 5, 3, 2, 0, -2, -4, -6, -8, -10, -13,
-13, -16, -16, -18, -20, -22, -23, -24, -25, -27, -28, -30, -30, -32, -33, -35,
-35, -36, -37, -38, -39, -39, -41, -41, -41, -42, -43, -42, -43, -44, -45, -44,
-44, -44, -45, -44, -44, -44, -45, -44, -43, -44, -43, -43, -42, -42, -40, -41,
-40, -38, -39, -37, -36, -36, -35, -33, -33, -32, -30, -30, -27, -26, -25, -24,
-22, -21, -20, -18, -17, -15, -13, -11, -9, -9, -6, -5, -3, -1, };