#define DATA_LENGTH 512
#define DATA AKWF_0897

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 7, 10, 13, 15, 20, 21, 25, 28,
32, 35, 38, 41, 44, 47, 49, 52, 55, 58, 61, 63, 65, 68, 71, 73, 76, 79, 80, 82,
85, 86, 89, 90, 92, 94, 95, 97, 99, 100, 100, 102, 103, 104, 105, 107, 107, 108,
109, 110, 110, 109, 111, 110, 111, 112, 112, 113, 112, 112, 113, 112, 114, 112,
113, 113, 112, 112, 112, 112, 113, 112, 112, 112, 112, 112, 112, 112, 112, 112,
113, 112, 113, 113, 113, 112, 113, 112, 113, 113, 113, 114, 113, 114, 114, 114,
114, 115, 115, 115, 116, 115, 116, 116, 116, 116, 117, 117, 117, 118, 118, 118,
118, 119, 118, 118, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 120,
119, 118, 119, 119, 119, 119, 118, 118, 119, 118, 119, 119, 119, 118, 118, 118,
118, 118, 118, 117, 118, 117, 118, 117, 118, 117, 117, 118, 117, 117, 117, 117,
117, 117, 117, 117, 117, 117, 116, 117, 117, 116, 118, 116, 117, 117, 118, 118,
118, 118, 117, 118, 118, 118, 118, 118, 118, 118, 118, 118, 119, 118, 118, 118,
118, 118, 118, 118, 119, 118, 119, 119, 118, 119, 118, 119, 119, 118, 117, 117,
117, 116, 116, 116, 115, 114, 113, 112, 111, 109, 108, 107, 104, 103, 102, 99,
97, 95, 93, 91, 88, 85, 83, 80, 77, 75, 72, 67, 64, 62, 59, 56, 53, 49, 46, 42,
39, 36, 32, 29, 26, 23, 19, 15, 12, 10, 6, 3, 0, -3, -7, -11, -13, -16, -19,
-23, -27, -29, -32, -36, -38, -41, -44, -47, -50, -53, -55, -59, -61, -63, -66,
-69, -71, -73, -76, -78, -81, -83, -84, -86, -89, -90, -92, -94, -95, -97, -99,
-100, -101, -103, -104, -104, -105, -106, -108, -108, -109, -109, -110, -111,
-111, -111, -111, -112, -112, -111, -111, -112, -113, -113, -112, -113, -113,
-113, -113, -113, -112, -112, -113, -112, -112, -112, -112, -112, -113, -113,
-112, -112, -112, -113, -113, -113, -113, -112, -112, -113, -113, -114, -114,
-114, -114, -114, -114, -114, -115, -115, -115, -115, -116, -116, -116, -116,
-117, -117, -116, -117, -117, -118, -118, -118, -118, -118, -118, -118, -118,
-119, -119, -119, -119, -119, -120, -118, -118, -120, -119, -119, -118, -119,
-119, -118, -119, -119, -119, -119, -118, -119, -118, -119, -119, -118, -119,
-118, -117, -118, -118, -118, -117, -117, -118, -117, -117, -118, -117, -117,
-117, -118, -117, -117, -117, -117, -117, -117, -118, -118, -117, -117, -116,
-117, -117, -117, -117, -117, -117, -118, -117, -117, -117, -118, -118, -117,
-118, -118, -118, -118, -118, -118, -118, -117, -118, -118, -118, -118, -119,
-118, -118, -118, -118, -118, -119, -118, -118, -118, -118, -118, -117, -117,
-117, -117, -116, -115, -115, -114, -112, -112, -110, -109, -108, -106, -105,
-103, -100, -99, -97, -95, -93, -90, -88, -85, -82, -80, -77, -74, -71, -67,
-65, -61, -58, -55, -52, -48, -46, -43, -39, -35, -32, -29, -25, -22, -18, -16,
-12, -9, -6, -3, };