#define DATA_LENGTH 512
#define DATA AKWF_0811

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 15, 20, 25, 31, 35, 40, 45, 49,
53, 57, 60, 65, 68, 71, 74, 76, 79, 82, 84, 86, 88, 89, 90, 92, 92, 94, 93, 94,
95, 96, 96, 96, 96, 96, 95, 95, 96, 95, 95, 95, 95, 95, 94, 94, 93, 93, 93, 92,
92, 92, 91, 91, 90, 89, 89, 87, 87, 86, 85, 84, 84, 82, 80, 79, 77, 77, 75, 73,
71, 70, 68, 66, 64, 62, 61, 58, 56, 54, 52, 50, 48, 45, 44, 42, 40, 38, 36, 33,
32, 29, 28, 26, 25, 23, 22, 20, 19, 17, 15, 15, 14, 12, 11, 11, 10, 8, 8, 7, 6,
5, 4, 3, 2, 2, 0, 0, -1, -2, -3, -5, -5, -6, -7, -8, -9, -10, -11, -12, -13,
-13, -14, -15, -16, -17, -17, -18, -18, -19, -20, -20, -21, -21, -21, -21, -22,
-22, -22, -22, -22, -21, -22, -22, -22, -22, -21, -21, -21, -20, -21, -20, -20,
-20, -19, -19, -19, -18, -18, -19, -18, -17, -17, -17, -17, -17, -17, -17, -16,
-16, -15, -16, -15, -15, -16, -15, -15, -15, -14, -14, -14, -14, -14, -13, -13,
-11, -7, -3, 1, 9, 14, 22, 29, 38, 46, 54, 61, 69, 75, 81, 87, 92, 96, 102, 105,
108, 111, 113, 116, 118, 119, 118, 120, 120, 119, 119, 117, 116, 114, 112, 110,
109, 105, 103, 100, 97, 94, 89, 87, 82, 78, 74, 68, 64, 59, 54, 50, 45, 39, 33,
28, 22, 17, 12, 6, 0, -4, -10, -16, -22, -25, -32, -35, -41, -45, -49, -53, -57,
-61, -65, -68, -71, -74, -77, -80, -82, -84, -87, -88, -89, -90, -91, -93, -94,
-93, -94, -95, -95, -95, -96, -96, -95, -96, -96, -95, -96, -95, -94, -95, -95,
-94, -93, -94, -94, -94, -92, -92, -92, -91, -90, -90, -90, -89, -88, -88, -86,
-85, -84, -84, -81, -81, -79, -78, -76, -75, -74, -71, -70, -68, -66, -65, -62,
-59, -58, -56, -53, -51, -50, -47, -44, -44, -41, -39, -37, -36, -34, -32, -29,
-28, -26, -24, -23, -21, -20, -19, -17, -17, -15, -13, -13, -11, -11, -10, -8,
-7, -7, -5, -4, -4, -3, -2, -1, 0, 1, 1, 3, 3, 5, 5, 6, 8, 8, 9, 10, 10, 12, 12,
13, 15, 16, 15, 17, 18, 18, 18, 19, 19, 19, 20, 21, 20, 21, 21, 21, 21, 23, 22,
22, 22, 22, 22, 21, 21, 22, 21, 20, 20, 20, 20, 19, 20, 19, 19, 19, 18, 17, 18,
18, 18, 18, 17, 17, 16, 17, 16, 16, 16, 16, 15, 15, 16, 16, 15, 15, 15, 15, 15,
14, 14, 13, 12, 11, 8, 3, -2, -9, -15, -22, -30, -38, -47, -54, -62, -69, -76,
-82, -88, -92, -97, -101, -105, -108, -111, -113, -115, -117, -119, -118, -119,
-118, -119, -118, -117, -116, -113, -112, -111, -108, -106, -103, -99, -96, -93,
-89, -86, -81, -77, -73, -68, -64, -59, -55, -49, -43, -38, -33, -28, -22, -17,
-11, -6, -1, };