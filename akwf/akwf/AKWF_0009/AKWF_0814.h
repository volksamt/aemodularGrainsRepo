#define DATA_LENGTH 512
#define DATA AKWF_0814

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 9, 15, 19, 24, 29, 35, 42, 49, 56,
63, 71, 77, 84, 89, 94, 100, 103, 107, 109, 112, 114, 116, 116, 116, 116, 115,
115, 114, 112, 109, 107, 104, 102, 98, 97, 93, 90, 86, 81, 75, 68, 60, 52, 44,
37, 30, 22, 16, 10, 3, -2, -7, -12, -15, -19, -23, -26, -29, -30, -32, -33, -34,
-35, -35, -35, -36, -35, -34, -34, -34, -32, -32, -31, -29, -29, -28, -26, -24,
-24, -21, -20, -19, -16, -11, -3, 6, 15, 25, 33, 42, 51, 59, 65, 71, 76, 81, 85,
87, 88, 90, 89, 90, 89, 87, 85, 82, 78, 75, 73, 68, 63, 59, 54, 50, 44, 39, 34,
29, 25, 20, 14, 10, 5, -1, -4, -8, -13, -19, -26, -33, -40, -48, -55, -63, -69,
-74, -80, -85, -90, -94, -97, -99, -102, -103, -104, -104, -104, -105, -103,
-103, -101, -99, -98, -95, -92, -89, -86, -83, -80, -77, -73, -70, -66, -63,
-59, -55, -52, -48, -44, -41, -37, -34, -31, -26, -24, -21, -16, -14, -10, -7,
-6, -2, 1, 3, 5, 7, 9, 11, 14, 15, 17, 19, 20, 22, 23, 25, 28, 31, 36, 40, 46,
50, 56, 59, 64, 67, 70, 72, 74, 75, 77, 78, 77, 77, 77, 76, 75, 73, 71, 69, 67,
64, 61, 58, 54, 52, 49, 45, 42, 39, 36, 32, 28, 25, 22, 19, 16, 13, 9, 6, 2, -6,
-15, -26, -35, -47, -57, -68, -77, -85, -92, -99, -105, -110, -113, -117, -117,
-118, -119, -119, -117, -115, -114, -110, -107, -102, -99, -94, -90, -85, -79,
-73, -68, -63, -57, -51, -46, -40, -34, -29, -23, -17, -12, -7, -1, 5, 12, 21,
29, 37, 46, 53, 60, 67, 73, 79, 84, 88, 92, 96, 98, 99, 101, 102, 102, 102, 102,
102, 100, 98, 97, 95, 92, 90, 86, 84, 81, 79, 76, 72, 68, 65, 62, 58, 54, 51,
47, 44, 40, 36, 33, 29, 26, 23, 20, 17, 15, 11, 9, 6, 3, 0, -2, -4, -7, -10,
-15, -19, -24, -29, -35, -39, -45, -49, -54, -57, -61, -62, -65, -68, -68, -69,
-70, -70, -70, -69, -69, -66, -65, -64, -62, -59, -59, -55, -52, -50, -48, -45,
-42, -40, -36, -34, -31, -28, -25, -23, -21, -16, -14, -10, -4, 4, 12, 22, 32,
41, 51, 60, 69, 76, 81, 87, 91, 94, 97, 99, 100, 100, 100, 100, 97, 96, 94, 91,
87, 84, 80, 75, 70, 67, 61, 56, 52, 47, 43, 37, 32, 31, 33, 31, 27, 24, 21, 19,
16, 12, 7, 2, -3, -8, -13, -18, -24, -28, -33, -37, -41, -45, -49, -53, -55,
-58, -59, -63, -63, -66, -67, -68, -68, -69, -70, -69, -69, -70, -69, -69, -69,
-67, -67, -66, -64, -63, -64, -66, -70, -76, -81, -87, -93, -97, -101, -106,
-108, -111, -112, -113, -113, -113, -111, -110, -107, -104, -101, -97, -92, -88,
-83, -76, -71, -65, -60, -54, -47, -43, -36, -30, -23, -17, -12, -6, -1, };