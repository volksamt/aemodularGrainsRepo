#define DATA_LENGTH 512
#define DATA AKWF_0853

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 5, 7, 8, 9, 12, 13, 15, 16, 18,
19, 20, 22, 23, 25, 26, 27, 28, 29, 30, 32, 33, 35, 36, 36, 38, 38, 39, 41, 41,
43, 44, 45, 46, 47, 47, 49, 49, 50, 52, 52, 52, 54, 54, 56, 56, 58, 58, 59, 60,
61, 61, 62, 64, 64, 65, 65, 65, 66, 67, 68, 68, 69, 70, 71, 72, 72, 73, 73, 74,
74, 76, 76, 77, 77, 78, 79, 79, 80, 80, 80, 81, 82, 83, 82, 84, 84, 85, 86, 86,
87, 86, 87, 88, 89, 89, 89, 89, 90, 90, 92, 91, 92, 92, 93, 93, 93, 95, 95, 95,
96, 96, 97, 97, 97, 98, 99, 99, 98, 99, 99, 100, 100, 100, 102, 102, 102, 102,
102, 103, 103, 104, 105, 104, 105, 105, 105, 106, 106, 106, 106, 107, 107, 107,
108, 107, 108, 108, 110, 109, 109, 109, 110, 110, 110, 111, 110, 111, 111, 111,
112, 112, 113, 112, 113, 113, 113, 113, 113, 113, 114, 114, 114, 114, 114, 115,
114, 115, 116, 115, 115, 116, 116, 116, 116, 116, 116, 117, 116, 116, 116, 116,
117, 117, 118, 118, 118, 118, 118, 118, 118, 119, 118, 118, 119, 118, 118, 119,
119, 119, 118, 118, 118, 119, 119, 119, 118, 119, 119, 118, 119, 119, 120, 118,
119, 119, 120, 118, 120, 117, 120, 117, 81, 69, 63, 55, 51, 45, 42, 38, 35, 31,
28, 25, 22, 20, 17, 15, 13, 10, 8, 6, 4, 3, 1, -2, -3, -6, -7, -9, -10, -12,
-13, -14, -16, -17, -20, -20, -22, -23, -25, -25, -27, -28, -29, -31, -31, -33,
-34, -35, -36, -38, -39, -39, -40, -41, -43, -44, -44, -45, -47, -47, -49, -49,
-50, -51, -52, -53, -54, -55, -57, -56, -57, -59, -59, -60, -61, -61, -62, -63,
-63, -64, -65, -65, -66, -67, -69, -69, -69, -70, -71, -71, -72, -72, -74, -74,
-75, -75, -76, -76, -78, -78, -78, -78, -80, -81, -80, -81, -82, -82, -82, -83,
-84, -85, -85, -85, -87, -86, -87, -88, -89, -89, -90, -90, -91, -90, -92, -92,
-92, -92, -93, -94, -95, -94, -94, -95, -96, -96, -96, -97, -98, -97, -98, -99,
-99, -100, -100, -100, -100, -101, -102, -102, -102, -102, -102, -103, -104,
-103, -104, -104, -105, -105, -106, -106, -107, -107, -107, -106, -108, -108,
-108, -108, -108, -108, -109, -109, -110, -109, -111, -110, -111, -111, -111,
-111, -111, -111, -111, -112, -113, -112, -112, -113, -113, -113, -113, -114,
-114, -114, -114, -115, -114, -114, -115, -115, -116, -115, -116, -116, -116,
-115, -116, -117, -117, -117, -117, -117, -117, -117, -117, -117, -117, -117,
-117, -117, -118, -118, -118, -118, -118, -118, -118, -118, -119, -119, -118,
-118, -118, -119, -119, -119, -119, -119, -119, -118, -120, -119, -119, -118,
-119, -118, -120, -119, -120, -118, -120, -118, -121, -113, -77, -69, -60, -55,
-50, -45, -42, -37, -34, -30, -27, -24, -23, -20, -17, -14, -13, -10, -8, -6,
-4, -2, 0, };