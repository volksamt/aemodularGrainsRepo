#define DATA_LENGTH 512
#define DATA AKWF_0824

const PROGMEM int8_t DATA[DATA_LENGTH] = {21, 16, 10, 15, 18, 23, 25, 29, 31,
36, 38, 42, 44, 48, 50, 54, 57, 60, 62, 65, 69, 70, 73, 74, 78, 79, 83, 83, 86,
88, 90, 92, 94, 96, 98, 99, 101, 102, 104, 105, 106, 107, 109, 110, 110, 111,
112, 113, 114, 114, 114, 116, 116, 116, 118, 117, 117, 118, 118, 118, 118, 118,
119, 119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 118, 117, 118, 118, 117,
117, 116, 116, 116, 116, 115, 115, 115, 114, 113, 114, 113, 113, 112, 112, 111,
111, 110, 109, 109, 108, 108, 107, 106, 106, 105, 106, 105, 104, 104, 105, 103,
106, 103, 106, 104, 105, 103, 106, 103, 105, 103, 105, 103, 105, 104, 102, 108,
72, 104, 89, 85, 99, 89, 93, 84, 86, 80, 82, 76, 77, 73, 72, 67, 66, 64, 61, 59,
57, 55, 52, 50, 48, 47, 43, 43, 39, 38, 37, 35, 33, 33, 30, 29, 27, 25, 21, 19,
17, 14, 12, 10, 7, 5, 2, 1, -2, -5, -7, -9, -11, -14, -15, -18, -20, -22, -25,
-27, -29, -32, -32, -35, -36, -39, -41, -41, -45, -46, -48, -49, -51, -52, -53,
-55, -56, -58, -60, -60, -62, -63, -65, -66, -67, -68, -68, -71, -70, -72, -73,
-73, -74, -74, -75, -76, -77, -76, -77, -76, -77, -77, -77, -77, -77, -77, -78,
-76, -76, -76, -75, -73, -73, -72, -70, -69, -68, -66, -67, -65, -63, -62, -62,
-60, -60, -59, -56, -56, -54, -54, -53, -51, -51, -50, -49, -47, -47, -47, -45,
-44, -43, -43, -42, -41, -40, -40, -39, -37, -38, -37, -36, -35, -35, -35, -33,
-34, -32, -32, -32, -31, -31, -31, -30, -30, -30, -31, -31, -31, -32, -32, -33,
-33, -33, -33, -34, -34, -35, -35, -35, -36, -36, -37, -37, -37, -38, -38, -38,
-39, -39, -40, -40, -40, -40, -41, -41, -40, -40, -41, -42, -42, -43, -42, -43,
-43, -44, -44, -45, -44, -44, -45, -45, -44, -45, -45, -45, -46, -45, -46, -46,
-46, -46, -46, -46, -45, -46, -45, -46, -45, -45, -45, -45, -46, -45, -44, -45,
-45, -43, -43, -43, -43, -43, -42, -42, -42, -42, -42, -42, -42, -42, -42, -41,
-42, -41, -41, -41, -41, -41, -41, -40, -40, -40, -40, -40, -40, -39, -39, -38,
-39, -38, -38, -37, -38, -37, -37, -37, -37, -35, -36, -36, -35, -34, -35, -34,
-34, -33, -33, -32, -33, -33, -31, -32, -31, -31, -31, -31, -32, -32, -33, -33,
-34, -35, -35, -35, -36, -36, -38, -38, -39, -39, -40, -40, -41, -41, -42, -42,
-42, -43, -44, -45, -45, -45, -46, -46, -47, -47, -49, -49, -49, -50, -51, -50,
-50, -51, -51, -52, -51, -52, -51, -51, -51, -52, -51, -51, -51, -50, -51, -50,
-50, -49, -49, -48, -47, -46, -46, -45, -45, -44, -43, -43, -42, -41, -39, -39,
-38, -37, -35, -33, -30, -30, -26, -27, -22, -23, -19, -20, -15, -17, -11, -13,
-9, -10, -6, -7, -4, 32, -9, };