#define DATA_LENGTH 512
#define DATA AKWF_0881

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 16, 20, 24, 27, 29, 32, 35, 36, 39,
41, 42, 44, 45, 47, 47, 50, 51, 53, 54, 55, 57, 57, 58, 60, 61, 61, 62, 63, 65,
65, 66, 68, 68, 69, 70, 71, 71, 72, 72, 74, 75, 76, 76, 76, 78, 78, 79, 79, 79,
81, 81, 82, 83, 82, 84, 84, 85, 85, 86, 85, 86, 87, 87, 88, 88, 88, 88, 89, 90,
89, 90, 91, 90, 90, 91, 91, 92, 91, 92, 91, 91, 92, 92, 93, 92, 92, 92, 93, 93,
93, 93, 92, 92, 93, 92, 93, 93, 92, 92, 92, 92, 92, 92, 91, 91, 92, 91, 92, 91,
91, 91, 91, 91, 90, 90, 90, 90, 90, 89, 89, 88, 88, 88, 87, 87, 87, 87, 86, 86,
86, 86, 86, 85, 85, 84, 84, 83, 83, 82, 82, 82, 82, 82, 81, 80, 80, 81, 80, 79,
79, 79, 79, 78, 77, 77, 77, 77, 76, 75, 75, 75, 75, 75, 74, 74, 73, 73, 73, 72,
71, 71, 71, 70, 70, 70, 70, 69, 69, 69, 68, 68, 67, 68, 67, 67, 66, 66, 66, 66,
65, 65, 65, 65, 65, 64, 63, 64, 64, 64, 63, 63, 62, 63, 62, 62, 63, 62, 62, 62,
62, 61, 62, 61, 61, 61, 61, 61, 61, 61, 61, 62, 61, 60, 61, 60, 60, 60, 60, 60,
60, 60, 60, 60, 60, 60, 58, 60, 59, 58, 58, 58, 58, 58, 57, 57, 57, 57, 57, 57,
56, 56, 56, 56, 56, 55, 55, 55, 54, 54, 53, 53, 53, 53, 52, 52, 51, 51, 51, 50,
49, 49, 49, 48, 47, 47, 46, 45, 45, 44, 44, 43, 42, 42, 42, 40, 39, 39, 37, 36,
35, 35, 33, 33, 31, 29, 27, 26, 23, 22, 18, 16, 8, -10, -16, -20, -22, -24, -26,
-29, -31, -33, -34, -36, -37, -39, -40, -41, -43, -45, -46, -47, -48, -49, -51,
-52, -53, -54, -56, -57, -58, -60, -61, -62, -63, -64, -66, -67, -68, -69, -70,
-72, -72, -73, -74, -75, -76, -77, -78, -80, -80, -81, -83, -84, -84, -85, -86,
-86, -88, -89, -90, -90, -91, -93, -94, -95, -96, -96, -96, -97, -98, -99, -100,
-101, -101, -102, -103, -104, -105, -105, -106, -107, -107, -107, -108, -109,
-111, -111, -111, -111, -113, -113, -114, -114, -114, -115, -115, -115, -117,
-117, -117, -118, -118, -118, -119, -119, -119, -118, -118, -118, -120, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -118, -118, -117, -117, -117,
-117, -117, -117, -115, -115, -115, -114, -114, -113, -113, -112, -112, -111,
-110, -111, -109, -109, -108, -107, -106, -105, -105, -103, -103, -102, -101,
-101, -100, -99, -98, -97, -97, -96, -95, -93, -94, -92, -91, -91, -89, -88,
-87, -86, -85, -84, -83, -82, -80, -80, -79, -77, -77, -75, -74, -74, -72, -71,
-69, -69, -68, -66, -64, -64, -61, -61, -60, -59, -56, -56, -54, -52, -50, -49,
-48, -46, -44, -41, -41, -38, -37, -35, -33, -29, -26, -23, -21, -13, };