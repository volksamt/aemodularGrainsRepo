#define DATA_LENGTH 512
#define DATA AKWF_0861

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 16, 23, 21, 22, 26, 24, 21, 23, 28,
29, 32, 44, 57, 62, 62, 66, 76, 92, 110, 119, 115, 103, 94, 91, 89, 88, 86, 83,
79, 77, 73, 71, 69, 66, 63, 61, 58, 57, 55, 51, 50, 47, 44, 42, 40, 38, 35, 33,
31, 30, 28, 25, 24, 22, 20, 19, 17, 14, 13, 11, 10, 8, 7, 6, 4, 2, 1, 0, -2, -3,
-4, -6, -6, -8, -10, -10, -11, -12, -14, -15, -15, -16, -17, -18, -20, -20, -21,
-21, -22, -23, -24, -24, -25, -25, -26, -26, -27, -27, -28, -28, -29, -28, -28,
-29, -30, -29, -31, -31, -31, -31, -31, -31, -31, -32, -31, -30, -31, -31, -31,
-30, -31, -30, -30, -30, -29, -29, -30, -29, -29, -29, -28, -27, -28, -27, -26,
-26, -26, -25, -24, -24, -23, -23, -23, -22, -21, -21, -20, -19, -19, -18, -18,
-17, -16, -15, -14, -14, -14, -13, -12, -10, -10, -10, -8, -8, -7, -7, -5, -5,
-3, -3, -2, -1, -1, 1, 2, 2, 3, 5, 5, 6, 8, 8, 9, 11, 11, 11, 13, 14, 16, 15,
17, 18, 19, 19, 21, 21, 22, 24, 25, 26, 27, 28, 29, 29, 30, 32, 33, 34, 34, 35,
37, 38, 38, 39, 40, 41, 43, 44, 45, 45, 47, 47, 48, 50, 51, 51, 53, 53, 54, 55,
56, 56, 57, 59, 59, 61, 61, 62, 64, 64, 65, 65, 66, 67, 68, 71, 78, 82, 70, 49,
30, 17, 13, 13, 10, -2, -17, -23, -22, -22, -27, -24, -21, -24, -28, -28, -32,
-45, -58, -63, -62, -67, -77, -94, -111, -120, -113, -101, -93, -91, -89, -88,
-85, -82, -79, -77, -74, -71, -69, -65, -64, -61, -59, -56, -54, -51, -49, -46,
-45, -42, -39, -38, -36, -34, -31, -30, -28, -26, -24, -22, -20, -18, -16, -15,
-13, -12, -10, -8, -6, -6, -4, -2, -1, 0, 3, 4, 4, 6, 7, 9, 9, 11, 12, 14, 13,
15, 16, 16, 18, 19, 19, 19, 20, 21, 23, 22, 23, 23, 25, 25, 25, 27, 27, 28, 27,
29, 29, 29, 29, 30, 30, 30, 30, 30, 31, 31, 31, 31, 30, 31, 31, 30, 31, 31, 31,
31, 31, 30, 29, 30, 29, 30, 29, 30, 29, 28, 28, 28, 27, 27, 26, 26, 26, 25, 25,
24, 24, 22, 22, 22, 21, 20, 20, 19, 18, 18, 17, 17, 17, 16, 15, 14, 13, 12, 11,
11, 10, 9, 9, 8, 7, 6, 5, 5, 4, 2, 2, 1, 0, -1, -2, -2, -4, -5, -5, -6, -7, -9,
-10, -10, -12, -12, -12, -14, -16, -15, -17, -18, -18, -20, -21, -22, -23, -23,
-24, -26, -26, -27, -29, -30, -31, -32, -33, -33, -35, -36, -37, -38, -39, -40,
-40, -41, -43, -44, -45, -45, -46, -47, -49, -49, -50, -51, -52, -53, -53, -55,
-55, -57, -58, -59, -59, -61, -62, -62, -63, -64, -65, -66, -66, -68, -68, -73,
-79, -81, -68, -47, -28, -17, -13, -13, -8, };