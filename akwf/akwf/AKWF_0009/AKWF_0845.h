#define DATA_LENGTH 512
#define DATA AKWF_0845

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 3, 4, 5, 7, 7, 8, 9, 11, 11, 13,
14, 15, 15, 17, 17, 19, 21, 21, 21, 23, 23, 24, 25, 27, 28, 28, 30, 30, 31, 32,
34, 34, 35, 36, 37, 37, 39, 40, 40, 41, 42, 43, 44, 44, 44, 46, 47, 47, 48, 49,
49, 50, 51, 51, 53, 53, 54, 55, 55, 56, 57, 57, 58, 59, 59, 60, 61, 61, 61, 62,
63, 63, 64, 64, 64, 66, 66, 66, 67, 67, 68, 68, 69, 69, 70, 69, 71, 71, 71, 72,
71, 72, 73, 73, 73, 73, 73, 74, 75, 74, 75, 75, 74, 75, 75, 75, 76, 76, 77, 76,
77, 76, 77, 76, 77, 76, 77, 76, 77, 77, 76, 77, 76, 76, 76, 74, 75, 73, 73, 73,
73, 72, 72, 71, 70, 70, 69, 68, 68, 67, 67, 65, 65, 65, 63, 63, 63, 62, 61, 60,
60, 59, 58, 57, 56, 55, 55, 54, 53, 52, 51, 50, 49, 48, 48, 47, 46, 45, 44, 43,
43, 41, 41, 40, 39, 37, 37, 36, 35, 34, 33, 32, 31, 30, 29, 27, 27, 26, 25, 24,
23, 22, 21, 19, 18, 18, 17, 15, 15, 14, 13, 12, 11, 10, 8, 8, 7, 5, 4, 3, 2, 1,
0, -1, -2, -3, -5, -6, -6, -7, -8, -9, -10, -11, -13, -13, -14, -16, -17, -18,
-18, -19, -21, -22, -23, -24, -25, -26, -27, -28, -29, -30, -30, -32, -34, -35,
-36, -36, -37, -39, -39, -40, -41, -43, -43, -44, -45, -46, -47, -48, -49, -50,
-50, -52, -53, -54, -56, -56, -57, -58, -59, -60, -61, -61, -62, -63, -64, -64,
-66, -66, -68, -68, -70, -70, -71, -72, -73, -74, -74, -76, -76, -77, -77, -78,
-79, -80, -81, -82, -83, -83, -84, -85, -86, -86, -87, -88, -88, -89, -89, -90,
-91, -92, -92, -93, -94, -95, -95, -96, -96, -97, -98, -98, -98, -100, -100,
-100, -101, -102, -103, -102, -104, -103, -105, -105, -106, -106, -107, -106,
-107, -108, -108, -109, -109, -109, -110, -110, -111, -111, -111, -112, -111,
-112, -113, -113, -114, -113, -114, -114, -115, -115, -115, -115, -115, -115,
-117, -117, -117, -117, -118, -118, -117, -118, -117, -118, -117, -118, -119,
-119, -119, -119, -118, -118, -119, -119, -119, -119, -118, -119, -119, -120,
-119, -118, -118, -118, -117, -116, -116, -116, -115, -115, -114, -113, -113,
-113, -111, -111, -111, -109, -109, -108, -107, -106, -106, -105, -104, -104,
-102, -101, -100, -100, -99, -98, -98, -96, -95, -94, -93, -92, -91, -90, -89,
-88, -87, -87, -85, -84, -83, -82, -80, -80, -79, -78, -76, -76, -75, -74, -72,
-71, -70, -69, -68, -66, -66, -65, -63, -62, -61, -59, -59, -58, -56, -55, -55,
-53, -52, -51, -50, -48, -47, -47, -45, -43, -44, -41, -40, -39, -38, -36, -36,
-34, -33, -32, -31, -30, -29, -28, -27, -26, -24, -22, -22, -21, -19, -19, -18,
-17, -15, -14, -12, -11, -11, -9, -8, -6, -5, -4, -4, -2, -2, 0, };