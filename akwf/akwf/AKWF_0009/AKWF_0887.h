#define DATA_LENGTH 512
#define DATA AKWF_0887

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 1, 1, 2, 5, 8, 11, 14, 18, 21, 25,
28, 31, 35, 38, 42, 45, 49, 51, 55, 57, 60, 63, 65, 69, 70, 73, 75, 78, 80, 81,
84, 86, 88, 89, 91, 93, 95, 96, 98, 98, 100, 101, 102, 104, 104, 105, 106, 106,
107, 108, 109, 109, 110, 110, 111, 111, 110, 111, 111, 112, 112, 112, 112, 112,
112, 112, 112, 111, 111, 111, 111, 111, 110, 110, 109, 110, 109, 109, 107, 107,
107, 106, 106, 104, 104, 103, 103, 102, 101, 101, 100, 99, 98, 97, 96, 96, 94,
93, 92, 92, 91, 90, 89, 88, 87, 86, 85, 84, 83, 82, 80, 79, 79, 78, 77, 75, 74,
73, 72, 70, 70, 68, 67, 65, 64, 63, 62, 60, 60, 59, 58, 56, 54, 53, 52, 52, 50,
48, 47, 46, 45, 43, 42, 41, 40, 38, 36, 36, 34, 33, 32, 30, 29, 28, 26, 25, 23,
22, 21, 20, 18, 16, 15, 14, 13, 12, 10, 9, 8, 6, 6, 4, 3, 1, 1, -2, -3, -4, -5,
-6, -8, -8, -10, -11, -13, -13, -15, -16, -17, -19, -20, -22, -23, -23, -25,
-26, -27, -28, -30, -31, -32, -33, -35, -36, -37, -38, -40, -41, -41, -42, -44,
-45, -46, -46, -48, -49, -50, -51, -53, -53, -55, -56, -56, -57, -59, -60, -61,
-62, -63, -64, -65, -66, -66, -67, -69, -70, -71, -71, -72, -73, -74, -75, -76,
-77, -77, -78, -79, -80, -81, -82, -83, -84, -84, -85, -86, -86, -87, -89, -89,
-90, -90, -92, -92, -92, -93, -94, -95, -95, -95, -96, -97, -98, -99, -99, -100,
-100, -101, -101, -102, -102, -104, -104, -104, -105, -105, -105, -107, -107,
-107, -107, -108, -109, -109, -110, -109, -110, -111, -111, -111, -111, -112,
-113, -113, -113, -114, -114, -115, -114, -115, -115, -115, -116, -116, -116,
-117, -117, -117, -118, -117, -118, -117, -118, -119, -118, -119, -118, -119,
-118, -118, -118, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -118, -119, -118, -118, -118,
-118, -118, -118, -118, -118, -117, -117, -117, -117, -116, -116, -116, -116,
-116, -115, -115, -115, -115, -114, -114, -113, -114, -113, -113, -112, -112,
-112, -111, -111, -110, -111, -109, -110, -110, -109, -109, -108, -108, -107,
-106, -106, -105, -105, -104, -105, -103, -103, -102, -103, -102, -101, -100,
-99, -100, -100, -99, -98, -97, -97, -96, -95, -95, -94, -94, -94, -93, -92,
-91, -90, -90, -89, -89, -89, -88, -87, -86, -85, -85, -84, -83, -83, -82, -82,
-81, -79, -78, -78, -77, -77, -76, -75, -74, -73, -73, -71, -71, -70, -70, -69,
-68, -68, -66, -65, -65, -65, -63, -62, -61, -61, -60, -59, -57, -56, -56, -55,
-55, -54, -53, -51, -51, -51, -49, -49, -48, -47, -45, -44, -44, -42, -42, -40,
-40, -38, -37, -38, -36, -36, -34, -34, -33, -32, -31, -30, -30, -28, -27, -26,
-25, -25, -23, -22, -21, -20, -20, -18, -17, -18, -12, };