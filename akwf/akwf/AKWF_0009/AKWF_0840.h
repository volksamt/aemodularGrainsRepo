#define DATA_LENGTH 512
#define DATA AKWF_0840

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 0, 1, 0, 0, 0, 1, 0, 2, 2, 2, 2,
2, 3, 4, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 16, 18, 19, 19, 22, 24, 25, 27,
28, 31, 32, 33, 36, 37, 39, 42, 44, 46, 48, 50, 52, 54, 57, 58, 60, 64, 65, 67,
70, 71, 74, 76, 79, 80, 82, 84, 87, 89, 91, 92, 94, 96, 98, 99, 101, 102, 104,
105, 107, 108, 109, 111, 111, 113, 114, 115, 116, 116, 117, 117, 118, 118, 119,
119, 119, 119, 119, 119, 119, 119, 118, 119, 118, 119, 118, 118, 118, 118, 117,
117, 116, 115, 115, 114, 114, 113, 113, 112, 112, 111, 110, 108, 108, 106, 105,
104, 104, 102, 101, 99, 97, 96, 95, 94, 92, 90, 88, 88, 86, 84, 81, 81, 78, 77,
74, 73, 72, 69, 67, 66, 64, 61, 60, 57, 55, 54, 52, 49, 47, 45, 43, 41, 39, 38,
37, 34, 33, 31, 29, 27, 26, 24, 23, 21, 20, 18, 16, 15, 14, 13, 12, 9, 9, 8, 8,
6, 6, 4, 4, 3, 2, 2, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, -1,
-1, 0, 0, -1, 0, 0, 0, -1, 0, 1, 0, 0, -1, 0, 0, -2, -1, -1, -1, -2, -2, -2, -2,
-2, -2, -3, -3, -3, -4, -4, -4, -5, -6, -5, -6, -6, -6, -6, -7, -8, -8, -8, -10,
-10, -10, -10, -11, -12, -12, -13, -14, -14, -16, -15, -17, -16, -18, -18, -19,
-19, -19, -21, -21, -22, -23, -24, -24, -24, -26, -27, -27, -28, -29, -30, -30,
-31, -32, -32, -33, -34, -34, -35, -35, -36, -38, -38, -39, -39, -41, -41, -42,
-43, -43, -44, -45, -46, -46, -47, -48, -48, -49, -50, -50, -50, -51, -51, -52,
-52, -53, -53, -54, -56, -55, -55, -56, -57, -57, -58, -58, -58, -59, -59, -59,
-59, -59, -61, -61, -60, -61, -61, -62, -61, -62, -61, -61, -62, -61, -61, -62,
-61, -61, -61, -62, -61, -61, -62, -61, -61, -61, -61, -61, -62, -60, -61, -62,
-61, -61, -61, -60, -60, -60, -59, -60, -60, -59, -59, -59, -58, -58, -58, -58,
-58, -57, -57, -57, -56, -57, -56, -55, -54, -54, -54, -54, -53, -53, -53, -52,
-51, -50, -51, -50, -49, -49, -48, -48, -47, -47, -46, -46, -44, -45, -44, -43,
-43, -42, -41, -40, -39, -39, -39, -38, -36, -36, -36, -35, -34, -33, -33, -32,
-32, -31, -30, -29, -28, -28, -27, -27, -26, -26, -24, -25, -24, -23, -22, -21,
-21, -20, -19, -18, -18, -17, -17, -17, -15, -15, -13, -14, -13, -12, -12, -12,
-11, -10, -9, -9, -8, -8, -7, -7, -7, -6, -6, -6, -6, -5, -4, -4, -3, -3, -3,
-2, -3, -2, -2, -2, -1, -1, -2, -1, -1, 0, -1, 0, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0,
1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, };