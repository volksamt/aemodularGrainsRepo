#define DATA_LENGTH 512
#define DATA AKWF_0831

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 1, 2, 2, 2, 3, 4, 4, 5, 6, 6, 6,
7, 8, 9, 8, 9, 10, 10, 12, 12, 13, 13, 13, 14, 15, 16, 17, 18, 19, 20, 20, 20,
22, 23, 23, 23, 25, 25, 27, 27, 28, 30, 30, 31, 32, 33, 33, 34, 36, 37, 38, 39,
40, 40, 41, 43, 44, 45, 45, 46, 47, 48, 50, 51, 52, 53, 54, 55, 56, 57, 58, 60,
60, 61, 62, 63, 64, 65, 67, 68, 68, 68, 70, 71, 72, 73, 75, 75, 76, 77, 78, 79,
80, 81, 82, 83, 84, 85, 85, 86, 87, 88, 89, 89, 90, 91, 91, 93, 93, 94, 94, 95,
96, 97, 98, 98, 98, 100, 100, 101, 101, 102, 102, 103, 103, 104, 105, 106, 105,
107, 108, 107, 108, 108, 108, 109, 110, 110, 111, 112, 112, 112, 112, 113, 113,
115, 115, 115, 115, 116, 116, 116, 117, 117, 117, 118, 118, 119, 118, 118, 119,
119, 118, 120, 119, 119, 119, 118, 119, 119, 119, 119, 119, 117, 118, 117, 117,
116, 116, 116, 114, 113, 113, 112, 111, 110, 108, 108, 106, 105, 103, 102, 100,
99, 98, 96, 94, 92, 90, 88, 86, 84, 82, 80, 78, 76, 72, 69, 68, 64, 62, 60, 57,
53, 50, 48, 45, 42, 40, 36, 33, 30, 28, 23, 21, 18, 15, 11, 9, 6, 2, -1, -4, -7,
-10, -12, -15, -19, -22, -24, -27, -31, -33, -35, -38, -42, -44, -47, -49, -52,
-54, -56, -59, -61, -64, -66, -69, -70, -73, -74, -77, -79, -81, -84, -84, -86,
-89, -90, -91, -93, -95, -97, -97, -98, -100, -102, -103, -104, -105, -106,
-108, -109, -109, -110, -111, -112, -113, -114, -114, -115, -115, -116, -117,
-116, -117, -116, -117, -118, -117, -118, -118, -118, -118, -117, -118, -117,
-117, -117, -116, -117, -116, -116, -116, -115, -114, -114, -113, -113, -111,
-112, -111, -110, -110, -109, -109, -107, -107, -107, -105, -105, -103, -102,
-102, -101, -100, -99, -98, -98, -96, -96, -95, -94, -93, -92, -91, -91, -89,
-89, -87, -87, -86, -84, -84, -83, -82, -80, -80, -79, -78, -78, -77, -76, -74,
-74, -72, -72, -70, -70, -68, -68, -67, -66, -65, -64, -64, -63, -62, -62, -61,
-60, -59, -58, -58, -57, -56, -55, -55, -54, -53, -53, -52, -52, -50, -49, -49,
-48, -47, -46, -46, -46, -46, -45, -45, -43, -44, -42, -42, -41, -40, -39, -39,
-39, -39, -38, -37, -36, -36, -36, -35, -35, -35, -34, -34, -33, -32, -32, -31,
-31, -31, -30, -29, -30, -29, -28, -28, -28, -27, -27, -27, -26, -26, -25, -25,
-24, -24, -23, -23, -23, -23, -22, -21, -22, -20, -21, -20, -20, -20, -19, -19,
-19, -18, -17, -18, -18, -17, -17, -16, -16, -15, -16, -16, -14, -14, -14, -13,
-13, -13, -13, -13, -12, -12, -12, -11, -10, -10, -10, -9, -10, -8, -9, -8, -8,
-7, -7, -7, -7, -5, -5, -4, -5, -4, -4, -3, -4, -2, -2, -2, -1, -1, 0, };