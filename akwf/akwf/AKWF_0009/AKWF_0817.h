#define DATA_LENGTH 512
#define DATA AKWF_0817

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 2, 2, 3, 2, 3, 4, 4, 4, 5, 5,
5, 6, 6, 7, 6, 21, 49, 82, 108, 114, 111, 107, 100, 95, 87, 75, 59, 41, 21, 2,
-15, -31, -44, -54, -63, -68, -73, -76, -76, -78, -76, -76, -73, -71, -68, -64,
-60, -57, -53, -49, -45, -41, -37, -33, -28, -26, -22, -17, -15, -12, -8, -6,
-3, 0, 2, 4, 6, 8, 11, 11, 14, 14, 17, 18, 18, 19, 20, 21, 22, 22, 22, 23, 23,
23, 24, 22, 23, 23, 23, 23, 23, 23, 22, 22, 22, 21, 20, 20, 20, 19, 19, 18, 17,
17, 16, 16, 14, 14, 13, 14, 13, 13, 11, 10, 10, 10, 9, 8, 7, 7, 6, 5, 5, 4, 5,
3, 3, 3, 3, 2, 1, 1, 1, 0, 0, 0, -1, -2, -2, -2, -4, -8, -12, -16, -19, -23,
-27, -29, -31, -35, -36, -38, -38, -38, -38, -36, -36, -33, -30, -29, -26, -23,
-20, -17, -15, -12, -10, -6, -5, -3, 0, 2, 5, 7, 8, 9, 12, 13, 14, 15, 17, 18,
19, 19, 20, 20, 21, 21, 21, 21, 22, 21, 21, 21, 21, 22, 21, 21, 20, 20, 19, 18,
19, 18, 17, 16, 17, 15, 15, 15, 14, 13, 11, 11, 11, 10, 10, 8, 8, 7, 6, 6, 5, 4,
4, 3, 3, 2, 1, 1, 2, 0, 0, -1, -1, -1, -3, -3, -3, -3, -3, -4, -5, -4, -5, -5,
-5, -6, -6, -5, -5, -6, -5, -6, -7, -7, -7, -7, -7, -7, -7, -7, -6, -6, -6, -7,
-7, -7, -7, -7, -20, -65, -105, -119, -117, -111, -105, -101, -95, -84, -70,
-53, -33, -12, 7, 24, 39, 52, 61, 70, 75, 78, 81, 82, 83, 82, 79, 77, 74, 71,
67, 64, 60, 56, 53, 48, 44, 40, 36, 32, 28, 24, 21, 17, 14, 10, 9, 5, 3, 0, -2,
-4, -7, -8, -9, -11, -13, -14, -16, -16, -18, -19, -19, -20, -21, -21, -22, -22,
-22, -22, -23, -22, -23, -22, -22, -22, -22, -22, -22, -22, -21, -21, -20, -19,
-20, -19, -18, -18, -17, -16, -16, -15, -14, -14, -13, -13, -12, -11, -11, -10,
-10, -9, -8, -8, -7, -7, -6, -6, -5, -5, -4, -4, -3, -2, -2, -3, -2, -1, 0, 0,
0, 0, 0, 1, 1, 2, 2, 2, 2, 4, 3, 3, 3, 4, 4, 4, 4, 4, 5, 5, 5, 4, 5, 5, 4, 5, 5,
6, 10, 13, 17, 21, 23, 28, 31, 34, 36, 38, 39, 40, 39, 38, 38, 36, 33, 30, 28,
26, 22, 19, 16, 13, 10, 8, 5, 3, -1, -3, -6, -8, -10, -12, -13, -15, -16, -18,
-19, -20, -21, -22, -22, -23, -24, -23, -25, -24, -23, -24, -25, -23, -24, -23,
-24, -23, -23, -22, -21, -21, -20, -19, -20, -18, -17, -17, -16, -15, -14, -14,
-14, -13, -12, -11, -11, -10, -8, -8, -7, -7, -6, -5, -5, -4, -3, -3, -2, -2,
-2, -1, 0, };