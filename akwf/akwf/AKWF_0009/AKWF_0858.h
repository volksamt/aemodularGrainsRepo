#define DATA_LENGTH 512
#define DATA AKWF_0858

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 12, 15, 19, 23, 27, 30, 33,
38, 41, 44, 47, 50, 54, 57, 60, 63, 66, 70, 72, 75, 78, 79, 82, 84, 86, 87, 89,
91, 92, 92, 94, 94, 95, 94, 95, 94, 94, 93, 93, 92, 91, 90, 88, 87, 85, 83, 81,
78, 76, 74, 70, 68, 64, 60, 57, 54, 49, 46, 41, 36, 32, 28, 24, 20, 15, 10, 6,
1, -4, -9, -14, -18, -23, -29, -34, -37, -42, -46, -52, -56, -60, -64, -68, -73,
-76, -80, -84, -87, -91, -94, -96, -99, -102, -104, -106, -108, -111, -112,
-114, -114, -116, -117, -115, -117, -117, -116, -115, -116, -114, -113, -112,
-109, -108, -105, -103, -101, -98, -95, -91, -88, -85, -81, -77, -73, -68, -64,
-59, -55, -50, -45, -41, -34, -30, -25, -19, -14, -8, -3, 3, 8, 13, 18, 24, 29,
34, 40, 44, 49, 55, 59, 64, 68, 73, 77, 81, 85, 88, 92, 95, 98, 101, 103, 106,
109, 110, 113, 114, 116, 117, 118, 118, 119, 119, 119, 119, 118, 118, 117, 116,
114, 113, 111, 109, 107, 104, 101, 99, 95, 92, 88, 85, 82, 78, 73, 70, 65, 61,
56, 52, 48, 44, 39, 33, 28, 24, 19, 15, 9, 5, 0, -5, -11, -15, -20, -24, -28,
-33, -38, -42, -46, -50, -53, -57, -61, -64, -67, -71, -74, -77, -80, -82, -84,
-87, -88, -90, -92, -93, -94, -95, -96, -95, -96, -97, -96, -97, -96, -95, -94,
-93, -92, -90, -89, -86, -85, -83, -81, -78, -76, -74, -70, -68, -65, -62, -59,
-55, -52, -49, -45, -42, -38, -34, -31, -27, -23, -20, -17, -13, -9, -5, -2, 2,
4, 9, 11, 15, 18, 21, 25, 27, 30, 33, 35, 39, 40, 43, 45, 47, 49, 50, 52, 53,
54, 56, 58, 57, 58, 58, 59, 59, 60, 60, 59, 58, 57, 57, 57, 56, 54, 54, 52, 51,
49, 47, 46, 45, 42, 40, 39, 37, 34, 32, 30, 27, 25, 23, 21, 18, 16, 13, 11, 8,
6, 4, 2, -1, -3, -4, -7, -9, -12, -13, -15, -16, -18, -20, -21, -22, -23, -25,
-26, -26, -27, -29, -29, -29, -30, -30, -31, -31, -30, -30, -29, -30, -30, -29,
-28, -27, -26, -25, -24, -24, -23, -21, -19, -18, -17, -15, -13, -11, -10, -9,
-6, -5, -4, -2, 1, 2, 3, 5, 7, 9, 10, 11, 14, 15, 16, 18, 19, 20, 20, 23, 24,
24, 25, 26, 26, 27, 28, 28, 28, 28, 28, 28, 28, 27, 26, 26, 25, 24, 24, 22, 21,
20, 19, 18, 16, 14, 12, 12, 10, 8, 6, 4, 1, -1, -3, -5, -7, -10, -12, -14, -16,
-19, -21, -23, -25, -28, -30, -32, -34, -36, -39, -41, -42, -44, -46, -48, -49,
-50, -52, -52, -54, -55, -55, -57, -56, -57, -58, -58, -58, -58, -58, -57, -57,
-56, -56, -55, -55, -53, -51, -50, -47, -47, -44, -42, -41, -37, -36, -32, -30,
-27, -24, -21, -17, -14, -12, -8, -5, -1, };