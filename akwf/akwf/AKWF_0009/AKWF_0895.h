#define DATA_LENGTH 512
#define DATA AKWF_0895

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 6, 2, 28, 28, 16, 22, 21, 26,
26, 31, 32, 36, 36, 39, 41, 43, 45, 47, 48, 49, 50, 51, 53, 55, 56, 56, 57, 58,
59, 61, 61, 62, 64, 64, 64, 65, 67, 67, 69, 68, 69, 71, 71, 71, 71, 72, 73, 73,
73, 75, 75, 75, 76, 76, 77, 77, 77, 77, 78, 78, 78, 78, 78, 79, 79, 78, 79, 79,
79, 79, 80, 79, 79, 79, 79, 79, 79, 79, 78, 79, 79, 79, 78, 78, 79, 78, 78, 78,
78, 78, 77, 78, 78, 78, 78, 78, 77, 78, 77, 77, 77, 78, 77, 77, 77, 77, 78, 77,
77, 78, 78, 77, 78, 78, 77, 78, 78, 78, 78, 78, 78, 79, 78, 79, 78, 79, 79, 79,
79, 79, 79, 80, 79, 79, 79, 79, 79, 79, 78, 80, 79, 79, 79, 79, 79, 79, 79, 79,
79, 78, 79, 79, 78, 79, 79, 80, 79, 78, 78, 79, 79, 79, 79, 78, 79, 78, 78, 79,
78, 79, 78, 78, 79, 79, 78, 79, 78, 79, 78, 79, 78, 79, 78, 79, 78, 79, 78, 78,
79, 78, 79, 78, 82, 61, 58, 73, 70, 71, 68, 68, 66, 66, 64, 64, 63, 60, 62, 59,
60, 57, 59, 56, 58, 55, 57, 54, 55, 56, 7, 25, 41, 35, 38, 30, 31, 24, 25, 19,
20, 15, 14, 12, 9, 11, -12, -15, -2, -8, -6, -13, -13, -19, -19, -24, -24, -27,
-28, -32, -58, -47, -44, -47, -48, -52, -56, -59, -62, -64, -67, -69, -71, -73,
-76, -78, -81, -83, -84, -86, -87, -90, -91, -93, -95, -96, -98, -99, -100,
-102, -102, -104, -104, -106, -107, -108, -109, -109, -111, -112, -113, -114,
-114, -114, -115, -116, -116, -116, -117, -117, -118, -118, -118, -118, -118,
-118, -119, -119, -118, -118, -118, -119, -118, -118, -118, -118, -118, -118,
-118, -118, -117, -117, -116, -117, -117, -116, -116, -116, -116, -117, -115,
-116, -115, -116, -116, -115, -116, -116, -115, -115, -115, -116, -115, -116,
-116, -115, -115, -117, -116, -115, -116, -117, -117, -116, -116, -117, -118,
-117, -118, -118, -118, -118, -117, -119, -118, -118, -119, -119, -119, -118,
-119, -119, -120, -119, -119, -120, -119, -119, -119, -119, -119, -118, -120,
-119, -118, -119, -119, -119, -118, -118, -119, -119, -118, -119, -118, -119,
-118, -118, -118, -117, -117, -117, -118, -117, -118, -118, -118, -118, -117,
-117, -118, -118, -117, -117, -118, -117, -117, -118, -118, -117, -117, -117,
-118, -117, -118, -118, -117, -118, -117, -118, -118, -118, -117, -118, -117,
-119, -117, -118, -117, -118, -118, -118, -117, -118, -118, -118, -119, -118,
-119, -117, -122, -97, -102, -113, -109, -111, -108, -108, -107, -105, -103,
-103, -102, -101, -100, -101, -98, -102, -78, -78, -91, -86, -89, -84, -84, -81,
-81, -79, -75, -79, -54, -56, -66, -62, -62, -57, -57, -53, -52, -49, -48, -45,
-45, -42, -41, -38, -39, -34, -35, -31, -35, -18, -5, -20, -16, -17, -13, -12,
-9, -6, -4, -2, };