#define DATA_LENGTH 512
#define DATA AKWF_0851

const PROGMEM int8_t DATA[DATA_LENGTH] = {13, 15, 13, 14, 14, 15, 13, 15, 14,
16, 13, 15, 12, 17, 11, 18, 10, 20, 4, 45, 127, 114, 122, 117, 120, 118, 119,
120, 119, 119, 118, 119, 118, 120, 118, 119, 118, 119, 118, 120, 119, 119, 119,
120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 120, 119, 119,
119, 118, 119, 118, 118, 119, 118, 118, 119, 118, 120, 118, 119, 119, 118, 118,
118, 118, 118, 118, 119, 118, 119, 118, 118, 118, 118, 119, 117, 119, 118, 119,
117, 119, 117, 119, 117, 119, 117, 119, 117, 118, 118, 118, 122, 28, 7, 17, 9,
16, 10, 16, 11, 15, 11, 15, 12, 14, 12, 14, 12, 13, 12, 13, 13, 13, 13, 13, 14,
12, 13, 13, 13, 12, 13, 13, 14, 12, 13, 12, 13, 13, 13, 13, 13, 13, 13, 13, 13,
13, 12, 13, 13, 13, 13, 13, 13, 13, 12, 12, 12, 13, 13, 13, 13, 13, 14, 13, 13,
13, 12, 12, 13, 12, 13, 13, 13, 13, 13, 13, 13, 13, 13, 14, 12, 12, 13, 14, 13,
13, 13, 13, 12, 13, 13, 12, 14, 13, 13, 13, 13, 13, 13, 13, 13, 12, 13, 12, 12,
13, 13, 13, 13, 13, 13, 13, 12, 12, 12, 13, 13, 14, 12, 12, 13, 12, 12, 13, 12,
13, 13, 13, 12, 13, 13, 13, 13, 12, 13, 12, 14, 10, 19, -28, -51, -41, -49, -43,
-47, -44, -46, -44, -47, -44, -46, -45, -46, -46, -45, -45, -45, -46, -45, -45,
-45, -46, -45, -46, -44, -45, -45, -46, -45, -46, -45, -46, -45, -45, -46, -46,
-45, -46, -45, -46, -45, -46, -45, -45, -45, -45, -45, -45, -45, -46, -45, -46,
-45, -45, -46, -44, -45, -45, -46, -46, -45, -46, -45, -45, -46, -45, -45, -45,
-45, -44, -45, -45, -44, -45, -45, -45, -45, -45, -45, -45, -45, -45, -46, -45,
-46, -45, -45, -45, -45, -45, -45, -45, -45, -45, -46, -45, -44, -45, -45, -45,
-44, -45, -45, -45, -45, -45, -46, -45, -46, -46, -45, -45, -45, -45, -44, -45,
-45, -45, -45, -45, -45, -45, -45, -45, -45, -45, -45, -46, -45, -45, -44, -44,
-45, -45, -45, -45, -45, -45, -44, -44, -45, -45, -46, -45, -45, -45, -45, -44,
-45, -44, -44, -45, -45, -45, -44, -45, -45, -45, -44, -44, -44, -45, -45, -45,
-45, -45, -45, -44, -44, -45, -45, -44, -44, -45, -44, -44, -44, -44, -44, -45,
-44, -45, -44, -45, -44, -44, -45, -44, -45, -44, -44, -44, -44, -43, -44, -44,
-44, -44, -45, -44, -45, -43, -44, -45, -44, -44, -44, -44, -45, -44, -43, -45,
-44, -45, -44, -44, -45, -44, -44, -44, -44, -44, -45, -43, -44, -44, -45, -44,
-44, -44, -44, -44, -44, -44, -44, -45, -44, -44, -45, -44, -44, -43, -44, -44,
-44, -45, -44, -44, -44, -44, -44, -44, -44, -44, -44, -43, -44, -45, -43, -45,
-43, -44, -43, -45, -43, -45, -42, -47, -38, };