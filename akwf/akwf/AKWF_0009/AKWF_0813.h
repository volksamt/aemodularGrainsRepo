#define DATA_LENGTH 512
#define DATA AKWF_0813

const PROGMEM int8_t DATA[DATA_LENGTH] = {14, 25, 26, 24, 19, 17, 19, 26, 37,
51, 66, 79, 89, 94, 94, 91, 84, 76, 67, 61, 54, 50, 46, 43, 40, 34, 28, 20, 11,
3, -4, -12, -17, -20, -23, -23, -23, -24, -24, -24, -25, -25, -24, -23, -22,
-21, -18, -15, -13, -9, -7, -6, -3, -3, -1, 0, 1, 2, 3, 4, 5, 5, 5, 4, 5, 4, 3,
4, 3, 1, 1, -1, -1, -3, -3, -3, -5, -5, -6, -7, -8, -9, -10, -9, -10, -10, -9,
-10, -9, -11, -10, -10, -10, -9, -9, -8, -8, -7, -6, -7, -6, -5, -5, -5, -4, -3,
-4, -2, -3, -1, -2, -1, 0, 0, -1, 0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1,
1, 0, 0, 0, 0, -1, 0, 0, 0, -1, -1, 0, -1, -1, -1, 0, -1, 0, -1, -1, -2, -2, -1,
-2, -1, -1, -1, -2, -1, -2, -1, -1, -1, -2, -1, -2, 0, 0, -1, -1, -1, 0, -1, -1,
0, -1, -1, -1, -1, -1, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0,
0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 1, 0, 0, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 1, 1, 1, 0, 0, 1, 1, 0, 1, 1, 1, 0,
0, 1, 0, 0, 0, 1, 1, 1, 0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0,
0, 1, 0, 0, 1, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 1,
0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, -1, 0, 1, -1, 0, 1, 1, 0, 1, 0, -1,
1, 1, 0, 0, 0, 0, 0, 1, 0, 0, -1, -1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 1, 0,
0, 1, 1, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 1, 1, 1, 0, 0, 0, 1, 1, 1, 0,
1, 0, 1, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 1, 0,
1, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 1, 0,
0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0,
-1, 0, 0, 0, 0, 0, 0, 1, 0, 1, -1, 1, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0,
0, 0, 0, 0, 0, 0, 0, -1, -6, -18, -38, -62, -88, -109, -120, -116, -103, -78,
-51, -22, -1, };