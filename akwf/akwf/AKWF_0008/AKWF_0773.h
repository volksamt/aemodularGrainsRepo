#define DATA_LENGTH 512
#define DATA AKWF_0773

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 12, 16, 19, 22, 25, 27, 29,
31, 33, 34, 36, 37, 38, 41, 42, 44, 46, 49, 51, 54, 57, 61, 66, 69, 73, 77, 80,
84, 87, 89, 92, 94, 96, 97, 98, 99, 99, 100, 101, 103, 105, 106, 110, 111, 112,
114, 115, 115, 115, 115, 114, 114, 112, 111, 109, 106, 104, 101, 99, 97, 93, 90,
87, 84, 82, 80, 78, 76, 73, 72, 70, 67, 66, 64, 64, 61, 61, 60, 61, 60, 59, 60,
60, 60, 61, 62, 63, 64, 64, 61, 59, 50, 37, 20, 4, -10, -22, -30, -36, -42, -45,
-49, -51, -53, -55, -56, -57, -58, -59, -60, -61, -61, -63, -63, -65, -67, -68,
-71, -73, -74, -78, -79, -83, -85, -89, -91, -93, -96, -99, -101, -103, -104,
-107, -107, -109, -109, -110, -109, -109, -109, -109, -108, -107, -105, -103,
-101, -98, -95, -91, -85, -78, -71, -64, -57, -54, -49, -48, -47, -47, -47, -49,
-49, -50, -52, -52, -52, -51, -50, -47, -46, -42, -40, -37, -34, -31, -26, -24,
-19, -16, -13, -9, -5, -4, -3, -5, -6, -9, -12, -14, -15, -16, -17, -14, -11,
-8, -4, 0, 2, 5, 7, 9, 11, 12, 13, 14, 18, 18, 21, 22, 24, 27, 29, 32, 36, 39,
41, 41, 39, 33, 21, 7, -7, -18, -26, -33, -38, -41, -44, -47, -49, -50, -51,
-52, -53, -53, -53, -53, -53, -51, -52, -51, -51, -51, -50, -47, -42, -36, -33,
-31, -31, -31, -30, -30, -29, -27, -24, -20, -16, -11, -6, -3, 1, 6, 8, 11, 12,
15, 17, 20, 22, 24, 26, 29, 32, 36, 39, 44, 50, 54, 59, 64, 68, 72, 75, 79, 81,
83, 85, 85, 87, 87, 86, 86, 86, 87, 90, 92, 95, 99, 101, 104, 105, 107, 109,
110, 110, 109, 109, 108, 108, 105, 103, 101, 99, 96, 94, 90, 87, 85, 83, 80, 78,
76, 74, 72, 71, 68, 67, 65, 64, 63, 61, 60, 59, 59, 58, 58, 58, 59, 59, 60, 61,
63, 62, 63, 61, 56, 47, 32, 14, -2, -15, -25, -33, -38, -43, -48, -49, -52, -54,
-55, -57, -57, -59, -59, -61, -61, -62, -63, -65, -66, -68, -70, -72, -75, -77,
-80, -83, -86, -89, -93, -94, -97, -100, -103, -106, -109, -110, -113, -114,
-115, -117, -117, -118, -119, -119, -119, -119, -118, -117, -116, -114, -112,
-111, -108, -104, -99, -96, -91, -87, -85, -81, -79, -78, -76, -75, -73, -72,
-72, -71, -69, -69, -68, -67, -65, -62, -62, -59, -58, -57, -56, -55, -55, -54,
-54, -54, -54, -55, -56, -57, -60, -62, -65, -66, -70, -72, -73, -75, -76, -76,
-76, -75, -74, -72, -70, -68, -65, -63, -60, -56, -52, -48, -43, -39, -33, -30,
-24, -17, -10, -4, 2, 7, 7, 3, -8, -19, -29, -36, -42, -46, -49, -51, -53, -55,
-54, -56, -56, -57, -57, -56, -56, -56, -55, -54, -54, -52, -52, -49, -49, -46,
-42, -34, -26, -19, -15, -11, -7, -5, -2, };