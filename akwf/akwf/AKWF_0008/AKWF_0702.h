#define DATA_LENGTH 512
#define DATA AKWF_0702

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 8, 13, 17, 22, 26, 30, 33, 38, 41,
45, 47, 50, 53, 56, 58, 60, 63, 64, 67, 68, 70, 71, 73, 73, 76, 76, 78, 77, 79,
79, 80, 79, 80, 82, 55, 40, 33, 24, 19, 13, 9, 3, 0, -4, -8, -11, -14, -18, -20,
-23, -26, -28, -30, -33, -35, -36, -38, -41, -42, -43, -45, -46, -48, -49, -49,
-50, -51, -52, -54, -54, -54, -55, -56, -56, -57, -57, -56, -58, -47, -36, -33,
-27, -25, -22, -20, -16, -15, -13, -10, -8, -7, -6, -4, -2, -1, 0, 2, 3, 5, 6,
7, 9, 10, 11, 11, 13, 14, 15, 16, 16, 18, 19, 19, 19, 20, 22, 22, 23, 23, 25,
25, 26, 26, 27, 26, 28, 28, 29, 29, 29, 31, 30, 31, 32, 31, 32, 32, 33, 32, 34,
34, 34, 34, 34, 34, 34, 35, 36, 36, 35, 36, 36, 36, 36, 36, 35, 36, 35, 36, 37,
38, 40, 40, 41, 41, 42, 42, 43, 44, 44, 42, 43, 44, 45, 45, 45, 45, 45, 45, 46,
46, 45, 47, 46, 47, 47, 47, 48, 47, 48, 48, 48, 48, 48, 49, 48, 48, 50, 49, 49,
50, 49, 50, 49, 50, 50, 50, 50, 49, 50, 50, 50, 50, 50, 51, 51, 50, 51, 51, 50,
50, 50, 51, 51, 51, 51, 51, 52, 51, 52, 51, 52, 51, 51, 51, 51, 51, 51, 51, 52,
51, 52, 51, 52, 52, 51, 51, 51, 52, 51, 52, 51, 52, 51, 53, 48, 31, 27, 21, 17,
14, 11, 8, 5, 4, 1, -1, -3, -4, -7, -8, -9, -11, -13, -15, -16, -18, -19, -21,
-21, -22, -23, -24, -25, -27, -28, -27, -29, -29, -29, -31, -32, -32, -33, -33,
-35, -35, -36, -36, -37, -37, -38, -38, -38, -39, -39, -40, -39, -41, -40, -41,
-40, -41, -41, -41, -41, -42, -42, -42, -42, -42, -41, -41, -42, -51, -59, -63,
-65, -68, -71, -73, -75, -77, -79, -80, -81, -83, -84, -85, -87, -87, -89, -90,
-91, -92, -93, -94, -95, -95, -97, -97, -98, -99, -100, -100, -100, -102, -102,
-103, -104, -105, -105, -105, -106, -107, -106, -107, -107, -108, -108, -109,
-110, -110, -110, -110, -111, -112, -112, -112, -113, -113, -113, -113, -114,
-114, -114, -114, -114, -114, -115, -115, -116, -116, -116, -117, -116, -116,
-116, -116, -117, -118, -116, -118, -118, -117, -118, -117, -118, -118, -118,
-118, -119, -118, -118, -119, -118, -119, -118, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -115,
-99, -85, -78, -74, -70, -66, -63, -60, -57, -54, -53, -50, -48, -46, -43, -42,
-40, -39, -37, -35, -34, -32, -31, -30, -28, -27, -26, -24, -24, -22, -21, -19,
-19, -18, -17, -16, -16, -15, -14, -14, -12, -13, -11, -10, -9, -9, -10, -8, -7,
-8, -7, -5, -6, -6, -5, -5, -3, -3, -4, -3, -3, -2, -2, -1, -2, -2, -2, -2, -2,
-2, -1, -2, -1, -1, -1, };