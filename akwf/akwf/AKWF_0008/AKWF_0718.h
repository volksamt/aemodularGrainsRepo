#define DATA_LENGTH 512
#define DATA AKWF_0718

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 10, 13, 15, 19, 21, 23, 26,
28, 32, 34, 36, 38, 40, 42, 44, 47, 48, 51, 53, 54, 56, 58, 60, 61, 64, 65, 67,
69, 70, 72, 74, 75, 76, 78, 79, 81, 82, 83, 85, 87, 88, 89, 89, 91, 92, 94, 95,
96, 96, 98, 99, 100, 101, 102, 102, 104, 105, 105, 106, 108, 108, 109, 109, 109,
110, 112, 111, 113, 112, 113, 114, 115, 115, 115, 115, 116, 117, 116, 118, 118,
119, 118, 119, 118, 119, 118, 120, 118, 120, 118, 120, 116, 99, 91, 85, 79, 74,
69, 65, 60, 57, 53, 49, 46, 42, 39, 37, 34, 30, 27, 25, 23, 20, 18, 14, 12, 9,
7, 5, 2, 0, -1, -5, -6, -8, -10, -12, -14, -15, -18, -20, -21, -24, -25, -28,
-29, -31, -32, -34, -36, -37, -39, -40, -41, -43, -45, -46, -48, -49, -50, -53,
-53, -55, -55, -57, -59, -60, -61, -63, -63, -64, -66, -68, -69, -69, -71, -71,
-73, -73, -75, -76, -77, -78, -79, -80, -81, -81, -83, -83, -83, -85, -85, -87,
-88, -88, -89, -90, -90, -91, -92, -93, -93, -94, -95, -95, -95, -96, -97, -97,
-98, -98, -99, -99, -99, -100, -100, -101, -102, -101, -103, -103, -102, -104,
-103, -104, -103, -104, -105, -105, -104, -106, -105, -105, -105, -107, -106,
-107, -106, -106, -107, -106, -107, -106, -108, -92, -78, -71, -63, -58, -52,
-47, -42, -39, -33, -30, -24, -22, -17, -14, -11, -7, -4, -1, 1, 5, 8, 10, 13,
16, 19, 21, 24, 26, 28, 31, 34, 36, 38, 40, 43, 44, 47, 48, 51, 52, 55, 56, 59,
60, 62, 64, 66, 67, 69, 71, 73, 74, 76, 77, 78, 80, 81, 83, 84, 86, 86, 88, 89,
90, 91, 93, 93, 95, 96, 98, 98, 99, 99, 101, 102, 103, 104, 104, 105, 106, 107,
108, 108, 109, 111, 110, 111, 112, 112, 113, 114, 115, 115, 115, 116, 117, 117,
117, 117, 117, 118, 117, 117, 119, 118, 118, 118, 120, 118, 120, 118, 120, 114,
97, 90, 84, 78, 74, 69, 65, 60, 57, 53, 49, 46, 43, 39, 36, 33, 30, 28, 25, 22,
20, 17, 14, 12, 9, 7, 4, 3, 0, -2, -3, -6, -8, -10, -13, -14, -16, -18, -20,
-22, -24, -26, -27, -30, -30, -33, -34, -36, -37, -38, -41, -42, -43, -45, -47,
-48, -49, -51, -52, -54, -55, -57, -57, -59, -60, -62, -62, -63, -65, -66, -67,
-69, -70, -70, -73, -73, -74, -75, -76, -78, -78, -79, -80, -81, -81, -83, -83,
-84, -84, -86, -87, -88, -88, -89, -90, -90, -91, -92, -92, -93, -93, -94, -94,
-95, -96, -96, -98, -97, -99, -99, -100, -100, -101, -101, -100, -101, -102,
-102, -103, -103, -104, -104, -104, -104, -104, -105, -105, -105, -106, -106,
-106, -106, -106, -106, -106, -106, -107, -106, -106, -106, -107, -108, -89,
-77, -70, -62, -58, -52, -47, -42, -37, -33, -29, -25, -22, -17, -14, -10, -8,
-4, -1, };