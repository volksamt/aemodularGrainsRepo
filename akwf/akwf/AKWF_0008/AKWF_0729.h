#define DATA_LENGTH 512
#define DATA AKWF_0729

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 6, 9, 10, 14, 16, 18, 20, 23,
25, 27, 30, 32, 36, 40, 42, 44, 46, 48, 49, 52, 53, 56, 57, 59, 61, 62, 65, 67,
68, 70, 72, 74, 77, 78, 80, 82, 83, 86, 87, 89, 92, 93, 95, 97, 99, 101, 102,
105, 107, 109, 110, 108, 106, 105, 103, 100, 99, 97, 95, 93, 91, 89, 88, 85, 84,
81, 80, 78, 76, 74, 72, 70, 69, 67, 64, 63, 60, 63, 15, -9, -1, -10, -6, -15,
-10, -21, -8, 21, 13, 11, 1, -3, -4, -7, -8, -11, -12, -15, -16, -20, -21, -23,
-25, -28, -30, -32, -34, -37, -38, -40, -43, -45, -47, -49, -50, -53, -56, -57,
-60, -62, -64, -65, -68, -71, -72, -74, -76, -79, -80, -82, -85, -87, -89, -91,
-93, -94, -98, -100, -102, -104, -106, -107, -110, -112, -114, -116, -119, -119,
-115, -114, -112, -109, -107, -106, -103, -101, -98, -96, -94, -93, -91, -87,
-85, -84, -82, -80, -78, -75, -74, -71, -70, -66, -65, -63, -61, -59, -57, -54,
-52, -50, -48, -46, -43, -41, -39, -37, -36, -33, -31, -29, -27, -25, -23, -20,
-18, -16, -14, -12, -10, -8, -5, -4, -2, 1, 2, 2, 1, 2, 2, 2, 2, 2, 2, 1, 2, 2,
2, 2, 2, 2, 2, 2, 2, 3, 2, 2, 2, 2, 2, 2, 2, 2, 1, 2, 2, 2, 2, 1, 2, 2, 2, 2, 2,
2, 2, 3, 3, 2, 2, 2, 2, 2, 1, 1, 2, 2, 2, 2, 2, 3, 2, 1, 1, 3, 2, 2, 2, 2, 2, 2,
2, 2, 1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 2, 1, 2, 2, 2, 2, 2, 2, 3,
2, 2, 2, 2, 2, 1, 1, 2, 2, 2, 1, 1, 2, 2, 2, 3, 3, 2, 3, 2, 2, 3, 2, 3, 2, 2, 2,
2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 2, 2, 2, 1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2,
2, 2, 3, 2, 2, 2, 2, 3, 2, 2, 2, 2, 2, 2, 1, 3, 1, 2, 3, 2, 2, 1, 2, 2, 2, 2, 2,
3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 2, 3, 2, 1, 2, 2, 2, 2, 2, 2, 2, 2, 3, 1, 4, 6,
9, 11, 12, 15, 17, 19, 22, 24, 26, 29, 30, 34, 35, 39, 38, 44, 42, 51, 36, 0, 9,
8, 10, 12, 14, 16, 18, 21, 22, 26, 24, 32, 9, -5, -4, -6, -9, -10, -15, -13,
-22, -9, 29, 22, 25, 24, 24, 23, 23, 22, 22, 22, 21, 21, 20, 21, 18, 20, 19, 20,
17, 19, 3, -2, -4, 1, 9, 4, 4, 0, -1, -4, -6, -9, -9, 3, 7, 8, 12, 13, 17, 14,
26, 4, -23, -15, -19, -15, -17, -15, -15, -14, -14, -14, -13, -14, -12, -12,
-11, -12, -5, 5, 6, 0, -2, };