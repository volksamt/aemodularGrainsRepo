#define DATA_LENGTH 512
#define DATA AKWF_0739

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 8, 13, 18, 22, 26, 29, 32, 35, 38,
39, 43, 44, 46, 48, 49, 51, 52, 53, 54, 55, 56, 59, 59, 60, 62, 63, 65, 66, 67,
68, 69, 70, 73, 73, 74, 74, 77, 78, 80, 81, 84, 85, 86, 87, 90, 91, 93, 95, 96,
98, 100, 102, 104, 105, 106, 108, 108, 111, 111, 113, 114, 114, 115, 117, 118,
118, 118, 119, 119, 118, 119, 120, 119, 119, 119, 119, 119, 118, 118, 116, 117,
116, 115, 114, 114, 113, 112, 112, 111, 111, 110, 110, 110, 109, 108, 109, 108,
107, 107, 108, 106, 107, 106, 106, 107, 106, 106, 106, 106, 106, 106, 107, 106,
106, 105, 106, 106, 105, 104, 104, 104, 103, 103, 102, 101, 101, 101, 100, 100,
99, 99, 97, 96, 96, 94, 92, 90, 89, 89, 87, 86, 84, 82, 81, 80, 79, 76, 75, 73,
71, 69, 68, 66, 64, 63, 62, 65, 64, 64, 62, 61, 59, 58, 56, 54, 53, 51, 50, 48,
46, 43, 40, 38, 35, 33, 31, 29, 27, 25, 22, 20, 17, 15, 5, -4, -5, -10, -10,
-26, -45, -53, -60, -65, -71, -74, -77, -79, -82, -82, -82, -83, -84, -84, -85,
-83, -83, -83, -83, -83, -83, -85, -85, -86, -87, -87, -90, -90, -93, -94, -95,
-96, -97, -99, -102, -103, -104, -107, -108, -108, -110, -111, -112, -113, -114,
-113, -114, -113, -114, -113, -114, -113, -112, -111, -111, -110, -109, -108,
-108, -107, -106, -105, -104, -104, -103, -101, -101, -100, -98, -98, -96, -96,
-94, -94, -92, -91, -90, -89, -88, -87, -84, -83, -82, -81, -79, -78, -76, -74,
-71, -69, -67, -65, -62, -61, -58, -56, -54, -51, -49, -48, -45, -44, -40, -38,
-37, -35, -31, -29, -27, -25, -23, -21, -20, -17, -15, -13, -12, -10, -8, -7,
-4, -4, -4, -1, -2, 0, 1, 2, 2, 3, 2, 3, 4, 4, 4, 2, 3, 2, 2, 2, 1, 1, -1, -1,
-2, -2, -3, -5, -6, -6, -8, -9, -9, -10, -10, -11, -12, -13, -12, -13, -14, -14,
-15, -15, -15, -14, -16, -15, -15, -15, -15, -15, -15, -14, -14, -13, -13, -13,
-12, -12, -12, -12, -11, -11, -11, -10, -10, -10, -11, -10, -9, -9, -10, -9, -9,
-9, -8, -8, -8, -9, -10, -11, -11, -11, -11, -11, -13, -13, -13, -14, -14, -14,
-15, -16, -17, -18, -18, -20, -20, -21, -20, -21, -20, -15, -16, -15, -15, -16,
-16, -16, -15, -16, -17, -17, -18, -18, -19, -20, -20, -21, -22, -23, -23, -23,
-25, -26, -26, -26, -28, -28, -38, -43, -43, -46, -44, -60, -78, -82, -89, -92,
-95, -96, -97, -98, -99, -98, -97, -96, -95, -93, -91, -90, -87, -85, -84, -82,
-81, -80, -79, -78, -78, -78, -77, -77, -77, -77, -76, -76, -76, -77, -77, -78,
-77, -77, -77, -77, -76, -76, -75, -75, -74, -73, -70, -68, -68, -67, -65, -63,
-61, -58, -56, -55, -52, -50, -48, -46, -45, -41, -41, -26, -11, -5, };