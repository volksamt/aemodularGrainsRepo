#define DATA_LENGTH 512
#define DATA AKWF_0703

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 5, 6, 9, 10, 13, 14, 16, 17, 18,
20, 22, 24, 24, 26, 27, 28, 30, 31, 32, 34, 35, 36, 37, 38, 40, 40, 41, 42, 44,
44, 46, 47, 47, 47, 49, 49, 50, 51, 51, 53, 53, 54, 55, 55, 56, 58, 58, 58, 59,
60, 60, 62, 61, 62, 62, 63, 64, 64, 65, 65, 66, 66, 67, 67, 68, 68, 69, 70, 70,
70, 71, 70, 71, 71, 71, 72, 72, 73, 73, 74, 74, 74, 75, 75, 75, 75, 75, 76, 76,
77, 78, 78, 78, 77, 78, 78, 78, 79, 79, 79, 79, 79, 79, 80, 80, 79, 80, 81, 81,
81, 81, 80, 81, 82, 81, 82, 82, 82, 82, 83, 82, 82, 83, 83, 83, 82, 82, 83, 83,
83, 83, 83, 83, 83, 84, 83, 84, 84, 84, 83, 84, 83, 84, 84, 83, 84, 83, 84, 83,
83, 84, 84, 84, 84, 83, 84, 84, 83, 84, 83, 83, 83, 83, 84, 83, 83, 83, 83, 83,
83, 82, 82, 82, 82, 82, 82, 82, 82, 82, 83, 82, 82, 81, 82, 81, 80, 81, 81, 81,
80, 81, 79, 81, 79, 82, 77, 85, 54, 5, 8, -1, -1, -6, -7, -9, -10, -12, -14,
-15, -17, -18, -19, -19, -21, -21, -22, -23, -23, -24, -25, -26, -26, -27, -27,
-28, -28, -29, -29, -30, -30, -30, -31, -32, -32, -33, -33, -33, -34, -34, -34,
-34, -34, -35, -36, -36, -35, -36, -37, -37, -37, -37, -37, -38, -38, -38, -39,
-38, -39, -39, -39, -40, -40, -40, -40, -40, -40, -40, -40, -40, -41, -40, -41,
-41, -41, -41, -41, -41, -41, -41, -42, -41, -41, -42, -42, -42, -43, -42, -42,
-42, -42, -42, -42, -42, -43, -43, -42, -42, -42, -42, -42, -43, -43, -43, -43,
-44, -43, -43, -43, -43, -43, -43, -44, -43, -43, -44, -43, -43, -44, -44, -43,
-43, -44, -43, -44, -43, -44, -43, -44, -43, -43, -43, -43, -43, -43, -43, -43,
-43, -43, -43, -43, -43, -43, -43, -43, -43, -43, -42, -43, -43, -43, -43, -42,
-43, -43, -42, -42, -43, -42, -43, -42, -42, -42, -42, -43, -42, -42, -42, -42,
-42, -41, -41, -41, -42, -41, -42, -42, -41, -41, -41, -41, -41, -41, -40, -41,
-41, -41, -40, -40, -41, -40, -41, -41, -40, -40, -40, -40, -40, -39, -39, -40,
-39, -40, -40, -39, -39, -39, -39, -40, -38, -39, -39, -39, -38, -38, -38, -39,
-38, -38, -38, -37, -38, -38, -37, -38, -37, -38, -38, -37, -37, -37, -37, -37,
-37, -37, -37, -36, -37, -36, -37, -35, -36, -36, -36, -35, -36, -35, -35, -35,
-35, -34, -34, -35, -34, -34, -34, -34, -33, -34, -33, -35, -32, -34, -32, -35,
-31, -36, -31, -37, -26, -48, -128, -73, -46, -49, -39, -39, -32, -33, -28, -28,
-24, -25, -22, -22, -19, -18, -17, -16, -15, -14, -13, -12, -11, -10, -10, -8,
-8, -7, -7, -6, -5, -4, -5, -3, -3, -3, -2, -1, -2, 0, };