#define DATA_LENGTH 512
#define DATA AKWF_0742

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 6, 7, 10, 13, 14, 17, 19, 22,
25, 26, 29, 32, 34, 37, 39, 41, 44, 46, 49, 51, 55, 56, 59, 61, 63, 66, 68, 71,
73, 75, 76, 80, 81, 83, 86, 87, 89, 91, 93, 95, 96, 99, 100, 101, 103, 104, 106,
106, 108, 110, 111, 111, 113, 114, 115, 115, 116, 116, 118, 117, 118, 118, 118,
119, 119, 118, 118, 119, 119, 119, 119, 118, 118, 118, 117, 116, 116, 115, 115,
115, 114, 112, 110, 110, 110, 108, 107, 106, 105, 104, 103, 102, 99, 99, 98, 96,
95, 93, 92, 91, 89, 87, 85, 85, 83, 82, 80, 79, 77, 76, 75, 72, 70, 70, 68, 66,
66, 64, 62, 61, 59, 58, 57, 54, 53, 52, 51, 49, 48, 47, 46, 44, 43, 42, 41, 40,
38, 37, 36, 36, 36, 34, 33, 32, 31, 31, 30, 29, 28, 28, 27, 26, 26, 25, 25, 25,
24, 24, 23, 23, 23, 22, 22, 22, 22, 22, 21, 22, 21, 21, 21, 22, 22, 21, 21, 22,
22, 22, 21, 22, 23, 22, 23, 22, 23, 24, 25, 24, 25, 25, 25, 25, 26, 26, 27, 27,
28, 29, 28, 29, 30, 30, 31, 32, 31, 32, 33, 32, 33, 33, 34, 34, 34, 35, 35, 35,
35, 35, 35, 36, 35, 35, 35, 35, 34, 35, 34, 33, 33, 33, 32, 30, 30, 30, 28, 27,
27, 25, 25, 22, 22, 20, 19, 18, 16, 15, 13, 12, 9, 7, 6, 4, 2, 0, -2, -4, -6,
-8, -11, -14, -15, -17, -20, -22, -25, -27, -29, -32, -34, -37, -39, -41, -44,
-47, -49, -52, -55, -56, -59, -62, -64, -66, -68, -71, -73, -75, -77, -80, -82,
-84, -85, -88, -89, -91, -93, -95, -97, -98, -100, -102, -103, -104, -106, -107,
-109, -110, -111, -112, -112, -113, -115, -116, -115, -116, -118, -118, -118,
-118, -118, -119, -119, -120, -119, -119, -118, -119, -119, -118, -117, -118,
-117, -117, -116, -115, -115, -114, -113, -112, -111, -110, -110, -109, -107,
-106, -105, -104, -102, -101, -100, -99, -97, -97, -94, -93, -93, -91, -89, -87,
-87, -84, -83, -81, -81, -78, -77, -76, -74, -73, -71, -69, -68, -66, -64, -63,
-62, -60, -58, -58, -57, -55, -53, -52, -50, -49, -48, -47, -46, -44, -43, -42,
-41, -41, -39, -39, -36, -36, -35, -34, -33, -32, -31, -30, -29, -30, -29, -28,
-28, -27, -27, -25, -25, -24, -24, -24, -23, -23, -22, -22, -22, -21, -22, -21,
-22, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -22, -23, -22, -22, -22,
-23, -23, -23, -23, -24, -24, -24, -25, -25, -27, -26, -27, -27, -27, -28, -29,
-29, -29, -29, -29, -31, -32, -31, -31, -32, -33, -33, -34, -34, -34, -35, -35,
-35, -35, -35, -35, -35, -35, -35, -35, -35, -34, -35, -34, -34, -33, -33, -32,
-32, -30, -30, -29, -28, -28, -26, -25, -25, -24, -21, -20, -19, -17, -16, -15,
-12, -11, -9, -8, -6, -4, -1, 0, };