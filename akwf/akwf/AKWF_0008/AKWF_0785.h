#define DATA_LENGTH 512
#define DATA AKWF_0785

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 6, 6, 8, 8, 10, 11, 13, 15,
16, 17, 19, 21, 21, 23, 24, 26, 27, 28, 30, 31, 31, 33, 35, 36, 37, 39, 39, 42,
42, 44, 45, 46, 48, 48, 50, 51, 53, 54, 55, 55, 56, 58, 60, 60, 62, 62, 65, 65,
66, 67, 68, 69, 70, 71, 72, 74, 75, 76, 77, 78, 78, 80, 81, 81, 82, 84, 84, 85,
86, 86, 88, 88, 90, 91, 91, 93, 94, 93, 94, 94, 96, 97, 98, 99, 99, 99, 100,
101, 102, 103, 103, 104, 105, 105, 106, 106, 107, 108, 108, 109, 109, 110, 109,
111, 110, 111, 113, 113, 113, 114, 113, 113, 115, 115, 116, 115, 116, 117, 116,
116, 117, 118, 118, 118, 118, 118, 118, 119, 118, 119, 119, 119, 119, 119, 119,
119, 119, 119, 118, 118, 119, 118, 118, 117, 117, 118, 116, 116, 115, 114, 114,
114, 112, 110, 109, 108, 108, 106, 104, 103, 102, 100, 98, 96, 95, 94, 92, 92,
90, 90, 88, 86, 85, 84, 83, 81, 81, 78, 77, 77, 79, 82, 82, 84, 87, 90, 91, 91,
91, 91, 91, 89, 87, 85, 83, 81, 78, 76, 74, 71, 69, 67, 66, 63, 61, 61, 59, 59,
57, 56, 54, 53, 52, 51, 48, 47, 46, 46, 45, 44, 43, 41, 41, 40, 39, 38, 36, 35,
35, 33, 33, 31, 30, 27, 26, 26, 24, 23, 21, 20, 18, 17, 16, 14, 13, 10, 9, 8, 6,
5, 3, 2, 1, 0, -1, -3, -5, -7, -8, -10, -10, -12, -14, -15, -17, -17, -19, -21,
-21, -23, -24, -26, -26, -28, -30, -31, -31, -34, -35, -36, -37, -38, -40, -41,
-42, -44, -44, -46, -47, -49, -50, -51, -53, -54, -55, -55, -56, -57, -59, -61,
-62, -63, -64, -65, -67, -67, -68, -69, -70, -72, -73, -73, -74, -75, -77, -77,
-78, -80, -81, -82, -83, -83, -84, -85, -85, -87, -88, -89, -90, -91, -91, -92,
-94, -93, -95, -96, -96, -96, -98, -98, -99, -101, -101, -101, -102, -103, -104,
-104, -104, -105, -107, -106, -107, -107, -108, -109, -109, -110, -110, -111,
-112, -111, -112, -113, -112, -114, -114, -114, -115, -115, -115, -116, -116,
-117, -117, -117, -117, -118, -118, -118, -118, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -118, -119, -119, -119, -118,
-117, -117, -117, -116, -117, -116, -115, -113, -113, -111, -111, -109, -108,
-107, -107, -104, -102, -102, -100, -99, -98, -96, -94, -93, -92, -90, -90, -87,
-86, -85, -83, -83, -81, -79, -78, -78, -76, -79, -82, -82, -84, -87, -89, -90,
-91, -90, -91, -90, -89, -87, -85, -83, -80, -78, -76, -73, -71, -68, -67, -66,
-64, -62, -61, -59, -58, -57, -56, -53, -51, -51, -50, -49, -48, -47, -45, -45,
-44, -43, -42, -42, -40, -39, -38, -37, -35, -35, -33, -32, -31, -29, -28, -27,
-26, -24, -23, -22, -20, -19, -17, -15, -14, -12, -11, -10, -8, -6, -4, -4, -2,
-1, };