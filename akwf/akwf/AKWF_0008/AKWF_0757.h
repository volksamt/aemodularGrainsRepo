#define DATA_LENGTH 512
#define DATA AKWF_0757

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 4, 4, 4, 6, 6, 7, 8, 9, 10,
10, 11, 11, 12, 12, 12, 13, 13, 14, 14, 14, 15, 16, 16, 15, 16, 16, 16, 17, 17,
17, 18, 18, 19, 19, 19, 18, 19, 20, 21, 21, 22, 22, 23, 22, 24, 23, 25, 24, 25,
27, 27, 28, 29, 29, 30, 31, 32, 32, 33, 34, 35, 37, 37, 38, 39, 40, 41, 43, 43,
45, 47, 46, 48, 49, 50, 51, 53, 54, 56, 57, 58, 59, 60, 62, 62, 64, 65, 66, 68,
68, 70, 72, 72, 74, 75, 76, 77, 78, 79, 81, 82, 83, 84, 85, 86, 88, 89, 90, 90,
92, 93, 94, 95, 96, 97, 98, 99, 99, 100, 101, 103, 103, 104, 105, 106, 106, 107,
107, 107, 107, 107, 108, 108, 107, 108, 107, 106, 106, 104, 104, 103, 102, 101,
100, 99, 96, 95, 94, 92, 89, 87, 84, 82, 80, 78, 76, 73, 71, 68, 64, 61, 58, 54,
51, 48, 45, 42, 37, 34, 31, 26, 23, 20, 16, 13, 10, 6, 2, -1, -3, -7, -10, -13,
-16, -19, -21, -24, -26, -28, -31, -34, -35, -37, -38, -41, -41, -44, -45, -47,
-48, -49, -50, -51, -52, -53, -53, -54, -54, -55, -56, -57, -57, -57, -58, -58,
-58, -59, -58, -58, -59, -59, -59, -58, -58, -58, -57, -58, -57, -57, -57, -56,
-55, -55, -55, -54, -54, -54, -53, -53, -52, -52, -51, -50, -49, -49, -48, -48,
-46, -47, -45, -45, -44, -44, -44, -43, -42, -42, -40, -40, -39, -39, -38, -37,
-37, -36, -35, -35, -34, -33, -32, -31, -31, -31, -30, -29, -28, -28, -27, -27,
-27, -25, -25, -24, -24, -23, -22, -21, -22, -21, -20, -19, -18, -19, -18, -18,
-17, -16, -15, -15, -15, -14, -14, -14, -13, -13, -13, -12, -12, -12, -12, -11,
-12, -12, -12, -12, -12, -12, -13, -12, -13, -13, -13, -15, -14, -15, -16, -16,
-17, -18, -18, -19, -20, -21, -22, -23, -23, -24, -24, -26, -27, -28, -29, -30,
-31, -32, -33, -34, -35, -36, -37, -38, -39, -40, -42, -43, -45, -45, -47, -48,
-48, -50, -52, -52, -53, -54, -56, -56, -58, -59, -60, -61, -62, -64, -64, -65,
-66, -67, -69, -70, -71, -72, -73, -74, -75, -75, -77, -78, -78, -80, -80, -83,
-83, -84, -85, -86, -86, -87, -88, -89, -91, -90, -92, -93, -94, -94, -96, -96,
-97, -98, -99, -100, -100, -101, -102, -102, -103, -103, -104, -106, -106, -107,
-107, -108, -109, -109, -110, -111, -111, -112, -112, -113, -113, -114, -114,
-115, -115, -116, -116, -116, -117, -118, -118, -119, -119, -119, -119, -118,
-118, -119, -118, -118, -117, -117, -117, -115, -114, -114, -112, -112, -109,
-108, -106, -104, -103, -101, -98, -96, -94, -91, -88, -85, -82, -80, -76, -74,
-71, -68, -65, -61, -58, -56, -53, -50, -47, -44, -42, -39, -36, -35, -33, -30,
-27, -26, -24, -21, -19, -18, -16, -14, -13, -11, -10, -8, -8, -6, -4, -4, -2,
-1, };