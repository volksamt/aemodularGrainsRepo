#define DATA_LENGTH 512
#define DATA AKWF_0774

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 8, 16, 23, 33, 41, 47, 52, 57,
60, 63, 65, 68, 71, 73, 75, 75, 77, 78, 78, 78, 78, 77, 76, 75, 75, 74, 74, 75,
75, 75, 77, 79, 81, 84, 86, 90, 92, 96, 98, 100, 102, 102, 104, 105, 104, 104,
103, 101, 99, 97, 95, 95, 94, 95, 95, 95, 95, 95, 94, 92, 92, 89, 86, 85, 80,
77, 73, 69, 64, 60, 55, 50, 45, 41, 36, 32, 30, 25, 22, 21, 18, 16, 14, 12, 11,
10, 9, 8, 8, 8, 8, 7, 8, 9, 10, 11, 13, 15, 16, 18, 18, 17, 12, 4, -9, -26, -45,
-63, -79, -93, -103, -110, -113, -116, -114, -114, -110, -108, -103, -100, -96,
-92, -89, -86, -85, -81, -80, -79, -79, -79, -79, -81, -81, -82, -85, -86, -88,
-89, -91, -92, -94, -95, -95, -96, -95, -94, -95, -93, -91, -90, -87, -86, -83,
-80, -77, -73, -69, -65, -60, -55, -49, -42, -34, -24, -15, -7, 1, 6, 9, 10, 10,
8, 5, 1, -2, -6, -8, -11, -12, -12, -11, -9, -8, -4, -1, 4, 7, 11, 16, 20, 24,
27, 31, 34, 35, 36, 35, 31, 27, 23, 17, 12, 9, 7, 8, 9, 12, 17, 21, 24, 28, 32,
33, 36, 36, 38, 38, 39, 41, 41, 42, 44, 46, 47, 49, 52, 54, 55, 55, 53, 45, 33,
18, 0, -17, -31, -44, -53, -58, -63, -64, -63, -63, -60, -58, -56, -53, -50,
-47, -44, -39, -38, -34, -31, -29, -26, -22, -17, -10, -4, 1, 2, 5, 6, 7, 8, 9,
11, 14, 18, 22, 27, 33, 36, 41, 45, 46, 48, 50, 51, 52, 52, 53, 54, 55, 57, 60,
61, 65, 68, 73, 77, 81, 84, 87, 89, 91, 92, 93, 92, 91, 89, 87, 84, 80, 78, 75,
75, 76, 76, 78, 80, 81, 82, 83, 83, 84, 82, 80, 78, 74, 71, 68, 63, 59, 54, 50,
45, 41, 36, 31, 28, 24, 20, 18, 15, 13, 11, 9, 8, 7, 5, 4, 3, 3, 2, 3, 2, 4, 5,
5, 6, 7, 9, 11, 12, 12, 11, 5, -4, -18, -35, -55, -72, -88, -101, -109, -115,
-118, -119, -118, -116, -113, -110, -106, -102, -99, -95, -91, -89, -87, -85,
-83, -82, -83, -83, -84, -85, -86, -88, -89, -92, -93, -96, -97, -99, -100,
-102, -103, -104, -103, -104, -103, -102, -101, -100, -99, -96, -94, -91, -89,
-86, -82, -78, -75, -70, -66, -59, -54, -48, -42, -36, -31, -26, -23, -20, -18,
-17, -17, -16, -15, -16, -15, -15, -14, -14, -13, -11, -10, -9, -8, -7, -6, -6,
-5, -5, -5, -6, -7, -7, -9, -12, -14, -17, -20, -23, -27, -29, -32, -33, -35,
-35, -34, -32, -30, -27, -23, -20, -15, -12, -7, -2, 4, 9, 15, 20, 27, 33, 39,
45, 52, 59, 65, 69, 69, 65, 54, 42, 27, 13, 1, -9, -17, -23, -25, -27, -28, -28,
-27, -25, -24, -21, -19, -17, -15, -12, -9, -7, -5, -1, };