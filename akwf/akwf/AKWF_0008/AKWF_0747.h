#define DATA_LENGTH 512
#define DATA AKWF_0747

const PROGMEM int8_t DATA[DATA_LENGTH] = {25, 18, 8, 14, 16, 21, 22, 26, 28, 31,
33, 36, 38, 41, 43, 46, 49, 52, 54, 57, 59, 62, 63, 66, 68, 70, 72, 73, 75, 77,
78, 80, 81, 83, 84, 85, 87, 88, 89, 90, 90, 92, 93, 94, 94, 95, 95, 97, 97, 99,
100, 100, 100, 101, 100, 102, 103, 102, 104, 104, 104, 104, 105, 105, 106, 105,
105, 106, 106, 107, 107, 107, 108, 108, 108, 107, 108, 108, 108, 108, 109, 108,
108, 108, 108, 109, 108, 109, 109, 109, 108, 108, 108, 108, 108, 109, 107, 108,
107, 107, 107, 107, 107, 107, 107, 106, 107, 106, 107, 105, 106, 104, 106, 103,
106, 103, 106, 101, 104, 101, 104, 101, 101, 101, 99, 106, 60, 100, 81, 76, 94,
80, 85, 73, 78, 69, 71, 64, 65, 59, 58, 53, 52, 47, 46, 42, 40, 37, 34, 32, 30,
28, 24, 23, 20, 18, 16, 14, 11, 10, 8, 6, 4, 3, 1, 0, -2, -3, -5, -5, -7, -8,
-9, -11, -12, -13, -15, -16, -16, -18, -18, -20, -21, -22, -23, -25, -25, -27,
-26, -28, -29, -29, -29, -30, -33, -32, -33, -34, -35, -35, -36, -36, -38, -39,
-40, -39, -40, -40, -41, -42, -42, -43, -44, -44, -45, -45, -47, -46, -47, -48,
-48, -48, -49, -49, -49, -50, -51, -50, -51, -52, -53, -53, -53, -52, -54, -53,
-54, -55, -55, -55, -54, -55, -55, -56, -56, -56, -56, -57, -56, -58, -57, -59,
-58, -58, -58, -59, -59, -59, -59, -60, -60, -60, -60, -59, -60, -59, -60, -60,
-60, -61, -61, -61, -60, -61, -61, -60, -60, -60, -61, -60, -60, -61, -61, -61,
-60, -61, -61, -61, -61, -61, -60, -61, -60, -60, -60, -61, -60, -60, -61, -59,
-60, -60, -59, -59, -59, -59, -59, -59, -59, -59, -58, -59, -59, -58, -58, -58,
-57, -56, -58, -57, -57, -56, -56, -57, -55, -56, -55, -56, -54, -54, -54, -55,
-54, -54, -53, -54, -53, -53, -53, -53, -52, -52, -52, -51, -51, -51, -51, -51,
-50, -50, -49, -49, -49, -49, -48, -48, -48, -48, -48, -48, -47, -46, -46, -46,
-45, -46, -45, -46, -44, -44, -43, -44, -43, -43, -42, -43, -42, -42, -42, -41,
-41, -40, -40, -40, -40, -40, -39, -38, -37, -38, -37, -38, -36, -37, -37, -36,
-36, -35, -35, -34, -34, -34, -34, -34, -32, -32, -33, -32, -31, -31, -32, -30,
-30, -30, -29, -29, -29, -28, -28, -29, -27, -27, -27, -26, -26, -27, -26, -25,
-25, -24, -24, -24, -23, -23, -22, -23, -22, -22, -21, -22, -22, -21, -20, -20,
-19, -19, -19, -19, -19, -18, -18, -18, -17, -17, -17, -16, -17, -16, -15, -16,
-15, -14, -15, -14, -13, -14, -13, -12, -12, -12, -11, -12, -11, -11, -11, -10,
-9, -10, -9, -10, -9, -9, -9, -8, -8, -7, -7, -7, -7, -6, -7, -6, -7, -5, -7,
-4, -6, -3, -5, -2, -5, -2, -6, -1, -5, 0, -4, 0, -4, -1, 40, -11, };