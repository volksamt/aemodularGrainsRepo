#define DATA_LENGTH 512
#define DATA AKWF_0707

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 12, 18, 24, 30, 36, 42, 48, 53, 60,
64, 70, 74, 79, 83, 88, 92, 96, 99, 101, 105, 108, 111, 113, 114, 115, 116, 117,
118, 119, 119, 119, 118, 118, 117, 116, 115, 112, 111, 109, 107, 105, 103, 100,
98, 95, 92, 90, 86, 84, 81, 78, 74, 72, 68, 66, 63, 60, 58, 55, 52, 50, 48, 45,
44, 42, 39, 38, 36, 34, 33, 32, 32, 31, 30, 28, 29, 28, 28, 28, 27, 27, 27, 28,
28, 28, 28, 28, 29, 29, 29, 29, 30, 29, 31, 31, 31, 30, 31, 31, 30, 30, 30, 30,
30, 29, 28, 28, 27, 26, 25, 24, 23, 22, 20, 20, 17, 16, 15, 13, 12, 10, 8, 7, 5,
3, 1, 1, -2, -3, -4, -6, -6, -9, -10, -11, -11, -12, -14, -13, -14, -14, -14,
-14, -14, -14, -14, -13, -12, -12, -11, -9, -8, -7, -5, -3, -2, 0, 2, 4, 5, 8,
10, 12, 15, 18, 19, 21, 23, 25, 28, 30, 32, 34, 36, 38, 39, 41, 43, 45, 45, 45,
46, 47, 47, 48, 49, 48, 47, 47, 47, 45, 44, 43, 41, 40, 39, 36, 34, 31, 30, 27,
25, 21, 18, 16, 12, 9, 7, 3, 0, -3, -6, -9, -13, -15, -18, -21, -24, -26, -28,
-31, -33, -36, -37, -39, -40, -42, -43, -44, -44, -44, -44, -45, -45, -44, -43,
-43, -41, -40, -39, -38, -35, -33, -31, -29, -26, -23, -21, -19, -15, -12, -10,
-6, -3, 0, 3, 6, 9, 13, 16, 19, 22, 24, 26, 29, 31, 34, 35, 38, 39, 40, 41, 42,
44, 44, 45, 45, 45, 45, 44, 43, 42, 42, 40, 39, 37, 35, 33, 32, 29, 27, 24, 22,
19, 15, 12, 10, 7, 3, 1, -3, -6, -9, -13, -15, -18, -21, -23, -26, -29, -32,
-33, -36, -38, -40, -41, -43, -44, -45, -46, -46, -48, -48, -47, -47, -47, -47,
-47, -46, -45, -45, -42, -41, -40, -38, -36, -34, -32, -30, -28, -26, -24, -22,
-20, -17, -16, -13, -11, -8, -6, -4, -2, 1, 1, 3, 5, 7, 9, 9, 10, 12, 12, 13,
14, 14, 14, 15, 15, 14, 14, 13, 12, 12, 11, 10, 10, 9, 7, 6, 4, 3, 2, 1, -2, -3,
-4, -6, -8, -9, -11, -14, -15, -16, -17, -19, -20, -21, -23, -24, -25, -26, -27,
-28, -28, -29, -29, -30, -30, -30, -30, -31, -30, -31, -31, -31, -30, -30, -30,
-29, -29, -29, -29, -28, -28, -29, -27, -27, -27, -27, -27, -27, -28, -27, -28,
-30, -30, -30, -31, -33, -33, -35, -37, -38, -39, -41, -44, -46, -47, -49, -53,
-55, -57, -60, -62, -66, -69, -72, -75, -76, -80, -83, -87, -89, -92, -95, -97,
-100, -103, -105, -107, -109, -111, -113, -115, -116, -116, -117, -118, -119,
-119, -119, -119, -117, -117, -115, -114, -113, -110, -108, -106, -103, -100,
-96, -92, -88, -83, -80, -74, -70, -65, -59, -54, -48, -42, -37, -30, -25, -18,
-12, -6, 0, };