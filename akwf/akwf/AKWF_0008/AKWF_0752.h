#define DATA_LENGTH 512
#define DATA AKWF_0752

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 5, 6, 8, 10, 10, 12, 13, 14,
16, 16, 17, 18, 19, 20, 21, 21, 23, 24, 24, 25, 26, 26, 28, 28, 29, 30, 31, 32,
32, 33, 34, 34, 34, 36, 36, 37, 37, 38, 38, 40, 40, 40, 41, 42, 42, 42, 43, 43,
44, 44, 44, 45, 45, 46, 46, 47, 47, 48, 49, 49, 49, 49, 50, 50, 51, 51, 51, 52,
51, 52, 53, 53, 54, 54, 54, 54, 55, 55, 55, 55, 56, 55, 57, 56, 57, 56, 57, 57,
57, 57, 57, 58, 57, 58, 58, 58, 59, 58, 59, 59, 59, 59, 52, 49, 48, 46, 44, 44,
42, 42, 41, 40, 39, 39, 37, 37, 37, 36, 36, 35, 34, 34, 33, 33, 33, 33, 32, 31,
31, 31, 30, 30, 29, 29, 29, 28, 27, 28, 26, 27, 27, 26, 25, 25, 25, 24, 24, 24,
23, 23, 23, 23, 22, 23, 21, 22, 21, 22, 21, 22, 20, 20, 20, 21, 20, 19, 18, 19,
18, 18, 18, 18, 17, 17, 17, 17, 17, 16, 16, 16, 16, 16, 15, 15, 15, 15, 14, 14,
14, 14, 14, 13, 12, 21, 28, 30, 34, 35, 37, 39, 41, 41, 42, 44, 46, 46, 48, 48,
48, 49, 51, 51, 51, 53, 53, 53, 55, 54, 56, 56, 57, 57, 57, 59, 58, 59, 59, 59,
60, 60, 61, 61, 62, 62, 62, 61, 62, 62, 64, 63, 64, 63, 63, 64, 64, 65, 64, 65,
64, 65, 64, 66, 64, 66, 64, 66, 64, 66, 64, 66, 64, 66, 63, 66, 61, 15, 5, -1,
-2, 4, 1, 3, 2, 2, 1, 3, 1, 2, 2, 2, 10, 17, 18, 23, 23, 26, 28, 29, 30, 31, 33,
35, 35, 36, 37, 37, 39, 39, 40, 40, 42, 42, 42, 43, 44, 43, 45, 45, 45, 45, 46,
46, 47, 47, 47, 47, 46, 47, 47, 48, 48, 48, 46, 31, 26, 22, 18, 16, 13, 11, 8,
8, 5, 5, 4, 3, 1, 1, 1, 0, 0, 0, -1, 0, 0, -11, -16, -18, -21, -29, -38, -42,
-47, -49, -53, -55, -59, -61, -64, -65, -68, -69, -71, -74, -75, -77, -78, -81,
-82, -83, -84, -86, -87, -88, -89, -91, -93, -93, -95, -96, -96, -98, -99, -100,
-100, -102, -103, -103, -105, -105, -106, -106, -107, -107, -109, -110, -110,
-111, -112, -113, -113, -113, -114, -115, -114, -116, -115, -117, -115, -117,
-116, -119, -116, -121, -117, -123, -108, -65, -60, -52, -55, -58, -58, -60,
-59, -60, -59, -61, -60, -61, -60, -61, -71, -76, -79, -82, -84, -87, -88, -90,
-91, -92, -94, -95, -96, -97, -99, -99, -101, -101, -103, -103, -103, -104,
-105, -105, -106, -107, -108, -107, -109, -108, -101, -99, -97, -97, -95, -94,
-92, -93, -91, -91, -90, -90, -85, -69, -64, -59, -55, -53, -50, -48, -44, -42,
-40, -38, -37, -36, -34, -33, -32, -32, -31, -30, -30, -29, -30, -30, -29, -28,
-28, -19, -14, -11, -8, -6, -3, -2, 0, };