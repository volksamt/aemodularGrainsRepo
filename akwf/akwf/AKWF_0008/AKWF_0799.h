#define DATA_LENGTH 512
#define DATA AKWF_0799

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 9, 13, 18, 21, 25, 29, 33, 36,
40, 44, 47, 51, 54, 58, 62, 64, 68, 71, 74, 77, 80, 84, 85, 88, 90, 93, 95, 98,
100, 101, 104, 105, 107, 109, 111, 112, 112, 113, 114, 116, 116, 117, 117, 118,
118, 118, 118, 119, 119, 118, 119, 118, 118, 117, 116, 116, 114, 113, 113, 111,
109, 108, 106, 104, 103, 102, 99, 97, 96, 93, 91, 89, 86, 85, 81, 78, 76, 73,
69, 67, 64, 61, 58, 55, 52, 49, 45, 42, 39, 35, 32, 28, 25, 21, 18, 15, 11, 7,
4, 1, -2, -6, -10, -13, -16, -20, -23, -26, -29, -32, -36, -39, -42, -45, -48,
-51, -54, -56, -59, -62, -64, -67, -69, -71, -75, -76, -78, -80, -82, -84, -86,
-88, -89, -91, -92, -93, -94, -96, -96, -98, -99, -99, -100, -101, -101, -102,
-102, -101, -102, -103, -102, -101, -102, -102, -101, -101, -100, -101, -99,
-99, -97, -96, -96, -94, -93, -92, -92, -90, -89, -87, -86, -85, -83, -81, -79,
-77, -76, -75, -73, -71, -68, -67, -65, -63, -62, -59, -56, -54, -52, -50, -48,
-45, -42, -39, -36, -34, -30, -27, -24, -20, -17, -14, -12, -7, -5, -1, 2, 5, 9,
12, 15, 18, 22, 24, 27, 30, 33, 36, 38, 39, 42, 43, 45, 46, 48, 49, 50, 50, 52,
52, 52, 52, 52, 52, 52, 51, 49, 49, 48, 46, 46, 43, 42, 39, 38, 36, 34, 32, 28,
27, 24, 22, 18, 16, 13, 11, 8, 6, 3, 1, -2, -4, -7, -9, -12, -13, -16, -18, -20,
-22, -24, -26, -28, -29, -31, -32, -34, -36, -37, -37, -39, -40, -41, -40, -41,
-42, -42, -43, -43, -43, -43, -41, -41, -40, -40, -39, -38, -38, -35, -34, -34,
-32, -31, -29, -27, -25, -23, -21, -19, -16, -15, -12, -10, -8, -4, -2, 0, 3, 6,
8, 11, 14, 16, 19, 22, 26, 29, 31, 34, 37, 40, 44, 46, 49, 53, 56, 58, 61, 64,
66, 69, 72, 74, 77, 79, 82, 83, 86, 89, 90, 93, 95, 97, 98, 100, 102, 102, 104,
105, 106, 107, 108, 109, 109, 110, 110, 111, 110, 110, 110, 110, 109, 109, 107,
107, 105, 104, 103, 102, 100, 98, 96, 94, 92, 90, 88, 85, 83, 81, 78, 75, 71,
69, 66, 62, 60, 55, 52, 49, 45, 41, 38, 34, 30, 26, 23, 19, 16, 12, 9, 4, 0, -3,
-8, -11, -15, -19, -22, -27, -29, -33, -37, -41, -44, -48, -51, -53, -57, -60,
-63, -66, -70, -72, -75, -77, -80, -83, -85, -88, -90, -92, -95, -97, -98, -100,
-102, -103, -105, -107, -107, -108, -110, -111, -113, -113, -114, -114, -114,
-115, -115, -115, -115, -115, -115, -115, -115, -114, -114, -113, -112, -111,
-111, -110, -109, -108, -106, -104, -103, -101, -100, -97, -95, -92, -91, -88,
-86, -83, -80, -78, -75, -72, -69, -66, -62, -59, -55, -52, -49, -45, -41, -38,
-34, -30, -25, -22, -18, -14, -10, -7, -3, };