#define DATA_LENGTH 512
#define DATA AKWF_0793

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 8, 10, 12, 14, 15, 17, 18,
20, 22, 24, 24, 25, 27, 29, 31, 31, 31, 34, 34, 36, 36, 37, 39, 39, 40, 42, 42,
43, 43, 44, 45, 46, 47, 47, 47, 48, 48, 49, 49, 49, 51, 51, 51, 51, 52, 52, 53,
52, 54, 54, 54, 53, 54, 54, 54, 54, 55, 54, 55, 55, 53, 68, 79, 82, 87, 89, 92,
95, 97, 99, 102, 103, 104, 106, 107, 108, 109, 111, 111, 112, 113, 114, 114,
116, 116, 117, 117, 117, 118, 118, 118, 119, 119, 118, 120, 113, 98, 93, 89, 85,
83, 80, 77, 76, 74, 71, 70, 68, 65, 65, 63, 61, 60, 59, 58, 56, 56, 54, 53, 53,
51, 50, 50, 48, 48, 46, 46, 45, 43, 43, 42, 42, 41, 40, 39, 39, 38, 37, 37, 36,
35, 35, 34, 34, 33, 33, 31, 32, 31, 30, 30, 30, 28, 29, 28, 28, 28, 26, 27, 26,
27, 26, 25, 25, 24, 24, 24, 24, 24, 23, 23, 23, 23, 23, 22, 22, 22, 22, 21, 22,
21, 22, 22, 21, 21, 21, 20, 20, 21, 20, 20, 20, 20, 21, 21, 20, 16, 14, 14, 13,
13, 10, 10, 9, 3, 2, 2, 1, 1, 1, -6, -10, -10, -11, -14, -14, -15, -16, -16,
-16, -17, -18, -17, -19, -17, -23, -31, -33, -36, -38, -40, -40, -42, -43, -45,
-45, -47, -47, -49, -49, -50, -50, -51, -51, -51, -52, -53, -53, -54, -54, -55,
-55, -54, -55, -55, -55, -56, -56, -56, -55, -56, -56, -60, -63, -63, -64, -65,
-66, -66, -67, -67, -68, -68, -69, -69, -69, -70, -70, -70, -71, -70, -71, -71,
-72, -73, -72, -73, -73, -73, -73, -74, -74, -74, -74, -75, -74, -75, -75, -75,
-74, -75, -75, -75, -76, -75, -76, -76, -77, -76, -76, -76, -77, -77, -77, -77,
-77, -77, -77, -78, -77, -77, -77, -77, -77, -77, -77, -77, -77, -77, -78, -78,
-78, -78, -78, -78, -77, -76, -79, -76, -57, -44, -39, -35, -32, -27, -24, -21,
-19, -15, -13, -11, -10, -8, -5, -4, 0, -1, 2, 2, 6, 6, 10, 7, 15, 42, 49, 50,
54, 53, 64, 93, 103, 109, 113, 117, 117, 121, 107, 83, 78, 69, 65, 59, 57, 52,
50, 47, 44, 41, 40, 38, 36, 35, 33, 31, 30, 30, 29, 28, 27, 26, 25, 24, 23, 23,
23, 22, 21, 21, 22, 21, 21, 21, 21, 20, 15, 13, 12, 7, 2, 2, -2, -9, -12, -14,
-16, -16, -17, -18, -28, -36, -38, -41, -43, -45, -47, -49, -49, -51, -51, -52,
-54, -53, -54, -54, -55, -55, -55, -57, -62, -64, -65, -66, -67, -68, -68, -69,
-69, -70, -71, -71, -71, -72, -73, -73, -73, -73, -74, -74, -74, -75, -74, -75,
-75, -76, -76, -76, -75, -77, -76, -77, -77, -77, -77, -76, -77, -78, -77, -77,
-77, -77, -77, -77, -77, -77, -80, -62, -42, -37, -31, -26, -21, -18, -15, -12,
-8, -5, -3, -1, };