#define DATA_LENGTH 512
#define DATA AKWF_0721

const PROGMEM int8_t DATA[DATA_LENGTH] = {66, 103, 110, 121, 117, 116, 107, 107,
102, 101, 97, 97, 94, 92, 90, 90, 87, 86, 84, 83, 81, 80, 79, 78, 76, 75, 74,
72, 71, 70, 69, 67, 67, 66, 65, 63, 62, 61, 61, 59, 58, 57, 56, 56, 55, 54, 53,
51, 51, 51, 49, 49, 47, 46, 46, 45, 44, 42, 43, 42, 40, 41, 39, 39, 38, 37, 37,
36, 35, 34, 34, 33, 32, 32, 31, 29, 29, 29, 28, 27, 26, 26, 25, 24, 24, 24, 22,
21, 21, 21, 20, 19, 19, 19, 18, 16, 17, 16, 15, 15, 14, 14, 13, 13, 12, 11, 11,
10, 9, 10, 9, 7, 8, 7, 7, 6, 5, 6, 5, 4, 5, 3, 2, 3, 1, 2, 0, 1, 0, 0, 0, -2,
-2, -2, -1, -2, -3, -3, -4, -5, -4, -6, -5, -6, -6, -7, -7, -7, -8, -9, -9, -9,
-9, -10, -10, -11, -10, -11, -11, -12, -12, -13, -13, -13, -13, -13, -15, -14,
-14, -16, -15, -16, -16, -16, -17, -17, -17, -18, -17, -17, -18, -18, -19, -19,
-19, -19, -19, -20, -20, -20, -21, -21, -21, -21, -22, -22, -22, -22, -22, -22,
-22, -23, -23, -23, -24, -23, -24, -23, -24, -24, -24, -25, -24, -25, -25, -25,
-25, -26, -25, -25, -26, -26, -26, -26, -26, -27, -26, -26, -26, -27, -26, -27,
-26, -27, -27, -28, -27, -26, -27, -27, -27, -27, -27, -27, -27, -27, -28, -28,
-27, -28, -27, -28, -28, -28, -28, -28, -29, -26, -33, -40, -38, -37, -35, -35,
-35, -34, -34, -33, -32, -32, -31, -31, -31, -31, -29, -29, -29, -29, -29, -28,
-28, -28, -28, -27, -27, -26, -25, -26, -25, -25, -25, -25, -25, -24, -24, -24,
-24, -24, -23, -22, -23, -23, -22, -22, -22, -22, -22, -22, -21, -21, -21, -20,
-20, -20, -20, -19, -20, -19, -19, -19, -19, -19, -18, -18, -18, -18, -18, -18,
-17, -17, -17, -17, -17, -17, -16, -16, -16, -16, -16, -16, -15, -15, -15, -15,
-14, -15, -15, -14, -15, -14, -14, -14, -14, -14, -14, -14, -13, -13, -13, -13,
-12, -12, -13, -12, -13, -13, -13, -11, -12, -12, -12, -11, -11, -11, -11, -11,
-11, -11, -11, -11, -10, -10, -10, -11, -10, -10, -9, -9, -10, -10, -9, -9, -9,
-9, -10, -8, -9, -8, -9, -9, -8, -8, -8, -8, -8, -7, -8, -8, -7, -7, -8, -8, -7,
-7, -7, -7, -7, -6, -7, -7, -7, -7, -6, -6, -6, -7, -6, -6, -6, -6, -6, -6, -6,
-5, -5, -6, -6, -5, -6, -6, -5, -5, -6, -6, -4, -5, -6, -5, -5, -4, -5, -5, -5,
-5, -5, -5, -5, -4, -5, -4, -4, -4, -5, -4, -4, -5, -4, -4, -4, -5, -4, -4, -4,
-4, -4, -4, -3, -4, -4, -4, -4, -4, -3, -4, -4, -4, -3, -4, -4, -4, -3, -4, -4,
-4, -3, -4, -3, -4, -3, -4, -4, -4, -4, -4, -4, -3, -4, -4, -4, -4, -4, -3, };