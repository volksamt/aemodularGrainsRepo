#define DATA_LENGTH 512
#define DATA AKWF_0794

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 2, 2, 2, 3, 3, 4, 4, 5, 6, 5,
6, 8, 7, 8, 8, 9, 8, 10, 10, 11, 10, 12, 12, 12, 13, 14, 14, 15, 14, 17, 40, 44,
35, 30, 30, 29, 29, 28, 28, 28, 27, 26, 26, 26, 26, 24, 24, 24, 23, 22, 23, 22,
21, 22, 21, 20, 19, 20, 18, 19, 16, 18, 14, 26, 55, 62, 68, 70, 74, 76, 80, 82,
84, 87, 89, 90, 93, 94, 96, 98, 99, 100, 101, 103, 104, 106, 107, 108, 109, 111,
111, 112, 114, 115, 117, 117, 119, 118, 117, 116, 116, 114, 113, 112, 111, 111,
109, 108, 107, 106, 104, 104, 103, 101, 100, 99, 99, 97, 96, 95, 94, 92, 90, 89,
89, 88, 86, 85, 83, 83, 82, 80, 79, 78, 77, 74, 73, 71, 70, 68, 67, 66, 64, 61,
60, 57, 56, 53, 52, 46, 49, 25, 10, 17, 14, 18, 16, 19, 18, 20, 21, 22, 22, 24,
24, 25, 26, 26, 28, 29, 30, 30, 31, 32, 33, 33, 35, 35, 36, 37, 38, 38, 40, 38,
44, 26, 9, 14, 10, 11, 9, 10, 8, 8, 7, 6, 5, 4, 5, 3, 3, 3, 3, 1, 1, 0, 0, -1,
-2, -3, -2, -4, -4, -4, -4, -6, -7, -6, -8, -7, -9, -9, -10, -10, -10, -11, -12,
-12, -12, -13, -14, -14, -14, -15, -16, -16, -16, -17, -17, -19, -18, -20, -19,
-20, -21, -22, -22, -22, -23, -24, -23, -23, -25, -25, -25, -26, -27, -27, -27,
-27, -28, -29, -29, -30, -30, -31, -32, -31, -32, -32, -33, -33, -33, -34, -34,
-35, -36, -35, -36, -36, -37, -37, -38, -37, -39, -39, -40, -39, -40, -40, -41,
-41, -42, -41, -43, -43, -43, -43, -44, -44, -45, -44, -45, -46, -46, -47, -46,
-47, -47, -48, -48, -49, -49, -49, -50, -50, -50, -51, -51, -51, -51, -52, -53,
-53, -54, -54, -53, -54, -54, -55, -55, -56, -55, -55, -57, -57, -57, -57, -58,
-58, -59, -59, -59, -59, -60, -60, -61, -61, -61, -62, -62, -62, -61, -61, -60,
-60, -60, -60, -59, -59, -58, -58, -58, -57, -57, -57, -56, -56, -55, -55, -55,
-54, -54, -54, -54, -53, -53, -52, -52, -52, -52, -51, -51, -50, -50, -50, -48,
-48, -49, -48, -48, -47, -47, -47, -46, -46, -46, -45, -44, -45, -44, -43, -44,
-43, -42, -43, -42, -41, -41, -40, -41, -40, -40, -38, -39, -39, -38, -38, -38,
-37, -36, -35, -36, -36, -35, -35, -35, -34, -33, -33, -32, -32, -32, -31, -31,
-31, -30, -30, -30, -29, -29, -28, -28, -28, -27, -27, -26, -26, -26, -25, -25,
-25, -24, -23, -23, -23, -23, -22, -21, -21, -21, -20, -20, -20, -19, -18, -18,
-19, -18, -18, -17, -16, -16, -15, -15, -15, -14, -14, -13, -12, -12, -12, -12,
-11, -11, -10, -10, -9, -9, -8, -8, -7, -7, -7, -7, -5, -6, -6, -4, -4, -4, -4,
-3, -3, -2, -1, -1, 0, 0, };