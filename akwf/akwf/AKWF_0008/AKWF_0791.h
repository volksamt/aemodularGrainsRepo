#define DATA_LENGTH 512
#define DATA AKWF_0791

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 3, 4, 4, 5, 5, 5, 6, 8, 8, 8,
10, 10, 11, 11, 10, 11, 12, 12, 14, 14, 14, 16, 15, 15, 17, 16, 18, 18, 19, 19,
20, 23, 27, 32, 35, 39, 43, 47, 51, 55, 59, 62, 64, 67, 71, 74, 77, 80, 82, 84,
86, 89, 91, 93, 94, 99, 104, 104, 107, 109, 109, 112, 112, 113, 114, 115, 116,
117, 117, 117, 118, 118, 118, 118, 119, 117, 118, 118, 118, 119, 119, 118, 119,
119, 120, 118, 120, 118, 119, 120, 119, 119, 118, 118, 118, 118, 117, 117, 116,
116, 116, 115, 114, 114, 113, 112, 112, 111, 109, 109, 107, 107, 107, 106, 104,
103, 101, 101, 99, 98, 98, 97, 96, 96, 96, 96, 95, 94, 94, 94, 93, 93, 93, 93,
93, 93, 91, 91, 90, 88, 87, 87, 87, 85, 84, 83, 82, 81, 80, 79, 78, 76, 75, 73,
72, 70, 69, 67, 66, 65, 63, 61, 59, 57, 57, 55, 54, 52, 51, 50, 50, 47, 47, 46,
45, 45, 44, 43, 42, 42, 42, 40, 39, 39, 38, 38, 36, 36, 35, 34, 33, 33, 32, 32,
32, 30, 30, 28, 29, 26, 26, 24, 24, 22, 21, 19, 17, 16, 14, 12, 11, 9, 8, 7, 6,
6, 5, 4, 4, 4, 3, 3, 3, 2, 2, 3, 3, 3, 3, 3, 1, -1, 0, 0, -2, -4, -3, -4, -4,
-4, -5, -6, -5, -6, -7, -7, -8, -9, -10, -10, -11, -11, -12, -13, -13, -15, -15,
-16, -18, -18, -20, -21, -23, -23, -24, -25, -26, -27, -27, -28, -29, -30, -30,
-31, -31, -33, -33, -34, -34, -35, -35, -36, -37, -37, -38, -38, -39, -41, -41,
-43, -43, -44, -45, -45, -46, -47, -47, -49, -49, -50, -52, -52, -53, -54, -55,
-56, -56, -57, -59, -60, -60, -61, -63, -64, -65, -65, -66, -67, -69, -70, -70,
-71, -73, -73, -74, -75, -76, -76, -77, -78, -78, -78, -80, -80, -80, -82, -81,
-81, -82, -82, -82, -83, -83, -83, -83, -84, -84, -83, -84, -84, -83, -84, -85,
-85, -85, -85, -85, -85, -85, -86, -86, -86, -86, -86, -86, -86, -86, -87, -86,
-86, -86, -86, -87, -87, -87, -87, -88, -88, -88, -88, -88, -87, -88, -88, -88,
-88, -88, -88, -89, -88, -89, -89, -88, -88, -89, -89, -89, -89, -89, -88, -88,
-88, -88, -87, -87, -87, -87, -85, -84, -84, -84, -82, -81, -81, -81, -81, -81,
-80, -78, -78, -77, -77, -75, -75, -74, -73, -72, -72, -71, -70, -69, -69, -68,
-66, -66, -65, -63, -63, -62, -61, -60, -60, -58, -57, -57, -56, -56, -53, -53,
-53, -51, -50, -50, -48, -47, -47, -46, -45, -44, -43, -42, -40, -39, -39, -37,
-38, -36, -35, -34, -32, -31, -31, -30, -29, -29, -28, -27, -25, -25, -23, -23,
-21, -22, -19, -20, -19, -18, -17, -16, -14, -14, -13, -12, -11, -11, -10, -10,
-9, -8, -7, -5, -5, -4, -3, -3, -2, -1, -1, -1, };