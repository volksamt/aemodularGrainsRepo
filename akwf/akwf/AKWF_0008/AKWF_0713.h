#define DATA_LENGTH 512
#define DATA AKWF_0713

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 1, 1, 1, 3, 2, 2, 3, 4, 3, 4,
5, 4, 5, 5, 6, 6, 6, 6, 7, 8, 7, 7, 8, 8, 9, 9, 10, 10, 10, 11, 11, 10, 11, 12,
12, 12, 14, 12, 13, 15, 14, 14, 19, 28, 37, 44, 52, 60, 66, 73, 81, 89, 95, 103,
112, 119, 119, 117, 116, 116, 115, 114, 114, 114, 112, 112, 112, 110, 110, 109,
109, 108, 107, 107, 106, 106, 105, 104, 103, 103, 102, 101, 101, 100, 99, 99,
98, 97, 96, 97, 96, 95, 94, 93, 93, 93, 91, 91, 91, 90, 89, 88, 87, 87, 86, 86,
85, 84, 84, 83, 82, 82, 81, 81, 80, 79, 78, 78, 76, 77, 76, 74, 75, 73, 73, 72,
71, 71, 70, 70, 70, 69, 68, 67, 66, 66, 65, 64, 63, 63, 63, 62, 62, 60, 60, 59,
59, 58, 57, 57, 56, 56, 54, 54, 54, 53, 51, 52, 50, 51, 50, 49, 48, 47, 46, 47,
46, 45, 44, 44, 43, 41, 41, 42, 40, 40, 38, 39, 38, 37, 36, 36, 35, 34, 35, 33,
32, 33, 31, 30, 31, 31, 25, 14, 10, 11, 11, 9, 7, 8, 7, 5, 5, 3, 2, 1, 1, -1,
-2, -3, -3, -5, -6, -6, -8, -9, -9, -10, -12, -13, -14, -15, -16, -17, -18, -19,
-19, -21, -22, -23, -23, -24, -26, -28, -28, -29, -30, -32, -33, -34, -34, -34,
-36, -37, -38, -39, -41, -41, -42, -43, -44, -45, -46, -47, -48, -49, -50, -52,
-52, -53, -54, -55, -56, -57, -57, -59, -60, -61, -62, -63, -63, -64, -66, -67,
-68, -69, -69, -71, -72, -73, -74, -76, -75, -75, -76, -74, -75, -74, -73, -74,
-74, -73, -73, -72, -72, -71, -71, -71, -71, -70, -69, -69, -68, -69, -68, -68,
-67, -67, -67, -66, -66, -66, -66, -65, -65, -64, -64, -65, -64, -64, -63, -63,
-62, -62, -62, -62, -61, -60, -60, -59, -60, -59, -58, -59, -58, -57, -57, -57,
-56, -56, -57, -55, -56, -56, -56, -54, -54, -54, -54, -52, -53, -53, -52, -52,
-52, -51, -50, -51, -51, -50, -49, -49, -49, -48, -48, -48, -47, -47, -47, -46,
-46, -46, -45, -45, -44, -44, -44, -44, -44, -43, -42, -42, -42, -41, -42, -41,
-41, -41, -39, -40, -39, -39, -39, -38, -39, -38, -37, -37, -37, -36, -36, -36,
-35, -34, -34, -34, -34, -33, -32, -33, -33, -32, -32, -31, -31, -31, -30, -31,
-30, -30, -29, -30, -28, -28, -27, -27, -28, -27, -27, -27, -26, -26, -25, -25,
-25, -25, -25, -23, -23, -23, -22, -22, -22, -21, -22, -21, -22, -20, -20, -20,
-19, -18, -19, -18, -18, -18, -17, -18, -17, -16, -16, -16, -15, -15, -15, -14,
-14, -14, -13, -13, -13, -13, -12, -12, -11, -11, -11, -11, -10, -10, -9, -9,
-9, -8, -8, -8, -7, -8, -7, -6, -5, -6, -6, -5, -5, -5, -3, -4, -4, -2, -2, -3,
-2, -2, -2, -1, -1, -1, 0, };