#define DATA_LENGTH 512
#define DATA AKWF_0767

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 7, 9, 10, 13, 14, 14, 16,
18, 19, 20, 22, 24, 25, 26, 27, 28, 30, 31, 32, 34, 35, 37, 38, 40, 41, 42, 42,
44, 45, 46, 47, 48, 49, 50, 52, 52, 54, 55, 55, 56, 57, 58, 59, 60, 60, 62, 62,
64, 65, 66, 65, 66, 68, 68, 69, 70, 71, 71, 72, 73, 73, 75, 75, 75, 77, 77, 78,
78, 79, 79, 80, 81, 82, 81, 83, 83, 83, 84, 85, 84, 85, 86, 87, 87, 86, 87, 88,
88, 89, 89, 91, 90, 90, 91, 91, 91, 92, 93, 92, 93, 93, 94, 94, 94, 94, 94, 95,
95, 95, 95, 95, 96, 96, 95, 96, 95, 94, 95, 95, 95, 94, 94, 94, 94, 93, 92, 92,
92, 91, 91, 91, 90, 90, 89, 88, 88, 88, 87, 86, 86, 85, 84, 84, 84, 83, 83, 82,
81, 81, 80, 78, 79, 78, 77, 76, 75, 76, 75, 74, 73, 73, 72, 70, 70, 68, 68, 67,
66, 64, 64, 62, 62, 60, 59, 58, 57, 56, 54, 54, 53, 51, 50, 49, 47, 47, 46, 44,
42, 42, 40, 40, 38, 37, 35, 35, 33, 33, 31, 29, 29, 28, 26, 25, 24, 23, 22, 20,
20, 19, 17, 16, 15, 15, 13, 12, 11, 10, 9, 8, 8, 6, 6, 4, 3, 3, 1, 1, 0, -2, -2,
-3, -4, -5, -7, -6, -8, -8, -9, -10, -11, -12, -13, -13, -14, -15, -17, -18,
-19, -20, -20, -23, -23, -24, -26, -26, -27, -29, -30, -32, -33, -35, -35, -37,
-37, -39, -40, -42, -43, -44, -45, -47, -47, -49, -50, -52, -53, -54, -56, -57,
-58, -59, -61, -61, -63, -63, -65, -66, -67, -68, -70, -70, -71, -73, -73, -74,
-76, -77, -79, -78, -80, -81, -82, -83, -84, -84, -85, -85, -87, -88, -88, -89,
-90, -90, -92, -92, -92, -94, -94, -94, -95, -96, -97, -99, -99, -99, -100,
-100, -100, -101, -102, -103, -102, -103, -104, -104, -105, -106, -105, -107,
-106, -107, -107, -108, -109, -108, -108, -109, -110, -110, -111, -111, -112,
-111, -111, -112, -112, -112, -113, -113, -113, -114, -114, -113, -115, -115,
-115, -115, -115, -115, -116, -116, -117, -116, -117, -116, -117, -118, -117,
-117, -117, -118, -118, -117, -117, -118, -119, -118, -118, -118, -118, -119,
-118, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -118, -119, -119, -119, -117, -118, -118, -117, -117,
-117, -116, -116, -116, -115, -115, -115, -114, -113, -112, -112, -112, -110,
-111, -110, -109, -108, -108, -107, -106, -105, -105, -104, -103, -102, -101,
-100, -98, -97, -97, -95, -94, -93, -92, -91, -90, -88, -88, -86, -85, -84, -82,
-81, -80, -78, -77, -76, -74, -72, -71, -70, -69, -67, -65, -63, -62, -61, -59,
-57, -55, -55, -52, -50, -49, -47, -44, -43, -41, -40, -38, -36, -34, -32, -31,
-29, -28, -26, -23, -21, -19, -17, -16, -15, -12, -11, -9, -8, -5, -4, -2, 0, };