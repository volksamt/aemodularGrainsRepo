#define DATA_LENGTH 512
#define DATA AKWF_0732

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 9, 13, 18, 22, 27, 31, 35, 40,
43, 48, 53, 56, 61, 66, 70, 75, 79, 83, 88, 92, 96, 101, 105, 109, 113, 118,
116, 111, 107, 103, 99, 94, 90, 85, 82, 77, 73, 69, 64, 59, 55, 51, 46, 42, 37,
34, 30, 24, 20, 16, 12, 8, 3, -1, -6, -8, -8, -8, -7, -7, -8, -7, -7, -7, -8,
-7, -7, -7, -7, -8, -7, -8, -7, -7, -8, -7, -8, -8, -8, -8, -7, -7, -7, -7, -8,
-7, -7, -8, -7, -8, -7, -8, -7, -8, -7, -7, -7, -8, -7, -8, -7, -7, -7, -7, -7,
-7, -7, -8, -7, -8, -7, -7, -7, -7, -7, -8, -7, -7, -8, -7, -8, -7, -8, -7, -7,
-7, -8, -8, -7, -7, -8, -7, -8, -7, -7, -8, -8, -7, -7, -8, -8, -7, -8, -7, -7,
-8, -7, -8, -8, -8, -7, -7, -7, -7, -8, -7, -7, -7, -8, -7, -7, -7, -7, -7, -8,
-8, -8, -8, -7, -7, -7, -7, -8, -7, -7, -7, -8, -7, -7, -8, -8, -7, -7, -7, -6,
-8, -7, -8, -8, -7, -7, -8, -8, -8, -7, -8, -8, -8, -7, -8, -8, -7, -8, -8, -8,
-8, -7, -8, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -8, -7, -8, -7, -7, -7, -7,
-7, -8, -7, -7, -7, -7, -7, -7, -7, -8, -7, -7, -7, -7, -7, -7, -8, -7, -7, -7,
-8, -7, -8, -7, -8, -7, -7, -7, -6, -7, -7, -7, -7, -7, -8, -7, -8, -8, -8, -7,
-7, -7, -8, -8, -7, -7, -8, -7, -7, -7, -7, -7, -7, -7, -7, -7, -8, -8, -7, -7,
-7, -8, -7, -7, -7, -7, -7, -7, -8, -7, -7, -8, -7, -7, -7, -8, -7, -7, -7, -7,
-7, -7, -8, -7, -7, -7, -7, -8, -7, -7, -7, -7, -7, -7, -7, -7, -8, -8, -8, -8,
-8, -8, -7, -7, -8, -7, -7, -7, -8, -7, -7, -8, -8, -8, -8, -8, -7, -8, -7, -7,
-7, -8, -8, -7, -7, -8, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -8, -7, -7, -8,
-7, -6, -8, -7, -7, -7, -7, -7, -7, -8, -7, -7, -7, -8, -6, -7, -6, -8, -7, -7,
-7, -6, -7, -7, -6, -7, -7, -7, -7, -8, -7, -7, -7, -7, -8, -8, -8, -8, -8, -7,
-7, -7, -7, -7, -7, -7, -7, -7, -8, -7, -6, -7, -7, -7, -7, -7, -6, -8, -7, -7,
-7, -6, -7, -7, -6, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -6, -7, -7,
-7, -7, -7, -7, -7, -7, -7, -7, -8, -7, -7, -7, -8, -7, -7, -7, -7, -8, -8, -7,
-7, -7, -7, -6, -7, -7, -7, -6, -7, -7, -7, -8, -7, -7, -7, -7, -7, -8, -7, -7,
-7, -7, -7, -8, -7, -7, -7, -7, -7, -6, -7, -7, -7, -8, -7, -7, -6, -7, -7, -6,
-1, 2, 7, 11, -3, };