#define DATA_LENGTH 512
#define DATA AKWF_0708

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 9, 18, 26, 34, 41, 49, 52, 56, 60,
61, 62, 62, 60, 60, 56, 54, 49, 46, 42, 38, 35, 30, 26, 23, 19, 17, 14, 12, 10,
8, 6, 5, 5, 3, 3, 4, 4, 6, 6, 7, 7, 9, 12, 13, 16, 18, 20, 23, 26, 29, 31, 34,
37, 41, 44, 47, 50, 52, 55, 57, 59, 62, 63, 64, 65, 66, 65, 65, 65, 65, 65, 64,
65, 65, 65, 67, 68, 70, 74, 76, 81, 85, 89, 94, 98, 104, 108, 111, 115, 118,
119, 119, 119, 117, 114, 111, 108, 102, 97, 91, 84, 79, 73, 65, 59, 53, 47, 41,
36, 31, 27, 22, 19, 16, 12, 9, 8, 5, 4, 3, 2, 1, 1, 0, 0, 0, 1, 0, 0, 1, 0, -1,
-1, -2, -2, -3, -5, -6, -8, -10, -12, -15, -18, -23, -26, -31, -36, -41, -48,
-53, -59, -66, -73, -80, -86, -92, -99, -103, -108, -112, -115, -117, -119,
-119, -118, -117, -115, -111, -107, -103, -98, -93, -89, -85, -80, -76, -73,
-70, -68, -66, -66, -65, -65, -65, -65, -66, -65, -66, -66, -65, -65, -64, -63,
-61, -59, -58, -55, -52, -49, -47, -43, -40, -38, -35, -31, -28, -25, -22, -20,
-17, -16, -13, -11, -9, -8, -6, -5, -4, -5, -3, -3, -3, -4, -5, -7, -8, -10,
-12, -15, -17, -20, -23, -27, -31, -35, -39, -42, -47, -51, -54, -56, -60, -62,
-61, -62, -61, -59, -57, -53, -47, -41, -33, -26, -18, -8, 1, 10, 19, 28, 36,
43, 49, 54, 57, 62, 63, 63, 64, 63, 60, 58, 54, 51, 47, 42, 37, 33, 27, 22, 17,
13, 8, 3, -2, -6, -11, -15, -20, -23, -28, -31, -35, -39, -42, -46, -48, -52,
-55, -58, -59, -62, -64, -66, -67, -68, -68, -69, -70, -69, -70, -70, -69, -68,
-67, -67, -67, -66, -65, -65, -64, -63, -64, -63, -64, -63, -63, -64, -62, -62,
-61, -59, -57, -55, -51, -48, -44, -39, -33, -29, -23, -17, -12, -7, -3, 2, 4,
6, 8, 8, 7, 5, 4, 0, -5, -9, -14, -19, -24, -28, -34, -39, -43, -46, -50, -53,
-55, -56, -57, -57, -56, -55, -54, -51, -49, -45, -41, -37, -32, -27, -23, -16,
-10, -5, 0, 7, 13, 18, 24, 28, 34, 38, 42, 45, 49, 52, 54, 56, 57, 58, 57, 56,
55, 51, 48, 45, 41, 37, 32, 28, 21, 17, 11, 7, 4, 0, -4, -7, -8, -8, -7, -5, -4,
-1, 4, 9, 14, 20, 25, 30, 36, 40, 45, 50, 53, 56, 59, 60, 61, 62, 63, 63, 64,
63, 63, 63, 64, 63, 65, 64, 65, 66, 66, 67, 68, 68, 69, 70, 69, 70, 69, 69, 68,
67, 67, 64, 63, 61, 59, 56, 53, 51, 47, 45, 41, 38, 34, 31, 26, 22, 18, 13, 9,
6, 1, -5, -9, -15, -19, -24, -29, -34, -39, -44, -49, -52, -56, -59, -62, -63,
-63, -64, -63, -61, -57, -52, -47, -40, -34, -25, -16, -7, };