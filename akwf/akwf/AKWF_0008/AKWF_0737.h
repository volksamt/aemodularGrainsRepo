#define DATA_LENGTH 512
#define DATA AKWF_0737

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 5, 5, 5, 6, 5, 6, 5, 5, 6, 6, 6, 6,
6, 6, 6, 6, 6, 6, 6, 6, 7, 6, 7, 7, 6, 6, 7, 7, 6, 7, 7, 7, 6, 8, 6, 7, 7, 7, 6,
8, 6, 7, 7, 7, 7, 7, 8, 8, 7, 8, 8, 8, 8, 7, 8, 8, 8, 8, 7, 8, 8, 9, 9, 8, 9, 8,
8, 8, 8, 8, 8, 8, 8, 9, 9, 8, 9, 8, 8, 8, 9, 8, 9, 8, 9, 8, 9, 9, 9, 9, 10, 9,
10, 9, 10, 9, 9, 10, 9, 10, 10, 10, 9, 10, 10, 10, 9, 10, 9, 10, 9, 11, 9, 10,
9, 10, 9, 11, 10, 11, 10, 11, 11, 10, 11, 6, 71, 89, 82, 88, 84, 89, 86, 90, 87,
90, 89, 90, 90, 92, 91, 93, 93, 94, 95, 94, 95, 96, 96, 97, 98, 99, 100, 99,
101, 101, 102, 102, 103, 102, 104, 104, 105, 105, 106, 106, 107, 107, 108, 110,
110, 110, 111, 111, 111, 112, 113, 114, 114, 114, 116, 116, 116, 116, 118, 118,
120, 116, 110, 111, 110, 111, 109, 109, 108, 109, 108, 107, 107, 107, 107, 106,
106, 106, 105, 105, 104, 104, 103, 103, 103, 102, 103, 102, 101, 101, 101, 100,
99, 99, 99, 99, 99, 98, 98, 97, 96, 97, 97, 96, 95, 95, 95, 95, 94, 94, 93, 93,
93, 93, 92, 91, 91, 91, 90, 91, 90, 89, 89, 88, 89, 89, 87, 88, 86, 86, 86, 86,
86, 85, 85, 84, 84, 83, 83, 83, 82, 83, 81, 82, 82, 81, 80, 80, 79, 79, 78, 78,
78, 78, 78, 77, 77, 76, 77, 75, 76, 73, 75, 73, 75, 73, 74, 72, 73, 71, 72, 72,
71, 71, 68, 72, 65, 78, 27, -9, -54, -75, -64, -73, -67, -73, -68, -72, -69,
-72, -70, -73, -71, -72, -73, -73, -73, -73, -74, -73, -75, -74, -74, -75, -75,
-75, -75, -75, -76, -76, -77, -77, -77, -78, -78, -77, -78, -78, -78, -79, -78,
-79, -79, -80, -79, -80, -80, -81, -80, -81, -82, -82, -82, -82, -83, -83, -83,
-83, -83, -83, -84, -84, -85, -85, -86, -84, -85, -85, -86, -86, -86, -87, -87,
-87, -87, -88, -88, -88, -88, -88, -89, -90, -89, -90, -89, -90, -90, -90, -90,
-91, -91, -91, -91, -92, -93, -93, -92, -93, -93, -94, -93, -94, -95, -94, -94,
-96, -96, -95, -96, -96, -96, -97, -97, -97, -97, -98, -98, -98, -97, -98, -99,
-99, -98, -100, -100, -100, -99, -100, -100, -100, -101, -101, -101, -102, -102,
-102, -103, -103, -103, -103, -104, -104, -105, -105, -105, -104, -103, -103,
-102, -102, -101, -100, -99, -99, -99, -98, -97, -97, -97, -96, -95, -95, -94,
-94, -93, -93, -92, -90, -90, -90, -89, -88, -89, -88, -87, -86, -86, -85, -84,
-84, -83, -82, -82, -81, -81, -80, -79, -79, -78, -78, -77, -77, -76, -76, -74,
-75, -73, -74, -71, -74, -69, -72, -67, -74, -59, };