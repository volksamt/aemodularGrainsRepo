#define DATA_LENGTH 512
#define DATA AKWF_0743

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 2, 4, 4, 5, 5, 6, 7, 8, 8,
10, 9, 10, 11, 12, 13, 13, 14, 14, 15, 16, 17, 18, 20, 20, 21, 22, 22, 24, 25,
26, 26, 28, 29, 30, 31, 31, 32, 34, 35, 37, 37, 39, 40, 41, 43, 43, 45, 46, 47,
49, 51, 52, 52, 54, 55, 56, 58, 58, 60, 62, 63, 64, 66, 67, 68, 69, 70, 71, 73,
74, 75, 76, 77, 78, 78, 80, 80, 81, 82, 83, 84, 85, 86, 85, 86, 87, 88, 89, 89,
89, 90, 90, 91, 90, 90, 90, 91, 90, 90, 92, 91, 90, 91, 89, 89, 90, 89, 89, 88,
89, 87, 88, 86, 86, 86, 84, 85, 83, 82, 82, 81, 81, 80, 78, 78, 76, 76, 74, 74,
73, 71, 71, 69, 68, 67, 66, 64, 63, 62, 62, 60, 59, 57, 56, 55, 54, 51, 51, 50,
48, 46, 45, 44, 43, 41, 39, 38, 36, 35, 33, 32, 31, 30, 28, 25, 24, 22, 21, 20,
17, 16, 15, 13, 12, 8, 7, 6, 3, 3, 1, -2, -3, -5, -6, -8, -10, -12, -13, -15,
-17, -19, -20, -22, -23, -26, -26, -29, -30, -31, -33, -34, -36, -37, -39, -39,
-40, -42, -43, -44, -45, -46, -46, -48, -48, -49, -49, -50, -50, -51, -51, -52,
-53, -52, -53, -52, -52, -52, -53, -52, -51, -51, -51, -50, -50, -48, -48, -47,
-46, -45, -43, -42, -41, -40, -39, -37, -37, -34, -33, -31, -30, -28, -26, -25,
-23, -21, -19, -17, -15, -13, -11, -9, -7, -5, -3, -1, 1, 3, 5, 8, 9, 12, 14,
16, 18, 20, 22, 23, 25, 27, 29, 31, 34, 35, 37, 38, 40, 42, 43, 45, 47, 48, 49,
50, 52, 53, 54, 56, 56, 58, 59, 60, 60, 61, 62, 63, 64, 64, 64, 65, 65, 65, 64,
65, 65, 65, 66, 65, 64, 64, 63, 62, 62, 61, 59, 59, 58, 58, 56, 55, 54, 52, 51,
49, 48, 46, 43, 42, 40, 38, 37, 34, 32, 29, 27, 25, 23, 20, 18, 15, 13, 10, 7,
5, 2, -2, -4, -7, -10, -13, -15, -18, -20, -23, -26, -30, -33, -36, -39, -41,
-43, -47, -49, -52, -55, -58, -61, -63, -66, -68, -71, -73, -75, -78, -81, -83,
-85, -87, -89, -91, -94, -95, -97, -99, -101, -102, -105, -105, -107, -109,
-109, -111, -112, -113, -114, -114, -116, -116, -117, -117, -118, -119, -119,
-119, -119, -118, -119, -119, -119, -118, -119, -118, -118, -117, -117, -116,
-115, -115, -114, -112, -112, -111, -110, -108, -107, -106, -106, -103, -102,
-100, -99, -98, -96, -95, -93, -91, -90, -88, -86, -84, -82, -81, -79, -78, -75,
-75, -73, -70, -68, -67, -66, -63, -61, -60, -57, -56, -54, -52, -50, -48, -47,
-46, -43, -42, -40, -39, -38, -35, -34, -33, -31, -29, -29, -27, -26, -24, -22,
-22, -20, -19, -17, -17, -16, -14, -13, -13, -11, -10, -9, -8, -8, -6, -6, -5,
-4, -3, -3, -2, 0, 0, };