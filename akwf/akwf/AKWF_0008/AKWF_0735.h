#define DATA_LENGTH 512
#define DATA AKWF_0735

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 4, 1, 3, 5, 7, 9, 11, 13, 15, 16,
18, 21, 23, 24, 27, 29, 31, 33, 35, 37, 39, 41, 44, 46, 48, 49, 51, 53, 54, 57,
59, 61, 63, 64, 67, 69, 71, 72, 75, 76, 79, 81, 83, 85, 87, 89, 91, 92, 95, 97,
98, 100, 102, 105, 106, 108, 111, 112, 115, 116, 119, 117, 115, 114, 111, 109,
108, 105, 104, 102, 100, 97, 96, 95, 91, 90, 88, 86, 83, 82, 79, 78, 76, 74, 72,
70, 68, 66, 63, 61, 60, 58, 56, 54, 52, 50, 47, 45, 44, 42, 40, 38, 36, 35, 32,
30, 27, 26, 25, 22, 20, 18, 16, 14, 12, 9, 8, 6, 4, 2, 0, -2, -1, -2, -3, -1,
-2, -2, -2, -1, -2, -3, -2, -2, -2, -2, -2, -1, -2, -2, -2, -3, -2, -2, -2, -2,
-2, -1, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -1, -2, -1,
-2, -2, -2, -2, -2, -2, -2, -2, -2, -1, -2, -2, -2, -2, -2, -2, -2, -3, -2, -2,
-1, -2, -1, -1, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -1, -2, -2,
-2, -2, -1, -2, -3, -2, -2, -2, -1, -1, -2, -2, -2, -3, -2, -2, -2, -3, -2, -2,
-2, -1, -2, -2, -2, -1, -2, -2, -2, -1, -2, -2, -1, -2, -2, -2, -2, -2, -1, -1,
-2, -2, -3, -1, -2, -2, -2, -1, -2, -2, -2, -2, -2, -3, -2, -2, -2, -2, -3, -2,
-2, -2, -2, -2, -2, -2, -2, -1, -2, -2, -3, -2, -2, -2, -2, -2, -1, -1, -2, -2,
-2, -2, -2, -2, -2, -2, -1, -1, -2, -2, -2, -2, -2, -2, -2, -2, -1, -1, -2, -1,
-3, -2, -2, -2, -3, -2, -2, -2, -1, -3, -2, -2, -3, -2, -1, -2, -1, -3, -1, -2,
-2, -2, -3, -3, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -1, -2, -2, -2, -2, -2,
-1, -2, -2, -2, -1, -2, -2, -2, -1, -1, -2, -2, -2, -2, -3, -2, -1, -2, -2, -1,
-2, -3, -2, -2, -2, -3, -1, -1, -2, -2, -2, -2, -3, -2, -2, -2, -2, -2, -2, -2,
-2, -1, -2, -1, -2, -2, -5, -7, -9, -10, -14, -15, -17, -19, -20, -23, -24, -29,
-9, -3, -9, -8, -12, -11, -15, -16, -19, -19, -22, -24, -26, -28, -30, -31, -34,
-36, -37, -38, -42, -43, -45, -46, -49, -50, -53, -55, -57, -59, -61, -62, -64,
-67, -67, -70, -71, -74, -75, -78, -79, -80, -83, -85, -87, -89, -90, -92, -94,
-96, -99, -100, -102, -104, -105, -107, -109, -112, -113, -115, -116, -114,
-113, -111, -109, -107, -105, -103, -101, -99, -98, -95, -93, -91, -90, -87,
-86, -83, -82, -79, -79, -76, -75, -72, -71, -68, -67, -64, -63, -61, -60, -57,
-55, -53, -2, 5, 4, 7, 10, 10, 16, 8, -21, -11, -10, -4, -2, };