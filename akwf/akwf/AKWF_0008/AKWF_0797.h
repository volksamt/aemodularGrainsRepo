#define DATA_LENGTH 512
#define DATA AKWF_0797

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 6, 8, 9, 11, 13, 14, 16, 18,
20, 20, 22, 23, 25, 28, 28, 30, 31, 32, 33, 35, 36, 36, 38, 38, 40, 39, 41, 42,
42, 42, 44, 44, 43, 45, 45, 45, 46, 46, 46, 46, 47, 47, 47, 47, 46, 47, 47, 46,
46, 47, 47, 47, 48, 48, 48, 48, 48, 49, 49, 50, 50, 50, 50, 51, 52, 52, 53, 53,
55, 55, 56, 57, 58, 58, 60, 60, 62, 62, 63, 65, 66, 68, 69, 71, 72, 74, 76, 77,
79, 80, 81, 83, 86, 87, 89, 91, 92, 94, 96, 97, 99, 100, 103, 104, 105, 106,
108, 109, 110, 111, 113, 114, 114, 115, 115, 116, 116, 117, 117, 117, 118, 119,
119, 118, 120, 119, 119, 119, 118, 119, 118, 119, 119, 118, 118, 118, 117, 117,
117, 117, 116, 116, 115, 115, 114, 114, 113, 113, 113, 111, 111, 110, 109, 108,
107, 107, 105, 105, 104, 103, 101, 99, 98, 96, 96, 93, 92, 91, 89, 87, 85, 84,
81, 79, 77, 76, 74, 72, 69, 67, 64, 62, 61, 57, 56, 53, 52, 49, 48, 45, 43, 40,
38, 36, 35, 32, 30, 28, 26, 24, 23, 21, 19, 18, 15, 14, 12, 10, 8, 7, 6, 4, 2,
0, -1, -2, -4, -6, -8, -10, -11, -13, -15, -17, -19, -21, -22, -24, -25, -27,
-29, -31, -33, -33, -36, -37, -40, -41, -43, -44, -46, -48, -49, -52, -52, -54,
-56, -57, -59, -60, -61, -61, -63, -64, -65, -65, -66, -67, -68, -67, -69, -69,
-69, -69, -69, -71, -70, -69, -70, -71, -70, -70, -70, -69, -70, -69, -68, -68,
-68, -67, -66, -66, -66, -65, -65, -64, -64, -64, -63, -63, -62, -62, -62, -62,
-61, -61, -61, -60, -61, -60, -60, -60, -61, -60, -61, -60, -60, -60, -60, -60,
-60, -60, -60, -61, -60, -60, -61, -61, -61, -60, -61, -60, -61, -60, -60, -61,
-60, -59, -59, -60, -59, -59, -58, -58, -57, -57, -56, -56, -55, -54, -53, -53,
-51, -51, -51, -50, -49, -48, -48, -46, -46, -44, -44, -43, -43, -41, -41, -40,
-41, -39, -38, -38, -37, -38, -38, -38, -37, -37, -37, -38, -37, -38, -38, -39,
-39, -39, -41, -41, -42, -43, -43, -44, -45, -47, -48, -49, -50, -50, -52, -52,
-54, -55, -56, -58, -58, -60, -60, -62, -62, -64, -64, -64, -66, -67, -67, -67,
-68, -68, -68, -69, -70, -70, -70, -70, -70, -71, -69, -70, -70, -69, -69, -68,
-68, -67, -67, -66, -66, -64, -64, -63, -62, -61, -61, -59, -60, -59, -58, -57,
-56, -55, -55, -53, -53, -52, -51, -51, -51, -49, -49, -48, -48, -47, -46, -45,
-45, -45, -45, -44, -44, -43, -42, -43, -42, -42, -42, -41, -41, -40, -40, -40,
-40, -39, -39, -37, -38, -37, -37, -37, -36, -36, -34, -34, -34, -32, -31, -31,
-29, -29, -29, -27, -26, -25, -24, -23, -22, -21, -19, -18, -15, -15, -13, -13,
-10, -9, -7, -6, -4, -3, 0, };