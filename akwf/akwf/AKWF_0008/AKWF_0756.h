#define DATA_LENGTH 512
#define DATA AKWF_0756

const PROGMEM int8_t DATA[DATA_LENGTH] = {16, 61, 64, 48, 42, 47, 52, 49, 49,
49, 35, -15, -61, -56, -49, -55, -50, -50, -47, -46, -49, -49, -47, -46, -45,
-45, -44, -44, -44, -44, -44, -43, -45, -44, -45, -45, -44, -46, -44, -45, -45,
-45, -46, -45, -45, -44, -44, -44, -45, -45, -46, -45, -45, -45, -41, -9, 47,
71, 60, 45, 43, 48, 50, 50, 52, 52, 51, 52, 52, 52, 53, 53, 54, 55, 54, 55, 55,
56, 56, 57, 58, 58, 58, 59, 58, 59, 59, 59, 59, 58, 58, 56, 55, 53, 51, 49, 48,
46, 44, 42, 40, 40, 39, 40, 39, 39, 40, 41, 41, 43, 44, 45, 47, 49, 50, 52, 54,
56, 57, 59, 61, 64, 65, 67, 70, 72, 73, 75, 77, 79, 81, 84, 85, 87, 88, 90, 93,
94, 95, 96, 99, 101, 102, 103, 104, 106, 107, 108, 109, 110, 111, 112, 113, 114,
115, 116, 116, 117, 117, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 117,
118, 117, 116, 115, 115, 115, 114, 112, 111, 111, 108, 107, 106, 105, 104, 102,
100, 100, 97, 96, 94, 92, 91, 88, 87, 86, 83, 81, 79, 76, 74, 73, 71, 68, 66,
64, 62, 59, 57, 53, 52, 49, 47, 45, 43, 40, 38, 36, 34, 31, 30, 28, 26, 24, 23,
23, 23, 21, 22, 24, 24, 24, 25, 25, 26, 27, 26, 27, 27, 27, 27, 26, 26, 26, 26,
25, 25, 25, 24, 23, 23, 22, 23, 22, 22, 21, 20, 20, 19, 18, 18, 18, 17, 16, 16,
16, 15, 15, 14, 14, 13, 12, 11, 12, 10, 9, 10, 8, 9, 8, 8, 7, 7, 6, 5, 7, 5, 5,
6, 6, 7, 7, 8, 9, 11, 13, 15, 18, 20, 23, 25, 28, 31, 32, 32, 29, 17, -3, -23,
-34, -34, -31, -29, -28, -24, -22, -19, -16, -14, -12, -10, -8, -8, -6, -6, -5,
-5, -6, -5, -5, -6, -6, -7, -7, -8, -8, -9, -9, -9, -11, -11, -11, -12, -12,
-13, -14, -15, -14, -15, -16, -16, -17, -18, -18, -18, -19, -20, -20, -20, -21,
-22, -21, -23, -23, -23, -24, -23, -25, -25, -25, -26, -26, -26, -26, -27, -27,
-26, -27, -26, -26, -26, -25, -25, -24, -23, -23, -22, -21, -22, -24, -25, -26,
-27, -29, -31, -33, -35, -37, -40, -42, -45, -47, -50, -52, -54, -57, -59, -62,
-64, -66, -69, -71, -73, -75, -78, -81, -81, -84, -86, -88, -91, -93, -94, -96,
-97, -100, -101, -103, -104, -106, -108, -108, -109, -111, -112, -113, -115,
-115, -116, -117, -117, -118, -118, -119, -119, -119, -119, -119, -118, -118,
-118, -117, -116, -115, -115, -114, -113, -112, -110, -108, -107, -106, -104,
-102, -99, -98, -95, -94, -91, -89, -86, -84, -82, -78, -76, -73, -70, -68, -64,
-61, -58, -55, -52, -50, -47, -44, -42, -41, -39, -39, -40, -40, -42, -45, -49,
-53, -55, -57, -59, -59, -58, -58, -58, -56, -56, -54, -53, -52, -52, -51, -50,
-26, };