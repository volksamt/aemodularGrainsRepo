#define DATA_LENGTH 512
#define DATA AKWF_0736

const PROGMEM int8_t DATA[DATA_LENGTH] = {16, 42, 62, 82, 96, 107, 110, 111,
105, 94, 78, 58, 35, 12, -13, -37, -61, -80, -98, -110, -117, -120, -117, -108,
-94, -77, -56, -32, -8, 0, 3, 7, 11, 15, 18, 22, 25, 27, 30, 33, 36, 38, 39, 42,
43, 44, 46, 47, 47, 46, 47, 47, 47, 47, 46, 45, 43, 42, 40, 39, 36, 35, 33, 31,
29, 27, 25, 21, 18, 17, 14, 11, 9, 6, 4, 1, -1, -3, -5, -8, -9, -12, -14, -14,
-16, -17, -19, -20, -23, -22, -23, -24, -24, -25, -26, -26, -26, -25, -25, -25,
-25, -24, -24, -23, -23, -21, -20, -20, -18, -18, -17, -16, -14, -14, -12, -12,
-11, -10, -9, -8, -8, -7, -6, -6, -5, -5, -5, -4, -8, -12, -16, -21, -26, -29,
-34, -37, -42, -46, -50, -54, -57, -60, -62, -66, -68, -70, -73, -75, -76, -78,
-79, -79, -79, -80, -80, -80, -78, -77, -76, -74, -72, -69, -66, -64, -60, -58,
-55, -50, -46, -41, -36, -32, -27, -22, -18, -12, -7, -2, 4, 9, 14, 20, 24, 30,
34, 40, 45, 49, 54, 58, 62, 66, 69, 72, 76, 78, 81, 83, 85, 85, 87, 86, 87, 87,
86, 86, 84, 82, 81, 79, 76, 73, 69, 66, 62, 58, 52, 47, 44, 38, 32, 26, 21, 15,
9, 3, -4, -14, -22, -28, -33, -35, -34, -32, -29, -24, -21, -15, -11, -7, -5,
-4, -4, -6, -8, -12, -16, -20, -24, -26, -27, -27, -23, -19, -13, -5, 17, 39,
60, 77, 91, 99, 103, 102, 97, 86, 71, 53, 31, 8, -15, -39, -60, -80, -95, -107,
-113, -114, -115, -107, -92, -75, -53, -30, -6, 1, 4, 8, 12, 16, 20, 22, 26, 29,
32, 36, 37, 39, 42, 43, 45, 46, 47, 48, 49, 49, 48, 48, 48, 47, 46, 45, 45, 43,
41, 40, 37, 36, 34, 31, 29, 26, 24, 21, 19, 17, 15, 11, 9, 6, 4, 2, -2, -3, -5,
-8, -10, -11, -13, -15, -16, -18, -19, -21, -21, -23, -24, -24, -24, -25, -26,
-26, -27, -26, -26, -25, -25, -25, -24, -23, -23, -22, -22, -20, -19, -19, -17,
-16, -15, -15, -13, -12, -12, -11, -10, -9, -8, -8, -7, -6, -5, -5, -5, -4, -9,
-12, -16, -20, -24, -29, -32, -35, -39, -42, -46, -49, -53, -54, -58, -61, -63,
-64, -66, -68, -70, -70, -72, -77, -78, -78, -78, -77, -76, -76, -74, -71, -71,
-68, -65, -62, -59, -55, -53, -48, -44, -39, -36, -31, -27, -21, -16, -11, -6,
-1, 4, 9, 15, 20, 25, 30, 35, 39, 44, 49, 52, 57, 61, 65, 67, 71, 74, 76, 78,
81, 82, 84, 84, 86, 86, 85, 84, 84, 83, 81, 79, 77, 74, 71, 68, 64, 60, 57, 51,
47, 41, 36, 31, 26, 19, 14, 8, 1, -5, -15, -23, -29, -33, -34, -34, -31, -27,
-24, -17, -13, -9, -6, -4, -4, -5, -8, -10, -16, -19, -23, -26, -29, -29, -29,
-25, -20, -12, -3, };