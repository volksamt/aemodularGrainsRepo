#define DATA_LENGTH 512
#define DATA AKWF_0772

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 4, 6, 7, 8, 9, 12, 13, 14,
16, 18, 20, 21, 24, 24, 28, 29, 30, 32, 35, 37, 38, 41, 42, 44, 47, 49, 51, 53,
55, 57, 58, 60, 63, 65, 67, 68, 70, 73, 75, 76, 78, 80, 82, 82, 85, 87, 89, 89,
91, 94, 94, 95, 98, 99, 100, 102, 102, 103, 105, 105, 106, 108, 108, 109, 110,
111, 112, 112, 114, 114, 115, 115, 115, 116, 116, 117, 118, 118, 118, 118, 119,
118, 119, 119, 118, 119, 119, 118, 119, 118, 119, 118, 118, 118, 119, 117, 117,
118, 116, 117, 116, 116, 115, 114, 114, 114, 113, 113, 112, 111, 111, 110, 110,
109, 108, 108, 106, 106, 105, 104, 104, 103, 101, 101, 101, 99, 98, 96, 95, 94,
94, 93, 92, 91, 89, 88, 87, 86, 86, 85, 82, 81, 80, 80, 79, 77, 76, 75, 74, 72,
71, 70, 69, 68, 67, 66, 64, 64, 62, 61, 61, 59, 58, 56, 56, 55, 54, 53, 51, 51,
50, 49, 48, 48, 47, 46, 44, 44, 44, 42, 42, 41, 40, 39, 38, 37, 37, 37, 36, 35,
35, 35, 34, 33, 32, 32, 32, 31, 30, 30, 30, 30, 30, 29, 29, 29, 28, 28, 27, 28,
27, 27, 27, 26, 26, 26, 26, 25, 24, 24, 23, 23, 23, 23, 22, 22, 21, 21, 21, 20,
20, 19, 19, 18, 18, 16, 16, 16, 15, 14, 13, 13, 12, 11, 10, 9, 8, 6, 5, 4, 3, 3,
1, 1, -2, -3, -3, -5, -7, -9, -10, -12, -13, -14, -17, -18, -19, -22, -23, -25,
-26, -29, -31, -33, -35, -37, -39, -40, -42, -45, -46, -48, -51, -52, -55, -57,
-59, -60, -63, -64, -66, -69, -70, -72, -74, -76, -78, -79, -82, -84, -86, -88,
-88, -90, -91, -93, -95, -96, -97, -99, -100, -101, -103, -104, -105, -105,
-107, -108, -108, -110, -110, -111, -112, -113, -113, -114, -115, -115, -115,
-117, -117, -118, -117, -118, -117, -118, -118, -119, -119, -119, -119, -118,
-120, -119, -119, -118, -119, -119, -118, -118, -119, -117, -117, -118, -117,
-116, -116, -116, -115, -115, -114, -113, -113, -113, -112, -111, -111, -109,
-109, -109, -108, -107, -106, -106, -105, -104, -104, -102, -101, -100, -99,
-98, -97, -97, -96, -96, -94, -92, -92, -90, -90, -88, -87, -86, -84, -84, -82,
-81, -81, -79, -78, -77, -75, -74, -73, -71, -71, -70, -69, -67, -66, -65, -64,
-63, -62, -60, -59, -59, -58, -56, -56, -55, -54, -53, -51, -51, -50, -49, -48,
-46, -46, -45, -45, -44, -43, -43, -41, -40, -41, -39, -39, -38, -38, -36, -36,
-36, -34, -34, -34, -33, -33, -32, -32, -31, -30, -31, -30, -30, -29, -29, -28,
-29, -29, -27, -28, -28, -28, -27, -26, -25, -25, -25, -25, -25, -24, -24, -24,
-23, -23, -22, -22, -22, -21, -22, -21, -20, -20, -19, -18, -18, -17, -16, -16,
-15, -15, -14, -13, -12, -12, -11, -10, -8, -7, -6, -5, -5, -3, -2, -1, };