#define DATA_LENGTH 512
#define DATA AKWF_0796

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 3, 3, 4, 6, 6, 7, 7, 8, 9,
10, 10, 10, 11, 12, 12, 14, 13, 19, 29, 33, 37, 41, 46, 50, 54, 58, 61, 65, 68,
71, 75, 78, 82, 85, 87, 89, 93, 95, 97, 99, 100, 103, 104, 106, 108, 109, 110,
110, 111, 113, 113, 114, 113, 114, 114, 115, 115, 115, 113, 113, 113, 113, 112,
112, 111, 110, 109, 107, 107, 106, 104, 104, 101, 101, 99, 98, 96, 96, 94, 93,
90, 89, 87, 87, 85, 83, 81, 80, 79, 76, 75, 73, 71, 69, 68, 66, 64, 62, 60, 59,
57, 55, 54, 51, 50, 47, 45, 44, 42, 40, 38, 36, 34, 32, 30, 29, 26, 24, 23, 21,
17, 16, 14, 12, 10, 8, 7, 4, 2, 0, -2, -3, -6, -8, -9, -11, -13, -14, -16, -19,
-20, -21, -23, -24, -26, -27, -29, -30, -31, -33, -35, -36, -36, -37, -39, -39,
-40, -40, -41, -42, -42, -44, -44, -44, -45, -45, -45, -45, -46, -46, -45, -45,
-45, -44, -44, -43, -43, -42, -41, -41, -40, -39, -39, -37, -37, -36, -34, -33,
-32, -30, -29, -28, -26, -24, -23, -22, -20, -18, -16, -15, -13, -12, -9, -8,
-7, -4, -2, -1, 2, 3, 5, 7, 10, 11, 14, 16, 18, 19, 22, 24, 25, 27, 29, 31, 34,
35, 36, 39, 40, 43, 44, 46, 48, 49, 51, 53, 55, 56, 57, 59, 61, 62, 63, 65, 66,
68, 69, 70, 71, 72, 74, 75, 76, 77, 78, 78, 79, 80, 80, 82, 82, 82, 83, 83, 84,
85, 84, 85, 85, 85, 85, 85, 85, 84, 84, 85, 84, 84, 84, 83, 82, 82, 81, 81, 80,
79, 78, 77, 76, 75, 75, 72, 72, 70, 69, 67, 66, 65, 63, 62, 60, 59, 57, 56, 54,
51, 50, 48, 46, 44, 41, 40, 38, 36, 33, 31, 29, 27, 24, 22, 20, 17, 15, 13, 10,
8, 6, 3, 1, -2, -4, -7, -10, -12, -14, -17, -19, -22, -24, -27, -29, -32, -34,
-37, -40, -41, -44, -46, -49, -51, -53, -55, -57, -60, -62, -64, -66, -68, -71,
-72, -75, -77, -79, -81, -83, -84, -86, -88, -90, -92, -93, -94, -96, -97, -99,
-100, -102, -103, -105, -105, -107, -108, -108, -111, -111, -112, -113, -113,
-114, -115, -115, -115, -116, -116, -118, -118, -118, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -118, -117, -117, -117, -116,
-116, -115, -114, -114, -113, -113, -112, -111, -111, -110, -108, -107, -106,
-105, -104, -104, -103, -101, -100, -99, -98, -97, -95, -94, -92, -91, -91, -89,
-88, -86, -84, -83, -81, -81, -79, -77, -76, -75, -74, -72, -69, -68, -68, -66,
-64, -62, -61, -60, -58, -57, -56, -53, -52, -50, -49, -47, -46, -44, -43, -41,
-40, -39, -37, -37, -36, -32, -31, -31, -29, -27, -27, -26, -24, -23, -22, -20,
-20, -18, -16, -15, -15, -13, -12, -11, -10, -9, -8, -7, -6, -5, -4, -3, -3, -1,
0, };