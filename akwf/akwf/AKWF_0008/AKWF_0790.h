#define DATA_LENGTH 512
#define DATA AKWF_0790

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 2, 3, 2, 3, 3, 5, 5, 5, 6, 5,
5, 7, 7, 8, 8, 8, 8, 9, 9, 9, 10, 10, 11, 10, 10, 11, 11, 11, 11, 12, 11, 12,
12, 12, 13, 12, 13, 14, 12, 13, 14, 15, 14, 15, 14, 14, 14, 15, 15, 14, 15, 15,
14, 14, 14, 15, 15, 15, 17, 20, 22, 24, 27, 29, 32, 34, 36, 38, 41, 42, 44, 46,
48, 49, 51, 52, 55, 56, 57, 58, 60, 62, 62, 64, 65, 67, 67, 68, 70, 71, 71, 73,
74, 75, 75, 77, 77, 78, 79, 79, 81, 81, 82, 83, 84, 84, 86, 86, 87, 87, 89, 89,
90, 90, 91, 91, 92, 93, 94, 94, 95, 95, 96, 97, 97, 98, 98, 99, 99, 99, 100,
100, 101, 102, 102, 103, 103, 103, 104, 105, 105, 106, 105, 106, 107, 107, 108,
108, 108, 110, 109, 109, 110, 111, 111, 110, 112, 111, 113, 112, 113, 114, 113,
113, 113, 115, 115, 115, 115, 116, 116, 116, 116, 117, 117, 117, 118, 117, 118,
117, 117, 119, 117, 118, 118, 118, 118, 119, 118, 119, 119, 119, 119, 119, 118,
119, 119, 120, 119, 119, 118, 119, 119, 118, 118, 118, 116, 115, 113, 110, 106,
103, 98, 93, 88, 82, 76, 70, 62, 56, 48, 41, 33, 26, 19, 12, 6, -1, -7, -12,
-17, -23, -28, -32, -37, -41, -45, -49, -52, -54, -57, -59, -63, -65, -67, -68,
-71, -71, -74, -74, -77, -78, -79, -79, -81, -81, -83, -83, -84, -84, -85, -86,
-86, -87, -87, -88, -87, -88, -88, -88, -88, -89, -89, -89, -89, -89, -90, -90,
-89, -89, -89, -89, -89, -89, -89, -89, -88, -88, -89, -89, -88, -88, -89, -88,
-88, -87, -88, -88, -86, -86, -86, -86, -86, -85, -85, -85, -85, -85, -85, -84,
-84, -84, -84, -84, -82, -83, -82, -82, -82, -81, -81, -81, -81, -80, -81, -79,
-80, -79, -79, -79, -78, -77, -77, -78, -78, -77, -77, -76, -76, -76, -75, -74,
-74, -74, -73, -74, -74, -74, -73, -72, -71, -72, -72, -71, -70, -70, -69, -70,
-69, -68, -68, -68, -67, -67, -66, -66, -66, -66, -65, -65, -64, -65, -64, -64,
-64, -63, -63, -63, -62, -61, -61, -60, -61, -61, -59, -59, -59, -58, -58, -58,
-58, -57, -57, -57, -56, -56, -54, -55, -54, -54, -53, -54, -54, -53, -53, -52,
-51, -50, -51, -50, -50, -49, -49, -49, -49, -48, -47, -47, -47, -46, -45, -45,
-46, -45, -44, -44, -44, -43, -43, -41, -42, -41, -41, -41, -41, -40, -39, -39,
-38, -38, -38, -37, -37, -36, -35, -35, -34, -34, -33, -33, -32, -32, -32, -31,
-30, -30, -30, -29, -29, -28, -27, -27, -27, -25, -25, -25, -23, -23, -23, -22,
-22, -20, -20, -20, -19, -18, -18, -17, -16, -16, -16, -15, -14, -14, -13, -13,
-12, -12, -11, -10, -9, -9, -8, -7, -7, -7, -6, -6, -5, -4, -5, -4, -3, -3, -2,
-1, -2, -1, 0, };