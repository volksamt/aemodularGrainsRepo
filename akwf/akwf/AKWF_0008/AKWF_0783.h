#define DATA_LENGTH 512
#define DATA AKWF_0783

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 9, 13, 16, 18, 21, 24, 26, 29,
31, 34, 36, 38, 41, 42, 44, 46, 49, 49, 52, 53, 55, 57, 58, 61, 61, 63, 64, 65,
67, 69, 70, 72, 72, 73, 75, 76, 78, 79, 80, 81, 82, 83, 85, 85, 86, 87, 88, 89,
90, 91, 91, 92, 94, 95, 94, 96, 96, 98, 98, 100, 99, 100, 101, 102, 102, 103,
104, 104, 105, 106, 106, 106, 107, 107, 108, 108, 109, 110, 110, 110, 111, 111,
111, 112, 112, 113, 113, 114, 113, 114, 114, 114, 115, 116, 115, 115, 116, 116,
116, 117, 117, 117, 117, 117, 117, 117, 117, 117, 118, 119, 118, 118, 117, 117,
118, 118, 118, 118, 119, 119, 120, 119, 118, 120, 119, 119, 119, 119, 119, 119,
119, 119, 119, 118, 119, 119, 120, 119, 119, 119, 118, 119, 119, 119, 118, 118,
118, 118, 117, 118, 118, 117, 117, 117, 117, 117, 117, 117, 116, 116, 116, 116,
115, 116, 116, 115, 115, 114, 114, 114, 113, 113, 113, 113, 111, 112, 111, 111,
111, 111, 110, 110, 109, 109, 107, 108, 107, 107, 106, 106, 105, 103, 104, 103,
103, 102, 101, 100, 100, 100, 98, 97, 95, 95, 95, 94, 93, 92, 91, 89, 89, 88,
86, 86, 84, 84, 82, 80, 79, 79, 77, 75, 73, 71, 70, 69, 67, 65, 63, 61, 60, 58,
56, 54, 52, 50, 48, 46, 43, 41, 39, 36, 34, 31, 28, 26, 23, 20, 17, 14, 11, 8,
5, 0, -3, -6, -10, -13, -16, -19, -21, -25, -27, -30, -32, -34, -36, -38, -41,
-43, -44, -47, -48, -50, -51, -54, -55, -56, -59, -60, -62, -63, -64, -66, -67,
-69, -70, -72, -72, -74, -76, -76, -78, -79, -80, -81, -82, -83, -84, -85, -87,
-88, -88, -89, -89, -91, -92, -93, -94, -95, -95, -96, -96, -97, -98, -99, -100,
-100, -101, -102, -103, -103, -103, -104, -105, -106, -106, -106, -107, -108,
-108, -108, -109, -109, -110, -110, -111, -111, -111, -111, -112, -112, -113,
-113, -114, -114, -114, -114, -115, -114, -116, -115, -116, -116, -115, -116,
-116, -116, -117, -117, -118, -118, -118, -118, -118, -118, -118, -118, -118,
-118, -119, -118, -118, -119, -118, -119, -119, -119, -119, -120, -120, -119,
-118, -119, -119, -120, -118, -119, -119, -119, -119, -120, -119, -119, -119,
-118, -118, -119, -119, -118, -118, -118, -118, -117, -118, -118, -118, -117,
-117, -117, -117, -116, -116, -116, -116, -116, -115, -115, -115, -115, -114,
-114, -114, -114, -114, -114, -114, -113, -113, -113, -112, -112, -111, -111,
-110, -110, -110, -109, -108, -107, -109, -107, -107, -106, -106, -106, -105,
-105, -103, -103, -102, -102, -101, -100, -99, -98, -98, -97, -96, -96, -94,
-94, -92, -92, -91, -90, -88, -88, -86, -86, -84, -83, -81, -81, -78, -77, -76,
-75, -74, -71, -70, -68, -67, -66, -63, -62, -60, -58, -57, -54, -53, -50, -48,
-45, -44, -41, -38, -37, -34, -31, -28, -25, -23, -20, -17, -14, -11, -8, -3,
-1, };