#define DATA_LENGTH 512
#define DATA AKWF_0704

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 5, 7, 8, 10, 10, 12, 13, 15,
16, 18, 18, 19, 22, 22, 24, 26, 27, 28, 28, 31, 31, 33, 35, 35, 36, 38, 39, 39,
42, 42, 43, 45, 46, 47, 48, 49, 51, 51, 54, 54, 55, 56, 58, 59, 60, 61, 63, 63,
65, 65, 67, 68, 68, 71, 71, 71, 73, 75, 75, 77, 77, 79, 80, 80, 81, 82, 83, 84,
85, 87, 87, 88, 89, 90, 92, 92, 92, 93, 95, 96, 96, 97, 98, 99, 99, 100, 101,
102, 103, 103, 103, 103, 104, 105, 106, 106, 107, 108, 108, 108, 108, 109, 109,
110, 110, 110, 111, 110, 112, 111, 111, 111, 111, 112, 111, 112, 112, 111, 112,
112, 111, 110, 110, 110, 110, 109, 109, 110, 109, 109, 108, 107, 107, 106, 105,
105, 104, 103, 103, 102, 101, 101, 100, 99, 97, 96, 96, 95, 94, 93, 92, 91, 90,
88, 87, 87, 86, 84, 82, 81, 80, 79, 77, 76, 75, 74, 72, 71, 70, 69, 68, 66, 65,
63, 61, 60, 59, 57, 55, 55, 52, 52, 51, 49, 48, 45, 45, 44, 42, 41, 40, 38, 37,
36, 34, 33, 32, 31, 29, 28, 27, 26, 23, 23, 22, 21, 20, 19, 18, 16, 16, 15, 14,
13, 12, 11, 10, 9, 8, 9, 7, 6, 5, 4, 3, 4, 3, 2, 2, 1, 1, 1, 1, -1, -1, -2, -2,
-2, -3, -3, -3, -3, -3, -4, -5, -4, -4, -5, -5, -4, -5, -5, -5, -6, -5, -6, -6,
-6, -6, -6, -6, -6, -6, -7, -5, -5, -5, -7, -6, -6, -6, -6, -6, -6, -6, -6, -6,
-6, -6, -7, -7, -7, -7, -7, -8, -8, -8, -7, -8, -8, -9, -8, -9, -10, -9, -10,
-10, -12, -12, -12, -12, -13, -14, -15, -15, -14, -16, -17, -17, -18, -19, -19,
-21, -21, -22, -22, -23, -24, -26, -26, -27, -29, -29, -30, -32, -32, -33, -35,
-36, -37, -38, -39, -42, -42, -43, -44, -46, -47, -49, -50, -51, -52, -53, -55,
-56, -58, -60, -61, -63, -63, -65, -68, -69, -70, -71, -73, -74, -74, -77, -79,
-80, -81, -82, -83, -84, -86, -88, -89, -90, -91, -93, -95, -95, -96, -98, -99,
-100, -101, -102, -103, -104, -105, -105, -106, -108, -109, -110, -111, -112,
-111, -113, -114, -113, -114, -115, -116, -117, -117, -118, -117, -117, -118,
-118, -118, -118, -119, -118, -119, -119, -119, -119, -119, -119, -118, -118,
-118, -117, -118, -117, -117, -116, -116, -115, -115, -114, -113, -113, -113,
-111, -111, -111, -110, -108, -107, -107, -106, -105, -104, -103, -101, -100,
-100, -99, -97, -95, -94, -94, -92, -91, -89, -88, -87, -86, -85, -83, -81, -81,
-78, -78, -76, -74, -73, -72, -70, -69, -66, -65, -64, -62, -61, -58, -58, -56,
-54, -52, -51, -50, -47, -46, -45, -43, -41, -40, -39, -37, -35, -34, -32, -31,
-28, -27, -27, -25, -23, -22, -20, -19, -17, -16, -14, -13, -11, -10, -8, -6,
-6, -2, -1, -1, };