#define DATA_LENGTH 512
#define DATA AKWF_0710

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 7, 11, 14, 17, 20, 23, 26, 29,
32, 36, 38, 41, 44, 47, 50, 52, 56, 59, 62, 65, 68, 72, 74, 76, 80, 82, 86, 88,
92, 95, 97, 101, 104, 107, 109, 112, 115, 119, 118, 113, 111, 107, 105, 102, 99,
96, 93, 90, 87, 84, 82, 78, 75, 72, 69, 67, 63, 60, 57, 54, 51, 49, 46, 42, 39,
36, 34, 30, 28, 24, 22, 19, 15, 12, 10, 6, 4, 1, -2, -5, -7, -9, -10, -10, -11,
-12, -12, -13, -14, -15, -16, -16, -17, -18, -18, -19, -20, -21, -22, -22, -23,
-24, -23, -22, -22, -21, -20, -20, -19, -18, -17, -16, -16, -15, -14, -14, -12,
-12, -11, -10, -10, -10, -8, -8, -9, -9, -9, -9, -11, -10, -11, -11, -12, -12,
-12, -12, -13, -14, -14, -14, -15, -15, -15, -15, -16, -16, -17, -18, -18, -17,
-18, -18, -18, -19, -20, -20, -20, -21, -21, -22, -22, -22, -23, -23, -23, -25,
-23, -21, -21, -19, -19, -17, -17, -15, -14, -13, -12, -11, -10, -8, -7, -7, -5,
-4, -3, -2, 0, 1, 2, 4, 4, 5, 6, 8, 8, 9, 10, 12, 14, 14, 15, 17, 18, 18, 19,
20, 22, 22, 23, 22, 19, 17, 15, 13, 9, 8, 6, 3, 1, 0, -3, -5, -7, -10, -13, -15,
-17, -19, -22, -24, -24, -25, -26, -26, -28, -27, -29, -30, -30, -31, -31, -32,
-33, -35, -35, -36, -36, -37, -38, -38, -39, -39, -37, -36, -34, -33, -32, -30,
-28, -27, -25, -24, -23, -21, -19, -18, -17, -15, -13, -11, -10, -9, -8, -6, -5,
-3, -2, 0, 1, 3, 5, 6, 7, 9, 10, 12, 13, 14, 17, 18, 19, 20, 23, 24, 22, 20, 19,
18, 17, 15, 14, 13, 10, 8, 7, 6, 5, 3, 1, 0, -2, -3, -4, -6, -7, -8, -10, -12,
-13, -14, -17, -17, -19, -21, -22, -23, -26, -27, -27, -29, -31, -32, -34, -36,
-37, -39, -40, -39, -38, -37, -37, -36, -34, -34, -34, -33, -32, -31, -31, -30,
-29, -28, -28, -28, -25, -25, -25, -24, -21, -20, -17, -15, -13, -10, -8, -6,
-4, -2, 0, 3, 5, 7, 9, 11, 14, 15, 19, 20, 23, 24, 22, 21, 20, 18, 18, 16, 16,
14, 12, 12, 11, 10, 9, 7, 6, 6, 4, 3, 1, 1, 0, -1, -3, -4, -5, -6, -7, -7, -9,
-10, -11, -13, -13, -15, -16, -17, -18, -18, -20, -21, -22, -23, -23, -23, -23,
-22, -22, -21, -21, -21, -21, -21, -20, -19, -19, -18, -19, -18, -18, -18, -17,
-17, -16, -15, -15, -15, -15, -14, -14, -13, -13, -13, -12, -12, -11, -12, -12,
-11, -10, -10, -10, -9, -8, -9, -8, -8, -9, -10, -11, -11, -12, -14, -14, -15,
-16, -17, -17, -18, -19, -19, -20, -21, -21, -23, -23, -23, -23, -22, -22, -20,
-20, -19, -19, -18, -17, -17, -15, -15, -15, -13, -13, -13, -12, -11, -10, -9,
-9, -6, -3, 0, };