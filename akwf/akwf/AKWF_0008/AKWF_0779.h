#define DATA_LENGTH 512
#define DATA AKWF_0779

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 7, 10, 11, 14, 16, 18, 21,
22, 24, 26, 28, 30, 31, 33, 36, 37, 38, 41, 42, 44, 45, 47, 48, 51, 52, 54, 55,
56, 58, 60, 62, 63, 64, 66, 67, 68, 69, 72, 72, 74, 75, 76, 77, 79, 80, 81, 82,
83, 84, 86, 87, 87, 88, 89, 90, 92, 92, 93, 94, 95, 96, 97, 97, 99, 99, 100,
100, 101, 101, 102, 103, 104, 104, 105, 106, 106, 106, 108, 108, 108, 108, 109,
109, 110, 111, 110, 112, 112, 112, 113, 114, 114, 113, 114, 115, 115, 116, 116,
116, 116, 116, 116, 117, 116, 117, 118, 117, 117, 118, 118, 119, 118, 118, 118,
119, 118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 118,
119, 119, 118, 118, 119, 118, 119, 118, 119, 117, 117, 118, 118, 117, 116, 117,
117, 116, 116, 115, 115, 115, 115, 114, 115, 114, 113, 113, 113, 112, 112, 112,
111, 111, 110, 110, 109, 109, 108, 108, 108, 107, 106, 106, 106, 104, 103, 104,
102, 102, 101, 101, 100, 99, 99, 97, 96, 96, 96, 95, 94, 93, 92, 91, 90, 89, 88,
88, 86, 86, 84, 83, 82, 81, 80, 79, 78, 77, 74, 73, 72, 71, 70, 69, 68, 66, 64,
63, 62, 60, 58, 57, 56, 54, 52, 51, 49, 47, 46, 45, 43, 41, 39, 37, 36, 35, 32,
30, 29, 27, 25, 23, 21, 19, 17, 15, 13, 12, 9, 7, 5, 3, 1, -1, -3, -7, -8, -10,
-11, -14, -17, -18, -21, -22, -24, -26, -28, -30, -31, -33, -35, -37, -39, -41,
-42, -44, -46, -47, -49, -51, -51, -54, -56, -56, -59, -60, -61, -62, -64, -66,
-67, -69, -70, -71, -73, -73, -75, -77, -78, -79, -80, -80, -83, -83, -84, -85,
-87, -87, -88, -89, -91, -92, -92, -93, -94, -95, -96, -97, -98, -98, -99, -100,
-100, -101, -102, -102, -103, -103, -104, -105, -106, -106, -106, -108, -108,
-109, -109, -109, -110, -110, -111, -111, -111, -112, -112, -112, -113, -113,
-114, -114, -114, -114, -115, -116, -116, -116, -117, -117, -117, -117, -118,
-117, -118, -118, -118, -118, -118, -118, -118, -119, -118, -119, -119, -119,
-119, -120, -120, -119, -119, -119, -119, -119, -118, -118, -119, -118, -119,
-119, -119, -119, -118, -118, -118, -118, -118, -117, -117, -117, -117, -118,
-117, -117, -117, -117, -116, -115, -116, -115, -115, -114, -114, -113, -113,
-113, -112, -112, -112, -111, -111, -110, -110, -110, -109, -109, -109, -109,
-108, -107, -106, -105, -105, -105, -104, -103, -102, -101, -101, -100, -99,
-99, -98, -98, -96, -96, -96, -94, -94, -92, -91, -91, -90, -90, -89, -87, -87,
-85, -85, -83, -82, -80, -79, -78, -77, -76, -74, -74, -72, -71, -70, -67, -67,
-65, -65, -64, -61, -60, -58, -57, -56, -55, -52, -51, -49, -47, -45, -44, -43,
-41, -39, -37, -36, -34, -32, -30, -28, -27, -24, -22, -21, -19, -16, -16, -13,
-11, -9, -7, -5, -3, 0, };