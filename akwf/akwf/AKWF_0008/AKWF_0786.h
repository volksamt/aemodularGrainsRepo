#define DATA_LENGTH 512
#define DATA AKWF_0786

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 1, 1, 1, 2, 2, 3, 2, 3, 4, 3,
4, 4, 4, 6, 5, 5, 6, 6, 7, 6, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 6, 7, 6, 6, 6, 5, 6,
5, 4, 4, 4, 4, 4, 4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 4, 4, 4, 5, 5, 6, 5, 7, 7,
7, 8, 8, 8, 9, 8, 9, 8, 8, 9, 10, 8, 12, 20, 17, 14, 13, 15, 16, 18, 19, 20, 21,
22, 23, 23, 24, 25, 26, 28, 28, 30, 32, 34, 37, 39, 43, 46, 49, 51, 52, 53, 55,
56, 56, 56, 56, 55, 55, 54, 54, 54, 53, 52, 53, 51, 52, 52, 52, 52, 52, 52, 52,
52, 53, 54, 54, 54, 55, 56, 56, 57, 59, 59, 59, 61, 61, 63, 62, 63, 64, 65, 66,
66, 68, 70, 70, 71, 72, 72, 74, 74, 76, 77, 78, 79, 80, 81, 82, 84, 84, 85, 87,
87, 89, 90, 91, 92, 92, 95, 96, 97, 98, 100, 102, 103, 105, 107, 110, 113, 117,
118, 117, 118, 118, 119, 119, 120, 118, 97, 59, 46, 53, 56, 53, 53, 53, 55, 55,
55, 55, 55, 54, 54, 54, 55, 56, 56, 56, 55, 55, 53, 53, 51, 50, 47, 45, 42, 41,
38, 35, 32, 30, 27, 26, 25, 24, 24, 23, 21, 21, 21, 19, 19, 17, 15, 14, 12, 12,
14, 15, 16, 13, 4, 0, 4, 5, 7, 5, 5, 3, 1, 0, 0, -1, -3, -3, -2, -4, -5, -5, -5,
-8, -9, -10, -11, -12, -14, -17, -19, -20, -23, -26, -27, -30, -31, -33, -33,
-35, -36, -36, -36, -36, -37, -37, -36, -35, -35, -34, -34, -33, -33, -34, -33,
-32, -32, -32, -31, -32, -32, -32, -32, -33, -32, -33, -33, -33, -34, -34, -35,
-34, -35, -36, -37, -37, -38, -38, -38, -39, -39, -40, -41, -41, -41, -42, -43,
-43, -44, -44, -45, -47, -46, -47, -47, -49, -49, -51, -51, -52, -52, -52, -52,
-54, -54, -56, -56, -57, -58, -59, -59, -60, -60, -61, -61, -63, -63, -64, -65,
-66, -66, -67, -68, -69, -69, -69, -71, -72, -72, -73, -74, -74, -74, -75, -76,
-78, -78, -80, -81, -81, -83, -83, -84, -85, -88, -88, -89, -93, -95, -97, -98,
-99, -98, -98, -99, -99, -99, -99, -99, -99, -99, -99, -100, -99, -92, -77, -55,
-36, -27, -27, -32, -35, -36, -35, -34, -32, -33, -33, -34, -34, -35, -35, -36,
-36, -35, -35, -35, -34, -33, -34, -35, -35, -34, -35, -36, -34, -35, -35, -36,
-36, -36, -36, -35, -36, -35, -35, -35, -35, -34, -33, -33, -33, -32, -32, -31,
-30, -29, -28, -28, -27, -25, -25, -24, -23, -22, -20, -19, -18, -18, -16, -14,
-13, -13, -12, -11, -11, -11, -9, -9, -7, -7, -6, -6, -6, -6, -6, -4, -4, -4,
-3, -3, -3, -3, -4, -2, -2, -2, -1, -1, -1, -1, 0, 0, 0, -1, 0, };