#define DATA_LENGTH 512
#define DATA AKWF_0740

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 8, 13, 17, 22, 26, 28, 33, 35, 38,
40, 43, 45, 47, 49, 50, 52, 53, 54, 57, 58, 59, 61, 61, 63, 64, 66, 66, 68, 69,
70, 72, 72, 74, 75, 76, 78, 79, 80, 82, 84, 84, 87, 88, 90, 91, 93, 94, 96, 97,
100, 101, 102, 103, 105, 106, 108, 109, 111, 111, 113, 113, 114, 116, 116, 117,
117, 118, 118, 119, 119, 119, 119, 119, 119, 118, 119, 118, 118, 117, 117, 117,
116, 115, 114, 114, 113, 112, 113, 112, 111, 111, 110, 111, 109, 109, 108, 108,
109, 108, 108, 106, 106, 106, 107, 106, 106, 106, 105, 105, 106, 106, 106, 105,
105, 105, 104, 105, 104, 104, 105, 103, 102, 102, 102, 101, 101, 100, 99, 97,
96, 97, 95, 95, 93, 92, 91, 89, 89, 86, 85, 84, 82, 81, 79, 78, 77, 75, 74, 72,
70, 68, 67, 64, 63, 61, 60, 59, 56, 54, 53, 52, 49, 48, 45, 44, 42, 40, 38, 37,
34, 32, 31, 28, 27, 24, 22, 20, 18, 16, 13, 10, 8, 5, 4, 0, -2, -6, -6, -23,
-41, -48, -58, -63, -67, -70, -73, -75, -77, -79, -79, -79, -79, -80, -79, -79,
-79, -78, -79, -79, -79, -80, -81, -82, -82, -84, -85, -87, -88, -91, -92, -94,
-95, -98, -99, -101, -102, -104, -105, -106, -108, -109, -110, -110, -112, -112,
-111, -112, -112, -112, -112, -111, -110, -110, -110, -109, -108, -108, -107,
-106, -106, -105, -104, -103, -102, -101, -100, -99, -99, -97, -96, -94, -94,
-92, -92, -90, -89, -88, -87, -85, -84, -82, -80, -78, -77, -75, -74, -72, -69,
-67, -64, -63, -61, -58, -56, -54, -51, -49, -47, -45, -42, -40, -38, -36, -34,
-31, -29, -27, -26, -23, -21, -19, -17, -15, -14, -12, -11, -8, -7, -6, -5, -3,
-2, -1, 1, 1, 1, 2, 3, 3, 4, 3, 4, 4, 3, 4, 3, 3, 3, 2, 2, 1, 0, 0, -1, -2, -3,
-3, -5, -6, -7, -7, -8, -9, -10, -10, -11, -11, -12, -12, -13, -14, -14, -14,
-14, -15, -15, -14, -14, -14, -14, -14, -14, -14, -14, -13, -13, -12, -12, -12,
-12, -11, -11, -12, -10, -10, -10, -10, -10, -10, -10, -9, -9, -10, -9, -9, -9,
-10, -11, -11, -11, -12, -12, -12, -13, -13, -14, -14, -14, -15, -15, -16, -18,
-17, -18, -19, -19, -20, -20, -21, -21, -22, -22, -22, -23, -24, -24, -25, -25,
-25, -25, -27, -27, -28, -28, -28, -29, -29, -30, -29, -31, -31, -32, -32, -33,
-34, -35, -36, -36, -37, -38, -39, -40, -42, -40, -57, -73, -78, -84, -87, -91,
-93, -94, -94, -95, -94, -93, -91, -90, -89, -86, -85, -83, -81, -79, -79, -77,
-76, -75, -75, -75, -73, -74, -74, -73, -74, -74, -74, -75, -75, -74, -75, -75,
-75, -74, -75, -75, -74, -73, -73, -71, -71, -69, -68, -66, -65, -63, -61, -59,
-59, -56, -54, -52, -49, -49, -46, -44, -42, -41, -25, -11, -4, };