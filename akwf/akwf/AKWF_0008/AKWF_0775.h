#define DATA_LENGTH 512
#define DATA AKWF_0775

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 4, 6, 7, 9, 11, 12, 14, 14,
18, 19, 21, 23, 24, 26, 28, 29, 31, 33, 35, 36, 38, 40, 42, 43, 45, 47, 48, 50,
51, 54, 55, 56, 57, 59, 60, 63, 63, 66, 66, 68, 69, 70, 73, 74, 75, 78, 78, 80,
82, 83, 84, 87, 87, 88, 90, 92, 94, 95, 96, 97, 99, 100, 100, 102, 103, 105,
105, 106, 107, 108, 109, 110, 110, 110, 111, 111, 113, 113, 113, 113, 113, 114,
113, 114, 114, 115, 114, 114, 114, 114, 114, 114, 114, 114, 113, 113, 114, 113,
113, 113, 112, 112, 112, 112, 111, 112, 112, 111, 112, 111, 111, 111, 112, 112,
113, 112, 113, 112, 113, 113, 113, 113, 113, 113, 114, 115, 114, 115, 116, 116,
117, 117, 116, 117, 117, 117, 118, 118, 119, 119, 119, 118, 118, 119, 119, 119,
119, 120, 118, 119, 118, 119, 118, 117, 117, 117, 116, 115, 114, 115, 114, 113,
113, 113, 112, 111, 110, 109, 109, 108, 107, 107, 106, 105, 104, 103, 103, 101,
100, 100, 99, 98, 96, 95, 95, 93, 93, 91, 90, 89, 87, 86, 85, 84, 82, 81, 80,
77, 76, 74, 71, 70, 68, 66, 64, 62, 60, 58, 57, 55, 54, 51, 50, 49, 47, 44, 43,
42, 40, 39, 37, 37, 34, 33, 32, 30, 29, 28, 26, 25, 23, 22, 21, 20, 19, 18, 16,
16, 14, 13, 12, 12, 9, 9, 9, 7, 7, 6, 5, 4, 4, 2, 1, 0, -1, -2, -4, -6, -6, -8,
-10, -12, -14, -15, -17, -18, -21, -23, -25, -26, -28, -30, -31, -33, -35, -37,
-38, -40, -41, -44, -45, -46, -49, -49, -51, -53, -54, -56, -58, -59, -60, -62,
-64, -64, -67, -68, -70, -71, -73, -74, -75, -77, -78, -80, -82, -84, -85, -85,
-88, -89, -91, -92, -93, -94, -96, -97, -99, -100, -101, -103, -103, -104, -105,
-106, -107, -108, -108, -109, -110, -111, -111, -111, -113, -112, -114, -113,
-114, -114, -115, -114, -115, -114, -114, -114, -115, -114, -114, -114, -113,
-114, -114, -114, -114, -112, -112, -112, -112, -112, -112, -112, -112, -111,
-111, -112, -112, -111, -112, -112, -111, -112, -112, -111, -112, -112, -113,
-112, -113, -114, -114, -114, -114, -115, -115, -116, -115, -116, -117, -116,
-117, -117, -117, -117, -118, -118, -118, -118, -119, -118, -119, -119, -119,
-118, -119, -120, -118, -119, -118, -118, -117, -118, -117, -117, -116, -116,
-115, -115, -114, -114, -114, -112, -111, -111, -110, -109, -108, -107, -106,
-107, -105, -104, -104, -103, -102, -102, -101, -99, -98, -98, -96, -95, -94,
-94, -92, -91, -90, -89, -88, -87, -85, -84, -82, -80, -79, -77, -75, -74, -71,
-70, -67, -66, -64, -63, -60, -59, -57, -56, -53, -52, -50, -48, -46, -45, -43,
-41, -40, -39, -37, -35, -34, -32, -32, -30, -28, -28, -26, -25, -23, -22, -21,
-20, -19, -17, -17, -15, -14, -13, -11, -11, -11, -9, -8, -7, -6, -6, -4, -4,
-3, -1, 0, };