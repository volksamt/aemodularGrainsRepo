#define DATA_LENGTH 512
#define DATA AKWF_0795

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 8, 12, 12, 19, 47, 61, 72,
81, 88, 96, 102, 110, 115, 119, 115, 110, 104, 100, 95, 91, 86, 82, 78, 75, 70,
67, 63, 59, 56, 52, 49, 45, 41, 38, 35, 32, 29, 26, 22, 19, 17, 13, 13, 13, 13,
12, 13, 13, 13, 13, 14, 13, 14, 13, 13, 13, 13, 12, 13, 12, 13, 13, 13, 12, 14,
13, 13, 13, 13, 13, 12, 12, 13, 13, 14, 13, 13, 12, 13, 12, 12, 13, 13, 13, 12,
12, 13, 12, 13, 13, 12, 13, 13, 13, 13, 13, 14, 12, 13, 13, 12, 13, 12, 13, 13,
13, 12, 14, 12, 13, 13, 12, 13, 13, 12, 13, 12, 13, 12, 13, 13, 13, 13, 12, 13,
13, 12, 13, 13, 12, 13, 12, 13, 13, 13, 13, 12, 12, 12, 13, 12, 13, 13, 13, 13,
13, 13, 13, 12, 12, 12, 13, 12, 12, 13, 13, 13, 13, 12, 13, 12, 13, 12, 13, 12,
13, 13, 13, 13, 12, 13, 13, 13, 13, 13, 12, 13, 13, 13, 13, 13, 12, 13, 13, 13,
13, 13, 13, 12, 12, 13, 13, 13, 12, 13, 13, 13, 13, 12, 12, 13, 13, 13, 12, 13,
12, 13, 12, 13, 13, 12, 12, 13, 12, 12, 13, 12, 13, 12, 12, 12, 13, 13, 12, 13,
13, 13, 13, 12, 13, 13, 12, 13, 13, 13, 12, 13, 13, 13, 12, 12, 13, 13, 12, 13,
13, 12, 13, 12, 12, 13, 12, 13, 13, 13, 13, 13, 13, 13, 12, 13, 12, 12, 12, 13,
12, 13, 12, 12, 13, 12, 12, 13, 12, 13, 13, 12, 12, 13, 12, 12, 12, 12, 13, 12,
13, 12, 13, 12, 12, 13, 13, 13, 12, 12, 13, 13, 13, 12, 13, 12, 13, 12, 12, 12,
12, 12, 12, 12, 12, 13, 13, 13, 12, 12, 12, 12, 12, 12, 12, 12, 12, 13, 13, 12,
12, 13, 13, 12, 12, 13, 12, 13, 12, 13, 13, 12, 10, 9, 7, 7, 5, 4, 3, 1, 0, -1,
-2, -3, -5, -6, -7, -8, -10, -10, 7, 12, 9, 8, 6, 6, 4, 4, 2, 1, 0, -2, -3, -3,
-5, -6, -7, -8, -10, -11, -12, -13, -14, -16, -16, -18, -19, -20, -21, -22, -23,
-24, -25, -27, -28, -29, -31, -31, -32, -34, -35, -36, -37, -38, -39, -40, -42,
-43, -44, -45, -46, -47, -49, -49, -51, -52, -53, -54, -55, -56, -57, -59, -60,
-61, -62, -63, -64, -65, -66, -68, -69, -69, -70, -71, -73, -73, -75, -76, -78,
-79, -79, -81, -82, -83, -84, -85, -85, -87, -88, -89, -88, -87, -86, -85, -83,
-82, -82, -81, -79, -78, -77, -76, -74, -73, -72, -71, -71, -68, -67, -66, -65,
-64, -63, -62, -62, -59, -58, -58, -57, -56, -55, -53, -52, -50, -50, -48, -48,
-46, -45, -44, -43, -41, -40, -40, -38, -38, -35, -35, -33, -38, -11, 19, 18,
18, 20, 21, 22, 23, 24, 25, 28, 29, 7, -4, };