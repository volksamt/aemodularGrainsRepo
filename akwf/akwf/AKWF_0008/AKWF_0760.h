#define DATA_LENGTH 512
#define DATA AKWF_0760

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 6, 6, 7, 9, 9, 10, 12, 13,
13, 14, 15, 15, 15, 16, 17, 17, 18, 18, 18, 19, 20, 19, 20, 20, 20, 21, 21, 21,
22, 21, 21, 22, 22, 23, 22, 22, 22, 23, 23, 22, 22, 22, 23, 23, 22, 22, 22, 22,
21, 22, 21, 21, 21, 21, 20, 20, 20, 20, 20, 20, 19, 20, 19, 19, 18, 18, 18, 17,
18, 17, 16, 16, 15, 16, 16, 16, 14, 13, 14, 14, 13, 12, 13, 12, 12, 11, 11, 10,
11, 10, 9, 9, 9, 9, 8, 7, 7, 7, 6, 6, 6, 5, 5, 4, 4, 3, 2, 2, 1, 1, 0, 0, 0, 0,
-1, -2, -2, -3, -2, -3, -4, -5, -5, -5, -6, -5, -7, -7, -7, -8, -8, -8, -9, -10,
-10, -11, -11, -11, -13, -13, -13, -13, -13, -14, -14, -16, -16, -16, -17, -17,
-18, -19, -18, -20, -20, -20, -21, -22, -21, -22, -23, -23, -24, -24, -25, -25,
-25, -26, -27, -26, -28, -29, -29, -29, -30, -30, -30, -32, -32, -31, -32, -33,
-33, -34, -34, -35, -35, -35, -36, -37, -38, -37, -37, -37, -38, -38, -37, -37,
-36, -35, -34, -33, -32, -30, -29, -27, -26, -24, -21, -19, -16, -14, -13, -9,
-7, -4, -1, 2, 4, 6, 9, 13, 14, 17, 20, 22, 24, 27, 29, 32, 33, 36, 39, 40, 43,
45, 48, 49, 51, 52, 55, 56, 57, 60, 60, 62, 64, 65, 67, 68, 69, 70, 71, 72, 74,
74, 75, 76, 76, 78, 79, 80, 81, 81, 82, 83, 84, 83, 84, 85, 86, 86, 86, 87, 87,
87, 87, 87, 88, 88, 87, 89, 88, 88, 89, 89, 89, 90, 89, 88, 89, 90, 89, 89, 90,
89, 90, 88, 88, 88, 88, 89, 89, 88, 88, 89, 87, 88, 88, 87, 87, 87, 86, 86, 85,
85, 85, 84, 84, 85, 83, 84, 84, 82, 82, 83, 82, 82, 81, 79, 79, 78, 76, 76, 74,
72, 71, 69, 67, 66, 64, 62, 59, 57, 56, 53, 51, 49, 45, 43, 41, 38, 35, 33, 31,
29, 25, 24, 20, 17, 15, 13, 10, 8, 6, 4, 1, -1, -3, -6, -8, -10, -12, -14, -17,
-18, -20, -22, -24, -26, -28, -30, -32, -33, -35, -36, -38, -40, -42, -43, -44,
-46, -48, -49, -51, -52, -53, -56, -56, -58, -59, -62, -62, -64, -65, -67, -68,
-70, -70, -71, -73, -73, -75, -76, -78, -79, -81, -82, -83, -85, -85, -87, -88,
-89, -91, -92, -94, -94, -95, -97, -99, -99, -100, -102, -103, -104, -106, -107,
-108, -109, -111, -111, -113, -114, -115, -116, -117, -118, -119, -119, -119,
-120, -118, -119, -118, -117, -117, -115, -114, -112, -111, -109, -106, -104,
-102, -100, -97, -94, -92, -89, -85, -82, -80, -77, -74, -70, -69, -65, -63,
-60, -56, -54, -51, -48, -46, -43, -40, -37, -35, -33, -30, -28, -26, -25, -23,
-21, -18, -16, -14, -13, -11, -9, -7, -6, -4, -3, -1, -1, };