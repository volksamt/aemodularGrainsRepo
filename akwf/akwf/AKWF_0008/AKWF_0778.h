#define DATA_LENGTH 512
#define DATA AKWF_0778

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 9, 11, 14, 17, 19, 21, 23,
26, 28, 31, 33, 35, 37, 38, 41, 43, 45, 46, 49, 50, 51, 54, 56, 57, 59, 60, 62,
63, 65, 67, 68, 69, 71, 73, 73, 75, 77, 77, 78, 79, 81, 82, 83, 85, 85, 86, 87,
88, 89, 89, 90, 91, 92, 92, 93, 94, 95, 96, 96, 98, 97, 99, 100, 101, 100, 101,
102, 103, 103, 104, 104, 105, 104, 105, 106, 106, 107, 107, 107, 108, 108, 109,
109, 109, 109, 110, 110, 110, 110, 111, 111, 112, 112, 112, 112, 113, 112, 113,
113, 113, 113, 114, 114, 114, 114, 114, 115, 115, 115, 115, 115, 115, 115, 116,
116, 116, 116, 117, 117, 116, 117, 117, 117, 117, 117, 117, 118, 117, 117, 117,
117, 117, 118, 118, 118, 118, 118, 117, 118, 119, 118, 118, 119, 118, 118, 119,
119, 118, 119, 118, 119, 118, 119, 118, 119, 118, 118, 119, 118, 118, 118, 119,
119, 118, 118, 118, 118, 119, 119, 119, 117, 118, 119, 118, 118, 118, 119, 118,
118, 117, 116, 116, 117, 116, 115, 115, 115, 115, 114, 113, 113, 113, 111, 111,
111, 110, 109, 106, 106, 105, 103, 103, 102, 101, 99, 98, 97, 95, 94, 92, 91,
90, 88, 87, 85, 83, 81, 81, 78, 77, 75, 72, 71, 69, 68, 65, 63, 61, 59, 58, 56,
54, 51, 49, 46, 45, 42, 39, 37, 36, 32, 31, 28, 25, 22, 20, 17, 14, 12, 10, 8,
5, 1, -1, -3, -6, -8, -10, -14, -15, -19, -21, -23, -25, -28, -29, -32, -34,
-36, -38, -40, -42, -44, -46, -49, -50, -52, -54, -54, -57, -59, -59, -62, -63,
-64, -66, -68, -68, -71, -72, -73, -74, -76, -77, -78, -80, -80, -82, -83, -83,
-84, -86, -87, -89, -88, -90, -90, -92, -92, -93, -95, -94, -96, -96, -97, -97,
-98, -98, -100, -100, -101, -102, -102, -102, -102, -103, -105, -105, -105,
-106, -106, -106, -107, -107, -108, -108, -108, -109, -109, -109, -111, -110,
-111, -111, -111, -111, -112, -112, -112, -113, -113, -112, -113, -114, -113,
-114, -114, -115, -114, -115, -115, -116, -116, -116, -115, -115, -116, -116,
-116, -116, -116, -117, -116, -117, -118, -117, -117, -118, -118, -118, -118,
-118, -118, -118, -117, -118, -118, -119, -118, -118, -119, -118, -119, -119,
-118, -118, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -118, -119, -118, -119, -119, -119, -119, -118, -118, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -118, -119, -119, -118, -119, -119,
-118, -117, -118, -117, -117, -116, -116, -117, -116, -115, -115, -115, -113,
-113, -112, -112, -112, -111, -111, -109, -108, -105, -105, -104, -103, -103,
-100, -99, -98, -97, -95, -93, -92, -91, -90, -87, -86, -84, -83, -80, -80, -77,
-75, -74, -73, -70, -68, -66, -64, -62, -61, -59, -56, -54, -53, -50, -48, -46,
-43, -40, -39, -36, -34, -31, -29, -26, -23, -21, -18, -16, -13, -11, -8, -5,
-3, -1, };