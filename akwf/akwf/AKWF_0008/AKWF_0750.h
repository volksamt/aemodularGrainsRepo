#define DATA_LENGTH 512
#define DATA AKWF_0750

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 13, 22, 29, 34, 37, 37, 37, 35, 34,
33, 35, 36, 41, 48, 56, 64, 72, 79, 84, 87, 88, 87, 84, 80, 78, 77, 76, 77, 82,
87, 93, 101, 108, 114, 118, 119, 116, 112, 107, 101, 94, 86, 82, 78, 77, 77, 79,
80, 81, 81, 80, 76, 70, 62, 54, 44, 35, 27, 21, 19, 18, 19, 21, 24, 27, 30, 30,
28, 24, 19, 11, 4, -4, -10, -15, -18, -19, -17, -15, -11, -9, -6, -6, -6, -10,
-15, -20, -27, -31, -35, -38, -39, -37, -31, -26, -20, -14, -9, -5, -3, -5, -8,
-14, -18, -25, -29, -32, -33, -32, -29, -25, -20, -16, -13, -12, -11, -13, -17,
-21, -27, -31, -35, -36, -35, -32, -25, -18, -11, -3, 4, 8, 11, 11, 10, 7, 3, 0,
-3, -4, -3, -1, 4, 10, 16, 22, 26, 30, 31, 29, 27, 22, 18, 13, 9, 7, 8, 10, 14,
19, 26, 31, 35, 37, 35, 33, 28, 21, 12, 4, -3, -8, -13, -15, -16, -15, -15, -15,
-16, -17, -22, -29, -38, -47, -56, -66, -73, -79, -83, -84, -82, -81, -77, -74,
-71, -71, -73, -76, -81, -88, -96, -103, -109, -112, -115, -115, -112, -109,
-105, -101, -98, -95, -96, -98, -102, -106, -111, -115, -118, -119, -118, -114,
-109, -100, -92, -84, -78, -73, -70, -69, -71, -74, -77, -80, -83, -84, -83,
-79, -74, -69, -62, -55, -50, -45, -43, -43, -45, -48, -49, -52, -53, -52, -48,
-42, -34, -24, -15, -4, 5, 12, 17, 20, 21, 20, 20, 18, 18, 19, 22, 28, 34, 44,
51, 60, 66, 72, 75, 76, 75, 73, 70, 68, 67, 67, 69, 74, 79, 87, 96, 102, 107,
111, 112, 111, 108, 102, 95, 89, 83, 79, 76, 74, 75, 78, 79, 81, 80, 80, 76, 71,
63, 55, 46, 37, 30, 25, 22, 22, 23, 27, 30, 34, 36, 36, 36, 32, 26, 19, 11, 5,
-2, -5, -8, -8, -6, -2, 1, 5, 8, 7, 7, 4, -1, -6, -13, -18, -21, -23, -22, -20,
-15, -9, -2, 4, 10, 13, 14, 13, 10, 7, 1, -4, -8, -10, -13, -10, -7, -3, 3, 7,
11, 13, 13, 11, 7, 2, -3, -7, -9, -11, -9, -6, 1, 8, 17, 25, 31, 36, 39, 40, 38,
36, 31, 28, 26, 25, 27, 29, 35, 41, 47, 53, 57, 60, 62, 60, 56, 53, 48, 44, 39,
39, 40, 41, 46, 51, 58, 64, 67, 69, 68, 65, 59, 53, 45, 36, 30, 23, 19, 16, 17,
17, 17, 17, 17, 14, 9, 3, -5, -14, -25, -34, -42, -47, -51, -51, -50, -48, -44,
-41, -39, -39, -41, -44, -50, -57, -65, -72, -78, -82, -84, -84, -82, -78, -73,
-70, -67, -66, -66, -69, -72, -78, -82, -87, -90, -91, -88, -85, -79, -71, -64,
-56, -50, -45, -43, -43, -44, -48, -52, -55, -58, -59, -58, -55, -50, -44, -37,
-31, -26, -22, -20, -21, -23, -26, -28, -32, -32, -32, -27, -22, -14, -4, };