#define DATA_LENGTH 512
#define DATA AKWF_0715

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 19, 10, 10, 14, 12, 10, 12, 14,
11, 12, 13, 12, 12, 12, 11, 12, 13, 13, 13, 12, 11, 13, 13, 11, 12, 13, 13, 11,
12, 16, 10, 7, 28, 61, 71, 62, 62, 69, 68, 65, 68, 70, 68, 69, 74, 73, 72, 74,
75, 75, 76, 78, 77, 77, 79, 80, 80, 81, 83, 83, 83, 85, 86, 85, 87, 88, 88, 88,
90, 91, 91, 92, 93, 93, 95, 96, 96, 97, 98, 98, 98, 100, 101, 101, 102, 103,
104, 103, 105, 106, 107, 107, 108, 109, 109, 111, 112, 112, 113, 114, 114, 114,
116, 117, 117, 118, 120, 118, 117, 119, 117, 116, 116, 115, 115, 114, 113, 113,
112, 112, 111, 111, 111, 110, 108, 108, 109, 108, 107, 106, 106, 104, 104, 104,
103, 103, 103, 101, 101, 100, 101, 99, 99, 99, 98, 97, 97, 97, 95, 95, 95, 94,
93, 93, 92, 91, 91, 91, 89, 89, 89, 88, 87, 87, 86, 86, 86, 86, 84, 83, 83, 82,
81, 81, 82, 80, 79, 80, 79, 77, 77, 78, 76, 75, 76, 75, 73, 74, 73, 72, 72, 72,
71, 69, 70, 69, 67, 68, 68, 65, 65, 67, 66, 62, 65, 66, 60, 61, 69, 57, 24, 3,
7, 13, 10, 7, 11, 10, 8, 10, 11, 8, 9, 11, 9, 9, 10, 10, 10, 9, 10, 10, 8, 10,
9, 8, 9, 9, 9, 9, 9, 9, 10, 9, 9, 9, 9, 9, 9, 9, 9, 9, 10, 9, 8, 9, 10, 8, 7,
12, 10, 5, 11, 15, -6, -39, -49, -41, -39, -46, -45, -42, -46, -48, -45, -45,
-48, -48, -47, -48, -49, -48, -49, -51, -51, -50, -52, -53, -52, -52, -54, -53,
-53, -56, -56, -55, -57, -57, -56, -58, -58, -59, -58, -60, -60, -60, -61, -62,
-61, -61, -63, -63, -63, -64, -65, -65, -65, -66, -66, -66, -68, -69, -68, -68,
-69, -70, -70, -71, -71, -71, -72, -73, -73, -74, -75, -74, -75, -75, -75, -76,
-77, -77, -77, -78, -79, -79, -79, -79, -80, -81, -81, -82, -82, -83, -83, -84,
-84, -85, -85, -86, -85, -87, -87, -86, -88, -88, -88, -88, -89, -90, -90, -91,
-91, -91, -92, -92, -93, -92, -94, -95, -94, -94, -96, -97, -97, -97, -98, -97,
-98, -96, -96, -96, -95, -95, -95, -93, -94, -92, -92, -92, -92, -90, -91, -89,
-89, -88, -89, -87, -87, -87, -86, -86, -85, -85, -85, -84, -84, -83, -82, -82,
-82, -81, -80, -81, -79, -80, -79, -79, -78, -78, -76, -75, -75, -75, -75, -74,
-74, -74, -72, -72, -72, -72, -71, -71, -70, -70, -69, -70, -68, -68, -68, -67,
-66, -66, -66, -64, -64, -64, -64, -62, -62, -63, -61, -62, -61, -60, -60, -60,
-58, -58, -58, -58, -57, -56, -57, -55, -55, -54, -55, -53, -53, -53, -51, -51,
-51, -51, -50, -50, -50, -48, -47, -49, -47, -47, -47, -48, -45, -44, -46, -44,
-43, -45, -43, -40, -42, -44, -39, -37, -46, -41, -12, };