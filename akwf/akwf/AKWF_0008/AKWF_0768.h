#define DATA_LENGTH 512
#define DATA AKWF_0768

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 5, 7, 7, 10, 11, 12, 14, 15,
17, 18, 18, 20, 21, 22, 23, 23, 25, 25, 27, 27, 28, 29, 29, 30, 31, 31, 32, 32,
33, 33, 34, 33, 34, 33, 34, 34, 34, 34, 34, 34, 34, 34, 34, 34, 33, 34, 33, 33,
34, 34, 34, 34, 34, 34, 34, 34, 33, 34, 33, 34, 34, 34, 34, 35, 34, 35, 35, 34,
35, 35, 36, 35, 36, 37, 37, 37, 38, 38, 38, 38, 39, 39, 39, 40, 41, 42, 41, 42,
42, 43, 43, 44, 44, 45, 44, 45, 45, 46, 47, 47, 47, 47, 48, 48, 48, 48, 49, 50,
50, 50, 51, 51, 51, 52, 53, 52, 53, 54, 54, 54, 56, 56, 56, 56, 56, 57, 58, 59,
59, 59, 61, 60, 61, 63, 63, 63, 64, 63, 64, 66, 66, 66, 67, 68, 68, 68, 70, 70,
70, 70, 71, 71, 72, 72, 72, 74, 75, 74, 74, 75, 76, 77, 76, 77, 77, 77, 77, 77,
79, 78, 79, 79, 79, 80, 79, 80, 81, 81, 81, 81, 81, 82, 82, 82, 83, 83, 83, 83,
84, 85, 85, 86, 85, 86, 85, 86, 87, 87, 87, 88, 87, 88, 88, 89, 89, 89, 90, 91,
91, 91, 90, 91, 91, 92, 92, 92, 92, 92, 92, 93, 93, 93, 92, 93, 93, 93, 94, 92,
92, 93, 93, 93, 92, 93, 92, 93, 91, 92, 91, 91, 90, 91, 89, 89, 88, 88, 87, 87,
87, 87, 85, 84, 83, 82, 81, 80, 80, 79, 79, 77, 76, 75, 74, 72, 72, 70, 70, 68,
66, 65, 64, 62, 59, 58, 57, 56, 53, 52, 50, 48, 47, 45, 42, 40, 37, 36, 34, 31,
29, 28, 25, 23, 21, 18, 16, 14, 11, 9, 6, 4, 2, 0, -2, -5, -8, -9, -13, -14,
-18, -19, -21, -23, -25, -28, -31, -32, -34, -36, -38, -40, -42, -44, -46, -47,
-49, -50, -52, -54, -55, -57, -58, -59, -62, -63, -64, -66, -67, -68, -69, -71,
-73, -73, -75, -77, -77, -79, -79, -81, -82, -83, -84, -85, -86, -87, -89, -90,
-91, -92, -92, -93, -94, -96, -96, -98, -97, -99, -99, -100, -102, -102, -103,
-104, -105, -105, -106, -106, -106, -107, -108, -108, -108, -108, -109, -110,
-111, -110, -112, -111, -112, -112, -113, -113, -113, -114, -114, -114, -114,
-114, -114, -115, -115, -116, -115, -116, -117, -116, -117, -116, -116, -118,
-117, -117, -118, -118, -118, -118, -118, -118, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -117, -119, -118, -118,
-117, -117, -116, -115, -114, -114, -114, -112, -112, -111, -111, -110, -109,
-108, -107, -105, -105, -103, -102, -100, -99, -98, -97, -95, -93, -93, -91,
-90, -88, -86, -85, -83, -82, -78, -77, -76, -73, -72, -69, -67, -65, -63, -61,
-60, -58, -55, -53, -52, -50, -47, -44, -42, -41, -39, -36, -34, -32, -29, -29,
-26, -23, -22, -19, -18, -16, -14, -12, -11, -8, -7, -5, -3, -1, };