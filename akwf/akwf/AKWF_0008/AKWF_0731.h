#define DATA_LENGTH 512
#define DATA AKWF_0731

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 12, 18, 21, 27, 31, 36, 41, 46,
51, 54, 60, 65, 68, 74, 78, 83, 87, 93, 97, 102, 106, 110, 116, 118, 113, 108,
103, 100, 94, 89, 84, 79, 75, 70, 66, 62, 57, 52, 47, 43, 38, 32, 28, 23, 19,
15, 10, 5, 0, -4, -6, -5, -5, -5, -5, -5, -6, -5, -5, -5, -6, -5, -5, -5, -5,
-6, -6, -5, -5, -6, -6, -4, -6, -6, -4, -5, -6, -5, -5, -5, -6, -6, -6, -6, -5,
-5, -5, -6, -5, -5, -5, -5, -6, -5, -6, -5, -5, -5, -6, -6, -5, -5, -5, -6, -5,
-5, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5, -6, -5, -5, -6, -6, -6, -5, -5, -6,
-5, -5, -5, -5, -5, -5, -5, -5, -5, -6, -5, -5, -5, -6, -5, -5, -5, -6, -5, -5,
-6, -5, -4, -5, -5, -6, -5, -4, -5, -5, -4, -4, -4, -3, -3, -4, -2, -3, -2, -2,
-2, -2, -1, -2, -2, -1, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, -1, -1, -2, -1, -2, -2,
-2, -3, -2, -3, -3, -4, -3, -3, -4, -4, -4, -4, -5, -4, -5, -5, -5, -6, -5, -5,
-6, -5, -5, -5, -5, -5, -5, -4, -5, -5, -5, -6, -6, -6, -6, -5, -5, -5, -5, -5,
-5, -5, -5, -5, -5, -5, -5, -5, -5, -6, -5, -6, -5, -5, -5, -5, -6, -5, -5, -5,
-5, -5, -6, -5, -5, -5, -5, -6, -5, -5, -6, -5, -5, -5, -5, -5, -5, -5, -5, -6,
-5, -5, -5, -5, -6, -6, -4, -4, -5, -5, -5, -6, -5, -5, -6, -6, -5, -5, -4, -5,
-5, -6, -7, -9, -10, -11, -11, -14, -15, -15, -16, -17, -19, -20, -21, -22, -23,
-24, -26, -27, -29, -30, -31, -31, -33, -34, -35, -36, -34, -33, -32, -31, -29,
-28, -27, -26, -25, -24, -23, -21, -21, -19, -18, -17, -16, -14, -13, -13, -10,
-10, -9, -7, -7, -5, -6, -5, -5, -5, -6, -5, -5, -5, -5, -6, -4, -5, -5, -5, -6,
-5, -5, -5, -5, -5, -5, -5, -6, -5, -5, -5, -5, -4, -5, -5, -5, -5, -6, -4, -5,
-6, -5, -5, -6, -6, -5, -6, -5, -5, -5, -5, -5, -5, -5, -5, -6, -5, -5, -5, -5,
-6, -4, -5, -6, -5, -6, -6, -6, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5, -4, -6,
-5, -4, -5, -5, -5, -5, -5, -4, -5, -5, -5, -5, -5, -5, -5, -4, -5, -5, -6, -5,
-5, -5, -6, -5, -5, -5, -6, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5, -4,
-5, -5, -5, -5, -4, -5, -4, -5, -5, -4, -4, -4, -5, -4, -5, -4, -4, -4, -4, -4,
-5, -4, -4, -4, -5, -5, -5, -5, -5, -5, -4, -5, -4, -5, -5, -5, -4, -5, -5, -5,
-5, -5, -6, -5, -4, -4, -5, -4, -5, -5, -4, -5, -5, -1, };