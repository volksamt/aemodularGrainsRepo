#define DATA_LENGTH 512
#define DATA AKWF_0745

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 7, 10, 13, 16, 18, 20, 24, 25,
27, 29, 30, 32, 33, 33, 34, 35, 34, 35, 34, 34, 34, 33, 31, 31, 28, 28, 26, 24,
22, 21, 18, 17, 14, 13, 12, 9, 8, 6, 5, 3, 3, 2, 1, 1, 2, 1, 1, 1, 2, 3, 5, 6,
8, 9, 11, 14, 15, 18, 21, 23, 26, 28, 32, 36, 40, 43, 47, 50, 54, 57, 61, 64,
68, 70, 74, 76, 79, 81, 83, 84, 86, 87, 87, 87, 86, 85, 83, 82, 79, 77, 74, 72,
69, 65, 61, 58, 54, 51, 48, 45, 42, 39, 38, 37, 36, 33, 34, 33, 34, 34, 35, 37,
39, 41, 44, 47, 50, 53, 57, 60, 64, 67, 70, 74, 78, 81, 85, 87, 91, 95, 97, 100,
104, 105, 108, 110, 112, 113, 115, 116, 118, 118, 118, 118, 119, 119, 119, 118,
117, 117, 115, 115, 113, 112, 111, 109, 107, 105, 102, 101, 99, 96, 95, 94, 92,
90, 88, 87, 86, 85, 84, 84, 83, 83, 83, 83, 83, 84, 84, 85, 86, 87, 88, 89, 90,
92, 94, 95, 97, 99, 100, 102, 104, 106, 108, 110, 111, 113, 114, 115, 116, 117,
118, 117, 118, 117, 116, 114, 112, 110, 108, 104, 101, 96, 92, 86, 81, 75, 69,
62, 56, 49, 42, 36, 29, 23, 16, 10, 4, -1, -6, -11, -16, -20, -22, -26, -28,
-30, -32, -32, -33, -34, -33, -33, -33, -32, -30, -29, -28, -26, -24, -23, -22,
-20, -19, -17, -15, -14, -14, -12, -11, -11, -11, -10, -10, -10, -10, -10, -10,
-12, -13, -15, -15, -17, -20, -22, -24, -26, -29, -32, -35, -38, -41, -44, -48,
-51, -55, -59, -62, -66, -69, -73, -75, -78, -81, -84, -87, -89, -91, -93, -95,
-95, -98, -98, -99, -99, -100, -100, -99, -100, -99, -97, -96, -96, -94, -91,
-89, -87, -86, -84, -81, -79, -76, -73, -71, -67, -65, -63, -60, -58, -56, -54,
-52, -51, -49, -48, -49, -49, -49, -49, -51, -53, -55, -57, -60, -63, -67, -70,
-74, -77, -82, -86, -89, -93, -97, -100, -103, -105, -108, -111, -113, -113,
-114, -116, -114, -115, -114, -113, -112, -110, -107, -104, -102, -100, -96,
-93, -90, -87, -84, -80, -77, -75, -71, -68, -66, -63, -61, -57, -55, -53, -51,
-50, -48, -47, -45, -44, -43, -43, -43, -43, -42, -43, -43, -44, -45, -46, -47,
-49, -51, -52, -53, -56, -57, -60, -62, -63, -65, -67, -69, -72, -73, -75, -76,
-77, -79, -79, -80, -80, -80, -81, -80, -80, -79, -79, -78, -75, -75, -74, -71,
-69, -66, -65, -62, -59, -56, -53, -49, -46, -43, -40, -36, -32, -29, -25, -21,
-18, -16, -12, -9, -6, -4, -2, 0, 1, 2, 3, 3, 2, 3, 1, 0, -3, -5, -8, -10, -14,
-17, -20, -24, -26, -30, -34, -37, -40, -42, -45, -47, -48, -50, -51, -51, -52,
-51, -49, -48, -47, -45, -43, -41, -37, -34, -31, -28, -23, -20, -17, -13, -10,
-6, -3, };