#define DATA_LENGTH 512
#define DATA AKWF_0771

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 8, 11, 15, 18, 21, 26, 28, 32,
35, 38, 43, 45, 47, 51, 53, 57, 60, 63, 65, 68, 70, 73, 76, 78, 81, 83, 85, 87,
89, 91, 92, 94, 96, 98, 99, 101, 103, 104, 106, 106, 107, 108, 109, 110, 111,
113, 113, 114, 115, 115, 116, 116, 116, 118, 118, 118, 118, 118, 119, 118, 118,
119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 118, 118, 118, 117, 117, 117,
117, 116, 117, 116, 116, 116, 116, 115, 114, 115, 114, 114, 114, 114, 113, 113,
113, 113, 112, 113, 112, 112, 112, 112, 111, 112, 112, 112, 110, 111, 111, 111,
110, 111, 111, 110, 110, 109, 109, 110, 110, 109, 109, 109, 109, 108, 109, 108,
108, 107, 107, 107, 106, 106, 105, 105, 103, 102, 102, 101, 100, 99, 98, 97, 95,
94, 92, 91, 89, 87, 87, 84, 83, 80, 78, 76, 74, 71, 70, 67, 64, 62, 59, 56, 53,
50, 47, 44, 41, 37, 33, 30, 26, 23, 19, 16, 12, 8, 5, 1, -3, -6, -10, -14, -17,
-21, -25, -29, -32, -36, -40, -43, -47, -50, -53, -57, -59, -62, -64, -68, -71,
-73, -76, -78, -79, -81, -83, -85, -87, -88, -90, -91, -92, -93, -94, -95, -96,
-96, -96, -97, -96, -96, -97, -96, -97, -96, -96, -94, -94, -94, -91, -91, -91,
-89, -88, -86, -86, -84, -83, -81, -79, -77, -75, -73, -71, -69, -67, -65, -64,
-61, -59, -56, -55, -52, -50, -48, -45, -43, -41, -39, -37, -34, -33, -30, -28,
-26, -24, -22, -21, -18, -17, -16, -13, -12, -11, -8, -8, -5, -5, -3, -3, -1,
-1, 0, 1, 3, 2, 3, 4, 4, 4, 5, 4, 5, 5, 6, 5, 5, 4, 5, 4, 4, 5, 4, 4, 3, 3, 3,
1, 2, 1, 0, 0, -1, -1, -2, -2, -4, -3, -5, -6, -6, -7, -7, -8, -8, -10, -10,
-11, -12, -12, -12, -13, -13, -14, -15, -15, -15, -17, -17, -17, -18, -19, -19,
-19, -20, -20, -21, -21, -22, -22, -23, -22, -23, -24, -23, -24, -25, -26, -26,
-25, -26, -27, -27, -27, -28, -28, -27, -28, -29, -28, -29, -30, -30, -29, -30,
-31, -30, -30, -31, -31, -31, -32, -33, -33, -33, -33, -34, -34, -35, -34, -35,
-35, -36, -36, -37, -37, -38, -38, -40, -40, -41, -41, -42, -43, -44, -45, -46,
-47, -48, -49, -50, -51, -52, -53, -55, -57, -59, -60, -60, -62, -64, -66, -67,
-69, -71, -73, -74, -75, -78, -80, -81, -82, -84, -86, -87, -88, -91, -92, -94,
-95, -97, -99, -99, -100, -102, -103, -105, -106, -108, -109, -109, -109, -111,
-111, -112, -112, -113, -113, -113, -113, -113, -114, -114, -113, -113, -113,
-113, -112, -111, -110, -108, -108, -108, -106, -105, -103, -103, -100, -99,
-97, -95, -94, -91, -89, -87, -86, -83, -81, -77, -75, -72, -70, -66, -64, -60,
-57, -55, -51, -48, -45, -41, -38, -35, -30, -28, -25, -21, -17, -13, -10, -6,
-2, };