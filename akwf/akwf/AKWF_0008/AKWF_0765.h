#define DATA_LENGTH 512
#define DATA AKWF_0765

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 3, 4, 6, 7, 7, 9, 11, 12, 13,
14, 15, 17, 18, 18, 20, 21, 22, 23, 24, 25, 26, 26, 27, 29, 30, 31, 31, 32, 32,
34, 34, 35, 35, 36, 37, 37, 38, 39, 39, 40, 40, 40, 42, 42, 42, 42, 44, 43, 44,
45, 44, 46, 45, 46, 47, 46, 47, 48, 48, 49, 49, 49, 49, 50, 50, 52, 52, 53, 54,
53, 54, 56, 55, 56, 57, 58, 58, 60, 61, 62, 62, 62, 64, 65, 66, 65, 66, 68, 68,
69, 70, 71, 71, 72, 73, 73, 74, 75, 75, 77, 76, 77, 77, 77, 79, 79, 81, 81, 81,
82, 81, 82, 82, 83, 83, 84, 84, 85, 85, 86, 86, 86, 87, 87, 88, 88, 88, 88, 89,
89, 90, 90, 89, 89, 90, 90, 90, 90, 91, 90, 91, 92, 91, 92, 91, 93, 93, 92, 92,
93, 93, 93, 92, 93, 93, 94, 94, 93, 94, 94, 95, 94, 95, 94, 95, 95, 95, 94, 95,
95, 94, 95, 95, 95, 94, 95, 95, 95, 95, 95, 94, 94, 93, 93, 94, 94, 93, 93, 92,
92, 91, 91, 90, 89, 89, 89, 88, 87, 86, 86, 85, 84, 84, 83, 82, 82, 81, 81, 80,
79, 79, 78, 77, 76, 75, 75, 74, 73, 72, 71, 69, 68, 66, 65, 63, 61, 58, 56, 54,
52, 50, 47, 44, 42, 38, 36, 34, 31, 27, 25, 21, 18, 15, 13, 9, 6, 3, -1, -3, -6,
-9, -12, -15, -19, -21, -24, -26, -29, -32, -34, -37, -39, -42, -43, -46, -49,
-50, -53, -55, -58, -59, -61, -63, -65, -67, -68, -70, -73, -74, -75, -77, -79,
-80, -81, -82, -83, -85, -87, -87, -89, -91, -92, -92, -93, -94, -95, -96, -97,
-97, -99, -99, -100, -102, -102, -102, -103, -104, -104, -105, -106, -106, -107,
-108, -108, -109, -109, -110, -111, -111, -111, -111, -113, -113, -114, -114,
-114, -114, -115, -114, -115, -115, -117, -116, -116, -117, -118, -118, -117,
-118, -117, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-118, -118, -118, -118, -117, -116, -116, -115, -116, -115, -113, -113, -112,
-112, -111, -110, -109, -109, -108, -107, -107, -106, -106, -105, -103, -103,
-102, -102, -101, -100, -99, -99, -98, -97, -97, -96, -96, -94, -95, -94, -94,
-94, -92, -92, -91, -90, -90, -90, -89, -89, -88, -88, -88, -87, -87, -87, -86,
-86, -85, -85, -85, -84, -84, -84, -84, -84, -84, -83, -83, -82, -81, -81, -82,
-80, -80, -80, -79, -79, -79, -78, -77, -76, -76, -75, -75, -75, -73, -72, -72,
-71, -71, -70, -69, -68, -68, -67, -66, -65, -64, -63, -62, -63, -61, -60, -60,
-60, -58, -58, -56, -57, -55, -54, -53, -53, -52, -51, -50, -47, -47, -46, -45,
-44, -42, -42, -40, -39, -38, -36, -35, -34, -33, -32, -31, -29, -28, -27, -25,
-25, -23, -22, -21, -21, -20, -18, -17, -15, -15, -13, -12, -11, -10, -10, -8,
-6, -6, -4, -3, -2, -1, };