#define DATA_LENGTH 512
#define DATA AKWF_0753

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 24, 47, 70, 84, 88, 88, 78, 62, 51,
45, 45, 48, 60, 76, 92, 104, 112, 114, 113, 109, 106, 102, 102, 102, 105, 109,
113, 115, 118, 119, 119, 118, 118, 118, 117, 116, 117, 118, 118, 119, 118, 118,
116, 115, 113, 111, 108, 105, 104, 101, 99, 97, 95, 92, 89, 86, 83, 79, 75, 71,
68, 64, 61, 56, 53, 49, 44, 41, 36, 32, 28, 23, 19, 15, 11, 7, 2, -1, -6, -10,
-14, -19, -23, -28, -32, -38, -42, -47, -49, -52, -55, -56, -59, -63, -66, -70,
-73, -78, -81, -84, -85, -88, -88, -90, -91, -93, -95, -96, -98, -99, -101,
-102, -103, -102, -103, -103, -104, -104, -104, -104, -103, -104, -103, -103,
-102, -101, -100, -100, -98, -98, -96, -95, -94, -92, -91, -89, -88, -86, -84,
-82, -80, -78, -77, -75, -72, -70, -68, -67, -64, -62, -60, -58, -55, -53, -51,
-49, -46, -45, -42, -40, -38, -35, -34, -32, -30, -27, -24, -19, -13, -2, 13,
33, 58, 77, 86, 88, 85, 71, 56, 47, 45, 45, 53, 67, 82, 98, 108, 113, 114, 112,
108, 105, 102, 101, 103, 106, 110, 113, 116, 118, 119, 119, 118, 118, 117, 117,
117, 118, 118, 119, 118, 119, 117, 115, 114, 112, 109, 107, 105, 102, 100, 99,
96, 93, 90, 87, 85, 81, 77, 73, 70, 66, 63, 58, 56, 51, 47, 44, 39, 35, 31, 26,
22, 18, 13, 9, 4, 1, -4, -8, -12, -16, -20, -25, -29, -34, -39, -44, -47, -50,
-54, -55, -57, -61, -64, -68, -72, -75, -80, -82, -84, -86, -87, -88, -90, -91,
-93, -95, -97, -99, -99, -102, -101, -103, -103, -103, -104, -104, -103, -104,
-104, -103, -103, -103, -102, -102, -102, -101, -99, -97, -97, -96, -94, -93,
-92, -91, -89, -87, -85, -84, -82, -81, -78, -75, -73, -72, -69, -67, -65, -63,
-60, -58, -57, -54, -53, -49, -48, -46, -43, -41, -39, -37, -35, -33, -30, -29,
-26, -23, -18, -8, 3, 20, 43, 67, 81, 87, 89, 80, 64, 51, 45, 45, 48, 58, 74,
89, 102, 111, 114, 113, 111, 106, 104, 102, 103, 105, 108, 112, 115, 117, 119,
120, 119, 118, 117, 117, 118, 117, 118, 119, 119, 118, 119, 117, 116, 114, 111,
108, 107, 104, 102, 99, 98, 95, 92, 89, 87, 84, 80, 76, 72, 69, 65, 62, 57, 54,
49, 46, 41, 37, 33, 29, 24, 21, 16, 12, 7, 2, -1, -5, -9, -14, -18, -22, -26,
-31, -37, -42, -45, -49, -52, -54, -56, -59, -62, -66, -70, -73, -77, -80, -84,
-85, -86, -88, -90, -91, -92, -94, -96, -98, -99, -101, -101, -103, -104, -104,
-103, -104, -103, -104, -104, -103, -103, -103, -103, -102, -102, -101, -100,
-99, -98, -97, -95, -94, -93, -91, -89, -88, -86, -85, -83, -81, -78, -77, -74,
-73, -70, -69, -67, -65, -63, -60, -58, -55, -53, -51, -49, -48, -45, -43, -41,
-38, -36, -34, -32, -30, -28, -25, -21, -13, -4, };