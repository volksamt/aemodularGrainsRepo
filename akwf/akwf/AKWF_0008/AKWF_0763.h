#define DATA_LENGTH 512
#define DATA AKWF_0763

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 8, 10, 14, 16, 20, 23, 28,
31, 36, 39, 43, 48, 52, 56, 61, 65, 70, 73, 78, 82, 86, 90, 94, 96, 100, 103,
106, 109, 111, 113, 114, 116, 117, 117, 119, 119, 118, 119, 118, 118, 117, 116,
115, 114, 112, 111, 109, 107, 105, 102, 101, 99, 96, 94, 91, 90, 88, 85, 83, 80,
77, 76, 74, 71, 69, 67, 65, 63, 61, 59, 57, 55, 53, 51, 49, 48, 45, 44, 43, 41,
39, 37, 36, 34, 32, 31, 30, 28, 27, 26, 25, 24, 22, 22, 21, 19, 18, 17, 16, 16,
14, 14, 12, 12, 11, 10, 9, 8, 7, 7, 6, 6, 5, 5, 3, 4, 3, 3, 3, 2, 1, 1, 0, -1,
-1, -1, -1, -2, -3, -3, -3, -4, -5, -4, -5, -5, -5, -6, -6, -7, -6, -7, -7, -7,
-7, -7, -7, -8, -8, -8, -8, -9, -9, -7, -9, -8, -9, -8, -9, -8, -9, -9, -8, -8,
-9, -8, -9, -8, -8, -8, -8, -8, -8, -7, -7, -7, -7, -7, -7, -6, -7, -8, -7, -6,
-7, -7, -6, -7, -7, -7, -7, -7, -7, -8, -7, -7, -8, -8, -8, -8, -9, -9, -8, -8,
-9, -8, -9, -9, -9, -9, -8, -10, -10, -9, -10, -9, -10, -10, -11, -10, -10, -11,
-11, -11, -10, -11, -12, -11, -12, -11, -12, -12, -12, -12, -12, -12, -13, -12,
-13, -12, -12, -13, -13, -13, -13, -13, -13, -13, -12, -13, -13, -12, -14, -14,
-14, -13, -14, -13, -13, -14, -13, -14, -13, -14, -14, -13, -14, -13, -14, -14,
-13, -14, -14, -14, -15, -13, -14, -14, -15, -14, -15, -15, -15, -15, -16, -16,
-17, -17, -18, -19, -18, -20, -20, -22, -21, -23, -23, -25, -25, -27, -28, -29,
-29, -31, -32, -32, -34, -35, -36, -38, -38, -39, -40, -42, -42, -43, -44, -44,
-45, -45, -45, -47, -47, -47, -48, -47, -48, -47, -47, -48, -47, -47, -47, -47,
-46, -46, -45, -45, -45, -45, -43, -43, -42, -42, -41, -40, -39, -39, -38, -38,
-38, -37, -37, -37, -35, -35, -35, -35, -33, -33, -32, -32, -31, -31, -30, -30,
-30, -29, -29, -28, -28, -28, -27, -26, -26, -26, -26, -25, -25, -24, -24, -24,
-24, -23, -24, -23, -23, -22, -22, -22, -22, -22, -21, -22, -21, -20, -20, -20,
-21, -20, -20, -19, -19, -20, -19, -19, -19, -18, -18, -19, -19, -19, -19, -17,
-18, -17, -18, -17, -18, -17, -17, -17, -16, -17, -17, -17, -17, -17, -17, -16,
-17, -16, -15, -16, -16, -15, -15, -15, -16, -15, -15, -15, -16, -15, -15, -15,
-16, -16, -15, -15, -16, -15, -16, -15, -15, -14, -14, -15, -15, -15, -15, -14,
-14, -15, -14, -14, -14, -15, -14, -14, -14, -14, -14, -14, -14, -14, -14, -14,
-14, -14, -14, -14, -14, -14, -14, -14, -14, -13, -14, -13, -13, -13, -14, -13,
-13, -13, -13, -12, -12, -11, -11, -10, -9, -8, -8, -5, -5, -3, -1, };