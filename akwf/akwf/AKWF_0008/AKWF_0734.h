#define DATA_LENGTH 512
#define DATA AKWF_0734

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 14, 21, 31, 35, 46, 50, 61, 67, 76,
82, 92, 97, 102, 106, 109, 119, 23, 5, 20, 15, 27, 25, 33, 33, 41, 42, 48, 49,
56, 58, 63, 67, 71, 74, 79, 83, 87, 91, 94, 99, 103, 107, 110, 114, 118, 116,
111, 108, 103, 100, 97, 93, 88, 85, 80, 77, 72, 68, 64, 61, 57, 53, 48, 45, 41,
36, 33, 29, 24, 20, 17, 13, 9, 4, 4, 4, 4, 4, 4, 4, 3, 5, 4, 4, 4, 4, 4, 4, 3,
4, 4, 5, 4, 4, 4, 3, 4, 5, 4, 4, 3, 4, 3, 4, 4, 4, 4, 3, 4, 4, 3, 4, 4, 4, 3, 4,
4, 4, 3, 3, 4, 4, 4, 4, 4, 4, 5, 3, 4, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 5, 4,
3, 4, 4, 4, 4, 4, 3, 1, -5, -7, -14, -4, -1, -8, -10, -15, -18, -23, -27, -31,
-34, -38, -43, -46, -51, -54, -59, -63, -68, -70, -75, -79, -84, -87, -91, -96,
-98, -104, -106, -114, -108, -110, -97, -109, -55, 10, -12, -7, -17, -16, -24,
-26, -30, -35, -38, -44, -46, -53, -54, -62, -61, -71, -69, -81, -75, -94, -67,
8, -6, -6, -11, -15, -18, -22, -25, -31, -33, -38, -40, -45, -47, -52, -54, -60,
-61, -67, -70, -74, -77, -81, -85, -88, -93, -95, -102, -101, -101, -92, -94,
-82, -92, -57, 16, 12, 17, 23, 22, 37, 8, -24, -6, -3, 6, 14, 21, 31, 35, 46,
51, 62, 66, 79, 81, 94, 96, 105, 105, 113, 112, 14, 8, 19, 17, 26, 25, 33, 34,
41, 42, 49, 50, 56, 58, 63, 67, 72, 75, 80, 84, 87, 91, 94, 100, 102, 107, 110,
115, 118, 116, 112, 108, 103, 100, 95, 92, 87, 84, 80, 76, 71, 68, 64, 60, 56,
52, 48, 45, 41, 36, 33, 28, 24, 20, 16, 12, 9, 4, 3, 4, 3, 5, 4, 3, 4, 4, 4, 4,
4, 5, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4,
4, 4, 4, 3, 4, 4, 3, 4, 5, 4, 4, 4, 4, 4, 3, 4, 5, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4,
4, 3, 3, 5, 4, 4, 3, 4, 3, 4, 4, 4, 0, -4, -8, -14, -3, -3, -8, -11, -16, -18,
-23, -27, -31, -35, -39, -43, -47, -52, -55, -60, -63, -68, -72, -76, -78, -83,
-88, -92, -95, -100, -104, -106, -113, -108, -109, -96, -109, -44, 10, -14, -6,
-19, -16, -25, -26, -32, -35, -40, -44, -48, -53, -55, -63, -62, -71, -70, -82,
-75, -96, -57, 9, -8, -6, -13, -15, -20, -23, -25, -31, -32, -38, -40, -46, -47,
-53, -54, -60, -62, -68, -70, -75, -77, -82, -85, -89, -94, -96, -101, -101,
-100, -91, -94, -82, -94, -47, 18, 10, 19, 23, 23, 36, 2, -23, -5, -4, };