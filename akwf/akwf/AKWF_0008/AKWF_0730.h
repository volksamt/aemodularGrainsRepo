#define DATA_LENGTH 512
#define DATA AKWF_0730

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 8, 8, 12, 12, 19, 11, -1, 4,
5, 8, 9, 12, 14, 16, 18, 21, 22, 25, 28, 29, 32, 33, 35, 37, 39, 41, 44, 45, 48,
50, 51, 53, 56, 59, 60, 62, 64, 67, 70, 71, 73, 75, 77, 79, 81, 84, 86, 88, 91,
93, 94, 97, 99, 101, 103, 105, 106, 108, 111, 113, 115, 117, 120, 117, 114, 111,
110, 108, 105, 104, 102, 99, 97, 96, 92, 91, 88, 87, 85, 82, 80, 78, 76, 74, 71,
69, 68, 65, 63, 61, 59, 57, 55, 52, 51, 48, 46, 44, 43, 39, 38, 36, 34, 32, 30,
27, 25, 23, 21, 19, 17, 15, 12, 10, 8, 6, 4, 1, -1, -2, -3, -3, -2, -3, -3, -3,
-3, -3, -2, -3, -3, -2, -3, -3, -3, -2, -2, -2, -2, -3, -3, -2, -3, -3, -2, -3,
-3, -2, -3, -3, -3, -3, -2, -2, -2, -3, -3, -2, -2, -3, -3, -2, -2, -2, -3, -2,
-2, -3, -2, -3, -3, -2, -3, -2, -2, -2, -3, -2, -2, -2, -2, -3, -2, -2, -3, -2,
-3, -3, -2, -2, -3, -2, -2, -3, -2, -2, -3, -2, -2, -3, -2, -3, -3, -2, -2, -2,
-2, -3, -2, -3, -2, -2, -2, -2, -2, -2, -3, -2, -3, -2, -2, -3, -2, -3, -3, -3,
-3, -3, -2, -3, -3, -3, -3, -3, -2, -3, -3, -2, -2, -3, -2, -3, -2, -2, -2, -3,
-2, -2, -2, -3, -3, -4, -7, -8, -11, -13, -16, -17, -21, -21, -28, -15, -2, -9,
-8, -11, -13, -15, -17, -19, -21, -22, -25, -26, -31, -29, -37, -25, 4, 1, 6, 0,
2, 3, 6, 7, 10, 11, 16, 7, -13, -6, -6, -2, -2, 3, 4, 8, 9, 12, 14, 16, 18, 21,
23, 27, 27, 31, 33, 36, 38, 40, 43, 43, 52, 7, -10, -6, -12, -11, -16, -17, -19,
-22, -16, -2, -8, -8, -11, -13, -15, -17, -17, -21, -21, -26, -24, -31, -27,
-36, -24, 18, 8, 3, -4, -10, -15, -22, -28, -35, -39, -47, -52, -60, -61, -64,
-66, -68, -69, -72, -73, -76, -78, -79, -81, -83, -85, -88, -89, -92, -93, -95,
-97, -100, -101, -103, -105, -106, -109, -111, -113, -114, -112, -110, -108,
-106, -104, -102, -100, -98, -96, -94, -92, -90, -89, -85, -84, -83, -80, -79,
-76, -73, -72, -71, -68, -66, -65, -62, -61, -59, -57, -54, -53, -51, -49, -47,
-46, -43, -41, -39, -37, -35, -33, -31, -29, -28, -25, -23, -21, -20, -18, -16,
-13, -12, -9, -7, -5, -3, -2, -2, -3, -2, -2, -2, -2, -2, -2, -1, -2, -2, -1,
-2, -2, -1, -2, -1, -1, -2, -2, -1, -2, -2, -2, -1, -1, -2, -1, -2, -1, -2, -2,
-2, -1, -2, -1, -2, -1, -2, -1, -2, -1, -1, -2, -1, -2, -1, -2, -2, -1, -2, -1,
-2, -2, -2, -1, -2, -2, -2, -1, -2, -1, -1, -2, -1, -1, -2, -2, -2, -1, };