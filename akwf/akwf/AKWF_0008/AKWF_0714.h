#define DATA_LENGTH 512
#define DATA AKWF_0714

const PROGMEM int8_t DATA[DATA_LENGTH] = {23, 56, 63, 62, 68, 77, 81, 85, 94,
99, 101, 109, 116, 119, 118, 118, 117, 116, 116, 117, 115, 115, 115, 114, 112,
113, 113, 112, 111, 111, 110, 110, 110, 110, 108, 108, 109, 106, 106, 107, 105,
105, 104, 104, 103, 103, 102, 102, 101, 101, 100, 99, 99, 99, 98, 98, 98, 97,
97, 96, 95, 95, 94, 95, 94, 92, 92, 92, 91, 91, 90, 91, 90, 89, 88, 87, 88, 86,
86, 85, 85, 85, 84, 84, 83, 83, 82, 82, 81, 81, 81, 80, 79, 78, 78, 77, 77, 77,
76, 75, 76, 74, 73, 74, 73, 72, 72, 73, 70, 70, 70, 70, 70, 68, 69, 68, 67, 66,
66, 66, 65, 65, 64, 64, 63, 62, 63, 61, 62, 61, 60, 60, 59, 59, 58, 58, 57, 56,
56, 55, 54, 55, 54, 53, 53, 54, 53, 50, 52, 52, 42, 23, 4, -4, -4, -4, -5, -7,
-7, -8, -9, -9, -10, -11, -12, -13, -13, -13, -14, -16, -16, -17, -18, -19, -20,
-20, -20, -22, -23, -23, -24, -25, -25, -26, -27, -27, -29, -30, -30, -31, -32,
-33, -33, -35, -34, -35, -36, -37, -38, -39, -39, -40, -42, -42, -42, -44, -44,
-45, -46, -46, -47, -49, -49, -50, -50, -51, -51, -52, -54, -54, -54, -56, -56,
-58, -58, -59, -59, -60, -62, -61, -62, -63, -64, -65, -65, -67, -67, -68, -68,
-70, -70, -69, -69, -69, -68, -69, -68, -68, -68, -68, -67, -67, -66, -66, -66,
-66, -66, -65, -66, -65, -65, -65, -64, -64, -63, -63, -63, -63, -63, -63, -63,
-62, -62, -61, -61, -61, -60, -60, -60, -60, -59, -58, -59, -59, -58, -58, -58,
-58, -57, -58, -57, -56, -56, -56, -57, -56, -56, -55, -54, -54, -54, -54, -54,
-53, -53, -53, -53, -53, -52, -52, -52, -51, -51, -52, -51, -51, -50, -49, -49,
-49, -49, -49, -48, -48, -48, -48, -48, -47, -47, -47, -47, -46, -46, -46, -45,
-45, -46, -44, -45, -45, -44, -43, -44, -44, -43, -43, -43, -42, -42, -41, -41,
-41, -41, -41, -41, -40, -40, -41, -39, -39, -38, -39, -38, -39, -37, -38, -38,
-37, -37, -36, -37, -36, -36, -35, -35, -36, -35, -35, -34, -34, -34, -34, -33,
-33, -33, -32, -33, -32, -32, -32, -31, -31, -31, -30, -30, -30, -30, -29, -29,
-29, -28, -29, -28, -28, -28, -27, -26, -27, -27, -26, -26, -26, -26, -26, -25,
-25, -25, -25, -24, -24, -23, -24, -23, -23, -23, -23, -21, -22, -22, -21, -21,
-20, -21, -20, -20, -20, -19, -19, -19, -20, -18, -19, -17, -18, -17, -17, -17,
-17, -16, -17, -16, -16, -16, -15, -15, -15, -14, -14, -14, -14, -13, -13, -13,
-14, -12, -12, -12, -12, -12, -11, -11, -10, -11, -11, -10, -9, -10, -9, -9, -9,
-9, -7, -8, -8, -8, -7, -7, -8, -6, -7, -7, -6, -6, -6, -5, -5, -5, -5, -3, -4,
-4, -3, -2, -4, -4, -1, -3, -4, 1, 0, -7, -2, };