#define DATA_LENGTH 512
#define DATA AKWF_0798

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 10, 15, 20, 25, 30, 35, 40, 45,
49, 54, 57, 62, 67, 71, 75, 78, 82, 86, 89, 92, 94, 97, 98, 101, 102, 103, 104,
105, 106, 106, 106, 106, 105, 105, 103, 102, 101, 99, 97, 96, 93, 90, 88, 85,
82, 79, 76, 73, 70, 67, 63, 60, 57, 53, 50, 47, 44, 41, 37, 34, 32, 29, 26, 23,
20, 18, 15, 13, 11, 8, 6, 4, 3, 0, -2, -4, -5, -7, -9, -10, -12, -13, -14, -16,
-17, -18, -19, -21, -22, -23, -24, -26, -26, -28, -29, -30, -32, -34, -34, -35,
-36, -38, -39, -40, -42, -43, -44, -45, -46, -49, -49, -51, -52, -52, -54, -55,
-55, -57, -58, -58, -60, -60, -61, -61, -62, -63, -63, -63, -63, -63, -63, -63,
-63, -62, -63, -62, -62, -61, -59, -59, -57, -57, -56, -55, -53, -52, -51, -50,
-47, -47, -45, -44, -42, -40, -39, -37, -36, -33, -32, -30, -28, -26, -24, -23,
-21, -20, -18, -17, -15, -14, -13, -11, -10, -8, -7, -6, -4, -3, -3, -1, 0, 0,
2, 3, 3, 5, 5, 6, 6, 8, 8, 9, 9, 9, 10, 10, 11, 11, 12, 13, 12, 13, 13, 14, 14,
14, 15, 15, 15, 17, 18, 17, 17, 18, 18, 19, 19, 20, 20, 21, 21, 20, 21, 22, 21,
21, 22, 23, 22, 22, 22, 22, 22, 20, 18, 14, 9, 5, -1, -5, -10, -17, -22, -27,
-32, -38, -44, -49, -53, -59, -64, -70, -74, -79, -82, -88, -91, -95, -99, -102,
-105, -108, -110, -112, -114, -116, -116, -118, -119, -120, -119, -119, -118,
-118, -117, -115, -114, -113, -110, -108, -106, -103, -101, -97, -95, -91, -88,
-85, -81, -78, -75, -71, -68, -64, -61, -57, -53, -51, -47, -43, -41, -37, -34,
-31, -27, -25, -23, -20, -17, -15, -13, -11, -8, -5, -4, -2, 1, 2, 4, 5, 8, 9,
11, 12, 14, 15, 16, 18, 19, 21, 23, 24, 26, 27, 29, 31, 32, 34, 35, 36, 38, 40,
41, 43, 45, 46, 48, 49, 52, 52, 54, 56, 58, 59, 61, 63, 63, 65, 66, 67, 69, 70,
71, 71, 72, 74, 73, 75, 74, 76, 75, 76, 75, 75, 76, 75, 75, 74, 74, 73, 72, 71,
70, 69, 68, 66, 66, 64, 62, 62, 60, 58, 57, 55, 53, 51, 49, 48, 46, 45, 43, 41,
40, 37, 35, 35, 33, 31, 30, 28, 26, 25, 24, 23, 21, 20, 18, 17, 16, 15, 14, 13,
12, 10, 10, 9, 9, 8, 7, 5, 5, 5, 3, 3, 3, 3, 2, 1, 0, 0, 0, -1, -2, -3, -2, -3,
-4, -4, -6, -5, -5, -7, -7, -7, -8, -9, -9, -9, -10, -11, -11, -12, -12, -13,
-13, -13, -14, -14, -15, -15, -15, -15, -17, -16, -17, -18, -16, -17, -18, -17,
-17, -17, -18, -18, -18, -18, -17, -18, -17, -17, -17, -16, -17, -17, -17, -17,
-16, -15, -15, -15, -15, -15, -15, -14, -15, -13, -13, -9, -7, -2, };