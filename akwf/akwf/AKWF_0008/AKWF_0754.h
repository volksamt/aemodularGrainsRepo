#define DATA_LENGTH 512
#define DATA AKWF_0754

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 1, 1, 0, 4, -1, 6, -8, 77,
125, 109, 117, 106, 110, 103, 104, 99, 99, 94, 92, 90, 89, 85, 84, 82, 80, 78,
75, 74, 71, 70, 67, 65, 63, 62, 60, 58, 56, 55, 53, 51, 49, 48, 46, 45, 42, 41,
39, 38, 36, 34, 33, 31, 30, 28, 27, 25, 24, 22, 20, 19, 18, 16, 16, 13, 13, 11,
10, 9, 7, 7, 6, 6, 4, 3, 4, 3, 2, 2, 2, 3, 3, 3, 3, 4, 5, 6, 6, 8, 7, 6, 4, 5,
3, 4, 5, 7, 10, 15, 22, 30, 43, -13, -42, -28, -22, -12, -11, -7, -7, -4, -4,
-3, -5, -6, -7, -6, -6, -6, -5, -4, -3, -4, -3, -2, -3, -2, -2, -3, -3, -4, -4,
-5, -5, -8, -9, -9, -11, -11, -12, -14, -15, -17, -18, -20, -20, -22, -24, -25,
-26, -28, -29, -32, -33, -35, -37, -39, -39, -42, -43, -44, -46, -49, -49, -52,
-54, -56, -57, -59, -61, -63, -65, -67, -69, -70, -72, -74, -77, -78, -81, -81,
-87, -86, -91, -91, -95, -96, -100, -101, -104, -107, -111, -114, -115, -117,
-16, 2, -5, 1, -3, 0, 0, 42, 38, 39, 37, 37, 35, 35, 33, 32, 32, 30, 29, 28, 28,
27, 27, 26, 26, 24, 25, 23, 24, 22, 23, 21, 22, 22, 22, 22, 22, 22, 22, 23, 23,
23, 24, 25, 25, 26, 27, 28, 29, 29, 31, 32, 33, 34, 35, 38, 39, 41, 42, 44, 46,
48, 50, 51, 54, 55, 58, 59, 61, 64, 65, 66, 68, 70, 71, 72, 72, 72, 73, 72, 72,
71, 71, 69, 68, 67, 65, 63, 62, 60, 58, 57, 56, 55, 54, 52, 52, 51, 50, 49, 49,
48, 48, 47, 47, 46, 46, 45, 45, 45, 45, 44, 44, 43, 43, 43, 43, 42, 42, 42, 41,
41, 39, 39, 37, 37, 36, 34, 32, 31, 28, 25, 22, 19, 16, 14, 11, 9, 8, 7, 6, 5,
4, 4, 4, 4, 3, 3, 2, 1, 2, 1, 2, 1, 1, 1, 1, 0, 1, 0, 1, 0, 0, 0, 1, 0, 0, 1,
-13, -2, 1, -1, 0, -2, 0, -1, 0, -2, 0, -2, -1, -2, -1, -2, -3, -3, -3, -4, -4,
-4, -5, -6, -8, -9, -10, -12, -15, -18, -21, -25, -29, -32, -33, -35, -37, -38,
-40, -39, -41, -41, -42, -43, -43, -43, -43, -45, -45, -45, -45, -46, -46, -47,
-47, -48, -48, -50, -50, -52, -53, -53, -55, -56, -59, -62, -64, -66, -68, -69,
-70, -72, -72, -72, -72, -70, -68, -66, -63, -59, -57, -53, -49, -45, -43, -41,
-37, -35, -32, -30, -28, -27, -25, -23, -23, -23, -22, -22, -22, -24, -23, -24,
-26, -28, -30, -32, -34, -38, -40, -43, -46, -48, -51, -55, -57, -60, -64, -66,
-70, -73, -77, -80, -83, -86, -90, -94, -97, -100, -104, -106, -110, -113, -116,
-116, -118, -118, -119, -115, -114, -105, -99, -83, -67, -37, -26, -57, -12, };