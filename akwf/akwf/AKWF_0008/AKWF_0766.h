#define DATA_LENGTH 512
#define DATA AKWF_0766

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 13, 18, 22, 27, 32, 36, 40, 46,
49, 54, 58, 63, 68, 71, 77, 80, 85, 88, 92, 95, 97, 99, 102, 102, 103, 104, 104,
105, 105, 106, 106, 107, 108, 108, 108, 109, 108, 109, 109, 108, 109, 109, 109,
109, 109, 108, 107, 108, 108, 107, 107, 105, 104, 102, 100, 98, 94, 91, 87, 84,
80, 76, 73, 69, 66, 62, 61, 57, 52, 50, 46, 43, 39, 36, 32, 28, 25, 21, 18, 15,
12, 9, 7, 5, 2, 0, -1, -3, -5, -7, -7, -7, -9, -9, -8, -8, -8, -8, -8, -7, -7,
-7, -7, -6, -5, -5, -4, -4, -2, -1, 0, 2, 3, 5, 6, 6, 6, 8, 6, 6, 5, 4, 4, 3, 2,
1, 0, -1, -2, -3, -5, -6, -7, -10, -11, -14, -15, -18, -20, -21, -22, -23, -24,
-23, -24, -23, -22, -22, -22, -22, -24, -24, -25, -26, -29, -30, -32, -33, -36,
-38, -40, -43, -44, -47, -48, -49, -50, -52, -55, -56, -59, -60, -63, -65, -65,
-67, -69, -69, -69, -70, -70, -70, -70, -71, -71, -71, -73, -72, -73, -74, -75,
-76, -77, -76, -77, -77, -78, -76, -76, -76, -75, -74, -73, -72, -70, -69, -68,
-66, -66, -65, -63, -62, -60, -58, -56, -54, -51, -48, -45, -42, -38, -36, -32,
-29, -26, -24, -22, -19, -17, -14, -13, -10, -8, -6, -4, -1, 2, 5, 6, 8, 11, 12,
15, 16, 19, 21, 23, 25, 26, 29, 31, 33, 36, 39, 42, 43, 45, 48, 50, 52, 54, 56,
58, 59, 60, 61, 61, 62, 63, 62, 62, 62, 61, 60, 60, 59, 58, 57, 56, 55, 53, 53,
52, 51, 49, 48, 46, 44, 44, 43, 42, 40, 39, 38, 38, 36, 34, 34, 33, 33, 33, 33,
33, 33, 35, 36, 36, 37, 37, 39, 41, 43, 45, 47, 49, 52, 53, 56, 58, 61, 61, 64,
66, 68, 70, 71, 74, 75, 78, 79, 81, 83, 84, 85, 85, 86, 86, 86, 85, 84, 82, 82,
80, 77, 76, 72, 71, 69, 67, 66, 65, 65, 64, 63, 62, 61, 60, 59, 57, 56, 55, 54,
54, 54, 53, 53, 54, 54, 55, 55, 55, 55, 55, 55, 55, 54, 54, 54, 53, 53, 52, 52,
50, 50, 48, 48, 47, 44, 43, 40, 38, 35, 31, 27, 22, 18, 13, 7, 2, -4, -9, -14,
-20, -24, -30, -35, -40, -45, -50, -55, -62, -66, -72, -75, -81, -85, -87, -92,
-93, -97, -99, -100, -100, -100, -101, -100, -101, -102, -101, -102, -103, -103,
-104, -104, -105, -106, -107, -108, -108, -109, -109, -108, -109, -110, -109,
-109, -109, -109, -109, -108, -109, -109, -109, -110, -111, -112, -114, -115,
-117, -117, -118, -118, -119, -119, -118, -118, -118, -117, -117, -117, -117,
-117, -116, -115, -116, -114, -113, -112, -111, -111, -110, -109, -108, -106,
-104, -100, -98, -94, -90, -86, -82, -77, -74, -69, -66, -62, -58, -54, -50,
-45, -43, -37, -33, -28, -23, -19, -13, -9, -4, 0, };