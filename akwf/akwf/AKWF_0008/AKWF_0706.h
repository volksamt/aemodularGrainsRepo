#define DATA_LENGTH 512
#define DATA AKWF_0706

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 11, 14, 16, 19, 22, 25, 27,
29, 34, 36, 39, 42, 45, 47, 50, 52, 56, 58, 60, 63, 67, 70, 72, 76, 77, 81, 82,
87, 87, 93, 93, 99, 99, 105, 103, 111, 108, 120, 105, 27, 35, 36, 39, 42, 45,
47, 50, 53, 56, 59, 61, 64, 66, 70, 71, 76, 77, 82, 81, 93, 16, -4, 9, 5, 13,
12, 18, 17, 24, 24, 29, 29, 34, 35, 41, 39, 46, 45, 54, 47, 66, 16, -40, -20,
-27, -16, -19, -13, -13, -7, -8, -3, -2, 3, 6, 8, 11, 14, 16, 18, 23, 24, 29,
29, 35, 35, 40, 40, 47, 45, 52, 51, 57, 56, 64, 61, 68, 68, 73, 74, 78, 82, 80,
96, -60, -100, -76, -87, -73, -80, -69, -73, -64, -67, -60, -61, -54, -55, -49,
-48, -44, -43, -39, -36, -35, -30, -29, -25, -24, -19, -17, -14, -12, -8, -6,
-2, 0, 3, 4, 8, 11, 14, 17, 19, 22, 25, 28, 30, 34, 36, 39, 41, 45, 46, 51, 52,
56, 58, 63, 63, 68, 69, 73, 75, 79, 81, 82, 89, 12, -2, 9, 5, 13, 12, 18, 18,
23, 24, 29, 29, 34, 34, 40, 40, 46, 45, 54, 47, 66, 11, -39, -20, -26, -17, -20,
-12, -13, -8, -8, -2, -1, 3, 5, 8, 11, 14, 17, 19, 23, 25, 29, 30, 35, 34, 40,
40, 47, 45, 52, 50, 57, 57, 64, 62, 69, 68, 75, 74, 79, 80, 82, 92, -68, -95,
-78, -86, -74, -80, -69, -74, -64, -67, -60, -60, -54, -54, -49, -49, -44, -43,
-38, -36, -33, -31, -28, -26, -22, -18, -18, -13, -12, -8, -7, -1, -2, 4, 4, 10,
9, 17, 14, 24, 17, 32, 7, -65, -52, -55, -49, -49, -43, -42, -38, -37, -33, -32,
-27, -26, -22, -20, -17, -15, -10, -8, -6, -1, -81, -90, -81, -83, -76, -77,
-71, -71, -65, -65, -61, -60, -54, -54, -50, -47, -44, -42, -39, -36, -34, -30,
-27, -25, -22, -19, -17, -13, -11, -8, -7, -2, -1, 4, 5, 9, 11, 14, 16, 20, 22,
26, 28, 30, 34, 35, 41, 41, 47, 46, 51, 51, 57, 56, 63, 61, 70, 67, 75, 72, 81,
79, 86, 86, -75, -93, -79, -86, -74, -79, -69, -73, -64, -67, -59, -62, -54,
-55, -48, -49, -42, -43, -38, -36, -33, -30, -28, -25, -22, -19, -17, -14, -11,
-8, -6, -2, -1, 4, 4, 11, 9, 17, 14, 24, 18, 35, 2, -67, -51, -56, -49, -49,
-44, -42, -39, -37, -32, -32, -26, -26, -21, -19, -16, -15, -10, -8, -5, -4,
-85, -88, -82, -82, -77, -76, -72, -71, -66, -65, -61, -59, -55, -54, -49, -49,
-43, -43, -36, -41, -23, -89, -127, -108, -115, -105, -108, -102, -102, -96,
-96, -91, -89, -86, -83, -80, -78, -76, -72, -70, -67, -64, -61, -59, -55, -54,
-51, -48, -44, -42, -38, -36, -33, -31, -28, -25, -22, -20, -16, -14, -11, -8,
-6, -3, 0, };