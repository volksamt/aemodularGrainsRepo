#define DATA_LENGTH 512
#define DATA AKWF_0789

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 1, 3, 3, 4, 4, 5, 6, 6, 6, 7,
6, 7, 8, 8, 9, 9, 10, 9, 10, 11, 11, 12, 12, 12, 12, 12, 13, 13, 14, 13, 14, 13,
14, 14, 15, 15, 16, 14, 16, 15, 16, 15, 16, 16, 16, 16, 16, 16, 17, 16, 16, 17,
16, 17, 17, 17, 18, 21, 24, 27, 29, 31, 33, 36, 38, 40, 42, 44, 45, 47, 49, 49,
50, 52, 52, 53, 53, 55, 55, 55, 56, 55, 56, 55, 56, 56, 54, 55, 54, 55, 54, 55,
55, 55, 55, 55, 55, 56, 56, 55, 57, 56, 58, 58, 57, 58, 59, 60, 61, 61, 62, 62,
63, 63, 65, 64, 66, 66, 67, 68, 68, 68, 69, 70, 70, 71, 72, 72, 73, 74, 74, 75,
75, 77, 77, 78, 79, 81, 81, 82, 82, 84, 84, 85, 86, 87, 88, 89, 90, 90, 91, 93,
93, 95, 95, 96, 97, 97, 99, 99, 100, 101, 101, 102, 102, 102, 103, 103, 104,
104, 105, 106, 105, 106, 106, 107, 107, 108, 108, 109, 110, 109, 111, 111, 111,
112, 112, 113, 113, 114, 114, 115, 116, 116, 116, 116, 117, 117, 118, 119, 119,
118, 118, 119, 119, 119, 119, 119, 120, 119, 118, 118, 118, 117, 117, 117, 117,
116, 116, 114, 114, 113, 112, 111, 110, 109, 108, 106, 106, 103, 102, 102, 100,
98, 96, 95, 93, 91, 88, 87, 83, 81, 80, 77, 75, 72, 70, 67, 63, 61, 58, 55, 51,
49, 46, 43, 39, 35, 32, 29, 26, 23, 19, 15, 12, 9, 6, 3, 0, -3, -6, -10, -12,
-15, -17, -21, -24, -26, -29, -31, -34, -35, -38, -40, -42, -45, -47, -48, -50,
-53, -54, -56, -58, -60, -62, -63, -64, -66, -68, -69, -71, -72, -74, -75, -76,
-78, -79, -80, -81, -83, -84, -86, -87, -87, -89, -90, -92, -93, -93, -94, -96,
-95, -96, -97, -99, -98, -100, -100, -101, -101, -102, -103, -104, -103, -105,
-105, -105, -106, -106, -107, -107, -107, -107, -108, -108, -109, -109, -110,
-109, -110, -110, -110, -110, -110, -110, -110, -111, -111, -112, -111, -112,
-112, -112, -113, -112, -113, -112, -113, -112, -113, -114, -113, -113, -114,
-114, -114, -113, -114, -113, -115, -114, -114, -114, -113, -114, -113, -113,
-113, -112, -112, -112, -112, -111, -112, -111, -110, -110, -110, -109, -108,
-107, -107, -106, -106, -105, -105, -103, -102, -101, -101, -101, -100, -99,
-97, -96, -96, -95, -94, -94, -91, -91, -91, -89, -88, -87, -85, -84, -84, -82,
-81, -79, -79, -77, -77, -75, -74, -73, -71, -70, -68, -68, -67, -65, -65, -63,
-62, -61, -59, -58, -56, -56, -55, -53, -51, -51, -50, -49, -47, -46, -45, -44,
-43, -41, -41, -39, -38, -37, -36, -35, -33, -33, -31, -30, -29, -29, -27, -25,
-25, -24, -23, -22, -22, -20, -20, -18, -18, -16, -16, -15, -14, -14, -12, -11,
-11, -10, -9, -9, -7, -7, -7, -6, -4, -4, -4, -2, -2, -1, -1, 0, };