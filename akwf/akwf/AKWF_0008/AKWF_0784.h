#define DATA_LENGTH 512
#define DATA AKWF_0784

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 8, 11, 13, 15, 18, 21, 23,
25, 27, 30, 32, 34, 36, 38, 39, 42, 44, 46, 48, 49, 52, 54, 56, 57, 58, 61, 62,
63, 65, 66, 67, 69, 71, 72, 74, 75, 77, 77, 78, 80, 80, 82, 83, 84, 86, 86, 87,
88, 89, 91, 91, 92, 92, 95, 94, 96, 97, 98, 98, 99, 100, 100, 100, 101, 102,
104, 104, 104, 105, 105, 106, 107, 107, 107, 109, 109, 109, 109, 110, 111, 112,
111, 112, 113, 112, 112, 114, 113, 114, 113, 114, 115, 114, 115, 115, 116, 116,
116, 117, 116, 117, 116, 117, 118, 117, 117, 117, 117, 119, 118, 118, 118, 118,
119, 119, 119, 119, 118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 119, 118, 118, 118, 118, 118, 118, 118, 118, 118, 117, 117, 117,
116, 116, 116, 117, 116, 115, 115, 115, 115, 114, 114, 113, 112, 111, 112, 111,
110, 109, 109, 108, 108, 106, 106, 105, 104, 104, 102, 101, 100, 99, 98, 95, 94,
92, 91, 88, 86, 83, 80, 77, 75, 72, 68, 65, 61, 56, 52, 48, 44, 40, 37, 32, 27,
23, 20, 15, 12, 8, 5, 1, -3, -7, -10, -13, -14, -11, -7, -4, 0, 3, 7, 9, 13, 17,
19, 22, 24, 26, 29, 30, 31, 34, 35, 36, 38, 37, 38, 39, 38, 38, 37, 35, 34, 33,
31, 30, 28, 25, 23, 21, 19, 16, 14, 11, 9, 6, 4, 2, -1, -3, -6, -9, -11, -13,
-16, -18, -21, -23, -26, -27, -30, -32, -34, -36, -38, -40, -41, -44, -46, -47,
-50, -52, -53, -55, -57, -59, -61, -62, -64, -65, -66, -68, -69, -72, -73, -73,
-75, -76, -78, -78, -81, -81, -82, -83, -84, -85, -87, -87, -89, -90, -90, -91,
-92, -94, -95, -95, -96, -96, -98, -98, -99, -100, -100, -101, -102, -103, -103,
-104, -105, -105, -106, -106, -107, -107, -108, -108, -108, -110, -109, -110,
-111, -111, -111, -111, -112, -113, -113, -113, -113, -113, -114, -115, -114,
-115, -115, -115, -115, -116, -116, -116, -117, -117, -117, -117, -118, -117,
-118, -117, -119, -118, -119, -118, -118, -118, -119, -118, -119, -118, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -118, -119, -119, -119,
-118, -119, -119, -119, -119, -118, -118, -118, -117, -118, -117, -117, -117,
-118, -117, -116, -116, -116, -116, -115, -115, -115, -114, -114, -113, -113,
-113, -112, -111, -111, -111, -109, -110, -108, -107, -107, -106, -105, -105,
-104, -102, -102, -99, -98, -96, -96, -93, -92, -90, -88, -85, -84, -80, -77,
-73, -71, -67, -63, -60, -56, -52, -48, -44, -40, -36, -31, -28, -24, -19, -16,
-11, -7, -4, 0, 4, 7, 10, 13, 13, 11, 7, 3, 0, -4, -7, -11, -14, -16, -20, -23,
-25, -26, -29, -30, -32, -34, -36, -37, -37, -37, -38, -38, -38, -38, -36, -36,
-34, -33, -31, -29, -28, -26, -23, -21, -18, -16, -13, -11, -9, -6, -4, -1, };