#define DATA_LENGTH 512
#define DATA AKWF_0744

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 6, 9, 13, 16, 20, 23, 26, 30,
33, 36, 40, 42, 45, 49, 52, 53, 57, 58, 60, 63, 64, 65, 66, 68, 68, 68, 69, 68,
69, 71, 70, 70, 70, 70, 70, 70, 71, 71, 71, 72, 72, 73, 73, 73, 74, 75, 76, 76,
77, 78, 79, 80, 79, 81, 81, 83, 83, 85, 85, 85, 88, 89, 90, 90, 91, 92, 93, 96,
97, 98, 99, 99, 101, 103, 104, 105, 105, 107, 106, 108, 108, 108, 108, 109, 109,
109, 108, 107, 108, 106, 105, 104, 104, 103, 101, 100, 99, 98, 96, 96, 93, 92,
91, 89, 88, 86, 85, 82, 81, 79, 77, 76, 74, 73, 70, 68, 67, 64, 63, 61, 59, 57,
56, 56, 54, 52, 51, 51, 50, 50, 49, 48, 47, 49, 48, 48, 48, 48, 48, 47, 47, 46,
46, 46, 46, 45, 45, 42, 41, 41, 39, 38, 36, 35, 32, 31, 29, 27, 25, 24, 23, 22,
20, 19, 18, 16, 15, 15, 14, 14, 13, 13, 13, 13, 13, 12, 12, 13, 14, 14, 14, 15,
15, 15, 17, 17, 19, 20, 20, 22, 23, 25, 26, 27, 29, 30, 31, 34, 35, 36, 37, 41,
42, 43, 45, 46, 48, 49, 50, 50, 51, 52, 54, 55, 55, 55, 56, 56, 56, 56, 57, 56,
56, 56, 56, 56, 56, 56, 56, 56, 56, 56, 55, 57, 56, 56, 55, 56, 55, 55, 55, 55,
54, 54, 54, 53, 53, 52, 53, 52, 52, 53, 52, 53, 53, 53, 54, 54, 55, 57, 55, 57,
58, 59, 59, 60, 61, 60, 61, 61, 60, 60, 59, 59, 57, 56, 54, 53, 51, 49, 47, 44,
41, 38, 35, 33, 30, 27, 23, 21, 17, 14, 12, 9, 6, 3, 1, -2, -4, -7, -9, -11,
-14, -16, -18, -20, -22, -24, -27, -28, -30, -32, -34, -37, -37, -39, -41, -42,
-44, -46, -46, -48, -49, -49, -51, -51, -53, -53, -55, -54, -56, -57, -57, -58,
-60, -60, -62, -63, -65, -65, -67, -69, -70, -72, -74, -75, -76, -78, -81, -84,
-84, -86, -88, -89, -92, -93, -94, -96, -98, -99, -100, -103, -104, -105, -107,
-108, -109, -110, -111, -112, -112, -114, -114, -116, -117, -117, -118, -119,
-118, -119, -119, -119, -118, -118, -117, -117, -116, -115, -114, -113, -111,
-111, -109, -109, -107, -106, -104, -103, -102, -102, -101, -101, -101, -100,
-101, -102, -102, -103, -103, -104, -105, -106, -107, -108, -110, -110, -111,
-113, -113, -114, -116, -115, -117, -117, -118, -118, -117, -118, -118, -118,
-118, -119, -118, -118, -117, -117, -116, -116, -115, -115, -114, -113, -112,
-111, -111, -110, -108, -107, -105, -104, -102, -101, -100, -98, -95, -94, -92,
-89, -88, -85, -83, -81, -80, -78, -76, -74, -73, -71, -69, -68, -66, -65, -63,
-63, -62, -60, -58, -57, -56, -55, -53, -53, -50, -50, -47, -46, -45, -44, -41,
-40, -38, -37, -35, -34, -31, -30, -28, -26, -25, -22, -21, -20, -17, -15, -13,
-11, -9, -7, -4, -1, };