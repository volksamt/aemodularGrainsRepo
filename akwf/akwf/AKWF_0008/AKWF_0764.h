#define DATA_LENGTH 512
#define DATA AKWF_0764

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 14, 20, 25, 30, 35, 40, 44, 49,
52, 56, 59, 62, 65, 68, 69, 71, 73, 73, 75, 75, 76, 75, 75, 74, 74, 72, 71, 70,
68, 66, 65, 63, 62, 59, 57, 55, 53, 51, 49, 47, 45, 43, 41, 40, 38, 37, 36, 35,
34, 35, 35, 36, 36, 37, 38, 38, 40, 41, 42, 42, 42, 43, 43, 41, 41, 39, 38, 36,
34, 32, 29, 26, 24, 21, 19, 16, 14, 11, 8, 7, 5, 3, 3, 1, 0, 0, 0, 0, -1, 0, 1,
1, 2, 3, 5, 6, 8, 10, 12, 14, 16, 17, 20, 21, 24, 26, 29, 30, 31, 34, 36, 38,
39, 41, 43, 43, 45, 46, 47, 48, 49, 48, 50, 49, 50, 49, 49, 48, 48, 47, 46, 46,
44, 43, 42, 40, 39, 37, 36, 34, 31, 31, 28, 27, 25, 23, 21, 19, 17, 15, 12, 11,
8, 7, 5, 3, 2, 0, -2, -3, -5, -6, -8, -9, -10, -11, -13, -13, -14, -15, -15,
-16, -18, -18, -19, -19, -20, -22, -22, -23, -24, -26, -26, -28, -30, -31, -32,
-35, -36, -39, -42, -44, -46, -48, -51, -54, -57, -60, -63, -67, -69, -73, -76,
-79, -82, -86, -89, -92, -95, -97, -100, -103, -105, -107, -109, -112, -113,
-115, -117, -118, -118, -119, -119, -119, -119, -118, -117, -116, -115, -112,
-111, -108, -106, -103, -100, -96, -93, -88, -85, -80, -75, -69, -65, -60, -54,
-48, -43, -37, -32, -26, -20, -15, -8, -3, 3, 9, 14, 21, 26, 31, 35, 40, 44, 48,
53, 57, 60, 63, 66, 68, 70, 73, 74, 75, 76, 76, 76, 76, 75, 75, 74, 73, 72, 71,
69, 67, 66, 64, 62, 61, 58, 55, 55, 52, 49, 48, 46, 44, 42, 40, 39, 38, 36, 36,
35, 35, 36, 36, 37, 37, 38, 39, 39, 40, 41, 42, 41, 42, 41, 40, 39, 38, 37, 34,
32, 30, 27, 25, 23, 19, 17, 15, 12, 10, 8, 5, 4, 3, 1, 0, 0, -1, -1, -1, 0, 1,
0, 2, 3, 3, 6, 7, 9, 11, 12, 14, 17, 19, 21, 23, 25, 28, 30, 32, 34, 35, 38, 39,
41, 43, 45, 46, 46, 47, 49, 49, 50, 51, 50, 51, 50, 51, 50, 49, 50, 49, 48, 47,
45, 45, 42, 41, 40, 38, 37, 35, 33, 30, 29, 27, 25, 23, 21, 18, 16, 15, 13, 11,
9, 7, 5, 3, 1, 0, -2, -3, -5, -6, -8, -9, -10, -11, -13, -13, -15, -16, -16,
-17, -17, -18, -20, -20, -21, -22, -22, -23, -24, -25, -26, -27, -29, -30, -32,
-35, -36, -39, -40, -43, -44, -47, -49, -53, -55, -58, -60, -64, -67, -68, -73,
-75, -78, -82, -85, -88, -90, -93, -95, -98, -100, -103, -105, -107, -108, -110,
-110, -112, -113, -113, -114, -113, -113, -112, -112, -111, -110, -107, -106,
-103, -101, -97, -95, -92, -87, -84, -80, -75, -71, -66, -61, -56, -51, -46,
-41, -34, -29, -23, -18, -12, -6, -1, };