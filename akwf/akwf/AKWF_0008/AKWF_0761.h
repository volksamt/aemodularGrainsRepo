#define DATA_LENGTH 512
#define DATA AKWF_0761

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 11, 18, 24, 30, 38, 43, 49, 55, 59,
65, 70, 74, 77, 80, 84, 87, 89, 91, 92, 94, 95, 95, 97, 95, 96, 95, 95, 95, 94,
93, 92, 90, 88, 88, 86, 85, 83, 81, 79, 77, 75, 74, 71, 70, 69, 67, 64, 63, 61,
59, 57, 55, 54, 52, 51, 49, 47, 46, 45, 43, 42, 40, 39, 36, 36, 35, 33, 32, 31,
29, 29, 27, 27, 26, 25, 23, 22, 21, 22, 20, 19, 19, 18, 17, 16, 14, 15, 14, 12,
12, 12, 12, 10, 10, 10, 8, 8, 7, 7, 7, 7, 6, 6, 5, 4, 4, 4, 3, 3, 3, 3, 2, 2, 2,
2, 0, 1, 0, 0, 0, -1, -1, -1, -1, -1, -2, -2, -2, -2, -2, -3, -3, -3, -3, -4,
-4, -4, -3, -4, -4, -4, -4, -5, -4, -4, -5, -5, -5, -5, -5, -4, -6, -6, -6, -5,
-6, -6, -6, -6, -6, -6, -6, -7, -7, -7, -7, -7, -7, -7, -6, -6, -7, -7, -7, -6,
-7, -7, -8, -7, -8, -7, -7, -8, -8, -8, -7, -7, -8, -7, -7, -8, -7, -7, -7, -8,
-8, -8, -7, -7, -8, -8, -8, -8, -8, -7, -7, -7, -8, -7, -7, -8, -8, -8, -9, -8,
-8, -7, -7, -8, -7, -8, -8, -8, -9, -8, -8, -9, -8, -7, -8, -8, -8, -8, -8, -7,
-8, -8, -8, -8, -8, -8, -8, -8, -7, -9, -8, -8, -8, -8, -8, -8, -8, -8, -7, -8,
-8, -8, -9, -9, -9, -8, -8, -8, -9, -8, -8, -7, -8, -8, -8, -8, -8, -8, -9, -9,
-8, -8, -8, -8, -8, -7, -8, -8, -9, -9, -8, -8, -8, -8, -8, -8, -9, -9, -8, -9,
-8, -8, -8, -9, -9, -9, -8, -8, -8, -8, -9, -8, -9, -8, -8, -8, -8, -8, -8, -8,
-8, -8, -8, -8, -7, -8, -8, -7, -9, -8, -9, -8, -9, -8, -8, -9, -8, -9, -8, -9,
-8, -9, -9, -8, -8, -8, -8, -8, -8, -9, -8, -8, -8, -8, -8, -8, -8, -8, -8, -8,
-8, -8, -8, -8, -8, -8, -8, -8, -8, -8, -8, -8, -8, -8, -8, -8, -8, -8, -8, -8,
-9, -8, -8, -7, -9, -9, -8, -8, -9, -8, -9, -7, -9, -9, -9, -8, -7, -7, -6, -7,
-5, -5, -4, -3, -2, 0, 1, 3, 4, 7, 9, 10, 13, 16, 17, 20, 22, 25, 27, 29, 32,
33, 36, 39, 40, 42, 44, 46, 47, 48, 48, 49, 50, 50, 50, 50, 50, 49, 49, 48, 47,
45, 44, 41, 40, 38, 35, 32, 29, 25, 21, 17, 12, 8, 3, -2, -7, -13, -18, -24,
-30, -37, -43, -48, -55, -60, -66, -72, -77, -81, -87, -91, -95, -100, -103,
-106, -109, -111, -114, -115, -117, -118, -118, -119, -119, -119, -118, -118,
-116, -115, -113, -112, -109, -107, -105, -103, -99, -96, -92, -88, -85, -81,
-76, -72, -67, -62, -58, -51, -45, -39, -34, -27, -20, -14, -7, -2, };