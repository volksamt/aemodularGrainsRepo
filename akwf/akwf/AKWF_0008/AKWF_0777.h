#define DATA_LENGTH 512
#define DATA AKWF_0777

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 5, 6, 8, 9, 11, 11, 14, 15,
16, 17, 19, 21, 22, 23, 24, 26, 26, 29, 29, 31, 32, 32, 34, 36, 37, 38, 39, 39,
41, 42, 44, 45, 44, 46, 48, 48, 49, 51, 52, 52, 53, 55, 55, 57, 58, 59, 60, 61,
62, 64, 65, 66, 67, 68, 69, 70, 72, 73, 74, 75, 77, 78, 78, 80, 82, 83, 84, 85,
87, 89, 90, 91, 94, 94, 96, 98, 99, 100, 102, 103, 105, 106, 108, 109, 111, 112,
113, 114, 114, 115, 116, 116, 117, 118, 117, 118, 119, 118, 120, 119, 118, 119,
118, 118, 118, 118, 117, 116, 116, 115, 115, 114, 114, 113, 112, 112, 111, 110,
110, 110, 108, 108, 107, 107, 106, 106, 104, 105, 104, 103, 104, 102, 101, 102,
101, 100, 100, 100, 99, 99, 100, 99, 98, 98, 98, 97, 98, 96, 97, 96, 97, 96, 97,
96, 96, 97, 96, 96, 97, 97, 96, 96, 95, 96, 95, 96, 97, 95, 97, 95, 95, 95, 95,
95, 95, 94, 93, 93, 92, 91, 91, 90, 90, 88, 89, 88, 87, 85, 86, 84, 83, 82, 80,
79, 79, 77, 76, 75, 74, 72, 70, 69, 68, 67, 66, 64, 63, 61, 60, 58, 58, 56, 55,
54, 52, 51, 50, 48, 47, 46, 44, 43, 42, 40, 40, 39, 37, 36, 33, 33, 31, 30, 29,
28, 26, 26, 23, 22, 21, 20, 17, 17, 15, 13, 12, 11, 10, 8, 7, 5, 3, 1, 1, 0, -2,
-4, -5, -7, -9, -10, -11, -12, -14, -15, -16, -18, -19, -21, -22, -23, -25, -26,
-26, -28, -29, -31, -31, -33, -34, -36, -37, -37, -39, -40, -41, -42, -44, -44,
-45, -46, -47, -48, -49, -51, -52, -53, -53, -55, -57, -57, -58, -60, -60, -62,
-62, -64, -64, -66, -67, -68, -70, -71, -72, -73, -74, -74, -77, -78, -79, -80,
-82, -83, -85, -86, -87, -88, -90, -91, -93, -95, -95, -97, -99, -100, -102,
-104, -106, -106, -108, -109, -110, -112, -113, -114, -114, -115, -116, -116,
-117, -117, -118, -119, -119, -119, -119, -119, -118, -119, -118, -118, -118,
-117, -117, -116, -116, -115, -115, -115, -114, -113, -113, -111, -111, -111,
-110, -110, -109, -107, -107, -107, -107, -106, -106, -104, -104, -104, -103,
-103, -102, -101, -102, -101, -100, -100, -100, -98, -99, -99, -98, -98, -97,
-98, -97, -98, -97, -97, -96, -96, -97, -97, -96, -96, -96, -97, -97, -97, -96,
-97, -96, -96, -97, -96, -96, -96, -96, -96, -95, -96, -95, -95, -94, -94, -93,
-93, -93, -91, -92, -91, -90, -89, -88, -88, -86, -85, -85, -84, -83, -82, -80,
-79, -78, -78, -75, -73, -73, -71, -70, -69, -67, -66, -65, -65, -62, -62, -60,
-59, -57, -56, -55, -53, -52, -51, -49, -48, -47, -46, -45, -43, -42, -41, -39,
-38, -36, -36, -35, -33, -32, -30, -29, -28, -26, -25, -23, -22, -22, -20, -18,
-16, -15, -14, -13, -11, -9, -7, -6, -5, -4, -2, 0, };