#define DATA_LENGTH 512
#define DATA AKWF_0722

const PROGMEM int8_t DATA[DATA_LENGTH] = {67, 114, 108, 112, 104, 104, 104, 105,
103, 105, 103, 105, 103, 104, 102, 113, 120, 118, 121, 118, 119, 118, 119, 119,
119, 120, 119, 119, 120, 120, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
118, 119, 119, 119, 119, 118, 118, 118, 119, 119, 119, 118, 118, 118, 118, 118,
118, 119, 118, 118, 119, 118, 118, 118, 118, 119, 118, 118, 118, 118, 118, 117,
119, 119, 117, 118, 118, 117, 118, 118, 118, 117, 118, 118, 118, 118, 118, 117,
118, 117, 118, 118, 118, 117, 117, 117, 117, 118, 117, 118, 118, 118, 117, 118,
118, 117, 117, 118, 117, 117, 117, 117, 117, 118, 117, 118, 117, 117, 117, 117,
117, 118, 117, 117, 117, 118, 117, 117, 117, 117, 117, 117, 117, 118, 117, 117,
117, 117, 117, 117, 117, 117, 117, 116, 118, 116, 117, 116, 117, 117, 117, 117,
117, 116, 117, 117, 116, 117, 116, 118, 116, 119, 115, 118, 114, 119, 112, 122,
110, 127, 48, -65, -42, -62, -52, -47, -46, -46, -47, -45, -48, -44, -52, -63,
-62, -62, -62, -61, -63, -61, -63, -61, -63, -61, -63, -63, -63, -61, -62, -62,
-62, -63, -62, -62, -62, -63, -62, -62, -62, -62, -62, -63, -62, -63, -62, -62,
-62, -62, -62, -62, -62, -62, -62, -62, -62, -62, -62, -63, -62, -62, -62, -62,
-62, -61, -62, -62, -62, -62, -62, -63, -62, -61, -62, -62, -62, -62, -61, -62,
-62, -62, -62, -63, -62, -62, -62, -62, -61, -62, -62, -61, -63, -62, -62, -62,
-62, -62, -61, -62, -63, -62, -62, -61, -61, -61, -62, -63, -61, -62, -63, -61,
-62, -62, -62, -62, -62, -61, -62, -61, -62, -61, -62, -62, -62, -62, -62, -61,
-62, -61, -62, -62, -61, -62, -61, -62, -62, -61, -61, -62, -61, -61, -61, -61,
-61, -62, -61, -61, -61, -61, -62, -62, -62, -62, -61, -61, -61, -62, -61, -61,
-61, -61, -61, -61, -62, -62, -62, -61, -61, -61, -61, -61, -61, -61, -61, -61,
-62, -61, -61, -61, -61, -61, -60, -61, -61, -61, -61, -61, -61, -61, -61, -61,
-61, -61, -61, -61, -62, -61, -61, -61, -60, -61, -61, -61, -61, -61, -60, -61,
-61, -61, -60, -61, -61, -62, -61, -60, -61, -61, -61, -60, -61, -61, -61, -60,
-60, -61, -61, -61, -61, -61, -61, -60, -61, -61, -61, -61, -61, -60, -60, -61,
-61, -61, -60, -61, -61, -61, -61, -60, -61, -61, -60, -60, -61, -60, -61, -60,
-61, -60, -61, -61, -60, -60, -61, -61, -61, -60, -61, -61, -61, -61, -61, -60,
-61, -60, -60, -60, -60, -60, -61, -60, -60, -61, -61, -60, -60, -60, -60, -60,
-61, -60, -61, -60, -60, -61, -60, -60, -60, -60, -60, -60, -60, -59, -60, -60,
-60, -60, -60, -60, -61, -60, -60, -59, -60, -60, -60, -60, -59, -60, -61, -60,
-60, -61, -59, -64, -27, -13, -19, -14, -19, -15, -18, -15, -17, -15, -17, -15,
-17, -15, -17, -16, -17, -16, -17, -13, };