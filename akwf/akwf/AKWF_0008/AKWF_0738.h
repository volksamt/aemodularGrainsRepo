#define DATA_LENGTH 512
#define DATA AKWF_0738

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 5, 4, 6, 6, 7, 7, 8, 8, 13,
18, 22, 25, 29, 32, 35, 38, 40, 40, 42, 43, 43, 46, 44, 50, 32, 21, 27, 30, 34,
35, 39, 41, 43, 45, 48, 49, 51, 53, 54, 55, 56, 57, 58, 60, 59, 59, 57, 57, 56,
58, 57, 58, 56, 57, 57, 57, 57, 58, 57, 58, 57, 58, 58, 58, 60, 58, 60, 58, 62,
58, 64, 56, 66, 51, 79, -3, -127, -108, -110, -98, -97, -89, -87, -81, -77, -75,
-70, -67, -62, -60, -56, -54, -50, -47, -43, -43, -38, -36, -33, -31, -28, -26,
-22, -21, -19, -16, -15, -12, -10, -8, -6, -5, -3, -1, 1, 2, 4, 7, 6, 9, 10, 12,
15, 17, 17, 20, 20, 22, 23, 23, 25, 26, 28, 29, 30, 31, 33, 34, 36, 38, 40, 41,
42, 43, 44, 46, 46, 47, 47, 48, 47, 51, 32, 21, 22, 19, 20, 19, 19, 18, 19, 18,
18, 17, 16, 16, 15, 14, 13, 13, 12, 13, 11, 9, 7, 5, 3, 3, 1, -1, -2, -4, -4,
-6, -7, -7, -8, -10, -10, -12, -12, -13, -13, -13, -15, -15, -15, -16, -17, -17,
-17, -15, -15, -14, -14, -14, -13, -13, -13, -13, -12, -13, -12, -11, -11, -11,
-12, -11, -11, -10, -10, -10, -11, -10, -10, -10, -10, -11, -10, -11, -10, -12,
-7, -35, -56, -49, -50, -45, -45, -42, -41, -38, -38, -37, -35, -33, -33, -32,
-30, -29, -27, -26, -24, -24, -21, -21, -20, -19, -17, -18, -16, -17, -16, -16,
-13, -12, -10, -10, -8, -7, -6, -5, -5, -6, -6, -7, -8, -8, -10, -7, -29, -39,
-33, -33, -30, -30, -28, -26, -25, -25, -25, -24, -23, -23, -22, -22, -22, -22,
-21, -21, -23, -25, -27, -26, -28, -29, -29, -31, -31, -31, -32, -32, -32, -33,
-33, -33, -34, -34, -34, -34, -34, -35, -34, -34, -34, -34, -33, -34, -35, -34,
-34, -35, -34, -33, -34, -34, -34, -34, -35, -34, -34, -34, -33, -35, -34, -34,
-34, -34, -34, -34, -34, -34, -33, -34, -34, -33, -34, -35, -34, -35, -34, -34,
-34, -34, -34, -35, -34, -34, -34, -34, -34, -34, -35, -33, -34, -35, -34, -34,
-32, -33, -32, -31, -31, -32, -31, -31, -31, -31, -30, -31, -31, -30, -29, -27,
-26, -24, -23, -24, -23, -21, -21, -20, -21, -19, -20, -19, -19, -18, -38, -46,
-41, -40, -36, -35, -34, -32, -31, -29, -28, -27, -26, -25, -25, -24, -23, -24,
-23, -21, -22, -23, -23, -25, -26, -26, -26, -26, -26, -27, -27, -28, -27, -29,
-29, -28, -28, -28, -28, -28, -28, -28, -28, -29, -28, -28, -28, -27, -26, -26,
-24, -23, -20, -17, -15, -14, -13, -9, -9, -8, -6, -5, -4, -2, -2, -1, 0, 2, 1,
4, 4, 5, 5, 6, 7, 6, 7, 7, 9, 7, 12, -20, -36, -28, -29, -23, -23, -20, -20,
-16, -16, -14, -13, -11, -10, -8, -7, -4, -3, -2, 0, };