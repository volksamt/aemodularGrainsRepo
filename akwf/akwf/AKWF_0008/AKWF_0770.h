#define DATA_LENGTH 512
#define DATA AKWF_0770

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 1, 2, 3, 4, 5, 6, 5, 6, 7, 7,
8, 8, 10, 11, 11, 11, 13, 13, 14, 15, 16, 16, 17, 18, 19, 19, 20, 21, 22, 23,
24, 24, 26, 25, 27, 27, 29, 29, 30, 31, 32, 33, 33, 34, 36, 37, 37, 38, 38, 40,
41, 42, 43, 44, 45, 45, 47, 48, 48, 49, 50, 51, 52, 53, 54, 55, 56, 57, 59, 59,
60, 62, 63, 64, 65, 66, 67, 67, 69, 70, 72, 72, 73, 74, 76, 76, 77, 78, 80, 80,
82, 83, 84, 86, 86, 87, 89, 89, 90, 92, 93, 94, 95, 96, 97, 99, 100, 101, 101,
102, 103, 105, 106, 107, 108, 108, 111, 111, 113, 112, 113, 115, 116, 117, 116,
116, 118, 118, 119, 118, 119, 119, 119, 119, 118, 119, 119, 118, 117, 117, 116,
115, 115, 115, 113, 112, 111, 110, 109, 108, 106, 105, 103, 101, 100, 99, 97,
96, 93, 92, 91, 89, 86, 84, 83, 80, 78, 77, 74, 73, 70, 68, 66, 64, 61, 60, 56,
54, 52, 50, 48, 46, 44, 42, 40, 37, 35, 33, 30, 28, 27, 24, 23, 19, 18, 16, 13,
11, 9, 8, 6, 3, 2, 0, -2, -5, -6, -8, -9, -11, -13, -15, -16, -18, -20, -21,
-23, -24, -26, -27, -28, -29, -31, -33, -34, -35, -36, -38, -38, -40, -41, -43,
-43, -44, -46, -46, -48, -48, -48, -50, -52, -52, -52, -53, -55, -55, -56, -56,
-57, -57, -58, -58, -59, -60, -61, -61, -61, -62, -63, -62, -64, -64, -64, -65,
-65, -65, -65, -66, -65, -66, -66, -67, -67, -67, -67, -67, -67, -68, -68, -68,
-68, -67, -68, -69, -68, -69, -68, -68, -68, -69, -69, -67, -69, -67, -68, -68,
-68, -68, -68, -68, -67, -67, -67, -67, -67, -67, -67, -67, -65, -66, -66, -66,
-65, -65, -65, -65, -65, -65, -64, -64, -63, -64, -63, -63, -62, -63, -63, -62,
-62, -62, -61, -62, -61, -60, -60, -60, -60, -60, -60, -59, -59, -59, -59, -59,
-58, -58, -57, -56, -56, -56, -57, -56, -55, -56, -55, -54, -54, -54, -53, -54,
-53, -53, -52, -52, -52, -52, -51, -51, -51, -51, -50, -49, -50, -49, -48, -48,
-48, -47, -48, -48, -47, -47, -46, -47, -46, -46, -45, -45, -45, -45, -44, -44,
-43, -43, -43, -43, -42, -43, -43, -42, -42, -41, -40, -41, -40, -41, -40, -40,
-39, -39, -39, -39, -38, -38, -38, -37, -37, -37, -36, -36, -36, -36, -36, -35,
-35, -34, -34, -35, -33, -33, -34, -32, -32, -32, -32, -32, -31, -30, -31, -30,
-30, -29, -29, -29, -29, -29, -27, -28, -28, -27, -27, -26, -26, -26, -26, -25,
-25, -24, -24, -23, -24, -23, -22, -22, -22, -21, -21, -21, -20, -20, -19, -19,
-19, -18, -18, -17, -17, -17, -15, -15, -15, -15, -14, -13, -13, -12, -13, -12,
-11, -11, -10, -10, -10, -9, -8, -8, -7, -6, -6, -5, -4, -4, -4, -3, -2, -3, -2,
0, -1, };