#define DATA_LENGTH 512
#define DATA AKWF_0776

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 8, 9, 12, 13, 15, 18, 20, 22,
25, 27, 28, 30, 33, 34, 37, 38, 40, 42, 44, 45, 47, 49, 50, 52, 53, 56, 57, 59,
60, 63, 64, 65, 67, 68, 70, 71, 74, 75, 76, 79, 80, 82, 83, 85, 87, 88, 89, 91,
92, 94, 96, 97, 98, 100, 100, 102, 103, 104, 105, 106, 107, 108, 110, 110, 112,
112, 112, 113, 114, 115, 115, 116, 115, 116, 116, 116, 117, 117, 117, 117, 116,
117, 116, 116, 116, 115, 115, 115, 114, 114, 114, 113, 113, 112, 112, 112, 112,
111, 111, 112, 111, 111, 110, 110, 111, 110, 110, 111, 111, 110, 111, 110, 110,
110, 111, 111, 110, 110, 110, 110, 110, 110, 109, 110, 110, 109, 108, 109, 109,
108, 108, 108, 108, 108, 108, 107, 106, 106, 106, 105, 104, 104, 104, 102, 103,
102, 100, 100, 99, 99, 98, 98, 97, 96, 95, 93, 94, 92, 91, 91, 90, 88, 87, 86,
85, 84, 83, 82, 81, 80, 79, 78, 76, 76, 76, 74, 72, 72, 71, 70, 68, 68, 66, 65,
64, 62, 61, 59, 59, 57, 56, 54, 52, 50, 48, 47, 45, 44, 42, 40, 39, 38, 36, 34,
33, 32, 31, 30, 28, 27, 27, 26, 25, 23, 22, 23, 22, 21, 20, 19, 18, 18, 18, 16,
16, 15, 14, 14, 13, 12, 12, 11, 10, 9, 9, 8, 8, 7, 8, 6, 6, 6, 6, 5, 6, 5, 4, 4,
3, 2, 2, 0, 0, -1, -3, -3, -4, -5, -7, -7, -9, -10, -12, -12, -13, -15, -16,
-16, -19, -20, -21, -22, -23, -25, -25, -27, -28, -29, -30, -31, -33, -34, -35,
-36, -37, -39, -40, -41, -42, -43, -44, -46, -47, -48, -50, -50, -52, -52, -54,
-56, -56, -58, -60, -60, -61, -63, -64, -65, -67, -68, -68, -70, -70, -71, -73,
-73, -74, -75, -76, -77, -77, -78, -79, -80, -80, -81, -81, -81, -82, -82, -83,
-83, -84, -85, -84, -85, -85, -86, -86, -86, -87, -86, -87, -88, -88, -88, -89,
-88, -90, -90, -90, -91, -91, -91, -91, -92, -92, -93, -93, -94, -94, -95, -94,
-95, -96, -97, -96, -98, -98, -100, -100, -100, -101, -103, -103, -104, -105,
-105, -107, -107, -110, -110, -111, -111, -112, -113, -113, -114, -115, -116,
-117, -116, -117, -117, -118, -117, -118, -119, -119, -119, -120, -118, -119,
-118, -119, -119, -119, -118, -117, -118, -118, -117, -117, -116, -115, -116,
-115, -114, -113, -113, -112, -111, -111, -111, -110, -109, -109, -107, -107,
-107, -105, -105, -104, -103, -103, -101, -101, -100, -99, -98, -97, -96, -95,
-93, -91, -91, -88, -88, -85, -84, -82, -81, -80, -77, -76, -74, -72, -70, -70,
-67, -66, -64, -62, -61, -59, -58, -57, -54, -54, -52, -50, -49, -47, -47, -44,
-43, -42, -40, -39, -37, -36, -35, -34, -32, -31, -30, -29, -28, -26, -25, -24,
-23, -22, -21, -20, -20, -18, -17, -16, -15, -14, -12, -10, -8, -7, -6, -4, -2,
0, };