#define DATA_LENGTH 512
#define DATA AKWF_0748

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 9, 13, 16, 19, 22, 26, 29, 31,
34, 37, 40, 43, 45, 48, 50, 52, 55, 57, 59, 61, 63, 66, 68, 70, 71, 73, 75, 78,
80, 82, 83, 85, 87, 88, 90, 92, 93, 94, 97, 97, 98, 99, 101, 101, 101, 103, 103,
103, 104, 103, 103, 104, 103, 103, 103, 103, 102, 101, 102, 101, 100, 99, 99,
99, 97, 97, 95, 96, 95, 94, 93, 92, 91, 89, 89, 88, 87, 86, 85, 84, 82, 81, 80,
79, 78, 77, 76, 75, 74, 72, 70, 70, 69, 67, 65, 66, 63, 62, 61, 59, 58, 58, 56,
54, 54, 56, 57, 57, 59, 59, 60, 60, 61, 61, 62, 62, 64, 64, 65, 65, 65, 67, 67,
67, 67, 69, 68, 69, 70, 70, 71, 70, 71, 72, 71, 73, 72, 73, 72, 72, 73, 72, 73,
72, 72, 72, 72, 72, 72, 72, 71, 70, 70, 70, 69, 69, 69, 68, 68, 67, 67, 63, 58,
55, 53, 48, 44, 41, 37, 34, 30, 26, 22, 19, 15, 11, 7, 2, -2, -5, -10, -14, -18,
-22, -25, -29, -33, -36, -40, -44, -47, -51, -54, -57, -59, -63, -66, -68, -72,
-73, -76, -79, -82, -84, -86, -89, -90, -92, -94, -95, -97, -99, -101, -103,
-104, -105, -104, -106, -106, -107, -107, -107, -107, -107, -106, -106, -105,
-105, -103, -102, -102, -100, -98, -96, -91, -88, -84, -79, -76, -72, -68, -65,
-60, -56, -53, -48, -44, -42, -37, -34, -29, -26, -23, -20, -16, -13, -10, -6,
-4, 0, 3, 5, 7, 11, 14, 17, 19, 22, 24, 26, 29, 30, 33, 35, 37, 39, 41, 42, 44,
45, 47, 48, 49, 50, 52, 52, 54, 53, 55, 52, 51, 50, 48, 47, 45, 44, 43, 41, 40,
39, 37, 36, 36, 34, 32, 30, 29, 28, 27, 25, 24, 22, 21, 20, 19, 18, 16, 15, 14,
12, 12, 10, 9, 7, 6, 5, 3, 2, 1, 0, -1, -2, -4, -4, -6, -6, -8, -8, -10, -12,
-12, -13, -14, -14, -16, -15, -17, -17, -18, -18, -19, -19, -19, -20, -19, -20,
-20, -20, -19, -19, -19, -19, -19, -20, -20, -20, -19, -20, -20, -20, -22, -21,
-21, -21, -22, -22, -24, -23, -24, -24, -24, -24, -25, -26, -26, -26, -26, -27,
-26, -27, -26, -27, -26, -27, -27, -27, -27, -27, -27, -27, -27, -26, -26, -26,
-26, -25, -26, -24, -25, -26, -25, -24, -25, -24, -23, -23, -23, -24, -26, -28,
-30, -33, -34, -37, -40, -41, -44, -46, -49, -52, -55, -57, -59, -61, -64, -66,
-69, -71, -74, -76, -78, -80, -82, -86, -87, -90, -92, -94, -97, -99, -101,
-102, -105, -107, -108, -110, -111, -113, -113, -115, -117, -117, -117, -118,
-119, -119, -119, -119, -119, -119, -119, -117, -118, -116, -116, -114, -113,
-112, -111, -110, -108, -107, -105, -104, -101, -99, -97, -96, -92, -88, -81,
-77, -72, -67, -63, -58, -54, -49, -45, -40, -36, -32, -27, -23, -19, -15, -11,
-8, -4, 0, };