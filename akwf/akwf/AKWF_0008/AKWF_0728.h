#define DATA_LENGTH 512
#define DATA AKWF_0728

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 11, 16, 24, 29, 38, 42, 51, 55, 66,
67, 82, 71, 1, 9, 15, 19, 28, 30, 39, 38, 51, 49, 64, 57, 82, 33, -19, -15, -26,
-28, -38, -40, -55, 21, 34, 11, 7, -11, -19, -13, -9, -22, -22, -33, -34, -44,
-47, -55, -59, -67, -72, -79, -84, -91, -96, -102, -108, -114, -119, -112, -106,
-100, -94, -88, -83, -75, -70, -63, -58, -52, -47, -41, -35, -28, -23, -17, -11,
-5, -1, -2, -2, -3, -2, -2, -1, -3, -1, 3, 11, 15, 24, 27, 39, 31, 2, 12, 16,
22, 28, 35, 40, 46, 53, 58, 65, 69, 76, 82, 88, 93, 99, 105, 113, 111, 104, 99,
92, 87, 81, 75, 69, 64, 57, 51, 46, 39, 33, 28, 22, 15, 10, 4, -2, -2, -2, -2,
-2, -2, -2, -2, -2, -2, -2, -3, -3, -2, -2, -2, -2, -3, -2, -2, -2, -2, -3, -2,
-2, -2, -3, -2, -2, -3, -2, -3, -2, -2, -3, -2, -2, -2, -1, -3, -2, -3, -2, -2,
-2, -2, -2, -2, -2, -2, -2, -2, -3, -2, -2, -3, -2, -2, -3, -3, -3, -2, -2, -1,
-2, -2, -2, -2, -3, -3, -3, -2, -2, -3, -2, -1, -2, -2, -2, -2, -2, -2, -2, -1,
-3, -2, -2, -3, -2, -2, -2, -2, -2, -3, -2, -1, -2, -2, -3, -2, -2, -2, -1, -2,
-2, -3, -2, -3, -3, -2, -2, -3, -2, -2, -2, -2, -2, -2, -2, -3, -2, -3, -2, -2,
-3, -2, -3, -2, -3, -2, -3, -3, -2, -3, -3, -2, -2, -3, -2, -2, -2, -2, -2, -2,
-2, -2, -2, -3, -2, -2, -2, -2, -2, -2, -3, -2, -3, -2, -3, -2, -2, -3, -2, -2,
-2, -2, -3, -2, -3, -2, -2, -3, -3, -2, -2, -2, -2, -2, -3, -2, -2, -3, -2, -3,
-2, -3, -2, -2, -3, -2, -2, -2, -2, -1, -3, -3, -2, -2, -2, -3, -2, -2, -2, -2,
-2, -3, -2, -2, -2, -2, -2, -1, -3, -1, -2, -2, -3, -2, -2, -2, -2, -2, -3, -2,
-2, -2, -3, -2, -3, -2, -2, -2, -3, -2, -3, -2, -2, -3, -2, -2, -2, -2, -2, -2,
-2, -2, -3, -3, -2, -3, -2, -2, -2, -2, -2, -3, -2, -3, -2, -3, -2, -1, -3, -2,
-3, -2, -2, -2, -2, -3, -2, -2, -3, -3, -3, -2, -3, -2, -2, -2, -2, -2, -2, -2,
-2, -2, -3, -3, -3, -1, -2, -2, -2, -2, -2, -3, -3, -2, -3, -3, -2, -2, -2, -2,
-2, -3, -2, -3, -2, -2, -3, -2, -3, -2, -2, -2, -2, -2, -3, -3, -2, -2, -2, -2,
-3, -3, -2, -3, -2, -2, -2, -2, -3, -2, -2, -3, -2, -2, -3, -2, -2, -3, -2, -2,
-3, -2, -2, -3, -3, -3, -3, -2, -2, -2, -2, -2, -2, -2, -3, -2, -2, -2, -2, -2,
-3, -2, -2, -3, -2, -2, -2, -3, -2, -2, -2, -1, -2, -2, -2, };