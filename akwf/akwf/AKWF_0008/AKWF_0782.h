#define DATA_LENGTH 512
#define DATA AKWF_0782

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 14, 26, 34, 43, 51, 58, 63, 68, 73,
75, 79, 82, 86, 89, 90, 92, 95, 97, 98, 100, 101, 102, 103, 104, 105, 107, 108,
109, 109, 110, 110, 110, 111, 113, 113, 114, 114, 114, 114, 115, 115, 115, 116,
116, 117, 117, 117, 118, 118, 118, 119, 118, 119, 118, 118, 118, 119, 119, 119,
118, 120, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 119,
119, 119, 119, 118, 118, 117, 118, 118, 117, 118, 117, 117, 117, 117, 117, 117,
116, 116, 116, 116, 115, 115, 115, 114, 114, 114, 114, 114, 114, 113, 113, 113,
112, 111, 110, 111, 110, 110, 110, 109, 109, 108, 108, 108, 107, 106, 106, 106,
104, 104, 104, 103, 103, 102, 102, 100, 100, 100, 98, 98, 97, 97, 96, 95, 95,
93, 93, 93, 91, 90, 89, 88, 88, 87, 86, 84, 83, 83, 81, 81, 80, 79, 77, 77, 75,
74, 73, 72, 71, 70, 69, 67, 66, 65, 63, 62, 61, 59, 59, 56, 55, 54, 53, 51, 50,
49, 48, 46, 46, 43, 42, 41, 40, 38, 38, 36, 34, 33, 32, 32, 30, 29, 27, 27, 25,
24, 23, 21, 21, 20, 18, 18, 16, 16, 14, 13, 12, 12, 11, 10, 9, 8, 8, 7, 7, 6, 6,
5, 4, 4, 4, 4, 2, 3, 2, 1, 2, 0, 1, 0, 0, 1, 0, -1, 0, 0, 0, 0, -1, -1, -1, -1,
-1, -1, -1, -1, -1, 0, -1, -1, -1, 0, -1, -1, -1, -1, 0, -1, -1, -2, -1, -2, -1,
-2, -2, -2, -2, -1, -2, -2, -2, -3, -3, -3, -4, -3, -3, -5, -5, -5, -6, -7, -7,
-7, -8, -8, -9, -9, -9, -11, -11, -13, -14, -14, -14, -16, -16, -18, -19, -19,
-20, -21, -22, -23, -25, -26, -26, -28, -29, -30, -32, -32, -34, -36, -37, -37,
-38, -40, -42, -43, -44, -45, -47, -48, -49, -51, -53, -53, -55, -56, -58, -58,
-60, -61, -62, -64, -64, -67, -67, -68, -70, -71, -72, -73, -75, -75, -77, -78,
-78, -80, -81, -82, -83, -84, -84, -86, -86, -88, -88, -90, -90, -91, -92, -93,
-95, -95, -95, -96, -97, -98, -98, -99, -99, -100, -100, -101, -102, -103, -103,
-104, -104, -105, -105, -106, -106, -107, -107, -108, -109, -109, -109, -109,
-109, -110, -111, -110, -112, -112, -111, -112, -112, -113, -113, -114, -114,
-114, -114, -114, -115, -115, -115, -116, -116, -115, -116, -116, -116, -116,
-116, -116, -117, -117, -118, -117, -117, -118, -117, -117, -117, -117, -117,
-118, -118, -117, -118, -118, -118, -117, -117, -118, -117, -118, -117, -117,
-118, -117, -117, -117, -117, -117, -117, -117, -116, -116, -116, -116, -115,
-116, -115, -115, -115, -114, -114, -113, -113, -113, -113, -112, -113, -111,
-112, -110, -110, -109, -109, -108, -107, -107, -106, -105, -103, -103, -102,
-101, -99, -98, -97, -95, -94, -92, -89, -87, -84, -82, -80, -76, -72, -69, -63,
-58, -53, -46, -39, -30, -21, -8, };