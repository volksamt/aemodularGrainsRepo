#define DATA_LENGTH 512
#define DATA AKWF_0719

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 6, 7, 9, 10, 11, 12, 13, 13, 13,
39, 61, 70, 81, 85, 86, 104, 119, 116, 111, 106, 102, 99, 98, 94, 92, 91, 89,
86, 85, 83, 81, 80, 78, 77, 75, 73, 72, 70, 69, 68, 66, 66, 65, 63, 63, 60, 59,
58, 57, 56, 54, 54, 53, 53, 50, 50, 48, 48, 47, 46, 45, 45, 44, 42, 41, 40, 40,
39, 38, 37, 36, 35, 34, 34, 33, 31, 31, 31, 30, 29, 28, 28, 26, 25, 24, 24, 24,
22, 22, 22, 21, 20, 20, 18, 19, 18, 18, 16, 17, 15, 15, 14, 14, 13, 13, 12, 12,
11, 10, 10, 9, 9, 8, 7, 8, 6, 6, 5, 5, 5, 5, 4, 3, 3, 2, 3, 1, 2, 2, 1, 0, 0, 0,
-1, -1, -2, -2, -2, -2, -3, -2, -3, -4, -4, -3, -5, -5, -4, -6, -5, -6, -5, -6,
-6, -6, -7, -6, -7, -8, -8, -8, -8, -8, -7, -8, -9, -8, -8, -9, -9, -9, -9, -9,
-10, -10, -9, -9, -9, -10, -10, -10, -10, -10, -10, -10, -11, -9, -14, -15, -10,
-10, -9, -9, -10, -11, -11, -10, -10, -10, -11, -10, -10, -11, -11, -11, -11,
-11, -11, -11, -12, -11, -11, -11, -12, -12, -12, -12, -11, -12, -12, -12, -12,
-12, -12, -12, -12, -12, -12, -12, -13, -12, -13, -12, -12, -12, -13, -13, -13,
-13, -13, -14, -12, -13, -13, -13, -13, -13, -13, -13, -13, -12, -13, -13, -13,
-14, -13, -14, -14, -13, -14, -14, -14, -14, -14, -13, -14, -14, -14, -14, -14,
-14, -14, -14, -14, -14, -14, -14, -14, -14, -15, -13, -14, -14, -14, -14, -15,
-15, -15, -15, -14, -15, -15, -15, -15, -15, -14, -15, -14, -15, -15, -14, -15,
-15, -16, -14, -14, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15, -15,
-16, -16, -15, -15, -15, -16, -15, -16, -15, -16, -15, -16, -15, -16, -15, -15,
-15, -16, -16, -15, -16, -16, -15, -15, -16, -15, -16, -16, -17, -16, -16, -16,
-16, -16, -15, -17, -16, -16, -16, -17, -17, -16, -17, -16, -17, -17, -17, -16,
-16, -17, -17, -17, -17, -16, -17, -17, -17, -16, -16, -16, -17, -16, -17, -16,
-17, -17, -17, -17, -16, -16, -16, -16, -17, -16, -17, -16, -16, -16, -16, -16,
-17, -17, -16, -17, -17, -17, -17, -17, -17, -16, -16, -17, -17, -17, -17, -17,
-16, -17, -16, -17, -16, -18, -17, -18, -17, -17, -17, -17, -17, -17, -17, -17,
-17, -17, -16, -17, -16, -17, -17, -17, -17, -18, -16, -18, -17, -17, -17, -17,
-17, -17, -17, -18, -18, -17, -17, -17, -17, -18, -17, -17, -18, -18, -17, -17,
-17, -17, -17, -17, -17, -17, -17, -18, -17, -17, -18, -17, -18, -17, -17, -17,
-17, -17, -17, -17, -18, -16, -17, -18, -18, -18, -17, -17, -17, -17, -17, -17,
-17, -17, -17, -17, -17, -18, -17, -17, -18, -16, -17, -17, -18, -12, -5, -2, };