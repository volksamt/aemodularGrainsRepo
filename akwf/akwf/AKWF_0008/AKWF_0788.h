#define DATA_LENGTH 512
#define DATA AKWF_0788

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 0, 0, 0, 1, 0, 1, 2, 2, 1, 2,
1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 3, 2, 4, 3, 3, 3, 3, 3, 4, 3, 3, 4, 3, 4, 3, 3,
3, 3, 4, 4, 5, 4, 5, 4, 4, 5, 4, 4, 4, 5, 4, 4, 5, 5, 4, 4, 5, 5, 5, 4, 5, 4, 4,
4, 5, 5, 5, 5, 4, 6, 6, 5, 5, 6, 5, 5, 5, 5, 5, 5, 5, 6, 5, 6, 5, 5, 5, 5, 5, 5,
5, 5, 6, 5, 6, 6, 5, 6, 6, 6, 5, 6, 6, 6, 5, 5, 5, 5, 5, 5, 6, 6, 6, 6, 6, 6, 6,
6, 6, 6, 6, 7, 7, 7, 7, 7, 8, 7, 8, 8, 8, 8, 7, 7, 8, 8, 7, 8, 8, 8, 8, 8, 9, 8,
8, 8, 8, 8, 8, 8, 8, 8, 8, 8, 9, 9, 9, 8, 8, 8, 8, 9, 9, 8, 9, 9, 10, 10, 10,
11, 12, 14, 13, 14, 17, 17, 18, 19, 20, 20, 22, 23, 24, 24, 25, 25, 25, 25, 25,
26, 26, 26, 26, 26, 26, 25, 26, 26, 27, 26, 26, 27, 27, 27, 27, 27, 27, 27, 26,
26, 26, 26, 27, 25, 25, 25, 25, 25, 24, 22, 22, 22, 20, 20, 20, 18, 17, 17, 16,
15, 14, 14, 14, 13, 12, 11, 10, 11, 11, 11, 11, 12, 12, 13, 14, 16, 16, 17, 20,
21, 23, 25, 27, 30, 31, 33, 36, 38, 41, 43, 47, 50, 53, 56, 58, 62, 65, 69, 71,
75, 78, 81, 84, 88, 90, 93, 97, 100, 101, 104, 107, 109, 111, 113, 115, 116,
117, 118, 119, 118, 119, 119, 118, 117, 116, 115, 114, 112, 111, 108, 105, 104,
102, 98, 97, 94, 90, 87, 85, 81, 78, 75, 71, 67, 64, 60, 58, 54, 50, 47, 43, 40,
37, 32, 28, 24, 21, 17, 13, 10, 5, 1, -2, -6, -10, -14, -19, -22, -26, -29, -34,
-37, -41, -46, -49, -52, -56, -60, -64, -67, -71, -75, -77, -80, -84, -86, -89,
-92, -94, -95, -98, -100, -101, -104, -105, -106, -109, -109, -110, -111, -111,
-112, -113, -114, -114, -113, -114, -113, -112, -113, -112, -111, -110, -110,
-109, -107, -106, -106, -105, -103, -102, -101, -99, -98, -96, -94, -93, -91,
-89, -88, -86, -85, -82, -81, -79, -77, -75, -73, -71, -70, -68, -66, -64, -63,
-61, -59, -58, -56, -54, -53, -52, -50, -49, -47, -45, -44, -44, -42, -41, -39,
-38, -37, -36, -35, -34, -32, -32, -30, -29, -29, -28, -27, -26, -25, -24, -23,
-22, -22, -21, -20, -20, -19, -19, -18, -18, -17, -16, -15, -15, -15, -14, -13,
-13, -12, -11, -12, -11, -11, -10, -10, -10, -9, -8, -8, -9, -7, -7, -7, -7, -6,
-5, -5, -5, -5, -5, -5, -4, -5, -4, -4, -3, -3, -2, -2, -3, -2, -2, -1, -2, -1,
-1, -1, -1, -1, 0, -1, 0, -1, };