#define DATA_LENGTH 512
#define DATA AKWF_0762

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 0, 1, 0, 0, 1, 1, 2, 1, 0, 2,
1, 1, 1, 1, 1, 1, 1, 2, 2, 2, 1, 2, 2, 2, 3, 2, 2, 3, 3, 2, 3, 2, 2, 2, 2, 2, 2,
2, 2, 3, 2, 3, 2, 2, 2, 2, 3, 3, 3, 3, 2, 3, 3, 4, 2, 3, 3, 3, 3, 2, 3, 2, 3, 3,
3, 3, 4, 2, 3, 3, 3, 3, 2, 3, 3, 3, 4, 3, 3, 3, 4, 3, 4, 4, 4, 5, 5, 5, 5, 5, 6,
7, 7, 8, 9, 9, 10, 10, 10, 12, 12, 12, 14, 14, 15, 16, 17, 17, 17, 18, 18, 19,
19, 20, 20, 20, 20, 21, 21, 20, 21, 21, 20, 22, 20, 20, 21, 21, 21, 20, 21, 21,
21, 21, 21, 21, 22, 22, 21, 22, 23, 22, 23, 22, 21, 23, 23, 23, 22, 21, 21, 22,
22, 22, 21, 21, 20, 20, 20, 20, 20, 20, 20, 19, 19, 18, 19, 18, 17, 17, 16, 15,
14, 14, 14, 13, 12, 13, 11, 11, 11, 10, 9, 9, 7, 8, 7, 7, 7, 7, 7, 6, 6, 6, 5,
6, 7, 6, 7, 7, 7, 8, 10, 9, 10, 11, 13, 13, 14, 15, 17, 18, 18, 21, 22, 23, 26,
26, 29, 30, 32, 34, 36, 37, 40, 42, 44, 46, 47, 50, 53, 55, 58, 60, 62, 63, 66,
69, 71, 73, 76, 79, 81, 83, 85, 87, 90, 92, 94, 97, 97, 100, 101, 103, 104, 106,
108, 109, 110, 111, 112, 113, 114, 114, 115, 115, 115, 116, 115, 114, 114, 114,
113, 112, 111, 109, 108, 107, 104, 103, 102, 100, 98, 95, 94, 92, 89, 87, 85,
83, 80, 77, 75, 73, 70, 67, 64, 63, 59, 56, 53, 51, 47, 44, 42, 40, 36, 34, 31,
27, 24, 21, 18, 16, 13, 9, 6, 2, -1, -4, -7, -10, -13, -16, -19, -23, -27, -30,
-33, -37, -39, -43, -46, -50, -52, -56, -59, -63, -66, -69, -72, -75, -77, -80,
-84, -86, -88, -92, -94, -96, -99, -100, -102, -104, -107, -108, -108, -111,
-112, -113, -115, -115, -116, -117, -117, -118, -119, -119, -118, -120, -119,
-119, -119, -119, -118, -118, -117, -116, -116, -114, -114, -112, -112, -110,
-109, -108, -107, -106, -104, -103, -101, -99, -97, -95, -94, -92, -89, -89,
-86, -85, -83, -81, -79, -77, -75, -74, -71, -69, -68, -66, -64, -63, -61, -58,
-57, -55, -54, -52, -52, -49, -48, -47, -45, -44, -43, -41, -39, -39, -37, -36,
-34, -34, -33, -32, -31, -29, -29, -28, -27, -26, -25, -24, -23, -22, -21, -21,
-21, -20, -19, -18, -17, -17, -17, -15, -15, -14, -14, -14, -13, -12, -12, -11,
-11, -11, -10, -10, -9, -8, -9, -7, -8, -7, -8, -6, -6, -6, -6, -5, -5, -5, -5,
-5, -5, -4, -3, -3, -3, -3, -3, -3, -2, -3, -2, -2, -2, -2, -2, -1, -1, -1, -1,
0, -1, 0, 0, 0, 0, 0, 0, };