#define DATA_LENGTH 512
#define DATA AKWF_0726

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, -2, -3, -5, -6, -8, -9, -11, -12,
-14, -14, -17, -16, -20, -19, -23, -22, -26, -24, -28, -27, -31, -30, -34, -33,
-36, -36, -39, -41, 40, 53, 49, 54, 52, 57, 55, 59, 58, 61, 60, 63, 63, 66, 65,
68, 68, 69, 70, 72, 73, 74, 75, 76, 77, 79, 80, 80, 81, 82, 84, 85, 85, 86, 88,
88, 89, 90, 91, 92, 93, 93, 94, 95, 95, 97, 97, 98, 99, 99, 101, 101, 102, 103,
104, 104, 104, 105, 106, 107, 108, 108, 109, 109, 109, 110, 110, 112, 112, 111,
112, 113, 113, 114, 115, 114, 115, 115, 116, 115, 116, 117, 117, 117, 117, 117,
118, 118, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 118, 119, 118, 119,
119, 119, 119, 119, 118, 118, 119, 118, 118, 118, 117, 118, 117, 118, 117, 117,
117, 116, 116, 115, 115, 115, 114, 114, 114, 113, 113, 112, 111, 111, 111, 110,
109, 109, 108, 108, 107, 107, 106, 105, 104, 104, 103, 102, 102, 101, 101, 100,
98, 98, 97, 96, 95, 94, 93, 93, 91, 90, 89, 88, 86, 87, 85, 84, 83, 82, 81, 80,
78, 77, 76, 74, 74, 73, 70, 70, 68, 66, 66, 64, 64, 60, 61, 57, 58, 53, 57, 49,
55, 43, 56, 20, -49, -36, -40, -35, -36, -34, -33, -32, -29, -29, -26, -27, -24,
-23, -21, -21, -18, -18, -15, -15, -13, -11, -9, -9, -7, -5, -3, -3, -2, 1, 3,
5, 6, 8, 9, 10, 12, 13, 15, 17, 19, 20, 21, 21, 25, 24, 27, 27, 30, 30, 33, 33,
36, 36, 38, 39, 40, 44, 40, 52, -21, -53, -40, -50, -45, -51, -48, -53, -52,
-56, -54, -58, -56, -59, -59, -61, -62, -64, -64, -65, -66, -68, -68, -69, -71,
-71, -73, -74, -76, -75, -77, -78, -79, -79, -80, -82, -83, -84, -85, -86, -85,
-87, -87, -89, -89, -90, -90, -92, -91, -93, -94, -94, -95, -96, -97, -98, -98,
-98, -99, -100, -100, -101, -102, -102, -102, -103, -103, -104, -104, -105,
-106, -105, -106, -107, -107, -107, -109, -108, -109, -109, -109, -109, -111,
-110, -110, -110, -111, -111, -111, -112, -111, -111, -112, -111, -112, -112,
-113, -112, -113, -113, -113, -113, -113, -114, -113, -113, -112, -113, -113,
-113, -112, -113, -112, -112, -112, -111, -112, -112, -112, -111, -111, -111,
-110, -110, -109, -110, -109, -110, -109, -108, -109, -107, -107, -107, -107,
-106, -105, -105, -104, -104, -103, -103, -103, -102, -102, -100, -101, -100,
-99, -99, -97, -97, -96, -95, -95, -94, -93, -94, -93, -91, -90, -91, -89, -87,
-87, -87, -86, -85, -84, -84, -82, -81, -80, -79, -78, -78, -77, -75, -74, -73,
-73, -71, -70, -70, -69, -66, -66, -64, -64, -63, -63, -60, -59, -58, -58, -55,
-55, -53, -53, -51, -50, -49, -46, -47, -43, -47, -38, -50, 14, 56, 38, 46, 38,
40, 35, 37, 32, 31, 28, 27, 24, 22, 19, 16, 14, 7, 4, 2, 1, };