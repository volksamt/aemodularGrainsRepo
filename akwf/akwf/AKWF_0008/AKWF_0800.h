#define DATA_LENGTH 512
#define DATA AKWF_0800

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 6, 9, 10, 12, 13, 16, 19, 20,
23, 23, 26, 29, 31, 33, 36, 38, 41, 43, 46, 48, 50, 52, 54, 58, 60, 62, 65, 67,
70, 71, 75, 77, 80, 81, 84, 86, 88, 90, 92, 95, 96, 98, 99, 101, 104, 105, 107,
108, 109, 111, 111, 113, 114, 114, 116, 116, 117, 118, 119, 119, 119, 119, 118,
119, 119, 118, 118, 117, 118, 117, 116, 115, 115, 114, 112, 111, 110, 109, 107,
105, 104, 101, 100, 98, 96, 94, 92, 90, 88, 84, 82, 80, 78, 75, 73, 70, 67, 64,
62, 59, 56, 53, 50, 46, 43, 41, 37, 34, 31, 28, 26, 21, 19, 15, 12, 9, 6, 2, 0,
-3, -6, -9, -13, -16, -18, -21, -25, -27, -30, -33, -36, -39, -42, -45, -47,
-50, -52, -55, -57, -60, -63, -65, -67, -70, -71, -73, -75, -77, -79, -81, -82,
-85, -86, -88, -90, -91, -92, -94, -95, -97, -97, -99, -100, -101, -102, -103,
-103, -104, -105, -105, -106, -105, -107, -106, -107, -107, -107, -107, -107,
-107, -108, -107, -106, -106, -106, -105, -104, -104, -104, -103, -102, -102,
-101, -99, -98, -97, -97, -96, -95, -94, -93, -92, -90, -89, -87, -86, -85, -83,
-83, -80, -80, -79, -77, -75, -74, -73, -71, -69, -68, -65, -65, -62, -60, -58,
-56, -54, -53, -50, -49, -47, -44, -41, -39, -37, -35, -33, -30, -29, -27, -24,
-22, -20, -18, -17, -15, -13, -11, -10, -9, -7, -5, -5, -3, -3, -2, -1, -1, -1,
0, 0, 0, -1, 0, 0, -1, -1, -2, -2, -4, -5, -6, -7, -9, -10, -11, -14, -15, -17,
-18, -21, -23, -24, -27, -28, -31, -33, -35, -38, -40, -42, -44, -46, -48, -51,
-53, -55, -57, -60, -61, -63, -65, -66, -68, -69, -71, -73, -74, -75, -75, -77,
-78, -79, -80, -80, -80, -80, -81, -80, -80, -80, -79, -78, -77, -76, -75, -74,
-73, -72, -69, -68, -66, -63, -61, -59, -56, -54, -52, -49, -46, -43, -40, -37,
-34, -30, -27, -24, -21, -17, -13, -10, -7, -3, -1, 3, 7, 11, 14, 17, 21, 24,
27, 31, 33, 36, 41, 43, 46, 48, 51, 54, 56, 59, 63, 64, 66, 69, 70, 73, 75, 76,
78, 80, 81, 81, 82, 84, 84, 85, 86, 86, 87, 86, 87, 87, 87, 86, 87, 86, 87, 86,
85, 84, 83, 83, 82, 81, 80, 79, 77, 75, 74, 74, 72, 71, 69, 68, 65, 63, 62, 59,
58, 56, 54, 53, 51, 49, 47, 45, 43, 41, 39, 37, 34, 32, 31, 29, 27, 25, 23, 22,
19, 17, 15, 14, 12, 10, 9, 7, 5, 4, 3, 0, 0, -3, -4, -5, -6, -7, -9, -9, -11,
-12, -12, -14, -14, -16, -16, -17, -18, -18, -19, -20, -20, -20, -20, -21, -21,
-22, -21, -21, -22, -22, -22, -21, -21, -21, -21, -20, -19, -19, -18, -18, -17,
-16, -16, -15, -15, -13, -12, -12, -10, -10, -9, -8, -6, -4, -4, -2, 0, };