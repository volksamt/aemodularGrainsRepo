#define DATA_LENGTH 512
#define DATA AKWF_0727

const PROGMEM int8_t DATA[DATA_LENGTH] = {25, 31, 29, 32, 32, 34, 34, 36, 35,
37, 38, 39, 39, 41, 42, 42, 44, 44, 44, 46, 46, 48, 48, 49, 51, 51, 52, 53, 54,
55, 55, 56, 57, 58, 59, 60, 60, 61, 62, 63, 64, 64, 65, 66, 67, 67, 68, 69, 70,
71, 72, 73, 74, 74, 75, 75, 77, 78, 78, 80, 80, 81, 81, 82, 83, 84, 84, 85, 86,
87, 87, 88, 89, 90, 90, 91, 92, 93, 94, 94, 95, 96, 96, 97, 98, 98, 100, 100,
101, 102, 103, 103, 103, 105, 105, 106, 107, 108, 108, 109, 109, 110, 110, 112,
112, 113, 113, 114, 115, 116, 117, 117, 117, 119, 119, 117, 116, 117, 115, 116,
114, 113, 113, 112, 111, 111, 109, 108, 108, 107, 107, 105, 105, 103, 103, 102,
101, 100, 99, 97, 97, 96, 95, 95, 93, 92, 92, 90, 90, 88, 88, 86, 85, 84, 83,
83, 81, 81, 79, 78, 77, 75, 74, 73, 72, 70, 69, 68, 66, 65, 63, 62, 60, 59, 57,
56, 54, 52, 52, 48, 47, 44, 43, 39, 38, 32, 34, 19, -11, -6, -6, -4, -5, -3, -2,
-1, 0, 0, 1, 3, 4, 4, 6, 7, 8, 8, 10, 11, 12, 12, 14, 14, 16, 16, 19, 18, 20,
20, 23, 21, 24, 22, 30, 11, -13, -7, -13, -10, -13, -13, -14, -14, -16, -17,
-17, -19, -19, -20, -20, -22, -22, -23, -24, -25, -25, -26, -27, -28, -29, -29,
-31, -31, -32, -33, -33, -33, -35, -36, -35, -37, -37, -38, -40, -40, -40, -41,
-42, -42, -43, -44, -44, -46, -46, -47, -48, -48, -49, -50, -50, -50, -51, -53,
-54, -54, -54, -55, -56, -56, -57, -58, -58, -59, -61, -61, -60, -62, -62, -63,
-64, -64, -65, -66, -66, -67, -67, -68, -69, -70, -71, -71, -71, -72, -73, -73,
-74, -74, -76, -75, -76, -77, -77, -78, -78, -79, -79, -80, -81, -81, -82, -83,
-84, -84, -84, -85, -85, -86, -86, -87, -89, -89, -89, -90, -91, -90, -91, -92,
-92, -93, -94, -94, -95, -96, -96, -96, -97, -97, -98, -99, -99, -99, -100, -97,
-98, -96, -97, -96, -95, -94, -94, -93, -93, -92, -92, -92, -90, -90, -90, -89,
-89, -88, -87, -87, -87, -85, -84, -84, -83, -83, -82, -82, -81, -80, -80, -79,
-78, -78, -78, -77, -76, -76, -75, -74, -74, -73, -71, -71, -71, -70, -69, -69,
-69, -68, -67, -66, -66, -66, -64, -64, -63, -62, -62, -61, -60, -60, -59, -57,
-57, -56, -56, -54, -55, -54, -53, -52, -51, -51, -50, -50, -49, -48, -47, -46,
-46, -44, -44, -43, -43, -42, -42, -41, -39, -39, -38, -37, -36, -36, -35, -34,
-33, -33, -32, -32, -30, -30, -28, -28, -26, -26, -24, -25, -23, -23, -21, -20,
-19, -20, -19, -17, -17, -15, -15, -14, -13, -12, -12, -9, -10, -7, -10, 3, 29,
13, 12, 10, 10, 8, 8, 7, 6, 4, 3, 4, 1, 1, 0, -1, -2, -2, -4, -4, -5, -5, };