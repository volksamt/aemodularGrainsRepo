#define DATA_LENGTH 512
#define DATA AKWF_0733

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 10, 15, 20, 24, 28, 33, 37, 41,
46, 50, 55, 59, 64, 69, 73, 78, 82, 87, 91, 95, 100, 105, 109, 114, 115, 110,
106, 101, 97, 92, 88, 83, 79, 75, 69, 65, 60, 56, 52, 47, 42, 38, 32, 28, 24,
19, 15, 11, 6, 2, -3, -7, -12, -16, -14, -14, -14, -15, -15, -15, -14, -15, -14,
-15, -15, -14, -14, -14, -14, -15, -14, -15, -14, -15, -15, -15, -15, -15, -15,
-15, -14, -14, -14, -15, -15, -15, -14, -14, -15, -15, -15, -15, -15, -15, -14,
-15, -15, -14, -15, -15, -14, -15, -14, -15, -15, -15, -15, -15, -15, -14, -15,
-15, -15, -15, -15, -15, -15, -15, -15, -16, -14, -14, -15, -15, -15, -15, -15,
-15, -15, -14, -15, -15, -16, -14, -15, -14, -15, -14, -15, -15, -15, -14, -14,
-15, -15, -15, -15, -15, -15, -14, -15, -14, -14, -15, -14, -14, -14, -15, -15,
-15, -14, -14, -15, -15, -15, -14, -14, -15, -15, -14, -15, -15, -15, -15, -15,
-15, -15, -14, -15, -15, -15, -15, -14, -14, -14, -14, -14, -15, -14, -14, -15,
-14, -14, -15, -14, -15, -14, -14, -14, -15, -14, -15, -14, -15, -14, -15, -14,
-15, -14, -15, -14, -15, -14, -14, -15, -15, -14, -15, -15, -14, -14, -14, -14,
-14, -14, -14, -15, -15, -15, -14, -15, -14, -15, -15, -14, -14, -15, -14, -14,
-14, -15, -15, -14, -14, -15, -14, -14, -15, -15, -15, -15, -15, -14, -14, -14,
-15, -13, -15, -14, -15, -10, -5, 0, 4, 9, 13, 18, 22, 27, 32, 36, 40, 46, 51,
54, 61, 61, 72, 68, 90, 26, -19, 3, -3, 9, 8, 16, 17, 24, 27, 32, 36, 42, 45,
50, 55, 58, 63, 67, 72, 76, 80, 85, 90, 94, 99, 103, 108, 112, 113, 107, 103,
97, 94, 89, 86, 80, 76, 71, 67, 63, 59, 53, 49, 45, 41, 36, 31, 27, 22, 19, 14,
10, 5, 1, -3, -8, -12, -15, -15, -16, -15, -15, -15, -15, -15, -15, -15, -14,
-15, -14, -14, -15, -15, -15, -15, -15, -14, -14, -14, -15, -15, -15, -15, -15,
-15, -14, -15, -15, -14, -15, -15, -14, -15, -14, -15, -15, -15, -15, -16, -15,
-14, -15, -15, -15, -15, -15, -15, -15, -14, -15, -15, -15, -16, -14, -14, -15,
-14, -15, -14, -14, -15, -14, -15, -14, -15, -15, -15, -14, -14, -15, -15, -15,
-14, -15, -15, -15, -15, -15, -15, -15, -15, -15, -16, -15, -15, -15, -14, -14,
-14, -14, -15, -14, -15, -15, -20, -24, -29, -33, -38, -42, -47, -52, -56, -62,
-65, -71, -73, -80, -82, -90, -90, -100, -98, -110, -106, -123, -101, -9, -18,
-15, -15, -16, -15, -16, -15, -17, -16, -17, -16, -18, -16, -18, -17, -17, -17,
-18, -18, -18, -19, -19, -19, -18, -21, -18, -22, -38, -18, -19, -19, -19, -18,
-18, -18, -19, -16, -10, -7, 0, 3, 9, 12, 19, 21, 28, 29, 42, 4, -12, 1, };