#define DATA_LENGTH 512
#define DATA AKWF_0701

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 28, 36, 43, 45, 50, 51, 56, 56, 60,
60, 63, 62, 66, 64, 68, 66, 67, 68, 68, 70, 67, 73, 65, 76, 59, 94, -50, -128,
-84, -99, -76, -83, -68, -71, -60, -62, -53, -52, -47, -45, -40, -37, -35, -31,
-30, -26, -24, -19, -20, -16, -15, -11, -10, -7, -6, -3, -2, 2, 2, 5, 5, 7, 9,
11, 12, 14, 14, 16, 18, 18, 20, 21, 22, 23, 24, 25, 27, 27, 28, 29, 30, 30, 32,
32, 33, 33, 34, 35, 36, 36, 37, 38, 38, 38, 39, 39, 40, 40, 40, 41, 41, 41, 41,
42, 42, 42, 42, 42, 43, 43, 43, 43, 42, 42, 39, 36, 35, 32, 32, 29, 28, 27, 26,
24, 24, 23, 21, 20, 20, 18, 18, 17, 16, 15, 14, 12, 11, 11, 10, 9, 9, 8, 7, 7,
6, 5, 4, 4, 3, 3, 2, 1, 2, 1, 0, -1, -2, -2, -2, -4, -3, -4, -5, -5, -5, -6, -7,
-8, -7, -9, -8, -9, -9, -9, -11, -11, -11, -11, -12, -12, -12, -12, -13, -13,
-13, -15, -15, -15, -15, -16, -16, -16, -17, -16, -17, -18, -18, -18, -17, -19,
-19, -19, -19, -19, -19, -20, -20, -20, -21, -20, -21, -21, -21, -21, -22, -22,
-22, -23, -21, -22, -22, -23, -22, -23, -23, -24, -23, -24, -23, -23, -24, -23,
-24, -24, -24, -24, -25, -24, -24, -24, -24, -24, -24, -25, -25, -25, -25, -25,
-24, -25, -25, -24, -24, -25, -25, -25, -25, -25, -24, -24, -25, -24, -24, -24,
-25, -24, -25, -24, -25, -24, -25, -25, -25, -25, -24, -24, -25, -24, -24, -24,
-25, -24, -25, -25, -24, -24, -24, -25, -25, -25, -24, -24, -24, -24, -24, -24,
-24, -24, -24, -24, -24, -24, -25, -24, -24, -24, -24, -24, -24, -24, -24, -24,
-25, -24, -24, -24, -23, -24, -24, -24, -24, -24, -24, -24, -24, -24, -24, -23,
-24, -24, -24, -24, -25, -24, -24, -25, -24, -24, -24, -24, -25, -25, -25, -24,
-25, -24, -24, -25, -23, -24, -24, -24, -25, -24, -24, -24, -25, -25, -24, -24,
-25, -24, -24, -24, -24, -24, -24, -24, -24, -25, -24, -24, -24, -24, -25, -24,
-25, -23, -25, -25, -24, -24, -25, -25, -25, -24, -24, -24, -24, -24, -24, -24,
-24, -25, -25, -24, -23, -24, -24, -24, -24, -24, -23, -25, -24, -25, -24, -24,
-23, -24, -24, -23, -24, -24, -24, -24, -24, -23, -23, -25, -24, -24, -24, -24,
-24, -24, -24, -24, -24, -24, -25, -24, -24, -24, -24, -24, -24, -24, -25, -24,
-24, -23, -24, -24, -24, -23, -23, -24, -25, -25, -24, -24, -24, -24, -25, -24,
-24, -24, -23, -23, -23, -24, -24, -24, -24, -24, -24, -24, -24, -23, -23, -24,
-24, -24, -25, -23, -25, -23, -24, -25, -24, -24, -24, -24, -23, -24, -23, -24,
-24, -24, -24, -24, -24, -24, -24, -24, -24, -23, -18, -16, -14, -13, -10, -10,
-9, -7, -6, -4, -3, -2, 0, };