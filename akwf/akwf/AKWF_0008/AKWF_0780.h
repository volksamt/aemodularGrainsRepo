#define DATA_LENGTH 512
#define DATA AKWF_0780

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 11, 16, 21, 25, 29, 33, 36, 39,
43, 47, 48, 52, 54, 57, 59, 61, 63, 66, 68, 68, 71, 74, 75, 77, 77, 79, 81, 82,
83, 84, 85, 86, 88, 89, 90, 92, 92, 92, 93, 94, 95, 95, 97, 97, 98, 99, 99, 100,
101, 100, 101, 102, 102, 104, 104, 105, 105, 106, 106, 106, 107, 107, 108, 108,
109, 109, 109, 110, 110, 110, 111, 111, 112, 111, 111, 111, 112, 113, 113, 113,
113, 114, 114, 114, 114, 115, 115, 115, 114, 115, 115, 116, 117, 116, 117, 117,
116, 116, 116, 116, 116, 117, 117, 117, 116, 117, 118, 117, 117, 117, 117, 117,
117, 117, 117, 117, 117, 117, 117, 117, 117, 118, 117, 118, 118, 118, 117, 117,
117, 117, 118, 118, 118, 118, 118, 117, 118, 117, 118, 118, 117, 117, 118, 117,
118, 118, 118, 117, 118, 117, 117, 117, 118, 117, 117, 118, 117, 118, 117, 117,
118, 118, 117, 117, 117, 117, 116, 117, 117, 118, 117, 116, 117, 117, 118, 118,
117, 118, 117, 116, 118, 117, 117, 118, 117, 117, 117, 117, 117, 116, 117, 117,
117, 116, 117, 117, 117, 117, 117, 117, 118, 117, 117, 116, 117, 117, 117, 116,
116, 116, 117, 116, 116, 117, 117, 117, 116, 117, 116, 117, 117, 116, 116, 117,
116, 116, 116, 116, 116, 117, 115, 116, 116, 116, 117, 116, 117, 115, 118, 115,
118, 113, 119, 114, 119, 113, 120, 112, 121, 111, 122, 110, 124, 102, -115,
-123, -115, -123, -116, -122, -115, -123, -116, -122, -115, -121, -117, -122,
-117, -121, -117, -121, -118, -119, -119, -120, -120, -119, -119, -119, -119,
-118, -120, -118, -119, -118, -119, -118, -119, -119, -119, -118, -119, -119,
-119, -118, -118, -119, -119, -119, -118, -118, -119, -120, -118, -119, -119,
-118, -119, -118, -119, -119, -118, -119, -118, -119, -119, -118, -118, -119,
-118, -119, -118, -118, -118, -118, -119, -118, -119, -119, -118, -118, -119,
-119, -118, -119, -119, -119, -118, -118, -119, -118, -118, -119, -118, -118,
-118, -118, -118, -118, -118, -118, -118, -118, -118, -119, -118, -118, -117,
-118, -118, -118, -118, -118, -118, -117, -118, -117, -117, -118, -117, -118,
-117, -117, -117, -117, -117, -117, -117, -117, -117, -117, -117, -117, -117,
-117, -117, -117, -117, -117, -116, -117, -117, -116, -117, -117, -117, -117,
-116, -116, -116, -115, -115, -116, -116, -115, -115, -115, -115, -116, -115,
-115, -115, -114, -115, -115, -114, -114, -114, -114, -113, -113, -113, -113,
-112, -112, -112, -112, -111, -111, -111, -111, -110, -110, -110, -109, -109,
-109, -109, -107, -108, -107, -107, -106, -106, -105, -106, -105, -105, -104,
-103, -104, -102, -102, -101, -101, -100, -99, -100, -99, -97, -98, -96, -96,
-94, -94, -94, -93, -92, -91, -90, -89, -89, -87, -87, -86, -85, -83, -82, -80,
-79, -78, -77, -76, -75, -73, -71, -70, -67, -66, -64, -62, -60, -58, -55, -54,
-51, -48, -45, -43, -39, -35, -33, -29, -26, -21, -17, -11, -8, -2, };