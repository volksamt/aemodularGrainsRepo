#define DATA_LENGTH 512
#define DATA AKWF_0746

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 13, 17, 20, 23, 26, 29,
32, 34, 37, 40, 43, 45, 46, 49, 51, 52, 54, 57, 58, 59, 61, 62, 63, 63, 64, 65,
66, 64, 65, 65, 65, 65, 65, 65, 64, 64, 64, 64, 63, 63, 63, 63, 62, 62, 62, 62,
62, 63, 63, 63, 64, 65, 65, 66, 67, 68, 69, 71, 72, 73, 75, 76, 78, 80, 80, 83,
84, 86, 88, 90, 92, 93, 95, 97, 99, 101, 103, 104, 105, 107, 108, 109, 110, 110,
110, 111, 112, 110, 110, 109, 108, 106, 104, 104, 102, 99, 97, 94, 91, 90, 87,
85, 82, 79, 77, 75, 72, 72, 70, 67, 67, 66, 66, 65, 65, 65, 65, 65, 66, 67, 67,
69, 70, 71, 72, 74, 74, 77, 77, 78, 80, 81, 82, 83, 85, 85, 87, 87, 88, 89, 88,
89, 89, 90, 90, 89, 88, 88, 87, 87, 86, 86, 84, 84, 82, 80, 79, 78, 76, 74, 72,
71, 69, 68, 65, 63, 61, 60, 57, 55, 54, 53, 52, 49, 48, 47, 45, 44, 43, 43, 43,
42, 40, 40, 40, 40, 39, 39, 39, 40, 40, 39, 40, 41, 42, 42, 43, 43, 44, 45, 46,
47, 46, 48, 49, 49, 50, 49, 50, 51, 51, 50, 50, 49, 48, 48, 46, 44, 42, 40, 38,
35, 33, 30, 27, 24, 21, 18, 15, 11, 8, 5, 2, -1, -3, -5, -7, -9, -11, -13, -14,
-15, -15, -15, -16, -15, -15, -15, -14, -14, -13, -12, -11, -10, -10, -8, -8,
-6, -5, -4, -3, -3, -3, -2, -1, 0, 0, 0, 1, 0, 1, 1, 0, 0, 0, -2, -2, -3, -4,
-5, -5, -8, -9, -10, -11, -13, -14, -17, -19, -21, -22, -25, -26, -28, -30, -32,
-34, -35, -37, -38, -40, -41, -42, -43, -44, -44, -46, -46, -47, -47, -47, -47,
-48, -48, -48, -47, -47, -47, -46, -46, -46, -45, -44, -44, -43, -43, -42, -41,
-41, -40, -39, -40, -39, -38, -38, -38, -38, -39, -39, -40, -41, -42, -43, -45,
-47, -50, -52, -54, -57, -59, -63, -66, -70, -73, -77, -81, -84, -88, -91, -95,
-98, -101, -104, -106, -109, -111, -112, -114, -116, -118, -117, -118, -119,
-119, -118, -118, -118, -117, -117, -116, -115, -114, -113, -111, -110, -109,
-107, -107, -106, -105, -104, -103, -102, -101, -100, -99, -98, -97, -98, -97,
-96, -96, -96, -96, -96, -95, -97, -97, -96, -97, -97, -99, -99, -100, -100,
-102, -103, -103, -104, -104, -105, -107, -107, -107, -109, -109, -108, -109,
-109, -109, -109, -109, -109, -108, -108, -106, -106, -104, -103, -102, -99,
-98, -97, -94, -92, -90, -88, -86, -83, -82, -78, -75, -73, -70, -68, -64, -63,
-59, -57, -52, -51, -47, -45, -42, -39, -37, -35, -33, -32, -31, -29, -28, -27,
-26, -26, -26, -25, -25, -26, -27, -27, -28, -29, -30, -30, -31, -31, -32, -32,
-33, -34, -32, -32, -32, -32, -31, -29, -27, -26, -23, -21, -19, -16, -14, -10,
-7, -5, -2, };