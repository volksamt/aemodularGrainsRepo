#define DATA_LENGTH 512
#define DATA AKWF_0781

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 20, 32, 43, 51, 58, 65, 70, 75, 78,
81, 84, 87, 90, 92, 95, 95, 97, 98, 99, 101, 102, 102, 104, 105, 105, 106, 107,
106, 106, 107, 107, 108, 108, 108, 109, 109, 109, 109, 109, 109, 108, 109, 109,
109, 108, 109, 109, 109, 109, 109, 109, 109, 109, 108, 108, 109, 109, 109, 108,
109, 110, 109, 109, 109, 109, 109, 109, 109, 109, 109, 108, 109, 109, 109, 108,
108, 109, 109, 108, 109, 108, 108, 109, 109, 109, 108, 108, 108, 109, 108, 108,
108, 109, 108, 108, 108, 108, 108, 108, 108, 108, 109, 108, 108, 109, 108, 107,
108, 108, 108, 108, 109, 109, 108, 108, 108, 108, 108, 107, 108, 108, 108, 107,
108, 108, 108, 107, 108, 108, 108, 107, 108, 108, 109, 108, 107, 108, 107, 108,
108, 108, 108, 108, 108, 108, 108, 108, 108, 108, 108, 108, 108, 108, 107, 107,
107, 107, 107, 107, 107, 108, 108, 107, 107, 108, 107, 108, 106, 107, 107, 108,
108, 107, 108, 108, 107, 108, 107, 107, 107, 107, 108, 106, 107, 107, 108, 106,
107, 107, 107, 107, 107, 107, 107, 107, 108, 107, 108, 107, 107, 107, 107, 107,
107, 107, 107, 107, 107, 107, 107, 107, 106, 106, 106, 106, 107, 107, 107, 106,
107, 107, 107, 107, 106, 106, 107, 106, 107, 106, 107, 106, 107, 107, 106, 105,
107, 106, 106, 106, 106, 105, 106, 107, 106, 107, 106, 107, 105, 107, 105, 108,
104, 108, 104, 109, 103, 109, 103, 109, 104, 110, 104, 109, 103, 108, 105, -102,
-128, -112, -125, -114, -124, -114, -123, -116, -122, -116, -122, -116, -121,
-117, -120, -118, -119, -118, -119, -119, -119, -119, -119, -119, -118, -119,
-118, -119, -118, -120, -119, -119, -118, -120, -118, -120, -119, -119, -119,
-119, -118, -119, -118, -119, -119, -118, -119, -119, -118, -118, -119, -119,
-120, -119, -119, -119, -119, -118, -118, -118, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -118, -118, -118, -118, -118, -118, -118, -118, -118,
-118, -118, -118, -119, -118, -118, -118, -117, -118, -118, -118, -117, -118,
-118, -117, -119, -118, -118, -118, -118, -118, -118, -119, -119, -117, -118,
-117, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118,
-117, -118, -118, -118, -117, -118, -118, -117, -117, -118, -118, -117, -118,
-118, -117, -117, -118, -118, -117, -117, -117, -117, -117, -117, -117, -118,
-117, -118, -117, -118, -117, -118, -117, -117, -117, -117, -117, -117, -117,
-116, -117, -116, -117, -117, -117, -116, -117, -118, -117, -117, -117, -116,
-117, -117, -117, -117, -117, -117, -116, -117, -117, -116, -117, -116, -117,
-116, -116, -116, -117, -116, -117, -117, -117, -117, -116, -116, -116, -116,
-116, -116, -116, -116, -116, -117, -116, -117, -116, -116, -117, -116, -115,
-116, -115, -114, -115, -115, -114, -114, -114, -113, -113, -112, -112, -110,
-109, -108, -107, -106, -105, -105, -102, -100, -99, -97, -93, -91, -88, -84,
-80, -77, -71, -65, -57, -48, -36, -25, -9, };