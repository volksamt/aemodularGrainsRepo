#define DATA_LENGTH 512
#define DATA AKWF_0709

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 120, 119, 118, 120, 117, 121, 118,
120, 117, 121, 117, 121, 118, 121, 118, 120, 119, 120, 119, 120, 118, 119, 119,
120, 119, 119, 119, 119, 118, 119, 118, 119, 119, 118, 119, 119, 120, 119, 119,
118, 121, 116, 124, 92, 65, 75, 69, 72, 70, 73, 72, 72, 71, 72, 71, 71, 72, 71,
72, 71, 73, 69, 74, 68, 77, 53, 19, 26, 22, 24, 23, 25, 23, 23, 24, 23, 25, 23,
25, 22, 25, 22, 27, 19, 39, 66, 76, 61, 20, 25, 24, 24, 23, 23, 24, 23, 25, 23,
25, 23, 24, 23, 25, 23, 24, 23, 24, 23, 24, 24, 24, 24, 24, 24, 23, 25, 23, 24,
23, 24, 23, 25, 22, 25, 23, 26, 21, 54, 62, 18, 28, 6, -22, -25, -24, -24, -25,
-23, -24, -24, -24, -24, -24, -23, -24, -23, -24, -23, -23, -23, -24, -23, -24,
-24, -25, -23, -24, -24, -25, -24, -23, -24, -24, -23, -24, -24, -25, -23, -27,
-13, 51, 75, 69, 72, 70, 72, 71, 72, 71, 72, 71, 72, 71, 72, 71, 71, 72, 70, 73,
70, 73, 68, 78, 50, 19, 26, 22, 24, 23, 24, 24, 24, 25, 24, 24, 23, 24, 23, 25,
23, 24, 23, 25, 22, -20, -26, -23, -25, -24, -25, -23, -24, -23, -24, -23, -25,
-23, -24, -24, -23, -24, -24, -24, -24, -23, -24, -23, -24, -23, -25, -24, -24,
-23, -24, -23, -24, -24, -24, -24, -23, -24, -24, -25, -22, -25, 62, 121, 121,
91, 65, 75, 68, 75, 60, 30, 22, 25, 23, 24, 24, 24, 24, 24, 24, 24, 25, 23, 24,
23, 24, 23, 24, 23, 24, 23, 25, 24, 25, 23, 24, 24, 24, 24, 24, 24, 23, 25, 22,
28, -8, -29, -20, -25, -23, -26, -22, -26, -23, -24, -23, -25, -24, -23, -24,
-24, -24, -23, -25, -22, -27, -18, -48, -77, -68, -73, -70, -72, -71, -72, -71,
-72, -71, -71, -72, -71, -72, -71, -72, -69, -76, -37, 23, 23, 24, 24, 23, 24,
24, 24, 24, 24, 23, 24, 23, 24, 24, 24, 24, 24, 23, 24, 24, 24, 23, 24, 23, 24,
24, 24, 24, 24, 24, 24, 25, 23, 25, 23, 25, 23, 25, 22, 26, 21, 59, 55, 16, 30,
1, -24, -24, -24, -25, -23, -23, -25, -24, -24, -24, -24, -24, -24, -24, -24,
-23, -24, -23, -24, -24, -24, -24, -24, -23, -24, -23, -24, -23, -24, -23, -24,
-23, -24, -23, -25, -22, -26, -15, 16, 27, 20, -22, -25, -22, -25, -22, -24,
-22, -25, -23, -25, -23, -24, -23, -23, -23, -23, -24, -22, -26, -18, -50, -77,
-69, -74, -70, -72, -71, -71, -71, -71, -72, -71, -73, -71, -73, -70, -73, -70,
-73, -70, -77, -120, -119, -119, -120, -119, -120, -119, -119, -119, -120, -118,
-119, -119, -119, -120, -118, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -120, -118, -121, -117, -121, -118, -121, -116, -122, -116,
-123, -114, -126, -102, };