#define DATA_LENGTH 512
#define DATA AKWF_0758

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 7, 10, 12, 15, 17, 20, 23,
24, 27, 30, 32, 35, 39, 41, 44, 46, 49, 52, 55, 58, 61, 65, 67, 69, 72, 74, 77,
80, 83, 85, 87, 90, 91, 93, 95, 97, 98, 100, 101, 103, 103, 104, 105, 106, 106,
107, 107, 106, 107, 107, 107, 106, 106, 106, 105, 105, 104, 103, 102, 102, 101,
101, 99, 99, 97, 98, 95, 94, 93, 93, 91, 90, 89, 88, 86, 85, 84, 83, 82, 80, 79,
78, 77, 76, 74, 73, 72, 71, 69, 68, 67, 66, 65, 63, 62, 61, 60, 59, 58, 57, 56,
54, 53, 52, 51, 49, 48, 47, 46, 45, 43, 41, 40, 38, 36, 35, 33, 32, 30, 28, 26,
24, 22, 20, 17, 15, 13, 11, 9, 6, 4, 2, -1, -3, -5, -9, -11, -13, -15, -17, -21,
-22, -25, -28, -29, -32, -34, -37, -40, -42, -44, -47, -48, -51, -53, -56, -59,
-60, -63, -64, -67, -69, -71, -73, -75, -77, -79, -81, -84, -86, -87, -89, -91,
-93, -95, -96, -98, -99, -101, -102, -104, -105, -107, -108, -110, -111, -112,
-113, -114, -116, -116, -118, -118, -118, -118, -119, -119, -119, -118, -118,
-118, -118, -117, -116, -115, -113, -112, -111, -109, -107, -106, -103, -102,
-101, -98, -96, -94, -91, -89, -86, -84, -81, -79, -77, -74, -71, -68, -65, -63,
-61, -58, -55, -52, -49, -47, -45, -42, -40, -36, -33, -32, -28, -26, -24, -22,
-19, -17, -13, -12, -10, -7, -5, -3, 0, 2, 5, 7, 9, 12, 14, 16, 19, 22, 24, 27,
30, 32, 35, 37, 41, 42, 46, 50, 51, 55, 58, 60, 64, 66, 69, 72, 75, 78, 80, 83,
85, 87, 89, 91, 93, 95, 96, 99, 100, 101, 101, 103, 103, 104, 106, 106, 106,
107, 107, 107, 107, 107, 106, 106, 105, 106, 105, 104, 104, 103, 102, 101, 100,
99, 99, 97, 96, 96, 94, 93, 91, 90, 90, 89, 88, 86, 85, 83, 83, 82, 80, 79, 77,
76, 75, 74, 73, 72, 70, 69, 68, 67, 66, 65, 64, 62, 62, 60, 59, 57, 57, 56, 55,
53, 52, 51, 50, 49, 47, 46, 44, 43, 41, 39, 38, 37, 34, 33, 32, 30, 28, 26, 24,
21, 20, 18, 15, 13, 10, 8, 6, 4, 2, -1, -3, -6, -8, -11, -13, -16, -18, -20,
-23, -26, -28, -30, -32, -35, -37, -40, -42, -45, -46, -50, -52, -53, -57, -59,
-61, -63, -65, -67, -70, -71, -74, -75, -78, -79, -82, -84, -85, -87, -89, -90,
-93, -94, -96, -99, -100, -101, -103, -104, -106, -107, -109, -109, -112, -112,
-113, -115, -115, -117, -117, -117, -119, -118, -119, -119, -119, -119, -118,
-119, -117, -116, -115, -114, -114, -112, -110, -108, -107, -105, -103, -101,
-98, -97, -94, -93, -91, -88, -85, -82, -80, -77, -75, -73, -70, -68, -65, -62,
-59, -57, -54, -51, -48, -45, -42, -40, -39, -36, -33, -29, -28, -25, -23, -20,
-18, -15, -13, -10, -8, -6, -3, -1, };