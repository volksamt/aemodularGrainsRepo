#define DATA_LENGTH 512
#define DATA AKWF_0755

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 11, 24, 33, 37, 40, 40, 37, 40, 47,
58, 67, 68, 44, 7, 0, 27, 40, 37, 38, 40, 39, 38, 43, 48, 56, 50, 16, -29, -41,
-32, -36, -40, -36, -21, 16, 37, 18, -7, -21, -29, -22, -19, -31, -40, -41, -39,
-38, -39, -44, -53, -63, -72, -79, -88, -95, -102, -108, -114, -118, -118, -113,
-104, -99, -91, -85, -76, -68, -58, -49, -41, -37, -38, -40, -41, -38, -31, -23,
-14, -6, -2, -3, -5, -4, -3, -4, -4, -3, 2, 12, 24, 34, 37, 41, 39, 28, 12, 14,
32, 40, 39, 40, 38, 38, 41, 48, 59, 68, 76, 84, 92, 99, 105, 111, 115, 112, 105,
97, 89, 83, 74, 66, 56, 48, 41, 37, 37, 39, 40, 36, 31, 22, 12, 3, -5, -7, -4,
-4, -4, -4, -4, -4, -5, -4, -5, -4, -4, -4, -5, -4, -4, -4, -4, -4, -5, -5, -4,
-4, -4, -4, -4, -4, -4, -5, -5, -4, -4, -4, -5, -4, -5, -5, -5, -5, -4, -4, -4,
-5, -4, -5, -4, -4, -5, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -5, -5, -5, -4,
-4, -5, -5, -4, -5, -4, -5, -5, -4, -4, -4, -4, -4, -5, -4, -5, -4, -4, -4, -4,
-4, -5, -4, -4, -4, -5, -4, -4, -4, -4, -4, -4, -4, -5, -5, -4, -4, -4, -4, -4,
-4, -4, -4, -5, -4, -4, -4, -4, -5, -4, -4, -4, -4, -4, -5, -4, -4, -5, -5, -4,
-4, -5, -4, -4, -5, -4, -4, -5, -5, -4, -5, -4, -5, -4, -5, -4, -5, -4, -4, -5,
-4, -4, -4, -5, -5, -5, -4, -5, -5, -5, -5, -5, -5, -5, -4, -4, -4, -4, -4, -5,
-4, -5, -4, -4, -4, -4, -4, -5, -4, -4, -4, -4, -4, -4, -5, -4, -4, -5, -4, -5,
-4, -5, -4, -4, -4, -5, -4, -4, -4, -5, -5, -5, -4, -4, -4, -5, -4, -4, -5, -4,
-5, -4, -4, -4, -4, -4, -5, -4, -4, -4, -4, -4, -5, -4, -3, -5, -4, -4, -4, -5,
-4, -4, -4, -4, -4, -4, -4, -5, -4, -5, -4, -4, -5, -4, -4, -3, -5, -4, -5, -4,
-4, -4, -4, -5, -5, -4, -3, -4, -5, -4, -4, -5, -4, -4, -4, -4, -5, -4, -5, -4,
-3, -5, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -5, -4, -4, -5, -4,
-5, -4, -4, -5, -4, -4, -5, -4, -4, -4, -4, -4, -4, -4, -4, -4, -5, -5, -4, -4,
-4, -5, -4, -4, -4, -4, -4, -5, -4, -4, -4, -4, -5, -4, -5, -5, -4, -4, -5, -4,
-4, -4, -4, -4, -4, -4, -4, -5, -4, -4, -4, -4, -4, -4, -4, -5, -4, -4, -4, -4,
-4, -5, -4, -4, -4, -4, -5, -5, -4, -4, -5, -4, -4, -4, -5, -3, -4, -4, -5, -5,
-4, -4, -4, -4, -4, -4, -3, -5, -4, -4, -4, -4, -4, -4, -2, };