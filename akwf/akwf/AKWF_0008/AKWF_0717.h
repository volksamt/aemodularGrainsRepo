#define DATA_LENGTH 512
#define DATA AKWF_0717

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 9, 10, 12, 14, 16, 17, 19,
21, 22, 24, 25, 26, 28, 28, 30, 31, 32, 33, 35, 36, 36, 38, 38, 39, 40, 41, 41,
42, 43, 43, 44, 45, 44, 45, 46, 47, 47, 47, 47, 48, 47, 48, 48, 49, 48, 49, 45,
61, 77, 80, 87, 90, 93, 96, 99, 101, 104, 105, 107, 109, 110, 111, 113, 113,
115, 115, 117, 117, 118, 118, 118, 118, 120, 116, 95, 89, 83, 78, 76, 72, 69,
66, 63, 61, 59, 56, 55, 52, 51, 49, 48, 46, 44, 42, 42, 40, 38, 37, 36, 36, 34,
33, 32, 31, 30, 30, 28, 28, 26, 25, 24, 23, 23, 23, 21, 21, 20, 20, 19, 19, 18,
18, 18, 16, 16, 16, 15, 15, 15, 14, 14, 14, 14, 13, 13, 13, 13, 12, 13, 12, 13,
11, 12, 12, 10, 5, 5, 4, 2, -1, -7, -8, -9, -10, -18, -22, -24, -26, -27, -28,
-29, -29, -29, -30, -39, -48, -50, -54, -55, -58, -59, -61, -62, -64, -64, -65,
-66, -67, -68, -69, -69, -69, -70, -71, -71, -71, -72, -71, -77, -79, -80, -82,
-83, -84, -85, -86, -85, -87, -88, -88, -87, -88, -89, -90, -90, -90, -90, -91,
-91, -92, -91, -92, -92, -93, -93, -94, -93, -93, -93, -94, -94, -94, -94, -94,
-95, -95, -95, -95, -95, -95, -96, -95, -95, -94, -97, -94, -99, -85, -59, -53,
-44, -40, -34, -30, -26, -22, -19, -16, -12, -9, -7, -4, -3, 1, 3, 5, 7, 9, 10,
13, 15, 16, 17, 20, 21, 22, 24, 26, 26, 28, 30, 30, 33, 33, 34, 35, 35, 37, 39,
39, 40, 41, 41, 42, 42, 43, 44, 44, 45, 46, 45, 46, 46, 46, 47, 47, 47, 48, 48,
48, 47, 49, 47, 64, 78, 81, 87, 90, 94, 96, 99, 101, 104, 105, 107, 109, 111,
112, 113, 114, 116, 116, 117, 118, 118, 117, 120, 118, 120, 114, 94, 88, 82, 78,
73, 71, 69, 65, 63, 60, 58, 56, 55, 52, 51, 49, 47, 46, 44, 43, 42, 39, 38, 38,
36, 35, 34, 33, 32, 31, 31, 28, 28, 27, 27, 25, 24, 23, 23, 22, 22, 21, 20, 20,
19, 18, 18, 18, 18, 17, 16, 16, 16, 16, 15, 14, 14, 14, 14, 13, 13, 13, 12, 13,
13, 12, 12, 12, 12, 13, 9, 4, 5, 4, 1, -2, -6, -8, -9, -10, -19, -22, -23, -25,
-26, -29, -28, -29, -30, -29, -41, -48, -51, -54, -55, -58, -59, -61, -63, -64,
-64, -67, -67, -68, -69, -69, -70, -69, -70, -71, -71, -71, -72, -71, -78, -79,
-81, -81, -83, -84, -85, -85, -86, -87, -87, -88, -88, -88, -89, -90, -90, -90,
-91, -92, -91, -92, -91, -93, -92, -93, -94, -93, -93, -94, -94, -94, -94, -94,
-94, -95, -95, -95, -96, -95, -95, -95, -96, -95, -96, -95, -97, -94, -99, -81,
-56, -51, -42, -39, -32, -28, -24, -21, -16, -14, -11, -8, -5, -3, -1, };