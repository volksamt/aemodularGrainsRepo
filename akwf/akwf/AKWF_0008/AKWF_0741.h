#define DATA_LENGTH 512
#define DATA AKWF_0741

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 5, 9, 10, 12, 15, 17, 19, 21,
23, 25, 27, 29, 31, 33, 35, 37, 39, 40, 43, 44, 45, 47, 49, 50, 52, 52, 54, 55,
58, 59, 60, 60, 62, 62, 64, 65, 65, 67, 68, 69, 69, 70, 71, 70, 72, 73, 72, 74,
74, 75, 74, 75, 76, 75, 76, 76, 77, 77, 78, 77, 77, 78, 77, 78, 77, 77, 78, 77,
78, 77, 76, 77, 77, 77, 77, 77, 76, 76, 76, 75, 75, 76, 75, 75, 74, 74, 73, 73,
73, 73, 72, 72, 71, 71, 71, 71, 71, 70, 69, 69, 70, 69, 69, 69, 68, 68, 68, 68,
67, 67, 67, 67, 66, 67, 67, 67, 66, 66, 66, 66, 65, 65, 66, 65, 66, 66, 65, 65,
65, 65, 65, 66, 65, 65, 66, 66, 66, 66, 66, 65, 66, 66, 67, 66, 66, 68, 67, 67,
68, 68, 68, 68, 68, 68, 68, 69, 69, 69, 69, 71, 70, 71, 71, 72, 71, 71, 71, 72,
73, 73, 74, 73, 73, 74, 74, 75, 74, 74, 75, 76, 76, 75, 76, 76, 77, 78, 77, 77,
78, 78, 79, 79, 78, 80, 80, 80, 80, 80, 80, 80, 81, 81, 81, 82, 81, 82, 82, 81,
82, 81, 82, 82, 82, 82, 82, 83, 83, 82, 83, 83, 83, 83, 83, 83, 82, 83, 83, 82,
82, 83, 82, 83, 83, 83, 82, 82, 83, 82, 82, 83, 81, 81, 82, 81, 82, 81, 81, 82,
81, 81, 80, 81, 80, 80, 80, 80, 80, 79, 79, 79, 79, 78, 78, 77, 78, 77, 76, 77,
76, 75, 75, 74, 74, 73, 72, 71, 71, 70, 69, 69, 68, 67, 65, 64, 63, 63, 62, 60,
60, 58, 57, 56, 55, 53, 52, 51, 49, 48, 47, 45, 43, 41, 41, 38, 37, 35, 34, 31,
30, 28, 26, 24, 22, 21, 18, 17, 15, 13, 11, 9, 7, 5, 3, 1, -1, -3, -5, -8, -9,
-12, -13, -15, -18, -19, -22, -24, -25, -27, -29, -31, -33, -35, -37, -39, -41,
-43, -44, -47, -47, -50, -52, -53, -55, -56, -58, -60, -63, -63, -65, -66, -68,
-69, -71, -73, -74, -76, -77, -77, -79, -81, -82, -83, -84, -85, -87, -88, -88,
-90, -91, -92, -94, -94, -95, -96, -97, -98, -98, -99, -101, -100, -102, -102,
-103, -104, -104, -104, -106, -107, -106, -108, -108, -108, -108, -109, -110,
-110, -111, -112, -112, -112, -112, -113, -113, -113, -114, -114, -114, -115,
-115, -116, -116, -117, -117, -117, -117, -118, -118, -118, -118, -119, -119,
-119, -119, -118, -119, -119, -119, -119, -119, -119, -118, -118, -118, -117,
-118, -116, -117, -116, -115, -114, -114, -114, -112, -113, -111, -110, -110,
-108, -108, -106, -105, -103, -103, -101, -100, -99, -97, -95, -94, -92, -91,
-89, -86, -84, -83, -80, -79, -76, -75, -73, -70, -69, -66, -63, -62, -59, -57,
-55, -52, -50, -48, -45, -42, -40, -37, -35, -32, -30, -27, -25, -23, -20, -17,
-15, -14, -10, -8, -6, -3, -1, };