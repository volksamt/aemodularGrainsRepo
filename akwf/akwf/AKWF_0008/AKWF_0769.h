#define DATA_LENGTH 512
#define DATA AKWF_0769

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 11, 18, 25, 33, 39, 45, 51, 58, 65,
68, 73, 79, 81, 85, 89, 91, 92, 93, 94, 94, 93, 93, 92, 90, 88, 86, 86, 84, 83,
82, 80, 79, 77, 75, 74, 71, 70, 67, 66, 65, 65, 65, 64, 64, 63, 63, 62, 61, 60,
60, 60, 61, 61, 62, 63, 63, 64, 64, 65, 65, 66, 67, 68, 68, 69, 69, 69, 70, 69,
68, 66, 65, 62, 60, 60, 57, 55, 52, 49, 46, 43, 41, 40, 37, 35, 31, 27, 25, 23,
21, 17, 16, 15, 14, 13, 12, 13, 13, 15, 14, 16, 18, 19, 21, 23, 25, 28, 30, 31,
32, 33, 35, 36, 37, 37, 36, 36, 36, 37, 38, 39, 38, 39, 40, 41, 42, 42, 44, 44,
45, 46, 45, 44, 43, 42, 40, 40, 38, 37, 36, 35, 34, 34, 33, 30, 29, 25, 24, 21,
18, 18, 15, 13, 11, 8, 4, -1, -5, -9, -14, -18, -22, -25, -28, -32, -34, -36,
-39, -40, -41, -43, -44, -47, -49, -50, -52, -52, -53, -52, -53, -52, -50, -50,
-48, -47, -46, -44, -43, -39, -37, -33, -29, -24, -19, -14, -8, -4, 1, 5, 10,
15, 21, 27, 32, 38, 43, 47, 51, 55, 59, 61, 63, 64, 65, 65, 64, 63, 62, 60, 59,
58, 56, 54, 51, 46, 44, 39, 35, 33, 29, 27, 24, 21, 20, 17, 13, 10, 8, 5, 4, 0,
-4, -7, -12, -16, -20, -25, -27, -31, -35, -38, -40, -43, -46, -49, -51, -53,
-56, -57, -57, -58, -58, -60, -60, -59, -59, -59, -58, -56, -56, -53, -52, -49,
-48, -47, -44, -42, -38, -34, -32, -27, -23, -18, -12, -6, -1, 3, 7, 11, 15, 19,
24, 29, 34, 38, 42, 47, 51, 55, 61, 64, 69, 73, 77, 80, 82, 84, 87, 88, 89, 90,
92, 92, 92, 92, 91, 90, 87, 87, 85, 83, 80, 76, 73, 70, 66, 63, 60, 55, 53, 50,
47, 45, 43, 41, 39, 35, 31, 29, 25, 23, 18, 14, 9, 5, 1, -4, -10, -15, -20, -26,
-32, -37, -44, -49, -53, -58, -62, -67, -74, -78, -82, -83, -86, -88, -88, -90,
-91, -91, -91, -90, -90, -90, -89, -89, -87, -85, -84, -82, -81, -78, -77, -76,
-74, -70, -68, -67, -65, -63, -61, -59, -58, -54, -52, -48, -46, -43, -42, -40,
-38, -37, -36, -33, -31, -28, -27, -25, -23, -22, -19, -17, -17, -15, -14, -15,
-13, -13, -12, -11, -11, -12, -12, -11, -12, -12, -14, -14, -14, -16, -17, -19,
-21, -21, -22, -23, -24, -24, -24, -25, -26, -27, -27, -27, -28, -29, -30, -31,
-31, -32, -32, -32, -33, -35, -36, -37, -40, -42, -43, -46, -49, -52, -56, -60,
-64, -67, -70, -75, -78, -83, -85, -88, -92, -94, -97, -102, -105, -108, -111,
-112, -112, -115, -115, -117, -118, -119, -119, -119, -119, -117, -116, -114,
-111, -109, -104, -101, -96, -93, -88, -83, -77, -71, -63, -56, -49, -43, -37,
-29, -21, -16, -7, -2, };