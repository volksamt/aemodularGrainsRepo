#define DATA_LENGTH 512
#define DATA AKWF_0705

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 13, 19, 24, 31, 37, 44, 50, 56, 60,
66, 72, 76, 82, 86, 90, 94, 98, 101, 105, 107, 110, 113, 114, 116, 117, 118,
119, 119, 119, 119, 118, 118, 116, 115, 113, 112, 110, 107, 105, 102, 99, 96,
93, 89, 87, 82, 79, 76, 72, 68, 64, 62, 58, 54, 50, 47, 43, 40, 38, 34, 31, 28,
25, 22, 21, 18, 16, 14, 11, 11, 8, 7, 7, 5, 4, 3, 1, 2, 0, 1, 0, 0, 0, 0, 0, 0,
1, 0, 0, 1, 1, 1, 0, 1, 1, 2, 1, 1, 1, 1, 0, 0, -1, -1, -2, -2, -4, -5, -5, -6,
-8, -9, -10, -12, -14, -15, -18, -19, -21, -22, -24, -26, -28, -30, -32, -33,
-36, -37, -39, -41, -42, -43, -44, -46, -47, -48, -49, -50, -51, -50, -51, -51,
-51, -51, -49, -50, -49, -48, -46, -46, -45, -43, -41, -39, -36, -35, -33, -31,
-28, -26, -23, -21, -18, -15, -12, -10, -7, -5, -2, 1, 3, 6, 8, 10, 13, 15, 16,
18, 20, 22, 23, 24, 25, 26, 26, 26, 27, 26, 26, 26, 26, 24, 24, 21, 20, 18, 17,
15, 12, 10, 8, 5, 2, -1, -3, -7, -10, -12, -15, -19, -22, -25, -28, -30, -33,
-37, -38, -43, -45, -46, -49, -50, -52, -55, -56, -57, -58, -60, -59, -59, -60,
-60, -59, -59, -58, -56, -55, -54, -52, -50, -47, -45, -42, -40, -37, -33, -30,
-27, -23, -20, -16, -12, -8, -3, 0, 4, 8, 11, 15, 19, 22, 27, 30, 33, 37, 40,
42, 45, 48, 49, 52, 53, 55, 57, 58, 59, 58, 59, 59, 60, 59, 58, 58, 57, 56, 54,
53, 51, 48, 46, 45, 42, 39, 37, 34, 31, 28, 26, 21, 19, 16, 12, 9, 6, 3, 0, -3,
-5, -8, -10, -12, -14, -17, -18, -20, -22, -23, -24, -24, -26, -27, -27, -27,
-26, -26, -26, -24, -24, -23, -21, -20, -19, -17, -15, -13, -11, -8, -5, -3, 0,
2, 4, 7, 10, 13, 15, 17, 20, 23, 26, 28, 31, 33, 35, 37, 39, 40, 43, 44, 45, 46,
49, 49, 49, 50, 51, 51, 51, 50, 51, 50, 50, 49, 48, 46, 46, 45, 42, 42, 40, 39,
37, 36, 33, 32, 30, 28, 26, 24, 22, 20, 19, 18, 16, 14, 12, 11, 9, 8, 6, 6, 4,
4, 3, 2, 2, 1, 1, 0, 0, -1, -1, -1, -1, -2, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, -1, -1, -1, -3, -3, -4, -5, -6, -7, -9, -10, -12, -13, -16, -18, -20,
-22, -25, -29, -31, -34, -37, -40, -44, -47, -50, -53, -58, -61, -65, -69, -72,
-75, -79, -82, -86, -90, -93, -96, -100, -102, -104, -107, -110, -111, -114,
-115, -115, -117, -118, -118, -119, -119, -119, -118, -117, -116, -114, -112,
-110, -108, -105, -102, -99, -94, -90, -86, -82, -78, -72, -67, -61, -56, -50,
-44, -39, -32, -25, -18, -13, -5, 0, };