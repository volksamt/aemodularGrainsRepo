#define DATA_LENGTH 512
#define DATA AKWF_0712

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 3, 4, 5, 6, 6, 7, 8, 9, 10,
11, 12, 12, 13, 14, 16, 15, 16, 17, 18, 19, 20, 20, 22, 23, 23, 25, 24, 26, 26,
28, 28, 29, 30, 31, 31, 33, 33, 34, 34, 36, 36, 37, 38, 39, 40, 40, 42, 42, 43,
44, 44, 46, 46, 48, 48, 48, 50, 50, 52, 53, 53, 53, 55, 55, 56, 57, 58, 59, 59,
60, 61, 61, 63, 63, 64, 66, 66, 67, 68, 68, 70, 70, 71, 71, 72, 74, 74, 75, 76,
76, 78, 79, 79, 80, 81, 81, 83, 83, 84, 85, 86, 86, 87, 88, 89, 90, 91, 91, 92,
92, 93, 95, 95, 96, 98, 97, 99, 100, 100, 102, 101, 103, 104, 104, 105, 107,
107, 108, 108, 110, 110, 111, 112, 112, 113, 115, 115, 116, 117, 118, 119, 118,
117, 116, 116, 114, 113, 111, 110, 109, 108, 108, 106, 105, 104, 103, 101, 101,
100, 99, 97, 97, 96, 95, 93, 93, 91, 90, 89, 88, 88, 87, 84, 84, 82, 82, 81, 80,
79, 78, 77, 75, 74, 74, 72, 71, 70, 69, 68, 67, 66, 65, 64, 63, 61, 60, 60, 59,
58, 56, 55, 54, 53, 52, 51, 49, 49, 48, 47, 46, 44, 44, 42, 41, 40, 39, 38, 38,
36, 34, 35, 33, 31, 31, 30, 29, 28, 27, 26, 25, 23, 22, 21, 20, 19, 18, 17, 15,
16, 14, 12, 12, 10, 10, 9, 7, 6, 5, 5, 4, 3, 1, 0, 0, -1, -3, -4, -5, -6, -7,
-9, -8, -10, -11, -12, -14, -14, -15, -16, -18, -19, -19, -20, -21, -23, -24,
-25, -26, -27, -28, -29, -30, -31, -32, -33, -33, -36, -36, -37, -39, -39, -40,
-42, -42, -44, -44, -45, -46, -48, -49, -50, -50, -51, -53, -53, -55, -56, -57,
-59, -59, -60, -61, -63, -64, -64, -65, -67, -67, -68, -69, -70, -71, -73, -73,
-74, -75, -76, -78, -79, -80, -81, -82, -83, -84, -85, -87, -87, -87, -88, -90,
-91, -92, -94, -94, -95, -96, -97, -98, -99, -100, -101, -103, -103, -105, -105,
-107, -107, -109, -110, -110, -112, -113, -113, -115, -116, -117, -118, -119,
-119, -117, -117, -116, -115, -114, -113, -112, -112, -110, -110, -109, -107,
-108, -106, -105, -105, -104, -103, -102, -102, -101, -100, -99, -98, -98, -97,
-96, -95, -93, -93, -92, -91, -90, -90, -88, -88, -87, -87, -85, -84, -84, -83,
-81, -81, -80, -79, -78, -77, -77, -76, -75, -73, -73, -72, -72, -70, -70, -69,
-69, -67, -67, -66, -64, -64, -64, -62, -62, -61, -59, -58, -58, -57, -56, -56,
-54, -54, -52, -52, -51, -51, -49, -48, -48, -46, -47, -45, -45, -44, -43, -42,
-42, -40, -39, -38, -37, -37, -36, -35, -35, -34, -33, -32, -32, -29, -29, -29,
-28, -26, -26, -25, -25, -24, -23, -22, -21, -21, -19, -18, -18, -16, -17, -15,
-14, -13, -12, -12, -11, -9, -10, -9, -7, -7, -6, -6, -4, -3, -3, -2, -1, 0, };