#define DATA_LENGTH 512
#define DATA AKWF_0751

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 10, 14, 17, 20, 19, 20, 19,
20, 19, 20, 20, 19, 20, 22, 22, 24, 25, 26, 28, 29, 31, 32, 33, 35, 35, 37, 39,
39, 41, 43, 43, 45, 47, 48, 48, 50, 51, 53, 53, 56, 57, 58, 60, 61, 62, 63, 65,
65, 67, 69, 70, 71, 72, 73, 75, 76, 77, 79, 79, 81, 82, 82, 82, 82, 82, 82, 81,
81, 81, 79, 78, 77, 74, 73, 71, 69, 68, 66, 65, 63, 61, 59, 57, 56, 54, 52, 50,
49, 47, 45, 44, 41, 40, 38, 36, 35, 34, 32, 31, 28, 26, 26, 23, 22, 20, 18, 17,
15, 14, 12, 10, 7, 7, 4, 2, 1, -1, 0, -1, 0, -1, 0, 0, 1, 0, -1, 0, 0, 1, 0, 0,
0, 1, 0, 1, 0, 0, 0, 0, 1, 1, -1, 0, 0, 0, 0, -1, 1, -1, 0, 0, 0, 0, 0, 0, 0,
-1, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 1,
3, 5, 7, 9, 11, 13, 14, 17, 19, 20, 22, 24, 26, 28, 30, 32, 33, 35, 38, 39, 41,
43, 45, 47, 49, 52, 52, 55, 56, 59, 60, 61, 64, 66, 67, 70, 72, 74, 75, 77, 80,
81, 83, 85, 88, 89, 91, 91, 91, 91, 91, 92, 92, 91, 91, 91, 91, 91, 92, 91, 92,
90, 88, 85, 84, 80, 78, 76, 73, 72, 69, 67, 64, 62, 59, 57, 55, 52, 49, 47, 45,
44, 40, 39, 35, 33, 30, 28, 26, 24, 21, 19, 16, 14, 12, 9, 6, 4, 2, -1, -2, -4,
-7, -10, -12, -14, -17, -19, -22, -23, -25, -26, -28, -30, -31, -32, -34, -36,
-37, -38, -41, -42, -43, -44, -47, -48, -49, -50, -53, -54, -55, -57, -58, -59,
-61, -63, -64, -66, -67, -68, -71, -72, -74, -75, -76, -78, -80, -81, -83, -83,
-86, -86, -88, -90, -91, -92, -94, -94, -93, -91, -88, -87, -86, -82, -81, -79,
-77, -75, -73, -71, -69, -67, -65, -64, -61, -59, -58, -55, -52, -51, -49, -47,
-45, -43, -41, -39, -37, -36, -33, -31, -29, -28, -25, -23, -21, -19, -18, -16,
-13, -11, -9, -7, -5, -3, -2, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0,
0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -2, -5, -8, -10, -12, -15,
-17, -19, -23, -25, -27, -31, -33, -35, -38, -41, -42, -46, -48, -50, -53, -56,
-58, -60, -63, -66, -69, -71, -73, -76, -79, -82, -84, -86, -89, -91, -94, -96,
-98, -102, -104, -106, -109, -112, -114, -117, -119, -119, -115, -113, -109,
-106, -103, -101, -98, -94, -92, -89, -86, -82, -80, -77, -75, -71, -69, -66,
-62, -59, -56, -54, -50, -48, -44, -42, -38, -36, -33, -29, -26, -24, -22, -19,
-16, -12, -9, -6, -4, -1, };