#define DATA_LENGTH 512
#define DATA AKWF_0711

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 125, 116, 122, 116, 122, 117,
121, 117, 120, 118, 121, 118, 120, 119, 119, 118, 119, 119, 119, 119, 119, 119,
119, 119, 118, 119, 119, 120, 118, 119, 119, 120, 119, 119, 119, 119, 118, 119,
119, 119, 119, 119, 120, 120, 118, 120, 119, 118, 119, 119, 119, 120, 119, 119,
120, 119, 119, 119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 119, 119, 118, 119, 120, 119, 119, 119, 118, 119, 119, 119, 119, 118,
118, 119, 119, 120, 119, 119, 120, 118, 120, 120, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 120, 119, 119, 119, 119, 119, 119, 119,
118, 119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 119, 120, 118, 120, 118,
120, 118, 120, 117, 121, 117, 122, 115, 123, 112, 127, 94, -9, 3, -2, 0, 0, -1,
1, 0, 2, -1, 1, -2, 0, -1, 1, -1, 0, -2, 1, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0,
0, 0, 0, 1, 0, 1, 0, 1, -1, 0, -1, 1, -1, 1, -2, 2, -7, -26, -22, -24, -24, -24,
-24, -23, -24, -24, -24, -24, -23, -23, -23, -23, -23, -24, -23, -24, -22, -25,
-21, 1, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0,
-1, 0, 0, 0, 1, 0, 0, 0, 1, -1, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0,
-1, 0, -1, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 20, 24, 23, 23, 23, 23,
23, 23, 22, 23, 23, 23, 23, 23, 23, 23, 23, 22, 0, 0, 1, 0, 0, 0, 1, 0, 0, -1,
1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, -1, 1, -1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 1, 0, 0,
-1, 0, -1, 1, -2, 2, -3, 3, -4, 5, -7, 12, -41, -127, -112, -122, -117, -120,
-117, -119, -119, -119, -119, -119, -119, -118, -119, -118, -120, -117, -120,
-118, -119, -119, -119, -118, -119, -119, -119, -118, -118, -118, -119, -119,
-119, -119, -119, -120, -118, -118, -118, -119, -119, -119, -119, -119, -118,
-118, -118, -119, -119, -119, -119, -119, -118, -118, -118, -118, -119, -118,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -118, -119, -119, -118, -119, -119, -119, -118,
-119, -119, -118, -119, -119, -118, -119, -119, -119, -118, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -118, -119, -119, -119,
-119, -119, -119, -118, -118, -118, -119, -119, -119, -119, -119, -118, -120,
-119, -120, -118, -119, -118, -119, -118, -118, -118, -119, -119, -119, -118,
-119, -120, -118, -120, -117, -121, -115, -124, -111, -128, -60, 14, -7, 5, -3,
2, -2, 1, -1, 1, 0, 0, -1, -1, 0, 0, };