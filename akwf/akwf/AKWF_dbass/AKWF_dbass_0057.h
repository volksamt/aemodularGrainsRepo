#define DATA_LENGTH 512
#define DATA AKWF_dbass_0057

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 7, 10, 11, 14, 16, 19, 21, 24,
26, 30, 33, 36, 39, 42, 45, 49, 51, 55, 59, 61, 65, 68, 71, 76, 80, 83, 87, 90,
93, 97, 99, 101, 105, 107, 110, 112, 114, 115, 115, 118, 117, 118, 119, 118,
118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 120, 119, 119, 118, 119,
118, 119, 118, 118, 117, 115, 116, 115, 114, 113, 113, 112, 111, 110, 109, 109,
108, 107, 106, 107, 107, 108, 109, 109, 111, 112, 113, 114, 115, 115, 115, 115,
116, 115, 115, 115, 114, 114, 113, 113, 112, 111, 108, 107, 103, 100, 97, 92,
89, 85, 82, 78, 74, 70, 67, 63, 62, 59, 57, 53, 51, 50, 48, 47, 44, 43, 41, 40,
40, 39, 36, 36, 35, 33, 33, 31, 30, 30, 29, 29, 28, 29, 29, 28, 28, 27, 25, 24,
23, 21, 19, 17, 14, 11, 9, 5, 2, -2, -7, -10, -13, -16, -18, -21, -23, -26, -27,
-29, -31, -33, -35, -37, -39, -40, -42, -44, -45, -47, -49, -51, -52, -53, -53,
-55, -55, -55, -56, -54, -55, -53, -54, -54, -54, -53, -54, -54, -54, -55, -57,
-57, -57, -58, -58, -59, -58, -57, -56, -55, -53, -51, -48, -45, -46, -44, -41,
-36, -34, -32, -30, -27, -24, -21, -17, -13, -16, -17, -17, -18, -14, -13, -11,
-9, -9, -8, -7, -7, -7, -8, -9, -9, -7, -3, -1, -3, -3, -2, 0, 0, 0, 0, 2, 6, 9,
10, 9, 8, 4, -1, -4, -9, -12, -15, -17, -17, -16, -12, -11, -9, -8, -8, -7, -5,
-3, -1, 0, -1, -2, -3, -5, -6, -7, -8, -10, -10, -11, -12, -14, -17, -19, -22,
-24, -26, -27, -27, -27, -28, -27, -28, -28, -27, -28, -28, -26, -25, -26, -25,
-26, -26, -28, -30, -30, -30, -31, -30, -28, -26, -22, -19, -15, -14, -13, -12,
-10, -7, -2, 1, 4, 8, 11, 13, 16, 18, 21, 24, 25, 25, 25, 24, 23, 21, 17, 13,
10, 8, 5, 3, 3, 1, 0, -1, -1, -2, -2, -1, 0, 1, 1, 2, 3, 1, 2, 0, -1, -3, -3,
-5, -8, -11, -14, -18, -22, -26, -29, -35, -37, -42, -44, -48, -51, -53, -56,
-58, -61, -63, -66, -70, -73, -78, -81, -87, -91, -95, -100, -103, -106, -110,
-111, -112, -113, -113, -113, -112, -111, -110, -108, -107, -106, -106, -105,
-105, -104, -103, -104, -103, -103, -102, -100, -98, -96, -95, -93, -93, -93,
-92, -93, -92, -92, -93, -93, -91, -91, -90, -89, -89, -87, -84, -83, -81, -78,
-76, -74, -71, -67, -65, -61, -58, -57, -53, -50, -47, -45, -42, -39, -36, -32,
-28, -24, -23, -21, -20, -19, -19, -21, -21, -23, -25, -28, -30, -33, -36, -38,
-40, -42, -44, -45, -47, -48, -49, -49, -50, -50, -50, -47, -46, -43, -41, -39,
-37, -34, -32, -29, -27, -27, -26, -25, -25, -24, -24, -24, -23, -22, -21, -19,
-17, -15, -12, -8, -5, -3, 0, };