#define DATA_LENGTH 512
#define DATA AKWF_dbass_0046

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 5, 7, 8, 10, 10, 11, 13, 14,
16, 17, 18, 19, 20, 22, 23, 25, 26, 27, 29, 31, 31, 32, 34, 36, 37, 39, 40, 40,
42, 44, 45, 46, 48, 49, 49, 51, 52, 53, 54, 55, 56, 57, 60, 60, 61, 62, 64, 65,
65, 67, 67, 68, 69, 70, 72, 72, 73, 74, 75, 76, 77, 77, 79, 79, 80, 82, 81, 83,
85, 84, 84, 86, 88, 88, 88, 89, 89, 90, 91, 91, 90, 91, 92, 93, 94, 95, 94, 95,
96, 96, 97, 97, 97, 98, 99, 99, 101, 100, 100, 102, 101, 101, 102, 103, 102,
103, 104, 104, 104, 105, 105, 105, 106, 106, 107, 106, 107, 107, 108, 109, 109,
109, 109, 110, 111, 111, 111, 111, 111, 111, 112, 112, 113, 114, 114, 114, 114,
115, 115, 115, 115, 116, 117, 116, 117, 117, 117, 117, 118, 118, 117, 118, 118,
118, 119, 119, 118, 118, 120, 118, 119, 119, 120, 120, 119, 119, 118, 119, 117,
118, 119, 118, 117, 118, 117, 117, 115, 115, 115, 115, 114, 114, 114, 112, 112,
112, 112, 110, 109, 109, 109, 108, 108, 107, 106, 104, 104, 103, 101, 101, 100,
99, 98, 97, 96, 95, 93, 91, 91, 90, 89, 87, 87, 86, 84, 83, 81, 80, 80, 78, 76,
75, 73, 73, 71, 70, 68, 68, 66, 64, 63, 62, 61, 59, 57, 56, 55, 52, 49, 50, 47,
46, 44, 43, 41, 39, 37, 36, 35, 33, 32, 29, 29, 26, 25, 23, 20, 19, 18, 16, 13,
12, 11, 9, 8, 6, 4, 2, 0, -1, -3, -4, -6, -7, -10, -11, -13, -13, -15, -16, -18,
-21, -22, -23, -25, -26, -28, -29, -29, -32, -33, -36, -37, -38, -38, -39, -41,
-43, -44, -44, -46, -47, -48, -50, -51, -52, -53, -55, -55, -57, -58, -60, -61,
-62, -62, -63, -65, -65, -66, -66, -68, -69, -70, -71, -72, -72, -73, -74, -75,
-76, -77, -78, -79, -79, -81, -82, -81, -83, -84, -84, -85, -86, -86, -86, -87,
-89, -90, -90, -91, -92, -92, -93, -94, -95, -96, -95, -96, -97, -97, -97, -99,
-98, -99, -99, -100, -101, -101, -101, -102, -103, -103, -103, -103, -104, -104,
-104, -104, -105, -106, -106, -106, -106, -107, -106, -106, -107, -106, -106,
-107, -107, -107, -106, -107, -108, -107, -107, -107, -107, -106, -106, -105,
-104, -104, -103, -104, -104, -103, -102, -102, -102, -101, -101, -100, -101,
-99, -98, -98, -98, -97, -95, -95, -95, -95, -93, -92, -91, -92, -90, -90, -88,
-87, -87, -85, -84, -83, -83, -82, -80, -80, -79, -77, -76, -76, -73, -73, -72,
-71, -69, -68, -67, -67, -66, -64, -63, -62, -61, -59, -58, -57, -56, -55, -54,
-53, -50, -49, -49, -48, -48, -45, -45, -43, -42, -41, -38, -37, -36, -35, -34,
-33, -32, -31, -30, -28, -27, -27, -25, -23, -23, -22, -20, -19, -18, -17, -16,
-14, -14, -13, -12, -11, -9, -8, -7, -5, -5, -4, -3, -3, -1, -1, };