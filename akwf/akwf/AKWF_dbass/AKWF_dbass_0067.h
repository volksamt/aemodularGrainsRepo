#define DATA_LENGTH 512
#define DATA AKWF_dbass_0067

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 6, 7, 7, 6, 9, 10, 11, 14,
16, 17, 18, 16, 18, 22, 26, 28, 30, 33, 34, 35, 37, 40, 43, 45, 46, 46, 46, 47,
48, 48, 46, 46, 47, 48, 48, 48, 49, 49, 51, 50, 50, 47, 47, 48, 48, 50, 51, 53,
52, 51, 52, 53, 55, 56, 55, 55, 56, 55, 55, 54, 55, 55, 55, 57, 58, 61, 62, 62,
63, 66, 68, 68, 69, 67, 67, 69, 69, 70, 69, 68, 66, 65, 64, 65, 66, 69, 69, 69,
69, 68, 68, 69, 69, 68, 67, 65, 65, 66, 66, 66, 68, 69, 69, 68, 67, 67, 67, 65,
64, 65, 64, 65, 66, 66, 67, 69, 70, 70, 69, 70, 70, 71, 72, 72, 72, 74, 74, 76,
78, 80, 81, 83, 85, 86, 89, 89, 89, 90, 90, 90, 90, 92, 93, 94, 95, 97, 97, 98,
98, 98, 98, 98, 99, 99, 98, 98, 99, 98, 98, 98, 99, 100, 100, 102, 103, 105,
104, 104, 103, 103, 102, 100, 98, 98, 97, 96, 94, 92, 89, 87, 85, 83, 80, 78,
76, 75, 75, 74, 74, 74, 72, 71, 70, 69, 70, 70, 71, 72, 71, 72, 73, 73, 74, 75,
75, 75, 75, 75, 75, 74, 74, 72, 70, 68, 65, 62, 61, 59, 56, 53, 50, 47, 43, 39,
35, 31, 28, 25, 22, 20, 18, 16, 13, 11, 9, 8, 7, 6, 5, 5, 5, 5, 6, 5, 4, 4, 3,
3, 3, 3, 4, 3, 2, 1, -1, -3, -3, -6, -7, -8, -9, -10, -10, -12, -13, -14, -14,
-15, -17, -18, -17, -19, -19, -19, -19, -20, -20, -22, -22, -24, -23, -24, -25,
-26, -27, -28, -28, -29, -30, -31, -31, -31, -33, -32, -33, -34, -35, -36, -36,
-37, -37, -37, -38, -38, -37, -38, -38, -38, -40, -40, -40, -41, -41, -42, -42,
-42, -42, -42, -42, -43, -45, -45, -45, -46, -47, -46, -48, -48, -50, -51, -52,
-53, -55, -56, -58, -60, -61, -62, -63, -64, -66, -67, -68, -68, -70, -70, -71,
-70, -70, -71, -71, -71, -71, -71, -72, -73, -72, -72, -73, -73, -73, -74, -75,
-75, -77, -78, -79, -80, -82, -83, -86, -87, -89, -91, -93, -95, -96, -98, -100,
-102, -105, -106, -108, -109, -111, -112, -114, -115, -116, -117, -118, -118,
-119, -119, -119, -119, -119, -119, -119, -118, -115, -114, -114, -113, -113,
-111, -110, -111, -110, -110, -110, -110, -110, -110, -110, -110, -109, -109,
-109, -107, -107, -107, -106, -105, -103, -102, -101, -99, -98, -97, -95, -95,
-94, -93, -93, -92, -91, -91, -90, -90, -89, -89, -88, -87, -86, -86, -85, -84,
-82, -81, -80, -79, -77, -77, -75, -73, -73, -71, -70, -68, -67, -64, -63, -62,
-59, -57, -53, -51, -49, -45, -44, -40, -38, -36, -33, -31, -30, -28, -27, -25,
-23, -22, -20, -19, -19, -17, -17, -15, -14, -13, -11, -12, -11, -9, -9, -7, -8,
-8, -7, -6, -6, -5, -4, -2, -1, -1, -2, 0, 0, };