#define DATA_LENGTH 512
#define DATA AKWF_dbass_0060

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 4, 6, 7, 8, 9, 12, 13, 14,
15, 17, 18, 20, 22, 23, 25, 27, 28, 30, 32, 33, 33, 35, 36, 38, 39, 40, 42, 42,
44, 46, 46, 48, 49, 51, 51, 54, 54, 56, 56, 58, 60, 62, 63, 65, 66, 68, 70, 72,
73, 74, 76, 77, 79, 80, 81, 83, 83, 85, 86, 88, 89, 90, 92, 93, 93, 95, 96, 97,
98, 100, 102, 102, 102, 103, 104, 105, 106, 106, 106, 107, 107, 109, 108, 109,
110, 111, 112, 111, 113, 112, 113, 114, 114, 114, 115, 116, 114, 115, 116, 116,
116, 116, 117, 116, 117, 118, 118, 119, 119, 119, 119, 119, 119, 119, 118, 118,
117, 117, 116, 116, 115, 116, 114, 113, 113, 113, 112, 112, 111, 110, 109, 108,
108, 107, 106, 105, 104, 104, 102, 102, 102, 101, 100, 100, 100, 98, 98, 97, 97,
96, 95, 94, 93, 92, 91, 89, 88, 86, 85, 84, 83, 81, 80, 78, 75, 73, 73, 72, 69,
69, 68, 67, 66, 65, 64, 64, 62, 60, 60, 59, 58, 56, 54, 54, 52, 50, 50, 47, 44,
42, 39, 38, 35, 32, 32, 29, 29, 27, 26, 23, 22, 20, 19, 17, 15, 14, 11, 10, 8,
7, 5, 3, 1, 0, -2, -3, -4, -6, -7, -8, -11, -11, -13, -15, -17, -18, -18, -19,
-20, -21, -22, -22, -23, -24, -25, -27, -28, -29, -31, -33, -33, -34, -34, -35,
-37, -38, -40, -41, -43, -44, -45, -47, -47, -48, -50, -51, -52, -52, -54, -55,
-55, -54, -53, -54, -53, -53, -53, -53, -54, -55, -56, -56, -58, -59, -60, -60,
-62, -63, -63, -66, -66, -67, -69, -70, -69, -69, -69, -69, -68, -68, -68, -67,
-66, -66, -65, -65, -65, -65, -65, -65, -64, -64, -64, -63, -64, -64, -63, -63,
-64, -62, -63, -62, -60, -61, -60, -58, -57, -57, -56, -54, -52, -52, -50, -48,
-46, -46, -44, -44, -43, -44, -44, -45, -46, -47, -49, -50, -50, -51, -53, -53,
-53, -54, -54, -54, -55, -55, -55, -55, -54, -54, -54, -54, -55, -55, -56, -56,
-56, -57, -58, -60, -60, -63, -64, -64, -67, -69, -70, -71, -74, -76, -76, -77,
-79, -80, -81, -82, -83, -84, -85, -85, -86, -87, -87, -88, -88, -89, -90, -91,
-92, -94, -94, -95, -97, -98, -98, -100, -101, -101, -102, -101, -102, -102,
-101, -100, -100, -99, -99, -98, -96, -95, -94, -94, -93, -92, -92, -91, -89,
-89, -88, -86, -83, -82, -81, -78, -78, -76, -74, -73, -72, -70, -69, -67, -65,
-64, -61, -61, -59, -56, -55, -54, -52, -50, -49, -47, -46, -44, -43, -42, -42,
-41, -40, -40, -40, -41, -40, -40, -41, -40, -39, -40, -38, -38, -38, -37, -36,
-38, -37, -36, -35, -36, -34, -34, -34, -33, -33, -32, -31, -31, -29, -30, -28,
-28, -27, -26, -25, -24, -24, -24, -24, -24, -24, -24, -23, -23, -21, -20, -19,
-17, -15, -13, -12, -10, -7, -7, -5, -4, -2, 0, };