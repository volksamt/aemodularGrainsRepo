#define DATA_LENGTH 512
#define DATA AKWF_dbass_0055

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 7, 10, 12, 14, 17, 19, 21, 24,
26, 28, 30, 32, 35, 37, 40, 44, 46, 50, 53, 56, 59, 62, 65, 68, 70, 73, 76, 78,
81, 83, 85, 87, 89, 90, 93, 96, 98, 97, 99, 100, 101, 103, 104, 105, 107, 108,
108, 109, 110, 112, 112, 113, 115, 115, 117, 118, 119, 119, 119, 118, 119, 118,
119, 119, 118, 118, 117, 116, 117, 116, 115, 114, 114, 111, 110, 109, 109, 108,
106, 105, 103, 102, 101, 99, 98, 97, 96, 95, 94, 92, 90, 89, 88, 86, 86, 85, 83,
83, 82, 81, 81, 80, 80, 80, 80, 80, 80, 80, 79, 79, 79, 79, 78, 77, 76, 76, 75,
74, 73, 73, 73, 72, 72, 72, 71, 71, 71, 70, 70, 68, 67, 67, 66, 64, 62, 60, 59,
58, 56, 54, 53, 51, 51, 48, 48, 46, 44, 42, 40, 38, 36, 33, 31, 28, 25, 22, 19,
15, 13, 9, 5, 3, -1, -3, -6, -9, -12, -13, -15, -17, -18, -20, -22, -23, -24,
-26, -28, -28, -29, -31, -31, -32, -34, -33, -34, -35, -35, -34, -35, -35, -33,
-34, -33, -31, -29, -28, -27, -25, -24, -22, -21, -20, -19, -17, -16, -15, -14,
-14, -13, -12, -10, -10, -8, -7, -6, -5, -5, -4, -3, -2, -1, -1, -1, -2, 0, -1,
1, 0, 1, 0, 2, 1, 0, 0, 0, 2, -1, 0, 0, -1, 0, 1, 0, -3, -4, -5, -6, -7, -8,
-10, -12, -15, -17, -18, -19, -22, -23, -24, -26, -28, -28, -30, -29, -28, -29,
-28, -28, -27, -27, -29, -30, -31, -31, -29, -29, -28, -28, -29, -28, -27, -27,
-27, -26, -26, -26, -25, -25, -26, -26, -26, -26, -24, -25, -23, -23, -23, -22,
-22, -22, -21, -20, -20, -18, -17, -16, -16, -14, -14, -14, -12, -10, -9, -9,
-7, -6, -6, -6, -4, -1, -1, -1, 0, 2, 2, 3, 3, 3, 4, 4, 4, 3, 2, 3, 0, -1, -2,
-3, -6, -6, -8, -8, -10, -10, -10, -11, -11, -10, -10, -10, -10, -10, -12, -12,
-13, -13, -14, -15, -17, -18, -19, -20, -21, -22, -22, -23, -23, -24, -24, -25,
-26, -26, -27, -28, -29, -29, -31, -34, -35, -38, -40, -42, -44, -46, -48, -49,
-50, -52, -53, -53, -55, -56, -56, -58, -59, -63, -64, -66, -69, -70, -72, -74,
-75, -77, -77, -79, -79, -80, -81, -81, -81, -81, -80, -81, -83, -83, -84, -84,
-85, -85, -86, -86, -88, -90, -90, -91, -93, -95, -95, -97, -97, -99, -99, -99,
-99, -100, -99, -97, -96, -95, -94, -93, -92, -90, -89, -89, -88, -87, -86, -87,
-85, -85, -84, -84, -83, -82, -82, -82, -81, -80, -80, -78, -77, -76, -74, -72,
-71, -70, -67, -67, -66, -64, -63, -63, -61, -61, -61, -60, -59, -58, -57, -55,
-55, -54, -52, -52, -49, -48, -48, -46, -44, -43, -41, -40, -39, -37, -35, -34,
-31, -30, -27, -25, -23, -20, -18, -15, -11, -9, -6, -3, 0, };