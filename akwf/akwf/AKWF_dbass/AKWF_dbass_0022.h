#define DATA_LENGTH 512
#define DATA AKWF_dbass_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 9, 11, 12, 14, 16, 18, 21,
23, 26, 28, 30, 32, 34, 37, 40, 43, 44, 45, 48, 50, 50, 51, 52, 54, 55, 56, 56,
57, 59, 61, 61, 63, 65, 65, 67, 68, 68, 70, 71, 72, 73, 73, 74, 75, 76, 76, 77,
79, 80, 84, 84, 87, 89, 91, 93, 95, 94, 95, 96, 96, 95, 95, 94, 93, 93, 91, 91,
89, 89, 89, 90, 91, 92, 94, 94, 94, 95, 95, 96, 96, 95, 94, 93, 92, 91, 89, 88,
87, 85, 85, 84, 83, 81, 79, 77, 75, 73, 71, 69, 67, 64, 64, 63, 61, 61, 59, 59,
58, 58, 57, 57, 57, 56, 57, 56, 57, 57, 57, 57, 56, 56, 55, 55, 55, 56, 53, 54,
52, 50, 50, 48, 46, 44, 42, 40, 39, 38, 37, 35, 33, 33, 31, 32, 32, 30, 31, 32,
30, 31, 30, 30, 29, 28, 27, 25, 23, 22, 20, 18, 18, 17, 14, 15, 14, 12, 12, 11,
11, 10, 10, 9, 9, 8, 8, 7, 7, 9, 9, 11, 12, 12, 14, 14, 17, 19, 20, 21, 23, 23,
24, 25, 27, 28, 29, 29, 31, 32, 33, 35, 35, 36, 37, 38, 39, 40, 40, 42, 42, 43,
43, 44, 44, 44, 45, 44, 45, 45, 45, 44, 44, 43, 43, 42, 42, 43, 41, 40, 40, 39,
39, 38, 37, 38, 38, 38, 37, 37, 38, 39, 40, 41, 41, 41, 42, 42, 43, 44, 45, 45,
45, 46, 47, 47, 48, 49, 50, 51, 51, 51, 52, 53, 53, 54, 54, 53, 54, 54, 54, 54,
53, 53, 52, 51, 52, 49, 48, 48, 46, 45, 44, 43, 43, 43, 42, 42, 41, 41, 41, 40,
40, 40, 40, 38, 36, 35, 35, 32, 31, 30, 29, 28, 26, 25, 23, 23, 22, 21, 22, 21,
20, 20, 20, 19, 20, 21, 20, 20, 20, 20, 21, 20, 21, 22, 21, 22, 23, 22, 23, 23,
22, 21, 21, 22, 21, 19, 19, 19, 17, 17, 16, 14, 13, 13, 12, 11, 10, 8, 8, 8, 7,
5, 4, 4, 2, 1, 0, -2, -4, -5, -7, -10, -13, -14, -18, -20, -24, -26, -28, -30,
-34, -36, -38, -41, -43, -43, -45, -45, -49, -49, -51, -51, -53, -54, -55, -57,
-58, -59, -60, -61, -62, -63, -65, -66, -67, -67, -69, -71, -72, -73, -75, -76,
-78, -80, -80, -84, -85, -87, -88, -89, -90, -91, -91, -92, -93, -95, -95, -96,
-97, -97, -98, -98, -99, -100, -101, -102, -103, -103, -105, -106, -107, -110,
-111, -111, -113, -114, -116, -117, -118, -118, -119, -119, -119, -118, -118,
-118, -117, -115, -114, -113, -111, -111, -109, -107, -107, -105, -105, -103,
-102, -101, -100, -97, -96, -95, -92, -91, -88, -86, -85, -82, -79, -78, -76,
-73, -70, -67, -66, -63, -61, -58, -56, -55, -53, -51, -49, -47, -44, -43, -40,
-40, -37, -36, -33, -31, -29, -26, -23, -22, -20, -19, -16, -15, -13, -11, -9,
-8, -5, -4, -2, 0, };