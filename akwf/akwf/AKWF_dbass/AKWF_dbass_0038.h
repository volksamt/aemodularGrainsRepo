#define DATA_LENGTH 512
#define DATA AKWF_dbass_0038

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 6, 7, 10, 13, 15, 17, 19, 21,
24, 27, 28, 31, 32, 35, 37, 39, 41, 43, 45, 48, 50, 52, 54, 56, 57, 59, 61, 64,
65, 67, 69, 71, 74, 75, 78, 79, 81, 82, 84, 85, 86, 88, 90, 91, 93, 94, 96, 98,
100, 101, 102, 103, 104, 105, 105, 107, 107, 108, 110, 110, 112, 112, 113, 112,
113, 114, 115, 115, 116, 118, 118, 117, 117, 118, 118, 118, 119, 119, 118, 118,
119, 118, 119, 118, 119, 118, 117, 117, 118, 117, 116, 116, 115, 115, 114, 114,
113, 112, 111, 109, 109, 108, 107, 106, 104, 103, 101, 99, 98, 96, 95, 93, 92,
90, 88, 86, 85, 82, 80, 79, 75, 74, 71, 69, 66, 63, 61, 59, 57, 54, 52, 49, 47,
44, 42, 39, 36, 32, 30, 26, 23, 21, 18, 14, 12, 8, 5, 2, -1, -3, -6, -10, -13,
-16, -19, -21, -25, -28, -31, -33, -37, -41, -43, -46, -49, -51, -54, -57, -60,
-63, -65, -68, -71, -73, -75, -78, -79, -83, -84, -87, -89, -90, -92, -94, -97,
-98, -100, -101, -103, -105, -107, -108, -109, -110, -111, -112, -112, -113,
-113, -114, -116, -117, -116, -117, -117, -118, -118, -117, -117, -116, -116,
-117, -116, -116, -115, -113, -112, -113, -112, -111, -110, -109, -107, -106,
-105, -103, -102, -101, -99, -99, -97, -95, -93, -92, -90, -88, -86, -84, -83,
-82, -79, -76, -75, -72, -71, -69, -66, -64, -61, -60, -56, -54, -52, -50, -47,
-45, -43, -41, -38, -35, -32, -31, -29, -26, -24, -21, -20, -17, -14, -13, -11,
-8, -6, -3, 0, 2, 4, 5, 8, 9, 12, 15, 17, 20, 22, 25, 26, 29, 31, 33, 34, 37,
40, 41, 43, 45, 47, 49, 51, 53, 55, 56, 59, 61, 61, 64, 65, 67, 69, 70, 72, 74,
75, 77, 78, 79, 81, 82, 83, 85, 86, 87, 88, 89, 91, 92, 93, 95, 95, 96, 97, 98,
98, 100, 101, 101, 101, 102, 102, 103, 103, 105, 104, 106, 106, 106, 106, 106,
106, 105, 106, 106, 107, 107, 107, 107, 108, 107, 106, 105, 104, 103, 104, 102,
102, 100, 99, 98, 97, 95, 96, 94, 93, 92, 90, 89, 88, 86, 84, 83, 81, 79, 77,
75, 74, 72, 70, 68, 67, 64, 62, 61, 59, 56, 55, 53, 49, 48, 44, 43, 40, 38, 35,
32, 30, 28, 25, 24, 21, 20, 16, 13, 11, 9, 6, 3, 1, -1, -4, -6, -7, -10, -13,
-15, -18, -21, -22, -24, -27, -28, -30, -33, -35, -36, -38, -39, -41, -42, -45,
-46, -48, -49, -50, -52, -53, -54, -57, -58, -59, -60, -60, -61, -62, -62, -63,
-64, -64, -65, -65, -65, -65, -66, -65, -65, -65, -64, -64, -63, -63, -62, -62,
-61, -61, -61, -60, -58, -57, -57, -55, -54, -52, -52, -51, -49, -48, -47, -45,
-45, -43, -41, -39, -37, -36, -35, -33, -29, -27, -25, -24, -21, -20, -18, -17,
-14, -12, -10, -7, -6, -4, -2, };