#define DATA_LENGTH 512
#define DATA AKWF_dbass_0049

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 10, 12, 14, 15, 15, 14, 13,
14, 13, 12, 14, 15, 17, 20, 23, 28, 31, 35, 38, 40, 42, 44, 47, 48, 49, 50, 50,
51, 51, 53, 54, 57, 59, 62, 65, 70, 73, 78, 83, 88, 91, 95, 97, 98, 98, 96, 92,
89, 86, 84, 83, 82, 83, 83, 85, 83, 81, 78, 73, 66, 60, 53, 46, 41, 36, 32, 30,
29, 31, 32, 35, 38, 42, 46, 49, 53, 54, 55, 56, 53, 49, 43, 37, 28, 20, 10, 1,
-9, -17, -25, -32, -38, -42, -43, -45, -48, -49, -49, -51, -52, -54, -56, -60,
-63, -67, -70, -75, -80, -85, -90, -95, -100, -104, -106, -108, -109, -109,
-108, -108, -107, -107, -108, -109, -111, -113, -115, -116, -117, -116, -116,
-115, -112, -107, -103, -98, -93, -89, -84, -82, -81, -79, -77, -74, -73, -69,
-65, -61, -59, -53, -50, -45, -41, -37, -33, -29, -25, -21, -18, -13, -10, -5,
-1, 2, 7, 11, 15, 20, 24, 30, 35, 41, 47, 54, 61, 67, 72, 76, 79, 83, 84, 86,
88, 89, 89, 90, 90, 88, 87, 84, 82, 79, 77, 75, 73, 70, 66, 62, 59, 55, 53, 50,
48, 44, 40, 36, 31, 26, 21, 17, 12, 7, 2, -2, -8, -12, -18, -24, -30, -38, -45,
-50, -55, -58, -60, -61, -60, -57, -53, -47, -43, -38, -35, -32, -32, -32, -31,
-30, -30, -30, -30, -31, -31, -29, -28, -28, -26, -24, -24, -20, -18, -14, -11,
-7, -3, 1, 5, 8, 12, 13, 13, 13, 11, 10, 9, 8, 9, 9, 10, 13, 16, 20, 24, 28, 30,
33, 35, 38, 40, 42, 44, 45, 46, 46, 46, 47, 48, 51, 53, 55, 59, 61, 66, 72, 77,
82, 87, 90, 91, 90, 89, 87, 84, 81, 77, 75, 73, 74, 75, 76, 76, 74, 70, 65, 60,
54, 47, 41, 34, 29, 27, 25, 24, 25, 26, 29, 31, 35, 38, 42, 44, 46, 47, 49, 47,
45, 41, 37, 29, 21, 12, 2, -8, -18, -27, -35, -42, -47, -50, -52, -54, -55, -56,
-56, -57, -60, -60, -63, -66, -69, -73, -77, -81, -88, -92, -98, -103, -108,
-112, -114, -114, -114, -112, -110, -108, -106, -106, -106, -109, -111, -112,
-115, -118, -119, -119, -119, -117, -114, -110, -105, -102, -98, -93, -89, -87,
-85, -82, -79, -75, -71, -66, -60, -56, -51, -47, -44, -40, -36, -34, -31, -27,
-23, -20, -17, -13, -9, -5, -1, 4, 8, 13, 18, 23, 27, 34, 40, 46, 54, 60, 66,
71, 76, 80, 83, 84, 86, 87, 89, 89, 89, 88, 87, 85, 84, 82, 81, 78, 74, 72, 70,
67, 63, 59, 56, 53, 49, 46, 42, 38, 34, 30, 24, 18, 14, 8, 5, 2, -2, -5, -8,
-14, -19, -23, -31, -37, -43, -48, -53, -58, -60, -61, -60, -57, -53, -49, -45,
-41, -39, -37, -36, -35, -34, -33, -32, -32, -31, -29, -28, -26, -23, -22, -21,
-19, -16, -12, -10, -10, -7, -3, 0, };