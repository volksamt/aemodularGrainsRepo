#define DATA_LENGTH 512
#define DATA AKWF_dbass_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 3, 4, 5, 7, 9, 11, 13, 14,
15, 17, 18, 18, 19, 21, 23, 24, 24, 25, 28, 28, 30, 32, 33, 34, 36, 38, 39, 41,
42, 44, 46, 48, 50, 52, 54, 56, 57, 57, 57, 57, 58, 58, 59, 59, 61, 62, 63, 64,
67, 67, 68, 69, 71, 72, 72, 74, 75, 76, 76, 77, 79, 79, 81, 82, 82, 82, 82, 83,
83, 84, 84, 83, 82, 83, 83, 82, 83, 82, 82, 82, 83, 82, 82, 82, 82, 83, 83, 83,
83, 85, 86, 87, 88, 88, 90, 92, 93, 95, 95, 96, 96, 96, 98, 97, 97, 98, 97, 97,
97, 97, 97, 97, 97, 96, 97, 97, 96, 96, 95, 95, 95, 95, 95, 95, 96, 97, 97, 99,
101, 101, 102, 103, 105, 105, 105, 106, 106, 106, 107, 108, 109, 109, 109, 110,
110, 110, 110, 109, 110, 107, 107, 106, 105, 104, 102, 103, 101, 100, 100, 98,
99, 97, 96, 96, 96, 94, 94, 93, 93, 93, 93, 94, 95, 95, 94, 95, 96, 96, 97, 98,
99, 99, 100, 100, 99, 99, 100, 99, 99, 100, 98, 97, 97, 95, 94, 92, 91, 90, 88,
86, 85, 84, 82, 81, 79, 78, 76, 75, 74, 74, 73, 72, 71, 71, 71, 70, 70, 69, 68,
67, 65, 64, 62, 59, 59, 57, 54, 51, 49, 47, 44, 41, 39, 38, 36, 33, 31, 29, 28,
26, 26, 25, 23, 21, 20, 18, 18, 18, 17, 15, 15, 14, 13, 11, 10, 10, 7, 7, 6, 6,
5, 4, 3, 3, 3, 1, 0, -1, -1, -3, -4, -4, -6, -8, -8, -10, -10, -12, -12, -14,
-15, -16, -18, -18, -20, -21, -22, -23, -24, -26, -26, -28, -30, -31, -33, -35,
-36, -38, -41, -42, -44, -44, -46, -48, -48, -49, -51, -51, -53, -53, -53, -54,
-54, -55, -56, -57, -57, -57, -56, -57, -58, -58, -57, -58, -59, -59, -60, -61,
-61, -63, -63, -63, -64, -65, -66, -66, -67, -69, -69, -70, -71, -72, -75, -76,
-77, -78, -80, -82, -82, -83, -85, -85, -86, -86, -88, -90, -90, -91, -91, -93,
-93, -95, -95, -97, -98, -99, -101, -101, -103, -104, -106, -106, -108, -110,
-111, -112, -113, -114, -115, -117, -117, -117, -118, -119, -119, -120, -119,
-119, -119, -118, -118, -117, -117, -115, -115, -115, -114, -113, -112, -111,
-110, -110, -108, -108, -107, -106, -104, -103, -103, -103, -101, -100, -99,
-98, -97, -96, -96, -93, -92, -91, -90, -88, -88, -87, -85, -83, -83, -81, -80,
-79, -78, -76, -74, -74, -74, -73, -72, -70, -69, -69, -68, -67, -66, -66, -66,
-65, -65, -65, -64, -64, -65, -64, -64, -63, -63, -61, -60, -60, -59, -58, -58,
-58, -56, -54, -53, -52, -51, -51, -49, -47, -46, -44, -43, -41, -41, -41, -40,
-39, -37, -36, -35, -34, -33, -32, -32, -30, -28, -27, -26, -25, -24, -22, -20,
-20, -17, -15, -15, -14, -13, -12, -11, -9, -7, -6, -5, -4, -3, -2, -1, };