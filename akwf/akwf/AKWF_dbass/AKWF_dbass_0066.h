#define DATA_LENGTH 512
#define DATA AKWF_dbass_0066

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 9, 12, 15, 16, 20, 22, 25,
26, 30, 32, 34, 36, 39, 41, 43, 47, 48, 51, 53, 56, 58, 61, 63, 66, 68, 71, 74,
76, 78, 80, 82, 84, 87, 89, 92, 94, 96, 98, 99, 102, 103, 104, 107, 107, 110,
110, 112, 113, 113, 115, 115, 116, 117, 117, 118, 119, 119, 118, 119, 119, 119,
118, 118, 118, 117, 116, 116, 115, 113, 113, 111, 109, 109, 108, 105, 104, 103,
101, 99, 98, 96, 94, 91, 89, 87, 85, 82, 80, 78, 75, 73, 71, 67, 65, 63, 59, 57,
55, 52, 49, 46, 44, 41, 39, 36, 33, 31, 28, 25, 22, 21, 18, 16, 13, 10, 8, 6, 5,
1, -1, -2, -5, -7, -9, -11, -12, -14, -16, -17, -19, -21, -22, -23, -25, -26,
-28, -28, -30, -31, -33, -34, -35, -36, -37, -39, -40, -40, -41, -43, -43, -45,
-46, -46, -48, -49, -51, -51, -53, -53, -54, -56, -56, -57, -59, -60, -62, -63,
-63, -65, -66, -67, -69, -71, -72, -72, -75, -75, -77, -78, -79, -81, -82, -83,
-84, -86, -86, -87, -89, -89, -91, -91, -91, -92, -93, -95, -95, -95, -96, -97,
-97, -97, -97, -97, -97, -97, -97, -97, -96, -96, -95, -95, -94, -94, -92, -92,
-91, -90, -89, -87, -87, -86, -84, -83, -82, -81, -79, -78, -76, -75, -73, -72,
-70, -68, -66, -63, -62, -60, -58, -57, -55, -53, -50, -48, -46, -43, -41, -39,
-37, -34, -32, -29, -27, -24, -22, -20, -17, -15, -12, -10, -8, -6, -4, -1, 2,
5, 7, 10, 12, 15, 18, 19, 22, 25, 26, 30, 32, 34, 37, 39, 42, 44, 47, 49, 51,
55, 57, 59, 61, 64, 65, 68, 70, 72, 74, 76, 77, 79, 82, 83, 84, 86, 88, 90, 91,
92, 92, 94, 95, 95, 97, 98, 98, 99, 99, 99, 99, 99, 99, 98, 98, 99, 98, 98, 98,
96, 95, 94, 94, 92, 92, 90, 89, 88, 86, 85, 83, 81, 80, 78, 75, 74, 72, 70, 68,
66, 64, 61, 59, 57, 54, 52, 50, 47, 45, 44, 40, 38, 36, 34, 31, 28, 26, 24, 21,
18, 17, 14, 12, 10, 8, 5, 4, 1, -1, -2, -4, -7, -8, -10, -12, -14, -16, -16,
-17, -19, -21, -22, -24, -25, -27, -27, -29, -31, -31, -32, -33, -34, -36, -36,
-37, -38, -38, -40, -41, -42, -42, -44, -44, -46, -46, -47, -48, -49, -49, -51,
-51, -53, -54, -55, -56, -57, -58, -58, -60, -61, -62, -63, -64, -65, -66, -67,
-68, -69, -70, -72, -73, -73, -74, -77, -77, -78, -79, -80, -81, -81, -81, -82,
-83, -83, -84, -85, -85, -85, -85, -85, -86, -85, -86, -85, -85, -85, -84, -84,
-83, -82, -81, -80, -79, -79, -77, -76, -74, -73, -73, -70, -70, -68, -67, -65,
-64, -62, -60, -59, -57, -55, -52, -50, -49, -46, -44, -42, -39, -38, -36, -33,
-32, -30, -27, -24, -23, -20, -18, -16, -12, -11, -8, -6, -3, 0, };