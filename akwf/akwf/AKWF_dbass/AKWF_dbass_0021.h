#define DATA_LENGTH 512
#define DATA AKWF_dbass_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 8, 11, 15, 18, 21, 23, 25, 28,
32, 34, 36, 39, 42, 45, 47, 50, 53, 56, 59, 61, 64, 65, 67, 71, 71, 74, 76, 77,
79, 81, 83, 85, 87, 88, 89, 91, 92, 92, 95, 95, 96, 97, 98, 99, 101, 103, 104,
106, 107, 109, 110, 110, 113, 114, 114, 115, 117, 115, 116, 115, 116, 116, 115,
115, 115, 115, 114, 114, 115, 114, 114, 115, 115, 115, 115, 114, 114, 112, 112,
110, 109, 107, 107, 104, 103, 103, 101, 101, 99, 98, 96, 94, 92, 90, 87, 85, 82,
79, 77, 75, 73, 72, 69, 68, 66, 64, 61, 59, 58, 54, 53, 51, 49, 46, 43, 41, 39,
38, 37, 35, 33, 31, 28, 27, 26, 23, 20, 18, 16, 14, 12, 10, 8, 6, 5, 4, 3, 1, 1,
0, 0, -1, -3, -4, -5, -6, -7, -9, -9, -10, -12, -12, -12, -12, -12, -12, -11,
-11, -11, -11, -11, -10, -11, -11, -11, -12, -12, -13, -14, -13, -14, -13, -13,
-13, -13, -12, -13, -13, -12, -12, -12, -12, -12, -13, -13, -13, -12, -12, -11,
-9, -9, -7, -7, -5, -3, -2, -2, -1, -1, 0, 2, 2, 3, 4, 6, 7, 8, 9, 10, 11, 13,
14, 15, 17, 19, 20, 21, 23, 25, 26, 26, 28, 30, 32, 33, 34, 37, 38, 39, 40, 41,
43, 44, 45, 47, 46, 48, 49, 49, 50, 52, 52, 53, 53, 55, 55, 55, 55, 55, 56, 55,
54, 54, 54, 54, 54, 53, 52, 53, 53, 52, 52, 51, 51, 50, 50, 48, 49, 47, 47, 46,
45, 44, 44, 44, 43, 42, 41, 39, 40, 38, 38, 36, 36, 35, 33, 33, 31, 30, 29, 28,
28, 27, 26, 25, 24, 24, 24, 22, 23, 23, 22, 22, 21, 22, 22, 21, 21, 19, 19, 18,
18, 17, 16, 16, 15, 14, 14, 13, 13, 11, 12, 12, 11, 10, 10, 9, 8, 7, 7, 6, 5, 4,
2, 2, 1, 0, 0, -2, -3, -4, -4, -6, -7, -8, -10, -11, -13, -14, -16, -18, -19,
-20, -22, -23, -23, -24, -25, -26, -27, -29, -29, -30, -32, -33, -34, -35, -36,
-37, -39, -40, -42, -42, -43, -45, -46, -47, -48, -50, -52, -54, -55, -56, -60,
-60, -61, -62, -63, -64, -65, -67, -68, -68, -70, -71, -72, -74, -75, -77, -78,
-80, -81, -84, -84, -85, -87, -88, -91, -92, -94, -95, -96, -98, -100, -100,
-102, -104, -104, -107, -108, -108, -109, -111, -110, -112, -111, -112, -112,
-114, -114, -115, -116, -116, -117, -118, -118, -118, -118, -118, -119, -119,
-119, -119, -118, -119, -119, -118, -118, -118, -118, -116, -116, -116, -114,
-114, -113, -112, -111, -109, -108, -107, -105, -104, -103, -101, -99, -98, -97,
-95, -93, -92, -90, -89, -87, -85, -83, -81, -78, -78, -75, -74, -72, -70, -69,
-67, -65, -63, -60, -58, -56, -54, -51, -50, -46, -44, -41, -37, -36, -33, -30,
-26, -23, -20, -16, -13, -12, -8, -6, -3, 0, };