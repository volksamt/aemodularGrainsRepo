#define DATA_LENGTH 512
#define DATA AKWF_dbass_0047

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 7, 7, 8, 10, 13, 18, 22, 24, 24,
25, 25, 26, 26, 27, 30, 30, 31, 32, 34, 38, 39, 39, 40, 39, 39, 41, 41, 42, 43,
43, 43, 43, 42, 42, 41, 40, 41, 41, 43, 43, 43, 43, 45, 47, 47, 46, 45, 48, 50,
50, 50, 50, 49, 48, 49, 52, 55, 58, 61, 62, 61, 61, 63, 65, 66, 64, 64, 67, 67,
68, 69, 69, 68, 67, 65, 65, 65, 65, 64, 64, 64, 62, 59, 58, 58, 57, 58, 59, 60,
61, 61, 62, 63, 63, 62, 62, 62, 61, 60, 60, 58, 58, 59, 59, 59, 60, 60, 61, 61,
62, 63, 63, 63, 64, 64, 64, 64, 66, 67, 69, 68, 69, 69, 71, 71, 73, 76, 77, 78,
78, 79, 79, 81, 80, 81, 83, 84, 86, 87, 88, 89, 90, 91, 93, 94, 96, 97, 97, 97,
97, 97, 97, 97, 97, 96, 95, 96, 96, 96, 96, 96, 96, 98, 98, 99, 100, 100, 101,
102, 101, 99, 98, 96, 94, 92, 90, 87, 85, 83, 80, 78, 75, 73, 71, 70, 69, 69,
69, 67, 68, 68, 68, 67, 67, 68, 68, 69, 69, 70, 71, 72, 74, 75, 76, 77, 78, 78,
77, 76, 76, 74, 73, 70, 68, 66, 63, 59, 54, 51, 46, 42, 39, 35, 31, 27, 22, 18,
15, 11, 8, 6, 4, 2, 1, 0, 1, -1, 0, 0, 1, 1, 3, 4, 6, 8, 8, 9, 9, 10, 10, 9, 9,
8, 7, 5, 4, 3, 0, -1, -3, -5, -7, -10, -10, -12, -12, -13, -13, -13, -15, -15,
-17, -17, -18, -20, -20, -23, -23, -25, -25, -27, -29, -29, -30, -31, -32, -31,
-30, -31, -32, -30, -31, -30, -31, -30, -30, -31, -30, -29, -29, -31, -30, -29,
-30, -30, -31, -31, -32, -32, -33, -33, -34, -34, -34, -35, -35, -35, -35, -35,
-36, -37, -37, -38, -38, -40, -41, -42, -45, -47, -49, -50, -53, -54, -57, -58,
-60, -62, -64, -65, -67, -67, -69, -70, -70, -71, -69, -69, -68, -68, -67, -66,
-66, -66, -67, -66, -66, -66, -67, -69, -69, -70, -73, -73, -75, -76, -77, -78,
-80, -81, -82, -85, -87, -89, -91, -94, -95, -98, -100, -102, -105, -106, -109,
-112, -114, -116, -117, -118, -120, -118, -119, -118, -118, -117, -116, -116,
-115, -113, -112, -111, -109, -108, -108, -106, -107, -106, -107, -107, -106,
-108, -107, -107, -106, -107, -107, -106, -106, -106, -105, -104, -102, -101,
-100, -98, -98, -95, -95, -94, -93, -91, -91, -91, -90, -90, -89, -89, -89, -89,
-89, -89, -88, -88, -86, -86, -85, -83, -82, -81, -78, -77, -76, -74, -72, -71,
-70, -68, -67, -66, -64, -62, -60, -58, -55, -53, -51, -48, -46, -43, -41, -38,
-36, -34, -32, -31, -30, -28, -27, -26, -25, -24, -23, -23, -22, -21, -21, -20,
-19, -18, -16, -16, -15, -15, -15, -14, -14, -12, -12, -12, -12, -10, -10, -9,
-6, -3, -2, -2, -1, -1, -1, -1, -1, };