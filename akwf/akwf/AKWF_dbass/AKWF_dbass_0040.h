#define DATA_LENGTH 512
#define DATA AKWF_dbass_0040

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 4, 4, 5, 6, 5, 6, 7, 9, 9,
10, 10, 12, 12, 14, 14, 15, 17, 18, 19, 19, 20, 22, 23, 24, 25, 25, 26, 27, 28,
30, 31, 33, 32, 34, 34, 36, 36, 37, 39, 39, 40, 42, 43, 43, 44, 45, 47, 47, 48,
50, 50, 51, 53, 53, 55, 56, 56, 58, 59, 60, 61, 62, 63, 63, 65, 66, 67, 68, 70,
71, 71, 72, 75, 76, 77, 77, 78, 80, 80, 82, 82, 84, 85, 86, 88, 87, 89, 90, 92,
92, 93, 93, 94, 96, 97, 98, 99, 100, 101, 100, 102, 103, 104, 104, 105, 106,
106, 106, 108, 109, 110, 111, 111, 112, 112, 113, 112, 113, 114, 114, 114, 115,
115, 116, 116, 117, 117, 118, 117, 117, 118, 118, 118, 118, 119, 118, 119, 120,
119, 119, 119, 119, 118, 118, 118, 118, 118, 117, 117, 117, 116, 115, 116, 115,
115, 115, 114, 114, 113, 112, 112, 112, 111, 110, 110, 108, 107, 107, 105, 106,
105, 104, 104, 102, 102, 101, 99, 99, 98, 97, 96, 95, 94, 93, 93, 91, 91, 89,
89, 87, 86, 86, 84, 85, 83, 81, 80, 80, 78, 77, 77, 76, 73, 73, 72, 71, 69, 68,
66, 66, 65, 64, 62, 61, 60, 59, 57, 56, 55, 53, 52, 51, 50, 48, 47, 45, 44, 43,
41, 40, 38, 36, 35, 34, 33, 31, 29, 29, 27, 26, 25, 23, 22, 19, 18, 17, 16, 15,
12, 11, 10, 8, 8, 7, 5, 4, 2, 1, 0, -1, -3, -5, -5, -6, -8, -8, -10, -11, -12,
-14, -16, -17, -19, -19, -20, -22, -22, -24, -25, -26, -28, -29, -30, -30, -32,
-32, -34, -36, -37, -38, -38, -39, -40, -41, -43, -44, -44, -46, -47, -49, -49,
-51, -51, -51, -53, -52, -54, -55, -56, -57, -58, -59, -59, -59, -59, -61, -61,
-63, -63, -63, -65, -65, -67, -67, -67, -68, -69, -68, -68, -70, -70, -70, -71,
-72, -72, -73, -73, -73, -73, -75, -75, -76, -76, -77, -76, -77, -77, -77, -78,
-78, -78, -79, -79, -79, -79, -79, -78, -79, -81, -80, -80, -80, -80, -81, -81,
-80, -81, -81, -80, -80, -80, -80, -82, -82, -81, -80, -82, -81, -81, -81, -82,
-82, -81, -82, -82, -81, -82, -81, -82, -82, -82, -82, -83, -83, -82, -82, -81,
-81, -82, -82, -81, -82, -82, -81, -82, -82, -81, -81, -81, -82, -82, -80, -81,
-82, -82, -81, -81, -80, -80, -80, -80, -79, -78, -78, -78, -77, -78, -77, -76,
-75, -75, -74, -75, -74, -73, -72, -72, -72, -71, -70, -70, -71, -68, -68, -68,
-65, -66, -65, -64, -64, -63, -61, -60, -59, -59, -58, -58, -57, -56, -56, -53,
-53, -52, -51, -50, -48, -47, -47, -46, -45, -44, -43, -42, -42, -39, -39, -38,
-36, -36, -36, -34, -32, -31, -28, -28, -27, -26, -25, -24, -24, -22, -20, -19,
-18, -16, -16, -15, -13, -13, -11, -9, -9, -7, -6, -5, -3, -2, -1, 0, };