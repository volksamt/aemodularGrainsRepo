#define DATA_LENGTH 512
#define DATA AKWF_dbass_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 6, 7, 10, 12, 14, 16, 19, 22,
24, 27, 29, 31, 33, 36, 39, 41, 45, 46, 49, 52, 54, 57, 61, 63, 66, 68, 72, 74,
77, 79, 82, 84, 87, 90, 91, 94, 96, 98, 100, 102, 104, 105, 106, 108, 108, 110,
110, 111, 114, 115, 115, 115, 117, 117, 118, 119, 119, 119, 119, 120, 119, 118,
119, 118, 118, 117, 116, 115, 114, 115, 113, 112, 112, 111, 111, 109, 110, 108,
107, 108, 107, 106, 106, 104, 104, 103, 103, 102, 101, 101, 100, 100, 98, 99,
97, 98, 98, 98, 98, 97, 97, 97, 97, 98, 97, 95, 96, 96, 96, 94, 95, 94, 94, 93,
93, 92, 92, 90, 89, 88, 87, 86, 85, 86, 84, 83, 82, 81, 80, 80, 79, 78, 78, 78,
76, 76, 74, 72, 72, 69, 67, 66, 64, 62, 60, 57, 57, 54, 53, 52, 51, 49, 49, 47,
47, 46, 45, 44, 43, 42, 41, 41, 40, 38, 38, 37, 37, 35, 36, 35, 36, 35, 36, 35,
36, 37, 37, 37, 36, 38, 36, 37, 36, 35, 35, 34, 34, 32, 32, 32, 31, 31, 31, 30,
29, 30, 29, 28, 28, 26, 26, 25, 25, 23, 22, 21, 20, 18, 16, 14, 13, 11, 11, 8,
6, 5, 2, 0, -3, -4, -7, -9, -11, -14, -16, -17, -19, -21, -23, -25, -27, -28,
-30, -32, -34, -35, -36, -38, -40, -40, -42, -44, -46, -47, -49, -50, -51, -53,
-54, -56, -56, -56, -58, -60, -59, -61, -61, -64, -63, -65, -65, -66, -68, -67,
-68, -68, -69, -69, -70, -71, -71, -70, -72, -72, -71, -72, -72, -73, -73, -74,
-75, -75, -76, -76, -79, -79, -81, -81, -81, -82, -83, -84, -85, -86, -87, -87,
-88, -88, -88, -88, -89, -89, -88, -88, -88, -88, -87, -87, -88, -88, -87, -87,
-86, -86, -86, -85, -83, -83, -82, -81, -80, -79, -78, -77, -77, -75, -74, -73,
-73, -72, -71, -70, -69, -68, -67, -66, -65, -63, -62, -62, -62, -60, -59, -58,
-58, -57, -55, -55, -53, -52, -51, -50, -49, -46, -45, -43, -41, -40, -38, -36,
-34, -34, -31, -30, -31, -29, -29, -28, -28, -28, -28, -28, -28, -29, -29, -28,
-28, -26, -26, -24, -23, -21, -21, -20, -20, -18, -18, -18, -18, -17, -18, -19,
-20, -21, -20, -21, -20, -21, -22, -21, -21, -21, -22, -22, -23, -23, -26, -26,
-27, -28, -30, -31, -32, -33, -33, -34, -34, -35, -35, -35, -36, -35, -36, -37,
-37, -38, -39, -40, -41, -42, -42, -42, -43, -45, -44, -45, -46, -46, -46, -46,
-46, -47, -47, -48, -48, -47, -48, -48, -48, -48, -48, -48, -47, -47, -46, -44,
-43, -42, -42, -40, -39, -39, -38, -37, -37, -36, -36, -35, -35, -35, -35, -34,
-34, -33, -31, -31, -30, -30, -30, -28, -29, -27, -27, -28, -26, -26, -25, -24,
-25, -24, -22, -22, -22, -21, -19, -18, -16, -14, -13, -12, -11, -8, -8, -6, -4,
-3, -2, -1, 0, };