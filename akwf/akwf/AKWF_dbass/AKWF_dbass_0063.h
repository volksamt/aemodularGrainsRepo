#define DATA_LENGTH 512
#define DATA AKWF_dbass_0063

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 9, 11, 12, 14, 16, 18, 20,
21, 22, 23, 24, 25, 27, 29, 29, 31, 32, 34, 35, 35, 37, 39, 40, 41, 40, 41, 43,
44, 45, 46, 46, 47, 48, 49, 49, 49, 48, 48, 50, 50, 51, 52, 53, 55, 56, 57, 58,
60, 62, 61, 62, 62, 61, 63, 63, 64, 64, 65, 66, 67, 67, 65, 65, 67, 66, 67, 65,
63, 63, 65, 65, 66, 66, 66, 67, 68, 67, 66, 67, 66, 66, 65, 65, 66, 65, 65, 66,
66, 66, 67, 68, 69, 69, 70, 71, 71, 73, 74, 75, 76, 77, 77, 79, 81, 81, 83, 84,
86, 86, 88, 90, 90, 93, 95, 95, 96, 96, 97, 98, 100, 101, 100, 100, 100, 101,
101, 101, 102, 101, 101, 102, 103, 103, 104, 105, 105, 104, 104, 104, 104, 105,
104, 104, 103, 104, 104, 103, 104, 104, 103, 104, 103, 104, 104, 105, 105, 106,
106, 107, 108, 109, 110, 110, 110, 111, 110, 111, 111, 112, 112, 113, 114, 114,
115, 115, 116, 116, 116, 116, 116, 114, 115, 113, 112, 111, 109, 108, 107, 105,
104, 103, 101, 100, 98, 95, 95, 92, 91, 90, 90, 88, 88, 88, 87, 88, 88, 88, 87,
88, 89, 88, 89, 90, 89, 89, 89, 89, 89, 89, 89, 90, 89, 88, 87, 87, 85, 83, 82,
81, 79, 77, 76, 74, 73, 71, 69, 68, 66, 65, 64, 62, 60, 59, 58, 58, 55, 54, 55,
53, 51, 50, 49, 46, 45, 42, 40, 37, 34, 32, 30, 27, 24, 21, 19, 18, 15, 13, 12,
10, 8, 7, 5, 5, 3, 2, 0, -1, -1, -2, -3, -4, -6, -7, -8, -11, -13, -14, -16,
-18, -19, -20, -23, -25, -27, -29, -31, -33, -36, -38, -40, -42, -44, -47, -49,
-50, -52, -55, -56, -58, -60, -62, -64, -66, -67, -70, -71, -72, -74, -77, -79,
-79, -83, -84, -86, -88, -90, -92, -93, -95, -97, -98, -99, -100, -102, -102,
-103, -104, -104, -105, -105, -106, -106, -106, -107, -106, -106, -106, -106,
-105, -106, -105, -105, -106, -106, -106, -106, -106, -105, -106, -106, -106,
-105, -106, -105, -106, -106, -107, -107, -107, -107, -107, -107, -108, -109,
-108, -109, -109, -109, -110, -110, -111, -111, -111, -112, -112, -112, -112,
-113, -113, -114, -114, -114, -114, -114, -116, -116, -115, -116, -116, -117,
-117, -117, -117, -116, -117, -117, -117, -116, -116, -116, -116, -115, -115,
-114, -115, -114, -113, -113, -113, -114, -113, -113, -114, -114, -114, -114,
-114, -115, -114, -115, -116, -117, -117, -117, -117, -117, -118, -119, -118,
-119, -119, -119, -118, -119, -118, -118, -117, -116, -116, -115, -113, -114,
-113, -112, -111, -110, -109, -107, -107, -107, -106, -104, -104, -103, -101,
-100, -99, -97, -97, -95, -93, -91, -89, -89, -87, -85, -83, -82, -80, -78, -76,
-74, -72, -69, -67, -65, -62, -59, -57, -53, -52, -49, -45, -43, -40, -37, -35,
-31, -28, -25, -22, -20, -17, -14, -12, -9, -6, -3, -1, };