#define DATA_LENGTH 512
#define DATA AKWF_dbass_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 5, 6, 5, 3, 3, 5, 5, 6, 8, 10,
11, 10, 12, 13, 16, 18, 19, 19, 19, 21, 24, 26, 28, 29, 31, 31, 32, 32, 32, 29,
29, 28, 28, 31, 34, 36, 37, 39, 41, 41, 43, 45, 45, 46, 48, 50, 51, 53, 54, 54,
53, 53, 54, 53, 53, 55, 54, 56, 57, 57, 59, 61, 63, 63, 65, 65, 66, 67, 68, 70,
71, 73, 74, 74, 73, 72, 72, 71, 71, 70, 69, 68, 67, 68, 69, 69, 68, 67, 66, 63,
62, 60, 59, 59, 58, 58, 59, 61, 60, 60, 58, 56, 55, 55, 54, 56, 56, 57, 59, 59,
62, 61, 62, 62, 63, 63, 63, 63, 62, 63, 63, 65, 66, 66, 67, 68, 69, 71, 72, 74,
76, 79, 80, 83, 86, 87, 90, 92, 93, 94, 94, 95, 96, 99, 100, 103, 105, 106, 106,
108, 109, 110, 110, 112, 112, 113, 114, 115, 116, 119, 118, 119, 119, 118, 115,
115, 113, 112, 111, 110, 108, 107, 106, 105, 103, 101, 101, 99, 100, 99, 97, 97,
97, 97, 96, 97, 96, 97, 96, 96, 96, 96, 96, 97, 98, 98, 99, 100, 101, 101, 100,
100, 98, 97, 96, 95, 92, 89, 87, 84, 79, 76, 71, 66, 61, 56, 51, 46, 40, 35, 30,
26, 21, 16, 12, 9, 4, 1, -3, -5, -8, -10, -10, -12, -15, -16, -16, -17, -18,
-19, -20, -21, -21, -23, -23, -24, -25, -25, -28, -29, -32, -34, -37, -39, -42,
-46, -48, -52, -54, -57, -59, -62, -65, -67, -69, -71, -73, -75, -77, -78, -78,
-79, -79, -79, -79, -79, -80, -80, -80, -79, -80, -80, -79, -79, -79, -79, -78,
-78, -79, -78, -78, -77, -77, -77, -77, -77, -76, -76, -76, -77, -76, -77, -78,
-78, -79, -81, -82, -82, -83, -84, -83, -84, -83, -82, -81, -81, -79, -77, -76,
-74, -73, -71, -68, -66, -64, -63, -61, -59, -58, -57, -55, -53, -51, -51, -50,
-49, -48, -47, -47, -47, -45, -45, -45, -44, -45, -45, -45, -46, -45, -45, -46,
-45, -46, -46, -45, -44, -44, -45, -43, -41, -41, -39, -38, -36, -35, -34, -33,
-32, -31, -30, -30, -31, -31, -31, -31, -31, -32, -32, -33, -34, -35, -36, -37,
-37, -39, -39, -40, -42, -42, -44, -45, -47, -46, -46, -47, -48, -49, -50, -51,
-50, -51, -52, -52, -52, -51, -52, -51, -51, -51, -50, -50, -50, -49, -49, -49,
-47, -49, -49, -50, -50, -51, -52, -54, -54, -56, -57, -58, -60, -61, -62, -62,
-63, -64, -63, -64, -65, -64, -65, -66, -66, -67, -67, -67, -66, -66, -67, -66,
-66, -65, -66, -66, -68, -66, -66, -65, -66, -68, -68, -69, -69, -68, -68, -68,
-68, -68, -70, -72, -73, -72, -71, -72, -74, -75, -74, -74, -75, -74, -74, -74,
-75, -72, -69, -67, -65, -63, -61, -58, -54, -53, -51, -49, -46, -42, -39, -37,
-36, -33, -29, -22, -18, -17, -15, -13, -10, -9, -7, -6, -5, -2, -1, };