#define DATA_LENGTH 512
#define DATA AKWF_dbass_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 8, 9, 10, 11, 13, 13, 13, 14,
17, 17, 18, 19, 21, 22, 23, 24, 25, 26, 27, 29, 30, 31, 32, 34, 36, 37, 40, 42,
44, 46, 48, 50, 52, 54, 57, 59, 59, 61, 61, 63, 63, 62, 61, 61, 61, 61, 60, 60,
62, 63, 63, 65, 66, 68, 69, 72, 72, 72, 72, 71, 70, 69, 66, 66, 63, 63, 61, 60,
60, 59, 58, 57, 57, 55, 53, 52, 50, 49, 47, 46, 45, 43, 43, 43, 43, 42, 43, 43,
43, 43, 43, 42, 43, 42, 43, 42, 43, 43, 43, 42, 42, 43, 44, 44, 44, 43, 44, 45,
45, 45, 46, 45, 46, 45, 44, 45, 44, 43, 44, 44, 45, 44, 45, 45, 46, 46, 46, 48,
48, 49, 48, 48, 48, 48, 48, 48, 47, 47, 47, 46, 47, 47, 47, 47, 48, 49, 50, 49,
50, 50, 50, 50, 49, 50, 50, 50, 49, 50, 52, 53, 53, 55, 57, 59, 60, 61, 63, 65,
65, 68, 69, 71, 73, 74, 77, 78, 79, 81, 82, 84, 84, 87, 87, 88, 89, 89, 90, 89,
89, 90, 90, 89, 89, 89, 88, 89, 88, 89, 87, 87, 87, 87, 87, 88, 88, 87, 87, 87,
86, 86, 86, 85, 84, 84, 83, 82, 82, 82, 81, 81, 82, 82, 80, 82, 82, 81, 81, 80,
79, 79, 79, 78, 78, 77, 76, 77, 76, 76, 76, 76, 75, 74, 74, 73, 73, 72, 72, 71,
69, 68, 66, 64, 63, 62, 60, 58, 56, 55, 54, 52, 51, 51, 48, 48, 47, 45, 45, 43,
43, 41, 40, 38, 37, 34, 34, 31, 29, 28, 26, 24, 23, 21, 20, 18, 18, 16, 14, 14,
13, 12, 10, 10, 10, 9, 9, 9, 8, 8, 8, 7, 5, 5, 5, 3, 3, 2, 0, 0, -1, -2, -3, -3,
-4, -4, -5, -6, -6, -7, -8, -8, -8, -10, -11, -11, -11, -13, -14, -14, -15, -17,
-17, -18, -18, -19, -19, -21, -21, -22, -23, -24, -26, -27, -27, -29, -31, -33,
-35, -37, -39, -40, -40, -42, -43, -43, -45, -46, -46, -48, -48, -50, -51, -53,
-54, -55, -57, -59, -61, -61, -62, -64, -66, -66, -68, -69, -70, -71, -72, -75,
-76, -78, -80, -81, -83, -84, -86, -87, -88, -90, -91, -93, -94, -94, -95, -96,
-98, -98, -100, -101, -102, -102, -104, -105, -106, -107, -107, -108, -111,
-111, -111, -113, -114, -114, -115, -115, -115, -117, -117, -118, -118, -119,
-119, -119, -119, -119, -120, -119, -118, -117, -117, -116, -116, -116, -116,
-113, -114, -114, -114, -113, -113, -113, -112, -113, -113, -113, -111, -110,
-108, -109, -107, -107, -106, -105, -103, -103, -101, -101, -99, -97, -96, -95,
-93, -90, -88, -88, -87, -86, -85, -82, -80, -79, -76, -74, -72, -70, -68, -65,
-62, -58, -57, -56, -55, -55, -53, -51, -47, -45, -43, -41, -39, -38, -37, -35,
-34, -32, -29, -29, -28, -27, -24, -21, -19, -17, -14, -12, -9, -7, -6, -4, -1,
};