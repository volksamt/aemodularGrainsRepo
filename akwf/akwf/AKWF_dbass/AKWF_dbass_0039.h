#define DATA_LENGTH 512
#define DATA AKWF_dbass_0039

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 4, 6, 7, 9, 11, 11, 12, 14,
16, 18, 19, 20, 21, 23, 23, 25, 27, 27, 29, 31, 32, 34, 34, 36, 37, 39, 40, 41,
42, 43, 45, 46, 47, 48, 50, 52, 52, 54, 55, 57, 58, 59, 59, 60, 62, 63, 65, 66,
66, 68, 69, 71, 71, 73, 73, 75, 76, 77, 77, 79, 80, 81, 82, 83, 85, 85, 86, 86,
88, 88, 89, 90, 90, 92, 92, 93, 94, 95, 95, 96, 98, 98, 99, 98, 99, 99, 101,
102, 102, 103, 104, 104, 104, 105, 105, 106, 107, 107, 108, 108, 109, 109, 109,
110, 110, 110, 111, 112, 112, 112, 113, 113, 113, 114, 114, 114, 114, 115, 115,
115, 116, 115, 115, 116, 115, 116, 117, 117, 118, 116, 117, 117, 118, 118, 118,
118, 119, 118, 118, 118, 119, 119, 119, 118, 118, 119, 119, 118, 119, 118, 118,
118, 118, 118, 117, 117, 117, 117, 117, 117, 117, 117, 116, 116, 116, 116, 117,
116, 117, 115, 116, 115, 115, 115, 114, 114, 114, 114, 114, 112, 114, 112, 112,
112, 112, 111, 110, 110, 109, 109, 109, 109, 109, 107, 107, 107, 107, 105, 105,
105, 104, 105, 103, 103, 103, 102, 100, 100, 99, 99, 98, 98, 97, 98, 96, 95, 95,
94, 93, 93, 92, 92, 90, 89, 89, 88, 88, 87, 85, 85, 84, 82, 82, 82, 81, 80, 78,
78, 77, 77, 75, 75, 73, 72, 71, 70, 70, 68, 68, 67, 64, 64, 63, 61, 61, 59, 59,
57, 56, 55, 55, 53, 52, 51, 50, 49, 48, 46, 45, 44, 43, 41, 40, 39, 38, 37, 36,
35, 34, 32, 32, 29, 28, 27, 26, 25, 24, 22, 21, 20, 19, 17, 17, 16, 15, 12, 12,
10, 10, 8, 7, 6, 5, 4, 2, 1, 1, -1, -2, -3, -5, -6, -7, -8, -9, -11, -12, -13,
-13, -15, -17, -18, -18, -20, -20, -22, -23, -24, -25, -26, -27, -28, -30, -30,
-30, -32, -33, -33, -35, -36, -37, -37, -39, -40, -41, -41, -42, -42, -44, -45,
-45, -45, -46, -47, -48, -50, -50, -51, -51, -51, -52, -53, -54, -54, -56, -56,
-57, -57, -57, -58, -58, -59, -59, -60, -60, -61, -62, -62, -62, -62, -64, -64,
-64, -64, -64, -65, -65, -65, -65, -66, -66, -66, -66, -67, -67, -68, -67, -68,
-68, -69, -68, -68, -69, -68, -68, -68, -68, -68, -68, -68, -69, -69, -68, -68,
-68, -68, -68, -68, -67, -67, -67, -67, -66, -65, -66, -66, -66, -65, -65, -64,
-64, -63, -63, -62, -62, -61, -61, -60, -59, -58, -58, -58, -57, -57, -56, -55,
-56, -54, -53, -52, -51, -51, -51, -50, -50, -48, -48, -46, -46, -45, -45, -43,
-43, -42, -40, -40, -41, -40, -39, -38, -37, -36, -35, -34, -33, -31, -31, -30,
-29, -29, -27, -26, -26, -24, -23, -23, -22, -21, -20, -19, -18, -17, -16, -15,
-14, -12, -11, -11, -10, -8, -8, -7, -6, -5, -4, -3, -2, 0, 0, };