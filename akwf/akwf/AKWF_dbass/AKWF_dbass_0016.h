#define DATA_LENGTH 512
#define DATA AKWF_dbass_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 11, 18, 24, 31, 37, 42, 44, 43,
45, 46, 46, 46, 47, 48, 52, 56, 58, 60, 60, 59, 59, 58, 60, 60, 62, 63, 65, 67,
69, 72, 77, 81, 85, 86, 90, 94, 100, 102, 104, 105, 104, 103, 103, 104, 104,
104, 105, 106, 109, 112, 114, 114, 113, 110, 110, 109, 108, 109, 111, 114, 117,
118, 119, 118, 118, 118, 117, 116, 115, 115, 114, 114, 115, 113, 113, 114, 113,
113, 112, 112, 111, 110, 111, 110, 108, 106, 103, 102, 100, 99, 98, 99, 99, 100,
102, 103, 104, 104, 103, 102, 101, 100, 100, 100, 99, 102, 103, 102, 103, 102,
100, 97, 96, 93, 91, 89, 87, 85, 83, 81, 79, 75, 73, 70, 67, 67, 65, 64, 63, 63,
61, 58, 56, 53, 50, 50, 52, 53, 54, 55, 55, 55, 54, 53, 52, 52, 50, 49, 49, 48,
47, 47, 49, 51, 54, 55, 57, 58, 59, 59, 60, 59, 60, 57, 56, 54, 52, 50, 48, 47,
46, 45, 44, 43, 41, 40, 39, 37, 38, 37, 39, 41, 44, 46, 50, 52, 54, 57, 59, 62,
64, 65, 67, 68, 68, 70, 71, 71, 72, 71, 71, 70, 71, 71, 72, 70, 69, 68, 65, 63,
61, 57, 54, 51, 47, 44, 41, 38, 36, 33, 30, 28, 25, 22, 20, 16, 14, 12, 10, 8,
6, 6, 5, 3, 1, 0, -3, -4, -5, -7, -9, -11, -14, -16, -19, -22, -23, -25, -28,
-31, -33, -35, -38, -39, -42, -44, -45, -48, -49, -48, -49, -48, -48, -47, -44,
-43, -42, -41, -41, -39, -39, -38, -36, -36, -35, -33, -34, -34, -34, -35, -35,
-37, -38, -40, -42, -43, -45, -47, -49, -51, -52, -54, -55, -57, -57, -59, -60,
-61, -61, -62, -64, -65, -66, -68, -68, -68, -69, -70, -70, -71, -70, -70, -70,
-70, -70, -71, -71, -71, -72, -72, -73, -73, -75, -76, -78, -80, -81, -84, -85,
-87, -90, -91, -92, -94, -94, -95, -96, -95, -94, -92, -89, -86, -84, -80, -77,
-72, -67, -62, -57, -52, -47, -41, -37, -32, -29, -24, -20, -18, -16, -14, -12,
-13, -12, -12, -13, -15, -16, -19, -20, -23, -26, -28, -32, -33, -38, -40, -43,
-46, -49, -53, -56, -59, -62, -64, -67, -69, -71, -74, -75, -75, -76, -77, -77,
-78, -77, -78, -77, -76, -76, -76, -75, -73, -73, -73, -73, -75, -76, -78, -80,
-83, -86, -89, -92, -95, -99, -102, -104, -108, -108, -111, -111, -110, -111,
-110, -108, -107, -106, -105, -104, -102, -101, -99, -97, -95, -93, -92, -91,
-90, -89, -87, -87, -86, -84, -82, -82, -81, -80, -79, -79, -79, -77, -77, -78,
-77, -78, -80, -80, -81, -82, -83, -83, -83, -81, -80, -79, -77, -76, -75, -76,
-76, -75, -73, -72, -70, -68, -67, -64, -61, -60, -58, -58, -59, -58, -58, -60,
-62, -63, -62, -63, -65, -63, -61, -57, -55, -52, -49, -46, -44, -43, -39, -35,
-31, -28, -25, -23, -19, -14, -10, -6, -1, };