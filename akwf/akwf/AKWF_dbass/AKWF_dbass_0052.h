#define DATA_LENGTH 512
#define DATA AKWF_dbass_0052

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 8, 12, 16, 21, 23, 28, 32, 36,
40, 42, 46, 49, 51, 55, 57, 60, 62, 65, 67, 70, 72, 74, 76, 78, 79, 81, 82, 85,
87, 88, 89, 92, 91, 93, 95, 96, 97, 99, 100, 101, 102, 103, 104, 105, 105, 107,
108, 108, 108, 109, 109, 110, 109, 110, 111, 111, 112, 112, 111, 113, 113, 114,
114, 113, 115, 116, 116, 117, 116, 116, 118, 117, 118, 117, 117, 117, 117, 117,
117, 117, 117, 118, 119, 118, 119, 119, 119, 118, 118, 117, 116, 114, 112, 110,
108, 106, 104, 102, 99, 96, 94, 91, 87, 84, 81, 78, 74, 71, 67, 63, 60, 56, 53,
49, 45, 43, 38, 35, 31, 29, 25, 22, 19, 17, 14, 11, 9, 6, 4, 2, -1, -2, -5, -7,
-10, -10, -13, -15, -16, -18, -19, -20, -20, -21, -22, -21, -20, -20, -19, -20,
-18, -19, -18, -17, -17, -16, -15, -15, -14, -15, -14, -13, -12, -12, -11, -9,
-9, -7, -7, -6, -5, -4, -3, -2, -2, -2, -2, -1, -2, -1, -1, -1, -1, 0, 0, 0, 2,
3, 4, 4, 4, 4, 6, 6, 6, 6, 7, 7, 7, 8, 7, 8, 7, 8, 8, 7, 7, 8, 8, 8, 7, 8, 7, 7,
7, 6, 6, 6, 6, 4, 4, 3, 2, 2, 1, -1, -2, -1, -1, 1, 0, 0, 2, 4, 3, 2, 3, 2, 3,
5, 3, 2, 3, 3, 2, 1, -1, -1, -1, -1, -1, -2, -4, -4, -5, -5, -7, -10, -10, -11,
-12, -13, -13, -14, -15, -15, -18, -18, -20, -20, -21, -22, -23, -24, -25, -27,
-26, -25, -26, -24, -24, -24, -26, -27, -27, -28, -30, -32, -33, -35, -36, -38,
-39, -41, -43, -43, -45, -46, -48, -49, -51, -53, -54, -57, -59, -61, -62, -63,
-63, -62, -62, -62, -62, -61, -61, -60, -60, -58, -56, -54, -52, -49, -47, -46,
-45, -44, -42, -42, -41, -41, -40, -39, -38, -38, -39, -39, -39, -38, -38, -37,
-37, -36, -35, -34, -32, -33, -32, -31, -32, -33, -34, -35, -36, -36, -37, -39,
-38, -40, -41, -41, -41, -40, -40, -41, -41, -42, -41, -42, -43, -44, -46, -47,
-48, -50, -51, -51, -53, -54, -53, -53, -54, -53, -52, -53, -54, -55, -54, -53,
-54, -53, -53, -51, -52, -51, -52, -51, -51, -51, -50, -50, -49, -49, -48, -47,
-47, -46, -46, -45, -44, -44, -43, -43, -43, -42, -41, -42, -41, -41, -40, -40,
-39, -39, -37, -35, -34, -32, -32, -30, -30, -30, -29, -30, -30, -30, -30, -31,
-30, -30, -30, -32, -31, -32, -33, -33, -35, -36, -36, -37, -38, -39, -39, -39,
-41, -41, -42, -43, -44, -46, -46, -48, -48, -49, -50, -51, -52, -53, -53, -53,
-53, -54, -54, -54, -54, -55, -54, -54, -54, -55, -54, -54, -54, -54, -53, -53,
-53, -51, -51, -49, -49, -48, -47, -45, -44, -44, -42, -39, -38, -36, -34, -33,
-30, -26, -24, -21, -17, -14, -11, -7, -4, -1, };