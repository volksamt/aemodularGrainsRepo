#define DATA_LENGTH 512
#define DATA AKWF_dbass_0050

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 5, 6, 7, 9, 12, 13, 16, 19,
21, 24, 26, 29, 30, 32, 33, 35, 36, 38, 40, 43, 47, 51, 56, 60, 63, 66, 69, 71,
73, 75, 78, 80, 81, 83, 85, 87, 88, 91, 93, 92, 94, 93, 92, 92, 92, 92, 91, 91,
89, 89, 88, 88, 88, 88, 87, 88, 89, 89, 89, 90, 90, 91, 91, 92, 93, 95, 97, 99,
101, 102, 104, 105, 105, 107, 107, 109, 109, 110, 111, 111, 112, 112, 113, 114,
114, 114, 114, 114, 115, 115, 114, 114, 113, 112, 112, 111, 110, 110, 109, 109,
108, 109, 109, 107, 108, 108, 109, 108, 109, 109, 110, 112, 112, 112, 114, 114,
115, 116, 116, 117, 117, 118, 118, 117, 117, 117, 117, 117, 117, 117, 116, 118,
118, 119, 119, 120, 119, 119, 119, 118, 118, 118, 118, 117, 117, 116, 116, 114,
114, 111, 111, 109, 106, 104, 101, 100, 97, 94, 94, 91, 89, 87, 85, 84, 81, 78,
77, 75, 73, 71, 70, 68, 67, 65, 64, 64, 63, 62, 62, 62, 62, 62, 61, 61, 61, 61,
60, 61, 60, 60, 60, 61, 62, 63, 62, 64, 63, 62, 61, 61, 59, 58, 56, 55, 55, 53,
51, 49, 47, 45, 43, 39, 36, 33, 30, 29, 26, 24, 21, 19, 16, 14, 11, 9, 8, 5, 4,
2, 1, 0, -1, -2, -2, -3, -3, -4, -5, -5, -6, -6, -7, -7, -9, -9, -11, -11, -13,
-13, -15, -16, -17, -19, -21, -23, -25, -27, -30, -31, -34, -37, -39, -43, -44,
-48, -50, -54, -56, -59, -62, -63, -66, -67, -70, -73, -75, -76, -78, -80, -81,
-82, -83, -84, -86, -87, -88, -90, -91, -93, -94, -94, -96, -98, -98, -99, -100,
-102, -103, -104, -105, -105, -107, -108, -107, -108, -108, -108, -108, -109,
-109, -110, -109, -109, -109, -108, -108, -106, -106, -106, -106, -106, -105,
-105, -104, -104, -105, -105, -104, -104, -104, -104, -105, -106, -106, -106,
-108, -107, -108, -110, -108, -109, -109, -108, -108, -108, -108, -107, -108,
-107, -107, -106, -106, -107, -106, -105, -105, -105, -105, -105, -104, -106,
-105, -106, -106, -106, -106, -106, -106, -106, -107, -106, -106, -107, -108,
-108, -108, -107, -108, -108, -109, -108, -108, -109, -109, -109, -108, -108,
-107, -106, -105, -104, -104, -102, -102, -101, -99, -97, -96, -94, -91, -90,
-88, -87, -87, -85, -85, -84, -82, -81, -79, -78, -76, -76, -75, -74, -72, -71,
-70, -68, -65, -63, -63, -61, -62, -61, -59, -57, -57, -55, -54, -52, -52, -50,
-49, -47, -46, -44, -43, -41, -41, -39, -38, -37, -37, -37, -37, -36, -37, -36,
-36, -37, -36, -37, -37, -36, -38, -39, -40, -40, -40, -40, -38, -37, -37, -38,
-37, -37, -36, -35, -32, -32, -30, -27, -25, -23, -21, -19, -19, -18, -17, -17,
-16, -15, -15, -14, -14, -13, -12, -12, -10, -10, -10, -10, -10, -10, -11, -11,
-13, -14, -14, -14, -13, -12, -9, -8, -6, -5, -3, -2, -1, };