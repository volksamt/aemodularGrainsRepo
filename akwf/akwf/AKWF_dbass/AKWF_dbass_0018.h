#define DATA_LENGTH 512
#define DATA AKWF_dbass_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 6, 9, 13, 16, 19, 23, 26, 29,
32, 37, 40, 43, 46, 48, 52, 56, 58, 61, 63, 65, 67, 69, 72, 75, 76, 78, 81, 84,
86, 88, 89, 92, 93, 95, 97, 97, 100, 100, 101, 101, 102, 103, 103, 104, 104,
104, 105, 105, 104, 105, 104, 105, 104, 104, 103, 103, 103, 102, 101, 101, 101,
101, 100, 100, 100, 98, 97, 97, 96, 95, 94, 91, 90, 89, 88, 87, 86, 84, 82, 81,
80, 78, 78, 76, 75, 75, 74, 73, 72, 72, 70, 69, 67, 67, 64, 62, 60, 58, 57, 54,
52, 51, 49, 48, 46, 45, 43, 42, 41, 40, 39, 37, 36, 36, 34, 32, 31, 28, 28, 26,
24, 23, 21, 19, 18, 16, 14, 13, 10, 9, 7, 4, 1, -1, -3, -5, -7, -10, -11, -13,
-15, -16, -19, -20, -22, -24, -26, -26, -29, -30, -33, -34, -36, -39, -40, -43,
-46, -48, -51, -53, -56, -58, -61, -64, -66, -69, -71, -72, -74, -76, -78, -79,
-80, -82, -83, -85, -87, -90, -92, -94, -96, -99, -101, -104, -106, -107, -109,
-110, -112, -114, -114, -114, -116, -117, -118, -118, -118, -119, -119, -119,
-119, -118, -118, -117, -117, -116, -116, -116, -116, -115, -114, -115, -114,
-113, -112, -112, -109, -109, -107, -105, -103, -101, -98, -96, -94, -92, -89,
-87, -85, -82, -80, -78, -76, -73, -70, -67, -65, -62, -60, -58, -55, -53, -50,
-47, -45, -43, -40, -37, -35, -33, -30, -28, -27, -25, -22, -19, -18, -15, -14,
-11, -9, -5, -2, 1, 4, 9, 11, 14, 18, 19, 22, 24, 26, 29, 31, 33, 35, 36, 38,
40, 42, 44, 45, 48, 50, 51, 52, 55, 57, 59, 60, 62, 64, 67, 67, 70, 73, 73, 75,
77, 78, 80, 81, 81, 83, 84, 85, 85, 85, 86, 88, 89, 89, 90, 92, 92, 92, 94, 93,
94, 93, 96, 96, 95, 95, 95, 95, 95, 97, 97, 96, 97, 98, 100, 101, 102, 102, 103,
103, 104, 104, 104, 105, 105, 105, 105, 105, 105, 104, 103, 102, 100, 101, 100,
98, 96, 95, 94, 95, 93, 93, 92, 90, 89, 88, 85, 84, 82, 80, 79, 77, 76, 75, 74,
73, 72, 72, 71, 69, 68, 66, 64, 62, 59, 55, 52, 50, 45, 42, 38, 35, 32, 30, 28,
28, 26, 24, 24, 22, 20, 16, 14, 11, 7, 4, 1, -2, -4, -7, -9, -12, -14, -17, -21,
-24, -27, -32, -36, -40, -45, -48, -51, -54, -57, -60, -62, -65, -68, -71, -73,
-76, -78, -82, -84, -87, -88, -91, -93, -96, -99, -101, -102, -105, -106, -108,
-111, -113, -115, -116, -117, -118, -118, -118, -119, -119, -118, -118, -118,
-118, -118, -118, -118, -117, -118, -117, -117, -115, -115, -113, -111, -111,
-108, -106, -104, -102, -99, -97, -93, -92, -91, -89, -86, -85, -83, -81, -78,
-75, -73, -70, -69, -65, -63, -60, -57, -55, -51, -48, -43, -40, -36, -34, -29,
-26, -22, -18, -15, -12, -9, -6, -2, };