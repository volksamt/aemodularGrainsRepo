#define DATA_LENGTH 512
#define DATA AKWF_dbass_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 6, 10, 12, 15, 19, 23, 28, 31,
35, 39, 43, 46, 50, 52, 55, 59, 62, 65, 68, 71, 75, 77, 81, 84, 88, 90, 93, 98,
100, 104, 104, 107, 110, 112, 114, 115, 116, 117, 117, 117, 117, 118, 119, 118,
119, 118, 119, 118, 119, 118, 117, 117, 116, 114, 113, 111, 110, 107, 107, 105,
103, 101, 99, 97, 94, 91, 88, 86, 83, 81, 77, 75, 73, 70, 68, 65, 63, 60, 57,
54, 52, 50, 45, 43, 40, 37, 34, 31, 28, 25, 22, 20, 19, 17, 14, 14, 12, 10, 8,
5, 4, 1, -1, -3, -5, -8, -9, -11, -13, -15, -16, -17, -18, -19, -19, -21, -23,
-24, -25, -26, -27, -29, -30, -31, -31, -32, -32, -34, -34, -36, -37, -37, -39,
-41, -42, -43, -44, -45, -45, -45, -46, -44, -44, -44, -44, -44, -43, -43, -43,
-44, -44, -44, -45, -44, -46, -47, -48, -49, -50, -52, -52, -54, -54, -54, -57,
-56, -57, -57, -58, -59, -60, -60, -61, -62, -63, -64, -65, -66, -68, -69, -70,
-72, -71, -72, -73, -76, -77, -78, -79, -80, -81, -81, -80, -81, -80, -79, -78,
-78, -77, -76, -77, -77, -76, -78, -77, -77, -76, -76, -75, -74, -73, -73, -71,
-70, -67, -66, -65, -63, -61, -57, -55, -53, -50, -46, -43, -39, -36, -33, -30,
-27, -24, -21, -18, -15, -13, -9, -7, -4, -1, 0, 3, 4, 7, 8, 10, 12, 13, 16, 18,
21, 23, 27, 30, 33, 36, 38, 42, 44, 47, 49, 51, 53, 56, 57, 59, 61, 63, 64, 65,
68, 69, 70, 72, 73, 74, 75, 76, 77, 79, 80, 81, 81, 83, 84, 84, 84, 85, 85, 85,
85, 84, 83, 82, 82, 82, 82, 80, 80, 79, 78, 76, 76, 75, 73, 71, 70, 69, 67, 66,
64, 62, 60, 59, 57, 55, 53, 53, 51, 48, 48, 45, 43, 43, 39, 38, 35, 33, 32, 29,
27, 25, 23, 23, 21, 19, 18, 17, 16, 15, 15, 13, 11, 11, 10, 8, 7, 6, 5, 3, 2, 1,
0, 0, -2, -4, -4, -6, -7, -8, -10, -12, -13, -15, -17, -17, -17, -16, -16, -16,
-15, -16, -14, -14, -14, -14, -14, -12, -10, -9, -10, -7, -6, -4, -2, 0, 1, 1,
2, 3, 4, 4, 5, 5, 5, 8, 8, 8, 9, 9, 9, 9, 8, 8, 9, 9, 10, 10, 12, 13, 13, 14,
15, 15, 14, 13, 10, 9, 5, 4, 2, 1, -1, 0, 1, 2, 4, 3, 3, 2, 1, 0, -2, -5, -8,
-8, -9, -10, -11, -11, -13, -14, -17, -19, -23, -25, -29, -31, -33, -36, -38,
-40, -40, -42, -43, -45, -45, -48, -49, -50, -52, -55, -55, -58, -58, -59, -59,
-61, -62, -62, -63, -64, -65, -65, -67, -66, -67, -66, -64, -63, -62, -60, -60,
-59, -58, -57, -56, -57, -54, -54, -52, -50, -50, -47, -44, -43, -40, -37, -36,
-33, -31, -27, -25, -21, -18, -16, -12, -9, -7, -4, -1, };