#define DATA_LENGTH 512
#define DATA AKWF_dbass_0053

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 13, 17, 21, 23, 27, 30, 34,
37, 41, 44, 46, 50, 52, 55, 58, 61, 63, 66, 68, 70, 72, 74, 76, 77, 79, 81, 83,
84, 87, 89, 89, 90, 91, 93, 94, 95, 96, 97, 99, 100, 102, 102, 103, 104, 106,
107, 107, 107, 109, 109, 109, 109, 110, 110, 111, 111, 111, 112, 113, 112, 114,
115, 114, 115, 115, 116, 116, 116, 117, 117, 116, 116, 117, 117, 118, 117, 118,
118, 118, 119, 118, 119, 119, 119, 119, 117, 118, 117, 115, 114, 112, 111, 109,
107, 105, 102, 99, 97, 93, 91, 88, 84, 81, 78, 75, 71, 67, 64, 60, 57, 53, 51,
46, 43, 40, 35, 33, 30, 27, 24, 21, 19, 16, 15, 12, 10, 7, 5, 2, 1, -2, -5, -7,
-10, -11, -13, -15, -16, -17, -17, -19, -18, -20, -20, -19, -19, -20, -20, -18,
-19, -18, -18, -17, -17, -15, -16, -15, -14, -15, -14, -13, -13, -12, -11, -10,
-10, -9, -8, -7, -7, -5, -4, -4, -4, -4, -3, -2, -2, -3, -2, -1, -1, 1, 2, 2, 3,
4, 5, 5, 5, 6, 6, 6, 7, 7, 7, 8, 7, 7, 7, 7, 8, 8, 8, 9, 8, 9, 8, 9, 9, 9, 8, 8,
8, 8, 8, 8, 7, 6, 5, 3, 3, 2, 2, 1, 1, 1, 1, 1, 2, 2, 2, 3, 4, 3, 3, 4, 4, 4, 6,
4, 3, 3, 2, 2, 2, 0, 0, 0, -1, -2, -4, -4, -5, -5, -6, -7, -8, -7, -9, -11, -13,
-14, -14, -16, -18, -19, -20, -20, -21, -22, -22, -22, -22, -22, -22, -21, -23,
-22, -23, -24, -25, -26, -28, -29, -31, -33, -34, -34, -36, -36, -38, -40, -42,
-43, -44, -47, -48, -50, -52, -54, -56, -57, -61, -61, -61, -61, -62, -62, -63,
-62, -62, -62, -61, -60, -58, -57, -55, -53, -51, -49, -48, -45, -44, -43, -42,
-42, -42, -42, -41, -41, -40, -40, -41, -40, -39, -39, -38, -36, -36, -36, -34,
-34, -34, -34, -34, -35, -37, -36, -36, -38, -39, -39, -41, -41, -41, -41, -41,
-42, -41, -41, -41, -40, -41, -41, -42, -43, -44, -45, -47, -48, -48, -50, -51,
-51, -51, -52, -52, -52, -52, -52, -52, -52, -52, -52, -52, -52, -52, -52, -51,
-52, -52, -52, -52, -52, -52, -52, -50, -50, -49, -49, -48, -47, -46, -46, -45,
-44, -44, -43, -42, -42, -42, -41, -41, -40, -40, -39, -38, -38, -37, -36, -35,
-34, -33, -32, -31, -30, -29, -30, -29, -29, -29, -28, -28, -29, -30, -30, -31,
-32, -32, -33, -34, -35, -36, -36, -37, -37, -38, -39, -39, -40, -40, -41, -42,
-44, -45, -47, -48, -48, -49, -50, -51, -51, -52, -52, -52, -52, -52, -53, -53,
-54, -54, -54, -54, -54, -53, -53, -52, -53, -52, -52, -52, -51, -52, -52, -51,
-50, -50, -48, -47, -46, -45, -44, -42, -40, -38, -36, -33, -31, -28, -26, -24,
-21, -18, -16, -13, -9, -5, -2, };