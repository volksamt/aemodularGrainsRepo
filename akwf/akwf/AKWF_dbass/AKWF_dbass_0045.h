#define DATA_LENGTH 512
#define DATA AKWF_dbass_0045

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 6, 9, 10, 13, 14, 17, 17, 20,
23, 24, 25, 27, 30, 33, 34, 35, 37, 39, 40, 42, 43, 45, 47, 48, 50, 51, 54, 55,
57, 58, 60, 62, 63, 64, 65, 66, 67, 70, 71, 73, 74, 75, 76, 78, 78, 79, 81, 82,
83, 85, 85, 87, 87, 89, 90, 91, 92, 93, 95, 96, 97, 98, 100, 101, 102, 104, 105,
107, 108, 109, 110, 111, 112, 114, 114, 115, 116, 116, 116, 116, 116, 117, 117,
118, 117, 118, 118, 118, 119, 118, 119, 119, 119, 118, 119, 118, 119, 118, 118,
119, 119, 117, 117, 116, 116, 115, 114, 113, 112, 111, 110, 109, 109, 107, 106,
105, 103, 102, 101, 100, 100, 99, 97, 97, 95, 94, 93, 93, 92, 91, 91, 89, 88,
87, 87, 85, 85, 84, 81, 80, 79, 78, 75, 74, 73, 72, 70, 68, 66, 65, 63, 62, 60,
58, 56, 55, 53, 52, 51, 50, 49, 47, 45, 44, 43, 43, 41, 39, 37, 37, 35, 33, 32,
30, 28, 28, 26, 25, 23, 23, 22, 20, 19, 19, 18, 17, 16, 14, 13, 11, 11, 8, 8, 7,
7, 5, 3, 3, 2, 1, 0, 0, 0, 0, -1, -1, -1, -2, -2, -3, -5, -6, -6, -7, -8, -9,
-9, -10, -11, -12, -15, -16, -17, -19, -20, -20, -19, -20, -19, -19, -20, -20,
-20, -20, -20, -20, -19, -18, -18, -18, -17, -18, -18, -17, -17, -16, -17, -16,
-16, -17, -16, -15, -15, -16, -16, -16, -16, -17, -17, -16, -16, -16, -15, -14,
-13, -12, -12, -11, -9, -9, -9, -9, -9, -7, -7, -7, -7, -8, -8, -7, -8, -8, -8,
-9, -9, -9, -9, -8, -9, -9, -10, -10, -10, -11, -11, -11, -11, -11, -11, -12,
-11, -12, -13, -13, -11, -12, -12, -12, -12, -12, -12, -12, -13, -12, -13, -13,
-13, -11, -12, -12, -13, -13, -14, -14, -15, -15, -17, -18, -19, -21, -23, -25,
-27, -28, -29, -31, -32, -34, -35, -36, -37, -39, -39, -40, -40, -40, -40, -41,
-40, -40, -40, -40, -39, -39, -40, -40, -39, -40, -40, -40, -42, -43, -44, -45,
-46, -47, -49, -50, -52, -53, -54, -56, -57, -57, -58, -58, -59, -59, -60, -61,
-61, -62, -64, -66, -66, -68, -69, -71, -73, -73, -74, -75, -75, -76, -77, -78,
-79, -79, -79, -80, -81, -80, -81, -81, -81, -82, -82, -82, -82, -83, -83, -84,
-84, -84, -84, -85, -86, -87, -86, -87, -89, -88, -89, -88, -89, -89, -90, -89,
-89, -89, -89, -89, -90, -91, -90, -90, -91, -91, -91, -92, -92, -91, -91, -91,
-91, -90, -89, -89, -87, -86, -85, -84, -83, -82, -80, -78, -78, -76, -75, -74,
-71, -71, -69, -69, -67, -66, -63, -62, -61, -60, -59, -57, -57, -55, -54, -54,
-53, -52, -50, -49, -48, -46, -44, -43, -43, -39, -38, -36, -34, -32, -30, -28,
-27, -25, -23, -20, -19, -18, -16, -14, -13, -12, -10, -9, -8, -7, -4, -4, -2,
};