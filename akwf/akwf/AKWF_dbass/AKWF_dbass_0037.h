#define DATA_LENGTH 512
#define DATA AKWF_dbass_0037

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 11, 15, 18, 21, 24, 27, 29,
32, 36, 38, 41, 43, 45, 49, 52, 53, 55, 57, 59, 61, 63, 66, 68, 69, 71, 73, 75,
76, 77, 79, 81, 82, 83, 84, 84, 86, 87, 88, 88, 88, 89, 90, 90, 90, 91, 90, 91,
90, 90, 90, 90, 89, 89, 89, 88, 88, 87, 86, 85, 85, 85, 83, 83, 82, 80, 80, 79,
77, 76, 74, 73, 70, 70, 68, 66, 65, 62, 61, 58, 58, 55, 54, 51, 50, 49, 46, 44,
41, 41, 38, 36, 34, 32, 31, 29, 26, 25, 23, 22, 20, 18, 16, 14, 12, 11, 11, 9,
8, 7, 5, 4, 3, 2, 1, -1, -2, -3, -4, -3, -5, -5, -5, -7, -8, -7, -8, -8, -7, -8,
-7, -8, -7, -7, -6, -7, -5, -4, -4, -3, -3, -2, 0, 0, 3, 5, 9, 11, 14, 17, 20,
22, 25, 28, 30, 33, 36, 39, 41, 44, 47, 49, 52, 54, 56, 58, 60, 62, 65, 68, 68,
71, 73, 74, 75, 76, 78, 80, 81, 83, 84, 85, 86, 87, 88, 88, 89, 90, 90, 91, 91,
92, 92, 93, 93, 93, 92, 92, 92, 92, 91, 91, 91, 90, 89, 89, 87, 88, 86, 85, 84,
84, 82, 81, 80, 78, 77, 75, 73, 72, 70, 69, 67, 65, 63, 61, 59, 58, 55, 53, 51,
48, 46, 44, 42, 38, 36, 33, 32, 28, 27, 25, 22, 19, 17, 15, 13, 10, 8, 7, 4, 2,
0, -2, -4, -6, -7, -8, -11, -12, -14, -15, -17, -18, -19, -21, -21, -23, -24,
-25, -27, -28, -27, -29, -30, -30, -31, -32, -33, -32, -34, -33, -33, -33, -33,
-34, -33, -33, -33, -32, -32, -32, -32, -30, -30, -30, -28, -27, -27, -25, -24,
-23, -22, -20, -18, -17, -15, -14, -12, -10, -7, -6, -4, -3, -1, 1, 3, 4, 6, 7,
8, 11, 12, 13, 15, 17, 18, 19, 21, 23, 23, 25, 28, 28, 30, 31, 33, 34, 35, 36,
38, 38, 40, 41, 43, 43, 43, 44, 45, 45, 46, 46, 47, 47, 47, 47, 48, 48, 46, 47,
46, 47, 46, 46, 45, 45, 44, 44, 43, 42, 42, 39, 38, 38, 36, 35, 34, 32, 31, 30,
28, 26, 25, 23, 21, 19, 18, 16, 13, 12, 10, 7, 5, 2, 2, -1, -4, -6, -9, -11,
-13, -16, -19, -21, -24, -27, -29, -32, -35, -38, -40, -42, -46, -48, -50, -53,
-55, -59, -61, -63, -66, -69, -71, -75, -77, -79, -81, -83, -85, -88, -90, -92,
-94, -96, -97, -99, -101, -103, -104, -106, -108, -109, -110, -110, -112, -113,
-114, -115, -117, -117, -117, -118, -118, -119, -119, -120, -119, -118, -119,
-118, -118, -117, -117, -116, -115, -114, -113, -112, -110, -109, -108, -106,
-105, -103, -101, -99, -96, -95, -92, -90, -88, -85, -82, -79, -77, -74, -71,
-68, -65, -62, -59, -55, -52, -49, -46, -43, -40, -37, -33, -30, -27, -24, -21,
-18, -15, -13, -9, -6, -3, -1, };