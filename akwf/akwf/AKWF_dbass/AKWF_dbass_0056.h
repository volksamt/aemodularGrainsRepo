#define DATA_LENGTH 512
#define DATA AKWF_dbass_0056

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 8, 11, 13, 15, 17, 19, 21,
23, 24, 25, 26, 27, 28, 30, 32, 33, 34, 37, 39, 40, 41, 43, 43, 46, 47, 49, 50,
51, 53, 53, 54, 55, 56, 57, 58, 59, 59, 60, 61, 62, 62, 64, 66, 68, 69, 70, 73,
74, 76, 77, 79, 81, 82, 82, 84, 84, 84, 84, 85, 86, 88, 89, 90, 94, 96, 98, 100,
103, 105, 107, 109, 111, 112, 114, 115, 116, 117, 117, 118, 118, 119, 119, 119,
119, 118, 118, 117, 117, 116, 115, 114, 113, 112, 110, 110, 108, 106, 104, 102,
100, 98, 96, 94, 93, 91, 90, 89, 88, 87, 85, 83, 83, 81, 81, 80, 78, 77, 76, 74,
72, 71, 71, 68, 68, 67, 67, 66, 65, 65, 65, 66, 65, 64, 64, 64, 62, 61, 60, 60,
60, 59, 60, 59, 60, 60, 60, 60, 60, 61, 62, 62, 62, 62, 62, 62, 62, 62, 61, 59,
58, 57, 55, 52, 50, 48, 47, 45, 42, 41, 39, 36, 35, 33, 31, 30, 30, 28, 26, 26,
24, 22, 21, 18, 17, 15, 12, 10, 8, 4, 1, -1, -5, -9, -11, -16, -18, -22, -24,
-26, -28, -30, -32, -33, -35, -37, -39, -43, -45, -48, -50, -51, -51, -52, -54,
-56, -58, -60, -61, -61, -61, -62, -60, -61, -61, -59, -58, -58, -59, -59, -57,
-55, -58, -59, -58, -58, -60, -59, -59, -59, -57, -57, -57, -57, -56, -57, -57,
-56, -56, -54, -55, -54, -53, -52, -51, -50, -49, -49, -50, -51, -51, -52, -53,
-54, -53, -52, -51, -49, -47, -45, -45, -44, -43, -43, -42, -41, -39, -40, -39,
-38, -38, -38, -38, -37, -36, -36, -34, -33, -32, -34, -34, -33, -34, -34, -35,
-37, -37, -39, -40, -41, -41, -41, -40, -41, -42, -42, -42, -42, -42, -41, -41,
-39, -38, -36, -34, -31, -29, -29, -26, -25, -25, -22, -23, -23, -25, -28, -29,
-31, -32, -32, -31, -28, -27, -26, -25, -23, -24, -23, -24, -23, -22, -21, -21,
-21, -21, -21, -22, -22, -24, -25, -26, -26, -27, -28, -28, -27, -27, -27, -27,
-25, -23, -21, -20, -18, -18, -17, -17, -18, -19, -21, -24, -26, -29, -32, -34,
-35, -36, -37, -37, -37, -37, -35, -33, -31, -30, -29, -27, -26, -25, -26, -26,
-26, -27, -27, -28, -29, -29, -30, -30, -31, -31, -31, -31, -31, -30, -29, -29,
-27, -27, -26, -27, -28, -28, -29, -31, -31, -32, -34, -35, -37, -38, -39, -40,
-42, -42, -44, -45, -44, -44, -44, -43, -41, -40, -38, -37, -36, -35, -35, -35,
-36, -37, -38, -40, -41, -43, -46, -49, -51, -52, -55, -57, -59, -61, -63, -65,
-66, -68, -69, -69, -69, -69, -68, -67, -65, -64, -65, -64, -65, -64, -64, -65,
-65, -64, -65, -63, -63, -62, -60, -59, -57, -55, -53, -51, -49, -48, -47, -44,
-44, -42, -41, -39, -38, -37, -35, -34, -34, -33, -32, -29, -28, -26, -25, -21,
-19, -17, -13, -9, -7, -4, -1, };