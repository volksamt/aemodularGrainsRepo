#define DATA_LENGTH 512
#define DATA AKWF_dbass_0041

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 4, 5, 7, 8, 10, 12, 13, 15,
17, 19, 21, 23, 25, 28, 31, 34, 36, 39, 41, 44, 47, 48, 51, 54, 55, 58, 59, 60,
62, 63, 65, 65, 67, 68, 69, 71, 72, 73, 73, 75, 77, 77, 79, 81, 82, 84, 86, 88,
89, 92, 93, 95, 97, 98, 98, 100, 102, 103, 104, 106, 107, 109, 110, 113, 113,
113, 115, 115, 116, 115, 116, 115, 116, 116, 115, 115, 115, 115, 115, 115, 114,
114, 115, 114, 114, 115, 115, 115, 115, 116, 116, 117, 118, 117, 119, 119, 119,
119, 119, 118, 118, 117, 117, 115, 113, 111, 109, 107, 106, 103, 101, 99, 97,
95, 93, 91, 90, 88, 87, 85, 84, 82, 82, 80, 79, 77, 77, 76, 74, 74, 73, 73, 72,
70, 70, 71, 68, 68, 66, 67, 66, 64, 62, 63, 62, 61, 59, 58, 56, 55, 55, 53, 52,
52, 52, 51, 50, 48, 48, 47, 47, 45, 43, 43, 41, 40, 37, 35, 34, 32, 30, 28, 27,
25, 24, 23, 23, 23, 22, 20, 20, 20, 21, 21, 21, 20, 20, 21, 19, 19, 20, 18, 18,
17, 16, 15, 15, 14, 14, 13, 12, 12, 11, 11, 10, 10, 9, 10, 10, 10, 11, 11, 11,
11, 11, 11, 9, 10, 9, 8, 8, 6, 6, 6, 6, 6, 4, 5, 5, 5, 5, 5, 6, 5, 5, 3, 4, 5,
4, 2, 0, -1, -3, -4, -5, -5, -7, -8, -10, -12, -12, -12, -12, -12, -12, -12,
-12, -13, -15, -16, -17, -17, -17, -17, -18, -18, -20, -20, -18, -17, -16, -15,
-16, -17, -18, -17, -19, -19, -19, -20, -20, -20, -18, -18, -16, -17, -16, -15,
-13, -13, -13, -14, -15, -15, -16, -16, -16, -17, -19, -21, -20, -22, -22, -22,
-24, -23, -24, -23, -23, -25, -25, -23, -25, -27, -27, -26, -26, -29, -29, -30,
-32, -31, -33, -33, -32, -31, -33, -32, -29, -28, -28, -26, -25, -23, -21, -20,
-19, -18, -18, -18, -16, -16, -15, -16, -17, -18, -19, -21, -22, -23, -26, -28,
-29, -30, -30, -32, -32, -32, -32, -31, -29, -28, -27, -26, -24, -23, -21, -20,
-20, -20, -20, -21, -21, -22, -23, -25, -26, -27, -28, -29, -30, -32, -33, -34,
-34, -36, -37, -37, -39, -42, -45, -47, -49, -51, -54, -56, -59, -62, -63, -65,
-66, -66, -67, -67, -68, -68, -68, -67, -68, -68, -69, -69, -69, -69, -70, -70,
-69, -70, -68, -68, -67, -67, -67, -67, -67, -67, -67, -69, -69, -69, -71, -73,
-74, -76, -78, -79, -80, -81, -83, -84, -84, -84, -85, -85, -83, -83, -82, -80,
-78, -75, -72, -69, -68, -65, -64, -63, -62, -61, -60, -59, -58, -58, -59, -57,
-58, -57, -58, -58, -56, -56, -55, -54, -53, -51, -50, -48, -45, -45, -43, -42,
-39, -38, -37, -36, -36, -33, -33, -32, -32, -31, -29, -28, -27, -25, -23, -22,
-19, -17, -16, -14, -12, -10, -8, -6, -5, -4, -4, -3, 0, };