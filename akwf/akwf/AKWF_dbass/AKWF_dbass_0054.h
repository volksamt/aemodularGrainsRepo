#define DATA_LENGTH 512
#define DATA AKWF_dbass_0054

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 12, 15, 19, 22, 24, 28, 30,
32, 34, 35, 37, 38, 39, 41, 43, 45, 46, 49, 52, 54, 58, 61, 65, 70, 73, 77, 81,
83, 86, 91, 93, 96, 98, 101, 104, 106, 109, 109, 111, 112, 113, 115, 115, 115,
115, 116, 115, 115, 116, 115, 116, 116, 116, 116, 117, 117, 118, 118, 118, 119,
119, 119, 119, 117, 118, 118, 116, 117, 115, 115, 115, 115, 114, 113, 112, 112,
111, 109, 109, 108, 106, 106, 104, 104, 101, 100, 99, 97, 95, 94, 92, 91, 89,
89, 87, 85, 83, 82, 79, 77, 76, 74, 73, 72, 72, 72, 72, 73, 73, 74, 75, 75, 76,
77, 75, 76, 76, 76, 76, 76, 75, 75, 74, 73, 74, 73, 73, 72, 71, 71, 71, 70, 70,
69, 69, 68, 66, 65, 64, 61, 60, 58, 57, 55, 52, 50, 48, 45, 42, 40, 37, 35, 32,
30, 27, 23, 20, 17, 12, 9, 4, -1, -5, -10, -14, -17, -22, -24, -28, -31, -33,
-35, -35, -37, -38, -39, -38, -39, -38, -38, -38, -37, -37, -36, -36, -35, -35,
-34, -33, -32, -31, -29, -29, -27, -26, -24, -23, -21, -20, -18, -15, -14, -12,
-11, -9, -6, -7, -6, -5, -5, -5, -4, -5, -4, -5, -4, -4, -3, -3, -2, 1, 1, 0, 1,
4, 4, 3, 3, 5, 6, 8, 6, 4, 5, 5, 5, 0, 1, -3, -5, -3, -3, -2, -4, -3, -2, -5,
-9, -9, -12, -16, -17, -17, -20, -29, -30, -33, -36, -38, -39, -40, -40, -40,
-41, -42, -43, -42, -41, -41, -42, -40, -40, -39, -37, -36, -36, -34, -33, -34,
-32, -29, -27, -26, -27, -30, -28, -28, -27, -29, -30, -30, -31, -30, -30, -29,
-30, -29, -28, -26, -26, -25, -23, -22, -23, -23, -21, -20, -19, -18, -18, -17,
-17, -14, -13, -9, -7, -5, -4, -2, 1, 2, 3, 3, 3, 3, 4, 4, 4, 3, 4, 4, 4, 3, 3,
1, -2, -4, -9, -10, -14, -15, -20, -23, -26, -28, -29, -30, -30, -29, -28, -27,
-25, -23, -21, -19, -19, -20, -20, -19, -19, -21, -22, -23, -25, -27, -28, -28,
-29, -30, -31, -32, -32, -32, -32, -34, -34, -34, -34, -34, -35, -39, -41, -46,
-48, -52, -55, -59, -63, -65, -69, -70, -71, -72, -73, -73, -73, -74, -74, -73,
-75, -75, -75, -77, -77, -78, -77, -79, -78, -79, -79, -80, -79, -80, -80, -80,
-81, -82, -82, -81, -81, -82, -83, -83, -84, -85, -87, -89, -90, -92, -94, -95,
-97, -98, -100, -101, -102, -101, -101, -99, -99, -98, -95, -93, -90, -87, -84,
-82, -79, -77, -75, -74, -74, -73, -73, -73, -73, -73, -73, -72, -72, -71, -71,
-71, -70, -70, -69, -68, -66, -63, -61, -60, -58, -57, -56, -55, -54, -54, -54,
-54, -53, -54, -53, -53, -52, -50, -48, -46, -46, -42, -40, -38, -35, -34, -31,
-30, -26, -23, -22, -20, -17, -16, -14, -13, -12, -10, -8, -6, -3, -1, };