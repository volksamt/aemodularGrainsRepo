#define DATA_LENGTH 512
#define DATA AKWF_dbass_0044

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 5, 5, 6, 7, 8, 7, 9, 9, 10,
10, 12, 12, 13, 13, 16, 16, 16, 18, 19, 19, 21, 23, 24, 26, 27, 28, 29, 30, 31,
34, 35, 37, 38, 39, 41, 42, 44, 47, 49, 50, 53, 54, 56, 59, 61, 61, 63, 65, 67,
69, 69, 71, 73, 74, 75, 77, 79, 80, 81, 81, 82, 84, 85, 86, 87, 87, 89, 90, 91,
91, 94, 94, 96, 97, 98, 99, 102, 104, 104, 107, 108, 109, 110, 112, 113, 114,
116, 117, 117, 118, 118, 119, 118, 118, 118, 118, 118, 118, 118, 118, 118, 117,
116, 116, 116, 114, 116, 116, 115, 115, 116, 115, 115, 114, 115, 115, 115, 115,
115, 114, 114, 114, 113, 114, 112, 113, 111, 111, 110, 110, 109, 109, 108, 108,
106, 106, 106, 105, 103, 103, 101, 100, 101, 99, 98, 96, 94, 93, 92, 91, 90, 90,
88, 87, 87, 85, 85, 85, 84, 83, 84, 83, 81, 82, 81, 82, 80, 79, 79, 78, 77, 77,
75, 74, 74, 72, 71, 70, 68, 67, 65, 65, 63, 61, 61, 59, 56, 56, 54, 53, 52, 50,
49, 48, 47, 45, 45, 42, 42, 40, 39, 38, 36, 36, 34, 32, 32, 30, 29, 29, 28, 28,
27, 27, 26, 25, 25, 24, 23, 22, 19, 19, 18, 15, 13, 13, 11, 11, 10, 9, 9, 7, 7,
6, 7, 6, 6, 5, 6, 7, 6, 7, 7, 7, 6, 6, 6, 5, 6, 6, 5, 6, 5, 6, 6, 7, 7, 7, 7, 6,
8, 8, 9, 8, 9, 9, 8, 9, 9, 9, 9, 9, 8, 8, 7, 6, 4, 3, 2, 1, 0, -1, -3, -3, -5,
-6, -7, -7, -6, -7, -7, -7, -8, -8, -9, -9, -9, -8, -10, -11, -11, -12, -13,
-14, -14, -14, -16, -16, -17, -18, -20, -20, -20, -22, -22, -23, -26, -27, -28,
-30, -34, -33, -35, -37, -38, -39, -40, -41, -44, -44, -45, -45, -45, -46, -46,
-46, -46, -47, -47, -46, -47, -45, -45, -45, -46, -46, -46, -46, -46, -46, -47,
-48, -50, -50, -53, -53, -53, -55, -57, -57, -59, -59, -61, -62, -62, -62, -62,
-62, -62, -61, -61, -61, -60, -60, -62, -60, -61, -61, -62, -63, -63, -65, -65,
-65, -65, -66, -67, -67, -68, -68, -68, -68, -67, -67, -67, -67, -67, -69, -69,
-68, -71, -72, -74, -75, -76, -78, -79, -81, -82, -83, -85, -84, -86, -88, -87,
-87, -87, -88, -88, -88, -87, -88, -88, -88, -88, -87, -88, -87, -88, -87, -88,
-88, -88, -88, -89, -89, -89, -88, -87, -86, -87, -87, -85, -83, -84, -82, -82,
-80, -80, -78, -79, -77, -76, -75, -75, -73, -72, -73, -71, -69, -68, -68, -66,
-64, -61, -60, -57, -55, -54, -52, -50, -46, -44, -42, -40, -39, -37, -35, -34,
-33, -32, -31, -30, -30, -28, -28, -28, -28, -27, -26, -24, -25, -24, -22, -21,
-20, -18, -16, -15, -13, -11, -10, -8, -7, -6, -3, -3, -1, 0, };