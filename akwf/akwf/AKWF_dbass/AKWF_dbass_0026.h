#define DATA_LENGTH 512
#define DATA AKWF_dbass_0026

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 7, 10, 11, 15, 17, 20, 21,
23, 26, 26, 28, 31, 32, 33, 36, 37, 39, 41, 44, 45, 48, 49, 52, 53, 57, 59, 62,
63, 65, 68, 69, 72, 75, 76, 79, 81, 82, 84, 85, 87, 90, 91, 93, 94, 97, 99, 101,
103, 105, 107, 108, 110, 111, 111, 113, 113, 115, 115, 116, 116, 117, 118, 118,
118, 119, 119, 119, 119, 118, 118, 117, 117, 116, 117, 115, 115, 114, 113, 112,
112, 110, 109, 107, 105, 105, 103, 101, 99, 97, 96, 93, 93, 90, 89, 89, 86, 85,
84, 82, 81, 79, 79, 76, 76, 75, 73, 71, 72, 70, 69, 69, 67, 66, 65, 64, 63, 62,
61, 60, 60, 59, 59, 58, 57, 57, 57, 57, 56, 57, 57, 57, 57, 58, 58, 57, 58, 58,
58, 57, 57, 57, 56, 55, 55, 55, 53, 53, 53, 52, 51, 52, 51, 51, 52, 52, 52, 53,
53, 53, 54, 53, 53, 54, 53, 54, 53, 54, 54, 54, 53, 53, 52, 53, 52, 52, 52, 52,
51, 51, 51, 50, 50, 49, 49, 47, 47, 45, 44, 43, 42, 40, 40, 39, 37, 36, 36, 36,
35, 34, 34, 33, 32, 32, 31, 30, 29, 28, 28, 27, 26, 24, 23, 22, 21, 20, 19, 18,
16, 15, 13, 12, 11, 8, 8, 6, 4, 2, 1, 0, -3, -4, -5, -6, -8, -9, -10, -11, -11,
-12, -13, -14, -15, -16, -17, -19, -19, -20, -22, -22, -23, -25, -27, -26, -29,
-29, -30, -33, -34, -34, -35, -36, -38, -39, -39, -41, -41, -43, -45, -45, -45,
-47, -48, -50, -51, -51, -54, -55, -55, -55, -56, -56, -56, -56, -56, -57, -57,
-56, -56, -57, -57, -59, -60, -62, -62, -63, -63, -65, -65, -65, -65, -66, -65,
-65, -64, -64, -63, -62, -63, -63, -63, -62, -62, -62, -61, -61, -60, -60, -58,
-58, -58, -56, -55, -54, -53, -53, -51, -52, -52, -50, -50, -50, -48, -46, -46,
-44, -44, -41, -40, -39, -36, -35, -34, -34, -31, -31, -29, -28, -28, -28, -27,
-28, -27, -28, -28, -30, -30, -31, -31, -32, -31, -32, -30, -30, -30, -28, -27,
-27, -25, -23, -23, -22, -22, -23, -23, -23, -25, -25, -25, -27, -28, -30, -30,
-31, -31, -33, -33, -33, -33, -33, -34, -34, -36, -36, -39, -40, -41, -44, -45,
-45, -47, -49, -49, -50, -51, -51, -51, -52, -52, -52, -52, -52, -52, -51, -52,
-53, -54, -55, -56, -57, -58, -58, -59, -59, -61, -61, -62, -63, -63, -63, -63,
-65, -65, -66, -67, -66, -67, -67, -68, -68, -68, -69, -69, -69, -68, -69, -69,
-68, -68, -69, -68, -69, -69, -68, -68, -68, -70, -69, -69, -68, -68, -68, -68,
-67, -66, -64, -63, -61, -61, -60, -57, -56, -54, -55, -54, -52, -51, -51, -50,
-49, -49, -47, -46, -44, -44, -43, -41, -40, -38, -37, -35, -34, -33, -31, -29,
-27, -25, -24, -21, -19, -18, -17, -15, -13, -11, -10, -7, -5, -5, -2, };