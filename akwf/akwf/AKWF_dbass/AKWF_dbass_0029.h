#define DATA_LENGTH 512
#define DATA AKWF_dbass_0029

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 4, 5, 7, 8, 9, 11, 13, 14,
15, 17, 19, 20, 20, 22, 23, 25, 26, 28, 29, 32, 32, 34, 35, 36, 38, 39, 41, 42,
42, 44, 45, 47, 49, 50, 51, 51, 54, 55, 56, 59, 59, 61, 61, 64, 65, 66, 69, 69,
71, 73, 74, 77, 77, 79, 81, 83, 84, 85, 86, 88, 89, 90, 91, 94, 95, 96, 97, 98,
99, 101, 101, 102, 103, 104, 105, 107, 107, 108, 110, 110, 111, 112, 113, 113,
114, 115, 114, 115, 116, 116, 117, 117, 117, 118, 118, 118, 119, 119, 119, 118,
119, 118, 119, 119, 120, 119, 119, 118, 118, 118, 118, 118, 118, 118, 117, 118,
118, 117, 117, 118, 116, 117, 116, 116, 116, 116, 116, 116, 115, 116, 115, 115,
115, 115, 115, 114, 114, 114, 113, 114, 113, 114, 113, 113, 113, 112, 112, 112,
111, 111, 110, 110, 110, 109, 108, 109, 108, 107, 107, 107, 107, 107, 105, 106,
105, 105, 105, 105, 104, 103, 103, 102, 102, 103, 101, 101, 100, 100, 100, 99,
99, 99, 98, 97, 98, 97, 96, 97, 97, 96, 94, 94, 94, 93, 93, 92, 91, 91, 91, 91,
89, 90, 89, 88, 87, 86, 86, 85, 84, 83, 83, 83, 82, 81, 81, 79, 79, 78, 77, 77,
75, 74, 73, 73, 71, 70, 69, 67, 66, 66, 65, 63, 62, 61, 59, 58, 57, 55, 54, 52,
52, 50, 48, 46, 45, 44, 42, 40, 39, 38, 36, 35, 33, 32, 30, 28, 27, 26, 24, 22,
21, 20, 18, 16, 14, 13, 11, 10, 8, 7, 5, 4, 2, -1, -1, -4, -5, -6, -8, -10, -11,
-14, -15, -16, -18, -20, -22, -23, -25, -26, -28, -29, -32, -33, -35, -35, -38,
-40, -41, -42, -43, -44, -47, -47, -48, -49, -51, -51, -53, -54, -55, -56, -57,
-57, -58, -59, -60, -60, -61, -63, -63, -64, -65, -65, -66, -66, -67, -68, -68,
-68, -68, -68, -69, -69, -70, -69, -70, -71, -71, -70, -71, -72, -72, -72, -72,
-72, -72, -73, -73, -73, -73, -73, -74, -74, -74, -74, -75, -75, -75, -76, -75,
-76, -76, -76, -76, -77, -76, -78, -77, -78, -78, -78, -78, -78, -77, -78, -78,
-78, -78, -79, -78, -78, -78, -78, -77, -77, -77, -77, -77, -77, -77, -77, -77,
-76, -76, -77, -75, -75, -75, -75, -76, -75, -74, -74, -75, -75, -75, -74, -74,
-74, -74, -73, -73, -73, -74, -73, -73, -73, -73, -73, -72, -72, -72, -71, -72,
-71, -71, -70, -70, -70, -70, -70, -69, -70, -69, -69, -69, -69, -68, -67, -68,
-67, -67, -67, -66, -65, -65, -66, -64, -64, -64, -63, -62, -61, -61, -60, -60,
-59, -58, -57, -56, -56, -55, -54, -53, -52, -50, -50, -49, -48, -47, -46, -45,
-44, -43, -42, -41, -39, -38, -38, -36, -35, -34, -32, -31, -30, -30, -28, -26,
-25, -23, -23, -22, -20, -18, -17, -16, -15, -13, -12, -11, -9, -8, -7, -6, -4,
-3, -2, -1, };