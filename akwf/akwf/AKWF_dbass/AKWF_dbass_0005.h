#define DATA_LENGTH 512
#define DATA AKWF_dbass_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 6, 6, 7, 9, 10, 11, 12,
13, 13, 15, 15, 16, 17, 18, 19, 19, 21, 21, 22, 23, 24, 25, 27, 28, 28, 30, 31,
33, 35, 36, 37, 38, 40, 41, 41, 44, 43, 44, 45, 46, 46, 46, 46, 47, 48, 47, 48,
49, 50, 50, 50, 51, 50, 51, 52, 52, 53, 53, 53, 53, 53, 54, 54, 54, 55, 55, 56,
56, 58, 59, 59, 60, 60, 60, 61, 61, 63, 62, 63, 65, 65, 65, 65, 67, 68, 68, 68,
69, 69, 70, 70, 70, 71, 72, 73, 75, 76, 75, 75, 75, 77, 78, 79, 80, 81, 83, 85,
86, 87, 88, 90, 90, 91, 92, 93, 94, 96, 97, 98, 99, 100, 101, 101, 102, 102,
102, 102, 102, 103, 103, 104, 104, 104, 105, 106, 107, 106, 107, 107, 107, 107,
107, 107, 108, 108, 108, 108, 108, 108, 108, 108, 108, 108, 108, 107, 106, 106,
106, 105, 105, 105, 105, 106, 105, 106, 107, 107, 108, 108, 107, 108, 108, 107,
107, 106, 104, 103, 101, 100, 99, 97, 97, 95, 94, 93, 92, 91, 90, 90, 89, 88,
87, 87, 88, 88, 89, 89, 89, 89, 89, 88, 88, 88, 88, 87, 87, 87, 86, 85, 84, 84,
82, 82, 80, 79, 78, 76, 75, 74, 72, 71, 70, 68, 67, 65, 65, 63, 61, 60, 60, 58,
57, 57, 56, 57, 56, 56, 56, 55, 55, 56, 55, 54, 54, 54, 52, 52, 51, 50, 49, 48,
47, 44, 42, 41, 38, 37, 35, 34, 31, 29, 27, 26, 23, 21, 20, 18, 16, 15, 14, 12,
11, 10, 9, 8, 6, 5, 3, 1, -1, -3, -4, -7, -8, -11, -12, -15, -17, -19, -20, -23,
-25, -27, -28, -30, -32, -33, -35, -35, -37, -37, -38, -39, -41, -43, -43, -44,
-46, -48, -49, -51, -52, -54, -55, -57, -60, -60, -63, -64, -66, -66, -67, -67,
-69, -69, -70, -70, -71, -71, -71, -71, -71, -71, -71, -71, -72, -71, -71, -71,
-71, -72, -72, -73, -73, -74, -75, -75, -76, -78, -79, -79, -82, -82, -84, -85,
-87, -87, -88, -89, -89, -90, -90, -90, -91, -91, -91, -91, -92, -92, -92, -92,
-92, -93, -94, -93, -95, -96, -95, -97, -98, -100, -100, -101, -103, -103, -104,
-105, -105, -107, -107, -108, -108, -109, -109, -110, -109, -109, -109, -110,
-111, -110, -110, -111, -111, -112, -111, -113, -113, -114, -114, -114, -115,
-116, -116, -117, -117, -118, -118, -119, -119, -119, -119, -118, -118, -119,
-116, -115, -115, -114, -114, -113, -113, -113, -112, -111, -112, -110, -110,
-109, -109, -108, -107, -106, -106, -104, -104, -103, -101, -101, -100, -98,
-96, -95, -93, -92, -90, -88, -87, -84, -83, -80, -78, -76, -73, -72, -69, -67,
-65, -63, -62, -59, -57, -57, -54, -52, -51, -49, -48, -46, -44, -43, -41, -39,
-38, -37, -35, -33, -32, -30, -29, -28, -25, -24, -22, -20, -19, -17, -16, -13,
-13, -11, -10, -8, -7, -6, -3, -3, -1, };