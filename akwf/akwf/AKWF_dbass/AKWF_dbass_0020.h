#define DATA_LENGTH 512
#define DATA AKWF_dbass_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 12, 15, 17, 21, 23, 26, 29,
32, 35, 38, 39, 42, 43, 47, 50, 52, 55, 58, 58, 61, 64, 67, 69, 72, 74, 76, 78,
79, 82, 84, 86, 90, 91, 92, 95, 97, 98, 101, 103, 103, 104, 105, 105, 107, 108,
110, 109, 110, 111, 111, 111, 112, 111, 111, 112, 111, 110, 111, 113, 114, 114,
113, 114, 114, 116, 116, 116, 116, 119, 119, 118, 117, 117, 117, 114, 112, 110,
107, 105, 103, 102, 100, 100, 100, 100, 100, 99, 99, 99, 98, 96, 93, 93, 90, 88,
84, 83, 80, 78, 75, 75, 72, 70, 69, 68, 64, 62, 60, 56, 53, 50, 46, 42, 39, 37,
33, 32, 29, 26, 24, 22, 20, 18, 19, 16, 15, 12, 11, 9, 6, 3, 1, -1, -3, -5, -7,
-9, -11, -12, -13, -15, -17, -18, -20, -21, -23, -22, -24, -24, -24, -24, -25,
-25, -24, -25, -23, -23, -22, -21, -22, -21, -19, -19, -19, -19, -19, -20, -19,
-19, -18, -16, -14, -12, -11, -10, -8, -6, -6, -5, -5, -4, -5, -5, -4, -5, -6,
-4, -4, -4, -5, -4, -4, -5, -5, -6, -6, -7, -7, -8, -9, -9, -9, -9, -7, -7, -5,
-4, -3, -2, 0, 1, 2, 4, 5, 5, 7, 8, 8, 9, 9, 10, 11, 12, 13, 15, 15, 17, 20, 21,
23, 24, 27, 28, 31, 33, 34, 37, 37, 39, 41, 41, 42, 44, 46, 47, 48, 49, 50, 52,
52, 53, 54, 54, 54, 54, 53, 54, 54, 53, 53, 51, 51, 50, 49, 49, 47, 47, 45, 46,
45, 44, 44, 42, 40, 40, 38, 37, 35, 34, 33, 30, 29, 27, 27, 25, 23, 23, 22, 22,
21, 20, 20, 19, 17, 17, 17, 15, 14, 12, 11, 11, 10, 8, 8, 7, 7, 7, 7, 6, 5, 5,
5, 5, 5, 5, 4, 4, 5, 5, 5, 5, 5, 4, 4, 3, 2, 1, 0, 0, -1, -3, -3, -3, -3, -3,
-4, -4, -4, -3, -4, -5, -6, -8, -8, -9, -10, -10, -11, -12, -14, -14, -14, -14,
-15, -15, -14, -15, -15, -16, -16, -18, -19, -21, -22, -23, -25, -26, -26, -28,
-29, -28, -29, -29, -30, -31, -31, -31, -32, -32, -34, -35, -36, -37, -38, -39,
-40, -41, -43, -44, -45, -47, -47, -50, -51, -52, -55, -57, -58, -60, -62, -64,
-66, -66, -68, -70, -71, -72, -73, -73, -74, -75, -76, -77, -79, -81, -82, -85,
-87, -88, -91, -93, -94, -97, -98, -100, -100, -102, -104, -104, -105, -105,
-107, -107, -108, -109, -109, -109, -109, -108, -109, -107, -107, -107, -106,
-105, -105, -105, -104, -105, -104, -104, -102, -103, -102, -103, -102, -100,
-99, -99, -96, -95, -94, -92, -91, -88, -86, -84, -81, -80, -78, -75, -73, -71,
-69, -67, -65, -65, -61, -58, -57, -56, -52, -49, -49, -47, -45, -43, -41, -39,
-37, -36, -33, -30, -28, -27, -25, -21, -20, -20, -19, -17, -16, -14, -12, -10,
-8, -6, -3, 0, };