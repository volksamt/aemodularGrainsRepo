#define DATA_LENGTH 512
#define DATA AKWF_dbass_0042

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 5, 8, 10, 12, 14, 17, 18, 20,
22, 24, 25, 26, 27, 30, 31, 33, 35, 37, 38, 40, 42, 44, 46, 48, 50, 52, 55, 57,
59, 61, 64, 67, 69, 72, 73, 74, 76, 78, 81, 82, 84, 86, 87, 88, 89, 90, 92, 93,
94, 95, 96, 97, 97, 99, 99, 101, 101, 102, 103, 104, 104, 106, 106, 107, 109,
109, 111, 112, 113, 114, 115, 116, 116, 117, 118, 119, 119, 119, 118, 119, 119,
119, 119, 118, 118, 117, 117, 117, 116, 115, 116, 114, 114, 113, 113, 112, 111,
110, 109, 107, 106, 105, 104, 103, 101, 99, 98, 96, 94, 93, 91, 90, 89, 88, 86,
85, 83, 83, 80, 80, 79, 78, 76, 75, 75, 74, 72, 71, 70, 70, 69, 67, 66, 65, 66,
64, 64, 64, 63, 63, 62, 63, 62, 61, 62, 62, 61, 61, 61, 61, 61, 61, 60, 60, 60,
59, 59, 58, 58, 57, 56, 57, 56, 54, 53, 52, 50, 50, 47, 47, 44, 44, 42, 41, 40,
37, 35, 34, 33, 30, 30, 28, 28, 26, 24, 23, 22, 21, 19, 17, 15, 13, 12, 9, 7, 5,
2, 1, -1, -3, -4, -7, -8, -9, -12, -14, -15, -15, -17, -19, -21, -23, -24, -26,
-28, -28, -29, -30, -32, -33, -35, -36, -38, -39, -40, -41, -43, -44, -44, -46,
-47, -47, -47, -47, -47, -47, -46, -46, -46, -46, -45, -43, -43, -42, -42, -43,
-41, -42, -42, -40, -39, -40, -38, -37, -37, -36, -35, -34, -33, -34, -32, -32,
-32, -32, -32, -33, -33, -33, -33, -34, -35, -33, -33, -33, -35, -35, -36, -36,
-35, -36, -35, -34, -34, -34, -34, -33, -33, -33, -31, -32, -32, -32, -31, -33,
-33, -35, -36, -36, -38, -39, -40, -41, -42, -43, -42, -43, -43, -43, -43, -41,
-41, -40, -38, -37, -36, -35, -35, -34, -34, -33, -33, -33, -34, -34, -35, -36,
-36, -36, -36, -36, -36, -36, -36, -36, -35, -35, -34, -33, -31, -31, -29, -27,
-27, -25, -24, -24, -25, -24, -25, -25, -26, -27, -28, -28, -29, -30, -31, -31,
-32, -31, -31, -30, -29, -28, -28, -29, -28, -28, -29, -29, -28, -30, -30, -31,
-32, -34, -35, -36, -37, -39, -39, -39, -40, -41, -40, -40, -40, -40, -39, -38,
-38, -38, -38, -38, -38, -37, -38, -38, -39, -38, -38, -38, -38, -38, -39, -39,
-39, -39, -39, -39, -39, -39, -41, -40, -40, -41, -42, -42, -42, -44, -44, -46,
-47, -48, -49, -49, -50, -48, -48, -48, -48, -46, -45, -44, -42, -40, -40, -38,
-37, -36, -37, -36, -37, -36, -37, -38, -39, -39, -40, -41, -43, -44, -44, -46,
-46, -47, -48, -48, -49, -49, -48, -50, -48, -49, -49, -48, -48, -48, -48, -48,
-48, -49, -48, -48, -49, -48, -49, -48, -47, -47, -47, -45, -44, -44, -41, -41,
-39, -37, -36, -36, -33, -32, -31, -30, -29, -28, -27, -26, -24, -23, -22, -20,
-18, -16, -14, -12, -10, -8, -5, -3, };