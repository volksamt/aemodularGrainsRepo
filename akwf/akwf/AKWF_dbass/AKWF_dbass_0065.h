#define DATA_LENGTH 512
#define DATA AKWF_dbass_0065

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 6, 8, 9, 12, 15, 16, 19, 20, 24,
25, 27, 30, 31, 33, 36, 37, 39, 42, 43, 46, 47, 49, 51, 52, 54, 56, 58, 59, 61,
62, 65, 64, 66, 69, 69, 71, 71, 73, 75, 75, 77, 78, 79, 80, 81, 81, 83, 84, 85,
85, 85, 87, 88, 89, 89, 89, 90, 91, 91, 91, 92, 92, 92, 94, 93, 93, 94, 95, 94,
94, 95, 94, 96, 94, 94, 94, 95, 95, 96, 95, 94, 94, 95, 95, 95, 94, 95, 94, 94,
93, 93, 93, 93, 93, 93, 93, 93, 92, 92, 91, 91, 91, 92, 92, 91, 91, 91, 90, 90,
90, 91, 90, 89, 90, 90, 89, 89, 89, 89, 90, 89, 90, 90, 91, 90, 91, 91, 92, 92,
92, 91, 92, 93, 92, 93, 93, 94, 94, 94, 95, 96, 96, 95, 96, 97, 98, 98, 99, 99,
99, 100, 100, 100, 101, 102, 102, 103, 103, 104, 104, 105, 105, 105, 106, 107,
107, 107, 106, 107, 107, 108, 108, 109, 109, 108, 109, 109, 109, 109, 110, 110,
108, 108, 108, 108, 109, 108, 107, 107, 108, 107, 106, 106, 105, 105, 103, 103,
103, 101, 101, 100, 99, 98, 97, 96, 96, 94, 94, 92, 90, 89, 88, 87, 85, 84, 82,
81, 80, 77, 76, 75, 73, 72, 69, 67, 65, 63, 62, 60, 58, 57, 54, 52, 49, 46, 45,
43, 40, 38, 36, 34, 31, 29, 27, 25, 22, 20, 19, 16, 14, 11, 9, 7, 5, 2, 1, -1,
-3, -5, -8, -9, -12, -15, -16, -18, -20, -23, -24, -26, -27, -30, -32, -34, -35,
-37, -39, -41, -42, -44, -45, -47, -50, -51, -52, -53, -55, -56, -58, -59, -60,
-61, -63, -64, -65, -67, -67, -68, -70, -71, -71, -72, -73, -74, -74, -76, -76,
-76, -77, -78, -79, -79, -80, -80, -81, -81, -81, -83, -82, -83, -82, -83, -83,
-84, -84, -84, -84, -85, -84, -85, -84, -85, -85, -86, -85, -86, -86, -85, -86,
-85, -86, -85, -86, -86, -86, -86, -86, -87, -87, -87, -87, -87, -87, -87, -87,
-87, -87, -88, -88, -89, -87, -88, -89, -89, -89, -89, -90, -89, -90, -91, -90,
-90, -91, -91, -93, -93, -94, -94, -94, -95, -95, -96, -97, -97, -98, -98, -98,
-99, -99, -101, -101, -102, -102, -102, -103, -105, -105, -106, -106, -107,
-107, -108, -108, -108, -109, -110, -110, -111, -111, -112, -112, -113, -113,
-114, -115, -115, -115, -116, -116, -116, -117, -117, -117, -118, -118, -118,
-119, -120, -119, -118, -119, -120, -118, -119, -118, -119, -119, -118, -118,
-118, -118, -118, -117, -117, -116, -116, -116, -115, -114, -113, -112, -112,
-110, -110, -109, -108, -107, -106, -105, -103, -102, -101, -100, -99, -99, -95,
-95, -93, -92, -91, -88, -87, -86, -83, -82, -80, -79, -77, -74, -73, -70, -68,
-66, -65, -62, -61, -58, -57, -54, -51, -48, -46, -45, -42, -39, -36, -35, -33,
-30, -29, -25, -23, -20, -19, -16, -14, -11, -9, -7, -4, -2, };