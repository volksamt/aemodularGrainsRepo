#define DATA_LENGTH 512
#define DATA AKWF_dbass_0033

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 8, 10, 10, 13, 14, 16, 18,
19, 20, 22, 23, 26, 27, 29, 30, 31, 33, 35, 36, 38, 39, 41, 43, 44, 46, 48, 50,
51, 53, 54, 55, 57, 59, 60, 62, 64, 65, 65, 68, 70, 71, 73, 74, 75, 76, 77, 78,
80, 81, 83, 84, 86, 86, 88, 89, 89, 91, 92, 93, 94, 95, 96, 97, 98, 99, 99, 100,
101, 103, 104, 104, 104, 105, 106, 107, 107, 109, 109, 110, 111, 111, 111, 112,
112, 113, 112, 113, 113, 114, 115, 114, 115, 116, 115, 116, 116, 118, 117, 117,
117, 118, 118, 118, 119, 118, 118, 118, 118, 119, 119, 119, 118, 118, 118, 118,
118, 119, 118, 119, 119, 120, 119, 120, 119, 119, 120, 119, 119, 119, 118, 118,
117, 118, 117, 118, 117, 117, 117, 117, 117, 117, 117, 117, 116, 117, 116, 116,
115, 115, 115, 115, 114, 114, 114, 113, 113, 113, 114, 113, 114, 112, 112, 113,
112, 111, 111, 111, 110, 110, 110, 110, 110, 108, 108, 107, 109, 107, 108, 107,
106, 107, 106, 106, 105, 105, 105, 104, 104, 103, 103, 102, 101, 102, 101, 100,
99, 98, 98, 97, 96, 95, 95, 95, 93, 93, 92, 91, 90, 89, 89, 89, 87, 86, 85, 84,
84, 83, 82, 81, 80, 78, 78, 76, 75, 74, 73, 72, 71, 69, 68, 66, 65, 64, 62, 61,
60, 58, 57, 55, 54, 52, 51, 49, 49, 46, 45, 43, 41, 40, 37, 35, 34, 33, 31, 29,
27, 26, 24, 21, 21, 18, 17, 15, 13, 12, 10, 8, 6, 5, 3, 0, -1, -3, -5, -7, -7,
-10, -12, -12, -14, -16, -18, -20, -21, -23, -25, -26, -27, -29, -31, -33, -34,
-36, -38, -39, -41, -42, -44, -45, -47, -48, -49, -51, -51, -54, -54, -56, -57,
-59, -59, -60, -62, -63, -64, -65, -66, -67, -67, -70, -70, -70, -71, -72, -73,
-74, -75, -76, -76, -77, -78, -79, -79, -80, -81, -81, -82, -82, -83, -83, -83,
-83, -85, -85, -85, -86, -86, -85, -86, -87, -87, -87, -87, -88, -88, -88, -89,
-89, -89, -90, -89, -90, -91, -90, -91, -90, -91, -90, -91, -92, -91, -91, -91,
-91, -92, -92, -92, -92, -91, -91, -92, -92, -92, -93, -93, -93, -92, -94, -93,
-94, -93, -93, -93, -94, -94, -94, -94, -94, -94, -94, -94, -94, -95, -94, -94,
-94, -94, -94, -94, -93, -94, -93, -94, -94, -93, -93, -94, -94, -93, -94, -93,
-94, -93, -92, -93, -92, -92, -91, -90, -90, -90, -90, -88, -89, -89, -88, -88,
-88, -87, -86, -86, -86, -85, -84, -84, -84, -83, -82, -82, -80, -80, -79, -78,
-77, -76, -75, -75, -74, -72, -72, -71, -70, -69, -68, -67, -65, -64, -62, -62,
-60, -59, -57, -57, -55, -53, -52, -52, -50, -48, -48, -46, -44, -43, -41, -39,
-38, -36, -35, -32, -31, -30, -28, -26, -24, -23, -22, -19, -18, -17, -15, -13,
-11, -9, -8, -6, -5, -2, -2, 1, };