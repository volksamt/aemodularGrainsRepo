#define DATA_LENGTH 512
#define DATA AKWF_dbass_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 7, 9, 10, 14, 14, 17, 19, 20,
23, 24, 26, 29, 29, 31, 33, 35, 37, 39, 40, 42, 43, 45, 47, 47, 49, 51, 52, 53,
55, 56, 58, 59, 61, 62, 63, 64, 65, 66, 67, 68, 69, 72, 72, 73, 73, 74, 76, 76,
77, 77, 77, 79, 80, 80, 80, 80, 81, 82, 82, 82, 83, 83, 82, 82, 83, 84, 83, 84,
84, 84, 83, 83, 83, 83, 83, 82, 82, 82, 82, 81, 80, 81, 80, 81, 81, 79, 79, 79,
78, 79, 79, 78, 77, 78, 78, 77, 77, 78, 77, 76, 76, 76, 76, 76, 77, 76, 76, 76,
76, 77, 77, 77, 78, 78, 78, 79, 79, 79, 79, 80, 82, 82, 81, 83, 82, 84, 84, 85,
86, 86, 87, 87, 89, 89, 90, 91, 91, 92, 94, 94, 94, 96, 96, 97, 97, 98, 99, 99,
101, 102, 103, 104, 103, 105, 105, 106, 107, 108, 108, 108, 109, 109, 111, 111,
112, 112, 113, 114, 114, 114, 115, 115, 116, 116, 117, 117, 118, 117, 118, 118,
118, 118, 118, 119, 119, 118, 119, 118, 119, 118, 118, 118, 118, 117, 117, 116,
116, 116, 115, 114, 113, 113, 111, 112, 110, 109, 108, 107, 107, 105, 104, 103,
102, 100, 99, 97, 96, 95, 93, 91, 89, 89, 86, 85, 83, 81, 80, 78, 75, 74, 71,
70, 67, 66, 64, 61, 60, 57, 55, 53, 50, 49, 46, 43, 42, 39, 38, 36, 34, 32, 30,
27, 25, 23, 22, 19, 17, 15, 14, 11, 10, 8, 7, 4, 3, 1, -1, -2, -3, -5, -7, -9,
-10, -11, -13, -15, -16, -17, -19, -19, -20, -23, -23, -25, -26, -26, -27, -27,
-29, -30, -31, -31, -33, -33, -34, -35, -35, -36, -36, -38, -38, -40, -39, -40,
-40, -41, -41, -41, -42, -42, -44, -44, -43, -44, -44, -45, -45, -44, -44, -46,
-45, -46, -46, -46, -46, -48, -46, -47, -47, -48, -48, -47, -47, -48, -49, -49,
-49, -50, -49, -49, -51, -50, -51, -51, -52, -51, -51, -52, -53, -53, -54, -54,
-55, -55, -56, -56, -56, -57, -57, -58, -60, -60, -60, -61, -62, -63, -63, -64,
-65, -66, -65, -66, -68, -69, -70, -70, -71, -73, -74, -76, -75, -76, -77, -79,
-79, -79, -81, -82, -83, -85, -86, -86, -87, -88, -89, -89, -91, -92, -93, -94,
-95, -95, -97, -97, -99, -98, -100, -100, -102, -102, -103, -103, -104, -105,
-105, -107, -107, -108, -108, -108, -108, -108, -110, -111, -110, -111, -111,
-112, -112, -111, -112, -111, -111, -112, -111, -111, -110, -110, -110, -109,
-109, -108, -109, -108, -107, -106, -106, -105, -103, -104, -102, -101, -101,
-100, -98, -98, -96, -96, -94, -93, -91, -90, -88, -87, -85, -84, -83, -82, -79,
-77, -76, -73, -73, -71, -69, -68, -66, -64, -63, -60, -59, -57, -56, -54, -51,
-49, -47, -45, -44, -41, -38, -36, -34, -33, -32, -29, -26, -24, -23, -20, -18,
-16, -14, -12, -11, -8, -6, -3, -2, };