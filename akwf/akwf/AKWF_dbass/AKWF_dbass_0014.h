#define DATA_LENGTH 512
#define DATA AKWF_dbass_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 6, 8, 11, 13, 15, 18, 21, 24,
25, 26, 27, 28, 29, 29, 29, 30, 29, 28, 29, 29, 30, 30, 31, 32, 32, 34, 35, 36,
37, 37, 38, 37, 37, 38, 41, 43, 46, 49, 52, 53, 55, 58, 58, 60, 61, 62, 63, 65,
67, 70, 73, 73, 73, 72, 74, 75, 75, 75, 75, 77, 77, 78, 79, 79, 80, 82, 83, 84,
85, 85, 86, 87, 88, 90, 90, 91, 93, 94, 94, 95, 95, 95, 94, 94, 94, 93, 94, 95,
97, 96, 97, 95, 94, 92, 91, 90, 89, 88, 88, 87, 87, 86, 87, 87, 86, 85, 84, 83,
81, 81, 80, 80, 80, 79, 78, 77, 79, 78, 79, 80, 80, 80, 81, 81, 81, 82, 82, 82,
83, 83, 84, 83, 82, 81, 81, 80, 81, 80, 80, 82, 81, 82, 83, 83, 83, 82, 82, 80,
78, 76, 75, 74, 72, 72, 70, 70, 68, 66, 64, 63, 62, 60, 59, 57, 57, 57, 57, 57,
57, 57, 56, 56, 55, 56, 56, 58, 58, 58, 60, 62, 64, 65, 66, 67, 69, 69, 71, 71,
73, 73, 74, 74, 75, 75, 74, 74, 72, 70, 69, 68, 66, 64, 62, 60, 58, 57, 55, 53,
50, 48, 47, 45, 44, 43, 41, 39, 38, 36, 35, 34, 34, 34, 34, 34, 34, 34, 35, 35,
35, 35, 36, 35, 35, 34, 34, 33, 32, 31, 31, 28, 27, 24, 23, 20, 17, 15, 12, 10,
5, 2, 0, -4, -8, -11, -14, -17, -20, -23, -26, -28, -30, -31, -34, -34, -36,
-38, -41, -43, -45, -45, -47, -48, -49, -51, -52, -54, -56, -58, -59, -61, -63,
-64, -67, -68, -70, -71, -73, -74, -76, -78, -78, -80, -81, -82, -84, -85, -86,
-87, -88, -89, -91, -92, -94, -95, -97, -98, -100, -100, -102, -102, -103, -103,
-104, -104, -104, -106, -106, -107, -107, -109, -109, -110, -110, -111, -112,
-113, -113, -113, -115, -116, -117, -117, -118, -118, -119, -118, -118, -118,
-119, -118, -119, -119, -118, -118, -118, -116, -116, -115, -114, -112, -112,
-110, -109, -106, -105, -103, -100, -97, -95, -92, -91, -88, -86, -84, -82, -81,
-78, -76, -75, -73, -73, -72, -71, -71, -70, -70, -69, -68, -67, -66, -66, -64,
-64, -63, -62, -60, -60, -58, -56, -55, -54, -52, -50, -48, -47, -47, -46, -45,
-43, -43, -43, -42, -43, -43, -41, -41, -41, -41, -41, -40, -40, -40, -39, -38,
-38, -37, -37, -36, -34, -34, -33, -31, -31, -31, -31, -32, -32, -31, -31, -31,
-31, -31, -32, -32, -32, -31, -32, -34, -35, -37, -38, -38, -37, -36, -36, -35,
-33, -34, -33, -35, -37, -38, -39, -39, -39, -37, -35, -34, -34, -35, -36, -36,
-38, -40, -42, -41, -40, -39, -38, -37, -35, -36, -35, -36, -37, -38, -39, -40,
-39, -36, -33, -30, -29, -27, -26, -26, -26, -27, -28, -28, -27, -25, -25, -25,
-25, -24, -23, -23, -24, -25, -25, -24, -22, -21, -19, -16, -12, -8, -4, -1, };