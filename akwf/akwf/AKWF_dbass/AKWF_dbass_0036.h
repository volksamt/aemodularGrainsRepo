#define DATA_LENGTH 512
#define DATA AKWF_dbass_0036

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 8, 10, 12, 15, 17, 20, 21,
25, 26, 29, 31, 33, 36, 39, 41, 44, 47, 49, 52, 55, 57, 61, 64, 66, 69, 70, 73,
75, 78, 80, 83, 84, 88, 88, 90, 92, 94, 95, 97, 98, 100, 102, 101, 103, 104,
105, 106, 107, 107, 108, 108, 109, 109, 109, 109, 110, 110, 110, 109, 110, 111,
110, 110, 111, 111, 112, 112, 112, 113, 113, 113, 113, 114, 115, 115, 117, 117,
117, 118, 119, 119, 120, 119, 119, 118, 118, 118, 117, 116, 115, 115, 115, 114,
113, 112, 112, 110, 110, 110, 110, 108, 106, 106, 105, 103, 101, 100, 98, 96,
95, 93, 89, 88, 86, 84, 81, 78, 76, 74, 72, 69, 68, 64, 62, 59, 58, 56, 53, 52,
50, 47, 46, 46, 44, 42, 42, 41, 40, 40, 38, 38, 38, 36, 35, 34, 33, 33, 31, 30,
29, 29, 26, 24, 24, 24, 25, 23, 24, 23, 24, 25, 26, 25, 26, 27, 28, 28, 29, 31,
32, 32, 34, 35, 34, 35, 35, 36, 36, 36, 37, 38, 38, 38, 39, 39, 38, 39, 38, 39,
39, 38, 36, 35, 35, 33, 32, 32, 30, 29, 28, 27, 27, 27, 25, 25, 24, 24, 23, 21,
20, 19, 17, 15, 14, 12, 12, 11, 10, 8, 7, 5, 4, 4, 3, 3, 3, 1, 0, 0, -2, -3, -4,
-4, -7, -8, -9, -10, -12, -13, -14, -16, -16, -16, -18, -18, -18, -19, -20, -20,
-20, -21, -22, -21, -22, -22, -22, -24, -24, -25, -27, -28, -27, -28, -29, -31,
-31, -32, -33, -33, -33, -35, -35, -35, -34, -35, -34, -33, -34, -33, -34, -33,
-33, -34, -34, -34, -34, -33, -33, -33, -33, -32, -33, -31, -32, -32, -31, -31,
-31, -31, -32, -32, -31, -32, -34, -34, -36, -35, -36, -37, -37, -38, -40, -39,
-38, -39, -42, -41, -41, -42, -43, -43, -42, -42, -41, -41, -39, -39, -37, -36,
-35, -33, -32, -30, -27, -26, -25, -24, -24, -24, -24, -24, -25, -27, -27, -27,
-28, -29, -30, -31, -31, -32, -31, -31, -31, -29, -28, -27, -27, -25, -24, -24,
-24, -23, -24, -24, -24, -26, -26, -27, -28, -29, -31, -32, -33, -35, -35, -36,
-37, -38, -39, -40, -41, -43, -45, -46, -49, -50, -51, -52, -54, -55, -56, -57,
-57, -58, -59, -62, -64, -63, -65, -65, -67, -67, -67, -68, -69, -69, -70, -70,
-70, -71, -70, -70, -70, -71, -70, -69, -70, -70, -70, -71, -71, -71, -71, -72,
-72, -72, -72, -72, -72, -73, -74, -74, -72, -72, -72, -70, -70, -68, -68, -67,
-66, -64, -63, -62, -61, -60, -58, -59, -57, -57, -55, -56, -56, -55, -56, -56,
-55, -55, -55, -54, -54, -53, -53, -53, -52, -52, -52, -51, -51, -50, -50, -49,
-49, -49, -49, -48, -47, -46, -45, -44, -43, -41, -40, -40, -38, -37, -36, -36,
-34, -33, -31, -32, -30, -29, -28, -26, -24, -23, -21, -20, -17, -15, -13, -11,
-9, -6, -4, -1, };