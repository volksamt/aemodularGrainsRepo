#define DATA_LENGTH 512
#define DATA AKWF_dbass_0043

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 4, 6, 7, 10, 9, 11, 13, 15, 15,
17, 19, 20, 20, 21, 22, 23, 24, 24, 25, 24, 26, 26, 27, 27, 28, 29, 30, 31, 31,
33, 34, 35, 36, 38, 40, 42, 45, 47, 50, 51, 54, 56, 58, 60, 62, 63, 65, 66, 68,
70, 72, 73, 74, 75, 77, 78, 79, 80, 82, 84, 85, 87, 88, 88, 88, 89, 90, 91, 91,
92, 93, 94, 94, 95, 97, 97, 98, 100, 102, 102, 105, 106, 108, 110, 110, 112,
113, 115, 115, 117, 117, 117, 118, 119, 119, 119, 119, 118, 119, 119, 118, 118,
118, 117, 116, 116, 115, 114, 114, 113, 113, 112, 112, 112, 111, 111, 111, 110,
111, 110, 110, 109, 110, 107, 108, 108, 107, 107, 106, 105, 105, 105, 104, 103,
102, 102, 101, 99, 100, 99, 98, 97, 95, 95, 94, 92, 91, 89, 88, 87, 85, 83, 81,
80, 79, 77, 77, 77, 77, 75, 74, 74, 73, 73, 74, 72, 72, 71, 70, 70, 69, 69, 68,
67, 66, 66, 64, 64, 61, 60, 59, 59, 57, 56, 55, 53, 52, 50, 49, 48, 47, 46, 43,
42, 42, 39, 39, 37, 36, 36, 35, 34, 33, 32, 31, 30, 28, 27, 29, 29, 29, 29, 27,
26, 25, 24, 22, 21, 19, 19, 17, 17, 15, 14, 14, 13, 12, 9, 8, 6, 5, 6, 5, 5, 5,
4, 5, 4, 3, 3, 2, 1, 1, 1, 2, 3, 3, 5, 4, 3, 2, 1, 2, 2, 2, 4, 3, 3, 3, 3, 3, 2,
1, 0, 1, 4, 5, 5, 7, 9, 11, 10, 10, 10, 9, 9, 7, 6, 7, 6, 7, 6, 4, 3, 3, 1, -1,
-2, -1, -1, -1, 0, 0, 1, 0, -1, -2, -3, -4, -4, -5, -6, -5, -6, -6, -6, -8, -10,
-13, -16, -17, -18, -19, -18, -18, -18, -17, -18, -19, -21, -23, -25, -28, -29,
-30, -33, -34, -36, -38, -40, -42, -45, -46, -49, -50, -51, -50, -49, -49, -50,
-50, -50, -49, -50, -50, -50, -50, -49, -49, -48, -46, -46, -46, -47, -47, -49,
-50, -49, -50, -52, -52, -53, -54, -55, -57, -59, -62, -63, -64, -65, -65, -66,
-64, -65, -64, -63, -63, -63, -63, -62, -61, -62, -61, -61, -61, -61, -61, -61,
-63, -63, -65, -66, -67, -67, -67, -67, -67, -67, -65, -65, -64, -66, -66, -65,
-65, -66, -65, -67, -68, -69, -69, -71, -74, -76, -78, -82, -85, -87, -89, -89,
-92, -91, -93, -92, -91, -92, -92, -91, -92, -91, -90, -88, -88, -87, -87, -88,
-88, -86, -88, -88, -88, -89, -88, -87, -88, -87, -85, -86, -85, -84, -83, -83,
-84, -82, -81, -81, -80, -77, -77, -77, -77, -77, -77, -75, -74, -75, -73, -73,
-70, -69, -68, -65, -64, -61, -59, -57, -55, -51, -47, -46, -43, -40, -36, -35,
-31, -29, -26, -26, -24, -22, -22, -20, -19, -18, -18, -17, -15, -16, -15, -13,
-14, -14, -12, -10, -10, -6, -5, -3, -3, 0, };