#define DATA_LENGTH 512
#define DATA AKWF_dbass_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 15, 20, 27, 31, 36, 41, 47, 51,
57, 60, 64, 69, 72, 76, 80, 84, 87, 90, 94, 96, 99, 102, 104, 105, 108, 110,
112, 113, 115, 117, 118, 118, 119, 119, 119, 119, 118, 117, 115, 115, 113, 113,
112, 111, 110, 109, 107, 105, 104, 101, 101, 99, 97, 94, 92, 90, 88, 87, 84, 83,
81, 80, 79, 76, 75, 74, 72, 71, 68, 67, 64, 62, 61, 60, 58, 57, 55, 54, 54, 52,
50, 49, 46, 44, 44, 42, 41, 39, 37, 36, 36, 33, 32, 30, 28, 25, 24, 21, 18, 17,
15, 15, 14, 12, 10, 10, 7, 6, 3, 1, -1, -3, -5, -7, -8, -12, -14, -16, -20, -23,
-26, -29, -31, -33, -36, -38, -40, -43, -45, -46, -49, -52, -54, -56, -59, -62,
-65, -67, -69, -72, -74, -78, -79, -81, -83, -85, -86, -89, -89, -89, -89, -91,
-91, -92, -92, -93, -94, -94, -94, -95, -94, -93, -94, -93, -91, -90, -89, -86,
-85, -82, -79, -77, -74, -70, -67, -62, -59, -56, -53, -50, -46, -44, -39, -37,
-33, -30, -28, -24, -20, -16, -13, -11, -9, -6, -4, -2, 1, 4, 7, 9, 12, 15, 17,
19, 23, 25, 28, 29, 31, 32, 34, 35, 37, 38, 38, 40, 41, 41, 43, 42, 43, 44, 44,
44, 44, 45, 46, 46, 46, 47, 47, 46, 47, 46, 46, 46, 46, 44, 43, 44, 43, 41, 41,
41, 40, 38, 38, 37, 36, 36, 35, 33, 32, 32, 31, 32, 30, 30, 30, 28, 28, 27, 28,
28, 28, 27, 28, 27, 29, 28, 27, 29, 29, 28, 28, 30, 29, 30, 32, 31, 33, 34, 35,
35, 35, 36, 39, 38, 39, 41, 42, 41, 43, 44, 44, 44, 45, 46, 46, 46, 46, 46, 47,
49, 47, 48, 48, 49, 48, 47, 47, 47, 47, 47, 48, 48, 48, 50, 49, 50, 48, 48, 48,
47, 47, 45, 44, 42, 42, 39, 36, 35, 33, 28, 27, 25, 22, 18, 14, 11, 7, 5, 2, -3,
-5, -9, -11, -16, -19, -21, -24, -26, -28, -29, -32, -35, -37, -39, -40, -40,
-42, -43, -42, -42, -42, -42, -41, -39, -38, -37, -37, -35, -32, -29, -28, -26,
-24, -22, -20, -18, -16, -15, -11, -10, -7, -5, -3, -1, 1, 4, 6, 8, 11, 15, 18,
20, 25, 29, 31, 35, 38, 38, 41, 43, 42, 42, 43, 46, 47, 50, 51, 53, 57, 58, 59,
59, 60, 61, 60, 62, 61, 61, 60, 60, 60, 59, 57, 55, 54, 50, 48, 45, 43, 41, 39,
36, 33, 30, 27, 23, 22, 19, 16, 12, 10, 6, 5, 2, -3, -6, -10, -13, -18, -21,
-25, -27, -30, -32, -35, -38, -40, -42, -45, -47, -50, -52, -57, -57, -60, -63,
-63, -64, -67, -69, -71, -73, -75, -76, -77, -77, -78, -79, -79, -79, -80, -79,
-78, -78, -78, -79, -76, -74, -73, -71, -67, -64, -61, -58, -52, -50, -46, -41,
-37, -32, -28, -23, -18, -12, -7, -2, };