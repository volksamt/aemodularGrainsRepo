#define DATA_LENGTH 512
#define DATA AKWF_dbass_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 4, 4, 6, 7, 8, 8, 9, 11, 13,
15, 17, 18, 20, 21, 23, 23, 24, 25, 27, 27, 30, 31, 33, 35, 37, 38, 39, 42, 45,
47, 49, 52, 54, 56, 58, 60, 61, 62, 62, 63, 63, 62, 62, 62, 61, 62, 62, 62, 63,
64, 65, 66, 67, 69, 71, 71, 71, 72, 70, 69, 68, 66, 65, 64, 63, 62, 61, 60, 59,
59, 59, 58, 57, 56, 55, 53, 51, 49, 48, 48, 46, 46, 46, 45, 47, 46, 47, 48, 48,
47, 48, 47, 46, 47, 47, 49, 49, 48, 49, 49, 51, 51, 50, 52, 52, 52, 52, 52, 52,
53, 52, 51, 51, 50, 49, 49, 48, 49, 49, 51, 51, 51, 53, 54, 54, 55, 55, 55, 55,
56, 55, 55, 56, 54, 53, 53, 53, 52, 52, 52, 53, 52, 53, 54, 54, 56, 56, 56, 56,
56, 56, 57, 57, 57, 58, 58, 60, 60, 62, 63, 65, 66, 68, 70, 71, 72, 73, 74, 76,
78, 79, 80, 82, 82, 84, 86, 87, 88, 90, 91, 92, 93, 94, 94, 94, 94, 94, 95, 94,
94, 93, 94, 93, 93, 92, 91, 91, 91, 90, 90, 89, 90, 88, 89, 87, 87, 86, 85, 86,
86, 84, 85, 84, 83, 83, 83, 83, 83, 82, 82, 82, 82, 83, 82, 82, 82, 80, 81, 80,
81, 80, 81, 80, 79, 79, 78, 79, 78, 78, 77, 77, 77, 76, 74, 75, 74, 72, 71, 69,
69, 66, 65, 63, 61, 59, 58, 57, 54, 53, 51, 50, 48, 47, 46, 45, 43, 42, 40, 38,
37, 35, 33, 32, 30, 28, 26, 25, 23, 20, 20, 19, 17, 15, 14, 13, 12, 11, 10, 8,
9, 8, 7, 7, 6, 6, 5, 4, 5, 4, 4, 4, 3, 1, 1, 0, 0, -2, -1, -3, -3, -4, -5, -5,
-6, -7, -7, -7, -7, -8, -9, -9, -10, -11, -11, -12, -13, -15, -15, -17, -18,
-18, -19, -19, -20, -20, -21, -21, -24, -24, -25, -26, -28, -30, -32, -34, -35,
-37, -39, -41, -41, -43, -45, -46, -47, -48, -50, -49, -51, -53, -54, -55, -56,
-56, -58, -60, -61, -62, -63, -65, -66, -67, -68, -69, -70, -72, -73, -74, -77,
-78, -80, -82, -83, -86, -86, -88, -89, -90, -92, -93, -94, -94, -97, -96, -98,
-98, -100, -101, -101, -102, -103, -105, -105, -107, -108, -108, -110, -111,
-110, -111, -112, -113, -114, -114, -116, -117, -117, -117, -118, -118, -119,
-120, -118, -119, -118, -118, -117, -117, -115, -114, -113, -112, -112, -112,
-112, -112, -111, -110, -111, -111, -110, -111, -109, -109, -109, -108, -108,
-107, -107, -105, -104, -103, -102, -101, -99, -98, -96, -95, -92, -91, -91,
-89, -88, -87, -85, -84, -82, -80, -79, -77, -76, -73, -71, -68, -66, -65, -63,
-61, -61, -59, -56, -54, -52, -51, -48, -45, -44, -43, -41, -39, -36, -36, -35,
-34, -32, -31, -30, -26, -24, -22, -19, -18, -15, -14, -12, -9, -6, -4, -2, -1,
};