#define DATA_LENGTH 512
#define DATA AKWF_dbass_0064

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 3, 4, 4, 5, 5, 6, 7, 7, 7, 8, 9,
10, 12, 13, 14, 16, 18, 19, 20, 21, 24, 25, 25, 26, 27, 27, 27, 27, 26, 25, 24,
24, 24, 23, 23, 23, 27, 28, 28, 29, 30, 29, 29, 31, 31, 30, 30, 29, 29, 29, 26,
26, 23, 21, 18, 17, 18, 19, 20, 17, 17, 15, 15, 18, 21, 22, 22, 24, 25, 26, 29,
32, 33, 34, 34, 32, 31, 32, 32, 31, 31, 30, 29, 28, 27, 27, 29, 31, 31, 33, 33,
35, 37, 40, 40, 41, 42, 43, 45, 44, 46, 47, 47, 49, 49, 48, 45, 45, 45, 47, 48,
48, 49, 49, 50, 51, 53, 54, 57, 59, 61, 63, 66, 67, 70, 71, 71, 72, 74, 76, 78,
78, 80, 82, 81, 82, 81, 81, 80, 80, 78, 78, 75, 75, 73, 70, 69, 68, 65, 65, 63,
63, 62, 61, 61, 61, 61, 61, 61, 60, 59, 58, 58, 56, 54, 52, 50, 47, 46, 45, 44,
42, 41, 40, 39, 38, 38, 38, 38, 38, 38, 38, 40, 39, 40, 41, 41, 42, 41, 42, 43,
42, 43, 43, 42, 41, 41, 43, 45, 47, 47, 49, 50, 52, 52, 55, 57, 59, 61, 62, 63,
64, 65, 65, 65, 65, 64, 63, 62, 62, 61, 59, 60, 58, 57, 55, 55, 54, 53, 53, 54,
54, 54, 54, 56, 56, 57, 58, 59, 60, 61, 61, 62, 62, 62, 62, 62, 63, 63, 63, 63,
63, 63, 62, 59, 59, 58, 58, 57, 56, 54, 53, 51, 51, 50, 49, 48, 47, 46, 46, 45,
45, 43, 42, 42, 41, 40, 38, 36, 36, 34, 33, 30, 30, 27, 24, 22, 20, 17, 15, 11,
9, 7, 4, 1, -2, -5, -7, -9, -12, -13, -15, -16, -17, -19, -20, -22, -22, -23,
-24, -26, -27, -28, -30, -31, -33, -35, -37, -40, -41, -43, -45, -46, -50, -51,
-53, -54, -55, -56, -57, -58, -58, -59, -59, -59, -60, -60, -59, -59, -58, -58,
-58, -56, -55, -55, -55, -54, -53, -52, -52, -52, -51, -51, -51, -51, -51, -50,
-51, -51, -51, -51, -50, -51, -52, -53, -53, -54, -54, -56, -56, -56, -56, -55,
-56, -56, -56, -55, -55, -54, -53, -53, -53, -52, -51, -51, -50, -49, -49, -48,
-47, -47, -47, -47, -47, -46, -47, -47, -46, -46, -46, -46, -46, -46, -46, -47,
-47, -47, -48, -48, -49, -49, -50, -52, -54, -54, -56, -58, -59, -61, -62, -64,
-65, -65, -66, -68, -68, -70, -71, -72, -74, -76, -78, -80, -82, -84, -87, -89,
-92, -96, -98, -101, -104, -106, -109, -111, -113, -115, -116, -118, -118, -119,
-118, -119, -119, -119, -118, -118, -119, -117, -117, -117, -117, -116, -117,
-115, -115, -113, -113, -110, -109, -105, -103, -101, -99, -95, -92, -89, -86,
-83, -81, -78, -75, -71, -70, -66, -63, -59, -55, -52, -48, -44, -41, -38, -35,
-32, -29, -26, -23, -21, -19, -15, -14, -12, -10, -8, -7, -4, -3, -2, 0, };