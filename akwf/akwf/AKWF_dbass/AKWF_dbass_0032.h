#define DATA_LENGTH 512
#define DATA AKWF_dbass_0032

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 6, 7, 8, 11, 12, 14, 16, 17,
19, 20, 22, 24, 26, 28, 29, 30, 33, 35, 36, 37, 39, 41, 42, 44, 45, 47, 48, 49,
51, 53, 54, 56, 57, 58, 61, 62, 64, 64, 66, 67, 68, 69, 71, 72, 73, 74, 75, 77,
77, 78, 79, 81, 82, 83, 84, 85, 86, 87, 88, 89, 89, 90, 91, 91, 92, 94, 94, 95,
95, 96, 97, 97, 98, 100, 100, 100, 101, 102, 102, 102, 104, 103, 105, 104, 105,
105, 107, 106, 107, 107, 108, 108, 109, 110, 109, 110, 111, 110, 111, 111, 112,
112, 112, 113, 112, 112, 113, 113, 114, 114, 115, 115, 114, 115, 115, 116, 115,
116, 116, 116, 116, 116, 117, 117, 117, 118, 117, 118, 118, 117, 118, 118, 118,
118, 117, 119, 119, 118, 118, 119, 118, 119, 119, 118, 119, 119, 119, 119, 118,
119, 119, 119, 118, 118, 118, 118, 118, 119, 119, 118, 119, 119, 118, 118, 118,
118, 117, 118, 117, 118, 118, 116, 116, 116, 115, 117, 116, 116, 115, 116, 115,
115, 114, 113, 114, 113, 113, 112, 112, 111, 110, 110, 109, 109, 108, 108, 107,
108, 107, 106, 106, 105, 104, 104, 103, 101, 101, 100, 100, 99, 98, 98, 97, 95,
95, 94, 93, 92, 91, 90, 89, 88, 87, 86, 85, 84, 82, 82, 81, 79, 78, 77, 77, 75,
73, 72, 70, 69, 68, 67, 65, 64, 62, 61, 60, 59, 57, 56, 54, 53, 52, 50, 48, 46,
45, 44, 42, 41, 39, 38, 36, 34, 32, 31, 30, 28, 26, 24, 23, 21, 20, 19, 17, 14,
13, 12, 10, 9, 7, 6, 4, 2, 1, -1, -2, -3, -4, -6, -7, -9, -10, -12, -13, -14,
-15, -17, -18, -20, -20, -22, -23, -25, -25, -26, -28, -29, -30, -31, -32, -33,
-35, -36, -37, -38, -39, -40, -41, -42, -42, -44, -44, -46, -46, -47, -48, -47,
-49, -49, -50, -50, -51, -52, -52, -53, -53, -53, -54, -53, -55, -55, -55, -55,
-56, -57, -56, -57, -58, -59, -58, -59, -59, -58, -59, -59, -59, -60, -60, -60,
-60, -59, -59, -60, -61, -60, -60, -60, -61, -60, -60, -61, -60, -60, -61, -61,
-62, -61, -61, -61, -62, -61, -61, -62, -62, -62, -62, -62, -61, -62, -62, -61,
-62, -62, -61, -61, -62, -61, -61, -62, -61, -61, -60, -60, -61, -61, -61, -61,
-60, -60, -61, -60, -60, -60, -61, -60, -60, -59, -61, -60, -60, -60, -60, -60,
-60, -60, -59, -59, -59, -60, -60, -60, -60, -59, -59, -58, -58, -59, -59, -58,
-58, -58, -57, -57, -57, -57, -56, -56, -55, -56, -55, -55, -54, -54, -54, -54,
-53, -53, -52, -52, -51, -50, -50, -49, -48, -48, -47, -46, -46, -45, -44, -44,
-43, -43, -42, -41, -40, -39, -38, -38, -37, -36, -36, -35, -34, -32, -31, -30,
-30, -28, -27, -26, -25, -23, -23, -22, -20, -19, -18, -17, -15, -14, -13, -11,
-9, -8, -6, -5, -4, -3, -2, };