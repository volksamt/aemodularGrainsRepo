#define DATA_LENGTH 512
#define DATA AKWF_dbass_0058

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 2, 0, 0, 0, 1, 3, 4, 4, 6, 8, 8, 6,
2, 4, 5, 8, 10, 11, 13, 15, 17, 18, 19, 21, 25, 28, 29, 30, 36, 40, 41, 39, 37,
37, 37, 38, 39, 39, 42, 44, 43, 41, 38, 39, 39, 39, 37, 38, 39, 39, 42, 42, 45,
44, 44, 45, 42, 43, 43, 45, 48, 49, 51, 52, 54, 55, 56, 56, 57, 57, 59, 61, 63,
64, 64, 64, 65, 66, 67, 68, 69, 68, 67, 66, 67, 67, 65, 62, 60, 60, 59, 59, 57,
56, 57, 58, 57, 58, 59, 59, 60, 61, 63, 64, 66, 66, 68, 68, 68, 68, 67, 65, 63,
62, 61, 62, 62, 63, 63, 61, 61, 63, 64, 65, 67, 69, 72, 75, 77, 80, 82, 84, 85,
86, 88, 90, 92, 93, 95, 94, 95, 95, 94, 92, 91, 91, 91, 90, 91, 91, 92, 91, 92,
94, 96, 96, 97, 97, 99, 100, 100, 101, 101, 100, 99, 99, 99, 98, 96, 95, 95, 95,
96, 97, 97, 96, 98, 99, 101, 102, 103, 104, 104, 103, 102, 99, 98, 95, 93, 89,
87, 84, 81, 77, 73, 71, 69, 67, 64, 64, 63, 63, 63, 63, 61, 62, 63, 62, 64, 65,
68, 69, 73, 74, 74, 75, 76, 76, 76, 76, 76, 75, 73, 71, 69, 66, 62, 58, 53, 49,
45, 41, 37, 34, 31, 28, 24, 20, 18, 16, 15, 15, 13, 13, 11, 12, 12, 11, 12, 13,
14, 16, 17, 18, 19, 20, 20, 20, 20, 19, 18, 17, 16, 14, 12, 10, 8, 5, 2, -1, -3,
-5, -7, -9, -11, -13, -15, -16, -17, -18, -19, -20, -22, -22, -23, -24, -25,
-25, -25, -26, -28, -28, -29, -30, -31, -31, -31, -30, -29, -28, -29, -28, -28,
-28, -28, -29, -28, -28, -28, -29, -31, -31, -33, -33, -35, -35, -37, -39, -40,
-41, -43, -43, -45, -46, -45, -46, -47, -48, -49, -50, -51, -52, -52, -53, -55,
-57, -58, -60, -62, -63, -64, -65, -65, -67, -69, -71, -71, -73, -73, -73, -73,
-72, -71, -69, -68, -67, -66, -64, -63, -62, -62, -62, -61, -61, -62, -63, -64,
-65, -67, -69, -71, -72, -74, -76, -78, -81, -84, -85, -88, -90, -91, -94, -96,
-98, -101, -103, -107, -109, -112, -114, -115, -117, -117, -119, -119, -119,
-119, -118, -119, -119, -117, -116, -116, -114, -112, -110, -109, -109, -106,
-105, -105, -104, -102, -102, -102, -102, -102, -102, -101, -101, -101, -102,
-102, -102, -101, -100, -100, -100, -98, -98, -98, -97, -97, -97, -97, -96, -97,
-96, -96, -96, -95, -94, -95, -93, -93, -92, -90, -90, -89, -88, -87, -85, -84,
-83, -82, -81, -81, -80, -79, -78, -77, -75, -74, -74, -73, -71, -69, -68, -67,
-65, -64, -62, -61, -59, -58, -56, -55, -53, -53, -51, -48, -47, -45, -43, -41,
-39, -37, -37, -34, -31, -30, -27, -25, -23, -22, -20, -18, -15, -15, -15, -13,
-13, -12, -10, -10, -8, -6, -5, -3, -2, 0, };