#define DATA_LENGTH 512
#define DATA AKWF_dbass_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 7, 10, 12, 15, 17, 20, 22,
25, 28, 31, 33, 37, 40, 42, 45, 48, 50, 52, 55, 56, 58, 59, 61, 63, 65, 67, 67,
68, 71, 72, 74, 75, 77, 79, 80, 82, 83, 86, 86, 87, 88, 89, 91, 91, 91, 93, 94,
94, 95, 96, 97, 99, 100, 100, 102, 102, 102, 103, 103, 103, 102, 102, 103, 104,
105, 105, 106, 105, 106, 107, 108, 108, 108, 109, 108, 109, 108, 108, 106, 107,
105, 104, 103, 103, 101, 101, 100, 97, 97, 94, 92, 90, 88, 86, 86, 83, 81, 79,
76, 74, 71, 69, 67, 64, 62, 58, 56, 53, 50, 47, 44, 40, 37, 34, 30, 27, 23, 19,
16, 12, 9, 5, 2, -2, -4, -8, -11, -14, -17, -19, -21, -24, -27, -30, -33, -36,
-38, -41, -43, -45, -49, -50, -53, -56, -57, -59, -62, -63, -66, -69, -71, -73,
-76, -76, -78, -80, -82, -84, -86, -87, -89, -92, -93, -95, -96, -98, -101,
-103, -106, -107, -108, -111, -111, -112, -113, -115, -116, -117, -117, -118,
-119, -119, -119, -119, -119, -119, -118, -118, -117, -117, -117, -117, -116,
-116, -114, -114, -113, -110, -110, -109, -108, -105, -102, -101, -100, -98,
-96, -95, -93, -91, -89, -88, -86, -85, -83, -82, -80, -79, -77, -75, -73, -73,
-71, -70, -68, -66, -65, -63, -62, -60, -57, -56, -54, -52, -51, -49, -48, -46,
-45, -43, -42, -40, -38, -35, -33, -31, -28, -26, -23, -22, -19, -17, -16, -13,
-11, -8, -7, -5, -3, 0, 2, 4, 6, 8, 10, 11, 13, 14, 16, 17, 19, 19, 21, 22, 25,
26, 27, 29, 31, 32, 33, 35, 37, 39, 39, 41, 43, 45, 47, 50, 52, 53, 55, 57, 59,
60, 62, 63, 65, 68, 68, 70, 71, 75, 77, 77, 80, 81, 83, 86, 87, 89, 90, 90, 91,
92, 94, 94, 94, 95, 96, 97, 97, 97, 97, 98, 97, 96, 96, 96, 95, 94, 94, 94, 95,
94, 93, 93, 93, 92, 92, 91, 90, 89, 90, 89, 89, 89, 89, 90, 90, 89, 90, 89, 89,
88, 88, 87, 85, 84, 82, 81, 80, 79, 78, 77, 75, 74, 73, 71, 70, 66, 64, 63, 59,
57, 56, 52, 51, 49, 46, 43, 40, 37, 35, 32, 28, 25, 22, 19, 15, 13, 10, 6, 4, 1,
0, -1, -4, -8, -10, -12, -14, -17, -19, -23, -25, -28, -29, -32, -34, -36, -39,
-40, -43, -45, -47, -49, -51, -53, -55, -57, -58, -59, -61, -63, -63, -65, -67,
-69, -69, -70, -71, -72, -74, -74, -76, -76, -77, -76, -77, -79, -79, -79, -80,
-80, -80, -80, -79, -79, -79, -78, -79, -78, -77, -77, -77, -76, -76, -75, -74,
-73, -73, -72, -71, -71, -70, -69, -68, -66, -64, -62, -61, -61, -59, -58, -56,
-56, -55, -54, -51, -51, -50, -49, -46, -45, -44, -42, -41, -38, -37, -35, -34,
-32, -31, -30, -27, -25, -24, -22, -18, -17, -14, -11, -9, -8, -5, -3, -1, };