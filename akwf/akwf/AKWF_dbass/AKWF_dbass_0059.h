#define DATA_LENGTH 512
#define DATA AKWF_dbass_0059

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 7, 9, 10, 12, 12, 14, 15,
16, 18, 19, 20, 22, 23, 24, 24, 26, 27, 26, 27, 28, 29, 30, 30, 31, 33, 33, 35,
36, 38, 39, 41, 43, 46, 48, 50, 53, 55, 58, 59, 62, 65, 67, 69, 70, 71, 74, 75,
77, 78, 80, 82, 84, 85, 88, 90, 92, 94, 96, 99, 100, 103, 104, 106, 107, 109,
110, 112, 113, 114, 114, 117, 117, 118, 118, 118, 119, 120, 119, 118, 118, 117,
118, 117, 117, 116, 116, 116, 115, 115, 115, 115, 115, 114, 115, 114, 113, 113,
113, 112, 111, 111, 109, 108, 108, 108, 107, 105, 103, 102, 101, 99, 97, 96, 94,
92, 89, 87, 86, 83, 81, 79, 78, 76, 75, 73, 71, 70, 68, 67, 66, 64, 63, 61, 60,
58, 57, 56, 54, 52, 51, 49, 46, 46, 43, 42, 39, 39, 38, 37, 36, 35, 35, 34, 33,
34, 33, 33, 33, 33, 32, 31, 30, 29, 28, 26, 24, 22, 20, 18, 17, 15, 13, 12, 11,
9, 8, 7, 4, 5, 4, 4, 4, 3, 3, 3, 4, 4, 3, 2, 1, 0, -1, -1, -1, -2, -5, -4, -4,
-5, -6, -8, -11, -12, -13, -13, -13, -14, -13, -12, -14, -14, -16, -17, -18,
-20, -21, -23, -23, -26, -29, -31, -35, -37, -40, -43, -45, -48, -47, -47, -47,
-45, -45, -47, -45, -46, -45, -45, -45, -43, -42, -40, -39, -38, -39, -38, -38,
-36, -34, -34, -35, -32, -30, -28, -28, -28, -28, -28, -27, -26, -25, -23, -21,
-20, -19, -17, -16, -16, -15, -15, -15, -13, -14, -16, -16, -15, -16, -17, -19,
-18, -18, -18, -17, -16, -14, -12, -11, -12, -10, -8, -9, -8, -6, -6, -5, -4,
-3, -4, -3, -3, -2, -1, -1, -1, -1, 0, 2, 1, 1, 0, 0, 0, -1, -1, -3, -4, -3, -4,
-5, -6, -8, -10, -11, -13, -15, -18, -20, -24, -25, -29, -31, -33, -36, -39,
-42, -42, -44, -46, -47, -48, -49, -50, -50, -51, -50, -51, -50, -49, -49, -49,
-50, -49, -49, -49, -49, -49, -50, -49, -50, -50, -51, -51, -53, -53, -54, -54,
-55, -57, -56, -56, -57, -57, -57, -57, -57, -58, -58, -58, -59, -60, -62, -63,
-64, -65, -66, -67, -67, -69, -70, -69, -70, -71, -71, -70, -69, -68, -68, -67,
-67, -65, -64, -64, -64, -64, -65, -65, -64, -64, -67, -67, -67, -68, -69, -69,
-70, -70, -70, -70, -71, -72, -71, -72, -73, -74, -74, -75, -75, -75, -77, -77,
-78, -79, -79, -80, -80, -81, -82, -83, -83, -83, -83, -83, -83, -83, -82, -80,
-79, -78, -77, -74, -72, -69, -67, -64, -63, -61, -59, -56, -55, -53, -51, -49,
-47, -45, -45, -43, -41, -39, -38, -37, -34, -32, -31, -31, -30, -28, -26, -26,
-25, -26, -24, -23, -23, -22, -21, -20, -18, -16, -15, -13, -13, -11, -10, -10,
-9, -8, -7, -7, -7, -7, -7, -5, -7, -6, -5, -5, -3, -1, -1, };