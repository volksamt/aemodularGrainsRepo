#define DATA_LENGTH 512
#define DATA AKWF_dbass_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 4, 4, 6, 6, 7, 8, 8, 8, 9,
10, 11, 10, 11, 12, 13, 13, 14, 14, 15, 16, 16, 18, 19, 20, 22, 22, 24, 24, 26,
27, 28, 29, 30, 30, 31, 32, 32, 33, 34, 34, 35, 35, 35, 35, 35, 37, 36, 37, 39,
38, 40, 39, 41, 41, 42, 43, 44, 45, 45, 48, 49, 50, 51, 53, 53, 54, 55, 56, 58,
59, 62, 62, 63, 64, 66, 67, 69, 70, 71, 73, 74, 75, 77, 77, 79, 80, 80, 80, 81,
83, 83, 84, 83, 84, 86, 87, 88, 89, 90, 91, 93, 94, 94, 96, 97, 99, 100, 102,
103, 104, 105, 105, 106, 107, 108, 110, 110, 111, 111, 113, 114, 115, 114, 115,
116, 117, 117, 117, 118, 119, 118, 119, 119, 119, 119, 118, 119, 118, 118, 119,
118, 117, 118, 118, 117, 115, 115, 114, 114, 113, 113, 113, 113, 112, 111, 111,
111, 111, 110, 111, 110, 110, 110, 110, 109, 109, 109, 107, 108, 106, 104, 104,
103, 101, 99, 98, 98, 95, 93, 92, 91, 90, 89, 89, 88, 88, 87, 87, 86, 86, 86,
86, 87, 87, 87, 87, 87, 87, 88, 87, 87, 87, 87, 86, 85, 86, 85, 84, 83, 82, 82,
80, 78, 77, 76, 75, 73, 71, 70, 69, 68, 66, 64, 65, 62, 62, 61, 59, 58, 58, 58,
58, 57, 56, 57, 56, 57, 57, 56, 56, 56, 55, 55, 53, 52, 52, 50, 48, 47, 45, 43,
40, 40, 37, 35, 33, 30, 30, 28, 25, 24, 22, 20, 19, 17, 15, 16, 14, 12, 12, 11,
9, 7, 5, 4, 1, 0, -2, -4, -6, -8, -11, -12, -14, -16, -17, -19, -22, -24, -26,
-27, -28, -30, -32, -33, -34, -36, -36, -39, -40, -41, -42, -43, -45, -47, -48,
-50, -52, -53, -54, -54, -57, -58, -60, -61, -61, -63, -64, -64, -65, -66, -66,
-66, -66, -68, -67, -68, -68, -67, -67, -67, -67, -66, -67, -66, -67, -67, -68,
-67, -67, -67, -69, -69, -69, -71, -71, -73, -73, -74, -76, -77, -78, -78, -80,
-81, -80, -81, -81, -81, -81, -82, -82, -81, -81, -80, -81, -80, -81, -82, -81,
-82, -81, -82, -82, -83, -84, -84, -85, -86, -87, -88, -88, -90, -90, -91, -93,
-93, -94, -95, -95, -96, -97, -98, -98, -99, -98, -99, -99, -99, -101, -101,
-101, -101, -102, -102, -103, -104, -104, -104, -105, -106, -106, -107, -107,
-108, -108, -109, -109, -109, -109, -110, -109, -109, -110, -109, -109, -109,
-108, -107, -107, -107, -108, -106, -106, -106, -105, -104, -103, -103, -102,
-102, -101, -100, -101, -100, -98, -98, -97, -96, -94, -94, -93, -90, -90, -89,
-87, -85, -83, -81, -79, -77, -76, -74, -72, -70, -68, -65, -64, -62, -60, -59,
-57, -55, -54, -53, -51, -49, -48, -48, -45, -43, -42, -41, -39, -37, -36, -36,
-34, -32, -31, -29, -27, -26, -25, -22, -21, -20, -17, -16, -14, -13, -10, -9,
-8, -6, -5, -3, -1, 0, };