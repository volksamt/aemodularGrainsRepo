#define DATA_LENGTH 512
#define DATA AKWF_dbass_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 9, 11, 13, 13, 13, 14, 14, 15,
15, 17, 18, 18, 20, 21, 23, 25, 26, 28, 29, 30, 31, 31, 32, 35, 35, 37, 38, 40,
42, 44, 45, 49, 51, 54, 56, 59, 62, 65, 67, 67, 69, 70, 71, 72, 71, 71, 70, 70,
69, 69, 69, 69, 70, 72, 73, 76, 78, 80, 81, 82, 82, 82, 81, 79, 77, 75, 73, 71,
69, 68, 67, 66, 65, 64, 63, 62, 61, 59, 58, 55, 53, 50, 48, 46, 45, 44, 43, 43,
43, 43, 43, 44, 44, 44, 43, 43, 43, 43, 43, 43, 44, 44, 44, 45, 46, 46, 47, 48,
49, 50, 50, 50, 49, 49, 49, 49, 48, 48, 47, 46, 46, 47, 47, 48, 48, 48, 49, 50,
50, 51, 51, 53, 53, 53, 53, 53, 53, 53, 52, 51, 51, 49, 49, 49, 49, 48, 49, 49,
50, 50, 50, 50, 50, 50, 49, 49, 50, 50, 49, 49, 50, 50, 51, 53, 54, 56, 57, 59,
61, 63, 65, 66, 68, 70, 71, 72, 74, 76, 78, 80, 81, 84, 85, 87, 87, 89, 91, 91,
92, 92, 93, 93, 92, 92, 92, 91, 92, 91, 90, 89, 90, 89, 90, 88, 88, 88, 88, 88,
88, 87, 87, 87, 86, 86, 85, 85, 84, 83, 83, 81, 81, 81, 80, 82, 80, 80, 80, 80,
79, 80, 80, 78, 79, 79, 79, 79, 78, 78, 77, 77, 78, 77, 77, 77, 78, 77, 77, 77,
75, 75, 75, 74, 72, 72, 69, 68, 66, 63, 62, 61, 58, 57, 55, 53, 52, 50, 49, 47,
46, 45, 43, 42, 40, 39, 37, 36, 33, 31, 28, 26, 24, 22, 21, 19, 18, 16, 14, 13,
12, 11, 9, 9, 8, 6, 6, 5, 5, 5, 5, 4, 3, 2, 2, 2, 1, 0, -2, -3, -3, -4, -4, -5,
-5, -7, -6, -7, -7, -7, -8, -8, -8, -7, -8, -9, -8, -10, -11, -11, -12, -13,
-14, -15, -15, -18, -18, -19, -19, -20, -19, -20, -21, -23, -24, -25, -27, -28,
-31, -33, -34, -37, -39, -40, -42, -44, -45, -45, -47, -49, -48, -50, -52, -52,
-53, -56, -56, -58, -60, -61, -63, -65, -65, -67, -69, -69, -71, -72, -73, -76,
-76, -77, -79, -80, -81, -84, -84, -87, -87, -89, -90, -92, -93, -94, -95, -97,
-96, -98, -98, -100, -101, -100, -102, -103, -104, -104, -105, -106, -107, -108,
-109, -111, -111, -111, -113, -113, -115, -115, -116, -117, -117, -118, -118,
-119, -119, -119, -119, -119, -118, -118, -117, -117, -116, -115, -114, -114,
-113, -112, -111, -113, -111, -111, -111, -112, -112, -112, -112, -111, -111,
-111, -110, -107, -106, -105, -105, -103, -102, -101, -100, -99, -98, -96, -94,
-93, -91, -89, -88, -85, -83, -83, -81, -81, -79, -77, -76, -73, -72, -69, -66,
-64, -62, -59, -58, -54, -51, -50, -49, -50, -48, -47, -44, -41, -40, -37, -36,
-35, -34, -31, -30, -28, -26, -25, -23, -21, -19, -16, -13, -10, -7, -4, -3, 0,
};