#define DATA_LENGTH 512
#define DATA AKWF_dbass_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 9, 11, 13, 17, 19, 21, 22,
23, 25, 25, 27, 29, 30, 30, 31, 33, 33, 34, 35, 36, 38, 39, 41, 43, 45, 47, 49,
50, 51, 54, 56, 58, 59, 62, 62, 63, 65, 66, 68, 69, 72, 74, 75, 76, 79, 81, 84,
85, 87, 88, 90, 92, 95, 97, 97, 99, 101, 103, 104, 104, 106, 105, 106, 106, 106,
106, 105, 104, 103, 102, 101, 100, 100, 99, 98, 98, 98, 99, 98, 100, 101, 103,
105, 107, 108, 109, 110, 111, 112, 113, 115, 116, 117, 118, 119, 119, 117, 116,
117, 117, 115, 113, 112, 110, 107, 105, 104, 102, 100, 98, 97, 95, 93, 92, 92,
90, 89, 89, 89, 88, 87, 87, 87, 87, 87, 86, 84, 85, 83, 82, 81, 80, 79, 76, 74,
72, 70, 66, 63, 62, 59, 57, 55, 54, 51, 50, 49, 47, 45, 45, 42, 42, 39, 37, 34,
33, 29, 26, 23, 21, 18, 14, 11, 9, 5, 3, 1, -2, -4, -6, -8, -10, -11, -13, -15,
-16, -17, -18, -19, -20, -21, -21, -21, -22, -21, -22, -22, -24, -25, -25, -26,
-28, -29, -31, -33, -37, -39, -41, -44, -48, -51, -54, -57, -61, -63, -65, -65,
-66, -67, -69, -71, -74, -76, -80, -83, -84, -86, -89, -88, -88, -91, -91, -91,
-92, -92, -93, -97, -100, -103, -102, -101, -100, -99, -98, -98, -99, -101,
-106, -107, -110, -111, -111, -110, -111, -112, -111, -110, -110, -111, -110,
-112, -114, -113, -111, -109, -108, -105, -102, -99, -97, -97, -97, -98, -98,
-94, -92, -89, -86, -81, -77, -71, -66, -61, -57, -53, -49, -46, -46, -45, -44,
-43, -40, -36, -34, -32, -32, -30, -30, -29, -30, -27, -27, -25, -23, -20, -18,
-12, -7, -1, 3, 6, 9, 11, 13, 15, 18, 22, 26, 28, 32, 32, 31, 31, 31, 32, 31,
32, 30, 28, 28, 26, 30, 32, 34, 37, 36, 35, 35, 36, 37, 38, 41, 43, 46, 46, 46,
46, 48, 48, 49, 49, 49, 48, 49, 48, 49, 52, 55, 58, 58, 60, 60, 61, 64, 66, 67,
71, 74, 76, 78, 81, 83, 85, 88, 92, 94, 96, 97, 98, 99, 99, 100, 99, 99, 97, 97,
95, 94, 91, 89, 88, 87, 86, 84, 84, 81, 82, 81, 82, 83, 84, 86, 87, 87, 87, 88,
87, 86, 84, 82, 77, 74, 69, 64, 59, 53, 48, 43, 37, 32, 27, 22, 18, 14, 11, 9,
8, 7, 5, 3, 3, 1, 1, -1, -3, -4, -7, -8, -12, -14, -16, -19, -21, -26, -29, -34,
-38, -42, -45, -48, -49, -51, -52, -53, -54, -56, -56, -54, -54, -54, -53, -53,
-54, -54, -54, -53, -52, -53, -52, -52, -54, -57, -57, -58, -59, -58, -58, -57,
-56, -55, -55, -52, -51, -48, -47, -46, -44, -42, -40, -36, -34, -30, -27, -24,
-23, -20, -19, -17, -17, -17, -17, -15, -14, -15, -16, -15, -16, -16, -16, -16,
-17, -16, -16, -14, -11, -9, -7, -6, -2, };