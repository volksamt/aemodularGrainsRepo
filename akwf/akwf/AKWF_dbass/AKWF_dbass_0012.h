#define DATA_LENGTH 512
#define DATA AKWF_dbass_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 6, 7, 10, 12, 14, 17, 19, 22,
25, 28, 31, 34, 35, 39, 40, 43, 47, 48, 51, 53, 57, 60, 63, 65, 68, 71, 74, 77,
80, 83, 87, 88, 92, 94, 97, 100, 101, 103, 106, 107, 109, 110, 111, 112, 113,
114, 114, 115, 116, 117, 117, 118, 118, 119, 119, 119, 119, 119, 118, 119, 118,
117, 118, 117, 117, 116, 115, 114, 113, 112, 111, 110, 110, 108, 107, 106, 106,
106, 105, 105, 105, 104, 104, 102, 102, 101, 101, 100, 98, 98, 98, 97, 97, 96,
97, 96, 96, 96, 95, 96, 97, 95, 96, 95, 96, 96, 95, 96, 94, 95, 94, 93, 91, 92,
90, 90, 88, 87, 87, 86, 85, 83, 81, 80, 79, 78, 78, 77, 76, 76, 75, 75, 74, 74,
73, 72, 72, 69, 69, 68, 65, 64, 61, 59, 57, 55, 53, 52, 50, 49, 48, 48, 46, 45,
45, 44, 44, 44, 43, 43, 42, 42, 41, 40, 40, 38, 38, 38, 37, 37, 37, 39, 39, 39,
40, 41, 43, 43, 43, 43, 44, 43, 43, 43, 42, 40, 40, 40, 38, 38, 37, 37, 36, 36,
35, 34, 33, 33, 33, 32, 31, 30, 29, 27, 25, 24, 23, 20, 19, 16, 15, 12, 10, 9,
7, 5, 2, -1, -2, -6, -7, -10, -12, -15, -18, -20, -23, -24, -26, -28, -30, -30,
-33, -34, -35, -37, -39, -39, -41, -42, -43, -46, -46, -48, -50, -51, -53, -54,
-55, -56, -58, -57, -59, -60, -59, -60, -61, -61, -61, -62, -63, -64, -64, -65,
-67, -67, -68, -68, -68, -68, -69, -69, -69, -69, -69, -69, -69, -69, -70, -71,
-71, -71, -73, -73, -75, -74, -75, -77, -78, -80, -81, -81, -83, -84, -84, -86,
-85, -85, -85, -85, -86, -86, -85, -84, -86, -85, -85, -85, -85, -84, -83, -83,
-84, -83, -82, -81, -81, -80, -79, -78, -77, -76, -75, -74, -73, -72, -69, -69,
-68, -68, -66, -66, -65, -64, -64, -63, -61, -59, -58, -58, -57, -56, -57, -55,
-55, -53, -52, -51, -50, -49, -48, -47, -45, -43, -41, -40, -37, -35, -34, -32,
-29, -27, -26, -24, -22, -20, -21, -21, -21, -20, -21, -22, -22, -23, -24, -25,
-25, -24, -23, -21, -20, -19, -17, -16, -15, -14, -15, -14, -14, -14, -15, -17,
-19, -19, -21, -21, -21, -23, -23, -23, -23, -22, -21, -21, -22, -24, -24, -25,
-28, -29, -32, -33, -35, -37, -39, -39, -41, -42, -42, -42, -43, -43, -43, -42,
-43, -43, -45, -44, -45, -46, -47, -48, -51, -51, -53, -53, -53, -55, -55, -55,
-54, -54, -53, -53, -53, -52, -53, -52, -52, -51, -52, -52, -50, -50, -50, -48,
-47, -46, -45, -44, -43, -42, -40, -39, -39, -39, -38, -38, -37, -37, -37, -37,
-36, -37, -36, -36, -34, -33, -32, -31, -30, -28, -28, -26, -26, -25, -25, -24,
-25, -25, -24, -24, -24, -22, -22, -20, -19, -18, -17, -15, -13, -12, -9, -7,
-7, -5, -3, -2, -1, };