#define DATA_LENGTH 512
#define DATA AKWF_dbass_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 5, 7, 9, 11, 12, 13, 15, 17,
18, 19, 22, 23, 24, 26, 26, 28, 29, 30, 32, 33, 34, 35, 37, 38, 39, 41, 42, 43,
45, 46, 48, 50, 51, 53, 54, 55, 58, 59, 61, 62, 64, 64, 66, 67, 69, 71, 72, 73,
74, 76, 78, 80, 80, 82, 83, 85, 86, 88, 88, 90, 91, 92, 93, 94, 95, 97, 97, 98,
99, 101, 102, 103, 105, 105, 106, 107, 108, 109, 110, 111, 112, 114, 114, 114,
115, 116, 116, 116, 116, 117, 117, 117, 118, 119, 118, 118, 118, 119, 120, 118,
119, 118, 119, 118, 118, 117, 118, 118, 117, 117, 118, 117, 117, 118, 116, 117,
117, 117, 116, 115, 116, 114, 114, 114, 114, 114, 113, 112, 111, 111, 110, 111,
110, 110, 109, 108, 108, 106, 107, 105, 104, 103, 103, 101, 100, 100, 99, 99,
96, 97, 96, 95, 94, 93, 92, 91, 89, 89, 88, 87, 85, 84, 83, 82, 82, 81, 81, 79,
78, 77, 76, 75, 74, 73, 73, 71, 72, 70, 69, 67, 67, 66, 66, 66, 66, 66, 64, 62,
61, 61, 61, 59, 60, 59, 58, 57, 56, 55, 54, 54, 54, 52, 51, 50, 50, 49, 49, 47,
46, 45, 45, 43, 42, 42, 40, 39, 37, 37, 35, 34, 33, 33, 32, 30, 30, 30, 29, 27,
25, 23, 22, 19, 20, 18, 18, 17, 16, 15, 13, 12, 12, 11, 10, 10, 8, 7, 5, 5, 2,
1, -1, -2, -5, -7, -8, -10, -12, -13, -15, -17, -17, -19, -20, -21, -21, -23,
-23, -25, -25, -26, -26, -27, -27, -27, -28, -28, -29, -30, -31, -31, -32, -33,
-34, -36, -37, -38, -41, -42, -43, -46, -48, -50, -51, -52, -53, -55, -57, -58,
-59, -62, -62, -64, -64, -64, -65, -64, -64, -65, -65, -64, -64, -64, -64, -63,
-63, -62, -62, -62, -62, -63, -63, -64, -65, -66, -66, -67, -68, -69, -69, -71,
-71, -72, -73, -75, -75, -76, -77, -78, -79, -79, -81, -80, -81, -81, -83, -83,
-84, -85, -86, -87, -88, -88, -90, -90, -91, -91, -92, -93, -94, -95, -96, -96,
-96, -97, -97, -98, -97, -98, -97, -98, -98, -98, -99, -99, -99, -101, -101,
-102, -103, -104, -104, -105, -106, -107, -108, -108, -108, -109, -109, -110,
-111, -110, -111, -112, -112, -112, -113, -113, -113, -113, -113, -112, -112,
-112, -113, -112, -113, -112, -112, -112, -112, -112, -112, -111, -111, -111,
-110, -110, -108, -108, -108, -105, -105, -103, -101, -100, -99, -97, -95, -94,
-93, -90, -90, -88, -87, -86, -84, -83, -82, -81, -80, -80, -79, -79, -77, -77,
-77, -76, -75, -73, -73, -72, -71, -70, -69, -67, -66, -64, -64, -62, -60, -59,
-57, -55, -55, -52, -51, -49, -48, -46, -45, -44, -43, -42, -40, -39, -38, -37,
-36, -35, -33, -33, -31, -29, -28, -26, -26, -24, -22, -22, -20, -18, -17, -16,
-16, -14, -13, -12, -11, -10, -9, -8, -7, -6, -5, -3, -3, -1, -1, };