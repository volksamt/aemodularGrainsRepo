#define DATA_LENGTH 512
#define DATA AKWF_dbass_0068

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 6, 10, 13, 16, 18, 19, 18, 17,
18, 20, 24, 26, 30, 34, 38, 41, 45, 48, 51, 53, 53, 53, 55, 58, 59, 63, 64, 65,
67, 70, 73, 75, 78, 79, 81, 83, 84, 86, 88, 88, 88, 89, 89, 92, 95, 96, 100,
101, 103, 106, 107, 108, 107, 108, 108, 108, 107, 107, 107, 108, 108, 108, 109,
110, 112, 115, 117, 118, 118, 119, 119, 117, 115, 112, 110, 108, 107, 105, 103,
102, 101, 99, 97, 96, 97, 97, 98, 97, 97, 97, 97, 98, 98, 98, 99, 99, 99, 101,
102, 102, 102, 104, 104, 104, 104, 103, 101, 99, 98, 97, 95, 93, 91, 89, 87, 84,
82, 80, 79, 77, 76, 74, 73, 72, 72, 71, 71, 69, 67, 66, 66, 64, 63, 60, 60, 58,
56, 57, 56, 55, 55, 56, 56, 55, 56, 58, 57, 58, 59, 59, 58, 59, 57, 56, 55, 55,
53, 53, 51, 50, 48, 46, 45, 42, 41, 40, 40, 38, 38, 38, 38, 38, 38, 38, 38, 38,
40, 40, 41, 42, 43, 44, 46, 46, 47, 48, 49, 49, 49, 50, 49, 51, 50, 50, 50, 48,
48, 47, 45, 45, 43, 41, 41, 39, 39, 38, 36, 34, 32, 30, 29, 29, 28, 27, 27, 27,
25, 25, 23, 23, 23, 22, 20, 21, 20, 20, 19, 19, 16, 16, 15, 14, 11, 9, 6, 3, 0,
-3, -7, -10, -14, -17, -22, -26, -29, -31, -34, -35, -36, -38, -39, -39, -40,
-39, -39, -37, -38, -36, -35, -34, -32, -31, -29, -29, -28, -28, -29, -27, -28,
-26, -27, -27, -28, -29, -29, -30, -31, -33, -34, -35, -36, -37, -39, -41, -42,
-44, -45, -47, -49, -52, -53, -55, -57, -57, -58, -58, -60, -60, -60, -60, -60,
-60, -58, -58, -58, -57, -56, -55, -54, -55, -55, -55, -56, -56, -57, -58, -60,
-61, -63, -65, -66, -69, -70, -73, -74, -75, -78, -79, -79, -81, -80, -80, -80,
-80, -79, -77, -76, -74, -72, -69, -66, -64, -61, -59, -56, -55, -52, -51, -49,
-47, -45, -44, -42, -42, -42, -41, -41, -41, -41, -41, -41, -42, -41, -42, -44,
-44, -45, -46, -48, -49, -51, -52, -53, -55, -57, -59, -61, -62, -63, -63, -64,
-65, -66, -67, -66, -67, -67, -67, -68, -68, -68, -68, -69, -68, -70, -71, -72,
-73, -74, -76, -77, -80, -81, -84, -85, -87, -89, -92, -93, -94, -95, -94, -96,
-95, -94, -95, -94, -94, -92, -91, -90, -89, -88, -86, -84, -83, -83, -82, -83,
-81, -80, -80, -80, -78, -79, -78, -78, -77, -76, -76, -77, -76, -76, -75, -74,
-74, -72, -71, -71, -71, -70, -69, -68, -68, -67, -66, -65, -66, -66, -66, -65,
-63, -62, -61, -59, -59, -60, -59, -57, -54, -54, -54, -52, -51, -50, -49, -48,
-47, -46, -47, -47, -47, -48, -47, -46, -46, -45, -44, -41, -38, -37, -34, -33,
-32, -30, -30, -30, -30, -29, -27, -25, -22, -19, -16, -13, -13, -9, -7, -4, -2,
};