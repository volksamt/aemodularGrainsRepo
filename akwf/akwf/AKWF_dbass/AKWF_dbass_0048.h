#define DATA_LENGTH 512
#define DATA AKWF_dbass_0048

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 3, 5, 7, 9, 9, 8, 9, 12, 14,
15, 16, 17, 18, 17, 17, 18, 18, 19, 20, 20, 20, 19, 19, 20, 20, 21, 21, 23, 25,
27, 26, 29, 29, 30, 29, 30, 29, 30, 31, 32, 32, 33, 33, 32, 31, 33, 34, 36, 38,
40, 41, 43, 46, 48, 51, 53, 56, 59, 62, 64, 67, 69, 71, 73, 75, 75, 75, 75, 76,
76, 76, 76, 76, 76, 75, 74, 75, 75, 76, 76, 77, 79, 80, 81, 82, 84, 85, 86, 89,
89, 90, 90, 90, 92, 92, 93, 93, 95, 95, 96, 96, 97, 98, 99, 98, 99, 98, 98, 97,
98, 99, 99, 98, 97, 97, 97, 96, 96, 95, 96, 96, 98, 98, 100, 101, 103, 105, 106,
107, 109, 111, 112, 114, 116, 116, 117, 118, 118, 119, 119, 118, 118, 117, 115,
114, 113, 111, 110, 108, 107, 106, 105, 104, 103, 103, 104, 103, 104, 103, 104,
103, 102, 101, 100, 98, 97, 95, 91, 89, 87, 84, 81, 78, 75, 73, 69, 67, 63, 62,
59, 58, 57, 56, 55, 53, 53, 52, 51, 50, 50, 49, 49, 49, 48, 49, 50, 49, 50, 51,
51, 52, 53, 52, 51, 51, 51, 50, 49, 48, 47, 45, 44, 41, 38, 36, 33, 31, 28, 25,
21, 19, 16, 13, 10, 8, 6, 4, 4, 2, 1, 1, 0, 1, 1, 1, 1, 1, 2, 3, 2, 2, 2, 3, 2,
4, 4, 4, 5, 5, 6, 5, 5, 5, 4, 4, 2, 1, 1, 1, -1, -2, -2, -4, -6, -8, -11, -13,
-15, -17, -19, -21, -23, -25, -24, -27, -27, -28, -28, -30, -31, -31, -31, -30,
-30, -30, -30, -29, -29, -28, -28, -27, -27, -27, -27, -28, -30, -32, -32, -33,
-35, -36, -37, -38, -39, -40, -41, -42, -42, -43, -44, -45, -45, -45, -45, -47,
-46, -47, -47, -47, -48, -48, -49, -49, -49, -49, -50, -50, -50, -51, -51, -52,
-53, -52, -53, -54, -55, -56, -56, -56, -57, -58, -59, -60, -61, -62, -64, -65,
-67, -69, -72, -73, -77, -78, -80, -81, -83, -85, -86, -87, -89, -90, -92, -94,
-94, -96, -97, -97, -98, -99, -100, -101, -101, -102, -102, -102, -103, -103,
-103, -104, -103, -103, -103, -102, -102, -102, -101, -100, -100, -98, -98, -97,
-98, -97, -97, -96, -95, -96, -96, -95, -96, -97, -96, -97, -97, -98, -99, -99,
-99, -100, -100, -100, -100, -100, -100, -100, -100, -100, -99, -100, -99, -98,
-97, -97, -96, -96, -95, -94, -93, -91, -89, -88, -86, -82, -79, -77, -75, -72,
-69, -67, -67, -66, -67, -66, -66, -66, -66, -66, -67, -67, -65, -64, -67, -68,
-68, -69, -68, -68, -69, -68, -68, -66, -65, -64, -62, -58, -55, -53, -52, -52,
-50, -49, -46, -45, -44, -43, -40, -38, -38, -37, -37, -36, -37, -35, -35, -34,
-32, -31, -30, -27, -25, -22, -20, -19, -18, -19, -19, -19, -20, -20, -18, -15,
-12, -10, -9, -7, -5, -2, -2, -1, };