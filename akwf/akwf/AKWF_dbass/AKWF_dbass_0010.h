#define DATA_LENGTH 512
#define DATA AKWF_dbass_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 12, 18, 21, 25, 28, 32, 36, 40,
44, 49, 54, 58, 62, 68, 72, 76, 81, 85, 88, 90, 93, 96, 98, 99, 102, 105, 109,
111, 114, 115, 117, 117, 117, 118, 117, 119, 118, 118, 118, 119, 118, 117, 117,
115, 114, 112, 111, 109, 106, 104, 101, 98, 97, 94, 92, 91, 90, 88, 87, 84, 82,
80, 76, 72, 70, 65, 62, 58, 54, 49, 46, 42, 39, 36, 33, 30, 27, 23, 22, 20, 17,
14, 12, 8, 5, 1, -2, -6, -10, -13, -15, -18, -19, -20, -19, -20, -21, -22, -21,
-23, -22, -22, -22, -22, -21, -21, -21, -19, -17, -17, -16, -16, -16, -17, -19,
-19, -22, -23, -23, -23, -22, -22, -22, -22, -21, -20, -21, -21, -22, -22, -24,
-25, -25, -27, -28, -30, -32, -33, -35, -38, -40, -43, -43, -45, -46, -47, -47,
-47, -46, -45, -44, -45, -46, -45, -47, -49, -50, -52, -53, -54, -56, -57, -58,
-59, -61, -62, -64, -64, -67, -67, -69, -70, -69, -69, -68, -69, -69, -69, -69,
-70, -73, -75, -76, -77, -79, -79, -79, -79, -78, -77, -74, -73, -71, -70, -66,
-65, -63, -60, -58, -56, -53, -50, -47, -44, -40, -38, -34, -31, -27, -23, -21,
-17, -13, -11, -8, -6, -4, -3, -1, 0, 1, 2, 4, 4, 5, 8, 10, 13, 16, 19, 21, 24,
24, 27, 28, 29, 30, 32, 31, 34, 36, 38, 41, 44, 47, 49, 53, 55, 58, 60, 62, 64,
66, 69, 71, 73, 74, 75, 76, 78, 78, 78, 78, 77, 78, 76, 74, 74, 73, 72, 72, 71,
70, 68, 67, 66, 63, 61, 59, 56, 54, 50, 47, 45, 44, 41, 41, 40, 39, 37, 38, 36,
36, 36, 34, 34, 32, 31, 30, 28, 28, 26, 25, 23, 23, 22, 21, 21, 23, 22, 21, 22,
23, 22, 22, 20, 20, 18, 18, 16, 15, 14, 12, 12, 10, 10, 8, 7, 5, 4, 3, 1, 0, 1,
-1, -1, -3, -4, -3, -4, -3, -4, -4, -3, -3, -2, -2, -1, 1, 3, 5, 5, 7, 9, 11,
12, 12, 12, 11, 12, 13, 14, 12, 12, 12, 12, 13, 12, 12, 13, 12, 11, 9, 6, 6, 7,
6, 4, 4, 4, 2, 0, -3, -8, -10, -13, -12, -14, -16, -16, -15, -17, -19, -20, -21,
-19, -18, -15, -14, -12, -10, -6, -2, 0, 5, 10, 12, 13, 13, 13, 11, 12, 11, 11,
11, 13, 16, 19, 22, 25, 26, 27, 26, 25, 23, 22, 20, 18, 17, 17, 16, 15, 13, 9,
5, 1, -4, -9, -15, -19, -22, -23, -25, -27, -29, -29, -32, -35, -36, -39, -40,
-41, -42, -43, -43, -43, -43, -43, -44, -45, -46, -46, -46, -46, -46, -43, -41,
-38, -36, -34, -33, -31, -29, -28, -29, -31, -32, -33, -34, -36, -35, -34, -34,
-31, -30, -31, -31, -31, -32, -34, -33, -33, -32, -31, -30, -30, -29, -29, -28,
-26, -26, -24, -23, -21, -20, -16, -13, -10, -4, 0, };