#define DATA_LENGTH 512
#define DATA AKWF_dbass_0051

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 3, 4, 5, 6, 8, 9, 10, 11, 13,
13, 15, 16, 17, 19, 21, 23, 25, 27, 30, 31, 35, 37, 40, 42, 45, 47, 49, 51, 52,
55, 56, 58, 60, 62, 64, 67, 68, 69, 70, 72, 74, 73, 74, 75, 75, 75, 74, 74, 75,
76, 76, 76, 78, 78, 78, 79, 79, 79, 79, 80, 80, 81, 81, 83, 84, 85, 86, 89, 90,
92, 94, 94, 96, 98, 99, 101, 101, 103, 104, 105, 105, 107, 108, 108, 111, 112,
112, 112, 113, 115, 115, 114, 115, 115, 116, 116, 116, 117, 118, 118, 118, 118,
118, 119, 119, 119, 118, 118, 117, 116, 116, 115, 114, 114, 114, 113, 112, 113,
112, 111, 111, 110, 110, 109, 108, 107, 106, 105, 104, 105, 103, 103, 103, 103,
102, 103, 103, 103, 102, 102, 103, 102, 101, 102, 101, 101, 100, 100, 100, 100,
101, 101, 100, 100, 100, 100, 98, 98, 98, 96, 94, 94, 92, 91, 91, 89, 88, 87,
84, 83, 82, 80, 77, 75, 72, 70, 69, 66, 64, 62, 61, 59, 58, 56, 54, 52, 51, 49,
48, 46, 45, 43, 43, 42, 40, 40, 40, 39, 39, 37, 37, 36, 35, 35, 34, 34, 32, 31,
31, 30, 30, 28, 28, 26, 26, 25, 23, 22, 20, 19, 18, 16, 14, 12, 10, 9, 7, 6, 4,
3, 1, 0, -2, -4, -5, -7, -9, -11, -12, -13, -15, -16, -17, -17, -19, -20, -20,
-22, -22, -23, -24, -25, -26, -27, -27, -29, -30, -30, -31, -32, -33, -34, -35,
-37, -39, -40, -41, -43, -44, -45, -47, -48, -49, -51, -52, -53, -54, -55, -56,
-57, -58, -59, -61, -61, -62, -62, -62, -64, -63, -63, -64, -64, -65, -65, -64,
-65, -65, -64, -65, -65, -65, -65, -64, -65, -64, -64, -63, -64, -64, -64, -63,
-64, -64, -63, -63, -63, -63, -65, -65, -65, -65, -67, -67, -68, -71, -71, -72,
-74, -75, -77, -77, -78, -80, -81, -82, -83, -84, -85, -86, -88, -89, -90, -91,
-92, -93, -94, -96, -96, -98, -98, -99, -99, -101, -101, -101, -101, -101, -101,
-101, -101, -102, -102, -102, -102, -101, -101, -100, -99, -97, -96, -96, -97,
-95, -94, -95, -96, -96, -95, -95, -95, -93, -93, -92, -93, -92, -92, -92, -93,
-94, -94, -94, -94, -95, -94, -93, -94, -95, -95, -94, -94, -93, -94, -94, -93,
-94, -93, -94, -93, -92, -92, -91, -90, -90, -88, -88, -87, -87, -86, -85, -84,
-84, -84, -82, -82, -81, -80, -78, -77, -76, -74, -73, -72, -70, -68, -67, -66,
-65, -64, -63, -63, -62, -60, -60, -59, -58, -57, -56, -55, -53, -53, -51, -50,
-50, -48, -48, -48, -46, -46, -45, -45, -44, -43, -42, -41, -41, -40, -39, -39,
-38, -37, -36, -35, -34, -33, -33, -32, -32, -31, -30, -29, -28, -26, -26, -24,
-22, -21, -20, -19, -18, -17, -16, -15, -14, -14, -12, -11, -9, -7, -6, -6, -4,
-3, -2, -1, -1, -1, 0, 0, 0, };