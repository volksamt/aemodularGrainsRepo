#define DATA_LENGTH 512
#define DATA AKWF_dbass_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 5, 8, 10, 11, 14, 16, 20, 22,
26, 28, 30, 33, 35, 38, 42, 44, 46, 49, 53, 56, 58, 61, 64, 67, 68, 71, 71, 74,
76, 78, 80, 83, 85, 87, 89, 90, 93, 94, 95, 98, 99, 100, 102, 103, 104, 106,
108, 108, 109, 109, 109, 109, 110, 110, 110, 110, 110, 110, 111, 112, 112, 113,
113, 112, 112, 112, 113, 112, 113, 111, 112, 112, 113, 112, 114, 114, 115, 115,
116, 117, 119, 119, 119, 119, 118, 117, 115, 115, 113, 113, 112, 111, 109, 108,
109, 109, 108, 107, 106, 103, 102, 100, 98, 95, 92, 90, 87, 84, 80, 78, 76, 73,
69, 67, 63, 58, 55, 52, 48, 44, 40, 35, 30, 27, 24, 21, 17, 15, 12, 9, 8, 4, 2,
0, -3, -6, -8, -11, -13, -15, -17, -19, -20, -23, -25, -27, -31, -32, -35, -37,
-40, -43, -45, -47, -50, -51, -53, -55, -57, -59, -61, -62, -64, -66, -68, -72,
-74, -77, -79, -82, -84, -87, -90, -92, -94, -96, -98, -99, -100, -100, -102,
-104, -105, -108, -108, -108, -109, -109, -111, -111, -110, -111, -110, -110,
-110, -109, -109, -108, -106, -106, -104, -103, -101, -99, -97, -93, -90, -87,
-84, -80, -77, -73, -70, -66, -63, -60, -56, -53, -49, -46, -42, -39, -35, -31,
-27, -24, -21, -17, -13, -10, -7, -4, 0, 3, 6, 8, 11, 13, 16, 17, 19, 21, 24,
28, 31, 33, 37, 40, 43, 46, 48, 50, 55, 56, 58, 61, 63, 67, 68, 71, 73, 75, 77,
79, 81, 84, 87, 88, 90, 92, 93, 94, 96, 97, 99, 100, 101, 101, 104, 104, 106,
106, 107, 109, 110, 109, 109, 111, 111, 110, 110, 107, 108, 106, 106, 104, 103,
102, 101, 99, 98, 96, 94, 94, 92, 90, 89, 87, 85, 84, 82, 80, 78, 76, 74, 74,
72, 69, 66, 64, 61, 59, 57, 54, 52, 49, 48, 45, 44, 44, 42, 41, 39, 38, 37, 36,
34, 32, 31, 28, 26, 26, 24, 22, 21, 19, 18, 18, 17, 16, 15, 13, 12, 11, 8, 7, 4,
3, 1, 0, -1, -3, -5, -5, -7, -8, -9, -11, -12, -13, -15, -16, -18, -20, -21,
-23, -24, -26, -29, -30, -32, -34, -36, -39, -41, -43, -46, -47, -51, -53, -54,
-56, -59, -61, -62, -64, -65, -66, -67, -69, -71, -72, -72, -74, -77, -78, -80,
-82, -83, -85, -85, -88, -89, -90, -91, -93, -93, -94, -96, -98, -99, -100,
-101, -102, -103, -105, -105, -104, -106, -105, -106, -107, -107, -108, -107,
-108, -110, -110, -111, -112, -113, -112, -113, -113, -113, -114, -114, -114,
-113, -112, -112, -111, -110, -109, -109, -108, -105, -106, -103, -102, -100,
-99, -98, -95, -93, -92, -90, -88, -86, -84, -82, -80, -78, -76, -74, -72, -70,
-67, -65, -63, -62, -59, -58, -55, -53, -52, -50, -47, -46, -44, -43, -39, -36,
-34, -31, -29, -27, -23, -20, -18, -16, -13, -11, -9, -8, -7, -5, -5, -3, -1, };