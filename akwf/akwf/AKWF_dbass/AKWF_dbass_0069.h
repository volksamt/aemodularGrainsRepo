#define DATA_LENGTH 512
#define DATA AKWF_dbass_0069

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 3, 6, 9, 15, 16, 19, 21, 22, 22,
21, 23, 26, 29, 31, 35, 36, 37, 38, 41, 43, 47, 50, 53, 56, 57, 59, 60, 62, 65,
68, 71, 73, 73, 74, 76, 79, 82, 84, 87, 89, 90, 91, 94, 95, 98, 100, 103, 104,
105, 106, 105, 105, 105, 106, 107, 107, 110, 112, 112, 111, 109, 109, 110, 111,
112, 114, 117, 118, 118, 119, 119, 118, 117, 116, 114, 113, 109, 108, 106, 104,
102, 99, 98, 95, 94, 95, 95, 95, 95, 97, 99, 100, 101, 101, 101, 101, 102, 102,
104, 105, 105, 106, 105, 106, 106, 106, 106, 105, 103, 102, 100, 99, 97, 95, 91,
90, 87, 86, 85, 84, 82, 82, 81, 81, 80, 79, 79, 80, 79, 78, 76, 73, 72, 70, 69,
67, 66, 66, 65, 65, 64, 64, 63, 64, 65, 66, 67, 68, 68, 69, 69, 69, 68, 68, 68,
67, 65, 63, 62, 60, 58, 56, 54, 52, 50, 48, 46, 46, 44, 44, 43, 43, 43, 43, 44,
45, 46, 46, 46, 47, 48, 49, 51, 52, 51, 52, 53, 54, 54, 55, 55, 55, 55, 54, 54,
54, 53, 51, 50, 49, 47, 45, 43, 42, 40, 38, 37, 35, 34, 33, 32, 31, 30, 28, 28,
27, 26, 25, 26, 24, 23, 21, 22, 21, 20, 19, 18, 17, 17, 16, 16, 14, 12, 10, 8,
5, 2, -1, -3, -8, -12, -15, -20, -25, -27, -31, -34, -36, -39, -40, -41, -41,
-42, -42, -41, -41, -40, -40, -39, -38, -36, -34, -32, -32, -32, -31, -30, -29,
-29, -29, -29, -28, -28, -27, -28, -28, -28, -29, -29, -31, -32, -34, -36, -37,
-40, -41, -43, -46, -49, -50, -52, -54, -56, -58, -60, -60, -61, -63, -63, -63,
-63, -63, -64, -63, -63, -62, -61, -59, -58, -58, -57, -57, -58, -57, -59, -58,
-59, -61, -62, -64, -65, -67, -70, -71, -74, -76, -79, -79, -81, -82, -83, -84,
-84, -84, -82, -81, -79, -78, -75, -73, -69, -66, -62, -60, -57, -54, -51, -49,
-47, -46, -44, -42, -42, -41, -40, -39, -39, -39, -38, -40, -40, -40, -41, -41,
-43, -43, -45, -46, -47, -48, -50, -52, -53, -55, -57, -58, -60, -62, -64, -65,
-66, -67, -67, -69, -69, -69, -69, -70, -69, -69, -69, -69, -70, -70, -70, -72,
-73, -75, -77, -79, -82, -84, -86, -88, -90, -93, -95, -96, -98, -99, -100,
-101, -101, -101, -101, -100, -99, -98, -98, -95, -94, -93, -92, -91, -90, -89,
-87, -87, -85, -84, -84, -83, -82, -83, -83, -82, -81, -80, -81, -80, -80, -79,
-79, -79, -80, -79, -79, -78, -77, -76, -76, -76, -76, -75, -76, -73, -72, -73,
-72, -71, -70, -70, -68, -69, -66, -65, -65, -65, -63, -64, -64, -62, -61, -59,
-57, -57, -55, -53, -53, -54, -55, -54, -55, -54, -53, -51, -50, -49, -47, -46,
-44, -41, -40, -37, -36, -35, -35, -35, -34, -31, -30, -28, -27, -25, -21, -20,
-16, -11, -7, -2, };