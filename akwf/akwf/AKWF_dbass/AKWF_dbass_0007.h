#define DATA_LENGTH 512
#define DATA AKWF_dbass_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 8, 11, 14, 16, 18, 19, 23,
25, 28, 29, 31, 33, 35, 37, 38, 41, 43, 44, 46, 47, 49, 50, 52, 54, 55, 56, 55,
56, 58, 60, 60, 61, 63, 64, 66, 66, 69, 70, 72, 73, 75, 76, 78, 80, 81, 81, 82,
85, 86, 88, 88, 89, 90, 91, 92, 93, 93, 93, 93, 93, 94, 94, 93, 92, 92, 92, 93,
94, 94, 95, 95, 96, 97, 98, 98, 98, 100, 100, 100, 100, 100, 101, 101, 100, 101,
102, 100, 101, 101, 101, 100, 100, 99, 99, 99, 100, 99, 99, 99, 98, 99, 99, 98,
98, 98, 98, 98, 98, 98, 99, 99, 98, 99, 100, 100, 100, 100, 100, 99, 100, 100,
99, 99, 99, 97, 97, 98, 97, 97, 97, 97, 97, 97, 98, 99, 99, 99, 98, 99, 98, 99,
98, 98, 98, 98, 98, 99, 98, 99, 99, 99, 98, 99, 99, 100, 100, 100, 99, 101, 101,
103, 103, 105, 105, 106, 108, 109, 110, 111, 112, 113, 114, 115, 116, 116, 117,
117, 118, 118, 118, 119, 119, 118, 119, 119, 118, 118, 116, 117, 115, 114, 115,
113, 112, 111, 112, 110, 110, 109, 108, 109, 107, 108, 107, 107, 107, 106, 105,
106, 106, 106, 107, 106, 107, 106, 106, 106, 105, 105, 105, 104, 101, 101, 100,
98, 98, 95, 93, 91, 88, 85, 82, 79, 77, 74, 71, 69, 65, 64, 62, 58, 56, 55, 52,
51, 49, 47, 45, 43, 41, 39, 37, 36, 33, 32, 31, 29, 27, 24, 22, 19, 16, 14, 11,
9, 7, 4, 0, -1, -4, -5, -7, -10, -12, -13, -15, -18, -19, -21, -22, -25, -26,
-28, -29, -31, -32, -34, -36, -37, -39, -41, -42, -44, -46, -48, -49, -50, -51,
-53, -53, -55, -55, -56, -58, -58, -59, -61, -61, -63, -63, -65, -65, -67, -68,
-69, -70, -71, -73, -74, -76, -77, -78, -80, -82, -82, -84, -86, -88, -89, -90,
-91, -93, -94, -96, -97, -97, -98, -98, -100, -99, -100, -101, -100, -101, -101,
-101, -101, -100, -99, -100, -99, -98, -98, -98, -97, -97, -97, -98, -98, -98,
-98, -100, -100, -100, -101, -102, -103, -102, -104, -105, -104, -106, -107,
-106, -107, -108, -108, -108, -108, -108, -108, -107, -108, -107, -107, -106,
-105, -106, -106, -106, -106, -105, -105, -105, -106, -106, -106, -106, -107,
-107, -108, -109, -109, -110, -110, -110, -111, -111, -111, -112, -112, -112,
-112, -113, -113, -112, -113, -113, -113, -113, -114, -114, -114, -115, -115,
-114, -115, -115, -116, -116, -117, -117, -117, -117, -117, -118, -120, -118,
-118, -118, -119, -118, -117, -117, -116, -116, -115, -114, -113, -112, -112,
-110, -108, -107, -106, -105, -103, -102, -99, -99, -96, -95, -93, -91, -90,
-87, -86, -84, -83, -80, -78, -78, -74, -72, -71, -70, -67, -65, -64, -62, -60,
-57, -56, -53, -51, -49, -47, -45, -43, -42, -40, -38, -36, -33, -31, -29, -26,
-25, -23, -21, -19, -17, -14, -12, -10, -8, -5, -3, 0, };