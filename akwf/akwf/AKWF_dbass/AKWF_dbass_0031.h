#define DATA_LENGTH 512
#define DATA AKWF_dbass_0031

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 7, 8, 10, 12, 13, 15, 17, 18,
20, 21, 22, 24, 27, 29, 30, 32, 33, 35, 36, 38, 39, 41, 42, 44, 47, 48, 50, 50,
53, 53, 55, 57, 58, 60, 61, 63, 64, 65, 66, 68, 70, 71, 73, 73, 75, 76, 78, 79,
80, 81, 82, 83, 84, 86, 87, 87, 88, 90, 91, 92, 93, 93, 94, 95, 95, 97, 98, 99,
100, 100, 101, 101, 103, 103, 103, 105, 106, 106, 107, 107, 106, 108, 108, 109,
109, 109, 111, 110, 111, 112, 112, 113, 113, 113, 113, 113, 113, 115, 114, 115,
116, 115, 115, 116, 116, 116, 116, 117, 118, 116, 117, 118, 118, 117, 118, 119,
118, 118, 119, 119, 118, 118, 119, 118, 118, 118, 118, 118, 119, 119, 119, 118,
119, 119, 118, 118, 119, 118, 119, 118, 119, 118, 118, 119, 119, 118, 118, 118,
118, 118, 118, 118, 118, 118, 117, 117, 117, 116, 116, 116, 116, 115, 116, 114,
115, 115, 115, 115, 113, 113, 114, 113, 113, 113, 112, 111, 111, 110, 111, 110,
109, 108, 109, 108, 107, 107, 106, 106, 104, 105, 103, 103, 104, 102, 101, 101,
100, 100, 98, 98, 98, 96, 95, 95, 93, 94, 93, 92, 91, 90, 89, 87, 87, 86, 85,
84, 82, 82, 81, 79, 79, 77, 77, 75, 73, 72, 71, 69, 68, 68, 67, 65, 63, 62, 61,
60, 57, 56, 55, 53, 51, 51, 49, 48, 46, 45, 44, 42, 40, 38, 36, 35, 34, 31, 30,
28, 26, 26, 24, 22, 20, 18, 16, 15, 14, 13, 10, 9, 6, 4, 3, 2, -1, -2, -3, -4,
-7, -8, -10, -11, -14, -15, -16, -17, -19, -21, -22, -24, -26, -27, -28, -30,
-31, -33, -35, -36, -37, -38, -39, -41, -42, -44, -44, -46, -48, -49, -50, -52,
-51, -53, -53, -55, -56, -57, -58, -59, -60, -60, -61, -62, -63, -64, -65, -66,
-67, -67, -68, -69, -70, -71, -71, -70, -72, -72, -73, -74, -73, -74, -75, -75,
-75, -76, -77, -77, -78, -78, -78, -79, -79, -80, -80, -80, -81, -81, -82, -83,
-82, -83, -83, -83, -83, -83, -84, -85, -85, -85, -85, -86, -85, -86, -86, -87,
-87, -87, -87, -87, -86, -87, -87, -87, -88, -88, -87, -88, -87, -89, -89, -88,
-89, -89, -89, -89, -89, -89, -89, -90, -89, -89, -89, -89, -91, -90, -90, -90,
-90, -90, -91, -90, -90, -91, -90, -90, -90, -89, -90, -89, -89, -89, -89, -89,
-89, -88, -88, -88, -87, -88, -87, -87, -87, -86, -87, -87, -86, -85, -86, -85,
-84, -85, -84, -84, -83, -82, -82, -81, -80, -80, -78, -79, -79, -77, -76, -75,
-75, -75, -74, -72, -72, -71, -70, -69, -68, -67, -65, -65, -64, -62, -61, -60,
-59, -58, -57, -56, -54, -53, -52, -51, -50, -48, -47, -45, -44, -42, -41, -40,
-38, -37, -35, -34, -32, -31, -29, -27, -26, -25, -23, -22, -21, -19, -17, -16,
-15, -13, -11, -10, -8, -7, -5, -3, -1, };