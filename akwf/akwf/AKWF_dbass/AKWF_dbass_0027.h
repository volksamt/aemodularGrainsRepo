#define DATA_LENGTH 512
#define DATA AKWF_dbass_0027

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 2, 3, 4, 6, 7, 9, 11, 11, 13,
16, 17, 18, 20, 20, 21, 21, 22, 24, 26, 28, 30, 31, 32, 34, 36, 38, 39, 43, 45,
48, 49, 52, 53, 55, 56, 57, 57, 57, 57, 56, 56, 54, 53, 55, 55, 57, 57, 58, 60,
61, 63, 65, 67, 68, 67, 67, 65, 64, 63, 62, 60, 58, 57, 56, 55, 54, 54, 55, 54,
54, 54, 52, 50, 49, 46, 45, 42, 42, 40, 40, 40, 39, 40, 40, 41, 41, 41, 42, 41,
41, 41, 41, 42, 43, 43, 44, 43, 44, 43, 45, 44, 46, 46, 47, 46, 47, 46, 45, 46,
46, 45, 44, 43, 44, 44, 45, 45, 46, 47, 48, 49, 49, 49, 50, 50, 50, 51, 52, 51,
51, 50, 50, 49, 49, 49, 48, 49, 49, 48, 49, 50, 51, 53, 52, 53, 54, 54, 54, 54,
53, 55, 55, 55, 55, 56, 57, 59, 60, 61, 64, 65, 66, 69, 69, 71, 72, 73, 75, 76,
77, 78, 81, 82, 83, 84, 86, 87, 89, 90, 91, 92, 93, 92, 92, 93, 92, 91, 91, 90,
89, 90, 89, 88, 89, 88, 87, 87, 86, 86, 86, 86, 88, 87, 86, 87, 85, 85, 85, 84,
84, 84, 83, 82, 82, 82, 82, 82, 82, 82, 81, 82, 80, 80, 80, 79, 79, 79, 78, 78,
79, 77, 77, 77, 77, 76, 76, 75, 75, 74, 74, 73, 72, 71, 70, 69, 67, 65, 64, 62,
61, 59, 58, 56, 54, 52, 51, 48, 47, 46, 45, 43, 42, 41, 41, 39, 38, 36, 35, 33,
31, 30, 28, 25, 24, 23, 22, 20, 19, 16, 16, 15, 13, 12, 11, 11, 9, 9, 8, 8, 7,
7, 7, 6, 7, 5, 5, 5, 3, 3, 2, 3, 0, 0, -1, -2, -2, -3, -4, -5, -5, -6, -5, -7,
-6, -7, -8, -9, -9, -10, -11, -11, -13, -14, -15, -16, -17, -18, -18, -19, -20,
-20, -22, -22, -22, -24, -25, -27, -28, -29, -32, -33, -35, -37, -39, -40, -42,
-43, -45, -45, -47, -47, -48, -49, -50, -52, -52, -54, -54, -55, -57, -58, -60,
-61, -62, -64, -64, -65, -67, -68, -69, -70, -72, -73, -74, -76, -79, -81, -81,
-84, -86, -87, -87, -89, -91, -91, -93, -93, -95, -95, -96, -97, -98, -99, -100,
-101, -102, -103, -103, -105, -106, -107, -108, -109, -109, -111, -112, -112,
-113, -114, -115, -116, -116, -116, -118, -118, -119, -119, -119, -118, -118,
-118, -118, -117, -116, -116, -115, -115, -114, -113, -113, -112, -113, -113,
-112, -113, -113, -113, -112, -111, -111, -110, -109, -108, -108, -107, -106,
-105, -103, -102, -101, -99, -98, -97, -96, -94, -93, -92, -90, -88, -87, -87,
-84, -83, -81, -79, -78, -76, -74, -71, -68, -66, -65, -61, -60, -60, -59, -57,
-54, -52, -50, -48, -46, -44, -43, -41, -39, -38, -36, -36, -34, -34, -32, -30,
-29, -26, -23, -22, -19, -17, -15, -12, -11, -8, -6, -4, -2, -1, -1, -1, };