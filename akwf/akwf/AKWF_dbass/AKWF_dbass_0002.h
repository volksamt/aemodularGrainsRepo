#define DATA_LENGTH 512
#define DATA AKWF_dbass_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 5, 7, 9, 10, 12, 14, 15, 18, 19,
21, 22, 24, 24, 26, 27, 28, 30, 31, 32, 34, 35, 36, 38, 40, 41, 42, 43, 45, 47,
48, 49, 52, 53, 54, 55, 59, 60, 61, 64, 65, 66, 69, 70, 71, 73, 74, 75, 76, 78,
78, 80, 81, 82, 83, 84, 85, 86, 88, 89, 90, 92, 92, 94, 96, 96, 97, 99, 99, 100,
100, 101, 102, 102, 102, 103, 103, 103, 104, 105, 106, 107, 107, 108, 109, 109,
110, 110, 111, 113, 113, 113, 114, 115, 114, 115, 117, 117, 118, 117, 119, 119,
118, 119, 118, 119, 119, 119, 118, 118, 117, 116, 116, 115, 115, 113, 113, 112,
111, 109, 109, 108, 108, 108, 106, 106, 107, 107, 105, 105, 105, 104, 103, 103,
104, 102, 103, 102, 101, 101, 100, 99, 98, 97, 96, 94, 93, 91, 91, 90, 89, 89,
88, 87, 87, 86, 85, 85, 83, 83, 82, 82, 81, 79, 79, 78, 78, 76, 75, 74, 73, 73,
72, 72, 72, 71, 70, 70, 69, 69, 68, 67, 66, 65, 65, 63, 62, 61, 60, 61, 59, 59,
59, 58, 56, 56, 55, 54, 52, 51, 51, 50, 49, 49, 48, 46, 45, 43, 43, 42, 41, 41,
41, 41, 41, 41, 41, 41, 39, 38, 37, 36, 34, 33, 32, 32, 31, 30, 29, 27, 26, 25,
22, 22, 21, 18, 17, 16, 15, 15, 14, 14, 13, 12, 12, 11, 11, 10, 9, 9, 8, 7, 7,
5, 4, 2, 0, -1, -3, -5, -7, -8, -8, -10, -11, -11, -11, -12, -13, -12, -12, -12,
-12, -12, -11, -11, -11, -11, -10, -10, -9, -9, -10, -9, -11, -12, -12, -14,
-14, -16, -17, -20, -22, -23, -26, -28, -30, -32, -34, -36, -38, -39, -40, -42,
-42, -44, -45, -45, -46, -47, -47, -49, -49, -50, -50, -51, -51, -52, -54, -54,
-55, -57, -57, -59, -60, -62, -63, -65, -65, -68, -69, -70, -72, -72, -73, -74,
-76, -77, -76, -77, -78, -78, -80, -80, -81, -82, -83, -84, -86, -88, -90, -91,
-93, -94, -95, -97, -98, -99, -99, -100, -100, -101, -101, -102, -101, -101,
-101, -101, -101, -102, -103, -102, -103, -103, -104, -104, -106, -106, -106,
-107, -108, -106, -107, -107, -106, -107, -106, -104, -105, -104, -104, -103,
-101, -101, -101, -101, -100, -99, -100, -99, -100, -101, -100, -101, -102,
-103, -102, -103, -104, -105, -106, -106, -106, -106, -106, -106, -106, -105,
-105, -104, -103, -101, -101, -98, -98, -96, -95, -95, -94, -91, -91, -90, -89,
-87, -86, -85, -85, -84, -84, -84, -83, -82, -82, -82, -82, -80, -80, -79, -78,
-77, -76, -75, -74, -73, -72, -72, -69, -69, -67, -66, -64, -64, -63, -62, -60,
-59, -59, -57, -56, -56, -55, -54, -52, -52, -51, -49, -47, -47, -46, -44, -44,
-43, -41, -41, -39, -38, -36, -36, -34, -33, -33, -32, -30, -29, -28, -27, -26,
-25, -24, -22, -20, -19, -17, -15, -14, -11, -9, -8, -5, -3, -1, };