#define DATA_LENGTH 512
#define DATA AKWF_dbass_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 8, 10, 13, 16, 19, 22, 25,
28, 30, 33, 37, 40, 43, 46, 49, 52, 56, 58, 60, 63, 67, 69, 72, 74, 77, 80, 83,
86, 88, 91, 92, 95, 97, 99, 101, 103, 104, 106, 108, 110, 111, 114, 115, 115,
116, 117, 117, 118, 118, 119, 119, 119, 119, 119, 119, 119, 118, 118, 119, 118,
118, 116, 115, 113, 112, 111, 110, 108, 106, 104, 101, 100, 99, 97, 95, 93, 90,
87, 86, 84, 81, 79, 76, 73, 71, 68, 66, 63, 60, 58, 55, 53, 49, 48, 45, 43, 41,
39, 37, 35, 33, 30, 28, 25, 23, 20, 16, 14, 12, 8, 7, 4, 1, 1, -2, -4, -5, -8,
-10, -12, -15, -18, -19, -20, -23, -25, -26, -29, -30, -32, -34, -36, -38, -40,
-43, -45, -47, -49, -51, -54, -57, -58, -60, -61, -63, -63, -65, -65, -67, -68,
-69, -71, -72, -73, -73, -76, -77, -78, -80, -82, -83, -84, -86, -88, -89, -91,
-92, -94, -94, -94, -95, -95, -95, -96, -96, -96, -95, -94, -95, -94, -94, -94,
-94, -93, -93, -93, -93, -92, -92, -91, -91, -91, -89, -89, -88, -88, -87, -86,
-85, -83, -82, -81, -79, -78, -77, -75, -75, -74, -74, -72, -72, -73, -72, -71,
-71, -70, -69, -68, -67, -65, -64, -63, -61, -60, -57, -55, -53, -52, -49, -46,
-45, -43, -41, -38, -36, -33, -31, -29, -26, -23, -20, -18, -16, -13, -10, -8,
-5, -1, 0, 3, 5, 7, 9, 11, 14, 15, 17, 19, 22, 25, 27, 30, 33, 35, 38, 41, 43,
44, 46, 47, 50, 50, 52, 54, 55, 56, 58, 59, 60, 62, 63, 64, 66, 66, 67, 68, 70,
71, 72, 71, 73, 73, 75, 76, 76, 77, 78, 79, 79, 79, 79, 79, 79, 80, 79, 80, 79,
79, 79, 78, 79, 79, 78, 78, 77, 77, 77, 75, 75, 74, 73, 72, 70, 69, 68, 67, 67,
66, 65, 65, 64, 64, 63, 62, 61, 59, 59, 58, 58, 56, 56, 55, 53, 52, 51, 49, 47,
46, 45, 45, 43, 43, 42, 41, 41, 39, 37, 38, 35, 34, 33, 30, 28, 27, 24, 22, 21,
19, 18, 17, 14, 13, 10, 9, 7, 4, 2, -1, -2, -3, -5, -5, -7, -10, -10, -11, -13,
-13, -14, -15, -16, -16, -16, -15, -15, -15, -14, -13, -13, -13, -13, -13, -14,
-16, -16, -17, -19, -22, -22, -23, -22, -23, -22, -22, -22, -23, -24, -24, -27,
-29, -30, -32, -33, -35, -35, -36, -38, -39, -41, -43, -46, -48, -49, -53, -55,
-57, -58, -59, -60, -60, -60, -60, -59, -60, -60, -62, -62, -62, -64, -62, -64,
-65, -65, -65, -64, -64, -63, -63, -64, -64, -64, -64, -64, -63, -63, -62, -60,
-59, -57, -57, -55, -55, -54, -53, -52, -51, -50, -50, -49, -48, -47, -46, -46,
-44, -43, -41, -38, -38, -36, -34, -33, -32, -31, -29, -27, -25, -23, -20, -18,
-16, -14, -12, -11, -10, -7, -6, -4, -3, -1, };