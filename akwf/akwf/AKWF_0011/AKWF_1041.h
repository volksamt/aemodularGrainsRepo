#define DATA_LENGTH 512
#define DATA AKWF_1041

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 12, 13, 16, 19, 21, 23, 25, 28, 30,
32, 35, 37, 39, 41, 44, 45, 48, 50, 53, 55, 57, 59, 60, 57, 55, 52, 51, 47, 45,
42, 39, 37, 34, 32, 31, 27, 25, 22, 19, 18, 14, 14, 2, -9, -4, -2, 1, 2, 4, 9,
-11, -20, -12, -15, 1, 14, 15, 19, 22, 25, 29, 32, 36, 40, 43, 46, 50, 52, 57,
59, 54, 46, 41, 34, 28, 20, 6, 9, 14, 18, 21, 26, 29, 34, 38, 41, 46, 49, 53,
53, 52, 51, 50, 49, 48, 47, 47, 46, 44, 44, 42, 43, 41, 41, 40, 43, 68, 79, 76,
75, 73, 72, 70, 69, 68, 66, 65, 64, 62, 61, 60, 59, 57, 56, 54, 53, 52, 50, 50,
47, 46, 44, 44, 42, 41, 39, 38, 37, 35, 34, 32, 31, 30, 29, 28, 25, 25, 23, 21,
21, 19, 18, 17, 15, 13, 13, 10, 11, 1, -10, -1, -1, 7, 3, -12, -12, -16, -19,
-22, -24, -26, -28, -30, -33, -36, -39, -41, -44, -46, -49, -51, -54, -56, -58,
-61, -63, -66, -68, -70, -73, -76, -78, -81, -84, -86, -89, -91, -94, -96, -99,
-101, -104, -106, -109, -111, -114, -117, -119, -118, -115, -113, -111, -108,
-106, -104, -102, -100, -97, -94, -92, -91, -88, -85, -83, -81, -79, -77, -74,
-72, -70, -67, -65, -63, -61, -59, -55, -55, -51, -48, -43, -40, -35, -31, -28,
-24, -20, -16, -13, 6, 7, 3, 2, -2, -4, -6, 10, 11, 14, 16, 18, 21, 23, 26, 28,
31, 33, 34, 37, 39, 41, 44, 46, 49, 51, 54, 55, 58, 60, 60, 57, 55, 52, 50, 47,
45, 42, 40, 37, 34, 33, 29, 27, 24, 22, 18, 18, 13, 14, 1, -10, -3, -4, 1, 2, 5,
8, -13, -18, -12, -14, 2, 14, 15, 19, 22, 26, 29, 33, 36, 39, 43, 46, 51, 52,
57, 59, 53, 46, 40, 32, 28, 18, 6, 10, 15, 18, 23, 26, 30, 34, 38, 42, 46, 49,
53, 53, 52, 51, 50, 50, 48, 48, 47, 46, 45, 43, 43, 43, 41, 41, 39, 44, 72, 78,
76, 75, 72, 72, 70, 69, 68, 66, 65, 64, 62, 61, 59, 59, 57, 56, 54, 53, 51, 51,
49, 47, 46, 44, 43, 42, 40, 39, 38, 37, 35, 34, 32, 31, 30, 28, 26, 26, 24, 23,
21, 20, 19, 17, 16, 15, 13, 12, 9, 11, 0, -9, 0, 0, 8, 1, -13, -12, -15, -18,
-21, -23, -26, -28, -31, -33, -36, -38, -41, -43, -46, -49, -50, -54, -56, -59,
-61, -63, -67, -69, -71, -75, -76, -78, -82, -84, -86, -89, -91, -94, -96, -99,
-102, -104, -106, -110, -112, -114, -117, -119, -118, -115, -112, -110, -107,
-106, -103, -101, -99, -97, -95, -93, -90, -87, -86, -84, -81, -78, -76, -74,
-71, -69, -67, -65, -62, -60, -58, -56, -54, -50, -47, -43, -40, -35, -31, -27,
-24, -20, -15, -12, 7, 6, 3, 1, -2, -4, -5, };