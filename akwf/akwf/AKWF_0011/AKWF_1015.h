#define DATA_LENGTH 512
#define DATA AKWF_1015

const PROGMEM int8_t DATA[DATA_LENGTH] = {15, 119, 114, 110, 108, 101, 101, 94,
93, 87, 85, 78, 77, 71, 70, 64, 62, 56, 54, 49, 46, 42, 38, 34, 31, 26, 22, 20,
14, 11, 6, 1, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0,
0, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1,
0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1,
0, 0, 1, 0, -1, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0,
0, 0, 0, 1, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 1, 1, 0, 1, 0, 1, 1,
0, 1, 1, 0, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 0, 0,
0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, -1, 1, 0, 1, 0,
0, 1, 0, 5, 8, 13, 16, 22, 25, 30, 33, 39, 41, 47, 48, 57, 57, 65, 66, 74, 73,
82, 81, 90, 90, 97, 99, 105, 110, 109, 127, -79, -128, -101, -116, -96, -105,
-90, -95, -84, -86, -76, -76, -68, -68, -60, -59, -54, -50, -46, -42, -38, -33,
-30, -25, -21, -17, -14, -9, -2, 2, -1, 1, -1, 1, 0, 2, 1, 0, 0, 0, 0, 0, 0, 0,
0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, -1, 1, 0, 0, 0, 1, 1, 0, 0, 0, 0,
0, 1, 0, 0, 0, 0, 1, 0, 0, -1, 1, 1, 0, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0,
1, 1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 1, 1, 1, 1, 0, 0, 0, 0, 1, 0, 0, 1,
0, 0, 0, -1, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 0,
1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 1, 1, 0, -1, 0, 0, 1, 1, 1, 0, 1, 1, 0,
0, 0, -1, 0, 0, 0, 1, 1, 0, 0, 1, 1, 0, -1, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 1,
0, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -2, -8, -11, -15, -17, -23, -26, -31, -34, -38,
-43, -45, -51, -53, -60, -60, -68, -66, -76, -73, -86, -81, -93, -89, -102, -97,
-110, -104, -117, -114, -34, -89, };