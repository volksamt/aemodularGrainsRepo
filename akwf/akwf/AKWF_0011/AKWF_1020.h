#define DATA_LENGTH 512
#define DATA AKWF_1020

const PROGMEM int8_t DATA[DATA_LENGTH] = {30, 71, 85, 85, 83, 85, 90, 93, 95,
97, 99, 100, 102, 103, 103, 104, 105, 106, 107, 107, 108, 109, 110, 110, 111,
111, 112, 112, 112, 112, 112, 114, 113, 113, 114, 115, 114, 116, 115, 115, 116,
115, 116, 116, 117, 116, 116, 117, 118, 117, 118, 117, 117, 117, 117, 118, 118,
118, 117, 118, 118, 118, 117, 117, 118, 117, 119, 118, 118, 118, 119, 118, 119,
118, 118, 119, 119, 118, 119, 119, 119, 119, 118, 118, 119, 119, 118, 119, 118,
118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 118, 120, 119, 119,
119, 120, 119, 119, 119, 119, 119, 118, 119, 119, 119, 120, 119, 120, 118, 119,
119, 119, 119, 120, 118, 119, 119, 120, 120, 119, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 120, 119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 119, 120, 119, 119, 119, 118, 119, 119, 119, 119, 118, 118, 119,
118, 118, 118, 118, 118, 118, 119, 119, 119, 118, 119, 118, 118, 118, 118, 119,
119, 118, 118, 118, 118, 118, 118, 118, 118, 118, 117, 118, 117, 117, 118, 118,
117, 117, 117, 117, 117, 117, 116, 116, 116, 116, 116, 116, 116, 116, 115, 116,
115, 115, 115, 114, 114, 113, 113, 112, 112, 113, 112, 112, 111, 111, 110, 110,
109, 108, 108, 107, 106, 106, 105, 104, 103, 102, 100, 99, 98, 95, 93, 91, 89,
86, 82, 77, 68, 52, 15, -36, -73, -85, -84, -83, -86, -91, -94, -96, -97, -98,
-100, -102, -102, -104, -104, -106, -107, -107, -108, -108, -109, -109, -110,
-111, -110, -112, -112, -112, -113, -112, -114, -113, -114, -114, -115, -115,
-115, -115, -115, -115, -116, -116, -116, -116, -116, -116, -116, -116, -117,
-117, -117, -117, -118, -118, -117, -117, -117, -118, -118, -118, -118, -118,
-118, -119, -118, -119, -118, -117, -118, -119, -119, -118, -118, -118, -118,
-119, -119, -119, -118, -118, -118, -119, -119, -119, -119, -118, -118, -119,
-119, -119, -119, -119, -119, -118, -120, -118, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -120, -118, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -118, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -118, -119, -118, -118, -119, -119, -118, -119, -118,
-119, -119, -118, -119, -119, -119, -119, -118, -119, -118, -118, -118, -119,
-118, -118, -119, -118, -119, -118, -118, -119, -117, -118, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -118, -118, -117, -117, -118, -117, -116,
-116, -117, -116, -116, -115, -116, -116, -116, -115, -115, -116, -115, -114,
-114, -114, -113, -114, -113, -113, -113, -112, -112, -111, -111, -111, -111,
-109, -109, -108, -108, -107, -107, -106, -104, -104, -103, -101, -100, -99,
-98, -95, -94, -91, -89, -85, -81, -75, -68, -49, -12, };