#define DATA_LENGTH 512
#define DATA AKWF_1026

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 4, 6, 6, 7, 8, 10, 11, 12,
13, 14, 15, 16, 17, 18, 19, 19, 21, 21, 22, 22, 23, 24, 24, 25, 26, 26, 27, 27,
27, 28, 29, 30, 30, 30, 31, 31, 32, 32, 32, 32, 33, 32, 33, 34, 34, 33, 34, 35,
35, 35, 35, 35, 35, 35, 35, 35, 35, 36, 36, 35, 35, 35, 35, 34, 35, 34, 34, 35,
35, 34, 35, 33, 34, 33, 32, 34, 33, 32, 33, 32, 32, 31, 31, 31, 30, 30, 29, 28,
29, 28, 27, 27, 27, 26, 26, 25, 25, 24, 24, 23, 23, 22, 22, 21, 21, 20, 20, 19,
18, 19, 17, 17, 16, 16, 15, 14, 14, 13, 13, 12, 11, 12, 11, 11, 9, 10, 9, 8, 8,
8, 7, 7, 6, 6, 6, 6, 5, 4, 4, 4, 4, 3, 4, 4, 3, 3, 3, 3, 3, 3, 4, 3, 3, 4, 3, 3,
4, 4, 5, 4, 5, 5, 6, 7, 7, 7, 8, 8, 9, 10, 10, 11, 12, 12, 13, 14, 15, 16, 17,
17, 19, 20, 21, 21, 23, 24, 25, 26, 27, 28, 30, 30, 31, 33, 34, 35, 36, 37, 39,
40, 41, 43, 44, 45, 47, 47, 50, 50, 51, 53, 55, 55, 57, 58, 59, 60, 61, 63, 63,
65, 66, 67, 69, 70, 71, 72, 73, 73, 74, 75, 76, 76, 78, 79, 80, 80, 82, 81, 82,
83, 84, 84, 85, 85, 85, 86, 86, 86, 87, 86, 87, 87, 88, 88, 87, 88, 88, 87, 87,
87, 87, 87, 87, 86, 85, 85, 85, 86, 85, 84, 84, 83, 82, 82, 81, 80, 80, 78, 79,
76, 77, 75, 75, 73, 72, 72, 71, 70, 69, 67, 67, 66, 64, 63, 62, 61, 59, 58, 57,
55, 54, 52, 52, 49, 48, 47, 45, 44, 42, 41, 40, 37, 37, 35, 33, 32, 30, 28, 27,
25, 23, 22, 20, 18, 16, 15, 13, 11, 10, 8, 6, 4, 2, 0, -2, -4, -5, -7, -10, -11,
-13, -14, -17, -18, -20, -22, -24, -26, -28, -29, -32, -34, -37, -37, -39, -42,
-43, -45, -47, -49, -51, -53, -55, -56, -58, -60, -62, -63, -66, -68, -70, -70,
-73, -74, -76, -79, -79, -81, -82, -84, -86, -88, -89, -90, -92, -93, -94, -96,
-98, -98, -100, -101, -103, -104, -105, -107, -107, -108, -110, -110, -111,
-111, -112, -113, -114, -115, -115, -116, -117, -117, -118, -118, -117, -118,
-119, -118, -119, -119, -119, -120, -119, -119, -118, -119, -118, -117, -118,
-116, -116, -116, -116, -114, -115, -114, -113, -112, -111, -110, -110, -108,
-107, -106, -105, -104, -102, -102, -101, -99, -98, -97, -94, -94, -93, -90,
-89, -87, -86, -84, -83, -82, -79, -77, -76, -74, -73, -71, -70, -68, -65, -65,
-62, -61, -59, -57, -55, -53, -52, -50, -48, -46, -44, -43, -40, -39, -38, -36,
-34, -32, -31, -28, -28, -26, -23, -22, -21, -20, -17, -17, -14, -13, -11, -10,
-9, -7, -6, -4, -3, -2, 0, };