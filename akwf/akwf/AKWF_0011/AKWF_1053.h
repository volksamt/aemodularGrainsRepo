#define DATA_LENGTH 512
#define DATA AKWF_1053

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 7, 8, 9, 11, 13, 14, 15, 17,
19, 20, 22, 23, 25, 27, 28, 29, 31, 32, 34, 35, 37, 38, 40, 42, 43, 44, 45, 47,
48, 50, 51, 52, 54, 55, 56, 57, 58, 59, 61, 62, 64, 64, 66, 67, 68, 69, 71, 72,
72, 73, 74, 76, 76, 77, 77, 78, 80, 81, 82, 82, 83, 84, 85, 86, 86, 87, 87, 88,
88, 90, 91, 91, 92, 92, 93, 93, 93, 94, 94, 94, 95, 95, 95, 96, 96, 97, 97, 97,
97, 97, 97, 98, 98, 98, 98, 98, 97, 97, 97, 98, 97, 98, 97, 97, 96, 97, 96, 96,
96, 97, 96, 95, 95, 95, 94, 94, 93, 92, 92, 92, 92, 91, 91, 90, 90, 89, 89, 88,
87, 87, 86, 84, 84, 84, 83, 83, 81, 81, 80, 80, 78, 77, 77, 75, 74, 74, 73, 73,
71, 70, 69, 68, 67, 65, 65, 64, 63, 62, 61, 59, 59, 57, 59, 71, 78, 68, 69, 76,
81, 81, 80, 80, 81, 85, 87, 87, 86, 84, 84, 84, 86, 85, 87, 86, 86, 86, 85, 86,
84, 85, 85, 84, 83, 83, 83, 83, 83, 81, 81, 75, 59, 59, 65, 59, 50, 44, 43, 42,
39, 35, 30, 27, 25, 23, 22, 20, 16, 14, 10, 8, 6, 3, 1, -2, -5, -7, -9, -11,
-14, -18, -20, -23, -24, -27, -24, -10, -13, -23, -21, -14, -12, -14, -16, -17,
-15, -14, -14, -16, -17, -19, -20, -20, -21, -20, -21, -23, -23, -25, -25, -25,
-26, -27, -28, -28, -29, -29, -30, -31, -32, -32, -33, -45, -58, -53, -50, -57,
-66, -70, -71, -71, -74, -79, -83, -85, -86, -87, -88, -90, -93, -95, -97, -100,
-101, -102, -104, -106, -108, -110, -111, -113, -114, -116, -117, -119, -113,
-100, -103, -111, -106, -99, -95, -97, -98, -98, -95, -92, -92, -92, -92, -93,
-92, -92, -90, -90, -88, -87, -87, -87, -86, -86, -84, -84, -84, -83, -82, -81,
-80, -80, -78, -77, -77, -77, -75, -74, -73, -72, -72, -69, -69, -68, -66, -67,
-66, -64, -63, -63, -62, -60, -60, -59, -57, -56, -56, -55, -53, -53, -52, -51,
-51, -48, -48, -48, -47, -46, -45, -44, -43, -43, -42, -40, -40, -39, -38, -38,
-37, -36, -35, -34, -34, -33, -32, -31, -31, -30, -29, -28, -27, -27, -26, -26,
-25, -28, -43, -45, -36, -39, -48, -52, -53, -52, -52, -56, -59, -60, -61, -60,
-60, -59, -62, -63, -64, -65, -65, -66, -66, -67, -66, -67, -68, -68, -68, -68,
-68, -69, -68, -68, -69, -69, -69, -69, -70, -70, -70, -70, -69, -69, -70, -68,
-69, -68, -68, -68, -67, -67, -67, -66, -66, -65, -65, -63, -62, -62, -61, -60,
-59, -58, -57, -57, -55, -55, -54, -53, -52, -51, -49, -48, -47, -46, -44, -43,
-42, -40, -39, -37, -36, -35, -34, -32, -31, -29, -28, -27, -25, -24, -21, -20,
-19, -17, -16, -14, -12, -10, -9, -8, -6, -4, -3, -2, 0, };