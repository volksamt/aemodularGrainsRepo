#define DATA_LENGTH 512
#define DATA AKWF_1028

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 10, 14, 20, 23, 29, 33, 38, 42,
47, 50, 56, 60, 64, 70, 75, 107, 110, 104, 104, 101, 101, 97, 96, 92, 92, 89,
88, 86, 84, 81, 80, 77, 76, 75, 71, 70, 67, 66, 63, 62, 59, 58, 56, 53, 52, 49,
48, 46, 44, 42, 39, 38, 36, 33, 32, 30, 28, 26, 24, 23, 21, 18, 16, 14, 11, 10,
9, 6, 4, 3, 0, -2, -3, -6, -6, -7, -6, -6, -6, -6, -6, -6, -6, -7, -7, -7, -7,
-6, -6, -7, -6, -7, -7, -7, -7, -6, -7, -7, -6, -7, -6, -7, -6, -7, -7, -7, -7,
-6, -7, -6, -6, -6, -6, -7, -6, -6, -6, -6, -7, -6, -6, -6, -7, -6, -6, -7, -6,
-6, -6, -7, -6, -6, -7, -7, -6, -7, -5, -6, -7, -6, -7, -7, -7, -6, -6, -6, -7,
-5, -6, -6, -6, -6, -6, -6, -6, -6, -7, -6, -7, -6, -6, -7, -6, -6, -6, -7, -6,
-6, -6, -7, -6, -6, -6, -6, -6, -6, -6, -7, -7, -6, -7, -6, -6, -6, -7, -6, -6,
-6, -7, -7, -6, -6, -6, -6, -6, -6, -7, -6, -7, -6, -7, -6, -6, -6, -6, -6, -7,
-6, -6, -6, -6, -5, -6, -6, -6, -7, -7, -6, -7, -7, -6, -7, -6, -6, -6, -5, -6,
-6, -6, -7, -5, -6, -6, -7, -6, -6, -7, -7, -7, -6, -6, -6, -6, -6, -6, -6, -6,
-5, -6, -6, -6, -7, -6, -6, -6, -6, -6, -7, -6, -6, -5, -6, -5, -6, -6, -7, -6,
-5, -6, -7, -6, -5, -6, -6, -6, -6, -6, -6, -5, -6, -6, -7, -7, -6, -5, -7, -6,
-6, -6, -6, -6, -6, -7, -9, -11, -12, -14, -16, -17, -19, -21, -23, -23, -25,
-26, -28, -30, -33, -33, -35, -36, -38, -39, -41, -43, -44, -46, -47, -49, -50,
-52, -54, -55, -57, -58, -59, -61, -62, -64, -66, -67, -67, -69, -70, -72, -73,
-74, -76, -78, -80, -81, -82, -83, -84, -86, -88, -89, -90, -92, -93, -94, -96,
-97, -98, -99, -101, -102, -103, -103, -107, -107, -109, -109, -112, -111, -115,
-112, -117, -114, -124, -102, -10, 2, -4, 0, -1, 1, 1, 3, 2, 4, 4, 7, 7, 9, 8,
10, 11, 12, 13, 13, 14, 15, 15, 17, 17, 18, 18, 19, 21, 21, 21, 23, 24, 24, 25,
26, 27, 28, 28, 28, 30, 30, 32, 32, 32, 33, 34, 35, 35, 36, 37, 38, 38, 39, 39,
40, 41, 42, 42, 43, 44, 44, 45, 45, 46, 47, 46, 48, 48, 49, 57, 44, -14, -62,
-63, -55, -54, -53, -53, -50, -50, -48, -48, -46, -45, -44, -43, -42, -40, -40,
-38, -37, -36, -35, -34, -33, -32, -32, -30, -29, -28, -27, -27, -26, -25, -24,
-23, -22, -21, -21, -20, -19, -18, -18, -17, -16, -15, -14, -14, -12, -12, -11,
-10, -10, -9, -9, -8, -7, -7, -6, -5, -4, -4, -3, -3, -3, -2, -1, -1, };