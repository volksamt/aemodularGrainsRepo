#define DATA_LENGTH 512
#define DATA AKWF_1024

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 6, 8, 10, 13, 15, 17, 19, 21,
22, 25, 26, 28, 30, 31, 34, 35, 37, 39, 40, 43, 44, 45, 47, 49, 50, 51, 54, 55,
56, 57, 60, 60, 62, 63, 64, 65, 66, 67, 69, 69, 71, 72, 73, 75, 75, 76, 77, 78,
79, 79, 80, 81, 81, 82, 84, 84, 85, 85, 86, 87, 88, 88, 89, 89, 90, 92, 91, 92,
92, 93, 94, 94, 94, 95, 96, 96, 96, 96, 96, 98, 98, 97, 98, 99, 99, 99, 100,
100, 101, 101, 100, 101, 102, 102, 103, 102, 103, 103, 104, 103, 103, 104, 104,
105, 105, 105, 105, 106, 106, 106, 106, 107, 107, 107, 108, 108, 107, 107, 108,
109, 108, 108, 108, 109, 109, 109, 110, 110, 109, 109, 111, 111, 111, 111, 111,
111, 112, 111, 111, 112, 112, 112, 113, 113, 113, 113, 113, 113, 114, 114, 114,
114, 115, 115, 116, 115, 115, 116, 116, 116, 116, 117, 117, 117, 117, 116, 118,
118, 118, 118, 117, 118, 119, 118, 118, 119, 118, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 118, 118, 118, 118, 117, 117, 116, 115, 115,
114, 112, 112, 110, 109, 109, 107, 105, 104, 102, 101, 99, 97, 96, 93, 92, 90,
87, 86, 84, 81, 79, 77, 74, 72, 70, 67, 65, 63, 60, 58, 55, 52, 51, 48, 46, 43,
40, 38, 35, 34, 31, 29, 26, 24, 21, 19, 17, 14, 12, 10, 7, 5, 3, 0, -2, -4, -6,
-8, -11, -12, -15, -17, -18, -21, -23, -25, -27, -29, -30, -33, -34, -36, -38,
-39, -41, -42, -44, -45, -48, -49, -50, -52, -54, -55, -56, -58, -58, -60, -62,
-63, -64, -65, -67, -67, -69, -70, -70, -72, -74, -74, -75, -76, -77, -78, -79,
-80, -80, -81, -82, -83, -83, -84, -84, -85, -86, -87, -88, -88, -89, -90, -90,
-91, -90, -92, -92, -93, -93, -95, -95, -95, -96, -96, -96, -97, -97, -98, -97,
-99, -99, -99, -99, -100, -100, -100, -101, -101, -101, -101, -102, -102, -102,
-103, -103, -103, -103, -104, -104, -104, -104, -105, -105, -105, -105, -106,
-106, -106, -106, -106, -106, -106, -108, -107, -108, -108, -108, -108, -108,
-108, -109, -109, -109, -109, -110, -110, -110, -110, -111, -110, -110, -112,
-111, -111, -112, -112, -112, -112, -112, -113, -113, -113, -113, -113, -113,
-113, -114, -114, -115, -115, -114, -116, -115, -115, -115, -115, -115, -116,
-117, -116, -117, -117, -117, -116, -118, -118, -117, -117, -117, -117, -117,
-118, -119, -119, -118, -118, -118, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -118, -118, -117, -117, -116, -115, -115,
-114, -113, -112, -111, -109, -108, -107, -106, -104, -102, -101, -100, -97,
-95, -93, -92, -90, -87, -85, -83, -81, -79, -77, -75, -72, -70, -68, -65, -63,
-60, -58, -56, -53, -50, -47, -45, -43, -40, -38, -35, -33, -31, -28, -26, -23,
-21, -19, -17, -13, -11, -9, -7, -4, -2, 0, };