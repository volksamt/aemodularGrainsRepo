#define DATA_LENGTH 512
#define DATA AKWF_1062

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 1, 3, 3, 4, 4, 5, 6, 7, 7, 8, 8,
10, 10, 10, 11, 12, 13, 13, 15, 15, 15, 16, 16, 18, 18, 19, 19, 21, 21, 22, 23,
25, 25, 26, 27, 29, 29, 29, 30, 31, 33, 34, 34, 35, 36, 37, 39, 40, 41, 40, 42,
43, 44, 44, 45, 46, 47, 48, 49, 49, 50, 51, 52, 52, 53, 53, 55, 54, 55, 56, 57,
57, 57, 57, 59, 59, 60, 60, 60, 61, 61, 62, 62, 63, 63, 64, 64, 65, 66, 66, 66,
67, 68, 68, 69, 70, 70, 72, 71, 72, 73, 74, 74, 75, 76, 76, 77, 77, 78, 79, 79,
80, 81, 82, 82, 82, 83, 83, 85, 85, 85, 86, 86, 87, 88, 88, 88, 89, 90, 91, 89,
91, 91, 91, 92, 92, 92, 93, 93, 93, 94, 94, 94, 95, 95, 95, 95, 96, 96, 96, 97,
97, 97, 97, 97, 98, 98, 98, 100, 99, 99, 100, 100, 100, 101, 101, 101, 102, 102,
103, 103, 104, 103, 104, 105, 105, 105, 105, 106, 106, 106, 107, 107, 107, 107,
108, 108, 109, 108, 109, 109, 109, 109, 110, 110, 110, 110, 110, 110, 110, 111,
111, 110, 111, 111, 110, 111, 111, 111, 111, 112, 111, 112, 111, 111, 111, 112,
111, 111, 112, 111, 111, 113, 114, 116, 115, 113, 112, 113, 112, 112, 112, 113,
114, 113, 114, 114, 113, 113, 112, 112, 112, 111, 108, 104, 101, 101, 99, 98,
97, 97, 95, 93, 92, 89, 86, 85, 84, 83, 80, 80, 78, 77, 76, 74, 72, 70, 69, 66,
65, 65, 63, 61, 60, 58, 57, 55, 55, 53, 53, 52, 50, 48, 48, 46, 45, 44, 43, 41,
39, 38, 38, 36, 35, 34, 33, 31, 31, 29, 28, 26, 25, 24, 23, 21, 20, 18, 17, 15,
14, 14, 11, 10, 9, 6, 6, 5, 3, 1, 0, -2, -4, -5, -6, -7, -10, -11, -13, -13,
-15, -16, -19, -18, -21, -22, -23, -25, -26, -28, -28, -30, -32, -32, -34, -35,
-36, -38, -39, -40, -41, -43, -43, -44, -46, -48, -49, -49, -50, -52, -53, -55,
-56, -57, -58, -59, -60, -62, -62, -64, -65, -67, -68, -69, -71, -71, -73, -74,
-76, -77, -79, -80, -81, -83, -84, -85, -86, -87, -89, -90, -91, -94, -95, -96,
-96, -98, -100, -100, -102, -103, -105, -106, -107, -108, -110, -110, -112,
-113, -115, -116, -116, -117, -119, -118, -115, -108, -105, -104, -102, -102,
-102, -101, -100, -98, -96, -95, -92, -89, -87, -87, -84, -83, -82, -82, -80,
-79, -77, -75, -73, -72, -70, -70, -69, -68, -68, -66, -66, -65, -64, -62, -61,
-60, -59, -59, -58, -57, -58, -56, -56, -55, -54, -53, -53, -51, -50, -50, -50,
-49, -48, -47, -46, -44, -44, -43, -42, -41, -39, -39, -37, -36, -36, -34, -33,
-32, -31, -30, -28, -28, -25, -24, -23, -22, -20, -19, -18, -16, -15, -15, -12,
-11, -11, -10, -9, -8, -6, -6, -4, -4, -2, -2, -1, };