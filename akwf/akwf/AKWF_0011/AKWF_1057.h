#define DATA_LENGTH 512
#define DATA AKWF_1057

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 19, 13, 6, 5, 7, 6, 10, 18, 23, 27,
35, 42, 45, 47, 52, 55, 55, 56, 58, 61, 62, 64, 66, 69, 68, 67, 67, 65, 65, 69,
74, 81, 86, 87, 85, 77, 70, 60, 52, 46, 40, 35, 27, 19, 12, 5, 3, 4, 8, 13, 20,
23, 27, 30, 32, 35, 36, 38, 42, 44, 46, 49, 50, 52, 51, 50, 48, 47, 46, 45, 46,
50, 54, 57, 63, 66, 70, 71, 71, 70, 68, 65, 64, 62, 61, 60, 60, 59, 56, 54, 49,
44, 40, 38, 38, 38, 35, 30, 18, 4, -12, -28, -41, -51, -58, -63, -69, -75, -83,
-90, -97, -103, -109, -112, -114, -112, -109, -104, -96, -91, -86, -81, -77,
-76, -73, -72, -71, -68, -66, -63, -60, -57, -55, -52, -50, -46, -43, -39, -35,
-30, -25, -20, -14, -11, -8, -6, -5, -4, -3, -2, 0, 1, 2, 2, 2, 2, 4, 6, 12, 17,
21, 21, 18, 11, 3, -6, -14, -20, -27, -32, -39, -46, -54, -59, -62, -61, -57,
-51, -44, -39, -35, -32, -30, -28, -26, -23, -20, -17, -14, -12, -9, -7, -8, -9,
-9, -10, -11, -8, -7, -1, 3, 10, 15, 20, 24, 26, 28, 31, 32, 33, 35, 36, 38, 39,
40, 40, 41, 39, 38, 36, 34, 34, 36, 38, 37, 31, 19, 5, -11, -27, -38, -45, -49,
-52, -54, -58, -64, -70, -76, -82, -85, -87, -87, -84, -79, -71, -63, -55, -49,
-45, -42, -40, -38, -33, -20, 2, 11, 5, -3, -3, -2, -3, 2, 9, 13, 17, 23, 30,
33, 35, 39, 42, 42, 43, 45, 48, 48, 50, 53, 54, 53, 53, 52, 51, 51, 55, 60, 66,
70, 72, 69, 62, 52, 45, 36, 30, 25, 19, 13, 5, -1, -7, -10, -7, -3, 3, 10, 14,
18, 22, 25, 27, 30, 33, 36, 39, 42, 45, 47, 49, 49, 49, 47, 47, 46, 46, 48, 51,
56, 61, 66, 69, 72, 73, 72, 72, 68, 66, 64, 63, 61, 60, 60, 58, 55, 52, 47, 42,
38, 37, 36, 36, 32, 26, 14, -1, -18, -33, -46, -55, -62, -67, -74, -80, -87,
-95, -102, -109, -114, -118, -119, -119, -114, -109, -101, -96, -91, -87, -85,
-83, -82, -81, -79, -77, -75, -72, -71, -68, -66, -64, -61, -59, -56, -52, -48,
-44, -39, -35, -31, -27, -25, -24, -22, -22, -22, -20, -20, -19, -18, -19, -19,
-19, -19, -15, -11, -6, -2, -3, -7, -14, -23, -31, -40, -45, -51, -58, -65, -72,
-80, -85, -88, -87, -81, -75, -69, -65, -61, -57, -55, -53, -49, -47, -44, -41,
-37, -34, -31, -30, -30, -31, -31, -32, -32, -29, -26, -21, -16, -10, -4, 1, 6,
9, 12, 15, 16, 19, 20, 22, 23, 26, 27, 29, 28, 28, 26, 25, 24, 26, 27, 30, 30,
23, 12, -3, -19, -32, -43, -49, -52, -54, -57, -61, -66, -71, -76, -81, -85,
-86, -85, -81, -74, -66, -58, -50, -44, -39, -35, -34, -30, -26, -11, };