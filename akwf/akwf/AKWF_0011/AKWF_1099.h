#define DATA_LENGTH 512
#define DATA AKWF_1099

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 1, 2, 3, 3, 3, 4, 4, 5, 6, 6,
7, 7, 8, 8, 9, 9, 10, 10, 11, 11, 13, 13, 13, 14, 14, 15, 16, 17, 18, 18, 19,
19, 21, 22, 23, 24, 25, 26, 26, 28, 29, 30, 32, 33, 34, 35, 37, 38, 40, 42, 43,
45, 47, 49, 51, 52, 54, 57, 58, 60, 62, 63, 65, 66, 68, 69, 71, 72, 74, 75, 77,
79, 81, 82, 84, 86, 88, 89, 91, 93, 95, 97, 99, 101, 103, 106, 107, 108, 110,
111, 112, 113, 114, 115, 117, 117, 117, 118, 118, 119, 119, 119, 119, 119, 119,
119, 119, 119, 118, 117, 118, 118, 117, 116, 116, 116, 115, 115, 114, 114, 113,
113, 112, 111, 110, 109, 109, 107, 107, 106, 105, 104, 102, 101, 101, 100, 99,
98, 97, 95, 94, 93, 92, 90, 90, 88, 86, 84, 84, 81, 80, 79, 77, 75, 74, 72, 70,
68, 67, 64, 62, 61, 58, 57, 56, 53, 52, 51, 49, 48, 47, 45, 43, 43, 42, 41, 39,
39, 38, 37, 36, 34, 34, 34, 32, 33, 30, 30, 30, 29, 29, 27, 28, 27, 26, 25, 25,
24, 23, 22, 23, 21, 21, 21, 20, 19, 19, 18, 18, 18, 17, 17, 17, 16, 16, 15, 14,
15, 14, 13, 14, 12, 12, 11, 11, 11, 11, 10, 10, 10, 8, 9, 9, 7, 8, 7, 7, 7, 6,
5, 6, 4, 4, 4, 3, 3, 2, 2, 3, 1, 1, 1, 0, 0, -1, -2, -2, -2, -2, -3, -4, -4, -4,
-5, -6, -6, -6, -7, -7, -8, -8, -9, -9, -10, -11, -12, -11, -12, -14, -14, -15,
-15, -16, -17, -18, -18, -19, -20, -21, -22, -23, -24, -25, -25, -26, -28, -28,
-30, -32, -32, -35, -36, -37, -38, -40, -42, -44, -46, -46, -49, -51, -53, -55,
-56, -58, -60, -61, -64, -65, -66, -69, -70, -71, -73, -75, -75, -77, -80, -81,
-82, -84, -86, -87, -90, -91, -93, -95, -98, -99, -102, -104, -105, -107, -109,
-110, -111, -112, -114, -114, -115, -116, -117, -118, -118, -118, -119, -119,
-119, -120, -119, -118, -119, -120, -118, -119, -118, -118, -118, -117, -117,
-117, -116, -116, -115, -114, -113, -113, -112, -112, -110, -110, -110, -108,
-108, -106, -106, -105, -104, -103, -102, -101, -99, -99, -97, -96, -96, -94,
-93, -92, -91, -89, -88, -86, -84, -84, -82, -81, -78, -76, -75, -73, -72, -70,
-68, -66, -64, -62, -60, -58, -57, -55, -53, -52, -50, -49, -47, -46, -45, -44,
-43, -42, -40, -39, -39, -37, -36, -35, -35, -34, -34, -33, -32, -31, -30, -30,
-29, -29, -27, -27, -27, -25, -25, -25, -24, -23, -22, -22, -21, -21, -21, -20,
-19, -20, -18, -19, -17, -17, -17, -17, -16, -16, -14, -15, -14, -14, -13, -13,
-12, -12, -12, -11, -11, -10, -11, -9, -9, -9, -9, -9, -7, -8, -7, -6, -7, -6,
-6, -5, -5, -4, -4, -3, -3, -2, -2, -1, -1, -1, -1, 0, };