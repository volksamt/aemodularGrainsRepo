#define DATA_LENGTH 512
#define DATA AKWF_1030

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 0, 0, 1, 2, 4, 5, 6, 6, 7, 9, 10,
10, 11, 12, 13, 14, 15, 16, 17, 17, 19, 20, 20, 21, 22, 23, 25, 25, 26, 27, 28,
28, 29, 30, 31, 32, 33, 34, 34, 35, 35, 37, 37, 38, 39, 40, 40, 41, 42, 43, 43,
52, 38, -25, -60, -52, -49, -48, -46, -44, -44, -42, -40, -39, -38, -37, -35,
-34, -32, -31, -30, -28, -27, -26, -24, -23, -22, -21, -19, -18, -17, -15, -15,
-14, -12, -11, -9, -8, -8, -6, -5, -4, -2, -1, 1, 6, 10, 15, 19, 23, 28, 32, 36,
40, 44, 49, 53, 58, 62, 66, 71, 96, 111, 106, 106, 102, 101, 98, 97, 94, 92, 89,
87, 86, 83, 81, 78, 77, 74, 73, 69, 69, 63, 67, 31, -7, 4, 2, 6, 8, 11, 12, 14,
16, 17, 21, 22, 25, 27, 29, 31, 34, 34, 38, 39, 42, 44, 46, 48, 49, 52, 54, 56,
59, 60, 63, 64, 66, 70, 70, 74, 75, 77, 79, 81, 83, 85, 87, 90, 92, 93, 95, 98,
100, 102, 105, 106, 108, 109, 105, 103, 101, 100, 97, 96, 92, 91, 89, 87, 85,
83, 80, 79, 76, 74, 72, 69, 68, 66, 64, 62, 60, 57, 55, 53, 52, 49, 47, 46, 43,
41, 39, 36, 35, 33, 31, 29, 27, 25, 23, 20, 19, 16, 15, 13, 10, 9, 7, 4, 3, 0,
-1, -4, -5, -6, -6, -6, -6, -6, -5, -6, -6, -6, -6, -6, -6, -7, -6, -6, -6, -6,
-5, -6, -6, -6, -6, -7, -6, -6, -6, -6, -6, -6, -6, -7, -6, -6, -6, -6, -6, -6,
-5, -6, -7, -7, -5, -6, -6, -6, -6, -6, -6, -6, -5, -7, -6, -6, -6, -6, -6, -6,
-5, -6, -6, -5, -6, -6, -6, -6, -6, -6, -7, -6, -6, -6, -8, -10, -11, -13, -15,
-17, -18, -21, -23, -24, -26, -27, -29, -32, -33, -34, -36, -38, -40, -42, -44,
-45, -47, -49, -51, -51, -54, -55, -58, -59, -60, -62, -64, -65, -67, -69, -70,
-73, -74, -75, -77, -79, -80, -81, -83, -86, -87, -88, -90, -92, -93, -95, -97,
-98, -100, -102, -103, -105, -106, -108, -110, -111, -113, -113, -115, -117,
-120, -118, -117, -115, -114, -112, -111, -109, -107, -105, -104, -102, -101,
-99, -98, -96, -95, -94, -91, -90, -89, -88, -85, -84, -82, -82, -80, -78, -77,
-75, -73, -72, -71, -69, -68, -66, -64, -64, -61, -60, -59, -57, -56, -54, -54,
-52, -52, -49, -48, -47, -45, -43, -42, -40, -39, -38, -37, -36, -34, -34, -31,
-33, -19, -4, -8, -8, -9, -11, -13, -13, -15, -17, -17, -18, -20, -21, -22, -23,
-25, -26, -27, -28, -30, -30, -32, -33, -34, -35, -36, -37, -39, -40, -41, -43,
-44, -45, -46, -47, -48, -50, -51, -52, -52, -54, -55, -56, -56, -57, -59, -60,
-61, -63, -64, -65, -65, -67, -67, -69, -69, -71, -71, -73, -73, -75, -75, -78,
-77, -81, -81, -26, };