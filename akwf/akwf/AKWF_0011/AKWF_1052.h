#define DATA_LENGTH 512
#define DATA AKWF_1052

const PROGMEM int8_t DATA[DATA_LENGTH] = {14, 47, 69, 88, 107, 118, 119, 111,
104, 97, 97, 101, 105, 106, 107, 105, 103, 102, 103, 103, 103, 105, 105, 103,
104, 103, 104, 104, 104, 104, 103, 103, 104, 104, 103, 104, 103, 104, 103, 103,
103, 103, 104, 104, 104, 103, 103, 104, 103, 104, 104, 103, 103, 103, 103, 103,
103, 104, 104, 103, 104, 103, 104, 104, 103, 103, 103, 103, 102, 103, 103, 103,
103, 103, 103, 104, 103, 103, 103, 103, 103, 103, 103, 103, 103, 103, 103, 103,
103, 103, 103, 103, 103, 103, 102, 102, 103, 103, 103, 103, 103, 103, 102, 102,
103, 102, 103, 102, 103, 102, 102, 103, 103, 103, 103, 103, 103, 102, 103, 103,
103, 102, 102, 102, 103, 102, 103, 102, 103, 103, 102, 102, 103, 102, 103, 102,
103, 103, 102, 102, 102, 102, 101, 103, 102, 103, 102, 102, 102, 103, 102, 102,
101, 102, 102, 102, 102, 102, 101, 102, 102, 102, 102, 101, 102, 101, 102, 102,
101, 102, 102, 101, 102, 101, 102, 102, 102, 102, 102, 102, 101, 101, 102, 102,
102, 101, 101, 102, 102, 102, 101, 102, 102, 102, 102, 102, 101, 101, 101, 101,
101, 102, 101, 102, 102, 99, 65, 54, 64, 38, 16, -15, -12, 2, 13, 46, 63, 44, 0,
-17, -29, -52, -57, -18, 18, 49, 86, 91, 51, 37, 18, -30, -18, -2, -32, -48,
-40, -44, -62, -85, -97, -97, -86, -76, -70, -71, -76, -81, -83, -82, -80, -78,
-78, -78, -79, -79, -80, -80, -79, -79, -79, -79, -79, -79, -80, -79, -79, -79,
-79, -79, -79, -79, -79, -79, -79, -79, -79, -79, -78, -78, -78, -78, -78, -78,
-79, -79, -78, -79, -80, -78, -80, -78, -79, -79, -79, -79, -79, -80, -79, -79,
-79, -79, -79, -79, -79, -79, -78, -78, -79, -79, -78, -78, -79, -78, -79, -79,
-79, -79, -79, -79, -79, -78, -79, -78, -78, -79, -78, -78, -79, -78, -79, -78,
-78, -78, -78, -78, -78, -79, -78, -78, -78, -78, -78, -78, -78, -78, -78, -78,
-79, -78, -78, -78, -78, -78, -78, -78, -78, -77, -78, -77, -77, -78, -78, -78,
-78, -78, -78, -78, -78, -79, -78, -78, -78, -78, -78, -78, -78, -78, -77, -77,
-78, -78, -78, -77, -78, -78, -78, -78, -77, -78, -78, -77, -78, -78, -77, -77,
-78, -77, -77, -77, -78, -77, -77, -77, -78, -78, -78, -77, -77, -77, -77, -77,
-77, -77, -78, -78, -77, -78, -77, -77, -78, -78, -78, -77, -78, -77, -77, -77,
-77, -78, -77, -78, -77, -77, -77, -77, -77, -78, -78, -77, -77, -77, -77, -78,
-77, -77, -77, -78, -78, -77, -77, -77, -77, -76, -77, -77, -77, -77, -77, -77,
-77, -77, -76, -77, -77, -77, -77, -77, -76, -76, -77, -76, -77, -76, -76, -76,
-77, -77, -77, -77, -77, -77, -77, -76, -76, -76, -76, -77, -76, -76, -77, -77,
-77, -77, -76, -77, -77, -76, -76, -77, -76, -76, -77, -76, -78, -55, -26, -42,
-63, -47, -11, 1, };