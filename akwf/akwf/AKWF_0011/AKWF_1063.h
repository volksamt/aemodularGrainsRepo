#define DATA_LENGTH 512
#define DATA AKWF_1063

const PROGMEM int8_t DATA[DATA_LENGTH] = {47, 116, 113, 116, 115, 116, 115, 116,
117, 116, 117, 117, 118, 118, 118, 119, 120, 118, 120, 119, 119, 118, 119, 118,
118, 118, 117, 118, 118, 117, 116, 116, 115, 114, 115, 113, 112, 112, 112, 111,
109, 110, 108, 108, 107, 106, 105, 105, 104, 103, 102, 101, 100, 99, 99, 98, 96,
95, 94, 94, 92, 91, 90, 88, 87, 86, 86, 85, 83, 81, 80, 80, 78, 76, 76, 74, 73,
72, 70, 68, 68, 66, 65, 63, 62, 61, 59, 58, 57, 56, 54, 52, 51, 50, 48, 47, 45,
44, 43, 41, 41, 39, 38, 36, 35, 34, 32, 31, 31, 29, 29, 27, 25, 24, 23, 21, 21,
20, 18, 18, 16, 15, 15, 14, 14, 12, 12, 11, 10, 9, 8, 8, 7, 5, 6, 5, 4, 3, 2, 2,
3, 2, 2, 2, 1, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1,
0, 0, -1, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 1, -1, 0, -1, 0, 0, 0, 0, 0, -1, 1, -1,
0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0,
0, 0, 0, -1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 1, 1, 0, 0, 0, -1, 0, 1, 0, 0, 0,
0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, -1, 0,
-1, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 1, 0, 0,
0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0,
0, 1, 0, 0, 1, 0, -1, 0, 0, -1, 0, 0, -1, -1, -1, -1, -1, 0, -1, -1, -2, -2, -2,
-2, -3, -1, -3, -3, -3, -4, -5, -5, -4, -5, -5, -6, -6, -6, -8, -7, -8, -9, -9,
-9, -10, -10, -11, -11, -13, -13, -14, -14, -14, -16, -17, -16, -18, -19, -19,
-20, -21, -21, -22, -23, -24, -25, -26, -27, -28, -29, -30, -31, -32, -32, -33,
-34, -36, -36, -37, -38, -40, -41, -41, -43, -44, -45, -46, -47, -48, -49, -50,
-52, -52, -54, -55, -56, -58, -58, -59, -61, -61, -63, -63, -65, -66, -67, -68,
-69, -70, -71, -72, -73, -74, -75, -77, -77, -78, -79, -80, -81, -83, -84, -84,
-85, -86, -87, -87, -89, -90, -90, -92, -92, -92, -93, -94, -94, -95, -96, -96,
-97, -97, -98, -99, -100, -100, -100, -100, -102, -102, -102, -102, -103, -103,
-103, -104, -104, -104, -104, -106, -103, -106, -103, -106, -103, -107, -59, };