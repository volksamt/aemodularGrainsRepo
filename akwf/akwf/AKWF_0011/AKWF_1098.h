#define DATA_LENGTH 512
#define DATA AKWF_1098

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 37, 64, 83, 97, 103, 107, 108, 108,
108, 107, 106, 105, 104, 104, 102, 101, 100, 99, 98, 98, 96, 95, 94, 93, 93, 92,
91, 90, 89, 88, 88, 86, 86, 85, 84, 84, 82, 81, 81, 80, 79, 78, 78, 77, 76, 75,
75, 75, 74, 73, 72, 72, 71, 70, 69, 69, 69, 68, 67, 66, 66, 66, 65, 63, 64, 63,
62, 62, 61, 60, 60, 58, 58, 58, 57, 57, 56, 56, 56, 54, 54, 54, 53, 53, 51, 51,
51, 51, 50, 50, 49, 49, 49, 48, 47, 47, 47, 46, 46, 45, 45, 44, 44, 44, 43, 43,
43, 42, 41, 41, 40, 40, 40, 39, 39, 38, 38, 38, 37, 38, 37, 36, 36, 37, 35, 35,
35, 35, 34, 35, 34, 33, 32, 33, 32, 32, 31, 31, 31, 30, 30, 31, 30, 30, 29, 29,
28, 28, 29, 28, 27, 27, 27, 27, 26, 27, 26, 26, 26, 25, 25, 24, 25, 25, 24, 24,
24, 24, 23, 23, 22, 22, 22, 22, 22, 22, 22, 22, 21, 21, 21, 20, 21, 20, 19, 19,
20, 19, 20, 19, 19, 18, 18, 17, 18, 18, 18, 17, 17, 18, 17, 17, 17, 16, 17, 16,
17, 16, 16, 16, 16, 16, 15, 15, 15, 15, 15, 14, 15, 14, 15, 14, 13, 14, 14, 14,
13, 14, 13, 13, 13, 13, 13, 12, 12, 11, 12, 13, 12, 12, 12, 11, 11, 12, 11, 11,
12, 10, 11, 10, 10, 11, 10, 10, 10, 11, 10, 10, 10, 10, 10, 10, 9, 10, 9, 9, 9,
8, 9, 9, 10, 9, 9, 8, 8, 8, 8, 9, 9, 9, 8, 8, 8, 7, 8, 8, 7, 7, 8, 7, 7, 8, 6,
6, 7, 7, 7, 7, 6, 6, 7, 6, 7, 6, 6, 2, -21, -51, -77, -97, -109, -115, -118,
-119, -119, -118, -117, -117, -116, -114, -113, -112, -110, -109, -109, -108,
-107, -105, -105, -104, -102, -101, -102, -100, -99, -99, -97, -95, -96, -94,
-93, -93, -91, -92, -89, -88, -89, -88, -87, -85, -85, -84, -84, -83, -81, -81,
-80, -80, -78, -78, -77, -76, -76, -75, -74, -74, -72, -72, -72, -70, -70, -69,
-69, -68, -67, -67, -66, -66, -64, -65, -64, -62, -63, -63, -62, -61, -60, -60,
-59, -58, -58, -57, -56, -56, -56, -55, -54, -55, -53, -53, -53, -52, -52, -52,
-51, -50, -49, -49, -49, -49, -48, -47, -47, -46, -45, -46, -46, -45, -44, -43,
-43, -43, -43, -42, -42, -41, -42, -40, -40, -40, -40, -38, -39, -38, -38, -38,
-38, -37, -37, -36, -36, -35, -36, -35, -34, -34, -34, -33, -33, -33, -32, -33,
-32, -31, -31, -31, -30, -30, -30, -30, -30, -29, -29, -29, -28, -29, -28, -27,
-28, -27, -27, -26, -26, -25, -26, -26, -25, -25, -25, -24, -25, -24, -24, -24,
-23, -23, -22, -23, -23, -23, -22, -22, -21, -22, -21, -21, -21, -21, -20, -20,
-20, -20, -19, -20, -19, -19, -19, -19, -18, -19, -10, };