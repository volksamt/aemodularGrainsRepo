#define DATA_LENGTH 512
#define DATA AKWF_1032

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 22, 21, 21, 21, 21, 52, 68, 66, 67,
66, 67, 66, 67, 67, 67, 68, 67, 68, 67, 67, 67, 67, 67, 67, 67, 67, 66, 67, 67,
67, 66, 67, 66, 66, 66, 67, 66, 66, 66, 66, 67, 67, 67, 64, 81, 109, 112, 113,
112, 112, 112, 113, 112, 112, 113, 112, 112, 112, 112, 112, 112, 112, 112, 113,
112, 112, 112, 112, 112, 112, 112, 112, 112, 112, 112, 112, 112, 112, 111, 112,
112, 112, 112, 112, 111, 112, 112, 112, 111, 112, 112, 112, 112, 111, 112, 112,
112, 112, 112, 112, 111, 112, 111, 112, 112, 111, 111, 111, 111, 111, 111, 111,
112, 111, 112, 111, 111, 111, 110, 111, 111, 111, 111, 111, 111, 111, 111, 110,
111, 111, 111, 111, 111, 111, 111, 111, 111, 111, 111, 111, 111, 111, 111, 111,
110, 110, 111, 111, 110, 111, 110, 112, 106, 90, 72, 63, 65, 65, 65, 64, 65, 65,
65, 65, 65, 65, 65, 65, 65, 65, 65, 65, 65, 65, 66, 65, 65, 64, 65, 65, 65, 65,
65, 65, 64, 65, 64, 65, 64, 65, 65, 65, 64, 65, 63, 68, 51, 5, -47, -76, -72,
-74, -73, -74, -73, -74, -73, -74, -74, -74, -72, -77, -94, -110, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -120, -118, -119, -119, -119, -118, -119, -120, -119, -119, -119, -118,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-118, -119, -118, -119, -118, -119, -118, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -118, -118, -119, -119, -119, -119, -118, -119, -118, -119,
-118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -119,
-118, -119, -119, -119, -118, -118, -117, -118, -119, -118, -119, -118, -119,
-119, -118, -118, -118, -118, -119, -118, -118, -118, -118, -118, -117, -118,
-118, -118, -118, -117, -118, -118, -118, -118, -118, -118, -117, -118, -118,
-118, -118, -118, -118, -117, -118, -117, -117, -118, -118, -117, -118, -118,
-117, -117, -118, -118, -118, -119, -117, -117, -118, -118, -117, -119, -115,
-102, -88, -74, -71, -72, -71, -72, -72, -72, -72, -72, -71, -71, -71, -71, -72,
-71, -71, -71, -71, -71, -72, -72, -72, -71, -71, -71, -71, -71, -71, -72, -71,
-72, -71, -71, -71, -71, -71, -71, -72, -71, -71, -71, -71, -72, -71, -71, -72,
-72, -71, -71, -71, -71, -71, -71, -71, -72, -71, -71, -71, -71, -71, -71, -71,
-70, -71, -70, -71, -70, -71, -71, -71, -71, -71, -71, -71, -71, -71, -71, -70,
-71, -71, -71, -71, -71, -70, -71, -71, -70, -71, -70, -70, -71, -71, -71, -71,
-71, -70, -71, -71, -72, -65, -52, -37, -26, -25, -25, -24, -24, -25, -25, -26,
-25, -24, -25, -25, -25, -25, -24, -25, -25, -25, -26, -24, -25, -25, -25, -24,
-25, -24, -25, -25, -24, -24, -25, -25, -25, -25, -24, -25, -25, -25, -25, -24,
-25, -24, -24, -25, -24, -25, -23, -8, };