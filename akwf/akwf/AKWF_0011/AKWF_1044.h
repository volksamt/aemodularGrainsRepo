#define DATA_LENGTH 512
#define DATA AKWF_1044

const PROGMEM int8_t DATA[DATA_LENGTH] = {39, 45, 42, 45, 42, 44, 41, 43, 41,
42, 40, 42, 41, 41, 41, 40, 40, 40, 39, 39, 40, 40, 39, 39, 39, 39, 39, 39, 38,
38, 38, 39, 37, 37, 38, 36, 37, 37, 36, 37, 36, 35, 36, 36, 35, 36, 35, 35, 35,
35, 35, 34, 34, 34, 34, 34, 33, 33, 33, 33, 33, 32, 33, 32, 32, 32, 31, 31, 32,
30, 30, 31, 30, 30, 31, 30, 30, 29, 29, 29, 29, 29, 29, 28, 28, 28, 27, 28, 28,
27, 27, 27, 27, 27, 27, 26, 26, 26, 26, 26, 25, 24, 25, 24, 24, 24, 24, 24, 23,
24, 23, 23, 23, 23, 23, 22, 22, 22, 22, 22, 22, 21, 22, 21, 21, 21, 21, 21, 20,
20, 20, 20, 19, 18, 19, 19, 19, 19, 19, 18, 18, 18, 17, 18, 18, 17, 17, 18, 16,
16, 16, 16, 16, 16, 15, 15, 15, 16, 15, 15, 15, 15, 14, 14, 14, 14, 14, 13, 13,
13, 12, 12, 12, 13, 13, 11, 12, 11, 11, 11, 11, 11, 10, 10, 11, 10, 9, 9, 9, 10,
10, 10, 8, 9, 9, 8, 7, 8, 7, 8, 7, 7, 6, 7, 6, 8, 5, 7, 5, -33, -38, -36, -38,
-36, -39, -37, -38, -37, -40, -37, -38, -39, -39, -39, -39, -39, -39, -39, -40,
-41, -41, -41, -40, -41, -41, -41, -42, -42, -41, -42, -42, -42, -41, -43, -42,
-42, -42, -44, -44, -43, -44, -44, -44, -44, -44, -44, -45, -45, -44, -45, -45,
-45, -45, -47, -47, -46, -46, -47, -46, -47, -48, -47, -48, -48, -47, -48, -47,
-48, -48, -49, -49, -50, -49, -50, -50, -50, -50, -50, -50, -50, -50, -51, -51,
-51, -54, -26, -17, -21, -18, -20, -17, -19, -17, -18, -16, -17, -15, -16, -16,
-16, -15, -14, -14, -13, -13, -14, -13, -12, -13, -12, -12, -11, -11, -10, -10,
-10, -9, -9, -10, -8, -8, -7, -8, -8, -7, -7, -5, -6, -6, -5, -5, -4, -4, -4,
-2, -3, -3, -3, -3, -1, -2, -1, 0, 0, 0, 0, 1, 1, 2, 2, 2, 3, 3, 4, 3, 3, 5, 5,
5, 5, 6, 5, 6, 6, 7, 8, 7, 8, 8, 8, 9, 9, 9, 9, 10, 11, 11, 10, 11, 13, 11, 13,
13, 13, 13, 13, 14, 14, 15, 15, 16, 16, 16, 16, 17, 17, 17, 18, 18, 18, 19, 19,
19, 20, 20, 20, 20, 21, 22, 22, 22, 22, 22, 23, 23, 23, 24, 25, 25, 25, 26, 26,
26, 26, 27, 27, 27, 27, 28, 28, 29, 29, 29, 30, 30, 31, 31, 30, 31, 32, 32, 33,
33, 34, 33, 36, 19, 1, -2, -13, -19, -28, -32, -45, -48, -60, -59, -96, -118,
-95, -93, -85, -86, -82, -80, -78, -76, -73, -72, -70, -68, -65, -63, -61, -58,
-56, -55, -52, -50, -47, -45, -43, -41, -39, -37, -35, -32, -31, -27, -25, -24,
-22, -20, -17, -15, -13, -11, -8, -6, -4, -2, -1, };