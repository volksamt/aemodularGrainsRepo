#define DATA_LENGTH 512
#define DATA AKWF_1045

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 1, 1, 1, 2, 2, 1, 2, 2, 2, 2,
1, 2, 2, 1, 2, 1, 2, 1, 2, 2, 2, 2, 1, 3, 2, 2, 2, 1, 2, 2, 1, 2, 1, 2, 2, 2, 2,
2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 2, 1, 2, 2, 2, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 3, 3,
2, 2, 2, 2, 2, 3, 3, 2, 3, 3, 3, 3, 3, 3, 2, 2, 3, 3, 2, 3, 3, 3, 3, 3, 2, 3, 2,
3, 3, 3, 3, 3, 3, 4, 3, 3, 4, 2, 3, 3, 3, 3, 3, 3, 4, 3, 2, 4, 3, 3, 3, 3, 3, 3,
3, 3, 4, 4, 3, 4, 4, 4, 3, 4, 4, 4, 3, 4, 4, 4, 3, 3, 4, 3, 3, 3, 3, 3, 4, 3, 4,
3, 3, 3, 4, 3, 3, 4, 4, 3, 4, 4, 3, 4, 3, 3, 4, 4, 3, 3, 4, 4, 3, 4, 4, 4, 4, 4,
5, 4, 4, 4, 4, 4, 4, 4, 3, 3, 4, 3, 3, 3, 3, 3, 4, 4, 4, 4, 3, 3, 4, 4, 4, 3, 4,
4, 3, 4, 3, 4, 3, 4, 4, 4, 3, 4, 3, 4, 3, 3, 3, 3, 4, 3, 3, 3, 3, 3, 5, 4, 3, 3,
1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 8, 13, 17, 19, 21, 23, 24, 25, 25, 25, 22, 20, 18,
18, 17, 16, 14, 14, 14, 12, 12, 12, 11, 10, 10, 10, 9, 8, 9, 9, 8, 8, 8, 6, 5,
5, 4, 4, 4, 5, 3, 4, 0, -7, -10, -13, -15, -16, -17, -19, -19, -18, -14, -12,
-11, -10, -8, -8, -7, -7, -6, -5, -5, -4, -4, -3, -3, -3, -4, -2, -3, 4, 17, 22,
29, 31, 36, 40, 45, 48, 51, 54, 57, 60, 62, 65, 68, 69, 72, 73, 76, 79, 80, 82,
84, 86, 87, 89, 90, 92, 93, 95, 95, 97, 97, 99, 100, 102, 102, 102, 104, 105,
106, 107, 106, 106, 107, 107, 108, 109, 109, 109, 110, 108, 110, 100, 88, 84,
78, 74, 69, 66, 61, 59, 56, 53, 50, 47, 45, 42, 40, 38, 36, 34, 32, 31, 30, 28,
27, 25, 24, 23, 23, 21, 21, 20, 20, 18, 19, 19, 19, 15, 0, -9, -14, -20, -26,
-30, -34, -39, -43, -46, -49, -53, -55, -59, -62, -65, -66, -70, -72, -75, -77,
-79, -82, -83, -86, -88, -90, -92, -93, -94, -96, -98, -99, -101, -103, -104,
-106, -107, -107, -108, -109, -111, -111, -112, -113, -114, -115, -115, -117,
-117, -117, -117, -118, -118, -119, -118, -120, -119, -120, -116, -103, -97,
-91, -86, -81, -77, -73, -70, -66, -64, -61, -58, -55, -51, -49, -47, -45, -42,
-40, -37, -35, -34, -32, -29, -28, -26, -24, -23, -22, -20, -18, -17, -15, -15,
-13, -11, -11, -10, -9, -8, -7, -6, -5, -3, -3, -3, -2, -1, -1, -1, 0, };