#define DATA_LENGTH 512
#define DATA AKWF_1047

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 5, 6, 7, 9, 10, 11, 12,
13, 15, 16, 18, 18, 20, 21, 23, 23, 25, 26, 27, 28, 30, 30, 32, 34, 35, 35, 37,
38, 39, 41, 42, 43, 45, 45, 46, 47, 49, 50, 51, 52, 53, 55, 56, 57, 59, 60, 61,
61, 62, 65, 65, 67, 68, 69, 70, 71, 73, 73, 75, 76, 77, 80, 80, 82, 82, 83, 85,
86, 88, 88, 90, 90, 91, 93, 94, 95, 96, 97, 99, 101, 102, 102, 100, 99, 98, 96,
94, 94, 92, 91, 91, 89, 87, 86, 85, 83, 82, 81, 79, 78, 76, 76, 74, 73, 72, 70,
70, 67, 67, 65, 64, 63, 61, 61, 59, 58, 56, 55, 54, 53, 51, 50, 49, 48, 46, 46,
43, 42, 41, 40, 39, 38, 35, 34, 33, 32, 31, 30, 27, 26, 26, 24, 23, 21, 21, 19,
18, 16, 15, 13, 13, 11, 10, 9, 7, 6, 5, 3, 2, 1, -1, -1, -3, -4, -4, -3, -2, 0,
1, 3, 4, 4, 7, 7, 9, 10, 11, 12, 14, 14, 15, 18, 18, 19, 21, 21, 23, 24, 26, 27,
28, 29, 30, 31, 32, 34, 35, 36, 37, 38, 39, 41, 42, 44, 45, 45, 47, 48, 50, 51,
51, 53, 54, 56, 57, 59, 59, 60, 61, 63, 64, 65, 66, 67, 69, 70, 70, 72, 73, 75,
75, 77, 79, 79, 81, 82, 83, 85, 85, 87, 88, 88, 90, 91, 92, 94, 95, 95, 97, 99,
100, 99, 94, 90, 87, 82, 79, 74, 71, 67, 63, 59, 55, 51, 47, 43, 39, 36, 32, 27,
24, 20, 16, 11, 8, 4, 0, -4, -9, -12, -15, -19, -24, -27, -32, -36, -40, -44,
-46, -51, -55, -64, -66, -64, -63, -61, -60, -58, -57, -56, -56, -54, -52, -52,
-50, -49, -47, -46, -45, -44, -43, -42, -40, -38, -38, -37, -35, -34, -33, -31,
-30, -29, -28, -27, -26, -25, -24, -22, -20, -20, -18, -17, -18, -20, -21, -22,
-23, -25, -26, -27, -28, -29, -30, -33, -33, -34, -35, -35, -37, -39, -39, -41,
-42, -43, -44, -46, -46, -48, -49, -51, -51, -52, -54, -54, -57, -57, -58, -59,
-60, -62, -63, -64, -65, -66, -67, -68, -69, -71, -71, -73, -74, -76, -77, -77,
-80, -81, -80, -82, -84, -84, -86, -86, -87, -89, -90, -91, -93, -94, -94, -97,
-97, -98, -100, -100, -102, -103, -105, -106, -107, -107, -108, -111, -110,
-112, -113, -114, -116, -117, -118, -119, -118, -117, -116, -114, -113, -112,
-111, -109, -108, -106, -106, -104, -104, -102, -101, -100, -99, -97, -96, -95,
-93, -92, -92, -90, -88, -88, -86, -85, -84, -83, -82, -80, -79, -78, -77, -76,
-74, -72, -72, -70, -69, -68, -66, -66, -65, -63, -63, -60, -59, -58, -58, -56,
-55, -54, -51, -51, -49, -49, -48, -46, -45, -43, -42, -42, -41, -39, -38, -36,
-35, -34, -33, -32, -30, -29, -27, -27, -25, -25, -24, -23, -21, -21, -15, -4,
-5, -3, -2, 0, };