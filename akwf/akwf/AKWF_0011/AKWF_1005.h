#define DATA_LENGTH 512
#define DATA AKWF_1005

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 2, 0, 2, 1, 2, 0, 2, 0, 2, 0,
2, 0, 1, 1, 2, 0, 2, 1, 1, 1, 1, 3, 0, 3, 0, 5, -4, 8, -13, 61, 127, 111, 124,
116, 121, 118, 119, 118, 119, 119, 119, 120, 119, 119, 118, 119, 118, 119, 119,
120, 118, 120, 118, 119, 118, 119, 118, 120, 118, 119, 119, 118, 118, 119, 119,
118, 119, 118, 119, 119, 120, 118, 119, 119, 118, 118, 118, 118, 119, 118, 118,
118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118,
118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 117, 118, 118, 117, 118, 118,
117, 118, 117, 117, 117, 118, 118, 117, 118, 118, 117, 118, 118, 118, 117, 118,
117, 118, 117, 117, 118, 117, 118, 118, 118, 117, 118, 117, 117, 117, 117, 117,
118, 118, 117, 118, 118, 116, 117, 118, 117, 118, 117, 118, 118, 117, 117, 117,
117, 117, 118, 117, 117, 118, 116, 118, 116, 118, 117, 118, 117, 118, 116, 118,
116, 118, 116, 118, 116, 118, 116, 117, 117, 115, 122, 17, -9, 4, -5, 2, -4, 2,
-4, 1, -3, 1, -3, 0, -2, 0, -2, 0, 0, -2, -1, -2, 0, -3, 1, -3, 2, -4, 2, -5, 4,
-9, 12, -49, -123, -103, -115, -105, -114, -106, -114, -105, -114, -105, -115,
-102, -119, -98, -128, -57, 127, 109, 123, 114, 120, 116, 118, 117, 118, 117,
118, 116, 118, 116, 120, 111, 0, -1, -1, -3, 0, -2, 0, -3, 0, -3, 0, -3, 1, -2,
0, -3, 0, -3, 0, -3, 0, -2, 0, -1, -1, -1, -3, -1, -4, 3, -8, 12, -75, -128,
-113, -124, -115, -122, -117, -121, -117, -121, -118, -119, -118, -119, -119,
-119, -120, -118, -120, -119, -119, -119, -119, -119, -119, -118, -120, -118,
-120, -119, -119, -118, -119, -118, -119, -118, -119, -119, -118, -119, -118,
-119, -119, -118, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -118, -118, -119, -118, -118, -118, -118, -119, -119,
-119, -119, -118, -118, -118, -119, -118, -118, -119, -118, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -119, -117, -119, -118, -119, -118, -118,
-117, -118, -118, -117, -118, -117, -118, -117, -118, -117, -118, -118, -117,
-118, -117, -117, -118, -118, -118, -118, -117, -117, -118, -117, -118, -117,
-117, -118, -117, -118, -118, -117, -117, -118, -117, -118, -117, -118, -117,
-118, -117, -117, -117, -118, -117, -117, -117, -117, -117, -117, -118, -116,
-118, -116, -118, -116, -118, -115, -119, -115, -119, -115, -119, -115, -119,
-114, -7, 5, -3, 4, -2, 4, -2, 3, -1, 3, -1, 2, -1, 3, 0, 2, 0, 1, 1, 0, 2, 1,
2, 0, 3, -1, 3, -2, 4, -4, 9, -13, 62, 122, 102, 114, 104, 114, 105, 114, 105,
114, 104, 115, 102, 119, 95, 127, 32, -128, -105, -125, -112, -122, -114, -120,
-115, -120, -115, -119, -115, -120, -114, -124, -101, };