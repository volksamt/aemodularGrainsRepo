#define DATA_LENGTH 512
#define DATA AKWF_1033

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 9, 11, 13, 14, 16, 18, 19,
21, 22, 23, 24, 25, 25, 26, 27, 27, 27, 28, 28, 28, 28, 30, 29, 29, 29, 30, 30,
30, 29, 29, 29, 30, 30, 30, 30, 30, 29, 30, 30, 29, 29, 43, 64, 66, 62, 58, 58,
61, 65, 69, 75, 79, 80, 81, 79, 66, 52, 50, 51, 48, 55, 72, 76, 69, 63, 61, 62,
68, 75, 83, 92, 98, 105, 108, 109, 106, 101, 95, 89, 83, 77, 69, 60, 51, 42, 34,
24, 14, 7, -1, -9, -14, -20, -25, -29, -34, -37, -39, -42, -45, -47, -48, -49,
-51, -51, -53, -53, -54, -54, -64, -69, -64, -59, -57, -54, -54, -54, -52, -50,
-47, -43, -39, -34, -29, -24, -19, -14, -8, -4, 1, 4, 6, 10, 13, 15, 16, 18, 21,
21, 23, 24, 25, 26, 26, 26, 27, 28, 28, 28, 29, 29, 30, 29, 30, 29, 30, 29, 29,
29, 30, 29, 29, 29, 29, 29, 30, 28, 29, 27, 31, 17, -33, -56, -52, -45, -43,
-49, -61, -74, -88, -100, -110, -116, -119, -118, -117, -113, -108, -102, -97,
-91, -84, -80, -75, -68, -35, -8, -10, -15, -17, -14, -6, 1, 9, 18, 21, 24, 24,
21, 18, 12, 6, 1, -5, -11, -17, -22, -26, -31, -33, -37, -39, -42, -44, -45,
-47, -48, -49, -51, -51, -53, -53, -53, -54, -55, -55, -54, -56, -56, -56, -56,
-56, -56, -57, -57, -56, -56, -57, -57, -53, -51, -48, -45, -43, -40, -37, -33,
-29, -25, -21, -17, -12, -7, -3, 1, 5, 8, 12, 13, 16, 18, 20, 22, 23, 25, 26,
27, 29, 29, 30, 30, 31, 31, 33, 32, 33, 33, 33, 33, 34, 34, 34, 34, 34, 34, 34,
34, 34, 34, 34, 34, 34, 34, 34, 34, 33, 33, 33, 34, 34, 33, 33, 33, 33, 33, 32,
32, 33, 31, 33, 32, 31, 31, 31, 31, 31, 31, 31, 30, 30, 30, 30, 30, 30, 30, 29,
28, 27, 26, 25, 25, 24, 22, 21, 20, 18, 16, 15, 13, 13, 11, 10, 9, 9, 8, 6, 6,
5, 4, 3, 2, 2, 3, 2, 1, 2, 1, 1, 1, 0, 0, -1, -1, 0, -1, -1, -1, -1, -1, -1, -2,
-2, -2, -1, -2, -1, -2, -1, -1, -2, -1, -1, -1, -2, -2, -2, -1, -1, -1, -2, -2,
-2, -2, -2, -3, -5, -4, -6, -7, -8, -8, -10, -10, -12, -13, -14, -16, -17, -18,
-19, -20, -20, -21, -23, -22, -23, -23, -24, -24, -25, -25, -25, -25, -25, -25,
-25, -25, -26, -26, -25, -26, -25, -25, -25, -25, -26, -25, -25, -26, -26, -25,
-25, -25, -24, -25, -25, -25, -24, -24, -24, -24, -24, -24, -24, -24, -24, -24,
-23, -23, -24, -23, -22, -22, -23, -23, -23, -23, -22, -23, -23, -22, -22, -23,
-22, -22, -22, -21, -22, -22, -21, -22, -21, -22, -20, -21, -21, -21, -21, -20,
-18, -17, -15, -13, -12, -10, -8, -7, -4, -1, };