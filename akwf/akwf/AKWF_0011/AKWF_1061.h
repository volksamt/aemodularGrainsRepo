#define DATA_LENGTH 512
#define DATA AKWF_1061

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 11, 15, 23, 31, 35, 36, 39, 40, 39,
40, 43, 46, 49, 52, 57, 60, 62, 63, 64, 65, 64, 66, 67, 69, 70, 72, 74, 75, 76,
76, 76, 77, 77, 78, 78, 80, 81, 82, 83, 83, 84, 84, 85, 86, 87, 88, 89, 91, 91,
92, 94, 95, 96, 97, 98, 98, 100, 102, 103, 104, 106, 107, 108, 109, 110, 111,
112, 113, 113, 114, 115, 116, 117, 117, 118, 118, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 118, 114, 103, 91, 86, 89, 89, 88, 89, 89, 86, 82, 79, 76,
72, 69, 68, 68, 65, 67, 66, 65, 64, 62, 61, 59, 56, 56, 56, 55, 54, 55, 56, 54,
54, 53, 52, 53, 52, 52, 52, 52, 52, 52, 52, 52, 52, 51, 52, 50, 50, 49, 49, 49,
50, 48, 48, 47, 45, 45, 44, 44, 43, 41, 41, 40, 39, 38, 36, 36, 34, 32, 31, 30,
29, 28, 26, 25, 24, 23, 22, 22, 20, 19, 18, 18, 16, 16, 15, 15, 15, 13, 13, 13,
12, 12, 11, 11, 11, 11, 10, 10, 10, 10, 10, 10, 9, 10, 10, 9, 9, 9, 8, 9, 9, 10,
9, 8, 7, 7, 7, 6, 6, 6, 6, 4, 4, 3, 3, 2, 1, 1, 0, 0, -2, -3, -3, -4, -5, -6,
-6, -7, -8, -9, -9, -11, -11, -12, -13, -13, -13, -15, -14, -15, -16, -16, -17,
-16, -18, -18, -18, -19, -19, -20, -20, -20, -19, -19, -19, -20, -19, -20, -21,
-19, -20, -20, -20, -20, -20, -21, -20, -21, -22, -21, -22, -22, -22, -23, -23,
-23, -24, -24, -25, -24, -25, -26, -26, -26, -27, -28, -28, -28, -30, -30, -31,
-31, -32, -32, -34, -34, -33, -34, -35, -35, -36, -37, -36, -36, -38, -37, -38,
-39, -38, -39, -39, -40, -39, -40, -40, -40, -40, -40, -40, -40, -41, -42, -41,
-42, -42, -41, -41, -41, -41, -42, -42, -41, -42, -42, -42, -43, -43, -43, -42,
-43, -43, -43, -44, -44, -44, -45, -45, -45, -45, -45, -46, -47, -47, -46, -48,
-48, -48, -49, -49, -49, -50, -50, -50, -51, -52, -51, -52, -52, -53, -53, -53,
-54, -53, -54, -53, -54, -53, -53, -54, -54, -54, -55, -55, -55, -55, -54, -55,
-54, -54, -55, -55, -55, -55, -55, -55, -55, -55, -55, -55, -56, -56, -56, -55,
-55, -56, -56, -56, -57, -57, -56, -57, -56, -58, -57, -58, -57, -58, -58, -58,
-59, -59, -59, -59, -60, -60, -60, -60, -60, -59, -60, -61, -61, -61, -61, -61,
-62, -61, -61, -62, -61, -62, -62, -61, -62, -61, -62, -63, -61, -62, -62, -62,
-61, -63, -62, -62, -62, -62, -62, -61, -62, -61, -62, -61, -62, -61, -62, -61,
-61, -62, -62, -62, -61, -62, -62, -62, -62, -62, -62, -62, -62, -62, -62, -62,
-62, -62, -63, -62, -62, -63, -62, -63, -63, -64, -63, -63, -63, -63, -63, -63,
-63, -64, -62, -46, -16, 5, 5, 0, 1, -1, -5, -3, };