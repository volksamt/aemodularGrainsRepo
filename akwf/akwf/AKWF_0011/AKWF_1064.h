#define DATA_LENGTH 512
#define DATA AKWF_1064

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, -1, 0, 0, 1, 1, 0, 1, 1, 1, 2,
2, 3, 3, 3, 4, 5, 5, 6, 6, 7, 9, 9, 9, 11, 12, 13, 14, 15, 16, 18, 19, 21, 23,
24, 25, 26, 28, 30, 32, 33, 35, 38, 39, 41, 43, 45, 46, 48, 49, 53, 54, 56, 58,
59, 63, 64, 66, 68, 70, 72, 74, 76, 78, 80, 82, 84, 86, 88, 89, 91, 93, 95, 96,
98, 100, 101, 102, 104, 105, 106, 107, 109, 110, 111, 112, 114, 114, 115, 115,
116, 117, 117, 118, 118, 118, 119, 119, 119, 119, 118, 120, 119, 118, 118, 119,
119, 118, 119, 118, 118, 118, 117, 117, 116, 115, 115, 115, 115, 114, 113, 112,
111, 111, 109, 109, 108, 107, 105, 104, 103, 102, 100, 100, 98, 96, 95, 93, 92,
90, 88, 87, 85, 83, 81, 79, 78, 75, 74, 72, 70, 68, 66, 64, 62, 60, 58, 56, 54,
52, 50, 48, 46, 43, 41, 40, 38, 36, 34, 33, 30, 29, 26, 26, 23, 22, 20, 19, 17,
16, 14, 13, 12, 11, 9, 8, 8, 6, 5, 5, 3, 3, 3, 1, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0,
-1, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 1, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0,
-1, 0, 0, -1, 0, 1, 0, 0, 0, -1, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, -1, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, -1, -3, -3, -3, -3, -5, -4, -5, -6, -7,
-8, -8, -9, -10, -12, -12, -13, -15, -16, -17, -19, -19, -21, -23, -24, -26,
-27, -29, -30, -32, -33, -35, -37, -40, -41, -42, -44, -46, -49, -50, -52, -55,
-57, -58, -61, -62, -64, -67, -68, -71, -73, -74, -76, -78, -80, -81, -84, -86,
-87, -89, -91, -93, -94, -97, -97, -100, -102, -103, -104, -105, -108, -107,
-109, -109, -112, -112, -114, -114, -115, -116, -116, -117, -117, -117, -119,
-118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -118,
-118, -118, -118, -117, -117, -117, -116, -116, -116, -115, -114, -113, -112,
-112, -111, -111, -110, -108, -107, -106, -105, -104, -103, -102, -101, -99,
-98, -96, -94, -93, -91, -89, -88, -87, -85, -82, -82, -80, -78, -75, -74, -72,
-70, -68, -66, -63, -62, -60, -58, -56, -53, -52, -49, -47, -46, -43, -42, -39,
-38, -36, -34, -32, -31, -29, -28, -25, -23, -23, -20, -19, -17, -16, -15, -13,
-11, -11, -10, -8, -8, -7, -5, -5, -3, -4, -3, -2, -1, -1, 0, -1, 0, -1, 0, -1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, -1, -1, 0, 0,
1, 0, 0, 1, 0, 0, 0, 1, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0,
};