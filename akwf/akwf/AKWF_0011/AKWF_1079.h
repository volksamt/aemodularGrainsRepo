#define DATA_LENGTH 512
#define DATA AKWF_1079

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 14, 20, 24, 31, 35, 42, 47, 52,
59, 64, 70, 74, 84, 92, 87, 86, 83, 82, 78, 77, 73, 72, 69, 67, 65, 62, 61, 58,
57, 51, 57, 16, -6, 0, -6, -4, -8, -7, -9, -10, -9, -15, 1, 11, 3, 2, -3, -6,
-10, -13, -16, -19, -22, -25, -26, -28, -29, -30, -31, -32, -35, -7, 3, -1, 2,
0, 2, 1, 3, 2, 4, 2, 4, 3, 4, 4, 4, 4, 5, 6, 6, 7, 6, 7, 6, 7, 7, 8, 9, 8, 10,
7, 12, 1, -7, 1, -2, -1, -2, -3, -3, -5, -4, -5, -2, 6, 4, 3, 3, 1, 1, -1, -1,
-2, -3, -4, -4, -6, -6, -7, -8, -8, -9, -9, -12, -11, -14, -9, 1, 1, 2, 2, 2, 4,
3, 5, 5, 6, 6, 7, 7, 8, 8, -6, -8, -5, -5, -2, -2, 0, 0, 1, 2, 3, 4, 6, 6, 8, 8,
10, 1, 0, 0, -1, -1, -1, -1, -2, -2, -4, -2, -3, -3, -4, -4, -4, -4, -5, -4, -6,
-2, 1, 1, -1, -2, -4, -6, -6, -9, -10, -13, -12, -16, -5, 7, 6, -8, -8, -5, -4,
-3, -1, 1, 2, 6, 6, 8, 9, 12, 12, 15, 15, 19, 18, 24, 13, -5, -3, -7, -8, -11,
-12, -14, -14, -19, -18, -22, -22, -25, -26, -30, -29, -34, -33, -38, -37, -42,
-40, -45, -45, -49, -47, 43, 45, 36, 34, 26, 23, 15, 13, 5, 2, -5, -9, -11, 2,
0, 3, 2, 3, 4, 5, 5, 6, 6, 7, 8, 9, 9, 10, 10, 11, 11, 13, 13, 14, 13, 17, 7,
-17, -11, -11, -6, -4, -1, 1, 3, 6, 0, -1, -1, -1, -1, -1, -2, -2, -3, -2, -4,
-3, -3, -3, -4, -4, -5, -4, -5, -4, -5, -6, -6, -5, -8, -1, 7, 4, 4, 3, 3, 2, 0,
0, -1, -2, -3, -4, -4, -9, -2, 3, 2, 3, 4, -1, -4, -1, -2, 0, 0, 2, 2, 4, 4, 6,
7, 7, 10, 9, 11, 11, 13, 13, 15, 12, -2, 0, -3, -2, -3, -5, -5, -6, -7, -7, -7,
-8, -8, -10, -9, -12, -10, -15, -1, 16, 9, 11, 7, 6, 5, 4, 2, 1, -1, -2, -3, -5,
-5, -7, -9, -11, -12, -13, -15, -26, -26, -25, -24, -24, -23, -23, -22, -21,
-21, -21, -20, -18, -19, -17, -18, -2, 2, 1, 2, 2, 2, 3, 4, 5, 1, -5, -2, -2, 0,
0, 2, 2, 4, 5, 7, 8, 9, 10, 11, 12, 12, 13, 13, 15, 15, 15, 16, 16, 17, 17, 19,
17, 21, 11, -6, -7, 5, 6, 0, -1, -7, -9, -14, -17, -22, -24, -29, -32, -37, -40,
-43, -48, -51, -56, -58, -63, -65, -71, -72, -79, -80, -86, -88, -94, -94, -100,
-102, -109, -111, -114, -121, -14, 12, 1, 14, 7, 17, 12, 21, 18, 25, 23, 29, 28,
33, 33, 35, 43, -25, -40, -25, -26, -16, -14, -5, -3, };