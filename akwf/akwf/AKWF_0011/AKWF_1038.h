#define DATA_LENGTH 512
#define DATA AKWF_1038

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 8, 11, 15, 20, 23, 27, 31, 35,
38, 42, 46, 49, 52, 56, 60, 63, 67, 70, 73, 76, 80, 82, 86, 88, 92, 94, 96, 98,
101, 102, 105, 107, 109, 111, 112, 113, 114, 116, 116, 117, 118, 118, 118, 120,
118, 119, 117, 116, 114, 112, 109, 107, 105, 101, 98, 93, 90, 86, 81, 77, 72,
69, 65, 59, 54, 49, 44, 40, 34, 30, 25, 19, 14, 9, 4, -1, -6, -10, -15, -19,
-24, -28, -32, -35, -39, -42, -46, -49, -53, -56, -58, -61, -63, -66, -67, -68,
-70, -71, -71, -73, -72, -72, -72, -73, -72, -71, -71, -71, -69, -68, -68, -67,
-65, -64, -62, -61, -60, -59, -57, -56, -54, -53, -51, -49, -47, -47, -44, -43,
-41, -39, -37, -35, -34, -32, -30, -28, -26, -24, -23, -22, -20, -17, -17, -14,
-13, -11, -10, -9, -7, -5, -5, -3, -2, -1, 1, 2, 4, 4, 5, 6, 7, 7, 8, 10, 10,
10, 10, 10, 11, 12, 13, 13, 13, 13, 13, 12, 11, 11, 10, 8, 8, 6, 5, 5, 2, 0, -1,
-2, -5, -6, -8, -9, -11, -12, -15, -17, -19, -22, -22, -24, -26, -29, -31, -32,
-34, -35, -39, -39, -41, -43, -45, -47, -48, -49, -50, -52, -53, -54, -54, -57,
-57, -57, -58, -58, -59, -59, -60, -61, -61, -61, -60, -59, -59, -58, -56, -54,
-53, -51, -48, -46, -44, -42, -38, -36, -33, -30, -27, -24, -20, -17, -14, -11,
-7, -2, 1, 4, 9, 12, 15, 19, 24, 27, 31, 34, 38, 42, 46, 49, 53, 57, 60, 64, 68,
70, 74, 76, 79, 82, 86, 89, 92, 94, 96, 99, 101, 103, 105, 106, 109, 110, 112,
113, 114, 116, 117, 117, 118, 118, 119, 118, 119, 119, 117, 116, 114, 113, 110,
107, 104, 100, 97, 93, 89, 85, 81, 77, 72, 68, 64, 58, 53, 49, 44, 38, 33, 28,
24, 19, 14, 9, 4, -1, -6, -10, -15, -19, -24, -28, -32, -35, -39, -43, -47, -50,
-54, -56, -59, -61, -63, -65, -66, -68, -70, -71, -73, -72, -72, -74, -72, -73,
-72, -71, -71, -69, -69, -69, -67, -65, -65, -64, -62, -62, -60, -58, -58, -56,
-55, -52, -51, -49, -47, -46, -45, -43, -40, -39, -37, -35, -34, -32, -30, -28,
-27, -24, -23, -21, -20, -19, -16, -14, -13, -11, -10, -8, -7, -6, -4, -3, -1,
0, 1, 2, 4, 5, 6, 6, 6, 7, 8, 9, 9, 10, 12, 11, 12, 12, 12, 12, 13, 13, 12, 12,
12, 10, 10, 9, 7, 6, 4, 3, 3, 1, -1, -3, -5, -6, -8, -9, -11, -14, -15, -17,
-19, -21, -24, -25, -28, -29, -31, -33, -35, -36, -38, -40, -41, -43, -45, -45,
-48, -49, -51, -52, -53, -54, -55, -56, -58, -58, -58, -59, -60, -60, -60, -60,
-60, -60, -61, -59, -60, -58, -56, -55, -54, -51, -49, -46, -43, -41, -39, -36,
-33, -30, -27, -22, -20, -16, -14, -10, -6, -3, };