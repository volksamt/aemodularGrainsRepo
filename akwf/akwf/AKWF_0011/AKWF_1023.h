#define DATA_LENGTH 512
#define DATA AKWF_1023

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 4, 6, 8, 9, 11, 13, 14, 16,
17, 18, 20, 22, 24, 26, 28, 29, 31, 33, 35, 37, 39, 40, 43, 43, 46, 47, 49, 51,
52, 54, 56, 57, 58, 60, 62, 63, 65, 66, 67, 67, 69, 70, 71, 72, 73, 74, 76, 77,
78, 78, 79, 80, 81, 82, 82, 84, 84, 84, 85, 86, 86, 87, 87, 88, 89, 88, 89, 90,
89, 91, 91, 93, 92, 93, 93, 94, 94, 94, 94, 95, 95, 96, 97, 96, 97, 98, 98, 100,
100, 100, 102, 102, 102, 103, 104, 105, 105, 106, 106, 108, 108, 109, 109, 111,
111, 112, 113, 114, 114, 116, 115, 117, 116, 117, 118, 118, 117, 119, 118, 119,
119, 120, 119, 119, 118, 118, 118, 118, 118, 118, 117, 116, 116, 115, 115, 115,
114, 113, 113, 112, 112, 110, 110, 108, 108, 108, 106, 105, 105, 103, 103, 102,
101, 100, 99, 98, 97, 96, 95, 94, 93, 92, 91, 90, 89, 88, 87, 86, 85, 84, 83,
82, 81, 80, 80, 78, 78, 77, 75, 73, 74, 72, 71, 71, 70, 68, 67, 66, 65, 64, 63,
61, 61, 60, 58, 57, 56, 55, 54, 53, 52, 51, 50, 49, 47, 47, 45, 45, 43, 43, 41,
40, 39, 38, 37, 36, 35, 34, 33, 32, 31, 29, 29, 28, 28, 26, 25, 24, 23, 23, 22,
20, 20, 19, 18, 17, 16, 16, 15, 14, 13, 12, 12, 10, 9, 8, 7, 6, 5, 4, 3, 1, 0,
0, -2, -3, -5, -6, -7, -9, -11, -12, -13, -16, -17, -20, -21, -23, -25, -26,
-27, -30, -32, -33, -36, -37, -40, -40, -42, -44, -45, -47, -49, -51, -53, -54,
-56, -58, -59, -60, -61, -64, -65, -65, -68, -68, -70, -70, -71, -72, -73, -75,
-76, -77, -78, -78, -80, -80, -80, -82, -83, -84, -83, -84, -85, -86, -87, -87,
-87, -88, -89, -89, -89, -90, -91, -91, -91, -92, -92, -92, -93, -93, -93, -95,
-95, -96, -95, -97, -96, -97, -98, -98, -99, -100, -100, -100, -101, -102, -102,
-103, -103, -104, -105, -106, -107, -107, -108, -109, -110, -111, -112, -112,
-113, -114, -114, -114, -115, -116, -116, -117, -117, -118, -118, -118, -119,
-119, -119, -119, -119, -119, -120, -118, -118, -119, -118, -117, -118, -117,
-116, -116, -115, -115, -115, -114, -112, -112, -111, -110, -110, -109, -108,
-106, -106, -104, -104, -104, -102, -100, -100, -100, -99, -97, -97, -95, -95,
-94, -93, -92, -91, -89, -89, -88, -87, -85, -85, -83, -83, -82, -81, -80, -79,
-78, -77, -76, -75, -74, -73, -72, -71, -70, -70, -69, -68, -66, -64, -64, -63,
-61, -61, -60, -58, -57, -56, -56, -54, -53, -51, -51, -50, -49, -48, -47, -46,
-45, -42, -43, -41, -40, -39, -38, -37, -35, -34, -33, -33, -31, -31, -29, -29,
-27, -26, -26, -25, -24, -23, -22, -22, -21, -19, -19, -18, -17, -16, -15, -14,
-14, -13, -12, -11, -10, -9, -8, -8, -6, -5, -4, -3, -2, 0, };