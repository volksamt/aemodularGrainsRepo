#define DATA_LENGTH 512
#define DATA AKWF_1011

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 0, 3, -3, 22, 41, 44, 53, 58, 67,
72, 79, 86, 94, 100, 107, 113, 115, 114, 114, 113, 113, 111, 111, 110, 110, 109,
109, 108, 107, 107, 105, 106, 105, 104, 104, 102, 102, 102, 101, 100, 100, 99,
99, 97, 97, 97, 96, 95, 94, 93, 93, 92, 91, 92, 90, 89, 88, 87, 87, 86, 86, 84,
84, 83, 82, 82, 81, 81, 79, 78, 79, 78, 76, 75, 74, 74, 72, 73, 71, 71, 70, 70,
68, 67, 67, 66, 66, 65, 65, 63, 63, 61, 61, 60, 59, 58, 58, 57, 56, 56, 55, 55,
53, 52, 52, 51, 50, 50, 49, 48, 47, 46, 46, 44, 45, 43, 43, 41, 42, 40, 40, 37,
39, 36, 37, 34, 37, 30, -2, 2, -2, 24, 37, 33, 37, 35, 38, 37, 40, 38, 41, 40,
42, 42, 44, 44, 45, 46, 47, 47, 48, 49, 49, 50, 50, 52, 52, 53, 53, 55, 55, 57,
57, 58, 57, 59, 60, 61, 61, 63, 63, 63, 64, 65, 66, 67, 67, 68, 69, 70, 70, 71,
72, 73, 74, 75, 75, 76, 76, 77, 78, 79, 79, 80, 81, 82, 82, 82, 85, 85, 85, 86,
87, 88, 89, 89, 91, 91, 91, 93, 93, 94, 95, 95, 96, 96, 97, 99, 99, 101, 101,
102, 103, 102, 104, 104, 105, 106, 107, 108, 108, 109, 109, 110, 111, 112, 112,
113, 114, 115, 116, 116, 118, 118, 110, 104, 98, 90, 85, 77, 71, 64, 58, 49, 47,
30, -3, -1, 1, -26, -37, -34, -37, -37, -39, -39, -40, -40, -41, -41, -43, -43,
-45, -45, -46, -46, -47, -48, -49, -50, -51, -51, -52, -53, -54, -54, -55, -56,
-57, -57, -58, -58, -59, -60, -61, -62, -63, -63, -65, -65, -66, -67, -67, -68,
-69, -70, -70, -71, -72, -72, -73, -74, -76, -76, -76, -77, -79, -79, -80, -80,
-81, -82, -82, -84, -84, -84, -86, -86, -88, -88, -89, -90, -91, -91, -92, -92,
-93, -94, -95, -96, -96, -98, -98, -99, -99, -100, -101, -102, -102, -103, -103,
-104, -105, -107, -106, -107, -109, -110, -110, -111, -110, -113, -113, -114,
-114, -115, -116, -117, -117, -118, -118, -113, -106, -101, -94, -88, -83, -75,
-70, -62, -58, -48, -47, -29, 1, 2, -22, -42, -44, -54, -60, -69, -74, -83, -89,
-96, -104, -109, -117, -118, -117, -116, -117, -115, -114, -113, -113, -111,
-111, -110, -110, -109, -108, -107, -107, -106, -105, -105, -104, -103, -102,
-101, -101, -99, -99, -98, -98, -96, -96, -96, -94, -94, -93, -92, -91, -90,
-90, -88, -87, -87, -86, -85, -86, -84, -84, -82, -82, -81, -81, -79, -79, -77,
-78, -76, -76, -74, -74, -73, -73, -72, -71, -70, -70, -69, -68, -67, -66, -66,
-65, -64, -63, -62, -62, -61, -61, -60, -59, -58, -58, -56, -56, -54, -54, -54,
-53, -51, -51, -51, -50, -49, -48, -47, -47, -46, -46, -44, -44, -43, -41, -41,
-40, -40, -38, -39, -36, -38, -34, -36, -33, -36, -29, };