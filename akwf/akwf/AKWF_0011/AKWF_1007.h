#define DATA_LENGTH 512
#define DATA AKWF_1007

const PROGMEM int8_t DATA[DATA_LENGTH] = {90, 107, 100, 105, 100, 105, 101, 104,
101, 105, 101, 104, 102, 104, 102, 104, 102, 102, 103, 103, 102, 103, 104, 103,
103, 103, 104, 102, 104, 102, 103, 103, 103, 103, 103, 103, 102, 103, 103, 103,
102, 103, 102, 103, 103, 103, 102, 103, 103, 102, 103, 102, 103, 103, 103, 102,
104, 102, 104, 101, 104, 101, 104, 101, 105, 98, 111, 53, -99, -124, -118, -120,
-118, -121, -117, -120, -118, -119, -118, -120, -118, -120, -118, -119, -118,
-120, -119, -119, -118, -119, -119, -119, -119, -119, -118, -120, -119, -118,
-119, -119, -119, -119, -119, -118, -120, -118, -119, -118, -119, -117, -120,
-117, -120, -118, -120, -117, -120, -117, -120, -117, -120, -118, -119, -120,
-116, -128, -47, 0, 91, 110, 97, 108, 99, 107, 100, 106, 101, 105, 100, 104,
101, 103, 102, 104, 102, 103, 103, 103, 103, 103, 103, 101, 104, 102, 103, 102,
104, 103, 104, 103, 103, 102, 103, 103, 103, 102, 103, 103, 102, 103, 103, 103,
102, 103, 103, 103, 103, 103, 103, 102, 103, 102, 103, 102, 103, 102, 103, 102,
104, 101, 105, 101, 105, 99, 111, 46, -104, -122, -117, -120, -119, -120, -118,
-120, -119, -119, -119, -119, -118, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -118, -119, -118, -119, -119,
-119, -119, -118, -120, -118, -120, -118, -120, -117, -120, -117, -121, -117,
-121, -117, -121, -117, -120, -117, -121, -118, -120, -118, -117, -125, -43, 4,
95, 109, 98, 108, 99, 106, 99, 106, 100, 106, 100, 104, 101, 105, 103, 104, 102,
104, 103, 103, 103, 103, 103, 103, 104, 102, 103, 103, 103, 103, 103, 102, 103,
102, 103, 103, 103, 103, 103, 102, 103, 103, 103, 104, 102, 102, 103, 103, 103,
103, 102, 102, 102, 102, 103, 103, 103, 102, 103, 101, 104, 101, 104, 101, 106,
98, 112, 37, -109, -120, -119, -119, -118, -119, -118, -119, -119, -120, -119,
-119, -118, -119, -119, -120, -119, -119, -119, -120, -118, -119, -118, -119,
-118, -120, -118, -120, -119, -119, -119, -118, -118, -119, -119, -119, -119,
-119, -119, -117, -119, -118, -119, -117, -120, -117, -121, -116, -121, -116,
-122, -117, -122, -116, -121, -117, -119, -122, -40, 8, 100, 107, 99, 107, 99,
107, 100, 106, 100, 106, 100, 105, 101, 104, 102, 104, 102, 103, 103, 104, 103,
103, 103, 103, 104, 103, 102, 103, 103, 103, 103, 103, 103, 102, 103, 102, 103,
103, 103, 103, 102, 103, 102, 103, 102, 103, 103, 104, 103, 102, 103, 102, 102,
102, 102, 103, 103, 102, 103, 101, 104, 101, 104, 100, 106, 99, 111, 29, -112,
-119, -119, -119, -119, -120, -119, -120, -118, -120, -119, -119, -119, -120,
-118, -120, -118, -119, -119, -119, -119, -120, -119, -120, -118, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -118, -120, -119, -119, -119,
-120, -118, -120, -118, -120, -117, -119, -117, -120, -117, -120, -117, -120,
-118, -119, -118, -117, -124, -30, -4, };