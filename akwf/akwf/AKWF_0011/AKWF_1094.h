#define DATA_LENGTH 512
#define DATA AKWF_1094

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 1, 2, 1, 1, 2, 2, 3, 5, 5, 6,
6, 6, 6, 7, 8, 11, 22, 20, 23, 24, 24, 24, 23, 24, 24, 24, 23, 27, 25, 33, 41,
39, 40, 39, 43, 42, 43, 41, 44, 55, 54, 56, 56, 56, 56, 57, 55, 57, 58, 58, 58,
58, 59, 57, 59, 59, 63, 73, 71, 72, 72, 72, 73, 73, 73, 73, 74, 73, 74, 72, 79,
85, 85, 85, 84, 86, 85, 85, 84, 84, 85, 86, 86, 85, 95, 93, 90, 91, 91, 91, 90,
92, 92, 92, 91, 91, 91, 93, 102, 99, 101, 99, 101, 101, 100, 100, 101, 101, 100,
101, 100, 106, 109, 108, 109, 109, 109, 109, 109, 109, 109, 108, 109, 108, 109,
113, 117, 112, 120, 89, 58, 67, 62, 66, 63, 65, 63, 65, 63, 65, 64, 65, 64, 66,
71, 70, 70, 70, 70, 69, 70, 71, 71, 71, 70, 70, 71, 71, 71, 71, 72, 72, 71, 71,
72, 76, 76, 77, 76, 77, 77, 77, 76, 78, 77, 78, 78, 79, 79, 80, 83, 82, 83, 83,
82, 83, 86, 86, 86, 86, 87, 87, 87, 87, 87, 86, 88, 89, 89, 88, 89, 89, 90, 89,
89, 91, 91, 93, 94, 94, 94, 95, 95, 94, 95, 94, 94, 95, 97, 96, 97, 97, 98, 98,
99, 100, 100, 100, 103, 103, 103, 104, 103, 104, 103, 104, 103, 103, 103, 108,
105, 107, 104, 106, 105, 108, 109, 110, 110, 110, 109, 109, 112, 111, 115, 109,
112, 100, 117, 93, 127, -4, -128, -94, -119, -103, -114, -106, -112, -106, -108,
-106, -106, -107, -104, -105, -103, -104, -102, -104, -102, -104, -103, -102,
-100, -101, -100, -101, -100, -101, -97, -98, -97, -98, -97, -97, -97, -95, -96,
-95, -96, -95, -95, -94, -93, -93, -92, -92, -92, -92, -91, -90, -90, -90, -90,
-90, -88, -86, -87, -87, -87, -86, -86, -86, -86, -87, -87, -84, -85, -84, -82,
-82, -83, -83, -83, -82, -82, -82, -81, -81, -81, -80, -82, -79, -77, -76, -77,
-76, -76, -76, -76, -76, -76, -75, -75, -76, -75, -72, -71, -70, -71, -70, -70,
-70, -71, -69, -71, -69, -70, -69, -71, -69, -70, -70, -69, -65, -65, -65, -64,
-65, -64, -65, -62, -67, -60, -95, -120, -112, -117, -114, -117, -114, -116,
-114, -117, -111, -108, -109, -108, -109, -109, -108, -109, -108, -109, -109,
-109, -109, -108, -108, -109, -105, -99, -102, -99, -102, -99, -92, -92, -91,
-91, -91, -92, -91, -92, -91, -93, -97, -97, -95, -96, -96, -96, -95, -95, -94,
-94, -95, -86, -85, -86, -85, -84, -84, -84, -84, -83, -85, -84, -84, -83, -85,
-79, -71, -73, -73, -71, -73, -67, -59, -61, -59, -60, -57, -57, -57, -57, -57,
-57, -57, -57, -56, -57, -56, -55, -54, -54, -54, -55, -53, -41, -40, -40, -40,
-38, -37, -38, -36, -38, -37, -38, -36, -38, -31, -22, -22, -22, -22, -21, -22,
-22, -20, -17, -19, -18, -19, -19, -8, -3, };