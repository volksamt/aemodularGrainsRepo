#define DATA_LENGTH 512
#define DATA AKWF_1019

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 7, 11, 12, 14, 15, 16, 17, 18,
18, 22, 55, 85, 102, 114, 119, 118, 113, 106, 95, 83, 68, 56, 37, -3, -36, -61,
-81, -95, -106, -109, -114, -97, -70, -49, -31, -18, -7, 1, 7, 12, 13, 15, 14,
15, -13, -48, -71, -89, -97, -103, -102, -99, -92, -83, -73, -60, -48, -34, -23,
-11, 0, 12, 21, 28, 36, 42, 47, 51, 53, 56, 57, 60, 68, 74, 77, 77, 75, 72, 67,
60, 53, 46, 39, 31, 24, 17, 9, 3, -2, -7, -12, -16, -20, -23, -24, -25, -26,
-28, -26, -26, -25, -24, -23, -22, -20, -18, -16, -15, -13, -11, -10, -7, -6,
-4, -3, -1, -1, 1, 0, 2, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 2, 4, 3, 2, 2, 2, 2,
0, 2, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, -1, -1, -1, -1, -1, 0, -1, 0, 0,
0, 0, 0, 1, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, -1,
1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 1, 0, 1, -1, 0, 0,
0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 8,
16, 23, 26, 30, 31, 31, 29, 26, 23, 20, 16, 13, 8, 5, 1, -1, -5, -8, -10, -13,
-14, -16, -17, -17, -19, -17, -24, -60, -87, -104, -115, -118, -119, -112, -105,
-92, -82, -66, -55, -32, 7, 38, 63, 83, 96, 106, 110, 113, 94, 66, 48, 29, 17,
6, -1, -9, -12, -14, -15, -14, -14, 17, 51, 73, 90, 98, 103, 103, 99, 91, 82,
71, 59, 46, 34, 21, 9, -2, -12, -21, -30, -37, -42, -48, -52, -54, -56, -57,
-60, -68, -74, -76, -77, -75, -72, -66, -60, -53, -45, -39, -31, -23, -15, -9,
-2, 3, 9, 13, 16, 20, 22, 24, 25, 27, 27, 27, 27, 25, 24, 23, 22, 20, 17, 17,
14, 12, 10, 9, 7, 6, 4, 4, 2, 0, -1, -1, -2, -3, -3, -3, -4, -4, -4, -4, -5, -4,
-4, -4, -4, -3, -3, -2, -2, -1, -1, -1, -1, -1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 1,
0, 0, 0, 1, 0, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, -1, 0,
0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0,
1, 0, 0, 0, 0, 0, 0, 0, -8, -18, -23, -28, -30, -31, -31, -29, -26, -24, -20,
-17, -12, -9, -5, -1, };