#define DATA_LENGTH 512
#define DATA AKWF_1090

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 9, 11, 16, 19, 22, 26, 29, 33,
37, 41, 44, 48, 50, 53, 57, 60, 63, 66, 70, 71, 75, 78, 80, 83, 85, 88, 91, 93,
95, 98, 99, 100, 102, 104, 106, 108, 109, 109, 112, 112, 114, 114, 115, 116,
116, 117, 117, 117, 117, 117, 117, 117, 115, 117, 119, 117, 112, 111, 109, 106,
103, 101, 98, 95, 93, 90, 87, 83, 80, 77, 75, 72, 70, 68, 65, 66, 66, 59, 54,
53, 49, 47, 44, 42, 39, 37, 35, 32, 31, 29, 27, 24, 23, 21, 19, 18, 19, 20, 16,
12, 9, 8, 5, 3, 2, 0, -1, -2, -5, -6, -8, -10, -11, -14, -17, -19, -22, -26,
-28, -31, -34, -37, -41, -42, -45, -48, -50, -52, -53, -55, -57, -59, -60, -61,
-62, -63, -63, -64, -63, -60, -59, -59, -59, -57, -56, -55, -52, -50, -48, -47,
-44, -41, -38, -35, -33, -31, -26, -24, -21, -17, -14, -12, -9, -5, -2, 1, 4, 7,
10, 14, 17, 20, 23, 25, 28, 30, 34, 36, 40, 42, 44, 47, 49, 51, 53, 55, 58, 59,
61, 62, 64, 65, 66, 67, 69, 70, 70, 70, 71, 72, 72, 71, 71, 74, 75, 71, 69, 67,
65, 62, 59, 58, 56, 53, 50, 47, 45, 42, 40, 37, 35, 32, 31, 28, 29, 29, 25, 20,
20, 18, 14, 12, 10, 9, 7, 6, 5, 3, 1, -2, -3, -6, -8, -11, -14, -17, -21, -24,
-26, -29, -33, -36, -38, -41, -44, -45, -48, -49, -52, -54, -54, -55, -56, -57,
-58, -58, -57, -55, -54, -55, -55, -53, -52, -52, -51, -48, -48, -47, -44, -42,
-40, -39, -37, -35, -33, -31, -29, -27, -26, -25, -23, -22, -20, -18, -18, -16,
-14, -13, -11, -10, -10, -8, -7, -6, -6, -5, -4, -4, -4, -2, 1, -1, -4, -6, -7,
-10, -12, -13, -15, -17, -19, -21, -24, -26, -28, -30, -33, -34, -36, -39, -39,
-38, -38, -41, -43, -42, -44, -44, -44, -44, -44, -42, -42, -42, -41, -40, -39,
-39, -38, -38, -37, -37, -36, -37, -36, -38, -36, -37, -36, -37, -37, -37, -37,
-37, -37, -36, -36, -37, -36, -36, -35, -36, -35, -35, -36, -36, -35, -35, -35,
-35, -35, -34, -35, -34, -35, -35, -35, -35, -35, -34, -34, -33, -34, -34, -33,
-31, -29, -31, -30, -30, -29, -28, -27, -26, -25, -24, -22, -21, -19, -19, -18,
-16, -14, -14, -12, -11, -9, -7, -7, -4, -4, -2, -2, 0, 0, 2, 3, 3, 5, 5, 6, 6,
8, 8, 8, 9, 7, 9, 12, 10, 7, 5, 3, 1, -1, -3, -6, -7, -9, -12, -14, -17, -20,
-22, -25, -26, -29, -30, -32, -31, -32, -38, -40, -42, -46, -49, -50, -52, -55,
-56, -58, -59, -61, -63, -64, -65, -67, -69, -71, -71, -70, -69, -70, -72, -72,
-71, -71, -70, -67, -66, -63, -61, -58, -56, -53, -50, -46, -43, -39, -36, -32,
-30, -26, -22, -18, -15, -13, -8, -5, -1, };