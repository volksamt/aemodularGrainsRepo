#define DATA_LENGTH 512
#define DATA AKWF_1010

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 4, 5, 5, 7, 8, 8, 9, 10,
11, 12, 12, 13, 14, 15, 16, 17, 18, 19, 19, 20, 21, 22, 23, 24, 25, 25, 27, 28,
28, 29, 29, 31, 32, 32, 33, 35, 35, 36, 37, 37, 39, 39, 41, 41, 42, 43, 43, 44,
45, 46, 47, 49, 49, 50, 51, 51, 53, 54, 55, 55, 56, 56, 58, 59, 59, 60, 61, 62,
62, 65, 65, 66, 67, 68, 68, 70, 70, 71, 71, 72, 73, 74, 75, 76, 78, 78, 78, 79,
80, 81, 82, 83, 84, 85, 86, 86, 87, 87, 89, 90, 92, 87, 85, 81, 78, 75, 72, 68,
65, 62, 59, 55, 53, 49, 46, 42, 40, 35, 32, 30, 26, 23, 20, 17, 13, 9, 6, 3, 0,
-3, -6, -10, -13, -17, -19, -22, -25, -28, -32, -36, -39, -42, -46, -48, -51,
-54, -58, -62, -64, -68, -71, -74, -78, -80, -83, -88, -91, -94, -96, -100,
-103, -107, -110, -113, -117, -119, -111, -105, -97, -91, -83, -76, -69, -62,
-55, -47, -41, -33, -26, -20, -12, -6, 2, 7, 6, 7, 7, 7, 7, 7, 8, 7, 7, 7, 6, 7,
7, 7, 7, 7, 7, 8, 7, 7, 7, 7, 7, 7, 7, 8, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7,
7, 8, 7, 7, 6, 8, 7, 7, 7, 7, 7, 7, 7, 7, 7, 8, 7, 7, 7, 8, 7, 7, 7, 7, 6, 7, 7,
8, 8, 7, 7, 7, 7, 7, 8, 7, 7, 8, 7, 6, 7, 7, 8, 8, 7, 6, 7, 6, 7, 7, 6, 7, 7, 8,
7, 7, 7, 8, 7, 7, 7, 7, 6, 8, 6, 8, 8, 6, 7, 7, 7, 7, 6, 7, 7, 7, 7, 7, 8, 7, 7,
7, 8, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 6, 7, 8, 7, 7, 7,
7, 6, 7, 7, 7, 7, 7, 6, 7, 7, 7, 7, 8, 7, 7, 7, 7, 7, 7, 7, 7, 7, 6, 7, 7, 8, 7,
6, 7, 8, 7, 7, 7, 8, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 6,
6, 7, 7, 7, 7, 7, 6, 7, 7, 6, 7, 7, 6, 2, -3, -6, -11, -15, -20, -24, -28, -32,
-37, -41, -46, -51, -55, -59, -64, -67, -72, -75, -80, -85, -89, -93, -98, -102,
-106, -110, -116, -119, -114, -109, -106, -100, -96, -91, -87, -83, -78, -73,
-69, -65, -60, -56, -52, -47, -42, -37, -33, -29, -24, -20, -15, -11, -6, -2, 2,
7, -24, -47, -43, -44, -42, -42, -41, -40, -39, -39, -37, -37, -36, -35, -34,
-33, -32, -31, -30, -29, -29, -28, -27, -26, -26, -24, -23, -23, -21, -21, -20,
-18, -18, -17, -16, -16, -15, -15, -12, -12, -11, -10, -9, -9, -8, -7, -5, -5,
-4, -3, -2, -2, -1, };