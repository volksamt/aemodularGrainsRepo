#define DATA_LENGTH 512
#define DATA AKWF_1082

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 14, 18, 22, 26, 31, 36, 40,
44, 48, 53, 57, 60, 66, 69, 74, 77, 82, 86, 90, 93, 96, 99, 100, 97, 94, 92, 89,
87, 85, 82, 80, 77, 75, 73, 69, 67, 64, 62, 60, 57, 54, 51, 50, 47, 45, 43, 40,
37, 35, 32, 30, 27, 24, 22, 20, 17, 14, 12, 10, 7, 5, 2, -3, -6, -9, -12, -15,
-17, -20, -23, -25, -29, -32, -35, -37, -40, -42, -46, -48, -51, -54, -57, -60,
-62, -65, -67, -72, -73, -77, -79, -81, -85, -88, -91, -94, -96, -99, -101,
-104, -108, -110, -114, -110, -108, -104, -104, -97, -100, -89, -101, -46, 16,
0, 14, 9, 20, 15, 25, 21, 32, 16, -29, -17, -14, -5, -3, 5, 10, 17, 21, 28, 32,
40, 44, 51, 56, 62, 67, 74, 78, 86, 90, 95, 97, 100, 103, 104, 109, 110, 117,
110, 123, 34, -13, 5, -8, 0, -8, -4, -8, -7, -10, -8, -12, -11, -13, -12, -14,
-14, -16, -17, -17, -19, -17, -25, 7, 23, 11, 13, 5, 4, -2, -4, -8, -12, -16,
-22, -6, 7, 4, 10, 9, 13, 15, -12, -14, -8, -8, -3, -1, 4, 6, 9, 11, 15, 17, 22,
25, 27, 31, 34, 38, 40, 44, 46, 50, 53, 57, 59, 63, 65, 68, 71, 74, 78, 80, 87,
89, 87, 83, 84, 76, 86, 25, -13, -2, -14, -9, -18, -14, -23, -18, -32, -6, 27,
12, 12, 4, 1, -4, -8, -15, -19, -24, -27, -34, -38, -42, -48, -52, -58, -63,
-67, -72, -76, -82, -88, -90, -93, -96, -98, -102, -103, -105, -101, -99, -95,
-93, -90, -88, -86, -83, -81, -78, -75, -72, -70, -67, -65, -62, -60, -56, -55,
-50, -50, -45, -45, -39, -40, -30, 3, 4, 6, 8, 9, -7, -4, 2, 5, 11, 14, 20, 23,
27, 28, 31, 33, 35, 36, 39, 40, 42, 45, 47, 48, 51, 52, 55, 56, 58, 61, 62, 64,
66, 68, 71, 72, 74, 76, 79, 75, 74, 71, 70, 68, 5, -9, -6, -14, -11, -21, -16,
-30, -7, 25, 12, 11, 5, 1, -6, -10, -15, -20, -24, -30, -34, -40, -43, -50, -54,
-59, -63, -69, -73, -80, -84, -89, -93, -99, -102, -107, -108, -113, -114, -120,
-116, -116, -109, -109, -104, -104, -95, -1, 7, 7, 11, 12, 16, 17, 21, 23, 25,
29, 27, -28, -22, -16, -11, -5, 1, 7, 11, 18, 22, 28, 33, 40, 44, 51, 54, 62,
65, 73, 77, 84, 87, 90, 92, 95, 98, 100, 102, 101, 98, 96, 93, 90, 88, 85, 83,
79, 78, 74, 74, 69, 68, 63, 63, 57, 61, 46, -4, -3, -5, -8, -7, -12, -10, -18,
4, 14, 6, 4, -3, -6, -11, -15, -19, -23, -27, -32, -35, -39, -40, -43, -43, -46,
-47, -50, -49, -53, -54, -56, -58, -60, -61, -63, -65, -66, -69, -68, -70, -63,
-72, -20, 9, 3, 11, 10, 14, 17, 17, 25, 13, -24, -13, -12, -6, -2, };