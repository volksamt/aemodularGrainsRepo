#define DATA_LENGTH 512
#define DATA AKWF_1046

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 23, 33, 42, 49, 55, 62, 68, 73,
77, 82, 87, 91, 95, 98, 101, 104, 107, 109, 110, 112, 114, 116, 117, 118, 119,
119, 120, 108, 97, 91, 85, 79, 74, 71, 66, 63, 58, 55, 51, 49, 45, 41, 39, 36,
34, 31, 29, 26, 24, 22, 20, 17, 16, 13, 12, 9, 9, 6, 4, 3, 1, 0, -1, -2, -4, -6,
-7, -8, -9, -10, -11, -13, -13, -14, -16, -16, -17, -17, -18, -18, -18, -19,
-20, -21, -20, -20, -21, -21, -21, -21, -21, -22, -20, -21, -21, -20, -21, -21,
-22, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -20, -22,
-20, -20, -21, -21, -21, -21, -22, -22, -20, -21, -21, -21, -21, -21, -21, -21,
-21, -21, -22, -21, -21, -21, -22, -21, -21, -22, -21, -21, -21, -21, -22, -21,
-21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21,
-21, -21, -20, -21, -21, -20, -21, -21, -20, -20, -21, -20, -21, -21, -21, -22,
-21, -21, -21, -20, -21, -21, -21, -21, -20, -21, -21, -21, -20, -21, -20, -21,
-21, -21, -21, -21, -21, -20, -21, -20, -21, -21, -20, -21, -20, -21, -21, -20,
-20, -21, -21, -21, -20, -20, -21, -21, -21, -21, -21, -20, -20, -20, -21, -21,
-20, -21, -20, -20, -20, -21, -21, -21, -20, -21, -21, -21, -20, -21, -20, -21,
-21, -20, -21, -21, -21, -21, -20, -21, -20, -21, -21, -21, -20, -20, -21, -21,
-20, -20, -20, -16, -15, -16, -16, -17, -16, -16, -16, -16, -16, -16, -16, -17,
-16, -16, -16, -16, -16, -16, -16, -16, -16, -12, 11, 23, 32, 41, 48, 55, 61,
67, 71, 77, 81, 84, 89, 92, 97, 100, 101, 105, 106, 109, 111, 112, 113, 115,
115, 116, 116, 117, 103, 95, 89, 82, 78, 73, 70, 66, 62, 58, 55, 52, 50, 46, 44,
41, 38, 36, 33, 30, 28, 27, 25, 22, 20, 18, 16, 14, 13, 11, 9, 7, 6, 5, 2, 1,
-1, -2, -3, -4, -5, -7, -8, -9, -9, -11, -11, -13, -14, -14, -15, -16, -17, -18,
-18, -19, -18, -19, -19, -20, -20, -20, -20, -20, -21, -21, -20, -21, -21, -21,
-21, -21, -21, -21, -21, -21, -21, -21, -22, -21, -21, -21, -21, -22, -21, -20,
-21, -21, -21, -22, -21, -20, -21, -22, -21, -21, -21, -22, -22, -21, -20, -21,
-21, -21, -21, -21, -21, -21, -20, -21, -21, -21, -21, -21, -21, -21, -22, -21,
-21, -21, -21, -21, -22, -21, -22, -20, -21, -21, -20, -21, -21, -21, -21, -21,
-21, -20, -21, -21, -21, -21, -21, -21, -21, -22, -21, -21, -20, -21, -22, -22,
-22, -22, -22, -23, -23, -24, -24, -24, -24, -24, -25, -24, -25, -25, -26, -25,
-25, -25, -26, -26, -26, -26, -27, -25, -26, -26, -26, -25, -23, -23, -22, -21,
-20, -19, -19, -20, -18, -18, -17, -18, -17, -17, -17, -17, -16, -17, -16, -17,
-10, };