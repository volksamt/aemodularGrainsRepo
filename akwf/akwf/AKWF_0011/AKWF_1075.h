#define DATA_LENGTH 512
#define DATA AKWF_1075

const PROGMEM int8_t DATA[DATA_LENGTH] = {102, 121, 112, 116, 109, 113, 106,
109, 103, 106, 101, 102, 97, 98, 95, 96, 92, 92, 90, 89, 87, 85, 83, 82, 81, 78,
77, 75, 74, 72, 70, 70, 68, 66, 65, 62, 62, 60, 59, 57, 55, 53, 51, 50, 48, 47,
46, 44, 42, 42, 40, 38, 37, 34, 33, 31, 30, 28, 27, 25, 24, 22, 20, 19, 18, 16,
13, 12, 10, 12, 14, 16, 17, 18, 20, 22, 23, 25, 26, 28, 29, 32, 33, 34, 36, 37,
39, 41, 42, 44, 46, 48, 49, 50, 52, 54, 56, 58, 59, 60, 62, 64, 65, 66, 68, 70,
72, 73, 74, 76, 78, 79, 81, 82, 85, 85, 88, 89, 91, 93, 94, 95, 97, 99, 100,
102, 104, 106, 106, 109, 108, 115, 110, 119, 109, 127, 63, -25, 2, -11, 0, -5,
2, -1, 3, 4, 6, 9, 6, 17, -70, -96, -81, -86, -78, -81, -75, -75, -71, -71, -67,
-66, -62, -62, -59, -57, -55, -52, -49, -48, -46, -43, -42, -38, -38, -33, -34,
-28, -31, -23, -28, -14, -46, -93, -79, -81, -74, -74, -70, -68, -65, -62, -58,
-57, -54, -50, -48, -44, -43, -38, -37, -33, -31, -27, -26, -21, -28, -34, -28,
-26, -23, -19, -18, -18, -19, -19, -18, -18, -18, -18, -19, -18, -18, -18, -18,
-18, -18, -19, -19, -19, -19, -18, -19, -18, -18, -19, -18, -18, -18, -18, -19,
-18, -18, -19, -18, -18, -18, -18, -18, -19, -19, -19, -19, -18, -18, -19, -19,
-19, -19, -18, -19, -19, -19, -19, -19, -19, -19, -18, -18, -19, -18, -18, -18,
-19, -19, -19, -18, -19, -19, -18, -19, -18, -19, -18, -18, -18, -19, -19, -18,
-19, -19, -18, -19, -19, -19, -19, -19, -19, -19, -18, -18, -19, -19, -18, -19,
-19, -19, -18, -19, -18, -18, -20, -19, -18, -18, -18, -19, -18, -18, -18, -19,
-18, -19, -19, -19, -19, -19, -19, -19, -19, -19, -19, -19, -19, -20, -19, -18,
-19, -19, -18, -19, -19, -19, -18, -19, -19, -19, -19, -19, -19, -18, -19, -19,
-20, -19, -18, -18, -20, -18, -19, -19, -19, -20, -19, -19, -18, -19, -18, -19,
-19, -19, -19, -18, -19, -19, -19, -19, -19, -20, -19, -19, -19, -19, -19, -18,
-18, -20, -19, -18, -16, -15, -13, -12, -12, -13, -12, -14, -14, -15, -16, -18,
-31, -31, -31, -31, -30, -31, -30, -30, -30, -30, -29, -29, -29, -30, -28, -28,
-28, -28, -28, -28, -28, -28, -28, -27, -27, -27, -27, -26, -27, -26, -26, -26,
-25, -26, -26, -25, -25, -25, -25, -24, -24, -25, -25, -24, -24, -24, -23, -22,
-23, -23, -23, -22, -23, -22, -22, -22, -22, -22, -21, -22, -21, -22, -21, -20,
-20, -21, -20, -20, -20, -19, -20, -19, -20, -18, -21, -17, -21, -15, -23, -14,
-25, -5, -49, -63, 2, -17, -8, -17, -14, -18, -17, -19, -20, -20, -22, -20, -26,
3, 9, 6, 5, 3, 2, 0, -2, -3, -5, -7, -8, -11, -10, };