#define DATA_LENGTH 512
#define DATA AKWF_1073

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 1, 2, 2, 2, 2, 3, 3, 3, 5, 5,
5, 5, 6, 5, 6, 7, 8, 8, 8, 8, 9, 8, 10, 9, 12, 9, 14, 5, -21, -18, -19, -18,
-17, -18, -17, -17, -18, -17, -17, -17, -16, -16, -15, -16, -15, -15, -14, -15,
-13, -13, -13, -13, -13, -13, -11, -12, -12, -12, -12, -13, -13, -14, -15, -15,
-16, -16, -17, -17, -17, -18, -17, -18, -18, -19, -17, -20, -8, -1, -6, -5, -7,
-7, -8, -9, -10, -11, -9, 6, 12, 11, 12, 12, 13, 12, 13, 14, 14, 14, 16, 15, 16,
16, 16, 17, 17, 17, 18, 18, 18, 19, 18, 20, 19, 20, 20, 21, 21, 22, 21, 23, 23,
23, 24, 23, 23, 24, 25, 25, 25, 25, 26, 25, 26, 26, 26, 27, 27, 27, 27, 27, 27,
28, 28, 28, 28, 27, 28, 28, 28, 28, 28, 29, 29, 29, 28, 28, 28, 29, 29, 29, 28,
28, 29, 29, 28, 29, 28, 28, 29, 29, 28, 28, 29, 28, 28, 28, 28, 28, 28, 28, 28,
28, 29, 28, 29, 29, 29, 28, 29, 28, 29, 29, 29, 29, 29, 29, 29, 30, 29, 30, 29,
30, 29, 30, 30, 30, 30, 30, 30, 31, 30, 31, 31, 31, 31, 32, 32, 32, 32, 33, 33,
32, 32, 33, 33, 33, 34, 33, 34, 33, 35, 34, 34, 34, 36, 34, 36, 36, 35, 36, 36,
36, 36, 37, 37, 37, 37, 36, 40, 26, 4, 12, 7, 11, 8, 11, 9, 11, 10, 10, 12, 7,
21, -94, -128, -113, -123, -113, -120, -113, -117, -111, -114, -108, -109, -105,
-104, -100, -97, -95, -92, -87, -85, -81, -78, -73, -72, -64, -63, -56, -56,
-47, -49, -35, 5, -18, -23, -30, -37, -43, -50, -56, -63, -68, -75, -81, -86,
-91, -96, -101, -104, -108, -109, -113, -113, -118, -115, -119, -116, -121,
-116, -124, -108, 9, -11, 16, 43, 30, 35, 22, 24, 7, 33, 14, 8, 9, 6, 5, 4, 2,
3, -2, 11, 28, 22, 26, 22, 24, 23, 23, 21, 22, 20, 19, 17, 17, 16, 14, 14, 13,
11, 12, 14, 14, 19, 18, 21, 19, 23, 21, 25, 22, 26, 22, 28, 18, -10, -4, -3, 2,
2, 7, 5, 16, -22, -37, -27, -26, -22, -18, -18, -9, -19, -26, 17, 8, 13, 9, 10,
10, 10, 11, 10, 11, 9, 10, 9, 10, 8, 10, 8, 9, 8, 10, 8, 10, 8, 12, 15, 14, 15,
14, 14, 14, 14, 15, 14, 13, 14, 14, 14, 13, 13, 13, 13, 13, 12, 12, 12, 11, 12,
11, 12, 12, 12, 12, 13, 13, 13, 13, 13, 13, 14, 14, 14, 15, 15, 15, 14, 16, 14,
16, 13, 17, 2, -14, -10, -11, -9, -10, -10, -10, -9, -9, -8, -9, -8, -9, -7, -8,
-8, -7, -7, -7, -7, -6, -6, -5, -5, -6, -5, -4, -4, -4, -4, -3, -4, -4, -2, -3,
-2, -3, -2, -2, -2, -2, -1, 0, 0, };