#define DATA_LENGTH 512
#define DATA AKWF_1096

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 9, 11, 15, 19, 24, 27, 31,
35, 39, 42, 46, 49, 53, 57, 59, 62, 65, 68, 71, 74, 75, 78, 81, 83, 86, 87, 90,
91, 93, 94, 96, 97, 99, 101, 102, 102, 104, 105, 107, 107, 108, 109, 110, 110,
112, 112, 113, 114, 115, 114, 115, 116, 116, 117, 117, 117, 118, 118, 118, 118,
118, 119, 119, 119, 119, 118, 119, 119, 119, 118, 118, 118, 117, 116, 116, 116,
115, 115, 115, 113, 113, 114, 112, 112, 112, 111, 111, 110, 109, 109, 108, 108,
107, 107, 106, 106, 105, 105, 104, 103, 103, 102, 101, 102, 101, 99, 99, 98, 97,
97, 95, 94, 93, 92, 91, 91, 90, 89, 89, 88, 88, 87, 87, 86, 85, 84, 83, 82, 82,
80, 80, 79, 78, 77, 76, 76, 74, 75, 74, 73, 72, 72, 71, 70, 71, 70, 69, 69, 69,
68, 68, 68, 67, 67, 67, 66, 66, 66, 67, 68, 67, 68, 68, 68, 69, 70, 70, 70, 70,
70, 70, 71, 72, 72, 73, 73, 73, 73, 74, 73, 74, 74, 74, 74, 73, 73, 72, 71, 71,
70, 69, 68, 69, 67, 67, 66, 65, 64, 63, 63, 62, 61, 60, 59, 59, 58, 56, 55, 53,
52, 51, 50, 48, 46, 45, 43, 41, 40, 38, 37, 34, 32, 31, 29, 27, 25, 23, 21, 19,
18, 16, 14, 12, 10, 9, 7, 6, 4, 2, 1, 0, -2, -2, -3, -5, -5, -5, -6, -6, -7, -8,
-10, -11, -12, -14, -15, -18, -19, -20, -22, -22, -24, -25, -26, -27, -29, -30,
-31, -32, -33, -34, -37, -37, -39, -39, -42, -42, -43, -44, -46, -47, -48, -49,
-50, -51, -52, -53, -53, -54, -56, -56, -56, -57, -58, -60, -60, -61, -63, -63,
-63, -64, -64, -64, -65, -65, -66, -66, -67, -67, -67, -68, -68, -69, -68, -69,
-70, -70, -70, -70, -70, -70, -71, -70, -71, -72, -71, -71, -71, -71, -71, -70,
-69, -70, -69, -68, -68, -68, -66, -67, -67, -67, -66, -65, -65, -64, -63, -63,
-62, -62, -62, -62, -61, -62, -62, -62, -62, -62, -63, -64, -64, -64, -64, -65,
-66, -67, -67, -68, -69, -69, -71, -70, -71, -72, -72, -73, -77, -78, -78, -81,
-82, -82, -84, -85, -87, -87, -88, -89, -89, -90, -91, -91, -92, -92, -92, -94,
-94, -95, -96, -96, -97, -97, -97, -98, -98, -98, -99, -99, -100, -101, -101,
-101, -102, -102, -104, -104, -105, -106, -105, -107, -107, -107, -107, -108,
-108, -110, -109, -110, -111, -111, -112, -112, -112, -113, -113, -113, -114,
-113, -113, -114, -113, -113, -113, -114, -114, -113, -114, -113, -113, -113,
-113, -112, -112, -112, -110, -110, -110, -110, -109, -108, -108, -107, -107,
-105, -104, -104, -104, -104, -103, -101, -101, -99, -98, -97, -96, -95, -93,
-92, -91, -89, -87, -86, -84, -82, -81, -79, -76, -74, -71, -68, -67, -63, -60,
-58, -55, -52, -49, -46, -41, -39, -35, -30, -27, -23, -18, -15, -11, -7, -5,
-1, };