#define DATA_LENGTH 512
#define DATA AKWF_1050

const PROGMEM int8_t DATA[DATA_LENGTH] = {52, 61, 56, 60, 55, 58, 54, 55, 52,
53, 51, 51, 50, 50, 47, 48, 46, 46, 45, 44, 44, 43, 42, 41, 40, 39, 39, 38, 37,
36, 35, 34, 35, 33, 32, 31, 31, 29, 30, 28, 27, 27, 25, 25, 24, 23, 21, 22, 21,
19, 19, 18, 17, 16, 16, 14, 15, 13, 13, 12, 11, 10, 9, 8, 7, 7, 6, 5, 4, 3, 3,
2, 1, 1, 0, -1, -2, -4, -4, -5, -6, -6, -7, -9, -9, -9, -10, -11, -12, -13, -14,
-14, -15, -17, -17, -18, -18, -20, -19, -21, -22, -22, -23, -25, -25, -26, -27,
-27, -28, -29, -31, -30, -32, -32, -34, -34, -35, -35, -37, -37, -39, -38, -41,
-40, -43, -41, -43, -43, -44, -45, -46, -47, -47, -49, -47, -52, -48, -56, -47,
-62, -44, -76, 27, 127, 108, 126, 114, 123, 117, 121, 117, 119, 119, 119, 119,
118, 120, 118, 120, 118, 120, 119, 119, 118, 121, 119, 119, 118, 119, 119, 119,
119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 120, 120,
120, 118, 119, 119, 120, 119, 119, 119, 119, 120, 119, 119, 119, 118, 119, 119,
119, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118,
119, 118, 120, 118, 118, 118, 118, 119, 119, 118, 119, 119, 119, 118, 119, 119,
119, 119, 118, 119, 119, 121, 117, 121, 117, 121, 116, 120, 115, 121, 115, 123,
114, 123, 113, 124, 107, -58, -62, -55, -60, -54, -58, -52, -56, -51, -55, -50,
-52, -48, -51, -47, -48, -45, -47, -44, -44, -43, -43, -42, -40, -41, -39, -38,
-37, -37, -35, -36, -34, -34, -32, -33, -31, -31, -29, -29, -28, -28, -26, -26,
-24, -24, -23, -23, -21, -21, -20, -18, -18, -18, -16, -16, -15, -13, -14, -12,
-12, -11, -10, -9, -8, -8, -7, -6, -4, -4, -3, -3, -2, -1, 0, 0, 2, 3, 3, 4, 5,
5, 7, 8, 8, 9, 10, 11, 11, 12, 13, 13, 14, 15, 16, 17, 17, 19, 20, 20, 21, 21,
23, 23, 25, 25, 27, 27, 28, 28, 30, 30, 31, 32, 32, 34, 34, 35, 35, 38, 37, 39,
38, 40, 40, 43, 41, 44, 43, 45, 45, 46, 47, 47, 49, 49, 51, 49, 54, 49, 60, 44,
75, -47, -128, -107, -127, -114, -123, -115, -121, -116, -121, -118, -120, -119,
-119, -119, -119, -120, -118, -119, -119, -120, -119, -120, -119, -119, -118,
-120, -119, -120, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -120, -120, -118, -119, -119, -118, -119, -118, -119, -119, -120,
-118, -120, -118, -119, -119, -119, -119, -119, -119, -118, -120, -119, -119,
-119, -119, -118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -120, -118, -119, -119, -119, -118, -118, -118, -119, -118,
-118, -118, -118, -119, -118, -119, -118, -119, -118, -119, -117, -120, -117,
-120, -117, -121, -116, -122, -115, -123, -114, -126, -101, };