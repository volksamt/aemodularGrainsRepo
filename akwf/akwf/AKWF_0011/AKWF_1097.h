#define DATA_LENGTH 512
#define DATA AKWF_1097

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 6, 9, 10, 12, 13, 15, 16,
18, 19, 20, 22, 24, 24, 26, 27, 30, 30, 32, 34, 34, 36, 37, 39, 41, 42, 43, 44,
46, 48, 49, 50, 52, 53, 54, 56, 57, 58, 60, 61, 62, 63, 64, 65, 67, 69, 69, 71,
72, 72, 74, 76, 76, 78, 79, 80, 81, 82, 83, 84, 85, 86, 88, 88, 90, 91, 91, 92,
93, 94, 95, 95, 97, 98, 98, 100, 100, 101, 102, 102, 103, 104, 104, 105, 105,
107, 107, 107, 108, 109, 110, 110, 112, 111, 111, 112, 113, 113, 114, 114, 115,
115, 116, 116, 115, 117, 116, 117, 118, 117, 118, 118, 117, 118, 119, 118, 118,
119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 118,
118, 118, 118, 116, 117, 116, 115, 114, 113, 112, 111, 109, 108, 108, 108, 106,
106, 105, 105, 104, 103, 101, 100, 99, 99, 98, 98, 96, 96, 94, 94, 93, 91, 90,
90, 89, 88, 88, 86, 86, 84, 83, 83, 82, 82, 81, 80, 80, 78, 78, 76, 76, 76, 74,
74, 74, 73, 72, 71, 70, 70, 69, 68, 68, 66, 66, 65, 66, 65, 64, 64, 63, 62, 62,
61, 60, 59, 59, 58, 57, 55, 54, 52, 50, 50, 49, 47, 46, 45, 44, 42, 42, 39, 39,
37, 36, 34, 34, 31, 31, 29, 28, 25, 24, 23, 20, 19, 18, 17, 15, 14, 13, 11, 9,
7, 7, 5, 4, 2, 1, -1, -3, -4, -6, -7, -9, -11, -11, -14, -15, -16, -18, -20,
-21, -22, -23, -24, -26, -28, -30, -31, -32, -34, -36, -37, -37, -39, -41, -42,
-43, -45, -46, -48, -48, -51, -52, -53, -54, -56, -57, -57, -59, -61, -63, -63,
-66, -67, -67, -68, -70, -71, -72, -73, -74, -75, -76, -78, -79, -80, -81, -82,
-84, -85, -85, -86, -87, -88, -89, -91, -91, -92, -93, -94, -95, -96, -97, -98,
-99, -99, -99, -101, -102, -103, -103, -103, -105, -105, -107, -107, -107, -108,
-108, -109, -110, -111, -110, -111, -112, -112, -113, -113, -113, -114, -115,
-115, -116, -116, -116, -116, -116, -117, -117, -118, -117, -119, -118, -118,
-118, -119, -119, -118, -119, -119, -119, -120, -119, -119, -119, -120, -119,
-119, -119, -120, -118, -119, -118, -118, -118, -118, -118, -117, -115, -115,
-113, -112, -111, -110, -109, -108, -108, -106, -107, -106, -105, -104, -103,
-102, -101, -100, -100, -99, -98, -97, -96, -95, -94, -93, -92, -91, -91, -90,
-89, -88, -87, -86, -85, -85, -83, -83, -81, -82, -81, -81, -79, -78, -78, -76,
-77, -75, -75, -74, -73, -73, -72, -71, -70, -69, -69, -68, -68, -67, -66, -66,
-66, -64, -64, -64, -63, -62, -62, -62, -60, -60, -59, -58, -57, -56, -55, -53,
-51, -50, -48, -47, -46, -45, -44, -42, -41, -39, -38, -37, -36, -34, -33, -32,
-30, -28, -27, -25, -24, -22, -21, -20, -18, -17, -14, -14, -11, -11, -9, -8,
-5, -5, -3, -2, 0, };