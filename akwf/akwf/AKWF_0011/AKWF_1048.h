#define DATA_LENGTH 512
#define DATA AKWF_1048

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 0, 17, 24, 22, 25, 25, 28,
28, 30, 30, 32, 33, 34, 35, 36, 37, 38, 39, 41, 41, 42, 43, 44, 45, 46, 48, 49,
50, 50, 51, 54, 53, 55, 56, 58, 58, 59, 60, 62, 62, 63, 64, 66, 67, 68, 69, 70,
71, 72, 74, 74, 75, 76, 78, 79, 80, 81, 82, 83, 84, 86, 86, 88, 89, 90, 91, 92,
92, 94, 94, 96, 97, 99, 99, 101, 101, 102, 103, 104, 106, 107, 108, 109, 111,
111, 112, 113, 114, 115, 116, 117, 120, 115, 109, 109, 108, 108, 106, 105, 104,
104, 103, 102, 101, 99, 98, 98, 97, 96, 95, 94, 93, 92, 91, 91, 89, 89, 88, 87,
86, 85, 84, 84, 83, 81, 80, 80, 78, 77, 77, 76, 75, 74, 73, 72, 72, 70, 70, 69,
67, 67, 66, 65, 64, 63, 62, 61, 59, 59, 58, 57, 56, 55, 54, 53, 52, 52, 50, 50,
49, 48, 47, 45, 45, 44, 43, 42, 41, 40, 40, 39, 37, 37, 35, 35, 33, 33, 32, 32,
31, 30, 28, 28, 26, 26, 25, 24, 23, 22, 21, 20, 19, 19, 17, 17, 15, 14, 14, 12,
12, 11, 9, 9, 8, 8, 6, 6, 4, 4, 3, 2, 1, 0, 0, -2, -3, -4, -4, -6, -6, -8, -8,
-10, -10, -11, -13, -13, -13, -14, -15, -16, -18, -19, -19, -20, -21, -22, -23,
-24, -25, -25, -27, -28, -28, -29, -30, -31, -32, -33, -33, -34, -36, -36, -38,
-38, -39, -40, -42, -42, -43, -44, -45, -46, -47, -47, -49, -50, -51, -51, -52,
-52, -53, -54, -56, -56, -58, -58, -60, -61, -61, -62, -63, -64, -65, -66, -67,
-67, -69, -69, -71, -71, -72, -73, -74, -75, -76, -76, -78, -78, -79, -81, -80,
-90, -93, -91, -91, -90, -90, -89, -89, -89, -88, -88, -88, -87, -87, -86, -85,
-85, -85, -84, -84, -83, -82, -83, -81, -82, -81, -81, -81, -80, -80, -79, -79,
-77, -77, -77, -76, -76, -75, -75, -75, -75, -74, -74, -72, -72, -72, -72, -71,
-71, -70, -69, -68, -69, -68, -68, -68, -66, -67, -66, -66, -66, -65, -64, -64,
-63, -63, -63, -62, -62, -61, -60, -60, -59, -59, -59, -59, -57, -58, -57, -56,
-56, -56, -56, -55, -54, -55, -53, -53, -52, -53, -52, -51, -51, -51, -50, -50,
-50, -48, -48, -47, -47, -46, -46, -46, -45, -45, -45, -44, -44, -43, -42, -43,
-42, -41, -41, -40, -40, -39, -39, -39, -39, -37, -37, -37, -36, -36, -36, -35,
-34, -35, -34, -33, -33, -32, -32, -31, -31, -30, -30, -29, -29, -29, -28, -28,
-28, -27, -27, -25, -25, -26, -25, -25, -24, -24, -23, -23, -22, -22, -21, -21,
-21, -20, -19, -19, -19, -18, -18, -17, -16, -16, -16, -16, -15, -15, -14, -13,
-13, -13, -13, -13, -12, -11, -10, -9, -9, -9, -9, -8, -7, -7, -6, -7, -6, -6,
-5, -4, -5, -4, -3, -3, -3, -2, -2, -2, 0, 0, };