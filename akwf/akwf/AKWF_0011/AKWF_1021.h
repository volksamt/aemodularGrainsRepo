#define DATA_LENGTH 512
#define DATA AKWF_1021

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 15, 21, 24, 28, 31, 33, 37, 39, 41,
44, 46, 47, 50, 52, 54, 56, 57, 59, 60, 62, 62, 64, 66, 68, 69, 70, 72, 73, 74,
75, 76, 77, 79, 79, 80, 82, 83, 83, 84, 85, 87, 88, 88, 89, 90, 91, 92, 93, 93,
95, 95, 95, 96, 97, 97, 98, 99, 99, 100, 100, 101, 102, 103, 103, 104, 104, 105,
105, 106, 106, 106, 107, 107, 108, 109, 109, 109, 109, 110, 111, 111, 112, 111,
111, 112, 112, 113, 113, 113, 113, 115, 115, 115, 115, 115, 115, 115, 116, 116,
116, 117, 117, 116, 117, 117, 117, 118, 117, 118, 118, 118, 119, 119, 119, 118,
118, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 118, 119, 118, 119, 119, 118, 118, 119, 119, 118, 118, 118,
118, 118, 117, 117, 116, 117, 116, 117, 116, 116, 115, 115, 115, 115, 115, 115,
113, 114, 113, 113, 112, 113, 112, 112, 111, 111, 111, 110, 109, 109, 108, 109,
108, 108, 107, 107, 107, 106, 105, 104, 104, 104, 103, 103, 103, 102, 101, 100,
99, 99, 98, 99, 97, 97, 95, 96, 94, 94, 93, 92, 92, 90, 89, 89, 87, 88, 86, 85,
84, 83, 82, 81, 80, 78, 77, 77, 76, 74, 73, 73, 70, 69, 68, 67, 65, 63, 62, 60,
59, 57, 56, 54, 52, 50, 48, 47, 44, 42, 40, 37, 34, 32, 29, 25, 21, 17, 10, 2,
-8, -17, -22, -26, -28, -31, -34, -37, -40, -41, -44, -47, -48, -50, -53, -53,
-55, -57, -59, -60, -62, -63, -64, -66, -68, -69, -70, -72, -73, -75, -75, -77,
-78, -79, -79, -81, -82, -83, -84, -85, -86, -86, -87, -89, -89, -90, -91, -92,
-92, -94, -94, -94, -95, -97, -97, -98, -98, -99, -100, -101, -101, -102, -102,
-103, -104, -104, -104, -105, -105, -106, -106, -107, -107, -108, -109, -108,
-109, -110, -110, -110, -111, -110, -112, -112, -112, -112, -112, -113, -113,
-113, -114, -114, -114, -114, -115, -115, -116, -116, -116, -116, -116, -117,
-116, -117, -117, -117, -117, -117, -117, -118, -118, -118, -119, -118, -118,
-118, -119, -118, -119, -119, -120, -119, -119, -120, -118, -119, -119, -118,
-119, -119, -120, -119, -119, -119, -118, -119, -119, -119, -118, -118, -119,
-119, -118, -118, -118, -118, -118, -117, -117, -117, -117, -117, -117, -117,
-117, -116, -116, -115, -115, -116, -115, -115, -115, -114, -114, -113, -114,
-113, -112, -112, -112, -111, -111, -111, -110, -110, -109, -110, -109, -108,
-108, -108, -108, -106, -107, -105, -105, -105, -104, -103, -103, -103, -102,
-102, -100, -100, -99, -99, -99, -97, -97, -96, -95, -96, -94, -93, -92, -92,
-91, -90, -89, -88, -88, -87, -85, -86, -84, -84, -81, -81, -80, -79, -78, -77,
-76, -74, -74, -71, -70, -69, -68, -67, -65, -64, -62, -61, -59, -57, -56, -54,
-52, -50, -49, -47, -44, -43, -39, -37, -34, -32, -29, -25, -21, -17, -11, -2,
};