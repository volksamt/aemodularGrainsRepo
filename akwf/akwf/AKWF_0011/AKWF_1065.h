#define DATA_LENGTH 512
#define DATA AKWF_1065

const PROGMEM int8_t DATA[DATA_LENGTH] = {102, 122, 113, 120, 115, 120, 115,
120, 117, 120, 117, 120, 118, 120, 118, 119, 119, 120, 119, 119, 119, 119, 120,
118, 119, 118, 119, 117, 118, 118, 119, 117, 117, 116, 118, 117, 117, 116, 116,
116, 115, 115, 115, 114, 115, 114, 113, 113, 113, 113, 112, 112, 111, 112, 110,
110, 110, 110, 109, 109, 108, 108, 107, 107, 107, 106, 106, 104, 105, 104, 104,
103, 102, 102, 102, 101, 101, 100, 99, 100, 98, 98, 98, 97, 97, 96, 94, 94, 93,
93, 92, 92, 91, 91, 89, 89, 89, 89, 88, 87, 85, 85, 85, 84, 83, 83, 81, 81, 80,
80, 79, 79, 78, 77, 76, 76, 74, 74, 72, 73, 72, 71, 69, 69, 69, 68, 67, 67, 66,
65, 64, 63, 63, 62, 60, 60, 60, 58, 58, 57, 57, 56, 54, 54, 54, 53, 52, 51, 50,
49, 49, 48, 46, 46, 46, 45, 45, 44, 43, 42, 41, 40, 40, 38, 38, 37, 36, 36, 35,
34, 34, 33, 33, 31, 31, 30, 30, 29, 29, 28, 28, 26, 26, 26, 24, 24, 23, 23, 22,
22, 20, 21, 20, 18, 18, 18, 17, 17, 16, 15, 15, 14, 13, 13, 13, 12, 12, 12, 11,
11, 10, 10, 10, 9, 9, 8, 8, 7, 7, 7, 6, 5, 5, 5, 5, 5, 4, 4, 3, 3, 3, 3, 2, 3,
3, 2, 2, 1, 1, 1, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 1, -1, 1, -2, 4, -50, -118,
-114, -117, -115, -116, -115, -116, -116, -116, -116, -116, -116, -115, -115,
-115, -115, -116, -115, -115, -115, -114, -115, -115, -114, -115, -115, -115,
-114, -114, -114, -113, -113, -113, -113, -112, -113, -112, -113, -112, -112,
-112, -112, -110, -111, -109, -109, -109, -109, -110, -109, -109, -108, -108,
-108, -108, -107, -106, -106, -106, -105, -104, -104, -104, -104, -103, -103,
-103, -102, -101, -102, -100, -100, -99, -98, -98, -97, -97, -97, -96, -95, -95,
-94, -94, -93, -92, -92, -92, -91, -90, -90, -90, -88, -88, -88, -86, -87, -86,
-85, -84, -84, -83, -82, -81, -80, -80, -79, -79, -78, -78, -77, -76, -75, -75,
-74, -73, -72, -72, -71, -71, -69, -69, -68, -68, -66, -66, -66, -65, -64, -63,
-62, -62, -61, -60, -59, -58, -57, -57, -56, -55, -54, -53, -54, -52, -52, -51,
-51, -50, -48, -48, -47, -46, -46, -46, -45, -43, -43, -42, -42, -41, -40, -40,
-38, -38, -38, -37, -36, -36, -34, -34, -33, -32, -32, -31, -30, -29, -29, -28,
-27, -27, -26, -25, -25, -24, -24, -24, -22, -22, -22, -21, -20, -20, -19, -18,
-18, -17, -17, -16, -16, -15, -15, -14, -14, -14, -13, -12, -11, -11, -10, -11,
-10, -10, -10, -10, -8, -7, -7, -7, -6, -7, -7, -5, -6, -5, -4, -5, -3, -4, -3,
-3, -3, -3, -3, -2, -2, -1, -1, -2, -2, -1, -1, -1, -1, 0, 0, -1, 0, 0, 0, -1,
0, 0, 1, 0, 0, 0, -1, };