#define DATA_LENGTH 512
#define DATA AKWF_1085

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 4, -27, -39, -37, -29, -21, -14,
-11, -6, -3, 2, 5, 8, 10, 14, 15, 17, 20, 22, 23, 24, 27, 27, 29, 29, 31, 31,
32, 33, 34, 34, 35, 36, 36, 37, 36, 37, 37, 39, 40, 40, 40, 39, 40, 40, 40, 41,
42, 42, 42, 42, 42, 43, 43, 43, 44, 44, 44, 44, 44, 43, 44, 44, 45, 45, 46, 45,
46, 45, 45, 46, 46, 45, 46, 46, 46, 46, 46, 46, 46, 46, 46, 46, 46, 47, 46, 46,
46, 46, 46, 46, 46, 46, 46, 46, 46, 45, 46, 45, 45, 46, 46, 46, 45, 45, 44, 45,
45, 45, 44, 44, 44, 44, 44, 43, 44, 43, 43, 43, 42, 42, 43, 43, 41, 42, 41, 41,
41, 41, 40, 40, 41, 40, 39, 40, 40, 39, 39, 38, 37, 38, 38, 37, 37, 36, 36, 35,
35, 36, 36, 34, 34, 34, 34, 33, 33, 33, 32, 32, 32, 31, 31, 30, 30, 29, 29, 29,
29, 28, 28, 28, 27, 26, 27, 27, 25, 26, 25, 25, 25, 24, 23, 23, 23, 23, 22, 21,
21, 20, 20, 20, 20, 19, 19, 19, 19, 17, 17, 17, 16, 16, 15, 15, 15, 15, 14, 14,
14, 13, 12, 12, 12, 12, 11, 10, 10, 9, 10, 9, 9, 8, 8, 7, 6, 7, 7, 6, 5, 4, 5,
4, 3, 3, 3, 3, 2, 3, 1, 2, 1, 1, 0, 0, 0, -1, -2, -2, -3, -2, -2, -3, -3, -4,
-4, -4, -5, -5, -6, -6, -7, -6, -7, -7, -7, -8, -7, -8, -9, -10, -9, -9, -9,
-11, -10, -10, -11, -12, -12, -12, -13, -13, -13, -12, -13, -14, -13, -14, -15,
-15, -14, -15, -15, -16, -16, -16, -16, -16, -17, -17, -16, -17, -18, -18, -18,
-17, -18, -19, -19, -19, -19, -19, -19, -20, -19, -20, -19, -20, -20, -20, -20,
-20, -21, -21, -20, -21, -21, -21, -21, -21, -22, -22, -22, -22, -23, -22, -22,
-23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -24,
-23, -23, -23, -24, -23, -23, -23, -24, -23, -23, -23, -23, -24, -24, -24, -24,
-23, -24, -24, -23, -22, -23, -23, -23, -23, -23, -22, -23, -22, -23, -22, -23,
-22, -23, -23, -23, -22, -22, -22, -22, -22, -22, -22, -22, -22, -21, -21, -21,
-21, -20, -20, -21, -21, -20, -21, -20, -20, -20, -20, -20, -20, -19, -19, -19,
-20, -20, -19, -19, -18, -18, -18, -18, -18, -18, -17, -17, -17, -17, -17, -17,
-17, -15, -17, -16, -16, -16, -16, -16, -16, -15, -15, -14, -14, -14, -14, -14,
-13, -14, -13, -13, -13, -13, -13, -13, -12, -12, -12, -12, -11, -11, -11, -11,
-11, -10, -10, -10, -11, -9, -10, -9, -10, -7, -10, -7, -72, -118, -79, -62,
-56, -63, -70, -76, -79, -82, -85, -87, -90, -92, -93, -94, -96, -97, -98, -97,
-98, -98, -98, -98, -98, -98, -97, -98, -95, -98, -94, -97, -91, -98, -66, };