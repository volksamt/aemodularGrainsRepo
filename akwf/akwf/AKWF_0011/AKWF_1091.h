#define DATA_LENGTH 512
#define DATA AKWF_1091

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 9, 14, 19, 23, 27, 31, 36, 41,
45, 50, 54, 57, 62, 66, 70, 74, 78, 82, 85, 88, 91, 94, 97, 100, 102, 106, 107,
110, 111, 113, 114, 115, 117, 117, 118, 119, 119, 120, 119, 118, 118, 117, 117,
116, 115, 114, 112, 110, 107, 106, 103, 101, 98, 94, 92, 89, 86, 83, 79, 75, 72,
68, 64, 60, 56, 51, 46, 42, 37, 32, 27, 22, 17, 11, 6, -1, -7, -13, -19, -26,
-32, -39, -46, -52, -58, -65, -70, -75, -80, -85, -87, -88, -88, -87, -82, -72,
-63, -65, -80, -77, -68, -65, -57, -51, -42, -36, -28, -21, -14, -8, -2, 3, 8,
12, 15, 18, 20, 21, 20, 21, 20, 20, 17, 15, 11, 8, 4, -1, -6, -11, -16, -23,
-29, -35, -41, -48, -52, -57, -61, -63, -62, -61, -55, -47, -34, -40, -65, -63,
-54, -53, -45, -40, -32, -26, -20, -14, -8, -2, 2, 5, 10, 13, 15, 15, 18, 18,
17, 16, 16, 13, 10, 8, 4, 1, -4, -8, -13, -19, -23, -30, -35, -42, -48, -54,
-59, -64, -69, -73, -77, -78, -79, -78, -76, -70, -63, -58, -68, -74, -64, -58,
-53, -45, -38, -29, -22, -13, -5, 3, 10, 16, 23, 29, 35, 40, 44, 49, 53, 55, 57,
60, 62, 63, 65, 64, 66, 65, 65, 63, 63, 61, 60, 59, 56, 55, 52, 51, 48, 46, 43,
41, 38, 35, 33, 30, 28, 25, 22, 20, 17, 15, 13, 10, 8, 6, 4, 1, 0, -1, -3, -5,
-6, -7, -8, -10, -11, -12, -11, -12, -14, -13, -13, -13, -13, -13, -12, -12,
-11, -11, -9, -8, -7, -6, -3, -2, 0, 3, 5, 7, 10, 14, 16, 19, 23, 27, 31, 34,
39, 43, 47, 52, 56, 60, 62, 67, 70, 72, 73, 73, 73, 70, 66, 59, 48, 37, 43, 53,
44, 36, 30, 21, 13, 5, -3, -12, -19, -28, -34, -41, -47, -52, -56, -60, -63,
-65, -66, -68, -68, -67, -66, -63, -60, -57, -53, -49, -43, -38, -32, -26, -21,
-15, -10, -8, -6, -8, -11, -20, -35, -49, -27, 7, -4, -9, -10, -18, -22, -30,
-34, -40, -44, -48, -51, -53, -55, -56, -55, -54, -52, -49, -46, -41, -36, -31,
-25, -19, -15, -10, -7, -7, -9, -15, -27, -45, -59, -23, 11, -5, -8, -11, -17,
-22, -29, -33, -38, -42, -46, -47, -49, -49, -49, -47, -45, -41, -38, -33, -29,
-22, -17, -12, -6, -2, 2, 3, 1, -3, -12, -26, -43, -24, 16, 9, 0, 0, -8, -11,
-18, -23, -29, -32, -37, -40, -42, -44, -44, -43, -44, -42, -40, -38, -34, -29,
-25, -21, -15, -9, -4, 2, 8, 14, 19, 23, 28, 30, 32, 30, 27, 22, 12, 6, 25, 37,
26, 22, 18, 12, 6, -1, -7, -15, -21, -27, -32, -36, -41, -45, -48, -51, -53,
-54, -56, -57, -56, -56, -56, -54, -52, -51, -49, -47, -45, -41, -38, -35, -32,
-29, -24, -20, -16, -12, -8, -2, };