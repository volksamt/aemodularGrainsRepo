#define DATA_LENGTH 512
#define DATA AKWF_1054

const PROGMEM int8_t DATA[DATA_LENGTH] = {13, 48, 33, 36, 61, 45, 13, 14, 32,
26, 23, 46, 68, 65, 62, 71, 70, 54, 48, 53, 53, 48, 56, 66, 67, 64, 66, 67, 59,
55, 54, 53, 51, 52, 56, 58, 56, 56, 56, 54, 51, 50, 50, 48, 49, 51, 53, 52, 53,
55, 56, 54, 55, 55, 56, 56, 59, 62, 62, 64, 65, 66, 67, 68, 70, 71, 73, 74, 76,
77, 79, 80, 81, 82, 82, 83, 84, 85, 86, 86, 85, 87, 87, 87, 87, 87, 86, 86, 85,
85, 85, 84, 83, 82, 82, 81, 81, 79, 78, 77, 76, 76, 75, 75, 75, 74, 73, 73, 73,
71, 72, 71, 72, 71, 71, 72, 73, 72, 72, 72, 73, 73, 75, 74, 75, 75, 77, 76, 80,
101, 107, 103, 106, 110, 108, 103, 105, 109, 109, 109, 114, 117, 116, 117, 118,
117, 115, 115, 117, 115, 114, 115, 117, 116, 116, 116, 116, 113, 112, 112, 110,
109, 109, 110, 109, 108, 106, 108, 105, 104, 104, 103, 102, 102, 102, 103, 102,
102, 102, 102, 101, 102, 101, 103, 103, 103, 104, 104, 105, 105, 107, 106, 107,
109, 109, 109, 110, 111, 111, 113, 113, 114, 115, 115, 116, 116, 116, 117, 118,
117, 118, 118, 117, 118, 118, 118, 118, 117, 117, 116, 117, 116, 115, 115, 114,
114, 113, 112, 111, 112, 110, 111, 109, 109, 108, 108, 108, 108, 106, 107, 106,
106, 106, 106, 107, 105, 107, 104, 107, 106, 108, 104, 110, 104, 111, 102, 118,
75, -41, -41, -31, -46, -60, -32, -8, -22, -31, -23, -30, -58, -68, -63, -66,
-74, -64, -51, -51, -55, -51, -51, -62, -70, -67, -66, -69, -67, -59, -56, -57,
-54, -54, -56, -60, -59, -59, -59, -59, -55, -53, -53, -52, -51, -52, -54, -55,
-55, -56, -57, -57, -56, -56, -57, -57, -58, -61, -63, -64, -65, -68, -68, -69,
-70, -71, -72, -74, -76, -77, -79, -80, -81, -82, -82, -83, -84, -84, -85, -86,
-86, -87, -87, -88, -88, -88, -87, -86, -86, -86, -87, -85, -85, -84, -84, -83,
-82, -82, -81, -80, -80, -78, -78, -77, -78, -76, -76, -75, -75, -74, -74, -74,
-74, -74, -73, -73, -73, -74, -74, -74, -74, -75, -74, -76, -76, -77, -76, -82,
-103, -105, -104, -107, -110, -107, -103, -106, -108, -107, -109, -114, -117,
-117, -117, -120, -118, -116, -116, -117, -116, -115, -117, -119, -118, -117,
-118, -116, -115, -114, -113, -113, -112, -111, -112, -111, -111, -111, -110,
-109, -107, -107, -105, -105, -105, -104, -105, -104, -104, -103, -104, -103,
-103, -103, -103, -104, -104, -105, -106, -106, -107, -107, -107, -109, -109,
-109, -110, -110, -111, -113, -113, -114, -114, -115, -115, -116, -116, -117,
-117, -117, -118, -118, -119, -118, -119, -119, -118, -119, -119, -117, -119,
-118, -117, -118, -116, -116, -116, -115, -115, -114, -113, -112, -113, -111,
-112, -110, -110, -110, -109, -110, -108, -109, -107, -109, -107, -109, -106,
-109, -106, -109, -105, -110, -105, -112, -103, -115, -92, };