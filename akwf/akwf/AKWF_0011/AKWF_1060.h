#define DATA_LENGTH 512
#define DATA AKWF_1060

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 4, 4, 5, 7, 7, 9, 10, 12, 12,
14, 16, 17, 18, 20, 22, 23, 24, 26, 28, 29, 31, 31, 34, 35, 35, 36, 39, 40, 41,
42, 43, 44, 45, 47, 48, 50, 50, 51, 52, 53, 53, 54, 55, 55, 57, 57, 58, 59, 59,
60, 60, 61, 62, 63, 62, 63, 63, 64, 65, 65, 65, 67, 67, 68, 69, 69, 69, 70, 71,
71, 73, 72, 75, 74, 75, 76, 77, 77, 79, 80, 80, 82, 82, 82, 84, 84, 86, 87, 87,
88, 89, 90, 91, 91, 91, 93, 93, 94, 95, 96, 97, 96, 97, 98, 98, 98, 99, 100,
100, 100, 100, 101, 101, 101, 102, 102, 102, 102, 103, 103, 103, 103, 104, 104,
104, 105, 104, 105, 106, 105, 106, 105, 106, 107, 106, 107, 108, 108, 108, 108,
109, 109, 110, 111, 111, 111, 111, 112, 112, 113, 113, 114, 114, 114, 115, 114,
115, 116, 116, 117, 117, 117, 117, 118, 118, 119, 118, 118, 119, 118, 119, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 118, 118,
118, 118, 117, 118, 118, 118, 118, 118, 118, 118, 118, 118, 117, 118, 117, 108,
86, 69, 67, 71, 70, 71, 75, 74, 68, 62, 60, 54, 47, 45, 45, 43, 41, 43, 42, 40,
37, 35, 32, 28, 26, 25, 24, 23, 23, 22, 22, 20, 19, 18, 16, 14, 12, 12, 12, 10,
10, 11, 8, 7, 7, 5, 4, 3, 1, 0, 0, -1, -2, -4, -5, -6, -7, -9, -10, -12, -13,
-15, -16, -17, -19, -21, -22, -23, -26, -27, -28, -29, -31, -32, -34, -35, -36,
-38, -38, -40, -41, -43, -44, -45, -47, -46, -47, -49, -50, -50, -51, -53, -53,
-53, -54, -55, -56, -57, -57, -57, -57, -58, -59, -60, -60, -61, -62, -62, -63,
-63, -63, -64, -65, -65, -66, -66, -67, -68, -69, -68, -70, -71, -71, -72, -73,
-74, -74, -75, -76, -77, -78, -79, -80, -80, -82, -83, -83, -85, -85, -86, -88,
-88, -88, -89, -91, -91, -91, -93, -93, -94, -95, -94, -95, -95, -96, -96, -97,
-97, -97, -98, -98, -99, -99, -99, -100, -100, -101, -100, -100, -101, -101,
-102, -102, -102, -102, -102, -103, -103, -103, -104, -104, -105, -104, -104,
-105, -106, -106, -107, -107, -106, -108, -108, -108, -108, -109, -109, -110,
-110, -111, -111, -111, -112, -112, -113, -113, -114, -114, -114, -115, -115,
-115, -116, -116, -117, -117, -116, -118, -118, -117, -117, -118, -117, -117,
-118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -117, -117, -118,
-118, -118, -118, -118, -117, -117, -117, -118, -117, -117, -117, -117, -117,
-117, -116, -117, -117, -117, -117, -117, -114, -99, -76, -64, -66, -69, -70,
-71, -74, -71, -63, -61, -57, -50, -45, -43, -43, -40, -40, -41, -40, -38, -35,
-33, -29, -26, -24, -23, -21, -22, -22, -21, -19, -17, -16, -15, -13, -11, -10,
-10, -9, -8, -8, -7, -6, -5, -3, -3, -1, };