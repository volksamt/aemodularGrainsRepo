#define DATA_LENGTH 512
#define DATA AKWF_1084

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 11, 20, 20, 27, 32, 34, 35, 36, 35,
33, 33, 29, 27, 22, 21, 18, 15, 12, 12, 11, 9, 7, 4, 3, 3, 1, 0, -2, -3, -3, -4,
-4, -6, -6, -6, -8, -8, -9, -8, -10, -10, -10, -10, -10, -10, -11, -11, -9, -10,
-9, -10, -9, -8, -9, -9, -8, -10, -10, -10, -8, -7, -7, -5, 5, 9, 6, 8, 4, 3, 3,
1, -1, -2, -3, -3, -5, -4, -4, -4, -4, -4, -4, -3, -3, -2, 0, 0, 0, 0, 1, 2, 1,
2, 1, 2, 2, 3, 2, 2, 2, 3, 2, 4, 2, 3, 2, 3, 3, 3, 3, 3, 3, 2, 4, 1, 5, -29,
-44, -73, -70, -59, -59, -42, -34, -20, -14, -7, -7, 9, 12, 19, 24, 26, 27, 29,
30, 30, 29, 26, 25, 23, 22, 16, 14, 12, 11, 9, 7, 5, 5, 3, 2, 1, 1, 0, -2, -2,
-4, -5, -4, -5, -6, -6, -7, -7, -7, -8, -8, -8, -8, -8, -10, -10, -10, -9, -8,
-9, -7, -7, -6, -5, -5, -4, -5, -4, -4, -4, -5, 5, 16, 16, 10, 4, 0, 0, -7, -6,
-12, -19, -27, -36, -35, -31, -24, -21, -16, -12, -7, -6, -4, -2, 0, 3, 4, 5, 6,
8, 7, 8, 8, 8, 8, 8, 7, 7, 5, 6, 5, 6, 4, 6, 3, 4, 2, 5, 2, 4, 2, 3, 1, 3, 1, 1,
1, -43, -67, -104, -101, -80, -64, -60, -50, -28, -24, -8, -1, 13, 20, 24, 29,
35, 36, 40, 39, 39, 38, 35, 32, 30, 27, 22, 20, 16, 16, 13, 11, 9, 8, 6, 4, 3,
0, 1, -1, -2, -4, -4, -5, -7, -7, -8, -8, -9, -10, -10, -11, -10, -11, -12, -12,
-12, -11, -10, -11, -10, -10, -11, -10, -9, -9, -9, -10, -10, -10, -10, -8, -8,
-7, -5, 5, 9, 6, 7, 4, 3, 2, 0, 0, -3, -3, -4, -5, -4, -4, -4, -5, -4, -3, -3,
-1, -1, -1, 0, 0, 1, 0, 1, 1, 2, 2, 1, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 4, 4, 3, 3,
4, 3, 3, 4, 4, 4, 2, -30, -48, -71, -95, -60, -64, -52, -42, -29, -17, -23, -4,
-7, 4, 11, 18, 20, 21, 26, 23, 26, 25, 25, 24, 22, 22, 19, 17, 14, 11, 9, 6, 4,
2, 1, -1, -1, -3, -4, -3, -5, -5, -6, -6, -8, -7, -7, -8, -8, -8, -9, -9, -8,
-8, -9, -9, -9, -9, -8, -8, -9, -9, -8, -8, -11, -11, -11, -10, -8, -7, -6, -5,
2, 10, 21, 21, 14, 12, 7, 5, 0, -1, -5, -10, -13, -16, -18, -16, -17, -13, -9,
-8, -6, -3, -2, -1, 0, 1, 0, 2, 2, 3, 3, 3, 3, 3, 4, 4, 4, 5, 4, 4, 4, 3, 5, 3,
4, 3, 4, 2, 4, 2, 4, 2, 3, 2, 4, -1, -39, -59, -91, -83, -67, -52, -52, -40,
-23, -16, -5, };