#define DATA_LENGTH 512
#define DATA AKWF_1074

const PROGMEM int8_t DATA[DATA_LENGTH] = {-67, -77, -68, -70, -64, -65, -59,
-61, -55, -56, -51, -52, -45, -47, -41, -41, -37, -37, -31, -33, -27, -27, -22,
-22, -18, -17, -17, -8, -63, -10, 9, -2, 8, 0, 6, 1, 5, 1, 5, 1, 5, 2, 4, 1, 3,
2, 3, 3, 3, 3, 3, 3, 2, 4, 3, 3, 2, 3, 3, 3, 3, 4, 3, 3, 2, 4, 3, 4, 4, 3, 3, 3,
2, 3, 3, 4, 3, 3, 3, 3, 2, 2, 3, 3, 3, 2, 3, 3, 3, 2, 4, 3, 4, 2, 4, 1, 5, 1, 4,
1, 5, 1, 4, 1, 4, 1, 4, 2, 3, 3, 1, 8, -5, 20, -84, -32, 29, -3, 18, 0, 12, 1,
9, 2, 7, 1, 4, 1, 3, 3, 3, 2, 3, 3, 2, 3, 1, 3, 2, 3, 1, 3, 2, 3, 2, 2, 2, 3, 2,
3, 3, 3, 3, 2, 2, 3, 4, 2, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 2, 2, 3, 2, 3, 3, 3, 3,
3, 3, 3, 2, 2, 3, 2, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 2, 3, 2, 3, 2, 3, 3, 3, 3, 3,
2, 2, 2, 3, 3, 2, 3, 3, 3, 2, 3, 3, 3, 3, 3, 4, 3, 2, 3, 2, 3, 3, 2, 3, 3, 4, 3,
2, 3, 3, 3, 3, 3, 3, 2, 2, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3,
3, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 2, 3, 2, 3, 3, 2, 3, 3, 3, 3, 3,
3, 2, 3, 2, 3, 3, 2, 3, 2, 3, 3, 3, 3, 2, 3, 2, 3, 3, 2, 3, 3, 2, 3, 2, 3, 3, 2,
3, 3, 3, 3, 4, 2, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 4, 3, 3, 3, 3, 2, 3,
3, 2, 3, 4, 3, 3, 3, 3, 4, 3, 3, 3, 3, 4, 3, 2, 3, 3, 3, 3, 3, 3, 2, 3, 2, 3, 3,
4, 3, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 2, 2, 3, 2, 3, 4, 3, 2, 3, 3, 4, 2, 3, 2,
3, 3, 2, 2, 3, 3, 3, 2, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 4, 3, 3, 2, 3,
3, 3, 2, 3, 3, 4, 3, 3, 2, 3, 2, 3, 2, 2, 3, 3, 4, 3, 4, 3, 3, 3, 3, 2, 3, 3, 3,
3, 3, 3, 4, 4, 3, 4, 3, 3, 3, 2, 3, 3, 3, 3, 3, 2, 2, 3, 4, 2, 3, 3, 3, 3, 3, 3,
3, 3, 3, 2, 3, 1, 6, 13, -7, -9, -5, -3, 1, 2, 3, 2, 3, 2, 2, 2, 3, 2, 2, 3, 3,
3, 3, 3, 3, 3, 3, 2, 3, 3, 2, 2, 3, 3, 3, };