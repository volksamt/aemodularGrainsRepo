#define DATA_LENGTH 512
#define DATA AKWF_1081

const PROGMEM int8_t DATA[DATA_LENGTH] = {-5, -10, -16, -22, -28, -34, -41, -46,
-51, -58, -63, -70, -73, -83, -84, -96, -94, -110, -101, -128, -64, 20, 4, 20,
18, 27, 28, 36, 37, 46, 48, 55, 56, 65, 64, 75, 71, 86, 78, 99, 81, 120, 44,
-122, -85, -84, -72, -53, 2, -3, -5, -3, -8, -2, -3, -9, -12, -10, -15, -13,
-17, -15, -20, -17, -22, -19, -24, -23, -27, -3, 1, 0, 1, 0, 2, 1, 2, 2, 4, 2,
3, 3, 5, 2, 5, 4, 5, 5, 6, 5, 6, 5, 6, 5, 0, -1, -1, -2, -3, -3, -3, -5, 1, 6,
3, 4, 2, 5, -5, -1, 3, 0, 0, -1, -1, -2, -3, -4, -4, -5, -6, -7, -7, -8, -9,
-10, -11, -11, -10, -14, -8, 2, -1, 1, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 1, 1, 1,
0, 1, 1, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 0, 0, -1, 0, 0, -1, -1,
-1, -1, 0, 0, 0, 1, 0, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, -1, -1, -2, -1,
-2, -2, -2, -2, -1, -2, -2, -2, -2, -3, -2, -2, -3, -2, -1, -2, -2, -2, -2, -2,
-1, -2, -1, -1, -1, -1, -1, -2, -1, -1, 0, -1, -1, -1, -1, 0, -1, 0, -1, -1, 0,
-1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 1, 1, 0, 0, 1,
1, 1, 2, 1, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 2, 2, 1, 1, 1, 1, 2, 2, 1, 1, 1, 1, 0,
1, 1, 1, 0, 1, 0, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 1, 1, -1, 1, 0, 0, 0, 0, 0, 0,
0, 1, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0,
0, -1, 0, 0, -1, 0, 1, 1, 0, -1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0,
1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1,
0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 1, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0,
-1, 0, 0, 0, 1, 0, 0, -1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0,
0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, };