#define DATA_LENGTH 512
#define DATA AKWF_1017

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 6, 7, 10, 12, 14, 17, 20, 22,
25, 28, 31, 34, 37, 41, 44, 46, 49, 52, 55, 58, 61, 64, 67, 70, 72, 76, 79, 83,
85, 88, 91, 92, 96, 98, 99, 102, 104, 106, 109, 110, 112, 113, 114, 115, 116,
117, 119, 119, 118, 119, 119, 118, 118, 118, 117, 116, 116, 115, 114, 114, 112,
110, 110, 108, 104, 103, 101, 98, 96, 94, 90, 88, 87, 82, 79, 75, 74, 71, 68,
65, 62, 58, 55, 51, 48, 46, 42, 38, 35, 32, 29, 25, 23, 20, 17, 14, 11, 7, 5, 1,
-3, -5, -8, -12, -14, -16, -18, -20, -22, -25, -27, -30, -30, -33, -34, -36,
-38, -40, -41, -42, -43, -45, -45, -46, -47, -48, -49, -49, -51, -52, -52, -54,
-54, -55, -57, -57, -58, -59, -59, -59, -59, -60, -60, -60, -62, -62, -62, -62,
-63, -63, -64, -64, -64, -64, -64, -63, -64, -63, -64, -63, -64, -64, -64, -63,
-64, -62, -63, -62, -62, -62, -62, -61, -59, -59, -58, -59, -59, -58, -59, -58,
-58, -58, -57, -57, -57, -56, -55, -55, -54, -54, -54, -53, -53, -54, -53, -53,
-53, -53, -52, -52, -51, -51, -51, -50, -49, -49, -49, -49, -49, -49, -50, -49,
-49, -49, -48, -48, -48, -47, -47, -46, -45, -44, -45, -44, -43, -43, -42, -42,
-42, -41, -40, -39, -38, -38, -37, -35, -33, -32, -31, -29, -27, -26, -24, -23,
-21, -19, -18, -15, -12, -10, -8, -5, -2, 0, 2, 4, 7, 10, 11, 14, 16, 18, 21,
24, 26, 28, 32, 34, 37, 40, 43, 47, 48, 51, 54, 56, 59, 63, 65, 67, 71, 74, 76,
80, 83, 85, 88, 90, 92, 95, 96, 98, 100, 101, 104, 104, 107, 108, 109, 110, 111,
112, 112, 112, 113, 113, 112, 112, 111, 110, 110, 109, 109, 107, 106, 106, 104,
103, 101, 99, 97, 95, 93, 91, 89, 85, 81, 79, 77, 75, 72, 69, 67, 64, 62, 59,
56, 52, 50, 45, 43, 40, 36, 32, 30, 28, 25, 21, 19, 16, 13, 10, 7, 5, 2, -2, -4,
-8, -10, -13, -16, -18, -20, -22, -25, -26, -28, -29, -31, -34, -35, -37, -39,
-40, -41, -43, -45, -44, -46, -47, -47, -48, -49, -50, -51, -51, -52, -53, -54,
-55, -55, -56, -56, -57, -57, -58, -58, -58, -58, -58, -59, -59, -61, -61, -61,
-61, -61, -61, -62, -62, -62, -61, -61, -60, -60, -60, -60, -59, -59, -60, -59,
-59, -59, -59, -58, -58, -58, -57, -55, -56, -55, -54, -55, -54, -53, -54, -53,
-53, -53, -53, -52, -51, -50, -50, -50, -49, -49, -49, -49, -48, -48, -48, -48,
-49, -48, -48, -48, -47, -47, -47, -47, -46, -46, -46, -46, -45, -45, -45, -46,
-46, -45, -46, -45, -44, -45, -44, -44, -43, -42, -42, -42, -41, -40, -40, -39,
-39, -38, -37, -36, -35, -34, -33, -31, -30, -29, -27, -26, -24, -23, -21, -19,
-18, -16, -15, -12, -9, -8, -6, -3, 0, };