#define DATA_LENGTH 512
#define DATA AKWF_1087

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 3, 4, 4, 6, 7, 9, 10, 11, 12,
13, 13, 16, 16, 16, 19, 20, 20, 21, 21, 22, 24, 25, 26, 27, 28, 29, 29, 31, 32,
32, 32, 33, 34, 34, 35, 36, 36, 38, 39, 40, 40, 41, 43, 43, 43, 44, 45, 45, 45,
46, 47, 48, 48, 49, 50, 50, 51, 51, 51, 52, 52, 53, 55, 55, 54, 54, 56, 56, 58,
59, 59, 59, 61, 61, 61, 60, 61, 60, 63, 63, 64, 64, 64, 65, 65, 65, 65, 65, 66,
66, 66, 66, 66, 68, 69, 68, 67, 68, 69, 69, 68, 68, 68, 68, 68, 69, 69, 70, 70,
70, 70, 70, 70, 70, 71, 71, 71, 72, 70, 71, 71, 70, 71, 69, 70, 69, 70, 69, 69,
68, 69, 67, 67, 67, 68, 68, 67, 66, 66, 66, 65, 65, 65, 64, 64, 63, 63, 63, 63,
62, 62, 62, 63, 63, 62, 63, 62, 62, 62, 61, 61, 61, 60, 60, 60, 58, 59, 58, 57,
58, 57, 56, 56, 57, 55, 55, 54, 53, 53, 53, 52, 52, 51, 52, 51, 50, 51, 49, 49,
48, 48, 47, 46, 45, 45, 45, 44, 43, 43, 43, 42, 42, 41, 41, 40, 40, 39, 39, 39,
38, 38, 38, 37, 37, 36, 36, 35, 35, 35, 33, 33, 32, 31, 29, 29, 28, 27, 26, 26,
25, 24, 23, 23, 23, 22, 22, 21, 20, 20, 19, 19, 18, 17, 17, 17, 17, 16, 16, 15,
15, 13, 12, 12, 11, 11, 10, 9, 9, 8, 8, 8, 6, 6, 6, 6, 5, 4, 4, 4, 3, 2, 2, 1,
1, 0, 0, -1, 0, -1, -1, -2, -3, -2, -4, -4, -4, -5, -6, -6, -7, -8, -8, -10, -9,
-10, -10, -10, -11, -12, -13, -13, -12, -13, -15, -16, -16, -16, -17, -18, -18,
-18, -18, -18, -19, -20, -20, -21, -21, -22, -23, -22, -23, -23, -24, -23, -23,
-24, -24, -25, -25, -26, -26, -27, -26, -26, -27, -27, -25, -27, -28, -28, -27,
-28, -28, -29, -29, -31, -31, -31, -31, -31, -31, -31, -31, -31, -31, -31, -32,
-32, -33, -33, -33, -32, -33, -32, -34, -29, -54, -94, -88, -81, -79, -81, -85,
-89, -92, -95, -98, -101, -104, -106, -109, -109, -112, -113, -114, -115, -116,
-117, -118, -119, -120, -119, -119, -119, -118, -117, -118, -118, -116, -115,
-115, -114, -113, -113, -113, -111, -110, -109, -109, -109, -108, -107, -106,
-106, -104, -104, -102, -102, -101, -100, -99, -97, -97, -95, -94, -94, -93,
-92, -90, -90, -88, -88, -87, -86, -84, -84, -83, -82, -81, -80, -79, -79, -77,
-76, -75, -73, -73, -72, -71, -70, -68, -66, -65, -65, -63, -62, -61, -59, -57,
-57, -55, -54, -53, -53, -51, -50, -49, -47, -45, -46, -44, -41, -40, -39, -38,
-38, -36, -35, -35, -32, -32, -30, -30, -28, -27, -26, -25, -23, -22, -21, -22,
-20, -19, -18, -18, -16, -16, -14, -12, -10, -9, -8, -6, -4, -4, -2, -1, 0, };