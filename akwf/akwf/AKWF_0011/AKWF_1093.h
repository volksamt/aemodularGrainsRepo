#define DATA_LENGTH 512
#define DATA AKWF_1093

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0,
0, 0, 0, -1, 0, 2, 4, 3, 4, 3, 4, 2, 4, 2, 6, 13, 13, 13, 13, 13, 13, 13, 13,
13, 13, 13, 16, 16, 16, 17, 16, 17, 16, 16, 15, 16, 16, 17, 16, 18, 13, 22, 48,
46, 46, 53, 58, 57, 57, 57, 57, 57, 57, 58, 56, 57, 57, 57, 56, 56, 56, 57, 57,
57, 56, 56, 57, 57, 57, 57, 57, 57, 57, 57, 58, 45, 40, 41, 41, 41, 41, 41, 40,
42, 42, 40, 41, 41, 41, 41, 42, 41, 41, 41, 42, 42, 41, 41, 41, 41, 41, 43, 39,
65, 74, 70, 73, 72, 73, 71, 73, 72, 73, 71, 73, 70, 74, 69, 76, 54, 18, 27, 24,
25, 25, 25, 25, 26, 25, 26, 26, 25, 25, 25, 25, 26, 26, 25, 25, 25, 25, 25, 26,
25, 29, 29, 28, 28, 29, 29, 29, 29, 29, 28, 28, 28, 28, 29, 32, 33, 32, 32, 31,
32, 32, 31, 31, 32, 32, 32, 31, 32, 32, 32, 31, 32, 35, 35, 35, 35, 35, 35, 34,
34, 35, 35, 35, 34, 37, 45, 45, 44, 45, 45, 45, 45, 47, 48, 48, 48, 48, 48, 48,
47, 48, 47, 48, 48, 48, 48, 48, 48, 48, 47, 48, 48, 49, 49, 48, 49, 48, 48, 49,
58, 58, 59, 57, 58, 57, 58, 57, 57, 57, 57, 58, 58, 58, 57, 58, 57, 58, 56, 59,
62, 72, 61, 56, 47, 58, 42, 69, -3, -118, -94, -106, -99, -104, -100, -102,
-101, -101, -101, -101, -103, -100, -102, -100, -103, -100, -103, -96, -92, -91,
-92, -92, -92, -91, -92, -91, -92, -92, -91, -92, -91, -92, -92, -92, -91, -92,
-91, -91, -92, -89, -89, -89, -88, -89, -89, -89, -88, -89, -81, -78, -79, -78,
-79, -78, -79, -79, -79, -78, -79, -78, -78, -77, -75, -75, -75, -76, -76, -76,
-75, -76, -76, -75, -76, -76, -75, -74, -71, -72, -73, -73, -72, -72, -72, -72,
-73, -72, -72, -72, -72, -72, -73, -72, -73, -71, -69, -70, -69, -69, -68, -69,
-69, -68, -68, -69, -69, -69, -69, -68, -70, -69, -69, -69, -70, -68, -66, -66,
-66, -64, -68, -64, -68, -61, -89, -121, -114, -117, -115, -117, -115, -117,
-115, -117, -115, -117, -114, -118, -110, -82, -86, -85, -86, -85, -84, -85,
-85, -85, -85, -85, -84, -85, -85, -85, -85, -85, -85, -85, -85, -86, -85, -85,
-84, -86, -84, -94, -102, -100, -101, -100, -101, -100, -100, -100, -100, -101,
-101, -101, -101, -101, -101, -101, -101, -101, -101, -101, -101, -100, -100,
-100, -101, -100, -102, -97, -90, -91, -90, -91, -91, -91, -90, -91, -90, -91,
-90, -92, -90, -62, -59, -61, -59, -59, -57, -58, -57, -58, -57, -57, -56, -57,
-56, -57, -57, -56, -58, -56, -57, -54, -46, -46, -46, -47, -48, -47, -45, -43,
-45, -43, -45, -43, -45, -43, -45, -43, -45, -43, -44, -43, -5, };