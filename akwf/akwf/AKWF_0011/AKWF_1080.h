#define DATA_LENGTH 512
#define DATA AKWF_1080

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 4, 6, 7, 9, 11, 12, 14, 15, 17,
19, 21, 22, 24, 25, 27, 28, 30, 32, 32, 35, 36, 38, 40, 41, 42, 44, 45, 47, 49,
51, 52, 53, 55, 56, 58, 60, 61, 62, 63, 61, 59, 57, 56, 54, 52, 51, 50, 48, 45,
45, 43, 41, 40, 38, 36, 35, 34, 32, 31, 28, 27, 25, 24, 23, 22, 19, 18, 16, 15,
13, 11, 10, 8, 7, 5, 4, 1, -3, -6, -10, -13, -17, -19, -22, -25, -27, -31, -34,
-37, -40, -42, -45, -50, -51, -54, -57, -61, -63, -67, -70, -73, -76, -78, -82,
-84, -88, -89, -94, -94, -101, -100, -108, -104, -117, -106, -128, -76, 15, -4,
8, 3, 10, 7, 10, 11, 12, 13, 15, 16, 17, 19, 20, 23, 23, 26, 25, 29, -21, -26,
-18, -16, -9, -7, -1, 2, 7, 11, 16, 19, 25, 28, 33, 35, 42, 45, 50, 53, 51, 50,
49, 47, 46, 45, 43, 43, 40, 40, 38, 37, 35, 34, 33, 32, 30, 29, 28, 26, 25, 23,
23, 20, 20, 18, 17, 16, 15, 13, 12, 11, 9, 8, 7, 6, 4, 2, 1, 0, -1, 0, 1, 0, 1,
-2, -4, -6, -8, -9, -12, -12, -14, -16, -18, -20, -22, -24, -26, -28, -30, -32,
-33, -36, -36, -39, -40, -43, -44, -46, -48, -49, -51, -54, -56, -56, -59, -60,
-63, -65, -67, -69, -70, -72, -74, -72, -70, -68, -67, -64, -64, -61, -59, -57,
-56, -53, -52, -51, -49, -46, -44, -43, -41, -40, -37, -36, -33, -32, -30, -28,
-26, -24, -22, -20, -18, -17, -15, -13, -11, -9, -8, -5, -5, -2, 0, 0, 0, 0, 0,
1, -1, -1, 0, -1, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, -1, 1, 3, 6, 8, 10, 12, 14, 17, 18, 20, 22, 24, 27, 29, 31, 34, 35, 38,
40, 41, 44, 46, 48, 51, 52, 55, 56, 58, 61, 62, 66, 66, 70, 70, 75, 73, 81, 74,
92, 51, -13, 1, -10, -5, -11, -10, -15, -14, -18, -18, -20, -22, -23, -27, 21,
26, 17, 17, 10, 8, 3, 1, -5, -9, -13, -16, -19, -24, -27, -32, -35, -42, -41,
-53, -29, 7, -3, 3, 0, 2, 1, 2, 1, 2, 3, 2, 3, 3, 3, 2, 3, 3, 4, 3, 4, 4, 4, 4,
4, 4, 4, 4, 5, 5, 6, 5, 6, 4, -2, -1, -1, -2, -2, -4, -2, 3, 2, 1, 0, -1, -1,
-2, -3, -4, -4, -5, -6, -7, -7, -8, -8, -9, -9, -10, -11, -12, -13, -13, -15,
-14, -16, -16, -18, -17, -19, -19, -20, -22, -22, -21, -21, -20, -20, -19, -18,
-17, -18, -17, -17, -15, -15, -15, -14, -13, -13, -12, -11, -11, -11, -9, -10,
-8, -8, -8, -8, -7, -6, -6, -6, -5, -4, -4, -3, -2, -2, -1, -1, 0, 0, 0, 0, 1,
1, 0, 0, };