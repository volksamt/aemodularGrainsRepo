#define DATA_LENGTH 512
#define DATA AKWF_1016

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 6, 61, 99, 91, 94, 92, 94, 90, 91,
90, 90, 89, 89, 88, 88, 87, 87, 87, 86, 85, 85, 85, 84, 85, 83, 83, 82, 81, 81,
80, 80, 80, 79, 79, 79, 76, 77, 76, 75, 75, 75, 74, 73, 73, 72, 72, 70, 71, 70,
69, 70, 69, 67, 68, 67, 66, 66, 65, 65, 64, 63, 63, 62, 62, 60, 60, 60, 58, 58,
58, 58, 56, 56, 55, 54, 54, 53, 52, 53, 51, 50, 49, 50, 49, 49, 47, 47, 46, 46,
45, 44, 44, 43, 42, 41, 42, 39, 42, 38, 43, 25, 2, 7, 4, 6, 4, 5, 5, 5, 5, 4, 5,
5, 5, 4, 5, 4, 5, 5, 5, 4, 5, 4, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 4, 5, 4, 5, 5, 5,
5, 5, 4, 4, 4, 4, 4, 5, 4, 4, 4, 5, 4, 5, 4, 5, 5, 4, 5, 4, 4, 4, 5, 3, 6, 1,
24, 43, 37, 42, 40, 42, 40, 43, 42, 45, 43, 44, 45, 47, 47, 47, 48, 48, 49, 50,
50, 50, 51, 52, 52, 53, 54, 55, 55, 56, 57, 58, 57, 58, 59, 59, 60, 60, 61, 62,
63, 64, 64, 65, 65, 65, 66, 67, 68, 69, 68, 69, 69, 70, 70, 71, 72, 73, 73, 75,
75, 75, 76, 76, 77, 77, 78, 79, 80, 80, 80, 81, 82, 82, 84, 83, 85, 85, 86, 86,
87, 87, 89, 87, 89, 88, 91, 89, 93, 90, 94, 92, 95, 93, 95, 96, 96, 99, 93, 108,
-12, -61, -59, -82, -86, -108, -115, -121, -115, -119, -114, -115, -113, -113,
-111, -112, -109, -108, -108, -107, -107, -104, -104, -103, -103, -100, -101,
-99, -99, -97, -98, -96, -95, -93, -92, -92, -91, -89, -89, -88, -87, -87, -86,
-85, -83, -82, -82, -81, -79, -79, -78, -77, -76, -74, -74, -74, -72, -72, -71,
-70, -68, -67, -67, -66, -64, -64, -63, -62, -61, -59, -59, -59, -57, -56, -55,
-54, -53, -52, -51, -51, -49, -49, -48, -46, -46, -44, -45, -42, -44, -39, -45,
-17, 11, 3, 7, 3, 6, 4, 5, 5, 5, 4, 5, 4, 4, 4, 4, 5, 5, 5, 5, 5, 4, 5, 5, 4, 4,
5, 4, 5, 5, 5, 4, 5, 5, 5, 4, 4, 4, 4, 5, 5, 4, 4, 4, 5, 5, 5, 4, 5, 4, 5, 5, 4,
5, 4, 5, 5, 5, 4, 6, 3, 6, 2, 10, -19, -45, -38, -43, -41, -43, -43, -45, -46,
-48, -48, -49, -50, -50, -51, -52, -54, -54, -55, -56, -58, -58, -59, -59, -61,
-61, -63, -64, -65, -66, -67, -67, -69, -68, -71, -71, -72, -73, -74, -74, -76,
-77, -78, -78, -79, -80, -81, -82, -84, -84, -85, -86, -87, -88, -89, -90, -90,
-91, -93, -94, -95, -95, -96, -97, -98, -98, -100, -101, -102, -102, -103, -105,
-105, -107, -106, -108, -109, -110, -110, -112, -111, -114, -113, -116, -114,
-119, -112, -98, -80, -68, -44, };