#define DATA_LENGTH 512
#define DATA AKWF_1027

const PROGMEM int8_t DATA[DATA_LENGTH] = {20, 28, 31, 35, 36, 39, 40, 42, 43,
45, 45, 47, 47, 48, 49, 49, 50, 51, 52, 52, 50, 52, 50, 52, 49, 36, 34, 33, 33,
32, 32, 32, 31, 32, 31, 31, 31, 30, 33, 28, 50, 78, 78, 83, 83, 85, 86, 87, 88,
88, 89, 89, 92, 88, 89, 85, 91, 107, 107, 109, 110, 109, 111, 110, 110, 109,
109, 109, 109, 108, 110, 107, 108, 108, 108, 109, 108, 108, 108, 108, 108, 108,
107, 108, 107, 107, 108, 107, 105, 92, 89, 89, 87, 87, 85, 87, 85, 86, 84, 86,
84, 85, 82, 86, 74, 48, 46, 43, 41, 39, 38, 38, 37, 37, 35, 36, 34, 34, 32, 32,
34, 14, 7, 7, 4, 3, 1, 0, -2, -2, -4, -5, -7, -7, -8, -8, -9, -10, -11, -11,
-11, -12, -13, -13, -13, -14, -14, -14, -15, -15, -16, -15, -19, -33, -35, -35,
-36, -38, -39, -39, -39, -39, -41, -42, -41, -43, -41, -45, -21, 4, 3, 8, 9, 10,
11, 13, 13, 13, 13, 13, 14, 13, 14, 11, 17, 32, 33, 35, 36, 36, 35, 34, 34, 34,
34, 35, 34, 33, 34, 33, 35, 33, 34, 33, 34, 32, 33, 34, 33, 33, 33, 34, 32, 33,
31, 34, 29, 17, 15, 14, 13, 12, 11, 12, 11, 11, 10, 12, 8, 12, 7, 13, -2, -28,
-29, -32, -33, -35, -36, -37, -38, -39, -39, -41, -40, -42, -39, -47, -15, 36,
33, 43, 42, 48, 45, 51, 42, 9, 8, 6, 5, 3, 3, 2, 2, 1, 0, 1, -1, -1, -2, -2, -3,
-2, -3, -4, -6, -5, -8, -5, -10, -24, -26, -27, -28, -29, -30, -30, -32, -32,
-33, -34, -33, -34, -33, -38, -12, 12, 11, 16, 15, 18, 18, 19, 19, 20, 20, 19,
20, 20, 20, 17, 26, 40, 40, 41, 41, 41, 42, 41, 41, 40, 40, 40, 40, 39, 40, 39,
39, 39, 39, 39, 38, 38, 39, 38, 37, 38, 38, 37, 37, 37, 37, 38, 33, 21, 19, 18,
16, 17, 16, 15, 14, 15, 14, 14, 13, 14, 11, 15, -1, -25, -25, -30, -30, -32,
-34, -34, -36, -36, -38, -38, -39, -38, -39, -39, -39, -60, -64, -65, -67, -69,
-71, -72, -75, -75, -77, -77, -78, -79, -80, -81, -82, -82, -83, -83, -84, -84,
-86, -86, -87, -86, -87, -87, -88, -87, -89, -89, -93, -107, -107, -109, -110,
-111, -111, -112, -113, -114, -113, -115, -114, -116, -114, -119, -90, -68, -70,
-64, -65, -62, -62, -60, -61, -60, -59, -61, -59, -60, -60, -63, -54, -41, -40,
-39, -39, -37, -38, -38, -38, -38, -39, -40, -39, -39, -39, -40, -39, -39, -40,
-40, -39, -40, -40, -40, -40, -40, -41, -41, -40, -40, -40, -39, -44, -56, -58,
-59, -60, -60, -61, -60, -62, -62, -63, -61, -64, -62, -65, -60, -79, -102,
-102, -105, -107, -107, -109, -110, -110, -112, -111, -113, -112, -114, -112,
-119, -80, -36, -38, -29, -31, -25, -28, -20, };