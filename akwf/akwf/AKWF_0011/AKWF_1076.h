#define DATA_LENGTH 512
#define DATA AKWF_1076

const PROGMEM int8_t DATA[DATA_LENGTH] = {20, 24, 23, 25, 24, 25, 26, 27, 26,
28, 28, 29, 29, 29, 29, 30, 31, 31, 31, 32, 33, 32, 34, 34, 34, 34, 35, 35, 36,
35, 36, 36, 36, 37, 38, 38, 38, 38, 37, 40, 6, -3, 1, -2, 2, 0, 1, -1, 2, 0, 1,
1, 1, 2, 2, 1, 2, 2, 2, 2, 3, 3, 4, 3, 4, 4, 4, 5, 5, 5, 6, 6, 6, 7, 7, 8, 8, 8,
9, 9, 9, 10, 10, 11, 11, 12, 12, 12, 13, 13, 15, 16, 15, 16, 16, 16, 17, 17, 19,
19, 20, 19, 22, 20, 23, 20, 26, 10, 11, 27, 22, 26, 24, 27, 25, 27, 27, 27, 28,
27, 29, 29, 30, 30, 31, 30, 32, 31, 33, 31, 34, 33, 34, 33, 35, 34, 36, 35, 36,
35, 36, 38, 36, 38, 36, 39, 33, 44, 9, -23, -8, -10, -3, -3, 1, 0, 1, -1, 0, 1,
0, 0, -1, 0, 0, 1, 0, 0, 0, 1, -1, 0, 0, 1, 0, -1, 0, -1, -1, 0, 0, -1, -1, 0,
0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, -1, 1, 0, -1, 0, 0, 0, 0, 1, 1, 0, 1, 0, 0,
0, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 0, -1, 1, -1, 0, 0, 1, 0, 0, 1, 1,
2, 1, 2, 1, 2, 2, 2, 3, 2, 3, 2, 4, 4, 4, 4, 5, 5, 6, 6, 7, 5, 7, 7, 7, 7, 9, 9,
9, 10, 10, 10, 11, 11, 12, 12, 13, 14, 14, 15, 15, 16, 15, 18, 16, 19, 16, 20,
16, 21, 17, 22, 17, 25, 17, 28, 10, -119, -119, -115, -118, -112, -113, -107,
-106, -100, -100, -92, -90, -83, -80, -73, -70, -63, -58, -53, -47, -42, -35,
-32, -26, -23, -26, -31, -37, -43, -51, -56, -64, -69, -78, -83, -92, -94, -106,
-102, -117, -107, -128, -67, 18, -8, 6, -4, 4, -3, 2, -2, 2, -2, 1, -4, -3, -10,
-8, -22, 0, 39, 16, 35, -4, -1, 2, -1, 2, -1, 1, -1, 1, -1, 1, -2, 1, -1, 0, -1,
1, -2, 0, 0, 0, 0, 0, 1, -1, 0, -1, 0, -1, 1, -1, 0, -1, 0, 0, 1, 0, 0, 0, 1, 0,
0, 0, -1, 0, -1, 1, -1, 0, -1, 1, -2, 2, -2, 2, -2, 2, -3, -27, -32, -24, 4, -2,
0, -1, 0, 1, -1, 1, -1, 1, -1, 1, -1, 1, 0, 1, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0,
-1, -1, 0, 0, 1, 0, 0, -1, 0, 0, 0, -1, 0, 1, 0, 0, -1, 0, 0, 0, -1, 0, 1, -1,
0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
1, 0, -1, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, -1, 1, };