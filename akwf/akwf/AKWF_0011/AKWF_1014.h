#define DATA_LENGTH 512
#define DATA AKWF_1014

const PROGMEM int8_t DATA[DATA_LENGTH] = {40, 121, 116, 114, 110, 108, 105, 102,
100, 95, 95, 90, 89, 85, 83, 79, 77, 75, 73, 69, 66, 64, 61, 59, 55, 53, 49, 49,
43, 45, 31, -2, 2, -1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0, -1, 1, 0, 1, 0, 1, 1,
0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 1,
0, 1, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, 0, 0, 0, 0, 0, 1, 0,
0, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 1, 0, 1, 0, 1, 1, 1, 0, 0,
0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1,
0, 0, 0, 0, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 1,
0, 1, 0, 0, 1, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, -1, 1, -1, 1, -1, 1, -1, 1, -1, 1,
-1, 1, -1, 2, 35, 41, 42, 46, 49, 52, 54, 58, 61, 63, 68, 69, 74, 75, 80, 81,
87, 86, 92, 93, 98, 98, 105, 104, 109, 112, 114, 104, -88, -128, -106, -116,
-103, -109, -98, -102, -94, -96, -88, -88, -83, -82, -78, -76, -72, -69, -67,
-64, -60, -58, -55, -52, -48, -47, -42, -44, -13, 5, -3, 3, -2, 1, -2, 1, 0, 1,
0, 0, -1, 1, 1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0,
-1, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 1, 1, 0,
0, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, -1, 0, 0, 1, 0, 1, 1, 0, 0,
1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1,
-1, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 1, 0, 0, 1, 0, 0,
1, 0, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 1, 0,
0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, -1, 0, 0, 1, 1, 1, 1, 1, 0, 0, 1, 0, 1, 0,
0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 2, -25, -42, -39, -46, -45, -51, -51,
-56, -57, -60, -64, -66, -70, -72, -76, -76, -82, -82, -89, -86, -95, -91, -100,
-95, -107, -101, -112, -107, -118, -113, -59, -91, };