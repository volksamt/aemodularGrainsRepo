#define DATA_LENGTH 512
#define DATA AKWF_1039

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 3, 6, 10, 13, 16, 20, 22, 26, 30,
33, 36, 39, 43, 45, 49, 53, 55, 59, 63, 66, 69, 72, 75, 78, 82, 85, 88, 92, 95,
98, 102, 105, 108, 112, 116, 118, 118, 118, 117, 116, 116, 113, 111, 109, 106,
103, 100, 98, 95, 93, 90, 87, 85, 82, 79, 77, 74, 72, 69, 66, 64, 61, 59, 56,
54, 51, 48, 45, 44, 40, 38, 35, 33, 30, 27, 25, 22, 19, 16, 15, 12, 10, 7, 4, 1,
-2, -5, -7, -9, -12, -15, -18, -20, -22, -25, -27, -30, -33, -35, -38, -41, -43,
-46, -49, -51, -54, -56, -57, -56, -54, -53, -52, -51, -49, -49, -47, -45, -44,
-43, -41, -39, -39, -38, -36, -35, -34, -32, -32, -29, -28, -26, -26, -25, -23,
-22, -21, -19, -18, -16, -15, -14, -13, -11, -11, -9, -8, -6, -5, -4, -2, 0, 1,
2, 4, 5, 7, 8, 8, 10, 11, 11, 14, 15, 16, 15, 12, 9, 8, 5, 1, 0, -3, -5, -8,
-11, -14, -16, -19, -21, -25, -27, -30, -32, -34, -35, -35, -36, -36, -37, -38,
-38, -38, -39, -41, -41, -41, -43, -42, -43, -44, -45, -45, -46, -47, -48, -48,
-48, -49, -49, -51, -51, -52, -52, -53, -54, -54, -55, -56, -56, -57, -58, -59,
-59, -59, -60, -61, -61, -62, -63, -63, -65, -65, -66, -67, -67, -65, -62, -59,
-56, -54, -50, -46, -42, -40, -37, -32, -30, -26, -24, -20, -16, -14, -11, -7,
-4, -1, 3, 6, 9, 12, 15, 19, 22, 26, 29, 33, 35, 39, 41, 45, 49, 52, 55, 59, 62,
64, 68, 72, 75, 79, 82, 85, 90, 92, 96, 99, 102, 106, 108, 112, 115, 118, 118,
118, 117, 117, 116, 113, 110, 108, 105, 103, 100, 98, 95, 93, 91, 87, 84, 82,
80, 76, 74, 72, 69, 67, 64, 61, 59, 57, 53, 50, 48, 46, 43, 40, 38, 36, 33, 29,
27, 24, 22, 19, 17, 14, 12, 8, 5, 3, 1, -1, -4, -8, -10, -13, -16, -17, -20,
-23, -25, -27, -31, -34, -36, -38, -41, -44, -46, -49, -52, -55, -57, -57, -56,
-55, -53, -52, -50, -50, -48, -47, -46, -44, -43, -42, -40, -39, -37, -37, -35,
-34, -32, -30, -29, -28, -27, -25, -24, -23, -22, -21, -18, -18, -17, -15, -14,
-13, -10, -10, -8, -7, -5, -5, -4, -2, 0, 1, 2, 4, 5, 6, 7, 9, 10, 12, 13, 14,
15, 16, 15, 12, 10, 7, 4, 1, -1, -4, -6, -9, -12, -14, -17, -19, -22, -24, -27,
-30, -33, -33, -34, -35, -35, -37, -36, -37, -39, -39, -40, -41, -41, -41, -42,
-43, -43, -44, -45, -45, -46, -46, -47, -48, -48, -50, -50, -50, -51, -52, -52,
-53, -54, -55, -55, -55, -56, -57, -58, -58, -60, -60, -61, -62, -61, -62, -62,
-64, -64, -64, -66, -66, -67, -66, -61, -58, -55, -51, -49, -45, -42, -38, -35,
-32, -28, -25, -22, -19, -16, -13, -10, -6, -2, };