#define DATA_LENGTH 512
#define DATA AKWF_1088

const PROGMEM int8_t DATA[DATA_LENGTH] = {23, 16, 15, 15, -15, -6, 5, 9, 11, 12,
12, 13, 14, 16, 16, 15, 15, 14, 14, 16, 15, 14, 15, 17, 19, 16, 16, 16, 15, 15,
16, 15, 12, 13, 14, 13, 12, 10, 9, 8, 10, 8, 8, 9, 9, 8, 7, 6, 5, 5, 5, 1, 1, 5,
7, 5, 3, -1, -2, 0, 1, 0, 0, -2, -2, -1, 2, 4, -3, -4, 0, 1, 2, -1, 0, 0, 0, 0,
-1, 0, 2, 0, 2, 3, 0, -3, 0, 1, 1, 0, 1, -1, 1, 2, 1, 3, 3, 3, 2, 3, 5, 5, 3, 3,
5, 5, 7, 7, 6, 9, 8, 9, 8, 7, 10, 8, 11, 10, 11, 13, 10, 10, 10, 12, 12, 12, 12,
10, 11, 18, 33, 26, 7, 9, 13, 16, 17, 19, 19, 18, 18, 18, 18, 19, 20, 19, 21,
22, 17, 15, 17, 19, 20, 20, 19, 19, 18, 18, 18, 20, 21, 18, 14, 17, 16, 17, 17,
16, 17, 17, 18, 17, 16, 16, 15, 17, 17, 15, 16, 13, 11, 15, 18, 15, 11, 9, 12,
14, 16, 16, 13, 11, 11, 11, 14, 17, 10, 8, 12, 12, 11, 13, 14, 13, 13, 12, 7, 9,
12, 12, 15, 14, 9, 9, 13, 14, 15, 12, 12, 14, 14, 13, 12, 9, 9, 10, 11, 15, 13,
12, 11, 10, 9, 10, 10, 8, 9, 10, 8, 11, 8, 8, 11, 10, 7, 8, 9, 11, 10, 12, 6,
19, 80, 77, 66, 71, 88, 101, 114, 116, 57, 72, 103, 108, 112, 111, 114, 112,
114, 112, 113, 110, 108, 105, 106, 105, 103, 98, 96, 95, 92, 89, 86, 84, 80, 75,
72, 68, 64, 61, 57, 56, 53, 49, 45, 43, 40, 35, 34, 31, 26, 24, 18, 17, 12, 9,
8, 1, 0, -1, -3, -6, -10, -14, -14, -14, -17, -23, -25, -27, -29, -28, -30, -25,
-33, -38, -34, -35, -36, -38, -39, -42, -38, -40, -46, -45, -44, -45, -43, -41,
-48, -49, -49, -50, -50, -50, -49, -48, -48, -49, -52, -51, -50, -52, -52, -50,
-50, -51, -49, -51, -50, -51, -52, -50, -49, -46, -47, -47, -47, -46, -45, -48,
-48, -46, -44, -40, -43, -44, -44, -43, -43, -43, -44, -43, -43, -38, -22, -28,
-46, -42, -37, -40, -37, -36, -34, -34, -31, -33, -35, -35, -37, -36, -34, -31,
-33, -37, -34, -33, -34, -33, -32, -32, -32, -33, -32, -29, -31, -31, -33, -31,
-34, -32, -33, -31, -30, -32, -32, -32, -33, -31, -32, -32, -32, -32, -31, -33,
-33, -31, -30, -33, -33, -35, -33, -29, -30, -32, -34, -35, -33, -33, -28, -26,
-33, -32, -30, -30, -30, -31, -30, -29, -29, -28, -31, -29, -27, -28, -26, -26,
-29, -31, -27, -26, -25, -26, -25, -24, -24, -25, -27, -28, -27, -26, -25, -24,
-24, -24, -24, -24, -22, -22, -21, -23, -23, -20, -21, -21, -22, -22, -19, -19,
-20, -21, -19, -18, -18, -17, -19, -17, -16, -15, -17, -15, };