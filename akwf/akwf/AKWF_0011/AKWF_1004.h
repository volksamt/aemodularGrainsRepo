#define DATA_LENGTH 512
#define DATA AKWF_1004

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 2, 1, 1,
1, 0, 2, 0, 3, -1, 3, -2, 5, -4, 9, -12, 40, 127, 112, 123, 117, 120, 119, 120,
119, 119, 119, 118, 119, 119, 120, 118, 120, 118, 119, 118, 120, 118, 120, 118,
119, 119, 119, 119, 118, 119, 118, 120, 118, 119, 119, 119, 118, 118, 118, 119,
119, 120, 119, 119, 118, 120, 119, 118, 119, 118, 119, 119, 118, 118, 118, 119,
118, 118, 118, 119, 119, 119, 119, 118, 118, 119, 119, 119, 119, 118, 118, 118,
118, 119, 118, 118, 118, 118, 117, 118, 118, 118, 118, 118, 118, 118, 117, 118,
118, 118, 118, 117, 119, 119, 118, 118, 119, 117, 119, 117, 119, 117, 119, 117,
120, 116, 119, 117, 119, 117, 119, 117, 118, 121, 14, -6, 4, -5, 4, -4, 2, -3,
2, -2, 1, -2, 0, -2, 0, -1, -1, 0, -1, 0, -2, 0, -2, 1, -2, 1, -3, 3, -5, 5,
-16, -87, -80, -83, -82, -81, -83, -81, -83, -81, -83, -81, -83, -81, -83, -82,
-82, -82, -83, -82, -83, -82, -82, -82, -82, -83, -82, -83, -82, -82, -82, -82,
-83, -82, -81, -82, -82, -83, -81, -82, -82, -82, -82, -83, -82, -82, -82, -82,
-82, -82, -81, -82, -82, -82, -81, -82, -82, -81, -81, -82, -81, -82, -81, -83,
-82, -82, -82, -81, -82, -81, -83, -80, -82, -80, -83, -80, -84, -80, -84, -78,
-87, -69, 3, -2, 1, 0, -1, 0, -1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 1, 0, 0, 1, -1, 0,
0, 1, -1, 1, -1, 0, -1, 2, -2, 3, -3, 5, -8, 26, 91, 78, 84, 80, 83, 81, 82, 81,
81, 82, 81, 82, 81, 83, 81, 82, 81, 83, 81, 82, 81, 82, 81, 82, 81, 82, 82, 82,
81, 82, 81, 82, 81, 81, 81, 82, 81, 81, 82, 81, 81, 81, 82, 81, 81, 82, 82, 81,
82, 82, 82, 81, 81, 81, 81, 81, 82, 81, 82, 81, 81, 81, 82, 82, 81, 82, 81, 81,
82, 81, 80, 82, 80, 82, 80, 84, 79, 85, 76, 89, 57, -8, 3, -2, 1, -1, -1, 1, -1,
0, -1, 1, -1, 0, -2, 1, -2, 0, -2, 1, -1, 0, -1, 0, 0, -1, 1, -3, 3, -8, 13,
-71, -128, -111, -124, -115, -121, -116, -120, -118, -119, -118, -119, -118,
-118, -119, -118, -119, -118, -118, -118, -120, -118, -119, -118, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -118, -119, -118, -118, -119, -119,
-119, -118, -119, -119, -118, -118, -118, -118, -119, -117, -118, -119, -118,
-118, -118, -118, -118, -118, -118, -118, -117, -118, -118, -118, -118, -118,
-118, -118, -117, -117, -118, -118, -118, -118, -118, -118, -118, -117, -118,
-118, -118, -117, -118, -118, -118, -117, -118, -118, -118, -116, -118, -117,
-117, -117, -118, -117, -117, -118, -118, -117, -116, -118, -117, -118, -115,
-118, -115, -119, -115, -120, -114, -120, -113, -125, -100, };