#define DATA_LENGTH 512
#define DATA AKWF_1006

const PROGMEM int8_t DATA[DATA_LENGTH] = {95, 113, 105, 112, 105, 111, 106, 110,
107, 111, 107, 110, 107, 109, 107, 110, 107, 110, 107, 110, 107, 109, 107, 110,
107, 110, 107, 109, 108, 108, 108, 105, 117, 36, -24, 15, 105, 112, 105, 111,
105, 111, 106, 110, 107, 109, 107, 108, 107, 107, 109, 107, 110, 106, 110, 106,
110, 106, 8, -13, 1, -13, 3, -16, 8, -36, -125, -117, -119, -120, -117, -121,
-117, -122, -117, -121, -118, -121, -118, -120, -120, -118, -121, -116, -123,
-114, -126, -107, -128, -65, -51, -128, -108, -125, -114, -121, -117, -119,
-119, -118, -119, -118, -120, -117, -120, -116, -122, -115, -122, -115, -121,
-115, -121, -115, -120, -117, -18, 1, -11, 1, -10, -1, -10, -1, -9, -2, -8, -1,
102, 112, 105, 111, 106, 111, 106, 110, 107, 110, 108, 109, 107, 109, 107, 109,
107, 110, 107, 109, 106, 109, 106, 110, 107, 109, 106, 110, 106, 109, 108, 106,
115, 32, -24, 20, 110, 110, 106, 111, 106, 111, 106, 111, 106, 109, 107, 108,
107, 108, 109, 106, 109, 106, 110, 104, 111, 103, 4, -12, 1, -12, 3, -15, 9,
-42, -128, -117, -119, -121, -118, -121, -116, -122, -117, -121, -117, -120,
-118, -119, -119, -119, -120, -116, -122, -114, -127, -108, -127, -58, -56,
-128, -108, -127, -113, -122, -117, -120, -118, -119, -119, -118, -120, -116,
-121, -116, -121, -115, -122, -115, -121, -115, -122, -114, -123, -114, -13, 0,
-10, 0, -9, -1, -9, -1, -9, -1, -10, 2, 106, 110, 106, 111, 107, 110, 107, 110,
107, 109, 107, 109, 107, 109, 108, 109, 107, 109, 106, 109, 106, 111, 107, 110,
106, 111, 106, 110, 106, 110, 107, 108, 113, 26, -24, 25, 111, 109, 107, 110,
106, 110, 106, 110, 106, 109, 107, 108, 108, 108, 109, 108, 110, 106, 110, 104,
112, 99, -2, -9, 0, -11, 2, -15, 10, -48, -128, -116, -119, -120, -118, -121,
-117, -121, -118, -121, -118, -121, -117, -120, -118, -119, -119, -117, -122,
-115, -125, -108, -128, -53, -62, -128, -106, -127, -113, -123, -116, -121,
-117, -120, -119, -118, -119, -118, -119, -116, -121, -116, -121, -115, -122,
-115, -122, -115, -124, -109, -9, -1, -9, -1, -10, -2, -10, 0, -9, 1, -11, 8,
109, 108, 107, 110, 107, 110, 107, 109, 108, 110, 107, 109, 107, 109, 107, 109,
108, 110, 107, 110, 107, 110, 107, 110, 107, 110, 106, 111, 106, 111, 106, 110,
111, 21, -24, 30, 114, 107, 108, 109, 107, 109, 107, 109, 107, 109, 106, 108,
108, 107, 109, 107, 110, 106, 111, 104, 114, 94, -6, -7, -2, -10, 2, -16, 10,
-53, -128, -115, -120, -119, -118, -121, -118, -121, -117, -122, -117, -121,
-118, -121, -118, -119, -119, -119, -121, -115, -125, -110, -128, -47, -69,
-128, -106, -127, -113, -123, -114, -121, -117, -120, -118, -118, -120, -118,
-120, -117, -121, -116, -122, -114, -122, -115, -122, -113, -125, -106, -4, -4,
-6, -4, -7, -3, -7, -3, -7, -4, -7, -3, };