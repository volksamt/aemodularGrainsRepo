#define DATA_LENGTH 512
#define DATA AKWF_1067

const PROGMEM int8_t DATA[DATA_LENGTH] = {17, 120, 119, 118, 119, 115, 117, 114,
117, 114, 116, 113, 116, 112, 114, 111, 113, 110, 112, 109, 111, 109, 109, 108,
108, 108, 107, 106, 106, 106, 105, 105, 104, 104, 103, 103, 102, 102, 101, 102,
100, 99, 100, 99, 99, 97, 98, 97, 96, 96, 95, 95, 94, 94, 93, 93, 93, 92, 92,
91, 91, 91, 90, 88, 89, 88, 87, 87, 86, 87, 86, 85, 85, 84, 84, 84, 84, 82, 82,
81, 81, 80, 81, 79, 79, 79, 79, 78, 78, 77, 76, 77, 76, 75, 74, 74, 73, 73, 73,
72, 72, 71, 70, 70, 71, 69, 69, 68, 68, 68, 66, 67, 65, 65, 65, 65, 64, 64, 63,
62, 62, 61, 61, 61, 61, 60, 59, 59, 58, 58, 57, 57, 56, 56, 55, 55, 54, 54, 53,
52, 53, 52, 51, 52, 50, 50, 50, 49, 49, 48, 48, 48, 47, 46, 46, 45, 44, 44, 43,
44, 43, 43, 42, 41, 41, 41, 39, 40, 38, 39, 38, 38, 37, 36, 37, 35, 35, 35, 34,
33, 34, 33, 32, 32, 32, 31, 31, 30, 29, 29, 28, 28, 28, 27, 27, 26, 25, 26, 25,
24, 24, 24, 23, 22, 22, 21, 20, 21, 20, 20, 19, 18, 18, 17, 17, 16, 16, 16, 15,
15, 14, 14, 12, 13, 11, 12, 10, 11, 10, 10, 9, 9, 8, 9, 7, 7, 7, 1, 1, -1, 1,
-2, 2, -3, 4, -4, 6, -7, 10, 58, 39, 48, 47, 44, 55, 32, -35, -96, -102, -95,
-99, -96, -98, -96, -97, -96, -97, -96, -96, -97, -96, -97, -95, -95, -95, -95,
-94, -94, -94, -94, -94, -94, -94, -93, -93, -93, -93, -92, -93, -92, -92, -91,
-91, -90, -90, -91, -90, -90, -89, -89, -89, -89, -88, -88, -88, -88, -88, -88,
-86, -86, -87, -85, -85, -85, -85, -85, -84, -84, -83, -84, -83, -83, -82, -82,
-82, -82, -81, -81, -80, -80, -80, -79, -80, -78, -78, -78, -77, -77, -77, -76,
-76, -75, -76, -75, -74, -74, -73, -73, -73, -73, -72, -71, -72, -71, -71, -70,
-70, -70, -69, -69, -68, -68, -68, -66, -67, -66, -66, -66, -65, -65, -64, -64,
-63, -62, -62, -62, -61, -60, -60, -60, -59, -59, -58, -58, -57, -57, -56, -56,
-54, -55, -54, -55, -54, -53, -52, -52, -52, -52, -50, -50, -51, -50, -50, -49,
-49, -47, -48, -48, -47, -46, -46, -45, -46, -45, -43, -44, -43, -43, -43, -42,
-42, -41, -41, -41, -40, -39, -39, -38, -38, -38, -37, -37, -37, -36, -36, -35,
-34, -34, -34, -33, -32, -32, -32, -31, -31, -31, -30, -30, -29, -28, -28, -27,
-27, -27, -26, -26, -26, -24, -25, -24, -23, -23, -22, -22, -22, -20, -21, -20,
-19, -19, -18, -18, -18, -17, -16, -16, -15, -15, -14, -15, -12, -14, -12, -13,
-11, -12, -10, -11, -8, -10, -7, -9, -7, -8, -8, -6, -4, 2, -3, 3, -4, 5, -7,
10, -18, -56, -41, -48, -49, -41, -63, -18, };