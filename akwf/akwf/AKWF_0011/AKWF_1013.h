#define DATA_LENGTH 512
#define DATA AKWF_1013

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 125, 115, 122, 117, 122, 117,
120, 118, 121, 119, 120, 118, 120, 119, 120, 118, 121, 118, 121, 118, 121, 117,
121, 116, 122, 115, 123, 113, 127, 94, -9, 4, -1, 1, 1, 0, 1, 0, 2, -1, 1, 0, 2,
0, 2, -1, 2, 0, 1, 1, 2, -1, 1, 0, 0, 1, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 1,
1, 1, 1, 1, 0, 1, 0, 0, 0, 0, 1, 0, 1, 1, 0, 0, 0, 1, 0, 0, 0, 1, 1, 1, 0, 1, 1,
1, 1, 0, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1,
0, 1, 0, 1, 0, 0, 1, 0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1,
1, 1, 0, 1, 0, 1, 1, 0, 0, 1, 1, 1, 0, 0, 1, 1, 1, 1, 0, 1, 1, 0, 1, 1, 1, 0, 0,
0, 0, 1, 2, 1, 1, -1, 0, 1, 1, 0, 0, 1, 0, 1, 1, 1, 0, 2, 0, 1, -1, 2, -1, 2,
-1, 2, -1, 2, -2, 3, -1, 2, -1, 3, -2, 3, 112, 122, 116, 122, 116, 121, 116,
121, 117, 120, 117, 120, 118, 119, 118, 119, 118, 118, 118, 118, 119, 117, 120,
116, 122, 113, 127, 43, -110, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -120, -119, -119, -119, -119, -119, -118, -119,
-118, -119, -116, -122, -113, -128, -37, 13, -7, 5, -3, 4, -2, 3, -2, 2, 0, 2,
0, 1, 0, 1, 0, 0, 1, 1, 1, 0, 1, 0, 1, 1, 1, 0, 1, -1, 1, 1, 0, 0, 0, 0, 1, 0,
1, 1, 0, 0, 1, 1, 0, 0, 1, 0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 1, 1, 0,
0, 1, 1, 0, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0,
0, 1, 0, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 0, 1, 1, 1, 1, 0, 0, 0, 0,
0, 0, 1, 1, 1, 1, 1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 1,
0, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 0, 1,
0, 0, 1, 0, 0, 1, 1, 0, 1, 0, 1, 0, 1, 1, 0, 0, 1, -1, 1, -1, 1, 0, 2, -1, 2, 0,
1, 0, 1, 0, 1, 0, -1, 2, -5, 12, -83, -128, -110, -122, -112, -121, -115, -119,
-115, -119, -116, -119, -116, -117, -117, -117, -118, -117, -118, -116, -118,
-116, -119, -114, -119, -114, -120, -114, -122, -112, -125, -100, };