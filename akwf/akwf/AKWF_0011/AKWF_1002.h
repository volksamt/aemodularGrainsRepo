#define DATA_LENGTH 512
#define DATA AKWF_1002

const PROGMEM int8_t DATA[DATA_LENGTH] = {-77, -92, -86, -94, -90, -95, -94,
-98, -97, -101, -99, -103, -102, -106, -106, -107, -108, -111, -112, -114, -114,
-116, -118, -119, -118, -118, -117, -116, -116, -115, -114, -113, -114, -112,
-111, -111, -110, -109, -109, -108, -108, -106, -106, -106, -105, -104, -104,
-102, -102, -101, -101, -100, -99, -99, -97, -98, -96, -97, -95, -96, -92, -95,
-91, -93, -89, -93, -87, -92, -84, -93, -73, 16, 12, 13, 13, 12, 14, 12, 14, 12,
14, 11, 13, 12, 13, 12, 14, 12, 14, 12, 13, 11, 13, 12, 13, 12, 12, 13, 13, 13,
12, 14, 12, 14, 12, 14, 10, 18, -14, -37, -30, -35, -33, -36, -35, -37, -37,
-40, -40, -41, -41, -42, -43, -44, -44, -46, -46, -44, -44, -44, -43, -43, -42,
-41, -41, -39, -39, -38, -39, -37, -38, -34, -36, -33, -36, -30, -38, -16, 18,
10, 14, 11, 14, 13, 13, 13, 13, 13, 13, 13, 13, 13, 12, 13, 12, 13, 13, 13, 12,
13, 13, 13, 13, 14, 13, 12, 13, 13, 13, 13, 13, 13, 13, 12, 13, 13, 13, 14, 13,
13, 13, 12, 13, 14, 13, 12, 12, 14, 12, 13, 13, 13, 13, 12, 13, 13, 13, 14, 14,
13, 13, 13, 12, 13, 12, 12, 13, 14, 13, 13, 13, 13, 13, 12, 12, 13, 13, 13, 12,
13, 13, 13, 13, 12, 13, 13, 13, 13, 12, 12, 13, 13, 14, 13, 12, 12, 13, 13, 13,
12, 13, 13, 13, 12, 12, 14, 13, 13, 13, 13, 13, 13, 12, 12, 13, 12, 13, 12, 14,
13, 12, 11, 13, 11, 13, 12, 13, 12, 15, 48, 51, 49, 51, 51, 54, 52, 54, 53, 55,
55, 56, 55, 57, 57, 58, 58, 59, 60, 60, 61, 61, 60, 59, 60, 58, 59, 57, 57, 57,
56, 56, 55, 55, 54, 54, 53, 53, 52, 52, 50, 52, 48, 54, 26, 9, 14, 10, 13, 11,
13, 12, 13, 12, 13, 12, 13, 12, 13, 13, 13, 12, 12, 12, 12, 12, 13, 12, 12, 12,
13, 13, 12, 13, 13, 12, 12, 13, 12, 13, 12, 12, 12, 13, 11, 12, 11, 14, 12, 12,
12, 13, 12, 12, 12, 13, 12, 11, 42, 48, 46, 48, 47, 49, 47, 49, 49, 51, 50, 51,
51, 52, 52, 53, 53, 54, 54, 55, 54, 54, 55, 56, 57, 56, 57, 55, 56, 55, 54, 54,
53, 53, 53, 52, 51, 51, 50, 51, 49, 49, 47, 49, 46, 49, 45, 50, 37, 9, 14, 11,
13, 12, 12, 12, 12, 13, 12, 13, 12, 12, 12, 13, 11, 12, 12, 12, 12, 12, 12, 12,
12, 13, 12, 12, 12, 12, 12, 12, 13, 11, 11, 11, 12, 12, 12, 12, 12, 12, 11, 11,
13, 12, 11, 12, 12, 12, 12, 11, 12, 12, 11, 12, 11, 11, 12, 11, 11, 12, 12, 12,
12, 12, 12, 12, 12, 12, 12, 12, 12, 12, 12, 12, 12, 12, 12, 13, 12, 13, 12, 13,
11, 12, 11, };