#define DATA_LENGTH 512
#define DATA AKWF_1031

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 18, 26, 24, 25, 25, 24, 25, 24, 24,
24, 25, 25, 24, 25, 24, 25, 25, 24, 25, 24, 24, 24, 25, 24, 24, 24, 23, 24, 24,
24, 24, 24, 24, 24, 25, 24, 24, 25, 24, 24, 24, 25, 24, 25, 24, 25, 25, 24, 25,
25, 24, 25, 25, 25, 25, 25, 24, 24, 24, 24, 25, 24, 24, 24, 24, 24, 24, 24, 24,
24, 24, 24, 24, 24, 24, 24, 24, 25, 24, 24, 24, 24, 25, 24, 23, 24, 24, 24, 25,
24, 23, 25, 24, 24, 24, 25, 24, 24, 24, 24, 24, 25, 24, 25, 23, 24, 24, 24, 25,
23, 24, 24, 25, 25, 24, 24, 24, 23, 24, 25, 24, 24, 24, 23, 24, 24, 24, 23, 25,
24, 24, 24, 24, 24, 24, 25, 24, 24, 23, 23, 24, 24, 24, 23, 24, 24, 24, 22, 29,
44, 59, 72, 72, 71, 70, 71, 71, 72, 71, 72, 71, 71, 71, 71, 71, 71, 71, 72, 71,
71, 71, 72, 71, 71, 71, 71, 71, 71, 71, 71, 71, 71, 71, 71, 71, 71, 70, 71, 71,
72, 72, 71, 71, 72, 71, 71, 71, 71, 70, 71, 71, 71, 71, 71, 71, 72, 71, 71, 71,
71, 70, 71, 72, 71, 72, 71, 71, 71, 70, 71, 71, 71, 71, 71, 70, 71, 71, 71, 71,
71, 71, 71, 71, 71, 71, 70, 70, 70, 71, 70, 71, 70, 70, 72, 71, 71, 71, 71, 71,
70, 70, 70, 71, 71, 72, 70, 71, 70, 70, 71, 71, 71, 71, 70, 71, 70, 71, 70, 70,
70, 71, 71, 71, 71, 71, 71, 70, 71, 70, 71, 70, 71, 71, 70, 71, 70, 71, 70, 71,
70, 70, 70, 71, 70, 70, 69, 71, 70, 70, 70, 70, 70, 70, 71, 69, 77, 90, 106,
117, 119, 117, 118, 116, 118, 116, 119, 116, 119, 116, 119, 116, 118, 117, 119,
118, 116, 60, -21, -40, -103, -81, -66, -77, -68, -75, -68, -75, -69, -73, -69,
-72, -70, -72, -70, -71, -72, -72, -72, -72, -71, -72, -72, -72, -71, -71, -72,
-71, -72, -71, -72, -70, -72, -71, -72, -71, -71, -71, -71, -72, -70, -70, -71,
-71, -71, -71, -71, -72, -71, -71, -71, -71, -71, -71, -71, -71, -70, -71, -70,
-71, -70, -70, -72, -63, -38, -23, -23, -24, -23, -24, -24, -24, -23, -23, -23,
-23, -23, -24, -24, -23, -24, -23, -23, -24, -23, -24, -24, -23, -24, -23, -23,
-23, -23, -24, -23, -24, -22, -24, -24, -23, -23, -22, -23, -24, -23, -23, -23,
-23, -24, -23, -23, -23, -23, -23, -23, -23, -23, -23, -24, -24, -23, -24, -23,
-23, -23, -22, -23, -23, -24, -23, -23, -24, -24, -22, -23, -23, -23, -23, -24,
-23, -23, -23, -23, -22, -23, -23, -23, -23, -23, -24, -22, -23, -23, -24, -23,
-23, -23, -23, -24, -23, -22, -22, -24, -24, -23, -23, -23, -24, -23, -23, -23,
-23, -23, -22, -24, -23, -23, -22, -23, -23, -24, -12, };