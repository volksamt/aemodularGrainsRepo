#define DATA_LENGTH 512
#define DATA AKWF_1077

const PROGMEM int8_t DATA[DATA_LENGTH] = {102, 122, 112, 119, 114, 119, 113,
118, 114, 117, 113, 116, 113, 116, 113, 114, 112, 113, 112, 111, 111, 111, 110,
109, 109, 108, 107, 107, 106, 105, 105, 103, 103, 102, 101, 101, 100, 98, 97,
95, 95, 94, 93, 91, 91, 89, 88, 86, 85, 84, 83, 80, 79, 76, 75, 74, 71, 69, 67,
66, 62, 61, 56, 57, 50, 51, 40, 45, 29, 39, 8, 67, 76, -18, 10, -7, 5, -2, 2,
-1, 1, 0, 0, 0, -10, -7, 6, 82, 93, 88, 91, 88, 90, 88, 89, 87, 89, 86, 87, 85,
86, 84, 83, 83, 82, 81, 79, 78, 77, 75, 74, 73, 71, 70, 68, 66, 64, 63, 60, 58,
55, 52, 50, 46, 44, 38, 35, 26, 24, 24, 33, 32, 48, 44, 75, 64, -9, 4, -2, 0, 1,
-1, 2, -2, 3, -1, 4, 0, 6, 3, 9, 8, 12, 15, 15, 28, -94, -128, -112, -124, -115,
-123, -116, -122, -116, -121, -117, -120, -117, -118, -117, -119, -118, -118,
-117, -117, -117, -116, -117, -115, -116, -115, -116, -114, -116, -114, -115,
-113, -114, -113, -112, -112, -112, -111, -111, -111, -110, -110, -109, -109,
-109, -108, -108, -108, -107, -106, -106, -105, -105, -104, -103, -103, -103,
-103, -101, -101, -99, -99, -98, -98, -97, -97, -95, -95, -94, -93, -92, -92,
-90, -90, -89, -88, -87, -86, -86, -84, -83, -81, -81, -79, -78, -78, -76, -75,
-74, -73, -71, -69, -68, -67, -65, -64, -62, -61, -59, -57, -54, -53, -51, -49,
-46, -43, -41, -38, -33, -30, -25, -19, -23, -23, -24, -24, -25, -24, -25, -27,
-26, -26, -27, -28, -28, -28, -28, -29, -29, -30, -31, -31, -32, -31, -31, -32,
-34, -34, -34, -34, -35, -35, -36, -36, -37, -37, -38, -39, -39, -40, -40, -40,
-41, -42, -42, -43, -44, -44, -45, -45, -46, -47, -47, -48, -48, -50, -50, -50,
-51, -52, -53, -54, -54, -55, -56, -57, -58, -59, -59, -60, -60, -61, -62, -63,
-66, -66, -68, -68, -70, -69, -71, -71, -74, -74, -77, -77, -81, -80, -83, -83,
-86, -88, -90, -93, -93, -101, -96, -126, -35, 12, -8, 6, -4, 3, -2, 3, -2, 2,
-1, 2, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, -1, 1, -1, 0, 0, 0, 0, -1, -1,
0, -1, 0, -1, 0, -1, -1, 0, -1, 0, -2, -1, -2, -1, -1, -2, -2, -1, -2, -2, -2,
-2, -2, -2, -2, -2, -3, -3, -3, -2, -4, -3, -3, -4, -3, -3, -4, -4, -4, -5, -5,
-5, -4, -5, -4, -4, -6, -5, -5, -7, -6, -7, -6, -6, -7, -7, -7, -8, -7, -8, -8,
-8, -8, -9, -8, -10, -9, -9, -9, -10, -10, -10, -10, -11, -11, -11, -11, -12,
-12, -12, -12, -13, -14, -14, -13, -14, -14, -15, -14, -15, -16, -15, -15, -16,
-16, -17, -18, -18, -18, -18, -18, -18, -19, -18, -20, -19, -20, -19, -22, -21,
-22, -21, -24, -19, };