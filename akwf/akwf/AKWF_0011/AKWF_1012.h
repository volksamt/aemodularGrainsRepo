#define DATA_LENGTH 512
#define DATA AKWF_1012

const PROGMEM int8_t DATA[DATA_LENGTH] = {27, 34, 32, 35, 34, 35, 35, 37, 35,
38, 38, 39, 38, 39, 40, 42, 42, 43, 42, 43, 44, 44, 45, 45, 47, 46, 48, 48, 49,
50, 50, 50, 50, 51, 52, 53, 54, 54, 54, 55, 56, 56, 57, 58, 58, 59, 60, 59, 61,
61, 62, 62, 63, 63, 64, 65, 65, 65, 65, 67, 67, 68, 68, 69, 70, 70, 71, 72, 72,
73, 73, 73, 74, 75, 76, 76, 77, 77, 79, 79, 79, 79, 80, 81, 82, 81, 83, 84, 84,
84, 85, 86, 86, 87, 87, 88, 88, 89, 90, 90, 90, 91, 92, 93, 93, 94, 95, 96, 96,
96, 97, 97, 98, 98, 99, 100, 100, 101, 101, 102, 103, 103, 104, 104, 105, 105,
106, 107, 107, 108, 109, 109, 109, 110, 111, 111, 112, 112, 113, 113, 115, 114,
116, 116, 116, 117, 117, 119, 119, 119, 117, 115, 115, 114, 113, 112, 111, 109,
108, 108, 106, 105, 103, 103, 102, 100, 98, 98, 96, 96, 95, 94, 93, 91, 90, 89,
88, 87, 86, 84, 83, 83, 81, 80, 79, 78, 77, 75, 75, 73, 72, 71, 70, 69, 67, 66,
65, 64, 63, 62, 60, 60, 59, 57, 57, 55, 54, 53, 52, 51, 49, 48, 48, 47, 45, 45,
43, 42, 41, 39, 40, 37, 37, 34, 36, 31, 35, 24, -7, -5, -4, -5, -2, -10, -32,
-31, -31, -31, -31, -33, -33, -33, -32, -34, -34, -34, -33, -34, -35, -35, -36,
-35, -37, -37, -37, -37, -37, -38, -39, -39, -39, -39, -40, -40, -40, -40, -41,
-41, -42, -41, -42, -42, -43, -43, -43, -44, -44, -44, -44, -45, -45, -45, -45,
-46, -46, -46, -48, -47, -48, -48, -48, -49, -49, -49, -49, -50, -50, -51, -51,
-51, -52, -52, -52, -53, -53, -53, -53, -54, -55, -54, -55, -56, -56, -56, -56,
-56, -57, -57, -58, -58, -58, -59, -59, -59, -59, -59, -60, -60, -60, -61, -62,
-62, -62, -62, -63, -64, -63, -64, -64, -63, -65, -66, -65, -65, -66, -66, -66,
-67, -66, -67, -68, -68, -68, -69, -68, -69, -70, -70, -71, -70, -71, -70, -72,
-72, -72, -72, -73, -73, -73, -73, -74, -75, -75, -75, -75, -76, -75, -75, -77,
-76, -77, -77, -78, -78, -79, -79, -79, -79, -80, -79, -80, -81, -81, -80, -81,
-82, -81, -82, -83, -83, -83, -84, -84, -84, -85, -85, -85, -85, -86, -87, -86,
-87, -87, -88, -88, -88, -88, -88, -89, -89, -90, -90, -90, -90, -91, -92, -92,
-92, -93, -93, -92, -93, -94, -94, -94, -94, -94, -93, -93, -92, -91, -90, -89,
-88, -87, -85, -84, -84, -82, -82, -81, -81, -80, -79, -78, -76, -76, -74, -74,
-73, -72, -71, -70, -69, -68, -67, -66, -65, -65, -63, -62, -62, -60, -60, -59,
-58, -57, -56, -56, -54, -53, -52, -51, -51, -50, -49, -48, -47, -45, -44, -43,
-43, -42, -41, -40, -39, -37, -38, -36, -36, -34, -34, -32, -32, -29, -31, -22,
0, -4, -2, -2, -2, };