#define DATA_LENGTH 512
#define DATA AKWF_1058

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 5, 6, 8, 7, 9, 11, 12, 13,
15, 16, 17, 18, 19, 21, 22, 23, 25, 25, 26, 27, 29, 30, 31, 31, 32, 34, 34, 36,
37, 39, 39, 41, 42, 43, 44, 45, 46, 48, 48, 49, 51, 52, 52, 53, 54, 55, 56, 58,
58, 59, 59, 61, 61, 63, 62, 64, 65, 65, 66, 66, 67, 67, 68, 69, 69, 69, 70, 69,
70, 70, 70, 70, 71, 70, 71, 70, 70, 70, 70, 53, -8, -90, -122, -82, -28, 3, 22,
33, 26, 6, -8, -14, -24, -29, -20, -7, 4, 12, 24, 29, 25, 22, 18, 14, 11, 15,
23, 31, 37, 44, 50, 50, 49, 49, 48, 47, 48, 53, 55, 59, 63, 67, 67, 67, 66, 65,
64, 63, 63, 63, 64, 65, 67, 65, 64, 62, 60, 57, 52, 45, 40, 36, 32, 28, 25, 21,
17, 12, 8, 4, -1, -4, -8, -11, -14, -17, -19, -21, -22, -24, -25, -26, -26, -28,
-27, -26, -25, -23, -21, -19, -18, -16, -14, -15, -13, -11, -9, -9, -7, -5, -2,
-1, 0, 0, 2, 2, 3, 4, 4, 5, 7, 6, 6, 6, 6, 6, 5, 5, 4, 3, 2, 1, 0, -1, -2, -3,
-5, -6, -7, -9, -10, -11, -11, -13, -14, -16, -16, -17, -18, -18, -19, -20, -20,
-20, -20, -21, -21, -20, -19, -20, -19, -19, -18, -18, -16, -16, -15, -14, -13,
-12, -11, -10, -9, -7, -7, -6, -4, -5, -7, -12, -17, -21, -24, -27, -30, -31,
-34, -37, -41, -45, -48, -53, -55, -59, -62, -64, -67, -69, -70, -73, -74, -76,
-78, -78, -79, -79, -79, -77, -75, -73, -72, -69, -69, -68, -67, -65, -63, -61,
-58, -56, -53, -51, -48, -45, -44, -41, -38, -35, -33, -30, -28, -26, -23, -21,
-19, -17, -15, -13, -11, -10, -8, -7, -5, -4, -4, -2, -2, -1, -1, -1, -1, -2,
-2, -1, -2, -3, -3, -5, -5, -6, -7, -8, -9, -10, -10, -13, -12, -14, -14, -15,
-16, -15, -16, -17, -17, -18, -18, -18, -18, -18, -18, -18, -16, -16, -15, -15,
-15, -13, -12, -12, -12, -10, -10, -9, -8, -8, -7, -7, -5, -4, -4, -4, -3, -3,
-2, -1, -1, -1, -1, 0, -1, -1, -1, -1, -1, -2, -2, -3, -3, -3, -4, -4, -4, -6,
-7, -7, -7, -7, -9, -10, -10, -11, -11, -12, -13, -13, -13, -13, -13, -14, -13,
-14, -15, -15, -15, -15, -15, -14, -13, -13, -13, -13, -13, -11, -11, -11, -10,
-9, -9, -8, -8, -7, -7, -7, -6, -6, -5, -4, -5, -5, -4, -3, -3, -3, -3, -3, -3,
-4, -3, -3, -3, -4, -4, -5, -4, -5, -5, -6, -5, -7, -6, -7, -8, -8, -8, -9, -9,
-9, -10, -10, -11, -11, -12, -12, -12, -13, -12, -13, -12, -13, -11, -12, -12,
-12, -12, -11, -11, -10, -10, -10, -10, -9, -9, -8, -9, -8, -8, -8, -7, -7, -6,
-6, -6, -6, -5, -4, -2, 1, };