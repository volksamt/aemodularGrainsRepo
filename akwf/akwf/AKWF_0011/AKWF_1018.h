#define DATA_LENGTH 512
#define DATA AKWF_1018

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 4, 4, 5, 6, 8, 9, 10, 11, 12,
13, 14, 15, 16, 18, 18, 19, 20, 21, 22, 23, 25, 25, 26, 27, 28, 29, 30, 32, 32,
33, 35, 36, 37, 38, 39, 41, 41, 43, 43, 45, 46, 48, 48, 50, 52, 53, 53, 56, 56,
58, 59, 60, 62, 62, 64, 65, 67, 68, 69, 71, 71, 73, 74, 74, 76, 77, 78, 80, 81,
81, 82, 84, 84, 86, 86, 88, 88, 89, 91, 91, 91, 94, 94, 95, 96, 96, 98, 98, 99,
100, 101, 100, 101, 102, 103, 103, 105, 105, 106, 106, 106, 106, 107, 107, 108,
109, 109, 110, 110, 110, 110, 110, 111, 111, 111, 111, 111, 111, 112, 111, 111,
111, 111, 111, 111, 111, 111, 111, 111, 111, 109, 111, 109, 109, 109, 108, 108,
108, 107, 107, 107, 106, 105, 104, 105, 104, 103, 104, 103, 102, 101, 100, 101,
99, 98, 98, 97, 97, 96, 95, 95, 94, 93, 92, 92, 91, 90, 89, 88, 87, 86, 84, 85,
83, 82, 82, 80, 79, 78, 77, 76, 76, 75, 74, 72, 72, 70, 69, 69, 67, 66, 65, 64,
63, 62, 61, 60, 58, 58, 57, 55, 55, 54, 52, 52, 49, 49, 47, 47, 45, 44, 44, 43,
41, 39, 38, 36, 37, 34, 34, 32, 31, 30, 29, 27, 26, 25, 24, 22, 21, 20, 19, 18,
16, 15, 14, 13, 11, 11, 10, 8, 6, 5, 4, 3, 2, 1, -1, -3, -5, -6, -9, -10, -11,
-13, -15, -17, -19, -22, -23, -25, -26, -28, -30, -32, -34, -36, -38, -39, -42,
-43, -45, -47, -49, -50, -53, -55, -57, -58, -60, -61, -63, -66, -67, -68, -71,
-72, -74, -76, -76, -79, -80, -82, -83, -85, -86, -88, -88, -91, -93, -93, -95,
-96, -97, -99, -99, -100, -102, -104, -104, -105, -105, -107, -108, -109, -109,
-110, -111, -112, -113, -113, -114, -114, -114, -115, -115, -116, -117, -118,
-118, -119, -118, -118, -118, -119, -119, -119, -119, -119, -120, -118, -119,
-119, -119, -119, -118, -118, -118, -117, -117, -116, -117, -117, -115, -115,
-115, -114, -114, -113, -112, -111, -111, -111, -110, -109, -108, -108, -107,
-106, -104, -103, -103, -102, -101, -100, -100, -98, -97, -96, -94, -94, -92,
-92, -91, -90, -88, -87, -87, -85, -85, -83, -82, -82, -80, -78, -77, -76, -75,
-74, -74, -72, -72, -70, -69, -68, -66, -66, -65, -65, -63, -61, -61, -60, -59,
-58, -57, -56, -55, -55, -53, -52, -52, -51, -49, -49, -49, -48, -46, -45, -44,
-44, -43, -42, -42, -42, -40, -41, -40, -38, -38, -38, -37, -36, -36, -35, -35,
-34, -34, -33, -32, -33, -31, -30, -30, -30, -29, -29, -29, -27, -27, -26, -26,
-26, -25, -25, -24, -24, -24, -22, -22, -22, -21, -21, -20, -20, -19, -19, -19,
-19, -17, -17, -17, -16, -16, -16, -14, -14, -14, -13, -12, -13, -12, -11, -11,
-11, -9, -9, -8, -8, -7, -7, -6, -4, -4, -3, -2, -1, -1, -1, };