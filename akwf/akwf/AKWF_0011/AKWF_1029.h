#define DATA_LENGTH 512
#define DATA AKWF_1029

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 1, 1,
1, 1, 1, 0, 0, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 1, 1, 0, 0, 1, 1, 1, 0, 0, 1, 0, 0,
1, 0, 1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 0, 3, 7, 10, 14, 17, 21, 25, 27, 32, 35, 39,
42, 45, 49, 52, 56, 60, 62, 66, 70, 74, 77, 80, 84, 87, 91, 94, 98, 100, 104,
108, 111, 115, 119, 116, 112, 109, 106, 103, 100, 96, 92, 89, 85, 82, 78, 75,
71, 68, 64, 61, 58, 54, 51, 47, 44, 40, 37, 33, 29, 26, 23, 20, 16, 12, 10, 6,
3, 0, -1, -1, -1, 0, 0, -1, 0, 0, -1, 0, -1, -1, -1, -1, 0, -1, -1, -1, 0, -1,
-1, -1, -1, -1, 0, -1, -1, -1, -1, 0, -1, -1, -2, -1, -1, -1, -1, -2, -1, 0, -1,
0, -1, -2, -1, -1, 0, -1, -2, -4, -7, -10, -12, -15, -18, -21, -24, -28, -30,
-33, -36, -39, -42, -44, -47, -50, -53, -55, -58, -62, -65, -66, -70, -72, -74,
-79, -80, -83, -87, -88, -91, -94, -97, -100, -103, -106, -106, -102, -100, -98,
-95, -91, -88, -85, -82, -79, -76, -75, -71, -69, -66, -63, -60, -59, -55, -53,
-50, -48, -45, -42, -40, -38, -34, -32, -30, -27, -24, -22, -18, -18, -9, 4, -1,
3, 8, 12, 16, 18, 22, 23, 26, 29, 31, 34, 36, 38, 41, 44, 47, 49, 51, 54, 56,
59, 61, 64, 66, 68, 71, 73, 76, 78, 80, 83, 85, 87, 90, 92, 95, 96, 100, 101,
103, 102, 99, 97, 95, 93, 91, 88, 86, 84, 80, 79, 76, 73, 72, 69, 67, 65, 63,
60, 58, 57, 54, 51, 49, 46, 44, 42, 40, 38, 36, 34, 31, 28, 27, 24, 23, 20, 18,
15, 13, 11, 10, 7, 5, 3, 0, -2, -1, 0, -1, -1, -1, -1, 0, -1, -1, -1, -2, 0, 0,
0, -1, -1, -1, 0, -1, -1, 0, -1, 0, -1, -1, -1, -1, 0, -1, -1, -1, -1, 0, -1,
-1, 0, -1, -1, -2, -4, -6, -8, -10, -12, -14, -17, -18, -20, -23, -24, -26, -28,
-30, -32, -35, -36, -38, -41, -42, -44, -46, -48, -50, -52, -53, -56, -58, -59,
-61, -64, -65, -67, -69, -70, -73, -74, -77, -78, -79, -82, -84, -86, -87, -89,
-91, -93, -94, -97, -98, -99, -101, -103, -105, -107, -109, -110, -112, -114,
-115, -115, -113, -111, -110, -108, -107, -105, -102, -101, -99, -98, -96, -96,
-93, -91, -90, -88, -86, -86, -83, -82, -80, -79, -78, -76, -75, -73, -71, -70,
-68, -67, -66, -64, -63, -62, -60, -58, -57, -56, -53, -53, -51, -49, -48, -47,
-46, -44, -43, -41, -41, -39, -37, -35, -35, -34, -32, -31, -30, -28, -27, -25,
-24, -23, -22, -20, -20, -18, -17, -15, -15, -13, -12, -11, -9, -8, -8, -7, -5,
-4, -3, -1, };