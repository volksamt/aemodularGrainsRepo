#define DATA_LENGTH 512
#define DATA AKWF_1083

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 18, 23, 28, 34, 38, 45, 50,
56, 60, 66, 70, 72, 74, 78, 79, 82, 84, 86, 89, 92, 93, 92, 89, 87, 83, 82, 79,
76, 76, 71, 75, 13, -5, 4, -3, 2, -2, 2, -1, 1, -1, 0, -1, 0, 0, 0, 0, 0, 2, 4,
6, 10, 12, 15, 17, 19, 23, 24, 27, 30, 33, 34, 38, 40, 43, 45, 47, 49, 53, 55,
59, 61, 63, 65, 69, 71, 74, 75, 78, 82, 83, 87, 89, 92, 94, 99, 98, 105, 102,
102, 96, 97, 89, 92, 82, 88, 70, -4, -4, -7, -10, -12, -16, -19, -20, -28, 13,
29, 14, 16, 5, 4, -5, -7, -16, -19, -26, -30, -37, -41, -46, -51, -57, -63, -68,
-72, -78, -84, -87, -90, -93, -96, -99, -102, -104, -108, -110, -108, -104,
-102, -99, -96, -93, -91, -89, -86, -83, -81, -77, -75, -72, -69, -66, -64, -61,
-58, -56, -53, -50, -47, -44, -42, -39, -36, -33, -30, -28, -25, -22, -20, -17,
-14, -12, -8, -7, -3, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 2, 3, 3,
4, 5, 4, 5, 6, 7, 8, 8, 9, 9, 10, 11, 11, 11, 13, 13, 14, 14, 15, 16, 16, 17,
18, 18, 19, 19, 19, 20, 20, 22, 22, 22, 23, 24, 25, 24, 23, 22, 22, 21, 21, 20,
20, 20, 19, 18, 17, 17, 17, 15, 14, 14, 13, 13, 12, 12, 11, 10, 10, 10, 8, 8, 7,
6, 6, 6, 5, 4, 3, 3, 2, 2, 1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, -1, -1, 0, -1, -1, 0, 0,
0, -1, -2, -1, -1, 0, 0, 0, -2, -1, -1, -1, -1, -2, -1, -1, -1, -1, -1, -1, -1,
-1, -1, -2, -1, -2, -1, -1, -2, -2, -1, -1, -1, 0, -1, -1, -1, -2, -1, 0, 0, -1,
-1, -1, -1, 0, 0, -1, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1,
0, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 1, 1, 0, 0,
1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 1,
0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, -5, -8, -11, -13, -17, -19, -22, -26,
-28, -31, -35, -38, -40, -44, -46, -50, -52, -56, -58, -62, -64, -67, -70, -73,
-76, -80, -81, -85, -88, -91, -94, -97, -99, -103, -106, -109, -111, -115, -118,
-117, -115, -111, -109, -103, -106, -96, -100, -87, -101, -57, 12, 2, 10, 9, 12,
16, 16, 22, 18, 29, 12, -28, -17, -13, -7, -1, };