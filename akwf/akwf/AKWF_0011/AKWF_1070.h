#define DATA_LENGTH 512
#define DATA AKWF_1070

const PROGMEM int8_t DATA[DATA_LENGTH] = {105, 124, 113, 119, 112, 116, 111,
114, 108, 111, 107, 110, 105, 106, 104, 103, 102, 102, 100, 99, 98, 97, 96, 95,
94, 92, 93, 91, 91, 89, 88, 86, 86, 84, 85, 83, 82, 81, 80, 79, 78, 78, 76, 76,
74, 73, 73, 70, 68, 69, 70, 71, 72, 74, 75, 75, 77, 77, 78, 79, 80, 82, 82, 83,
85, 85, 87, 87, 90, 89, 90, 91, 93, 94, 95, 96, 96, 98, 98, 101, 100, 103, 102,
105, 104, 107, 105, 109, 107, 112, 108, 114, 111, 115, 113, 118, 115, 120, 116,
6, -3, 3, -2, 1, -2, 1, -1, 1, 0, -1, 2, -7, -47, -41, -42, -40, -41, -40, -40,
-39, -38, -37, -36, -36, -34, -35, -32, -33, -31, -32, -30, -30, -29, -29, -28,
-28, -26, -26, -25, -25, -26, -26, -27, -28, -28, -28, -29, -30, -31, -32, -32,
-33, -33, -33, -34, -35, -36, -36, -37, -37, -38, -38, -40, -39, -41, -39, -43,
-40, -46, -36, 3, -1, 0, -1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, -1, 0, 0, 2,
-1, 2, -3, 13, 36, 29, 32, 29, 31, 28, 29, 28, 27, 26, 27, 26, 25, 25, 25, 24,
24, 23, 22, 22, 21, 22, 20, 20, 20, 19, 18, 18, 18, 18, 19, 20, 20, 20, 20, 21,
22, 22, 23, 23, 22, 24, 24, 23, 25, 25, 25, 25, 27, 27, 27, 27, 28, 28, 30, 28,
29, 28, 31, 29, 34, 26, -2, 1, -1, 0, 1, 0, 0, 0, 1, 0, 1, 0, 0, 0, 1, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0,
1, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, -18, -20, -17, -19, -16, -17, -16, -17,
-16, -15, -14, -15, -14, -14, -13, -13, -12, -10, -11, -10, -12, -12, -13, -14,
-14, -14, -14, -15, -15, -16, -17, -16, -17, -18, -19, -18, 0, -1, 0, 0, 0, 0,
0, 1, -1, 3, -54, -70, -63, -68, -63, -66, -63, -66, -63, -65, -62, -64, -63,
-63, -63, -63, -62, -61, -61, -61, -61, -61, -60, -60, -61, -59, -60, -58, -59,
-58, -58, -57, -58, -57, -57, -56, -57, -56, -56, -56, -55, -55, -56, -54, -54,
-54, -54, -54, -54, -53, -52, -53, -52, -52, -52, -51, -51, -52, -50, -50, -49,
-50, -49, -49, -49, -48, -48, -48, -48, -48, -48, -47, -46, -46, -47, -45, -46,
-46, -45, -45, -44, -45, -44, -43, -44, -43, -42, -43, -42, -42, -42, -42, -41,
-42, -41, -40, -39, -40, -40, -40, -39, -39, -38, -38, -38, -38, -38, -39, -40,
-40, -41, -43, -43, -44, -44, -45, -46, -47, -48, -49, -49, -50, -51, -52, -52,
-53, -54, -54, -56, -55, -57, -58, -59, -59, -62, -60, -64, -61, -66, -60, -70,
-51, 6, -2, 1, -1, 0, 0, -1, 0, 0, 0, -1, };