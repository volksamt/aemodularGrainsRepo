#define DATA_LENGTH 512
#define DATA AKWF_1042

const PROGMEM int8_t DATA[DATA_LENGTH] = {87, 123, 115, 121, 116, 120, 117, 120,
117, 120, 118, 120, 118, 120, 118, 119, 119, 119, 119, 119, 119, 118, 119, 119,
119, 119, 118, 119, 119, 119, 120, 118, 119, 119, 120, 119, 120, 118, 118, 119,
119, 118, 118, 119, 118, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 118,
118, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 118, 119, 119, 119, 119, 118, 119, 120, 119, 119, 119, 118, 119,
119, 118, 119, 119, 119, 119, 118, 118, 119, 119, 119, 118, 119, 119, 118, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 119, 118, 119, 119, 119,
119, 119, 120, 120, 119, 119, 120, 119, 119, 118, 119, 119, 120, 118, 119, 119,
119, 118, 121, 107, 103, 105, 103, 104, 103, 104, 103, 104, 103, 104, 105, 112,
107, 113, 42, -26, -13, -20, -15, -19, -16, -18, -17, -18, -16, -17, -18, -17,
-17, -17, -18, -16, -19, -13, -49, -66, -59, -63, -61, -62, -61, -62, -61, -62,
-62, -62, -61, -62, -62, -62, -62, -61, -62, -61, -62, -62, -63, -62, -61, -62,
-62, -62, -62, -61, -61, -61, -61, -61, -62, -61, -62, -62, -62, -62, -62, -61,
-61, -61, -62, -61, -62, -62, -62, -61, -62, -62, -62, -61, -61, -61, -61, -61,
-62, -62, -62, -61, -62, -62, -61, -62, -61, -62, -61, -61, -61, -62, -62, -62,
-61, -61, -61, -61, -62, -61, -61, -62, -62, -61, -61, -62, -61, -62, -62, -62,
-62, -61, -61, -62, -61, -61, -62, -62, -63, -62, -62, -62, -62, -62, -61, -61,
-62, -62, -62, -62, -62, -62, -62, -61, -62, -61, -62, -61, -62, -61, -62, -62,
-62, -61, -61, -61, -61, -62, -62, -62, -62, -62, -61, -62, -62, -62, -62, -61,
-62, -62, -62, -62, -62, -62, -62, -61, -62, -61, -62, -61, -62, -62, -62, -61,
-61, -62, -61, -61, -61, -62, -62, -62, -62, -62, -61, -62, -61, -62, -62, -62,
-61, -63, -61, -62, -61, -62, -62, -62, -61, -62, -62, -62, -62, -61, -62, -62,
-62, -62, -62, -62, -61, -61, -61, -62, -62, -62, -61, -63, -62, -62, -62, -62,
-62, -62, -62, -62, -62, -62, -61, -62, -61, -62, -61, -62, -62, -62, -61, -61,
-61, -62, -62, -61, -61, -62, -62, -62, -62, -62, -62, -63, -62, -62, -61, -61,
-63, -62, -62, -61, -62, -62, -62, -62, -62, -61, -61, -61, -62, -62, -61, -62,
-62, -61, -62, -62, -62, -61, -61, -62, -62, -61, -61, -62, -62, -62, -61, -62,
-62, -62, -61, -61, -61, -62, -62, -62, -62, -62, -61, -61, -62, -62, -61, -62,
-61, -63, -62, -62, -62, -62, -62, -62, -62, -62, -61, -62, -62, -62, -62, -62,
-62, -62, -61, -62, -62, -62, -62, -60, -62, -61, -63, -60, -45, -45, -46, -45,
-46, -44, -46, -46, -60, -50, -52, -42, };