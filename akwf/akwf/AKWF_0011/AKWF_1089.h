#define DATA_LENGTH 512
#define DATA AKWF_1089

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 4, 5, 7, 7, 8, 9, 10, 11, 12,
14, 14, 15, 17, 17, 18, 21, 21, 20, 20, 20, 20, 20, 21, 20, 22, 21, 21, 20, 20,
21, 20, 19, 19, 19, 18, 18, 18, 17, 17, 16, 16, 15, 15, 14, 14, 14, 13, 14, 13,
13, 13, 14, 13, 13, 12, 12, 12, 12, 12, 11, 10, 11, 10, 10, 10, 10, 10, 8, 11,
15, 18, 20, 22, 25, 26, 28, 32, 34, 37, 40, 44, 47, 50, 54, 58, 63, 67, 71, 75,
79, 83, 86, 89, 93, 97, 100, 103, 107, 109, 112, 115, 119, 118, 112, 110, 109,
107, 105, 104, 102, 100, 97, 94, 90, 86, 82, 77, 72, 67, 62, 57, 52, 46, 41, 35,
31, 27, 23, 19, 15, 11, 7, 3, -1, -4, -8, -11, -13, -12, -12, -14, -15, -17,
-18, -20, -21, -21, -21, -21, -22, -21, -20, -21, -19, -19, -18, -17, -17, -16,
-16, -16, -16, -15, -14, -14, -14, -14, -13, -13, -14, -13, -12, -12, -13, -12,
-13, -12, -12, -11, -11, -12, -11, -11, -10, -11, -10, -13, -17, -18, -19, -22,
-24, -26, -27, -28, -32, -33, -36, -39, -43, -45, -48, -52, -55, -58, -61, -65,
-67, -71, -74, -76, -79, -82, -83, -86, -90, -92, -95, -97, -99, -101, -104,
-106, -107, -102, -100, -99, -98, -95, -93, -92, -91, -89, -87, -84, -80, -77,
-73, -69, -66, -61, -57, -52, -49, -44, -41, -37, -33, -30, -27, -24, -20, -18,
-15, -12, -8, -7, 0, 15, 14, 4, 14, 25, 25, 24, 29, 34, 35, 38, 42, 47, 49, 53,
56, 58, 61, 63, 66, 68, 71, 73, 75, 76, 79, 80, 82, 84, 86, 88, 91, 92, 94, 97,
99, 100, 102, 105, 107, 109, 111, 110, 105, 104, 103, 101, 100, 98, 97, 96, 94,
91, 89, 86, 82, 79, 75, 72, 68, 64, 61, 57, 53, 49, 46, 43, 40, 37, 34, 32, 29,
26, 25, 22, 19, 17, 14, 11, 9, 7, 4, 2, -1, -4, -5, -7, -10, -12, -12, -11, -12,
-14, -15, -15, -16, -16, -16, -17, -17, -17, -18, -17, -17, -16, -15, -15, -14,
-14, -14, -13, -14, -13, -11, -11, -11, -12, -11, -11, -11, -12, -11, -11, -10,
-10, -11, -9, -10, -13, -14, -16, -16, -18, -20, -21, -22, -24, -25, -27, -29,
-31, -34, -35, -38, -40, -42, -44, -47, -49, -51, -53, -55, -56, -59, -60, -62,
-63, -65, -67, -68, -70, -72, -73, -75, -77, -78, -79, -81, -82, -84, -86, -87,
-88, -91, -92, -93, -94, -95, -97, -99, -100, -102, -103, -104, -106, -106,
-108, -110, -110, -106, -105, -104, -103, -102, -101, -101, -99, -96, -95, -94,
-91, -89, -87, -84, -82, -79, -76, -73, -71, -68, -66, -63, -61, -60, -57, -55,
-53, -51, -50, -49, -46, -45, -42, -41, -39, -37, -36, -34, -33, -31, -30, -28,
-26, -24, -23, -21, -20, -18, -17, -16, -14, -12, -11, -10, -8, -7, -6, -5, -3,
-3, -1, };