#define DATA_LENGTH 512
#define DATA AKWF_1078

const PROGMEM int8_t DATA[DATA_LENGTH] = {105, 124, 115, 122, 116, 121, 116,
121, 117, 120, 117, 119, 116, 118, 116, 118, 116, 118, 116, 116, 115, 116, 115,
114, 114, 114, 113, 113, 113, 111, 112, 111, 110, 109, 109, 108, 109, 107, 107,
106, 105, 105, 104, 104, 102, 102, 101, 101, 100, 100, 98, 98, 97, 96, 95, 94,
93, 93, 92, 91, 90, 89, 88, 87, 85, 85, 84, 83, 82, 80, 79, 78, 77, 76, 75, 75,
73, 72, 71, 69, 68, 67, 66, 65, 64, 62, 62, 60, 58, 56, 56, 54, 54, 53, 50, 50,
48, 47, 45, 43, 43, 41, 39, 38, 37, 36, 34, 33, 30, 30, 28, 26, 25, 24, 21, 23,
24, 25, 26, 27, 28, 28, 29, 31, 32, 32, 33, 34, 35, 36, 38, 39, 39, 41, 41, 42,
44, 45, 46, 48, 48, 50, 51, 52, 53, 54, 55, 57, 58, 59, 60, 61, 63, 64, 65, 67,
67, 69, 71, 73, 74, 75, 76, 78, 80, 81, 82, 83, 85, 85, 88, 89, 91, 92, 95, 94,
97, 97, 101, 100, 104, 104, 106, 108, 110, 111, 111, 117, 110, 127, 19, -33, -9,
-22, -10, -16, -7, -12, -5, -7, -3, -3, 0, 0, 0, 0, 0, -1, 1, 1, -1, 0, 1, 2, 1,
2, 0, 3, 1, 2, 1, 4, 3, 4, 4, 5, 4, 5, 5, 6, 7, 8, 8, 8, 8, 8, 10, 9, 11, 10,
12, 11, 14, 12, 15, 13, 18, 14, 19, 15, 21, 16, 22, 17, 27, 14, -117, -121,
-117, -122, -117, -121, -117, -121, -116, -120, -116, -119, -116, -118, -116,
-118, -115, -117, -115, -116, -114, -116, -115, -114, -115, -114, -112, -112,
-112, -111, -112, -111, -111, -109, -109, -108, -108, -107, -107, -106, -105,
-105, -103, -103, -102, -102, -101, -101, -100, -99, -98, -98, -96, -96, -95,
-94, -93, -93, -92, -91, -89, -88, -88, -87, -85, -84, -84, -82, -82, -80, -79,
-78, -77, -77, -75, -74, -73, -72, -70, -69, -68, -67, -66, -64, -63, -61, -60,
-60, -58, -57, -55, -54, -53, -53, -50, -49, -48, -46, -45, -44, -42, -41, -39,
-38, -37, -35, -34, -33, -32, -29, -28, -26, -25, -23, -22, -22, -24, -25, -26,
-27, -28, -29, -30, -31, -31, -32, -33, -35, -35, -36, -37, -39, -39, -40, -41,
-43, -44, -45, -46, -47, -48, -50, -50, -52, -53, -54, -55, -57, -58, -59, -60,
-62, -63, -64, -66, -66, -68, -69, -71, -72, -73, -75, -77, -78, -79, -80, -82,
-83, -86, -86, -89, -88, -92, -91, -95, -94, -99, -97, -101, -100, -104, -104,
-107, -107, -111, -111, -113, -115, -113, -127, -5, 29, 11, 21, 10, 16, 8, 11,
5, 8, 2, 3, -1, 1, 0, 1, -1, 0, -1, 0, 0, 0, 0, -2, -1, -2, -2, -2, -1, -2, -3,
-4, -4, -4, -3, -4, -5, -5, -5, -6, -6, -7, -7, -8, -8, -8, -9, -9, -11, -12,
-12, -12, -14, -14, -15, -15, -16, -17, -17, -18, -20, -19, -21, -20, -24, -19,
};