#define DATA_LENGTH 512
#define DATA AKWF_1095

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 5, 6, 8, 9, 9, 10, 11, 11,
11, 12, 12, 12, 14, 13, 13, 14, 13, 14, 15, 15, 15, 16, 16, 17, 16, 17, 17, 17,
18, 19, 20, 21, 22, 22, 24, 25, 26, 26, 26, 26, 27, 29, 28, 29, 29, 30, 30, 30,
31, 31, 31, 32, 32, 32, 32, 34, 34, 34, 35, 35, 36, 37, 37, 38, 39, 39, 40, 41,
42, 43, 44, 45, 45, 46, 47, 48, 47, 48, 49, 49, 50, 44, 37, 33, 31, 30, 28, 30,
31, 32, 35, 35, 35, 35, 33, 33, 33, 34, 37, 40, 43, 45, 48, 48, 47, 47, 45, 44,
44, 44, 45, 47, 47, 49, 50, 49, 49, 48, 48, 49, 50, 51, 48, 40, 32, 27, 22, 18,
16, 14, 13, 11, 13, 15, 18, 21, 24, 26, 26, 27, 25, 23, 22, 20, 20, 20, 22, 24,
27, 30, 32, 37, 39, 41, 44, 44, 46, 44, 44, 42, 41, 39, 37, 37, 36, 37, 38, 39,
41, 42, 44, 46, 46, 46, 46, 45, 46, 44, 44, 45, 46, 46, 47, 49, 50, 52, 54, 55,
58, 57, 57, 59, 59, 58, 58, 58, 58, 58, 58, 58, 58, 59, 60, 62, 63, 63, 65, 64,
66, 65, 65, 65, 65, 65, 67, 67, 67, 69, 69, 71, 72, 73, 73, 74, 75, 76, 76, 77,
77, 77, 77, 77, 77, 77, 79, 80, 80, 81, 82, 82, 82, 84, 83, 84, 84, 85, 80, 66,
49, 29, 10, -11, -34, -53, -68, -78, -86, -93, -97, -100, -103, -106, -109,
-113, -116, -118, -119, -118, -114, -108, -101, -94, -87, -81, -76, -73, -71,
-69, -68, -69, -69, -70, -71, -73, -76, -80, -83, -88, -93, -95, -98, -100,
-101, -100, -99, -96, -95, -92, -89, -84, -79, -74, -68, -60, -53, -46, -37,
-32, -27, -21, -17, -13, -12, -9, -8, -8, -9, -11, -13, -16, -20, -24, -29, -33,
-38, -41, -45, -48, -51, -53, -54, -54, -55, -56, -54, -54, -51, -49, -46, -43,
-41, -39, -36, -34, -32, -31, -30, -29, -28, -28, -29, -30, -31, -33, -34, -36,
-37, -39, -40, -41, -42, -42, -41, -41, -40, -39, -38, -35, -33, -30, -26, -23,
-20, -17, -13, -10, -7, -4, -7, -14, -21, -26, -31, -33, -35, -37, -40, -41,
-41, -42, -41, -41, -40, -40, -41, -43, -45, -47, -50, -52, -53, -53, -53, -50,
-47, -44, -39, -35, -30, -27, -23, -22, -21, -21, -21, -23, -24, -27, -28, -30,
-30, -31, -36, -44, -48, -51, -53, -53, -54, -53, -52, -50, -50, -50, -52, -53,
-53, -51, -49, -45, -40, -34, -29, -25, -22, -20, -20, -21, -23, -24, -25, -24,
-24, -23, -22, -23, -23, -23, -24, -24, -25, -24, -23, -22, -22, -21, -22, -22,
-22, -22, -23, -23, -22, -21, -19, -18, -15, -14, -13, -13, -11, -11, -10, -10,
-10, -10, -10, -9, -9, -8, -7, -8, -8, -8, -8, -8, -7, -8, -8, -6, -7, -6, -5,
-6, -5, -4, -2, -2, -1, };