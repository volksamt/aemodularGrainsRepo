#define DATA_LENGTH 512
#define DATA AKWF_1049

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 9, 10, 10, 10, 10, 11, 12, 12, 14,
14, 15, 15, 15, 16, 18, 18, 18, 19, 20, 19, 22, 21, 23, 23, 23, 23, 25, 25, 26,
27, 27, 27, 29, 30, 29, 30, 31, 31, 31, 32, 34, 34, 35, 35, 35, 36, 36, 37, 38,
39, 40, 40, 41, 41, 42, 42, 43, 44, 44, 45, 45, 45, 47, 47, 48, 48, 50, 50, 51,
51, 51, 52, 52, 54, 55, 55, 55, 56, 57, 57, 58, 59, 60, 59, 60, 61, 61, 63, 62,
63, 65, 64, 65, 66, 66, 67, 68, 68, 69, 69, 70, 71, 72, 72, 72, 73, 74, 74, 75,
77, 76, 77, 77, 79, 79, 80, 80, 81, 81, 83, 83, 84, 84, 85, 85, 85, 86, 87, 87,
87, 89, 89, 90, 90, 91, 92, 92, 93, 93, 93, 95, 95, 95, 97, 97, 98, 98, 99, 100,
100, 100, 102, 101, 103, 103, 104, 105, 105, 106, 106, 107, 108, 108, 109, 109,
110, 110, 110, 112, 113, 112, 114, 115, 115, 116, 115, 118, 111, 105, 105, 103,
102, 100, 99, 98, 97, 95, 94, 93, 92, 90, 89, 88, 86, 86, 83, 82, 81, 80, 78,
78, 76, 74, 73, 73, 71, 70, 68, 67, 65, 65, 63, 61, 61, 59, 57, 56, 56, 55, 52,
51, 50, 49, 47, 46, 45, 43, 42, 40, 40, 37, 36, 36, 34, 32, 32, 30, 28, 28, 27,
25, 24, 23, 21, 21, 19, 18, 16, 14, 13, 13, 11, 10, 9, 7, 6, 4, 4, 2, 1, 0, -1,
-3, -5, -6, -8, -9, -10, -11, -12, -13, -14, -16, -18, -19, -20, -20, -22, -23,
-25, -26, -28, -29, -30, -31, -33, -34, -35, -36, -38, -39, -40, -42, -42, -45,
-46, -47, -48, -49, -51, -51, -54, -55, -56, -58, -58, -60, -61, -62, -64, -65,
-66, -68, -68, -71, -71, -72, -75, -75, -77, -78, -78, -80, -82, -83, -84, -85,
-86, -88, -88, -91, -91, -94, -95, -95, -98, -99, -100, -101, -103, -103, -106,
-105, -111, -120, -118, -118, -116, -117, -115, -115, -115, -113, -113, -112,
-111, -111, -112, -110, -109, -109, -108, -107, -106, -106, -106, -105, -104,
-104, -103, -103, -101, -101, -100, -100, -99, -98, -98, -98, -97, -95, -96,
-94, -94, -94, -93, -92, -91, -91, -90, -89, -89, -88, -88, -88, -87, -86, -85,
-84, -84, -83, -83, -82, -82, -81, -81, -79, -79, -79, -78, -77, -77, -76, -75,
-74, -74, -73, -73, -72, -71, -72, -70, -69, -69, -68, -67, -67, -66, -66, -65,
-64, -64, -63, -63, -62, -61, -60, -60, -60, -58, -59, -58, -57, -57, -56, -55,
-54, -53, -53, -53, -53, -52, -51, -50, -50, -48, -48, -48, -47, -46, -45, -45,
-44, -44, -43, -43, -42, -41, -41, -41, -40, -39, -38, -37, -37, -37, -36, -35,
-34, -33, -33, -32, -31, -31, -30, -30, -29, -29, -28, -28, -27, -26, -26, -25,
-24, -23, -23, -23, -22, -22, -21, -20, -19, -19, -17, -18, -16, -17, -15, -16,
-13, };