#define DATA_LENGTH 512
#define DATA AKWF_1036

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 4, 4, 6, 7, 8, 9, 10, 11, 12,
12, 13, 14, 16, 16, 17, 18, 19, 20, 21, 21, 23, 24, 24, 24, 25, 26, 27, 28, 28,
30, 31, 31, 32, 33, 34, 34, 36, 36, 37, 39, 39, 41, 41, 43, 43, 44, 46, 46, 48,
49, 50, 51, 53, 53, 55, 55, 56, 57, 58, 60, 61, 62, 63, 63, 64, 65, 66, 66, 68,
68, 68, 69, 70, 70, 70, 70, 71, 71, 71, 71, 71, 71, 71, 70, 70, 70, 70, 69, 68,
67, 66, 66, 64, 63, 63, 60, 59, 58, 55, 54, 53, 51, 50, 49, 46, 44, 41, 40, 38,
36, 33, 32, 30, 26, 26, 23, 21, 18, 15, 13, 11, 10, 7, 5, 2, -1, -2, -3, -6, -8,
-10, -12, -13, -16, -18, -19, -21, -22, -23, -26, -28, -29, -30, -31, -32, -34,
-34, -36, -37, -37, -38, -38, -39, -40, -41, -41, -41, -41, -41, -41, -42, -42,
-42, -42, -42, -42, -42, -41, -42, -41, -40, -40, -40, -38, -38, -38, -36, -35,
-34, -34, -33, -32, -31, -29, -28, -26, -25, -22, -20, -18, -16, -13, -10, -6,
-3, 1, 6, 10, 14, 19, 24, 29, 35, 41, 45, 50, 56, 61, 66, 71, 77, 82, 86, 91,
94, 98, 103, 106, 109, 111, 113, 115, 116, 118, 119, 119, 119, 119, 118, 118,
116, 115, 113, 111, 108, 107, 104, 101, 97, 93, 90, 86, 82, 78, 74, 69, 65, 60,
55, 50, 46, 42, 36, 32, 28, 22, 18, 14, 9, 5, 1, -3, -6, -11, -14, -18, -21,
-25, -28, -30, -33, -35, -37, -39, -41, -42, -45, -46, -47, -48, -49, -49, -51,
-51, -51, -52, -52, -52, -52, -51, -51, -50, -50, -49, -48, -48, -47, -47, -46,
-46, -45, -44, -44, -43, -42, -42, -41, -40, -40, -39, -39, -37, -37, -36, -37,
-35, -36, -35, -34, -33, -33, -33, -32, -32, -31, -32, -31, -31, -30, -30, -29,
-30, -29, -28, -29, -28, -28, -27, -28, -27, -27, -27, -26, -26, -25, -26, -26,
-26, -26, -26, -25, -25, -26, -26, -26, -26, -25, -26, -27, -27, -27, -28, -29,
-28, -29, -29, -30, -31, -31, -32, -33, -33, -34, -35, -36, -36, -37, -38, -39,
-40, -40, -40, -41, -42, -43, -43, -45, -44, -45, -46, -46, -47, -46, -48, -48,
-48, -48, -48, -48, -48, -48, -48, -48, -48, -48, -48, -46, -46, -46, -46, -45,
-44, -44, -43, -43, -42, -42, -41, -39, -39, -38, -38, -36, -36, -35, -34, -33,
-33, -32, -32, -30, -30, -30, -29, -28, -28, -27, -26, -26, -25, -25, -25, -25,
-24, -25, -24, -24, -24, -24, -24, -23, -23, -24, -23, -24, -23, -24, -24, -25,
-23, -24, -25, -25, -23, -24, -24, -25, -24, -25, -24, -25, -25, -24, -24, -23,
-24, -24, -24, -23, -23, -23, -22, -22, -22, -22, -21, -20, -19, -19, -18, -17,
-16, -16, -15, -14, -14, -12, -11, -11, -9, -8, -7, -6, -6, -5, -3, -3, -1, -1,
};