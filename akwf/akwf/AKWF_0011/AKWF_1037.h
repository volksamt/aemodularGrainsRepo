#define DATA_LENGTH 512
#define DATA AKWF_1037

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 13, 16, 19, 23, 26, 30, 33,
37, 40, 43, 47, 49, 52, 56, 58, 62, 64, 67, 71, 73, 76, 78, 81, 84, 86, 89, 90,
93, 95, 97, 99, 100, 102, 104, 106, 107, 109, 110, 110, 112, 112, 113, 114, 114,
115, 116, 116, 116, 115, 119, 118, 116, 116, 112, 110, 106, 104, 101, 98, 95,
91, 88, 86, 83, 82, 79, 78, 76, 75, 75, 77, 78, 76, 75, 72, 71, 68, 65, 61, 58,
55, 52, 48, 47, 44, 41, 39, 37, 37, 35, 35, 36, 39, 37, 36, 35, 33, 31, 30, 27,
25, 22, 19, 17, 14, 11, 8, 6, 3, 0, -3, -7, -9, -12, -15, -18, -20, -23, -25,
-28, -30, -33, -34, -37, -38, -39, -40, -42, -43, -44, -45, -46, -46, -47, -44,
-42, -43, -41, -40, -39, -38, -35, -34, -32, -31, -28, -26, -25, -22, -20, -17,
-15, -12, -10, -7, -5, -1, 2, 5, 6, 9, 12, 15, 18, 21, 23, 26, 29, 30, 33, 36,
38, 41, 44, 46, 48, 51, 53, 55, 56, 59, 60, 62, 64, 64, 67, 68, 69, 70, 71, 72,
72, 73, 74, 74, 74, 75, 74, 77, 78, 76, 74, 72, 70, 67, 65, 61, 58, 54, 52, 49,
46, 43, 41, 39, 38, 35, 36, 34, 36, 39, 37, 36, 35, 33, 31, 29, 27, 25, 22, 19,
17, 13, 11, 8, 4, 2, 0, -4, -6, -10, -12, -14, -18, -21, -23, -26, -28, -31,
-32, -35, -37, -38, -39, -41, -42, -43, -45, -46, -46, -46, -46, -44, -42, -44,
-42, -42, -41, -40, -39, -38, -37, -35, -35, -33, -32, -31, -30, -28, -28, -26,
-25, -23, -22, -21, -19, -18, -17, -16, -15, -14, -13, -12, -10, -10, -10, -8,
-8, -7, -7, -6, -7, -7, -6, -6, -3, -3, -5, -7, -9, -11, -15, -18, -21, -24,
-27, -30, -33, -35, -38, -40, -42, -43, -46, -46, -47, -45, -43, -43, -43, -43,
-43, -43, -43, -43, -43, -43, -43, -43, -43, -43, -43, -43, -43, -43, -44, -43,
-44, -43, -44, -44, -44, -44, -44, -45, -44, -44, -45, -45, -45, -44, -45, -45,
-44, -45, -45, -44, -45, -45, -45, -46, -45, -46, -45, -45, -45, -46, -45, -45,
-46, -46, -46, -46, -45, -45, -46, -46, -46, -46, -47, -44, -42, -43, -42, -41,
-39, -40, -38, -37, -37, -35, -34, -33, -32, -30, -29, -28, -26, -24, -24, -22,
-21, -20, -18, -17, -16, -14, -13, -14, -12, -11, -10, -9, -9, -8, -8, -7, -6,
-7, -6, -6, -5, -5, -2, -3, -5, -6, -9, -12, -15, -18, -20, -23, -27, -30, -33,
-35, -38, -40, -41, -44, -45, -45, -45, -43, -43, -44, -46, -48, -51, -54, -57,
-60, -64, -66, -68, -72, -75, -77, -80, -82, -83, -85, -85, -86, -84, -81, -82,
-80, -80, -79, -77, -75, -73, -72, -70, -68, -66, -63, -60, -57, -56, -53, -49,
-46, -44, -40, -37, -34, -31, -28, -25, -21, -18, -14, -11, -8, -5, -1, };