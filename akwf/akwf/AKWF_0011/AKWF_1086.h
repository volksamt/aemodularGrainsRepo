#define DATA_LENGTH 512
#define DATA AKWF_1086

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 10, 15, 20, 24, 29, 33, 36, 40, 42,
45, 47, 50, 53, 55, 56, 58, 59, 60, 62, 63, 63, 65, 67, 67, 68, 68, 69, 70, 71,
71, 72, 72, 73, 74, 74, 74, 75, 75, 75, 75, 76, 77, 77, 76, 77, 78, 77, 78, 78,
78, 79, 78, 79, 79, 79, 79, 80, 80, 80, 79, 80, 80, 80, 80, 80, 80, 81, 80, 80,
80, 81, 80, 80, 79, 79, 79, 79, 79, 79, 79, 79, 79, 79, 79, 78, 78, 78, 78, 77,
78, 77, 77, 76, 76, 76, 75, 76, 75, 75, 75, 74, 73, 74, 74, 73, 73, 72, 72, 72,
71, 70, 69, 70, 69, 68, 68, 68, 68, 68, 67, 66, 65, 65, 64, 64, 64, 63, 62, 63,
61, 61, 61, 60, 59, 58, 58, 58, 57, 56, 56, 55, 55, 54, 54, 53, 52, 52, 51, 50,
49, 49, 48, 48, 47, 46, 46, 45, 44, 43, 43, 42, 42, 42, 41, 40, 39, 38, 38, 37,
36, 37, 35, 35, 34, 33, 33, 32, 31, 30, 29, 29, 28, 27, 27, 27, 25, 25, 24, 24,
23, 22, 22, 21, 20, 19, 19, 18, 17, 16, 16, 16, 14, 13, 14, 12, 12, 11, 10, 10,
9, 9, 8, 7, 6, 6, 5, 4, 4, 3, 2, 1, 1, 1, 0, -1, -1, -1, -2, -4, -4, -4, -4, -6,
-6, -7, -7, -7, -8, -9, -9, -11, -11, -11, -12, -12, -13, -14, -14, -14, -16,
-15, -16, -17, -17, -18, -18, -20, -19, -20, -20, -20, -22, -22, -22, -23, -24,
-24, -24, -24, -25, -25, -25, -26, -26, -26, -27, -28, -28, -29, -29, -29, -29,
-30, -30, -31, -31, -32, -31, -31, -32, -32, -32, -33, -34, -34, -34, -34, -34,
-35, -34, -35, -35, -36, -36, -36, -36, -37, -36, -38, -37, -37, -37, -38, -37,
-38, -38, -38, -38, -38, -38, -39, -39, -39, -38, -39, -40, -40, -40, -39, -40,
-40, -39, -40, -41, -40, -40, -40, -40, -40, -41, -40, -40, -40, -40, -40, -41,
-40, -40, -40, -40, -41, -40, -40, -40, -40, -41, -40, -40, -39, -40, -39, -40,
-39, -40, -39, -38, -39, -40, -39, -39, -39, -38, -38, -38, -38, -38, -37, -37,
-38, -37, -37, -37, -36, -36, -36, -35, -36, -36, -35, -35, -35, -34, -34, -34,
-34, -33, -33, -33, -33, -32, -32, -33, -32, -32, -31, -31, -31, -31, -30, -30,
-30, -29, -29, -29, -29, -28, -28, -27, -28, -27, -27, -26, -27, -25, -26, -25,
-25, -24, -24, -24, -24, -24, -23, -22, -22, -23, -21, -23, -19, -24, -17, -26,
-8, -72, -128, -89, -73, -63, -72, -77, -84, -86, -90, -92, -94, -96, -98, -100,
-102, -103, -103, -104, -103, -104, -103, -105, -103, -103, -101, -103, -101,
-101, -100, -100, -98, -98, -96, -96, -94, -94, -93, -92, -90, -90, -88, -88,
-86, -84, -85, -83, -81, -80, -80, -77, -78, -74, -75, -72, -72, -69, -71, -65,
-69, -61, -70, -44, 40, 27, 0, -9, -6, };