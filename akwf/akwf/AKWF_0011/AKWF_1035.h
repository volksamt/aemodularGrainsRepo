#define DATA_LENGTH 512
#define DATA AKWF_1035

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 5, 5, 7, 7, 8, 10, 10, 12,
13, 13, 15, 15, 16, 17, 18, 18, 20, 19, 21, 22, 22, 22, 24, 24, 26, 26, 27, 27,
28, 28, 29, 30, 30, 31, 31, 32, 34, 33, 35, 34, 35, 36, 36, 37, 37, 38, 38, 39,
39, 40, 40, 40, 41, 41, 42, 42, 43, 42, 42, 44, 43, 44, 45, 45, 45, 45, 45, 46,
46, 46, 47, 47, 47, 47, 47, 47, 47, 47, 49, 48, 48, 48, 48, 49, 48, 49, 49, 49,
50, 49, 49, 49, 49, 50, 50, 50, 50, 50, 49, 50, 50, 50, 50, 50, 49, 50, 51, 49,
50, 50, 50, 50, 50, 49, 51, 50, 50, 49, 49, 50, 50, 50, 49, 50, 49, 49, 49, 49,
50, 48, 49, 49, 49, 50, 49, 49, 49, 50, 50, 49, 49, 50, 50, 50, 50, 51, 51, 51,
51, 52, 53, 52, 54, 53, 54, 55, 55, 56, 56, 56, 57, 58, 58, 59, 59, 59, 60, 60,
61, 62, 62, 62, 62, 63, 63, 64, 64, 64, 65, 65, 65, 65, 65, 66, 66, 66, 66, 66,
67, 67, 68, 68, 67, 68, 68, 68, 68, 67, 68, 67, 67, 67, 67, 67, 68, 68, 67, 67,
67, 67, 67, 66, 67, 66, 66, 66, 65, 66, 65, 65, 65, 65, 64, 65, 64, 64, 63, 63,
62, 62, 62, 62, 61, 62, 61, 61, 61, 61, 59, 60, 60, 58, 59, 59, 59, 58, 58, 57,
56, 56, 56, 56, 56, 55, 54, 55, 53, 54, 53, 52, 52, 51, 51, 50, 50, 49, 49, 49,
48, 48, 47, 46, 46, 45, 45, 43, 42, 41, 41, 40, 39, 37, 36, 35, 34, 33, 32, 30,
28, 27, 25, 24, 23, 20, 19, 18, 16, 15, 13, 11, 10, 7, 5, 3, 2, -1, -2, -4, -6,
-7, -10, -11, -13, -16, -17, -19, -21, -22, -25, -27, -28, -30, -32, -34, -36,
-38, -38, -41, -42, -43, -46, -48, -49, -50, -53, -54, -55, -57, -59, -60, -61,
-64, -64, -67, -68, -69, -71, -72, -73, -74, -76, -77, -78, -80, -82, -82, -84,
-85, -85, -88, -89, -89, -91, -91, -93, -93, -94, -96, -97, -98, -99, -99, -101,
-102, -102, -103, -104, -104, -106, -105, -107, -108, -108, -109, -110, -111,
-111, -111, -112, -113, -114, -114, -114, -116, -116, -116, -116, -116, -117,
-118, -118, -118, -119, -118, -119, -119, -119, -119, -118, -118, -118, -119,
-119, -119, -118, -118, -118, -117, -117, -116, -115, -115, -114, -113, -113,
-111, -111, -110, -109, -107, -106, -106, -104, -102, -101, -101, -100, -98,
-97, -95, -94, -93, -91, -90, -88, -86, -84, -83, -82, -81, -79, -77, -75, -74,
-72, -72, -70, -69, -67, -64, -63, -62, -60, -59, -57, -56, -54, -53, -50, -50,
-48, -47, -45, -43, -43, -41, -40, -37, -37, -35, -33, -33, -30, -29, -28, -26,
-25, -25, -22, -21, -20, -19, -18, -16, -16, -14, -12, -12, -10, -10, -8, -7,
-6, -5, -2, -2, -1, 0, };