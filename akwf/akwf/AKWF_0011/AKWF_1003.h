#define DATA_LENGTH 512
#define DATA AKWF_1003

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 10, 8, 10, 8, 10, 8, 9, 8, 9, 8, 9,
8, 10, 8, 10, 9, 9, 9, 8, 10, 6, 43, 59, 51, 56, 53, 56, 53, 14, 6, 11, 7, 11,
7, 11, 8, 9, 9, 10, 8, 9, 8, 9, 8, 9, 9, 10, 9, 10, 9, 10, 9, 9, 9, 9, 9, 9, 9,
8, 10, 8, 10, 8, 10, 7, 11, 7, 11, 7, 11, 6, 12, 6, 15, 2, 27, 124, 117, 119,
120, 119, 119, 119, 119, 119, 120, 118, 120, 119, 120, 118, 119, 119, 119, 119,
119, 118, 119, 120, 119, 119, 119, 119, 119, 117, 120, 117, 122, 116, 123, 112,
127, 68, 3, 20, 10, 17, 14, 15, 14, 15, 15, 14, 14, 15, 14, 15, 14, 17, 12, 17,
12, 18, 11, 20, 7, 23, 2, 32, -21, -61, -5, -57, -35, -37, 10, 8, 8, 10, 6, 11,
6, 11, 6, 10, 6, 11, 6, 11, 7, 10, 7, 10, 7, 10, 7, 9, 8, 8, 9, 8, 10, 7, 10, 6,
10, 5, 11, 5, 13, -2, -40, -35, -38, -35, -38, -34, -41, -12, 14, 5, 10, 7, 9,
6, 10, 7, 8, 8, 8, 8, 8, 8, 7, 9, 6, 10, 6, 12, 3, 26, 58, 53, 54, 54, 51, 58,
28, 2, 11, 6, 9, 7, 9, 8, 8, 8, 8, 9, 8, 9, 8, 8, 8, 9, 7, 8, 8, 8, 8, 8, 8, 8,
8, 8, 8, 8, 8, 8, 7, 8, 9, 9, 8, 9, 8, 8, 7, 9, 7, 9, 7, 10, 6, 11, 5, -72, -91,
-64, -46, -44, -56, -48, -50, -21, 13, 6, 9, 7, 9, 9, 8, 8, 8, 9, 8, 8, 9, 8, 8,
9, 8, 8, 8, 8, 8, 7, 9, 8, 8, 9, 9, 8, 7, 8, 8, 9, 8, 10, 7, 9, 7, 11, 5, 14,
-13, -43, -34, -38, -35, -38, -35, -41, -1, 12, 7, 11, 6, 10, 8, 9, 7, 9, 8, 9,
9, 8, 9, 8, 9, 6, 10, 4, 21, 56, 50, 56, 53, 54, 54, 52, 54, 16, 5, 10, 7, 8, 8,
8, 8, 8, 8, 8, 8, 8, 9, 8, 8, 9, 8, 8, 8, 9, 8, 8, 8, 9, 7, 8, 7, 8, 7, 10, 7,
10, 6, 10, 6, 10, 6, 11, 5, 11, 3, -109, -118, -111, -116, -112, -116, -113,
-116, -112, -116, -113, -115, -113, -116, -112, -115, -113, -114, -114, -114,
-114, -114, -114, -114, -114, -114, -114, -113, -114, -114, -114, -113, -114,
-114, -114, -114, -114, -114, -114, -114, -114, -114, -113, -114, -112, -114,
-113, -114, -112, -114, -112, -114, -111, -115, -112, -115, -112, -115, -112,
-115, -113, -112, -117, -7, 15, 4, 13, 6, 11, 6, 11, 7, 10, 7, 11, 7, 10, 8, 9,
9, 9, 9, 9, 8, 9, 9, 9, 9, 8, 9, 8, 10, 8, 9, 9, 10, 8, 8, 9, 8, 9, 7, 10, 8,
10, 7, 10, 8, 10, 7, -32, -39, -34, -39, -34, -39, -30, };