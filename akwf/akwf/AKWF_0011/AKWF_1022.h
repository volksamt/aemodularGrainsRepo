#define DATA_LENGTH 512
#define DATA AKWF_1022

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 9, 11, 14, 15, 18, 19, 23,
24, 26, 28, 31, 33, 36, 38, 39, 41, 43, 45, 48, 49, 51, 53, 55, 56, 59, 60, 63,
64, 66, 68, 69, 71, 72, 74, 75, 77, 77, 79, 81, 82, 83, 86, 86, 88, 89, 90, 91,
92, 92, 94, 95, 96, 97, 98, 99, 99, 101, 101, 102, 102, 103, 104, 105, 105, 106,
106, 107, 108, 108, 108, 108, 109, 111, 110, 111, 112, 112, 112, 113, 113, 113,
113, 115, 114, 114, 115, 115, 115, 115, 116, 116, 116, 116, 116, 116, 116, 117,
117, 117, 118, 117, 118, 118, 118, 117, 118, 119, 118, 119, 118, 118, 119, 118,
119, 119, 119, 118, 119, 119, 118, 119, 119, 119, 120, 120, 118, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 118, 119, 118, 119, 118, 117, 118, 118, 118,
118, 118, 118, 118, 118, 118, 117, 117, 117, 117, 116, 116, 116, 116, 115, 115,
116, 114, 114, 114, 114, 113, 113, 113, 113, 112, 112, 112, 111, 112, 111, 110,
109, 110, 109, 108, 108, 107, 107, 106, 106, 106, 104, 104, 103, 101, 101, 100,
100, 98, 98, 97, 96, 94, 94, 93, 92, 91, 90, 89, 87, 87, 85, 83, 82, 81, 80, 78,
77, 76, 74, 72, 71, 70, 67, 66, 64, 63, 61, 58, 57, 56, 53, 52, 50, 48, 46, 44,
42, 40, 38, 36, 34, 32, 30, 28, 24, 22, 21, 19, 15, 15, 11, 9, 6, 4, 2, 0, -2,
-4, -6, -9, -11, -14, -15, -18, -19, -23, -25, -27, -30, -31, -33, -35, -37,
-40, -42, -44, -46, -47, -49, -51, -53, -56, -58, -59, -61, -62, -64, -66, -67,
-70, -70, -72, -74, -75, -76, -78, -80, -81, -83, -84, -85, -86, -87, -88, -89,
-91, -92, -93, -95, -96, -96, -97, -98, -99, -100, -100, -101, -102, -102, -104,
-104, -104, -105, -106, -107, -107, -108, -109, -108, -109, -109, -110, -110,
-111, -112, -111, -112, -113, -112, -114, -114, -113, -114, -114, -115, -115,
-116, -115, -115, -116, -116, -117, -117, -117, -117, -117, -117, -117, -117,
-117, -117, -118, -118, -118, -118, -117, -119, -118, -119, -119, -118, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -118, -119, -119, -119, -120, -119, -119, -118, -119, -118,
-119, -118, -118, -118, -118, -118, -118, -118, -117, -118, -117, -118, -117,
-117, -116, -117, -116, -116, -116, -117, -116, -116, -116, -114, -115, -114,
-113, -114, -113, -114, -112, -112, -112, -112, -111, -111, -111, -110, -109,
-109, -108, -109, -108, -107, -106, -106, -105, -105, -104, -103, -102, -102,
-101, -100, -99, -99, -98, -98, -95, -94, -94, -93, -92, -91, -90, -89, -87,
-85, -85, -84, -82, -81, -79, -79, -77, -75, -74, -72, -70, -70, -68, -66, -64,
-62, -61, -58, -57, -55, -53, -51, -50, -48, -46, -44, -42, -40, -37, -37, -34,
-32, -29, -27, -26, -23, -20, -19, -16, -14, -12, -8, -6, -4, -2, 0, };