#define DATA_LENGTH 512
#define DATA AKWF_1025

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 6, 7, 8, 10, 11, 13, 15,
15, 16, 17, 18, 20, 21, 21, 24, 24, 24, 26, 27, 28, 28, 30, 31, 31, 31, 32, 33,
34, 34, 34, 36, 36, 37, 36, 37, 37, 38, 38, 39, 38, 40, 40, 40, 40, 40, 40, 40,
40, 41, 40, 40, 40, 40, 39, 40, 40, 39, 39, 39, 39, 39, 39, 38, 38, 38, 38, 37,
37, 36, 36, 36, 35, 34, 34, 32, 33, 32, 32, 32, 30, 30, 29, 29, 28, 27, 27, 27,
26, 25, 24, 24, 24, 22, 22, 22, 21, 19, 19, 19, 18, 17, 18, 16, 15, 15, 15, 14,
14, 14, 13, 11, 11, 11, 11, 10, 10, 9, 9, 9, 8, 8, 8, 7, 7, 6, 6, 6, 6, 6, 5, 6,
4, 5, 5, 5, 5, 5, 5, 5, 4, 4, 5, 5, 5, 5, 5, 5, 6, 6, 6, 7, 7, 7, 7, 8, 8, 8, 9,
10, 10, 11, 12, 12, 12, 12, 13, 14, 15, 15, 17, 17, 17, 19, 19, 20, 21, 22, 23,
24, 25, 26, 26, 28, 29, 29, 31, 31, 32, 33, 34, 35, 37, 37, 39, 40, 40, 42, 43,
44, 45, 46, 47, 48, 50, 50, 52, 53, 53, 55, 56, 57, 58, 60, 60, 62, 62, 64, 64,
66, 66, 68, 69, 70, 71, 71, 72, 74, 74, 75, 76, 77, 78, 77, 79, 79, 80, 81, 81,
82, 83, 83, 84, 85, 85, 86, 87, 86, 87, 88, 87, 88, 87, 88, 89, 89, 88, 88, 89,
89, 89, 88, 88, 88, 88, 88, 88, 88, 88, 87, 86, 86, 86, 85, 85, 83, 83, 82, 82,
81, 81, 79, 79, 78, 76, 76, 75, 75, 74, 72, 71, 69, 69, 67, 66, 64, 63, 62, 61,
60, 58, 56, 54, 53, 52, 50, 49, 47, 45, 43, 41, 39, 38, 35, 35, 32, 31, 29, 26,
24, 23, 21, 19, 17, 15, 12, 10, 8, 7, 4, 3, 0, -2, -4, -6, -8, -10, -12, -15,
-18, -19, -21, -23, -25, -27, -29, -31, -34, -36, -38, -40, -41, -44, -46, -49,
-50, -52, -55, -56, -59, -60, -63, -65, -66, -67, -70, -71, -73, -76, -77, -78,
-80, -82, -83, -85, -87, -88, -89, -91, -93, -94, -96, -97, -98, -99, -101,
-101, -103, -104, -105, -107, -107, -108, -110, -110, -111, -112, -113, -114,
-114, -114, -115, -116, -116, -117, -118, -117, -118, -118, -118, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -118, -117, -116,
-117, -116, -116, -115, -114, -113, -113, -113, -112, -111, -111, -109, -108,
-108, -107, -106, -105, -104, -103, -102, -100, -99, -98, -97, -96, -95, -93,
-92, -90, -88, -87, -86, -84, -83, -82, -80, -78, -78, -75, -73, -72, -71, -70,
-67, -66, -64, -63, -61, -59, -57, -55, -54, -52, -51, -49, -47, -45, -44, -42,
-39, -38, -36, -35, -32, -31, -29, -28, -26, -25, -23, -20, -19, -18, -16, -14,
-13, -11, -10, -8, -7, -6, -4, -2, -1, };