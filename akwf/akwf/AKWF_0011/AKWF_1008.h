#define DATA_LENGTH 512
#define DATA AKWF_1008

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 10, 13, 18, 23, 28, 31, 36, 40,
45, 49, 53, 58, 62, 66, 71, 75, 79, 85, 88, 93, 97, 102, 105, 111, 108, 91, 77,
61, 47, 31, 16, 0, -4, -1, 25, 53, 78, 108, 109, 100, 96, 88, 82, 75, 69, 62,
56, 49, 43, 37, 31, 24, 17, 11, 5, -2, -3, -3, -3, -4, -3, -4, -3, -5, -11, -17,
-23, -29, -35, -41, -48, -54, -59, -66, -72, -79, -84, -91, -97, -104, -108,
-118, -112, -87, -66, -41, -19, 0, -13, -36, -58, -81, -105, -119, -110, -106,
-100, -95, -89, -82, -78, -72, -66, -60, -54, -49, -44, -38, -32, -27, -22, -15,
-10, -4, -3, -3, -2, -3, -3, -3, -3, -3, -3, -3, -3, -4, 0, 5, 10, 15, 19, 23,
28, 32, 36, 41, 45, 48, 53, 57, 62, 66, 71, 76, 79, 84, 89, 93, 97, 102, 105,
112, 107, 89, 75, 61, 45, 30, 16, 0, -4, 0, 26, 53, 80, 110, 108, 100, 95, 88,
82, 75, 68, 63, 55, 49, 42, 36, 30, 23, 17, 10, 4, -2, -4, -3, -3, -3, -4, -4,
-2, -4, -11, -17, -24, -30, -36, -42, -48, -54, -60, -66, -72, -79, -85, -91,
-97, -104, -109, -118, -111, -84, -64, -40, -17, 0, -14, -36, -60, -82, -107,
-120, -110, -106, -99, -94, -88, -84, -76, -71, -66, -60, -54, -49, -43, -38,
-32, -26, -21, -14, -9, -4, -3, -3, -3, -3, -3, -3, -3, -2, -3, -3, -3, -3, 1,
6, 11, 14, 18, 24, 28, 32, 36, 41, 45, 50, 53, 57, 63, 67, 71, 76, 79, 84, 89,
93, 97, 102, 106, 112, 107, 90, 75, 59, 45, 30, 14, -1, -5, 0, 27, 55, 82, 110,
108, 101, 95, 88, 82, 74, 68, 62, 55, 49, 42, 35, 29, 23, 17, 9, 3, -3, -4, -3,
-3, -3, -3, -4, -3, -5, -12, -18, -24, -30, -36, -42, -48, -55, -60, -66, -73,
-80, -85, -92, -97, -104, -109, -118, -110, -84, -62, -39, -16, 1, -15, -38,
-60, -83, -108, -118, -110, -105, -99, -93, -88, -83, -77, -72, -65, -60, -54,
-48, -42, -37, -32, -26, -20, -14, -9, -3, -2, -3, -3, -3, -3, -3, -3, -4, -3,
-3, -3, -3, 2, 6, 10, 14, 19, 23, 28, 32, 36, 41, 46, 50, 54, 58, 62, 66, 71,
76, 80, 85, 89, 94, 97, 103, 105, 112, 105, 88, 74, 59, 44, 29, 14, -1, -4, 2,
29, 56, 83, 110, 107, 100, 93, 87, 80, 74, 68, 61, 55, 49, 42, 35, 29, 23, 16,
10, 3, -3, -3, -3, -4, -3, -3, -3, -3, -5, -12, -18, -25, -30, -36, -43, -49,
-55, -61, -67, -73, -79, -85, -92, -97, -105, -109, -119, -108, -83, -62, -38,
-15, 0, -17, -39, -62, -84, -108, -119, -109, -105, -98, -93, -88, -82, -76,
-71, -66, -60, -54, -48, -42, -37, -32, -26, -20, -14, -8, -3, -3, -3, -3, -3,
-3, -3, -3, -3, -3, -3, -3, -3, };