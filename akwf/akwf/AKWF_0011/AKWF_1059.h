#define DATA_LENGTH 512
#define DATA AKWF_1059

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -1, 1, 1, 1, 2, 3, 6, 9, 11, 13,
15, 13, 12, 12, 12, 12, 12, 13, 14, 15, 15, 15, 14, 13, 13, 11, 12, 12, 12, 11,
13, 12, 12, 12, 11, 10, 11, 10, 10, 10, 10, 10, 10, 10, 10, 10, 9, 9, 9, 9, 9,
9, 8, 9, 9, 9, 9, 9, 9, 9, 9, 9, 9, 10, 10, 11, 11, 11, 11, 11, 11, 12, 12, 12,
12, 13, 13, 14, 15, 15, 16, 17, 16, 18, 18, 18, 19, 20, 20, 21, 20, 22, 22, 22,
22, 23, 22, 23, 24, 24, 24, 25, 24, 25, 26, 25, 26, 27, 25, 26, 27, 27, 27, 28,
28, 28, 28, 28, 28, 30, 29, 29, 29, 30, 35, 39, 34, 30, 29, 28, 26, 27, 29, 29,
29, 28, 29, 27, 26, 25, 25, 25, 24, 23, 24, 24, 23, 24, 22, 22, 21, 20, 20, 19,
19, 20, 19, 18, 18, 19, 18, 18, 16, 17, 17, 16, 16, 16, 16, 16, 16, 15, 15, 15,
17, 17, 18, 18, 18, 17, 17, 17, 18, 18, 19, 19, 20, 19, 20, 21, 20, 20, 20, 21,
21, 22, 23, 24, 25, 25, 25, 24, 23, 23, 22, 22, 22, 23, 22, 22, 22, 22, 21, 20,
20, 19, 18, 19, 19, 17, 17, 17, 17, 16, 17, 15, 15, 15, 15, 15, 15, 15, 14, 13,
13, 13, 13, 13, 12, 12, 12, 13, 12, 12, 13, 12, 12, 12, 12, 12, 12, 10, -12,
-46, -51, -26, -9, -10, -5, 2, -5, -16, -18, -17, -23, -28, -22, -17, -19, -17,
-13, -12, -18, -20, -20, -23, -26, -24, -21, -20, -19, -18, -16, -17, -19, -19,
-20, -21, -21, -20, -19, -19, -17, -17, -17, -18, -18, -19, -19, -19, -19, -18,
-18, -16, -15, -15, -14, -12, -10, -8, -5, -5, -5, -5, -5, -4, -4, -2, -1, 1, 3,
4, 5, 4, 5, 5, 6, 7, 9, 10, 12, 15, 16, 18, 17, 15, 15, 13, 13, 13, 14, 13, 14,
14, 14, 14, 13, 12, 12, 10, 11, 11, 11, 12, 11, 11, 10, 10, 9, 9, 9, 9, 9, 8, 8,
8, 9, 9, 8, 8, 8, 9, 8, 8, 8, 7, 8, 8, 8, 8, -28, -97, -122, -91, -46, -34, -28,
-13, -18, -39, -49, -47, -57, -65, -59, -47, -44, -42, -32, -28, -35, -39, -40,
-44, -49, -48, -43, -38, -37, -33, -28, -30, -32, -32, -33, -35, -36, -33, -31,
-30, -27, -26, -25, -27, -27, -27, -28, -29, -28, -27, -27, -26, -26, -25, -27,
-27, -27, -29, -28, -29, -29, -29, -30, -29, -29, -30, -30, -30, -31, -31, -32,
-32, -32, -32, -31, -31, -31, -31, -32, -32, -32, -31, -31, -31, -30, -29, -30,
-29, -29, -28, -29, -28, -28, -28, -26, -25, -26, -25, -24, -25, -24, -24, -23,
-23, -22, -22, -22, -22, -21, -20, -20, -20, -19, -19, -19, -17, -16, -13, -11,
-9, -10, -9, -9, -10, -9, -8, -7, -6, -3, -1, 0, };