#define DATA_LENGTH 512
#define DATA AKWF_1056

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 70, 121, 97, 45, 24, 20, 4, 4, 22,
38, 38, 44, 56, 53, 41, 35, 34, 26, 18, 23, 30, 31, 33, 39, 40, 35, 30, 28, 25,
21, 20, 23, 25, 26, 28, 28, 27, 24, 24, 22, 19, 19, 19, 21, 22, 23, 24, 24, 23,
22, 22, 22, 22, 22, 23, 24, 25, 26, 27, 26, 26, 27, 27, 26, 27, 29, 29, 30, 31,
31, 31, 31, 31, 31, 31, 31, 31, 30, 31, 31, 31, 31, 31, 29, 30, 30, 29, 29, 28,
27, 28, 28, 27, 26, 25, 26, 25, 24, 23, 25, 24, 24, 23, 23, 23, 22, 23, 23, 22,
22, 22, 22, 22, 22, 23, 23, 23, 22, 23, 24, 23, 24, 24, 25, 24, 25, 25, 26, 25,
26, 27, 26, 27, 28, 27, 27, 27, 27, 28, 27, 28, 28, 28, 28, 28, 27, 27, 28, 28,
27, 26, 27, 26, 26, 26, 25, 25, 25, 25, 24, 25, 24, 24, 23, 23, 23, 22, 23, 23,
22, 22, 22, 22, 22, 22, 23, 21, 21, 22, 22, 22, 22, 22, 22, 22, 23, 23, 22, 23,
23, 23, 24, 24, 24, 24, 24, 24, 25, 25, 25, 25, 24, 25, 25, 25, 25, 25, 25, 26,
25, 25, 25, 25, 26, 25, 25, 25, 25, 24, 24, 24, 23, 23, 23, 23, 23, 22, 23, 22,
23, 22, 22, 21, 21, 21, 22, 22, 21, 21, 21, 22, 21, 21, 21, 22, 21, 21, 21, 21,
20, 22, 21, 21, 21, 20, -7, -82, -128, -91, -37, -23, -18, -3, -3, -26, -40,
-38, -45, -57, -51, -39, -35, -34, -24, -17, -24, -31, -31, -34, -40, -40, -34,
-30, -29, -24, -20, -21, -24, -24, -25, -28, -29, -27, -24, -23, -22, -20, -19,
-20, -21, -22, -23, -25, -24, -23, -23, -22, -22, -21, -22, -24, -23, -25, -26,
-27, -27, -27, -27, -27, -28, -28, -28, -29, -30, -31, -30, -31, -30, -30, -31,
-30, -31, -31, -31, -31, -31, -31, -30, -31, -30, -29, -30, -29, -30, -28, -28,
-28, -28, -27, -26, -26, -25, -25, -25, -24, -24, -24, -23, -23, -23, -23, -23,
-22, -22, -22, -22, -22, -21, -22, -22, -23, -23, -22, -23, -23, -23, -24, -24,
-24, -24, -24, -25, -25, -25, -25, -26, -27, -26, -27, -27, -28, -27, -28, -28,
-27, -28, -28, -28, -28, -28, -28, -28, -28, -28, -27, -28, -27, -26, -26, -27,
-26, -25, -26, -26, -24, -24, -25, -25, -23, -24, -23, -23, -22, -23, -22, -23,
-22, -22, -22, -22, -22, -22, -23, -22, -22, -22, -21, -22, -23, -23, -22, -23,
-22, -23, -23, -22, -24, -24, -24, -23, -24, -23, -25, -25, -25, -25, -25, -25,
-25, -25, -25, -25, -26, -26, -26, -25, -25, -26, -26, -25, -25, -25, -25, -25,
-24, -24, -24, -24, -23, -23, -23, -22, -22, -22, -23, -22, -22, -22, -22, -21,
-21, -22, -21, -21, -22, -21, -21, -21, -20, -22, -21, -21, -21, -22, -21, -22,
-21, -22, -21, -24, -16, };