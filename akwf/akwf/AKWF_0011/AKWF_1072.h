#define DATA_LENGTH 512
#define DATA AKWF_1072

const PROGMEM int8_t DATA[DATA_LENGTH] = {94, 109, 94, 92, 77, 69, 51, 40, 23,
7, 7, 15, 12, 15, 15, 18, 17, 19, 20, 21, 22, 24, 25, 25, 27, 27, 29, 30, 31,
32, 33, 34, 36, 36, 38, 38, 40, 41, 42, 42, 44, 45, 46, 47, 48, 50, 49, 52, 53,
54, 54, 56, 56, 57, 58, 58, 60, 61, 62, 63, 63, 64, 65, 66, 68, 68, 69, 69, 70,
71, 71, 73, 73, 74, 75, 75, 76, 78, 78, 78, 79, 80, 81, 81, 82, 83, 83, 84, 84,
85, 85, 87, 86, 87, 87, 88, 88, 90, 90, 90, 91, 90, 91, 91, 92, 92, 92, 93, 93,
93, 94, 95, 95, 95, 95, 95, 95, 96, 96, 97, 97, 97, 96, 98, 98, 98, 98, 98, 99,
99, 98, 99, 99, 99, 99, 99, 99, 100, 100, 100, 100, 100, 99, 100, 101, 101, 100,
100, 100, 100, 100, 101, 101, 100, 101, 100, 101, 101, 101, 101, 100, 101, 101,
101, 101, 101, 100, 102, 102, 102, 102, 102, 101, 101, 101, 101, 101, 101, 102,
101, 101, 102, 101, 102, 102, 101, 102, 101, 102, 101, 101, 102, 102, 101, 102,
101, 102, 102, 101, 101, 101, 101, 101, 101, 101, 102, 101, 101, 101, 102, 101,
102, 102, 101, 102, 101, 102, 101, 102, 102, 101, 102, 102, 102, 102, 102, 102,
102, 102, 103, 102, 103, 103, 102, 102, 103, 103, 103, 103, 103, 103, 103, 103,
103, 103, 104, 104, 104, 104, 104, 104, 103, 104, 105, 103, 104, 104, 104, 104,
104, 105, 104, 104, 105, 105, 104, 105, 104, 105, 105, 105, 105, 105, 105, 106,
106, 105, 106, 106, 106, 106, 106, 106, 106, 106, 106, 105, 107, 107, 106, 106,
106, 107, 107, 107, 107, 107, 106, 107, 107, 107, 107, 107, 107, 108, 106, 107,
108, 107, 108, 107, 108, 107, 108, 107, 108, 107, 107, 107, 107, 108, 107, 108,
108, 107, 108, 108, 108, 107, 108, 108, 108, 108, 109, 108, 108, 108, 108, 109,
109, 108, 108, 108, 108, 108, 108, 108, 108, 108, 108, 108, 108, 108, 108, 109,
109, 109, 108, 108, 108, 109, 108, 108, 108, 108, 109, 109, 109, 108, 108, 109,
109, 109, 109, 108, 108, 108, 108, 109, 108, 109, 109, 109, 109, 108, 109, 109,
109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 108, 109, 108, 109, 108, 110,
108, 110, 107, 110, 107, 111, 107, 111, 107, 111, 107, 111, 107, 110, 106, -3,
-13, -5, -11, -5, -8, -3, -6, -1, -4, 1, -2, 2, 1, 4, 3, 5, 6, 7, 9, 9, 12, -13,
-21, -17, -19, -17, -18, -17, -18, -17, -16, -16, -14, -14, -14, -14, -13, -12,
-11, -22, -37, -49, -61, -71, -80, -87, -94, -98, -101, -103, -106, -107, -108,
-108, -108, -108, -109, -109, -108, -108, -109, -109, -108, -109, -110, -110,
-110, -111, -111, -112, -113, -113, -113, -114, -115, -114, -115, -115, -117,
-114, -117, -115, -117, -115, -117, -114, -118, -115, -117, -114, -118, -116,
-14, };