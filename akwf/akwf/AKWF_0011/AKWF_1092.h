#define DATA_LENGTH 512
#define DATA AKWF_1092

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 14, 18, 22, 25, 28, 33,
37, 41, 44, 47, 50, 54, 58, 61, 65, 68, 71, 73, 77, 80, 83, 85, 89, 91, 93, 96,
98, 99, 101, 104, 105, 107, 108, 109, 110, 111, 114, 114, 114, 116, 116, 117,
118, 118, 117, 118, 119, 119, 119, 118, 120, 120, 120, 119, 119, 119, 119, 118,
118, 118, 118, 118, 118, 118, 116, 116, 116, 115, 116, 115, 116, 116, 115, 113,
114, 113, 113, 113, 112, 112, 112, 112, 111, 111, 110, 109, 108, 108, 106, 107,
105, 104, 104, 102, 102, 101, 99, 98, 97, 95, 94, 92, 90, 88, 87, 86, 84, 81,
79, 77, 76, 74, 72, 70, 68, 66, 64, 61, 59, 59, 56, 53, 53, 51, 48, 48, 46, 44,
43, 41, 40, 40, 39, 38, 37, 37, 36, 36, 36, 36, 36, 37, 36, 37, 38, 39, 39, 39,
40, 41, 42, 43, 43, 45, 47, 47, 49, 49, 50, 52, 53, 54, 55, 56, 57, 57, 59, 60,
61, 62, 62, 63, 65, 65, 66, 67, 68, 68, 68, 69, 69, 70, 70, 70, 72, 71, 72, 71,
72, 71, 71, 72, 71, 71, 70, 71, 70, 71, 70, 69, 69, 69, 68, 68, 67, 66, 66, 66,
65, 64, 63, 63, 62, 61, 60, 60, 59, 58, 57, 56, 56, 55, 53, 52, 51, 49, 48, 47,
46, 45, 43, 41, 40, 38, 36, 34, 32, 30, 28, 26, 24, 22, 19, 16, 14, 11, 7, 5, 1,
-1, -4, -8, -11, -15, -18, -22, -25, -28, -32, -36, -39, -42, -47, -50, -53,
-57, -60, -64, -66, -69, -72, -76, -79, -80, -83, -86, -88, -91, -93, -95, -97,
-98, -100, -101, -102, -103, -105, -105, -107, -108, -108, -108, -109, -109,
-111, -111, -111, -110, -111, -111, -111, -110, -110, -111, -109, -110, -109,
-109, -108, -108, -108, -107, -107, -106, -106, -106, -105, -105, -105, -104,
-104, -103, -102, -103, -102, -102, -102, -100, -99, -99, -99, -99, -98, -97,
-97, -97, -96, -96, -95, -94, -94, -94, -92, -92, -92, -90, -91, -89, -89, -87,
-85, -85, -84, -83, -82, -81, -79, -77, -76, -75, -73, -72, -70, -68, -67, -65,
-64, -61, -60, -58, -56, -54, -53, -51, -50, -49, -46, -46, -44, -43, -42, -41,
-40, -39, -39, -38, -37, -37, -36, -36, -36, -36, -37, -37, -36, -37, -38, -38,
-39, -40, -41, -41, -43, -44, -45, -46, -48, -48, -50, -51, -53, -54, -56, -57,
-57, -60, -61, -61, -62, -64, -65, -66, -67, -69, -70, -70, -71, -73, -74, -74,
-75, -76, -76, -77, -77, -78, -78, -79, -78, -80, -79, -80, -80, -79, -80, -80,
-80, -80, -80, -80, -80, -79, -80, -78, -78, -78, -78, -78, -77, -76, -76, -76,
-75, -73, -74, -72, -71, -71, -70, -69, -69, -68, -67, -67, -64, -65, -63, -61,
-61, -60, -58, -57, -56, -55, -54, -51, -50, -49, -48, -46, -45, -43, -41, -38,
-37, -35, -33, -30, -28, -25, -22, -19, -18, -14, -11, -8, -6, -2, };