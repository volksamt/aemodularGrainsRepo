#define DATA_LENGTH 512
#define DATA AKWF_1009

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 3, 4, 5, 5, 6, 7, 8, 9, 9,
10, 11, 12, 13, 14, 15, 15, 16, 17, 18, 18, 19, 19, 21, 22, 22, 22, 23, 25, 25,
26, 26, 27, 28, 29, 29, 30, 31, 31, 33, 34, 34, 35, 35, 37, 37, 38, 39, 40, 41,
41, 42, 43, 44, 45, 45, 45, 46, 48, 48, 49, 49, 51, 51, 52, 53, 54, 54, 55, 56,
57, 57, 58, 59, 60, 61, 62, 61, 62, 63, 64, 64, 66, 67, 67, 68, 69, 70, 71, 71,
72, 73, 74, 74, 75, 76, 76, 77, 78, 78, 80, 80, 81, 81, 83, 83, 84, 84, 86, 87,
88, 88, 89, 89, 91, 89, 81, 73, 65, 58, 50, 42, 35, 27, 19, 11, 4, -2, -1, -1,
-1, -1, 0, -1, -1, -1, -1, -2, -1, -1, -1, -1, -7, -14, -19, -26, -32, -37, -45,
-51, -57, -63, -69, -76, -83, -89, -94, -102, -102, -96, -92, -88, -83, -80,
-75, -71, -66, -62, -57, -53, -49, -45, -41, -37, -32, -27, -24, -20, -15, -11,
-6, -2, -1, -1, 0, -1, -1, -1, -1, -1, -1, -2, -2, -1, -2, -1, -1, -2, -1, 0,
-2, -1, -1, -1, -1, -1, -2, -2, -2, -1, -1, -1, -1, -1, -1, -2, -1, -2, -1, -1,
-1, -1, -2, -1, -1, -2, -1, -1, -1, -1, -1, 0, -1, 0, -2, -1, -2, -2, -2, -1,
-1, -1, -1, -1, -1, -1, -1, -2, -1, -1, -1, -1, -2, -1, -1, -1, -1, -1, -1, -1,
-1, -2, -1, -2, -2, -2, -1, -1, -1, -1, -2, -1, -1, -1, -1, -2, -1, -1, -2, -1,
-1, -1, -2, -1, -1, -1, -1, -1, -1, -2, -1, 0, -2, -2, -1, -1, -2, -1, -1, -2,
-1, -2, -1, -2, -1, -1, -1, -1, -1, -1, -2, -2, -1, -1, -1, -1, -1, -1, -1, -1,
-1, -2, -2, -1, -1, -1, -1, -1, -2, -1, -1, -1, -2, -1, -2, -1, -1, -2, -1, -1,
-1, 0, -1, -1, -1, -1, -1, -2, -1, -1, -1, -1, -1, -1, 0, -1, -1, -1, -2, -1,
-1, -1, -1, -1, -2, -1, -1, -1, -1, -1, -1, -1, 0, -1, -1, -1, -2, -1, -2, -1,
-1, 0, -1, -1, -1, -1, -1, 0, -1, -1, -1, -1, -1, -1, -1, -2, -1, -1, -1, -1, 0,
-2, -1, -2, -1, -1, -2, -1, -1, 0, 0, 0, -2, -1, -2, -1, -1, -1, -2, -1, -1, -1,
-1, -1, -1, -1, -2, -1, 0, -1, 0, -3, -9, -14, -18, -23, -28, -33, -37, -43,
-47, -52, -57, -62, -66, -71, -75, -81, -86, -90, -96, -100, -105, -109, -114,
-118, -116, -112, -109, -105, -102, -99, -95, -91, -88, -84, -81, -77, -74, -70,
-67, -64, -61, -57, -54, -50, -46, -43, -39, -35, -32, -29, -25, -23, -19, -15,
-12, -8, -5, -1, -1, -1, 0, -1, -1, -1, -2, -1, -1, 0, 0, -1, -1, 0, -1, 0, 0,
0, -1, };