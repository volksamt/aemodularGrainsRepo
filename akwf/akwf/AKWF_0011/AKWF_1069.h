#define DATA_LENGTH 512
#define DATA AKWF_1069

const PROGMEM int8_t DATA[DATA_LENGTH] = {33, 41, 37, 39, 36, 39, 38, 38, 37,
38, 37, 37, 37, 38, 37, 37, 37, 37, 36, 37, 37, 36, 37, 36, 36, 36, 37, 35, 36,
35, 35, 35, 35, 35, 35, 35, 35, 34, 34, 34, 34, 35, 34, 34, 34, 33, 34, 34, 33,
33, 34, 33, 33, 32, 33, 33, 33, 32, 32, 32, 32, 32, 32, 32, 32, 32, 32, 31, 31,
31, 31, 31, 31, 30, 30, 31, 30, 30, 31, 30, 30, 30, 30, 30, 30, 29, 30, 29, 30,
28, 29, 28, 28, 28, 29, 29, 28, 29, 27, 28, 28, 28, 27, 27, 28, 28, 27, 27, 28,
27, 26, 26, 27, 26, 26, 26, 26, 26, 27, 25, 25, 25, 26, 25, 25, 25, 24, 25, 25,
25, 24, 24, 25, 24, 25, 24, 24, 23, 23, 24, 23, 23, 22, 24, 22, 23, 22, 24, 22,
23, 21, 22, 21, 23, 22, 22, 22, 23, 28, 27, 33, 31, 39, -7, 14, -52, -128, -109,
-119, -109, -114, -107, -108, -104, -104, -102, -99, -98, -95, -94, -92, -91,
-88, -87, -84, -84, -81, -81, -77, -77, -75, -73, -70, -69, -67, -70, -71, -72,
-73, -75, -76, -77, -78, -80, -82, -82, -84, -85, -87, -88, -90, -91, -92, -93,
-94, -96, -96, -99, -98, -102, -101, -105, -104, -108, -106, -111, -108, -114,
-110, -117, -111, -122, -107, 0, 0, -1, 2, -2, 2, -1, 1, 0, 0, 19, 27, 21, 25,
20, 22, 19, 21, 18, 18, 16, 17, 15, 15, 14, 15, 16, 16, 18, 17, 18, 19, 19, 20,
20, 22, 22, 23, 22, 25, 22, -1, 1, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 1, 0, 1, 1,
1, 0, -1, 0, -1, 1, -1, 2, -7, -19, -17, -18, -15, -16, -16, -15, -15, -14, -14,
-13, -13, -11, -11, -10, -11, -10, -10, -11, -11, -12, -13, -13, -13, -14, -13,
-14, -14, -15, -15, -16, -16, -16, -16, -17, -17, -17, -17, -1, 0, 0, 0, -1, 0,
0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0,
1, -1, 0, -1, 0, -1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 1, 0, 0, -1, 1, 0, -1, 0, 0, 0, 0, 0,
0, 0, 1, 1, 0, 1, -1, 11, 15, 13, 14, 12, 13, 12, 12, 10, 11, 10, 9, 9, 8, 8, 9,
9, 10, 11, 12, 11, 13, 12, 14, 12, 15, 9, -1, 1, 0, 0, 1, 0, 1, 0, -1, 0, 0, 0,
0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 1,
-1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, 1, 0, 1, };