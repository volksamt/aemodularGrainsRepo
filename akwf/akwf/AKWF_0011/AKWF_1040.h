#define DATA_LENGTH 512
#define DATA AKWF_1040

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 29, 48, 54, 54, 53, 55, 55, 56, 57,
57, 58, 58, 58, 59, 59, 60, 60, 62, 61, 62, 62, 62, 63, 64, 64, 65, 65, 66, 66,
67, 67, 68, 68, 69, 69, 70, 70, 70, 71, 71, 72, 73, 73, 74, 74, 75, 75, 76, 75,
76, 76, 78, 78, 78, 79, 80, 80, 80, 81, 81, 82, 82, 83, 83, 83, 84, 85, 85, 85,
86, 86, 87, 88, 87, 89, 89, 89, 89, 91, 91, 91, 92, 93, 93, 94, 93, 94, 95, 95,
95, 96, 97, 98, 97, 98, 99, 99, 99, 100, 101, 101, 102, 102, 102, 103, 104, 103,
104, 105, 106, 106, 107, 107, 108, 108, 108, 109, 109, 110, 110, 110, 112, 112,
112, 112, 114, 114, 113, 114, 115, 115, 116, 117, 117, 116, 118, 118, 119, 119,
115, 107, 100, 98, 91, 83, 80, 76, 66, 60, 64, 50, 13, -17, -14, -4, -8, -11,
-6, -5, -7, -6, -1, -4, -10, -13, -13, -13, -12, -12, -14, -14, -14, -14, -15,
-15, -15, -16, -16, -16, -16, -17, -17, -17, -17, -17, -17, -18, -18, -19, -18,
-19, -19, -19, -20, -20, -20, -21, -20, -20, -21, -22, -22, -22, -22, -22, -23,
-23, -23, -23, -23, -24, -25, -24, -25, -25, -26, -26, -26, -26, -26, -27, -27,
-27, -27, -28, -27, -28, -29, -28, -29, -29, -30, -29, -29, -30, -30, -30, -31,
-31, -32, -32, -32, -32, -32, -33, -33, -33, -34, -34, -34, -34, -34, -34, -34,
-34, -35, -36, -36, -36, -36, -36, -37, -38, -37, -37, -38, -38, -38, -39, -38,
-38, -38, -39, -39, -40, -40, -41, -41, -41, -41, -41, -42, -42, -43, -42, -43,
-43, -43, -43, -44, -44, -44, -44, -44, -45, -45, -45, -45, -45, -46, -46, -47,
-46, -46, -47, -47, -48, -48, -48, -49, -49, -48, -49, -49, -49, -50, -50, -50,
-50, -51, -51, -52, -52, -52, -52, -53, -53, -53, -53, -53, -53, -54, -54, -54,
-54, -55, -55, -55, -55, -56, -56, -56, -57, -57, -57, -57, -57, -57, -58, -58,
-58, -59, -59, -59, -59, -60, -60, -59, -61, -61, -61, -61, -60, -62, -62, -62,
-61, -63, -62, -63, -63, -64, -64, -64, -64, -64, -65, -65, -65, -66, -66, -66,
-66, -67, -67, -67, -67, -67, -67, -68, -68, -68, -67, -69, -69, -69, -69, -70,
-69, -68, -67, -66, -66, -65, -64, -64, -62, -61, -61, -60, -59, -60, -58, -58,
-56, -56, -54, -54, -53, -52, -52, -50, -50, -49, -49, -48, -47, -46, -46, -44,
-44, -43, -42, -42, -41, -39, -39, -38, -38, -37, -36, -36, -34, -33, -33, -32,
-30, -30, -30, -28, -28, -27, -27, -25, -25, -24, -24, -23, -22, -20, -20, -20,
-19, -17, -18, -16, -15, -15, -15, -13, -12, -12, -12, -6, -1, 0, -2, -2, -1,
-2, -2, -2, -3, -3, -3, -3, -3, -4, -5, -5, -5, -5, -6, -6, -6, -5, -6, -6, -6,
-8, -7, -8, -7, -7, -7, -9, -9, -8, -9, -12, -8, };