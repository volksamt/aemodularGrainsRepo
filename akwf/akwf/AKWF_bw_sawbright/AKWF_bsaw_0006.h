#define DATA_LENGTH 512
#define DATA AKWF_bsaw_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {43, 114, 115, 108, 108, 106, 107, 106,
106, 105, 105, 103, 102, 100, 98, 95, 93, 91, 87, 85, 82, 78, 75, 73, 70, 67,
65, 62, 59, 57, 55, 53, 50, 48, 47, 45, 44, 43, 43, 41, 41, 40, 40, 40, 39, 39,
39, 40, 39, 40, 41, 41, 41, 41, 42, 43, 43, 43, 44, 44, 45, 45, 46, 46, 47, 47,
47, 47, 48, 49, 48, 48, 48, 48, 48, 48, 48, 48, 48, 46, 48, 47, 46, 47, 46, 45,
45, 44, 44, 44, 44, 43, 43, 42, 42, 42, 41, 41, 41, 40, 41, 39, 39, 39, 39, 39,
38, 38, 38, 37, 37, 37, 37, 36, 37, 36, 35, 36, 36, 36, 35, 34, 34, 34, 33, 34,
33, 33, 33, 33, 33, 32, 32, 32, 32, 31, 31, 32, 31, 30, 30, 30, 30, 29, 29, 29,
29, 29, 29, 28, 28, 28, 27, 27, 27, 27, 26, 26, 26, 26, 25, 25, 25, 25, 24, 24,
24, 24, 22, 23, 23, 22, 23, 21, 21, 22, 21, 20, 21, 20, 20, 20, 19, 19, 19, 19,
19, 18, 18, 18, 18, 17, 16, 16, 17, 16, 15, 15, 15, 14, 15, 15, 14, 13, 14, 13,
13, 13, 13, 13, 13, 13, 11, 12, 11, 10, 11, 11, 10, 9, 9, 9, 9, 9, 8, 9, 8, 7,
7, 7, 6, 6, 7, 5, 5, 6, 5, 5, 5, 4, 4, 4, 4, 4, 3, 3, 3, 2, 2, 1, 1, 1, 1, 0, 0,
-1, 0, 0, -1, 0, -2, -1, -1, -2, -2, -2, -2, -3, -3, -3, -5, -5, -5, -5, -5, -5,
-5, -6, -6, -7, -7, -8, -7, -8, -8, -7, -9, -8, -8, -9, -9, -9, -9, -10, -11,
-11, -11, -11, -11, -12, -12, -12, -12, -13, -13, -13, -13, -14, -14, -14, -14,
-15, -16, -15, -16, -15, -16, -17, -17, -17, -17, -18, -18, -18, -19, -19, -19,
-19, -19, -20, -20, -20, -21, -21, -21, -20, -22, -22, -22, -22, -22, -22, -22,
-23, -23, -24, -24, -25, -25, -24, -26, -25, -26, -26, -26, -26, -27, -27, -27,
-28, -28, -28, -28, -28, -29, -29, -29, -29, -30, -30, -30, -31, -31, -31, -31,
-31, -31, -32, -32, -31, -32, -32, -34, -33, -34, -34, -34, -33, -34, -33, -35,
-35, -35, -35, -36, -36, -36, -36, -37, -37, -37, -37, -37, -37, -38, -39, -38,
-39, -40, -39, -40, -40, -41, -41, -41, -42, -42, -42, -43, -43, -44, -44, -44,
-44, -45, -45, -46, -45, -47, -47, -47, -47, -47, -47, -48, -48, -47, -48, -49,
-48, -48, -47, -47, -47, -47, -47, -47, -47, -46, -46, -46, -45, -44, -44, -44,
-43, -42, -42, -42, -42, -40, -40, -40, -40, -40, -39, -39, -39, -40, -39, -40,
-41, -42, -42, -43, -45, -46, -47, -49, -51, -52, -54, -57, -59, -62, -64, -67,
-70, -73, -76, -79, -81, -86, -88, -90, -94, -96, -98, -99, -102, -103, -105,
-106, -106, -107, -107, -107, -109, -107, -116, -110, -39, };