#define DATA_LENGTH 512
#define DATA AKWF_symetric_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 4, 5, 8, 10, 12, 14, 16, 18, 20,
22, 24, 26, 28, 31, 33, 35, 38, 39, 41, 43, 45, 47, 48, 50, 52, 54, 55, 57, 58,
61, 62, 64, 65, 67, 68, 70, 72, 74, 75, 76, 79, 80, 81, 83, 83, 85, 85, 87, 88,
90, 91, 92, 93, 94, 94, 95, 97, 97, 98, 99, 100, 101, 102, 102, 103, 104, 104,
105, 105, 107, 107, 108, 108, 109, 109, 109, 110, 110, 111, 111, 112, 112, 113,
114, 113, 113, 113, 115, 114, 115, 115, 115, 115, 116, 115, 116, 116, 117, 118,
117, 117, 117, 117, 117, 117, 119, 119, 118, 118, 118, 118, 119, 119, 119, 118,
119, 118, 119, 119, 119, 119, 119, 120, 120, 120, 119, 119, 119, 119, 119, 119,
118, 119, 119, 118, 119, 119, 119, 119, 119, 118, 118, 118, 118, 118, 118, 118,
118, 117, 117, 118, 117, 117, 117, 118, 117, 117, 116, 115, 115, 116, 116, 115,
115, 114, 114, 114, 113, 113, 113, 113, 112, 112, 112, 110, 111, 110, 110, 110,
108, 108, 108, 107, 106, 106, 106, 105, 104, 103, 102, 101, 101, 100, 99, 98,
98, 97, 95, 95, 93, 92, 92, 90, 89, 88, 87, 85, 84, 84, 82, 81, 79, 78, 76, 74,
74, 73, 70, 68, 67, 65, 65, 62, 61, 58, 58, 55, 53, 52, 51, 48, 46, 45, 42, 40,
39, 37, 35, 32, 30, 28, 26, 24, 23, 20, 18, 17, 14, 12, 10, 8, 5, 3, 1, -1, -4,
-5, -8, -9, -11, -13, -16, -18, -20, -23, -24, -26, -29, -30, -33, -35, -37,
-39, -41, -43, -45, -46, -49, -50, -52, -54, -55, -58, -59, -61, -62, -64, -66,
-67, -69, -71, -72, -74, -75, -76, -78, -79, -80, -82, -83, -84, -86, -87, -89,
-90, -90, -92, -93, -94, -95, -96, -97, -98, -98, -100, -100, -101, -102, -102,
-103, -104, -105, -105, -106, -106, -107, -108, -108, -109, -109, -109, -111,
-111, -111, -111, -112, -112, -113, -112, -114, -114, -114, -114, -115, -114,
-115, -116, -116, -117, -116, -116, -116, -118, -118, -117, -117, -118, -117,
-118, -118, -118, -119, -118, -118, -118, -118, -118, -119, -118, -119, -119,
-119, -118, -119, -118, -118, -118, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -120, -119, -118, -118, -118, -119, -119, -119, -119, -118,
-119, -118, -119, -119, -118, -118, -118, -118, -118, -118, -117, -117, -117,
-116, -116, -117, -116, -116, -116, -115, -116, -115, -115, -114, -115, -113,
-113, -113, -113, -112, -112, -112, -111, -111, -111, -110, -110, -109, -108,
-108, -107, -106, -106, -105, -104, -103, -103, -102, -102, -101, -100, -98,
-98, -98, -96, -95, -95, -93, -93, -91, -91, -88, -87, -87, -86, -84, -83, -82,
-81, -79, -77, -76, -75, -73, -72, -71, -68, -68, -65, -64, -62, -60, -58, -57,
-55, -54, -52, -49, -49, -46, -44, -42, -41, -38, -37, -34, -33, -30, -29, -27,
-25, -22, -20, -18, -16, -14, -11, -9, -8, -5, -3, -1, 0, };