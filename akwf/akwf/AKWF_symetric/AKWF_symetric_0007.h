#define DATA_LENGTH 512
#define DATA AKWF_symetric_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {54, 64, 59, 63, 59, 63, 61, 64, 62,
63, 63, 64, 64, 67, 68, 69, 68, 70, 69, 70, 70, 70, 71, 70, 71, 72, 73, 72, 72,
74, 73, 75, 76, 77, 78, 79, 79, 81, 82, 82, 82, 85, 85, 86, 87, 88, 89, 90, 90,
92, 93, 95, 94, 96, 97, 98, 98, 99, 100, 102, 102, 103, 104, 105, 105, 107, 108,
108, 110, 111, 111, 112, 113, 114, 115, 118, 119, 119, 119, 119, 118, 119, 119,
119, 117, 119, 117, 117, 116, 117, 116, 117, 114, 114, 113, 115, 112, 113, 110,
54, 48, 52, 49, 52, 50, 52, 49, 51, 49, 51, 49, 50, 49, 51, 48, 49, 49, 49, 49,
49, 49, 49, 48, 48, 48, 48, 49, 48, 48, 47, 48, 47, 47, 48, 47, 47, 47, 47, 48,
47, 47, 47, 47, 47, 46, 46, 46, 47, 47, 47, 46, 46, 45, 47, 46, 46, 46, 46, 46,
46, 45, 46, 46, 45, 45, 46, 45, 45, 45, 45, 45, 45, 45, 44, 44, 44, 46, 44, 45,
43, 46, 41, 48, 21, -1, 6, 0, 5, 2, 4, 2, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2,
2, 2, 2, 1, 2, 1, 2, 1, 2, 1, 2, 1, 1, 2, 0, 2, 1, 2, 0, 1, 1, 1, 0, 1, 0, 1, 1,
0, 0, 1, 0, 1, 0, 1, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, -1, -1, 0, 0, -1, -1, -1, -1, 0, 0, -1, 0,
-1, 0, -1, 0, 0, -1, 0, -1, 0, -1, -1, -2, -1, -1, 0, -1, -1, -2, -2, -2, -2,
-1, -1, -3, -1, -3, -2, -2, -2, -2, -1, -3, -2, -2, -2, -3, -3, -2, -2, -2, -4,
-2, -4, -1, -5, 2, -25, -48, -41, -45, -43, -45, -44, -44, -44, -45, -45, -45,
-45, -44, -45, -45, -45, -45, -45, -46, -45, -45, -46, -45, -46, -45, -46, -46,
-46, -45, -45, -46, -47, -46, -47, -46, -46, -47, -47, -46, -47, -46, -46, -47,
-46, -47, -47, -47, -47, -47, -47, -48, -47, -48, -48, -48, -49, -48, -48, -48,
-48, -49, -48, -49, -49, -48, -49, -49, -49, -49, -50, -49, -50, -50, -51, -50,
-51, -49, -52, -48, -52, -49, -52, -47, -56, -113, -112, -112, -114, -112, -115,
-114, -116, -115, -117, -116, -118, -116, -118, -118, -119, -118, -119, -119,
-119, -119, -119, -119, -118, -115, -114, -114, -112, -111, -110, -110, -108,
-108, -107, -106, -105, -104, -102, -102, -102, -100, -99, -99, -97, -97, -96,
-95, -93, -92, -92, -91, -90, -89, -88, -87, -86, -85, -84, -83, -82, -81, -80,
-80, -77, -77, -76, -75, -75, -74, -73, -73, -71, -72, -71, -72, -71, -71, -70,
-70, -70, -69, -70, -68, -69, -68, -67, -64, -64, -62, -65, -62, -64, -61, -64,
-59, -64, -59, -65, -53, };