#define DATA_LENGTH 512
#define DATA AKWF_symetric_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 7, 9, 11, 12, 13, 14, 16,
18, 19, 20, 22, 24, 25, 26, 27, 29, 31, 31, 33, 34, 36, 37, 38, 40, 41, 42, 44,
45, 46, 47, 48, 51, 51, 53, 54, 55, 56, 57, 59, 60, 62, 63, 64, 66, 67, 68, 70,
71, 72, 73, 74, 75, 76, 78, 79, 79, 80, 82, 82, 83, 84, 85, 86, 88, 88, 89, 90,
92, 93, 93, 94, 94, 96, 96, 97, 99, 99, 101, 100, 101, 102, 103, 103, 104, 104,
105, 106, 106, 107, 107, 108, 109, 110, 109, 111, 110, 111, 112, 112, 113, 113,
114, 114, 114, 116, 116, 116, 117, 117, 117, 117, 118, 117, 118, 118, 119, 119,
119, 119, 120, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 119, 118, 118,
118, 119, 118, 118, 117, 118, 116, 117, 116, 116, 116, 115, 115, 114, 114, 114,
113, 113, 112, 112, 111, 111, 110, 110, 109, 108, 108, 108, 107, 106, 106, 105,
104, 104, 103, 103, 102, 101, 100, 99, 99, 98, 97, 97, 96, 94, 94, 92, 92, 91,
90, 89, 88, 87, 86, 85, 84, 83, 82, 80, 81, 79, 78, 77, 76, 75, 73, 73, 71, 70,
69, 68, 66, 66, 65, 63, 62, 61, 59, 58, 56, 55, 55, 52, 52, 50, 48, 47, 45, 45,
43, 42, 41, 38, 37, 36, 35, 33, 32, 30, 29, 26, 26, 24, 22, 21, 19, 18, 16, 14,
14, 12, 9, 8, 7, 5, 4, 3, 1, 0, -2, -4, -6, -6, -8, -10, -11, -13, -15, -15,
-18, -20, -22, -22, -24, -26, -26, -29, -30, -32, -33, -35, -36, -38, -39, -40,
-43, -44, -44, -46, -47, -49, -50, -52, -53, -54, -56, -56, -58, -59, -60, -62,
-63, -65, -66, -66, -68, -69, -70, -72, -72, -74, -75, -76, -77, -78, -79, -80,
-81, -83, -83, -84, -85, -87, -88, -88, -89, -91, -92, -93, -93, -94, -95, -96,
-96, -97, -98, -99, -99, -100, -102, -101, -102, -103, -104, -104, -106, -105,
-106, -108, -108, -109, -108, -110, -111, -111, -111, -111, -113, -112, -113,
-113, -114, -113, -114, -115, -116, -116, -116, -117, -116, -117, -117, -117,
-117, -118, -118, -118, -118, -118, -119, -118, -119, -118, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -118, -118, -119, -117, -118,
-117, -117, -116, -116, -116, -116, -116, -114, -114, -114, -113, -113, -113,
-112, -112, -110, -111, -110, -109, -109, -109, -107, -107, -107, -106, -106,
-104, -104, -104, -103, -102, -101, -101, -99, -98, -99, -98, -97, -96, -95,
-94, -93, -93, -91, -90, -89, -88, -88, -87, -85, -84, -83, -83, -82, -80, -79,
-78, -77, -76, -75, -73, -73, -71, -70, -70, -68, -67, -66, -65, -63, -62, -61,
-59, -59, -57, -55, -55, -53, -51, -50, -48, -48, -46, -46, -44, -42, -40, -39,
-39, -37, -35, -34, -32, -31, -29, -29, -28, -26, -25, -23, -22, -20, -20, -17,
-17, -14, -13, -12, -10, -8, -7, -6, -4, -2, 0, };