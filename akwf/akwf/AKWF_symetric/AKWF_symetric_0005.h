#define DATA_LENGTH 512
#define DATA AKWF_symetric_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 9, 11, 13, 16, 17, 20, 23,
27, 30, 33, 36, 41, 44, 47, 50, 53, 56, 59, 62, 64, 68, 70, 73, 78, 80, 83, 87,
90, 93, 95, 97, 99, 101, 103, 104, 104, 105, 106, 106, 108, 108, 109, 109, 110,
110, 110, 112, 112, 113, 113, 114, 115, 115, 115, 116, 117, 118, 118, 118, 119,
119, 117, 116, 115, 114, 113, 111, 111, 111, 110, 110, 110, 110, 109, 108, 107,
105, 104, 103, 102, 100, 100, 101, 100, 100, 100, 99, 98, 98, 97, 96, 96, 95,
94, 94, 94, 94, 92, 92, 91, 91, 91, 89, 89, 89, 89, 88, 87, 88, 86, 86, 85, 84,
84, 80, 77, 74, 72, 70, 68, 66, 63, 58, 53, 49, 45, 39, 34, 30, 25, 23, 20, 19,
18, 16, 11, 4, 1, -1, -3, -4, -8, -10, -13, -15, -18, -20, -22, -23, -25, -26,
-29, -29, -32, -34, -37, -40, -43, -46, -53, -59, -61, -61, -64, -65, -66, -68,
-68, -70, -70, -71, -72, -73, -73, -75, -75, -76, -77, -78, -79, -80, -81, -82,
-83, -84, -85, -85, -87, -89, -91, -92, -92, -93, -93, -94, -94, -94, -95, -94,
-94, -94, -94, -94, -95, -94, -93, -93, -91, -89, -87, -86, -86, -86, -86, -86,
-86, -83, -82, -78, -76, -73, -72, -72, -71, -70, -69, -70, -69, -68, -68, -68,
-68, -61, -56, -55, -51, -48, -46, -40, -35, -31, -29, -26, -23, -19, -17, -14,
-10, -6, -6, -4, -4, -3, 2, 3, 4, 5, 6, 9, 14, 17, 19, 24, 26, 29, 32, 35, 41,
45, 48, 51, 54, 56, 62, 68, 68, 68, 68, 69, 69, 70, 70, 72, 71, 72, 73, 76, 78,
81, 84, 87, 86, 86, 85, 84, 86, 87, 90, 91, 92, 93, 94, 95, 95, 94, 94, 95, 94,
95, 94, 94, 94, 93, 92, 92, 92, 90, 89, 87, 87, 85, 83, 83, 82, 81, 80, 79, 78,
76, 76, 75, 75, 74, 72, 72, 71, 70, 70, 68, 67, 66, 65, 63, 62, 60, 59, 52, 46,
42, 40, 37, 34, 32, 29, 28, 27, 24, 23, 21, 20, 17, 14, 12, 10, 7, 5, 3, 0, -1,
-3, -12, -17, -18, -19, -20, -22, -26, -30, -36, -40, -45, -50, -53, -59, -63,
-67, -68, -70, -72, -74, -77, -81, -84, -85, -86, -87, -87, -88, -87, -88, -88,
-89, -90, -90, -91, -92, -92, -92, -93, -93, -94, -94, -94, -95, -96, -96, -97,
-98, -98, -99, -99, -99, -100, -100, -101, -102, -103, -103, -104, -106, -107,
-109, -109, -109, -110, -110, -111, -110, -111, -111, -113, -115, -114, -116,
-117, -119, -119, -119, -118, -117, -117, -116, -116, -114, -114, -114, -114,
-113, -112, -111, -111, -110, -109, -109, -108, -108, -107, -107, -106, -105,
-105, -103, -103, -100, -98, -96, -95, -93, -89, -87, -83, -80, -78, -74, -70,
-67, -64, -61, -58, -55, -53, -50, -47, -43, -40, -36, -34, -30, -27, -23, -20,
-18, -15, -12, -10, -8, -6, -3, 0, };