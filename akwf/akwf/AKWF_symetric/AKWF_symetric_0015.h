#define DATA_LENGTH 512
#define DATA AKWF_symetric_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 13, 15, 18, 21, 24, 28, 30,
33, 36, 39, 41, 45, 47, 50, 53, 55, 57, 59, 61, 63, 65, 68, 69, 71, 72, 75, 76,
78, 80, 81, 82, 83, 83, 85, 86, 88, 88, 89, 91, 90, 91, 92, 93, 92, 93, 94, 94,
94, 95, 96, 95, 95, 96, 96, 96, 96, 96, 96, 97, 97, 97, 97, 97, 97, 97, 98, 98,
98, 98, 98, 99, 99, 98, 99, 99, 100, 100, 100, 101, 100, 101, 101, 101, 101,
102, 102, 102, 104, 104, 104, 104, 105, 105, 105, 105, 106, 108, 107, 108, 109,
109, 109, 110, 111, 111, 111, 111, 112, 113, 112, 113, 113, 114, 115, 115, 115,
115, 116, 116, 117, 117, 117, 117, 117, 117, 118, 118, 119, 118, 119, 119, 119,
118, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 118, 119, 118, 118, 118,
118, 117, 117, 117, 116, 117, 116, 117, 116, 115, 115, 115, 116, 115, 115, 114,
115, 113, 114, 114, 114, 113, 113, 113, 112, 113, 113, 112, 112, 111, 112, 112,
112, 112, 111, 111, 112, 112, 111, 111, 111, 110, 110, 112, 111, 110, 110, 110,
110, 110, 110, 110, 110, 109, 108, 108, 108, 107, 107, 106, 105, 104, 104, 104,
103, 101, 100, 99, 99, 96, 95, 94, 93, 92, 90, 89, 86, 85, 83, 80, 78, 75, 73,
71, 68, 66, 63, 60, 57, 54, 50, 48, 44, 41, 38, 34, 30, 28, 24, 20, 17, 13, 9,
6, 2, -2, -6, -9, -13, -17, -20, -24, -28, -31, -34, -39, -41, -44, -47, -51,
-54, -57, -60, -63, -65, -68, -72, -74, -76, -78, -80, -83, -84, -87, -88, -90,
-91, -94, -95, -96, -97, -99, -100, -100, -101, -103, -103, -104, -104, -105,
-106, -106, -108, -107, -108, -108, -108, -109, -110, -110, -110, -110, -109,
-110, -110, -110, -110, -110, -111, -111, -111, -111, -111, -112, -111, -111,
-112, -112, -111, -112, -112, -112, -112, -112, -112, -113, -113, -114, -114,
-113, -113, -113, -114, -115, -114, -115, -115, -116, -116, -115, -116, -116,
-116, -117, -117, -117, -117, -118, -117, -118, -119, -118, -118, -118, -118,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-118, -118, -119, -118, -118, -117, -118, -117, -117, -117, -117, -116, -116,
-116, -115, -115, -114, -114, -114, -113, -113, -113, -112, -112, -111, -110,
-110, -110, -109, -109, -108, -108, -107, -107, -106, -106, -105, -105, -105,
-104, -105, -104, -104, -103, -102, -103, -102, -101, -100, -100, -101, -100,
-99, -99, -99, -99, -99, -99, -99, -99, -98, -98, -98, -98, -97, -97, -97, -97,
-97, -97, -97, -96, -97, -96, -97, -97, -96, -96, -95, -95, -95, -95, -93, -94,
-93, -94, -93, -93, -92, -92, -90, -90, -89, -88, -88, -87, -85, -85, -83, -82,
-80, -80, -78, -76, -75, -73, -71, -69, -66, -66, -63, -61, -60, -57, -55, -52,
-48, -47, -44, -42, -39, -35, -33, -30, -27, -25, -21, -18, -16, -12, -9, -5, 0,
};