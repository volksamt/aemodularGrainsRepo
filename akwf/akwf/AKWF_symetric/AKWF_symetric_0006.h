#define DATA_LENGTH 512
#define DATA AKWF_symetric_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {103, 123, 115, 121, 115, 121, 117,
121, 117, 120, 116, 120, 117, 118, 117, 118, 116, 117, 117, 117, 116, 116, 117,
117, 116, 116, 115, 115, 115, 114, 116, 115, 115, 115, 115, 115, 115, 114, 115,
114, 115, 115, 115, 114, 114, 114, 115, 113, 114, 113, 113, 113, 113, 113, 113,
113, 112, 112, 112, 113, 113, 112, 112, 112, 112, 112, 111, 111, 111, 112, 111,
110, 111, 111, 110, 109, 109, 108, 109, 109, 109, 108, 109, 108, 108, 107, 106,
106, 106, 106, 105, 105, 104, 103, 103, 102, 102, 101, 101, 98, 96, 95, 95, 94,
92, 92, 91, 91, 89, 88, 87, 87, 85, 83, 80, 78, 75, 73, 69, 65, 63, 60, 58, 54,
52, 52, 52, 51, 51, 50, 52, 48, 45, 42, 40, 40, 40, 39, 39, 38, 36, 34, 33, 32,
31, 30, 29, 28, 27, 27, 26, 24, 24, 23, 21, 21, 21, 20, 21, 20, 19, 19, 18, 17,
17, 17, 16, 15, 15, 15, 14, 15, 14, 14, 13, 14, 13, 12, 11, 11, 11, 10, 11, 10,
11, 10, 10, 10, 10, 10, 9, 10, 10, 9, 10, 9, 9, 9, 9, 9, 9, 8, 8, 8, 7, 7, 7, 7,
7, 6, 7, 6, 6, 6, 5, 6, 5, 6, 4, 5, 4, 4, 5, 5, 4, 4, 4, 3, 4, 3, 3, 3, 3, 3, 3,
2, 2, 3, 3, 3, 3, 2, 2, 1, 2, 1, 1, 1, 0, 2, 1, 1, 0, 0, 1, 0, 0, -1, 0, -1, -1,
-1, -1, -1, -1, -1, -2, -2, -2, -2, -2, -2, -3, -2, -3, -3, -2, -3, -3, -3, -3,
-3, -3, -3, -4, -4, -3, -4, -4, -5, -5, -5, -5, -5, -5, -4, -6, -5, -6, -6, -6,
-7, -6, -6, -7, -7, -7, -8, -8, -8, -9, -8, -8, -9, -9, -9, -9, -9, -10, -10,
-10, -10, -10, -10, -11, -11, -10, -11, -11, -11, -11, -11, -11, -11, -12, -12,
-13, -13, -14, -13, -13, -15, -15, -16, -16, -17, -16, -16, -16, -18, -19, -20,
-20, -20, -20, -21, -21, -21, -22, -24, -24, -26, -26, -27, -28, -30, -31, -32,
-33, -34, -34, -36, -39, -39, -39, -39, -41, -40, -43, -45, -49, -50, -51, -51,
-52, -52, -52, -51, -54, -58, -61, -62, -65, -69, -73, -75, -77, -80, -83, -86,
-86, -87, -88, -90, -90, -91, -92, -93, -94, -94, -95, -96, -99, -102, -101,
-102, -102, -103, -103, -104, -105, -105, -105, -106, -106, -106, -108, -108,
-109, -108, -108, -109, -109, -109, -110, -109, -109, -110, -111, -111, -112,
-112, -111, -111, -111, -112, -113, -112, -112, -113, -112, -112, -113, -112,
-113, -112, -112, -113, -113, -113, -113, -113, -113, -113, -114, -115, -114,
-114, -115, -115, -115, -114, -115, -115, -114, -115, -115, -115, -115, -116,
-115, -116, -115, -116, -115, -117, -115, -115, -116, -116, -116, -116, -117,
-116, -117, -117, -118, -117, -119, -117, -120, -117, -121, -116, -121, -116,
-121, -116, -123, -114, -125, -101, };