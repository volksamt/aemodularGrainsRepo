#define DATA_LENGTH 512
#define DATA AKWF_symetric_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 10, 13, 16, 19, 22, 24, 28,
25, 28, 32, 34, 37, 40, 42, 44, 47, 49, 51, 53, 57, 58, 60, 64, 66, 68, 70, 71,
74, 77, 78, 80, 83, 84, 87, 89, 91, 92, 94, 95, 97, 100, 100, 102, 104, 106,
107, 108, 110, 110, 112, 113, 114, 115, 116, 116, 118, 118, 118, 118, 119, 119,
118, 119, 118, 118, 117, 118, 116, 115, 114, 112, 111, 110, 107, 105, 102, 100,
96, 94, 90, 86, 83, 78, 74, 73, 68, 61, 52, 44, 36, 28, 20, 15, 5, -9, -15, -19,
-22, -27, -48, -60, -56, -58, -56, -56, -55, -54, -54, -54, -53, -53, -53, -52,
-52, -53, -53, -51, -52, -49, -50, -48, -48, -46, -46, -46, -45, -43, -43, -42,
-41, -40, -39, -38, -37, -35, -35, -35, -33, -33, -32, -31, -31, -30, -30, -29,
-28, -27, -27, -26, -25, -25, -24, -24, -23, -24, -25, -25, -25, -26, -25, -25,
-26, -26, -27, -26, -27, -28, -29, -29, -30, -31, -31, -31, -32, -34, -34, -35,
-35, -36, -37, -37, -38, -39, -40, -40, -42, -42, -43, -44, -44, -45, -46, -47,
-47, -47, -48, -49, -50, -50, -51, -52, -52, -52, -53, -54, -54, -55, -56, -55,
-56, -56, -57, -57, -57, -57, -57, -56, -54, -53, -52, -49, -49, -49, -48, -49,
-48, -47, -46, -46, -44, -44, -44, -42, -41, -41, -40, -39, -38, -37, -35, -35,
-33, -32, -32, -30, -29, -27, -25, -24, -24, -25, -36, -21, 24, 35, 24, 24, 24,
26, 27, 28, 30, 31, 32, 34, 34, 36, 37, 38, 39, 40, 41, 41, 43, 43, 45, 45, 45,
47, 47, 48, 49, 49, 49, 49, 49, 53, 54, 55, 57, 57, 56, 57, 57, 57, 56, 55, 56,
54, 55, 54, 54, 53, 53, 52, 52, 51, 50, 50, 48, 48, 47, 47, 47, 45, 45, 45, 43,
43, 41, 41, 41, 39, 38, 38, 37, 36, 36, 35, 34, 34, 32, 32, 32, 31, 31, 30, 28,
28, 27, 27, 27, 26, 26, 26, 25, 25, 26, 25, 25, 25, 24, 23, 24, 25, 25, 25, 26,
26, 28, 27, 28, 29, 31, 31, 31, 33, 34, 33, 35, 36, 37, 37, 38, 40, 40, 41, 42,
42, 43, 44, 46, 46, 47, 48, 48, 49, 50, 51, 52, 52, 53, 52, 52, 52, 53, 54, 54,
54, 55, 55, 56, 56, 58, 56, 59, 47, 26, 22, 19, 15, 8, -7, -16, -21, -28, -36,
-44, -53, -60, -68, -74, -74, -79, -82, -86, -90, -93, -97, -100, -103, -105,
-107, -109, -111, -112, -114, -115, -117, -118, -118, -118, -118, -119, -119,
-119, -119, -119, -118, -118, -116, -117, -116, -115, -115, -114, -111, -111,
-109, -108, -107, -105, -103, -102, -100, -99, -98, -96, -93, -92, -90, -89,
-86, -84, -82, -80, -79, -76, -74, -72, -70, -67, -64, -62, -61, -58, -56, -53,
-52, -49, -47, -44, -42, -40, -37, -33, -32, -27, -26, -28, -24, -22, -18, -15,
-12, -10, -7, -4, -1, };