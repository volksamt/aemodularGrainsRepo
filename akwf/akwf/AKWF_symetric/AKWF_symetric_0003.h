#define DATA_LENGTH 512
#define DATA AKWF_symetric_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 17, 24, 31, 37, 44, 49, 55, 60,
64, 67, 70, 73, 73, 72, 73, 70, 68, 66, 63, 60, 57, 55, 52, 51, 50, 49, 50, 52,
54, 57, 58, 63, 67, 71, 75, 79, 84, 88, 93, 96, 101, 104, 108, 111, 114, 115,
117, 118, 119, 120, 119, 117, 114, 112, 108, 103, 98, 93, 86, 80, 74, 67, 61,
56, 50, 45, 42, 39, 36, 34, 34, 32, 31, 31, 31, 31, 31, 31, 31, 32, 32, 31, 31,
30, 30, 29, 27, 27, 23, 21, 19, 16, 13, 10, 6, 2, -2, -8, -12, -17, -21, -26,
-30, -33, -37, -37, -39, -40, -40, -39, -39, -38, -36, -34, -32, -29, -27, -25,
-22, -20, -17, -16, -14, -13, -12, -10, -10, -10, -8, -9, -10, -9, -9, -11, -11,
-12, -14, -15, -17, -17, -18, -19, -19, -18, -17, -16, -15, -11, -8, -5, -2, 3,
7, 10, 15, 20, 23, 26, 30, 32, 35, 36, 37, 38, 38, 39, 38, 37, 36, 34, 32, 30,
27, 23, 21, 17, 13, 9, 7, 4, 1, -1, -2, -4, -4, -3, -3, -2, 1, 5, 8, 12, 17, 21,
26, 29, 33, 36, 38, 40, 41, 41, 41, 40, 39, 37, 35, 32, 29, 26, 23, 18, 15, 10,
7, 3, -2, -7, -11, -14, -18, -21, -23, -25, -25, -26, -25, -23, -20, -17, -12,
-7, -2, 3, 9, 14, 19, 23, 28, 30, 32, 33, 33, 32, 32, 29, 28, 24, 20, 17, 14, 9,
6, 2, -3, -6, -10, -13, -17, -21, -24, -27, -29, -32, -33, -33, -33, -32, -29,
-27, -24, -19, -15, -8, -3, 3, 8, 13, 17, 20, 24, 25, 25, 25, 25, 23, 20, 18,
15, 10, 6, 2, -2, -6, -10, -15, -19, -22, -26, -29, -31, -34, -36, -39, -41,
-40, -41, -42, -41, -38, -35, -33, -29, -26, -21, -17, -12, -8, -4, -2, 2, 3, 4,
5, 3, 3, 1, -1, -5, -7, -10, -14, -17, -21, -23, -27, -30, -31, -34, -36, -37,
-37, -38, -38, -38, -37, -36, -34, -32, -29, -26, -22, -19, -15, -11, -6, -2, 2,
6, 9, 12, 15, 16, 17, 18, 19, 19, 19, 18, 16, 15, 13, 12, 12, 10, 9, 9, 10, 8,
9, 9, 10, 10, 12, 13, 14, 16, 19, 20, 23, 24, 26, 29, 32, 34, 36, 37, 39, 39,
41, 40, 39, 38, 36, 32, 29, 25, 20, 16, 12, 7, 2, -2, -6, -10, -13, -17, -19,
-21, -23, -26, -28, -28, -30, -32, -31, -31, -32, -32, -31, -31, -31, -30, -31,
-31, -30, -32, -33, -34, -36, -39, -43, -46, -51, -56, -62, -68, -75, -80, -86,
-93, -99, -104, -109, -112, -115, -118, -119, -119, -119, -119, -117, -116,
-114, -110, -108, -105, -101, -96, -93, -88, -84, -78, -74, -71, -66, -63, -60,
-56, -53, -51, -50, -50, -51, -51, -52, -55, -57, -60, -63, -66, -68, -71, -72,
-72, -73, -73, -70, -68, -64, -60, -55, -49, -44, -37, -30, -24, -16, -10, -2,
};