#define DATA_LENGTH 512
#define DATA AKWF_symetric_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 6, 8, 10, 11, 13, 14, 16,
17, 18, 20, 21, 23, 24, 25, 27, 28, 30, 32, 33, 34, 35, 36, 38, 39, 40, 41, 43,
44, 45, 46, 48, 49, 50, 51, 52, 53, 54, 55, 57, 58, 58, 59, 60, 61, 62, 64, 63,
64, 65, 66, 67, 69, 69, 70, 72, 72, 72, 72, 74, 75, 75, 76, 77, 78, 78, 79, 79,
80, 81, 81, 82, 84, 84, 85, 85, 86, 86, 87, 88, 89, 89, 89, 90, 91, 91, 92, 92,
94, 94, 95, 95, 96, 96, 97, 97, 97, 99, 99, 100, 100, 101, 102, 103, 103, 105,
104, 105, 105, 106, 107, 107, 108, 109, 108, 109, 110, 110, 111, 111, 112, 113,
113, 113, 113, 113, 114, 115, 115, 116, 117, 117, 117, 117, 117, 118, 118, 118,
119, 119, 119, 119, 119, 118, 120, 118, 119, 120, 119, 120, 119, 119, 119, 118,
118, 117, 118, 117, 117, 116, 116, 116, 116, 115, 115, 113, 114, 113, 112, 111,
112, 110, 110, 109, 108, 107, 107, 106, 105, 104, 103, 102, 101, 100, 100, 99,
98, 97, 95, 95, 93, 92, 91, 91, 89, 88, 87, 85, 84, 82, 82, 80, 78, 77, 76, 75,
73, 71, 70, 69, 68, 66, 65, 64, 62, 61, 59, 57, 56, 55, 53, 52, 50, 48, 46, 45,
43, 41, 40, 38, 37, 36, 33, 32, 31, 28, 27, 26, 25, 22, 20, 19, 18, 15, 14, 13,
11, 9, 7, 6, 5, 3, 1, -1, -3, -5, -6, -8, -9, -12, -12, -15, -16, -18, -19, -21,
-22, -25, -25, -27, -29, -31, -33, -34, -35, -36, -39, -40, -42, -44, -45, -47,
-49, -50, -52, -53, -55, -56, -58, -59, -60, -62, -64, -65, -67, -68, -70, -71,
-72, -74, -74, -76, -78, -79, -79, -81, -83, -84, -85, -86, -88, -90, -90, -91,
-92, -93, -95, -96, -98, -97, -99, -99, -101, -102, -103, -103, -105, -105,
-106, -107, -108, -108, -109, -110, -111, -111, -111, -112, -113, -113, -114,
-115, -116, -116, -115, -116, -116, -117, -117, -118, -118, -118, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119,
-118, -118, -117, -117, -117, -117, -117, -116, -116, -116, -115, -115, -114,
-115, -113, -113, -114, -112, -112, -112, -111, -110, -109, -109, -109, -108,
-107, -106, -106, -106, -105, -105, -105, -104, -103, -102, -103, -101, -100,
-100, -100, -99, -98, -97, -97, -95, -95, -95, -94, -93, -93, -93, -91, -91,
-90, -89, -89, -88, -88, -88, -87, -87, -85, -85, -84, -84, -83, -83, -81, -81,
-80, -80, -78, -78, -78, -77, -76, -75, -75, -74, -74, -73, -71, -70, -70, -69,
-68, -67, -66, -66, -64, -64, -63, -62, -61, -60, -59, -58, -57, -55, -54, -55,
-53, -51, -52, -50, -49, -47, -47, -44, -43, -43, -41, -40, -38, -37, -36, -34,
-34, -32, -30, -29, -28, -27, -25, -24, -22, -21, -19, -18, -17, -15, -13, -12,
-10, -9, -7, -6, -5, -3, -3, -1, };