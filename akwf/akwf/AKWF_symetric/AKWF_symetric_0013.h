#define DATA_LENGTH 512
#define DATA AKWF_symetric_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 11, 15, 20, 24, 28, 31, 34, 38,
40, 42, 44, 47, 50, 53, 56, 58, 61, 63, 66, 67, 70, 73, 75, 77, 79, 81, 82, 83,
85, 86, 87, 89, 88, 89, 90, 91, 92, 92, 94, 93, 94, 94, 95, 96, 97, 96, 97, 98,
98, 99, 100, 100, 101, 100, 101, 102, 103, 103, 103, 104, 104, 104, 106, 105,
105, 106, 106, 107, 107, 108, 108, 107, 108, 108, 108, 109, 109, 109, 110, 110,
111, 111, 111, 112, 112, 113, 113, 112, 113, 113, 113, 114, 114, 114, 114, 114,
114, 114, 115, 115, 115, 115, 116, 116, 115, 116, 115, 117, 116, 116, 116, 116,
116, 116, 116, 117, 117, 117, 117, 118, 118, 117, 118, 118, 119, 118, 118, 119,
119, 119, 119, 120, 119, 119, 118, 119, 119, 119, 118, 119, 119, 118, 118, 117,
116, 117, 116, 114, 114, 113, 112, 111, 110, 108, 108, 105, 103, 101, 100, 98,
96, 92, 91, 88, 87, 84, 81, 78, 77, 74, 71, 71, 68, 65, 64, 61, 60, 58, 56, 55,
53, 52, 50, 48, 48, 46, 44, 44, 42, 41, 40, 39, 37, 38, 36, 35, 35, 34, 33, 32,
31, 31, 30, 29, 28, 27, 27, 27, 26, 25, 24, 25, 24, 23, 22, 23, 22, 21, 21, 20,
20, 19, 18, 18, 17, 16, 16, 16, 14, 15, 13, 12, 12, 12, 11, 11, 10, 9, 9, 8, 7,
6, 7, 5, 5, 5, 4, 4, 3, 3, 3, 1, 1, 0, 0, -1, -2, -1, -3, -3, -4, -4, -4, -6,
-5, -6, -7, -7, -8, -8, -10, -10, -10, -12, -12, -12, -13, -14, -14, -15, -16,
-16, -16, -17, -17, -18, -19, -19, -20, -21, -21, -22, -22, -23, -23, -24, -25,
-25, -25, -26, -26, -27, -28, -28, -28, -29, -30, -30, -32, -33, -34, -35, -35,
-36, -37, -38, -39, -40, -42, -43, -44, -45, -46, -48, -49, -50, -51, -53, -55,
-57, -58, -60, -62, -64, -67, -68, -71, -73, -75, -77, -78, -82, -84, -86, -88,
-91, -93, -95, -97, -99, -102, -104, -106, -107, -108, -110, -111, -112, -113,
-115, -115, -116, -116, -117, -117, -118, -118, -119, -119, -119, -119, -119,
-119, -119, -120, -120, -119, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -118, -118, -117, -117, -118, -117, -116, -116, -116, -116, -116, -117,
-116, -115, -115, -116, -115, -115, -115, -115, -115, -115, -115, -115, -114,
-114, -114, -114, -114, -114, -114, -113, -113, -113, -112, -113, -112, -111,
-111, -111, -111, -111, -110, -111, -109, -109, -109, -109, -107, -108, -108,
-108, -107, -108, -106, -106, -106, -105, -105, -104, -104, -104, -104, -104,
-103, -103, -101, -101, -101, -100, -100, -99, -99, -99, -98, -98, -97, -97,
-96, -94, -95, -94, -94, -93, -92, -92, -91, -91, -90, -89, -88, -87, -86, -84,
-83, -82, -80, -79, -76, -75, -73, -70, -67, -66, -62, -60, -58, -55, -52, -49,
-48, -45, -43, -40, -36, -35, -32, -28, -24, -20, -15, -11, -7, -1, };