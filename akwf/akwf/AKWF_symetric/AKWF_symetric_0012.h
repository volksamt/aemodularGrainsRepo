#define DATA_LENGTH 512
#define DATA AKWF_symetric_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 14, 23, 31, 36, 39, 43, 45, 46, 49,
53, 55, 58, 61, 64, 66, 68, 72, 74, 76, 78, 80, 81, 82, 84, 84, 85, 86, 86, 87,
86, 88, 88, 89, 91, 91, 93, 93, 95, 96, 97, 98, 99, 100, 100, 101, 102, 102,
102, 103, 104, 104, 104, 105, 106, 105, 106, 107, 108, 107, 109, 109, 110, 110,
110, 110, 112, 112, 112, 112, 113, 112, 113, 113, 113, 113, 113, 113, 114, 113,
114, 114, 114, 115, 115, 115, 116, 116, 117, 116, 117, 117, 118, 118, 118, 118,
118, 119, 118, 118, 118, 118, 118, 119, 118, 119, 119, 119, 118, 118, 119, 119,
119, 118, 119, 118, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 120, 118, 118, 119, 119, 119, 119, 118, 119, 119, 119, 118, 119, 118,
118, 118, 117, 118, 118, 117, 117, 116, 117, 116, 116, 116, 115, 117, 116, 115,
116, 115, 115, 115, 115, 115, 115, 114, 115, 114, 115, 114, 114, 113, 114, 113,
113, 113, 112, 112, 112, 112, 111, 112, 110, 110, 111, 110, 109, 109, 109, 108,
108, 108, 107, 108, 106, 106, 105, 105, 104, 104, 103, 102, 103, 102, 102, 101,
101, 101, 99, 100, 99, 98, 98, 98, 97, 96, 96, 95, 94, 94, 92, 92, 90, 90, 88,
86, 85, 82, 80, 77, 73, 70, 66, 63, 59, 54, 50, 45, 42, 37, 34, 31, 28, 24, 22,
19, 17, 14, 12, 10, 8, 5, 3, 1, 0, -3, -6, -8, -9, -12, -14, -17, -20, -22, -26,
-28, -30, -34, -38, -42, -45, -50, -55, -59, -62, -67, -71, -74, -77, -80, -83,
-85, -87, -88, -90, -91, -92, -93, -93, -94, -95, -96, -96, -98, -97, -98, -98,
-100, -99, -100, -100, -101, -101, -102, -103, -102, -103, -103, -104, -104,
-105, -105, -106, -106, -107, -107, -108, -108, -109, -110, -110, -110, -110,
-110, -110, -111, -110, -110, -111, -111, -112, -112, -113, -113, -113, -114,
-114, -114, -114, -115, -114, -115, -115, -115, -114, -115, -115, -115, -116,
-115, -116, -116, -116, -116, -116, -116, -117, -116, -117, -116, -116, -118,
-117, -118, -118, -118, -118, -119, -119, -119, -120, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -118, -118, -119,
-118, -119, -119, -120, -120, -118, -119, -119, -118, -119, -119, -119, -120,
-119, -118, -118, -118, -119, -118, -119, -118, -118, -118, -118, -118, -118,
-118, -117, -118, -116, -117, -117, -117, -116, -115, -116, -116, -116, -115,
-115, -115, -114, -113, -113, -114, -113, -113, -114, -113, -112, -112, -111,
-112, -112, -111, -111, -110, -110, -110, -109, -109, -109, -108, -107, -107,
-106, -106, -106, -105, -104, -105, -103, -103, -102, -101, -101, -101, -101,
-99, -98, -98, -96, -95, -95, -94, -93, -92, -91, -90, -89, -88, -88, -87, -87,
-85, -85, -83, -83, -82, -81, -80, -77, -76, -74, -71, -69, -66, -64, -61, -58,
-55, -52, -50, -47, -44, -43, -40, -35, -31, -23, -14, -3, };