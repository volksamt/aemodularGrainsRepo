#define DATA_LENGTH 512
#define DATA AKWF_symetric_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 15, 21, 24, 30, 34, 39, 43,
48, 53, 57, 61, 65, 70, 73, 78, 81, 86, 88, 92, 95, 98, 101, 104, 106, 108, 111,
112, 114, 115, 116, 117, 119, 119, 119, 118, 119, 119, 119, 118, 117, 116, 116,
114, 113, 111, 112, 110, 108, 107, 106, 105, 103, 101, 100, 99, 97, 96, 94, 92,
91, 89, 88, 87, 85, 82, 82, 80, 79, 77, 76, 74, 72, 70, 70, 68, 67, 66, 64, 62,
61, 60, 57, 57, 55, 54, 52, 51, 49, 47, 46, 45, 43, 42, 40, 39, 37, 35, 33, 31,
31, 29, 27, 25, 23, 22, 20, 17, 17, 14, 13, 10, 9, 8, 5, 3, 2, 1, -1, -3, -5,
-6, -8, -9, -11, -11, -13, -14, -14, -14, -15, -15, -16, -15, -14, -15, -14,
-13, -12, -11, -9, -7, -6, -2, 0, 2, 5, 7, 11, 14, 17, 21, 23, 27, 30, 34, 37,
40, 44, 47, 51, 53, 56, 59, 61, 65, 67, 69, 71, 73, 75, 76, 79, 80, 81, 82, 83,
84, 86, 86, 87, 87, 88, 88, 88, 89, 89, 89, 88, 89, 89, 88, 88, 87, 87, 87, 86,
85, 85, 84, 84, 83, 82, 80, 81, 79, 78, 77, 76, 75, 73, 72, 71, 70, 69, 67, 65,
64, 63, 61, 59, 58, 56, 55, 54, 52, 50, 48, 47, 45, 42, 41, 40, 38, 37, 34, 32,
31, 28, 26, 25, 24, 21, 19, 18, 16, 14, 12, 10, 9, 7, 5, 3, 1, 0, -2, -5, -7,
-9, -10, -13, -14, -16, -17, -20, -22, -24, -24, -28, -29, -30, -33, -34, -36,
-38, -39, -42, -43, -44, -46, -48, -51, -52, -53, -56, -57, -59, -60, -61, -63,
-64, -66, -67, -69, -70, -70, -73, -74, -75, -76, -77, -78, -79, -80, -81, -82,
-83, -84, -85, -86, -85, -86, -87, -87, -87, -88, -88, -89, -89, -89, -89, -88,
-89, -88, -88, -88, -87, -87, -86, -86, -85, -83, -82, -81, -80, -78, -77, -74,
-73, -70, -69, -66, -64, -61, -59, -56, -53, -50, -47, -45, -41, -37, -34, -31,
-27, -23, -21, -17, -13, -11, -8, -5, -2, 1, 4, 6, 7, 9, 10, 12, 13, 14, 15, 16,
15, 15, 15, 15, 15, 14, 13, 13, 11, 11, 9, 8, 7, 4, 3, 1, 0, -2, -3, -6, -8,
-10, -11, -14, -14, -17, -19, -19, -23, -24, -25, -27, -29, -31, -32, -34, -36,
-37, -38, -40, -42, -44, -45, -47, -48, -50, -50, -52, -54, -55, -56, -59, -60,
-61, -62, -64, -65, -66, -68, -70, -71, -72, -74, -76, -77, -78, -80, -82, -83,
-85, -87, -87, -89, -91, -92, -94, -95, -97, -98, -99, -101, -104, -105, -106,
-108, -108, -109, -112, -112, -113, -114, -116, -116, -116, -118, -118, -119,
-119, -119, -119, -118, -118, -117, -116, -115, -113, -112, -111, -109, -106,
-103, -101, -99, -95, -92, -88, -85, -81, -77, -74, -69, -65, -61, -56, -52,
-48, -43, -38, -34, -29, -26, -20, -16, -10, -6, -1, };