#define DATA_LENGTH 512
#define DATA AKWF_symetric_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 3, 3, 3, 4, 3, 5, 5, 6, 6,
5, 6, 7, 8, 9, 9, 10, 10, 11, 11, 12, 11, 10, 12, 15, 16, 15, 16, 16, 17, 18,
18, 17, 17, 18, 18, 19, 19, 19, 20, 19, 20, 21, 22, 22, 23, 22, 23, 25, 26, 26,
25, 25, 27, 28, 29, 28, 29, 28, 29, 31, 30, 31, 31, 32, 31, 31, 31, 33, 34, 33,
34, 36, 36, 36, 36, 36, 36, 38, 40, 41, 41, 41, 42, 42, 42, 42, 43, 43, 41, 43,
44, 45, 45, 44, 46, 48, 48, 48, 47, 48, 47, 49, 51, 51, 51, 51, 52, 54, 54, 53,
53, 53, 53, 55, 55, 55, 56, 55, 56, 57, 57, 57, 58, 59, 59, 60, 61, 63, 64, 63,
64, 65, 65, 64, 64, 65, 65, 66, 67, 67, 66, 67, 67, 68, 69, 70, 70, 69, 70, 71,
73, 73, 73, 73, 73, 73, 74, 75, 76, 75, 75, 76, 78, 79, 78, 78, 79, 80, 80, 81,
81, 81, 81, 81, 82, 83, 82, 83, 84, 85, 85, 87, 87, 86, 86, 88, 89, 89, 90, 90,
91, 92, 91, 92, 92, 92, 91, 92, 94, 96, 95, 95, 95, 96, 96, 98, 98, 97, 98, 99,
101, 101, 101, 101, 102, 103, 102, 103, 104, 103, 103, 104, 105, 107, 106, 106,
106, 106, 107, 108, 107, 109, 107, 109, 111, 112, 111, 111, 113, 115, 115, 112,
117, 113, 63, 23, 27, 32, 30, 32, 25, 8, -8, -25, -32, -31, -32, -27, -25, -67,
-114, -117, -112, -115, -115, -112, -111, -112, -113, -111, -109, -108, -108,
-108, -108, -107, -107, -106, -106, -107, -106, -106, -104, -103, -103, -103,
-103, -102, -103, -101, -101, -101, -101, -100, -98, -97, -97, -98, -97, -96,
-95, -95, -95, -95, -95, -94, -93, -91, -92, -92, -92, -93, -92, -91, -90, -90,
-90, -89, -87, -86, -87, -86, -86, -85, -84, -84, -83, -83, -82, -83, -81, -81,
-81, -81, -81, -81, -80, -80, -78, -79, -78, -79, -76, -76, -75, -76, -75, -74,
-73, -74, -73, -73, -74, -73, -70, -69, -70, -70, -69, -69, -68, -66, -66, -66,
-67, -66, -65, -66, -65, -65, -64, -65, -64, -64, -63, -64, -63, -61, -60, -58,
-59, -58, -57, -57, -57, -56, -56, -55, -56, -56, -54, -53, -53, -54, -53, -53,
-53, -52, -51, -51, -51, -51, -49, -48, -48, -48, -47, -49, -47, -45, -45, -44,
-44, -44, -42, -42, -42, -42, -42, -42, -42, -41, -42, -41, -41, -39, -37, -36,
-37, -37, -36, -37, -37, -35, -33, -34, -33, -31, -31, -32, -30, -31, -31, -31,
-31, -29, -28, -29, -29, -29, -28, -26, -25, -25, -25, -25, -26, -23, -22, -22,
-22, -22, -21, -20, -19, -19, -18, -19, -18, -18, -18, -18, -18, -17, -17, -18,
-16, -16, -16, -15, -14, -12, -11, -11, -11, -12, -11, -11, -9, -9, -9, -9, -7,
-6, -6, -6, -6, -5, -5, -3, -3, -3, -3, -4, -3, -2, 0, 0, };