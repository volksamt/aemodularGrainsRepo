#define DATA_LENGTH 512
#define DATA AKWF_symetric_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 3, 6, 7, 10, 11, 14, 17, 19, 21,
23, 26, 29, 31, 32, 35, 37, 39, 41, 42, 45, 47, 49, 51, 51, 54, 56, 57, 59, 61,
62, 64, 64, 65, 67, 69, 70, 71, 72, 72, 73, 75, 76, 76, 77, 78, 79, 79, 81, 81,
82, 82, 82, 83, 83, 83, 84, 84, 85, 85, 86, 86, 86, 86, 86, 86, 87, 88, 87, 87,
88, 88, 88, 89, 88, 88, 88, 89, 89, 89, 89, 89, 90, 89, 90, 90, 90, 91, 91, 91,
91, 91, 92, 92, 93, 92, 92, 92, 93, 94, 94, 95, 94, 94, 95, 96, 96, 96, 96, 96,
97, 97, 98, 98, 98, 98, 99, 99, 99, 100, 101, 101, 102, 102, 103, 103, 103, 104,
105, 105, 105, 105, 105, 106, 107, 107, 108, 108, 108, 109, 110, 111, 110, 111,
112, 111, 112, 113, 112, 113, 114, 115, 115, 115, 115, 116, 116, 117, 117, 117,
118, 118, 119, 118, 119, 118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 118, 118, 118, 118, 117, 117, 117, 117, 115, 115, 115, 114, 114, 113, 112,
112, 110, 110, 109, 108, 108, 106, 104, 105, 103, 103, 100, 100, 98, 97, 96, 94,
93, 91, 90, 88, 86, 85, 83, 82, 79, 78, 76, 74, 73, 71, 69, 67, 66, 63, 61, 60,
57, 56, 53, 51, 49, 46, 44, 42, 40, 37, 35, 34, 32, 29, 26, 24, 22, 20, 18, 15,
12, 10, 8, 6, 4, 1, -1, -4, -6, -8, -11, -12, -15, -17, -20, -22, -25, -27, -29,
-32, -34, -37, -38, -40, -43, -45, -47, -50, -52, -53, -55, -58, -60, -61, -64,
-65, -68, -69, -71, -74, -75, -77, -78, -80, -82, -83, -85, -87, -88, -90, -92,
-93, -95, -95, -97, -98, -100, -100, -102, -103, -104, -106, -106, -107, -108,
-110, -110, -110, -112, -112, -113, -113, -114, -115, -115, -116, -116, -118,
-118, -118, -117, -118, -118, -118, -119, -120, -119, -120, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -118, -118, -117, -118, -116, -116, -116,
-116, -116, -115, -115, -115, -115, -114, -114, -113, -113, -112, -112, -111,
-111, -111, -110, -110, -109, -109, -108, -108, -107, -107, -106, -105, -106,
-105, -106, -104, -104, -103, -102, -103, -102, -102, -101, -100, -101, -99,
-99, -100, -98, -98, -98, -97, -98, -97, -97, -96, -95, -95, -95, -96, -95, -94,
-95, -93, -94, -93, -93, -93, -93, -92, -92, -91, -91, -91, -91, -91, -91, -90,
-90, -89, -90, -89, -90, -90, -89, -89, -90, -89, -89, -88, -88, -88, -88, -88,
-87, -87, -87, -87, -87, -87, -86, -86, -86, -85, -86, -85, -84, -84, -84, -84,
-84, -82, -82, -82, -81, -79, -79, -78, -78, -78, -76, -76, -74, -73, -72, -71,
-71, -69, -68, -67, -65, -65, -63, -61, -61, -59, -57, -56, -53, -52, -50, -48,
-46, -44, -42, -40, -38, -36, -34, -33, -30, -27, -25, -24, -21, -19, -16, -14,
-11, -10, -8, -5, -3, -2, -1, };