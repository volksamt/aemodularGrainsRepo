#define DATA_LENGTH 512
#define DATA AKWF_symetric_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 12, 16, 21, 25, 29, 34, 37, 40,
45, 48, 51, 54, 56, 59, 60, 62, 63, 65, 66, 67, 68, 69, 69, 70, 70, 71, 71, 70,
69, 70, 69, 68, 68, 66, 65, 65, 64, 64, 63, 64, 63, 62, 62, 63, 63, 62, 62, 61,
61, 61, 60, 58, 58, 57, 56, 56, 55, 54, 53, 53, 52, 50, 50, 49, 48, 48, 46, 45,
45, 44, 43, 44, 43, 43, 44, 43, 44, 45, 45, 46, 48, 49, 51, 53, 55, 57, 58, 62,
65, 68, 71, 74, 78, 81, 85, 87, 91, 95, 98, 100, 103, 105, 107, 109, 112, 113,
114, 116, 117, 118, 119, 118, 119, 119, 118, 118, 115, 113, 111, 108, 106, 103,
98, 96, 92, 87, 84, 81, 76, 72, 68, 65, 61, 57, 53, 48, 44, 41, 35, 30, 26, 21,
16, 12, 8, 5, 1, -3, -7, -11, -16, -19, -22, -27, -31, -35, -41, -44, -48, -52,
-55, -59, -63, -66, -69, -73, -77, -81, -83, -86, -90, -92, -95, -98, -99, -101,
-102, -103, -104, -103, -104, -104, -102, -101, -101, -101, -98, -96, -94, -93,
-92, -90, -88, -86, -84, -82, -80, -78, -74, -71, -68, -67, -64, -63, -61, -60,
-59, -60, -60, -61, -60, -61, -61, -61, -62, -63, -62, -63, -64, -63, -64, -65,
-65, -64, -65, -66, -66, -66, -65, -65, -64, -63, -64, -62, -60, -58, -55, -53,
-51, -49, -46, -43, -39, -37, -34, -31, -27, -23, -20, -17, -13, -9, -4, -1, 1,
5, 9, 13, 17, 20, 23, 27, 31, 34, 36, 39, 43, 45, 49, 51, 53, 54, 57, 60, 61,
64, 63, 63, 64, 65, 65, 66, 65, 66, 65, 65, 65, 65, 63, 62, 63, 62, 63, 61, 61,
61, 61, 61, 60, 60, 60, 60, 60, 61, 62, 65, 66, 68, 71, 74, 76, 81, 82, 84, 87,
89, 90, 92, 93, 95, 96, 98, 100, 101, 101, 103, 103, 104, 104, 103, 102, 102,
100, 99, 96, 94, 92, 90, 86, 83, 80, 77, 73, 70, 66, 62, 59, 55, 51, 48, 44, 40,
35, 31, 27, 22, 20, 15, 11, 6, 4, -2, -5, -9, -13, -17, -21, -26, -31, -37, -41,
-45, -49, -53, -57, -61, -65, -69, -74, -77, -81, -84, -88, -92, -96, -99, -103,
-106, -109, -111, -114, -116, -117, -118, -119, -119, -119, -119, -118, -117,
-116, -114, -112, -111, -109, -107, -106, -103, -100, -98, -94, -90, -87, -84,
-81, -77, -74, -70, -67, -65, -62, -59, -56, -54, -53, -51, -50, -48, -46, -45,
-44, -44, -44, -43, -43, -43, -43, -43, -45, -45, -46, -46, -48, -48, -49, -50,
-51, -51, -52, -53, -53, -55, -55, -56, -57, -57, -59, -60, -61, -61, -62, -62,
-62, -63, -63, -62, -63, -63, -63, -63, -64, -64, -65, -66, -67, -67, -68, -69,
-69, -70, -71, -70, -71, -70, -70, -69, -68, -68, -67, -66, -64, -63, -61, -60,
-58, -56, -54, -51, -48, -44, -41, -37, -33, -29, -25, -21, -15, -11, -6, -2, };