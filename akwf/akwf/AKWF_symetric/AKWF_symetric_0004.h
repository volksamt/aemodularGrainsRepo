#define DATA_LENGTH 512
#define DATA AKWF_symetric_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 13, 20, 26, 34, 41, 42, 44, 47,
49, 51, 52, 55, 56, 57, 58, 61, 62, 64, 64, 66, 68, 70, 70, 71, 73, 75, 75, 77,
78, 80, 80, 81, 83, 83, 83, 85, 86, 87, 87, 88, 90, 90, 91, 91, 93, 92, 94, 93,
96, 94, 97, 96, 98, 98, 98, 98, 98, 99, 99, 100, 101, 99, 101, 99, 101, 99, 100,
103, 92, 122, -33, -114, -64, -85, -61, -68, -55, -56, -49, -45, -42, -37, -34,
-29, -27, -23, -20, -17, -13, -11, -8, -5, -2, 1, 3, 7, 8, 13, 13, 16, 17, 21,
23, 25, 27, 29, 31, 33, 35, 37, 39, 39, 41, 43, 44, 47, 47, 48, 49, 50, 51, 53,
53, 54, 54, 55, 55, 56, 57, 56, 56, 58, 57, 57, 58, 58, 57, 56, 57, 56, 57, 55,
55, 54, 54, 53, 52, 52, 49, 45, 41, 40, 37, 34, 32, 30, 27, 25, 23, 21, 19, 18,
15, 13, 11, 9, 8, 5, 4, 2, 1, -1, -4, -4, -6, -7, -9, -11, -12, -13, -15, -16,
-17, -19, -20, -22, -23, -25, -26, -28, -29, -31, -33, -37, -38, -36, -36, -36,
-35, -34, -33, -32, -31, -30, -29, -27, -27, -26, -23, -23, -22, -21, -19, -18,
-16, -14, -13, -12, -10, -9, -7, -5, -4, -1, 1, 2, 4, 5, 9, 10, 13, 14, 15, 18,
18, 31, -28, -58, -43, -47, -38, -38, -34, -31, -28, -25, -23, -19, -17, -13,
-10, -7, -5, -2, 2, 4, 8, 11, 12, 17, 19, 23, 24, 29, 31, 34, 38, 38, 47, 44,
59, 23, -31, -17, -18, -15, -14, -13, -9, -8, -6, -4, -1, -1, 2, 3, 5, 7, 9, 9,
12, 13, 15, 15, 18, 20, 21, 22, 23, 25, 26, 27, 28, 30, 30, 31, 32, 33, 34, 35,
36, 37, 36, 37, 37, 33, 31, 30, 28, 25, 24, 23, 22, 21, 19, 18, 17, 15, 13, 12,
11, 9, 8, 6, 5, 3, 2, -1, -2, -4, -6, -7, -9, -11, -13, -15, -17, -18, -21, -24,
-25, -27, -31, -31, -35, -37, -39, -42, -45, -50, -52, -52, -53, -54, -55, -55,
-55, -56, -56, -56, -57, -57, -57, -57, -57, -58, -57, -57, -56, -57, -57, -57,
-55, -55, -53, -54, -53, -52, -51, -49, -48, -47, -45, -44, -43, -42, -39, -40,
-36, -35, -33, -31, -30, -27, -25, -23, -21, -18, -17, -13, -13, -7, -6, -3, -1,
3, 5, 8, 10, 13, 16, 21, 22, 28, 29, 35, 36, 43, 44, 49, 55, 57, 68, 63, 84, 65,
117, 19, -124, -90, -105, -100, -101, -101, -100, -100, -100, -100, -100, -99,
-99, -98, -99, -98, -98, -97, -96, -97, -95, -95, -94, -95, -92, -94, -92, -91,
-90, -90, -89, -88, -88, -86, -85, -84, -84, -82, -81, -79, -78, -78, -77, -75,
-75, -73, -72, -70, -69, -67, -67, -65, -63, -62, -60, -59, -57, -55, -54, -51,
-50, -48, -46, -45, -43, -41, -35, -25, -20, -14, -7, -2, };