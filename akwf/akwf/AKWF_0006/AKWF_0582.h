#define DATA_LENGTH 512
#define DATA AKWF_0582

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 9, 12, 15, 18, 21, 24, 27, 31,
34, 36, 39, 43, 46, 50, 52, 55, 57, 58, 60, 61, 64, 64, 66, 68, 70, 71, 73, 74,
76, 76, 78, 80, 82, 83, 86, 87, 87, 89, 91, 93, 95, 96, 97, 99, 100, 103, 103,
105, 106, 109, 110, 111, 113, 114, 116, 118, 119, 118, 116, 115, 112, 111, 109,
109, 106, 105, 103, 101, 100, 98, 96, 96, 93, 91, 90, 89, 88, 86, 84, 82, 80,
80, 78, 77, 74, 72, 71, 69, 68, 67, 64, 64, 62, 60, 58, 57, 56, 54, 53, 50, 50,
48, 46, 45, 43, 41, 41, 38, 36, 34, 34, 32, 30, 29, 8, 6, 10, 9, 12, 12, 15, 16,
18, 18, 22, 22, 23, 24, 26, 27, 30, 30, 32, 34, 36, 36, 37, 40, 41, 43, 43, 46,
47, 49, 50, 51, 53, 55, 56, 57, 59, 60, 62, 64, 66, 66, 68, 68, 71, 72, 74, 76,
77, 78, 80, 81, 83, 84, 86, 88, 88, 90, 91, 95, 93, 98, 96, 101, 98, 105, 100,
109, 102, 114, 95, -2, 1, -1, -4, -4, -7, -6, -11, -10, -14, -14, -17, -16, -19,
-21, -22, -25, -23, -28, -26, -32, -28, -40, -17, 43, 32, 32, 28, 25, 23, 19,
16, 12, 10, 6, 4, 0, -1, -6, -7, -12, -14, -17, -20, -25, -27, -30, -33, -36,
-39, -43, -45, -48, -51, -54, -58, -60, -63, -67, -70, -73, -76, -79, -82, -85,
-88, -91, -94, -98, -101, -103, -107, -110, -108, -106, -104, -103, -101, -99,
-97, -97, -94, -93, -92, -90, -89, -88, -86, -84, -82, -81, -79, -77, -76, -74,
-73, -71, -70, -68, -67, -65, -64, -62, -60, -59, -57, -55, -54, -52, -50, -50,
-48, -47, -45, -43, -41, -40, -39, -37, -35, -33, -32, -30, -29, -27, -25, -24,
-22, -20, -18, -18, -16, -14, -13, -11, -10, -8, -6, -6, -4, -2, 0, 1, 3, 5, 5,
4, 4, 4, 5, 5, 5, 4, 5, 5, 5, 4, 4, 4, 5, 4, 5, 4, 5, 4, 5, 5, 4, 4, 4, 4, 4, 4,
4, 4, 5, 5, 4, 4, 5, 5, 4, 4, 4, 4, 5, 4, 4, 4, 4, 4, 4, 4, 5, 4, 4, 4, 5, 2, 1,
0, -2, -3, -5, -7, -9, -10, -11, -13, -14, -16, -18, -19, -20, -23, -24, -25,
-27, -28, -30, -31, -32, -34, -37, -37, -39, -40, -43, -45, -45, -47, -49, -50,
-52, -53, -54, -56, -57, -59, -61, -63, -64, -66, -67, -69, -70, -72, -73, -74,
-76, -77, -79, -81, -82, -83, -85, -87, -89, -90, -91, -93, -94, -96, -97, -99,
-101, -103, -104, -105, -107, -106, -105, -103, -102, -100, -98, -97, -96, -94,
-93, -91, -89, -88, -86, -84, -82, -81, -80, -78, -77, -75, -73, -72, -70, -68,
-67, -65, -64, -62, -60, -58, -58, -56, -54, -54, -52, -49, -48, -48, -44, -47,
-3, 12, 7, 13, 11, 17, 15, 20, 17, 26, 5, -10, -1, -1, };