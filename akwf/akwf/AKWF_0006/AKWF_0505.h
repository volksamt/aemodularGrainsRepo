#define DATA_LENGTH 512
#define DATA AKWF_0505

const PROGMEM int8_t DATA[DATA_LENGTH] = {81, 115, 108, 113, 109, 113, 109, 112,
110, 112, 110, 112, 109, 112, 111, 111, 111, 111, 110, 111, 111, 111, 111, 110,
111, 110, 111, 111, 111, 110, 111, 110, 111, 111, 111, 111, 110, 111, 111, 111,
110, 111, 111, 111, 111, 111, 111, 111, 111, 110, 110, 110, 111, 110, 110, 110,
110, 110, 110, 110, 111, 110, 111, 111, 111, 111, 111, 110, 110, 111, 110, 110,
110, 110, 110, 110, 111, 109, 110, 110, 110, 110, 109, 110, 110, 110, 110, 110,
110, 110, 110, 111, 110, 109, 109, 110, 110, 110, 110, 109, 109, 109, 110, 109,
110, 109, 110, 110, 110, 110, 109, 109, 110, 110, 109, 110, 109, 109, 110, 109,
110, 109, 109, 110, 110, 109, 109, 109, 110, 109, 109, 110, 109, 109, 109, 109,
110, 109, 109, 110, 110, 109, 108, 109, 109, 109, 109, 109, 109, 109, 109, 109,
109, 109, 110, 109, 108, 109, 109, 109, 108, 108, 108, 109, 109, 109, 109, 109,
109, 109, 108, 109, 109, 109, 109, 109, 109, 109, 108, 109, 109, 108, 109, 108,
108, 108, 108, 108, 109, 108, 108, 109, 108, 109, 108, 109, 108, 108, 109, 108,
109, 109, 108, 108, 108, 108, 108, 108, 109, 108, 109, 109, 108, 108, 108, 108,
108, 109, 108, 108, 108, 108, 108, 107, 109, 108, 108, 109, 107, 108, 108, 108,
108, 107, 107, 108, 108, 108, 107, 108, 107, 109, 107, 109, 106, 109, 107, 109,
107, 109, 105, 109, 106, 109, 107, 109, 108, 107, 108, 107, 110, 103, 114, 96,
127, -41, -128, -105, -128, -111, -125, -114, -123, -117, -122, -117, -120,
-119, -120, -119, -118, -119, -118, -119, -118, -120, -118, -120, -119, -120,
-118, -120, -119, -119, -118, -119, -119, -120, -119, -119, -119, -119, -119,
-118, -118, -119, -119, -119, -118, -118, -120, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -118, -119,
-118, -118, -119, -119, -119, -118, -118, -118, -119, -118, -118, -118, -119,
-119, -118, -118, -118, -118, -119, -118, -117, -118, -118, -117, -118, -118,
-118, -117, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -117,
-119, -118, -118, -117, -118, -118, -117, -119, -118, -118, -118, -118, -117,
-118, -119, -118, -118, -118, -118, -118, -118, -117, -118, -118, -117, -118,
-117, -118, -118, -117, -117, -117, -117, -117, -118, -117, -117, -117, -117,
-117, -117, -118, -118, -118, -117, -117, -117, -117, -117, -117, -118, -117,
-117, -117, -118, -117, -117, -118, -117, -117, -117, -117, -118, -117, -118,
-117, -118, -116, -116, -117, -117, -117, -117, -117, -117, -117, -116, -116,
-116, -116, -116, -117, -116, -117, -117, -116, -116, -116, -117, -117, -117,
-117, -117, -117, -117, -116, -117, -117, -117, -116, -116, -117, -117, -116,
-116, -116, -117, -116, -116, -116, -116, -117, -116, -117, -116, -117, -116,
-116, -116, -117, -115, -116, -115, -116, -115, -116, -116, -115, -116, -115,
-117, -115, -117, -115, -118, -114, -119, -113, -118, -113, -120, -112, -123,
-98, };