#define DATA_LENGTH 512
#define DATA AKWF_0507

const PROGMEM int8_t DATA[DATA_LENGTH] = {105, 125, 115, 122, 117, 121, 117,
120, 118, 120, 118, 120, 119, 119, 118, 119, 119, 119, 119, 119, 119, 120, 119,
120, 117, 120, 117, 121, 116, 123, 115, 123, 113, 126, 110, 127, 75, -75, -52,
-63, -58, -60, -58, -59, -59, -58, -60, -58, -60, -58, -61, -58, -59, -57, -60,
-58, -60, -57, -60, -57, -62, -57, -62, -56, -62, -54, -64, -53, -67, -48, -76,
-11, 127, 112, 123, 117, 120, 118, 119, 119, 118, 119, 118, 120, 118, 119, 118,
119, 118, 119, 118, 118, 119, 118, 119, 118, 119, 119, 119, 119, 118, 120, 117,
121, 114, 125, 109, 127, 11, -80, -47, -68, -52, -64, -55, -63, -56, -61, -57,
-61, -58, -59, -59, -60, -59, -59, -59, -58, -61, -57, -61, -57, -62, -56, -63,
-56, -64, -53, -67, -49, -78, -1, 127, 110, 123, 116, 120, 118, 119, 118, 118,
119, 118, 120, 117, 119, 118, 119, 118, 120, 117, 119, 118, 119, 118, 119, 118,
118, 119, 118, 118, 118, 119, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118,
118, 118, 118, 118, 118, 118, 119, 118, 119, 117, 117, 119, 118, 118, 118, 118,
118, 117, 118, 118, 117, 118, 118, 118, 117, 118, 117, 119, 117, 117, 117, 118,
117, 118, 117, 118, 117, 117, 118, 117, 119, 116, 119, 116, 119, 115, 120, 115,
120, 114, 121, 112, 122, 111, 126, 98, -64, -60, -59, -62, -59, -62, -58, -62,
-58, -63, -59, -63, -59, -62, -59, -63, -60, -62, -60, -61, -60, -61, -60, -61,
-60, -61, -62, -61, -61, -60, -60, -60, -61, -61, -62, -60, -61, -60, -61, -61,
-60, -61, -60, -61, -61, -61, -61, -60, -60, -61, -60, -61, -61, -60, -61, -61,
-60, -61, -61, -60, -61, -60, -60, -61, -60, -60, -60, -60, -60, -60, -60, -61,
-61, -61, -61, -61, -61, -60, -61, -60, -60, -60, -60, -60, -60, -60, -61, -60,
-61, -60, -61, -60, -59, -61, -61, -61, -60, -60, -60, -61, -60, -60, -61, -60,
-61, -60, -60, -60, -60, -61, -60, -60, -60, -60, -61, -60, -60, -60, -60, -61,
-60, -60, -61, -60, -60, -60, -61, -60, -61, -60, -60, -60, -60, -60, -60, -60,
-59, -60, -60, -60, -59, -59, -59, -60, -59, -61, -60, -59, -60, -60, -60, -59,
-61, -60, -60, -60, -59, -60, -60, -60, -60, -60, -60, -59, -59, -60, -59, -60,
-60, -59, -60, -59, -59, -59, -59, -60, -60, -60, -60, -60, -59, -60, -59, -60,
-60, -59, -59, -59, -60, -60, -60, -59, -59, -59, -59, -60, -60, -59, -59, -59,
-59, -59, -59, -59, -58, -59, -60, -59, -59, -59, -59, -60, -59, -60, -60, -59,
-59, -60, -59, -60, -59, -59, -59, -59, -59, -59, -60, -60, -59, -59, -59, -59,
-59, -59, -59, -59, -59, -59, -59, -58, -59, -59, -59, -60, -59, -59, -59, -59,
-60, -59, -59, -59, -58, -60, -59, -59, -58, -59, -59, -60, -59, -59, -58, -59,
-58, -60, -58, -60, -57, -61, -56, -62, -50, };