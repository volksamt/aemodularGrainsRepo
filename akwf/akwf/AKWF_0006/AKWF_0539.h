#define DATA_LENGTH 512
#define DATA AKWF_0539

const PROGMEM int8_t DATA[DATA_LENGTH] = {14, 30, 43, 55, 63, 69, 73, 75, 76,
74, 73, 70, 67, 63, 58, 54, 48, 44, 38, 34, 29, 24, 20, 16, 12, 8, 5, 0, -3, -6,
-9, -11, -14, -16, -18, -20, -22, -24, -25, -25, -26, -26, -27, -27, -26, -26,
-26, -25, -24, -23, -22, -21, -19, -18, -17, -15, -14, -12, -10, -8, -6, -5, -3,
-1, 0, 1, 2, 3, 4, 7, 6, 9, 7, 13, 21, 2, -20, -28, -31, -25, -18, -6, 5, 15,
24, 32, 37, 42, 44, 44, 44, 42, 39, 36, 33, 29, 24, 20, 16, 13, 9, 6, 3, 0, -2,
-4, -5, -7, -8, -8, -9, -9, -10, -10, -9, -9, -9, -8, -8, -7, -7, -7, -6, -7,
-5, -5, -5, -5, -5, -6, -6, -5, -5, -5, -5, -6, -6, -6, -6, -5, -5, -5, -4, -4,
-3, -4, -3, -3, -2, -1, -1, -1, 0, 0, 1, 0, 2, -11, -3, 34, 56, 66, 64, 56, 41,
25, 9, -6, -19, -28, -36, -42, -44, -46, -44, -42, -38, -34, -29, -24, -19, -14,
-10, -6, -1, 2, 6, 7, 10, 12, 14, 15, 15, 15, 16, 16, 15, 15, 14, 14, 13, 12,
11, 11, 10, 9, 8, 8, 6, 5, 5, 4, 4, 2, 0, 0, -1, -1, -2, -3, -4, -4, -4, -5, -6,
-6, -6, -6, -6, -7, -6, -7, -7, -7, -8, -6, -6, -6, -5, -24, -25, -12, -6, -7,
-12, -20, -29, -37, -42, -46, -49, -48, -47, -43, -40, -33, -28, -21, -14, -8,
-1, 7, 13, 19, 26, 32, 37, 41, 44, 47, 49, 50, 51, 51, 50, 48, 46, 45, 42, 39,
37, 34, 30, 27, 23, 20, 17, 14, 11, 8, 5, 2, -1, -3, -6, -8, -10, -13, -15, -17,
-20, -21, -22, -23, -24, -26, -27, -27, -26, -27, -27, -26, -25, -25, -24, -23,
-21, -20, -18, -17, -16, -14, -12, -11, -9, -7, -4, -5, -17, 8, 44, 61, 68, 64,
55, 40, 24, 10, -4, -15, -24, -30, -34, -36, -35, -33, -30, -27, -22, -17, -12,
-7, -4, 2, 5, 9, 12, 14, 16, 18, 18, 20, 19, 20, 19, 20, 20, 2, -13, -21, -27,
-34, -40, -44, -45, -45, -45, -41, -37, -21, -28, -47, -55, -53, -42, -28, -11,
6, 22, 38, 51, 61, 68, 73, 76, 76, 75, 73, 69, 64, 59, 52, 46, 40, 33, 26, 20,
14, 10, 4, 0, -5, -9, -12, -14, -7, -25, -51, -63, -69, -65, -59, -50, -40, -29,
-19, -10, -3, 2, 5, 8, 9, 9, 8, 8, 6, 5, 3, 1, 0, -2, -3, -3, -4, -5, -4, -4,
-4, -3, -2, -2, 0, 1, 3, 3, 5, 6, 6, 8, 9, 9, 10, 11, 11, 12, 12, 12, 11, 12,
11, 9, 9, 9, 8, 7, 6, 5, 4, 2, 1, 1, 0, -1, -1, -1, -2, -3, -3, -3, -4, -5, -4,
-4, -4, 5, 2, -4, -15, -27, -41, -42, -60, -95, -112, -119, -114, -102, -84,
-63, -41, -20, -1, };