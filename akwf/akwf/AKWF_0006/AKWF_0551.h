#define DATA_LENGTH 512
#define DATA AKWF_0551

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 47, 75, 80, 92, 111, 107, 88, 79,
74, 74, 83, 95, 101, 99, 96, 94, 94, 100, 108, 114, 115, 115, 114, 112, 113,
114, 116, 115, 113, 110, 106, 103, 101, 98, 97, 95, 91, 89, 87, 84, 83, 84, 84,
83, 83, 84, 86, 87, 90, 92, 93, 96, 97, 99, 101, 102, 104, 104, 104, 105, 105,
103, 103, 102, 101, 101, 98, 97, 96, 94, 93, 91, 90, 89, 88, 88, 89, 89, 89, 90,
91, 92, 93, 95, 96, 98, 99, 101, 102, 102, 104, 105, 106, 106, 106, 106, 106,
105, 106, 105, 105, 103, 103, 102, 101, 101, 100, 100, 99, 99, 100, 100, 100,
101, 102, 102, 104, 105, 106, 107, 108, 108, 109, 110, 111, 112, 112, 113, 114,
113, 114, 114, 113, 114, 113, 112, 112, 112, 112, 111, 111, 111, 111, 110, 111,
111, 112, 111, 112, 113, 113, 114, 114, 115, 115, 116, 116, 117, 118, 118, 119,
119, 119, 119, 119, 118, 119, 119, 118, 118, 118, 117, 117, 118, 117, 117, 116,
115, 116, 115, 116, 116, 117, 116, 117, 116, 117, 118, 117, 118, 118, 118, 118,
119, 119, 118, 119, 119, 119, 118, 118, 119, 119, 117, 117, 117, 118, 117, 116,
115, 115, 116, 116, 114, 115, 114, 115, 115, 115, 115, 115, 115, 115, 114, 115,
115, 116, 115, 114, 115, 114, 114, 114, 115, 114, 113, 113, 113, 112, 113, 112,
112, 111, 112, 110, 111, 109, 111, 110, 111, 109, 110, 108, 112, 65, -13, -51,
-77, -80, -95, -112, -105, -87, -78, -75, -75, -84, -97, -100, -97, -95, -93,
-95, -101, -109, -114, -115, -115, -113, -112, -114, -115, -116, -115, -113,
-110, -106, -102, -100, -99, -97, -94, -91, -88, -85, -84, -84, -83, -84, -84,
-84, -85, -85, -86, -90, -92, -94, -95, -97, -99, -101, -102, -103, -104, -104,
-105, -105, -103, -103, -102, -101, -99, -98, -97, -96, -94, -93, -91, -91, -89,
-89, -89, -88, -89, -89, -90, -92, -93, -93, -95, -96, -97, -99, -100, -102,
-104, -105, -105, -106, -106, -107, -107, -106, -105, -105, -105, -104, -104,
-102, -103, -100, -101, -100, -100, -100, -99, -100, -100, -101, -101, -102,
-103, -104, -104, -106, -106, -108, -109, -110, -110, -112, -112, -113, -113,
-113, -113, -113, -114, -114, -113, -114, -113, -112, -112, -112, -111, -111,
-111, -111, -111, -111, -110, -111, -112, -112, -112, -113, -114, -114, -114,
-116, -116, -116, -117, -117, -118, -118, -119, -119, -119, -119, -119, -118,
-118, -118, -119, -118, -117, -118, -117, -116, -117, -116, -116, -116, -115,
-116, -115, -116, -116, -116, -117, -117, -117, -117, -118, -118, -118, -119,
-118, -119, -119, -119, -119, -119, -119, -118, -118, -118, -117, -117, -117,
-117, -116, -116, -116, -116, -115, -116, -114, -115, -115, -115, -115, -115,
-114, -115, -115, -114, -115, -115, -115, -115, -116, -114, -114, -115, -114,
-115, -114, -114, -113, -114, -113, -113, -112, -112, -112, -112, -111, -111,
-111, -110, -111, -110, -111, -109, -111, -108, -111, -55, };