#define DATA_LENGTH 512
#define DATA AKWF_0516

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 26, 43, 59, 69, 78, 82, 83, 80,
77, 71, 64, 56, 48, 41, 33, 28, 22, 19, 15, 14, 12, 14, 12, 14, 9, 1, 5, -7,
-10, -15, -13, -10, -6, -3, 2, -4, -21, -34, -54, -71, -86, -99, -109, -117,
-119, -117, -112, -103, -93, -80, -67, -52, -39, -27, -14, -3, 8, 17, 25, 34,
41, 48, 54, 59, 62, 67, 68, 63, 56, 46, 34, 21, 12, 14, 15, 18, 23, 27, 33, 39,
42, 44, 45, 44, 42, 39, 36, 31, 28, 24, 23, 21, 20, 20, 21, 21, 22, 23, 24, 26,
25, 25, 24, 22, 20, 18, 16, 15, 14, 13, 13, 14, 15, 17, 19, 23, 25, 29, 33, 36,
39, 41, 43, 44, 46, 45, 45, 44, 44, 42, 42, 41, 41, 40, 39, 38, 38, 37, 37, 36,
35, 35, 35, 35, 35, 36, 36, 36, 37, 38, 40, 40, 42, 42, 47, 51, 52, 53, 56, 57,
58, 59, 59, 59, 52, 49, 54, 53, 51, 52, 50, 48, 45, 43, 40, 37, 36, 34, 32, 32,
30, 28, 26, 25, 24, 22, 21, 21, 20, 20, 19, 19, 18, 20, 21, 19, 21, 20, 20, 21,
20, 21, 23, 23, 24, 24, 25, 25, 27, 28, 28, 29, 29, 30, 32, 33, 34, 35, 35, 35,
36, 36, 38, 41, 42, 44, 49, 52, 52, 52, 53, 53, 55, 57, 60, 61, 62, 62, 64, 64,
63, 63, 64, 63, 63, 64, 65, 64, 65, 63, 62, 60, 57, 56, 54, 51, 50, 49, 47, 44,
42, 39, 38, 35, 34, 32, 31, 29, 27, 25, 22, 20, 19, 17, 17, 17, 14, 14, 13, 13,
13, 14, 14, 15, 15, 13, 15, 15, 16, 8, 8, -26, -36, -49, -53, -47, -63, -57,
-37, -15, -19, -14, 4, 4, -4, 14, -5, -20, -20, -31, -30, -57, -70, -74, -78,
-80, -86, -69, -64, -71, -71, -75, -75, -77, -101, -102, -99, -99, -95, -93,
-67, -61, -56, -55, -30, -17, -19, -11, -12, -6, -25, -30, -27, -29, -29, -30,
-31, -34, -35, -41, -29, -16, -24, -24, -29, -30, -32, -34, -36, -61, -64, -65,
-66, -68, -67, -46, -43, -45, -42, -45, -40, -46, -65, -60, -59, -60, -58, -58,
-58, -58, -60, -39, -31, -37, -34, -39, -36, -42, -38, -50, -69, -71, -70, -73,
-72, -77, -65, -49, -55, -54, -57, -56, -58, -58, -58, -59, -59, -59, -58, -59,
-59, -58, -59, -59, -58, -58, -55, -55, -54, -55, -61, -63, -56, -57, -57, -55,
-56, -57, -57, -59, -60, -61, -61, -62, -61, -62, -62, -63, -62, -64, -63, -61,
-59, -60, -60, -60, -61, -60, -60, -61, -60, -61, -61, -59, -58, -58, -57, -57,
-57, -54, -54, -54, -53, -51, -51, -49, -49, -47, -48, -46, -45, -44, -44, -42,
-41, -40, -40, -39, -39, -40, -18, -12, -14, -12, -14, -12, -14, -13, -13, -13,
-14, -13, -13, -13, -13, -13, -13, -13, -13, -12, -12, -13, -11, -11, -11, -11,
-11, -12, -12, -9, -1, };