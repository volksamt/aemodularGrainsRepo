#define DATA_LENGTH 512
#define DATA AKWF_0510

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 9, 10, 12, 15, 18, 19, 22,
24, 26, 28, 30, 32, 34, 36, 38, 40, 43, 45, 46, 48, 50, 51, 54, 56, 58, 59, 60,
63, 64, 66, 68, 69, 72, 73, 74, 76, 77, 80, 80, 81, 83, 84, 85, 87, 88, 90, 91,
92, 94, 94, 95, 97, 97, 98, 99, 100, 102, 102, 102, 104, 104, 106, 106, 107,
108, 108, 109, 109, 110, 110, 111, 112, 112, 113, 114, 113, 113, 114, 114, 114,
116, 115, 116, 117, 116, 117, 117, 117, 117, 117, 118, 117, 118, 118, 119, 118,
118, 118, 118, 119, 119, 118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 118, 120, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 120, 119, 118,
119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119,
118, 119, 118, 119, 119, 118, 119, 119, 118, 119, 118, 118, 118, 118, 117, 117,
116, 117, 116, 117, 116, 116, 116, 115, 115, 115, 114, 114, 113, 114, 113, 112,
112, 111, 111, 111, 110, 110, 108, 108, 107, 107, 105, 105, 105, 104, 102, 103,
101, 100, 99, 98, 98, 96, 96, 94, 93, 92, 91, 89, 88, 87, 86, 84, 84, 82, 80,
79, 77, 75, 74, 72, 70, 69, 68, 65, 64, 62, 61, 59, 57, 55, 53, 52, 49, 48, 45,
43, 42, 40, 38, 35, 34, 32, 29, 27, 25, 24, 21, 19, 17, 15, 13, 11, 9, 6, 4, 2,
0, -1, -5, -7, -9, -11, -13, -16, -17, -19, -22, -24, -27, -28, -31, -32, -33,
-36, -38, -40, -42, -45, -46, -48, -50, -52, -53, -55, -57, -59, -61, -62, -64,
-67, -67, -69, -71, -73, -75, -76, -77, -78, -80, -82, -83, -84, -86, -88, -88,
-90, -91, -91, -93, -93, -96, -96, -98, -99, -99, -100, -102, -102, -103, -104,
-104, -106, -106, -106, -108, -108, -108, -109, -110, -110, -111, -111, -112,
-113, -113, -113, -114, -114, -115, -115, -115, -116, -115, -115, -117, -116,
-116, -117, -117, -117, -118, -117, -118, -118, -119, -118, -118, -119, -119,
-119, -119, -118, -119, -119, -118, -119, -118, -119, -119, -119, -118, -119,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -118, -120, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -118, -119, -119, -119, -118, -118, -119, -118, -118,
-118, -118, -118, -118, -118, -118, -117, -118, -117, -117, -117, -117, -116,
-116, -116, -116, -116, -115, -115, -115, -114, -114, -113, -113, -112, -112,
-111, -111, -110, -110, -109, -108, -108, -107, -107, -106, -106, -104, -103,
-103, -102, -101, -100, -99, -98, -97, -96, -95, -93, -93, -92, -90, -89, -88,
-86, -85, -84, -83, -81, -80, -78, -77, -75, -74, -72, -71, -69, -68, -66, -64,
-63, -60, -59, -57, -55, -53, -51, -50, -48, -46, -44, -42, -39, -37, -36, -34,
-31, -30, -28, -25, -24, -21, -19, -17, -14, -13, -10, -8, -7, -4, -1, };