#define DATA_LENGTH 512
#define DATA AKWF_0545

const PROGMEM int8_t DATA[DATA_LENGTH] = {25, 119, 103, 98, 97, 89, 82, 67, 74,
84, 74, 67, 61, 54, 51, 37, 70, 83, 73, 65, 60, 59, 49, 42, 42, 49, 44, 36, 35,
24, 21, 2, 47, 91, 70, 70, 57, 57, 48, 44, 51, 50, 43, 33, 32, 26, 18, 8, 24,
54, 42, 37, 33, 24, 19, 7, 20, 23, 12, 3, -4, -5, -11, -22, 18, 53, 42, 36, 35,
27, 19, 7, 11, 23, 11, 6, -2, -7, -12, -23, 8, 22, 12, 3, -2, -3, -13, -20, -19,
-12, -18, -26, -26, -37, -41, -60, -13, 30, 8, 8, -5, -4, -13, -18, -11, -11,
-19, -28, -30, -35, -44, -53, -36, -7, -20, -23, -30, -38, -43, -54, -41, -39,
-50, -59, -65, -69, -70, -90, 9, 92, 68, 70, 63, 58, 48, 38, 42, 54, 42, 38, 28,
23, 18, 8, 40, 53, 42, 34, 29, 27, 18, 12, 12, 18, 12, 5, 4, -8, -9, -29, 21,
60, 39, 38, 25, 26, 16, 13, 19, 18, 11, 2, 1, -4, -14, -22, -4, 24, 10, 8, 0,
-7, -12, -24, -10, -8, -20, -28, -35, -37, -42, -56, 26, 89, 69, 68, 64, 58, 49,
39, 43, 54, 40, 38, 28, 24, 18, 9, 41, 53, 41, 33, 29, 27, 17, 11, 12, 19, 12,
5, 4, -7, -10, -29, 23, 59, 38, 38, 25, 27, 16, 13, 20, 20, 11, 2, 1, -4, -13,
-23, -3, 24, 9, 7, 0, -7, -14, -22, -9, -9, -20, -29, -34, -37, -42, -58, 29,
90, 68, 68, 63, 59, 48, 38, 43, 54, 40, 37, 27, 25, 17, 9, 42, 53, 41, 33, 29,
28, 17, 12, 11, 19, 11, 4, 3, -7, -11, -29, 26, 60, 39, 37, 25, 26, 16, 13, 20,
18, 12, 2, 1, -4, -13, -23, -2, 23, 10, 7, 0, -6, -14, -23, -8, -9, -21, -29,
-35, -36, -45, -51, -7, 22, 10, 5, 3, -4, -13, -24, -18, -8, -21, -24, -34, -37,
-44, -52, -19, -10, -21, -29, -32, -34, -45, -50, -50, -43, -51, -57, -58, -69,
-74, -91, -35, -3, -24, -25, -37, -36, -46, -48, -41, -42, -51, -59, -61, -66,
-76, -84, -63, -38, -53, -54, -62, -68, -76, -85, -71, -71, -83, -92, -96, -99,
-103, -117, -7, 61, 35, 38, 32, 28, 16, 8, 12, 24, 9, 7, -5, -6, -15, -21, 13,
22, 10, 2, -1, -4, -15, -20, -19, -12, -21, -26, -28, -38, -43, -59, -2, 27, 7,
6, -7, -5, -15, -17, -10, -12, -20, -29, -30, -36, -44, -53, -31, -6, -22, -23,
-32, -37, -45, -53, -39, -40, -52, -59, -67, -68, -75, -83, 6, 57, 37, 38, 32,
27, 16, 7, 14, 23, 9, 6, -5, -7, -15, -20, 14, 22, 10, 2, -2, -4, -14, -20, -19,
-11, -21, -26, -28, -39, -43, -60, 0, 27, 8, 6, -6, -5, -16, -17, -11, -12, -21,
-29, -30, -36, -45, -53, -31, -6, -23, -22, -33, -36, -47, -53, -40, -38, -54,
-58, -70, -64, -81, -76, };