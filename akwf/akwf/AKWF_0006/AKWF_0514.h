#define DATA_LENGTH 512
#define DATA AKWF_0514

const PROGMEM int8_t DATA[DATA_LENGTH] = {20, 23, 23, 23, 23, 23, 24, 24, 24,
25, 26, 26, 26, 28, 28, 28, 28, 29, 30, 30, 32, 32, 31, 31, 32, 31, 32, 32, 31,
32, 30, 31, 31, 30, 30, 30, 29, 30, 29, 28, 29, 29, 29, 29, 29, 29, 29, 30, 29,
30, 31, 32, 31, 31, 31, 31, 30, 32, 32, 31, 33, 34, 35, 36, 36, 38, 38, 39, 40,
40, 42, 42, 43, 44, 45, 44, 45, 45, 46, 47, 46, 47, 49, 51, 50, 51, 51, 52, 51,
51, 51, 48, 42, 43, 45, 44, 43, 44, 42, 40, 39, 37, 36, 35, 34, 33, 31, 32, 31,
31, 30, 29, 28, 27, 26, 26, 26, 26, 25, 23, 25, 26, 25, 25, 23, 23, 24, 24, 24,
24, 24, 25, 25, 25, 26, 27, 26, 28, 28, 29, 30, 30, 32, 33, 34, 34, 34, 35, 35,
36, 39, 41, 41, 44, 48, 49, 50, 49, 50, 50, 53, 55, 56, 57, 58, 58, 58, 58, 59,
59, 58, 59, 58, 60, 59, 59, 58, 58, 55, 55, 51, 55, 78, 87, 95, 96, 85, 76, 71,
68, 65, 63, 61, 59, 58, 56, 55, 54, 52, 50, 48, 48, 47, 47, 45, 46, 44, 45, 45,
46, 44, 46, 45, 46, 45, 48, 44, 42, 30, -21, -46, -75, -80, -93, -108, -104,
-89, -82, -86, -75, -63, -67, -61, -49, -67, -66, -68, -67, -68, -88, -88, -89,
-88, -90, -86, -68, -69, -70, -69, -71, -81, -96, -118, -115, -119, -117, -96,
-75, -53, -50, -49, -46, -27, -27, -27, -28, -27, -30, -47, -46, -48, -47, -48,
-47, -48, -48, -48, -48, -33, -28, -30, -27, -31, -28, -30, -27, -35, -52, -48,
-51, -49, -53, -44, -29, -33, -32, -33, -34, -32, -45, -55, -50, -54, -53, -53,
-55, -55, -58, -55, -36, -40, -40, -40, -43, -42, -45, -43, -58, -68, -65, -68,
-68, -67, -70, -52, -47, -50, -49, -50, -50, -51, -50, -51, -51, -52, -51, -51,
-52, -51, -51, -51, -52, -51, -51, -50, -50, -48, -52, -57, -55, -52, -54, -53,
-51, -53, -54, -55, -55, -57, -57, -57, -57, -57, -57, -57, -58, -58, -58, -58,
-55, -55, -54, -55, -55, -55, -54, -54, -54, -54, -55, -54, -54, -53, -53, -52,
-52, -51, -50, -49, -49, -48, -47, -46, -46, -45, -45, -44, -43, -43, -42, -42,
-39, -40, -38, -40, -37, -40, -33, -16, -18, -17, -17, -17, -16, -16, -17, -17,
-16, -16, -17, -17, -16, -17, -16, -16, -16, -17, -16, -16, -15, -16, -14, -17,
-14, -17, -12, -20, 6, 49, 40, 46, 39, 16, 17, 18, 19, 21, 20, 23, 23, 25, 26,
28, 28, 31, 32, 34, 35, 37, 38, 41, 42, 44, 46, 39, 42, 37, 32, 29, 27, 29, 31,
25, 37, -18, -43, -24, -28, -22, -24, -20, -21, -18, -20, -17, -18, -16, -15,
-15, -15, -14, -13, -13, -12, -12, -11, -11, -10, -10, -10, -10, -10, -10, -10,
-9, -12, -38, -36, -38, -35, -38, -31, };