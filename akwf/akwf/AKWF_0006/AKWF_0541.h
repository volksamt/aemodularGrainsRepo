#define DATA_LENGTH 512
#define DATA AKWF_0541

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 51, 66, 64, 78, 80, 57, 43, 70, 96,
85, 57, 49, 42, 28, 32, 73, 109, 104, 85, 82, 77, 48, 28, 43, 61, 46, 25, 22,
20, 6, 14, 63, 113, 118, 104, 103, 99, 76, 62, 79, 92, 69, 38, 32, 28, 5, -1,
34, 71, 71, 53, 46, 33, 2, -12, 13, 33, 16, -10, -10, -3, -6, 5, 54, 100, 108,
105, 113, 112, 84, 70, 91, 114, 96, 66, 54, 45, 27, 28, 67, 100, 90, 68, 63, 55,
22, 1, 13, 29, 11, -12, -15, -19, -35, -28, 21, 69, 72, 57, 55, 50, 25, 13, 31,
42, 18, -12, -18, -22, -43, -47, -12, 26, 25, 11, 5, -8, -38, -50, -23, 0, -16,
-42, -39, -29, -32, -17, 34, 81, 92, 89, 101, 100, 75, 61, 87, 110, 94, 66, 56,
48, 31, 36, 76, 110, 101, 78, 76, 68, 36, 15, 30, 45, 28, 5, 2, -2, -17, -9, 41,
87, 89, 73, 70, 65, 39, 25, 43, 53, 27, -5, -11, -17, -42, -46, -12, 24, 20, 1,
-5, -21, -52, -66, -41, -23, -42, -69, -68, -61, -66, -52, -4, 40, 47, 43, 53,
48, 20, 6, 30, 50, 31, 1, -10, -20, -39, -35, 5, 36, 25, 2, -1, -10, -43, -62,
-48, -33, -52, -75, -76, -80, -96, -86, -34, 12, 14, -1, -2, -7, -31, -41, -22,
-11, -35, -63, -67, -72, -94, -95, -55, -19, -20, -34, -38, -50, -80, -89, -60,
-38, -56, -77, -72, -62, -63, -46, 7, 53, 64, 63, 75, 75, 50, 39, 67, 90, 74,
46, 38, 32, 17, 23, 67, 98, 88, 68, 68, 59, 28, 11, 28, 41, 25, 3, 1, -1, -16,
-5, 47, 93, 93, 78, 77, 71, 45, 34, 54, 62, 35, 6, 0, -7, -30, -32, 5, 39, 34,
16, 10, -6, -39, -50, -23, -5, -27, -51, -50, -44, -48, -33, 17, 60, 64, 60, 70,
64, 35, 23, 48, 67, 45, 16, 5, -5, -24, -18, 22, 51, 37, 15, 11, 0, -34, -53,
-37, -25, -46, -68, -70, -75, -91, -80, -28, 15, 14, -1, -1, -9, -34, -44, -25,
-17, -44, -72, -76, -82, -104, -105, -65, -32, -35, -50, -56, -71, -101, -108,
-79, -61, -81, -103, -98, -89, -92, -73, -19, 24, 30, 30, 41, 38, 11, 2, 31, 51,
31, 3, -5, -13, -30, -21, 22, 51, 38, 19, 17, 7, -26, -43, -25, -13, -32, -53,
-55, -59, -75, -61, -9, 33, 32, 17, 16, 8, -18, -27, -9, -1, -30, -59, -63, -71,
-95, -95, -56, -25, -31, -48, -55, -71, -104, -111, -84, -69, -91, -115, -111,
-105, -109, -92, -40, 1, 5, 2, 12, 7, -22, -31, -6, 12, -9, -39, -47, -56, -74,
-65, -22, 4, -9, -30, -33, -43, -75, -91, -74, -61, -82, -103, -102, -107, -121,
-106, -50, -8, -9, -23, -21, -29, -52, -59, -37, -29, -55, -81, -82, -87, -108,
-105, -63, -27, -31, -45, -47, -61, -90, -93, -62, -43, -63, -81, -75, -63, -68,
-38, };