#define DATA_LENGTH 512
#define DATA AKWF_0579

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 6, 7, 9, 11, 12, 13, 15, 17,
18, 19, 22, 23, 25, 26, 28, 30, 30, 33, 34, 36, 38, 40, 41, 43, 44, 46, 47, 49,
51, 52, 53, 55, 57, 58, 60, 61, 64, 66, 66, 68, 69, 71, 73, 75, 77, 78, 79, 81,
83, 84, 86, 88, 89, 91, 92, 94, 96, 97, 99, 101, 102, 104, 105, 106, 109, 110,
112, 113, 115, 116, 118, 118, 116, 113, 113, 111, 109, 108, 105, 105, 102, 100,
99, 98, 96, 95, 93, 91, 89, 88, 86, 84, 83, 81, 79, 78, 76, 75, 73, 71, 70, 68,
66, 64, 64, 62, 60, 58, 56, 55, 53, 52, 50, 49, 48, 45, 44, 41, 41, 38, 37, 35,
34, 32, 30, 29, 27, 25, 24, 22, 21, 20, 17, 16, 14, 12, 10, 9, 4, -7, -1, -1,
-6, -7, -11, -14, -15, -17, -17, -19, -21, -22, -24, -25, -27, -28, -29, -32,
-32, -34, -36, -37, -38, -40, -41, -42, -44, -46, -47, -48, -50, -51, -53, -54,
-56, -56, -58, -61, -62, -62, -64, -65, -67, -69, -70, -71, -72, -75, -76, -77,
-78, -81, -82, -83, -85, -86, -87, -89, -90, -91, -93, -94, -96, -97, -99, -100,
-102, -103, -105, -105, -107, -109, -110, -107, -108, -105, -105, -102, -102,
-99, -99, -96, -95, -94, -92, -92, -88, -94, -20, 7, -3, 6, 3, 8, 6, 9, 10, 13,
12, 15, 17, 17, 20, 19, 23, 21, 27, 17, -30, -25, -22, -19, -15, -15, -10, -8,
-3, -3, 2, 3, 7, 9, 13, 14, 19, 21, 24, 26, 29, 32, 36, 38, 41, 44, 46, 50, 52,
54, 57, 62, 64, 66, 70, 73, 75, 78, 81, 83, 84, 85, 86, 88, 89, 91, 92, 93, 95,
97, 98, 100, 101, 103, 103, 101, 100, 98, 96, 96, 93, 92, 91, 89, 88, 87, 85,
84, 81, 80, 80, 78, 77, 74, 74, 72, 71, 69, 68, 66, 65, 63, 62, 59, 59, 57, 56,
55, 54, 52, 50, 49, 48, 46, 43, 47, 6, -9, -6, -10, -9, -13, -13, -14, -19, -7,
15, 6, 6, 1, 0, -4, -7, -10, -13, -16, -19, -22, -25, -28, -31, -33, -38, -39,
-43, -45, -49, -52, -54, -56, -57, -58, -61, -62, -64, -65, -68, -68, -70, -71,
-73, -75, -76, -78, -79, -81, -83, -84, -85, -87, -89, -90, -92, -93, -95, -97,
-98, -100, -101, -103, -104, -107, -108, -108, -110, -112, -113, -115, -117,
-118, -119, -116, -115, -113, -112, -110, -109, -107, -105, -104, -103, -101,
-100, -97, -96, -95, -92, -91, -90, -88, -87, -85, -83, -82, -80, -78, -77, -75,
-74, -71, -70, -68, -67, -65, -64, -62, -60, -59, -58, -56, -54, -53, -52, -49,
-48, -46, -45, -44, -42, -40, -38, -37, -35, -34, -32, -31, -29, -27, -27, -24,
-23, -22, -19, -18, -16, -16, -14, -12, -10, -8, -7, -5, -5, -1, -1, -1, -1, -1,
-1, -1, -1, -1, -1, -2, -1, -1, -1, -2, -1, -1, 0, };