#define DATA_LENGTH 512
#define DATA AKWF_0524

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 5, 5, 5, 5, 4, 5, 4, 5, 4, 5, 4, 5,
4, 5, 5, 3, 52, 63, 57, 61, 58, 60, 58, 61, 59, 61, 59, 60, 59, 60, 59, 60, 60,
60, 59, 60, 60, 59, 59, 59, 60, 59, 60, 59, 60, 59, 60, 59, 60, 59, 60, 59, 59,
59, 60, 60, 60, 60, 59, 60, 59, 59, 59, 59, 60, 60, 60, 60, 60, 60, 60, 59, 59,
59, 60, 60, 59, 60, 60, 60, 59, 60, 59, 59, 59, 59, 60, 59, 60, 59, 59, 60, 59,
59, 59, 60, 60, 60, 60, 59, 59, 59, 60, 59, 60, 59, 59, 59, 59, 59, 59, 60, 59,
60, 60, 60, 59, 60, 59, 59, 59, 59, 59, 59, 59, 60, 59, 60, 60, 59, 60, 60, 60,
61, 59, 61, 65, 64, 64, 63, 64, 65, 64, 64, 64, 64, 59, 59, 60, 59, 59, 60, 60,
60, 60, 60, 60, 59, 60, 59, 59, 59, 61, 58, 61, 57, 61, 55, 65, 42, -1, 7, 3, 5,
4, 5, 4, 5, 5, 4, 4, 4, 5, 4, 5, 5, 4, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0,
0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 2, -3, 6, -32, -61, -51, -57, -53,
-56, -54, -55, -54, -56, -54, -55, -55, -56, -55, -54, -55, -55, -54, -55, -55,
-55, -56, -55, -56, -55, -55, -55, -55, -55, -55, -54, -55, -55, -55, -55, -55,
-55, -55, -55, -55, -55, -54, -55, -55, -56, -55, -55, -55, -55, -54, -55, -54,
-55, -55, -55, -55, -54, -55, -55, -55, -54, -56, -56, -54, -55, -55, -54, -55,
-55, -55, -54, -55, -55, -55, -56, -61, -58, -60, -58, -61, -59, -60, -59, -60,
-60, -59, -60, -58, -106, -118, -113, -116, -113, -115, -113, -116, -114, -116,
-114, -116, -113, -115, -114, -115, -114, -115, -114, -115, -115, -115, -114,
-114, -119, -119, -120, -119, -120, -120, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -118, -119, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -118, -119, -118, -114, -115, -114,
-114, -114, -115, -114, -114, -115, -115, -114, -115, -115, -114, -114, -114,
-115, -115, -114, -115, -114, -114, -114, -114, -115, -114, -114, -114, -114,
-114, -115, -114, -115, -114, -114, -114, -114, -114, -115, -114, -115, -115,
-114, -115, -114, -115, -114, -114, -115, -114, -114, -115, -114, -114, -115,
-115, -115, -115, -114, -114, -115, -114, -114, -115, -114, -115, -114, -115,
-115, -115, -115, -115, -114, -114, -115, -114, -114, -114, -115, -114, -115,
-113, -116, -113, -116, -113, -115, -113, -115, -113, -116, -109, -59, -60, -59,
-58, -61, -59, -60, -59, -60, -59, -60, -60, -60, -58, -54, -55, -55, -55, -54,
-56, -55, -56, -54, -54, -56, -54, -60, -12, 5, -3, 2, -2, 1, -1, 2, -1, 1, 0,
0, -1, 0, };