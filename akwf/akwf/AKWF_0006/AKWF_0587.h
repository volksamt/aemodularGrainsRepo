#define DATA_LENGTH 512
#define DATA AKWF_0587

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 11, 14, 19, 23, 28, 32, 37, 41,
44, 48, 52, 55, 56, 60, 62, 63, 65, 65, 66, 67, 68, 68, 69, 69, 69, 69, 69, 70,
69, 69, 70, 70, 71, 72, 72, 72, 72, 73, 73, 73, 72, 72, 70, 70, 69, 66, 66, 64,
63, 61, 58, 56, 54, 52, 49, 47, 45, 43, 41, 39, 36, 35, 33, 32, 30, 28, 26, 23,
20, 17, 14, 11, 9, 4, 1, -4, -7, -12, -15, -20, -24, -27, -31, -35, -38, -40,
-43, -46, -47, -49, -50, -52, -53, -53, -52, -54, -53, -54, -53, -54, -53, -53,
-52, -52, -51, -51, -50, -49, -47, -46, -46, -44, -43, -42, -40, -38, -36, -35,
-32, -31, -31, -29, -26, -25, -23, -22, -21, -20, -18, -18, -16, -15, -15, -14,
-12, -11, -10, -9, -6, -4, -2, -1, 3, 5, 9, 11, 15, 17, 21, 23, 26, 30, 32, 35,
37, 39, 41, 42, 43, 45, 45, 46, 47, 47, 47, 46, 46, 45, 45, 45, 44, 44, 43, 43,
41, 40, 39, 38, 36, 35, 34, 31, 28, 26, 24, 21, 18, 14, 11, 7, 3, -1, -5, -9,
-14, -18, -22, -26, -30, -35, -39, -43, -48, -49, -59, -79, -92, -105, -112,
-118, -119, -119, -114, -107, -98, -90, -81, -72, -65, -57, -54, -51, -51, -53,
-57, -62, -69, -75, -82, -88, -91, -94, -92, -89, -82, -74, -62, -52, -50, -48,
-45, -43, -39, -38, -34, -32, -28, -24, -21, -18, -14, -10, -8, -3, 1, 6, 9, 14,
18, 23, 28, 32, 36, 40, 43, 48, 51, 54, 57, 59, 61, 64, 65, 67, 67, 69, 69, 69,
69, 70, 70, 70, 71, 71, 71, 71, 71, 73, 74, 73, 74, 74, 75, 75, 75, 75, 75, 74,
73, 72, 71, 70, 68, 66, 65, 63, 60, 58, 55, 54, 51, 49, 46, 45, 43, 40, 38, 37,
35, 34, 31, 30, 26, 25, 22, 19, 16, 11, 8, 4, 0, -3, -9, -13, -16, -20, -24,
-29, -32, -35, -37, -40, -42, -45, -47, -49, -50, -52, -52, -53, -54, -53, -54,
-54, -54, -53, -52, -52, -52, -50, -50, -49, -48, -47, -45, -43, -42, -39, -37,
-35, -32, -30, -28, -25, -22, -20, -17, -16, -13, -11, -10, -8, -7, -6, -4, -3,
-1, -1, 0, 1, 2, 4, 4, 7, 8, 10, 12, 16, 18, 20, 24, 26, 29, 32, 34, 37, 39, 42,
43, 46, 47, 48, 49, 50, 50, 51, 50, 49, 49, 49, 47, 46, 44, 43, 42, 42, 40, 38,
37, 35, 35, 32, 32, 29, 27, 26, 24, 20, 19, 16, 14, 10, 7, 4, 1, -3, -5, -9,
-13, -16, -20, -24, -28, -31, -35, -39, -42, -45, -48, -50, -61, -80, -94, -106,
-114, -118, -119, -118, -113, -106, -98, -90, -79, -71, -63, -56, -52, -51, -51,
-53, -57, -63, -69, -76, -82, -88, -92, -93, -92, -88, -82, -73, -62, -51, -50,
-46, -46, -42, -39, -36, -33, -31, -28, -24, -21, -17, -13, -10, -7, -2, };