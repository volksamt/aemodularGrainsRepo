#define DATA_LENGTH 512
#define DATA AKWF_0535

const PROGMEM int8_t DATA[DATA_LENGTH] = {68, 97, 88, 75, 74, 62, 75, 101, 68,
78, 63, 68, 60, 63, 60, 61, 60, 60, 60, 59, 60, 58, 60, 58, 61, 58, 60, 59, 60,
58, 60, 59, 59, 59, 60, 58, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 60,
59, 59, 59, 59, 59, 59, 59, 59, 60, 60, 59, 59, 60, 59, 60, 59, 59, 60, 58, 58,
59, 59, 59, 60, 59, 60, 59, 58, 60, 59, 59, 60, 59, 59, 59, 59, 59, 60, 59, 60,
60, 60, 60, 59, 59, 59, 60, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 60,
59, 59, 59, 60, 60, 59, 58, 59, 59, 59, 60, 60, 60, 58, 60, 59, 60, 60, 59, 59,
59, 59, 59, 60, 58, 60, 59, 59, 59, 60, 59, 59, 59, 59, 59, 59, 59, 59, 59, 60,
60, 59, 60, 59, 59, 60, 59, 59, 60, 59, 59, 60, 59, 59, 59, 58, 59, 60, 59, 60,
59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 60, 60, 60, 59, 59, 59, 59, 59, 60, 59,
59, 59, 59, 59, 59, 59, 60, 60, 59, 59, 59, 59, 59, 59, 60, 60, 60, 59, 59, 58,
60, 59, 59, 59, 60, 59, 60, 59, 60, 60, 60, 59, 59, 59, 59, 59, 60, 59, 60, 59,
59, 59, 59, 59, 60, 59, 59, 59, 59, 59, 59, 59, 59, 60, 60, 59, 59, 59, 59, 60,
59, 59, 59, 58, 59, 59, 60, 59, 59, 59, 59, 59, 59, 59, 60, 59, 60, 59, 59, 59,
59, 59, 60, 59, 59, 59, 59, 59, 59, 59, 60, 59, 59, 59, 60, 60, 60, 60, 60, 60,
60, 59, 59, 60, 59, 59, 59, 59, 60, 59, 59, 59, 60, 60, 59, 59, 60, 59, 59, 59,
59, 58, 60, 60, 59, 60, 59, 59, 58, 60, 59, 59, 59, 59, 59, 59, 59, 60, 59, 59,
59, 59, 59, 59, 59, 59, 59, 60, 60, 59, 59, 59, 60, 59, 59, 59, 60, 59, 59, 59,
59, 58, 59, 60, 60, 59, 59, 60, 59, 59, 59, 59, 59, 59, 59, 60, 60, 59, 59, 60,
60, 60, 59, 59, 59, 59, 60, 60, 59, 59, 60, 59, 59, 59, 60, 60, 59, 59, 59, 59,
59, 59, 59, 59, 60, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 58,
59, 59, 60, 58, 59, 59, 59, 59, 60, 58, 60, 58, 61, 59, 60, 59, 60, 59, 59, 59,
59, 60, 58, 61, 58, 62, 57, 63, 56, 64, 54, 66, 51, 70, 47, 76, 10, -124, -70,
-101, -83, -77, -71, -67, -65, -62, -63, -59, -62, -58, -62, -57, -61, -57, -61,
-58, -61, -57, -61, -58, -61, -57, -60, -59, -59, -58, -60, -60, -59, -59, -59,
-59, -59, -59, -59, -60, -58, -59, -58, -60, -58, -60, -58, -60, -58, -61, -59,
-61, -58, -61, -57, -60, -58, -60, -59, -59, -60, -57, -61, -55, -65, -49, -77,
};