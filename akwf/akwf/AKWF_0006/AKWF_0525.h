#define DATA_LENGTH 512
#define DATA AKWF_0525

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, -1, 2, 4, 3, 6, 18, 17, 18, 20,
22, 20, 25, 36, 35, 35, 35, 35, 35, 36, 40, 38, 40, 52, 54, 53, 55, 56, 56, 57,
57, 57, 55, 67, 72, 69, 73, 74, 74, 73, 75, 73, 75, 74, 75, 73, 77, 88, 88, 88,
88, 88, 89, 88, 87, 87, 88, 92, 92, 91, 91, 91, 92, 91, 92, 91, 91, 91, 92, 92,
92, 92, 92, 92, 92, 91, 92, 91, 92, 92, 93, 91, 92, 91, 92, 91, 93, 92, 91, 92,
92, 103, 107, 104, 106, 104, 106, 104, 106, 105, 107, 105, 105, 105, 105, 105,
105, 106, 95, 91, 92, 91, 92, 91, 92, 91, 92, 92, 92, 92, 92, 92, 88, 88, 87,
88, 88, 87, 88, 87, 88, 88, 88, 87, 90, 82, 73, 76, 74, 74, 74, 74, 74, 74, 73,
75, 74, 75, 74, 74, 74, 74, 74, 74, 75, 74, 70, 71, 70, 70, 71, 70, 71, 70, 71,
70, 71, 69, 72, 66, 55, 58, 56, 57, 57, 57, 54, 52, 53, 52, 53, 52, 54, 43, 38,
40, 38, 34, 35, 35, 36, 34, 36, 29, 20, 23, 21, 18, 18, 17, 18, 17, 19, 15, 3,
4, 4, 3, 4, 4, 3, 4, 4, 4, 0, 0, -1, 0, 0, 1, -2, -15, -13, -14, -14, -13, -14,
-14, -14, -13, -14, -13, -14, -14, -14, -13, -15, -14, -14, -14, -14, -13, -14,
-13, -14, -14, -14, -14, -13, -14, -14, -14, -14, -14, -14, -14, -13, -16, -5,
1, 0, -2, -15, -13, -14, -14, -14, -14, -13, -14, -13, -14, -13, -14, -14, -13,
-14, -14, -13, -15, -13, -14, -13, -14, -13, -16, -17, -18, -17, -18, -18, -18,
-17, -18, -17, -19, -32, -31, -31, -31, -32, -31, -32, -35, -35, -36, -34, -36,
-34, -41, -50, -47, -50, -48, -50, -49, -51, -53, -52, -53, -52, -53, -52, -63,
-67, -66, -66, -67, -67, -66, -70, -70, -70, -70, -70, -69, -71, -70, -70, -69,
-80, -85, -84, -85, -84, -84, -83, -84, -83, -85, -86, -89, -87, -89, -87, -88,
-87, -88, -88, -88, -88, -87, -88, -87, -100, -103, -100, -102, -101, -102,
-102, -102, -101, -101, -104, -106, -105, -106, -105, -105, -106, -105, -106,
-103, -110, -120, -118, -120, -119, -119, -120, -120, -120, -119, -119, -118,
-119, -119, -119, -119, -119, -118, -118, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -118, -120, -118, -120, -116, -104, -106, -104,
-106, -105, -105, -106, -105, -105, -105, -105, -105, -106, -105, -105, -105,
-105, -105, -106, -106, -106, -105, -105, -105, -106, -105, -106, -106, -105,
-105, -103, -101, -101, -102, -102, -102, -101, -101, -102, -102, -101, -102,
-101, -102, -101, -102, -101, -102, -101, -103, -100, -88, -89, -89, -88, -88,
-87, -88, -83, -84, -84, -85, -83, -86, -78, -68, -70, -70, -67, -65, -69, -58,
-51, -54, -50, -49, -48, -50, -38, -34, -36, -33, -31, -31, -32, -18, -17, -18,
-16, -13, -14, -12, };