#define DATA_LENGTH 512
#define DATA AKWF_0521

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 7, 10, 13, 15, 17, 21, 22,
26, 28, 31, 33, 36, 38, 41, 44, 46, 49, 51, 53, 56, 58, 61, 62, 65, 68, 71, 72,
74, 77, 79, 81, 82, 85, 88, 88, 90, 93, 95, 97, 98, 100, 101, 103, 104, 106,
107, 108, 109, 111, 112, 113, 114, 115, 115, 116, 116, 116, 118, 118, 119, 119,
119, 120, 119, 119, 119, 119, 118, 119, 117, 117, 117, 116, 115, 115, 114, 113,
112, 112, 110, 109, 107, 105, 104, 103, 102, 99, 99, 96, 95, 92, 91, 90, 87, 85,
83, 81, 78, 76, 74, 72, 69, 67, 64, 61, 59, 57, 54, 51, 49, 46, 44, 41, 38, 35,
33, 31, 28, 25, 23, 20, 17, 15, 12, 8, 7, 4, 1, -2, -3, -7, -8, -11, -14, -16,
-19, -22, -24, -26, -27, -30, -31, -34, -36, -38, -40, -42, -44, -46, -47, -49,
-50, -52, -54, -54, -57, -57, -59, -60, -62, -62, -64, -64, -65, -66, -66, -67,
-68, -68, -69, -69, -69, -70, -70, -70, -69, -70, -70, -69, -70, -69, -69, -68,
-67, -67, -67, -65, -64, -64, -64, -62, -62, -60, -59, -58, -58, -57, -54, -54,
-52, -52, -50, -49, -47, -45, -43, -42, -41, -38, -37, -35, -35, -32, -30, -29,
-27, -25, -22, -21, -19, -18, -16, -14, -12, -11, -9, -6, -5, -3, -1, 0, 2, 4,
6, 7, 9, 11, 11, 14, 15, 16, 18, 20, 22, 23, 24, 25, 27, 29, 30, 31, 33, 33, 35,
36, 37, 38, 39, 39, 41, 41, 43, 44, 44, 44, 46, 46, 46, 48, 48, 48, 48, 49, 49,
49, 51, 50, 50, 51, 50, 50, 50, 50, 50, 50, 50, 50, 50, 49, 49, 48, 49, 48, 47,
47, 46, 46, 45, 44, 44, 43, 43, 42, 42, 40, 39, 39, 38, 37, 36, 35, 34, 33, 33,
32, 31, 29, 29, 27, 27, 25, 24, 23, 22, 21, 20, 19, 18, 17, 16, 14, 13, 12, 10,
10, 8, 8, 6, 6, 4, 3, 2, 0, 0, -2, -2, -4, -5, -6, -7, -8, -10, -11, -12, -13,
-15, -15, -16, -17, -19, -19, -21, -22, -23, -24, -26, -26, -28, -28, -29, -31,
-32, -32, -33, -35, -35, -37, -37, -39, -40, -41, -41, -42, -44, -45, -45, -47,
-47, -48, -49, -50, -51, -52, -53, -54, -55, -56, -57, -58, -59, -60, -60, -60,
-62, -63, -64, -65, -65, -66, -67, -68, -69, -70, -70, -71, -72, -72, -73, -73,
-74, -75, -75, -76, -77, -77, -78, -79, -79, -79, -79, -81, -80, -81, -81, -82,
-82, -83, -83, -84, -84, -83, -85, -84, -84, -85, -84, -84, -85, -84, -84, -84,
-84, -83, -84, -82, -83, -81, -81, -80, -81, -80, -80, -79, -78, -78, -76, -76,
-74, -74, -73, -71, -71, -69, -69, -68, -66, -65, -64, -62, -60, -59, -57, -57,
-55, -53, -51, -49, -48, -46, -44, -42, -40, -39, -36, -34, -32, -29, -27, -26,
-23, -22, -19, -16, -14, -12, -9, -7, -4, -2, };