#define DATA_LENGTH 512
#define DATA AKWF_0554

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 6, 9, 12, 14, 17, 20, 22, 25,
28, 30, 33, 37, 39, 42, 44, 47, 50, 53, 55, 58, 60, 63, 66, 69, 71, 74, 77, 79,
83, 85, 88, 90, 93, 96, 97, 101, 102, 105, 107, 108, 110, 111, 113, 114, 116,
117, 118, 118, 119, 119, 119, 118, 118, 119, 118, 118, 117, 115, 114, 113, 112,
110, 109, 107, 105, 103, 102, 99, 97, 96, 93, 91, 89, 86, 84, 82, 78, 76, 74,
72, 69, 66, 64, 61, 60, 56, 53, 50, 48, 45, 43, 39, 38, 35, 32, 30, 27, 24, 21,
19, 17, 13, 11, 8, 6, 4, 1, -1, -5, -7, -10, -13, -15, -17, -20, -23, -26, -27,
-31, -33, -36, -39, -40, -43, -46, -49, -52, -54, -56, -60, -63, -65, -68, -70,
-73, -75, -78, -81, -83, -86, -89, -92, -93, -96, -99, -101, -103, -105, -107,
-109, -110, -112, -112, -115, -117, -117, -118, -118, -119, -118, -119, -120,
-119, -119, -118, -117, -117, -115, -115, -114, -112, -111, -109, -108, -106,
-105, -103, -101, -100, -98, -95, -93, -90, -88, -86, -85, -81, -79, -77, -74,
-72, -69, -67, -63, -61, -59, -56, -54, -52, -48, -47, -44, -41, -38, -37, -34,
-31, -28, -25, -23, -20, -18, -15, -13, -9, -8, -4, -3, 6, 45, 67, 82, 96, 105,
113, 117, 119, 117, 117, 113, 110, 104, 99, 93, 87, 80, 74, 68, 62, 55, 50, 44,
38, 32, 26, 21, 15, 9, 4, -2, -6, -12, -17, -22, -27, -33, -36, -41, -47, -52,
-56, -62, -65, -71, -75, -80, -85, -89, -93, -98, -101, -106, -108, -111, -113,
-115, -117, -117, -119, -120, -119, -118, -117, -116, -115, -113, -111, -108,
-106, -104, -100, -97, -95, -91, -88, -84, -80, -76, -73, -70, -66, -62, -59,
-54, -51, -49, -44, -41, -37, -33, -29, -26, -22, -19, -15, -12, -7, -4, -1, 3,
7, 11, 14, 18, 20, 24, 27, 31, 34, 38, 42, 46, 48, 52, 56, 59, 63, 65, 69, 72,
76, 79, 83, 86, 90, 93, 95, 99, 102, 105, 107, 110, 111, 114, 115, 116, 117,
118, 119, 119, 119, 119, 119, 118, 117, 116, 114, 113, 112, 111, 108, 106, 104,
103, 99, 97, 96, 92, 90, 86, 84, 81, 79, 75, 73, 69, 67, 63, 60, 58, 54, 51, 48,
46, 42, 39, 36, 33, 30, 28, 24, 21, 18, 14, 11, 9, 6, 2, 0, -4, -5, -10, -12,
-15, -18, -20, -25, -27, -29, -33, -35, -39, -42, -45, -48, -51, -53, -56, -60,
-63, -65, -68, -71, -74, -77, -80, -83, -86, -89, -92, -95, -97, -100, -102,
-104, -107, -108, -111, -112, -113, -115, -116, -118, -119, -119, -119, -119,
-119, -118, -118, -118, -117, -116, -115, -114, -112, -110, -109, -108, -106,
-104, -102, -100, -98, -95, -94, -91, -88, -86, -84, -81, -78, -76, -74, -71,
-68, -65, -62, -60, -57, -54, -52, -50, -46, -43, -40, -37, -35, -32, -29, -26,
-23, -21, -18, -16, -13, -10, -7, -4, -2, };