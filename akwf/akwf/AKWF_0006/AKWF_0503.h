#define DATA_LENGTH 512
#define DATA AKWF_0503

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 116, 122, 116, 122, 117,
122, 117, 121, 117, 121, 118, 120, 118, 120, 119, 120, 119, 120, 119, 119, 119,
119, 120, 119, 119, 118, 119, 118, 119, 119, 119, 119, 119, 118, 119, 118, 119,
118, 119, 119, 119, 118, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 118,
119, 118, 118, 119, 118, 118, 119, 119, 118, 119, 119, 119, 118, 118, 119, 118,
118, 118, 118, 119, 118, 118, 118, 118, 118, 119, 119, 118, 119, 118, 119, 118,
118, 118, 118, 118, 119, 118, 119, 117, 119, 118, 118, 118, 118, 117, 117, 118,
118, 118, 119, 118, 117, 119, 116, 119, 116, 119, 116, 119, 115, 121, 115, 121,
115, 121, 113, 122, 114, 121, 114, 122, 111, -104, -124, -111, -122, -112, -121,
-112, -121, -113, -120, -113, -119, -114, -119, -115, -118, -115, -117, -116,
-117, -117, -117, -117, -116, -117, -116, -117, -116, -116, -116, -118, -116,
-117, -116, -116, -116, -117, -116, -116, -116, -118, -117, -116, -117, -116,
-116, -117, -117, -116, -117, -115, -117, -116, -116, -117, -116, -117, -116,
-116, -116, -116, -116, -117, -116, -117, -117, -117, -117, -116, -117, -116,
-115, -116, -116, -116, -116, -115, -115, -116, -116, -116, -116, -116, -116,
-116, -116, -115, -116, -115, -116, -116, -116, -115, -117, -115, -116, -115,
-117, -115, -116, -114, -116, -115, -116, -116, -115, -116, -115, -117, -114,
-116, -114, -117, -114, -118, -114, -118, -112, -118, -112, -119, -111, -121,
-110, -120, -109, -122, -101, 116, 123, 116, 123, 115, 122, 116, 122, 116, 123,
117, 122, 117, 120, 117, 121, 118, 121, 118, 120, 119, 119, 118, 120, 120, 119,
119, 119, 118, 118, 119, 118, 119, 119, 120, 119, 120, 118, 119, 119, 119, 118,
119, 119, 119, 120, 119, 119, 119, 119, 118, 118, 119, 119, 119, 119, 119, 119,
118, 118, 119, 119, 118, 119, 118, 119, 119, 119, 119, 118, 118, 119, 119, 118,
119, 119, 118, 118, 119, 119, 118, 119, 119, 118, 119, 118, 119, 118, 118, 118,
118, 118, 118, 118, 118, 117, 118, 118, 117, 119, 118, 119, 118, 119, 117, 118,
117, 118, 117, 119, 116, 119, 117, 120, 117, 118, 118, 117, 118, 116, 120, 113,
123, 107, 127, -20, -128, -104, -125, -111, -122, -113, -120, -114, -119, -115,
-117, -116, -117, -116, -117, -117, -116, -117, -117, -117, -116, -117, -116,
-117, -116, -117, -116, -118, -116, -116, -117, -117, -116, -117, -116, -116,
-116, -117, -116, -117, -117, -116, -116, -117, -116, -116, -117, -117, -116,
-117, -117, -116, -116, -117, -116, -116, -116, -117, -116, -116, -116, -116,
-116, -116, -116, -115, -116, -117, -116, -116, -116, -117, -116, -116, -117,
-115, -116, -116, -115, -116, -116, -116, -116, -116, -116, -115, -116, -116,
-116, -116, -116, -115, -116, -116, -116, -117, -116, -115, -116, -116, -115,
-117, -116, -115, -115, -116, -114, -116, -116, -116, -115, -115, -116, -115,
-115, -115, -116, -114, -116, -114, -117, -113, -118, -114, -118, -112, -119,
-111, -122, -98, };