#define DATA_LENGTH 512
#define DATA AKWF_0589

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 2, 2, 3, 4, 4, 5, 4, 6, 6, 7,
7, 8, 8, 9, 9, 11, 10, 10, 11, 12, 13, 14, 14, 14, 16, 15, 16, 17, 17, 18, 18,
18, 19, 19, 20, 20, 21, 22, 23, 22, 24, 24, 25, 26, 25, 26, 26, 27, 29, 28, 30,
30, 30, 31, 32, 32, 32, 33, 33, 34, 35, 35, 36, 37, 37, 37, 38, 39, 39, 39, 40,
41, 41, 41, 42, 43, 44, 44, 44, 45, 45, 46, 47, 47, 48, 49, 49, 49, 50, 50, 51,
51, 52, 53, 53, 54, 54, 54, 55, 57, 57, 57, 57, 58, 58, 60, 60, 60, 61, 61, 61,
62, 63, 64, 64, 64, 64, 66, 66, 66, 67, 68, 68, 69, 70, 70, 71, 70, 71, 72, 73,
73, 74, 74, 74, 74, 75, 76, 77, 78, 77, 79, 79, 79, 81, 81, 81, 82, 82, 83, 83,
84, 84, 84, 85, 86, 86, 86, 87, 88, 88, 89, 90, 91, 90, 91, 91, 93, 93, 93, 93,
94, 95, 95, 95, 96, 96, 98, 97, 99, 99, 99, 101, 100, 101, 101, 102, 103, 104,
104, 104, 105, 106, 106, 106, 107, 107, 107, 108, 109, 110, 110, 110, 108, 106,
104, 101, 100, 98, 96, 94, 93, 90, 88, 86, 84, 83, 80, 78, 77, 75, 72, 71, 69,
66, 64, 63, 61, 59, 58, 55, 53, 50, 50, 47, 45, 43, 41, 39, 37, 35, 34, 32, 30,
27, 25, 24, 22, 20, 18, 16, 13, 12, 10, 8, 6, 4, 3, 0, -2, -2, -5, -7, -9, -10,
-12, -15, -17, -19, -21, -23, -24, -26, -28, -30, -32, -34, -36, -39, -39, -42,
-44, -45, -48, -50, -52, -54, -56, -58, -59, -60, -63, -64, -66, -68, -71, -72,
-75, -76, -79, -80, -82, -84, -87, -88, -91, -92, -94, -96, -98, -99, -101,
-103, -105, -107, -109, -111, -112, -115, -116, -118, -118, -118, -117, -117,
-116, -115, -114, -114, -112, -112, -112, -111, -110, -110, -109, -109, -108,
-107, -106, -106, -104, -103, -104, -104, -102, -102, -101, -100, -100, -99,
-98, -97, -97, -96, -96, -94, -94, -93, -93, -92, -91, -91, -90, -90, -88, -88,
-87, -87, -86, -85, -84, -85, -83, -83, -81, -81, -80, -80, -79, -78, -78, -77,
-76, -76, -75, -74, -73, -72, -72, -72, -70, -70, -70, -69, -69, -68, -67, -66,
-65, -65, -64, -64, -63, -62, -62, -62, -60, -60, -60, -58, -57, -58, -57, -56,
-55, -54, -54, -52, -53, -51, -51, -50, -50, -49, -49, -48, -46, -46, -45, -46,
-44, -44, -43, -42, -41, -41, -41, -40, -39, -39, -38, -37, -37, -36, -36, -35,
-35, -34, -33, -33, -32, -32, -31, -30, -30, -30, -29, -28, -28, -27, -27, -26,
-26, -25, -24, -24, -23, -23, -22, -22, -21, -20, -19, -19, -19, -19, -17, -17,
-17, -16, -15, -15, -14, -14, -13, -12, -12, -11, -11, -11, -11, -9, -8, -8, -7,
-7, -7, -6, -5, -4, -5, -3, -3, -2, -1, -2, -1, 0, };