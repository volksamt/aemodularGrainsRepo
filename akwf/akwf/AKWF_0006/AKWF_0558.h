#define DATA_LENGTH 512
#define DATA AKWF_0558

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -1, 0, 1, 0, 1, 1, 1, 1, 2, 1, 0,
2, 1, 2, 1, 1, 3, 2, 2, 3, 1, 3, 3, 3, 3, 3, 4, 3, 3, 4, 4, 4, 4, 4, 4, 5, 4, 4,
5, 4, 5, 5, 6, 5, 6, 4, 6, 6, 6, 6, 6, 6, 5, 6, 7, 7, 8, 7, 6, 7, 7, 8, 8, 8, 8,
8, 8, 8, 9, 9, 9, 9, 9, 9, 9, 9, 9, 10, 9, 9, 10, 10, 10, 10, 10, 10, 11, 12,
11, 11, 11, 12, 12, 12, 12, 13, 12, 13, 13, 13, 13, 13, 14, 14, 14, 13, 14, 13,
15, 14, 15, 14, 15, 15, 15, 15, 16, 16, 16, 17, 15, 16, 16, 17, 17, 16, 16, 17,
17, 17, 18, 18, 18, 18, 19, 19, 18, 19, 19, 19, 18, 19, 19, 20, 20, 20, 20, 20,
20, 21, 20, 21, 20, 22, 21, 22, 22, 22, 22, 22, 23, 22, 22, 22, 23, 23, 23, 24,
24, 24, 24, 24, 24, 24, 24, 25, 25, 25, 25, 26, 26, 26, 26, 26, 26, 27, 26, 27,
27, 27, 27, 27, 27, 28, 28, 28, 28, 28, 31, 28, 31, 26, 33, 24, 41, -19, -107,
-114, -123, -111, -107, -98, -92, -83, -77, -70, -64, -59, -53, -48, -44, -41,
-36, -33, -29, -27, -23, -22, -19, -16, -15, -13, -11, -10, -8, -7, -6, -5, -4,
-4, -2, -2, -1, -1, 0, 0, 1, 1, 1, 1, 1, 1, 1, 2, 2, 2, 1, 2, 2, 2, 1, 2, 1, 1,
1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, -1, 0, -1, -1, -1, -2, -2, -2, -2,
-3, -3, -3, -3, -3, -3, -3, -4, -4, -3, -4, -3, -5, -4, -4, -5, -4, -4, -5, -5,
-5, -6, -6, -5, -6, -6, -6, -5, -6, -5, -5, -6, -7, -6, -7, -7, -7, -7, -6, -7,
-7, -7, -7, -7, -8, -7, -8, -7, -8, -8, -7, -7, -8, -8, -8, -7, -8, -9, -8, -8,
-8, -8, -8, -8, -9, -9, -8, -8, -9, -9, -9, -9, -8, -8, -9, -9, -9, -9, -9, -9,
-9, -9, -8, -9, -8, -9, -9, -9, -8, -9, -8, -9, -8, -8, -9, -9, -8, -9, -9, -8,
-8, -9, -9, -8, -9, -9, -9, -9, -8, -9, -8, -9, -8, -8, -9, -8, -8, -9, -7, -7,
-7, -7, -8, -8, -8, -8, -8, -7, -8, -8, -7, -7, -8, -8, -6, -7, -7, -7, -7, -7,
-7, -7, -7, -6, -7, -6, -7, -6, -6, -6, -7, -6, -6, -5, -6, -5, -6, -6, -6, -6,
-5, -5, -5, -6, -5, -4, -5, -5, -5, -5, -5, -5, -5, -5, -4, -5, -5, -5, -3, -4,
-4, -4, -4, -4, -4, -4, -4, -3, -4, -3, -3, -3, -3, -3, -2, -3, -3, -2, -2, -2,
-3, -2, -2, -1, -1, -2, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, 0, 0, 0, 0,
1, 0, };