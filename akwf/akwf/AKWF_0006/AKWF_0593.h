#define DATA_LENGTH 512
#define DATA AKWF_0593

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 0, 0, 1, 1, 2, 0, 0, 1, 0, 1,
0, 0, 1, 0, 1, 1, 0, 0, 0, 1, 1, 2, 1, 0, 1, 0, 1, 0, 0, 1, 1, 1, 1, 1, 0, 1, 0,
0, 1, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 0, 1, 0,
-1, 1, 0, 1, 1, 1, 4, 7, 1, 0, 1, 1, 1, 1, -1, -3, 2, 1, 0, 0, 1, 1, 1, 2, 1, 1,
0, 2, 1, 2, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 2, 0, 2, -1, 2, 0, 2, -1, 2, -1, 2,
-1, 2, -2, 3, -1, 3, -1, 0, 3, -70, -10, 8, -4, 5, -4, 4, -2, 3, -2, 3, -1, 3,
-2, 3, -1, 2, 0, 0, 0, 1, 0, 0, 1, 0, 1, 0, 1, 1, 1, 1, 1, 0, 1, 1, 1, 0, 0, 0,
0, 0, 1, 0, 1, 1, 1, 0, 1, 0, 0, 1, 1, 1, 0, -2, -2, 1, 1, 1, 1, 1, 1, 1, 0, 0,
1, 1, 0, 1, 0, 4, 7, 12, 7, -1, 1, -1, 2, 0, -1, -4, -6, -11, -9, 2, 1, 0, 0, 1,
1, 1, 1, 0, 1, 0, 1, 0, 1, 0, 2, 1, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 0, 2, -1, 2,
-2, 3, -2, 4, -2, 4, -2, 4, -3, 5, -2, 3, -1, -97, -8, 8, -5, 5, -4, 5, -3, 5,
-3, 3, -3, 4, -1, 3, -1, 2, 0, 1, 0, 0, 1, 0, 0, 1, 1, 1, 1, 0, 2, 0, 1, 0, 1,
0, 1, 0, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 1, 1, 0, 1, 1, 1, 0, 1, 0, 2, 1, 0, 1, 1,
1, 1, 1, 0, 1, 1, 0, 0, 1, 1, 0, 0, 2, 5, 6, 1, 0, 0, 0, 1, 1, -2, -2, 1, 0, 0,
0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 2, 0, 2, 1, 1, 1, 1, 2, 0, 2, 0, 1, 0, 2,
-1, 2, -1, 3, -2, 3, -2, 3, -3, 4, -3, 4, -3, 4, -4, -71, -1, 3, -2, 4, -3, 3,
-2, 3, -1, 3, -1, 3, -1, 2, 0, 2, 0, 2, 0, 1, 0, 0, 1, 1, 1, 0, 1, 0, 0, 0, 1,
1, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 0, 1, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 0,
1, 1, 0, 1, -1, -3, 1, 0, 0, 1, 1, 0, 5, 8, 13, 4, -1, 1, 0, 1, 0, -1, -4, -7,
-5, 1, 0, 2, 1, 1, 0, 1, 2, 0, 1, 0, 2, 0, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0, 1, 1,
1, 1, 0, 1, -1, 3, -2, 3, -2, 4, -2, 4, -3, 4, -3, 5, -4, 7, -10, -83, };