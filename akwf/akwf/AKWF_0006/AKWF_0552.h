#define DATA_LENGTH 512
#define DATA AKWF_0552

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 5, 8, 8, 10, 12, 14, 15, 16,
18, 20, 22, 23, 25, 26, 28, 29, 31, 33, 34, 36, 38, 40, 41, 43, 44, 46, 48, 48,
51, 51, 53, 54, 56, 57, 58, 59, 60, 62, 63, 64, 65, 66, 68, 68, 69, 71, 71, 72,
74, 74, 76, 76, 78, 80, 80, 81, 82, 83, 84, 85, 86, 86, 88, 88, 90, 90, 90, 91,
92, 92, 94, 95, 95, 95, 97, 97, 98, 98, 98, 99, 100, 101, 101, 102, 102, 102,
102, 103, 104, 104, 105, 106, 106, 106, 106, 106, 107, 109, 109, 109, 109, 109,
110, 111, 110, 111, 111, 111, 111, 112, 112, 113, 112, 113, 114, 114, 114, 114,
115, 114, 115, 115, 116, 115, 116, 115, 117, 117, 117, 117, 117, 117, 117, 117,
117, 118, 118, 118, 118, 118, 118, 119, 118, 118, 118, 118, 118, 118, 118, 119,
119, 119, 119, 118, 118, 119, 118, 119, 120, 120, 119, 119, 119, 119, 119, 119,
118, 118, 118, 119, 119, 118, 119, 118, 119, 118, 119, 118, 118, 118, 119, 118,
118, 118, 118, 118, 117, 118, 117, 118, 117, 118, 117, 117, 117, 117, 117, 118,
117, 116, 116, 117, 116, 116, 116, 116, 116, 116, 116, 116, 115, 115, 114, 115,
115, 115, 114, 114, 114, 114, 113, 113, 113, 114, 113, 112, 113, 112, 113, 112,
113, 112, 112, 111, 112, 111, 111, 110, 110, 110, 110, 109, 110, 109, 110, 108,
109, 108, 109, 106, 108, 107, 107, 107, 107, 107, 106, 110, 20, -35, -65, -83,
-79, -108, -112, -97, -79, -77, -73, -78, -91, -101, -99, -97, -93, -93, -96,
-104, -111, -115, -115, -113, -112, -112, -113, -116, -116, -113, -112, -107,
-104, -102, -101, -99, -97, -94, -92, -88, -87, -85, -85, -86, -85, -87, -86,
-88, -90, -91, -93, -96, -97, -99, -101, -102, -104, -105, -106, -107, -108,
-108, -107, -107, -106, -106, -104, -103, -102, -100, -99, -98, -97, -96, -94,
-94, -93, -94, -95, -94, -96, -97, -97, -99, -100, -101, -103, -104, -106, -108,
-108, -110, -111, -112, -112, -112, -112, -111, -112, -112, -111, -111, -110,
-109, -109, -108, -108, -107, -106, -106, -106, -106, -106, -107, -107, -108,
-108, -109, -109, -111, -113, -113, -115, -114, -115, -116, -116, -117, -117,
-118, -117, -118, -118, -118, -118, -116, -116, -115, -114, -114, -113, -113,
-112, -113, -112, -112, -112, -112, -110, -112, -111, -111, -111, -111, -112,
-112, -112, -112, -113, -112, -113, -113, -112, -112, -111, -112, -110, -109,
-109, -109, -106, -106, -106, -105, -104, -103, -102, -100, -100, -99, -98, -97,
-97, -95, -96, -94, -94, -93, -93, -92, -91, -91, -90, -88, -89, -87, -86, -85,
-84, -83, -82, -80, -80, -77, -76, -74, -73, -72, -70, -68, -67, -65, -64, -62,
-61, -59, -58, -56, -55, -54, -52, -51, -50, -48, -46, -44, -43, -43, -41, -39,
-38, -36, -35, -33, -31, -29, -27, -25, -24, -22, -20, -18, -15, -14, -12, -10,
-8, -7, -5, -3, -1, };