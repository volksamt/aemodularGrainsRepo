#define DATA_LENGTH 512
#define DATA AKWF_0586

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 12, 16, 20, 23, 27, 31, 34,
38, 41, 45, 49, 53, 57, 60, 65, 68, 72, 75, 78, 81, 84, 88, 90, 93, 94, 96, 97,
100, 102, 102, 104, 106, 107, 108, 108, 110, 111, 110, 112, 112, 113, 113, 114,
114, 114, 115, 115, 114, 115, 116, 115, 114, 113, 113, 112, 110, 109, 107, 106,
105, 103, 100, 99, 97, 95, 93, 91, 89, 86, 84, 82, 79, 77, 74, 72, 69, 67, 65,
61, 58, 55, 51, 48, 45, 41, 37, 32, 29, 25, 21, 18, 14, 10, 6, 3, -1, -3, -7,
-11, -13, -16, -19, -22, -24, -28, -30, -32, -35, -37, -40, -42, -44, -46, -47,
-50, -51, -52, -55, -56, -58, -58, -60, -60, -63, -64, -65, -65, -66, -67, -67,
-69, -68, -69, -70, -71, -72, -72, -73, -75, -75, -75, -76, -78, -78, -78, -78,
-78, -80, -78, -79, -78, -78, -78, -77, -76, -75, -74, -72, -72, -70, -69, -68,
-67, -66, -64, -64, -63, -63, -62, -61, -60, -60, -58, -58, -57, -56, -57, -55,
-55, -54, -54, -53, -51, -51, -50, -48, -48, -46, -45, -44, -44, -42, -42, -40,
-39, -38, -39, -37, -36, -35, -35, -34, -33, -33, -32, -31, -30, -29, -27, -28,
-27, -25, -25, -23, -23, -17, -8, 1, 12, 20, 27, 33, 38, 40, 39, 36, 30, 22, 10,
-2, -18, -32, -49, -65, -81, -94, -105, -113, -118, -119, -116, -108, -98, -83,
-66, -45, -24, -18, -15, -12, -9, -6, -3, 1, 5, 10, 12, 16, 20, 24, 27, 31, 34,
39, 42, 46, 49, 53, 57, 61, 64, 69, 72, 74, 79, 82, 85, 87, 90, 93, 94, 97, 99,
100, 102, 103, 105, 105, 107, 108, 109, 109, 111, 111, 111, 112, 113, 114, 114,
114, 115, 115, 114, 115, 115, 115, 114, 114, 113, 112, 111, 110, 108, 107, 106,
104, 103, 100, 99, 97, 94, 92, 90, 88, 87, 84, 81, 79, 76, 74, 72, 69, 67, 64,
61, 58, 55, 52, 47, 44, 41, 37, 33, 28, 25, 21, 18, 13, 10, 7, 3, -1, -4, -8,
-11, -14, -16, -20, -22, -24, -28, -29, -33, -35, -38, -39, -41, -43, -45, -47,
-50, -51, -52, -55, -55, -57, -58, -60, -61, -62, -63, -65, -65, -65, -67, -68,
-69, -69, -69, -70, -71, -72, -72, -74, -74, -75, -76, -76, -78, -77, -78, -79,
-78, -79, -79, -79, -79, -78, -78, -76, -75, -75, -74, -73, -71, -70, -69, -68,
-66, -66, -65, -64, -63, -62, -61, -61, -60, -60, -58, -58, -58, -57, -56, -55,
-55, -54, -53, -52, -50, -51, -49, -49, -48, -47, -45, -44, -44, -42, -41, -40,
-39, -39, -38, -36, -36, -35, -35, -34, -34, -33, -32, -31, -31, -28, -28, -27,
-27, -25, -24, -23, -24, -17, -6, 2, 12, 21, 28, 34, 38, 39, 39, 35, 29, 20, 9,
-4, -20, -34, -51, -67, -82, -96, -106, -113, -119, -118, -116, -108, -96, -81,
-64, -42, -22, -18, -14, -11, -8, -4, -1, };