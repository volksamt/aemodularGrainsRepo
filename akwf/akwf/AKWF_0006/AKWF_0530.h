#define DATA_LENGTH 512
#define DATA AKWF_0530

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 118, 116, 113, 114, 109, 110, 105,
106, 102, 103, 98, 99, 95, 94, 91, 90, 88, 87, 83, 84, 81, 79, 77, 75, 73, 71,
70, 67, 66, 63, 62, 61, 59, 57, 55, 53, 51, 49, 48, 45, 44, 42, 40, 39, 36, 34,
33, 31, 28, 27, 25, 24, 21, 20, 18, 16, 13, 12, 10, 9, 7, 5, 3, 1, -1, -2, -5,
-7, -8, -10, -12, -14, -16, -18, -19, -22, -23, -25, -27, -29, -30, -32, -34,
-37, -38, -40, -42, -43, -45, -47, -49, -51, -52, -55, -56, -58, -60, -61, -63,
-66, -67, -69, -71, -74, -75, -77, -79, -80, -82, -85, -86, -88, -90, -91, -93,
-96, -97, -99, -100, -103, -105, -106, -108, -110, -112, -114, -115, -118, -119,
-118, -117, -115, -114, -114, -112, -111, -110, -109, -108, -106, -106, -105,
-103, -103, -101, -100, -99, -98, -97, -95, -95, -93, -92, -91, -91, -89, -88,
-87, -85, -85, -84, -83, -81, -81, -79, -78, -76, -76, -75, -74, -72, -72, -70,
-70, -68, -67, -65, -65, -64, -63, -61, -61, -59, -59, -57, -57, -56, -54, -53,
-52, -51, -50, -48, -47, -46, -45, -45, -43, -42, -40, -40, -39, -38, -37, -35,
-35, -33, -31, -31, -30, -29, -28, -26, -26, -24, -23, -22, -22, -20, -19, -19,
-17, -16, -14, -13, -12, -11, -11, -9, -8, -7, -6, -4, -4, -2, -2, 0, 0, 0, 0,
0, 0, 0, 1, 0, 0, 0, 1, 0, 1, 1, 1, 1, 1, 1, 0, 2, 1, 0, 1, 1, 1, 1, 0, 1, 2, 1,
1, 1, 1, 2, 1, 1, 1, 2, 2, 2, 1, 2, 2, 2, 2, 2, 1, 1, 2, 1, 3, 3, 3, 2, 2, 1, 2,
2, 3, 2, 2, 2, 2, 2, 2, 3, 1, 2, 3, 3, 3, 2, 3, 3, 2, 2, 3, 2, 2, 3, 3, 3, 2, 2,
3, 2, 2, 3, 2, 2, 3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 4, 2, 3, 3, 3, 3, 2, 3, 2, 3, 2,
2, 3, 3, 4, 3, 2, 3, 3, 3, 4, 3, 3, 3, 3, 3, 3, 3, 2, 3, 2, 3, 2, 3, 3, 3, 3, 3,
3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 2, 3, 3, 3, 2, 3, 3, 2, 3, 2, 2, 3, 3, 2, 2, 3, 3,
2, 3, 3, 2, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 2, 2, 2, 2, 2, 1, 2, 1, 2, 2, 2, 2,
2, 2, 2, 2, 2, 3, 2, 2, 1, 2, 1, 2, 2, 2, 1, 2, 1, 1, 2, 2, 1, 2, 1, 1, 1, 1, 0,
1, 1, 2, 1, 1, 0, 1, 1, 2, 1, 1, 1, 0, 1, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0,
0, 0, 1, 0, 0, 0, 1, 0, 1, 1, 0, 0, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, };