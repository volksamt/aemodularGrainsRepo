#define DATA_LENGTH 512
#define DATA AKWF_0583

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 13, 16, 19, 23, 25, 30,
31, 36, 38, 42, 44, 48, 50, 54, 56, 61, 61, 68, 68, 75, 110, 110, 107, 107, 103,
104, 101, 100, 97, 98, 95, 94, 91, 91, 88, 88, 85, 84, 82, 81, 79, 77, 77, 74,
74, 69, 70, 66, 69, 61, 71, 31, -9, 4, 0, 5, 3, 7, 8, 10, 11, 12, 13, 16, 18,
18, 21, 22, 23, 25, 26, 28, 30, 31, 34, 34, 35, 37, 39, 40, 41, 44, 45, 47, 48,
50, 51, 53, 54, 57, 58, 59, 60, 62, 64, 65, 66, 69, 70, 71, 72, 75, 77, 78, 79,
81, 83, 84, 86, 87, 89, 90, 91, 93, 96, 96, 98, 99, 101, 103, 105, 106, 108,
108, 108, 106, 104, 103, 101, 100, 97, 96, 96, 93, 91, 91, 89, 87, 85, 83, 82,
80, 78, 77, 75, 73, 73, 70, 70, 68, 67, 65, 63, 62, 59, 58, 57, 55, 53, 51, 50,
48, 47, 46, 43, 42, 41, 39, 38, 37, 34, 33, 31, 29, 27, 27, 25, 24, 23, 21, 19,
17, 15, 13, 13, 11, 9, 8, 6, 4, 3, 1, 0, -1, -3, -5, -6, -6, -6, -6, -6, -6, -6,
-6, -6, -6, -6, -5, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -7, -7, -6, -6,
-5, -6, -6, -6, -6, -7, -6, -7, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6,
-6, -6, -6, -6, -5, -6, -7, -5, -5, -6, -5, -6, -6, -6, -6, -7, -6, -5, -6, -6,
-5, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -5, -6, -5, -6, -6, -6, -8,
-9, -10, -12, -14, -16, -17, -18, -21, -22, -24, -25, -27, -28, -29, -31, -32,
-34, -37, -38, -39, -41, -42, -44, -46, -47, -48, -49, -52, -53, -54, -56, -58,
-60, -61, -62, -64, -67, -67, -69, -71, -72, -73, -75, -77, -78, -79, -81, -83,
-84, -87, -87, -89, -90, -92, -94, -96, -97, -99, -99, -102, -103, -104, -106,
-107, -109, -111, -113, -113, -116, -116, -118, -118, -116, -115, -113, -112,
-110, -109, -107, -105, -104, -102, -100, -99, -97, -97, -94, -93, -91, -89,
-88, -87, -85, -84, -81, -80, -78, -76, -75, -73, -72, -71, -68, -67, -65, -65,
-62, -60, -58, -57, -56, -55, -53, -51, -49, -47, -47, -45, -43, -42, -40, -38,
-37, -35, -35, -31, -33, -21, -3, -9, -7, -11, -11, -14, -14, -17, -19, -19,
-21, -22, -24, -25, -27, -29, -31, -32, -34, -35, -37, -37, -40, -41, -43, -44,
-45, -47, -49, -51, -52, -54, -54, -57, -58, -61, -60, -64, -64, -67, -66, -69,
-70, -73, -73, -76, -77, -78, -82, -10, 4, -1, 5, 2, 7, 6, 10, 10, 13, 13, 16,
16, 19, 19, 22, 22, 26, 26, 28, 29, 33, 32, 36, 35, 40, 36, 44, 38, 52, 26, -58,
-46, -47, -41, -39, -37, -32, -31, -26, -24, -19, -19, -13, -13, -8, -6, 0, };