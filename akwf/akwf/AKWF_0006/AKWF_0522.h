#define DATA_LENGTH 512
#define DATA AKWF_0522

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 6, 7, 10, 11, 13, 16, 17, 20,
21, 24, 25, 28, 30, 32, 34, 36, 38, 40, 41, 44, 47, 48, 51, 53, 54, 57, 58, 59,
62, 64, 65, 67, 69, 71, 73, 75, 76, 78, 79, 81, 83, 85, 86, 88, 89, 91, 92, 94,
96, 96, 98, 99, 101, 101, 102, 104, 105, 106, 107, 108, 109, 110, 110, 112, 112,
113, 113, 114, 114, 115, 116, 117, 116, 117, 117, 118, 118, 118, 119, 118, 119,
119, 119, 119, 119, 119, 119, 119, 118, 118, 117, 118, 117, 117, 116, 115, 115,
114, 113, 113, 112, 112, 111, 111, 110, 108, 107, 107, 105, 105, 104, 103, 102,
100, 99, 99, 98, 97, 95, 94, 93, 91, 91, 90, 88, 88, 86, 84, 83, 82, 81, 79, 78,
77, 76, 75, 74, 71, 71, 69, 68, 67, 65, 65, 64, 62, 62, 61, 59, 58, 56, 55, 55,
53, 52, 51, 51, 50, 48, 46, 46, 45, 44, 44, 43, 42, 41, 40, 39, 39, 38, 37, 37,
35, 34, 34, 33, 32, 33, 32, 31, 31, 29, 28, 28, 28, 28, 27, 26, 27, 26, 25, 25,
25, 24, 24, 24, 24, 23, 24, 23, 22, 22, 21, 21, 21, 21, 21, 20, 21, 20, 21, 21,
19, 19, 19, 19, 19, 19, 20, 19, 18, 19, 18, 18, 18, 18, 18, 17, 16, 17, 17, 16,
16, 16, 16, 15, 15, 15, 15, 15, 14, 14, 13, 13, 12, 12, 11, 12, 11, 11, 9, 9, 9,
8, 8, 7, 6, 6, 5, 5, 4, 4, 3, 2, 1, 0, 0, -1, -3, -3, -3, -5, -5, -6, -7, -8,
-8, -10, -11, -12, -13, -14, -14, -16, -18, -18, -19, -20, -20, -22, -22, -23,
-25, -27, -27, -28, -30, -30, -32, -33, -34, -36, -37, -37, -39, -40, -41, -42,
-43, -44, -45, -46, -47, -49, -50, -51, -53, -54, -54, -55, -56, -57, -58, -60,
-60, -61, -62, -63, -64, -65, -67, -67, -68, -69, -70, -71, -72, -72, -74, -75,
-75, -76, -76, -77, -79, -80, -80, -81, -82, -82, -83, -83, -84, -84, -84, -85,
-87, -86, -88, -88, -88, -89, -89, -90, -91, -91, -91, -92, -91, -93, -93, -93,
-94, -93, -94, -94, -95, -95, -96, -96, -95, -96, -96, -96, -97, -96, -96, -97,
-96, -97, -97, -97, -97, -97, -97, -97, -98, -97, -97, -97, -97, -98, -97, -97,
-96, -97, -97, -97, -96, -96, -96, -96, -96, -96, -96, -95, -96, -95, -95, -95,
-94, -94, -93, -94, -93, -93, -93, -93, -92, -91, -92, -90, -91, -90, -90, -89,
-89, -88, -88, -87, -86, -86, -86, -85, -84, -83, -84, -82, -82, -82, -80, -80,
-78, -77, -77, -76, -75, -74, -74, -73, -72, -70, -69, -69, -68, -67, -65, -64,
-63, -63, -61, -59, -59, -58, -56, -56, -53, -52, -51, -50, -47, -47, -46, -43,
-42, -41, -39, -37, -37, -34, -34, -31, -29, -28, -25, -24, -22, -21, -19, -17,
-15, -13, -12, -10, -8, -6, -4, -2, 0, };