#define DATA_LENGTH 512
#define DATA AKWF_0523

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, -21, -128, -106, -128, -13, -3, 13,
-47, -128, -114, -120, -4, 1, -4, 4, -5, 8, -19, -126, -114, -128, -31, 13, -10,
8, -6, 7, -5, 5, -4, 4, -3, 3, -2, 2, -1, 1, -1, 0, -1, 0, 0, -1, 1, 0, 0, -1,
1, -1, 1, -1, 1, -1, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0,
0, 1, -1, 0, 1, -1, -1, 0, 0, 0, 1, 0, 0, 0, 1, 0, -1, 0, 0, 0, 1, 0, 1, 0, 0,
0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0,
0, -1, 1, 0, -1, -1, 0, 0, -1, 0, 1, 0, 0, -1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0,
0, -1, -1, -1, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, -1, 0, -1,
-1, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0,
0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 1, -1, 0,
0, 1, -1, 2, -1, 1, -2, 1, 0, 0, -1, 0, -1, 0, 0, -2, 1, -2, 2, -2, 3, -4, 4,
-5, 6, -9, 15, -94, -122, -125, -88, 19, -13, 13, -119, -110, -128, -56, 11, -2,
-8, -124, -118, -119, -121, -115, -128, -89, 11, -5, 2, 0, 0, 0, -1, 2, -2, 1,
-2, 2, -1, 2, -1, 2, -2, 1, -2, 1, -1, 0, -1, 1, 0, 0, 0, 0, 0, -1, 0, -1, 0,
-1, 0, -1, 0, 0, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1,
0, 1, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, -1, 0, -1, -1, 0, 0, 0, 1, 0,
0, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 0, -1, 0, 0, 0, -1, 1, 0, 0, 0, 1, 0, 1, 0, 0,
-1, -1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0,
-1, 0, 0, -1, 0, 0, 1, 1, 0, -1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 1, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, };