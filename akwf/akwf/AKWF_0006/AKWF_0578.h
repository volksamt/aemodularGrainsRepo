#define DATA_LENGTH 512
#define DATA AKWF_0578

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 4, 2, 2, 3, 3, 3, 2, 3, 2, 3, 6,
7, 9, 10, 11, 14, 15, 16, 19, 20, 22, 23, 24, 26, 28, 29, 31, 32, 34, 36, 37,
40, 41, 42, 44, 45, 47, 48, 51, 52, 53, 55, 56, 59, 60, 61, 63, 65, 66, 67, 70,
70, 73, 73, 76, 77, 78, 80, 81, 84, 84, 86, 88, 89, 92, 93, 95, 96, 98, 100,
101, 101, 104, 105, 107, 109, 110, 112, 113, 116, 116, 118, 119, 116, 115, 114,
112, 109, 108, 106, 105, 104, 102, 101, 99, 98, 95, 94, 93, 90, 89, 87, 85, 84,
83, 81, 79, 78, 76, 74, 73, 72, 70, 68, 67, 65, 64, 62, 60, 59, 56, 54, 54, 52,
50, 49, 47, 46, 43, 43, 41, 39, 38, 36, 34, 32, 32, 29, 28, 26, 25, 23, 22, 20,
19, 16, 15, 13, 12, 10, 9, 7, 5, 3, 2, 0, -1, -1, -1, 0, -1, -1, -1, -1, 0, -1,
0, -1, 0, -1, -1, -1, -1, -1, 0, -1, -1, -1, -1, 0, -1, 0, -1, -1, -1, -2, -1,
0, -1, -1, -1, -1, -1, -1, 0, -1, -1, 0, 0, -1, 0, -1, 0, -1, 0, -1, 0, -1, -1,
-1, -1, -1, -1, -1, 0, -1, 0, 0, -1, -1, 0, -1, -1, -1, -1, -1, -1, -1, 0, 0,
-1, -1, -1, -1, -1, -1, 0, -1, 0, -1, 0, 0, -1, -1, -1, -1, -1, -1, -1, -1, 0,
-1, 0, 0, -1, 0, -1, 0, -1, 0, -1, -1, 0, -1, -1, -1, 0, -1, -1, -1, -2, -1, 0,
0, -2, 0, 0, 0, -1, -1, -1, 0, -1, -1, -1, -1, -1, -1, -1, 0, -1, -1, -2, -1, 0,
-1, -1, -1, -1, -1, -1, -1, -1, 0, -1, 0, -1, -1, -1, -1, -1, -1, -1, -1, -1,
-1, -1, -1, -2, -1, -1, -1, -1, -1, -1, -1, -1, -1, 0, -2, -1, -1, -1, -1, -1,
-1, -1, -1, -1, -1, -2, -2, 0, 0, -1, -1, -1, -1, -1, -1, -1, -1, -1, 0, -1, -1,
0, -1, -1, -2, -1, -1, 0, 0, -1, -2, -1, -2, 0, -1, -1, -1, 0, -1, -1, -1, -2,
-4, -5, -7, -8, -10, -12, -14, -15, -16, -18, -21, -22, -24, -25, -26, -28, -30,
-31, -33, -35, -36, -37, -39, -41, -42, -43, -45, -47, -49, -50, -52, -53, -55,
-57, -59, -60, -61, -64, -65, -66, -68, -69, -71, -73, -74, -77, -78, -79, -80,
-82, -84, -85, -88, -88, -90, -92, -94, -95, -96, -98, -99, -101, -103, -105,
-106, -108, -109, -110, -112, -114, -116, -117, -119, -118, -116, -114, -112,
-111, -109, -107, -106, -104, -103, -101, -100, -98, -97, -95, -93, -92, -90,
-89, -88, -85, -84, -82, -81, -78, -77, -75, -73, -73, -70, -68, -68, -65, -64,
-63, -60, -59, -58, -55, -54, -52, -51, -49, -48, -46, -45, -43, -42, -40, -38,
-37, -34, -34, -31, -31, -27, -27, -24, -25, -19, };