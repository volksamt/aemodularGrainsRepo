#define DATA_LENGTH 512
#define DATA AKWF_0546

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 14, 21, 28, 35, 42, 49, 55, 60, 64,
69, 74, 77, 80, 83, 85, 86, 87, 87, 88, 88, 89, 89, 89, 91, 91, 91, 92, 91, 93,
92, 92, 91, 92, 91, 90, 89, 88, 88, 87, 85, 84, 82, 82, 80, 78, 76, 74, 72, 69,
66, 64, 63, 60, 58, 56, 55, 54, 52, 52, 50, 50, 49, 47, 46, 45, 44, 41, 41, 39,
38, 36, 34, 32, 31, 29, 27, 24, 22, 19, 16, 15, 11, 9, 6, 3, 1, -1, -3, -4, -6,
-7, -8, -10, -11, -12, -13, -15, -16, -18, -20, -22, -23, -25, -28, -30, -31,
-33, -35, -38, -40, -43, -46, -49, -50, -52, -54, -54, -53, -52, -50, -46, -43,
-38, -34, -29, -24, -18, -12, -7, -2, 3, 8, 13, 16, 20, 24, 27, 30, 33, 34, 36,
37, 39, 39, 39, 38, 38, 38, 37, 37, 36, 37, 36, 35, 36, 36, 35, 35, 34, 34, 33,
32, 32, 30, 29, 28, 27, 25, 24, 23, 21, 19, 17, 15, 13, 10, 8, 6, 4, 3, 2, 2, 3,
4, 6, 8, 10, 13, 16, 20, 23, 27, 29, 33, 36, 39, 41, 44, 45, 47, 48, 50, 52, 52,
53, 52, 52, 52, 51, 49, 49, 48, 47, 45, 44, 45, 43, 43, 42, 41, 42, 41, 39, 39,
38, 38, 36, 35, 33, 32, 31, 29, 27, 25, 23, 22, 19, 17, 16, 13, 10, 8, 6, 5, 4,
4, 4, 5, 7, 10, 11, 16, 18, 21, 24, 28, 31, 34, 37, 40, 43, 45, 47, 49, 50, 52,
52, 53, 53, 53, 52, 53, 51, 50, 49, 48, 47, 45, 45, 45, 43, 43, 43, 42, 41, 41,
41, 40, 39, 37, 36, 35, 34, 32, 31, 29, 28, 26, 24, 22, 20, 19, 16, 13, 11, 8,
5, 2, 0, -2, -3, -6, -7, -9, -9, -10, -12, -12, -15, -16, -17, -19, -19, -22,
-24, -25, -27, -29, -30, -32, -34, -36, -39, -41, -44, -47, -50, -53, -56, -58,
-61, -63, -65, -67, -68, -70, -71, -72, -73, -75, -77, -78, -80, -82, -83, -85,
-86, -89, -91, -91, -94, -96, -97, -101, -103, -105, -108, -110, -113, -115,
-117, -119, -119, -117, -117, -115, -111, -108, -103, -98, -93, -87, -82, -77,
-72, -66, -62, -57, -53, -48, -44, -40, -37, -35, -32, -30, -28, -27, -27, -26,
-26, -28, -27, -27, -28, -29, -29, -29, -30, -30, -30, -30, -30, -30, -31, -31,
-31, -33, -34, -35, -37, -38, -38, -40, -42, -43, -45, -46, -49, -50, -53, -55,
-58, -60, -62, -63, -64, -63, -63, -62, -60, -57, -56, -52, -48, -45, -42, -38,
-36, -32, -29, -26, -24, -22, -20, -17, -16, -15, -13, -13, -12, -13, -13, -13,
-15, -15, -17, -17, -19, -20, -21, -22, -22, -23, -23, -24, -24, -25, -26, -26,
-27, -29, -29, -31, -32, -33, -35, -36, -38, -39, -41, -43, -46, -47, -51, -53,
-55, -57, -57, -58, -57, -55, -52, -49, -43, -37, -31, -24, -16, -8, -1, };