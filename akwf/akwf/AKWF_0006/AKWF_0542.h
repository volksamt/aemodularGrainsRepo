#define DATA_LENGTH 512
#define DATA AKWF_0542

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 11, 19, 24, 28, 30, 34, 40, 47, 54,
59, 64, 68, 69, 70, 71, 70, 70, 68, 67, 63, 60, 60, 63, 68, 74, 80, 88, 92, 95,
98, 101, 104, 103, 102, 100, 95, 89, 86, 84, 84, 84, 85, 83, 80, 76, 71, 70, 65,
62, 58, 53, 50, 46, 46, 49, 54, 61, 69, 78, 85, 90, 97, 102, 107, 110, 112, 112,
110, 107, 106, 106, 109, 109, 111, 110, 108, 103, 99, 95, 90, 84, 77, 70, 63,
56, 51, 50, 51, 54, 56, 59, 60, 61, 61, 61, 60, 58, 55, 50, 44, 37, 32, 29, 27,
25, 25, 23, 20, 16, 12, 9, 6, 4, 0, -3, -7, -9, -8, -3, 4, 13, 23, 32, 42, 50,
57, 64, 73, 78, 82, 84, 85, 84, 86, 88, 92, 96, 98, 101, 101, 99, 97, 94, 91,
87, 83, 77, 71, 66, 62, 62, 64, 69, 72, 75, 77, 77, 77, 78, 77, 75, 71, 65, 58,
50, 44, 40, 37, 35, 32, 28, 24, 16, 11, 6, 0, -6, -12, -19, -25, -29, -31, -29,
-26, -20, -14, -6, 0, 3, 8, 12, 15, 18, 18, 16, 13, 11, 8, 8, 8, 10, 8, 8, 5, 1,
-4, -9, -14, -19, -27, -35, -42, -49, -53, -54, -52, -50, -47, -43, -42, -42,
-41, -41, -40, -42, -45, -50, -54, -61, -65, -67, -67, -68, -68, -68, -69, -73,
-75, -77, -79, -81, -83, -86, -87, -87, -86, -79, -70, -59, -48, -36, -25, -16,
-6, 3, 11, 18, 24, 29, 30, 32, 34, 40, 47, 50, 56, 59, 61, 61, 60, 60, 58, 56,
52, 49, 45, 41, 39, 41, 46, 51, 56, 61, 64, 66, 68, 71, 72, 70, 67, 62, 57, 51,
46, 43, 42, 41, 40, 36, 33, 28, 23, 18, 14, 9, 3, -2, -7, -12, -13, -10, -6, 0,
9, 15, 21, 27, 31, 35, 39, 42, 42, 41, 37, 33, 31, 32, 32, 32, 33, 31, 28, 23,
18, 12, 6, -1, -7, -16, -24, -32, -37, -37, -37, -36, -33, -31, -30, -30, -31,
-32, -34, -36, -40, -46, -54, -60, -65, -69, -70, -72, -74, -76, -81, -85, -88,
-92, -94, -98, -103, -107, -110, -112, -111, -107, -99, -90, -80, -70, -62, -55,
-47, -39, -32, -26, -23, -21, -20, -21, -20, -17, -13, -9, -6, -5, -4, -6, -8,
-11, -14, -17, -22, -28, -34, -39, -41, -40, -38, -35, -31, -27, -25, -24, -23,
-23, -23, -26, -29, -35, -41, -48, -53, -58, -60, -62, -63, -67, -71, -77, -82,
-87, -92, -98, -103, -108, -115, -118, -119, -116, -111, -105, -98, -90, -84,
-79, -74, -68, -64, -61, -61, -60, -64, -65, -66, -66, -64, -63, -63, -62, -63,
-68, -72, -76, -79, -85, -91, -97, -104, -109, -112, -112, -109, -105, -101,
-97, -93, -93, -90, -89, -88, -89, -91, -93, -98, -104, -106, -107, -105, -104,
-103, -102, -104, -106, -106, -107, -107, -108, -110, -111, -111, -109, -106,
-97, -87, -75, -63, -49, -37, -26, -16, -6, };