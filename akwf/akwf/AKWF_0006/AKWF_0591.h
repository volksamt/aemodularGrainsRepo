#define DATA_LENGTH 512
#define DATA AKWF_0591

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 3, 4, 5, 7, 8, 9, 10, 12, 12,
14, 15, 17, 18, 19, 20, 21, 22, 24, 24, 27, 27, 29, 30, 32, 32, 34, 34, 37, 37,
38, 40, 40, 43, 44, 45, 46, 46, 48, 49, 50, 52, 53, 55, 56, 57, 58, 59, 61, 62,
63, 64, 66, 66, 68, 69, 70, 71, 73, 73, 75, 77, 78, 80, 79, 82, 82, 84, 84, 88,
83, 101, 121, 116, 118, 117, 118, 118, 118, 118, 118, 118, 118, 117, 117, 117,
117, 117, 117, 117, 117, 116, 116, 116, 117, 116, 117, 116, 117, 117, 116, 115,
117, 115, 116, 116, 116, 117, 116, 117, 117, 116, 116, 118, 117, 118, 118, 118,
118, 118, 118, 118, 118, 119, 118, 118, 118, 119, 119, 118, 120, 116, 116, 116,
116, 115, 116, 115, 115, 116, 114, 114, 115, 115, 114, 114, 114, 113, 113, 113,
113, 113, 113, 112, 112, 111, 112, 111, 112, 112, 111, 111, 110, 111, 110, 110,
110, 110, 109, 110, 109, 109, 109, 109, 108, 108, 108, 107, 108, 107, 107, 107,
107, 107, 107, 106, 106, 106, 106, 105, 105, 106, 105, 105, 105, 105, 105, 104,
105, 104, 103, 103, 103, 103, 103, 103, 103, 102, 103, 102, 102, 102, 101, 101,
101, 101, 100, 101, 100, 100, 100, 100, 100, 100, 99, 99, 99, 99, 98, 98, 98,
97, 98, 98, 97, 97, 97, 96, 97, 96, 97, 95, 96, 95, 96, 96, 96, 96, 95, 94, 94,
95, 94, 95, 93, 96, 85, 53, 34, 14, -6, -26, -48, -63, -106, -122, -117, -121,
-118, -119, -118, -119, -119, -118, -117, -118, -118, -118, -119, -118, -118,
-118, -118, -118, -118, -118, -117, -118, -118, -118, -118, -117, -117, -118,
-117, -117, -117, -117, -117, -117, -116, -117, -117, -116, -116, -116, -116,
-116, -116, -116, -116, -117, -116, -116, -115, -116, -116, -115, -115, -115,
-116, -115, -116, -115, -115, -115, -114, -114, -115, -114, -115, -114, -114,
-115, -114, -115, -113, -114, -114, -114, -113, -113, -114, -114, -114, -113,
-113, -113, -113, -113, -114, -112, -112, -113, -113, -112, -113, -112, -112,
-113, -113, -113, -112, -112, -112, -112, -111, -111, -113, -111, -111, -111,
-111, -112, -111, -111, -112, -111, -111, -111, -111, -111, -111, -111, -111,
-111, -110, -110, -110, -110, -109, -110, -110, -110, -109, -109, -110, -110,
-110, -110, -110, -111, -110, -110, -111, -111, -111, -111, -112, -111, -111,
-112, -111, -112, -112, -111, -112, -112, -111, -111, -112, -112, -111, -111,
-111, -110, -110, -110, -110, -110, -109, -109, -109, -109, -109, -108, -108,
-107, -108, -108, -107, -107, -107, -106, -106, -107, -106, -107, -105, -108,
-83, -72, -75, -70, -72, -69, -68, -67, -66, -64, -64, -62, -61, -59, -58, -57,
-55, -55, -53, -51, -50, -49, -48, -48, -46, -44, -43, -42, -41, -39, -38, -37,
-35, -34, -33, -31, -30, -29, -28, -27, -26, -24, -22, -22, -20, -19, -18, -17,
-15, -15, -13, -12, -11, -9, -9, -7, -5, -4, -3, -2, -1, };