#define DATA_LENGTH 512
#define DATA AKWF_0565

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 17, 23, 28, 32, 36, 40, 44, 45,
49, 51, 53, 56, 58, 60, 62, 63, 66, 67, 69, 71, 72, 74, 76, 77, 78, 80, 81, 82,
83, 85, 86, 87, 88, 89, 89, 91, 92, 93, 94, 95, 96, 96, 97, 98, 98, 99, 100,
101, 102, 102, 103, 104, 104, 106, 106, 106, 107, 107, 108, 108, 109, 109, 109,
110, 110, 112, 112, 111, 112, 112, 112, 113, 113, 114, 114, 114, 114, 115, 116,
115, 115, 116, 116, 116, 116, 117, 117, 117, 116, 118, 117, 117, 117, 118, 118,
117, 117, 118, 117, 120, 117, 120, 118, 122, 109, 78, 76, 71, 69, 67, 64, 63,
60, 59, 57, 57, 55, 54, 52, 52, 51, 51, 49, 48, 48, 47, 46, 45, 45, 45, 43, 42,
43, 42, 41, 40, 40, 40, 39, 39, 39, 37, 37, 37, 36, 36, 36, 36, 35, 34, 34, 34,
33, 33, 33, 33, 32, 31, 32, 32, 30, 31, 30, 30, 30, 30, 29, 30, 30, 28, 29, 29,
28, 28, 28, 28, 28, 28, 28, 28, 27, 27, 27, 26, 27, 27, 26, 27, 26, 26, 25, 26,
26, 25, 25, 26, 25, 25, 25, 26, 25, 25, 26, 25, 26, 25, 25, 25, 26, 24, 26, 15,
7, 7, 4, 3, 2, 2, 1, 0, -2, -2, -2, -2, -3, -4, -4, -4, -4, -5, -4, -6, -6, -6,
-6, -7, -7, -7, -7, -7, -7, -8, -7, -8, -9, -9, -9, -9, -9, -9, -8, -10, -9, -9,
-9, -10, -9, -10, -10, -10, -11, -11, -11, -10, -10, -10, -11, -10, -11, -10,
-11, -9, -12, -23, -24, -25, -26, -27, -28, -28, -29, -28, -30, -30, -31, -31,
-32, -32, -32, -31, -33, -33, -34, -33, -34, -34, -34, -35, -35, -34, -34, -35,
-36, -36, -35, -36, -36, -37, -36, -36, -36, -37, -37, -38, -38, -38, -37, -37,
-38, -38, -38, -38, -38, -38, -39, -39, -38, -38, -38, -39, -39, -39, -39, -39,
-39, -39, -39, -40, -40, -40, -40, -40, -39, -40, -40, -40, -41, -41, -41, -41,
-41, -40, -41, -41, -40, -41, -41, -41, -41, -40, -42, -41, -42, -41, -41, -42,
-42, -42, -41, -42, -41, -42, -42, -42, -41, -43, -42, -42, -42, -42, -42, -42,
-42, -43, -43, -42, -42, -43, -43, -42, -42, -42, -42, -43, -43, -44, -42, -42,
-42, -43, -43, -43, -43, -43, -43, -43, -42, -42, -43, -44, -44, -43, -43, -43,
-43, -43, -43, -43, -43, -43, -44, -44, -43, -44, -44, -43, -44, -44, -43, -43,
-43, -43, -43, -44, -42, -44, -43, -45, -43, -44, -42, -37, -36, -35, -36, -34,
-34, -34, -35, -33, -35, -33, -35, -30, -51, -72, -71, -78, -77, -81, -82, -85,
-86, -86, -88, -90, -90, -92, -92, -92, -94, -95, -94, -95, -96, -96, -97, -98,
-98, -98, -99, -99, -100, -100, -101, -101, -102, -100, -102, -102, -102, -101,
-103, -101, -103, -102, -103, -101, -104, -102, -105, -104, -105, -105, -105,
-105, -103, -109, -35, 0, };