#define DATA_LENGTH 512
#define DATA AKWF_0518

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 19, 33, 49, 66, 82, 92, 93, 90,
83, 72, 58, 50, 45, 39, 36, 33, 32, 31, 29, 28, 26, 23, 20, 16, 14, 8, 7, -5,
-7, -14, -23, -25, -28, -23, -22, -17, -12, -12, -23, -35, -50, -66, -81, -93,
-104, -111, -117, -117, -113, -107, -98, -86, -73, -59, -46, -33, -18, -7, 5,
14, 23, 31, 38, 44, 49, 54, 57, 59, 61, 57, 49, 42, 31, 19, 6, 4, 5, 5, 7, 10,
14, 17, 20, 22, 22, 22, 21, 19, 16, 14, 11, 9, 8, 8, 8, 9, 11, 12, 14, 15, 16,
18, 21, 19, 19, 18, 17, 15, 13, 11, 9, 9, 8, 6, 8, 8, 9, 11, 13, 15, 18, 21, 22,
24, 26, 28, 28, 28, 28, 28, 28, 28, 26, 27, 26, 26, 26, 26, 25, 24, 25, 24, 24,
25, 24, 24, 24, 23, 25, 25, 25, 26, 28, 28, 29, 29, 32, 35, 36, 38, 39, 41, 41,
42, 42, 42, 39, 33, 36, 39, 36, 35, 35, 33, 32, 30, 27, 25, 24, 21, 20, 20, 18,
17, 16, 15, 14, 13, 12, 12, 11, 11, 10, 9, 9, 11, 11, 11, 11, 10, 10, 11, 11,
12, 12, 12, 14, 14, 15, 15, 15, 16, 17, 17, 18, 19, 19, 21, 22, 21, 22, 23, 23,
24, 24, 27, 28, 29, 32, 39, 45, 50, 57, 65, 74, 80, 87, 93, 95, 97, 97, 95, 93,
89, 85, 82, 77, 72, 69, 64, 60, 55, 51, 47, 43, 39, 34, 30, 26, 25, 22, 20, 17,
16, 15, 15, 15, 15, 18, 20, 21, 24, 25, 28, 30, 32, 33, 36, 36, 36, 37, 36, 37,
36, 35, 33, 33, 29, 29, 26, 28, 18, 17, -2, -25, -30, -46, -38, -49, -53, -42,
-21, -18, -19, -5, 2, -6, 4, 5, -16, -13, -21, -20, -32, -52, -51, -57, -56,
-60, -53, -40, -45, -47, -48, -51, -49, -62, -77, -70, -73, -69, -71, -55, -42,
-41, -39, -30, -9, -11, -5, -7, 0, -8, -21, -18, -20, -19, -22, -21, -24, -23,
-28, -26, -11, -11, -16, -15, -19, -18, -23, -19, -35, -47, -45, -49, -46, -51,
-37, -26, -29, -28, -28, -28, -27, -43, -46, -40, -42, -41, -41, -41, -41, -44,
-36, -19, -24, -22, -26, -25, -27, -29, -28, -47, -53, -52, -55, -53, -57, -55,
-38, -39, -39, -40, -40, -40, -41, -41, -42, -42, -42, -42, -42, -42, -42, -41,
-41, -42, -41, -40, -39, -38, -38, -42, -46, -42, -40, -42, -40, -39, -40, -41,
-42, -43, -45, -45, -45, -45, -46, -45, -45, -46, -47, -47, -45, -44, -43, -43,
-45, -42, -31, -19, -5, 8, 16, 23, 27, 28, 26, 22, 18, 11, 5, -3, -10, -17, -23,
-29, -33, -35, -39, -40, -42, -42, -45, -46, -45, -45, -45, -44, -46, -43, -45,
-30, -13, -13, -14, -30, -40, -57, -72, -87, -98, -109, -115, -119, -118, -115,
-110, -102, -93, -81, -71, -60, -49, -39, -30, -21, -13, -7, -1, };