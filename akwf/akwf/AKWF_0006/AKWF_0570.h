#define DATA_LENGTH 512
#define DATA AKWF_0570

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 4, 4, 5, 6, 9, 10, 10, 11,
13, 15, 16, 17, 19, 20, 22, 23, 24, 25, 27, 28, 30, 32, 33, 34, 36, 37, 38, 39,
41, 43, 44, 45, 46, 48, 50, 51, 52, 55, 55, 56, 58, 60, 60, 62, 63, 65, 66, 68,
69, 69, 72, 73, 74, 75, 75, 77, 78, 79, 80, 82, 83, 85, 86, 87, 88, 90, 90, 90,
92, 93, 94, 95, 96, 98, 98, 99, 100, 101, 102, 103, 104, 104, 105, 106, 107,
108, 108, 109, 109, 109, 111, 111, 111, 112, 113, 113, 114, 114, 116, 116, 116,
116, 116, 117, 116, 117, 117, 118, 118, 119, 118, 119, 118, 119, 119, 119, 119,
119, 119, 118, 117, 116, 115, 114, 114, 113, 112, 111, 110, 109, 108, 106, 106,
105, 102, 101, 101, 100, 98, 97, 95, 95, 94, 93, 92, 90, 89, 87, 86, 85, 83, 83,
82, 80, 78, 78, 77, 75, 74, 72, 71, 69, 68, 67, 67, 65, 64, 62, 61, 60, 58, 58,
57, 56, 53, 53, 53, 51, 50, 48, 48, 47, 46, 44, 43, 42, 41, 39, 39, 38, 37, 36,
34, 34, 32, 31, 31, 30, 29, 28, 27, 26, 25, 25, 24, 23, 22, 22, 21, 21, 19, 19,
18, 17, 16, 16, 15, 15, 14, 14, 13, 13, 12, 12, 11, 12, 11, 11, 11, 10, 9, 8, 8,
8, 8, 8, 8, 8, 7, 7, 7, 7, 6, 6, 6, 7, 7, 6, 5, 3, 3, 1, 1, 0, -2, -2, -3, -4,
-6, -6, -8, -9, -11, -11, -12, -14, -15, -16, -17, -19, -20, -22, -23, -24, -25,
-27, -29, -30, -31, -32, -35, -35, -37, -38, -39, -41, -43, -44, -46, -46, -48,
-49, -50, -52, -54, -54, -55, -57, -59, -60, -62, -62, -64, -66, -66, -68, -70,
-71, -73, -74, -74, -76, -77, -78, -79, -81, -81, -83, -84, -85, -86, -87, -89,
-89, -91, -93, -93, -94, -95, -95, -97, -97, -99, -99, -101, -102, -102, -103,
-104, -105, -105, -107, -107, -108, -108, -109, -110, -111, -111, -112, -112,
-112, -113, -114, -114, -114, -116, -116, -117, -116, -117, -117, -118, -118,
-117, -118, -118, -119, -119, -119, -119, -119, -118, -119, -120, -118, -118,
-118, -116, -116, -114, -114, -113, -112, -111, -109, -108, -108, -106, -105,
-104, -102, -102, -100, -100, -98, -96, -96, -95, -94, -92, -91, -89, -88, -87,
-85, -84, -83, -82, -80, -79, -79, -77, -76, -74, -72, -72, -70, -69, -68, -66,
-65, -65, -63, -61, -61, -59, -58, -57, -55, -54, -53, -52, -51, -50, -49, -48,
-46, -46, -45, -43, -42, -41, -40, -38, -37, -37, -36, -35, -34, -32, -32, -31,
-29, -28, -28, -28, -27, -25, -24, -23, -23, -23, -21, -20, -20, -19, -18, -19,
-17, -17, -16, -16, -15, -14, -13, -13, -13, -11, -12, -11, -11, -10, -10, -9,
-9, -10, -9, -8, -8, -8, -8, -7, -8, -8, -7, -7, -7, -7, -7, -7, -7, -6, -5, -4,
-4, -3, -2, -1, };