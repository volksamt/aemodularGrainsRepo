#define DATA_LENGTH 512
#define DATA AKWF_0576

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 7, 9, 10, 12, 14, 15, 17,
18, 20, 22, 23, 25, 26, 27, 29, 31, 33, 34, 36, 38, 38, 40, 43, 43, 45, 46, 48,
50, 52, 53, 55, 56, 59, 60, 61, 63, 64, 66, 67, 69, 70, 72, 73, 75, 77, 78, 80,
81, 84, 85, 86, 88, 89, 91, 92, 94, 96, 97, 99, 100, 101, 103, 105, 106, 108,
110, 111, 113, 114, 115, 118, 119, 117, 116, 115, 113, 111, 110, 108, 106, 105,
103, 102, 100, 99, 96, 95, 93, 92, 90, 88, 87, 85, 84, 81, 81, 79, 77, 75, 74,
73, 70, 69, 68, 66, 65, 63, 61, 59, 58, 56, 55, 53, 52, 50, 48, 47, 46, 44, 42,
41, 39, 37, 36, 34, 32, 30, 29, 27, 26, 24, 23, 21, 20, 18, 16, 15, 13, 11, 11,
8, 6, 5, 4, 2, 1, -2, -3, -5, -6, -8, -9, -11, -13, -15, -15, -17, -20, -19,
-18, -18, -19, -19, -19, -19, -18, -20, -19, -18, -19, -20, -20, -19, -19, -20,
-18, -19, -19, -19, -19, -18, -19, -19, -19, -19, -19, -19, -19, -19, -20, -19,
-18, -19, -18, -18, -20, -18, -19, -19, -19, -19, -19, -19, -19, -19, -19, -19,
-19, -19, -19, -19, -19, -18, -18, -18, -19, -19, -19, -19, -19, -19, -18, -19,
-18, -18, -18, -18, -20, -18, -19, -19, -19, -19, -20, -19, -18, -19, -19, -18,
-18, -19, -19, -19, -19, -18, -19, -19, -19, -18, -19, -18, -18, -19, -18, -19,
-19, -18, -19, -19, -19, -19, -19, -19, -19, -18, -18, -19, -18, -19, -18, -19,
-19, -18, -18, -19, -19, -19, -18, -19, -18, -19, -19, -19, -19, -18, -19, -19,
-18, -19, -19, -19, -18, -18, -19, -18, -18, -18, -19, -19, -18, -18, -18, -19,
-19, -18, -19, -19, -18, -18, -19, -18, -18, -19, -18, -19, -18, -18, -18, -18,
-18, -18, -18, -19, -18, -19, -18, -18, -19, -18, -19, -19, -18, -18, -19, -22,
-25, -28, -32, -33, -22, -24, -27, -30, -32, -35, -39, -40, -44, -45, -50, -52,
-56, -57, -62, -62, -67, -67, -73, -73, -80, -77, -87, -76, -17, -24, -25, -26,
-29, -30, -34, -35, -38, -40, -42, -44, -47, -48, -51, -53, -56, -58, -60, -62,
-64, -67, -69, -72, -73, -76, -77, -80, -81, -84, -87, -89, -92, -27, -14, -22,
-16, -21, -17, -20, -18, -20, -18, -20, -19, -20, -19, -21, -20, -20, -19, -22,
-20, -21, -21, -21, -21, -21, -22, -22, -22, -23, -22, -22, -23, -22, -23, -22,
-23, -24, -24, -24, -24, -24, -24, -24, -24, -25, -25, -25, -25, -25, -26, -27,
-26, -26, -26, -26, -27, -26, -26, -27, -28, -27, -28, -28, -28, -28, -28, -28,
-29, -28, -29, -29, -29, -29, -29, -30, -30, -30, -30, -30, -32, -30, -31, -29,
-16, -16, -15, -14, -14, -13, -12, -11, -12, -10, -22, -23, -21, -21, -19, -19,
-18, -18, -16, -15, -12, -11, -10, -9, -7, -6, -3, -2, 0, };