#define DATA_LENGTH 512
#define DATA AKWF_0597

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 7, 9, 12, 15, 17, 20, 22, 25,
28, 30, 33, 36, 38, 40, 42, 46, 47, 50, 53, 56, 57, 60, 62, 65, 66, 69, 71, 73,
75, 77, 79, 81, 83, 85, 86, 88, 90, 92, 93, 94, 96, 98, 99, 101, 102, 103, 104,
105, 106, 107, 108, 110, 110, 110, 112, 113, 113, 114, 114, 114, 116, 116, 116,
115, 117, 116, 116, 116, 116, 116, 116, 116, 116, 115, 114, 115, 114, 113, 113,
112, 111, 110, 109, 109, 107, 107, 106, 104, 103, 102, 101, 99, 97, 96, 96, 93,
92, 91, 90, 87, 87, 85, 82, 81, 79, 77, 75, 73, 71, 69, 67, 65, 63, 62, 59, 57,
55, 53, 51, 49, 46, 43, 42, 41, 37, 36, 33, 31, 29, 27, 24, 22, 20, 18, 15, 14,
12, 9, 8, 4, 2, 0, -2, -5, -6, -9, -10, -12, -12, -17, -18, -18, -21, -23, -23,
-26, -27, -29, -30, -30, -32, -33, -34, -35, -36, -36, -38, -38, -38, -39, -39,
-40, -41, -41, -41, -42, -42, -42, -43, -43, -44, -43, -44, -44, -44, -43, -43,
-44, -44, -44, -44, -45, -44, -44, -44, -43, -43, -43, -43, -43, -42, -43, -43,
-42, -42, -41, -42, -41, -40, -40, -40, -40, -39, -39, -38, -38, -37, -36, -36,
-36, -35, -34, -34, -33, -33, -32, -32, -31, -30, -30, -28, -28, -27, -27, -26,
-25, -24, -23, -23, -22, -21, -20, -20, -19, -19, -18, -16, -16, -15, -15, -13,
-12, -11, -11, -10, -9, -8, -7, -6, -5, -4, -4, -1, -1, -1, 0, 1, 2, 4, 4, 6, 7,
7, 8, 9, 11, 11, 12, 12, 13, 15, 16, 17, 18, 19, 20, 20, 22, 23, 24, 24, 24, 25,
27, 27, 28, 29, 29, 30, 31, 31, 33, 34, 34, 34, 36, 36, 36, 38, 38, 37, 39, 40,
40, 40, 41, 42, 41, 41, 43, 43, 43, 43, 43, 44, 44, 44, 44, 44, 43, 43, 43, 45,
44, 43, 43, 43, 43, 43, 43, 42, 42, 42, 42, 41, 41, 40, 40, 39, 39, 38, 37, 36,
36, 35, 34, 34, 33, 31, 30, 30, 29, 28, 26, 26, 25, 23, 22, 21, 20, 19, 17, 16,
15, 13, 12, 11, 9, 7, 5, 4, 3, 2, 0, -2, -3, -5, -7, -7, -10, -11, -13, -15,
-17, -18, -21, -24, -22, -28, -28, -29, -32, -35, -37, -39, -42, -45, -47, -50,
-52, -54, -58, -60, -62, -64, -67, -69, -71, -74, -77, -80, -82, -84, -86, -88,
-90, -93, -94, -96, -97, -99, -101, -103, -105, -107, -107, -109, -110, -111,
-112, -113, -114, -115, -116, -117, -117, -118, -118, -118, -118, -119, -119,
-119, -120, -119, -119, -117, -118, -116, -117, -116, -115, -114, -114, -112,
-110, -110, -109, -107, -106, -104, -102, -100, -99, -97, -96, -94, -92, -89,
-87, -86, -82, -80, -79, -76, -73, -70, -69, -65, -62, -60, -57, -54, -52, -49,
-45, -43, -40, -36, -34, -30, -27, -24, -21, -17, -14, -11, -8, -5, -1, };