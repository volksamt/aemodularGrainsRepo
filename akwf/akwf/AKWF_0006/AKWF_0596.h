#define DATA_LENGTH 512
#define DATA AKWF_0596

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 13, 26, 38, 48, 59, 67, 75, 82, 85,
88, 91, 91, 90, 88, 84, 79, 74, 68, 61, 54, 46, 38, 30, 21, 12, 4, -3, -10, -17,
-24, -30, -36, -40, -45, -48, -49, -51, -52, -52, -52, -51, -49, -47, -44, -40,
-36, -31, -26, -22, -16, -10, -4, 2, 6, 10, 14, 17, 22, 25, 29, 32, 36, 39, 41,
45, 47, 49, 50, 52, 53, 53, 54, 53, 53, 52, 52, 50, 48, 46, 44, 41, 39, 36, 33,
29, 26, 22, 18, 13, 10, 6, 2, -3, -8, -12, -16, -20, -25, -29, -33, -37, -41,
-45, -48, -51, -53, -56, -58, -59, -62, -63, -63, -65, -63, -63, -63, -61, -60,
-57, -55, -51, -48, -44, -40, -35, -30, -25, -18, -14, -7, -2, 12, 30, 45, 57,
67, 73, 75, 74, 68, 59, 46, 33, 18, 1, -14, -29, -42, -53, -60, -64, -65, -62,
-57, -48, -36, -23, -8, 3, 7, 12, 16, 20, 24, 28, 32, 36, 39, 43, 46, 48, 52,
54, 57, 59, 61, 64, 65, 67, 69, 69, 71, 72, 73, 73, 72, 71, 72, 71, 70, 69, 66,
64, 61, 58, 54, 50, 46, 42, 38, 33, 28, 23, 17, 13, 8, 2, -4, -8, -14, -19, -25,
-29, -33, -38, -44, -49, -53, -58, -63, -66, -70, -73, -76, -80, -82, -85, -86,
-88, -90, -90, -90, -91, -90, -90, -89, -87, -86, -83, -81, -78, -75, -71, -67,
-63, -58, -53, -48, -43, -37, -31, -24, -17, -12, -5, 3, 15, 27, 39, 50, 60, 68,
75, 82, 87, 89, 91, 91, 89, 87, 84, 80, 73, 67, 61, 52, 44, 37, 29, 20, 12, 3,
-3, -12, -18, -25, -31, -36, -41, -45, -48, -50, -51, -52, -53, -52, -50, -50,
-46, -43, -40, -36, -31, -26, -20, -15, -9, -4, 2, 5, 10, 14, 19, 22, 25, 29,
33, 36, 40, 42, 45, 48, 49, 51, 52, 53, 53, 53, 54, 52, 53, 50, 49, 47, 46, 43,
40, 38, 36, 32, 29, 24, 22, 18, 13, 10, 6, 1, -3, -8, -12, -17, -20, -25, -29,
-34, -38, -41, -44, -47, -51, -53, -56, -58, -60, -62, -62, -63, -63, -64, -63,
-62, -61, -59, -57, -55, -51, -47, -44, -40, -35, -29, -25, -18, -12, -7, -1,
14, 32, 46, 59, 68, 74, 76, 74, 67, 58, 45, 31, 16, -1, -16, -32, -43, -54, -61,
-65, -65, -63, -56, -47, -35, -22, -6, 4, 8, 11, 15, 20, 24, 29, 32, 36, 39, 41,
46, 49, 53, 55, 58, 61, 62, 65, 66, 69, 70, 71, 72, 73, 73, 73, 73, 73, 72, 71,
70, 68, 66, 63, 60, 58, 54, 51, 46, 42, 37, 32, 28, 23, 18, 12, 6, 2, -3, -8,
-14, -20, -24, -30, -35, -39, -44, -49, -53, -58, -62, -66, -70, -73, -78, -80,
-81, -85, -87, -89, -89, -90, -91, -91, -91, -90, -88, -88, -86, -82, -81, -79,
-75, -71, -67, -62, -57, -53, -48, -42, -36, -30, -24, -17, -11, -4, };