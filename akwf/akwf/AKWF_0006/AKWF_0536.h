#define DATA_LENGTH 512
#define DATA AKWF_0536

const PROGMEM int8_t DATA[DATA_LENGTH] = {24, -17, 21, -43, 21, 74, 43, 35, 10,
3, -12, -15, -25, -23, -26, -22, -22, -17, -16, -11, -10, -7, -6, -2, -1, 0, 2,
4, 5, 5, 6, 7, 6, 5, 6, 5, 5, 5, 5, 4, 4, 4, 4, 3, 4, 3, 3, 2, 1, 1, 1, 0, 1, 1,
1, 0, 0, -1, 0, -1, -1, -2, -1, -1, -2, -2, -3, 0, -2, -2, -4, 0, -4, 1, -4, 1,
-5, 1, -5, 2, -5, 2, -4, -1, 7, -48, 2, 18, 7, -4, -12, -18, -20, -20, -20, -17,
-17, -11, -11, -4, -6, 0, 0, 5, 6, 11, 10, 13, 13, 16, 16, 17, 17, 17, 17, 16,
17, 15, 14, 13, 11, 10, 10, 9, 7, 6, 5, 4, 3, 2, 2, 1, 0, -2, -2, -3, -3, -3,
-5, -5, -5, -6, -7, -7, -7, -7, -8, -8, -8, -9, -8, -8, -8, -8, -7, -8, -6, -7,
-5, -6, -3, -6, -2, -4, 0, -4, 0, -4, 2, -3, 3, -2, 5, -2, -35, 60, 63, 40, 28,
6, 1, -14, -14, -23, -19, -23, -18, -19, -12, -13, -7, -7, -3, -2, 1, 3, 4, 6,
5, 9, 6, 9, 5, 10, 5, 10, 3, 10, 1, 10, 0, 6, 14, -42, -14, -23, -15, -23, -17,
-19, -15, -12, -10, -3, -7, 32, -30, -45, -22, -11, 7, 14, 24, 27, 32, 33, 34,
31, 30, 26, 24, 21, 18, 15, 13, 8, 8, 4, 4, 0, 1, -4, -3, -7, -5, -8, -6, -10,
-6, -11, -7, 18, -48, -50, -34, -26, -11, -6, 3, 5, 10, 9, 11, 8, 10, 6, 6, 3,
4, 1, 1, -1, -1, -2, -3, -3, -3, -3, -2, -1, -2, -1, -1, 0, 1, 1, 1, 2, 3, 3, 3,
3, 3, 4, 5, 3, 4, 3, 4, 3, 3, 3, 4, 3, 3, 1, 2, 0, 2, 0, 0, 1, -1, 0, -1, 0, -3,
2, -3, 1, -5, 3, -6, 4, -7, 4, -7, 5, -6, 0, 24, -15, -4, -28, -19, -39, 0, -53,
-82, -52, -44, -17, -10, 10, 12, 26, 24, 33, 29, 33, 30, 32, 28, 27, 24, 24, 20,
19, 16, 14, 12, 10, 8, 6, 6, 2, 3, 0, 1, -2, -1, -2, -3, -4, -4, -4, -5, -6, -7,
-8, -7, -8, -8, -8, -9, -8, -8, -9, -8, -8, -7, -8, -7, -7, -5, -5, -5, -5, -3,
-4, -2, -3, -1, -2, -1, -1, 1, 1, 1, 2, 1, 3, 2, 4, 2, 4, 0, 6, 0, 10, -5, 25,
8, -49, -26, -22, -4, 1, 11, 15, 19, 20, 20, 20, 17, 17, 13, 12, 9, 9, 6, 4, 2,
2, -1, 0, -1, -2, -4, -3, -4, -3, -4, -4, -3, -4, -3, -4, -3, -4, -2, -3, -2,
-3, -1, -2, -1, -1, -1, -1, 0, 0, -1, -2, -1, -1, -2, -1, -3, 0, -2, -1, -3, -1,
-2, -1, -2, 0, -2, -1, -2, 0, -1, 0, 0, -1, 2, -3, 6, -7, 12, -24, };