#define DATA_LENGTH 512
#define DATA AKWF_0506

const PROGMEM int8_t DATA[DATA_LENGTH] = {45, 99, 85, 92, 88, 91, 90, 91, 90,
90, 90, 90, 91, 89, 90, 89, 90, 89, 90, 89, 90, 90, 90, 90, 90, 90, 90, 89, 89,
90, 90, 89, 89, 90, 89, 90, 89, 90, 88, 90, 88, 91, 88, 90, 89, 90, 89, 89, 90,
89, 91, 88, 91, 88, 91, 86, 93, 84, 96, 79, 105, 29, -116, -98, -107, -101,
-105, -104, -104, -105, -103, -105, -103, -105, -103, -105, -103, -104, -103,
-104, -103, -105, -103, -104, -102, -104, -104, -105, -103, -105, -103, -104,
-104, -104, -103, -103, -103, -104, -103, -104, -103, -103, -103, -103, -103,
-103, -103, -102, -104, -101, -105, -100, -106, -100, -107, -98, -110, -94,
-119, -44, 103, 83, 93, 88, 91, 89, 89, 90, 89, 91, 89, 91, 89, 91, 89, 91, 89,
92, 89, 90, 89, 90, 89, 90, 89, 90, 90, 90, 89, 90, 90, 89, 90, 89, 89, 89, 90,
90, 90, 90, 89, 89, 89, 89, 89, 89, 90, 89, 89, 89, 90, 90, 89, 89, 90, 89, 89,
89, 89, 90, 90, 89, 89, 89, 89, 89, 89, 89, 88, 89, 89, 89, 88, 89, 88, 89, 88,
90, 88, 90, 87, 90, 88, 90, 88, 89, 87, 90, 88, 89, 88, 87, 91, 84, 98, -57,
-119, -96, -111, -100, -109, -102, -108, -101, -107, -103, -107, -103, -106,
-104, -105, -104, -105, -105, -104, -104, -104, -105, -103, -105, -104, -105,
-103, -105, -104, -105, -103, -105, -103, -105, -104, -104, -104, -104, -104,
-105, -104, -104, -105, -103, -104, -103, -104, -102, -105, -102, -107, -101,
-107, -100, -107, -99, -109, -96, -115, -66, 92, 88, 89, 89, 89, 90, 88, 91, 88,
91, 89, 91, 88, 90, 88, 90, 88, 90, 89, 90, 89, 90, 89, 90, 89, 89, 89, 89, 90,
89, 89, 89, 90, 89, 89, 89, 89, 89, 90, 89, 90, 89, 90, 89, 89, 89, 89, 89, 89,
88, 89, 89, 89, 88, 89, 88, 88, 88, 89, 89, 89, 89, 88, 88, 88, 89, 89, 88, 88,
89, 88, 89, 88, 88, 88, 88, 88, 87, 88, 88, 88, 88, 88, 87, 89, 88, 88, 88, 89,
87, 89, 88, 88, 86, 88, 87, 89, 87, 88, 87, 88, 88, 87, 88, 86, 88, 86, 88, 85,
89, 85, 90, 84, 91, 82, 93, 78, 100, 41, -114, -102, -108, -106, -106, -106,
-105, -107, -104, -108, -105, -108, -104, -107, -105, -107, -105, -107, -105,
-106, -105, -106, -104, -106, -105, -105, -106, -105, -106, -106, -106, -105,
-106, -105, -105, -104, -105, -105, -106, -105, -105, -105, -105, -105, -105,
-105, -105, -105, -105, -105, -104, -105, -104, -105, -104, -105, -104, -105,
-104, -105, -105, -104, -105, -105, -105, -105, -105, -104, -104, -104, -104,
-104, -104, -104, -104, -104, -104, -104, -104, -104, -105, -103, -105, -103,
-104, -104, -104, -103, -104, -104, -104, -103, -105, -104, -104, -103, -104,
-104, -103, -104, -103, -105, -102, -105, -102, -105, -101, -105, -101, -106,
-100, -105, -101, -106, -100, -107, -97, };