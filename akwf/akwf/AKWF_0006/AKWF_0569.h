#define DATA_LENGTH 512
#define DATA AKWF_0569

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 16, 23, 28, 32, 36, 40, 43, 45, 49,
50, 53, 54, 57, 58, 61, 62, 63, 64, 67, 67, 68, 70, 71, 73, 73, 74, 75, 77, 78,
78, 80, 81, 81, 82, 82, 84, 85, 85, 86, 87, 87, 88, 89, 89, 90, 91, 92, 92, 93,
93, 94, 95, 95, 96, 96, 97, 97, 97, 98, 98, 99, 99, 100, 100, 101, 101, 102,
102, 103, 103, 104, 103, 105, 104, 105, 105, 106, 106, 106, 107, 107, 107, 107,
109, 108, 108, 109, 110, 109, 111, 110, 111, 111, 111, 110, 112, 112, 112, 112,
112, 113, 113, 113, 113, 113, 114, 113, 114, 115, 115, 115, 115, 116, 115, 115,
115, 116, 116, 115, 116, 116, 116, 117, 116, 117, 117, 116, 117, 117, 117, 118,
117, 118, 118, 118, 118, 119, 117, 119, 118, 120, 118, 119, 118, 119, 118, 120,
118, 119, 119, 120, 119, 119, 120, 118, 120, 117, 121, 116, 127, 47, -3, 3, -13,
-10, -20, -19, -26, -26, -31, -31, -34, -35, -39, -39, -41, -43, -45, -46, -47,
-49, -49, -51, -52, -54, -55, -56, -57, -57, -58, -60, -59, -62, -62, -63, -62,
-64, -64, -66, -66, -66, -67, -68, -69, -69, -70, -70, -72, -73, -72, -73, -73,
-73, -75, -75, -76, -76, -77, -77, -78, -78, -79, -79, -79, -81, -81, -81, -81,
-82, -82, -82, -83, -83, -85, -84, -85, -85, -85, -86, -86, -86, -88, -87, -87,
-88, -88, -89, -89, -89, -90, -90, -91, -90, -90, -91, -92, -91, -92, -92, -93,
-93, -93, -94, -94, -94, -95, -94, -95, -95, -95, -95, -95, -95, -96, -96, -97,
-96, -97, -97, -97, -99, -98, -99, -98, -99, -99, -100, -99, -99, -100, -100,
-100, -100, -101, -101, -100, -102, -101, -102, -103, -102, -102, -102, -103,
-102, -102, -104, -103, -103, -104, -104, -104, -104, -104, -104, -105, -105,
-105, -105, -105, -105, -105, -106, -106, -106, -106, -106, -106, -107, -106,
-107, -106, -107, -107, -107, -107, -107, -108, -108, -108, -108, -108, -108,
-109, -108, -109, -110, -109, -108, -109, -109, -109, -110, -110, -109, -109,
-110, -110, -110, -111, -111, -110, -111, -111, -111, -111, -112, -111, -111,
-111, -111, -111, -112, -111, -112, -112, -111, -112, -112, -112, -112, -112,
-112, -113, -112, -112, -112, -113, -114, -113, -112, -113, -113, -113, -113,
-113, -113, -113, -113, -114, -114, -113, -113, -114, -114, -114, -114, -114,
-114, -115, -114, -115, -115, -115, -114, -114, -114, -114, -115, -115, -115,
-115, -116, -115, -116, -115, -115, -116, -116, -116, -115, -116, -115, -115,
-116, -116, -116, -115, -117, -116, -116, -116, -116, -117, -117, -116, -116,
-116, -117, -117, -116, -117, -116, -116, -118, -117, -117, -117, -117, -117,
-117, -117, -117, -117, -117, -118, -118, -117, -117, -118, -117, -118, -117,
-118, -116, -118, -117, -118, -117, -118, -118, -118, -117, -118, -117, -118,
-118, -117, -118, -118, -118, -118, -118, -118, -119, -117, -119, -116, -118,
-117, -120, -117, -119, -117, -119, -116, -120, -116, -121, -114, -10, };