#define DATA_LENGTH 512
#define DATA AKWF_0519

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 9, 12, 15, 17, 20, 22, 24,
27, 30, 33, 35, 37, 40, 43, 45, 48, 49, 52, 53, 55, 57, 59, 62, 63, 64, 66, 67,
68, 69, 70, 71, 71, 73, 74, 74, 74, 75, 74, 75, 75, 76, 77, 76, 77, 78, 77, 78,
79, 79, 79, 80, 80, 81, 82, 81, 82, 83, 84, 84, 84, 84, 85, 85, 85, 86, 87, 87,
86, 87, 87, 87, 88, 88, 87, 88, 87, 87, 86, 86, 87, 87, 87, 86, 85, 85, 83, 82,
81, 80, 79, 77, 76, 74, 72, 71, 69, 67, 65, 62, 60, 58, 56, 53, 51, 50, 47, 45,
43, 41, 39, 38, 35, 34, 31, 30, 28, 27, 25, 22, 21, 20, 18, 16, 14, 13, 12, 9,
8, 7, 5, 3, 1, -1, -1, -3, -5, -6, -7, -9, -10, -11, -12, -13, -15, -16, -17,
-18, -20, -20, -21, -22, -23, -24, -25, -25, -27, -27, -29, -29, -30, -30, -32,
-32, -32, -33, -35, -35, -36, -36, -37, -38, -39, -39, -39, -40, -40, -40, -41,
-41, -42, -41, -42, -42, -42, -42, -42, -41, -42, -41, -41, -41, -40, -39, -39,
-39, -39, -38, -37, -36, -36, -35, -34, -34, -32, -32, -30, -29, -29, -26, -26,
-25, -24, -22, -21, -19, -18, -16, -15, -13, -12, -11, -9, -8, -5, -5, -3, -2,
1, 2, 3, 6, 8, 8, 10, 12, 13, 15, 16, 18, 20, 21, 23, 25, 26, 27, 28, 30, 30,
32, 33, 35, 36, 36, 39, 40, 40, 41, 43, 44, 45, 45, 47, 48, 49, 49, 50, 52, 52,
53, 54, 55, 55, 57, 58, 58, 59, 60, 60, 61, 62, 62, 62, 63, 64, 64, 64, 63, 64,
64, 64, 63, 63, 63, 64, 63, 64, 63, 63, 62, 62, 61, 61, 62, 60, 60, 59, 59, 58,
57, 57, 56, 56, 55, 54, 53, 52, 51, 50, 49, 48, 46, 45, 44, 43, 42, 40, 38, 37,
35, 34, 32, 31, 29, 27, 26, 25, 23, 21, 20, 18, 17, 15, 13, 12, 10, 8, 6, 4, 2,
-1, -2, -4, -7, -9, -12, -14, -17, -19, -22, -23, -25, -28, -30, -32, -35, -38,
-39, -42, -44, -46, -48, -51, -53, -54, -57, -59, -61, -63, -65, -67, -68, -71,
-73, -75, -76, -78, -80, -83, -85, -86, -87, -89, -91, -92, -94, -95, -97, -97,
-99, -100, -101, -102, -104, -104, -106, -107, -108, -108, -110, -110, -111,
-111, -112, -113, -113, -114, -115, -115, -116, -115, -116, -117, -117, -117,
-118, -118, -119, -118, -118, -119, -119, -119, -119, -119, -119, -119, -118,
-118, -118, -117, -117, -117, -117, -116, -114, -113, -113, -113, -112, -112,
-111, -109, -108, -108, -106, -105, -105, -103, -101, -100, -99, -98, -96, -94,
-93, -92, -90, -88, -88, -85, -84, -82, -80, -77, -76, -74, -72, -70, -68, -65,
-64, -62, -60, -56, -56, -52, -51, -49, -47, -45, -42, -41, -39, -37, -34, -32,
-31, -29, -26, -23, -21, -19, -16, -14, -12, -9, -7, -3, -1, };