#define DATA_LENGTH 512
#define DATA AKWF_0547

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 12, 9, 14, 16, 32, 42, 35, 50, 54,
48, 50, 40, 34, 34, 30, 34, 48, 40, 53, 66, 67, 73, 66, 75, 87, 87, 88, 84, 88,
90, 93, 101, 93, 86, 86, 95, 105, 107, 93, 103, 116, 108, 114, 98, 85, 90, 84,
100, 103, 90, 93, 102, 108, 107, 97, 90, 95, 96, 95, 95, 87, 85, 82, 92, 92, 78,
81, 76, 85, 87, 74, 83, 79, 66, 60, 43, 28, 22, 9, 9, 15, 1, 6, 14, 9, 9, -3, 1,
9, 5, 4, -5, -2, -4, -3, 3, -7, -16, -15, -8, 0, 1, -12, -3, 8, 1, 7, -12, -25,
-19, -25, -11, -8, -20, -15, -8, -2, -2, -12, -18, -11, -11, -9, -8, -14, -13,
-15, -1, 0, -7, -2, -3, 10, 17, 8, 22, 21, 15, 13, 2, -7, -9, -16, -12, -1, -11,
0, 10, 10, 14, 3, 13, 22, 22, 22, 15, 18, 18, 21, 27, 17, 10, 11, 19, 28, 28,
14, 24, 36, 29, 35, 17, 4, 10, 4, 19, 23, 10, 15, 23, 30, 29, 18, 12, 19, 19,
19, 18, 11, 11, 8, 19, 19, 7, 10, 4, 16, 16, 5, 15, 10, -2, -8, -26, -40, -45,
-57, -56, -51, -65, -56, -51, -55, -54, -68, -60, -53, -57, -59, -67, -65, -66,
-64, -59, -68, -76, -76, -67, -60, -59, -71, -60, -50, -56, -49, -68, -79, -73,
-78, -61, -59, -70, -65, -55, -47, -48, -56, -61, -53, -52, -48, -46, -49, -47,
-46, -31, -28, -35, -26, -27, -9, -4, -8, 8, 9, 4, 5, -5, -12, -10, -17, -9, 3,
-5, 10, 20, 21, 27, 18, 31, 40, 41, 42, 37, 43, 43, 48, 54, 45, 39, 41, 50, 58,
58, 46, 59, 68, 63, 68, 49, 40, 43, 38, 56, 56, 44, 48, 57, 63, 61, 50, 45, 50,
50, 50, 49, 42, 40, 37, 47, 45, 34, 36, 31, 43, 41, 30, 38, 31, 21, 13, -4, -17,
-24, -36, -35, -31, -44, -36, -31, -36, -36, -50, -42, -36, -39, -42, -49, -48,
-50, -47, -43, -53, -62, -61, -53, -45, -46, -60, -47, -38, -45, -40, -60, -70,
-67, -72, -55, -55, -67, -62, -53, -46, -50, -60, -64, -57, -58, -56, -55, -61,
-61, -60, -47, -46, -53, -49, -50, -33, -32, -36, -22, -24, -30, -33, -44, -52,
-53, -61, -53, -45, -54, -40, -31, -32, -28, -38, -26, -18, -19, -19, -24, -20,
-21, -15, -10, -20, -27, -24, -15, -6, -7, -20, -5, 4, -1, 5, -16, -23, -18,
-23, -4, -4, -14, -8, 1, 8, 6, -4, -6, 1, 1, 3, 3, -4, -3, -5, 9, 5, -3, 1, -3,
11, 8, 1, 12, 5, -5, -10, -27, -38, -43, -55, -51, -47, -59, -47, -42, -45, -45,
-57, -46, -40, -43, -46, -52, -46, -48, -43, -39, -48, -56, -52, -44, -34, -36,
-46, -32, -23, -27, -21, -41, -47, -43, -47, -26, -27, -36, -30, -19, -12, -12,
-21, -22, -15, -13, -9, -6, -10, -7, -5, };