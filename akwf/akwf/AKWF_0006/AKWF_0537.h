#define DATA_LENGTH 512
#define DATA AKWF_0537

const PROGMEM int8_t DATA[DATA_LENGTH] = {-4, 19, -1, -76, -56, -48, -18, 12,
-30, -8, 5, 24, 32, 42, 45, 47, 47, 44, 39, 33, 27, 20, 14, 6, 1, -5, -8, -15,
-16, -19, -20, -21, -20, -21, -19, -18, -16, -16, -14, -11, -10, -9, -7, -5, -6,
-5, -3, -3, -1, -1, 0, 0, 1, 1, 2, 3, 3, 4, 4, 5, 6, 6, 6, 6, 5, 5, 4, 5, 3, 2,
2, 1, 0, -1, -2, -2, -3, -4, -3, -4, -4, -4, -4, -3, -2, -2, -2, 0, 1, 1, 2, 2,
3, 4, 5, 6, 5, 6, 5, 5, 5, 5, 4, 3, 3, 2, 2, 3, 0, 1, -1, 0, -2, -1, -2, -2, -2,
-2, -2, -2, -2, -3, 0, -4, 2, -7, 3, -8, -4, -2, -12, -12, -19, -14, -15, -9,
-6, 1, 2, 9, 10, 14, 15, 15, 15, 15, 14, 12, 10, 7, 5, 2, 0, -3, -4, -6, -7, -8,
-8, -8, -8, -8, -6, -6, -4, -4, -2, -3, -1, -1, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 2,
1, 2, 2, 1, 2, 3, 3, 3, 4, 4, 4, 4, 5, 4, 5, 3, 4, 3, 3, 2, 2, 0, 0, -2, -3, -4,
-4, -5, -6, -7, -7, -7, -7, -8, -8, -7, -6, -6, -4, -4, -3, -1, 0, 1, 2, 3, 3,
4, 5, 5, 5, 5, 5, 6, 5, 5, 5, 4, 4, 3, 3, 3, 3, 1, 1, 0, 0, 0, 0, 1, -1, 1, -3,
2, -4, -4, -5, -10, 19, -35, -71, -43, -46, 4, -12, -31, -6, 5, 24, 30, 40, 42,
45, 42, 41, 36, 31, 25, 21, 15, 8, 3, -2, -6, -9, -11, -14, -15, -16, -15, -16,
-15, -14, -12, -11, -10, -9, -7, -7, -7, -5, -4, -4, -3, -3, -2, -3, -3, -3, -2,
-2, -3, -2, -2, -2, -2, -1, -2, -1, -1, 1, 0, 1, 1, 1, 2, 3, 3, 3, 4, 3, 4, 5,
4, 4, 4, 4, 4, 4, 4, 4, 3, 3, 2, 3, 2, 2, 2, 2, 2, 1, 1, 1, -1, 0, 0, 0, -1, -1,
-1, -1, -2, -1, -1, -1, -1, -1, -1, 0, -1, -1, 0, -1, 0, 1, 1, 1, 1, 1, 1, 2, 3,
2, 1, 2, 2, 2, 1, 1, -1, -1, -2, -2, -4, -5, -5, -6, -7, -7, -7, -8, -7, -7, -7,
-5, -5, -4, -3, -3, -1, 0, 1, 2, 2, 5, 4, 5, 6, 6, 6, 6, 6, 5, 7, 6, 6, 5, 5, 4,
3, 3, 1, 2, 2, 1, 1, 1, 0, 0, -1, 0, -1, -2, -1, -1, -1, -2, -1, -1, -1, -2, -1,
-2, -1, -1, -1, -2, -2, -2, -1, -1, -2, -2, -1, -1, -1, -1, -1, 0, 0, -1, 0, -1,
-1, -1, -1, 0, -1, -2, -2, -2, -2, -1, -2, 0, -1, -1, 0, 0, 0, 0, 0, 1, 0, 1, 2,
2, 2, 2, 3, 2, 3, 2, 2, 1, 2, 1, 2, 1, 2, 3, };