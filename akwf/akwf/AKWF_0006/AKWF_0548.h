#define DATA_LENGTH 512
#define DATA AKWF_0548

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 10, 13, 15, 19, 22, 24, 27,
31, 34, 38, 40, 44, 48, 51, 54, 58, 60, 64, 68, 71, 74, 77, 80, 83, 86, 89, 92,
94, 96, 99, 101, 103, 104, 106, 108, 109, 110, 112, 113, 114, 114, 116, 117,
118, 118, 118, 119, 119, 119, 120, 120, 119, 119, 118, 118, 118, 116, 116, 114,
113, 112, 110, 107, 105, 102, 98, 95, 92, 88, 84, 81, 77, 72, 70, 66, 63, 59,
55, 52, 48, 45, 43, 39, 37, 33, 32, 29, 27, 25, 22, 22, 20, 18, 16, 14, 13, 12,
10, 9, 8, 6, 5, 5, 3, 2, 1, 1, -1, -1, -1, -2, -4, -3, -4, -3, -4, -4, -3, -4,
-3, -2, -1, -1, 0, 1, 1, 0, 2, 1, 2, 2, 1, 2, 3, 3, 4, 3, 4, 5, 5, 6, 8, 8, 9,
9, 10, 11, 12, 12, 14, 15, 15, 16, 17, 17, 18, 19, 19, 20, 20, 21, 21, 21, 22,
21, 22, 23, 23, 23, 23, 23, 23, 24, 23, 23, 23, 22, 22, 22, 22, 22, 21, 21, 20,
20, 19, 18, 17, 16, 14, 11, 9, 7, 3, 2, -3, -5, -9, -13, -16, -19, -22, -26,
-29, -33, -36, -38, -41, -44, -47, -49, -52, -54, -56, -58, -60, -62, -63, -64,
-66, -67, -69, -70, -71, -71, -72, -73, -74, -74, -74, -76, -75, -75, -76, -76,
-75, -75, -75, -74, -73, -72, -71, -70, -69, -67, -66, -64, -62, -59, -57, -55,
-52, -49, -46, -45, -42, -40, -38, -36, -33, -30, -28, -26, -22, -20, -17, -15,
-11, -8, -5, -3, 0, 3, 7, 10, 12, 16, 19, 21, 25, 27, 30, 32, 34, 36, 39, 41,
43, 44, 45, 47, 48, 49, 51, 52, 53, 54, 55, 55, 57, 57, 57, 57, 57, 57, 58, 58,
57, 57, 57, 57, 57, 55, 54, 54, 51, 50, 48, 46, 42, 41, 36, 33, 30, 27, 23, 18,
15, 12, 7, 4, 0, -3, -7, -10, -14, -16, -19, -22, -25, -28, -31, -33, -35, -37,
-39, -41, -42, -44, -46, -47, -49, -51, -52, -53, -55, -57, -57, -59, -59, -61,
-62, -63, -64, -64, -65, -65, -66, -67, -67, -67, -67, -67, -66, -66, -65, -65,
-64, -64, -63, -63, -62, -62, -62, -61, -61, -61, -60, -60, -58, -59, -58, -58,
-57, -55, -55, -54, -52, -51, -50, -50, -48, -47, -46, -45, -43, -41, -40, -39,
-38, -36, -35, -34, -32, -32, -31, -29, -28, -27, -27, -26, -24, -24, -22, -22,
-20, -20, -18, -18, -17, -16, -15, -14, -13, -12, -11, -11, -10, -10, -9, -9,
-8, -7, -8, -9, -9, -10, -11, -12, -14, -16, -18, -21, -22, -24, -26, -29, -30,
-33, -35, -36, -38, -40, -41, -43, -44, -46, -48, -47, -48, -50, -50, -51, -50,
-50, -51, -51, -51, -51, -51, -50, -50, -50, -49, -49, -48, -47, -46, -44, -44,
-43, -41, -40, -39, -38, -36, -34, -32, -31, -28, -25, -22, -20, -17, -14, -11,
-8, -4, -2, };