#define DATA_LENGTH 512
#define DATA AKWF_0531

const PROGMEM int8_t DATA[DATA_LENGTH] = {28, 38, 40, 40, 40, 41, 40, 41, 40,
40, 39, 40, 40, 40, 40, 40, 40, 41, 41, 40, 40, 40, 41, 40, 40, 40, 40, 40, 40,
40, 40, 39, 40, 41, 40, 40, 41, 41, 40, 40, 41, 40, 41, 40, 40, 41, 40, 40, 40,
40, 41, 41, 40, 40, 40, 40, 39, 41, 40, 40, 40, 41, 40, 40, 40, 40, 40, 40, 39,
40, 40, 40, 40, 40, 40, 40, 41, 40, 40, 40, 40, 40, 40, 41, 39, 39, 40, 40, 40,
40, 40, 40, 40, 40, 40, 40, 40, 40, 39, 40, 40, 39, 40, 40, 40, 40, 40, 40, 39,
40, 40, 40, 39, 39, 40, 40, 40, 39, 40, 40, 40, 39, 40, 39, 39, 40, 40, 40, 39,
39, 39, 39, 40, 39, 40, 39, 44, 70, 88, 97, 111, 119, 118, 119, 119, 119, 118,
118, 118, 117, 118, 118, 117, 118, 117, 117, 118, 118, 118, 118, 117, 118, 118,
118, 117, 118, 118, 118, 118, 118, 117, 117, 118, 118, 117, 117, 118, 118, 117,
118, 117, 117, 117, 117, 118, 117, 117, 118, 118, 118, 117, 118, 117, 118, 117,
117, 118, 117, 117, 118, 118, 117, 117, 117, 117, 118, 118, 117, 117, 118, 117,
117, 117, 117, 118, 118, 117, 117, 116, 118, 116, 118, 116, 117, 116, 117, 117,
117, 117, 118, 117, 117, 117, 117, 116, 116, 116, 116, 117, 116, 117, 115, 118,
116, 118, 116, 119, 115, 119, 115, 106, 84, 75, 54, 46, 20, -106, -121, -117,
-121, -117, -122, -117, -121, -118, -121, -118, -120, -117, -120, -118, -120,
-119, -120, -118, -119, -119, -119, -119, -119, -119, -118, -119, -118, -119,
-119, -120, -119, -119, -118, -120, -120, -119, -119, -119, -119, -120, -119,
-119, -118, -119, -119, -119, -119, -118, -119, -118, -119, -118, -119, -118,
-118, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -118, -118,
-119, -119, -118, -119, -119, -119, -118, -118, -118, -119, -118, -119, -118,
-119, -117, -118, -118, -118, -119, -118, -118, -119, -118, -118, -119, -118,
-118, -118, -118, -118, -118, -119, -118, -118, -118, -118, -117, -118, -117,
-118, -118, -118, -118, -112, -107, -100, -97, -89, -88, -70, -43, -42, -38,
-40, -39, -39, -38, -39, -39, -39, -39, -39, -40, -39, -39, -39, -39, -39, -40,
-39, -39, -39, -39, -40, -39, -39, -39, -40, -38, -39, -39, -39, -38, -39, -39,
-39, -39, -38, -39, -39, -39, -39, -38, -38, -39, -39, -39, -39, -39, -39, -39,
-38, -39, -38, -39, -39, -38, -38, -39, -38, -39, -39, -39, -39, -39, -39, -38,
-38, -39, -38, -39, -39, -38, -39, -39, -39, -39, -38, -39, -38, -39, -38, -38,
-38, -38, -39, -39, -39, -38, -39, -38, -39, -39, -39, -38, -39, -39, -39, -39,
-39, -39, -39, -38, -38, -39, -38, -39, -38, -39, -39, -39, -39, -38, -39, -39,
-39, -38, -39, -38, -38, -39, -38, -39, -39, -39, -39, -38, -38, -39, -39, -37,
-39, -37, -39, -37, -38, -38, -7, };