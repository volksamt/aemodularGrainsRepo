#define DATA_LENGTH 512
#define DATA AKWF_0544

const PROGMEM int8_t DATA[DATA_LENGTH] = {14, 118, 101, 96, 95, 87, 81, 67, 73,
82, 73, 66, 61, 53, 50, 37, 69, 83, 73, 63, 59, 58, 48, 43, 42, 49, 42, 36, 36,
23, 21, 1, 47, 89, 69, 67, 55, 56, 47, 43, 49, 50, 42, 33, 32, 27, 18, 8, 25,
53, 42, 38, 32, 24, 19, 7, 20, 23, 11, 3, -4, -6, -11, -23, 33, 85, 70, 66, 63,
58, 48, 37, 42, 53, 41, 37, 28, 24, 18, 8, 38, 52, 42, 34, 28, 26, 18, 12, 12,
18, 12, 5, 4, -7, -9, -29, 19, 59, 38, 37, 26, 25, 17, 13, 20, 18, 12, 3, 1, -4,
-13, -22, -4, 23, 11, 7, 1, -6, -13, -24, -10, -7, -19, -28, -33, -36, -41, -56,
23, 88, 69, 68, 63, 58, 49, 38, 41, 54, 41, 37, 28, 24, 18, 8, 40, 51, 41, 33,
28, 27, 17, 12, 11, 18, 11, 5, 4, -7, -9, -29, 21, 59, 38, 37, 24, 25, 16, 13,
19, 19, 11, 2, 1, -4, -12, -22, -4, 23, 11, 7, 0, -6, -12, -24, -9, -7, -20,
-28, -34, -36, -42, -53, 8, 55, 38, 36, 33, 27, 18, 7, 12, 23, 10, 7, -3, -7,
-13, -22, 11, 21, 10, 3, -2, -3, -14, -19, -19, -12, -20, -26, -27, -37, -40,
-59, -8, 27, 8, 6, -6, -4, -14, -17, -10, -11, -20, -27, -29, -34, -44, -52,
-34, -7, -21, -22, -30, -36, -44, -53, -39, -39, -49, -59, -64, -68, -70, -89,
17, 92, 65, 69, 61, 59, 46, 38, 43, 54, 40, 37, 27, 23, 17, 8, 42, 51, 41, 32,
28, 27, 17, 11, 13, 19, 11, 5, 4, -7, -11, -29, 24, 58, 38, 37, 24, 25, 16, 12,
20, 19, 10, 2, 0, -5, -12, -22, -2, 23, 9, 8, 0, -6, -13, -23, -10, -9, -20,
-28, -34, -36, -43, -52, 13, 55, 38, 36, 32, 26, 17, 7, 13, 23, 9, 7, -4, -6,
-14, -21, 12, 22, 10, 3, -2, -3, -13, -19, -18, -12, -20, -25, -28, -38, -42,
-58, -4, 27, 7, 6, -6, -4, -15, -17, -10, -12, -20, -28, -29, -35, -44, -52,
-31, -7, -21, -23, -30, -37, -43, -53, -39, -40, -50, -59, -65, -67, -73, -84,
4, 57, 37, 37, 31, 26, 16, 7, 13, 23, 9, 6, -4, -6, -15, -20, 13, 20, 9, 2, -1,
-4, -13, -19, -18, -12, -20, -25, -27, -38, -43, -58, -3, 27, 8, 6, -6, -6, -16,
-17, -10, -12, -19, -28, -30, -36, -43, -53, -30, -8, -21, -23, -31, -37, -45,
-52, -38, -40, -51, -59, -66, -65, -75, -80, -14, 24, 6, 6, 2, -5, -14, -24,
-17, -8, -22, -24, -35, -37, -46, -51, -16, -9, -20, -28, -33, -34, -45, -49,
-48, -42, -51, -56, -58, -68, -73, -89, -29, -4, -23, -25, -36, -36, -46, -47,
-41, -43, -50, -60, -60, -66, -76, -83, -60, -36, -53, -52, -63, -66, -77, -81,
-71, -68, -85, -86, -100, -92, -111, -101, };