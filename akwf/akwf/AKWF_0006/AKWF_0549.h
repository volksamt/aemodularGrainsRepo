#define DATA_LENGTH 512
#define DATA AKWF_0549

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 19, 30, 40, 51, 60, 70, 79, 87, 95,
100, 106, 111, 113, 114, 117, 115, 112, 110, 106, 102, 95, 90, 83, 73, 65, 55,
44, 34, 22, 11, 0, -11, -23, -33, -44, -56, -64, -73, -82, -89, -96, -104, -110,
-112, -115, -119, -119, -117, -117, -114, -109, -104, -99, -91, -85, -75, -73,
-63, -50, -37, -25, -14, -3, 8, 19, 31, 42, 52, 61, 71, 79, 87, 94, 101, 105,
108, 111, 114, 113, 114, 114, 110, 106, 103, 97, 90, 82, 75, 65, 54, 43, 32, 22,
10, -1, -11, -23, -34, -45, -54, -66, -75, -82, -90, -97, -103, -108, -112,
-114, -117, -118, -119, -115, -112, -108, -104, -98, -93, -85, -75, -67, -56,
-47, -36, -26, -15, -3, 9, 22, 31, 42, 51, 63, 71, 81, 86, 89, 98, 104, 111,
112, 114, 115, 114, 112, 110, 106, 100, 96, 90, 82, 73, 65, 55, 44, 33, 22, 10,
-1, -12, -24, -34, -46, -57, -64, -74, -82, -89, -96, -104, -109, -113, -115,
-119, -118, -117, -117, -114, -109, -104, -99, -92, -83, -75, -66, -56, -46,
-36, -25, -13, -1, 11, 22, 33, 43, 52, 62, 71, 79, 87, 95, 101, 105, 110, 114,
114, 116, 116, 114, 110, 108, 102, 95, 88, 81, 79, 67, 55, 42, 31, 21, 10, -1,
-13, -23, -35, -45, -55, -66, -75, -83, -90, -98, -104, -107, -113, -115, -116,
-118, -118, -115, -111, -108, -104, -97, -93, -85, -75, -66, -56, -45, -35, -26,
-14, -3, 10, 21, 31, 42, 52, 63, 71, 81, 90, 94, 100, 105, 110, 111, 116, 115,
114, 112, 110, 106, 101, 95, 89, 80, 73, 64, 54, 44, 33, 23, 11, 0, -12, -22,
-33, -45, -56, -65, -76, -79, -85, -95, -103, -111, -112, -116, -118, -119,
-117, -117, -114, -109, -104, -99, -91, -83, -75, -66, -56, -47, -36, -24, -13,
0, 11, 22, 34, 43, 52, 63, 72, 80, 87, 96, 101, 105, 111, 114, 114, 115, 116,
113, 110, 108, 103, 95, 88, 80, 72, 62, 55, 43, 33, 22, 10, -2, -14, -25, -36,
-47, -57, -67, -75, -84, -93, -97, -102, -108, -112, -114, -118, -119, -118,
-115, -115, -109, -104, -98, -95, -90, -77, -67, -55, -46, -35, -25, -13, -1,
11, 22, 32, 43, 53, 62, 72, 82, 89, 95, 100, 105, 108, 112, 116, 117, 113, 112,
110, 105, 100, 95, 88, 80, 72, 63, 53, 43, 33, 21, 11, -1, -12, -23, -34, -45,
-55, -66, -77, -85, -90, -98, -105, -108, -112, -117, -117, -116, -117, -114,
-111, -109, -105, -97, -90, -83, -74, -65, -56, -45, -34, -24, -12, -1, 10, 20,
33, 42, 53, 61, 65, 75, 85, 95, 102, 106, 111, 114, 114, 115, 117, 113, 110,
107, 102, 94, 88, 80, 71, 63, 54, 44, 32, 21, 10, -1, -14, -26, -37, -46, -57,
-66, -75, -84, -92, -99, -103, -109, -113, -115, -118, -118, -117, -115, -114,
-109, -103, -98, -91, -82, -73, -64, -55, -44, -34, -23, -11, -1, };