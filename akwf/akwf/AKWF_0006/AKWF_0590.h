#define DATA_LENGTH 512
#define DATA AKWF_0590

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 5, 6, 9, 11, 13, 15, 16, 18, 20,
22, 25, 27, 28, 30, 32, 34, 35, 38, 40, 41, 43, 46, 48, 49, 52, 54, 55, 57, 59,
61, 63, 65, 67, 69, 71, 72, 75, 76, 79, 81, 82, 86, 82, 111, 123, 117, 120, 117,
119, 118, 120, 119, 120, 119, 119, 118, 119, 119, 118, 118, 118, 118, 119, 119,
118, 118, 118, 118, 119, 118, 118, 118, 119, 118, 119, 118, 117, 118, 117, 118,
118, 118, 117, 117, 118, 117, 118, 117, 117, 117, 118, 117, 118, 116, 117, 117,
117, 117, 118, 115, 117, 116, 119, 111, 84, 86, 84, 83, 83, 82, 82, 82, 81, 79,
80, 79, 79, 79, 78, 76, 76, 75, 75, 74, 74, 73, 72, 72, 71, 71, 70, 69, 69, 69,
67, 67, 67, 66, 65, 65, 64, 63, 63, 63, 62, 61, 61, 60, 59, 60, 58, 58, 57, 56,
56, 56, 55, 55, 54, 53, 53, 52, 51, 51, 50, 50, 49, 48, 48, 47, 47, 46, 46, 44,
45, 44, 43, 42, 42, 41, 41, 40, 40, 39, 39, 38, 38, 37, 36, 35, 35, 35, 34, 34,
33, 32, 32, 32, 30, 30, 30, 29, 28, 27, 26, 26, 27, 26, 24, 24, 24, 23, 22, 22,
21, 21, 21, 19, 19, 18, 18, 17, 17, 16, 16, 15, 15, 15, 13, 12, 12, 11, 11, 11,
10, 10, 9, 8, 8, 7, 7, 5, 5, 5, 5, 4, 3, 3, 2, 2, 1, 0, 0, -1, -1, -2, -2, -3,
-4, -5, -5, -6, -6, -6, -7, -7, -8, -9, -9, -9, -11, -11, -12, -13, -13, -13,
-14, -14, -14, -16, -16, -16, -17, -17, -19, -19, -20, -20, -20, -21, -22, -22,
-23, -23, -25, -25, -25, -25, -26, -27, -27, -28, -28, -29, -30, -29, -31, -32,
-31, -32, -32, -33, -34, -34, -35, -35, -37, -37, -37, -38, -39, -39, -39, -41,
-41, -41, -42, -43, -43, -43, -44, -44, -45, -46, -46, -46, -47, -48, -49, -50,
-50, -50, -50, -52, -52, -52, -53, -53, -55, -55, -55, -56, -56, -57, -58, -58,
-59, -59, -60, -60, -60, -61, -62, -62, -63, -64, -63, -65, -65, -66, -66, -66,
-67, -68, -69, -68, -70, -70, -71, -72, -72, -72, -73, -74, -74, -74, -75, -76,
-77, -76, -77, -77, -79, -78, -79, -80, -80, -81, -82, -83, -83, -83, -83, -85,
-84, -87, -82, -102, -121, -115, -118, -117, -117, -117, -117, -117, -117, -117,
-116, -117, -117, -118, -116, -117, -117, -117, -116, -117, -116, -117, -116,
-116, -116, -117, -117, -116, -116, -117, -116, -115, -116, -116, -117, -116,
-116, -116, -115, -115, -116, -116, -115, -115, -116, -115, -115, -115, -116,
-116, -115, -115, -114, -116, -114, -116, -114, -119, -95, -79, -83, -77, -79,
-74, -73, -70, -69, -67, -65, -63, -61, -59, -57, -55, -54, -51, -50, -47, -46,
-43, -42, -39, -38, -36, -33, -32, -29, -28, -26, -24, -22, -20, -18, -16, -14,
-12, -11, -8, -6, -5, -2, -1, };