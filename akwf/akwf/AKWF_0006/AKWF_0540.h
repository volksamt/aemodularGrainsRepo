#define DATA_LENGTH 512
#define DATA AKWF_0540

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 28, 54, 75, 95, 107, 116, 119, 117,
111, 103, 90, 77, 60, 46, 29, 14, 0, -14, -25, -35, -42, -49, -52, -54, -55,
-56, -54, -53, -50, -47, -43, -39, -36, -33, -29, -26, -22, -19, -16, -13, -10,
-6, -4, -1, 1, 5, 7, 9, 12, 13, 14, 15, 17, 17, 17, 17, 16, 15, 13, 11, 8, 6, 3,
0, -2, -4, -6, -8, -10, -10, -11, -10, -10, -9, -8, -5, -4, -1, 1, 4, 5, 8, 10,
12, 12, 15, 16, 15, 16, 16, 16, 16, 15, 14, 11, 11, 9, 8, 6, 4, 4, 2, 1, -1, -2,
-3, -3, -5, -5, -6, -7, -6, -8, -6, -9, -10, -12, -16, -24, -31, -35, -39, -37,
-35, -29, -22, -14, -5, 5, 13, 22, 29, 33, 38, 39, 39, 36, 34, 30, 25, 20, 13,
7, 2, -3, -7, -12, -14, -16, -18, -18, -19, -18, -17, -15, -14, -11, -10, -8,
-8, -5, -4, -2, -2, -1, 0, 0, 2, 1, 2, 3, 4, 4, 5, 6, 7, 8, 9, 11, 12, 12, 13,
13, 14, 15, 15, 14, 13, 11, 10, 8, 5, 2, 0, -3, -6, -10, -13, -16, -18, -20,
-22, -24, -23, -24, -24, -23, -21, -19, -17, -16, -12, -8, -6, -2, 0, 4, 7, 9,
12, 13, 15, 16, 17, 17, 17, 17, 17, 16, 16, 14, 13, 11, 11, 10, 8, 7, 6, 4, 4,
2, 2, -1, -3, -7, -7, -4, -32, -67, -87, -94, -82, -80, -83, -74, -56, -31, -5,
22, 45, 66, 84, 97, 104, 108, 108, 103, 96, 86, 74, 62, 48, 34, 22, 10, -1, -11,
-19, -26, -31, -36, -39, -40, -41, -39, -38, -37, -35, -34, -31, -29, -26, -24,
-23, -21, -20, -18, -17, -16, -15, -15, -15, -13, -12, -11, -10, -10, -8, -7,
-5, -3, -2, 0, 0, 3, 4, 5, 8, 9, 10, 12, 12, 13, 14, 15, 15, 15, 15, 15, 15, 14,
14, 14, 13, 12, 11, 10, 9, 9, 7, 7, 5, 5, 4, 3, 2, 1, 0, -1, -1, -2, -3, -3, -3,
-4, -4, -5, -5, -5, -4, -3, -2, -3, 0, 0, 0, 2, 4, 4, 5, 6, 7, 6, 7, 6, 6, 5, 4,
3, 1, -2, -4, -6, -9, -12, -15, -17, -19, -21, -22, -23, -23, -25, -24, -23,
-21, -19, -17, -15, -11, -8, -5, -1, 2, 5, 7, 10, 14, 15, 18, 19, 20, 20, 20,
20, 19, 19, 18, 18, 16, 15, 13, 12, 10, 9, 7, 6, 4, 4, 2, 1, 0, -1, -2, -2, -2,
-4, -4, -5, -5, -6, -5, -7, -6, -6, -6, -6, -7, -6, -7, -5, -6, -5, -5, -6, -5,
-5, -5, -4, -4, -3, -4, -4, -3, -3, -4, -5, -5, -4, -5, -6, -6, -6, -5, -5, -5,
-4, -3, -3, -2, -2, -1, 1, 2, 1, 3, 3, 3, 5, 5, 5, 6, 7, 6, 7, 6, 7, 8, 4, 7,
13, -12, -54, -80, -90, -78, -70, -74, -63, -46, -19, };