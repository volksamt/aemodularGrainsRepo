#define DATA_LENGTH 512
#define DATA AKWF_0594

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 0, 1, 1, 1, 1, 1, 2, 1, 0, 1, 1,
1, 1, 1, 1, 0, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 0, 1, 1, 2, 1, 1,
1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 2, 0, 0, 1, 1, 2, 2, 1, 1, 1, 1, 0,
1, 1, 1, 1, 1, 2, 1, 1, 1, 2, 2, 1, 2, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1,
1, 1, 1, 2, 1, 2, 2, 2, 1, 1, 0, 1, 1, 1, 1, 2, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1,
2, 1, 1, 1, 2, 6, 8, 10, 12, 16, 18, 20, 23, 25, 28, 31, 33, 36, 39, 41, 44, 46,
49, 52, 55, 57, 59, 61, 64, 66, 70, 72, 75, 77, 79, 83, 85, 87, 90, 93, 94, 97,
100, 103, 105, 107, 111, 113, 115, 118, 113, 112, 108, 107, 104, 101, 99, 96,
94, 91, 88, 86, 84, 80, 78, 75, 73, 69, 67, 64, 63, 59, 58, 53, 52, 50, 46, 44,
41, 39, 35, 34, 30, 29, 24, 26, 7, -2, 1, 0, 1, -1, 0, -1, 1, 0, 1, 0, 1, 0, 0,
0, 0, -1, -1, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 1, -1, 1, 0, -1,
0, -1, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, -1, 0, -1, 0, -1, 0, -1, -1, 0, -1, 0, 0, 0, -1, 0, 0, -1, -1, 0, 0, 0, 0,
0, -1, 0, -1, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0,
0, 0, 0, 0, -1, -1, -1, 0, -1, -1, 0, 0, 1, 0, 0, 0, 1, 0, -1, -1, 0, -1, -1, 0,
0, 0, 0, 0, -1, 0, -1, 1, 0, -1, 0, 0, 0, 1, -1, -1, 0, 0, 0, 0, -1, 0, 0, -1,
0, -1, 0, 0, -1, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, -1,
0, -1, 0, 1, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, -1, 0, 0, -1, 0, -1, 0, 0, 0, -1,
-1, 0, 0, 0, -1, 0, -1, 0, -1, -4, -6, -10, -12, -14, -17, -20, -23, -25, -28,
-31, -33, -35, -38, -41, -44, -46, -49, -51, -54, -57, -59, -62, -65, -67, -70,
-72, -75, -77, -81, -83, -86, -88, -91, -93, -96, -98, -101, -103, -106, -109,
-112, -115, -117, -119, -116, -113, -111, -107, -106, -103, -101, -98, -95, -92,
-89, -86, -85, -81, -79, -76, -73, -71, -69, -66, -62, -60, -57, -55, -52, -49,
-47, -44, -42, -39, -36, -33, -31, -29, -26, -22, -21, -18, -16, -10, };