#define DATA_LENGTH 512
#define DATA AKWF_0585

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 13, 17, 21, 24, 28, 31, 35,
38, 42, 44, 47, 50, 53, 56, 60, 63, 66, 68, 71, 74, 77, 78, 80, 82, 84, 85, 87,
87, 89, 89, 89, 88, 89, 88, 89, 88, 87, 87, 86, 86, 85, 84, 85, 84, 84, 83, 83,
81, 80, 77, 75, 74, 70, 68, 64, 61, 56, 52, 47, 42, 39, 34, 28, 24, 20, 15, 11,
7, 3, -1, -3, -6, -9, -11, -13, -15, -17, -18, -20, -20, -21, -22, -23, -23,
-23, -24, -24, -23, -23, -22, -21, -21, -20, -19, -18, -17, -14, -13, -11, -10,
-9, -6, -5, -3, -2, -1, 0, 3, 3, 4, 5, 5, 6, 8, 8, 9, 9, 10, 12, 13, 15, 16, 18,
20, 23, 24, 27, 29, 31, 34, 36, 37, 39, 40, 42, 43, 44, 43, 44, 44, 43, 43, 43,
43, 40, 39, 37, 36, 35, 33, 31, 29, 28, 26, 25, 23, 20, 18, 16, 15, 12, 9, 7, 4,
2, -2, -5, -7, -12, -14, -17, -20, -24, -31, -38, -45, -51, -57, -63, -68, -73,
-76, -78, -81, -81, -82, -81, -79, -78, -75, -72, -67, -62, -58, -53, -48, -44,
-38, -34, -30, -27, -23, -20, -18, -16, -15, -15, -15, -17, -21, -24, -27, -31,
-37, -42, -48, -54, -61, -67, -73, -80, -85, -91, -97, -101, -106, -109, -112,
-115, -117, -119, -119, -118, -118, -117, -114, -113, -109, -104, -99, -93, -86,
-79, -69, -61, -51, -40, -30, -20, -17, -12, -8, -2, 1, 6, 10, 13, 18, 21, 25,
29, 32, 35, 38, 41, 44, 47, 51, 55, 57, 60, 63, 66, 70, 72, 74, 76, 79, 81, 82,
84, 85, 86, 87, 88, 89, 89, 89, 89, 88, 89, 88, 87, 87, 86, 86, 85, 85, 84, 84,
83, 83, 82, 81, 80, 78, 76, 73, 70, 68, 64, 59, 56, 52, 48, 42, 38, 33, 28, 23,
19, 15, 10, 6, 4, -1, -4, -6, -9, -12, -14, -15, -16, -18, -19, -21, -22, -22,
-22, -23, -24, -23, -23, -23, -22, -23, -21, -21, -20, -18, -17, -16, -15, -13,
-11, -11, -8, -6, -5, -3, -2, -1, 1, 2, 3, 4, 5, 6, 7, 8, 7, 8, 9, 11, 13, 14,
15, 17, 19, 21, 23, 26, 27, 30, 32, 34, 35, 37, 40, 41, 42, 43, 43, 44, 45, 44,
44, 43, 43, 42, 40, 39, 37, 36, 34, 34, 31, 30, 28, 27, 24, 22, 21, 18, 17, 13,
11, 9, 6, 4, 1, -2, -5, -8, -11, -14, -18, -20, -25, -32, -39, -45, -52, -58,
-63, -68, -73, -76, -79, -81, -82, -82, -81, -80, -77, -74, -71, -66, -62, -57,
-52, -48, -43, -38, -33, -29, -25, -21, -20, -17, -16, -15, -14, -16, -18, -20,
-23, -28, -32, -38, -43, -49, -55, -61, -68, -73, -80, -86, -91, -96, -101,
-105, -109, -113, -115, -117, -119, -118, -120, -118, -117, -116, -113, -107,
-104, -98, -92, -85, -77, -69, -59, -50, -40, -28, -19, -16, -11, -7, -3, };