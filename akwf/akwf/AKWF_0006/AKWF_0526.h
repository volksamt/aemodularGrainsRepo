#define DATA_LENGTH 512
#define DATA AKWF_0526

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 1, -2, 10, 19, 16, 19, 22, 22, 20,
31, 37, 32, 40, 54, 51, 53, 55, 58, 55, 63, 72, 69, 71, 74, 75, 73, 75, 73, 74,
74, 74, 75, 75, 74, 74, 75, 74, 74, 74, 74, 75, 74, 75, 72, 69, 71, 70, 75, 73,
75, 73, 75, 73, 78, 90, 87, 89, 88, 88, 88, 88, 88, 89, 87, 88, 88, 89, 79, 73,
75, 74, 74, 74, 75, 71, 69, 72, 64, 55, 58, 56, 54, 52, 54, 44, 38, 39, 38, 36,
34, 36, 21, 15, 21, 12, 3, 5, 4, 0, 0, 0, 0, 0, 1, -2, -14, -14, -14, -16, -17,
-17, -16, -14, -14, -14, -1, 1, 0, 0, -1, 0, 0, 4, 3, 4, 3, 5, 3, 8, 19, 17, 17,
18, 17, 18, 18, 18, 17, 18, 16, 18, 17, 19, 16, 19, 14, 3, 4, 3, 3, 4, 4, 3, 0,
1, 0, -12, -14, -13, -16, -19, -16, -20, -36, -35, -33, -45, -50, -48, -50, -54,
-53, -52, -66, -68, -65, -67, -66, -67, -65, -67, -66, -67, -66, -66, -65, -68,
-71, -70, -70, -71, -70, -71, -70, -70, -70, -71, -84, -84, -83, -86, -89, -87,
-90, -103, -101, -103, -101, -102, -101, -103, -105, -105, -106, -105, -107,
-105, -113, -121, -119, -120, -119, -119, -119, -120, -119, -118, -119, -118,
-119, -118, -120, -118, -120, -112, -103, -107, -105, -102, -101, -103, -90,
-82, -86, -78, -65, -66, -67, -51, -48, -51, -41, -29, -33, -28, -1, 2, -2, 12,
19, 17, 19, 22, 21, 22, 31, 37, 33, 42, 55, 51, 54, 56, 58, 56, 64, 72, 69, 72,
74, 75, 74, 74, 74, 75, 74, 75, 74, 75, 74, 74, 74, 75, 74, 74, 74, 74, 74, 75,
72, 70, 70, 71, 75, 73, 75, 73, 76, 72, 80, 88, 87, 88, 88, 88, 87, 88, 88, 88,
88, 88, 87, 88, 78, 73, 74, 74, 74, 74, 75, 71, 70, 72, 63, 55, 58, 55, 53, 51,
54, 42, 38, 40, 37, 35, 35, 34, 20, 17, 19, 10, 3, 5, 3, 0, 0, 0, 1, -1, 1, -3,
-15, -14, -14, -16, -17, -18, -15, -14, -14, -13, 0, 0, 1, 0, 0, 0, 1, 4, 3, 5,
4, 5, 2, 9, 19, 17, 17, 18, 17, 17, 18, 17, 18, 17, 17, 17, 17, 19, 16, 19, 13,
3, 5, 4, 5, 4, 5, 3, -1, 0, -2, -13, -13, -14, -16, -19, -16, -22, -36, -35,
-35, -47, -50, -48, -51, -53, -52, -53, -66, -66, -66, -66, -66, -66, -66, -67,
-66, -67, -65, -66, -65, -69, -70, -70, -70, -71, -70, -70, -70, -71, -69, -72,
-85, -84, -84, -86, -88, -86, -92, -102, -100, -102, -101, -101, -101, -103,
-106, -105, -106, -104, -107, -103, -115, -121, -119, -119, -118, -120, -119,
-119, -118, -119, -120, -120, -119, -118, -120, -118, -120, -111, -104, -106,
-104, -101, -101, -102, -88, -82, -87, -77, -64, -67, -66, -51, -48, -50, -40,
-28, -34, -26, };