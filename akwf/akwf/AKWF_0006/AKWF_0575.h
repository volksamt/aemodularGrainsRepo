#define DATA_LENGTH 512
#define DATA AKWF_0575

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 2, 3, 2, 2, 3, 3, 4, 3, 3, 3, 3, 3,
3, 3, 3, 2, 3, 3, 3, 2, 2, 3, 3, 3, 3, 3, 4, 4, 3, 2, 3, 3, 2, 4, 3, 3, 4, 4, 3,
3, 2, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3,
4, 3, 3, 2, 3, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3,
2, 3, 3, 3, 3, 3, 2, 3, 3, 4, 3, 4, 3, 2, 4, 3, 2, 3, 3, 2, 3, 2, 2, 3, 3, 3, 3,
3, 3, 3, 3, 2, 2, 4, 2, 3, 3, 3, 3, 3, 2, 3, 3, 3, 4, 4, 3, 3, 3, 4, 2, 3, 3, 3,
3, 4, 3, 3, 3, 4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 3,
2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 2, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 2,
3, 3, 3, 3, 3, 2, 2, 3, 3, 2, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3,
3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3,
2, 3, 3, 3, 3, 2, 3, 3, 3, 2, 3, 3, 3, 2, 3, 2, 2, 3, 3, 3, 2, 2, 2, 3, 3, 3, 3,
3, 3, 3, 3, 3, 3, 2, 2, 3, 4, 3, 2, 3, 2, 3, 2, 3, 3, 2, 2, 3, 3, 2, 3, 2, 3, 3,
2, 3, 3, 2, 3, 4, 3, 3, 3, 3, 3, 4, 2, 3, 3, 2, 3, 2, 3, 3, 3, 3, 2, 3, 3, 3, 2,
3, 3, 2, 3, 3, 3, 2, 2, 3, 2, 2, 3, 3, 3, 3, 3, 3, 4, 4, 4, 6, 7, 7, 8, 9, 10,
10, 11, 11, 3, 3, 3, 2, 4, 3, 3, 2, 3, 2, 3, 3, 3, 2, 3, 3, 3, 3, 3, 2, 3, 3, 3,
2, 3, 1, 0, -3, -5, -8, -9, -12, -14, -17, -19, -21, -24, -26, -29, -30, -33,
-36, -38, -40, -43, -45, -47, -49, -53, -53, -58, -58, -62, -61, -68, -66, -74,
-68, -83, -54, 11, -1, 4, 1, 4, 3, 3, 3, 2, 3, 3, 3, 2, 4, 2, 3, 3, 3, 2, 3, 2,
3, 2, 3, 2, 3, 3, 4, 2, 2, 2, 3, 3, 3, 3, 3, 2, 3, 2, 3, 3, 3, 3, 2, 3, 2, 3, 2,
3, 2, 3, 3, 4, 3, 3, 2, 4, 3, 4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 4, 1, 4, 0, 6, 0,
7, -1, 6, -2, 8, -2, 8, -3, 11, -9, -96, };