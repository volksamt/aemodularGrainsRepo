#define DATA_LENGTH 512
#define DATA AKWF_0581

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 11, 15, 18, 24, 28, 31, 36, 40,
44, 49, 52, 57, 61, 66, 69, 73, 77, 82, 86, 91, 94, 98, 101, 103, 106, 108, 107,
104, 101, 99, 97, 94, 91, 89, 86, 83, 81, 79, 76, 74, 70, 68, 66, 63, 61, 57,
55, 53, 50, 47, 45, 43, 40, 38, 35, 31, 29, 27, 25, 21, 19, 17, 14, 12, 9, 6, 3,
2, -1, -4, -5, -6, -6, -6, -6, -5, -6, -5, -5, -6, -5, -6, -5, -6, -5, -6, -5,
-5, -5, -5, -5, -6, -6, -6, -5, -6, -6, -6, -5, -5, -6, -5, -6, -6, -6, -6, -6,
-5, -5, -6, -6, -5, -5, -6, -6, -5, -6, -5, -6, -5, -6, -6, -6, -5, -5, -6, -5,
-6, -5, -6, -6, -6, -5, -6, -5, -6, -6, -6, -6, -6, -6, -5, -6, -5, -6, -5, -6,
-5, -6, -6, -6, -6, -5, -5, -5, -6, -5, -5, -5, -5, -5, -6, -5, -6, -9, -12,
-14, -17, -19, -22, -25, -27, -29, -32, -34, -37, -41, -42, -45, -47, -51, -52,
-55, -58, -60, -63, -66, -68, -71, -73, -76, -78, -81, -83, -86, -89, -92, -93,
-96, -99, -101, -104, -106, -110, -111, -115, -114, -121, -113, -117, -108,
-113, -101, -113, -75, 6, -4, 4, 3, 7, 9, 11, 13, 16, 16, 20, 19, 30, -11, -36,
-20, -22, -12, -11, -4, -1, 6, 9, 15, 19, 24, 28, 33, 37, 42, 47, 52, 58, 62,
67, 71, 76, 78, 81, 82, 86, 88, 90, 92, 91, 88, 86, 84, 83, 79, 77, 76, 73, 71,
68, 67, 64, 61, 60, 58, 55, 53, 51, 48, 47, 45, 42, 40, 37, 35, 33, 31, 29, 26,
25, 22, 20, 18, 16, 14, 11, 9, 7, 5, 2, 0, -1, -4, -5, -5, -6, -5, -6, -6, -5,
-6, -5, -5, -5, -5, -5, -6, -5, -6, -5, -6, -6, -5, -5, -5, -5, -5, -5, -6, -5,
-5, -5, -5, -5, -5, -5, -5, -5, -6, -5, -6, -5, -5, -5, -6, -6, -6, -5, -5, -6,
-5, -5, -5, -5, -5, -5, -5, -6, -4, -6, -5, -5, -6, -5, -5, -6, -5, -6, -5, -5,
-5, -5, -6, -5, -5, -5, -6, -6, -5, -5, -6, -6, -6, -5, -5, -6, -5, -6, -5, -5,
-5, -5, -5, -5, -6, -6, -6, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5, -6, -5,
-6, -5, -5, -5, -6, -5, -5, -5, -5, -6, -5, -6, -6, -5, -5, -6, -5, -5, -6, -5,
-5, -5, -5, -5, -5, -6, -5, -5, -5, -6, -5, -5, -6, -5, -6, -8, -10, -11, -13,
-14, -17, -19, -19, -21, -23, -24, -26, -27, -29, -31, -33, -35, -36, -37, -39,
-40, -42, -45, -45, -48, -50, -51, -53, -55, -55, -57, -59, -62, -63, -64, -66,
-66, -70, -70, -73, -73, -76, -75, -79, -72, -78, -68, -78, -46, 5, -2, 5, 6, 8,
11, 13, 16, 18, -23, -24, -16, -15, -8, -6, 0, };