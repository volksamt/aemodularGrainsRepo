#define DATA_LENGTH 512
#define DATA AKWF_0574

const PROGMEM int8_t DATA[DATA_LENGTH] = {32, 39, 36, 38, 36, 38, 35, 37, 36,
37, 35, 36, 36, 36, 35, 34, 35, 35, 35, 34, 34, 34, 34, 34, 33, 32, 33, 32, 32,
32, 32, 32, 32, 32, 32, 31, 31, 31, 31, 31, 31, 30, 30, 30, 30, 30, 29, 29, 29,
29, 30, 29, 29, 30, 30, 28, 29, 29, 28, 29, 29, 29, 29, 28, 28, 28, 28, 29, 28,
28, 28, 29, 28, 28, 28, 29, 29, 28, 28, 28, 29, 28, 28, 28, 28, 28, 28, 28, 29,
28, 29, 28, 28, 29, 28, 29, 28, 29, 28, 28, 28, 28, 29, 28, 28, 28, 29, 28, 28,
27, 26, 27, 27, 26, 26, 26, 26, 25, 26, 25, 26, 25, 25, 25, 24, 24, 24, 23, 23,
22, 22, 22, 21, 21, 21, 20, 20, 19, 19, 19, 19, 18, 18, 17, 17, 16, 17, 15, 16,
15, 15, 14, 14, 13, 14, 13, 13, 12, 12, 12, 12, 11, 12, 11, 11, 11, 10, 11, 10,
11, 9, 11, 8, 12, 7, 15, -9, -49, -45, -53, -55, -59, -64, -68, -72, -75, -80,
-83, -87, -89, -93, -95, -99, -101, -105, -107, -109, -111, -113, -114, -116,
-116, -117, -118, -118, -119, -119, -119, -119, -119, -118, -117, -118, -117,
-116, -115, -113, -111, -109, -105, -102, -97, -92, -87, -82, -76, -69, -64,
-57, -51, -45, -39, -32, -25, -18, -12, -4, 2, 11, 16, 25, 27, 35, 34, 42, 28,
-4, 3, 2, 4, 5, 6, 7, 8, 10, 10, 12, 13, 15, 15, 18, 18, 19, 19, 20, 20, 22, 22,
23, 24, 25, 24, 25, 24, 25, 24, 25, 24, 24, 24, 22, 21, 20, 19, 18, 17, 15, 13,
11, 9, 7, 6, 2, 1, -2, -5, -8, -10, -14, -16, -19, -22, -26, -31, -32, -43, -5,
14, 6, 11, 7, 10, 8, 10, 8, 10, 8, 10, 10, 9, 9, 9, 9, 10, 11, 10, 10, 11, 11,
11, 11, 12, 12, 12, 12, 12, 13, 13, 12, 13, 13, 14, 14, 14, 14, 13, 14, 14, 14,
15, 15, 14, 15, 15, 15, 14, 15, 15, 16, 14, 15, 15, 14, 14, 14, 13, 14, 15, 14,
13, 13, 13, 13, 12, 12, 12, 12, 11, 11, 11, 11, 10, 9, 9, 9, 9, 8, 8, 7, 7, 6,
6, 5, 5, 5, 4, 5, 4, 3, 3, 3, 2, 2, 1, 2, 0, 0, 1, 0, -1, -1, -2, -1, -2, -2,
-3, -3, -3, -4, -4, -4, -4, -4, -5, -5, -4, -5, -6, -5, -6, -6, -6, -6, -7, -7,
-7, -7, -8, -8, -8, -7, -9, -9, -9, -9, -10, -10, -10, -10, -10, -10, -11, -11,
-11, -12, -12, -12, -12, -13, -14, -14, -13, -14, -14, -15, -15, -15, -16, -16,
-16, -16, -17, -17, -17, -18, -18, -18, -18, -18, -18, -19, -18, -18, -18, -18,
-18, -19, -18, -18, -17, -18, -17, -16, -16, -16, -15, -15, -14, -13, -13, -11,
-11, -10, -10, -8, -8, -7, -5, -4, -3, -2, -1, };