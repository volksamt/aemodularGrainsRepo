#define DATA_LENGTH 512
#define DATA AKWF_0584

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3,
3, 4, 2, 4, 3, 6, 17, 15, 16, 17, 15, 17, 16, 16, 16, 16, 16, 17, 15, 23, 31,
29, 30, 28, 30, 29, 29, 28, 30, 42, 41, 42, 41, 41, 42, 41, 42, 41, 41, 41, 42,
42, 42, 41, 42, 41, 44, 54, 53, 53, 52, 53, 53, 53, 54, 52, 54, 53, 54, 52, 60,
65, 64, 65, 64, 64, 64, 64, 64, 64, 64, 64, 64, 63, 73, 74, 73, 74, 74, 74, 74,
74, 74, 74, 74, 74, 73, 76, 84, 82, 82, 82, 82, 83, 83, 83, 82, 82, 82, 83, 81,
87, 91, 89, 90, 90, 91, 91, 91, 90, 90, 90, 91, 90, 90, 96, 97, 97, 97, 97, 97,
97, 97, 97, 97, 97, 97, 97, 96, 97, 97, 97, 96, 98, 102, 102, 102, 103, 102,
102, 102, 102, 102, 101, 102, 101, 102, 101, 102, 102, 102, 101, 103, 102, 101,
106, 106, 106, 106, 107, 106, 105, 106, 106, 106, 105, 105, 106, 105, 107, 109,
110, 110, 109, 109, 109, 112, 112, 111, 111, 111, 111, 111, 111, 111, 111, 110,
112, 111, 111, 110, 111, 111, 111, 111, 111, 111, 112, 112, 112, 113, 111, 112,
112, 112, 111, 113, 112, 112, 111, 113, 113, 113, 112, 113, 113, 113, 113, 113,
113, 113, 113, 113, 114, 112, 113, 112, 114, 112, 114, 112, 114, 112, 114, 111,
113, 112, 113, 112, 113, 113, 112, 113, 111, 114, 109, 118, 106, 122, 97, 127,
-4, -128, -104, -128, -112, -124, -116, -122, -117, -120, -119, -119, -119,
-119, -120, -118, -120, -117, -120, -117, -120, -118, -120, -117, -119, -118,
-120, -118, -119, -118, -119, -118, -119, -119, -119, -118, -118, -119, -118,
-118, -119, -117, -116, -117, -116, -118, -117, -118, -117, -117, -117, -117,
-117, -117, -117, -116, -115, -115, -116, -115, -115, -115, -115, -115, -115,
-115, -115, -115, -114, -112, -112, -112, -112, -112, -113, -113, -113, -112,
-111, -112, -112, -113, -110, -108, -109, -108, -110, -108, -109, -108, -108,
-109, -109, -109, -108, -108, -104, -104, -103, -104, -104, -104, -103, -104,
-104, -103, -104, -104, -104, -103, -103, -103, -103, -103, -98, -98, -98, -98,
-97, -98, -97, -97, -98, -98, -98, -98, -97, -97, -97, -98, -98, -98, -98, -98,
-94, -89, -90, -90, -91, -90, -91, -90, -90, -90, -90, -90, -90, -90, -90, -91,
-88, -81, -83, -82, -83, -80, -72, -74, -73, -73, -72, -73, -73, -74, -72, -74,
-72, -73, -73, -73, -73, -73, -72, -73, -73, -74, -72, -64, -62, -63, -62, -63,
-62, -63, -63, -62, -63, -62, -63, -62, -63, -57, -50, -52, -51, -52, -53, -46,
-38, -41, -39, -40, -38, -39, -39, -40, -39, -39, -40, -39, -40, -39, -39, -40,
-39, -40, -39, -40, -38, -26, -28, -27, -28, -27, -27, -27, -27, -28, -26, -27,
-26, -28, -20, -13, -15, -13, -15, -14, -14, -13, -14, -14, -13, -14, -14, -15,
-3, 0, };