#define DATA_LENGTH 512
#define DATA AKWF_0508

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 115, 122, 116, 121, 116,
121, 117, 121, 118, 121, 117, 120, 118, 120, 119, 119, 119, 119, 119, 119, 119,
119, 120, 119, 119, 118, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 120,
118, 120, 119, 119, 119, 119, 119, 119, 118, 119, 118, 118, 119, 118, 119, 118,
119, 119, 119, 118, 119, 118, 119, 118, 119, 118, 118, 119, 118, 119, 118, 118,
119, 119, 118, 118, 118, 119, 118, 118, 119, 118, 118, 118, 118, 118, 118, 118,
119, 118, 119, 118, 118, 118, 118, 118, 118, 117, 118, 118, 118, 118, 118, 117,
118, 118, 117, 117, 118, 118, 118, 118, 118, 118, 118, 118, 117, 118, 117, 119,
118, 118, 117, 119, 117, 118, 118, 118, 117, 117, 118, 117, 117, 117, 119, 116,
119, 116, 119, 116, 119, 116, 119, 116, 118, 115, 118, 117, 117, 117, 116, 119,
114, 124, 106, 127, -45, -127, -102, -127, -109, -123, -112, -121, -113, -119,
-115, -119, -116, -118, -117, -117, -117, -117, -117, -117, -117, -116, -118,
-116, -117, -117, -117, -117, -117, -116, -117, -117, -118, -117, -118, -116,
-117, -117, -117, -117, -116, -116, -117, -117, -117, -117, -117, -117, -117,
-117, -117, -117, -117, -117, -117, -117, -116, -116, -116, -116, -117, -116,
-116, -116, -117, -116, -115, -117, -117, -117, -116, -116, -116, -116, -116,
-116, -116, -116, -116, -116, -115, -116, -116, -116, -117, -116, -117, -115,
-116, -116, -116, -116, -116, -117, -116, -116, -116, -116, -116, -116, -116,
-116, -117, -116, -115, -116, -116, -115, -116, -116, -116, -115, -116, -116,
-116, -116, -116, -116, -115, -116, -115, -115, -116, -115, -116, -115, -116,
-115, -116, -115, -116, -115, -116, -115, -116, -114, -116, -114, -116, -115,
-116, -114, -115, -115, -115, -116, -116, -116, -115, -117, -113, -118, -112,
-120, -110, -121, -107, -126, -101, -128, -40, 127, 108, 126, 115, 122, 118,
120, 119, 118, 120, 118, 120, 117, 121, 118, 120, 118, 120, 117, 121, 118, 120,
118, 120, 119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
119, 118, 120, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 119, 118,
118, 119, 118, 118, 119, 119, 119, 118, 118, 118, 119, 119, 118, 119, 118, 119,
118, 119, 118, 120, 117, 120, 118, 119, 118, 119, 119, 117, 119, 118, 119, 117,
120, 116, 121, 114, 122, 113, 124, 111, 127, 105, 127, 64, -128, -109, -120,
-114, -117, -116, -115, -117, -114, -118, -114, -118, -114, -118, -114, -118,
-114, -118, -114, -117, -116, -117, -114, -117, -115, -116, -116, -115, -116,
-115, -117, -116, -116, -116, -116, -115, -116, -115, -116, -115, -116, -116,
-116, -116, -116, -116, -116, -116, -116, -115, -116, -115, -115, -115, -115,
-115, -116, -116, -115, -115, -116, -116, -116, -115, -116, -115, -114, -115,
-115, -116, -115, -116, -115, -115, -115, -115, -115, -115, -115, -115, -115,
-114, -115, -115, -116, -114, -117, -113, -117, -114, -118, -113, -118, -112,
-118, -110, -123, -99, };