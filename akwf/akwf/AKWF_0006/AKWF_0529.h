#define DATA_LENGTH 512
#define DATA AKWF_0529

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 0, 1, 1, 0, 0, 0, 0, 1, 0, 1,
0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 1, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 1, 1, 0, 1, 0, 1,
0, 1, 1, 1, 1, 1, 0, 1, 1, 0, 1, 0, 1, 0, 2, 0, 2, 0, 1, 0, 2, -1, 2, 0, 1, 1,
1, 2, -6, 100, 126, 114, 123, 115, 122, 116, 121, 117, 120, 118, 119, 118, 120,
119, 120, 119, 119, 119, 119, 119, 119, 120, 118, 120, 119, 119, 119, 120, 118,
120, 119, 119, 119, 119, 118, 120, 119, 120, 119, 119, 118, 119, 118, 118, 119,
119, 119, 118, 120, 118, 120, 118, 121, 118, 121, 117, 123, 114, 127, 97, 27,
39, 34, 36, 36, 36, 36, 35, 36, 35, 35, 34, 36, 34, 36, 35, 36, 35, 36, 35, 36,
35, 36, 35, 35, 35, 35, 36, 35, 35, 36, 35, 35, 35, 35, 35, 35, 35, 36, 35, 35,
35, 35, 32, 30, 31, 30, 31, 30, 31, 30, 31, 30, 31, 32, 31, 31, 31, 31, 30, 31,
30, 31, 31, 30, 31, 31, 31, 30, 30, 31, 30, 30, 31, 31, 31, 31, 30, 30, 31, 31,
31, 30, 31, 31, 31, 31, 32, 29, 32, 29, 33, 23, 2, 7, 5, 6, 5, 5, 5, 5, 6, 5, 6,
5, 6, 5, 6, 5, 6, 6, 6, 5, 5, 6, 5, 5, 5, 5, 5, 5, 6, 6, 5, 6, 5, 5, 5, 5, 5, 5,
5, 5, 6, 6, 6, 1, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, -1, 0, 1, 1, 0,
0, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, -1, 0, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, -2, -7, -5, -5, -6, -5, -6, -6, -6, -6, -5, -5, -5, -6, -5, -5, -6, -5,
-6, -6, -5, -5, -5, -5, -5, -5, -6, -5, -6, -5, -6, -5, -6, -5, -6, -5, -6, -5,
-6, -6, -6, -5, -6, -5, -6, -28, -31, -29, -30, -29, -30, -29, -31, -30, -30,
-30, -31, -30, -30, -30, -30, -30, -30, -29, -30, -31, -30, -30, -31, -31, -30,
-30, -31, -31, -31, -31, -30, -31, -31, -31, -31, -31, -30, -30, -31, -31, -32,
-31, -32, -31, -30, -31, -31, -31, -32, -31, -32, -36, -35, -35, -35, -36, -36,
-35, -36, -36, -36, -35, -36, -36, -35, -35, -35, -35, -35, -36, -36, -36, -36,
-36, -36, -35, -35, -36, -35, -36, -36, -36, -35, -37, -35, -37, -34, -38, -33,
-39, -33, -40, -27, -59, -127, -115, -121, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -120, -119, -119, -118, -120, -118, -119, -118, -118,
-119, -118, -119, -119, -120, -119, -120, -118, -120, -118, -120, -119, -119,
-119, -119, -119, -118, -119, -119, -120, -119, -120, -118, -120, -117, -121,
-117, -121, -116, -121, -115, -123, -114, -127, -101, };