#define DATA_LENGTH 512
#define DATA AKWF_0532

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 40, 40, 40, 40, 40, 40, 40, 41, 39,
41, 40, 40, 40, 40, 40, 40, 39, 40, 40, 40, 40, 41, 41, 40, 41, 40, 40, 40, 41,
40, 39, 40, 40, 40, 40, 40, 40, 39, 40, 40, 40, 40, 40, 41, 40, 40, 40, 40, 40,
40, 40, 40, 41, 40, 41, 40, 40, 41, 39, 40, 40, 40, 40, 39, 40, 40, 40, 40, 40,
40, 41, 41, 40, 40, 40, 40, 40, 40, 40, 40, 41, 40, 40, 39, 40, 40, 40, 39, 40,
40, 40, 40, 39, 41, 39, 40, 40, 40, 40, 40, 40, 39, 40, 40, 40, 40, 40, 40, 40,
40, 40, 40, 40, 40, 39, 39, 40, 39, 40, 39, 40, 40, 39, 39, 40, 40, 40, 39, 39,
40, 40, 40, 39, 40, 38, 41, 36, 68, 117, 118, 118, 118, 118, 118, 118, 118, 118,
118, 118, 117, 117, 118, 118, 118, 118, 118, 118, 118, 117, 118, 118, 118, 117,
119, 118, 117, 119, 118, 118, 118, 117, 118, 118, 118, 118, 117, 118, 117, 117,
118, 118, 118, 117, 117, 118, 118, 118, 118, 118, 117, 118, 118, 118, 117, 117,
118, 117, 117, 117, 117, 118, 118, 117, 118, 118, 118, 117, 117, 118, 117, 117,
118, 117, 117, 117, 118, 117, 117, 117, 117, 118, 116, 117, 116, 117, 117, 117,
116, 118, 117, 117, 117, 116, 117, 116, 117, 116, 116, 116, 116, 116, 117, 116,
118, 116, 118, 116, 118, 115, 117, 116, 117, 117, 117, 116, 49, -17, -92, -124,
-116, -121, -117, -121, -117, -120, -118, -120, -118, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -118, -119, -119,
-120, -118, -118, -119, -119, -118, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -118, -119, -119, -118,
-118, -119, -118, -119, -118, -119, -118, -118, -119, -119, -119, -118, -119,
-119, -118, -118, -118, -119, -118, -118, -118, -118, -119, -118, -118, -119,
-119, -118, -118, -119, -118, -119, -118, -117, -118, -117, -118, -119, -118,
-118, -119, -118, -118, -118, -118, -118, -118, -118, -118, -117, -118, -118,
-118, -117, -118, -118, -118, -117, -118, -117, -95, -73, -48, -38, -40, -39,
-40, -38, -40, -38, -39, -39, -40, -39, -40, -39, -40, -39, -38, -39, -39, -39,
-40, -39, -39, -39, -39, -39, -39, -40, -39, -39, -39, -39, -39, -39, -39, -39,
-39, -38, -39, -39, -40, -39, -39, -39, -39, -39, -38, -38, -38, -39, -39, -39,
-38, -39, -38, -39, -38, -39, -39, -39, -39, -39, -39, -39, -39, -39, -39, -39,
-39, -38, -39, -39, -39, -39, -39, -38, -39, -39, -39, -38, -38, -38, -39, -38,
-39, -39, -38, -38, -39, -38, -39, -39, -38, -39, -38, -38, -38, -38, -39, -38,
-39, -39, -38, -38, -38, -38, -39, -38, -38, -39, -39, -38, -39, -38, -39, -38,
-38, -39, -38, -38, -38, -38, -38, -38, -39, -38, -38, -39, -39, -38, -39, -38,
-38, -37, -40, -37, -41, -33, };