#define DATA_LENGTH 512
#define DATA AKWF_0555

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 2, 4, 4, 6, 6, 7, 8, 9, 10,
11, 11, 11, 14, 14, 14, 15, 17, 16, 18, 18, 19, 20, 20, 22, 22, 24, 24, 25, 25,
26, 27, 28, 29, 29, 30, 31, 31, 32, 32, 33, 34, 34, 35, 36, 37, 37, 38, 39, 39,
40, 40, 42, 42, 42, 43, 43, 44, 45, 44, 45, 46, 47, 47, 48, 48, 50, 50, 50, 51,
52, 51, 52, 52, 53, 54, 55, 55, 54, 56, 56, 56, 57, 58, 58, 58, 58, 59, 60, 60,
60, 61, 60, 63, 63, 63, 62, 63, 63, 64, 64, 65, 65, 66, 65, 67, 67, 67, 68, 68,
68, 69, 69, 70, 70, 70, 71, 72, 72, 72, 72, 73, 74, 73, 73, 74, 74, 74, 76, 76,
76, 76, 76, 77, 78, 78, 79, 79, 80, 80, 80, 81, 81, 81, 82, 82, 83, 83, 84, 84,
85, 84, 86, 86, 86, 87, 87, 88, 88, 89, 89, 90, 90, 91, 90, 92, 92, 92, 93, 94,
94, 95, 95, 96, 97, 96, 97, 98, 99, 99, 100, 100, 100, 101, 101, 102, 103, 103,
103, 104, 105, 106, 106, 106, 108, 108, 108, 109, 110, 110, 111, 112, 112, 113,
113, 114, 115, 115, 116, 117, 118, 118, 118, 119, 119, 119, 118, 118, 117, 116,
115, 113, 110, 110, 108, 105, 102, 100, 97, 94, 91, 88, 85, 81, 78, 74, 71, 67,
63, 58, 55, 51, 47, 43, 38, 35, 30, 26, 21, 17, 13, 10, 5, 2, -3, -7, -10, -14,
-18, -21, -26, -28, -33, -34, -38, -41, -44, -48, -50, -53, -56, -59, -62, -65,
-67, -70, -72, -75, -78, -80, -82, -83, -86, -88, -89, -92, -93, -94, -96, -97,
-98, -101, -102, -103, -103, -104, -106, -105, -106, -108, -108, -109, -109,
-109, -110, -110, -111, -111, -110, -111, -112, -112, -111, -112, -111, -112,
-112, -112, -111, -111, -110, -110, -110, -110, -109, -109, -108, -108, -107,
-107, -107, -105, -106, -106, -105, -104, -103, -102, -102, -102, -102, -101,
-101, -98, -98, -98, -97, -96, -97, -96, -94, -94, -94, -93, -92, -92, -92, -91,
-90, -90, -88, -88, -88, -87, -87, -86, -85, -84, -84, -83, -82, -83, -82, -81,
-81, -80, -80, -80, -79, -78, -78, -77, -77, -77, -76, -76, -75, -75, -74, -74,
-74, -73, -73, -73, -72, -73, -71, -71, -70, -70, -70, -69, -68, -68, -68, -68,
-68, -66, -67, -66, -65, -65, -65, -64, -64, -64, -64, -63, -62, -62, -61, -62,
-61, -60, -60, -59, -59, -58, -58, -58, -57, -56, -56, -56, -55, -55, -54, -54,
-54, -53, -52, -52, -51, -51, -49, -49, -48, -49, -47, -47, -47, -46, -45, -45,
-44, -43, -43, -42, -41, -40, -40, -40, -38, -38, -37, -37, -36, -35, -34, -34,
-33, -32, -31, -30, -30, -28, -28, -28, -26, -25, -24, -24, -24, -23, -22, -20,
-20, -20, -18, -17, -16, -16, -15, -15, -12, -13, -11, -11, -10, -8, -8, -7, -6,
-6, -5, -3, -3, -2, -1, 1, };