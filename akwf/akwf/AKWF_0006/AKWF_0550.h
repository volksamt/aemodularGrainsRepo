#define DATA_LENGTH 512
#define DATA AKWF_0550

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 1, 2, 3, 4, 5, 5, 6, 7, 7, 8,
9, 9, 10, 10, 12, 13, 13, 14, 14, 15, 15, 16, 16, 17, 17, 18, 18, 19, 19, 19,
21, 21, 21, 21, 22, 23, 22, 24, 25, 25, 25, 26, 27, 27, 27, 27, 28, 29, 29, 30,
30, 31, 31, 31, 32, 32, 32, 33, 33, 34, 34, 34, 35, 36, 36, 35, 37, 36, 37, 37,
37, 38, 38, 39, 39, 40, 40, 40, 41, 41, 41, 42, 42, 43, 43, 44, 43, 45, 45, 44,
44, 45, 45, 45, 46, 47, 46, 47, 48, 48, 48, 48, 49, 49, 48, 50, 50, 50, 51, 51,
51, 52, 52, 52, 53, 52, 53, 53, 54, 53, 55, 54, 55, 55, 55, 56, 56, 56, 58, 57,
57, 58, 58, 59, 59, 59, 59, 60, 60, 60, 61, 62, 61, 62, 63, 62, 63, 64, 63, 64,
65, 65, 65, 66, 66, 67, 66, 68, 67, 68, 69, 69, 69, 69, 70, 71, 71, 71, 72, 72,
73, 73, 74, 75, 75, 75, 75, 75, 75, 76, 77, 78, 78, 78, 79, 79, 80, 80, 80, 81,
81, 82, 82, 83, 84, 84, 84, 85, 85, 86, 86, 88, 88, 87, 89, 89, 89, 89, 91, 90,
91, 91, 92, 92, 93, 93, 94, 95, 95, 96, 97, 96, 97, 97, 98, 99, 98, 100, 101,
101, 100, 103, 102, 104, 102, 105, 103, 106, 104, 108, 106, 107, 106, 109, 108,
109, 108, 10, -40, -73, -85, -84, -114, -116, -97, -80, -77, -71, -78, -90, -99,
-96, -94, -90, -89, -91, -100, -106, -108, -109, -105, -104, -102, -104, -106,
-106, -103, -98, -94, -90, -87, -84, -81, -79, -76, -72, -69, -66, -65, -65,
-63, -63, -62, -63, -64, -64, -66, -68, -69, -71, -72, -73, -74, -76, -76, -77,
-78, -77, -76, -75, -75, -74, -72, -70, -68, -66, -65, -63, -61, -59, -58, -56,
-55, -55, -54, -54, -54, -54, -54, -55, -57, -57, -58, -59, -61, -62, -64, -64,
-64, -65, -66, -66, -66, -65, -65, -65, -64, -63, -62, -61, -60, -59, -57, -57,
-57, -56, -55, -53, -55, -54, -54, -54, -55, -55, -56, -57, -57, -58, -59, -60,
-60, -61, -61, -61, -62, -63, -62, -62, -62, -62, -61, -61, -61, -59, -59, -58,
-57, -57, -56, -55, -54, -55, -54, -54, -53, -54, -54, -54, -55, -55, -54, -55,
-55, -56, -56, -56, -56, -56, -56, -57, -56, -56, -55, -55, -54, -55, -53, -52,
-52, -51, -50, -50, -49, -48, -47, -47, -46, -46, -46, -46, -46, -45, -44, -44,
-45, -44, -44, -43, -44, -43, -44, -44, -42, -43, -41, -41, -41, -41, -40, -39,
-38, -37, -37, -36, -35, -34, -33, -33, -32, -30, -30, -29, -29, -29, -28, -27,
-27, -26, -26, -25, -25, -24, -24, -23, -23, -23, -22, -21, -21, -21, -20, -19,
-19, -18, -16, -16, -15, -14, -13, -12, -11, -11, -9, -9, -9, -8, -8, -7, -6,
-6, -5, -3, -3, -2, -3, -2, -1, -1, 0, };