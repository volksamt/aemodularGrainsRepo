#define DATA_LENGTH 512
#define DATA AKWF_0502

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 116, 122, 116, 122, 117,
121, 118, 121, 118, 121, 118, 119, 118, 120, 118, 119, 119, 119, 120, 119, 119,
119, 118, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119,
119, 119, 118, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 118, 118, 119,
118, 119, 119, 118, 120, 118, 118, 119, 119, 119, 118, 118, 119, 119, 119, 118,
118, 119, 118, 118, 118, 119, 118, 118, 118, 119, 118, 118, 118, 118, 118, 118,
118, 119, 118, 118, 118, 118, 118, 118, 118, 119, 118, 118, 118, 118, 118, 118,
119, 118, 118, 118, 117, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118,
118, 117, 117, 117, 118, 117, 117, 117, 117, 117, 117, 118, 117, 118, 117, 118,
118, 118, 117, 118, 117, 117, 116, 118, 118, 118, 118, 118, 117, 117, 118, 117,
116, 118, 117, 117, 117, 118, 116, 117, 117, 117, 117, 117, 117, 117, 117, 117,
117, 117, 116, 117, 117, 117, 117, 117, 116, 117, 117, 117, 117, 117, 117, 117,
116, 116, 116, 117, 116, 117, 116, 117, 117, 116, 117, 116, 117, 117, 116, 116,
117, 117, 117, 117, 116, 116, 116, 116, 116, 116, 116, 116, 116, 116, 117, 116,
117, 116, 116, 116, 117, 115, 117, 116, 117, 116, 117, 116, 116, 116, 115, 116,
116, 116, 114, 117, 114, 118, 114, 118, 113, 120, 112, 119, 112, 120, 110, 120,
110, 122, 105, -105, -118, -109, -119, -110, -117, -110, -118, -110, -116, -110,
-116, -112, -116, -111, -115, -112, -115, -113, -115, -113, -114, -114, -114,
-114, -114, -114, -114, -114, -113, -114, -113, -114, -113, -114, -113, -114,
-113, -114, -113, -114, -114, -113, -113, -113, -114, -113, -113, -113, -113,
-114, -113, -113, -113, -114, -113, -113, -113, -114, -113, -113, -113, -113,
-113, -113, -113, -113, -114, -113, -113, -114, -113, -112, -113, -113, -112,
-113, -114, -113, -114, -114, -113, -112, -112, -113, -113, -113, -113, -112,
-113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113,
-112, -112, -112, -113, -113, -113, -112, -113, -112, -113, -113, -113, -113,
-112, -112, -112, -113, -112, -112, -113, -112, -112, -112, -112, -112, -112,
-112, -113, -113, -112, -112, -112, -112, -112, -112, -113, -112, -111, -112,
-113, -112, -112, -113, -112, -112, -111, -112, -112, -112, -112, -112, -112,
-112, -112, -112, -111, -111, -112, -113, -112, -111, -113, -112, -112, -112,
-111, -112, -112, -111, -112, -111, -111, -112, -111, -112, -111, -111, -111,
-112, -111, -112, -111, -112, -111, -112, -112, -112, -111, -111, -111, -111,
-112, -112, -111, -111, -112, -112, -112, -112, -112, -111, -112, -111, -111,
-111, -110, -111, -111, -111, -110, -111, -111, -111, -111, -112, -110, -111,
-111, -111, -111, -110, -111, -111, -111, -111, -111, -111, -111, -111, -111,
-111, -111, -111, -111, -110, -110, -111, -111, -111, -111, -110, -110, -111,
-110, -111, -109, -111, -110, -111, -108, -112, -109, -112, -108, -113, -107,
-115, -106, -117, -95, };