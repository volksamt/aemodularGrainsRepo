#define DATA_LENGTH 512
#define DATA AKWF_0553

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 9, 12, 14, 15, 19, 21, 23,
25, 28, 31, 32, 35, 37, 40, 43, 45, 48, 52, 53, 57, 59, 61, 65, 67, 69, 73, 75,
78, 80, 82, 84, 88, 90, 93, 95, 98, 101, 104, 107, 109, 113, 115, 118, 118, 117,
117, 115, 112, 111, 109, 108, 107, 105, 104, 101, 99, 97, 94, 94, 91, 89, 86,
84, 83, 81, 79, 77, 74, 73, 72, 70, 68, 66, 66, 63, 62, 61, 58, 57, 55, 52, 50,
47, 46, 43, 41, 39, 38, 36, 34, 32, 30, 28, 26, 24, 23, 21, 19, 17, 15, 12, 10,
8, 5, 3, 1, -1, -4, -6, -8, -10, -13, -15, -17, -20, -22, -24, -26, -28, -31,
-33, -36, -38, -41, -44, -45, -48, -50, -54, -57, -59, -60, -64, -66, -69, -71,
-74, -76, -79, -81, -84, -87, -89, -92, -94, -97, -100, -102, -105, -107, -110,
-113, -116, -118, -119, -118, -117, -115, -113, -111, -110, -108, -107, -105,
-104, -101, -100, -98, -96, -93, -92, -89, -87, -85, -83, -81, -79, -78, -76,
-74, -72, -71, -70, -68, -66, -64, -63, -62, -60, -57, -57, -54, -51, -50, -47,
-46, -44, -41, -40, -38, -36, -33, -32, -30, -28, -26, -25, -23, -21, -19, -17,
-15, -12, -11, -9, -7, -3, -4, 10, 47, 64, 80, 94, 105, 116, 116, 109, 104, 97,
90, 85, 79, 74, 69, 64, 59, 56, 50, 45, 40, 35, 32, 26, 23, 18, 14, 9, 4, -1,
-5, -10, -15, -19, -24, -28, -32, -38, -42, -47, -51, -56, -61, -66, -70, -74,
-79, -84, -88, -92, -98, -102, -106, -111, -115, -119, -118, -115, -112, -110,
-107, -104, -102, -99, -96, -91, -88, -86, -82, -80, -77, -75, -71, -69, -67,
-65, -62, -58, -57, -54, -50, -47, -44, -41, -38, -35, -32, -30, -27, -25, -23,
-19, -17, -13, -11, -8, -4, -1, 2, 6, 8, 11, 14, 17, 20, 23, 26, 29, 33, 36, 39,
43, 47, 49, 53, 56, 60, 63, 66, 70, 73, 76, 79, 83, 86, 89, 93, 96, 99, 102,
106, 109, 113, 115, 119, 118, 116, 115, 112, 110, 108, 106, 104, 102, 100, 98,
94, 91, 90, 87, 84, 82, 80, 78, 75, 73, 71, 69, 68, 66, 64, 62, 60, 58, 55, 52,
50, 48, 46, 43, 41, 37, 35, 33, 31, 29, 27, 26, 23, 20, 17, 16, 13, 11, 8, 5, 3,
0, -3, -5, -7, -11, -13, -16, -18, -21, -23, -26, -29, -31, -34, -36, -39, -42,
-45, -48, -51, -53, -57, -59, -62, -65, -68, -70, -74, -77, -80, -82, -85, -87,
-91, -94, -96, -99, -103, -105, -108, -111, -114, -117, -118, -118, -116, -115,
-113, -111, -110, -108, -106, -105, -102, -100, -98, -96, -93, -92, -89, -87,
-84, -81, -80, -78, -76, -75, -72, -71, -68, -67, -65, -64, -63, -60, -58, -56,
-54, -52, -49, -47, -45, -44, -41, -39, -37, -35, -33, -31, -29, -27, -25, -23,
-20, -19, -17, -14, -12, -10, -7, -5, -3, 0, };