#define DATA_LENGTH 512
#define DATA AKWF_0559

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -3, -8, -16, -26, -38, -50, -63,
-74, -85, -95, -103, -110, -115, -118, -119, -119, -117, -113, -109, -104, -98,
-92, -84, -76, -69, -61, -53, -46, -39, -33, -26, -21, -17, -12, -8, -6, -2, -1,
2, 3, 2, 3, 3, 4, 3, 2, 3, 2, 1, -1, 0, -1, -3, -2, -3, -3, -4, -4, -4, -5, -4,
-4, -4, -4, -3, -3, -3, -3, -3, -2, -2, -3, -3, -2, -1, -2, -2, -2, -1, -1, -2,
-1, -2, -2, -2, -1, -1, -1, -2, -2, -2, -1, -2, -2, -2, -1, -2, -2, -2, -1, -2,
-2, -1, -1, -2, -2, -1, -1, -1, -1, -2, -2, 0, -1, 0, -1, -1, -1, -1, -1, 0, -1,
-1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 2, 2, 1, 2, 2, 1, 2, 2, 2, 1, 2, 1, 2,
3, 2, 2, 2, 2, 3, 3, 3, 3, 3, 4, 3, 4, 4, 4, 4, 4, 4, 4, 5, 4, 4, 5, 4, 5, 4, 6,
5, 5, 5, 6, 6, 5, 6, 6, 7, 6, 6, 7, 7, 7, 6, 6, 7, 6, 8, 6, 7, 8, 8, 7, 8, 8, 8,
8, 8, 7, 8, 8, 7, 9, 8, 8, 8, 8, 9, 9, 9, 9, 9, 8, 9, 9, 8, 9, 9, 8, 9, 9, 10,
10, 10, 10, 9, 9, 9, 10, 10, 10, 10, 10, 11, 10, 9, 10, 10, 10, 11, 10, 11, 10,
11, 11, 10, 11, 10, 11, 10, 11, 12, 12, 11, 11, 11, 10, 11, 11, 11, 11, 11, 11,
10, 11, 11, 11, 11, 11, 10, 11, 11, 10, 11, 12, 11, 12, 11, 11, 11, 11, 11, 12,
11, 11, 11, 11, 10, 11, 11, 11, 12, 11, 11, 11, 11, 10, 11, 11, 11, 10, 10, 10,
11, 10, 11, 10, 10, 10, 10, 9, 11, 10, 10, 10, 10, 10, 10, 10, 10, 10, 10, 10,
10, 10, 10, 10, 10, 9, 9, 9, 9, 9, 9, 9, 10, 9, 9, 8, 9, 9, 9, 9, 9, 9, 8, 9, 9,
8, 9, 9, 9, 8, 8, 8, 8, 7, 8, 8, 8, 9, 8, 8, 8, 8, 7, 7, 7, 8, 7, 7, 7, 7, 7, 7,
7, 7, 7, 7, 6, 7, 7, 6, 7, 6, 7, 7, 5, 6, 6, 6, 6, 5, 6, 5, 6, 5, 5, 6, 5, 5, 5,
5, 5, 6, 5, 5, 5, 5, 4, 5, 5, 4, 4, 5, 4, 4, 4, 4, 4, 4, 4, 4, 3, 4, 4, 3, 3, 3,
4, 3, 4, 3, 4, 3, 3, 3, 3, 3, 3, 3, 3, 2, 2, 3, 3, 2, 3, 3, 2, 2, 2, 2, 2, 3, 2,
3, 2, 2, 2, 1, 3, 2, 2, 2, 2, 2, 2, 1, 2, 1, 2, 2, 1, 1, 2, 1, 1, 1, 2, 1, 2, 2,
1, 0, 2, 1, 1, 1, 0, 0, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 0, 0, 0, 0, };