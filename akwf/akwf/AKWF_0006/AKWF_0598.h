#define DATA_LENGTH 512
#define DATA AKWF_0598

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 10, 14, 19, 23, 27, 33, 37, 41,
46, 50, 55, 59, 62, 67, 71, 75, 78, 82, 84, 88, 90, 94, 96, 99, 101, 103, 105,
108, 109, 111, 113, 113, 115, 115, 117, 117, 117, 116, 117, 117, 116, 116, 115,
115, 113, 112, 110, 109, 106, 104, 102, 100, 98, 96, 93, 90, 87, 84, 81, 77, 74,
70, 67, 62, 59, 56, 51, 47, 42, 39, 34, 30, 26, 21, 18, 13, 8, 3, 0, -5, -9,
-14, -18, -21, -26, -30, -34, -38, -42, -46, -50, -53, -56, -59, -63, -66, -69,
-72, -75, -77, -80, -82, -85, -87, -89, -91, -92, -94, -96, -98, -98, -99, -100,
-100, -102, -101, -102, -101, -102, -101, -101, -100, -99, -99, -98, -96, -95,
-94, -92, -91, -87, -87, -84, -82, -79, -77, -73, -73, -68, -68, -62, -62, -56,
-54, -50, -48, -43, -42, -32, -34, -32, -22, -23, -16, -17, -7, -13, 3, -15, 64,
10, -71, 9, 1, 13, 13, 20, 22, 27, 30, 33, 36, 37, 41, 42, 46, 46, 48, 48, 51,
50, 52, 50, 52, 50, 52, 50, 50, 48, 48, 46, 45, 43, 42, 39, 37, 35, 33, 31, 28,
26, 23, 21, 19, 16, 12, 11, 8, 5, 3, 0, -2, -5, -8, -10, -12, -14, -17, -19,
-20, -22, -24, -26, -28, -28, -30, -30, -32, -32, -33, -34, -33, -34, -34, -34,
-33, -34, -33, -33, -32, -30, -30, -29, -28, -26, -25, -24, -21, -20, -18, -16,
-16, -13, -10, -9, -7, -5, -2, -1, 1, 2, 3, 5, 7, 8, 9, 11, 11, 13, 14, 15, 17,
19, 19, 21, 21, 22, 24, 24, 25, 26, 28, 28, 29, 31, 30, 31, 33, 32, 33, 33, 34,
35, 35, 34, 35, 35, 36, 35, 36, 35, 34, 35, 35, 34, 35, 34, 32, 32, 31, 31, 30,
29, 29, 27, 26, 25, 23, 23, 21, 21, 19, 17, 17, 15, 14, 11, 10, 9, 7, 6, 4, 1,
0, -1, -4, -5, -7, -9, -11, -12, -14, -17, -18, -20, -21, -24, -24, -27, -29,
-30, -32, -34, -34, -36, -37, -39, -40, -42, -43, -43, -45, -46, -46, -48, -48,
-50, -50, -50, -50, -51, -51, -51, -51, -51, -51, -51, -50, -50, -50, -48, -50,
-47, -48, -45, -46, -43, -43, -41, -41, -37, -39, -34, -35, -31, -34, -31, -24,
-27, -25, -22, -19, -18, -13, -13, -6, -11, 2, -10, 68, -2, -68, 13, 0, 16, 15,
25, 27, 35, 39, 45, 51, 56, 62, 66, 72, 75, 81, 84, 88, 90, 95, 96, 99, 101,
103, 102, 104, 104, 104, 101, 101, 99, 96, 94, 91, 88, 83, 80, 75, 70, 64, 59,
53, 46, 39, 34, 26, 19, 12, 6, -3, -10, -17, -24, -32, -39, -46, -53, -59, -65,
-71, -77, -83, -88, -93, -98, -101, -106, -109, -112, -114, -116, -117, -119,
-119, -120, -118, -117, -115, -114, -112, -109, -106, -102, -97, -92, -88, -83,
-76, -70, -64, -57, -50, -44, -37, -29, -21, -14, -5, };