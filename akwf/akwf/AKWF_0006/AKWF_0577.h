#define DATA_LENGTH 512
#define DATA AKWF_0577

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 10, 13, 16, 19, 22, 26, 29,
32, 35, 39, 40, 45, 47, 51, 53, 58, 59, 63, 64, 70, 69, 82, 112, 107, 108, 106,
104, 103, 102, 100, 99, 98, 96, 95, 94, 92, 90, 90, 88, 87, 85, 84, 82, 81, 80,
79, 77, 76, 74, 73, 71, 70, 70, 68, 66, 65, 64, 62, 61, 59, 59, 57, 56, 54, 53,
52, 50, 49, 47, 45, 44, 43, 42, 40, 40, 39, 37, 35, 35, 33, 32, 29, 28, 28, 26,
24, 23, 21, 21, 19, 17, 16, 15, 13, 13, 12, 10, 9, 7, 6, 4, 2, 1, 0, -1, -2, -3,
-5, -7, -6, -6, -7, -6, -6, -6, -7, -6, -6, -6, -6, -6, -6, -7, -6, -6, -7, -7,
-7, -6, -7, -7, -7, -7, -6, -6, -6, -6, -6, -6, -6, -6, -7, -6, -7, -6, -7, -6,
-7, -6, -6, -7, -6, -6, -6, -6, -6, -6, -7, -6, -7, -6, -6, -7, -7, -7, -6, -6,
-7, -6, -7, -6, -6, -6, -6, -7, -6, -7, -7, -6, -6, -6, -6, -6, -7, -7, -6, -6,
-6, -6, -7, -7, -7, -6, -6, -7, -6, -6, -6, -6, -6, -7, -6, -6, -6, -6, -6, -6,
-7, -7, -6, -6, -6, -6, -6, -6, -7, -6, -6, -6, -6, -6, -6, -6, -6, -7, -6, -5,
-6, -6, -6, -6, -7, -6, -6, -6, -7, -6, -6, -6, -6, -6, -6, -6, -6, -6, -7, -6,
-6, -6, -7, -6, -7, -6, -7, -6, -7, -6, -7, -6, -6, -5, -6, -5, -7, -7, -6, -7,
-6, -7, -7, -6, -6, -6, -6, -6, -7, -6, -6, -5, -6, -6, -6, -6, -7, -6, -7, -7,
-6, -6, -6, -7, -6, -6, -6, -7, -6, -6, -6, -6, -6, -6, -6, -6, -6, -7, -6, -5,
-6, -6, -6, -6, -6, -6, -6, -7, -6, -5, -6, -6, -6, -5, -6, -7, -6, -6, -6, -7,
-6, -6, -6, -6, -6, -7, -6, -6, -6, -6, -6, -6, -6, -6, -7, -6, -6, -6, -6, -6,
-6, -6, -6, -6, -6, -5, -6, -6, -7, -6, -6, -7, -5, -7, -5, -6, -6, -6, -6, -6,
-6, -6, -6, -6, -5, -6, -6, -6, -6, -6, -6, -6, -7, -6, -7, -8, -9, -12, -13,
-16, -16, -18, -20, -22, -23, -25, -27, -29, -30, -32, -34, -35, -37, -39, -40,
-42, -44, -45, -48, -49, -51, -53, -54, -56, -57, -58, -61, -63, -65, -66, -67,
-69, -71, -73, -74, -76, -78, -79, -80, -83, -84, -88, -87, -91, -90, -95, -93,
-98, -98, -101, -101, -103, -104, -107, -108, -110, -113, -111, -119, -111,
-128, -38, 8, -9, 5, -3, 5, 2, 7, 4, 8, 9, 12, 11, 13, 15, 16, 17, 19, 20, 21,
22, 23, 26, 27, 28, 30, 31, 32, 33, 35, 36, 38, 37, 41, 40, 43, 45, 44, 48, 45,
58, -33, -66, -46, -54, -43, -46, -37, -40, -33, -32, -27, -26, -21, -20, -16,
-14, -10, -7, -3, -1, };