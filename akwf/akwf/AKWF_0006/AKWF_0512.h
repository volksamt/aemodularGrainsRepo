#define DATA_LENGTH 512
#define DATA AKWF_0512

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 5, 7, 9, 10, 12, 15, 15, 18,
18, 24, 18, 33, -20, -65, -47, -54, -46, -49, -45, -45, -41, -41, -38, -37, -35,
-34, -32, -30, -29, -26, -25, -22, -21, -20, -18, -16, -16, -13, -12, -9, -10,
-5, -5, -2, -2, 1, 1, 4, 4, 9, 8, 11, 12, 14, 16, -56, -65, -58, -61, -56, -57,
-52, -54, -48, -50, -45, -46, -43, -43, -39, -39, -35, -35, -33, -32, -29, -28,
-26, -25, -23, -20, -19, -17, -17, -14, -13, -11, -10, -7, -7, -3, -5, 1, -2, 6,
0, 14, -14, -79, -67, -71, -66, -66, -63, -61, -60, -58, -57, -55, -54, -50,
-50, -47, -47, -43, -44, -41, -41, -37, -37, -34, -33, -31, -30, -27, -26, -24,
-23, -21, -19, -17, -16, -14, -12, -11, -9, -7, -5, -4, -2, 0, 2, 2, 4, 6, 9,
11, 11, 14, 15, 16, 18, 21, 21, 24, 25, 26, 28, 30, 32, 33, 35, 36, 39, 40, 42,
44, 46, 47, 49, 50, 53, 52, 57, 56, 60, 60, 64, 63, 67, 67, 70, 69, -4, -10, -3,
-5, -1, -2, 3, 2, 7, 6, 9, 9, 14, 13, 16, 16, 20, 20, 22, 23, 26, 27, 29, 30,
32, 33, 35, 38, 39, 42, 42, 45, 45, 49, 48, 53, 51, 56, 53, 62, 55, 70, 37, -26,
-11, -16, -10, -10, -8, -7, -4, -4, -2, 0, 2, 5, 5, 7, 8, 11, 11, 14, 15, 18,
18, 21, 22, 24, 25, 29, 29, 31, 31, 34, 35, 38, 39, 41, 44, 44, 47, 46, 51, 47,
62, -1, -34, -19, -25, -17, -20, -15, -17, -12, -13, -9, -8, -6, -5, -3, -1, 0,
2, 4, 6, 7, 9, 11, 13, 14, 16, 18, 19, 21, 22, 24, 26, 28, 29, 32, 32, 35, 36,
38, 40, 42, 44, 44, 47, 48, 50, 53, 53, 56, 56, 58, 61, 62, 63, 66, 67, 68, 71,
71, 74, 75, 77, 79, 81, 82, 85, 86, 88, 88, 91, 93, 94, 97, 98, 99, 101, 103,
103, 107, 107, 112, 109, 116, 109, 125, 88, 29, 45, 39, 46, 43, 48, 48, 51, 52,
54, 56, 57, 58, 60, 63, 63, 67, 66, 70, 70, 74, 73, 77, 76, 80, 79, 85, 82, 88,
86, 91, 89, 95, 94, 97, 98, 100, 103, 102, 109, 97, 127, -54, -128, -94, -115,
-96, -107, -95, -104, -93, -98, -91, -94, -89, -90, -87, -86, -83, -82, -80,
-78, -77, -74, -74, -71, -70, -67, -68, -63, -64, -60, -61, -56, -58, -53, -54,
-49, -51, -46, -48, -42, -45, -37, -47, -120, -117, -115, -114, -111, -111,
-108, -108, -104, -104, -101, -101, -98, -97, -95, -94, -92, -90, -88, -88, -84,
-83, -81, -80, -78, -75, -75, -72, -71, -70, -68, -66, -64, -62, -61, -59, -57,
-55, -54, -52, -50, -49, -48, -45, -44, -41, -41, -38, -37, -36, -33, -32, -30,
-28, -27, -25, -24, -22, -20, -18, -17, -14, -13, -12, -9, -8, -6, -4, -3, -1,
};