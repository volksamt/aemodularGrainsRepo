#define DATA_LENGTH 512
#define DATA AKWF_0572

const PROGMEM int8_t DATA[DATA_LENGTH] = {17, 29, 34, 40, 45, 49, 53, 57, 61,
64, 66, 70, 73, 74, 77, 80, 81, 83, 86, 88, 89, 91, 93, 94, 97, 98, 99, 100,
102, 103, 105, 105, 107, 108, 108, 110, 111, 111, 112, 112, 113, 114, 114, 115,
115, 115, 115, 115, 116, 116, 115, 117, 119, 117, 117, 118, 118, 118, 117, 117,
117, 117, 117, 117, 117, 116, 116, 116, 116, 116, 116, 115, 116, 115, 115, 116,
115, 116, 115, 115, 115, 114, 115, 116, 115, 115, 115, 115, 115, 114, 115, 115,
115, 114, 115, 115, 115, 114, 114, 114, 114, 114, 114, 114, 114, 115, 114, 114,
114, 114, 114, 114, 115, 113, 114, 114, 113, 113, 114, 113, 114, 114, 113, 113,
113, 114, 113, 114, 114, 113, 113, 113, 112, 113, 113, 113, 112, 113, 113, 112,
113, 113, 113, 113, 113, 112, 112, 112, 112, 112, 113, 112, 112, 112, 112, 113,
112, 112, 113, 112, 112, 112, 112, 112, 112, 112, 112, 112, 113, 113, 113, 113,
112, 112, 113, 112, 112, 112, 112, 112, 112, 112, 112, 112, 112, 112, 112, 112,
112, 112, 112, 111, 112, 112, 113, 112, 112, 112, 112, 112, 112, 112, 111, 112,
112, 112, 112, 112, 112, 112, 112, 112, 112, 113, 112, 113, 112, 112, 112, 112,
112, 113, 111, 112, 112, 112, 112, 113, 112, 112, 112, 113, 113, 112, 112, 113,
112, 113, 113, 113, 113, 112, 112, 112, 113, 113, 112, 112, 113, 113, 113, 113,
113, 113, 113, 113, 111, 103, 100, 96, 93, 92, 91, 87, 87, 85, 84, 82, 81, 79,
79, 77, 76, 75, 74, 72, 72, 71, 71, 70, 68, 68, 67, 67, 65, 65, 64, 63, 62, 62,
61, 60, 60, 58, 59, 58, 58, 57, 56, 55, 54, 54, 54, 54, 53, 53, 52, 52, 50, 49,
49, 48, 46, 46, 44, 45, 44, 43, 42, 42, 41, 40, 40, 39, 38, 38, 37, 37, 36, 35,
35, 35, 34, 34, 33, 32, 32, 32, 30, 31, 30, 30, 29, 28, 28, 27, 27, 27, 26, 26,
25, 25, 24, 24, 24, 23, 23, 23, 22, 22, 22, 20, 21, 19, 20, 19, 19, 18, 18, 18,
17, 16, 17, 16, 15, 16, 15, 14, 15, 14, 14, 14, 13, 14, 12, 12, 12, 11, 11, 11,
11, 11, 10, 10, 10, 10, 8, 8, 9, 8, 7, 8, 8, 7, 7, 6, 6, 6, 5, 5, 5, 5, 5, 5, 5,
4, 5, 4, 4, 4, 4, 4, 3, 3, 3, 2, 2, 3, 3, 2, 3, 2, 2, 2, 2, 2, 1, 1, 1, 1, 1, 1,
1, 0, 1, 1, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 1, 0, -1, -1, 0, 1, 0, 0, 0,
-1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, -1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, -1, 0, 0, -1, 0, 0, };