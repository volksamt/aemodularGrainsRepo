#define DATA_LENGTH 512
#define DATA AKWF_0501

const PROGMEM int8_t DATA[DATA_LENGTH] = {99, 119, 109, 116, 110, 115, 111, 116,
112, 115, 112, 114, 111, 114, 112, 114, 113, 114, 112, 113, 112, 113, 113, 113,
113, 112, 113, 113, 113, 113, 113, 113, 113, 112, 113, 113, 114, 113, 113, 113,
113, 112, 113, 112, 114, 112, 112, 113, 114, 112, 112, 113, 112, 112, 113, 113,
113, 113, 112, 113, 113, 112, 113, 112, 113, 113, 112, 113, 112, 112, 112, 112,
112, 113, 112, 112, 112, 112, 112, 112, 112, 113, 112, 113, 112, 113, 112, 112,
112, 112, 112, 112, 113, 112, 112, 112, 112, 112, 112, 112, 113, 111, 113, 112,
112, 112, 111, 112, 112, 112, 112, 112, 112, 111, 112, 112, 111, 112, 112, 112,
111, 112, 112, 112, 112, 112, 112, 112, 111, 112, 112, 112, 111, 111, 111, 111,
111, 111, 112, 111, 112, 111, 111, 111, 111, 111, 111, 111, 111, 111, 112, 111,
112, 111, 112, 111, 111, 112, 111, 111, 111, 112, 111, 110, 111, 111, 112, 111,
111, 111, 111, 111, 112, 111, 111, 111, 111, 111, 111, 111, 111, 111, 110, 110,
110, 111, 111, 111, 110, 110, 111, 110, 111, 111, 110, 111, 110, 111, 111, 110,
111, 111, 111, 110, 110, 111, 111, 111, 110, 110, 111, 111, 110, 111, 110, 110,
110, 110, 111, 110, 110, 110, 110, 111, 110, 111, 110, 110, 109, 111, 108, 112,
108, 111, 109, 111, 109, 112, 108, 112, 109, 111, 109, 109, 110, 108, 111, 108,
113, 105, 118, 96, 127, -27, -128, -104, -128, -111, -124, -114, -122, -116,
-120, -118, -120, -119, -120, -120, -119, -119, -118, -120, -119, -120, -119,
-120, -118, -120, -118, -120, -118, -120, -118, -119, -118, -120, -118, -119,
-119, -119, -118, -119, -119, -119, -120, -119, -119, -118, -119, -119, -119,
-118, -119, -118, -119, -118, -119, -119, -118, -119, -118, -118, -118, -117,
-119, -118, -119, -118, -119, -118, -120, -118, -119, -118, -119, -118, -119,
-119, -118, -118, -118, -119, -117, -120, -115, -122, -113, -126, -105, -128,
17, 127, 93, 124, 98, 122, 99, 124, 93, 127, 29, -128, -107, -125, -114, -121,
-116, -119, -117, -118, -118, -118, -118, -117, -118, -117, -119, -117, -118,
-117, -119, -117, -119, -117, -119, -118, -119, -117, -118, -118, -118, -117,
-118, -118, -117, -119, -118, -118, -117, -118, -117, -118, -118, -117, -117,
-118, -117, -117, -118, -117, -117, -118, -118, -117, -118, -117, -117, -117,
-117, -117, -117, -117, -117, -117, -117, -118, -117, -117, -117, -117, -118,
-117, -117, -117, -117, -117, -117, -117, -118, -117, -117, -117, -117, -117,
-117, -117, -117, -117, -117, -117, -117, -116, -117, -116, -118, -117, -116,
-117, -116, -117, -116, -117, -117, -117, -117, -117, -116, -117, -117, -116,
-116, -117, -116, -117, -116, -117, -116, -117, -117, -116, -117, -116, -116,
-117, -116, -117, -117, -117, -115, -116, -116, -116, -116, -117, -116, -116,
-116, -116, -116, -116, -116, -116, -116, -116, -116, -116, -117, -114, -117,
-115, -117, -115, -117, -113, -117, -113, -118, -112, -120, -111, -123, -99, };