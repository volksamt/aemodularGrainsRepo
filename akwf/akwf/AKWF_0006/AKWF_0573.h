#define DATA_LENGTH 512
#define DATA AKWF_0573

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 17, 33, 48, 62, 74, 85, 95, 102,
106, 109, 109, 109, 108, 109, 109, 108, 109, 109, 109, 108, 109, 108, 109, 109,
109, 109, 109, 109, 108, 108, 109, 109, 109, 109, 109, 108, 109, 109, 108, 109,
108, 108, 109, 109, 109, 108, 109, 109, 109, 109, 109, 109, 109, 108, 109, 108,
109, 108, 108, 109, 109, 109, 108, 109, 108, 108, 108, 108, 109, 108, 108, 108,
108, 108, 108, 108, 109, 108, 108, 108, 109, 108, 109, 108, 109, 108, 108, 109,
108, 108, 108, 108, 109, 109, 108, 108, 108, 108, 107, 108, 108, 108, 108, 108,
108, 108, 108, 108, 108, 108, 108, 107, 108, 108, 108, 108, 107, 107, 107, 107,
108, 107, 108, 107, 106, 107, 107, 107, 107, 106, 106, 107, 107, 107, 106, 106,
106, 107, 106, 107, 106, 106, 106, 106, 107, 106, 106, 105, 106, 106, 106, 105,
105, 106, 105, 104, 106, 105, 105, 105, 105, 105, 105, 104, 105, 105, 105, 104,
104, 104, 103, 104, 104, 104, 104, 103, 104, 103, 104, 104, 104, 104, 103, 103,
103, 103, 103, 103, 102, 103, 103, 102, 102, 102, 102, 102, 102, 103, 102, 102,
102, 102, 102, 102, 101, 103, 102, 102, 101, 102, 101, 101, 102, 101, 101, 102,
102, 101, 102, 101, 101, 102, 102, 101, 101, 101, 102, 102, 101, 101, 102, 102,
101, 101, 102, 101, 101, 101, 101, 101, 101, 101, 101, 101, 101, 102, 101, 102,
102, 102, 101, 101, 101, 102, 101, 102, 101, 101, 100, 101, 101, 101, 102, 100,
101, 101, 102, 101, 101, 101, 101, 101, 101, 101, 101, 101, 100, 100, 101, 101,
100, 100, 100, 100, 100, 100, 100, 100, 100, 100, 99, 100, 100, 99, 99, 99, 99,
99, 98, 99, 98, 98, 97, 97, 98, 97, 97, 96, 96, 96, 96, 95, 95, 95, 94, 94, 94,
94, 93, 93, 92, 93, 92, 92, 91, 91, 90, 90, 90, 89, 89, 89, 88, 87, 86, 86, 85,
85, 85, 84, 83, 83, 82, 82, 82, 81, 79, 79, 78, 77, 77, 76, 75, 74, 73, 72, 73,
71, 71, 69, 69, 68, 68, 66, 65, 64, 63, 62, 62, 62, 61, 59, 58, 57, 55, 55, 54,
53, 53, 51, 51, 49, 48, 48, 47, 45, 44, 42, 42, 41, 40, 39, 38, 37, 35, 35, 34,
32, 32, 31, 29, 28, 27, 27, 26, 24, 22, 21, 21, 19, 19, 17, 15, 14, 14, 12, 11,
10, 10, 8, 8, 5, 6, 3, 3, 2, 2, 0, 0, -2, -3, -4, -6, -5, -7, -7, -8, -9, -11,
-10, -12, -11, -14, -13, -16, -13, -16, -14, -17, -16, -19, -17, -19, -18, -19,
-19, -16, -106, -122, -112, -119, -113, -119, -113, -118, -115, -117, -115,
-117, -114, -116, -115, -116, -115, -115, -114, -114, -114, -112, -112, -112,
-112, -110, -110, -109, -110, -110, -109, -109, -109, -108, -109, -109, -108,
-108, -108, -107, -107, -105, -104, -102, -99, -93, -87, -81, -73, -62, -50,
-38, -25, -9, };