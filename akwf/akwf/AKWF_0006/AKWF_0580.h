#define DATA_LENGTH 512
#define DATA AKWF_0580

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 0, 0, 1, 1, 0, 0, 0, 1, 0, 0, 1,
0, 0, 0, 1, 1, 0, 1, 0, 1, 0, 1, 1, 1, 0, 0, 1, 0, 1, 0, 1, 1, 0, 0, 1, 1, 1, 1,
1, 1, 0, 0, 0, 1, 0, 1, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 0, 1,
1, 1, 1, 3, 6, 8, 11, 14, 16, 19, 21, 25, 28, 30, 32, 35, 38, 41, 43, 46, 48,
51, 54, 57, 60, 62, 65, 68, 70, 73, 75, 78, 81, 83, 86, 89, 91, 94, 96, 100,
102, 104, 108, 109, 113, 115, 118, 119, 115, 113, 109, 107, 104, 102, 98, 95,
93, 90, 88, 85, 83, 80, 77, 74, 72, 68, 66, 63, 61, 58, 56, 52, 51, 47, 45, 42,
40, 36, 34, 31, 28, 26, 23, 21, 18, 15, 13, 10, 6, 5, 1, -1, -1, 0, 0, -1, 0, 0,
0, -1, -1, 0, -1, 0, -1, 0, 0, 0, -1, -1, 0, -1, -1, -1, -1, -1, -1, -1, -2, -1,
-1, 0, -1, -1, 0, -1, -1, -1, 0, 0, -1, -1, -1, 0, -1, -1, -1, 0, 0, -1, -1, 0,
-1, 0, -1, -1, -1, -1, -1, -1, -1, -1, -3, -5, -7, -10, -12, -14, -16, -19, -21,
-23, -27, -28, -31, -34, -36, -39, -40, -43, -46, -48, -50, -53, -55, -57, -60,
-63, -64, -67, -70, -71, -73, -77, -79, -81, -83, -86, -88, -91, -92, -96, -98,
-99, -103, -105, -106, -104, -101, -98, -96, -94, -91, -87, -86, -84, -81, -78,
-76, -74, -71, -69, -66, -64, -62, -60, -58, -55, -52, -50, -47, -45, -43, -41,
-38, -36, -33, -31, -28, -26, -24, -21, -19, -17, -15, 3, 3, -2, 6, 10, 14, 16,
19, 21, 24, 26, 29, 30, 33, 35, 38, 40, 43, 45, 46, 50, 52, 54, 56, 59, 61, 63,
66, 68, 70, 73, 74, 78, 79, 82, 85, 86, 89, 91, 94, 96, 99, 101, 103, 103, 100,
98, 96, 93, 91, 89, 86, 85, 81, 79, 77, 75, 72, 70, 67, 65, 63, 60, 58, 56, 53,
51, 48, 47, 43, 42, 39, 37, 34, 31, 30, 27, 25, 23, 20, 18, 16, 13, 11, 8, 7, 4,
1, -1, 0, -1, 0, 0, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1,
-1, -1, 0, -1, -1, 0, -1, -1, -1, -2, -1, 0, 0, -1, -2, -6, -8, -11, -14, -15,
-19, -21, -25, -27, -30, -32, -34, -37, -39, -42, -45, -47, -50, -53, -56, -57,
-60, -63, -66, -68, -70, -73, -76, -78, -81, -83, -86, -89, -91, -94, -97, -98,
-102, -105, -107, -109, -112, -115, -114, -111, -109, -106, -104, -102, -98,
-95, -93, -90, -88, -86, -83, -79, -77, -75, -73, -70, -67, -65, -62, -59, -56,
-53, -52, -49, -46, -43, -41, -38, -35, -33, -30, -28, -25, -23, -20, -17, -14,
-12, -10, -6, -4, -2, };