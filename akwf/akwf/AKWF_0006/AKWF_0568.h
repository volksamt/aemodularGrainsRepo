#define DATA_LENGTH 512
#define DATA AKWF_0568

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 11, 15, 21, 25, 29, 32, 37, 39, 42,
45, 48, 50, 52, 55, 57, 59, 61, 63, 64, 66, 69, 70, 71, 73, 74, 75, 77, 78, 79,
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 91, 92, 92, 94, 94, 95, 95, 96, 96, 97,
97, 98, 99, 99, 99, 100, 100, 100, 101, 101, 102, 102, 103, 102, 103, 103, 104,
103, 104, 104, 104, 103, 104, 104, 44, 14, 8, -3, -9, -17, -20, -26, -30, -35,
-37, -42, -44, -48, -51, -53, -56, -59, -61, -63, -65, -67, -69, -71, -73, -74,
-77, -77, -80, -81, -83, -84, -85, -86, -88, -89, -90, -91, -92, -94, -95, -95,
-97, -98, -98, -101, -100, -101, -102, -103, -104, -105, -104, -107, -106, -108,
-107, -108, -109, -109, -110, -111, -111, -111, -112, -112, -113, -112, -113,
-113, -113, -113, -115, -113, -115, -114, -115, -113, -117, -111, -120, -85,
-29, -22, -7, -2, 7, 11, 17, 22, 25, 29, 33, 37, 39, 42, 45, 49, 51, 53, 55, 58,
59, 62, 63, 65, 67, 69, 69, 72, 73, 75, 77, 77, 79, 81, 81, 83, 84, 85, 85, 86,
87, 88, 90, 90, 92, 92, 92, 94, 94, 94, 95, 95, 96, 97, 97, 97, 98, 99, 99, 99,
100, 100, 100, 99, 100, 99, 101, 98, 104, 76, 37, 32, 21, 19, 12, 9, 4, 1, -1,
-5, -8, -10, -13, -14, -16, -19, -20, -23, -24, -27, -27, -29, -30, -32, -33,
-35, -35, -37, -38, -40, -41, -41, -43, -43, -44, -46, -46, -47, -48, -48, -50,
-51, -52, -52, -54, -54, -55, -56, -56, -56, -58, -59, -58, -59, -60, -60, -61,
-62, -61, -62, -63, -63, -63, -64, -65, -65, -65, -66, -65, -67, -67, -68, -68,
-69, -68, -68, -68, -68, -70, -70, -70, -70, -70, -70, -70, -71, -70, -71, -71,
-71, -71, -70, -72, -70, -73, -70, -75, -56, -24, -19, -11, -8, -3, -1, 2, 6, 8,
10, 12, 14, 16, 18, 19, 21, 22, 24, 25, 26, 27, 29, 30, 30, 31, 33, 34, 34, 35,
37, 38, 39, 39, 40, 41, 42, 42, 43, 44, 44, 45, 46, 46, 46, 47, 48, 47, 48, 49,
49, 50, 49, 51, 51, 51, 52, 52, 52, 52, 53, 54, 54, 54, 54, 54, 55, 56, 55, 56,
56, 56, 56, 57, 56, 57, 56, 57, 57, 57, 57, 57, 57, 57, 58, 56, 58, 24, 3, 0,
-9, -10, -16, -19, -23, -25, -28, -30, -33, -35, -37, -39, -41, -42, -44, -45,
-47, -49, -50, -52, -52, -54, -56, -57, -58, -60, -60, -62, -63, -65, -65, -67,
-68, -69, -70, -71, -72, -72, -73, -75, -76, -77, -78, -78, -80, -81, -81, -82,
-83, -84, -85, -85, -86, -87, -88, -89, -90, -90, -90, -91, -91, -92, -91, -93,
-92, -93, -92, -93, -94, -94, -94, -95, -95, -95, -94, -95, -96, -95, -96, -96,
-96, -96, -97, -96, -97, -96, -97, -97, -97, -96, -99, -96, -99, -95, -102, -78,
-22, -15, 0, };