#define DATA_LENGTH 512
#define DATA AKWF_0567

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 11, 15, 19, 23, 27, 30, 34, 36, 39,
42, 44, 46, 49, 51, 53, 55, 56, 58, 60, 62, 62, 63, 65, 66, 67, 68, 70, 71, 71,
73, 74, 75, 75, 76, 75, 78, 77, 79, 79, 80, 80, 80, 81, 81, 81, 82, 82, 82, 82,
83, 82, 82, 83, 81, 90, 102, 102, 106, 105, 107, 107, 108, 109, 110, 110, 110,
112, 112, 111, 112, 112, 113, 112, 114, 113, 114, 113, 114, 115, 114, 115, 114,
119, 115, 123, 53, 13, 11, -5, -7, -17, -19, -26, -29, -35, -36, -41, -44, -47,
-49, -53, -55, -58, -60, -62, -64, -66, -68, -70, -72, -72, -76, -76, -79, -80,
-81, -82, -84, -86, -87, -88, -89, -90, -92, -92, -94, -94, -96, -96, -98, -98,
-99, -101, -101, -102, -103, -103, -104, -105, -105, -106, -106, -107, -108,
-108, -109, -108, -109, -110, -111, -111, -111, -112, -112, -113, -113, -113,
-113, -113, -114, -114, -114, -115, -114, -114, -114, -115, -114, -115, -114,
-116, -113, -111, -112, -111, -111, -110, -112, -92, -81, -80, -76, -75, -71,
-72, -69, -70, -67, -68, -66, -65, -64, -63, -63, -63, -62, -61, -62, -60, -61,
-59, -60, -58, -60, -59, -59, -58, -59, -58, -58, -58, -57, -60, 1, 28, 31, 43,
44, 51, 54, 59, 60, 65, 67, 70, 71, 75, 76, 78, 79, 81, 82, 84, 84, 86, 86, 88,
89, 90, 90, 91, 91, 92, 92, 92, 93, 93, 92, 94, 108, 109, 111, 112, 113, 114,
115, 115, 116, 117, 117, 118, 118, 120, 117, 121, 116, 123, 114, 127, 77, 20,
20, 3, 2, -10, -12, -19, -22, -26, -29, -33, -36, -39, -43, -45, -48, -50, -53,
-54, -57, -59, -62, -62, -65, -66, -69, -69, -71, -73, -76, -75, -78, -79, -80,
-82, -83, -84, -85, -87, -88, -89, -89, -91, -92, -93, -94, -95, -96, -97, -98,
-98, -100, -101, -101, -101, -102, -103, -104, -105, -106, -106, -107, -108,
-108, -109, -109, -110, -110, -110, -111, -112, -112, -112, -113, -113, -114,
-114, -114, -115, -115, -115, -116, -115, -115, -115, -117, -115, -115, -115,
-111, -109, -109, -108, -109, -108, -108, -107, -105, -110, -79, -58, -58, -51,
-49, -44, -43, -40, -40, -36, -36, -34, -33, -31, -31, -29, -28, -27, -26, -25,
-24, -24, -23, -23, -23, -23, -21, -22, -21, -20, -20, -21, -19, -21, -19, -21,
-17, -21, 12, 54, 57, 65, 68, 73, 76, 80, 82, 84, 87, 88, 91, 93, 95, 95, 97,
98, 99, 101, 102, 103, 104, 105, 105, 107, 107, 108, 108, 110, 110, 110, 111,
111, 112, 112, 112, 112, 113, 113, 114, 113, 116, 113, 116, 112, 118, 112, 119,
114, 124, 101, 4, -8, -23, -32, -41, -48, -53, -60, -63, -70, -72, -78, -79,
-83, -86, -90, -91, -94, -97, -98, -100, -102, -104, -105, -108, -108, -110,
-110, -111, -112, -113, -113, -115, -115, -116, -115, -117, -116, -112, -109,
-109, -109, -108, -109, -106, -110, -103, -115, -66, -14, -14, 1, };