#define DATA_LENGTH 512
#define DATA AKWF_0592

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 3, 3, 3, 4, 5, 5, 7, 6, 8, 8,
8, 10, 10, 11, 12, 12, 13, 13, 14, 15, 15, 16, 16, 17, 17, 19, 19, 19, 21, 21,
21, 22, 23, 23, 24, 25, 25, 25, 27, 27, 27, 28, 28, 29, 31, 31, 31, 32, 33, 33,
34, 35, 35, 35, 37, 38, 39, 39, 39, 40, 40, 41, 42, 43, 43, 43, 46, 43, 37, 31,
26, 24, 24, 24, 25, 25, 25, 25, 25, 25, 24, 25, 25, 25, 26, 26, 26, 25, 26, 26,
26, 26, 26, 26, 26, 26, 25, 26, 27, 26, 27, 27, 26, 27, 27, 27, 28, 27, 28, 27,
28, 28, 28, 27, 28, 27, 28, 28, 28, 29, 29, 28, 29, 28, 28, 29, 29, 29, 30, 30,
29, 29, 30, 29, 29, 29, 29, 29, 30, 30, 30, 30, 30, 31, 30, 30, 31, 30, 31, 31,
31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 32, 31, 32, 32, 31, 31, 32, 32, 32, 32,
32, 33, 33, 32, 32, 32, 34, 32, 32, 32, 34, 34, 33, 33, 33, 34, 33, 33, 34, 34,
34, 34, 35, 34, 34, 34, 35, 34, 35, 35, 34, 35, 35, 35, 34, 35, 35, 34, 36, 35,
36, 36, 36, 36, 35, 37, 35, 36, 36, 36, 36, 37, 36, 37, 37, 37, 37, 36, 37, 37,
37, 37, 37, 37, 37, 37, 37, 37, 38, 37, 37, 37, 38, 37, 39, 38, 38, 38, 38, 39,
39, 39, 39, 38, 39, 39, 39, 39, 39, 39, 39, 40, 39, 39, 40, 39, 40, 40, 40, 41,
39, 40, 40, 40, 41, 40, 41, 41, 41, 41, 41, 41, 41, 41, 41, 41, 42, 41, 42, 41,
42, 42, 41, 43, 42, 42, 43, 42, 43, 43, 43, 42, 43, 43, 43, 43, 43, 43, 43, 43,
43, 43, 44, 44, 44, 44, 44, 45, 44, 44, 45, 45, 44, 38, 31, 23, 6, -18, -39,
-63, -84, -111, -121, -117, -113, -112, -112, -110, -111, -110, -110, -108,
-108, -108, -107, -106, -106, -104, -105, -103, -103, -103, -101, -101, -100,
-100, -99, -98, -98, -98, -97, -95, -95, -95, -94, -92, -92, -92, -91, -90, -91,
-90, -89, -88, -87, -86, -85, -85, -85, -84, -84, -83, -81, -81, -80, -80, -80,
-79, -78, -78, -77, -76, -76, -74, -74, -73, -72, -72, -72, -71, -71, -70, -68,
-68, -67, -67, -65, -66, -64, -65, -64, -62, -62, -62, -61, -61, -60, -59, -57,
-57, -57, -57, -56, -55, -54, -54, -53, -53, -51, -51, -51, -50, -49, -48, -48,
-47, -46, -46, -45, -45, -43, -44, -42, -42, -42, -41, -39, -39, -38, -39, -37,
-38, -36, -35, -35, -35, -34, -32, -33, -32, -31, -30, -30, -29, -28, -28, -27,
-27, -27, -25, -25, -24, -23, -22, -22, -22, -21, -20, -19, -19, -18, -18, -17,
-16, -16, -14, -15, -14, -13, -12, -11, -11, -10, -9, -10, -8, -8, -6, -6, -6,
-5, -5, -5, -3, -2, -2, -1, -1, -1, };