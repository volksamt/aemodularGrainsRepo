#define DATA_LENGTH 512
#define DATA AKWF_0504

const PROGMEM int8_t DATA[DATA_LENGTH] = {73, 87, 81, 86, 81, 85, 82, 85, 81,
85, 82, 84, 83, 84, 82, 84, 83, 84, 84, 84, 83, 83, 84, 84, 84, 83, 83, 83, 83,
83, 83, 82, 83, 82, 83, 83, 84, 83, 83, 83, 83, 83, 83, 83, 84, 82, 84, 83, 84,
83, 84, 83, 84, 82, 84, 83, 83, 83, 83, 83, 84, 83, 84, 83, 83, 84, 83, 84, 83,
84, 82, 84, 81, 86, 80, 86, 78, 88, 77, 91, 73, 98, 45, -128, -113, -119, -118,
-116, -118, -116, -120, -115, -119, -115, -120, -116, -119, -116, -118, -116,
-117, -116, -116, -118, -116, -119, -114, -120, -115, -121, -114, -122, -113,
-123, -111, -126, -99, 83, 84, 81, 86, 81, 86, 80, 86, 80, 85, 80, 85, 81, 86,
81, 85, 81, 84, 82, 84, 83, 84, 82, 83, 83, 83, 83, 83, 83, 82, 84, 82, 84, 83,
83, 82, 83, 82, 83, 83, 83, 83, 84, 83, 83, 83, 83, 83, 83, 83, 82, 83, 83, 82,
82, 82, 83, 83, 83, 83, 83, 82, 83, 82, 83, 82, 83, 82, 83, 82, 82, 83, 82, 83,
82, 83, 83, 82, 83, 83, 82, 83, 82, 83, 82, 82, 82, 83, 82, 82, 83, 82, 83, 82,
83, 82, 82, 82, 83, 82, 83, 82, 82, 82, 82, 83, 82, 82, 83, 82, 82, 82, 82, 83,
82, 82, 82, 82, 82, 82, 83, 83, 82, 82, 82, 82, 82, 81, 81, 82, 81, 82, 82, 81,
83, 82, 81, 82, 82, 82, 82, 82, 82, 81, 82, 82, 82, 82, 82, 81, 82, 82, 81, 82,
82, 82, 81, 82, 82, 82, 82, 81, 82, 82, 81, 82, 82, 82, 81, 81, 81, 82, 81, 82,
82, 82, 81, 82, 81, 82, 82, 82, 81, 82, 82, 82, 81, 81, 81, 82, 82, 80, 81, 81,
82, 80, 83, 80, 83, 81, 83, 79, 83, 79, 83, 79, 82, 80, 82, 80, 82, 82, 81, 82,
78, 86, 72, 100, -62, -128, -107, -127, -113, -124, -115, -122, -117, -122,
-117, -120, -118, -119, -119, -119, -119, -119, -119, -119, -120, -119, -120,
-118, -120, -118, -120, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -118, -119, -119,
-118, -119, -119, -119, -119, -118, -118, -118, -118, -119, -118, -118, -118,
-119, -119, -118, -119, -118, -119, -119, -118, -118, -119, -119, -118, -118,
-119, -119, -119, -119, -119, -118, -118, -118, -119, -118, -118, -118, -118,
-118, -117, -118, -118, -118, -118, -118, -118, -118, -117, -118, -118, -118,
-118, -117, -118, -118, -118, -119, -118, -119, -117, -117, -118, -117, -118,
-118, -118, -118, -118, -118, -117, -117, -118, -118, -118, -118, -117, -118,
-118, -117, -118, -117, -118, -117, -118, -117, -117, -117, -117, -117, -117,
-117, -117, -117, -118, -118, -117, -117, -117, -117, -117, -118, -116, -118,
-117, -117, -118, -117, -117, -117, -117, -117, -118, -116, -118, -115, -119,
-115, -119, -115, -119, -114, -120, -114, -120, -112, -124, -100, };