#define DATA_LENGTH 512
#define DATA AKWF_0509

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 5, 6, 6, 8, 9, 11, 11, 12,
14, 15, 17, 18, 18, 19, 21, 22, 24, 24, 26, 27, 27, 29, 30, 31, 32, 33, 34, 35,
37, 37, 38, 40, 41, 42, 43, 43, 45, 46, 47, 48, 50, 50, 51, 52, 54, 54, 55, 56,
57, 59, 59, 60, 61, 62, 62, 63, 64, 66, 65, 68, 67, 70, 69, 70, 72, 72, 73, 74,
74, 76, 76, 77, 78, 78, 80, 80, 82, 80, 83, 80, 89, 65, 38, 47, 43, 46, 45, 48,
47, 48, 48, 49, 49, 50, 50, 51, 52, 52, 53, 53, 52, 53, 54, 54, 55, 56, 56, 56,
55, 57, 56, 57, 57, 58, 57, 58, 58, 59, 58, 59, 58, 59, 61, 56, 109, 122, 117,
121, 117, 120, 117, 121, 118, 120, 118, 120, 119, 119, 119, 118, 119, 119, 118,
118, 119, 118, 119, 118, 118, 117, 118, 117, 117, 116, 117, 115, 117, 114, 116,
115, 115, 114, 114, 113, 113, 112, 112, 113, 111, 111, 111, 110, 110, 109, 109,
107, 108, 107, 107, 106, 105, 105, 105, 104, 103, 103, 102, 101, 100, 100, 99,
99, 98, 97, 98, 96, 95, 95, 94, 93, 92, 92, 92, 90, 89, 89, 88, 88, 86, 86, 85,
84, 83, 82, 82, 80, 80, 79, 78, 77, 76, 75, 74, 75, 72, 72, 72, 70, 69, 69, 68,
67, 66, 65, 65, 62, 63, 60, 61, 58, 60, 56, 58, 55, 56, 53, 53, 51, 52, 50, 49,
51, -36, -54, -45, -52, -48, -54, -50, -56, -53, -57, -56, -58, -57, -60, -60,
-62, -62, -63, -64, -65, -65, -67, -67, -68, -70, -70, -72, -72, -73, -74, -74,
-75, -77, -77, -78, -79, -79, -80, -82, -82, -83, -84, -84, -86, -86, -87, -88,
-89, -89, -90, -91, -92, -93, -92, -93, -94, -95, -96, -97, -98, -98, -98, -100,
-100, -101, -102, -102, -102, -104, -104, -104, -104, -106, -106, -106, -108,
-108, -108, -108, -109, -109, -111, -110, -111, -111, -112, -112, -113, -114,
-114, -113, -115, -115, -115, -115, -116, -115, -116, -116, -116, -117, -118,
-117, -118, -117, -117, -118, -118, -118, -118, -119, -118, -119, -118, -119,
-118, -120, -118, -119, -119, -120, -118, -120, -119, -119, -119, -119, -118,
-64, -57, -60, -57, -60, -57, -60, -58, -59, -57, -57, -57, -57, -56, -58, -56,
-56, -56, -55, -54, -55, -54, -54, -54, -53, -53, -52, -52, -51, -50, -51, -49,
-49, -49, -48, -47, -48, -45, -47, -44, -46, -40, -55, -87, -81, -84, -82, -82,
-81, -79, -79, -78, -78, -77, -76, -76, -75, -74, -74, -71, -72, -70, -70, -69,
-68, -67, -66, -65, -65, -64, -63, -61, -61, -60, -60, -58, -58, -56, -55, -54,
-53, -53, -50, -50, -50, -49, -48, -47, -46, -44, -44, -42, -41, -39, -39, -38,
-37, -36, -34, -33, -32, -31, -29, -28, -28, -27, -25, -25, -24, -22, -20, -20,
-19, -18, -17, -15, -14, -13, -11, -10, -10, -8, -7, -5, -5, -3, -3, -1, 0, };