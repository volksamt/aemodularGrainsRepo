#define DATA_LENGTH 512
#define DATA AKWF_0543

const PROGMEM int8_t DATA[DATA_LENGTH] = {-3, 56, 60, 82, 72, 59, 78, 91, 62,
42, 61, 72, 69, 56, 72, 94, 72, 35, 67, 71, 64, 57, 68, 87, 62, 33, 58, 77, 60,
54, 74, 83, 54, 40, 51, 69, 63, 47, 68, 90, 58, 34, 58, 64, 59, 49, 58, 87, 47,
26, 56, 66, 56, 49, 66, 78, 59, 30, 46, 65, 49, 45, 57, 83, 37, 23, 51, 60, 57,
39, 63, 73, 43, 25, 44, 56, 50, 40, 54, 79, 50, 19, 49, 55, 47, 39, 52, 71, 43,
16, 41, 59, 43, 36, 56, 65, 35, 22, 34, 51, 45, 28, 51, 72, 39, 17, 41, 46, 41,
32, 43, 68, 28, 8, 38, 47, 37, 31, 50, 60, 41, 12, 30, 46, 32, 26, 43, 61, 5, 8,
33, 43, 38, 21, 46, 55, 24, 7, 27, 38, 31, 22, 37, 61, 31, 1, 32, 37, 28, 21,
35, 53, 24, -1, 25, 41, 24, 20, 40, 47, 17, 5, 17, 34, 26, 11, 33, 54, 20, -1,
24, 28, 24, 13, 25, 51, 9, -9, 22, 29, 19, 13, 32, 43, 22, -6, 12, 29, 13, 9,
23, 46, -1, -10, 17, 25, 20, 4, 28, 37, 6, -10, 9, 20, 13, 5, 20, 43, 11, -16,
15, 19, 10, 5, 17, 35, 5, -19, 8, 23, 6, 2, 23, 29, -1, -13, 0, 17, 7, -7, 18,
37, 2, -18, 6, 11, 5, -4, 9, 33, -9, -26, 5, 11, 1, -5, 16, 23, 5, -27, -1, 7,
-1, -14, 16, 11, -59, -18, -5, 9, 1, -13, 11, 19, -13, -28, -8, 3, -5, -14, 3,
25, -6, -34, -1, 1, -7, -15, 1, 17, -13, -38, -9, 5, -12, -15, 6, 11, -20, -30,
-17, -1, -11, -24, 1, 18, -17, -35, -11, -8, -12, -22, -8, 15, -29, -43, -13,
-6, -17, -21, -2, 6, -16, -42, -22, -6, -23, -26, -9, 10, -38, -44, -19, -9,
-16, -32, -5, 0, -32, -45, -25, -14, -22, -30, -14, 9, -27, -51, -19, -16, -25,
-32, -17, 0, -33, -55, -26, -12, -31, -34, -12, -8, -38, -48, -35, -17, -29,
-41, -16, 0, -37, -52, -27, -24, -29, -41, -24, -4, -48, -60, -30, -24, -35,
-40, -18, -11, -34, -60, -37, -25, -39, -45, -24, -13, -71, -59, -37, -27, -34,
-49, -22, -18, -50, -62, -42, -33, -41, -49, -30, -11, -45, -69, -36, -36, -44,
-49, -33, -19, -51, -72, -41, -31, -49, -51, -28, -25, -57, -66, -52, -35, -46,
-60, -33, -18, -55, -70, -45, -44, -48, -58, -41, -21, -66, -77, -46, -42, -53,
-56, -36, -29, -52, -77, -55, -43, -59, -63, -43, -27, -77, -78, -53, -45, -53,
-66, -39, -36, -69, -80, -59, -50, -59, -65, -48, -27, -65, -85, -53, -53, -61,
-66, -50, -37, -70, -90, -59, -49, -66, -69, -44, -46, -74, -84, -69, -54, -65,
-78, -49, -36, -74, -87, -62, -61, -66, -74, -58, -38, -87, -92, -66, -57, -74,
-70, -57, -43, -75, -90, -75, -57, -81, -77, -61, -44, };