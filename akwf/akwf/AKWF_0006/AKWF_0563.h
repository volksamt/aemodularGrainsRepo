#define DATA_LENGTH 512
#define DATA AKWF_0563

const PROGMEM int8_t DATA[DATA_LENGTH] = {-4, 4, -5, 4, -5, 7, 81, 1, -3, 3, -3,
2, -2, 2, -2, 2, -1, 0, 0, 0, 0, -1, 1, -2, 2, -3, 2, -2, 2, 52, 3, -3, 4, -3,
4, -3, 4, -4, 3, -2, 2, -1, 0, 1, -5, 50, 17, -8, 6, -5, 4, -3, 3, -3, 1, -1, 1,
-1, 0, 0, 1, 0, 0, 0, -1, 1, 0, 1, -1, 1, -1, 0, -1, 1, -1, 1, 0, 0, -1, 0, 0,
0, 0, -1, 0, 0, 0, 0, 1, 0, -1, -1, 1, -1, 1, -1, 1, -1, 2, -1, 1, -1, 0, -1, 0,
0, 0, 1, -1, 1, -2, 2, -3, 5, -6, 9, -12, 21, -57, -71, 20, -11, 7, -5, 3, -3,
2, -1, 0, 0, -1, 1, 0, 1, -1, 1, -2, 1, -1, 1, 0, 1, -1, 1, 0, 0, 0, 0, -1, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, -1, 0, 1, 0, 0, -1, 0, -1,
0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 2, 1,
0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0,
-1, 0, 0, 0, -2, 2, -1, 2, -2, 1, -1, 2, -2, 1, -2, 2, -1, 1, -1, 0, 2, -1, 2,
-5, 8, -15, 72, 40, -16, 11, -7, 6, -4, 4, -3, 3, -2, 2, -1, 0, 0, 1, 1, 0, 0,
-1, 1, -1, 0, -1, 1, -1, 0, -1, 0, -1, 0, -1, 0, 0, 1, -1, 0, -1, 0, 0, -1, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, -1,
0, 0, -1, 0, 0, -1, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1,
0, 0, 0, -1, 0, 0, 1, 1, 0, 1, 0, -1, 0, -1, 0, 0, 0, 1, 1, 0, 0, 1, -1, 0, 0,
0, 0, 1, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0,
0, 1, 0, 0, 0, 0, 0, -1, 1, 0, 1, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, -2, 0, -1, 1,
0, 1, 0, 0, -1, 0, 1, 0, 0, 0, 1, -1, 1, -1, 2, -2, 3, -3, 4, -4, 4, -6, 7, -8,
12, -22, -79, 10, -4, 1, -1, -1, 1, -1, 1, -2, 2, -2, 2, -2, 2, -1, 1, -1, 2,
-1, 1, -1, 0, 0, -1, 0, 1, 0, 1, 0, 0, 1, -1, 0, -1, 0, -1, 1, 0, 0, 0, 1, 0, 1,
0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, };