#define DATA_LENGTH 512
#define DATA AKWF_0564

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 2, 2, 3, 3, 4, 4, 5, 6, 5,
6, 7, 8, 8, 8, 8, 10, 10, 10, 11, 10, 11, 12, 12, 13, 13, 14, 14, 14, 15, 16,
15, 17, 17, 18, 17, 18, 19, 19, 19, 19, 20, 21, 20, 22, 22, 23, 23, 24, 23, 24,
24, 25, 25, 26, 27, 27, 27, 28, 28, 29, 29, 30, 30, 30, 32, 32, 32, 32, 33, 33,
33, 34, 35, 35, 35, 37, 36, 37, 38, 37, 37, 38, 39, 39, 39, 40, 41, 41, 42, 42,
41, 42, 43, 44, 45, 45, 46, 46, 47, 48, 48, 49, 50, 51, 51, 52, 53, 53, 54, 55,
56, 56, 57, 58, 57, 58, 59, 60, 62, 62, 62, 63, 64, 64, 64, 65, 66, 67, 68, 67,
68, 68, 69, 70, 70, 71, 72, 72, 73, 74, 75, 76, 75, 76, 77, 78, 78, 79, 79, 80,
81, 81, 82, 83, 83, 83, 83, 85, 85, 86, 86, 88, 87, 89, 89, 90, 90, 90, 92, 91,
91, 92, 93, 94, 94, 95, 96, 96, 96, 96, 97, 98, 98, 99, 100, 99, 101, 102, 102,
102, 102, 103, 104, 104, 104, 104, 106, 106, 106, 107, 107, 108, 108, 109, 109,
109, 110, 111, 111, 111, 112, 112, 112, 113, 113, 115, 113, 117, 118, 114, 94,
81, 83, 78, 77, 73, 73, 70, 68, 66, 64, 61, 59, 57, 54, 52, 50, 49, 45, 44, 41,
39, 37, 35, 32, 30, 27, 26, 24, 21, 19, 17, 15, 12, 10, 8, 7, 4, 1, 0, -3, -5,
-7, -9, -11, -14, -16, -19, -20, -23, -26, -28, -30, -32, -34, -36, -38, -40,
-44, -45, -47, -49, -51, -54, -56, -58, -61, -62, -65, -67, -69, -71, -74, -76,
-79, -80, -83, -85, -87, -90, -92, -94, -97, -98, -101, -102, -106, -109, -108,
-107, -106, -105, -105, -105, -104, -103, -103, -102, -102, -102, -101, -100,
-100, -99, -98, -98, -97, -97, -96, -96, -95, -95, -94, -93, -92, -92, -93, -92,
-91, -90, -89, -89, -89, -88, -87, -87, -86, -86, -86, -84, -84, -83, -83, -82,
-82, -81, -80, -80, -79, -79, -78, -78, -77, -77, -76, -75, -75, -75, -74, -73,
-72, -73, -73, -72, -71, -70, -70, -69, -69, -67, -67, -67, -66, -66, -65, -65,
-65, -64, -63, -64, -63, -61, -61, -61, -60, -59, -59, -58, -58, -58, -56, -56,
-56, -55, -54, -54, -54, -53, -53, -52, -52, -51, -50, -49, -49, -49, -49, -48,
-48, -46, -46, -46, -45, -45, -44, -44, -43, -43, -41, -42, -41, -42, -40, -40,
-39, -39, -38, -37, -37, -36, -36, -36, -34, -34, -33, -34, -32, -32, -32, -32,
-30, -31, -30, -29, -30, -29, -28, -27, -27, -26, -26, -26, -24, -24, -24, -24,
-22, -23, -22, -21, -21, -20, -20, -20, -19, -19, -18, -17, -17, -16, -16, -15,
-15, -14, -15, -13, -13, -12, -13, -12, -10, -11, -10, -9, -9, -8, -8, -8, -7,
-7, -6, -6, -4, -5, -4, -3, -3, -2, };