#define DATA_LENGTH 512
#define DATA AKWF_0528

const PROGMEM int8_t DATA[DATA_LENGTH] = {22, 26, 24, 25, 25, 25, 25, 26, 25,
25, 25, 25, 25, 25, 25, 25, 25, 25, 26, 25, 25, 26, 25, 26, 25, 27, 24, 26, 23,
28, 22, 29, 21, 31, 17, 39, -11, -128, -114, -122, -118, -120, -119, -119, -120,
-117, -120, -118, -121, -118, -120, -118, -121, -118, -120, -118, -120, -118,
-120, -119, -120, -119, -119, -118, -120, -119, -119, -120, -118, -119, -118,
-119, -117, -121, -101, -92, -94, -93, -95, -93, -94, -93, -94, -93, -94, -93,
-94, -93, -94, -94, -95, -95, -93, -95, -94, -94, -94, -94, -94, -94, -94, -94,
-94, -95, -94, -94, -93, -94, -94, -94, -94, -94, -94, -94, -93, -94, -94, -93,
-94, -94, -93, -94, -94, -94, -94, -94, -94, -94, -94, -94, -94, -94, -94, -93,
-95, -94, -94, -94, -93, -94, -94, -94, -93, -94, -94, -94, -94, -94, -94, -94,
-93, -94, -94, -94, -94, -93, -94, -94, -93, -93, -93, -95, -94, -94, -93, -94,
-94, -93, -94, -94, -93, -94, -94, -94, -95, -94, -94, -94, -94, -94, -94, -94,
-93, -94, -94, -94, -94, -93, -94, -93, -94, -93, -94, -94, -94, -94, -95, -93,
-94, -94, -94, -94, -95, -94, -94, -94, -94, -94, -94, -93, -94, -93, -94, -94,
-94, -94, -94, -93, -94, -94, -94, -94, -94, -94, -93, -94, -94, -94, -93, -94,
-93, -94, -94, -94, -94, -93, -93, -94, -94, -94, -94, -93, -94, -94, -94, -93,
-94, -94, -93, -94, -94, -94, -94, -93, -94, -94, -93, -94, -93, -94, -94, -94,
-94, -94, -93, -93, -94, -93, -94, -94, -93, -93, -94, -93, -94, -93, -94, -93,
-93, -95, -94, -94, -93, -95, -93, -96, -92, -96, -91, -98, -88, -104, -61, 10,
-4, 3, -2, 0, -1, 0, 0, 0, 1, 0, 0, -1, 1, 0, 1, -1, 1, 0, 1, -1, 1, 0, 0, 0, 0,
0, 0, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, -1, 0, -1, -1, 0, 0, 0,
0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, -1, 0, 1, 0, -1, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 1, 0, 0, 0, 0, -1, -1, -1, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0,
-1, 0, 1, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0,
1, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1,
0, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, };