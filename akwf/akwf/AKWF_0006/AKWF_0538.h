#define DATA_LENGTH 512
#define DATA AKWF_0538

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 28, 45, 60, 79, 91, 99, 105, 109,
112, 113, 114, 115, 116, 117, 117, 117, 118, 119, 119, 119, 119, 119, 119, 119,
119, 118, 119, 119, 118, 119, 118, 119, 119, 118, 120, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 120, 119,
119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 120, 120, 119, 119, 119, 118,
119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120,
120, 119, 119, 120, 119, 119, 119, 119, 120, 119, 119, 120, 119, 120, 118, 119,
119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120, 118, 119,
119, 119, 120, 119, 119, 119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119,
118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119,
120, 119, 119, 119, 119, 119, 119, 119, 120, 119, 120, 119, 120, 119, 119, 119,
119, 118, 120, 120, 119, 119, 119, 119, 119, 119, 120, 119, 120, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 120, 118, 119, 119, 119, 119, 118, 119, 120, 120, 119, 119,
119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 119, 118, 119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 120, 119, 120, 119, 120, 119, 119, 119, 119, 119, 118, 119, 119, 120,
119, 119, 118, 119, 119, 119, 119, 120, 119, 120, 120, 118, 119, 119, 120, 119,
119, 120, 120, 119, 120, 119, 120, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 120, 119, 120, 119, 119, 119, 120, 120, 119, 120, 119, 119, 119, 118,
120, 118, 119, 118, 120, 119, 119, 119, 119, 118, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 118, 119, 119, 119,
119, 120, 120, 119, 120, 119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119,
119, 119, 120, 118, 119, 119, 118, 119, 119, 118, 119, 119, 119, 119, 118, 119,
120, 118, 119, 118, 119, 120, 120, 119, 120, 119, 120, 119, 119, 119, 119, 118,
120, 107, 63, 26, -3, -31, -50, -64, -74, -83, -89, -95, -98, -103, -106, -107,
-110, -110, -112, -114, -115, -115, -116, -115, -117, -117, -117, -117, -117,
-117, -118, -118, -118, -118, -119, -118, -118, -118, -119, -118, -119, -119,
-119, -119, -120, -119, -120, -119, -119, -120, -119, -119, -118, -118, -119,
-118, -119, -119, -119, -118, -119, -119, -119, -119, -119, -120, -118, -118,
-89, -44, -13, };