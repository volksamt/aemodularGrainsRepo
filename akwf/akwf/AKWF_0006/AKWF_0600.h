#define DATA_LENGTH 512
#define DATA AKWF_0600

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 5, 6, 8, 9, 11, 11, 13, 15,
16, 18, 19, 20, 21, 23, 25, 26, 27, 28, 30, 31, 34, 39, 39, 38, 39, 38, 38, 39,
38, 39, 38, 38, 38, 38, 38, 38, 38, 38, 38, 38, 38, 38, 38, 38, 37, 38, 37, 38,
38, 38, 38, 38, 38, 38, 38, 38, 38, 39, 38, 39, 37, 38, 38, 37, 38, 38, 38, 38,
37, 38, 38, 38, 38, 37, 38, 38, 37, 38, 38, 37, 38, 37, 37, 38, 38, 38, 38, 38,
38, 37, 37, 38, 37, 38, 38, 38, 38, 38, 38, 37, 37, 37, 38, 37, 38, 38, 38, 38,
38, 38, 38, 38, 37, 37, 37, 38, 37, 37, 37, 37, 37, 38, 38, 37, 37, 37, 38, 37,
37, 37, 37, 37, 37, 37, 38, 37, 37, 37, 37, 37, 37, 38, 38, 37, 37, 37, 37, 38,
37, 37, 37, 37, 37, 38, 37, 36, 38, 36, 37, 37, 36, 36, 37, 36, 37, 37, 37, 37,
37, 37, 36, 37, 37, 37, 37, 36, 37, 37, 37, 37, 36, 37, 37, 36, 37, 37, 36, 37,
37, 37, 37, 37, 37, 37, 37, 37, 37, 36, 37, 37, 37, 36, 37, 37, 36, 37, 36, 36,
37, 36, 36, 37, 36, 37, 37, 36, 37, 36, 37, 37, 37, 37, 37, 37, 37, 37, 36, 36,
37, 37, 36, 36, 37, 36, 35, 36, 37, 36, 36, 37, 35, 37, 36, 37, 36, 36, 36, 36,
36, 37, 36, 36, 36, 36, 36, 37, 36, 36, 36, 35, 36, 35, 36, 37, 36, 36, 35, 36,
36, 35, 36, 36, 36, 36, 36, 36, 36, 36, 36, 35, 36, 36, 36, 35, 36, 36, 36, 36,
36, 36, 35, 36, 36, 36, 35, 34, 31, 30, 29, 28, 26, 24, 24, 22, 22, 21, 19, 19,
17, 16, 15, 13, 12, 10, 10, 8, 7, 6, 6, 4, 3, 2, 0, -1, -2, -4, -4, -5, -7, -8,
-9, -10, -12, -12, -14, -16, -16, -18, -19, -19, -22, -22, -23, -24, -25, -27,
-28, -29, -30, -32, -32, -34, -35, -36, -37, -38, -40, -41, -42, -43, -45, -45,
-47, -48, -49, -50, -51, -52, -55, -55, -56, -57, -59, -59, -60, -62, -63, -64,
-66, -67, -67, -70, -70, -72, -73, -73, -75, -76, -77, -78, -80, -81, -82, -82,
-84, -85, -86, -88, -89, -90, -92, -92, -93, -94, -96, -97, -98, -100, -100,
-101, -103, -104, -104, -106, -107, -109, -109, -110, -111, -113, -114, -115,
-117, -117, -118, -118, -117, -116, -113, -113, -111, -110, -107, -107, -106,
-103, -103, -101, -100, -99, -97, -96, -94, -92, -91, -89, -89, -88, -85, -84,
-82, -80, -80, -79, -77, -75, -74, -73, -71, -70, -68, -67, -65, -64, -63, -61,
-60, -58, -56, -56, -55, -53, -51, -50, -49, -47, -46, -44, -42, -41, -39, -39,
-37, -36, -34, -33, -31, -31, -29, -28, -25, -24, -24, -22, -21, -18, -17, -16,
-14, -13, -12, -11, -9, -7, -5, -5, -3, -2, 0, };