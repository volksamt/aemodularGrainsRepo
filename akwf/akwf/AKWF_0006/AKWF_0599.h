#define DATA_LENGTH 512
#define DATA AKWF_0599

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 2, 2, 3, 4, 4, 4, 5, 7, 7, 7,
8, 7, 8, 10, 10, 10, 12, 12, 12, 12, 13, 14, 14, 15, 15, 16, 16, 18, 18, 18, 18,
20, 20, 20, 21, 22, 22, 22, 22, 23, 24, 24, 25, 26, 27, 27, 27, 28, 29, 29, 29,
30, 31, 31, 31, 32, 33, 34, 34, 34, 35, 36, 36, 36, 37, 38, 39, 38, 39, 40, 40,
41, 42, 42, 43, 44, 43, 45, 45, 45, 46, 47, 47, 48, 48, 48, 49, 49, 50, 51, 51,
52, 53, 53, 53, 54, 55, 56, 55, 56, 57, 57, 58, 59, 60, 60, 60, 61, 61, 62, 62,
63, 63, 64, 64, 65, 66, 66, 67, 68, 68, 68, 69, 68, 70, 70, 71, 71, 72, 73, 72,
73, 74, 75, 76, 76, 77, 76, 77, 78, 79, 79, 80, 80, 80, 81, 82, 82, 82, 83, 84,
84, 85, 85, 86, 87, 87, 88, 87, 89, 89, 90, 90, 90, 88, 86, 84, 82, 81, 80, 78,
76, 74, 73, 71, 69, 68, 66, 65, 63, 61, 60, 58, 57, 55, 52, 51, 49, 48, 46, 45,
43, 42, 39, 38, 36, 34, 33, 32, 30, 27, 26, 25, 23, 21, 20, 17, 17, 14, 13, 10,
10, 8, 7, 4, 3, 2, -1, -1, -5, -4, -10, -4, -17, -3, -30, 49, 127, 107, 117,
106, 111, 102, 104, 99, 97, 94, 92, 89, 87, 84, 81, 80, 76, 75, 71, 69, 65, 64,
61, 58, 56, 54, 50, 48, 44, 43, 41, 38, 35, 32, 29, 26, 24, 22, 19, 17, 14, 12,
10, 6, 5, 2, -2, -4, -6, -10, -12, -14, -17, -20, -22, -25, -28, -30, -32, -35,
-38, -39, -43, -45, -48, -50, -52, -55, -59, -60, -63, -66, -68, -71, -74, -76,
-80, -81, -84, -86, -88, -92, -94, -96, -99, -101, -105, -107, -110, -109, -108,
-108, -107, -108, -105, -106, -105, -105, -104, -103, -104, -102, -102, -101,
-101, -100, -99, -100, -98, -98, -97, -96, -96, -95, -95, -94, -93, -93, -93,
-91, -91, -91, -90, -89, -88, -89, -88, -87, -87, -86, -85, -85, -85, -85, -84,
-83, -83, -82, -82, -81, -80, -79, -79, -78, -78, -77, -77, -76, -76, -75, -74,
-73, -73, -73, -72, -71, -71, -71, -70, -69, -69, -68, -67, -67, -66, -66, -65,
-64, -63, -63, -63, -62, -62, -61, -61, -59, -59, -59, -58, -58, -56, -57, -55,
-56, -56, -55, -54, -53, -52, -52, -51, -50, -50, -49, -48, -48, -48, -46, -47,
-46, -46, -45, -45, -43, -43, -43, -43, -42, -41, -41, -41, -40, -39, -38, -38,
-37, -37, -36, -36, -35, -35, -33, -33, -33, -32, -32, -31, -30, -29, -29, -28,
-28, -28, -27, -26, -26, -26, -24, -24, -23, -22, -22, -22, -21, -21, -21, -20,
-19, -18, -18, -17, -17, -17, -15, -15, -15, -14, -13, -13, -12, -12, -11, -11,
-11, -10, -9, -8, -8, -7, -7, -6, -5, -5, -5, -4, -3, -3, -3, -2, -1, -1, 0, };