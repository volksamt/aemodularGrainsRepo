#define DATA_LENGTH 512
#define DATA AKWF_0517

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 14, 28, 41, 49, 55, 59, 59, 59, 55,
50, 44, 39, 32, 26, 20, 15, 11, 9, 6, 5, 3, 3, 3, 4, 1, -4, -3, -11, -14, -18,
-15, -14, -12, -8, -5, -8, -18, -24, -34, -41, -47, -53, -55, -56, -56, -52,
-47, -41, -34, -27, -20, -12, -5, 1, 7, 12, 16, 20, 24, 26, 29, 32, 34, 35, 38,
39, 38, 33, 28, 20, 11, 1, -4, -2, 2, 7, 14, 22, 30, 37, 42, 47, 51, 53, 53, 52,
50, 48, 46, 43, 40, 38, 36, 35, 34, 33, 31, 29, 28, 27, 26, 24, 21, 18, 16, 13,
12, 9, 8, 7, 6, 7, 9, 11, 14, 18, 20, 24, 28, 32, 36, 38, 41, 44, 44, 46, 45,
46, 46, 44, 45, 43, 44, 42, 42, 41, 39, 39, 37, 37, 36, 35, 34, 34, 34, 33, 34,
34, 34, 33, 35, 35, 37, 38, 41, 43, 45, 47, 49, 49, 51, 52, 52, 51, 46, 45, 49,
48, 48, 49, 47, 45, 44, 42, 40, 37, 35, 34, 33, 32, 30, 29, 27, 28, 26, 25, 24,
23, 22, 22, 21, 21, 21, 22, 22, 22, 21, 21, 21, 22, 22, 22, 23, 24, 24, 25, 26,
26, 27, 28, 28, 28, 30, 30, 31, 33, 34, 34, 34, 35, 35, 35, 36, 39, 39, 42, 45,
48, 47, 48, 47, 48, 50, 51, 54, 55, 55, 55, 55, 56, 56, 57, 56, 57, 56, 56, 58,
56, 57, 56, 55, 53, 53, 50, 50, 54, 62, 72, 81, 89, 95, 100, 100, 99, 95, 89,
83, 76, 66, 58, 50, 41, 35, 27, 22, 19, 14, 11, 7, 6, 4, 4, 2, 1, 0, 0, 1, 3, 5,
-1, 2, -25, -41, -59, -76, -84, -109, -117, -112, -103, -111, -109, -96, -92,
-93, -72, -78, -81, -71, -71, -60, -72, -74, -68, -65, -61, -58, -40, -31, -32,
-28, -28, -24, -28, -50, -56, -61, -70, -75, -79, -60, -57, -50, -46, -25, -11,
-8, 0, 0, 5, -10, -17, -17, -21, -25, -29, -33, -38, -39, -46, -36, -27, -33,
-32, -35, -35, -36, -37, -40, -60, -63, -66, -67, -70, -69, -52, -52, -53, -49,
-51, -45, -49, -62, -56, -52, -50, -46, -45, -43, -42, -42, -25, -19, -23, -21,
-26, -25, -31, -28, -38, -56, -57, -59, -63, -64, -69, -61, -49, -55, -55, -57,
-58, -58, -60, -60, -60, -61, -60, -59, -59, -58, -57, -54, -54, -53, -51, -49,
-47, -45, -45, -50, -51, -47, -46, -46, -44, -45, -47, -47, -49, -50, -52, -52,
-53, -54, -54, -55, -56, -56, -58, -58, -56, -56, -56, -56, -57, -57, -56, -56,
-56, -55, -55, -55, -55, -54, -53, -52, -52, -51, -49, -48, -47, -46, -46, -45,
-44, -43, -43, -42, -41, -41, -40, -41, -38, -38, -37, -37, -37, -36, -38, -20,
-16, -17, -16, -17, -16, -17, -16, -17, -17, -17, -17, -18, -16, -17, -17, -17,
-17, -16, -17, -16, -16, -16, -15, -14, -15, -15, -15, -14, -14, -6, };