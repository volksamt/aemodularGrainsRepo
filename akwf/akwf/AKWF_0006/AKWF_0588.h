#define DATA_LENGTH 512
#define DATA AKWF_0588

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 14, 22, 31, 39, 46, 55, 63, 71, 79,
88, 96, 104, 114, 119, 117, 118, 118, 118, 117, 117, 117, 118, 118, 117, 117,
117, 117, 117, 117, 117, 117, 117, 117, 116, 116, 116, 116, 117, 116, 117, 116,
115, 116, 116, 115, 115, 116, 116, 115, 116, 115, 115, 116, 115, 114, 114, 114,
114, 115, 114, 115, 114, 115, 114, 114, 114, 114, 114, 114, 114, 113, 114, 113,
113, 113, 113, 113, 113, 113, 113, 113, 112, 112, 112, 113, 112, 112, 112, 112,
111, 111, 112, 112, 111, 110, 112, 112, 111, 110, 110, 111, 110, 110, 111, 110,
110, 110, 110, 107, 100, 96, 90, 84, 79, 74, 68, 62, 56, 52, 46, 40, 34, 29, 24,
18, 13, 8, 2, -3, -9, -14, -20, -25, -31, -36, -42, -48, -52, -58, -64, -69,
-74, -80, -85, -91, -96, -101, -107, -112, -119, -119, -118, -118, -119, -118,
-119, -119, -118, -118, -119, -119, -119, -119, -118, -119, -118, -119, -118,
-119, -118, -118, -118, -119, -118, -119, -117, -118, -117, -118, -118, -118,
-118, -118, -118, -117, -118, -117, -118, -118, -118, -118, -117, -117, -118,
-118, -117, -116, -117, -117, -117, -117, -117, -117, -117, -117, -117, -116,
-117, -116, -116, -117, -115, -116, -117, -116, -116, -116, -116, -116, -115,
-115, -116, -116, -115, -115, -116, -115, -116, -116, -115, -115, -114, -115,
-115, -115, -114, -114, -115, -115, -115, -115, -110, -101, -94, -85, -77, -68,
-60, -51, -44, -36, -27, -18, -10, -3, 7, 14, 23, 31, 39, 47, 56, 64, 72, 81,
89, 96, 105, 114, 119, 118, 118, 118, 118, 118, 117, 118, 117, 117, 117, 117,
117, 117, 116, 116, 117, 116, 117, 117, 116, 117, 116, 116, 116, 116, 116, 116,
116, 116, 116, 115, 115, 115, 116, 115, 115, 114, 116, 115, 115, 115, 115, 115,
114, 115, 114, 115, 115, 114, 115, 114, 114, 114, 114, 113, 114, 113, 114, 113,
113, 112, 113, 113, 112, 112, 113, 113, 112, 112, 113, 112, 112, 113, 112, 112,
112, 112, 111, 111, 112, 111, 111, 111, 112, 110, 111, 111, 111, 111, 111, 110,
110, 111, 110, 106, 100, 94, 90, 84, 78, 74, 68, 62, 57, 50, 45, 40, 34, 29, 23,
18, 13, 8, 1, -4, -9, -14, -20, -26, -32, -37, -42, -48, -53, -59, -65, -70,
-75, -80, -86, -92, -97, -102, -109, -114, -119, -120, -118, -119, -119, -119,
-118, -119, -119, -119, -118, -119, -119, -119, -118, -118, -119, -118, -118,
-118, -118, -119, -118, -118, -118, -118, -119, -118, -118, -117, -118, -117,
-118, -117, -117, -118, -118, -118, -117, -118, -118, -118, -117, -117, -118,
-118, -118, -117, -117, -117, -117, -116, -116, -118, -117, -116, -116, -116,
-117, -116, -116, -117, -117, -116, -116, -116, -116, -116, -116, -117, -115,
-115, -116, -115, -116, -115, -115, -116, -116, -115, -115, -115, -115, -116,
-115, -115, -115, -115, -115, -115, -114, -115, -109, -100, -92, -84, -76, -68,
-59, -50, -42, -35, -26, -18, -9, -1, };