#define DATA_LENGTH 512
#define DATA AKWF_0595

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 22, 35, 49, 61, 73, 87, 98, 114,
115, 100, 87, 74, 61, 49, 36, 24, 10, -1, -1, -1, -1, -2, -2, -2, -1, -2, -2,
-1, -2, -1, -2, -1, -2, -1, -2, -2, -1, -1, -2, -2, -2, -2, -2, -2, -2, -1, -2,
-2, -1, -2, -1, -2, -10, -18, -26, -34, -43, -52, -60, -68, -77, -76, -66, -59,
-50, -42, -32, -25, -16, -8, -1, -2, -2, -2, -1, -2, -1, -1, -1, -1, -3, -1, -2,
-1, -2, -2, -1, -1, -1, -1, -2, -2, -2, -2, -2, -1, -1, -1, -2, -2, -2, -2, -1,
-2, -1, -1, -2, -2, -1, -1, -1, -1, -2, -2, -2, -1, -1, -2, -2, -2, -1, -2, -1,
-2, -1, -1, -1, -1, 0, -1, 0, 2, 4, 6, 8, 11, 13, 15, 17, 18, 17, 14, 11, 11, 9,
6, 3, 2, -1, -2, -1, -2, -1, -1, -2, -2, -2, -2, -5, -7, -9, -12, -14, -17, -19,
-21, -24, -23, -19, -17, -14, -12, -10, -8, -5, -3, -1, -2, -2, -1, -1, -2, -2,
-2, -2, -2, -2, -1, -1, -1, -1, -1, -1, -1, -2, -1, -1, -2, -1, -1, -2, -1, -2,
-2, -1, -1, -2, -1, -2, -1, -1, -1, -2, -1, -1, -2, -2, -1, -1, -1, -2, -1, -1,
-2, -2, -2, -2, -1, -1, -1, -1, -2, -1, -1, -2, -2, -1, -2, -1, -2, -1, -1, -1,
-2, -2, -2, -1, -1, -1, -1, -1, -1, -2, -1, -2, 11, 24, 37, 49, 62, 75, 88, 100,
115, 114, 98, 86, 73, 60, 48, 34, 22, 9, -2, -1, -1, -2, -1, -2, -1, -1, -2, -1,
-2, -1, -2, -2, -1, -2, -1, -2, -2, -1, -2, -1, -1, -1, -2, -1, -2, -2, -2, -1,
-2, -2, -2, -1, -2, -10, -19, -27, -35, -44, -52, -61, -68, -78, -75, -65, -58,
-49, -41, -32, -25, -16, -7, -1, -2, -1, -2, -1, -1, -2, -2, -1, -1, -2, -1, -2,
-2, -2, -1, -1, -2, -1, -2, -2, -2, -1, -1, -1, -2, -1, -1, -2, -1, -2, -2, -1,
-2, -2, -2, -2, -1, -2, -2, -1, -1, -2, -2, -1, -1, -2, -1, -1, -1, -1, -2, -1,
-2, -2, -2, -2, -2, -1, -2, 0, 2, 4, 7, 9, 11, 12, 15, 18, 19, 16, 14, 12, 10,
8, 5, 3, 0, -1, -2, -1, -2, -2, -1, -1, -2, -1, -2, -5, -7, -9, -12, -14, -17,
-19, -22, -24, -22, -19, -16, -14, -12, -10, -8, -5, -2, -1, -2, -2, -2, -1, -1,
-1, -1, -1, -1, -2, -1, -2, -1, -1, -2, -2, -2, -1, -1, -2, -1, -2, -2, -1, -2,
-2, -2, -1, -1, -1, -1, -1, -2, -1, -2, -1, -1, -1, -1, -1, -1, -1, -2, -2, -2,
-1, -1, -2, -1, -2, -2, -2, -2, -1, -1, -1, -2, -1, -2, -2, -2, -1, -1, -1, -2,
-2, -1, -1, -2, -1, -2, -2, -2, -2, -2, -2, -2, -1, };