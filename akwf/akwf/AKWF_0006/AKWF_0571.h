#define DATA_LENGTH 512
#define DATA AKWF_0571

const PROGMEM int8_t DATA[DATA_LENGTH] = {61, 80, 79, 87, 87, 92, 91, 95, 95,
98, 98, 101, 100, 103, 102, 104, 104, 106, 106, 107, 108, 109, 109, 110, 110,
110, 111, 111, 112, 112, 113, 113, 113, 113, 114, 114, 114, 115, 115, 114, 115,
114, 116, 115, 115, 116, 116, 117, 115, 116, 115, 117, 119, 115, 114, 114, 114,
114, 113, 114, 113, 113, 113, 113, 113, 113, 113, 113, 113, 113, 112, 113, 112,
112, 112, 113, 113, 113, 112, 113, 113, 112, 113, 112, 112, 112, 112, 112, 112,
113, 112, 112, 113, 112, 112, 113, 113, 113, 112, 112, 112, 112, 112, 112, 112,
112, 112, 112, 112, 112, 112, 112, 112, 111, 112, 112, 112, 111, 112, 112, 111,
112, 112, 112, 111, 111, 111, 111, 112, 112, 111, 112, 112, 112, 112, 111, 112,
112, 111, 111, 112, 111, 112, 111, 111, 111, 112, 112, 111, 112, 111, 111, 111,
111, 111, 112, 111, 111, 111, 112, 111, 110, 112, 112, 111, 111, 111, 111, 111,
112, 111, 111, 111, 111, 112, 112, 112, 112, 111, 111, 112, 111, 111, 112, 112,
110, 111, 111, 111, 112, 110, 111, 111, 112, 111, 112, 112, 111, 111, 111, 111,
111, 111, 111, 111, 110, 111, 111, 112, 111, 111, 111, 111, 111, 111, 112, 111,
111, 111, 111, 112, 112, 112, 111, 110, 111, 111, 111, 111, 111, 111, 110, 111,
111, 111, 112, 111, 111, 111, 112, 111, 112, 110, 112, 110, 111, 110, 112, 110,
112, 109, 112, 110, 113, 108, 115, 101, 49, 48, 44, 41, 40, 38, 37, 34, 34, 32,
32, 30, 30, 28, 29, 26, 27, 27, 25, 25, 24, 23, 23, 22, 22, 22, 22, 20, 20, 20,
19, 19, 19, 19, 17, 18, 17, 17, 17, 17, 16, 16, 15, 15, 15, 14, 14, 14, 14, 13,
14, 13, 13, 13, 13, 13, 12, 11, 12, 11, 11, 10, 12, 10, 10, 10, 10, 10, 10, 10,
9, 9, 8, 8, 9, 8, 9, 8, 8, 7, 8, 8, 8, 8, 7, 7, 7, 7, 7, 7, 6, 6, 6, 6, 6, 6, 6,
6, 6, 5, 5, 5, 5, 4, 5, 5, 5, 5, 5, 5, 4, 4, 3, 4, 4, 5, 4, 4, 3, 4, 3, 2, 3, 3,
3, 3, 2, 3, 2, 2, 2, 3, 2, 2, 2, 2, 3, 2, 2, 1, 2, 2, 1, 2, 2, 1, 2, 2, 1, 2, 1,
2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 1, 0, 0, 1, 1, 0, 0, 0, 1, 0,
1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 1, -1,
0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, -1, 0, -1, 0, 0, -1, 1, 0, 0, 0, 0, 0,
};