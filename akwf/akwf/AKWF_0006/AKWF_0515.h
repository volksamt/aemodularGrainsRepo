#define DATA_LENGTH 512
#define DATA AKWF_0515

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 15, 29, 42, 49, 55, 58, 59, 58, 55,
50, 44, 38, 32, 26, 20, 16, 11, 10, 6, 5, 3, 3, 3, 5, 2, -6, -2, -11, -14, -17,
-16, -14, -11, -7, -4, -9, -17, -24, -34, -41, -47, -52, -55, -56, -55, -52,
-47, -41, -34, -27, -19, -12, -5, 1, 7, 12, 15, 20, 23, 25, 29, 31, 33, 36, 37,
39, 38, 33, 27, 19, 12, 2, -4, -1, 2, 7, 14, 22, 30, 37, 43, 48, 52, 52, 53, 52,
50, 49, 45, 43, 40, 39, 36, 35, 33, 32, 31, 30, 29, 28, 25, 24, 22, 19, 16, 14,
11, 9, 8, 7, 8, 7, 10, 11, 15, 18, 21, 24, 28, 32, 36, 38, 42, 43, 46, 46, 47,
46, 46, 45, 45, 44, 44, 43, 41, 40, 40, 38, 38, 37, 36, 35, 34, 34, 34, 32, 33,
33, 34, 34, 34, 36, 37, 38, 40, 44, 44, 46, 49, 50, 50, 51, 52, 52, 47, 45, 49,
49, 48, 48, 48, 45, 43, 41, 39, 36, 36, 34, 33, 32, 30, 30, 28, 27, 26, 24, 23,
23, 22, 22, 21, 20, 21, 22, 21, 21, 21, 21, 21, 22, 22, 23, 23, 24, 24, 25, 25,
26, 27, 28, 27, 29, 29, 31, 31, 33, 33, 34, 34, 34, 35, 35, 37, 39, 40, 41, 45,
48, 47, 48, 48, 49, 49, 51, 53, 53, 55, 55, 56, 56, 57, 57, 56, 56, 55, 56, 58,
56, 57, 55, 55, 53, 52, 49, 50, 55, 61, 72, 82, 89, 96, 99, 99, 98, 94, 89, 84,
76, 67, 58, 50, 42, 34, 28, 23, 19, 14, 12, 8, 5, 4, 4, 3, 1, 1, -1, 2, 2, 4, 1,
3, -25, -40, -60, -76, -84, -110, -117, -112, -103, -111, -109, -96, -92, -93,
-71, -78, -81, -71, -71, -60, -73, -73, -69, -66, -61, -58, -40, -31, -32, -27,
-27, -25, -27, -50, -56, -61, -69, -75, -79, -61, -56, -51, -46, -25, -9, -8, 0,
1, 6, -10, -17, -17, -20, -25, -29, -33, -38, -39, -47, -36, -28, -33, -32, -35,
-35, -36, -38, -39, -60, -63, -65, -67, -70, -70, -53, -50, -53, -49, -50, -45,
-49, -61, -55, -52, -49, -45, -44, -42, -41, -41, -25, -18, -24, -22, -26, -25,
-31, -28, -39, -56, -57, -59, -63, -62, -68, -60, -49, -55, -54, -57, -57, -59,
-59, -60, -60, -60, -60, -60, -59, -58, -56, -55, -53, -52, -52, -48, -46, -46,
-46, -50, -50, -46, -46, -46, -45, -46, -46, -47, -50, -50, -52, -53, -53, -54,
-54, -56, -56, -56, -57, -58, -55, -56, -56, -57, -57, -57, -57, -56, -56, -55,
-56, -55, -55, -54, -53, -52, -50, -50, -50, -48, -47, -47, -45, -44, -44, -44,
-42, -42, -41, -41, -40, -41, -38, -38, -38, -37, -37, -36, -38, -20, -16, -18,
-16, -18, -17, -18, -17, -17, -17, -18, -17, -16, -17, -17, -17, -16, -16, -16,
-17, -17, -16, -15, -15, -15, -14, -14, -15, -15, -14, -7, };