#define DATA_LENGTH 512
#define DATA AKWF_0527

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 3, 10, 19, 16, 18, 18, 18, 18,
17, 18, 17, 18, 17, 17, 17, 17, 18, 17, 18, 17, 18, 17, 17, 18, 17, 17, 17, 17,
17, 18, 17, 19, 16, 20, 13, 31, 57, 51, 54, 55, 57, 57, 56, 57, 56, 57, 56, 57,
56, 56, 56, 57, 57, 57, 57, 57, 57, 56, 56, 57, 57, 57, 56, 56, 57, 57, 57, 57,
57, 56, 57, 57, 57, 53, 52, 53, 52, 53, 53, 53, 52, 53, 52, 52, 52, 53, 52, 52,
53, 52, 53, 52, 53, 53, 53, 53, 53, 53, 52, 53, 52, 53, 53, 52, 52, 53, 52, 65,
73, 67, 78, 93, 91, 92, 92, 91, 93, 92, 92, 92, 92, 91, 92, 92, 92, 92, 92, 91,
92, 91, 92, 92, 92, 92, 92, 91, 92, 92, 92, 92, 92, 92, 92, 91, 92, 92, 92, 92,
91, 92, 92, 91, 91, 91, 92, 91, 91, 92, 92, 92, 92, 93, 92, 92, 92, 91, 92, 92,
93, 92, 92, 92, 92, 92, 92, 92, 92, 92, 91, 92, 92, 92, 92, 92, 92, 92, 91, 92,
92, 92, 92, 92, 92, 92, 93, 91, 92, 91, 92, 92, 91, 92, 92, 92, 92, 92, 92, 92,
92, 92, 91, 92, 92, 91, 92, 91, 92, 92, 91, 92, 92, 92, 91, 93, 91, 93, 84, 68,
72, 70, 55, 51, 53, 53, 53, 53, 53, 52, 53, 52, 53, 53, 52, 53, 53, 52, 52, 53,
52, 53, 53, 52, 52, 53, 53, 52, 53, 52, 54, 52, 53, 51, 54, 52, 32, 12, 34, -15,
-80, -66, -72, -69, -70, -71, -68, -72, -67, -76, -102, -102, -100, -115, -119,
-118, -119, -119, -119, -119, -118, -120, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -120, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -120, -120, -119, -119, -119, -119, -119,
-120, -120, -120, -120, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -120, -118, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -120, -119, -119,
-119, -120, -118, -119, -119, -119, -119, -120, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -118, -120, -116, -106, -104, -108, -80, -67, -73, -69,
-71, -70, -71, -70, -71, -70, -70, -70, -70, -69, -70, -71, -71, -70, -70, -70,
-71, -70, -71, -70, -70, -70, -70, -71, -70, -70, -71, -70, -70, -70, -70, -70,
-70, -71, -70, -70, -71, -70, -70, -70, -71, -70, -70, -70, -71, -69, -70, -70,
-70, -70, -71, -70, -71, -70, -70, -71, -70, -70, -70, -70, -69, -71, -70, -70,
-70, -70, -70, -70, -71, -70, -72, -60, -50, -56, -46, -29, -32, -32, -31, -31,
-31, -31, -31, -31, -31, -31, -31, -31, -31, -31, -31, -32, -31, -31, -31, -32,
-31, -32, -31, -31, -31, -32, -31, -31, -30, -33, -30, -33, -27, };