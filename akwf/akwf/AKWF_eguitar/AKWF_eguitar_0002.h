#define DATA_LENGTH 512
#define DATA AKWF_eguitar_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 13, 24, 33, 44, 56, 67, 79, 91,
105, 116, 119, 119, 118, 118, 118, 119, 118, 118, 118, 118, 118, 117, 117, 118,
117, 117, 117, 117, 117, 117, 116, 117, 117, 117, 116, 117, 116, 117, 116, 116,
116, 116, 116, 116, 116, 116, 116, 116, 116, 116, 116, 115, 115, 115, 115, 115,
114, 115, 115, 114, 114, 114, 114, 114, 114, 114, 113, 113, 113, 114, 113, 113,
113, 113, 113, 113, 113, 112, 112, 112, 113, 112, 112, 112, 112, 112, 111, 112,
111, 111, 111, 112, 111, 111, 111, 111, 111, 110, 110, 110, 109, 110, 110, 109,
110, 109, 109, 109, 109, 109, 109, 108, 109, 109, 109, 108, 108, 108, 108, 109,
108, 108, 108, 108, 108, 108, 107, 108, 106, 106, 107, 106, 107, 106, 107, 107,
106, 106, 106, 107, 106, 106, 106, 106, 106, 106, 105, 106, 106, 105, 104, 106,
105, 105, 104, 104, 104, 104, 104, 103, 104, 105, 104, 103, 104, 104, 104, 103,
103, 102, 103, 103, 103, 103, 102, 103, 102, 102, 102, 102, 102, 101, 101, 102,
102, 102, 101, 101, 100, 102, 101, 101, 101, 101, 100, 100, 100, 100, 100, 101,
101, 100, 100, 99, 100, 99, 100, 99, 98, 99, 99, 98, 98, 99, 98, 99, 98, 98, 98,
98, 98, 98, 97, 97, 97, 96, 97, 96, 96, 97, 96, 96, 96, 96, 95, 93, 90, 85, 83,
79, 76, 71, 67, 63, 57, 52, 46, 40, 34, 28, 21, 14, 6, -2, -10, -20, -29, -39,
-50, -60, -71, -81, -91, -102, -113, -118, -119, -117, -118, -116, -117, -117,
-117, -117, -116, -118, -116, -117, -116, -116, -117, -117, -116, -116, -117,
-117, -116, -116, -115, -115, -116, -116, -116, -115, -115, -115, -115, -115,
-115, -115, -115, -115, -115, -115, -114, -114, -115, -114, -115, -115, -113,
-113, -113, -114, -114, -114, -114, -113, -114, -113, -113, -113, -112, -112,
-113, -112, -112, -112, -113, -113, -112, -111, -111, -112, -112, -111, -111,
-112, -111, -111, -111, -111, -111, -110, -111, -111, -110, -111, -110, -110,
-110, -110, -110, -110, -109, -110, -109, -109, -109, -109, -108, -109, -109,
-108, -109, -108, -109, -108, -108, -107, -107, -108, -108, -107, -108, -107,
-108, -107, -107, -106, -107, -107, -106, -106, -106, -106, -106, -106, -106,
-105, -106, -105, -106, -105, -105, -105, -105, -105, -106, -104, -105, -104,
-104, -105, -105, -104, -104, -104, -103, -104, -104, -103, -103, -104, -103,
-103, -103, -103, -103, -102, -103, -103, -103, -103, -102, -102, -102, -102,
-102, -102, -102, -102, -101, -102, -102, -101, -101, -101, -101, -100, -101,
-101, -101, -101, -99, -101, -101, -100, -100, -100, -100, -99, -100, -99, -99,
-100, -99, -99, -98, -99, -99, -99, -99, -98, -98, -98, -98, -97, -97, -97, -97,
-97, -98, -96, -97, -96, -96, -97, -96, -96, -97, -96, -95, -96, -95, -96, -95,
-95, -95, -94, -93, -89, -87, -84, -82, -79, -76, -73, -69, -66, -62, -57, -53,
-48, -42, -36, -31, -24, -17, -8, -1, };