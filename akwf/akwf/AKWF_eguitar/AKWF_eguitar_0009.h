#define DATA_LENGTH 512
#define DATA AKWF_eguitar_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 9, 15, 22, 29, 38, 47, 57, 68,
82, 96, 112, 118, 119, 119, 119, 118, 119, 119, 119, 119, 118, 119, 118, 118,
118, 117, 117, 117, 118, 106, 85, 63, 43, 25, 10, -2, -11, -16, -17, -15, -10,
-3, 8, 20, 35, 53, 73, 93, 112, 117, 117, 117, 116, 117, 116, 116, 116, 116,
116, 116, 116, 116, 114, 115, 115, 115, 114, 114, 114, 115, 114, 114, 114, 114,
114, 114, 114, 113, 113, 113, 113, 112, 112, 112, 112, 113, 112, 112, 113, 113,
112, 112, 111, 112, 111, 111, 112, 111, 110, 111, 111, 110, 110, 111, 110, 110,
110, 110, 109, 109, 109, 109, 109, 108, 109, 109, 108, 108, 109, 108, 108, 108,
108, 107, 107, 108, 107, 106, 107, 106, 107, 107, 106, 105, 106, 106, 106, 105,
105, 106, 105, 105, 105, 104, 105, 105, 104, 104, 104, 105, 104, 104, 104, 104,
103, 103, 103, 103, 102, 103, 103, 102, 103, 102, 102, 101, 102, 102, 101, 101,
102, 101, 101, 101, 100, 100, 100, 101, 101, 100, 100, 100, 100, 100, 99, 99,
98, 97, 95, 93, 91, 89, 86, 85, 84, 81, 79, 77, 75, 74, 73, 70, 71, 69, 68, 67,
65, 64, 63, 62, 61, 60, 58, 57, 57, 55, 54, 54, 53, 53, 51, 51, 50, 48, 47, 46,
45, 44, 42, 41, 39, 37, 36, 35, 33, 32, 29, 28, 26, 25, 24, 23, 21, 20, 19, 17,
17, 15, 13, 11, 9, 7, 6, 3, 2, 0, -3, -5, -8, -10, -13, -15, -18, -22, -24, -27,
-31, -34, -37, -40, -43, -45, -49, -51, -54, -57, -60, -62, -64, -66, -69, -73,
-80, -86, -94, -101, -108, -114, -117, -115, -116, -115, -115, -115, -115, -115,
-115, -114, -114, -114, -114, -114, -114, -115, -114, -114, -114, -114, -114,
-113, -113, -113, -112, -112, -112, -113, -112, -113, -112, -112, -112, -112,
-112, -111, -111, -111, -110, -111, -110, -110, -111, -110, -110, -110, -110,
-110, -110, -110, -109, -109, -109, -109, -109, -109, -108, -108, -108, -108,
-109, -108, -108, -108, -108, -108, -107, -106, -107, -107, -106, -106, -106,
-106, -106, -106, -106, -106, -106, -105, -106, -106, -105, -105, -106, -105,
-105, -104, -105, -104, -104, -104, -104, -103, -104, -104, -103, -103, -103,
-103, -103, -104, -103, -102, -102, -102, -102, -102, -102, -102, -101, -102,
-101, -102, -101, -101, -101, -101, -101, -101, -100, -100, -100, -101, -100,
-99, -100, -99, -100, -99, -99, -99, -99, -99, -99, -98, -99, -98, -98, -98,
-98, -97, -98, -97, -97, -97, -97, -97, -97, -97, -96, -97, -96, -97, -95, -95,
-95, -94, -94, -93, -92, -92, -92, -91, -90, -90, -89, -88, -88, -87, -86, -84,
-82, -81, -79, -77, -76, -74, -72, -70, -67, -65, -63, -61, -59, -58, -55, -54,
-53, -51, -50, -48, -47, -46, -44, -43, -42, -41, -39, -39, -38, -38, -36, -35,
-34, -33, -32, -31, -30, -29, -27, -25, -23, -21, -20, -17, -15, -12, -9, -7,
-4, -1, };