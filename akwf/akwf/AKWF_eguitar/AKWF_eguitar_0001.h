#define DATA_LENGTH 512
#define DATA AKWF_eguitar_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {14, 90, 107, 96, 101, 99, 99, 100, 99,
99, 99, 98, 100, 98, 100, 99, 100, 99, 98, 99, 99, 98, 99, 99, 98, 98, 98, 98,
97, 99, 96, 76, 49, 27, 10, -7, -18, -26, -34, -38, -40, -41, -42, -38, -34,
-29, -22, -13, -3, 7, 18, 28, 40, 52, 64, 77, 88, 96, 97, 96, 97, 97, 96, 100,
93, 88, 28, -68, -115, -111, -106, -112, -107, -111, -108, -109, -110, -108,
-110, -109, -109, -109, -109, -108, -108, -107, -108, -107, -108, -107, -107,
-107, -106, -107, -108, -100, -76, -46, -21, 6, 30, 51, 73, 92, 100, 99, 98, 98,
99, 99, 98, 98, 98, 98, 98, 98, 98, 98, 98, 98, 98, 97, 98, 98, 98, 98, 97, 98,
97, 98, 97, 97, 97, 97, 96, 96, 96, 97, 97, 88, 69, 49, 36, 24, 15, 8, 4, 2, 1,
2, 5, 10, 16, 23, 31, 41, 50, 62, 73, 84, 95, 93, 97, 94, 95, 99, 72, -31, -116,
-111, -111, -111, -111, -111, -111, -111, -111, -111, -110, -111, -111, -111,
-110, -111, -111, -111, -111, -111, -110, -110, -110, -110, -110, -109, -110,
-101, -79, -55, -34, -15, 1, 13, 22, 29, 32, 32, 33, 30, 26, 21, 13, 7, -3, -13,
-23, -34, -46, -58, -71, -82, -95, -104, -108, -108, -106, -110, -105, -109,
-107, -96, -84, -16, 74, 108, 97, 99, 99, 96, 100, 97, 98, 98, 98, 98, 98, 98,
98, 99, 98, 97, 98, 98, 97, 97, 98, 96, 97, 97, 97, 97, 96, 96, 97, 95, 81, 61,
45, 33, 21, 13, 8, 4, 1, 2, 2, 6, 9, 13, 21, 29, 37, 45, 56, 67, 77, 88, 94, 97,
96, 96, 97, 96, 96, 96, 96, 96, 95, 96, 96, 95, 95, 95, 94, 95, 95, 94, 94, 95,
94, 94, 94, 95, 95, 93, 94, 94, 94, 93, 93, 93, 93, 93, 94, 93, 93, 93, 93, 92,
92, 93, 93, 93, 92, 92, 91, 92, 93, 92, 91, 92, 92, 92, 91, 92, 91, 91, 91, 91,
91, 90, 90, 91, 90, 90, 89, 90, 89, 89, 89, 89, 89, 87, 87, 84, 85, 82, 82, 81,
80, 79, 79, 78, 77, 75, 73, 72, 70, 66, 64, 61, 54, 51, 41, 33, 19, 1, -23, -66,
-105, -120, -118, -119, -118, -118, -118, -117, -119, -119, -119, -119, -118,
-118, -118, -118, -119, -118, -119, -119, -118, -118, -119, -118, -118, -117,
-118, -117, -117, -117, -117, -117, -117, -117, -117, -115, -104, -91, -81, -74,
-70, -67, -65, -67, -71, -76, -82, -90, -98, -108, -115, -116, -116, -116, -115,
-115, -115, -115, -116, -115, -116, -115, -115, -114, -115, -114, -114, -114,
-114, -113, -113, -114, -113, -113, -113, -113, -113, -113, -113, -113, -113,
-112, -112, -113, -113, -112, -112, -112, -112, -112, -110, -111, -110, -111,
-111, -111, -110, -110, -110, -110, -110, -110, -109, -109, -110, -110, -110,
-109, -109, -109, -110, -108, -109, -107, -110, -107, -109, -106, -108, -108,
-107, -106, -115, -70, };