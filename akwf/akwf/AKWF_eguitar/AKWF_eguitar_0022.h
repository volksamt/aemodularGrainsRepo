#define DATA_LENGTH 512
#define DATA AKWF_eguitar_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 23, 51, 86, 107, 109, 107, 108,
107, 107, 108, 107, 107, 107, 107, 108, 107, 106, 107, 107, 107, 107, 106, 106,
107, 106, 106, 106, 107, 106, 105, 106, 106, 106, 106, 106, 106, 106, 106, 106,
105, 106, 105, 105, 105, 105, 105, 105, 105, 105, 105, 105, 105, 105, 105, 104,
104, 104, 103, 104, 104, 103, 104, 103, 103, 103, 103, 104, 103, 104, 102, 102,
102, 102, 103, 102, 102, 102, 102, 101, 101, 102, 102, 103, 102, 101, 101, 102,
101, 101, 101, 101, 101, 100, 100, 101, 100, 101, 100, 100, 100, 100, 99, 100,
99, 99, 100, 99, 99, 99, 99, 98, 98, 99, 98, 98, 98, 98, 98, 97, 99, 98, 98, 98,
98, 98, 97, 97, 97, 97, 96, 97, 97, 97, 96, 96, 97, 96, 96, 96, 96, 96, 96, 96,
96, 96, 96, 96, 96, 95, 95, 95, 95, 95, 95, 94, 95, 95, 94, 94, 94, 93, 94, 94,
94, 94, 93, 94, 93, 94, 93, 94, 93, 93, 93, 94, 92, 93, 93, 93, 92, 92, 92, 92,
92, 92, 92, 92, 91, 91, 92, 91, 92, 91, 91, 91, 91, 91, 91, 91, 91, 91, 90, 90,
90, 91, 91, 91, 90, 91, 90, 90, 90, 90, 89, 89, 88, 89, 89, 89, 89, 89, 90, 89,
88, 88, 88, 88, 89, 89, 88, 88, 88, 88, 87, 88, 87, 88, 87, 86, 87, 86, 87, 84,
84, 81, 79, 78, 77, 74, 73, 71, 70, 67, 67, 64, 63, 62, 61, 59, 56, 55, 53, 51,
49, 46, 43, 38, 34, 28, 24, 19, 14, 8, 4, -2, -8, -15, -23, -32, -44, -57, -78,
-103, -118, -119, -118, -118, -118, -118, -118, -119, -118, -118, -119, -118,
-118, -118, -118, -118, -118, -117, -118, -118, -118, -118, -119, -118, -118,
-119, -119, -119, -119, -118, -118, -119, -119, -118, -119, -118, -119, -119,
-120, -119, -118, -118, -118, -119, -119, -119, -119, -118, -118, -118, -119,
-119, -118, -119, -119, -118, -119, -118, -118, -119, -118, -119, -119, -118,
-119, -118, -119, -119, -118, -118, -118, -117, -117, -118, -118, -117, -117,
-117, -116, -117, -117, -116, -117, -117, -116, -116, -117, -116, -117, -116,
-116, -115, -116, -115, -115, -116, -115, -115, -115, -114, -114, -116, -115,
-114, -114, -114, -115, -115, -114, -114, -114, -114, -113, -114, -113, -113,
-113, -113, -113, -112, -112, -113, -112, -112, -112, -113, -112, -112, -111,
-111, -111, -112, -112, -111, -111, -111, -111, -111, -111, -110, -110, -110,
-110, -111, -110, -110, -110, -109, -110, -109, -110, -109, -109, -109, -108,
-109, -109, -109, -109, -108, -108, -108, -108, -108, -108, -107, -107, -108,
-108, -107, -107, -107, -108, -107, -107, -107, -106, -107, -106, -107, -106,
-106, -106, -106, -106, -106, -106, -104, -105, -105, -104, -105, -105, -105,
-104, -103, -104, -104, -103, -103, -102, -103, -104, -103, -103, -103, -103,
-103, -102, -103, -102, -100, -97, -94, -90, -87, -83, -79, -75, -71, -66, -61,
-55, -49, -40, -30, -18, -3, };