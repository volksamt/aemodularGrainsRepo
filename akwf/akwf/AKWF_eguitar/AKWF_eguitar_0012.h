#define DATA_LENGTH 512
#define DATA AKWF_eguitar_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 14, 27, 42, 54, 67, 81, 93, 104,
113, 117, 117, 117, 117, 117, 118, 117, 117, 117, 117, 117, 117, 117, 117, 117,
117, 117, 117, 117, 116, 116, 117, 116, 117, 116, 116, 116, 116, 116, 116, 116,
116, 116, 116, 115, 115, 116, 116, 116, 116, 116, 115, 115, 115, 116, 115, 115,
115, 115, 115, 116, 115, 115, 116, 115, 115, 115, 116, 114, 115, 115, 115, 115,
114, 115, 115, 115, 114, 114, 114, 115, 114, 114, 111, 108, 104, 101, 97, 95,
92, 91, 89, 87, 87, 86, 85, 86, 86, 86, 87, 87, 89, 91, 92, 94, 96, 98, 101,
104, 106, 108, 110, 113, 112, 113, 113, 113, 112, 112, 112, 112, 112, 112, 112,
111, 111, 111, 112, 111, 112, 112, 111, 111, 111, 110, 111, 111, 111, 111, 110,
111, 110, 110, 110, 110, 111, 109, 110, 110, 110, 109, 110, 110, 110, 110, 110,
110, 110, 109, 109, 109, 110, 109, 109, 109, 109, 109, 109, 109, 108, 109, 109,
108, 108, 108, 107, 108, 109, 108, 108, 109, 108, 107, 108, 107, 107, 107, 107,
107, 107, 107, 108, 106, 107, 106, 107, 106, 106, 106, 106, 106, 106, 105, 105,
106, 105, 105, 105, 105, 105, 106, 105, 105, 105, 104, 105, 105, 105, 105, 105,
105, 105, 104, 104, 105, 104, 105, 104, 103, 104, 103, 104, 104, 104, 103, 104,
103, 104, 102, 103, 103, 102, 100, 97, 93, 89, 84, 79, 72, 66, 58, 51, 42, 31,
20, 8, -4, -18, -33, -47, -61, -77, -92, -105, -113, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -118,
-119, -118, -119, -118, -119, -118, -118, -118, -118, -118, -118, -118, -117,
-118, -117, -117, -117, -117, -117, -117, -117, -117, -118, -117, -117, -117,
-116, -117, -117, -117, -117, -117, -117, -117, -116, -117, -117, -117, -116,
-115, -117, -117, -117, -116, -116, -117, -116, -117, -116, -116, -116, -114,
-110, -105, -101, -96, -92, -89, -87, -84, -82, -80, -79, -78, -77, -77, -77,
-78, -78, -80, -81, -81, -84, -86, -88, -91, -93, -97, -99, -102, -105, -109,
-112, -114, -114, -115, -114, -114, -115, -113, -113, -114, -113, -114, -113,
-114, -113, -113, -114, -113, -113, -113, -114, -114, -113, -113, -113, -113,
-112, -113, -112, -112, -112, -112, -112, -111, -112, -112, -111, -112, -111,
-112, -112, -111, -112, -112, -111, -111, -111, -111, -111, -111, -111, -110,
-110, -110, -111, -111, -111, -111, -111, -110, -110, -110, -110, -110, -110,
-109, -110, -110, -110, -110, -109, -110, -110, -110, -109, -109, -109, -109,
-109, -109, -109, -109, -109, -108, -108, -108, -107, -108, -107, -108, -108,
-107, -107, -107, -107, -107, -107, -107, -106, -107, -107, -107, -107, -107,
-107, -107, -106, -107, -107, -107, -106, -106, -106, -106, -105, -107, -106,
-106, -105, -105, -105, -105, -105, -105, -105, -104, -104, -106, -105, -105,
-105, -104, -104, -102, -100, -96, -91, -85, -79, -72, -63, -55, -47, -36, -24,
-10, 0, };