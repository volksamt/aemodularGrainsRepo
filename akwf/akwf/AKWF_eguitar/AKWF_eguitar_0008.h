#define DATA_LENGTH 512
#define DATA AKWF_eguitar_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 14, 18, 20, 24, 26, 27, 29,
30, 31, 33, 34, 37, 37, 39, 38, 39, 40, 41, 42, 42, 42, 44, 44, 44, 46, 48, 50,
54, 61, 66, 72, 79, 85, 92, 99, 106, 114, 116, 116, 115, 115, 115, 115, 115,
116, 115, 115, 115, 114, 114, 113, 114, 114, 114, 114, 114, 113, 113, 112, 113,
112, 113, 112, 113, 113, 113, 111, 112, 113, 112, 111, 111, 111, 111, 111, 112,
112, 111, 110, 110, 110, 109, 110, 110, 110, 109, 109, 109, 109, 110, 109, 109,
108, 108, 109, 108, 108, 108, 107, 107, 107, 108, 107, 107, 107, 106, 107, 107,
106, 106, 106, 106, 106, 106, 106, 105, 104, 106, 104, 105, 105, 105, 105, 105,
105, 105, 104, 104, 103, 104, 104, 104, 103, 103, 103, 102, 102, 102, 103, 102,
102, 102, 101, 102, 102, 102, 101, 101, 100, 101, 100, 100, 100, 100, 100, 100,
100, 99, 100, 99, 100, 99, 99, 100, 98, 99, 98, 99, 98, 99, 97, 98, 98, 98, 98,
97, 97, 97, 97, 97, 97, 96, 97, 96, 97, 96, 97, 96, 96, 94, 93, 91, 90, 88, 87,
85, 83, 81, 80, 78, 77, 75, 73, 71, 70, 69, 68, 66, 65, 64, 63, 61, 59, 57, 56,
54, 51, 49, 47, 45, 43, 40, 38, 36, 33, 31, 28, 26, 23, 22, 20, 18, 16, 15, 15,
14, 14, 14, 14, 14, 15, 15, 15, 14, 14, 14, 14, 15, 14, 14, 12, 11, 11, 10, 9,
7, 5, 2, 0, -3, -6, -8, -12, -15, -17, -20, -24, -28, -33, -38, -44, -51, -57,
-61, -66, -70, -74, -79, -83, -86, -89, -93, -98, -104, -108, -114, -119, -120,
-119, -119, -119, -118, -119, -119, -118, -118, -119, -117, -118, -117, -117,
-117, -117, -117, -116, -118, -117, -117, -116, -117, -116, -116, -116, -115,
-115, -115, -115, -108, -91, -77, -67, -57, -50, -46, -45, -47, -53, -61, -74,
-88, -103, -114, -114, -114, -114, -114, -113, -113, -113, -113, -113, -113,
-113, -111, -112, -113, -112, -111, -112, -111, -111, -111, -111, -112, -110,
-110, -111, -110, -111, -111, -110, -111, -110, -110, -110, -110, -110, -109,
-110, -109, -108, -109, -108, -108, -108, -108, -108, -108, -107, -107, -108,
-107, -107, -107, -107, -106, -107, -106, -106, -107, -106, -105, -106, -106,
-106, -104, -105, -104, -104, -105, -105, -104, -104, -104, -105, -103, -105,
-104, -104, -103, -104, -103, -104, -104, -104, -103, -103, -103, -102, -102,
-101, -102, -102, -101, -101, -101, -101, -101, -102, -101, -101, -100, -101,
-100, -101, -100, -100, -100, -99, -96, -93, -89, -87, -84, -82, -79, -78, -77,
-76, -75, -76, -76, -76, -76, -76, -76, -76, -75, -75, -74, -73, -71, -71, -69,
-66, -64, -62, -60, -57, -55, -52, -49, -46, -44, -42, -40, -38, -36, -34, -32,
-31, -29, -27, -26, -24, -22, -20, -20, -18, -17, -15, -15, -13, -12, -10, -10,
-9, -10, -10, -9, -9, -9, -8, -7, -7, -6, -4, -2, 0, };