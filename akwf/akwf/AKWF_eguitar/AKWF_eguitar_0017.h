#define DATA_LENGTH 512
#define DATA AKWF_eguitar_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {40, 94, 117, 112, 96, 98, 107, 107,
100, 99, 101, 105, 102, 100, 99, 103, 103, 101, 100, 101, 102, 102, 102, 101,
102, 102, 101, 101, 101, 101, 101, 101, 101, 101, 101, 101, 99, 100, 101, 101,
100, 100, 100, 100, 101, 100, 100, 99, 100, 99, 99, 100, 100, 99, 99, 99, 99,
99, 98, 99, 100, 98, 91, 82, 70, 58, 46, 38, 30, 20, 11, 6, 0, -6, -12, -15,
-17, -19, -22, -25, -23, -21, -21, -24, -21, -10, -6, -20, -45, -76, -108, -119,
-114, -106, -110, -113, -112, -109, -109, -111, -112, -110, -109, -111, -111,
-110, -110, -109, -110, -111, -110, -110, -110, -110, -111, -109, -110, -109,
-111, -110, -108, -110, -111, -110, -108, -108, -110, -110, -109, -107, -108,
-110, -110, -107, -107, -110, -113, -108, -103, -109, -118, -116, -97, -52, 22,
92, 114, 104, 100, 101, 102, 101, 100, 101, 101, 101, 102, 101, 101, 101, 102,
101, 101, 101, 100, 101, 101, 101, 101, 101, 102, 101, 101, 100, 102, 102, 101,
100, 100, 102, 100, 98, 99, 101, 102, 99, 97, 100, 103, 101, 96, 96, 102, 104,
95, 90, 102, 116, 102, 59, -2, -69, -116, -119, -106, -103, -113, -116, -110,
-107, -109, -112, -111, -109, -108, -110, -111, -109, -108, -109, -110, -110,
-110, -110, -110, -110, -110, -110, -110, -110, -110, -110, -109, -109, -109,
-109, -109, -108, -109, -109, -108, -109, -108, -108, -108, -109, -108, -107,
-107, -109, -108, -106, -105, -108, -110, -107, -100, -88, -72, -54, -37, -23,
-15, -9, 4, 25, 52, 84, 106, 108, 102, 100, 103, 103, 102, 102, 102, 102, 101,
101, 101, 102, 102, 101, 101, 101, 102, 101, 101, 101, 102, 102, 101, 101, 101,
101, 101, 101, 101, 102, 101, 101, 100, 100, 100, 101, 101, 101, 100, 101, 101,
99, 100, 101, 100, 100, 100, 101, 99, 100, 99, 99, 99, 100, 100, 100, 96, 89,
76, 60, 50, 44, 34, 20, 12, 13, 12, -11, -46, -80, -107, -119, -114, -106, -107,
-112, -112, -108, -107, -110, -111, -111, -109, -109, -110, -111, -109, -109,
-109, -111, -111, -110, -109, -110, -110, -110, -109, -109, -110, -110, -109,
-109, -109, -109, -109, -108, -109, -109, -108, -107, -108, -110, -109, -107,
-106, -108, -110, -108, -105, -106, -109, -110, -106, -101, -96, -87, -68, -38,
8, 65, 105, 110, 101, 100, 102, 103, 102, 101, 101, 102, 101, 102, 101, 102,
102, 101, 100, 101, 102, 102, 101, 101, 103, 102, 101, 102, 101, 101, 101, 101,
101, 101, 102, 102, 101, 100, 102, 101, 100, 99, 100, 101, 99, 98, 99, 101, 101,
99, 98, 101, 103, 100, 95, 100, 106, 107, 97, 55, -24, -97, -120, -114, -109,
-110, -109, -110, -110, -110, -109, -110, -110, -110, -109, -109, -110, -109,
-109, -109, -109, -110, -110, -109, -110, -109, -110, -110, -110, -109, -109,
-108, -108, -109, -108, -108, -108, -108, -108, -107, -107, -109, -109, -107,
-106, -108, -110, -110, -103, -106, -116, -115, -71, -10, };