#define DATA_LENGTH 512
#define DATA AKWF_eguitar_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 12, 20, 25, 28, 30, 32, 37, 44, 52,
62, 73, 85, 95, 102, 103, 101, 98, 97, 98, 98, 100, 99, 99, 99, 97, 98, 98, 98,
99, 98, 99, 98, 98, 98, 98, 98, 99, 98, 98, 98, 98, 98, 98, 98, 98, 98, 98, 98,
98, 98, 97, 97, 97, 98, 98, 98, 97, 98, 98, 97, 98, 98, 98, 98, 97, 98, 97, 97,
98, 97, 98, 98, 97, 97, 96, 97, 98, 98, 97, 97, 97, 97, 96, 96, 97, 97, 97, 97,
96, 96, 94, 96, 98, 98, 97, 97, 95, 94, 95, 97, 98, 99, 98, 95, 93, 92, 95, 98,
101, 103, 102, 98, 85, 58, 18, -31, -76, -104, -113, -114, -108, -106, -106,
-107, -109, -108, -108, -109, -108, -108, -107, -107, -108, -107, -107, -109,
-108, -108, -108, -107, -107, -107, -107, -108, -108, -108, -108, -108, -107,
-107, -108, -107, -107, -108, -107, -108, -108, -107, -107, -107, -107, -108,
-108, -107, -108, -108, -107, -107, -107, -108, -107, -108, -108, -107, -108,
-107, -106, -105, -106, -111, -116, -116, -101, -67, -21, 30, 67, 90, 101, 106,
107, 104, 100, 96, 94, 94, 98, 100, 100, 100, 97, 95, 96, 97, 99, 99, 100, 98,
97, 97, 97, 98, 99, 99, 99, 98, 97, 96, 97, 98, 99, 98, 99, 97, 97, 97, 97, 97,
98, 98, 97, 97, 96, 97, 96, 97, 97, 97, 97, 98, 97, 96, 97, 96, 96, 96, 98, 98,
97, 95, 94, 93, 98, 105, 108, 98, 69, 24, -24, -63, -91, -107, -117, -119, -118,
-112, -106, -103, -104, -108, -112, -113, -110, -108, -107, -106, -107, -110,
-111, -111, -109, -108, -107, -107, -108, -109, -109, -108, -108, -107, -107,
-107, -106, -108, -107, -107, -108, -107, -107, -106, -107, -107, -107, -108,
-108, -108, -108, -108, -107, -106, -107, -108, -108, -108, -108, -105, -104,
-105, -106, -108, -110, -111, -114, -110, -97, -67, -21, 31, 73, 98, 106, 105,
102, 100, 99, 97, 96, 95, 98, 99, 100, 99, 98, 96, 97, 97, 99, 99, 99, 99, 97,
96, 97, 98, 98, 99, 99, 98, 96, 96, 97, 98, 98, 99, 98, 98, 97, 96, 97, 97, 99,
98, 97, 95, 95, 95, 96, 97, 97, 97, 96, 95, 94, 94, 96, 98, 98, 97, 95, 93, 93,
95, 96, 99, 99, 96, 91, 89, 91, 97, 104, 107, 104, 94, 77, 51, 14, -34, -78,
-110, -119, -119, -113, -106, -106, -107, -110, -111, -110, -109, -108, -108,
-108, -109, -109, -109, -108, -109, -108, -108, -108, -108, -108, -108, -108,
-108, -107, -107, -107, -108, -108, -107, -107, -107, -107, -107, -107, -107,
-108, -108, -107, -107, -107, -108, -107, -107, -107, -107, -108, -107, -106,
-107, -107, -108, -107, -107, -107, -107, -106, -106, -106, -106, -105, -106,
-106, -106, -106, -106, -105, -106, -105, -106, -105, -107, -106, -105, -106,
-106, -106, -106, -106, -105, -104, -104, -104, -105, -108, -107, -105, -101,
-96, -87, -79, -68, -57, -47, -38, -31, -24, -17, -7, };