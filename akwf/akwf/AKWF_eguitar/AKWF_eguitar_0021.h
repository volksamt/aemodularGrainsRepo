#define DATA_LENGTH 512
#define DATA AKWF_eguitar_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 31, 59, 82, 99, 111, 118, 119, 120,
116, 114, 113, 114, 117, 117, 116, 116, 114, 114, 115, 116, 116, 116, 116, 116,
115, 116, 116, 115, 117, 115, 116, 115, 115, 115, 116, 116, 116, 116, 116, 115,
116, 116, 116, 116, 115, 116, 115, 115, 116, 115, 116, 115, 115, 116, 115, 115,
114, 115, 115, 115, 114, 114, 114, 115, 115, 114, 114, 114, 114, 114, 114, 114,
114, 113, 114, 114, 114, 114, 114, 113, 113, 113, 114, 114, 115, 114, 110, 102,
91, 78, 65, 52, 38, 26, 10, -3, -16, -31, -47, -64, -81, -94, -103, -107, -109,
-110, -110, -107, -105, -106, -106, -107, -108, -108, -106, -106, -104, -105,
-106, -108, -109, -109, -107, -102, -94, -79, -59, -35, -15, 3, 19, 30, 40, 49,
55, 60, 65, 67, 70, 71, 72, 73, 76, 77, 79, 81, 86, 90, 94, 100, 106, 110, 113,
115, 114, 115, 114, 113, 114, 114, 113, 113, 114, 113, 114, 113, 113, 114, 113,
112, 113, 113, 113, 113, 112, 113, 112, 112, 113, 112, 112, 113, 112, 113, 113,
113, 112, 113, 113, 113, 113, 113, 113, 113, 111, 112, 112, 112, 112, 111, 112,
112, 111, 111, 112, 112, 111, 111, 110, 110, 110, 111, 111, 110, 110, 111, 110,
110, 109, 110, 110, 109, 109, 110, 109, 110, 110, 110, 110, 110, 110, 108, 107,
104, 101, 95, 92, 88, 83, 79, 76, 73, 70, 66, 63, 61, 58, 56, 54, 52, 49, 48,
45, 43, 41, 40, 37, 33, 31, 28, 25, 22, 17, 12, 7, 3, -4, -12, -19, -28, -38,
-51, -67, -81, -95, -105, -110, -113, -114, -114, -113, -112, -110, -111, -111,
-111, -112, -113, -112, -111, -111, -112, -112, -112, -112, -111, -111, -111,
-111, -111, -111, -111, -111, -112, -111, -110, -110, -111, -111, -111, -111,
-111, -111, -111, -111, -111, -112, -111, -110, -111, -111, -111, -110, -111,
-111, -111, -111, -111, -110, -111, -111, -111, -111, -110, -110, -110, -110,
-110, -110, -110, -110, -110, -110, -110, -110, -110, -110, -109, -110, -110,
-110, -108, -109, -110, -110, -110, -110, -109, -108, -109, -109, -110, -110,
-111, -109, -107, -104, -98, -92, -83, -75, -67, -60, -54, -47, -42, -36, -30,
-25, -20, -15, -10, -7, -3, 1, 4, 7, 10, 12, 13, 15, 16, 18, 18, 19, 20, 20, 19,
18, 18, 16, 15, 14, 12, 10, 8, 7, 4, 2, -1, -3, -5, -8, -12, -15, -19, -22, -25,
-28, -32, -35, -38, -41, -45, -48, -52, -55, -60, -62, -67, -70, -74, -76, -81,
-83, -87, -90, -93, -97, -99, -103, -105, -106, -107, -107, -108, -109, -107,
-107, -107, -107, -107, -107, -107, -107, -107, -107, -106, -107, -108, -107,
-107, -107, -106, -106, -107, -107, -107, -106, -106, -107, -107, -106, -106,
-105, -106, -106, -106, -106, -105, -106, -105, -105, -105, -105, -105, -105,
-105, -105, -105, -104, -105, -105, -105, -104, -105, -105, -104, -105, -105,
-106, -106, -103, -97, -90, -84, -77, -69, -59, -44, -20, };