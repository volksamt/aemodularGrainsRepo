#define DATA_LENGTH 512
#define DATA AKWF_eguitar_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 19, 29, 39, 48, 56, 64, 70, 77, 82,
87, 90, 95, 97, 99, 100, 99, 99, 99, 100, 99, 100, 99, 100, 100, 99, 99, 99, 99,
100, 99, 98, 99, 99, 99, 99, 99, 98, 98, 98, 98, 98, 98, 99, 98, 97, 99, 99, 97,
98, 98, 98, 98, 98, 97, 97, 97, 98, 97, 98, 97, 98, 97, 97, 97, 97, 97, 96, 97,
97, 96, 97, 98, 97, 91, 80, 66, 49, 35, 23, 12, -2, -12, -23, -33, -43, -52,
-61, -69, -76, -85, -93, -102, -109, -113, -114, -115, -114, -114, -113, -113,
-114, -113, -114, -114, -114, -113, -114, -113, -113, -113, -114, -113, -114,
-113, -113, -113, -113, -112, -112, -113, -113, -113, -113, -113, -113, -112,
-112, -112, -112, -112, -112, -113, -111, -111, -111, -111, -111, -111, -112,
-111, -110, -111, -112, -111, -110, -110, -113, -112, -104, -91, -74, -56, -39,
-24, -9, 8, 23, 37, 52, 68, 85, 96, 100, 100, 100, 99, 99, 99, 99, 99, 99, 99,
100, 98, 99, 99, 99, 98, 99, 99, 99, 99, 99, 99, 99, 99, 99, 100, 100, 99, 99,
99, 99, 100, 99, 99, 99, 98, 98, 99, 98, 99, 98, 99, 98, 98, 98, 98, 98, 97, 97,
98, 100, 94, 76, 44, -5, -59, -95, -112, -117, -115, -111, -112, -113, -113,
-112, -112, -112, -112, -112, -111, -112, -112, -112, -112, -112, -112, -111,
-112, -112, -111, -111, -112, -113, -114, -113, -96, -53, 4, 54, 92, 108, 103,
95, 97, 101, 100, 98, 97, 98, 101, 99, 98, 98, 99, 99, 98, 98, 99, 99, 99, 99,
99, 99, 98, 98, 98, 98, 99, 98, 97, 97, 98, 97, 97, 97, 97, 97, 96, 96, 97, 97,
96, 96, 95, 97, 97, 96, 95, 97, 98, 98, 93, 81, 60, 31, -14, -63, -97, -114,
-119, -115, -112, -113, -115, -115, -113, -112, -113, -115, -114, -113, -113,
-114, -113, -113, -113, -113, -114, -113, -113, -113, -114, -114, -113, -113,
-113, -113, -113, -113, -112, -113, -112, -113, -112, -112, -111, -111, -112,
-112, -111, -111, -112, -111, -111, -111, -111, -113, -111, -106, -93, -71, -48,
-27, -8, 13, 34, 56, 79, 95, 101, 100, 100, 99, 99, 99, 99, 99, 98, 98, 99, 98,
98, 97, 98, 99, 99, 99, 98, 99, 98, 98, 99, 98, 98, 97, 98, 99, 98, 98, 98, 97,
97, 98, 98, 98, 97, 98, 97, 98, 97, 96, 97, 97, 97, 97, 96, 97, 97, 96, 96, 97,
97, 95, 96, 97, 97, 96, 90, 77, 60, 45, 29, 15, 0, -13, -24, -36, -48, -59, -68,
-76, -85, -94, -102, -110, -114, -115, -114, -113, -114, -114, -114, -113, -114,
-114, -114, -114, -114, -114, -114, -113, -114, -114, -113, -113, -113, -113,
-114, -113, -113, -113, -113, -112, -113, -112, -113, -113, -112, -112, -112,
-112, -112, -112, -112, -111, -112, -112, -111, -111, -111, -111, -112, -112,
-110, -112, -112, -111, -110, -111, -113, -111, -103, -90, -74, -57, -43, -29,
-17, -5, };