#define DATA_LENGTH 512
#define DATA AKWF_eguitar_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {67, 118, 89, 93, 96, 94, 92, 95, 93,
92, 94, 94, 93, 92, 94, 92, 93, 93, 94, 92, 93, 92, 94, 92, 93, 93, 93, 93, 94,
93, 92, 93, 92, 93, 91, 92, 92, 92, 92, 93, 93, 86, 73, 56, 44, 33, 24, 16, 9,
3, -4, -7, -12, -15, -17, -18, -15, -27, -68, -100, -110, -110, -105, -108,
-109, -108, -107, -109, -108, -107, -108, -108, -107, -108, -107, -107, -108,
-107, -107, -107, -107, -107, -107, -107, -107, -106, -107, -106, -105, -106,
-106, -105, -107, -107, -105, -105, -107, -104, -104, -108, -105, -80, -8, 77,
101, 97, 94, 92, 95, 94, 93, 94, 95, 92, 93, 94, 94, 93, 94, 94, 93, 94, 94, 93,
94, 94, 94, 94, 94, 94, 94, 94, 94, 94, 93, 94, 94, 93, 93, 93, 93, 93, 93, 93,
91, 93, 92, 84, 68, 49, 30, 9, -14, -48, -87, -105, -107, -108, -107, -106,
-107, -108, -106, -104, -109, -108, -100, -111, -115, -54, 29, 91, 108, 87, 89,
98, 92, 89, 94, 94, 91, 92, 93, 91, 92, 93, 93, 92, 93, 94, 92, 92, 92, 92, 92,
92, 92, 91, 91, 92, 91, 91, 91, 91, 89, 90, 91, 90, 90, 90, 90, 89, 91, 89, 88,
91, 90, 65, 9, -70, -111, -111, -110, -109, -109, -110, -110, -110, -109, -109,
-109, -109, -109, -108, -109, -110, -109, -109, -109, -108, -109, -109, -108,
-109, -108, -108, -108, -109, -108, -108, -107, -107, -108, -107, -107, -108,
-108, -106, -107, -107, -109, -102, -88, -69, -52, -40, -30, -18, -11, -6, 1, 5,
3, 12, 34, 67, 93, 95, 92, 93, 92, 92, 92, 93, 92, 93, 92, 91, 93, 92, 92, 92,
93, 92, 92, 92, 93, 92, 91, 92, 91, 92, 92, 91, 91, 91, 91, 90, 91, 91, 92, 91,
91, 91, 92, 92, 92, 66, -14, -84, -112, -115, -105, -107, -110, -108, -107,
-110, -109, -108, -108, -108, -108, -108, -109, -108, -108, -107, -108, -109,
-107, -107, -108, -109, -105, -107, -110, -105, -104, -110, -108, -98, -112,
-117, -83, -8, 84, 109, 89, 92, 97, 93, 92, 95, 93, 92, 92, 93, 92, 92, 93, 92,
92, 93, 92, 93, 93, 93, 92, 92, 92, 91, 92, 91, 92, 92, 92, 92, 92, 92, 91, 91,
92, 91, 91, 91, 90, 89, 91, 92, 85, 73, 55, 38, 25, 12, 0, -10, -19, -27, -34,
-39, -44, -47, -48, -48, -49, -47, -43, -40, -37, -30, -24, -18, -11, -3, 3, 10,
21, 29, 36, 46, 56, 61, 71, 82, 86, 88, 95, 94, 71, -11, -97, -114, -109, -109,
-110, -111, -110, -109, -110, -110, -109, -109, -110, -109, -109, -110, -111,
-110, -110, -109, -110, -109, -109, -110, -109, -109, -109, -108, -108, -108,
-108, -108, -107, -108, -107, -108, -107, -107, -106, -107, -107, -102, -88,
-74, -63, -54, -47, -41, -37, -33, -30, -30, -28, -28, -28, -31, -32, -36, -41,
-45, -48, -57, -61, -67, -76, -85, -86, -102, -119, -46, };