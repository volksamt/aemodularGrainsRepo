#define DATA_LENGTH 512
#define DATA AKWF_eguitar_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 52, 86, 96, 96, 93, 91, 89, 90, 90,
92, 91, 91, 89, 89, 90, 91, 91, 89, 89, 90, 91, 91, 91, 89, 89, 90, 92, 91, 90,
90, 89, 90, 92, 91, 89, 87, 88, 90, 91, 91, 88, 87, 90, 92, 93, 90, 86, 86, 91,
95, 94, 86, 81, 85, 99, 106, 94, 66, 25, -26, -77, -114, -119, -109, -100, -101,
-109, -113, -112, -106, -104, -106, -110, -110, -109, -106, -106, -108, -109,
-108, -107, -105, -105, -107, -108, -108, -106, -105, -107, -107, -108, -107,
-105, -104, -105, -108, -107, -106, -104, -104, -106, -108, -107, -105, -104,
-103, -108, -110, -107, -103, -101, -106, -113, -115, -109, -92, -56, 3, 65, 99,
104, 94, 90, 89, 92, 92, 93, 91, 92, 91, 91, 92, 92, 92, 91, 92, 91, 91, 90, 90,
91, 91, 90, 91, 91, 90, 91, 90, 91, 90, 89, 90, 91, 91, 91, 90, 90, 90, 91, 90,
90, 88, 89, 89, 91, 91, 89, 86, 87, 90, 92, 90, 88, 86, 87, 91, 93, 90, 83, 82,
90, 101, 100, 86, 56, 13, -41, -95, -119, -117, -106, -100, -105, -111, -112,
-109, -106, -105, -107, -108, -108, -107, -105, -105, -107, -108, -107, -106,
-106, -107, -106, -107, -107, -107, -107, -107, -106, -107, -107, -107, -107,
-107, -106, -107, -106, -106, -106, -106, -106, -106, -106, -106, -106, -106,
-106, -106, -106, -106, -105, -105, -105, -105, -105, -105, -106, -104, -104,
-105, -105, -105, -104, -104, -104, -105, -106, -105, -103, -96, -85, -72, -58,
-47, -36, -26, -19, -11, -4, 4, 9, 15, 20, 25, 29, 33, 42, 58, 75, 88, 93, 94,
93, 93, 92, 92, 92, 93, 93, 92, 92, 92, 92, 92, 93, 92, 91, 92, 92, 92, 92, 92,
91, 91, 92, 92, 91, 92, 91, 91, 92, 91, 92, 92, 91, 92, 92, 92, 92, 91, 92, 92,
91, 92, 91, 91, 91, 92, 92, 91, 92, 92, 91, 91, 91, 91, 90, 91, 90, 91, 90, 91,
90, 90, 91, 91, 90, 90, 90, 91, 91, 92, 90, 89, 82, 74, 64, 54, 46, 38, 30, 23,
17, 11, 6, 1, -3, -7, -11, -13, -16, -20, -22, -23, -25, -25, -26, -25, -26,
-24, -24, -23, -22, -19, -17, -15, -12, -9, -5, -2, 2, 5, 11, 14, 19, 23, 27,
32, 37, 42, 48, 51, 56, 61, 67, 73, 76, 82, 86, 89, 90, 91, 89, 88, 87, 89, 90,
90, 89, 86, 86, 89, 91, 91, 88, 84, 86, 90, 93, 90, 83, 80, 88, 101, 102, 85,
51, 7, -45, -96, -119, -119, -109, -101, -106, -111, -114, -110, -107, -106,
-108, -111, -110, -108, -106, -107, -109, -110, -110, -108, -107, -108, -109,
-109, -109, -108, -108, -109, -108, -109, -108, -108, -108, -108, -108, -108,
-107, -108, -107, -107, -109, -108, -107, -106, -106, -107, -108, -107, -106,
-106, -106, -107, -108, -107, -106, -106, -107, -108, -107, -106, -104, -106,
-108, -110, -107, -102, -97, -91, -82, -75, -66, -55, -25, };