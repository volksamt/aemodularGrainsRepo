#define DATA_LENGTH 512
#define DATA AKWF_eguitar_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 7, 8, 11, 14, 16, 18, 21, 25,
28, 33, 38, 44, 52, 60, 71, 84, 101, 117, 119, 119, 119, 119, 119, 119, 118,
118, 118, 119, 118, 118, 118, 118, 118, 117, 117, 117, 117, 117, 116, 117, 117,
117, 116, 116, 116, 116, 116, 116, 115, 116, 116, 115, 115, 115, 114, 114, 114,
114, 114, 114, 114, 114, 113, 114, 113, 114, 112, 113, 113, 113, 113, 113, 112,
112, 113, 112, 112, 112, 112, 111, 111, 111, 111, 110, 111, 110, 111, 110, 110,
109, 110, 110, 109, 110, 109, 109, 109, 108, 109, 108, 108, 108, 108, 108, 109,
108, 107, 108, 108, 107, 107, 107, 106, 107, 107, 106, 106, 106, 106, 106, 106,
105, 106, 106, 105, 106, 105, 105, 104, 105, 105, 104, 105, 104, 104, 104, 103,
103, 103, 104, 103, 103, 103, 103, 103, 102, 102, 103, 102, 102, 102, 102, 101,
101, 101, 102, 102, 101, 101, 101, 101, 100, 100, 100, 100, 100, 100, 100, 99,
98, 95, 95, 92, 89, 88, 86, 84, 82, 81, 79, 77, 75, 73, 72, 70, 68, 66, 64, 63,
61, 59, 58, 56, 54, 53, 52, 50, 49, 48, 47, 45, 44, 43, 41, 40, 39, 37, 36, 35,
34, 32, 31, 30, 29, 28, 27, 25, 24, 23, 23, 21, 21, 19, 18, 17, 17, 15, 15, 13,
13, 13, 11, 10, 9, 9, 8, 8, 7, 6, 6, 5, 4, 3, 3, 3, 1, 1, 0, 0, -2, -1, -2, -4,
-3, -4, -5, -6, -7, -8, -8, -9, -10, -10, -11, -11, -14, -14, -14, -15, -16,
-18, -18, -19, -21, -21, -22, -24, -24, -25, -26, -28, -29, -32, -33, -36, -38,
-41, -44, -49, -54, -60, -67, -77, -89, -106, -116, -116, -116, -116, -116,
-116, -116, -115, -115, -115, -114, -115, -115, -115, -115, -114, -114, -115,
-115, -115, -114, -114, -114, -114, -114, -113, -113, -114, -113, -113, -113,
-112, -113, -112, -113, -112, -112, -111, -112, -111, -111, -112, -111, -112,
-111, -110, -111, -110, -110, -110, -110, -109, -109, -110, -109, -108, -110,
-109, -109, -109, -109, -109, -108, -108, -109, -107, -107, -108, -107, -107,
-108, -107, -107, -107, -107, -107, -106, -107, -106, -106, -105, -106, -106,
-106, -106, -106, -105, -105, -105, -104, -105, -104, -105, -104, -104, -105,
-104, -104, -104, -103, -103, -103, -103, -104, -103, -103, -103, -103, -102,
-102, -103, -102, -102, -102, -102, -102, -101, -101, -101, -101, -101, -101,
-101, -101, -101, -101, -100, -100, -100, -100, -100, -99, -99, -99, -99, -98,
-100, -99, -99, -99, -99, -98, -98, -99, -97, -98, -97, -98, -97, -98, -97, -97,
-96, -97, -95, -92, -91, -89, -87, -86, -83, -82, -80, -78, -76, -74, -72, -72,
-69, -67, -66, -65, -63, -61, -60, -59, -57, -56, -55, -54, -53, -52, -50, -50,
-48, -46, -45, -44, -42, -41, -40, -38, -36, -35, -33, -31, -30, -29, -27, -25,
-24, -21, -19, -19, -17, -15, -13, -11, -9, -8, -7, -4, -4, -1, };