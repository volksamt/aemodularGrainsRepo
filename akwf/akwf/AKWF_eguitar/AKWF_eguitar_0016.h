#define DATA_LENGTH 512
#define DATA AKWF_eguitar_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 9, 20, 30, 43, 55, 68, 81, 94, 106,
111, 111, 111, 111, 111, 111, 110, 111, 112, 111, 111, 111, 111, 111, 110, 111,
110, 110, 110, 110, 109, 110, 110, 108, 102, 96, 92, 87, 81, 78, 73, 72, 70, 68,
67, 67, 67, 68, 70, 73, 78, 81, 87, 93, 99, 104, 108, 108, 108, 109, 109, 108,
108, 107, 108, 108, 108, 107, 108, 107, 107, 106, 107, 107, 107, 106, 106, 106,
107, 107, 106, 106, 106, 106, 105, 106, 105, 105, 105, 106, 105, 105, 105, 105,
105, 104, 105, 105, 105, 104, 104, 104, 104, 104, 105, 103, 103, 103, 103, 103,
103, 104, 103, 103, 102, 102, 102, 102, 102, 102, 102, 102, 103, 102, 102, 102,
101, 102, 102, 101, 102, 101, 101, 101, 101, 100, 100, 101, 100, 100, 100, 101,
100, 99, 99, 99, 100, 99, 99, 100, 99, 99, 99, 98, 98, 98, 98, 97, 97, 97, 97,
98, 96, 97, 96, 98, 97, 96, 96, 96, 97, 96, 96, 96, 95, 96, 95, 95, 95, 95, 95,
96, 95, 90, 78, 61, 40, 11, -24, -68, -109, -119, -118, -118, -118, -118, -117,
-118, -117, -117, -118, -118, -118, -118, -117, -117, -118, -117, -117, -117,
-117, -117, -118, -117, -116, -116, -117, -117, -116, -115, -116, -116, -116,
-117, -110, -96, -81, -69, -60, -52, -46, -42, -39, -39, -39, -42, -45, -49,
-55, -62, -70, -78, -87, -96, -106, -114, -115, -114, -114, -115, -115, -115,
-114, -115, -115, -114, -114, -114, -114, -114, -114, -114, -113, -113, -113,
-113, -113, -112, -112, -112, -112, -112, -112, -112, -112, -112, -112, -111,
-112, -111, -111, -111, -111, -111, -110, -111, -110, -111, -111, -110, -108,
-105, -100, -96, -92, -88, -84, -79, -75, -69, -65, -61, -56, -52, -49, -45,
-42, -39, -36, -34, -32, -29, -26, -23, -22, -19, -17, -15, -13, -10, -8, -5,
-4, -3, -1, 2, 5, 6, 8, 11, 13, 16, 19, 22, 26, 30, 35, 38, 41, 46, 49, 52, 55,
59, 63, 65, 68, 70, 72, 73, 74, 76, 79, 81, 81, 84, 87, 89, 89, 91, 91, 91, 91,
91, 90, 89, 89, 89, 87, 87, 88, 87, 86, 85, 83, 80, 77, 74, 71, 68, 66, 62, 58,
54, 50, 45, 41, 37, 32, 26, 21, 14, 8, 1, -6, -13, -22, -32, -41, -50, -61, -71,
-82, -95, -107, -112, -111, -110, -111, -110, -110, -110, -111, -110, -110,
-110, -110, -110, -110, -109, -109, -110, -110, -110, -109, -110, -109, -110,
-109, -109, -109, -109, -109, -109, -109, -109, -109, -108, -108, -108, -107,
-108, -109, -102, -92, -84, -77, -70, -64, -61, -58, -56, -54, -54, -54, -55,
-58, -59, -62, -64, -69, -71, -75, -80, -84, -88, -92, -95, -99, -102, -105,
-106, -106, -105, -106, -106, -105, -105, -105, -105, -105, -105, -105, -103,
-104, -103, -104, -104, -103, -102, -100, -97, -94, -90, -86, -83, -80, -75,
-71, -66, -63, -58, -54, -49, -44, -39, -34, -27, -22, -16, -8, -2, };