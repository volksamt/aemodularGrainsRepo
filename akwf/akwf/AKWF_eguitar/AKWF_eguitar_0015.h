#define DATA_LENGTH 512
#define DATA AKWF_eguitar_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 30, 61, 94, 111, 117, 114, 112,
115, 113, 114, 114, 113, 113, 113, 113, 113, 114, 113, 113, 113, 113, 114, 112,
113, 112, 112, 113, 113, 113, 113, 112, 112, 112, 112, 112, 112, 112, 111, 111,
111, 111, 110, 111, 112, 112, 111, 111, 112, 110, 101, 89, 77, 66, 58, 48, 40,
35, 30, 25, 23, 19, 18, 18, 19, 19, 22, 25, 28, 31, 35, 40, 45, 51, 57, 62, 67,
73, 81, 86, 92, 98, 104, 108, 110, 110, 110, 110, 110, 110, 109, 109, 109, 109,
109, 109, 109, 108, 108, 109, 108, 109, 108, 108, 107, 108, 107, 108, 107, 107,
106, 107, 107, 106, 107, 106, 107, 106, 107, 107, 106, 103, 97, 90, 85, 77, 70,
63, 53, 44, 32, 20, 6, -9, -25, -42, -59, -78, -96, -113, -120, -118, -119,
-118, -119, -119, -119, -118, -118, -118, -118, -118, -118, -118, -119, -118,
-117, -118, -117, -117, -118, -117, -117, -116, -117, -117, -117, -116, -116,
-117, -117, -117, -116, -116, -116, -116, -116, -117, -116, -117, -116, -117,
-116, -117, -116, -107, -94, -77, -64, -51, -39, -27, -16, -5, 4, 14, 22, 29,
37, 43, 50, 57, 61, 67, 70, 74, 75, 75, 76, 74, 71, 67, 59, 52, 43, 32, 18, 6,
-9, -26, -42, -58, -78, -97, -111, -118, -116, -115, -115, -115, -115, -114,
-116, -115, -114, -115, -114, -114, -114, -115, -114, -115, -114, -113, -113,
-114, -114, -114, -114, -114, -114, -114, -112, -113, -113, -112, -112, -113,
-111, -112, -112, -113, -111, -111, -113, -112, -106, -92, -74, -50, -25, 7, 53,
91, 113, 115, 110, 112, 112, 111, 112, 112, 111, 111, 112, 111, 111, 111, 112,
112, 111, 111, 111, 111, 111, 111, 111, 111, 111, 111, 110, 110, 110, 110, 110,
110, 111, 109, 109, 110, 110, 108, 109, 110, 103, 87, 65, 44, 27, 11, -7, -20,
-34, -47, -59, -69, -77, -86, -94, -102, -109, -113, -114, -114, -114, -113,
-114, -113, -114, -114, -114, -113, -114, -113, -113, -113, -113, -113, -113,
-113, -113, -114, -112, -112, -113, -112, -111, -112, -112, -111, -112, -113,
-111, -111, -117, -111, -86, -42, 15, 68, 104, 114, 114, 110, 112, 113, 111,
111, 112, 111, 110, 112, 112, 111, 111, 112, 112, 111, 111, 111, 111, 111, 111,
111, 110, 110, 110, 110, 110, 110, 110, 109, 109, 109, 109, 109, 111, 110, 97,
59, -2, -65, -107, -118, -115, -114, -114, -113, -113, -114, -113, -113, -112,
-113, -113, -113, -114, -113, -114, -113, -113, -113, -114, -113, -113, -114,
-113, -114, -113, -113, -113, -113, -113, -113, -112, -113, -112, -112, -113,
-111, -111, -113, -112, -100, -79, -52, -30, -10, 9, 25, 40, 53, 64, 73, 81, 87,
90, 92, 94, 92, 89, 86, 81, 75, 68, 60, 52, 43, 33, 23, 12, 2, -8, -19, -31,
-42, -53, -63, -73, -83, -92, -101, -107, -113, -112, -111, -111, -112, -111,
-112, -111, -111, -110, -110, -111, -111, -108, -97, -78, -58, -35, -6, };