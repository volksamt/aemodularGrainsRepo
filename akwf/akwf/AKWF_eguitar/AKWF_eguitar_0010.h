#define DATA_LENGTH 512
#define DATA AKWF_eguitar_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 15, 28, 41, 55, 68, 81, 91, 101,
108, 113, 116, 116, 114, 112, 108, 105, 102, 99, 97, 97, 96, 98, 99, 100, 101,
103, 104, 106, 105, 105, 104, 103, 102, 101, 99, 99, 98, 99, 99, 100, 100, 101,
102, 102, 102, 102, 103, 103, 102, 101, 101, 101, 101, 100, 100, 100, 99, 100,
100, 100, 101, 100, 102, 102, 101, 102, 101, 101, 100, 100, 99, 99, 99, 99, 100,
100, 100, 101, 101, 100, 101, 101, 100, 101, 101, 101, 101, 101, 100, 101, 100,
100, 100, 100, 100, 101, 101, 100, 100, 100, 101, 101, 100, 100, 100, 100, 100,
101, 100, 100, 100, 100, 100, 99, 100, 100, 100, 100, 100, 100, 100, 100, 100,
99, 100, 100, 100, 100, 99, 99, 100, 99, 99, 100, 99, 99, 99, 100, 100, 99, 99,
99, 100, 99, 99, 99, 99, 99, 99, 99, 98, 99, 98, 99, 99, 99, 100, 99, 99, 99,
98, 98, 99, 98, 99, 99, 99, 98, 99, 98, 98, 99, 98, 98, 98, 98, 98, 98, 99, 97,
99, 98, 99, 98, 98, 98, 98, 98, 98, 98, 98, 98, 98, 97, 98, 97, 98, 97, 97, 97,
97, 97, 97, 98, 97, 97, 97, 97, 97, 96, 98, 96, 97, 97, 97, 97, 97, 97, 97, 97,
97, 97, 97, 96, 96, 96, 95, 96, 96, 96, 96, 96, 97, 98, 98, 99, 98, 97, 97, 97,
96, 96, 94, 92, 90, 89, 88, 85, 82, 79, 76, 72, 69, 66, 62, 59, 56, 53, 49, 46,
43, 40, 37, 33, 31, 28, 25, 22, 18, 16, 12, 8, 3, -4, -10, -18, -28, -36, -45,
-56, -65, -74, -82, -89, -96, -101, -106, -110, -113, -115, -117, -119, -119,
-119, -118, -118, -118, -117, -115, -114, -114, -113, -112, -112, -112, -114,
-113, -115, -115, -115, -116, -116, -116, -116, -115, -115, -114, -114, -114,
-113, -113, -113, -114, -114, -114, -114, -115, -114, -115, -115, -115, -115,
-115, -114, -114, -114, -113, -113, -114, -113, -114, -113, -113, -113, -114,
-115, -114, -114, -114, -114, -115, -113, -113, -113, -113, -113, -113, -113,
-114, -113, -114, -114, -114, -114, -114, -113, -113, -114, -114, -114, -114,
-113, -113, -114, -114, -114, -113, -114, -113, -114, -113, -114, -113, -113,
-114, -113, -113, -113, -113, -112, -112, -113, -113, -113, -113, -112, -113,
-112, -113, -114, -113, -113, -113, -112, -113, -113, -112, -113, -112, -112,
-112, -112, -112, -112, -113, -113, -112, -113, -112, -113, -112, -112, -112,
-112, -112, -111, -112, -111, -111, -111, -111, -111, -111, -111, -111, -111,
-111, -111, -112, -111, -111, -110, -111, -111, -111, -110, -110, -110, -110,
-110, -110, -111, -110, -110, -111, -111, -110, -111, -111, -111, -110, -111,
-111, -110, -110, -109, -109, -110, -110, -110, -110, -110, -111, -111, -111,
-110, -110, -111, -109, -110, -109, -110, -109, -110, -109, -110, -110, -109,
-111, -111, -111, -112, -112, -111, -111, -111, -110, -110, -108, -105, -102,
-97, -92, -85, -76, -67, -57, -45, -33, -22, -8, };