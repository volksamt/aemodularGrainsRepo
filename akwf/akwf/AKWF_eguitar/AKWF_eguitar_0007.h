#define DATA_LENGTH 512
#define DATA AKWF_eguitar_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 14, 17, 22, 27, 32, 37, 43,
50, 57, 64, 73, 81, 92, 103, 116, 119, 118, 119, 119, 118, 118, 119, 118, 118,
118, 117, 118, 118, 118, 118, 118, 117, 117, 117, 117, 117, 116, 117, 117, 116,
116, 116, 116, 116, 116, 116, 115, 115, 115, 115, 115, 115, 115, 114, 114, 114,
114, 113, 113, 113, 114, 113, 114, 114, 113, 114, 113, 112, 113, 112, 112, 112,
112, 111, 111, 112, 111, 112, 111, 110, 111, 110, 110, 110, 110, 110, 110, 110,
110, 110, 110, 109, 109, 109, 108, 109, 109, 109, 108, 108, 108, 108, 107, 108,
108, 108, 108, 107, 107, 107, 107, 107, 106, 107, 107, 106, 107, 105, 106, 106,
105, 106, 106, 104, 105, 105, 105, 104, 105, 105, 104, 104, 104, 103, 104, 104,
103, 104, 103, 103, 103, 103, 102, 102, 103, 102, 102, 102, 102, 102, 102, 101,
102, 101, 101, 101, 101, 101, 100, 100, 101, 100, 101, 100, 100, 100, 99, 99,
99, 99, 99, 99, 99, 99, 99, 97, 96, 93, 92, 90, 89, 86, 85, 83, 81, 80, 78, 76,
74, 73, 71, 68, 68, 66, 65, 63, 62, 60, 58, 57, 55, 54, 52, 51, 49, 48, 46, 45,
43, 42, 40, 40, 37, 36, 35, 34, 32, 31, 30, 29, 29, 27, 26, 25, 24, 24, 21, 22,
21, 19, 19, 17, 16, 15, 13, 12, 11, 10, 8, 7, 6, 4, 2, 1, -1, -2, -3, -5, -6,
-8, -8, -9, -10, -12, -12, -12, -12, -13, -13, -14, -16, -16, -17, -18, -19,
-19, -20, -22, -24, -25, -27, -27, -29, -31, -33, -35, -39, -42, -46, -50, -54,
-60, -67, -77, -86, -100, -112, -119, -118, -119, -118, -118, -118, -118, -117,
-118, -117, -118, -118, -117, -117, -117, -117, -116, -117, -116, -117, -116,
-116, -116, -116, -116, -115, -116, -115, -115, -114, -115, -116, -115, -115,
-114, -114, -114, -114, -114, -114, -113, -114, -114, -114, -113, -113, -113,
-113, -113, -112, -113, -112, -112, -112, -113, -112, -111, -112, -111, -111,
-112, -111, -111, -110, -110, -111, -110, -110, -109, -110, -110, -110, -109,
-109, -108, -108, -109, -109, -108, -108, -108, -108, -108, -108, -108, -107,
-107, -108, -107, -107, -107, -106, -107, -107, -106, -105, -106, -107, -106,
-105, -105, -106, -106, -105, -105, -105, -105, -105, -104, -105, -104, -103,
-104, -104, -103, -104, -104, -103, -103, -103, -103, -103, -102, -103, -103,
-102, -103, -102, -102, -102, -102, -102, -102, -102, -102, -101, -101, -101,
-101, -101, -100, -101, -100, -101, -100, -100, -101, -100, -99, -99, -99, -99,
-98, -98, -99, -98, -98, -96, -94, -93, -91, -89, -89, -87, -84, -84, -81, -80,
-79, -77, -76, -73, -72, -71, -69, -68, -66, -65, -63, -61, -61, -59, -58, -56,
-55, -52, -51, -51, -49, -47, -46, -44, -43, -42, -40, -38, -38, -36, -35, -33,
-31, -30, -28, -27, -26, -25, -22, -22, -20, -18, -17, -16, -13, -12, -10, -9,
-7, -6, -5, -3, -1, 0, };