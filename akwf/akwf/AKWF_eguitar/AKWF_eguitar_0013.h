#define DATA_LENGTH 512
#define DATA AKWF_eguitar_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {34, 76, 92, 99, 98, 95, 94, 96, 97,
96, 96, 96, 96, 95, 95, 96, 96, 96, 96, 95, 96, 96, 97, 95, 97, 95, 96, 96, 97,
96, 95, 96, 96, 95, 95, 95, 96, 96, 95, 95, 94, 94, 95, 95, 94, 96, 95, 95, 94,
95, 95, 95, 92, 85, 75, 61, 47, 35, 23, 12, 1, -8, -16, -24, -31, -37, -42, -46,
-49, -51, -53, -55, -55, -55, -55, -53, -52, -49, -47, -44, -40, -36, -32, -27,
-22, -16, -11, -5, 1, 7, 14, 21, 28, 34, 42, 49, 55, 63, 69, 76, 82, 89, 93, 95,
95, 95, 95, 95, 95, 95, 95, 95, 95, 94, 95, 96, 94, 94, 95, 94, 94, 94, 95, 95,
95, 95, 93, 93, 94, 94, 94, 93, 94, 93, 94, 93, 93, 93, 93, 93, 93, 93, 93, 93,
93, 92, 92, 92, 94, 93, 92, 92, 92, 92, 93, 92, 92, 92, 93, 93, 92, 92, 92, 93,
92, 92, 92, 92, 92, 92, 92, 92, 91, 92, 92, 92, 92, 92, 91, 92, 91, 92, 92, 90,
91, 91, 91, 91, 91, 91, 91, 91, 91, 90, 90, 91, 91, 90, 90, 90, 90, 90, 90, 90,
91, 89, 90, 89, 90, 89, 90, 89, 90, 89, 90, 89, 89, 90, 89, 89, 89, 89, 89, 88,
89, 89, 88, 89, 88, 89, 89, 89, 88, 88, 88, 88, 87, 88, 88, 87, 87, 87, 86, 87,
87, 87, 86, 87, 87, 86, 87, 87, 86, 86, 87, 85, 87, 86, 86, 87, 86, 87, 87, 86,
86, 86, 86, 86, 85, 86, 86, 86, 85, 85, 85, 86, 85, 85, 84, 84, 85, 85, 84, 84,
84, 84, 85, 84, 85, 83, 82, 77, 69, 58, 48, 36, 14, -19, -53, -85, -109, -119,
-118, -116, -118, -118, -118, -117, -117, -118, -119, -118, -118, -118, -118,
-118, -118, -117, -118, -119, -118, -118, -118, -119, -118, -118, -118, -118,
-117, -118, -118, -119, -118, -117, -118, -118, -118, -117, -117, -118, -118,
-118, -118, -119, -118, -118, -118, -117, -118, -118, -118, -118, -118, -118,
-114, -109, -99, -88, -77, -67, -58, -50, -43, -37, -32, -28, -25, -22, -20,
-20, -19, -20, -21, -23, -26, -28, -31, -36, -39, -44, -49, -54, -60, -67, -72,
-78, -85, -92, -100, -107, -113, -116, -118, -119, -118, -119, -118, -118, -118,
-119, -118, -119, -118, -118, -118, -118, -118, -118, -118, -118, -118, -117,
-118, -119, -118, -117, -118, -118, -118, -117, -117, -117, -118, -117, -117,
-118, -118, -116, -117, -117, -116, -116, -116, -116, -117, -116, -116, -116,
-116, -116, -116, -116, -116, -116, -116, -116, -117, -115, -115, -116, -115,
-115, -115, -115, -114, -114, -115, -115, -115, -114, -114, -114, -114, -114,
-114, -114, -114, -114, -114, -113, -114, -113, -113, -113, -114, -113, -113,
-114, -113, -113, -114, -113, -113, -113, -114, -112, -112, -112, -112, -113,
-112, -112, -112, -112, -111, -112, -112, -112, -111, -111, -111, -111, -110,
-112, -110, -112, -109, -105, -95, -81, -52, -7, };