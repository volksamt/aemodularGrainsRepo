#define DATA_LENGTH 512
#define DATA AKWF_eguitar_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {18, 44, 67, 94, 109, 112, 111, 110,
110, 110, 111, 111, 111, 110, 110, 111, 111, 110, 110, 109, 110, 110, 110, 110,
110, 109, 110, 109, 109, 109, 109, 110, 110, 109, 109, 109, 100, 85, 69, 54, 41,
30, 21, 11, 3, -1, -4, -6, -6, -5, -1, 4, 10, 17, 25, 35, 46, 56, 67, 78, 90,
103, 108, 109, 108, 108, 108, 108, 107, 107, 108, 107, 107, 106, 106, 106, 105,
106, 106, 106, 105, 105, 105, 106, 105, 105, 105, 106, 104, 105, 105, 105, 104,
104, 105, 104, 105, 104, 99, 89, 77, 62, 43, 18, -11, -49, -93, -116, -115,
-115, -115, -115, -115, -115, -114, -115, -115, -115, -115, -114, -115, -115,
-114, -114, -115, -115, -115, -114, -115, -114, -114, -115, -113, -113, -114,
-113, -113, -114, -109, -92, -70, -54, -38, -25, -13, -4, 3, 8, 10, 12, 11, 8,
3, -1, -9, -15, -24, -32, -42, -52, -63, -73, -84, -96, -105, -112, -112, -112,
-112, -112, -112, -113, -112, -111, -111, -111, -111, -110, -111, -111, -110,
-109, -110, -110, -109, -110, -106, -89, -67, -23, 14, 64, 115, 109, 109, 111,
108, 110, 109, 109, 109, 109, 109, 109, 109, 109, 108, 109, 109, 109, 108, 109,
108, 109, 108, 108, 107, 108, 108, 107, 107, 107, 108, 106, 93, 71, 54, 38, 26,
16, 9, 6, 4, 4, 7, 10, 15, 21, 29, 39, 48, 60, 71, 83, 95, 104, 107, 106, 106,
106, 106, 105, 106, 106, 106, 106, 105, 105, 105, 104, 105, 105, 104, 106, 103,
105, 105, 87, 46, -22, -91, -118, -113, -114, -115, -114, -114, -114, -114,
-113, -114, -114, -115, -114, -114, -113, -113, -113, -112, -112, -113, -112,
-113, -114, -86, -11, 71, 108, 108, 106, 107, 106, 106, 107, 105, 105, 105, 105,
105, 105, 104, 104, 105, 105, 105, 105, 105, 105, 104, 105, 105, 104, 103, 104,
104, 104, 103, 104, 104, 100, 80, 55, 34, 16, 1, -12, -23, -31, -36, -39, -39,
-36, -33, -28, -21, -13, -3, 7, 17, 29, 42, 53, 67, 77, 90, 100, 103, 103, 102,
103, 102, 103, 102, 103, 102, 102, 102, 102, 101, 101, 102, 101, 101, 101, 101,
100, 100, 100, 99, 100, 100, 100, 100, 98, 90, 70, 51, 22, -37, -103, -120,
-118, -119, -118, -119, -119, -119, -118, -118, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -118, -118, -119, -118, -118, -117, -118, -117,
-117, -117, -118, -114, -98, -77, -59, -45, -35, -27, -21, -19, -19, -22, -27,
-33, -41, -50, -59, -71, -82, -96, -110, -117, -118, -116, -116, -115, -116,
-116, -115, -116, -116, -115, -116, -115, -115, -115, -116, -115, -115, -114,
-115, -115, -114, -114, -114, -113, -114, -114, -113, -114, -113, -113, -113,
-113, -113, -113, -113, -113, -113, -112, -111, -112, -111, -111, -111, -111,
-112, -112, -111, -111, -111, -110, -110, -110, -110, -110, -109, -109, -109,
-109, -110, -109, -109, -109, -108, -109, -104, -92, -78, -62, -42, -20, -1, };