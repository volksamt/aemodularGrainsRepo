#define DATA_LENGTH 512
#define DATA AKWF_eguitar_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 13, 16, 19, 24, 29, 34,
42, 51, 61, 76, 97, 116, 120, 119, 119, 118, 118, 119, 118, 118, 119, 119, 118,
118, 118, 118, 118, 117, 118, 117, 116, 117, 117, 117, 116, 117, 116, 116, 116,
117, 117, 116, 115, 115, 115, 115, 115, 115, 115, 115, 115, 115, 115, 114, 114,
114, 114, 113, 113, 113, 113, 112, 114, 113, 113, 113, 113, 113, 112, 111, 111,
111, 112, 111, 112, 111, 111, 111, 110, 111, 110, 110, 110, 110, 111, 111, 110,
109, 110, 109, 109, 109, 109, 109, 109, 109, 108, 108, 109, 108, 107, 108, 107,
108, 108, 107, 107, 106, 107, 106, 106, 106, 106, 106, 106, 106, 106, 105, 105,
105, 105, 105, 106, 105, 105, 104, 104, 104, 104, 104, 104, 104, 103, 103, 104,
103, 103, 103, 102, 103, 103, 102, 103, 102, 102, 102, 102, 102, 102, 102, 101,
101, 101, 101, 101, 100, 100, 101, 100, 100, 99, 97, 95, 93, 91, 89, 87, 85, 84,
81, 79, 78, 76, 74, 72, 70, 68, 67, 64, 63, 61, 60, 58, 57, 56, 53, 52, 50, 48,
47, 46, 44, 44, 41, 40, 38, 38, 37, 35, 34, 32, 31, 30, 29, 27, 26, 25, 24, 23,
22, 21, 20, 19, 18, 18, 15, 15, 14, 14, 13, 12, 12, 10, 10, 9, 8, 8, 8, 7, 6, 5,
5, 5, 4, 2, 2, 2, 2, 1, 1, 1, 0, -1, 0, 0, 0, -1, -2, -1, -2, -2, -3, -3, -2,
-4, -3, -2, -4, -3, -4, -4, -4, -4, -4, -3, -4, -4, -5, -5, -7, -7, -9, -11,
-12, -14, -15, -17, -19, -20, -22, -24, -25, -27, -29, -31, -33, -36, -40, -42,
-46, -53, -58, -66, -77, -93, -110, -114, -114, -115, -114, -114, -114, -115,
-113, -114, -113, -113, -113, -113, -113, -113, -112, -113, -113, -112, -111,
-112, -112, -111, -112, -111, -111, -111, -111, -112, -110, -110, -110, -110,
-111, -110, -110, -110, -110, -110, -110, -109, -110, -109, -109, -109, -109,
-109, -109, -108, -107, -108, -108, -108, -107, -107, -107, -107, -107, -107,
-106, -107, -107, -107, -106, -107, -106, -106, -107, -106, -105, -106, -105,
-105, -106, -104, -104, -105, -104, -104, -104, -105, -104, -104, -104, -104,
-103, -104, -103, -103, -103, -102, -102, -102, -102, -102, -102, -102, -102,
-103, -102, -101, -101, -101, -102, -101, -101, -101, -101, -101, -101, -100,
-99, -99, -100, -99, -100, -99, -99, -100, -100, -99, -99, -99, -98, -99, -98,
-99, -98, -98, -97, -99, -98, -97, -97, -97, -97, -98, -97, -97, -96, -97, -96,
-96, -96, -96, -96, -96, -95, -96, -95, -96, -96, -95, -93, -92, -90, -88, -88,
-86, -85, -83, -82, -80, -79, -77, -76, -75, -72, -71, -70, -68, -68, -66, -65,
-64, -62, -60, -60, -59, -58, -56, -55, -54, -53, -52, -50, -49, -49, -48, -46,
-45, -41, -37, -33, -31, -29, -27, -25, -23, -22, -20, -17, -15, -13, -11, -10,
-9, -7, -5, -4, -2, -1, };