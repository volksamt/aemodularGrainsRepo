#define DATA_LENGTH 512
#define DATA AKWF_eguitar_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 19, 26, 35, 43, 51, 60, 68, 75, 82,
88, 94, 100, 105, 110, 112, 113, 113, 112, 112, 112, 112, 112, 112, 112, 112,
112, 111, 112, 112, 112, 111, 111, 111, 110, 111, 111, 111, 110, 112, 111, 111,
110, 110, 111, 111, 111, 110, 110, 110, 110, 110, 110, 110, 109, 109, 110, 110,
109, 110, 110, 109, 110, 110, 110, 110, 108, 104, 100, 95, 90, 85, 79, 73, 68,
61, 54, 47, 39, 30, 22, 14, 5, -4, -13, -23, -32, -42, -51, -62, -71, -81, -92,
-102, -111, -116, -119, -118, -118, -118, -118, -118, -118, -118, -118, -118,
-118, -117, -118, -118, -118, -117, -118, -118, -118, -117, -117, -117, -117,
-117, -117, -116, -117, -118, -116, -116, -117, -117, -116, -117, -116, -115,
-115, -117, -115, -116, -115, -115, -116, -115, -115, -115, -117, -116, -109,
-97, -81, -64, -46, -30, -14, 3, 22, 39, 56, 74, 94, 107, 111, 113, 112, 110,
110, 111, 111, 111, 110, 111, 112, 111, 111, 111, 110, 112, 110, 111, 111, 110,
111, 110, 111, 111, 111, 111, 110, 110, 111, 110, 111, 110, 109, 110, 110, 110,
110, 109, 109, 109, 109, 109, 109, 109, 108, 109, 110, 109, 108, 109, 110, 110,
106, 95, 77, 57, 36, 19, 2, -18, -36, -52, -69, -86, -103, -113, -118, -119,
-117, -117, -117, -117, -118, -118, -117, -117, -117, -118, -118, -117, -117,
-117, -117, -118, -118, -118, -117, -117, -116, -117, -116, -117, -117, -116,
-117, -116, -117, -116, -116, -116, -116, -116, -116, -116, -115, -115, -117,
-116, -112, -104, -93, -83, -70, -60, -49, -38, -27, -16, -8, 2, 12, 23, 31, 40,
50, 60, 68, 76, 84, 90, 97, 102, 107, 109, 111, 111, 111, 111, 111, 111, 111,
111, 111, 111, 112, 110, 111, 111, 111, 111, 111, 111, 111, 111, 110, 111, 110,
110, 110, 109, 110, 108, 104, 101, 96, 92, 89, 84, 79, 74, 69, 64, 58, 53, 48,
42, 37, 31, 27, 21, 17, 12, 6, 2, -2, -7, -12, -18, -21, -26, -31, -35, -40,
-44, -49, -52, -56, -60, -64, -68, -70, -73, -76, -77, -79, -80, -82, -84, -85,
-86, -87, -87, -88, -87, -86, -85, -83, -80, -79, -75, -71, -68, -64, -60, -57,
-52, -49, -44, -40, -36, -31, -25, -21, -15, -9, -3, 3, 9, 15, 21, 26, 33, 39,
45, 51, 57, 62, 66, 72, 75, 80, 83, 87, 91, 93, 96, 98, 99, 100, 101, 102, 102,
102, 101, 99, 97, 96, 93, 89, 85, 82, 77, 72, 67, 61, 56, 49, 42, 34, 28, 20,
12, 4, -4, -12, -20, -30, -37, -46, -54, -63, -73, -82, -92, -102, -112, -118,
-119, -119, -118, -118, -118, -118, -118, -118, -117, -117, -118, -118, -117,
-118, -117, -117, -117, -117, -118, -117, -117, -117, -117, -117, -117, -117,
-116, -116, -116, -116, -116, -116, -116, -116, -115, -115, -116, -115, -115,
-116, -115, -114, -115, -116, -113, -106, -97, -87, -77, -68, -59, -49, -42,
-32, -25, -15, -3, };