#define DATA_LENGTH 512
#define DATA AKWF_eguitar_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 24, 37, 49, 59, 67, 74, 80, 85, 88,
91, 92, 93, 93, 95, 95, 95, 94, 92, 92, 90, 87, 86, 84, 82, 80, 80, 79, 79, 80,
81, 82, 83, 84, 86, 87, 87, 88, 89, 89, 89, 88, 87, 87, 86, 84, 84, 83, 81, 82,
82, 82, 83, 83, 83, 85, 85, 85, 86, 87, 87, 87, 87, 87, 86, 85, 85, 86, 85, 84,
83, 83, 82, 83, 82, 83, 83, 83, 83, 84, 85, 86, 85, 86, 86, 86, 86, 86, 85, 85,
85, 84, 84, 84, 83, 83, 82, 82, 83, 83, 83, 82, 83, 84, 84, 84, 85, 85, 84, 84,
85, 85, 84, 84, 84, 83, 83, 82, 82, 83, 82, 83, 82, 84, 84, 84, 83, 83, 83, 84,
84, 83, 83, 84, 84, 83, 83, 82, 83, 82, 83, 82, 82, 83, 82, 83, 83, 82, 83, 83,
83, 83, 84, 83, 83, 83, 83, 83, 83, 83, 82, 83, 82, 83, 82, 82, 82, 82, 83, 82,
82, 83, 82, 82, 82, 82, 82, 83, 83, 83, 81, 82, 82, 82, 82, 82, 82, 81, 81, 82,
82, 82, 82, 82, 81, 82, 81, 82, 82, 82, 82, 82, 82, 82, 82, 82, 81, 83, 82, 82,
82, 83, 82, 82, 82, 82, 81, 81, 82, 81, 81, 81, 81, 81, 81, 80, 80, 81, 81, 82,
82, 82, 82, 83, 83, 82, 82, 83, 83, 82, 81, 81, 80, 80, 80, 79, 79, 79, 79, 79,
80, 81, 81, 83, 82, 84, 84, 83, 84, 84, 83, 83, 81, 79, 79, 77, 76, 75, 75, 73,
75, 76, 78, 81, 84, 87, 90, 94, 96, 97, 97, 95, 91, 86, 79, 71, 60, 49, 38, 24,
11, -1, -13, -25, -35, -46, -56, -65, -74, -82, -90, -98, -104, -109, -114,
-118, -120, -119, -119, -119, -119, -119, -119, -118, -116, -115, -112, -111,
-110, -110, -110, -110, -111, -111, -112, -113, -113, -114, -115, -115, -115,
-114, -114, -115, -114, -114, -113, -113, -113, -112, -112, -112, -112, -112,
-112, -112, -113, -113, -114, -113, -114, -114, -114, -113, -114, -113, -113,
-114, -114, -112, -112, -113, -113, -113, -113, -113, -113, -113, -113, -113,
-113, -113, -113, -113, -113, -112, -113, -113, -113, -113, -113, -113, -113,
-113, -113, -113, -112, -113, -112, -112, -113, -113, -113, -112, -113, -112,
-112, -112, -111, -112, -112, -112, -113, -112, -112, -112, -113, -113, -113,
-113, -113, -112, -113, -112, -113, -112, -112, -111, -111, -111, -111, -111,
-111, -111, -111, -112, -112, -112, -112, -113, -113, -113, -113, -113, -113,
-112, -112, -112, -112, -112, -111, -111, -110, -110, -111, -110, -110, -110,
-110, -111, -112, -112, -113, -112, -113, -114, -114, -114, -113, -113, -112,
-112, -112, -110, -110, -109, -108, -109, -108, -109, -109, -109, -111, -111,
-112, -113, -114, -114, -114, -115, -114, -114, -114, -112, -110, -110, -108,
-106, -105, -105, -106, -106, -106, -108, -111, -115, -116, -116, -117, -116,
-116, -116, -117, -115, -107, -97, -83, -70, -53, -37, -20, -5, };