#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0045

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 11, 17, 22, 28, 32, 36, 40, 45, 49,
52, 55, 59, 62, 65, 67, 69, 72, 74, 76, 78, 79, 81, 84, 85, 86, 87, 89, 89, 92,
93, 94, 95, 95, 95, 97, 102, 107, 108, 116, 117, 93, 88, 83, 79, 75, 69, 66, 62,
59, 55, 53, 49, 47, 43, 40, 38, 37, 33, 31, 30, 29, 27, 25, 23, 22, 21, 20, 19,
17, 16, 15, 14, 13, 13, 12, 11, 10, 9, 9, 9, 9, 8, 7, 6, 7, 6, 6, 6, 5, 5, 4, 5,
4, 3, 4, 3, 2, 3, 2, 2, 3, 2, 2, 3, 3, 3, 3, 2, 3, 3, 3, 3, 2, 1, 1, 0, 0, 0,
-2, -5, -7, -6, -6, -5, -7, -6, -6, -6, -7, -6, -7, -7, -7, -8, -7, -7, -7, -7,
-8, -8, -8, -7, -8, -8, -8, -8, -8, -8, -9, -8, -7, -8, -8, -9, -8, -9, -9, -9,
-9, -9, -9, -8, -9, -9, -9, -9, -10, -8, -9, -9, -9, -9, -10, -9, -9, -9, -9,
-9, -9, -9, -9, -9, -10, -9, -9, -10, -10, -10, -10, -9, -10, -10, -9, -9, -9,
-10, -9, -10, -10, -9, -10, -10, -10, -10, -10, -10, -10, -10, -10, -10, -10,
-10, -10, -10, -10, -10, -10, -9, -9, -10, -10, -10, -9, -10, -9, -10, -10, -10,
-9, -10, -10, -9, -9, -9, -10, -10, -9, -10, -10, -10, -10, -10, -10, -10, -10,
-9, -10, -9, -9, -10, -9, -10, -10, -9, -10, -10, -10, -9, -9, -9, -10, -10,
-10, -9, -10, -9, -9, -10, -9, -10, -9, -11, -13, -15, -17, -18, -20, -22, -24,
-25, -26, -27, -29, -31, -32, -34, -35, -38, -38, -40, -42, -43, -45, -46, -48,
-49, -51, -52, -53, -54, -56, -57, -58, -60, -60, -61, -62, -63, -64, -64, -64,
-64, -64, -64, -63, -64, -63, -64, -63, -63, -63, -64, -64, -63, -63, -63, -62,
-63, -63, -62, -63, -62, -63, -63, -62, -60, -60, -59, -58, -55, -54, -53, -52,
-50, -48, -47, -45, -43, -41, -39, -37, -35, -34, -32, -31, -28, -27, -25, -23,
-22, -20, -17, -16, -14, -12, -10, -8, -7, -5, -3, 0, 1, 3, 5, 6, 9, 10, 13, 15,
16, 19, 22, 24, 26, 28, 30, 32, 34, 35, 35, 35, 35, 35, 35, 36, 36, 35, 37, 37,
36, 36, 37, 37, 36, 37, 37, 37, 36, 36, 36, 36, 37, 37, 37, 37, 38, 37, 37, 38,
37, 37, 37, 37, 37, 37, 36, 36, 36, 37, 37, 37, 37, 36, 37, 37, 37, 37, 37, 37,
37, 38, 37, 38, 37, 36, 35, 34, 34, 33, 33, 33, 32, 31, 31, 30, 31, 30, 28, 29,
28, 28, 27, 26, 27, 26, 26, 26, 25, 25, 24, 23, 22, 22, 22, 21, 21, 20, 20, 19,
19, 18, 19, 18, 16, 17, 16, 16, 15, 15, 15, 14, 13, 12, 13, 11, 11, 11, 11, 9,
10, 9, 8, 8, 7, 7, 6, 6, 5, 6, 5, 4, };