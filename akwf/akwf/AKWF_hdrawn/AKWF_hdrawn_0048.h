#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0048

const PROGMEM int8_t DATA[DATA_LENGTH] = {75, 88, 83, 87, 82, 87, 83, 86, 84,
86, 84, 86, 84, 84, 83, 85, 83, 84, 82, 84, 83, 84, 83, 84, 84, 83, 84, 83, 84,
83, 84, 83, 84, 83, 83, 83, 84, 84, 83, 84, 84, 84, 83, 83, 84, 83, 83, 84, 83,
83, 83, 84, 83, 84, 83, 84, 84, 83, 82, 83, 82, 82, 83, 83, 82, 82, 82, 82, 77,
73, 73, 71, 69, 67, 65, 63, 62, 60, 58, 56, 53, 51, 48, 47, 46, 45, 43, 42, 41,
40, 38, 37, 35, 35, 32, 32, 30, 28, 27, 26, 24, 23, 21, 20, 18, 17, 15, 13, 11,
9, 8, 7, 5, 4, 2, 1, -1, -1, -3, -7, -9, -12, -14, -17, -19, -20, -23, -25, -27,
-29, -31, -33, -36, -38, -40, -42, -44, -47, -48, -50, -53, -55, -57, -59, -61,
-63, -66, -67, -70, -71, -74, -77, -79, -80, -83, -84, -87, -88, -91, -92, -94,
-96, -98, -100, -101, -103, -103, -107, -106, -112, -108, -116, -109, -122,
-107, -127, -68, 40, 15, 27, 19, 22, 17, 18, 15, 14, 13, 10, 10, 5, 6, 2, 1, -3,
-3, -6, -7, -10, -11, -13, -15, -18, -18, -22, -22, -24, -26, -28, -29, -31,
-34, -34, -36, -37, -40, -40, -42, -44, -46, -47, -48, -49, -50, -52, -53, -55,
-56, -56, -59, -59, -60, -62, -64, -65, -66, -68, -69, -70, -71, -73, -75, -76,
-77, -79, -81, -82, -84, -85, -86, -87, -88, -90, -91, -92, -95, -96, -97, -97,
-100, -103, -107, -108, -104, -104, -100, -99, -97, -95, -93, -90, -88, -86,
-84, -81, -79, -76, -75, -72, -69, -67, -64, -61, -60, -56, -54, -51, -48, -46,
-44, -43, -42, -41, -39, -38, -37, -35, -34, -34, -33, -31, -30, -29, -29, -28,
-26, -26, -25, -24, -24, -24, -22, -21, -21, -21, -21, -19, -19, -19, -20, -20,
-18, -19, -18, -19, -19, -19, -19, -19, -20, -20, -20, -22, -22, -24, -24, -24,
-27, -29, -30, -33, -36, -38, -39, -42, -45, -48, -51, -55, -58, -62, -65, -69,
-71, -75, -77, -80, -82, -84, -86, -88, -89, -90, -91, -93, -94, -96, -97, -100,
-101, -104, -106, -109, -111, -111, -112, -114, -114, -115, -116, -118, -117,
-118, -117, -117, -118, -118, -118, -118, -118, -118, -118, -117, -118, -117,
-117, -116, -117, -117, -117, -115, -115, -114, -114, -113, -112, -112, -111,
-110, -110, -109, -109, -109, -107, -107, -106, -105, -105, -105, -103, -102,
-101, -102, -100, -100, -99, -98, -97, -96, -95, -94, -93, -91, -90, -89, -88,
-87, -85, -84, -82, -81, -80, -79, -78, -77, -75, -75, -74, -73, -71, -71, -70,
-69, -66, -65, -64, -63, -62, -60, -59, -57, -56, -55, -53, -51, -51, -49, -48,
-47, -46, -45, -44, -43, -42, -41, -39, -38, -37, -35, -34, -34, -31, -30, -28,
-27, -25, -23, -22, -21, -19, -17, -16, -17, -16, -16, -16, -15, -15, -13, -13,
-12, -11, -10, -10, -9, -8, -6, -5, -4, -3, -1, 0, 1, };