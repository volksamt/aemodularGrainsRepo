#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 0, -1, -1, -1, -1, -1, -1, -1, -1,
-1, -1, -1, -1, -1, -1, -1, -1, -1, 0, -1, 0, -1, -2, -1, -2, -1, -1, 0, 0, -1,
0, -2, -1, -1, -1, -1, 0, -1, -1, -1, -1, -1, -1, 0, 0, -1, -1, -1, 0, 0, 0, 0,
-1, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 1, 0, -1, 0,
0, 0, 1, 0, 0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 0, 0, 1, 1, 1, 0, 0, 0, 1, 0, 2, -1,
1, 0, 5, 24, 7, -2, 1, 0, 1, 1, 1, -1, 1, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1,
1, 1, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, 1, 1, 0, 1, 1, 0, 1, 1, 0, 0, 0, 1, 0, 1,
-1, 1, -1, 5, -14, -28, -23, -25, -23, -25, -25, -24, -25, -25, -24, -24, -24,
-23, -27, -19, 2, -1, 1, 0, 0, 1, 1, 0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, -1, 1, 0,
1, 0, 1, -1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 0, 0, -1, 0, 0, 0, 0,
0, 1, -1, 0, -1, 0, 0, 0, 0, -1, -1, -1, -1, 0, -1, -3, -2, -3, -3, -4, -4, -4,
-4, -5, -6, -5, -6, -6, -6, -7, -8, -8, -9, -10, -10, -11, -11, -13, -12, -14,
-14, -15, -16, -16, -17, -17, -18, -18, -19, -19, -20, -20, -21, -22, -23, -24,
-24, -26, -27, -26, -28, -28, -30, -30, -31, -32, -34, -34, -37, -39, -40, -41,
-42, -43, -45, -49, -50, -78, -97, -98, -106, -106, -110, -110, -115, -115,
-116, -115, -117, -116, -117, -117, -117, -118, -118, -118, -119, -118, -118,
-120, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -118, -119, -118, -118, -117, -118, -116, -116, -117,
-116, -115, -113, -114, -114, -112, -111, -109, -107, -105, -102, -102, -102,
-101, -101, -100, -99, -96, -91, -85, -80, -76, -68, -62, -60, -58, -56, -53,
-51, -48, -46, -44, -41, -39, -37, -35, -33, -30, -28, -25, -23, -22, -20, -16,
-16, -13, -12, -11, -9, -8, -7, -8, -6, -5, -4, -3, -2, -3, -2, -1, -1, 0, 0, 0,
0, 1, 1, 2, 0, 2, 0, 2, 1, 1, 1, 1, 1, 1, 2, 1, 2, 0, 2, 0, 2, 0, 2, 0, 2, 0, 2,
0, 2, 0, 1, -1, 1, 1, 0, 2, -3, 6, -10, 84, 127, 113, 123, 115, 121, 116, 120,
118, 118, 118, 118, 119, 116, 120, 116, 122, 114, 124, 106, -1, -1, 1, -1, 1,
-1, 1, -2, 2, -2, 1, -2, 1, -1, 1, -2, 1, -1, 0, -1, 0, -1, -1, -1, -1, 0, 0, 0,
-1, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, -1, 1, };