#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0036

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 1, 0, -1, 0, 1, 3, 0, -1, -1, -2,
-1, -2, -2, -2, 2, 4, 4, -1, -2, 0, 0, 2, 2, 4, 4, 6, 6, 8, 9, 11, 11, 12, 13,
14, 15, 16, 17, 18, 19, 20, 21, 23, 23, 25, 26, 27, 27, 30, 30, 32, 33, 33, 34,
36, 36, 37, 40, 40, 40, 42, 44, 45, 45, 48, 49, 50, 50, 52, 54, 54, 56, 56, 58,
59, 60, 61, 63, 63, 64, 65, 67, 66, 69, 70, 70, 71, 72, 74, 74, 75, 77, 77, 78,
79, 81, 82, 83, 84, 85, 85, 86, 87, 88, 88, 89, 89, 89, 90, 89, 89, 89, 90, 90,
91, 91, 91, 91, 90, 91, 90, 91, 90, 91, 90, 91, 90, 90, 90, 90, 89, 89, 88, 88,
87, 87, 87, 86, 86, 86, 85, 86, 84, 85, 84, 84, 84, 83, 84, 83, 84, 81, 81, 76,
78, 73, 77, 65, 79, 32, -28, -19, -34, -33, -39, -38, -42, -42, -45, -46, -47,
-48, -48, -48, -47, -48, -48, -49, -49, -49, -49, -50, -50, -51, -50, -52, -52,
-52, -53, -54, -52, -53, -53, -52, -53, -53, -53, -52, -53, -53, -54, -54, -53,
-53, -54, -53, -54, -53, -53, -54, -54, -54, -54, -54, -55, -54, -55, -55, -54,
-53, -52, -51, -49, -49, -47, -47, -44, -44, -41, -40, -39, -37, -36, -36, -35,
-34, -33, -33, -32, -31, -30, -28, -26, -26, -24, -24, -23, -22, -21, -18, -17,
-16, -13, -12, -10, -8, -7, -7, -7, -6, -5, -4, -2, 0, 4, 6, 7, 8, 10, 12, 14,
15, 17, 17, 20, 20, 22, 23, 24, 24, 25, 27, 27, 27, 29, 29, 29, 30, 31, 32, 31,
31, 31, 31, 31, 31, 32, 32, 31, 32, 32, 32, 32, 32, 32, 32, 32, 31, 32, 31, 33,
30, 32, 30, 32, 30, 33, 30, 32, 27, 27, 23, 24, 21, 21, 19, 19, 19, 15, 24, -93,
-127, -111, -120, -112, -118, -112, -117, -110, -113, -109, -110, -107, -108,
-105, -105, -102, -101, -99, -97, -96, -95, -94, -92, -91, -89, -91, -89, -90,
-87, -88, -87, -87, -85, -85, -85, -81, -80, -78, -74, -74, -72, -70, -69, -66,
-65, -63, -61, -61, -60, -58, -57, -56, -55, -51, -49, -48, -47, -47, -45, -46,
-44, -44, -42, -42, -40, -39, -38, -36, -36, -35, -35, -34, -33, -32, -31, -29,
-27, -26, -25, -23, -23, -21, -20, -17, -16, -15, -12, -11, -10, -8, -7, -7, -4,
-2, -1, 0, 2, 3, 3, 3, 2, 2, 3, 2, 2, 3, 4, 4, 5, 4, 4, 5, 5, 4, 4, 4, 4, 4, 4,
5, 5, 5, 4, 5, 5, 5, 4, 3, 3, 3, 2, 2, 3, 3, 2, 3, 3, 3, 3, 2, 3, 2, 2, 2, 2, 2,
1, 2, 1, 1, 0, 0, 0, 1, 0, -1, 0, 1, 0, -1, -1, 0, -1, 0, 0, -1, 0, 0, 0, -1, 0,
1, 0, -1, -1, -1, 0, 0, 0, 0, 0, };