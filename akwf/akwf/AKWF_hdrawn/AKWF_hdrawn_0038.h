#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0038

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 4, 5, 5, 8, 9, 11, 10, 11, 11,
12, 16, 18, 20, 23, 24, 29, 32, 32, 34, 36, 38, 43, 45, 48, 50, 53, 55, 57, 58,
59, 61, 62, 63, 64, 66, 67, 66, 66, 68, 68, 68, 68, 70, 65, 66, 67, 67, 69, 71,
71, 73, 71, 73, 74, 75, 74, 74, 74, 74, 74, 74, 74, 74, 74, 74, 75, 75, 74, 74,
75, 74, 74, 74, 74, 74, 74, 74, 74, 74, 75, 73, 74, 75, 75, 76, 77, 76, 76, 76,
76, 76, 75, 75, 75, 75, 74, 74, 71, 69, 68, 66, 66, 64, 61, 60, 57, 55, 54, 51,
48, 47, 46, 44, 42, 41, 39, 40, 39, 38, 36, 37, 42, 44, 49, 54, 57, 66, 70, 72,
75, 78, 80, 80, 81, 83, 82, 82, 82, 82, 83, 83, 83, 84, 83, 83, 84, 84, 84, 84,
83, 85, 84, 84, 85, 85, 85, 85, 86, 86, 86, 86, 86, 86, 87, 86, 86, 86, 86, 86,
86, 86, 86, 86, 86, 85, 86, 86, 86, 85, 86, 85, 86, 86, 85, 86, 86, 86, 86, 86,
86, 86, 85, 86, 86, 86, 86, 86, 87, 86, 86, 86, 86, 86, 86, 85, 86, 86, 86, 86,
85, 85, 86, 86, 86, 85, 85, 85, 84, 85, 84, 83, 83, 83, 82, 83, 82, 83, 82, 82,
82, 82, 82, 81, 83, 82, 81, 80, 77, 76, 72, 68, 67, 66, 66, 67, 66, 67, 66, 67,
66, 66, 67, 67, 66, 64, -16, -76, -71, -85, -90, -94, -95, -99, -101, -104,
-104, -105, -107, -108, -108, -109, -111, -111, -112, -112, -114, -116, -116,
-115, -116, -117, -117, -117, -117, -117, -119, -119, -120, -119, -118, -119,
-119, -119, -119, -119, -119, -120, -119, -118, -115, -113, -111, -108, -104,
-101, -95, -88, -73, -49, -31, -20, -14, -8, 4, 6, 9, 11, 10, 10, 9, 9, 10, 9,
5, 5, 3, 2, -2, -6, -11, -16, -19, -21, -27, -29, -39, -56, -60, -64, -70, -72,
-74, -77, -81, -82, -84, -85, -86, -88, -88, -87, -89, -89, -89, -89, -89, -90,
-91, -91, -92, -92, -93, -94, -94, -95, -95, -96, -96, -96, -95, -96, -96, -95,
-96, -95, -96, -96, -96, -95, -96, -95, -95, -96, -95, -96, -96, -95, -96, -96,
-95, -95, -96, -96, -95, -95, -96, -97, -96, -96, -97, -97, -97, -97, -98, -98,
-98, -98, -97, -98, -97, -97, -98, -97, -97, -98, -98, -97, -98, -98, -98, -98,
-98, -97, -97, -98, -97, -98, -97, -97, -98, -98, -98, -97, -97, -97, -98, -98,
-98, -97, -97, -96, -96, -95, -96, -96, -95, -95, -95, -96, -95, -95, -95, -95,
-94, -94, -95, -93, -92, -91, -89, -90, -86, -84, -82, -80, -78, -73, -71, -68,
-66, -64, -61, -58, -57, -55, -54, -52, -51, -48, -46, -45, -45, -45, -44, -43,
-43, -42, -42, -42, -40, -38, -36, -35, -33, -32, -30, -29, -27, -24, -21, -17,
-14, -15, -15, -11, -9, -4, -4, 0, 3, };