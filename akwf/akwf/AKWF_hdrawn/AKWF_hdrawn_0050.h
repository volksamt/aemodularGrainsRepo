#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0050

const PROGMEM int8_t DATA[DATA_LENGTH] = {100, 119, 111, 118, 113, 117, 113,
118, 114, 117, 114, 116, 113, 116, 112, 118, 112, 120, 109, 126, 75, 8, 8, -5,
2, -3, 1, -2, 0, -2, 0, 9, 14, 14, 14, 13, 14, 14, 14, 14, 13, 13, 13, 14, 13,
14, 14, 14, 13, 14, 14, 14, 0, -2, -1, -2, -1, -2, -1, -2, 0, -2, -2, -2, -2,
-2, -2, -2, -2, -2, -2, -2, -3, -2, -2, -3, -3, -2, -2, -2, -2, -3, -4, -3, -3,
-4, -4, -3, -3, -3, -4, -4, -4, -4, -4, -4, -5, -5, -5, -4, -4, -4, -4, -4, -4,
-4, -5, -4, -4, -4, -4, -5, -4, -4, -5, -4, -5, -5, -5, -5, -5, -5, -5, -5, -6,
-5, -5, -5, -5, -6, -5, -6, -5, -5, -6, -6, -5, -5, -6, -5, -5, -5, -5, -6, -6,
-5, -5, -5, -5, -5, -6, -5, -5, -6, -5, -5, -5, -5, -5, -5, -5, -5, -6, -4, -5,
-5, -5, -6, -5, -5, -5, -5, -6, -6, -6, -5, -5, -5, -5, -5, -5, -5, -5, -5, -6,
-5, -4, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5, -4, -5, -4, -4, -4,
-5, -4, -4, -5, -4, -4, -4, -4, -4, -4, -4, -4, -3, -4, -4, -4, -4, -5, -4, -3,
-4, -4, -4, -3, -3, -4, -3, -3, -4, -4, -3, -4, -3, -3, -4, -4, -4, -3, -4, -3,
-3, -3, -4, -3, -4, -3, -3, -3, -3, -3, -3, -4, -4, -3, -3, -3, -4, -4, -4, -2,
-4, -2, -5, -26, -49, -72, -94, -116, -119, -118, -118, -118, -119, -118, -118,
-118, -119, -118, -119, -118, -118, -118, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -120, -118, -120, -120, -119,
-119, -119, -118, -120, -118, -119, -119, -119, -118, -113, -113, -50, -8, -2,
1, -1, 1, -1, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, -1, 1, -1, 0, 0,
-1, -1, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 2,
0, 2, 1, 1, 1, 1, 2, 2, 1, 1, 1, 1, 0, 1, 1, 1, 0, 2, 1, 1, 2, 1, 1, 2, 1, 1, 1,
1, 2, 1, 1, 1, 2, 1, 1, 1, 1, 2, 1, 1, 1, 2, 2, 1, 2, 1, 0, 2, 1, 1, 1, 1, 1, 2,
1, 1, 2, 1, 0, 2, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 2, 1, 1, 0, 0, 1,
2, 1, 1, 2, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 1, 1, 1,
1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, -1, };