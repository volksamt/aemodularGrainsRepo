#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, -1, 0, 0, 1, 2, 3, 5, 5, 7, 7, 8,
8, 9, 11, 12, 16, 16, 18, 21, 29, 45, 50, 52, 55, 59, 62, 62, 63, 65, 66, 66,
68, 70, 72, 72, 74, 73, 75, 75, 76, 77, 78, 77, 79, 81, 84, 85, 86, 86, 86, 88,
88, 89, 89, 89, 90, 91, 93, 94, 96, 96, 96, 97, 98, 98, 99, 100, 100, 100, 102,
101, 102, 103, 103, 104, 107, 107, 107, 108, 108, 109, 109, 109, 110, 110, 111,
111, 111, 111, 111, 112, 112, 112, 113, 114, 114, 114, 114, 116, 115, 116, 116,
117, 116, 116, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 118, 118,
118, 117, 118, 118, 117, 118, 119, 118, 117, 118, 118, 118, 118, 118, 118, 118,
119, 118, 118, 119, 119, 119, 119, 118, 118, 120, 119, 119, 119, 119, 118, 119,
119, 120, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 119, 118, 118, 118, 118, 119, 118, 118, 119, 118, 118, 118, 119,
118, 118, 118, 118, 117, 118, 118, 117, 117, 116, 117, 117, 117, 116, 117, 116,
117, 116, 115, 115, 115, 115, 114, 113, 113, 113, 113, 112, 111, 111, 111, 110,
111, 109, 109, 110, 108, 107, 105, 105, 104, 105, 104, 103, 100, 98, 97, 95, 95,
91, 93, 86, 94, 47, 16, 23, 15, 19, 12, 14, 8, 8, 3, 4, 1, 2, -1, 1, -4, -5,
-11, -11, -17, -67, -75, -81, -89, -93, -100, -102, -110, -110, -112, -111,
-113, -110, -114, -111, -112, -110, -112, -110, -112, -111, -111, -111, -108,
-109, -103, -111, -31, 4, -5, 8, 2, 7, 2, 6, 2, 3, 0, 2, -3, -4, -5, -7, -10,
-11, -12, -13, -13, -13, -14, -15, -15, -15, -16, -16, -16, -16, -16, -16, -16,
-17, -16, -17, -17, -16, -16, -17, -17, -16, -15, -15, -14, -14, -14, -12, -11,
-9, -9, -8, -8, -7, -7, -6, -5, -4, -5, -5, -4, -4, -4, -3, -2, -2, -2, -2, -1,
-2, 0, 0, -1, 0, 0, 0, 1, 1, 0, 1, 1, 1, 1, 1, 0, 1, 0, 0, 1, 1, 0, 1, 1, 0, 1,
0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, 0, 0, 1, 0, 0, 0, 1, 1, 1, 1,
0, 1, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 0, 1, 1, 2, 0, 1, 1, 1, 1, 1, 1, 1, 1, 0, 1,
0, 1, 1, 0, 1, 1, 2, 1, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0,
0, 0, 0, 0, -1, 1, 0, 1, 1, 1, 0, 0, 0, 0, -1, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 1, 0,
0, };