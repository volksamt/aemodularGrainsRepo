#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 2, 1, 1, 2, 2, 2, 3, 5, 5, 5, 6,
7, 7, 8, 7, 8, 8, 9, 9, 10, 9, 9, 10, 9, 10, 11, 11, 11, 12, 12, 12, 12, 12, 14,
13, 14, 16, 16, 18, 19, 19, 20, 20, 21, 21, 22, 23, 23, 24, 25, 29, 29, 30, 30,
31, 32, 34, 36, 38, 40, 42, 45, 48, 51, 55, 60, 62, 69, 75, 79, 85, 95, 100,
100, 102, 101, 103, 104, 104, 105, 105, 105, 105, 106, 106, 105, 106, 107, 107,
106, 106, 107, 107, 107, 107, 107, 107, 108, 108, 107, 107, 109, 108, 108, 109,
108, 108, 108, 109, 108, 108, 109, 109, 109, 109, 109, 109, 109, 108, 109, 109,
109, 109, 109, 108, 108, 108, 109, 109, 109, 108, 109, 109, 108, 108, 107, 108,
107, 108, 107, 107, 108, 107, 107, 107, 107, 107, 107, 107, 106, 107, 106, 107,
107, 107, 106, 107, 106, 106, 106, 106, 105, 105, 105, 105, 105, 104, 104, 102,
103, 101, 101, 101, 100, 100, 99, 99, 98, 97, 96, 94, 94, 93, 92, 91, 90, 88,
86, 86, 86, 85, 84, 82, 80, 79, 79, 79, 77, 76, 69, 68, 64, 60, 54, 48, 39, 33,
28, 23, 18, 10, 2, -5, -11, -21, -25, -37, -35, -73, -104, -103, -109, -109,
-113, -113, -117, -116, -117, -116, -118, -118, -118, -118, -119, -119, -119,
-119, -118, -118, -117, -116, -117, -114, -112, -111, -103, -95, -90, -84, -64,
-59, -56, -46, -42, -36, -29, 10, 40, 43, 49, 52, 58, 64, 69, 71, 73, 77, 80,
82, 85, 87, 88, 90, 92, 93, 94, 97, 97, 98, 98, 98, 99, 100, 100, 102, 101, 101,
102, 102, 103, 104, 104, 104, 105, 105, 106, 106, 106, 106, 106, 108, 108, 107,
108, 109, 109, 109, 109, 110, 110, 110, 110, 110, 110, 109, 110, 111, 111, 111,
111, 112, 111, 112, 112, 112, 112, 112, 111, 113, 113, 112, 112, 112, 113, 113,
113, 112, 112, 112, 114, 113, 113, 113, 113, 114, 113, 113, 113, 113, 114, 114,
114, 114, 114, 114, 114, 114, 114, 115, 114, 115, 114, 115, 114, 114, 115, 115,
114, 114, 114, 115, 115, 114, 114, 114, 115, 115, 114, 114, 114, 114, 114, 114,
114, 114, 114, 114, 114, 113, 113, 113, 113, 113, 113, 114, 114, 113, 113, 112,
112, 112, 111, 112, 111, 111, 111, 110, 109, 109, 110, 109, 109, 109, 108, 108,
107, 107, 108, 107, 107, 106, 106, 105, 105, 104, 104, 104, 104, 103, 102, 101,
101, 100, 100, 99, 98, 98, 97, 96, 95, 95, 95, 93, 93, 92, 92, 91, 91, 91, 90,
88, 88, 87, 86, 86, 85, 85, 83, 84, 83, 81, 81, 80, 79, 78, 78, 78, 77, 76, 75,
73, 73, 73, 70, 67, 66, 66, 64, 64, 63, 60, 56, 52, 43, 36, 32, 23, 10, 9, 8, 6,
6, 5, 5, 4, 4, 4, 2, 1, 1, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, };