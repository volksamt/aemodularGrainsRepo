#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 2, 5, 6, 7, 9, 11, 12, 14,
16, 19, 24, 28, 29, 32, 34, 36, 39, 48, 51, 53, 56, 58, 61, 63, 65, 67, 69, 71,
75, 80, 85, 90, 95, 101, 103, 104, 105, 108, 109, 111, 113, 114, 115, 117, 119,
119, 119, 119, 118, 119, 120, 119, 120, 119, 118, 117, 117, 117, 117, 115, 113,
112, 111, 110, 108, 107, 106, 104, 104, 102, 101, 101, 99, 98, 98, 95, 95, 93,
92, 91, 90, 89, 87, 85, 83, 81, 78, 77, 74, 67, 59, 56, 52, 46, 43, 40, 36, 34,
32, 28, 26, 24, 21, 18, 14, 11, 8, 4, 2, -2, -5, -8, -10, -19, -26, -28, -30,
-32, -34, -37, -43, -47, -53, -57, -63, -68, -73, -78, -82, -84, -85, -89, -90,
-93, -97, -101, -102, -103, -104, -104, -104, -105, -104, -105, -106, -106,
-107, -106, -107, -107, -109, -108, -109, -109, -110, -109, -109, -109, -110,
-110, -110, -110, -110, -110, -110, -110, -110, -111, -111, -110, -110, -110,
-110, -110, -110, -110, -110, -110, -110, -110, -110, -110, -110, -110, -110,
-110, -109, -109, -110, -109, -109, -108, -107, -107, -106, -106, -105, -104,
-104, -103, -103, -101, -101, -100, -100, -99, -99, -99, -99, -99, -98, -98,
-98, -97, -98, -97, -96, -95, -94, -94, -93, -91, -90, -89, -88, -86, -84, -83,
-81, -80, -79, -77, -77, -74, -73, -71, -71, -69, -67, -66, -64, -64, -62, -60,
-58, -58, -56, -54, -53, -52, -50, -50, -48, -47, -46, -45, -44, -42, -41, -39,
-38, -36, -35, -32, -31, -28, -25, -23, -22, -21, -19, -17, -16, -13, -12, -10,
-8, -6, -3, -1, 0, 3, 4, 5, 7, 9, 11, 11, 12, 14, 13, 14, 14, 14, 15, 16, 16,
17, 16, 17, 17, 17, 18, 17, 18, 17, 18, 17, 17, 17, 18, 18, 17, 18, 17, 16, 15,
14, 13, 11, 10, 9, 8, 8, 8, 7, 6, 5, 6, 4, 3, 2, 0, -1, -2, -3, -4, -4, -4, -4,
-5, -6, -6, -7, -8, -8, -9, -9, -8, -9, -10, -10, -9, -9, -11, -11, -12, -11,
-12, -11, -11, -11, -12, -11, -11, -12, -12, -12, -12, -11, -11, -11, -12, -11,
-11, -12, -11, -11, -11, -10, -11, -10, -10, -11, -10, -10, -10, -9, -9, -8, -7,
-6, -6, -5, -4, -4, -4, -3, -2, -2, -1, -1, 1, 2, 2, 3, 4, 5, 6, 7, 8, 9, 9, 9,
10, 10, 11, 13, 14, 13, 15, 16, 16, 16, 17, 16, 17, 18, 18, 19, 19, 19, 19, 19,
19, 19, 19, 18, 19, 20, 19, 19, 18, 19, 19, 19, 19, 19, 19, 18, 19, 19, 19, 19,
20, 19, 19, 19, 19, 18, 18, 18, 17, 17, 18, 18, 17, 15, 12, 10, 8, 6, 4, 1, 0,
-3, -5, -7, -8, -11, -13, -14, -15, -18, -19, -21, -24, -25, -24, -24, -23, -22,
-20, -19, -19, -18, -17, -16, -13, -10, -11, -8, -6, -4, -2, -1, -2, -2, };