#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0041

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 1, 1, 1, 1, 1, 1, 3, 2, 3, 3,
3, 3, 4, 4, 5, 5, 5, 5, 6, 6, 6, 6, 7, 6, 7, 7, 8, 8, 8, 9, 8, 10, 10, 9, 10,
11, 10, 10, 12, 12, 14, 15, 15, 16, 17, 18, 18, 19, 20, 22, 23, 24, 25, 28, 28,
29, 31, 33, 33, 37, 39, 39, 40, 41, 42, 42, 43, 45, 47, 48, 50, 52, 54, 55, 56,
60, 61, 65, 66, 67, 68, 68, 69, 72, 75, 75, 78, 79, 80, 81, 83, 85, 88, 89, 92,
94, 95, 96, 97, 98, 99, 102, 102, 105, 105, 107, 108, 110, 112, 113, 114, 116,
116, 117, 119, 118, 118, 118, 119, 118, 117, 118, 118, 118, 117, 117, 117, 117,
116, 116, 116, 116, 116, 115, 115, 115, 114, 114, 114, 115, 114, 113, 113, 113,
114, 114, 113, 113, 113, 112, 113, 113, 112, 108, 103, 99, 96, 94, 91, 89, 86,
83, 79, 76, 72, 68, 63, 58, 52, 47, 42, 37, 34, 30, 26, 23, 21, 17, 16, 12, 11,
3, -2, -3, -5, -5, -7, -9, -10, -12, -13, -15, -16, -17, -18, -20, -21, -23,
-24, -26, -27, -27, -29, -31, -31, -33, -34, -35, -36, -37, -38, -39, -41, -41,
-41, -43, -44, -45, -46, -47, -48, -50, -50, -52, -53, -54, -55, -58, -57, -60,
-60, -61, -63, -63, -64, -68, -70, -73, -74, -75, -79, -80, -81, -84, -87, -89,
-90, -95, -98, -101, -100, -103, -105, -107, -110, -110, -109, -110, -108, -107,
-106, -106, -106, -104, -104, -103, -103, -102, -102, -102, -101, -100, -99,
-98, -98, -98, -97, -97, -97, -95, -95, -94, -94, -93, -92, -91, -90, -90, -89,
-88, -88, -86, -87, -86, -86, -84, -84, -83, -82, -81, -80, -80, -80, -79, -78,
-78, -77, -76, -76, -75, -74, -74, -74, -72, -73, -71, -71, -71, -69, -69, -68,
-68, -67, -66, -65, -65, -63, -64, -63, -63, -62, -62, -61, -60, -60, -59, -59,
-57, -56, -55, -55, -55, -53, -53, -52, -51, -50, -49, -48, -48, -47, -46, -45,
-45, -43, -43, -43, -42, -40, -40, -40, -39, -38, -38, -37, -37, -35, -34, -33,
-32, -32, -30, -30, -29, -28, -27, -27, -25, -25, -25, -25, -22, -22, -21, -20,
-19, -18, -17, -16, -15, -14, -13, -11, -10, -10, -9, -6, -6, -5, -2, -1, -1, 0,
2, 2, 4, 4, 7, 8, 9, 10, 12, 13, 14, 16, 17, 20, 21, 23, 23, 24, 25, 25, 25, 26,
28, 27, 29, 29, 28, 29, 28, 27, 27, 26, 26, 26, 24, 24, 23, 23, 22, 21, 20, 20,
19, 18, 18, 17, 16, 17, 17, 15, 17, 16, 16, 16, 16, 16, 15, 16, 16, 15, 16, 16,
15, 15, 16, 15, 15, 15, 15, 15, 15, 14, 14, 14, 14, 15, 14, 14, 14, 14, 14, 14,
13, 13, 13, 14, 13, 12, 12, 12, 12, 11, 11, 11, 11, 10, 11, 10, 9, 8, 7, 6, 6,
6, 4, 2, };