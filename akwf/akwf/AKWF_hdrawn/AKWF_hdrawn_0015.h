#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 1, -1, 0, -1, 1, 2, 1, 0, 2, 2,
1, 1, 2, 2, 3, 2, 2, 3, 3, 4, 3, 3, 4, 4, 5, 6, 5, 6, 6, 5, 6, 7, 6, 6, 6, 7, 7,
7, 6, 7, 7, 7, 7, 8, 8, 8, 8, 9, 8, 9, 8, 9, 9, 10, 10, 8, 8, 7, 3, 2, 1, 0, -1,
-2, -2, -4, -4, -5, -6, -7, -8, -11, -13, -14, -15, -16, -17, -18, -18, -20,
-21, -21, -23, -24, -26, -26, -28, -29, -31, -32, -34, -34, -36, -38, -39, -40,
-41, -42, -44, -45, -46, -47, -49, -51, -53, -54, -56, -56, -58, -60, -62, -64,
-65, -67, -69, -70, -71, -72, -73, -74, -75, -76, -77, -78, -80, -81, -83, -83,
-85, -87, -89, -89, -90, -90, -91, -92, -93, -94, -95, -96, -97, -98, -98, -99,
-100, -100, -101, -102, -103, -104, -105, -105, -106, -106, -107, -108, -108,
-110, -111, -112, -112, -112, -112, -113, -114, -114, -115, -115, -115, -115,
-116, -115, -116, -116, -116, -116, -117, -117, -117, -118, -118, -118, -119,
-119, -118, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -120, -118, -119, -117, -118, -118, -117, -117, -116, -116, -116,
-115, -114, -114, -112, -111, -110, -109, -109, -108, -106, -106, -104, -104,
-102, -100, -100, -99, -97, -96, -94, -92, -91, -86, -83, -81, -81, -79, -79,
-75, -64, -63, -61, -60, -59, -56, -54, -52, -49, -48, -46, -43, -40, -38, -35,
-33, -31, -29, -26, -24, -21, -18, -16, -13, -11, -8, -6, -5, -3, -2, -1, 0, 1,
3, 4, 4, 6, 7, 10, 11, 13, 14, 17, 18, 20, 20, 22, 23, 23, 25, 27, 27, 27, 28,
30, 31, 31, 33, 34, 35, 36, 38, 38, 40, 40, 42, 43, 43, 44, 45, 46, 47, 48, 49,
50, 51, 51, 53, 54, 55, 55, 55, 57, 58, 59, 59, 60, 60, 61, 62, 63, 64, 64, 65,
65, 66, 67, 68, 67, 69, 70, 69, 69, 70, 70, 70, 70, 70, 71, 71, 71, 71, 70, 72,
72, 71, 72, 72, 73, 72, 72, 73, 73, 73, 73, 73, 73, 73, 73, 73, 73, 73, 73, 73,
72, 74, 73, 73, 71, 69, 68, 66, 64, 62, 62, 61, 60, 58, 57, 57, 55, 54, 53, 52,
51, 50, 49, 49, 49, 47, 45, 44, 43, 42, 41, 40, 40, 38, 37, 36, 36, 35, 34, 34,
35, 34, 34, 33, 33, 32, 31, 30, 29, 28, 28, 26, 26, 25, 24, 23, 22, 20, 19, 19,
18, 17, 17, 15, 15, 14, 13, 13, 12, 11, 11, 9, 9, 8, 7, 6, 4, 4, 3, 4, 3, 2, 3,
2, 2, 2, 1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, -1, -1, -1, -1, -1, -2, -2, -1,
-2, -2, -2, -1, -2, -2, -2, -2, -1, -2, -2, -2, -1, -1, -1, -1, -1, 0, 0, -1,
-1, 0, 0, 0, -1, 0, -1, 2, -4, -3, -6, -8, };