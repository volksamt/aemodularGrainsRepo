#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 0, 0, 0, 2, 4, 5, 6, 7, 7, 8, 9,
11, 11, 12, 16, 16, 18, 20, 30, 44, 50, 52, 55, 59, 61, 64, 63, 65, 65, 66, 67,
71, 71, 72, 72, 73, 75, 74, 76, 76, 77, 78, 79, 82, 83, 85, 85, 87, 87, 88, 88,
89, 89, 89, 90, 91, 92, 94, 95, 96, 96, 97, 98, 99, 99, 100, 100, 101, 101, 102,
102, 102, 103, 105, 107, 108, 107, 107, 108, 109, 108, 109, 110, 111, 110, 111,
111, 111, 112, 112, 112, 113, 113, 113, 114, 114, 115, 115, 115, 116, 116, 116,
116, 117, 117, 116, 117, 117, 116, 117, 117, 117, 117, 118, 118, 118, 117, 118,
118, 118, 118, 117, 118, 118, 118, 118, 119, 118, 118, 118, 118, 118, 119, 119,
118, 118, 119, 118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119,
119, 119, 119, 120, 119, 118, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 118, 119, 118, 117, 118, 118, 118, 117, 118,
118, 118, 118, 117, 117, 117, 117, 117, 118, 117, 117, 116, 117, 116, 116, 116,
116, 116, 115, 115, 115, 114, 114, 114, 114, 112, 112, 111, 111, 110, 111, 111,
110, 110, 109, 109, 107, 105, 104, 104, 103, 103, 103, 101, 99, 97, 96, 95, 93,
91, 89, 88, 85, 82, 82, 79, 75, 73, 71, 68, 66, 63, 61, 58, 55, 52, 50, 49, 48,
47, 47, 45, 43, 39, 37, 32, 28, 26, 22, 18, 13, -4, -17, -21, -32, -37, -40,
-45, -52, -53, -55, -57, -58, -59, -60, -62, -64, -64, -65, -68, -71, -76, -78,
-78, -80, -80, -82, -82, -83, -84, -85, -85, -87, -87, -88, -88, -89, -89, -91,
-91, -92, -91, -92, -93, -93, -95, -96, -97, -98, -97, -97, -99, -98, -100, -99,
-100, -101, -100, -101, -102, -101, -102, -102, -103, -102, -104, -103, -103,
-104, -105, -104, -104, -106, -106, -106, -107, -106, -108, -108, -108, -109,
-109, -110, -110, -111, -110, -110, -110, -110, -112, -111, -111, -112, -111,
-111, -111, -111, -111, -111, -111, -111, -111, -112, -112, -112, -112, -111,
-111, -111, -112, -112, -111, -111, -112, -111, -111, -111, -111, -111, -111,
-111, -110, -111, -111, -110, -111, -111, -111, -111, -110, -110, -111, -110,
-111, -111, -110, -111, -110, -110, -110, -110, -109, -110, -110, -109, -109,
-108, -109, -110, -109, -109, -109, -108, -108, -109, -108, -108, -108, -108,
-108, -107, -107, -107, -106, -107, -107, -107, -106, -106, -106, -106, -106,
-106, -105, -104, -105, -105, -105, -104, -104, -104, -103, -104, -102, -102,
-102, -101, -101, -100, -101, -100, -100, -99, -99, -99, -99, -99, -99, -97,
-97, -97, -96, -96, -96, -95, -95, -94, -94, -91, -90, -89, -85, -83, -82, -78,
-75, -73, -71, -72, -70, -69, -69, -68, -66, -64, -61, -58, -55, -52, -51, -48,
-46, -44, -40, -38, -35, -31, -28, -26, -23, -20, -15, -12, -7, -3, -1, 1, 0, };