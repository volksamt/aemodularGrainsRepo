#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0027

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 125, 115, 123, 116, 121, 117,
121, 118, 120, 118, 120, 118, 120, 118, 119, 118, 119, 119, 119, 120, 119, 119,
118, 119, 120, 120, 120, 119, 119, 119, 120, 118, 119, 118, 120, 118, 120, 118,
120, 119, 120, 119, 119, 119, 119, 119, 118, 121, 114, 122, 20, 1, 25, -5, 4,
-4, 2, -2, 2, 0, 1, 0, 0, 0, 0, 1, 0, 1, 1, 2, 1, 1, 1, 2, 1, 1, 0, 2, 1, 1, 1,
2, 2, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 3, 2, 3, 3, 2, 2, 2, 3, 3, 3, 3, 3, 3, 3, 4,
4, 4, 4, 3, 4, 4, 5, 5, 3, 5, 5, 5, 4, 4, 4, 4, 4, 4, 4, 4, 4, 4, 5, 5, 5, 5, 5,
4, 4, 5, 5, 5, 5, 5, 6, 5, 6, 6, 6, 5, 6, 6, 6, 5, 6, 6, 5, 6, 6, 5, 5, 6, 5, 5,
6, 6, 5, 6, 5, 6, 5, 5, 5, 5, 5, 6, 6, 6, 6, 5, 5, 6, 5, 6, 6, 6, 5, 5, 6, 5, 5,
6, 6, 6, 6, 5, 6, 6, 5, 5, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 5, 5, 6, 6, 5, 6, 5, 6,
6, 5, 6, 5, 6, 5, 6, 6, 6, 6, 5, 6, 6, 6, 5, 5, 6, 5, 5, 6, 6, 5, 6, 5, 6, 6, 6,
5, 5, 5, 6, 6, 5, 5, 6, 5, 5, 6, 5, 5, 5, 6, 5, 5, 6, 6, 5, 5, 6, 6, 6, 6, 6, 5,
6, 5, 6, 5, 5, 5, 5, 5, 5, 6, 5, 6, 6, 5, 6, 6, 6, 6, 6, 5, 5, 6, 5, 6, 6, 6, 5,
6, 6, 5, 6, 5, 6, 5, 5, 5, 6, 6, 5, 6, 6, 5, 5, 5, 5, 5, 5, 5, 6, 6, 5, 5, 5, 6,
5, 6, 6, 5, 5, 5, 5, 5, 5, 5, 6, 6, 5, 5, 5, 5, 6, 4, 4, 5, 3, 5, 5, 4, 5, 3, 4,
3, 3, 4, 3, 4, 3, 3, 3, 2, 3, 2, 3, 3, 3, 2, 3, 3, 2, 3, 3, 3, 2, 2, 3, 3, 2, 2,
2, 3, 3, 3, 3, 3, 2, 2, 3, 4, 3, 2, 2, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 2, 4, 3, 3,
3, 3, 3, 3, 3, 3, 2, 3, 2, 2, 2, 2, 3, 3, 3, 2, 1, 2, 1, 2, 2, 1, 2, 1, 2, 1, 3,
0, 4, -2, 3, -21, -70, -92, -105, -99, -103, -100, -102, -101, -103, -102, -103,
-102, -102, -103, -103, -103, -102, -104, -103, -104, -104, -104, -103, -104,
-103, -104, -104, -105, -106, -106, -105, -107, -107, -107, -106, -107, -107,
-107, -106, -107, -110, -109, -110, -104, -93, -81, -75, -49, 2, 8, 6, 7, 5, 5,
5, 5, 4, 5, 4, 5, 3, 4, 4, 3, 3, 3, 3, 3, 3, 2, 2, 2, 1, 1, };