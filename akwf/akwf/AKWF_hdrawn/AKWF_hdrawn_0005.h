#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 3, 5, 12, 17, 21, 31, 35, 40, 44,
45, 48, 50, 53, 54, 58, 58, 58, 59, 60, 60, 61, 62, 62, 63, 65, 65, 68, 70, 70,
72, 71, 71, 74, 73, 74, 74, 75, 76, 76, 76, 78, 77, 80, 82, 82, 83, 83, 85, 83,
84, 85, 86, 86, 86, 87, 87, 87, 88, 88, 91, 91, 92, 93, 92, 93, 95, 95, 96, 96,
97, 98, 97, 99, 100, 100, 100, 101, 101, 101, 101, 103, 104, 104, 104, 104, 105,
105, 106, 107, 106, 106, 107, 107, 107, 108, 108, 108, 109, 108, 109, 109, 110,
109, 110, 109, 110, 111, 110, 110, 110, 111, 110, 111, 111, 111, 111, 111, 112,
112, 112, 112, 111, 112, 112, 112, 112, 112, 112, 112, 112, 113, 113, 113, 112,
112, 113, 112, 112, 113, 113, 113, 112, 112, 113, 113, 112, 112, 113, 113, 112,
113, 112, 113, 113, 112, 113, 113, 112, 113, 112, 113, 113, 113, 112, 112, 112,
112, 112, 113, 113, 112, 111, 113, 112, 112, 112, 111, 112, 112, 111, 111, 111,
111, 111, 111, 111, 111, 110, 110, 109, 110, 110, 110, 109, 108, 108, 108, 108,
106, 106, 106, 105, 105, 105, 105, 104, 104, 103, 102, 102, 102, 101, 101, 101,
100, 100, 99, 99, 97, 97, 94, 94, 91, 89, 88, 87, 84, 80, 79, 78, 77, 74, 73,
71, 68, 66, 62, 59, 56, 54, 48, 42, 38, 31, 25, 21, 17, 11, 8, 2, -5, -9, -13,
-18, -23, -30, -33, -34, -37, -40, -43, -45, -48, -48, -52, -55, -58, -60, -63,
-66, -68, -70, -72, -74, -75, -75, -76, -76, -78, -78, -79, -80, -81, -81, -83,
-83, -84, -85, -85, -86, -87, -89, -90, -93, -93, -94, -95, -95, -95, -97, -99,
-98, -99, -99, -100, -101, -102, -102, -105, -105, -107, -108, -109, -110, -111,
-111, -112, -113, -113, -113, -114, -113, -115, -114, -115, -114, -115, -115,
-115, -116, -116, -116, -116, -117, -118, -118, -118, -118, -118, -119, -119,
-119, -119, -118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -118, -118, -118, -119, -118, -118,
-117, -118, -117, -118, -118, -118, -118, -117, -117, -117, -116, -117, -117,
-116, -118, -117, -117, -117, -117, -116, -116, -116, -116, -117, -115, -115,
-115, -116, -115, -115, -113, -113, -114, -113, -113, -114, -113, -112, -111,
-111, -111, -109, -109, -109, -109, -109, -108, -108, -107, -107, -106, -106,
-105, -105, -106, -105, -104, -103, -104, -104, -102, -102, -100, -100, -99,
-99, -99, -98, -97, -97, -96, -96, -96, -96, -95, -94, -94, -92, -90, -89, -87,
-85, -83, -82, -78, -75, -73, -70, -65, -61, -56, -54, -51, -48, -45, -43, -42,
-37, -36, -33, -30, -29, -26, -23, -22, -19, -18, -17, -15, -13, -12, -11, -11,
-10, -8, -9, -8, -7, -7, -5, -5, -4, -5, -5, -4, -3, -3, -2, -2, -2, -1, };