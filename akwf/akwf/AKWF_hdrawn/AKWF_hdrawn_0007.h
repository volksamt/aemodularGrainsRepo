#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 15, 24, 25, 30, 36, 42, 47,
55, 63, 69, 76, 80, 87, 94, 115, 120, 117, 118, 118, 119, 118, 119, 119, 118,
118, 118, 118, 118, 119, 118, 119, 120, 118, 119, 119, 120, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 120, 118, 119, 119, 119, 119, 119, 120, 118,
120, 118, 120, 118, 121, 118, 121, 118, 121, 118, 120, 117, 121, 118, 120, 118,
120, 119, 119, 120, 117, 122, 114, 127, 106, 127, -30, -128, -102, -127, -108,
-123, -111, -119, -113, -118, -115, -117, -115, -117, -116, -115, -117, -115,
-116, -115, -117, -115, -117, -115, -116, -115, -117, -115, -116, -115, -116,
-115, -116, -115, -115, -115, -115, -116, -115, -116, -114, -116, -115, -115,
-114, -115, -116, -115, -115, -116, -115, -116, -115, -115, -115, -116, -115,
-116, -115, -115, -115, -115, -115, -115, -114, -115, -115, -115, -115, -115,
-114, -115, -115, -115, -116, -115, -115, -115, -115, -115, -115, -115, -115,
-115, -115, -116, -115, -116, -115, -115, -115, -114, -116, -116, -115, -116,
-116, -116, -116, -116, -116, -115, -117, -116, -116, -116, -116, -116, -118,
-117, -117, -118, -117, -117, -117, -116, -118, -117, -117, -118, -118, -117,
-118, -117, -118, -117, -117, -118, -117, -118, -118, -118, -118, -118, -117,
-118, -117, -117, -117, -118, -118, -118, -117, -118, -118, -117, -119, -118,
-118, -118, -118, -118, -118, -118, -119, -118, -118, -118, -118, -118, -119,
-118, -118, -119, -118, -118, -119, -119, -119, -119, -119, -119, -118, -118,
-118, -118, -119, -119, -118, -118, -118, -118, -118, -118, -118, -119, -118,
-119, -118, -119, -118, -118, -119, -118, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -118, -118, -118, -119, -118, -119, -119,
-119, -119, -118, -119, -119, -119, -119, -119, -118, -118, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -118, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -118, -120, -118, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -118,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -120, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -120, -119, -119, -120, -118, -120, -120, -119, -119,
-119, -119, -119, -120, -118, -119, -119, -119, -120, -119, -120, -119, -120,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -120, -119, -119, -119,
-119, -120, -119, -119, -120, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -120, -120, -119, -119, -120, -119, -119, -119, -118, -120, -119, -118,
-120, -120, -119, -119, -118, -120, -119, -119, -119, -119, -118, -119, -119,
-118, -119, -119, -119, -119, -119, -119, -120, -119, -118, -118, -119, -118,
-119, -119, -118, -119, -119, -118, -118, -119, -118, -119, -119, -119, -119,
-119, -118, -119, -118, -118, -119, -118, -118, -118, -117, -117, -118, -117,
-118, -118, -119, -117, -121, -90, -46, -42, -34, -32, -25, -19, -16, -10, -9,
-7, -1, 0, -1, };