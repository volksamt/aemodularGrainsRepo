#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 10, 22, 23, 31, 34, 44, 63, 83,
89, 92, 99, 102, 105, 106, 107, 108, 110, 110, 112, 113, 113, 112, 113, 114,
114, 114, 115, 116, 116, 117, 116, 117, 118, 117, 116, 117, 118, 117, 118, 117,
118, 118, 118, 117, 118, 118, 118, 119, 118, 119, 118, 119, 118, 119, 119, 119,
119, 119, 119, 118, 118, 119, 118, 119, 120, 119, 120, 118, 119, 119, 119, 119,
118, 119, 119, 119, 119, 119, 120, 119, 120, 119, 118, 120, 119, 119, 118, 119,
119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 118, 119,
120, 119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 120, 118, 119, 119, 118, 119, 118, 118, 118, 119, 119, 119, 118, 119, 119,
119, 118, 119, 118, 118, 119, 120, 119, 119, 119, 118, 119, 119, 118, 118, 118,
118, 119, 119, 119, 118, 119, 119, 119, 118, 119, 118, 118, 118, 118, 118, 119,
118, 119, 118, 118, 118, 118, 118, 118, 118, 118, 118, 119, 118, 118, 118, 118,
118, 117, 119, 118, 118, 117, 117, 119, 117, 118, 118, 117, 118, 117, 118, 117,
118, 118, 118, 118, 117, 118, 118, 118, 118, 118, 117, 118, 118, 118, 117, 117,
118, 118, 118, 118, 119, 117, 118, 117, 118, 117, 118, 117, 118, 118, 117, 118,
118, 117, 118, 118, 117, 117, 116, 117, 117, 118, 116, 117, 117, 118, 115, 118,
115, 118, 115, 118, 112, 117, 111, 114, 107, 113, 99, 97, 85, -77, -108, -105,
-116, -111, -116, -111, -117, -112, -116, -112, -116, -113, -116, -114, -116,
-115, -116, -114, -116, -115, -116, -115, -115, -116, -115, -116, -116, -115,
-116, -117, -116, -117, -116, -118, -116, -117, -116, -117, -116, -116, -116,
-116, -117, -117, -117, -118, -117, -117, -117, -117, -118, -117, -118, -118,
-118, -118, -117, -117, -118, -118, -119, -117, -118, -117, -118, -118, -118,
-117, -118, -118, -118, -118, -118, -117, -118, -119, -118, -118, -118, -118,
-117, -118, -118, -118, -118, -117, -118, -117, -118, -118, -118, -118, -119,
-119, -118, -118, -117, -118, -117, -118, -118, -118, -118, -118, -117, -118,
-118, -118, -118, -118, -119, -118, -118, -119, -119, -117, -118, -118, -118,
-118, -118, -118, -118, -117, -118, -118, -117, -118, -117, -118, -117, -118,
-119, -117, -118, -118, -117, -118, -117, -118, -117, -117, -118, -118, -117,
-117, -118, -117, -118, -118, -118, -118, -117, -118, -117, -118, -117, -117,
-118, -117, -117, -117, -117, -118, -117, -118, -117, -118, -117, -118, -117,
-118, -118, -118, -118, -117, -117, -118, -118, -117, -117, -117, -116, -117,
-116, -116, -117, -117, -116, -117, -116, -115, -116, -115, -116, -115, -115,
-115, -116, -115, -115, -115, -115, -114, -115, -114, -115, -114, -113, -113,
-110, -114, -82, -63, -63, -54, -50, -46, -43, -40, -38, -34, -29, -26, -21,
-13, -8, -7, -7, -4, -2, 0, };