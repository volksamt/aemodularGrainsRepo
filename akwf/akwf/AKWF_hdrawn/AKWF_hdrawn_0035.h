#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0035

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 1, -1, 1, 1, 1, 1, -3, -1, -2,
-1, -1, 0, 1, 1, 1, 2, 2, 0, -3, -4, 0, -5, -6, -5, -6, -5, -5, -5, -6, -11,
-14, -11, -11, -10, -9, -8, -7, -7, -9, -9, -11, -12, -13, -15, -2, -7, -8, -7,
-8, -8, -9, -8, -10, -11, -12, -12, -14, -15, -10, -7, -9, -8, -9, -7, -8, -7,
-9, -7, -1, -15, -14, -14, -12, -11, -11, -10, -9, -8, -8, -10, -11, -13, -14,
-14, -12, -12, -7, 3, 1, -1, -2, -4, -4, -6, -6, -8, -9, 2, 4, 3, 4, 1, 0, -3,
-4, -7, -9, -5, 4, -7, -15, -12, -11, -9, -8, -5, -4, -2, 0, 3, 3, -5, -9, -7,
-5, -3, 0, 1, 4, 0, -12, -13, -12, -12, -10, -10, -5, 4, 5, 4, 5, 5, 3, 4, 3,
-6, -11, -10, -10, -9, -9, -6, 2, 4, 4, 5, 3, 4, 2, -1, -5, -8, -8, -7, -3, 1,
4, 5, 4, 5, 5, 4, 6, 6, 5, 6, 5, 5, 5, 6, 5, 5, 5, 6, 6, 6, 7, 7, 6, 6, 7, 7, 7,
7, 7, 7, 8, 8, 7, 8, 8, 8, 8, 8, 8, 8, 9, 9, 9, 9, 9, 9, 9, 9, 10, 10, 9, 9, 9,
9, 10, 10, 10, 10, 10, 10, 11, 11, 12, 11, 12, 12, 13, 12, 12, 12, 13, 11, 12,
13, 13, 14, 15, 16, 16, 17, 17, 18, 18, 19, 20, 20, 21, 22, 23, 25, 26, 26, 26,
27, 28, 28, 30, 31, 31, 33, 35, 37, 38, 39, 42, 43, 44, 45, 45, 48, 49, 51, 53,
54, 57, 59, 60, 61, 64, 65, 67, 67, 70, 71, 73, 74, 76, 77, 79, 78, 79, 79, 80,
81, 84, 88, 92, 93, 95, 97, 97, 99, 101, 103, 103, 106, 107, 110, 109, 113, 113,
117, 116, 119, 117, 111, 89, 51, 36, 32, 16, 8, -10, -104, -112, -104, -108,
-102, -106, -101, -103, -98, -101, -97, -99, -95, -97, -95, -95, -93, -93, -92,
-90, -89, -87, -86, -84, -83, -81, -80, -78, -77, -75, -73, -72, -70, -68, -67,
-66, -64, -62, -61, -59, -58, -55, -55, -52, -51, -50, -49, -47, -46, -43, -42,
-40, -37, -36, -34, -31, -29, -28, -25, -18, -15, -15, -13, -13, -12, -11, -11,
-10, -10, -9, -8, -7, -7, -6, -6, -4, -5, -4, -4, -4, -3, -3, -3, -3, -3, -2,
-2, -2, -1, 1, 1, 1, 1, 3, 3, 3, 2, 3, 3, 2, 3, 4, 3, 3, 4, 2, 4, 4, 4, 4, 4, 4,
4, 4, 4, 4, 4, 4, 4, 4, 5, 4, 4, 4, 4, 3, 4, 3, 3, 3, 2, 3, 3, 3, 3, 3, 2, 3, 3,
2, 3, 3, 1, 2, 1, 1, 1, 1, 0, 1, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0,
0, 0, 0, -1, 0, 0, -1, 0, -1, -2, -1, 0, 1, 0, 0, 0, };