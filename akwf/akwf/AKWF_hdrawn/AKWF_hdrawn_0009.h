#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 1, 0, 1, 1, -1, 2, 3, 0, 1,
-1, 2, 6, 7, 7, 8, 7, 9, 9, 9, 10, 10, 11, 12, 13, 14, 15, 15, 16, 17, 17, 17,
18, 19, 18, 20, 20, 20, 21, 22, 22, 23, 23, 24, 25, 26, 26, 26, 27, 27, 28, 29,
29, 30, 30, 30, 31, 32, 34, 34, 35, 36, 35, 35, 36, 37, 37, 36, 37, 38, 38, 39,
38, 39, 39, 39, 40, 40, 40, 41, 41, 42, 42, 43, 43, 44, 44, 45, 44, 46, 45, 44,
44, 44, 45, 44, 45, 43, 43, 40, 39, 37, 36, 31, 31, 25, 27, 16, 15, 6, -32, -29,
-32, -32, -32, -35, -36, -39, -42, -46, -47, -50, -50, -53, -52, -54, -57, -63,
-68, -69, -69, -70, -72, -73, -73, -76, -80, -86, -92, -97, -102, -103, -105,
-106, -108, -111, -114, -115, -116, -116, -117, -117, -117, -117, -117, -117,
-118, -118, -118, -118, -118, -119, -118, -118, -119, -118, -119, -119, -118,
-119, -118, -119, -118, -119, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -118, -118, -118, -118, -118, -119, -119, -118,
-118, -117, -117, -118, -117, -117, -117, -117, -117, -117, -117, -116, -116,
-116, -116, -117, -116, -114, -113, -113, -113, -113, -113, -112, -112, -111,
-111, -111, -110, -109, -109, -109, -109, -108, -108, -107, -107, -108, -107,
-107, -106, -105, -105, -105, -104, -104, -103, -103, -103, -103, -102, -101,
-101, -102, -100, -100, -101, -100, -99, -99, -99, -98, -97, -97, -96, -96, -95,
-94, -95, -94, -94, -93, -93, -92, -92, -91, -91, -91, -90, -88, -89, -88, -87,
-87, -87, -86, -84, -82, -80, -80, -78, -78, -77, -76, -76, -73, -73, -71, -70,
-70, -67, -65, -64, -63, -62, -61, -60, -56, -53, -50, -49, -48, -47, -47, -45,
-43, -39, -36, -32, -25, -18, -14, -10, -3, 4, 11, 18, 21, 23, 24, 26, 27, 29,
31, 34, 37, 38, 40, 41, 41, 42, 43, 45, 47, 47, 49, 51, 52, 53, 54, 55, 56, 57,
59, 60, 61, 61, 62, 64, 64, 65, 66, 66, 67, 68, 69, 70, 70, 71, 72, 72, 74, 76,
78, 80, 84, 86, 88, 92, 95, 97, 99, 102, 103, 104, 105, 106, 106, 107, 108, 109,
109, 110, 109, 110, 110, 110, 111, 111, 112, 112, 112, 112, 113, 112, 113, 112,
114, 113, 114, 114, 115, 113, 112, 109, 111, 99, 17, -45, -55, -53, -54, -52,
-52, -51, -51, -51, -50, -50, -48, -48, -47, -48, -47, -46, -45, -45, -44, -44,
-43, -43, -41, -42, -41, -40, -39, -38, -36, -36, -35, -34, -33, -32, -32, -32,
-31, -31, -31, -30, -29, -29, -29, -28, -28, -27, -27, -25, -26, -25, -25, -24,
-24, -22, -23, -23, -22, -21, -21, -20, -19, -19, -18, -17, -17, -16, -16, -15,
-15, -15, -13, -13, -12, -12, -11, -11, -11, -10, -9, -9, -7, -7, -5, -5, -4,
-3, -2, -2, -2, -1, -1, -1, 0, 0, 1, 1, };