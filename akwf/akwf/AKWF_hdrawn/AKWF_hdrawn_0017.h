#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 1, 0, 0, 0, 2, 3, 4, 9, 13, 15, 16,
18, 20, 23, 23, 31, 42, 46, 50, 53, 54, 58, 61, 63, 68, 71, 74, 78, 81, 85, 88,
91, 95, 98, 99, 100, 101, 102, 103, 105, 106, 107, 109, 110, 111, 113, 114, 115,
117, 119, 119, 118, 117, 116, 115, 114, 113, 113, 112, 110, 108, 107, 105, 105,
103, 102, 100, 98, 96, 95, 92, 90, 89, 88, 86, 83, 82, 80, 78, 75, 74, 71, 70,
67, 64, 62, 59, 57, 53, 52, 49, 46, 43, 40, 37, 33, 30, 26, 22, 20, 15, 13, 9,
6, 4, 0, -2, -6, -9, -11, -15, -18, -22, -25, -29, -33, -34, -37, -40, -42, -44,
-47, -49, -52, -53, -55, -57, -59, -61, -64, -64, -67, -69, -70, -72, -74, -75,
-77, -79, -81, -82, -83, -84, -85, -85, -86, -86, -87, -86, -86, -86, -86, -86,
-85, -84, -83, -83, -81, -81, -79, -78, -77, -75, -74, -71, -71, -68, -66, -63,
-62, -59, -56, -54, -52, -49, -48, -45, -44, -42, -39, -37, -33, -31, -28, -25,
-23, -21, -17, -14, -11, -9, -7, -2, 2, 6, 9, 14, 15, 17, 19, 21, 23, 25, 27,
29, 31, 34, 36, 38, 41, 44, 46, 47, 50, 52, 53, 53, 54, 54, 54, 55, 54, 51, 50,
48, 47, 45, 45, 44, 43, 42, 41, 39, 38, 37, 36, 35, 35, 33, 32, 30, 29, 27, 27,
25, 24, 22, 21, 20, 18, 16, 15, 13, 13, 11, 9, 7, 5, 3, 2, 0, -1, -4, -5, -6,
-9, -11, -11, -15, -17, -19, -23, -25, -27, -28, -30, -31, -33, -34, -36, -37,
-38, -41, -42, -43, -44, -45, -48, -49, -51, -50, -52, -53, -54, -55, -56, -57,
-57, -57, -58, -58, -59, -60, -60, -60, -60, -59, -60, -60, -60, -59, -59, -58,
-59, -59, -58, -57, -57, -55, -54, -53, -53, -52, -52, -50, -49, -49, -48, -46,
-45, -44, -44, -42, -41, -40, -39, -38, -37, -36, -34, -34, -33, -30, -30, -27,
-25, -24, -22, -20, -20, -18, -15, -15, -14, -13, -11, -9, -7, -7, -5, -4, -3,
-1, 1, 2, 4, 5, 7, 8, 10, 11, 13, 15, 17, 18, 21, 23, 25, 27, 30, 33, 33, 34,
35, 37, 38, 39, 40, 41, 42, 44, 44, 45, 45, 44, 43, 42, 40, 39, 39, 38, 36, 35,
34, 33, 33, 30, 29, 28, 27, 26, 24, 24, 22, 21, 20, 18, 18, 16, 14, 14, 12, 11,
11, 8, 7, 7, 5, 3, 2, 1, 0, -2, -4, -6, -7, -10, -11, -13, -15, -17, -19, -21,
-23, -25, -27, -30, -32, -35, -37, -37, -38, -41, -41, -43, -45, -46, -47, -48,
-50, -51, -52, -54, -55, -56, -56, -57, -59, -60, -61, -61, -63, -61, -62, -60,
-59, -58, -56, -54, -54, -51, -46, -43, -38, -33, -25, -21, -15, -5, -2, 3, 3,
3, 4, 3, 3, 3, 3, 3, 4, 4, 5, 3, 3, 2, 2, 0, 1, -2, -1, 3, };