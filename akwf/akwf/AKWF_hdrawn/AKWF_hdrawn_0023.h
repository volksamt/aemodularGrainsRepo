#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {-2, -1, 1, 0, 0, -2, -3, -5, -6, -6,
-7, -8, -9, -8, -10, -11, -12, -13, -15, -16, -17, -17, -19, -19, -21, -21, -24,
-26, -30, -34, -35, -36, -39, -42, -44, -45, -45, -47, -47, -51, -56, -60, -63,
-64, -66, -68, -70, -72, -73, -75, -75, -78, -80, -83, -87, -88, -89, -90, -91,
-92, -94, -95, -96, -97, -98, -99, -101, -101, -103, -103, -104, -105, -106,
-107, -108, -109, -109, -110, -110, -112, -112, -114, -114, -115, -115, -116,
-118, -118, -120, -119, -118, -120, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -120, -119, -120, -119, -119, -119, -117, -117, -117, -116,
-117, -117, -116, -116, -115, -115, -115, -114, -113, -113, -113, -112, -112,
-112, -111, -111, -109, -109, -106, -98, -92, -88, -76, -72, -61, -43, -26, 1,
11, 18, 28, 36, 44, 51, 59, 65, 72, 74, 78, 82, 87, 90, 92, 93, 94, 95, 96, 98,
99, 101, 103, 104, 105, 106, 106, 106, 108, 109, 111, 115, 115, 114, 116, 115,
116, 115, 115, 116, 115, 114, 114, 114, 114, 113, 113, 113, 111, 110, 110, 107,
106, 105, 103, 102, 100, 99, 98, 96, 95, 94, 92, 90, 90, 88, 86, 84, 84, 81, 79,
78, 76, 75, 73, 71, 69, 68, 65, 64, 62, 60, 60, 57, 56, 54, 53, 51, 49, 48, 46,
43, 42, 41, 38, 36, 35, 34, 33, 32, 32, 30, 29, 28, 26, 25, 25, 23, 22, 21, 19,
17, 16, 15, 13, 12, 11, 10, 8, 8, 8, 7, 5, 4, 3, 4, 1, 1, 2, 2, 0, -1, 1, 0, -1,
-1, -1, -1, -1, -2, -2, -2, -2, -1, -1, -1, -3, -2, -1, -2, -2, -2, -1, -2, -1,
-1, -1, -3, -2, -3, -1, -2, -2, -2, -2, -2, -1, -2, -2, -2, -1, -1, -2, -2, -2,
-2, -2, -2, -2, -2, -2, -2, -1, -1, -1, -1, -2, -2, -2, -1, -1, -2, -2, -2, -2,
-1, -1, -1, -3, -1, -2, -2, -2, -2, -2, -2, -2, -3, -2, -1, -2, -1, -2, -2, -2,
-2, -1, -2, -1, -3, -2, -3, -2, -2, -2, -1, -2, -2, -2, -2, -3, -2, -2, -2, -2,
-2, -2, -2, -1, -2, -1, -1, -1, -1, -1, -1, 0, 0, -1, -1, 0, 0, 1, 0, -1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 1, -1, -1, 0,
0, 0, 0, 0, 0, 0, 0, 1, 0, -1, 1, 0, 0, -1, 0, 0, 1, 1, 0, 0, 0, 1, -1, -1, -1,
-1, 0, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1,
0, 0, 0, 0, 1, 0, -1, 0, 0, -1, 1, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, -1, 0, -1,
-1, -1, -1, -1, -2, -1, -2, -2, -2, -2, -2, -2, -1, 1, };