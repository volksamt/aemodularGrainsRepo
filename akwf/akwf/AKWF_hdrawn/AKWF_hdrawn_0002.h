#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, -2, -2, -1, 2, 2, 2, 2, 1, 3, 3,
3, 5, 6, 6, 7, 8, 8, 8, 9, 9, 9, 9, 11, 12, 14, 15, 17, 17, 18, 18, 19, 19, 19,
19, 20, 20, 21, 21, 21, 21, 21, 21, 21, 21, 22, 22, 23, 22, 23, 24, 24, 25, 24,
24, 25, 26, 25, 25, 26, 27, 28, 30, 31, 32, 32, 33, 32, 33, 32, 33, 33, 33, 34,
34, 34, 34, 34, 35, 34, 35, 36, 36, 37, 37, 37, 39, 38, 39, 39, 39, 40, 40, 39,
40, 40, 40, 40, 39, 41, 40, 40, 40, 40, 41, 41, 42, 41, 42, 42, 42, 43, 43, 43,
43, 44, 45, 45, 44, 44, 45, 45, 45, 46, 46, 46, 46, 46, 46, 46, 46, 47, 47, 47,
48, 48, 48, 48, 48, 49, 50, 49, 49, 50, 49, 51, 51, 51, 52, 51, 52, 52, 52, 53,
53, 53, 53, 53, 53, 54, 54, 55, 55, 55, 56, 55, 56, 56, 57, 58, 59, 59, 61, 61,
63, 64, 64, 65, 65, 66, 66, 66, 66, 67, 67, 68, 67, 68, 68, 69, 69, 69, 69, 70,
71, 72, 73, 75, 75, 77, 77, 79, 80, 80, 83, 83, 84, 85, 87, 87, 86, 88, 88, 88,
89, 90, 91, 94, 94, 96, 96, 98, 97, 98, 98, 98, 99, 100, 101, 100, 102, 101,
102, 102, 102, 103, 104, 104, 105, 105, 106, 105, 106, 105, 107, 106, 107, 107,
108, 108, 108, 109, 108, 110, 109, 111, 109, 112, 109, 115, 111, 117, 110, 118,
112, 118, 111, 119, 113, 120, 113, 122, 112, -106, -127, -113, -125, -114, -123,
-115, -123, -114, -121, -114, -119, -112, -117, -113, -115, -112, -113, -111,
-112, -111, -113, -112, -112, -113, -111, -112, -111, -113, -111, -112, -110,
-111, -110, -110, -109, -109, -108, -109, -108, -107, -107, -107, -107, -106,
-105, -105, -105, -104, -104, -104, -103, -103, -102, -102, -101, -101, -100,
-99, -99, -99, -97, -96, -97, -95, -95, -95, -94, -94, -93, -93, -92, -91, -91,
-90, -90, -89, -88, -88, -87, -87, -86, -85, -84, -85, -83, -82, -82, -82, -82,
-80, -79, -79, -79, -78, -78, -78, -77, -76, -75, -75, -74, -74, -74, -72, -72,
-71, -71, -70, -69, -68, -68, -67, -66, -64, -65, -64, -63, -63, -62, -61, -61,
-60, -60, -59, -58, -58, -57, -57, -56, -55, -54, -53, -53, -52, -51, -49, -49,
-48, -47, -47, -45, -45, -45, -44, -44, -44, -44, -43, -44, -44, -43, -42, -43,
-41, -41, -41, -42, -41, -41, -40, -40, -40, -39, -38, -38, -38, -38, -37, -34,
-32, -31, -30, -29, -29, -27, -28, -28, -27, -27, -26, -24, -24, -23, -21, -21,
-20, -19, -19, -18, -17, -17, -17, -17, -16, -16, -15, -15, -15, -15, -15, -15,
-14, -15, -13, -14, -13, -13, -13, -12, -11, -12, -12, -12, -11, -11, -11, -10,
-10, -9, -9, -8, -7, -6, -6, -4, -3, -1, -1, 0, 0, 1, 2, 2, 2, 1, 1, -1, -1, };