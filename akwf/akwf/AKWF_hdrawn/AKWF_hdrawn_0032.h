#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0032

const PROGMEM int8_t DATA[DATA_LENGTH] = {-2, -1, -2, -2, -1, 0, 1, 3, 2, 2, 2,
2, 5, 5, 7, 8, 7, 8, 8, 9, 10, 10, 11, 10, 12, 11, 12, 13, 14, 15, 16, 17, 19,
21, 22, 24, 26, 28, 30, 31, 33, 34, 36, 38, 41, 43, 44, 45, 47, 50, 51, 52, 55,
56, 58, 59, 61, 63, 65, 66, 68, 69, 72, 74, 76, 77, 80, 80, 82, 83, 86, 88, 90,
91, 93, 100, 102, 101, 101, 100, 101, 101, 100, 101, 100, 101, 99, 101, 98, 100,
96, 98, 93, 97, 91, 95, 91, 93, 88, -15, -24, -19, -24, -20, -23, -20, -23, -19,
-24, -20, -24, -20, -23, -22, -23, -22, -23, -22, -23, -22, -23, -23, -23, -23,
-22, -22, -22, -23, -22, -22, -22, -23, -22, -23, -22, -23, -22, -22, -22, -23,
-22, -23, -23, -23, -22, -23, -22, -23, -23, -23, -22, -23, -22, -23, -23, -23,
-23, -23, -23, -23, -22, -23, -23, -23, -22, -22, -22, -22, -23, -23, -23, -22,
-22, -23, -23, -23, -23, -23, -24, -22, -23, -23, -23, -22, -23, -23, -23, -22,
-22, -22, -23, -23, -22, -24, -22, -22, -23, -23, -22, -23, -23, -23, -23, -23,
-22, -22, -23, -23, -22, -23, -23, -23, -23, -23, -23, -23, -22, -23, -22, -23,
-23, -22, -22, -22, -23, -22, -23, -23, -22, -23, -23, -22, -22, -22, -23, -22,
-22, -22, -23, -22, -23, -23, -22, -22, -22, -23, -22, -23, -23, -23, -24, -23,
-23, -23, -23, -22, -23, -23, -23, -24, -23, -23, -23, -23, -23, -23, -24, -23,
-24, -24, -23, -23, -24, -24, -24, -24, -23, -23, -24, -23, -23, -24, -24, -23,
-25, -24, -24, -23, -24, -24, -24, -24, -25, -25, -25, -25, -25, -25, -25, -25,
-25, -26, -25, -26, -25, -26, -25, -26, -26, -27, -26, -27, -26, -27, -26, -27,
-27, -27, -27, -26, -28, -27, -29, -27, -30, -25, -33, -20, -68, -110, -97,
-105, -101, -105, -102, -105, -103, -104, -104, -104, -104, -105, -105, -104,
-105, -105, -106, -106, -106, -105, -106, -106, -107, -106, -107, -107, -107,
-107, -107, -106, -107, -107, -107, -107, -108, -107, -107, -107, -108, -108,
-108, -109, -108, -108, -108, -109, -109, -109, -110, -109, -109, -110, -110,
-110, -111, -111, -110, -111, -111, -111, -112, -111, -112, -112, -111, -112,
-112, -112, -112, -112, -113, -113, -113, -114, -112, -113, -113, -113, -113,
-113, -113, -113, -113, -113, -113, -114, -114, -114, -114, -115, -114, -114,
-114, -115, -114, -114, -114, -115, -116, -115, -115, -116, -116, -116, -116,
-116, -117, -117, -116, -118, -117, -118, -117, -118, -118, -118, -118, -117,
-118, -118, -119, -119, -119, -119, -118, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -120, -119, -118, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -118, -120, -118, -119, -119, -120, -119, -119, -119, -120, -119,
-119, -119, -119, -118, -120, -119, -118, -118, -117, -118, -117, -119, -112,
-114, -112, -115, -111, -115, -111, -116, -111, -118, -108, -121, -98, };