#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 0, 0, 1, -1, 0, 1, 1, 1, 0,
1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 2, 1, 1, 2, 2, 2, 2, 2, 2, 2, 2, 3, 3, 2, 2, 3,
3, 3, 2, 3, 2, 2, 2, 3, 3, 3, 4, 3, 2, 3, 2, 3, 2, 3, 3, 3, 3, 3, 2, 2, 3, 2, 2,
3, 2, 3, 3, 2, 2, 2, 3, 3, 3, 2, 2, 2, 3, 2, 2, 2, 2, 3, 2, 2, 3, 2, 3, 2, 2, 2,
2, 2, 2, 3, 2, 2, 3, 2, 2, 2, 2, 3, 2, 2, 2, 2, 2, 2, 2, 2, 3, 2, 2, 2, 3, 2, 2,
3, 3, 2, 2, 3, 3, 3, 3, 4, 3, 3, 2, 3, 3, 3, 3, 3, 2, 2, 3, 2, 3, 3, 3, 3, 3, 4,
2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 4, 4, 4, 3, 3, 4, 4, 3, 4, 4, 4, 3, 3, 4,
4, 3, 4, 3, 3, 3, 4, 3, 3, 3, 3, 4, 4, 4, 3, 4, 4, 4, 4, 4, 4, 3, 3, 4, 4, 4, 3,
3, 3, 3, 3, 4, 4, 4, 3, 3, 3, 3, 4, 4, 3, 3, 3, 3, 3, 4, 3, 3, 4, 4, 3, 3, 4, 3,
3, 4, 3, 3, 4, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 2, 3, 3, 3, 3, 3, 2, 3, 2, 2, 2,
3, 3, 2, 2, 3, 2, 2, 2, 2, 2, 2, 1, 0, 1, 1, 1, 1, 1, 0, 1, 1, 1, 0, 0, 1, 0, 0,
0, 1, 0, 0, -1, 1, -1, 1, -1, 0, -2, 1, -1, -1, -1, 0, -1, -1, -1, -2, -1, -3,
3, -11, 76, 121, 110, 120, 113, 119, 115, 119, 116, 118, 116, 119, 117, 119,
117, 118, 118, 118, 119, 118, 118, 118, 119, 119, 118, 118, 119, 119, 120, 119,
118, 118, 120, 118, 119, 118, 120, 119, 118, 119, 119, 118, 119, 119, 119, 118,
119, 118, 118, 118, 118, 118, 118, 119, 117, 118, 118, 118, 118, 119, 118, 118,
117, 118, 118, 119, 117, 118, 118, 118, 118, 117, 118, 117, 118, 116, 119, 115,
122, 111, 127, 19, -85, -78, -92, -90, -106, -108, -115, -116, -118, -117, -119,
-118, -119, -118, -118, -118, -118, -119, -118, -119, -118, -119, -119, -119,
-118, -118, -118, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-118, -119, -119, -119, -118, -120, -119, -118, -119, -120, -119, -119, -119,
-118, -119, -119, -120, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -120, -118, -120, -118, -119, -119, -119, -118, -118, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -117, -117, -117,
-117, -117, -117, -118, -116, -119, -116, -118, -115, -119, -112, -113, -81,
-50, -51, -41, -41, -35, -27, -17, -12, 0, };