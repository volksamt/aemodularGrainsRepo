#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 15, 25, 25, 30, 35, 43, 48,
55, 63, 69, 76, 81, 86, 94, 113, 119, 117, 119, 118, 118, 119, 119, 118, 118,
118, 118, 118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 118, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 118, 119,
119, 119, 120, 119, 119, 119, 119, 119, 118, 119, 119, 119, 120, 120, 120, 119,
119, 118, 119, 120, 119, 119, 119, 119, 119, 120, 119, 118, 119, 120, 119, 119,
120, 119, 119, 119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119,
119, 119, 120, 119, 118, 120, 119, 119, 119, 119, 118, 120, 118, 119, 118, 120,
118, 120, 118, 121, 111, 47, 4, 1, -13, -7, -39, -110, -113, -116, -116, -117,
-117, -116, -118, -116, -117, -116, -117, -116, -117, -117, -117, -116, -118,
-117, -117, -117, -117, -117, -118, -117, -118, -117, -118, -117, -118, -118,
-117, -118, -117, -118, -118, -118, -118, -118, -118, -118, -117, -117, -118,
-118, -117, -118, -118, -118, -118, -119, -118, -118, -119, -118, -119, -118,
-118, -118, -118, -118, -119, -118, -118, -118, -119, -119, -119, -118, -118,
-118, -118, -119, -119, -118, -119, -118, -119, -118, -119, -118, -118, -118,
-118, -119, -119, -118, -118, -119, -118, -118, -118, -119, -118, -118, -119,
-119, -119, -119, -119, -119, -118, -119, -118, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -118, -118, -119, -118,
-119, -118, -119, -120, -119, -119, -118, -119, -119, -118, -119, -119, -119,
-119, -118, -119, -120, -118, -118, -118, -118, -119, -118, -119, -118, -119,
-118, -119, -119, -119, -119, -120, -119, -118, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -118, -118, -119, -119, -119, -119, -119,
-119, -119, -118, -120, -119, -119, -119, -119, -119, -118, -119, -118, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -118, -118, -119, -119,
-119, -119, -119, -119, -120, -120, -119, -119, -120, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -118, -118, -120, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -120, -119, -120, -119, -119,
-119, -119, -120, -120, -119, -119, -119, -119, -120, -119, -119, -118, -119,
-118, -119, -118, -119, -118, -119, -119, -118, -119, -119, -119, -119, -118,
-119, -118, -118, -119, -119, -118, -119, -118, -118, -118, -118, -119, -118,
-117, -118, -117, -118, -117, -118, -117, -118, -117, -118, -116, -120, -89,
-46, -41, -34, -31, -26, -20, -15, -10, -9, -6, -1, 0, -1, };