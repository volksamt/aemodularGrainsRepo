#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0031

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, -2, -1, -2, -2, 1, 0, 2, 2, 2, 2,
3, 5, 4, 7, 8, 8, 8, 8, 9, 9, 9, 10, 11, 11, 11, 12, 12, 14, 15, 16, 17, 19, 21,
23, 25, 27, 28, 29, 32, 33, 34, 36, 38, 40, 41, 44, 45, 48, 49, 51, 52, 54, 56,
58, 59, 61, 63, 65, 67, 68, 70, 72, 73, 75, 77, 79, 81, 83, 85, 86, 88, 90, 91,
93, 100, 101, 101, 100, 101, 101, 101, 100, 101, 101, 100, 99, 100, 99, 98, 98,
97, 95, 95, 94, 93, 93, 91, 91, 90, 89, 88, 86, 85, 85, 83, 83, 81, 80, 79, 78,
78, 76, 75, 73, 72, 71, 69, 68, 67, 66, 64, 64, 62, 60, 60, 59, 57, 57, 55, 54,
53, 51, 50, 49, 48, 47, 46, 45, 43, 42, 42, 40, 39, 37, 36, 35, 34, 32, 31, 30,
29, 28, 26, 24, 23, 23, 24, 22, 22, 22, 21, 21, 21, 20, 20, 20, 19, 18, 18, 18,
16, 16, 15, 16, 15, 15, 16, 15, 15, 16, 15, 15, 14, 16, 15, 15, 16, 15, 15, 15,
15, 15, 15, 15, 15, 15, 15, 15, 15, 15, 15, 15, 16, 16, 17, 17, 19, 18, 20, 21,
23, 25, 26, 29, 30, 33, 38, 42, 44, 47, 49, 51, 54, 60, 64, 66, 68, 69, 74, 74,
77, 78, 80, 82, 85, 84, 88, 89, 91, 92, 96, 95, 99, 100, 102, 101, 103, 101,
104, 104, 106, 108, 104, 110, 105, 115, 100, 127, 14, -65, -39, -59, -50, -67,
-63, -73, -72, -77, -76, -79, -78, -80, -82, -84, -85, -86, -89, -90, -92, -93,
-94, -93, -95, -93, -94, -96, -97, -96, -98, -97, -99, -99, -99, -98, -99, -99,
-99, -99, -102, -100, -102, -100, -103, -101, -104, -101, -104, -100, -105,
-100, -105, -100, -96, -103, -61, -65, -61, -91, -103, -96, -103, -97, -103,
-99, -102, -99, -102, -100, -103, -101, -102, -103, -103, -102, -104, -104,
-104, -105, -105, -105, -104, -104, -104, -106, -105, -105, -105, -106, -105,
-106, -105, -106, -106, -107, -106, -106, -107, -107, -106, -106, -107, -107,
-107, -107, -107, -108, -108, -108, -109, -109, -109, -108, -109, -109, -109,
-109, -110, -109, -110, -110, -109, -109, -109, -110, -110, -110, -110, -110,
-112, -111, -111, -112, -111, -112, -112, -111, -111, -112, -112, -113, -113,
-113, -113, -113, -113, -113, -113, -113, -113, -113, -114, -113, -113, -113,
-113, -114, -114, -113, -114, -115, -114, -114, -114, -115, -115, -115, -114,
-115, -115, -115, -116, -115, -116, -116, -116, -117, -117, -117, -117, -118,
-118, -117, -118, -118, -119, -118, -118, -118, -118, -118, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -120, -120, -119, -119, -119, -118, -119,
-119, -119, -120, -119, -119, -120, -119, -119, -119, -119, -120, -119, -119,
-118, -119, -119, -120, -118, -119, -119, -120, -120, -119, -119, -119, -118,
-118, -118, -118, -118, -117, -118, -112, -114, -111, -115, -111, -114, -111,
-116, -110, -117, -108, -121, -97, };