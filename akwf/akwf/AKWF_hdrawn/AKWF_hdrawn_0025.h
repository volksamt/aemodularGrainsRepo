#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 4, 6, 7, 9, 11, 13, 13, 13, 14,
15, 18, 22, 24, 27, 29, 34, 37, 39, 41, 44, 46, 52, 55, 56, 60, 60, 58, 59, 57,
57, 56, 57, 57, 56, 56, 55, 56, 55, 55, 55, 55, 54, 54, 54, 54, 54, 54, 54, 53,
53, 54, 54, 53, 53, 53, 53, 52, 53, 53, 53, 52, 52, 52, 52, 52, 52, 51, 51, 52,
51, 52, 51, 51, 51, 50, 50, 50, 50, 49, 50, 49, 49, 49, 48, 47, 49, 48, 48, 48,
48, 47, 46, 47, 47, 46, 47, 46, 46, 47, 47, 47, 47, 47, 47, 46, 47, 46, 46, 47,
47, 46, 47, 47, 46, 47, 47, 46, 47, 47, 47, 47, 47, 47, 47, 46, 47, 47, 47, 47,
46, 46, 47, 47, 47, 47, 47, 47, 46, 47, 47, 46, 46, 47, 46, 46, 47, 46, 46, 46,
47, 46, 46, 46, 47, 47, 47, 47, 47, 47, 46, 47, 45, 47, 44, 46, 42, 44, 36, 48,
8, -33, -21, -27, -24, -27, -24, -27, -24, -25, -25, -25, -24, -23, -24, -23,
-24, -23, -24, -23, -24, -23, -24, -24, -23, -25, -23, -26, -22, -31, 12, 39,
29, 36, 31, 34, 31, 34, 32, 34, 33, 33, 33, 23, 20, 22, 20, 22, 21, 23, 22, 24,
22, 24, 21, 25, 22, 26, 22, 28, 23, 32, 101, 101, 99, 101, 97, 99, 98, 98, 97,
97, 81, 55, 42, 19, -33, -48, -57, -73, -79, -85, -87, -91, -91, -94, -99, -101,
-102, -104, -109, -110, -115, -114, -115, -119, -118, -117, -111, -100, -92,
-88, -81, -76, -71, -65, -61, -58, -53, -49, -45, -41, -38, -34, -29, -26, -22,
-17, -14, -11, -6, -2, 1, 5, 7, 12, 27, 22, 5, -9, -18, -23, -29, -36, -41, -55,
-60, -58, -59, -58, -58, -58, -58, -58, -61, -60, -62, -57, -54, -51, -47, -44,
-39, -36, -33, -30, -31, -31, -31, -32, -32, -34, -41, -40, -41, -42, -42, -44,
-42, -54, -59, -82, -91, -91, -98, -96, -101, -101, -103, -105, -105, -105,
-105, -106, -105, -105, -105, -104, -105, -104, -105, -105, -105, -105, -105,
-105, -105, -105, -105, -105, -105, -105, -104, -106, -106, -106, -105, -105,
-105, -105, -105, -105, -105, -105, -105, -105, -106, -104, -105, -105, -106,
-105, -104, -105, -105, -105, -105, -105, -105, -105, -105, -104, -104, -104,
-105, -104, -104, -104, -103, -104, -103, -103, -103, -103, -103, -103, -102,
-102, -102, -102, -102, -102, -100, -101, -101, -100, -101, -100, -99, -100,
-99, -100, -99, -99, -99, -99, -98, -98, -98, -98, -98, -97, -98, -98, -97, -97,
-96, -96, -95, -96, -96, -95, -96, -97, -96, -96, -95, -97, -95, -96, -96, -96,
-95, -96, -96, -96, -96, -95, -96, -96, -97, -95, -97, -94, -97, -94, -99, -82,
-56, -60, -55, -55, -52, -53, -52, -52, -50, -50, -50, -49, -48, -45, -45, -42,
-39, -37, -36, -34, -33, -28, -23, -20, -17, -18, -18, -13, -10, -5, -4, 0, 5,
};