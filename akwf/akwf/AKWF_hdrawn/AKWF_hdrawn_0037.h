#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0037

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 1, -2, 0, 2, 3, 1, -2, -2, -2,
-2, -3, -2, -3, 4, 7, 5, -2, -1, 1, 0, 3, 4, 5, 7, 8, 9, 11, 13, 14, 15, 17, 18,
20, 21, 24, 25, 26, 28, 29, 32, 33, 34, 35, 36, 39, 41, 42, 43, 46, 46, 49, 50,
52, 53, 55, 57, 58, 60, 62, 63, 66, 66, 68, 70, 72, 73, 75, 77, 79, 80, 82, 83,
85, 88, 89, 91, 91, 94, 93, 98, 95, 102, 98, 106, 97, 113, 83, -8, 1, -6, -6,
-8, -10, -10, -13, -13, -17, -16, -20, -20, -24, -24, -27, -28, -31, -32, -34,
-35, -39, -40, -42, -44, -45, -48, -49, -50, -52, -53, -54, -55, -57, -58, -60,
-61, -61, -64, -65, -67, -68, -69, -71, -72, -73, -76, -77, -78, -79, -81, -83,
-85, -86, -88, -90, -90, -92, -93, -95, -97, -98, -99, -100, -102, -103, -104,
-106, -106, -106, -107, -108, -107, -108, -108, -108, -109, -107, -105, -104,
-102, -101, -99, -97, -95, -94, -93, -91, -89, -87, -86, -85, -82, -81, -80,
-78, -77, -75, -74, -72, -70, -68, -67, -66, -64, -62, -61, -59, -57, -55, -54,
-52, -50, -47, -47, -45, -43, -41, -39, -37, -36, -34, -32, -30, -28, -27, -26,
-24, -22, -21, -19, -16, -16, -13, -11, -9, -7, -6, -3, 0, 4, 7, 10, 12, 12, 12,
9, 7, 4, 2, -1, -3, -5, -7, -10, -12, -15, -17, -20, -22, -24, -28, -29, -32,
-35, -37, -39, -42, -44, -47, -49, -52, -54, -57, -59, -62, -64, -66, -68, -71,
-74, -76, -78, -81, -82, -83, -84, -85, -87, -88, -90, -90, -92, -93, -94, -95,
-96, -98, -99, -100, -102, -103, -105, -106, -108, -109, -111, -112, -114, -115,
-117, -119, -119, -116, -113, -110, -109, -106, -104, -102, -100, -97, -94, -91,
-90, -87, -85, -83, -81, -79, -77, -74, -71, -70, -68, -66, -63, -61, -59, -56,
-53, -51, -49, -48, -45, -42, -40, -38, -35, -33, -29, -28, -25, -23, -20, -18,
-15, -13, -11, -8, -6, -4, -1, 1, 3, 6, 8, 11, 14, 17, 19, 21, 24, 26, 28, 30,
34, 35, 38, 40, 43, 45, 48, 50, 54, 55, 54, 52, 49, 46, 43, 41, 37, 35, 31, 28,
26, 23, 21, 19, 16, 14, 12, 9, 8, 4, 2, -1, -3, -6, -9, -12, -15, -18, -21, -25,
-27, -31, -33, -37, -40, -43, -46, -49, -52, -55, -58, -60, -63, -67, -68, -69,
-72, -72, -75, -74, -79, -76, -84, -88, -94, -88, -97, -94, -102, -98, -107,
-103, -111, -108, -115, -116, 91, 118, 100, 111, 98, 106, 97, 104, 97, 104, 97,
102, 95, 97, 92, 96, 91, 91, 89, 88, 86, 84, 83, 82, 82, 80, 80, 78, 80, 76, 75,
74, 72, 69, 68, 66, 65, 64, 62, 60, 59, 58, 56, 54, 53, 51, 48, 45, 43, 41, 38,
35, 33, 32, 29, 28, 26, 24, 22, 20, 19, 17, 15, 13, 11, 9, 8, 7, 5, 15, 8, };