#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0040

const PROGMEM int8_t DATA[DATA_LENGTH] = {-23, -26, -22, -5, -14, -26, -17, -21,
-16, -16, -14, 8, 15, 14, 18, 19, 23, 22, 24, 24, 29, 31, 37, 21, 5, 36, 53, 55,
60, 62, 66, 68, 70, 73, 75, 78, 79, 82, 82, 79, 68, 61, 52, 44, 35, 27, 26, 28,
28, 30, 30, 32, 33, 33, 35, 36, 37, 38, 40, 40, 41, 42, 43, 44, 46, 45, 47, 48,
49, 51, 52, 52, 54, 54, 57, 57, 59, 60, 61, 62, 64, 65, 66, 67, 68, 69, 70, 72,
72, 74, 75, 76, 78, 79, 79, 81, 83, 83, 84, 86, 87, 87, 89, 89, 91, 92, 93, 94,
95, 96, 96, 98, 99, 100, 101, 102, 103, 103, 105, 106, 108, 108, 108, 110, 110,
111, 111, 112, 113, 113, 113, 114, 115, 115, 117, 116, 118, 118, 119, 118, 118,
119, 118, 119, 118, 118, 119, 119, 118, 116, 114, 113, 111, 110, 107, 104, 102,
99, 97, 95, 93, 90, 88, 85, 82, 79, 76, 73, 70, 66, 64, 61, 58, 55, 52, 49, 46,
43, 40, 37, 34, 32, 29, 25, 23, 20, 17, 14, 11, 9, 5, 3, -1, -4, -6, -9, -12,
-14, -17, -20, -22, -24, -27, -28, -32, -32, -32, -33, -33, -33, -33, -34, -34,
-35, -34, -34, -34, -35, -34, -33, -33, -33, -31, -30, -31, -30, -30, -30, -31,
-30, -31, -30, -31, -30, -30, -30, -30, -31, -30, -30, -30, -30, -31, -31, -30,
-30, -30, -30, -30, -30, -31, -31, -31, -30, -31, -31, -31, -30, -31, -31, -30,
-30, -30, -30, -30, -30, -30, -30, -31, -30, -30, -30, -30, -31, -30, -30, -30,
-30, -31, -30, -31, -30, -31, -31, -31, -30, -30, -31, -30, -31, -30, -30, -30,
-30, -30, -30, -29, -29, -30, -30, -29, -29, -28, -28, -27, -27, -28, -27, -27,
-27, -26, -27, -27, -27, -27, -27, -27, -27, -26, -26, -26, -26, -25, -24, -25,
-24, -24, -24, -23, -24, -23, -23, -23, -22, -22, -22, -22, -21, -21, -21, -21,
-21, -21, -21, -20, -20, -20, -20, -19, -19, -19, -19, -18, -19, -19, -18, -18,
-19, -18, -17, -17, -16, -16, -14, -14, -13, -12, -12, -10, -11, -11, -10, -10,
-10, -9, -9, -10, -9, -8, -9, -8, -8, -8, -8, -8, -8, -7, -7, -7, -7, -6, -6,
-6, -6, -5, -5, -4, -4, -4, -3, -3, -2, -2, -1, -1, -1, -1, 0, 1, 2, 1, 2, 3, 3,
3, 4, 4, 4, 6, 6, 6, 6, 7, 7, 7, 8, 9, 9, 9, 9, 10, 10, 12, 11, 12, 12, 13, 13,
13, 13, 14, 15, 15, 15, 17, 17, 17, 16, 17, 17, 18, 17, 17, 18, 18, 18, 19, 19,
16, 15, 15, 14, 15, 13, 13, 12, 12, 12, 12, 11, 11, 10, 10, 10, 10, 9, 9, 8, 9,
7, 7, 7, 6, 6, 6, 5, 6, 6, 6, 6, 5, 5, 5, 5, 5, 4, 4, 3, 3, 4, 3, 2, 2, 1, 1, 1,
0, 0, 0, 0, -1, 0, };