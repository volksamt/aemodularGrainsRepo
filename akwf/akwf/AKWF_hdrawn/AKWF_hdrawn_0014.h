#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -1, 1, 1, 4, 7, 11, 20, 28, 29, 32,
35, 35, 38, 45, 51, 56, 59, 60, 63, 64, 65, 66, 69, 68, 71, 71, 73, 73, 74, 76,
77, 77, 79, 80, 81, 82, 81, 82, 84, 84, 86, 86, 87, 87, 88, 89, 89, 91, 92, 94,
96, 97, 98, 99, 102, 102, 106, 108, 108, 113, 116, 118, 118, 119, 118, 118, 119,
119, 119, 119, 118, 120, 118, 118, 119, 118, 121, 112, 86, 64, 41, 17, -2, -12,
-20, -67, -87, -86, -94, -95, -101, -101, -106, -106, -107, -108, -109, -109,
-110, -111, -111, -112, -113, -113, -114, -114, -113, -114, -114, -114, -114,
-116, -114, -115, -115, -116, -115, -115, -116, -115, -116, -117, -117, -116,
-116, -117, -117, -117, -117, -117, -117, -117, -117, -117, -118, -117, -117,
-117, -116, -118, -117, -118, -117, -116, -117, -116, -116, -117, -117, -117,
-117, -118, -116, -117, -117, -117, -117, -117, -116, -117, -117, -116, -116,
-116, -117, -116, -116, -116, -115, -115, -115, -115, -115, -114, -114, -113,
-114, -113, -112, -113, -112, -112, -113, -112, -111, -111, -111, -110, -110,
-110, -109, -109, -109, -109, -108, -108, -107, -107, -106, -106, -106, -106,
-105, -105, -104, -103, -102, -102, -101, -100, -99, -99, -99, -99, -98, -97,
-98, -97, -96, -96, -95, -95, -94, -94, -95, -94, -93, -94, -94, -93, -93, -93,
-93, -92, -93, -93, -93, -94, -93, -93, -93, -94, -93, -94, -93, -94, -93, -94,
-94, -93, -93, -93, -93, -93, -94, -94, -95, -95, -96, -95, -95, -95, -95, -96,
-96, -96, -96, -96, -96, -97, -96, -96, -97, -97, -97, -97, -97, -97, -96, -97,
-97, -97, -97, -97, -98, -97, -97, -97, -97, -98, -97, -97, -97, -97, -97, -97,
-97, -97, -97, -97, -97, -98, -96, -97, -97, -97, -96, -96, -96, -95, -95, -95,
-95, -94, -94, -93, -94, -94, -94, -93, -94, -93, -93, -93, -93, -92, -93, -92,
-92, -92, -91, -92, -91, -95, -100, -98, -99, -99, -98, -97, -98, -97, -97, -97,
-97, -96, -95, -96, -96, -95, -95, -94, -94, -94, -94, -93, -92, -92, -92, -92,
-92, -90, -90, -90, -89, -89, -88, -88, -87, -87, -86, -86, -86, -85, -85, -84,
-83, -83, -82, -82, -81, -81, -80, -81, -79, -79, -78, -77, -76, -76, -74, -74,
-74, -73, -72, -72, -70, -67, -65, -64, -63, -62, -60, -58, -54, -51, -46, -42,
-34, -27, -23, -17, -12, -3, 1, 8, 11, 12, 13, 14, 15, 15, 18, 18, 20, 21, 23,
26, 29, 31, 33, 34, 36, 36, 37, 41, 45, 47, 49, 52, 54, 55, 57, 57, 59, 60, 61,
61, 62, 62, 63, 64, 64, 64, 66, 66, 67, 67, 67, 67, 69, 69, 70, 70, 71, 72, 72,
72, 72, 72, 73, 73, 74, 74, 74, 73, 73, 74, 75, 74, 74, 74, 73, 74, 74, 74, 73,
73, 72, 72, 72, 71, 69, 68, 66, 62, 59, 55, 54, 47, 41, 34, 29, 25, 19, 12, 6,
4, 2, 1, 0, };