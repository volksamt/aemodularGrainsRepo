#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0039

const PROGMEM int8_t DATA[DATA_LENGTH] = {-10, 24, 123, 110, 115, 111, 111, 111,
109, 109, 106, 107, 103, 104, 101, 101, 98, 99, 96, 98, 94, 94, 92, 91, 91, 90,
88, 87, 85, 85, 83, 81, 80, 79, 78, 76, 75, 73, 72, 71, 70, 68, 67, 66, 65, 64,
63, 62, 61, 59, 58, 56, 55, 55, 53, 52, 50, 49, 48, 46, 45, 43, 42, 40, 38, 36,
34, 32, 31, 29, 27, 25, 23, 19, 19, 17, 12, 10, 10, 6, 5, 4, 4, 3, 2, 1, 0, 0,
0, 0, 0, 0, 0, -1, 0, -1, 0, -1, 0, -1, 0, -2, 6, 13, 10, 11, 11, 11, 10, 10,
11, 10, 11, 11, 11, 12, -1, -1, -1, 1, -12, -20, -17, -18, -17, -18, -18, -17,
-19, -13, 1, -2, -1, -1, -1, -1, -1, -1, -2, -1, -1, 0, -3, 6, 11, 10, 12, 8,
14, -7, -19, -14, -18, -15, -17, -16, -17, -16, -17, -17, -16, -17, -16, -18,
-17, -17, -16, -18, -15, -19, -11, 1, -1, 0, -1, -1, 0, -1, -2, 0, -1, -1, -1,
-6, -13, -13, -24, -60, -66, -75, -111, -121, -118, -118, -119, -117, -120,
-117, -120, -116, -121, -116, -123, -99, 1, 1, 1, 2, 0, 2, 0, 3, 0, 2, 0, 3, 2,
4, 2, 5, 4, 5, 6, 7, 7, 9, 9, 10, 10, 10, 12, 12, 13, 13, 16, 17, 18, 17, 19,
19, 20, 21, 20, 22, 22, 22, 22, 23, 24, 22, 20, 18, 17, 16, 14, 13, 12, 11, 9,
7, 5, 1, -4, -7, -9, -10, -12, -12, -15, -17, -18, -20, -20, -21, -21, -21, -21,
-21, -22, -22, -22, -22, -22, -22, -22, -21, -21, -20, -20, -19, -17, -16, -15,
-15, -15, -13, -12, -11, -9, -8, -8, -6, -5, -4, -2, -2, -1, 1, 1, 1, 2, 3, 4,
6, 6, 5, 6, 6, 6, 6, 5, 3, 3, 3, 2, 1, 0, -1, -2, -3, -4, -4, -3, -4, -4, -3,
-3, -4, -3, -3, -2, -3, -2, -1, -2, -2, -1, -2, -1, -1, 0, 0, 0, -1, 0, 0, 0, 0,
0, 0, 1, 0, 1, 1, 0, 2, 1, 1, 1, 2, 1, 1, 2, 2, 3, 3, 3, 4, 4, 4, 5, 6, 6, 7, 7,
8, 9, 9, 11, 12, 12, 13, 14, 15, 17, 17, 19, 19, 21, 21, 23, 24, 25, 27, 26, 27,
29, 29, 30, 32, 33, 33, 35, 37, 37, 39, 41, 42, 43, 44, 45, 46, 46, 47, 49, 48,
48, 48, 48, 47, 47, 48, 47, 47, 45, 44, 43, 43, 41, 40, 40, 39, 37, 37, 35, 31,
31, 28, 23, 18, 15, 11, 7, 4, 2, -2, -7, -8, -9, -12, -15, -16, -16, -18, -19,
-21, -21, -23, -23, -25, -24, -25, -26, -26, -27, -28, -28, -27, -26, -26, -26,
-24, -23, -22, -21, -21, -19, -17, -16, -15, -14, -13, -10, -4, -1, 0, 1, 2, 4,
0, 0, 0, -1, 2, 1, 1, 2, 2, 2, 2, 3, 2, };