#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, -2, -2, -2, 0, 0, 1, 3, 4, 3, 4,
5, 5, 5, 7, 8, 9, 10, 11, 12, 14, 14, 15, 16, 15, 17, 16, 17, 19, 21, 22, 23,
26, 26, 28, 30, 32, 34, 35, 37, 39, 41, 41, 43, 45, 46, 46, 47, 47, 48, 51, 57,
58, 57, 59, 59, 60, 62, 62, 62, 64, 67, 69, 70, 73, 74, 77, 77, 80, 81, 82, 84,
85, 87, 87, 88, 90, 90, 90, 92, 91, 95, 100, 100, 102, 101, 103, 104, 104, 104,
104, 105, 104, 107, 108, 108, 108, 109, 110, 110, 111, 113, 114, 116, 116, 113,
111, 113, 113, 113, 114, 113, 115, 114, 116, 117, 118, 118, 118, 118, 119, 120,
119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 120, 118, 119, 119, 118, 119,
119, 118, 119, 118, 118, 118, 117, 116, 116, 115, 115, 114, 114, 114, 113, 113,
113, 112, 112, 111, 111, 110, 110, 109, 107, 106, 104, 102, 101, 99, 99, 97, 96,
94, 93, 92, 90, 89, 87, 85, 84, 82, 80, 78, 76, 74, 71, 69, 68, 66, 64, 63, 61,
59, 58, 55, 48, 43, 41, 38, 36, 35, 32, 29, 26, 23, 20, 17, 16, 14, 12, 9, 8, 6,
2, -6, -9, -11, -13, -15, -17, -21, -23, -25, -27, -29, -33, -41, -43, -45, -48,
-51, -52, -54, -56, -58, -59, -61, -65, -70, -71, -73, -78, -84, -86, -88, -92,
-94, -97, -100, -102, -104, -107, -110, -113, -114, -117, -117, -118, -120,
-119, -119, -119, -119, -119, -118, -117, -116, -112, -109, -102, -99, -95, -93,
-90, -84, -79, -74, -70, -69, -67, -66, -64, -62, -59, -58, -55, -53, -50, -42,
-39, -28, -22, -14, -10, -6, -3, -3, 1, 3, 7, 8, 11, 12, 14, 15, 16, 15, 17, 18,
18, 19, 19, 18, 20, 20, 20, 21, 20, 20, 20, 21, 19, 18, 18, 17, 17, 16, 15, 15,
13, 12, 10, 9, 7, 5, 4, 2, -1, -3, -5, -5, -5, -6, -7, -8, -11, -16, -21, -26,
-29, -31, -34, -36, -37, -46, -50, -51, -52, -53, -56, -58, -63, -68, -69, -72,
-76, -81, -83, -86, -88, -88, -91, -92, -93, -95, -98, -100, -102, -103, -104,
-104, -106, -106, -106, -106, -108, -107, -108, -108, -107, -107, -104, -102,
-99, -96, -88, -76, -73, -65, -56, -54, -43, -31, -21, -16, -11, -4, -1, 1, 3,
6, 9, 11, 17, 22, 27, 28, 32, 37, 39, 40, 42, 44, 45, 48, 49, 50, 51, 52, 54,
54, 55, 56, 56, 56, 56, 57, 56, 56, 56, 56, 56, 56, 55, 55, 55, 53, 53, 52, 51,
49, 49, 49, 48, 46, 44, 42, 41, 39, 38, 35, 34, 32, 31, 28, 28, 26, 23, 23, 21,
19, 17, 16, 14, 12, 12, 10, 7, 7, 5, 7, 6, 5, 5, 6, 5, 7, 9, 9, 11, 11, 12, 11,
12, 11, 10, 10, 9, 9, 6, 6, 6, 5, 5, 3, 3, 3, 1, 2, 1, 0, -2, -2, };