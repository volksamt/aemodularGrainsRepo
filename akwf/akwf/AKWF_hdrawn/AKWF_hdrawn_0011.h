#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 0, 0, 0, 1, 0, 1, 0, 1, 1, 1, 1,
1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 2, 2, 2, 2, 3, 2, 2, 2, 2, 2, 2, 2, 3, 2, 2, 2,
2, 3, 2, 3, 2, 4, 3, 3, 2, 4, 1, 3, 1, 4, 1, 4, 1, 4, 2, 4, 1, 4, 3, -1, 61, 84,
72, 81, 73, 80, 73, 7, 0, 5, 1, 5, 0, 4, 1, 4, 2, 4, 2, 4, 2, 2, 1, 3, 2, 2, 2,
2, 2, 2, 2, 3, 2, 1, 2, 3, 2, 2, 2, 2, 3, 2, 2, 2, 3, 2, 3, 2, 2, 2, 2, 3, 3, 3,
3, 2, 3, 2, 2, 3, 3, 3, 3, 3, 3, 3, 3, 2, 2, 3, -14, -18, -17, -18, -18, -3, 5,
2, 4, 2, 4, 2, 4, 3, 4, 4, 3, 3, 3, 3, 4, 3, 3, 4, 4, 3, 4, 3, 3, 4, 3, 4, 4, 4,
3, 4, 3, 3, 3, 4, 4, 3, 3, 3, 4, 4, 4, 4, 3, 4, 4, 3, 4, 3, 4, 4, 4, 3, 4, 2, 6,
11, 11, 5, 3, 4, 4, 4, 4, 3, 3, 4, 4, 4, 3, 4, 3, 3, 4, 3, 3, 3, 3, 3, 4, 4, 4,
2, 4, 3, 3, 2, 1, 2, 2, -1, -2, -4, -5, -6, -8, -7, -9, -10, -11, -11, -11, -13,
-13, -16, -16, -16, -15, -15, -15, -14, -13, -13, -11, -9, -7, -7, -5, -4, -4,
-4, -2, -2, -2, 0, 1, 2, 2, 2, 4, 3, 3, 3, 4, 3, 3, 3, 3, 4, 3, 3, 2, 3, 1, 2,
0, 0, -2, -1, -2, -2, -3, -3, -2, -3, -4, -3, -2, -4, -2, -4, -2, -6, -2, -6,
-2, -8, 0, -10, 2, -16, 30, 127, 112, 119, 115, 117, 117, 117, 118, 118, 119,
117, 118, 117, 120, 117, 119, 118, 119, 118, 119, 119, 119, 119, 117, 120, 117,
120, 117, 121, 116, 122, 115, 125, 103, 21, 29, 26, 29, 26, 29, 26, 29, 25, 31,
21, 48, 127, 114, 120, 117, 119, 118, 117, 119, 117, 119, 116, 119, 117, 119,
117, 119, 116, 119, 116, 119, 117, 118, 117, 118, 117, 117, 119, 115, 121, 110,
127, 20, -85, -79, -94, -91, -107, -109, -115, -115, -118, -118, -119, -118,
-118, -118, -118, -119, -118, -119, -117, -119, -118, -120, -117, -118, -118,
-119, -118, -118, -118, -119, -118, -119, -119, -120, -118, -119, -119, -119,
-120, -119, -119, -119, -119, -118, -119, -118, -121, -116, -124, -103, -63,
-72, -67, -69, -68, -69, -70, -66, -110, -122, -116, -120, -118, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-118, -119, -118, -118, -120, -119, -119, -117, -119, -118, -119, -117, -118,
-118, -118, -118, -119, -118, -118, -118, -119, -117, -117, -117, -118, -117,
-117, -118, -117, -118, -116, -119, -116, -119, -112, -112, -81, -50, -51, -42,
-41, -35, -28, -17, -12, 0, };