#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0026

const PROGMEM int8_t DATA[DATA_LENGTH] = {95, 127, 70, 66, 127, 112, 121, 117,
120, 119, 119, 120, 118, 120, 118, 121, 119, 120, 118, 119, 119, 119, 119, 119,
121, 108, 24, -4, 1, -2, 1, -1, 1, 0, 0, 0, 1, 0, 0, -1, 1, 0, 1, -1, 0, 1, 0,
0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, -1, 1, -1, 0, 0, 1, -1, 1, 0, 1, 2, 1, 1, 0,
1, 1, 1, 1, 1, 2, 1, 1, 2, 1, 2, 2, 2, 1, 1, 2, 2, 2, 1, 2, 2, 3, 3, 3, 2, 3, 3,
2, 2, 3, 2, 2, 2, 4, 3, 4, 4, 3, 3, 4, 3, 4, 3, 4, 4, 4, 4, 4, 3, 4, 4, 5, 4, 5,
5, 4, 4, 5, 4, 4, 4, 4, 4, 5, 5, 5, 5, 5, 5, 4, 6, 5, 6, 5, 6, 6, 6, 6, 6, 5, 5,
5, 5, 5, 6, 5, 5, 6, 6, 6, 6, 5, 6, 5, 6, 5, 6, 6, 5, 6, 5, 5, 6, 5, 6, 5, 5, 5,
6, 6, 6, 6, 5, 5, 6, 6, 5, 5, 5, 6, 6, 5, 6, 5, 6, 6, 5, 6, 6, 6, 5, 5, 5, 5, 5,
6, 5, 6, 6, 5, 6, 5, 5, 5, 5, 5, 6, 6, 5, 5, 5, 6, 6, 6, 6, 5, 5, 5, 5, 5, 6, 5,
5, 6, 6, 6, 6, 5, 5, 5, 6, 5, 5, 6, 5, 5, 6, 5, 5, 6, 5, 5, 5, 5, 5, 6, 5, 6, 5,
6, 6, 5, 5, 5, 6, 6, 5, 5, 5, 6, 6, 6, 6, 6, 5, 6, 5, 5, 6, 5, 6, 5, 6, 5, 6, 5,
6, 5, 6, 6, 5, 6, 5, 5, 5, 6, 5, 6, 6, 6, 5, 6, 5, 6, 6, 6, 5, 5, 6, 6, 6, 5, 6,
5, 5, 5, 6, 5, 5, 6, 5, 6, 5, 5, 5, 5, 5, 6, 5, 5, 5, 5, 5, 6, 5, 6, 6, 5, 5, 5,
5, 4, 4, 3, 4, 4, 4, 5, 4, 4, 3, 3, 3, 3, 3, 3, 3, 3, 2, 2, 3, 3, 3, 3, 2, 3, 3,
3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 2, 2, 3, 3, 2, 3, 2, 2, 3, 2, 2, 3, 2, 2,
2, 3, 2, 3, 3, 2, 3, 3, 2, 2, 3, 3, 2, 3, 2, 3, 3, 2, 2, 3, 2, 3, 2, 3, 3, 1, 2,
2, 2, 2, 2, 1, 2, 1, 2, 2, 1, 2, 1, 1, 2, 1, 1, 1, 1, 1, 0, 1, 1, 1, 0, 0, 0, 1,
0, 0, 0, -1, -35, -95, -110, -108, -109, -107, -109, -108, -109, -108, -108,
-109, -108, -108, -108, -109, -109, -108, -109, -108, -108, -107, -108, -107,
-109, -108, -109, -103, -93, -81, -74, -48, 1, 8, 5, 6, 4, 5, 5, 5, 4, 4, 3, 5,
4, 4, 4, 3, 3, 3, 3, 3, 2, 2, 2, 2, 1, 2, };