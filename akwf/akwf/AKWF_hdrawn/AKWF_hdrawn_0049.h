#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0049

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 113, 116, 106, 110, 103,
105, 100, 101, 96, 97, 92, 94, 90, 89, 85, 84, 83, 84, 83, 83, 84, 83, 83, 83,
83, 84, 84, 83, 83, 83, 83, 83, 84, 83, 84, 83, 84, 83, 84, 83, 84, 84, 84, 83,
83, 84, 84, 84, 84, 83, 83, 83, 84, 83, 83, 83, 82, 84, 82, 82, 82, 83, 82, 82,
82, 83, 77, 74, 72, 71, 68, 67, 66, 64, 61, 60, 58, 55, 52, 51, 48, 47, 46, 45,
44, 42, 41, 40, 38, 37, 36, 34, 32, 32, 30, 29, 27, 26, 25, 23, 22, 21, 17, 16,
15, 12, 11, 9, 8, 6, 5, 4, 2, 1, -1, -2, -4, -7, -10, -12, -14, -17, -19, -20,
-23, -25, -27, -30, -31, -33, -35, -38, -41, -43, -44, -46, -49, -50, -53, -55,
-56, -59, -61, -63, -66, -72, -74, -74, -75, -76, -77, -79, -80, -80, -81, -82,
-82, -84, -84, -85, -87, -86, -87, -86, -87, -87, -87, -88, -88, -87, -88, -87,
-87, -86, -86, -86, -86, -86, -85, -85, -83, -83, -83, -83, -82, -82, -81, -81,
-81, -81, -80, -79, -79, -79, -78, -78, -77, -76, -76, -75, -75, -75, -74, -73,
-73, -72, -72, -70, -69, -69, -68, -68, -67, -65, -64, -63, -62, -62, -60, -58,
-57, -55, -54, -51, -50, -49, -47, -45, -43, -42, -39, -37, -35, -34, -32, -30,
-28, -26, -24, -23, -20, -19, -17, -16, -13, -12, -11, -10, -8, -7, -5, -2, -1,
1, 2, 3, 4, 5, 7, 7, 10, 11, 12, 12, 14, 14, 14, 16, 16, 17, 17, 20, 20, 20, 20,
21, 21, 23, 23, 24, 24, 24, 24, 24, 24, 25, 24, 25, 25, 25, 25, 24, 24, 23, 23,
23, 22, 21, 21, 20, 19, 18, 17, 17, 16, 16, 16, 14, 14, 13, 13, 12, 10, 9, 7, 7,
5, 4, 3, 2, 0, -2, -4, -5, -7, -8, -9, -10, -12, -13, -14, -16, -15, -17, -18,
-18, -19, -20, -21, -22, -24, -23, -25, -26, -26, -26, -27, -28, -29, -29, -29,
-29, -29, -30, -29, -29, -29, -30, -30, -29, -30, -29, -29, -29, -29, -28, -27,
-27, -27, -26, -25, -25, -23, -23, -23, -22, -21, -20, -20, -18, -18, -17, -17,
-16, -15, -14, -14, -13, -12, -12, -11, -10, -9, -9, -7, -8, -8, -7, -6, -5, -4,
-4, -3, -4, -2, -2, -3, -3, -3, -2, -2, -1, -2, -2, -2, -2, -2, -1, -1, -2, -1,
-1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -2, 0, -1, -1, 0, 0, 0,
0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 1, 2, 1, 1, 1, 2, 1, 1, 2, 1, 2, 2, 1, 1, 0, 1, 0,
1, 0, 1, 1, 0, 1, 0, -1, 1, 0, 0, -1, -1, 0, 0, 0, -1, -1, -1, -1, -1, 0, -1, 0,
0, -1, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, -2, 0, 1, };