#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 48, 47, 47, 48, 47, 48, 47, 48, 47,
48, 46, 48, 46, 48, 47, 48, 46, 46, 47, 47, 46, 47, 47, 47, 48, 46, 47, 46, 48,
47, 46, 47, 46, 47, 47, 46, 47, 47, 46, 46, 46, 46, 46, 46, 46, 47, 46, 46, 46,
46, 46, 45, 46, 46, 46, 47, 47, 46, 45, 47, 46, 46, 46, 46, 45, 46, 46, 46, 47,
46, 46, 46, 46, 46, 47, 45, 46, 47, 46, 46, 46, 47, 46, 46, 46, 46, 47, 46, 46,
46, 45, 46, 45, 45, 47, 47, 46, 45, 46, 46, 46, 46, 46, 46, 45, 46, 46, 45, 45,
46, 46, 46, 47, 47, 47, 46, 46, 47, 47, 47, 47, 47, 47, 47, 46, 46, 46, 47, 47,
46, 47, 47, 47, 47, 47, 47, 47, 47, 47, 47, 47, 47, 47, 47, 47, 48, 47, 47, 47,
47, 47, 47, 47, 47, 48, 47, 47, 48, 47, 48, 47, 47, 48, 48, 47, 47, 47, 47, 48,
47, 48, 47, 48, 47, 47, 48, 48, 48, 47, 47, 47, 47, 48, 47, 48, 49, 47, 48, 49,
48, 49, 49, 48, 49, 48, 48, 48, 48, 49, 49, 48, 49, 48, 49, 49, 48, 49, 49, 49,
48, 48, 48, 49, 49, 49, 49, 49, 49, 49, 49, 49, 50, 49, 49, 49, 49, 50, 49, 49,
50, 49, 49, 49, 49, 49, 50, 49, 50, 50, 49, 49, 49, 49, 49, 50, 49, 50, 49, 50,
49, 51, 49, 51, 48, 51, 47, 57, 68, 67, 66, 68, 66, 69, 66, 68, 66, 69, 66, 69,
68, 69, 67, 72, 118, 109, 118, 107, 123, 99, 127, 11, -128, -104, -128, -113,
-124, -116, -122, -117, -120, -119, -119, -120, -118, -120, -119, -121, -118,
-121, -117, -121, -119, -120, -118, -120, -118, -119, -118, -119, -119, -120,
-119, -119, -118, -119, -119, -119, -119, -119, -119, -118, -119, -118, -119,
-120, -120, -119, -118, -120, -120, -119, -119, -118, -119, -119, -118, -119,
-119, -119, -119, -113, -110, -112, -110, -111, -110, -110, -110, -112, -111,
-112, -112, -111, -111, -111, -111, -111, -111, -111, -111, -112, -110, -115,
-121, -118, -118, -118, -118, -118, -117, -118, -118, -116, -116, -116, -115,
-115, -115, -114, -114, -113, -113, -112, -111, -110, -110, -107, -105, -103,
-87, -74, -70, -67, -65, -66, -65, -65, -65, -65, -65, -65, -66, -66, -68, -70,
-72, -74, -75, -78, -79, -83, -86, -90, -92, -95, -96, -101, -102, -104, -107,
-112, -112, -114, -116, -117, -116, -117, -118, -118, -118, -118, -119, -118,
-119, -118, -120, -116, -122, -115, -124, -112, -128, -74, 14, -7, 4, -3, 2, 0,
1, 0, 1, 1, 1, 0, -1, 1, 0, 1, 0, 2, 0, 2, 0, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 1,
1, 0, 1, 0, 0, 1, 0, 1, 1, 0, 1, 0, 1, 0, 0, 1, 1, 1, 0, 1, 1, 2, 1, 1, 1, 1, 2,
1, 1, 1, 1, 2, 1, 0, 1, 1, };