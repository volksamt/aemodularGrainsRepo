#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0046

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 12, 17, 22, 27, 32, 37, 41, 45, 49,
52, 56, 59, 61, 64, 67, 69, 71, 74, 77, 79, 80, 82, 84, 84, 86, 88, 89, 89, 91,
92, 94, 94, 96, 96, 98, 103, 108, 108, 116, 117, 93, 87, 84, 78, 75, 69, 66, 62,
59, 54, 51, 49, 46, 42, 41, 38, 36, 34, 32, 30, 28, 27, 26, 24, 22, 21, 19, 19,
18, 16, 16, 15, 13, 13, 12, 12, 10, 10, 10, 9, 8, 8, 7, 7, 6, 6, 6, 6, 5, 5, 4,
5, 4, 4, 4, 4, 4, 3, 3, 3, 2, 1, 2, 1, 1, 0, 1, 0, 1, 0, 1, 1, 2, 1, 1, 0, 1, 1,
1, 1, 0, 0, 0, 0, -1, -1, -3, -3, -5, -6, -7, -8, -10, -10, -11, -13, -14, -15,
-17, -18, -20, -23, -26, -27, -29, -30, -29, -29, -30, -29, -30, -29, -30, -29,
-30, -30, -30, -31, -30, -30, -30, -31, -30, -30, -30, -30, -30, -30, -30, -30,
-30, -29, -30, -30, -29, -30, -30, -29, -31, -30, -30, -30, -31, -30, -30, -30,
-31, -22, -13, -10, -2, 1, -1, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 3, -6, 33, 56,
47, 53, 49, 52, 51, 51, 51, 51, 52, 49, 54, 48, 56, 36, -4, 2, 0, 1, 1, 0, 1, 0,
1, -1, 1, -1, -1, -1, 0, 0, 1, 0, -1, -6, -7, -8, -10, -12, -14, -16, -17, -19,
-20, -22, -23, -25, -26, -26, -28, -29, -30, -31, -33, -35, -35, -36, -37, -39,
-41, -41, -43, -44, -45, -45, -48, -49, -50, -52, -53, -54, -56, -58, -59, -61,
-62, -64, -65, -68, -69, -72, -73, -75, -77, -79, -81, -83, -84, -87, -94, -97,
-100, -105, -110, -111, -112, -117, -120, -119, -118, -116, -113, -111, -110,
-109, -107, -107, -105, -104, -103, -102, -100, -99, -98, -95, -93, -91, -90,
-89, -86, -85, -83, -82, -81, -80, -78, -77, -76, -75, -74, -72, -70, -69, -67,
-66, -65, -64, -62, -61, -59, -59, -56, -56, -54, -52, -52, -49, -48, -48, -46,
-45, -43, -42, -41, -40, -39, -38, -37, -36, -35, -34, -32, -32, -31, -29, -29,
-27, -26, -26, -25, -24, -23, -22, -19, -19, -17, -17, -14, -14, -13, -12, -12,
-9, -8, -8, -5, -5, -4, -3, -1, 0, 2, 4, 9, 12, 16, 20, 22, 23, 26, 29, 31, 33,
34, 36, 37, 40, 42, 47, 10, -5, 0, -3, 0, -2, 0, -2, 0, -1, -1, -1, -1, -1, -2,
-1, -1, -1, -1, 0, -1, -1, -1, -1, 0, -1, -1, -1, -1, -1, -1, -1, -1, 0, -1, -1,
-2, -1, -1, 0, -1, -1, -1, -1, 0, -1, -1, -1, -1, -1, -1, -2, -2, -2, -1, -1,
-1, -2, -1, -1, -1, -1, -2, -1, -1, -1, -1, -1, -2, -1, -2, -2, -1, -1, -2, -1,
-2, -2, -2, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -2, -1, };