#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0034

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, -2, 0, 1, 2, 1, 1, 0, -1, 0, 1, 3,
2, 2, 1, 0, 3, 2, 4, 4, 5, 2, 2, 5, 4, 5, 4, 2, 2, 4, 0, 1, 1, 2, 2, 3, 1, 0, 3,
1, 1, -1, -1, -1, 2, 21, 30, 29, 29, 29, 29, 29, 29, 29, 30, 30, 30, 29, 29, 30,
29, 32, 48, 54, 52, 53, 52, 52, 52, 52, 52, 52, 53, 51, 62, 79, 80, 80, 80, 80,
80, 81, 80, 81, 81, 80, 80, 80, 80, 79, 80, 80, 85, 89, 94, 100, 106, 107, 108,
109, 109, 108, 108, 109, 108, 109, 109, 109, 109, 117, 120, 119, 120, 119, 120,
119, 120, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 121, 114, 100,
102, 100, 101, 100, 100, 100, 99, 99, 99, 99, 99, 100, 97, 94, 91, 89, 85, 83,
80, 76, 67, 66, 69, 67, 69, 68, 69, 68, 69, 68, 69, 68, 69, 67, 68, 66, 69, 64,
33, 32, 32, 31, 32, 32, 32, 32, 32, 32, 33, 31, 32, 32, 32, 31, 31, 31, 31, 30,
31, 31, 31, 30, 30, 30, 30, 30, 30, 27, 24, 24, 20, 18, 8, 8, 6, 18, 30, 26, 25,
19, 14, 9, 8, 9, 8, 8, 9, 9, 7, 8, 8, 8, 7, 8, 7, 8, 7, 8, 6, 6, 7, 5, 6, 4, -6,
-8, 6, 13, 7, -4, -4, -4, -4, -3, -4, -4, -5, -4, -4, -5, -6, -8, -9, -10, -12,
-14, -15, -17, -20, -21, -23, -26, -38, -47, -48, -48, -47, -48, -49, -49, -48,
-48, -48, -48, -48, -47, -49, -47, -54, -65, -66, -65, -65, -65, -65, -66, -66,
-66, -66, -66, -66, -65, -66, -66, -68, -67, -67, -67, -67, -67, -67, -66, -67,
-67, -66, -67, -66, -67, -67, -68, -67, -67, -68, -68, -67, -67, -68, -68, -68,
-68, -68, -68, -69, -68, -70, -70, -70, -70, -70, -69, -70, -71, -70, -71, -71,
-70, -71, -71, -71, -71, -71, -71, -72, -71, -72, -70, -71, -71, -72, -72, -72,
-72, -71, -71, -72, -72, -72, -71, -72, -72, -73, -72, -73, -73, -72, -73, -72,
-73, -72, -73, -73, -75, -73, -75, -73, -75, -71, -53, -52, -52, -52, -52, -52,
-52, -52, -52, -52, -52, -52, -51, -53, -51, -53, -48, -55, -41, -80, -127,
-115, -121, -118, -116, -103, -107, -106, -106, -106, -106, -106, -105, -106,
-105, -106, -106, -106, -105, -106, -105, -105, -105, -106, -104, -102, -100,
-97, -96, -95, -94, -96, -95, -95, -94, -95, -95, -95, -95, -95, -95, -95, -95,
-95, -94, -96, -94, -96, -95, -75, -73, -74, -72, -73, -70, -71, -70, -71, -71,
-70, -71, -71, -72, -66, -57, -54, -52, -53, -51, -52, -51, -50, -52, -50, -51,
-50, -51, -48, -51, -42, -22, -25, -23, -23, -23, -22, -22, -22, -21, -20, -21,
-21, -22, -19, -16, -12, -10, -6, -2, -1, -2, -1, -2, 1, -1, 1, 1, 1, 2, 1, 1,
1, 2, 1, };