#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0044

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 12, 17, 22, 27, 32, 36, 41, 45, 48,
52, 55, 58, 61, 64, 68, 70, 71, 74, 76, 78, 79, 82, 83, 84, 86, 87, 89, 89, 92,
91, 93, 93, 96, 96, 97, 102, 107, 108, 115, 116, 93, 87, 84, 79, 75, 70, 67, 62,
59, 54, 52, 48, 46, 43, 40, 37, 37, 34, 31, 30, 28, 27, 25, 23, 22, 20, 19, 18,
18, 16, 15, 15, 14, 12, 12, 12, 10, 10, 9, 9, 8, 7, 8, 7, 7, 6, 5, 6, 5, 5, 4,
5, 4, 3, 4, 3, 3, 3, 3, 3, 2, 2, 3, 2, 2, 3, 3, 4, 3, 3, 2, 2, 2, 1, 2, 1, 0,
-1, -2, -2, -4, -5, -6, -6, -7, -7, -8, -8, -10, -10, -11, -12, -13, -13, -15,
-14, -15, -16, -16, -17, -17, -17, -17, -18, -18, -20, -20, -21, -21, -23, -23,
-23, -25, -26, -26, -26, -27, -29, -29, -30, -31, -32, -32, -33, -34, -35, -36,
-36, -38, -38, -38, -40, -41, -42, -42, -43, -44, -44, -46, -46, -47, -48, -49,
-49, -51, -50, -52, -51, -55, -52, -59, -51, -2, -14, 17, 38, 29, 36, 30, 36,
30, 37, 29, 39, 17, -17, -11, -14, -13, -15, -15, -16, -16, -17, -18, -19, -21,
-21, -21, -23, -25, -26, -25, -19, -15, -11, -9, -5, -2, 1, 3, 6, 7, 9, 11, 10,
10, 10, 10, 10, 11, 10, 10, 10, 11, 10, 10, 10, 10, 10, 9, 10, 10, 10, 10, 10,
10, 10, 10, 10, 10, 7, 5, 4, 1, 0, -2, -5, -6, -7, -10, -12, -14, -15, -17, -19,
-20, -22, -23, -25, -26, -27, -29, -31, -32, -34, -36, -37, -39, -40, -41, -43,
-45, -45, -47, -49, -50, -51, -53, -54, -56, -57, -58, -60, -61, -62, -62, -63,
-64, -63, -64, -65, -63, -64, -64, -64, -64, -63, -64, -64, -63, -64, -63, -63,
-64, -63, -63, -63, -62, -63, -64, -63, -62, -63, -62, -60, -60, -58, -57, -55,
-55, -52, -50, -49, -48, -47, -44, -43, -41, -39, -37, -36, -33, -32, -31, -29,
-26, -24, -22, -22, -19, -18, -16, -14, -12, -10, -9, -6, -4, -3, -1, 0, 2, 4,
6, 9, 10, 13, 15, 17, 19, 22, 23, 26, 28, 30, 32, 34, 35, 35, 35, 36, 35, 35,
36, 36, 37, 36, 36, 37, 37, 37, 37, 37, 37, 36, 37, 37, 37, 37, 37, 37, 37, 37,
36, 37, 37, 38, 38, 37, 37, 38, 37, 38, 37, 37, 37, 37, 37, 37, 38, 37, 37, 37,
37, 38, 37, 37, 37, 38, 37, 37, 38, 37, 35, 35, 34, 35, 33, 33, 32, 32, 31, 30,
31, 30, 29, 29, 29, 28, 28, 27, 27, 26, 26, 26, 25, 25, 24, 24, 23, 22, 22, 22,
22, 20, 20, 20, 20, 20, 19, 18, 18, 17, 16, 15, 16, 15, 14, 15, 14, 13, 12, 12,
12, 11, 11, 11, 10, 10, 9, 9, 7, 8, 7, 6, 6, 7, 5, 6, 4, };