#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0042

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 1, 1, 1, 2, 1, 2, 2, 3, 2, 3,
5, 4, 4, 4, 4, 3, 3, 2, 3, 2, 1, 0, 0, 0, -1, -2, -3, -3, -5, -6, -6, -6, -7,
-9, -8, -10, -10, -10, -11, -11, -11, -12, -12, -13, -14, -13, -15, -14, -16,
-16, -17, -15, -18, -17, -19, -17, -21, -18, -23, -18, -24, -15, 41, 40, 42, 43,
44, 46, 47, 49, 49, 52, 54, 57, 56, 60, 62, 65, 65, 67, 68, 69, 70, 72, 74, 76,
78, 80, 80, 81, 84, 86, 88, 89, 92, 93, 95, 96, 98, 98, 99, 101, 103, 104, 106,
107, 108, 110, 112, 113, 114, 115, 116, 118, 120, 120, 118, 118, 118, 118, 118,
118, 118, 118, 118, 117, 117, 116, 117, 116, 117, 116, 115, 116, 116, 115, 115,
114, 114, 114, 114, 113, 114, 113, 114, 114, 113, 113, 113, 113, 112, 112, 111,
108, 102, 99, 97, 93, 91, 89, 86, 83, 79, 75, 71, 67, 63, 58, 53, 48, 42, 38,
34, 30, 26, 23, 20, 17, 15, 12, 11, 4, -3, -3, -5, -4, -6, -9, -10, -11, -14,
-15, -15, -18, -19, -20, -22, -23, -24, -25, -26, -28, -29, -30, -31, -32, -34,
-35, -37, -37, -38, -39, -40, -41, -42, -43, -43, -44, -46, -48, -48, -49, -51,
-51, -52, -54, -56, -57, -59, -60, -60, -61, -62, -64, -64, -67, -70, -72, -73,
-75, -78, -80, -81, -84, -87, -88, -91, -94, -99, -99, -100, -103, -105, -107,
-109, -110, -109, -109, -108, -108, -107, -105, -105, -104, -104, -103, -104,
-102, -102, -101, -101, -100, -100, -99, -99, -98, -98, -97, -97, -96, -96, -94,
-94, -93, -92, -91, -91, -90, -89, -88, -88, -86, -86, -86, -86, -85, -84, -83,
-83, -83, -80, -81, -80, -79, -78, -78, -77, -76, -76, -74, -75, -74, -74, -73,
-73, -72, -72, -70, -70, -68, -69, -67, -67, -66, -66, -65, -63, -63, -62, -63,
-62, -61, -61, -61, -60, -59, -59, -57, -56, -56, -55, -55, -54, -53, -52, -51,
-51, -50, -48, -47, -47, -45, -46, -44, -44, -43, -43, -41, -41, -40, -41, -39,
-38, -37, -37, -36, -34, -34, -33, -32, -31, -31, -30, -29, -29, -28, -28, -25,
-25, -24, -24, -23, -22, -21, -19, -19, -18, -17, -16, -16, -14, -13, -12, -10,
-9, -8, -7, -6, -5, -3, -2, -1, 0, 1, 2, 4, 5, 7, 8, 9, 11, 11, 13, 15, 15, 17,
19, 20, 23, 23, 25, 26, 26, 26, 26, 28, 28, 28, 28, 29, 29, 27, 27, 27, 26, 26,
26, 24, 24, 23, 23, 22, 22, 20, 19, 20, 18, 18, 18, 18, 17, 16, 15, 16, 15, 15,
16, 17, 17, 16, 15, 17, 16, 16, 16, 15, 16, 15, 15, 15, 15, 15, 15, 14, 15, 14,
14, 15, 14, 14, 14, 14, 14, 14, 14, 14, 14, 13, 12, 13, 12, 12, 12, 12, 11, 11,
12, 11, 11, 10, 9, 9, 7, 7, 7, 6, 6, 5, 3, };