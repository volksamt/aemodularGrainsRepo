#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 4, 6, 9, 12, 13, 15, 17, 18,
19, 20, 23, 23, 25, 25, 28, 30, 29, 31, 31, 31, 33, 34, 35, 36, 36, 37, 38, 39,
41, 42, 44, 44, 46, 46, 47, 48, 49, 51, 51, 51, 52, 54, 54, 56, 57, 58, 59, 60,
62, 64, 64, 66, 67, 69, 71, 72, 72, 74, 75, 75, 76, 79, 79, 80, 81, 81, 82, 83,
83, 84, 84, 85, 87, 87, 88, 90, 90, 91, 92, 92, 95, 98, 100, 103, 106, 109, 110,
112, 112, 113, 115, 116, 117, 119, 120, 117, 115, 111, 105, 105, 103, 102, 100,
100, 97, 96, 93, 93, 90, 86, 79, 71, 67, 61, 56, 49, 45, 43, 40, 38, 37, 34, 27,
23, 22, 20, 18, 15, 13, 7, 5, 2, 1, -1, -4, -6, -8, -9, -11, -13, -19, -26, -30,
-35, -39, -40, -41, -43, -43, -45, -46, -48, -49, -50, -51, -52, -55, -55, -57,
-58, -59, -61, -64, -66, -67, -68, -69, -70, -71, -74, -76, -79, -81, -84, -89,
-89, -92, -95, -98, -100, -102, -103, -103, -103, -105, -106, -107, -109, -113,
-115, -117, -116, -107, -105, -103, -101, -99, -97, -95, -94, -92, -90, -88,
-87, -85, -83, -82, -81, -79, -77, -76, -75, -74, -72, -70, -70, -68, -67, -65,
-64, -62, -60, -58, -56, -54, -52, -49, -47, -47, -44, -43, -42, -40, -39, -39,
-36, -35, -34, -33, -32, -30, -28, -27, -26, -24, -22, -21, -19, -13, -7, -1, 2,
2, 4, 5, 8, 8, 10, 12, 13, 14, 17, 20, 21, 22, 24, 24, 25, 25, 21, 20, 18, 18,
16, 15, 13, 12, 11, 9, 9, 8, 7, 6, 5, 4, 1, -6, -11, -15, -16, -19, -20, -22,
-22, -18, -14, -8, -4, -4, -2, -1, 0, 1, 2, 3, 3, 5, 7, 8, 10, 11, 15, 13, 12,
12, 11, 8, 8, 7, 6, 5, 4, 2, 1, 2, 0, -1, -2, -3, -4, -4, -7, -7, -8, -9, -10,
-10, -12, -11, -12, -13, -14, -14, -15, -16, -17, -18, -19, -20, -21, -21, -21,
-22, -24, -24, -25, -26, -26, -27, -27, -26, -21, -20, -18, -16, -16, -14, -14,
-12, -11, -10, -8, -8, -7, -5, -5, -3, -2, -1, 0, 2, 2, 3, 4, 7, 7, 6, 5, 4, 3,
2, 1, 0, 0, -2, -2, -3, -4, -5, -5, -7, -7, -9, -10, -10, -10, -12, -12, -12,
-13, -14, -15, -15, -15, -17, -14, -8, -7, -5, -4, -2, -1, 1, 2, 3, 4, 5, 6, 5,
4, 4, 3, 2, 2, 1, 1, -1, -1, -1, -2, -3, -3, -4, -5, -6, -5, -7, -7, -7, -7, -9,
-9, -9, -9, -7, -6, -6, -5, -5, -2, -3, -1, 0, 0, 0, 1, 2, 3, 2, 3, 3, 4, 4, 3,
2, 2, 2, 1, 1, 0, 0, -1, -1, -1, -2, -3, -3, -3, -3, -3, -3, -3, -2, -2, -2, -1,
-2, -1, -1, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, };