#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0029

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 115, 122, 117, 122, 118,
121, 117, 121, 117, 120, 115, 116, 114, 116, 114, 115, 114, 113, 111, 110, 108,
107, 106, 103, 102, 101, 99, 96, 91, 88, 87, 85, 83, 78, 75, 69, 65, 63, 63, 57,
49, 49, 49, 48, 48, 47, 37, 36, 33, 30, 28, 26, 23, 19, 19, 14, 10, 8, 5, 3, 1,
0, -2, -3, 2, 1, 1, 1, 1, 0, 1, 1, 1, 1, 0, 2, 2, 1, 1, 1, 2, 1, 1, 1, 2, 2, 1,
1, 2, 2, 2, 2, 3, 3, 2, 3, 3, 3, 3, 2, 4, 3, 3, 3, 3, 3, 4, 4, 4, 5, 5, 4, 4, 4,
4, 4, 3, 4, 4, 4, 4, 4, 4, 5, 4, 4, 4, 5, 5, 4, 4, 5, 5, 5, 5, 5, 5, 6, 5, 5, 5,
5, 5, 6, 5, 6, 5, 5, 5, 5, 5, 5, 6, 6, 6, 6, 6, 6, 6, 5, 5, 6, 6, 5, 6, 6, 5, 6,
6, 5, 6, 5, 5, 6, 5, 5, 5, 6, 6, 6, 5, 6, 5, 5, 6, 6, 6, 6, 6, 5, 6, 5, 6, 6, 6,
5, 6, 5, 6, 5, 6, 6, 6, 6, 6, 5, 6, 6, 6, 5, 5, 5, 5, 5, 6, 6, 6, 6, 5, 6, 6, 6,
5, 6, 5, 5, 5, 5, 6, 6, 6, 5, 6, 5, 5, 6, 6, 5, 5, 5, 5, 6, 5, 5, 5, 6, 6, 6, 5,
5, 5, 6, 6, 5, 5, 6, 5, 6, 5, 6, 5, 5, 5, 5, 5, 6, 6, 6, 5, 6, 5, 5, 5, 5, 5, 6,
5, 5, 5, 5, 6, 6, 5, 5, 5, 5, 6, 6, 6, 6, 6, 6, 5, 6, 6, 6, 5, 5, 6, 5, 5, 6, 6,
5, 6, 5, 5, 6, 5, 5, 6, 6, 6, 6, 6, 6, 5, 6, 6, 6, 5, 5, 6, 6, 6, 6, 5, 6, 6, 6,
6, 6, 6, 6, 5, 5, 5, 5, 5, 4, 5, 5, 4, 4, 4, 5, 4, 4, 3, 4, 3, 3, 3, 3, 3, 3, 2,
3, 3, 3, 2, 2, 3, 2, 4, 3, 3, 3, 2, 3, 3, 3, 2, 3, 3, 3, 3, 3, 4, 3, 2, 3, 2, 3,
3, 3, 3, 2, 3, 2, 3, 3, 3, 2, 2, 3, 3, 2, 3, 3, 3, 3, 2, 3, 3, 3, 3, 3, 2, 3, 3,
2, 3, 3, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 1, 1, 1, 0, -1, 0, 0, -1,
0, -1, -1, -1, -1, -1, -1, -1, -2, -2, -2, -1, -1, -1, -1, -1, -1, -1, 0, -1, 0,
0, 0, -1, 1, 0, 2, 0, 2, 1, 3, -1, -5, -24, -56, -74, -102, -106, -106, -111,
-108, -111, -104, -95, -80, -75, -48, 0, 9, 5, 7, 5, 6, 5, 5, 4, 5, 4, 4, 4, 3,
4, 4, 3, 4, 2, 3, 3, 3, 3, 2, 2, 2, };