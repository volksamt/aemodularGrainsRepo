#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {103, 122, 114, 120, 115, 121, 117,
121, 116, 120, 117, 120, 116, 116, 115, 117, 115, 115, 115, 114, 114, 113, 114,
113, 112, 111, 112, 111, 112, 112, 112, 111, 111, 111, 110, 110, 110, 110, 111,
111, 111, 111, 111, 110, 109, 109, 109, 108, 108, 108, 107, 107, 106, 107, 106,
106, 106, 107, 105, 107, 106, 106, 107, 106, 106, 106, 106, 106, 106, 105, 105,
104, 105, 104, 104, 104, 103, 104, 103, 103, 103, 103, 102, 102, 102, 102, 101,
102, 102, 101, 101, 101, 101, 101, 101, 101, 101, 101, 101, 100, 100, 100, 100,
100, 100, 100, 99, 100, 99, 99, 99, 99, 99, 99, 99, 98, 98, 98, 99, 98, 99, 98,
98, 98, 98, 97, 98, 98, 98, 98, 98, 99, 98, 98, 97, 98, 97, 98, 98, 97, 98, 97,
96, 98, 96, 96, 96, 96, 95, 96, 96, 95, 95, 95, 96, 94, 94, 94, 94, 94, 94, 94,
93, 94, 94, 93, 93, 93, 93, 93, 93, 93, 93, 93, 92, 92, 92, 92, 92, 92, 93, 92,
92, 91, 92, 92, 91, 92, 93, 92, 92, 92, 91, 92, 92, 92, 91, 92, 91, 91, 90, 91,
91, 91, 91, 91, 90, 90, 91, 91, 90, 89, 90, 90, 89, 89, 89, 89, 89, 89, 88, 89,
88, 88, 89, 88, 88, 88, 88, 88, 87, 88, 87, 88, 87, 88, 87, 87, 87, 87, 87, 87,
87, 87, 86, 86, 86, 86, 86, 86, 86, 86, 86, 85, 86, 85, 85, 85, 85, 85, 84, 85,
84, 84, 83, 84, 83, 84, 84, 83, 83, 83, 82, 82, 82, 82, 82, 82, 82, 81, 82, 80,
81, 81, 81, 81, 81, 81, 80, 80, 81, 80, 80, 80, 79, 79, 79, 79, 78, 78, 78, 78,
78, 77, 77, 77, 76, 76, 76, 76, 76, 74, 75, 74, 75, 74, 73, 73, 72, 72, 73, 72,
72, 71, 72, 71, 72, 71, 70, 71, 71, 71, 69, 70, 69, 69, 66, 66, 65, 66, 64, 64,
64, 63, 62, 62, 61, 61, 60, 60, 56, 56, 55, 55, 54, 54, 54, 53, 51, 47, 47, 45,
43, 42, 41, 38, 37, 35, 33, 31, 30, 27, 21, 21, 21, 19, 19, 19, 13, 9, 1, -2,
-2, -2, -3, -4, -4, -4, -9, -16, -21, -26, -31, -37, -43, -48, -54, -59, -64,
-69, -71, -72, -74, -76, -78, -80, -80, -82, -84, -86, -88, -89, -94, -98, -99,
-99, -99, -100, -101, -103, -104, -106, -105, -107, -107, -108, -108, -110,
-111, -110, -111, -110, -111, -110, -110, -110, -111, -112, -113, -113, -113,
-113, -113, -113, -113, -114, -114, -114, -114, -114, -115, -115, -114, -115,
-115, -115, -115, -115, -115, -115, -115, -115, -115, -115, -114, -114, -115,
-115, -115, -114, -115, -115, -115, -115, -115, -116, -115, -115, -114, -115,
-115, -115, -114, -115, -115, -115, -114, -115, -115, -115, -114, -115, -115,
-114, -116, -114, -116, -114, -116, -114, -116, -113, -117, -113, -118, -112,
-118, -112, -118, -109, -122, -98, };