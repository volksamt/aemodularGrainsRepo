#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, -1, -1, -1, -1, -2, -1, -1, -1,
0, 0, 1, 2, 2, 3, 3, 3, 4, 4, 4, 5, 5, 6, 7, 7, 7, 8, 9, 10, 10, 11, 10, 11, 11,
13, 13, 13, 14, 14, 15, 16, 18, 17, 19, 20, 21, 22, 22, 23, 23, 24, 24, 24, 25,
25, 25, 25, 26, 27, 27, 27, 27, 27, 29, 29, 29, 30, 30, 30, 31, 31, 31, 32, 32,
32, 33, 33, 33, 34, 35, 34, 35, 35, 35, 36, 37, 37, 37, 37, 37, 38, 37, 38, 38,
39, 39, 40, 40, 41, 40, 41, 41, 41, 42, 43, 42, 43, 44, 44, 44, 44, 45, 45, 46,
45, 46, 46, 45, 47, 47, 43, 37, 31, 24, 21, 23, 24, 26, 26, 26, 27, 27, 29, 29,
28, 30, 30, 30, 31, 31, 32, 33, 32, 33, 34, 35, 36, 36, 36, 37, 37, 39, 39, 40,
40, 41, 42, 42, 42, 42, 43, 44, 44, 45, 45, 45, 46, 46, 48, 48, 48, 49, 50, 50,
51, 51, 52, 52, 53, 54, 55, 55, 55, 56, 57, 58, 59, 59, 60, 61, 63, 64, 65, 66,
67, 68, 69, 71, 71, 72, 72, 73, 73, 74, 75, 75, 76, 77, 76, 77, 78, 79, 79, 79,
80, 80, 82, 82, 83, 83, 84, 84, 84, 85, 86, 86, 87, 87, 88, 88, 88, 90, 90, 90,
86, 77, 73, 74, 74, 75, 76, 76, 77, 77, 78, 78, 79, 79, 79, 80, 80, 80, 82, 82,
82, 83, 83, 84, 84, 86, 86, 87, 87, 88, 88, 89, 89, 90, 90, 91, 91, 91, 93, 92,
94, 93, 95, 95, 96, 95, 96, 97, 98, 98, 99, 100, 100, 100, 101, 102, 103, 103,
105, 105, 105, 106, 106, 108, 105, 113, 65, 4, -60, -102, -109, -122, -117,
-120, -117, -118, -116, -117, -116, -116, -116, -115, -115, -115, -115, -114,
-113, -111, -110, -107, -106, -105, -103, -101, -101, -100, -99, -100, -100,
-98, -97, -96, -96, -95, -95, -94, -94, -93, -93, -92, -90, -90, -88, -88, -88,
-88, -87, -86, -86, -86, -86, -85, -85, -85, -85, -84, -84, -83, -83, -84, -83,
-83, -83, -83, -84, -83, -89, -91, -90, -91, -90, -90, -90, -89, -89, -89, -87,
-87, -87, -86, -85, -85, -84, -84, -84, -83, -81, -81, -81, -80, -79, -79, -79,
-78, -77, -78, -76, -76, -77, -75, -76, -74, -75, -74, -73, -72, -72, -72, -71,
-71, -70, -69, -68, -68, -67, -66, -66, -65, -64, -64, -62, -61, -60, -59, -59,
-57, -56, -55, -55, -53, -53, -52, -51, -51, -49, -49, -48, -47, -46, -46, -45,
-44, -43, -43, -42, -41, -41, -40, -40, -37, -37, -36, -35, -35, -34, -33, -32,
-31, -30, -30, -30, -29, -28, -28, -27, -27, -26, -26, -26, -25, -25, -25, -23,
-22, -23, -22, -21, -21, -20, -19, -18, -16, -15, -14, -13, -13, -12, -11, -11,
-10, -10, -8, -8, -8, -7, -6, -6, -5, -5, -4, -3, -2, -2, -1, 0, 0, 0, };