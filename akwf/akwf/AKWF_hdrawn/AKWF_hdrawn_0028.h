#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0028

const PROGMEM int8_t DATA[DATA_LENGTH] = {105, 125, 116, 122, 116, 121, 118,
122, 117, 120, 117, 120, 119, 121, 118, 119, 119, 119, 119, 119, 119, 120, 119,
120, 119, 118, 119, 119, 119, 120, 119, 119, 119, 119, 118, 120, 118, 120, 118,
120, 118, 119, 119, 120, 119, 119, 119, 118, 122, 114, 122, 20, 2, 25, -5, 4,
-3, 3, -2, 2, -1, 1, -1, 2, 0, 1, 1, 1, 0, 1, 1, 0, 1, 0, 1, 0, 2, 1, 2, 1, 1,
1, 2, 1, 2, 2, 2, 2, 2, 2, 2, 2, 3, 2, 2, 3, 2, 3, 3, 2, 2, 3, 2, 3, 3, 3, 3, 3,
3, 4, 4, 4, 4, 4, 4, 4, 5, 4, 4, 3, 5, 4, 5, 4, 4, 5, 5, 3, 4, 5, 4, 4, 5, 5, 5,
4, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 6, 6, 5, 5, 6, 6, 6, 5, 6, 6, 5, 5, 6, 5, 5, 5,
5, 5, 6, 5, 6, 6, 6, 5, 5, 5, 5, 5, 6, 5, 5, 6, 5, 5, 5, 6, 6, 6, 5, 5, 6, 6, 6,
5, 5, 5, 6, 6, 6, 5, 6, 6, 6, 5, 6, 5, 6, 5, 5, 6, 6, 5, 6, 5, 6, 6, 5, 6, 5, 5,
6, 5, 5, 6, 5, 6, 5, 6, 5, 6, 6, 5, 5, 6, 5, 6, 5, 6, 6, 6, 5, 5, 5, 5, 5, 6, 5,
5, 5, 6, 6, 6, 6, 6, 6, 5, 6, 5, 5, 6, 5, 5, 6, 6, 5, 5, 6, 6, 6, 5, 5, 6, 5, 5,
6, 6, 5, 5, 6, 6, 6, 5, 5, 5, 6, 5, 5, 6, 5, 6, 6, 5, 5, 6, 5, 5, 5, 6, 5, 6, 6,
5, 5, 6, 6, 6, 5, 5, 6, 6, 5, 5, 6, 6, 6, 5, 5, 6, 6, 5, 6, 6, 6, 6, 6, 5, 6, 5,
5, 5, 6, 5, 6, 5, 6, 6, 5, 5, 5, 5, 6, 5, 5, 5, 4, 5, 5, 4, 4, 5, 4, 3, 4, 3, 4,
3, 4, 3, 4, 3, 3, 2, 3, 3, 4, 3, 2, 3, 3, 3, 3, 2, 3, 2, 3, 3, 2, 2, 2, 3, 3, 3,
3, 3, 3, 2, 3, 2, 2, 3, 3, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 4, 3, 3, 2, 3, 2, 3,
2, 2, 3, 3, 2, 3, 4, 3, 2, 3, 3, 3, 2, 2, 2, 2, 2, 2, 2, 1, 2, 1, 2, 2, 1, 2, 1,
0, 0, 0, 1, 1, -1, -1, -1, 0, 0, -1, -1, -2, -1, -2, -1, -1, -1, -1, -2, -2, -1,
-2, -1, -1, -1, -1, 0, -1, 0, -1, 1, 0, 2, 0, 2, 1, 2, 0, -5, -24, -56, -75,
-102, -106, -106, -111, -108, -110, -104, -95, -82, -75, -47, 1, 8, 6, 6, 5, 5,
4, 5, 4, 5, 4, 5, 4, 4, 4, 4, 3, 3, 2, 3, 3, 3, 2, 2, 2, 1, };