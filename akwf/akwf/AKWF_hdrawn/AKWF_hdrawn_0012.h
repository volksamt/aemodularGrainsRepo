#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 0, 0, -1, 0, 0, -1, 0, 1, 1, 0, 0,
0, 1, 0, 0, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1,
1, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, 1, 1, 0, 0, 2, 0, 2, 0, 2, -1, 2, 0, 2, -2, 5,
45, 46, 48, 49, 50, 53, 54, 56, 57, 61, 61, 64, 65, 66, 66, 66, 66, 67, 69, 70,
70, 71, 73, 73, 73, 74, 74, 75, 76, 77, 76, 77, 79, 79, 79, 81, 81, 82, 82, 83,
84, 84, 86, 86, 86, 86, 87, 87, 88, 90, 91, 93, 94, 96, 98, 97, 98, 97, 98, 99,
99, 100, 101, 101, 103, 102, 104, 105, 105, 105, 108, 110, 109, 108, 108, 108,
109, 107, 104, 103, 102, 102, 100, 101, 100, 100, 100, 99, 97, 96, 97, 96, 95,
95, 94, 93, 93, 92, 91, 90, 89, 86, 85, 83, 81, 80, 80, 79, 79, 76, 77, 75, 74,
73, 74, 69, 69, 66, 66, 61, 60, 57, 57, 56, 54, 55, 9, -3, 3, 0, 3, 0, 3, 1, 2,
0, 3, 2, 2, 1, 2, 1, 2, 1, 2, 1, 2, 2, 1, 2, 2, 1, 2, 1, 1, 1, 1, 1, 1, 2, 1, 1,
1, 1, 1, 0, 0, 1, 0, 2, 2, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 0, -1, 1, -1, 0, 0,
0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, -1, -1, 0, 0, -1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, -9, -20, -25, -30, -32, -36, -38, -41, -44,
-48, -50, -55, -57, -60, -63, -65, -68, -70, -72, -75, -77, -78, -81, -82, -84,
-84, -84, -84, -86, -85, -88, -89, -90, -89, -91, -91, -91, -92, -94, -94, -94,
-95, -96, -95, -97, -97, -97, -97, -98, -98, -99, -99, -101, -100, -100, -101,
-102, -103, -103, -103, -104, -104, -105, -105, -105, -106, -106, -106, -107,
-108, -107, -107, -108, -109, -109, -109, -110, -112, -112, -111, -112, -113,
-113, -113, -115, -114, -114, -115, -115, -116, -116, -116, -116, -115, -115,
-116, -116, -117, -117, -117, -117, -117, -117, -117, -118, -118, -118, -118,
-119, -118, -119, -119, -119, -120, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -118, -118, -119, -119, -119, -119, -119, -118,
-119, -118, -119, -118, -118, -118, -117, -118, -118, -117, -118, -117, -117,
-117, -117, -116, -116, -117, -117, -116, -117, -115, -116, -116, -115, -114,
-113, -114, -113, -112, -110, -109, -106, -105, -104, -104, -103, -102, -102,
-101, -101, -100, -99, -98, -98, -97, -96, -95, -94, -92, -92, -91, -91, -89,
-88, -85, -83, -76, -71, -64, -54, -45, -37, -33, -28, -24, -21, -20, -18, -13,
-10, -10, -8, -8, -7, -6, -5, -6, -5, -4, -4, -3, -2, -2, 0, 0, -1, 0, 0, };