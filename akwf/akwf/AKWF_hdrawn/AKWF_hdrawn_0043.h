#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0043

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 0, 1, 1, 1, 1, 2, 2, 2, 3, 4,
6, 5, 5, 4, 4, 4, 3, 3, 3, 2, 1, 1, 0, 0, -1, -2, -3, -3, -5, -6, -6, -7, -7,
-8, -8, -10, -10, -11, -10, -11, -12, -12, -12, -12, -14, -13, -14, -15, -16,
-15, -17, -16, -18, -17, -19, -17, -20, -18, -22, -19, -25, -16, 41, 41, 42, 43,
43, 46, 48, 48, 50, 52, 53, 57, 56, 60, 62, 65, 65, 67, 68, 69, 69, 72, 74, 76,
77, 79, 80, 81, 83, 86, 88, 89, 91, 93, 95, 96, 98, 99, 100, 101, 103, 104, 105,
108, 109, 110, 112, 113, 114, 115, 116, 116, 119, 118, 114, 112, 110, 108, 103,
97, 91, 88, 87, 84, 79, 76, 76, 73, 72, 72, 73, 74, 74, 75, 77, 79, 81, 85, 89,
93, 94, 98, 104, 105, 108, 108, 110, 110, 110, 111, 111, 108, 102, 100, 96, 93,
91, 89, 87, 84, 79, 76, 72, 67, 63, 57, 53, 48, 42, 38, 34, 30, 26, 23, 20, 18,
15, 13, 11, 4, -2, -3, -5, -5, -7, -8, -9, -11, -13, -15, -17, -17, -18, -20,
-21, -22, -25, -21, -20, -20, -18, -19, -18, -17, -16, -16, -15, -16, -15, -14,
-14, -14, -13, -13, -13, -13, -11, -12, -12, -13, -12, -13, -12, -12, -12, -12,
-11, -11, -11, -12, -11, -11, -12, -12, -11, -11, -12, -12, -12, -11, -11, -12,
-12, -12, -11, -12, -12, -13, -12, -12, -14, -14, -15, -16, -16, -18, -20, -21,
-23, -25, -26, -29, -31, -34, -36, -39, -42, -44, -46, -48, -49, -50, -51, -53,
-54, -55, -56, -57, -58, -59, -59, -61, -61, -62, -63, -64, -64, -64, -65, -67,
-67, -68, -68, -70, -70, -70, -72, -71, -71, -73, -73, -74, -75, -75, -75, -75,
-74, -75, -75, -74, -72, -73, -73, -71, -71, -70, -70, -69, -68, -67, -68, -66,
-66, -65, -64, -63, -63, -63, -62, -61, -61, -60, -60, -59, -58, -58, -57, -56,
-55, -54, -54, -53, -52, -51, -50, -49, -48, -48, -47, -46, -46, -45, -44, -44,
-42, -42, -41, -41, -40, -39, -38, -37, -36, -37, -35, -35, -33, -32, -31, -31,
-29, -30, -29, -28, -27, -26, -25, -24, -23, -23, -21, -20, -20, -19, -18, -17,
-16, -15, -14, -13, -11, -10, -9, -8, -7, -6, -5, -3, -1, -1, 0, 2, 3, 4, 4, 6,
8, 9, 11, 11, 13, 15, 15, 17, 20, 21, 24, 23, 25, 25, 26, 26, 26, 27, 28, 28,
29, 28, 29, 28, 27, 27, 26, 26, 26, 26, 24, 24, 23, 23, 22, 20, 20, 19, 19, 18,
17, 17, 16, 17, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 16, 15, 16, 15, 15,
15, 16, 15, 15, 15, 15, 15, 14, 14, 14, 15, 14, 14, 15, 14, 14, 14, 13, 13, 13,
13, 13, 13, 12, 12, 12, 11, 11, 12, 11, 11, 11, 9, 9, 8, 7, 7, 7, 6, 5, 3, };