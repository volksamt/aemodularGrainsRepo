#define DATA_LENGTH 512
#define DATA AKWF_hdrawn_0033

const PROGMEM int8_t DATA[DATA_LENGTH] = {-2, -2, -1, -2, 2, 4, 4, 4, 4, 4, 3,
4, 4, 4, 4, 4, 3, 4, 4, 5, 6, 5, 7, 6, 9, 14, 27, 35, 34, 34, 36, 35, 36, 35,
36, 35, 35, 36, 36, 36, 37, 61, 62, 61, 62, 61, 62, 61, 63, 61, 61, 61, 62, 62,
62, 62, 63, 63, 63, 63, 64, 62, 63, 62, 65, 69, 76, 80, 79, 79, 80, 80, 80, 80,
80, 79, 80, 80, 80, 80, 80, 80, 80, 79, 80, 79, 80, 80, 80, 80, 80, 80, 80, 79,
81, 79, 81, 82, 83, 95, 101, 99, 100, 99, 99, 99, 100, 99, 100, 99, 100, 99, 99,
99, 100, 100, 99, 99, 99, 99, 101, 110, 112, 111, 111, 111, 112, 110, 111, 111,
111, 112, 111, 112, 111, 112, 111, 111, 113, 113, 118, 119, 120, 119, 119, 119,
119, 119, 119, 119, 119, 119, 117, 116, 110, 105, 106, 105, 106, 106, 106, 106,
106, 106, 106, 106, 106, 106, 106, 106, 106, 106, 105, 107, 106, 106, 106, 105,
107, 90, 84, 86, 85, 85, 85, 85, 85, 85, 85, 85, 85, 74, 60, 60, 62, 62, 62, 61,
62, 62, 61, 61, 61, 61, 60, 61, 61, 61, 61, 60, 61, 59, 51, 45, 38, 32, 26, 25,
26, 26, 26, 27, 27, 26, 26, 25, 12, 10, 11, 10, 11, 9, 10, 10, 10, 10, 11, 9,
13, 6, -5, -4, -4, -4, -4, -4, -4, -4, -3, -4, -5, -5, -7, -8, -11, -12, -13,
-15, -17, -19, -20, -22, -25, -38, -47, -47, -48, -48, -47, -48, -47, -47, -47,
-47, -47, -47, -47, -48, -47, -53, -65, -64, -65, -64, -64, -64, -63, -64, -64,
-64, -63, -64, -63, -65, -64, -66, -74, -78, -81, -81, -81, -82, -80, -81, -81,
-80, -82, -82, -80, -81, -81, -82, -83, -83, -83, -85, -88, -90, -90, -90, -89,
-88, -88, -87, -88, -88, -88, -88, -91, -93, -101, -106, -106, -106, -106, -105,
-105, -107, -105, -106, -105, -106, -106, -106, -107, -107, -107, -107, -107,
-107, -107, -107, -108, -107, -107, -109, -109, -108, -109, -109, -113, -116,
-117, -117, -116, -117, -116, -117, -117, -117, -116, -117, -117, -116, -117,
-116, -116, -116, -117, -117, -116, -116, -116, -116, -117, -116, -116, -117,
-116, -117, -116, -116, -116, -117, -116, -117, -116, -117, -116, -117, -116,
-117, -111, -102, -104, -103, -103, -103, -104, -104, -103, -103, -104, -103,
-103, -104, -103, -103, -103, -102, -104, -104, -103, -100, -98, -95, -95, -94,
-92, -93, -93, -93, -93, -92, -92, -93, -92, -93, -93, -93, -93, -93, -92, -94,
-93, -94, -93, -74, -72, -72, -71, -72, -69, -69, -69, -69, -69, -69, -70, -69,
-71, -65, -56, -53, -50, -51, -49, -50, -50, -49, -50, -49, -50, -48, -49, -47,
-50, -41, -21, -24, -23, -23, -22, -22, -22, -21, -21, -20, -21, -21, -22, -19,
-16, -13, -9, -7, -2, -1, -1, -1, -1, 0, 0, 0, 1, 1, 2, 1, 1, 1, 1, 1, };