#define DATA_LENGTH 512
#define DATA AKWF_clarinett_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 10, 13, 16, 20, 22, 24, 27, 29,
31, 32, 33, 34, 36, 37, 37, 38, 38, 40, 42, 44, 46, 47, 51, 54, 56, 56, 56, 57,
56, 56, 56, 57, 56, 57, 57, 59, 59, 61, 61, 62, 62, 62, 63, 62, 61, 61, 61, 60,
60, 59, 60, 60, 60, 59, 59, 59, 58, 58, 58, 58, 58, 58, 59, 58, 57, 56, 54, 52,
50, 50, 48, 48, 47, 47, 47, 47, 45, 46, 45, 45, 45, 44, 43, 42, 41, 41, 39, 38,
36, 34, 32, 30, 28, 27, 26, 25, 25, 24, 22, 21, 21, 20, 18, 17, 15, 13, 11, 10,
10, 9, 10, 11, 10, 11, 11, 11, 11, 10, 11, 11, 11, 12, 12, 13, 14, 15, 16, 16,
17, 17, 16, 16, 16, 15, 14, 14, 14, 14, 15, 16, 17, 18, 21, 23, 25, 28, 28, 30,
30, 32, 32, 33, 33, 34, 35, 37, 37, 39, 40, 42, 44, 45, 45, 49, 50, 51, 52, 54,
56, 57, 58, 61, 63, 64, 65, 67, 67, 68, 68, 69, 69, 70, 71, 72, 73, 74, 75, 76,
78, 79, 81, 82, 83, 84, 85, 84, 84, 84, 85, 86, 88, 89, 92, 93, 94, 94, 95, 96,
95, 96, 95, 96, 96, 97, 97, 97, 98, 98, 99, 99, 98, 99, 98, 98, 97, 97, 96, 95,
94, 94, 93, 92, 91, 89, 87, 86, 83, 81, 79, 78, 75, 73, 70, 67, 64, 61, 59, 54,
52, 49, 45, 42, 38, 33, 29, 24, 21, 16, 14, 10, 7, 4, 0, -3, -8, -12, -16, -19,
-24, -27, -29, -32, -35, -37, -39, -40, -42, -45, -47, -50, -52, -54, -56, -58,
-58, -60, -60, -60, -60, -60, -60, -60, -62, -62, -62, -62, -62, -63, -61, -63,
-63, -64, -65, -66, -66, -66, -64, -63, -62, -59, -58, -58, -56, -56, -56, -56,
-56, -57, -57, -57, -56, -55, -53, -51, -50, -50, -49, -49, -49, -48, -49, -48,
-49, -48, -49, -49, -49, -49, -49, -49, -49, -48, -48, -47, -47, -46, -45, -44,
-44, -42, -40, -38, -37, -35, -34, -33, -32, -32, -30, -30, -28, -27, -26, -24,
-23, -20, -19, -17, -15, -15, -14, -14, -12, -11, -10, -10, -8, -7, -7, -6, -6,
-6, -5, -5, -5, -4, -6, -5, -5, -4, -4, -5, -4, -4, -6, -7, -7, -9, -10, -10,
-12, -13, -15, -15, -17, -19, -20, -22, -24, -26, -28, -31, -33, -35, -38, -40,
-42, -44, -47, -51, -54, -56, -58, -61, -63, -65, -68, -69, -72, -74, -76, -78,
-79, -82, -84, -86, -90, -92, -95, -97, -98, -100, -101, -102, -102, -104, -105,
-108, -108, -110, -111, -112, -114, -114, -115, -116, -117, -117, -117, -118,
-117, -118, -117, -118, -118, -119, -119, -119, -119, -118, -117, -115, -113,
-110, -109, -106, -105, -104, -102, -99, -97, -94, -90, -88, -85, -82, -79, -76,
-74, -69, -66, -64, -60, -56, -52, -47, -43, -39, -36, -31, -28, -26, -23, -20,
-17, -15, -12, -8, -5, -1, };