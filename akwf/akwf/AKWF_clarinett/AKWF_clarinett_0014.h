#define DATA_LENGTH 512
#define DATA AKWF_clarinett_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 5, 8, 9, 10, 10, 12, 13,
14, 17, 18, 20, 20, 21, 22, 23, 24, 25, 27, 28, 30, 30, 31, 32, 33, 35, 37, 38,
40, 41, 43, 44, 46, 47, 49, 49, 50, 52, 53, 54, 55, 57, 57, 59, 59, 60, 60, 61,
62, 63, 64, 66, 65, 66, 67, 68, 70, 70, 72, 73, 72, 74, 75, 76, 76, 77, 77, 77,
77, 79, 80, 79, 81, 82, 82, 83, 83, 84, 84, 86, 87, 88, 89, 90, 91, 92, 93, 94,
94, 95, 97, 98, 99, 100, 100, 101, 101, 102, 103, 104, 104, 106, 106, 106, 107,
108, 108, 108, 109, 108, 109, 110, 110, 110, 111, 111, 111, 111, 112, 112, 113,
114, 114, 114, 115, 115, 116, 117, 116, 118, 117, 117, 117, 118, 118, 118, 119,
119, 119, 118, 118, 118, 118, 117, 118, 118, 117, 117, 117, 117, 115, 115, 114,
113, 114, 114, 114, 113, 113, 111, 111, 109, 109, 108, 108, 107, 107, 106, 105,
105, 105, 103, 102, 102, 101, 99, 99, 98, 98, 96, 95, 94, 93, 90, 90, 89, 87,
87, 85, 85, 84, 84, 82, 80, 79, 78, 76, 76, 75, 74, 72, 71, 70, 69, 68, 67, 65,
63, 62, 61, 60, 58, 55, 54, 53, 51, 50, 50, 48, 47, 45, 44, 43, 41, 40, 37, 35,
33, 33, 31, 29, 29, 27, 25, 24, 24, 22, 20, 19, 18, 16, 16, 15, 13, 11, 11, 8,
9, 7, 5, 4, 3, 2, 1, -1, -2, -4, -5, -6, -8, -9, -10, -11, -12, -13, -15, -16,
-17, -19, -20, -21, -22, -22, -24, -25, -27, -28, -28, -29, -30, -31, -33, -34,
-35, -36, -37, -38, -39, -40, -42, -43, -43, -44, -45, -46, -47, -49, -50, -52,
-53, -54, -55, -56, -57, -58, -59, -61, -62, -63, -64, -65, -66, -67, -68, -70,
-70, -71, -73, -73, -74, -76, -76, -76, -78, -79, -80, -80, -81, -82, -83, -83,
-84, -84, -86, -85, -87, -88, -88, -89, -90, -90, -92, -93, -93, -93, -94, -95,
-96, -97, -97, -97, -99, -100, -101, -102, -103, -104, -104, -105, -106, -106,
-108, -108, -109, -109, -109, -111, -111, -112, -112, -113, -113, -114, -115,
-115, -116, -115, -114, -115, -114, -115, -115, -115, -115, -115, -115, -116,
-116, -116, -117, -116, -117, -117, -118, -118, -119, -119, -118, -117, -117,
-118, -117, -118, -119, -119, -118, -117, -117, -118, -117, -117, -117, -117,
-116, -115, -115, -114, -113, -113, -113, -112, -112, -111, -111, -109, -108,
-107, -106, -106, -106, -104, -105, -103, -102, -100, -100, -98, -97, -95, -95,
-94, -93, -91, -90, -88, -86, -86, -85, -84, -82, -80, -79, -77, -77, -77, -76,
-73, -72, -71, -70, -68, -67, -66, -65, -63, -61, -61, -60, -57, -56, -55, -54,
-53, -52, -50, -49, -47, -45, -44, -42, -40, -40, -38, -37, -35, -33, -32, -30,
-29, -27, -26, -25, -23, -21, -19, -18, -16, -14, -14, -12, -11, -9, -9, -7, -6,
-4, -3, -1, 0, };