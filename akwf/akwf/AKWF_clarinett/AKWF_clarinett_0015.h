#define DATA_LENGTH 512
#define DATA AKWF_clarinett_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 3, 5, 4, 6, 8, 10, 12, 14, 16,
19, 19, 19, 20, 21, 22, 24, 26, 28, 30, 32, 32, 33, 34, 37, 38, 40, 41, 42, 41,
42, 42, 44, 44, 46, 47, 48, 49, 50, 49, 51, 51, 53, 55, 56, 56, 57, 57, 58, 59,
60, 61, 62, 63, 63, 64, 65, 68, 68, 71, 72, 73, 74, 74, 76, 76, 77, 77, 78, 79,
81, 82, 83, 83, 85, 85, 86, 87, 88, 88, 88, 89, 91, 90, 90, 90, 92, 92, 92, 92,
91, 91, 93, 94, 95, 95, 97, 96, 98, 99, 99, 100, 100, 101, 101, 102, 103, 104,
105, 106, 107, 108, 108, 108, 108, 108, 109, 110, 111, 113, 113, 113, 113, 113,
113, 113, 113, 115, 116, 116, 116, 117, 116, 116, 116, 116, 116, 117, 117, 116,
117, 116, 117, 116, 117, 117, 117, 117, 117, 116, 116, 116, 115, 116, 115, 115,
115, 116, 114, 114, 113, 112, 112, 112, 112, 110, 110, 109, 108, 107, 107, 108,
106, 106, 105, 103, 102, 101, 101, 99, 99, 98, 98, 96, 97, 95, 94, 93, 92, 91,
89, 88, 88, 86, 85, 83, 82, 81, 79, 77, 76, 75, 73, 71, 70, 68, 67, 67, 66, 65,
64, 62, 60, 58, 57, 56, 54, 54, 52, 51, 50, 48, 46, 45, 43, 42, 41, 39, 36, 35,
33, 31, 30, 29, 28, 26, 25, 23, 21, 19, 18, 16, 15, 14, 12, 11, 10, 10, 9, 8, 7,
3, 3, 1, 0, -2, -3, -4, -4, -6, -7, -8, -10, -9, -12, -12, -13, -15, -15, -17,
-17, -19, -20, -22, -24, -26, -27, -29, -30, -30, -31, -32, -33, -35, -36, -37,
-38, -40, -41, -42, -43, -44, -45, -46, -47, -49, -50, -51, -51, -52, -54, -54,
-56, -56, -57, -58, -58, -60, -61, -63, -63, -65, -65, -67, -68, -69, -70, -70,
-71, -73, -73, -75, -75, -76, -77, -77, -77, -79, -81, -80, -82, -83, -84, -85,
-87, -87, -87, -87, -88, -88, -90, -91, -92, -93, -93, -93, -94, -94, -94, -95,
-96, -97, -98, -98, -99, -100, -100, -101, -102, -104, -104, -106, -107, -106,
-107, -107, -107, -108, -110, -110, -111, -110, -111, -110, -110, -111, -111,
-112, -113, -114, -115, -115, -114, -114, -114, -114, -115, -115, -116, -115,
-116, -115, -117, -118, -118, -118, -118, -117, -117, -118, -117, -118, -119,
-120, -119, -119, -119, -118, -118, -117, -118, -117, -118, -117, -117, -118,
-116, -116, -116, -115, -113, -113, -112, -111, -112, -110, -109, -110, -110,
-108, -107, -106, -107, -106, -104, -103, -102, -102, -101, -101, -100, -99,
-97, -96, -93, -92, -90, -90, -88, -87, -87, -86, -85, -83, -81, -80, -77, -77,
-76, -75, -73, -72, -70, -69, -67, -65, -64, -63, -61, -61, -59, -58, -55, -53,
-52, -50, -49, -47, -47, -45, -44, -42, -41, -38, -37, -35, -35, -33, -32, -31,
-29, -28, -27, -25, -24, -21, -19, -17, -15, -14, -12, -10, -10, -8, -8, -7, -6,
-6, -3, -3, 0, };