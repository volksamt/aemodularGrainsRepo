#define DATA_LENGTH 512
#define DATA AKWF_clarinett_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 8, 10, 12, 14, 17, 20, 22,
24, 27, 29, 31, 34, 36, 38, 41, 44, 47, 50, 51, 54, 54, 55, 56, 57, 58, 61, 61,
63, 64, 65, 67, 67, 68, 69, 70, 71, 72, 73, 74, 76, 76, 78, 79, 80, 82, 84, 86,
89, 90, 92, 94, 97, 99, 101, 103, 106, 108, 109, 109, 112, 114, 116, 116, 118,
119, 119, 118, 119, 119, 118, 118, 117, 116, 116, 114, 111, 110, 108, 105, 102,
100, 96, 94, 90, 87, 84, 80, 77, 73, 69, 65, 60, 54, 50, 46, 42, 39, 35, 31, 27,
23, 19, 15, 10, 8, 3, -1, -5, -9, -12, -17, -21, -25, -28, -31, -35, -38, -41,
-44, -48, -51, -53, -56, -58, -61, -63, -65, -67, -67, -69, -70, -71, -71, -71,
-71, -71, -70, -70, -68, -67, -65, -64, -62, -61, -59, -58, -57, -55, -52, -51,
-48, -47, -44, -42, -40, -39, -37, -35, -32, -30, -29, -26, -26, -24, -22, -21,
-18, -16, -14, -12, -10, -7, -4, -3, 0, 2, 4, 6, 7, 8, 10, 11, 14, 14, 16, 17,
18, 18, 19, 19, 19, 20, 20, 21, 22, 21, 22, 22, 23, 22, 22, 22, 22, 22, 20, 21,
20, 20, 21, 20, 20, 20, 20, 19, 20, 19, 19, 19, 19, 19, 18, 19, 18, 18, 19, 19,
18, 19, 19, 19, 20, 20, 20, 21, 21, 20, 20, 18, 18, 17, 16, 16, 15, 13, 11, 10,
9, 6, 5, 3, 1, -1, -3, -6, -6, -8, -11, -12, -14, -17, -18, -20, -22, -24, -25,
-26, -29, -30, -32, -34, -35, -37, -37, -39, -41, -41, -44, -45, -47, -48, -50,
-52, -53, -56, -57, -58, -60, -61, -62, -63, -66, -68, -69, -72, -74, -76, -78,
-79, -81, -83, -84, -85, -88, -89, -92, -94, -95, -97, -99, -100, -102, -102,
-104, -106, -108, -108, -109, -111, -111, -111, -112, -112, -113, -113, -115,
-114, -114, -115, -114, -114, -112, -113, -112, -110, -109, -108, -107, -106,
-103, -101, -99, -95, -93, -89, -87, -83, -79, -76, -72, -68, -63, -59, -54,
-50, -44, -40, -35, -29, -24, -19, -14, -8, -4, 1, 6, 10, 15, 20, 24, 28, 32,
36, 40, 43, 46, 50, 52, 56, 58, 60, 61, 64, 65, 67, 68, 70, 71, 72, 72, 73, 73,
73, 73, 74, 73, 73, 73, 73, 72, 72, 70, 69, 68, 66, 64, 64, 62, 61, 59, 56, 54,
51, 49, 46, 45, 42, 40, 37, 35, 32, 29, 26, 23, 20, 17, 14, 12, 9, 7, 5, 3, 2,
-2, -3, -6, -7, -10, -12, -12, -14, -15, -16, -16, -18, -20, -19, -21, -21, -23,
-22, -23, -23, -24, -23, -24, -24, -25, -25, -27, -27, -27, -27, -28, -28, -29,
-28, -29, -29, -29, -30, -30, -29, -28, -28, -29, -28, -29, -30, -29, -28, -27,
-27, -27, -25, -26, -24, -23, -22, -22, -20, -19, -19, -17, -17, -17, -16, -15,
-15, -13, -12, -11, -9, -8, -7, -5, -3, -3, -1, };