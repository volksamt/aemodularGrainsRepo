#define DATA_LENGTH 512
#define DATA AKWF_clarinett_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 1, 1, 1, 0, 1, 2, 3, 4, 4, 6,
7, 7, 8, 8, 8, 8, 8, 8, 9, 9, 11, 12, 13, 13, 14, 16, 17, 19, 19, 21, 22, 23,
23, 24, 26, 28, 29, 31, 33, 35, 36, 39, 40, 43, 45, 48, 49, 51, 52, 54, 56, 60,
62, 64, 67, 69, 72, 74, 75, 77, 78, 80, 81, 85, 87, 89, 91, 94, 95, 97, 98, 99,
101, 101, 103, 105, 106, 107, 109, 110, 111, 112, 113, 114, 114, 115, 114, 114,
114, 114, 114, 114, 112, 113, 112, 112, 111, 111, 111, 110, 110, 110, 108, 109,
108, 106, 107, 107, 105, 103, 103, 103, 102, 101, 100, 99, 99, 98, 97, 97, 97,
96, 95, 94, 94, 94, 94, 95, 95, 95, 94, 96, 95, 95, 94, 95, 94, 95, 95, 95, 96,
97, 99, 100, 100, 100, 102, 102, 102, 102, 103, 104, 104, 104, 104, 106, 106,
107, 109, 109, 109, 109, 110, 109, 109, 108, 107, 107, 105, 104, 103, 103, 102,
100, 99, 98, 97, 96, 93, 91, 88, 85, 83, 80, 77, 74, 71, 68, 66, 62, 58, 55, 52,
49, 45, 42, 39, 36, 34, 31, 27, 25, 21, 18, 15, 12, 9, 8, 5, 2, 1, 0, -2, -3,
-3, -4, -4, -6, -6, -7, -9, -11, -11, -13, -13, -12, -11, -11, -9, -9, -8, -7,
-6, -5, -4, -3, -2, -1, -1, 0, 1, 0, 2, 3, 4, 4, 5, 4, 4, 3, 3, 1, 1, 1, -1, -1,
-1, -3, -3, -5, -7, -9, -11, -13, -16, -19, -23, -26, -29, -32, -35, -36, -39,
-42, -44, -47, -50, -53, -57, -61, -63, -67, -70, -72, -75, -78, -81, -83, -86,
-90, -92, -94, -97, -99, -101, -104, -105, -108, -110, -110, -113, -114, -115,
-116, -118, -118, -119, -119, -119, -119, -120, -119, -117, -116, -116, -114,
-113, -111, -109, -107, -106, -104, -102, -100, -98, -96, -95, -93, -91, -90,
-87, -86, -84, -82, -81, -79, -76, -74, -73, -70, -68, -66, -65, -64, -62, -61,
-60, -58, -58, -57, -56, -56, -55, -55, -54, -54, -54, -54, -56, -56, -57, -58,
-58, -59, -60, -61, -62, -64, -66, -67, -69, -71, -72, -75, -77, -80, -82, -84,
-86, -88, -90, -91, -93, -94, -97, -97, -99, -101, -102, -104, -105, -106, -107,
-108, -110, -111, -110, -111, -111, -111, -111, -110, -110, -109, -107, -107,
-104, -104, -102, -100, -98, -96, -94, -92, -90, -88, -85, -83, -80, -79, -77,
-75, -72, -71, -68, -66, -62, -60, -57, -55, -52, -49, -48, -47, -44, -43, -41,
-39, -37, -35, -32, -31, -29, -27, -25, -24, -23, -21, -20, -20, -19, -18, -18,
-18, -17, -17, -16, -16, -15, -14, -15, -15, -15, -16, -15, -16, -16, -15, -16,
-16, -16, -16, -15, -15, -14, -14, -14, -14, -13, -15, -15, -14, -15, -15, -14,
-14, -13, -12, -11, -11, -10, -9, -9, -8, -6, -6, -5, -5, -4, -4, -4, -3, -3,
-3, -2, -1, -1, -1, -1, };