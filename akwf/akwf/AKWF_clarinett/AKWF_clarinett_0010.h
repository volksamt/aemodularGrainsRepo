#define DATA_LENGTH 512
#define DATA AKWF_clarinett_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 7, 9, 12, 14, 16, 19, 22, 23,
26, 27, 29, 31, 34, 35, 38, 40, 41, 43, 46, 48, 49, 51, 53, 54, 55, 58, 59, 60,
62, 62, 64, 65, 66, 68, 70, 71, 72, 72, 74, 74, 76, 77, 77, 79, 80, 81, 83, 84,
85, 86, 87, 89, 90, 90, 90, 92, 92, 94, 94, 95, 96, 97, 98, 99, 100, 100, 101,
102, 102, 104, 104, 105, 106, 107, 107, 108, 109, 110, 111, 112, 111, 112, 113,
114, 114, 116, 115, 117, 117, 118, 118, 118, 119, 120, 119, 120, 119, 119, 119,
120, 119, 119, 119, 119, 118, 119, 118, 118, 118, 117, 116, 115, 115, 114, 115,
113, 112, 111, 111, 111, 108, 108, 108, 107, 106, 105, 104, 104, 103, 103, 102,
100, 100, 99, 99, 98, 96, 97, 95, 95, 94, 93, 93, 92, 91, 90, 90, 88, 88, 87,
87, 86, 86, 85, 84, 83, 84, 83, 82, 82, 82, 81, 80, 80, 79, 80, 78, 78, 78, 78,
77, 76, 77, 75, 75, 75, 74, 73, 74, 73, 72, 73, 72, 71, 71, 70, 69, 69, 68, 67,
67, 66, 65, 64, 64, 63, 62, 62, 61, 61, 59, 59, 59, 58, 57, 56, 56, 55, 54, 53,
51, 51, 51, 48, 48, 47, 46, 45, 43, 42, 41, 40, 38, 37, 36, 35, 33, 32, 31, 29,
27, 26, 25, 24, 22, 21, 19, 18, 17, 15, 13, 13, 11, 9, 8, 6, 4, 2, 0, 0, -3, -5,
-6, -7, -8, -10, -12, -14, -14, -16, -16, -17, -19, -21, -22, -23, -23, -26,
-27, -28, -30, -31, -32, -33, -34, -35, -36, -38, -38, -40, -41, -42, -44, -44,
-47, -47, -48, -49, -50, -52, -53, -54, -55, -56, -58, -58, -59, -60, -61, -62,
-63, -64, -65, -67, -68, -69, -71, -72, -73, -74, -75, -77, -77, -79, -80, -82,
-82, -84, -85, -86, -87, -87, -87, -89, -90, -91, -92, -93, -93, -95, -95, -97,
-97, -98, -99, -99, -100, -100, -101, -101, -102, -102, -103, -104, -103, -104,
-105, -104, -104, -105, -105, -105, -106, -105, -105, -106, -106, -106, -105,
-106, -105, -105, -105, -105, -104, -105, -104, -104, -105, -104, -105, -103,
-103, -103, -102, -102, -102, -101, -100, -100, -99, -100, -100, -99, -98, -99,
-97, -97, -97, -96, -96, -96, -96, -94, -94, -94, -93, -93, -92, -91, -91, -91,
-91, -91, -90, -91, -89, -90, -90, -89, -89, -89, -88, -87, -88, -87, -88, -88,
-88, -87, -87, -87, -87, -88, -88, -88, -88, -88, -88, -88, -87, -88, -87, -88,
-87, -87, -88, -87, -89, -88, -88, -87, -87, -87, -88, -87, -87, -86, -86, -85,
-85, -85, -84, -83, -83, -82, -82, -81, -81, -80, -79, -79, -78, -77, -77, -75,
-75, -74, -73, -71, -70, -69, -68, -66, -64, -63, -62, -59, -58, -56, -55, -53,
-51, -51, -49, -47, -46, -44, -42, -40, -39, -37, -35, -33, -32, -29, -27, -25,
-22, -20, -17, -16, -14, -12, -9, -8, -5, -3, 0, };