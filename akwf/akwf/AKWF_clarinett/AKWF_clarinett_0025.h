#define DATA_LENGTH 512
#define DATA AKWF_clarinett_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 8, 10, 13, 15, 18, 21, 24,
27, 31, 32, 35, 38, 40, 43, 45, 47, 50, 52, 55, 57, 58, 60, 62, 64, 65, 67, 68,
70, 72, 74, 75, 78, 78, 81, 82, 84, 85, 87, 89, 89, 90, 90, 92, 92, 94, 94, 95,
96, 97, 97, 99, 100, 100, 100, 100, 100, 100, 100, 100, 100, 100, 101, 100, 100,
100, 99, 98, 98, 96, 95, 93, 92, 90, 89, 86, 85, 83, 80, 78, 74, 72, 68, 65, 61,
58, 55, 52, 48, 46, 43, 40, 37, 35, 32, 29, 27, 23, 19, 16, 13, 10, 6, 5, 2, -1,
-3, -5, -8, -10, -13, -16, -18, -20, -22, -25, -27, -29, -31, -33, -34, -37,
-39, -41, -43, -44, -44, -46, -47, -47, -48, -49, -50, -51, -51, -51, -52, -53,
-54, -55, -55, -55, -55, -55, -55, -56, -55, -56, -56, -56, -57, -58, -58, -57,
-57, -57, -56, -56, -55, -55, -54, -52, -51, -51, -48, -47, -46, -45, -44, -42,
-41, -38, -36, -36, -33, -31, -30, -28, -24, -23, -19, -17, -14, -12, -9, -6,
-5, -3, 0, 2, 5, 8, 10, 12, 14, 18, 19, 23, 24, 27, 28, 30, 32, 34, 36, 38, 38,
40, 41, 42, 43, 43, 44, 44, 45, 46, 46, 46, 47, 46, 46, 45, 45, 45, 44, 44, 44,
43, 43, 42, 42, 41, 41, 39, 39, 38, 36, 36, 34, 34, 33, 32, 31, 30, 30, 28, 26,
25, 22, 21, 18, 15, 14, 11, 9, 7, 5, 2, 0, -4, -6, -9, -13, -15, -18, -22, -25,
-28, -31, -35, -38, -42, -46, -49, -52, -56, -59, -63, -66, -70, -71, -75, -78,
-81, -84, -87, -88, -91, -95, -97, -99, -101, -104, -105, -108, -109, -110,
-112, -113, -114, -115, -117, -117, -117, -118, -119, -119, -119, -119, -118,
-119, -118, -117, -117, -115, -114, -113, -111, -110, -109, -107, -106, -103,
-102, -100, -97, -95, -92, -88, -86, -83, -80, -76, -73, -70, -67, -64, -60,
-57, -53, -50, -46, -42, -38, -35, -32, -27, -24, -21, -19, -15, -11, -9, -6,
-2, 1, 4, 7, 10, 13, 15, 17, 20, 22, 24, 26, 27, 29, 31, 32, 34, 35, 37, 38, 39,
40, 41, 43, 43, 44, 45, 46, 46, 47, 47, 48, 48, 49, 48, 49, 51, 51, 51, 51, 52,
52, 51, 52, 52, 52, 51, 51, 50, 51, 50, 50, 50, 49, 48, 48, 48, 46, 45, 44, 43,
41, 40, 38, 38, 36, 34, 33, 32, 30, 28, 27, 27, 25, 22, 21, 19, 18, 17, 14, 12,
11, 9, 7, 5, 3, 0, -2, -3, -4, -7, -9, -10, -13, -13, -14, -17, -17, -19, -21,
-21, -23, -24, -26, -28, -29, -29, -30, -30, -32, -33, -34, -35, -36, -37, -37,
-36, -37, -36, -37, -36, -37, -37, -37, -37, -37, -37, -37, -36, -35, -35, -34,
-33, -34, -33, -32, -30, -30, -28, -27, -25, -24, -23, -22, -21, -19, -18, -15,
-14, -13, -11, -9, -7, -5, -2, 0, };