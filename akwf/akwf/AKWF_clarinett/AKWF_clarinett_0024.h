#define DATA_LENGTH 512
#define DATA AKWF_clarinett_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 11, 13, 15, 17, 18, 20, 21,
21, 21, 21, 22, 22, 22, 22, 22, 21, 22, 21, 21, 21, 20, 20, 19, 20, 20, 20, 21,
20, 21, 23, 24, 24, 26, 26, 29, 29, 32, 34, 37, 39, 42, 45, 49, 52, 56, 60, 62,
66, 69, 73, 78, 81, 87, 90, 94, 97, 101, 105, 107, 108, 109, 111, 113, 115, 117,
118, 119, 120, 119, 118, 119, 118, 117, 117, 116, 113, 111, 109, 106, 104, 102,
99, 98, 96, 95, 93, 92, 92, 90, 90, 89, 87, 85, 84, 82, 81, 80, 80, 80, 81, 81,
82, 81, 82, 82, 82, 82, 83, 82, 82, 81, 82, 82, 83, 84, 85, 85, 84, 85, 84, 83,
83, 82, 81, 81, 81, 80, 80, 80, 81, 79, 79, 78, 77, 78, 77, 76, 75, 74, 73, 71,
70, 68, 65, 62, 59, 57, 54, 51, 48, 45, 43, 39, 35, 32, 29, 27, 24, 21, 18, 15,
12, 8, 4, 2, 1, -3, -3, -5, -7, -7, -8, -9, -9, -10, -11, -11, -10, -8, -8, -6,
-4, -2, 0, 2, 7, 12, 16, 20, 24, 29, 32, 37, 42, 47, 52, 57, 61, 65, 68, 70, 74,
77, 80, 83, 85, 88, 91, 92, 93, 93, 93, 92, 90, 89, 88, 86, 85, 85, 83, 82, 81,
80, 77, 74, 71, 67, 64, 60, 57, 53, 50, 48, 48, 45, 44, 43, 41, 38, 37, 35, 34,
31, 31, 28, 27, 25, 23, 21, 20, 18, 17, 16, 15, 14, 13, 13, 12, 11, 9, 7, 5, 4,
3, 2, 0, -1, -3, -4, -6, -7, -8, -11, -13, -17, -19, -22, -26, -28, -32, -36,
-39, -42, -45, -48, -50, -54, -56, -59, -62, -65, -67, -71, -73, -76, -78, -80,
-81, -85, -86, -88, -89, -92, -93, -94, -95, -97, -98, -99, -99, -99, -99, -99,
-98, -98, -98, -98, -97, -97, -98, -97, -96, -96, -95, -95, -94, -94, -93, -93,
-92, -91, -92, -91, -89, -89, -88, -86, -85, -85, -83, -83, -83, -82, -82, -81,
-81, -81, -81, -81, -80, -81, -82, -82, -84, -85, -86, -86, -88, -89, -90, -90,
-92, -93, -94, -94, -95, -95, -96, -95, -95, -96, -96, -96, -97, -97, -99, -100,
-100, -101, -102, -101, -101, -100, -99, -97, -96, -94, -93, -92, -90, -88, -87,
-83, -80, -77, -74, -71, -67, -64, -61, -57, -54, -51, -46, -43, -39, -36, -32,
-28, -24, -22, -19, -16, -13, -11, -8, -6, -5, -4, -4, -3, -2, -3, -2, -2, -2,
-2, -3, -5, -6, -8, -10, -11, -11, -13, -14, -15, -16, -18, -19, -21, -24, -27,
-30, -32, -35, -37, -39, -40, -42, -44, -46, -48, -50, -51, -53, -56, -57, -59,
-59, -61, -63, -63, -64, -65, -66, -67, -65, -65, -65, -64, -65, -64, -64, -64,
-65, -65, -64, -64, -64, -63, -62, -61, -60, -60, -57, -58, -57, -56, -54, -53,
-51, -50, -47, -44, -42, -38, -36, -32, -29, -26, -22, -20, -15, -13, -9, -6,
-4, -1, };