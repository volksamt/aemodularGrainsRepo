#define DATA_LENGTH 512
#define DATA AKWF_clarinett_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 5, 7, 8, 10, 11, 13, 15, 16,
18, 20, 21, 22, 23, 24, 26, 27, 27, 29, 30, 30, 31, 31, 31, 31, 32, 32, 30, 30,
29, 28, 28, 27, 27, 26, 25, 24, 24, 23, 24, 24, 24, 25, 26, 27, 28, 29, 31, 34,
35, 36, 40, 42, 45, 46, 50, 52, 55, 58, 60, 64, 66, 69, 72, 74, 77, 78, 80, 82,
85, 87, 89, 91, 92, 93, 95, 97, 99, 101, 103, 104, 106, 107, 109, 111, 112, 113,
114, 115, 115, 117, 117, 118, 119, 119, 119, 118, 118, 116, 115, 113, 112, 110,
108, 106, 102, 99, 97, 94, 91, 88, 85, 83, 80, 78, 75, 73, 71, 68, 66, 65, 62,
59, 58, 56, 52, 51, 50, 47, 46, 45, 43, 42, 39, 37, 35, 34, 31, 29, 27, 25, 23,
20, 18, 15, 12, 9, 7, 5, 3, 1, -2, -4, -6, -7, -9, -11, -12, -14, -14, -15, -15,
-16, -17, -19, -19, -19, -20, -20, -21, -22, -21, -22, -22, -22, -22, -22, -22,
-22, -22, -21, -21, -20, -20, -19, -19, -19, -18, -17, -16, -15, -14, -13, -12,
-11, -10, -8, -6, -5, -4, -2, 0, 0, 2, 3, 4, 7, 7, 9, 10, 11, 11, 12, 12, 13,
12, 12, 11, 11, 11, 10, 10, 9, 8, 8, 6, 6, 6, 6, 7, 7, 6, 6, 6, 7, 7, 8, 8, 6,
7, 7, 7, 6, 7, 6, 6, 5, 6, 5, 3, 2, 1, 0, -1, -3, -4, -5, -8, -9, -11, -13, -14,
-15, -17, -18, -20, -20, -23, -24, -25, -26, -27, -28, -30, -29, -31, -32, -31,
-32, -33, -34, -34, -34, -35, -36, -36, -36, -37, -38, -39, -40, -40, -41, -40,
-41, -42, -43, -43, -43, -43, -44, -44, -44, -45, -45, -45, -45, -46, -46, -46,
-46, -47, -47, -48, -49, -50, -51, -54, -55, -57, -59, -61, -63, -64, -68, -69,
-72, -74, -77, -78, -82, -83, -86, -87, -88, -91, -92, -94, -95, -96, -97, -99,
-99, -100, -101, -100, -101, -101, -102, -102, -102, -103, -103, -103, -103,
-103, -103, -104, -104, -104, -104, -103, -105, -105, -104, -103, -103, -103,
-103, -102, -101, -100, -99, -97, -95, -94, -93, -91, -89, -87, -85, -83, -80,
-77, -75, -71, -69, -67, -64, -62, -58, -55, -52, -49, -46, -44, -40, -37, -34,
-31, -27, -23, -20, -16, -14, -10, -7, -5, -1, 1, 3, 7, 10, 13, 17, 18, 21, 25,
26, 29, 31, 34, 35, 37, 39, 39, 40, 41, 41, 43, 43, 44, 44, 43, 44, 44, 43, 43,
43, 41, 41, 39, 38, 37, 36, 35, 33, 31, 30, 28, 27, 25, 23, 22, 21, 18, 18, 16,
14, 12, 11, 10, 9, 8, 5, 4, 2, 1, 1, -1, -3, -4, -6, -6, -8, -10, -10, -12, -13,
-14, -15, -17, -18, -18, -19, -20, -21, -20, -21, -21, -21, -20, -20, -20, -19,
-18, -18, -17, -16, -15, -14, -13, -11, -10, -9, -7, -6, -4, -3, -1, };