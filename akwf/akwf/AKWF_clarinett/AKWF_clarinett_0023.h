#define DATA_LENGTH 512
#define DATA AKWF_clarinett_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 12, 14, 17, 20, 22, 25, 26,
29, 31, 33, 35, 38, 40, 41, 44, 44, 45, 46, 47, 48, 48, 50, 50, 52, 54, 55, 57,
60, 62, 64, 66, 69, 70, 72, 73, 75, 75, 76, 77, 78, 77, 79, 79, 79, 79, 80, 79,
78, 78, 77, 76, 76, 76, 74, 73, 70, 67, 65, 62, 59, 58, 55, 52, 50, 49, 46, 43,
41, 38, 36, 34, 33, 31, 31, 31, 31, 33, 32, 34, 32, 31, 29, 28, 28, 27, 27, 26,
25, 26, 27, 28, 28, 29, 28, 29, 27, 27, 25, 24, 24, 23, 23, 23, 23, 21, 21, 20,
18, 17, 17, 16, 15, 16, 16, 16, 18, 20, 23, 25, 27, 29, 31, 34, 38, 41, 44, 49,
54, 57, 62, 66, 71, 74, 79, 83, 86, 89, 93, 95, 98, 100, 101, 103, 105, 106,
107, 107, 106, 106, 105, 104, 103, 102, 102, 101, 100, 97, 96, 93, 90, 89, 87,
85, 83, 84, 83, 83, 83, 82, 83, 82, 81, 81, 82, 83, 85, 87, 87, 87, 88, 89, 91,
91, 91, 92, 93, 92, 94, 93, 94, 93, 93, 92, 91, 90, 88, 87, 87, 86, 84, 83, 82,
79, 76, 74, 74, 72, 72, 70, 70, 68, 67, 67, 66, 67, 66, 65, 64, 64, 64, 63, 63,
64, 64, 64, 64, 63, 62, 62, 61, 61, 61, 60, 60, 59, 58, 58, 56, 55, 54, 52, 50,
48, 45, 43, 40, 38, 36, 33, 31, 26, 23, 19, 15, 12, 9, 6, 2, -1, -5, -11, -15,
-19, -23, -27, -31, -34, -39, -41, -45, -47, -49, -52, -54, -57, -59, -61, -64,
-66, -67, -69, -70, -71, -72, -72, -72, -74, -75, -76, -77, -77, -77, -78, -79,
-79, -79, -79, -80, -81, -82, -82, -83, -83, -84, -84, -84, -85, -84, -84, -83,
-83, -82, -82, -80, -79, -78, -76, -75, -72, -70, -67, -65, -62, -59, -57, -53,
-51, -47, -45, -43, -39, -37, -33, -30, -28, -25, -22, -20, -18, -15, -13, -11,
-9, -8, -6, -4, -3, -2, -2, -1, -1, -1, -1, -1, -2, -3, -4, -6, -7, -8, -8, -9,
-9, -12, -16, -20, -23, -27, -29, -33, -36, -38, -41, -44, -46, -48, -51, -53,
-56, -56, -59, -60, -62, -63, -63, -64, -65, -65, -66, -66, -68, -68, -69, -70,
-71, -73, -74, -74, -76, -77, -78, -79, -80, -81, -82, -85, -87, -89, -90, -92,
-94, -96, -98, -98, -100, -102, -103, -106, -108, -111, -112, -114, -115, -116,
-117, -118, -118, -119, -120, -118, -119, -119, -119, -118, -117, -116, -115,
-114, -114, -113, -112, -110, -109, -107, -105, -105, -103, -101, -99, -97, -94,
-92, -90, -87, -85, -84, -80, -78, -76, -74, -70, -69, -68, -65, -64, -63, -62,
-60, -60, -58, -57, -55, -53, -53, -53, -53, -52, -52, -52, -52, -52, -50, -51,
-51, -49, -49, -49, -48, -47, -45, -44, -42, -42, -40, -37, -36, -33, -31, -30,
-27, -24, -21, -19, -16, -14, -11, -8, -4, -2, };