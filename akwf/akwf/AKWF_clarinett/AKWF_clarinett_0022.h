#define DATA_LENGTH 512
#define DATA AKWF_clarinett_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 5, 6, 7, 9, 11, 13, 13, 14, 17,
18, 20, 21, 22, 23, 24, 27, 29, 30, 32, 34, 35, 38, 40, 41, 43, 46, 47, 48, 50,
53, 54, 56, 58, 60, 61, 62, 63, 65, 65, 67, 67, 68, 67, 69, 68, 69, 69, 69, 70,
72, 72, 72, 74, 75, 76, 78, 79, 81, 81, 83, 85, 87, 89, 90, 93, 93, 95, 97, 99,
101, 102, 105, 106, 109, 111, 112, 113, 114, 115, 116, 118, 119, 119, 119, 120,
120, 120, 119, 119, 117, 117, 115, 114, 112, 109, 106, 104, 102, 99, 96, 94, 91,
87, 84, 80, 77, 72, 68, 64, 59, 56, 51, 47, 42, 37, 33, 28, 24, 21, 15, 11, 6,
1, -4, -8, -13, -17, -22, -26, -29, -35, -39, -44, -49, -51, -55, -59, -62, -66,
-70, -74, -77, -79, -81, -83, -86, -87, -89, -90, -91, -92, -93, -92, -93, -92,
-92, -91, -89, -87, -86, -84, -81, -79, -77, -74, -72, -70, -66, -64, -60, -58,
-56, -52, -48, -46, -42, -39, -37, -34, -31, -28, -26, -24, -20, -17, -13, -10,
-7, -5, -2, 1, 3, 6, 9, 12, 15, 17, 20, 22, 25, 26, 28, 30, 32, 35, 36, 38, 40,
41, 41, 42, 44, 44, 45, 47, 46, 47, 47, 46, 46, 46, 46, 45, 45, 43, 43, 43, 41,
40, 39, 37, 36, 33, 32, 30, 28, 26, 26, 22, 20, 18, 17, 15, 13, 11, 9, 8, 6, 4,
3, 1, 0, -2, -4, -4, -5, -7, -8, -10, -12, -13, -14, -15, -15, -17, -18, -20,
-21, -23, -25, -25, -27, -28, -29, -30, -32, -33, -36, -37, -39, -39, -42, -43,
-44, -46, -47, -48, -50, -51, -52, -54, -55, -56, -57, -59, -60, -61, -62, -63,
-65, -66, -68, -69, -70, -72, -73, -75, -75, -77, -78, -79, -80, -81, -83, -84,
-84, -85, -87, -88, -89, -89, -91, -92, -94, -94, -97, -97, -99, -100, -101,
-102, -104, -105, -107, -110, -111, -112, -114, -115, -115, -116, -116, -116,
-116, -116, -116, -115, -115, -114, -115, -113, -112, -111, -109, -106, -106,
-102, -100, -97, -94, -90, -87, -83, -78, -74, -70, -66, -61, -56, -51, -47,
-42, -37, -32, -27, -22, -17, -11, -7, -1, 4, 8, 12, 18, 22, 28, 33, 36, 40, 44,
49, 53, 56, 60, 64, 67, 71, 74, 76, 79, 81, 83, 85, 87, 89, 91, 93, 93, 94, 95,
95, 96, 96, 96, 95, 95, 94, 92, 91, 89, 86, 83, 82, 78, 76, 72, 69, 66, 64, 60,
57, 53, 48, 45, 42, 38, 34, 30, 27, 23, 20, 16, 12, 10, 7, 3, 1, -3, -5, -8,
-11, -13, -16, -19, -22, -24, -27, -29, -30, -32, -34, -36, -37, -39, -40, -41,
-42, -44, -45, -46, -46, -46, -47, -47, -48, -47, -49, -48, -49, -48, -48, -48,
-47, -46, -45, -44, -43, -41, -40, -37, -36, -34, -33, -31, -29, -27, -25, -24,
-21, -20, -18, -16, -13, -12, -9, -6, -5, -3, -2, 1, };