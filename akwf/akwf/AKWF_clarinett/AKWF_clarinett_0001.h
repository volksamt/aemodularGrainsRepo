#define DATA_LENGTH 512
#define DATA AKWF_clarinett_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 2, 3, 5, 6, 8, 10, 11, 12, 13, 15,
16, 17, 19, 20, 22, 23, 24, 24, 24, 26, 26, 28, 28, 29, 28, 27, 28, 27, 26, 24,
23, 23, 22, 20, 19, 17, 16, 16, 14, 14, 14, 15, 14, 14, 15, 16, 17, 18, 20, 22,
24, 26, 29, 30, 33, 36, 38, 40, 43, 47, 50, 52, 55, 57, 60, 62, 65, 68, 70, 73,
75, 76, 79, 80, 82, 83, 86, 88, 90, 92, 94, 96, 98, 99, 102, 103, 105, 107, 109,
111, 112, 114, 115, 116, 116, 118, 118, 119, 119, 118, 117, 115, 114, 112, 111,
109, 106, 103, 100, 97, 95, 92, 90, 86, 84, 81, 78, 75, 73, 71, 68, 65, 64, 62,
59, 57, 54, 53, 50, 48, 46, 44, 41, 39, 37, 35, 33, 31, 29, 27, 25, 23, 21, 19,
16, 14, 12, 9, 7, 5, 2, 0, -2, -4, -6, -7, -9, -11, -12, -14, -15, -17, -18,
-19, -19, -19, -21, -21, -21, -21, -22, -21, -21, -22, -23, -23, -25, -25, -25,
-25, -25, -26, -26, -27, -27, -27, -27, -27, -26, -25, -24, -24, -22, -21, -19,
-17, -15, -14, -14, -12, -10, -8, -6, -4, -2, 1, 3, 4, 7, 7, 10, 11, 12, 13, 15,
14, 15, 15, 17, 16, 16, 16, 15, 15, 14, 15, 13, 13, 12, 11, 10, 10, 10, 9, 8, 9,
8, 7, 6, 6, 6, 6, 6, 5, 5, 6, 5, 4, 4, 3, 2, 1, 0, -2, -3, -5, -6, -7, -8, -10,
-11, -12, -13, -15, -16, -18, -18, -18, -19, -19, -20, -20, -21, -22, -21, -21,
-22, -23, -22, -23, -24, -24, -24, -23, -23, -25, -27, -26, -28, -28, -29, -28,
-29, -30, -31, -32, -33, -32, -34, -33, -33, -33, -34, -35, -35, -36, -37, -37,
-37, -37, -38, -38, -38, -39, -41, -41, -42, -43, -45, -46, -48, -51, -52, -54,
-56, -59, -60, -63, -65, -68, -70, -72, -75, -77, -79, -81, -82, -84, -85, -87,
-89, -89, -91, -92, -92, -92, -93, -94, -94, -95, -96, -97, -98, -98, -98, -99,
-99, -99, -99, -99, -100, -100, -100, -102, -102, -102, -101, -101, -101, -100,
-100, -99, -99, -97, -96, -94, -95, -93, -91, -90, -89, -87, -85, -83, -81, -79,
-77, -74, -72, -70, -67, -65, -62, -59, -56, -52, -48, -46, -43, -39, -37, -33,
-30, -26, -23, -19, -16, -13, -10, -6, -2, 0, 4, 8, 11, 14, 17, 20, 24, 27, 30,
32, 34, 37, 39, 41, 42, 44, 45, 47, 49, 48, 50, 49, 50, 50, 50, 51, 51, 50, 50,
49, 47, 46, 44, 43, 41, 39, 37, 35, 34, 32, 29, 27, 24, 23, 20, 19, 17, 15, 14,
12, 10, 9, 8, 5, 4, 2, 0, -1, -2, -4, -4, -7, -8, -11, -12, -13, -15, -15, -16,
-17, -18, -19, -21, -21, -21, -22, -23, -22, -23, -23, -22, -23, -22, -21, -21,
-21, -20, -19, -17, -17, -15, -14, -12, -11, -9, -7, -6, -5, -1, };