#define DATA_LENGTH 512
#define DATA AKWF_clarinett_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 11, 13, 16, 19, 21, 24, 26,
29, 32, 35, 39, 42, 46, 50, 52, 56, 58, 61, 65, 67, 70, 72, 75, 78, 81, 83, 87,
89, 90, 92, 94, 97, 99, 101, 102, 104, 107, 108, 112, 113, 114, 115, 116, 117,
117, 118, 119, 119, 120, 119, 119, 119, 118, 117, 117, 116, 116, 115, 115, 114,
113, 112, 110, 109, 108, 107, 105, 104, 103, 102, 101, 101, 99, 98, 97, 96, 97,
95, 95, 94, 93, 92, 91, 90, 88, 87, 86, 84, 83, 83, 81, 81, 80, 79, 79, 78, 77,
76, 75, 73, 72, 70, 71, 69, 67, 66, 65, 65, 64, 63, 63, 62, 60, 60, 59, 58, 57,
56, 55, 53, 51, 50, 49, 48, 46, 45, 45, 44, 44, 44, 43, 43, 42, 41, 42, 41, 41,
40, 39, 39, 37, 37, 37, 36, 36, 35, 36, 35, 33, 34, 33, 31, 30, 31, 31, 30, 29,
29, 28, 26, 26, 25, 24, 23, 22, 22, 20, 20, 18, 17, 16, 15, 15, 13, 13, 12, 11,
11, 10, 9, 9, 9, 10, 9, 9, 8, 9, 8, 8, 9, 8, 8, 9, 9, 9, 9, 9, 10, 9, 10, 11,
12, 11, 11, 11, 10, 10, 9, 7, 7, 6, 5, 4, 3, 2, 1, 1, 0, -2, -4, -6, -8, -11,
-13, -14, -16, -18, -19, -20, -22, -24, -26, -28, -31, -33, -34, -37, -39, -41,
-43, -44, -47, -47, -49, -51, -54, -55, -57, -59, -61, -62, -65, -66, -67, -69,
-70, -70, -72, -72, -73, -74, -75, -74, -74, -75, -75, -75, -76, -77, -77, -77,
-79, -79, -79, -79, -78, -78, -77, -76, -76, -77, -77, -76, -77, -77, -77, -77,
-77, -76, -75, -76, -75, -75, -74, -75, -74, -75, -73, -73, -72, -71, -71, -70,
-68, -68, -67, -66, -66, -65, -64, -63, -63, -61, -60, -59, -58, -57, -57, -56,
-54, -53, -53, -53, -51, -51, -52, -52, -51, -51, -52, -51, -52, -53, -53, -53,
-53, -54, -55, -56, -56, -57, -57, -58, -59, -59, -59, -61, -61, -61, -63, -64,
-64, -64, -65, -66, -65, -65, -66, -65, -65, -65, -64, -63, -62, -60, -59, -57,
-56, -55, -53, -53, -51, -51, -49, -47, -46, -44, -43, -41, -40, -38, -37, -35,
-34, -33, -33, -31, -30, -28, -27, -25, -24, -22, -20, -20, -18, -17, -15, -14,
-13, -13, -12, -11, -10, -9, -8, -7, -7, -6, -5, -4, -3, -3, -2, -2, -2, -2, -2,
-2, -2, -2, -3, -2, -3, -4, -4, -3, -4, -4, -4, -5, -6, -5, -5, -6, -7, -7, -8,
-9, -10, -11, -12, -14, -14, -16, -17, -18, -19, -20, -22, -23, -24, -25, -27,
-29, -30, -31, -31, -33, -33, -35, -35, -37, -37, -37, -38, -39, -40, -41, -41,
-41, -42, -42, -43, -42, -44, -43, -43, -42, -42, -41, -41, -42, -41, -39, -40,
-39, -37, -36, -35, -34, -33, -31, -29, -28, -26, -24, -24, -21, -20, -18, -16,
-16, -13, -11, -9, -6, -4, -1, };