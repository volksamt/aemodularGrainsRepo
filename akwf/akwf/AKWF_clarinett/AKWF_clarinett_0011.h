#define DATA_LENGTH 512
#define DATA AKWF_clarinett_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 5, 7, 8, 9, 12, 13, 14, 16,
18, 18, 21, 21, 24, 26, 27, 28, 30, 32, 34, 34, 36, 38, 39, 40, 42, 44, 46, 47,
48, 50, 52, 53, 55, 56, 58, 59, 61, 63, 63, 65, 66, 67, 69, 70, 71, 73, 74, 75,
78, 78, 80, 81, 82, 84, 85, 85, 87, 88, 89, 90, 91, 92, 94, 93, 95, 96, 97, 99,
99, 100, 100, 101, 102, 103, 104, 105, 105, 106, 106, 107, 108, 108, 110, 110,
110, 111, 112, 112, 112, 112, 113, 114, 115, 115, 115, 115, 115, 116, 116, 117,
117, 117, 117, 118, 118, 117, 118, 118, 118, 118, 118, 119, 118, 119, 119, 119,
119, 119, 119, 118, 117, 118, 117, 116, 117, 116, 116, 115, 115, 115, 114, 116,
114, 114, 114, 112, 112, 112, 111, 110, 109, 108, 107, 106, 105, 104, 103, 102,
101, 99, 99, 97, 95, 94, 93, 91, 90, 90, 88, 87, 85, 83, 82, 80, 79, 77, 76, 75,
73, 72, 70, 68, 67, 66, 63, 62, 60, 59, 56, 55, 52, 50, 48, 47, 45, 44, 42, 40,
38, 36, 35, 34, 32, 29, 28, 27, 25, 23, 22, 20, 19, 17, 17, 15, 13, 13, 10, 8,
7, 5, 4, 2, 0, -1, -2, -4, -5, -6, -6, -8, -8, -10, -10, -11, -13, -13, -14,
-16, -16, -17, -18, -18, -19, -20, -21, -21, -22, -24, -24, -24, -25, -26, -25,
-26, -27, -27, -28, -28, -28, -29, -29, -30, -30, -31, -31, -31, -32, -31, -32,
-32, -32, -31, -32, -31, -32, -32, -33, -33, -32, -33, -34, -34, -34, -34, -34,
-35, -35, -35, -36, -35, -35, -36, -36, -35, -36, -37, -36, -37, -38, -38, -39,
-38, -39, -40, -41, -41, -41, -41, -42, -43, -44, -44, -45, -44, -46, -47, -47,
-48, -49, -49, -51, -51, -51, -52, -53, -53, -54, -55, -55, -56, -57, -57, -59,
-60, -61, -62, -63, -64, -65, -66, -67, -67, -68, -69, -70, -71, -72, -73, -74,
-75, -76, -77, -77, -79, -79, -79, -81, -81, -82, -83, -84, -84, -85, -86, -86,
-86, -88, -88, -87, -87, -88, -89, -90, -90, -90, -91, -90, -90, -90, -91, -92,
-91, -92, -93, -93, -93, -92, -92, -92, -93, -92, -92, -93, -92, -92, -92, -92,
-91, -91, -91, -91, -90, -90, -89, -89, -90, -89, -88, -88, -87, -87, -87, -86,
-86, -85, -85, -84, -85, -84, -85, -84, -83, -83, -82, -82, -82, -82, -82, -81,
-80, -81, -80, -79, -78, -78, -78, -78, -77, -77, -75, -76, -75, -75, -74, -73,
-74, -73, -72, -71, -71, -71, -71, -70, -69, -68, -68, -69, -67, -68, -67, -66,
-65, -65, -64, -64, -63, -62, -62, -61, -59, -60, -58, -58, -58, -57, -56, -55,
-55, -53, -52, -51, -50, -49, -48, -47, -46, -44, -44, -41, -41, -40, -39, -37,
-36, -35, -34, -33, -32, -30, -29, -28, -26, -24, -23, -22, -20, -20, -17, -16,
-14, -13, -11, -10, -8, -6, -5, -4, -2, 0, };