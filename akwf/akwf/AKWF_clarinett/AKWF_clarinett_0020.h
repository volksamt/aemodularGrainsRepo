#define DATA_LENGTH 512
#define DATA AKWF_clarinett_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 7, 9, 11, 14, 17, 18, 21, 24,
26, 28, 30, 33, 35, 37, 40, 42, 45, 47, 50, 52, 54, 57, 58, 61, 62, 64, 65, 66,
67, 66, 67, 65, 64, 63, 61, 60, 58, 56, 53, 50, 48, 46, 43, 42, 40, 37, 36, 33,
32, 31, 30, 30, 31, 31, 31, 33, 33, 35, 36, 38, 41, 44, 46, 48, 51, 54, 58, 60,
64, 67, 71, 73, 75, 78, 80, 83, 85, 87, 88, 91, 92, 94, 95, 96, 97, 98, 99, 101,
102, 104, 107, 107, 109, 110, 111, 112, 112, 113, 114, 115, 117, 119, 119, 120,
119, 119, 118, 118, 117, 116, 114, 111, 110, 107, 104, 102, 98, 94, 90, 86, 81,
76, 72, 68, 65, 60, 56, 52, 48, 44, 39, 35, 30, 26, 22, 18, 14, 8, 3, 0, -5,
-10, -14, -19, -23, -26, -30, -31, -35, -37, -39, -42, -44, -45, -47, -49, -49,
-50, -50, -49, -49, -48, -47, -47, -47, -46, -46, -45, -43, -41, -40, -38, -35,
-33, -31, -27, -25, -23, -21, -18, -15, -11, -8, -5, -3, 0, 2, 3, 4, 5, 7, 7, 8,
8, 7, 7, 6, 5, 5, 4, 3, 4, 4, 4, 4, 6, 5, 5, 6, 7, 7, 9, 10, 12, 13, 15, 16, 17,
19, 19, 20, 21, 23, 24, 25, 25, 25, 25, 25, 25, 25, 24, 24, 24, 24, 23, 23, 21,
20, 19, 18, 16, 13, 12, 10, 8, 6, 3, 1, -1, -2, -5, -7, -8, -9, -11, -12, -13,
-15, -16, -17, -18, -19, -20, -21, -21, -21, -23, -24, -25, -27, -27, -29, -30,
-31, -31, -33, -34, -35, -37, -37, -38, -39, -40, -40, -41, -41, -43, -42, -42,
-43, -42, -43, -44, -46, -46, -47, -48, -48, -49, -49, -51, -52, -54, -56, -58,
-58, -60, -60, -61, -63, -64, -65, -67, -69, -70, -72, -72, -73, -73, -73, -72,
-72, -73, -73, -73, -74, -73, -74, -73, -72, -71, -71, -71, -70, -70, -69, -69,
-70, -70, -70, -71, -72, -72, -74, -75, -75, -75, -77, -78, -79, -80, -81, -83,
-85, -85, -87, -87, -89, -89, -90, -92, -93, -93, -93, -93, -94, -93, -93, -92,
-92, -92, -90, -90, -88, -88, -87, -86, -85, -84, -82, -80, -79, -77, -74, -71,
-70, -66, -66, -63, -61, -59, -56, -53, -49, -47, -45, -42, -38, -34, -30, -27,
-22, -18, -15, -11, -7, -2, 2, 7, 10, 15, 17, 22, 25, 29, 33, 37, 40, 43, 47,
50, 53, 56, 58, 59, 60, 61, 62, 64, 64, 66, 66, 66, 66, 65, 65, 62, 60, 59, 58,
55, 53, 51, 49, 45, 42, 38, 36, 32, 29, 26, 23, 21, 18, 15, 11, 8, 5, 1, -1, -3,
-5, -7, -9, -11, -15, -17, -20, -22, -24, -27, -28, -30, -33, -36, -37, -38,
-40, -41, -44, -44, -46, -47, -48, -49, -50, -50, -50, -49, -50, -49, -47, -47,
-45, -44, -43, -40, -38, -36, -32, -28, -24, -21, -19, -15, -13, -9, -6, -1, };