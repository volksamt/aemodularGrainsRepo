#define DATA_LENGTH 512
#define DATA AKWF_clarinett_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 6, 9, 12, 14, 15, 18, 21, 22,
23, 25, 28, 30, 31, 33, 35, 37, 39, 41, 43, 46, 48, 51, 52, 54, 56, 57, 60, 61,
62, 64, 66, 67, 68, 70, 71, 72, 74, 76, 77, 80, 81, 83, 86, 87, 89, 90, 92, 93,
96, 97, 98, 99, 101, 100, 102, 103, 104, 106, 106, 108, 109, 110, 111, 113, 113,
115, 115, 116, 118, 117, 118, 118, 118, 116, 116, 116, 115, 114, 113, 113, 112,
111, 109, 108, 106, 105, 104, 102, 100, 98, 98, 95, 94, 91, 89, 87, 84, 82, 79,
77, 73, 71, 69, 65, 63, 59, 57, 53, 50, 47, 44, 41, 38, 37, 34, 31, 28, 26, 24,
21, 17, 15, 12, 10, 6, 4, 2, 0, -3, -7, -8, -12, -13, -16, -18, -20, -22, -24,
-27, -29, -30, -32, -34, -36, -37, -39, -41, -42, -45, -48, -50, -51, -53, -56,
-57, -58, -59, -61, -63, -65, -66, -69, -70, -72, -74, -76, -77, -79, -80, -83,
-85, -85, -88, -90, -91, -92, -95, -96, -98, -99, -100, -102, -103, -104, -106,
-107, -108, -110, -110, -112, -113, -113, -114, -116, -117, -117, -118, -119,
-119, -118, -118, -119, -119, -119, -117, -118, -117, -116, -114, -114, -112,
-112, -110, -108, -107, -105, -104, -103, -100, -99, -96, -94, -93, -90, -87,
-86, -84, -80, -78, -75, -71, -68, -65, -62, -60, -56, -52, -50, -47, -43, -40,
-37, -34, -31, -28, -24, -22, -19, -16, -13, -11, -8, -5, -2, 0, 3, 5, 8, 11,
13, 16, 19, 21, 23, 25, 28, 30, 31, 33, 36, 37, 39, 41, 43, 45, 46, 49, 50, 52,
53, 55, 57, 58, 60, 62, 64, 67, 68, 70, 72, 74, 75, 77, 80, 81, 83, 84, 85, 87,
87, 90, 91, 92, 94, 95, 97, 98, 101, 102, 103, 104, 106, 107, 108, 108, 110,
111, 112, 112, 113, 114, 114, 114, 114, 115, 116, 116, 115, 115, 116, 115, 115,
116, 114, 114, 113, 112, 112, 110, 110, 108, 106, 105, 104, 101, 100, 98, 95,
93, 91, 89, 86, 83, 81, 79, 77, 74, 71, 69, 66, 64, 60, 57, 55, 53, 50, 47, 45,
41, 38, 35, 31, 28, 25, 22, 18, 16, 12, 11, 7, 4, 2, 0, -3, -5, -7, -8, -10,
-13, -14, -15, -17, -19, -22, -24, -25, -28, -30, -32, -35, -37, -39, -41, -44,
-46, -48, -51, -52, -53, -55, -56, -58, -60, -61, -62, -64, -66, -69, -69, -71,
-74, -76, -78, -80, -81, -84, -87, -88, -89, -91, -93, -94, -95, -97, -98, -100,
-101, -102, -104, -104, -107, -107, -109, -111, -112, -113, -114, -115, -116,
-116, -117, -117, -117, -117, -117, -117, -117, -117, -118, -117, -116, -116,
-116, -114, -114, -114, -113, -112, -111, -110, -110, -107, -105, -103, -101,
-98, -97, -94, -93, -90, -87, -85, -81, -78, -76, -72, -69, -67, -64, -60, -58,
-54, -52, -50, -46, -44, -41, -37, -36, -33, -30, -26, -24, -20, -18, -13, -11,
-7, -5, -2, };