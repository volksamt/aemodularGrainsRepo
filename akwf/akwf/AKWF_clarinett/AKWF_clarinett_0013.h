#define DATA_LENGTH 512
#define DATA AKWF_clarinett_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 3, 4, 5, 7, 8, 9, 11, 13, 13,
15, 17, 18, 19, 21, 22, 23, 25, 25, 28, 28, 29, 31, 31, 32, 34, 34, 35, 36, 38,
38, 40, 40, 41, 42, 44, 44, 45, 46, 47, 47, 48, 49, 49, 49, 50, 51, 51, 53, 52,
53, 52, 53, 54, 54, 55, 55, 55, 56, 57, 57, 57, 58, 59, 59, 60, 61, 62, 62, 63,
64, 63, 63, 65, 65, 66, 67, 68, 68, 68, 69, 70, 71, 71, 72, 73, 74, 75, 76, 76,
77, 78, 79, 79, 80, 82, 83, 84, 85, 86, 87, 88, 89, 89, 91, 92, 93, 93, 94, 95,
95, 97, 98, 99, 101, 101, 102, 103, 104, 105, 107, 107, 107, 108, 108, 109, 109,
110, 110, 112, 113, 113, 113, 114, 115, 115, 116, 117, 117, 118, 118, 118, 119,
118, 119, 119, 119, 119, 118, 119, 119, 119, 120, 119, 119, 118, 118, 117, 116,
116, 115, 114, 113, 112, 111, 110, 110, 108, 107, 106, 105, 103, 103, 102, 100,
98, 97, 97, 94, 93, 92, 90, 89, 87, 86, 83, 82, 81, 79, 77, 75, 73, 72, 71, 69,
68, 66, 65, 63, 62, 60, 58, 56, 55, 54, 52, 51, 48, 48, 45, 44, 42, 41, 38, 37,
36, 33, 32, 30, 28, 26, 24, 23, 21, 20, 18, 15, 14, 12, 10, 9, 7, 5, 4, 1, 0,
-3, -4, -6, -7, -10, -12, -13, -15, -17, -18, -20, -21, -23, -25, -26, -27, -29,
-31, -32, -34, -35, -36, -38, -39, -41, -41, -43, -45, -45, -47, -48, -48, -50,
-51, -52, -52, -53, -54, -55, -55, -56, -57, -57, -57, -58, -57, -59, -58, -59,
-58, -59, -59, -59, -60, -59, -59, -59, -59, -59, -58, -57, -58, -57, -56, -56,
-56, -56, -54, -54, -54, -53, -52, -53, -52, -52, -51, -51, -50, -49, -49, -49,
-48, -48, -47, -47, -46, -46, -46, -46, -46, -45, -46, -45, -45, -45, -46, -45,
-46, -46, -46, -47, -47, -48, -50, -49, -50, -50, -51, -52, -53, -54, -54, -54,
-55, -57, -57, -58, -60, -60, -62, -62, -64, -65, -66, -68, -69, -69, -73, -73,
-75, -76, -78, -80, -80, -83, -84, -86, -87, -88, -89, -91, -92, -94, -95, -96,
-97, -98, -99, -99, -101, -102, -102, -103, -103, -104, -104, -105, -105, -106,
-106, -107, -107, -106, -107, -108, -108, -107, -107, -107, -106, -107, -106,
-105, -106, -104, -105, -104, -103, -103, -102, -101, -100, -99, -99, -98, -97,
-96, -96, -95, -94, -93, -91, -91, -89, -89, -86, -86, -85, -83, -82, -80, -79,
-78, -76, -76, -75, -73, -72, -71, -70, -69, -68, -67, -66, -65, -64, -63, -61,
-60, -60, -58, -57, -57, -57, -56, -54, -53, -53, -52, -52, -50, -49, -48, -47,
-46, -46, -44, -44, -43, -41, -41, -39, -38, -38, -36, -35, -34, -33, -33, -31,
-29, -28, -27, -26, -25, -23, -23, -21, -20, -19, -18, -16, -15, -14, -12, -11,
-10, -8, -7, -6, -5, -4, -3, -1, -1, };