#define DATA_LENGTH 512
#define DATA AKWF_clarinett_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 7, 8, 9, 10, 10, 12, 14,
15, 16, 18, 18, 19, 21, 21, 22, 23, 23, 25, 26, 28, 30, 31, 32, 33, 34, 34, 35,
35, 36, 38, 39, 40, 41, 43, 43, 45, 47, 48, 48, 50, 51, 53, 53, 55, 55, 57, 58,
58, 59, 60, 61, 63, 64, 65, 66, 67, 69, 69, 71, 72, 72, 74, 75, 77, 78, 79, 79,
81, 80, 82, 83, 84, 85, 86, 86, 88, 87, 89, 90, 91, 91, 92, 92, 94, 95, 95, 95,
97, 98, 100, 100, 102, 102, 103, 103, 103, 104, 104, 105, 106, 107, 108, 109,
109, 109, 110, 110, 111, 112, 112, 112, 113, 113, 114, 115, 115, 116, 116, 116,
116, 116, 116, 116, 116, 116, 116, 116, 115, 115, 115, 115, 116, 115, 116, 116,
115, 115, 114, 113, 113, 113, 113, 112, 113, 112, 113, 113, 112, 112, 111, 111,
109, 109, 109, 108, 106, 106, 106, 104, 104, 103, 101, 100, 99, 98, 98, 96, 95,
94, 93, 92, 90, 89, 88, 87, 87, 85, 85, 83, 82, 82, 81, 79, 79, 77, 77, 75, 75,
74, 74, 73, 72, 71, 70, 70, 68, 67, 66, 65, 64, 64, 63, 62, 61, 60, 59, 57, 56,
55, 54, 52, 51, 50, 50, 47, 46, 44, 42, 41, 40, 38, 37, 36, 35, 33, 32, 30, 28,
26, 25, 25, 24, 22, 22, 20, 19, 17, 17, 17, 15, 14, 13, 11, 11, 10, 9, 8, 8, 6,
5, 4, 3, 2, 2, 1, -1, -1, -3, -4, -4, -6, -8, -9, -10, -12, -12, -13, -15, -16,
-18, -18, -19, -21, -22, -24, -25, -27, -29, -30, -31, -32, -34, -34, -36, -37,
-38, -39, -40, -41, -42, -43, -44, -45, -45, -47, -49, -49, -50, -52, -52, -54,
-54, -56, -57, -57, -59, -59, -60, -62, -63, -64, -65, -65, -67, -67, -69, -70,
-71, -72, -74, -75, -75, -76, -78, -79, -81, -81, -81, -83, -84, -85, -86, -87,
-87, -89, -91, -90, -92, -94, -95, -96, -96, -97, -99, -99, -99, -99, -100,
-100, -102, -102, -103, -104, -105, -106, -105, -107, -107, -109, -109, -110,
-110, -110, -111, -111, -112, -113, -113, -113, -114, -114, -115, -115, -116,
-117, -117, -117, -118, -118, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -118, -119, -118, -117, -117, -116, -116, -115, -116,
-115, -115, -115, -115, -114, -113, -112, -112, -110, -109, -109, -108, -106,
-106, -106, -106, -105, -105, -104, -104, -102, -101, -99, -99, -98, -97, -95,
-95, -95, -94, -93, -92, -89, -88, -88, -87, -87, -85, -85, -84, -82, -81, -80,
-78, -78, -76, -75, -74, -72, -72, -70, -69, -68, -67, -66, -64, -64, -62, -60,
-59, -57, -57, -56, -55, -53, -53, -51, -49, -48, -46, -45, -44, -43, -42, -41,
-39, -39, -37, -37, -35, -33, -32, -31, -30, -30, -28, -27, -25, -23, -22, -21,
-19, -19, -18, -16, -15, -13, -12, -11, -9, -8, -6, -5, -4, -4, -3, -1, 0, };