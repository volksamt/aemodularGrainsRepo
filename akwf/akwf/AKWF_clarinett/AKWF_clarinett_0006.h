#define DATA_LENGTH 512
#define DATA AKWF_clarinett_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 3, 4, 6, 8, 8, 10, 11, 14, 14,
17, 18, 19, 21, 23, 24, 25, 25, 27, 29, 29, 31, 31, 33, 34, 34, 36, 37, 36, 37,
37, 37, 37, 39, 39, 39, 40, 41, 42, 42, 43, 44, 45, 45, 46, 46, 47, 47, 47, 47,
49, 49, 50, 51, 52, 54, 55, 55, 57, 58, 58, 60, 60, 62, 62, 64, 64, 65, 66, 68,
69, 71, 71, 73, 74, 76, 77, 78, 79, 81, 83, 84, 85, 87, 89, 90, 92, 93, 94, 96,
97, 98, 99, 101, 101, 103, 104, 105, 106, 107, 108, 109, 110, 112, 112, 113,
113, 115, 115, 115, 116, 117, 116, 117, 118, 118, 118, 119, 119, 120, 119, 119,
119, 119, 119, 118, 118, 118, 118, 117, 117, 117, 115, 115, 115, 114, 113, 113,
113, 113, 113, 113, 113, 113, 113, 113, 113, 113, 113, 113, 113, 112, 112, 113,
112, 112, 111, 111, 111, 111, 110, 111, 111, 111, 110, 111, 110, 110, 108, 108,
107, 107, 106, 105, 104, 103, 103, 102, 101, 99, 98, 97, 96, 94, 92, 91, 90, 88,
86, 84, 83, 81, 81, 78, 77, 75, 73, 71, 70, 67, 65, 63, 61, 59, 57, 54, 51, 50,
47, 44, 42, 40, 38, 35, 33, 31, 29, 26, 24, 23, 20, 19, 16, 14, 12, 11, 7, 6, 4,
2, 0, -3, -4, -6, -8, -10, -11, -13, -15, -16, -18, -20, -21, -21, -23, -25,
-27, -28, -28, -30, -32, -33, -34, -35, -37, -37, -38, -40, -41, -42, -43, -44,
-46, -46, -48, -48, -50, -50, -52, -52, -54, -55, -56, -58, -60, -61, -61, -62,
-64, -65, -67, -68, -69, -70, -71, -74, -73, -75, -77, -77, -78, -78, -79, -79,
-80, -81, -82, -81, -81, -82, -83, -83, -83, -84, -85, -85, -86, -86, -86, -86,
-87, -88, -88, -88, -88, -87, -88, -87, -87, -87, -86, -87, -86, -85, -85, -86,
-85, -85, -85, -85, -86, -85, -85, -84, -85, -84, -84, -84, -84, -85, -84, -84,
-84, -84, -84, -85, -85, -86, -86, -85, -86, -86, -85, -86, -85, -84, -85, -84,
-85, -85, -85, -85, -85, -85, -85, -86, -85, -85, -86, -85, -86, -86, -86, -85,
-85, -85, -85, -85, -84, -84, -84, -85, -84, -85, -84, -85, -85, -84, -83, -84,
-84, -84, -83, -83, -83, -82, -82, -82, -81, -81, -81, -80, -80, -79, -80, -80,
-79, -79, -78, -78, -78, -77, -76, -76, -75, -75, -74, -74, -74, -73, -72, -72,
-71, -71, -70, -70, -70, -69, -68, -67, -67, -66, -66, -64, -63, -63, -62, -60,
-61, -59, -60, -58, -57, -57, -56, -55, -54, -53, -53, -52, -51, -50, -49, -49,
-47, -47, -45, -45, -43, -43, -43, -41, -41, -40, -40, -39, -39, -39, -37, -37,
-36, -36, -35, -36, -35, -33, -34, -33, -32, -32, -31, -30, -31, -29, -29, -28,
-27, -26, -25, -24, -24, -24, -23, -21, -21, -19, -19, -18, -17, -15, -14, -12,
-12, -10, -9, -8, -6, -5, -3, -2, -1, };