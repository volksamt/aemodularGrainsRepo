#define DATA_LENGTH 512
#define DATA AKWF_clarinett_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 7, 8, 10, 12, 13, 15, 18, 20,
22, 23, 26, 27, 30, 33, 35, 36, 38, 40, 42, 44, 46, 47, 49, 51, 53, 55, 56, 58,
60, 61, 62, 64, 65, 66, 67, 70, 71, 72, 73, 74, 75, 77, 78, 79, 80, 81, 83, 83,
83, 85, 86, 87, 89, 89, 91, 93, 93, 94, 95, 96, 97, 98, 98, 100, 101, 101, 102,
103, 103, 104, 105, 106, 107, 107, 108, 109, 110, 109, 110, 111, 111, 112, 112,
113, 113, 114, 114, 114, 114, 115, 116, 117, 116, 116, 118, 118, 118, 118, 118,
119, 119, 120, 119, 120, 119, 119, 120, 119, 120, 118, 119, 118, 118, 118, 117,
117, 116, 115, 114, 114, 113, 112, 112, 111, 109, 109, 109, 108, 107, 107, 106,
105, 105, 104, 103, 102, 101, 99, 98, 98, 96, 96, 94, 94, 93, 91, 91, 89, 88,
88, 87, 85, 84, 83, 83, 82, 80, 79, 78, 76, 76, 75, 73, 72, 70, 68, 68, 67, 65,
64, 63, 62, 60, 60, 59, 57, 56, 56, 54, 54, 54, 52, 52, 51, 51, 49, 48, 49, 49,
48, 47, 48, 46, 46, 46, 46, 45, 45, 45, 45, 45, 44, 45, 45, 44, 44, 44, 44, 45,
44, 44, 45, 45, 45, 45, 44, 45, 43, 44, 44, 43, 44, 44, 43, 43, 42, 41, 41, 41,
39, 38, 38, 37, 36, 35, 35, 34, 33, 32, 31, 31, 30, 29, 28, 26, 25, 24, 23, 21,
20, 18, 16, 15, 13, 10, 10, 7, 6, 4, 2, 0, -2, -3, -6, -8, -9, -11, -13, -16,
-17, -18, -20, -23, -25, -27, -28, -31, -33, -34, -37, -38, -40, -41, -43, -45,
-48, -50, -51, -53, -55, -56, -59, -60, -61, -62, -64, -66, -67, -70, -71, -73,
-74, -75, -77, -78, -80, -81, -82, -84, -84, -86, -86, -87, -89, -89, -90, -92,
-92, -92, -93, -94, -95, -96, -96, -97, -97, -98, -98, -99, -100, -100, -100,
-101, -102, -103, -103, -103, -103, -103, -104, -104, -106, -105, -106, -106,
-106, -107, -107, -108, -108, -107, -108, -108, -108, -109, -109, -108, -109,
-109, -109, -108, -110, -109, -108, -109, -109, -108, -109, -109, -109, -108,
-108, -108, -108, -108, -107, -107, -106, -106, -106, -106, -105, -105, -105,
-104, -104, -104, -103, -102, -102, -102, -102, -100, -101, -100, -99, -99, -98,
-98, -97, -96, -96, -95, -95, -94, -93, -93, -92, -92, -91, -91, -90, -90, -90,
-90, -88, -87, -87, -87, -86, -86, -85, -84, -83, -83, -83, -82, -82, -81, -81,
-81, -79, -80, -79, -78, -78, -77, -77, -77, -76, -77, -76, -76, -75, -75, -75,
-74, -74, -74, -73, -72, -72, -71, -71, -70, -70, -69, -69, -69, -69, -67, -67,
-66, -65, -65, -64, -63, -63, -61, -61, -60, -58, -58, -58, -56, -55, -54, -53,
-53, -51, -50, -48, -47, -46, -44, -42, -41, -39, -37, -36, -34, -33, -31, -29,
-27, -25, -24, -22, -19, -18, -15, -13, -12, -9, -8, -6, -3, -3, -1, };