#define DATA_LENGTH 512
#define DATA AKWF_clarinett_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 7, 8, 10, 12, 14, 15, 17, 18,
21, 23, 24, 26, 29, 30, 33, 34, 36, 38, 40, 42, 43, 44, 46, 48, 49, 51, 53, 53,
55, 57, 57, 59, 60, 62, 64, 64, 66, 67, 68, 69, 70, 72, 72, 74, 75, 76, 77, 77,
78, 79, 80, 81, 82, 83, 84, 84, 86, 86, 87, 86, 88, 88, 88, 88, 89, 91, 90, 91,
91, 91, 92, 93, 92, 92, 93, 93, 93, 93, 94, 95, 96, 96, 95, 96, 96, 95, 96, 95,
96, 96, 95, 97, 96, 95, 96, 96, 95, 95, 95, 94, 95, 94, 93, 93, 93, 92, 92, 92,
92, 91, 91, 90, 90, 88, 88, 87, 88, 87, 86, 86, 86, 84, 84, 83, 83, 82, 82, 81,
80, 80, 80, 79, 79, 78, 78, 78, 78, 78, 77, 76, 76, 76, 76, 76, 77, 76, 76, 76,
76, 76, 77, 77, 78, 77, 77, 78, 78, 78, 78, 79, 78, 78, 79, 79, 79, 79, 80, 79,
80, 80, 80, 80, 80, 80, 80, 81, 81, 81, 81, 82, 81, 80, 80, 80, 81, 81, 81, 81,
81, 80, 81, 81, 80, 80, 81, 81, 81, 81, 81, 81, 80, 80, 80, 80, 80, 80, 80, 80,
80, 80, 80, 80, 80, 79, 79, 79, 80, 79, 78, 78, 78, 77, 76, 75, 75, 75, 74, 73,
72, 70, 69, 68, 67, 65, 64, 62, 60, 59, 57, 55, 53, 50, 48, 46, 44, 41, 40, 37,
34, 33, 31, 28, 26, 23, 20, 18, 16, 13, 11, 9, 6, 4, 2, 0, -3, -6, -9, -10, -13,
-15, -16, -19, -21, -23, -26, -28, -30, -32, -34, -36, -39, -40, -42, -44, -46,
-47, -50, -51, -54, -56, -57, -59, -60, -62, -64, -65, -68, -69, -71, -72, -73,
-75, -77, -77, -78, -79, -81, -82, -82, -85, -85, -86, -87, -89, -89, -91, -91,
-92, -94, -95, -95, -97, -97, -98, -100, -101, -101, -103, -104, -104, -106,
-107, -108, -109, -110, -110, -111, -111, -112, -113, -114, -114, -114, -115,
-117, -117, -117, -118, -118, -118, -119, -118, -119, -119, -119, -118, -119,
-119, -119, -119, -118, -118, -118, -118, -117, -117, -117, -116, -116, -115,
-114, -113, -113, -112, -110, -110, -110, -109, -108, -107, -106, -105, -104,
-103, -102, -101, -100, -99, -98, -97, -96, -95, -95, -94, -92, -93, -92, -91,
-91, -91, -91, -89, -89, -90, -88, -88, -88, -87, -87, -88, -86, -87, -86, -86,
-86, -86, -85, -86, -85, -86, -85, -85, -86, -85, -85, -84, -84, -84, -84, -84,
-83, -84, -83, -83, -83, -83, -83, -83, -82, -82, -82, -80, -80, -81, -80, -80,
-78, -79, -79, -77, -78, -76, -75, -75, -75, -73, -73, -72, -72, -70, -70, -70,
-68, -67, -66, -66, -65, -64, -64, -62, -62, -61, -59, -58, -57, -56, -54, -53,
-51, -50, -49, -47, -45, -43, -43, -41, -40, -38, -36, -35, -32, -30, -30, -27,
-26, -24, -22, -21, -19, -17, -16, -14, -12, -10, -8, -6, -4, -2, -1, };