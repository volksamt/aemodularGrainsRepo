#define DATA_LENGTH 512
#define DATA AKWF_clarinett_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 5, 6, 8, 9, 11, 12, 14, 15,
17, 19, 19, 21, 23, 24, 26, 29, 29, 32, 32, 34, 35, 38, 39, 40, 42, 43, 45, 46,
47, 50, 50, 51, 52, 54, 55, 56, 56, 58, 58, 60, 61, 61, 62, 63, 63, 65, 66, 66,
67, 68, 68, 69, 70, 70, 70, 70, 71, 71, 72, 72, 71, 71, 72, 73, 72, 73, 73, 72,
72, 71, 71, 71, 71, 70, 70, 69, 69, 69, 69, 68, 68, 68, 68, 68, 68, 68, 69, 69,
68, 69, 69, 68, 69, 69, 69, 69, 69, 69, 70, 69, 69, 70, 70, 70, 69, 70, 70, 70,
71, 72, 72, 73, 73, 74, 74, 76, 76, 77, 78, 79, 79, 80, 81, 82, 83, 84, 84, 84,
85, 86, 87, 87, 88, 89, 90, 91, 92, 94, 94, 96, 96, 96, 98, 99, 99, 100, 101,
101, 102, 102, 103, 104, 105, 106, 107, 108, 108, 109, 110, 110, 111, 113, 113,
114, 114, 114, 115, 117, 116, 118, 116, 117, 118, 118, 120, 119, 119, 120, 120,
119, 120, 118, 119, 119, 118, 117, 116, 116, 116, 115, 113, 112, 112, 110, 110,
108, 107, 105, 104, 103, 101, 100, 98, 96, 95, 92, 90, 88, 86, 84, 82, 79, 78,
76, 74, 72, 68, 67, 63, 61, 58, 56, 54, 51, 48, 46, 43, 40, 37, 35, 32, 29, 26,
23, 21, 17, 14, 11, 8, 4, 2, -1, -4, -7, -10, -13, -16, -18, -21, -25, -27, -30,
-32, -35, -38, -39, -42, -44, -48, -49, -52, -54, -56, -59, -61, -63, -65, -68,
-69, -70, -72, -73, -74, -76, -77, -78, -80, -80, -82, -83, -83, -85, -86, -86,
-88, -88, -89, -91, -90, -91, -91, -92, -93, -93, -94, -94, -94, -94, -95, -95,
-95, -96, -96, -95, -96, -96, -95, -95, -95, -95, -95, -94, -94, -94, -94, -94,
-94, -93, -93, -92, -92, -92, -91, -90, -89, -90, -89, -88, -88, -87, -88, -87,
-87, -85, -85, -85, -85, -83, -82, -83, -82, -81, -81, -80, -80, -79, -78, -78,
-77, -77, -76, -75, -76, -75, -74, -74, -73, -73, -72, -72, -72, -71, -71, -71,
-71, -71, -70, -70, -69, -70, -70, -70, -70, -69, -69, -69, -69, -69, -70, -70,
-69, -70, -70, -70, -70, -70, -70, -70, -70, -71, -71, -72, -72, -73, -73, -73,
-74, -75, -74, -76, -76, -76, -77, -76, -76, -77, -78, -78, -78, -79, -79, -79,
-79, -80, -80, -81, -80, -81, -81, -81, -81, -81, -82, -81, -80, -80, -80, -80,
-79, -78, -79, -78, -77, -77, -78, -77, -75, -76, -76, -74, -75, -74, -73, -71,
-71, -70, -69, -68, -68, -67, -66, -66, -65, -64, -63, -62, -60, -60, -59, -58,
-57, -56, -55, -54, -52, -51, -51, -49, -49, -47, -46, -45, -44, -42, -42, -41,
-40, -37, -37, -36, -35, -34, -33, -33, -32, -31, -29, -28, -28, -26, -24, -22,
-21, -20, -18, -18, -17, -16, -14, -13, -12, -10, -10, -8, -7, -6, -4, -3, -1,
};