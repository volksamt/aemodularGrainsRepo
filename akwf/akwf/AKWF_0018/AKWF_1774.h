#define DATA_LENGTH 512
#define DATA AKWF_1774

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 19, 22, 27, 29, 32, 34, 37, 37,
41, 42, 43, 45, 47, 48, 49, 51, 52, 53, 55, 56, 56, 58, 60, 60, 62, 62, 65, 65,
66, 67, 68, 69, 70, 70, 72, 72, 73, 75, 74, 76, 76, 77, 78, 79, 80, 80, 82, 83,
83, 84, 85, 85, 85, 86, 87, 87, 88, 88, 89, 90, 91, 91, 92, 92, 93, 93, 94, 94,
95, 96, 95, 97, 98, 98, 98, 99, 99, 100, 100, 101, 102, 102, 101, 103, 103, 104,
104, 105, 104, 106, 105, 106, 107, 107, 107, 107, 107, 108, 108, 109, 110, 110,
110, 111, 110, 110, 111, 111, 112, 112, 112, 113, 112, 113, 113, 113, 114, 114,
114, 114, 114, 115, 114, 115, 114, 115, 115, 115, 116, 116, 116, 117, 116, 116,
117, 116, 117, 118, 117, 118, 117, 118, 118, 118, 118, 117, 118, 118, 118, 118,
119, 119, 118, 118, 119, 119, 118, 118, 119, 119, 119, 118, 119, 119, 119, 119,
118, 119, 119, 119, 118, 118, 118, 119, 118, 119, 119, 118, 118, 119, 119, 119,
119, 119, 119, 119, 120, 119, 118, 115, 115, 113, 112, 111, 110, 108, 107, 106,
104, 104, 102, 100, 100, 99, 98, 95, 95, 93, 93, 91, 90, 88, 87, 86, 85, 84, 82,
81, 80, 79, 78, 76, 75, 74, 72, 70, 70, 68, 68, 66, 65, 63, 61, 60, 58, 57, 56,
55, 53, 51, 50, 48, 46, 45, 43, 40, 38, 37, 35, 32, 29, 28, 22, 19, 10, -14,
-19, -23, -27, -29, -32, -35, -37, -38, -41, -42, -44, -45, -47, -48, -49, -51,
-53, -53, -54, -56, -58, -58, -60, -61, -61, -63, -64, -65, -66, -67, -68, -69,
-70, -70, -72, -73, -74, -75, -74, -75, -76, -77, -78, -80, -80, -80, -81, -82,
-83, -84, -84, -85, -86, -86, -87, -88, -87, -89, -89, -90, -90, -92, -92, -93,
-94, -93, -94, -94, -95, -96, -96, -97, -98, -98, -99, -99, -99, -100, -101,
-101, -101, -102, -102, -103, -103, -104, -104, -104, -105, -106, -105, -106,
-106, -107, -107, -107, -108, -108, -108, -109, -109, -110, -110, -111, -110,
-111, -111, -111, -112, -111, -112, -112, -113, -113, -113, -114, -114, -114,
-113, -114, -115, -114, -114, -115, -114, -115, -116, -115, -116, -116, -116,
-116, -116, -116, -117, -116, -117, -117, -117, -118, -117, -118, -117, -118,
-118, -117, -117, -118, -119, -118, -118, -118, -118, -118, -119, -118, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -120, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -120, -119, -119, -120, -120, -119, -119, -119,
-119, -120, -120, -119, -118, -118, -116, -115, -113, -112, -111, -110, -108,
-106, -106, -105, -103, -101, -101, -99, -98, -98, -96, -95, -93, -93, -91, -89,
-89, -87, -86, -84, -84, -83, -81, -80, -78, -77, -76, -75, -73, -72, -72, -70,
-68, -67, -66, -65, -63, -62, -60, -58, -58, -56, -55, -52, -51, -49, -48, -46,
-45, -42, -40, -39, -37, -34, -32, -29, -27, -22, -18, -10, };