#define DATA_LENGTH 512
#define DATA AKWF_1793

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 8, 10, 14, 16, 18, 22, 24,
27, 28, 30, 31, 33, 33, 35, 35, 34, 34, 33, 33, 33, 31, 30, 29, 28, 28, 26, 25,
24, 24, 22, 22, 22, 21, 22, 22, 21, 21, 22, 23, 23, 23, 23, 24, 26, 28, 28, 30,
32, 33, 35, 36, 40, 41, 43, 46, 47, 49, 52, 53, 55, 57, 58, 60, 61, 62, 63, 63,
63, 64, 63, 63, 63, 61, 62, 61, 59, 59, 57, 56, 56, 55, 53, 52, 52, 51, 51, 51,
50, 52, 51, 52, 52, 52, 53, 56, 57, 60, 61, 63, 66, 67, 70, 73, 75, 77, 80, 82,
83, 85, 86, 87, 88, 86, 85, 84, 81, 78, 74, 70, 65, 61, 55, 49, 43, 38, 31, 27,
22, 19, 15, 13, 12, 11, 12, 13, 15, 18, 21, 26, 31, 36, 43, 47, 53, 59, 64, 68,
74, 78, 82, 86, 89, 93, 95, 98, 100, 102, 104, 106, 106, 108, 108, 110, 110,
111, 110, 112, 111, 112, 109, 111, 108, 110, 107, 107, 104, 103, 100, 97, 96,
89, 91, 81, 87, 68, 93, -22, -108, -73, -86, -69, -74, -63, -63, -56, -56, -51,
-49, -47, -45, -44, -42, -41, -40, -40, -38, -39, -38, -39, -38, -38, -37, -39,
-37, -38, -37, -38, -37, -38, -38, -37, -37, -38, -38, -38, -40, -40, -43, -44,
-47, -50, -53, -57, -62, -66, -71, -77, -82, -87, -93, -99, -103, -108, -112,
-115, -117, -118, -118, -118, -116, -113, -110, -105, -98, -93, -86, -81, -73,
-66, -61, -55, -50, -44, -41, -37, -35, -33, -31, -32, -32, -33, -34, -35, -37,
-39, -42, -44, -46, -49, -51, -52, -55, -57, -57, -59, -60, -61, -61, -61, -63,
-62, -61, -61, -60, -60, -59, -57, -57, -54, -53, -52, -51, -48, -46, -45, -42,
-41, -39, -37, -35, -33, -32, -30, -29, -28, -28, -26, -26, -25, -25, -25, -25,
-25, -26, -26, -27, -27, -28, -28, -29, -31, -31, -31, -31, -33, -33, -33, -34,
-33, -33, -33, -33, -32, -32, -31, -31, -30, -30, -29, -28, -27, -26, -26, -25,
-24, -23, -23, -22, -20, -21, -21, -20, -22, -22, -23, -24, -25, -27, -29, -31,
-32, -35, -37, -38, -40, -42, -43, -45, -45, -46, -46, -45, -44, -43, -42, -41,
-39, -37, -36, -34, -32, -31, -29, -27, -25, -24, -23, -21, -21, -20, -19, -17,
-18, -17, -17, -16, -16, -15, -15, -15, -15, -15, -15, -14, -15, -13, -14, -14,
-13, -14, -14, -14, -14, -14, -13, -14, -13, -13, -13, -14, -13, -13, -12, -13,
-13, -13, -13, -12, -12, -12, -12, -11, -12, -12, -10, -10, -9, -8, -9, -8, -8,
-7, -6, -6, -5, -4, -4, -2, -3, -2, -2, 0, 0, 1, 2, 1, 2, 4, 3, 3, 4, 5, 6, 6,
7, 7, 7, 7, 8, 8, 9, 9, 10, 10, 9, 9, 8, 8, 8, 7, 6, 6, 5, 5, 3, 3, 1, 1, 0, -2,
-3, -3, -4, -4, -4, -4, -3, -2, 0, };