#define DATA_LENGTH 512
#define DATA AKWF_1773

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 4, 4, 3, 4, 3, 3, 3, 3, 3,
2, 3, 3, 3, 3, 4, 4, 4, 3, 3, 4, 3, 3, 3, 4, 4, 3, 4, 4, 3, 3, 4, 3, 3, 3, 4, 4,
4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 4, 3, 4, 3, 3, 3, 4, 4, 3, 3, 3, 3, 3, 3, 3, 3, 3,
4, 3, 4, 3, 3, 3, 3, 3, 4, 4, 3, 4, 3, 4, 4, 4, 4, 3, 4, 3, 4, 3, 3, 3, 3, 3, 3,
3, 3, 4, 3, 3, 3, 4, 3, 3, 4, 3, 3, 3, 4, 4, 3, 3, 4, 3, 3, 3, 4, 3, 3, 3, 3, 4,
3, 3, 4, 3, 3, 3, 3, 3, 4, 4, 4, 4, 3, 4, 3, 4, 3, 3, 4, 4, 4, 4, 3, 3, 3, 3, 4,
4, 3, 3, 3, 3, 4, 3, 3, 4, 3, 4, 3, 3, 3, 3, 3, 3, 4, 3, 3, 4, 4, 3, 3, 3, 3, 4,
3, 3, 3, 4, 3, 3, 3, 3, 4, 3, 3, 3, 3, 3, 3, 3, 4, 3, 4, 3, 4, 3, 3, 3, 3, 3, 3,
4, 3, 4, 3, 3, 3, 3, 3, 3, 4, 3, 3, 4, 4, 3, 3, 4, 3, 3, 4, 4, 3, 3, 3, 3, 3, 3,
2, 3, 3, 3, 3, 3, 4, 4, 2, 3, 3, 4, 3, 4, 3, 4, 4, 3, 3, 4, 3, 3, 3, 4, 3, 4, 3,
4, 3, 4, 4, 4, 3, 3, 4, 3, 3, 3, 4, 4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3,
3, 3, 3, 3, 3, 4, 3, 3, 4, 3, 3, 3, 3, 4, 3, 2, 3, 4, 3, 4, 3, 3, 3, 3, 4, 3, 3,
3, 3, 3, 3, 2, 3, 3, 3, 4, 4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 4, 3, 3, 4, 5, 6,
6, 8, 8, 9, 11, 12, 12, 14, 14, 15, 17, 17, 18, 19, 19, 20, 22, 23, 24, 25, 26,
27, 27, 29, 29, 30, 31, 31, 33, 34, 35, 36, 38, 38, 38, 41, 41, 42, 43, 44, 44,
46, 47, 49, 48, 50, 50, 52, 51, 54, 54, 56, 55, 58, 57, 60, 60, 61, 62, 62, 64,
64, 68, 63, 72, 60, 86, -18, -84, -58, -70, -58, -62, -55, -57, -53, -50, -47,
-46, -45, -40, -46, -128, -92, -48, -58, -50, -56, -50, -54, -51, -52, -49, -51,
-49, -50, -47, -49, -47, -47, -46, -46, -45, -45, -44, -43, -44, -42, -42, -41,
-41, -40, -40, -39, -39, -37, -37, -36, -36, -35, -35, -34, -34, -33, -33, -33,
-32, -32, -30, -30, -29, -29, -29, -29, -27, -26, -26, -26, -25, -24, -25, -24,
-23, -23, -21, -21, -20, -20, -19, -20, -19, -18, -18, -16, -17, -16, -15, -14,
-14, -14, -13, -13, -12, -11, -11, -11, -10, -9, -8, -7, -6, -5, -4, -3, -1, };