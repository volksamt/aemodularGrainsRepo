#define DATA_LENGTH 512
#define DATA AKWF_1780

const PROGMEM int8_t DATA[DATA_LENGTH] = {103, 123, 114, 121, 115, 120, 116,
121, 116, 120, 117, 120, 117, 120, 117, 119, 118, 120, 117, 119, 119, 119, 119,
118, 119, 119, 119, 119, 120, 118, 120, 118, 121, 117, 120, 117, 121, 116, 122,
116, 121, 117, 121, 116, 121, 115, 120, 116, 120, 117, 116, 123, -80, -114, -93,
-108, -96, -106, -96, -105, -97, -104, -96, -104, -97, -102, -98, -102, -98,
-101, -99, -100, -98, -99, -99, -98, -99, -98, -99, -98, -100, -96, -100, -95,
-101, -93, -104, -89, -110, -59, -22, -66, -50, -59, -52, -58, -54, -55, -55,
-55, -56, -55, -55, -55, -57, -55, -55, -54, -56, -55, -56, -55, -56, -54, -56,
-55, -55, -55, -55, -55, -55, -55, -55, -55, -55, -56, -56, -55, -55, -54, -56,
-53, -56, -54, -57, -50, -72, -108, -101, -105, -103, -104, -103, -103, -103,
-103, -103, -103, -103, -102, -102, -101, -103, -101, -102, -101, -102, -101,
-101, -101, -101, -100, -101, -102, -101, -101, -100, -101, -100, -101, -100,
-103, -107, -106, -107, -106, -105, -105, -106, -106, -105, -105, -104, -105,
-104, -104, -104, -104, -104, -104, -104, -103, -103, -103, -102, -102, -103,
-102, -101, -101, -101, -101, -101, -101, -100, -100, -100, -100, -99, -100,
-98, -99, -98, -98, -97, -98, -97, -97, -96, -97, -97, -95, -96, -94, -90, -88,
-84, -82, -79, -76, -74, -71, -68, -65, -63, -60, -58, -55, -53, -50, -49, -49,
-48, -49, -49, -49, -49, -49, -49, -48, -49, -49, -49, -48, -48, -48, -48, -48,
-49, -48, -49, -48, -48, -48, -48, -47, -49, -48, -48, -48, -49, -48, -48, -48,
-48, -48, -48, -48, -47, -48, -48, -48, -49, -49, -48, -48, -47, -48, -48, -48,
-47, -48, -47, -47, -48, -47, -48, -48, -47, -48, -47, -47, -48, -48, -47, -47,
-48, -48, -48, -47, -47, -47, -47, -47, -47, -46, -47, -47, -48, -47, -47, -46,
-46, -46, -47, -47, -47, -47, -47, -47, -47, -48, -47, -47, -46, -47, -47, -47,
-47, -46, -46, -47, -47, -47, -47, -47, -46, -47, -47, -46, -47, -47, -46, -46,
-46, -47, -47, -46, -46, -46, -47, -46, -47, -47, -47, -46, -46, -47, -46, -46,
-46, -46, -47, -46, -46, -46, -46, -47, -46, -46, -45, -46, -46, -46, -46, -46,
-46, -45, -45, -46, -46, -46, -45, -46, -45, -45, -45, -46, -46, -45, -46, -46,
-45, -46, -46, -45, -45, -46, -45, -45, -45, -45, -45, -45, -45, -46, -45, -45,
-46, -45, -44, -45, -45, -45, -45, -44, -44, -46, -44, -46, -45, -46, -45, -46,
-45, -44, -46, -45, -45, -44, -44, -44, -45, -45, -45, -44, -45, -45, -45, -45,
-45, -45, -44, -45, -45, -44, -45, -45, -44, -45, -45, -45, -45, -45, -44, -44,
-44, -44, -44, -45, -45, -45, -45, -44, -45, -44, -44, -44, -45, -44, -44, -43,
-46, -43, -45, -42, -46, -40, -55, -111, -107, -108, -107, -107, -108, -106,
-107, -106, -108, -105, -109, -106, -109, -105, -109, -104, -110, -104, -110,
-102, -113, -90, };