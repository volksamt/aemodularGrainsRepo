#define DATA_LENGTH 512
#define DATA AKWF_1750

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 7, 8, 11, 12, 14, 15, 18, 19,
20, 23, 24, 25, 27, 28, 30, 32, 33, 35, 35, 38, 38, 41, 41, 43, 45, 45, 47, 48,
50, 52, 52, 53, 55, 57, 57, 58, 60, 61, 63, 64, 64, 66, 67, 69, 70, 70, 72, 74,
75, 75, 77, 78, 80, 80, 81, 82, 84, 84, 86, 87, 89, 89, 91, 91, 93, 94, 96, 95,
97, 98, 98, 101, 101, 103, 103, 105, 104, 108, 106, 109, 108, 111, 110, 113,
111, 116, 113, 120, 113, 124, 107, 13, 17, 19, 19, 23, 23, 26, 25, 30, 28, 32,
30, 35, 35, 38, 37, 41, 40, 43, 43, 46, 46, 48, 48, 51, 52, 53, 55, 54, 60, 54,
69, -9, -51, -35, -47, -40, -46, -42, -47, -45, -48, -47, -49, -49, -51, -52,
-53, -54, -55, -56, -56, -58, -58, -61, -60, -64, -63, -70, -65, -48, -44, -38,
-35, -31, -27, -26, -23, -20, -17, -14, -12, -10, -8, -6, -3, -1, 1, 2, 4, 6, 7,
10, 12, 13, 15, 17, 18, 19, 21, 23, 25, 26, 28, 29, 31, 32, 34, 35, 37, 38, 40,
41, 42, 42, 46, 46, 48, 49, 50, 52, 53, 54, 55, 58, 58, 61, 59, 64, 61, 67, 62,
70, 64, 73, 65, 80, 54, -54, -47, -51, -51, -51, -54, -53, -57, -55, -59, -57,
-62, -60, -64, -63, -68, -69, -52, -45, -42, -35, -33, -28, -26, -23, -20, -17,
-16, -13, -11, -9, -5, -9, -12, -12, -14, -14, -14, -14, -15, -16, -16, -17,
-18, -18, -19, -19, -20, -21, -22, -22, -22, -24, -24, -24, -25, -25, -27, -27,
-28, -28, -30, -30, -30, -32, -33, -33, -33, -34, -35, -36, -37, -36, -38, -39,
-39, -41, -41, -41, -42, -43, -44, -45, -46, -48, -48, -49, -49, -50, -50, -52,
-53, -55, -55, -56, -58, -58, -60, -62, -64, -64, -71, -56, -44, -42, -36, -34,
-29, -27, -23, -20, -18, -16, -13, -11, -8, -6, -4, -2, -1, 2, 3, 7, 6, 10, 9,
15, 8, -19, -16, -18, -19, -19, -21, -20, -21, -22, -23, -23, -23, -24, -26,
-26, -27, -27, -28, -29, -29, -30, -30, -32, -32, -34, -33, -35, -35, -36, -36,
-36, -42, 2, 16, 8, 13, 8, 12, 8, 10, 7, 8, 7, 7, 6, 6, 5, 5, 4, 4, 3, 3, 2, 2,
1, 0, 0, -1, -1, -2, -2, -3, -3, -4, -4, -6, -5, -6, -6, -7, -7, -9, -9, -9,
-10, -10, -12, -12, -12, -13, -13, -14, -15, -15, -16, -17, -17, -17, -18, -19,
-20, -21, -21, -21, -22, -22, -23, -24, -24, -26, -26, -27, -28, -29, -29, -29,
-30, -31, -31, -32, -32, -34, -35, -35, -36, -37, -37, -38, -39, -40, -41, -41,
-42, -43, -44, -44, -45, -46, -48, -48, -49, -50, -50, -52, -52, -54, -55, -56,
-56, -59, -59, -63, -61, -67, -67, -48, -43, -37, -34, -31, -27, -24, -21, -18,
-15, -14, -12, -9, -6, -6, -3, 0, };