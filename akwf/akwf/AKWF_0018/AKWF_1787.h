#define DATA_LENGTH 512
#define DATA AKWF_1787

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 14, 19, 21, 24, 25, 28, 29, 29,
29, 29, 28, 28, 27, 25, 23, 23, 19, 17, 14, 10, 7, 4, -1, -5, -9, -13, -18, -20,
-4, -5, -6, -6, -6, -7, -8, -8, -9, -8, -9, -7, -7, -7, -7, -7, -6, -5, -6, -4,
-4, -4, -2, -1, -1, 0, 0, 1, 2, 1, 2, 3, 3, 3, 3, 3, 4, 3, 3, 4, 4, 4, 3, 3, 3,
3, 3, 2, 3, 2, 2, 1, 0, 1, 1, 0, -1, 0, -1, -1, -2, -1, -2, -2, -2, -3, -3, -4,
-4, -3, -3, -3, -3, -3, -2, -1, -2, -1, -1, -1, -1, 0, 0, 1, 1, 1, 1, 2, 1, 2,
2, 2, 2, 2, 3, 3, 3, 2, 3, 3, 3, 2, 2, 2, 2, 2, 2, 2, 2, 0, 1, 2, 1, 1, 0, 0, 0,
0, 0, 0, 0, 0, -1, -1, -1, -1, -1, -1, -1, -1, -1, 0, -1, -1, -1, 0, 0, 0, -1,
0, 1, 0, 0, 1, 1, 1, 1, 2, 1, 2, 2, 2, 1, 1, 2, 1, 1, 2, 1, 1, 0, 0, 1, 0, 0, 0,
0, 1, 0, 0, -1, -1, -1, -1, -1, -1, 0, -2, -1, -1, -1, -1, -1, -2, -1, -1, -1,
-1, -1, -2, -3, -3, -2, -2, -1, -1, -2, -2, -3, -3, -3, -4, -5, -5, -5, -6, -6,
-7, -7, -7, -6, -7, -6, -6, -5, -5, -4, -3, -1, -1, 0, 0, 1, 3, 2, 3, 2, 3, 2,
1, 1, 0, -1, -2, -2, -3, -4, -4, -4, -5, -5, -4, -4, -4, -4, -4, -3, -3, -4, -3,
-3, -2, -2, -1, -2, -2, -2, -1, -1, -2, -2, -2, -2, -2, -1, -2, -2, -2, -1, -1,
-1, -1, -1, 0, 1, 1, 1, 1, 2, 1, 2, 1, 2, 1, 1, 2, 1, 2, 1, 1, 2, 2, 2, 2, 3, 3,
3, 4, 3, 4, 4, 4, 3, 3, 3, 3, 3, 3, 2, 2, 1, 1, 1, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0,
1, 0, 0, 1, 1, 2, 1, 2, 2, 2, 2, 3, 2, 2, 2, 3, 3, 2, 3, 2, 2, 3, 3, 3, 3, 3, 2,
3, 3, 3, 3, 3, 2, 3, 2, 2, 3, 4, 3, 4, 4, 5, 4, 5, 5, 4, 6, 5, 6, 6, 5, 5, 5, 6,
6, 4, 5, 5, 5, 5, 5, 6, 6, 6, 5, 5, 6, 6, 5, 6, 6, 6, 7, 6, 6, 6, 6, 6, 6, 6, 5,
5, 5, 4, 5, 5, 4, 4, 3, 4, 4, 4, 3, 3, 4, 4, 3, 2, 3, 3, 4, 3, 4, 4, 3, 2, 2, 2,
3, 2, 2, 1, 2, 2, 2, 1, 1, 1, 0, 0, -2, 0, -3, -2, -4, -5, -6, -6, -10, -10,
-12, -13, -15, -17, -18, -19, -17, -22, -12, -95, -128, -113, -120, -109, -110,
-99, -98, -87, -81, -71, -65, -54, -46, -37, -30, -22, -13, -6, 0, };