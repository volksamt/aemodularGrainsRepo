#define DATA_LENGTH 512
#define DATA AKWF_1744

const PROGMEM int8_t DATA[DATA_LENGTH] = {13, 32, 48, 63, 78, 89, 103, 112, 114,
114, 114, 115, 113, 114, 113, 114, 114, 114, 114, 113, 114, 114, 113, 114, 113,
114, 114, 113, 114, 114, 113, 113, 114, 113, 113, 114, 114, 114, 113, 114, 114,
113, 113, 113, 114, 114, 113, 113, 113, 113, 113, 113, 112, 108, 104, 101, 96,
93, 89, 85, 81, 77, 73, 70, 66, 62, 58, 54, 51, 48, 44, 40, 37, 34, 31, 27, 24,
22, 18, 15, 13, 10, 8, 6, 3, 0, -3, -5, -7, -10, -12, -14, -16, -18, -20, -22,
-24, -26, -28, -29, -30, -32, -33, -35, -37, -37, -39, -40, -41, -42, -44, -44,
-45, -45, -47, -48, -48, -49, -50, -50, -51, -51, -52, -52, -52, -53, -54, -54,
-54, -54, -54, -55, -55, -55, -54, -55, -55, -55, -56, -55, -54, -55, -54, -55,
-54, -54, -53, -54, -54, -54, -52, -52, -52, -51, -52, -51, -51, -50, -50, -50,
-49, -48, -48, -48, -47, -46, -46, -46, -46, -45, -45, -44, -43, -43, -42, -42,
-41, -40, -41, -40, -39, -38, -38, -37, -37, -36, -36, -36, -35, -35, -33, -33,
-33, -33, -31, -31, -31, -30, -29, -29, -28, -27, -26, -27, -26, -26, -25, -24,
-24, -23, -22, -23, -22, -21, -21, -21, -21, -20, -20, -18, -18, -18, -17, -17,
-16, -16, -15, -14, -15, -14, -13, -13, -13, -13, -13, -12, -12, -12, -11, -11,
-11, -10, -9, -8, -9, -9, -9, -7, -7, -7, -7, -7, -6, -6, -6, -5, -5, -5, -4,
-4, -4, -4, -3, -3, -4, -3, -3, -3, -2, -1, -2, -2, -2, -1, -1, 0, 0, -1, 0, 0,
-1, 0, 0, 0, 0, 1, 1, 1, 2, 2, 2, 1, 1, 2, 2, 1, 2, 1, 3, 3, 3, 3, 3, 2, 2, 3,
3, 2, 3, 3, 4, 4, 3, 3, 4, 3, 4, 4, 4, 3, 3, 3, 3, 3, 5, 4, 4, 4, 4, 4, 3, 4, 4,
4, 3, 4, 4, 4, 4, 3, 4, 4, 4, 3, 3, 3, 4, 4, 4, 4, 5, 3, 4, 4, 5, 5, 4, 4, 4, 4,
4, 4, 3, 4, 4, 4, 5, 4, 3, 3, 3, 3, 3, 3, 3, 4, 4, 3, 3, 3, 4, 3, 4, 3, 3, 3, 3,
3, 3, 3, 3, 3, 3, 3, 2, 2, 2, 3, 2, 3, 2, 2, 2, 2, 2, 3, 2, 2, 2, 2, 2, 2, 2, 2,
2, 1, 3, 2, 2, 1, 2, 2, 2, 2, 2, 1, 2, 1, 2, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1,
1, 1, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 1, 0, 0, 0, 1, -1, 1, -1, 1, 0, 0, -1, 0,
-1, 1, 0, 0, 0, 0, 1, 0, 0, 0, 1, -3, 2, -2, 0, -2, 1, -4, 5, -5, 4, -2, 2, -6,
11, -8, -119, -116, -120, -119, -119, -119, -118, -120, -119, -120, -118, -120,
-119, -119, -116, -96, -66, -49, -21, -6, };