#define DATA_LENGTH 512
#define DATA AKWF_1775

const PROGMEM int8_t DATA[DATA_LENGTH] = {15, 25, 28, 31, 33, 34, 36, 38, 38,
40, 41, 42, 42, 44, 44, 45, 46, 47, 47, 49, 48, 49, 49, 50, 51, 51, 52, 52, 54,
54, 54, 55, 55, 55, 55, 55, 56, 57, 58, 58, 58, 59, 59, 60, 61, 60, 61, 62, 61,
62, 61, 63, 63, 63, 63, 64, 64, 64, 65, 65, 65, 66, 67, 69, 69, 70, 72, 72, 73,
74, 75, 76, 77, 77, 78, 79, 80, 80, 81, 83, 83, 84, 84, 86, 87, 87, 88, 89, 90,
90, 91, 91, 92, 93, 94, 95, 95, 95, 96, 96, 98, 98, 98, 99, 100, 100, 101, 103,
103, 104, 104, 104, 105, 105, 106, 106, 108, 108, 108, 108, 109, 109, 110, 111,
111, 111, 111, 112, 112, 112, 113, 113, 114, 114, 115, 115, 115, 115, 115, 115,
116, 116, 116, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 118, 118, 118,
118, 119, 118, 119, 118, 118, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 118, 118, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119,
119, 119, 117, 116, 114, 113, 111, 109, 109, 107, 106, 105, 104, 102, 102, 100,
98, 98, 97, 95, 95, 93, 91, 90, 89, 88, 87, 85, 85, 84, 83, 81, 79, 79, 77, 76,
75, 74, 73, 72, 71, 69, 68, 67, 66, 64, 62, 62, 60, 58, 57, 56, 55, 53, 52, 50,
49, 47, 46, 44, 43, 39, 38, 34, 34, 27, 26, 11, -43, -53, -56, -61, -62, -65,
-66, -68, -69, -71, -72, -75, -75, -77, -77, -79, -80, -81, -83, -84, -84, -84,
-85, -86, -87, -88, -88, -89, -90, -90, -91, -91, -92, -92, -93, -94, -95, -95,
-95, -95, -96, -97, -97, -98, -98, -99, -99, -99, -100, -101, -101, -101, -102,
-102, -102, -102, -103, -104, -104, -105, -103, -104, -102, -103, -103, -102,
-102, -102, -101, -101, -102, -100, -100, -100, -99, -99, -99, -99, -99, -99,
-98, -97, -97, -97, -97, -96, -96, -96, -95, -95, -94, -94, -94, -94, -93, -92,
-93, -92, -92, -92, -91, -91, -91, -91, -91, -90, -89, -89, -89, -89, -88, -88,
-88, -88, -87, -88, -87, -88, -87, -87, -86, -87, -86, -85, -86, -86, -86, -85,
-85, -85, -85, -85, -84, -85, -84, -84, -84, -84, -84, -84, -83, -83, -83, -83,
-83, -82, -82, -83, -82, -82, -82, -82, -82, -82, -82, -81, -82, -81, -81, -82,
-81, -80, -81, -81, -80, -81, -81, -81, -81, -81, -81, -80, -81, -81, -80, -80,
-80, -81, -81, -81, -81, -80, -80, -81, -80, -81, -80, -80, -80, -82, -81, -81,
-81, -80, -81, -80, -80, -80, -79, -80, -80, -79, -80, -80, -79, -80, -79, -80,
-79, -79, -79, -79, -79, -79, -79, -79, -79, -78, -78, -79, -78, -77, -78, -77,
-77, -77, -77, -76, -77, -76, -76, -75, -75, -75, -75, -74, -73, -74, -73, -71,
-72, -70, -70, -70, -69, -67, -66, -65, -65, -62, -62, -58, -58, -52, -53, -34,
};