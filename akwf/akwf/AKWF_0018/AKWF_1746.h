#define DATA_LENGTH 512
#define DATA AKWF_1746

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 38, 71, 104, 117, 120, 118, 119,
119, 119, 119, 119, 120, 118, 120, 119, 119, 118, 119, 118, 119, 119, 119, 119,
119, 119, 119, 118, 119, 119, 120, 118, 119, 119, 119, 120, 118, 119, 119, 119,
119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 118,
119, 118, 119, 118, 119, 119, 119, 119, 118, 118, 118, 116, 110, 104, 98, 90,
84, 78, 71, 66, 60, 53, 48, 42, 37, 32, 27, 22, 16, 11, 7, 2, -2, -7, -11, -15,
-19, -23, -26, -30, -34, -38, -41, -45, -47, -50, -53, -55, -59, -61, -64, -65,
-69, -70, -72, -74, -75, -78, -79, -81, -82, -84, -84, -87, -87, -88, -89, -89,
-91, -92, -93, -93, -94, -94, -95, -95, -95, -96, -96, -95, -97, -96, -95, -96,
-96, -96, -95, -95, -96, -94, -95, -94, -93, -92, -93, -92, -91, -90, -90, -89,
-89, -88, -87, -86, -85, -85, -84, -83, -83, -82, -81, -80, -79, -79, -77, -76,
-75, -74, -73, -72, -70, -70, -70, -67, -67, -66, -64, -65, -63, -62, -61, -60,
-59, -58, -56, -56, -55, -53, -53, -52, -50, -49, -48, -47, -46, -45, -43, -43,
-42, -41, -40, -39, -38, -38, -36, -35, -34, -33, -32, -32, -31, -30, -29, -29,
-27, -26, -25, -25, -24, -24, -23, -21, -21, -19, -19, -19, -17, -17, -16, -15,
-14, -15, -13, -13, -12, -11, -11, -10, -9, -9, -8, -7, -7, -7, -6, -6, -4, -4,
-4, -3, -2, -2, -1, -2, 0, 0, 1, 1, 1, 2, 2, 2, 2, 3, 3, 4, 5, 5, 6, 5, 5, 6, 7,
7, 8, 8, 8, 8, 8, 8, 9, 9, 10, 10, 10, 10, 10, 11, 12, 10, 11, 12, 11, 12, 13,
12, 13, 13, 13, 13, 13, 14, 13, 13, 13, 13, 14, 14, 13, 14, 14, 14, 14, 14, 14,
14, 15, 14, 15, 14, 15, 15, 15, 15, 15, 15, 15, 15, 14, 15, 15, 16, 14, 16, 16,
15, 16, 14, 16, 15, 15, 14, 16, 14, 15, 14, 15, 15, 15, 16, 15, 15, 14, 16, 15,
14, 14, 15, 15, 15, 14, 14, 15, 14, 15, 14, 14, 15, 14, 14, 14, 14, 14, 14, 13,
13, 14, 14, 13, 13, 13, 13, 13, 13, 13, 13, 13, 13, 13, 13, 12, 13, 12, 12, 12,
12, 13, 13, 13, 12, 12, 11, 12, 11, 11, 11, 12, 12, 11, 12, 10, 11, 10, 11, 11,
11, 10, 10, 10, 9, 11, 10, 10, 11, 9, 9, 10, 10, 10, 9, 9, 10, 10, 9, 9, 9, 8,
10, 8, 9, 9, 8, 9, 8, 8, 8, 8, 8, 8, 7, 9, 9, 8, 7, 10, 7, 9, 7, 8, 8, 8, 6, 10,
5, 8, 8, 6, 7, 9, 6, 7, 8, 5, 9, 5, 8, 5, 9, -1, 15, -3, 13, 3, 11, -7, 32, -2,
-127, -105, -122, -110, -118, -112, -115, -115, -114, -114, -113, -116, -113,
-116, -113, -116, -111, -79, -27, };