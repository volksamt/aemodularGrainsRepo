#define DATA_LENGTH 512
#define DATA AKWF_1708

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 1, 2, 3, 3, 4, 4, 5, 6, 6, 7,
7, 9, 9, 9, 10, 11, 11, 11, 11, 13, 14, 14, 14, 15, 15, 16, 16, 16, 17, 17, 17,
18, 17, 18, 18, 18, 18, 19, 19, 19, 19, 18, 18, 17, 18, 17, 18, 17, 17, 16, 15,
16, 16, 14, 15, 14, 15, 15, 15, 14, 14, 14, 14, 15, 15, 16, 16, 17, 18, 19, 19,
21, 22, 23, 25, 27, 28, 30, 32, 34, 35, 38, 40, 42, 45, 47, 50, 53, 55, 58, 60,
63, 65, 68, 70, 74, 75, 79, 81, 84, 86, 88, 90, 93, 95, 96, 99, 100, 102, 104,
105, 105, 107, 108, 108, 108, 110, 110, 111, 110, 110, 111, 110, 110, 110, 109,
108, 107, 106, 104, 104, 101, 100, 98, 96, 94, 92, 90, 88, 86, 83, 80, 78, 74,
72, 70, 68, 63, 61, 58, 55, 52, 48, 46, 42, 39, 36, 34, 30, 28, 24, 22, 19, 15,
14, 10, 7, 5, 2, 0, -3, -5, -8, -10, -12, -15, -17, -18, -20, -22, -23, -25,
-26, -28, -29, -30, -31, -32, -33, -34, -34, -35, -37, -37, -37, -38, -38, -38,
-38, -39, -38, -39, -39, -39, -39, -38, -38, -38, -37, -37, -36, -36, -35, -35,
-34, -34, -32, -32, -32, -31, -31, -30, -29, -28, -28, -27, -27, -26, -26, -25,
-25, -25, -24, -23, -23, -23, -22, -22, -22, -22, -22, -22, -23, -23, -23, -23,
-23, -25, -25, -26, -27, -28, -30, -30, -32, -34, -35, -36, -39, -41, -42, -44,
-46, -49, -51, -52, -55, -57, -60, -62, -64, -67, -69, -70, -73, -76, -78, -81,
-83, -85, -88, -89, -93, -94, -97, -98, -100, -102, -104, -106, -107, -109,
-110, -111, -112, -114, -114, -116, -116, -117, -118, -118, -118, -118, -119,
-118, -119, -118, -118, -117, -117, -116, -115, -114, -113, -111, -109, -107,
-105, -103, -102, -98, -95, -93, -89, -86, -83, -79, -74, -72, -67, -62, -58,
-53, -49, -44, -39, -35, -29, -25, -20, -14, -9, -6, 0, 5, 9, 15, 19, 24, 30,
33, 38, 43, 47, 52, 56, 58, 63, 67, 71, 74, 77, 80, 83, 86, 88, 90, 92, 94, 96,
97, 99, 99, 99, 100, 100, 100, 100, 99, 99, 98, 98, 97, 95, 94, 92, 90, 89, 86,
84, 81, 79, 77, 73, 71, 68, 64, 61, 59, 54, 52, 48, 45, 42, 38, 35, 31, 27, 25,
22, 17, 14, 11, 7, 4, 1, -2, -5, -9, -12, -15, -16, -20, -23, -24, -28, -30,
-32, -35, -36, -39, -40, -41, -44, -45, -47, -47, -48, -49, -50, -51, -52, -52,
-53, -53, -53, -53, -53, -53, -53, -53, -52, -51, -50, -50, -50, -49, -47, -46,
-45, -43, -43, -42, -41, -39, -37, -37, -35, -34, -32, -32, -29, -29, -28, -26,
-25, -24, -22, -21, -20, -19, -18, -16, -15, -14, -13, -12, -12, -11, -11, -10,
-9, -8, -7, -7, -6, -6, -5, -5, -5, -3, -3, -3, -3, -2, -1, -1, 0, };