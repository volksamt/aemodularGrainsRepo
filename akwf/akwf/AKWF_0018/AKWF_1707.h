#define DATA_LENGTH 512
#define DATA AKWF_1707

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 20, 33, 38, 45, 50, 54, 57, 59, 60,
60, 60, 60, 59, 59, 59, 58, 58, 57, 57, 56, 55, 55, 54, 54, 54, 53, 52, 51, 51,
50, 49, 48, 48, 46, 45, 45, 45, 43, 42, 42, 41, 40, 40, 40, 38, 37, 37, 36, 35,
34, 33, 32, 31, 29, 28, 27, 26, 23, 23, 34, 61, 84, 97, 103, 108, 111, 114, 116,
118, 119, 119, 118, 117, 116, 114, 113, 112, 110, 109, 107, 106, 104, 103, 102,
100, 99, 96, 95, 94, 92, 90, 90, 87, 85, 83, 82, 81, 78, 76, 74, 72, 70, 69, 67,
65, 63, 61, 59, 56, 55, 54, 51, 50, 48, 46, 45, 43, 41, 39, 38, 37, 34, 32, 31,
29, 28, 26, 26, 25, 23, 22, 19, 17, 16, 15, 13, 11, 10, 8, 6, 4, 3, 2, 1, 0, -1,
-2, -3, -5, -5, 11, 35, 53, 62, 67, 71, 73, 76, 78, 78, 78, 78, 77, 76, 74, 73,
72, 69, 69, 66, 65, 64, 62, 61, 59, 58, 56, 54, 53, 52, 50, 48, 48, 46, 45, 44,
42, 41, 41, 39, 39, 38, 37, 36, 36, 34, 32, 31, 29, 28, 27, 26, 24, 22, 21, 19,
18, 16, 15, 13, 12, 10, 9, 7, 6, 6, 5, 4, 2, 0, -1, -1, -3, -3, -5, -7, -7, -9,
-10, -12, -13, -15, -17, -18, -20, -22, -23, -25, -26, -28, -30, -32, -34, -35,
-37, -38, -42, -43, -44, -46, -47, -49, -50, -52, -54, -55, -55, -56, -56, -58,
-59, -60, -60, -62, -62, -63, -64, -65, -66, -68, -67, -69, -70, -72, -72, -73,
-75, -76, -78, -78, -79, -80, -82, -84, -84, -85, -87, -88, -89, -90, -90, -92,
-93, -94, -94, -95, -96, -97, -98, -99, -99, -100, -100, -101, -101, -102, -102,
-104, -104, -104, -105, -106, -107, -106, -95, -82, -71, -57, -40, -28, -20,
-15, -11, -8, -6, -4, -3, -3, -3, -4, -3, -4, -5, -6, -6, -7, -7, -8, -7, -8,
-8, -10, -10, -10, -11, -11, -11, -13, -13, -14, -15, -15, -16, -17, -18, -19,
-20, -21, -21, -22, -24, -24, -26, -28, -27, -29, -31, -32, -33, -34, -36, -37,
-38, -40, -40, -42, -43, -44, -45, -47, -47, -49, -50, -51, -52, -52, -53, -54,
-55, -57, -57, -59, -60, -62, -63, -64, -65, -66, -68, -68, -68, -70, -71, -73,
-71, -67, -53, -29, -11, -1, 5, 9, 12, 14, 16, 17, 18, 18, 17, 16, 15, 14, 14,
12, 11, 11, 9, 8, 9, 7, 6, 5, 4, 4, 2, 2, 1, 1, 0, -1, -2, -3, -4, -3, -3, -5,
-5, -6, -5, -7, -6, -8, -10, -11, -11, -13, -14, -15, -16, -18, -19, -21, -22,
-22, -25, -25, -27, -27, -28, -29, -31, -32, -33, -34, -35, -35, -36, -37, -39,
-39, -40, -42, -43, -44, -45, -47, -48, -49, -50, -51, -52, -54, -56, -57, -59,
-59, -61, -62, -62, -64, -64, -66, -67, -69, -70, -71, -72, -73, -75, -63, -24,
};