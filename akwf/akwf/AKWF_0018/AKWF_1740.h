#define DATA_LENGTH 512
#define DATA AKWF_1740

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 3, 3, 5, 6, 6, 7, 8, 9, 10,
9, 11, 11, 12, 13, 13, 14, 14, 15, 15, 15, 17, 16, 17, 17, 18, 18, 18, 18, 19,
19, 19, 20, 20, 20, 21, 21, 20, 21, 22, 22, 21, 22, 22, 22, 23, 22, 22, 23, 22,
23, 22, 22, 23, 23, 22, 23, 22, 23, 22, 23, 23, 22, 23, 23, 23, 22, 23, 23, 23,
23, 22, 22, 23, 22, 22, 23, 23, 23, 22, 22, 22, 22, 23, 21, 21, 22, 21, 21, 22,
22, 21, 21, 21, 21, 21, 21, 21, 21, 21, 20, 20, 20, 20, 20, 19, 19, 20, 19, 19,
19, 19, 19, 19, 19, 19, 18, 18, 18, 18, 18, 18, 19, 18, 18, 18, 18, 18, 17, 17,
17, 18, 17, 16, 17, 17, 17, 17, 16, 17, 17, 17, 16, 15, 15, 16, 16, 16, 15, 16,
15, 16, 16, 15, 16, 15, 15, 15, 15, 15, 15, 15, 15, 15, 14, 15, 15, 14, 14, 15,
14, 14, 15, 15, 15, 14, 15, 14, 14, 14, 15, 15, 14, 15, 14, 14, 14, 14, 14, 15,
14, 14, 15, 14, 15, 14, 14, 14, 15, 15, 14, 14, 14, 14, 15, 14, 14, 14, 14, 15,
14, 14, 14, 14, 15, 15, 15, 15, 15, 15, 15, 15, 15, 15, 15, 15, 15, 15, 16, 15,
16, 15, 15, 16, 16, 16, 16, 16, 15, 16, 15, 16, 16, 16, 16, 17, 17, 17, 17, 17,
17, 17, 17, 18, 17, 17, 17, 17, 18, 18, 17, 18, 18, 18, 19, 19, 18, 18, 18, 18,
19, 19, 19, 19, 18, 20, 19, 19, 20, 20, 20, 20, 20, 20, 20, 21, 21, 21, 20, 20,
21, 21, 20, 21, 20, 21, 21, 21, 22, 21, 21, 21, 21, 22, 21, 22, 21, 22, 21, 21,
22, 21, 22, 22, 22, 22, 22, 22, 21, 22, 21, 21, 21, 22, 22, 21, 22, 22, 22, 21,
21, 22, 21, 21, 21, 21, 20, 20, 20, 20, 20, 20, 19, 19, 19, 18, 18, 18, 18, 18,
18, 17, 16, 17, 16, 15, 15, 15, 14, 14, 13, 13, 12, 12, 11, 11, 11, 10, 9, 8, 7,
7, 6, 5, 5, 4, 3, 2, 1, 1, 0, -2, -2, -4, -4, -5, -6, -7, -9, -9, -11, -12, -13,
-15, -16, -17, -18, -20, -22, -22, -25, -26, -28, -29, -31, -32, -34, -36, -37,
-39, -40, -43, -45, -47, -49, -50, -53, -55, -56, -59, -61, -63, -64, -67, -70,
-72, -74, -76, -79, -81, -83, -85, -88, -89, -92, -94, -98, -100, -101, -104,
-106, -109, -111, -114, -117, -119, -118, -115, -113, -110, -108, -106, -102,
-101, -98, -95, -93, -91, -88, -87, -83, -82, -79, -77, -74, -73, -70, -68, -66,
-63, -61, -60, -57, -55, -52, -51, -48, -46, -45, -44, -41, -39, -38, -36, -33,
-32, -31, -29, -27, -26, -23, -22, -21, -20, -18, -17, -16, -15, -13, -11, -11,
-10, -8, -7, -5, -4, -4, -3, -1, 0, };