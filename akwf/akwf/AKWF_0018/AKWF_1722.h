#define DATA_LENGTH 512
#define DATA AKWF_1722

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 125, 115, 121, 115, 120, 115,
119, 115, 118, 115, 117, 115, 117, 115, 116, 114, 115, 114, 113, 113, 114, 113,
113, 113, 112, 112, 111, 112, 111, 111, 110, 111, 109, 109, 109, 108, 108, 109,
107, 108, 107, 107, 106, 106, 106, 106, 104, 105, 104, 104, 104, 104, 103, 103,
103, 102, 101, 101, 101, 101, 100, 99, 100, 99, 99, 99, 98, 97, 96, 96, 96, 95,
95, 95, 95, 94, 94, 93, 93, 92, 92, 92, 91, 90, 90, 90, 89, 89, 89, 87, 87, 87,
86, 85, 84, 85, 84, 82, 83, 82, 82, 81, 80, 80, 80, 78, 78, 78, 77, 77, 76, 75,
75, 73, 72, 72, 71, 71, 69, 69, 68, 68, 67, 66, 65, 65, 64, 64, 63, 62, 61, 60,
60, 58, 57, 57, 56, 55, 54, 53, 53, 51, 50, 49, 49, 48, 46, 46, 45, 44, 42, 42,
40, 39, 39, 37, 37, 35, 34, 33, 32, 31, 30, 29, 27, 27, 25, 24, 23, 22, 21, 19,
17, 17, 15, 13, 12, 12, 10, 9, 7, 6, 5, 4, 1, 0, -1, -3, -4, -5, -6, -8, -10,
-12, -12, -14, -16, -18, -19, -20, -22, -24, -25, -27, -28, -29, -31, -33, -35,
-36, -38, -40, -42, -43, -44, -46, -49, -49, -51, -53, -55, -56, -58, -59, -62,
-62, -65, -66, -68, -70, -71, -73, -75, -77, -79, -80, -82, -83, -83, -83, -84,
-83, -84, -84, -84, -84, -83, -83, -83, -83, -83, -83, -83, -84, -84, -83, -83,
-83, -83, -82, -83, -83, -83, -83, -82, -83, -83, -83, -84, -83, -83, -82, -81,
-79, -79, -78, -77, -77, -75, -74, -74, -73, -71, -70, -69, -68, -67, -67, -66,
-65, -65, -63, -63, -61, -61, -60, -58, -58, -57, -56, -54, -54, -53, -53, -52,
-52, -50, -49, -48, -48, -47, -47, -45, -44, -43, -43, -42, -42, -41, -40, -39,
-38, -39, -38, -37, -36, -36, -35, -35, -34, -33, -33, -32, -31, -31, -30, -31,
-30, -30, -29, -28, -28, -28, -28, -27, -27, -26, -26, -26, -25, -24, -24, -24,
-24, -24, -23, -23, -22, -22, -23, -22, -22, -22, -21, -21, -21, -21, -21, -20,
-21, -21, -20, -21, -21, -20, -21, -20, -21, -20, -21, -20, -20, -21, -20, -20,
-20, -20, -20, -20, -21, -20, -20, -21, -22, -21, -21, -22, -21, -21, -22, -22,
-22, -23, -22, -23, -23, -23, -23, -23, -24, -24, -25, -25, -24, -25, -25, -26,
-25, -26, -27, -26, -27, -27, -27, -27, -28, -29, -30, -29, -30, -30, -31, -30,
-31, -31, -32, -31, -33, -32, -34, -33, -34, -34, -35, -35, -36, -36, -37, -37,
-37, -37, -38, -38, -39, -40, -40, -40, -41, -41, -41, -41, -42, -42, -42, -44,
-44, -45, -45, -46, -46, -47, -47, -48, -48, -48, -49, -49, -50, -51, -50, -52,
-52, -53, -52, -53, -54, -54, -54, -56, -56, -56, -56, -57, -58, -59, -59, -59,
-60, -60, -61, -60, -63, -61, -64, -62, -66, -63, -69, -61, -84, -69, };