#define DATA_LENGTH 512
#define DATA AKWF_1748

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 14, 21, 29, 35, 43, 49, 56, 62, 69,
74, 79, 84, 89, 93, 98, 101, 105, 109, 111, 113, 115, 116, 117, 119, 119, 119,
118, 119, 117, 117, 115, 113, 110, 108, 106, 103, 100, 97, 94, 90, 87, 82, 79,
75, 71, 67, 62, 58, 54, 49, 45, 40, 37, 33, 28, 23, 20, 15, 12, 9, 5, 1, -3, -6,
-10, -12, -15, -18, -20, -23, -25, -27, -29, -31, -33, -34, -36, -36, -38, -39,
-40, -41, -41, -41, -41, -42, -41, -41, -41, -41, -41, -41, -39, -38, -37, -37,
-36, -34, -34, -33, -32, -30, -30, -28, -27, -25, -25, -23, -22, -20, -19, -18,
-17, -15, -14, -12, -11, -10, -10, -8, -7, -6, -5, -3, -4, -3, -1, -1, 0, 2, 2,
2, 3, 4, 5, 5, 6, 5, 6, 6, 7, 7, 6, 7, 7, 7, 8, 7, 7, 8, 8, 8, 6, 6, 6, 7, 7, 7,
6, 6, 5, 6, 6, 5, 5, 4, 4, 4, 4, 3, 3, 2, 2, 3, 1, 1, 1, 1, 1, 0, 0, 0, 0, -1,
-1, -1, -1, -1, -1, -3, -2, -2, -2, -3, -3, -2, -4, -3, -4, -3, -3, -3, -4, -3,
-3, -3, -3, -3, -3, -3, -4, -3, -4, -3, -4, -4, -4, -4, -3, -3, -4, -3, -3, -4,
-3, -3, -3, -3, -3, -2, -2, -3, -3, -3, -2, -2, -2, -2, -2, -1, -1, -2, -2, -2,
-2, -1, -1, -2, -1, -1, -1, -1, 0, -1, -1, -2, -1, -1, -1, -1, -1, -1, -1, -1,
-1, 0, -1, -1, -1, -1, -1, -1, -1, 0, -1, 0, 0, 0, -1, -1, -1, 0, -1, -1, -1, 0,
-1, 0, 0, 0, -1, -1, -1, -1, 0, -1, -1, -1, -1, -1, 0, 0, -1, -1, -1, 0, -1, 0,
0, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, 0, -1, -1, -2, 0, -1, -1, 0, -1, -1,
-1, -1, 0, -1, -1, -1, 0, -1, -1, -1, -1, 0, -1, -1, 0, -1, -1, -2, -1, -1, -1,
-1, -1, 0, 0, -1, 0, -1, 0, -1, 0, 0, 0, -1, -1, -1, -1, -1, 0, -1, -1, -1, 0,
-1, 0, -1, -1, 0, 0, -1, 0, -1, 0, 0, -1, -1, 0, -1, -1, -1, -1, -1, 0, -1, -1,
0, -1, -1, -1, -1, -1, -1, 0, 0, 0, 0, -1, -1, 0, -1, -1, 0, 0, 0, 0, 0, -1, -1,
0, 0, 0, 0, 0, -1, 0, -1, 0, -1, 0, 0, -1, -1, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0,
0, -1, -1, 0, -1, -1, 0, 0, 0, 0, 0, 0, -1, -1, 0, -1, 0, 0, 0, -1, -1, -1, -1,
-1, -2, -5, -9, -13, -19, -23, -30, -36, -42, -48, -55, -62, -68, -74, -79, -84,
-90, -93, -97, -100, -102, -104, -106, -106, -107, -105, -104, -103, -101, -97,
-94, -90, -86, -81, -75, -70, -64, -57, -51, -45, -38, -31, -23, -16, -9, -1, };