#define DATA_LENGTH 512
#define DATA AKWF_1800

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 3, 3, 5, 5, 5, 6, 7, 7, 7, 8,
8, 9, 10, 10, 10, 11, 11, 10, 11, 11, 11, 11, 10, 11, 10, 11, 11, 10, 10, 11,
10, 11, 11, 11, 12, 12, 13, 13, 14, 15, 17, 17, 19, 19, 22, 21, 23, 25, 26, 27,
29, 30, 32, 34, 36, 38, 39, 42, 45, 47, 48, 51, 53, 56, 58, 60, 62, 63, 65, 67,
68, 70, 72, 73, 75, 76, 77, 79, 80, 80, 82, 83, 84, 85, 85, 86, 86, 86, 87, 88,
88, 89, 90, 91, 91, 92, 93, 95, 96, 98, 100, 101, 103, 105, 107, 109, 110, 111,
113, 114, 113, 115, 114, 115, 116, 115, 115, 116, 116, 116, 115, 117, 116, 116,
117, 117, 118, 116, 115, 115, 113, 112, 112, 111, 109, 109, 107, 107, 107, 106,
105, 104, 103, 102, 101, 100, 99, 99, 98, 97, 97, 96, 96, 95, 95, 94, 94, 93,
93, 93, 92, 92, 93, 93, 93, 92, 93, 93, 93, 92, 92, 91, 90, 89, 87, 86, 84, 84,
81, 80, 79, 77, 76, 76, 75, 75, 73, 72, 71, 70, 69, 68, 68, 67, 66, 66, 64, 63,
63, 62, 60, 59, 58, 57, 55, 54, 53, 51, 50, 48, 48, 47, 46, 45, 43, 42, 41, 40,
39, 37, 37, 35, 35, 34, 33, 32, 32, 30, 30, 29, 29, 28, 27, 24, 24, 23, 21, 20,
19, 17, 16, 14, 13, 12, 10, 9, 7, 6, 5, 3, 3, 1, 1, 0, -1, -2, -2, -3, -4, -4,
-6, -6, -7, -7, -7, -8, -8, -9, -9, -9, -10, -9, -11, -10, -11, -10, -10, -10,
-10, -10, -9, -9, -10, -9, -10, -10, -10, -10, -9, -11, -12, -11, -12, -13, -15,
-15, -16, -18, -18, -20, -21, -22, -23, -24, -26, -27, -29, -30, -32, -35, -37,
-39, -40, -43, -46, -47, -51, -52, -54, -56, -59, -62, -63, -65, -66, -68, -70,
-72, -74, -76, -77, -78, -80, -81, -83, -83, -85, -86, -87, -88, -88, -89, -89,
-90, -91, -91, -92, -93, -92, -94, -95, -95, -97, -98, -100, -102, -104, -104,
-107, -108, -110, -112, -114, -115, -117, -118, -118, -118, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -118, -118, -118, -119, -118, -119, -117,
-117, -115, -113, -113, -112, -112, -110, -109, -108, -108, -107, -106, -105,
-103, -103, -101, -101, -99, -99, -97, -97, -97, -95, -94, -94, -92, -92, -91,
-90, -90, -89, -89, -88, -88, -89, -89, -89, -88, -89, -89, -88, -88, -88, -87,
-87, -86, -83, -82, -81, -79, -78, -77, -76, -75, -74, -72, -73, -72, -70, -69,
-68, -67, -67, -66, -65, -64, -64, -63, -62, -61, -61, -59, -59, -57, -56, -55,
-54, -53, -51, -50, -49, -48, -47, -47, -45, -44, -42, -41, -41, -40, -38, -37,
-37, -35, -34, -34, -33, -32, -31, -31, -30, -29, -29, -28, -27, -26, -24, -23,
-22, -20, -18, -17, -15, -14, -12, -11, -10, -8, -7, -6, -6, -4, -2, -2, 0, };