#define DATA_LENGTH 512
#define DATA AKWF_1779

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 8, 12, 16, 20, 23, 27, 29, 31, 34,
36, 38, 40, 43, 45, 46, 48, 49, 51, 53, 54, 54, 57, 58, 59, 60, 61, 62, 63, 64,
64, 65, 67, 67, 69, 69, 70, 71, 71, 72, 72, 74, 74, 74, 75, 75, 76, 77, 77, 78,
79, 79, 79, 81, 80, 81, 81, 81, 81, 83, 82, 83, 83, 83, 85, 84, 85, 85, 85, 86,
85, 86, 87, 86, 87, 86, 88, 87, 88, 87, 88, 88, 88, 89, 89, 89, 90, 89, 88, 89,
89, 89, 89, 89, 89, 90, 90, 90, 90, 90, 90, 91, 90, 90, 91, 90, 90, 91, 91, 91,
90, 91, 90, 91, 89, 91, 89, 94, 109, 109, 111, 111, 112, 113, 114, 114, 114,
114, 114, 115, 115, 115, 115, 116, 116, 117, 116, 116, 117, 117, 117, 117, 117,
117, 118, 118, 117, 118, 117, 118, 118, 118, 118, 119, 118, 118, 119, 119, 118,
119, 118, 118, 118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 118,
118, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119,
119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120, 118, 118, 119,
119, 120, 118, 118, 120, 119, 118, 118, 119, 119, 119, 120, 118, 119, 119, 120,
118, 120, 118, 119, 117, 119, 118, 119, 117, 119, 118, 118, 119, 117, 119, 116,
120, 115, 122, 113, 124, 109, 127, 56, -74, -80, -90, -77, -78, -71, -71, -67,
-68, -66, -64, -65, -63, -64, -62, -63, -62, -64, -61, -63, -62, -63, -62, -63,
-61, -62, -62, -63, -63, -64, -64, -64, -65, -64, -65, -65, -66, -66, -66, -67,
-66, -67, -67, -67, -68, -69, -69, -69, -70, -70, -69, -69, -71, -71, -71, -72,
-72, -71, -72, -72, -73, -72, -72, -73, -73, -73, -74, -75, -74, -74, -75, -76,
-75, -75, -75, -76, -75, -76, -76, -77, -77, -77, -77, -77, -77, -78, -78, -78,
-79, -78, -79, -79, -78, -79, -80, -79, -80, -80, -79, -79, -79, -80, -80, -80,
-80, -80, -80, -80, -80, -79, -81, -80, -80, -79, -81, -80, -80, -80, -81, -80,
-81, -80, -80, -80, -81, -78, -85, -99, -99, -101, -101, -103, -104, -103, -105,
-106, -106, -106, -106, -107, -107, -108, -107, -107, -108, -109, -109, -109,
-109, -109, -109, -109, -109, -109, -109, -110, -111, -110, -111, -111, -111,
-111, -110, -111, -110, -112, -111, -111, -112, -111, -111, -111, -112, -111,
-112, -112, -112, -112, -112, -112, -113, -112, -111, -112, -112, -112, -112,
-112, -112, -112, -112, -112, -112, -112, -112, -112, -112, -113, -112, -113,
-112, -112, -112, -113, -113, -112, -112, -112, -113, -113, -112, -113, -112,
-113, -113, -113, -113, -113, -112, -113, -113, -113, -112, -112, -112, -113,
-112, -112, -112, -113, -113, -113, -112, -112, -112, -112, -112, -112, -112,
-112, -113, -111, -113, -111, -113, -111, -112, -111, -113, -110, -114, -109,
-116, -101, -66, -85, -76, -59, -46, -35, -27, -18, -12, -5, -1, };