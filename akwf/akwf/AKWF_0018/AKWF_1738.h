#define DATA_LENGTH 512
#define DATA AKWF_1738

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 14, 26, 37, 48, 59, 72, 81, 94,
104, 116, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 120, 119, 119,
119, 119, 118, 119, 119, 120, 118, 118, 119, 119, 119, 119, 118, 118, 119, 118,
118, 119, 119, 118, 118, 119, 118, 119, 119, 118, 118, 119, 119, 118, 118, 118,
118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 119, 119, 118, 118, 118, 119,
119, 119, 118, 117, 118, 118, 118, 118, 118, 118, 118, 118, 119, 117, 118, 118,
118, 118, 118, 117, 118, 118, 118, 118, 118, 117, 118, 117, 117, 118, 117, 118,
117, 118, 118, 117, 118, 117, 117, 118, 118, 118, 117, 118, 118, 117, 118, 117,
117, 118, 118, 117, 116, 118, 118, 118, 117, 117, 117, 117, 117, 117, 118, 118,
117, 117, 117, 116, 118, 117, 117, 117, 117, 118, 117, 116, 117, 116, 116, 117,
117, 117, 117, 117, 117, 117, 116, 117, 117, 116, 117, 116, 116, 116, 117, 117,
117, 116, 116, 117, 117, 116, 116, 116, 117, 117, 116, 117, 116, 116, 117, 117,
116, 116, 116, 116, 117, 116, 116, 117, 117, 117, 116, 117, 116, 116, 116, 116,
115, 116, 116, 116, 116, 116, 115, 117, 116, 116, 117, 116, 115, 116, 116, 116,
116, 115, 116, 115, 116, 116, 116, 116, 116, 116, 116, 115, 116, 110, 98, 87,
75, 64, 53, 42, 30, 19, 8, -4, -15, -27, -37, -48, -60, -71, -82, -94, -104,
-116, -120, -119, -119, -120, -119, -118, -119, -119, -119, -118, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -118, -118, -118, -119, -118, -119, -119, -120, -119, -119, -119,
-118, -118, -118, -118, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-118, -118, -118, -118, -119, -118, -118, -118, -118, -118, -118, -119, -119,
-117, -118, -119, -118, -119, -118, -118, -117, -118, -118, -118, -118, -118,
-117, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118,
-118, -118, -118, -117, -118, -118, -118, -118, -117, -118, -118, -118, -117,
-117, -117, -118, -118, -117, -117, -118, -118, -118, -117, -118, -117, -117,
-117, -117, -117, -118, -117, -117, -118, -117, -118, -117, -117, -118, -118,
-117, -117, -117, -117, -118, -117, -117, -117, -117, -117, -117, -117, -117,
-117, -117, -117, -116, -117, -117, -117, -117, -117, -117, -117, -117, -117,
-117, -116, -117, -117, -118, -117, -117, -116, -117, -117, -117, -117, -117,
-117, -117, -117, -116, -117, -117, -116, -116, -116, -117, -116, -117, -117,
-116, -117, -116, -117, -116, -116, -116, -116, -116, -116, -116, -116, -116,
-116, -116, -117, -115, -116, -116, -116, -116, -116, -116, -116, -116, -116,
-117, -116, -116, -117, -116, -116, -116, -116, -116, -116, -116, -116, -115,
-115, -116, -116, -116, -115, -116, -116, -116, -116, -116, -116, -116, -116,
-116, -116, -110, -98, -86, -75, -64, -52, -41, -30, -20, -7, };