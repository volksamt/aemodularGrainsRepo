#define DATA_LENGTH 512
#define DATA AKWF_1712

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 6, 8, 10, 11, 14, 16, 18, 20,
23, 25, 28, 31, 33, 35, 37, 37, 40, 41, 43, 45, 47, 48, 50, 51, 53, 56, 57, 59,
61, 61, 62, 61, 60, 60, 59, 58, 59, 60, 59, 59, 60, 60, 62, 62, 64, 64, 65, 66,
66, 68, 67, 68, 69, 68, 68, 68, 68, 66, 65, 64, 63, 63, 61, 60, 58, 57, 55, 53,
50, 48, 47, 46, 44, 43, 40, 38, 36, 33, 30, 29, 27, 26, 22, 22, 20, 20, 19, 18,
19, 17, 18, 17, 17, 19, 18, 18, 19, 19, 18, 18, 20, 21, 21, 23, 25, 26, 27, 28,
30, 32, 32, 34, 35, 36, 38, 39, 40, 41, 42, 42, 45, 46, 48, 50, 51, 52, 54, 56,
58, 59, 61, 64, 67, 70, 73, 77, 79, 82, 86, 88, 90, 92, 97, 99, 102, 104, 105,
105, 107, 108, 109, 109, 111, 111, 112, 112, 112, 112, 112, 113, 112, 114, 113,
114, 115, 115, 114, 114, 114, 115, 115, 115, 114, 112, 112, 110, 109, 109, 107,
106, 105, 104, 104, 102, 101, 102, 100, 100, 100, 99, 99, 97, 97, 95, 94, 93,
92, 91, 90, 89, 88, 87, 86, 84, 83, 80, 80, 79, 76, 75, 72, 70, 68, 65, 62, 61,
58, 55, 52, 48, 45, 42, 40, 36, 33, 30, 30, 26, 26, 23, 21, 19, 18, 17, 16, 15,
12, 11, 9, 8, 8, 6, 5, 4, 4, 4, 4, 4, 5, 6, 6, 7, 7, 8, 8, 8, 8, 10, 8, 8, 8, 7,
5, 4, 3, 2, 1, 0, -1, -2, -3, -4, -6, -8, -10, -12, -13, -16, -19, -21, -24,
-27, -29, -33, -36, -39, -42, -44, -46, -49, -51, -53, -55, -58, -60, -62, -64,
-65, -66, -68, -70, -70, -72, -74, -75, -77, -78, -80, -81, -82, -83, -85, -87,
-88, -89, -90, -90, -91, -91, -92, -93, -95, -97, -99, -102, -102, -103, -106,
-107, -110, -110, -111, -113, -112, -113, -113, -114, -114, -114, -115, -116,
-116, -116, -116, -116, -116, -117, -117, -119, -119, -119, -119, -117, -116,
-116, -116, -115, -114, -112, -110, -108, -106, -103, -100, -98, -95, -93, -89,
-86, -84, -81, -79, -76, -74, -72, -71, -69, -68, -65, -63, -62, -60, -58, -56,
-55, -54, -52, -52, -50, -48, -47, -45, -44, -41, -39, -36, -35, -33, -31, -30,
-28, -27, -25, -24, -23, -22, -22, -21, -21, -19, -17, -17, -17, -17, -16, -16,
-17, -17, -18, -19, -21, -22, -23, -25, -26, -28, -30, -33, -35, -37, -39, -40,
-41, -43, -45, -47, -49, -50, -53, -54, -55, -56, -58, -60, -60, -62, -62, -62,
-63, -63, -64, -64, -65, -65, -64, -64, -64, -63, -62, -61, -62, -61, -61, -61,
-62, -63, -64, -65, -65, -67, -67, -69, -69, -69, -68, -67, -65, -64, -63, -61,
-61, -61, -60, -60, -59, -56, -56, -54, -52, -50, -48, -46, -43, -42, -39, -38,
-36, -34, -33, -32, -30, -28, -25, -22, -19, -16, -13, -9, -4, -2, };