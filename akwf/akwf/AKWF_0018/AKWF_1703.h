#define DATA_LENGTH 512
#define DATA AKWF_1703

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 13, 17, 21, 25, 29, 32, 35,
38, 41, 43, 45, 47, 49, 51, 52, 54, 55, 56, 58, 59, 61, 62, 64, 66, 67, 69, 70,
71, 73, 74, 75, 77, 78, 80, 82, 85, 87, 90, 92, 95, 96, 98, 99, 102, 102, 101,
102, 103, 102, 102, 103, 103, 104, 104, 105, 105, 106, 106, 106, 107, 106, 106,
105, 104, 102, 101, 98, 97, 94, 91, 88, 85, 83, 80, 78, 75, 73, 71, 67, 66, 63,
60, 57, 53, 51, 47, 44, 41, 38, 36, 32, 30, 27, 24, 23, 20, 17, 15, 13, 11, 8,
7, 4, 2, -1, -3, -5, -6, -7, -7, -7, -7, -7, -6, -4, -3, -3, -1, -2, 0, 1, 1, 1,
2, 3, 3, 4, 4, 5, 4, 5, 6, 6, 5, 5, 4, 4, 4, 4, 4, 5, 5, 7, 8, 10, 12, 12, 13,
15, 17, 18, 20, 20, 21, 22, 23, 22, 22, 21, 20, 20, 18, 17, 16, 15, 13, 13, 11,
10, 11, 10, 10, 9, 10, 9, 9, 10, 10, 12, 12, 14, 15, 16, 18, 20, 21, 23, 25, 26,
28, 29, 30, 32, 33, 35, 34, 35, 35, 33, 33, 30, 30, 27, 24, 23, 22, 21, 20, 19,
19, 19, 19, 19, 20, 20, 22, 22, 23, 24, 26, 27, 28, 31, 32, 35, 38, 40, 43, 45,
47, 48, 50, 52, 53, 55, 56, 57, 59, 61, 61, 62, 63, 64, 64, 66, 65, 67, 67, 67,
68, 69, 70, 71, 73, 76, 78, 81, 84, 86, 87, 90, 91, 91, 92, 90, 90, 88, 88, 87,
85, 83, 82, 79, 77, 75, 73, 70, 69, 67, 64, 62, 60, 59, 56, 54, 52, 50, 48, 46,
43, 40, 38, 35, 32, 29, 24, 20, 16, 10, 6, 0, -7, -13, -18, -24, -29, -34, -38,
-42, -44, -47, -49, -52, -55, -58, -62, -64, -66, -70, -73, -77, -80, -84, -87,
-91, -94, -99, -101, -104, -106, -108, -110, -112, -113, -115, -116, -117, -117,
-119, -118, -119, -119, -118, -119, -118, -119, -119, -118, -117, -116, -115,
-115, -114, -113, -112, -113, -112, -112, -112, -111, -110, -110, -109, -108,
-106, -104, -103, -100, -98, -97, -94, -92, -90, -88, -86, -85, -84, -82, -81,
-80, -80, -79, -76, -76, -73, -72, -71, -70, -70, -70, -70, -70, -68, -67, -66,
-66, -64, -64, -62, -62, -61, -60, -60, -60, -59, -60, -59, -60, -60, -60, -60,
-61, -61, -62, -63, -63, -64, -65, -66, -66, -66, -67, -67, -67, -68, -67, -69,
-68, -69, -69, -69, -69, -68, -68, -67, -67, -67, -66, -66, -66, -65, -65, -63,
-62, -61, -60, -60, -58, -56, -56, -55, -54, -53, -52, -52, -51, -50, -50, -48,
-47, -46, -45, -43, -42, -40, -39, -36, -34, -32, -30, -28, -26, -24, -23, -22,
-22, -19, -19, -17, -17, -16, -16, -16, -16, -16, -16, -16, -17, -17, -17, -16,
-16, -15, -16, -16, -14, -15, -13, -13, -12, -11, -10, -9, -7, -6, -7, -5, -3,
-1, };