#define DATA_LENGTH 512
#define DATA AKWF_1798

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 5, 5, 7, 8, 9, 10, 12, 13,
14, 16, 16, 18, 19, 20, 20, 23, 24, 25, 25, 26, 27, 28, 28, 30, 31, 30, 31, 32,
33, 34, 34, 34, 35, 36, 36, 36, 37, 37, 38, 37, 38, 38, 38, 39, 39, 39, 39, 38,
38, 39, 39, 40, 40, 40, 39, 39, 39, 40, 39, 40, 39, 39, 39, 39, 39, 38, 39, 38,
39, 38, 38, 39, 38, 40, 39, 39, 39, 39, 39, 39, 40, 40, 41, 40, 41, 41, 42, 42,
43, 44, 43, 44, 44, 45, 45, 46, 47, 48, 49, 49, 50, 52, 52, 53, 54, 55, 56, 57,
58, 59, 61, 61, 63, 64, 66, 66, 68, 70, 71, 72, 74, 75, 77, 78, 80, 81, 83, 85,
86, 89, 90, 92, 94, 96, 98, 100, 102, 103, 104, 104, 104, 106, 106, 107, 106,
108, 108, 108, 109, 108, 110, 109, 110, 110, 110, 111, 111, 111, 112, 113, 112,
112, 112, 112, 112, 112, 113, 112, 113, 112, 112, 112, 112, 113, 112, 113, 112,
112, 112, 111, 111, 110, 110, 110, 110, 109, 109, 108, 108, 107, 107, 106, 105,
105, 104, 104, 103, 103, 102, 101, 100, 100, 98, 99, 98, 97, 96, 95, 94, 93, 92,
91, 90, 89, 89, 87, 86, 85, 85, 82, 81, 81, 79, 78, 78, 75, 74, 73, 72, 71, 70,
68, 67, 66, 64, 62, 62, 59, 58, 56, 56, 53, 52, 51, 49, 47, 46, 44, 42, 41, 38,
38, 36, 34, 32, 30, 28, 27, 26, 23, 22, 20, 18, 17, 14, 13, 10, 9, 7, 5, 2, 1,
-1, -3, -4, -7, -9, -11, -12, -15, -17, -19, -20, -23, -25, -27, -29, -31, -32,
-35, -37, -38, -41, -43, -45, -47, -48, -51, -53, -54, -56, -59, -61, -62, -64,
-65, -68, -70, -71, -73, -74, -77, -79, -80, -83, -83, -85, -87, -88, -90, -92,
-92, -94, -96, -97, -99, -100, -101, -103, -104, -105, -105, -108, -108, -109,
-109, -111, -112, -113, -113, -114, -115, -115, -116, -116, -117, -117, -117,
-119, -118, -119, -119, -118, -119, -119, -118, -119, -119, -118, -119, -119,
-118, -118, -118, -118, -117, -118, -116, -117, -116, -116, -115, -114, -114,
-115, -115, -115, -116, -115, -115, -115, -114, -113, -113, -113, -113, -112,
-112, -112, -112, -111, -112, -111, -110, -109, -106, -105, -103, -101, -100,
-98, -96, -95, -94, -93, -92, -89, -89, -88, -87, -85, -85, -84, -83, -81, -81,
-80, -80, -79, -79, -77, -77, -77, -75, -75, -75, -74, -74, -72, -72, -73, -71,
-72, -70, -70, -70, -70, -69, -68, -68, -67, -67, -67, -66, -66, -65, -64, -65,
-64, -64, -62, -62, -62, -61, -60, -59, -59, -58, -58, -57, -56, -55, -54, -53,
-53, -52, -51, -50, -50, -48, -47, -46, -46, -45, -44, -43, -42, -40, -39, -39,
-37, -35, -34, -33, -32, -31, -30, -29, -28, -26, -24, -23, -22, -21, -20, -18,
-16, -16, -14, -13, -11, -9, -9, -7, -6, -5, -2, -2, 0, };