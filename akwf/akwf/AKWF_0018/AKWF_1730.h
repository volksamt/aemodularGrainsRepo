#define DATA_LENGTH 512
#define DATA AKWF_1730

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 8, 12, 16, 19, 22, 25, 28, 30,
34, 36, 38, 41, 44, 46, 48, 50, 51, 53, 56, 56, 58, 60, 61, 62, 65, 66, 66, 68,
69, 69, 70, 71, 73, 74, 74, 75, 75, 76, 78, 78, 78, 79, 81, 80, 81, 82, 83, 82,
82, 84, 83, 84, 85, 85, 85, 86, 86, 86, 87, 87, 87, 87, 88, 87, 89, 89, 88, 89,
89, 89, 89, 90, 89, 90, 90, 91, 89, 90, 90, 90, 91, 90, 91, 91, 90, 91, 91, 91,
91, 91, 92, 91, 92, 92, 91, 92, 91, 91, 91, 91, 91, 91, 91, 91, 92, 91, 91, 91,
92, 92, 91, 91, 91, 90, 91, 91, 91, 90, 91, 90, 90, 90, 91, 90, 90, 90, 90, 90,
89, 90, 89, 89, 88, 88, 88, 88, 88, 88, 87, 87, 87, 87, 86, 86, 86, 86, 85, 85,
84, 85, 84, 84, 83, 82, 83, 81, 81, 81, 81, 80, 80, 79, 79, 78, 77, 77, 76, 76,
75, 74, 74, 73, 71, 71, 70, 68, 68, 67, 66, 64, 63, 62, 61, 60, 57, 56, 54, 54,
52, 50, 47, 46, 43, 42, 39, 37, 34, 33, 30, 27, 25, 20, 17, 15, 11, 8, 4, 0, -3,
-8, -12, -15, -20, -25, -29, -33, -39, -43, -48, -53, -59, -64, -69, -75, -79,
-86, -91, -97, -103, -109, -114, -118, -115, -110, -107, -102, -99, -95, -91,
-88, -84, -80, -78, -74, -71, -68, -64, -62, -59, -57, -54, -52, -49, -47, -44,
-43, -41, -39, -38, -35, -35, -33, -32, -30, -30, -29, -28, -27, -28, -27, -26,
-27, -26, -26, -26, -26, -25, -25, -26, -26, -27, -27, -27, -28, -28, -28, -29,
-29, -30, -30, -30, -31, -32, -33, -34, -34, -35, -35, -36, -37, -38, -38, -39,
-40, -40, -41, -42, -42, -42, -44, -45, -45, -45, -47, -47, -48, -48, -49, -49,
-51, -51, -52, -52, -53, -53, -54, -55, -55, -56, -56, -56, -56, -58, -58, -58,
-59, -59, -59, -60, -60, -61, -61, -62, -61, -62, -62, -62, -62, -62, -63, -63,
-63, -64, -63, -64, -63, -63, -63, -63, -64, -63, -63, -64, -63, -63, -63, -63,
-62, -63, -62, -62, -62, -62, -62, -61, -60, -60, -60, -60, -59, -59, -59, -59,
-58, -57, -57, -56, -56, -56, -55, -55, -54, -53, -53, -51, -51, -51, -51, -50,
-49, -49, -47, -47, -47, -46, -45, -44, -43, -43, -42, -42, -40, -40, -39, -38,
-38, -37, -37, -35, -35, -34, -33, -32, -32, -31, -30, -31, -29, -28, -28, -27,
-27, -26, -25, -26, -26, -25, -25, -24, -23, -24, -24, -24, -24, -24, -24, -25,
-25, -25, -26, -26, -26, -27, -27, -28, -29, -30, -32, -33, -35, -37, -37, -40,
-42, -43, -45, -48, -51, -53, -55, -58, -61, -63, -67, -69, -73, -76, -80, -83,
-87, -90, -94, -97, -102, -106, -109, -114, -115, -109, -102, -97, -92, -86,
-80, -75, -69, -64, -58, -53, -47, -43, -38, -33, -28, -23, -20, -14, -10, -5,
-2, };