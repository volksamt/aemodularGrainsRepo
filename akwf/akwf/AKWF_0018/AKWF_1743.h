#define DATA_LENGTH 512
#define DATA AKWF_1743

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 20, 30, 41, 50, 60, 68, 78, 84, 91,
98, 103, 108, 111, 115, 116, 118, 119, 119, 119, 117, 116, 112, 110, 106, 102,
97, 92, 87, 81, 75, 69, 64, 57, 51, 45, 38, 33, 26, 21, 15, 10, 5, 0, -6, -9,
-13, -17, -22, -25, -27, -29, -32, -34, -36, -37, -38, -39, -39, -38, -39, -39,
-38, -37, -36, -35, -34, -33, -31, -30, -28, -26, -25, -23, -21, -19, -17, -15,
-14, -12, -10, -8, -7, -5, -5, -2, -1, 0, 2, 3, 3, 4, 5, 5, 6, 6, 8, 8, 8, 8, 8,
9, 8, 8, 8, 8, 8, 8, 7, 6, 7, 6, 6, 5, 5, 4, 4, 4, 3, 3, 2, 2, 2, 0, 1, 0, 1, 0,
-1, -1, -1, -1, -2, -2, -2, -2, -2, -3, -3, -2, -3, -3, -3, -3, -3, -2, -2, -4,
-2, -3, -2, -3, -2, -2, -2, -2, -2, -1, -2, -2, -2, -1, -1, -1, -2, -1, -2, 0,
0, 0, -1, -1, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 1, -1, -1, 0, 0, 0,
-1, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, -1,
0, -1, -1, 0, 0, 0, 0, 0, 3, 7, 15, 22, 31, 40, 50, 59, 69, 78, 85, 93, 98, 102,
106, 108, 110, 109, 107, 103, 100, 94, 88, 80, 73, 63, 55, 45, 34, 24, 13, 2,
-9, -21, -31, -41, -50, -60, -68, -77, -85, -91, -97, -102, -107, -111, -115,
-117, -119, -120, -119, -118, -117, -115, -113, -109, -105, -101, -97, -92, -86,
-80, -75, -69, -63, -58, -51, -45, -38, -32, -27, -21, -15, -10, -4, 1, 5, 9,
13, 18, 21, 25, 27, 30, 32, 33, 36, 36, 37, 39, 39, 39, 39, 38, 37, 37, 37, 35,
34, 33, 31, 30, 28, 26, 24, 23, 21, 19, 16, 15, 14, 11, 11, 8, 7, 5, 5, 3, 1,
-1, -1, -2, -3, -4, -5, -6, -7, -6, -7, -8, -7, -9, -9, -8, -8, -8, -8, -9, -8,
-7, -7, -7, -7, -6, -6, -6, -6, -5, -4, -4, -3, -2, -2, -2, -2, -2, -1, 0, -1,
0, 0, 0, 2, 1, 1, 2, 2, 2, 2, 2, 2, 3, 3, 3, 2, 3, 3, 4, 2, 3, 3, 2, 3, 2, 2, 2,
2, 2, 2, 2, 2, 2, 1, 2, 1, 2, 1, 1, 0, 1, 1, 2, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, 0,
1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 1, 1, 1, 0,
0, 0, 1, 0, 0, 0, 0, 0, 1, 1, 1, 1, 0, 0, 1, 0, -3, -7, -14, -23, -31, -40, -50,
-59, -69, -78, -86, -92, -98, -103, -106, -108, -109, -109, -107, -104, -100,
-95, -87, -81, -72, -64, -54, -45, -34, -23, -12, -1, };