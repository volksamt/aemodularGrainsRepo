#define DATA_LENGTH 512
#define DATA AKWF_1716

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 6, 11, 15, 20, 25, 30, 35, 41, 46,
50, 54, 58, 63, 67, 71, 74, 78, 81, 83, 85, 88, 89, 91, 91, 93, 93, 93, 94, 93,
93, 93, 92, 90, 90, 89, 88, 86, 84, 83, 82, 80, 78, 77, 74, 73, 72, 69, 67, 66,
65, 63, 62, 60, 59, 59, 57, 57, 57, 55, 55, 54, 55, 55, 56, 56, 57, 57, 58, 58,
60, 60, 61, 62, 63, 64, 63, 64, 64, 63, 63, 62, 62, 61, 59, 58, 56, 55, 52, 49,
47, 45, 42, 39, 36, 34, 31, 28, 26, 23, 20, 16, 14, 12, 9, 6, 3, 2, 0, -2, -5,
-7, -9, -10, -12, -14, -15, -17, -18, -19, -20, -21, -22, -23, -24, -25, -25,
-26, -26, -27, -27, -27, -27, -27, -27, -27, -27, -27, -27, -26, -27, -26, -26,
-26, -25, -25, -26, -25, -26, -26, -26, -26, -26, -26, -27, -27, -28, -28, -28,
-29, -28, -28, -30, -30, -29, -30, -30, -31, -31, -31, -32, -33, -33, -34, -34,
-34, -34, -34, -36, -36, -37, -36, -38, -39, -39, -40, -39, -40, -41, -41, -42,
-42, -43, -42, -42, -43, -42, -43, -43, -42, -43, -42, -42, -41, -42, -41, -40,
-40, -39, -39, -39, -38, -38, -37, -37, -37, -37, -37, -36, -36, -35, -35, -35,
-34, -34, -34, -33, -33, -33, -32, -31, -31, -31, -29, -29, -28, -27, -27, -26,
-24, -23, -23, -22, -20, -20, -19, -19, -17, -16, -14, -13, -13, -12, -11, -10,
-9, -7, -6, -5, -4, -3, -1, 0, 1, 3, 4, 6, 7, 8, 9, 11, 12, 12, 14, 16, 16, 19,
19, 20, 21, 22, 23, 23, 25, 25, 26, 27, 27, 28, 27, 27, 28, 29, 29, 29, 29, 29,
28, 29, 29, 29, 28, 28, 28, 27, 27, 26, 26, 26, 25, 24, 23, 23, 23, 22, 21, 21,
22, 20, 21, 20, 21, 21, 22, 22, 23, 24, 25, 27, 28, 30, 32, 34, 37, 40, 42, 44,
46, 49, 51, 54, 55, 58, 59, 61, 63, 63, 64, 65, 65, 66, 66, 66, 67, 66, 66, 65,
64, 61, 61, 59, 57, 56, 54, 52, 50, 49, 47, 44, 42, 41, 38, 36, 33, 32, 30, 28,
25, 23, 21, 20, 18, 17, 16, 15, 14, 13, 12, 13, 12, 11, 12, 12, 14, 14, 14, 15,
16, 16, 17, 18, 18, 19, 20, 20, 21, 20, 20, 21, 19, 19, 18, 17, 15, 13, 12, 11,
9, 5, 3, 1, -1, -4, -7, -9, -13, -15, -18, -21, -23, -26, -29, -32, -35, -39,
-41, -45, -47, -50, -53, -55, -59, -62, -65, -68, -71, -73, -76, -79, -82, -85,
-88, -90, -93, -95, -98, -101, -102, -105, -106, -109, -110, -112, -113, -115,
-116, -118, -117, -118, -120, -119, -119, -118, -119, -117, -116, -116, -114,
-112, -111, -109, -108, -105, -102, -100, -98, -96, -93, -90, -86, -83, -80,
-77, -73, -70, -66, -63, -60, -56, -53, -49, -45, -41, -37, -33, -30, -25, -21,
-17, -11, -8, -3, };