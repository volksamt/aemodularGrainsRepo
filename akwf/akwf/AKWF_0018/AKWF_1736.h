#define DATA_LENGTH 512
#define DATA AKWF_1736

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 10, 13, 16, 20, 24, 27, 31, 35,
39, 43, 46, 50, 54, 57, 61, 65, 68, 72, 76, 80, 84, 87, 90, 94, 97, 102, 105,
108, 111, 116, 118, 119, 119, 119, 119, 120, 119, 119, 120, 118, 119, 119, 120,
119, 119, 119, 119, 118, 119, 119, 118, 119, 119, 119, 119, 119, 118, 118, 119,
119, 118, 118, 118, 119, 118, 118, 118, 119, 119, 119, 118, 119, 119, 118, 118,
118, 118, 118, 118, 119, 119, 119, 118, 119, 118, 118, 118, 118, 119, 118, 118,
118, 118, 118, 118, 118, 119, 118, 118, 119, 118, 118, 118, 118, 118, 117, 119,
118, 117, 118, 118, 118, 117, 118, 118, 117, 118, 118, 118, 117, 117, 117, 118,
118, 118, 117, 118, 118, 118, 117, 117, 118, 118, 117, 117, 117, 118, 117, 117,
117, 117, 118, 117, 117, 118, 117, 117, 117, 118, 117, 117, 117, 117, 117, 117,
117, 117, 118, 117, 117, 117, 117, 118, 117, 117, 118, 117, 117, 117, 116, 117,
117, 117, 118, 117, 117, 117, 117, 118, 116, 117, 117, 117, 116, 116, 117, 117,
117, 117, 117, 116, 117, 117, 116, 116, 116, 117, 117, 116, 116, 117, 116, 117,
117, 117, 117, 117, 117, 117, 116, 116, 117, 115, 116, 116, 116, 116, 116, 116,
116, 117, 116, 116, 113, 110, 106, 103, 99, 95, 92, 88, 84, 81, 78, 74, 70, 66,
63, 59, 56, 52, 48, 44, 41, 36, 33, 29, 25, 22, 18, 14, 10, 6, 3, -1, -4, -9,
-12, -16, -21, -24, -28, -32, -36, -39, -43, -47, -50, -54, -58, -62, -65, -69,
-73, -76, -80, -83, -87, -91, -94, -97, -102, -104, -109, -112, -116, -118,
-119, -119, -119, -119, -119, -119, -118, -118, -119, -119, -120, -119, -118,
-120, -119, -120, -119, -119, -118, -119, -118, -118, -119, -118, -119, -119,
-118, -119, -119, -119, -118, -119, -119, -118, -118, -118, -118, -118, -118,
-119, -119, -119, -118, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-118, -119, -118, -118, -118, -118, -118, -118, -118, -119, -118, -118, -117,
-118, -118, -119, -117, -118, -118, -118, -118, -118, -118, -119, -119, -118,
-118, -118, -119, -117, -118, -117, -119, -119, -117, -118, -118, -118, -118,
-117, -117, -118, -118, -118, -118, -118, -118, -117, -118, -118, -117, -118,
-118, -118, -117, -118, -118, -118, -118, -117, -117, -117, -118, -118, -117,
-117, -117, -118, -118, -117, -118, -117, -118, -117, -117, -117, -118, -117,
-117, -118, -118, -117, -117, -117, -117, -117, -117, -117, -116, -117, -117,
-117, -117, -117, -117, -117, -117, -117, -116, -117, -117, -117, -117, -117,
-117, -117, -117, -117, -117, -117, -116, -116, -116, -117, -117, -117, -116,
-117, -116, -116, -117, -116, -117, -116, -116, -117, -117, -117, -116, -117,
-117, -117, -116, -116, -116, -116, -116, -116, -116, -117, -114, -110, -106,
-102, -100, -96, -92, -89, -85, -82, -78, -73, -71, -66, -64, -58, -56, -52,
-48, -44, -40, -36, -34, -29, -25, -22, -18, -14, -11, -6, -3, };