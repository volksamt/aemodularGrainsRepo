#define DATA_LENGTH 512
#define DATA AKWF_1725

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 12, 17, 20, 24, 28, 31, 34,
37, 41, 43, 46, 49, 52, 54, 56, 59, 61, 64, 66, 68, 70, 71, 74, 75, 77, 78, 80,
82, 84, 84, 86, 86, 88, 89, 91, 92, 93, 94, 95, 96, 96, 98, 98, 100, 100, 101,
102, 103, 103, 104, 105, 104, 106, 106, 107, 108, 109, 108, 108, 109, 110, 111,
111, 111, 112, 112, 113, 113, 114, 113, 114, 115, 114, 115, 115, 116, 115, 116,
117, 116, 117, 117, 117, 117, 118, 117, 118, 119, 117, 119, 118, 119, 118, 118,
118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120, 119, 119, 119, 120,
119, 118, 118, 119, 118, 118, 118, 118, 118, 118, 117, 118, 116, 116, 117, 117,
116, 117, 116, 115, 115, 115, 115, 114, 113, 113, 113, 113, 112, 112, 112, 111,
111, 110, 110, 109, 108, 109, 108, 107, 107, 107, 106, 106, 104, 104, 103, 103,
102, 101, 100, 100, 99, 99, 97, 97, 96, 95, 94, 93, 92, 91, 90, 90, 88, 86, 85,
85, 83, 82, 81, 79, 78, 76, 74, 73, 71, 70, 67, 66, 64, 62, 60, 57, 54, 53, 51,
47, 45, 42, 39, 36, 33, 29, 26, 23, 20, 15, 13, 8, 3, 0, -5, -9, -13, -18, -23,
-28, -32, -37, -42, -48, -52, -59, -64, -70, -75, -81, -87, -92, -98, -103,
-111, -111, -107, -104, -101, -98, -94, -92, -88, -85, -82, -79, -77, -74, -71,
-69, -67, -64, -62, -60, -58, -56, -54, -52, -52, -49, -49, -48, -47, -45, -45,
-44, -43, -43, -42, -41, -41, -41, -41, -41, -41, -41, -41, -41, -41, -42, -42,
-43, -44, -44, -45, -44, -45, -46, -47, -48, -48, -49, -49, -51, -51, -52, -53,
-54, -55, -56, -57, -58, -59, -60, -60, -62, -62, -64, -64, -66, -66, -67, -68,
-69, -70, -71, -72, -72, -72, -74, -75, -76, -77, -77, -78, -79, -79, -80, -81,
-81, -82, -83, -83, -83, -85, -86, -86, -86, -87, -87, -88, -88, -89, -89, -90,
-90, -90, -90, -92, -91, -91, -92, -92, -92, -92, -93, -93, -93, -93, -93, -93,
-94, -94, -93, -92, -92, -93, -92, -92, -92, -92, -92, -91, -91, -91, -91, -90,
-91, -90, -89, -89, -88, -88, -88, -88, -87, -87, -86, -86, -85, -84, -83, -83,
-82, -81, -81, -80, -80, -78, -77, -77, -76, -75, -75, -74, -73, -73, -71, -70,
-69, -69, -67, -67, -66, -65, -64, -63, -61, -61, -60, -59, -58, -57, -56, -55,
-55, -53, -53, -51, -51, -50, -48, -48, -46, -47, -46, -44, -44, -43, -43, -42,
-41, -41, -41, -40, -39, -39, -39, -39, -38, -38, -37, -37, -38, -38, -39, -39,
-39, -40, -40, -41, -41, -43, -43, -44, -46, -47, -49, -50, -52, -53, -55, -57,
-59, -62, -64, -66, -68, -72, -74, -76, -80, -82, -85, -88, -91, -94, -98, -101,
-104, -108, -105, -97, -93, -86, -80, -75, -69, -63, -59, -52, -47, -42, -37,
-32, -27, -21, -17, -12, -7, -3, };