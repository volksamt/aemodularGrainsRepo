#define DATA_LENGTH 512
#define DATA AKWF_1770

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 3, 4, 5, 5, 5, 5, 4, 6, 5, 5, 5,
5, 5, 5, 5, 5, 5, 5, 5, 4, 5, 5, 5, 4, 5, 5, 5, 5, 5, 5, 5, 5, 4, 6, 4, 5, 5, 5,
4, 5, 5, 5, 5, 5, 4, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 4, 5, 4, 5, 5, 4, 4, 5, 4, 5,
5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 4, 5, 4, 5, 5, 4, 6, 5, 5, 5, 5, 5, 4, 5, 5, 5,
5, 5, 4, 5, 4, 5, 5, 5, 4, 4, 5, 5, 5, 5, 5, 5, 4, 5, 4, 4, 5, 4, 5, 6, 5, 5, 5,
5, 5, 5, 5, 5, 4, 5, 5, 4, 5, 5, 5, 5, 5, 4, 5, 4, 5, 5, 5, 4, 5, 5, 5, 5, 5, 5,
5, 5, 6, 5, 4, 4, 4, 5, 4, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5,
5, 4, 4, 4, 4, 4, 4, 5, 6, 5, 5, 5, 4, 4, 5, 5, 5, 5, 4, 4, 5, 5, 5, 5, 5, 5, 5,
5, 4, 5, 4, 5, 5, 5, 4, 5, 5, 5, 4, 5, 5, 5, 5, 5, 5, 5, 5, 5, 4, 5, 4, 5, 4, 4,
5, 5, 5, 5, 5, 4, 5, 5, 5, 4, 4, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 4, 4, 5,
5, 5, 5, 4, 4, 4, 4, 5, 4, 5, 5, 5, 5, 4, 5, 4, 4, 4, 5, 4, 5, 4, 5, 5, 5, 5, 4,
5, 5, 5, 5, 4, 4, 5, 4, 5, 4, 5, 4, 5, 4, 4, 5, 5, 4, 4, 5, 5, 5, 5, 5, 5, 5, 5,
4, 5, 5, 5, 5, 5, 5, 4, 5, 7, 9, 10, 11, 13, 14, 16, 17, 18, 19, 20, 22, 23, 25,
27, 27, 29, 30, 32, 33, 34, 36, 36, 38, 40, 41, 41, 43, 45, 46, 48, 49, 51, 51,
54, 54, 57, 57, 59, 59, 62, 62, 64, 66, 67, 68, 70, 71, 72, 74, 75, 77, 77, 79,
80, 82, 83, 85, 85, 88, 87, 90, 90, 94, 92, 96, 95, 99, 98, 102, 101, 103, 104,
105, 108, 107, 112, 109, 116, 110, 121, 107, 127, 76, 5, -60, -124, -97, -113,
-101, -107, -101, -104, -102, -102, -101, -100, -100, -98, -98, -95, -97, -94,
-95, -93, -94, -91, -92, -89, -90, -89, -89, -87, -86, -85, -85, -84, -83, -83,
-81, -81, -79, -80, -79, -78, -76, -76, -75, -75, -74, -73, -73, -72, -71, -69,
-69, -68, -67, -67, -65, -65, -65, -64, -63, -62, -61, -60, -60, -59, -58, -58,
-56, -56, -55, -55, -53, -52, -52, -51, -50, -50, -49, -48, -47, -46, -45, -45,
-44, -43, -42, -42, -40, -38, -35, -34, -33, -30, -29, -27, -25, -23, -22, -19,
-18, -17, -14, -13, -10, -8, -7, -5, -3, -2, };