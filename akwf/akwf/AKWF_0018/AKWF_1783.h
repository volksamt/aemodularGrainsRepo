#define DATA_LENGTH 512
#define DATA AKWF_1783

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 11, 16, 21, 25, 27, 31, 35, 38,
41, 44, 47, 49, 52, 53, 56, 57, 59, 62, 63, 63, 65, 65, 65, 66, 66, 66, 66, 68,
68, 68, 68, 68, 68, 68, 67, 67, 66, 66, 66, 64, 64, 64, 64, 63, 62, 63, 63, 62,
62, 61, 61, 61, 60, 59, 59, 58, 58, 57, 57, 56, 56, 54, 55, 53, 53, 51, 51, 51,
49, 48, 48, 47, 46, 45, 44, 44, 43, 40, 40, 38, 37, 35, 34, 33, 31, 30, 30, 27,
24, 19, 15, 10, 6, 2, -1, -5, -8, -11, -14, -16, -17, -18, -19, -20, -20, -21,
-22, -22, -22, -22, -22, -20, -20, -17, -15, -13, -9, -5, -2, 2, 6, 10, 13, 17,
20, 23, 27, 29, 32, 34, 37, 40, 43, 46, 49, 52, 54, 55, 56, 58, 58, 59, 58, 57,
56, 55, 54, 53, 52, 52, 51, 50, 48, 48, 47, 44, 43, 42, 40, 39, 37, 35, 34, 33,
32, 32, 32, 32, 31, 32, 33, 33, 34, 34, 35, 36, 37, 37, 38, 38, 40, 41, 41, 43,
44, 44, 45, 45, 44, 43, 40, 35, 27, 21, 19, 19, 18, 16, 11, 5, -1, -8, -13, -18,
-23, -27, -33, -38, -44, -50, -56, -60, -66, -71, -75, -79, -84, -87, -91, -95,
-98, -102, -105, -107, -110, -112, -114, -116, -117, -118, -119, -119, -119,
-119, -119, -117, -116, -114, -113, -112, -109, -107, -105, -102, -100, -97,
-93, -91, -88, -84, -80, -77, -74, -70, -65, -62, -58, -55, -51, -49, -45, -42,
-37, -33, -31, -26, -22, -16, -9, -2, 3, 5, 8, 10, 15, 19, 25, 29, 33, 36, 40,
45, 48, 51, 55, 59, 61, 64, 67, 70, 71, 74, 75, 76, 78, 78, 80, 80, 82, 82, 83,
82, 82, 82, 82, 82, 81, 80, 79, 77, 75, 74, 71, 70, 65, 58, 53, 50, 49, 47, 44,
40, 35, 32, 27, 21, 18, 13, 10, 6, 1, -3, -7, -11, -16, -21, -24, -28, -31, -35,
-38, -41, -44, -47, -53, -58, -64, -70, -75, -80, -84, -89, -93, -96, -98, -100,
-102, -103, -104, -104, -104, -105, -105, -106, -106, -105, -104, -102, -100,
-96, -93, -89, -85, -80, -75, -69, -63, -57, -49, -39, -32, -26, -22, -17, -12,
-8, 0, 6, 14, 21, 26, 31, 36, 41, 44, 48, 52, 54, 57, 58, 58, 60, 60, 61, 61,
62, 62, 63, 64, 63, 61, 61, 61, 59, 58, 56, 56, 53, 52, 51, 50, 49, 49, 48, 48,
48, 46, 46, 46, 45, 45, 44, 44, 43, 42, 41, 41, 40, 39, 39, 36, 31, 27, 26, 25,
24, 23, 20, 17, 14, 10, 6, 3, -1, -4, -7, -10, -13, -18, -20, -23, -28, -30,
-34, -37, -41, -45, -48, -51, -55, -57, -60, -62, -63, -65, -68, -69, -71, -73,
-73, -74, -75, -75, -75, -76, -75, -74, -74, -72, -70, -69, -67, -64, -62, -60,
-57, -54, -51, -50, -46, -43, -39, -35, -28, -22, -16, -12, -8, -6, -2, };