#define DATA_LENGTH 512
#define DATA AKWF_1745

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 31, 58, 76, 97, 113, 117, 116, 116,
117, 117, 117, 116, 117, 117, 117, 117, 116, 116, 117, 117, 117, 117, 117, 117,
117, 117, 116, 117, 117, 117, 116, 117, 117, 116, 116, 116, 117, 117, 116, 116,
117, 117, 116, 117, 117, 117, 117, 116, 117, 116, 117, 116, 117, 115, 116, 116,
117, 116, 117, 115, 108, 103, 99, 95, 88, 85, 78, 73, 69, 65, 60, 55, 50, 47,
42, 38, 34, 29, 26, 23, 18, 15, 11, 8, 4, 1, -3, -5, -8, -13, -15, -17, -20,
-23, -26, -28, -31, -33, -34, -37, -39, -41, -43, -45, -46, -48, -50, -52, -53,
-55, -56, -58, -59, -59, -61, -62, -63, -65, -64, -65, -66, -66, -67, -69, -69,
-70, -69, -70, -71, -70, -70, -71, -71, -72, -71, -71, -71, -71, -70, -71, -72,
-71, -70, -70, -70, -70, -69, -69, -69, -69, -68, -68, -67, -66, -67, -66, -66,
-65, -64, -64, -63, -63, -62, -62, -61, -60, -60, -59, -58, -57, -57, -57, -55,
-55, -54, -53, -53, -52, -51, -51, -49, -49, -48, -48, -46, -45, -45, -45, -44,
-43, -42, -42, -41, -40, -39, -38, -38, -37, -36, -36, -34, -34, -34, -33, -33,
-32, -31, -29, -29, -29, -27, -27, -27, -25, -25, -24, -25, -23, -23, -22, -22,
-21, -20, -19, -19, -19, -18, -18, -17, -17, -16, -15, -15, -15, -14, -13, -13,
-12, -11, -12, -11, -10, -10, -9, -9, -9, -8, -7, -7, -6, -7, -7, -5, -4, -5,
-4, -5, -5, -3, -3, -3, -3, -2, -2, -2, -1, -1, 0, -1, -1, 0, 0, 1, 1, 1, 1, 1,
2, 3, 2, 3, 3, 3, 3, 3, 4, 4, 4, 4, 4, 5, 5, 5, 6, 5, 5, 6, 6, 6, 5, 6, 6, 6, 6,
6, 7, 6, 7, 7, 7, 8, 7, 8, 7, 7, 6, 7, 7, 7, 8, 8, 8, 8, 8, 8, 7, 8, 7, 8, 8, 8,
8, 7, 8, 8, 8, 8, 8, 7, 9, 8, 8, 8, 8, 8, 8, 8, 8, 7, 7, 8, 9, 9, 8, 8, 8, 8, 8,
8, 7, 7, 7, 8, 8, 8, 8, 8, 7, 7, 7, 8, 8, 6, 8, 8, 6, 7, 7, 7, 7, 7, 7, 7, 7, 7,
7, 6, 6, 7, 7, 6, 7, 6, 6, 7, 6, 7, 6, 6, 6, 6, 6, 6, 5, 6, 6, 5, 5, 5, 5, 6, 6,
5, 5, 5, 5, 5, 5, 4, 5, 5, 5, 5, 5, 4, 4, 5, 5, 4, 4, 4, 5, 4, 3, 3, 3, 4, 3, 4,
3, 3, 3, 3, 4, 4, 4, 4, 3, 3, 4, 3, 2, 3, 3, 3, 3, 2, 3, 3, 2, 2, 3, 1, 3, 3, 3,
2, 3, 1, 4, 1, 3, 2, 2, 1, 4, 0, 3, 3, 1, 2, 2, 1, 1, 5, -5, 10, -7, 8, -5, 16,
-60, -128, -110, -126, -113, -123, -116, -122, -117, -121, -118, -120, -118,
-119, -118, -121, -105, -76, -45, -15, };