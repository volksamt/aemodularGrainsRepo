#define DATA_LENGTH 512
#define DATA AKWF_1786

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 21, 50, 85, 112, 119, 113, 96, 94,
90, 88, 67, 36, 4, -20, -23, -28, -30, -47, -66, -85, -94, -94, -88, -80, -77,
-79, -86, -87, -82, -64, -46, -26, -18, -14, -10, 2, 24, 43, 57, 55, 55, 56, 67,
78, 83, 80, 69, 57, 45, 40, 38, 38, 33, 24, 8, -9, -27, -38, -44, -47, -49, -55,
-60, -64, -61, -57, -50, -52, -55, -59, -56, -44, -27, -8, 3, 4, -1, 1, 6, 20,
33, 38, 43, 45, 51, 53, 51, 47, 42, 39, 35, 27, 21, 18, 17, 12, 1, -10, -19,
-23, -25, -29, -35, -40, -40, -39, -37, -36, -37, -38, -39, -37, -31, -22, -12,
-3, 1, 5, 8, 11, 15, 17, 22, 27, 32, 35, 34, 31, 27, 25, 23, 23, 22, 21, 15, 9,
2, -3, -7, -10, -12, -17, -23, -28, -28, -25, -20, -19, -22, -28, -32, -24, -18,
-9, -10, -12, -10, -7, 2, 8, 12, 13, 13, 12, 15, 17, 20, 22, 22, 20, 18, 16, 13,
11, 9, 9, 7, 2, -4, -6, -7, -5, -6, -10, -17, -23, -22, -18, -14, -13, -13, -15,
-15, -13, -10, -7, -4, -3, -4, -4, -1, 2, 7, 11, 13, 13, 11, 9, 10, 11, 12, 9,
8, 6, 8, 12, 9, 4, -2, -5, -6, -3, -3, -4, -7, -10, -11, -11, -10, -12, -13,
-14, -13, -8, -3, 0, -2, -5, -10, -9, -4, 3, 9, 8, 6, 2, 4, 6, 10, 10, 7, 4, 1,
4, 6, 9, 9, 5, 0, -3, -2, 0, 0, -4, -6, -7, -6, -6, -6, -6, -4, -6, -5, -6, -6,
-3, -1, -1, -1, -3, -5, -3, -1, 2, 4, 7, 7, 7, 3, 0, -1, 1, 4, 6, 4, 2, 2, 2, 2,
0, -1, -1, 1, 0, 0, -3, -2, -1, 0, 0, -4, -6, -7, -4, -1, 1, -1, -2, -2, -3, -1,
-1, -1, 2, 1, 3, 3, 1, 1, 3, 4, 3, 0, 0, 1, 1, 2, 2, 3, 2, 2, 1, 0, 0, 0, 0, 0,
-2, -2, -1, -1, 0, 0, -1, -1, -2, -2, 0, 1, 1, 0, 0, 0, 0, 0, -1, 0, 3, 3, 1,
-1, -2, -1, 2, 4, 3, 2, 0, 0, 0, 1, 1, 0, -1, -2, 0, 2, 4, 1, 1, -1, -1, 1, 1,
-1, -1, -1, 0, 0, 1, 1, 0, 0, -1, -2, -1, 0, 2, 3, 1, -1, -2, -3, -1, 1, 2, 2,
1, 1, 1, 1, 1, -1, -2, -1, 0, 2, 1, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0,
-1, -1, -1, -1, -1, 0, 0, 0, -2, -1, -1, 0, 2, 2, 1, 0, 1, 2, 3, 2, 0, -1, 0, 3,
3, 2, 2, 1, 2, 2, 2, 1, 0, -1, 0, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1,
-2, -1, -1, 0, 1, 2, 2, 2, 2, 2, 1, -1, -1, -3, -6, -6, -6, -3, -1, };