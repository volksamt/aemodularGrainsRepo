#define DATA_LENGTH 512
#define DATA AKWF_1776

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 0, 0, 1, 1, 1, 0, 0, 2, 2, 1,
1, 2, 2, 2, 3, 2, 2, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 5, 5, 5, 5, 6, 6, 7, 7, 6,
7, 7, 7, 8, 8, 8, 8, 9, 9, 10, 10, 10, 10, 10, 11, 11, 10, 11, 12, 12, 12, 13,
14, 13, 13, 14, 14, 14, 15, 16, 17, 17, 18, 19, 20, 19, 20, 21, 22, 23, 23, 24,
24, 24, 25, 26, 27, 29, 28, 29, 30, 31, 32, 31, 33, 33, 35, 35, 36, 37, 37, 39,
40, 40, 41, 42, 43, 43, 45, 45, 46, 47, 48, 49, 49, 51, 51, 52, 52, 54, 54, 56,
56, 57, 59, 59, 59, 60, 61, 62, 63, 63, 64, 66, 67, 67, 69, 68, 70, 72, 72, 72,
73, 75, 76, 75, 76, 78, 79, 80, 80, 82, 82, 83, 84, 85, 86, 87, 87, 88, 89, 90,
90, 92, 92, 93, 93, 94, 95, 96, 97, 98, 99, 99, 100, 101, 101, 102, 104, 104,
105, 105, 107, 106, 108, 108, 110, 109, 111, 110, 114, 115, 114, 89, 59, 59, 54,
51, 48, 45, 42, 39, 36, 33, 31, 28, 26, 23, 22, 19, 17, 15, 13, 11, 10, 8, 6, 5,
4, 2, 2, 1, 0, -1, -1, -2, -3, -3, -3, -3, -4, -4, -3, -3, -4, -5, -4, -4, -5,
-5, -6, -7, -7, -9, -9, -10, -11, -12, -15, -16, -17, -18, -21, -23, -24, -26,
-28, -31, -34, -36, -38, -41, -43, -47, -49, -52, -55, -59, -62, -64, -69, -71,
-75, -80, -83, -86, -89, -93, -97, -101, -107, -107, -106, -105, -103, -104,
-102, -101, -100, -99, -98, -97, -95, -95, -93, -92, -91, -90, -90, -89, -89,
-87, -86, -85, -83, -83, -83, -81, -81, -79, -78, -78, -77, -76, -75, -74, -73,
-72, -72, -71, -70, -69, -68, -67, -66, -66, -64, -63, -64, -62, -61, -61, -60,
-59, -57, -57, -56, -55, -55, -54, -53, -52, -52, -50, -50, -49, -49, -49, -47,
-46, -46, -44, -45, -44, -43, -43, -42, -41, -39, -39, -39, -37, -36, -36, -36,
-35, -35, -34, -34, -33, -33, -32, -31, -30, -30, -29, -28, -27, -27, -28, -27,
-26, -25, -26, -24, -25, -23, -22, -23, -22, -21, -21, -21, -20, -20, -19, -19,
-19, -18, -17, -17, -17, -16, -16, -15, -15, -15, -14, -14, -14, -14, -13, -13,
-13, -13, -12, -12, -11, -11, -10, -11, -11, -10, -9, -8, -9, -9, -8, -8, -8,
-7, -7, -7, -7, -7, -6, -6, -5, -6, -6, -5, -6, -5, -5, -4, -5, -5, -4, -5, -3,
-4, -4, -4, -3, -3, -3, -3, -4, -3, -2, -3, -3, -3, -2, -3, -3, -2, -2, -2, -2,
-2, -2, -2, -2, -1, -2, -1, -1, -2, -1, -2, -2, -2, -2, -2, -2, -2, -2, -1, -1,
-1, -1, -2, -1, -1, -2, -1, -2, -2, 0, -1, -1, -1, -1, -1, -1, -1, 0, -1, 0, 0,
1, };