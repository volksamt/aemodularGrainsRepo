#define DATA_LENGTH 512
#define DATA AKWF_1784

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 12, 17, 21, 26, 31, 35, 38, 41,
45, 47, 50, 54, 56, 59, 61, 64, 65, 66, 68, 69, 71, 72, 73, 74, 75, 75, 76, 77,
78, 78, 78, 77, 77, 77, 76, 76, 75, 74, 73, 72, 72, 70, 69, 67, 64, 63, 63, 62,
59, 58, 56, 55, 53, 51, 49, 48, 47, 44, 43, 42, 39, 38, 36, 35, 34, 32, 30, 29,
27, 26, 24, 24, 21, 20, 20, 18, 17, 16, 15, 14, 13, 12, 12, 11, 10, 10, 10, 9,
8, 9, 8, 8, 9, 10, 11, 11, 12, 12, 13, 13, 13, 14, 15, 15, 15, 16, 17, 17, 18,
19, 20, 21, 22, 24, 26, 27, 29, 32, 34, 37, 39, 42, 44, 46, 48, 50, 52, 54, 55,
56, 58, 58, 58, 58, 59, 59, 58, 57, 57, 57, 56, 55, 56, 55, 55, 55, 55, 55, 55,
55, 56, 55, 55, 55, 55, 55, 55, 54, 53, 52, 51, 50, 48, 47, 46, 44, 43, 40, 39,
38, 37, 36, 35, 34, 34, 34, 34, 33, 33, 32, 33, 33, 32, 32, 31, 31, 29, 28, 25,
23, 20, 15, 8, 0, -7, -10, -13, -14, -19, -24, -31, -38, -43, -50, -54, -59,
-64, -69, -73, -78, -82, -86, -91, -94, -98, -101, -104, -107, -108, -110, -113,
-114, -115, -116, -117, -117, -118, -118, -119, -119, -118, -119, -116, -115,
-115, -113, -111, -110, -107, -105, -102, -100, -98, -95, -92, -88, -84, -82,
-79, -75, -71, -69, -65, -60, -56, -51, -47, -44, -41, -36, -33, -29, -25, -22,
-18, -15, -11, -7, 0, 7, 14, 17, 19, 20, 24, 28, 33, 38, 43, 46, 50, 54, 58, 61,
65, 68, 70, 73, 75, 77, 79, 80, 82, 82, 84, 83, 84, 83, 83, 83, 81, 81, 79, 79,
77, 75, 74, 72, 70, 67, 64, 63, 60, 57, 53, 48, 42, 36, 33, 30, 28, 24, 21, 15,
11, 5, 1, -3, -8, -12, -16, -19, -24, -27, -31, -35, -37, -41, -44, -47, -49,
-52, -53, -55, -57, -58, -59, -60, -61, -61, -61, -60, -61, -61, -60, -61, -60,
-60, -59, -58, -58, -57, -56, -56, -55, -53, -52, -50, -49, -46, -44, -40, -37,
-34, -31, -27, -23, -19, -13, -7, 1, 7, 10, 13, 14, 17, 20, 25, 29, 33, 36, 38,
39, 42, 45, 47, 49, 50, 52, 55, 56, 57, 58, 61, 62, 64, 65, 66, 68, 68, 68, 69,
69, 68, 68, 68, 67, 65, 65, 63, 61, 59, 57, 55, 53, 52, 50, 48, 47, 45, 43, 41,
41, 40, 38, 36, 35, 34, 32, 29, 26, 22, 17, 11, 8, 6, 3, 0, -4, -9, -14, -18,
-23, -29, -33, -36, -41, -45, -49, -53, -57, -60, -63, -67, -69, -73, -75, -77,
-79, -81, -84, -85, -85, -87, -87, -87, -88, -88, -88, -87, -86, -86, -85, -84,
-83, -83, -81, -79, -77, -74, -72, -69, -66, -64, -61, -59, -55, -52, -48, -45,
-42, -38, -35, -29, -24, -17, -11, -8, -5, -1, };