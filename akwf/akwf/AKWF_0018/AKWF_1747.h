#define DATA_LENGTH 512
#define DATA AKWF_1747

const PROGMEM int8_t DATA[DATA_LENGTH] = {41, 86, 115, 118, 117, 119, 117, 118,
117, 119, 118, 118, 117, 117, 117, 118, 117, 117, 117, 117, 118, 117, 117, 118,
117, 118, 117, 118, 114, 106, 96, 84, 75, 65, 56, 46, 38, 28, 22, 14, 7, 0, -7,
-12, -17, -24, -28, -32, -37, -40, -44, -47, -50, -53, -55, -57, -59, -60, -61,
-63, -63, -64, -64, -65, -65, -66, -64, -65, -64, -64, -63, -62, -62, -61, -60,
-58, -59, -57, -55, -55, -53, -52, -51, -49, -48, -47, -44, -44, -42, -41, -40,
-37, -36, -35, -34, -32, -31, -30, -29, -27, -26, -25, -24, -22, -21, -19, -19,
-17, -16, -16, -14, -14, -13, -11, -11, -10, -9, -8, -7, -7, -7, -5, -5, -4, -4,
-3, -3, -2, -2, -1, -1, -1, -1, 0, 1, 1, 2, 3, 3, 3, 2, 3, 3, 4, 4, 5, 4, 5, 4,
4, 5, 5, 5, 5, 6, 6, 6, 6, 6, 5, 5, 6, 6, 6, 6, 6, 6, 6, 5, 6, 5, 5, 6, 5, 5, 6,
5, 6, 5, 6, 5, 5, 5, 5, 5, 4, 5, 4, 5, 4, 4, 4, 4, 5, 4, 4, 4, 4, 4, 3, 4, 4, 3,
4, 4, 3, 3, 3, 3, 3, 3, 3, 3, 2, 2, 3, 2, 3, 2, 2, 1, 1, 2, 2, 3, 2, 1, 2, 2, 2,
1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 2, 2, 1, 1, 2, 1, 1, 1, 0, 1, 0, 1, 1, 1, 0, 1,
0, 1, 1, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1,
0, -1, 0, 0, 0, -1, 0, 0, -1, -1, 0, 0, 0, -1, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0,
0, -1, -1, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, -1, -1, -1, -1, -1, -1, -1, 0, -1, 0,
-1, -1, 0, -1, -1, 0, 0, -1, -1, -1, -1, 0, -1, -1, -1, 0, -1, 0, -1, 0, 0, -1,
0, 0, -1, -1, -1, -1, -1, -1, 0, -1, -1, -1, -1, -1, -1, -1, -1, 0, -1, -1, -1,
0, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, 0, -1, -1, 0, 0, -1, -1, -1, -1,
-1, 0, -1, -1, -1, -1, 0, -1, -1, 0, -2, -1, -1, -1, -1, -1, -1, -1, -1, -1, 0,
-1, -1, -1, -1, 0, 0, 0, -1, -1, -1, -1, -1, -1, 0, -1, -1, 0, -1, -1, 0, -1, 0,
-1, -1, 0, -2, -1, 0, -1, -1, -1, -1, 0, 0, -1, 0, -1, 0, 0, -2, -1, 0, -1, 0,
0, -1, -1, -1, -2, 0, -1, -2, 1, -2, 0, -1, -1, -2, 0, -3, 0, -2, -1, 0, -1, -2,
-1, -1, -1, 1, -3, 0, -1, 0, -3, 3, -6, 6, -6, 2, -4, 5, -11, 13, -16, 6, 14,
-128, -108, -125, -117, -120, -120, -117, -120, -66, -16, };