#define DATA_LENGTH 512
#define DATA AKWF_1721

const PROGMEM int8_t DATA[DATA_LENGTH] = {13, 46, 67, 81, 91, 97, 103, 106, 109,
110, 113, 113, 115, 116, 117, 118, 119, 118, 119, 119, 119, 119, 120, 119, 119,
119, 118, 119, 118, 118, 117, 118, 117, 117, 117, 116, 116, 116, 115, 116, 114,
115, 114, 113, 113, 112, 112, 112, 113, 111, 111, 112, 111, 110, 110, 109, 109,
108, 109, 107, 107, 107, 107, 107, 106, 105, 105, 105, 105, 104, 104, 103, 103,
103, 101, 102, 101, 101, 99, 99, 98, 98, 98, 98, 97, 96, 96, 96, 96, 95, 94, 94,
93, 93, 93, 92, 91, 90, 90, 90, 89, 89, 88, 87, 87, 86, 86, 85, 84, 84, 84, 82,
82, 81, 80, 80, 79, 78, 77, 77, 76, 75, 75, 74, 73, 72, 72, 72, 70, 70, 68, 68,
67, 66, 65, 64, 64, 63, 62, 60, 60, 59, 59, 57, 56, 56, 55, 53, 53, 52, 50, 49,
49, 48, 47, 45, 44, 43, 43, 40, 40, 39, 38, 35, 35, 34, 32, 32, 31, 30, 28, 27,
25, 24, 23, 21, 20, 19, 17, 16, 14, 14, 11, 10, 8, 7, 6, 5, 3, 2, 0, -2, -2, -4,
-5, -7, -9, -10, -12, -14, -16, -17, -18, -21, -21, -24, -25, -26, -28, -30,
-32, -34, -35, -36, -38, -40, -42, -44, -45, -46, -48, -51, -52, -54, -56, -58,
-59, -62, -63, -66, -67, -68, -70, -72, -75, -76, -78, -80, -81, -82, -85, -87,
-88, -90, -92, -93, -95, -95, -94, -93, -92, -91, -90, -90, -87, -86, -86, -85,
-84, -83, -82, -81, -80, -79, -77, -77, -76, -75, -74, -73, -73, -72, -70, -70,
-69, -68, -67, -67, -65, -64, -63, -63, -61, -61, -61, -59, -58, -57, -57, -57,
-56, -55, -53, -53, -53, -52, -52, -50, -49, -49, -48, -48, -46, -47, -47, -45,
-44, -45, -44, -44, -42, -42, -41, -41, -40, -40, -40, -39, -38, -39, -38, -37,
-37, -37, -36, -36, -35, -35, -35, -35, -35, -33, -33, -33, -33, -32, -32, -32,
-31, -31, -31, -31, -31, -31, -30, -31, -30, -30, -31, -30, -30, -29, -29, -29,
-29, -30, -30, -29, -29, -29, -29, -28, -28, -29, -29, -29, -29, -29, -29, -29,
-28, -30, -29, -29, -29, -30, -29, -29, -30, -29, -29, -30, -30, -30, -30, -31,
-30, -30, -31, -32, -31, -31, -31, -32, -32, -32, -32, -32, -33, -33, -33, -32,
-33, -33, -33, -34, -34, -34, -35, -35, -35, -36, -35, -36, -36, -36, -37, -37,
-38, -38, -37, -38, -38, -39, -39, -39, -40, -39, -41, -41, -41, -41, -41, -42,
-43, -42, -43, -43, -43, -43, -45, -44, -45, -44, -45, -46, -46, -47, -47, -47,
-48, -48, -49, -49, -48, -50, -50, -50, -51, -50, -52, -52, -52, -53, -53, -54,
-54, -54, -54, -55, -55, -55, -55, -56, -57, -57, -58, -58, -58, -59, -59, -59,
-61, -60, -60, -61, -61, -61, -62, -63, -62, -64, -64, -65, -65, -66, -65, -66,
-66, -67, -66, -68, -67, -69, -68, -69, -56, -35, -29, -54, -85, -28, };