#define DATA_LENGTH 512
#define DATA AKWF_1701

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 7, 10, 13, 16, 19, 22, 25, 28,
31, 34, 37, 39, 43, 44, 47, 49, 51, 53, 55, 57, 58, 60, 62, 64, 65, 68, 70, 71,
72, 73, 75, 76, 77, 80, 80, 82, 83, 84, 85, 87, 87, 88, 89, 90, 91, 91, 92, 93,
94, 95, 95, 95, 95, 94, 94, 94, 93, 93, 92, 91, 93, 91, 91, 92, 91, 91, 91, 91,
90, 91, 90, 89, 89, 89, 88, 88, 86, 86, 85, 85, 84, 82, 81, 81, 79, 78, 76, 75,
74, 74, 72, 71, 69, 69, 67, 66, 64, 62, 61, 59, 57, 55, 53, 51, 50, 48, 46, 45,
42, 40, 39, 36, 33, 31, 29, 27, 25, 23, 21, 19, 17, 14, 13, 11, 8, 6, 4, 1, -2,
-4, -6, -8, -10, -12, -14, -16, -18, -20, -22, -24, -25, -28, -29, -31, -33,
-34, -36, -37, -39, -40, -41, -41, -41, -43, -44, -44, -45, -44, -45, -45, -46,
-47, -46, -48, -47, -48, -48, -49, -49, -48, -48, -47, -48, -47, -46, -44, -44,
-43, -42, -40, -40, -39, -38, -37, -36, -36, -34, -33, -33, -32, -32, -32, -30,
-30, -30, -30, -28, -28, -27, -28, -27, -25, -25, -24, -22, -23, -22, -22, -21,
-22, -22, -21, -21, -20, -19, -18, -16, -15, -14, -13, -10, -9, -7, -6, -4, -3,
-1, 0, 2, 3, 4, 5, 6, 8, 10, 11, 13, 15, 15, 18, 19, 20, 22, 23, 24, 25, 26, 27,
27, 30, 31, 32, 35, 35, 38, 40, 41, 43, 45, 47, 49, 50, 52, 53, 55, 58, 60, 61,
64, 66, 67, 69, 70, 71, 73, 74, 75, 76, 75, 77, 77, 79, 79, 79, 80, 80, 79, 80,
80, 80, 81, 81, 82, 81, 82, 81, 81, 80, 80, 80, 80, 79, 80, 79, 79, 79, 78, 77,
76, 75, 74, 73, 71, 69, 68, 67, 65, 64, 63, 62, 61, 60, 59, 58, 56, 55, 54, 52,
51, 49, 48, 45, 44, 44, 41, 40, 37, 35, 32, 30, 27, 26, 24, 21, 20, 18, 15, 13,
12, 9, 6, 3, 2, -2, -4, -7, -9, -12, -14, -16, -18, -20, -23, -26, -28, -32,
-33, -36, -39, -42, -45, -47, -50, -53, -55, -58, -60, -63, -65, -68, -69, -71,
-74, -77, -79, -80, -82, -84, -86, -87, -91, -93, -93, -96, -97, -98, -101,
-101, -104, -105, -107, -109, -109, -112, -112, -114, -114, -115, -115, -116,
-115, -115, -116, -117, -116, -116, -117, -118, -118, -118, -119, -119, -119,
-119, -119, -119, -118, -117, -117, -115, -114, -113, -112, -112, -110, -109,
-109, -107, -107, -105, -104, -104, -102, -101, -99, -98, -97, -96, -95, -94,
-93, -92, -91, -90, -88, -88, -87, -85, -84, -82, -80, -80, -78, -78, -78, -78,
-76, -76, -75, -74, -72, -71, -71, -69, -67, -65, -63, -61, -60, -57, -54, -53,
-52, -50, -48, -48, -45, -43, -42, -40, -38, -36, -34, -32, -30, -28, -25, -24,
-21, -20, -18, -16, -14, -12, -9, -8, -7, -4, -2, 0, };