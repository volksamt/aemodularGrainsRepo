#define DATA_LENGTH 512
#define DATA AKWF_1741

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 22, 36, 50, 62, 73, 83, 93, 99,
107, 112, 115, 118, 118, 119, 118, 115, 111, 107, 102, 95, 89, 81, 74, 65, 58,
49, 42, 34, 25, 18, 11, 3, -3, -9, -14, -19, -24, -27, -31, -33, -35, -37, -38,
-38, -39, -38, -38, -37, -36, -33, -33, -31, -28, -26, -24, -21, -19, -17, -14,
-11, -9, -7, -5, -3, -1, 0, 2, 4, 4, 5, 6, 7, 8, 8, 8, 8, 8, 9, 8, 7, 8, 7, 7,
6, 6, 5, 5, 4, 3, 3, 2, 1, 1, 1, 0, 1, 0, -2, -1, -1, -2, -1, -2, -2, -2, -2,
-2, -3, -3, -3, -3, -3, -2, -3, -3, -2, -2, -2, -2, -1, -2, -1, -1, -2, -1, -1,
-1, -1, -1, -1, -1, -1, -1, 0, 0, -1, 0, 0, -1, 0, -1, 0, 1, 0, 0, 0, 0, -1, 0,
0, -1, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, -1, -1, 0, -1, -1,
0, -1, 0, -1, -1, -1, -2, -1, -1, -1, 0, 0, 0, 0, -1, 0, 0, -1, -1, 0, 0, 0, 0,
-1, 0, 0, 0, -1, 0, 0, 0, -1, -1, 0, 0, 0, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, -1,
0, -1, 0, 0, 0, 0, -1, 0, -1, -1, 0, -1, 1, -1, 0, 0, 0, -1, -1, -1, -1, 0, 0,
0, 0, -1, 0, -1, 0, -1, 0, -1, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, -1, 0, 0, -1,
0, 0, -1, 0, -1, 0, 0, 0, -1, -1, -1, 0, 0, -1, 0, 0, -1, 0, -1, 0, 0, 0, -1,
-1, 0, 0, -1, -1, 0, -1, 0, 0, 0, 0, 0, -1, 1, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0,
0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0,
-1, -1, 0, -1, 0, -1, 1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, -1,
0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, -1, 0, 0, 1, -1, 0, 0,
0, -1, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, -1, -1, 0, 1, -1, 0, 0, 0,
0, -1, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1,
0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, -1, 0, 0, -1, -1, 0, -1, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, -1, -5, -12,
-23, -34, -46, -60, -72, -83, -94, -102, -108, -112, -113, -112, -108, -103,
-96, -87, -77, -65, -52, -39, -24, -9, 0, };