#define DATA_LENGTH 512
#define DATA AKWF_1732

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 7, 9, 10, 12, 14, 15, 17, 18,
19, 21, 22, 23, 24, 24, 25, 26, 26, 27, 28, 29, 29, 29, 30, 31, 30, 30, 31, 32,
31, 31, 32, 33, 32, 32, 32, 32, 32, 33, 32, 32, 32, 33, 32, 32, 32, 32, 32, 32,
32, 31, 32, 31, 31, 31, 32, 31, 30, 31, 30, 30, 30, 30, 30, 30, 29, 29, 30, 30,
29, 29, 29, 29, 30, 29, 29, 29, 28, 28, 28, 28, 29, 28, 28, 28, 29, 28, 27, 27,
28, 27, 28, 27, 28, 27, 27, 27, 28, 28, 27, 28, 28, 27, 27, 27, 28, 27, 28, 28,
28, 28, 28, 27, 28, 28, 28, 28, 28, 28, 28, 28, 28, 29, 28, 30, 28, 29, 29, 29,
29, 30, 30, 30, 29, 30, 30, 30, 31, 31, 31, 31, 31, 31, 31, 30, 31, 31, 31, 31,
31, 31, 31, 31, 32, 32, 32, 32, 32, 32, 31, 32, 31, 31, 31, 30, 31, 30, 30, 29,
29, 29, 28, 28, 27, 26, 26, 26, 25, 24, 22, 21, 21, 19, 17, 16, 16, 14, 13, 11,
10, 8, 6, 3, 1, -1, -3, -6, -8, -10, -13, -17, -19, -22, -26, -29, -34, -37,
-40, -44, -48, -53, -56, -61, -66, -70, -75, -79, -85, -89, -95, -98, -103,
-108, -113, -118, -115, -109, -105, -100, -96, -91, -86, -82, -78, -73, -69,
-65, -61, -57, -53, -50, -46, -42, -39, -35, -32, -29, -26, -24, -21, -18, -16,
-13, -12, -10, -7, -5, -4, -2, -1, 0, 3, 3, 5, 5, 6, 8, 8, 9, 9, 10, 11, 11, 12,
11, 13, 12, 13, 13, 13, 13, 14, 13, 13, 13, 14, 14, 13, 13, 12, 13, 12, 12, 12,
12, 11, 12, 12, 11, 11, 11, 11, 9, 10, 9, 9, 9, 9, 8, 8, 8, 7, 7, 7, 7, 6, 6, 6,
6, 6, 5, 5, 4, 4, 4, 4, 4, 3, 3, 3, 3, 3, 3, 2, 2, 2, 2, 1, 1, 1, 2, 2, 1, 1, 1,
1, 1, 2, 1, 1, 1, 1, 1, 2, 2, 0, 1, 0, 1, 2, 1, 1, 1, 1, 1, 2, 2, 2, 1, 2, 2, 2,
2, 3, 3, 3, 3, 3, 4, 4, 4, 5, 5, 5, 6, 5, 6, 6, 6, 6, 7, 7, 7, 7, 8, 8, 8, 8, 8,
9, 9, 9, 10, 11, 11, 11, 11, 12, 11, 12, 12, 12, 12, 13, 12, 13, 13, 13, 13, 14,
13, 13, 14, 12, 13, 12, 13, 13, 12, 12, 12, 12, 11, 10, 9, 10, 9, 7, 7, 6, 4, 4,
3, 1, 0, -1, -3, -5, -6, -8, -10, -12, -14, -17, -19, -21, -24, -26, -29, -33,
-36, -39, -42, -45, -49, -53, -56, -62, -65, -69, -73, -77, -82, -87, -91, -96,
-100, -105, -110, -115, -118, -113, -108, -103, -98, -93, -88, -83, -78, -73,
-69, -64, -60, -56, -52, -47, -43, -40, -35, -32, -28, -25, -22, -18, -15, -13,
-10, -6, -4, -1, };