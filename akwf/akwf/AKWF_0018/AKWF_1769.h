#define DATA_LENGTH 512
#define DATA AKWF_1769

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 2, 4, 6, 7, 8, 10, 12, 13, 14, 15,
17, 18, 20, 22, 23, 25, 26, 27, 29, 30, 32, 34, 35, 37, 38, 39, 41, 41, 43, 45,
47, 48, 49, 51, 52, 54, 56, 57, 58, 60, 61, 62, 64, 65, 67, 68, 69, 70, 73, 74,
76, 76, 78, 80, 82, 82, 85, 85, 87, 89, 90, 92, 92, 94, 96, 98, 97, 101, 100,
105, 103, 108, 105, 112, 108, 115, 109, 119, 111, 125, 108, 4, -25, -67, -61,
-61, -61, -60, -61, -58, -62, -57, -60, -56, -59, -56, -59, -55, -57, -54, -56,
-55, -55, -54, -54, -53, -53, -52, -52, -51, -51, -51, -50, -51, -49, -49, -48,
-48, -47, -48, -46, -47, -45, -46, -45, -45, -44, -44, -43, -43, -42, -43, -42,
-41, -41, -40, -40, -40, -39, -40, -38, -38, -38, -38, -37, -36, -36, -35, -36,
-35, -34, -34, -33, -32, -33, -33, -32, -31, -31, -30, -31, -30, -29, -29, -29,
-28, -27, -27, -26, -25, -24, -23, -23, -22, -22, -20, -18, -18, -17, -15, -15,
-14, -13, -13, -12, -11, -10, -8, -8, -7, -7, -6, -4, -3, -4, -4, -4, -4, -4,
-4, -4, -4, -3, -4, -4, -5, -3, -3, -4, -4, -4, -4, -4, -4, -5, -4, -4, -4, -4,
-4, -4, -4, -4, -4, -3, -4, -4, -4, -4, -4, -4, -3, -4, -4, -3, -4, -4, -4, -4,
-4, -5, -4, -4, -4, -4, -5, -3, -4, -3, -5, 0, 10, 7, 8, 8, 7, 8, 7, 8, 7, 7, 6,
6, 6, 6, 6, 6, 6, 6, 6, 5, 6, 5, 5, 4, 5, 5, 4, 4, 5, 4, 4, 3, 4, 3, 4, 3, 3, 3,
3, 2, 3, 3, 2, 2, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, -1, 0, 0, -1, 0, -1,
-1, -1, -2, -2, -1, -1, -1, -1, -2, -2, -3, -3, -3, -3, -3, -3, -4, -3, -4, -4,
-4, -4, -5, -4, -5, -4, -4, -4, -4, -4, -4, -5, -4, -4, -4, -4, -4, -3, -4, -4,
-4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -3, -3, -4, -4, -4, -3, -4, -4, -4,
-4, -3, -4, -4, -4, -4, -5, -4, -4, -3, -4, -4, -4, -3, -4, -4, -4, -4, -4, -4,
-5, -3, -4, -4, -4, -4, -4, -4, -3, -3, -3, -4, -4, -4, -4, -4, -3, -4, -3, -4,
-4, -4, -4, -4, -3, -4, -4, -4, -3, -4, -3, -4, -3, -4, -4, -3, -4, -3, -4, -4,
-4, -4, -4, -5, -4, -4, -3, -4, -3, -3, -4, -4, -3, -5, -5, -4, -4, -3, -3, -3,
-4, -3, -4, -4, -4, -4, -3, -4, -3, -3, -3, -4, -4, -3, -4, -4, -4, -4, -5, -4,
-4, -4, -4, -4, -4, -4, -3, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -3, -3,
-4, -4, -3, -4, -4, -4, -4, -4, -4, -4, -4, -4, -4, -3, -1, 0, };