#define DATA_LENGTH 512
#define DATA AKWF_1791

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 17, 21, 26, 32, 37, 41, 45, 49,
53, 57, 60, 63, 67, 69, 71, 74, 77, 79, 81, 82, 85, 87, 89, 90, 93, 94, 94, 95,
94, 95, 95, 96, 96, 97, 98, 98, 99, 100, 100, 101, 102, 103, 104, 104, 106, 106,
107, 107, 108, 110, 110, 111, 112, 113, 113, 114, 115, 116, 116, 117, 118, 119,
117, 118, 119, 118, 118, 118, 118, 120, 119, 120, 119, 120, 120, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 118, 118, 118, 118, 118, 118, 118, 118, 118,
117, 117, 117, 116, 117, 116, 116, 116, 116, 116, 115, 116, 115, 114, 115, 115,
114, 114, 114, 113, 113, 113, 114, 113, 112, 113, 112, 111, 112, 111, 111, 111,
111, 110, 110, 109, 109, 109, 109, 109, 108, 108, 107, 107, 107, 105, 105, 104,
104, 104, 102, 103, 102, 102, 101, 100, 100, 101, 100, 100, 99, 98, 98, 98, 97,
98, 97, 97, 96, 96, 96, 96, 95, 95, 96, 93, 78, 65, 54, 44, 37, 28, 20, 13, 6,
0, -6, -11, -17, -22, -25, -30, -34, -37, -40, -44, -46, -48, -51, -53, -55,
-57, -60, -61, -62, -64, -65, -66, -68, -69, -69, -71, -70, -72, -72, -73, -73,
-75, -75, -75, -75, -75, -75, -76, -76, -75, -76, -76, -76, -76, -76, -76, -76,
-76, -75, -75, -75, -76, -74, -74, -74, -74, -74, -73, -73, -73, -73, -72, -71,
-71, -71, -71, -71, -70, -69, -70, -69, -68, -68, -67, -68, -67, -66, -66, -65,
-65, -64, -64, -63, -64, -62, -63, -62, -61, -61, -60, -60, -59, -58, -58, -57,
-57, -57, -57, -56, -56, -56, -55, -53, -54, -53, -53, -53, -52, -52, -51, -51,
-50, -49, -49, -49, -49, -47, -48, -46, -46, -46, -45, -45, -45, -44, -43, -44,
-42, -42, -42, -42, -41, -41, -44, -47, -51, -53, -55, -58, -60, -61, -64, -65,
-66, -69, -69, -70, -72, -74, -75, -76, -76, -77, -78, -78, -79, -79, -80, -81,
-81, -83, -82, -82, -83, -83, -84, -84, -84, -84, -84, -84, -85, -86, -84, -82,
-78, -75, -72, -68, -66, -64, -62, -61, -58, -57, -55, -54, -52, -52, -50, -50,
-49, -47, -46, -47, -45, -44, -44, -44, -43, -43, -42, -42, -42, -42, -42, -41,
-41, -41, -41, -41, -40, -40, -41, -40, -40, -40, -40, -40, -40, -40, -40, -41,
-40, -40, -40, -41, -40, -40, -39, -40, -41, -41, -40, -40, -40, -41, -41, -41,
-41, -41, -41, -41, -41, -42, -42, -42, -41, -42, -43, -42, -42, -42, -42, -42,
-43, -42, -43, -43, -44, -44, -43, -44, -44, -43, -43, -44, -43, -44, -44, -44,
-43, -44, -44, -45, -44, -44, -45, -44, -44, -45, -45, -45, -45, -45, -45, -44,
-44, -45, -45, -45, -44, -45, -44, -45, -46, -45, -45, -45, -45, -44, -45, -45,
-45, -44, -45, -44, -45, -45, -45, -45, -45, -45, -45, -45, -45, -44, -42, -38,
-36, -34, -31, -29, -28, -26, -25, -22, -16, -8, -2, };