#define DATA_LENGTH 512
#define DATA AKWF_1709

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 11, 20, 28, 36, 44, 51, 59, 66, 73,
79, 86, 92, 97, 102, 107, 111, 113, 116, 118, 119, 119, 119, 118, 116, 114, 111,
107, 103, 98, 94, 89, 85, 80, 75, 70, 66, 62, 57, 54, 51, 48, 46, 43, 41, 40,
38, 38, 38, 38, 38, 39, 39, 40, 41, 42, 44, 46, 46, 48, 49, 50, 50, 51, 51, 53,
53, 52, 52, 51, 51, 50, 49, 47, 47, 44, 43, 41, 39, 38, 36, 33, 32, 29, 28, 26,
24, 23, 22, 20, 19, 17, 18, 17, 15, 14, 13, 13, 13, 14, 13, 14, 13, 12, 13, 14,
14, 14, 13, 14, 13, 13, 13, 13, 13, 12, 13, 11, 11, 11, 9, 8, 9, 8, 7, 6, 5, 5,
3, 3, 2, 2, 0, 0, -1, -3, -3, -3, -4, -4, -5, -5, -6, -6, -6, -7, -8, -8, -8,
-8, -9, -9, -9, -9, -9, -10, -10, -9, -10, -11, -11, -12, -12, -12, -12, -13,
-13, -14, -14, -14, -16, -15, -17, -17, -17, -18, -17, -19, -20, -20, -19, -20,
-21, -22, -21, -21, -22, -23, -22, -24, -24, -24, -24, -25, -25, -25, -25, -26,
-26, -26, -27, -27, -26, -27, -27, -28, -28, -28, -29, -28, -29, -28, -29, -29,
-30, -29, -30, -30, -31, -31, -31, -31, -32, -33, -33, -33, -33, -34, -35, -34,
-34, -35, -36, -35, -35, -36, -36, -36, -37, -36, -36, -37, -37, -37, -35, -34,
-32, -30, -28, -24, -22, -19, -16, -12, -8, -5, -1, 1, 4, 7, 10, 12, 13, 15, 17,
19, 20, 21, 23, 24, 27, 29, 30, 31, 33, 35, 36, 37, 39, 39, 40, 41, 42, 42, 42,
43, 42, 42, 41, 40, 39, 38, 37, 34, 34, 32, 30, 28, 26, 24, 22, 19, 18, 16, 15,
13, 12, 10, 9, 7, 7, 5, 5, 4, 4, 3, 3, 2, 2, 2, 3, 2, 3, 2, 3, 4, 4, 4, 4, 5, 4,
5, 5, 5, 4, 5, 4, 4, 3, 3, 3, 2, 2, 1, 0, 0, -2, -2, -4, -4, -5, -5, -7, -7, -8,
-10, -9, -10, -11, -13, -13, -14, -14, -14, -15, -16, -16, -17, -18, -17, -18,
-18, -17, -17, -18, -17, -18, -19, -18, -19, -19, -19, -19, -19, -19, -19, -19,
-19, -19, -19, -20, -20, -20, -21, -21, -21, -21, -22, -23, -22, -23, -23, -24,
-24, -25, -25, -26, -26, -26, -26, -27, -27, -28, -28, -28, -29, -29, -29, -30,
-30, -31, -30, -31, -31, -31, -32, -32, -32, -33, -33, -33, -33, -33, -33, -34,
-33, -35, -35, -34, -34, -35, -35, -35, -35, -36, -35, -36, -36, -37, -37, -36,
-37, -38, -36, -38, -37, -38, -38, -38, -38, -39, -38, -38, -39, -39, -39, -39,
-40, -39, -40, -40, -40, -40, -41, -41, -41, -41, -41, -41, -42, -42, -43, -42,
-43, -43, -42, -42, -43, -43, -44, -44, -44, -44, -43, -44, -44, -44, -44, -44,
-44, -43, -42, -40, -38, -36, -33, -29, -26, -20, -15, -9, -2, };