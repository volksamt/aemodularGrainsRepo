#define DATA_LENGTH 512
#define DATA AKWF_1735

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 10, 14, 18, 22, 25, 29, 33, 37,
40, 44, 48, 53, 56, 60, 63, 67, 71, 75, 78, 82, 85, 89, 93, 96, 101, 103, 106,
112, 115, 118, 119, 118, 119, 120, 119, 119, 118, 119, 120, 119, 119, 119, 119,
119, 118, 119, 119, 119, 118, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119,
119, 118, 119, 118, 118, 118, 118, 119, 118, 119, 118, 118, 119, 119, 118, 118,
118, 118, 119, 119, 118, 118, 118, 118, 118, 119, 118, 119, 118, 119, 119, 118,
118, 118, 118, 119, 118, 118, 118, 119, 118, 118, 118, 118, 118, 118, 118, 118,
118, 117, 118, 117, 118, 118, 117, 117, 118, 118, 117, 118, 118, 117, 118, 118,
118, 118, 118, 117, 117, 117, 118, 118, 117, 117, 117, 118, 118, 117, 117, 118,
117, 117, 117, 118, 118, 118, 117, 117, 117, 118, 118, 117, 118, 118, 117, 117,
117, 117, 117, 118, 117, 116, 117, 117, 118, 117, 117, 117, 117, 117, 118, 117,
117, 116, 117, 117, 116, 117, 117, 116, 117, 117, 117, 117, 117, 117, 116, 117,
117, 117, 117, 116, 117, 117, 117, 117, 116, 116, 117, 117, 116, 117, 116, 116,
116, 116, 117, 117, 116, 117, 116, 117, 117, 117, 116, 116, 116, 116, 116, 116,
116, 116, 117, 115, 113, 110, 106, 102, 98, 96, 91, 87, 84, 80, 77, 73, 69, 66,
62, 58, 55, 51, 47, 43, 39, 36, 31, 28, 24, 20, 16, 12, 9, 5, 1, -3, -6, -11,
-14, -19, -21, -26, -29, -33, -37, -41, -45, -49, -53, -56, -60, -63, -67, -71,
-75, -77, -82, -87, -89, -93, -97, -100, -104, -108, -111, -115, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -118, -119, -119,
-119, -119, -120, -119, -118, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -118, -119, -119, -118, -119,
-118, -119, -119, -118, -119, -119, -119, -118, -119, -118, -118, -118, -118,
-118, -118, -118, -119, -119, -119, -118, -118, -117, -118, -118, -118, -118,
-119, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -117, -118,
-118, -119, -118, -118, -118, -117, -118, -117, -118, -118, -118, -117, -118,
-118, -118, -118, -118, -117, -118, -118, -118, -118, -118, -118, -117, -117,
-117, -117, -117, -117, -118, -117, -118, -118, -117, -118, -117, -117, -117,
-118, -118, -117, -118, -117, -117, -117, -117, -116, -117, -117, -117, -117,
-117, -117, -118, -117, -117, -117, -117, -117, -117, -117, -117, -117, -116,
-117, -117, -117, -117, -117, -117, -117, -117, -116, -117, -117, -117, -116,
-117, -117, -117, -117, -117, -116, -117, -116, -116, -116, -116, -116, -117,
-116, -116, -116, -117, -116, -116, -117, -116, -117, -116, -117, -117, -116,
-117, -116, -116, -117, -116, -116, -117, -117, -116, -115, -113, -109, -106,
-101, -99, -95, -91, -87, -84, -80, -77, -73, -69, -66, -62, -58, -54, -50, -47,
-42, -38, -35, -31, -27, -23, -21, -16, -13, -8, -5, -1, };