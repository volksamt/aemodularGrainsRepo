#define DATA_LENGTH 512
#define DATA AKWF_1757

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 6, 8, 11, 14, 17, 20, 23, 25,
27, 30, 32, 35, 38, 40, 43, 45, 48, 49, 51, 54, 56, 58, 60, 61, 64, 66, 67, 69,
71, 73, 74, 76, 77, 78, 80, 81, 82, 84, 85, 86, 87, 88, 89, 88, 89, 91, 91, 91,
92, 93, 92, 93, 93, 94, 92, 93, 93, 94, 93, 93, 93, 92, 91, 92, 91, 91, 89, 89,
88, 87, 87, 86, 84, 85, 83, 82, 81, 80, 78, 77, 76, 74, 73, 72, 71, 70, 68, 66,
65, 63, 62, 61, 59, 56, 56, 54, 52, 50, 49, 47, 45, 44, 41, 40, 38, 37, 34, 33,
32, 28, 27, 26, 24, 23, 20, 18, 17, 15, 13, 12, 10, 8, 6, 5, 3, 1, -1, -2, -3,
-4, -6, -8, -9, -11, -13, -13, -14, -16, -17, -19, -21, -22, -23, -23, -25, -26,
-26, -28, -29, -30, -30, -32, -33, -33, -34, -35, -36, -35, -37, -37, -37, -39,
-39, -39, -40, -40, -39, -41, -41, -42, -42, -42, -42, -41, -42, -42, -41, -41,
-42, -42, -41, -41, -41, -41, -41, -40, -40, -40, -39, -39, -38, -38, -38, -37,
-37, -36, -36, -35, -34, -34, -34, -33, -32, -31, -32, -29, -29, -29, -27, -27,
-26, -26, -25, -24, -24, -23, -23, -22, -21, -21, -19, -19, -18, -18, -18, -17,
-16, -17, -17, -16, -16, -15, -15, -15, -14, -13, -13, -13, -12, -11, -11, -10,
-10, -8, -8, -8, -7, -5, -5, -4, -3, -3, -2, -1, 0, 1, 2, 3, 4, 5, 6, 8, 9, 9,
10, 11, 12, 15, 15, 16, 17, 18, 19, 21, 23, 23, 25, 26, 27, 29, 30, 31, 32, 33,
33, 36, 36, 37, 40, 40, 41, 42, 43, 44, 46, 47, 47, 49, 50, 51, 52, 53, 53, 55,
56, 57, 56, 58, 59, 60, 60, 61, 61, 63, 63, 63, 63, 65, 64, 65, 66, 66, 66, 67,
67, 66, 67, 67, 67, 66, 67, 67, 66, 66, 66, 65, 65, 65, 64, 64, 62, 63, 62, 62,
61, 60, 59, 58, 56, 56, 55, 54, 53, 52, 50, 49, 47, 47, 45, 43, 41, 40, 38, 37,
35, 34, 33, 30, 28, 27, 25, 23, 21, 18, 16, 15, 13, 10, 8, 6, 4, 2, -1, -3, -5,
-7, -9, -12, -14, -17, -19, -21, -23, -26, -28, -31, -33, -35, -37, -40, -43,
-45, -47, -50, -52, -54, -57, -59, -61, -63, -65, -68, -70, -72, -75, -76, -78,
-80, -82, -84, -86, -88, -90, -92, -94, -96, -96, -98, -100, -101, -104, -104,
-105, -107, -108, -110, -110, -111, -112, -114, -114, -116, -116, -116, -117,
-117, -117, -118, -119, -119, -119, -119, -118, -119, -119, -119, -118, -118,
-117, -117, -117, -115, -114, -114, -114, -111, -111, -109, -108, -107, -106,
-104, -103, -102, -100, -98, -97, -95, -91, -90, -87, -83, -81, -78, -76, -74,
-71, -67, -64, -61, -58, -55, -53, -50, -47, -44, -41, -38, -34, -32, -28, -26,
-23, -20, -17, -14, -10, -8, -6, -2, };