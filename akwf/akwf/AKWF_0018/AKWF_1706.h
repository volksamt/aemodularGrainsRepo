#define DATA_LENGTH 512
#define DATA AKWF_1706

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 12, 19, 25, 31, 36, 40, 45, 47,
50, 53, 54, 55, 55, 56, 56, 57, 58, 58, 59, 62, 62, 65, 68, 69, 71, 74, 77, 79,
81, 83, 86, 87, 89, 90, 90, 90, 90, 88, 88, 87, 85, 83, 81, 78, 76, 73, 71, 67,
65, 63, 60, 58, 56, 53, 52, 52, 50, 49, 48, 48, 48, 47, 47, 47, 48, 48, 49, 49,
49, 48, 49, 50, 49, 49, 48, 48, 47, 46, 45, 44, 42, 40, 39, 37, 36, 34, 31, 30,
28, 27, 24, 22, 20, 19, 18, 16, 15, 14, 13, 12, 12, 11, 11, 10, 9, 9, 9, 8, 8,
8, 7, 8, 8, 6, 6, 5, 6, 5, 4, 4, 3, 3, 2, 3, 4, 6, 9, 11, 15, 20, 24, 28, 33,
39, 45, 49, 53, 58, 61, 65, 66, 69, 69, 69, 69, 67, 65, 63, 59, 56, 52, 46, 43,
38, 33, 28, 24, 21, 17, 14, 11, 8, 7, 6, 5, 5, 4, 5, 6, 7, 8, 10, 12, 13, 16,
17, 18, 19, 22, 22, 22, 23, 23, 23, 22, 22, 19, 19, 17, 15, 13, 11, 7, 5, 3, 0,
-1, -4, -7, -9, -11, -12, -14, -15, -17, -17, -17, -18, -18, -19, -18, -17, -17,
-17, -15, -16, -15, -14, -14, -15, -14, -14, -14, -14, -14, -15, -15, -17, -17,
-18, -19, -21, -22, -23, -25, -25, -26, -29, -29, -31, -32, -33, -33, -35, -35,
-37, -38, -41, -42, -45, -50, -53, -58, -63, -68, -74, -78, -84, -90, -96, -101,
-105, -110, -112, -115, -118, -119, -119, -118, -116, -113, -108, -101, -95,
-87, -78, -67, -59, -48, -39, -29, -20, -11, -4, 3, 10, 14, 18, 19, 21, 20, 18,
15, 11, 5, 0, -6, -12, -19, -25, -33, -39, -45, -50, -55, -60, -64, -66, -68,
-69, -69, -69, -67, -64, -61, -57, -54, -49, -44, -39, -35, -31, -25, -22, -19,
-16, -13, -11, -10, -8, -9, -8, -10, -11, -14, -15, -18, -21, -25, -28, -31,
-35, -38, -41, -44, -46, -49, -51, -53, -53, -54, -54, -55, -54, -53, -52, -50,
-48, -48, -45, -42, -41, -39, -37, -35, -33, -31, -30, -30, -29, -29, -29, -29,
-29, -31, -31, -31, -31, -31, -31, -29, -27, -25, -22, -18, -15, -11, -6, -1, 4,
9, 14, 18, 22, 26, 29, 31, 33, 35, 36, 36, 35, 34, 33, 30, 27, 25, 22, 18, 16,
11, 7, 6, 1, -1, -3, -5, -8, -9, -9, -10, -11, -10, -10, -8, -7, -6, -5, -2, 0,
2, 3, 4, 6, 8, 9, 10, 10, 10, 11, 11, 9, 9, 8, 6, 6, 4, 2, 0, -2, -4, -6, -7,
-10, -11, -13, -15, -16, -17, -18, -18, -19, -19, -20, -20, -20, -18, -19, -18,
-18, -16, -16, -16, -15, -15, -14, -13, -14, -13, -14, -14, -14, -15, -15, -15,
-16, -17, -19, -18, -20, -20, -21, -23, -23, -25, -26, -26, -27, -27, -28, -29,
-28, -27, -26, -24, -21, -17, -13, -8, -3, };