#define DATA_LENGTH 512
#define DATA AKWF_1739

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 12, 17, 24, 29, 35, 41, 46, 52,
60, 68, 74, 81, 88, 94, 100, 104, 107, 110, 111, 113, 114, 114, 115, 116, 115,
116, 117, 117, 118, 119, 119, 118, 117, 114, 113, 108, 105, 101, 96, 91, 87, 83,
79, 76, 72, 69, 67, 63, 59, 55, 50, 46, 41, 36, 32, 26, 21, 17, 12, 8, 5, 2, 0,
-5, -6, -9, -12, -15, -17, -20, -24, -26, -29, -30, -33, -36, -37, -38, -39,
-39, -40, -39, -39, -40, -40, -40, -40, -41, -41, -41, -42, -41, -41, -41, -40,
-39, -38, -36, -35, -34, -32, -30, -30, -28, -28, -26, -25, -24, -22, -23, -22,
-20, -19, -16, -15, -13, -12, -11, -9, -9, -7, -6, -5, -4, -4, -2, -3, -1, 0, 0,
1, 2, 3, 4, 4, 5, 4, 6, 7, 7, 6, 7, 7, 6, 7, 7, 7, 7, 7, 8, 7, 8, 8, 7, 7, 7, 6,
7, 7, 6, 5, 5, 5, 5, 4, 5, 4, 4, 4, 3, 3, 3, 2, 2, 2, 1, 1, 1, 0, 0, 0, 0, 0, 0,
-1, -1, -2, -1, -2, -2, -2, -2, -2, -3, -2, -3, -3, -4, -3, -4, -4, -3, -3, -3,
-4, -4, -4, -3, -3, -3, -3, -4, -4, -3, -4, -3, -4, -3, -3, -4, -4, -3, -3, -4,
-3, -3, -3, -3, -2, -3, -3, -3, -3, -2, -3, -2, -2, -2, -2, -1, -3, -1, -2, -2,
-1, -1, -2, -1, -1, -1, -2, -1, -1, -1, -2, 0, 0, -1, -1, 0, -1, -1, 0, -1, -1,
-1, -1, 0, -1, -1, 0, 0, -1, -1, 0, -1, 0, -1, -1, -1, 0, -1, -1, -1, 0, -1, -2,
0, 0, 0, -1, -1, -1, -1, -1, 0, -2, -1, -1, -1, -1, -1, -1, -1, -1, 0, 0, -1,
-1, 0, -1, 0, -1, -1, -1, -1, -1, 0, 0, -2, -1, -1, -1, -1, 0, -1, -1, -1, -1,
-1, -1, -1, -1, -1, 0, 0, -1, 0, -1, -2, -1, 0, -1, -1, -1, -1, -1, -1, -1, -1,
-1, -1, 0, -1, -1, -1, 0, -1, -1, -1, 0, -1, 0, -1, -1, -1, -1, -1, -1, 0, -1,
0, 0, 0, -1, -1, -1, -1, 0, -1, -1, -1, -1, 0, 0, -1, -1, -1, 0, 0, 0, 0, -1, 0,
-1, 0, -1, 0, 0, -1, -1, -1, -1, 0, 0, 0, -1, -1, -1, -1, -1, 0, -1, -1, 0, -1,
0, -1, 0, -1, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, -1, -1, 0, -1, -1, 0, -1, 0,
0, -1, -1, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, -1, 0, -1, -1, -1, 0,
0, 0, -1, -3, -6, -10, -14, -20, -24, -29, -34, -41, -46, -53, -58, -66, -73,
-80, -86, -92, -97, -102, -105, -107, -108, -108, -106, -105, -102, -101, -98,
-97, -95, -93, -91, -88, -85, -81, -76, -70, -63, -55, -47, -38, -29, -20, -11,
-3, };