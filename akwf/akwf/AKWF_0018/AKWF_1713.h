#define DATA_LENGTH 512
#define DATA AKWF_1713

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 6, 8, 11, 13, 16, 18, 21, 24,
26, 30, 32, 34, 37, 41, 43, 47, 50, 52, 55, 58, 62, 65, 68, 72, 74, 77, 80, 82,
86, 88, 91, 94, 96, 99, 102, 105, 107, 108, 111, 112, 114, 115, 117, 118, 119,
119, 119, 119, 119, 118, 117, 116, 114, 112, 109, 107, 105, 101, 98, 93, 88, 85,
80, 75, 68, 64, 57, 51, 44, 38, 32, 25, 19, 13, 6, 0, -6, -11, -16, -22, -27,
-30, -35, -38, -42, -45, -47, -49, -52, -53, -53, -54, -54, -54, -54, -53, -53,
-51, -50, -49, -48, -46, -45, -43, -42, -40, -37, -37, -35, -34, -31, -29, -28,
-27, -25, -23, -22, -19, -18, -16, -15, -13, -11, -9, -8, -5, -4, -1, 1, 3, 6,
7, 10, 13, 14, 17, 19, 23, 25, 27, 31, 33, 36, 39, 41, 44, 47, 49, 52, 54, 57,
60, 62, 64, 67, 68, 70, 72, 74, 76, 77, 78, 79, 81, 80, 81, 81, 81, 81, 80, 79,
77, 76, 74, 72, 70, 67, 64, 60, 57, 53, 49, 44, 40, 34, 29, 24, 18, 13, 7, 1,
-5, -11, -16, -22, -27, -32, -37, -41, -47, -52, -55, -59, -63, -65, -68, -71,
-74, -76, -78, -79, -81, -81, -83, -84, -84, -85, -86, -85, -86, -87, -86, -87,
-87, -88, -87, -87, -88, -87, -87, -87, -87, -88, -88, -87, -87, -86, -85, -86,
-84, -83, -82, -82, -81, -78, -78, -75, -74, -71, -70, -68, -66, -63, -62, -59,
-56, -54, -51, -49, -47, -44, -41, -38, -35, -32, -30, -28, -25, -21, -18, -16,
-13, -11, -8, -6, -4, -2, 1, 4, 5, 8, 9, 10, 12, 15, 15, 17, 19, 20, 19, 21, 21,
22, 22, 22, 22, 22, 21, 20, 19, 18, 17, 16, 14, 13, 11, 9, 7, 5, 4, 2, -1, -3,
-5, -7, -10, -11, -13, -15, -18, -20, -22, -23, -24, -27, -28, -30, -31, -33,
-34, -36, -38, -39, -41, -42, -44, -45, -48, -48, -50, -53, -54, -56, -58, -59,
-62, -63, -65, -66, -68, -69, -70, -72, -73, -74, -74, -75, -76, -76, -75, -75,
-75, -73, -72, -71, -70, -69, -66, -64, -62, -60, -58, -55, -52, -50, -48, -45,
-42, -39, -37, -34, -31, -28, -26, -21, -19, -16, -13, -11, -8, -5, -3, 0, 3, 6,
8, 11, 14, 16, 18, 22, 24, 26, 29, 31, 33, 35, 38, 40, 42, 45, 46, 48, 51, 51,
54, 56, 57, 59, 60, 61, 63, 64, 65, 66, 67, 67, 68, 68, 69, 70, 69, 70, 70, 70,
70, 69, 69, 68, 67, 67, 66, 65, 63, 61, 60, 57, 56, 53, 50, 48, 45, 42, 39, 35,
31, 28, 23, 19, 14, 9, 5, -1, -4, -10, -15, -19, -25, -29, -32, -37, -41, -43,
-47, -50, -53, -55, -57, -58, -58, -59, -60, -61, -59, -59, -58, -58, -55, -54,
-53, -50, -48, -46, -44, -41, -39, -36, -33, -30, -28, -25, -22, -20, -17, -15,
-12, -10, -7, -5, -2, };