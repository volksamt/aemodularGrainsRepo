#define DATA_LENGTH 512
#define DATA AKWF_1756

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 12, 14, 18, 21, 24, 26, 29,
31, 35, 38, 41, 44, 46, 49, 52, 54, 57, 60, 63, 65, 67, 70, 71, 74, 76, 79, 82,
83, 86, 87, 88, 91, 93, 95, 95, 98, 99, 101, 103, 104, 105, 106, 108, 109, 110,
110, 112, 112, 113, 114, 114, 115, 116, 116, 118, 118, 118, 118, 119, 119, 119,
119, 119, 119, 118, 118, 118, 119, 118, 118, 118, 118, 117, 117, 117, 115, 115,
115, 114, 114, 113, 112, 112, 111, 110, 109, 109, 108, 108, 107, 106, 106, 105,
104, 104, 102, 102, 101, 100, 101, 99, 99, 98, 97, 96, 97, 96, 95, 94, 94, 94,
93, 93, 93, 93, 91, 92, 92, 92, 91, 91, 91, 91, 91, 91, 91, 91, 90, 91, 91, 91,
91, 93, 92, 93, 93, 93, 93, 94, 94, 95, 95, 96, 96, 97, 97, 97, 98, 99, 100,
101, 102, 101, 103, 103, 104, 105, 106, 106, 107, 107, 108, 109, 110, 111, 112,
112, 112, 113, 114, 114, 115, 115, 115, 116, 117, 117, 117, 117, 119, 119, 118,
119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 117, 118, 117, 116, 116, 115,
115, 115, 114, 112, 113, 112, 111, 108, 107, 107, 105, 104, 102, 101, 100, 98,
97, 94, 93, 91, 89, 87, 85, 84, 82, 79, 77, 75, 72, 70, 67, 65, 63, 60, 58, 56,
52, 50, 47, 44, 41, 38, 36, 33, 30, 27, 23, 21, 18, 15, 12, 10, 6, 3, 1, -2, -6,
-9, -12, -15, -17, -20, -24, -26, -29, -32, -36, -39, -41, -45, -47, -50, -53,
-54, -57, -59, -63, -65, -67, -70, -72, -74, -77, -78, -81, -83, -85, -87, -90,
-91, -93, -95, -96, -99, -100, -101, -103, -103, -105, -106, -108, -108, -110,
-111, -112, -112, -113, -114, -115, -116, -116, -117, -117, -117, -118, -118,
-119, -119, -119, -119, -120, -118, -118, -119, -119, -119, -119, -118, -118,
-118, -117, -116, -116, -116, -115, -115, -114, -114, -113, -112, -111, -111,
-110, -110, -110, -108, -108, -107, -107, -106, -104, -105, -103, -102, -102,
-101, -101, -100, -99, -99, -98, -98, -97, -97, -96, -96, -94, -94, -94, -94,
-93, -93, -93, -92, -91, -91, -90, -91, -91, -91, -91, -91, -91, -91, -90, -90,
-92, -91, -92, -91, -92, -92, -92, -93, -93, -93, -94, -94, -95, -95, -97, -96,
-97, -97, -98, -99, -99, -99, -100, -101, -102, -102, -103, -103, -105, -105,
-107, -107, -108, -108, -109, -110, -111, -111, -112, -113, -113, -113, -115,
-114, -115, -116, -117, -118, -117, -117, -117, -118, -119, -119, -118, -119,
-120, -119, -119, -118, -118, -119, -119, -118, -118, -118, -117, -117, -116,
-116, -115, -114, -114, -114, -112, -110, -109, -109, -108, -107, -105, -104,
-103, -101, -100, -98, -97, -95, -93, -90, -89, -88, -85, -84, -82, -78, -77,
-75, -72, -70, -68, -65, -63, -60, -57, -54, -52, -50, -47, -44, -41, -39, -35,
-33, -30, -26, -23, -21, -17, -14, -12, -9, -6, -3, 1, };