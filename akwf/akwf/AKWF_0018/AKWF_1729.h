#define DATA_LENGTH 512
#define DATA AKWF_1729

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 13, 17, 20, 24, 27, 30, 33,
36, 39, 42, 44, 47, 50, 53, 54, 56, 58, 61, 63, 64, 67, 68, 70, 73, 74, 76, 77,
79, 80, 81, 83, 83, 86, 87, 88, 89, 89, 91, 91, 93, 94, 94, 96, 97, 97, 98, 99,
99, 101, 102, 103, 103, 104, 104, 105, 106, 106, 107, 108, 108, 108, 110, 110,
110, 110, 111, 112, 112, 112, 112, 113, 114, 114, 114, 114, 114, 115, 115, 116,
116, 116, 116, 116, 116, 117, 117, 117, 117, 118, 118, 118, 118, 118, 119, 118,
118, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 118,
119, 119, 119, 119, 119, 119, 118, 118, 118, 118, 117, 117, 117, 116, 116, 116,
116, 115, 115, 116, 115, 115, 114, 114, 113, 113, 112, 112, 112, 112, 111, 110,
110, 110, 110, 109, 109, 108, 107, 105, 106, 106, 104, 105, 104, 102, 102, 101,
100, 100, 100, 98, 97, 96, 96, 95, 94, 93, 92, 92, 90, 89, 88, 87, 86, 85, 84,
83, 82, 80, 79, 77, 76, 74, 72, 72, 69, 68, 66, 64, 63, 60, 58, 56, 54, 51, 50,
47, 44, 42, 39, 36, 33, 30, 27, 24, 22, 18, 15, 11, 8, 4, 0, -4, -8, -11, -16,
-21, -25, -29, -33, -38, -44, -47, -53, -58, -63, -68, -73, -78, -83, -88, -94,
-93, -90, -88, -85, -83, -80, -78, -76, -73, -71, -69, -67, -65, -63, -62, -59,
-57, -56, -55, -54, -52, -51, -49, -48, -48, -46, -46, -46, -46, -44, -44, -44,
-43, -43, -43, -43, -43, -43, -43, -43, -44, -44, -44, -45, -46, -45, -46, -46,
-48, -48, -50, -49, -51, -51, -53, -53, -54, -55, -56, -56, -57, -58, -60, -60,
-60, -62, -63, -64, -65, -66, -67, -67, -69, -69, -70, -71, -72, -73, -74, -74,
-75, -76, -77, -79, -78, -80, -80, -81, -82, -83, -84, -84, -85, -86, -86, -87,
-87, -88, -88, -90, -90, -91, -90, -91, -92, -92, -92, -93, -94, -94, -94, -94,
-95, -95, -96, -95, -96, -96, -96, -96, -96, -96, -97, -97, -97, -98, -97, -96,
-97, -96, -97, -97, -97, -96, -96, -96, -96, -95, -95, -95, -95, -95, -94, -93,
-94, -92, -93, -92, -92, -91, -92, -91, -90, -89, -89, -89, -87, -87, -87, -86,
-85, -85, -83, -82, -82, -81, -81, -80, -80, -78, -77, -77, -76, -75, -75, -73,
-72, -72, -71, -69, -69, -67, -67, -65, -64, -64, -63, -63, -62, -60, -59, -58,
-56, -56, -56, -53, -53, -53, -51, -50, -49, -49, -49, -47, -46, -46, -46, -44,
-44, -44, -43, -43, -42, -41, -42, -41, -40, -41, -40, -40, -40, -40, -40, -41,
-40, -40, -41, -42, -43, -43, -44, -45, -46, -46, -48, -49, -51, -53, -53, -55,
-56, -59, -61, -62, -65, -67, -69, -70, -73, -75, -77, -81, -83, -85, -87, -89,
-87, -81, -75, -71, -65, -60, -55, -50, -46, -41, -36, -31, -26, -22, -18, -13,
-9, -5, -1, };