#define DATA_LENGTH 512
#define DATA AKWF_1723

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 115, 122, 115, 120, 115,
119, 114, 118, 114, 117, 114, 116, 114, 115, 113, 114, 113, 112, 112, 112, 112,
110, 110, 110, 111, 109, 109, 109, 109, 108, 108, 107, 108, 107, 106, 105, 105,
105, 104, 104, 103, 103, 102, 102, 102, 101, 101, 100, 100, 99, 98, 98, 98, 97,
97, 96, 95, 95, 95, 93, 93, 92, 92, 91, 90, 90, 88, 88, 87, 87, 86, 85, 84, 84,
82, 82, 81, 81, 80, 79, 78, 77, 76, 75, 74, 73, 73, 72, 71, 69, 68, 67, 66, 65,
64, 64, 61, 60, 60, 59, 57, 56, 54, 54, 52, 51, 50, 47, 47, 45, 45, 43, 41, 40,
38, 36, 35, 33, 32, 31, 29, 27, 26, 24, 21, 21, 18, 17, 15, 13, 11, 10, 7, 6, 4,
2, 1, -2, -4, -7, -8, -9, -12, -13, -16, -18, -20, -22, -24, -26, -29, -30, -32,
-34, -35, -39, -40, -42, -45, -48, -47, -46, -47, -48, -48, -47, -48, -47, -46,
-47, -48, -46, -47, -47, -48, -46, -47, -47, -47, -47, -47, -47, -46, -46, -47,
-47, -47, -47, -46, -46, -46, -46, -48, -47, -46, -47, -46, -47, -47, -47, -46,
-47, -47, -47, -47, -47, -46, -47, -47, -46, -46, -46, -46, -46, -46, -46, -46,
-47, -47, -47, -47, -47, -46, -47, -46, -47, -46, -46, -47, -47, -46, -46, -47,
-46, -47, -46, -47, -46, -47, -46, -47, -47, -46, -47, -46, -46, -46, -46, -47,
-46, -46, -46, -46, -47, -46, -47, -46, -46, -47, -46, -47, -46, -45, -46, -46,
-46, -47, -46, -46, -46, -46, -45, -46, -47, -46, -46, -45, -46, -45, -46, -46,
-46, -46, -45, -45, -45, -46, -46, -46, -46, -46, -46, -46, -46, -46, -46, -46,
-47, -46, -46, -45, -46, -46, -46, -45, -45, -45, -46, -46, -46, -46, -46, -46,
-46, -45, -46, -46, -45, -46, -45, -46, -46, -46, -46, -46, -45, -45, -45, -46,
-45, -45, -46, -45, -45, -46, -45, -45, -45, -45, -44, -45, -46, -45, -45, -45,
-45, -45, -43, -42, -42, -41, -39, -39, -37, -36, -35, -34, -32, -32, -30, -28,
-28, -27, -26, -24, -23, -22, -21, -21, -20, -18, -18, -17, -16, -15, -13, -12,
-13, -12, -10, -10, -9, -9, -7, -7, -6, -6, -4, -3, -3, -3, -2, -2, -1, -1, 0,
0, 1, 1, 2, 2, 3, 3, 3, 4, 4, 4, 4, 5, 5, 5, 4, 6, 5, 5, 5, 6, 5, 5, 6, 6, 5, 6,
5, 5, 5, 5, 6, 5, 5, 5, 5, 5, 5, 4, 3, 3, 3, 3, 3, 2, 2, 2, 1, 1, 1, 0, 0, 0,
-1, 0, -2, -1, -2, -2, -3, -4, -4, -4, -5, -6, -6, -6, -6, -7, -7, -7, -8, -9,
-9, -10, -11, -11, -11, -12, -12, -14, -14, -14, -15, -15, -16, -17, -18, -19,
-18, -19, -20, -20, -22, -21, -23, -23, -23, -24, -24, -25, -25, -27, -27, -29,
-28, -30, -29, -31, -29, -33, -31, -46, -38, };