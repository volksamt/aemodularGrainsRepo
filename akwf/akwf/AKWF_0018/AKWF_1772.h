#define DATA_LENGTH 512
#define DATA AKWF_1772

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 3, 3, 4, 3, 3, 4, 3, 3, 4, 3,
3, 3, 4, 4, 3, 3, 3, 4, 3, 3, 3, 3, 3, 4, 3, 3, 3, 3, 3, 3, 3, 3, 4, 4, 4, 3, 3,
3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 3, 4, 3, 3, 3, 3, 3, 3, 3,
4, 4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 4, 3, 3, 3, 3, 4, 4, 3, 3, 4, 3, 3, 3, 4,
3, 4, 3, 3, 4, 4, 3, 3, 3, 3, 4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3,
4, 4, 3, 4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 4, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3,
4, 3, 3, 3, 3, 3, 4, 3, 3, 4, 4, 5, 5, 7, 7, 8, 8, 9, 11, 12, 13, 13, 15, 15,
15, 17, 17, 18, 19, 19, 21, 21, 22, 24, 24, 25, 25, 26, 27, 28, 29, 30, 31, 31,
32, 33, 33, 34, 36, 36, 37, 38, 39, 39, 41, 42, 42, 43, 43, 45, 45, 46, 47, 47,
49, 50, 51, 51, 52, 53, 53, 54, 55, 55, 57, 58, 58, 59, 60, 60, 62, 63, 64, 64,
65, 66, 66, 68, 66, 71, 68, 73, 67, 80, 24, -2, 58, 53, 56, 54, 55, 53, 52, 51,
51, 51, 50, 49, 49, 49, 46, 47, 45, 46, 45, 45, 44, 43, 42, 42, 41, 40, 39, 39,
37, 38, 36, 36, 36, 36, 34, 34, 33, 32, 32, 31, 30, 30, 29, 29, 28, 28, 27, 26,
26, 25, 25, 24, 23, 23, 22, 22, 20, 20, 19, 18, 18, 17, 17, 16, 15, 15, 14, 13,
13, 13, 11, 11, 10, 10, 10, 8, 7, 7, 7, 6, 5, 5, 3, 3, 3, 3, 3, 2, 2, 2, 3, 3,
2, 3, 2, 3, 2, 2, 3, 3, 3, 2, 3, 3, 3, 2, 3, 2, 2, 3, 2, 3, 2, 2, 2, 2, 2, 2, 2,
2, 2, 2, 3, 3, 2, 2, 3, 3, 3, 3, 2, 2, 3, 2, 3, 2, 3, 1, 3, 2, 2, 2, 3, 1, 4, 2,
3, 2, 3, 2, 3, 3, 2, 3, 1, 4, -1, 6, -4, 16, -73, -128, -109, -121, -111, -117,
-111, -114, -109, -110, -107, -107, -105, -105, -103, -103, -101, -100, -100,
-98, -98, -96, -95, -94, -93, -91, -91, -89, -89, -88, -87, -84, -84, -82, -82,
-80, -80, -78, -78, -76, -75, -74, -73, -71, -70, -69, -69, -67, -66, -65, -64,
-62, -61, -60, -59, -59, -57, -56, -55, -54, -53, -51, -51, -50, -49, -47, -47,
-45, -44, -42, -41, -40, -39, -38, -37, -36, -35, -33, -32, -32, -30, -29, -28,
-27, -27, -25, -24, -23, -22, -20, -20, -19, -16, -17, -15, -14, -12, -12, -10,
-9, -8, -7, -6, -5, -4, -3, -1, -1, };