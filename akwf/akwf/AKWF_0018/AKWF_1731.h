#define DATA_LENGTH 512
#define DATA AKWF_1731

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 7, 9, 11, 14, 17, 17, 21, 23,
24, 26, 28, 29, 32, 33, 34, 36, 36, 38, 38, 41, 40, 42, 43, 43, 45, 46, 46, 47,
47, 47, 48, 48, 50, 50, 49, 50, 51, 51, 50, 51, 51, 52, 52, 52, 52, 53, 52, 53,
53, 53, 53, 53, 53, 53, 54, 53, 54, 53, 54, 53, 53, 54, 54, 53, 53, 53, 54, 54,
53, 53, 53, 54, 53, 54, 53, 54, 53, 54, 53, 53, 53, 53, 53, 54, 53, 53, 52, 53,
53, 53, 53, 52, 53, 53, 53, 53, 53, 52, 52, 53, 53, 53, 53, 52, 53, 53, 53, 53,
52, 53, 53, 53, 53, 52, 52, 53, 53, 54, 52, 53, 52, 53, 53, 53, 53, 52, 52, 53,
53, 52, 53, 53, 53, 53, 53, 53, 52, 52, 53, 52, 52, 53, 53, 52, 53, 52, 53, 53,
52, 52, 52, 52, 51, 51, 51, 51, 51, 51, 51, 50, 49, 49, 50, 49, 49, 48, 48, 48,
47, 46, 46, 45, 44, 44, 43, 42, 42, 41, 40, 39, 38, 37, 37, 35, 34, 33, 31, 29,
27, 26, 24, 22, 20, 19, 16, 13, 12, 9, 7, 5, 1, -2, -5, -8, -11, -14, -18, -22,
-26, -30, -34, -38, -42, -46, -51, -56, -61, -65, -70, -76, -80, -85, -89, -95,
-101, -106, -111, -117, -118, -112, -108, -103, -99, -95, -90, -86, -82, -78,
-74, -70, -66, -62, -60, -56, -52, -49, -47, -44, -40, -37, -35, -32, -30, -28,
-26, -23, -21, -21, -17, -17, -15, -13, -12, -12, -11, -9, -9, -7, -7, -6, -6,
-5, -5, -5, -4, -4, -3, -3, -3, -3, -3, -4, -4, -4, -4, -4, -4, -5, -4, -5, -6,
-6, -6, -5, -7, -7, -8, -8, -8, -8, -8, -10, -10, -10, -11, -12, -12, -11, -12,
-14, -13, -13, -14, -15, -16, -16, -16, -16, -17, -16, -18, -18, -18, -19, -19,
-19, -19, -20, -21, -21, -21, -21, -22, -22, -22, -22, -22, -22, -23, -23, -23,
-24, -23, -23, -23, -25, -24, -24, -24, -24, -24, -24, -25, -25, -25, -25, -25,
-25, -25, -24, -24, -25, -24, -24, -24, -25, -24, -24, -24, -23, -23, -23, -23,
-22, -22, -23, -22, -21, -22, -21, -21, -21, -20, -21, -20, -19, -18, -19, -19,
-17, -17, -17, -16, -16, -16, -16, -15, -15, -14, -14, -14, -13, -12, -12, -12,
-10, -10, -10, -10, -10, -9, -8, -8, -7, -7, -7, -6, -6, -6, -5, -5, -4, -4, -4,
-4, -3, -4, -3, -2, -3, -2, -3, -2, -3, -3, -3, -4, -3, -3, -4, -4, -5, -6, -7,
-8, -8, -9, -9, -11, -13, -13, -14, -16, -17, -20, -22, -23, -25, -28, -29, -32,
-35, -37, -40, -43, -46, -49, -52, -56, -59, -62, -66, -71, -74, -78, -82, -86,
-90, -94, -99, -103, -107, -112, -116, -114, -109, -104, -97, -93, -87, -83,
-77, -72, -67, -62, -57, -52, -48, -44, -39, -35, -30, -27, -23, -19, -16, -12,
-8, -5, -2, };