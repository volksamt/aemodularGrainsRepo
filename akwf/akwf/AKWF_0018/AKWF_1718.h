#define DATA_LENGTH 512
#define DATA AKWF_1718

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 7, 10, 13, 16, 19, 21, 24, 28,
29, 29, 31, 31, 32, 32, 32, 33, 34, 35, 36, 37, 37, 38, 38, 39, 40, 41, 43, 45,
46, 47, 48, 49, 50, 50, 51, 50, 50, 50, 51, 50, 49, 48, 47, 44, 43, 43, 42, 42,
40, 39, 37, 35, 34, 34, 33, 32, 33, 32, 32, 34, 36, 35, 34, 34, 34, 34, 34, 33,
33, 33, 34, 33, 34, 34, 35, 36, 37, 37, 38, 38, 39, 42, 43, 45, 48, 49, 52, 55,
58, 61, 63, 66, 68, 71, 73, 75, 76, 78, 79, 81, 83, 84, 84, 87, 88, 91, 93, 95,
99, 100, 102, 103, 104, 106, 106, 106, 107, 108, 109, 108, 109, 109, 109, 109,
109, 110, 111, 110, 112, 112, 113, 113, 113, 114, 114, 113, 113, 112, 112, 111,
110, 111, 111, 110, 110, 110, 110, 110, 110, 110, 110, 110, 110, 111, 111, 112,
111, 112, 113, 112, 114, 115, 116, 118, 119, 119, 119, 119, 119, 118, 118, 118,
118, 118, 117, 116, 114, 112, 111, 109, 107, 106, 105, 105, 103, 102, 103, 101,
101, 101, 100, 97, 97, 94, 93, 93, 91, 90, 88, 87, 86, 84, 80, 79, 77, 75, 72,
69, 66, 65, 63, 61, 59, 57, 55, 52, 50, 49, 48, 46, 46, 45, 45, 44, 42, 40, 38,
39, 37, 37, 35, 34, 32, 31, 27, 25, 24, 22, 20, 19, 18, 16, 13, 12, 10, 8, 7, 5,
3, 2, 1, 1, 0, 1, -1, -1, -1, -1, -2, -4, -6, -7, -8, -10, -12, -14, -16, -18,
-19, -20, -21, -23, -25, -29, -31, -33, -34, -36, -37, -38, -39, -40, -40, -42,
-44, -44, -45, -45, -46, -47, -49, -50, -52, -55, -57, -59, -62, -62, -65, -67,
-70, -72, -74, -77, -78, -81, -84, -85, -88, -89, -90, -92, -92, -94, -94, -96,
-98, -100, -101, -101, -102, -103, -102, -102, -104, -105, -106, -107, -110,
-110, -113, -114, -115, -116, -117, -118, -119, -118, -119, -118, -119, -119,
-119, -119, -117, -116, -115, -113, -113, -112, -112, -112, -112, -111, -110,
-111, -110, -110, -110, -110, -110, -111, -110, -110, -111, -112, -110, -111,
-111, -111, -113, -113, -113, -113, -113, -114, -114, -112, -112, -111, -111,
-110, -110, -109, -108, -109, -110, -109, -108, -108, -108, -107, -107, -105,
-105, -104, -103, -102, -100, -98, -96, -93, -91, -89, -86, -85, -84, -82, -81,
-79, -79, -77, -74, -72, -71, -68, -66, -63, -61, -58, -54, -52, -50, -46, -45,
-43, -41, -39, -39, -37, -37, -36, -36, -35, -34, -34, -34, -34, -33, -33, -34,
-34, -33, -34, -33, -34, -36, -35, -34, -33, -32, -33, -33, -34, -33, -34, -36,
-36, -38, -40, -41, -42, -43, -44, -46, -47, -47, -49, -49, -51, -51, -51, -50,
-51, -50, -50, -49, -48, -46, -45, -44, -43, -42, -40, -39, -38, -38, -38, -36,
-36, -35, -33, -33, -33, -32, -32, -30, -30, -30, -28, -26, -24, -20, -18, -15,
-13, -10, -7, -4, -1, };