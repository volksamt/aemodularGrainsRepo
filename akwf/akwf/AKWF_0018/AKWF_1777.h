#define DATA_LENGTH 512
#define DATA AKWF_1777

const PROGMEM int8_t DATA[DATA_LENGTH] = {95, 113, 102, 108, 102, 105, 102, 105,
100, 104, 99, 102, 99, 101, 99, 100, 99, 99, 98, 99, 99, 99, 98, 98, 97, 97, 98,
96, 97, 97, 97, 96, 97, 96, 97, 96, 96, 96, 95, 95, 95, 95, 95, 95, 95, 95, 95,
94, 95, 94, 94, 95, 94, 96, 96, 95, 96, 95, 96, 96, 95, 96, 95, 95, 95, 95, 96,
95, 95, 95, 96, 96, 96, 96, 96, 95, 95, 96, 95, 95, 95, 95, 96, 95, 95, 96, 96,
95, 95, 95, 95, 96, 95, 96, 95, 95, 95, 95, 95, 94, 95, 95, 95, 95, 95, 95, 95,
95, 95, 95, 95, 95, 96, 95, 95, 94, 94, 95, 95, 95, 95, 95, 94, 95, 95, 95, 95,
94, 94, 95, 95, 95, 95, 94, 94, 94, 94, 95, 94, 94, 95, 95, 94, 95, 94, 94, 94,
94, 94, 94, 94, 94, 95, 93, 94, 95, 93, 94, 95, 94, 94, 94, 94, 94, 94, 93, 93,
93, 94, 94, 94, 94, 93, 94, 94, 93, 94, 93, 93, 94, 94, 93, 94, 93, 93, 93, 93,
93, 93, 93, 93, 93, 93, 93, 93, 93, 93, 94, 93, 93, 92, 93, 93, 93, 93, 93, 93,
92, 92, 93, 93, 93, 93, 93, 93, 93, 93, 93, 93, 92, 92, 92, 93, 92, 93, 92, 92,
93, 93, 92, 92, 92, 92, 92, 93, 93, 92, 92, 92, 92, 93, 91, 92, 92, 93, 92, 92,
92, 92, 92, 92, 93, 92, 91, 92, 91, 93, 99, 90, 84, 76, 71, 64, 58, 53, 46, 40,
35, 29, 23, 20, 14, 10, 5, 0, -4, -8, -12, -17, -20, -23, -27, -30, -34, -38,
-40, -43, -47, -49, -51, -54, -57, -59, -61, -63, -66, -68, -70, -72, -74, -75,
-77, -78, -81, -81, -83, -85, -86, -88, -88, -89, -91, -92, -94, -94, -95, -95,
-97, -98, -99, -100, -101, -101, -103, -103, -104, -104, -105, -106, -106, -107,
-106, -107, -108, -109, -109, -110, -110, -111, -110, -111, -112, -111, -113,
-112, -113, -113, -114, -114, -114, -114, -114, -115, -116, -116, -115, -116,
-116, -116, -116, -117, -116, -116, -117, -117, -116, -117, -117, -117, -118,
-117, -118, -118, -118, -118, -118, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -118, -119, -118, -119, -119, -119, -118, -119, -120, -118, -119,
-119, -119, -120, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -118, -119, -119, -118, -119, -119,
-118, -118, -118, -119, -118, -118, -119, -118, -118, -119, -119, -118, -118,
-118, -118, -117, -118, -119, -118, -118, -118, -118, -118, -118, -118, -117,
-118, -118, -117, -117, -118, -118, -118, -118, -118, -117, -117, -117, -117,
-118, -118, -118, -117, -117, -118, -116, -118, -116, -118, -118, -117, -118,
-117, -117, -118, -117, -116, -117, -116, -117, -117, -117, -117, -118, -116,
-118, -115, -118, -115, -118, -114, -120, -113, -121, -111, -123, -99, };