#define DATA_LENGTH 512
#define DATA AKWF_1737

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 13, 20, 27, 34, 40, 46, 53, 60,
67, 73, 80, 87, 93, 100, 107, 113, 118, 119, 118, 119, 119, 119, 119, 119, 119,
119, 118, 120, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 120,
118, 118, 119, 119, 118, 119, 119, 119, 118, 119, 119, 119, 118, 119, 119, 118,
118, 119, 118, 119, 119, 118, 118, 118, 118, 119, 119, 119, 119, 119, 118, 119,
118, 118, 119, 118, 119, 118, 119, 118, 118, 118, 118, 119, 118, 118, 118, 118,
118, 119, 118, 118, 119, 118, 117, 118, 117, 119, 117, 117, 118, 118, 117, 118,
118, 118, 118, 117, 118, 118, 118, 117, 118, 118, 117, 118, 118, 117, 118, 118,
118, 118, 117, 118, 118, 118, 118, 117, 117, 117, 117, 118, 118, 118, 117, 117,
117, 118, 117, 118, 118, 117, 117, 117, 117, 117, 117, 117, 117, 117, 118, 117,
118, 117, 116, 118, 117, 117, 117, 117, 117, 116, 116, 117, 117, 117, 117, 117,
116, 117, 116, 117, 116, 116, 116, 116, 116, 117, 117, 117, 117, 116, 117, 116,
117, 117, 116, 116, 116, 117, 116, 117, 116, 117, 117, 116, 116, 116, 116, 117,
117, 116, 116, 117, 116, 116, 117, 117, 116, 116, 116, 116, 116, 117, 117, 116,
117, 116, 115, 116, 116, 116, 116, 117, 115, 116, 116, 116, 116, 117, 117, 116,
116, 116, 116, 115, 111, 105, 98, 92, 85, 78, 71, 65, 58, 51, 45, 39, 31, 24,
17, 11, 4, -2, -9, -15, -23, -29, -35, -43, -50, -56, -63, -70, -76, -83, -90,
-96, -103, -109, -117, -119, -119, -120, -118, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -118, -119, -118, -119, -118, -118, -118, -118, -119, -118, -118, -119,
-119, -119, -118, -119, -118, -118, -119, -118, -118, -118, -118, -118, -118,
-118, -117, -118, -118, -119, -118, -118, -118, -119, -119, -118, -118, -119,
-118, -118, -119, -119, -118, -118, -118, -118, -118, -118, -118, -118, -118,
-118, -119, -119, -117, -117, -118, -118, -117, -117, -117, -117, -118, -117,
-117, -117, -118, -118, -118, -118, -117, -118, -117, -117, -118, -117, -118,
-118, -118, -118, -118, -118, -118, -117, -117, -118, -118, -116, -118, -118,
-117, -117, -117, -117, -117, -117, -118, -117, -118, -117, -117, -117, -118,
-117, -117, -117, -117, -117, -117, -117, -117, -117, -117, -117, -117, -117,
-117, -117, -117, -116, -117, -117, -117, -117, -116, -116, -117, -117, -117,
-117, -116, -116, -117, -117, -117, -116, -117, -117, -117, -117, -117, -117,
-116, -116, -116, -117, -117, -116, -116, -117, -116, -116, -116, -117, -116,
-116, -116, -116, -116, -117, -116, -116, -115, -116, -116, -116, -116, -116,
-116, -116, -115, -116, -116, -116, -116, -117, -116, -116, -116, -116, -116,
-116, -116, -116, -115, -109, -103, -96, -88, -82, -76, -69, -62, -55, -49, -42,
-36, -28, -22, -15, -9, -3, };