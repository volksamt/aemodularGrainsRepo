#define DATA_LENGTH 512
#define DATA AKWF_1796

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 2, 3, 4, 5, 5, 6, 6, 8, 8,
10, 10, 11, 11, 12, 12, 13, 13, 15, 15, 15, 16, 16, 16, 18, 19, 18, 19, 19, 19,
21, 21, 21, 22, 22, 23, 23, 23, 24, 25, 26, 26, 26, 27, 27, 27, 28, 28, 29, 29,
29, 30, 30, 31, 32, 32, 32, 34, 34, 35, 35, 35, 36, 37, 37, 38, 39, 39, 39, 40,
41, 41, 43, 43, 44, 44, 45, 46, 47, 48, 49, 49, 50, 51, 51, 52, 53, 53, 54, 55,
56, 57, 57, 58, 58, 59, 60, 62, 61, 63, 63, 64, 64, 65, 66, 67, 67, 68, 69, 69,
69, 70, 71, 71, 71, 72, 73, 74, 74, 74, 74, 75, 75, 76, 76, 76, 76, 77, 77, 78,
78, 77, 78, 78, 78, 79, 78, 78, 79, 79, 79, 79, 79, 80, 79, 79, 80, 79, 80, 79,
79, 79, 80, 80, 80, 79, 79, 80, 79, 79, 80, 80, 80, 79, 80, 80, 79, 80, 80, 80,
80, 80, 81, 80, 81, 81, 82, 81, 82, 81, 82, 82, 83, 83, 83, 84, 84, 83, 84, 85,
85, 85, 86, 86, 87, 87, 87, 88, 88, 89, 89, 89, 90, 90, 90, 91, 91, 91, 93, 92,
93, 94, 95, 95, 94, 95, 95, 96, 95, 97, 95, 98, 95, 99, 95, 100, 96, 100, 96,
99, 96, 100, 95, 100, 97, 99, 97, 97, 99, 93, 108, -80, -128, -105, -121, -106,
-116, -105, -112, -103, -110, -102, -105, -100, -101, -98, -97, -94, -93, -92,
-90, -89, -87, -86, -83, -81, -80, -78, -76, -75, -71, -71, -67, -67, -64, -63,
-59, -59, -57, -54, -52, -51, -49, -47, -45, -44, -42, -41, -40, -38, -38, -37,
-35, -36, -35, -34, -35, -35, -35, -35, -37, -37, -38, -40, -41, -42, -44, -47,
-49, -52, -55, -58, -60, -63, -68, -72, -75, -79, -83, -87, -91, -95, -97, -101,
-104, -106, -108, -109, -111, -112, -114, -115, -117, -117, -117, -118, -118,
-119, -119, -119, -119, -119, -118, -119, -119, -118, -117, -116, -116, -115,
-115, -113, -113, -111, -110, -109, -108, -107, -105, -104, -104, -102, -101,
-99, -98, -96, -94, -93, -91, -89, -88, -87, -84, -83, -82, -80, -78, -76, -76,
-74, -73, -70, -69, -68, -67, -66, -64, -63, -62, -60, -58, -58, -56, -56, -54,
-53, -52, -51, -50, -49, -47, -46, -45, -44, -43, -42, -41, -39, -38, -38, -37,
-35, -35, -33, -33, -32, -31, -30, -29, -28, -28, -26, -25, -24, -24, -23, -22,
-22, -21, -21, -19, -20, -19, -18, -18, -17, -17, -17, -16, -17, -15, -15, -16,
-15, -15, -15, -15, -14, -16, -15, -15, -14, -14, -15, -14, -15, -15, -15, -15,
-15, -15, -15, -15, -15, -15, -14, -15, -15, -15, -14, -15, -14, -14, -15, -15,
-15, -14, -13, -14, -14, -14, -14, -13, -13, -13, -14, -12, -13, -13, -12, -11,
-12, -11, -10, -10, -10, -9, -8, -8, -8, -7, -6, -5, -5, -5, -4, -3, -2, -1, -1,
};