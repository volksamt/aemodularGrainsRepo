#define DATA_LENGTH 512
#define DATA AKWF_1771

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 1, 3, 3, 3, 3, 4, 4, 3, 3, 3, 3,
3, 3, 3, 3, 3, 3, 2, 4, 2, 4, 3, 3, 4, 3, 3, 3, 3, 3, 3, 4, 3, 3, 4, 3, 3, 3, 3,
3, 2, 4, 3, 3, 3, 3, 3, 4, 3, 3, 4, 4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 4, 3, 3, 4, 2,
3, 2, 3, 4, 3, 4, 3, 3, 3, 4, 3, 4, 3, 3, 3, 3, 3, 3, 4, 4, 2, 3, 4, 3, 3, 3, 3,
2, 3, 3, 4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 4, 3, 4, 3, 4, 3, 3, 3,
3, 3, 4, 3, 3, 3, 3, 3, 3, 4, 3, 3, 4, 3, 4, 3, 3, 3, 3, 2, 3, 3, 3, 3, 4, 3, 4,
3, 4, 4, 3, 3, 3, 3, 4, 3, 3, 3, 4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2,
3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 4, 3, 3, 3, 3, 3, 4, 2, 3, 4, 4, 4, 3, 2, 3, 3, 4,
3, 3, 3, 3, 3, 3, 3, 3, 3, 4, 3, 4, 3, 3, 3, 4, 3, 2, 3, 3, 3, 3, 3, 3, 3, 4, 3,
4, 3, 3, 4, 3, 2, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 3, 2,
3, 4, 2, 3, 2, 4, 4, 3, 3, 3, 3, 2, 4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3,
3, 3, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 4, 3, 4,
3, 3, 3, 3, 3, 3, 3, 4, 4, 4, 3, 2, 3, 3, 4, 3, 3, 4, 5, 5, 6, 7, 8, 9, 11, 11,
12, 12, 13, 15, 15, 16, 17, 17, 19, 19, 21, 22, 23, 23, 24, 24, 26, 27, 27, 28,
30, 30, 31, 31, 33, 34, 35, 35, 36, 37, 38, 39, 39, 41, 42, 43, 44, 44, 45, 46,
47, 48, 48, 50, 50, 52, 52, 54, 53, 56, 55, 57, 57, 59, 58, 60, 60, 62, 62, 64,
64, 65, 67, 66, 70, 66, 75, 63, 87, -9, -68, -47, -54, -50, -41, -92, -128, -59,
-62, -59, -59, -58, -58, -57, -57, -57, -56, -57, -54, -55, -53, -55, -52, -53,
-51, -52, -50, -52, -50, -50, -48, -49, -48, -47, -46, -47, -45, -45, -45, -44,
-44, -43, -43, -42, -43, -41, -40, -40, -40, -39, -38, -38, -38, -37, -37, -37,
-36, -35, -35, -34, -35, -33, -33, -32, -32, -31, -31, -29, -29, -29, -29, -29,
-27, -27, -27, -26, -26, -25, -25, -25, -23, -23, -22, -23, -22, -22, -21, -20,
-19, -19, -19, -18, -18, -16, -15, -14, -12, -12, -10, -8, -8, -6, -6, -4, -3,
-1, -1, };