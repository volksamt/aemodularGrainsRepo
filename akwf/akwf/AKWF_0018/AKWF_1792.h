#define DATA_LENGTH 512
#define DATA AKWF_1792

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 1, 2, 2, 3, 3, 3, 5, 5, 5, 5, 6,
7, 8, 7, 9, 8, 9, 9, 11, 11, 11, 12, 13, 12, 15, 15, 15, 15, 17, 16, 18, 18, 19,
19, 20, 20, 22, 23, 23, 24, 25, 28, 32, 33, 34, 36, 37, 37, 39, 39, 40, 41, 42,
43, 44, 44, 45, 45, 46, 47, 49, 48, 49, 51, 51, 52, 52, 55, 54, 56, 57, 57, 57,
59, 59, 60, 61, 62, 62, 63, 63, 64, 65, 66, 66, 68, 68, 69, 69, 69, 70, 72, 72,
72, 72, 73, 74, 74, 74, 75, 75, 75, 76, 76, 77, 77, 77, 77, 75, 74, 74, 72, 70,
71, 71, 71, 70, 70, 70, 70, 70, 69, 68, 69, 69, 69, 69, 68, 67, 67, 67, 68, 67,
66, 66, 66, 66, 66, 67, 66, 66, 67, 66, 67, 67, 67, 68, 68, 68, 68, 68, 69, 69,
70, 70, 70, 71, 71, 71, 71, 72, 73, 73, 74, 74, 75, 75, 75, 75, 76, 77, 77, 78,
78, 79, 79, 80, 80, 81, 81, 81, 81, 82, 83, 84, 84, 84, 85, 85, 86, 83, 91, 50,
21, 28, 24, 26, 25, 25, 25, 26, 26, 26, 27, 25, 27, 26, 27, 26, 28, 27, 32, 92,
100, 95, 99, 97, 100, 97, 100, 99, 100, 100, 101, 101, 102, 102, 103, 103, 105,
104, 106, 104, 107, 105, 108, 105, 109, 105, 111, 106, 111, 106, 113, 108, 113,
108, 113, 110, 114, 111, 112, 120, -92, -127, -109, -125, -111, -122, -112,
-121, -113, -119, -112, -117, -111, -115, -112, -114, -111, -112, -111, -110,
-111, -109, -109, -108, -109, -107, -108, -106, -107, -106, -106, -104, -105,
-104, -104, -103, -103, -102, -102, -101, -101, -101, -100, -99, -98, -98, -98,
-97, -97, -97, -96, -95, -95, -94, -94, -93, -93, -92, -92, -91, -91, -91, -89,
-90, -89, -89, -88, -88, -88, -87, -86, -86, -86, -85, -84, -83, -83, -83, -83,
-82, -82, -81, -81, -81, -80, -79, -79, -78, -78, -78, -77, -77, -75, -76, -75,
-74, -73, -74, -73, -73, -72, -71, -71, -71, -70, -70, -66, -61, -67, -68, -68,
-67, -66, -66, -66, -66, -64, -65, -64, -63, -63, -62, -62, -62, -60, -61, -60,
-59, -60, -58, -58, -58, -57, -56, -56, -56, -56, -55, -55, -54, -53, -53, -53,
-53, -51, -50, -50, -50, -50, -50, -49, -48, -48, -47, -47, -46, -47, -45, -45,
-45, -49, -51, -49, -50, -49, -47, -47, -47, -47, -46, -46, -45, -44, -43, -44,
-41, -36, -37, -36, -36, -35, -35, -34, -33, -33, -33, -33, -32, -31, -31, -30,
-29, -29, -29, -29, -28, -28, -28, -26, -26, -26, -25, -25, -24, -25, -24, -23,
-22, -22, -22, -22, -21, -21, -20, -21, -18, -19, -18, -18, -17, -17, -16, -17,
-15, -14, -14, -14, -14, -13, -13, -13, -11, -11, -11, -10, -10, -9, -10, -8,
-8, -8, -7, -6, -6, -6, -5, -4, -5, -4, -4, -3, -3, -2, -2, -2, 0, 0, };