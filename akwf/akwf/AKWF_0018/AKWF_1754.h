#define DATA_LENGTH 512
#define DATA AKWF_1754

const PROGMEM int8_t DATA[DATA_LENGTH] = {37, 45, 41, 43, 41, 44, 42, 43, 41,
43, 42, 43, 42, 43, 41, 43, 41, 42, 43, 42, 42, 42, 41, 42, 42, 42, 41, 43, 42,
42, 41, 42, 43, 42, 41, 41, 42, 42, 42, 41, 43, 42, 42, 42, 42, 42, 42, 42, 41,
43, 42, 42, 41, 42, 42, 42, 42, 42, 42, 41, 42, 41, 41, 42, 41, 42, 41, 42, 41,
41, 41, 42, 42, 41, 41, 42, 41, 41, 41, 42, 41, 41, 41, 41, 41, 41, 42, 42, 41,
41, 41, 41, 42, 41, 41, 41, 41, 40, 41, 41, 40, 41, 41, 41, 41, 41, 41, 41, 41,
41, 41, 40, 40, 41, 41, 40, 41, 41, 41, 40, 41, 41, 41, 40, 40, 40, 40, 40, 41,
41, 40, 40, 41, 41, 40, 40, 40, 40, 41, 40, 40, 41, 41, 40, 40, 40, 41, 40, 40,
40, 39, 40, 41, 39, 40, 40, 39, 40, 39, 40, 40, 39, 40, 39, 40, 40, 40, 40, 39,
40, 39, 40, 40, 40, 40, 39, 40, 39, 40, 40, 40, 39, 40, 40, 39, 40, 39, 39, 39,
39, 39, 40, 39, 39, 39, 39, 40, 39, 39, 40, 39, 39, 40, 39, 40, 40, 38, 39, 39,
39, 39, 39, 39, 39, 39, 39, 39, 39, 38, 39, 39, 39, 39, 39, 39, 39, 39, 39, 38,
39, 39, 38, 39, 38, 39, 39, 38, 39, 39, 38, 39, 38, 39, 38, 38, 39, 38, 38, 39,
38, 39, 38, 39, 38, 38, 38, 38, 38, 39, 38, 39, 38, 38, 37, 39, 39, 38, 38, 38,
37, 38, 37, 38, 38, 39, 37, 39, 38, 39, 37, 38, 38, 37, 39, 36, 40, 34, 45, -2,
-33, -22, -29, -23, -28, -25, -27, -25, -26, -25, -26, -25, -26, -26, -25, -26,
-26, -26, -26, -27, -26, -25, -26, -25, -25, -26, -25, -25, -25, -26, -25, -26,
-25, -25, -26, -26, -26, -26, -26, -25, -26, -25, -26, -25, -26, -24, -26, -24,
-26, -25, -25, -25, -26, -25, -25, -26, -25, -26, -24, -26, -23, -28, -22, -28,
-21, -30, -14, -61, -128, -114, -122, -117, -121, -118, -119, -118, -120, -118,
-118, -120, -118, -119, -118, -119, -119, -119, -118, -118, -118, -118, -118,
-118, -117, -117, -118, -118, -117, -118, -118, -117, -118, -118, -117, -117,
-117, -117, -116, -118, -117, -116, -117, -117, -117, -117, -116, -116, -116,
-117, -117, -116, -116, -117, -116, -116, -116, -116, -117, -116, -116, -115,
-117, -113, -118, -113, -120, -109, -126, -74, -10, -27, -17, -23, -18, -22,
-20, -21, -20, -21, -20, -20, -20, -19, -20, -20, -20, -19, -21, -19, -20, -19,
-20, -19, -20, -19, -19, -19, -19, -19, -20, -20, -19, -19, -19, -19, -19, -19,
-19, -20, -19, -19, -20, -19, -19, -19, -19, -19, -19, -19, -19, -19, -19, -19,
-18, -18, -20, -19, -19, -19, -19, -19, -19, -19, -18, -19, -20, -18, -19, -19,
-19, -19, -19, -19, -19, -20, -19, -19, -18, -19, -18, -19, -18, -20, -15, };