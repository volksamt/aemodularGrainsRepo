#define DATA_LENGTH 512
#define DATA AKWF_1766

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 2, 3, 5, 5, 5, 6, 7, 8, 8, 8, 8,
8, 8, 9, 8, 9, 9, 9, 9, 8, 8, 9, 8, 9, 8, 9, 8, 8, 8, 8, 8, 8, 8, 8, 8, 8, 8, 8,
8, 8, 9, 9, 9, 9, 9, 9, 9, 9, 11, 11, 11, 11, 12, 12, 12, 13, 14, 14, 14, 15,
15, 15, 16, 18, 18, 18, 19, 20, 21, 21, 22, 23, 23, 24, 24, 26, 27, 27, 27, 29,
30, 31, 32, 32, 33, 34, 35, 36, 37, 38, 39, 39, 41, 42, 43, 44, 45, 45, 47, 48,
48, 49, 51, 52, 53, 53, 54, 55, 55, 57, 58, 59, 60, 61, 61, 62, 63, 64, 66, 66,
66, 68, 68, 69, 69, 70, 71, 72, 73, 72, 74, 75, 75, 76, 76, 78, 78, 77, 79, 79,
79, 80, 80, 81, 81, 82, 82, 82, 83, 83, 83, 84, 85, 85, 85, 86, 86, 85, 86, 86,
87, 86, 86, 87, 86, 87, 87, 86, 87, 87, 87, 86, 87, 87, 86, 87, 86, 87, 87, 86,
86, 87, 86, 86, 86, 86, 85, 86, 85, 85, 85, 85, 85, 85, 85, 85, 84, 84, 84, 83,
84, 83, 83, 83, 82, 83, 82, 82, 81, 82, 81, 80, 81, 81, 81, 80, 80, 81, 79, 79,
80, 79, 79, 80, 80, 80, 79, 80, 80, 80, 79, 79, 79, 80, 79, 80, 80, 80, 80, 79,
81, 80, 81, 79, 82, 80, 82, 79, 83, 80, 84, 78, 86, 77, 91, 62, -37, -27, -31,
-29, -29, -29, -28, -30, -28, -31, -30, -32, -30, -33, -32, -34, -33, -35, -34,
-37, -37, -37, -38, -40, -40, -41, -43, -44, -46, -46, -48, -49, -50, -51, -53,
-55, -55, -57, -59, -60, -62, -63, -64, -65, -67, -69, -71, -71, -73, -75, -76,
-78, -80, -81, -83, -84, -86, -88, -89, -89, -92, -93, -94, -96, -97, -98, -99,
-100, -102, -103, -104, -105, -107, -107, -108, -109, -110, -111, -112, -112,
-113, -114, -115, -115, -116, -116, -116, -117, -118, -118, -118, -118, -119,
-119, -120, -119, -119, -118, -118, -120, -119, -119, -118, -118, -118, -117,
-116, -116, -115, -115, -115, -113, -112, -112, -112, -110, -109, -109, -108,
-107, -106, -104, -104, -102, -101, -100, -98, -96, -95, -94, -94, -92, -90,
-88, -88, -86, -85, -84, -82, -80, -78, -78, -76, -74, -72, -71, -70, -67, -66,
-65, -64, -62, -60, -59, -56, -55, -54, -52, -50, -48, -47, -46, -45, -43, -41,
-41, -39, -36, -35, -34, -33, -32, -31, -29, -27, -26, -25, -24, -22, -22, -21,
-19, -19, -17, -16, -15, -15, -14, -13, -13, -11, -11, -10, -9, -8, -7, -7, -7,
-6, -5, -5, -4, -5, -5, -4, -3, -4, -3, -3, -2, -2, -2, -1, -2, -2, -2, -2, -2,
-1, -3, -2, -3, -2, -3, -3, -3, -3, -3, -4, -3, -4, -3, -3, -4, -4, -4, -5, -5,
-6, -5, -6, -5, -5, -6, -6, -5, -5, -5, -5, -5, -4, -3, -3, -2, -1, };