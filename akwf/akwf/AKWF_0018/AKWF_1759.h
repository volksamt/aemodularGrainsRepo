#define DATA_LENGTH 512
#define DATA AKWF_1759

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 8, 14, 21, 27, 33, 39, 44, 49,
53, 56, 58, 60, 62, 62, 63, 64, 65, 67, 70, 73, 75, 78, 81, 84, 85, 86, 87, 87,
87, 87, 86, 87, 86, 86, 86, 85, 85, 85, 85, 84, 83, 81, 78, 76, 72, 67, 63, 60,
57, 57, 58, 59, 61, 63, 66, 67, 68, 66, 65, 60, 54, 47, 39, 33, 28, 25, 22, 21,
21, 21, 22, 23, 24, 25, 27, 26, 26, 26, 23, 23, 20, 19, 19, 19, 19, 19, 20, 21,
22, 22, 21, 22, 21, 20, 20, 20, 20, 21, 23, 24, 27, 30, 34, 38, 41, 45, 47, 50,
51, 52, 52, 52, 51, 51, 51, 52, 54, 56, 59, 62, 67, 72, 76, 80, 83, 86, 88, 90,
90, 90, 89, 88, 87, 86, 86, 86, 88, 90, 93, 96, 99, 103, 106, 110, 112, 114,
114, 116, 115, 116, 116, 115, 115, 115, 115, 115, 115, 117, 118, 119, 118, 117,
117, 115, 112, 110, 109, 106, 106, 105, 104, 105, 103, 102, 101, 98, 95, 91, 85,
79, 71, 60, 51, 42, 33, 27, 23, 20, 19, 19, 20, 21, 20, 21, 18, 16, 12, 7, 2,
-3, -6, -10, -11, -12, -13, -13, -12, -12, -13, -12, -13, -12, -12, -12, -13,
-14, -14, -14, -15, -15, -14, -13, -12, -10, -11, -11, -11, -13, -15, -17, -20,
-22, -25, -27, -29, -29, -28, -26, -25, -23, -20, -18, -15, -13, -11, -11, -10,
-11, -13, -14, -15, -16, -16, -16, -15, -12, -8, -5, -1, 5, 9, 13, 17, 19, 22,
22, 23, 24, 23, 23, 22, 21, 21, 21, 21, 22, 24, 24, 26, 26, 27, 26, 24, 24, 21,
19, 17, 15, 14, 11, 10, 8, 6, 5, 3, 2, -1, -4, -9, -14, -18, -24, -29, -34, -37,
-39, -40, -39, -39, -37, -36, -36, -37, -40, -44, -49, -57, -66, -74, -81, -87,
-91, -95, -96, -98, -97, -98, -98, -98, -97, -97, -99, -100, -102, -104, -106,
-109, -111, -113, -113, -114, -114, -114, -115, -115, -115, -116, -117, -117,
-118, -119, -119, -118, -118, -117, -116, -113, -110, -106, -103, -99, -96, -93,
-92, -92, -90, -92, -91, -93, -93, -93, -92, -91, -90, -87, -83, -79, -74, -69,
-64, -61, -57, -55, -54, -53, -53, -53, -54, -55, -55, -55, -54, -52, -50, -47,
-42, -39, -35, -31, -28, -25, -23, -21, -20, -19, -18, -17, -16, -16, -14, -14,
-13, -11, -10, -7, -6, -5, -5, -5, -7, -8, -10, -12, -11, -12, -12, -11, -11,
-11, -11, -11, -13, -15, -18, -23, -27, -35, -43, -51, -59, -66, -70, -73, -73,
-73, -71, -70, -68, -66, -65, -65, -67, -70, -72, -76, -79, -82, -83, -84, -83,
-82, -80, -79, -77, -76, -74, -71, -69, -69, -67, -66, -66, -64, -63, -61, -59,
-57, -54, -51, -49, -47, -46, -46, -46, -46, -47, -47, -48, -48, -49, -48, -46,
-44, -41, -37, -33, -28, -24, -20, -17, -13, -11, -9, -8, -8, -7, -7, -5, -2,
-1, };