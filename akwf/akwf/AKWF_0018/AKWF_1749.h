#define DATA_LENGTH 512
#define DATA AKWF_1749

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 6, 7, 9, 10, 11, 11, 12,
13, 13, 14, 13, 14, 13, 14, 13, 13, 13, 13, 12, 11, 10, 10, 9, 8, 8, 7, 7, 5, 5,
5, 4, 3, 4, 4, 3, 3, 2, 2, 3, 3, 2, 3, 3, 4, 4, 5, 5, 6, 6, 7, 8, 8, 9, 10, 11,
11, 12, 13, 13, 13, 13, 15, 15, 15, 16, 17, 18, 19, 19, 22, 23, 25, 27, 28, 29,
32, 33, 36, 38, 40, 43, 44, 47, 50, 51, 54, 57, 60, 62, 65, 69, 71, 75, 78, 80,
83, 85, 88, 90, 93, 94, 97, 98, 100, 101, 102, 103, 104, 105, 105, 106, 106,
106, 107, 106, 105, 106, 104, 104, 103, 101, 101, 99, 98, 96, 93, 91, 89, 86,
83, 81, 76, 73, 70, 66, 61, 56, 52, 48, 43, 38, 34, 28, 23, 17, 13, 8, 3, -2,
-7, -11, -17, -22, -27, -33, -38, -44, -51, -55, -60, -66, -70, -75, -79, -83,
-87, -91, -94, -96, -100, -101, -104, -105, -108, -110, -111, -112, -113, -115,
-116, -117, -118, -118, -118, -118, -119, -119, -119, -118, -118, -117, -115,
-115, -114, -113, -112, -111, -110, -110, -107, -107, -105, -105, -103, -102,
-100, -99, -97, -95, -94, -93, -90, -89, -87, -85, -83, -81, -79, -77, -75, -73,
-70, -68, -66, -64, -62, -59, -56, -54, -51, -48, -45, -42, -40, -36, -33, -30,
-27, -24, -20, -17, -15, -11, -8, -5, -3, 0, 3, 5, 8, 10, 13, 16, 17, 20, 22,
25, 26, 27, 29, 31, 31, 33, 34, 35, 36, 36, 35, 34, 35, 35, 34, 33, 33, 31, 30,
28, 27, 25, 24, 23, 20, 18, 17, 15, 13, 11, 9, 8, 6, 5, 2, 1, 0, -2, -3, -6, -6,
-7, -10, -9, -10, -10, -12, -12, -13, -11, -11, -11, -11, -10, -10, -9, -8, -7,
-7, -5, -4, -3, -1, -2, 0, 2, 3, 4, 6, 7, 9, 11, 12, 14, 16, 18, 20, 21, 23, 25,
27, 28, 30, 31, 33, 35, 36, 38, 41, 42, 44, 46, 48, 50, 52, 53, 55, 57, 58, 60,
62, 63, 65, 66, 68, 69, 71, 72, 73, 73, 74, 75, 75, 75, 75, 75, 76, 75, 75, 74,
73, 73, 71, 70, 67, 66, 64, 61, 59, 56, 53, 51, 47, 45, 41, 38, 35, 32, 30, 27,
24, 21, 20, 16, 15, 12, 10, 9, 7, 5, 3, 2, 0, 0, -2, -2, -3, -3, -3, -3, -2, -3,
-3, -2, -1, 0, -1, 0, 1, 1, 1, 1, 0, 0, 0, -1, -2, -3, -3, -5, -6, -7, -9, -11,
-12, -15, -18, -19, -22, -26, -28, -32, -34, -38, -41, -44, -48, -50, -53, -56,
-59, -61, -63, -64, -66, -69, -69, -71, -71, -72, -73, -74, -74, -74, -74, -73,
-73, -72, -72, -71, -69, -67, -67, -64, -62, -60, -58, -55, -54, -50, -49, -46,
-43, -42, -39, -37, -34, -32, -29, -27, -24, -22, -20, -17, -15, -11, -8, -8,
-5, -3, 0, };