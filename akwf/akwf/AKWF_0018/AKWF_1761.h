#define DATA_LENGTH 512
#define DATA AKWF_1761

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 5, 7, 7, 9, 10, 12, 11, 12,
14, 15, 15, 16, 16, 17, 17, 18, 19, 19, 20, 21, 20, 21, 21, 22, 22, 23, 23, 23,
24, 24, 24, 24, 25, 25, 26, 26, 27, 26, 26, 27, 27, 28, 28, 28, 28, 29, 30, 29,
30, 31, 30, 30, 31, 31, 32, 31, 32, 32, 31, 32, 33, 33, 33, 33, 33, 33, 34, 34,
35, 35, 35, 35, 36, 35, 36, 36, 37, 36, 37, 37, 37, 38, 38, 38, 38, 39, 39, 39,
40, 39, 40, 40, 40, 40, 41, 41, 41, 41, 41, 42, 43, 42, 43, 43, 43, 43, 43, 44,
44, 44, 44, 45, 45, 45, 45, 45, 45, 46, 46, 46, 46, 47, 47, 47, 47, 48, 48, 48,
49, 49, 48, 48, 48, 50, 50, 50, 50, 50, 51, 52, 52, 52, 52, 53, 52, 52, 52, 53,
52, 54, 54, 53, 54, 54, 54, 55, 55, 54, 55, 55, 56, 56, 55, 56, 56, 57, 56, 58,
58, 58, 58, 58, 58, 59, 58, 60, 59, 59, 61, 60, 60, 60, 61, 61, 61, 62, 61, 62,
63, 63, 62, 63, 62, 63, 63, 64, 64, 64, 65, 65, 65, 65, 65, 66, 65, 66, 66, 66,
66, 67, 67, 67, 67, 67, 68, 68, 68, 69, 69, 69, 69, 69, 69, 70, 70, 70, 70, 70,
70, 72, 72, 71, 73, 72, 73, 72, 74, 72, 75, 73, 75, 74, 76, 74, 75, 74, 76, 74,
76, 75, 75, 78, -2, -20, -17, -29, -33, -47, -55, -68, -77, -90, -97, -106,
-111, -117, -118, -120, -116, -114, -109, -104, -96, -87, -80, -71, -64, -56,
-50, -45, -41, -38, -37, -38, -39, -43, -46, -51, -56, -62, -67, -72, -77, -82,
-85, -88, -89, -91, -90, -89, -86, -83, -80, -75, -71, -67, -62, -57, -54, -52,
-49, -47, -47, -47, -47, -47, -50, -52, -54, -56, -60, -62, -65, -67, -68, -70,
-71, -71, -72, -71, -71, -68, -67, -64, -62, -59, -58, -54, -53, -51, -50, -49,
-48, -47, -47, -48, -48, -50, -50, -53, -53, -54, -56, -57, -58, -59, -59, -59,
-59, -58, -58, -58, -56, -55, -54, -53, -52, -50, -48, -47, -46, -46, -46, -45,
-45, -45, -45, -45, -46, -45, -46, -47, -48, -48, -49, -49, -50, -49, -49, -49,
-48, -48, -48, -47, -46, -46, -45, -44, -43, -43, -42, -41, -41, -40, -40, -40,
-39, -39, -40, -40, -40, -40, -41, -41, -41, -41, -41, -40, -40, -40, -40, -40,
-39, -39, -38, -38, -37, -36, -36, -36, -36, -35, -35, -34, -34, -34, -35, -33,
-33, -33, -33, -33, -33, -33, -33, -32, -33, -32, -33, -32, -32, -32, -32, -31,
-31, -30, -30, -29, -29, -29, -28, -28, -27, -28, -27, -26, -27, -26, -26, -26,
-26, -25, -25, -25, -24, -25, -24, -23, -24, -23, -23, -22, -23, -21, -21, -21,
-20, -19, -18, -18, -18, -17, -16, -15, -15, -14, -14, -13, -13, -11, -11, -10,
-8, -7, -6, -5, -4, -2, -1, };