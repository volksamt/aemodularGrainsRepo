#define DATA_LENGTH 512
#define DATA AKWF_1704

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 13, 19, 25, 32, 39, 44, 50, 54, 58,
61, 64, 67, 69, 70, 71, 72, 73, 74, 74, 76, 78, 80, 83, 87, 90, 94, 98, 103,
107, 109, 113, 115, 117, 118, 119, 118, 118, 117, 115, 112, 111, 109, 108, 107,
106, 105, 104, 103, 102, 101, 99, 94, 91, 87, 82, 79, 74, 69, 66, 63, 60, 58,
55, 54, 52, 51, 49, 46, 44, 42, 40, 37, 35, 32, 28, 24, 21, 18, 13, 9, 5, 0, -5,
-11, -16, -22, -28, -32, -39, -44, -50, -55, -58, -62, -65, -67, -68, -68, -69,
-69, -69, -69, -69, -69, -69, -70, -70, -70, -68, -65, -63, -59, -54, -50, -44,
-38, -32, -25, -19, -12, -6, 1, 9, 16, 22, 29, 35, 40, 44, 48, 51, 54, 57, 59,
61, 62, 64, 66, 66, 67, 68, 68, 67, 66, 65, 64, 63, 61, 61, 61, 61, 61, 60, 60,
59, 58, 57, 56, 53, 50, 47, 43, 40, 36, 31, 26, 21, 16, 10, 5, -1, -5, -10, -14,
-18, -20, -23, -24, -26, -27, -27, -28, -28, -27, -27, -28, -29, -29, -30, -31,
-33, -35, -35, -36, -37, -38, -39, -38, -38, -37, -36, -34, -34, -33, -32, -33,
-33, -33, -33, -33, -32, -31, -30, -29, -26, -23, -20, -17, -14, -11, -8, -6,
-4, -3, -1, 0, 1, 2, 3, 4, 6, 6, 7, 9, 8, 9, 10, 9, 9, 8, 7, 8, 6, 7, 6, 6, 6,
7, 7, 7, 8, 9, 10, 12, 14, 15, 16, 17, 18, 19, 21, 21, 21, 22, 21, 21, 19, 19,
16, 14, 12, 10, 8, 6, 5, 4, 3, 4, 4, 6, 9, 11, 14, 16, 19, 22, 24, 26, 27, 28,
27, 28, 26, 24, 23, 20, 19, 17, 17, 16, 15, 14, 15, 14, 13, 13, 12, 8, 7, 3, 1,
-2, -5, -8, -9, -12, -13, -14, -16, -17, -17, -18, -19, -20, -22, -23, -26, -28,
-30, -34, -36, -38, -41, -44, -46, -49, -53, -55, -58, -61, -65, -68, -72, -74,
-77, -79, -81, -83, -84, -84, -84, -82, -81, -80, -77, -76, -74, -74, -73, -73,
-73, -72, -72, -70, -67, -65, -61, -57, -52, -46, -41, -35, -29, -23, -17, -10,
-4, 1, 7, 13, 17, 22, 25, 27, 30, 31, 31, 32, 33, 32, 32, 32, 32, 32, 32, 32,
33, 33, 33, 32, 33, 33, 33, 33, 33, 32, 33, 32, 33, 32, 31, 30, 29, 27, 24, 22,
19, 17, 13, 9, 5, 1, -4, -9, -13, -18, -23, -27, -31, -34, -37, -39, -40, -41,
-41, -42, -41, -41, -40, -41, -40, -40, -40, -41, -43, -45, -46, -48, -50, -52,
-53, -54, -54, -56, -56, -55, -56, -57, -57, -58, -58, -58, -58, -58, -59, -60,
-59, -59, -59, -58, -57, -56, -55, -54, -54, -53, -52, -52, -52, -52, -52, -53,
-54, -52, -54, -54, -53, -53, -52, -52, -50, -49, -49, -48, -49, -48, -47, -46,
-45, -44, -42, -41, -39, -36, -33, -28, -23, -18, -12, -5, -1, };