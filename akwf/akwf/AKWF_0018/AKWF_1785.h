#define DATA_LENGTH 512
#define DATA AKWF_1785

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 9, 13, 16, 19, 22, 26, 29, 33, 36,
38, 42, 44, 46, 49, 52, 55, 57, 58, 60, 61, 63, 64, 66, 67, 67, 68, 69, 70, 71,
70, 72, 71, 71, 70, 70, 70, 70, 70, 70, 70, 69, 70, 69, 68, 65, 62, 61, 60, 60,
61, 61, 60, 58, 57, 54, 53, 52, 51, 50, 49, 48, 47, 45, 44, 42, 41, 39, 39, 39,
39, 37, 36, 34, 32, 29, 29, 28, 29, 29, 29, 28, 26, 26, 26, 25, 24, 23, 21, 21,
21, 21, 22, 21, 21, 20, 20, 20, 21, 21, 22, 23, 22, 22, 21, 22, 23, 23, 24, 24,
26, 28, 29, 29, 30, 30, 32, 32, 34, 35, 35, 36, 36, 36, 37, 38, 40, 41, 43, 45,
47, 49, 49, 46, 44, 40, 40, 41, 44, 49, 54, 56, 58, 55, 54, 55, 58, 62, 63, 60,
51, 37, 25, 21, 23, 31, 45, 53, 57, 56, 51, 46, 41, 38, 37, 36, 34, 33, 35, 36,
39, 43, 46, 49, 54, 56, 58, 57, 53, 48, 40, 33, 31, 31, 36, 43, 49, 53, 51, 46,
35, 20, 8, 0, -4, -7, -11, -15, -20, -25, -30, -33, -35, -39, -44, -50, -57,
-66, -75, -84, -91, -96, -98, -97, -92, -91, -88, -89, -93, -99, -105, -110,
-113, -116, -117, -116, -115, -114, -111, -110, -107, -106, -107, -108, -109,
-112, -115, -117, -118, -119, -118, -115, -111, -106, -102, -98, -97, -97, -98,
-98, -99, -97, -96, -94, -91, -87, -82, -76, -69, -65, -60, -57, -52, -49, -46,
-43, -40, -32, -25, -18, -12, -6, 0, 7, 15, 22, 27, 32, 36, 38, 40, 42, 45, 49,
55, 60, 66, 72, 76, 79, 80, 80, 79, 79, 78, 78, 76, 76, 78, 80, 82, 83, 84, 83,
82, 79, 78, 75, 73, 69, 66, 62, 60, 57, 52, 47, 43, 42, 40, 38, 33, 26, 19, 11,
5, 0, -4, -7, -10, -13, -18, -21, -27, -31, -35, -40, -45, -49, -54, -58, -61,
-63, -66, -66, -68, -70, -71, -72, -72, -73, -75, -77, -79, -82, -82, -82, -80,
-76, -75, -74, -74, -73, -73, -72, -70, -68, -66, -65, -65, -64, -63, -61, -59,
-54, -49, -44, -41, -37, -32, -26, -23, -21, -18, -15, -10, -4, 0, 5, 10, 12,
16, 20, 24, 31, 34, 38, 42, 43, 46, 48, 51, 54, 57, 62, 65, 68, 67, 67, 67, 67,
68, 72, 74, 76, 77, 77, 76, 76, 75, 75, 74, 74, 73, 73, 72, 70, 70, 67, 65, 63,
62, 61, 61, 59, 56, 52, 48, 44, 41, 37, 32, 26, 22, 20, 19, 16, 12, 7, 1, -4,
-9, -11, -16, -17, -22, -25, -29, -34, -37, -40, -43, -44, -45, -47, -50, -54,
-57, -60, -62, -63, -64, -65, -65, -66, -66, -67, -69, -69, -71, -70, -70, -69,
-69, -67, -67, -66, -67, -66, -65, -63, -62, -60, -59, -57, -55, -53, -52, -50,
-48, -45, -43, -39, -35, -28, -23, -18, -17, -14, -12, -9, -5, -1, };