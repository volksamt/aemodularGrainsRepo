#define DATA_LENGTH 512
#define DATA AKWF_1755

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 11, 14, 17, 19, 23, 23, 26, 28,
31, 33, 36, 39, 44, 47, 52, 56, 61, 66, 70, 74, 78, 82, 85, 87, 90, 93, 96, 97,
100, 102, 104, 106, 109, 110, 111, 112, 114, 115, 115, 117, 117, 118, 119, 118,
119, 119, 119, 120, 120, 119, 119, 118, 118, 118, 117, 116, 116, 116, 115, 115,
113, 113, 113, 112, 112, 110, 110, 109, 108, 108, 107, 106, 105, 105, 103, 102,
102, 101, 101, 100, 100, 99, 98, 98, 96, 96, 95, 95, 94, 94, 93, 92, 93, 92, 91,
90, 90, 90, 88, 88, 87, 87, 86, 86, 84, 84, 83, 82, 81, 80, 79, 78, 75, 75, 73,
72, 70, 69, 67, 65, 64, 63, 60, 60, 58, 58, 57, 56, 55, 54, 54, 52, 52, 51, 50,
49, 48, 46, 44, 44, 42, 41, 39, 39, 37, 37, 35, 36, 35, 33, 34, 33, 32, 32, 33,
31, 30, 30, 30, 30, 31, 31, 31, 30, 30, 30, 31, 31, 30, 30, 31, 31, 31, 31, 32,
32, 32, 31, 32, 33, 32, 34, 33, 33, 34, 33, 33, 34, 35, 35, 34, 35, 34, 35, 35,
36, 35, 34, 34, 34, 34, 33, 33, 33, 32, 31, 30, 29, 29, 28, 27, 26, 26, 25, 24,
22, 20, 20, 18, 16, 14, 13, 11, 9, 8, 5, 4, 1, -1, -2, -4, -6, -8, -11, -13,
-15, -16, -18, -20, -22, -23, -24, -25, -27, -27, -28, -28, -29, -28, -27, -26,
-26, -25, -23, -23, -22, -20, -20, -19, -19, -19, -20, -21, -21, -22, -21, -22,
-21, -22, -21, -21, -20, -20, -20, -19, -19, -19, -21, -21, -21, -23, -23, -24,
-26, -28, -28, -29, -30, -30, -30, -32, -33, -34, -34, -35, -36, -37, -38, -38,
-39, -40, -40, -41, -41, -42, -41, -43, -43, -44, -43, -44, -45, -45, -45, -46,
-45, -46, -45, -46, -46, -46, -47, -46, -46, -46, -46, -46, -46, -46, -46, -46,
-47, -46, -47, -46, -46, -46, -46, -47, -47, -46, -46, -46, -46, -46, -45, -45,
-45, -45, -45, -44, -44, -43, -44, -44, -44, -44, -44, -45, -44, -45, -45, -46,
-46, -47, -47, -47, -49, -50, -51, -52, -53, -54, -56, -57, -58, -59, -61, -62,
-62, -63, -64, -64, -66, -66, -67, -67, -69, -70, -70, -72, -73, -74, -76, -77,
-79, -80, -82, -83, -85, -86, -86, -86, -87, -89, -89, -89, -91, -90, -91, -91,
-91, -92, -92, -92, -93, -92, -92, -92, -91, -91, -90, -91, -91, -90, -91, -91,
-90, -90, -91, -90, -91, -91, -90, -91, -91, -91, -90, -90, -91, -91, -90, -90,
-90, -90, -90, -89, -90, -89, -88, -89, -89, -89, -88, -89, -88, -88, -89, -88,
-88, -88, -88, -87, -86, -87, -86, -86, -85, -85, -84, -85, -84, -83, -82, -81,
-82, -81, -80, -79, -78, -78, -77, -75, -75, -73, -72, -70, -69, -67, -65, -63,
-62, -59, -56, -54, -51, -48, -46, -43, -40, -37, -32, -30, -25, -21, -16, -13,
-8, -4, -1, };