#define DATA_LENGTH 512
#define DATA AKWF_1720

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 20, 31, 41, 50, 57, 63, 69, 75, 79,
83, 86, 89, 91, 95, 97, 99, 100, 103, 104, 106, 107, 107, 109, 111, 110, 112,
113, 113, 113, 115, 115, 115, 116, 116, 116, 117, 117, 118, 118, 119, 119, 118,
120, 119, 118, 119, 119, 119, 120, 120, 119, 119, 119, 119, 118, 118, 119, 119,
118, 118, 119, 118, 117, 118, 117, 117, 117, 116, 116, 116, 116, 115, 115, 115,
115, 115, 114, 113, 114, 113, 112, 113, 112, 112, 111, 110, 110, 110, 110, 109,
108, 109, 109, 108, 108, 107, 106, 106, 106, 105, 105, 104, 103, 102, 102, 102,
102, 101, 100, 100, 99, 98, 97, 97, 97, 96, 96, 95, 95, 94, 93, 92, 92, 90, 90,
91, 89, 88, 88, 87, 87, 86, 85, 83, 82, 82, 82, 81, 80, 79, 78, 77, 76, 76, 74,
73, 72, 71, 70, 69, 68, 68, 66, 65, 65, 63, 62, 61, 60, 59, 58, 57, 55, 54, 52,
51, 50, 49, 48, 47, 46, 44, 42, 42, 39, 38, 37, 35, 34, 33, 31, 30, 27, 27, 25,
23, 21, 19, 18, 16, 16, 14, 12, 10, 8, 7, 5, 3, 1, -1, -2, -4, -7, -8, -10, -12,
-13, -16, -18, -19, -21, -23, -25, -28, -29, -32, -33, -35, -39, -40, -42, -44,
-46, -48, -50, -52, -55, -56, -58, -61, -63, -66, -67, -70, -72, -74, -76, -79,
-81, -83, -86, -87, -90, -92, -94, -96, -98, -101, -103, -105, -104, -102, -102,
-100, -99, -97, -97, -96, -95, -94, -92, -91, -89, -88, -88, -86, -84, -84, -82,
-80, -80, -80, -78, -77, -75, -75, -73, -73, -71, -70, -70, -69, -66, -66, -65,
-65, -63, -62, -61, -60, -59, -59, -58, -57, -56, -55, -55, -54, -52, -52, -51,
-51, -50, -49, -48, -48, -47, -47, -46, -45, -44, -44, -44, -43, -42, -42, -42,
-41, -40, -40, -39, -39, -40, -38, -38, -38, -38, -37, -37, -36, -37, -36, -35,
-36, -35, -35, -34, -35, -34, -34, -33, -34, -34, -33, -34, -33, -33, -33, -33,
-33, -33, -34, -33, -33, -33, -33, -34, -34, -34, -33, -33, -33, -34, -34, -34,
-34, -33, -34, -35, -34, -35, -35, -35, -35, -36, -36, -36, -36, -37, -37, -37,
-37, -37, -38, -38, -38, -39, -39, -38, -39, -40, -40, -41, -41, -41, -41, -41,
-43, -43, -42, -43, -43, -44, -44, -45, -44, -45, -46, -46, -47, -47, -47, -48,
-49, -48, -49, -50, -49, -50, -50, -51, -51, -53, -53, -53, -54, -54, -54, -55,
-55, -56, -56, -56, -57, -58, -58, -58, -59, -59, -61, -61, -61, -62, -62, -62,
-63, -64, -63, -65, -65, -65, -66, -67, -66, -67, -68, -69, -70, -70, -70, -70,
-71, -72, -72, -72, -73, -74, -75, -75, -75, -76, -77, -76, -78, -78, -79, -80,
-80, -79, -81, -81, -81, -82, -82, -84, -84, -84, -84, -85, -83, -77, -68, -59,
-50, -42, -36, -33, -31, -33, -37, -45, -53, -66, -77, -92, -99, -77, -57, -37,
-19, -4, };