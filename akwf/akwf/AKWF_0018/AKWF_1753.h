#define DATA_LENGTH 512
#define DATA AKWF_1753

const PROGMEM int8_t DATA[DATA_LENGTH] = {22, 19, 16, 28, 31, 34, 32, 32, 31,
33, 32, 32, 32, 32, 32, 33, 32, 33, 32, 32, 32, 32, 32, 32, 33, 32, 33, 32, 32,
32, 33, 33, 32, 32, 32, 32, 33, 33, 33, 33, 33, 32, 32, 32, 32, 33, 32, 33, 32,
33, 33, 33, 32, 33, 32, 32, 32, 32, 32, 32, 32, 32, 32, 32, 31, 33, 31, 33, 32,
33, 31, 33, 31, 33, 31, 23, 58, 62, 60, 61, 57, 55, 52, 54, 53, 54, 55, 57, 57,
59, 59, 60, 59, 59, 60, 60, 60, 58, 59, 58, 58, 59, 59, 59, 58, 59, 58, 58, 59,
58, 58, 57, 58, 57, 58, 58, 58, 57, 58, 58, 58, 57, 57, 57, 57, 57, 57, 57, 57,
57, 57, 56, 57, 58, 57, 58, 56, 56, 57, 58, 57, 57, 57, 56, 57, 57, 57, 57, 57,
57, 57, 58, 57, 57, 56, 57, 57, 48, 49, 49, 48, 48, 48, 48, 48, 48, 47, 47, 47,
48, 47, 48, 47, 48, 48, 47, 48, 47, 48, 47, 47, 48, 47, 46, 47, 48, 47, 48, 47,
47, 48, 47, 48, 47, 48, 46, 48, 46, 47, 47, 47, 47, 47, 47, 47, 47, 47, 48, 47,
47, 47, 46, 47, 46, 48, 46, 46, 46, 46, 47, 46, 47, 46, 48, 46, 56, 65, 63, 63,
62, 61, 59, 60, 59, 60, 59, 60, 60, 60, 60, 60, 60, 60, 61, 61, 60, 60, 60, 60,
59, 60, 60, 60, 60, 60, 61, 61, 59, 60, 60, 60, 61, 59, 61, 60, 60, 60, 59, 60,
60, 60, 59, 60, 60, 59, 60, 59, 60, 59, 59, 59, 59, 59, 60, 60, 58, 61, 57, 61,
57, 62, 53, 69, 11, -100, -116, -117, -104, -99, -93, -90, -88, -85, -85, -85,
-86, -88, -91, -94, -97, -97, -100, -100, -101, -101, -101, -100, -99, -99, -98,
-97, -98, -97, -96, -96, -96, -96, -96, -96, -96, -96, -95, -96, -95, -95, -96,
-95, -95, -95, -95, -95, -95, -95, -95, -95, -95, -95, -95, -95, -95, -94, -94,
-94, -95, -95, -94, -94, -94, -95, -95, -94, -95, -93, -94, -94, -94, -95, -94,
-95, -94, -94, -93, -95, -93, -98, -79, -57, -59, -60, -64, -65, -68, -68, -69,
-69, -70, -69, -68, -68, -67, -67, -66, -66, -66, -66, -67, -67, -66, -66, -67,
-67, -67, -67, -67, -67, -67, -68, -67, -68, -67, -67, -68, -67, -67, -67, -67,
-67, -67, -68, -67, -67, -67, -68, -67, -66, -67, -67, -67, -67, -67, -68, -67,
-67, -67, -67, -67, -68, -67, -68, -66, -67, -65, -69, -56, -26, -22, -24, -28,
-30, -32, -32, -33, -34, -33, -33, -32, -32, -31, -30, -30, -30, -29, -30, -30,
-30, -29, -29, -30, -31, -29, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30,
-31, -30, -30, -30, -30, -30, -30, -30, -31, -31, -29, -30, -30, -30, -30, -29,
-30, -30, -30, -30, -30, -29, -30, -29, -30, -29, -31, -30, -31, -28, -31, -25,
};