#define DATA_LENGTH 512
#define DATA AKWF_1733

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 19, 29, 41, 51, 65, 79, 91, 102,
111, 114, 115, 116, 116, 116, 119, 119, 118, 114, 109, 100, 91, 83, 76, 69, 63,
57, 49, 40, 30, 21, 11, 4, 0, -6, -10, -14, -20, -25, -31, -34, -37, -38, -38,
-37, -38, -37, -39, -38, -38, -37, -35, -32, -29, -27, -24, -22, -20, -19, -16,
-14, -11, -8, -5, -4, -2, -1, 1, 2, 4, 5, 6, 7, 8, 8, 9, 8, 8, 8, 8, 9, 8, 8, 7,
7, 6, 5, 4, 5, 4, 4, 3, 3, 2, 1, 1, 1, 0, 0, -1, -2, -1, -2, -2, -3, -3, -2, -3,
-2, -3, -3, -3, -3, -3, -3, -3, -2, -3, -2, -1, -2, -1, -1, -1, -1, -1, -1, -2,
-1, -1, -1, 0, 0, 0, -1, 0, 0, -1, 0, 0, -1, -1, -1, 0, 0, 0, -1, -1, 0, 0, 0,
0, 0, 0, 0, 0, -1, 0, 0, -1, -1, -1, 0, -1, 0, 0, 0, 0, -1, -1, -1, -1, -1, 0,
-1, 0, -1, 0, -1, -1, 0, 0, -1, 0, -1, 0, -1, 0, 0, 0, 0, -1, 0, -1, -1, -1, 0,
-1, -1, -1, 0, 0, 0, 0, 0, 0, -1, -1, 0, -1, 0, 0, 0, 0, -1, -1, 0, 0, 0, -1,
-1, -1, 0, -1, -1, -1, 0, -1, -1, -1, -1, -1, -1, 0, 0, -1, -1, 0, -1, -1, 0,
-1, 0, 0, 0, 0, 0, -1, -1, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, -1, -1,
0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0,
0, 0, 0, 0, -1, -1, 0, 0, -1, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 1, 0, -1, 1,
-1, 0, -1, -1, 0, 0, 0, 0, -1, -1, 0, 0, -1, 0, 0, 0, -1, -1, -1, -1, -1, 0, -1,
0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0,
0, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1,
0, 0, 0, -1, -1, 0, 0, 0, 0, 1, 0, -1, 1, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, -1, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0,
0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, -1,
0, 0, 0, 0, 0, 0, -1, 0, 0, -1, -1, 0, 0, 1, 0, 0, 0, 0, 0, 1, -1, 0, 0, -1, -5,
-12, -22, -32, -43, -55, -67, -81, -94, -105, -113, -115, -114, -110, -106,
-102, -97, -93, -85, -74, -59, -41, -25, -7, };