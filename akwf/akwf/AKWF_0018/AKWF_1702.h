#define DATA_LENGTH 512
#define DATA AKWF_1702

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 6, 11, 16, 22, 27, 33, 38, 44, 49,
54, 58, 63, 68, 73, 76, 79, 82, 86, 88, 91, 93, 96, 99, 102, 104, 107, 111, 113,
115, 116, 118, 117, 116, 116, 114, 112, 108, 106, 104, 101, 99, 98, 97, 96, 94,
96, 94, 93, 91, 91, 90, 90, 90, 89, 90, 89, 90, 91, 92, 91, 92, 93, 92, 91, 91,
91, 91, 91, 91, 91, 91, 93, 93, 95, 95, 96, 97, 98, 99, 99, 101, 101, 102, 102,
102, 101, 100, 100, 100, 98, 98, 97, 96, 96, 96, 96, 97, 96, 98, 97, 98, 98, 97,
97, 96, 96, 93, 94, 91, 90, 89, 87, 85, 85, 83, 83, 81, 81, 79, 77, 75, 73, 70,
67, 65, 61, 59, 56, 52, 50, 47, 43, 39, 35, 30, 25, 19, 14, 7, 1, -5, -10, -17,
-22, -28, -33, -37, -42, -48, -52, -57, -61, -64, -67, -70, -72, -74, -75, -77,
-77, -78, -80, -80, -81, -81, -83, -83, -83, -83, -83, -83, -81, -82, -80, -79,
-78, -77, -77, -76, -75, -74, -74, -74, -73, -71, -70, -69, -67, -65, -64, -62,
-59, -57, -57, -55, -54, -53, -52, -51, -50, -49, -48, -47, -47, -46, -47, -47,
-47, -49, -51, -53, -56, -58, -59, -61, -62, -63, -64, -64, -64, -64, -63, -62,
-59, -58, -55, -54, -52, -49, -47, -46, -44, -42, -41, -39, -37, -36, -35, -34,
-32, -31, -29, -28, -26, -24, -23, -20, -18, -16, -13, -10, -7, -4, 1, 4, 8, 12,
14, 19, 22, 25, 28, 30, 31, 32, 33, 34, 34, 34, 34, 33, 33, 32, 30, 29, 28, 27,
25, 22, 21, 18, 15, 11, 8, 4, 0, -7, -12, -18, -25, -31, -38, -45, -52, -59,
-66, -72, -78, -83, -90, -94, -98, -103, -107, -111, -113, -115, -117, -117,
-118, -119, -119, -119, -119, -118, -118, -118, -118, -117, -117, -116, -115,
-114, -112, -110, -108, -104, -101, -97, -94, -89, -84, -80, -75, -70, -65, -61,
-56, -52, -48, -44, -41, -37, -34, -30, -28, -25, -23, -20, -17, -15, -12, -10,
-8, -4, -2, 1, 3, 6, 8, 11, 11, 14, 15, 16, 16, 17, 18, 19, 19, 20, 21, 21, 22,
22, 23, 24, 23, 24, 24, 25, 24, 25, 24, 24, 22, 21, 20, 18, 15, 13, 12, 8, 6, 3,
0, -3, -6, -8, -10, -14, -15, -18, -19, -22, -22, -23, -23, -24, -24, -24, -24,
-23, -23, -22, -21, -22, -20, -20, -19, -18, -17, -17, -17, -16, -16, -16, -15,
-13, -12, -10, -9, -8, -5, -4, -3, -1, 0, 3, 4, 5, 6, 7, 7, 8, 8, 9, 10, 9, 9,
9, 9, 9, 9, 9, 9, 9, 8, 7, 5, 5, 2, 1, -3, -6, -8, -11, -15, -17, -20, -22, -26,
-29, -31, -32, -34, -35, -36, -37, -37, -37, -36, -36, -36, -36, -37, -36, -37,
-38, -38, -39, -39, -39, -40, -39, -38, -37, -37, -35, -34, -33, -31, -29, -28,
-25, -23, -19, -16, -12, -8, -3, };