#define DATA_LENGTH 512
#define DATA AKWF_1711

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 5, 5, 5, 5, 7, 7, 7, 8, 10,
11, 14, 16, 16, 17, 18, 21, 22, 23, 25, 25, 23, 25, 27, 30, 32, 32, 33, 34, 37,
41, 44, 46, 47, 46, 48, 49, 53, 54, 54, 53, 51, 51, 54, 55, 55, 56, 56, 55, 58,
61, 63, 65, 65, 64, 65, 67, 69, 70, 69, 67, 65, 62, 63, 65, 65, 64, 63, 63, 65,
69, 73, 76, 76, 77, 78, 81, 83, 85, 84, 82, 81, 81, 84, 85, 84, 85, 85, 85, 89,
92, 93, 96, 97, 98, 101, 103, 106, 108, 108, 107, 108, 110, 109, 110, 109, 108,
109, 108, 108, 109, 107, 107, 108, 109, 110, 112, 113, 114, 116, 118, 118, 118,
118, 117, 117, 115, 113, 112, 109, 106, 105, 103, 103, 103, 103, 102, 103, 102,
103, 105, 107, 106, 105, 103, 102, 104, 105, 101, 99, 96, 93, 93, 95, 93, 91,
89, 87, 90, 93, 94, 96, 94, 92, 95, 94, 96, 96, 92, 88, 88, 87, 86, 87, 85, 82,
81, 80, 82, 85, 83, 81, 80, 80, 81, 81, 80, 78, 76, 75, 74, 75, 73, 70, 67, 67,
66, 64, 62, 61, 59, 58, 57, 57, 55, 53, 52, 52, 52, 51, 49, 45, 45, 43, 44, 43,
40, 36, 36, 35, 34, 33, 31, 28, 28, 29, 29, 29, 28, 26, 25, 26, 28, 27, 26, 24,
21, 21, 21, 19, 16, 13, 12, 9, 10, 9, 7, 6, 5, 6, 7, 7, 6, 4, 4, 3, 1, 1, -1,
-4, -7, -7, -8, -9, -12, -15, -15, -15, -13, -14, -15, -16, -17, -17, -15, -15,
-18, -19, -22, -21, -20, -22, -25, -27, -30, -30, -29, -32, -34, -36, -37, -39,
-39, -40, -40, -43, -43, -44, -45, -46, -48, -50, -52, -52, -54, -56, -59, -60,
-62, -62, -62, -65, -68, -69, -69, -69, -68, -71, -73, -73, -74, -72, -69, -70,
-73, -75, -77, -76, -77, -79, -82, -84, -88, -88, -85, -85, -86, -86, -88, -87,
-84, -82, -81, -82, -86, -86, -85, -85, -86, -89, -93, -95, -96, -96, -97, -97,
-100, -102, -101, -101, -98, -98, -98, -98, -97, -98, -99, -99, -100, -103,
-105, -108, -111, -113, -114, -115, -116, -117, -117, -116, -115, -115, -114,
-112, -113, -111, -110, -110, -110, -110, -111, -109, -111, -113, -113, -113,
-114, -112, -112, -114, -113, -113, -113, -111, -109, -107, -105, -105, -104,
-100, -97, -94, -92, -93, -94, -93, -91, -89, -90, -93, -94, -95, -93, -90, -87,
-86, -86, -85, -82, -77, -75, -73, -73, -74, -75, -74, -73, -73, -73, -75, -78,
-79, -78, -76, -74, -75, -75, -76, -74, -71, -68, -66, -65, -67, -68, -66, -65,
-63, -61, -64, -65, -65, -64, -62, -60, -60, -60, -59, -57, -53, -50, -48, -47,
-46, -45, -43, -40, -39, -37, -39, -38, -37, -36, -35, -32, -32, -30, -29, -26,
-25, -23, -23, -21, -20, -20, -20, -18, -20, -20, -18, -18, -16, -14, -12, -12,
-8, -5, -4, -2, 0, };