#define DATA_LENGTH 512
#define DATA AKWF_1790

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 14, 17, 20, 28, 32, 39, 43, 44,
45, 46, 46, 47, 49, 52, 55, 55, 56, 57, 57, 58, 58, 59, 60, 61, 63, 63, 63, 64,
64, 66, 66, 67, 68, 68, 69, 70, 69, 71, 71, 71, 72, 72, 72, 73, 72, 74, 73, 73,
74, 75, 74, 76, 77, 79, 80, 82, 82, 85, 87, 87, 89, 91, 91, 92, 92, 92, 92, 92,
93, 93, 93, 92, 92, 93, 92, 92, 92, 92, 92, 92, 92, 90, 91, 91, 91, 90, 91, 90,
90, 90, 90, 89, 88, 87, 85, 87, 61, 14, -2, -3, -2, -2, -1, -1, 0, -1, 0, 1, 2,
1, 2, 2, 2, 3, 3, 4, 4, 5, 5, 6, 6, 6, 7, 7, 7, 8, 8, 10, 9, 10, 11, 11, 11, 12,
11, 13, 13, 12, 12, 13, 13, 14, 14, 14, 14, 16, 16, 16, 16, 16, 16, 16, 17, 17,
17, 18, 18, 18, 18, 18, 19, 20, 19, 19, 19, 20, 20, 20, 21, 22, 21, 22, 22, 22,
22, 22, 22, 23, 22, 23, 24, 24, 24, 25, 25, 26, 25, 25, 25, 25, 25, 26, 26, 26,
26, 26, 27, 26, 26, 25, 27, 27, 27, 30, 26, 26, 26, 27, 34, 36, 36, 38, 38, 39,
40, 40, 41, 42, 42, 45, 47, 48, 48, 49, 50, 51, 52, 52, 53, 53, 54, 55, 56, 56,
57, 58, 59, 60, 61, 61, 63, 63, 65, 66, 66, 66, 68, 68, 68, 69, 70, 71, 71, 73,
75, 76, 76, 77, 78, 78, 79, 79, 78, 80, 80, 80, 80, 81, 80, 81, 81, 82, 81, 82,
83, 83, 83, 84, 85, 85, 86, 85, 87, 88, 88, 88, 89, 87, 86, 86, 87, 86, 86, 85,
84, 82, 80, 76, 75, 70, 67, 60, 60, 51, 43, 43, -8, -17, -16, -18, -17, -20,
-21, -26, -29, -33, -36, -39, -40, -43, -44, -44, -47, -54, -61, -64, -63, -66,
-67, -68, -69, -71, -74, -82, -89, -95, -104, -104, -105, -108, -110, -113,
-116, -117, -118, -118, -119, -119, -119, -119, -118, -119, -118, -118, -118,
-118, -117, -118, -118, -117, -117, -117, -116, -116, -116, -115, -115, -115,
-115, -114, -115, -114, -114, -113, -113, -113, -112, -112, -111, -110, -110,
-110, -110, -109, -108, -109, -108, -108, -108, -106, -107, -106, -106, -105,
-104, -105, -103, -104, -103, -102, -103, -102, -101, -100, -100, -100, -99,
-99, -96, -96, -96, -94, -93, -93, -92, -92, -91, -90, -89, -89, -88, -88, -87,
-86, -86, -85, -84, -84, -83, -83, -82, -81, -80, -80, -79, -78, -78, -77, -76,
-76, -74, -74, -73, -73, -71, -71, -71, -71, -69, -69, -69, -68, -67, -67, -66,
-65, -65, -64, -63, -62, -62, -60, -60, -60, -58, -58, -57, -57, -56, -55, -55,
-54, -54, -52, -52, -51, -50, -49, -45, -45, -44, -43, -41, -40, -40, -39, -38,
-37, -35, -35, -33, -31, -29, -28, -26, -25, -24, -23, -20, -18, -15, -13, -12,
-12, -11, -10, -8, -6, -3, -1, };