#define DATA_LENGTH 512
#define DATA AKWF_1760

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 13, 16, 20, 23, 26, 31,
35, 40, 43, 47, 51, 56, 60, 64, 69, 74, 77, 81, 86, 89, 94, 97, 100, 104, 107,
109, 111, 113, 115, 117, 118, 119, 119, 119, 119, 117, 117, 115, 114, 111, 109,
106, 103, 100, 96, 92, 88, 85, 80, 76, 72, 66, 63, 57, 52, 47, 43, 37, 33, 28,
24, 19, 14, 10, 5, 1, -2, -7, -11, -15, -17, -22, -26, -28, -31, -35, -37, -41,
-44, -47, -48, -50, -53, -55, -57, -59, -61, -63, -64, -65, -66, -67, -68, -68,
-69, -69, -69, -69, -68, -68, -67, -66, -65, -62, -61, -59, -57, -55, -52, -49,
-47, -45, -41, -38, -36, -32, -29, -26, -23, -20, -16, -13, -9, -6, -4, -1, 2,
5, 8, 10, 11, 14, 16, 18, 19, 21, 22, 24, 25, 26, 26, 27, 27, 28, 27, 28, 28,
27, 27, 28, 27, 28, 26, 25, 24, 24, 23, 22, 21, 21, 19, 19, 17, 16, 15, 14, 12,
11, 9, 8, 6, 3, 2, 0, -2, -4, -6, -8, -10, -12, -14, -16, -18, -21, -24, -25,
-27, -29, -32, -34, -35, -37, -39, -41, -41, -44, -45, -46, -47, -48, -49, -50,
-51, -51, -51, -52, -52, -53, -53, -52, -53, -51, -52, -52, -52, -51, -51, -49,
-49, -49, -48, -48, -47, -46, -46, -45, -43, -43, -42, -41, -41, -39, -37, -38,
-36, -34, -33, -31, -30, -29, -27, -25, -23, -21, -20, -18, -16, -13, -11, -9,
-7, -4, -2, 1, 3, 7, 9, 11, 15, 18, 21, 24, 27, 31, 35, 37, 41, 44, 48, 52, 55,
58, 62, 65, 68, 71, 74, 77, 79, 82, 84, 86, 89, 89, 91, 91, 92, 92, 91, 92, 91,
91, 88, 87, 84, 83, 81, 78, 75, 71, 68, 65, 62, 57, 53, 50, 45, 40, 36, 32, 28,
24, 19, 15, 11, 5, 2, -3, -6, -10, -14, -18, -23, -25, -29, -34, -37, -40, -43,
-46, -50, -53, -56, -60, -63, -65, -68, -71, -73, -76, -79, -81, -83, -86, -89,
-90, -92, -94, -96, -98, -99, -100, -102, -102, -102, -104, -103, -104, -103,
-103, -103, -102, -102, -99, -98, -97, -96, -93, -92, -90, -87, -86, -83, -80,
-78, -75, -72, -71, -67, -65, -62, -60, -58, -54, -52, -49, -46, -44, -42, -39,
-37, -35, -32, -29, -29, -26, -25, -22, -20, -17, -15, -14, -11, -9, -6, -4, -3,
-1, 2, 4, 7, 9, 11, 14, 16, 18, 20, 23, 25, 27, 28, 32, 33, 34, 36, 37, 39, 41,
42, 43, 44, 45, 46, 47, 47, 47, 47, 48, 46, 47, 45, 46, 46, 44, 43, 43, 41, 40,
38, 39, 37, 35, 34, 32, 31, 30, 28, 26, 25, 24, 22, 21, 19, 16, 16, 15, 12, 11,
9, 7, 6, 4, 2, 2, 0, -2, -3, -6, -7, -8, -10, -11, -12, -13, -15, -15, -17, -17,
-18, -18, -18, -18, -19, -18, -18, -17, -18, -17, -17, -15, -14, -13, -11, -9,
-8, -6, -4, -1, };