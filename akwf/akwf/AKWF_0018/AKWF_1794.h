#define DATA_LENGTH 512
#define DATA AKWF_1794

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 2, 3, 3, 4, 4, 6, 6, 7, 8, 9,
10, 11, 12, 14, 15, 15, 16, 18, 19, 21, 22, 23, 24, 25, 28, 28, 30, 30, 33, 33,
34, 36, 36, 37, 39, 39, 41, 40, 42, 42, 43, 43, 43, 44, 44, 44, 44, 45, 45, 45,
44, 45, 44, 43, 43, 42, 43, 41, 41, 40, 40, 39, 38, 39, 38, 37, 36, 35, 35, 35,
34, 33, 32, 33, 32, 31, 31, 30, 31, 30, 30, 30, 30, 29, 29, 29, 30, 30, 30, 30,
30, 31, 32, 32, 32, 33, 33, 34, 35, 35, 37, 38, 39, 40, 40, 42, 43, 44, 45, 46,
48, 49, 51, 52, 54, 55, 57, 58, 60, 62, 64, 66, 67, 68, 70, 73, 74, 75, 77, 79,
80, 82, 84, 85, 86, 88, 90, 91, 92, 95, 96, 96, 98, 99, 100, 101, 103, 103, 104,
105, 107, 107, 108, 109, 110, 111, 112, 112, 113, 114, 114, 116, 116, 117, 116,
117, 115, 118, 117, 118, 118, 119, 117, 117, 117, 116, 117, 116, 115, 114, 115,
112, 114, 109, 111, 107, 108, 103, 106, 100, 102, 95, 97, 91, 93, 85, 87, 80,
79, 79, -100, -125, -106, -115, -100, -105, -93, -97, -88, -89, -81, -82, -76,
-76, -71, -71, -66, -64, -61, -60, -57, -55, -55, -52, -52, -49, -49, -47, -48,
-46, -48, -46, -47, -46, -46, -46, -47, -46, -47, -48, -49, -49, -49, -50, -50,
-50, -50, -50, -51, -52, -52, -52, -53, -53, -53, -53, -53, -53, -53, -53, -54,
-54, -53, -53, -52, -52, -52, -52, -51, -52, -50, -50, -50, -49, -49, -48, -47,
-46, -46, -46, -45, -44, -44, -43, -43, -41, -42, -41, -41, -40, -40, -40, -40,
-40, -39, -39, -38, -39, -39, -38, -39, -39, -39, -38, -39, -39, -39, -39, -39,
-41, -40, -40, -40, -40, -40, -41, -41, -42, -41, -41, -42, -42, -41, -43, -41,
-43, -41, -41, -42, -41, -42, -41, -41, -41, -40, -39, -40, -40, -40, -38, -38,
-38, -38, -38, -37, -36, -35, -35, -35, -34, -34, -34, -33, -33, -32, -33, -32,
-32, -32, -32, -31, -31, -31, -32, -32, -31, -32, -31, -32, -33, -32, -34, -34,
-34, -34, -35, -36, -37, -37, -37, -39, -40, -40, -42, -42, -43, -43, -43, -44,
-45, -45, -46, -46, -47, -47, -47, -48, -49, -48, -48, -48, -48, -48, -48, -49,
-49, -48, -49, -48, -48, -48, -47, -46, -46, -46, -46, -45, -44, -43, -43, -43,
-42, -41, -41, -40, -40, -39, -39, -38, -37, -37, -37, -35, -34, -34, -34, -32,
-32, -31, -31, -30, -30, -29, -28, -28, -27, -26, -26, -25, -24, -24, -24, -23,
-22, -21, -21, -20, -19, -19, -18, -17, -17, -17, -16, -16, -15, -15, -14, -15,
-13, -13, -12, -12, -11, -11, -11, -11, -11, -10, -10, -9, -10, -9, -8, -9, -9,
-8, -7, -8, -7, -7, -7, -6, -5, -7, -5, -4, -5, -5, -5, -4, -4, -4, -2, -1, -3,
-2, -1, 0, };