#define DATA_LENGTH 512
#define DATA AKWF_1715

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 11, 15, 19, 24, 28, 32, 35, 40,
44, 48, 52, 54, 59, 62, 67, 70, 73, 76, 80, 83, 86, 88, 92, 94, 95, 99, 100,
102, 105, 105, 107, 108, 110, 111, 111, 113, 113, 114, 114, 114, 115, 114, 115,
114, 113, 113, 110, 110, 108, 107, 105, 104, 101, 99, 97, 95, 92, 90, 87, 84,
80, 78, 75, 71, 68, 64, 61, 57, 54, 50, 47, 43, 40, 36, 33, 29, 25, 22, 19, 14,
10, 7, 3, 0, -4, -7, -11, -15, -18, -20, -25, -28, -30, -32, -36, -38, -41, -43,
-45, -48, -50, -53, -54, -56, -58, -59, -61, -62, -63, -65, -67, -67, -68, -69,
-69, -69, -71, -70, -70, -70, -70, -70, -71, -70, -70, -69, -69, -69, -69, -68,
-68, -67, -67, -66, -65, -65, -63, -62, -60, -60, -57, -56, -54, -52, -51, -49,
-48, -46, -43, -41, -39, -38, -36, -34, -32, -30, -28, -26, -24, -23, -21, -18,
-16, -15, -13, -13, -10, -8, -7, -5, -3, -2, -1, 1, 2, 3, 5, 6, 8, 9, 11, 11,
13, 15, 15, 17, 19, 19, 20, 22, 23, 23, 25, 26, 27, 29, 28, 31, 31, 33, 33, 34,
34, 35, 36, 36, 37, 37, 38, 37, 38, 38, 38, 38, 38, 38, 38, 37, 38, 36, 37, 35,
34, 34, 34, 33, 31, 30, 29, 28, 28, 26, 24, 24, 23, 21, 19, 18, 16, 15, 14, 12,
10, 9, 8, 7, 6, 4, 3, 1, 0, -1, -2, -3, -4, -5, -7, -8, -9, -9, -11, -12, -13,
-14, -16, -16, -18, -19, -20, -21, -23, -24, -25, -27, -28, -29, -31, -32, -33,
-33, -34, -35, -36, -37, -37, -38, -39, -39, -40, -40, -40, -40, -41, -40, -41,
-42, -42, -41, -41, -41, -42, -42, -41, -41, -40, -40, -39, -40, -38, -38, -37,
-37, -37, -35, -35, -34, -33, -32, -31, -29, -29, -27, -26, -25, -23, -22, -21,
-18, -17, -16, -14, -12, -9, -8, -6, -4, -2, -1, 2, 5, 7, 9, 11, 12, 15, 18, 19,
22, 24, 28, 29, 32, 34, 37, 39, 42, 45, 47, 50, 52, 54, 57, 59, 62, 64, 66, 68,
71, 72, 75, 76, 78, 80, 81, 82, 84, 85, 85, 87, 87, 89, 89, 89, 90, 90, 90, 90,
91, 90, 88, 89, 87, 87, 86, 84, 84, 81, 81, 79, 76, 74, 72, 70, 67, 65, 62, 59,
56, 53, 50, 47, 44, 41, 37, 33, 30, 27, 23, 20, 16, 12, 8, 5, 1, -3, -8, -11,
-14, -18, -22, -27, -30, -33, -38, -41, -45, -49, -52, -56, -59, -64, -67, -70,
-74, -77, -80, -82, -85, -89, -91, -94, -97, -99, -102, -104, -105, -108, -110,
-112, -113, -114, -115, -117, -118, -118, -118, -119, -119, -119, -119, -118,
-118, -117, -116, -116, -114, -113, -111, -109, -107, -107, -103, -102, -99,
-96, -94, -91, -87, -84, -81, -77, -74, -70, -68, -63, -59, -55, -52, -48, -43,
-40, -35, -31, -27, -22, -18, -13, -9, -6, -2, };