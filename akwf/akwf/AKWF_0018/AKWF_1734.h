#define DATA_LENGTH 512
#define DATA AKWF_1734

const PROGMEM int8_t DATA[DATA_LENGTH] = {23, 47, 73, 91, 114, 120, 117, 120,
118, 120, 118, 120, 118, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 118, 119, 118, 119, 119, 119, 119, 118, 119,
119, 118, 119, 119, 119, 119, 118, 119, 119, 118, 118, 119, 118, 119, 118, 118,
119, 119, 118, 119, 113, 108, 102, 96, 91, 86, 81, 75, 70, 65, 60, 54, 50, 44,
40, 35, 31, 26, 23, 17, 14, 10, 6, 2, -2, -6, -9, -12, -16, -19, -23, -25, -29,
-32, -34, -37, -39, -42, -44, -47, -49, -51, -54, -55, -58, -59, -61, -63, -64,
-65, -67, -68, -69, -71, -72, -74, -74, -75, -77, -77, -78, -79, -79, -80, -81,
-81, -81, -82, -82, -83, -83, -82, -83, -83, -83, -84, -83, -82, -84, -83, -82,
-83, -82, -82, -82, -81, -82, -82, -81, -80, -79, -79, -79, -77, -77, -78, -76,
-75, -75, -74, -74, -73, -72, -72, -71, -70, -70, -69, -68, -67, -66, -65, -65,
-64, -63, -62, -61, -61, -59, -59, -58, -57, -56, -55, -54, -54, -53, -51, -51,
-51, -49, -48, -48, -46, -46, -46, -44, -44, -42, -42, -41, -41, -39, -40, -37,
-38, -36, -36, -35, -34, -33, -33, -32, -30, -30, -28, -29, -27, -27, -25, -27,
-22, -28, -22, -24, -21, -24, -17, -26, -17, -19, -21, -17, -15, -24, -32, 104,
122, 117, 121, 118, 121, 117, 122, 117, 121, 117, 121, 117, 120, 117, 118, 95,
68, 31, 6, -24, -47, -73, -91, -115, -120, -117, -121, -117, -120, -118, -119,
-117, -120, -118, -120, -119, -119, -119, -119, -118, -119, -119, -120, -118,
-119, -119, -119, -119, -119, -119, -118, -119, -118, -118, -119, -120, -119,
-119, -118, -119, -118, -118, -118, -118, -119, -118, -118, -118, -119, -119,
-118, -119, -118, -119, -118, -118, -119, -118, -118, -113, -107, -101, -97,
-92, -85, -80, -75, -70, -65, -59, -55, -50, -44, -40, -35, -30, -27, -23, -18,
-14, -9, -5, -2, 2, 7, 10, 13, 16, 18, 22, 26, 29, 32, 34, 37, 40, 41, 44, 47,
50, 52, 54, 55, 57, 59, 60, 63, 64, 66, 67, 69, 70, 72, 72, 74, 75, 75, 76, 77,
78, 79, 79, 80, 80, 81, 82, 82, 82, 82, 84, 83, 83, 83, 83, 83, 84, 83, 83, 82,
83, 83, 82, 82, 82, 81, 81, 81, 81, 80, 80, 79, 79, 77, 78, 77, 76, 75, 75, 74,
74, 73, 72, 72, 71, 71, 70, 68, 68, 68, 66, 65, 64, 63, 63, 62, 61, 61, 60, 58,
58, 58, 57, 56, 54, 53, 54, 52, 51, 51, 49, 48, 48, 46, 47, 46, 44, 44, 43, 42,
42, 40, 39, 39, 37, 38, 37, 35, 35, 34, 32, 33, 32, 30, 31, 29, 29, 29, 27, 26,
28, 23, 26, 22, 23, 22, 24, 17, 25, 17, 19, 20, 16, 13, 31, 12, -113, -118,
-119, -120, -117, -120, -117, -120, -117, -121, -117, -121, -117, -121, -117,
-119, -95, -67, -30, -4, };