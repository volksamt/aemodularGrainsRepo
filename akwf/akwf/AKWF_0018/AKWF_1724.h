#define DATA_LENGTH 512
#define DATA AKWF_1724

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 10, 15, 20, 23, 27, 29, 30, 33, 33,
33, 32, 31, 31, 29, 27, 23, 24, 17, 19, 10, 14, 2, 11, -18, 36, 127, 110, 120,
112, 114, 109, 109, 105, 103, 101, 97, 94, 90, 86, 80, 76, 67, 62, 54, 47, 37,
28, 18, 9, -4, -6, -5, -6, -6, -6, -6, -6, -6, -5, -5, -6, -5, -6, -6, -6, -5,
-6, -6, -6, -6, -6, -6, -5, -6, -5, -5, -6, -6, -5, -6, -5, -6, -5, -6, -6, -6,
-6, -6, -5, -6, -6, -6, -6, -6, -6, -5, -6, -5, -6, -5, -6, -5, -6, -5, -5, -5,
-6, -6, -6, -6, -6, -6, -5, -5, -6, -5, -6, -6, -6, -5, -6, -6, -6, -5, -6, -6,
-6, -5, -5, -5, -5, -6, -6, -6, -5, -5, -6, -6, -6, -6, -5, -5, -5, -5, -6, -6,
-5, -5, -5, -5, -6, -6, -6, -5, -5, -5, -6, -5, -7, -5, -6, -6, -5, -6, -6, -5,
-5, -5, -6, -6, -5, -6, -6, -6, -6, -6, -5, -6, -5, -5, -6, -5, -6, -5, -5, -6,
-5, -6, -5, -5, -5, -6, -5, -5, -5, -6, -6, -6, -5, -5, -5, -6, -5, -6, -6, -5,
-5, -6, -6, -5, -5, -5, -6, -6, -5, -5, -5, -6, -6, -5, -5, -6, -6, -6, -6, -6,
-6, -5, -5, -6, -6, -6, -5, -5, -5, -6, -6, -5, -6, -5, -5, -5, -5, -5, -6, -6,
-5, -5, -5, -5, -6, -5, -5, -6, -5, -6, -6, -6, -5, -6, -6, -5, -5, -6, -6, -6,
-6, -6, -6, -5, -5, -5, -5, -6, -6, -6, -5, -6, -6, -6, -5, -6, -6, -5, -6, -6,
-6, -6, -5, -5, -5, -5, -6, -5, -6, -5, -6, -5, -6, -6, -5, -6, -5, -5, -6, -6,
-6, -6, -5, -5, -5, -6, -6, -6, -6, -6, -5, -6, -6, -6, -5, -5, -5, -6, -5, -6,
-6, -6, -5, -6, -5, -5, -6, -5, -6, -5, -5, -6, -5, -5, -6, -6, -6, -5, -6, -6,
-5, -6, -6, -6, -4, -6, -6, -5, -5, -5, -5, -6, -5, -5, -5, -6, -5, -5, -6, -5,
-5, -6, -6, -5, -5, -6, -5, -6, -6, -5, -5, -6, -6, -6, -5, -6, -6, -5, -5, -5,
-6, -5, -5, -6, -5, -6, -6, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5, -6, -5,
-5, -5, -5, -6, -6, -5, -5, -5, -4, -6, -5, -5, -6, -6, -6, -4, -6, -5, -5, -5,
-5, -5, -5, -5, -5, -5, -6, -6, -6, -5, -6, -5, -6, -5, -5, -5, -5, -5, -5, -5,
-5, -5, -6, -5, -5, -5, -5, -6, -6, -6, -5, -5, -5, -5, -5, -5, -5, -5, -5, -5,
-5, -6, -5, -5, -6, -5, -5, -5, -5, -6, -5, -5, -5, -5, -6, -5, -5, -5, -5, -5,
-5, -5, -5, -5, -5, -5, -5, -6, -4, -6, -5, -5, -5, -5, -5, -6, -5, -6, -6, -5,
-5, -5, -5, -6, 0, };