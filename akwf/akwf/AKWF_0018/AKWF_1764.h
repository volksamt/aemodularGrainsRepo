#define DATA_LENGTH 512
#define DATA AKWF_1764

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 5, 7, 8, 9, 10, 12, 12, 15,
15, 16, 17, 18, 19, 20, 20, 22, 21, 22, 22, 23, 24, 23, 25, 25, 25, 26, 24, 25,
26, 25, 26, 25, 26, 26, 26, 26, 26, 27, 26, 28, 27, 27, 27, 28, 27, 28, 28, 28,
28, 29, 29, 30, 30, 30, 31, 31, 32, 32, 33, 34, 33, 33, 34, 34, 35, 35, 36, 36,
36, 37, 37, 37, 38, 38, 39, 39, 39, 39, 39, 39, 40, 39, 39, 40, 39, 40, 41, 40,
41, 41, 41, 40, 40, 41, 42, 41, 42, 41, 42, 42, 42, 42, 43, 43, 44, 44, 44, 44,
44, 45, 44, 45, 46, 46, 47, 46, 46, 47, 48, 48, 48, 48, 48, 49, 49, 50, 50, 50,
51, 50, 51, 52, 51, 52, 51, 52, 52, 53, 52, 53, 53, 53, 54, 54, 53, 53, 54, 55,
54, 54, 55, 54, 55, 55, 56, 56, 55, 56, 56, 56, 57, 57, 57, 57, 58, 58, 58, 59,
59, 58, 60, 59, 59, 60, 60, 60, 61, 61, 62, 61, 63, 62, 63, 62, 63, 62, 63, 63,
64, 64, 64, 64, 64, 66, 65, 66, 65, 66, 66, 66, 66, 67, 66, 67, 68, 68, 67, 68,
69, 68, 68, 69, 69, 69, 70, 69, 70, 70, 70, 70, 71, 71, 71, 71, 71, 72, 72, 73,
72, 74, 73, 74, 73, 74, 74, 74, 75, 75, 74, 76, 75, 76, 75, 77, 76, 77, 77, 76,
79, 74, 87, 10, -21, -9, -20, -16, -26, -25, -33, -35, -42, -46, -53, -58, -66,
-71, -78, -82, -88, -93, -98, -104, -107, -111, -113, -116, -117, -118, -118,
-120, -117, -117, -115, -113, -110, -106, -103, -99, -96, -91, -86, -81, -76,
-72, -67, -63, -58, -54, -51, -47, -44, -41, -38, -36, -35, -34, -33, -32, -32,
-32, -34, -35, -36, -38, -41, -42, -45, -49, -52, -54, -57, -60, -63, -66, -69,
-71, -74, -76, -78, -80, -81, -82, -83, -83, -83, -83, -83, -81, -81, -80, -78,
-76, -74, -73, -70, -67, -65, -63, -60, -57, -54, -52, -50, -48, -46, -44, -42,
-40, -39, -38, -37, -36, -36, -36, -36, -36, -36, -37, -38, -39, -39, -40, -42,
-43, -44, -46, -47, -48, -50, -51, -52, -54, -55, -55, -57, -58, -59, -58, -59,
-59, -59, -59, -58, -58, -57, -57, -56, -54, -53, -52, -50, -49, -48, -47, -45,
-43, -42, -41, -40, -39, -38, -35, -35, -33, -33, -32, -33, -31, -30, -31, -31,
-31, -31, -31, -31, -32, -32, -32, -33, -34, -34, -34, -35, -35, -36, -37, -37,
-37, -38, -39, -39, -40, -39, -39, -39, -40, -39, -38, -38, -38, -37, -37, -37,
-36, -35, -35, -34, -32, -32, -31, -30, -29, -29, -28, -27, -26, -25, -24, -23,
-22, -23, -22, -21, -21, -21, -20, -20, -20, -20, -19, -19, -19, -19, -19, -19,
-18, -18, -18, -18, -18, -18, -18, -18, -17, -16, -17, -16, -15, -15, -14, -13,
-12, -11, -11, -8, -7, -5, -4, -2, };