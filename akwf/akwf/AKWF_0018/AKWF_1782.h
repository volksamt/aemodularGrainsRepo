#define DATA_LENGTH 512
#define DATA AKWF_1782

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 13, 20, 27, 34, 39, 44, 47, 51, 54,
56, 56, 56, 56, 56, 56, 54, 53, 50, 48, 46, 44, 41, 38, 35, 33, 31, 29, 26, 25,
23, 20, 19, 17, 16, 15, 14, 11, 9, 8, 5, 4, 2, 0, -4, -7, -11, -14, -16, -20,
-23, -26, -29, -32, -36, -38, -41, -43, -44, -46, -46, -47, -46, -45, -45, -43,
-40, -37, -33, -29, -25, -20, -14, -8, -4, 3, 9, 14, 21, 27, 33, 39, 44, 49, 54,
59, 63, 67, 69, 73, 76, 78, 79, 81, 82, 82, 84, 83, 84, 83, 83, 82, 82, 81, 80,
78, 78, 76, 76, 75, 73, 72, 71, 69, 67, 67, 65, 64, 63, 61, 60, 57, 55, 53, 51,
49, 47, 44, 42, 40, 36, 34, 32, 28, 25, 23, 21, 19, 16, 15, 13, 12, 11, 11, 9,
10, 10, 9, 10, 11, 12, 14, 16, 18, 20, 22, 24, 26, 30, 32, 35, 38, 40, 43, 45,
47, 50, 52, 54, 55, 56, 57, 59, 59, 60, 61, 60, 61, 61, 60, 60, 59, 59, 58, 57,
56, 55, 54, 53, 53, 52, 50, 49, 48, 46, 45, 44, 43, 41, 39, 38, 37, 34, 32, 30,
28, 26, 23, 21, 19, 17, 15, 12, 10, 8, 6, 3, 1, -2, -3, -5, -6, -8, -8, -10,
-11, -12, -13, -13, -13, -13, -14, -14, -14, -12, -12, -12, -11, -10, -9, -9,
-9, -6, -6, -6, -4, -4, -3, -2, -2, -1, -1, 0, 1, 3, 3, 2, 3, 3, 3, 4, 5, 3, 3,
4, 3, 4, 4, 3, 2, 1, 1, 1, 0, -1, -2, -3, -3, -4, -5, -6, -7, -9, -10, -10, -12,
-14, -15, -17, -17, -19, -21, -22, -23, -24, -26, -26, -27, -30, -30, -30, -33,
-33, -34, -35, -36, -36, -37, -38, -38, -38, -38, -38, -39, -39, -39, -38, -37,
-37, -36, -36, -35, -35, -33, -32, -30, -30, -28, -28, -27, -25, -24, -23, -22,
-22, -21, -19, -18, -19, -17, -17, -17, -17, -16, -17, -17, -16, -16, -17, -17,
-17, -18, -17, -18, -18, -19, -19, -19, -20, -20, -20, -21, -21, -22, -22, -22,
-23, -24, -23, -23, -23, -23, -24, -24, -24, -25, -25, -23, -25, -24, -23, -24,
-23, -24, -24, -23, -23, -22, -22, -22, -21, -21, -21, -20, -20, -19, -18, -18,
-17, -16, -16, -15, -14, -12, -11, -10, -10, -9, -6, -5, -4, -3, -1, 1, 1, 3, 5,
6, 8, 8, 10, 10, 12, 13, 14, 13, 14, 14, 13, 14, 13, 12, 12, 11, 9, 9, 7, 5, 3,
1, -1, -3, -4, -7, -8, -10, -13, -14, -16, -19, -20, -22, -22, -24, -26, -28,
-28, -29, -29, -31, -30, -32, -32, -32, -32, -33, -34, -34, -35, -37, -38, -40,
-42, -45, -48, -52, -55, -61, -64, -69, -74, -79, -84, -89, -94, -99, -103,
-107, -110, -114, -117, -117, -118, -119, -118, -116, -113, -110, -105, -100,
-94, -88, -81, -72, -64, -55, -46, -38, -28, -20, -10, -1, };