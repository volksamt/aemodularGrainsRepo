#define DATA_LENGTH 512
#define DATA AKWF_1758

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 14, 18, 22, 26, 30, 34, 38,
42, 44, 48, 51, 54, 57, 59, 61, 64, 66, 67, 68, 69, 70, 70, 72, 72, 71, 72, 72,
71, 72, 70, 69, 69, 69, 68, 66, 66, 65, 64, 63, 63, 62, 63, 63, 63, 63, 64, 64,
66, 66, 67, 69, 70, 71, 74, 74, 76, 78, 80, 81, 83, 85, 87, 88, 90, 91, 93, 93,
95, 95, 97, 98, 99, 99, 100, 99, 100, 101, 101, 101, 101, 101, 101, 101, 101,
100, 100, 100, 100, 99, 98, 98, 97, 96, 95, 94, 93, 93, 92, 92, 92, 91, 90, 90,
90, 90, 91, 91, 91, 92, 92, 93, 93, 93, 93, 95, 95, 95, 96, 95, 95, 96, 95, 94,
95, 94, 93, 92, 93, 91, 91, 90, 89, 89, 88, 88, 88, 87, 86, 87, 86, 87, 87, 86,
86, 86, 86, 87, 85, 85, 84, 83, 82, 81, 80, 78, 77, 75, 73, 72, 70, 66, 65, 64,
66, 66, 65, 64, 63, 61, 60, 58, 56, 54, 52, 49, 46, 43, 40, 38, 35, 32, 29, 26,
24, 22, 19, 17, 15, 13, 11, 9, 7, 5, 2, 2, 0, -2, -5, -7, -10, -12, -13, -17,
-18, -21, -23, -26, -28, -30, -33, -35, -37, -40, -43, -44, -48, -50, -53, -56,
-58, -60, -62, -64, -67, -68, -70, -73, -74, -75, -76, -77, -77, -77, -77, -78,
-77, -77, -76, -76, -75, -74, -73, -72, -73, -71, -71, -70, -70, -69, -68, -68,
-66, -65, -64, -62, -61, -59, -57, -56, -54, -53, -50, -49, -48, -46, -46, -43,
-42, -41, -41, -39, -38, -37, -38, -38, -38, -38, -38, -39, -40, -40, -41, -43,
-43, -44, -46, -47, -48, -50, -51, -52, -52, -55, -55, -57, -57, -58, -58, -58,
-59, -60, -59, -60, -59, -60, -60, -61, -62, -61, -63, -64, -65, -66, -67, -70,
-71, -74, -76, -78, -80, -83, -85, -88, -90, -94, -95, -98, -101, -103, -106,
-107, -110, -111, -113, -114, -115, -117, -117, -119, -119, -119, -119, -119,
-119, -118, -118, -118, -117, -116, -114, -114, -113, -111, -110, -108, -107,
-105, -103, -101, -98, -95, -92, -90, -88, -85, -82, -79, -77, -73, -70, -66,
-63, -60, -57, -53, -49, -47, -43, -39, -36, -33, -30, -26, -23, -21, -18, -15,
-14, -11, -10, -10, -13, -21, -29, -35, -39, -43, -46, -49, -51, -55, -56, -56,
-57, -57, -56, -58, -59, -60, -61, -61, -63, -64, -64, -63, -61, -58, -57, -57,
-55, -55, -53, -54, -53, -52, -52, -52, -52, -52, -51, -52, -51, -51, -53, -53,
-53, -53, -53, -54, -54, -54, -55, -55, -55, -55, -55, -54, -54, -55, -55, -55,
-56, -56, -56, -56, -56, -56, -57, -57, -58, -58, -58, -59, -59, -59, -59, -59,
-60, -60, -61, -61, -62, -63, -63, -64, -65, -66, -67, -68, -69, -68, -70, -69,
-70, -70, -70, -69, -68, -66, -64, -62, -60, -57, -54, -51, -47, -42, -39, -35,
-30, -28, -26, -24, -21, -17, -14, -10, -6, -3, };