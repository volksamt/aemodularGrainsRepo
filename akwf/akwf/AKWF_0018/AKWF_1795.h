#define DATA_LENGTH 512
#define DATA AKWF_1795

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 1, 1, 2, 3, 3, 4, 4, 5, 5, 5,
6, 7, 7, 9, 9, 9, 10, 11, 11, 12, 12, 13, 14, 14, 15, 15, 16, 17, 17, 18, 18,
18, 18, 19, 20, 21, 20, 20, 22, 22, 23, 22, 24, 24, 24, 25, 26, 25, 26, 27, 27,
28, 29, 29, 30, 30, 30, 30, 31, 31, 31, 32, 32, 32, 32, 33, 33, 32, 33, 32, 32,
33, 33, 32, 32, 31, 31, 31, 30, 28, 28, 27, 26, 26, 25, 24, 24, 23, 22, 21, 20,
19, 17, 17, 17, 14, 15, 13, 14, 13, 11, 10, 10, 10, 10, 10, 9, 9, 8, 9, 9, 9,
10, 9, 10, 11, 12, 12, 12, 13, 13, 14, 15, 17, 17, 18, 19, 20, 21, 21, 22, 23,
24, 25, 26, 27, 28, 29, 29, 31, 31, 31, 33, 32, 34, 34, 35, 36, 36, 36, 37, 38,
37, 37, 38, 38, 38, 38, 37, 37, 36, 36, 36, 35, 35, 34, 34, 33, 33, 33, 32, 30,
29, 28, 28, 27, 25, 24, 24, 22, 21, 20, 20, 18, 19, 17, 17, 17, 17, 16, 16, 16,
17, 16, 17, 18, 20, 21, 23, 24, 26, 28, 31, 34, 37, 41, 44, 47, 52, 55, 60, 64,
68, 72, 76, 80, 85, 88, 92, 95, 100, 102, 106, 109, 112, 113, 115, 115, 118,
117, 119, 118, 120, 117, 119, 115, 115, 111, 111, 108, 107, 103, 100, 98, 93,
94, 85, 89, 73, 95, -15, -89, -58, -72, -57, -62, -53, -55, -48, -48, -43, -43,
-40, -37, -36, -33, -33, -31, -30, -28, -29, -26, -26, -24, -26, -24, -24, -23,
-23, -22, -23, -21, -22, -21, -22, -21, -22, -21, -21, -21, -21, -21, -20, -21,
-21, -21, -21, -21, -19, -20, -20, -21, -19, -20, -20, -20, -20, -20, -20, -21,
-21, -21, -22, -22, -22, -22, -23, -23, -24, -25, -26, -26, -28, -29, -29, -31,
-32, -33, -35, -36, -37, -40, -41, -42, -43, -45, -47, -48, -51, -52, -54, -55,
-57, -59, -60, -62, -63, -65, -66, -68, -68, -70, -70, -71, -72, -73, -73, -74,
-74, -74, -74, -75, -75, -74, -74, -73, -73, -73, -73, -71, -70, -69, -69, -68,
-66, -66, -65, -63, -62, -61, -60, -59, -57, -56, -55, -54, -53, -52, -51, -50,
-49, -48, -46, -46, -45, -44, -43, -43, -42, -41, -40, -39, -39, -38, -39, -37,
-37, -37, -36, -35, -36, -35, -35, -35, -36, -35, -35, -35, -35, -35, -35, -35,
-35, -35, -35, -35, -35, -35, -36, -35, -35, -35, -36, -35, -36, -35, -35, -35,
-35, -35, -34, -34, -34, -33, -33, -32, -31, -31, -31, -30, -29, -28, -27, -26,
-27, -25, -24, -23, -21, -20, -20, -19, -17, -17, -16, -14, -14, -13, -12, -10,
-10, -9, -8, -8, -6, -6, -5, -5, -5, -4, -4, -4, -4, -3, -2, -3, -2, -3, -3, -2,
-3, -2, -2, -2, -2, -3, -2, -2, -2, -3, -2, -3, -2, -2, -1, -1, 0, 0, -1, };