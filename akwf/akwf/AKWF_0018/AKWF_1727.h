#define DATA_LENGTH 512
#define DATA AKWF_1727

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 9, 11, 14, 16, 19, 21, 22,
24, 27, 29, 30, 32, 35, 38, 38, 41, 43, 44, 46, 48, 51, 51, 53, 55, 57, 58, 59,
61, 63, 63, 65, 66, 68, 69, 71, 72, 74, 75, 76, 77, 78, 80, 81, 82, 83, 84, 85,
86, 87, 88, 89, 90, 91, 91, 92, 94, 94, 95, 96, 97, 98, 98, 100, 100, 101, 101,
103, 103, 104, 104, 105, 106, 107, 107, 108, 108, 109, 110, 110, 111, 111, 111,
112, 112, 114, 113, 114, 115, 115, 115, 115, 115, 116, 116, 117, 116, 117, 118,
118, 117, 117, 118, 119, 119, 118, 118, 118, 119, 118, 119, 120, 119, 118, 119,
119, 118, 119, 118, 118, 118, 118, 118, 118, 119, 118, 117, 118, 117, 116, 117,
117, 116, 115, 116, 115, 115, 115, 114, 114, 114, 113, 112, 113, 112, 112, 111,
110, 110, 108, 108, 107, 107, 106, 105, 105, 105, 104, 103, 102, 102, 102, 101,
100, 98, 98, 98, 97, 96, 94, 94, 92, 93, 92, 90, 90, 88, 87, 86, 85, 85, 82, 82,
81, 80, 79, 77, 76, 76, 74, 74, 72, 70, 70, 68, 66, 64, 64, 62, 61, 60, 58, 56,
55, 54, 52, 50, 49, 46, 45, 43, 42, 39, 37, 35, 35, 31, 29, 27, 26, 24, 22, 20,
18, 15, 13, 11, 9, 6, 4, 0, -1, -4, -6, -9, -12, -14, -17, -20, -22, -24, -27,
-30, -32, -32, -32, -33, -32, -34, -33, -33, -34, -34, -34, -34, -35, -36, -35,
-36, -37, -37, -38, -37, -38, -39, -39, -40, -41, -42, -42, -43, -44, -44, -45,
-45, -46, -47, -48, -49, -50, -50, -52, -53, -54, -56, -56, -56, -58, -58, -60,
-60, -62, -63, -63, -65, -66, -68, -68, -69, -70, -71, -72, -72, -74, -75, -76,
-76, -78, -79, -81, -81, -81, -82, -84, -84, -85, -87, -87, -88, -89, -90, -90,
-92, -92, -93, -94, -95, -96, -97, -97, -98, -99, -99, -100, -100, -101, -101,
-102, -102, -103, -105, -104, -106, -106, -105, -106, -107, -108, -109, -109,
-109, -109, -109, -109, -109, -110, -110, -110, -110, -110, -110, -111, -111,
-112, -112, -112, -112, -112, -113, -112, -112, -112, -112, -112, -112, -112,
-112, -112, -112, -111, -111, -111, -111, -110, -110, -110, -109, -109, -109,
-108, -108, -108, -107, -107, -106, -106, -105, -104, -104, -104, -104, -103,
-102, -101, -101, -99, -100, -98, -97, -97, -97, -95, -95, -95, -94, -92, -92,
-91, -91, -89, -89, -88, -87, -86, -86, -83, -83, -82, -81, -81, -79, -79, -78,
-76, -76, -74, -73, -72, -71, -70, -70, -68, -67, -66, -65, -64, -64, -62, -60,
-60, -59, -57, -57, -56, -55, -53, -52, -52, -50, -50, -48, -47, -47, -46, -44,
-44, -43, -42, -41, -40, -40, -38, -38, -38, -37, -36, -35, -35, -34, -34, -33,
-32, -33, -32, -31, -31, -31, -30, -30, -30, -29, -29, -29, -29, -28, -28, -28,
-27, -28, -27, -25, -21, -18, -16, -13, -11, -8, -6, -3, 0, };