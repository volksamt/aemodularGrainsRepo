#define DATA_LENGTH 512
#define DATA AKWF_1781

const PROGMEM int8_t DATA[DATA_LENGTH] = {34, 89, 104, 120, 111, 96, 95, 96, 96,
95, 95, 95, 96, 96, 96, 95, 95, 95, 96, 95, 95, 86, 67, 54, 53, 54, 54, 54, 55,
55, 56, 55, 56, 57, 57, 58, 58, 58, 59, 59, 59, 59, 60, 60, 61, 62, 62, 62, 62,
63, 63, 64, 65, 64, 65, 65, 66, 65, 68, 63, 56, 56, 57, 58, 58, 59, 60, 60, 61,
62, 63, 63, 64, 64, 65, 66, 66, 67, 67, 68, 69, 69, 70, 70, 70, 72, 72, 73, 73,
74, 75, 75, 76, 76, 76, 77, 77, 78, 78, 79, 80, 80, 81, 82, 82, 83, 83, 83, 83,
84, 85, 85, 85, 86, 86, 86, 86, 87, 87, 88, 89, 88, 90, 90, 89, 90, 91, 93, 80,
70, 73, 72, 73, 72, 73, 73, 73, 73, 74, 74, 74, 74, 74, 74, 74, 74, 74, 74, 74,
74, 74, 74, 74, 75, 75, 76, 75, 75, 75, 75, 76, 75, 75, 76, 75, 75, 76, 76, 75,
76, 76, 76, 76, 76, 76, 76, 76, 76, 76, 76, 76, 75, 76, 76, 77, 76, 78, 72, 64,
65, 65, 66, 65, 65, 66, 67, 66, 66, 67, 67, 67, 68, 68, 68, 67, 68, 68, 68, 69,
69, 69, 69, 69, 70, 70, 69, 69, 70, 70, 71, 70, 70, 71, 71, 71, 70, 71, 70, 71,
71, 70, 71, 71, 71, 70, 71, 71, 71, 70, 71, 71, 72, 70, 71, 70, 72, 70, 71, 71,
70, 71, 70, 72, 69, 74, 36, 23, 30, 25, 25, 26, 32, 20, 13, 5, -1, -9, -14, -18,
-22, -26, -30, -33, -35, -39, -42, -45, -47, -48, -51, -52, -53, -55, -55, -58,
-58, -63, -73, -72, -74, -74, -74, -75, -75, -76, -76, -78, -78, -79, -77, -79,
-79, -79, -79, -80, -81, -81, -80, -81, -82, -82, -81, -81, -82, -81, -87, -95,
-93, -95, -93, -93, -93, -93, -93, -92, -93, -92, -92, -91, -91, -90, -91, -91,
-91, -90, -89, -90, -89, -89, -89, -89, -88, -88, -88, -87, -87, -88, -86, -87,
-85, -86, -85, -85, -84, -85, -84, -85, -84, -84, -83, -72, -71, -70, -70, -70,
-70, -69, -69, -69, -68, -68, -68, -67, -67, -67, -65, -66, -66, -65, -65, -65,
-64, -64, -63, -77, -84, -81, -82, -81, -82, -81, -82, -80, -80, -81, -80, -80,
-80, -81, -80, -80, -79, -79, -78, -79, -78, -78, -89, -89, -88, -88, -88, -87,
-86, -87, -86, -86, -85, -85, -85, -85, -85, -85, -83, -83, -83, -83, -83, -82,
-82, -81, -81, -80, -80, -80, -79, -79, -79, -77, -78, -76, -77, -76, -82, -88,
-86, -86, -84, -84, -84, -82, -82, -81, -80, -80, -79, -78, -79, -77, -77, -75,
-76, -75, -74, -73, -73, -72, -71, -70, -71, -69, -68, -67, -67, -67, -66, -65,
-64, -63, -63, -63, -61, -62, -60, -59, -59, -58, -58, -57, -57, -56, -56, -55,
-55, -54, -53, -52, -51, -52, -50, -50, -49, -48, -47, -48, -46, -47, -45, -46,
-44, -44, -29, };