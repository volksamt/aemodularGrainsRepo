#define DATA_LENGTH 512
#define DATA AKWF_1719

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 18, 24, 31, 37, 42, 48, 53, 57,
61, 66, 70, 74, 77, 80, 82, 85, 88, 91, 93, 95, 98, 99, 101, 103, 105, 106, 107,
108, 109, 111, 111, 113, 113, 114, 114, 116, 116, 117, 117, 118, 118, 118, 119,
119, 119, 119, 119, 119, 120, 120, 119, 119, 118, 118, 118, 118, 117, 118, 117,
117, 117, 115, 115, 115, 114, 114, 113, 112, 112, 111, 111, 110, 109, 108, 108,
107, 106, 106, 105, 104, 103, 102, 101, 100, 100, 98, 97, 95, 95, 93, 92, 90,
89, 87, 84, 83, 81, 78, 77, 74, 72, 68, 65, 63, 60, 57, 53, 51, 47, 44, 42, 39,
35, 33, 30, 27, 25, 22, 20, 17, 15, 13, 11, 8, 6, 4, 1, -2, -4, -6, -9, -12,
-15, -19, -22, -25, -28, -31, -34, -38, -40, -44, -47, -50, -53, -55, -57, -60,
-62, -64, -65, -66, -66, -67, -67, -67, -67, -66, -67, -65, -64, -61, -61, -60,
-57, -55, -54, -52, -50, -47, -46, -43, -42, -40, -38, -37, -35, -32, -32, -29,
-28, -26, -25, -24, -24, -22, -22, -20, -19, -19, -18, -18, -18, -18, -18, -20,
-19, -20, -20, -21, -22, -23, -23, -24, -26, -27, -27, -30, -30, -31, -33, -33,
-35, -36, -36, -39, -40, -41, -43, -44, -46, -48, -49, -52, -54, -55, -59, -61,
-64, -67, -71, -74, -73, -71, -70, -68, -66, -63, -62, -59, -57, -54, -52, -51,
-49, -47, -45, -44, -42, -40, -38, -37, -35, -33, -33, -31, -30, -29, -27, -26,
-26, -25, -23, -22, -21, -21, -20, -20, -19, -19, -18, -17, -17, -16, -17, -16,
-16, -16, -16, -15, -15, -15, -15, -15, -14, -15, -15, -16, -15, -15, -14, -16,
-16, -16, -15, -15, -15, -15, -16, -15, -15, -16, -17, -16, -16, -16, -17, -16,
-16, -15, -15, -15, -16, -16, -14, -15, -15, -14, -14, -15, -15, -15, -14, -14,
-16, -16, -16, -17, -16, -16, -18, -18, -18, -19, -19, -19, -20, -21, -21, -21,
-22, -22, -23, -21, -22, -23, -22, -23, -23, -23, -24, -24, -24, -23, -24, -24,
-24, -25, -25, -26, -26, -27, -26, -26, -27, -28, -28, -29, -29, -29, -30, -30,
-30, -31, -31, -30, -31, -32, -32, -32, -32, -32, -31, -32, -31, -30, -31, -30,
-30, -29, -28, -27, -27, -27, -25, -25, -24, -24, -23, -22, -21, -21, -20, -20,
-18, -19, -17, -17, -17, -17, -17, -16, -15, -15, -15, -15, -14, -15, -14, -14,
-14, -14, -14, -14, -14, -14, -14, -14, -14, -15, -15, -15, -15, -16, -16, -16,
-16, -16, -16, -17, -16, -18, -18, -17, -17, -18, -17, -18, -18, -18, -18, -18,
-18, -17, -17, -17, -17, -17, -16, -17, -16, -16, -16, -15, -15, -15, -15, -15,
-14, -15, -14, -13, -15, -14, -14, -15, -15, -16, -16, -17, -18, -18, -19, -20,
-21, -23, -25, -26, -28, -30, -33, -34, -39, -41, -44, -48, -51, -55, -60, -65,
-70, -72, -63, -55, -45, -38, -28, -19, -12, -4, };