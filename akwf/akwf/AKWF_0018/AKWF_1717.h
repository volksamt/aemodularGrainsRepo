#define DATA_LENGTH 512
#define DATA AKWF_1717

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 11, 15, 18, 21, 23, 26, 29,
32, 35, 38, 40, 43, 44, 46, 49, 50, 53, 55, 56, 58, 60, 62, 64, 66, 67, 69, 70,
72, 73, 74, 76, 77, 78, 79, 80, 82, 82, 83, 84, 85, 85, 86, 86, 87, 89, 90, 90,
90, 91, 93, 93, 94, 94, 95, 96, 97, 98, 98, 100, 102, 102, 104, 105, 106, 107,
108, 108, 109, 110, 111, 113, 114, 115, 116, 116, 116, 116, 117, 119, 118, 118,
119, 118, 119, 119, 119, 119, 118, 118, 118, 118, 116, 117, 116, 116, 115, 115,
115, 115, 113, 113, 113, 112, 111, 111, 109, 109, 108, 107, 106, 106, 104, 103,
101, 101, 99, 98, 96, 94, 92, 91, 89, 87, 85, 84, 82, 81, 79, 78, 76, 74, 74,
72, 70, 69, 68, 66, 66, 65, 63, 61, 60, 60, 58, 56, 54, 53, 52, 49, 47, 46, 45,
42, 40, 39, 36, 34, 32, 30, 27, 25, 22, 19, 16, 13, 10, 7, 5, 2, -1, -4, -6, -9,
-12, -14, -17, -20, -21, -23, -26, -27, -30, -31, -33, -35, -35, -38, -39, -40,
-41, -42, -44, -43, -45, -46, -47, -48, -49, -49, -49, -50, -51, -52, -51, -52,
-52, -53, -53, -53, -53, -53, -51, -51, -52, -51, -51, -49, -48, -48, -47, -46,
-44, -43, -42, -41, -39, -38, -36, -35, -35, -33, -31, -30, -28, -27, -27, -25,
-23, -22, -21, -20, -19, -17, -16, -15, -13, -13, -11, -10, -8, -7, -5, -3, -2,
1, 2, 4, 5, 7, 10, 11, 13, 14, 17, 19, 21, 22, 25, 26, 29, 30, 31, 33, 34, 36,
37, 38, 39, 40, 41, 43, 44, 44, 46, 46, 47, 48, 50, 51, 51, 52, 53, 53, 54, 54,
56, 57, 56, 57, 57, 56, 57, 57, 57, 56, 56, 55, 54, 53, 52, 50, 49, 48, 47, 45,
43, 41, 39, 37, 34, 33, 31, 29, 26, 24, 22, 19, 17, 15, 13, 10, 9, 6, 5, 1, 0,
-2, -3, -6, -7, -9, -11, -12, -13, -16, -17, -18, -21, -21, -23, -24, -26, -27,
-29, -31, -33, -35, -38, -39, -41, -44, -45, -48, -50, -52, -54, -56, -57, -59,
-61, -63, -65, -67, -69, -71, -73, -74, -76, -77, -78, -80, -81, -83, -84, -85,
-87, -89, -91, -92, -93, -95, -97, -97, -99, -100, -101, -104, -104, -106, -107,
-108, -110, -110, -111, -112, -112, -114, -114, -115, -115, -116, -115, -116,
-116, -116, -116, -115, -115, -114, -115, -114, -115, -113, -113, -113, -113,
-112, -112, -111, -111, -111, -110, -110, -109, -109, -109, -108, -109, -108,
-108, -108, -108, -107, -107, -107, -106, -107, -106, -106, -105, -105, -105,
-104, -103, -104, -102, -102, -103, -102, -101, -101, -100, -100, -99, -99, -98,
-97, -97, -95, -95, -94, -93, -91, -91, -90, -88, -87, -86, -85, -83, -81, -80,
-78, -76, -73, -71, -68, -66, -63, -60, -58, -55, -52, -50, -46, -45, -41, -38,
-35, -32, -29, -25, -21, -18, -13, -11, -6, -3, -1, };