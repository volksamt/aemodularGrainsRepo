#define DATA_LENGTH 512
#define DATA AKWF_1728

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 12, 14, 18, 20, 23, 26, 29,
31, 34, 36, 39, 41, 44, 46, 48, 50, 51, 53, 55, 57, 59, 61, 63, 64, 66, 68, 68,
71, 72, 73, 74, 76, 78, 79, 80, 81, 82, 84, 85, 86, 87, 88, 88, 90, 90, 91, 92,
93, 95, 96, 96, 97, 98, 98, 100, 100, 101, 102, 102, 103, 104, 104, 105, 106,
107, 107, 108, 107, 109, 109, 110, 110, 111, 112, 112, 112, 113, 112, 113, 114,
114, 114, 115, 115, 116, 116, 116, 117, 117, 117, 118, 117, 118, 118, 118, 118,
118, 118, 119, 119, 118, 119, 119, 119, 119, 118, 120, 120, 119, 119, 119, 118,
119, 118, 118, 119, 118, 118, 118, 118, 118, 117, 117, 118, 117, 117, 116, 116,
115, 116, 115, 115, 115, 115, 114, 114, 114, 113, 112, 112, 112, 111, 111, 111,
110, 109, 109, 108, 107, 107, 106, 106, 105, 104, 104, 103, 102, 102, 101, 100,
99, 98, 98, 97, 96, 95, 95, 93, 92, 92, 91, 90, 89, 88, 87, 86, 85, 84, 83, 82,
81, 79, 78, 77, 76, 74, 73, 72, 70, 69, 67, 66, 64, 62, 61, 60, 57, 56, 55, 52,
51, 48, 46, 44, 42, 39, 37, 35, 34, 31, 27, 25, 23, 20, 17, 15, 12, 9, 5, 3, 0,
-3, -7, -10, -13, -18, -20, -24, -27, -31, -34, -38, -41, -45, -49, -52, -57,
-59, -57, -56, -55, -55, -54, -53, -51, -51, -50, -49, -48, -48, -47, -47, -46,
-45, -45, -45, -44, -45, -44, -44, -44, -45, -44, -44, -44, -45, -44, -45, -46,
-45, -45, -46, -47, -48, -48, -48, -48, -49, -50, -50, -52, -52, -53, -54, -55,
-56, -57, -58, -58, -59, -60, -61, -62, -64, -64, -65, -66, -66, -67, -69, -70,
-70, -72, -72, -74, -74, -75, -76, -77, -79, -79, -80, -80, -82, -83, -83, -84,
-85, -86, -87, -87, -88, -89, -90, -90, -91, -92, -93, -93, -94, -95, -95, -97,
-97, -97, -97, -98, -99, -99, -100, -100, -101, -101, -102, -102, -102, -103,
-103, -104, -103, -104, -104, -104, -105, -105, -104, -104, -105, -106, -104,
-105, -105, -106, -106, -106, -105, -106, -106, -105, -105, -106, -105, -105,
-104, -104, -104, -104, -104, -104, -103, -103, -102, -102, -102, -101, -100,
-100, -100, -100, -99, -99, -98, -97, -97, -97, -95, -95, -94, -94, -93, -92,
-92, -91, -90, -90, -89, -88, -87, -87, -86, -85, -83, -83, -82, -82, -81, -80,
-79, -78, -77, -75, -76, -74, -73, -71, -71, -71, -69, -68, -68, -66, -66, -64,
-63, -63, -61, -60, -59, -58, -57, -56, -56, -55, -54, -53, -51, -52, -50, -50,
-48, -47, -46, -46, -45, -45, -45, -43, -43, -43, -42, -41, -42, -41, -41, -40,
-40, -40, -40, -41, -40, -40, -40, -41, -40, -41, -42, -41, -42, -43, -44, -45,
-45, -45, -46, -46, -48, -48, -49, -50, -51, -52, -52, -54, -53, -49, -45, -42,
-38, -34, -30, -27, -23, -20, -17, -14, -9, -6, -3, -1, };