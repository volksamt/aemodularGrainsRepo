#define DATA_LENGTH 512
#define DATA AKWF_1726

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 7, 9, 11, 12, 15, 17, 18, 19,
22, 24, 26, 26, 29, 31, 32, 34, 36, 38, 40, 41, 43, 44, 45, 47, 48, 50, 51, 53,
54, 56, 57, 59, 60, 61, 63, 65, 65, 66, 68, 69, 70, 72, 73, 74, 74, 76, 77, 79,
80, 80, 82, 82, 85, 85, 87, 87, 88, 89, 90, 91, 92, 93, 94, 95, 95, 97, 97, 98,
99, 99, 100, 101, 102, 103, 103, 103, 105, 105, 107, 106, 107, 107, 109, 109,
110, 110, 110, 111, 112, 112, 112, 113, 114, 113, 114, 115, 115, 115, 116, 116,
116, 117, 117, 118, 117, 118, 119, 118, 119, 118, 118, 119, 118, 119, 119, 119,
119, 119, 119, 119, 120, 119, 119, 119, 118, 118, 119, 118, 119, 118, 118, 118,
117, 117, 117, 117, 116, 116, 115, 115, 114, 114, 114, 113, 113, 112, 112, 112,
111, 111, 110, 110, 109, 108, 107, 107, 106, 105, 106, 105, 104, 103, 102, 102,
101, 100, 100, 99, 98, 97, 96, 95, 94, 94, 93, 92, 90, 90, 88, 88, 88, 86, 85,
84, 83, 81, 81, 80, 79, 78, 77, 75, 74, 73, 71, 71, 70, 67, 67, 66, 65, 62, 61,
60, 58, 57, 55, 54, 53, 52, 50, 49, 47, 46, 43, 42, 41, 39, 38, 36, 35, 34, 31,
30, 28, 25, 25, 23, 21, 19, 17, 16, 14, 12, 10, 8, 6, 5, 2, 0, -2, -3, -6, -8,
-9, -11, -14, -16, -16, -17, -19, -19, -21, -21, -22, -22, -23, -24, -25, -27,
-27, -28, -29, -30, -32, -32, -34, -34, -35, -36, -38, -39, -40, -41, -42, -43,
-44, -45, -46, -48, -48, -49, -50, -52, -53, -54, -55, -56, -57, -58, -59, -60,
-62, -63, -65, -66, -66, -68, -69, -70, -71, -71, -73, -74, -75, -76, -76, -78,
-79, -80, -81, -82, -84, -85, -85, -87, -88, -88, -90, -89, -90, -92, -93, -93,
-95, -95, -96, -98, -98, -98, -99, -100, -101, -101, -102, -103, -104, -104,
-104, -106, -107, -107, -107, -107, -108, -108, -109, -109, -110, -110, -111,
-112, -113, -112, -113, -113, -113, -114, -114, -114, -114, -115, -115, -116,
-115, -115, -115, -116, -116, -116, -116, -116, -115, -115, -116, -116, -116,
-116, -116, -116, -115, -116, -115, -115, -115, -115, -115, -114, -114, -113,
-113, -113, -112, -112, -111, -112, -111, -111, -111, -110, -110, -109, -108,
-108, -108, -107, -106, -106, -105, -105, -104, -104, -103, -102, -101, -101,
-99, -99, -98, -98, -96, -95, -95, -94, -94, -92, -91, -90, -90, -89, -87, -87,
-86, -86, -84, -82, -82, -81, -80, -79, -77, -76, -75, -74, -74, -72, -71, -70,
-69, -67, -68, -66, -64, -64, -63, -62, -60, -59, -57, -56, -55, -54, -53, -52,
-50, -50, -49, -48, -46, -45, -44, -43, -42, -41, -39, -39, -37, -36, -35, -34,
-33, -31, -30, -30, -29, -28, -27, -26, -25, -24, -23, -22, -21, -19, -19, -18,
-16, -17, -15, -14, -13, -12, -11, -11, -9, -5, -5, -2, -1, };