#define DATA_LENGTH 512
#define DATA AKWF_1751

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 13, 25, 34, 44, 52, 60, 66, 71, 77,
81, 85, 88, 91, 94, 96, 99, 101, 101, 102, 104, 104, 104, 104, 104, 104, 104,
104, 104, 102, 102, 101, 101, 99, 98, 97, 97, 95, 93, 93, 91, 89, 88, 85, 84,
83, 82, 80, 78, 76, 76, 74, 72, 71, 69, 68, 67, 66, 66, 64, 62, 62, 61, 59, 59,
59, 57, 56, 56, 55, 55, 55, 54, 54, 53, 53, 53, 53, 52, 53, 53, 53, 52, 53, 54,
53, 53, 53, 53, 54, 54, 54, 54, 54, 54, 54, 54, 55, 54, 55, 55, 54, 55, 54, 56,
55, 55, 55, 56, 55, 56, 56, 56, 56, 55, 55, 55, 56, 55, 55, 55, 55, 55, 54, 55,
54, 53, 53, 54, 54, 53, 53, 52, 52, 52, 53, 51, 52, 52, 52, 51, 51, 50, 51, 51,
50, 50, 50, 50, 49, 49, 49, 49, 48, 48, 48, 48, 48, 48, 48, 48, 47, 47, 47, 47,
47, 46, 46, 46, 45, 46, 46, 46, 45, 45, 45, 44, 45, 44, 44, 44, 43, 44, 43, 43,
43, 44, 43, 43, 43, 43, 42, 42, 41, 42, 43, 41, 41, 41, 41, 41, 41, 41, 41, 41,
40, 40, 40, 40, 40, 40, 39, 40, 39, 39, 38, 38, 38, 39, 39, 38, 37, 38, 37, 37,
37, 37, 37, 37, 36, 37, 35, 32, 28, 22, 16, 7, -4, -14, -26, -39, -53, -66, -78,
-92, -102, -115, -119, -113, -111, -105, -99, -93, -86, -80, -74, -68, -62, -57,
-53, -48, -46, -43, -42, -39, -39, -37, -37, -37, -36, -36, -36, -37, -37, -37,
-37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -36, -37, -37, -37,
-37, -37, -37, -36, -36, -36, -37, -37, -36, -37, -37, -37, -38, -38, -38, -39,
-39, -39, -39, -40, -39, -41, -40, -42, -42, -42, -42, -42, -43, -43, -44, -44,
-43, -44, -44, -44, -44, -44, -44, -44, -45, -44, -44, -45, -45, -45, -45, -44,
-44, -45, -45, -44, -44, -45, -44, -44, -45, -45, -44, -44, -44, -44, -44, -44,
-43, -44, -43, -44, -43, -44, -43, -43, -44, -43, -43, -44, -43, -43, -43, -43,
-43, -43, -44, -43, -44, -44, -44, -44, -43, -43, -43, -43, -44, -44, -44, -44,
-43, -44, -44, -44, -45, -44, -45, -44, -44, -44, -44, -45, -44, -45, -44, -45,
-44, -45, -44, -45, -44, -45, -45, -45, -46, -45, -45, -45, -46, -45, -45, -46,
-46, -45, -46, -46, -46, -45, -46, -46, -45, -46, -46, -46, -46, -46, -46, -47,
-46, -47, -46, -46, -46, -47, -46, -47, -47, -47, -47, -47, -47, -47, -47, -47,
-47, -46, -47, -48, -48, -48, -47, -48, -47, -48, -47, -47, -47, -47, -47, -48,
-48, -48, -48, -48, -48, -49, -48, -49, -48, -48, -48, -47, -49, -48, -48, -49,
-49, -48, -50, -49, -50, -50, -52, -55, -58, -61, -68, -73, -78, -85, -90, -97,
-102, -108, -112, -116, -111, -100, -87, -74, -62, -48, -35, -21, -7, };