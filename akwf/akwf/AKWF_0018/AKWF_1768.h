#define DATA_LENGTH 512
#define DATA AKWF_1768

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 5, 7, 8, 9, 10, 12, 14, 15,
18, 19, 20, 23, 23, 25, 27, 28, 30, 31, 32, 34, 36, 37, 39, 40, 43, 42, 45, 47,
48, 49, 51, 51, 55, 56, 57, 59, 60, 62, 63, 65, 66, 68, 69, 70, 72, 74, 75, 77,
78, 81, 81, 83, 84, 87, 88, 90, 89, 93, 93, 96, 96, 99, 99, 102, 103, 105, 106,
107, 111, 108, 114, 109, 120, 108, 127, 59, -22, -32, -58, -44, -53, -46, -51,
-47, -50, -48, -49, -48, -48, -48, -48, -49, -46, -47, -46, -47, -45, -47, -46,
-47, -45, -46, -45, -45, -45, -45, -45, -45, -44, -44, -43, -44, -43, -44, -43,
-43, -43, -43, -43, -41, -43, -41, -42, -41, -42, -41, -42, -41, -40, -41, -40,
-40, -40, -40, -40, -40, -40, -39, -38, -38, -38, -39, -38, -38, -37, -37, -37,
-38, -37, -37, -37, -37, -36, -36, -37, -35, -35, -35, -35, -35, -36, -34, -34,
-33, -32, -32, -31, -29, -28, -28, -27, -25, -25, -24, -23, -22, -20, -20, -19,
-18, -17, -15, -15, -13, -13, -12, -11, -11, -11, -10, -10, -11, -10, -10, -10,
-10, -10, -9, -10, -10, -10, -11, -10, -10, -10, -10, -10, -10, -10, -10, -10,
-10, -10, -10, -11, -10, -11, -10, -10, -11, -10, -10, -10, -10, -9, -10, -10,
-10, -10, -10, -10, -11, -10, -11, -10, -11, -10, -10, -10, -10, -10, -9, -12,
-7, -17, 37, 60, 49, 55, 49, 53, 49, 50, 48, 48, 46, 47, 45, 45, 43, 43, 42, 41,
41, 41, 40, 38, 39, 37, 37, 35, 35, 34, 34, 32, 32, 30, 30, 29, 29, 29, 28, 27,
26, 25, 24, 23, 22, 22, 21, 20, 19, 19, 18, 17, 17, 16, 15, 15, 13, 13, 12, 11,
10, 9, 9, 7, 7, 7, 5, 5, 5, 4, 2, 2, 1, 0, -1, -1, -2, -3, -3, -4, -6, -6, -6,
-8, -8, -9, -11, -10, -10, -10, -11, -10, -10, -10, -10, -10, -10, -11, -10,
-10, -10, -10, -11, -11, -10, -10, -10, -10, -10, -10, -10, -11, -10, -10, -10,
-10, -10, -10, -10, -11, -11, -10, -11, -10, -11, -11, -10, -11, -10, -11, -10,
-10, -10, -10, -10, -11, -10, -10, -11, -10, -11, -11, -10, -10, -11, -10, -10,
-10, -10, -11, -10, -11, -11, -11, -10, -10, -11, -10, -11, -10, -10, -11, -10,
-10, -10, -10, -10, -10, -10, -10, -10, -10, -11, -10, -11, -11, -11, -11, -10,
-10, -10, -10, -9, -10, -10, -10, -11, -11, -10, -9, -10, -10, -10, -10, -10,
-11, -10, -9, -10, -10, -11, -10, -10, -9, -10, -10, -10, -10, -10, -11, -11,
-10, -10, -10, -10, -10, -10, -10, -11, -10, -10, -10, -10, -11, -10, -10, -10,
-10, -9, -11, -10, -10, -11, -10, -10, -10, -11, -11, -10, -9, -10, -10, -9,
-10, -11, -10, -10, -10, -10, -10, -10, -10, -10, -10, -10, -10, -10, -11, -10,
-11, -8, -7, -5, -4, -3, -2, };