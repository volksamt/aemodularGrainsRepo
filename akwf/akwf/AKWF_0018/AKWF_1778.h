#define DATA_LENGTH 512
#define DATA AKWF_1778

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 12, 15, 19, 21, 24, 27, 30,
33, 35, 38, 40, 43, 45, 48, 50, 53, 55, 57, 59, 61, 63, 64, 66, 68, 70, 71, 73,
75, 76, 77, 79, 80, 82, 83, 83, 85, 87, 88, 89, 91, 91, 92, 93, 94, 95, 97, 97,
98, 98, 99, 100, 101, 102, 103, 103, 104, 105, 105, 106, 106, 107, 108, 108,
108, 109, 110, 111, 110, 112, 111, 113, 112, 112, 113, 114, 114, 115, 115, 116,
116, 116, 116, 116, 116, 117, 116, 117, 117, 117, 117, 118, 118, 118, 118, 119,
118, 119, 118, 119, 119, 119, 119, 119, 120, 119, 119, 119, 118, 119, 119, 119,
118, 119, 118, 119, 118, 119, 119, 118, 118, 119, 118, 118, 117, 117, 117, 118,
116, 117, 116, 116, 115, 115, 114, 115, 114, 114, 114, 114, 114, 113, 111, 112,
111, 112, 111, 110, 109, 110, 108, 108, 108, 107, 107, 106, 104, 104, 105, 103,
103, 102, 101, 100, 100, 99, 98, 98, 97, 97, 95, 95, 93, 93, 92, 91, 90, 89, 88,
87, 86, 84, 83, 82, 80, 79, 79, 77, 76, 74, 72, 70, 70, 67, 67, 64, 62, 61, 59,
57, 54, 51, 49, 48, 45, 42, 40, 36, 34, 32, 28, 26, 22, 19, 15, 12, 9, 5, 2, -2,
-6, -10, -13, -18, -22, -26, -30, -34, -38, -43, -48, -51, -56, -61, -65, -69,
-74, -75, -73, -71, -70, -68, -67, -65, -63, -63, -62, -61, -60, -59, -57, -56,
-55, -54, -54, -53, -52, -52, -51, -50, -49, -51, -49, -49, -49, -48, -48, -48,
-49, -50, -50, -50, -50, -50, -50, -51, -52, -52, -52, -53, -53, -55, -54, -56,
-56, -57, -58, -57, -58, -59, -60, -61, -62, -63, -64, -64, -65, -67, -67, -67,
-68, -70, -70, -71, -72, -72, -73, -74, -75, -75, -77, -77, -79, -79, -79, -80,
-81, -82, -82, -84, -84, -84, -85, -85, -86, -87, -87, -88, -89, -89, -89, -90,
-90, -91, -91, -92, -92, -92, -92, -93, -94, -93, -94, -94, -95, -95, -96, -96,
-96, -96, -97, -96, -97, -96, -97, -97, -97, -97, -97, -97, -98, -98, -97, -97,
-98, -98, -98, -97, -98, -97, -97, -98, -96, -97, -97, -96, -97, -97, -96, -96,
-95, -95, -95, -95, -95, -94, -94, -93, -94, -92, -92, -91, -91, -90, -91, -90,
-90, -89, -89, -88, -88, -88, -87, -86, -85, -85, -85, -83, -83, -82, -82, -80,
-80, -79, -79, -78, -77, -76, -77, -75, -75, -74, -73, -72, -72, -70, -69, -69,
-68, -67, -66, -66, -65, -64, -63, -62, -62, -61, -60, -58, -58, -58, -57, -56,
-55, -55, -53, -53, -52, -51, -51, -51, -50, -48, -48, -48, -47, -47, -47, -46,
-45, -47, -45, -45, -45, -45, -46, -46, -45, -46, -47, -48, -48, -49, -49, -49,
-51, -51, -52, -54, -54, -56, -57, -58, -59, -61, -62, -63, -65, -66, -68, -69,
-71, -67, -63, -59, -54, -50, -46, -41, -38, -32, -28, -24, -20, -17, -13, -8,
-5, -1, };