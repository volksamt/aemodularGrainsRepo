#define DATA_LENGTH 512
#define DATA AKWF_1765

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 1, 3, 3, 3, 4, 5, 6, 6, 7, 8, 8,
10, 10, 11, 12, 13, 13, 15, 15, 16, 17, 17, 19, 20, 21, 21, 23, 24, 24, 25, 27,
27, 28, 29, 30, 31, 32, 33, 33, 34, 36, 36, 37, 38, 38, 39, 40, 40, 40, 42, 42,
43, 43, 43, 44, 44, 45, 46, 45, 46, 46, 47, 46, 46, 47, 47, 47, 46, 47, 47, 46,
46, 47, 46, 46, 46, 46, 46, 46, 45, 45, 45, 45, 45, 45, 44, 44, 44, 43, 44, 43,
43, 43, 42, 43, 42, 43, 42, 43, 43, 43, 42, 42, 42, 42, 43, 42, 43, 43, 43, 43,
43, 44, 44, 44, 45, 44, 45, 45, 45, 46, 47, 46, 47, 48, 48, 48, 49, 49, 51, 51,
52, 51, 52, 52, 53, 53, 55, 56, 55, 56, 56, 57, 59, 58, 59, 60, 60, 60, 62, 62,
61, 63, 63, 63, 64, 64, 65, 65, 65, 67, 66, 67, 67, 67, 67, 68, 68, 68, 69, 69,
68, 69, 69, 69, 69, 70, 70, 70, 70, 70, 70, 70, 70, 71, 71, 70, 70, 70, 70, 71,
71, 71, 70, 71, 71, 71, 70, 70, 71, 70, 71, 71, 71, 70, 71, 70, 71, 71, 71, 71,
72, 72, 71, 72, 72, 73, 73, 73, 72, 73, 73, 74, 74, 74, 74, 75, 75, 76, 75, 76,
76, 76, 77, 77, 79, 76, 80, 78, 82, 77, 84, 74, 92, 41, -27, -9, -18, -14, -17,
-16, -18, -19, -21, -22, -24, -26, -28, -31, -32, -36, -37, -40, -42, -46, -48,
-52, -55, -58, -61, -65, -67, -71, -74, -77, -80, -83, -86, -89, -92, -94, -97,
-99, -101, -104, -106, -108, -109, -112, -113, -114, -115, -117, -118, -118,
-118, -119, -120, -119, -119, -118, -119, -117, -116, -116, -114, -113, -112,
-111, -109, -107, -105, -103, -101, -99, -97, -95, -92, -89, -87, -85, -83, -78,
-76, -74, -71, -68, -65, -64, -61, -58, -56, -53, -51, -48, -46, -43, -41, -39,
-37, -36, -34, -32, -31, -30, -28, -27, -27, -25, -23, -23, -22, -22, -22, -22,
-22, -22, -22, -22, -22, -23, -23, -24, -25, -26, -26, -28, -29, -29, -30, -32,
-33, -35, -36, -37, -39, -40, -42, -44, -44, -46, -47, -49, -51, -51, -54, -55,
-56, -57, -58, -60, -60, -62, -63, -64, -65, -65, -66, -67, -67, -67, -68, -68,
-68, -68, -69, -69, -68, -68, -68, -68, -67, -67, -65, -65, -64, -63, -63, -61,
-60, -59, -58, -57, -55, -54, -53, -51, -50, -48, -46, -46, -45, -43, -42, -40,
-38, -37, -35, -34, -33, -31, -30, -28, -27, -25, -24, -23, -22, -21, -20, -19,
-17, -17, -16, -15, -14, -13, -12, -13, -12, -12, -11, -10, -10, -10, -10, -9,
-9, -10, -9, -10, -10, -10, -10, -10, -11, -10, -11, -10, -11, -12, -12, -13,
-13, -13, -13, -12, -13, -14, -13, -13, -13, -13, -14, -12, -12, -12, -11, -10,
-10, -8, -7, -5, -5, -4, -3, -3, -2, -1, -1, };