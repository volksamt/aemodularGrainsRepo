#define DATA_LENGTH 512
#define DATA AKWF_1742

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 15, 26, 36, 46, 56, 64, 73, 81, 88,
95, 101, 106, 109, 114, 117, 117, 119, 119, 119, 117, 116, 114, 111, 107, 103,
99, 93, 89, 83, 77, 72, 65, 60, 54, 47, 41, 35, 29, 23, 17, 11, 5, 2, -3, -8,
-12, -16, -20, -23, -26, -29, -32, -34, -36, -36, -38, -39, -40, -40, -40, -39,
-38, -39, -37, -36, -35, -34, -32, -31, -29, -28, -26, -24, -22, -20, -18, -17,
-15, -13, -12, -9, -8, -6, -5, -3, -2, -1, 0, 1, 3, 3, 5, 5, 6, 6, 7, 7, 7, 8,
8, 8, 8, 8, 8, 7, 7, 6, 6, 7, 6, 6, 5, 5, 6, 5, 4, 4, 4, 3, 2, 1, 1, 1, 1, 0, 0,
0, -1, 0, -1, -1, -1, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3,
-3, -3, -3, -2, -3, -2, -2, -3, -2, -2, -2, -2, -2, -1, -2, -2, -1, -1, -2, -1,
-2, -1, -1, -1, -1, 0, -1, 0, -1, 0, 0, 0, -1, -1, 0, -1, 0, 0, -1, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, -1, 0, 0, 0, -1, -1, -1, -1, -1, 0, -1,
-1, -1, -1, 0, -1, -1, 0, -1, 0, -1, -1, -1, 0, -1, 0, -1, -1, -1, 0, -1, -1,
-1, -1, -1, -1, -1, -1, -1, -1, -1, -1, 0, -1, -1, 0, 0, -1, 0, 0, -1, -1, 0,
-1, 0, -1, -1, -1, -1, 0, 0, -1, 0, -1, 0, 0, 0, -1, 0, -1, 0, -1, 0, 0, -1, -1,
0, -1, 0, 0, -1, -1, -1, -1, 0, 0, -1, -1, 0, 0, -1, 0, 0, 0, -1, -1, -1, 0, 0,
0, -1, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0,
-1, 0, -1, -1, 0, 0, -1, 0, -1, -1, -1, 0, 0, -1, -1, 0, 0, -1, 0, -1, 0, 0, 0,
0, 0, 0, 1, 0, -1, 0, 0, -1, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, -1, 0, 0, -1, 0, -1, 0, -1, 0, 0, 0,
-1, 0, 0, 0, 0, 0, -1, 0, -1, 1, -1, 0, -1, -1, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0,
0, 0, 0, 0, -1, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 1, -1, -1, 0, 0, 0, 0, 0,
0, -1, -1, -1, 0, 0, 0, -2, -6, -13, -19, -28, -37, -47, -56, -66, -75, -83,
-91, -97, -102, -106, -109, -110, -109, -108, -106, -102, -98, -92, -85, -77,
-68, -59, -49, -39, -28, -18, -6, };