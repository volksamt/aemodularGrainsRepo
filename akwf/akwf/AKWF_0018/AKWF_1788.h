#define DATA_LENGTH 512
#define DATA AKWF_1788

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 3, 14, 18, 18, 23, 23, 31, 40,
45, 42, 42, 42, 41, 39, 38, 37, 36, 35, 33, 32, 32, 30, 29, 28, 28, 27, 27, 26,
25, 25, 24, 25, 25, 24, 23, 23, 23, 22, 23, 21, 22, 22, 22, 21, 22, 21, 21, 22,
22, 20, 21, 21, 21, 21, 21, 21, 20, 20, 20, 20, 21, 21, 20, 21, 21, 21, 21, 21,
21, 20, 20, 21, 20, 20, 21, 20, 21, 21, 20, 21, 21, 21, 20, 21, 21, 21, 21, 21,
20, 20, 20, 21, 21, 20, 20, 21, 21, 20, 20, 21, 20, 20, 21, 21, 20, 21, 20, 21,
21, 21, 21, 20, 20, 21, 20, 21, 21, 20, 20, 21, 21, 21, 20, 21, 20, 20, 21, 20,
21, 21, 20, 21, 20, 21, 20, 21, 20, 21, 20, 21, 21, 20, 20, 20, 20, 21, 20, 20,
21, 20, 20, 20, 21, 20, 20, 21, 20, 20, 20, 20, 20, 21, 20, 21, 20, 20, 19, 20,
20, 20, 19, 20, 20, 21, 20, 21, 21, 19, 22, 19, 22, 18, 23, 16, 27, 9, 62, 127,
113, 123, 117, 121, 117, 120, 118, 118, 119, 118, 118, 119, 120, 118, 119, 118,
120, 119, 119, 119, 119, 118, 118, 118, 118, 119, 119, 118, 119, 118, 118, 118,
119, 117, 120, 117, 119, 117, 119, 117, 121, 118, 120, 118, 119, 117, 119, 117,
28, 16, 23, 19, 22, 18, 22, 19, 22, 19, 22, 19, 21, 20, 21, 20, 21, 20, 21, 20,
20, 20, 20, 20, 20, 20, 21, 21, 19, 21, 20, 20, 19, 20, 20, 18, 20, 19, 19, 16,
19, 2, -19, -18, -20, -20, -19, -20, -20, -21, -20, -19, -20, -19, -20, -19,
-20, -20, -20, -19, -20, -20, -20, -20, -19, -20, -20, -20, -20, -20, -20, -20,
-20, -20, -20, -20, -20, -20, -21, -21, -20, -20, -19, -20, -19, -20, -20, -21,
-20, -19, -20, -20, -20, -20, -20, -21, -20, -20, -20, -21, -21, -21, -20, -21,
-20, -21, -20, -20, -20, -20, -21, -20, -21, -21, -20, -21, -20, -20, -21, -20,
-20, -20, -21, -21, -20, -20, -21, -20, -21, -21, -21, -20, -20, -20, -21, -20,
-21, -21, -20, -21, -20, -21, -21, -20, -21, -21, -20, -20, -20, -21, -20, -21,
-20, -21, -20, -20, -21, -20, -21, -21, -21, -19, -21, -20, -21, -21, -21, -20,
-22, -19, -21, -20, -21, -20, -21, -19, -21, -20, -20, -21, -19, -21, -20, -21,
-19, -22, -17, -26, -9, -79, -128, -112, -123, -116, -120, -117, -119, -117,
-119, -117, -118, -118, -119, -119, -118, -118, -118, -118, -118, -119, -118,
-118, -117, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -117,
-117, -117, -118, -117, -117, -116, -117, -117, -117, -116, -117, -116, -117,
-116, -116, -116, -115, -115, -116, -116, -115, -115, -114, -115, -115, -115,
-114, -115, -112, -115, -102, -68, -64, -58, -51, -48, -45, -41, -39, -37, -32,
-29, -23, -17, -11, -9, -7, -6, -4, -1, };