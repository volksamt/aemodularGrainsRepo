#define DATA_LENGTH 512
#define DATA AKWF_saw_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 7, 9, 11, 12, 15, 16, 16, 18,
18, 20, 20, 22, 23, 23, 24, 25, 26, 27, 27, 28, 29, 30, 31, 31, 32, 33, 33, 34,
34, 35, 36, 36, 37, 37, 38, 38, 39, 39, 40, 40, 41, 42, 42, 42, 42, 42, 43, 44,
44, 45, 45, 45, 46, 47, 47, 48, 48, 48, 49, 49, 48, 50, 50, 51, 51, 51, 52, 52,
51, 53, 53, 53, 54, 54, 54, 54, 55, 55, 57, 56, 56, 57, 57, 57, 58, 57, 58, 58,
59, 59, 59, 59, 59, 60, 61, 61, 62, 62, 62, 62, 62, 63, 63, 63, 63, 64, 63, 65,
65, 65, 65, 65, 65, 66, 66, 67, 66, 67, 67, 67, 68, 68, 68, 68, 68, 68, 69, 69,
69, 70, 70, 70, 70, 71, 71, 71, 71, 71, 72, 71, 72, 72, 73, 73, 72, 73, 73, 73,
74, 74, 74, 75, 75, 75, 75, 75, 76, 76, 75, 75, 76, 76, 76, 77, 77, 77, 77, 77,
78, 78, 79, 78, 78, 79, 79, 80, 79, 79, 79, 80, 80, 80, 80, 81, 80, 81, 81, 80,
81, 81, 81, 81, 82, 82, 82, 83, 83, 83, 82, 83, 83, 84, 83, 84, 83, 84, 84, 84,
84, 85, 85, 85, 84, 84, 85, 86, 85, 86, 86, 86, 86, 85, 86, 87, 86, 87, 86, 87,
87, 87, 86, 87, 88, 88, 87, 88, 87, 88, 88, 88, 89, 88, 88, 89, 88, 88, 89, 89,
88, 88, 89, 89, 89, 79, 26, -58, -112, -117, -103, -94, -93, -95, -97, -97, -95,
-95, -94, -95, -94, -94, -94, -92, -92, -92, -92, -91, -90, -90, -91, -90, -90,
-89, -90, -89, -89, -89, -89, -87, -88, -87, -87, -87, -87, -86, -86, -86, -85,
-84, -84, -85, -84, -85, -84, -83, -83, -83, -82, -82, -82, -81, -81, -82, -81,
-81, -81, -81, -80, -80, -79, -80, -80, -79, -80, -78, -79, -78, -78, -77, -78,
-77, -77, -76, -77, -76, -76, -76, -75, -75, -75, -75, -75, -75, -74, -74, -73,
-73, -73, -73, -72, -72, -72, -72, -71, -71, -71, -71, -71, -70, -69, -69, -69,
-69, -69, -68, -68, -68, -68, -68, -68, -66, -67, -67, -67, -66, -66, -66, -65,
-66, -65, -64, -64, -64, -64, -64, -62, -64, -63, -62, -62, -62, -62, -61, -61,
-61, -61, -60, -60, -59, -59, -59, -58, -58, -58, -58, -58, -56, -56, -57, -56,
-56, -55, -56, -54, -55, -55, -54, -53, -53, -53, -53, -53, -52, -52, -51, -51,
-50, -50, -49, -49, -50, -49, -49, -48, -48, -48, -48, -47, -46, -46, -46, -46,
-45, -45, -44, -44, -44, -43, -43, -42, -42, -42, -41, -41, -40, -40, -39, -39,
-39, -38, -38, -37, -37, -37, -37, -36, -36, -36, -34, -35, -34, -33, -32, -32,
-31, -31, -31, -29, -29, -29, -28, -27, -27, -26, -26, -26, -24, -23, -24, -23,
-22, -21, -21, -20, -19, -18, -18, -17, -16, -15, -14, -14, -12, -11, -10, -9,
-8, -6, -4, -3, -1, };