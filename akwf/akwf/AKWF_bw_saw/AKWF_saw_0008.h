#define DATA_LENGTH 512
#define DATA AKWF_saw_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 3, 5, 5, 5, 6, 7, 7, 9, 10,
10, 11, 12, 12, 13, 15, 15, 16, 16, 17, 18, 19, 19, 20, 20, 21, 22, 23, 24, 24,
25, 26, 26, 27, 28, 28, 29, 30, 31, 31, 32, 32, 33, 34, 35, 35, 36, 37, 38, 37,
38, 39, 40, 40, 42, 42, 41, 43, 43, 44, 45, 45, 46, 46, 47, 48, 49, 49, 50, 50,
50, 51, 51, 52, 53, 53, 54, 54, 56, 56, 56, 57, 58, 58, 58, 59, 59, 59, 62, 62,
62, 62, 63, 63, 64, 65, 64, 66, 67, 67, 67, 67, 68, 69, 69, 70, 70, 71, 70, 71,
72, 73, 73, 73, 74, 74, 74, 76, 76, 75, 76, 77, 78, 79, 78, 78, 79, 80, 80, 80,
81, 82, 81, 83, 82, 83, 84, 85, 84, 85, 85, 85, 86, 86, 86, 87, 87, 88, 88, 89,
89, 89, 90, 90, 90, 91, 91, 92, 93, 92, 93, 94, 93, 94, 94, 94, 95, 96, 95, 96,
96, 96, 97, 97, 98, 98, 99, 98, 100, 99, 101, 100, 100, 101, 101, 101, 102, 102,
102, 102, 103, 104, 104, 103, 104, 105, 105, 106, 106, 106, 106, 106, 107, 107,
107, 108, 108, 108, 108, 109, 109, 109, 110, 111, 110, 110, 110, 112, 111, 112,
111, 112, 113, 113, 113, 114, 114, 113, 114, 115, 114, 115, 115, 115, 116, 117,
116, 116, 117, 116, 117, 117, 117, 118, 118, 118, 119, 119, 119, 118, 108, 76,
28, -18, -54, -79, -95, -105, -110, -113, -115, -117, -116, -118, -117, -117,
-117, -117, -117, -117, -117, -117, -115, -115, -116, -115, -115, -114, -114,
-115, -114, -113, -113, -113, -113, -112, -112, -112, -111, -111, -111, -111,
-110, -110, -110, -109, -109, -109, -108, -109, -108, -108, -107, -108, -107,
-107, -107, -107, -107, -106, -105, -105, -104, -104, -104, -104, -103, -103,
-102, -102, -102, -102, -102, -101, -101, -100, -100, -100, -100, -99, -98, -98,
-98, -97, -98, -96, -97, -96, -96, -96, -95, -95, -95, -94, -94, -94, -94, -93,
-93, -91, -91, -91, -91, -90, -91, -90, -89, -88, -89, -88, -88, -87, -87, -86,
-86, -86, -85, -85, -85, -84, -85, -83, -83, -83, -82, -81, -80, -81, -80, -80,
-79, -79, -78, -78, -78, -77, -76, -76, -76, -75, -75, -75, -73, -73, -72, -72,
-72, -71, -72, -70, -70, -71, -69, -69, -68, -68, -68, -67, -67, -66, -66, -65,
-64, -64, -64, -62, -62, -62, -61, -61, -61, -60, -59, -59, -58, -57, -58, -57,
-56, -55, -54, -53, -54, -52, -52, -52, -52, -51, -51, -50, -49, -48, -48, -47,
-47, -46, -46, -44, -45, -43, -43, -42, -42, -41, -40, -40, -39, -39, -38, -37,
-37, -36, -35, -35, -33, -33, -33, -32, -31, -30, -29, -29, -29, -27, -27, -26,
-26, -25, -25, -24, -23, -22, -21, -20, -20, -20, -18, -18, -17, -15, -15, -14,
-14, -13, -13, -12, -11, -10, -10, -8, -8, -7, -6, -6, -4, -4, -4, -2, -1, 0, };