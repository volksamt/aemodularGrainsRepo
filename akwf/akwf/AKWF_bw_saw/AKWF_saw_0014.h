#define DATA_LENGTH 512
#define DATA AKWF_saw_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {-66, -107, -105, -110, -109, -112,
-111, -114, -114, -117, -116, -117, -116, -118, -118, -119, -119, -119, -119,
-118, -118, -118, -119, -119, -118, -117, -119, -118, -117, -117, -116, -116,
-115, -114, -113, -112, -112, -112, -111, -110, -110, -109, -107, -107, -105,
-105, -104, -103, -102, -101, -100, -98, -98, -97, -96, -95, -93, -92, -91, -90,
-89, -88, -87, -86, -86, -84, -83, -82, -80, -80, -78, -77, -76, -75, -74, -73,
-71, -70, -68, -68, -67, -66, -65, -64, -62, -61, -61, -59, -58, -57, -56, -54,
-53, -52, -52, -51, -50, -48, -48, -46, -45, -44, -43, -42, -42, -41, -39, -38,
-38, -37, -36, -35, -34, -33, -33, -31, -30, -29, -29, -27, -26, -26, -24, -24,
-24, -22, -21, -21, -20, -19, -19, -17, -17, -17, -15, -14, -14, -13, -12, -12,
-11, -9, -9, -9, -7, -7, -5, -5, -4, -4, -4, -3, -1, -1, 0, -1, 0, 0, 1, 2, 2,
2, 3, 4, 4, 5, 6, 6, 6, 7, 8, 8, 9, 9, 10, 10, 11, 11, 12, 12, 13, 13, 13, 14,
15, 15, 15, 16, 16, 17, 17, 18, 18, 19, 19, 18, 19, 20, 20, 20, 22, 21, 22, 22,
22, 23, 24, 23, 23, 24, 24, 25, 25, 26, 26, 26, 25, 27, 27, 28, 27, 27, 28, 28,
28, 28, 29, 29, 29, 30, 30, 30, 30, 31, 31, 31, 31, 31, 32, 32, 32, 33, 31, 32,
33, 32, 33, 33, 34, 33, 33, 34, 34, 34, 33, 34, 35, 34, 36, 36, 36, 35, 36, 36,
36, 35, 36, 37, 36, 36, 37, 36, 36, 37, 37, 36, 36, 36, 36, 38, 37, 37, 37, 38,
38, 38, 37, 38, 38, 38, 38, 38, 38, 38, 39, 38, 38, 37, 38, 37, 38, 39, 38, 38,
38, 38, 38, 38, 38, 39, 39, 38, 39, 39, 38, 38, 38, 38, 39, 39, 38, 38, 39, 38,
39, 38, 38, 38, 39, 38, 38, 38, 38, 39, 39, 37, 37, 38, 38, 38, 37, 38, 37, 38,
38, 38, 38, 38, 38, 38, 37, 37, 37, 37, 38, 37, 36, 37, 38, 37, 37, 37, 37, 36,
36, 36, 36, 36, 36, 36, 37, 36, 36, 36, 36, 36, 36, 36, 35, 35, 36, 35, 35, 35,
35, 36, 35, 36, 35, 34, 34, 34, 34, 34, 35, 34, 33, 34, 33, 34, 34, 34, 33, 33,
34, 33, 33, 33, 32, 32, 32, 32, 33, 32, 32, 31, 31, 32, 32, 31, 31, 31, 31, 30,
31, 31, 31, 31, 30, 31, 31, 30, 31, 29, 30, 30, 31, 29, 30, 30, 29, 29, 29, 30,
29, 29, 29, 29, 28, 29, 27, 28, 28, 28, 28, 27, 27, 27, 27, 27, 27, 26, 26, 26,
26, 25, 26, 26, 26, 26, 25, 25, 25, 26, 25, 25, 24, 24, 24, 24, 23, 24, 24, 23,
24, 23, 24, 23, 23, 23, 23, 23, 22, 23, 22, 22, 21, 22, 21, 22, 22, 21, 21, 21,
22, 21, 20, 21, 21, 19, 23, 6, };