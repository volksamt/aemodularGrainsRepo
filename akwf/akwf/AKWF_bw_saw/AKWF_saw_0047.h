#define DATA_LENGTH 512
#define DATA AKWF_saw_0047

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 2, 3, 4, 4, 5, 5, 7, 6, 6,
8, 8, 9, 9, 10, 10, 10, 11, 12, 13, 13, 13, 14, 15, 15, 16, 17, 17, 17, 18, 18,
20, 19, 19, 20, 20, 21, 22, 22, 23, 23, 24, 25, 25, 25, 26, 26, 27, 27, 28, 29,
29, 29, 30, 30, 31, 31, 32, 32, 33, 33, 33, 34, 34, 35, 35, 36, 36, 37, 37, 38,
37, 38, 39, 39, 40, 40, 41, 41, 41, 42, 42, 42, 44, 44, 44, 44, 45, 45, 45, 46,
46, 46, 47, 48, 49, 48, 49, 50, 50, 50, 50, 51, 52, 52, 52, 52, 52, 53, 54, 53,
55, 54, 55, 55, 56, 56, 57, 57, 58, 57, 59, 59, 59, 60, 59, 61, 61, 60, 62, 62,
62, 62, 62, 64, 64, 63, 64, 65, 65, 66, 65, 65, 66, 66, 67, 67, 68, 69, 68, 69,
70, 70, 70, 70, 71, 71, 71, 71, 73, 72, 73, 72, 72, 73, 73, 74, 74, 75, 75, 76,
75, 76, 77, 77, 77, 78, 77, 77, 78, 79, 79, 79, 80, 79, 80, 80, 81, 81, 82, 81,
82, 82, 82, 83, 83, 82, 84, 84, 84, 84, 85, 85, 85, 85, 86, 86, 87, 87, 87, 87,
87, 87, 88, 89, 88, 89, 89, 89, 89, 90, 89, 91, 90, 92, 90, 92, 91, 92, 92, 92,
92, 93, 94, 92, 95, 93, 96, 93, 97, 93, 98, 92, 99, 92, 101, 92, 101, 92, 103,
93, 109, 100, -111, -105, -95, -102, -94, -100, -92, -101, -92, -100, -93, -98,
-92, -98, -93, -95, -92, -94, -92, -94, -92, -94, -93, -92, -92, -92, -92, -91,
-91, -90, -91, -90, -91, -89, -90, -89, -89, -89, -88, -88, -88, -88, -88, -86,
-86, -87, -86, -85, -86, -85, -86, -84, -84, -84, -84, -84, -83, -84, -83, -82,
-82, -82, -82, -82, -80, -80, -80, -80, -80, -79, -79, -78, -78, -78, -77, -78,
-77, -77, -77, -76, -75, -76, -75, -75, -75, -74, -74, -74, -74, -73, -73, -73,
-72, -71, -72, -71, -70, -70, -70, -69, -69, -69, -69, -69, -67, -68, -67, -67,
-67, -67, -67, -66, -65, -65, -64, -64, -63, -63, -64, -62, -62, -62, -62, -62,
-61, -60, -59, -60, -60, -58, -58, -58, -59, -58, -58, -57, -57, -56, -56, -55,
-55, -55, -55, -54, -54, -53, -52, -52, -52, -51, -51, -51, -50, -50, -50, -48,
-48, -48, -48, -48, -46, -47, -46, -46, -45, -44, -45, -45, -44, -43, -43, -43,
-42, -41, -41, -41, -41, -40, -39, -39, -38, -38, -38, -37, -37, -36, -36, -36,
-35, -35, -34, -34, -33, -33, -32, -32, -31, -30, -30, -30, -29, -28, -28, -28,
-28, -26, -27, -26, -25, -25, -25, -24, -23, -24, -21, -22, -21, -20, -20, -20,
-19, -20, -18, -18, -17, -17, -17, -15, -16, -15, -14, -13, -13, -13, -11, -11,
-10, -10, -10, -9, -9, -8, -7, -7, -7, -6, -5, -5, -3, -3, -4, -2, -1, -2, 0, 0,
};