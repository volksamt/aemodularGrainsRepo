#define DATA_LENGTH 512
#define DATA AKWF_saw_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {-68, -106, -105, -109, -108, -112,
-112, -114, -114, -115, -115, -117, -116, -118, -118, -118, -118, -118, -119,
-118, -120, -119, -119, -119, -119, -118, -118, -117, -118, -117, -117, -115,
-115, -114, -114, -113, -113, -111, -111, -110, -109, -109, -108, -107, -106,
-105, -104, -104, -103, -102, -101, -99, -98, -97, -97, -95, -94, -93, -92, -90,
-90, -89, -87, -87, -85, -85, -83, -82, -81, -79, -79, -78, -77, -76, -74, -73,
-72, -71, -70, -69, -67, -66, -66, -65, -63, -62, -62, -60, -59, -57, -57, -56,
-55, -54, -53, -52, -50, -49, -48, -47, -46, -45, -44, -44, -42, -41, -41, -40,
-38, -38, -36, -36, -35, -34, -33, -33, -31, -30, -29, -29, -27, -26, -26, -24,
-23, -23, -22, -22, -21, -21, -20, -18, -17, -17, -16, -16, -14, -14, -13, -13,
-11, -10, -10, -9, -9, -8, -7, -6, -5, -5, -5, -3, -3, -3, -2, -2, -1, 0, 0, 1,
3, 2, 3, 4, 3, 5, 6, 5, 6, 7, 7, 8, 8, 9, 10, 10, 10, 11, 11, 12, 13, 13, 13,
14, 14, 15, 15, 16, 16, 17, 17, 18, 18, 18, 18, 19, 19, 20, 20, 20, 21, 21, 21,
22, 22, 23, 23, 23, 24, 23, 25, 25, 25, 25, 25, 25, 26, 27, 26, 27, 27, 28, 28,
28, 28, 29, 28, 30, 29, 30, 29, 30, 30, 30, 31, 30, 31, 32, 32, 31, 32, 32, 32,
32, 32, 32, 34, 34, 34, 33, 34, 34, 34, 35, 34, 35, 35, 35, 35, 35, 35, 35, 36,
36, 36, 36, 35, 35, 36, 36, 37, 37, 37, 37, 37, 37, 36, 37, 37, 37, 37, 37, 36,
37, 38, 38, 38, 37, 37, 37, 38, 38, 38, 38, 38, 38, 38, 38, 39, 39, 39, 38, 38,
38, 38, 38, 38, 39, 38, 38, 38, 39, 39, 38, 39, 38, 38, 39, 38, 39, 38, 39, 38,
38, 39, 39, 38, 38, 39, 39, 38, 38, 39, 38, 38, 37, 38, 39, 38, 38, 39, 39, 38,
39, 39, 38, 39, 38, 38, 38, 38, 38, 37, 37, 37, 38, 37, 37, 37, 37, 37, 37, 37,
36, 37, 37, 37, 38, 36, 36, 37, 37, 36, 36, 36, 36, 37, 36, 36, 36, 36, 36, 36,
36, 35, 35, 35, 36, 35, 35, 35, 35, 35, 35, 34, 35, 34, 35, 35, 34, 34, 34, 34,
34, 34, 33, 34, 33, 33, 33, 33, 32, 33, 32, 33, 33, 32, 32, 32, 32, 33, 32, 32,
32, 32, 31, 31, 31, 31, 31, 30, 31, 31, 30, 30, 30, 30, 31, 30, 29, 30, 30, 30,
29, 29, 28, 29, 29, 29, 29, 29, 29, 29, 28, 28, 28, 27, 28, 27, 27, 27, 28, 27,
27, 27, 27, 26, 27, 26, 26, 27, 25, 26, 26, 26, 26, 25, 25, 24, 25, 25, 25, 25,
25, 24, 25, 24, 24, 24, 24, 25, 24, 24, 24, 22, 23, 24, 24, 23, 23, 22, 23, 22,
22, 22, 23, 22, 21, 22, 20, 23, 8, };