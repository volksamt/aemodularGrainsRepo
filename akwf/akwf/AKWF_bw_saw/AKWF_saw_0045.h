#define DATA_LENGTH 512
#define DATA AKWF_saw_0045

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 2, 3, 4, 4, 5, 6, 7, 8, 8, 9,
10, 11, 11, 12, 12, 13, 13, 14, 14, 15, 17, 17, 18, 18, 18, 20, 20, 21, 22, 21,
22, 23, 23, 24, 24, 26, 27, 27, 28, 28, 28, 29, 30, 30, 31, 31, 32, 32, 33, 34,
35, 36, 36, 36, 37, 37, 39, 39, 40, 39, 41, 41, 41, 42, 43, 43, 44, 43, 45, 44,
46, 46, 46, 47, 48, 48, 50, 50, 50, 50, 51, 51, 52, 53, 52, 53, 53, 55, 55, 56,
56, 56, 57, 58, 58, 58, 59, 59, 60, 60, 61, 61, 61, 62, 63, 62, 63, 64, 64, 64,
65, 66, 66, 66, 67, 67, 67, 68, 69, 69, 70, 70, 69, 71, 71, 71, 72, 72, 73, 73,
73, 73, 75, 74, 75, 75, 76, 77, 77, 77, 77, 78, 78, 78, 79, 78, 80, 79, 81, 81,
81, 81, 81, 82, 83, 83, 83, 84, 84, 84, 85, 85, 85, 86, 86, 87, 87, 87, 88, 88,
88, 89, 88, 90, 90, 89, 90, 91, 90, 91, 92, 92, 92, 93, 93, 93, 94, 95, 93, 95,
95, 96, 95, 96, 96, 97, 96, 97, 97, 98, 98, 98, 99, 99, 99, 99, 100, 100, 100,
101, 100, 101, 101, 102, 102, 102, 102, 103, 103, 103, 104, 103, 105, 104, 104,
104, 106, 105, 106, 106, 106, 107, 106, 108, 106, 109, 106, 109, 106, 111, 106,
112, 107, 114, 105, 114, 105, 115, 105, 117, 106, 122, 103, -114, -116, -109,
-115, -107, -115, -106, -114, -107, -112, -106, -112, -106, -110, -105, -109,
-106, -108, -106, -108, -107, -107, -106, -106, -105, -105, -105, -104, -105,
-104, -105, -104, -104, -103, -103, -102, -103, -102, -102, -101, -101, -101,
-101, -101, -100, -100, -99, -99, -98, -99, -98, -98, -98, -98, -97, -97, -96,
-96, -96, -95, -95, -95, -95, -95, -94, -93, -94, -92, -93, -92, -92, -92, -91,
-92, -91, -90, -91, -90, -89, -89, -89, -88, -88, -88, -88, -87, -87, -86, -86,
-86, -86, -84, -85, -85, -84, -84, -83, -83, -82, -82, -82, -82, -81, -81, -81,
-80, -79, -79, -79, -78, -79, -78, -77, -78, -77, -77, -75, -75, -74, -75, -74,
-74, -74, -73, -73, -72, -72, -72, -71, -70, -71, -69, -69, -69, -69, -69, -67,
-67, -67, -66, -66, -66, -64, -64, -64, -63, -63, -62, -62, -62, -61, -61, -60,
-61, -59, -59, -58, -58, -58, -58, -57, -57, -56, -55, -55, -55, -53, -54, -52,
-52, -52, -51, -50, -50, -50, -49, -49, -48, -48, -47, -47, -46, -46, -45, -44,
-45, -43, -44, -42, -42, -42, -41, -40, -40, -39, -38, -39, -37, -37, -36, -35,
-36, -35, -35, -33, -34, -33, -31, -32, -30, -30, -29, -29, -28, -27, -27, -27,
-26, -25, -25, -24, -23, -23, -22, -22, -20, -20, -20, -19, -17, -17, -18, -16,
-16, -15, -14, -13, -14, -11, -11, -11, -10, -9, -9, -9, -7, -7, -6, -5, -4, -4,
-2, -2, -2, -1, 0, };