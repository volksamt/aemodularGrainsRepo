#define DATA_LENGTH 512
#define DATA AKWF_saw_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 2, 3, 4, 4, 5, 6, 5, 7, 8, 8,
9, 9, 9, 11, 11, 12, 13, 13, 14, 14, 15, 15, 16, 17, 18, 19, 19, 20, 20, 21, 22,
22, 23, 24, 24, 25, 24, 25, 26, 27, 27, 28, 29, 29, 29, 30, 31, 31, 32, 33, 33,
34, 35, 35, 35, 36, 36, 37, 37, 38, 40, 39, 41, 41, 41, 42, 42, 42, 43, 44, 44,
45, 45, 46, 47, 47, 47, 49, 48, 49, 50, 50, 52, 51, 53, 53, 53, 53, 55, 55, 55,
56, 57, 57, 57, 58, 59, 59, 59, 60, 61, 61, 62, 62, 62, 63, 64, 64, 65, 65, 67,
67, 67, 67, 68, 68, 69, 70, 71, 71, 71, 72, 72, 72, 74, 74, 74, 75, 76, 77, 77,
77, 77, 79, 79, 80, 80, 80, 80, 82, 82, 82, 83, 84, 83, 84, 86, 86, 87, 87, 87,
88, 88, 89, 89, 90, 91, 90, 91, 92, 92, 93, 94, 93, 94, 95, 96, 96, 96, 97, 97,
97, 99, 99, 99, 100, 100, 101, 101, 102, 102, 103, 103, 105, 104, 105, 105, 107,
106, 107, 107, 109, 109, 109, 109, 110, 111, 111, 111, 112, 113, 112, 114, 113,
117, 114, 118, 113, 120, 113, 123, 110, 127, 86, 18, 44, 19, 24, 15, 14, 10, 8,
5, 2, 1, -3, -3, -7, -8, -12, -12, -15, -16, -20, -20, -22, -23, -26, -26, -29,
-29, -32, -33, -34, -35, -37, -39, -40, -42, -43, -43, -45, -46, -46, -48, -49,
-50, -51, -53, -53, -54, -55, -55, -57, -58, -58, -59, -59, -60, -61, -62, -63,
-63, -64, -64, -65, -66, -65, -67, -67, -68, -67, -68, -69, -69, -70, -71, -70,
-71, -71, -73, -72, -73, -73, -74, -74, -74, -74, -74, -75, -74, -75, -75, -76,
-76, -74, -76, -75, -75, -76, -76, -76, -76, -76, -77, -77, -77, -77, -76, -77,
-76, -77, -77, -76, -77, -76, -77, -76, -76, -75, -76, -75, -76, -76, -75, -75,
-75, -76, -75, -75, -75, -76, -74, -75, -74, -74, -73, -73, -74, -74, -72, -73,
-73, -72, -72, -71, -72, -71, -71, -71, -71, -70, -71, -71, -70, -69, -69, -69,
-68, -68, -68, -67, -68, -66, -67, -66, -66, -66, -66, -65, -65, -65, -64, -63,
-63, -63, -63, -63, -62, -61, -61, -61, -60, -60, -60, -59, -58, -58, -58, -58,
-57, -58, -56, -56, -55, -55, -55, -55, -54, -54, -53, -52, -53, -52, -52, -51,
-50, -50, -50, -49, -49, -48, -47, -48, -47, -46, -46, -46, -45, -45, -44, -43,
-44, -43, -42, -42, -41, -42, -41, -40, -40, -39, -39, -37, -37, -37, -36, -36,
-35, -36, -34, -35, -33, -33, -32, -32, -32, -31, -30, -30, -29, -29, -28, -27,
-27, -26, -26, -25, -25, -24, -23, -23, -22, -22, -21, -20, -20, -19, -18, -17,
-17, -18, -16, -15, -15, -14, -14, -13, -12, -12, -11, -11, -11, -10, -9, -9,
-7, -7, -6, -6, -6, -5, -4, -4, -3, -2, -1, 0, 0, };