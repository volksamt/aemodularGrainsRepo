#define DATA_LENGTH 512
#define DATA AKWF_ebass_0063

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 13, 16, 19, 22, 25, 29, 31,
34, 37, 39, 41, 43, 45, 47, 49, 50, 53, 55, 57, 59, 60, 62, 62, 63, 65, 66, 67,
68, 69, 70, 71, 72, 74, 75, 75, 76, 76, 77, 78, 79, 80, 80, 81, 80, 81, 82, 83,
83, 82, 83, 84, 84, 84, 84, 85, 85, 86, 86, 85, 86, 86, 86, 87, 87, 86, 87, 87,
86, 87, 88, 87, 87, 87, 88, 87, 88, 88, 87, 87, 87, 86, 86, 86, 86, 86, 85, 85,
86, 86, 86, 86, 85, 85, 85, 84, 84, 85, 84, 84, 84, 83, 83, 83, 83, 83, 82, 81,
81, 81, 81, 81, 80, 80, 79, 79, 79, 78, 79, 78, 78, 77, 77, 76, 76, 76, 75, 75,
75, 74, 74, 74, 73, 72, 73, 72, 72, 71, 71, 70, 70, 69, 70, 69, 69, 68, 68, 67,
67, 67, 66, 65, 65, 64, 65, 64, 63, 63, 62, 62, 60, 61, 60, 60, 59, 58, 58, 57,
57, 57, 56, 56, 55, 55, 54, 54, 53, 52, 52, 51, 50, 50, 49, 49, 48, 47, 46, 46,
45, 44, 44, 43, 43, 42, 41, 40, 40, 39, 38, 38, 38, 37, 36, 35, 35, 34, 33, 33,
31, 32, 31, 31, 30, 29, 29, 28, 27, 28, 26, 26, 26, 25, 24, 24, 23, 22, 21, 22,
22, 20, 19, 20, 19, 19, 18, 18, 16, 16, 15, 15, 14, 14, 13, 13, 13, 12, 13, 12,
11, 11, 10, 10, 10, 10, 9, 9, 9, 8, 9, 10, 9, 9, 10, 10, 9, 10, 10, 10, 10, 9,
10, 10, 11, 11, 12, 12, 12, 12, 12, 13, 14, 14, 14, 14, 15, 15, 16, 16, 17, 17,
18, 18, 19, 20, 20, 21, 22, 22, 23, 24, 25, 26, 26, 27, 27, 29, 29, 30, 31, 31,
33, 34, 33, 35, 36, 36, 36, 38, 38, 39, 39, 40, 40, 41, 41, 41, 42, 42, 43, 43,
43, 43, 42, 42, 42, 42, 42, 41, 42, 41, 40, 40, 38, 38, 37, 36, 34, 33, 33, 31,
30, 28, 27, 25, 23, 21, 18, 16, 14, 12, 8, 6, 4, -1, -4, -8, -10, -14, -18, -21,
-25, -29, -32, -35, -39, -42, -46, -48, -51, -55, -58, -60, -63, -66, -69, -71,
-74, -76, -79, -81, -83, -85, -87, -89, -91, -93, -95, -96, -97, -99, -101,
-102, -102, -104, -105, -106, -107, -109, -110, -110, -111, -112, -113, -112,
-114, -114, -115, -115, -116, -116, -116, -117, -117, -117, -118, -118, -118,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -118, -117, -118, -117, -117, -117, -116, -116, -116,
-114, -115, -115, -113, -114, -113, -112, -111, -111, -110, -109, -108, -108,
-107, -106, -105, -103, -102, -101, -99, -99, -97, -96, -94, -93, -91, -89, -88,
-85, -83, -82, -80, -77, -75, -72, -70, -67, -65, -62, -59, -56, -54, -51, -47,
-44, -41, -36, -33, -28, -25, -22, -17, -15, -12, -9, -5, -1, };