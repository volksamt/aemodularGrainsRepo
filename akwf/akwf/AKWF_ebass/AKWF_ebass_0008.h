#define DATA_LENGTH 512
#define DATA AKWF_ebass_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 9, 11, 14, 17, 21, 22, 26,
28, 29, 31, 33, 36, 37, 40, 42, 45, 48, 50, 52, 54, 56, 58, 60, 62, 64, 65, 68,
69, 72, 74, 76, 78, 79, 81, 83, 84, 85, 87, 89, 90, 92, 93, 95, 96, 98, 100,
100, 101, 102, 103, 104, 105, 107, 107, 109, 109, 110, 112, 111, 111, 112, 113,
113, 114, 114, 115, 115, 115, 116, 116, 116, 117, 116, 117, 115, 115, 114, 114,
113, 112, 112, 112, 112, 113, 113, 113, 114, 113, 113, 112, 111, 110, 108, 107,
106, 104, 103, 101, 101, 100, 99, 98, 98, 97, 97, 95, 94, 93, 92, 92, 91, 91,
89, 88, 86, 85, 84, 82, 80, 79, 76, 75, 73, 72, 70, 69, 67, 67, 65, 66, 64, 63,
63, 61, 61, 59, 58, 57, 55, 53, 51, 47, 45, 43, 41, 38, 36, 33, 32, 30, 28, 27,
26, 25, 26, 25, 26, 26, 26, 27, 27, 27, 26, 25, 24, 22, 19, 16, 13, 11, 8, 4, 1,
-2, -4, -7, -8, -9, -10, -10, -11, -11, -11, -11, -9, -9, -8, -8, -9, -8, -8,
-9, -10, -11, -12, -14, -15, -16, -17, -19, -20, -20, -21, -20, -21, -20, -19,
-19, -18, -17, -15, -15, -14, -15, -15, -15, -17, -17, -19, -21, -22, -24, -27,
-28, -30, -31, -33, -33, -34, -34, -33, -33, -32, -30, -29, -27, -27, -26, -25,
-25, -24, -25, -27, -28, -29, -31, -34, -37, -39, -43, -46, -49, -52, -54, -57,
-60, -63, -65, -68, -70, -73, -75, -77, -80, -82, -85, -87, -90, -93, -96, -99,
-102, -104, -107, -109, -112, -113, -115, -116, -118, -119, -119, -119, -119,
-118, -119, -119, -117, -118, -116, -116, -115, -116, -116, -115, -115, -114,
-113, -112, -111, -110, -110, -108, -106, -103, -100, -98, -95, -92, -87, -82,
-78, -73, -68, -63, -57, -52, -45, -41, -34, -30, -23, -18, -13, -7, -3, 3, 7,
12, 16, 20, 25, 29, 32, 37, 40, 43, 47, 50, 53, 56, 58, 61, 63, 65, 68, 69, 70,
73, 74, 76, 78, 78, 79, 79, 79, 79, 79, 79, 79, 79, 78, 77, 77, 76, 74, 72, 71,
69, 67, 64, 62, 60, 58, 56, 53, 51, 47, 46, 41, 39, 35, 33, 29, 26, 23, 20, 16,
14, 10, 6, 3, 0, -4, -8, -11, -15, -18, -21, -25, -28, -31, -34, -37, -40, -44,
-47, -49, -53, -55, -58, -61, -64, -66, -70, -73, -74, -76, -78, -80, -82, -84,
-85, -88, -89, -91, -93, -95, -97, -98, -100, -101, -101, -101, -103, -103,
-103, -105, -106, -107, -107, -108, -109, -108, -109, -109, -108, -108, -107,
-106, -107, -106, -106, -105, -105, -104, -104, -103, -102, -101, -100, -98,
-97, -96, -94, -93, -91, -91, -89, -87, -86, -84, -83, -81, -78, -76, -74, -73,
-70, -68, -67, -65, -62, -61, -58, -57, -54, -51, -50, -47, -45, -43, -41, -38,
-36, -33, -31, -28, -26, -24, -21, -19, -16, -13, -11, -9, -6, -3, -2, };