#define DATA_LENGTH 512
#define DATA AKWF_ebass_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 3, 6, 8, 8, 10, 11, 13, 15, 16,
18, 19, 20, 21, 22, 24, 25, 27, 28, 29, 30, 31, 32, 33, 35, 35, 36, 38, 39, 41,
41, 42, 43, 44, 45, 46, 46, 48, 48, 49, 50, 51, 53, 52, 54, 55, 55, 56, 56, 57,
57, 59, 59, 60, 61, 61, 61, 62, 62, 63, 64, 64, 64, 64, 64, 66, 66, 66, 67, 68,
68, 68, 68, 69, 69, 69, 69, 69, 69, 69, 70, 70, 70, 70, 71, 70, 70, 71, 71, 70,
71, 71, 70, 71, 71, 70, 71, 70, 70, 70, 70, 69, 70, 70, 69, 69, 69, 69, 69, 69,
68, 68, 67, 67, 67, 68, 67, 66, 66, 66, 66, 65, 66, 65, 65, 65, 64, 64, 64, 63,
63, 63, 62, 62, 62, 62, 62, 60, 60, 60, 59, 59, 58, 58, 58, 58, 58, 56, 56, 56,
55, 54, 55, 54, 53, 53, 53, 52, 51, 50, 50, 50, 50, 49, 49, 48, 47, 47, 46, 46,
46, 46, 45, 44, 43, 44, 43, 43, 42, 42, 42, 41, 40, 40, 40, 39, 39, 38, 38, 38,
37, 38, 37, 36, 36, 36, 36, 35, 34, 34, 35, 34, 34, 34, 34, 32, 33, 31, 32, 32,
32, 31, 31, 31, 31, 30, 30, 30, 30, 29, 29, 29, 28, 28, 28, 28, 29, 27, 27, 28,
28, 27, 28, 28, 27, 27, 27, 27, 27, 28, 27, 28, 28, 27, 27, 27, 27, 27, 27, 27,
27, 28, 27, 28, 27, 27, 27, 27, 28, 27, 27, 27, 28, 27, 28, 28, 27, 28, 27, 27,
27, 27, 28, 28, 27, 28, 27, 27, 27, 26, 27, 26, 26, 26, 25, 26, 26, 25, 25, 24,
23, 23, 23, 22, 22, 21, 22, 20, 19, 19, 18, 18, 16, 17, 16, 15, 15, 14, 12, 11,
10, 10, 9, 8, 6, 6, 5, 4, 2, 1, 0, -1, -2, -3, -5, -6, -7, -8, -11, -11, -13,
-14, -15, -17, -19, -21, -22, -22, -24, -26, -28, -29, -32, -32, -34, -36, -38,
-39, -42, -42, -45, -46, -48, -49, -52, -53, -55, -56, -59, -61, -62, -64, -66,
-68, -69, -70, -71, -74, -75, -77, -79, -80, -82, -84, -85, -86, -88, -90, -91,
-92, -94, -94, -96, -98, -99, -100, -100, -103, -103, -105, -106, -107, -108,
-108, -109, -110, -111, -111, -113, -113, -114, -115, -115, -116, -116, -116,
-117, -118, -118, -118, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-118, -119, -118, -118, -118, -118, -117, -116, -116, -115, -115, -114, -114,
-113, -113, -112, -111, -110, -109, -109, -107, -107, -106, -104, -104, -102,
-101, -100, -99, -98, -97, -95, -94, -93, -91, -90, -89, -87, -86, -85, -83,
-82, -80, -79, -77, -75, -74, -72, -72, -69, -67, -66, -64, -62, -61, -59, -58,
-56, -55, -53, -51, -49, -47, -46, -44, -43, -41, -39, -37, -36, -34, -33, -31,
-30, -27, -25, -24, -23, -20, -20, -18, -15, -15, -13, -12, -10, -8, -7, -6, -3,
-2, -1, };