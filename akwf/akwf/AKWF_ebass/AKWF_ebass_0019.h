#define DATA_LENGTH 512
#define DATA AKWF_ebass_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 9, 11, 14, 18, 21, 24, 27, 30,
33, 35, 37, 40, 42, 46, 48, 50, 53, 55, 58, 59, 62, 64, 66, 68, 70, 72, 74, 75,
77, 79, 81, 82, 83, 83, 86, 87, 88, 89, 89, 91, 92, 92, 94, 94, 95, 95, 96, 96,
97, 97, 97, 98, 97, 97, 97, 98, 98, 98, 98, 97, 98, 97, 97, 97, 97, 96, 96, 95,
95, 96, 94, 94, 94, 93, 93, 92, 92, 91, 90, 89, 89, 88, 87, 87, 85, 86, 84, 85,
83, 82, 81, 81, 80, 79, 78, 77, 77, 75, 75, 73, 72, 72, 71, 70, 69, 68, 67, 66,
65, 65, 63, 62, 61, 60, 60, 58, 57, 57, 55, 55, 54, 53, 51, 51, 50, 50, 48, 47,
47, 45, 45, 44, 42, 42, 40, 40, 39, 38, 38, 37, 35, 35, 34, 33, 32, 31, 31, 30,
29, 28, 27, 27, 26, 25, 24, 23, 23, 21, 21, 20, 20, 19, 18, 17, 17, 17, 16, 15,
15, 13, 14, 13, 13, 11, 11, 10, 10, 9, 8, 8, 7, 8, 6, 6, 6, 4, 5, 4, 4, 3, 3, 3,
2, 1, 1, 0, -1, 0, -1, -3, -2, -2, -2, -3, -4, -4, -5, -4, -5, -6, -7, -7, -7,
-8, -8, -9, -8, -9, -10, -11, -10, -11, -12, -11, -12, -12, -13, -13, -13, -13,
-13, -14, -14, -15, -15, -15, -15, -15, -17, -16, -17, -18, -18, -18, -18, -18,
-18, -19, -20, -20, -19, -20, -19, -20, -20, -21, -21, -21, -21, -21, -21, -22,
-22, -23, -23, -22, -22, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23,
-22, -22, -23, -23, -22, -23, -23, -22, -22, -22, -22, -23, -23, -22, -23, -23,
-22, -22, -23, -23, -22, -22, -22, -22, -22, -22, -21, -21, -22, -22, -21, -20,
-19, -20, -20, -19, -19, -19, -17, -17, -16, -16, -16, -15, -14, -15, -14, -13,
-12, -12, -11, -10, -10, -9, -9, -9, -7, -8, -6, -7, -6, -5, -4, -4, -3, -3, -2,
-1, -2, -1, -1, 0, 1, 2, 2, 2, 3, 4, 4, 4, 5, 5, 6, 6, 6, 6, 6, 7, 6, 8, 8, 8,
8, 8, 8, 8, 7, 7, 7, 7, 6, 6, 4, 4, 4, 3, 2, 2, 0, -2, -2, -3, -5, -6, -8, -9,
-11, -12, -13, -15, -18, -19, -21, -24, -25, -27, -29, -31, -34, -35, -38, -40,
-41, -44, -46, -48, -51, -52, -56, -57, -60, -62, -64, -66, -69, -70, -73, -75,
-78, -80, -82, -84, -86, -88, -91, -91, -93, -95, -98, -99, -101, -103, -104,
-106, -107, -109, -109, -112, -113, -114, -115, -116, -116, -118, -117, -118,
-119, -119, -119, -119, -119, -119, -118, -118, -117, -117, -115, -114, -113,
-113, -111, -109, -108, -107, -105, -103, -102, -100, -98, -96, -93, -91, -88,
-87, -84, -81, -78, -75, -72, -70, -66, -63, -61, -58, -54, -51, -48, -45, -42,
-39, -35, -33, -29, -26, -23, -19, -16, -13, -9, -7, -3, 0, };