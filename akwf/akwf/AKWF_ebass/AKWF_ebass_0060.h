#define DATA_LENGTH 512
#define DATA AKWF_ebass_0060

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 6, 8, 11, 13, 16, 18, 21, 24,
25, 27, 30, 31, 33, 36, 37, 38, 41, 42, 44, 46, 47, 48, 49, 51, 52, 53, 55, 55,
57, 57, 59, 60, 61, 62, 62, 63, 64, 65, 66, 66, 67, 67, 68, 69, 69, 69, 70, 71,
71, 71, 72, 72, 72, 73, 73, 74, 74, 74, 75, 74, 75, 75, 75, 75, 76, 75, 76, 75,
76, 76, 76, 76, 75, 76, 76, 76, 76, 76, 76, 77, 76, 76, 76, 76, 76, 76, 75, 75,
75, 74, 74, 75, 74, 73, 73, 74, 73, 73, 73, 73, 72, 72, 71, 72, 72, 71, 70, 70,
70, 70, 69, 69, 69, 69, 68, 67, 67, 68, 67, 67, 66, 65, 65, 65, 64, 64, 65, 64,
64, 64, 62, 62, 62, 62, 61, 60, 61, 61, 60, 60, 59, 58, 58, 58, 57, 56, 57, 56,
55, 55, 54, 54, 54, 53, 53, 52, 52, 52, 50, 50, 50, 50, 49, 49, 48, 48, 48, 47,
47, 46, 46, 45, 45, 44, 44, 43, 43, 43, 42, 41, 40, 40, 39, 39, 38, 38, 37, 37,
35, 36, 35, 34, 34, 33, 33, 33, 32, 31, 30, 30, 29, 28, 28, 27, 27, 27, 26, 25,
25, 24, 24, 23, 23, 22, 22, 22, 21, 20, 20, 21, 19, 19, 18, 18, 19, 16, 16, 17,
16, 15, 15, 15, 15, 14, 14, 14, 12, 12, 12, 12, 11, 10, 10, 9, 9, 9, 9, 9, 8, 7,
7, 8, 7, 7, 8, 7, 7, 7, 7, 7, 7, 6, 6, 7, 7, 6, 7, 7, 7, 8, 7, 8, 8, 8, 8, 8, 8,
9, 10, 9, 10, 10, 10, 11, 11, 12, 11, 12, 12, 13, 14, 14, 13, 15, 15, 16, 16,
17, 17, 18, 18, 19, 19, 21, 21, 21, 22, 22, 24, 23, 25, 26, 27, 27, 27, 28, 28,
29, 30, 29, 30, 30, 32, 32, 32, 33, 33, 33, 33, 33, 33, 33, 34, 34, 33, 33, 34,
33, 32, 32, 32, 31, 30, 30, 29, 28, 27, 27, 25, 24, 23, 23, 21, 19, 18, 16, 15,
13, 11, 10, 7, 5, 3, 0, -2, -5, -7, -10, -12, -15, -18, -21, -23, -26, -29, -32,
-34, -37, -39, -43, -45, -48, -51, -54, -57, -59, -62, -64, -67, -69, -71, -73,
-76, -78, -79, -81, -84, -85, -87, -89, -91, -93, -95, -96, -97, -99, -100,
-101, -103, -105, -106, -106, -108, -108, -110, -110, -111, -113, -113, -113,
-114, -114, -115, -116, -116, -117, -117, -117, -118, -118, -119, -118, -118,
-119, -118, -119, -119, -119, -119, -119, -118, -119, -118, -117, -118, -117,
-117, -116, -116, -116, -116, -115, -114, -113, -112, -112, -111, -110, -109,
-108, -107, -106, -105, -104, -103, -101, -100, -98, -98, -97, -94, -93, -92,
-90, -89, -86, -85, -83, -82, -79, -78, -76, -73, -70, -68, -67, -64, -62, -60,
-57, -55, -52, -50, -46, -44, -41, -37, -35, -32, -30, -26, -23, -20, -17, -14,
-11, -9, -8, -4, -1, };