#define DATA_LENGTH 512
#define DATA AKWF_ebass_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 8, 12, 19, 25, 31, 36, 40, 45, 50,
53, 57, 62, 66, 69, 71, 75, 78, 80, 83, 85, 88, 91, 93, 95, 98, 99, 102, 104,
106, 107, 109, 112, 113, 115, 117, 117, 118, 119, 119, 119, 118, 119, 119, 118,
117, 116, 115, 113, 112, 110, 108, 107, 104, 103, 100, 98, 96, 94, 90, 88, 86,
84, 80, 79, 75, 73, 70, 67, 64, 60, 57, 55, 51, 47, 44, 42, 37, 35, 32, 30, 26,
23, 21, 17, 15, 12, 11, 8, 6, 4, 2, 0, -3, -5, -7, -8, -10, -13, -15, -16, -18,
-20, -22, -24, -27, -28, -30, -32, -35, -37, -39, -40, -43, -44, -46, -46, -48,
-49, -49, -51, -50, -50, -51, -51, -51, -52, -52, -52, -52, -52, -53, -54, -54,
-55, -55, -57, -56, -57, -57, -59, -59, -60, -60, -61, -61, -61, -61, -60, -59,
-60, -59, -58, -58, -57, -58, -57, -58, -57, -58, -57, -58, -57, -58, -58, -58,
-58, -58, -58, -58, -57, -56, -56, -54, -55, -54, -52, -52, -51, -49, -49, -47,
-47, -46, -46, -45, -46, -46, -47, -47, -48, -48, -49, -50, -50, -51, -51, -51,
-52, -51, -52, -51, -50, -50, -48, -47, -47, -46, -46, -45, -44, -42, -43, -42,
-43, -43, -44, -44, -45, -46, -47, -48, -50, -50, -51, -51, -51, -51, -51, -50,
-49, -48, -47, -46, -46, -44, -43, -42, -41, -40, -40, -39, -39, -39, -40, -41,
-41, -43, -44, -45, -46, -46, -46, -48, -48, -47, -47, -46, -44, -43, -42, -40,
-37, -35, -34, -30, -28, -27, -25, -24, -23, -22, -21, -20, -20, -21, -20, -20,
-20, -20, -20, -19, -19, -18, -17, -17, -15, -14, -12, -11, -8, -6, -3, -1, 1,
2, 4, 5, 8, 8, 8, 8, 9, 9, 10, 9, 9, 9, 8, 9, 9, 9, 10, 12, 12, 15, 16, 18, 19,
21, 23, 26, 28, 30, 31, 34, 36, 36, 38, 40, 41, 41, 41, 40, 40, 40, 40, 38, 37,
36, 35, 34, 33, 32, 31, 30, 31, 29, 30, 30, 30, 30, 29, 30, 30, 30, 32, 31, 32,
33, 34, 35, 35, 35, 36, 38, 38, 39, 41, 41, 42, 42, 44, 45, 46, 46, 47, 47, 48,
48, 48, 48, 47, 47, 46, 46, 45, 43, 44, 43, 42, 41, 40, 39, 38, 38, 37, 37, 37,
36, 36, 36, 36, 37, 37, 37, 39, 40, 41, 42, 43, 44, 46, 47, 48, 50, 52, 52, 54,
55, 56, 56, 56, 56, 56, 55, 55, 54, 52, 50, 48, 45, 43, 40, 37, 33, 29, 26, 21,
19, 14, 10, 6, 2, 0, -4, -6, -9, -11, -13, -16, -17, -18, -21, -22, -24, -26,
-28, -29, -30, -33, -35, -36, -39, -41, -44, -45, -48, -51, -53, -55, -57, -59,
-62, -63, -65, -66, -67, -70, -69, -71, -71, -72, -73, -74, -75, -75, -76, -76,
-76, -76, -75, -75, -75, -74, -72, -70, -68, -65, -62, -59, -54, -51, -45, -40,
-35, -30, -25, -19, -12, -8, -2, };