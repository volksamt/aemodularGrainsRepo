#define DATA_LENGTH 512
#define DATA AKWF_ebass_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 7, 11, 15, 18, 21, 23, 27, 29,
32, 35, 38, 40, 45, 48, 51, 53, 57, 60, 63, 66, 70, 73, 77, 80, 82, 86, 89, 92,
94, 97, 99, 101, 103, 106, 107, 109, 110, 111, 112, 114, 115, 116, 117, 117,
118, 119, 119, 119, 120, 119, 120, 120, 119, 119, 119, 117, 117, 117, 116, 115,
114, 114, 113, 110, 110, 108, 106, 105, 104, 102, 99, 98, 96, 94, 92, 91, 88,
87, 85, 83, 81, 79, 76, 75, 73, 71, 69, 67, 65, 62, 61, 58, 56, 53, 50, 47, 45,
43, 40, 38, 34, 32, 30, 27, 24, 22, 20, 18, 16, 13, 10, 9, 6, 5, 4, 1, -1, -1,
-4, -5, -7, -9, -11, -12, -14, -16, -18, -20, -22, -25, -27, -28, -31, -32, -34,
-35, -37, -39, -40, -42, -43, -44, -45, -47, -47, -48, -49, -50, -51, -52, -53,
-54, -55, -57, -58, -59, -60, -62, -62, -63, -64, -66, -66, -66, -67, -67, -68,
-67, -68, -68, -69, -68, -70, -69, -70, -69, -70, -70, -72, -72, -74, -73, -75,
-77, -77, -77, -78, -79, -79, -80, -80, -81, -81, -82, -82, -82, -82, -82, -81,
-82, -81, -80, -81, -81, -80, -80, -81, -81, -82, -82, -83, -85, -84, -85, -87,
-87, -88, -88, -89, -88, -89, -89, -88, -88, -87, -86, -86, -85, -85, -84, -84,
-84, -83, -83, -84, -83, -83, -84, -84, -84, -85, -85, -87, -87, -88, -88, -88,
-87, -87, -86, -85, -84, -83, -80, -79, -77, -76, -74, -73, -72, -71, -69, -68,
-67, -67, -66, -66, -65, -66, -65, -64, -65, -63, -64, -63, -62, -61, -60, -59,
-58, -55, -54, -51, -49, -47, -45, -43, -41, -40, -38, -37, -36, -35, -34, -33,
-33, -32, -31, -31, -31, -30, -28, -27, -27, -25, -23, -22, -19, -18, -16, -14,
-11, -9, -7, -5, -3, 0, 2, 4, 5, 6, 8, 9, 9, 10, 11, 11, 12, 12, 11, 12, 12, 12,
13, 13, 13, 14, 15, 16, 17, 18, 19, 21, 21, 22, 24, 25, 26, 28, 28, 31, 32, 33,
34, 35, 37, 37, 38, 39, 40, 41, 43, 43, 44, 45, 46, 47, 47, 48, 50, 50, 51, 51,
52, 51, 51, 52, 51, 52, 53, 52, 53, 53, 52, 53, 54, 54, 54, 55, 55, 56, 57, 57,
58, 59, 61, 62, 63, 63, 64, 65, 67, 67, 68, 69, 71, 72, 72, 72, 74, 73, 74, 73,
74, 74, 73, 72, 72, 71, 70, 68, 66, 64, 63, 61, 58, 56, 54, 51, 49, 47, 45, 42,
39, 37, 36, 33, 32, 30, 28, 27, 25, 23, 21, 20, 17, 15, 13, 12, 9, 7, 5, 2, 0,
-3, -6, -8, -12, -14, -17, -21, -23, -26, -30, -32, -35, -38, -40, -41, -43,
-45, -47, -48, -50, -52, -53, -54, -55, -56, -58, -58, -58, -59, -60, -60, -60,
-60, -60, -58, -58, -55, -54, -52, -50, -47, -45, -42, -38, -35, -32, -29, -26,
-22, -19, -16, -13, -9, -7, -5, 0, };