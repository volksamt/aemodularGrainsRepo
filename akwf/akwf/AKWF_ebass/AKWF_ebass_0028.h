#define DATA_LENGTH 512
#define DATA AKWF_ebass_0028

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 16, 21, 26, 32, 38, 43, 48, 52,
57, 62, 67, 72, 76, 79, 83, 87, 90, 94, 96, 99, 102, 104, 106, 108, 111, 111,
113, 113, 114, 115, 116, 116, 116, 116, 115, 115, 114, 114, 112, 111, 110, 107,
106, 104, 102, 99, 96, 94, 91, 87, 84, 81, 77, 74, 70, 66, 62, 57, 52, 48, 44,
38, 33, 29, 24, 18, 13, 7, 1, -5, -11, -16, -23, -28, -35, -41, -46, -51, -57,
-63, -68, -74, -79, -84, -89, -93, -98, -101, -105, -108, -110, -112, -115,
-116, -118, -119, -119, -119, -118, -118, -117, -115, -115, -111, -110, -106,
-104, -100, -98, -95, -91, -86, -83, -79, -76, -71, -68, -64, -60, -55, -53,
-48, -44, -40, -35, -31, -27, -23, -19, -15, -11, -7, -2, 2, 7, 11, 16, 19, 24,
29, 33, 37, 42, 46, 51, 55, 58, 63, 68, 72, 75, 79, 82, 85, 88, 91, 95, 96, 99,
102, 103, 104, 106, 107, 107, 107, 107, 107, 106, 105, 104, 103, 101, 98, 95,
93, 89, 87, 82, 79, 74, 70, 66, 62, 56, 52, 46, 41, 36, 30, 25, 19, 14, 8, 3,
-2, -8, -13, -18, -24, -29, -35, -39, -44, -48, -53, -58, -61, -66, -70, -74,
-77, -80, -82, -87, -88, -91, -94, -96, -96, -98, -99, -101, -101, -102, -102,
-103, -103, -103, -102, -101, -101, -99, -98, -95, -93, -92, -90, -88, -85, -82,
-79, -76, -73, -69, -65, -62, -57, -52, -49, -45, -40, -36, -32, -28, -22, -18,
-12, -7, -2, 2, 6, 12, 17, 22, 26, 31, 36, 41, 45, 50, 54, 59, 63, 68, 70, 74,
79, 82, 85, 88, 91, 93, 96, 98, 100, 103, 103, 105, 106, 107, 107, 108, 108,
107, 107, 106, 106, 105, 103, 102, 100, 99, 96, 94, 91, 88, 86, 83, 80, 76, 73,
69, 67, 63, 59, 56, 52, 49, 44, 40, 36, 33, 28, 26, 22, 17, 13, 10, 6, 2, -2,
-6, -9, -13, -17, -20, -24, -27, -31, -34, -38, -41, -45, -48, -51, -53, -56,
-58, -61, -64, -65, -67, -69, -70, -71, -72, -73, -74, -75, -74, -74, -74, -74,
-74, -72, -71, -71, -70, -68, -66, -66, -63, -62, -59, -56, -55, -52, -48, -46,
-44, -41, -38, -35, -31, -27, -23, -20, -16, -12, -8, -5, -1, 3, 7, 12, 16, 19,
23, 27, 30, 34, 38, 40, 43, 46, 48, 51, 53, 54, 56, 57, 58, 59, 59, 59, 59, 59,
59, 58, 56, 55, 54, 53, 50, 49, 47, 44, 43, 40, 37, 35, 32, 29, 27, 23, 20, 18,
14, 13, 9, 7, 3, 0, -3, -6, -9, -12, -15, -19, -23, -26, -29, -34, -38, -40,
-45, -48, -52, -56, -61, -64, -67, -72, -75, -78, -82, -85, -88, -91, -94, -97,
-99, -101, -103, -105, -106, -106, -107, -108, -108, -108, -108, -107, -106,
-104, -102, -100, -98, -95, -92, -89, -85, -82, -77, -73, -69, -65, -60, -55,
-50, -44, -39, -33, -29, -23, -17, -10, -6, 0, };