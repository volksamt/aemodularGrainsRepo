#define DATA_LENGTH 512
#define DATA AKWF_ebass_0046

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 0, 1, 2, 2, 3, 4, 4, 5, 6, 7, 9,
10, 12, 12, 14, 16, 17, 18, 19, 20, 20, 20, 20, 20, 20, 19, 20, 20, 19, 18, 18,
17, 16, 15, 14, 12, 11, 10, 8, 7, 6, 5, 3, 1, 0, -3, -5, -7, -9, -11, -14, -16,
-19, -22, -24, -26, -28, -32, -35, -37, -39, -42, -44, -47, -49, -52, -54, -57,
-59, -62, -63, -66, -67, -70, -72, -73, -74, -77, -77, -80, -81, -83, -84, -85,
-86, -87, -90, -90, -91, -91, -93, -93, -95, -95, -96, -97, -97, -98, -98, -98,
-98, -98, -98, -98, -99, -98, -99, -99, -99, -99, -99, -98, -97, -98, -96, -95,
-95, -94, -93, -93, -91, -90, -90, -88, -88, -86, -86, -84, -83, -81, -80, -78,
-78, -77, -74, -73, -73, -71, -69, -69, -67, -65, -64, -63, -61, -61, -59, -57,
-57, -56, -55, -53, -51, -50, -48, -48, -47, -46, -45, -43, -41, -41, -40, -40,
-37, -37, -36, -35, -34, -32, -31, -31, -29, -29, -28, -27, -26, -25, -24, -23,
-23, -22, -20, -19, -18, -17, -17, -16, -15, -15, -14, -13, -14, -13, -12, -12,
-11, -11, -12, -11, -11, -10, -11, -11, -11, -10, -10, -11, -11, -11, -11, -12,
-12, -13, -12, -13, -13, -13, -14, -14, -15, -14, -15, -16, -15, -16, -16, -16,
-16, -18, -17, -17, -17, -18, -18, -17, -18, -17, -18, -17, -17, -17, -17, -18,
-18, -17, -17, -17, -17, -17, -17, -17, -17, -16, -17, -17, -16, -17, -16, -16,
-16, -16, -14, -14, -14, -14, -13, -14, -13, -12, -12, -12, -11, -10, -10, -9,
-9, -8, -8, -7, -6, -5, -5, -4, -4, -3, -4, -3, -3, -3, -2, -2, -2, -2, -1, -2,
-2, -2, -2, -3, -3, -4, -5, -5, -6, -7, -9, -9, -11, -13, -14, -16, -18, -19,
-21, -23, -25, -27, -29, -32, -34, -36, -39, -41, -44, -47, -49, -52, -55, -59,
-61, -64, -67, -69, -72, -75, -78, -80, -83, -85, -88, -90, -92, -95, -97, -100,
-102, -104, -105, -107, -109, -111, -112, -113, -114, -115, -115, -116, -117,
-118, -119, -118, -119, -120, -120, -119, -118, -118, -118, -117, -116, -116,
-115, -113, -111, -109, -107, -107, -104, -102, -100, -97, -95, -92, -90, -88,
-85, -83, -79, -76, -73, -70, -67, -64, -61, -58, -55, -51, -49, -45, -42, -40,
-37, -34, -31, -29, -26, -23, -20, -18, -16, -14, -12, -10, -9, -7, -5, -3, -1,
0, 1, 2, 3, 4, 5, 5, 6, 6, 7, 7, 8, 7, 7, 7, 6, 6, 4, 5, 4, 3, 1, 1, -1, -1, -2,
-4, -5, -6, -8, -10, -10, -11, -13, -13, -14, -16, -17, -18, -19, -20, -20, -21,
-22, -22, -24, -23, -24, -24, -24, -24, -25, -23, -23, -23, -23, -22, -22, -21,
-21, -19, -19, -18, -17, -17, -16, -14, -14, -14, -12, -11, -10, -9, -9, -7, -7,
-6, -5, -4, -4, -3, -3, -2, -2, 0, -1, -1, -1, 0, -1, 1, };