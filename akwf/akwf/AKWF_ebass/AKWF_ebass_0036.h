#define DATA_LENGTH 512
#define DATA AKWF_ebass_0036

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 7, 9, 11, 13, 16, 19, 20, 23,
26, 28, 30, 33, 35, 38, 40, 42, 44, 46, 48, 49, 52, 53, 55, 57, 58, 59, 60, 62,
62, 63, 63, 63, 63, 62, 62, 61, 61, 60, 59, 58, 56, 56, 55, 54, 53, 53, 52, 51,
51, 51, 50, 51, 51, 52, 53, 53, 54, 56, 57, 59, 61, 63, 66, 67, 70, 72, 75, 78,
81, 84, 85, 88, 91, 92, 95, 97, 98, 99, 101, 103, 104, 105, 106, 107, 107, 108,
108, 109, 110, 109, 109, 109, 109, 108, 108, 107, 106, 106, 105, 105, 103, 102,
99, 98, 96, 93, 91, 89, 88, 84, 83, 80, 77, 74, 71, 69, 67, 63, 61, 58, 55, 53,
50, 47, 44, 41, 38, 35, 33, 29, 27, 24, 22, 19, 17, 15, 12, 10, 8, 5, 3, 0, -2,
-4, -6, -8, -10, -12, -13, -15, -15, -17, -18, -19, -19, -21, -21, -21, -21,
-22, -22, -22, -22, -21, -22, -21, -22, -21, -21, -21, -21, -22, -22, -21, -22,
-21, -21, -20, -21, -20, -19, -18, -18, -17, -16, -16, -14, -14, -13, -13, -12,
-12, -12, -12, -12, -11, -13, -13, -14, -13, -15, -15, -15, -15, -15, -16, -17,
-17, -17, -18, -18, -18, -18, -18, -17, -17, -17, -17, -17, -17, -16, -17, -17,
-18, -18, -18, -18, -18, -19, -19, -18, -18, -18, -17, -17, -17, -16, -15, -14,
-13, -13, -12, -11, -10, -10, -9, -8, -8, -7, -7, -6, -5, -4, -5, -3, -2, -2,
-3, -3, -2, -3, -3, -4, -4, -5, -6, -6, -6, -7, -7, -8, -8, -7, -8, -8, -8, -8,
-7, -7, -7, -6, -6, -6, -5, -5, -4, -4, -4, -3, -2, -3, -3, -3, -3, -4, -5, -5,
-5, -6, -7, -8, -8, -9, -10, -10, -11, -12, -13, -13, -14, -14, -14, -15, -16,
-15, -16, -16, -16, -17, -16, -17, -17, -17, -17, -18, -18, -19, -19, -19, -20,
-20, -20, -20, -21, -21, -23, -23, -24, -25, -25, -27, -29, -28, -30, -31, -32,
-34, -35, -36, -37, -38, -39, -40, -40, -42, -42, -42, -43, -43, -43, -43, -44,
-43, -43, -44, -43, -43, -43, -42, -43, -43, -42, -43, -42, -43, -42, -43, -44,
-45, -44, -46, -46, -48, -49, -50, -51, -54, -55, -57, -59, -60, -61, -64, -66,
-67, -68, -69, -70, -71, -72, -72, -73, -73, -74, -73, -73, -73, -72, -73, -72,
-72, -71, -69, -69, -69, -68, -67, -66, -65, -65, -65, -63, -63, -63, -64, -64,
-65, -66, -66, -67, -69, -69, -70, -71, -73, -75, -75, -77, -78, -79, -81, -82,
-84, -86, -88, -89, -91, -92, -93, -95, -98, -98, -101, -102, -103, -106, -107,
-109, -109, -111, -112, -113, -115, -115, -117, -118, -118, -119, -119, -119,
-119, -118, -118, -116, -116, -113, -112, -111, -107, -105, -103, -99, -96, -93,
-89, -86, -81, -77, -73, -70, -65, -61, -57, -54, -49, -46, -43, -39, -35, -32,
-28, -25, -21, -19, -15, -11, -9, -6, -2, 0, };