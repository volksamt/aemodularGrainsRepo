#define DATA_LENGTH 512
#define DATA AKWF_ebass_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 5, 6, 8, 9, 10, 11, 13,
14, 15, 17, 19, 20, 21, 22, 24, 25, 27, 27, 29, 29, 30, 32, 33, 33, 34, 34, 36,
35, 36, 38, 38, 38, 39, 39, 40, 41, 42, 42, 42, 44, 44, 45, 45, 46, 48, 48, 49,
50, 52, 52, 53, 55, 56, 57, 57, 59, 60, 61, 62, 63, 63, 63, 65, 65, 66, 66, 65,
66, 66, 65, 66, 65, 65, 64, 64, 63, 63, 61, 61, 59, 59, 57, 55, 54, 53, 51, 49,
48, 45, 44, 42, 40, 39, 37, 35, 32, 32, 30, 27, 25, 23, 21, 20, 17, 16, 14, 12,
9, 6, 4, 2, -2, -3, -6, -8, -12, -15, -18, -21, -25, -28, -32, -35, -39, -43,
-45, -50, -53, -57, -61, -65, -68, -72, -75, -78, -81, -84, -88, -91, -93, -97,
-99, -101, -104, -106, -107, -109, -110, -112, -113, -114, -114, -116, -117,
-117, -118, -119, -119, -119, -119, -118, -120, -119, -119, -119, -119, -117,
-117, -116, -115, -115, -114, -112, -112, -111, -109, -108, -107, -105, -103,
-102, -100, -97, -95, -93, -91, -88, -84, -82, -80, -77, -73, -70, -66, -64,
-61, -58, -54, -50, -46, -43, -39, -35, -33, -29, -26, -23, -20, -17, -13, -10,
-7, -6, -4, 1, 5, 7, 9, 11, 14, 14, 16, 19, 21, 22, 24, 25, 27, 28, 30, 31, 32,
33, 35, 36, 37, 37, 39, 39, 40, 42, 42, 42, 43, 43, 45, 45, 45, 46, 47, 47, 48,
48, 48, 49, 48, 48, 49, 48, 48, 48, 47, 47, 47, 46, 45, 46, 45, 43, 42, 41, 39,
39, 38, 36, 35, 33, 32, 31, 30, 29, 28, 27, 26, 24, 24, 23, 23, 21, 21, 20, 19,
18, 18, 18, 17, 16, 16, 15, 15, 14, 15, 14, 13, 13, 12, 12, 11, 11, 10, 9, 9, 8,
8, 6, 6, 5, 4, 3, 2, 1, 0, -2, -2, -2, -4, -5, -5, -7, -7, -9, -9, -9, -10, -11,
-11, -11, -12, -12, -11, -12, -11, -11, -11, -10, -9, -9, -8, -8, -8, -6, -6,
-5, -3, -4, -3, -1, -2, 0, 0, 1, 1, 2, 3, 2, 3, 3, 3, 3, 4, 4, 5, 5, 5, 6, 6, 6,
7, 7, 8, 8, 9, 10, 9, 10, 11, 11, 12, 12, 12, 13, 13, 14, 15, 16, 16, 17, 17,
16, 18, 18, 19, 20, 20, 20, 20, 22, 22, 22, 21, 22, 22, 22, 22, 23, 22, 21, 20,
21, 20, 19, 19, 18, 17, 16, 15, 14, 13, 12, 11, 10, 9, 8, 7, 6, 6, 5, 4, 4, 2,
2, 3, 1, 1, 0, 0, 0, -1, -1, -2, -3, -4, -4, -5, -5, -6, -6, -6, -7, -8, -9, -8,
-9, -10, -9, -10, -11, -10, -11, -10, -10, -12, -11, -11, -11, -10, -11, -10,
-10, -10, -10, -10, -9, -9, -9, -8, -8, -8, -8, -8, -7, -7, -7, -7, -7, -7, -6,
-6, -7, -6, -5, -4, -3, -4, -3, -2, -2, 0, };