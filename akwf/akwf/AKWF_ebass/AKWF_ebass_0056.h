#define DATA_LENGTH 512
#define DATA AKWF_ebass_0056

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 6, 8, 11, 13, 14, 16, 18, 20,
21, 24, 25, 26, 28, 29, 31, 33, 34, 35, 37, 38, 40, 40, 42, 43, 45, 46, 47, 47,
48, 48, 50, 50, 52, 53, 53, 55, 55, 56, 57, 57, 58, 58, 59, 59, 60, 61, 61, 61,
62, 61, 62, 62, 63, 64, 64, 64, 65, 65, 65, 64, 65, 66, 65, 65, 66, 66, 66, 66,
66, 66, 66, 66, 66, 66, 67, 67, 66, 67, 66, 66, 66, 67, 65, 66, 66, 65, 65, 65,
64, 65, 65, 64, 64, 63, 64, 64, 63, 63, 63, 62, 62, 62, 62, 61, 62, 61, 60, 60,
60, 59, 60, 59, 59, 58, 58, 57, 58, 57, 56, 56, 56, 57, 56, 56, 54, 55, 54, 53,
53, 53, 53, 53, 52, 51, 51, 51, 51, 50, 51, 49, 49, 49, 49, 47, 47, 46, 47, 46,
46, 45, 45, 45, 44, 43, 43, 43, 43, 42, 42, 41, 40, 40, 41, 40, 40, 39, 38, 39,
37, 36, 36, 37, 36, 35, 34, 34, 34, 34, 34, 33, 32, 32, 31, 31, 30, 30, 29, 28,
27, 27, 28, 26, 26, 26, 25, 24, 24, 24, 23, 22, 22, 22, 21, 21, 22, 20, 20, 20,
19, 20, 18, 18, 17, 17, 17, 16, 16, 16, 16, 14, 14, 14, 14, 13, 14, 13, 12, 13,
12, 11, 11, 11, 11, 10, 10, 10, 9, 8, 9, 9, 8, 8, 8, 7, 7, 7, 6, 5, 7, 6, 6, 6,
5, 5, 5, 6, 5, 5, 4, 6, 6, 5, 5, 6, 4, 6, 5, 5, 6, 6, 6, 6, 6, 7, 7, 7, 7, 8, 6,
7, 9, 9, 8, 8, 8, 9, 9, 10, 9, 10, 10, 11, 11, 12, 12, 13, 12, 13, 14, 14, 15,
15, 16, 15, 17, 17, 17, 18, 18, 19, 20, 20, 21, 22, 22, 23, 23, 23, 24, 24, 25,
25, 24, 26, 26, 26, 25, 27, 26, 26, 27, 27, 26, 26, 27, 26, 25, 26, 26, 25, 24,
24, 24, 22, 22, 21, 21, 20, 19, 19, 17, 16, 16, 13, 12, 11, 10, 9, 7, 6, 4, 2,
1, -1, -4, -5, -7, -10, -12, -14, -15, -18, -21, -23, -25, -28, -30, -32, -34,
-37, -39, -42, -45, -48, -48, -52, -54, -57, -59, -62, -63, -66, -68, -69, -72,
-75, -76, -79, -81, -83, -85, -88, -88, -90, -92, -94, -96, -98, -99, -100,
-102, -104, -104, -106, -106, -108, -109, -111, -111, -112, -113, -114, -115,
-115, -116, -116, -117, -118, -118, -118, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -118, -117, -117, -115, -115, -115, -114,
-113, -113, -112, -111, -109, -108, -107, -106, -106, -103, -102, -101, -100,
-99, -97, -96, -94, -93, -91, -89, -87, -85, -83, -82, -80, -78, -75, -74, -72,
-70, -67, -65, -63, -61, -59, -57, -55, -53, -50, -47, -45, -43, -40, -38, -36,
-33, -30, -28, -26, -23, -20, -18, -16, -13, -10, -9, -6, -6, -3, -1, };