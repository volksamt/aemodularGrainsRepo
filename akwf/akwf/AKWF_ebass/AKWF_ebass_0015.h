#define DATA_LENGTH 512
#define DATA AKWF_ebass_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 7, 8, 11, 13, 15, 17, 19, 20,
23, 25, 27, 29, 31, 32, 34, 36, 38, 40, 42, 43, 45, 48, 49, 51, 53, 54, 56, 58,
59, 61, 63, 64, 66, 68, 69, 70, 73, 74, 75, 76, 78, 79, 81, 82, 82, 84, 85, 86,
87, 88, 90, 91, 90, 92, 92, 93, 94, 94, 94, 95, 96, 96, 97, 97, 97, 98, 98, 98,
97, 98, 98, 98, 98, 97, 97, 97, 97, 97, 96, 95, 96, 95, 95, 94, 93, 93, 92, 92,
90, 90, 88, 88, 86, 85, 85, 83, 83, 82, 79, 79, 78, 76, 74, 74, 73, 71, 69, 67,
66, 64, 63, 61, 60, 58, 56, 54, 53, 50, 48, 47, 45, 43, 42, 39, 37, 35, 34, 32,
30, 28, 26, 24, 22, 20, 19, 16, 15, 12, 11, 9, 7, 6, 4, 2, 0, -1, -2, -4, -5,
-7, -8, -10, -11, -12, -13, -14, -16, -17, -17, -18, -19, -20, -21, -22, -23,
-23, -24, -25, -24, -25, -26, -26, -27, -26, -27, -27, -27, -28, -28, -28, -27,
-28, -28, -28, -27, -27, -27, -27, -27, -26, -26, -26, -25, -24, -24, -24, -22,
-21, -21, -20, -20, -18, -17, -17, -15, -13, -13, -12, -10, -10, -8, -7, -6, -4,
-4, -1, -1, 0, 2, 4, 5, 6, 8, 9, 11, 12, 13, 16, 16, 18, 20, 21, 22, 25, 26, 28,
29, 29, 31, 32, 33, 35, 36, 37, 39, 40, 41, 43, 44, 44, 45, 47, 47, 48, 49, 50,
50, 52, 51, 53, 53, 54, 55, 55, 56, 57, 57, 58, 57, 58, 59, 58, 59, 59, 59, 60,
60, 60, 61, 59, 60, 59, 59, 59, 60, 59, 59, 59, 59, 58, 58, 57, 57, 56, 56, 55,
55, 55, 54, 54, 53, 52, 51, 50, 49, 49, 47, 47, 46, 45, 43, 42, 41, 41, 38, 38,
36, 35, 34, 32, 31, 30, 28, 27, 25, 23, 22, 21, 19, 16, 15, 14, 12, 11, 10, 7,
4, 3, 1, 0, -2, -4, -5, -7, -10, -12, -13, -15, -17, -19, -21, -22, -25, -26,
-28, -30, -32, -34, -36, -38, -39, -43, -44, -46, -48, -49, -52, -54, -55, -57,
-60, -62, -64, -65, -67, -68, -70, -72, -74, -75, -77, -79, -81, -83, -85, -86,
-87, -90, -90, -92, -94, -95, -96, -98, -99, -101, -102, -103, -104, -105, -106,
-107, -109, -110, -111, -111, -112, -113, -114, -114, -115, -115, -116, -117,
-117, -117, -118, -118, -118, -119, -118, -119, -119, -119, -119, -118, -119,
-119, -118, -118, -118, -117, -117, -116, -116, -115, -115, -115, -114, -113,
-112, -112, -111, -110, -109, -108, -107, -106, -105, -104, -104, -102, -101,
-100, -99, -97, -96, -94, -93, -92, -91, -89, -87, -86, -85, -83, -81, -79, -78,
-76, -75, -72, -71, -70, -67, -65, -64, -61, -59, -58, -57, -54, -52, -50, -49,
-47, -46, -43, -41, -39, -37, -35, -33, -31, -29, -28, -25, -23, -22, -21, -18,
-16, -14, -11, -10, -8, -5, -3, -1, };