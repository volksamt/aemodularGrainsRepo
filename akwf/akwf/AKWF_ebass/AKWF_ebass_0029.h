#define DATA_LENGTH 512
#define DATA AKWF_ebass_0029

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 6, 8, 11, 13, 15, 18, 20, 22,
25, 28, 30, 33, 35, 38, 41, 44, 47, 49, 52, 55, 57, 59, 62, 65, 67, 70, 73, 75,
78, 80, 83, 84, 87, 89, 92, 94, 96, 99, 100, 102, 104, 106, 108, 108, 110, 112,
112, 114, 115, 116, 117, 118, 118, 118, 119, 120, 119, 119, 118, 117, 117, 116,
115, 114, 113, 111, 108, 107, 104, 102, 99, 97, 94, 90, 87, 84, 80, 76, 73, 69,
65, 61, 56, 53, 49, 43, 39, 35, 32, 27, 23, 20, 15, 12, 8, 4, 0, -4, -8, -11,
-14, -17, -20, -23, -26, -30, -31, -34, -36, -40, -42, -44, -46, -48, -51, -52,
-54, -56, -59, -61, -64, -65, -67, -70, -73, -75, -77, -79, -82, -84, -86, -90,
-91, -93, -96, -98, -100, -102, -104, -106, -108, -109, -111, -113, -114, -115,
-115, -116, -117, -117, -117, -118, -117, -117, -116, -114, -114, -113, -111,
-110, -108, -106, -104, -101, -99, -96, -94, -92, -89, -86, -82, -79, -76, -74,
-70, -67, -64, -59, -56, -52, -49, -45, -41, -37, -34, -30, -25, -22, -18, -13,
-9, -6, -2, 2, 7, 10, 13, 17, 21, 25, 28, 32, 34, 38, 42, 45, 48, 50, 53, 55,
58, 61, 62, 65, 66, 68, 69, 72, 72, 74, 75, 75, 77, 77, 77, 78, 78, 78, 77, 77,
76, 77, 76, 75, 74, 74, 72, 71, 70, 69, 68, 66, 65, 63, 61, 61, 58, 57, 56, 55,
53, 51, 49, 49, 47, 45, 43, 42, 41, 40, 39, 37, 36, 33, 33, 31, 30, 28, 26, 25,
24, 22, 20, 19, 17, 14, 13, 11, 9, 7, 4, 1, -1, -3, -5, -9, -11, -14, -17, -19,
-22, -26, -30, -33, -36, -39, -42, -45, -47, -51, -54, -57, -60, -63, -66, -69,
-71, -75, -77, -79, -82, -84, -85, -87, -90, -91, -93, -95, -96, -97, -98, -99,
-99, -99, -100, -99, -100, -100, -98, -98, -98, -97, -96, -95, -94, -91, -89,
-89, -87, -84, -82, -80, -78, -75, -73, -70, -67, -65, -62, -60, -57, -54, -51,
-49, -46, -43, -41, -38, -35, -33, -30, -27, -24, -22, -20, -16, -14, -11, -9,
-7, -4, -2, 1, 3, 6, 8, 11, 13, 16, 19, 21, 23, 26, 28, 31, 32, 35, 37, 39, 41,
43, 45, 46, 48, 49, 51, 53, 54, 55, 56, 57, 57, 59, 59, 60, 60, 61, 60, 60, 59,
59, 58, 57, 56, 55, 55, 53, 52, 52, 50, 48, 46, 45, 42, 42, 39, 37, 35, 32, 31,
28, 26, 24, 22, 19, 17, 14, 13, 10, 8, 6, 4, 1, -1, -3, -6, -8, -10, -12, -14,
-17, -18, -20, -21, -24, -26, -27, -29, -31, -31, -33, -34, -35, -37, -38, -38,
-40, -40, -41, -42, -43, -43, -43, -43, -43, -43, -43, -42, -42, -41, -42, -41,
-40, -39, -38, -37, -36, -35, -34, -33, -31, -30, -29, -27, -26, -25, -24, -21,
-20, -19, -16, -16, -12, -11, -9, -8, -6, -4, -2, };