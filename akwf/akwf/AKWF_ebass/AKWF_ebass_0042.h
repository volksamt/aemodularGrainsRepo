#define DATA_LENGTH 512
#define DATA AKWF_ebass_0042

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 12, 15, 18, 21, 24, 26, 29,
31, 33, 36, 37, 39, 41, 43, 45, 46, 48, 50, 52, 54, 55, 57, 59, 61, 62, 64, 66,
68, 70, 71, 74, 76, 77, 79, 81, 83, 85, 86, 89, 90, 93, 94, 96, 97, 99, 101,
102, 104, 106, 107, 109, 109, 111, 112, 114, 114, 115, 115, 117, 117, 117, 116,
118, 117, 117, 117, 117, 116, 115, 115, 114, 113, 112, 111, 111, 109, 108, 107,
106, 104, 103, 101, 100, 98, 96, 94, 93, 91, 88, 87, 84, 83, 81, 78, 76, 74, 72,
68, 66, 64, 61, 57, 56, 53, 50, 48, 45, 42, 40, 37, 35, 31, 30, 27, 24, 22, 19,
17, 15, 13, 10, 9, 7, 5, 3, 3, 1, 0, -1, -2, -4, -3, -4, -6, -6, -6, -7, -8, -8,
-8, -9, -9, -9, -9, -9, -9, -10, -10, -11, -10, -11, -11, -11, -12, -11, -11,
-12, -12, -12, -13, -13, -13, -13, -14, -14, -15, -14, -15, -16, -15, -16, -17,
-17, -16, -17, -17, -17, -18, -17, -17, -17, -16, -17, -17, -17, -16, -16, -16,
-15, -15, -15, -15, -14, -14, -13, -13, -13, -12, -12, -13, -12, -12, -12, -12,
-12, -11, -11, -11, -12, -13, -13, -13, -12, -13, -13, -14, -13, -14, -13, -13,
-13, -12, -12, -12, -12, -11, -10, -11, -10, -10, -9, -10, -8, -9, -8, -8, -8,
-8, -7, -7, -7, -7, -6, -6, -6, -6, -5, -6, -6, -6, -6, -6, -7, -8, -8, -9, -8,
-8, -9, -9, -10, -10, -10, -11, -11, -12, -12, -12, -11, -13, -12, -12, -13,
-13, -13, -13, -13, -13, -13, -12, -12, -12, -12, -12, -11, -11, -11, -11, -10,
-11, -11, -10, -11, -10, -10, -10, -10, -10, -12, -11, -11, -11, -12, -12, -11,
-11, -12, -11, -11, -11, -12, -12, -12, -12, -12, -13, -13, -13, -13, -14, -14,
-14, -15, -16, -15, -14, -15, -16, -14, -15, -15, -15, -15, -15, -15, -15, -15,
-15, -16, -15, -16, -17, -17, -17, -17, -17, -18, -19, -18, -18, -18, -19, -19,
-20, -20, -21, -22, -22, -23, -23, -23, -23, -23, -23, -24, -25, -25, -26, -26,
-27, -26, -26, -27, -28, -28, -29, -28, -28, -29, -29, -31, -31, -31, -32, -33,
-33, -34, -35, -34, -36, -36, -37, -38, -39, -40, -40, -40, -41, -42, -43, -43,
-45, -44, -46, -47, -47, -50, -50, -51, -52, -53, -54, -56, -57, -58, -59, -61,
-63, -64, -65, -67, -68, -70, -72, -74, -76, -78, -80, -82, -83, -85, -87, -89,
-91, -93, -94, -96, -97, -99, -101, -102, -104, -106, -107, -108, -110, -111,
-112, -114, -113, -115, -116, -116, -118, -118, -119, -119, -119, -119, -119,
-118, -119, -118, -117, -117, -117, -116, -115, -114, -114, -111, -111, -110,
-108, -105, -103, -102, -99, -98, -95, -93, -89, -86, -83, -82, -78, -75, -72,
-68, -66, -63, -59, -56, -53, -50, -46, -42, -40, -36, -33, -29, -25, -22, -19,
-15, -11, -7, -4, -1, };