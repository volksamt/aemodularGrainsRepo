#define DATA_LENGTH 512
#define DATA AKWF_ebass_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 9, 11, 14, 18, 21, 23, 27,
30, 33, 35, 39, 42, 45, 47, 50, 52, 55, 57, 58, 61, 63, 65, 67, 69, 70, 71, 73,
73, 74, 74, 76, 76, 76, 76, 76, 76, 75, 76, 74, 73, 73, 72, 71, 69, 68, 67, 66,
63, 63, 61, 58, 57, 55, 53, 51, 49, 47, 46, 44, 42, 41, 39, 38, 36, 34, 33, 32,
30, 29, 30, 28, 27, 27, 26, 27, 26, 27, 27, 26, 28, 27, 29, 29, 30, 31, 33, 33,
35, 36, 37, 38, 41, 41, 42, 44, 46, 48, 49, 50, 52, 53, 54, 55, 57, 58, 59, 59,
61, 60, 61, 62, 63, 63, 63, 63, 62, 61, 62, 62, 62, 61, 61, 60, 60, 59, 58, 59,
57, 58, 57, 57, 57, 56, 57, 56, 56, 56, 57, 56, 56, 57, 57, 58, 59, 60, 59, 61,
62, 63, 64, 66, 67, 68, 70, 72, 73, 76, 78, 80, 82, 84, 86, 87, 89, 90, 92, 93,
94, 94, 94, 95, 95, 96, 95, 94, 93, 92, 91, 89, 88, 85, 82, 80, 77, 74, 72, 68,
65, 63, 60, 58, 55, 52, 49, 47, 45, 42, 39, 37, 36, 34, 31, 30, 28, 27, 24, 22,
22, 20, 19, 18, 16, 14, 13, 12, 12, 10, 9, 8, 7, 5, 4, 2, 2, 1, 0, -1, -3, -3,
-4, -4, -4, -6, -5, -6, -7, -6, -7, -7, -7, -7, -7, -6, -6, -7, -5, -5, -4, -4,
-2, -2, -2, 0, 1, 3, 4, 5, 7, 7, 10, 11, 12, 14, 15, 17, 18, 20, 21, 23, 24, 26,
27, 28, 30, 31, 32, 32, 34, 36, 36, 36, 36, 37, 37, 37, 38, 37, 37, 35, 36, 35,
34, 33, 31, 30, 28, 26, 24, 22, 19, 17, 14, 12, 8, 5, 1, -2, -6, -8, -13, -16,
-20, -25, -28, -32, -36, -41, -44, -48, -52, -55, -60, -64, -68, -72, -75, -79,
-82, -85, -88, -91, -95, -96, -99, -101, -104, -106, -108, -110, -111, -113,
-115, -115, -116, -117, -118, -119, -119, -119, -119, -119, -119, -119, -118,
-118, -117, -116, -115, -114, -113, -112, -110, -109, -108, -107, -106, -104,
-102, -101, -99, -97, -96, -95, -93, -91, -91, -88, -87, -86, -85, -83, -83,
-81, -79, -78, -78, -76, -75, -74, -72, -72, -71, -69, -69, -68, -67, -66, -66,
-64, -64, -63, -63, -63, -62, -61, -61, -60, -59, -59, -59, -59, -58, -58, -57,
-57, -56, -56, -56, -56, -55, -55, -54, -54, -53, -53, -53, -52, -51, -51, -51,
-51, -50, -50, -49, -48, -47, -47, -47, -46, -47, -45, -46, -46, -46, -46, -46,
-46, -47, -46, -47, -48, -47, -48, -49, -48, -48, -49, -49, -50, -50, -50, -51,
-51, -51, -52, -52, -53, -52, -52, -52, -52, -52, -52, -52, -52, -52, -51, -51,
-50, -50, -50, -48, -48, -48, -47, -46, -46, -44, -44, -42, -41, -39, -38, -35,
-34, -33, -30, -29, -27, -25, -22, -20, -18, -16, -12, -10, -7, -6, -2, };