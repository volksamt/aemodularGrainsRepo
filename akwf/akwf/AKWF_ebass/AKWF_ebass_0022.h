#define DATA_LENGTH 512
#define DATA AKWF_ebass_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 8, 9, 10, 11, 11, 12, 13, 14,
15, 16, 18, 19, 21, 22, 24, 25, 27, 28, 28, 28, 28, 27, 27, 29, 30, 32, 34, 36,
37, 39, 40, 41, 41, 43, 44, 45, 45, 45, 45, 43, 43, 42, 42, 41, 43, 45, 46, 47,
48, 48, 48, 48, 48, 48, 49, 47, 45, 44, 43, 43, 42, 42, 43, 45, 44, 45, 44, 44,
44, 43, 43, 43, 42, 41, 41, 38, 38, 36, 36, 36, 35, 35, 35, 35, 35, 35, 35, 36,
38, 38, 39, 38, 37, 36, 32, 29, 26, 24, 23, 24, 23, 24, 24, 24, 24, 24, 24, 24,
23, 23, 21, 18, 17, 14, 15, 16, 15, 16, 18, 18, 21, 20, 20, 21, 20, 19, 18, 16,
14, 12, 10, 10, 10, 11, 10, 13, 13, 12, 11, 10, 8, 7, 6, 7, 7, 8, 9, 7, 6, 4, 4,
3, 2, 1, 1, 0, 0, -1, -1, -1, 0, 0, 0, 0, -1, -4, -5, -8, -9, -11, -11, -9, -9,
-8, -6, -6, -5, -4, -4, -4, -5, -5, -7, -8, -8, -10, -9, -9, -9, -8, -8, -8, -7,
-10, -10, -12, -11, -13, -12, -12, -12, -12, -12, -11, -11, -9, -8, -7, -6, -5,
-5, -5, -6, -6, -5, -3, -1, 2, 3, 5, 6, 6, 5, 5, 5, 5, 6, 7, 9, 10, 12, 13, 15,
16, 17, 17, 17, 16, 16, 15, 14, 14, 15, 17, 18, 20, 20, 22, 22, 21, 21, 20, 19,
19, 18, 16, 14, 14, 12, 13, 15, 18, 20, 23, 23, 22, 21, 19, 17, 13, 11, 9, 8, 7,
6, 6, 4, 3, 2, 0, 1, 1, -1, -1, -3, -6, -8, -9, -11, -12, -14, -15, -15, -14,
-16, -15, -15, -14, -13, -11, -11, -10, -12, -13, -16, -17, -19, -21, -23, -24,
-27, -29, -31, -32, -32, -30, -27, -23, -21, -16, -14, -13, -13, -14, -16, -16,
-17, -17, -14, -13, -10, -7, -4, -1, 1, 6, 10, 15, 19, 21, 23, 24, 24, 25, 25,
28, 30, 32, 34, 38, 40, 42, 43, 44, 47, 49, 51, 52, 53, 51, 51, 51, 51, 52, 51,
54, 57, 59, 60, 62, 64, 66, 69, 72, 76, 79, 82, 82, 82, 79, 77, 77, 74, 70, 69,
66, 64, 61, 58, 57, 55, 54, 53, 50, 48, 44, 38, 32, 25, 19, 14, 10, 6, 2, -2,
-5, -10, -13, -17, -21, -26, -30, -33, -37, -41, -45, -49, -51, -54, -55, -58,
-60, -63, -66, -70, -73, -76, -79, -83, -85, -88, -91, -94, -96, -97, -99, -101,
-102, -104, -108, -111, -114, -116, -118, -119, -119, -118, -117, -116, -114,
-113, -112, -111, -110, -109, -108, -107, -105, -105, -103, -103, -102, -100,
-100, -97, -96, -94, -92, -90, -90, -86, -85, -82, -80, -78, -76, -76, -74, -72,
-70, -67, -64, -62, -59, -58, -56, -54, -51, -49, -45, -42, -38, -34, -32, -30,
-29, -27, -27, -25, -24, -22, -22, -19, -17, -14, -11, -8, -5, -1, };