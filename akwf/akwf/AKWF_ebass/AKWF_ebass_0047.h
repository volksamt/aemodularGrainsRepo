#define DATA_LENGTH 512
#define DATA AKWF_ebass_0047

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 6, 8, 10, 11, 13, 15, 16, 19,
20, 22, 23, 25, 24, 27, 27, 28, 29, 30, 31, 32, 32, 33, 33, 33, 34, 33, 34, 35,
35, 33, 34, 34, 34, 34, 34, 34, 32, 32, 33, 32, 32, 32, 31, 30, 30, 30, 30, 29,
29, 28, 29, 27, 27, 26, 26, 25, 23, 23, 23, 21, 20, 20, 19, 18, 18, 16, 15, 15,
13, 13, 12, 11, 11, 9, 8, 7, 7, 6, 5, 5, 3, 3, 2, 1, 1, 0, 0, -2, -1, -2, -2,
-3, -3, -4, -5, -6, -6, -6, -7, -7, -7, -8, -8, -9, -9, -10, -10, -11, -11, -12,
-12, -13, -12, -14, -13, -14, -14, -14, -14, -14, -14, -14, -14, -15, -14, -14,
-14, -14, -13, -13, -13, -12, -12, -12, -11, -11, -10, -10, -8, -7, -8, -7, -5,
-5, -4, -4, -2, -2, -1, -1, 0, 1, 2, 2, 4, 4, 4, 5, 6, 5, 7, 7, 6, 8, 9, 8, 10,
10, 11, 11, 11, 13, 13, 13, 15, 15, 16, 16, 18, 18, 19, 19, 19, 19, 21, 21, 22,
21, 22, 22, 22, 21, 22, 21, 22, 21, 21, 21, 20, 19, 19, 18, 16, 15, 15, 14, 13,
12, 12, 10, 9, 9, 6, 6, 5, 4, 3, 3, 1, 1, -1, -2, -3, -4, -6, -7, -7, -9, -9,
-11, -12, -13, -14, -15, -15, -18, -18, -21, -21, -22, -25, -25, -26, -29, -29,
-30, -32, -34, -35, -36, -37, -38, -39, -40, -41, -42, -42, -44, -43, -44, -44,
-46, -45, -46, -46, -46, -46, -46, -46, -47, -46, -46, -47, -46, -47, -47, -46,
-46, -47, -46, -46, -46, -46, -46, -46, -46, -45, -45, -45, -45, -45, -45, -44,
-44, -42, -42, -42, -41, -41, -40, -40, -39, -38, -39, -37, -37, -36, -36, -33,
-34, -32, -32, -32, -30, -30, -29, -28, -28, -27, -26, -26, -25, -26, -24, -24,
-23, -23, -22, -23, -23, -22, -22, -21, -22, -22, -22, -22, -22, -21, -20, -21,
-21, -20, -20, -21, -20, -20, -21, -20, -20, -20, -20, -20, -20, -21, -21, -21,
-22, -22, -22, -24, -24, -26, -25, -27, -27, -28, -30, -31, -32, -33, -35, -35,
-36, -38, -39, -39, -42, -43, -44, -45, -46, -48, -49, -51, -52, -52, -54, -56,
-58, -59, -59, -62, -64, -66, -67, -68, -70, -72, -74, -76, -78, -80, -82, -83,
-85, -87, -89, -90, -93, -95, -96, -98, -99, -101, -102, -104, -105, -108, -109,
-111, -110, -111, -113, -114, -114, -115, -116, -117, -117, -117, -117, -118,
-119, -118, -119, -118, -119, -119, -119, -119, -119, -118, -118, -118, -118,
-117, -117, -117, -117, -117, -116, -115, -114, -113, -113, -111, -110, -109,
-108, -106, -103, -103, -101, -98, -97, -95, -94, -90, -88, -85, -84, -82, -79,
-77, -74, -72, -69, -67, -65, -63, -60, -57, -54, -53, -49, -48, -45, -42, -41,
-39, -37, -34, -32, -30, -27, -26, -23, -21, -19, -17, -15, -13, -11, -8, -7,
-5, -4, 0, };