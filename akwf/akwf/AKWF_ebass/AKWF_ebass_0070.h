#define DATA_LENGTH 512
#define DATA AKWF_ebass_0070

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 8, 10, 12, 13, 15, 17, 20,
21, 23, 25, 27, 28, 31, 32, 33, 36, 37, 39, 41, 42, 43, 45, 46, 47, 49, 49, 51,
52, 53, 55, 56, 57, 58, 59, 60, 61, 62, 63, 64, 63, 66, 65, 66, 67, 68, 68, 68,
69, 71, 71, 72, 71, 72, 72, 73, 73, 73, 73, 74, 74, 74, 74, 75, 74, 75, 76, 75,
75, 75, 76, 76, 76, 75, 75, 75, 75, 75, 75, 75, 75, 75, 76, 75, 75, 75, 76, 76,
76, 76, 76, 76, 77, 76, 78, 78, 77, 78, 79, 79, 79, 80, 80, 80, 81, 82, 82, 82,
83, 84, 83, 84, 84, 85, 86, 85, 86, 87, 88, 88, 87, 88, 89, 89, 89, 90, 90, 91,
90, 91, 91, 91, 92, 92, 92, 93, 92, 92, 93, 92, 92, 92, 92, 92, 92, 92, 91, 90,
90, 90, 89, 88, 88, 86, 86, 85, 84, 83, 82, 80, 79, 79, 77, 76, 75, 74, 72, 70,
69, 66, 65, 64, 62, 60, 58, 56, 54, 52, 50, 48, 46, 44, 42, 40, 38, 36, 34, 31,
29, 27, 25, 23, 20, 20, 17, 15, 13, 12, 8, 7, 6, 3, 2, 0, -2, -3, -5, -6, -7,
-8, -9, -10, -11, -12, -13, -13, -14, -14, -15, -15, -15, -15, -16, -16, -17,
-16, -16, -17, -16, -17, -16, -17, -17, -16, -17, -17, -17, -18, -18, -19, -18,
-19, -20, -20, -21, -22, -22, -22, -23, -23, -24, -25, -26, -27, -28, -27, -29,
-29, -31, -32, -32, -33, -35, -36, -36, -37, -38, -40, -40, -42, -42, -43, -45,
-46, -47, -47, -49, -50, -51, -53, -53, -56, -56, -57, -58, -60, -61, -62, -63,
-65, -65, -67, -69, -70, -71, -72, -74, -75, -76, -77, -79, -80, -81, -82, -83,
-84, -86, -86, -88, -89, -90, -91, -92, -92, -94, -95, -95, -97, -98, -99, -100,
-101, -101, -103, -104, -104, -106, -106, -107, -108, -109, -109, -110, -111,
-111, -112, -113, -113, -114, -114, -115, -116, -116, -116, -115, -116, -118,
-117, -118, -119, -117, -119, -119, -119, -118, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -118, -118, -117, -116, -117, -116,
-115, -116, -115, -115, -114, -113, -113, -112, -112, -112, -110, -110, -109,
-109, -108, -108, -106, -105, -105, -103, -102, -101, -100, -99, -98, -98, -95,
-95, -93, -92, -91, -90, -88, -87, -86, -85, -84, -82, -81, -80, -78, -77, -76,
-74, -73, -72, -71, -69, -68, -66, -65, -64, -62, -61, -60, -59, -57, -56, -55,
-54, -53, -52, -50, -50, -49, -49, -47, -45, -45, -45, -44, -43, -42, -41, -41,
-40, -40, -39, -39, -38, -38, -37, -37, -36, -37, -36, -36, -36, -36, -36, -35,
-36, -36, -35, -35, -35, -34, -34, -33, -33, -32, -32, -32, -32, -31, -32, -31,
-30, -30, -30, -29, -29, -29, -27, -27, -26, -25, -25, -24, -23, -22, -21, -19,
-18, -18, -16, -14, -14, -13, -11, -9, -9, -6, -4, -2, -1, };