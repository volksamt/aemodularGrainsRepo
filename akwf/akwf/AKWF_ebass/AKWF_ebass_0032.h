#define DATA_LENGTH 512
#define DATA AKWF_ebass_0032

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 13, 15, 18, 20, 22, 23, 25,
24, 24, 25, 25, 23, 23, 22, 21, 19, 18, 18, 18, 19, 19, 20, 22, 24, 25, 29, 32,
36, 38, 43, 46, 50, 54, 57, 60, 63, 67, 71, 74, 78, 80, 84, 87, 90, 92, 96, 97,
100, 102, 104, 105, 106, 108, 109, 111, 112, 113, 114, 115, 117, 117, 119, 119,
119, 119, 119, 118, 118, 116, 115, 114, 112, 110, 108, 106, 102, 99, 96, 91, 87,
83, 79, 74, 70, 67, 62, 59, 55, 53, 49, 48, 45, 42, 39, 37, 33, 30, 26, 24, 19,
15, 11, 7, 3, -2, -6, -10, -13, -18, -21, -26, -30, -33, -36, -40, -43, -44,
-47, -49, -50, -52, -52, -53, -53, -55, -55, -55, -56, -57, -56, -57, -57, -58,
-58, -58, -58, -57, -56, -55, -56, -54, -54, -54, -55, -54, -55, -54, -54, -53,
-51, -50, -49, -46, -45, -44, -42, -40, -38, -36, -34, -33, -31, -31, -30, -28,
-28, -26, -26, -24, -24, -22, -20, -18, -17, -16, -13, -12, -10, -7, -6, -2, 2,
4, 8, 14, 18, 22, 27, 31, 35, 40, 43, 45, 48, 49, 51, 51, 52, 52, 53, 53, 52,
52, 51, 50, 48, 48, 46, 44, 42, 40, 39, 38, 37, 35, 35, 34, 34, 34, 34, 34, 35,
34, 35, 35, 37, 36, 37, 37, 36, 35, 36, 34, 35, 34, 32, 31, 30, 28, 25, 24, 21,
19, 16, 15, 13, 11, 9, 9, 8, 5, 5, 4, 4, 3, 3, 2, 1, 0, -1, 0, 0, -1, 0, -1, 0,
1, 1, 1, 1, 1, 2, 2, 2, 1, 1, 1, 1, 1, 1, 2, 2, 0, 1, 1, 1, 1, 0, 0, -2, -4, -5,
-6, -9, -11, -12, -15, -17, -20, -22, -25, -28, -30, -33, -36, -37, -39, -42,
-44, -46, -48, -48, -50, -51, -51, -52, -52, -53, -53, -52, -51, -50, -49, -47,
-46, -45, -44, -42, -40, -38, -38, -36, -35, -33, -32, -31, -30, -28, -27, -26,
-24, -22, -21, -19, -18, -16, -16, -16, -14, -14, -13, -13, -13, -12, -12, -12,
-12, -12, -13, -14, -15, -16, -17, -19, -19, -22, -23, -25, -27, -29, -30, -32,
-34, -34, -37, -39, -40, -42, -43, -45, -46, -47, -48, -50, -50, -52, -53, -54,
-55, -56, -57, -58, -59, -60, -61, -62, -62, -63, -63, -63, -64, -64, -64, -63,
-62, -61, -60, -59, -56, -54, -52, -48, -45, -43, -41, -37, -33, -30, -27, -24,
-22, -19, -17, -16, -14, -13, -12, -13, -12, -14, -16, -17, -18, -20, -22, -25,
-28, -31, -35, -37, -42, -45, -49, -53, -57, -61, -65, -70, -74, -78, -82, -87,
-90, -94, -98, -99, -103, -105, -107, -108, -109, -110, -110, -111, -112, -112,
-112, -111, -112, -111, -111, -109, -108, -107, -105, -104, -102, -102, -99,
-98, -95, -94, -91, -89, -86, -83, -81, -78, -76, -73, -69, -66, -63, -60, -56,
-54, -51, -47, -43, -40, -36, -32, -28, -24, -20, -15, -10, -6, -1, };