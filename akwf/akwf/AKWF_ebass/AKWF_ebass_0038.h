#define DATA_LENGTH 512
#define DATA AKWF_ebass_0038

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 12, 15, 18, 22, 25, 28, 30,
33, 35, 38, 40, 42, 45, 46, 49, 51, 53, 54, 56, 58, 59, 61, 62, 65, 66, 67, 68,
71, 72, 74, 75, 76, 79, 80, 82, 84, 85, 87, 88, 90, 91, 93, 95, 96, 97, 99, 102,
102, 104, 105, 107, 108, 110, 110, 111, 112, 113, 114, 115, 116, 116, 117, 118,
117, 118, 118, 118, 119, 118, 118, 118, 118, 117, 117, 116, 115, 114, 114, 112,
111, 111, 109, 108, 105, 103, 103, 101, 99, 97, 94, 93, 90, 87, 85, 83, 80, 78,
74, 72, 69, 66, 64, 61, 58, 56, 52, 50, 48, 45, 42, 41, 38, 36, 33, 30, 28, 26,
24, 22, 19, 17, 16, 14, 12, 9, 8, 6, 6, 4, 2, 1, 1, 0, -2, -3, -2, -4, -5, -6,
-7, -7, -7, -7, -8, -8, -8, -10, -10, -9, -9, -9, -10, -10, -9, -11, -10, -10,
-10, -10, -10, -11, -9, -9, -10, -9, -10, -9, -8, -9, -9, -9, -8, -9, -9, -8,
-8, -9, -8, -7, -8, -7, -7, -8, -7, -7, -7, -6, -6, -6, -6, -6, -6, -6, -5, -5,
-5, -5, -4, -5, -4, -4, -4, -4, -3, -3, -2, -3, -3, -4, -3, -3, -2, -3, -2, -4,
-3, -3, -4, -3, -4, -3, -4, -4, -4, -4, -3, -4, -4, -4, -4, -5, -5, -5, -5, -6,
-7, -6, -7, -7, -6, -7, -6, -7, -7, -6, -7, -7, -7, -7, -8, -7, -8, -8, -8, -8,
-8, -9, -8, -9, -9, -9, -10, -10, -10, -11, -11, -11, -12, -12, -13, -12, -12,
-13, -14, -14, -14, -14, -14, -14, -16, -15, -15, -16, -15, -16, -16, -16, -16,
-17, -16, -16, -17, -17, -17, -17, -17, -18, -17, -18, -18, -18, -18, -18, -19,
-18, -20, -19, -19, -19, -19, -20, -20, -21, -20, -21, -20, -21, -21, -22, -22,
-23, -23, -24, -24, -25, -24, -25, -25, -25, -25, -26, -26, -25, -26, -26, -26,
-25, -26, -25, -25, -26, -25, -25, -26, -25, -26, -25, -25, -25, -26, -24, -25,
-25, -26, -26, -25, -26, -26, -26, -27, -27, -27, -27, -28, -28, -28, -29, -29,
-29, -29, -30, -30, -29, -31, -31, -31, -32, -32, -33, -33, -33, -34, -34, -35,
-36, -36, -38, -38, -39, -39, -40, -42, -43, -42, -44, -44, -45, -46, -47, -47,
-47, -49, -50, -51, -52, -53, -53, -53, -55, -56, -57, -58, -58, -60, -61, -62,
-63, -66, -66, -68, -69, -71, -72, -74, -75, -77, -78, -80, -82, -83, -85, -86,
-89, -90, -91, -93, -95, -96, -98, -99, -100, -102, -104, -105, -106, -107,
-108, -110, -111, -112, -112, -113, -113, -115, -116, -116, -117, -117, -117,
-119, -119, -118, -119, -119, -119, -118, -119, -118, -117, -117, -115, -115,
-113, -111, -110, -108, -106, -104, -102, -100, -97, -94, -90, -88, -85, -82,
-79, -75, -73, -69, -65, -62, -59, -55, -51, -47, -45, -40, -37, -34, -30, -25,
-22, -18, -15, -11, -8, -5, -1, };