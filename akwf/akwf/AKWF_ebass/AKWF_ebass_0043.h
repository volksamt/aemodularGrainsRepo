#define DATA_LENGTH 512
#define DATA AKWF_ebass_0043

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 11, 14, 15, 17, 20, 23, 27, 29,
34, 38, 43, 50, 56, 62, 68, 73, 77, 80, 82, 84, 83, 84, 84, 85, 85, 85, 87, 88,
90, 92, 94, 95, 98, 101, 103, 106, 107, 108, 110, 110, 110, 110, 111, 109, 108,
108, 107, 107, 108, 108, 108, 109, 107, 105, 101, 96, 90, 85, 79, 72, 67, 62,
59, 56, 54, 51, 52, 52, 53, 53, 52, 51, 48, 44, 38, 32, 26, 20, 14, 8, 4, 0, -2,
-4, -5, -7, -9, -10, -11, -15, -18, -21, -24, -27, -30, -32, -35, -37, -38, -38,
-38, -39, -39, -43, -45, -48, -51, -54, -57, -60, -62, -63, -63, -63, -61, -57,
-55, -51, -46, -42, -36, -30, -26, -22, -20, -18, -19, -20, -22, -25, -26, -29,
-29, -29, -26, -21, -16, -8, -1, 6, 13, 21, 26, 29, 34, 35, 37, 36, 35, 35, 35,
35, 38, 40, 44, 47, 50, 53, 57, 60, 62, 62, 63, 63, 62, 62, 62, 64, 65, 67, 70,
72, 75, 78, 79, 80, 81, 81, 78, 75, 71, 66, 62, 56, 51, 47, 44, 41, 40, 38, 39,
40, 42, 45, 46, 48, 48, 46, 41, 36, 30, 22, 15, 9, 4, 0, -3, -4, -5, -2, 0, 3,
6, 7, 9, 8, 5, 1, -3, -8, -12, -17, -21, -23, -25, -25, -24, -23, -21, -19, -19,
-21, -24, -26, -30, -33, -36, -38, -39, -40, -40, -38, -35, -29, -24, -18, -12,
-7, -2, 2, 7, 11, 13, 14, 15, 13, 10, 8, 7, 6, 7, 7, 10, 14, 19, 25, 32, 38, 44,
47, 50, 50, 48, 45, 42, 37, 33, 29, 27, 26, 28, 31, 35, 37, 39, 41, 40, 38, 36,
32, 28, 23, 20, 16, 14, 13, 10, 8, 6, 3, 0, -4, -6, -10, -13, -18, -24, -31,
-39, -48, -56, -62, -71, -78, -84, -88, -93, -93, -93, -92, -89, -87, -86, -86,
-89, -91, -94, -98, -103, -108, -113, -117, -119, -119, -118, -117, -114, -111,
-108, -103, -98, -93, -90, -86, -83, -81, -79, -78, -75, -73, -71, -69, -66,
-63, -61, -56, -52, -47, -42, -39, -35, -31, -27, -23, -19, -15, -12, -9, -4, 0,
5, 10, 14, 19, 24, 28, 33, 37, 41, 44, 48, 50, 52, 54, 53, 53, 53, 51, 51, 50,
50, 50, 48, 47, 47, 46, 45, 44, 41, 39, 36, 31, 26, 21, 16, 11, 7, 5, 2, 1, -1,
-3, -3, -5, -5, -4, -6, -8, -9, -12, -15, -17, -21, -23, -26, -28, -31, -34,
-36, -38, -40, -40, -42, -42, -44, -45, -46, -46, -49, -51, -54, -56, -59, -62,
-65, -67, -70, -72, -72, -72, -72, -72, -69, -68, -69, -68, -69, -70, -71, -73,
-76, -79, -82, -85, -86, -86, -86, -85, -83, -81, -79, -77, -75, -73, -72, -71,
-72, -72, -73, -75, -76, -76, -77, -77, -76, -77, -76, -76, -75, -72, -71, -67,
-64, -60, -55, -49, -45, -41, -39, -36, -34, -31, -28, -25, -21, -18, -14, -9,
-6, -2, };