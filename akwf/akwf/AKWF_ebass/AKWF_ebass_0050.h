#define DATA_LENGTH 512
#define DATA AKWF_ebass_0050

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 6, 10, 12, 17, 21, 23, 27, 29,
33, 38, 41, 43, 45, 45, 43, 44, 45, 48, 51, 54, 56, 57, 58, 58, 56, 55, 54, 54,
54, 55, 55, 56, 55, 54, 54, 55, 56, 59, 59, 59, 59, 58, 58, 59, 60, 63, 64, 66,
66, 65, 63, 60, 60, 60, 60, 61, 62, 63, 62, 61, 59, 58, 59, 59, 62, 63, 64, 63,
61, 61, 60, 61, 62, 64, 65, 64, 62, 59, 57, 54, 54, 54, 56, 60, 61, 62, 63, 62,
61, 60, 62, 63, 63, 64, 64, 65, 65, 68, 68, 70, 70, 70, 68, 65, 63, 61, 59, 58,
59, 63, 65, 67, 68, 68, 66, 63, 61, 59, 58, 58, 58, 58, 58, 58, 59, 59, 60, 60,
59, 56, 55, 52, 51, 51, 51, 51, 53, 54, 55, 55, 56, 53, 50, 46, 44, 43, 42, 41,
40, 38, 37, 36, 35, 36, 34, 33, 30, 27, 25, 23, 21, 19, 17, 17, 16, 17, 19, 19,
17, 16, 14, 13, 11, 11, 11, 11, 10, 9, 10, 10, 11, 10, 10, 10, 8, 8, 7, 6, 5, 4,
4, 3, 4, 5, 5, 5, 5, 4, 3, 4, 4, 5, 4, 5, 5, 5, 6, 7, 8, 10, 10, 12, 13, 13, 14,
15, 15, 14, 15, 16, 19, 21, 24, 25, 25, 26, 25, 25, 24, 24, 25, 25, 26, 28, 29,
30, 30, 31, 32, 34, 34, 35, 35, 34, 32, 31, 30, 30, 33, 36, 38, 38, 38, 37, 36,
35, 35, 35, 34, 32, 29, 28, 28, 27, 26, 26, 27, 29, 29, 29, 27, 22, 17, 13, 11,
12, 13, 14, 14, 12, 11, 10, 10, 10, 10, 8, 7, 6, 3, 1, -1, -4, -7, -8, -9, -8,
-8, -11, -13, -16, -18, -18, -18, -19, -20, -21, -24, -26, -27, -28, -27, -26,
-26, -26, -28, -29, -32, -34, -38, -40, -42, -44, -45, -43, -39, -37, -34, -33,
-32, -32, -31, -31, -32, -34, -36, -39, -41, -43, -44, -45, -46, -48, -49, -49,
-47, -48, -49, -52, -52, -52, -50, -46, -42, -38, -35, -34, -33, -33, -32, -34,
-36, -39, -40, -42, -43, -44, -43, -45, -44, -43, -42, -41, -39, -41, -44, -46,
-47, -45, -44, -41, -39, -37, -37, -38, -38, -39, -39, -38, -38, -36, -33, -31,
-28, -26, -22, -21, -17, -14, -11, -12, -15, -21, -27, -32, -35, -35, -36, -36,
-38, -41, -43, -47, -49, -50, -51, -51, -52, -52, -54, -56, -58, -59, -60, -60,
-61, -62, -64, -68, -73, -77, -81, -83, -83, -83, -83, -82, -84, -87, -89, -91,
-91, -91, -91, -91, -92, -95, -97, -98, -100, -101, -104, -105, -106, -106,
-107, -109, -110, -111, -113, -111, -109, -109, -111, -113, -117, -119, -118,
-116, -112, -108, -104, -102, -98, -97, -95, -94, -93, -92, -87, -83, -77, -73,
-69, -65, -63, -59, -55, -50, -48, -48, -49, -49, -49, -47, -45, -42, -39, -36,
-33, -33, -31, -30, -28, -25, -21, -17, -12, -6, -3, 0, };