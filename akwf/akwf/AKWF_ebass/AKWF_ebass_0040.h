#define DATA_LENGTH 512
#define DATA AKWF_ebass_0040

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 8, 12, 15, 18, 21, 25, 27, 32,
36, 38, 43, 46, 50, 53, 56, 59, 63, 66, 69, 71, 74, 77, 80, 82, 85, 87, 89, 91,
93, 96, 97, 99, 100, 102, 102, 102, 105, 105, 105, 106, 106, 106, 107, 107, 106,
107, 106, 105, 104, 103, 103, 101, 99, 99, 96, 95, 92, 90, 89, 86, 83, 80, 79,
75, 72, 69, 66, 63, 60, 56, 54, 51, 49, 45, 43, 39, 37, 34, 32, 30, 27, 25, 23,
21, 20, 17, 16, 14, 12, 11, 10, 8, 8, 7, 5, 5, 4, 3, 1, 1, 1, 1, 0, -1, -1, -1,
-3, -3, -3, -3, -5, -5, -4, -5, -6, -5, -6, -5, -6, -5, -6, -6, -6, -6, -5, -5,
-5, -5, -5, -5, -4, -4, -5, -4, -3, -4, -4, -4, -3, -3, -2, -2, -1, -3, -2, -2,
-2, -1, -1, -1, -1, -1, -1, -2, -1, 0, -1, -1, -1, -1, -1, -2, -1, -1, -1, -1,
-1, -2, -1, -1, -1, -2, -2, -1, -2, -1, -2, -1, -1, -2, -2, -2, -3, -3, -3, -3,
-4, -4, -5, -6, -5, -5, -7, -6, -7, -8, -8, -8, -8, -8, -7, -9, -8, -8, -9, -8,
-9, -9, -10, -10, -9, -9, -10, -11, -11, -11, -11, -11, -11, -12, -13, -12, -12,
-13, -14, -13, -13, -13, -14, -14, -15, -16, -15, -16, -16, -16, -16, -17, -17,
-17, -16, -17, -17, -16, -16, -16, -17, -16, -15, -16, -16, -16, -17, -16, -17,
-16, -16, -17, -17, -18, -18, -18, -17, -18, -18, -17, -18, -18, -17, -17, -17,
-16, -16, -16, -16, -16, -15, -15, -15, -15, -14, -13, -12, -13, -13, -13, -12,
-11, -11, -11, -11, -12, -11, -11, -10, -9, -10, -9, -9, -9, -9, -8, -8, -7, -7,
-7, -5, -6, -5, -5, -5, -4, -4, -3, -3, -3, -3, -2, -1, -1, -1, -1, 0, 0, 0, 0,
0, 1, 1, 1, 1, 2, 1, 1, 1, 1, 1, 2, 2, 2, 2, 3, 3, 2, 4, 4, 5, 5, 5, 6, 7, 6, 6,
6, 7, 6, 6, 6, 5, 5, 5, 5, 3, 3, 3, 2, 1, 1, 1, 0, -1, -1, -1, -2, -2, -2, -3,
-3, -3, -4, -4, -4, -4, -5, -5, -5, -5, -6, -6, -7, -7, -8, -8, -9, -10, -9,
-10, -11, -11, -12, -12, -12, -14, -14, -14, -14, -15, -16, -16, -16, -17, -18,
-18, -19, -19, -21, -21, -23, -23, -25, -26, -28, -30, -32, -33, -35, -36, -39,
-41, -42, -45, -47, -50, -52, -56, -58, -61, -64, -67, -68, -72, -74, -76, -80,
-82, -84, -87, -90, -92, -93, -96, -98, -100, -103, -104, -107, -109, -110,
-111, -112, -113, -115, -115, -116, -117, -119, -118, -119, -120, -119, -119,
-118, -119, -117, -116, -115, -113, -112, -109, -107, -104, -101, -98, -94, -92,
-88, -84, -80, -76, -72, -67, -64, -59, -56, -51, -48, -44, -39, -36, -33, -30,
-27, -23, -19, -16, -13, -11, -7, -3, 0, };