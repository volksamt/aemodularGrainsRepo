#define DATA_LENGTH 512
#define DATA AKWF_ebass_0064

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 12, 15, 19, 23, 26, 29, 32, 36,
38, 41, 44, 46, 49, 51, 53, 55, 57, 59, 60, 62, 64, 65, 67, 69, 70, 72, 72, 74,
75, 75, 77, 78, 78, 79, 80, 81, 81, 82, 84, 83, 84, 85, 85, 86, 87, 87, 87, 87,
89, 88, 89, 89, 89, 90, 90, 90, 91, 91, 91, 91, 91, 92, 92, 92, 91, 92, 92, 93,
92, 93, 92, 92, 92, 92, 93, 92, 93, 92, 92, 92, 92, 92, 91, 92, 92, 91, 92, 91,
92, 91, 91, 90, 91, 91, 90, 90, 91, 89, 90, 89, 89, 89, 89, 88, 87, 88, 88, 87,
87, 87, 87, 86, 86, 86, 86, 85, 85, 85, 84, 84, 83, 83, 83, 82, 83, 82, 82, 82,
81, 81, 81, 80, 79, 80, 79, 78, 78, 77, 77, 77, 77, 76, 75, 76, 74, 75, 74, 73,
73, 73, 72, 71, 71, 70, 70, 70, 70, 69, 69, 67, 68, 67, 67, 66, 65, 64, 64, 64,
64, 62, 62, 61, 61, 60, 60, 60, 58, 59, 59, 57, 56, 56, 55, 54, 54, 53, 52, 51,
51, 50, 50, 49, 47, 48, 47, 46, 45, 44, 43, 43, 42, 42, 41, 40, 39, 39, 38, 37,
37, 36, 36, 34, 33, 33, 33, 33, 31, 30, 30, 30, 29, 28, 27, 27, 27, 26, 26, 24,
24, 23, 23, 22, 21, 21, 19, 20, 20, 19, 18, 17, 17, 16, 16, 15, 14, 14, 14, 13,
13, 11, 12, 11, 12, 11, 12, 11, 11, 10, 11, 10, 10, 10, 11, 11, 11, 10, 11, 12,
12, 12, 12, 12, 13, 13, 13, 14, 13, 14, 14, 14, 15, 16, 16, 17, 17, 18, 18, 19,
19, 20, 21, 21, 22, 23, 24, 24, 24, 26, 26, 27, 28, 28, 30, 31, 31, 32, 33, 34,
35, 35, 36, 37, 38, 39, 40, 41, 41, 43, 42, 43, 45, 45, 46, 47, 47, 47, 48, 47,
48, 48, 49, 47, 48, 48, 48, 47, 47, 46, 46, 46, 45, 45, 44, 43, 42, 41, 39, 39,
37, 36, 34, 32, 30, 29, 26, 24, 22, 20, 16, 14, 10, 6, 3, -1, -5, -9, -13, -17,
-20, -25, -29, -33, -36, -40, -43, -47, -51, -54, -58, -61, -64, -67, -70, -72,
-76, -77, -80, -82, -85, -86, -89, -91, -93, -95, -96, -98, -99, -100, -102,
-104, -105, -105, -107, -107, -107, -108, -110, -110, -112, -112, -113, -114,
-113, -115, -115, -115, -115, -116, -117, -117, -117, -117, -117, -118, -117,
-118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -118, -118, -119, -119, -118, -119, -118, -118, -119, -118, -117, -116,
-116, -117, -117, -116, -115, -116, -114, -114, -114, -113, -113, -113, -112,
-111, -110, -110, -108, -107, -107, -106, -104, -104, -102, -101, -101, -99,
-97, -96, -94, -93, -91, -89, -87, -86, -83, -81, -79, -76, -74, -71, -68, -66,
-63, -59, -56, -53, -49, -45, -41, -37, -33, -29, -25, -19, -16, -13, -10, -5,
-1, };