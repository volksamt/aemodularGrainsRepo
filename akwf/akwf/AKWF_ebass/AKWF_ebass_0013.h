#define DATA_LENGTH 512
#define DATA AKWF_ebass_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 8, 13, 18, 21, 26, 30, 34, 39,
43, 48, 52, 56, 60, 64, 68, 73, 76, 80, 83, 86, 89, 92, 95, 98, 101, 103, 105,
107, 108, 110, 112, 114, 114, 116, 116, 117, 117, 118, 119, 119, 118, 119, 119,
119, 118, 119, 118, 118, 117, 117, 114, 114, 111, 109, 108, 105, 102, 99, 97,
94, 91, 88, 84, 81, 77, 75, 72, 68, 66, 63, 60, 58, 56, 54, 53, 49, 47, 45, 44,
41, 40, 37, 35, 32, 29, 27, 23, 21, 18, 15, 12, 9, 6, 4, 1, -2, -4, -6, -8, -10,
-12, -14, -14, -17, -18, -19, -20, -21, -23, -24, -25, -27, -28, -30, -32, -33,
-35, -37, -38, -39, -41, -42, -43, -44, -45, -45, -46, -47, -46, -46, -46, -46,
-47, -47, -47, -48, -48, -50, -50, -51, -53, -54, -54, -56, -57, -58, -59, -60,
-61, -62, -62, -63, -62, -63, -63, -62, -60, -60, -59, -57, -57, -56, -54, -54,
-53, -53, -52, -53, -52, -53, -54, -54, -55, -56, -56, -58, -57, -58, -59, -58,
-58, -57, -57, -56, -56, -54, -54, -52, -51, -51, -48, -48, -47, -47, -46, -47,
-47, -47, -48, -49, -50, -52, -53, -52, -54, -55, -55, -55, -55, -56, -54, -53,
-53, -52, -50, -49, -48, -47, -46, -45, -44, -44, -44, -43, -44, -44, -45, -45,
-47, -49, -50, -50, -53, -53, -54, -54, -55, -56, -55, -55, -55, -55, -54, -53,
-52, -51, -49, -49, -47, -46, -46, -46, -46, -45, -46, -45, -45, -46, -46, -47,
-47, -47, -47, -46, -47, -46, -45, -44, -42, -41, -39, -37, -35, -33, -31, -29,
-27, -25, -24, -23, -20, -20, -20, -19, -18, -18, -17, -18, -19, -18, -18, -17,
-18, -17, -17, -15, -14, -13, -12, -10, -9, -7, -6, -3, -2, 0, 3, 4, 7, 8, 11,
13, 14, 16, 17, 19, 21, 22, 23, 25, 26, 28, 29, 30, 30, 30, 31, 31, 31, 32, 31,
32, 32, 32, 32, 32, 30, 30, 30, 29, 30, 29, 29, 29, 29, 29, 29, 29, 29, 29, 30,
30, 31, 32, 34, 34, 35, 36, 36, 38, 38, 39, 40, 41, 42, 43, 44, 45, 46, 46, 47,
47, 48, 47, 48, 48, 48, 48, 48, 46, 46, 44, 42, 42, 41, 40, 38, 37, 35, 33, 32,
31, 30, 30, 30, 31, 31, 33, 33, 36, 38, 39, 43, 44, 46, 49, 51, 52, 53, 55, 57,
57, 58, 59, 58, 58, 57, 56, 55, 54, 53, 51, 49, 46, 45, 43, 42, 40, 39, 37, 35,
33, 31, 29, 27, 24, 22, 20, 16, 15, 12, 9, 6, 4, 1, -1, -5, -7, -10, -12, -14,
-17, -19, -21, -23, -24, -25, -27, -29, -30, -31, -33, -35, -36, -37, -39, -42,
-43, -47, -49, -52, -55, -59, -61, -65, -67, -69, -72, -74, -77, -78, -80, -81,
-81, -82, -82, -80, -78, -79, -75, -74, -71, -68, -65, -63, -59, -55, -51, -47,
-44, -40, -36, -32, -28, -24, -20, -16, -11, -7, -2, };