#define DATA_LENGTH 512
#define DATA AKWF_ebass_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 11, 19, 26, 33, 42, 48, 54, 61, 67,
72, 78, 83, 88, 91, 96, 99, 103, 105, 109, 112, 114, 115, 116, 118, 119, 118,
119, 118, 119, 118, 117, 117, 116, 115, 115, 113, 112, 109, 107, 104, 102, 99,
96, 92, 89, 86, 82, 79, 74, 71, 67, 62, 58, 55, 49, 46, 41, 36, 33, 28, 23, 19,
15, 10, 7, 3, -1, -6, -9, -14, -17, -22, -25, -29, -34, -38, -41, -45, -49, -52,
-55, -59, -61, -64, -67, -69, -71, -74, -76, -78, -80, -82, -83, -86, -87, -89,
-92, -92, -93, -94, -95, -96, -96, -97, -98, -98, -97, -98, -98, -98, -98, -98,
-97, -98, -98, -97, -96, -97, -96, -96, -95, -94, -95, -93, -92, -91, -89, -89,
-87, -86, -85, -83, -83, -82, -81, -80, -79, -77, -76, -74, -73, -70, -68, -66,
-65, -61, -59, -56, -54, -51, -49, -47, -45, -43, -41, -39, -37, -35, -33, -31,
-30, -28, -27, -24, -22, -21, -18, -15, -14, -11, -9, -7, -4, -3, 1, 3, 6, 8,
10, 11, 13, 16, 16, 18, 19, 20, 22, 24, 26, 27, 31, 32, 34, 37, 38, 42, 44, 46,
48, 50, 52, 53, 56, 56, 58, 57, 58, 58, 59, 58, 59, 60, 62, 64, 65, 67, 69, 72,
72, 75, 77, 79, 81, 81, 83, 83, 84, 84, 85, 85, 83, 82, 82, 80, 80, 80, 80, 81,
81, 83, 84, 84, 86, 87, 88, 90, 91, 92, 92, 91, 92, 91, 90, 88, 87, 86, 84, 81,
79, 77, 76, 74, 73, 73, 72, 73, 73, 73, 75, 76, 77, 79, 80, 81, 80, 80, 79, 77,
75, 70, 68, 63, 60, 56, 52, 48, 45, 42, 41, 40, 38, 36, 37, 38, 39, 41, 43, 45,
46, 48, 49, 49, 48, 47, 45, 42, 38, 35, 31, 27, 24, 20, 17, 14, 12, 9, 7, 6, 4,
3, 3, 3, 4, 4, 4, 5, 5, 4, 2, 1, -2, -4, -6, -10, -12, -15, -16, -19, -20, -21,
-21, -23, -23, -22, -21, -20, -20, -19, -18, -18, -18, -17, -18, -17, -18, -20,
-22, -24, -27, -30, -34, -39, -41, -45, -48, -50, -52, -54, -53, -53, -53, -51,
-49, -48, -47, -44, -43, -41, -39, -37, -35, -32, -30, -28, -27, -26, -24, -23,
-23, -23, -22, -23, -22, -23, -22, -21, -21, -20, -20, -19, -18, -18, -18, -16,
-16, -17, -17, -16, -16, -16, -15, -14, -14, -13, -12, -11, -11, -9, -8, -7, -5,
-3, 0, 2, 5, 7, 10, 12, 14, 16, 17, 18, 19, 19, 20, 19, 19, 16, 14, 12, 9, 4, 1,
-4, -9, -14, -18, -23, -29, -34, -39, -43, -47, -51, -55, -58, -62, -65, -68,
-69, -71, -73, -74, -75, -75, -75, -76, -76, -77, -78, -78, -80, -82, -83, -84,
-86, -88, -89, -91, -92, -93, -95, -96, -97, -98, -100, -99, -100, -100, -99,
-98, -97, -95, -93, -91, -87, -84, -81, -76, -72, -67, -62, -56, -51, -45, -39,
-32, -26, -18, -11, -4, };