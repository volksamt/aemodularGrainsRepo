#define DATA_LENGTH 512
#define DATA AKWF_ebass_0045

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 7, 10, 12, 14, 16, 16, 19,
20, 22, 23, 25, 27, 29, 29, 31, 33, 33, 35, 36, 37, 39, 40, 40, 40, 40, 42, 42,
43, 42, 44, 43, 44, 44, 44, 44, 44, 44, 43, 42, 43, 41, 41, 40, 40, 38, 38, 37,
35, 35, 32, 31, 30, 28, 27, 25, 24, 22, 19, 18, 16, 13, 12, 10, 8, 5, 3, 0, -2,
-4, -6, -9, -11, -14, -16, -19, -22, -24, -25, -29, -31, -34, -36, -38, -40,
-44, -47, -49, -51, -54, -57, -58, -61, -64, -66, -68, -70, -73, -75, -78, -80,
-83, -85, -86, -89, -91, -92, -93, -96, -98, -98, -100, -102, -104, -105, -107,
-108, -109, -110, -111, -111, -112, -113, -114, -114, -116, -117, -118, -117,
-117, -117, -118, -119, -118, -117, -118, -117, -118, -117, -117, -116, -117,
-116, -115, -114, -113, -113, -112, -111, -109, -110, -109, -108, -107, -106,
-104, -103, -103, -101, -100, -99, -97, -96, -96, -94, -92, -90, -89, -88, -86,
-85, -84, -82, -81, -80, -77, -77, -74, -74, -72, -71, -69, -67, -66, -65, -63,
-62, -61, -58, -58, -56, -55, -53, -52, -50, -49, -48, -47, -46, -45, -43, -43,
-42, -41, -41, -38, -39, -38, -36, -35, -36, -35, -34, -34, -33, -31, -32, -31,
-31, -30, -29, -29, -29, -28, -28, -28, -29, -28, -27, -26, -26, -27, -28, -27,
-26, -25, -26, -25, -26, -26, -26, -25, -27, -26, -26, -26, -26, -27, -26, -27,
-26, -27, -28, -27, -28, -27, -27, -28, -28, -27, -27, -28, -28, -28, -28, -28,
-27, -28, -27, -28, -28, -28, -28, -28, -27, -27, -27, -27, -26, -26, -26, -25,
-26, -25, -24, -24, -24, -23, -23, -23, -23, -22, -21, -22, -21, -21, -20, -19,
-18, -18, -18, -18, -17, -15, -16, -15, -13, -14, -13, -12, -13, -11, -10, -10,
-10, -10, -9, -9, -9, -8, -8, -7, -6, -6, -6, -6, -5, -4, -4, -3, -3, -3, -3,
-3, -2, -3, -2, -2, -2, -3, -3, -3, -2, -4, -3, -4, -4, -4, -4, -5, -6, -7, -7,
-8, -8, -8, -9, -11, -11, -12, -13, -15, -16, -17, -18, -19, -20, -22, -23, -25,
-26, -27, -28, -30, -32, -34, -35, -37, -39, -41, -42, -44, -46, -47, -50, -51,
-54, -55, -57, -59, -60, -63, -65, -66, -69, -71, -72, -74, -76, -77, -80, -81,
-83, -84, -86, -87, -90, -91, -93, -95, -96, -98, -99, -100, -101, -103, -105,
-106, -107, -107, -109, -110, -111, -112, -113, -114, -115, -115, -116, -117,
-117, -118, -118, -118, -118, -119, -119, -119, -119, -119, -120, -118, -118,
-118, -118, -117, -116, -116, -117, -114, -113, -113, -112, -111, -110, -110,
-108, -107, -106, -105, -103, -102, -100, -100, -98, -96, -94, -92, -91, -89,
-87, -85, -83, -81, -78, -76, -75, -73, -70, -68, -67, -64, -62, -59, -57, -56,
-53, -51, -48, -46, -44, -41, -39, -36, -34, -32, -29, -26, -24, -23, -20, -18,
-16, -13, -11, -9, -6, -4, -1, -1, };