#define DATA_LENGTH 512
#define DATA AKWF_ebass_0033

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 6, 8, 9, 9, 11, 12, 12,
12, 12, 12, 13, 13, 13, 13, 14, 15, 17, 18, 19, 21, 22, 24, 25, 26, 27, 29, 30,
31, 31, 32, 31, 32, 32, 31, 30, 30, 29, 28, 27, 26, 26, 25, 26, 25, 26, 26, 27,
29, 30, 32, 34, 36, 37, 41, 41, 43, 45, 47, 49, 50, 52, 52, 52, 54, 55, 55, 55,
55, 55, 56, 57, 56, 57, 56, 56, 58, 58, 59, 58, 58, 58, 57, 57, 56, 55, 54, 54,
52, 50, 49, 48, 47, 46, 44, 42, 42, 41, 41, 41, 41, 41, 42, 42, 43, 45, 46, 49,
50, 53, 56, 58, 60, 63, 64, 66, 68, 70, 70, 72, 72, 72, 71, 71, 68, 67, 64, 62,
58, 55, 51, 47, 45, 39, 36, 33, 30, 27, 25, 25, 24, 23, 24, 26, 28, 31, 35, 38,
44, 49, 55, 62, 67, 74, 81, 85, 93, 97, 102, 107, 111, 114, 116, 118, 119, 119,
119, 118, 117, 116, 112, 109, 106, 102, 97, 92, 86, 81, 74, 67, 61, 53, 47, 38,
33, 26, 19, 13, 7, 2, -3, -6, -9, -11, -11, -11, -12, -11, -9, -7, -6, -3, -2,
0, 2, 1, 1, 1, 0, -1, -2, -4, -7, -10, -14, -18, -23, -27, -31, -35, -39, -43,
-46, -48, -50, -51, -53, -54, -54, -53, -52, -50, -48, -45, -42, -37, -33, -27,
-23, -16, -11, -4, 2, 9, 14, 19, 25, 30, 34, 38, 40, 44, 47, 49, 51, 52, 53, 53,
54, 54, 53, 53, 52, 51, 49, 47, 45, 43, 40, 37, 35, 33, 29, 26, 24, 21, 17, 15,
11, 8, 4, 2, -2, -6, -9, -10, -14, -17, -20, -24, -27, -30, -33, -36, -40, -44,
-47, -50, -53, -58, -61, -65, -67, -70, -73, -75, -76, -79, -82, -83, -85, -87,
-88, -89, -91, -90, -91, -89, -88, -86, -84, -81, -78, -75, -71, -68, -66, -62,
-61, -58, -57, -55, -55, -55, -56, -57, -58, -62, -64, -67, -70, -73, -76, -78,
-80, -81, -81, -79, -78, -75, -72, -68, -64, -61, -58, -54, -52, -51, -50, -50,
-50, -51, -53, -54, -56, -57, -60, -62, -64, -64, -65, -66, -66, -66, -64, -64,
-62, -60, -58, -56, -55, -53, -53, -53, -52, -51, -53, -55, -55, -57, -58, -58,
-60, -61, -62, -61, -62, -61, -60, -60, -58, -58, -57, -57, -57, -57, -58, -59,
-61, -63, -65, -66, -66, -69, -70, -70, -70, -70, -69, -68, -67, -65, -63, -60,
-57, -54, -50, -47, -44, -40, -38, -35, -34, -32, -30, -30, -30, -30, -31, -31,
-33, -33, -35, -36, -37, -37, -39, -39, -40, -41, -40, -41, -40, -40, -39, -38,
-38, -36, -34, -32, -30, -28, -25, -24, -21, -19, -15, -13, -11, -9, -7, -5, -4,
-3, -2, -1, -1, 0, -1, 0, -2, -2, -3, -4, -5, -7, -7, -10, -10, -11, -12, -12,
-12, -13, -12, -12, -10, -10, -10, -8, -8, -7, -5, -5, -3, -2, -1, 0, 1, };