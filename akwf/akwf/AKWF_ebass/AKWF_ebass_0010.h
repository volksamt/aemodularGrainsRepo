#define DATA_LENGTH 512
#define DATA AKWF_ebass_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 11, 14, 17, 20, 22, 25, 28,
30, 33, 36, 38, 41, 42, 45, 47, 49, 52, 53, 56, 59, 60, 63, 64, 66, 68, 70, 73,
74, 76, 78, 79, 82, 82, 84, 87, 87, 89, 90, 91, 93, 94, 95, 96, 98, 98, 99, 100,
101, 101, 102, 103, 104, 103, 105, 104, 105, 105, 105, 105, 105, 105, 104, 105,
105, 105, 104, 103, 104, 104, 103, 103, 103, 102, 100, 101, 100, 100, 98, 98,
98, 97, 95, 96, 95, 94, 94, 93, 92, 91, 90, 90, 88, 87, 86, 85, 85, 84, 82, 82,
80, 79, 78, 78, 77, 76, 75, 73, 72, 71, 71, 70, 68, 67, 66, 66, 64, 64, 63, 61,
61, 60, 59, 58, 57, 56, 55, 54, 53, 52, 50, 50, 49, 48, 47, 46, 45, 44, 43, 42,
41, 38, 38, 37, 35, 34, 33, 31, 30, 29, 28, 26, 24, 23, 21, 20, 17, 16, 16, 14,
13, 11, 10, 8, 7, 7, 5, 4, 3, 2, 1, 0, -1, -2, -3, -4, -4, -5, -6, -5, -6, -7,
-7, -7, -8, -9, -9, -9, -9, -10, -10, -11, -10, -12, -11, -12, -12, -12, -13,
-14, -14, -14, -15, -16, -16, -17, -17, -18, -19, -19, -21, -22, -22, -23, -24,
-23, -25, -26, -26, -27, -27, -28, -28, -29, -29, -31, -30, -30, -31, -32, -32,
-33, -34, -33, -33, -34, -34, -34, -35, -35, -34, -35, -35, -34, -34, -34, -34,
-34, -34, -33, -33, -33, -33, -33, -32, -32, -31, -31, -31, -31, -29, -30, -29,
-29, -28, -27, -27, -26, -26, -26, -25, -25, -25, -24, -23, -24, -23, -23, -22,
-23, -21, -22, -22, -22, -22, -22, -21, -21, -21, -21, -21, -20, -21, -20, -19,
-19, -19, -19, -18, -17, -17, -17, -15, -15, -14, -13, -13, -11, -10, -9, -8,
-7, -6, -5, -4, -3, -2, 0, 1, 3, 4, 5, 6, 8, 9, 10, 11, 12, 14, 15, 16, 18, 18,
19, 20, 21, 21, 23, 23, 23, 24, 24, 25, 25, 26, 25, 26, 25, 25, 25, 25, 24, 24,
24, 24, 23, 22, 22, 21, 21, 20, 19, 18, 17, 17, 16, 15, 15, 13, 13, 11, 11, 11,
10, 8, 8, 6, 6, 5, 3, 2, 1, 1, -1, -3, -4, -5, -8, -9, -10, -12, -13, -16, -17,
-18, -20, -23, -25, -26, -29, -31, -33, -35, -37, -40, -42, -44, -46, -49, -52,
-55, -57, -60, -62, -65, -67, -70, -71, -75, -78, -79, -81, -85, -88, -89, -91,
-94, -95, -97, -100, -101, -103, -105, -107, -108, -109, -111, -112, -113, -114,
-116, -117, -117, -117, -118, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -118, -118, -118, -116, -116, -116, -116, -114, -113, -113, -111, -110,
-109, -109, -108, -106, -104, -103, -101, -100, -98, -97, -95, -94, -91, -89,
-87, -85, -83, -81, -78, -76, -73, -71, -69, -66, -63, -59, -55, -53, -50, -46,
-44, -41, -38, -34, -30, -27, -24, -21, -17, -14, -11, -8, -5, -2, };