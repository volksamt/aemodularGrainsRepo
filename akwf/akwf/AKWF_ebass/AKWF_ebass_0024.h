#define DATA_LENGTH 512
#define DATA AKWF_ebass_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 10, 13, 17, 20, 22, 26, 28,
31, 34, 37, 40, 43, 45, 49, 50, 54, 56, 58, 61, 64, 66, 69, 70, 72, 74, 76, 78,
80, 81, 84, 85, 87, 88, 90, 92, 92, 94, 96, 97, 98, 98, 100, 101, 100, 102, 103,
102, 103, 104, 104, 104, 104, 105, 104, 105, 105, 105, 104, 105, 105, 103, 103,
103, 102, 102, 101, 101, 100, 99, 98, 98, 97, 95, 95, 93, 92, 91, 89, 88, 87,
86, 84, 83, 81, 79, 77, 76, 75, 72, 71, 69, 68, 66, 64, 61, 59, 57, 55, 53, 52,
49, 47, 44, 43, 40, 38, 35, 33, 31, 29, 26, 24, 21, 19, 15, 13, 11, 9, 6, 3, 0,
-1, -4, -7, -10, -13, -14, -18, -20, -23, -26, -29, -31, -35, -36, -40, -41,
-44, -47, -50, -52, -55, -57, -59, -62, -65, -67, -69, -72, -75, -77, -78, -81,
-83, -84, -87, -89, -91, -93, -95, -96, -99, -100, -102, -104, -105, -107, -108,
-109, -110, -112, -113, -113, -115, -116, -116, -118, -117, -117, -118, -119,
-119, -119, -119, -120, -118, -118, -118, -118, -117, -117, -117, -115, -115,
-114, -112, -112, -110, -109, -107, -106, -104, -103, -101, -99, -98, -96, -93,
-91, -89, -86, -85, -81, -79, -77, -75, -72, -69, -67, -64, -61, -58, -55, -52,
-50, -46, -44, -40, -38, -34, -31, -28, -25, -22, -18, -15, -12, -9, -6, -3, 0,
3, 6, 10, 12, 15, 19, 21, 24, 27, 31, 33, 35, 39, 42, 44, 47, 48, 51, 53, 56,
58, 61, 63, 64, 65, 69, 70, 72, 74, 74, 76, 77, 79, 80, 81, 82, 84, 85, 85, 86,
87, 88, 88, 88, 88, 88, 89, 89, 88, 90, 89, 89, 88, 88, 87, 88, 86, 86, 86, 85,
84, 83, 83, 81, 81, 80, 80, 78, 77, 76, 75, 74, 73, 72, 70, 69, 68, 67, 66, 65,
63, 62, 62, 60, 59, 58, 56, 56, 55, 53, 52, 51, 50, 49, 48, 47, 46, 45, 44, 43,
43, 42, 41, 40, 39, 38, 37, 36, 36, 34, 34, 33, 32, 32, 31, 30, 29, 29, 28, 27,
26, 26, 26, 25, 25, 24, 22, 22, 21, 20, 20, 19, 18, 18, 17, 16, 15, 14, 13, 12,
12, 10, 10, 8, 8, 6, 5, 4, 2, 1, 1, -1, -2, -4, -5, -6, -8, -9, -10, -12, -14,
-15, -16, -19, -20, -22, -23, -25, -27, -29, -31, -32, -34, -36, -38, -40, -43,
-44, -46, -48, -50, -51, -54, -56, -57, -60, -61, -64, -65, -67, -69, -71, -73,
-74, -76, -77, -78, -81, -82, -83, -84, -86, -87, -89, -90, -90, -92, -93, -94,
-94, -96, -96, -97, -97, -98, -98, -97, -97, -98, -98, -98, -98, -97, -96, -95,
-95, -94, -94, -93, -91, -90, -89, -89, -87, -84, -83, -82, -80, -78, -76, -75,
-72, -71, -68, -66, -63, -60, -59, -56, -53, -51, -49, -46, -43, -40, -38, -35,
-32, -29, -26, -23, -20, -17, -14, -11, -7, -5, -1, };