#define DATA_LENGTH 512
#define DATA AKWF_ebass_0031

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 8, 10, 12, 14, 17, 18, 21,
23, 24, 26, 28, 31, 33, 35, 36, 38, 40, 41, 43, 45, 48, 49, 50, 51, 53, 55, 56,
57, 59, 61, 61, 63, 64, 64, 66, 67, 67, 69, 69, 70, 71, 72, 72, 73, 72, 73, 73,
72, 73, 73, 73, 71, 71, 70, 70, 69, 68, 66, 65, 64, 63, 60, 59, 57, 56, 53, 51,
49, 47, 44, 43, 41, 39, 36, 33, 31, 28, 27, 24, 22, 20, 18, 17, 15, 13, 12, 10,
9, 8, 7, 6, 5, 4, 4, 3, 3, 2, 3, 4, 3, 3, 3, 4, 4, 6, 7, 7, 9, 9, 10, 11, 12,
12, 13, 15, 16, 17, 18, 19, 20, 21, 22, 22, 22, 24, 25, 25, 26, 25, 26, 26, 26,
27, 27, 28, 28, 28, 28, 28, 28, 28, 29, 28, 29, 30, 30, 31, 32, 33, 34, 34, 35,
36, 37, 40, 41, 42, 44, 45, 47, 50, 52, 54, 56, 59, 61, 64, 66, 70, 72, 75, 77,
81, 84, 86, 89, 92, 96, 98, 100, 104, 106, 108, 110, 111, 113, 114, 116, 117,
118, 119, 119, 120, 119, 118, 118, 117, 116, 114, 113, 111, 109, 106, 104, 101,
98, 94, 91, 88, 85, 81, 77, 74, 70, 67, 62, 58, 55, 51, 46, 42, 38, 34, 32, 27,
23, 19, 16, 13, 9, 6, 2, 0, -4, -7, -10, -11, -14, -16, -20, -22, -24, -25, -26,
-28, -30, -30, -32, -32, -33, -33, -34, -33, -34, -33, -32, -31, -31, -30, -29,
-27, -26, -24, -22, -20, -18, -17, -14, -11, -8, -7, -4, 0, 2, 5, 7, 10, 13, 16,
18, 21, 23, 26, 28, 32, 34, 36, 38, 41, 42, 44, 48, 49, 51, 53, 54, 55, 56, 58,
60, 61, 61, 62, 63, 64, 63, 64, 64, 65, 64, 65, 64, 62, 62, 61, 60, 58, 57, 56,
54, 52, 51, 48, 46, 44, 42, 39, 37, 34, 31, 28, 26, 22, 18, 16, 12, 9, 5, 1, -3,
-6, -9, -14, -17, -21, -25, -29, -32, -36, -39, -43, -47, -50, -53, -57, -60,
-63, -66, -70, -71, -75, -77, -79, -82, -84, -86, -88, -91, -92, -93, -95, -97,
-99, -99, -100, -101, -102, -102, -103, -105, -104, -105, -105, -105, -105,
-106, -106, -106, -106, -106, -106, -105, -106, -105, -105, -106, -106, -106,
-106, -106, -107, -107, -107, -107, -107, -107, -107, -107, -108, -108, -109,
-108, -109, -109, -110, -110, -110, -111, -111, -111, -111, -111, -111, -112,
-111, -111, -111, -110, -111, -110, -110, -110, -110, -108, -107, -107, -107,
-106, -105, -104, -102, -102, -100, -99, -98, -97, -95, -94, -93, -91, -90, -89,
-88, -86, -85, -83, -82, -81, -79, -78, -77, -76, -74, -73, -72, -71, -69, -68,
-67, -66, -65, -64, -63, -61, -60, -59, -58, -57, -56, -54, -53, -52, -51, -49,
-48, -46, -45, -43, -41, -40, -38, -37, -34, -33, -31, -29, -27, -25, -23, -20,
-19, -16, -14, -12, -10, -7, -4, -3, -1, };