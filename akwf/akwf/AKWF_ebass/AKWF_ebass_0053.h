#define DATA_LENGTH 512
#define DATA AKWF_ebass_0053

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 4, 5, 7, 9, 10, 10, 12, 13,
15, 16, 17, 19, 20, 21, 22, 22, 24, 24, 24, 26, 26, 27, 28, 29, 31, 32, 34, 35,
35, 37, 38, 40, 41, 40, 42, 42, 43, 44, 43, 44, 44, 45, 45, 45, 46, 47, 49, 50,
50, 51, 51, 52, 53, 53, 53, 52, 53, 53, 53, 52, 52, 51, 52, 51, 52, 53, 52, 53,
53, 53, 53, 54, 54, 55, 54, 54, 54, 54, 54, 53, 54, 54, 53, 54, 54, 54, 55, 54,
56, 56, 55, 56, 57, 57, 58, 60, 61, 60, 61, 62, 63, 64, 63, 64, 65, 65, 65, 65,
66, 66, 66, 66, 66, 66, 66, 66, 66, 66, 65, 66, 64, 64, 64, 64, 63, 63, 61, 61,
60, 59, 58, 56, 55, 54, 53, 51, 51, 49, 47, 45, 44, 44, 41, 39, 38, 36, 35, 33,
31, 29, 28, 25, 23, 22, 20, 19, 17, 15, 13, 11, 9, 6, 4, 2, -1, -4, -6, -9, -11,
-15, -17, -20, -23, -25, -27, -29, -32, -33, -37, -38, -40, -41, -43, -45, -46,
-48, -48, -50, -50, -51, -52, -53, -55, -54, -55, -56, -56, -57, -58, -57, -58,
-58, -58, -58, -57, -56, -57, -56, -56, -56, -56, -55, -54, -53, -53, -52, -52,
-50, -50, -49, -48, -47, -47, -45, -45, -43, -42, -40, -40, -37, -36, -35, -33,
-32, -30, -29, -28, -26, -25, -23, -22, -21, -19, -19, -18, -17, -15, -12, -11,
-9, -7, -6, -5, -3, -1, 0, 2, 5, 8, 10, 11, 11, 12, 13, 14, 15, 16, 20, 21, 23,
24, 25, 26, 29, 30, 34, 36, 39, 42, 45, 46, 48, 48, 49, 50, 52, 53, 54, 56, 57,
58, 58, 58, 60, 61, 62, 64, 65, 67, 66, 67, 67, 67, 67, 66, 65, 64, 62, 61, 59,
58, 57, 57, 56, 54, 54, 53, 53, 52, 51, 51, 50, 51, 48, 48, 46, 45, 43, 41, 41,
40, 39, 38, 37, 38, 37, 36, 36, 37, 36, 37, 36, 36, 36, 35, 35, 35, 35, 36, 36,
36, 37, 37, 38, 38, 38, 38, 36, 36, 36, 35, 36, 35, 35, 34, 34, 33, 33, 31, 32,
32, 32, 32, 32, 32, 30, 31, 28, 27, 25, 25, 22, 21, 19, 18, 16, 13, 12, 9, 8, 6,
5, 3, 1, -1, -4, -5, -8, -11, -14, -17, -19, -23, -25, -27, -31, -33, -36, -38,
-41, -44, -47, -49, -51, -55, -58, -62, -65, -68, -71, -74, -77, -80, -83, -86,
-89, -91, -93, -95, -97, -100, -100, -102, -105, -106, -108, -110, -111, -112,
-114, -115, -115, -116, -117, -118, -118, -119, -119, -118, -119, -119, -119,
-118, -119, -118, -118, -116, -116, -115, -113, -111, -109, -108, -106, -104,
-102, -101, -99, -97, -95, -92, -90, -88, -84, -81, -79, -77, -74, -71, -68,
-66, -62, -60, -57, -55, -53, -51, -49, -46, -44, -42, -39, -38, -35, -32, -31,
-28, -26, -23, -21, -18, -14, -11, -8, -7, -5, -3, -1, -1, };