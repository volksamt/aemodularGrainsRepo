#define DATA_LENGTH 512
#define DATA AKWF_ebass_0049

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 6, 11, 16, 19, 22, 25, 27, 31, 33,
36, 39, 43, 48, 55, 61, 65, 71, 73, 76, 77, 76, 75, 74, 73, 73, 74, 77, 79, 83,
89, 94, 98, 104, 109, 113, 116, 117, 119, 119, 119, 118, 117, 116, 115, 112,
111, 109, 107, 105, 105, 104, 102, 101, 99, 99, 95, 94, 91, 88, 85, 82, 79, 75,
73, 71, 69, 68, 66, 63, 61, 58, 52, 46, 42, 35, 29, 22, 17, 12, 8, 5, 5, 5, 7,
10, 13, 13, 13, 11, 8, 3, -2, -11, -18, -27, -34, -42, -47, -50, -54, -54, -53,
-52, -51, -49, -47, -45, -43, -42, -41, -42, -42, -44, -45, -46, -47, -48, -48,
-48, -47, -44, -42, -40, -37, -35, -34, -31, -28, -27, -26, -24, -22, -20, -16,
-14, -9, -5, 0, 6, 12, 17, 23, 28, 31, 32, 33, 31, 29, 28, 25, 25, 25, 27, 30,
35, 42, 49, 56, 63, 70, 74, 78, 79, 78, 77, 74, 71, 69, 67, 66, 64, 65, 67, 69,
72, 74, 75, 76, 75, 75, 75, 74, 72, 69, 66, 62, 59, 56, 52, 50, 48, 46, 43, 42,
41, 40, 41, 41, 40, 37, 33, 27, 22, 16, 11, 6, 3, 1, 1, 3, 7, 11, 14, 17, 18,
18, 15, 11, 5, -1, -7, -14, -20, -26, -29, -34, -34, -35, -34, -33, -31, -30,
-28, -27, -25, -23, -23, -23, -23, -24, -25, -26, -27, -27, -26, -25, -22, -20,
-15, -10, -5, -1, 2, 6, 7, 8, 9, 10, 10, 11, 13, 13, 17, 20, 24, 28, 32, 36, 40,
42, 44, 45, 44, 43, 41, 38, 35, 34, 33, 33, 33, 35, 36, 38, 40, 44, 47, 50, 53,
54, 53, 50, 45, 41, 35, 29, 22, 16, 10, 4, -1, -5, -8, -12, -14, -18, -21, -24,
-27, -31, -35, -40, -44, -50, -54, -59, -65, -71, -76, -81, -89, -94, -98, -102,
-105, -106, -108, -109, -108, -110, -110, -109, -110, -110, -110, -110, -110,
-110, -109, -106, -104, -102, -98, -95, -93, -91, -89, -87, -86, -86, -87, -86,
-85, -84, -80, -76, -72, -66, -62, -57, -51, -48, -41, -36, -30, -25, -19, -14,
-10, -6, -3, 0, 3, 6, 8, 12, 15, 20, 24, 30, 36, 41, 48, 52, 57, 59, 61, 61, 60,
57, 53, 48, 43, 39, 35, 32, 29, 28, 28, 29, 29, 31, 32, 32, 31, 31, 29, 27, 24,
19, 16, 12, 9, 6, 4, 1, -2, -4, -5, -7, -9, -11, -12, -13, -15, -16, -17, -20,
-22, -24, -26, -28, -29, -30, -32, -34, -35, -38, -39, -41, -43, -45, -49, -52,
-56, -60, -64, -67, -70, -71, -72, -71, -68, -66, -62, -58, -56, -54, -53, -55,
-58, -63, -67, -73, -77, -81, -82, -83, -83, -83, -81, -79, -78, -77, -76, -76,
-76, -78, -79, -80, -80, -81, -82, -82, -81, -79, -78, -75, -73, -69, -65, -63,
-59, -57, -53, -50, -50, -49, -48, -47, -47, -45, -43, -41, -38, -34, -30, -24,
-18, -12, -4, };