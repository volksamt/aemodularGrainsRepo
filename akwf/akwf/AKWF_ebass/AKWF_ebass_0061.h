#define DATA_LENGTH 512
#define DATA AKWF_ebass_0061

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 6, 9, 11, 14, 17, 20, 22, 25,
27, 29, 31, 33, 36, 38, 38, 40, 43, 44, 46, 47, 49, 50, 52, 53, 55, 56, 57, 58,
59, 60, 62, 63, 63, 64, 65, 66, 66, 68, 67, 68, 69, 70, 71, 71, 72, 72, 73, 72,
73, 75, 75, 75, 75, 76, 76, 77, 77, 77, 77, 77, 77, 77, 78, 77, 77, 77, 79, 78,
78, 78, 78, 79, 79, 78, 79, 78, 78, 79, 78, 78, 78, 78, 79, 77, 77, 78, 77, 77,
77, 77, 77, 77, 77, 76, 76, 76, 75, 75, 75, 75, 75, 74, 74, 74, 74, 73, 73, 73,
73, 72, 72, 72, 71, 70, 71, 70, 70, 69, 69, 69, 69, 68, 69, 68, 67, 68, 67, 66,
66, 66, 66, 65, 65, 65, 64, 63, 62, 62, 61, 62, 62, 61, 61, 61, 59, 59, 58, 59,
59, 57, 56, 56, 57, 56, 55, 55, 55, 54, 53, 53, 53, 52, 52, 51, 50, 50, 50, 49,
48, 48, 48, 47, 47, 46, 46, 45, 45, 44, 44, 42, 43, 42, 41, 41, 41, 40, 39, 38,
37, 37, 37, 36, 36, 36, 34, 33, 33, 32, 32, 31, 30, 31, 29, 29, 28, 29, 27, 28,
26, 25, 26, 25, 24, 24, 24, 23, 23, 22, 22, 22, 21, 21, 19, 19, 19, 19, 18, 18,
17, 16, 16, 15, 16, 15, 14, 14, 13, 14, 13, 12, 11, 12, 10, 10, 10, 10, 10, 9,
8, 8, 9, 8, 7, 8, 8, 7, 8, 7, 7, 7, 7, 7, 7, 7, 7, 8, 7, 8, 9, 8, 8, 8, 9, 9, 9,
9, 10, 9, 9, 10, 10, 10, 11, 11, 12, 12, 13, 12, 13, 14, 13, 15, 15, 16, 16, 17,
17, 18, 19, 19, 19, 20, 21, 21, 22, 23, 23, 24, 25, 26, 26, 27, 27, 28, 28, 29,
30, 31, 31, 32, 32, 33, 33, 34, 33, 34, 35, 34, 36, 35, 35, 35, 36, 35, 35, 35,
35, 34, 34, 33, 33, 33, 33, 31, 31, 30, 29, 28, 27, 27, 25, 23, 23, 21, 19, 17,
16, 14, 12, 10, 9, 6, 3, 1, -2, -5, -8, -10, -13, -17, -19, -22, -25, -28, -31,
-34, -37, -39, -42, -45, -48, -51, -54, -56, -59, -61, -64, -66, -69, -71, -74,
-76, -78, -80, -82, -83, -87, -87, -91, -92, -93, -95, -96, -98, -99, -101,
-101, -103, -105, -106, -107, -108, -109, -110, -111, -110, -112, -113, -114,
-114, -115, -115, -116, -116, -117, -117, -118, -118, -118, -118, -118, -119,
-120, -118, -119, -119, -118, -119, -120, -119, -118, -118, -119, -119, -118,
-118, -117, -117, -116, -116, -115, -115, -115, -113, -113, -112, -112, -111,
-109, -109, -107, -108, -107, -105, -104, -103, -102, -101, -100, -99, -97, -96,
-93, -92, -90, -88, -87, -85, -83, -82, -80, -78, -75, -73, -71, -69, -66, -64,
-62, -59, -57, -54, -51, -49, -46, -44, -41, -37, -34, -31, -28, -25, -22, -19,
-14, -11, -9, -9, -5, -2, };