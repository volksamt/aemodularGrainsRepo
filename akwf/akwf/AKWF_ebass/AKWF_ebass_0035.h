#define DATA_LENGTH 512
#define DATA AKWF_ebass_0035

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 6, 9, 11, 14, 15, 18, 20, 23,
25, 27, 30, 31, 33, 35, 38, 39, 41, 43, 45, 48, 49, 51, 53, 55, 57, 58, 60, 62,
64, 65, 67, 67, 69, 70, 72, 73, 75, 75, 76, 77, 79, 78, 79, 79, 80, 80, 80, 81,
81, 81, 81, 81, 80, 79, 79, 78, 77, 76, 75, 74, 73, 72, 71, 70, 68, 68, 65, 64,
62, 62, 60, 58, 57, 55, 53, 51, 49, 48, 47, 45, 43, 41, 40, 38, 37, 36, 34, 32,
31, 29, 28, 26, 25, 23, 22, 21, 20, 18, 18, 16, 16, 14, 14, 13, 12, 11, 11, 10,
9, 9, 9, 9, 9, 9, 9, 8, 8, 7, 8, 8, 7, 7, 7, 7, 7, 7, 6, 8, 7, 7, 8, 7, 8, 8, 8,
8, 8, 7, 7, 7, 8, 8, 8, 7, 7, 6, 7, 7, 7, 6, 6, 5, 5, 4, 4, 5, 4, 4, 3, 4, 3, 3,
3, 2, 2, 2, 1, 2, 2, 1, 1, -1, -1, 0, -1, -1, -2, -2, -2, -2, -2, -3, -3, -3,
-3, -3, -4, -4, -4, -4, -4, -5, -5, -5, -5, -6, -6, -6, -6, -6, -7, -7, -7, -7,
-9, -8, -8, -8, -9, -10, -9, -9, -10, -10, -11, -10, -11, -11, -12, -12, -11,
-11, -11, -10, -11, -11, -11, -11, -10, -10, -11, -10, -10, -10, -10, -9, -10,
-10, -8, -9, -9, -9, -9, -8, -7, -8, -7, -8, -7, -7, -6, -6, -7, -7, -6, -6, -6,
-7, -6, -6, -6, -6, -7, -7, -6, -6, -6, -6, -6, -6, -6, -7, -6, -6, -6, -6, -7,
-7, -7, -6, -6, -6, -5, -6, -5, -5, -5, -5, -4, -5, -4, -4, -4, -3, -3, -2, -3,
-2, -3, -3, -2, -2, -2, -3, -2, -3, -3, -4, -3, -3, -3, -3, -3, -3, -3, -3, -3,
-3, -3, -2, -2, -2, -2, -3, -2, -2, -2, -2, -2, -2, -3, -3, -3, -2, -2, -3, -3,
-3, -3, -3, -3, -3, -4, -3, -3, -3, -4, -4, -4, -5, -5, -6, -5, -7, -7, -8, -7,
-9, -10, -11, -12, -12, -12, -14, -14, -15, -16, -17, -17, -19, -19, -19, -20,
-20, -21, -21, -23, -22, -23, -23, -25, -25, -25, -26, -26, -26, -27, -28, -28,
-30, -30, -32, -32, -33, -34, -35, -35, -38, -38, -40, -40, -41, -43, -44, -45,
-46, -48, -49, -51, -52, -53, -55, -56, -57, -60, -61, -62, -63, -66, -66, -69,
-70, -72, -73, -74, -77, -79, -81, -81, -84, -85, -87, -89, -90, -92, -94, -96,
-98, -99, -101, -102, -105, -105, -106, -108, -110, -112, -112, -115, -114,
-115, -117, -117, -119, -119, -119, -119, -119, -119, -119, -118, -118, -118,
-116, -116, -114, -114, -112, -111, -109, -107, -107, -104, -102, -101, -99,
-95, -94, -91, -89, -87, -84, -82, -80, -77, -75, -71, -69, -66, -63, -60, -57,
-54, -51, -48, -44, -41, -39, -34, -32, -29, -25, -22, -19, -16, -12, -11, -8,
-4, -2, };