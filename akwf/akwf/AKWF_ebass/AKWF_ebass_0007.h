#define DATA_LENGTH 512
#define DATA AKWF_ebass_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 7, 8, 9, 11, 13, 15, 15,
17, 19, 21, 22, 24, 25, 26, 28, 30, 31, 33, 34, 35, 37, 39, 40, 41, 43, 44, 45,
45, 47, 48, 48, 49, 50, 51, 51, 52, 52, 53, 54, 55, 54, 54, 56, 56, 57, 58, 58,
58, 59, 58, 59, 60, 60, 60, 62, 61, 62, 62, 63, 64, 64, 64, 64, 65, 65, 65, 66,
66, 66, 66, 67, 67, 67, 68, 68, 68, 68, 69, 68, 69, 68, 68, 69, 69, 69, 69, 69,
69, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 67, 67, 67, 67, 67, 66, 67,
66, 65, 65, 65, 65, 65, 63, 63, 62, 62, 62, 61, 61, 60, 59, 59, 58, 58, 57, 56,
54, 54, 53, 53, 51, 51, 50, 49, 48, 47, 46, 46, 46, 44, 44, 43, 43, 42, 42, 41,
40, 39, 39, 39, 40, 38, 39, 39, 37, 37, 38, 38, 38, 37, 37, 36, 37, 37, 37, 36,
37, 36, 36, 36, 35, 34, 34, 33, 32, 31, 31, 31, 30, 28, 27, 26, 25, 24, 24, 22,
21, 21, 20, 18, 18, 16, 16, 15, 14, 13, 13, 12, 11, 11, 10, 9, 9, 9, 8, 7, 7, 7,
6, 6, 6, 6, 6, 6, 5, 5, 5, 5, 4, 5, 5, 4, 5, 4, 5, 4, 4, 5, 5, 4, 5, 6, 4, 4, 4,
4, 5, 5, 4, 5, 5, 4, 5, 4, 4, 3, 3, 4, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 2, 1, 2,
2, 1, 2, 1, 1, 1, 1, 1, 2, 1, 2, 2, 3, 2, 3, 3, 4, 5, 5, 5, 7, 7, 8, 9, 11, 11,
13, 13, 14, 15, 16, 16, 18, 19, 20, 20, 22, 22, 24, 24, 24, 26, 27, 27, 27, 26,
27, 27, 27, 27, 28, 26, 27, 27, 26, 25, 26, 25, 24, 23, 22, 22, 21, 21, 19, 19,
18, 17, 17, 16, 15, 14, 13, 12, 11, 10, 9, 8, 7, 5, 4, 3, 2, 1, 0, 0, -1, -2,
-4, -4, -5, -6, -7, -8, -10, -11, -12, -14, -14, -16, -18, -19, -21, -22, -24,
-26, -28, -30, -32, -34, -37, -38, -41, -42, -45, -48, -50, -52, -56, -57, -60,
-62, -65, -67, -71, -73, -74, -76, -79, -81, -83, -86, -88, -90, -92, -94, -96,
-98, -100, -102, -103, -103, -106, -107, -108, -109, -111, -113, -112, -114,
-114, -114, -116, -117, -117, -117, -118, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -118, -118, -118, -117, -118, -118, -116, -116, -115, -115,
-114, -114, -114, -114, -113, -112, -112, -110, -109, -108, -108, -106, -105,
-104, -103, -102, -100, -99, -97, -96, -94, -92, -91, -89, -86, -85, -83, -81,
-79, -77, -75, -72, -71, -67, -66, -64, -61, -59, -56, -54, -52, -50, -47, -45,
-43, -40, -38, -36, -35, -32, -31, -29, -28, -25, -23, -22, -20, -18, -17, -15,
-13, -12, -10, -8, -7, -5, -4, -2, -1, };