#define DATA_LENGTH 512
#define DATA AKWF_ebass_0069

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 16, 20, 24, 28, 33, 36, 39,
44, 47, 50, 52, 57, 59, 62, 65, 68, 71, 74, 76, 78, 81, 83, 86, 88, 90, 91, 94,
95, 97, 100, 101, 102, 103, 105, 107, 108, 109, 110, 111, 112, 112, 114, 114,
115, 116, 116, 117, 117, 117, 117, 119, 119, 119, 119, 118, 119, 118, 118, 118,
119, 118, 117, 117, 117, 116, 115, 115, 114, 113, 112, 112, 110, 110, 108, 107,
105, 104, 103, 101, 100, 98, 96, 94, 94, 91, 89, 88, 85, 84, 81, 79, 77, 76, 73,
71, 68, 66, 63, 62, 60, 56, 54, 52, 51, 47, 45, 43, 41, 38, 36, 34, 32, 29, 28,
25, 23, 20, 19, 17, 15, 13, 10, 10, 7, 6, 4, 3, 1, -1, -2, -4, -6, -7, -8, -9,
-10, -11, -13, -14, -14, -15, -16, -18, -18, -18, -20, -20, -20, -21, -21, -22,
-22, -22, -23, -23, -23, -22, -23, -23, -23, -23, -22, -22, -22, -23, -22, -22,
-21, -21, -20, -21, -20, -20, -20, -19, -19, -18, -17, -17, -16, -15, -15, -15,
-14, -13, -12, -12, -11, -11, -10, -10, -10, -8, -8, -8, -7, -6, -6, -6, -4, -4,
-3, -2, -2, -2, -1, -1, 1, 1, 1, 2, 2, 3, 3, 4, 4, 4, 4, 4, 5, 4, 6, 6, 6, 5, 6,
7, 6, 8, 7, 7, 8, 8, 8, 8, 9, 9, 10, 10, 10, 11, 11, 10, 12, 12, 11, 12, 12, 12,
12, 13, 12, 12, 12, 12, 12, 12, 12, 12, 12, 11, 11, 11, 11, 11, 10, 10, 10, 10,
10, 9, 9, 9, 9, 9, 8, 8, 8, 6, 8, 7, 6, 6, 6, 6, 5, 5, 5, 4, 4, 4, 3, 3, 2, 1,
1, 0, -1, -2, -2, -3, -4, -4, -5, -6, -7, -8, -8, -9, -10, -10, -11, -11, -12,
-13, -15, -16, -16, -17, -18, -19, -20, -20, -22, -23, -25, -25, -26, -28, -29,
-29, -30, -32, -32, -33, -35, -36, -38, -38, -40, -41, -42, -44, -44, -47, -48,
-49, -51, -51, -53, -54, -55, -57, -58, -59, -61, -61, -63, -63, -65, -66, -67,
-68, -70, -70, -72, -73, -73, -74, -76, -78, -79, -80, -81, -81, -83, -83, -84,
-85, -87, -87, -88, -90, -91, -92, -92, -93, -94, -94, -95, -96, -97, -97, -99,
-100, -100, -100, -101, -102, -102, -103, -104, -105, -105, -105, -107, -106,
-107, -108, -107, -108, -109, -110, -109, -111, -110, -110, -111, -111, -111,
-112, -112, -112, -113, -113, -113, -114, -114, -115, -115, -114, -114, -114,
-115, -115, -115, -115, -116, -116, -117, -116, -117, -116, -116, -116, -117,
-116, -117, -117, -116, -116, -115, -115, -116, -116, -116, -115, -115, -114,
-114, -114, -113, -113, -111, -112, -111, -109, -109, -108, -107, -105, -105,
-104, -101, -101, -99, -99, -96, -95, -93, -92, -90, -88, -86, -83, -81, -79,
-77, -74, -72, -69, -66, -63, -60, -57, -53, -50, -46, -44, -39, -36, -32, -28,
-23, -19, -15, -11, -5, -2, };