#define DATA_LENGTH 512
#define DATA AKWF_ebass_0066

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 12, 17, 23, 27, 31, 37, 41, 45,
49, 53, 58, 61, 65, 69, 73, 75, 78, 81, 84, 87, 89, 92, 95, 96, 98, 100, 102,
104, 105, 108, 109, 110, 112, 113, 115, 115, 116, 117, 117, 118, 117, 118, 119,
119, 119, 119, 119, 119, 119, 118, 117, 117, 117, 115, 116, 115, 114, 114, 113,
111, 111, 109, 109, 108, 106, 106, 104, 102, 102, 99, 98, 97, 95, 93, 91, 88,
88, 86, 83, 81, 78, 76, 74, 70, 69, 67, 64, 62, 58, 56, 53, 51, 49, 45, 43, 41,
38, 34, 31, 29, 25, 23, 19, 17, 13, 10, 7, 4, 0, -3, -6, -8, -12, -13, -16, -19,
-20, -23, -26, -28, -30, -32, -33, -36, -38, -40, -42, -43, -46, -48, -49, -51,
-53, -55, -57, -59, -60, -61, -62, -64, -65, -65, -67, -67, -69, -68, -69, -70,
-71, -72, -72, -72, -73, -74, -75, -76, -75, -76, -77, -77, -78, -78, -79, -79,
-80, -81, -81, -81, -81, -81, -82, -81, -82, -81, -81, -82, -81, -82, -82, -82,
-82, -83, -82, -82, -84, -83, -83, -84, -83, -85, -84, -85, -85, -85, -84, -85,
-86, -85, -85, -86, -85, -84, -84, -84, -84, -84, -83, -84, -83, -84, -83, -83,
-83, -84, -84, -84, -84, -84, -85, -85, -86, -85, -86, -86, -86, -86, -86, -87,
-87, -85, -86, -86, -86, -85, -85, -85, -85, -85, -85, -85, -85, -85, -84, -85,
-84, -84, -85, -84, -84, -83, -84, -82, -82, -83, -82, -81, -80, -79, -79, -79,
-77, -77, -75, -75, -74, -73, -71, -70, -70, -68, -68, -67, -66, -65, -64, -64,
-63, -61, -61, -60, -59, -58, -57, -56, -55, -53, -52, -51, -49, -47, -46, -44,
-42, -40, -38, -37, -34, -33, -31, -28, -25, -23, -21, -19, -18, -14, -12, -10,
-8, -6, -3, -1, 1, 4, 5, 6, 9, 10, 12, 14, 15, 16, 18, 19, 20, 21, 22, 24, 25,
25, 27, 27, 28, 29, 31, 31, 32, 34, 35, 35, 37, 38, 39, 40, 41, 43, 42, 45, 46,
47, 48, 48, 50, 51, 52, 54, 55, 56, 56, 57, 58, 59, 59, 60, 60, 60, 61, 61, 62,
62, 61, 62, 62, 62, 62, 62, 61, 62, 62, 61, 61, 61, 63, 62, 63, 63, 64, 65, 65,
66, 67, 67, 69, 69, 71, 71, 73, 73, 74, 75, 76, 75, 76, 76, 76, 76, 76, 77, 76,
75, 76, 75, 76, 75, 74, 73, 74, 72, 71, 70, 70, 68, 67, 67, 64, 63, 62, 59, 58,
56, 53, 52, 50, 47, 44, 43, 41, 38, 35, 32, 31, 28, 25, 22, 19, 17, 14, 11, 8,
5, 1, -2, -5, -9, -13, -16, -19, -23, -27, -31, -35, -36, -40, -43, -47, -50,
-53, -55, -57, -60, -62, -64, -65, -67, -69, -69, -70, -70, -72, -72, -73, -72,
-72, -71, -72, -71, -71, -69, -68, -67, -65, -63, -61, -60, -57, -55, -53, -50,
-48, -45, -42, -37, -34, -29, -26, -22, -18, -13, -8, -3, };