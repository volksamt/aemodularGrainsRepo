#define DATA_LENGTH 512
#define DATA AKWF_ebass_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 5, 5, 7, 10, 11, 13, 16, 17, 19,
21, 23, 23, 25, 26, 28, 29, 29, 30, 31, 33, 34, 34, 36, 37, 37, 38, 40, 41, 41,
42, 43, 44, 44, 45, 46, 47, 47, 47, 48, 49, 50, 51, 50, 51, 51, 51, 52, 52, 52,
52, 52, 53, 52, 53, 53, 52, 52, 52, 52, 53, 53, 52, 53, 52, 54, 53, 54, 53, 54,
54, 54, 54, 55, 55, 55, 55, 55, 55, 55, 55, 55, 56, 55, 56, 55, 55, 55, 55, 53,
54, 53, 52, 52, 51, 51, 49, 50, 49, 49, 48, 47, 47, 47, 46, 46, 45, 45, 45, 45,
44, 44, 44, 44, 44, 44, 44, 44, 44, 43, 44, 42, 42, 41, 41, 41, 41, 40, 39, 39,
38, 37, 37, 36, 36, 36, 34, 35, 34, 35, 32, 33, 33, 32, 31, 31, 31, 30, 29, 28,
29, 27, 28, 28, 28, 27, 27, 26, 25, 25, 26, 26, 25, 25, 24, 24, 24, 23, 24, 23,
23, 23, 22, 23, 23, 22, 21, 22, 21, 20, 21, 19, 19, 18, 18, 18, 18, 17, 17, 17,
15, 15, 16, 15, 15, 14, 14, 12, 13, 12, 11, 11, 11, 10, 10, 10, 10, 9, 9, 9, 8,
8, 7, 6, 7, 6, 6, 6, 6, 6, 6, 6, 6, 5, 5, 6, 5, 5, 5, 4, 4, 3, 4, 3, 2, 2, 1, 1,
0, -2, -2, -3, -2, -4, -4, -5, -6, -6, -7, -7, -8, -8, -9, -8, -8, -7, -8, -7,
-7, -6, -5, -5, -4, -4, -3, -2, -3, -2, -1, -1, -2, -2, -2, -2, -2, -2, -3, -3,
-3, -4, -5, -4, -5, -6, -7, -7, -8, -7, -8, -8, -9, -9, -9, -9, -9, -10, -9,
-10, -10, -9, -9, -9, -10, -8, -8, -8, -7, -6, -6, -5, -4, -3, -1, -1, 0, 2, 2,
3, 4, 5, 5, 7, 7, 8, 8, 8, 8, 8, 8, 7, 9, 9, 8, 8, 7, 7, 7, 7, 7, 7, 7, 7, 8, 9,
9, 9, 9, 10, 11, 12, 13, 13, 14, 15, 17, 17, 18, 19, 21, 21, 23, 23, 24, 24, 25,
26, 26, 25, 26, 27, 26, 26, 25, 26, 24, 24, 22, 22, 20, 20, 18, 17, 16, 13, 11,
9, 7, 5, 2, 0, -3, -6, -8, -10, -13, -14, -17, -19, -21, -23, -25, -27, -29,
-31, -32, -33, -36, -37, -39, -40, -42, -45, -47, -48, -50, -52, -54, -57, -59,
-61, -64, -67, -70, -73, -77, -80, -83, -86, -89, -93, -96, -98, -101, -103,
-106, -107, -110, -111, -113, -114, -115, -116, -117, -118, -118, -119, -119,
-119, -119, -118, -119, -118, -118, -117, -117, -115, -114, -114, -113, -113,
-111, -110, -109, -107, -106, -105, -103, -102, -100, -98, -95, -93, -92, -91,
-88, -85, -83, -80, -79, -76, -75, -72, -70, -68, -65, -63, -60, -59, -56, -52,
-51, -48, -45, -42, -40, -38, -35, -33, -29, -27, -25, -24, -20, -17, -15, -12,
-10, -8, -5, -3, -1, };