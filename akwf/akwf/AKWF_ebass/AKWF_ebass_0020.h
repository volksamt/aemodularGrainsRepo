#define DATA_LENGTH 512
#define DATA AKWF_ebass_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 6, 8, 11, 14, 16, 17, 21, 23,
25, 27, 30, 31, 35, 36, 39, 42, 44, 46, 48, 51, 53, 55, 57, 60, 61, 65, 66, 68,
70, 72, 75, 76, 79, 80, 82, 84, 86, 88, 90, 92, 93, 95, 96, 97, 100, 101, 103,
104, 106, 107, 108, 109, 110, 112, 112, 114, 114, 115, 116, 117, 117, 118, 118,
118, 118, 119, 119, 119, 119, 119, 119, 119, 118, 118, 117, 116, 115, 114, 112,
113, 110, 109, 108, 106, 104, 103, 101, 99, 97, 94, 92, 90, 87, 85, 83, 79, 76,
74, 70, 68, 65, 62, 59, 56, 53, 50, 47, 45, 40, 39, 36, 32, 29, 26, 22, 20, 16,
14, 10, 8, 5, 2, -1, -4, -7, -10, -12, -15, -17, -20, -22, -26, -28, -30, -33,
-34, -37, -39, -41, -43, -45, -47, -49, -51, -53, -55, -57, -57, -59, -61, -62,
-63, -64, -66, -67, -68, -68, -69, -70, -70, -71, -71, -72, -72, -73, -72, -73,
-73, -73, -72, -72, -72, -72, -71, -70, -71, -70, -68, -69, -67, -66, -65, -64,
-63, -62, -60, -60, -58, -57, -57, -55, -53, -52, -51, -50, -49, -47, -45, -44,
-42, -41, -40, -39, -38, -37, -34, -34, -33, -31, -30, -30, -28, -26, -25, -24,
-23, -22, -21, -20, -19, -18, -18, -16, -15, -15, -14, -13, -12, -12, -10, -10,
-10, -9, -9, -8, -7, -7, -5, -5, -4, -3, -3, -3, -2, -1, 0, 1, 2, 2, 3, 5, 4, 6,
6, 7, 8, 9, 10, 11, 11, 12, 13, 14, 16, 16, 17, 19, 20, 20, 22, 23, 23, 25, 25,
27, 28, 29, 30, 32, 32, 33, 34, 35, 36, 37, 39, 40, 41, 42, 44, 44, 46, 46, 47,
49, 49, 50, 50, 52, 53, 54, 54, 55, 56, 56, 58, 57, 58, 59, 59, 59, 60, 60, 61,
61, 61, 61, 61, 61, 61, 61, 60, 60, 60, 59, 59, 58, 58, 57, 57, 56, 56, 54, 53,
52, 51, 50, 49, 48, 46, 46, 44, 43, 41, 39, 38, 37, 36, 35, 33, 31, 29, 28, 26,
25, 23, 21, 19, 18, 16, 15, 14, 12, 9, 8, 7, 4, 3, 2, 0, -2, -4, -6, -7, -8,
-10, -11, -13, -15, -16, -17, -19, -20, -22, -22, -24, -26, -27, -28, -28, -30,
-32, -34, -35, -35, -36, -38, -38, -40, -42, -42, -44, -44, -45, -46, -48, -48,
-50, -51, -51, -51, -53, -54, -54, -55, -56, -57, -58, -58, -59, -60, -60, -62,
-62, -61, -63, -63, -64, -64, -64, -65, -65, -66, -67, -67, -69, -69, -68, -69,
-70, -70, -70, -70, -71, -71, -71, -72, -71, -72, -72, -72, -71, -72, -72, -71,
-72, -72, -72, -71, -71, -71, -70, -70, -70, -69, -68, -68, -67, -67, -66, -66,
-64, -64, -62, -62, -61, -59, -58, -56, -56, -54, -53, -52, -50, -48, -47, -45,
-44, -42, -41, -39, -37, -36, -33, -32, -30, -27, -25, -24, -22, -20, -18, -15,
-13, -10, -9, -7, -4, -2, -1, };