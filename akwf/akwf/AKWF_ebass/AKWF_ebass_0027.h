#define DATA_LENGTH 512
#define DATA AKWF_ebass_0027

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 6, 9, 9, 12, 14, 16, 18, 20,
22, 24, 28, 30, 32, 36, 37, 41, 43, 45, 48, 51, 53, 55, 57, 59, 61, 65, 67, 68,
69, 71, 73, 75, 77, 77, 78, 79, 80, 80, 80, 81, 82, 82, 83, 81, 82, 82, 82, 81,
82, 81, 80, 80, 79, 79, 78, 78, 77, 77, 76, 76, 76, 75, 76, 75, 76, 76, 76, 76,
75, 76, 77, 77, 78, 78, 79, 79, 81, 81, 82, 81, 82, 81, 82, 82, 82, 83, 84, 83,
84, 85, 85, 86, 86, 86, 87, 87, 86, 86, 86, 86, 85, 85, 85, 85, 85, 86, 85, 87,
87, 88, 88, 88, 88, 88, 88, 89, 89, 89, 90, 90, 89, 90, 90, 90, 91, 92, 92, 93,
93, 94, 94, 95, 95, 95, 95, 96, 95, 96, 97, 97, 97, 96, 97, 97, 97, 97, 97, 97,
96, 96, 97, 95, 96, 95, 95, 94, 93, 93, 92, 91, 91, 90, 90, 88, 87, 86, 85, 85,
83, 81, 81, 79, 77, 76, 75, 73, 72, 71, 69, 68, 67, 64, 63, 62, 60, 58, 57, 55,
53, 52, 50, 49, 46, 45, 43, 42, 40, 39, 37, 36, 34, 33, 31, 30, 28, 27, 25, 23,
22, 21, 18, 17, 14, 13, 12, 10, 8, 7, 5, 3, 0, -1, -3, -5, -8, -9, -11, -14,
-15, -18, -19, -22, -25, -27, -28, -31, -34, -36, -39, -41, -45, -47, -49, -51,
-53, -56, -58, -61, -63, -65, -67, -69, -72, -75, -78, -79, -81, -84, -86, -88,
-89, -92, -95, -96, -97, -99, -102, -103, -104, -106, -108, -109, -110, -111,
-112, -113, -114, -115, -116, -117, -118, -117, -118, -119, -119, -118, -119,
-119, -119, -118, -119, -118, -118, -118, -117, -116, -116, -115, -114, -113,
-112, -111, -110, -110, -108, -109, -107, -107, -105, -104, -103, -103, -102,
-100, -100, -99, -98, -97, -97, -97, -96, -96, -95, -95, -94, -94, -93, -93,
-92, -92, -92, -91, -91, -90, -90, -90, -90, -89, -88, -88, -87, -87, -86, -85,
-84, -82, -81, -82, -79, -79, -77, -76, -75, -74, -72, -71, -70, -68, -67, -65,
-64, -63, -61, -59, -57, -57, -55, -52, -52, -51, -50, -47, -47, -45, -44, -42,
-41, -39, -38, -37, -36, -36, -34, -33, -33, -32, -31, -29, -29, -28, -28, -27,
-27, -26, -26, -26, -25, -26, -25, -25, -25, -25, -25, -24, -25, -25, -25, -25,
-26, -26, -27, -26, -27, -27, -28, -28, -28, -29, -28, -29, -29, -29, -29, -29,
-30, -30, -31, -31, -31, -31, -32, -32, -31, -31, -31, -32, -31, -31, -30, -30,
-30, -30, -29, -28, -28, -28, -28, -26, -26, -25, -24, -23, -23, -22, -22, -21,
-20, -19, -18, -18, -16, -15, -15, -14, -13, -13, -13, -12, -12, -11, -11, -10,
-11, -10, -10, -10, -9, -10, -9, -9, -8, -9, -10, -9, -10, -9, -9, -10, -11,
-10, -10, -10, -10, -10, -9, -9, -10, -9, -9, -8, -8, -7, -6, -6, -5, -4, -2,
-2, 0, };