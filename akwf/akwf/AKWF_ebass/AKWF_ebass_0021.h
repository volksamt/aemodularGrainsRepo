#define DATA_LENGTH 512
#define DATA AKWF_ebass_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 6, 6, 9, 9, 12, 13, 14, 16,
17, 19, 20, 22, 23, 24, 26, 27, 29, 29, 30, 33, 32, 35, 35, 37, 39, 39, 40, 41,
43, 43, 46, 47, 47, 49, 50, 51, 52, 54, 54, 54, 56, 57, 58, 58, 59, 60, 61, 62,
63, 64, 65, 66, 66, 67, 68, 69, 69, 70, 71, 72, 72, 74, 74, 74, 75, 76, 76, 77,
77, 78, 79, 79, 80, 81, 81, 81, 83, 82, 83, 84, 84, 84, 85, 85, 85, 87, 86, 87,
86, 88, 87, 88, 88, 88, 88, 89, 89, 89, 90, 90, 90, 90, 90, 90, 90, 90, 91, 91,
90, 91, 91, 92, 91, 91, 91, 91, 91, 91, 91, 90, 90, 90, 90, 90, 90, 91, 90, 90,
90, 90, 89, 89, 89, 88, 89, 88, 88, 88, 87, 87, 87, 87, 86, 86, 85, 85, 85, 83,
84, 83, 83, 82, 82, 82, 81, 80, 80, 80, 79, 79, 79, 78, 78, 77, 76, 76, 76, 75,
75, 74, 74, 72, 73, 72, 71, 71, 70, 70, 69, 69, 68, 68, 67, 66, 65, 65, 65, 63,
63, 62, 62, 62, 61, 60, 59, 60, 59, 58, 58, 56, 56, 56, 55, 55, 55, 54, 54, 52,
52, 52, 52, 51, 51, 50, 49, 50, 49, 49, 48, 48, 47, 47, 47, 46, 45, 46, 46, 45,
45, 45, 45, 45, 43, 43, 44, 43, 44, 43, 42, 43, 43, 43, 43, 43, 42, 43, 43, 42,
43, 42, 43, 43, 42, 42, 44, 42, 43, 43, 44, 44, 44, 44, 44, 45, 45, 45, 45, 45,
44, 45, 44, 45, 45, 45, 45, 45, 45, 45, 45, 45, 45, 45, 45, 45, 44, 45, 45, 44,
44, 43, 43, 42, 42, 42, 41, 41, 40, 39, 39, 38, 37, 37, 36, 34, 33, 33, 31, 30,
30, 29, 27, 26, 25, 23, 22, 21, 19, 19, 17, 14, 13, 12, 10, 9, 6, 6, 4, 2, 1,
-1, -4, -5, -7, -9, -11, -13, -14, -15, -19, -20, -22, -24, -25, -27, -30, -31,
-33, -34, -37, -39, -41, -42, -46, -46, -48, -50, -52, -55, -56, -58, -59, -61,
-62, -64, -66, -68, -70, -71, -74, -75, -76, -78, -79, -81, -82, -84, -86, -87,
-89, -91, -92, -93, -94, -95, -97, -98, -99, -101, -102, -103, -103, -104, -106,
-107, -107, -109, -110, -110, -111, -112, -113, -114, -114, -115, -115, -116,
-116, -117, -117, -117, -118, -118, -118, -119, -119, -119, -119, -119, -118,
-120, -119, -119, -118, -119, -118, -118, -118, -117, -117, -116, -116, -116,
-114, -113, -112, -112, -112, -110, -110, -110, -107, -107, -105, -105, -104,
-102, -101, -100, -98, -97, -96, -94, -94, -92, -90, -89, -87, -85, -84, -83,
-81, -80, -77, -75, -74, -73, -71, -70, -67, -66, -65, -63, -61, -59, -57, -56,
-54, -52, -50, -49, -47, -45, -43, -41, -39, -39, -36, -35, -33, -32, -30, -28,
-26, -24, -23, -22, -19, -18, -17, -15, -13, -11, -9, -8, -6, -4, -3, -2, 0, };