#define DATA_LENGTH 512
#define DATA AKWF_ebass_0039

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 9, 12, 14, 18, 20, 22, 25,
28, 30, 33, 35, 37, 40, 42, 45, 48, 48, 51, 54, 55, 58, 60, 62, 64, 66, 68, 69,
72, 74, 76, 77, 78, 80, 82, 84, 86, 86, 88, 90, 91, 91, 93, 93, 94, 95, 95, 96,
96, 96, 96, 96, 96, 95, 94, 95, 95, 94, 92, 91, 91, 91, 89, 88, 87, 86, 84, 83,
82, 80, 79, 77, 76, 74, 72, 70, 69, 67, 66, 64, 62, 61, 59, 57, 56, 54, 52, 51,
51, 49, 47, 46, 44, 43, 41, 41, 40, 39, 38, 36, 35, 34, 33, 33, 32, 31, 30, 29,
28, 27, 26, 26, 25, 25, 24, 23, 22, 23, 21, 21, 21, 20, 19, 19, 19, 20, 19, 18,
18, 18, 18, 19, 18, 18, 18, 18, 17, 18, 18, 17, 17, 17, 17, 16, 16, 15, 15, 15,
15, 15, 13, 13, 13, 12, 12, 11, 10, 9, 9, 8, 8, 7, 7, 6, 6, 5, 5, 4, 3, 2, 2, 1,
0, -1, -1, -2, -3, -3, -4, -4, -5, -6, -6, -8, -8, -8, -9, -9, -10, -11, -11,
-13, -14, -14, -13, -15, -16, -17, -18, -18, -19, -20, -21, -22, -23, -24, -24,
-26, -28, -29, -29, -30, -30, -32, -32, -33, -34, -35, -36, -36, -37, -37, -38,
-37, -39, -39, -39, -39, -39, -39, -40, -40, -40, -40, -39, -40, -40, -39, -40,
-40, -39, -39, -39, -38, -38, -38, -38, -38, -38, -37, -36, -36, -36, -35, -35,
-35, -35, -35, -33, -34, -33, -33, -33, -32, -33, -31, -31, -31, -31, -29, -28,
-28, -27, -27, -26, -26, -25, -25, -24, -24, -22, -21, -21, -20, -19, -19, -18,
-18, -17, -17, -17, -15, -15, -16, -14, -15, -14, -13, -13, -13, -13, -11, -11,
-10, -11, -10, -9, -8, -7, -6, -6, -4, -4, -3, -2, -2, -2, 0, 0, 1, 1, 1, 2, 2,
4, 4, 5, 5, 4, 5, 6, 5, 5, 5, 6, 6, 5, 6, 6, 6, 5, 5, 5, 4, 4, 4, 4, 3, 2, 2, 2,
1, 1, 0, -1, -1, -2, -3, -4, -5, -5, -6, -7, -8, -9, -9, -10, -11, -13, -13,
-14, -15, -14, -16, -17, -17, -18, -19, -19, -20, -21, -22, -23, -24, -26, -25,
-27, -28, -29, -30, -32, -33, -34, -35, -36, -37, -38, -40, -42, -43, -45, -47,
-47, -49, -50, -52, -53, -55, -57, -59, -61, -63, -65, -66, -68, -71, -72, -73,
-76, -78, -80, -82, -84, -86, -89, -90, -92, -94, -96, -98, -100, -102, -103,
-105, -107, -108, -109, -111, -111, -113, -115, -115, -116, -117, -118, -119,
-119, -119, -120, -119, -119, -119, -119, -117, -117, -116, -116, -116, -115,
-113, -112, -111, -110, -108, -107, -105, -104, -102, -101, -97, -96, -93, -92,
-90, -87, -85, -82, -81, -78, -74, -73, -69, -68, -65, -63, -61, -58, -54, -53,
-51, -48, -45, -42, -41, -38, -36, -33, -31, -28, -26, -24, -21, -19, -16, -14,
-11, -8, -5, -3, 0, };