#define DATA_LENGTH 512
#define DATA AKWF_ebass_0051

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 16, 23, 28, 34, 40, 46, 54, 61,
66, 73, 77, 82, 87, 92, 95, 100, 104, 108, 111, 114, 115, 117, 114, 113, 112,
111, 112, 114, 115, 116, 117, 118, 120, 120, 117, 115, 111, 108, 106, 103, 102,
100, 99, 99, 99, 100, 99, 98, 96, 92, 91, 86, 83, 77, 73, 70, 67, 66, 66, 66,
64, 63, 59, 57, 54, 52, 50, 47, 45, 45, 46, 45, 45, 45, 45, 43, 41, 39, 37, 35,
33, 31, 31, 30, 31, 31, 31, 32, 32, 31, 29, 27, 25, 22, 18, 16, 14, 11, 9, 6, 4,
2, 0, -3, -5, -9, -14, -18, -22, -27, -32, -36, -41, -47, -51, -56, -60, -64,
-68, -72, -76, -78, -80, -82, -84, -88, -90, -93, -97, -100, -103, -105, -106,
-108, -109, -108, -108, -107, -105, -105, -103, -102, -101, -100, -99, -100,
-97, -95, -93, -91, -89, -88, -85, -82, -77, -71, -66, -62, -57, -52, -46, -40,
-35, -28, -22, -18, -13, -9, -5, -1, 3, 6, 10, 15, 19, 24, 29, 34, 40, 46, 50,
54, 56, 57, 61, 64, 68, 73, 75, 77, 78, 78, 78, 77, 76, 75, 74, 74, 75, 76, 78,
80, 81, 84, 84, 83, 82, 80, 78, 75, 75, 74, 75, 75, 75, 74, 75, 75, 74, 72, 69,
64, 61, 56, 53, 50, 50, 47, 47, 47, 48, 48, 46, 46, 43, 40, 37, 35, 33, 31, 31,
31, 31, 31, 31, 30, 27, 27, 25, 23, 22, 20, 19, 19, 20, 21, 21, 23, 23, 23, 22,
21, 18, 16, 14, 12, 8, 6, 3, 1, -1, -3, -6, -9, -13, -15, -19, -22, -27, -31,
-34, -37, -40, -44, -47, -52, -57, -61, -64, -68, -73, -75, -80, -82, -85, -89,
-92, -97, -100, -103, -107, -110, -113, -114, -116, -117, -115, -113, -110,
-110, -108, -108, -106, -106, -104, -102, -101, -101, -100, -99, -98, -96, -91,
-88, -85, -82, -77, -74, -71, -67, -60, -55, -50, -45, -39, -36, -31, -26, -21,
-16, -12, -9, -8, -5, -1, 3, 8, 13, 18, 22, 25, 27, 29, 32, 35, 37, 39, 41, 43,
45, 47, 48, 47, 47, 45, 44, 41, 41, 40, 41, 43, 45, 46, 49, 49, 48, 46, 45, 43,
41, 40, 37, 37, 35, 35, 35, 35, 35, 34, 34, 32, 29, 27, 25, 21, 19, 18, 17, 17,
18, 18, 18, 19, 19, 17, 15, 12, 8, 6, 6, 6, 8, 9, 8, 9, 10, 11, 11, 11, 9, 8, 8,
7, 9, 10, 12, 13, 14, 16, 18, 20, 20, 21, 21, 19, 19, 18, 16, 14, 12, 11, 11,
10, 8, 6, 4, 1, -3, -5, -9, -14, -17, -21, -25, -28, -33, -37, -43, -48, -54,
-57, -61, -65, -70, -76, -80, -84, -88, -92, -96, -102, -106, -110, -114, -116,
-116, -117, -116, -117, -117, -116, -116, -115, -113, -113, -112, -113, -112,
-112, -112, -110, -107, -104, -102, -99, -96, -91, -86, -79, -72, -64, -57, -52,
-44, -37, -30, -21, -13, -5, 1, };