#define DATA_LENGTH 512
#define DATA AKWF_ebass_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 9, 11, 14, 17, 20, 23, 25,
29, 30, 33, 36, 38, 41, 44, 45, 48, 51, 53, 55, 57, 60, 62, 64, 66, 69, 71, 74,
75, 78, 79, 81, 84, 86, 87, 88, 91, 92, 94, 95, 96, 98, 99, 100, 102, 104, 104,
105, 106, 108, 108, 110, 110, 112, 113, 114, 115, 115, 116, 117, 117, 118, 119,
119, 119, 118, 118, 119, 118, 119, 119, 118, 117, 118, 117, 118, 117, 117, 116,
115, 114, 115, 114, 114, 114, 113, 112, 112, 111, 109, 109, 108, 106, 106, 105,
103, 102, 101, 99, 97, 97, 95, 93, 92, 91, 89, 88, 87, 84, 84, 82, 81, 78, 76,
75, 73, 70, 70, 67, 65, 64, 62, 60, 57, 56, 54, 53, 50, 49, 47, 45, 44, 41, 39,
37, 36, 34, 32, 30, 28, 27, 25, 24, 21, 19, 17, 14, 13, 11, 9, 7, 5, 3, 1, -1,
-3, -5, -7, -8, -10, -11, -13, -15, -16, -17, -19, -20, -21, -22, -24, -24, -26,
-27, -27, -28, -28, -29, -31, -31, -31, -32, -32, -33, -33, -33, -35, -34, -35,
-36, -36, -36, -36, -37, -36, -36, -37, -37, -36, -37, -37, -37, -36, -37, -35,
-35, -34, -34, -34, -33, -33, -33, -31, -30, -30, -29, -28, -28, -26, -26, -24,
-24, -23, -23, -23, -22, -22, -21, -22, -21, -21, -21, -23, -23, -23, -23, -24,
-26, -26, -28, -29, -30, -32, -32, -34, -35, -37, -39, -41, -41, -43, -46, -47,
-49, -51, -52, -54, -56, -59, -60, -62, -64, -67, -69, -70, -73, -75, -76, -79,
-80, -82, -85, -87, -89, -91, -93, -96, -96, -98, -99, -101, -103, -104, -105,
-106, -107, -107, -108, -108, -108, -108, -107, -106, -106, -105, -105, -104,
-102, -100, -99, -96, -93, -91, -89, -86, -83, -80, -77, -73, -69, -66, -62,
-58, -55, -51, -46, -42, -38, -33, -28, -25, -20, -16, -10, -7, -2, 2, 7, 12,
16, 20, 24, 28, 32, 36, 40, 43, 47, 51, 54, 57, 61, 63, 65, 69, 70, 73, 76, 77,
79, 81, 82, 84, 86, 86, 87, 87, 88, 88, 89, 88, 88, 88, 87, 87, 87, 86, 85, 83,
83, 81, 79, 77, 76, 73, 71, 70, 67, 66, 63, 60, 57, 55, 53, 49, 45, 43, 40, 37,
34, 30, 28, 23, 21, 18, 14, 11, 7, 3, 0, -3, -7, -9, -13, -16, -20, -23, -26,
-30, -32, -36, -39, -43, -45, -47, -51, -54, -56, -58, -62, -64, -67, -69, -72,
-73, -76, -79, -80, -82, -85, -87, -88, -90, -92, -93, -94, -96, -97, -98, -99,
-101, -101, -102, -102, -103, -104, -105, -104, -105, -105, -106, -105, -107,
-106, -105, -105, -106, -104, -103, -103, -103, -102, -101, -100, -100, -98,
-97, -96, -95, -93, -92, -90, -89, -87, -86, -85, -83, -82, -80, -77, -75, -73,
-72, -69, -67, -65, -63, -61, -59, -56, -53, -51, -48, -45, -44, -41, -39, -36,
-33, -30, -29, -26, -23, -20, -17, -14, -13, -9, -7, -4, -2, };