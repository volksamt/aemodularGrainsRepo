#define DATA_LENGTH 512
#define DATA AKWF_ebass_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 2, 4, 4, 7, 8, 10, 11, 13, 15, 16,
18, 19, 20, 21, 23, 23, 25, 26, 28, 29, 31, 31, 33, 34, 35, 36, 37, 38, 38, 39,
41, 41, 43, 44, 44, 44, 46, 46, 47, 48, 48, 49, 50, 50, 50, 52, 52, 53, 53, 53,
54, 54, 55, 55, 56, 56, 56, 56, 56, 57, 57, 57, 57, 58, 58, 58, 57, 59, 59, 58,
59, 58, 59, 59, 59, 59, 59, 58, 58, 58, 58, 59, 58, 59, 58, 57, 57, 58, 57, 57,
56, 57, 56, 57, 56, 56, 56, 56, 55, 54, 55, 55, 55, 54, 54, 54, 54, 53, 53, 53,
53, 51, 51, 51, 50, 50, 51, 50, 50, 49, 49, 48, 48, 49, 48, 48, 47, 47, 46, 46,
46, 45, 45, 45, 44, 43, 44, 43, 43, 42, 42, 42, 42, 41, 40, 41, 40, 40, 40, 39,
38, 39, 38, 37, 36, 36, 37, 35, 36, 34, 34, 35, 35, 34, 33, 34, 33, 33, 32, 31,
30, 31, 31, 29, 29, 29, 29, 27, 28, 27, 28, 27, 26, 26, 26, 25, 24, 24, 23, 23,
23, 22, 22, 21, 21, 22, 20, 20, 20, 19, 19, 18, 18, 18, 17, 17, 16, 16, 15, 15,
15, 16, 15, 14, 13, 14, 14, 13, 13, 13, 13, 13, 11, 12, 12, 10, 11, 10, 10, 10,
9, 9, 9, 9, 8, 7, 7, 7, 8, 7, 7, 6, 6, 6, 5, 5, 6, 5, 5, 6, 5, 4, 5, 4, 5, 5, 3,
4, 3, 4, 3, 4, 3, 4, 4, 5, 5, 5, 5, 5, 4, 5, 4, 5, 5, 6, 5, 5, 5, 5, 5, 6, 6, 6,
6, 6, 7, 7, 7, 7, 8, 8, 8, 8, 9, 9, 10, 9, 10, 10, 10, 12, 11, 12, 12, 13, 14,
13, 14, 14, 15, 16, 16, 16, 17, 17, 18, 18, 18, 19, 20, 20, 19, 20, 20, 21, 21,
22, 21, 21, 22, 21, 22, 22, 21, 21, 21, 22, 21, 20, 21, 20, 20, 19, 19, 18, 18,
17, 17, 16, 15, 15, 14, 13, 11, 12, 10, 9, 8, 6, 6, 4, 3, 2, 0, -1, -3, -4, -6,
-7, -9, -11, -13, -15, -17, -18, -21, -23, -25, -26, -29, -30, -33, -36, -37,
-40, -42, -44, -47, -48, -51, -54, -56, -57, -60, -63, -65, -67, -70, -71, -74,
-75, -79, -81, -82, -85, -86, -88, -90, -92, -94, -95, -98, -99, -100, -102,
-104, -105, -107, -108, -109, -110, -112, -112, -113, -114, -115, -115, -116,
-117, -118, -117, -118, -118, -119, -119, -119, -119, -118, -118, -119, -118,
-118, -118, -117, -117, -117, -114, -115, -113, -113, -112, -111, -109, -107,
-107, -106, -105, -103, -100, -100, -99, -97, -95, -93, -91, -90, -88, -87, -84,
-83, -80, -78, -76, -75, -72, -70, -68, -67, -65, -62, -59, -58, -55, -53, -51,
-48, -47, -45, -43, -40, -38, -36, -33, -31, -29, -27, -25, -23, -21, -18, -17,
-15, -12, -10, -8, -7, -6, -5, -3, -1, };