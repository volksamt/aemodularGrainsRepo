#define DATA_LENGTH 512
#define DATA AKWF_ebass_0062

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 12, 14, 18, 20, 23, 26, 27,
30, 32, 35, 38, 39, 42, 43, 45, 47, 49, 51, 52, 53, 55, 56, 57, 59, 60, 62, 62,
63, 65, 66, 66, 68, 68, 69, 71, 71, 72, 72, 73, 73, 75, 74, 76, 77, 76, 77, 77,
78, 78, 79, 78, 80, 80, 80, 80, 80, 81, 81, 81, 81, 82, 81, 83, 82, 81, 82, 82,
82, 82, 82, 82, 82, 83, 83, 82, 82, 82, 82, 82, 82, 82, 81, 81, 81, 82, 82, 82,
81, 81, 81, 81, 80, 81, 80, 80, 79, 79, 78, 79, 79, 78, 78, 77, 77, 76, 77, 77,
77, 76, 75, 76, 75, 74, 75, 74, 74, 73, 73, 72, 72, 72, 72, 72, 71, 71, 70, 70,
69, 70, 69, 69, 69, 68, 68, 67, 67, 66, 66, 65, 65, 64, 64, 64, 63, 63, 63, 62,
61, 61, 60, 60, 59, 59, 59, 58, 57, 57, 57, 57, 56, 56, 55, 55, 54, 54, 52, 53,
52, 52, 52, 51, 50, 51, 49, 49, 48, 48, 48, 46, 45, 46, 45, 45, 43, 43, 42, 41,
41, 40, 39, 39, 39, 37, 37, 37, 35, 35, 35, 33, 34, 34, 33, 31, 31, 30, 30, 29,
29, 28, 28, 27, 27, 26, 26, 26, 25, 24, 23, 22, 22, 22, 22, 21, 20, 20, 19, 19,
19, 17, 17, 18, 17, 16, 16, 14, 15, 15, 13, 13, 13, 12, 12, 11, 11, 11, 10, 10,
9, 9, 10, 9, 8, 9, 8, 9, 8, 8, 8, 8, 8, 8, 8, 7, 9, 8, 8, 9, 9, 9, 9, 10, 9, 11,
10, 10, 10, 10, 11, 11, 12, 12, 12, 13, 12, 13, 14, 15, 14, 16, 15, 16, 17, 17,
18, 18, 19, 20, 21, 21, 21, 22, 23, 23, 25, 25, 26, 27, 28, 28, 28, 30, 30, 31,
32, 32, 33, 34, 35, 35, 35, 36, 36, 37, 37, 38, 38, 38, 39, 38, 38, 38, 38, 38,
38, 38, 37, 38, 37, 37, 37, 35, 34, 34, 32, 32, 31, 30, 29, 28, 26, 25, 23, 23,
20, 18, 17, 14, 12, 10, 7, 5, 2, 0, -4, -6, -9, -12, -16, -18, -22, -25, -29,
-32, -35, -38, -41, -44, -47, -49, -53, -55, -58, -61, -63, -66, -68, -72, -74,
-77, -79, -81, -83, -85, -87, -88, -90, -91, -93, -96, -97, -98, -99, -101,
-102, -103, -104, -106, -107, -107, -109, -109, -110, -111, -112, -113, -114,
-114, -114, -114, -115, -116, -116, -117, -117, -118, -117, -118, -119, -118,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -118, -119, -119,
-119, -118, -118, -118, -116, -117, -116, -116, -116, -115, -115, -114, -113,
-112, -112, -111, -110, -109, -109, -108, -107, -106, -105, -104, -102, -102,
-100, -98, -97, -96, -95, -93, -91, -90, -88, -87, -85, -82, -81, -80, -77, -74,
-72, -70, -67, -65, -62, -59, -57, -53, -51, -49, -46, -42, -40, -36, -32, -29,
-25, -22, -19, -15, -12, -10, -7, -4, -1, };