#define DATA_LENGTH 512
#define DATA AKWF_ebass_0052

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 6, 8, 9, 10, 10, 9, 10, 10,
12, 13, 14, 17, 17, 18, 20, 20, 21, 21, 21, 22, 21, 22, 21, 22, 24, 25, 26, 26,
28, 29, 32, 33, 34, 36, 38, 40, 41, 41, 42, 43, 43, 45, 45, 47, 48, 48, 49, 51,
52, 54, 55, 55, 56, 57, 57, 58, 59, 61, 62, 64, 63, 63, 63, 63, 64, 65, 65, 66,
66, 64, 64, 64, 65, 66, 67, 69, 69, 69, 68, 68, 69, 70, 71, 72, 72, 71, 71, 69,
70, 69, 70, 71, 72, 72, 73, 74, 74, 73, 74, 73, 73, 72, 73, 72, 72, 70, 70, 70,
70, 69, 69, 70, 68, 69, 69, 69, 69, 68, 68, 69, 68, 68, 67, 66, 66, 65, 64, 65,
65, 66, 66, 66, 66, 64, 64, 62, 62, 60, 62, 62, 61, 61, 62, 62, 62, 62, 61, 61,
61, 60, 59, 58, 58, 58, 59, 59, 60, 60, 59, 59, 58, 57, 59, 59, 60, 62, 62, 62,
62, 61, 60, 59, 60, 60, 61, 62, 61, 62, 62, 63, 63, 63, 63, 62, 61, 61, 61, 62,
62, 62, 63, 63, 62, 63, 63, 64, 64, 66, 69, 69, 70, 70, 71, 71, 71, 72, 72, 71,
71, 70, 70, 72, 73, 75, 76, 75, 75, 73, 73, 72, 71, 71, 71, 71, 71, 69, 67, 66,
66, 64, 64, 64, 63, 63, 62, 61, 61, 59, 59, 58, 57, 57, 56, 57, 56, 56, 56, 55,
55, 53, 52, 51, 49, 48, 46, 43, 42, 41, 40, 39, 38, 38, 36, 34, 33, 32, 30, 30,
27, 25, 23, 18, 14, 9, 6, 4, 1, 0, -1, -3, -3, -5, -8, -11, -13, -15, -17, -18,
-20, -22, -23, -23, -24, -24, -23, -25, -27, -27, -29, -31, -32, -33, -34, -36,
-40, -43, -46, -50, -54, -58, -60, -63, -65, -67, -69, -71, -74, -77, -80, -83,
-86, -88, -90, -91, -92, -93, -92, -92, -92, -92, -93, -94, -94, -94, -96, -97,
-98, -99, -100, -101, -103, -104, -105, -105, -106, -106, -106, -106, -106,
-106, -108, -111, -113, -115, -117, -118, -119, -119, -118, -115, -113, -112,
-111, -110, -111, -110, -111, -111, -113, -112, -111, -109, -108, -106, -105,
-105, -105, -105, -105, -105, -105, -105, -103, -102, -101, -100, -100, -101,
-103, -103, -103, -102, -101, -99, -98, -95, -93, -92, -90, -89, -88, -88, -87,
-86, -85, -83, -81, -78, -76, -73, -72, -70, -70, -68, -69, -68, -68, -68, -69,
-68, -69, -69, -70, -70, -69, -69, -67, -66, -65, -63, -61, -61, -61, -61, -61,
-62, -61, -62, -60, -57, -56, -53, -50, -48, -46, -44, -43, -43, -44, -45, -45,
-45, -46, -45, -45, -43, -41, -41, -39, -40, -39, -38, -38, -36, -36, -34, -33,
-33, -32, -32, -32, -33, -32, -32, -32, -31, -29, -27, -27, -25, -24, -24, -24,
-23, -23, -24, -24, -24, -23, -23, -22, -22, -21, -20, -19, -18, -18, -17, -17,
-16, -15, -14, -12, -11, -9, -7, -4, -2, 0, };