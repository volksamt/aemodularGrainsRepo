#define DATA_LENGTH 512
#define DATA AKWF_ebass_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 6, 7, 8, 10, 11, 13, 14, 15,
17, 18, 20, 21, 22, 24, 25, 27, 28, 30, 31, 32, 33, 35, 37, 37, 39, 41, 42, 43,
45, 46, 48, 49, 50, 51, 53, 53, 55, 56, 58, 59, 59, 60, 61, 63, 64, 63, 65, 66,
66, 66, 67, 68, 69, 69, 69, 70, 70, 70, 70, 70, 70, 70, 70, 70, 69, 70, 70, 70,
69, 68, 67, 68, 67, 66, 66, 65, 63, 63, 62, 62, 60, 59, 58, 57, 55, 54, 53, 51,
49, 49, 46, 45, 43, 42, 39, 38, 38, 35, 33, 31, 30, 27, 26, 24, 23, 21, 19, 17,
15, 14, 12, 11, 9, 8, 6, 4, 4, 2, 1, 0, -2, -3, -3, -5, -6, -7, -7, -7, -8, -9,
-10, -10, -9, -10, -9, -10, -10, -9, -9, -9, -9, -9, -8, -7, -7, -6, -5, -5, -3,
-3, -1, 0, 1, 3, 5, 5, 6, 9, 10, 12, 14, 15, 16, 19, 21, 23, 24, 27, 29, 31, 33,
35, 37, 41, 42, 44, 46, 48, 51, 52, 55, 57, 59, 63, 64, 66, 69, 71, 73, 76, 77,
79, 80, 84, 84, 87, 89, 91, 91, 94, 95, 97, 98, 101, 102, 102, 104, 105, 106,
108, 108, 109, 110, 112, 113, 113, 114, 114, 115, 116, 116, 116, 116, 117, 118,
117, 117, 117, 117, 118, 117, 116, 116, 116, 116, 114, 115, 114, 113, 112, 111,
110, 109, 108, 108, 107, 106, 104, 103, 102, 101, 99, 97, 96, 94, 93, 92, 89,
89, 86, 85, 83, 81, 80, 78, 76, 75, 71, 71, 69, 66, 64, 63, 60, 59, 56, 55, 52,
50, 48, 46, 44, 41, 39, 38, 35, 33, 31, 29, 27, 25, 22, 21, 18, 16, 14, 12, 10,
8, 6, 3, 1, -1, -3, -5, -6, -8, -11, -12, -14, -16, -18, -20, -23, -24, -26,
-29, -29, -32, -34, -35, -37, -38, -40, -43, -44, -46, -48, -50, -51, -52, -53,
-56, -57, -59, -61, -62, -63, -65, -66, -67, -69, -70, -72, -74, -74, -76, -78,
-79, -81, -81, -83, -84, -85, -87, -87, -88, -90, -91, -92, -93, -94, -95, -96,
-97, -99, -99, -101, -101, -101, -103, -103, -104, -105, -106, -106, -108, -109,
-109, -110, -110, -111, -112, -112, -113, -114, -114, -115, -115, -116, -116,
-116, -117, -118, -117, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -118, -119, -118, -117, -118, -117, -117,
-117, -116, -115, -115, -115, -114, -114, -113, -113, -112, -112, -111, -110,
-109, -108, -108, -106, -105, -105, -104, -104, -102, -102, -100, -99, -99, -97,
-96, -95, -94, -92, -91, -90, -89, -87, -86, -84, -83, -82, -80, -79, -78, -76,
-75, -74, -72, -71, -69, -68, -66, -65, -63, -61, -60, -59, -56, -56, -55, -53,
-52, -50, -49, -47, -44, -43, -43, -41, -39, -38, -35, -35, -32, -31, -30, -29,
-26, -24, -24, -21, -19, -18, -17, -14, -14, -11, -10, -9, -6, -5, -4, -2, -1,
};