#define DATA_LENGTH 512
#define DATA AKWF_ebass_0057

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 8, 9, 11, 13, 15, 16, 19, 21,
22, 25, 26, 28, 29, 31, 33, 34, 36, 37, 38, 39, 41, 42, 43, 45, 45, 47, 48, 50,
50, 51, 52, 52, 53, 55, 55, 56, 56, 58, 59, 59, 60, 59, 61, 61, 61, 63, 62, 63,
63, 65, 64, 65, 65, 65, 66, 66, 67, 66, 66, 67, 67, 68, 67, 67, 68, 68, 68, 68,
68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 67, 68, 67, 67, 68, 67, 67, 67,
67, 67, 66, 66, 66, 66, 65, 65, 65, 65, 64, 64, 64, 64, 63, 64, 63, 63, 62, 62,
61, 61, 61, 60, 60, 60, 59, 59, 59, 59, 59, 59, 57, 57, 57, 57, 57, 57, 56, 55,
55, 55, 55, 54, 54, 52, 53, 53, 52, 52, 51, 50, 50, 50, 49, 49, 49, 49, 48, 48,
47, 47, 46, 46, 45, 45, 45, 44, 44, 44, 43, 42, 43, 41, 42, 41, 40, 40, 40, 40,
38, 39, 37, 37, 37, 36, 36, 36, 35, 35, 34, 35, 33, 32, 33, 32, 32, 31, 30, 30,
30, 29, 29, 28, 28, 28, 26, 26, 26, 24, 24, 24, 24, 22, 22, 22, 21, 21, 20, 20,
20, 19, 20, 18, 18, 18, 18, 16, 16, 17, 16, 16, 16, 15, 15, 14, 14, 14, 14, 12,
13, 12, 12, 11, 11, 10, 10, 10, 9, 10, 9, 9, 9, 8, 8, 8, 8, 7, 7, 7, 6, 6, 6, 6,
5, 5, 6, 6, 6, 5, 6, 5, 5, 6, 6, 6, 6, 6, 6, 6, 6, 7, 7, 6, 7, 7, 8, 7, 8, 8, 7,
8, 8, 8, 8, 9, 9, 9, 10, 9, 9, 11, 10, 11, 11, 12, 13, 13, 14, 14, 14, 15, 16,
16, 16, 16, 18, 17, 19, 18, 20, 20, 21, 21, 21, 22, 23, 23, 24, 24, 25, 25, 26,
25, 26, 27, 26, 28, 27, 27, 28, 27, 28, 28, 29, 27, 28, 27, 27, 27, 27, 26, 26,
25, 25, 24, 24, 22, 22, 21, 20, 20, 17, 17, 16, 15, 14, 12, 10, 8, 7, 6, 4, 3,
1, -2, -4, -6, -8, -10, -11, -14, -17, -18, -21, -23, -26, -28, -31, -33, -35,
-39, -41, -44, -45, -49, -51, -53, -56, -58, -60, -63, -66, -68, -70, -72, -74,
-77, -79, -80, -83, -85, -87, -88, -90, -92, -94, -95, -96, -99, -100, -101,
-103, -104, -105, -107, -108, -108, -110, -111, -111, -113, -114, -114, -115,
-116, -117, -116, -117, -117, -118, -118, -119, -119, -119, -119, -119, -119,
-120, -119, -118, -118, -119, -118, -118, -117, -116, -116, -116, -115, -114,
-114, -113, -111, -111, -111, -109, -109, -107, -106, -105, -103, -102, -100,
-100, -98, -97, -96, -93, -93, -90, -88, -87, -85, -84, -82, -79, -78, -75, -73,
-71, -69, -67, -65, -63, -61, -58, -57, -54, -51, -49, -47, -44, -42, -39, -38,
-34, -31, -30, -27, -25, -21, -18, -16, -14, -12, -8, -8, -7, -3, -1, };