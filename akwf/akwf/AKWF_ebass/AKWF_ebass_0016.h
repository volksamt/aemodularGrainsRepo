#define DATA_LENGTH 512
#define DATA AKWF_ebass_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 6, 8, 10, 13, 14, 16, 18, 21,
23, 24, 26, 28, 30, 32, 33, 34, 36, 38, 40, 41, 43, 44, 46, 48, 49, 50, 52, 54,
54, 55, 57, 57, 59, 59, 60, 60, 60, 61, 62, 63, 64, 65, 65, 67, 68, 69, 71, 71,
73, 75, 76, 77, 79, 81, 82, 83, 85, 86, 87, 88, 88, 89, 89, 89, 89, 87, 87, 85,
86, 84, 83, 82, 81, 78, 77, 75, 74, 72, 71, 70, 68, 66, 66, 64, 63, 62, 59, 58,
55, 54, 51, 50, 48, 46, 42, 41, 38, 35, 33, 31, 28, 26, 23, 21, 18, 17, 14, 11,
8, 7, 4, 1, -2, -5, -7, -11, -15, -18, -22, -26, -29, -34, -37, -42, -46, -50,
-54, -57, -61, -65, -68, -72, -74, -78, -80, -83, -85, -88, -90, -92, -94, -96,
-98, -99, -101, -103, -105, -106, -108, -109, -110, -112, -113, -115, -116,
-117, -117, -118, -118, -119, -120, -118, -118, -119, -118, -117, -115, -114,
-112, -110, -107, -105, -102, -100, -96, -94, -91, -88, -85, -81, -77, -75, -72,
-68, -65, -62, -59, -55, -52, -48, -44, -41, -37, -33, -29, -24, -20, -15, -12,
-8, -3, 1, 5, 9, 12, 15, 18, 22, 24, 27, 29, 32, 34, 35, 37, 39, 42, 44, 45, 48,
50, 51, 53, 55, 55, 58, 59, 60, 61, 62, 61, 62, 63, 62, 62, 60, 60, 59, 57, 56,
55, 53, 50, 48, 47, 45, 43, 41, 39, 38, 35, 34, 32, 32, 29, 28, 26, 25, 23, 23,
21, 19, 17, 16, 14, 13, 10, 9, 7, 6, 5, 4, 2, 1, 0, 0, -1, -1, -2, -2, -3, -3,
-4, -5, -5, -6, -6, -6, -5, -7, -6, -6, -5, -4, -3, -3, -1, 1, 2, 4, 7, 9, 10,
13, 16, 18, 20, 22, 25, 27, 28, 30, 31, 32, 34, 35, 35, 36, 36, 38, 38, 39, 38,
38, 39, 39, 39, 39, 39, 38, 37, 38, 37, 36, 37, 37, 36, 35, 35, 34, 35, 34, 35,
34, 34, 34, 34, 33, 33, 32, 32, 30, 30, 28, 26, 24, 22, 19, 16, 14, 12, 8, 4, 1,
-2, -6, -9, -13, -16, -18, -21, -24, -26, -28, -30, -31, -34, -35, -37, -39,
-40, -41, -42, -43, -44, -45, -46, -47, -47, -47, -48, -48, -49, -49, -49, -49,
-49, -49, -49, -49, -49, -49, -50, -50, -51, -50, -51, -50, -51, -52, -52, -53,
-53, -52, -54, -53, -52, -52, -51, -50, -49, -47, -45, -44, -42, -39, -38, -36,
-35, -32, -30, -29, -26, -24, -23, -22, -21, -20, -18, -18, -18, -16, -16, -15,
-14, -15, -14, -14, -14, -14, -13, -14, -13, -13, -14, -14, -14, -14, -15, -16,
-16, -17, -18, -18, -18, -19, -18, -18, -18, -17, -17, -16, -15, -14, -13, -11,
-9, -8, -8, -7, -5, -4, -4, -4, -3, -4, -3, -4, -4, -5, -6, -6, -7, -7, -8, -8,
-9, -8, -9, -10, -9, -9, -8, -8, -6, -6, -5, -3, -3, -1, };