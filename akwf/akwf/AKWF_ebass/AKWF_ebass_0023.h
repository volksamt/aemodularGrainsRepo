#define DATA_LENGTH 512
#define DATA AKWF_ebass_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 7, 5, 2, 1, 2, 9, 18, 28, 30,
28, 21, 12, 8, 7, 14, 23, 33, 38, 39, 35, 29, 24, 21, 25, 31, 40, 48, 52, 51,
46, 41, 39, 40, 44, 48, 49, 50, 49, 48, 46, 43, 39, 40, 43, 52, 60, 64, 60, 51,
45, 42, 43, 45, 46, 45, 43, 42, 42, 44, 46, 49, 50, 50, 47, 45, 41, 34, 29, 31,
39, 50, 58, 57, 53, 42, 34, 30, 30, 34, 37, 40, 40, 38, 31, 23, 12, 4, 3, 13,
28, 43, 47, 42, 31, 22, 17, 18, 22, 28, 33, 36, 37, 36, 34, 29, 24, 21, 21, 25,
32, 36, 36, 36, 35, 34, 33, 32, 32, 33, 36, 42, 47, 49, 49, 46, 41, 38, 36, 36,
39, 42, 46, 50, 54, 56, 52, 47, 41, 38, 42, 49, 58, 65, 71, 73, 72, 68, 64, 62,
63, 65, 68, 71, 72, 71, 66, 60, 57, 55, 56, 57, 58, 60, 60, 60, 56, 50, 44, 43,
43, 45, 48, 52, 52, 49, 43, 38, 34, 33, 33, 31, 30, 29, 30, 27, 23, 18, 16, 15,
13, 11, 8, 6, 6, 6, 7, 5, -1, -9, -17, -25, -29, -29, -28, -27, -28, -32, -36,
-40, -45, -50, -55, -55, -53, -48, -44, -46, -52, -61, -66, -66, -61, -53, -48,
-44, -43, -44, -46, -51, -58, -62, -61, -54, -44, -38, -35, -39, -45, -51, -51,
-50, -47, -44, -42, -37, -31, -26, -24, -27, -32, -34, -32, -25, -14, -8, -5,
-5, -3, 1, 3, 4, 7, 12, 19, 27, 30, 29, 27, 25, 25, 27, 33, 38, 42, 44, 47, 51,
54, 55, 53, 51, 51, 53, 58, 61, 62, 60, 59, 59, 62, 66, 73, 76, 80, 84, 87, 90,
90, 88, 84, 82, 80, 82, 85, 89, 90, 90, 91, 91, 90, 89, 87, 83, 81, 80, 82, 86,
87, 85, 80, 75, 72, 70, 69, 71, 74, 78, 78, 75, 70, 64, 60, 57, 58, 62, 65, 66,
63, 55, 45, 38, 35, 34, 37, 43, 48, 48, 43, 34, 25, 18, 15, 15, 16, 18, 15, 10,
3, -5, -10, -13, -13, -11, -11, -11, -15, -20, -28, -32, -33, -32, -31, -31,
-34, -39, -43, -49, -53, -55, -55, -54, -54, -54, -54, -58, -63, -67, -70, -70,
-67, -67, -70, -75, -79, -80, -81, -79, -77, -74, -73, -73, -78, -84, -91, -95,
-95, -93, -90, -88, -89, -92, -97, -101, -103, -105, -103, -102, -100, -98, -97,
-99, -101, -106, -109, -110, -109, -107, -104, -102, -105, -109, -113, -116,
-117, -115, -112, -109, -105, -103, -103, -108, -113, -118, -118, -118, -115,
-109, -105, -101, -101, -102, -104, -106, -108, -107, -104, -99, -96, -96, -97,
-99, -102, -101, -96, -91, -85, -83, -84, -84, -85, -84, -79, -75, -70, -67,
-67, -68, -70, -71, -72, -69, -65, -58, -53, -51, -53, -57, -59, -58, -51, -42,
-33, -28, -27, -31, -36, -40, -40, -35, -26, -15, -6, -1, -2, -9, -16, -21, -20,
-13, -5, };