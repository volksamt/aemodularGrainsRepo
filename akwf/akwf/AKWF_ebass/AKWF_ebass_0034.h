#define DATA_LENGTH 512
#define DATA AKWF_ebass_0034

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 11, 16, 20, 25, 28, 33, 38, 41,
45, 49, 53, 56, 58, 63, 65, 67, 70, 72, 74, 75, 78, 79, 81, 83, 83, 85, 87, 89,
90, 92, 94, 94, 97, 98, 100, 102, 104, 105, 107, 108, 109, 112, 112, 114, 115,
116, 117, 118, 118, 118, 119, 119, 119, 120, 119, 119, 119, 118, 117, 116, 116,
115, 113, 112, 110, 107, 106, 104, 102, 99, 96, 94, 90, 88, 84, 80, 78, 74, 69,
66, 63, 60, 55, 52, 49, 46, 42, 39, 36, 33, 30, 27, 24, 22, 19, 18, 15, 13, 12,
10, 9, 8, 6, 5, 4, 3, 2, 2, 1, 0, -1, 0, 0, -1, -2, -2, -3, -3, -3, -4, -3, -4,
-4, -3, -4, -3, -3, -3, -3, -3, -3, -3, -2, -2, -3, -2, -3, -2, -2, -2, -1, -2,
-2, -1, -1, -2, -1, -1, -2, -2, -1, -1, -1, -1, -1, -2, -1, -2, -2, -1, 0, -2,
-1, -1, 0, -1, -1, 0, -1, 0, -1, -1, -1, 0, 0, 0, 0, -1, -1, -1, 0, -2, -1, 0,
-1, -1, -1, -2, -2, -2, -1, -2, -2, -2, -3, -2, -2, -2, -2, -2, -2, -2, -2, -2,
-2, -2, -3, -3, -2, -3, -2, -3, -2, -4, -3, -4, -3, -3, -4, -4, -3, -3, -4, -4,
-4, -3, -4, -4, -4, -4, -5, -4, -4, -4, -4, -4, -4, -4, -4, -5, -5, -6, -5, -5,
-6, -6, -6, -7, -7, -7, -7, -8, -8, -7, -9, -9, -9, -9, -10, -10, -10, -9, -10,
-11, -10, -12, -11, -12, -12, -13, -13, -12, -13, -13, -13, -13, -13, -13, -13,
-13, -15, -15, -15, -15, -15, -16, -16, -16, -16, -16, -17, -16, -17, -16, -17,
-16, -16, -16, -16, -15, -15, -14, -14, -14, -13, -13, -14, -13, -13, -13, -13,
-14, -14, -14, -13, -13, -14, -13, -14, -13, -12, -12, -13, -13, -12, -12, -12,
-11, -12, -12, -12, -11, -12, -12, -11, -11, -11, -10, -10, -10, -10, -10, -10,
-9, -10, -9, -10, -10, -10, -10, -9, -9, -9, -9, -8, -8, -9, -8, -8, -8, -8, -9,
-8, -9, -8, -9, -9, -9, -9, -10, -10, -10, -11, -10, -11, -10, -11, -11, -11,
-11, -12, -12, -11, -12, -12, -13, -12, -13, -14, -13, -13, -13, -14, -15, -14,
-16, -14, -16, -16, -17, -17, -17, -17, -18, -18, -18, -19, -19, -20, -20, -21,
-22, -22, -23, -24, -25, -25, -26, -26, -28, -30, -30, -31, -32, -34, -34, -36,
-38, -39, -40, -41, -42, -44, -44, -46, -48, -49, -51, -52, -54, -54, -56, -58,
-60, -61, -63, -63, -66, -67, -69, -71, -73, -75, -77, -79, -81, -83, -85, -88,
-90, -92, -93, -97, -98, -100, -102, -104, -105, -106, -108, -110, -111, -113,
-112, -114, -114, -115, -115, -116, -115, -114, -114, -114, -112, -112, -110,
-109, -107, -104, -101, -98, -95, -91, -87, -83, -79, -73, -69, -64, -59, -53,
-47, -42, -35, -30, -24, -19, -13, -8, -3, };