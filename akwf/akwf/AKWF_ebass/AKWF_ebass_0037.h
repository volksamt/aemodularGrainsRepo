#define DATA_LENGTH 512
#define DATA AKWF_ebass_0037

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 9, 12, 16, 20, 23, 27, 29, 33,
37, 40, 43, 46, 50, 52, 55, 58, 61, 62, 65, 68, 70, 71, 73, 76, 77, 81, 82, 84,
86, 87, 90, 92, 93, 94, 97, 99, 100, 101, 103, 105, 106, 108, 110, 112, 112,
113, 115, 115, 116, 117, 117, 118, 118, 118, 120, 119, 119, 119, 119, 118, 119,
117, 118, 117, 116, 115, 114, 113, 112, 111, 111, 108, 108, 106, 104, 102, 101,
99, 97, 95, 92, 89, 88, 85, 82, 80, 77, 75, 71, 69, 66, 62, 60, 56, 53, 50, 47,
43, 41, 37, 34, 32, 29, 25, 23, 21, 18, 15, 12, 9, 8, 6, 4, 2, -1, -3, -4, -6,
-8, -9, -11, -13, -13, -14, -17, -18, -18, -19, -19, -20, -22, -22, -23, -24,
-24, -24, -25, -26, -26, -26, -26, -26, -28, -27, -27, -27, -27, -27, -26, -27,
-27, -26, -26, -26, -26, -27, -27, -26, -26, -27, -25, -26, -25, -26, -25, -25,
-23, -24, -24, -22, -22, -22, -21, -20, -20, -18, -19, -17, -17, -17, -16, -15,
-15, -13, -13, -12, -11, -10, -10, -9, -8, -8, -8, -7, -6, -5, -5, -4, -5, -4,
-3, -2, -1, 0, 0, 1, 2, 2, 3, 4, 3, 4, 4, 5, 5, 6, 4, 6, 5, 5, 6, 6, 7, 6, 7, 7,
8, 8, 8, 9, 8, 9, 9, 9, 9, 9, 8, 8, 8, 7, 7, 6, 5, 6, 6, 5, 6, 5, 6, 6, 7, 7, 8,
9, 9, 9, 10, 10, 10, 10, 9, 10, 9, 9, 9, 9, 9, 9, 9, 9, 9, 9, 10, 9, 9, 9, 8, 8,
7, 7, 6, 5, 5, 5, 3, 3, 3, 3, 2, 2, 2, 2, 1, 2, 2, 2, 2, 1, 0, 1, 0, 1, -1, -1,
-2, -2, -2, -2, -3, -3, -3, -3, -4, -4, -4, -4, -4, -5, -6, -7, -8, -9, -9, -11,
-12, -11, -13, -14, -15, -14, -15, -15, -16, -17, -16, -18, -17, -18, -19, -20,
-21, -21, -22, -23, -25, -26, -27, -28, -29, -29, -31, -32, -32, -32, -34, -35,
-35, -37, -38, -39, -39, -40, -42, -43, -44, -46, -47, -48, -50, -51, -53, -54,
-55, -56, -57, -58, -58, -59, -59, -60, -61, -62, -63, -64, -65, -66, -67, -67,
-68, -70, -71, -71, -72, -73, -74, -74, -76, -76, -77, -77, -78, -79, -80, -81,
-81, -82, -83, -83, -85, -85, -85, -86, -86, -88, -89, -89, -89, -90, -90, -91,
-90, -90, -91, -90, -91, -91, -90, -91, -91, -92, -91, -91, -91, -92, -92, -92,
-92, -91, -91, -91, -91, -90, -90, -91, -92, -91, -92, -91, -92, -91, -91, -92,
-92, -92, -92, -93, -92, -92, -93, -92, -92, -92, -90, -91, -90, -89, -90, -90,
-89, -88, -88, -87, -85, -86, -84, -84, -82, -81, -79, -78, -76, -75, -73, -71,
-69, -67, -65, -63, -61, -58, -56, -54, -51, -48, -46, -43, -41, -38, -35, -32,
-29, -27, -24, -20, -17, -15, -11, -9, -5, -1, };