#define DATA_LENGTH 512
#define DATA AKWF_ebass_0026

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 7, 8, 10, 11, 12, 14, 15,
16, 18, 19, 21, 21, 23, 25, 25, 27, 28, 29, 30, 32, 33, 34, 36, 37, 38, 40, 41,
43, 45, 46, 46, 48, 49, 50, 51, 53, 55, 55, 57, 58, 58, 61, 61, 63, 64, 66, 66,
68, 69, 69, 71, 71, 72, 74, 75, 76, 78, 78, 79, 80, 81, 82, 84, 83, 85, 87, 87,
88, 89, 90, 91, 92, 92, 93, 95, 95, 97, 97, 98, 99, 100, 101, 101, 101, 102,
103, 104, 105, 106, 107, 107, 107, 108, 108, 109, 109, 110, 110, 111, 112, 112,
113, 113, 113, 114, 115, 115, 115, 116, 115, 117, 117, 117, 117, 117, 117, 119,
118, 118, 118, 119, 118, 118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
119, 118, 118, 119, 118, 118, 117, 117, 117, 117, 117, 116, 116, 115, 116, 115,
115, 114, 114, 113, 112, 112, 112, 111, 110, 111, 109, 109, 108, 108, 107, 107,
105, 105, 104, 103, 102, 102, 101, 101, 99, 98, 98, 96, 95, 95, 94, 92, 93, 91,
90, 89, 88, 88, 86, 85, 84, 83, 82, 80, 79, 79, 77, 76, 75, 74, 72, 71, 71, 69,
67, 67, 65, 64, 63, 62, 60, 58, 57, 56, 55, 54, 52, 50, 50, 49, 46, 45, 44, 42,
41, 40, 38, 36, 36, 34, 32, 31, 30, 28, 26, 26, 23, 23, 21, 19, 17, 17, 15, 14,
13, 11, 10, 7, 6, 5, 3, 1, 0, -1, -3, -4, -6, -7, -8, -10, -11, -13, -14, -15,
-17, -19, -20, -22, -24, -25, -25, -27, -29, -30, -31, -32, -33, -35, -37, -39,
-40, -41, -42, -44, -45, -47, -47, -49, -50, -52, -53, -54, -55, -57, -58, -59,
-61, -62, -62, -65, -66, -67, -68, -70, -70, -71, -72, -74, -75, -76, -77, -78,
-79, -80, -81, -82, -84, -83, -85, -86, -87, -88, -89, -89, -90, -91, -92, -93,
-94, -95, -96, -96, -98, -98, -99, -99, -100, -101, -102, -102, -103, -104,
-105, -105, -105, -106, -107, -107, -108, -109, -110, -110, -110, -110, -112,
-112, -112, -112, -113, -114, -115, -113, -114, -115, -115, -116, -115, -115,
-116, -116, -117, -116, -117, -116, -117, -117, -117, -117, -117, -118, -117,
-117, -118, -117, -118, -118, -118, -117, -118, -117, -117, -117, -116, -117,
-116, -116, -115, -115, -115, -115, -114, -114, -113, -114, -113, -112, -112,
-112, -110, -110, -110, -109, -108, -108, -107, -107, -106, -105, -106, -105,
-104, -103, -102, -102, -101, -100, -99, -98, -97, -97, -96, -96, -95, -94, -93,
-91, -91, -90, -89, -88, -86, -86, -85, -83, -82, -82, -81, -80, -79, -77, -76,
-75, -75, -73, -72, -71, -70, -68, -67, -66, -65, -63, -63, -61, -60, -58, -57,
-57, -55, -54, -51, -51, -50, -48, -47, -46, -44, -42, -42, -40, -39, -38, -36,
-35, -34, -32, -31, -29, -28, -28, -26, -24, -23, -22, -20, -19, -18, -15, -15,
-13, -11, -10, -9, -8, -6, -4, -4, -2, -1, };