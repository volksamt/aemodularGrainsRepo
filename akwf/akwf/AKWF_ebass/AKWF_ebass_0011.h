#define DATA_LENGTH 512
#define DATA AKWF_ebass_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 13, 16, 20, 25, 29, 33, 37, 41,
44, 48, 51, 55, 57, 60, 64, 66, 69, 72, 74, 77, 79, 82, 86, 88, 90, 91, 94, 96,
98, 100, 101, 102, 104, 105, 107, 107, 109, 108, 109, 109, 109, 109, 110, 109,
109, 109, 109, 107, 107, 106, 105, 105, 104, 103, 101, 100, 99, 97, 97, 94, 94,
93, 91, 89, 88, 85, 84, 82, 80, 78, 76, 75, 73, 71, 70, 68, 65, 64, 63, 61, 60,
58, 57, 55, 53, 52, 51, 50, 49, 46, 46, 45, 43, 42, 41, 40, 39, 38, 36, 35, 34,
33, 32, 31, 30, 29, 28, 27, 27, 25, 25, 25, 23, 23, 23, 23, 22, 21, 20, 20, 18,
18, 18, 18, 17, 17, 16, 16, 15, 14, 15, 14, 13, 14, 13, 12, 12, 10, 10, 9, 8, 7,
8, 6, 7, 5, 5, 5, 4, 4, 3, 2, 2, 2, 2, 1, 1, 1, 0, -1, 0, 0, 0, -1, 0, -1, -1,
0, 0, -1, -2, -2, -1, -2, -2, -3, -4, -4, -4, -4, -4, -4, -4, -5, -5, -6, -5,
-6, -6, -6, -7, -6, -7, -8, -8, -8, -8, -8, -8, -8, -8, -8, -8, -7, -7, -8, -7,
-7, -7, -8, -8, -7, -8, -8, -8, -8, -8, -8, -8, -8, -8, -8, -7, -8, -8, -8, -7,
-8, -9, -10, -10, -9, -10, -11, -11, -11, -11, -10, -11, -12, -11, -12, -13,
-12, -13, -13, -13, -14, -13, -14, -14, -14, -14, -14, -14, -13, -13, -12, -13,
-13, -12, -12, -13, -13, -13, -13, -13, -14, -14, -14, -14, -14, -14, -15, -14,
-15, -15, -15, -14, -15, -15, -14, -15, -15, -16, -16, -15, -15, -14, -15, -16,
-16, -15, -15, -16, -16, -17, -16, -16, -16, -15, -16, -16, -16, -15, -14, -14,
-13, -13, -12, -10, -10, -9, -9, -8, -7, -7, -6, -7, -6, -6, -5, -5, -6, -6, -7,
-7, -8, -9, -8, -10, -9, -10, -10, -11, -11, -12, -12, -12, -11, -12, -12, -11,
-10, -9, -8, -7, -7, -5, -4, -3, -2, -1, 2, 3, 3, 5, 6, 7, 8, 9, 10, 11, 12, 13,
13, 15, 15, 15, 17, 15, 15, 16, 17, 16, 16, 16, 16, 15, 15, 15, 14, 15, 14, 13,
13, 13, 14, 13, 13, 13, 13, 13, 13, 13, 13, 12, 13, 13, 14, 13, 14, 14, 14, 14,
13, 13, 12, 12, 11, 10, 9, 7, 6, 3, 2, 0, -3, -6, -9, -12, -15, -19, -22, -26,
-29, -34, -37, -40, -44, -48, -51, -55, -59, -62, -66, -69, -72, -75, -79, -82,
-85, -88, -90, -93, -96, -98, -101, -103, -105, -107, -108, -109, -110, -112,
-113, -113, -115, -116, -116, -116, -117, -117, -117, -118, -118, -119, -118,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -117, -117, -116, -115,
-114, -112, -111, -109, -105, -104, -100, -97, -94, -90, -85, -82, -77, -72,
-68, -63, -58, -52, -47, -42, -37, -31, -27, -22, -17, -13, -8, -3, -1, };