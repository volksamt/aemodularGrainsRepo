#define DATA_LENGTH 512
#define DATA AKWF_ebass_0054

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 5, 7, 9, 11, 11, 12, 14, 14,
14, 14, 14, 15, 15, 16, 17, 18, 19, 19, 20, 20, 21, 21, 22, 22, 22, 24, 24, 24,
26, 26, 28, 28, 29, 30, 31, 32, 33, 34, 35, 36, 37, 38, 39, 39, 40, 41, 41, 42,
41, 41, 40, 39, 38, 37, 36, 35, 35, 35, 36, 34, 34, 34, 35, 34, 33, 34, 34, 34,
34, 34, 35, 36, 36, 36, 37, 36, 38, 38, 38, 38, 38, 38, 37, 36, 36, 35, 35, 34,
34, 34, 35, 35, 35, 35, 35, 36, 36, 36, 37, 37, 38, 37, 39, 38, 38, 38, 38, 37,
38, 38, 39, 40, 40, 42, 41, 41, 41, 42, 44, 44, 45, 46, 46, 48, 48, 48, 49, 49,
49, 51, 52, 52, 54, 55, 55, 56, 56, 57, 57, 57, 58, 58, 60, 61, 63, 64, 64, 65,
66, 67, 68, 68, 69, 70, 69, 68, 67, 66, 66, 65, 63, 64, 63, 63, 64, 62, 62, 61,
61, 61, 60, 60, 59, 58, 58, 57, 56, 54, 53, 52, 51, 50, 49, 47, 46, 44, 42, 40,
38, 35, 32, 30, 27, 24, 21, 18, 15, 12, 9, 6, 4, 1, -3, -5, -10, -12, -17, -21,
-25, -29, -34, -35, -39, -42, -45, -47, -51, -53, -57, -59, -62, -64, -67, -70,
-73, -76, -78, -81, -84, -86, -89, -91, -93, -94, -97, -98, -101, -103, -105,
-107, -109, -111, -112, -114, -116, -116, -116, -117, -118, -118, -118, -119,
-119, -119, -119, -120, -119, -118, -118, -118, -117, -118, -117, -115, -115,
-115, -113, -112, -111, -108, -107, -106, -103, -101, -99, -96, -93, -92, -89,
-86, -84, -82, -79, -76, -73, -70, -69, -65, -62, -60, -57, -55, -52, -50, -46,
-44, -42, -40, -36, -35, -32, -29, -26, -24, -21, -17, -14, -10, -7, -5, -1, 2,
6, 8, 12, 14, 17, 20, 24, 26, 28, 31, 34, 37, 38, 40, 41, 44, 44, 45, 47, 48,
49, 50, 50, 51, 51, 52, 53, 53, 54, 56, 56, 57, 58, 59, 59, 58, 59, 60, 59, 59,
59, 60, 60, 60, 59, 59, 59, 59, 59, 58, 57, 57, 55, 54, 52, 50, 48, 46, 45, 42,
40, 39, 38, 37, 34, 33, 32, 31, 29, 28, 26, 25, 23, 21, 20, 17, 17, 16, 15, 14,
12, 11, 9, 7, 5, 3, 1, -1, -4, -7, -9, -11, -14, -16, -17, -20, -21, -23, -24,
-25, -27, -28, -28, -30, -31, -32, -32, -33, -35, -36, -36, -38, -39, -39, -39,
-40, -41, -41, -43, -43, -44, -45, -46, -47, -49, -50, -50, -51, -51, -52, -52,
-53, -53, -52, -52, -50, -49, -49, -48, -47, -47, -46, -46, -46, -46, -46, -46,
-45, -45, -43, -42, -42, -41, -40, -40, -39, -39, -38, -38, -38, -38, -39, -38,
-38, -37, -37, -36, -33, -31, -30, -28, -27, -25, -25, -24, -23, -24, -23, -21,
-21, -20, -19, -17, -16, -14, -12, -11, -9, -8, -7, -5, -4, -4, -2, -1, -1, 0,
};