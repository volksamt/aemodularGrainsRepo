#define DATA_LENGTH 512
#define DATA AKWF_ebass_0068

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 8, 11, 14, 17, 20, 22, 25, 28,
30, 32, 35, 37, 38, 42, 43, 45, 47, 49, 51, 52, 55, 57, 57, 59, 60, 62, 62, 64,
64, 66, 66, 67, 68, 69, 70, 69, 70, 70, 70, 70, 70, 70, 70, 70, 69, 69, 69, 68,
68, 68, 66, 65, 65, 63, 63, 63, 61, 59, 59, 58, 57, 56, 54, 53, 53, 51, 49, 48,
47, 47, 45, 45, 43, 43, 41, 40, 40, 39, 38, 38, 37, 36, 35, 35, 35, 35, 34, 34,
34, 33, 34, 33, 34, 35, 34, 35, 34, 35, 35, 35, 36, 36, 36, 36, 36, 37, 37, 37,
38, 39, 37, 38, 39, 39, 39, 40, 40, 40, 40, 40, 41, 41, 42, 42, 43, 43, 44, 44,
45, 46, 47, 48, 48, 49, 50, 51, 53, 54, 54, 56, 58, 59, 60, 62, 64, 65, 67, 68,
70, 72, 73, 76, 77, 79, 81, 83, 85, 86, 88, 90, 91, 93, 94, 95, 97, 98, 100,
101, 102, 103, 104, 104, 105, 107, 106, 107, 108, 107, 109, 108, 108, 109, 109,
108, 107, 107, 107, 107, 107, 106, 105, 104, 103, 101, 100, 99, 98, 97, 96, 94,
92, 90, 90, 87, 86, 83, 80, 79, 76, 74, 72, 70, 67, 65, 62, 60, 58, 54, 52, 49,
46, 43, 42, 38, 36, 33, 31, 29, 27, 24, 22, 20, 19, 17, 14, 13, 12, 10, 8, 9, 7,
7, 7, 6, 5, 6, 6, 5, 6, 7, 7, 8, 9, 10, 11, 12, 14, 15, 16, 19, 20, 21, 23, 25,
26, 28, 30, 32, 33, 35, 37, 38, 41, 42, 44, 45, 47, 48, 50, 50, 53, 53, 54, 56,
57, 58, 59, 61, 61, 61, 62, 62, 64, 64, 64, 64, 64, 64, 65, 64, 64, 64, 64, 62,
63, 61, 60, 59, 58, 57, 55, 53, 51, 51, 49, 47, 44, 43, 40, 37, 35, 31, 29, 26,
23, 19, 16, 12, 8, 5, 1, -3, -7, -11, -16, -19, -23, -26, -30, -34, -36, -41,
-42, -46, -49, -52, -54, -58, -60, -62, -65, -67, -70, -71, -73, -76, -78, -78,
-82, -82, -84, -85, -87, -88, -90, -90, -92, -93, -94, -96, -97, -97, -98, -99,
-99, -102, -102, -102, -103, -104, -105, -105, -107, -106, -108, -107, -108,
-110, -110, -111, -111, -112, -112, -113, -114, -114, -114, -115, -115, -116,
-116, -116, -117, -117, -118, -118, -118, -118, -118, -118, -118, -118, -119,
-118, -119, -119, -119, -119, -119, -119, -118, -118, -118, -118, -119, -118,
-118, -117, -117, -117, -117, -116, -115, -115, -115, -114, -114, -114, -114,
-112, -112, -112, -111, -110, -109, -109, -108, -108, -107, -106, -106, -105,
-104, -105, -104, -102, -101, -101, -99, -99, -98, -98, -97, -96, -95, -94, -92,
-91, -89, -89, -88, -86, -85, -84, -82, -81, -79, -78, -76, -74, -73, -70, -69,
-67, -66, -64, -61, -60, -57, -55, -53, -50, -47, -45, -43, -40, -38, -36, -34,
-30, -27, -25, -21, -18, -17, -13, -10, -7, -4, -1, };