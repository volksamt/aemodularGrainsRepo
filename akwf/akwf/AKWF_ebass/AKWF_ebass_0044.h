#define DATA_LENGTH 512
#define DATA AKWF_ebass_0044

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 7, 11, 14, 18, 21, 25, 27, 31,
33, 36, 40, 42, 45, 49, 50, 53, 57, 59, 61, 64, 65, 68, 71, 72, 73, 76, 77, 79,
80, 82, 82, 83, 84, 85, 87, 87, 87, 88, 89, 89, 89, 89, 89, 89, 88, 89, 88, 88,
87, 87, 86, 84, 83, 83, 83, 81, 79, 79, 77, 76, 75, 74, 72, 71, 69, 68, 66, 65,
63, 60, 59, 57, 55, 53, 51, 48, 48, 46, 42, 41, 39, 36, 34, 32, 29, 27, 25, 23,
21, 18, 16, 13, 12, 9, 7, 5, 3, 1, -2, -3, -6, -9, -10, -12, -14, -15, -18, -20,
-22, -24, -25, -27, -29, -30, -31, -34, -35, -36, -38, -39, -41, -42, -44, -46,
-47, -48, -50, -51, -53, -54, -56, -56, -59, -59, -60, -62, -63, -65, -66, -67,
-69, -70, -71, -71, -73, -74, -75, -74, -76, -77, -78, -80, -80, -82, -83, -84,
-84, -86, -87, -87, -89, -90, -92, -91, -92, -94, -95, -96, -97, -98, -100,
-100, -101, -102, -104, -104, -106, -107, -107, -107, -109, -110, -111, -112,
-112, -112, -114, -115, -115, -116, -116, -117, -118, -117, -118, -118, -117,
-118, -118, -118, -119, -119, -119, -118, -118, -118, -118, -116, -117, -116,
-115, -115, -114, -113, -112, -111, -111, -110, -109, -107, -107, -105, -104,
-103, -101, -100, -99, -97, -96, -94, -93, -90, -90, -88, -86, -84, -82, -80,
-78, -76, -74, -73, -71, -69, -66, -65, -63, -61, -60, -57, -55, -54, -52, -50,
-49, -47, -46, -45, -43, -41, -40, -40, -38, -36, -36, -35, -34, -33, -32, -30,
-30, -29, -29, -28, -27, -26, -26, -26, -25, -25, -24, -24, -24, -24, -23, -23,
-23, -22, -23, -22, -23, -24, -24, -23, -24, -24, -24, -25, -26, -27, -27, -28,
-27, -29, -29, -29, -29, -29, -31, -32, -32, -32, -33, -33, -34, -33, -34, -34,
-33, -34, -33, -33, -33, -33, -33, -32, -32, -31, -31, -31, -29, -30, -29, -28,
-28, -27, -26, -25, -24, -23, -22, -23, -20, -20, -19, -18, -17, -17, -15, -16,
-14, -13, -12, -11, -10, -9, -8, -6, -6, -6, -5, -3, -2, -1, 1, 1, 2, 3, 5, 5,
7, 8, 9, 9, 10, 12, 12, 13, 14, 15, 16, 16, 17, 17, 18, 18, 19, 19, 19, 20, 20,
19, 19, 19, 19, 18, 18, 17, 16, 16, 14, 14, 12, 12, 11, 10, 8, 7, 5, 5, 2, 1, 1,
-2, -3, -4, -7, -8, -10, -12, -13, -16, -18, -19, -22, -24, -25, -28, -31, -33,
-35, -37, -41, -42, -44, -48, -50, -52, -54, -57, -59, -61, -63, -66, -67, -70,
-72, -74, -77, -78, -80, -83, -84, -85, -87, -89, -90, -90, -93, -93, -94, -94,
-95, -95, -96, -97, -96, -96, -96, -95, -96, -95, -94, -93, -92, -91, -90, -89,
-87, -86, -84, -83, -81, -78, -76, -74, -73, -70, -68, -65, -63, -59, -57, -54,
-51, -48, -45, -42, -39, -36, -32, -29, -26, -23, -19, -16, -12, -8, -5, -3, };