#define DATA_LENGTH 512
#define DATA AKWF_ebass_0065

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 17, 21, 25, 29, 33, 36, 40,
43, 45, 49, 51, 54, 56, 58, 60, 63, 64, 67, 68, 69, 71, 72, 74, 76, 77, 78, 79,
81, 81, 82, 83, 84, 85, 85, 87, 87, 87, 88, 89, 90, 90, 90, 91, 91, 92, 92, 92,
93, 93, 94, 94, 95, 95, 94, 95, 95, 95, 96, 96, 95, 96, 96, 96, 96, 97, 97, 97,
98, 97, 97, 97, 98, 97, 97, 98, 97, 97, 97, 97, 96, 97, 96, 96, 96, 96, 95, 97,
95, 95, 96, 95, 96, 95, 94, 95, 94, 94, 94, 93, 93, 93, 93, 93, 93, 93, 93, 92,
92, 91, 91, 91, 91, 91, 90, 90, 90, 89, 90, 89, 89, 88, 88, 87, 88, 87, 87, 87,
86, 86, 85, 85, 85, 85, 84, 84, 83, 83, 82, 82, 82, 81, 81, 81, 80, 80, 80, 79,
78, 78, 77, 77, 77, 76, 76, 75, 75, 74, 74, 73, 73, 72, 72, 71, 71, 70, 69, 70,
68, 68, 68, 67, 66, 66, 66, 65, 64, 63, 63, 62, 62, 61, 60, 60, 59, 58, 57, 57,
56, 55, 55, 53, 53, 52, 51, 50, 49, 48, 48, 47, 46, 45, 45, 44, 44, 43, 42, 42,
41, 40, 39, 39, 39, 38, 37, 35, 35, 34, 33, 33, 32, 32, 31, 30, 30, 29, 29, 27,
27, 27, 26, 26, 25, 24, 23, 23, 21, 21, 21, 19, 19, 18, 17, 17, 16, 16, 15, 15,
15, 15, 13, 13, 13, 13, 13, 12, 12, 12, 12, 12, 12, 12, 12, 12, 12, 13, 13, 13,
13, 14, 13, 14, 15, 15, 15, 15, 16, 17, 17, 17, 18, 18, 19, 19, 19, 20, 21, 21,
21, 22, 23, 24, 25, 26, 26, 27, 28, 29, 29, 30, 32, 32, 33, 34, 34, 36, 38, 37,
39, 40, 41, 42, 43, 44, 44, 45, 47, 47, 47, 48, 48, 50, 51, 50, 52, 52, 52, 53,
53, 53, 52, 54, 53, 53, 52, 53, 53, 52, 51, 50, 50, 49, 48, 48, 46, 45, 45, 43,
41, 40, 38, 37, 35, 31, 29, 27, 25, 22, 18, 16, 12, 8, 3, -1, -6, -11, -15, -19,
-23, -27, -32, -36, -40, -44, -48, -52, -55, -59, -62, -65, -70, -72, -75, -78,
-81, -82, -85, -88, -90, -92, -94, -96, -97, -99, -100, -102, -103, -104, -106,
-107, -108, -109, -109, -110, -111, -111, -112, -113, -113, -114, -115, -114,
-115, -115, -117, -117, -116, -117, -117, -117, -118, -118, -119, -119, -119,
-119, -119, -119, -118, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -118, -118, -119, -118, -118, -118, -118, -117,
-117, -117, -118, -117, -116, -116, -116, -115, -115, -115, -115, -114, -113,
-113, -113, -112, -111, -110, -109, -109, -107, -107, -107, -105, -104, -103,
-101, -100, -99, -97, -96, -94, -92, -91, -89, -86, -84, -81, -79, -76, -74,
-71, -67, -64, -61, -57, -54, -50, -46, -42, -37, -33, -27, -22, -19, -15, -12,
-7, -2, };