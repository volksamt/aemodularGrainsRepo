#define DATA_LENGTH 512
#define DATA AKWF_ebass_0055

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 2, 3, 4, 6, 5, 8, 7, 8, 8, 9,
10, 10, 11, 12, 13, 14, 16, 17, 20, 22, 24, 26, 28, 32, 33, 36, 37, 39, 41, 43,
44, 46, 48, 48, 50, 50, 51, 51, 51, 51, 52, 51, 52, 52, 53, 54, 54, 56, 57, 58,
59, 60, 62, 63, 66, 67, 68, 70, 72, 72, 74, 76, 76, 78, 79, 79, 80, 81, 81, 82,
82, 83, 83, 84, 84, 83, 84, 84, 85, 85, 86, 88, 88, 91, 92, 94, 95, 97, 97, 98,
98, 98, 98, 99, 99, 100, 101, 100, 101, 102, 102, 102, 102, 103, 103, 103, 102,
103, 103, 104, 103, 104, 103, 102, 103, 101, 100, 100, 98, 96, 94, 93, 91, 89,
88, 87, 86, 84, 84, 81, 80, 79, 77, 74, 72, 71, 70, 68, 67, 65, 64, 62, 60, 59,
58, 56, 54, 53, 50, 50, 48, 46, 44, 41, 38, 34, 31, 26, 23, 19, 15, 12, 9, 7, 4,
1, -3, -6, -9, -14, -18, -23, -27, -32, -35, -39, -42, -45, -47, -50, -52, -53,
-55, -58, -61, -63, -65, -68, -70, -72, -74, -76, -77, -79, -82, -84, -85, -88,
-92, -94, -97, -99, -101, -103, -105, -106, -107, -110, -111, -112, -114, -114,
-115, -116, -117, -117, -117, -117, -117, -117, -117, -118, -118, -117, -117,
-117, -117, -117, -117, -117, -117, -117, -117, -118, -119, -118, -119, -119,
-119, -118, -117, -116, -115, -114, -112, -109, -107, -106, -102, -100, -98,
-95, -93, -91, -88, -87, -83, -81, -78, -76, -74, -71, -69, -68, -67, -66, -64,
-64, -63, -61, -60, -58, -56, -54, -52, -50, -48, -47, -44, -43, -40, -38, -35,
-31, -29, -25, -21, -18, -16, -13, -11, -8, -7, -5, -2, -1, 2, 3, 4, 5, 6, 7, 8,
10, 11, 11, 13, 15, 15, 16, 18, 20, 21, 22, 23, 24, 26, 28, 29, 30, 32, 34, 36,
37, 39, 39, 40, 40, 41, 41, 42, 42, 42, 42, 42, 43, 44, 43, 44, 45, 45, 45, 45,
44, 44, 43, 42, 42, 42, 41, 41, 42, 42, 43, 43, 43, 42, 41, 41, 40, 39, 37, 37,
36, 36, 35, 34, 33, 31, 30, 29, 28, 26, 25, 23, 21, 19, 18, 16, 14, 13, 12, 11,
10, 7, 7, 5, 4, 4, 2, 1, 1, -1, -3, -4, -5, -7, -10, -11, -12, -14, -15, -15,
-16, -18, -18, -19, -20, -22, -23, -24, -26, -27, -29, -28, -29, -30, -32, -32,
-33, -34, -34, -35, -38, -39, -41, -43, -45, -47, -48, -49, -51, -52, -53, -53,
-55, -55, -56, -56, -56, -55, -56, -56, -55, -54, -54, -53, -52, -51, -49, -48,
-47, -46, -46, -44, -45, -43, -44, -43, -44, -43, -43, -43, -42, -43, -43, -43,
-43, -43, -43, -43, -43, -42, -41, -40, -40, -38, -37, -36, -35, -33, -32, -31,
-29, -27, -24, -23, -20, -19, -17, -15, -14, -12, -10, -9, -9, -7, -5, -4, -3,
-3, -3, -2, -2, -2, -3, -2, -1, 0, };