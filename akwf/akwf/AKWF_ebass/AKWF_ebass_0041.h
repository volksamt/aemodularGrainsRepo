#define DATA_LENGTH 512
#define DATA AKWF_ebass_0041

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 7, 9, 10, 11, 13, 14, 15, 16,
17, 19, 19, 21, 22, 23, 25, 27, 30, 31, 34, 35, 38, 41, 42, 46, 48, 51, 53, 56,
58, 60, 62, 62, 64, 66, 68, 69, 70, 71, 72, 73, 74, 75, 78, 78, 80, 81, 84, 85,
88, 90, 91, 94, 95, 97, 98, 101, 102, 105, 106, 107, 107, 109, 109, 110, 110,
110, 109, 108, 106, 104, 104, 101, 99, 97, 93, 90, 86, 83, 80, 77, 73, 68, 65,
60, 56, 52, 48, 45, 41, 37, 33, 29, 27, 24, 20, 18, 15, 13, 10, 8, 6, 3, 1, 0,
-3, -5, -6, -7, -8, -10, -11, -12, -14, -14, -15, -16, -16, -17, -16, -17, -18,
-18, -19, -19, -21, -21, -21, -22, -23, -22, -22, -24, -23, -24, -24, -24, -24,
-24, -23, -24, -23, -21, -22, -20, -20, -20, -20, -19, -19, -19, -18, -19, -18,
-18, -18, -17, -18, -16, -15, -14, -14, -13, -12, -11, -11, -10, -11, -10, -9,
-9, -9, -8, -8, -8, -8, -8, -7, -7, -6, -7, -6, -6, -7, -7, -6, -6, -5, -5, -4,
-4, -3, -1, 0, 1, 1, 2, 1, 2, 3, 1, 2, 1, 2, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0,
-1, -1, -1, -1, 0, -1, 0, -1, -1, -1, -1, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1,
-2, -2, -2, -2, -3, -4, -4, -4, -6, -7, -8, -9, -11, -11, -12, -12, -13, -13,
-13, -14, -13, -14, -14, -15, -14, -15, -15, -16, -17, -17, -18, -19, -20, -20,
-22, -21, -23, -23, -23, -24, -25, -25, -26, -26, -26, -25, -26, -27, -26, -26,
-25, -26, -25, -26, -25, -25, -25, -25, -26, -26, -26, -27, -26, -26, -26, -26,
-26, -24, -25, -24, -23, -23, -22, -21, -21, -20, -20, -21, -20, -19, -19, -18,
-18, -17, -17, -16, -15, -14, -14, -13, -13, -12, -12, -12, -12, -12, -13, -13,
-14, -13, -14, -13, -14, -13, -13, -13, -11, -11, -10, -10, -10, -9, -9, -7, -8,
-7, -6, -6, -6, -5, -5, -4, -4, -3, -4, -3, -3, -3, -2, -2, -2, -1, -1, -1, -1,
-1, -1, 0, 0, 1, 1, 3, 3, 4, 4, 4, 6, 6, 7, 7, 8, 9, 8, 9, 9, 9, 10, 8, 9, 9, 8,
9, 8, 8, 8, 8, 7, 7, 7, 6, 6, 5, 5, 4, 4, 4, 3, 2, 1, 1, -1, -2, -3, -5, -7, -9,
-10, -12, -14, -16, -19, -20, -22, -25, -27, -28, -31, -33, -35, -37, -39, -40,
-42, -44, -45, -47, -49, -50, -53, -54, -57, -60, -63, -66, -68, -70, -74, -76,
-80, -83, -85, -88, -91, -94, -96, -99, -101, -104, -107, -108, -112, -114,
-115, -117, -119, -119, -119, -118, -117, -116, -114, -113, -110, -107, -103,
-100, -97, -94, -90, -85, -82, -78, -75, -71, -67, -64, -60, -56, -52, -48, -45,
-40, -36, -32, -29, -26, -21, -18, -15, -11, -7, -5, -2, };