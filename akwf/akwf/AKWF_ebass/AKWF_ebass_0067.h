#define DATA_LENGTH 512
#define DATA AKWF_ebass_0067

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 11, 14, 16, 19, 22, 25, 27,
29, 31, 33, 35, 38, 40, 41, 43, 45, 47, 48, 50, 51, 53, 55, 57, 58, 59, 61, 61,
64, 63, 65, 67, 67, 69, 69, 71, 71, 72, 73, 75, 76, 76, 76, 76, 78, 79, 80, 80,
80, 81, 82, 83, 84, 83, 84, 85, 85, 86, 86, 86, 87, 87, 87, 88, 88, 89, 89, 89,
90, 90, 90, 91, 90, 91, 91, 91, 91, 91, 92, 92, 91, 92, 92, 92, 92, 92, 92, 93,
93, 92, 93, 92, 92, 93, 93, 93, 92, 92, 93, 92, 92, 93, 92, 93, 92, 92, 91, 92,
92, 92, 91, 91, 90, 91, 91, 91, 91, 90, 90, 90, 89, 89, 89, 89, 89, 89, 88, 88,
87, 87, 87, 86, 86, 86, 86, 86, 85, 84, 85, 84, 84, 84, 84, 83, 82, 82, 81, 81,
82, 80, 80, 80, 79, 79, 79, 77, 78, 77, 78, 76, 76, 75, 75, 75, 73, 73, 73, 73,
72, 71, 72, 70, 71, 70, 69, 68, 68, 67, 67, 66, 66, 65, 65, 64, 64, 64, 63, 63,
62, 62, 61, 61, 60, 59, 59, 59, 59, 57, 57, 56, 56, 56, 55, 54, 54, 54, 53, 52,
52, 52, 51, 51, 51, 50, 50, 50, 48, 49, 49, 48, 47, 47, 47, 47, 46, 46, 45, 45,
45, 46, 45, 45, 45, 44, 44, 44, 44, 43, 44, 44, 43, 44, 44, 43, 43, 43, 44, 43,
43, 43, 43, 43, 42, 43, 43, 43, 43, 43, 44, 42, 43, 43, 43, 43, 43, 44, 43, 44,
43, 43, 44, 44, 43, 43, 43, 43, 43, 42, 42, 42, 42, 42, 43, 42, 41, 41, 41, 40,
40, 39, 39, 39, 38, 38, 37, 36, 36, 35, 34, 33, 33, 32, 31, 30, 28, 27, 26, 25,
23, 22, 21, 20, 18, 16, 15, 13, 11, 8, 7, 4, 3, 0, -3, -5, -8, -10, -13, -16,
-18, -21, -23, -25, -28, -31, -32, -35, -38, -39, -42, -45, -47, -49, -51, -54,
-56, -58, -60, -62, -64, -66, -68, -69, -72, -74, -75, -77, -79, -81, -82, -84,
-85, -87, -88, -89, -91, -92, -94, -96, -96, -98, -98, -100, -101, -101, -103,
-104, -104, -105, -106, -106, -107, -108, -109, -110, -110, -111, -112, -112,
-113, -113, -113, -114, -114, -115, -115, -115, -116, -116, -117, -117, -117,
-118, -117, -118, -117, -118, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -120, -119, -118, -119, -118, -118, -118,
-118, -118, -118, -117, -116, -117, -116, -116, -116, -115, -115, -114, -114,
-114, -112, -113, -112, -112, -111, -111, -110, -109, -109, -108, -107, -106,
-106, -104, -104, -103, -103, -101, -101, -100, -99, -98, -96, -94, -95, -93,
-91, -91, -89, -89, -87, -85, -84, -82, -81, -79, -77, -77, -75, -72, -71, -68,
-67, -65, -63, -61, -59, -57, -54, -52, -49, -48, -46, -43, -40, -38, -35, -33,
-30, -27, -25, -21, -19, -16, -13, -11, -7, -3, -1, };