#define DATA_LENGTH 512
#define DATA AKWF_ebass_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 5, 6, 6, 9, 10, 12, 12, 14,
14, 16, 16, 19, 19, 20, 22, 22, 23, 25, 26, 27, 27, 29, 30, 31, 32, 34, 35, 36,
36, 38, 39, 40, 41, 42, 44, 45, 45, 46, 47, 48, 49, 51, 51, 53, 54, 54, 55, 57,
57, 58, 60, 60, 61, 62, 63, 63, 65, 65, 66, 67, 69, 69, 70, 71, 71, 72, 73, 74,
75, 76, 77, 78, 78, 79, 79, 80, 82, 82, 82, 84, 84, 85, 85, 86, 87, 88, 89, 89,
90, 90, 91, 92, 92, 93, 94, 94, 94, 95, 96, 96, 97, 98, 99, 99, 99, 99, 100,
100, 102, 103, 102, 103, 103, 105, 105, 105, 104, 105, 106, 107, 107, 108, 108,
108, 108, 109, 109, 109, 109, 110, 110, 110, 111, 111, 111, 111, 111, 112, 112,
111, 112, 112, 112, 113, 112, 112, 112, 113, 113, 113, 112, 112, 113, 113, 112,
113, 112, 112, 112, 112, 111, 110, 111, 111, 110, 111, 110, 110, 109, 109, 109,
108, 108, 106, 107, 106, 106, 104, 104, 104, 104, 103, 102, 102, 101, 101, 101,
99, 98, 98, 97, 96, 95, 94, 94, 92, 92, 91, 90, 88, 88, 87, 86, 85, 84, 83, 82,
81, 80, 79, 78, 77, 75, 74, 73, 72, 71, 69, 68, 66, 66, 64, 63, 61, 60, 59, 57,
56, 55, 53, 52, 50, 49, 47, 46, 44, 43, 42, 39, 39, 36, 35, 34, 32, 30, 29, 27,
26, 23, 22, 21, 19, 17, 15, 15, 13, 10, 9, 8, 6, 4, 3, 0, 0, -3, -4, -6, -8,
-10, -11, -14, -15, -16, -18, -19, -21, -23, -24, -26, -28, -29, -32, -34, -34,
-35, -37, -40, -42, -43, -44, -45, -48, -48, -51, -52, -53, -54, -56, -58, -60,
-61, -63, -63, -66, -66, -68, -69, -72, -72, -73, -74, -77, -78, -78, -81, -82,
-82, -84, -85, -86, -87, -89, -89, -91, -92, -93, -94, -95, -97, -97, -99, -99,
-100, -101, -102, -103, -103, -105, -105, -106, -107, -107, -108, -108, -110,
-110, -111, -111, -112, -112, -113, -114, -113, -115, -114, -115, -115, -116,
-116, -117, -118, -118, -118, -118, -118, -118, -119, -118, -119, -118, -119,
-119, -119, -119, -118, -118, -119, -119, -119, -119, -118, -119, -118, -118,
-118, -117, -118, -117, -118, -117, -117, -115, -116, -114, -114, -114, -114,
-113, -113, -113, -112, -111, -110, -111, -110, -109, -108, -109, -107, -106,
-107, -105, -104, -104, -103, -103, -102, -101, -100, -100, -99, -97, -97, -97,
-95, -95, -93, -93, -92, -91, -90, -88, -88, -87, -86, -85, -84, -83, -82, -82,
-80, -80, -78, -77, -77, -75, -74, -73, -72, -71, -69, -69, -68, -67, -65, -65,
-63, -62, -60, -60, -59, -57, -56, -55, -54, -53, -52, -50, -49, -48, -47, -46,
-44, -43, -42, -41, -40, -38, -37, -36, -35, -33, -33, -32, -29, -29, -27, -26,
-25, -24, -22, -21, -20, -18, -18, -17, -14, -14, -12, -12, -10, -9, -7, -6, -6,
-5, -3, -2, 0, };