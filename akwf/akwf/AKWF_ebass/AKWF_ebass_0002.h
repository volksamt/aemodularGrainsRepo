#define DATA_LENGTH 512
#define DATA AKWF_ebass_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 6, 8, 12, 15, 19, 22, 24, 27,
30, 34, 37, 40, 43, 46, 49, 52, 56, 60, 62, 65, 68, 71, 73, 77, 79, 81, 84, 86,
89, 90, 94, 95, 98, 99, 101, 104, 105, 107, 108, 110, 111, 112, 113, 114, 115,
115, 116, 117, 117, 118, 118, 120, 119, 119, 119, 119, 119, 118, 119, 118, 117,
117, 117, 116, 115, 113, 113, 112, 111, 109, 108, 107, 105, 104, 102, 101, 99,
98, 96, 94, 92, 90, 88, 87, 85, 82, 81, 78, 77, 74, 72, 69, 68, 66, 64, 61, 58,
57, 54, 52, 49, 48, 45, 43, 40, 38, 35, 33, 30, 28, 26, 24, 21, 19, 18, 15, 12,
11, 8, 6, 3, 2, 0, -3, -5, -8, -10, -11, -13, -15, -17, -19, -22, -22, -25, -28,
-29, -31, -32, -34, -35, -37, -39, -40, -41, -43, -45, -46, -48, -49, -50, -52,
-53, -55, -56, -57, -58, -60, -60, -61, -63, -64, -65, -66, -66, -67, -68, -69,
-70, -71, -72, -74, -74, -75, -75, -75, -76, -77, -78, -79, -79, -80, -80, -81,
-82, -83, -83, -84, -85, -85, -86, -86, -86, -87, -87, -88, -87, -89, -88, -89,
-89, -90, -89, -91, -90, -91, -92, -92, -92, -93, -93, -94, -94, -95, -95, -95,
-96, -96, -95, -96, -96, -96, -96, -97, -97, -98, -98, -97, -97, -98, -97, -97,
-97, -98, -97, -97, -97, -97, -97, -97, -97, -97, -97, -97, -96, -96, -95, -95,
-95, -95, -93, -93, -94, -93, -91, -92, -90, -91, -90, -89, -88, -88, -87, -86,
-85, -84, -83, -82, -82, -80, -79, -79, -77, -77, -75, -75, -75, -74, -71, -71,
-69, -68, -67, -66, -64, -62, -61, -60, -58, -56, -55, -53, -52, -50, -49, -46,
-45, -43, -42, -41, -39, -37, -35, -34, -32, -31, -29, -28, -25, -24, -23, -22,
-20, -18, -17, -16, -13, -13, -11, -9, -7, -7, -6, -5, -3, -1, 1, 2, 3, 5, 6, 7,
8, 9, 11, 12, 14, 15, 17, 18, 19, 21, 22, 24, 24, 25, 27, 28, 29, 31, 31, 33,
34, 35, 36, 37, 38, 40, 40, 41, 42, 43, 44, 45, 46, 46, 47, 48, 49, 50, 50, 50,
52, 53, 53, 54, 55, 56, 57, 57, 58, 59, 60, 60, 62, 62, 64, 65, 65, 66, 67, 67,
68, 69, 69, 71, 72, 72, 72, 73, 74, 74, 75, 74, 74, 73, 75, 74, 74, 73, 73, 73,
73, 73, 71, 71, 71, 70, 69, 68, 67, 66, 65, 63, 62, 61, 60, 58, 57, 56, 53, 52,
50, 49, 47, 44, 42, 41, 38, 37, 34, 33, 30, 28, 26, 24, 22, 19, 17, 14, 12, 9,
7, 4, 2, -1, -4, -6, -8, -11, -13, -16, -19, -21, -23, -25, -27, -28, -30, -32,
-34, -35, -37, -37, -39, -40, -41, -42, -43, -43, -43, -44, -44, -44, -44, -44,
-44, -43, -41, -41, -39, -38, -37, -37, -35, -33, -32, -30, -28, -26, -24, -22,
-20, -18, -15, -12, -10, -8, -4, -2, };