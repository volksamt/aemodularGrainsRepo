#define DATA_LENGTH 512
#define DATA AKWF_ebass_0058

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 7, 9, 12, 14, 15, 18, 20, 22,
23, 26, 28, 29, 31, 32, 34, 35, 37, 38, 39, 41, 43, 44, 45, 46, 47, 49, 50, 51,
52, 54, 54, 55, 55, 57, 57, 58, 59, 59, 60, 60, 61, 62, 63, 63, 64, 64, 65, 65,
65, 65, 67, 67, 67, 67, 67, 68, 68, 69, 69, 69, 70, 69, 69, 70, 69, 70, 70, 70,
70, 70, 70, 71, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 70, 69, 69, 69, 68,
68, 68, 68, 68, 69, 67, 68, 68, 67, 68, 67, 66, 66, 66, 66, 65, 65, 64, 65, 64,
63, 63, 62, 63, 63, 63, 62, 62, 62, 61, 60, 61, 60, 60, 60, 59, 58, 58, 58, 57,
57, 57, 57, 56, 56, 56, 55, 54, 54, 54, 53, 53, 53, 52, 52, 51, 51, 50, 50, 50,
49, 49, 49, 48, 48, 47, 47, 47, 46, 45, 45, 45, 44, 43, 43, 42, 43, 42, 42, 41,
41, 41, 39, 39, 39, 38, 38, 38, 37, 36, 35, 36, 35, 35, 34, 34, 33, 33, 32, 31,
31, 30, 29, 29, 28, 28, 28, 27, 27, 26, 25, 25, 25, 24, 24, 23, 23, 22, 22, 21,
21, 21, 21, 21, 19, 19, 19, 19, 17, 17, 17, 17, 16, 16, 15, 15, 14, 15, 15, 13,
13, 13, 13, 12, 12, 10, 11, 10, 11, 10, 9, 10, 10, 9, 8, 8, 7, 8, 7, 6, 7, 6, 6,
6, 6, 6, 6, 6, 5, 6, 5, 6, 6, 6, 6, 6, 6, 6, 5, 6, 6, 6, 7, 7, 8, 7, 8, 8, 8, 7,
8, 8, 9, 9, 10, 9, 10, 10, 9, 11, 11, 12, 12, 12, 13, 13, 13, 14, 15, 14, 15,
16, 16, 17, 17, 19, 18, 19, 19, 20, 20, 21, 22, 22, 23, 24, 25, 25, 26, 25, 26,
26, 26, 28, 27, 28, 28, 29, 29, 29, 30, 29, 29, 28, 29, 29, 29, 29, 29, 28, 27,
27, 27, 26, 26, 25, 25, 24, 23, 22, 21, 20, 19, 17, 17, 15, 14, 13, 12, 10, 8,
6, 4, 2, 1, -2, -4, -6, -8, -10, -13, -15, -18, -20, -24, -25, -29, -31, -33,
-36, -38, -41, -43, -45, -48, -51, -53, -56, -58, -61, -62, -65, -67, -69, -72,
-74, -77, -79, -80, -82, -85, -86, -88, -90, -91, -94, -95, -97, -98, -100,
-101, -102, -104, -105, -107, -107, -108, -109, -110, -112, -111, -112, -115,
-115, -115, -116, -116, -117, -118, -118, -119, -118, -118, -118, -119, -119,
-119, -118, -119, -119, -119, -119, -118, -117, -118, -118, -118, -117, -117,
-116, -114, -113, -113, -112, -111, -111, -110, -108, -108, -107, -106, -104,
-104, -102, -101, -99, -97, -97, -95, -93, -92, -91, -89, -87, -85, -83, -82,
-80, -77, -75, -73, -72, -69, -68, -65, -62, -60, -58, -56, -54, -52, -48, -47,
-43, -41, -38, -36, -34, -31, -28, -25, -23, -20, -17, -14, -12, -9, -8, -7, -4,
-1, };