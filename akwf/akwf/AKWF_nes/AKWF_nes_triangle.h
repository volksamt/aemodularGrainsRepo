#define DATA_LENGTH 512
#define DATA AKWF_nes_triangle

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 16, 13, 16, 14, 15, 15, 15, 15, 15,
16, 14, 15, 14, 15, 13, 22, 31, 28, 30, 29, 29, 29, 30, 29, 29, 30, 29, 29, 29,
29, 29, 28, 40, 45, 43, 45, 43, 45, 43, 45, 44, 45, 44, 45, 44, 44, 43, 44, 56,
59, 59, 60, 57, 59, 58, 59, 58, 58, 58, 59, 58, 59, 58, 59, 72, 75, 72, 73, 73,
74, 73, 74, 73, 73, 73, 74, 73, 74, 72, 75, 88, 88, 87, 88, 87, 88, 88, 88, 87,
88, 88, 88, 87, 89, 86, 89, 103, 102, 102, 102, 102, 104, 102, 102, 102, 103,
102, 103, 102, 103, 102, 105, 118, 118, 118, 117, 116, 117, 117, 117, 118, 117,
117, 116, 118, 116, 118, 114, 101, 103, 102, 103, 102, 103, 102, 102, 103, 102,
103, 102, 104, 101, 103, 98, 86, 88, 87, 88, 87, 87, 87, 87, 87, 88, 88, 87, 88,
87, 89, 82, 71, 73, 72, 73, 73, 74, 72, 72, 73, 73, 73, 73, 73, 72, 74, 66, 57,
60, 58, 59, 58, 59, 58, 58, 58, 58, 58, 58, 59, 58, 60, 51, 42, 45, 43, 44, 43,
44, 44, 44, 44, 43, 44, 43, 44, 43, 45, 34, 28, 30, 29, 30, 29, 30, 29, 30, 29,
29, 29, 30, 30, 30, 30, 19, 13, 16, 14, 15, 14, 15, 14, 14, 14, 14, 15, 15, 15,
15, 15, 2, -1, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, -2, -15, -14, -14, -15,
-14, -15, -14, -16, -15, -15, -14, -16, -14, -15, -14, -18, -30, -29, -29, -29,
-29, -29, -30, -29, -29, -30, -28, -30, -28, -30, -27, -32, -44, -44, -44, -44,
-44, -44, -44, -44, -43, -44, -43, -45, -43, -45, -42, -49, -60, -58, -59, -58,
-59, -58, -58, -59, -58, -58, -58, -59, -57, -60, -57, -65, -75, -72, -74, -72,
-73, -73, -73, -73, -74, -74, -73, -74, -73, -74, -72, -81, -90, -87, -89, -88,
-89, -87, -88, -88, -88, -88, -87, -88, -87, -88, -86, -96, -104, -101, -103,
-101, -103, -101, -102, -102, -103, -103, -102, -102, -102, -103, -101, -113,
-118, -117, -118, -117, -117, -117, -117, -117, -118, -117, -118, -117, -117,
-116, -118, -105, -101, -103, -102, -103, -101, -103, -102, -103, -102, -102,
-103, -103, -102, -102, -104, -91, -86, -89, -87, -89, -87, -88, -87, -88, -87,
-88, -87, -88, -87, -87, -88, -76, -72, -73, -73, -74, -72, -73, -73, -73, -72,
-74, -73, -74, -73, -73, -73, -59, -58, -59, -59, -59, -58, -58, -58, -58, -57,
-59, -58, -59, -58, -59, -57, -44, -43, -45, -43, -44, -43, -44, -43, -44, -43,
-44, -44, -45, -43, -45, -42, -29, -29, -29, -29, -30, -29, -30, -30, -29, -30,
-29, -30, -29, -30, -29, -31, -24, -13, -16, -14, -15, -14, -15, -14, -15, -14,
-15, -15, -15, -15, -14, -17, -7, 2, -1, 1, 0, 0, 0, 0, 0, 0, 1, 1, -1, 0, 0,
-1, };