#define DATA_LENGTH 512
#define DATA AKWF_nes_pulse_25

const PROGMEM int8_t DATA[DATA_LENGTH] = {63, 97, 91, 96, 92, 95, 93, 95, 94,
95, 93, 95, 93, 95, 94, 94, 94, 94, 94, 95, 94, 93, 94, 93, 94, 93, 94, 94, 94,
95, 95, 94, 95, 94, 94, 93, 94, 93, 94, 94, 94, 94, 93, 93, 94, 94, 94, 94, 94,
94, 94, 94, 94, 93, 95, 94, 95, 94, 94, 93, 94, 94, 95, 94, 93, 94, 94, 95, 94,
94, 93, 94, 94, 94, 94, 94, 94, 95, 94, 94, 94, 94, 94, 94, 93, 94, 94, 94, 94,
94, 94, 94, 93, 94, 94, 94, 95, 94, 95, 93, 95, 94, 94, 94, 94, 94, 94, 94, 94,
94, 94, 95, 93, 94, 94, 96, 93, 96, 92, 97, 91, 97, 91, 98, 89, 101, 84, 110,
49, -108, -89, -97, -92, -94, -95, -94, -95, -93, -96, -93, -95, -93, -96, -92,
-96, -92, -95, -93, -94, -94, -94, -93, -94, -94, -95, -93, -94, -94, -94, -94,
-93, -94, -93, -94, -94, -94, -94, -94, -94, -94, -94, -95, -94, -94, -94, -95,
-94, -94, -93, -95, -94, -95, -95, -94, -94, -95, -94, -95, -94, -95, -94, -94,
-94, -93, -94, -94, -94, -94, -94, -93, -94, -94, -94, -94, -94, -93, -94, -94,
-94, -94, -94, -94, -94, -94, -94, -94, -94, -93, -94, -94, -94, -94, -94, -94,
-94, -93, -95, -94, -94, -94, -94, -93, -94, -94, -94, -94, -94, -94, -94, -94,
-94, -94, -93, -94, -94, -94, -94, -93, -94, -93, -94, -94, -94, -94, -94, -94,
-94, -94, -93, -94, -94, -94, -94, -95, -94, -93, -93, -94, -94, -95, -94, -93,
-94, -94, -94, -94, -94, -94, -94, -94, -94, -94, -94, -94, -94, -95, -94, -94,
-94, -93, -94, -94, -94, -93, -95, -94, -94, -94, -94, -94, -93, -94, -94, -93,
-93, -94, -94, -94, -94, -93, -94, -94, -94, -94, -94, -94, -94, -93, -95, -94,
-94, -94, -94, -95, -94, -94, -94, -93, -95, -94, -93, -95, -94, -93, -94, -94,
-94, -94, -94, -94, -94, -94, -94, -94, -94, -94, -94, -94, -94, -95, -94, -94,
-94, -95, -94, -95, -94, -94, -94, -94, -95, -94, -94, -95, -93, -94, -95, -94,
-94, -94, -94, -94, -94, -94, -93, -94, -94, -94, -94, -94, -94, -94, -94, -94,
-93, -94, -95, -94, -94, -94, -94, -94, -93, -94, -94, -94, -94, -95, -95, -95,
-95, -94, -94, -95, -95, -94, -95, -93, -94, -93, -93, -94, -95, -94, -93, -94,
-93, -94, -94, -94, -94, -94, -94, -93, -95, -94, -93, -94, -94, -94, -95, -94,
-93, -94, -94, -94, -94, -95, -93, -94, -94, -94, -94, -95, -94, -94, -94, -94,
-94, -94, -94, -94, -94, -94, -94, -94, -94, -94, -94, -94, -95, -94, -94, -93,
-94, -94, -93, -94, -94, -94, -94, -94, -94, -94, -94, -94, -93, -94, -93, -94,
-94, -94, -94, -95, -94, -94, -94, -95, -93, -94, -94, -94, -94, -93, -95, -93,
-95, -93, -96, -92, -95, -92, -96, -92, -96, -92, -95, -92, -96, -93, -95, -95,
};