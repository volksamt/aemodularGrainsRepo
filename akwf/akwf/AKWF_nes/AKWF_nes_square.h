#define DATA_LENGTH 512
#define DATA AKWF_nes_square

const PROGMEM int8_t DATA[DATA_LENGTH] = {82, 99, 91, 96, 92, 96, 92, 96, 93,
95, 93, 96, 92, 95, 94, 95, 93, 94, 94, 94, 95, 93, 95, 94, 93, 94, 95, 94, 94,
93, 94, 94, 95, 94, 94, 94, 95, 94, 95, 94, 94, 93, 94, 94, 94, 93, 94, 95, 94,
94, 94, 94, 94, 94, 95, 93, 94, 94, 94, 94, 93, 93, 95, 94, 95, 93, 94, 94, 94,
94, 93, 94, 94, 93, 93, 94, 94, 94, 94, 93, 94, 94, 95, 94, 94, 95, 93, 94, 94,
95, 94, 94, 93, 94, 93, 94, 94, 94, 93, 95, 94, 94, 93, 94, 94, 94, 94, 94, 95,
93, 94, 94, 94, 94, 94, 94, 93, 94, 94, 93, 94, 94, 94, 93, 95, 94, 94, 94, 93,
94, 94, 94, 94, 94, 94, 93, 93, 93, 94, 94, 94, 94, 94, 94, 94, 93, 94, 94, 93,
94, 94, 95, 95, 94, 94, 94, 94, 95, 93, 93, 94, 94, 93, 94, 94, 94, 94, 95, 94,
94, 94, 95, 94, 94, 94, 94, 94, 94, 94, 94, 94, 94, 94, 93, 94, 94, 94, 94, 94,
94, 94, 94, 95, 94, 94, 93, 94, 93, 94, 94, 94, 94, 94, 94, 93, 95, 93, 94, 94,
93, 94, 95, 94, 94, 94, 94, 94, 94, 94, 95, 93, 95, 93, 95, 94, 94, 93, 94, 95,
94, 94, 94, 94, 93, 94, 93, 95, 92, 95, 93, 95, 92, 96, 93, 95, 92, 96, 93, 96,
93, 96, 93, 94, 94, 93, 100, -65, -106, -86, -99, -89, -98, -90, -97, -91, -97,
-91, -95, -93, -95, -93, -95, -93, -94, -94, -94, -94, -94, -95, -93, -94, -93,
-95, -94, -95, -93, -94, -93, -94, -94, -94, -94, -94, -94, -94, -94, -94, -94,
-94, -94, -94, -94, -94, -95, -94, -95, -94, -94, -94, -94, -94, -93, -93, -94,
-94, -94, -94, -94, -94, -94, -94, -94, -95, -93, -94, -94, -94, -94, -94, -94,
-94, -93, -94, -95, -94, -94, -95, -94, -94, -94, -94, -95, -94, -94, -93, -94,
-94, -95, -94, -93, -94, -95, -94, -93, -94, -93, -94, -94, -94, -94, -94, -94,
-94, -94, -93, -94, -94, -95, -94, -93, -94, -94, -94, -93, -93, -94, -94, -93,
-94, -94, -94, -93, -94, -94, -94, -94, -93, -94, -94, -94, -93, -95, -95, -94,
-95, -94, -95, -93, -94, -94, -94, -94, -93, -94, -94, -93, -94, -93, -94, -93,
-93, -94, -94, -94, -93, -94, -94, -94, -95, -94, -93, -94, -94, -94, -93, -94,
-93, -94, -94, -94, -94, -94, -93, -93, -94, -94, -94, -94, -93, -94, -93, -95,
-93, -93, -94, -93, -93, -94, -94, -94, -94, -94, -94, -94, -94, -94, -93, -94,
-94, -95, -94, -94, -94, -93, -94, -94, -94, -94, -93, -94, -94, -94, -94, -94,
-94, -94, -94, -94, -94, -93, -95, -94, -94, -94, -94, -94, -94, -94, -94, -94,
-95, -94, -94, -94, -94, -94, -93, -94, -94, -94, -94, -95, -95, -94, -94, -94,
-95, -92, -96, -91, -101, -51, };