#define DATA_LENGTH 512
#define DATA AKWF_nes_pulse_12_5

const PROGMEM int8_t DATA[DATA_LENGTH] = {62, 96, 91, 95, 92, 94, 93, 94, 92,
94, 93, 94, 92, 94, 93, 93, 93, 94, 92, 93, 93, 93, 93, 93, 93, 93, 93, 92, 94,
93, 93, 93, 94, 93, 94, 93, 93, 93, 94, 92, 94, 92, 94, 92, 94, 93, 94, 93, 93,
94, 93, 94, 92, 95, 92, 95, 91, 96, 89, 97, 88, 101, 83, 110, 36, -110, -86,
-97, -92, -95, -92, -93, -94, -93, -94, -92, -94, -92, -95, -93, -95, -92, -94,
-93, -95, -92, -95, -92, -94, -93, -93, -93, -93, -93, -93, -93, -92, -93, -93,
-93, -93, -94, -93, -93, -92, -94, -92, -93, -93, -94, -92, -93, -93, -93, -94,
-93, -92, -93, -93, -93, -93, -93, -93, -94, -93, -93, -93, -93, -93, -94, -94,
-93, -93, -93, -93, -94, -94, -93, -94, -93, -93, -93, -93, -94, -93, -93, -93,
-93, -93, -92, -93, -94, -94, -93, -94, -93, -93, -93, -93, -93, -92, -93, -93,
-93, -94, -93, -93, -93, -94, -93, -93, -93, -93, -93, -93, -93, -94, -93, -93,
-93, -93, -94, -94, -93, -93, -92, -94, -93, -93, -94, -93, -94, -93, -94, -93,
-93, -93, -93, -93, -93, -94, -93, -93, -94, -93, -94, -94, -93, -93, -92, -93,
-93, -93, -93, -93, -94, -93, -93, -93, -94, -94, -94, -93, -94, -94, -94, -93,
-94, -94, -93, -93, -94, -94, -93, -93, -93, -93, -93, -93, -93, -93, -94, -93,
-93, -93, -93, -93, -93, -93, -93, -93, -94, -93, -93, -94, -93, -93, -93, -94,
-93, -94, -93, -94, -93, -93, -94, -94, -93, -93, -93, -93, -93, -93, -93, -93,
-94, -93, -93, -93, -93, -93, -94, -93, -93, -94, -93, -93, -94, -93, -93, -93,
-93, -93, -94, -93, -93, -94, -93, -93, -94, -93, -93, -92, -93, -93, -93, -94,
-93, -93, -93, -93, -93, -94, -93, -94, -93, -93, -93, -94, -93, -93, -94, -94,
-94, -93, -94, -94, -93, -93, -93, -93, -94, -93, -94, -93, -93, -93, -93, -93,
-93, -93, -93, -93, -94, -93, -93, -93, -93, -93, -94, -93, -93, -93, -93, -93,
-93, -94, -93, -93, -93, -93, -93, -93, -93, -93, -93, -93, -94, -93, -93, -93,
-93, -93, -93, -93, -94, -93, -93, -92, -93, -93, -94, -93, -93, -93, -93, -93,
-92, -93, -93, -93, -94, -93, -93, -93, -94, -93, -94, -93, -93, -93, -93, -93,
-94, -94, -94, -93, -94, -93, -93, -93, -93, -93, -94, -94, -93, -93, -94, -94,
-93, -93, -93, -94, -94, -94, -93, -93, -94, -93, -93, -93, -93, -94, -93, -93,
-94, -93, -93, -93, -93, -93, -94, -93, -93, -93, -92, -93, -93, -93, -94, -94,
-93, -93, -94, -94, -93, -93, -93, -93, -93, -93, -94, -94, -93, -93, -93, -94,
-94, -93, -94, -93, -94, -93, -93, -93, -94, -93, -93, -93, -94, -93, -94, -93,
-93, -94, -93, -93, -93, -94, -93, -94, -93, -94, -93, -94, -92, -94, -92, -95,
-91, -95, -91, -95, -92, -95, -91, -95, -92, -95, -92, -93, -95, };