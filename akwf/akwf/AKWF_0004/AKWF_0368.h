#define DATA_LENGTH 512
#define DATA AKWF_0368

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 5, 8, 9, 11, 13, 14, 17, 20,
22, 23, 24, 26, 28, 31, 32, 34, 35, 36, 37, 37, 39, 39, 40, 42, 41, 42, 43, 44,
45, 46, 46, 47, 49, 49, 50, 50, 51, 51, 52, 54, 54, 55, 55, 56, 57, 58, 58, 59,
60, 60, 61, 61, 63, 63, 63, 65, 65, 65, 66, 67, 68, 69, 70, 70, 70, 71, 72, 73,
73, 73, 74, 74, 75, 76, 76, 77, 77, 79, 79, 80, 80, 80, 81, 82, 83, 83, 84, 85,
84, 86, 86, 86, 87, 88, 88, 89, 89, 89, 90, 90, 91, 91, 91, 93, 93, 94, 94, 94,
95, 95, 95, 96, 96, 97, 97, 98, 98, 98, 99, 99, 100, 101, 100, 101, 101, 101,
103, 103, 103, 104, 103, 103, 104, 104, 105, 106, 105, 106, 106, 106, 107, 107,
107, 108, 108, 108, 108, 109, 110, 110, 110, 110, 111, 110, 111, 110, 111, 111,
111, 112, 112, 112, 113, 112, 113, 113, 114, 114, 114, 113, 115, 114, 114, 115,
115, 115, 115, 115, 115, 115, 115, 115, 116, 115, 117, 116, 116, 117, 117, 116,
117, 117, 117, 117, 117, 117, 117, 117, 117, 118, 118, 118, 117, 117, 118, 118,
117, 118, 119, 118, 118, 119, 118, 118, 119, 118, 119, 118, 120, 118, 119, 118,
120, 119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 120, 118, 120, 118, 121,
117, 121, 116, 122, 115, 122, 115, 123, 115, 124, 114, 125, 113, 126, 104, -115,
-123, -116, -123, -115, -123, -115, -123, -115, -122, -117, -121, -116, -121,
-117, -121, -118, -120, -118, -119, -119, -119, -118, -119, -119, -119, -119,
-118, -120, -118, -120, -119, -118, -118, -119, -118, -119, -118, -119, -118,
-119, -118, -118, -118, -119, -119, -118, -118, -118, -118, -117, -117, -118,
-117, -117, -117, -117, -117, -117, -118, -118, -117, -117, -116, -116, -116,
-116, -117, -116, -116, -116, -116, -116, -115, -116, -115, -115, -115, -115,
-115, -114, -114, -115, -114, -113, -114, -113, -114, -112, -112, -112, -113,
-112, -111, -112, -112, -112, -111, -111, -111, -110, -110, -110, -110, -109,
-109, -109, -109, -109, -108, -107, -107, -107, -107, -107, -106, -105, -106,
-106, -106, -105, -103, -103, -103, -103, -102, -102, -101, -102, -101, -101,
-101, -100, -100, -99, -99, -98, -97, -97, -98, -97, -97, -96, -96, -96, -94,
-94, -93, -94, -92, -92, -93, -91, -91, -90, -89, -89, -89, -88, -88, -87, -86,
-86, -86, -85, -84, -84, -84, -83, -83, -81, -80, -81, -81, -80, -78, -78, -78,
-77, -77, -75, -75, -75, -74, -73, -73, -72, -71, -71, -70, -69, -69, -68, -68,
-66, -67, -66, -65, -65, -64, -63, -62, -62, -61, -61, -59, -58, -59, -57, -57,
-56, -54, -54, -54, -52, -53, -51, -51, -50, -49, -48, -47, -47, -46, -45, -45,
-43, -44, -42, -42, -41, -40, -40, -38, -38, -37, -36, -35, -34, -32, -30, -28,
-26, -24, -22, -21, -19, -16, -15, -12, -11, -9, -8, -5, -3, -2, };