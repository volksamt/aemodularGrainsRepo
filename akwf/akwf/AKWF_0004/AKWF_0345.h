#define DATA_LENGTH 512
#define DATA AKWF_0345

const PROGMEM int8_t DATA[DATA_LENGTH] = {-104, -125, -115, -122, -116, -121,
-117, -122, -118, -121, -119, -120, -120, -117, -123, -93, -66, -76, -69, -73,
-70, -72, -71, -72, -72, -72, -71, -72, -72, -72, -73, -72, -72, -71, -72, -71,
-71, -71, -72, -72, -71, -71, -72, -72, -71, -72, -71, -72, -72, -72, -71, -71,
-72, -72, -72, -71, -71, -72, -72, -71, -71, -72, -71, -72, -72, -71, -72, -71,
-71, -72, -71, -72, -72, -71, -72, -72, -71, -72, -71, -72, -72, -71, -71, -71,
-71, -71, -72, -71, -71, -71, -71, -71, -71, -71, -71, -70, -70, -71, -71, -71,
-71, -71, -71, -71, -71, -71, -71, -72, -71, -72, -70, -70, -71, -72, -71, -71,
-71, -71, -70, -70, -71, -71, -70, -71, -71, -71, -70, -71, -71, -70, -72, -68,
-72, -67, -75, -56, -19, -26, -23, -24, -23, -24, -24, -23, -24, -23, -23, -23,
-23, -23, -23, -23, -23, -22, -24, -23, -23, -23, -23, -23, -23, -23, -23, -23,
-23, -23, -23, -24, -23, -23, -23, -23, -23, -23, -23, -22, -23, -23, -24, -24,
-23, -23, -23, -24, -23, -23, -23, -22, -23, -24, -23, -23, -23, -23, -23, -24,
-23, -24, -23, -24, -22, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23, -23,
-23, -23, -23, -23, -23, -23, -22, -23, -23, -23, -23, -24, -22, -24, -22, -23,
-23, -22, -24, -23, -22, -22, -22, -23, -23, -23, -22, -23, -23, -23, -23, -22,
-24, -22, -24, -23, -24, -22, -24, -23, -24, -21, -24, -19, 24, 25, 23, 26, 23,
26, 23, 25, 23, 25, 23, 25, 24, 25, 24, 25, 24, 25, 25, 25, 24, 24, 24, 24, 25,
24, 24, 25, 25, 24, 25, 23, 25, 24, 25, 24, 24, 25, 24, 24, 25, 25, 24, 25, 24,
24, 24, 25, 24, 24, 24, 24, 24, 24, 25, 24, 24, 24, 24, 24, 25, 25, 25, 24, 25,
24, 25, 25, 25, 25, 24, 24, 25, 24, 24, 24, 25, 24, 25, 24, 24, 24, 24, 25, 24,
25, 24, 24, 24, 24, 24, 24, 24, 24, 25, 24, 25, 24, 24, 23, 25, 24, 25, 24, 25,
24, 25, 23, 24, 24, 25, 24, 24, 24, 24, 24, 25, 24, 24, 25, 24, 66, 74, 70, 73,
70, 72, 70, 72, 70, 72, 71, 72, 72, 72, 71, 72, 71, 72, 71, 71, 72, 71, 72, 72,
71, 71, 71, 71, 71, 71, 72, 71, 71, 71, 72, 70, 71, 71, 71, 71, 71, 71, 71, 71,
71, 72, 71, 71, 71, 71, 71, 71, 70, 71, 71, 71, 72, 70, 70, 72, 71, 71, 71, 71,
71, 71, 71, 71, 71, 71, 71, 71, 71, 71, 70, 70, 70, 71, 70, 71, 71, 70, 70, 70,
70, 71, 71, 72, 71, 70, 70, 71, 71, 70, 71, 70, 71, 71, 71, 70, 71, 70, 71, 71,
70, 70, 71, 70, 71, 70, 70, 70, 71, 70, 71, 70, 72, 69, 72, 65, 98, 123, 114,
120, 115, 119, 114, 121, 114, 120, 114, 122, 112, 125, 100, };