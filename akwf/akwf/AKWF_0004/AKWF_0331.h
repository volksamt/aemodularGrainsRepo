#define DATA_LENGTH 512
#define DATA AKWF_0331

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 2, 3, 2, 1, 1, 2, 2, 3, 3, 5,
6, 8, 10, 11, 12, 12, 11, 11, 11, 11, 9, 8, 9, 10, 9, 11, 12, 12, 13, 14, 14,
14, 13, 12, 10, 9, 9, 9, 8, 7, 8, 8, 9, 9, 10, 9, 10, 10, 10, 8, 7, 6, 6, 6, 5,
6, 6, 7, 7, 8, 9, 9, 10, 10, 10, 10, 11, 11, 10, 11, 11, 11, 13, 13, 15, 15, 17,
17, 18, 18, 19, 19, 19, 19, 20, 19, 20, 20, 21, 22, 22, 24, 24, 24, 24, 25, 25,
24, 24, 24, 23, 23, 23, 23, 23, 23, 23, 23, 24, 22, 23, 23, 22, 21, 21, 20, 20,
19, 19, 19, 18, 18, 18, 18, 18, 18, 18, 18, 19, 18, 18, 18, 18, 17, 17, 18, 18,
18, 18, 19, 19, 20, 20, 20, 21, 21, 22, 22, 23, 22, 23, 24, 24, 25, 26, 26, 26,
27, 27, 28, 28, 28, 28, 29, 29, 29, 29, 30, 30, 30, 29, 31, 30, 31, 31, 31, 30,
30, 30, 29, 29, 29, 29, 28, 28, 27, 28, 27, 27, 27, 27, 26, 26, 26, 25, 24, 24,
24, 24, 24, 23, 24, 22, 23, 23, 22, 23, 23, 23, 23, 23, 23, 24, 23, 23, 24, 24,
23, 24, 25, 25, 26, 26, 26, 27, 26, 28, 28, 28, 29, 29, 28, 30, 30, 30, 30, 31,
31, 31, 32, 32, 32, 32, 32, 32, 32, 32, 32, 32, 32, 33, 32, 32, 31, 31, 31, 30,
32, 31, 30, 30, 30, 29, 28, 29, 28, 28, 27, 27, 28, 26, 26, 26, 26, 26, 25, 25,
24, 24, 25, 24, 24, 24, 24, 24, 24, 24, 24, 25, 24, 24, 24, 25, 25, 25, 26, 26,
25, 26, 27, 26, 27, 28, 28, 28, 29, 30, 30, 29, 30, 30, 30, 31, 31, 32, 31, 31,
31, 29, 7, -30, -63, -86, -103, -114, -118, -118, -112, -100, -86, -72, -58,
-48, -41, -39, -40, -46, -54, -63, -72, -80, -85, -87, -87, -84, -79, -75, -71,
-68, -66, -66, -69, -75, -79, -83, -85, -86, -83, -78, -70, -61, -51, -43, -35,
-30, -29, -31, -35, -41, -49, -56, -63, -68, -70, -69, -67, -61, -53, -46, -39,
-33, -30, -28, -27, -30, -34, -38, -41, -44, -46, -46, -45, -42, -38, -35, -31,
-30, -30, -32, -35, -38, -42, -46, -49, -52, -52, -51, -48, -45, -40, -35, -30,
-27, -27, -26, -27, -31, -35, -38, -41, -45, -46, -45, -44, -41, -38, -34, -30,
-28, -25, -23, -23, -24, -25, -27, -29, -29, -29, -29, -26, -23, -20, -17, -14,
-12, -11, -10, -10, -11, -14, -15, -17, -18, -19, -18, -16, -14, -11, -8, -6,
-4, -3, -2, -3, -4, -7, -9, -11, -12, -13, -14, -13, -13, -11, -9, -9, -7, -7,
-7, -7, -8, -9, -12, -13, -14, -14, -14, -14, -13, -12, -10, -8, -7, -6, -6, -7,
-6, -8, -9, -10, -11, -11, -11, -10, -8, -6, -4, -2, -1, };