#define DATA_LENGTH 512
#define DATA AKWF_0376

const PROGMEM int8_t DATA[DATA_LENGTH] = {16, 18, 17, 18, 17, 18, 17, 17, 17,
17, 17, 17, 17, 18, 17, 17, 18, 17, 18, 17, 18, 18, 17, 16, 17, 17, 17, 17, 17,
48, 51, 49, 52, 50, 51, 50, 52, 50, 51, 50, 52, 50, 51, 51, 50, 51, 51, 51, 50,
51, 50, 51, 50, 51, 51, 52, 50, 51, 51, 51, 50, 51, 51, 51, 51, 50, 52, 48, 74,
88, 82, 86, 84, 85, 83, 84, 84, 85, 84, 85, 84, 84, 85, 84, 84, 84, 84, 84, 83,
83, 84, 84, 85, 85, 84, 84, 84, 84, 84, 84, 84, 84, 84, 84, 85, 84, 84, 83, 83,
84, 84, 83, 83, 84, 84, 84, 84, 84, 84, 83, 84, 83, 84, 84, 83, 84, 84, 84, 83,
84, 83, 84, 83, 84, 83, 84, 84, 84, 84, 83, 83, 84, 83, 83, 83, 83, 83, 83, 83,
83, 84, 83, 83, 83, 83, 83, 83, 84, 83, 83, 83, 83, 83, 83, 83, 83, 84, 84, 83,
83, 83, 82, 84, 83, 84, 82, 83, 82, 83, 83, 82, 82, 84, 83, 83, 82, 83, 82, 83,
82, 85, 80, 88, 117, 115, 116, 116, 116, 116, 116, 117, 116, 117, 116, 116, 116,
116, 116, 116, 116, 117, 116, 117, 117, 116, 115, 116, 116, 116, 116, 116, 116,
116, 116, 116, 116, 116, 116, 115, 116, 116, 115, 116, 114, 117, 115, 116, 115,
116, 115, 116, 114, 116, 114, 83, 81, 84, 81, 84, 80, 85, 73, 44, 51, 46, 52,
42, 13, 15, 14, 15, -14, -22, -14, -36, -55, -51, -52, -52, -52, -53, -51, -80,
-88, -83, -87, -84, -87, -84, -86, -85, -86, -84, -87, -83, -91, -121, -118,
-119, -119, -118, -119, -118, -120, -118, -119, -119, -118, -119, -120, -119,
-119, -119, -119, -119, -120, -119, -118, -118, -119, -119, -119, -118, -118,
-119, -118, -119, -120, -118, -119, -118, -119, -119, -119, -118, -120, -116,
-123, -100, -80, -87, -83, -85, -85, -86, -85, -85, -86, -85, -85, -85, -86,
-85, -86, -85, -85, -84, -85, -85, -85, -84, -85, -85, -85, -85, -85, -85, -85,
-85, -85, -85, -85, -85, -85, -84, -84, -84, -84, -84, -84, -84, -85, -85, -85,
-85, -84, -85, -84, -85, -84, -84, -84, -85, -84, -84, -84, -85, -85, -85, -85,
-84, -84, -84, -84, -84, -84, -84, -85, -84, -84, -85, -84, -84, -84, -84, -84,
-84, -84, -84, -85, -84, -84, -84, -84, -84, -84, -84, -84, -84, -84, -83, -84,
-84, -84, -84, -84, -84, -84, -83, -83, -84, -84, -83, -84, -83, -84, -84, -84,
-83, -84, -84, -83, -84, -84, -83, -85, -83, -84, -83, -85, -82, -85, -81, -87,
-74, -47, -51, -50, -51, -50, -50, -49, -51, -50, -50, -50, -50, -50, -50, -50,
-50, -51, -50, -49, -49, -50, -50, -50, -50, -50, -50, -50, -50, -49, -51, -49,
-50, -50, -50, -50, -50, -49, -51, -49, -51, -49, -51, -49, -52, -46, -16, -16,
-16, -16, -17, -16, -17, -15, -17, -15, -18, -13, };