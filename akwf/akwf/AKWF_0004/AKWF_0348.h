#define DATA_LENGTH 512
#define DATA AKWF_0348

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 8, 11, 13, 14, 16, 19, 21,
22, 24, 25, 27, 29, 31, 33, 35, 36, 38, 40, 42, 43, 46, 47, 50, 51, 52, 55, 56,
58, 59, 60, 61, 62, 62, 63, 64, 63, 65, 66, 67, 67, 67, 68, 68, 69, 70, 70, 71,
71, 73, 72, 74, 74, 74, 75, 75, 77, 78, 76, 78, 78, 77, 78, 77, 77, 77, 78, 76,
77, 77, 77, 77, 77, 77, 76, 77, 77, 77, 77, 77, 77, 76, 77, 77, 77, 77, 77, 77,
76, 74, 74, 73, 73, 73, 72, 72, 71, 70, 69, 69, 68, 67, 67, 66, 65, 65, 64, 64,
64, 63, 62, 62, 61, 60, 58, 57, 56, 54, 54, 52, 51, 51, 49, 47, 46, 45, 43, 42,
41, 40, 39, 38, 36, 35, 34, 32, 32, 30, 29, 29, 27, 26, 25, 24, 24, 22, 23, 22,
22, 20, 20, 19, 19, 18, 17, 17, 17, 15, 15, 15, 14, 13, 12, 12, 11, 11, 10, 9,
9, 8, 8, 8, 9, 8, 8, 8, 7, 8, 8, 8, 8, 8, 8, 7, 8, 8, 8, 7, 9, 8, 8, 8, 9, 8, 8,
9, 8, 7, 8, 8, 8, 9, 8, 8, 8, 8, 8, 8, 8, 8, 8, 8, 9, 8, 8, 9, 8, 8, 8, 8, 9, 8,
8, 8, 8, 8, 8, 7, 7, 6, 6, 5, 4, 3, 2, 3, 2, 1, 0, 0, 0, -2, -2, -2, -3, -4, -5,
-5, -6, -6, -7, -7, -8, -9, -9, -9, -10, -9, -9, -9, -9, -9, -9, -9, -10, -9,
-8, -9, -9, -9, -9, -8, -10, -9, -9, -10, -9, -9, -8, -9, -9, -8, -9, -9, -9,
-9, -9, -9, -9, -8, -9, -9, -8, -9, -8, -9, -9, -8, -9, -10, -8, -8, -9, -9, -9,
-9, -9, -9, -9, -9, -9, -9, -9, -9, -9, -9, -9, -9, -8, -9, -8, -9, -9, -9, -8,
-9, -9, -9, -9, -9, -10, -9, -8, -8, -9, -9, -8, -9, -10, -9, -10, -11, -11,
-12, -12, -13, -14, -15, -15, -15, -17, -17, -18, -19, -18, -19, -20, -20, -21,
-22, -22, -23, -23, -25, -26, -26, -28, -28, -29, -31, -32, -34, -35, -36, -37,
-39, -40, -41, -42, -43, -45, -46, -47, -49, -49, -50, -51, -53, -54, -55, -56,
-58, -59, -60, -61, -61, -63, -63, -63, -64, -63, -65, -65, -66, -67, -67, -68,
-68, -70, -70, -70, -70, -71, -71, -72, -73, -74, -74, -75, -75, -76, -77, -77,
-76, -76, -76, -77, -76, -76, -77, -76, -76, -77, -77, -77, -76, -76, -77, -76,
-76, -77, -76, -76, -77, -76, -76, -76, -76, -77, -77, -76, -76, -74, -74, -74,
-73, -73, -72, -70, -69, -69, -69, -68, -68, -67, -66, -65, -65, -65, -64, -64,
-63, -62, -61, -61, -60, -59, -57, -55, -54, -52, -50, -49, -46, -45, -43, -41,
-40, -37, -36, -34, -32, -31, -28, -27, -24, -23, -21, -20, -18, -15, -14, -12,
-11, -8, -7, -5, -3, -1, };