#define DATA_LENGTH 512
#define DATA AKWF_0372

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 7, 7, 10, 12, 14, 17, 18, 19,
18, 18, 19, 21, 22, 26, 27, 27, 26, 25, 25, 26, 27, 30, 32, 31, 32, 33, 34, 35,
35, 35, 37, 40, 43, 46, 49, 50, 52, 52, 54, 55, 57, 56, 57, 58, 58, 60, 60, 61,
59, 57, 55, 51, 50, 47, 44, 40, 36, 32, 28, 24, 21, 19, 16, 16, 16, 15, 16, 16,
17, 18, 21, 23, 25, 26, 25, 25, 23, 23, 24, 25, 25, 26, 27, 27, 28, 30, 31, 32,
32, 31, 31, 30, 30, 27, 27, 26, 26, 26, 25, 25, 25, 24, 23, 20, 19, 18, 17, 18,
20, 20, 20, 20, 19, 20, 19, 18, 17, 18, 18, 17, 17, 16, 16, 15, 17, 16, 15, 12,
12, 10, 10, 10, 9, 9, 8, 9, 10, 10, 11, 9, 9, 11, 12, 13, 15, 16, 17, 16, 15,
14, 14, 13, 12, 13, 14, 14, 16, 17, 19, 18, 17, 18, 19, 20, 21, 19, 20, 21, 22,
25, 29, 34, 40, 44, 50, 54, 58, 63, 66, 68, 69, 69, 71, 75, 78, 79, 79, 80, 82,
83, 85, 86, 87, 89, 89, 91, 93, 93, 93, 94, 94, 94, 94, 94, 96, 97, 99, 99, 99,
100, 101, 103, 102, 101, 102, 102, 103, 104, 103, 102, 101, 101, 101, 100, 99,
97, 98, 100, 98, 97, 95, 94, 93, 92, 90, 88, 87, 87, 85, 84, 80, 78, 76, 74, 73,
72, 71, 72, 73, 73, 72, 70, 67, 64, 61, 56, 51, 47, 45, 42, 42, 41, 40, 39, 41,
40, 40, 40, 38, 37, 37, 35, 32, 31, 26, 24, 20, 19, 18, 18, 18, 19, 18, 17, 14,
12, 10, 8, 8, 6, 3, 0, -3, -6, -8, -10, -12, -14, -17, -20, -22, -25, -28, -30,
-34, -36, -38, -41, -44, -48, -51, -53, -57, -60, -66, -71, -75, -80, -83, -87,
-91, -95, -101, -105, -108, -111, -113, -115, -117, -119, -119, -119, -116,
-115, -112, -108, -106, -104, -101, -98, -94, -92, -88, -84, -83, -82, -80, -77,
-74, -71, -68, -64, -61, -57, -54, -51, -48, -46, -44, -41, -41, -42, -43, -42,
-43, -40, -38, -36, -33, -31, -28, -27, -30, -28, -28, -27, -26, -26, -23, -22,
-20, -19, -16, -16, -15, -13, -10, -7, -3, 0, 3, 4, 6, 5, 4, 1, -2, -5, -8, -12,
-15, -19, -21, -23, -26, -28, -30, -31, -32, -35, -37, -41, -44, -48, -50, -52,
-55, -56, -59, -61, -62, -64, -65, -68, -71, -73, -74, -76, -79, -79, -79, -78,
-80, -80, -82, -83, -85, -86, -84, -84, -85, -88, -92, -94, -98, -99, -103,
-105, -106, -108, -109, -109, -110, -109, -107, -107, -106, -105, -102, -101,
-99, -98, -95, -96, -97, -96, -97, -98, -97, -98, -97, -95, -93, -92, -90, -87,
-84, -80, -76, -71, -68, -64, -59, -56, -53, -51, -48, -45, -41, -39, -37, -34,
-31, -26, -24, -21, -17, -14, -13, -13, -12, -11, -12, -11, -11, -10, -8, -4,
-3, };