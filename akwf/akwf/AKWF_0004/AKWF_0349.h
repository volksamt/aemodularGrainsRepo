#define DATA_LENGTH 512
#define DATA AKWF_0349

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 12, 16, 20, 22, 26, 29, 32,
36, 38, 42, 46, 49, 54, 58, 62, 67, 72, 76, 80, 83, 86, 88, 89, 90, 90, 90, 89,
86, 84, 79, 75, 70, 64, 57, 50, 41, 34, 25, 14, 4, -7, -16, -27, -36, -45, -52,
-60, -65, -69, -73, -76, -77, -78, -77, -75, -74, -70, -67, -64, -58, -54, -49,
-44, -39, -34, -30, -26, -22, -19, -16, -12, -9, -8, -6, -4, -1, 0, 1, 2, 5, 7,
7, 8, 9, 9, 9, 9, 9, 7, 5, 4, 1, 0, -3, -5, -7, -10, -12, -16, -18, -20, -23,
-26, -28, -30, -32, -32, -34, -34, -33, -32, -29, -27, -24, -19, -14, -9, -4, 3,
7, 14, 19, 24, 29, 35, 40, 44, 48, 51, 54, 56, 58, 60, 61, 62, 62, 63, 62, 63,
63, 63, 63, 63, 63, 63, 62, 61, 60, 60, 58, 55, 53, 49, 45, 41, 36, 32, 27, 20,
14, 8, 0, -7, -15, -24, -32, -42, -51, -60, -69, -78, -86, -94, -101, -106,
-110, -114, -116, -118, -119, -119, -118, -116, -113, -110, -106, -102, -98,
-93, -88, -84, -78, -74, -69, -65, -60, -56, -52, -49, -45, -43, -39, -37, -33,
-32, -28, -26, -24, -23, -21, -20, -19, -18, -18, -18, -19, -19, -21, -23, -24,
-25, -28, -29, -32, -35, -37, -39, -41, -43, -46, -48, -49, -51, -53, -54, -53,
-54, -53, -52, -50, -45, -42, -38, -33, -27, -23, -18, -13, -6, -2, 3, 8, 11,
16, 20, 23, 26, 30, 32, 34, 36, 39, 40, 43, 43, 46, 47, 49, 51, 53, 56, 58, 60,
63, 64, 66, 69, 70, 70, 70, 70, 70, 69, 67, 65, 62, 59, 56, 51, 45, 41, 34, 29,
22, 15, 7, 0, -7, -14, -21, -27, -32, -35, -39, -41, -42, -43, -44, -42, -41,
-40, -38, -36, -33, -31, -28, -26, -23, -21, -19, -17, -15, -13, -11, -10, -9,
-7, -8, -7, -6, -5, -5, -5, -4, -4, -2, -1, -1, -1, 0, 1, 1, 1, 0, 1, 0, 0, 0,
-1, -1, -2, -2, -4, -4, -4, -5, -6, -7, -8, -10, -12, -13, -14, -14, -14, -14,
-14, -12, -10, -8, -6, -3, 1, 3, 7, 10, 13, 16, 19, 22, 25, 26, 28, 30, 31, 32,
33, 33, 34, 34, 34, 35, 34, 35, 34, 33, 34, 34, 34, 34, 35, 35, 35, 35, 34, 34,
33, 31, 29, 27, 24, 23, 19, 16, 11, 8, 4, -1, -4, -9, -15, -20, -25, -30, -36,
-40, -46, -50, -55, -58, -61, -65, -66, -67, -68, -68, -68, -68, -67, -65, -63,
-62, -60, -57, -55, -53, -51, -47, -45, -43, -41, -40, -37, -37, -36, -34, -33,
-34, -33, -33, -31, -31, -31, -30, -31, -30, -31, -30, -30, -30, -32, -33, -34,
-35, -36, -37, -39, -40, -42, -43, -45, -47, -49, -51, -53, -54, -56, -58, -60,
-61, -62, -63, -62, -62, -60, -58, -56, -53, -50, -45, -41, -36, -31, -27, -22,
-17, -12, -8, -3, };