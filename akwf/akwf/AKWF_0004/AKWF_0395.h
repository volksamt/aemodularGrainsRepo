#define DATA_LENGTH 512
#define DATA AKWF_0395

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 8, 10, 12, 13, 16, 17, 20,
22, 24, 26, 28, 30, 31, 34, 36, 37, 40, 42, 43, 45, 47, 48, 50, 52, 54, 55, 58,
59, 61, 63, 63, 65, 66, 68, 70, 71, 72, 74, 75, 76, 78, 79, 81, 82, 83, 85, 85,
87, 88, 89, 90, 91, 92, 94, 95, 96, 96, 96, 98, 99, 100, 101, 102, 102, 103,
104, 105, 106, 106, 107, 108, 109, 109, 109, 111, 111, 111, 112, 113, 114, 114,
114, 114, 115, 115, 115, 116, 116, 116, 116, 117, 117, 118, 118, 118, 119, 118,
119, 119, 119, 119, 118, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119, 118,
119, 118, 117, 118, 118, 119, 117, 118, 117, 118, 118, 117, 116, 116, 115, 116,
115, 115, 115, 115, 115, 115, 114, 114, 113, 114, 113, 113, 113, 112, 112, 112,
112, 111, 111, 110, 110, 110, 109, 110, 110, 109, 109, 108, 108, 108, 108, 108,
107, 107, 107, 107, 107, 106, 106, 106, 106, 106, 106, 105, 105, 104, 105, 105,
105, 105, 105, 104, 104, 104, 104, 104, 104, 103, 102, 102, 101, 101, 100, 100,
99, 98, 97, 97, 96, 95, 94, 93, 92, 92, 90, 89, 88, 86, 86, 85, 82, 82, 80, 79,
76, 76, 75, 73, 71, 69, 68, 66, 65, 63, 61, 60, 57, 56, 53, 52, 50, 48, 45, 43,
41, 39, 38, 35, 33, 30, 29, 26, 25, 22, 21, 19, 16, 14, 12, 9, 8, 5, 3, 1, -1,
-4, -6, -8, -10, -12, -14, -16, -18, -20, -23, -24, -26, -28, -31, -32, -34,
-36, -37, -40, -42, -44, -45, -46, -48, -51, -53, -55, -56, -58, -60, -60, -62,
-64, -65, -67, -68, -69, -71, -73, -74, -76, -77, -78, -80, -81, -82, -83, -84,
-86, -87, -87, -89, -90, -92, -92, -93, -94, -95, -96, -97, -99, -99, -100,
-101, -103, -102, -104, -104, -105, -106, -107, -107, -108, -109, -109, -110,
-110, -111, -111, -112, -113, -113, -114, -114, -115, -114, -114, -116, -117,
-116, -117, -117, -117, -117, -117, -118, -119, -119, -118, -119, -118, -118,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-118, -118, -118, -118, -118, -118, -118, -118, -117, -117, -116, -117, -116,
-116, -116, -116, -116, -116, -115, -115, -114, -114, -114, -113, -114, -113,
-113, -112, -113, -111, -112, -112, -112, -111, -112, -110, -111, -110, -110,
-110, -110, -110, -109, -109, -108, -109, -109, -107, -108, -107, -107, -107,
-107, -106, -106, -106, -106, -106, -106, -106, -106, -105, -105, -105, -105,
-105, -105, -104, -104, -104, -103, -103, -102, -102, -103, -102, -101, -100,
-100, -100, -99, -98, -98, -97, -96, -96, -94, -94, -93, -91, -91, -89, -89,
-87, -86, -84, -83, -81, -80, -78, -77, -75, -74, -73, -71, -69, -67, -66, -64,
-62, -61, -58, -57, -55, -53, -51, -49, -48, -45, -44, -41, -40, -38, -35, -34,
-31, -29, -27, -24, -22, -19, -18, -15, -14, -12, -9, -8, -5, -3, -1, };