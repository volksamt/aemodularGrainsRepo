#define DATA_LENGTH 512
#define DATA AKWF_0341

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 7, 10, 14, 17, 20, 23, 26, 30,
33, 35, 38, 41, 43, 45, 48, 49, 51, 52, 54, 56, 56, 58, 57, 58, 58, 58, 59, 58,
58, 57, 57, 55, 54, 52, 52, 50, 49, 47, 46, 45, 44, 42, 42, 40, 39, 38, 38, 37,
36, 36, 35, 35, 35, 35, 35, 36, 37, 37, 39, 39, 41, 42, 43, 44, 46, 47, 49, 50,
51, 52, 52, 52, 53, 53, 53, 52, 52, 52, 50, 49, 48, 47, 46, 44, 42, 42, 40, 38,
37, 35, 33, 32, 29, 27, 25, 22, 19, 17, 15, 11, 9, 6, 4, 0, -4, -6, -10, -13,
-17, -20, -24, -27, -31, -34, -37, -41, -44, -46, -48, -51, -52, -54, -55, -56,
-56, -56, -56, -56, -55, -54, -53, -50, -49, -47, -44, -42, -39, -36, -33, -30,
-27, -25, -21, -18, -14, -11, -8, -5, -2, 2, 5, 6, 10, 13, 15, 19, 21, 23, 24,
27, 28, 30, 31, 33, 34, 35, 36, 37, 38, 39, 38, 39, 39, 40, 40, 40, 40, 40, 39,
39, 38, 38, 37, 38, 37, 36, 36, 36, 35, 36, 35, 35, 34, 34, 33, 32, 30, 30, 28,
27, 25, 24, 22, 20, 18, 16, 14, 11, 10, 8, 6, 3, 2, 0, -2, -2, -4, -5, -6, -6,
-8, -9, -9, -10, -10, -11, -11, -12, -12, -12, -12, -12, -13, -13, -13, -13,
-13, -13, -13, -12, -13, -13, -12, -12, -11, -11, -10, -9, -7, -6, -5, -3, -1,
2, 5, 7, 10, 12, 16, 18, 21, 24, 27, 30, 32, 35, 37, 39, 42, 43, 45, 46, 47, 49,
49, 50, 51, 50, 51, 50, 49, 49, 49, 48, 47, 45, 44, 43, 41, 38, 37, 35, 33, 30,
28, 25, 24, 22, 20, 18, 16, 14, 12, 10, 8, 6, 5, 3, 2, 1, 0, -1, -2, -1, -1, -2,
-2, -3, -2, -2, -2, -2, -3, -2, -3, -3, -4, -5, -6, -7, -8, -10, -11, -13, -15,
-17, -18, -20, -23, -24, -26, -29, -31, -33, -35, -36, -39, -41, -43, -46, -49,
-50, -53, -56, -58, -62, -65, -67, -70, -73, -76, -79, -82, -86, -89, -92, -95,
-97, -101, -103, -106, -110, -111, -113, -115, -116, -119, -119, -119, -119,
-119, -118, -117, -115, -114, -111, -109, -107, -104, -102, -98, -95, -92, -87,
-83, -80, -77, -73, -68, -65, -60, -57, -53, -49, -44, -41, -37, -33, -29, -26,
-22, -19, -16, -13, -9, -6, -4, -2, 0, 3, 5, 6, 8, 10, 12, 12, 13, 15, 15, 17,
17, 17, 18, 19, 18, 19, 19, 19, 18, 18, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19,
18, 17, 16, 15, 14, 13, 11, 11, 8, 7, 4, 4, 2, -1, -2, -5, -6, -7, -9, -12, -12,
-13, -14, -15, -16, -17, -17, -17, -18, -19, -19, -19, -19, -20, -19, -20, -20,
-19, -20, -19, -20, -19, -19, -18, -18, -19, -18, -18, -18, -16, -16, -15, -14,
-12, -11, -10, -8, -6, -3, -1, };