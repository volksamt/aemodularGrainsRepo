#define DATA_LENGTH 512
#define DATA AKWF_0317

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, -9, -45, -74, -68, -38, -20, -9,
41, 91, 112, 119, 110, 87, 54, 20, -12, -40, -60, -73, -79, -77, -72, -62, -50,
-36, -19, -4, 10, 22, 31, 37, 39, 38, 35, 29, 21, 14, 7, 1, -5, -8, -10, -9,
-10, -7, -6, -4, -1, 1, 1, 3, 2, 2, 1, 0, 0, -1, -2, -3, -3, -2, -3, -2, -1, -2,
-1, -1, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, -1, -1, 1, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0,
0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 1, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 1, -1, -30, -64, -50, -19, 7, 36,
64, 78, 79, 68, 47, 21, -5, -29, -48, -59, -64, -61, -52, -39, -23, -8, 6, 18,
28, 32, 33, 31, 26, 20, 13, 6, 0, -6, -9, -11, -12, -12, -10, -7, -5, -3, 1, 2,
3, 4, 5, 5, 3, 2, 2, 1, -1, -2, -2, -2, -2, -2, -1, -1, -1, 0, 0, 0, 0, 1, 0, 1,
0, 1, 0, 0, 0, -1, 0, -1, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0,
0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, -1, -15, -47, -76, -75,
-51, -15, 16, 34, 42, 45, 36, 0, -22, -13, 14, 20, 21, 61, 97, 105, 101, 86, 57,
22, -13, -44, -69, -85, -91, -92, -87, -76, -63, -47, -29, -12, 5, 20, 32, 40,
47, 48, 46, 41, 34, 26, 18, 9, 2, -2, -7, -9, -10, -8, -7, -5, -3, -1, -1, 2, 2,
3, 2, 1, 0, -1, -2, -3, -3, -4, -4, -3, -3, -2, -2, -1, -1, 0, 0, 0, 0, 1, 1, 0,
0, 0, 0, 0, -1, -1, -1, -1, -1, -1, -1, -2, -1, -1, 0, 0, 0, 0, 0, 0, 0, -1, -1,
0, 0, 0, -1, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, -1,
0, 0, 0, -1, 0, 0, -1, -1, 0, 0, -3, -35, -67, -46, -15, 10, 39, 66, 79, 78, 65,
45, 18, -9, -31, -50, -60, -64, -59, -50, -37, -22, -6, 8, 19, 28, 31, 33, 31,
26, 20, 13, 5, -2, -6, -10, -12, -12, -12, -10, -7, -5, -2, 0, 3, 3, 4, 5, 5, 3,
2, 1, 1, -1, -1, -1, -2, -2, -1, -2, 0, -1, -1, 1, 1, 1, 0, 1, 0, 0, 0, 0, 0,
-1, 0, 0, -1, 0, -1, -1, -1, 0, 0, -1, 0, 0, 0, -1, 1, 0, 0, 0, 0, -1, 0, 0, 1,
0, 0, 0, 0, 0, 0, 1, -1, 0, 0, -1, 1, 0, 0, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, 0, };