#define DATA_LENGTH 512
#define DATA AKWF_0360

const PROGMEM int8_t DATA[DATA_LENGTH] = {-5, -27, -47, -64, -77, -89, -99,
-106, -112, -115, -118, -119, -119, -117, -116, -112, -110, -106, -101, -97,
-93, -88, -82, -77, -71, -66, -61, -56, -50, -46, -41, -38, -33, -30, -25, -22,
-19, -15, -13, -10, -8, -5, -3, -1, 1, 1, 3, 4, 6, 7, 7, 8, 9, 8, 9, 10, 10, 10,
10, 11, 10, 11, 11, 11, 10, 10, 9, 10, 10, 9, 10, 9, 9, 9, 8, 8, 7, 7, 8, 8, 7,
6, 7, 7, 7, 7, 7, 7, 6, 7, 6, 6, 7, 6, 5, 5, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6,
5, 6, 6, 6, 5, 6, 5, 5, 5, 6, 6, 6, 5, 6, 6, 6, 6, 6, 5, 6, 6, 6, 5, 5, 6, 6, 6,
6, 5, 6, 6, 6, 6, 5, 6, 6, 6, 6, 6, 6, 5, 6, 6, 6, 6, 6, 6, 6, 6, 5, 5, 6, 6, 6,
6, 6, 5, 6, 6, 6, 5, 6, 6, 6, 6, 7, 5, 5, 5, 6, 6, 6, 5, 5, 5, 6, 6, 6, 6, 6, 6,
5, 5, 6, 6, 6, 6, 5, 5, 6, 5, 5, 6, 5, 6, 6, 6, 6, 6, 5, 6, 6, 5, 6, 6, 6, 6, 5,
6, 6, 6, 5, 5, 5, 6, 5, 6, 5, 5, 5, 6, 6, 5, 6, 5, 6, 6, 7, 6, 5, 6, 6, 6, 6, 6,
6, 6, 7, 7, 7, 6, 5, 6, 6, 6, 6, 7, 6, 6, 6, 6, 6, 5, 5, 5, 6, 6, 6, 6, 5, 6, 6,
6, 6, 5, 6, 6, 6, 6, 6, 7, 6, 6, 5, 6, 5, 5, 6, 6, 6, 6, 6, 6, 6, 7, 5, 6, 6, 6,
6, 5, 6, 5, 6, 5, 6, 5, 6, 6, 6, 5, 6, 5, 6, 5, 6, 6, 5, 5, 5, 5, 6, 5, 6, 6, 6,
6, 6, 6, 6, 6, 6, 6, 5, 5, 5, 6, 6, 5, 6, 6, 6, 6, 6, 6, 5, 6, 6, 6, 6, 6, 5, 6,
6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 5, 6, 6, 5, 6, 5, 6, 5, 6, 5, 5, 6, 6, 5, 7,
6, 6, 6, 6, 6, 5, 5, 6, 6, 6, 6, 5, 5, 6, 5, 6, 7, 6, 6, 6, 6, 6, 6, 5, 6, 6, 6,
6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 6, 5, 6, 7, 5, 6, 5, 5, 6, 6, 7, 6, 7,
6, 6, 5, 6, 5, 6, 5, 6, 5, 6, 6, 6, 6, 5, 6, 6, 6, 6, 6, 6, 6, 6, 5, 6, 5, 6, 6,
6, 5, 6, 5, 6, 6, 5, 6, 6, 5, 5, 5, 5, 6, 6, 6, 6, 6, 6, 5, 6, 6, 6, 6, 5, 6, 6,
6, 6, 6, 6, 6, 6, 6, 5, 6, 6, 6, 5, 6, 6, 6, 6, 6, 6, 6, 6, 6, 5, 6, 5, 7, 6, };