#define DATA_LENGTH 512
#define DATA AKWF_0347

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 21, 21, 21, 21, 21, 21, 21, 21, 21,
21, 22, 21, 21, 21, 21, 22, 22, 21, 22, 22, 20, 21, 21, 21, 22, 21, 21, 22, 22,
21, 22, 21, 21, 21, 23, 39, 58, 68, 67, 66, 67, 67, 66, 67, 67, 67, 66, 67, 67,
67, 66, 66, 68, 67, 67, 67, 67, 67, 67, 67, 67, 66, 67, 67, 67, 67, 67, 67, 67,
67, 67, 67, 67, 67, 67, 67, 67, 67, 67, 66, 67, 67, 67, 66, 66, 67, 67, 67, 66,
66, 66, 67, 67, 66, 67, 67, 66, 66, 67, 67, 67, 67, 67, 66, 67, 66, 67, 67, 66,
80, 100, 113, 113, 113, 112, 112, 113, 112, 113, 111, 113, 112, 113, 113, 113,
112, 112, 112, 112, 112, 112, 112, 112, 112, 112, 112, 112, 112, 112, 112, 112,
111, 113, 112, 112, 112, 113, 112, 111, 112, 112, 112, 112, 112, 112, 112, 112,
112, 112, 112, 111, 112, 112, 112, 112, 112, 112, 112, 111, 112, 111, 112, 112,
112, 112, 112, 112, 111, 112, 111, 112, 111, 112, 112, 111, 112, 111, 111, 112,
112, 111, 112, 111, 112, 112, 112, 111, 111, 111, 111, 111, 111, 111, 111, 112,
111, 112, 111, 111, 111, 111, 111, 111, 111, 110, 111, 112, 111, 111, 111, 110,
111, 111, 111, 110, 112, 109, 91, 71, 64, 65, 64, 64, 64, 66, 64, 64, 65, 65,
65, 64, 65, 64, 65, 65, 65, 65, 65, 65, 64, 64, 64, 66, 64, 65, 64, 65, 64, 65,
64, 65, 64, 65, 64, 65, 64, 21, -40, -75, -72, -73, -73, -73, -73, -73, -73,
-73, -73, -75, -92, -111, -120, -118, -120, -119, -120, -119, -120, -119, -120,
-119, -119, -120, -119, -119, -119, -119, -118, -120, -118, -119, -119, -118,
-120, -120, -118, -119, -118, -120, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -119, -118, -119, -118, -119, -118, -119,
-118, -119, -119, -119, -118, -119, -118, -118, -118, -118, -119, -119, -118,
-118, -119, -118, -118, -118, -118, -118, -118, -119, -119, -118, -118, -118,
-118, -118, -118, -118, -118, -119, -118, -118, -118, -118, -119, -118, -118,
-118, -119, -118, -118, -118, -117, -118, -118, -118, -118, -118, -118, -118,
-118, -117, -118, -118, -117, -118, -118, -118, -118, -118, -118, -118, -117,
-117, -119, -113, -93, -75, -71, -72, -71, -72, -72, -72, -71, -72, -71, -72,
-72, -71, -72, -71, -71, -71, -72, -71, -72, -71, -71, -72, -72, -72, -71, -72,
-71, -72, -71, -70, -71, -71, -71, -71, -71, -71, -71, -71, -71, -71, -71, -71,
-71, -71, -71, -71, -71, -71, -72, -72, -71, -70, -71, -71, -71, -70, -71, -71,
-71, -71, -71, -70, -71, -71, -70, -71, -70, -72, -71, -71, -70, -71, -71, -72,
-62, -41, -26, -24, -25, -25, -25, -24, -25, -25, -25, -24, -25, -25, -25, -25,
-25, -25, -24, -25, -25, -26, -25, -24, -25, -25, -25, -25, -24, -25, -24, -25,
-24, -24, -25, -25, -24, -8, };