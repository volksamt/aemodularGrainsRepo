#define DATA_LENGTH 512
#define DATA AKWF_0392

const PROGMEM int8_t DATA[DATA_LENGTH] = {89, 108, 100, 106, 102, 107, 103, 107,
104, 107, 106, 108, 106, 108, 107, 108, 107, 109, 109, 109, 109, 109, 110, 111,
111, 110, 112, 111, 113, 112, 113, 113, 113, 113, 115, 114, 115, 115, 116, 116,
116, 117, 94, 87, 90, 88, 90, 89, 91, 90, 91, 91, 92, 91, 92, 93, 93, 93, 93,
93, 94, 95, 94, 95, 95, 95, 97, 96, 96, 97, 97, 98, 99, 98, 98, 99, 99, 100,
100, 101, 101, 102, 102, 102, 102, 102, 103, 103, 103, 104, 104, 104, 105, 105,
106, 107, 106, 106, 107, 107, 108, 109, 109, 110, 109, 110, 109, 110, 111, 111,
111, 112, 111, 111, 112, 113, 114, 113, 114, 114, 114, 114, 116, 115, 117, 115,
120, 101, 86, 90, 87, 90, 89, 90, 90, 90, 91, 91, 91, 93, 92, 92, 93, 93, 93,
94, 94, 95, 95, 95, 95, 96, 96, 97, 98, 97, 98, 98, 98, 99, 99, 100, 100, 100,
101, 101, 101, 101, 102, 102, 103, 103, 103, 104, 104, 105, 105, 104, 105, 106,
106, 106, 107, 107, 107, 108, 109, 108, 109, 109, 109, 110, 110, 111, 110, 111,
111, 111, 112, 113, 113, 113, 113, 114, 114, 115, 115, 115, 114, 116, 115, 119,
110, 86, 90, 88, 89, 89, 90, 90, 90, 91, 91, 92, 92, 93, 92, 94, 92, 94, 93, 95,
94, 95, 95, 95, 96, 96, 96, 97, 97, 97, 98, 98, 99, 99, 100, 99, 100, 99, 102,
99, 104, 98, 108, 7, -106, -100, -103, -100, -102, -99, -100, -99, -99, -99,
-99, -98, -97, -98, -97, -96, -97, -96, -96, -96, -95, -95, -94, -95, -94, -94,
-93, -94, -92, -93, -92, -93, -91, -91, -89, -90, -89, -91, -89, -89, -88, -89,
-113, -117, -116, -116, -115, -115, -114, -114, -113, -114, -113, -113, -112,
-112, -112, -111, -111, -111, -111, -110, -110, -110, -109, -109, -108, -108,
-108, -107, -108, -107, -106, -106, -106, -105, -105, -104, -105, -104, -104,
-104, -104, -103, -102, -103, -102, -102, -101, -101, -100, -100, -100, -99,
-99, -98, -99, -98, -98, -97, -97, -97, -97, -97, -96, -95, -96, -95, -94, -93,
-95, -93, -93, -92, -92, -91, -92, -92, -91, -90, -91, -90, -90, -90, -88, -90,
-86, -106, -120, -115, -117, -115, -116, -114, -115, -114, -115, -114, -114,
-113, -113, -112, -112, -111, -112, -111, -110, -111, -109, -110, -109, -109,
-109, -107, -108, -107, -107, -107, -106, -107, -106, -106, -104, -105, -105,
-104, -103, -103, -103, -102, -102, -102, -101, -102, -101, -100, -99, -101,
-100, -98, -99, -99, -98, -98, -97, -97, -97, -97, -97, -96, -95, -96, -94, -94,
-94, -94, -93, -93, -93, -92, -92, -91, -92, -91, -91, -90, -90, -89, -90, -89,
-90, -86, -98, -118, -116, -117, -116, -115, -115, -115, -114, -114, -114, -112,
-114, -113, -113, -112, -113, -112, -111, -111, -111, -110, -109, -109, -108,
-109, -108, -108, -107, -108, -106, -108, -105, -107, -104, -108, -103, -107,
-103, -105, -101, -105, -99, -4, };