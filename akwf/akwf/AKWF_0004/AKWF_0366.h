#define DATA_LENGTH 512
#define DATA AKWF_0366

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 16, 22, 27, 32, 38, 44, 49, 55,
60, 66, 71, 76, 81, 85, 90, 94, 97, 101, 104, 106, 109, 111, 113, 114, 115, 116,
118, 118, 119, 119, 119, 119, 119, 119, 118, 118, 116, 116, 115, 114, 114, 112,
111, 109, 109, 107, 105, 103, 101, 98, 95, 93, 90, 86, 82, 80, 75, 70, 68, 64,
59, 55, 52, 48, 45, 41, 39, 35, 32, 29, 27, 24, 21, 19, 15, 13, 12, 10, 7, 6, 3,
2, 1, -1, -3, -4, -4, -5, -6, -6, -6, -7, -7, -7, -5, -5, -6, -4, -3, -1, -1, 0,
2, 3, 5, 7, 8, 8, 10, 12, 13, 15, 17, 17, 19, 20, 22, 24, 25, 27, 28, 29, 32,
31, 34, 35, 35, 37, 38, 38, 39, 39, 39, 40, 40, 40, 40, 39, 39, 39, 38, 37, 36,
35, 34, 33, 32, 30, 28, 27, 25, 24, 22, 20, 19, 18, 16, 15, 13, 12, 11, 9, 7, 7,
4, 3, 2, 0, -1, -2, -2, -4, -5, -6, -6, -7, -9, -9, -10, -10, -11, -11, -11,
-11, -12, -11, -12, -11, -10, -11, -10, -9, -10, -8, -8, -8, -7, -6, -5, -3, -3,
-1, 0, 2, 2, 2, 4, 5, 6, 7, 9, 9, 10, 11, 12, 13, 13, 13, 14, 14, 15, 15, 15,
15, 16, 16, 15, 17, 16, 17, 15, 17, 16, 15, 15, 14, 14, 14, 13, 13, 13, 12, 12,
10, 10, 10, 9, 8, 7, 6, 5, 3, 2, 0, 0, -2, -4, -4, -6, -7, -7, -9, -10, -11,
-12, -12, -13, -13, -14, -15, -15, -15, -15, -15, -15, -16, -16, -16, -17, -16,
-16, -16, -16, -15, -15, -14, -14, -14, -13, -14, -12, -12, -11, -11, -11, -10,
-9, -8, -8, -6, -5, -4, -3, -2, -1, 0, 1, 3, 3, 4, 5, 7, 7, 9, 9, 10, 10, 10,
11, 11, 11, 11, 11, 11, 11, 11, 10, 10, 10, 10, 9, 7, 8, 7, 6, 5, 3, 2, 0, -1,
-2, -3, -4, -5, -7, -8, -9, -11, -12, -14, -15, -17, -18, -20, -20, -23, -24,
-26, -27, -29, -31, -31, -33, -34, -35, -35, -37, -37, -39, -39, -39, -39, -41,
-40, -39, -40, -39, -38, -38, -37, -37, -35, -35, -34, -32, -31, -29, -28, -26,
-25, -23, -21, -20, -18, -17, -15, -14, -13, -12, -10, -8, -7, -6, -4, -3, -2,
0, 0, 1, 2, 3, 4, 5, 6, 6, 7, 6, 6, 6, 5, 4, 4, 3, 2, 1, -1, -3, -4, -7, -8, -9,
-14, -15, -18, -21, -24, -26, -29, -31, -34, -38, -41, -44, -46, -50, -53, -57,
-60, -63, -68, -72, -75, -80, -83, -87, -90, -93, -96, -100, -102, -104, -107,
-109, -110, -112, -114, -115, -115, -117, -117, -117, -118, -118, -118, -118,
-118, -118, -118, -117, -116, -116, -115, -114, -113, -110, -109, -108, -106,
-104, -101, -98, -95, -92, -87, -83, -79, -73, -68, -64, -58, -53, -47, -42,
-37, -30, -25, -18, -12, -7, -1, };