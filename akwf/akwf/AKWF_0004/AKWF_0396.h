#define DATA_LENGTH 512
#define DATA AKWF_0396

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 7, 9, 10, 13, 15, 17, 19, 21,
22, 26, 27, 30, 31, 34, 34, 36, 38, 41, 42, 44, 46, 47, 49, 51, 53, 55, 56, 58,
60, 61, 64, 64, 65, 68, 68, 70, 72, 74, 75, 76, 78, 79, 80, 82, 82, 83, 85, 86,
88, 89, 90, 91, 93, 93, 94, 95, 96, 96, 98, 99, 100, 101, 101, 103, 104, 104,
105, 106, 106, 107, 108, 109, 109, 110, 111, 111, 112, 112, 113, 112, 113, 114,
114, 115, 116, 116, 116, 116, 117, 117, 117, 117, 117, 119, 118, 118, 118, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 118, 119, 118, 118, 118, 119, 118, 118, 118, 117, 117, 117, 117, 117, 117,
118, 117, 117, 117, 117, 116, 116, 117, 115, 117, 116, 116, 116, 116, 115, 117,
116, 116, 115, 115, 115, 116, 115, 116, 115, 115, 115, 114, 114, 113, 114, 114,
113, 113, 112, 111, 110, 111, 110, 109, 109, 109, 108, 108, 107, 107, 107, 105,
105, 104, 104, 102, 103, 101, 100, 100, 100, 98, 97, 96, 95, 94, 94, 92, 92, 91,
90, 89, 88, 87, 86, 84, 83, 82, 82, 79, 79, 77, 76, 75, 75, 72, 72, 70, 69, 68,
66, 65, 63, 61, 60, 59, 57, 56, 55, 52, 51, 49, 48, 46, 45, 42, 41, 39, 37, 35,
33, 31, 30, 27, 26, 23, 22, 20, 18, 15, 13, 11, 10, 7, 5, 4, 1, -1, -2, -5, -7,
-9, -12, -13, -15, -17, -19, -20, -23, -25, -28, -28, -31, -33, -36, -37, -38,
-40, -42, -43, -45, -47, -49, -51, -53, -54, -57, -59, -59, -61, -63, -64, -66,
-68, -69, -70, -71, -73, -75, -76, -77, -79, -80, -82, -82, -84, -86, -86, -87,
-88, -90, -91, -92, -93, -94, -95, -97, -98, -98, -99, -100, -101, -102, -103,
-103, -105, -105, -106, -106, -107, -108, -108, -109, -110, -110, -111, -111,
-112, -112, -113, -114, -114, -115, -115, -115, -116, -116, -117, -117, -117,
-117, -118, -117, -117, -118, -118, -119, -119, -119, -119, -118, -119, -119,
-119, -118, -119, -119, -120, -119, -119, -119, -119, -118, -118, -119, -118,
-118, -119, -118, -118, -118, -117, -118, -117, -117, -117, -117, -117, -117,
-118, -117, -117, -117, -117, -117, -116, -116, -116, -117, -117, -116, -116,
-115, -116, -116, -116, -116, -116, -115, -116, -116, -116, -115, -115, -114,
-114, -114, -113, -114, -114, -113, -113, -112, -112, -113, -111, -111, -111,
-111, -110, -109, -110, -108, -108, -107, -107, -107, -105, -105, -104, -104,
-103, -101, -102, -100, -100, -99, -97, -97, -96, -96, -95, -93, -92, -92, -91,
-89, -88, -87, -87, -84, -84, -84, -82, -81, -80, -79, -77, -76, -75, -73, -73,
-72, -70, -69, -68, -66, -64, -63, -61, -60, -59, -56, -56, -54, -52, -50, -50,
-47, -46, -44, -43, -41, -39, -36, -35, -33, -32, -29, -28, -25, -23, -22, -20,
-18, -15, -14, -11, -10, -7, -6, -3, -1, };