#define DATA_LENGTH 512
#define DATA AKWF_0385

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 2, 4, 7, 9, 12, 15, 17, 19,
20, 20, 20, 20, 20, 20, 19, 18, 19, 17, 17, 17, 16, 16, 16, 15, 14, 14, 14, 14,
12, 13, 16, 26, 39, 53, 62, 65, 60, 53, 46, 41, 38, 36, 35, 34, 33, 31, 31, 30,
29, 29, 28, 26, 25, 25, 23, 21, 19, 16, 14, 12, 11, 10, 9, 7, 6, 4, 1, -10, -29,
-53, -75, -90, -100, -105, -107, -108, -111, -114, -117, -119, -118, -118, -115,
-113, -112, -111, -110, -107, -104, -100, -96, -94, -88, -84, -80, -77, -73,
-70, -69, -70, -76, -79, -82, -83, -78, -67, -49, -31, -17, -6, 1, 5, 7, 9, 11,
13, 15, 17, 17, 19, 20, 22, 23, 25, 26, 26, 27, 28, 28, 28, 29, 29, 28, 28, 27,
26, 22, 17, 14, 13, 13, 14, 15, 17, 16, 17, 17, 17, 17, 17, 17, 17, 17, 17, 17,
16, 17, 17, 17, 17, 17, 17, 17, 16, 16, 16, 16, 15, 15, 15, 15, 16, 15, 14, 14,
14, 13, 13, 13, 12, 12, 11, 11, 10, 11, 10, 10, 9, 10, 8, 8, 8, 8, 8, 6, 7, 6,
6, 6, 5, 5, 4, 5, 4, 3, 4, 4, 3, 4, 2, 3, 3, 3, 2, 3, 3, 2, 3, 3, 2, 2, 2, 2, 2,
2, 2, 2, 2, 1, 1, 2, 1, 0, 1, 0, 0, 0, -1, -1, -1, -1, -2, -3, -3, -2, -3, -4,
-4, -4, -4, -4, -5, -4, -5, -5, -6, -5, -6, -6, -7, -7, -7, -7, -7, -8, -7, -5,
-4, -3, -2, -1, 0, 1, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, -1, -1, -2, -2, -2,
-3, -3, -2, -3, -2, -3, -3, -3, -3, -3, -4, -4, -5, -4, -4, -5, -4, -2, 1, 4, 7,
10, 11, 13, 13, 14, 14, 13, 12, 12, 12, 11, 10, 14, 21, 26, 30, 29, 26, 21, 16,
12, 9, 10, 8, 10, 10, 11, 11, 10, 10, 11, 11, 11, 9, 7, 2, -1, -5, -7, -7, -5,
-3, -1, 1, 2, 4, 1, -1, -3, -5, -6, -6, -4, -2, 1, 4, 6, 9, 13, 14, 15, 16, 15,
12, 10, 8, 7, 8, 6, 7, 7, 8, 9, 11, 14, 16, 17, 18, 18, 18, 18, 16, 14, 14, 12,
12, 12, 14, 17, 18, 21, 21, 21, 19, 16, 15, 11, 9, 8, 8, 7, 6, 7, 8, 9, 12, 12,
14, 14, 13, 12, 11, 9, 5, 3, 1, 0, -1, 1, 3, 4, 7, 8, 8, 8, 8, 7, 6, 6, 5, 6, 5,
5, 4, 4, 4, 3, 3, 2, 2, 2, 1, 1, 0, 0, -1, -1, -1, -1, -1, -2, -2, -2, -2, -4,
-5, -10, -13, -16, -17, -18, -18, -17, -18, -17, -17, -16, -16, -15, -16, -14,
-14, -14, -13, -13, -12, -11, -11, -10, -10, -8, -9, -7, -7, -7, -6, -6, -5, -4,
-3, -3, -3, -3, -2, -2, -1, 0, 1, };