#define DATA_LENGTH 512
#define DATA AKWF_0314

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 5, 4, 10, 6, 15, 7, 23, -34,
-73, -17, 8, 41, 57, 73, 76, 78, 73, 66, 55, 43, 32, 19, 9, -1, -7, -12, -15,
-17, -14, -12, -7, -4, 3, 8, 14, 18, 24, 26, 29, 31, 31, 31, 31, 30, 26, 24, 21,
18, 15, 12, 9, 5, 3, 1, -1, -2, -4, -4, -5, -5, -6, -6, -5, -4, -4, -5, -3, -4,
-3, -3, -3, -3, -4, -3, -4, -4, -5, -5, -5, -6, -7, -7, -7, -8, -8, -7, -8, -9,
-8, -8, -8, -8, -7, -7, -8, -7, -7, -7, -6, -7, -6, -5, -6, -5, -6, -4, -5, -4,
-4, -4, -4, -3, -4, -1, -3, -2, -3, -2, -2, -1, -2, -1, -1, -1, -1, -1, 0, -1,
2, -2, 4, -4, 6, -7, 15, -58, -76, -59, -113, -50, -21, 16, 34, 51, 59, 62, 63,
59, 55, 47, 42, 33, 28, 22, 21, 15, 15, 12, 13, 11, 13, 11, 12, 11, 11, 10, 8,
4, 2, -2, -6, -11, -15, -18, -23, -25, -29, -32, -34, -35, -36, -35, -35, -33,
-31, -29, -26, -22, -19, -16, -13, -9, -4, -1, 3, 5, 7, 10, 12, 13, 15, 17, 17,
19, 18, 18, 18, 18, 18, 16, 16, 14, 13, 13, 11, 10, 8, 7, 7, 6, 5, 3, 2, 0, 0,
0, -2, -2, -4, -5, -5, -6, -6, -6, -7, -6, -7, -7, -7, -6, -7, -6, -6, -6, -5,
-4, -5, -4, -5, -2, -4, -2, -2, -1, -1, -1, 0, -1, 2, -1, 4, -4, 11, -57, -83,
-28, -5, 27, 40, 55, 58, 59, 53, 45, 33, 21, 9, -3, -13, -23, -29, -34, -36,
-37, -35, -32, -28, -23, -16, -10, -4, 1, 6, 10, 13, 15, 18, 18, 17, 17, 14, 14,
11, 8, 6, 4, 0, -1, -4, -5, -5, -6, -6, -6, -6, -6, -5, -4, -4, -3, -2, -1, -1,
0, 0, 1, 2, 2, 2, 2, 2, 1, 3, 1, 2, 1, 1, 0, 1, 0, 0, 0, -1, 0, 0, -1, -1, -1,
-1, -1, 1, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 1, -1, 1, -1, 1, -1, 1,
0, 1, 0, 0, -1, 0, 0, 0, 0, -2, 1, -1, 2, -3, 4, -5, 6, -8, 14, -71, -70, -70,
-111, -45, -21, 21, -85, -79, -48, -40, -22, -20, -9, -10, -1, -2, 7, 7, 16, 17,
27, 29, 39, 42, 51, 55, 60, 62, 66, 67, 66, 67, 64, 63, 59, 56, 51, 48, 42, 39,
33, 29, 25, 22, 19, 17, 14, 14, 12, 11, 10, 11, 10, 10, 10, 11, 10, 10, 10, 9,
9, 8, 6, 5, 4, 2, -1, -3, -6, -8, -11, -12, -16, -18, -21, -23, -26, -28, -30,
-32, -34, -36, -37, -39, -40, -42, -42, -43, -44, -43, -44, -44, -44, -43, -43,
-41, -41, -41, -39, -37, -36, -35, -32, -31, -29, -27, -25, -23, -21, -18, -16,
-15, -12, -10, -8, -6, -4, -2, };