#define DATA_LENGTH 512
#define DATA AKWF_0373

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 7, 10, 12, 15, 18, 21, 22, 23,
25, 27, 32, 38, 44, 51, 55, 61, 66, 71, 74, 78, 80, 81, 83, 86, 89, 93, 93, 93,
94, 96, 97, 99, 100, 101, 102, 104, 105, 106, 106, 107, 107, 107, 107, 108, 109,
109, 111, 113, 113, 114, 115, 116, 117, 116, 116, 118, 118, 119, 118, 119, 117,
117, 118, 117, 117, 116, 114, 116, 117, 116, 114, 114, 114, 113, 111, 111, 110,
111, 111, 110, 107, 105, 105, 102, 102, 101, 101, 101, 102, 104, 105, 105, 102,
99, 97, 94, 90, 85, 82, 81, 79, 79, 77, 76, 76, 76, 76, 76, 73, 72, 71, 69, 66,
63, 59, 56, 52, 49, 46, 44, 44, 44, 42, 40, 38, 35, 32, 29, 27, 24, 21, 18, 13,
8, 6, 4, 1, -1, -4, -6, -9, -11, -14, -17, -19, -20, -24, -26, -28, -31, -34,
-37, -39, -42, -46, -50, -55, -59, -63, -66, -70, -74, -79, -84, -86, -90, -93,
-95, -99, -101, -102, -104, -104, -105, -104, -103, -102, -102, -101, -101,
-101, -100, -99, -98, -97, -98, -98, -99, -99, -98, -98, -98, -97, -96, -95,
-95, -93, -94, -93, -93, -94, -96, -98, -100, -101, -101, -100, -99, -97, -96,
-93, -92, -94, -94, -93, -94, -92, -92, -90, -89, -88, -86, -84, -82, -82, -79,
-77, -73, -69, -65, -61, -58, -55, -53, -53, -52, -53, -55, -55, -56, -58, -60,
-60, -61, -59, -59, -59, -58, -56, -56, -56, -55, -57, -58, -58, -58, -58, -58,
-58, -58, -58, -57, -56, -57, -58, -59, -58, -59, -60, -60, -59, -59, -58, -58,
-57, -58, -59, -60, -61, -59, -58, -60, -62, -66, -68, -71, -72, -75, -77, -79,
-80, -80, -81, -81, -79, -78, -78, -77, -75, -73, -72, -69, -68, -66, -67, -67,
-67, -67, -66, -68, -66, -65, -62, -61, -60, -57, -55, -52, -49, -44, -40, -35,
-32, -29, -25, -22, -19, -17, -13, -10, -8, -5, -3, 3, 8, 10, 14, 18, 20, 22,
23, 24, 25, 25, 25, 27, 30, 32, 35, 37, 41, 43, 45, 47, 48, 51, 52, 55, 56, 57,
56, 57, 56, 57, 57, 59, 60, 60, 59, 57, 55, 55, 56, 56, 58, 58, 58, 57, 56, 56,
55, 54, 54, 56, 57, 58, 61, 61, 62, 61, 62, 62, 63, 63, 64, 64, 64, 65, 66, 67,
66, 65, 61, 59, 58, 56, 52, 50, 47, 43, 39, 36, 33, 30, 29, 27, 27, 26, 26, 26,
26, 27, 29, 29, 29, 31, 30, 28, 26, 23, 22, 22, 21, 20, 17, 15, 13, 13, 13, 11,
9, 6, 4, 1, -2, -7, -9, -14, -15, -17, -21, -23, -25, -28, -31, -34, -37, -40,
-42, -43, -44, -44, -44, -46, -48, -48, -48, -50, -51, -52, -50, -51, -52, -53,
-53, -53, -53, -52, -53, -55, -56, -56, -57, -56, -56, -54, -54, -53, -50, -48,
-47, -46, -44, -43, -39, -37, -32, -29, -26, -25, -22, -21, -20, -17, -16, -13,
-11, -7, -4, -1, };