#define DATA_LENGTH 512
#define DATA AKWF_0394

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 6, 7, 9, 11, 12, 14, 16, 17,
19, 20, 22, 24, 25, 27, 29, 29, 31, 32, 34, 35, 36, 39, 40, 41, 43, 44, 45, 46,
48, 49, 50, 51, 53, 54, 56, 58, 59, 60, 61, 62, 63, 65, 66, 67, 68, 69, 71, 73,
74, 74, 75, 77, 78, 79, 80, 81, 82, 84, 85, 85, 86, 88, 89, 89, 90, 91, 92, 93,
95, 96, 96, 97, 98, 99, 99, 101, 101, 102, 103, 104, 104, 105, 105, 106, 107,
108, 108, 109, 110, 111, 111, 111, 111, 112, 113, 114, 113, 114, 114, 115, 115,
116, 116, 117, 116, 117, 117, 118, 117, 118, 118, 118, 119, 119, 119, 119, 119,
120, 120, 119, 119, 119, 119, 118, 119, 119, 119, 118, 119, 118, 117, 118, 118,
118, 117, 117, 117, 117, 116, 116, 116, 115, 115, 115, 114, 113, 114, 113, 112,
111, 111, 112, 111, 111, 111, 109, 109, 110, 108, 108, 107, 107, 107, 106, 105,
104, 104, 104, 103, 102, 101, 101, 101, 100, 100, 99, 98, 97, 96, 96, 95, 94,
94, 93, 92, 91, 90, 89, 88, 87, 87, 86, 85, 84, 83, 82, 81, 80, 79, 78, 77, 75,
74, 73, 72, 71, 69, 69, 67, 65, 64, 63, 62, 61, 60, 59, 57, 56, 54, 53, 51, 50,
48, 47, 45, 44, 42, 40, 40, 37, 36, 34, 32, 31, 30, 28, 26, 25, 22, 21, 20, 18,
16, 15, 13, 11, 10, 8, 7, 5, 4, 3, 0, -1, -3, -5, -6, -8, -9, -10, -13, -14,
-15, -17, -18, -21, -22, -24, -25, -26, -28, -30, -31, -32, -34, -35, -37, -38,
-40, -41, -42, -44, -45, -48, -48, -50, -51, -52, -53, -55, -56, -57, -59, -60,
-61, -63, -63, -65, -66, -68, -68, -70, -71, -71, -73, -75, -76, -77, -78, -78,
-80, -82, -82, -83, -85, -85, -85, -87, -89, -89, -91, -91, -92, -93, -94, -95,
-96, -96, -98, -98, -100, -100, -102, -102, -103, -103, -104, -105, -106, -106,
-108, -107, -108, -109, -109, -110, -112, -111, -112, -112, -113, -113, -113,
-114, -115, -115, -116, -116, -116, -116, -117, -117, -117, -117, -118, -118,
-118, -118, -118, -119, -118, -119, -118, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -118, -118, -118, -117, -118, -118, -118, -118, -117, -116,
-116, -116, -116, -115, -115, -116, -115, -115, -114, -114, -113, -113, -113,
-113, -111, -112, -111, -111, -110, -110, -109, -109, -108, -108, -107, -107,
-107, -106, -105, -105, -105, -104, -103, -102, -102, -101, -101, -100, -99,
-98, -98, -97, -97, -96, -96, -94, -93, -93, -91, -91, -90, -90, -88, -88, -86,
-86, -85, -84, -83, -82, -81, -79, -79, -78, -77, -75, -74, -73, -72, -71, -70,
-68, -67, -66, -66, -63, -62, -62, -60, -58, -56, -56, -53, -52, -51, -50, -49,
-47, -44, -43, -42, -40, -40, -37, -36, -34, -32, -31, -30, -28, -26, -24, -23,
-21, -19, -18, -16, -14, -13, -12, -9, -7, -7, -5, -4, -1, 0, };