#define DATA_LENGTH 512
#define DATA AKWF_0313

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 20, 31, 42, 53, 62, 71, 80, 88, 94,
101, 107, 110, 114, 117, 119, 119, 119, 117, 115, 113, 109, 104, 99, 93, 86, 79,
72, 64, 55, 47, 40, 31, 24, 14, 7, -1, -9, -16, -22, -29, -36, -40, -45, -50,
-52, -57, -59, -62, -63, -64, -64, -64, -63, -62, -61, -57, -56, -53, -51, -46,
-42, -39, -35, -30, -27, -23, -18, -14, -9, -6, -2, 2, 6, 10, 12, 16, 18, 20,
22, 25, 27, 27, 29, 29, 29, 30, 30, 30, 29, 29, 27, 27, 26, 24, 22, 22, 20, 17,
15, 14, 12, 10, 8, 7, 5, 3, 1, -1, -2, -3, -5, -6, -7, -9, -10, -9, -10, -11,
-11, -11, -12, -12, -11, -11, -11, -10, -10, -10, -8, -9, -8, -8, -6, -5, -4,
-3, -3, -2, -1, 0, 1, 0, 2, 3, 4, 4, 5, 6, 5, 6, 7, 6, 7, 8, 8, 7, 8, 8, 8, 7,
8, 8, 7, 7, 6, 6, 6, 6, 5, 5, 4, 4, 3, 3, 3, 3, 2, 2, 2, 1, 2, 2, 0, 2, 0, 1, 1,
0, 0, 1, 0, 1, 1, 0, -1, 0, 0, 0, 1, 0, 0, 1, 1, 1, 2, 2, 2, 1, 2, 2, 2, 2, 2,
1, 2, 2, 2, 2, 2, 1, 2, 2, 3, 2, 2, 1, 2, 2, 1, 1, 1, 1, 2, 0, 0, 0, 0, 0, 0, 0,
-1, 0, -1, -1, -1, -1, -1, -2, -2, -2, -2, -3, -3, -2, -2, -2, -3, -2, -3, -4,
-3, -4, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -4, -3, -3, -3, -3, -3, -3, -3,
-4, -3, -3, -2, -3, -2, -2, -2, -3, -3, -2, -2, -3, -3, -2, -2, -1, -3, -2, -2,
-2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -1, -1, -2, -2, -2, -1, -2,
-2, -2, -2, -2, -1, -1, -2, -2, -1, -1, -2, 0, -1, -1, -1, -1, -1, -1, -1, -1,
-1, -1, -1, -2, -2, -1, -1, -1, -1, 0, -2, -1, -1, 0, -1, -1, -2, -1, -2, 0, -1,
-1, -1, -1, -1, -1, -1, -1, 0, -1, -1, -1, -1, -1, -1, 0, -1, -1, 0, -1, -1, 0,
-1, -1, -1, 0, -1, -1, 0, -1, -1, -1, 0, 0, -1, 0, -1, -1, 0, -1, -1, -1, 0, -1,
-1, -1, -1, 0, 0, -1, -1, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0,
-1, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, -1, -1, -1, 0, 0, -1, -1, 0, 0, 0, 0, 0,
1, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, -1, 0, 0, -1,
0, -1, 0, -1, -5, -10, -17, -24, -32, -40, -48, -56, -64, -71, -78, -84, -89,
-92, -94, -96, -95, -94, -91, -88, -82, -76, -69, -61, -52, -43, -32, -22, -11,
-1, };