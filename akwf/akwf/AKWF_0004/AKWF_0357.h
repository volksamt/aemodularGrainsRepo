#define DATA_LENGTH 512
#define DATA AKWF_0357

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 3, 3, 4, 5, 5, 6, 6, 7, 8, 9,
8, 10, 10, 11, 12, 12, 12, 13, 12, 14, 14, 15, 15, 15, 16, 17, 17, 17, 18, 19,
21, 27, 40, 56, 71, 82, 92, 100, 105, 109, 113, 115, 116, 117, 118, 119, 119,
119, 118, 118, 117, 118, 117, 115, 115, 114, 113, 112, 111, 110, 109, 109, 108,
107, 105, 105, 103, 102, 102, 101, 100, 99, 98, 97, 96, 95, 95, 93, 92, 91, 90,
89, 89, 87, 86, 85, 85, 83, 83, 82, 80, 80, 79, 79, 77, 76, 75, 75, 74, 72, 71,
71, 70, 68, 68, 67, 66, 65, 64, 63, 62, 62, 61, 60, 60, 58, 58, 56, 55, 55, 54,
53, 52, 51, 50, 50, 48, 48, 47, 47, 46, 44, 44, 43, 42, 42, 41, 41, 39, 38, 37,
38, 37, 35, 34, 34, 33, 32, 32, 31, 31, 30, 29, 29, 27, 27, 26, 25, 23, 16, 4,
-12, -26, -38, -47, -55, -61, -65, -69, -71, -74, -75, -76, -77, -76, -77, -77,
-77, -77, -76, -76, -75, -74, -74, -73, -73, -73, -71, -71, -70, -70, -69, -67,
-67, -66, -66, -66, -64, -63, -64, -62, -62, -61, -60, -60, -59, -59, -58, -57,
-56, -55, -56, -54, -54, -52, -52, -51, -51, -51, -50, -50, -49, -48, -48, -46,
-46, -46, -45, -44, -43, -43, -42, -42, -41, -41, -40, -39, -39, -39, -37, -37,
-36, -36, -36, -35, -34, -33, -33, -32, -31, -32, -32, -30, -29, -29, -29, -28,
-27, -27, -26, -26, -25, -25, -24, -24, -24, -22, -22, -22, -21, -20, -20, -20,
-19, -19, -19, -18, -18, -17, -17, -16, -16, -15, -16, -15, -14, -17, -26, -31,
-33, -32, -32, -32, -31, -30, -29, -28, -27, -27, -27, -25, -24, -24, -24, -23,
-23, -22, -21, -21, -20, -20, -19, -18, -18, -17, -17, -17, -17, -15, -15, -14,
-13, -13, -13, -12, -11, -12, -11, -11, -10, -9, -8, -8, -7, -8, -8, -6, -6, -5,
-5, -4, -4, -4, -3, -3, -2, -3, -3, -2, -2, -1, 0, 0, 0, 1, 1, 1, 2, 3, 2, 3, 3,
3, 4, 4, 4, 5, 5, 5, 5, 6, 6, 6, 7, 7, 8, 8, 8, 8, 9, 9, 10, 9, 10, 10, 10, 10,
10, 10, 11, 11, 11, 11, 12, 12, 13, 13, 12, 13, 14, 13, 13, 14, 14, 14, 14, 14,
14, 14, 14, 15, 16, 15, 15, 13, 6, -7, -22, -35, -46, -55, -61, -65, -69, -72,
-73, -75, -75, -76, -75, -75, -75, -73, -74, -72, -72, -70, -68, -68, -67, -65,
-64, -63, -62, -61, -60, -59, -57, -56, -55, -55, -52, -52, -50, -49, -49, -47,
-46, -44, -44, -42, -42, -40, -39, -39, -37, -36, -36, -35, -34, -33, -31, -31,
-29, -29, -27, -26, -25, -25, -24, -23, -22, -21, -20, -19, -18, -17, -16, -15,
-15, -14, -13, -12, -11, -10, -10, -9, -8, -7, -7, -5, -5, -4, -4, -3, -2, -1,
-1, 0, };