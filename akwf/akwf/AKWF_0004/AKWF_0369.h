#define DATA_LENGTH 512
#define DATA AKWF_0369

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 36, 60, 82, 98, 108, 114, 118,
119, 119, 119, 118, 115, 109, 100, 84, 65, 43, 20, -3, -26, -47, -65, -78, -89,
-96, -100, -102, -102, -101, -98, -92, -86, -76, -65, -53, -40, -27, -15, -4, 6,
14, 22, 29, 35, 38, 41, 41, 42, 41, 40, 37, 35, 31, 28, 25, 21, 18, 14, 12, 9,
6, 3, 1, -1, -4, -6, -8, -11, -13, -16, -19, -21, -24, -26, -28, -30, -31, -32,
-32, -32, -32, -30, -27, -24, -21, -16, -12, -7, -1, 4, 10, 15, 22, 28, 33, 38,
44, 47, 50, 52, 53, 54, 53, 53, 50, 47, 43, 39, 33, 27, 21, 15, 8, 2, -5, -11,
-17, -23, -28, -33, -37, -42, -45, -47, -48, -49, -49, -49, -47, -45, -42, -39,
-35, -32, -26, -22, -17, -12, -7, -2, 2, 6, 11, 14, 17, 20, 23, 25, 27, 28, 28,
29, 29, 28, 26, 25, 22, 20, 17, 14, 11, 8, 4, 2, -2, -5, -8, -11, -13, -15, -17,
-17, -18, -18, -18, -18, -17, -16, -14, -12, -10, -8, -4, -2, 2, 5, 7, 10, 14,
17, 19, 22, 23, 25, 27, 27, 27, 27, 27, 25, 24, 22, 19, 17, 14, 11, 6, 4, 0, -4,
-8, -10, -14, -18, -21, -24, -27, -28, -30, -32, -33, -33, -33, -33, -32, -30,
-29, -26, -24, -21, -19, -15, -12, -8, -4, 0, 3, 6, 9, 12, 16, 19, 23, 26, 29,
31, 32, 33, 33, 33, 31, 29, 26, 23, 19, 15, 11, 6, 1, -3, -6, -10, -13, -16,
-19, -21, -22, -22, -23, -20, -20, -18, -16, -13, -11, -8, -5, -2, 0, 3, 6, 8,
11, 12, 14, 15, 15, 16, 16, 16, 15, 15, 13, 13, 12, 10, 7, 6, 4, 2, -1, -1, -3,
-6, -8, -9, -12, -13, -14, -16, -18, -18, -20, -20, -20, -20, -21, -21, -20,
-18, -18, -17, -15, -12, -11, -8, -6, -4, -2, 1, 3, 7, 8, 11, 13, 15, 17, 19,
19, 21, 21, 21, 22, 21, 20, 20, 19, 16, 15, 13, 12, 9, 8, 6, 3, 1, -1, -2, -5,
-6, -7, -9, -9, -11, -11, -11, -11, -12, -11, -10, -11, -10, -8, -8, -6, -5, -4,
-3, -2, 0, 0, 2, 2, 4, 5, 5, 5, 6, 6, 6, 6, 5, 5, 4, 3, 1, 2, 0, 0, -2, -3, -4,
-5, -6, -7, -9, -9, -10, -10, -11, -12, -10, -11, -10, -10, -8, -8, -7, -6, -4,
-4, -2, 0, 2, 3, 4, 6, 7, 9, 10, 11, 12, 13, 14, 15, 15, 15, 15, 15, 14, 14, 13,
12, 11, 9, 8, 7, 6, 3, 2, 1, 0, -1, -4, -5, -5, -7, -8, -8, -10, -10, -10, -11,
-12, -11, -11, -10, -10, -10, -9, -8, -7, -6, -5, -4, -3, -3, -1, -1, 1, 2, 2,
2, 2, 3, 4, 4, 4, 3, 4, 3, 3, 3, 2, 1, -5, -16, -28, -43, -57, -69, -79, -86,
-90, -90, -86, -79, -67, -51, -30, -8, };