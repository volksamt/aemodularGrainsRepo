#define DATA_LENGTH 512
#define DATA AKWF_0353

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 2, 2, 3, 4, 6, 4, 6, 8, 7, 6, 7, 8,
10, 9, 9, 9, 10, 9, 10, 9, 11, 13, 12, 11, 12, 14, 13, 14, 14, 17, 16, 17, 17,
19, 21, 21, 21, 22, 21, 22, 21, 21, 21, 22, 21, 21, 23, 24, 27, 26, 27, 26, 27,
26, 27, 29, 28, 28, 29, 32, 31, 33, 34, 33, 33, 34, 33, 33, 33, 33, 32, 35, 36,
35, 38, 38, 37, 38, 38, 38, 40, 41, 41, 40, 42, 44, 43, 43, 43, 43, 42, 42, 43,
46, 45, 45, 45, 48, 48, 48, 47, 49, 52, 53, 52, 52, 52, 52, 52, 53, 54, 55, 54,
54, 55, 55, 57, 58, 57, 56, 57, 57, 57, 60, 60, 60, 60, 62, 62, 63, 64, 65, 65,
64, 64, 65, 67, 67, 67, 67, 66, 67, 66, 68, 69, 69, 69, 69, 71, 72, 72, 70, 73,
75, 74, 74, 74, 76, 76, 76, 76, 76, 77, 76, 76, 77, 79, 79, 79, 79, 82, 83, 83,
84, 83, 83, 83, 83, 85, 86, 86, 86, 87, 88, 88, 88, 88, 88, 89, 89, 88, 91, 90,
91, 90, 93, 93, 93, 95, 95, 95, 96, 95, 97, 98, 98, 97, 98, 100, 100, 99, 101,
100, 99, 101, 100, 101, 103, 102, 102, 104, 105, 106, 104, 106, 106, 109, 106,
108, 108, 111, 107, 111, 109, 113, 112, 111, 112, 112, 116, 112, 118, 109, 123,
100, 127, -19, -128, -104, -128, -112, -122, -111, -117, -112, -115, -113, -115,
-114, -114, -116, -113, -116, -112, -113, -112, -110, -109, -110, -109, -111,
-108, -108, -107, -108, -107, -106, -104, -105, -103, -102, -101, -103, -102,
-103, -102, -102, -103, -102, -100, -100, -100, -100, -98, -98, -98, -98, -97,
-94, -96, -96, -95, -93, -93, -92, -94, -90, -91, -90, -90, -91, -91, -90, -91,
-90, -88, -88, -89, -88, -86, -85, -83, -84, -83, -83, -83, -84, -82, -81, -81,
-81, -80, -79, -79, -78, -78, -79, -79, -78, -79, -77, -76, -76, -76, -75, -73,
-74, -74, -72, -72, -71, -71, -71, -69, -69, -68, -69, -68, -69, -69, -70, -68,
-66, -66, -66, -67, -64, -64, -64, -64, -62, -62, -63, -62, -61, -57, -57, -57,
-57, -57, -57, -57, -57, -57, -57, -57, -57, -55, -55, -52, -52, -52, -52, -53,
-53, -52, -51, -51, -49, -50, -48, -48, -46, -45, -46, -45, -45, -46, -46, -45,
-43, -43, -44, -43, -43, -43, -41, -40, -41, -40, -40, -38, -38, -38, -39, -38,
-35, -36, -35, -36, -35, -36, -36, -36, -34, -34, -33, -33, -32, -31, -31, -30,
-31, -27, -25, -25, -26, -27, -26, -26, -26, -24, -24, -24, -23, -24, -23, -22,
-21, -21, -21, -22, -21, -21, -19, -19, -19, -19, -17, -17, -16, -14, -14, -14,
-14, -14, -14, -12, -12, -12, -12, -12, -12, -13, -10, -9, -10, -9, -10, -8, -7,
-7, -8, -7, -5, -5, -5, -5, -2, -2, -3, -2, 0, 0, 0, 0, 0, -1, 0, 0, 1, };