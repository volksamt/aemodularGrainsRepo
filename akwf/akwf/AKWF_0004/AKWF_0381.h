#define DATA_LENGTH 512
#define DATA AKWF_0381

const PROGMEM int8_t DATA[DATA_LENGTH] = {20, 22, 24, 17, 54, 74, 66, 70, 69,
68, 69, 67, 75, 117, 115, 115, 118, 74, 67, 70, 68, 70, 68, 69, 69, 70, 67, 73,
32, 19, 24, 22, 22, 22, 21, 24, 11, -30, -23, -27, -25, -26, -24, -25, -25, -25,
-26, -24, -26, -25, -27, -25, -26, -25, -25, -24, -25, -24, -25, -25, -26, -25,
-25, -26, -25, -25, -25, -26, -24, -28, -23, -31, -5, 27, 19, 23, 21, 22, 21,
22, 22, 21, 21, 22, 22, 21, 22, 21, 21, 22, 22, 21, 22, 21, 21, 21, 22, 21, 22,
21, 22, 21, 21, 21, 22, 22, 22, 22, 21, 22, 21, 22, 21, 22, 21, 24, 19, 27, 4,
-30, -23, -26, -24, -26, -25, -26, -24, -24, -26, -25, -25, -25, -25, -25, -26,
-25, -25, -24, -26, -25, -26, -24, -26, -25, -26, -25, -26, -25, -26, -26, -25,
-25, -25, -25, -25, -26, -25, -25, -25, -25, -25, -25, -25, -25, -25, -26, -25,
-25, -25, -25, -25, -25, -25, -25, -25, -26, -25, -25, -25, -25, -25, -24, -25,
-25, -26, -24, -26, -25, -25, -25, -25, -25, -24, -26, -25, -25, -25, -25, -25,
-25, -25, -24, -25, -25, -25, -25, -25, -24, -25, -25, -25, -25, -25, -25, -24,
-26, -24, -25, -26, -25, -25, -25, -25, -25, -25, -24, -25, -25, -25, -25, -25,
-25, -25, -25, -25, -24, -25, -25, -25, -25, -25, -26, -25, -25, -25, -26, -24,
-26, -24, -26, -24, -26, -25, -25, -24, -25, -25, -26, -24, -25, -26, 18, 24,
20, 23, 21, 24, 21, 23, 21, 23, 22, 24, 22, 23, 22, 22, 21, 22, 23, 22, 22, 22,
23, 21, 22, 22, 23, 23, 22, 22, 23, 22, 23, 22, 22, 22, 22, 22, 22, 22, 22, 23,
22, 23, 22, 22, 22, 22, 22, 22, 21, 22, 21, 22, 22, 22, 21, 22, 22, 23, 21, 22,
21, 22, 22, 22, 22, 23, 22, 21, 23, 22, 21, 22, 22, 22, 22, 22, 22, 22, 22, 22,
22, 22, 23, 22, 21, 22, 21, 21, 22, 23, 21, 21, 21, 21, 22, 22, 22, 21, 22, 22,
22, 22, 22, 22, 22, 22, 22, 22, 22, 22, 22, 22, 22, 22, 21, 22, 21, 22, 22, 21,
22, 22, 22, 22, 22, 22, 22, 22, 22, 22, 22, 22, 21, 22, 22, 22, 22, 21, 22, 22,
22, 21, 22, 22, 21, 22, 22, 22, 22, 21, 22, 22, 21, 22, 22, 21, 22, 22, 22, 22,
21, 22, 21, 21, 22, 22, 22, 21, 22, 21, 21, 21, 22, 21, 21, 22, 21, 22, 20, 24,
20, 26, -10, -30, -22, -27, -24, -26, -25, -27, -25, -26, -25, -25, -25, -26,
-25, -26, -25, -25, -25, -25, -25, -25, -25, -25, -25, -26, -26, -25, -26, -25,
-25, -26, -25, -26, -25, -26, -25, -26, -25, -25, -25, -24, -26, -25, -27, -22,
-51, -77, -68, -76, -65, -96, -124, -116, -122, -116, -124, -95, -65, -77, -67,
-80, -52, -21, -26, -25, -22, };