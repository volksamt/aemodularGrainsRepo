#define DATA_LENGTH 512
#define DATA AKWF_0322

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 6, 9, 12, 14, 17, 20, 22, 25,
27, 29, 32, 34, 37, 39, 41, 44, 46, 49, 51, 53, 56, 57, 59, 61, 63, 65, 68, 69,
71, 73, 75, 77, 78, 79, 81, 83, 85, 86, 88, 89, 91, 91, 93, 94, 96, 98, 98, 99,
99, 100, 101, 102, 103, 103, 104, 104, 105, 106, 106, 106, 107, 108, 107, 108,
109, 108, 108, 109, 110, 108, 110, 110, 110, 109, 110, 111, 110, 111, 111, 112,
112, 113, 112, 113, 113, 113, 113, 114, 114, 115, 114, 115, 115, 115, 115, 115,
115, 115, 115, 116, 116, 116, 115, 116, 115, 116, 115, 115, 113, 113, 113, 113,
113, 112, 111, 109, 108, 108, 107, 107, 106, 105, 104, 103, 103, 102, 101, 100,
100, 99, 98, 98, 97, 96, 96, 95, 94, 93, 94, 93, 93, 92, 92, 92, 92, 91, 90, 89,
89, 88, 88, 88, 87, 87, 85, 85, 84, 84, 84, 82, 81, 81, 80, 79, 79, 77, 77, 75,
75, 74, 73, 72, 70, 69, 68, 67, 65, 62, 61, 60, 58, 56, 54, 53, 50, 48, 47, 44,
43, 41, 39, 38, 35, 34, 32, 32, 30, 28, 27, 26, 24, 23, 21, 20, 18, 17, 16, 14,
14, 12, 10, 9, 8, 7, 5, 5, 3, 3, 2, 2, 0, 0, 0, -1, -1, -1, -2, -3, -4, -4, -3,
-3, -4, -5, -5, -5, -5, -6, -5, -5, -5, -5, -4, -4, -4, -4, -3, -1, -3, -2, -1,
-1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -2, -1, -2, -1, -2, -2, -2,
-3, -3, -3, -4, -4, -5, -5, -6, -7, -7, -8, -9, -10, -11, -12, -13, -14, -15,
-16, -18, -19, -19, -20, -21, -22, -24, -25, -26, -27, -29, -30, -32, -33, -35,
-36, -38, -39, -40, -42, -43, -45, -46, -49, -50, -51, -53, -54, -56, -58, -59,
-61, -62, -63, -66, -67, -68, -68, -69, -70, -72, -72, -73, -74, -76, -77, -77,
-77, -80, -80, -81, -81, -83, -85, -85, -85, -86, -87, -88, -89, -90, -90, -91,
-92, -93, -93, -93, -94, -95, -96, -96, -97, -97, -99, -100, -100, -100, -102,
-105, -105, -106, -107, -109, -110, -111, -111, -112, -113, -114, -114, -115,
-115, -116, -117, -118, -118, -118, -118, -118, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -118, -118, -118, -119, -118, -117, -117,
-117, -117, -116, -115, -116, -114, -114, -114, -114, -114, -114, -113, -113,
-112, -112, -112, -112, -111, -111, -110, -110, -110, -109, -108, -109, -109,
-108, -107, -107, -106, -107, -106, -106, -106, -105, -106, -105, -105, -105,
-105, -104, -104, -105, -105, -105, -105, -104, -104, -103, -103, -102, -102,
-101, -100, -99, -99, -98, -97, -96, -94, -94, -92, -91, -90, -89, -86, -85,
-84, -82, -80, -78, -76, -75, -73, -70, -68, -66, -63, -62, -60, -57, -55, -52,
-49, -46, -44, -42, -39, -36, -33, -30, -28, -24, -20, -18, -14, -10, -7, -5,
-2, };