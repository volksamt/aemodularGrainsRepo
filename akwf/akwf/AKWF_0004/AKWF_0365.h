#define DATA_LENGTH 512
#define DATA AKWF_0365

const PROGMEM int8_t DATA[DATA_LENGTH] = {17, 76, 113, 119, 113, 103, 98, 97,
99, 101, 103, 102, 102, 101, 102, 101, 102, 101, 101, 102, 102, 101, 102, 102,
101, 101, 101, 102, 101, 102, 102, 101, 101, 101, 101, 101, 101, 101, 102, 102,
101, 101, 100, 101, 100, 101, 101, 101, 101, 101, 102, 102, 101, 101, 101, 101,
101, 101, 101, 100, 101, 101, 101, 101, 101, 101, 102, 101, 102, 101, 102, 102,
102, 101, 102, 101, 102, 101, 102, 101, 102, 102, 102, 101, 102, 101, 101, 101,
101, 101, 101, 101, 101, 101, 101, 101, 102, 101, 102, 101, 101, 101, 101, 101,
101, 101, 101, 101, 101, 101, 101, 101, 101, 101, 102, 102, 101, 101, 101, 102,
102, 101, 101, 101, 101, 102, 101, 101, 101, 101, 101, 101, 101, 101, 101, 102,
102, 101, 100, 101, 102, 101, 101, 100, 101, 101, 102, 101, 101, 101, 100, 102,
101, 101, 102, 100, 101, 101, 102, 101, 101, 101, 100, 102, 101, 102, 101, 101,
102, 101, 101, 101, 102, 101, 101, 101, 101, 101, 101, 101, 102, 101, 101, 101,
102, 101, 102, 101, 101, 101, 101, 102, 101, 101, 101, 101, 101, 101, 101, 102,
101, 101, 101, 102, 101, 101, 102, 101, 101, 101, 101, 101, 100, 101, 101, 101,
101, 102, 101, 101, 101, 102, 101, 101, 102, 102, 102, 101, 100, 101, 101, 101,
101, 102, 101, 102, 102, 101, 101, 102, 100, 102, 101, 100, 101, 102, 100, 102,
101, 102, 102, 101, 100, 102, 101, 101, 101, 101, 101, 102, 101, 102, 96, 71,
13, -54, -101, -119, -116, -107, -99, -97, -99, -100, -101, -102, -101, -102,
-101, -101, -101, -102, -101, -101, -101, -101, -101, -101, -101, -102, -101,
-101, -102, -101, -101, -101, -101, -101, -101, -102, -102, -102, -102, -101,
-101, -101, -101, -102, -101, -101, -102, -101, -102, -101, -102, -101, -102,
-101, -101, -102, -101, -102, -101, -101, -100, -101, -102, -101, -102, -102,
-102, -101, -101, -101, -101, -101, -102, -101, -101, -101, -101, -101, -101,
-101, -102, -101, -101, -101, -102, -101, -101, -101, -101, -101, -101, -100,
-101, -101, -101, -101, -102, -101, -102, -102, -102, -101, -102, -102, -102,
-101, -101, -101, -102, -101, -101, -101, -101, -101, -101, -102, -100, -101,
-101, -101, -101, -102, -102, -101, -101, -101, -101, -101, -102, -101, -102,
-102, -102, -101, -101, -101, -102, -101, -101, -102, -102, -101, -101, -101,
-101, -101, -101, -101, -101, -101, -101, -102, -101, -102, -101, -101, -101,
-101, -102, -101, -101, -102, -101, -101, -101, -102, -102, -100, -102, -101,
-101, -101, -101, -101, -101, -101, -101, -102, -101, -101, -101, -102, -101,
-101, -101, -101, -102, -101, -101, -101, -100, -101, -101, -101, -101, -102,
-101, -101, -101, -101, -101, -101, -101, -102, -101, -101, -101, -101, -101,
-101, -101, -102, -101, -101, -102, -102, -101, -101, -101, -100, -101, -101,
-101, -101, -102, -102, -101, -101, -101, -101, -101, -102, -101, -102, -100,
-101, -101, -101, -101, -102, -101, -100, -102, -101, -102, -99, -86, -36, };