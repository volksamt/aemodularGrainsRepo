#define DATA_LENGTH 512
#define DATA AKWF_0327

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 3, 3, 5, 4, 5, 7, 8, 8, 9,
11, 12, 14, 15, 16, 18, 20, 22, 24, 25, 27, 29, 31, 32, 34, 36, 38, 39, 41, 43,
44, 46, 48, 49, 50, 52, 53, 55, 57, 59, 60, 61, 63, 65, 66, 68, 70, 71, 73, 74,
76, 77, 77, 78, 75, 69, 62, 59, 56, 55, 54, 53, 52, 51, 50, 48, 45, 43, 42, 40,
37, 36, 35, 34, 34, 33, 33, 31, 31, 31, 31, 30, 30, 30, 29, 29, 29, 28, 28, 27,
27, 26, 26, 25, 24, 23, 22, 21, 21, 20, 18, 17, 16, 15, 14, 14, 13, 11, 11, 10,
10, 9, 9, 8, 7, 7, 6, 7, 6, 2, -2, -4, -4, -5, -6, -6, -6, -5, -6, -7, -6, -8,
-7, -8, -7, -7, -7, -6, -6, -5, -4, -3, -1, 0, 0, 1, 4, 4, 5, 7, 9, 10, 12, 12,
14, 16, 17, 18, 19, 21, 22, 24, 26, 27, 28, 30, 32, 32, 34, 36, 37, 39, 40, 41,
42, 44, 46, 47, 48, 50, 51, 52, 50, 46, 41, 39, 39, 37, 38, 38, 38, 39, 38, 37,
36, 35, 33, 32, 32, 32, 31, 32, 32, 32, 32, 33, 33, 33, 33, 33, 35, 34, 34, 35,
35, 35, 35, 36, 37, 36, 37, 36, 36, 36, 37, 37, 36, 37, 36, 36, 37, 36, 35, 36,
36, 36, 35, 36, 36, 36, 36, 35, 36, 36, 36, 37, 36, 33, 29, 28, 29, 28, 28, 27,
28, 28, 28, 28, 27, 26, 26, 27, 27, 27, 27, 28, 28, 29, 30, 31, 31, 31, 33, 34,
34, 36, 36, 38, 39, 39, 40, 41, 42, 43, 44, 45, 46, 47, 48, 49, 49, 50, 52, 52,
53, 54, 54, 55, 55, 57, 58, 59, 59, 60, 61, 61, 61, 62, 61, 59, 54, 45, 38, 33,
29, 26, 23, 20, 18, 15, 11, 8, 4, 0, -4, -7, -11, -14, -16, -19, -22, -22, -24,
-26, -28, -31, -31, -33, -34, -36, -37, -39, -41, -43, -44, -46, -48, -49, -52,
-55, -56, -58, -60, -63, -65, -67, -69, -71, -73, -75, -77, -79, -82, -84, -86,
-87, -89, -91, -93, -94, -95, -97, -98, -99, -100, -105, -110, -112, -112, -113,
-114, -115, -116, -116, -117, -118, -119, -118, -119, -118, -119, -119, -118,
-117, -117, -116, -115, -113, -112, -111, -110, -107, -106, -104, -103, -100,
-99, -96, -95, -93, -92, -89, -87, -85, -83, -81, -79, -78, -76, -73, -72, -69,
-67, -65, -63, -62, -58, -56, -55, -52, -50, -48, -46, -43, -42, -38, -37, -35,
-37, -41, -44, -45, -45, -45, -44, -42, -42, -41, -41, -42, -42, -42, -41, -42,
-41, -41, -41, -40, -39, -39, -37, -36, -35, -34, -32, -32, -29, -29, -28, -26,
-25, -24, -23, -22, -21, -20, -18, -18, -17, -16, -15, -14, -13, -14, -13, -12,
-11, -10, -9, -9, -8, -7, -7, -6, -5, -4, -3, -2, 0, 0, 1, 3, 2, -1, -3, -3, -2,
-1, -2, 0, };