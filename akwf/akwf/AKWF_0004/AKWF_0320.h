#define DATA_LENGTH 512
#define DATA AKWF_0320

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 7, 9, 11, 14, 16, 19, 20, 23,
25, 27, 29, 31, 33, 34, 37, 39, 40, 42, 44, 47, 49, 50, 52, 53, 55, 57, 58, 61,
62, 64, 65, 66, 68, 70, 72, 73, 75, 77, 78, 79, 80, 81, 82, 84, 85, 87, 88, 89,
90, 91, 92, 93, 94, 95, 96, 97, 97, 98, 99, 100, 100, 102, 103, 104, 104, 105,
105, 107, 107, 107, 107, 109, 109, 109, 110, 109, 110, 110, 112, 112, 113, 113,
114, 115, 114, 114, 114, 115, 116, 116, 116, 117, 116, 115, 116, 117, 117, 117,
117, 116, 116, 117, 116, 116, 116, 115, 115, 115, 114, 114, 113, 113, 112, 111,
109, 110, 108, 108, 107, 107, 105, 105, 104, 103, 102, 102, 101, 100, 100, 99,
98, 97, 97, 96, 95, 94, 95, 94, 93, 93, 92, 92, 91, 91, 90, 89, 89, 88, 88, 87,
86, 86, 85, 84, 85, 83, 82, 81, 81, 80, 80, 79, 78, 77, 76, 75, 75, 73, 74, 72,
72, 70, 69, 67, 66, 65, 64, 62, 61, 60, 58, 57, 56, 54, 53, 51, 50, 49, 47, 46,
45, 43, 43, 41, 41, 40, 38, 37, 36, 35, 33, 32, 32, 30, 29, 28, 28, 26, 24, 23,
23, 20, 20, 19, 17, 17, 15, 16, 14, 14, 12, 11, 10, 10, 10, 9, 8, 8, 7, 6, 6, 6,
4, 4, 3, 3, 3, 2, 1, 1, 1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, -1, 0, 0, -1, -2, -2,
-2, -2, -3, -3, -4, -4, -5, -6, -5, -6, -7, -7, -8, -10, -10, -10, -11, -12,
-12, -12, -13, -15, -15, -16, -18, -19, -20, -20, -22, -23, -23, -24, -25, -27,
-27, -28, -31, -31, -32, -34, -35, -36, -36, -38, -39, -41, -41, -42, -43, -44,
-45, -47, -49, -49, -50, -52, -53, -54, -55, -55, -57, -58, -59, -60, -61, -63,
-63, -65, -66, -66, -67, -68, -69, -70, -71, -72, -73, -73, -74, -75, -76, -76,
-78, -78, -79, -80, -81, -82, -83, -84, -84, -85, -86, -87, -87, -88, -89, -90,
-90, -91, -91, -93, -94, -94, -95, -95, -96, -98, -98, -99, -99, -101, -102,
-104, -105, -106, -107, -109, -109, -109, -111, -111, -112, -113, -113, -113,
-114, -116, -116, -116, -117, -117, -118, -117, -118, -118, -119, -118, -119,
-119, -119, -119, -118, -118, -119, -119, -118, -119, -119, -119, -119, -118,
-118, -118, -117, -117, -116, -116, -117, -115, -116, -116, -115, -115, -114,
-115, -113, -114, -113, -112, -111, -110, -110, -110, -109, -108, -107, -107,
-106, -105, -105, -104, -103, -101, -101, -100, -99, -100, -99, -98, -97, -97,
-96, -96, -96, -96, -95, -94, -93, -93, -92, -90, -89, -89, -88, -87, -87, -86,
-85, -84, -82, -82, -80, -79, -78, -77, -75, -74, -72, -71, -69, -68, -67, -65,
-64, -62, -60, -58, -57, -54, -52, -51, -48, -47, -45, -42, -40, -38, -36, -33,
-30, -29, -27, -23, -20, -18, -15, -12, -10, -7, -4, -2, };