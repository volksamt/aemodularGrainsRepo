#define DATA_LENGTH 512
#define DATA AKWF_0329

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 28, 51, 63, 70, 80, 90, 97, 102,
103, 101, 96, 88, 76, 63, 49, 33, 17, 0, -16, -33, -48, -61, -72, -82, -90, -98,
-110, -119, -117, -109, -96, -81, -65, -49, -32, -15, 1, 15, 29, 39, 47, 54, 58,
60, 60, 58, 55, 51, 45, 39, 32, 26, 21, 15, 10, 5, 0, -4, -8, -10, -13, -17,
-26, -32, -32, -30, -28, -28, -28, -27, -28, -33, -36, -35, -34, -43, -48, -48,
-44, -38, -30, -19, -7, 2, 11, 19, 26, 31, 34, 36, 35, 32, 25, 14, 2, -8, -6,
-3, -2, 0, 3, 10, 17, 24, 33, 39, 45, 49, 52, 53, 51, 48, 43, 37, 31, 23, 16,
10, 3, -3, -7, -11, -13, -16, -16, -16, -14, -12, -11, -9, -7, -8, -9, -11, -13,
-15, -16, -15, -13, -10, -6, -4, -2, 0, 4, 18, 27, 29, 30, 28, 25, 23, 19, 17,
14, 11, 10, 8, 7, 5, 3, 1, 0, -2, -3, -5, -4, -3, -4, -2, 1, 12, 23, 27, 28, 24,
20, 15, 11, 6, 1, -2, -5, -9, -11, -12, -13, -14, -14, -13, -12, -7, 8, 15, 17,
18, 16, 14, 12, 9, 6, 4, 1, -1, -1, -3, -3, -2, 3, 19, 34, 45, 48, 45, 43, 42,
37, 32, 22, 13, 2, -10, -17, -12, -3, 0, 1, 1, 0, -1, 0, 2, 5, 11, 21, 31, 34,
40, 51, 56, 54, 46, 35, 21, 7, -3, -15, -32, -49, -67, -80, -84, -81, -83, -88,
-91, -95, -95, -96, -92, -88, -80, -73, -62, -52, -37, -12, 9, 22, 33, 41, 46,
50, 53, 56, 56, 56, 56, 53, 50, 47, 45, 51, 57, 56, 51, 44, 34, 25, 15, 6, -3,
-11, -19, -24, -28, -32, -34, -36, -36, -36, -35, -32, -23, -8, -1, 1, 1, 0, -3,
-7, -9, -13, -14, -19, -21, -22, -24, -25, -25, -24, -25, -24, -23, -22, -20,
-19, -17, -15, -14, -14, -14, -14, -13, -13, -13, -12, -11, -11, -10, -10, -10,
-9, -8, -8, -9, -9, -9, -7, -8, -9, -13, -15, -16, -15, -13, -11, -6, -2, 2, 7,
11, 15, 18, 20, 21, 19, 18, 13, 10, 5, 1, -5, -10, -14, -17, -21, -24, -25, -25,
-24, -21, -18, -14, -10, -12, -18, -17, -14, -9, -4, 0, 4, 7, 10, 13, 16, 18,
17, 17, 16, 13, 10, 5, 0, -11, -30, -44, -51, -56, -58, -58, -55, -51, -49, -44,
-40, -36, -32, -29, -26, -27, -36, -44, -43, -41, -35, -29, -22, -14, -8, -3, 4,
8, 12, 14, 8, -4, -10, -14, -18, -18, -15, -11, -14, -12, -1, 11, 22, 29, 22, 9,
1, 1, 3, 7, 12, 16, 21, 26, 30, 35, 38, 42, 39, 31, 29, 33, 39, 44, 51, 55, 58,
59, 58, 55, 49, 39, 25, 2, -18, -28, -33, -34, -33, -30, -26, -19, -13, -6, 0,
7, 13, 19, 24, 19, 11, 12, 15, 21, 28, 36, 43, 47, 33, -4, -38, -56, -56, -42,
-17, };