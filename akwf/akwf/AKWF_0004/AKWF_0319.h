#define DATA_LENGTH 512
#define DATA AKWF_0319

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 2, 5, 6, 7, 9, 10, 13, 14, 15, 17,
19, 21, 22, 24, 26, 28, 29, 31, 34, 35, 36, 39, 41, 43, 44, 46, 48, 49, 52, 52,
55, 56, 58, 61, 61, 63, 65, 68, 68, 71, 72, 73, 75, 77, 79, 80, 81, 82, 84, 85,
87, 87, 89, 91, 92, 93, 93, 95, 96, 97, 98, 98, 99, 100, 101, 102, 103, 104,
104, 104, 105, 106, 106, 106, 108, 108, 107, 109, 109, 109, 109, 110, 109, 109,
110, 111, 110, 110, 111, 110, 111, 110, 110, 110, 109, 109, 109, 109, 108, 108,
107, 106, 107, 105, 105, 104, 104, 103, 102, 101, 101, 98, 98, 97, 96, 95, 94,
93, 91, 89, 88, 87, 85, 84, 82, 81, 80, 78, 75, 74, 73, 70, 69, 68, 65, 64, 61,
59, 58, 55, 53, 51, 49, 47, 45, 43, 42, 39, 37, 35, 32, 30, 28, 25, 23, 21, 18,
15, 13, 11, 9, 6, 4, 1, -1, -4, -7, -8, -11, -13, -16, -18, -22, -24, -27, -29,
-31, -34, -37, -39, -41, -44, -47, -49, -52, -54, -56, -59, -60, -63, -66, -68,
-70, -72, -74, -77, -80, -80, -83, -85, -87, -89, -90, -93, -95, -96, -98, -99,
-101, -102, -103, -105, -107, -107, -108, -110, -111, -111, -112, -113, -114,
-115, -115, -116, -117, -117, -117, -118, -118, -118, -119, -119, -119, -118,
-119, -119, -119, -118, -118, -118, -118, -118, -117, -117, -116, -115, -115,
-114, -113, -113, -111, -111, -110, -109, -108, -107, -106, -105, -105, -104,
-102, -101, -100, -98, -97, -96, -95, -94, -92, -90, -89, -88, -86, -85, -83,
-82, -80, -78, -77, -75, -73, -72, -70, -68, -67, -65, -63, -62, -59, -58, -56,
-55, -53, -52, -50, -48, -46, -45, -43, -42, -40, -38, -37, -35, -33, -32, -30,
-29, -27, -26, -24, -23, -21, -20, -19, -17, -16, -14, -13, -12, -11, -10, -8,
-6, -6, -4, -3, -2, -1, 1, 1, 3, 3, 4, 6, 7, 8, 9, 9, 10, 12, 13, 14, 14, 15,
16, 17, 18, 19, 20, 20, 21, 22, 23, 23, 24, 25, 25, 25, 26, 26, 27, 28, 28, 28,
28, 29, 29, 29, 29, 30, 30, 30, 29, 30, 30, 29, 30, 30, 30, 30, 29, 29, 28, 29,
28, 29, 28, 27, 27, 27, 26, 27, 25, 26, 25, 24, 24, 23, 23, 22, 21, 21, 21, 20,
19, 18, 17, 17, 17, 15, 14, 14, 12, 11, 11, 10, 10, 8, 8, 7, 6, 5, 4, 3, 2, 1,
-1, -1, -3, -4, -5, -5, -6, -7, -8, -10, -11, -12, -13, -14, -15, -16, -17, -18,
-20, -21, -21, -23, -23, -24, -25, -25, -26, -27, -28, -28, -29, -30, -30, -31,
-31, -32, -32, -32, -33, -33, -33, -34, -33, -33, -33, -33, -33, -33, -32, -32,
-32, -32, -31, -31, -31, -30, -29, -29, -28, -27, -26, -26, -25, -24, -24, -22,
-22, -20, -20, -18, -17, -16, -15, -13, -12, -11, -9, -9, -7, -6, -5, -4, -1,
-1, };