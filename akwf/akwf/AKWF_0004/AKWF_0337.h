#define DATA_LENGTH 512
#define DATA AKWF_0337

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 7, 11, 13, 16, 18, 21, 25,
26, 28, 28, 30, 31, 32, 32, 33, 33, 33, 34, 35, 35, 36, 37, 37, 37, 38, 39, 40,
41, 42, 42, 44, 45, 46, 47, 50, 51, 54, 55, 57, 59, 61, 64, 64, 67, 68, 69, 71,
73, 75, 76, 79, 81, 84, 85, 87, 90, 91, 93, 96, 98, 100, 102, 104, 106, 109,
110, 112, 115, 118, 119, 119, 119, 116, 114, 110, 106, 101, 95, 90, 84, 77, 70,
63, 57, 50, 44, 37, 29, 25, 17, 10, 5, -1, -7, -12, -17, -22, -26, -30, -34,
-37, -41, -43, -47, -50, -53, -56, -59, -61, -64, -66, -68, -70, -72, -73, -74,
-75, -75, -76, -77, -77, -77, -76, -77, -77, -76, -76, -76, -75, -73, -72, -71,
-70, -68, -67, -67, -66, -65, -66, -67, -66, -67, -67, -68, -69, -69, -69, -70,
-69, -70, -70, -71, -70, -69, -69, -69, -68, -68, -67, -66, -65, -65, -63, -62,
-60, -57, -56, -53, -51, -50, -49, -48, -46, -43, -42, -40, -39, -36, -33, -32,
-29, -26, -24, -22, -18, -17, -14, -11, -9, -6, -3, 0, 2, 5, 8, 11, 14, 17, 19,
19, 20, 20, 19, 18, 17, 15, 13, 12, 10, 7, 5, 3, 1, -2, -3, -6, -9, -10, -12,
-14, -15, -17, -19, -20, -21, -22, -22, -22, -22, -23, -22, -22, -22, -22, -22,
-22, -21, -21, -20, -20, -19, -19, -18, -17, -15, -13, -12, -9, -9, -7, -5, -3,
0, 1, 3, 6, 8, 10, 13, 16, 19, 22, 25, 27, 28, 29, 30, 31, 32, 32, 34, 34, 33,
34, 34, 35, 36, 37, 36, 37, 39, 40, 40, 40, 41, 43, 44, 45, 46, 48, 50, 51, 54,
56, 58, 60, 61, 62, 65, 66, 68, 70, 71, 73, 75, 77, 78, 81, 82, 85, 88, 89, 92,
94, 96, 98, 100, 102, 105, 106, 108, 111, 114, 116, 117, 119, 119, 118, 116,
114, 110, 106, 100, 94, 90, 82, 76, 70, 63, 56, 49, 43, 36, 30, 23, 17, 10, 5,
-2, -7, -12, -17, -22, -27, -31, -33, -37, -41, -45, -47, -51, -53, -56, -59,
-62, -64, -66, -69, -70, -72, -73, -74, -75, -76, -76, -77, -77, -77, -77, -77,
-77, -77, -76, -75, -74, -73, -72, -71, -69, -68, -67, -67, -66, -65, -67, -66,
-67, -66, -68, -67, -69, -69, -69, -70, -70, -70, -70, -70, -70, -70, -70, -69,
-69, -69, -67, -67, -65, -64, -63, -61, -59, -57, -55, -53, -52, -50, -48, -47,
-46, -44, -42, -40, -38, -36, -34, -31, -29, -27, -23, -21, -19, -16, -14, -11,
-9, -6, -3, 0, 3, 5, 8, 11, 14, 18, 19, 20, 20, 20, 19, 19, 17, 15, 14, 11, 9,
7, 5, 3, 0, -2, -4, -6, -9, -10, -12, -15, -16, -17, -19, -21, -21, -21, -22,
-23, -23, -22, -23, -22, -23, -22, -22, -22, -22, -21, -21, -20, -20, -19, -17,
-17, -14, -13, -11, -10, -8, -7, -5, -3, -1, };