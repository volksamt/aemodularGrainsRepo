#define DATA_LENGTH 512
#define DATA AKWF_0384

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 13, 17, 21, 23, 28, 30,
34, 37, 40, 43, 46, 50, 52, 55, 59, 62, 65, 67, 70, 73, 76, 79, 80, 83, 85, 88,
90, 92, 94, 97, 98, 100, 102, 103, 105, 106, 108, 109, 111, 111, 113, 114, 115,
115, 116, 117, 117, 118, 118, 118, 119, 119, 119, 119, 119, 119, 119, 118, 118,
117, 116, 116, 115, 114, 113, 112, 110, 110, 109, 107, 107, 104, 103, 101, 100,
98, 96, 94, 92, 90, 88, 86, 85, 83, 80, 78, 76, 73, 70, 68, 66, 64, 62, 59, 56,
54, 52, 49, 46, 45, 42, 39, 36, 33, 32, 29, 26, 23, 22, 18, 16, 14, 11, 9, 5, 4,
1, -1, -4, -6, -9, -11, -13, -15, -18, -21, -23, -24, -27, -29, -31, -34, -36,
-36, -39, -42, -43, -46, -47, -48, -50, -53, -54, -56, -58, -59, -60, -61, -64,
-66, -67, -68, -70, -71, -72, -74, -75, -77, -78, -79, -79, -81, -81, -83, -84,
-84, -86, -87, -87, -89, -88, -89, -91, -92, -92, -92, -93, -94, -93, -93, -94,
-95, -95, -94, -94, -95, -95, -95, -94, -95, -94, -95, -93, -93, -93, -93, -92,
-91, -92, -91, -90, -89, -89, -87, -87, -86, -85, -84, -83, -81, -80, -79, -78,
-77, -75, -74, -73, -71, -70, -69, -67, -65, -63, -62, -59, -58, -56, -54, -52,
-50, -48, -47, -44, -42, -40, -38, -35, -33, -31, -29, -27, -24, -22, -19, -17,
-15, -12, -11, -8, -6, -2, 0, 2, 5, 7, 10, 12, 14, 16, 19, 21, 24, 26, 28, 31,
34, 36, 38, 40, 42, 44, 47, 49, 51, 53, 54, 58, 59, 61, 62, 64, 67, 68, 69, 71,
72, 75, 75, 78, 80, 80, 82, 82, 84, 85, 87, 87, 89, 89, 90, 91, 92, 93, 93, 94,
95, 95, 96, 96, 96, 97, 97, 98, 97, 97, 98, 97, 97, 98, 97, 97, 97, 96, 95, 95,
95, 95, 94, 93, 92, 91, 90, 90, 89, 88, 88, 85, 84, 84, 82, 81, 80, 78, 77, 76,
74, 73, 71, 70, 68, 66, 65, 63, 62, 59, 58, 55, 54, 53, 51, 49, 47, 45, 43, 41,
39, 36, 34, 33, 31, 28, 27, 24, 22, 21, 18, 16, 14, 12, 9, 7, 4, 3, 1, -1, -4,
-6, -8, -11, -12, -15, -18, -20, -22, -24, -26, -28, -31, -33, -35, -38, -40,
-43, -45, -47, -50, -51, -54, -56, -57, -60, -62, -64, -67, -69, -70, -73, -75,
-76, -79, -81, -82, -84, -86, -87, -89, -91, -93, -95, -96, -96, -98, -100,
-102, -103, -104, -105, -106, -106, -108, -109, -110, -111, -111, -112, -112,
-113, -113, -114, -114, -114, -115, -114, -114, -114, -113, -113, -113, -112,
-112, -111, -110, -110, -109, -109, -107, -107, -105, -102, -102, -101, -99,
-97, -96, -94, -92, -90, -88, -86, -84, -82, -79, -77, -76, -72, -70, -67, -64,
-62, -60, -56, -54, -51, -48, -45, -42, -39, -34, -32, -29, -26, -22, -19, -16,
-12, -9, -6, -3, };