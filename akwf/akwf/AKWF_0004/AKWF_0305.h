#define DATA_LENGTH 512
#define DATA AKWF_0305

const PROGMEM int8_t DATA[DATA_LENGTH] = {-2, 3, -4, 10, -62, -110, -103, -118,
-115, -122, -116, -117, -111, -107, -97, -91, -81, -71, -60, -48, -36, -24, -12,
0, 11, 23, 33, 44, 53, 62, 70, 78, 83, 89, 93, 96, 98, 101, 101, 101, 99, 98,
95, 93, 88, 84, 79, 73, 68, 62, 57, 50, 44, 38, 31, 26, 19, 13, 8, 2, -3, -8,
-13, -16, -21, -24, -27, -29, -31, -34, -35, -36, -37, -37, -37, -37, -36, -35,
-36, -34, -32, -31, -29, -27, -25, -23, -21, -19, -18, -15, -12, -10, -8, -7,
-5, -3, -2, 1, 2, 3, 5, 5, 6, 8, 8, 10, 9, 10, 10, 11, 11, 11, 10, 10, 10, 11,
9, 10, 9, 8, 8, 7, 7, 6, 5, 4, 4, 3, 4, 3, 2, 1, 2, 1, 0, -1, -1, 0, -1, -2, -1,
-2, -2, -2, -2, -3, -2, -2, -3, -2, -3, -2, -3, -3, -2, -2, -2, -2, -1, -2, -1,
-2, -1, -1, -1, -1, -1, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 0,
0, 1, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0,
-1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0,
0, 0, 0, 0, -1, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0,
1, 1, 0, 0, 0, -1, 0, 0, 1, -1, -1, 0, 0, 1, 0, -1, 1, 0, 0, 0, 0, 0, 1, 0, 0,
0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1,
0, 0, 0, 1, 0, 0, 0, -1, 0, -1, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
-1, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0,
-1, 1, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0,
0, 1, 0, -1, 0, 0, 0, 0, -1, -1, 0, -1, 0, 0, -1, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0,
0, 0, 0, -1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0,
0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, -1, 0,
0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, -1, 0, 0, -1, 0, 0, 1, 0, 0, 1, 0, -1,
-1, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, };