#define DATA_LENGTH 512
#define DATA AKWF_0346

const PROGMEM int8_t DATA[DATA_LENGTH] = {-42, -121, -118, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -120, -113, -93, -76, -70, -72, -71,
-73, -71, -73, -72, -72, -72, -72, -71, -72, -72, -72, -71, -71, -71, -71, -72,
-71, -73, -71, -71, -72, -72, -72, -71, -72, -72, -71, -71, -71, -71, -71, -71,
-71, -72, -71, -72, -72, -71, -71, -71, -71, -72, -72, -71, -72, -72, -72, -71,
-72, -72, -71, -71, -72, -72, -71, -71, -72, -72, -71, -71, -71, -71, -72, -71,
-72, -72, -71, -71, -71, -72, -71, -72, -71, -71, -71, -71, -71, -72, -72, -71,
-72, -71, -71, -70, -71, -71, -71, -71, -71, -70, -70, -71, -71, -72, -71, -71,
-71, -71, -70, -71, -71, -71, -71, -71, -70, -72, -70, -71, -70, -71, -71, -71,
-70, -72, -69, -51, -31, -22, -24, -24, -25, -24, -23, -23, -24, -24, -23, -23,
-24, -24, -23, -23, -23, -23, -23, -24, -23, -24, -24, -23, -23, -24, -24, -23,
-23, -23, -23, -23, -24, -23, -23, -24, -23, -24, -24, -23, -24, -24, -23, -23,
-23, -23, -23, -24, -23, -24, -23, -23, -24, -23, -23, -23, -23, -23, -23, -23,
-23, -23, -23, -24, -23, -23, -24, -23, -23, -23, -23, -23, -23, -23, -23, -23,
-23, -23, -22, -23, -23, -24, -23, -23, -23, -23, -23, -22, -23, -23, -23, -24,
-23, -23, -23, -23, -23, -23, -23, -24, -24, -23, -23, -23, -23, -23, -23, -23,
-23, -24, -23, -23, -23, -23, -23, -22, -24, -15, 5, 24, 25, 25, 25, 24, 24, 24,
24, 24, 24, 24, 25, 24, 24, 24, 25, 25, 24, 25, 25, 24, 24, 25, 25, 24, 25, 24,
25, 24, 24, 25, 24, 24, 24, 24, 24, 24, 24, 25, 24, 24, 25, 24, 24, 24, 25, 24,
24, 24, 23, 24, 24, 24, 24, 24, 24, 25, 25, 24, 25, 24, 24, 24, 24, 24, 25, 24,
25, 24, 24, 25, 24, 24, 24, 25, 24, 24, 25, 24, 25, 24, 24, 24, 25, 24, 25, 24,
24, 25, 24, 24, 23, 24, 25, 23, 24, 24, 25, 25, 24, 25, 24, 24, 24, 24, 24, 24,
24, 24, 24, 24, 24, 25, 24, 24, 24, 24, 24, 23, 24, 23, 35, 56, 71, 71, 70, 72,
71, 72, 70, 71, 71, 71, 71, 72, 71, 71, 71, 71, 71, 71, 72, 72, 72, 71, 72, 71,
72, 71, 71, 72, 71, 71, 70, 71, 71, 71, 71, 71, 71, 71, 71, 71, 71, 71, 71, 71,
71, 71, 71, 71, 71, 71, 70, 70, 70, 71, 70, 71, 71, 71, 71, 71, 71, 70, 71, 71,
71, 71, 70, 71, 72, 70, 70, 71, 71, 71, 71, 71, 70, 71, 70, 70, 70, 70, 71, 71,
71, 71, 70, 70, 70, 71, 71, 71, 71, 71, 70, 71, 71, 71, 70, 70, 71, 70, 71, 70,
70, 70, 71, 70, 72, 70, 71, 70, 71, 70, 71, 69, 72, 91, 111, 119, 117, 118, 116,
118, 117, 119, 116, 119, 116, 120, 114, 125, 46, -35, };