#define DATA_LENGTH 512
#define DATA AKWF_0379

const PROGMEM int8_t DATA[DATA_LENGTH] = {35, 43, 39, 41, 39, 41, 39, 41, 40,
41, 40, 40, 39, 40, 40, 41, 40, 41, 40, 41, 40, 40, 40, 40, 40, 40, 41, 41, 40,
41, 40, 40, 40, 40, 40, 40, 40, 41, 40, 39, 40, 40, 40, 41, 40, 40, 40, 40, 40,
40, 40, 41, 40, 40, 41, 40, 40, 40, 40, 40, 40, 40, 40, 40, 41, 40, 40, 41, 41,
40, 40, 40, 40, 40, 40, 41, 40, 41, 39, 40, 40, 39, 40, 40, 40, 40, 39, 40, 40,
40, 40, 39, 40, 39, 40, 40, 40, 40, 40, 40, 39, 39, 40, 41, 40, 40, 40, 39, 40,
40, 41, 39, 40, 40, 39, 39, 40, 39, 39, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40,
39, 40, 40, 39, 39, 40, 39, 40, 39, 40, 39, 40, 40, 39, 39, 40, 39, 39, 39, 39,
40, 39, 39, 40, 40, 40, 40, 40, 40, 39, 40, 40, 40, 40, 39, 39, 40, 39, 39, 39,
39, 40, 40, 40, 39, 40, 39, 39, 40, 40, 40, 39, 40, 39, 39, 39, 40, 39, 40, 39,
40, 40, 39, 40, 39, 40, 39, 39, 40, 41, 39, 40, 39, 40, 38, 40, 39, 39, 39, 39,
39, 40, 39, 40, 39, 39, 41, 37, 43, 31, 96, 125, 114, 121, 116, 120, 117, 119,
117, 119, 117, 118, 117, 118, 118, 118, 117, 119, 117, 119, 116, 119, 116, 120,
116, 120, 115, 120, 115, 122, 113, 122, 113, 123, 112, 125, 102, -115, -123,
-115, -122, -116, -122, -115, -123, -115, -122, -116, -121, -116, -121, -117,
-120, -117, -120, -118, -120, -118, -120, -118, -119, -119, -120, -119, -118,
-119, -118, -121, -118, -121, -117, -122, -113, -128, -78, -31, -45, -37, -42,
-38, -41, -39, -40, -39, -40, -41, -40, -40, -39, -40, -39, -40, -39, -40, -39,
-40, -39, -40, -40, -40, -40, -40, -40, -40, -39, -40, -40, -40, -40, -40, -40,
-39, -40, -40, -40, -39, -39, -39, -40, -39, -40, -40, -40, -40, -40, -39, -40,
-40, -40, -40, -40, -40, -39, -40, -40, -39, -39, -39, -40, -39, -39, -40, -40,
-39, -40, -39, -39, -39, -39, -39, -40, -39, -39, -39, -39, -40, -39, -40, -39,
-39, -40, -39, -40, -40, -40, -39, -40, -39, -40, -39, -40, -40, -39, -40, -39,
-40, -39, -40, -39, -39, -40, -39, -40, -39, -39, -39, -39, -39, -39, -40, -39,
-39, -39, -39, -39, -40, -39, -39, -39, -39, -39, -38, -39, -38, -39, -39, -39,
-38, -39, -39, -39, -39, -39, -39, -39, -39, -39, -40, -39, -39, -39, -39, -38,
-38, -40, -38, -39, -40, -39, -39, -39, -39, -38, -40, -39, -38, -39, -39, -39,
-39, -39, -39, -39, -39, -39, -39, -39, -39, -39, -39, -39, -39, -39, -39, -38,
-39, -38, -38, -38, -39, -39, -39, -39, -38, -39, -39, -38, -39, -39, -39, -38,
-39, -40, -38, -39, -39, -38, -39, -39, -39, -38, -39, -39, -39, -38, -39, -39,
-39, -38, -40, -38, -41, -33, };