#define DATA_LENGTH 512
#define DATA AKWF_0344

const PROGMEM int8_t DATA[DATA_LENGTH] = {35, 42, 39, 40, 39, 41, 39, 42, 40,
41, 40, 41, 40, 40, 40, 40, 40, 40, 40, 40, 40, 41, 41, 40, 40, 40, 41, 40, 41,
39, 41, 40, 39, 40, 40, 41, 40, 40, 39, 40, 40, 40, 41, 39, 41, 41, 40, 40, 40,
40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 40, 41, 40, 40, 40, 40, 40, 40, 40, 40,
40, 40, 40, 39, 40, 40, 40, 40, 41, 39, 40, 39, 40, 40, 39, 40, 40, 40, 40, 39,
41, 40, 40, 39, 39, 40, 40, 40, 40, 40, 40, 39, 40, 40, 40, 40, 40, 40, 40, 39,
40, 40, 40, 40, 39, 40, 40, 40, 40, 40, 39, 41, 39, 40, 39, 41, 39, 40, 40, 40,
40, 40, 40, 38, 41, 36, 44, 30, 87, 127, 113, 122, 116, 120, 116, 120, 117, 120,
117, 118, 118, 119, 118, 117, 118, 118, 118, 118, 118, 118, 119, 118, 118, 117,
118, 117, 118, 118, 118, 118, 118, 117, 117, 117, 118, 118, 118, 118, 118, 118,
118, 118, 117, 117, 118, 117, 117, 118, 118, 117, 117, 118, 118, 117, 117, 118,
118, 117, 118, 118, 117, 117, 118, 117, 117, 117, 116, 117, 118, 117, 117, 117,
117, 117, 117, 117, 117, 118, 118, 117, 117, 117, 117, 116, 118, 116, 118, 116,
118, 116, 117, 117, 117, 117, 117, 117, 117, 117, 116, 117, 115, 118, 115, 118,
114, 119, 114, 120, 114, 121, 112, 121, 112, 123, 111, 124, 101, -116, -122,
-116, -122, -115, -123, -116, -123, -116, -122, -116, -122, -117, -122, -117,
-120, -117, -120, -118, -120, -119, -120, -119, -119, -120, -119, -118, -118,
-119, -118, -120, -119, -120, -119, -119, -118, -119, -118, -119, -119, -119,
-118, -118, -118, -119, -119, -119, -118, -119, -119, -119, -119, -119, -118,
-119, -119, -118, -118, -118, -119, -119, -118, -119, -118, -118, -118, -118,
-118, -119, -118, -119, -118, -118, -119, -119, -118, -118, -118, -119, -117,
-119, -119, -118, -118, -118, -119, -118, -118, -117, -118, -118, -118, -117,
-119, -118, -118, -118, -119, -118, -118, -118, -117, -118, -118, -117, -117,
-119, -117, -119, -117, -119, -116, -119, -116, -121, -113, -126, -93, -31, -42,
-37, -41, -38, -40, -39, -39, -39, -39, -40, -38, -39, -38, -39, -38, -40, -38,
-40, -39, -39, -39, -39, -38, -39, -38, -40, -38, -39, -39, -39, -39, -39, -39,
-39, -38, -39, -38, -39, -39, -39, -39, -39, -40, -39, -38, -40, -39, -39, -39,
-38, -39, -39, -38, -38, -39, -39, -39, -39, -38, -38, -39, -39, -39, -39, -39,
-38, -39, -39, -39, -39, -38, -39, -40, -38, -38, -38, -38, -39, -39, -39, -38,
-39, -39, -39, -38, -38, -39, -39, -38, -38, -38, -39, -38, -39, -39, -38, -38,
-39, -38, -39, -38, -39, -38, -38, -39, -38, -38, -38, -38, -39, -38, -38, -38,
-39, -39, -38, -39, -38, -38, -38, -38, -39, -38, -38, -39, -39, -38, -39, -38,
-40, -38, -40, -36, -39, -36, -41, -33, };