#define DATA_LENGTH 512
#define DATA AKWF_0370

const PROGMEM int8_t DATA[DATA_LENGTH] = {13, 37, 57, 75, 88, 98, 106, 111, 114,
116, 115, 113, 111, 107, 103, 97, 91, 84, 79, 72, 66, 60, 54, 49, 43, 39, 33,
28, 22, 16, 9, 4, -3, -10, -19, -26, -35, -44, -52, -59, -67, -73, -78, -81,
-85, -88, -88, -87, -86, -84, -81, -76, -70, -64, -57, -49, -40, -31, -23, -13,
-5, 3, 10, 17, 25, 30, 36, 42, 46, 50, 52, 54, 56, 57, 57, 57, 56, 55, 52, 50,
47, 43, 38, 33, 29, 24, 18, 11, 4, 0, -7, -12, -19, -25, -30, -36, -41, -45,
-50, -52, -54, -57, -58, -59, -59, -57, -55, -52, -50, -46, -41, -37, -31, -26,
-20, -14, -6, 0, 5, 11, 17, 24, 29, 36, 40, 45, 50, 53, 56, 59, 61, 63, 63, 62,
62, 61, 59, 58, 55, 51, 47, 43, 38, 33, 28, 22, 16, 11, 4, -1, -7, -13, -18,
-23, -28, -32, -37, -40, -45, -47, -48, -50, -51, -51, -51, -50, -50, -47, -45,
-42, -40, -36, -32, -28, -24, -18, -14, -10, -6, -1, 3, 7, 12, 16, 20, 22, 25,
28, 30, 32, 34, 35, 34, 33, 34, 33, 31, 29, 27, 23, 20, 17, 14, 11, 7, 3, 0, -4,
-7, -11, -15, -19, -22, -25, -27, -30, -32, -33, -34, -36, -35, -35, -35, -34,
-32, -29, -28, -25, -22, -19, -15, -12, -8, -3, 0, 5, 9, 14, 19, 23, 29, 33, 38,
42, 46, 49, 52, 52, 53, 52, 52, 50, 47, 44, 42, 37, 33, 29, 23, 18, 13, 8, 4, 0,
-4, -8, -13, -16, -19, -22, -25, -28, -30, -32, -34, -36, -37, -37, -38, -38,
-38, -38, -37, -36, -33, -32, -30, -27, -24, -22, -18, -15, -11, -7, -3, -1, 4,
6, 9, 12, 15, 17, 20, 22, 24, 25, 26, 26, 26, 26, 25, 24, 22, 21, 19, 17, 14,
11, 9, 6, 4, 1, -2, -5, -7, -10, -12, -15, -17, -20, -21, -23, -24, -25, -26,
-26, -26, -26, -25, -24, -23, -22, -20, -18, -15, -13, -11, -7, -5, -2, 1, 4, 6,
9, 12, 16, 18, 20, 23, 25, 27, 28, 30, 31, 32, 33, 33, 31, 31, 31, 29, 28, 26,
24, 22, 19, 17, 14, 12, 9, 6, 4, 0, -2, -5, -8, -10, -12, -15, -16, -19, -21,
-22, -23, -23, -24, -24, -25, -25, -24, -24, -23, -21, -20, -19, -17, -15, -13,
-10, -9, -6, -5, -2, 0, 2, 3, 5, 7, 8, 9, 10, 12, 12, 13, 13, 13, 14, 13, 13,
13, 11, 11, 10, 8, 8, 6, 4, 2, 0, 0, -3, -3, -6, -7, -9, -11, -12, -13, -14,
-15, -15, -16, -16, -16, -16, -17, -15, -14, -13, -13, -11, -9, -8, -6, -6, -3,
-2, 1, 2, 4, 5, 8, 10, 11, 13, 15, 16, 17, 18, 20, 20, 21, 21, 21, 22, 21, 21,
20, 19, 18, 17, 12, 4, -8, -24, -42, -61, -78, -93, -104, -112, -118, -119,
-118, -116, -109, -100, -86, -68, -48, -25, -4, };