#define DATA_LENGTH 512
#define DATA AKWF_0308

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 16, 22, 29, 34, 40, 47, 53, 57,
63, 68, 73, 78, 81, 86, 89, 94, 98, 101, 104, 106, 109, 111, 113, 115, 116, 117,
118, 119, 119, 120, 120, 118, 118, 117, 115, 114, 112, 112, 110, 108, 105, 103,
99, 98, 94, 91, 88, 84, 81, 79, 75, 72, 68, 64, 61, 57, 53, 48, 44, 41, 37, 34,
30, 26, 22, 18, 16, 12, 8, 5, 2, -2, -5, -7, -10, -13, -16, -19, -21, -23, -25,
-27, -29, -31, -32, -35, -36, -37, -39, -39, -41, -42, -42, -43, -44, -44, -44,
-44, -45, -44, -45, -44, -44, -44, -44, -42, -42, -40, -40, -40, -39, -38, -37,
-36, -34, -33, -33, -32, -30, -29, -28, -27, -26, -24, -23, -21, -20, -18, -18,
-16, -14, -14, -12, -10, -9, -8, -7, -6, -4, -4, -3, -1, -1, 1, 1, 3, 3, 4, 5,
5, 7, 7, 8, 9, 9, 10, 10, 11, 11, 11, 12, 12, 12, 13, 13, 13, 12, 13, 13, 13,
14, 13, 13, 14, 13, 13, 13, 13, 12, 12, 12, 12, 11, 11, 11, 10, 10, 9, 9, 9, 9,
8, 7, 8, 8, 7, 6, 6, 5, 5, 5, 4, 5, 3, 3, 3, 2, 2, 1, 2, 1, 1, 1, 0, -1, 0, 0,
-1, -1, -2, -1, -2, -2, -2, -3, -3, -2, -3, -3, -3, -3, -3, -3, -3, -4, -3, -4,
-3, -4, -3, -3, -4, -4, -3, -3, -4, -3, -3, -4, -3, -3, -3, -3, -2, -3, -3, -3,
-3, -2, -2, -2, -2, -2, -2, -2, -2, -2, -1, -2, -2, -2, -1, 0, 0, -1, 0, 0, -1,
-1, -1, 0, 0, -1, 1, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1,
1, 1, 1, 1, 2, 0, 1, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 1, 0, 0, 1, 1,
0, 0, 1, 1, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0,
1, 1, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, -1, -1, -1, 0, 0, -1, 0,
0, -1, 0, -1, -1, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, -1, 0, 0, 1, 0, -1, 1, 0, 0,
0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 1, 1, 0, 1, 0, 0, -1, 0, 1, 0, 0, 0, -1, 0, 0,
1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 1, 0, -1, 1, 0, 0, 0, -3, -5, -8,
-11, -16, -20, -25, -29, -34, -40, -45, -51, -57, -62, -67, -72, -77, -82, -87,
-92, -94, -98, -102, -105, -107, -109, -110, -113, -112, -113, -113, -114, -112,
-112, -109, -108, -105, -102, -99, -95, -91, -87, -82, -78, -73, -67, -62, -57,
-52, -45, -39, -33, -26, -21, -14, -9, -2, };