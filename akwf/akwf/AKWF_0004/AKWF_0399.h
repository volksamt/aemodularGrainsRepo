#define DATA_LENGTH 512
#define DATA AKWF_0399

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 10, 13, 16, 20, 23, 27, 30, 34,
37, 41, 45, 48, 51, 54, 56, 58, 61, 62, 64, 65, 67, 68, 69, 70, 71, 72, 73, 75,
74, 77, 77, 78, 79, 80, 81, 82, 84, 85, 86, 87, 89, 89, 91, 93, 94, 94, 96, 96,
97, 97, 97, 97, 96, 96, 97, 98, 98, 99, 100, 100, 100, 101, 101, 102, 101, 100,
100, 99, 98, 98, 97, 96, 96, 95, 96, 96, 96, 97, 97, 97, 98, 98, 98, 96, 96, 96,
96, 94, 94, 93, 92, 91, 90, 89, 88, 88, 88, 85, 84, 83, 82, 80, 80, 79, 79, 77,
75, 74, 72, 71, 69, 68, 66, 65, 64, 62, 60, 60, 57, 56, 55, 54, 54, 54, 54, 54,
55, 56, 57, 59, 60, 61, 63, 64, 65, 66, 67, 67, 68, 68, 68, 68, 69, 70, 68, 70,
71, 72, 74, 75, 75, 75, 76, 78, 78, 78, 80, 81, 83, 83, 86, 87, 89, 91, 93, 94,
95, 95, 96, 96, 96, 95, 96, 96, 96, 96, 97, 97, 98, 99, 101, 101, 103, 105, 106,
107, 108, 111, 113, 115, 116, 117, 117, 118, 119, 118, 118, 119, 118, 119, 119,
119, 119, 117, 117, 118, 118, 119, 118, 119, 118, 118, 117, 118, 117, 116, 116,
114, 111, 109, 107, 106, 105, 104, 102, 101, 99, 98, 98, 97, 98, 96, 96, 94, 96,
79, 46, 49, 46, 36, 25, 12, 2, -8, -15, -22, -27, -32, -37, -42, -45, -48, -52,
-56, -58, -61, -64, -65, -68, -70, -72, -72, -73, -74, -74, -74, -74, -74, -73,
-75, -75, -75, -75, -77, -77, -77, -77, -79, -79, -80, -80, -82, -82, -83, -84,
-85, -87, -88, -88, -89, -90, -90, -90, -91, -91, -92, -93, -92, -93, -93, -92,
-92, -93, -93, -93, -94, -95, -95, -96, -96, -96, -96, -98, -98, -99, -99, -98,
-99, -99, -101, -101, -102, -103, -104, -105, -104, -105, -105, -104, -103,
-103, -103, -101, -101, -100, -99, -96, -95, -93, -91, -88, -85, -82, -81, -78,
-77, -76, -75, -74, -72, -71, -70, -69, -69, -68, -67, -67, -67, -66, -65, -65,
-64, -65, -65, -65, -64, -65, -66, -66, -67, -66, -67, -68, -68, -68, -68, -68,
-68, -67, -67, -68, -67, -68, -68, -69, -68, -69, -70, -70, -72, -72, -73, -73,
-73, -75, -75, -75, -76, -76, -77, -78, -79, -79, -79, -80, -80, -81, -82, -82,
-83, -84, -85, -86, -87, -89, -89, -90, -91, -92, -92, -92, -93, -94, -94, -95,
-95, -95, -95, -95, -96, -96, -97, -96, -97, -97, -99, -98, -98, -99, -100, -99,
-100, -99, -100, -100, -100, -101, -101, -103, -104, -104, -105, -105, -106,
-107, -107, -106, -106, -105, -104, -102, -99, -98, -96, -92, -89, -86, -81,
-78, -75, -73, -69, -66, -64, -61, -59, -58, -54, -53, -51, -48, -46, -42, -40,
-38, -37, -34, -32, -30, -28, -28, -27, -26, -27, -27, -27, -27, -28, -28, -27,
-27, -25, -23, -22, -19, -16, -12, -8, -4, -1, };