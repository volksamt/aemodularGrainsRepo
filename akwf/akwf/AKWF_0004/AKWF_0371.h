#define DATA_LENGTH 512
#define DATA AKWF_0371

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 9, 15, 21, 28, 33, 39, 43, 47, 50,
54, 57, 60, 61, 65, 66, 68, 69, 72, 74, 76, 77, 81, 83, 84, 87, 89, 90, 91, 94,
95, 96, 98, 99, 99, 99, 98, 98, 97, 96, 93, 92, 89, 86, 82, 79, 74, 70, 65, 58,
52, 47, 39, 33, 26, 21, 13, 7, 0, -6, -12, -19, -25, -31, -38, -44, -49, -55,
-61, -66, -72, -77, -82, -86, -90, -94, -98, -101, -104, -106, -108, -112, -113,
-115, -116, -117, -118, -118, -119, -119, -119, -118, -119, -118, -117, -115,
-114, -112, -111, -108, -106, -103, -100, -97, -93, -88, -84, -79, -75, -69,
-63, -57, -51, -45, -38, -32, -25, -19, -12, -7, 0, 5, 11, 18, 24, 30, 37, 43,
47, 53, 58, 63, 67, 72, 76, 79, 83, 86, 88, 91, 93, 96, 97, 99, 99, 100, 101,
102, 102, 102, 102, 101, 101, 101, 99, 99, 96, 94, 93, 91, 89, 86, 84, 81, 78,
75, 73, 69, 65, 61, 58, 55, 50, 46, 43, 38, 35, 29, 26, 22, 18, 15, 12, 8, 4, 1,
-2, -6, -7, -10, -14, -16, -18, -22, -23, -25, -28, -30, -31, -32, -34, -35,
-37, -37, -37, -38, -38, -39, -39, -39, -39, -39, -39, -38, -39, -38, -38, -37,
-37, -36, -34, -34, -32, -32, -31, -30, -31, -28, -28, -27, -26, -24, -22, -23,
-21, -20, -18, -18, -17, -17, -16, -15, -14, -15, -15, -14, -14, -15, -15, -17,
-17, -18, -19, -20, -21, -23, -23, -25, -25, -27, -28, -29, -30, -31, -32, -32,
-32, -34, -33, -34, -35, -36, -36, -36, -35, -35, -35, -35, -35, -34, -33, -33,
-32, -32, -32, -29, -28, -27, -26, -24, -22, -20, -19, -17, -16, -13, -10, -7,
-6, -3, 0, 2, 5, 7, 11, 13, 16, 20, 23, 25, 28, 32, 34, 38, 41, 44, 46, 49, 51,
55, 56, 58, 60, 62, 63, 65, 67, 68, 69, 70, 71, 71, 72, 72, 71, 72, 72, 72, 71,
70, 70, 68, 67, 65, 65, 62, 61, 58, 56, 54, 51, 47, 45, 42, 40, 37, 33, 29, 26,
23, 19, 16, 12, 8, 5, 2, -2, -5, -8, -12, -15, -18, -22, -24, -28, -30, -34,
-37, -39, -42, -45, -46, -49, -50, -52, -54, -55, -57, -57, -58, -59, -60, -60,
-61, -61, -61, -61, -60, -60, -60, -59, -58, -57, -56, -55, -54, -51, -51, -49,
-47, -46, -44, -41, -40, -37, -35, -33, -30, -29, -26, -24, -21, -19, -17, -16,
-13, -12, -10, -7, -6, -4, -2, 0, 0, 3, 3, 5, 7, 8, 9, 10, 10, 12, 13, 13, 14,
14, 15, 15, 15, 16, 16, 16, 16, 17, 16, 16, 15, 15, 15, 15, 14, 14, 13, 13, 12,
11, 11, 10, 10, 10, 9, 9, 10, 9, 8, 8, 8, 8, 7, 8, 7, 7, 6, 3, 0, -5, -10, -17,
-23, -30, -36, -43, -49, -53, -58, -62, -63, -64, -65, -64, -62, -59, -56, -51,
-44, -39, -31, -25, -17, -10, -3, };