#define DATA_LENGTH 512
#define DATA AKWF_0356

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 4, 7, 10, 15, 17, 21, 24, 28, 30,
33, 36, 39, 42, 44, 47, 49, 51, 54, 56, 59, 60, 62, 64, 65, 67, 69, 71, 72, 73,
76, 77, 79, 79, 81, 82, 84, 84, 86, 87, 88, 90, 91, 91, 92, 93, 94, 96, 95, 96,
97, 98, 100, 100, 101, 102, 103, 103, 103, 104, 104, 105, 106, 106, 106, 107,
109, 109, 109, 108, 110, 110, 110, 111, 111, 112, 112, 112, 112, 112, 113, 113,
114, 113, 114, 113, 115, 115, 114, 114, 114, 115, 116, 115, 115, 115, 115, 115,
116, 115, 115, 116, 116, 116, 115, 115, 115, 115, 115, 114, 115, 115, 114, 114,
114, 114, 114, 114, 114, 113, 113, 113, 112, 113, 112, 112, 112, 111, 111, 111,
110, 111, 110, 110, 110, 109, 109, 109, 108, 108, 108, 107, 107, 107, 106, 106,
105, 104, 103, 104, 104, 102, 102, 102, 102, 102, 100, 100, 100, 99, 98, 98, 98,
97, 97, 97, 96, 96, 94, 95, 94, 93, 92, 93, 91, 90, 91, 91, 89, 89, 88, 88, 87,
87, 86, 85, 86, 84, 84, 82, 83, 82, 81, 80, 80, 80, 78, 78, 77, 77, 77, 75, 74,
74, 74, 74, 72, 72, 71, 70, 70, 69, 68, 68, 68, 67, 66, 66, 65, 65, 64, 63, 62,
62, 62, 61, 61, 59, 58, 58, 57, 56, 56, 55, 55, 54, 54, 52, 52, 51, 52, 49, 50,
48, 49, 47, 48, 46, 45, 44, 14, 56, 40, 13, 33, 22, 23, 15, 16, 8, 7, 3, 1, -4,
-7, -11, -14, -18, -22, -25, -28, -31, -35, -38, -41, -43, -47, -49, -51, -53,
-56, -58, -60, -62, -65, -68, -68, -71, -73, -74, -76, -78, -79, -81, -83, -84,
-85, -86, -88, -89, -90, -92, -93, -94, -94, -95, -96, -97, -99, -99, -101,
-101, -102, -103, -103, -104, -105, -106, -106, -107, -108, -108, -110, -109,
-111, -111, -112, -111, -112, -113, -113, -114, -113, -114, -115, -115, -115,
-115, -116, -116, -116, -117, -117, -117, -117, -117, -117, -118, -118, -118,
-119, -118, -118, -119, -119, -119, -118, -119, -119, -119, -119, -118, -119,
-119, -118, -118, -118, -120, -118, -119, -119, -118, -118, -118, -118, -117,
-117, -118, -117, -117, -117, -117, -117, -117, -115, -116, -115, -115, -115,
-115, -114, -114, -114, -113, -114, -113, -113, -111, -112, -110, -111, -111,
-110, -109, -109, -108, -108, -108, -108, -107, -107, -106, -106, -105, -105,
-104, -103, -103, -103, -102, -101, -101, -101, -101, -100, -99, -99, -97, -98,
-97, -96, -96, -96, -95, -94, -93, -93, -92, -92, -91, -90, -91, -89, -89, -88,
-88, -87, -86, -86, -85, -85, -84, -83, -83, -82, -82, -80, -80, -80, -78, -79,
-77, -78, -76, -76, -75, -75, -75, -73, -72, -71, -72, -70, -70, -69, -69, -68,
-67, -66, -67, -65, -64, -65, -64, -63, -62, -62, -60, -60, -59, -59, -57, -59,
-55, -59, -52, -61, -29, -47, -66, -22, -39, -35, -33, -28, -24, -20, -16, -14,
-9, -7, -2, };