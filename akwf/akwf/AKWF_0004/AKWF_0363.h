#define DATA_LENGTH 512
#define DATA AKWF_0363

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 10, 14, 16, 19, 21, 23, 25, 28,
29, 30, 31, 32, 34, 35, 35, 37, 37, 38, 39, 39, 41, 41, 42, 42, 42, 43, 42, 43,
44, 43, 43, 42, 42, 43, 42, 42, 41, 41, 41, 41, 39, 39, 38, 38, 37, 36, 35, 35,
34, 33, 32, 32, 30, 31, 29, 29, 28, 27, 25, 24, 24, 22, 23, 21, 21, 19, 19, 17,
16, 16, 15, 13, 13, 13, 12, 10, 10, 10, 9, 8, 8, 8, 6, 6, 5, 4, 4, 4, 2, 3, 2,
1, 0, 1, 1, 0, 0, -1, 0, -1, -2, -1, -3, -1, -3, -2, -3, -2, -3, -3, -2, -3, -2,
-4, 6, 21, 28, 33, 35, 34, 32, 30, 28, 24, 21, 17, 15, 12, 9, 7, 6, 3, 2, 0, -1,
-1, -3, -4, -4, -5, -4, -5, -5, -6, -7, -7, -7, -7, -8, -7, -8, -8, -8, -8, -8,
-9, -8, -9, -9, -9, -9, -8, -9, -9, -8, -10, -8, -9, -9, -9, -9, -9, -8, -8, -8,
-8, -8, -8, -8, -9, -7, -9, -1, 19, 30, 37, 40, 39, 39, 36, 32, 29, 26, 22, 18,
14, 12, 9, 6, 4, 2, 1, -1, -3, -3, -4, -5, -5, -6, -6, -7, -7, -7, -8, -8, -9,
-9, -9, -9, -9, -10, -9, -10, -2, 14, 25, 30, 32, 31, 30, 28, 25, 21, 17, 14,
11, 7, 4, 1, -2, -3, -4, -6, -7, -9, -10, -9, -11, -12, -12, -11, -12, -13, -12,
-13, -14, -14, -14, -14, -14, -13, -14, -14, -14, -14, -14, -15, -14, -13, -14,
-13, -14, -13, -13, -13, -13, -12, -12, 2, 18, 26, 30, 31, 31, 28, 26, 23, 20,
17, 13, 10, 7, 4, 2, 1, -2, -2, -5, -5, -6, -7, -7, -7, -9, -9, -9, -10, -9, -9,
-10, -10, -10, -10, -10, -10, -10, -11, -10, -10, -11, -10, -11, -10, -10, -10,
-10, -10, -10, -11, -10, -10, -10, -9, -10, -10, -10, -9, -9, -10, -1, 18, 29,
35, 38, 38, 37, 35, 31, 28, 24, 20, 16, 13, 10, 7, 5, 2, 1, 0, -3, -4, -5, -5,
-7, -6, -7, -7, -8, -8, -8, -9, -9, -10, -10, -10, -10, -10, -10, -10, -10, -10,
-11, -10, -12, -11, -11, -11, -11, -11, -11, -11, -11, -11, -11, -11, -11, -11,
-10, -10, -9, -10, -10, -10, -10, -10, -10, -9, -9, -8, -8, -8, -7, -8, -8, -7,
-6, -6, -6, -7, -6, -6, -6, -5, -5, -5, -5, -5, -4, -4, -3, -4, -4, -3, -3, -3,
-2, -3, -3, -3, -2, -2, -2, -1, -2, -1, -1, -1, -1, -1, -1, -1, -1, 0, 0, 0, 0,
1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 0, 0, 1, 1, 2, 0, 0, 0, 1, 0, 1,
0, 1, 0, 2, -9, -67, -100, -112, -118, -119, -118, -114, -111, -104, -98, -90,
-81, -72, -62, -53, -44, -36, -28, -20, -14, -7, -2, };