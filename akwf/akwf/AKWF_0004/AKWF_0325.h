#define DATA_LENGTH 512
#define DATA AKWF_0325

const PROGMEM int8_t DATA[DATA_LENGTH] = {-3, -8, -11, -12, -12, -10, -6, -3, 0,
-5, -21, -43, -57, -42, 6, 63, 102, 112, 98, 60, 4, -57, -102, -119, -107, -76,
-31, 21, 69, 105, 117, 111, 84, 43, -7, -55, -92, -112, -112, -93, -60, -19, 24,
60, 84, 95, 90, 72, 41, 7, -26, -54, -72, -78, -70, -54, -29, -2, 23, 44, 57,
61, 55, 42, 24, 2, -18, -34, -45, -48, -44, -34, -21, -4, 10, 23, 31, 33, 31,
23, 13, 1, -11, -21, -27, -29, -28, -21, -13, -3, 6, 14, 19, 19, 17, 11, 5, -2,
-8, -13, -15, -14, -12, -8, -4, 2, 7, 11, 11, 12, 11, 8, 3, 1, -3, -5, -6, -6,
-5, -2, 0, 3, 6, 7, 8, 7, 6, 5, 2, 0, -1, -3, -3, -2, -2, -1, 1, 2, 3, 5, 5, 5,
3, 2, 0, -2, -2, -2, -2, -1, -1, 1, 2, 1, 3, 2, 1, 1, 0, -1, -1, 0, -1, -1, 0,
1, 1, 2, 4, 4, 6, 12, 15, 11, -12, -48, -79, -87, -70, -37, 5, 46, 83, 103, 103,
86, 58, 21, -20, -61, -90, -104, -102, -81, -47, -6, 34, 68, 89, 97, 88, 67, 38,
4, -29, -57, -74, -79, -74, -57, -32, -4, 22, 44, 57, 62, 57, 43, 25, 3, -18,
-34, -45, -48, -44, -34, -20, -5, 11, 24, 33, 36, 34, 28, 16, 5, -8, -18, -25,
-27, -26, -21, -12, -4, 6, 13, 18, 21, 20, 15, 10, 2, -4, -10, -13, -16, -15,
-12, -8, 3, 27, 62, 84, 65, 13, -40, -78, -100, -104, -79, -26, 34, 75, 88, 82,
60, 24, -20, -56, -77, -83, -75, -53, -21, 17, 52, 75, 86, 81, 62, 32, -2, -33,
-57, -70, -73, -62, -43, -17, 9, 34, 51, 61, 61, 51, 33, 12, -10, -29, -43, -49,
-48, -39, -26, -9, 9, 23, 35, 40, 39, 33, 21, 8, -6, -17, -26, -29, -28, -23,
-16, -6, 6, 16, 23, 26, 26, 22, 15, 7, -2, -8, -15, -16, -17, -14, -9, -2, 5, 9,
13, 14, 14, 12, 7, 4, -2, -7, -10, -12, -12, -11, -8, -5, 0, 4, 6, 7, 6, 6, 2,
-1, -4, -6, -8, -9, -9, -7, -5, -3, 0, 2, 4, 4, 4, 2, 1, 0, -3, -4, -4, -5, -5,
-5, -2, -1, 1, 1, 3, 2, 2, 0, -2, -2, -2, -3, -2, -2, 0, 0, 0, 0, 1, 1, 1, 0, 0,
0, 0, -3, -3, -5, -6, -7, -10, -12, -14, -3, 28, 67, 90, 87, 61, 22, -23, -68,
-99, -112, -103, -81, -47, -6, 39, 78, 103, 112, 101, 73, 34, -10, -52, -82,
-99, -100, -86, -61, -26, 10, 44, 69, 83, 83, 72, 50, 23, -8, -35, -54, -65,
-66, -57, -40, -17, 6, 28, 44, 53, 53, 45, 31, 14, -5, -21, -33, -41, -41, -35,
-23, -9, 6, 18, 27, 31, 30, 25, 16, 6, -6, -14, -21, -23, -23, -18, -11, -4, 4,
11, 15, 18, 16, 13, 7, 2, };