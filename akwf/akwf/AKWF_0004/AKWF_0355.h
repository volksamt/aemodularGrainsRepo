#define DATA_LENGTH 512
#define DATA AKWF_0355

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 4, 4, 6, 6, 7, 8, 9, 10,
11, 11, 12, 13, 15, 16, 16, 17, 17, 18, 19, 19, 21, 22, 21, 24, 24, 25, 26, 26,
27, 27, 28, 29, 30, 31, 31, 32, 34, 34, 35, 35, 36, 37, 38, 38, 38, 39, 40, 41,
42, 43, 44, 43, 45, 45, 46, 46, 47, 47, 47, 48, 49, 51, 51, 51, 52, 53, 53, 54,
54, 54, 56, 56, 57, 57, 57, 58, 58, 60, 60, 61, 60, 61, 62, 62, 63, 63, 65, 64,
65, 66, 66, 66, 67, 67, 68, 68, 68, 69, 70, 70, 70, 71, 71, 71, 71, 71, 72, 74,
74, 74, 73, 74, 75, 75, 75, 76, 76, 76, 77, 77, 77, 78, 78, 78, 79, 79, 80, 80,
80, 80, 80, 81, 80, 81, 81, 82, 82, 82, 83, 82, 82, 83, 83, 84, 83, 84, 84, 84,
85, 85, 85, 85, 85, 85, 86, 86, 86, 86, 86, 86, 86, 86, 87, 87, 87, 87, 86, 86,
87, 87, 88, 87, 88, 87, 87, 88, 88, 88, 88, 88, 87, 88, 88, 88, 87, 87, 89, 88,
87, 88, 88, 88, 89, 88, 89, 88, 87, 87, 89, 88, 89, 88, 88, 88, 88, 88, 88, 87,
88, 88, 88, 88, 88, 88, 88, 87, 88, 87, 87, 87, 86, 88, 87, 87, 86, 88, 86, 87,
87, 86, 85, 86, 86, 86, 87, 85, 86, 85, 86, 83, 88, 83, 88, 81, 88, 81, 88, 80,
87, 80, 88, 79, 87, 81, 84, 87, 6, 89, 40, 44, 70, 48, 56, 37, 43, 29, 34, 21,
23, 11, 12, 3, 2, -6, -8, -15, -19, -24, -28, -31, -36, -39, -43, -46, -50, -52,
-57, -59, -63, -64, -68, -69, -72, -74, -77, -78, -80, -83, -84, -86, -88, -90,
-91, -93, -94, -96, -97, -99, -100, -101, -102, -102, -103, -105, -106, -106,
-108, -108, -108, -109, -110, -111, -111, -112, -113, -113, -113, -114, -114,
-115, -115, -116, -116, -116, -117, -117, -117, -118, -117, -117, -118, -118,
-119, -118, -118, -118, -119, -118, -118, -119, -118, -117, -117, -117, -117,
-117, -117, -117, -116, -116, -117, -116, -117, -115, -115, -115, -115, -114,
-114, -114, -114, -113, -112, -112, -111, -112, -110, -110, -109, -110, -108,
-108, -108, -107, -107, -106, -105, -106, -105, -104, -103, -102, -103, -101,
-100, -100, -99, -98, -98, -97, -96, -95, -94, -94, -94, -93, -92, -92, -90,
-89, -89, -88, -88, -87, -86, -86, -84, -83, -82, -82, -81, -81, -79, -78, -77,
-76, -76, -75, -74, -73, -73, -72, -70, -70, -69, -68, -67, -66, -65, -65, -63,
-62, -61, -61, -60, -59, -57, -56, -56, -55, -54, -53, -52, -52, -50, -50, -48,
-47, -46, -46, -45, -43, -43, -42, -41, -39, -39, -38, -36, -36, -35, -34, -33,
-32, -31, -30, -29, -28, -28, -27, -25, -25, -24, -23, -22, -20, -20, -18, -18,
-17, -16, -15, -14, -13, -13, -11, -11, -9, -8, -8, -7, -6, -5, -4, -3, -2, -2,
-1, };