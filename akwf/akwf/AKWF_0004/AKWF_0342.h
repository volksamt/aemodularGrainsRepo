#define DATA_LENGTH 512
#define DATA AKWF_0342

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 29, 44, 61, 75, 89, 100, 107, 113,
118, 120, 117, 115, 110, 102, 94, 84, 73, 63, 53, 41, 32, 21, 12, 4, -3, -10,
-16, -19, -23, -24, -26, -25, -25, -24, -24, -22, -20, -17, -13, -7, -3, 1, 5,
9, 11, 13, 14, 15, 16, 17, 17, 16, 16, 16, 14, 13, 11, 10, 9, 7, 5, 3, 3, 1, 0,
0, -2, -2, -2, -3, -2, -3, -3, -3, -2, -1, 0, 0, 1, 1, 2, 2, 3, 2, 3, 3, 3, 3,
3, 3, 3, 2, 3, 3, 2, 1, 1, -1, -2, -4, -7, -11, -14, -18, -20, -24, -26, -25,
-25, -21, -18, -13, -6, 0, 5, 10, 15, 16, 18, 18, 16, 15, 13, 11, 8, 7, 5, 3, 2,
2, 1, 2, 3, 4, 4, 3, 5, 4, 4, 5, 3, 3, 3, 2, 2, 1, 2, 2, 1, 1, 0, 0, 1, 0, 1, 1,
0, 1, 0, 0, -1, -1, -3, -4, -6, -5, -5, -4, -3, -2, -1, 0, 0, -1, -2, -2, -1,
-1, -1, -1, -1, -2, -1, -1, -1, -1, -2, -1, -1, -2, -1, -2, -1, -2, -3, -2, -3,
-2, -3, -2, -3, -2, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -2, -4,
-3, -3, -4, -3, -3, -3, -3, -4, -5, -6, -8, -10, -13, -17, -20, -26, -31, -37,
-47, -56, -66, -74, -81, -86, -92, -95, -98, -98, -98, -95, -91, -83, -75, -64,
-51, -36, -21, -5, 12, 30, 47, 62, 77, 89, 100, 109, 115, 118, 119, 118, 114,
109, 101, 93, 83, 72, 61, 51, 40, 29, 19, 12, 3, -4, -11, -15, -20, -22, -24,
-26, -26, -25, -24, -22, -21, -19, -16, -12, -7, -3, 2, 6, 9, 11, 13, 15, 15,
16, 17, 16, 16, 15, 16, 14, 12, 11, 10, 8, 7, 5, 4, 3, 1, 1, -1, -1, -2, -2, -2,
-3, -3, -2, -1, -1, -1, 0, 0, 1, 1, 2, 2, 2, 3, 3, 3, 3, 4, 3, 3, 3, 2, 2, 2, 2,
1, 1, 0, -2, -4, -7, -11, -14, -18, -21, -24, -25, -26, -24, -22, -17, -12, -6,
1, 6, 11, 15, 17, 17, 17, 17, 14, 13, 10, 8, 6, 5, 4, 3, 2, 1, 3, 2, 3, 3, 4, 4,
4, 5, 5, 4, 3, 3, 3, 1, 1, 1, 2, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, -2, -2,
-5, -6, -6, -5, -4, -2, -2, -1, 0, 0, -2, -2, -1, -1, -1, -2, -1, 0, -1, -1, -2,
-2, -1, -1, -1, -1, -2, -2, -2, -2, -2, -3, -3, -2, -2, -3, -3, -3, -3, -3, -3,
-3, -3, -3, -2, -3, -3, -2, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -3, -4, -4,
-3, -5, -5, -8, -10, -13, -17, -21, -26, -32, -39, -49, -57, -66, -74, -82, -87,
-92, -96, -97, -99, -98, -94, -90, -83, -73, -63, -49, -36, -19, -3, };