#define DATA_LENGTH 512
#define DATA AKWF_0388

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, -3, 4, -7, 53, 122, 16, -47, -43,
-29, -10, -2, 2, -2, -4, -6, -5, -7, -5, -6, -4, -4, -3, -3, -2, -2, -1, -1, -1,
-2, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0,
0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 1, 0, 0, 1,
0, 0, 0, 1, 1, 1, 0, 0, -1, 0, 1, -1, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0,
-1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, -1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0,
0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 1, 0, 0, -1,
0, 0, 0, 0, 1, -1, -1, 0, 0, 0, 0, 0, 0, -1, 1, 1, 1, 0, 1, 0, 0, 0, 0, -1, 0,
0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, -1, -1, 0, 0, 1, -1, 1, -1, 1, -2,
3, -4, 8, -65, -118, -3, 47, 42, 26, 9, 1, -1, 2, 4, 7, 6, 6, 5, 5, 3, 3, 3, 3,
2, 2, 1, 1, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0, -1, -1, 0, 1, 0, -1, 0, 0, 0, 0, 0,
-1, 0, 1, 1, 0, 0, 0, -1, 0, -1, 0, 0, -1, -1, 0, -1, 1, 0, 0, -1, 0, -1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0,
0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1,
0, -1, 0, -1, 0, 0, 0, 1, 0, 0, 0, -1, 1, 0, 1, 0, 0, -1, 0, 1, 1, -1, 0, 0, -1,
-1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 1, 1, 0, -1, 0,
0, 0, -1, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0,
0, -1, 0, 0, 1, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0,
0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 1, -1, -1, 1, -1, 0, 0, 0,
0, -1, 0, 1, };