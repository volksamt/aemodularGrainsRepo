#define DATA_LENGTH 512
#define DATA AKWF_0361

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 43, 105, 118, 91, 64, 51, 43, 37,
33, 27, 23, 19, 16, 14, 12, 9, 7, 6, 4, 3, 1, 0, -1, -2, -3, -4, -5, -7, -7, -8,
-9, -9, -11, -11, -12, -13, -14, -14, -15, -15, -16, -16, -16, -17, -16, -17,
-18, -18, -18, -18, -19, -19, -18, -19, -19, -19, -18, -19, -19, -18, -18, -19,
-17, -18, -18, -17, -17, -17, -17, -17, -16, -16, -16, -15, -15, -15, -15, -15,
-13, -13, -13, -12, -13, -12, -12, -11, -11, -11, -10, -10, -9, -9, -10, -9, -9,
-8, -7, -8, -7, -6, -7, -6, -6, -5, -5, -5, -5, -4, -4, -4, -3, -3, -3, -3, -2,
-2, -2, -2, -2, -1, -1, -1, -1, -1, -1, -1, 0, -5, -30, -44, -32, -19, -16, -13,
-11, -9, -7, -6, -4, -3, -1, -1, 0, 1, 1, 1, 3, 3, 3, 4, 4, 5, 5, 5, 5, 6, 6, 7,
6, 7, 6, 7, 8, 7, 8, 8, 8, 8, 8, 9, 8, 8, 9, 9, 9, 8, 9, 9, 9, 9, 8, 9, 8, 9, 8,
8, 8, 8, 7, 8, 8, 7, 7, 7, 8, 8, 6, 7, 6, 5, 6, 6, 6, 6, 5, 6, 5, 6, 5, 4, 5, 4,
4, 4, 4, 4, 4, 4, 3, 3, 4, 2, 3, 3, 3, 3, 3, 2, 3, 2, 2, 2, 3, 1, 2, 2, 1, 1, 1,
1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 6, 11, -21, -53, -50, -32, -22,
-20, -18, -18, -16, -13, -13, -11, -11, -9, -8, -8, -8, -7, -7, -6, -6, -6, -4,
-4, -4, -3, -3, -2, -2, -1, -1, -1, -1, 0, 0, 0, 1, 1, 1, 2, 2, 2, 3, 3, 3, 3,
4, 3, 4, 4, 4, 5, 5, 4, 5, 5, 5, 5, 5, 6, 6, 6, 5, 6, 5, 5, 6, 5, 6, 6, 5, 5, 6,
6, 5, 6, 5, 5, 5, 6, 6, 5, 5, 5, 5, 5, 4, 4, 5, 4, 4, 5, 4, 5, 4, 4, 4, 4, 4, 4,
3, 3, 3, 3, 4, 4, 2, 3, 3, 3, 2, 2, 2, 2, 2, 3, 2, 2, 1, 2, 2, 1, 1, 1, 0, 1,
-6, -33, -44, -29, -18, -15, -14, -11, -9, -7, -5, -4, -4, -3, -2, -1, -1, 0, 0,
1, 1, 2, 2, 2, 2, 4, 3, 4, 4, 3, 4, 5, 4, 5, 5, 5, 5, 5, 6, 5, 5, 5, 6, 6, 7, 5,
6, 6, 6, 6, 5, 6, 6, 6, 5, 6, 5, 5, 6, 5, 5, 6, 6, 5, 5, 5, 5, 5, 5, 4, 5, 4, 4,
4, 4, 3, 4, 3, 3, 3, 3, 3, 2, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 0, 2, 1, 1, 1, 1, 0,
1, 1, 1, 0, 0, -1, 0, -1, 0, -1, -1, 0, 0, 0, -1, -1, -1, -1, -2, 0, -1, 0, -1,
-1, -2, -2, -2, -1, };