#define DATA_LENGTH 512
#define DATA AKWF_0338

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 17, 21, 25, 30, 34, 38, 41,
44, 47, 50, 52, 55, 56, 59, 60, 63, 65, 67, 68, 70, 71, 75, 75, 78, 80, 82, 85,
87, 89, 91, 94, 97, 99, 101, 102, 104, 105, 107, 107, 106, 106, 105, 105, 104,
103, 102, 101, 100, 98, 96, 95, 94, 93, 92, 92, 90, 90, 90, 90, 89, 89, 89, 89,
90, 91, 90, 91, 91, 91, 91, 91, 90, 90, 90, 88, 88, 87, 87, 86, 86, 85, 85, 84,
84, 83, 83, 83, 83, 84, 84, 84, 86, 87, 86, 88, 89, 91, 90, 91, 90, 90, 87, 86,
83, 79, 76, 71, 67, 62, 58, 53, 47, 43, 37, 33, 28, 24, 19, 15, 11, 7, 3, 1, -3,
-6, -8, -11, -12, -14, -17, -19, -21, -23, -24, -27, -29, -31, -33, -37, -38,
-41, -44, -45, -47, -50, -51, -53, -55, -56, -57, -58, -59, -60, -60, -60, -60,
-61, -61, -60, -59, -60, -60, -60, -59, -61, -61, -63, -64, -65, -68, -70, -72,
-74, -77, -79, -82, -84, -87, -88, -91, -92, -95, -97, -98, -99, -100, -100,
-101, -103, -103, -103, -103, -103, -104, -104, -104, -104, -106, -107, -107,
-108, -109, -109, -111, -112, -112, -114, -115, -116, -116, -117, -118, -118,
-120, -118, -119, -119, -119, -118, -117, -117, -116, -116, -115, -114, -113,
-111, -109, -106, -104, -102, -98, -95, -91, -87, -83, -79, -75, -70, -66, -61,
-56, -52, -46, -42, -38, -32, -27, -22, -17, -12, -7, -2, 2, 7, 12, 17, 22, 27,
31, 35, 38, 41, 45, 47, 50, 52, 55, 58, 59, 62, 63, 64, 66, 68, 70, 72, 74, 76,
78, 80, 82, 84, 87, 89, 92, 94, 97, 98, 101, 103, 104, 106, 107, 107, 107, 107,
106, 105, 104, 103, 102, 100, 100, 98, 96, 95, 94, 93, 93, 91, 90, 91, 89, 90,
90, 89, 90, 90, 90, 91, 90, 91, 91, 91, 91, 91, 90, 90, 90, 88, 88, 88, 86, 87,
85, 84, 84, 84, 83, 83, 83, 83, 83, 84, 84, 85, 85, 87, 87, 88, 89, 91, 90, 91,
91, 89, 88, 86, 82, 79, 75, 72, 67, 62, 57, 52, 47, 42, 36, 32, 28, 23, 18, 15,
11, 7, 4, 0, -3, -6, -8, -10, -13, -15, -18, -19, -22, -22, -25, -28, -29, -32,
-34, -37, -39, -41, -44, -46, -47, -49, -52, -53, -55, -56, -58, -58, -59, -59,
-60, -61, -60, -60, -61, -60, -60, -60, -59, -60, -60, -60, -61, -63, -63, -65,
-68, -70, -72, -74, -76, -80, -82, -84, -87, -89, -91, -93, -95, -96, -97, -99,
-100, -102, -102, -103, -103, -103, -104, -104, -104, -104, -104, -106, -105,
-106, -107, -109, -109, -110, -111, -111, -112, -114, -115, -115, -117, -117,
-118, -118, -119, -119, -119, -119, -118, -118, -118, -117, -116, -116, -115,
-113, -113, -110, -109, -107, -103, -101, -98, -95, -91, -87, -83, -79, -73,
-70, -65, -61, -56, -51, -46, -41, -36, -32, -27, -22, -16, -12, -6, -2, };