#define DATA_LENGTH 512
#define DATA AKWF_0375

const PROGMEM int8_t DATA[DATA_LENGTH] = {39, 46, 43, 45, 45, 45, 44, 44, 44,
44, 44, 44, 44, 44, 44, 46, 41, 109, 124, 116, 121, 116, 121, 118, 120, 118,
120, 117, 120, 118, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 120, 120,
118, 119, 119, 119, 118, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119, 119,
119, 119, 118, 119, 118, 119, 120, 119, 118, 118, 118, 119, 119, 119, 119, 119,
118, 118, 118, 118, 119, 118, 118, 118, 118, 119, 118, 119, 119, 118, 119, 118,
118, 119, 118, 118, 118, 118, 118, 118, 118, 119, 118, 118, 118, 118, 118, 118,
118, 118, 118, 118, 117, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 117,
119, 118, 118, 117, 118, 117, 118, 118, 117, 118, 118, 117, 117, 119, 116, 119,
115, 120, 112, 126, 82, 34, 48, 40, 45, 40, 43, 41, 43, 42, 43, 43, 43, 43, 42,
42, 43, 43, 43, 43, 42, 43, 42, 42, 43, 43, 43, 43, 42, 42, 43, 42, 42, 42, 42,
41, 42, 42, 42, 42, 42, 42, 42, 42, 42, 43, 43, 43, 43, 42, 43, 42, 42, 43, 42,
42, 42, 42, 43, 42, 42, 43, 43, 41, 42, 41, 42, 42, 42, 42, 42, 41, 42, 43, 42,
43, 42, 43, 43, 42, 42, 41, 42, 42, 42, 42, 43, 42, 41, 41, 43, 42, 42, 43, 43,
42, 42, 41, 42, 42, 42, 41, 42, 41, 43, 41, 42, 42, 41, 42, 42, 41, 42, 42, 41,
43, 41, 43, 39, 45, 37, 51, 4, -42, -29, -36, -31, -34, -32, -34, -32, -33, -33,
-33, -33, -32, -33, -32, -33, -33, -33, -33, -34, -32, -33, -32, -33, -33, -33,
-34, -34, -32, -33, -33, -33, -33, -32, -33, -34, -32, -33, -32, -33, -32, -34,
-33, -33, -33, -33, -33, -33, -32, -33, -34, -33, -33, -32, -34, -31, -36, -26,
-77, -113, -104, -111, -105, -109, -106, -108, -107, -108, -106, -108, -108,
-108, -106, -107, -107, -107, -108, -107, -107, -107, -107, -108, -108, -107,
-107, -107, -107, -107, -107, -107, -108, -108, -107, -107, -107, -107, -107,
-107, -108, -107, -107, -107, -107, -107, -107, -107, -107, -107, -107, -107,
-106, -106, -107, -107, -106, -106, -107, -107, -106, -107, -106, -106, -107,
-107, -107, -106, -106, -106, -106, -106, -107, -106, -106, -107, -106, -107,
-106, -107, -106, -106, -106, -106, -106, -106, -106, -106, -107, -107, -106,
-107, -106, -106, -107, -107, -107, -106, -107, -107, -107, -106, -106, -106,
-106, -106, -106, -106, -106, -106, -106, -106, -105, -106, -106, -106, -106,
-106, -107, -106, -106, -106, -106, -106, -106, -105, -106, -106, -106, -107,
-106, -106, -105, -106, -106, -106, -106, -106, -106, -106, -106, -105, -106,
-106, -106, -106, -106, -105, -105, -105, -106, -106, -106, -105, -105, -105,
-106, -105, -105, -105, -105, -105, -106, -106, -104, -106, -104, -108, -103,
-108, -100, -113, -79, -23, -35, -28, -32, -30, -31, -30, -30, -32, -30, -30,
-29, -33, -28, -33, -25, };