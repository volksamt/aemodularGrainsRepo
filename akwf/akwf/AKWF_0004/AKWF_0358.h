#define DATA_LENGTH 512
#define DATA AKWF_0358

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 47, 77, 83, 95, 106, 105, 96, 97,
106, 111, 101, 89, 79, 72, 64, 63, 68, 76, 79, 77, 71, 63, 53, 40, 31, 23, 15,
8, 2, -6, -18, -7, 11, 8, 1, 9, 25, 26, 19, 15, 18, 16, 7, -1, -4, -9, -16, -25,
-29, -33, -33, -38, -40, -41, -42, -45, -48, -50, -50, -50, -67, -71, -73, -46,
-12, -9, -18, -19, -13, -16, -16, -6, 15, 31, 35, 34, 32, 30, 27, 27, 32, 40,
43, 42, 39, 35, 31, 29, 28, 28, 30, 28, 25, 18, 4, 13, 24, 15, 0, 3, 14, 12, 2,
0, 4, 6, 2, -1, 2, 2, -1, -6, -7, -9, -9, -14, -15, -17, -16, -20, -20, -57,
-66, -40, -71, -75, -60, -24, 16, 29, 24, 21, 21, 9, -5, -9, -2, -2, -9, -19,
-23, -24, -22, -15, 0, 16, 28, 34, 37, 36, 33, 29, 24, 21, 18, 13, 9, 2, -11, 2,
16, 12, 3, 12, 25, 24, 17, 12, 15, 14, 7, 1, 0, -1, -5, -8, -8, -7, -5, -5, -4,
-2, 1, -2, -3, -4, -6, -8, -26, -33, -38, -14, 13, 10, -5, -11, -12, -20, -27,
-21, -5, 4, 5, -1, -3, -7, -11, -13, -7, 1, 5, 5, 4, 3, 3, 2, 5, 9, 13, 14, 13,
9, -3, 9, 21, 13, -2, 6, 14, 15, 3, 3, 7, 10, 5, 5, 5, 8, 5, 2, 1, 2, 1, -66,
-54, -59, -39, -17, -35, -77, -93, -57, -80, -65, -44, 0, 42, 63, 65, 70, 76,
66, 52, 48, 55, 51, 40, 24, 14, 4, -3, -6, 1, 8, 12, 9, 5, -2, -10, -19, -25,
-30, -33, -36, -37, -41, -48, -28, -9, -8, -10, 7, 25, 31, 28, 30, 37, 38, 33,
28, 28, 25, 21, 15, 12, 10, 9, 6, 4, 2, 1, -3, -8, -12, -13, -18, -37, -42, -45,
-19, 8, 6, -5, -9, -7, -13, -17, -9, 10, 21, 21, 16, 13, 7, 3, 1, 4, 10, 12, 8,
5, 2, -3, -6, -5, -4, -3, -4, -4, -11, -22, -8, 3, -8, -16, -10, 2, 2, -4, -4,
3, 7, 5, 5, 11, 13, 11, 8, 10, 10, 9, 7, 8, 7, 8, 3, 3, -39, -38, -17, -51, -51,
-36, 2, 37, 46, 40, 36, 34, 19, 4, -1, 4, 2, -8, -19, -24, -27, -27, -22, -8, 7,
18, 22, 23, 21, 17, 11, 7, 2, 1, -6, -10, -18, -28, -13, 0, -5, -12, -1, 13, 12,
5, 3, 8, 7, 1, -3, -2, -2, -5, -8, -5, -3, 0, 1, 5, 7, 10, 8, 9, 8, 8, 3, -15,
-21, -24, 3, 27, 21, 6, 0, -1, -11, -17, -10, 6, 12, 12, 5, 0, -5, -9, -11, -5,
0, 4, 2, 1, -1, -3, -4, -3, 1, 5, 4, 4, -2, -12, 2, 10, 1, -12, -3, 5, 6, -34,
-98, -92, -49, -62, -80, -73, -37, -22, -23, -33, -35, -49, -117, -105, -117,
-88, -65, -75, -112, -108, -70, -87, -64, -36, };