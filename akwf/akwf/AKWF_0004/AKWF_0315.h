#define DATA_LENGTH 512
#define DATA AKWF_0315

const PROGMEM int8_t DATA[DATA_LENGTH] = {19, 55, 73, 90, 96, 95, 86, 73, 56,
41, 24, 11, -1, -10, -17, -22, -24, -24, -24, -23, -20, -18, -15, -12, -9, -7,
-4, -2, -1, 1, 3, 3, 4, 5, 5, 5, 5, 5, 4, 3, 3, 2, 0, 0, 0, 0, -2, -2, -2, -2,
-2, -2, -2, -2, -2, -1, -1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 0, -1,
0, 1, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0,
0, -1, 1, 1, 1, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 1, -1, 1, -2, 1, -2, 3, -3, 5,
-24, -51, -28, -18, 7, 17, 29, 31, 31, 25, 18, 10, 2, -5, -9, -11, -13, -10, -9,
-6, -4, -1, 1, 3, 5, 5, 5, 5, 4, 3, 2, 2, 0, 0, 0, -2, -2, -2, -2, -2, -1, -1,
-1, -2, -1, -1, -1, -1, -1, 0, 0, -1, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, -1, 0, 0, 1, 0, 0, 0, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 1, 1,
0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, -1, 1, -1, 0, 0, 0, 0, 0, 0, -1, 0,
-1, -7, -21, -39, -60, -76, -92, -99, -105, -101, -101, -82, -103, -114, -78,
-53, -18, 4, 24, 35, 40, 37, 33, 25, 18, 14, 9, 8, 8, 11, 15, 22, 28, 36, 42,
51, 56, 63, 66, 71, 73, 74, 75, 73, 72, 70, 67, 63, 58, 52, 47, 41, 34, 28, 22,
15, 9, 3, -2, -7, -12, -17, -20, -22, -26, -28, -29, -30, -30, -31, -30, -30,
-29, -28, -27, -25, -22, -20, -19, -17, -15, -13, -11, -9, -6, -5, -4, -2, 0, 1,
2, 3, 4, 6, 6, 8, 8, 8, 8, 9, 8, 9, 8, 8, 8, 8, 7, 6, 6, 5, 5, 5, 4, 3, 2, 2, 2,
0, 1, 0, 0, -1, -1, -2, -1, -2, -2, -2, -2, -2, -2, -2, -3, -1, -3, -1, -3, 1,
-5, 5, -30, -50, -28, -16, 7, 17, 30, 30, 30, 24, 17, 9, 2, -5, -10, -11, -12,
-10, -9, -6, -4, 0, 2, 3, 4, 6, 5, 6, 4, 4, 2, 2, 1, 0, -1, -1, -2, -1, -2, -1,
-2, -1, -1, -2, 0, -1, -1, -1, -1, -1, -1, -1, 0, -1, -1, -1, 0, -1, 0, -1, 0,
-1, 0, -1, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, 1, 1, 1, 0, 1, -1, 1, 0, -1, 1,
0, 1, 0, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 1, 1, 1, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0,
0, 0, 1, 0, -1, -8, -20, -35, -48, -56, -62, -61, -58, -46, -38, -14, -35, -36,
1, };