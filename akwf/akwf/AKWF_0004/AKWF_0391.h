#define DATA_LENGTH 512
#define DATA AKWF_0391

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 7, 10, 13, 16, 20, 22, 25, 27,
30, 32, 35, 38, 39, 42, 43, 45, 48, 49, 51, 53, 55, 56, 58, 59, 61, 62, 63, 64,
65, 67, 67, 68, 69, 70, 71, 72, 74, 73, 75, 76, 75, 76, 77, 78, 78, 78, 79, 80,
80, 81, 81, 83, 82, 83, 84, 84, 85, 85, 85, 86, 86, 86, 87, 86, 86, 88, 87, 88,
88, 88, 89, 89, 90, 89, 91, 90, 90, 91, 90, 91, 91, 92, 91, 93, 92, 93, 93, 94,
93, 93, 93, 94, 94, 95, 94, 95, 94, 94, 95, 95, 95, 96, 96, 96, 96, 96, 97, 97,
98, 97, 97, 97, 98, 98, 98, 98, 99, 98, 99, 98, 99, 99, 99, 99, 100, 99, 76, 74,
76, 74, 75, 75, 75, 75, 76, 75, 76, 76, 77, 76, 76, 76, 77, 77, 77, 77, 78, 77,
78, 78, 77, 77, 79, 79, 78, 78, 78, 78, 79, 79, 79, 80, 79, 78, 79, 80, 79, 80,
79, 79, 80, 79, 80, 79, 80, 80, 80, 79, 81, 81, 80, 81, 80, 80, 81, 81, 79, 80,
80, 80, 80, 79, 79, 80, 79, 80, 80, 79, 79, 79, 79, 79, 78, 79, 78, 77, 78, 77,
77, 77, 77, 76, 76, 75, 74, 75, 74, 74, 73, 72, 72, 71, 70, 70, 69, 67, 67, 66,
65, 65, 64, 61, 60, 59, 58, 56, 56, 53, 53, 51, 48, 47, 46, 42, 41, 38, 37, 34,
32, 29, 28, 23, 23, 17, -16, -20, -21, -25, -27, -31, -31, -35, -36, -40, -41,
-44, -45, -47, -48, -51, -53, -54, -55, -57, -58, -60, -60, -63, -64, -65, -66,
-67, -68, -67, -70, -69, -71, -71, -73, -73, -74, -74, -75, -75, -75, -76, -76,
-77, -77, -78, -77, -77, -78, -78, -77, -78, -78, -79, -79, -79, -80, -80, -79,
-80, -79, -81, -80, -80, -80, -80, -79, -80, -80, -80, -80, -80, -81, -80, -80,
-80, -79, -80, -79, -80, -80, -80, -79, -79, -80, -79, -80, -79, -79, -79, -80,
-79, -78, -79, -78, -78, -78, -79, -78, -78, -78, -77, -78, -78, -78, -77, -77,
-77, -78, -77, -77, -76, -77, -76, -76, -76, -76, -76, -75, -75, -75, -76, -75,
-76, -74, -75, -73, -76, -100, -100, -100, -100, -99, -99, -99, -100, -99, -98,
-98, -98, -98, -98, -97, -97, -97, -97, -96, -97, -97, -97, -96, -95, -96, -96,
-95, -95, -95, -95, -95, -94, -95, -94, -95, -94, -93, -93, -93, -93, -93, -93,
-93, -92, -92, -92, -92, -91, -91, -91, -90, -90, -91, -90, -90, -89, -89, -89,
-88, -89, -87, -87, -87, -86, -86, -86, -86, -85, -85, -85, -84, -84, -83, -83,
-82, -82, -81, -81, -81, -80, -79, -79, -78, -78, -77, -76, -76, -74, -74, -73,
-73, -72, -72, -70, -69, -68, -67, -66, -65, -63, -63, -62, -60, -58, -57, -56,
-54, -52, -51, -49, -47, -45, -43, -42, -39, -36, -34, -32, -30, -27, -25, -21,
-19, -15, -13, -10, -7, -3, };