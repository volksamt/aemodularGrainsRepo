#define DATA_LENGTH 512
#define DATA AKWF_0302

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 24, 30, 36, 38, 40, 41, 39, 36,
34, 31, 27, 22, 19, 15, 13, 8, 5, 2, 0, -3, -4, -5, -9, -9, -11, -10, -11, -12,
-13, -13, -12, -13, -12, -11, -12, -11, -10, -10, -9, -8, -8, -7, -7, -6, -4,
-4, -4, -3, -2, -2, -2, -2, -1, 0, 0, 0, 0, 0, 1, 1, 2, 1, 1, 2, 1, 1, 2, 2, 2,
2, 2, 1, 2, 1, 2, 2, 2, 2, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 0, 1, 1, 1, 1, 0, 1, 1,
0, 1, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, -1, -1, -1, 0, 0, 1, 0,
1, 0, 0, 0, 1, 0, -1, 0, 0, -1, 0, 0, 0, 0, -1, -1, 0, 0, 0, -1, 0, 1, 1, 0, 0,
1, 0, 1, 0, -1, 0, -1, 0, -1, -1, -1, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0, 0, 1, 0,
0, 0, 1, -1, 0, 1, 0, 0, 0, 0, 1, 0, 0, -1, -1, 0, 0, 0, 0, 0, -1, 1, 0, -1, 0,
0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 1, 0, 0, -1, 1, 0, -1, 0, 0,
1, 1, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 1, -1, 1, 0,
0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0,
0, 0, 1, 0, 0, 0, 0, 1, 1, 0, 1, 0, -1, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 0, 0, 0,
1, 1, 0, 0, 0, 0, 0, 0, 0, 1, -1, -1, 0, 0, 0, 1, 0, -1, 0, 0, -1, -1, -1, 0, 0,
0, 0, 1, 0, 0, 0, -1, 0, 0, -1, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, -1, 0, 1,
0, 0, -1, 0, 0, 1, 1, 1, 0, 1, 0, 0, 1, 1, 0, 1, 0, -1, 0, 0, 0, 0, 1, 0, 0, 1,
0, 0, 0, 0, 1, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 1, 0, 0,
0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, -1, 0, 1, -1, 0, -1, 1, -1, 1, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, -1, 0, -2, 1, -3, 2, -2, 4, -5, 5, -7, 13,
-33, -119, -64, -43, -16, -1, };