#define DATA_LENGTH 512
#define DATA AKWF_0307

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 1, -1, -7, -16, -27, -40, -53,
-65, -78, -88, -98, -105, -111, -113, -115, -113, -110, -103, -95, -86, -75,
-61, -49, -34, -19, -5, 10, 25, 39, 53, 65, 76, 86, 95, 103, 109, 114, 117, 119,
119, 117, 116, 112, 107, 102, 96, 89, 82, 73, 65, 57, 48, 39, 30, 22, 13, 6, -2,
-8, -15, -21, -25, -30, -33, -37, -39, -41, -42, -44, -44, -44, -43, -41, -39,
-37, -35, -32, -30, -27, -24, -21, -18, -16, -13, -10, -7, -4, -2, 1, 3, 4, 7,
8, 8, 10, 10, 12, 12, 12, 13, 12, 12, 12, 12, 11, 11, 10, 9, 9, 7, 7, 5, 4, 4,
3, 2, 2, 1, 0, 0, -1, -1, -2, -3, -2, -2, -3, -4, -3, -4, -4, -3, -3, -3, -3,
-4, -2, -3, -2, -2, -2, -1, -2, -1, -1, -1, 0, -1, 0, 0, 0, 1, 0, 0, 1, 1, 1, 1,
1, 1, 1, 1, 1, 2, 0, 1, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, -1, 0, -1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0, 0,
-1, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, 1, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1,
1, -1, 0, 0, 1, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 1, 1, -1, 0, 0, 0, 0, 0, 1, 0, 0,
0, 0, 1, -1, 1, 0, 1, 0, -1, 0, 0, 1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, -1, 0, 0, 1, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0,
0, 0, -1, 0, 1, 0, 0, 1, 0, 1, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, -1,
-1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 1, -1, 0, 0, 0,
0, -1, 1, 1, 0, 0, 0, 0, 0, -1, -1, 0, -1, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0,
1, 0, 0, 1, -1, -1, 0, 0, -1, 1, 0, 0, 1, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
-1, -1, 0, 1, -1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, -1, 0, 0, 1, 0, -1, 0, 0, 0, };