#define DATA_LENGTH 512
#define DATA AKWF_0334

const PROGMEM int8_t DATA[DATA_LENGTH] = {-4, -10, -15, -19, -23, -26, -29, -31,
-33, -35, -37, -37, -40, -40, -41, -42, -42, -44, -44, -44, -45, -45, -46, -46,
-47, -47, -47, -47, -47, -47, -47, -48, -48, -48, -48, -48, -48, -48, -47, -48,
-48, -48, -48, -48, -48, -48, -48, -49, -49, -48, -49, -49, -49, -49, -48, -48,
-48, -48, -49, -48, -48, -48, -48, -48, -48, -48, -48, -48, -49, -49, -48, -48,
-48, -48, -49, -48, -47, -48, -48, -48, -49, -48, -48, -48, -49, -48, -48, -49,
-48, -48, -49, -48, -48, -48, -49, -48, -48, -48, -47, -49, -48, -49, -48, -48,
-48, -48, -48, -48, -48, -48, -47, -48, -49, -49, -48, -51, -58, -66, -73, -79,
-85, -89, -93, -96, -99, -101, -103, -105, -107, -108, -109, -111, -112, -113,
-114, -114, -115, -116, -116, -116, -117, -117, -118, -117, -118, -117, -118,
-119, -118, -119, -118, -118, -119, -119, -118, -119, -118, -118, -119, -119,
-119, -118, -120, -119, -119, -119, -118, -120, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -118, -118, -119, -120, -120, -120, -120, -118,
-119, -120, -119, -120, -119, -120, -119, -119, -119, -118, -118, -119, -119,
-119, -119, -119, -118, -118, -119, -119, -120, -119, -118, -119, -119, -119,
-120, -119, -119, -119, -119, -120, -119, -119, -118, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-117, -101, -77, -51, -28, -8, 7, 22, 33, 44, 54, 62, 69, 75, 81, 86, 89, 93,
97, 99, 101, 104, 106, 108, 109, 110, 111, 112, 113, 114, 115, 115, 115, 115,
116, 116, 117, 118, 117, 118, 118, 118, 117, 118, 117, 118, 118, 119, 119, 119,
118, 119, 119, 119, 119, 120, 119, 118, 119, 119, 119, 118, 119, 120, 119, 118,
119, 119, 119, 119, 118, 119, 118, 118, 119, 119, 119, 119, 118, 119, 119, 118,
119, 119, 120, 119, 119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 119, 120,
120, 120, 119, 119, 119, 119, 119, 119, 120, 118, 118, 119, 119, 119, 118, 119,
119, 119, 120, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119,
119, 118, 118, 115, 108, 99, 93, 88, 83, 78, 74, 72, 68, 66, 64, 62, 60, 58, 56,
56, 54, 53, 53, 52, 52, 51, 51, 51, 51, 50, 50, 50, 49, 49, 49, 50, 49, 49, 49,
49, 49, 49, 49, 48, 48, 48, 48, 48, 48, 49, 48, 47, 49, 48, 48, 49, 49, 48, 48,
48, 48, 48, 48, 49, 49, 48, 48, 48, 48, 48, 48, 49, 48, 48, 48, 48, 48, 48, 49,
49, 48, 48, 48, 48, 48, 48, 49, 48, 48, 48, 48, 49, 49, 49, 48, 48, 48, 49, 48,
47, 49, 48, 48, 48, 48, 49, 48, 48, 48, 48, 48, 49, 48, 49, 49, 48, 48, 48, 48,
49, 48, 48, 48, 48, 47, 47, 49, 54, 61, 70, 76, 81, 85, 90, 93, 90, 78, 62, 46,
35, 23, 15, 7, 1, };