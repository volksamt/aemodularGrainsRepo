#define DATA_LENGTH 512
#define DATA AKWF_0324

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 4, 7, 8, 11, 11, 14, 14, 16,
18, 20, 21, 22, 24, 25, 26, 26, 28, 30, 30, 31, 32, 32, 33, 34, 35, 36, 35, 36,
37, 37, 37, 37, 39, 38, 38, 39, 39, 40, 39, 40, 40, 39, 41, 41, 40, 40, 41, 41,
42, 41, 42, 42, 43, 43, 44, 46, 47, 50, 52, 54, 57, 59, 61, 64, 66, 68, 69, 72,
74, 75, 77, 78, 80, 80, 82, 82, 83, 85, 85, 86, 86, 87, 87, 87, 88, 89, 88, 89,
88, 89, 89, 88, 89, 88, 88, 88, 87, 86, 87, 87, 86, 85, 85, 84, 84, 84, 84, 83,
84, 84, 84, 85, 85, 87, 87, 88, 89, 91, 91, 93, 95, 96, 98, 100, 101, 102, 104,
105, 106, 107, 107, 107, 108, 110, 110, 110, 110, 110, 110, 110, 110, 110, 109,
109, 110, 109, 108, 107, 107, 107, 107, 107, 106, 104, 104, 103, 102, 101, 101,
99, 98, 98, 97, 95, 94, 93, 93, 92, 90, 89, 89, 87, 87, 85, 85, 84, 83, 82, 81,
80, 79, 79, 79, 79, 80, 81, 81, 83, 84, 86, 87, 87, 88, 90, 90, 91, 91, 92, 93,
94, 93, 93, 93, 93, 94, 93, 93, 91, 91, 92, 90, 89, 89, 88, 87, 85, 86, 84, 83,
82, 81, 80, 78, 77, 76, 74, 73, 73, 70, 69, 68, 68, 66, 65, 65, 65, 64, 63, 63,
63, 63, 63, 63, 61, 59, 55, 52, 46, 40, 34, 28, 22, 15, 9, 3, -4, -9, -15, -20,
-25, -30, -35, -39, -43, -48, -51, -55, -59, -62, -66, -70, -74, -76, -78, -82,
-85, -87, -89, -91, -92, -94, -97, -98, -100, -102, -103, -103, -105, -106,
-107, -108, -109, -110, -111, -112, -112, -114, -114, -115, -115, -116, -117,
-117, -117, -118, -119, -119, -119, -118, -119, -119, -118, -116, -115, -113,
-110, -109, -108, -105, -104, -102, -100, -98, -98, -95, -95, -93, -92, -91,
-91, -90, -89, -88, -87, -87, -87, -86, -86, -86, -87, -86, -86, -85, -86, -86,
-86, -87, -87, -87, -87, -88, -89, -88, -89, -89, -90, -90, -90, -91, -92, -92,
-91, -92, -93, -93, -95, -96, -98, -98, -99, -101, -103, -104, -105, -107, -107,
-107, -108, -107, -107, -107, -105, -106, -105, -104, -103, -102, -101, -101,
-100, -100, -99, -97, -97, -97, -95, -95, -95, -94, -93, -93, -92, -92, -91,
-91, -91, -90, -90, -91, -89, -89, -89, -89, -88, -89, -88, -88, -89, -88, -88,
-88, -87, -87, -87, -86, -87, -86, -86, -85, -85, -85, -84, -84, -84, -82, -83,
-81, -81, -79, -78, -76, -74, -70, -67, -65, -61, -59, -56, -54, -51, -49, -47,
-45, -42, -40, -38, -35, -34, -32, -30, -29, -28, -26, -25, -23, -22, -21, -20,
-19, -18, -17, -16, -16, -15, -14, -13, -12, -11, -11, -10, -10, -9, -8, -8, -7,
-6, -6, -5, -4, -4, -4, -6, -5, -5, -5, -5, -7, -7, -8, -9, -9, -9, -9, -9, -8,
-6, -4, -3, -2, };