#define DATA_LENGTH 512
#define DATA AKWF_0400

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 10, 15, 17, 18, 18, 19,
21, 20, 21, 18, 15, 15, 15, 14, 12, 16, 18, 18, 23, 27, 29, 28, 26, 25, 25, 26,
25, 26, 28, 27, 27, 28, 30, 31, 33, 34, 36, 37, 37, 37, 34, 33, 32, 28, 26, 21,
17, 18, 18, 17, 17, 17, 19, 22, 25, 29, 32, 35, 36, 36, 35, 37, 39, 42, 44, 45,
47, 49, 51, 53, 52, 52, 52, 55, 57, 60, 63, 66, 69, 69, 69, 70, 70, 70, 72, 73,
75, 77, 80, 84, 89, 90, 88, 86, 82, 80, 77, 76, 73, 71, 70, 68, 64, 63, 61, 60,
60, 57, 54, 54, 52, 50, 50, 51, 54, 54, 56, 58, 59, 60, 61, 62, 63, 64, 66, 66,
65, 66, 66, 66, 67, 70, 72, 76, 80, 82, 83, 85, 87, 88, 91, 91, 94, 96, 97, 98,
100, 99, 98, 94, 93, 93, 94, 95, 94, 92, 92, 95, 97, 102, 106, 112, 116, 119,
119, 118, 115, 113, 111, 113, 110, 109, 103, 103, 98, 99, 90, 13, -22, -38, -51,
-55, -60, -60, -65, -65, -67, -68, -69, -68, -70, -69, -69, -67, -68, -68, -69,
-70, -71, -72, -73, -75, -75, -75, -75, -77, -77, -77, -77, -80, -83, -87, -92,
-93, -93, -94, -95, -92, -90, -89, -90, -93, -95, -100, -102, -104, -105, -105,
-105, -105, -103, -99, -97, -94, -91, -90, -90, -89, -89, -90, -89, -88, -85,
-82, -78, -72, -67, -68, -69, -73, -76, -75, -76, -78, -78, -78, -77, -77, -76,
-74, -72, -72, -69, -70, -70, -70, -73, -73, -73, -69, -64, -62, -61, -59, -57,
-54, -51, -49, -47, -48, -48, -51, -53, -51, -50, -52, -55, -56, -56, -56, -57,
-59, -59, -59, -59, -58, -60, -62, -66, -68, -70, -73, -74, -75, -75, -74, -72,
-69, -69, -71, -70, -69, -68, -65, -62, -58, -55, -53, -50, -43, -37, -33, -30,
-27, -27, -24, -24, -22, -20, -18, -14, -14, -16, -17, -15, -13, -9, -7, -7, -9,
-9, -8, -10, -10, -11, -13, -12, -13, -14, -17, -20, -23, -24, -25, -26, -24,
-24, -22, -21, -18, -14, -10, -11, -14, -15, -13, -11, -5, -1, 4, 7, 10, 15, 16,
19, 22, 24, 26, 26, 28, 28, 30, 28, 26, 23, 21, 20, 18, 18, 17, 15, 14, 13, 12,
11, 11, 9, 8, 9, 9, 9, 8, 8, 9, 10, 7, 6, 5, 3, 2, 2, 0, -4, -8, -11, -15, -18,
-20, -22, -24, -26, -25, -24, -23, -17, -7, -1, 4, 6, 6, 5, 3, 2, -1, -3, -4,
-4, -6, -7, -9, -9, -7, -5, -3, -1, 1, 3, 2, 2, 1, 2, 3, 5, 6, 7, 7, 6, 6, 6, 4,
1, -2, -7, -8, -6, -3, 1, 5, 7, 10, 10, 10, 10, 11, 11, 9, 9, 10, 7, 5, 2, -2,
-5, -5, -6, -5, -5, -4, -1, 2, 3, 7, 10, 12, 13, 14, 12, 8, 6, 4, 1, -2, -5, -5,
-5, -1, 0, -1, };