#define DATA_LENGTH 512
#define DATA AKWF_0351

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 11, 27, 46, 68, 86, 102, 113, 120,
117, 107, 90, 69, 46, 22, 0, -19, -35, -46, -54, -60, -64, -66, -67, -67, -64,
-60, -53, -46, -37, -30, -21, -13, -8, -2, 0, 1, 2, 3, 3, 4, 6, 8, 10, 14, 18,
22, 26, 27, 27, 25, 23, 20, 17, 12, 8, 4, 1, 0, -2, -1, 0, 1, 2, 2, 2, 2, 1, -1,
-4, -7, -12, -15, -20, -25, -28, -32, -34, -34, -33, -29, -26, -20, -13, -5, 2,
11, 20, 28, 34, 40, 44, 43, 42, 40, 34, 26, 19, 11, 2, -5, -12, -17, -21, -24,
-24, -24, -23, -21, -18, -15, -11, -8, -6, -2, 0, 1, 2, 3, 3, 3, 3, 2, 1, 0, -2,
-3, -7, -20, -36, -42, -42, -37, -25, -11, 7, 27, 41, 50, 55, 56, 55, 50, 41,
30, 18, 8, 1, -3, -5, -6, -4, -4, -5, -8, -11, -14, -16, -19, -20, -20, -20,
-20, -21, -22, -24, -25, -27, -27, -27, -25, -21, -15, -9, 0, 8, 18, 25, 31, 36,
38, 37, 35, 31, 27, 22, 17, 12, 9, 7, 4, 3, 3, 2, 3, 2, 2, 0, -2, -4, -7, -11,
-15, -19, -21, -25, -27, -30, -30, -29, -28, -25, -20, -17, -11, -5, 2, 9, 15,
20, 24, 28, 30, 30, 30, 29, 27, 24, 21, 18, 15, 11, 8, 5, 2, 0, -4, -6, -9, -11,
-14, -17, -18, -19, -20, -21, -21, -21, -21, -19, -18, -21, -29, -37, -42, -42,
-41, -35, -21, 1, 23, 45, 62, 76, 87, 91, 88, 80, 67, 52, 36, 19, 3, -10, -20,
-29, -36, -41, -45, -48, -48, -48, -43, -39, -32, -24, -17, -10, -4, -2, -1, -3,
-4, -5, -8, -8, -9, -8, -3, 2, 7, 13, 19, 25, 27, 28, 28, 25, 21, 17, 11, 7, 1,
-2, -5, -8, -7, -7, -6, -3, -1, 1, 3, 5, 6, 6, 5, 3, 0, -4, -9, -14, -19, -22,
-26, -27, -28, -27, -24, -20, -16, -9, -2, 6, 13, 20, 25, 31, 33, 34, 33, 31,
27, 22, 16, 10, 4, -1, -5, -10, -12, -13, -15, -15, -14, -12, -12, -10, -8, -8,
-5, -5, -4, -5, -5, -4, -5, -3, -4, -4, -3, -2, -2, -5, -17, -30, -35, -34, -28,
-16, -1, 17, 33, 45, 51, 54, 53, 49, 41, 30, 18, 6, -4, -11, -15, -15, -14, -11,
-9, -8, -9, -9, -10, -11, -11, -11, -10, -8, -10, -10, -12, -14, -16, -19, -20,
-21, -21, -18, -14, -9, -3, 5, 13, 19, 25, 27, 29, 29, 27, 22, 17, 14, 9, 5, 2,
1, 0, 2, 2, 3, 3, 4, 5, 3, 2, 0, -4, -5, -9, -13, -16, -19, -21, -23, -24, -24,
-23, -21, -18, -13, -9, -3, 2, 8, 13, 17, 20, 22, 23, 24, 23, 21, 18, 16, 14,
11, 9, 6, 4, 2, 1, -2, -2, -4, -5, -7, -9, -17, -28, -40, -52, -56, -56, -53,
-46, -37, -29, -23, -23, -23, -16, -7, };