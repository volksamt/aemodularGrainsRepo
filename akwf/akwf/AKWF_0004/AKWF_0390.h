#define DATA_LENGTH 512
#define DATA AKWF_0390

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 2, 4, 4, 6, 7, 8, 9, 9,
11, 12, 13, 13, 14, 15, 15, 16, 16, 17, 19, 19, 21, 21, 21, 22, 23, 24, 24, 19,
1, -15, -24, -26, -27, -26, -24, -23, -21, -20, -18, -17, -15, -14, -12, -10,
-10, -9, -8, -6, -5, -4, -3, -2, -2, -1, 0, 1, 1, 2, 3, 4, 4, 6, 6, 7, 8, 8, 10,
11, 13, 12, 13, 14, 15, 16, 17, 17, 18, 19, 19, 21, 21, 22, 23, 23, 25, 25, 25,
26, 28, 28, 28, 29, 29, 30, 31, 31, 32, 32, 33, 34, 34, 36, 36, 36, 36, 38, 37,
38, 39, 39, 39, 39, 36, 19, 0, -9, -13, -13, -13, -12, -10, -10, -9, -8, -7, -5,
-4, -4, -3, -2, -1, -1, -1, 0, 2, 2, 4, 3, 4, 5, 6, 7, 7, 8, 9, 10, 11, 11, 13,
13, 14, 15, 15, 16, 17, 18, 19, 20, 20, 21, 21, 23, 23, 23, 24, 25, 26, 26, 27,
27, 28, 28, 29, 29, 30, 30, 32, 32, 32, 33, 33, 33, 34, 34, 35, 35, 36, 37, 37,
37, 38, 37, 39, 39, 40, 40, 40, 39, 26, 4, -6, -12, -13, -14, -13, -12, -11,
-10, -8, -8, -6, -5, -4, -4, -3, -2, -2, 0, -1, 1, 1, 2, 2, 2, 3, 5, 6, 5, 7, 7,
8, 10, 10, 11, 11, 12, 13, 14, 14, 16, 16, 16, 17, 18, 18, 19, 20, 20, 20, 21,
22, 23, 23, 23, 24, 24, 25, 26, 26, 28, 28, 28, 28, 29, 29, 30, 30, 30, 31, 32,
32, 33, 33, 33, 34, 35, 35, 35, 35, 36, 36, 36, 36, 27, 8, -7, -14, -17, -17,
-16, -15, -14, -13, -12, -11, -10, -8, -8, -7, -5, -5, -4, -3, -3, -2, -1, -1,
0, 0, 2, 1, 2, 3, 4, 4, 6, 6, 6, 7, 8, 9, 10, 9, 11, 11, 12, 13, 13, 14, 14, 15,
15, 17, 17, 17, 18, 19, 20, 21, 20, 21, 22, 22, 23, 23, 24, 24, 26, 26, 26, 26,
26, 27, 28, 28, 29, 29, 28, 29, 30, 31, 32, 31, 32, 33, 32, 33, 33, 29, 11, -7,
-16, -20, -20, -20, -19, -18, -18, -15, -14, -13, -13, -10, -10, -9, -8, -8, -6,
-5, -4, -4, -2, -3, -1, -1, 0, 0, 0, 1, 2, 2, 3, 4, 4, 5, 6, 6, 6, 8, 9, -1,
-84, -123, -113, -115, -110, -110, -106, -105, -102, -100, -97, -95, -92, -90,
-87, -86, -83, -81, -79, -76, -74, -70, -68, -66, -65, -62, -60, -58, -56, -54,
-51, -49, -48, -45, -43, -42, -40, -38, -36, -34, -32, -31, -31, -44, -68, -82,
-85, -86, -84, -83, -80, -77, -75, -73, -70, -67, -66, -64, -61, -59, -57, -54,
-52, -50, -48, -45, -43, -41, -39, -37, -35, -34, -32, -31, -28, -27, -25, -23,
-22, -20, -18, -17, -15, -14, -13, -11, -10, -9, -8, -7, -5, -5, -3, -3, -2, -1,
0, };