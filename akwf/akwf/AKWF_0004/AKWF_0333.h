#define DATA_LENGTH 512
#define DATA AKWF_0333

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 21, 32, 44, 53, 61, 68, 75, 81, 85,
89, 93, 97, 99, 102, 103, 106, 107, 110, 110, 111, 112, 113, 114, 115, 115, 116,
116, 117, 117, 117, 117, 118, 118, 118, 118, 118, 118, 119, 118, 118, 118, 118,
119, 118, 119, 119, 118, 120, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119,
119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119,
120, 119, 119, 118, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 120, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 119, 119, 118,
119, 118, 119, 119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119, 119, 119,
119, 120, 119, 119, 118, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 118, 120, 118, 119, 120, 120, 119, 118, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 119,
120, 120, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 120, 118, 119, 118, 119, 118, 118, 119,
119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 116,
101, 75, 49, 26, 8, -8, -22, -34, -44, -54, -62, -70, -75, -81, -86, -90, -94,
-96, -100, -103, -105, -106, -108, -109, -111, -111, -112, -114, -114, -114,
-115, -116, -117, -117, -116, -117, -117, -118, -118, -118, -117, -118, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -118, -119, -120, -119, -118, -118, -119,
-119, -119, -119, -119, -120, -118, -120, -119, -118, -120, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -118, -119, -120, -119, -120,
-120, -119, -119, -120, -119, -120, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -120, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -120, -119, -119, -120, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119,
-118, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -118, -120, -119, -119,
-120, -119, -120, -119, -119, -119, -120, -120, -119, -119, -120, -118, -120,
-119, -119, -119, -120, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -120, -118, -119, -119,
-118, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -114, -98, -72, -46, -25, -6, };