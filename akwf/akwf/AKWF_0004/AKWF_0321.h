#define DATA_LENGTH 512
#define DATA AKWF_0321

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 6, 8, 12, 14, 17, 19, 21, 24,
26, 29, 32, 34, 38, 40, 42, 45, 47, 50, 52, 55, 58, 60, 62, 65, 66, 69, 71, 74,
76, 78, 80, 81, 82, 85, 88, 88, 90, 91, 92, 94, 95, 97, 97, 98, 99, 99, 101,
101, 101, 102, 102, 102, 101, 100, 102, 100, 100, 99, 98, 98, 96, 97, 96, 95,
95, 95, 94, 93, 92, 91, 91, 89, 89, 88, 89, 88, 88, 88, 87, 88, 89, 89, 89, 90,
90, 90, 90, 91, 92, 92, 92, 93, 94, 94, 95, 95, 96, 97, 98, 99, 99, 99, 100,
101, 102, 102, 103, 103, 105, 105, 106, 106, 107, 107, 107, 108, 108, 108, 108,
109, 109, 109, 108, 108, 109, 109, 109, 110, 109, 110, 110, 110, 109, 110, 110,
111, 111, 111, 111, 112, 112, 112, 113, 114, 114, 113, 115, 114, 114, 115, 115,
115, 116, 115, 115, 115, 115, 115, 115, 114, 114, 113, 112, 111, 112, 110, 109,
108, 109, 106, 106, 104, 103, 101, 99, 96, 95, 93, 90, 87, 86, 83, 80, 76, 74,
71, 68, 65, 62, 60, 57, 55, 51, 48, 45, 44, 41, 39, 36, 34, 32, 29, 28, 26, 24,
21, 20, 19, 17, 16, 14, 13, 11, 9, 8, 8, 6, 6, 5, 4, 3, 3, 2, 2, 2, 1, 1, 1, 0,
0, 0, -1, -1, -1, -1, -1, -2, -1, 0, -1, -1, -1, -1, -1, -1, -1, -1, 0, -1, 0,
0, -1, -1, 0, -2, -1, 0, -2, -2, -2, -2, -1, -2, -2, -2, -3, -3, -3, -3, -3, -3,
-3, -4, -3, -3, -4, -3, -4, -5, -5, -5, -6, -6, -7, -8, -9, -10, -11, -12, -12,
-14, -15, -16, -17, -18, -21, -22, -24, -25, -27, -28, -30, -32, -34, -36, -38,
-40, -42, -45, -47, -51, -53, -55, -58, -60, -63, -66, -69, -71, -74, -77, -80,
-82, -85, -87, -90, -92, -93, -96, -98, -99, -101, -102, -104, -105, -107, -108,
-108, -109, -111, -113, -112, -113, -114, -115, -116, -116, -117, -117, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -118, -119, -118,
-117, -117, -117, -118, -117, -116, -117, -118, -117, -117, -117, -118, -119,
-117, -117, -118, -118, -117, -117, -117, -118, -117, -117, -117, -117, -115,
-115, -114, -113, -114, -112, -111, -111, -110, -110, -109, -108, -107, -106,
-105, -104, -103, -103, -102, -101, -100, -100, -97, -97, -96, -95, -95, -93,
-93, -92, -92, -91, -91, -91, -90, -90, -90, -90, -89, -90, -88, -88, -89, -88,
-89, -88, -89, -89, -89, -89, -89, -90, -91, -91, -92, -93, -94, -95, -95, -97,
-97, -98, -100, -100, -100, -101, -102, -103, -104, -103, -104, -103, -103,
-103, -102, -102, -101, -100, -100, -99, -98, -97, -96, -95, -93, -93, -91, -89,
-86, -85, -84, -81, -79, -77, -76, -73, -71, -69, -66, -64, -62, -59, -57, -53,
-51, -48, -44, -42, -39, -37, -34, -31, -28, -26, -21, -18, -17, -13, -10, -8,
-4, -1, };