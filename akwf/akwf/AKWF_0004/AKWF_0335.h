#define DATA_LENGTH 512
#define DATA AKWF_0335

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 15, 20, 24, 29, 34, 37, 41, 44,
47, 50, 53, 57, 61, 65, 68, 71, 75, 78, 81, 82, 84, 86, 87, 87, 88, 87, 89, 89,
90, 91, 90, 90, 91, 91, 91, 89, 89, 88, 87, 87, 85, 85, 85, 86, 86, 89, 90, 92,
92, 94, 95, 97, 98, 99, 98, 98, 99, 98, 99, 99, 100, 98, 99, 99, 98, 96, 94, 93,
91, 88, 85, 82, 78, 76, 72, 70, 69, 66, 65, 62, 60, 57, 55, 52, 49, 45, 42, 38,
34, 30, 27, 24, 21, 18, 16, 13, 11, 7, 5, 2, 0, -3, -4, -7, -9, -10, -11, -10,
-10, -8, -7, -5, -3, -1, 2, 4, 6, 7, 8, 10, 11, 13, 15, 17, 19, 21, 23, 24, 25,
26, 26, 26, 26, 26, 25, 24, 22, 21, 20, 20, 19, 19, 19, 18, 17, 16, 16, 13, 11,
9, 6, 2, 0, -4, -7, -10, -13, -15, -19, -21, -25, -28, -32, -35, -38, -42, -46,
-49, -53, -56, -58, -60, -61, -61, -62, -63, -63, -63, -64, -64, -64, -67, -66,
-68, -68, -70, -72, -71, -72, -73, -73, -74, -76, -77, -79, -80, -83, -85, -88,
-91, -94, -96, -98, -99, -100, -102, -102, -103, -104, -105, -106, -107, -109,
-109, -111, -114, -115, -117, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -117, -117, -116, -115, -113, -110, -107, -103, -100, -94, -89, -84,
-77, -72, -65, -60, -54, -49, -42, -37, -32, -27, -20, -13, -7, -1, 5, 11, 15,
20, 25, 30, 34, 38, 40, 44, 46, 50, 54, 57, 60, 65, 68, 72, 75, 77, 80, 82, 85,
86, 86, 87, 87, 88, 89, 89, 90, 90, 91, 91, 91, 91, 90, 90, 90, 88, 87, 86, 86,
86, 85, 86, 87, 88, 90, 92, 94, 94, 96, 98, 98, 99, 99, 100, 98, 99, 99, 99, 99,
99, 99, 99, 97, 96, 94, 93, 91, 88, 86, 82, 78, 76, 72, 70, 68, 66, 63, 62, 59,
57, 55, 51, 48, 45, 41, 38, 34, 30, 26, 24, 20, 18, 16, 13, 10, 7, 4, 2, -1, -3,
-6, -7, -9, -10, -11, -10, -9, -8, -6, -5, -3, 0, 1, 3, 6, 6, 9, 11, 11, 13, 14,
17, 20, 21, 23, 24, 25, 26, 27, 27, 26, 25, 25, 23, 22, 21, 20, 20, 20, 19, 19,
18, 17, 16, 15, 13, 11, 9, 6, 2, -1, -4, -8, -10, -13, -16, -18, -21, -25, -28,
-32, -35, -39, -42, -47, -51, -54, -56, -58, -61, -62, -62, -62, -63, -63, -64,
-64, -64, -65, -65, -66, -68, -70, -70, -72, -72, -72, -73, -73, -74, -76, -78,
-79, -80, -84, -86, -87, -91, -93, -96, -98, -99, -100, -102, -102, -103, -104,
-106, -105, -108, -108, -110, -112, -113, -116, -117, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -118, -117, -117, -115, -115, -113, -111, -108,
-104, -99, -94, -89, -83, -78, -72, -65, -59, -53, -47, -41, -37, -30, -26, -19,
-13, -7, -1, };