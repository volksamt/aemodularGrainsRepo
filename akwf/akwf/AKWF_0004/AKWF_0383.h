#define DATA_LENGTH 512
#define DATA AKWF_0383

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 3, 3, 4, 5, 5, 5, 6, 7, 8, 8,
9, 10, 12, 13, 14, 17, 19, 21, 23, 25, 28, 30, 34, 36, 38, 40, 43, 46, 49, 52,
54, 57, 61, 62, 65, 68, 71, 72, 75, 78, 81, 83, 86, 88, 90, 93, 94, 98, 99, 101,
103, 105, 107, 108, 110, 112, 113, 114, 116, 116, 118, 118, 117, 119, 118, 119,
119, 119, 119, 119, 118, 118, 117, 117, 116, 115, 114, 112, 112, 111, 109, 108,
106, 104, 102, 100, 98, 95, 92, 89, 87, 84, 80, 78, 74, 72, 68, 65, 61, 58, 55,
52, 49, 46, 44, 41, 38, 35, 32, 30, 27, 25, 23, 21, 19, 17, 15, 14, 12, 11, 9,
8, 6, 5, 4, 3, 2, 0, -1, -2, -3, -4, -4, -6, -7, -9, -10, -12, -13, -15, -17,
-18, -21, -22, -24, -25, -27, -29, -31, -32, -34, -36, -36, -39, -40, -41, -42,
-44, -45, -46, -47, -48, -49, -50, -51, -52, -53, -54, -54, -55, -56, -57, -58,
-58, -59, -60, -60, -61, -62, -61, -63, -62, -63, -63, -64, -63, -64, -66, -66,
-66, -66, -67, -67, -68, -68, -68, -68, -70, -70, -71, -71, -73, -73, -72, -74,
-75, -75, -76, -76, -76, -76, -77, -77, -77, -78, -78, -78, -78, -78, -78, -78,
-78, -77, -78, -77, -76, -76, -75, -75, -75, -74, -73, -73, -72, -71, -70, -70,
-68, -68, -67, -66, -65, -64, -62, -60, -60, -58, -58, -56, -54, -53, -52, -49,
-49, -46, -44, -43, -41, -39, -37, -34, -33, -31, -29, -26, -24, -22, -19, -17,
-15, -12, -10, -7, -5, -2, 2, 4, 6, 9, 11, 15, 17, 20, 21, 25, 27, 30, 32, 35,
38, 39, 42, 45, 47, 50, 51, 53, 56, 58, 60, 63, 65, 68, 69, 71, 73, 76, 77, 79,
80, 82, 83, 84, 85, 85, 87, 87, 89, 90, 89, 89, 90, 90, 90, 89, 89, 88, 88, 87,
87, 86, 85, 84, 84, 82, 81, 80, 78, 78, 75, 74, 72, 70, 69, 67, 65, 63, 61, 59,
56, 55, 52, 50, 48, 46, 43, 41, 38, 35, 33, 30, 27, 24, 23, 19, 17, 14, 12, 8,
5, 4, 0, -2, -5, -7, -11, -13, -15, -17, -20, -22, -25, -26, -29, -30, -33, -35,
-37, -39, -41, -43, -43, -46, -47, -49, -50, -52, -54, -55, -57, -57, -59, -61,
-62, -64, -65, -65, -68, -68, -69, -71, -71, -71, -73, -73, -74, -75, -75, -75,
-75, -75, -74, -76, -75, -74, -74, -74, -75, -73, -74, -73, -73, -73, -72, -71,
-71, -71, -70, -69, -69, -69, -68, -67, -67, -67, -66, -65, -65, -63, -64, -63,
-63, -62, -62, -60, -60, -60, -59, -58, -58, -58, -58, -57, -57, -56, -54, -54,
-53, -53, -53, -53, -51, -50, -50, -48, -48, -47, -46, -43, -42, -41, -40, -38,
-36, -34, -32, -30, -29, -27, -26, -23, -23, -21, -19, -18, -16, -14, -12, -12,
-10, -9, -8, -7, -5, -4, -3, -2, -2, -1, };