#define DATA_LENGTH 512
#define DATA AKWF_0374

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 8, 10, 14, 17, 20, 24, 27,
31, 36, 40, 44, 49, 52, 57, 62, 65, 69, 73, 77, 81, 84, 88, 92, 94, 97, 100,
103, 106, 108, 111, 114, 115, 115, 109, 106, 104, 104, 102, 103, 102, 102, 103,
103, 103, 101, 101, 100, 100, 99, 100, 99, 98, 99, 98, 98, 97, 97, 96, 95, 94,
93, 91, 90, 89, 85, 83, 80, 78, 74, 71, 68, 65, 61, 58, 54, 51, 47, 44, 40, 37,
32, 29, 25, 20, 17, 12, 9, 5, 1, -3, -8, -12, -17, -21, -25, -30, -35, -42, -49,
-54, -58, -64, -67, -70, -74, -78, -80, -84, -87, -90, -92, -96, -98, -101,
-103, -106, -108, -111, -111, -114, -115, -116, -118, -118, -118, -119, -119,
-120, -119, -117, -116, -116, -115, -112, -111, -109, -106, -105, -102, -100,
-97, -96, -93, -90, -88, -85, -83, -81, -78, -75, -72, -70, -68, -65, -63, -61,
-58, -56, -54, -52, -52, -55, -56, -56, -56, -54, -53, -52, -49, -46, -44, -43,
-40, -38, -35, -33, -30, -27, -24, -21, -17, -14, -11, -7, -3, 0, 4, 7, 10, 13,
16, 19, 22, 24, 27, 29, 30, 33, 34, 36, 38, 39, 40, 40, 42, 43, 44, 45, 46, 47,
47, 47, 47, 47, 48, 48, 47, 47, 46, 46, 44, 43, 42, 40, 38, 33, 29, 26, 25, 23,
20, 20, 18, 18, 16, 15, 14, 12, 12, 11, 10, 10, 8, 7, 7, 4, 5, 4, 3, 3, 2, 1, 2,
2, 2, 2, 4, 5, 6, 6, 8, 10, 12, 14, 17, 18, 22, 24, 26, 30, 32, 34, 37, 40, 42,
44, 46, 48, 51, 52, 54, 55, 58, 59, 62, 63, 64, 66, 64, 58, 55, 53, 52, 51, 51,
51, 51, 51, 50, 50, 51, 50, 50, 49, 50, 50, 49, 51, 50, 52, 52, 53, 53, 54, 54,
54, 54, 54, 54, 53, 52, 51, 51, 49, 47, 46, 44, 43, 41, 39, 37, 35, 34, 32, 30,
29, 26, 24, 23, 21, 19, 17, 15, 13, 10, 8, 6, 3, -1, -2, -5, -8, -12, -18, -22,
-25, -29, -31, -33, -36, -38, -40, -42, -43, -46, -48, -50, -50, -53, -55, -56,
-57, -59, -60, -62, -63, -64, -64, -65, -66, -66, -66, -66, -66, -67, -65, -66,
-65, -63, -63, -61, -60, -59, -57, -56, -54, -52, -51, -50, -48, -48, -46, -45,
-43, -42, -41, -40, -40, -39, -38, -37, -37, -36, -36, -35, -35, -36, -42, -44,
-47, -48, -49, -48, -48, -48, -49, -48, -48, -49, -47, -47, -46, -45, -44, -43,
-41, -40, -38, -35, -34, -32, -30, -28, -26, -24, -23, -22, -19, -18, -17, -15,
-15, -13, -14, -13, -12, -10, -11, -10, -9, -9, -8, -8, -7, -6, -6, -5, -4, -5,
-5, -5, -4, -5, -4, -4, -5, -4, -5, -7, -7, -8, -13, -15, -16, -18, -19, -19,
-19, -19, -18, -18, -18, -17, -16, -16, -16, -15, -14, -13, -12, -11, -11, -10,
-8, -8, -6, -5, -3, -1, };