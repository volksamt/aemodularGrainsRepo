#define DATA_LENGTH 512
#define DATA AKWF_0389

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 6, 7, 10, 11, 13, 14, 16, 18,
19, 21, 23, 25, 26, 28, 29, 31, 32, 35, 35, 37, 38, 40, 41, 43, 44, 45, 46, 48,
49, 50, 52, 52, 53, 55, 56, 57, 58, 59, 60, 62, 61, 62, 64, 65, 66, 66, 68, 69,
70, 71, 71, 71, 73, 73, 74, 76, 75, 76, 78, 78, 78, 79, 79, 82, 81, 83, 83, 83,
84, 85, 85, 86, 87, 88, 88, 89, 89, 90, 90, 91, 92, 93, 93, 94, 95, 96, 96, 97,
97, 98, 98, 99, 100, 100, 101, 102, 102, 102, 103, 104, 105, 106, 106, 107, 107,
108, 109, 109, 110, 110, 111, 111, 112, 112, 113, 113, 113, 115, 114, 115, 115,
115, 116, 117, 117, 117, 118, 118, 118, 117, 118, 118, 118, 119, 119, 119, 119,
119, 118, 119, 119, 119, 119, 119, 119, 118, 118, 117, 117, 118, 117, 117, 116,
116, 116, 115, 115, 113, 114, 113, 113, 112, 111, 111, 110, 109, 108, 108, 107,
105, 106, 104, 103, 103, 101, 101, 100, 99, 98, 97, 96, 94, 94, 93, 91, 91, 89,
89, 87, 86, 85, 83, 82, 81, 80, 79, 79, 77, 74, 74, 73, 71, 71, 69, 68, 67, 65,
64, 63, 62, 61, 59, 58, 57, 55, 54, 53, 52, 50, 49, 48, 46, 46, 44, 43, 41, 40,
38, 37, 36, 35, 33, 32, 32, 29, 29, 28, 26, 26, 24, 22, 21, 20, 19, 17, 17, 15,
14, 12, 10, 9, 8, 7, 6, 3, 3, 2, -1, -1, -3, -5, -6, -7, -8, -10, -11, -13, -14,
-15, -17, -19, -19, -21, -23, -24, -26, -27, -29, -31, -32, -33, -35, -36, -38,
-40, -40, -43, -44, -46, -47, -48, -50, -51, -53, -55, -55, -57, -59, -61, -63,
-62, -64, -66, -67, -69, -70, -72, -73, -75, -76, -77, -78, -79, -81, -82, -83,
-84, -85, -86, -88, -89, -90, -91, -92, -93, -94, -95, -96, -97, -97, -98, -99,
-101, -101, -101, -102, -103, -104, -105, -104, -106, -106, -106, -107, -108,
-108, -108, -109, -109, -110, -110, -110, -110, -111, -111, -111, -112, -112,
-112, -112, -112, -111, -112, -112, -112, -112, -112, -112, -111, -112, -112,
-113, -112, -112, -112, -112, -112, -111, -111, -111, -112, -112, -111, -110,
-111, -111, -110, -110, -110, -109, -110, -110, -109, -109, -110, -108, -109,
-109, -108, -108, -107, -108, -107, -107, -107, -107, -106, -106, -106, -106,
-105, -106, -105, -106, -105, -104, -104, -103, -104, -103, -103, -103, -103,
-102, -102, -102, -101, -101, -101, -101, -100, -100, -99, -99, -98, -98, -98,
-96, -96, -96, -95, -94, -95, -93, -93, -93, -91, -90, -90, -89, -89, -87, -86,
-86, -85, -84, -83, -82, -81, -79, -79, -77, -76, -75, -74, -73, -72, -70, -69,
-68, -67, -64, -64, -62, -61, -60, -57, -56, -54, -52, -51, -50, -48, -46, -45,
-42, -42, -40, -37, -35, -34, -33, -30, -28, -27, -25, -23, -21, -19, -17, -16,
-14, -11, -9, -8, -7, -4, -3, -1, };