#define DATA_LENGTH 512
#define DATA AKWF_0326

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 18, 29, 41, 52, 62, 72, 79, 87, 93,
98, 102, 105, 108, 108, 109, 108, 106, 104, 101, 97, 93, 87, 82, 76, 70, 64, 57,
50, 44, 37, 30, 24, 18, 11, 5, -1, -5, -11, -15, -19, -24, -26, -29, -32, -34,
-36, -38, -39, -40, -40, -40, -39, -39, -38, -36, -36, -34, -32, -31, -29, -27,
-24, -22, -20, -17, -15, -12, -10, -7, -5, -3, -1, 2, 4, 5, 7, 9, 11, 12, 13,
14, 16, 17, 17, 18, 18, 19, 19, 20, 20, 19, 19, 18, 18, 18, 18, 17, 16, 15, 15,
14, 14, 13, 12, 10, 9, 8, 7, 7, 6, 6, 4, 3, 3, 3, 2, 1, 1, 0, -1, -2, -2, -3,
-4, -3, -4, -5, -5, -5, -5, -6, -5, -6, -6, -7, -7, -6, -6, -7, -6, -6, -6, -6,
-6, -7, -6, -6, -6, -6, -6, -6, -5, -6, -5, -5, -6, -5, -5, -4, -4, -4, -4, -4,
-5, -4, -4, -4, -3, -4, -3, -3, -3, -3, -2, -3, -3, -3, -4, -2, -3, -3, -3, -3,
-2, -3, -2, -2, -3, -3, -2, -3, -3, -2, -2, -2, -3, -3, -3, -3, -2, -3, -3, -2,
-2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -2, -1, -2, -2, -2, -1, -2, -2, -2, -1,
-1, -1, -2, -1, -1, -1, -2, -2, -2, -1, -2, 0, -1, 0, 0, -1, 0, 0, 0, -1, -1, 0,
-1, 0, 0, -1, -1, 0, 0, 0, 1, 0, -1, 0, 0, 0, -1, 0, -1, -1, 0, 1, 0, 0, 0, 0,
1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1, 1, 0,
1, 1, 1, 0, 0, 1, 0, 1, 1, 1, 1, 0, 0, 0, 1, 1, 1, 0, 1, 0, 1, 1, 1, 1, 1, 0, 1,
1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 2, 1, 0, 1, 0, 1, 0, 0, 1, 1, 1, 1, 1, 1, 0,
1, 0, 1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 1, 0, 1, 0, 0, 0, 1, 1, 1, 0, 1, 0, 0,
0, 0, 0, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 1, 0,
0, 1, 0, 0, 1, 0, 1, 0, -1, 0, 0, 1, 1, 0, 0, 1, 0, 0, 0, 1, 1, 1, 0, 0, -1, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, -1, 0, 1,
0, 0, 0, 0, 0, -1, 0, -1, 1, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, -1, 0, 0,
-1, -1, 0, 0, 1, 0, 0, -1, -6, -24, -49, -73, -88, -97, -104, -109, -114, -117,
-119, -118, -114, -107, -98, -89, -79, -67, -55, -43, -31, -18, -5, };