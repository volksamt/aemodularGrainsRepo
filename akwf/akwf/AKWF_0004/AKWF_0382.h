#define DATA_LENGTH 512
#define DATA AKWF_0382

const PROGMEM int8_t DATA[DATA_LENGTH] = {-20, -47, -60, -86, -82, -112, -124,
-109, -82, -85, -86, -59, -45, -56, -31, -31, -57, -45, -54, -44, -64, -87, -83,
-86, -82, -89, -67, -47, -51, -50, -50, -51, -47, -72, -88, -82, -87, -81, -89,
-62, -48, -50, -52, -37, -9, -18, -13, -18, -10, -31, -54, -48, -51, -48, -51,
-48, -51, -47, -53, -42, -14, -16, -16, -14, -16, -13, -17, -11, -40, -52, -48,
-51, -47, -53, -25, -12, -18, -13, -16, -15, -15, -45, -52, -48, -51, -49, -50,
-49, -48, -52, -34, -9, -19, -12, -17, -13, -17, -14, -17, -47, -51, -48, -52,
-48, -52, -44, -13, -16, -15, -15, -15, -15, -15, -14, -16, -15, -15, -14, -15,
-15, -15, -15, -15, -15, -15, -15, -15, -14, -15, -15, -15, -16, -15, -15, -15,
-16, -14, -15, -15, -15, -15, -15, -14, -14, -14, -15, -15, -15, -15, -14, -15,
-15, -15, -14, -15, -14, -15, -15, -15, -15, -15, -15, -15, -14, -14, -15, -15,
-15, -15, -15, -15, -15, -15, -15, -15, -15, -14, -15, -14, -15, -15, -15, -15,
-14, -16, -14, -16, -12, -19, 5, 24, 18, 21, 19, 21, 19, 21, 19, 21, 19, 20, 20,
20, 20, 20, 20, 19, 19, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 19, 21, 19, 19,
20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 19, 20, 19, 20, 20, 20, 20, 19, 20,
20, 19, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 19, 20, 20, 20, 19, 20, 20,
19, 19, 20, 19, 19, 19, 19, 20, 19, 19, 19, 20, 20, 20, 19, 20, 19, 19, 20, 20,
20, 20, 20, 19, 19, 20, 19, 20, 20, 19, 19, 21, 19, 20, 19, 20, 19, 19, 20, 19,
20, 20, 20, 19, 20, 19, 19, 20, 20, 19, 20, 19, 19, 20, 20, 20, 19, 19, 20, 20,
20, 19, 19, 20, 20, 20, 20, 19, 20, 19, 20, 19, 20, 20, 19, 20, 19, 20, 20, 20,
20, 19, 20, 20, 20, 19, 19, 20, 19, 20, 19, 20, 19, 19, 19, 20, 19, 19, 19, 20,
20, 19, 19, 19, 19, 19, 19, 20, 20, 19, 20, 20, 20, 19, 20, 19, 19, 20, 19, 19,
19, 19, 19, 19, 19, 19, 19, 20, 19, 20, 19, 20, 20, 20, 19, 19, 20, 19, 20, 19,
20, 20, 20, 20, 19, 19, 20, 19, 19, 19, 19, 19, 19, 19, 19, 19, 20, 20, 19, 19,
20, 19, 19, 20, 19, 19, 19, 20, 19, 19, 19, 19, 19, 20, 19, 19, 19, 20, 20, 19,
20, 20, 19, 19, 19, 19, 20, 19, 18, 20, 20, 19, 19, 19, 19, 19, 20, 19, 19, 19,
18, 18, 20, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 18, 19, 19, 19, 18, 19,
20, 19, 19, 19, 19, 20, 18, 19, 19, 18, 18, 18, 19, 19, 19, 19, 18, 19, 19, 19,
20, 19, 19, 18, 20, 19, 20, 18, 21, 16, };