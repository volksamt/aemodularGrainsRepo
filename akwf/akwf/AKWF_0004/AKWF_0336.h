#define DATA_LENGTH 512
#define DATA AKWF_0336

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 9, 15, 19, 24, 29, 33, 37, 40, 44,
48, 52, 54, 58, 61, 64, 67, 69, 71, 74, 74, 76, 78, 79, 80, 80, 82, 82, 84, 84,
84, 84, 85, 86, 86, 85, 84, 84, 84, 83, 82, 82, 83, 82, 82, 82, 83, 83, 83, 84,
84, 84, 84, 85, 84, 85, 83, 84, 83, 83, 83, 83, 82, 82, 81, 80, 79, 78, 77, 76,
74, 73, 71, 71, 69, 67, 66, 65, 63, 61, 60, 58, 57, 54, 52, 50, 48, 45, 43, 41,
39, 37, 35, 33, 30, 28, 25, 23, 20, 18, 15, 13, 10, 8, 6, 5, 4, 5, 3, 4, 4, 5,
5, 6, 7, 8, 8, 9, 9, 11, 11, 13, 14, 14, 15, 16, 17, 16, 17, 17, 17, 17, 17, 16,
15, 15, 14, 13, 12, 12, 12, 10, 9, 8, 7, 6, 5, 4, 2, 0, -2, -4, -6, -8, -9, -11,
-12, -14, -16, -18, -20, -22, -24, -27, -30, -32, -35, -35, -38, -40, -41, -43,
-44, -46, -46, -48, -49, -49, -50, -51, -52, -53, -54, -56, -57, -58, -58, -59,
-61, -60, -62, -64, -65, -66, -68, -68, -70, -73, -74, -76, -77, -79, -81, -83,
-83, -86, -88, -88, -90, -93, -94, -95, -97, -99, -102, -104, -105, -107, -108,
-110, -111, -112, -114, -115, -115, -117, -117, -118, -119, -119, -119, -119,
-117, -116, -113, -110, -107, -104, -99, -94, -89, -84, -78, -72, -67, -61, -55,
-49, -43, -37, -30, -23, -18, -12, -7, 0, 4, 10, 15, 21, 24, 30, 33, 38, 41, 45,
48, 52, 55, 58, 61, 64, 67, 69, 71, 73, 75, 77, 77, 80, 80, 81, 83, 83, 84, 84,
85, 85, 86, 85, 85, 85, 85, 84, 83, 83, 83, 83, 83, 82, 82, 83, 84, 83, 83, 83,
84, 84, 84, 84, 84, 84, 84, 83, 83, 82, 83, 82, 82, 81, 81, 79, 79, 78, 77, 76,
74, 73, 71, 69, 68, 68, 66, 65, 62, 61, 60, 57, 56, 54, 52, 50, 49, 46, 43, 41,
39, 37, 34, 32, 30, 27, 25, 22, 19, 17, 14, 12, 10, 9, 7, 5, 4, 3, 3, 4, 4, 4,
5, 6, 6, 8, 8, 9, 10, 10, 12, 13, 14, 14, 15, 16, 16, 17, 17, 17, 17, 17, 16,
16, 16, 14, 13, 13, 12, 12, 11, 10, 10, 8, 7, 5, 5, 3, 2, 0, -1, -4, -6, -7, -9,
-10, -13, -15, -17, -18, -20, -22, -26, -27, -30, -32, -34, -36, -39, -39, -42,
-44, -44, -45, -46, -47, -48, -49, -50, -51, -52, -53, -54, -55, -57, -57, -58,
-60, -60, -62, -63, -64, -65, -66, -68, -70, -70, -72, -74, -76, -78, -80, -80,
-82, -84, -86, -87, -89, -90, -92, -94, -96, -97, -99, -101, -103, -105, -106,
-109, -110, -111, -113, -113, -115, -116, -117, -118, -118, -119, -119, -119,
-118, -117, -115, -112, -111, -107, -102, -98, -94, -88, -83, -77, -71, -65,
-59, -54, -49, -42, -35, -29, -25, -17, -12, -5, 0, };