#define DATA_LENGTH 512
#define DATA AKWF_0350

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 4, 7, 8, 10, 12, 13, 15, 17, 19,
20, 22, 24, 25, 27, 29, 31, 34, 34, 37, 38, 41, 42, 44, 46, 47, 50, 52, 54, 55,
57, 58, 61, 61, 63, 65, 65, 68, 69, 70, 72, 74, 75, 75, 77, 78, 79, 79, 80, 81,
83, 83, 82, 84, 84, 84, 85, 84, 86, 86, 87, 86, 86, 86, 85, 85, 86, 85, 84, 85,
85, 84, 83, 83, 83, 82, 82, 82, 82, 82, 82, 81, 80, 81, 80, 80, 79, 79, 80, 79,
79, 80, 80, 79, 79, 79, 79, 79, 80, 79, 79, 80, 80, 80, 81, 81, 81, 82, 82, 83,
83, 84, 84, 85, 85, 86, 88, 87, 89, 88, 89, 90, 89, 89, 88, 87, 86, 86, 86, 85,
85, 84, 83, 83, 81, 80, 80, 79, 78, 77, 76, 75, 73, 73, 72, 71, 70, 69, 67, 67,
66, 64, 64, 63, 62, 61, 60, 59, 58, 57, 55, 55, 53, 53, 52, 50, 49, 48, 48, 46,
44, 44, 43, 41, 41, 39, 37, 36, 34, 35, 32, 32, 30, 28, 27, 25, 24, 22, 21, 17,
16, 14, 11, 10, 7, 5, 4, 1, -2, -4, -7, -9, -11, -14, -17, -20, -23, -24, -27,
-29, -32, -35, -38, -40, -42, -45, -47, -51, -54, -56, -58, -61, -64, -66, -69,
-71, -73, -76, -79, -80, -83, -86, -86, -89, -91, -93, -95, -96, -99, -99, -101,
-102, -105, -106, -108, -108, -110, -111, -112, -113, -115, -115, -116, -117,
-117, -118, -118, -119, -119, -119, -119, -119, -118, -118, -117, -116, -116,
-114, -113, -112, -111, -109, -108, -107, -105, -103, -101, -100, -98, -96, -94,
-93, -91, -89, -86, -85, -83, -81, -80, -78, -76, -74, -72, -70, -68, -66, -66,
-64, -62, -60, -59, -57, -55, -55, -53, -52, -50, -48, -48, -47, -45, -44, -44,
-42, -42, -42, -40, -40, -40, -40, -41, -41, -40, -41, -41, -41, -41, -41, -42,
-42, -42, -42, -43, -43, -43, -44, -44, -45, -46, -46, -45, -47, -47, -47, -47,
-47, -48, -47, -47, -48, -48, -48, -48, -49, -48, -49, -48, -49, -48, -49, -49,
-49, -49, -49, -49, -49, -48, -49, -49, -49, -49, -48, -49, -50, -50, -49, -50,
-49, -50, -50, -51, -50, -50, -51, -50, -51, -51, -51, -52, -52, -52, -53, -53,
-53, -53, -54, -54, -54, -55, -54, -54, -55, -55, -55, -56, -55, -55, -56, -55,
-55, -54, -55, -54, -55, -54, -54, -54, -54, -53, -53, -53, -53, -53, -51, -51,
-51, -50, -50, -49, -50, -49, -48, -48, -47, -47, -46, -46, -45, -44, -43, -44,
-43, -42, -42, -42, -42, -40, -40, -40, -40, -40, -39, -39, -39, -39, -39, -38,
-39, -38, -38, -38, -38, -37, -37, -37, -37, -37, -36, -36, -36, -35, -35, -35,
-35, -34, -33, -33, -34, -33, -32, -32, -30, -30, -30, -29, -28, -27, -27, -27,
-25, -24, -23, -23, -23, -21, -20, -19, -18, -17, -16, -15, -13, -12, -11, -9,
-8, -6, -4, -4, -2, 0, };