#define DATA_LENGTH 512
#define DATA AKWF_0328

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 2, 5, 6, 9, 10, 12, 14, 16, 17, 20,
21, 23, 25, 25, 28, 29, 31, 31, 33, 33, 35, 36, 37, 38, 39, 42, 43, 44, 44, 44,
46, 47, 47, 47, 47, 48, 48, 50, 49, 49, 49, 49, 49, 50, 49, 50, 51, 51, 50, 50,
50, 49, 50, 49, 50, 50, 49, 48, 49, 49, 48, 48, 48, 48, 48, 48, 48, 48, 47, 47,
46, 46, 42, 40, 37, 33, 31, 28, 26, 24, 23, 21, 19, 18, 19, 17, 18, 17, 17, 18,
18, 20, 20, 20, 20, 20, 21, 20, 19, 20, 19, 19, 19, 18, 18, 19, 18, 17, 18, 16,
15, 14, 14, 13, 12, 11, 11, 10, 9, 10, 10, 9, 9, 8, 8, 8, 7, 7, 6, 7, 7, 7, 8,
7, 8, 9, 11, 11, 10, 11, 11, 13, 13, 13, 14, 15, 15, 16, 16, 17, 18, 18, 19, 20,
21, 20, 22, 24, 25, 25, 26, 28, 29, 31, 33, 36, 38, 41, 43, 46, 50, 52, 55, 60,
62, 65, 68, 72, 74, 78, 81, 84, 88, 91, 94, 97, 100, 103, 104, 107, 110, 113,
114, 116, 117, 118, 119, 119, 119, 117, 116, 115, 113, 110, 108, 106, 104, 101,
99, 96, 94, 92, 90, 87, 85, 83, 80, 77, 75, 74, 71, 68, 66, 63, 61, 59, 57, 55,
53, 52, 50, 48, 46, 44, 44, 41, 39, 39, 36, 33, 31, 29, 28, 26, 24, 23, 21, 18,
17, 16, 14, 12, 11, 9, 8, 7, 5, 3, 2, -2, -3, -5, -7, -7, -9, -10, -12, -13,
-14, -16, -18, -19, -19, -21, -23, -24, -28, -28, -29, -30, -31, -32, -33, -34,
-36, -37, -37, -38, -38, -39, -41, -42, -42, -43, -43, -44, -44, -44, -44, -45,
-45, -45, -45, -46, -47, -47, -47, -46, -46, -47, -48, -47, -47, -47, -47, -47,
-46, -48, -48, -49, -49, -48, -49, -48, -49, -50, -49, -51, -51, -51, -52, -53,
-55, -57, -57, -59, -58, -60, -60, -61, -61, -61, -62, -62, -63, -63, -63, -63,
-63, -65, -66, -66, -65, -65, -65, -65, -64, -64, -63, -62, -62, -61, -60, -59,
-59, -58, -56, -55, -56, -53, -53, -52, -51, -49, -49, -47, -45, -45, -45, -44,
-42, -42, -40, -41, -40, -39, -38, -38, -37, -37, -38, -38, -39, -38, -38, -38,
-38, -37, -37, -36, -36, -36, -36, -35, -35, -36, -35, -36, -34, -34, -33, -34,
-33, -33, -33, -32, -33, -32, -32, -32, -32, -33, -33, -35, -36, -37, -38, -38,
-41, -42, -44, -45, -46, -48, -49, -51, -53, -55, -57, -58, -62, -63, -64, -67,
-67, -69, -70, -71, -73, -74, -75, -76, -77, -78, -78, -80, -81, -82, -83, -85,
-86, -85, -85, -86, -87, -88, -88, -87, -88, -87, -86, -86, -85, -83, -82, -81,
-79, -77, -76, -73, -71, -69, -67, -65, -63, -60, -58, -55, -54, -50, -49, -46,
-44, -41, -39, -36, -34, -30, -28, -26, -24, -22, -19, -16, -15, -12, -11, -8,
-6, -5, -1, };