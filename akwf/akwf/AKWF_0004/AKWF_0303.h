#define DATA_LENGTH 512
#define DATA AKWF_0303

const PROGMEM int8_t DATA[DATA_LENGTH] = {-12, -116, -88, -61, -40, -16, 0, 20,
30, 44, 49, 59, 59, 64, 61, 61, 56, 53, 46, 40, 32, 24, 16, 9, 1, -6, -13, -19,
-24, -30, -32, -37, -38, -40, -41, -40, -40, -40, -37, -35, -32, -30, -26, -22,
-18, -14, -11, -6, -3, 0, 3, 6, 9, 12, 13, 15, 16, 18, 19, 19, 20, 19, 19, 18,
17, 16, 15, 14, 13, 11, 10, 9, 7, 5, 4, 2, 1, -1, -2, -2, -4, -4, -5, -5, -6,
-7, -7, -7, -7, -7, -6, -6, -6, -5, -5, -4, -5, -4, -4, -3, -2, -1, -2, -1, 0,
-1, 0, 0, 1, 1, 1, 2, 1, 2, 2, 2, 2, 3, 2, 1, 2, 1, 1, 1, 1, 1, 0, 0, 1, 1, 1,
1, 1, 0, 0, 0, 0, -1, 0, -1, 0, -1, 0, -1, -2, -1, 0, -1, -1, -1, -1, 0, -1, -1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0,
0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 1, -1, -1, -1, 1, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0,
0, 0, 0, 0, 0, 0, 1, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, -1, -1, 0,
0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0,
0, 1, -1, 1, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0,
0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 1, 0, -1, 0, 0, 0, 0,
-1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, -1, -1, -1, 0, 0, 0, 1, 0, 1, 0, 0, 0, 1,
-1, 0, 1, -1, 0, 0, 0, 0, 0, 0, 1, 0, -1, 1, 0, 0, 0, -1, 0, 0, 0, -1, 0, 1, 0,
0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, -1, 1, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0,
-1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
1, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0,
0, 0, -1, 1, 0, -1, 0, 0, 1, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, -1, 1, 0, 1, -1, 1,
0, 0, -1, -1, -1, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 1, 0, 0,
1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0,
-1, };