#define DATA_LENGTH 512
#define DATA AKWF_0398

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 9, 12, 16, 18, 21, 24, 26,
28, 31, 34, 38, 40, 42, 45, 47, 50, 52, 55, 57, 60, 62, 64, 68, 68, 71, 74, 76,
79, 80, 82, 85, 86, 88, 91, 92, 94, 95, 97, 98, 100, 102, 103, 105, 106, 107,
108, 109, 110, 111, 113, 113, 114, 114, 115, 116, 116, 117, 117, 119, 118, 119,
119, 119, 119, 119, 120, 118, 118, 118, 119, 118, 118, 117, 117, 116, 116, 115,
115, 115, 114, 112, 113, 111, 110, 109, 108, 107, 106, 106, 104, 103, 103, 100,
99, 98, 97, 96, 94, 93, 91, 90, 89, 86, 85, 84, 82, 80, 78, 77, 75, 74, 72, 70,
68, 67, 65, 64, 62, 60, 59, 57, 55, 53, 51, 50, 48, 47, 45, 44, 42, 41, 39, 37,
36, 35, 33, 31, 30, 28, 28, 25, 24, 23, 22, 21, 19, 19, 17, 16, 16, 14, 14, 13,
12, 11, 10, 9, 9, 7, 7, 6, 6, 4, 5, 4, 3, 3, 2, 2, 2, 1, 2, 1, 0, 1, -1, 0, 0,
0, 0, -1, -1, -1, 0, 0, 0, -1, -1, 0, 0, 0, 1, 1, 0, 0, 1, 1, 2, 2, 2, 2, 3, 3,
3, 4, 4, 5, 5, 6, 6, 7, 8, 8, 8, 8, 8, 9, 9, 9, 9, 9, 9, 9, 10, 10, 9, 9, 10, 8,
9, 8, 8, 9, 7, 7, 6, 7, 7, 6, 5, 5, 4, 4, 3, 3, 2, 2, 1, 0, 1, 0, -1, -2, -2,
-2, -3, -3, -4, -5, -5, -6, -6, -7, -7, -7, -8, -8, -8, -9, -9, -9, -9, -10,
-10, -9, -11, -10, -11, -11, -11, -11, -11, -11, -11, -12, -11, -11, -11, -12,
-12, -12, -12, -12, -12, -12, -11, -12, -11, -12, -12, -11, -10, -11, -11, -11,
-10, -9, -10, -9, -10, -9, -10, -9, -9, -8, -8, -8, -9, -8, -9, -8, -8, -8, -7,
-7, -7, -8, -8, -7, -8, -8, -7, -8, -7, -8, -8, -8, -9, -9, -8, -9, -9, -11,
-11, -10, -11, -12, -13, -13, -13, -14, -15, -16, -16, -18, -18, -19, -20, -21,
-21, -22, -24, -24, -25, -26, -28, -29, -30, -31, -32, -34, -35, -36, -37, -39,
-40, -41, -43, -45, -47, -47, -49, -51, -52, -54, -56, -57, -59, -61, -62, -63,
-65, -66, -67, -69, -70, -72, -74, -75, -77, -78, -79, -81, -83, -84, -86, -87,
-89, -90, -91, -92, -94, -95, -96, -98, -99, -100, -101, -102, -102, -104, -105,
-107, -107, -107, -109, -109, -110, -111, -112, -112, -113, -112, -114, -113,
-115, -116, -115, -115, -115, -115, -115, -115, -116, -115, -115, -115, -115,
-115, -114, -113, -112, -112, -111, -111, -111, -108, -108, -107, -106, -105,
-103, -103, -102, -100, -98, -97, -96, -94, -92, -90, -89, -87, -85, -83, -82,
-78, -77, -75, -73, -71, -69, -67, -64, -62, -60, -58, -54, -53, -51, -48, -45,
-43, -40, -37, -35, -32, -29, -27, -24, -22, -20, -16, -14, -11, -9, -5, -3, 0,
};