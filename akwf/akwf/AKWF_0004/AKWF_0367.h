#define DATA_LENGTH 512
#define DATA AKWF_0367

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 6, 7, 9, 10, 11, 12, 14, 15, 15,
17, 17, 18, 19, 20, 22, 23, 25, 26, 27, 29, 31, 33, 36, 38, 42, 46, 48, 52, 57,
61, 65, 70, 75, 79, 84, 87, 91, 95, 98, 101, 105, 108, 109, 111, 112, 114, 116,
117, 117, 118, 118, 119, 119, 119, 119, 118, 117, 117, 116, 115, 114, 113, 112,
111, 110, 109, 108, 106, 106, 104, 102, 101, 100, 99, 97, 96, 94, 94, 92, 90,
89, 87, 86, 84, 83, 82, 80, 79, 78, 76, 75, 73, 72, 72, 70, 68, 67, 66, 65, 64,
63, 62, 60, 59, 57, 57, 56, 54, 54, 53, 51, 50, 50, 49, 48, 47, 46, 45, 45, 44,
43, 43, 41, 41, 40, 40, 39, 39, 38, 37, 36, 36, 35, 35, 34, 34, 33, 32, 33, 32,
32, 32, 30, 30, 30, 29, 30, 30, 28, 29, 28, 28, 27, 28, 27, 26, 26, 26, 26, 27,
26, 26, 25, 26, 24, 25, 26, 25, 25, 23, 25, 24, 23, 24, 24, 24, 24, 23, 23, 23,
23, 23, 23, 22, 23, 23, 23, 23, 22, 23, 23, 22, 22, 22, 23, 22, 22, 23, 22, 22,
22, 23, 21, 22, 23, 22, 22, 22, 22, 21, 22, 21, 22, 22, 22, 23, 21, 21, 22, 22,
22, 22, 21, 21, 22, 22, 21, 21, 21, 22, 22, 21, 21, 22, 21, 22, 22, 22, 22, 21,
22, 21, 23, 21, 22, 21, 22, 22, 22, 21, 23, 20, 24, 19, -21, -22, -21, -22, -21,
-22, -22, -22, -21, -23, -21, -22, -21, -22, -21, -22, -22, -22, -22, -22, -21,
-22, -21, -22, -21, -21, -22, -21, -21, -22, -22, -22, -21, -22, -22, -22, -22,
-21, -22, -22, -22, -22, -22, -22, -22, -22, -22, -22, -21, -22, -22, -22, -22,
-22, -22, -23, -22, -21, -22, -22, -22, -23, -23, -22, -23, -23, -23, -23, -23,
-23, -23, -23, -23, -23, -24, -23, -24, -23, -24, -24, -24, -24, -23, -23, -25,
-24, -25, -24, -25, -25, -25, -25, -25, -26, -26, -26, -27, -26, -27, -27, -27,
-27, -28, -29, -28, -28, -28, -30, -29, -30, -30, -30, -31, -31, -31, -32, -32,
-32, -33, -34, -34, -36, -35, -36, -37, -37, -37, -39, -39, -40, -40, -41, -42,
-42, -43, -44, -45, -45, -47, -47, -49, -49, -49, -51, -52, -53, -54, -55, -55,
-57, -58, -59, -60, -62, -63, -64, -65, -66, -68, -68, -70, -71, -72, -75, -75,
-76, -78, -79, -80, -82, -83, -86, -86, -88, -89, -91, -92, -93, -94, -96, -97,
-99, -100, -102, -103, -104, -105, -107, -108, -110, -111, -112, -113, -114,
-115, -116, -116, -118, -118, -118, -119, -118, -119, -119, -118, -118, -118,
-117, -115, -114, -113, -111, -109, -107, -104, -101, -97, -94, -90, -86, -82,
-78, -74, -69, -64, -60, -56, -52, -48, -44, -41, -38, -35, -33, -31, -29, -26,
-26, -24, -23, -22, -21, -19, -18, -17, -16, -15, -15, -14, -12, -12, -10, -9,
-6, -5, -2, };