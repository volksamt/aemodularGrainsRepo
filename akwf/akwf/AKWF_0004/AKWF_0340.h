#define DATA_LENGTH 512
#define DATA AKWF_0340

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 10, 16, 19, 24, 28, 31, 35, 39,
41, 45, 47, 51, 52, 56, 57, 59, 61, 63, 65, 67, 69, 71, 73, 74, 77, 79, 82, 84,
86, 89, 91, 92, 95, 97, 100, 101, 102, 103, 104, 104, 105, 104, 104, 104, 104,
102, 102, 100, 99, 98, 97, 96, 95, 95, 94, 94, 93, 92, 92, 92, 91, 91, 91, 93,
92, 93, 93, 93, 92, 93, 92, 93, 92, 91, 92, 90, 89, 89, 88, 88, 86, 85, 86, 84,
84, 83, 84, 83, 84, 83, 83, 83, 84, 85, 85, 85, 85, 84, 84, 82, 80, 79, 77, 76,
73, 69, 66, 62, 58, 55, 50, 45, 42, 37, 33, 29, 26, 20, 17, 14, 9, 7, 4, 1, -3,
-5, -7, -9, -11, -14, -15, -17, -19, -22, -24, -27, -28, -30, -33, -35, -37,
-40, -42, -43, -46, -49, -50, -52, -54, -56, -55, -57, -58, -60, -60, -60, -61,
-61, -61, -62, -61, -61, -62, -63, -63, -65, -66, -66, -69, -70, -72, -74, -76,
-78, -80, -83, -85, -88, -90, -92, -94, -95, -97, -99, -100, -102, -103, -103,
-104, -105, -104, -106, -106, -106, -106, -107, -107, -108, -108, -109, -109,
-110, -110, -111, -113, -114, -114, -115, -116, -117, -117, -119, -119, -119,
-119, -119, -119, -118, -118, -117, -118, -116, -116, -114, -113, -111, -111,
-109, -107, -105, -102, -99, -96, -92, -88, -86, -81, -78, -73, -69, -65, -61,
-56, -51, -46, -43, -38, -33, -28, -23, -18, -12, -9, -3, 1, 5, 10, 16, 21, 24,
29, 33, 36, 39, 42, 46, 48, 51, 53, 55, 57, 60, 62, 63, 66, 67, 68, 71, 73, 75,
78, 79, 82, 84, 86, 89, 91, 93, 95, 97, 99, 101, 102, 103, 104, 104, 104, 105,
105, 103, 103, 103, 101, 100, 99, 98, 97, 96, 95, 94, 93, 93, 92, 92, 92, 92,
92, 92, 92, 93, 92, 92, 93, 93, 93, 93, 92, 92, 92, 91, 90, 90, 90, 89, 87, 87,
87, 85, 85, 84, 84, 84, 83, 83, 83, 83, 83, 84, 83, 85, 85, 85, 85, 84, 83, 83,
81, 79, 77, 75, 72, 69, 66, 62, 58, 55, 50, 46, 42, 36, 33, 28, 24, 21, 17, 12,
10, 6, 4, 1, -3, -5, -7, -10, -11, -14, -15, -18, -20, -22, -24, -26, -28, -31,
-33, -35, -37, -40, -42, -45, -46, -48, -50, -52, -54, -55, -56, -57, -59, -60,
-60, -60, -61, -61, -61, -61, -61, -62, -62, -63, -64, -64, -66, -67, -68, -70,
-71, -73, -76, -78, -80, -83, -85, -88, -90, -92, -93, -96, -98, -99, -100,
-102, -102, -103, -104, -105, -105, -106, -106, -107, -107, -106, -108, -108,
-108, -109, -109, -111, -111, -112, -113, -113, -114, -115, -117, -116, -117,
-117, -118, -119, -119, -118, -119, -118, -118, -118, -117, -116, -115, -113,
-112, -111, -111, -108, -107, -105, -102, -98, -96, -91, -89, -86, -81, -76,
-73, -69, -64, -59, -55, -50, -46, -42, -37, -32, -27, -22, -17, -12, -7, -3, };