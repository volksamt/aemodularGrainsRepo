#define DATA_LENGTH 512
#define DATA AKWF_0343

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 115, 122, 116, 121, 117,
121, 118, 121, 118, 121, 118, 121, 118, 119, 118, 120, 118, 120, 119, 118, 119,
119, 119, 119, 120, 118, 120, 119, 119, 119, 119, 119, 120, 118, 118, 118, 119,
118, 119, 119, 119, 119, 118, 118, 119, 119, 119, 119, 119, 119, 118, 119, 118,
118, 119, 119, 118, 119, 119, 118, 119, 119, 118, 118, 119, 118, 118, 118, 118,
118, 118, 118, 118, 119, 119, 119, 119, 119, 118, 118, 118, 118, 119, 118, 118,
118, 119, 119, 118, 118, 118, 118, 118, 117, 118, 118, 118, 118, 118, 118, 118,
117, 118, 118, 119, 119, 118, 117, 117, 118, 118, 118, 118, 117, 118, 118, 117,
117, 118, 117, 118, 118, 117, 118, 117, 118, 117, 118, 117, 118, 118, 118, 117,
117, 118, 117, 117, 118, 117, 117, 117, 118, 117, 117, 117, 118, 118, 117, 117,
117, 118, 117, 116, 117, 117, 117, 117, 117, 117, 118, 116, 118, 117, 117, 116,
116, 117, 116, 118, 116, 117, 117, 117, 116, 117, 118, 116, 116, 118, 117, 117,
117, 117, 117, 117, 117, 117, 116, 116, 116, 117, 116, 117, 117, 117, 116, 116,
116, 116, 117, 116, 117, 116, 116, 117, 116, 116, 117, 116, 117, 116, 116, 116,
116, 116, 116, 117, 117, 116, 116, 116, 116, 116, 115, 117, 116, 117, 115, 117,
115, 117, 115, 116, 115, 116, 115, 115, 116, 115, 117, 115, 117, 114, 118, 113,
120, 111, 120, 111, 122, 109, 124, 104, 127, 73, -128, -114, -121, -119, -118,
-120, -117, -121, -116, -121, -117, -121, -117, -121, -117, -121, -117, -120,
-118, -121, -118, -119, -119, -120, -119, -119, -119, -119, -119, -118, -119,
-118, -119, -119, -119, -118, -120, -119, -119, -118, -119, -119, -119, -118,
-119, -118, -118, -118, -119, -119, -118, -119, -118, -119, -119, -119, -118,
-119, -118, -118, -119, -119, -118, -118, -118, -119, -119, -119, -118, -118,
-118, -118, -118, -119, -119, -118, -119, -118, -119, -119, -118, -118, -118,
-118, -118, -118, -118, -119, -118, -118, -118, -118, -118, -118, -118, -118,
-118, -118, -118, -118, -118, -117, -118, -118, -117, -118, -117, -118, -118,
-118, -117, -118, -118, -118, -118, -118, -117, -117, -118, -118, -118, -118,
-118, -117, -118, -118, -118, -118, -117, -118, -117, -117, -117, -117, -117,
-118, -117, -116, -117, -117, -118, -117, -117, -117, -118, -117, -117, -118,
-117, -117, -117, -117, -117, -118, -117, -117, -117, -118, -117, -117, -117,
-117, -117, -117, -118, -117, -117, -118, -117, -117, -118, -116, -116, -117,
-117, -117, -116, -117, -118, -116, -118, -117, -116, -116, -117, -117, -117,
-116, -117, -116, -117, -116, -116, -116, -117, -116, -117, -117, -117, -117,
-117, -116, -117, -116, -117, -116, -117, -116, -116, -117, -117, -116, -116,
-116, -116, -117, -115, -117, -115, -116, -115, -117, -115, -116, -115, -117,
-115, -116, -115, -116, -115, -117, -115, -115, -117, -115, -117, -115, -117,
-113, -119, -112, -120, -112, -121, -111, -121, -110, -122, -108, -123, -107,
-126, -99, 91, };