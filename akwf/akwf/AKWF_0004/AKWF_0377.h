#define DATA_LENGTH 512
#define DATA AKWF_0377

const PROGMEM int8_t DATA[DATA_LENGTH] = {16, 18, 18, 18, 17, 18, 18, 18, 18,
18, 17, 17, 17, 17, 17, 18, 18, 18, 17, 18, 17, 18, 17, 18, 17, 18, 16, 18, 16,
20, 52, 52, 52, 52, 51, 52, 51, 51, 51, 51, 51, 51, 52, 52, 51, 53, 22, 15, 19,
16, 18, 17, 18, 16, 20, 14, 39, 55, 49, 53, 50, 53, 50, 53, 82, 87, 84, 87, 83,
87, 84, 88, 84, 88, 82, 88, 116, 124, 102, 82, 86, 85, 86, 86, 85, 85, 86, 85,
85, 85, 84, 84, 84, 85, 85, 85, 84, 86, 85, 85, 84, 85, 85, 85, 85, 86, 85, 84,
84, 84, 86, 86, 85, 85, 85, 84, 84, 85, 84, 84, 84, 85, 85, 84, 85, 85, 85, 84,
85, 85, 84, 85, 84, 85, 85, 84, 84, 85, 85, 84, 84, 84, 85, 84, 85, 85, 85, 84,
84, 85, 85, 85, 85, 84, 85, 83, 86, 82, 89, 70, 46, 52, 48, 50, 49, 51, 51, 51,
51, 50, 50, 50, 50, 51, 50, 51, 50, 50, 51, 50, 51, 50, 50, 49, 52, 21, 14, 18,
16, 17, 15, 16, 15, 17, 16, 16, 15, 16, 16, 17, 15, 16, 16, 16, 16, 16, 16, 17,
16, 16, 16, 16, 16, 16, 16, 16, 17, 15, 17, 14, 19, 10, -20, -18, -18, -18, -18,
-17, -18, -18, -18, -18, -17, -18, -17, -19, -18, -18, -17, -18, -17, -18, -18,
-18, -19, -17, -18, -18, -17, -17, -18, -18, -18, -18, -18, -18, -18, -18, -18,
-18, -18, -18, -18, -17, -18, -17, -18, -17, -17, -18, -18, -17, -18, -17, -18,
-18, -17, -18, -17, -19, -18, -18, -18, -18, -17, -18, -16, -18, -17, -18, -15,
14, 17, 16, 17, 16, 17, 16, 17, 16, 17, 16, 16, 16, 16, 16, 16, 17, 16, 17, 14,
18, 14, 19, 10, -19, -19, -16, -20, -14, -25, -53, -51, -52, -52, -50, -53, -51,
-53, -49, -55, -48, -61, -89, -85, -86, -86, -86, -86, -85, -86, -85, -87, -85,
-86, -85, -85, -85, -85, -85, -86, -85, -85, -86, -85, -85, -85, -85, -86, -85,
-85, -85, -85, -84, -86, -86, -85, -85, -85, -85, -85, -85, -85, -85, -85, -86,
-86, -85, -84, -85, -84, -86, -85, -85, -85, -85, -86, -85, -85, -85, -85, -85,
-85, -86, -85, -84, -86, -84, -88, -61, -48, -52, -49, -52, -50, -52, -50, -51,
-51, -51, -50, -51, -51, -51, -51, -51, -51, -51, -51, -50, -51, -51, -51, -51,
-51, -50, -50, -51, -50, -51, -51, -50, -51, -51, -51, -51, -51, -51, -51, -50,
-51, -50, -50, -51, -51, -50, -51, -51, -51, -50, -51, -50, -50, -51, -51, -50,
-50, -50, -50, -51, -50, -51, -51, -50, -50, -51, -50, -51, -51, -50, -50, -51,
-50, -51, -50, -51, -50, -50, -50, -50, -50, -50, -51, -48, -54, -31, -12, -19,
-14, -17, -15, -17, -16, -17, -16, -16, -17, -16, -16, -16, -16, -16, -17, -16,
-17, -15, -17, -16, -17, -15, -17, -14, };