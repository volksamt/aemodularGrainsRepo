#define DATA_LENGTH 512
#define DATA AKWF_0323

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 9, 13, 16, 19, 20, 20, 20, 22, 23,
24, 25, 25, 27, 27, 25, 26, 26, 26, 26, 27, 27, 26, 27, 26, 25, 25, 25, 25, 24,
23, 23, 21, 21, 20, 20, 20, 18, 19, 18, 18, 18, 17, 17, 15, 15, 15, 15, 15, 14,
14, 14, 13, 13, 13, 13, 12, 13, 15, 17, 20, 24, 30, 40, 50, 57, 62, 67, 69, 71,
73, 74, 75, 76, 77, 76, 77, 77, 77, 77, 75, 75, 75, 74, 74, 74, 74, 73, 73, 73,
72, 72, 71, 72, 71, 69, 69, 69, 68, 68, 67, 67, 66, 65, 65, 65, 65, 64, 63, 64,
63, 63, 63, 62, 62, 63, 62, 61, 61, 61, 62, 61, 61, 60, 59, 61, 63, 70, 76, 79,
82, 84, 85, 85, 85, 85, 85, 85, 86, 86, 86, 86, 87, 86, 86, 86, 84, 85, 84, 85,
84, 83, 83, 84, 82, 83, 82, 80, 80, 80, 79, 79, 78, 78, 77, 77, 76, 76, 75, 74,
74, 74, 74, 73, 73, 72, 72, 72, 71, 71, 71, 70, 70, 70, 69, 69, 71, 73, 74, 78,
81, 89, 97, 102, 106, 110, 113, 114, 115, 117, 116, 117, 118, 119, 119, 119,
117, 118, 118, 116, 116, 116, 116, 115, 116, 114, 115, 114, 114, 114, 113, 112,
112, 111, 110, 109, 108, 109, 108, 108, 107, 107, 106, 106, 106, 106, 105, 104,
104, 104, 103, 104, 103, 103, 103, 102, 103, 100, 100, 96, 89, 80, 65, 39, 8,
-12, -26, -41, -52, -61, -69, -75, -79, -83, -84, -85, -85, -84, -84, -85, -86,
-87, -89, -91, -94, -96, -97, -101, -103, -103, -105, -105, -107, -107, -108,
-108, -109, -110, -110, -110, -111, -111, -111, -112, -113, -113, -114, -113,
-114, -114, -115, -116, -116, -117, -117, -117, -117, -118, -117, -118, -119,
-118, -119, -119, -118, -116, -114, -113, -107, -101, -94, -88, -83, -79, -77,
-75, -74, -74, -73, -72, -71, -70, -70, -71, -71, -72, -71, -73, -73, -73, -73,
-75, -75, -75, -75, -76, -75, -76, -77, -78, -78, -80, -79, -81, -81, -80, -81,
-82, -82, -82, -84, -84, -83, -84, -85, -85, -85, -85, -86, -86, -86, -86, -87,
-87, -87, -87, -88, -88, -88, -88, -88, -88, -85, -80, -73, -69, -66, -64, -63,
-63, -63, -64, -64, -63, -62, -62, -62, -63, -62, -63, -63, -62, -64, -64, -64,
-63, -64, -65, -65, -66, -65, -67, -66, -67, -68, -69, -69, -70, -70, -71, -71,
-71, -72, -72, -74, -74, -74, -74, -75, -75, -74, -75, -76, -76, -76, -77, -76,
-77, -76, -77, -77, -78, -76, -75, -72, -70, -64, -56, -47, -40, -33, -28, -23,
-20, -18, -16, -16, -16, -14, -12, -13, -13, -14, -15, -14, -15, -16, -16, -16,
-17, -17, -17, -18, -18, -19, -19, -19, -21, -22, -21, -22, -23, -23, -25, -25,
-25, -25, -26, -26, -26, -27, -27, -27, -27, -27, -27, -27, -26, -28, -27, -27,
-27, -27, -27, -26, -25, -25, -24, -23, -20, -16, -7, };