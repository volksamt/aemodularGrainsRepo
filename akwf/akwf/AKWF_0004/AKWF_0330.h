#define DATA_LENGTH 512
#define DATA AKWF_0330

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 5, 6, 9, 11, 13, 15, 17, 19, 21,
23, 25, 28, 30, 32, 34, 36, 38, 42, 42, 45, 48, 49, 51, 54, 56, 58, 59, 61, 63,
65, 65, 68, 69, 70, 71, 72, 73, 74, 75, 75, 76, 77, 78, 79, 80, 80, 80, 81, 83,
84, 84, 85, 86, 87, 88, 89, 90, 90, 92, 93, 93, 95, 96, 97, 99, 99, 101, 102,
102, 104, 104, 105, 106, 107, 108, 108, 109, 110, 110, 110, 111, 112, 111, 112,
114, 113, 112, 113, 114, 114, 114, 114, 114, 114, 114, 114, 114, 115, 115, 115,
115, 114, 114, 116, 115, 115, 114, 115, 115, 116, 116, 116, 116, 116, 117, 116,
117, 118, 117, 118, 118, 118, 118, 117, 118, 118, 119, 119, 119, 119, 119, 119,
119, 118, 119, 118, 118, 117, 118, 117, 116, 116, 115, 115, 115, 114, 113, 113,
112, 112, 110, 110, 109, 109, 108, 108, 107, 107, 106, 106, 105, 105, 103, 103,
102, 101, 101, 100, 99, 98, 98, 97, 97, 95, 94, 94, 93, 93, 93, 91, 91, 89, 90,
88, 87, 86, 87, 86, 84, 83, 83, 81, 80, 79, 78, 77, 76, 75, 74, 72, 71, 71, 69,
68, 66, 65, 65, 63, 61, 60, 59, 58, 57, 55, 55, 53, 51, 50, 49, 48, 47, 46, 45,
44, 43, 41, 40, 39, 38, 36, 35, 34, 33, 32, 31, 29, 28, 27, 26, 25, 23, 22, 22,
20, 20, 18, 17, 16, 15, 15, 13, 12, 10, 9, 8, 6, 4, 3, 1, 0, -1, -4, -5, -7, -9,
-12, -13, -16, -17, -20, -21, -24, -27, -29, -31, -33, -35, -37, -39, -41, -42,
-44, -46, -49, -50, -52, -52, -54, -55, -56, -57, -59, -59, -60, -61, -63, -63,
-64, -65, -66, -67, -68, -69, -70, -70, -71, -72, -74, -74, -75, -76, -77, -78,
-78, -79, -80, -82, -83, -84, -85, -86, -87, -87, -89, -90, -91, -93, -92, -93,
-94, -96, -97, -97, -98, -100, -101, -101, -102, -103, -104, -105, -105, -106,
-108, -108, -109, -109, -109, -110, -111, -112, -112, -112, -114, -114, -114,
-115, -116, -115, -115, -116, -116, -117, -117, -118, -117, -119, -118, -119,
-119, -119, -118, -119, -119, -119, -118, -119, -119, -120, -120, -120, -119,
-119, -119, -119, -119, -119, -119, -118, -118, -118, -118, -118, -118, -118,
-118, -118, -117, -117, -117, -117, -117, -116, -117, -116, -115, -115, -114,
-114, -112, -112, -111, -111, -111, -110, -110, -109, -109, -109, -108, -107,
-107, -106, -107, -106, -105, -105, -105, -104, -104, -105, -104, -103, -103,
-102, -102, -102, -102, -102, -101, -100, -100, -99, -100, -98, -98, -98, -97,
-96, -95, -95, -94, -94, -92, -91, -92, -91, -90, -89, -87, -86, -85, -85, -84,
-82, -80, -79, -78, -77, -75, -73, -72, -71, -69, -67, -65, -64, -63, -61, -59,
-57, -54, -53, -50, -49, -47, -45, -43, -41, -39, -38, -34, -33, -32, -29, -28,
-25, -24, -22, -20, -19, -16, -15, -12, -10, -8, -6, -4, -2, -1, };