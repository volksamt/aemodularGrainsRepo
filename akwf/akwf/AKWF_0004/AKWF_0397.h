#define DATA_LENGTH 512
#define DATA AKWF_0397

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 5, 8, 10, 12, 14, 17, 19, 22,
25, 29, 31, 34, 37, 39, 42, 45, 49, 52, 54, 57, 60, 63, 66, 69, 72, 74, 76, 80,
82, 84, 86, 88, 90, 92, 94, 97, 99, 100, 102, 103, 104, 106, 107, 109, 110, 111,
112, 114, 115, 115, 115, 116, 117, 118, 118, 118, 119, 118, 119, 119, 119, 119,
119, 119, 119, 118, 118, 118, 118, 117, 117, 117, 116, 115, 114, 115, 113, 113,
112, 111, 110, 110, 109, 108, 107, 107, 105, 104, 103, 102, 101, 100, 99, 98,
97, 96, 95, 93, 92, 91, 89, 88, 87, 86, 85, 83, 81, 80, 78, 77, 75, 73, 72, 71,
69, 67, 66, 63, 62, 60, 59, 57, 56, 53, 52, 49, 47, 46, 43, 41, 40, 37, 35, 34,
32, 30, 27, 26, 24, 22, 21, 19, 17, 17, 16, 15, 13, 13, 13, 11, 11, 11, 10, 10,
10, 8, 8, 8, 7, 7, 7, 6, 6, 6, 7, 6, 5, 5, 5, 5, 5, 5, 5, 4, 5, 4, 4, 4, 3, 3,
4, 5, 3, 4, 3, 4, 3, 4, 4, 4, 4, 5, 4, 5, 4, 4, 5, 5, 6, 5, 5, 5, 6, 5, 6, 7, 8,
7, 7, 8, 9, 8, 9, 9, 9, 10, 10, 11, 10, 11, 11, 12, 13, 14, 14, 14, 15, 15, 15,
16, 16, 18, 17, 17, 18, 19, 19, 20, 20, 21, 22, 22, 23, 24, 24, 25, 25, 25, 27,
27, 25, 14, -8, -34, -50, -54, -51, -42, -34, -28, -25, -23, -23, -23, -22, -23,
-22, -21, -20, -19, -19, -19, -18, -17, -17, -16, -16, -15, -15, -14, -14, -13,
-13, -13, -11, -12, -12, -11, -10, -10, -10, -10, -9, -9, -9, -8, -7, -7, -7,
-6, -7, -7, -7, -6, -5, -5, -6, -5, -5, -4, -4, -5, -5, -4, -4, -4, -4, -4, -4,
-4, -4, -4, -4, -4, -3, -4, -3, -4, -4, -3, -4, -5, -4, -5, -5, -5, -5, -5, -6,
-6, -5, -6, -6, -7, -6, -7, -8, -8, -8, -9, -8, -9, -10, -10, -11, -11, -12,
-12, -13, -13, -16, -16, -17, -18, -20, -21, -22, -24, -26, -28, -30, -32, -33,
-35, -38, -39, -41, -43, -45, -47, -50, -51, -53, -54, -57, -58, -61, -62, -64,
-65, -67, -69, -71, -72, -74, -75, -77, -77, -80, -81, -82, -84, -86, -87, -88,
-89, -91, -91, -93, -94, -95, -97, -98, -99, -100, -101, -103, -103, -104, -105,
-106, -107, -108, -108, -110, -111, -112, -112, -113, -113, -113, -114, -115,
-115, -117, -116, -117, -118, -118, -118, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -118, -118, -119, -117, -117, -116, -116, -115, -115, -113,
-113, -112, -111, -109, -108, -106, -105, -104, -102, -100, -99, -97, -95, -92,
-90, -88, -86, -84, -82, -80, -77, -74, -71, -69, -67, -63, -60, -58, -55, -52,
-49, -46, -44, -40, -38, -34, -31, -29, -25, -23, -21, -17, -15, -13, -11, -8,
-5, -4, -1, -1, };