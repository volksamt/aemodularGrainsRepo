#define DATA_LENGTH 512
#define DATA AKWF_0318

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 7, 8, 10, 12, 14, 16, 17,
18, 21, 22, 23, 24, 26, 27, 29, 31, 33, 34, 36, 38, 40, 40, 43, 43, 45, 46, 48,
49, 50, 52, 53, 55, 55, 57, 58, 59, 60, 61, 62, 63, 65, 65, 67, 67, 68, 69, 71,
71, 73, 72, 73, 75, 75, 76, 77, 78, 78, 79, 79, 80, 81, 82, 83, 83, 84, 85, 85,
85, 86, 87, 87, 88, 88, 87, 88, 88, 89, 89, 89, 89, 90, 89, 91, 91, 90, 91, 91,
91, 92, 92, 92, 92, 93, 92, 93, 94, 94, 93, 95, 95, 94, 94, 94, 95, 96, 96, 96,
96, 96, 95, 96, 96, 96, 96, 96, 95, 95, 95, 95, 95, 94, 94, 94, 93, 93, 94, 92,
92, 91, 90, 89, 87, 85, 82, 78, 71, 63, 58, 55, 52, 49, 46, 40, 36, 32, 26, 23,
18, 14, 9, 4, 0, -4, -8, -12, -16, -19, -23, -27, -30, -33, -36, -37, -40, -43,
-46, -48, -50, -52, -55, -57, -57, -61, -62, -63, -65, -66, -68, -70, -71, -71,
-72, -74, -74, -76, -77, -77, -78, -79, -80, -80, -81, -82, -82, -83, -82, -83,
-84, -84, -84, -86, -86, -87, -87, -88, -88, -88, -88, -89, -90, -90, -89, -91,
-90, -91, -90, -91, -91, -91, -91, -91, -91, -92, -91, -91, -91, -90, -91, -90,
-91, -90, -90, -89, -89, -89, -89, -88, -88, -88, -87, -86, -85, -86, -84, -85,
-84, -83, -82, -82, -82, -80, -78, -78, -78, -77, -75, -73, -73, -71, -71, -70,
-68, -68, -66, -64, -63, -61, -61, -59, -57, -57, -55, -53, -53, -50, -49, -47,
-46, -44, -44, -42, -41, -39, -37, -36, -34, -33, -31, -29, -29, -27, -25, -24,
-23, -22, -20, -18, -17, -16, -15, -14, -12, -11, -10, -8, -7, -6, -6, -4, -3,
-2, -1, 1, 1, 3, 4, 4, 5, 7, 7, 9, 9, 10, 12, 12, 13, 15, 15, 16, 15, 14, 15,
16, 18, 18, 18, 19, 19, 20, 20, 21, 21, 22, 22, 22, 22, 24, 23, 24, 25, 25, 25,
26, 26, 27, 28, 28, 27, 27, 28, 29, 29, 29, 29, 29, 29, 29, 30, 30, 30, 29, 30,
30, 29, 29, 30, 29, 29, 29, 29, 27, 27, 27, 26, 25, 25, 23, 22, 21, 21, 20, 20,
18, 18, 17, 15, 15, 14, 12, 11, 10, 8, 8, 7, 6, 5, 4, 3, 2, 0, 0, -2, -3, -3,
-4, -5, -6, -7, -8, -8, -9, -10, -10, -11, -12, -12, -13, -14, -15, -15, -15,
-16, -17, -17, -17, -17, -18, -19, -18, -19, -19, -19, -19, -21, -21, -20, -20,
-20, -21, -21, -22, -21, -21, -21, -21, -22, -21, -22, -24, -23, -24, -23, -23,
-23, -23, -23, -23, -24, -24, -24, -24, -24, -23, -24, -24, -23, -24, -22, -23,
-23, -23, -22, -22, -21, -21, -21, -20, -20, -19, -18, -17, -16, -16, -15, -15,
-14, -13, -12, -11, -10, -8, -8, -7, -6, -4, -3, -2, -1, };