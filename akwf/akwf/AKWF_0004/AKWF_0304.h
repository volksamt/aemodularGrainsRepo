#define DATA_LENGTH 512
#define DATA AKWF_0304

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, -2, 2, -3, 5, -8, 14, -65,
-128, -92, -95, -75, -71, -56, -50, -37, -30, -20, -12, -4, 3, 10, 17, 23, 28,
33, 38, 42, 46, 49, 52, 54, 56, 57, 60, 59, 60, 60, 60, 59, 59, 57, 56, 54, 51,
50, 47, 45, 41, 39, 36, 34, 31, 27, 24, 21, 17, 15, 11, 7, 4, 1, -2, -5, -7,
-11, -13, -16, -18, -20, -22, -24, -26, -29, -31, -32, -33, -35, -35, -37, -38,
-38, -39, -39, -40, -39, -40, -39, -39, -39, -38, -37, -38, -36, -35, -35, -32,
-32, -30, -30, -28, -27, -26, -23, -23, -21, -20, -18, -16, -15, -13, -11, -10,
-8, -6, -5, -4, -2, -1, 1, 2, 4, 4, 6, 7, 8, 10, 11, 11, 12, 14, 14, 16, 16, 16,
18, 17, 17, 18, 18, 18, 19, 19, 19, 19, 19, 18, 19, 19, 18, 18, 18, 18, 16, 17,
17, 16, 15, 14, 13, 14, 13, 13, 12, 11, 11, 10, 9, 8, 8, 7, 6, 6, 5, 5, 4, 4, 2,
2, 2, 1, 0, 0, -1, -1, -2, -1, -2, -3, -3, -4, -4, -4, -4, -4, -6, -5, -6, -7,
-7, -6, -6, -7, -7, -6, -7, -6, -7, -6, -6, -6, -6, -7, -6, -6, -6, -7, -6, -6,
-6, -5, -5, -6, -5, -4, -4, -5, -4, -4, -4, -3, -3, -3, -3, -2, -2, -2, -3, -2,
-1, -1, 0, -1, 0, 0, 0, -1, 0, 0, 1, 0, 1, 0, 1, 1, 1, 1, 1, 1, 2, 1, 1, 2, 1,
2, 2, 1, 2, 2, 2, 2, 2, 2, 2, 3, 2, 1, 2, 2, 1, 2, 2, 2, 2, 1, 2, 2, 2, 2, 2, 1,
1, 2, 1, 1, 1, 1, 0, 0, 1, 1, 1, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0,
0, -1, -1, -1, -1, 0, -1, -1, 0, -1, -1, -1, 0, -1, -1, -1, -1, -1, -1, -2, 0,
0, -1, 0, 0, 0, 0, -1, -1, -1, -1, -1, -1, 0, -1, 0, -1, 0, -1, 0, 0, -1, 0, -1,
0, 0, -1, 0, -1, 1, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0,
0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0,
0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1, 1, -1, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1,
1, 0, 1, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0,
-1, 1, 0, -1, 0, 1, 0, 0, -1, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1, };