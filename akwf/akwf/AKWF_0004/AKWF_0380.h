#define DATA_LENGTH 512
#define DATA AKWF_0380

const PROGMEM int8_t DATA[DATA_LENGTH] = {22, 25, 23, 25, 24, 25, 23, 25, 23,
25, 23, 25, 25, 24, 23, 25, 24, 24, 25, 24, 24, 24, 25, 24, 24, 24, 24, 24, 24,
24, 24, 24, 24, 24, 24, 24, 24, 25, 25, 24, 25, 25, 24, 25, 24, 24, 24, 24, 24,
25, 25, 25, 24, 25, 24, 24, 24, 24, 24, 24, 24, 25, 24, 25, 23, 25, 23, 24, 25,
25, 24, 24, 24, 24, 24, 25, 24, 24, 24, 24, 24, 25, 24, 25, 24, 24, 25, 24, 25,
25, 24, 25, 25, 25, 24, 25, 24, 24, 25, 25, 24, 24, 24, 24, 24, 24, 24, 24, 24,
24, 25, 24, 24, 24, 25, 24, 24, 23, 24, 24, 24, 24, 24, 25, 24, 24, 23, 24, 24,
24, 24, 24, 25, 25, 23, 24, 25, 24, 24, 24, 24, 24, 24, 24, 24, 24, 25, 24, 24,
24, 24, 24, 23, 25, 25, 23, 24, 23, 24, 23, 23, 23, 24, 24, 24, 24, 24, 24, 25,
24, 24, 23, 24, 24, 24, 24, 24, 24, 23, 25, 24, 24, 23, 24, 24, 25, 24, 24, 24,
24, 24, 24, 24, 24, 25, 23, 24, 23, 24, 24, 24, 23, 25, 24, 25, 23, 24, 23, 25,
24, 24, 23, 24, 23, 24, 25, 22, 27, 16, 91, 127, 110, 127, 94, 69, 73, 71, 71,
71, 72, 72, 72, 71, 72, 71, 71, 72, 70, 72, 70, 72, 70, 72, 70, 72, 70, 73, 68,
73, 68, 74, 67, 74, 67, 76, 63, -69, -73, -70, -74, -70, -74, -69, -74, -69,
-74, -70, -73, -70, -72, -70, -74, -71, -73, -70, -72, -70, -73, -71, -73, -71,
-73, -71, -72, -70, -75, -68, -92, -127, -113, -125, -111, -128, -70, -13, -29,
-20, -26, -22, -25, -23, -25, -23, -24, -23, -24, -24, -24, -24, -23, -24, -24,
-24, -24, -24, -24, -25, -24, -24, -24, -24, -24, -24, -24, -23, -23, -23, -24,
-24, -23, -23, -24, -23, -24, -24, -24, -24, -24, -23, -23, -23, -23, -24, -24,
-24, -24, -24, -24, -23, -23, -24, -24, -24, -24, -25, -24, -23, -24, -24, -24,
-24, -23, -24, -23, -23, -23, -24, -23, -24, -23, -24, -23, -23, -24, -24, -24,
-24, -24, -24, -24, -23, -23, -24, -23, -24, -24, -24, -23, -23, -23, -23, -24,
-23, -23, -23, -24, -23, -23, -24, -24, -24, -23, -24, -23, -24, -23, -23, -24,
-23, -24, -24, -24, -23, -23, -24, -23, -24, -23, -24, -23, -23, -24, -23, -24,
-23, -24, -23, -23, -24, -23, -23, -23, -24, -23, -24, -24, -24, -24, -24, -24,
-23, -23, -24, -24, -24, -23, -23, -24, -24, -23, -23, -23, -23, -23, -23, -24,
-24, -24, -23, -24, -23, -23, -24, -23, -23, -23, -23, -23, -23, -23, -24, -23,
-23, -23, -23, -24, -23, -23, -23, -24, -23, -24, -23, -24, -23, -24, -23, -24,
-23, -23, -24, -22, -24, -23, -23, -23, -23, -23, -23, -23, -23, -23, -24, -22,
-24, -22, -23, -22, -25, -22, -24, -20, };