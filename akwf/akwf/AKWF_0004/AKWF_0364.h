#define DATA_LENGTH 512
#define DATA AKWF_0364

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 8, 12, 16, 20, 23, 27, 30, 32, 34,
36, 39, 42, 43, 45, 47, 48, 49, 50, 51, 53, 54, 54, 54, 56, 56, 57, 57, 56, 57,
56, 57, 57, 56, 55, 56, 58, 59, 61, 64, 66, 67, 68, 69, 70, 72, 73, 74, 75, 75,
75, 77, 78, 79, 78, 79, 79, 79, 80, 79, 80, 80, 81, 80, 80, 80, 80, 79, 78, 78,
77, 77, 76, 75, 74, 74, 72, 71, 71, 70, 68, 67, 66, 64, 63, 61, 60, 59, 56, 55,
54, 51, 49, 47, 46, 44, 42, 40, 38, 40, 54, 66, 70, 74, 78, 82, 85, 89, 89, 91,
89, 88, 86, 82, 77, 73, 69, 66, 63, 61, 58, 57, 55, 57, 68, 76, 78, 78, 79, 79,
82, 84, 84, 84, 87, 93, 98, 96, 91, 85, 79, 72, 65, 57, 49, 42, 32, 23, 15, 4,
-6, -15, -23, -30, -37, -43, -49, -54, -60, -64, -68, -72, -75, -78, -81, -83,
-86, -88, -89, -91, -93, -93, -94, -96, -96, -98, -98, -99, -99, -100, -100,
-99, -100, -100, -99, -100, -99, -99, -98, -97, -96, -96, -95, -94, -94, -93,
-91, -90, -90, -87, -87, -85, -84, -83, -81, -80, -79, -76, -75, -73, -72, -70,
-68, -67, -65, -63, -62, -59, -57, -56, -56, -56, -56, -56, -57, -57, -57, -58,
-57, -58, -58, -59, -58, -59, -59, -59, -59, -59, -59, -59, -60, -59, -59, -59,
-59, -59, -58, -58, -57, -58, -57, -56, -56, -56, -55, -55, -54, -53, -53, -51,
-51, -50, -49, -49, -48, -47, -46, -45, -43, -42, -41, -40, -39, -38, -36, -34,
-34, -32, -31, -29, -28, -28, -25, -24, -23, -21, -20, -19, -18, -15, -14, -13,
-12, -10, -9, -7, -5, -5, -4, -2, 0, 1, 2, 3, 4, 5, 7, 7, 8, 9, 10, 10, 12, 12,
13, 14, 15, 15, 16, 17, 16, 18, 18, 19, 19, 20, 20, 20, 20, 21, 21, 21, 21, 11,
-14, -30, -34, -36, -38, -41, -42, -44, -45, -46, -47, -49, -50, -52, -54, -56,
-58, -60, -61, -62, -61, -62, -62, -60, -59, -57, -56, -54, -51, -48, -45, -41,
-36, -33, -28, -24, -19, -13, -8, -3, 3, 8, 14, 18, 22, 28, 32, 36, 40, 44, 47,
50, 53, 55, 58, 60, 62, 65, 67, 69, 70, 71, 73, 74, 74, 76, 76, 77, 79, 79, 79,
80, 80, 80, 80, 80, 80, 80, 79, 79, 79, 78, 78, 77, 76, 76, 75, 74, 74, 72, 72,
70, 69, 68, 67, 66, 64, 62, 60, 60, 57, 56, 54, 53, 52, 50, 48, 47, 46, 43, 43,
40, 38, 37, 35, 33, 31, 30, 28, 26, 25, 24, 21, 20, 18, 17, 15, 14, 11, -5, -26,
-36, -41, -45, -50, -55, -62, -68, -77, -90, -99, -103, -105, -108, -111, -115,
-118, -119, -118, -118, -115, -112, -108, -106, -102, -99, -97, -92, -89, -84,
-81, -77, -72, -68, -63, -59, -55, -49, -44, -40, -35, -30, -25, -20, -15, -10,
-4, -1, };