#define DATA_LENGTH 512
#define DATA AKWF_0301

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 13, 17, 22, 30, 35, 43, 49, 57,
63, 71, 78, 86, 93, 97, 104, 108, 113, 115, 118, 119, 119, 117, 116, 113, 108,
102, 97, 89, 81, 71, 62, 53, 42, 32, 21, 10, 0, -12, -21, -31, -41, -51, -58,
-67, -74, -81, -86, -92, -96, -100, -103, -105, -106, -107, -108, -107, -106,
-104, -102, -100, -97, -94, -90, -87, -83, -78, -74, -70, -65, -60, -56, -52,
-47, -42, -38, -34, -29, -26, -22, -18, -15, -10, -7, -5, -1, 1, 5, 6, 9, 10,
13, 14, 16, 17, 19, 19, 21, 22, 22, 24, 24, 23, 24, 24, 24, 24, 25, 24, 24, 24,
24, 24, 24, 23, 22, 22, 21, 22, 21, 20, 20, 20, 19, 18, 18, 17, 17, 16, 15, 15,
15, 14, 12, 13, 12, 12, 12, 11, 11, 10, 10, 9, 9, 8, 8, 8, 7, 6, 7, 6, 6, 5, 6,
5, 4, 4, 4, 4, 3, 4, 4, 3, 3, 3, 2, 3, 2, 2, 3, 1, 2, 1, 2, 1, 2, 2, 1, 1, 1, 1,
1, 2, 2, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 2, 2, 1, 2, 2, 2, 2, 2, 3, 3,
3, 4, 3, 4, 5, 5, 4, 5, 6, 6, 6, 6, 6, 7, 8, 9, 10, 9, 10, 10, 10, 12, 12, 13,
14, 14, 16, 16, 16, 17, 18, 18, 18, 17, 18, 19, 18, 18, 17, 16, 15, 13, 11, 10,
7, 4, 2, -4, -8, -13, -17, -23, -29, -36, -42, -51, -58, -65, -72, -79, -86,
-92, -99, -105, -108, -113, -116, -118, -119, -119, -118, -115, -112, -108,
-102, -95, -89, -81, -72, -62, -51, -41, -31, -20, -9, 2, 13, 23, 33, 43, 51,
60, 68, 75, 82, 88, 92, 96, 100, 103, 105, 107, 106, 107, 107, 106, 104, 102,
99, 97, 93, 89, 86, 82, 78, 74, 70, 65, 60, 55, 51, 47, 42, 38, 32, 29, 25, 21,
17, 13, 10, 8, 4, 2, -2, -4, -6, -9, -11, -13, -15, -16, -18, -20, -20, -21,
-22, -22, -23, -23, -24, -24, -24, -25, -25, -25, -24, -24, -25, -23, -24, -24,
-24, -23, -22, -22, -20, -21, -20, -20, -19, -19, -18, -18, -17, -16, -15, -15,
-16, -15, -14, -13, -13, -12, -12, -12, -12, -10, -10, -10, -9, -10, -8, -7, -8,
-8, -7, -7, -7, -5, -6, -5, -6, -5, -5, -5, -5, -3, -3, -3, -3, -3, -3, -3, -2,
-2, -2, -3, -2, -2, -2, -2, -2, -2, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1,
-1, -1, 0, -1, -1, -1, -2, -1, -2, -1, -2, -2, -2, -2, -2, -3, -3, -3, -3, -3,
-3, -3, -4, -3, -4, -3, -4, -6, -5, -5, -6, -6, -6, -7, -7, -9, -8, -10, -9,
-10, -11, -11, -12, -13, -12, -13, -14, -15, -15, -16, -16, -17, -18, -18, -19,
-17, -18, -18, -17, -17, -16, -15, -13, -12, -10, -7, -4, 0, };