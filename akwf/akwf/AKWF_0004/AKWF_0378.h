#define DATA_LENGTH 512
#define DATA AKWF_0378

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 12, 13, 12, 13, 13, 13, 13, 12,
14, 11, 49, 59, 55, 58, 55, 57, 56, 57, 56, 57, 56, 57, 55, 56, 56, 57, 56, 56,
56, 56, 56, 56, 56, 56, 56, 56, 56, 56, 56, 56, 56, 56, 56, 57, 55, 56, 55, 58,
51, 83, 104, 96, 101, 98, 101, 98, 100, 99, 100, 98, 99, 99, 100, 99, 99, 99,
99, 99, 99, 100, 98, 100, 99, 100, 98, 101, 96, 104, 72, 51, 59, 54, 57, 54, 56,
55, 56, 55, 55, 55, 55, 56, 56, 55, 55, 56, 55, 56, 55, 56, 55, 56, 55, 55, 56,
55, 56, 55, 57, 55, 57, 55, 56, 55, 55, 95, 101, 98, 100, 97, 100, 99, 99, 98,
99, 98, 99, 98, 99, 98, 99, 98, 99, 99, 99, 98, 98, 99, 98, 100, 98, 100, 98,
99, 98, 99, 98, 98, 98, 99, 98, 98, 98, 98, 100, 62, 51, 57, 53, 56, 55, 55, 54,
56, 55, 55, 55, 56, 55, 56, 54, 54, 54, 54, 54, 55, 56, 55, 55, 55, 55, 55, 55,
55, 55, 55, 55, 54, 55, 54, 55, 55, 54, 55, 55, 55, 55, 54, 55, 55, 54, 55, 54,
56, 53, 59, 26, 7, 14, 9, 13, 10, 12, 11, 12, 10, 12, 11, 11, 10, 11, 10, 12,
11, 11, 11, 11, 11, 12, 11, 11, 11, 11, 12, 10, 11, 10, 12, 10, 13, 9, 13, 8,
14, 5, 30, 58, 53, 54, 11, 10, 12, 10, 12, 10, 13, 10, 12, 10, 12, 49, 58, 52,
57, 52, 57, 51, 56, 52, 56, 51, 58, 48, 10, 11, 11, 10, 11, 11, 11, 10, 11, 11,
12, 11, 11, 10, 12, 11, 12, 11, 10, 11, 11, 11, 11, 11, 10, 11, 10, 12, 11, 11,
10, 12, 10, 12, 10, 12, 10, 11, 10, 12, 6, -35, -27, -61, -80, -73, -78, -75,
-77, -75, -77, -75, -77, -75, -77, -72, -112, -121, -117, -120, -118, -120,
-118, -120, -119, -119, -118, -120, -118, -119, -119, -119, -119, -120, -118,
-119, -118, -120, -119, -118, -119, -119, -120, -119, -118, -118, -119, -118,
-119, -119, -120, -119, -119, -118, -119, -119, -118, -119, -118, -119, -118,
-119, -118, -120, -118, -121, -117, -120, -116, -122, -108, -71, -76, -75, -76,
-75, -75, -75, -75, -75, -74, -75, -74, -76, -75, -75, -75, -76, -75, -75, -74,
-75, -75, -75, -75, -75, -75, -75, -75, -75, -74, -75, -75, -75, -74, -74, -76,
-75, -74, -75, -74, -74, -74, -74, -75, -75, -74, -75, -74, -75, -75, -75, -74,
-75, -74, -74, -73, -74, -75, -75, -74, -74, -74, -74, -75, -75, -74, -75, -75,
-75, -74, -74, -74, -74, -75, -75, -74, -75, -75, -75, -74, -75, -74, -73, -74,
-74, -74, -73, -75, -74, -75, -74, -75, -74, -74, -74, -75, -74, -73, -75, -72,
-78, -42, -27, -33, -29, -33, -29, -31, -29, -31, -30, -31, -30, -31, -30, -30,
-30, -31, -30, -31, -30, -31, -29, -31, -29, -32, -26, };