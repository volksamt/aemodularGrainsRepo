#define DATA_LENGTH 512
#define DATA AKWF_0316

const PROGMEM int8_t DATA[DATA_LENGTH] = {20, 52, 79, 101, 113, 119, 117, 109,
97, 82, 65, 48, 31, 15, 3, -9, -18, -23, -27, -25, -23, -19, -14, -9, -4, 1, 4,
7, 7, 7, 8, 7, 5, 3, 1, 1, 0, 0, 0, 0, 2, 2, 3, 4, 5, 5, 4, 4, 4, 4, 4, 3, 2, 2,
1, 1, 0, 0, 1, 1, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, -1, 0, -1, 1, 0, 0,
0, 0, 0, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0,
1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 1, -2, -21, -45, -48, -45, -37,
-23, -3, 18, 34, 47, 55, 55, 51, 42, 31, 18, 5, -5, -14, -21, -24, -24, -22,
-18, -13, -8, -2, 2, 5, 8, 8, 9, 8, 7, 5, 2, 1, -1, -2, -3, -3, -3, -3, -1, -1,
0, 0, 1, 2, 2, 3, 2, 1, 2, 0, 0, 0, 0, -1, -1, -1, 0, -1, 0, 0, 0, 0, 0, 0, 1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, -1, 0, 0, 0, -1, 0,
0, -1, 0, -1, -1, 0, 0, 1, 1, -1, 0, -1, 0, -1, -1, 0, 0, 0, 0, 1, 0, 0, -1, -1,
-1, 0, 0, -1, -10, -35, -58, -68, -69, -75, -72, -47, -16, 11, 39, 62, 76, 83,
84, 80, 72, 60, 47, 32, 18, 4, -7, -17, -25, -28, -31, -30, -27, -22, -17, -12,
-8, -3, 0, 3, 4, 5, 4, 2, 2, 0, -1, -3, -2, -2, -2, -2, -1, 0, 0, 2, 2, 4, 3, 3,
2, 3, 2, 2, 1, 0, 0, 0, -1, 0, 0, -1, -2, -1, -1, 0, -1, -1, 0, -1, 0, 0, -1,
-1, 0, -1, 0, -1, -1, -1, -1, -1, -1, 0, -1, -1, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0,
-1, 0, 0, 0, -1, -1, -1, 0, 0, 0, -1, -1, -1, -1, -1, -1, -1, -1, -1, 0, 0, 0,
-1, -1, 0, -1, 0, 0, 0, 0, -4, -25, -46, -48, -45, -36, -21, 0, 18, 36, 47, 54,
54, 49, 41, 28, 16, 4, -7, -15, -22, -24, -25, -22, -18, -14, -8, -3, 1, 5, 8,
9, 8, 8, 6, 4, 2, 1, -1, -2, -3, -3, -4, -4, -2, -1, -1, -1, 1, 1, 1, 1, 1, 1,
1, 0, 0, -1, -1, -1, -1, -1, -2, -1, -1, 0, -1, 0, -1, 0, 0, 0, 0, -1, 0, -1,
-1, -1, -1, -1, -1, -1, -1, 0, 0, -1, 0, 0, 0, 0, -1, 0, -1, -1, 0, -1, -1, 0,
-1, -1, -1, 0, -1, -1, -1, 0, -1, 0, -1, -1, -1, 0, 0, -2, -14, -37, -62, -76,
-80, -75, -68, -60, -53, -46, -47, -61, -67, -64, -52, -49, -37, -7, };