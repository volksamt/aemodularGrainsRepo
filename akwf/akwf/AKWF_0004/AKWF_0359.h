#define DATA_LENGTH 512
#define DATA AKWF_0359

const PROGMEM int8_t DATA[DATA_LENGTH] = {-17, -58, -87, -104, -116, -119, -117,
-112, -105, -96, -86, -75, -64, -54, -44, -35, -28, -21, -15, -8, -6, -2, 2, 4,
5, 6, 7, 7, 7, 7, 7, 8, 7, 7, 6, 5, 5, 4, 5, 4, 3, 4, 4, 3, 3, 3, 3, 3, 2, 2, 3,
3, 3, 3, 3, 3, 2, 2, 3, 3, 3, 3, 2, 3, 2, 3, 3, 3, 3, 3, 3, 3, 2, 3, 2, 3, 3, 3,
3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 2, 3, 2, 2, 2, 3, 3, 3,
3, 3, 3, 3, 3, 4, 3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 3, 3, 2, 3, 2, 3, 2, 3, 4, 3, 3,
3, 2, 2, 3, 3, 2, 3, 3, 3, 2, 3, 3, 3, 3, 3, 3, 3, 2, 2, 3, 4, 2, 3, 2, 3, 2, 3,
2, 3, 3, 3, 2, 3, 2, 3, 3, 2, 3, 3, 2, 2, 3, 3, 3, 2, 2, 2, 2, 3, 3, 3, 3, 3, 3,
3, 3, 3, 3, 2, 3, 2, 3, 2, 3, 3, 3, 3, 2, 3, 3, 3, 3, 2, 3, 3, 3, 3, 2, 3, 3, 2,
3, 3, 3, 3, 3, 3, 3, 3, 2, 3, 3, 2, 2, 3, 4, 3, 3, 2, 2, 3, 3, 3, 2, 2, 2, 2, 3,
3, 3, 2, 2, 3, 2, 2, 3, 3, 3, 3, 2, 2, 2, 3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 3, 2, 3,
3, 3, 2, 3, 2, 3, 3, 3, 3, 2, 3, 3, 3, 3, 3, 2, 3, 2, 3, 2, 3, 3, 3, 3, 3, 3, 3,
3, 2, 3, 3, 3, 3, 2, 3, 3, 3, 2, 3, 3, 2, 3, 3, 3, 3, 3, 3, 2, 2, 3, 3, 3, 3, 3,
3, 2, 3, 3, 3, 3, 2, 3, 3, 3, 3, 3, 2, 2, 3, 3, 3, 3, 2, 3, 3, 3, 3, 3, 2, 3, 3,
3, 3, 3, 2, 3, 3, 3, 3, 2, 3, 3, 3, 2, 3, 3, 3, 2, 3, 3, 3, 3, 3, 2, 3, 2, 3, 2,
4, 3, 3, 3, 2, 2, 3, 3, 2, 3, 3, 4, 3, 3, 3, 4, 3, 2, 3, 3, 3, 3, 3, 2, 3, 3, 2,
3, 3, 2, 2, 3, 3, 3, 3, 3, 3, 2, 3, 2, 3, 3, 2, 3, 3, 2, 3, 3, 3, 2, 3, 2, 3, 2,
2, 3, 2, 3, 3, 3, 3, 2, 2, 2, 3, 3, 4, 3, 2, 2, 2, 3, 3, 2, 3, 2, 3, 3, 2, 3, 3,
4, 3, 2, 2, 2, 3, 3, 3, 2, 3, 2, 3, 3, 3, 3, 3, 2, 3, 3, 3, 2, 2, 3, 3, 3, 2, 3,
2, 3, 2, 3, 3, 2, 2, 2, 3, 3, 3, 3, 3, 3, 2, 4, 3, 3, 3, 3, 2, 2, 3, 3, 3, 2, 2,
2, 2, };