#define DATA_LENGTH 512
#define DATA AKWF_0312

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 23, 36, 49, 61, 74, 84, 94, 103,
109, 113, 117, 119, 119, 117, 114, 108, 100, 93, 84, 73, 61, 49, 35, 22, 9, -5,
-18, -30, -42, -54, -63, -72, -80, -86, -91, -95, -98, -97, -97, -94, -90, -86,
-79, -73, -63, -55, -45, -36, -26, -14, -4, 6, 16, 25, 34, 43, 50, 56, 61, 66,
69, 71, 73, 73, 72, 70, 67, 62, 57, 52, 45, 39, 31, 23, 16, 7, -1, -8, -14, -22,
-27, -33, -38, -42, -47, -49, -52, -52, -53, -52, -51, -50, -46, -42, -39, -34,
-30, -25, -19, -13, -8, -2, 3, 8, 14, 18, 24, 27, 31, 33, 36, 38, 38, 39, 39,
38, 36, 35, 33, 31, 27, 24, 20, 16, 13, 8, 4, 0, -4, -7, -12, -14, -17, -19,
-22, -24, -25, -26, -28, -28, -28, -26, -26, -23, -22, -20, -17, -15, -12, -10,
-6, -3, 0, 3, 5, 9, 11, 13, 15, 17, 19, 19, 21, 22, 21, 21, 21, 20, 19, 18, 17,
15, 13, 11, 9, 7, 5, 3, 0, -1, -3, -5, -8, -9, -10, -11, -12, -13, -14, -14,
-14, -14, -13, -13, -13, -11, -10, -10, -7, -6, -4, -3, -1, 1, 2, 3, 5, 5, 8, 8,
9, 11, 11, 11, 11, 11, 12, 11, 10, 10, 10, 9, 7, 6, 5, 5, 4, 2, 1, 0, -2, -3,
-4, -5, -6, -6, -7, -7, -8, -8, -8, -9, -8, -8, -8, -8, -7, -6, -6, -5, -4, -4,
-3, -2, -1, 0, 1, 1, 3, 3, 3, 4, 4, 4, 4, 5, 6, 4, 5, 4, 4, 3, 3, 3, 2, 2, 1, 1,
0, -1, -2, -1, -2, -3, -3, -3, -4, -4, -4, -4, -5, -5, -5, -5, -5, -5, -5, -4,
-4, -4, -3, -3, -2, -1, -1, -1, -1, 0, 1, 0, 0, 2, 3, 2, 2, 3, 2, 2, 2, 2, 2, 1,
2, 2, 1, 2, 1, 1, 0, 0, -1, 0, -1, -1, -2, -2, -2, -3, -2, -2, -2, -3, -2, -3,
-3, -3, -2, -2, -2, -1, -2, -1, -1, -1, 0, -1, 1, -1, 0, 0, 1, 1, 0, 2, 1, 1, 1,
2, 1, 1, 1, 1, 2, 2, 1, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, -1, -2, -1, -2, -1, -1,
-2, -2, -1, -1, -2, -2, -1, -1, -2, -1, -1, -1, 0, 0, -1, -1, -1, 0, 0, 0, 0, 0,
1, 0, 1, 0, 0, 1, 0, 1, 1, 1, 1, 0, 0, 1, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, -1, 0,
0, 0, -1, -1, 0, -2, 0, 0, -2, -1, -1, -1, -1, -1, 0, -1, 0, -1, 0, 0, 0, 0, 0,
1, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 0, 0, 1, 0, 0, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0,
-3, -8, -15, -21, -30, -39, -48, -55, -62, -69, -73, -76, -78, -78, -75, -70,
-66, -58, -48, -38, -27, -14, -2, };