#define DATA_LENGTH 512
#define DATA AKWF_0352

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 2, 2, 3, 4, 6, 6, 9, 10, 11,
13, 14, 15, 17, 18, 20, 21, 22, 24, 24, 24, 26, 26, 26, 26, 26, 27, 28, 28, 29,
30, 31, 31, 32, 33, 34, 36, 37, 39, 39, 42, 42, 43, 45, 46, 47, 48, 47, 49, 49,
49, 49, 50, 50, 51, 51, 52, 51, 52, 52, 53, 54, 55, 56, 56, 57, 60, 60, 62, 64,
65, 67, 70, 71, 74, 75, 78, 80, 82, 84, 87, 89, 90, 93, 93, 95, 97, 98, 99, 100,
102, 103, 104, 105, 105, 106, 106, 107, 108, 109, 110, 109, 111, 111, 112, 112,
114, 114, 115, 116, 117, 118, 118, 118, 118, 119, 119, 119, 119, 118, 119, 118,
118, 118, 117, 117, 116, 116, 115, 113, 112, 113, 112, 110, 110, 109, 108, 107,
106, 105, 104, 103, 101, 100, 100, 99, 98, 97, 95, 94, 92, 92, 91, 88, 87, 85,
84, 82, 80, 78, 76, 74, 72, 70, 67, 65, 62, 60, 58, 55, 52, 50, 47, 45, 42, 41,
39, 36, 35, 33, 31, 29, 29, 27, 25, 24, 23, 22, 21, 20, 19, 18, 17, 17, 16, 14,
14, 13, 13, 12, 11, 10, 10, 7, 7, 6, 4, 4, 2, 0, -2, -4, -5, -7, -8, -11, -11,
-13, -15, -16, -18, -20, -22, -23, -24, -26, -27, -28, -28, -30, -31, -32, -32,
-33, -35, -36, -36, -38, -39, -39, -39, -40, -41, -42, -42, -42, -42, -42, -43,
-43, -43, -43, -44, -43, -43, -43, -43, -44, -45, -44, -44, -45, -45, -45, -46,
-46, -47, -47, -48, -49, -49, -50, -50, -50, -50, -50, -51, -51, -52, -52, -53,
-52, -52, -52, -53, -51, -52, -51, -53, -54, -54, -53, -53, -52, -51, -50, -50,
-50, -50, -49, -50, -49, -49, -48, -46, -45, -45, -45, -45, -45, -47, -47, -47,
-47, -46, -46, -46, -46, -47, -48, -49, -50, -51, -52, -53, -54, -55, -56, -55,
-58, -58, -60, -62, -63, -64, -66, -68, -69, -69, -70, -70, -72, -72, -72, -72,
-73, -73, -75, -74, -75, -74, -74, -73, -73, -74, -73, -72, -73, -73, -73, -73,
-73, -73, -74, -73, -73, -73, -73, -73, -72, -72, -72, -72, -72, -72, -72, -72,
-72, -72, -71, -72, -72, -72, -73, -72, -72, -72, -73, -71, -73, -73, -73, -73,
-73, -73, -73, -72, -72, -72, -72, -71, -70, -71, -69, -67, -67, -67, -66, -64,
-64, -63, -63, -62, -60, -60, -59, -58, -57, -56, -55, -53, -52, -50, -49, -47,
-45, -43, -41, -40, -39, -38, -37, -36, -36, -35, -34, -33, -33, -32, -32, -31,
-30, -29, -29, -28, -27, -26, -25, -25, -24, -24, -23, -24, -24, -24, -24, -23,
-24, -25, -23, -25, -23, -23, -22, -22, -21, -20, -18, -17, -16, -14, -14, -12,
-11, -11, -10, -10, -9, -10, -10, -10, -10, -10, -10, -10, -10, -11, -10, -9,
-9, -9, -7, -7, -6, -6, -4, -3, -3, -2, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, };