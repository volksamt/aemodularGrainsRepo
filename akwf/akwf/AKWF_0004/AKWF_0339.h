#define DATA_LENGTH 512
#define DATA AKWF_0339

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 9, 15, 20, 24, 29, 31, 37, 40, 42,
46, 50, 52, 55, 57, 60, 62, 64, 66, 68, 69, 70, 71, 72, 73, 74, 75, 76, 76, 77,
77, 77, 77, 78, 78, 78, 78, 77, 77, 77, 76, 77, 75, 76, 75, 75, 75, 76, 76, 76,
75, 75, 74, 74, 74, 74, 74, 72, 73, 73, 72, 72, 71, 70, 70, 68, 69, 68, 68, 66,
65, 65, 64, 61, 61, 60, 59, 57, 56, 55, 53, 52, 52, 50, 48, 46, 45, 42, 41, 40,
38, 36, 34, 33, 31, 30, 29, 27, 25, 24, 21, 19, 18, 17, 15, 13, 12, 11, 11, 10,
10, 11, 11, 10, 11, 11, 11, 12, 10, 11, 12, 12, 12, 12, 12, 12, 12, 12, 12, 12,
13, 12, 11, 12, 11, 10, 9, 8, 8, 7, 7, 6, 5, 4, 3, 2, 0, 0, -2, -4, -4, -6, -7,
-9, -10, -12, -12, -15, -16, -17, -19, -19, -21, -23, -25, -26, -28, -30, -31,
-33, -35, -35, -36, -38, -39, -40, -41, -42, -42, -43, -44, -45, -47, -47, -49,
-50, -51, -51, -52, -53, -54, -55, -56, -58, -58, -59, -62, -63, -64, -65, -67,
-68, -69, -70, -72, -74, -75, -76, -79, -80, -82, -83, -85, -87, -89, -90, -93,
-94, -96, -98, -99, -101, -103, -105, -106, -108, -110, -112, -113, -116, -116,
-118, -119, -119, -118, -115, -112, -109, -104, -99, -93, -87, -81, -75, -69,
-63, -55, -49, -43, -36, -30, -24, -17, -12, -6, 0, 4, 10, 15, 21, 24, 28, 32,
35, 40, 43, 46, 50, 52, 56, 58, 60, 63, 65, 66, 68, 70, 71, 71, 72, 73, 75, 75,
75, 76, 76, 77, 77, 78, 79, 78, 77, 78, 78, 76, 77, 76, 76, 76, 76, 76, 75, 75,
76, 76, 75, 76, 75, 75, 75, 75, 74, 74, 73, 73, 72, 72, 72, 70, 70, 70, 69, 68,
68, 67, 66, 65, 64, 63, 62, 60, 59, 58, 57, 56, 55, 53, 51, 50, 49, 48, 46, 44,
42, 41, 39, 38, 36, 34, 33, 32, 31, 28, 26, 25, 23, 21, 19, 17, 15, 14, 13, 13,
11, 11, 11, 10, 11, 11, 11, 11, 10, 11, 11, 11, 11, 11, 12, 12, 12, 12, 12, 12,
11, 12, 12, 12, 12, 12, 12, 11, 10, 9, 9, 8, 7, 7, 5, 5, 5, 3, 2, 1, 0, -2, -3,
-4, -5, -7, -9, -10, -11, -13, -14, -16, -18, -19, -20, -21, -23, -25, -26, -27,
-30, -31, -33, -34, -35, -36, -37, -39, -39, -40, -41, -42, -43, -44, -46, -47,
-48, -48, -50, -51, -51, -53, -53, -54, -56, -57, -58, -58, -60, -61, -63, -64,
-66, -67, -68, -69, -71, -73, -74, -76, -77, -78, -79, -82, -83, -85, -87, -88,
-91, -93, -95, -96, -98, -99, -101, -104, -104, -107, -108, -109, -111, -114,
-116, -117, -118, -119, -119, -116, -114, -112, -108, -104, -98, -93, -86, -81,
-74, -68, -61, -55, -49, -42, -36, -30, -24, -16, -11, -6, 1, };