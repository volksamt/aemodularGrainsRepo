#define DATA_LENGTH 512
#define DATA AKWF_linear_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 2, 4, 5, 6, 8, 7, 9, 10, 11,
11, 12, 14, 14, 16, 16, 18, 19, 19, 21, 23, 26, 28, 30, 33, 35, 38, 39, 42, 45,
47, 50, 53, 54, 57, 60, 61, 64, 66, 69, 71, 74, 76, 79, 81, 84, 86, 88, 91, 93,
96, 98, 100, 103, 105, 108, 109, 109, 109, 109, 110, 110, 110, 111, 110, 111,
112, 111, 112, 112, 113, 114, 112, 114, 113, 114, 115, 115, 115, 115, 115, 116,
116, 117, 116, 117, 117, 117, 117, 119, 118, 118, 119, 114, 110, 106, 103, 98,
93, 90, 86, 81, 78, 73, 69, 65, 61, 57, 53, 49, 44, 41, 37, 32, 28, 24, 19, 16,
11, 8, 3, -1, -4, -9, -13, -18, -21, -25, -30, -31, -31, -31, -31, -32, -31,
-31, -32, -31, -32, -32, -32, -32, -33, -32, -32, -33, -33, -33, -33, -34, -33,
-34, -33, -34, -34, -33, -33, -34, -34, -35, -34, -34, -35, -35, -36, -35, -35,
-35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -34, -34, -34, -35,
-34, -34, -34, -34, -35, -34, -34, -35, -34, -35, -35, -35, -34, -35, -34, -34,
-34, -34, -34, -34, -33, -33, -33, -33, -32, -32, -32, -31, -31, -31, -30, -29,
-30, -29, -29, -28, -29, -28, -27, -27, -27, -26, -26, -25, -26, -25, -24, -24,
-23, -24, -23, -23, -22, -22, -21, -21, -18, -15, -12, -10, -6, -4, -1, 3, 5, 9,
11, 15, 17, 21, 23, 25, 28, 33, 35, 38, 41, 43, 46, 49, 52, 55, 58, 62, 64, 67,
70, 73, 76, 79, 81, 84, 85, 83, 81, 78, 78, 74, 73, 70, 68, 66, 64, 62, 59, 56,
55, 53, 50, 49, 47, 44, 42, 40, 38, 36, 33, 30, 28, 26, 24, 22, 20, 18, 15, 13,
11, 10, 8, 5, 5, 5, 5, 5, 4, 4, 4, 3, 4, 4, 3, 2, 2, 2, 1, 0, 1, 0, 1, 1, 0, -1,
-1, -2, -2, -2, -2, -3, -2, -3, -4, -3, -3, -4, -5, -4, -5, -5, -6, -5, -6, -5,
-5, -6, -6, -6, -6, -7, -6, -6, -7, -6, -6, -6, -7, -7, -7, -6, -7, -8, -8, -7,
-7, -8, -7, -8, -8, -8, -8, -8, -8, -8, -10, -11, -13, -15, -16, -18, -19, -21,
-22, -25, -26, -28, -30, -31, -33, -35, -36, -38, -39, -40, -42, -43, -46, -47,
-49, -50, -52, -54, -55, -57, -59, -60, -62, -64, -64, -67, -68, -67, -66, -65,
-65, -63, -62, -60, -60, -59, -57, -57, -56, -54, -53, -52, -51, -51, -49, -48,
-47, -46, -45, -43, -42, -41, -40, -39, -39, -38, -36, -35, -34, -33, -32, -31,
-29, -30, -29, -28, -28, -27, -27, -27, -26, -25, -26, -26, -25, -24, -24, -24,
-23, -22, -22, -22, -22, -21, -20, -20, -20, -19, -19, -19, -19, -18, -18, -18,
-17, -16, -16, -16, -16, -15, -14, -13, -12, -11, -9, -9, -8, -8, -6, -5, -5,
-4, -3, -2, 0, };