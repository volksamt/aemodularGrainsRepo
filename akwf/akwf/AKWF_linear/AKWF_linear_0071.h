#define DATA_LENGTH 512
#define DATA AKWF_linear_0071

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 16, 22, 28, 34, 39, 44, 47, 49,
52, 54, 57, 59, 62, 64, 67, 70, 72, 74, 77, 79, 82, 84, 86, 89, 91, 94, 97, 99,
101, 104, 106, 106, 103, 101, 97, 96, 93, 91, 88, 85, 83, 81, 78, 76, 74, 71,
69, 66, 64, 62, 60, 57, 55, 51, 49, 48, 45, 48, 51, 54, 57, 61, 62, 66, 68, 71,
74, 77, 80, 83, 86, 90, 92, 94, 98, 100, 104, 106, 109, 112, 116, 118, 119, 117,
114, 112, 110, 109, 107, 105, 103, 100, 98, 96, 96, 93, 91, 90, 88, 85, 83, 82,
80, 78, 76, 74, 73, 70, 70, 71, 71, 72, 72, 72, 73, 72, 72, 73, 73, 74, 74, 74,
75, 76, 76, 76, 76, 77, 77, 77, 77, 78, 79, 78, 78, 77, 78, 77, 76, 77, 76, 75,
76, 75, 76, 75, 75, 75, 74, 74, 74, 74, 74, 73, 73, 72, 72, 72, 72, 70, 69, 66,
64, 63, 61, 58, 57, 55, 53, 51, 49, 48, 45, 43, 42, 40, 38, 36, 33, 32, 30, 29,
27, 25, 24, 26, 27, 30, 32, 33, 36, 38, 40, 42, 44, 47, 48, 50, 52, 54, 57, 58,
60, 62, 65, 67, 68, 71, 73, 75, 73, 66, 62, 55, 51, 44, 39, 33, 28, 23, 17, 11,
6, 0, -6, -11, -17, -22, -28, -33, -39, -43, -50, -56, -60, -64, -63, -59, -56,
-52, -49, -45, -42, -39, -36, -32, -28, -26, -22, -18, -15, -11, -8, -4, -2, 1,
5, 8, 12, 16, 19, 21, 21, 21, 22, 22, 22, 22, 22, 23, 23, 24, 24, 24, 24, 24,
24, 25, 25, 26, 26, 26, 27, 26, 27, 27, 27, 24, 19, 14, 11, 6, 2, -3, -6, -11,
-15, -20, -25, -29, -33, -38, -42, -46, -50, -54, -59, -64, -68, -73, -77, -82,
-83, -80, -78, -75, -73, -71, -68, -66, -63, -60, -57, -55, -52, -50, -47, -45,
-43, -39, -38, -35, -33, -30, -27, -24, -21, -19, -20, -23, -26, -30, -32, -36,
-38, -42, -45, -48, -52, -53, -57, -60, -64, -66, -69, -73, -76, -79, -82, -85,
-88, -92, -94, -96, -95, -93, -93, -91, -90, -88, -87, -86, -84, -84, -81, -80,
-79, -78, -77, -75, -74, -72, -71, -70, -69, -67, -65, -65, -62, -63, -64, -66,
-66, -68, -70, -71, -72, -73, -75, -76, -77, -78, -79, -82, -83, -84, -86, -86,
-88, -89, -90, -93, -94, -95, -96, -96, -96, -97, -96, -96, -98, -97, -97, -97,
-98, -98, -98, -98, -98, -99, -98, -99, -98, -99, -99, -99, -99, -99, -99, -100,
-98, -97, -95, -94, -91, -90, -87, -85, -84, -82, -80, -77, -76, -74, -72, -70,
-68, -66, -64, -62, -60, -58, -56, -55, -52, -51, -51, -54, -56, -59, -60, -64,
-65, -68, -70, -72, -75, -77, -80, -82, -84, -86, -88, -91, -94, -95, -98, -99,
-102, -105, -107, -107, -102, -95, -90, -83, -78, -72, -66, -60, -55, -47, -41,
-36, -30, -24, -18, -13, -6, -1, };