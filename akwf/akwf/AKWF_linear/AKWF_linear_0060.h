#define DATA_LENGTH 512
#define DATA AKWF_linear_0060

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 6, 6, 7, 8, 9, 10, 11, 12,
14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 26, 27, 28, 28, 29, 31, 32, 33, 34,
34, 36, 37, 38, 39, 40, 41, 42, 44, 45, 45, 47, 47, 49, 50, 51, 52, 52, 54, 55,
56, 57, 58, 59, 61, 62, 62, 64, 65, 66, 68, 68, 69, 70, 71, 72, 73, 74, 76, 77,
77, 79, 79, 81, 82, 83, 83, 83, 84, 84, 83, 84, 83, 83, 83, 84, 84, 84, 84, 83,
84, 84, 84, 84, 84, 84, 84, 84, 83, 84, 84, 84, 85, 84, 84, 84, 84, 84, 83, 84,
84, 84, 84, 84, 84, 83, 84, 85, 84, 85, 85, 84, 84, 85, 84, 84, 84, 84, 84, 84,
84, 84, 84, 84, 84, 84, 84, 84, 84, 85, 85, 84, 85, 84, 84, 85, 84, 84, 85, 84,
85, 84, 85, 85, 85, 84, 85, 85, 85, 84, 85, 84, 85, 85, 85, 85, 86, 85, 84, 85,
85, 85, 84, 85, 84, 85, 85, 85, 86, 83, 80, 79, 77, 75, 72, 71, 68, 67, 65, 62,
61, 60, 57, 55, 53, 51, 49, 47, 45, 43, 41, 39, 36, 35, 33, 31, 28, 28, 25, 23,
21, 18, 17, 15, 12, 11, 9, 7, 5, 2, 1, -1, -4, -5, -7, -9, -11, -13, -15, -17,
-19, -22, -23, -25, -27, -30, -31, -33, -35, -37, -39, -41, -44, -46, -47, -49,
-51, -53, -55, -56, -59, -62, -63, -65, -67, -68, -71, -73, -75, -77, -79, -81,
-83, -85, -87, -89, -91, -93, -95, -97, -99, -100, -103, -105, -106, -109, -110,
-112, -114, -116, -119, -118, -117, -117, -116, -115, -115, -113, -112, -111,
-110, -109, -108, -107, -106, -106, -104, -104, -103, -101, -101, -100, -99,
-97, -97, -96, -95, -94, -93, -92, -90, -91, -89, -88, -88, -86, -85, -85, -84,
-82, -82, -80, -81, -79, -78, -78, -76, -76, -74, -74, -73, -71, -70, -70, -69,
-67, -67, -66, -64, -64, -63, -62, -61, -61, -59, -58, -58, -57, -56, -55, -54,
-52, -52, -51, -50, -50, -49, -48, -46, -46, -45, -44, -43, -42, -41, -40, -39,
-38, -37, -35, -36, -34, -33, -32, -32, -31, -30, -28, -28, -27, -26, -25, -24,
-24, -23, -23, -24, -23, -23, -24, -24, -24, -23, -24, -24, -24, -23, -24, -24,
-24, -24, -25, -23, -24, -24, -24, -23, -24, -25, -24, -24, -24, -23, -25, -24,
-23, -24, -24, -25, -24, -24, -24, -24, -24, -24, -24, -24, -25, -24, -25, -24,
-25, -25, -25, -24, -24, -25, -24, -24, -25, -25, -25, -26, -25, -25, -24, -25,
-25, -24, -26, -25, -26, -24, -25, -25, -26, -25, -25, -24, -25, -25, -26, -26,
-25, -25, -25, -25, -25, -26, -26, -25, -25, -26, -25, -25, -26, -26, -26, -25,
-25, -26, -26, -26, -26, -26, -26, -25, -23, -22, -22, -21, -19, -19, -17, -16,
-15, -14, -13, -12, -11, -10, -8, -7, -6, -6, -4, -4, -2, 0, 0, };