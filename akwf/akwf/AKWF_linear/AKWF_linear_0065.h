#define DATA_LENGTH 512
#define DATA AKWF_linear_0065

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 11, 16, 21, 25, 31, 36, 40, 45,
50, 55, 60, 65, 70, 74, 77, 78, 81, 81, 84, 85, 87, 89, 91, 92, 94, 96, 98, 99,
100, 103, 105, 106, 108, 111, 112, 113, 115, 117, 119, 119, 115, 113, 109, 107,
104, 102, 98, 95, 93, 89, 86, 84, 81, 78, 76, 72, 69, 66, 63, 60, 57, 54, 51,
48, 45, 43, 39, 36, 33, 29, 26, 22, 19, 16, 12, 9, 5, 2, -1, -5, -8, -11, -15,
-18, -22, -25, -29, -31, -35, -38, -41, -41, -41, -43, -42, -42, -43, -43, -43,
-44, -44, -45, -44, -45, -46, -45, -46, -46, -47, -47, -47, -48, -48, -48, -49,
-49, -49, -46, -46, -45, -43, -41, -41, -40, -38, -38, -36, -34, -33, -32, -30,
-29, -28, -26, -25, -24, -23, -21, -20, -19, -17, -17, -16, -16, -15, -16, -16,
-14, -14, -15, -14, -15, -13, -13, -13, -13, -13, -13, -13, -12, -11, -12, -11,
-11, -11, -10, -10, -10, -9, -8, -8, -8, -9, -8, -8, -7, -6, -6, -6, -6, -6, -6,
-5, -5, -5, -4, -4, -4, -4, -3, -3, -2, -2, -2, -3, -2, -2, -2, -2, -1, -2, -2,
-2, -2, -2, -2, -2, -1, -1, 0, -1, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 1, 1, 1,
0, 0, 0, 1, 0, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 2, 0, 2, 1, 1, 1, 1, 1, 1,
1, 1, 1, 1, 1, 1, 1, 2, 1, 2, 1, 2, 2, 2, 2, 2, 2, 1, 1, 1, 2, 1, 2, 1, 1, 1, 1,
1, 1, 0, 0, 0, 0, 1, 1, 0, 0, 0, -1, 0, -1, -2, -1, 0, -1, 0, 0, 0, 0, 0, 0, 1,
0, 0, 1, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 1, 2, 1, 1, 0, 1, 0, 0, -1, -1, 0,
-2, -1, -2, -2, -2, -2, -2, -3, -4, -4, -4, -5, -4, -4, -4, -5, -6, -6, -4, -4,
-4, -5, -3, -4, -3, -2, -3, -2, -1, -1, 0, -1, 0, 1, 1, 1, 2, 2, 3, 2, 2, 3, 3,
3, 3, 3, 3, 3, 3, 2, 3, 3, 3, 3, 3, 2, 2, 3, 2, 2, 3, 3, 2, 3, 3, 3, 3, 4, 5, 6,
7, 8, 11, 12, 13, 14, 15, 17, 18, 19, 21, 23, 25, 25, 27, 28, 30, 31, 32, 34,
35, 37, 38, 38, 35, 34, 31, 28, 26, 24, 21, 19, 16, 15, 12, 10, 7, 6, 4, 0, -1,
-3, -6, -9, -11, -13, -15, -17, -20, -22, -25, -28, -31, -34, -37, -40, -43,
-46, -48, -51, -55, -57, -60, -62, -66, -69, -72, -74, -77, -80, -83, -86, -88,
-91, -93, -91, -89, -88, -85, -85, -83, -81, -79, -77, -76, -74, -72, -71, -69,
-68, -65, -64, -62, -60, -59, -58, -55, -54, -52, -50, -46, -41, -36, -31, -27,
-22, -17, -12, -8, -2, };