#define DATA_LENGTH 512
#define DATA AKWF_linear_0051

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 8, 10, 13, 15, 18, 20, 23,
25, 27, 29, 31, 33, 36, 38, 41, 44, 46, 48, 50, 53, 55, 57, 60, 61, 64, 66, 69,
70, 71, 71, 71, 72, 72, 72, 72, 72, 73, 73, 74, 74, 74, 74, 74, 75, 75, 74, 76,
75, 75, 75, 76, 76, 76, 76, 76, 77, 78, 78, 78, 78, 78, 78, 78, 79, 78, 79, 78,
79, 78, 77, 77, 76, 77, 76, 76, 76, 75, 76, 76, 76, 75, 75, 75, 74, 74, 74, 73,
74, 73, 73, 73, 73, 72, 72, 72, 72, 71, 71, 71, 70, 71, 70, 71, 71, 72, 73, 73,
72, 73, 74, 73, 73, 74, 74, 75, 76, 76, 76, 76, 76, 77, 77, 77, 78, 78, 78, 78,
80, 80, 80, 80, 81, 82, 81, 82, 82, 82, 82, 81, 79, 77, 76, 74, 72, 70, 68, 67,
65, 63, 62, 60, 59, 57, 55, 54, 52, 49, 48, 46, 44, 43, 41, 39, 38, 36, 34, 33,
31, 28, 27, 26, 23, 22, 21, 19, 17, 15, 13, 11, 10, 8, 7, 4, 3, 1, -1, -2, -4,
-6, -8, -9, -11, -13, -15, -16, -19, -20, -22, -25, -26, -27, -29, -31, -33,
-34, -36, -38, -40, -42, -44, -45, -45, -47, -46, -48, -48, -49, -49, -50, -51,
-52, -52, -52, -54, -54, -55, -55, -56, -57, -58, -58, -59, -59, -60, -60, -61,
-62, -63, -63, -64, -64, -65, -66, -66, -67, -67, -68, -69, -67, -67, -67, -66,
-66, -65, -65, -65, -64, -64, -64, -63, -63, -63, -61, -62, -60, -60, -60, -59,
-59, -59, -59, -58, -57, -56, -56, -55, -56, -55, -54, -54, -53, -52, -53, -52,
-49, -45, -41, -39, -34, -30, -27, -23, -20, -16, -13, -9, -6, -2, 3, 7, 10, 13,
16, 20, 24, 28, 31, 34, 39, 42, 46, 50, 53, 56, 60, 63, 68, 72, 75, 78, 80, 76,
71, 68, 64, 59, 55, 52, 47, 43, 39, 34, 31, 27, 23, 19, 15, 11, 6, 2, -2, -6,
-10, -14, -18, -22, -26, -30, -33, -38, -42, -47, -51, -54, -58, -63, -67, -68,
-68, -67, -67, -67, -67, -66, -66, -65, -66, -66, -65, -65, -64, -63, -64, -63,
-63, -63, -62, -62, -63, -62, -62, -60, -61, -60, -60, -60, -60, -60, -60, -60,
-59, -59, -58, -58, -56, -53, -51, -49, -47, -44, -42, -41, -38, -37, -34, -32,
-29, -27, -25, -23, -22, -19, -16, -15, -13, -10, -7, -6, -4, -1, 1, 3, 5, 7, 9,
12, 14, 17, 17, 21, 19, 14, 11, 7, 3, -1, -5, -9, -12, -16, -21, -23, -28, -31,
-36, -39, -43, -47, -51, -54, -58, -62, -66, -70, -74, -78, -82, -85, -89, -94,
-97, -100, -104, -108, -113, -116, -119, -116, -113, -110, -108, -105, -101,
-99, -96, -93, -91, -88, -84, -82, -79, -76, -73, -70, -68, -65, -62, -58, -56,
-53, -50, -47, -43, -41, -37, -34, -32, -29, -26, -24, -21, -17, -15, -12, -10,
-7, -6, -2, -1, };