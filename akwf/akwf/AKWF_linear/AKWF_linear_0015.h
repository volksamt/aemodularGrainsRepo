#define DATA_LENGTH 512
#define DATA AKWF_linear_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 10, 14, 18, 23, 28, 33, 37, 40,
43, 44, 46, 46, 49, 51, 52, 53, 54, 56, 56, 58, 61, 61, 63, 64, 66, 67, 68, 70,
72, 73, 74, 76, 77, 78, 80, 82, 82, 84, 86, 87, 89, 90, 91, 93, 93, 89, 84, 79,
74, 70, 66, 60, 57, 52, 48, 42, 38, 34, 29, 24, 20, 16, 11, 6, 2, -2, -8, -12,
-15, -21, -25, -30, -35, -39, -43, -49, -52, -57, -62, -67, -71, -71, -68, -66,
-63, -61, -59, -56, -53, -51, -48, -46, -43, -40, -38, -35, -32, -31, -28, -26,
-23, -21, -18, -15, -12, -11, -8, -5, -3, 0, 3, 4, 8, 9, 13, 15, 18, 20, 21, 24,
26, 28, 30, 32, 33, 35, 38, 39, 41, 44, 45, 47, 49, 50, 53, 56, 57, 59, 60, 63,
65, 66, 69, 70, 72, 74, 77, 77, 80, 82, 84, 86, 88, 90, 89, 87, 85, 82, 80, 78,
75, 73, 72, 69, 67, 64, 62, 60, 58, 56, 53, 52, 49, 47, 44, 42, 40, 38, 36, 33,
31, 28, 27, 24, 22, 20, 18, 15, 14, 11, 9, 7, 7, 6, 5, 5, 3, 2, 2, 2, 2, 0, -1,
-2, -3, -4, -4, -5, -6, -7, -8, -7, -9, -9, -11, -11, -12, -13, -13, -15, -16,
-16, -17, -17, -19, -19, -20, -20, -19, -18, -18, -17, -15, -15, -13, -12, -12,
-11, -10, -8, -8, -7, -6, -5, -3, -4, -2, -2, -1, 0, 1, 1, 3, 4, 5, 6, 7, 8, 9,
10, 11, 12, 12, 13, 14, 15, 16, 18, 18, 20, 20, 21, 23, 23, 25, 26, 26, 27, 29,
29, 30, 32, 33, 34, 35, 36, 36, 37, 39, 40, 41, 42, 43, 44, 46, 46, 46, 48, 49,
50, 51, 49, 47, 47, 45, 44, 42, 40, 39, 38, 37, 35, 34, 32, 31, 30, 29, 27, 26,
24, 23, 22, 20, 19, 18, 16, 15, 13, 13, 11, 10, 8, 7, 5, 4, 2, 1, 1, -2, -1, -2,
-4, -5, -5, -7, -7, -8, -10, -10, -11, -11, -13, -14, -15, -16, -16, -18, -19,
-19, -21, -21, -22, -23, -24, -25, -25, -27, -28, -29, -29, -30, -31, -32, -33,
-31, -29, -29, -27, -25, -23, -22, -20, -19, -18, -15, -14, -12, -10, -10, -8,
-6, -4, -3, -2, 0, 2, 4, 5, 7, 8, 9, 11, 12, 14, 16, 17, 19, 20, 21, 24, 22, 19,
16, 13, 9, 6, 3, -2, -5, -8, -11, -14, -18, -22, -25, -28, -32, -35, -39, -42,
-45, -49, -52, -55, -58, -62, -65, -69, -72, -75, -79, -82, -85, -89, -92, -96,
-98, -100, -100, -100, -101, -102, -102, -103, -103, -104, -104, -104, -105,
-106, -106, -108, -108, -108, -108, -109, -109, -111, -110, -112, -112, -114,
-113, -114, -114, -114, -116, -116, -117, -117, -118, -118, -119, -118, -113,
-109, -103, -99, -95, -90, -86, -82, -77, -73, -69, -64, -59, -55, -51, -47,
-42, -37, -33, -29, -25, -19, -16, -11, -6, -3, };