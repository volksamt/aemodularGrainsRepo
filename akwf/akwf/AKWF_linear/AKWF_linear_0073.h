#define DATA_LENGTH 512
#define DATA AKWF_linear_0073

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 5, 8, 10, 12, 15, 17, 21, 23,
27, 29, 32, 36, 38, 41, 44, 47, 50, 53, 56, 59, 62, 65, 68, 71, 74, 77, 80, 82,
86, 88, 89, 91, 91, 94, 94, 96, 96, 98, 99, 101, 101, 103, 104, 106, 107, 108,
109, 110, 112, 113, 114, 115, 115, 118, 119, 118, 119, 118, 117, 117, 117, 117,
117, 116, 116, 116, 116, 116, 114, 115, 114, 114, 114, 114, 112, 112, 113, 112,
111, 111, 112, 110, 110, 109, 108, 108, 107, 106, 105, 105, 104, 103, 104, 103,
101, 101, 100, 99, 99, 98, 97, 97, 96, 95, 95, 94, 94, 95, 96, 97, 98, 99, 100,
101, 102, 103, 103, 104, 105, 106, 107, 108, 108, 109, 111, 111, 113, 113, 114,
115, 116, 116, 114, 112, 110, 108, 106, 104, 102, 100, 97, 95, 93, 91, 89, 88,
85, 83, 81, 79, 77, 75, 73, 70, 69, 66, 64, 61, 58, 54, 50, 46, 43, 38, 35, 32,
27, 23, 19, 15, 12, 8, 5, 1, -3, -7, -11, -14, -19, -22, -26, -29, -33, -33,
-29, -27, -25, -23, -20, -18, -15, -13, -10, -9, -5, -3, -1, 1, 4, 7, 8, 11, 13,
15, 18, 20, 24, 25, 28, 29, 33, 35, 36, 39, 41, 44, 46, 48, 50, 53, 55, 58, 59,
61, 63, 66, 69, 70, 73, 75, 77, 80, 82, 84, 83, 78, 74, 69, 65, 61, 56, 52, 47,
43, 39, 35, 30, 27, 22, 17, 14, 9, 4, 0, -4, -8, -12, -18, -22, -26, -29, -33,
-36, -40, -43, -48, -51, -54, -58, -62, -66, -68, -73, -76, -80, -83, -87, -90,
-95, -98, -100, -104, -109, -112, -116, -117, -116, -117, -116, -116, -116,
-116, -116, -114, -115, -115, -114, -114, -114, -114, -113, -113, -113, -113,
-112, -111, -112, -111, -112, -111, -111, -110, -110, -111, -111, -111, -112,
-111, -111, -112, -111, -112, -112, -112, -112, -113, -113, -113, -113, -113,
-113, -114, -114, -114, -114, -114, -115, -115, -115, -115, -115, -115, -115,
-115, -115, -115, -115, -115, -116, -116, -116, -115, -116, -116, -116, -116,
-116, -116, -116, -117, -116, -116, -117, -115, -115, -114, -114, -113, -112,
-112, -111, -111, -109, -109, -109, -108, -108, -107, -106, -106, -105, -104,
-104, -103, -103, -102, -102, -101, -98, -95, -91, -89, -86, -83, -80, -77, -74,
-70, -68, -65, -62, -59, -57, -53, -50, -48, -45, -41, -38, -36, -33, -29, -26,
-24, -23, -21, -20, -18, -17, -16, -14, -14, -11, -10, -9, -7, -6, -5, -3, -2,
-1, 1, 3, 4, 5, 7, 8, 10, 11, 10, 7, 6, 3, 1, 0, -3, -5, -7, -9, -10, -12, -14,
-16, -18, -20, -22, -25, -26, -28, -30, -32, -34, -36, -38, -39, -39, -40, -40,
-40, -40, -41, -40, -40, -40, -41, -41, -41, -41, -41, -41, -41, -42, -42, -42,
-42, -42, -42, -42, -42, -43, -41, -39, -37, -35, -32, -30, -29, -26, -24, -22,
-19, -18, -15, -14, -11, -9, -7, -5, -2, 0, };