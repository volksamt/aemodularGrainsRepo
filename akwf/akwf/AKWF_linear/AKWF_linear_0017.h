#define DATA_LENGTH 512
#define DATA AKWF_linear_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 7, 8, 12, 13, 15, 17, 19, 21,
23, 25, 27, 30, 32, 34, 36, 38, 40, 42, 45, 46, 48, 50, 53, 55, 57, 59, 62, 64,
65, 68, 69, 72, 75, 76, 78, 81, 83, 85, 87, 89, 92, 93, 95, 98, 99, 101, 103,
106, 107, 107, 108, 108, 108, 108, 108, 109, 108, 108, 108, 109, 108, 109, 108,
108, 109, 109, 109, 109, 109, 109, 108, 109, 108, 109, 110, 110, 110, 109, 110,
109, 110, 110, 109, 110, 111, 108, 103, 100, 97, 92, 89, 86, 81, 77, 74, 70, 67,
63, 59, 56, 51, 47, 44, 40, 36, 33, 30, 25, 21, 18, 14, 10, 7, 3, -1, -5, -8,
-12, -16, -20, -24, -27, -27, -28, -28, -29, -30, -30, -31, -30, -31, -32, -32,
-33, -34, -35, -35, -36, -36, -36, -36, -37, -38, -38, -39, -39, -39, -40, -41,
-41, -41, -42, -43, -43, -43, -44, -44, -45, -44, -42, -41, -39, -38, -35, -32,
-32, -30, -28, -26, -25, -22, -20, -18, -17, -15, -13, -11, -9, -7, -6, -4, -2,
0, 2, 3, 6, 7, 9, 11, 14, 15, 17, 18, 20, 22, 23, 24, 25, 25, 26, 27, 28, 28,
29, 30, 30, 32, 32, 33, 34, 35, 36, 36, 37, 38, 39, 40, 40, 42, 43, 43, 44, 46,
45, 46, 48, 48, 49, 50, 50, 52, 51, 49, 47, 44, 42, 39, 38, 35, 33, 30, 28, 26,
24, 21, 20, 17, 15, 12, 10, 8, 5, 2, 1, -2, -4, -7, -9, -10, -13, -15, -17, -20,
-22, -25, -27, -29, -30, -33, -36, -38, -41, -43, -46, -48, -51, -52, -56, -58,
-60, -62, -64, -66, -68, -72, -74, -76, -78, -81, -84, -86, -88, -91, -93, -96,
-98, -100, -103, -106, -108, -110, -112, -115, -117, -119, -118, -118, -118,
-116, -117, -116, -116, -116, -115, -114, -113, -113, -113, -113, -112, -111,
-111, -111, -109, -110, -109, -109, -109, -108, -107, -107, -106, -106, -105,
-105, -104, -105, -103, -103, -102, -102, -99, -96, -93, -89, -85, -83, -78,
-74, -71, -68, -64, -61, -57, -53, -50, -46, -44, -40, -36, -33, -30, -26, -22,
-18, -15, -12, -9, -6, -2, 2, 5, 9, 12, 17, 19, 23, 26, 27, 27, 28, 29, 29, 29,
30, 30, 31, 32, 32, 32, 32, 32, 34, 34, 35, 36, 35, 35, 37, 37, 37, 38, 39, 39,
39, 40, 40, 42, 42, 42, 42, 44, 44, 45, 44, 42, 40, 38, 37, 34, 32, 31, 29, 26,
25, 23, 22, 20, 19, 17, 14, 12, 11, 9, 7, 5, 4, 1, 0, -3, -4, -5, -8, -10, -11,
-13, -15, -17, -19, -21, -23, -23, -23, -24, -25, -25, -26, -26, -27, -28, -29,
-30, -30, -30, -30, -32, -32, -33, -33, -34, -34, -35, -36, -37, -37, -39, -38,
-39, -40, -40, -41, -42, -42, -43, -43, -44, -46, -44, -43, -40, -38, -36, -34,
-32, -30, -28, -27, -23, -21, -20, -17, -15, -13, -12, -9, -7, -5, -4, -1, };