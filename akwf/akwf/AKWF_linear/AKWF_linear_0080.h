#define DATA_LENGTH 512
#define DATA AKWF_linear_0080

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 13, 16, 20, 23, 28, 31, 35,
40, 43, 46, 50, 54, 57, 62, 64, 69, 72, 73, 73, 73, 75, 74, 75, 75, 77, 76, 77,
79, 79, 80, 81, 81, 82, 83, 84, 84, 84, 85, 85, 87, 87, 87, 88, 88, 89, 90, 91,
91, 92, 92, 93, 93, 93, 94, 95, 96, 97, 97, 98, 98, 98, 100, 100, 101, 102, 102,
103, 103, 103, 101, 101, 99, 98, 96, 96, 95, 94, 93, 91, 90, 89, 88, 88, 87, 86,
85, 84, 83, 81, 80, 80, 78, 77, 76, 75, 75, 74, 73, 71, 70, 69, 68, 67, 66, 64,
64, 62, 62, 61, 59, 59, 57, 57, 55, 54, 53, 52, 52, 51, 51, 53, 53, 55, 55, 57,
57, 59, 60, 61, 62, 63, 63, 65, 66, 67, 68, 69, 70, 70, 72, 73, 74, 76, 76, 77,
79, 79, 80, 81, 83, 83, 85, 85, 86, 87, 89, 90, 90, 91, 93, 93, 94, 95, 97, 98,
98, 100, 100, 101, 103, 101, 98, 97, 94, 92, 90, 87, 85, 84, 81, 79, 77, 75, 71,
69, 67, 66, 63, 61, 59, 56, 54, 53, 49, 47, 45, 44, 40, 39, 36, 34, 32, 29, 27,
24, 23, 21, 18, 16, 13, 12, 9, 6, 5, 3, 0, -2, -5, -6, -9, -11, -11, -11, -11,
-11, -11, -11, -10, -9, -10, -10, -10, -9, -8, -8, -9, -9, -8, -8, -8, -7, -6,
-7, -6, -7, -6, -6, -6, -6, -5, -5, -5, -6, -4, -5, -5, -4, -4, -4, -3, -4, -3,
-3, -2, -3, -2, -1, -2, -2, -1, -1, -1, -1, -2, -2, -2, -2, -3, -3, -4, -4, -4,
-5, -6, -5, -6, -7, -7, -6, -8, -8, -9, -9, -10, -9, -10, -11, -11, -11, -12,
-12, -12, -13, -13, -14, -15, -15, -15, -15, -15, -15, -17, -17, -18, -18, -18,
-18, -20, -19, -20, -21, -21, -21, -22, -23, -25, -27, -28, -30, -32, -34, -36,
-38, -40, -41, -43, -45, -47, -49, -50, -53, -54, -56, -58, -60, -62, -63, -65,
-67, -69, -71, -73, -75, -77, -78, -80, -82, -83, -85, -87, -89, -91, -93, -94,
-96, -98, -100, -102, -104, -105, -108, -109, -111, -113, -114, -114, -112,
-112, -110, -109, -108, -107, -106, -105, -104, -104, -102, -100, -100, -99,
-97, -96, -95, -94, -94, -93, -91, -90, -89, -87, -87, -85, -85, -83, -83, -82,
-81, -80, -79, -78, -76, -76, -75, -74, -72, -71, -70, -69, -67, -67, -66, -64,
-64, -64, -62, -61, -61, -62, -65, -65, -66, -68, -69, -70, -71, -72, -74, -75,
-75, -76, -77, -79, -81, -81, -82, -83, -85, -86, -87, -89, -89, -90, -91, -93,
-94, -95, -96, -97, -99, -99, -100, -102, -103, -103, -105, -106, -108, -109,
-110, -112, -112, -113, -114, -116, -116, -117, -119, -118, -113, -109, -106,
-102, -98, -94, -90, -87, -83, -79, -75, -72, -68, -64, -60, -57, -53, -49, -46,
-42, -38, -35, -31, -27, -23, -20, -16, -12, -8, -5, -1, };