#define DATA_LENGTH 512
#define DATA AKWF_linear_0079

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 12, 16, 19, 22, 26, 29, 32,
36, 39, 42, 45, 48, 50, 52, 53, 53, 55, 56, 58, 59, 60, 62, 63, 64, 65, 66, 67,
69, 71, 71, 73, 73, 75, 76, 77, 79, 80, 82, 83, 84, 85, 86, 88, 88, 90, 92, 92,
94, 95, 95, 98, 98, 100, 101, 103, 103, 105, 107, 107, 109, 110, 111, 112, 112,
110, 110, 109, 107, 106, 105, 104, 102, 102, 100, 99, 97, 96, 95, 94, 93, 92,
90, 89, 88, 87, 85, 84, 83, 82, 80, 79, 78, 77, 75, 75, 74, 72, 71, 70, 68, 66,
66, 65, 64, 62, 60, 59, 59, 58, 56, 55, 54, 53, 52, 51, 52, 53, 54, 54, 56, 56,
58, 58, 59, 60, 61, 62, 62, 63, 64, 65, 66, 67, 68, 68, 70, 71, 71, 72, 73, 74,
75, 75, 77, 78, 78, 79, 79, 81, 81, 82, 84, 85, 85, 86, 87, 87, 88, 89, 90, 91,
92, 93, 93, 95, 94, 94, 92, 91, 88, 87, 85, 84, 82, 81, 79, 78, 76, 75, 73, 71,
70, 69, 68, 66, 65, 62, 61, 60, 58, 57, 55, 54, 52, 51, 49, 48, 47, 45, 42, 42,
40, 38, 36, 35, 35, 33, 30, 29, 28, 27, 25, 24, 22, 20, 19, 17, 17, 17, 16, 16,
16, 15, 15, 15, 14, 13, 13, 13, 12, 12, 12, 11, 11, 11, 9, 10, 9, 8, 8, 8, 8, 7,
6, 6, 6, 5, 5, 5, 4, 5, 4, 3, 3, 2, 3, 1, 1, 1, 1, -1, 0, -1, -2, -2, -2, -2,
-3, -3, -4, -6, -6, -7, -8, -9, -9, -10, -11, -11, -12, -12, -14, -15, -15, -16,
-18, -18, -18, -19, -21, -21, -22, -22, -24, -25, -25, -25, -26, -26, -28, -29,
-29, -30, -30, -32, -33, -33, -34, -35, -35, -36, -38, -38, -39, -40, -40, -41,
-42, -43, -44, -45, -47, -47, -48, -49, -51, -52, -52, -54, -54, -55, -57, -58,
-60, -60, -61, -62, -63, -65, -65, -67, -68, -70, -71, -72, -73, -74, -75, -76,
-78, -78, -80, -80, -82, -83, -83, -85, -87, -88, -89, -89, -90, -91, -93, -94,
-95, -96, -97, -98, -99, -100, -99, -98, -97, -96, -96, -95, -94, -93, -92, -91,
-92, -90, -90, -90, -87, -87, -87, -86, -84, -84, -83, -83, -82, -81, -79, -79,
-78, -78, -76, -76, -75, -74, -74, -74, -73, -71, -71, -71, -69, -68, -68, -67,
-66, -65, -64, -63, -63, -62, -62, -61, -61, -63, -63, -64, -66, -67, -68, -69,
-70, -71, -72, -73, -75, -77, -78, -79, -79, -80, -82, -83, -85, -85, -86, -88,
-89, -90, -91, -93, -93, -94, -96, -97, -98, -99, -100, -101, -103, -104, -105,
-107, -108, -108, -110, -111, -112, -113, -114, -115, -117, -117, -118, -118,
-115, -111, -109, -106, -102, -99, -95, -93, -89, -85, -82, -80, -75, -72, -69,
-66, -62, -59, -56, -53, -49, -47, -43, -39, -36, -33, -30, -27, -23, -20, -16,
-13, -10, -7, -4, -1, };