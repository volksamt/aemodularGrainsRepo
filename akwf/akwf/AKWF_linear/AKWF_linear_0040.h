#define DATA_LENGTH 512
#define DATA AKWF_linear_0040

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 7, 9, 10, 13, 16, 18, 20, 21,
24, 26, 28, 30, 31, 33, 36, 38, 40, 42, 44, 46, 48, 50, 52, 54, 53, 52, 52, 52,
51, 50, 50, 49, 50, 48, 48, 47, 47, 46, 46, 46, 45, 45, 44, 44, 43, 43, 42, 42,
42, 41, 40, 40, 39, 38, 39, 38, 38, 37, 36, 37, 38, 39, 40, 42, 43, 45, 46, 48,
49, 51, 52, 53, 54, 57, 59, 60, 61, 62, 64, 65, 66, 68, 70, 71, 72, 74, 75, 77,
79, 79, 81, 83, 84, 86, 87, 88, 88, 85, 83, 80, 78, 75, 73, 70, 67, 65, 63, 60,
57, 55, 51, 49, 47, 44, 42, 40, 37, 34, 31, 28, 26, 24, 21, 19, 17, 13, 11, 8,
6, 3, 1, -2, -5, -7, -10, -13, -14, -18, -20, -24, -25, -29, -31, -34, -37, -40,
-42, -45, -48, -51, -53, -56, -58, -61, -64, -67, -70, -73, -74, -78, -80, -83,
-87, -89, -91, -94, -97, -99, -102, -103, -103, -101, -100, -97, -96, -96, -94,
-93, -90, -90, -89, -87, -87, -84, -83, -82, -81, -78, -78, -76, -75, -74, -72,
-71, -70, -69, -67, -66, -64, -63, -61, -60, -58, -58, -56, -55, -54, -53, -52,
-53, -52, -51, -51, -51, -49, -49, -48, -48, -47, -47, -47, -45, -46, -45, -45,
-45, -43, -42, -42, -42, -41, -41, -39, -40, -39, -38, -37, -37, -37, -37, -35,
-35, -34, -33, -30, -29, -28, -26, -24, -22, -20, -19, -17, -16, -14, -12, -9,
-8, -6, -5, -2, 0, 1, 3, 4, 6, 9, 10, 12, 14, 15, 17, 18, 21, 22, 24, 25, 27,
29, 32, 34, 35, 37, 39, 41, 43, 45, 47, 48, 51, 53, 54, 56, 58, 61, 62, 64, 66,
67, 70, 72, 73, 75, 78, 80, 82, 83, 85, 87, 88, 91, 93, 95, 97, 99, 101, 99, 98,
97, 97, 95, 95, 94, 93, 92, 91, 90, 88, 88, 87, 86, 85, 84, 83, 82, 81, 80, 79,
78, 77, 76, 75, 74, 73, 72, 70, 70, 69, 67, 67, 66, 65, 63, 61, 60, 59, 57, 55,
53, 52, 50, 48, 46, 45, 42, 41, 40, 38, 36, 34, 31, 31, 29, 27, 26, 24, 22, 20,
18, 17, 15, 13, 12, 10, 7, 7, 4, 3, 2, 0, -1, -2, -3, -3, -5, -6, -6, -7, -9,
-9, -11, -12, -13, -14, -15, -16, -17, -17, -19, -20, -20, -21, -23, -24, -24,
-25, -27, -27, -28, -30, -30, -31, -33, -34, -35, -36, -38, -41, -43, -46, -47,
-50, -52, -54, -57, -59, -61, -64, -66, -68, -70, -73, -76, -77, -80, -82, -84,
-87, -89, -91, -94, -95, -98, -101, -104, -106, -108, -110, -112, -115, -117,
-119, -117, -114, -112, -109, -107, -104, -101, -99, -96, -93, -91, -87, -85,
-83, -80, -77, -75, -72, -70, -67, -64, -62, -58, -56, -53, -51, -48, -45, -43,
-40, -37, -34, -33, -30, -27, -25, -22, -21, -17, -15, -14, -12, -10, -7, -6,
-3, -1, };