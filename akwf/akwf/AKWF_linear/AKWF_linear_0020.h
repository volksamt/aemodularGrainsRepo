#define DATA_LENGTH 512
#define DATA AKWF_linear_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 2, 1, 3, 2, 3, 3, 4, 4, 6, 6,
6, 7, 7, 8, 8, 9, 10, 10, 11, 12, 12, 12, 13, 14, 14, 14, 16, 16, 16, 17, 17,
18, 18, 20, 20, 20, 21, 21, 21, 22, 23, 24, 25, 24, 25, 26, 27, 28, 28, 29, 30,
30, 31, 32, 33, 33, 34, 35, 36, 36, 38, 38, 39, 40, 40, 41, 42, 43, 43, 44, 44,
44, 46, 48, 47, 48, 49, 50, 50, 52, 52, 53, 53, 55, 55, 56, 57, 59, 59, 60, 61,
62, 63, 63, 64, 66, 66, 67, 67, 68, 69, 70, 71, 72, 73, 74, 74, 76, 76, 76, 78,
78, 80, 80, 81, 82, 83, 84, 85, 85, 87, 86, 88, 88, 89, 89, 91, 92, 92, 93, 94,
95, 96, 97, 97, 97, 98, 99, 101, 102, 102, 103, 103, 104, 105, 106, 107, 107,
108, 109, 110, 110, 110, 110, 111, 111, 111, 111, 112, 113, 113, 113, 112, 113,
113, 114, 113, 115, 115, 115, 115, 116, 115, 115, 116, 116, 116, 116, 116, 117,
117, 118, 118, 118, 118, 119, 119, 119, 118, 117, 116, 115, 114, 114, 112, 111,
111, 109, 108, 107, 106, 105, 104, 104, 103, 101, 101, 100, 99, 97, 97, 95, 95,
93, 92, 92, 90, 88, 89, 88, 86, 85, 84, 84, 82, 79, 76, 73, 69, 67, 64, 61, 58,
55, 53, 50, 47, 44, 42, 38, 35, 33, 30, 27, 24, 21, 18, 16, 13, 10, 6, 4, 1, -2,
-4, -8, -10, -14, -16, -19, -21, -25, -27, -28, -31, -34, -35, -37, -40, -42,
-43, -46, -48, -51, -53, -55, -57, -59, -62, -64, -65, -68, -71, -72, -75, -77,
-79, -82, -84, -86, -88, -90, -92, -95, -96, -99, -100, -102, -103, -103, -104,
-104, -105, -105, -105, -105, -106, -106, -107, -106, -107, -108, -108, -109,
-109, -109, -110, -110, -110, -110, -111, -111, -111, -112, -112, -112, -113,
-114, -114, -114, -115, -116, -115, -115, -115, -115, -114, -114, -114, -113,
-113, -113, -113, -112, -112, -112, -111, -111, -110, -110, -109, -109, -109,
-108, -108, -108, -108, -107, -107, -106, -106, -106, -105, -104, -105, -104,
-104, -104, -103, -103, -102, -101, -100, -100, -99, -99, -98, -96, -96, -95,
-95, -93, -92, -91, -90, -90, -89, -88, -88, -86, -86, -84, -83, -83, -82, -81,
-80, -80, -79, -78, -77, -76, -75, -74, -74, -74, -72, -71, -71, -70, -69, -68,
-67, -67, -66, -65, -64, -63, -62, -62, -61, -60, -60, -59, -58, -58, -56, -55,
-54, -53, -52, -53, -51, -50, -50, -49, -48, -47, -46, -46, -45, -44, -43, -42,
-41, -40, -39, -39, -38, -37, -37, -36, -35, -34, -33, -32, -31, -31, -30, -29,
-29, -28, -26, -26, -24, -25, -23, -22, -22, -21, -20, -19, -18, -17, -17, -15,
-16, -14, -14, -13, -12, -12, -11, -10, -11, -10, -9, -9, -9, -8, -7, -7, -7,
-7, -7, -6, -5, -5, -4, -4, -4, -2, -2, -2, -2, -2, -2, -1, 1, };