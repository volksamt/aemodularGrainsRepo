#define DATA_LENGTH 512
#define DATA AKWF_linear_0046

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 2, 3, 4, 4, 6, 6, 6, 7, 9,
9, 10, 10, 12, 14, 13, 15, 15, 16, 18, 19, 19, 20, 21, 23, 24, 24, 25, 26, 26,
28, 28, 30, 31, 31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 43, 44, 46, 47,
48, 49, 50, 51, 52, 53, 54, 56, 56, 57, 59, 60, 60, 62, 63, 65, 66, 67, 67, 69,
70, 71, 71, 73, 75, 75, 76, 77, 79, 79, 82, 82, 82, 84, 85, 85, 86, 87, 87, 88,
89, 89, 90, 90, 92, 92, 93, 94, 95, 96, 96, 96, 97, 98, 99, 100, 101, 101, 101,
103, 103, 105, 105, 106, 106, 107, 108, 108, 108, 110, 109, 111, 110, 110, 111,
112, 111, 112, 111, 113, 113, 113, 112, 113, 113, 113, 114, 115, 114, 115, 116,
115, 116, 115, 116, 116, 117, 118, 117, 118, 118, 118, 119, 119, 119, 119, 118,
119, 118, 117, 117, 117, 115, 116, 116, 115, 115, 113, 114, 114, 113, 113, 112,
112, 112, 112, 110, 111, 111, 110, 109, 109, 109, 109, 108, 108, 107, 106, 106,
106, 105, 104, 103, 102, 100, 100, 98, 97, 95, 94, 92, 91, 90, 89, 87, 87, 85,
83, 83, 81, 79, 80, 77, 77, 75, 74, 72, 72, 70, 68, 67, 66, 65, 63, 62, 61, 60,
57, 56, 53, 51, 49, 47, 45, 42, 39, 38, 35, 33, 31, 29, 27, 24, 21, 20, 17, 16,
13, 10, 8, 6, 5, 1, -1, -3, -6, -8, -10, -11, -14, -17, -18, -21, -24, -25, -27,
-29, -30, -33, -34, -36, -38, -40, -42, -43, -45, -47, -49, -50, -52, -54, -55,
-57, -59, -61, -64, -65, -67, -68, -71, -72, -73, -76, -77, -80, -81, -83, -84,
-86, -88, -90, -91, -91, -92, -94, -94, -94, -95, -96, -96, -97, -98, -98, -99,
-100, -101, -101, -102, -104, -104, -105, -105, -106, -107, -108, -108, -109,
-110, -110, -111, -112, -113, -113, -115, -115, -115, -117, -117, -117, -117,
-116, -116, -117, -117, -117, -117, -117, -117, -116, -117, -116, -117, -117,
-117, -117, -117, -117, -116, -117, -117, -117, -117, -117, -116, -117, -117,
-117, -116, -117, -117, -117, -116, -116, -116, -116, -115, -114, -115, -113,
-114, -112, -113, -111, -111, -110, -109, -109, -108, -108, -107, -107, -106,
-105, -105, -105, -104, -104, -102, -102, -101, -101, -101, -100, -99, -99, -98,
-98, -96, -96, -97, -95, -94, -93, -92, -91, -91, -90, -89, -87, -87, -87, -85,
-84, -83, -82, -81, -81, -79, -79, -78, -77, -75, -74, -73, -73, -72, -71, -71,
-70, -68, -68, -67, -65, -64, -64, -63, -62, -62, -59, -59, -57, -56, -54, -53,
-52, -50, -49, -48, -48, -45, -45, -43, -41, -40, -40, -38, -37, -35, -34, -33,
-31, -31, -29, -28, -27, -25, -25, -23, -22, -21, -19, -18, -17, -15, -16, -15,
-14, -13, -12, -12, -11, -10, -10, -10, -9, -8, -8, -7, -7, -6, -5, -5, -5, -4,
-3, -2, -1, -1, -1, };