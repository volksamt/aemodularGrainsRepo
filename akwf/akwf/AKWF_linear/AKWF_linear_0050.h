#define DATA_LENGTH 512
#define DATA AKWF_linear_0050

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 9, 11, 13, 15, 18, 20, 23,
25, 27, 30, 31, 34, 36, 38, 40, 43, 45, 48, 50, 52, 55, 57, 59, 62, 63, 66, 68,
71, 73, 74, 78, 80, 81, 84, 86, 88, 90, 94, 96, 97, 100, 101, 101, 102, 104,
103, 104, 105, 105, 105, 106, 107, 107, 108, 108, 108, 108, 110, 110, 111, 111,
111, 112, 111, 113, 113, 114, 114, 115, 115, 116, 116, 117, 117, 117, 118, 118,
119, 118, 117, 116, 114, 113, 112, 111, 110, 109, 108, 106, 105, 104, 103, 102,
101, 100, 98, 97, 96, 94, 94, 93, 91, 90, 89, 88, 86, 85, 84, 83, 82, 80, 80,
78, 78, 75, 74, 72, 70, 69, 67, 65, 65, 62, 61, 58, 57, 54, 53, 52, 49, 48, 45,
44, 42, 41, 39, 37, 35, 33, 32, 30, 28, 26, 24, 24, 22, 19, 17, 16, 14, 13, 12,
12, 13, 13, 13, 13, 13, 14, 14, 14, 14, 14, 13, 14, 14, 15, 15, 15, 15, 14, 15,
15, 15, 15, 16, 16, 16, 16, 16, 16, 16, 17, 16, 17, 17, 17, 17, 20, 23, 25, 28,
31, 34, 37, 39, 41, 45, 48, 50, 52, 55, 58, 60, 63, 66, 69, 71, 74, 76, 79, 81,
84, 86, 89, 92, 96, 98, 100, 104, 106, 109, 112, 114, 112, 108, 105, 101, 96,
93, 89, 86, 81, 78, 74, 69, 66, 62, 58, 54, 50, 46, 43, 39, 35, 32, 26, 23, 19,
16, 11, 7, 3, 0, -4, -8, -11, -16, -20, -23, -27, -30, -31, -35, -36, -39, -41,
-44, -46, -48, -51, -53, -55, -57, -60, -61, -64, -66, -69, -71, -74, -75, -78,
-80, -82, -84, -87, -89, -92, -94, -97, -98, -101, -103, -106, -107, -111, -111,
-111, -111, -110, -109, -109, -108, -108, -107, -107, -107, -106, -105, -106,
-106, -105, -105, -104, -103, -104, -102, -103, -102, -102, -101, -101, -101,
-100, -99, -100, -99, -98, -98, -98, -97, -97, -96, -96, -96, -97, -96, -96,
-96, -97, -97, -97, -96, -96, -96, -97, -96, -97, -96, -96, -96, -96, -96, -96,
-96, -97, -96, -96, -95, -96, -96, -96, -96, -96, -96, -96, -96, -96, -95, -95,
-91, -89, -86, -84, -81, -78, -74, -71, -68, -65, -63, -59, -55, -52, -50, -48,
-44, -42, -39, -35, -32, -30, -26, -24, -21, -18, -14, -12, -9, -6, -3, 0, 3, 7,
9, 12, 12, 9, 7, 4, 3, -1, -2, -4, -8, -9, -11, -14, -17, -18, -21, -22, -24,
-27, -30, -32, -34, -37, -38, -41, -43, -46, -48, -49, -51, -55, -56, -58, -61,
-63, -65, -68, -69, -69, -70, -69, -69, -69, -70, -70, -70, -70, -70, -71, -70,
-70, -71, -71, -71, -71, -71, -71, -71, -71, -71, -72, -72, -71, -71, -72, -71,
-72, -72, -72, -72, -72, -72, -72, -73, -71, -69, -67, -63, -60, -58, -57, -54,
-51, -49, -46, -44, -40, -39, -35, -34, -31, -29, -26, -24, -21, -19, -16, -14,
-11, -9, -6, -3, -1, };