#define DATA_LENGTH 512
#define DATA AKWF_linear_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 7, 12, 14, 17, 21, 23, 27, 30,
33, 37, 40, 43, 45, 49, 52, 55, 59, 62, 65, 68, 72, 75, 78, 80, 83, 87, 90, 93,
97, 101, 103, 107, 110, 112, 115, 115, 115, 113, 112, 111, 110, 109, 107, 105,
104, 103, 102, 101, 99, 98, 97, 95, 94, 94, 92, 91, 89, 88, 86, 85, 85, 83, 82,
80, 79, 77, 76, 75, 74, 73, 71, 70, 68, 66, 64, 62, 60, 57, 56, 53, 51, 48, 47,
44, 42, 41, 37, 36, 34, 31, 29, 27, 25, 22, 20, 18, 16, 14, 12, 9, 8, 6, 4, 0,
-1, -3, -5, -7, -8, -9, -9, -9, -9, -11, -10, -10, -11, -11, -12, -12, -13, -13,
-13, -13, -13, -14, -13, -14, -14, -14, -15, -16, -16, -16, -16, -16, -17, -17,
-17, -19, -18, -19, -18, -18, -19, -19, -19, -19, -19, -20, -19, -19, -19, -20,
-20, -20, -20, -20, -19, -20, -19, -19, -20, -20, -20, -19, -20, -19, -20, -19,
-20, -20, -20, -19, -20, -20, -20, -20, -20, -19, -20, -19, -18, -16, -15, -13,
-11, -10, -8, -6, -4, -3, -2, 0, 1, 2, 5, 6, 8, 9, 10, 12, 14, 15, 17, 19, 20,
22, 23, 26, 26, 28, 30, 30, 32, 35, 37, 38, 39, 42, 44, 46, 49, 51, 53, 56, 58,
60, 63, 65, 66, 69, 72, 73, 75, 78, 79, 83, 84, 87, 88, 91, 94, 96, 97, 100,
102, 105, 107, 109, 111, 113, 115, 118, 119, 117, 114, 111, 109, 107, 104, 102,
100, 96, 94, 93, 89, 87, 85, 83, 80, 78, 75, 72, 70, 67, 65, 63, 60, 58, 55, 54,
50, 49, 46, 44, 41, 39, 36, 35, 31, 28, 25, 21, 18, 14, 10, 8, 3, -1, -3, -8,
-11, -14, -18, -22, -25, -29, -33, -36, -39, -43, -46, -50, -53, -57, -60, -65,
-68, -71, -74, -78, -82, -86, -89, -93, -96, -98, -99, -97, -97, -96, -96, -94,
-94, -94, -92, -91, -91, -90, -89, -88, -88, -87, -86, -85, -86, -85, -84, -83,
-81, -82, -80, -80, -79, -79, -77, -78, -77, -76, -74, -75, -74, -73, -71, -70,
-69, -67, -66, -64, -62, -62, -60, -59, -58, -56, -55, -53, -53, -50, -49, -47,
-47, -45, -44, -42, -41, -39, -38, -36, -35, -33, -32, -31, -29, -28, -26, -25,
-24, -22, -21, -21, -20, -21, -21, -20, -21, -20, -20, -20, -20, -19, -19, -19,
-20, -19, -20, -20, -19, -19, -19, -19, -19, -19, -19, -19, -19, -19, -18, -19,
-18, -18, -18, -18, -17, -17, -17, -18, -19, -20, -20, -20, -22, -22, -23, -25,
-25, -25, -26, -27, -28, -29, -30, -30, -30, -31, -32, -34, -34, -36, -35, -37,
-38, -38, -39, -39, -40, -40, -41, -43, -43, -44, -44, -46, -44, -42, -42, -41,
-39, -37, -37, -36, -34, -33, -31, -31, -30, -29, -27, -25, -24, -23, -21, -21,
-19, -18, -16, -16, -13, -13, -12, -10, -9, -8, -6, -5, -4, -3, -1, -1, };