#define DATA_LENGTH 512
#define DATA AKWF_linear_0039

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 7, 9, 10, 11, 12, 12, 13, 14,
15, 15, 16, 16, 17, 18, 19, 19, 20, 21, 22, 22, 23, 24, 24, 25, 25, 26, 27, 28,
28, 28, 29, 30, 31, 31, 32, 33, 34, 34, 35, 35, 38, 39, 41, 43, 44, 46, 47, 49,
50, 52, 53, 56, 58, 58, 60, 62, 64, 64, 67, 68, 69, 71, 72, 75, 76, 78, 80, 81,
82, 84, 86, 87, 89, 91, 93, 94, 94, 93, 92, 92, 91, 91, 91, 91, 90, 90, 88, 89,
89, 87, 87, 87, 86, 86, 86, 84, 85, 84, 83, 84, 83, 82, 83, 82, 82, 81, 80, 80,
80, 79, 79, 78, 77, 74, 70, 67, 64, 60, 57, 54, 51, 47, 45, 40, 37, 34, 30, 27,
25, 21, 17, 15, 11, 8, 4, 1, -2, -5, -8, -12, -15, -19, -22, -25, -28, -31, -34,
-38, -41, -42, -43, -45, -47, -48, -48, -50, -51, -53, -53, -55, -55, -57, -58,
-59, -61, -61, -63, -64, -65, -67, -67, -70, -71, -71, -72, -74, -75, -76, -78,
-79, -80, -81, -82, -83, -85, -85, -85, -85, -85, -84, -84, -84, -85, -83, -84,
-84, -83, -83, -83, -83, -82, -82, -81, -82, -82, -82, -82, -80, -81, -80, -81,
-80, -80, -80, -80, -79, -79, -80, -79, -78, -78, -79, -78, -75, -75, -72, -72,
-69, -69, -67, -65, -64, -62, -61, -61, -58, -57, -56, -54, -53, -52, -50, -49,
-47, -46, -44, -42, -42, -41, -39, -38, -35, -34, -33, -31, -30, -28, -28, -26,
-23, -20, -17, -14, -11, -9, -6, -2, 0, 2, 6, 8, 11, 13, 16, 19, 22, 25, 28, 30,
34, 36, 38, 42, 44, 47, 50, 53, 56, 58, 61, 65, 67, 69, 72, 75, 76, 76, 77, 76,
76, 78, 79, 79, 78, 79, 79, 79, 79, 80, 80, 81, 81, 81, 81, 82, 82, 82, 83, 83,
84, 84, 84, 84, 85, 85, 84, 86, 86, 86, 86, 86, 87, 85, 85, 84, 83, 82, 81, 80,
79, 77, 77, 77, 76, 74, 73, 72, 71, 70, 70, 69, 68, 67, 66, 64, 63, 63, 62, 61,
60, 59, 58, 56, 56, 55, 54, 53, 52, 51, 49, 46, 45, 42, 40, 37, 35, 34, 31, 29,
27, 25, 23, 20, 19, 16, 13, 11, 10, 8, 5, 3, 1, -1, -3, -5, -7, -10, -12, -13,
-16, -18, -20, -22, -24, -27, -29, -32, -35, -37, -40, -42, -44, -47, -49, -52,
-54, -58, -60, -62, -64, -67, -70, -73, -75, -77, -80, -82, -84, -87, -90, -92,
-95, -98, -100, -102, -105, -108, -110, -113, -115, -118, -119, -116, -114,
-112, -111, -110, -108, -106, -105, -102, -101, -99, -97, -96, -93, -93, -91,
-88, -86, -84, -84, -81, -80, -77, -76, -74, -72, -71, -70, -67, -65, -64, -62,
-60, -58, -57, -55, -52, -52, -49, -48, -46, -44, -43, -40, -38, -37, -36, -34,
-31, -30, -28, -27, -25, -23, -21, -19, -18, -15, -14, -12, -10, -9, -7, -6, -4,
-2, 0, };