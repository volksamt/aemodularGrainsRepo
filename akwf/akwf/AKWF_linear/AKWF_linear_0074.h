#define DATA_LENGTH 512
#define DATA AKWF_linear_0074

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 8, 11, 14, 17, 20, 22, 25, 27,
31, 33, 34, 38, 41, 43, 46, 48, 50, 53, 56, 59, 61, 64, 66, 68, 71, 73, 76, 79,
81, 82, 84, 85, 87, 88, 89, 91, 92, 93, 94, 95, 97, 97, 99, 100, 102, 103, 105,
106, 107, 108, 110, 111, 113, 114, 114, 115, 114, 114, 114, 114, 115, 115, 114,
115, 114, 114, 114, 114, 114, 114, 115, 114, 114, 114, 115, 115, 115, 114, 114,
114, 114, 114, 115, 115, 115, 115, 115, 115, 116, 116, 117, 117, 117, 117, 117,
117, 117, 118, 118, 118, 119, 119, 119, 118, 118, 119, 118, 117, 116, 114, 113,
112, 110, 110, 109, 107, 106, 104, 103, 102, 101, 99, 98, 98, 96, 95, 93, 92,
91, 90, 89, 85, 80, 74, 69, 62, 56, 51, 45, 39, 33, 28, 22, 16, 11, 5, -1, -7,
-13, -18, -24, -30, -35, -41, -47, -53, -58, -61, -63, -65, -67, -70, -72, -75,
-77, -79, -81, -83, -86, -89, -91, -93, -96, -97, -100, -102, -105, -107, -109,
-112, -114, -116, -117, -115, -114, -112, -110, -108, -107, -105, -103, -101,
-100, -98, -96, -94, -92, -91, -89, -87, -86, -84, -83, -81, -78, -77, -76, -73,
-73, -72, -71, -69, -69, -69, -67, -67, -66, -64, -64, -63, -62, -62, -60, -60,
-59, -58, -58, -57, -56, -55, -54, -55, -53, -52, -51, -51, -51, -49, -50, -48,
-48, -47, -47, -45, -46, -44, -44, -42, -42, -41, -41, -41, -40, -39, -39, -38,
-38, -36, -36, -35, -33, -33, -30, -30, -28, -27, -26, -24, -23, -21, -20, -19,
-18, -16, -15, -13, -12, -12, -9, -9, -7, -6, -4, -3, -1, 1, 5, 7, 10, 13, 16,
20, 22, 24, 28, 30, 34, 37, 40, 42, 46, 49, 51, 54, 57, 60, 63, 65, 69, 71, 74,
76, 77, 79, 81, 83, 84, 86, 88, 91, 92, 94, 95, 97, 99, 101, 103, 105, 107, 108,
110, 112, 114, 115, 117, 118, 116, 113, 111, 107, 104, 101, 97, 94, 92, 88, 85,
82, 79, 76, 73, 69, 67, 64, 60, 56, 53, 50, 48, 44, 40, 38, 33, 29, 25, 23, 18,
14, 11, 7, 2, -1, -5, -9, -12, -16, -21, -24, -28, -31, -35, -40, -44, -47, -51,
-55, -58, -61, -61, -62, -64, -65, -65, -67, -67, -68, -69, -70, -70, -71, -72,
-73, -74, -75, -75, -77, -78, -79, -80, -80, -82, -82, -83, -84, -84, -85, -85,
-87, -86, -88, -88, -88, -89, -90, -91, -91, -92, -93, -93, -93, -94, -95, -96,
-96, -96, -97, -97, -98, -99, -99, -101, -102, -102, -102, -103, -104, -104,
-105, -105, -107, -107, -108, -108, -109, -110, -111, -112, -113, -114, -114,
-114, -115, -116, -117, -115, -113, -112, -109, -108, -106, -103, -102, -100,
-97, -95, -94, -92, -90, -88, -86, -85, -83, -81, -79, -76, -74, -73, -71, -69,
-66, -63, -60, -56, -54, -50, -47, -43, -40, -37, -34, -30, -27, -24, -21, -17,
-14, -10, -7, -5, -1, };