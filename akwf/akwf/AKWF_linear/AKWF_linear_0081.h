#define DATA_LENGTH 512
#define DATA AKWF_linear_0081

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 8, 12, 15, 19, 23, 27, 31, 35,
39, 43, 47, 51, 54, 58, 62, 66, 70, 74, 78, 79, 79, 81, 81, 81, 82, 83, 82, 83,
83, 83, 84, 85, 85, 85, 86, 86, 87, 87, 87, 88, 89, 89, 89, 90, 89, 90, 91, 92,
91, 92, 93, 93, 94, 94, 94, 94, 95, 95, 96, 96, 96, 98, 98, 98, 99, 99, 99, 100,
100, 101, 100, 98, 98, 97, 96, 94, 93, 93, 92, 91, 90, 89, 87, 87, 86, 86, 84,
83, 82, 81, 80, 79, 78, 77, 76, 74, 73, 73, 72, 71, 69, 68, 68, 66, 65, 65, 63,
63, 61, 61, 60, 58, 57, 56, 56, 54, 53, 52, 51, 51, 49, 50, 50, 51, 53, 53, 55,
55, 57, 58, 59, 60, 60, 61, 62, 64, 65, 66, 67, 68, 69, 70, 71, 72, 73, 74, 75,
77, 77, 79, 79, 80, 82, 82, 84, 85, 84, 86, 87, 88, 89, 91, 92, 93, 94, 95, 95,
96, 97, 99, 99, 101, 101, 99, 97, 95, 92, 91, 88, 85, 83, 81, 78, 76, 74, 72,
70, 67, 65, 63, 61, 59, 57, 53, 52, 50, 47, 45, 43, 40, 38, 36, 34, 32, 30, 28,
25, 22, 21, 19, 16, 14, 12, 10, 8, 6, 3, 0, -1, -4, -7, -8, -11, -12, -13, -11,
-12, -12, -12, -12, -12, -11, -11, -11, -10, -10, -10, -10, -9, -9, -9, -9, -9,
-8, -8, -9, -8, -8, -7, -7, -7, -7, -7, -6, -6, -6, -6, -6, -5, -5, -4, -5, -5,
-4, -4, -4, -3, -4, -4, -3, -3, -2, -2, -2, -2, -2, -2, -2, -3, -4, -4, -4, -4,
-5, -5, -6, -6, -7, -7, -7, -8, -8, -9, -9, -9, -9, -10, -10, -11, -11, -12,
-12, -12, -13, -13, -13, -14, -14, -15, -15, -16, -16, -16, -17, -16, -17, -18,
-18, -19, -20, -19, -20, -21, -21, -21, -22, -23, -25, -26, -28, -30, -31, -33,
-36, -37, -39, -41, -43, -45, -47, -49, -50, -52, -53, -56, -57, -59, -61, -63,
-65, -66, -68, -70, -72, -74, -76, -78, -79, -81, -83, -84, -87, -89, -90, -92,
-93, -96, -98, -99, -102, -103, -105, -106, -109, -111, -112, -114, -115, -114,
-112, -111, -109, -108, -108, -107, -106, -105, -103, -102, -101, -100, -99,
-98, -98, -96, -95, -94, -93, -92, -90, -90, -88, -88, -86, -85, -85, -83, -83,
-81, -80, -78, -78, -77, -76, -74, -74, -72, -71, -70, -69, -68, -66, -66, -64,
-64, -63, -62, -60, -61, -62, -63, -64, -64, -67, -68, -69, -69, -71, -72, -73,
-74, -76, -76, -78, -80, -80, -81, -82, -84, -85, -86, -87, -89, -90, -90, -92,
-92, -94, -96, -96, -98, -100, -100, -101, -103, -104, -104, -106, -106, -109,
-109, -110, -111, -113, -114, -115, -116, -118, -118, -119, -115, -111, -108,
-103, -99, -96, -91, -89, -84, -80, -76, -73, -68, -64, -60, -56, -53, -49, -45,
-41, -37, -33, -30, -26, -23, -18, -14, -10, -6, -3, };