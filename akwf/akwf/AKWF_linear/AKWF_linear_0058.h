#define DATA_LENGTH 512
#define DATA AKWF_linear_0058

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 4, 5, 5, 7, 8, 8, 10, 12, 12,
14, 15, 16, 17, 19, 20, 21, 21, 23, 25, 25, 27, 28, 29, 30, 32, 33, 35, 35, 36,
38, 39, 40, 42, 42, 44, 46, 46, 48, 49, 50, 50, 52, 54, 54, 53, 53, 54, 53, 53,
54, 53, 54, 53, 53, 53, 54, 53, 53, 54, 54, 54, 54, 54, 54, 54, 53, 53, 53, 54,
53, 54, 54, 53, 53, 54, 53, 54, 53, 54, 54, 53, 54, 54, 54, 53, 54, 54, 53, 53,
53, 54, 53, 54, 53, 53, 52, 52, 53, 54, 53, 53, 53, 53, 53, 53, 53, 53, 53, 53,
53, 53, 53, 52, 53, 53, 53, 53, 53, 54, 53, 53, 53, 54, 53, 53, 54, 53, 54, 54,
55, 54, 54, 54, 54, 55, 55, 54, 55, 54, 54, 54, 54, 54, 55, 55, 55, 55, 55, 55,
56, 55, 55, 55, 54, 53, 52, 51, 50, 49, 48, 47, 46, 44, 43, 43, 42, 41, 40, 39,
37, 36, 36, 34, 34, 33, 32, 31, 29, 28, 27, 26, 26, 25, 24, 23, 22, 21, 19, 19,
17, 17, 15, 15, 14, 12, 12, 11, 11, 8, 8, 8, 6, 6, 4, 3, 3, 1, 1, -1, -2, -2,
-4, -5, -5, -7, -8, -8, -8, -11, -11, -12, -13, -14, -15, -16, -17, -18, -18,
-19, -20, -20, -20, -22, -23, -24, -23, -25, -25, -26, -26, -27, -28, -29, -30,
-30, -31, -31, -32, -33, -33, -34, -35, -35, -36, -37, -38, -39, -39, -40, -41,
-42, -42, -42, -42, -41, -42, -42, -41, -41, -41, -40, -41, -40, -40, -40, -40,
-40, -40, -40, -39, -39, -40, -39, -39, -39, -38, -38, -37, -38, -38, -37, -38,
-38, -38, -37, -36, -37, -37, -37, -36, -36, -37, -36, -35, -36, -35, -36, -35,
-35, -35, -35, -35, -35, -34, -35, -35, -35, -34, -34, -34, -34, -34, -34, -34,
-33, -34, -33, -34, -34, -33, -33, -33, -33, -33, -33, -31, -29, -27, -25, -23,
-21, -18, -16, -14, -13, -10, -8, -6, -4, -3, 0, 3, 4, 6, 8, 11, 12, 14, 16, 19,
21, 22, 25, 27, 28, 31, 33, 34, 38, 39, 41, 43, 41, 40, 38, 37, 36, 34, 33, 32,
30, 29, 28, 25, 23, 23, 21, 19, 19, 17, 16, 14, 13, 11, 10, 9, 7, 5, 3, 3, 1,
-1, -2, -3, -5, -7, -9, -10, -12, -15, -17, -21, -23, -26, -30, -33, -36, -38,
-42, -45, -48, -51, -54, -56, -60, -62, -65, -69, -71, -74, -78, -80, -84, -86,
-90, -93, -95, -98, -102, -105, -107, -110, -113, -117, -119, -117, -115, -112,
-109, -107, -104, -103, -100, -97, -94, -92, -90, -87, -84, -83, -80, -78, -75,
-73, -70, -67, -65, -63, -60, -57, -55, -53, -50, -48, -46, -44, -40, -38, -36,
-33, -30, -29, -27, -27, -26, -24, -24, -23, -21, -20, -20, -18, -17, -16, -15,
-14, -13, -12, -12, -10, -9, -8, -7, -6, -4, -3, -3, -1, -1, };