#define DATA_LENGTH 512
#define DATA AKWF_linear_0041

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 10, 13, 18, 22, 27, 30, 34, 39,
43, 46, 51, 55, 60, 63, 68, 72, 76, 80, 81, 82, 81, 83, 83, 83, 84, 84, 84, 85,
86, 87, 87, 87, 87, 88, 89, 89, 89, 90, 90, 92, 92, 93, 92, 93, 94, 94, 95, 96,
97, 97, 96, 98, 98, 98, 99, 97, 96, 95, 94, 92, 92, 91, 89, 89, 87, 86, 86, 84,
83, 82, 80, 80, 78, 78, 76, 75, 74, 72, 71, 71, 70, 68, 68, 66, 65, 64, 62, 62,
61, 59, 58, 59, 61, 61, 63, 63, 63, 65, 66, 66, 67, 67, 69, 70, 71, 71, 72, 74,
74, 74, 75, 77, 77, 78, 79, 80, 81, 81, 83, 84, 85, 85, 86, 87, 88, 89, 90, 89,
85, 82, 78, 76, 72, 69, 65, 63, 59, 56, 53, 49, 46, 43, 39, 35, 34, 29, 25, 23,
20, 17, 12, 10, 6, 3, 1, -4, -6, -10, -13, -16, -20, -23, -25, -29, -30, -33,
-33, -35, -36, -37, -38, -39, -41, -41, -44, -44, -47, -47, -48, -50, -51, -52,
-54, -55, -56, -58, -58, -60, -61, -62, -64, -65, -67, -68, -69, -70, -71, -73,
-74, -75, -75, -74, -73, -72, -71, -69, -68, -66, -66, -64, -63, -61, -60, -59,
-58, -56, -56, -54, -52, -52, -49, -49, -48, -46, -45, -44, -43, -42, -40, -39,
-36, -37, -35, -33, -32, -31, -30, -30, -29, -29, -29, -29, -29, -29, -29, -28,
-28, -27, -27, -27, -27, -28, -27, -27, -26, -26, -27, -27, -26, -26, -27, -26,
-25, -25, -25, -25, -26, -25, -25, -24, -24, -25, -24, -25, -22, -20, -20, -19,
-18, -16, -14, -12, -12, -10, -8, -7, -6, -5, -3, -2, 0, 2, 3, 3, 5, 7, 8, 9,
11, 12, 14, 15, 16, 18, 19, 21, 22, 24, 26, 27, 28, 31, 33, 36, 38, 40, 42, 45,
48, 49, 52, 54, 57, 59, 61, 64, 67, 69, 72, 74, 76, 79, 81, 83, 86, 88, 90, 93,
95, 98, 101, 103, 104, 107, 109, 113, 114, 111, 108, 105, 101, 98, 94, 91, 88,
84, 81, 77, 75, 71, 68, 65, 60, 57, 54, 51, 48, 44, 41, 38, 34, 30, 28, 23, 21,
18, 14, 11, 7, 4, 0, -3, -7, -9, -12, -15, -18, -22, -24, -28, -30, -33, -36,
-40, -42, -46, -48, -51, -55, -58, -61, -64, -66, -70, -73, -77, -80, -83, -85,
-88, -92, -94, -98, -100, -104, -106, -109, -112, -116, -119, -119, -118, -119,
-118, -118, -117, -117, -117, -117, -116, -116, -116, -115, -115, -115, -114,
-115, -115, -114, -114, -113, -113, -112, -113, -112, -113, -112, -112, -111,
-111, -112, -110, -111, -109, -109, -109, -109, -108, -107, -106, -104, -104,
-103, -102, -101, -100, -99, -98, -97, -96, -95, -94, -93, -92, -91, -89, -90,
-88, -87, -87, -85, -85, -84, -82, -81, -80, -80, -78, -78, -76, -75, -75, -73,
-70, -66, -62, -58, -53, -49, -45, -40, -36, -32, -28, -24, -19, -15, -12, -7,
-3, };