#define DATA_LENGTH 512
#define DATA AKWF_linear_0076

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 10, 14, 18, 23, 27, 31, 36, 40,
45, 50, 53, 57, 63, 67, 72, 75, 80, 84, 88, 93, 97, 101, 107, 110, 114, 118,
118, 118, 118, 115, 115, 113, 113, 112, 112, 110, 110, 108, 108, 106, 106, 105,
105, 103, 103, 101, 101, 100, 100, 98, 97, 96, 95, 95, 93, 93, 92, 92, 89, 90,
88, 88, 86, 86, 84, 84, 83, 82, 81, 80, 79, 79, 78, 77, 75, 75, 74, 72, 68, 65,
62, 59, 56, 52, 49, 47, 43, 40, 37, 33, 29, 27, 24, 21, 17, 13, 10, 7, 4, 1, -2,
-5, -8, -12, -15, -18, -21, -25, -28, -31, -35, -38, -40, -43, -47, -50, -54,
-57, -60, -63, -65, -70, -72, -76, -80, -83, -86, -88, -88, -87, -85, -84, -82,
-80, -79, -77, -75, -74, -72, -70, -69, -68, -65, -63, -61, -60, -58, -56, -55,
-53, -52, -50, -48, -47, -44, -44, -41, -39, -38, -37, -35, -33, -31, -30, -28,
-27, -24, -23, -21, -20, -18, -16, -14, -13, -11, -9, -7, -6, -4, -3, -4, -4,
-3, -5, -4, -5, -5, -5, -4, -5, -5, -6, -6, -6, -6, -6, -7, -6, -8, -7, -7, -8,
-8, -8, -8, -9, -8, -9, -8, -9, -9, -9, -10, -9, -10, -11, -9, -10, -11, -10,
-11, -11, -11, -12, -12, -13, -12, -12, -13, -12, -12, -12, -11, -12, -11, -10,
-10, -9, -9, -9, -9, -9, -8, -8, -7, -6, -7, -7, -6, -6, -5, -5, -5, -5, -4, -3,
-3, -2, -2, -2, -1, -1, -1, -1, -1, 0, 1, 0, 1, 2, 2, 3, 2, 2, 2, 4, 4, 5, 5, 6,
6, 6, 6, 5, 5, 4, 4, 4, 4, 3, 2, 2, 2, 2, 1, 1, 0, 0, 1, -1, -1, -1, -1, -2, -1,
-2, -3, -3, -3, -3, -5, -5, -5, -5, -6, -6, -6, -7, -7, -7, -7, -8, -8, -9, -9,
-9, -10, -10, -10, -11, -12, -12, -12, -12, -11, -11, -11, -10, -11, -10, -9,
-9, -10, -9, -8, -8, -7, -7, -7, -8, -7, -7, -6, -6, -5, -6, -5, -4, -5, -4, -3,
-3, -3, -3, -3, -2, -2, -1, -1, -1, 0, 0, 0, 0, 1, 2, 2, 2, 1, 2, 3, 2, 4, 3, 3,
4, 5, 5, 6, 6, 5, 7, 7, 7, 7, 8, 8, 8, 8, 8, 9, 10, 10, 11, 10, 11, 11, 11, 12,
11, 12, 13, 13, 13, 13, 14, 14, 14, 15, 15, 15, 17, 16, 16, 16, 17, 17, 17, 18,
18, 19, 19, 19, 19, 19, 19, 16, 14, 11, 8, 7, 4, 2, -1, -4, -6, -8, -10, -13,
-16, -18, -20, -23, -25, -27, -30, -33, -35, -38, -41, -42, -45, -48, -50, -53,
-55, -58, -60, -61, -64, -67, -69, -72, -75, -77, -78, -82, -84, -86, -89, -91,
-94, -96, -98, -100, -103, -103, -99, -94, -90, -86, -82, -77, -72, -68, -63,
-59, -55, -51, -46, -41, -37, -33, -29, -23, -20, -15, -10, -6, -2, };