#define DATA_LENGTH 512
#define DATA AKWF_linear_0026

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 12, 15, 17, 18, 20, 21, 23,
25, 26, 28, 29, 30, 32, 33, 35, 37, 39, 40, 41, 42, 44, 47, 49, 49, 50, 53, 55,
56, 58, 58, 61, 62, 64, 65, 68, 69, 70, 72, 71, 68, 66, 64, 61, 58, 56, 54, 51,
50, 48, 46, 43, 41, 39, 36, 34, 32, 30, 26, 25, 22, 21, 17, 16, 14, 11, 9, 7, 4,
3, -1, -2, -5, -7, -9, -11, -7, -5, -1, 1, 4, 8, 10, 13, 17, 20, 23, 25, 27, 32,
33, 36, 40, 42, 45, 48, 51, 54, 57, 60, 63, 66, 68, 72, 74, 78, 80, 83, 86, 90,
92, 95, 96, 95, 95, 95, 94, 94, 94, 93, 93, 93, 91, 92, 91, 92, 91, 90, 89, 89,
88, 89, 88, 88, 88, 88, 86, 87, 86, 86, 85, 85, 84, 85, 85, 84, 84, 84, 82, 77,
71, 65, 60, 55, 49, 43, 38, 33, 27, 21, 15, 10, 5, -1, -7, -12, -18, -22, -28,
-35, -39, -46, -50, -56, -62, -67, -72, -78, -84, -89, -95, -101, -107, -111,
-117, -118, -118, -116, -116, -115, -113, -112, -111, -110, -109, -107, -106,
-106, -105, -104, -102, -100, -100, -98, -97, -96, -95, -94, -93, -92, -91, -90,
-89, -87, -87, -86, -84, -84, -81, -80, -80, -79, -77, -73, -72, -69, -66, -64,
-61, -59, -58, -53, -51, -50, -47, -45, -41, -40, -38, -35, -32, -30, -28, -26,
-23, -20, -18, -16, -13, -12, -8, -6, -4, -1, 1, 3, 6, 9, 9, 11, 12, 13, 14, 13,
15, 15, 16, 18, 18, 18, 20, 20, 21, 21, 22, 23, 25, 25, 26, 26, 27, 28, 29, 30,
30, 31, 32, 32, 33, 34, 35, 35, 36, 37, 38, 37, 35, 34, 32, 32, 30, 27, 26, 24,
24, 22, 20, 19, 18, 16, 14, 13, 12, 10, 8, 7, 6, 4, 3, 2, -1, -3, -3, -4, -6,
-8, -9, -11, -12, -14, -16, -16, -14, -14, -12, -11, -8, -8, -6, -6, -4, -2, -2,
0, 1, 2, 4, 5, 7, 8, 10, 11, 12, 13, 15, 16, 18, 18, 20, 21, 23, 23, 25, 27, 29,
30, 31, 32, 33, 34, 34, 35, 35, 36, 37, 38, 38, 37, 39, 40, 40, 40, 41, 41, 42,
42, 43, 44, 45, 44, 46, 46, 47, 47, 48, 47, 50, 50, 49, 50, 50, 53, 51, 54, 52,
49, 47, 43, 40, 37, 34, 30, 28, 25, 21, 18, 16, 11, 9, 5, 2, -1, -3, -8, -10,
-13, -17, -20, -22, -26, -29, -32, -36, -39, -42, -45, -48, -51, -54, -57, -61,
-62, -64, -64, -66, -68, -69, -70, -72, -74, -75, -76, -77, -79, -80, -81, -84,
-84, -86, -88, -88, -90, -91, -92, -94, -95, -96, -97, -100, -101, -101, -104,
-105, -107, -108, -109, -110, -111, -108, -104, -100, -97, -94, -91, -88, -84,
-81, -77, -73, -70, -66, -63, -60, -57, -53, -50, -46, -42, -39, -35, -32, -28,
-25, -21, -18, -15, -11, -8, -5, -2, };