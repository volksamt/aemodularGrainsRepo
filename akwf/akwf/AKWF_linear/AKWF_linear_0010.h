#define DATA_LENGTH 512
#define DATA AKWF_linear_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 12, 15, 19, 22, 25, 30, 33,
37, 39, 44, 47, 48, 50, 52, 53, 55, 58, 58, 60, 62, 63, 65, 67, 68, 70, 72, 74,
75, 77, 80, 80, 82, 84, 86, 88, 90, 90, 92, 94, 97, 98, 100, 101, 104, 105, 106,
108, 108, 108, 109, 108, 107, 108, 106, 108, 106, 107, 106, 106, 105, 106, 105,
104, 105, 105, 104, 104, 103, 104, 104, 103, 102, 102, 102, 102, 102, 101, 101,
101, 101, 101, 100, 100, 99, 100, 100, 99, 99, 100, 99, 99, 100, 99, 99, 100,
100, 100, 100, 99, 100, 100, 100, 100, 99, 100, 100, 100, 99, 99, 100, 100, 100,
100, 100, 99, 100, 100, 100, 99, 99, 99, 100, 101, 100, 100, 101, 100, 101, 100,
101, 101, 101, 101, 101, 101, 101, 101, 101, 101, 101, 102, 102, 102, 102, 102,
102, 101, 102, 102, 103, 103, 103, 103, 103, 104, 103, 103, 103, 102, 102, 102,
102, 102, 101, 101, 100, 100, 100, 100, 100, 100, 99, 99, 98, 98, 98, 98, 98,
96, 96, 97, 96, 95, 96, 95, 95, 94, 94, 93, 94, 93, 93, 92, 93, 94, 93, 94, 95,
94, 96, 96, 96, 96, 97, 98, 98, 99, 98, 98, 99, 99, 101, 100, 101, 101, 102,
102, 102, 103, 103, 104, 103, 105, 105, 106, 105, 106, 107, 107, 107, 105, 103,
100, 98, 96, 94, 92, 89, 87, 85, 82, 80, 78, 75, 74, 71, 69, 67, 65, 62, 60, 57,
55, 53, 51, 49, 46, 44, 41, 40, 38, 35, 33, 30, 28, 25, 24, 19, 16, 12, 8, 4, 0,
-3, -7, -11, -14, -18, -22, -26, -30, -34, -37, -41, -45, -48, -52, -57, -60,
-64, -68, -71, -75, -79, -82, -86, -90, -94, -98, -102, -105, -110, -112, -114,
-114, -113, -114, -114, -113, -114, -114, -113, -114, -113, -113, -113, -113,
-114, -113, -113, -113, -113, -113, -114, -113, -113, -113, -114, -113, -113,
-114, -113, -113, -113, -113, -113, -113, -113, -113, -113, -114, -114, -114,
-114, -113, -113, -113, -114, -113, -115, -114, -114, -114, -115, -115, -114,
-115, -115, -115, -114, -115, -115, -115, -115, -116, -116, -116, -116, -116,
-115, -115, -116, -116, -116, -117, -116, -116, -115, -116, -115, -116, -115,
-115, -115, -115, -114, -114, -115, -114, -114, -113, -113, -113, -113, -112,
-112, -112, -112, -112, -112, -111, -111, -111, -111, -110, -111, -110, -110,
-110, -109, -110, -109, -109, -109, -110, -110, -110, -110, -111, -112, -112,
-112, -113, -113, -113, -113, -114, -113, -114, -114, -114, -114, -115, -115,
-116, -116, -116, -117, -116, -117, -118, -117, -118, -118, -117, -118, -118,
-119, -119, -118, -117, -117, -116, -114, -114, -113, -113, -111, -110, -109,
-107, -107, -106, -104, -104, -104, -102, -102, -101, -99, -98, -97, -97, -96,
-95, -93, -93, -92, -91, -90, -90, -88, -87, -86, -85, -84, -80, -77, -73, -70,
-66, -63, -59, -55, -51, -49, -45, -41, -38, -35, -31, -26, -24, -20, -16, -12,
-9, -5, -2, };