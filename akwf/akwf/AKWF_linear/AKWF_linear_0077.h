#define DATA_LENGTH 512
#define DATA AKWF_linear_0077

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 8, 10, 13, 15, 17, 19, 20,
23, 24, 26, 26, 27, 28, 29, 30, 31, 31, 32, 33, 34, 34, 36, 36, 37, 38, 39, 39,
41, 42, 42, 43, 44, 45, 46, 47, 47, 49, 49, 50, 52, 53, 53, 53, 55, 55, 56, 57,
58, 59, 60, 60, 62, 63, 64, 65, 65, 65, 66, 68, 67, 66, 64, 63, 61, 61, 60, 58,
57, 57, 55, 53, 53, 51, 50, 48, 48, 46, 45, 44, 43, 41, 40, 39, 37, 37, 36, 34,
32, 31, 31, 30, 28, 27, 25, 24, 23, 22, 21, 19, 17, 17, 16, 14, 13, 12, 11, 9,
8, 8, 6, 7, 9, 11, 13, 16, 18, 20, 22, 24, 26, 29, 31, 33, 36, 38, 39, 42, 44,
47, 48, 52, 53, 56, 57, 60, 63, 64, 67, 69, 72, 74, 75, 77, 80, 82, 85, 86, 89,
91, 94, 95, 99, 100, 102, 104, 107, 109, 111, 113, 115, 117, 119, 118, 119, 117,
117, 116, 116, 115, 114, 114, 113, 113, 113, 112, 111, 111, 110, 110, 109, 108,
109, 107, 107, 106, 106, 106, 105, 104, 103, 104, 102, 102, 102, 101, 100, 100,
99, 99, 98, 97, 97, 97, 96, 95, 96, 95, 94, 94, 93, 92, 92, 91, 87, 84, 82, 78,
75, 72, 69, 66, 63, 59, 56, 54, 50, 47, 44, 41, 38, 34, 31, 29, 25, 23, 20, 16,
12, 10, 7, 4, 0, -2, -6, -9, -12, -15, -19, -22, -24, -28, -30, -33, -37, -40,
-43, -46, -49, -53, -56, -59, -62, -66, -67, -68, -67, -69, -68, -68, -69, -69,
-68, -68, -69, -69, -68, -69, -69, -69, -69, -69, -69, -70, -70, -70, -70, -70,
-70, -70, -70, -70, -71, -71, -72, -70, -71, -71, -71, -71, -71, -72, -72, -71,
-72, -72, -72, -73, -73, -72, -73, -73, -72, -73, -73, -73, -72, -72, -71, -70,
-70, -68, -68, -67, -66, -66, -65, -64, -64, -62, -62, -62, -61, -61, -60, -58,
-58, -57, -56, -55, -55, -55, -53, -53, -52, -51, -51, -50, -49, -48, -47, -47,
-46, -46, -45, -44, -43, -43, -42, -41, -41, -39, -39, -38, -38, -37, -37, -36,
-36, -37, -36, -36, -36, -37, -36, -37, -37, -37, -37, -37, -37, -37, -37, -37,
-38, -37, -38, -37, -38, -38, -39, -37, -37, -38, -38, -38, -39, -39, -39, -39,
-39, -40, -39, -40, -40, -39, -40, -40, -40, -40, -39, -40, -40, -39, -41, -40,
-40, -41, -41, -42, -42, -43, -45, -46, -47, -47, -49, -50, -51, -51, -53, -53,
-54, -55, -57, -57, -58, -59, -61, -61, -63, -64, -64, -65, -66, -67, -68, -69,
-70, -71, -72, -73, -74, -76, -76, -77, -77, -79, -81, -80, -82, -83, -84, -85,
-85, -86, -88, -89, -89, -88, -87, -85, -83, -81, -78, -76, -73, -72, -70, -67,
-64, -62, -60, -59, -56, -54, -51, -50, -46, -44, -42, -40, -37, -36, -34, -31,
-29, -27, -24, -23, -20, -18, -16, -14, -12, -8, -8, -4, -3, 0, };