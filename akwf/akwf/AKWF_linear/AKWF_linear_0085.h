#define DATA_LENGTH 512
#define DATA AKWF_linear_0085

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 5, 8, 11, 13, 16, 18, 21, 23,
25, 27, 29, 30, 32, 34, 35, 37, 38, 40, 41, 43, 44, 47, 49, 49, 51, 53, 55, 56,
58, 59, 61, 64, 65, 66, 67, 70, 71, 73, 74, 75, 78, 80, 80, 83, 85, 85, 88, 89,
90, 92, 94, 95, 97, 98, 101, 102, 104, 105, 107, 109, 110, 109, 109, 109, 110,
110, 110, 110, 111, 111, 111, 112, 111, 111, 112, 112, 111, 113, 112, 113, 113,
113, 113, 113, 114, 114, 114, 115, 115, 115, 115, 116, 116, 115, 116, 116, 117,
117, 117, 117, 117, 117, 117, 117, 118, 118, 118, 118, 119, 119, 118, 117, 114,
112, 107, 105, 101, 99, 95, 92, 89, 86, 83, 80, 76, 73, 71, 67, 63, 61, 57, 54,
51, 48, 45, 42, 39, 34, 33, 29, 26, 23, 19, 16, 13, 10, 7, 4, 1, -3, -6, -8,
-13, -14, -18, -21, -24, -27, -31, -33, -37, -40, -42, -43, -44, -45, -47, -47,
-48, -50, -51, -53, -54, -55, -55, -56, -57, -58, -59, -60, -62, -63, -64, -64,
-66, -67, -68, -68, -69, -71, -72, -73, -75, -75, -76, -77, -78, -80, -80, -81,
-83, -83, -84, -85, -87, -88, -89, -89, -91, -92, -94, -94, -95, -95, -93, -93,
-91, -91, -89, -87, -87, -85, -84, -83, -81, -80, -79, -78, -76, -75, -74, -72,
-72, -70, -68, -68, -67, -65, -64, -63, -61, -60, -59, -57, -56, -55, -55, -53,
-52, -50, -49, -48, -46, -45, -45, -42, -41, -40, -39, -37, -36, -35, -34, -33,
-31, -30, -28, -26, -24, -21, -19, -17, -15, -13, -12, -9, -7, -6, -4, -1, 0, 2,
4, 7, 8, 11, 12, 15, 16, 18, 20, 22, 25, 26, 28, 30, 33, 34, 36, 39, 41, 42, 44,
46, 49, 50, 52, 54, 56, 58, 60, 62, 64, 65, 69, 70, 69, 69, 70, 69, 68, 67, 67,
67, 66, 66, 65, 65, 65, 64, 64, 64, 62, 63, 62, 62, 60, 61, 60, 60, 60, 59, 58,
58, 57, 57, 57, 56, 56, 55, 55, 55, 54, 54, 54, 53, 53, 52, 52, 51, 51, 51, 50,
49, 49, 49, 48, 46, 43, 40, 37, 34, 31, 28, 26, 22, 19, 15, 14, 10, 7, 5, 2, -2,
-4, -7, -10, -14, -17, -19, -22, -25, -28, -31, -34, -37, -40, -43, -46, -49,
-52, -54, -57, -60, -64, -67, -70, -73, -74, -79, -81, -85, -87, -91, -93, -96,
-99, -102, -103, -102, -103, -103, -103, -102, -103, -103, -102, -102, -101,
-103, -102, -102, -102, -102, -102, -101, -102, -101, -102, -102, -102, -101,
-101, -101, -101, -100, -101, -101, -101, -101, -101, -100, -101, -101, -101,
-100, -100, -100, -100, -100, -100, -100, -100, -100, -100, -100, -100, -99,
-99, -99, -96, -94, -91, -89, -86, -83, -82, -79, -77, -74, -72, -69, -67, -64,
-61, -59, -57, -54, -52, -49, -47, -45, -42, -41, -37, -35, -32, -30, -28, -25,
-22, -20, -18, -15, -13, -10, -7, -5, -3, -1, };