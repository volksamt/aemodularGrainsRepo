#define DATA_LENGTH 512
#define DATA AKWF_linear_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 5, 7, 8, 9, 12, 14, 15, 19,
21, 23, 26, 27, 30, 33, 35, 37, 39, 42, 44, 46, 49, 51, 53, 56, 57, 60, 63, 65,
67, 70, 72, 75, 77, 79, 81, 83, 85, 88, 91, 93, 95, 98, 98, 99, 99, 100, 100,
100, 101, 101, 101, 102, 104, 104, 104, 104, 105, 106, 106, 106, 107, 107, 107,
109, 109, 109, 110, 111, 110, 111, 111, 111, 112, 113, 113, 113, 114, 114, 114,
110, 106, 103, 99, 96, 92, 89, 85, 81, 77, 75, 71, 67, 63, 61, 56, 53, 49, 46,
43, 39, 35, 32, 28, 24, 21, 17, 14, 11, 7, 3, -1, -4, -8, -11, -14, -17, -20,
-22, -25, -27, -30, -32, -35, -38, -41, -43, -45, -48, -51, -54, -56, -59, -61,
-63, -66, -69, -72, -73, -75, -78, -81, -83, -86, -89, -91, -94, -97, -99, -101,
-103, -106, -108, -105, -103, -102, -99, -96, -95, -93, -89, -88, -86, -83, -80,
-79, -76, -74, -71, -69, -67, -66, -62, -62, -59, -57, -54, -53, -50, -47, -45,
-43, -40, -39, -36, -34, -31, -29, -27, -24, -21, -18, -14, -10, -7, -3, 0, 3,
6, 10, 15, 17, 20, 25, 27, 31, 34, 38, 42, 45, 49, 52, 56, 59, 62, 66, 68, 72,
76, 80, 83, 86, 90, 93, 96, 100, 100, 101, 101, 102, 103, 102, 104, 104, 105,
104, 106, 105, 107, 108, 108, 109, 109, 109, 110, 110, 112, 111, 113, 112, 113,
113, 114, 115, 115, 116, 117, 117, 118, 118, 118, 119, 118, 117, 115, 113, 112,
110, 108, 106, 105, 104, 102, 100, 98, 97, 95, 93, 92, 91, 88, 87, 85, 83, 83,
80, 79, 77, 75, 74, 73, 70, 69, 67, 65, 63, 61, 60, 59, 56, 55, 53, 50, 48, 46,
44, 42, 40, 38, 36, 33, 32, 30, 27, 25, 23, 21, 19, 18, 15, 13, 11, 9, 7, 5, 3,
0, -1, -3, -6, -8, -10, -12, -14, -16, -18, -20, -21, -23, -25, -26, -29, -29,
-32, -33, -35, -37, -38, -40, -42, -43, -45, -47, -49, -50, -51, -54, -55, -56,
-58, -59, -61, -63, -65, -66, -68, -70, -72, -74, -75, -76, -79, -79, -80, -80,
-82, -82, -83, -83, -85, -86, -86, -87, -87, -87, -89, -89, -91, -91, -93, -93,
-94, -94, -95, -96, -97, -98, -98, -99, -99, -100, -101, -101, -103, -103, -105,
-105, -106, -107, -106, -106, -106, -106, -106, -106, -106, -106, -105, -107,
-106, -107, -106, -106, -106, -105, -106, -106, -105, -106, -106, -105, -105,
-106, -105, -105, -106, -106, -105, -105, -105, -105, -105, -105, -105, -106,
-104, -102, -100, -99, -97, -96, -94, -93, -90, -90, -88, -86, -84, -83, -81,
-80, -78, -76, -74, -72, -72, -69, -68, -66, -64, -63, -62, -60, -58, -56, -55,
-53, -51, -50, -49, -47, -45, -43, -42, -41, -38, -37, -35, -34, -32, -30, -29,
-27, -26, -25, -23, -21, -20, -17, -16, -15, -13, -12, -10, -8, -7, -6, -4, -2,
-1, };