#define DATA_LENGTH 512
#define DATA AKWF_linear_0042

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 10, 13, 16, 18, 22, 25, 28,
31, 34, 36, 38, 40, 43, 45, 48, 50, 52, 55, 57, 60, 62, 63, 67, 69, 71, 74, 76,
79, 81, 83, 85, 88, 90, 93, 96, 97, 100, 103, 104, 107, 110, 113, 114, 117, 119,
117, 116, 112, 110, 107, 105, 102, 99, 97, 94, 92, 90, 86, 84, 81, 78, 75, 74,
70, 68, 64, 62, 60, 57, 55, 52, 50, 46, 45, 41, 39, 36, 34, 31, 29, 25, 24, 21,
18, 15, 12, 9, 7, 5, 1, -1, -4, -6, -9, -11, -15, -17, -20, -22, -24, -27, -30,
-33, -36, -38, -41, -44, -46, -50, -52, -55, -57, -60, -63, -65, -68, -71, -74,
-73, -69, -67, -63, -60, -57, -55, -52, -49, -46, -44, -40, -38, -34, -31, -28,
-26, -23, -20, -17, -13, -10, -7, -4, -1, 1, 5, 8, 9, 12, 17, 19, 22, 25, 28,
30, 34, 33, 32, 31, 30, 29, 30, 28, 27, 27, 27, 25, 25, 24, 23, 22, 22, 20, 20,
20, 19, 18, 17, 17, 16, 15, 15, 14, 13, 12, 12, 11, 11, 10, 8, 8, 7, 6, 6, 6, 5,
6, 4, 5, 4, 3, 3, 2, 2, 1, 0, 0, 0, -1, -1, -2, -2, -2, -3, -4, -3, -4, -6, -6,
-5, -6, -7, -8, -8, -9, -9, -9, -10, -10, -10, -8, -6, -5, -4, -1, 0, 1, 2, 4,
4, 6, 8, 8, 11, 12, 12, 13, 16, 17, 18, 19, 21, 22, 23, 25, 26, 27, 29, 30, 32,
33, 35, 36, 37, 38, 39, 39, 39, 41, 40, 41, 40, 41, 42, 42, 41, 43, 43, 43, 43,
44, 43, 43, 44, 45, 44, 45, 44, 46, 45, 46, 46, 47, 47, 47, 46, 48, 48, 48, 48,
48, 48, 48, 48, 47, 47, 46, 46, 45, 44, 45, 44, 43, 43, 44, 42, 41, 42, 41, 41,
40, 40, 39, 39, 39, 38, 38, 38, 37, 37, 36, 35, 36, 35, 34, 34, 33, 34, 32, 30,
27, 25, 22, 19, 17, 14, 12, 9, 6, 5, 2, -1, -2, -5, -8, -10, -12, -15, -18, -21,
-22, -25, -28, -30, -32, -35, -38, -39, -42, -45, -48, -50, -53, -54, -57, -58,
-59, -58, -58, -59, -59, -59, -59, -59, -59, -60, -61, -61, -61, -61, -61, -62,
-62, -61, -62, -62, -62, -63, -63, -63, -63, -64, -64, -64, -63, -65, -64, -65,
-64, -65, -65, -65, -66, -65, -64, -64, -65, -64, -64, -63, -64, -63, -64, -63,
-63, -62, -63, -61, -62, -62, -61, -61, -61, -60, -60, -60, -59, -59, -59, -60,
-59, -59, -58, -58, -58, -58, -58, -57, -58, -58, -58, -59, -59, -59, -60, -61,
-61, -61, -61, -62, -62, -62, -63, -64, -64, -64, -64, -65, -66, -66, -66, -66,
-67, -68, -67, -68, -68, -69, -69, -69, -70, -70, -70, -71, -71, -68, -66, -62,
-60, -58, -55, -51, -48, -46, -43, -40, -37, -35, -32, -29, -26, -23, -20, -17,
-15, -13, -9, -6, -3, -1, };