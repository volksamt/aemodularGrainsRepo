#define DATA_LENGTH 512
#define DATA AKWF_linear_0075

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 6, 8, 9, 11, 12, 14, 16, 17,
19, 21, 23, 24, 25, 28, 29, 31, 33, 34, 36, 38, 39, 41, 41, 42, 42, 43, 44, 44,
44, 44, 46, 47, 47, 47, 48, 49, 48, 50, 51, 50, 51, 52, 53, 53, 54, 55, 55, 56,
56, 56, 57, 58, 58, 59, 60, 60, 61, 61, 62, 62, 64, 64, 64, 65, 65, 66, 67, 68,
68, 68, 68, 69, 69, 66, 63, 59, 56, 52, 48, 43, 40, 36, 32, 29, 26, 22, 19, 14,
11, 7, 4, -1, -4, -8, -12, -15, -19, -23, -26, -30, -34, -38, -42, -45, -48,
-52, -56, -59, -64, -67, -72, -75, -79, -82, -86, -89, -92, -97, -101, -104,
-107, -111, -114, -119, -117, -115, -111, -108, -106, -104, -100, -97, -95, -92,
-89, -86, -83, -80, -78, -74, -72, -69, -66, -63, -60, -57, -55, -52, -49, -46,
-43, -41, -38, -35, -33, -29, -26, -23, -21, -18, -16, -12, -9, -7, -4, -1, 2,
5, 8, 10, 13, 17, 19, 21, 24, 27, 26, 27, 28, 29, 30, 30, 31, 32, 33, 34, 34,
35, 35, 38, 38, 39, 38, 40, 40, 42, 43, 43, 43, 45, 45, 46, 48, 47, 49, 49, 50,
52, 52, 53, 54, 55, 56, 55, 57, 57, 58, 59, 60, 60, 61, 62, 62, 64, 64, 66, 65,
62, 61, 59, 56, 55, 52, 50, 48, 46, 44, 41, 40, 38, 35, 34, 32, 30, 27, 26, 24,
21, 20, 18, 16, 13, 12, 10, 8, 5, 4, 1, -1, -2, -4, -6, -8, -12, -14, -14, -17,
-19, -21, -23, -25, -27, -29, -31, -34, -36, -38, -39, -38, -39, -38, -37, -36,
-36, -35, -36, -35, -35, -34, -34, -32, -33, -32, -31, -31, -31, -31, -29, -29,
-29, -29, -28, -28, -27, -26, -27, -26, -26, -25, -24, -23, -23, -24, -22, -22,
-22, -21, -21, -21, -20, -19, -19, -19, -18, -18, -17, -17, -16, -17, -16, -16,
-16, -17, -17, -17, -17, -17, -19, -17, -18, -19, -18, -19, -19, -19, -19, -19,
-20, -20, -20, -21, -21, -20, -21, -21, -20, -21, -21, -21, -22, -22, -22, -22,
-23, -23, -23, -23, -23, -23, -24, -24, -25, -23, -25, -24, -25, -25, -24, -26,
-25, -23, -22, -21, -20, -19, -18, -16, -15, -13, -12, -11, -9, -8, -7, -6, -4,
-2, -1, 0, 1, 3, 4, 6, 7, 8, 10, 11, 13, 13, 15, 17, 17, 19, 21, 22, 23, 25, 27,
28, 29, 31, 31, 32, 34, 35, 36, 38, 39, 40, 42, 44, 42, 40, 38, 36, 36, 33, 32,
30, 29, 26, 25, 23, 21, 20, 18, 16, 15, 13, 11, 9, 7, 5, 4, 2, 1, -2, -4, -4,
-6, -8, -9, -12, -14, -16, -16, -18, -20, -22, -24, -26, -27, -28, -30, -32,
-34, -36, -37, -39, -40, -43, -45, -44, -42, -40, -38, -38, -35, -34, -32, -30,
-29, -27, -25, -24, -23, -21, -19, -17, -15, -15, -12, -11, -9, -7, -5, -3, -2,
-1, };