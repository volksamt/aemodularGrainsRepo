#define DATA_LENGTH 512
#define DATA AKWF_linear_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 3, 5, 5, 7, 7, 7, 10, 10, 11,
12, 12, 13, 14, 16, 17, 18, 19, 20, 22, 24, 27, 29, 31, 34, 36, 38, 41, 44, 45,
48, 51, 54, 55, 58, 60, 62, 64, 67, 70, 73, 74, 77, 79, 81, 83, 86, 89, 91, 94,
96, 99, 101, 103, 106, 107, 108, 109, 109, 109, 110, 110, 110, 110, 110, 111,
111, 112, 112, 111, 113, 113, 113, 114, 114, 114, 114, 114, 115, 116, 116, 116,
116, 117, 118, 117, 118, 118, 117, 119, 119, 119, 116, 113, 108, 104, 101, 97,
92, 88, 84, 79, 76, 72, 68, 63, 59, 55, 51, 47, 42, 39, 35, 30, 27, 22, 18, 14,
9, 6, 2, -3, -6, -10, -15, -19, -22, -27, -30, -31, -31, -31, -31, -31, -31,
-31, -32, -32, -32, -32, -32, -32, -32, -33, -32, -33, -33, -32, -33, -33, -34,
-34, -34, -34, -34, -34, -34, -35, -35, -35, -35, -35, -34, -35, -35, -35, -35,
-35, -35, -34, -35, -35, -36, -35, -36, -35, -35, -35, -35, -35, -34, -35, -35,
-35, -35, -35, -35, -35, -35, -35, -34, -35, -35, -34, -35, -34, -35, -35, -34,
-33, -34, -35, -34, -33, -33, -33, -32, -32, -31, -31, -31, -30, -31, -30, -30,
-29, -28, -28, -29, -28, -27, -27, -27, -27, -26, -27, -25, -25, -25, -24, -24,
-24, -23, -23, -23, -23, -22, -22, -20, -17, -14, -11, -8, -6, -3, 0, 4, 7, 9,
13, 15, 17, 21, 24, 27, 30, 32, 36, 38, 41, 45, 48, 51, 53, 56, 59, 62, 65, 67,
71, 75, 78, 80, 83, 86, 84, 83, 80, 78, 76, 74, 71, 70, 67, 64, 63, 61, 59, 56,
53, 51, 50, 47, 45, 43, 40, 39, 37, 34, 33, 30, 28, 26, 23, 21, 19, 16, 14, 12,
10, 8, 6, 6, 6, 6, 5, 5, 5, 5, 5, 3, 3, 2, 3, 3, 2, 2, 1, 1, 1, 1, 0, -1, 0, -1,
-1, -2, -2, -1, -1, -2, -2, -4, -4, -4, -3, -4, -4, -4, -6, -6, -6, -5, -6, -6,
-5, -6, -6, -6, -7, -6, -6, -7, -7, -7, -7, -6, -7, -6, -6, -7, -7, -7, -7, -7,
-8, -8, -8, -7, -8, -8, -8, -8, -8, -8, -9, -11, -13, -15, -17, -18, -20, -21,
-23, -25, -26, -27, -30, -32, -33, -35, -37, -37, -40, -42, -43, -44, -46, -48,
-50, -51, -52, -54, -56, -58, -60, -61, -63, -64, -65, -67, -68, -66, -66, -65,
-63, -62, -62, -60, -59, -58, -57, -56, -55, -53, -53, -52, -51, -50, -48, -47,
-47, -45, -45, -43, -41, -41, -40, -38, -38, -36, -36, -34, -34, -32, -32, -30,
-29, -28, -29, -28, -27, -27, -26, -27, -26, -25, -25, -25, -24, -24, -24, -23,
-23, -23, -22, -22, -21, -21, -21, -21, -20, -19, -18, -18, -17, -18, -17, -17,
-16, -16, -16, -16, -15, -15, -14, -12, -11, -11, -10, -9, -7, -7, -5, -5, -4,
-3, -2, -2, 0, };