#define DATA_LENGTH 512
#define DATA AKWF_linear_0048

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 1, 0, 1, 1, 1, 1, 2, 1, 2, 1,
2, 3, 2, 3, 3, 3, 4, 3, 3, 4, 4, 4, 6, 8, 10, 11, 13, 14, 16, 17, 20, 22, 23,
24, 26, 28, 29, 31, 34, 34, 37, 38, 39, 41, 43, 45, 47, 48, 50, 51, 54, 54, 57,
57, 60, 62, 64, 66, 67, 68, 70, 71, 72, 74, 75, 76, 77, 79, 79, 81, 82, 84, 86,
87, 88, 89, 91, 93, 93, 95, 96, 98, 99, 101, 102, 103, 104, 105, 108, 108, 110,
111, 112, 114, 115, 116, 114, 114, 114, 114, 114, 114, 114, 113, 113, 113, 113,
112, 112, 111, 111, 110, 110, 110, 110, 111, 110, 110, 109, 109, 109, 108, 108,
108, 108, 108, 107, 106, 107, 106, 106, 105, 105, 107, 107, 107, 107, 107, 108,
107, 107, 108, 109, 109, 109, 109, 109, 110, 110, 110, 110, 110, 110, 111, 111,
111, 112, 112, 112, 113, 113, 113, 113, 114, 113, 114, 114, 114, 114, 114, 114,
112, 112, 111, 111, 110, 110, 110, 108, 109, 108, 108, 107, 106, 107, 106, 105,
105, 105, 105, 103, 103, 103, 103, 102, 102, 101, 100, 100, 100, 99, 99, 98, 98,
97, 93, 88, 84, 81, 76, 72, 67, 64, 60, 54, 50, 47, 43, 39, 34, 31, 26, 22, 17,
13, 10, 5, 1, -3, -8, -12, -16, -20, -24, -29, -32, -36, -41, -45, -49, -52,
-55, -57, -59, -61, -63, -64, -66, -68, -70, -71, -74, -75, -78, -79, -80, -82,
-84, -86, -87, -89, -91, -92, -94, -97, -99, -100, -101, -103, -105, -106, -110,
-110, -113, -115, -115, -118, -119, -119, -118, -119, -118, -118, -118, -118,
-117, -117, -117, -118, -116, -116, -116, -116, -117, -115, -115, -115, -115,
-115, -114, -114, -114, -114, -114, -113, -113, -113, -113, -112, -113, -113,
-113, -112, -112, -111, -113, -112, -112, -112, -112, -112, -113, -113, -112,
-114, -115, -115, -114, -114, -115, -115, -115, -115, -115, -115, -116, -115,
-116, -116, -116, -117, -116, -117, -117, -117, -118, -118, -118, -118, -118,
-119, -117, -117, -116, -116, -116, -115, -114, -113, -112, -112, -111, -110,
-110, -110, -109, -109, -108, -107, -107, -106, -105, -106, -104, -104, -103,
-103, -102, -101, -100, -100, -99, -99, -98, -97, -96, -97, -95, -94, -91, -90,
-87, -85, -82, -81, -78, -76, -74, -71, -70, -67, -66, -63, -61, -59, -57, -56,
-53, -50, -48, -47, -45, -42, -40, -38, -35, -34, -31, -29, -27, -24, -22, -21,
-19, -18, -16, -15, -15, -14, -13, -12, -10, -9, -9, -7, -7, -6, -5, -4, -3, -1,
-1, 0, 1, 1, 3, 4, 4, 6, 6, 7, 8, 10, 10, 11, 13, 14, 14, 15, 16, 17, 17, 16,
15, 14, 15, 13, 13, 13, 12, 12, 11, 10, 9, 10, 9, 8, 8, 8, 7, 6, 6, 5, 5, 4, 4,
3, 3, 2, 2, 2, 1, 0, 0, -1, -1, -2, -2, -1, -2, -2, -1, -1, -1, -1, -1, 0, 0, 0,
};