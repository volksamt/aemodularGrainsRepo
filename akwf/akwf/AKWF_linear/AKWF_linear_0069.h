#define DATA_LENGTH 512
#define DATA AKWF_linear_0069

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 13, 20, 28, 35, 41, 48, 53, 54,
58, 60, 63, 65, 68, 71, 74, 75, 79, 80, 83, 86, 88, 91, 94, 95, 98, 101, 103,
106, 109, 111, 114, 116, 115, 112, 109, 107, 103, 100, 98, 96, 92, 89, 87, 84,
82, 78, 76, 73, 70, 67, 64, 62, 59, 56, 53, 50, 48, 46, 47, 49, 50, 51, 52, 55,
56, 57, 59, 59, 62, 63, 63, 66, 67, 68, 70, 71, 72, 74, 76, 77, 78, 79, 81, 80,
78, 77, 73, 71, 69, 68, 65, 63, 61, 59, 57, 55, 52, 51, 48, 46, 44, 42, 39, 37,
36, 33, 31, 30, 27, 27, 30, 32, 33, 34, 36, 38, 39, 41, 42, 44, 45, 47, 48, 50,
52, 53, 55, 57, 57, 59, 61, 62, 64, 65, 67, 67, 68, 69, 70, 71, 71, 71, 73, 74,
74, 76, 76, 76, 78, 78, 79, 81, 80, 82, 82, 83, 84, 85, 86, 87, 85, 82, 79, 78,
75, 73, 70, 69, 66, 64, 62, 59, 57, 55, 53, 50, 48, 46, 43, 41, 39, 37, 35, 33,
30, 28, 29, 30, 31, 31, 33, 34, 34, 35, 35, 36, 37, 38, 39, 40, 40, 41, 42, 43,
44, 44, 44, 46, 46, 48, 48, 45, 39, 34, 29, 24, 17, 12, 7, 2, -4, -9, -15, -20,
-25, -31, -36, -42, -47, -52, -57, -63, -68, -73, -79, -85, -88, -84, -79, -76,
-71, -67, -62, -58, -53, -49, -44, -40, -35, -31, -27, -21, -18, -13, -8, -4, 0,
5, 8, 14, 18, 22, 25, 27, 28, 29, 30, 31, 33, 33, 35, 36, 37, 39, 39, 41, 41,
44, 44, 46, 47, 48, 50, 50, 51, 53, 54, 55, 51, 46, 42, 38, 32, 27, 23, 18, 14,
9, 4, 0, -5, -9, -14, -19, -24, -28, -32, -37, -42, -47, -52, -56, -61, -64,
-63, -61, -60, -59, -57, -56, -55, -54, -52, -51, -50, -48, -47, -46, -44, -43,
-42, -42, -39, -37, -37, -35, -34, -33, -31, -33, -37, -39, -42, -45, -48, -51,
-55, -57, -59, -62, -66, -69, -72, -75, -78, -81, -84, -87, -89, -92, -95, -98,
-101, -105, -106, -104, -101, -99, -96, -93, -91, -88, -85, -82, -81, -78, -76,
-73, -70, -68, -66, -63, -61, -58, -55, -52, -50, -47, -45, -42, -41, -42, -42,
-42, -42, -43, -44, -44, -43, -43, -44, -44, -45, -45, -46, -45, -47, -47, -46,
-47, -48, -48, -48, -48, -48, -50, -50, -51, -51, -52, -54, -55, -56, -56, -58,
-59, -59, -61, -62, -63, -62, -64, -65, -66, -68, -68, -68, -70, -71, -71, -73,
-73, -72, -72, -71, -71, -70, -69, -68, -68, -68, -67, -66, -66, -65, -64, -63,
-63, -63, -62, -61, -60, -60, -59, -58, -58, -57, -58, -62, -64, -66, -69, -72,
-74, -76, -79, -82, -84, -86, -88, -91, -94, -96, -98, -101, -104, -106, -108,
-110, -114, -116, -118, -118, -112, -104, -99, -91, -85, -78, -71, -64, -58,
-51, -45, -38, -32, -24, -18, -12, -4, };