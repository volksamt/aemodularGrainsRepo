#define DATA_LENGTH 512
#define DATA AKWF_linear_0038

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 3, 4, 5, 6, 6, 7, 8, 8, 9, 9,
10, 11, 11, 12, 12, 13, 14, 14, 15, 16, 16, 18, 19, 19, 20, 21, 21, 21, 22, 23,
24, 24, 24, 25, 26, 27, 28, 28, 29, 30, 32, 33, 34, 35, 36, 37, 39, 40, 42, 43,
44, 44, 46, 47, 48, 50, 51, 53, 53, 55, 56, 57, 59, 60, 61, 63, 63, 64, 67, 67,
68, 70, 72, 72, 73, 75, 76, 78, 78, 80, 81, 82, 84, 84, 86, 87, 88, 89, 91, 92,
92, 94, 95, 97, 98, 99, 100, 101, 103, 105, 106, 106, 108, 108, 110, 111, 113,
114, 115, 116, 118, 119, 119, 118, 118, 118, 118, 117, 117, 116, 117, 116, 116,
116, 115, 115, 115, 114, 113, 114, 114, 114, 113, 112, 113, 113, 112, 111, 111,
111, 110, 109, 109, 110, 109, 110, 109, 109, 108, 106, 104, 103, 101, 99, 98,
96, 94, 93, 90, 89, 88, 85, 84, 81, 80, 79, 76, 74, 72, 71, 71, 68, 67, 65, 63,
61, 59, 58, 57, 54, 52, 51, 49, 47, 45, 43, 41, 39, 38, 35, 33, 31, 30, 28, 25,
24, 21, 20, 17, 15, 13, 11, 10, 7, 5, 3, 1, -1, -3, -5, -7, -9, -11, -13, -15,
-17, -19, -21, -23, -26, -27, -29, -31, -32, -33, -34, -36, -37, -38, -39, -40,
-41, -42, -43, -45, -46, -46, -48, -49, -49, -52, -53, -54, -55, -56, -57, -58,
-59, -60, -62, -62, -64, -65, -66, -67, -69, -70, -71, -72, -72, -72, -72, -72,
-72, -72, -73, -72, -73, -72, -72, -73, -72, -73, -73, -73, -73, -73, -73, -73,
-73, -73, -74, -74, -73, -73, -74, -74, -74, -74, -74, -74, -74, -74, -74, -75,
-73, -72, -73, -72, -71, -72, -71, -71, -71, -69, -69, -69, -69, -67, -68, -67,
-66, -66, -66, -66, -65, -65, -64, -63, -63, -62, -62, -61, -61, -61, -60, -60,
-60, -59, -59, -58, -58, -57, -57, -57, -57, -56, -55, -56, -55, -55, -54, -53,
-54, -52, -53, -53, -52, -52, -51, -51, -50, -50, -50, -49, -49, -50, -48, -48,
-47, -47, -48, -48, -46, -46, -45, -45, -45, -45, -45, -44, -45, -45, -44, -44,
-44, -45, -44, -43, -43, -43, -43, -43, -43, -43, -43, -42, -42, -42, -43, -43,
-42, -42, -42, -42, -41, -42, -41, -41, -42, -41, -41, -41, -41, -40, -40, -40,
-40, -41, -40, -40, -40, -40, -40, -39, -39, -39, -39, -39, -39, -39, -38, -38,
-39, -39, -38, -38, -37, -38, -38, -38, -37, -37, -37, -37, -36, -36, -37, -36,
-36, -36, -36, -35, -35, -34, -35, -34, -34, -34, -33, -33, -33, -33, -32, -32,
-32, -31, -31, -31, -31, -31, -31, -29, -29, -30, -28, -29, -29, -28, -28, -27,
-28, -27, -26, -26, -27, -27, -26, -25, -23, -23, -22, -22, -21, -20, -20, -19,
-18, -17, -15, -15, -15, -13, -13, -11, -11, -10, -9, -8, -8, -6, -6, -5, -4,
-4, -2, -2, -1, -1, };