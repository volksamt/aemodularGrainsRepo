#define DATA_LENGTH 512
#define DATA AKWF_linear_0064

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 6, 9, 11, 14, 18, 20, 23, 26,
30, 33, 36, 38, 42, 45, 49, 51, 55, 57, 61, 64, 67, 70, 72, 76, 80, 82, 86, 88,
88, 88, 89, 89, 88, 89, 89, 89, 89, 90, 89, 90, 89, 91, 91, 90, 91, 91, 91, 90,
91, 91, 92, 92, 91, 88, 83, 78, 73, 67, 62, 57, 52, 47, 41, 36, 31, 26, 21, 15,
9, 5, 0, -5, -10, -16, -21, -26, -32, -36, -42, -45, -47, -51, -54, -57, -60,
-63, -67, -69, -72, -76, -79, -82, -85, -88, -91, -94, -96, -100, -103, -107,
-109, -113, -116, -118, -119, -115, -113, -110, -107, -106, -102, -100, -98,
-96, -92, -90, -87, -85, -83, -80, -77, -74, -72, -69, -66, -64, -62, -59, -57,
-53, -50, -48, -44, -41, -38, -34, -31, -27, -23, -21, -17, -14, -11, -8, -4,
-1, 2, 5, 10, 12, 15, 19, 22, 25, 29, 32, 33, 34, 36, 37, 39, 41, 43, 44, 45,
47, 49, 50, 52, 53, 54, 56, 58, 60, 60, 62, 65, 65, 67, 68, 70, 70, 70, 69, 69,
68, 68, 67, 67, 67, 67, 66, 66, 66, 66, 65, 64, 64, 64, 64, 64, 63, 62, 63, 62,
62, 61, 59, 57, 54, 53, 51, 48, 47, 45, 42, 40, 37, 36, 34, 32, 30, 27, 25, 24,
21, 19, 16, 15, 13, 10, 8, 7, 5, 3, 2, 0, -2, -3, -5, -7, -9, -10, -11, -14,
-15, -16, -18, -20, -22, -24, -25, -27, -29, -31, -32, -34, -35, -36, -35, -35,
-35, -35, -35, -34, -35, -34, -33, -34, -34, -33, -34, -33, -34, -33, -33, -33,
-32, -32, -33, -32, -32, -33, -31, -30, -29, -27, -25, -24, -22, -22, -21, -19,
-18, -16, -15, -14, -13, -11, -11, -8, -8, -6, -5, -2, -1, 0, 1, 1, 2, 2, 2, 1,
0, 0, -1, -2, -2, -2, -4, -3, -4, -5, -6, -6, -6, -6, -8, -7, -9, -9, -10, -10,
-10, -12, -12, -13, -15, -15, -16, -16, -18, -19, -20, -21, -22, -23, -24, -25,
-26, -27, -28, -28, -30, -30, -31, -33, -34, -34, -35, -35, -33, -32, -31, -29,
-27, -26, -25, -24, -22, -21, -19, -18, -16, -15, -13, -12, -11, -10, -7, -6,
-4, -3, -2, 0, 1, 3, 6, 8, 11, 14, 16, 19, 21, 24, 26, 29, 31, 34, 36, 40, 41,
45, 46, 49, 52, 54, 56, 59, 61, 64, 65, 64, 62, 61, 59, 58, 56, 55, 53, 51, 51,
49, 47, 46, 45, 42, 42, 40, 39, 37, 36, 34, 33, 31, 30, 28, 25, 21, 18, 14, 10,
6, 3, -2, -5, -10, -13, -17, -21, -25, -28, -33, -36, -40, -44, -48, -51, -55,
-60, -63, -67, -69, -69, -69, -67, -67, -67, -67, -67, -65, -65, -64, -64, -63,
-63, -62, -62, -62, -61, -60, -60, -60, -59, -58, -58, -58, -56, -54, -52, -50,
-47, -44, -42, -40, -36, -35, -32, -30, -27, -24, -22, -20, -17, -15, -12, -10,
-7, -5, -2, };