#define DATA_LENGTH 512
#define DATA AKWF_linear_0061

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 3, 5, 6, 7, 8, 8, 10, 10, 11,
12, 13, 14, 15, 16, 17, 19, 19, 21, 21, 21, 23, 24, 25, 25, 27, 28, 29, 30, 31,
31, 33, 34, 35, 36, 37, 37, 38, 39, 41, 42, 43, 44, 45, 45, 47, 48, 49, 49, 51,
51, 52, 54, 55, 55, 56, 57, 58, 60, 60, 61, 62, 64, 64, 66, 66, 67, 69, 69, 70,
71, 72, 73, 74, 75, 75, 78, 78, 79, 80, 81, 82, 83, 84, 85, 86, 86, 88, 89, 89,
91, 91, 92, 94, 94, 95, 96, 98, 99, 100, 101, 101, 103, 103, 104, 105, 106, 107,
108, 109, 110, 111, 112, 113, 114, 115, 116, 118, 117, 119, 119, 118, 118, 117,
117, 115, 114, 114, 113, 112, 112, 111, 111, 108, 109, 108, 107, 107, 106, 105,
104, 103, 103, 102, 101, 100, 100, 98, 97, 97, 96, 96, 96, 95, 93, 93, 92, 91,
90, 89, 90, 88, 88, 87, 86, 85, 84, 84, 83, 83, 81, 81, 80, 80, 78, 78, 78, 76,
75, 75, 75, 73, 72, 72, 71, 70, 69, 69, 69, 67, 67, 66, 65, 65, 64, 64, 61, 62,
61, 60, 59, 59, 57, 57, 56, 56, 55, 54, 54, 52, 52, 50, 50, 50, 49, 48, 48, 47,
46, 45, 44, 44, 43, 41, 40, 38, 38, 35, 35, 33, 31, 30, 28, 27, 26, 24, 23, 22,
20, 19, 17, 16, 14, 13, 11, 10, 8, 8, 6, 5, 3, 1, 0, -1, -3, -5, -5, -7, -7,
-10, -11, -12, -13, -15, -17, -19, -20, -20, -23, -23, -25, -27, -28, -30, -31,
-32, -33, -35, -36, -37, -39, -41, -43, -43, -44, -47, -48, -49, -51, -51, -53,
-54, -56, -58, -59, -60, -62, -64, -64, -66, -67, -68, -70, -71, -73, -75, -75,
-77, -78, -80, -82, -82, -84, -85, -87, -88, -90, -91, -93, -94, -96, -97, -98,
-100, -100, -100, -101, -101, -100, -99, -101, -99, -100, -99, -99, -99, -99,
-98, -99, -98, -98, -98, -97, -98, -96, -97, -97, -97, -97, -96, -96, -96, -95,
-96, -95, -95, -95, -94, -94, -94, -94, -94, -93, -93, -93, -93, -93, -92, -92,
-92, -92, -91, -91, -91, -91, -91, -90, -90, -91, -90, -90, -89, -89, -90, -89,
-89, -89, -89, -88, -88, -87, -88, -88, -87, -87, -86, -86, -87, -87, -86, -86,
-86, -86, -85, -85, -85, -85, -84, -84, -84, -84, -84, -83, -83, -83, -82, -83,
-82, -82, -82, -81, -81, -81, -81, -81, -81, -81, -81, -80, -78, -77, -76, -75,
-75, -73, -72, -71, -70, -69, -68, -68, -67, -65, -64, -63, -63, -62, -61, -60,
-59, -57, -56, -56, -55, -54, -53, -52, -51, -50, -49, -48, -47, -46, -44, -44,
-43, -42, -42, -40, -39, -38, -37, -36, -35, -33, -32, -32, -31, -30, -30, -28,
-27, -26, -26, -24, -23, -23, -22, -21, -19, -18, -18, -16, -15, -14, -14, -13,
-12, -10, -10, -10, -8, -7, -5, -5, -4, -3, -2, -1, 0, };