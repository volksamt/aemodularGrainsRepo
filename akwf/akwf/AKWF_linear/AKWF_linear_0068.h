#define DATA_LENGTH 512
#define DATA AKWF_linear_0068

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 11, 16, 20, 24, 29, 32, 35, 39,
42, 46, 49, 53, 55, 59, 63, 65, 69, 73, 76, 80, 83, 87, 90, 94, 97, 100, 104,
107, 109, 113, 114, 115, 113, 114, 114, 114, 115, 115, 115, 113, 114, 114, 114,
114, 114, 115, 115, 114, 115, 114, 114, 114, 115, 114, 115, 114, 113, 110, 109,
107, 105, 103, 103, 101, 98, 97, 95, 94, 91, 89, 89, 86, 84, 83, 82, 80, 77, 76,
74, 72, 71, 69, 69, 68, 67, 66, 65, 63, 64, 62, 61, 60, 60, 58, 58, 57, 56, 55,
55, 54, 53, 52, 50, 50, 50, 48, 47, 47, 48, 50, 51, 51, 52, 53, 53, 55, 55, 56,
57, 58, 59, 58, 59, 61, 60, 61, 62, 64, 64, 65, 66, 66, 67, 68, 69, 70, 71, 72,
73, 74, 76, 76, 78, 79, 79, 80, 81, 83, 83, 85, 86, 86, 87, 89, 90, 90, 92, 92,
92, 91, 91, 91, 90, 89, 88, 88, 87, 87, 86, 85, 85, 84, 83, 82, 82, 81, 80, 80,
80, 79, 79, 77, 78, 76, 74, 72, 69, 68, 67, 64, 62, 60, 57, 55, 53, 51, 50, 48,
46, 43, 41, 39, 38, 35, 33, 31, 30, 28, 25, 23, 21, 19, 17, 15, 12, 10, 9, 7, 5,
3, 0, -2, -4, -6, -9, -10, -13, -14, -16, -18, -21, -22, -24, -27, -28, -27,
-26, -25, -23, -22, -21, -19, -19, -16, -15, -14, -13, -11, -9, -8, -7, -6, -4,
-3, -1, -1, 0, 3, 3, 5, 6, 6, 6, 7, 7, 8, 8, 8, 9, 10, 11, 10, 11, 11, 12, 12,
13, 13, 13, 15, 15, 16, 16, 16, 17, 17, 15, 12, 10, 7, 4, 2, -1, -2, -5, -7,
-10, -13, -15, -18, -19, -22, -25, -28, -31, -33, -35, -38, -40, -43, -45, -48,
-49, -50, -52, -53, -55, -57, -59, -61, -62, -63, -65, -66, -68, -70, -71, -73,
-75, -76, -77, -79, -80, -83, -84, -86, -88, -88, -88, -88, -88, -88, -88, -90,
-89, -89, -90, -90, -90, -90, -89, -91, -90, -91, -91, -91, -91, -91, -91, -91,
-91, -92, -92, -90, -89, -87, -87, -85, -84, -83, -81, -79, -78, -77, -76, -76,
-73, -72, -71, -70, -69, -67, -66, -64, -63, -61, -60, -60, -59, -58, -57, -58,
-58, -57, -57, -56, -56, -56, -56, -56, -55, -55, -55, -54, -53, -54, -54, -53,
-53, -52, -52, -52, -52, -52, -52, -54, -55, -56, -57, -59, -59, -61, -61, -62,
-65, -65, -66, -67, -69, -70, -71, -72, -73, -74, -75, -76, -79, -79, -80, -81,
-83, -85, -86, -88, -89, -91, -93, -94, -95, -97, -98, -99, -102, -103, -104,
-106, -107, -108, -110, -111, -113, -115, -117, -117, -119, -118, -118, -117,
-116, -113, -113, -113, -111, -110, -108, -108, -107, -105, -104, -104, -102,
-101, -100, -98, -98, -97, -96, -95, -94, -93, -91, -86, -81, -76, -72, -67,
-62, -58, -54, -49, -44, -39, -34, -29, -26, -21, -16, -11, -7, -2, };