#define DATA_LENGTH 512
#define DATA AKWF_linear_0033

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 7, 9, 12, 14, 18, 19, 22, 26,
28, 31, 34, 36, 37, 40, 41, 44, 46, 48, 50, 52, 54, 56, 58, 61, 62, 64, 66, 68,
71, 71, 74, 77, 78, 80, 83, 84, 86, 89, 90, 92, 94, 97, 99, 101, 103, 105, 106,
107, 107, 107, 106, 106, 107, 107, 107, 108, 106, 107, 107, 107, 107, 107, 107,
108, 106, 108, 107, 107, 107, 107, 107, 108, 107, 107, 107, 108, 107, 107, 107,
107, 106, 107, 106, 107, 107, 107, 108, 107, 106, 106, 105, 106, 105, 106, 106,
106, 106, 105, 106, 105, 105, 105, 106, 105, 104, 105, 104, 104, 105, 104, 104,
104, 104, 103, 103, 103, 104, 103, 103, 104, 104, 103, 104, 105, 104, 105, 105,
106, 105, 106, 106, 106, 106, 107, 108, 108, 107, 108, 109, 109, 109, 109, 109,
110, 111, 111, 110, 111, 111, 111, 112, 112, 112, 113, 113, 114, 112, 110, 107,
104, 103, 99, 97, 95, 91, 89, 86, 84, 81, 78, 76, 73, 70, 68, 65, 63, 60, 57,
54, 53, 50, 47, 44, 42, 39, 37, 35, 32, 29, 27, 23, 22, 18, 15, 11, 7, 4, -1,
-4, -8, -11, -15, -18, -23, -26, -30, -34, -37, -41, -44, -49, -53, -57, -60,
-63, -67, -71, -76, -79, -83, -87, -90, -95, -98, -101, -105, -109, -113, -117,
-120, -118, -116, -115, -114, -112, -110, -110, -108, -107, -104, -104, -103,
-101, -100, -98, -96, -95, -93, -92, -90, -89, -88, -86, -85, -84, -82, -81,
-79, -77, -77, -75, -74, -72, -71, -69, -68, -67, -64, -62, -60, -58, -56, -54,
-53, -50, -48, -46, -44, -43, -41, -39, -37, -34, -33, -31, -28, -26, -25, -22,
-21, -18, -17, -14, -13, -11, -10, -7, -5, -4, -1, 1, 3, 3, 1, -1, -4, -7, -10,
-12, -15, -17, -19, -22, -25, -27, -30, -32, -35, -38, -40, -43, -46, -48, -51,
-54, -55, -58, -62, -64, -67, -70, -72, -75, -78, -80, -82, -85, -88, -90, -91,
-90, -89, -87, -87, -85, -85, -83, -82, -81, -80, -79, -77, -77, -75, -74, -73,
-73, -72, -70, -69, -68, -67, -65, -65, -64, -62, -61, -61, -59, -59, -57, -56,
-55, -54, -53, -51, -50, -48, -46, -44, -43, -42, -39, -37, -35, -35, -32, -30,
-29, -27, -26, -23, -22, -20, -18, -17, -15, -13, -11, -10, -7, -5, -4, -2, 0,
1, 3, 5, 6, 8, 10, 12, 11, 9, 5, 3, -1, -4, -7, -11, -13, -15, -19, -22, -25,
-28, -30, -34, -36, -40, -43, -46, -49, -53, -56, -58, -61, -65, -67, -70, -74,
-76, -79, -83, -86, -88, -91, -94, -97, -98, -97, -95, -95, -95, -94, -93, -92,
-91, -91, -90, -89, -88, -86, -86, -86, -85, -84, -83, -82, -82, -81, -80, -79,
-79, -78, -78, -76, -75, -75, -74, -73, -72, -71, -71, -70, -68, -66, -64, -61,
-57, -55, -52, -49, -47, -44, -40, -38, -35, -32, -30, -27, -24, -21, -18, -15,
-13, -11, -8, -4, -1, };