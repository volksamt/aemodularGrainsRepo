#define DATA_LENGTH 512
#define DATA AKWF_linear_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 3, 4, 4, 6, 6, 7, 7, 9, 10,
10, 11, 12, 13, 13, 15, 18, 20, 23, 25, 29, 31, 35, 37, 40, 42, 45, 47, 51, 53,
56, 58, 61, 63, 67, 70, 72, 75, 78, 80, 83, 85, 89, 91, 94, 96, 99, 102, 105,
108, 110, 113, 114, 114, 113, 114, 114, 115, 115, 115, 115, 115, 115, 115, 115,
115, 115, 116, 116, 117, 117, 116, 117, 117, 117, 117, 118, 116, 118, 118, 118,
118, 118, 118, 119, 119, 119, 119, 117, 114, 111, 106, 104, 98, 95, 91, 87, 83,
79, 75, 72, 68, 65, 60, 56, 53, 49, 45, 41, 38, 33, 30, 26, 21, 18, 14, 9, 6, 3,
-2, -6, -10, -13, -17, -21, -22, -23, -23, -25, -24, -25, -26, -26, -27, -27,
-28, -28, -30, -30, -29, -31, -31, -32, -32, -32, -34, -33, -34, -34, -35, -35,
-36, -37, -37, -38, -38, -39, -39, -40, -41, -42, -41, -42, -42, -41, -42, -42,
-41, -41, -41, -42, -41, -41, -42, -41, -41, -41, -41, -42, -41, -41, -41, -40,
-42, -41, -41, -41, -42, -41, -41, -40, -40, -41, -41, -40, -41, -41, -40, -40,
-39, -39, -37, -36, -35, -33, -33, -32, -30, -30, -29, -28, -27, -25, -25, -23,
-22, -21, -20, -19, -18, -17, -15, -15, -14, -13, -12, -11, -10, -9, -9, -6, -6,
-5, -4, -3, -1, 2, 4, 6, 8, 10, 13, 15, 18, 20, 22, 24, 26, 29, 30, 33, 34, 37,
40, 42, 43, 46, 48, 50, 53, 55, 58, 59, 61, 64, 66, 69, 70, 72, 76, 77, 78, 75,
74, 72, 70, 67, 65, 64, 62, 60, 58, 56, 53, 52, 50, 48, 46, 44, 42, 40, 38, 36,
34, 32, 31, 28, 25, 24, 23, 21, 18, 16, 14, 12, 10, 9, 6, 6, 5, 4, 3, 4, 4, 2,
2, 1, 0, 0, 0, -1, -2, -2, -4, -4, -4, -6, -6, -6, -7, -8, -7, -9, -9, -9, -10,
-11, -11, -12, -13, -13, -14, -15, -15, -16, -17, -16, -16, -16, -17, -17, -17,
-17, -18, -17, -18, -18, -18, -18, -18, -19, -19, -18, -19, -18, -20, -20, -20,
-20, -20, -21, -20, -20, -21, -21, -21, -21, -22, -22, -23, -22, -22, -23, -24,
-26, -26, -27, -28, -29, -30, -30, -31, -32, -34, -33, -34, -36, -37, -39, -39,
-39, -40, -42, -42, -43, -44, -45, -45, -47, -48, -48, -49, -50, -50, -52, -53,
-53, -54, -53, -53, -52, -52, -51, -50, -49, -49, -48, -48, -47, -46, -46, -46,
-45, -44, -44, -43, -42, -41, -42, -40, -39, -40, -39, -38, -38, -36, -37, -36,
-36, -34, -33, -34, -33, -32, -32, -31, -31, -31, -30, -29, -29, -28, -29, -27,
-27, -27, -26, -26, -25, -25, -25, -24, -24, -24, -22, -22, -22, -21, -21, -20,
-19, -19, -18, -19, -18, -18, -17, -16, -16, -16, -15, -15, -14, -12, -12, -12,
-10, -10, -9, -8, -8, -6, -5, -5, -3, -3, -2, -1, -1, 0, };