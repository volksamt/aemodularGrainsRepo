#define DATA_LENGTH 512
#define DATA AKWF_linear_0037

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 2, 3, 3, 4, 4, 5, 5, 6, 7, 8,
9, 9, 10, 10, 11, 11, 12, 12, 13, 13, 13, 13, 14, 14, 14, 15, 14, 14, 14, 15,
15, 15, 15, 15, 16, 16, 15, 16, 16, 16, 17, 16, 16, 16, 16, 18, 17, 17, 18, 18,
18, 19, 18, 19, 19, 21, 22, 24, 26, 28, 29, 31, 32, 34, 37, 38, 40, 41, 42, 44,
46, 48, 48, 51, 52, 54, 55, 57, 58, 61, 62, 64, 65, 68, 69, 70, 72, 74, 76, 78,
79, 80, 80, 81, 81, 81, 82, 82, 82, 83, 83, 84, 84, 85, 85, 85, 86, 87, 87, 86,
87, 88, 88, 88, 89, 90, 90, 90, 90, 91, 92, 92, 92, 93, 93, 93, 93, 93, 91, 88,
85, 82, 79, 76, 73, 70, 66, 62, 59, 56, 54, 49, 47, 44, 40, 37, 34, 31, 28, 24,
21, 18, 15, 12, 9, 5, 2, -1, -4, -8, -11, -14, -17, -20, -22, -23, -24, -25,
-27, -29, -30, -32, -33, -34, -36, -36, -37, -39, -41, -42, -42, -44, -45, -47,
-48, -48, -51, -51, -53, -54, -55, -57, -58, -59, -60, -61, -63, -64, -66, -67,
-68, -68, -67, -67, -66, -66, -66, -65, -64, -65, -63, -63, -64, -63, -62, -61,
-61, -60, -61, -61, -60, -60, -58, -58, -58, -57, -57, -56, -55, -56, -55, -54,
-54, -53, -53, -52, -52, -52, -51, -49, -49, -46, -46, -45, -43, -42, -41, -40,
-39, -37, -36, -35, -33, -33, -31, -31, -29, -28, -27, -26, -25, -23, -22, -21,
-20, -19, -18, -16, -15, -14, -13, -12, -10, -9, -8, -5, -2, 0, 2, 5, 7, 10, 12,
15, 17, 19, 22, 25, 27, 29, 32, 34, 36, 40, 41, 44, 46, 48, 50, 53, 56, 58, 62,
63, 66, 67, 70, 73, 75, 78, 79, 80, 81, 81, 82, 82, 82, 83, 83, 83, 84, 85, 84,
85, 86, 86, 87, 88, 88, 89, 89, 90, 90, 91, 90, 92, 91, 92, 93, 93, 93, 93, 94,
94, 94, 95, 96, 94, 92, 88, 86, 83, 80, 79, 76, 73, 70, 67, 66, 63, 60, 57, 54,
52, 49, 47, 44, 41, 38, 36, 33, 30, 27, 25, 22, 19, 18, 14, 12, 9, 6, 4, 0, -2,
-5, -9, -11, -15, -17, -21, -24, -27, -31, -33, -37, -40, -44, -47, -50, -53,
-56, -60, -64, -66, -69, -73, -75, -79, -82, -86, -89, -92, -95, -99, -102,
-105, -109, -111, -114, -117, -119, -118, -119, -117, -117, -117, -116, -115,
-115, -114, -113, -114, -113, -113, -111, -112, -111, -110, -109, -109, -109,
-107, -107, -107, -106, -105, -105, -105, -105, -104, -104, -103, -102, -101,
-101, -101, -100, -97, -95, -93, -91, -87, -85, -82, -80, -78, -76, -73, -70,
-68, -66, -64, -61, -58, -55, -54, -50, -48, -46, -43, -41, -38, -35, -33, -31,
-28, -26, -23, -21, -18, -16, -13, -10, -9, -9, -8, -7, -7, -6, -5, -5, -4, -4,
-3, -3, -2, -1, -1, 0, };