#define DATA_LENGTH 512
#define DATA AKWF_linear_0063

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 6, 8, 9, 12, 13, 15, 17, 19, 20,
23, 25, 27, 29, 31, 33, 35, 38, 39, 41, 43, 45, 47, 49, 51, 53, 54, 57, 58, 61,
64, 66, 67, 69, 72, 74, 76, 77, 79, 81, 83, 85, 86, 89, 91, 94, 95, 98, 100,
101, 103, 105, 107, 109, 112, 113, 115, 118, 119, 118, 117, 117, 116, 115, 114,
113, 111, 111, 109, 108, 107, 106, 105, 104, 102, 102, 101, 100, 98, 98, 97, 95,
95, 94, 92, 92, 90, 89, 89, 88, 86, 86, 84, 83, 81, 81, 80, 79, 78, 77, 76, 75,
74, 73, 72, 70, 69, 68, 68, 67, 65, 65, 64, 62, 62, 61, 59, 57, 57, 57, 55, 54,
53, 52, 50, 49, 49, 48, 47, 46, 45, 44, 43, 41, 40, 40, 38, 38, 36, 35, 34, 33,
33, 31, 30, 29, 29, 26, 26, 25, 24, 23, 22, 21, 20, 18, 18, 17, 16, 15, 14, 13,
13, 12, 11, 10, 10, 9, 9, 8, 8, 7, 7, 7, 7, 5, 5, 5, 4, 3, 3, 3, 3, 2, 1, 0, 1,
-1, -1, -2, -1, -3, -3, -3, -4, -4, -4, -5, -6, -6, -6, -7, -8, -9, -9, -9, -10,
-11, -11, -11, -12, -12, -13, -14, -14, -14, -15, -15, -16, -17, -17, -17, -18,
-19, -19, -20, -20, -21, -21, -22, -22, -23, -24, -24, -24, -25, -25, -26, -27,
-27, -27, -27, -28, -29, -29, -30, -30, -30, -30, -32, -32, -32, -33, -33, -34,
-34, -35, -36, -36, -36, -37, -38, -38, -39, -39, -38, -37, -37, -36, -37, -37,
-35, -36, -35, -35, -35, -35, -34, -34, -33, -33, -32, -33, -33, -33, -32, -32,
-31, -31, -30, -31, -30, -29, -30, -29, -29, -28, -29, -27, -28, -28, -27, -27,
-26, -26, -26, -25, -26, -25, -25, -25, -24, -23, -23, -23, -22, -22, -22, -23,
-21, -21, -21, -20, -21, -20, -20, -20, -19, -19, -19, -18, -18, -17, -18, -17,
-16, -16, -17, -16, -15, -15, -15, -15, -15, -15, -14, -13, -13, -12, -13, -12,
-12, -12, -11, -11, -11, -11, -9, -10, -10, -9, -9, -9, -8, -8, -8, -7, -9, -10,
-11, -11, -12, -13, -13, -14, -15, -17, -17, -17, -18, -19, -20, -20, -21, -22,
-22, -24, -24, -26, -27, -27, -27, -27, -29, -30, -31, -31, -32, -33, -34, -34,
-35, -36, -37, -37, -39, -38, -40, -40, -41, -42, -43, -44, -45, -45, -47, -47,
-47, -48, -49, -50, -50, -52, -52, -52, -53, -55, -55, -56, -57, -58, -58, -59,
-60, -60, -62, -62, -62, -63, -63, -65, -66, -67, -67, -69, -69, -70, -71, -71,
-72, -73, -73, -75, -76, -76, -77, -77, -79, -79, -79, -80, -81, -81, -83, -83,
-84, -85, -86, -86, -83, -81, -79, -78, -75, -73, -71, -69, -67, -66, -63, -62,
-59, -57, -55, -54, -51, -49, -47, -45, -43, -40, -39, -37, -36, -32, -30, -28,
-27, -24, -22, -21, -18, -17, -14, -13, -11, -8, -7, -5, -3, -1, };