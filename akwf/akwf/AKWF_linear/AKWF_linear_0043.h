#define DATA_LENGTH 512
#define DATA AKWF_linear_0043

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 10, 15, 17, 21, 24, 27, 31,
33, 37, 40, 43, 46, 50, 53, 56, 59, 63, 66, 69, 72, 76, 78, 83, 86, 88, 91, 90,
90, 88, 87, 86, 85, 84, 84, 82, 82, 80, 80, 78, 77, 76, 75, 74, 73, 72, 71, 71,
69, 69, 67, 66, 66, 64, 63, 63, 61, 60, 59, 59, 57, 56, 55, 55, 55, 53, 52, 51,
50, 49, 49, 48, 47, 45, 45, 44, 43, 43, 41, 41, 40, 39, 38, 36, 36, 35, 35, 34,
33, 31, 31, 30, 29, 28, 28, 26, 25, 25, 24, 23, 24, 25, 26, 25, 27, 28, 29, 29,
30, 31, 32, 33, 34, 34, 34, 36, 36, 37, 39, 39, 40, 41, 42, 42, 43, 43, 44, 45,
47, 47, 48, 49, 49, 51, 51, 52, 52, 49, 46, 44, 41, 40, 37, 34, 32, 29, 27, 25,
22, 19, 17, 15, 13, 9, 8, 5, 3, 1, -2, -4, -8, -9, -12, -14, -16, -19, -22, -24,
-27, -29, -31, -33, -36, -38, -39, -41, -43, -44, -47, -48, -49, -51, -53, -54,
-56, -58, -59, -61, -62, -64, -66, -67, -69, -71, -73, -74, -76, -77, -79, -81,
-82, -85, -86, -88, -89, -91, -92, -95, -96, -96, -95, -91, -90, -88, -85, -83,
-81, -78, -77, -74, -72, -69, -67, -64, -62, -60, -58, -56, -53, -50, -48, -46,
-43, -42, -39, -37, -35, -32, -31, -28, -25, -23, -20, -18, -16, -14, -12, -12,
-10, -9, -9, -7, -6, -5, -4, -3, -2, -2, 0, 1, 3, 3, 3, 5, 6, 7, 9, 9, 10, 11,
12, 13, 15, 16, 17, 17, 18, 19, 20, 22, 23, 24, 25, 25, 25, 25, 25, 25, 26, 26,
26, 26, 26, 26, 27, 26, 27, 27, 27, 27, 27, 28, 27, 28, 28, 28, 28, 29, 29, 28,
29, 29, 29, 30, 29, 29, 30, 29, 30, 30, 32, 33, 33, 35, 36, 38, 39, 40, 41, 42,
43, 45, 46, 47, 49, 49, 50, 51, 52, 53, 55, 56, 58, 58, 59, 60, 61, 62, 63, 65,
67, 67, 69, 69, 70, 71, 70, 70, 67, 66, 65, 64, 63, 62, 60, 58, 58, 56, 55, 54,
52, 52, 50, 48, 48, 46, 45, 43, 42, 41, 40, 39, 37, 37, 35, 33, 32, 31, 30, 28,
27, 25, 24, 22, 19, 15, 12, 9, 6, 4, 1, -2, -5, -8, -11, -14, -16, -20, -23,
-26, -28, -32, -34, -37, -40, -43, -46, -48, -51, -54, -58, -60, -63, -66, -69,
-72, -74, -77, -80, -81, -82, -83, -84, -85, -87, -88, -88, -90, -91, -92, -94,
-94, -96, -97, -98, -98, -99, -100, -102, -102, -104, -104, -106, -107, -107,
-109, -110, -111, -113, -113, -115, -116, -117, -117, -120, -118, -116, -113,
-110, -108, -105, -104, -101, -98, -95, -94, -90, -88, -86, -83, -81, -78, -75,
-72, -70, -68, -65, -63, -60, -57, -56, -52, -50, -47, -45, -42, -40, -37, -35,
-33, -30, -28, -24, -21, -18, -15, -12, -7, -4, -2, };