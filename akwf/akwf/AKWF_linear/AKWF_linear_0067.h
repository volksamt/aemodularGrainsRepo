#define DATA_LENGTH 512
#define DATA AKWF_linear_0067

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 5, 6, 7, 9, 9, 11, 12, 14,
15, 17, 17, 19, 21, 21, 22, 25, 26, 27, 28, 29, 31, 32, 33, 35, 37, 38, 39, 40,
42, 44, 46, 46, 51, 52, 56, 59, 62, 65, 67, 71, 73, 77, 78, 82, 85, 88, 91, 94,
96, 99, 103, 106, 108, 111, 114, 117, 119, 118, 116, 114, 113, 110, 109, 107,
105, 102, 101, 100, 97, 95, 93, 91, 91, 88, 86, 84, 82, 80, 78, 77, 74, 73, 71,
70, 68, 68, 66, 65, 63, 63, 61, 60, 59, 58, 56, 55, 54, 53, 51, 50, 49, 48, 46,
45, 44, 43, 42, 41, 39, 36, 36, 34, 31, 29, 29, 26, 24, 23, 20, 19, 18, 16, 13,
13, 11, 9, 7, 6, 3, 1, -1, -2, -4, -5, -6, -6, -6, -8, -8, -8, -9, -9, -9, -10,
-10, -11, -11, -11, -11, -12, -12, -13, -14, -13, -14, -15, -15, -15, -15, -16,
-16, -16, -16, -17, -17, -17, -18, -18, -18, -19, -18, -19, -19, -19, -20, -21,
-20, -20, -21, -22, -22, -22, -21, -23, -23, -23, -23, -23, -23, -23, -24, -24,
-25, -24, -24, -24, -24, -25, -25, -25, -25, -25, -26, -26, -26, -26, -26, -26,
-26, -28, -27, -27, -26, -25, -26, -25, -24, -24, -23, -23, -23, -23, -22, -21,
-22, -21, -20, -20, -20, -19, -19, -19, -17, -17, -16, -17, -17, -17, -17, -17,
-16, -16, -16, -17, -17, -16, -16, -16, -16, -17, -16, -16, -16, -16, -16, -16,
-15, -16, -16, -16, -16, -16, -14, -15, -15, -14, -15, -14, -14, -14, -15, -13,
-13, -13, -13, -13, -13, -13, -13, -12, -12, -12, -12, -12, -11, -12, -11, -11,
-10, -8, -8, -7, -7, -6, -5, -5, -4, -4, -3, -2, -1, 0, 0, 0, 1, 3, 3, 4, 5, 6,
6, 7, 8, 9, 9, 11, 12, 13, 15, 15, 17, 17, 18, 19, 21, 22, 23, 24, 25, 26, 28,
28, 29, 30, 31, 32, 33, 35, 35, 35, 37, 36, 37, 38, 39, 40, 39, 40, 40, 41, 42,
41, 42, 43, 43, 43, 45, 45, 45, 45, 46, 47, 46, 47, 44, 43, 39, 36, 34, 30, 27,
26, 22, 20, 17, 13, 11, 8, 6, 3, 0, -3, -6, -9, -11, -14, -17, -19, -23, -26,
-27, -30, -32, -35, -37, -39, -41, -43, -46, -48, -50, -53, -54, -56, -59, -62,
-64, -66, -68, -70, -73, -75, -77, -80, -82, -82, -83, -81, -82, -81, -81, -82,
-81, -81, -80, -80, -80, -80, -79, -79, -79, -79, -79, -78, -78, -78, -77, -78,
-78, -77, -77, -76, -76, -74, -74, -73, -72, -72, -71, -70, -69, -69, -67, -68,
-67, -65, -66, -65, -64, -63, -62, -61, -61, -60, -59, -59, -58, -56, -55, -54,
-52, -50, -50, -47, -46, -44, -43, -41, -41, -39, -37, -35, -34, -33, -31, -31,
-28, -27, -25, -24, -23, -22, -19, -19, -18, -17, -15, -14, -12, -11, -10, -8,
-7, -7, -4, -4, -3, -1, -1, };