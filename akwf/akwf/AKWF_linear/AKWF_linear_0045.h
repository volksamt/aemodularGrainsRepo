#define DATA_LENGTH 512
#define DATA AKWF_linear_0045

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 6, 9, 11, 13, 16, 17, 20, 21,
23, 25, 28, 30, 32, 34, 36, 38, 40, 42, 44, 47, 48, 50, 53, 54, 56, 59, 61, 62,
65, 67, 69, 72, 74, 76, 78, 79, 81, 83, 85, 88, 90, 91, 91, 92, 93, 93, 94, 95,
97, 96, 97, 98, 100, 100, 101, 102, 103, 103, 103, 105, 106, 106, 107, 108, 108,
110, 111, 111, 112, 112, 114, 114, 114, 115, 117, 117, 118, 118, 116, 114, 111,
110, 106, 104, 102, 100, 98, 95, 93, 91, 88, 87, 84, 81, 79, 77, 75, 73, 70, 67,
65, 63, 62, 59, 56, 54, 52, 50, 47, 45, 42, 40, 38, 36, 33, 29, 26, 22, 19, 15,
11, 8, 4, 0, -4, -7, -10, -15, -18, -21, -25, -28, -31, -35, -38, -43, -46, -50,
-53, -57, -60, -65, -68, -72, -75, -78, -81, -86, -89, -93, -96, -96, -96, -98,
-99, -99, -99, -100, -100, -101, -101, -103, -103, -103, -104, -104, -105, -105,
-106, -106, -107, -108, -108, -109, -110, -111, -110, -111, -111, -112, -112,
-113, -113, -114, -115, -115, -115, -115, -113, -112, -110, -107, -105, -104,
-102, -100, -97, -96, -94, -92, -91, -88, -87, -84, -83, -81, -78, -76, -75,
-72, -70, -69, -67, -65, -64, -62, -60, -58, -55, -53, -52, -49, -48, -45, -44,
-43, -41, -39, -37, -36, -35, -33, -32, -30, -29, -27, -25, -23, -22, -21, -19,
-17, -16, -14, -13, -10, -9, -8, -6, -4, -3, -1, 0, 2, 4, 5, 7, 9, 10, 12, 13,
16, 17, 18, 21, 21, 24, 24, 26, 29, 30, 33, 33, 35, 37, 38, 40, 41, 43, 45, 47,
49, 50, 52, 54, 56, 56, 58, 61, 62, 64, 65, 68, 69, 70, 72, 74, 75, 76, 78, 79,
80, 81, 83, 84, 85, 86, 87, 88, 90, 91, 92, 94, 95, 96, 97, 98, 99, 100, 102,
104, 104, 105, 106, 107, 109, 110, 112, 112, 114, 116, 116, 119, 118, 116, 115,
113, 111, 110, 108, 106, 105, 103, 102, 100, 98, 97, 96, 94, 92, 91, 88, 87, 85,
84, 82, 81, 79, 77, 76, 74, 72, 70, 70, 67, 66, 64, 62, 60, 59, 56, 52, 49, 45,
41, 38, 34, 31, 26, 23, 18, 16, 11, 8, 4, 1, -3, -7, -11, -14, -18, -22, -26,
-30, -32, -36, -41, -44, -48, -52, -55, -58, -64, -67, -70, -75, -78, -78, -80,
-82, -82, -83, -84, -86, -87, -87, -89, -90, -91, -92, -93, -95, -96, -96, -97,
-99, -100, -101, -103, -103, -105, -106, -107, -108, -110, -111, -111, -113,
-114, -115, -116, -117, -119, -119, -116, -116, -114, -112, -111, -110, -109,
-108, -106, -105, -104, -101, -100, -99, -98, -97, -96, -93, -93, -90, -89, -88,
-86, -85, -83, -83, -81, -79, -79, -77, -75, -74, -72, -71, -69, -68, -66, -64,
-62, -59, -57, -55, -52, -50, -48, -46, -43, -42, -39, -36, -34, -32, -29, -27,
-25, -22, -21, -18, -16, -13, -12, -10, -7, -4, -3, 0, };