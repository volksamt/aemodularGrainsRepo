#define DATA_LENGTH 512
#define DATA AKWF_linear_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 13, 17, 21, 25, 29, 33, 37,
40, 44, 49, 53, 57, 61, 64, 68, 72, 76, 79, 84, 88, 92, 96, 100, 104, 108, 112,
116, 118, 117, 115, 113, 110, 109, 106, 103, 101, 99, 96, 95, 92, 89, 87, 84,
83, 81, 78, 75, 73, 70, 69, 66, 64, 61, 59, 57, 55, 52, 50, 47, 45, 42, 40, 38,
35, 34, 32, 30, 27, 25, 22, 21, 18, 15, 14, 12, 10, 7, 5, 4, 0, -2, -4, -5, -8,
-10, -13, -14, -17, -19, -20, -23, -25, -28, -30, -32, -34, -36, -39, -41, -43,
-45, -44, -43, -43, -41, -41, -38, -38, -37, -36, -34, -33, -33, -31, -30, -29,
-28, -28, -25, -25, -24, -22, -22, -20, -19, -19, -17, -16, -15, -14, -13, -12,
-10, -10, -8, -7, -6, -6, -7, -7, -7, -9, -9, -10, -10, -11, -12, -12, -13, -13,
-14, -15, -16, -16, -17, -17, -19, -19, -19, -20, -20, -21, -22, -22, -23, -24,
-25, -26, -27, -26, -27, -29, -29, -29, -29, -29, -28, -28, -28, -27, -27, -27,
-26, -25, -26, -24, -24, -24, -23, -23, -22, -21, -22, -22, -21, -20, -19, -19,
-18, -18, -19, -18, -17, -17, -17, -16, -15, -15, -14, -14, -13, -13, -14, -15,
-14, -15, -15, -15, -16, -17, -17, -16, -17, -17, -17, -17, -18, -18, -18, -19,
-18, -19, -20, -19, -19, -20, -20, -20, -20, -21, -21, -22, -22, -21, -22, -23,
-22, -21, -19, -16, -14, -11, -9, -7, -4, -1, 1, 3, 6, 8, 11, 12, 15, 17, 20,
23, 25, 28, 30, 32, 35, 37, 40, 43, 44, 47, 49, 51, 54, 57, 59, 62, 64, 66, 65,
64, 62, 61, 59, 58, 56, 55, 54, 53, 52, 50, 50, 48, 47, 45, 44, 43, 42, 40, 38,
37, 36, 35, 33, 31, 30, 29, 27, 27, 25, 24, 22, 22, 19, 18, 18, 16, 14, 13, 11,
8, 6, 5, 3, 2, 0, -2, -3, -5, -7, -8, -10, -12, -13, -15, -17, -19, -20, -22,
-24, -25, -27, -29, -31, -31, -33, -35, -37, -39, -41, -43, -43, -43, -43, -41,
-41, -39, -39, -38, -37, -36, -36, -34, -33, -33, -31, -30, -30, -29, -28, -28,
-26, -25, -24, -23, -23, -21, -21, -20, -18, -18, -17, -16, -15, -14, -14, -13,
-11, -11, -12, -12, -12, -12, -12, -13, -14, -14, -13, -14, -14, -15, -15, -15,
-16, -17, -16, -17, -17, -17, -18, -17, -19, -18, -18, -18, -19, -19, -19, -20,
-20, -21, -21, -21, -22, -21, -22, -22, -22, -22, -22, -22, -21, -21, -22, -21,
-21, -21, -21, -20, -21, -20, -21, -20, -21, -21, -21, -21, -21, -20, -20, -21,
-21, -21, -21, -20, -20, -20, -19, -20, -21, -20, -20, -20, -20, -21, -21, -21,
-21, -21, -21, -21, -20, -21, -22, -21, -22, -22, -22, -22, -22, -23, -23, -22,
-23, -23, -23, -23, -23, -23, -23, -24, -24, -25, -25, -24, -24, -25, -25, -22,
-19, -14, -10, -6, -3, };