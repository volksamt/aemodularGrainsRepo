#define DATA_LENGTH 512
#define DATA AKWF_linear_0055

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 11, 15, 18, 23, 26, 29, 30, 32,
35, 37, 38, 40, 43, 45, 45, 48, 50, 52, 55, 56, 57, 60, 61, 63, 66, 68, 70, 72,
74, 75, 77, 79, 81, 82, 85, 86, 88, 91, 93, 94, 97, 98, 97, 97, 98, 98, 97, 98,
98, 98, 98, 99, 98, 98, 98, 99, 99, 99, 99, 98, 99, 99, 100, 100, 100, 99, 100,
100, 100, 100, 100, 100, 100, 101, 100, 101, 101, 101, 100, 99, 98, 98, 97, 96,
95, 94, 93, 92, 91, 91, 90, 90, 88, 88, 86, 86, 86, 84, 83, 83, 82, 81, 80, 80,
78, 78, 77, 76, 76, 74, 74, 73, 72, 71, 68, 64, 59, 53, 47, 43, 37, 32, 27, 22,
16, 11, 5, 0, -5, -10, -15, -21, -25, -31, -36, -41, -46, -52, -57, -62, -67,
-73, -78, -83, -88, -93, -99, -103, -109, -114, -118, -118, -117, -117, -116,
-114, -113, -112, -110, -110, -108, -108, -106, -106, -104, -103, -102, -101,
-99, -99, -97, -96, -95, -93, -94, -92, -91, -90, -88, -87, -86, -85, -83, -83,
-82, -81, -80, -77, -72, -68, -63, -58, -53, -48, -43, -39, -35, -29, -25, -20,
-15, -10, -5, -1, 4, 9, 13, 18, 23, 28, 33, 37, 42, 47, 52, 57, 61, 66, 71, 75,
80, 85, 89, 95, 93, 90, 88, 85, 83, 79, 76, 74, 72, 68, 66, 62, 60, 58, 55, 52,
49, 46, 43, 42, 38, 35, 33, 30, 27, 25, 21, 19, 17, 13, 10, 8, 5, 2, 0, -3, -6,
-7, -9, -10, -12, -13, -15, -17, -18, -19, -21, -22, -24, -25, -27, -29, -30,
-32, -33, -35, -36, -38, -39, -40, -42, -43, -45, -46, -47, -49, -51, -52, -55,
-56, -57, -58, -60, -57, -52, -50, -45, -41, -37, -33, -29, -24, -20, -16, -11,
-7, -3, 1, 5, 9, 14, 17, 22, 26, 30, 35, 39, 43, 46, 51, 55, 60, 64, 67, 72, 76,
81, 85, 89, 91, 88, 84, 80, 77, 73, 69, 66, 62, 58, 54, 50, 47, 42, 39, 35, 31,
28, 24, 20, 17, 13, 8, 5, 1, -3, -6, -10, -13, -17, -21, -25, -29, -33, -37,
-39, -44, -46, -47, -47, -47, -48, -49, -50, -50, -50, -51, -51, -52, -52, -53,
-54, -53, -55, -55, -56, -56, -57, -58, -58, -59, -58, -60, -59, -61, -61, -61,
-63, -62, -63, -64, -64, -64, -65, -63, -61, -59, -56, -55, -53, -51, -49, -47,
-44, -43, -40, -39, -36, -34, -31, -30, -28, -26, -24, -22, -20, -17, -15, -13,
-11, -10, -7, -6, -3, -1, 1, 2, 5, 7, 10, 9, 5, 2, -1, -5, -9, -12, -17, -19,
-23, -27, -30, -33, -37, -40, -44, -48, -51, -54, -59, -62, -65, -69, -72, -76,
-79, -83, -86, -90, -94, -97, -101, -104, -108, -111, -115, -118, -116, -111,
-108, -103, -99, -95, -91, -87, -83, -79, -75, -71, -67, -63, -60, -56, -52,
-48, -43, -39, -35, -33, -28, -23, -20, -16, -13, -8, -4, 0, };