#define DATA_LENGTH 512
#define DATA AKWF_linear_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 3, 3, 4, 5, 5, 6, 7, 7, 9, 9,
9, 11, 11, 11, 12, 13, 13, 14, 15, 16, 17, 18, 18, 19, 20, 20, 20, 21, 22, 24,
25, 26, 28, 29, 30, 32, 33, 36, 36, 37, 40, 42, 44, 45, 46, 47, 49, 51, 51, 53,
55, 56, 57, 58, 60, 62, 64, 65, 67, 69, 69, 71, 72, 73, 75, 76, 78, 78, 79, 80,
81, 82, 83, 84, 84, 85, 86, 87, 88, 88, 89, 91, 90, 93, 93, 94, 95, 95, 96, 98,
98, 98, 100, 101, 102, 102, 104, 104, 105, 106, 107, 107, 108, 109, 109, 109,
109, 109, 110, 110, 110, 111, 111, 111, 112, 112, 112, 113, 113, 113, 114, 114,
114, 115, 115, 114, 115, 115, 115, 117, 117, 118, 117, 117, 118, 118, 119, 118,
119, 119, 119, 118, 117, 117, 117, 116, 116, 116, 115, 114, 115, 114, 114, 113,
113, 112, 112, 111, 111, 111, 110, 110, 109, 109, 109, 109, 107, 107, 107, 106,
105, 105, 104, 104, 104, 104, 103, 102, 101, 100, 99, 98, 96, 96, 95, 94, 93,
92, 91, 91, 90, 88, 88, 87, 85, 84, 84, 82, 81, 80, 79, 78, 77, 77, 75, 75, 74,
72, 72, 71, 70, 68, 67, 66, 65, 63, 61, 60, 58, 58, 56, 55, 54, 51, 49, 48, 48,
46, 45, 42, 42, 40, 39, 38, 36, 35, 33, 31, 30, 29, 28, 26, 24, 24, 22, 20, 18,
18, 16, 15, 13, 11, 10, 9, 6, 5, 3, 1, 0, -1, -2, -4, -6, -6, -8, -10, -12, -13,
-15, -16, -18, -19, -21, -22, -24, -26, -27, -29, -31, -32, -33, -35, -36, -38,
-40, -41, -42, -44, -44, -46, -47, -48, -50, -51, -52, -53, -54, -56, -57, -58,
-60, -61, -62, -63, -64, -66, -67, -67, -69, -71, -72, -73, -74, -76, -77, -78,
-80, -79, -81, -83, -83, -85, -86, -88, -87, -89, -89, -90, -90, -92, -93, -93,
-95, -96, -96, -97, -99, -98, -100, -100, -102, -103, -103, -104, -104, -105,
-106, -108, -108, -109, -110, -111, -112, -112, -113, -114, -115, -116, -116,
-117, -116, -116, -116, -116, -116, -116, -117, -117, -117, -117, -117, -117,
-117, -116, -117, -117, -118, -117, -117, -117, -116, -117, -117, -118, -117,
-118, -117, -117, -118, -117, -118, -117, -118, -119, -118, -118, -118, -117,
-116, -116, -116, -115, -115, -114, -115, -114, -113, -113, -113, -112, -112,
-112, -111, -111, -111, -110, -110, -109, -109, -108, -108, -108, -108, -108,
-107, -107, -106, -106, -105, -106, -104, -103, -103, -100, -100, -98, -97, -95,
-93, -92, -90, -88, -87, -86, -84, -82, -80, -80, -78, -77, -76, -73, -72, -69,
-69, -67, -66, -64, -62, -60, -59, -58, -56, -54, -54, -52, -51, -48, -47, -45,
-45, -44, -42, -41, -39, -38, -37, -37, -35, -34, -33, -31, -30, -29, -28, -26,
-25, -24, -22, -21, -20, -19, -18, -16, -16, -15, -12, -12, -10, -9, -8, -6, -5,
-4, -4, -2, -2, -2, 0, };