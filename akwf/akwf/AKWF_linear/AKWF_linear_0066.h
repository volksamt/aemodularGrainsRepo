#define DATA_LENGTH 512
#define DATA AKWF_linear_0066

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 4, 7, 8, 10, 12, 13, 15, 17, 18,
19, 22, 23, 25, 26, 28, 29, 32, 32, 34, 36, 37, 39, 40, 42, 43, 46, 47, 48, 49,
50, 50, 51, 52, 52, 53, 54, 54, 55, 55, 56, 57, 57, 58, 58, 59, 60, 60, 60, 61,
62, 63, 62, 64, 64, 62, 60, 59, 57, 56, 55, 54, 52, 50, 48, 47, 46, 44, 42, 41,
40, 39, 37, 35, 34, 33, 31, 29, 28, 26, 25, 24, 23, 22, 20, 20, 19, 17, 16, 15,
14, 14, 11, 11, 9, 8, 7, 6, 4, 4, 2, 2, 0, -1, -1, -2, -1, 1, 1, 4, 5, 6, 8, 10,
11, 13, 14, 15, 18, 20, 20, 21, 24, 25, 28, 29, 30, 31, 32, 35, 36, 38, 40, 42,
46, 47, 49, 52, 54, 56, 59, 61, 64, 66, 67, 70, 72, 75, 77, 79, 82, 83, 87, 89,
91, 93, 94, 96, 98, 98, 99, 100, 101, 101, 103, 103, 105, 105, 106, 107, 109,
110, 110, 111, 112, 113, 114, 115, 116, 116, 117, 119, 118, 117, 115, 114, 111,
110, 108, 107, 105, 103, 101, 100, 97, 96, 93, 92, 91, 88, 86, 84, 83, 81, 79,
78, 76, 74, 71, 68, 65, 62, 59, 56, 53, 50, 47, 44, 40, 37, 34, 30, 27, 25, 21,
17, 14, 11, 8, 5, 1, -1, -4, -7, -8, -10, -12, -14, -16, -17, -20, -22, -23,
-24, -26, -28, -31, -32, -34, -35, -37, -39, -40, -43, -44, -46, -48, -49, -52,
-52, -52, -53, -54, -54, -54, -55, -55, -55, -56, -55, -56, -57, -57, -57, -57,
-58, -59, -59, -59, -59, -60, -60, -60, -61, -61, -61, -61, -59, -60, -59, -59,
-58, -58, -57, -56, -56, -54, -54, -54, -54, -53, -53, -52, -52, -51, -52, -50,
-50, -50, -49, -48, -48, -48, -49, -48, -49, -49, -49, -49, -48, -49, -48, -48,
-48, -49, -48, -48, -48, -48, -48, -48, -49, -48, -48, -49, -49, -48, -48, -46,
-46, -46, -45, -45, -44, -43, -43, -43, -42, -41, -41, -40, -40, -39, -38, -39,
-38, -38, -37, -37, -35, -35, -35, -33, -32, -32, -31, -30, -28, -28, -27, -26,
-25, -24, -23, -22, -22, -20, -19, -18, -18, -17, -16, -15, -14, -13, -12, -10,
-12, -11, -13, -14, -13, -14, -15, -15, -16, -16, -17, -18, -18, -19, -20, -20,
-20, -22, -22, -22, -22, -24, -24, -24, -25, -26, -26, -28, -29, -31, -31, -33,
-34, -34, -36, -37, -38, -40, -41, -42, -42, -45, -46, -47, -48, -48, -50, -52,
-53, -54, -55, -56, -57, -59, -60, -61, -62, -63, -65, -66, -66, -68, -68, -70,
-71, -72, -73, -75, -76, -77, -77, -79, -80, -82, -83, -84, -85, -84, -82, -80,
-79, -77, -75, -74, -71, -69, -68, -66, -64, -63, -61, -60, -58, -56, -54, -52,
-51, -48, -47, -46, -44, -42, -41, -38, -37, -34, -33, -31, -29, -27, -26, -23,
-21, -19, -17, -15, -14, -11, -10, -8, -6, -4, -3, -1, };