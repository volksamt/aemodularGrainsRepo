#define DATA_LENGTH 512
#define DATA AKWF_linear_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 1, 1, 1, 1, 3, 2, 3, 3, 3, 4, 5,
5, 6, 6, 7, 8, 7, 8, 9, 10, 10, 10, 10, 11, 12, 12, 13, 13, 14, 15, 15, 16, 16,
16, 17, 17, 18, 19, 19, 19, 20, 20, 21, 22, 22, 23, 24, 24, 25, 26, 26, 27, 28,
28, 29, 29, 30, 30, 31, 31, 32, 34, 33, 35, 36, 36, 36, 37, 38, 39, 39, 40, 41,
42, 43, 42, 44, 45, 44, 46, 47, 47, 48, 48, 49, 50, 50, 51, 52, 52, 54, 54, 55,
55, 56, 57, 58, 58, 59, 59, 61, 62, 62, 63, 64, 64, 65, 66, 66, 67, 68, 69, 70,
70, 70, 71, 72, 74, 74, 75, 75, 76, 77, 77, 77, 79, 79, 80, 81, 82, 83, 83, 83,
84, 85, 86, 86, 87, 89, 89, 90, 90, 90, 92, 93, 92, 94, 95, 95, 95, 97, 97, 98,
99, 99, 99, 99, 100, 99, 100, 100, 101, 102, 101, 103, 103, 102, 103, 103, 103,
104, 103, 105, 104, 105, 105, 105, 105, 106, 107, 107, 107, 107, 109, 107, 108,
108, 109, 110, 109, 109, 109, 108, 108, 107, 107, 106, 106, 105, 105, 104, 104,
102, 103, 101, 101, 101, 100, 100, 99, 99, 98, 97, 96, 96, 95, 95, 95, 94, 94,
94, 93, 92, 92, 91, 91, 89, 87, 84, 82, 79, 76, 73, 71, 69, 66, 64, 60, 58, 55,
53, 50, 47, 44, 43, 40, 36, 34, 32, 29, 26, 23, 21, 18, 16, 13, 10, 7, 5, 3, 0,
-2, -6, -9, -11, -13, -17, -19, -21, -24, -26, -30, -32, -36, -39, -40, -43,
-45, -49, -51, -54, -56, -59, -62, -64, -67, -70, -73, -75, -78, -81, -83, -86,
-89, -91, -93, -96, -98, -102, -104, -104, -104, -106, -106, -106, -107, -107,
-107, -109, -108, -108, -108, -110, -110, -110, -111, -110, -111, -111, -113,
-113, -113, -113, -113, -114, -115, -116, -115, -116, -116, -116, -117, -117,
-118, -118, -119, -118, -118, -118, -117, -117, -116, -116, -115, -114, -114,
-113, -113, -112, -112, -111, -111, -110, -109, -108, -108, -107, -107, -106,
-107, -105, -104, -104, -103, -102, -102, -103, -101, -101, -101, -100, -99,
-100, -98, -97, -96, -95, -95, -93, -92, -92, -91, -90, -89, -88, -88, -86, -86,
-84, -83, -82, -81, -81, -79, -79, -77, -77, -77, -76, -74, -73, -73, -70, -71,
-69, -68, -68, -66, -66, -65, -64, -64, -62, -62, -61, -60, -60, -58, -58, -57,
-56, -55, -55, -53, -54, -52, -51, -50, -50, -49, -48, -47, -47, -45, -45, -44,
-44, -42, -42, -41, -40, -39, -38, -38, -37, -35, -36, -35, -34, -33, -33, -32,
-31, -30, -30, -30, -29, -28, -27, -27, -26, -25, -24, -24, -23, -21, -22, -20,
-21, -19, -19, -18, -17, -16, -16, -15, -15, -14, -13, -13, -12, -11, -10, -10,
-10, -10, -9, -8, -8, -8, -8, -7, -8, -6, -5, -5, -5, -5, -5, -4, -4, -3, -2,
-3, -2, -3, -1, -1, -1, 0, 0, };