#define DATA_LENGTH 512
#define DATA AKWF_linear_0053

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 10, 12, 14, 17, 20, 22, 25,
28, 28, 31, 34, 36, 38, 40, 42, 45, 47, 49, 52, 54, 56, 58, 61, 62, 65, 67, 69,
73, 74, 76, 79, 81, 83, 86, 88, 90, 92, 94, 96, 99, 101, 103, 105, 104, 105,
106, 105, 106, 107, 107, 107, 107, 108, 107, 108, 109, 109, 109, 109, 110, 110,
112, 112, 111, 111, 112, 112, 113, 113, 113, 114, 114, 114, 115, 115, 115, 115,
117, 116, 117, 117, 117, 116, 117, 117, 117, 117, 117, 117, 118, 117, 117, 118,
118, 118, 117, 117, 117, 118, 118, 118, 118, 118, 119, 118, 118, 118, 118, 119,
119, 119, 118, 119, 119, 119, 116, 113, 109, 106, 103, 99, 95, 91, 88, 84, 81,
77, 73, 70, 66, 62, 59, 55, 52, 48, 44, 41, 37, 33, 29, 26, 22, 18, 15, 11, 8,
4, 0, -3, -7, -11, -14, -17, -19, -22, -25, -28, -31, -34, -37, -39, -43, -45,
-48, -51, -54, -57, -60, -62, -66, -68, -71, -75, -77, -79, -83, -86, -88, -92,
-94, -97, -100, -102, -105, -108, -111, -114, -117, -117, -115, -112, -111,
-108, -106, -104, -103, -100, -98, -96, -93, -90, -89, -87, -85, -83, -80, -77,
-77, -73, -71, -70, -67, -66, -64, -61, -58, -56, -55, -52, -50, -48, -46, -43,
-42, -39, -38, -39, -40, -39, -39, -39, -40, -39, -39, -39, -38, -40, -39, -40,
-40, -39, -39, -39, -39, -40, -40, -40, -40, -40, -39, -40, -40, -40, -40, -41,
-40, -40, -41, -40, -41, -40, -40, -37, -35, -33, -31, -28, -26, -25, -22, -20,
-18, -16, -13, -11, -8, -7, -4, -2, -1, 2, 5, 6, 8, 11, 13, 15, 18, 20, 22, 24,
27, 28, 30, 33, 35, 37, 39, 42, 43, 45, 47, 50, 52, 53, 56, 58, 59, 62, 63, 65,
67, 68, 71, 74, 75, 77, 79, 81, 82, 85, 87, 89, 91, 93, 95, 97, 98, 100, 102,
105, 106, 108, 111, 111, 107, 103, 100, 96, 91, 88, 84, 81, 77, 73, 69, 65, 62,
58, 55, 50, 47, 42, 39, 35, 31, 27, 24, 19, 16, 13, 8, 4, 1, -3, -7, -10, -14,
-19, -21, -26, -28, -30, -32, -32, -35, -37, -39, -40, -42, -43, -45, -46, -48,
-50, -52, -53, -55, -58, -60, -61, -63, -65, -66, -68, -70, -70, -74, -75, -76,
-78, -79, -82, -83, -85, -87, -88, -90, -90, -91, -92, -92, -93, -93, -94, -94,
-95, -96, -95, -96, -97, -97, -98, -99, -99, -99, -101, -101, -102, -102, -103,
-104, -104, -105, -104, -105, -107, -107, -108, -108, -109, -109, -110, -110,
-109, -108, -109, -107, -105, -105, -104, -104, -101, -101, -101, -99, -99, -98,
-97, -95, -94, -93, -92, -92, -90, -89, -88, -88, -86, -85, -85, -83, -82, -81,
-80, -80, -78, -77, -77, -76, -75, -72, -70, -67, -65, -61, -59, -57, -55, -51,
-48, -46, -43, -41, -38, -35, -33, -30, -27, -25, -22, -19, -16, -15, -11, -8,
-6, -3, -1, };