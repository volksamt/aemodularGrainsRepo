#define DATA_LENGTH 512
#define DATA AKWF_linear_0078

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 6, 9, 11, 13, 15, 16, 18, 20,
22, 24, 26, 28, 31, 32, 33, 36, 39, 40, 41, 45, 46, 48, 50, 51, 54, 56, 58, 59,
61, 64, 65, 67, 69, 72, 74, 75, 77, 78, 78, 80, 80, 81, 82, 82, 83, 85, 85, 85,
86, 87, 89, 90, 90, 91, 91, 92, 93, 94, 95, 96, 96, 97, 98, 99, 99, 100, 101,
102, 103, 104, 105, 105, 106, 107, 108, 109, 109, 110, 111, 111, 112, 114, 114,
115, 116, 117, 118, 117, 116, 113, 112, 109, 106, 104, 101, 99, 96, 94, 91, 89,
86, 84, 82, 79, 77, 75, 72, 69, 68, 66, 63, 60, 58, 55, 54, 51, 48, 45, 43, 40,
38, 35, 34, 31, 29, 27, 24, 21, 19, 17, 14, 12, 9, 7, 5, 2, 0, -3, -5, -6, -6,
-7, -7, -8, -9, -9, -10, -11, -10, -11, -11, -12, -13, -13, -15, -14, -15, -16,
-16, -16, -17, -17, -18, -18, -18, -20, -20, -21, -21, -22, -22, -23, -24, -24,
-24, -25, -26, -27, -26, -27, -27, -28, -28, -30, -30, -30, -31, -31, -31, -32,
-32, -33, -32, -32, -31, -31, -31, -31, -31, -30, -31, -30, -30, -31, -30, -30,
-30, -29, -30, -29, -29, -29, -30, -29, -28, -30, -29, -28, -29, -27, -28, -28,
-27, -28, -27, -27, -28, -26, -27, -26, -26, -27, -26, -27, -26, -26, -26, -26,
-25, -25, -25, -25, -26, -25, -24, -24, -24, -24, -25, -25, -24, -24, -24, -24,
-23, -23, -23, -23, -23, -23, -23, -22, -23, -22, -22, -23, -22, -22, -22, -21,
-21, -21, -21, -21, -21, -21, -20, -21, -20, -20, -20, -19, -19, -20, -19, -19,
-19, -18, -19, -19, -19, -19, -17, -16, -15, -14, -12, -10, -9, -7, -6, -5, -3,
-2, -1, 1, 2, 3, 5, 6, 8, 10, 11, 13, 14, 15, 16, 18, 19, 21, 22, 24, 26, 27,
28, 29, 31, 33, 35, 36, 37, 38, 40, 42, 44, 44, 46, 48, 49, 50, 52, 53, 55, 56,
54, 53, 51, 49, 47, 47, 44, 43, 41, 39, 38, 36, 35, 33, 32, 30, 29, 27, 24, 24,
21, 21, 19, 16, 16, 13, 13, 10, 9, 7, 6, 4, 3, 1, -1, -2, -4, -6, -7, -9, -10,
-11, -13, -15, -16, -18, -19, -21, -24, -25, -26, -29, -30, -32, -34, -35, -37,
-39, -41, -43, -45, -46, -48, -50, -51, -54, -55, -57, -59, -61, -63, -64, -66,
-68, -70, -72, -74, -76, -78, -80, -82, -82, -85, -87, -89, -90, -92, -93, -96,
-97, -100, -102, -103, -104, -107, -109, -110, -112, -114, -115, -118, -119,
-119, -116, -114, -114, -111, -109, -107, -105, -104, -102, -99, -98, -97, -93,
-92, -90, -89, -86, -85, -83, -81, -78, -76, -75, -72, -71, -70, -68, -65, -65,
-62, -61, -59, -56, -54, -52, -50, -49, -47, -45, -43, -41, -38, -37, -36, -33,
-32, -30, -27, -26, -23, -22, -20, -18, -17, -14, -12, -11, -8, -7, -5, -2, -1,
};