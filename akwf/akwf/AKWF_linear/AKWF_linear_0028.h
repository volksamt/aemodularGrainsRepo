#define DATA_LENGTH 512
#define DATA AKWF_linear_0028

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 2, 3, 4, 4, 6, 7, 7, 8, 9, 9,
10, 10, 11, 12, 12, 13, 14, 14, 15, 16, 16, 17, 18, 18, 19, 19, 20, 21, 21, 22,
22, 24, 23, 24, 26, 25, 25, 27, 27, 28, 29, 30, 30, 30, 31, 33, 34, 36, 39, 41,
44, 46, 49, 52, 54, 56, 58, 60, 63, 65, 68, 71, 73, 75, 77, 80, 82, 84, 86, 89,
92, 95, 97, 99, 101, 103, 106, 108, 111, 113, 116, 118, 119, 115, 112, 109, 107,
104, 101, 99, 96, 93, 91, 88, 85, 82, 80, 78, 74, 72, 69, 66, 63, 61, 57, 56,
53, 50, 48, 45, 42, 40, 36, 34, 32, 28, 26, 23, 20, 18, 15, 12, 11, 7, 5, 3, 0,
-3, -6, -7, -11, -13, -15, -18, -21, -24, -26, -29, -31, -34, -37, -40, -42,
-44, -47, -50, -52, -55, -57, -60, -62, -65, -67, -71, -73, -74, -71, -69, -66,
-63, -61, -59, -56, -54, -51, -49, -47, -43, -41, -38, -35, -34, -32, -30, -26,
-23, -22, -19, -17, -13, -11, -10, -6, -4, -2, 2, 3, 6, 8, 10, 13, 16, 17, 20,
21, 23, 24, 27, 28, 30, 32, 34, 35, 37, 39, 40, 42, 44, 45, 48, 50, 52, 53, 54,
57, 58, 61, 62, 63, 65, 67, 69, 71, 73, 74, 76, 78, 79, 80, 82, 83, 84, 85, 87,
87, 88, 89, 90, 91, 93, 93, 94, 95, 96, 97, 97, 99, 101, 101, 102, 103, 105,
105, 107, 107, 108, 109, 110, 111, 112, 113, 114, 115, 116, 117, 114, 111, 107,
104, 101, 98, 93, 90, 87, 84, 79, 76, 73, 69, 66, 62, 59, 56, 52, 48, 45, 41,
38, 34, 31, 28, 25, 21, 17, 14, 10, 7, 3, 0, -3, -8, -10, -13, -16, -17, -19,
-22, -24, -26, -29, -31, -33, -35, -37, -40, -43, -44, -47, -50, -52, -54, -56,
-58, -61, -63, -66, -67, -70, -73, -75, -77, -80, -82, -85, -87, -88, -90, -93,
-95, -93, -92, -92, -93, -92, -92, -91, -91, -90, -89, -89, -88, -88, -87, -88,
-86, -86, -86, -85, -85, -84, -84, -84, -83, -83, -82, -82, -81, -81, -80, -80,
-79, -80, -79, -78, -78, -77, -77, -78, -76, -77, -76, -76, -76, -76, -76, -77,
-76, -75, -75, -76, -75, -75, -75, -75, -74, -74, -74, -74, -73, -74, -73, -73,
-73, -72, -73, -72, -72, -73, -73, -72, -72, -71, -71, -69, -69, -69, -68, -68,
-67, -66, -65, -64, -64, -63, -63, -62, -62, -61, -61, -59, -59, -58, -58, -57,
-55, -55, -54, -53, -54, -52, -52, -51, -51, -50, -49, -48, -48, -47, -47, -45,
-45, -44, -43, -43, -41, -41, -40, -40, -39, -38, -37, -36, -36, -34, -34, -33,
-33, -32, -30, -30, -29, -29, -28, -28, -26, -26, -24, -24, -24, -22, -22, -21,
-20, -19, -19, -18, -17, -15, -16, -15, -14, -13, -13, -11, -11, -10, -9, -9,
-7, -7, -7, -5, -5, -4, -4, -3, -2, -2, 0, };