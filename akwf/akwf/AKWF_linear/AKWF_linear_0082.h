#define DATA_LENGTH 512
#define DATA AKWF_linear_0082

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 8, 11, 14, 18, 22, 25, 29, 31,
36, 39, 42, 45, 49, 53, 56, 57, 58, 60, 61, 63, 64, 64, 66, 67, 67, 69, 70, 73,
73, 74, 75, 77, 78, 79, 79, 81, 82, 82, 84, 85, 86, 88, 89, 90, 92, 93, 94, 94,
95, 97, 99, 100, 101, 101, 103, 104, 105, 106, 107, 108, 110, 111, 112, 114,
115, 116, 116, 116, 116, 116, 115, 115, 115, 114, 114, 114, 114, 113, 112, 113,
113, 112, 112, 112, 111, 111, 112, 111, 110, 110, 110, 110, 110, 109, 109, 109,
109, 109, 107, 108, 107, 106, 107, 107, 106, 106, 106, 106, 106, 105, 105, 105,
104, 104, 104, 103, 103, 103, 102, 102, 102, 102, 102, 101, 101, 101, 101, 100,
101, 100, 99, 98, 99, 99, 99, 98, 97, 97, 98, 97, 96, 96, 97, 96, 96, 95, 95,
95, 94, 94, 94, 93, 94, 92, 92, 93, 92, 91, 92, 91, 91, 90, 91, 90, 90, 89, 90,
90, 89, 87, 86, 85, 83, 81, 81, 79, 77, 76, 75, 74, 72, 70, 69, 68, 67, 65, 64,
62, 61, 60, 58, 57, 56, 53, 53, 52, 51, 49, 47, 46, 45, 43, 42, 42, 40, 38, 37,
35, 34, 33, 31, 29, 29, 27, 26, 25, 23, 22, 21, 18, 18, 18, 18, 16, 17, 16, 15,
16, 14, 14, 14, 14, 13, 12, 12, 11, 11, 10, 10, 10, 8, 8, 8, 8, 7, 6, 5, 5, 4,
5, 5, 4, 4, 2, 2, 2, 1, 0, 0, 0, 0, -2, -2, -2, -3, -4, -4, -5, -5, -5, -6, -7,
-7, -8, -9, -9, -11, -10, -11, -13, -13, -13, -15, -15, -15, -16, -17, -18, -19,
-19, -20, -20, -21, -22, -23, -24, -23, -24, -25, -26, -27, -28, -28, -28, -29,
-30, -30, -31, -33, -33, -33, -35, -34, -36, -36, -37, -38, -39, -39, -40, -41,
-41, -43, -44, -46, -46, -48, -48, -50, -51, -52, -53, -54, -55, -57, -58, -59,
-61, -62, -63, -64, -66, -66, -69, -69, -70, -71, -72, -74, -75, -76, -77, -79,
-79, -81, -82, -83, -85, -86, -87, -88, -90, -91, -92, -93, -94, -96, -96, -98,
-100, -100, -101, -103, -103, -103, -104, -105, -104, -104, -104, -104, -105,
-105, -105, -106, -106, -106, -106, -106, -107, -107, -108, -107, -108, -108,
-108, -108, -109, -109, -109, -109, -109, -110, -109, -109, -111, -110, -111,
-110, -110, -111, -112, -112, -111, -112, -113, -112, -113, -112, -113, -113,
-114, -114, -115, -114, -115, -113, -114, -115, -115, -115, -115, -114, -115,
-115, -115, -115, -114, -115, -115, -115, -116, -116, -116, -116, -117, -117,
-116, -117, -117, -117, -117, -117, -116, -117, -117, -118, -118, -117, -118,
-118, -118, -118, -117, -118, -118, -118, -118, -118, -119, -118, -119, -119,
-119, -119, -119, -115, -112, -108, -105, -101, -97, -95, -91, -88, -84, -81,
-78, -74, -71, -67, -64, -60, -56, -53, -49, -46, -42, -39, -36, -33, -29, -26,
-22, -19, -15, -12, -8, -5, -1, };