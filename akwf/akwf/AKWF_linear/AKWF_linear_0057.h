#define DATA_LENGTH 512
#define DATA AKWF_linear_0057

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 3, 4, 4, 5, 6, 7, 8, 9, 9,
11, 11, 13, 13, 15, 15, 17, 18, 18, 20, 20, 22, 23, 24, 24, 26, 26, 27, 28, 29,
31, 32, 33, 34, 35, 36, 37, 38, 39, 39, 42, 42, 42, 43, 44, 45, 45, 46, 46, 47,
47, 47, 48, 48, 50, 50, 50, 51, 51, 52, 52, 53, 53, 54, 55, 54, 55, 56, 56, 57,
56, 59, 59, 58, 59, 60, 61, 61, 61, 61, 61, 62, 60, 61, 61, 61, 59, 60, 60, 60,
59, 59, 59, 59, 59, 58, 59, 57, 58, 57, 57, 57, 57, 57, 56, 56, 56, 56, 56, 55,
55, 55, 55, 54, 55, 54, 53, 54, 52, 51, 50, 50, 49, 48, 47, 47, 46, 45, 44, 43,
43, 41, 41, 40, 40, 39, 37, 37, 36, 35, 35, 34, 33, 32, 30, 31, 30, 30, 29, 27,
26, 26, 24, 25, 23, 23, 21, 20, 21, 20, 19, 19, 17, 16, 16, 14, 14, 13, 12, 12,
11, 10, 9, 8, 9, 7, 6, 6, 5, 5, 2, 2, 1, 1, 0, 0, -2, -2, -2, -3, -4, -4, -5,
-6, -7, -7, -8, -9, -10, -9, -11, -11, -12, -13, -14, -14, -15, -16, -17, -17,
-17, -18, -19, -19, -20, -20, -22, -23, -22, -24, -24, -25, -26, -27, -27, -28,
-28, -28, -29, -28, -28, -29, -29, -29, -28, -30, -30, -30, -30, -30, -31, -31,
-31, -31, -31, -31, -31, -32, -31, -32, -31, -32, -32, -33, -33, -32, -34, -33,
-33, -33, -33, -34, -34, -33, -33, -33, -32, -32, -32, -32, -31, -31, -32, -31,
-31, -31, -30, -29, -30, -28, -29, -29, -28, -28, -28, -27, -27, -27, -27, -27,
-26, -25, -26, -25, -25, -24, -24, -24, -25, -23, -22, -21, -21, -20, -19, -18,
-17, -17, -16, -15, -15, -13, -13, -12, -11, -11, -10, -8, -7, -6, -5, -5, -4,
-3, -2, -2, 0, 0, 1, 1, 2, 3, 4, 4, 6, 7, 9, 12, 13, 15, 17, 20, 20, 23, 25, 26,
28, 31, 32, 34, 37, 38, 40, 42, 45, 46, 48, 50, 52, 54, 56, 57, 60, 61, 63, 66,
67, 70, 72, 73, 75, 76, 74, 70, 68, 63, 60, 57, 54, 50, 47, 42, 40, 36, 33, 29,
27, 23, 19, 15, 12, 9, 5, 3, -1, -5, -9, -11, -15, -18, -22, -26, -28, -32, -35,
-38, -42, -46, -49, -50, -52, -55, -56, -57, -60, -62, -64, -66, -68, -70, -72,
-74, -76, -78, -80, -83, -83, -86, -87, -89, -92, -94, -95, -98, -99, -101,
-104, -105, -107, -109, -111, -113, -115, -117, -119, -117, -115, -112, -109,
-105, -103, -100, -97, -95, -91, -90, -86, -85, -81, -78, -75, -72, -69, -67,
-65, -62, -59, -56, -53, -51, -48, -45, -43, -39, -37, -34, -32, -28, -26, -23,
-20, -17, -17, -17, -16, -15, -15, -14, -13, -13, -12, -12, -11, -11, -10, -9,
-8, -8, -7, -6, -5, -5, -4, -3, -3, -3, -2, -1, 0, };