#define DATA_LENGTH 512
#define DATA AKWF_linear_0056

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 10, 14, 20, 23, 28, 32, 38, 42,
46, 51, 56, 59, 65, 70, 74, 78, 83, 88, 92, 96, 101, 106, 110, 108, 105, 102,
99, 96, 93, 89, 86, 83, 80, 77, 73, 71, 67, 65, 61, 59, 55, 52, 49, 46, 43, 40,
37, 34, 31, 29, 25, 22, 19, 15, 12, 10, 7, 4, 0, -2, -6, -9, -12, -15, -19, -22,
-25, -28, -31, -34, -38, -41, -44, -47, -51, -54, -58, -60, -64, -66, -70, -72,
-76, -79, -82, -86, -89, -93, -95, -97, -102, -105, -107, -110, -115, -117,
-118, -117, -117, -118, -118, -118, -119, -118, -118, -118, -118, -118, -118,
-118, -118, -118, -118, -118, -119, -119, -119, -118, -118, -118, -119, -118,
-118, -118, -119, -119, -119, -119, -119, -119, -119, -120, -119, -118, -117,
-115, -114, -113, -112, -112, -111, -109, -109, -107, -106, -105, -104, -103,
-102, -100, -100, -99, -97, -97, -96, -94, -93, -92, -91, -90, -90, -89, -87,
-86, -86, -83, -82, -81, -80, -77, -75, -71, -68, -65, -62, -59, -55, -52, -50,
-45, -43, -39, -36, -33, -30, -26, -23, -20, -18, -14, -10, -8, -3, 0, 3, 6, 9,
12, 14, 18, 22, 24, 27, 31, 34, 37, 40, 41, 43, 45, 48, 50, 52, 54, 56, 58, 60,
62, 64, 65, 68, 70, 72, 74, 76, 78, 80, 82, 84, 87, 88, 91, 93, 94, 97, 98, 101,
102, 104, 106, 108, 111, 110, 108, 107, 104, 103, 100, 98, 97, 95, 93, 92, 90,
88, 85, 84, 81, 80, 77, 76, 74, 73, 71, 67, 67, 65, 62, 61, 59, 57, 55, 53, 51,
49, 47, 46, 44, 42, 41, 40, 39, 37, 37, 35, 35, 34, 33, 31, 30, 29, 27, 27, 26,
25, 24, 23, 21, 21, 20, 18, 18, 17, 17, 15, 13, 13, 12, 11, 10, 8, 7, 7, 5, 5,
4, 4, 2, 3, 3, 3, 2, 2, 2, 1, 1, 1, 2, 1, 1, 0, 0, 1, 0, -1, -1, -1, -1, -1, -2,
-3, -2, -2, -2, -2, -4, -3, -4, -4, -4, -4, -5, -3, -3, -2, -2, 0, 0, 1, 2, 2,
4, 4, 4, 5, 6, 7, 8, 8, 10, 10, 11, 12, 12, 14, 14, 15, 16, 17, 17, 18, 20, 20,
20, 21, 21, 23, 23, 25, 27, 28, 31, 33, 35, 37, 38, 41, 43, 45, 48, 48, 51, 53,
55, 57, 59, 61, 64, 66, 67, 69, 72, 73, 76, 77, 79, 82, 84, 86, 88, 90, 92, 94,
96, 98, 95, 90, 87, 83, 79, 74, 71, 67, 63, 59, 55, 51, 48, 44, 39, 36, 32, 28,
24, 20, 16, 12, 8, 4, 0, -3, -7, -12, -15, -19, -23, -27, -31, -35, -39, -42,
-46, -46, -47, -46, -47, -47, -48, -48, -48, -49, -49, -49, -50, -50, -50, -50,
-51, -52, -52, -52, -53, -52, -53, -53, -54, -55, -54, -55, -55, -56, -56, -55,
-56, -56, -56, -57, -57, -54, -50, -44, -40, -36, -31, -27, -22, -18, -13, -8,
-3, };