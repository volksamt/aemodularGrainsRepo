#define DATA_LENGTH 512
#define DATA AKWF_linear_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 3, 4, 5, 6, 5, 7, 7, 8, 8, 9,
10, 11, 12, 13, 13, 14, 15, 15, 16, 17, 17, 18, 19, 18, 20, 20, 20, 21, 23, 22,
23, 24, 25, 25, 25, 27, 27, 27, 28, 29, 30, 31, 32, 32, 32, 33, 37, 39, 40, 43,
45, 47, 50, 52, 54, 57, 58, 61, 63, 65, 68, 69, 73, 75, 76, 79, 81, 85, 85, 88,
91, 93, 94, 98, 99, 102, 104, 107, 109, 111, 113, 115, 113, 110, 108, 105, 103,
100, 98, 95, 92, 89, 87, 84, 82, 79, 76, 73, 71, 68, 66, 64, 61, 58, 55, 52, 49,
47, 44, 42, 39, 36, 35, 31, 28, 26, 23, 21, 18, 15, 12, 10, 6, 3, 2, -2, -5, -6,
-9, -12, -15, -17, -20, -23, -25, -28, -30, -34, -36, -39, -41, -44, -47, -50,
-52, -56, -58, -60, -63, -66, -69, -71, -75, -77, -79, -79, -75, -73, -70, -68,
-65, -63, -61, -57, -55, -52, -50, -47, -45, -42, -39, -37, -35, -32, -30, -28,
-25, -22, -20, -17, -15, -12, -9, -7, -4, -2, 0, 3, 5, 8, 11, 13, 14, 16, 18,
18, 20, 21, 22, 24, 26, 27, 29, 30, 31, 32, 34, 35, 37, 38, 40, 41, 43, 44, 45,
47, 48, 49, 51, 53, 54, 55, 57, 58, 60, 61, 62, 64, 65, 66, 68, 70, 71, 73, 75,
75, 77, 78, 80, 82, 83, 84, 86, 88, 90, 90, 93, 94, 95, 97, 99, 99, 102, 103,
105, 106, 108, 109, 110, 112, 113, 115, 117, 118, 119, 117, 114, 112, 109, 108,
105, 103, 101, 97, 95, 92, 90, 88, 85, 84, 80, 78, 76, 74, 71, 69, 66, 64, 62,
59, 56, 53, 52, 49, 47, 45, 42, 40, 37, 35, 33, 30, 27, 23, 20, 16, 13, 10, 7,
3, 0, -4, -7, -9, -14, -16, -20, -23, -27, -30, -33, -36, -40, -43, -47, -50,
-54, -57, -60, -64, -66, -71, -74, -76, -80, -83, -87, -90, -90, -89, -90, -89,
-89, -90, -89, -89, -88, -88, -88, -89, -88, -88, -88, -89, -88, -88, -87, -87,
-87, -87, -87, -86, -87, -86, -86, -86, -85, -86, -85, -85, -86, -85, -85, -85,
-85, -85, -85, -85, -84, -84, -83, -83, -82, -82, -82, -82, -82, -81, -81, -81,
-80, -80, -81, -80, -80, -80, -79, -79, -78, -78, -78, -78, -78, -77, -77, -76,
-76, -76, -76, -75, -75, -75, -74, -74, -74, -72, -73, -71, -71, -70, -69, -69,
-69, -68, -67, -67, -66, -65, -64, -64, -64, -63, -63, -62, -61, -61, -61, -59,
-59, -59, -58, -57, -57, -56, -55, -55, -54, -53, -53, -51, -51, -49, -49, -48,
-47, -46, -45, -45, -43, -43, -42, -41, -39, -38, -37, -37, -35, -36, -34, -33,
-32, -31, -31, -29, -28, -27, -26, -26, -24, -24, -23, -22, -21, -20, -19, -18,
-18, -16, -16, -15, -14, -13, -13, -12, -11, -11, -9, -9, -8, -7, -6, -5, -5,
-4, -3, -2, -2, -1, 0, };