#define DATA_LENGTH 512
#define DATA AKWF_linear_0059

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 3, 3, 3, 5, 6, 6, 7, 8, 8, 9,
10, 10, 11, 12, 12, 14, 15, 14, 16, 17, 17, 18, 19, 19, 21, 21, 21, 23, 23, 24,
24, 25, 25, 27, 28, 28, 28, 29, 30, 31, 32, 32, 33, 33, 34, 35, 36, 36, 38, 38,
39, 40, 41, 41, 42, 43, 43, 44, 45, 45, 46, 47, 48, 49, 50, 50, 51, 52, 52, 53,
54, 54, 55, 56, 57, 57, 58, 59, 60, 60, 61, 61, 62, 63, 63, 62, 63, 63, 64, 64,
65, 65, 65, 64, 64, 64, 65, 66, 65, 65, 65, 66, 66, 66, 66, 66, 66, 67, 67, 67,
66, 67, 67, 67, 68, 68, 68, 68, 69, 68, 68, 68, 68, 69, 69, 68, 68, 69, 69, 69,
69, 70, 71, 69, 71, 70, 71, 70, 72, 71, 71, 71, 71, 72, 72, 72, 71, 72, 72, 72,
72, 73, 73, 73, 73, 74, 73, 73, 74, 74, 74, 74, 74, 74, 75, 75, 75, 75, 76, 75,
75, 76, 76, 75, 76, 76, 76, 76, 76, 77, 76, 77, 78, 78, 77, 77, 76, 74, 72, 71,
68, 66, 64, 62, 61, 59, 57, 54, 53, 51, 49, 47, 45, 44, 42, 40, 38, 36, 33, 32,
29, 27, 26, 23, 22, 20, 18, 16, 14, 13, 10, 9, 7, 4, 3, 0, -1, -3, -5, -7, -10,
-10, -13, -15, -16, -19, -20, -23, -24, -27, -28, -30, -32, -34, -36, -38, -40,
-43, -44, -45, -47, -50, -52, -54, -56, -56, -59, -62, -62, -64, -66, -68, -70,
-72, -74, -76, -79, -80, -81, -84, -85, -88, -89, -91, -94, -95, -97, -99, -101,
-104, -104, -106, -108, -111, -112, -115, -116, -119, -119, -117, -117, -116,
-115, -113, -113, -112, -110, -110, -109, -107, -106, -104, -103, -102, -101,
-101, -100, -98, -97, -96, -96, -94, -93, -92, -90, -90, -89, -87, -87, -85,
-84, -83, -82, -82, -80, -79, -77, -77, -75, -75, -73, -73, -72, -70, -68, -68,
-67, -66, -65, -64, -62, -61, -60, -59, -58, -58, -56, -55, -54, -52, -53, -51,
-50, -48, -47, -46, -46, -44, -43, -42, -42, -40, -39, -38, -37, -36, -35, -34,
-33, -32, -30, -29, -28, -27, -26, -25, -24, -23, -22, -21, -20, -18, -18, -17,
-15, -14, -13, -12, -12, -9, -9, -9, -9, -8, -9, -10, -9, -9, -10, -9, -9, -10,
-10, -10, -9, -10, -10, -10, -10, -10, -10, -10, -9, -9, -10, -10, -9, -10, -10,
-10, -10, -10, -10, -10, -10, -10, -11, -10, -10, -11, -10, -10, -10, -11, -11,
-10, -10, -11, -10, -11, -10, -10, -11, -11, -11, -10, -11, -11, -11, -11, -11,
-11, -11, -11, -11, -11, -12, -11, -11, -11, -10, -11, -11, -11, -12, -11, -12,
-12, -12, -12, -12, -12, -11, -11, -11, -12, -12, -12, -11, -12, -12, -12, -11,
-12, -12, -12, -13, -12, -12, -12, -12, -13, -11, -12, -11, -10, -9, -9, -7, -8,
-6, -6, -5, -4, -4, -3, -3, -1, 0, };