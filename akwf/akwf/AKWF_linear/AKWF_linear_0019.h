#define DATA_LENGTH 512
#define DATA AKWF_linear_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 8, 10, 11, 14, 17, 20, 23,
24, 28, 30, 32, 36, 38, 40, 44, 46, 49, 52, 54, 56, 59, 61, 66, 67, 71, 73, 76,
78, 81, 83, 86, 88, 91, 94, 97, 99, 102, 105, 107, 109, 108, 107, 106, 105, 105,
104, 102, 102, 101, 100, 99, 97, 97, 95, 95, 95, 93, 92, 91, 90, 89, 89, 88, 87,
87, 85, 84, 83, 82, 82, 81, 80, 79, 78, 77, 76, 73, 69, 65, 61, 57, 53, 49, 45,
41, 37, 33, 29, 24, 21, 17, 12, 9, 5, 0, -3, -7, -10, -15, -19, -23, -28, -30,
-35, -40, -43, -47, -51, -55, -59, -63, -66, -70, -69, -67, -65, -64, -63, -62,
-60, -60, -58, -57, -55, -54, -53, -52, -50, -49, -48, -46, -46, -43, -42, -41,
-40, -39, -38, -37, -34, -33, -32, -31, -30, -28, -28, -26, -25, -24, -21, -18,
-16, -14, -12, -9, -7, -5, -2, 0, 3, 6, 7, 9, 13, 14, 16, 20, 21, 24, 26, 28,
32, 35, 36, 38, 40, 44, 46, 48, 51, 52, 55, 58, 60, 62, 64, 64, 65, 66, 66, 66,
67, 67, 68, 67, 69, 69, 69, 69, 70, 69, 71, 71, 72, 72, 71, 73, 73, 73, 73, 75,
75, 75, 75, 76, 76, 77, 77, 77, 78, 78, 79, 77, 73, 70, 67, 64, 61, 58, 54, 52,
48, 45, 42, 39, 36, 32, 28, 26, 23, 20, 16, 14, 11, 8, 4, 0, -3, -6, -9, -11,
-15, -18, -22, -24, -27, -30, -34, -37, -38, -39, -40, -40, -41, -42, -42, -42,
-44, -44, -45, -45, -46, -47, -48, -49, -48, -49, -50, -51, -51, -52, -53, -54,
-54, -55, -55, -56, -57, -58, -58, -59, -60, -60, -61, -62, -62, -61, -59, -57,
-55, -54, -52, -50, -49, -47, -46, -44, -42, -41, -39, -38, -36, -34, -32, -31,
-29, -27, -25, -24, -23, -21, -19, -18, -16, -15, -13, -11, -10, -8, -6, -5, -3,
-2, 1, 2, 4, 5, 7, 8, 9, 12, 13, 15, 17, 18, 19, 22, 23, 24, 26, 28, 29, 30, 32,
35, 36, 37, 38, 41, 42, 44, 45, 47, 49, 51, 51, 53, 56, 55, 53, 51, 48, 46, 43,
41, 39, 36, 34, 32, 30, 28, 25, 23, 21, 18, 15, 13, 10, 8, 6, 4, 2, -1, -4, -6,
-8, -11, -13, -15, -17, -19, -21, -24, -27, -29, -32, -34, -37, -39, -41, -44,
-46, -49, -51, -54, -57, -59, -61, -64, -66, -68, -71, -74, -75, -78, -81, -84,
-85, -88, -90, -94, -96, -98, -100, -103, -106, -108, -110, -114, -115, -118,
-119, -118, -115, -114, -112, -110, -108, -106, -105, -102, -101, -99, -97, -96,
-93, -92, -89, -88, -86, -84, -82, -81, -78, -77, -75, -73, -70, -69, -67, -65,
-64, -62, -59, -57, -55, -54, -52, -49, -48, -47, -45, -43, -41, -40, -37, -37,
-34, -32, -31, -30, -28, -26, -24, -22, -22, -20, -17, -15, -13, -12, -10, -9,
-7, -5, -3, -2, 0, };