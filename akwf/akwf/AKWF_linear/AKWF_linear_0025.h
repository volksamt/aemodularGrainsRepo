#define DATA_LENGTH 512
#define DATA AKWF_linear_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 6, 8, 10, 11, 13, 14, 16, 18,
20, 21, 22, 24, 26, 28, 29, 32, 33, 34, 36, 38, 40, 41, 42, 45, 47, 47, 49, 52,
53, 55, 56, 58, 59, 61, 60, 56, 53, 50, 47, 44, 41, 38, 34, 31, 28, 26, 22, 20,
15, 13, 9, 7, 3, -1, -4, -6, -9, -13, -16, -19, -22, -25, -29, -32, -34, -37,
-40, -45, -47, -50, -53, -51, -48, -45, -43, -40, -37, -35, -32, -30, -27, -25,
-22, -18, -16, -14, -11, -7, -5, -2, -1, 2, 5, 8, 11, 14, 15, 19, 21, 24, 27,
29, 33, 35, 37, 40, 43, 45, 46, 47, 49, 49, 50, 51, 52, 53, 55, 55, 57, 59, 60,
61, 61, 62, 64, 65, 67, 67, 68, 70, 70, 72, 73, 75, 75, 76, 78, 79, 80, 81, 82,
84, 85, 85, 83, 80, 77, 75, 72, 69, 66, 62, 60, 57, 54, 50, 47, 44, 42, 38, 36,
33, 30, 27, 24, 21, 18, 16, 13, 9, 7, 3, 0, -2, -5, -8, -11, -14, -18, -20, -21,
-20, -17, -14, -12, -10, -7, -5, -2, 0, 3, 4, 6, 9, 12, 15, 17, 19, 22, 23, 26,
28, 30, 32, 35, 37, 40, 43, 45, 47, 49, 51, 55, 57, 59, 61, 64, 64, 62, 61, 60,
59, 58, 57, 56, 54, 53, 52, 51, 50, 49, 48, 47, 45, 44, 43, 42, 41, 40, 38, 37,
37, 35, 34, 33, 32, 30, 30, 29, 28, 27, 25, 24, 23, 21, 20, 19, 18, 16, 14, 14,
12, 11, 10, 8, 6, 6, 5, 3, 1, 0, -1, -2, -4, -5, -6, -8, -9, -11, -11, -13, -14,
-16, -17, -18, -20, -21, -22, -24, -24, -24, -25, -23, -22, -21, -21, -20, -19,
-19, -17, -16, -15, -16, -13, -13, -12, -11, -10, -10, -9, -8, -7, -6, -5, -5,
-4, -4, -3, -2, -1, 0, 1, 2, 3, 4, 4, 4, 5, 5, 5, 4, 4, 5, 4, 4, 4, 4, 3, 4, 3,
4, 3, 4, 3, 3, 2, 2, 2, 2, 2, 3, 1, 1, 1, 1, 2, 1, 1, 1, 1, 1, 2, 1, 1, 3, 2, 3,
4, 5, 6, 8, 8, 9, 10, 10, 11, 12, 14, 14, 15, 15, 16, 16, 18, 19, 20, 20, 21,
23, 24, 24, 25, 26, 27, 27, 28, 29, 30, 31, 31, 29, 25, 22, 18, 14, 11, 8, 4, 1,
-4, -7, -10, -14, -18, -22, -24, -27, -32, -34, -38, -42, -46, -49, -53, -56,
-60, -64, -66, -70, -73, -78, -80, -84, -88, -91, -94, -96, -98, -99, -99, -100,
-100, -101, -101, -102, -103, -102, -104, -104, -105, -106, -106, -107, -107,
-108, -108, -110, -110, -111, -111, -111, -112, -113, -113, -115, -115, -116,
-115, -117, -117, -118, -118, -119, -117, -113, -109, -107, -103, -100, -96,
-93, -90, -87, -83, -80, -77, -74, -71, -67, -64, -60, -57, -54, -51, -48, -44,
-40, -37, -34, -32, -28, -24, -22, -17, -15, -11, -8, -5, -1, };