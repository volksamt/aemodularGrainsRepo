#define DATA_LENGTH 512
#define DATA AKWF_linear_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 12, 15, 19, 22, 24, 28, 31,
34, 37, 41, 43, 45, 46, 49, 51, 53, 55, 57, 58, 61, 62, 64, 66, 69, 71, 72, 75,
78, 78, 81, 83, 85, 87, 88, 91, 93, 95, 97, 99, 101, 103, 105, 108, 109, 111,
114, 115, 113, 114, 114, 113, 111, 112, 111, 110, 109, 110, 109, 109, 108, 108,
107, 106, 107, 107, 106, 105, 105, 104, 104, 104, 103, 103, 102, 103, 102, 101,
100, 100, 100, 100, 98, 98, 99, 98, 99, 99, 99, 99, 98, 98, 98, 99, 99, 99, 98,
98, 99, 99, 99, 99, 99, 98, 98, 99, 99, 98, 98, 99, 98, 99, 99, 99, 99, 99, 99,
99, 99, 99, 99, 99, 99, 100, 100, 100, 100, 100, 100, 101, 100, 100, 102, 102,
102, 102, 102, 103, 103, 103, 103, 103, 104, 104, 104, 105, 104, 104, 105, 105,
105, 105, 106, 107, 106, 107, 107, 106, 106, 106, 105, 105, 105, 105, 104, 104,
104, 105, 104, 103, 103, 103, 102, 102, 101, 102, 102, 101, 100, 100, 100, 100,
100, 99, 100, 99, 99, 98, 98, 98, 97, 96, 97, 97, 96, 97, 98, 98, 98, 98, 99,
99, 98, 99, 99, 99, 99, 100, 101, 101, 101, 100, 101, 101, 102, 102, 102, 102,
103, 103, 103, 104, 104, 104, 104, 104, 105, 105, 105, 106, 103, 98, 95, 91, 86,
82, 78, 74, 71, 67, 62, 59, 55, 50, 46, 42, 38, 34, 30, 25, 21, 18, 13, 9, 6, 2,
-2, -7, -11, -15, -19, -23, -27, -30, -35, -39, -43, -45, -47, -49, -52, -54,
-56, -57, -60, -62, -64, -66, -68, -70, -72, -74, -76, -78, -81, -83, -85, -87,
-89, -91, -93, -96, -97, -99, -102, -103, -105, -108, -109, -112, -115, -116,
-118, -119, -118, -117, -116, -115, -114, -114, -112, -111, -111, -110, -109,
-109, -108, -107, -106, -105, -104, -103, -102, -101, -101, -100, -99, -98, -97,
-96, -96, -95, -95, -93, -92, -91, -90, -89, -89, -89, -88, -90, -90, -92, -92,
-92, -93, -93, -94, -95, -96, -97, -97, -98, -98, -100, -100, -101, -101, -102,
-103, -103, -104, -105, -105, -106, -107, -108, -108, -110, -109, -110, -112,
-111, -112, -112, -114, -112, -114, -112, -113, -112, -112, -112, -111, -111,
-110, -111, -110, -110, -111, -110, -110, -110, -110, -109, -109, -108, -108,
-108, -107, -107, -107, -107, -107, -107, -106, -106, -106, -106, -106, -105,
-105, -105, -105, -106, -106, -107, -107, -107, -108, -107, -107, -108, -108,
-108, -109, -109, -110, -110, -109, -110, -110, -110, -111, -112, -111, -111,
-112, -112, -112, -112, -114, -113, -114, -115, -113, -114, -115, -114, -114,
-113, -112, -111, -109, -108, -107, -106, -105, -104, -104, -102, -101, -101,
-100, -98, -97, -96, -95, -94, -93, -92, -91, -91, -89, -88, -87, -86, -84, -84,
-83, -82, -80, -81, -78, -78, -75, -72, -69, -65, -62, -59, -56, -52, -50, -46,
-43, -39, -36, -33, -30, -27, -23, -21, -17, -14, -11, -8, -4, -1, };