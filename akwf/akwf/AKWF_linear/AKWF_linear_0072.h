#define DATA_LENGTH 512
#define DATA AKWF_linear_0072

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 5, 6, 8, 9, 11, 12, 14, 15,
16, 17, 20, 21, 22, 23, 24, 26, 28, 29, 31, 31, 33, 35, 36, 38, 41, 43, 44, 48,
50, 51, 54, 56, 58, 61, 63, 66, 67, 69, 73, 73, 76, 79, 80, 83, 85, 88, 89, 91,
93, 95, 95, 96, 98, 99, 100, 101, 102, 103, 104, 104, 106, 107, 107, 109, 110,
112, 112, 113, 114, 115, 116, 117, 118, 118, 117, 116, 113, 112, 110, 108, 106,
104, 102, 101, 98, 97, 96, 93, 92, 89, 87, 85, 83, 82, 80, 77, 76, 74, 72, 70,
67, 63, 60, 56, 54, 50, 46, 43, 40, 36, 33, 29, 27, 22, 19, 16, 12, 9, 6, 3, -1,
-4, -8, -11, -14, -16, -16, -17, -17, -18, -19, -20, -21, -21, -22, -22, -22,
-24, -24, -26, -26, -26, -27, -28, -29, -29, -30, -31, -31, -32, -32, -28, -25,
-24, -21, -17, -15, -12, -9, -6, -4, 0, 3, 6, 7, 10, 13, 16, 19, 23, 25, 28, 30,
33, 36, 39, 41, 44, 48, 51, 53, 56, 58, 62, 65, 67, 69, 72, 75, 78, 81, 83, 87,
89, 92, 94, 97, 100, 104, 106, 109, 111, 111, 111, 112, 111, 111, 111, 110, 112,
110, 111, 111, 111, 111, 110, 112, 111, 111, 111, 111, 110, 111, 110, 111, 110,
110, 110, 106, 105, 102, 99, 96, 95, 92, 89, 87, 85, 81, 80, 77, 75, 72, 70, 68,
65, 62, 59, 57, 55, 52, 50, 47, 45, 42, 40, 36, 35, 32, 29, 26, 23, 21, 19, 16,
14, 11, 8, 6, 3, 0, -2, -4, -8, -11, -14, -16, -18, -20, -23, -23, -26, -27,
-28, -30, -31, -33, -34, -37, -37, -39, -41, -42, -43, -45, -47, -48, -50, -52,
-53, -55, -57, -58, -59, -61, -61, -61, -62, -63, -63, -64, -65, -65, -66, -67,
-68, -68, -68, -69, -70, -71, -71, -71, -73, -73, -74, -75, -75, -76, -76, -77,
-77, -77, -77, -77, -77, -78, -77, -79, -79, -79, -79, -79, -79, -79, -80, -80,
-81, -81, -81, -81, -81, -81, -81, -81, -82, -81, -82, -83, -81, -82, -81, -81,
-81, -83, -82, -83, -82, -82, -82, -82, -83, -82, -82, -83, -82, -82, -82, -82,
-83, -82, -81, -82, -82, -82, -82, -82, -82, -82, -81, -82, -82, -81, -82, -81,
-82, -81, -81, -81, -82, -80, -80, -80, -80, -81, -80, -81, -79, -80, -79, -79,
-79, -78, -79, -79, -78, -78, -78, -78, -77, -77, -77, -77, -76, -77, -76, -76,
-76, -76, -75, -76, -75, -74, -74, -74, -74, -73, -72, -71, -70, -71, -70, -70,
-70, -69, -68, -68, -67, -68, -66, -66, -66, -65, -64, -64, -64, -63, -62, -61,
-60, -60, -59, -58, -58, -57, -57, -55, -55, -53, -53, -53, -51, -51, -50, -49,
-48, -48, -47, -46, -45, -45, -44, -42, -42, -41, -38, -37, -35, -33, -32, -30,
-29, -27, -25, -24, -21, -21, -18, -16, -15, -14, -12, -10, -8, -7, -5, -4, -1,
0, };