#define DATA_LENGTH 512
#define DATA AKWF_linear_0084

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 4, 5, 7, 7, 8, 9, 10, 10,
12, 14, 14, 16, 16, 17, 18, 20, 21, 21, 23, 23, 25, 25, 26, 28, 29, 30, 31, 32,
33, 35, 37, 38, 40, 41, 42, 44, 46, 47, 49, 50, 51, 52, 54, 55, 57, 57, 59, 61,
63, 64, 66, 67, 68, 69, 71, 72, 74, 75, 76, 79, 79, 80, 82, 83, 85, 86, 88, 89,
91, 93, 93, 96, 96, 98, 99, 101, 101, 102, 103, 102, 102, 102, 103, 104, 103,
104, 104, 104, 104, 104, 105, 105, 105, 106, 106, 106, 107, 106, 106, 108, 108,
108, 107, 108, 108, 109, 109, 110, 109, 110, 111, 110, 110, 111, 111, 111, 112,
112, 112, 112, 112, 113, 113, 112, 114, 113, 114, 114, 113, 111, 108, 107, 106,
105, 102, 101, 99, 98, 96, 95, 93, 92, 90, 89, 87, 86, 85, 82, 81, 79, 78, 77,
75, 73, 72, 70, 68, 68, 66, 64, 62, 61, 59, 58, 56, 55, 54, 52, 51, 48, 47, 46,
44, 43, 41, 39, 38, 36, 35, 34, 35, 34, 35, 34, 34, 34, 33, 33, 33, 32, 33, 33,
33, 33, 32, 32, 32, 31, 31, 32, 31, 31, 31, 31, 31, 31, 31, 31, 30, 30, 31, 31,
30, 29, 29, 29, 30, 30, 29, 29, 28, 29, 29, 29, 28, 27, 27, 28, 28, 28, 26, 26,
25, 24, 24, 22, 21, 20, 20, 19, 19, 18, 17, 16, 15, 14, 14, 14, 12, 12, 10, 10,
9, 8, 7, 7, 6, 4, 4, 3, 3, 2, 1, 0, -1, -1, -2, -3, -3, -5, -5, -6, -7, -8, -8,
-9, -10, -11, -12, -12, -13, -15, -17, -19, -21, -23, -25, -27, -29, -32, -34,
-36, -37, -39, -42, -44, -45, -48, -50, -52, -54, -56, -59, -61, -62, -65, -67,
-69, -71, -74, -74, -78, -79, -82, -84, -85, -88, -89, -91, -93, -96, -97, -100,
-102, -103, -106, -109, -110, -112, -114, -117, -118, -118, -119, -119, -119,
-118, -118, -118, -119, -118, -119, -118, -118, -118, -117, -117, -117, -118,
-118, -117, -118, -116, -117, -116, -117, -116, -116, -116, -116, -116, -116,
-115, -116, -115, -115, -115, -116, -116, -115, -115, -115, -114, -114, -114,
-113, -114, -113, -114, -114, -114, -114, -114, -113, -111, -110, -108, -106,
-105, -104, -102, -101, -100, -98, -96, -94, -93, -92, -90, -89, -87, -87, -84,
-83, -82, -80, -79, -77, -76, -74, -73, -71, -70, -68, -66, -65, -64, -63, -61,
-59, -57, -57, -55, -54, -52, -50, -49, -48, -46, -45, -43, -42, -41, -38, -38,
-37, -37, -37, -36, -37, -36, -35, -35, -35, -34, -34, -34, -34, -34, -33, -33,
-32, -32, -33, -32, -32, -31, -31, -31, -31, -30, -30, -29, -29, -28, -28, -29,
-28, -28, -27, -28, -27, -27, -27, -27, -26, -25, -25, -25, -25, -24, -24, -23,
-23, -23, -22, -21, -21, -19, -19, -17, -17, -16, -15, -14, -13, -12, -11, -9,
-9, -8, -6, -6, -4, -4, -3, -2, 0, };