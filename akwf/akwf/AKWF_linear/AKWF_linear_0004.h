#define DATA_LENGTH 512
#define DATA AKWF_linear_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 3, 4, 5, 6, 7, 8, 9, 10, 11,
11, 12, 14, 15, 16, 16, 17, 19, 19, 21, 23, 27, 28, 30, 33, 35, 38, 41, 43, 45,
47, 50, 52, 55, 57, 60, 62, 65, 67, 69, 72, 74, 77, 78, 82, 84, 87, 89, 92, 94,
96, 99, 101, 103, 106, 108, 109, 110, 109, 109, 109, 110, 111, 111, 111, 112,
112, 111, 112, 112, 113, 113, 113, 113, 114, 114, 114, 116, 115, 115, 115, 117,
116, 117, 117, 118, 118, 118, 118, 119, 119, 119, 118, 113, 110, 105, 101, 97,
94, 88, 85, 81, 76, 72, 69, 64, 59, 56, 52, 48, 43, 39, 36, 31, 28, 23, 19, 15,
11, 7, 2, -2, -5, -10, -14, -18, -22, -26, -31, -32, -31, -31, -31, -31, -32,
-32, -32, -33, -32, -33, -33, -32, -32, -32, -33, -33, -33, -33, -34, -33, -34,
-34, -34, -33, -34, -34, -33, -34, -35, -34, -34, -35, -35, -34, -35, -36, -36,
-35, -35, -35, -35, -35, -35, -35, -35, -34, -35, -35, -35, -35, -35, -34, -35,
-34, -34, -35, -35, -34, -34, -35, -34, -34, -34, -35, -34, -34, -35, -34, -34,
-34, -34, -33, -34, -33, -34, -33, -32, -33, -32, -32, -31, -30, -30, -30, -30,
-30, -29, -29, -29, -28, -28, -27, -27, -26, -26, -26, -25, -25, -24, -25, -23,
-23, -24, -22, -23, -22, -22, -22, -21, -17, -15, -12, -10, -5, -3, 0, 3, 6, 9,
12, 15, 18, 20, 23, 27, 29, 32, 35, 38, 41, 44, 47, 50, 53, 57, 59, 62, 65, 68,
71, 74, 77, 80, 82, 86, 86, 83, 82, 79, 77, 74, 72, 70, 67, 65, 64, 61, 59, 57,
55, 52, 50, 48, 46, 43, 41, 39, 36, 35, 32, 31, 28, 26, 24, 21, 20, 17, 15, 12,
11, 9, 7, 6, 6, 4, 5, 5, 4, 4, 4, 3, 3, 3, 3, 2, 3, 2, 2, 1, 2, 0, 0, 0, 0, 0,
0, -1, -2, -2, -2, -3, -3, -3, -4, -4, -4, -4, -4, -5, -4, -5, -5, -5, -5, -5,
-6, -6, -6, -6, -7, -6, -6, -6, -6, -6, -6, -7, -6, -6, -6, -7, -8, -7, -8, -7,
-8, -8, -8, -7, -8, -8, -8, -8, -8, -8, -10, -12, -14, -15, -16, -18, -19, -21,
-22, -24, -27, -28, -29, -31, -32, -34, -36, -38, -39, -41, -42, -44, -47, -47,
-49, -51, -53, -54, -56, -57, -60, -61, -63, -64, -66, -68, -69, -67, -66, -65,
-65, -63, -61, -61, -59, -59, -58, -56, -55, -54, -53, -52, -51, -50, -49, -48,
-47, -45, -45, -43, -42, -40, -41, -38, -38, -36, -35, -35, -34, -33, -32, -30,
-29, -29, -28, -28, -27, -27, -27, -27, -26, -26, -26, -25, -25, -24, -23, -23,
-23, -22, -22, -22, -22, -22, -21, -19, -20, -19, -19, -18, -19, -17, -17, -17,
-17, -16, -17, -15, -16, -15, -13, -13, -12, -11, -10, -9, -8, -7, -6, -5, -4,
-3, -2, -2, 0, };