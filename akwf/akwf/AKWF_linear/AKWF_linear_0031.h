#define DATA_LENGTH 512
#define DATA AKWF_linear_0031

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 5, 6, 8, 9, 10, 12, 13, 14,
17, 19, 21, 23, 25, 28, 29, 32, 34, 36, 37, 40, 43, 44, 47, 49, 52, 53, 55, 58,
59, 61, 63, 66, 68, 70, 72, 75, 77, 78, 81, 82, 85, 88, 90, 92, 92, 93, 95, 95,
96, 97, 97, 97, 99, 100, 100, 100, 101, 102, 103, 104, 105, 104, 106, 107, 107,
108, 109, 110, 110, 111, 112, 112, 113, 114, 114, 116, 116, 117, 117, 119, 119,
119, 119, 119, 119, 119, 119, 119, 118, 118, 118, 117, 118, 118, 118, 117, 117,
117, 118, 117, 117, 117, 118, 117, 117, 116, 117, 117, 116, 117, 115, 116, 116,
115, 115, 116, 116, 115, 116, 115, 116, 116, 115, 115, 115, 116, 116, 116, 116,
117, 117, 117, 117, 116, 117, 117, 116, 116, 117, 117, 117, 117, 117, 117, 117,
118, 118, 117, 118, 118, 117, 118, 118, 118, 117, 116, 114, 113, 111, 110, 107,
107, 105, 104, 103, 101, 100, 98, 96, 95, 94, 92, 91, 89, 88, 86, 85, 83, 81,
80, 79, 78, 76, 74, 73, 71, 70, 69, 68, 66, 64, 62, 59, 56, 53, 51, 49, 46, 43,
41, 38, 35, 32, 30, 27, 24, 21, 18, 16, 14, 11, 8, 5, 2, 0, -2, -5, -8, -10,
-13, -16, -18, -21, -24, -27, -29, -32, -34, -34, -35, -36, -38, -38, -39, -40,
-41, -42, -42, -44, -44, -45, -47, -48, -48, -49, -50, -51, -52, -52, -54, -55,
-56, -57, -58, -59, -59, -60, -61, -62, -63, -64, -65, -66, -67, -67, -66, -67,
-66, -67, -66, -66, -65, -65, -65, -65, -65, -66, -64, -64, -64, -64, -63, -63,
-64, -64, -64, -63, -62, -62, -62, -63, -62, -62, -62, -62, -62, -61, -61, -61,
-61, -61, -63, -63, -64, -66, -66, -68, -69, -70, -71, -73, -73, -75, -76, -77,
-78, -79, -80, -82, -83, -83, -85, -86, -87, -88, -89, -91, -92, -92, -93, -95,
-95, -97, -98, -100, -100, -101, -102, -102, -102, -101, -102, -102, -102, -103,
-103, -103, -104, -104, -104, -104, -105, -105, -106, -106, -106, -106, -106,
-107, -106, -107, -107, -107, -108, -108, -108, -108, -108, -108, -109, -109,
-109, -109, -110, -107, -107, -104, -103, -102, -100, -99, -97, -96, -95, -93,
-92, -91, -90, -88, -87, -85, -84, -82, -81, -81, -78, -77, -76, -74, -73, -71,
-70, -68, -67, -66, -65, -64, -61, -61, -59, -59, -58, -58, -59, -59, -59, -58,
-59, -59, -58, -59, -59, -59, -59, -59, -59, -59, -59, -59, -58, -59, -58, -59,
-58, -59, -59, -58, -59, -58, -59, -59, -59, -58, -59, -59, -59, -59, -58, -57,
-56, -56, -56, -55, -55, -53, -53, -52, -52, -51, -50, -49, -49, -48, -48, -47,
-46, -46, -45, -45, -44, -43, -43, -43, -41, -41, -40, -40, -39, -39, -38, -38,
-37, -36, -35, -33, -32, -31, -29, -28, -27, -25, -24, -23, -21, -20, -18, -17,
-15, -13, -13, -11, -11, -8, -8, -6, -4, -4, -1, 0, };