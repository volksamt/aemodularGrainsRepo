#define DATA_LENGTH 512
#define DATA AKWF_linear_0052

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 1, 2, 2, 3, 4, 4, 4, 4, 6, 6,
7, 8, 8, 9, 10, 10, 11, 11, 12, 13, 13, 14, 15, 16, 16, 17, 17, 18, 19, 19, 21,
21, 22, 22, 23, 24, 24, 25, 26, 27, 27, 28, 28, 29, 30, 31, 32, 32, 34, 35, 36,
36, 36, 37, 38, 40, 40, 41, 42, 43, 43, 45, 45, 46, 46, 47, 49, 49, 50, 51, 52,
53, 54, 54, 55, 56, 57, 58, 59, 60, 60, 61, 62, 62, 64, 64, 66, 65, 67, 68, 69,
70, 70, 72, 72, 73, 73, 74, 75, 76, 76, 78, 79, 80, 80, 80, 82, 82, 82, 84, 84,
86, 87, 88, 87, 89, 90, 90, 91, 91, 93, 92, 94, 93, 94, 95, 96, 96, 97, 97, 98,
98, 98, 100, 101, 101, 101, 102, 102, 103, 104, 105, 104, 106, 105, 107, 108,
107, 108, 109, 109, 109, 110, 111, 112, 111, 112, 112, 113, 112, 113, 112, 113,
113, 113, 113, 115, 114, 114, 115, 115, 115, 115, 116, 116, 117, 116, 116, 117,
117, 118, 117, 118, 118, 117, 119, 118, 118, 119, 119, 118, 118, 116, 115, 114,
112, 111, 109, 108, 106, 105, 105, 103, 102, 101, 99, 98, 97, 95, 94, 93, 92,
90, 90, 88, 87, 86, 84, 83, 82, 80, 80, 78, 77, 75, 74, 73, 70, 67, 64, 61, 57,
53, 51, 48, 45, 42, 39, 36, 32, 28, 27, 22, 20, 16, 13, 10, 7, 3, 1, -2, -5, -9,
-12, -14, -17, -21, -24, -28, -31, -34, -36, -40, -42, -43, -46, -47, -51, -52,
-53, -56, -57, -59, -61, -63, -64, -67, -69, -70, -72, -74, -77, -78, -80, -82,
-84, -86, -88, -89, -92, -93, -95, -96, -99, -100, -103, -105, -105, -109, -110,
-110, -110, -110, -111, -110, -112, -112, -112, -112, -112, -111, -112, -112,
-113, -113, -114, -114, -113, -114, -114, -114, -114, -115, -115, -115, -116,
-116, -116, -117, -116, -117, -117, -117, -117, -118, -117, -117, -117, -116,
-116, -115, -116, -115, -114, -113, -113, -114, -113, -112, -112, -111, -110,
-111, -109, -109, -108, -108, -108, -107, -107, -106, -106, -106, -105, -105,
-103, -103, -103, -103, -102, -102, -101, -101, -99, -98, -98, -97, -97, -94,
-94, -93, -92, -91, -91, -89, -90, -88, -86, -86, -86, -83, -83, -82, -81, -80,
-79, -78, -78, -76, -76, -75, -74, -73, -73, -71, -70, -69, -69, -67, -66, -65,
-64, -64, -64, -62, -62, -62, -61, -60, -59, -59, -58, -57, -57, -55, -54, -54,
-53, -52, -51, -52, -50, -49, -49, -48, -47, -46, -46, -45, -44, -44, -43, -43,
-42, -41, -39, -39, -38, -37, -37, -36, -35, -34, -34, -33, -32, -31, -31, -30,
-29, -28, -26, -27, -26, -25, -24, -24, -22, -23, -21, -20, -20, -18, -18, -17,
-17, -16, -14, -15, -14, -13, -11, -11, -11, -11, -10, -10, -10, -9, -9, -8, -7,
-6, -7, -6, -6, -5, -5, -4, -4, -3, -3, -3, -3, -3, -1, -2, 0, 0, };