#define DATA_LENGTH 512
#define DATA AKWF_linear_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 4, 5, 6, 8, 9, 10, 11, 12,
15, 16, 18, 20, 23, 24, 27, 28, 30, 32, 34, 37, 38, 41, 43, 45, 47, 49, 51, 53,
56, 58, 59, 61, 63, 66, 68, 70, 72, 74, 75, 77, 79, 82, 84, 87, 86, 88, 89, 89,
91, 92, 92, 94, 94, 95, 96, 97, 97, 99, 99, 100, 101, 103, 103, 104, 105, 105,
107, 108, 109, 110, 110, 112, 112, 113, 114, 116, 116, 116, 118, 118, 119, 119,
118, 117, 118, 117, 115, 116, 116, 114, 114, 113, 114, 112, 112, 112, 110, 110,
109, 110, 109, 108, 109, 106, 107, 106, 107, 105, 105, 105, 103, 103, 102, 102,
101, 100, 100, 101, 101, 101, 102, 101, 101, 101, 102, 102, 103, 102, 103, 104,
103, 103, 104, 104, 104, 104, 104, 105, 104, 105, 105, 105, 106, 106, 105, 106,
106, 106, 106, 106, 107, 107, 107, 107, 107, 106, 105, 105, 105, 104, 103, 103,
102, 101, 101, 100, 100, 99, 99, 99, 97, 97, 96, 95, 95, 95, 93, 94, 93, 93, 92,
91, 91, 90, 90, 88, 88, 88, 88, 86, 85, 85, 85, 83, 81, 80, 79, 79, 78, 77, 76,
74, 73, 72, 71, 70, 69, 69, 67, 66, 65, 64, 63, 62, 61, 60, 59, 58, 57, 56, 55,
53, 53, 51, 51, 50, 49, 46, 44, 42, 39, 38, 35, 34, 32, 29, 27, 25, 23, 21, 19,
16, 14, 13, 10, 8, 6, 4, 1, 0, -3, -4, -6, -8, -11, -14, -16, -17, -20, -21,
-23, -26, -29, -30, -33, -34, -36, -39, -40, -42, -44, -47, -48, -50, -52, -55,
-56, -57, -60, -63, -65, -67, -68, -71, -73, -74, -76, -78, -80, -82, -85, -87,
-89, -91, -92, -94, -97, -98, -100, -102, -102, -102, -102, -102, -102, -102,
-103, -103, -103, -103, -103, -102, -103, -102, -102, -103, -103, -102, -102,
-103, -103, -102, -102, -102, -103, -102, -103, -102, -102, -103, -102, -102,
-102, -103, -102, -103, -103, -103, -103, -103, -104, -104, -104, -104, -104,
-104, -104, -105, -104, -104, -105, -105, -105, -106, -105, -106, -106, -105,
-106, -106, -106, -107, -107, -107, -107, -108, -108, -108, -107, -108, -108,
-109, -108, -108, -109, -107, -108, -108, -108, -108, -107, -108, -108, -108,
-107, -107, -107, -107, -107, -108, -106, -107, -107, -106, -107, -106, -106,
-106, -106, -106, -106, -106, -106, -106, -107, -106, -106, -105, -105, -106,
-104, -104, -104, -102, -102, -102, -101, -101, -99, -99, -99, -97, -97, -96,
-96, -95, -94, -93, -93, -92, -92, -91, -90, -90, -90, -88, -89, -87, -87, -86,
-86, -84, -85, -84, -82, -82, -82, -79, -77, -76, -74, -73, -71, -70, -69, -67,
-65, -64, -62, -60, -58, -57, -56, -53, -53, -51, -50, -48, -46, -45, -43, -42,
-40, -38, -37, -35, -33, -32, -30, -29, -27, -26, -24, -23, -22, -22, -20, -19,
-18, -18, -16, -16, -14, -13, -13, -12, -10, -9, -9, -8, -6, -6, -5, -4, -3, -2,
-1, 0, };