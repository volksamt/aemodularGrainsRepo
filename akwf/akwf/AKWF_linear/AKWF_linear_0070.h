#define DATA_LENGTH 512
#define DATA AKWF_linear_0070

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 17, 24, 30, 37, 43, 49, 53, 55,
57, 60, 62, 66, 67, 70, 73, 76, 79, 81, 83, 86, 88, 92, 94, 97, 98, 102, 104,
107, 110, 112, 115, 115, 111, 108, 103, 101, 97, 93, 90, 88, 84, 81, 77, 73, 69,
67, 64, 60, 57, 54, 50, 46, 43, 39, 35, 32, 28, 30, 31, 32, 33, 35, 36, 37, 39,
39, 41, 43, 43, 45, 46, 48, 48, 49, 50, 52, 53, 55, 55, 57, 58, 59, 61, 59, 58,
59, 57, 56, 56, 55, 54, 53, 53, 52, 50, 51, 49, 48, 48, 47, 46, 45, 45, 45, 43,
42, 42, 41, 40, 41, 42, 42, 43, 45, 44, 45, 46, 46, 46, 46, 48, 48, 49, 49, 50,
50, 51, 52, 52, 52, 53, 54, 54, 55, 54, 55, 55, 55, 55, 56, 56, 55, 56, 56, 56,
56, 56, 56, 58, 57, 58, 58, 59, 59, 59, 58, 59, 59, 60, 59, 57, 57, 56, 55, 55,
53, 53, 52, 51, 50, 49, 48, 47, 47, 45, 45, 44, 43, 42, 42, 40, 40, 40, 38, 37,
38, 39, 38, 39, 39, 40, 40, 40, 41, 41, 43, 42, 43, 44, 43, 45, 45, 45, 46, 46,
47, 48, 48, 48, 49, 48, 42, 36, 31, 25, 19, 13, 8, 2, -4, -9, -14, -20, -26,
-31, -37, -44, -49, -55, -59, -65, -71, -77, -82, -87, -94, -92, -86, -83, -77,
-73, -67, -63, -58, -53, -49, -44, -40, -35, -30, -25, -21, -16, -10, -6, -2, 3,
8, 13, 16, 22, 26, 27, 29, 30, 32, 33, 35, 35, 37, 39, 39, 42, 43, 45, 45, 48,
49, 50, 52, 53, 54, 56, 57, 58, 60, 62, 60, 54, 49, 44, 39, 33, 28, 23, 18, 13,
7, 2, -3, -8, -13, -18, -24, -28, -33, -39, -44, -50, -54, -59, -65, -69, -68,
-67, -66, -64, -63, -60, -59, -57, -57, -56, -54, -52, -51, -49, -48, -45, -45,
-44, -42, -40, -39, -38, -36, -35, -32, -32, -35, -36, -38, -40, -41, -43, -44,
-46, -49, -49, -51, -53, -54, -56, -58, -59, -61, -63, -64, -66, -67, -69, -71,
-72, -74, -74, -72, -70, -70, -68, -68, -66, -64, -63, -61, -61, -59, -58, -57,
-56, -54, -53, -52, -50, -49, -48, -47, -45, -45, -42, -42, -43, -44, -43, -44,
-45, -46, -46, -47, -47, -48, -48, -49, -49, -50, -51, -52, -51, -53, -52, -53,
-54, -54, -55, -56, -56, -56, -56, -55, -55, -54, -53, -54, -53, -53, -53, -53,
-52, -52, -52, -50, -50, -50, -51, -50, -50, -48, -49, -48, -49, -48, -47, -48,
-47, -48, -47, -48, -47, -47, -47, -47, -48, -48, -48, -47, -47, -47, -48, -48,
-47, -47, -47, -47, -47, -47, -47, -47, -49, -52, -54, -57, -61, -63, -66, -68,
-72, -74, -77, -80, -83, -85, -89, -91, -93, -96, -99, -102, -105, -108, -111,
-114, -116, -119, -113, -107, -100, -93, -87, -81, -74, -67, -61, -53, -47, -40,
-35, -27, -21, -15, -8, -1, };