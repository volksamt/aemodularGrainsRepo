#define DATA_LENGTH 512
#define DATA AKWF_linear_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 8, 11, 14, 17, 19, 21, 24,
26, 28, 29, 30, 33, 33, 35, 37, 38, 39, 42, 43, 45, 46, 47, 48, 51, 53, 54, 56,
57, 59, 60, 62, 64, 65, 66, 68, 70, 71, 73, 75, 76, 77, 80, 81, 81, 80, 78, 76,
73, 72, 70, 68, 66, 64, 62, 61, 58, 57, 55, 53, 50, 48, 46, 45, 43, 41, 40, 36,
35, 34, 31, 29, 27, 25, 24, 21, 19, 17, 15, 13, 11, 10, 13, 15, 17, 19, 20, 22,
23, 25, 27, 28, 30, 32, 33, 35, 37, 38, 40, 42, 43, 45, 47, 48, 50, 52, 53, 55,
57, 58, 60, 63, 63, 65, 67, 69, 70, 71, 71, 70, 68, 68, 67, 65, 64, 64, 62, 61,
60, 59, 58, 56, 55, 55, 53, 52, 51, 50, 48, 47, 46, 45, 43, 43, 42, 40, 38, 39,
37, 36, 35, 34, 32, 32, 28, 25, 21, 17, 12, 8, 4, 0, -5, -8, -13, -16, -20, -24,
-29, -33, -38, -41, -45, -50, -53, -58, -62, -65, -69, -74, -79, -82, -86, -91,
-94, -98, -103, -108, -111, -116, -119, -116, -111, -106, -101, -97, -91, -87,
-83, -78, -74, -68, -64, -58, -54, -50, -45, -41, -36, -31, -27, -21, -16, -12,
-8, -2, 3, 7, 11, 17, 22, 26, 30, 35, 40, 45, 50, 52, 50, 49, 47, 46, 44, 44,
41, 39, 38, 37, 36, 34, 33, 31, 30, 28, 26, 25, 24, 23, 20, 19, 18, 16, 15, 12,
12, 11, 9, 7, 6, 4, 2, 0, 0, -1, -2, -3, -5, -4, -5, -6, -5, -7, -8, -8, -9, -9,
-10, -10, -11, -11, -12, -13, -13, -13, -14, -15, -16, -16, -17, -17, -18, -19,
-19, -20, -20, -21, -22, -22, -22, -24, -24, -22, -19, -18, -17, -14, -13, -10,
-10, -7, -7, -4, -3, 0, 1, 2, 4, 6, 7, 9, 11, 12, 15, 16, 18, 20, 21, 23, 25,
26, 27, 29, 31, 33, 34, 36, 38, 38, 34, 32, 29, 27, 23, 21, 18, 15, 13, 10, 7,
4, 1, -2, -4, -7, -10, -12, -15, -18, -21, -24, -26, -30, -31, -35, -37, -40,
-43, -45, -48, -51, -53, -56, -59, -61, -60, -59, -58, -56, -56, -55, -53, -52,
-51, -49, -48, -46, -46, -45, -43, -42, -41, -39, -39, -37, -35, -35, -33, -32,
-31, -30, -29, -27, -26, -25, -23, -22, -22, -20, -19, -16, -17, -17, -18, -17,
-17, -17, -18, -18, -18, -17, -17, -18, -19, -18, -18, -19, -19, -20, -19, -20,
-20, -19, -19, -20, -21, -20, -21, -20, -21, -21, -21, -22, -21, -21, -21, -21,
-22, -23, -24, -25, -26, -28, -29, -31, -31, -33, -33, -35, -36, -37, -38, -39,
-41, -42, -43, -44, -45, -46, -48, -49, -50, -51, -53, -54, -55, -56, -58, -59,
-60, -61, -63, -63, -65, -64, -62, -59, -57, -54, -52, -49, -47, -45, -42, -40,
-38, -35, -32, -30, -28, -26, -22, -20, -18, -15, -13, -10, -7, -5, -3, -1, };