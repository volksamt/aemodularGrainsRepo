#define DATA_LENGTH 512
#define DATA AKWF_linear_0034

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 12, 16, 19, 22, 25, 28, 31,
35, 38, 40, 41, 42, 44, 45, 46, 48, 49, 51, 52, 53, 54, 56, 57, 59, 60, 61, 62,
64, 65, 65, 68, 69, 71, 71, 73, 74, 75, 77, 79, 80, 81, 83, 84, 84, 86, 87, 87,
87, 87, 87, 86, 87, 86, 87, 86, 87, 87, 86, 87, 86, 86, 87, 86, 86, 85, 85, 86,
86, 86, 85, 86, 86, 86, 86, 86, 86, 86, 85, 85, 85, 85, 85, 85, 84, 84, 85, 85,
85, 85, 84, 86, 86, 86, 85, 85, 85, 86, 86, 87, 86, 87, 86, 86, 86, 87, 87, 87,
87, 88, 87, 87, 88, 88, 87, 87, 87, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88, 88,
89, 89, 89, 90, 89, 89, 89, 90, 89, 89, 90, 89, 89, 90, 90, 90, 91, 90, 91, 91,
91, 90, 91, 91, 91, 91, 91, 91, 91, 88, 85, 83, 80, 78, 76, 73, 70, 67, 66, 63,
60, 58, 55, 54, 50, 47, 46, 43, 41, 39, 36, 32, 30, 29, 25, 23, 20, 18, 16, 13,
11, 8, 7, 3, 0, -2, -6, -9, -13, -16, -20, -23, -26, -29, -32, -35, -39, -42,
-45, -49, -52, -55, -59, -62, -65, -69, -72, -76, -78, -82, -85, -88, -92, -94,
-98, -102, -105, -108, -111, -115, -118, -119, -117, -116, -114, -112, -111,
-108, -107, -105, -103, -101, -100, -97, -97, -94, -93, -91, -90, -87, -85, -84,
-82, -80, -78, -77, -75, -72, -72, -70, -68, -67, -64, -62, -61, -58, -57, -55,
-53, -51, -48, -45, -43, -40, -37, -35, -32, -29, -26, -24, -22, -19, -16, -14,
-11, -9, -5, -4, -1, 1, 4, 7, 9, 11, 14, 17, 20, 22, 25, 28, 30, 33, 36, 39, 39,
36, 32, 29, 26, 23, 19, 16, 12, 10, 6, 2, 0, -5, -7, -11, -14, -17, -20, -24,
-28, -31, -34, -38, -41, -44, -47, -51, -54, -57, -60, -63, -68, -71, -74, -77,
-81, -81, -79, -77, -74, -73, -72, -70, -67, -65, -64, -63, -61, -59, -57, -55,
-54, -51, -50, -48, -46, -45, -42, -40, -40, -37, -35, -34, -32, -30, -29, -26,
-24, -23, -21, -19, -17, -16, -14, -13, -11, -10, -8, -7, -5, -4, -2, -1, 0, 2,
4, 5, 7, 8, 9, 12, 13, 14, 17, 17, 18, 21, 21, 23, 25, 27, 28, 29, 30, 32, 33,
35, 36, 39, 36, 32, 28, 24, 19, 14, 11, 6, 2, -2, -7, -11, -15, -19, -23, -28,
-33, -36, -42, -45, -49, -54, -58, -63, -66, -71, -75, -80, -84, -88, -92, -96,
-101, -105, -110, -114, -118, -116, -115, -115, -113, -112, -112, -110, -109,
-108, -106, -106, -105, -104, -102, -101, -101, -100, -99, -98, -97, -95, -94,
-93, -92, -91, -91, -89, -88, -87, -87, -84, -84, -83, -82, -81, -80, -78, -75,
-72, -68, -65, -62, -58, -55, -52, -48, -45, -42, -39, -35, -33, -30, -26, -23,
-20, -17, -14, -9, -7, -4, -1, };