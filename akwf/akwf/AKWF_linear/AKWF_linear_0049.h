#define DATA_LENGTH 512
#define DATA AKWF_linear_0049

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 12, 16, 21, 24, 28, 33, 36,
40, 45, 48, 51, 52, 54, 56, 58, 59, 63, 64, 66, 67, 70, 72, 74, 75, 77, 79, 82,
84, 85, 86, 89, 90, 93, 95, 97, 99, 101, 102, 105, 107, 108, 110, 112, 114, 116,
118, 118, 114, 110, 107, 103, 98, 94, 91, 86, 84, 80, 75, 72, 68, 65, 60, 56,
53, 49, 45, 42, 38, 34, 30, 27, 22, 19, 15, 11, 6, 3, 0, -5, -8, -12, -15, -19,
-20, -20, -20, -21, -20, -21, -20, -20, -20, -21, -21, -21, -22, -21, -20, -21,
-21, -21, -21, -21, -21, -21, -21, -20, -21, -21, -21, -21, -21, -21, -20, -21,
-21, -21, -21, -21, -20, -17, -14, -11, -8, -5, -1, 2, 5, 9, 11, 14, 17, 21, 23,
27, 31, 34, 37, 40, 42, 46, 50, 52, 56, 59, 62, 64, 68, 71, 74, 77, 80, 84, 87,
90, 94, 92, 89, 86, 84, 80, 77, 74, 71, 68, 66, 61, 59, 56, 53, 49, 47, 45, 41,
37, 34, 31, 29, 25, 23, 19, 16, 13, 9, 7, 4, 1, -2, -5, -9, -10, -13, -16, -17,
-17, -17, -17, -17, -17, -17, -17, -17, -17, -18, -18, -17, -17, -17, -18, -17,
-18, -18, -18, -17, -18, -18, -18, -18, -18, -17, -18, -18, -18, -18, -18, -18,
-19, -18, -18, -18, -18, -18, -17, -16, -16, -15, -15, -16, -14, -14, -14, -13,
-12, -13, -12, -11, -12, -12, -11, -10, -10, -9, -8, -8, -8, -7, -7, -7, -6, -6,
-5, -5, -5, -4, -4, -4, -3, -2, -2, -1, 0, -1, 0, 1, 1, 1, 2, 3, 4, 4, 5, 5, 6,
6, 6, 7, 8, 9, 9, 9, 9, 10, 11, 11, 13, 12, 14, 13, 15, 15, 15, 15, 15, 13, 10,
7, 6, 4, 0, -2, -4, -7, -9, -11, -14, -17, -18, -20, -23, -26, -28, -30, -33,
-35, -38, -39, -42, -44, -47, -49, -52, -54, -56, -59, -62, -64, -65, -68, -71,
-71, -69, -69, -68, -67, -67, -65, -65, -64, -63, -62, -62, -60, -61, -60, -59,
-57, -56, -55, -55, -54, -54, -53, -51, -51, -50, -50, -48, -48, -47, -46, -45,
-44, -43, -43, -43, -41, -37, -34, -31, -28, -25, -21, -18, -14, -11, -7, -5, 0,
2, 5, 8, 11, 15, 18, 21, 25, 29, 31, 34, 38, 41, 44, 48, 51, 54, 58, 61, 63, 68,
72, 74, 78, 76, 71, 68, 63, 59, 55, 51, 48, 43, 40, 36, 31, 27, 23, 20, 15, 12,
7, 3, 0, -4, -8, -11, -16, -20, -24, -29, -32, -36, -40, -44, -48, -52, -56,
-60, -64, -67, -68, -68, -70, -70, -71, -73, -72, -73, -75, -75, -76, -78, -77,
-79, -79, -80, -81, -82, -83, -83, -84, -85, -86, -86, -87, -87, -89, -90, -91,
-92, -91, -93, -94, -94, -95, -96, -93, -90, -86, -82, -78, -74, -70, -66, -62,
-58, -55, -50, -46, -43, -39, -34, -30, -27, -22, -19, -15, -10, -6, -3, };