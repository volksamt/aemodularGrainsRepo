#define DATA_LENGTH 512
#define DATA AKWF_linear_0029

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 4, 5, 5, 7, 8, 9, 10, 10,
11, 12, 13, 15, 16, 18, 19, 21, 22, 22, 24, 25, 27, 28, 29, 31, 31, 33, 35, 35,
36, 37, 39, 40, 42, 43, 45, 45, 47, 48, 49, 50, 52, 53, 54, 55, 57, 58, 59, 60,
61, 62, 64, 65, 66, 66, 68, 69, 70, 71, 73, 74, 74, 76, 77, 78, 79, 80, 81, 82,
83, 85, 86, 87, 88, 89, 90, 91, 92, 94, 95, 96, 97, 98, 98, 99, 99, 100, 100,
101, 102, 102, 102, 103, 104, 104, 105, 105, 106, 107, 107, 108, 108, 109, 109,
109, 111, 111, 112, 112, 112, 113, 113, 113, 114, 114, 116, 115, 117, 116, 117,
117, 117, 117, 117, 116, 116, 116, 116, 115, 116, 116, 115, 115, 116, 115, 116,
115, 116, 115, 114, 114, 115, 114, 115, 114, 114, 114, 114, 113, 114, 114, 114,
114, 114, 114, 113, 113, 112, 111, 110, 109, 109, 108, 108, 106, 105, 105, 104,
103, 101, 101, 101, 100, 98, 97, 97, 97, 95, 94, 93, 93, 92, 91, 91, 89, 89, 88,
88, 86, 85, 84, 84, 83, 81, 80, 78, 77, 76, 75, 73, 72, 71, 69, 69, 67, 66, 64,
63, 62, 61, 59, 59, 57, 55, 54, 52, 52, 50, 49, 47, 46, 45, 44, 42, 42, 41, 39,
37, 36, 34, 33, 32, 30, 28, 26, 26, 24, 22, 21, 19, 18, 16, 15, 13, 12, 11, 8,
7, 6, 5, 2, 1, 0, -1, -3, -5, -6, -8, -10, -11, -12, -13, -16, -17, -18, -20,
-21, -23, -24, -26, -28, -28, -30, -31, -32, -34, -35, -36, -38, -39, -41, -42,
-43, -45, -46, -47, -49, -51, -52, -53, -54, -56, -57, -59, -60, -61, -63, -64,
-66, -67, -69, -70, -70, -72, -73, -74, -75, -76, -76, -78, -79, -81, -81, -82,
-82, -85, -85, -85, -87, -88, -89, -90, -90, -91, -93, -94, -95, -96, -97, -98,
-98, -100, -101, -102, -103, -104, -105, -107, -107, -107, -107, -108, -108,
-109, -109, -109, -109, -110, -110, -110, -111, -111, -111, -112, -112, -113,
-112, -113, -114, -114, -115, -114, -114, -115, -116, -116, -117, -117, -117,
-117, -118, -118, -118, -119, -119, -119, -118, -118, -118, -117, -117, -118,
-117, -116, -115, -115, -115, -115, -115, -114, -114, -114, -113, -113, -112,
-111, -111, -111, -111, -110, -110, -109, -109, -108, -108, -108, -108, -108,
-108, -107, -107, -105, -105, -104, -103, -102, -102, -100, -100, -99, -98, -96,
-97, -94, -94, -93, -92, -92, -91, -90, -89, -88, -87, -87, -85, -85, -83, -82,
-82, -81, -80, -79, -77, -77, -76, -76, -74, -74, -73, -71, -70, -69, -67, -65,
-64, -62, -61, -59, -58, -57, -55, -54, -53, -51, -49, -48, -47, -45, -45, -42,
-41, -40, -39, -36, -35, -34, -32, -31, -29, -28, -27, -25, -25, -23, -22, -21,
-19, -19, -18, -17, -16, -16, -14, -13, -13, -11, -11, -9, -9, -8, -7, -6, -6,
-4, -3, -3, -2, -1, 0, };