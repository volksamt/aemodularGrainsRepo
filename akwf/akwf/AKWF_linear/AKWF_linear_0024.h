#define DATA_LENGTH 512
#define DATA AKWF_linear_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 9, 12, 15, 18, 20, 23, 25,
28, 31, 33, 37, 39, 41, 44, 47, 50, 52, 55, 58, 60, 62, 66, 68, 71, 74, 77, 78,
82, 85, 86, 90, 92, 93, 93, 93, 92, 93, 93, 93, 93, 93, 94, 94, 94, 94, 94, 94,
94, 94, 94, 95, 95, 95, 94, 95, 95, 95, 95, 95, 95, 96, 96, 96, 97, 96, 97, 96,
97, 94, 88, 83, 77, 71, 65, 60, 53, 47, 42, 36, 30, 23, 18, 12, 6, 0, -6, -12,
-17, -24, -30, -35, -41, -48, -53, -59, -65, -71, -76, -82, -88, -94, -101,
-106, -111, -117, -114, -109, -105, -100, -96, -91, -87, -82, -76, -71, -67,
-63, -58, -54, -47, -43, -38, -34, -29, -25, -20, -15, -11, -6, -1, 3, 8, 13,
18, 23, 28, 32, 36, 41, 46, 51, 55, 55, 56, 57, 59, 59, 60, 61, 61, 63, 64, 65,
65, 67, 67, 69, 69, 70, 71, 72, 72, 73, 75, 76, 76, 78, 78, 80, 79, 81, 82, 82,
83, 84, 85, 86, 87, 83, 77, 72, 66, 60, 54, 49, 44, 38, 32, 26, 20, 15, 10, 3,
-2, -8, -13, -19, -25, -30, -36, -42, -47, -53, -59, -64, -69, -76, -81, -87,
-93, -98, -105, -109, -115, -119, -118, -115, -113, -111, -108, -107, -104,
-101, -100, -97, -95, -92, -91, -88, -86, -85, -82, -79, -77, -75, -72, -69,
-68, -65, -64, -61, -59, -56, -54, -52, -49, -48, -45, -44, -41, -39, -37, -36,
-35, -34, -32, -32, -30, -29, -28, -27, -26, -24, -23, -22, -21, -20, -19, -17,
-16, -15, -15, -13, -12, -10, -9, -8, -7, -6, -4, -3, -3, -1, -1, 1, 2, 4, 5, 5,
5, 5, 5, 4, 5, 5, 6, 6, 5, 5, 6, 6, 6, 5, 5, 6, 6, 6, 7, 6, 6, 7, 7, 6, 7, 7, 7,
7, 7, 7, 7, 7, 6, 7, 7, 7, 7, 7, 7, 7, 7, 6, 7, 7, 7, 7, 6, 6, 6, 6, 6, 6, 6, 6,
6, 5, 5, 5, 6, 5, 5, 5, 5, 5, 5, 4, 5, 4, 4, 5, 4, 4, 3, 2, 3, 2, 1, 0, -1, 0,
-1, -1, -3, -4, -4, -5, -4, -6, -6, -7, -8, -8, -9, -9, -10, -11, -11, -12, -13,
-13, -14, -15, -15, -17, -17, -16, -18, -18, -18, -19, -19, -19, -20, -20, -20,
-21, -21, -21, -21, -21, -21, -22, -23, -22, -22, -23, -23, -24, -23, -24, -24,
-25, -25, -24, -24, -26, -26, -26, -25, -26, -26, -27, -27, -27, -27, -28, -27,
-27, -27, -26, -26, -26, -25, -24, -25, -25, -25, -24, -25, -24, -23, -23, -23,
-23, -23, -23, -22, -22, -21, -21, -22, -22, -21, -21, -20, -21, -20, -20, -19,
-19, -19, -19, -19, -18, -18, -17, -17, -16, -17, -16, -15, -16, -15, -15, -14,
-15, -13, -13, -12, -12, -12, -12, -11, -11, -10, -9, -9, -9, -9, -8, -8, -8,
-8, -7, -7, -6, -6, -6, -3, -1, };