#define DATA_LENGTH 512
#define DATA AKWF_linear_0044

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 7, 9, 12, 14, 18, 20, 23, 25,
29, 31, 33, 35, 38, 40, 41, 43, 46, 48, 51, 53, 55, 57, 59, 62, 64, 66, 68, 70,
73, 74, 78, 80, 81, 84, 86, 88, 90, 93, 94, 97, 99, 101, 104, 106, 109, 110,
110, 108, 107, 105, 103, 102, 99, 98, 97, 96, 93, 92, 90, 88, 87, 85, 83, 81,
79, 78, 76, 75, 73, 71, 69, 67, 66, 64, 63, 61, 59, 58, 56, 54, 52, 51, 50, 49,
50, 51, 52, 52, 52, 53, 54, 54, 54, 55, 55, 55, 56, 56, 57, 57, 58, 58, 59, 58,
59, 60, 61, 61, 61, 61, 62, 63, 63, 63, 63, 65, 66, 65, 66, 66, 65, 65, 65, 64,
64, 64, 62, 62, 62, 61, 61, 60, 60, 60, 60, 59, 58, 58, 57, 57, 56, 56, 55, 55,
55, 54, 53, 53, 53, 52, 52, 51, 51, 50, 50, 49, 47, 43, 39, 37, 33, 30, 26, 23,
19, 16, 13, 9, 7, 3, 0, -4, -7, -11, -13, -17, -21, -24, -27, -30, -33, -38,
-40, -44, -47, -50, -54, -56, -59, -64, -67, -70, -71, -69, -67, -65, -64, -61,
-60, -59, -56, -55, -53, -51, -49, -48, -44, -44, -41, -40, -37, -36, -34, -32,
-31, -29, -27, -25, -23, -21, -19, -17, -16, -14, -13, -10, -8, -6, -5, -4, -5,
-4, -4, -4, -4, -4, -4, -4, -5, -4, -4, -4, -5, -3, -4, -4, -4, -4, -4, -4, -4,
-4, -3, -3, -4, -4, -3, -4, -4, -4, -4, -4, -5, -3, -4, -3, -4, -3, -4, -4, -3,
-4, -4, -4, -3, -3, -4, -3, -4, -4, -4, -4, -3, -4, -4, -3, -4, -4, -4, -3, -4,
-3, -4, -4, -3, -3, -4, -4, -3, -3, -3, -4, -2, 2, 4, 6, 10, 12, 16, 18, 21, 24,
27, 29, 31, 34, 38, 40, 43, 45, 49, 52, 54, 56, 60, 63, 65, 68, 71, 73, 76, 79,
82, 84, 86, 90, 92, 96, 97, 94, 91, 87, 85, 81, 78, 74, 71, 69, 66, 62, 59, 56,
53, 50, 47, 43, 40, 37, 33, 31, 27, 24, 21, 18, 15, 12, 9, 5, 2, -1, -4, -8,
-11, -13, -16, -20, -22, -26, -28, -32, -34, -37, -38, -43, -45, -47, -50, -52,
-56, -58, -61, -65, -67, -69, -72, -75, -77, -80, -83, -86, -89, -92, -94, -97,
-100, -103, -105, -108, -111, -115, -117, -119, -119, -119, -118, -119, -119,
-119, -118, -119, -118, -119, -119, -118, -118, -117, -118, -117, -117, -118,
-117, -117, -117, -117, -117, -117, -117, -117, -117, -116, -116, -116, -116,
-116, -116, -116, -116, -117, -116, -113, -113, -111, -110, -108, -107, -106,
-104, -103, -102, -101, -99, -98, -96, -95, -94, -92, -91, -90, -88, -88, -86,
-84, -83, -81, -80, -78, -77, -76, -75, -74, -73, -71, -71, -69, -66, -65, -61,
-59, -57, -54, -51, -48, -46, -43, -41, -37, -36, -32, -30, -28, -25, -22, -19,
-16, -14, -12, -9, -5, -4, -1, };