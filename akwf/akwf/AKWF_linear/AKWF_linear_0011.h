#define DATA_LENGTH 512
#define DATA AKWF_linear_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 8, 12, 17, 20, 24, 27, 31, 35,
39, 43, 46, 50, 51, 53, 54, 55, 55, 56, 57, 58, 59, 60, 60, 61, 62, 63, 64, 65,
66, 66, 66, 68, 68, 69, 71, 71, 73, 73, 74, 74, 76, 77, 78, 79, 79, 79, 80, 81,
82, 83, 83, 83, 82, 82, 82, 82, 82, 82, 83, 82, 83, 83, 83, 82, 83, 82, 83, 82,
82, 83, 82, 83, 82, 83, 82, 82, 83, 83, 82, 82, 82, 81, 83, 82, 82, 80, 76, 74,
71, 68, 64, 61, 57, 55, 51, 49, 44, 42, 39, 36, 32, 28, 25, 22, 20, 17, 13, 10,
7, 4, 0, -3, -6, -9, -12, -15, -19, -23, -25, -28, -31, -35, -36, -38, -41, -42,
-44, -46, -48, -50, -53, -54, -56, -59, -59, -62, -64, -66, -68, -70, -72, -74,
-76, -77, -81, -81, -83, -86, -87, -90, -92, -94, -96, -97, -100, -101, -103,
-106, -105, -101, -100, -96, -93, -90, -88, -85, -82, -80, -77, -73, -71, -67,
-65, -61, -59, -56, -53, -51, -48, -44, -42, -39, -37, -33, -30, -27, -24, -22,
-19, -16, -13, -11, -8, -4, -1, 2, 3, 6, 8, 11, 13, 16, 19, 21, 24, 26, 28, 31,
34, 36, 38, 42, 45, 47, 49, 52, 54, 56, 59, 61, 64, 67, 69, 72, 75, 77, 80, 82,
85, 87, 89, 91, 89, 86, 84, 82, 80, 78, 76, 73, 71, 69, 68, 65, 63, 62, 59, 57,
55, 52, 50, 48, 46, 44, 41, 40, 38, 36, 34, 32, 29, 27, 25, 23, 21, 19, 17, 15,
13, 14, 14, 13, 13, 12, 12, 12, 11, 11, 11, 10, 10, 10, 10, 9, 9, 8, 9, 8, 7, 6,
6, 6, 7, 6, 5, 5, 5, 5, 4, 4, 4, 2, 2, 2, 3, 6, 8, 9, 13, 16, 17, 21, 22, 25,
28, 30, 33, 36, 38, 40, 43, 46, 49, 50, 53, 56, 58, 60, 63, 66, 68, 71, 73, 76,
79, 81, 84, 85, 89, 92, 93, 93, 91, 89, 86, 85, 82, 80, 78, 76, 74, 72, 69, 67,
66, 63, 61, 59, 57, 54, 54, 50, 48, 46, 44, 42, 40, 38, 36, 34, 31, 29, 28, 25,
24, 21, 19, 17, 14, 10, 8, 6, 2, 0, -2, -6, -8, -11, -14, -18, -19, -23, -26,
-29, -32, -34, -37, -40, -42, -45, -48, -50, -53, -57, -58, -62, -64, -67, -70,
-73, -76, -79, -81, -85, -86, -87, -88, -89, -90, -90, -92, -92, -94, -94, -95,
-96, -97, -99, -99, -99, -101, -102, -102, -104, -104, -105, -106, -107, -107,
-109, -110, -110, -112, -112, -113, -115, -116, -116, -117, -118, -119, -118,
-117, -116, -115, -115, -114, -112, -112, -111, -110, -109, -108, -108, -107,
-106, -105, -104, -104, -103, -102, -100, -100, -99, -99, -98, -97, -96, -95,
-94, -93, -92, -91, -90, -89, -88, -87, -86, -81, -78, -74, -71, -67, -63, -60,
-55, -52, -48, -44, -40, -37, -33, -29, -25, -22, -18, -15, -10, -6, -2, };