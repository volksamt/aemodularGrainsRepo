#define DATA_LENGTH 512
#define DATA AKWF_linear_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 7, 8, 10, 12, 13, 15, 17, 19,
21, 23, 24, 26, 27, 29, 30, 33, 35, 38, 39, 41, 44, 46, 49, 51, 53, 56, 58, 60,
62, 65, 67, 68, 71, 74, 76, 78, 80, 83, 86, 88, 90, 92, 95, 97, 99, 101, 104,
106, 108, 110, 112, 115, 116, 117, 117, 117, 116, 116, 116, 116, 116, 116, 116,
116, 116, 115, 116, 116, 116, 115, 116, 116, 116, 116, 116, 116, 116, 116, 115,
115, 115, 115, 115, 116, 116, 116, 116, 115, 114, 115, 114, 114, 115, 114, 113,
113, 113, 112, 111, 111, 112, 112, 111, 110, 111, 110, 110, 109, 109, 109, 109,
109, 108, 108, 108, 107, 107, 107, 107, 106, 106, 106, 105, 105, 105, 105, 104,
104, 105, 105, 106, 105, 106, 105, 106, 106, 107, 106, 107, 106, 107, 107, 106,
107, 107, 107, 107, 107, 107, 107, 108, 108, 108, 107, 108, 108, 109, 109, 108,
108, 108, 109, 109, 108, 106, 106, 105, 104, 103, 102, 101, 101, 100, 98, 98,
97, 95, 96, 94, 93, 93, 92, 91, 90, 88, 88, 87, 86, 85, 84, 83, 82, 81, 81, 79,
79, 78, 77, 76, 75, 73, 73, 71, 70, 68, 67, 66, 65, 63, 62, 60, 59, 58, 57, 56,
54, 53, 52, 51, 49, 48, 46, 45, 44, 43, 41, 39, 38, 38, 36, 35, 34, 33, 31, 30,
29, 27, 26, 24, 23, 21, 20, 19, 16, 16, 14, 12, 11, 10, 9, 6, 6, 4, 3, 2, 0, -1,
-3, -4, -5, -7, -9, -10, -12, -13, -15, -16, -18, -19, -20, -21, -24, -25, -28,
-31, -32, -34, -36, -39, -41, -44, -45, -47, -50, -52, -54, -56, -58, -61, -63,
-66, -68, -70, -72, -75, -76, -79, -81, -82, -85, -87, -90, -92, -94, -97, -99,
-101, -103, -105, -105, -106, -106, -106, -106, -107, -107, -108, -108, -110,
-110, -110, -110, -110, -110, -111, -111, -112, -112, -112, -113, -113, -114,
-114, -115, -115, -115, -116, -116, -117, -117, -118, -118, -118, -119, -119,
-119, -118, -118, -117, -117, -117, -116, -116, -116, -115, -115, -114, -114,
-114, -114, -113, -112, -113, -111, -111, -111, -111, -110, -110, -109, -109,
-109, -108, -108, -107, -106, -107, -106, -107, -105, -105, -104, -105, -104,
-105, -105, -105, -105, -106, -105, -106, -106, -105, -105, -106, -105, -105,
-106, -106, -105, -106, -106, -106, -105, -107, -107, -107, -107, -107, -107,
-107, -107, -108, -108, -107, -106, -107, -107, -107, -106, -106, -106, -106,
-104, -103, -104, -102, -102, -101, -101, -100, -100, -100, -99, -99, -98, -97,
-97, -96, -96, -95, -94, -94, -93, -94, -93, -92, -92, -91, -89, -89, -89, -89,
-88, -87, -86, -85, -83, -81, -80, -78, -76, -76, -74, -73, -70, -69, -67, -66,
-64, -62, -60, -59, -58, -57, -55, -54, -52, -51, -48, -47, -46, -44, -43, -40,
-39, -37, -37, -35, -33, -32, -30, -28, -27, -25, -23, -21, -19, -18, -15, -15,
-13, -11, -9, -7, -5, -4, -1, 0, };