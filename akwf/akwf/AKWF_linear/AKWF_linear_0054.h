#define DATA_LENGTH 512
#define DATA AKWF_linear_0054

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 6, 8, 10, 12, 13, 14, 15, 15,
17, 18, 18, 20, 22, 22, 24, 24, 26, 26, 28, 28, 30, 31, 32, 34, 33, 35, 36, 37,
38, 39, 40, 41, 42, 43, 45, 45, 46, 48, 48, 49, 50, 50, 48, 49, 49, 49, 49, 49,
49, 48, 48, 49, 49, 48, 48, 49, 47, 47, 48, 48, 48, 48, 47, 48, 48, 47, 47, 47,
47, 47, 47, 47, 48, 47, 46, 47, 47, 47, 46, 47, 46, 46, 46, 46, 46, 46, 46, 45,
45, 46, 46, 45, 45, 44, 45, 44, 44, 45, 45, 44, 44, 44, 44, 45, 44, 44, 44, 44,
44, 43, 43, 44, 44, 43, 44, 43, 45, 45, 45, 45, 45, 45, 46, 46, 46, 47, 47, 47,
48, 47, 47, 48, 48, 49, 48, 49, 49, 49, 49, 49, 50, 50, 50, 51, 51, 51, 51, 52,
53, 52, 51, 51, 50, 50, 48, 49, 49, 48, 48, 47, 47, 45, 45, 45, 44, 43, 43, 43,
42, 42, 41, 40, 41, 40, 39, 39, 38, 38, 37, 36, 36, 35, 35, 34, 34, 33, 32, 32,
30, 30, 28, 27, 27, 25, 24, 23, 22, 21, 19, 19, 19, 17, 16, 15, 14, 12, 11, 11,
10, 9, 7, 6, 5, 4, 2, 2, 1, 0, -1, -2, -3, -4, -5, -7, -7, -8, -9, -11, -11,
-12, -13, -15, -16, -17, -19, -19, -20, -21, -22, -23, -25, -26, -27, -28, -29,
-29, -30, -32, -33, -34, -34, -36, -37, -38, -39, -41, -42, -42, -43, -43, -43,
-43, -44, -44, -44, -44, -44, -43, -44, -44, -44, -44, -44, -44, -44, -43, -44,
-44, -44, -43, -44, -44, -43, -44, -44, -44, -44, -44, -44, -44, -44, -44, -45,
-44, -43, -44, -43, -43, -41, -41, -40, -41, -39, -39, -39, -37, -36, -36, -35,
-35, -34, -34, -33, -33, -33, -31, -31, -30, -29, -29, -28, -28, -26, -26, -25,
-25, -24, -24, -23, -22, -22, -22, -20, -17, -16, -14, -13, -11, -9, -7, -5, -3,
-1, 0, 2, 4, 6, 7, 9, 11, 13, 15, 17, 18, 20, 22, 24, 26, 27, 30, 32, 33, 35,
36, 39, 40, 42, 44, 45, 45, 44, 43, 42, 40, 39, 38, 38, 36, 35, 34, 33, 32, 31,
30, 29, 28, 26, 26, 24, 23, 22, 21, 21, 19, 18, 17, 15, 14, 14, 12, 12, 11, 10,
8, 7, 5, 1, -2, -6, -9, -13, -16, -19, -23, -26, -30, -33, -37, -40, -44, -47,
-51, -53, -57, -61, -63, -68, -71, -74, -78, -82, -85, -88, -91, -95, -99, -102,
-105, -109, -112, -116, -119, -119, -116, -115, -113, -111, -109, -108, -105,
-103, -102, -100, -98, -97, -96, -93, -91, -89, -88, -86, -84, -83, -80, -79,
-77, -76, -73, -72, -71, -69, -67, -65, -62, -61, -59, -58, -56, -54, -53, -50,
-48, -47, -45, -43, -42, -40, -38, -36, -35, -33, -31, -30, -27, -25, -24, -21,
-20, -18, -16, -15, -13, -11, -9, -8, -5, -4, -2, -1, };