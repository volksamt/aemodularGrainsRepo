#define DATA_LENGTH 512
#define DATA AKWF_linear_0035

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 7, 9, 11, 14, 16, 18, 21, 23,
25, 26, 30, 31, 34, 35, 38, 40, 42, 42, 41, 41, 42, 41, 41, 41, 41, 41, 42, 41,
40, 41, 41, 41, 41, 41, 40, 40, 40, 41, 40, 40, 40, 40, 40, 40, 39, 39, 39, 39,
40, 39, 39, 38, 39, 39, 40, 40, 41, 41, 42, 42, 43, 43, 44, 45, 45, 45, 46, 47,
48, 48, 49, 49, 50, 51, 51, 51, 51, 52, 52, 53, 53, 54, 54, 55, 56, 56, 57, 57,
58, 58, 57, 57, 57, 58, 56, 56, 56, 55, 55, 55, 55, 54, 54, 53, 53, 52, 52, 51,
52, 51, 51, 50, 50, 50, 49, 48, 48, 48, 47, 48, 47, 47, 46, 46, 46, 45, 45, 44,
44, 44, 43, 43, 43, 42, 42, 42, 41, 42, 40, 41, 41, 40, 40, 38, 38, 39, 39, 37,
37, 37, 37, 36, 36, 36, 35, 36, 35, 35, 34, 34, 34, 34, 34, 30, 25, 22, 18, 13,
10, 5, 1, -2, -7, -11, -15, -20, -23, -28, -31, -35, -40, -43, -48, -52, -56,
-59, -64, -68, -72, -76, -80, -83, -88, -92, -96, -100, -104, -109, -112, -114,
-115, -114, -113, -112, -111, -111, -110, -109, -108, -107, -106, -105, -105,
-104, -103, -103, -102, -101, -101, -99, -98, -98, -96, -96, -96, -94, -94, -93,
-92, -91, -90, -90, -89, -88, -88, -86, -85, -80, -77, -72, -69, -66, -63, -59,
-56, -51, -48, -45, -41, -38, -34, -31, -28, -24, -21, -17, -13, -10, -7, -3, 1,
5, 8, 12, 14, 18, 22, 26, 29, 33, 36, 40, 43, 43, 43, 45, 45, 46, 46, 47, 47,
48, 48, 49, 50, 49, 51, 52, 51, 53, 53, 54, 54, 55, 55, 57, 56, 57, 57, 58, 59,
59, 59, 60, 60, 61, 62, 62, 62, 62, 57, 54, 50, 48, 43, 40, 37, 32, 29, 26, 22,
19, 15, 11, 8, 4, 1, -3, -7, -10, -14, -17, -20, -24, -27, -31, -34, -38, -41,
-44, -49, -53, -55, -60, -63, -66, -62, -59, -56, -51, -47, -44, -41, -36, -33,
-29, -25, -23, -19, -16, -10, -7, -4, -1, 4, 8, 11, 15, 18, 22, 26, 29, 33, 37,
40, 43, 47, 51, 55, 59, 62, 67, 68, 67, 66, 64, 64, 64, 62, 61, 61, 59, 59, 58,
57, 57, 55, 55, 53, 52, 51, 50, 50, 49, 48, 46, 46, 45, 44, 44, 43, 41, 40, 39,
39, 38, 37, 36, 36, 32, 27, 23, 19, 14, 10, 6, 2, -3, -7, -11, -15, -19, -23,
-27, -31, -36, -41, -45, -49, -53, -57, -62, -66, -70, -75, -79, -83, -88, -91,
-95, -100, -105, -108, -112, -117, -118, -116, -115, -113, -110, -108, -105,
-103, -101, -99, -96, -95, -92, -90, -87, -85, -83, -82, -79, -77, -74, -73,
-70, -68, -65, -64, -62, -59, -56, -54, -52, -50, -48, -45, -43, -41, -39, -36,
-34, -32, -30, -27, -25, -23, -21, -19, -17, -15, -13, -10, -8, -5, -5, -1, };