#define DATA_LENGTH 512
#define DATA AKWF_linear_0027

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 7, 8, 10, 12, 13, 15, 16, 18,
19, 22, 23, 25, 27, 30, 32, 35, 37, 40, 42, 46, 48, 50, 52, 56, 58, 61, 63, 66,
68, 71, 74, 76, 79, 82, 84, 87, 90, 92, 95, 98, 99, 103, 106, 109, 110, 113,
116, 118, 118, 113, 109, 104, 99, 95, 90, 86, 81, 77, 73, 67, 63, 59, 54, 49,
44, 40, 36, 31, 26, 22, 17, 13, 8, 4, -1, -5, -10, -15, -19, -23, -28, -32, -37,
-42, -46, -47, -47, -45, -45, -45, -44, -44, -43, -43, -43, -41, -41, -41, -40,
-40, -40, -38, -38, -37, -37, -37, -36, -35, -35, -36, -34, -34, -34, -33, -32,
-32, -31, -30, -30, -30, -29, -28, -28, -28, -27, -26, -25, -25, -25, -24, -24,
-22, -22, -22, -21, -20, -20, -19, -18, -18, -18, -16, -15, -15, -14, -14, -14,
-13, -12, -11, -11, -11, -10, -9, -9, -8, -8, -7, -7, -9, -9, -10, -12, -12,
-13, -13, -15, -16, -16, -17, -17, -18, -20, -21, -22, -22, -23, -23, -25, -26,
-26, -27, -28, -30, -30, -31, -31, -33, -33, -35, -35, -36, -37, -38, -38, -35,
-34, -31, -29, -25, -24, -22, -19, -16, -13, -11, -9, -6, -4, -2, 1, 4, 6, 9,
11, 14, 16, 18, 20, 23, 25, 27, 30, 32, 35, 37, 40, 42, 45, 47, 49, 50, 48, 46,
45, 44, 42, 41, 39, 39, 36, 35, 35, 32, 30, 30, 28, 27, 25, 24, 22, 22, 19, 18,
17, 16, 14, 13, 11, 10, 9, 7, 6, 4, 2, 1, 0, -1, -1, 0, 2, 3, 3, 4, 7, 7, 8, 10,
10, 11, 13, 13, 16, 16, 17, 18, 19, 20, 21, 22, 23, 25, 25, 27, 28, 28, 30, 30,
32, 33, 34, 35, 36, 38, 36, 35, 34, 33, 31, 29, 28, 26, 26, 24, 22, 20, 20, 19,
17, 15, 15, 13, 11, 9, 8, 7, 5, 4, 2, 1, 0, -3, -3, -4, -6, -8, -9, -10, -12,
-13, -15, -15, -16, -17, -16, -17, -18, -18, -18, -18, -19, -19, -20, -20, -21,
-21, -21, -22, -23, -23, -23, -23, -24, -25, -24, -26, -26, -26, -27, -27, -28,
-27, -28, -29, -29, -29, -30, -31, -30, -29, -28, -28, -27, -26, -26, -25, -25,
-24, -24, -23, -22, -22, -21, -21, -20, -20, -19, -18, -17, -17, -15, -16, -16,
-14, -13, -14, -13, -12, -11, -11, -10, -10, -8, -8, -9, -8, -10, -10, -10, -10,
-10, -10, -11, -12, -12, -12, -13, -13, -12, -14, -13, -15, -14, -15, -15, -15,
-16, -16, -16, -17, -17, -17, -17, -18, -18, -19, -19, -18, -19, -20, -19, -20,
-21, -21, -23, -22, -23, -23, -23, -23, -24, -25, -26, -25, -27, -27, -28, -27,
-28, -28, -29, -29, -30, -30, -31, -31, -31, -31, -33, -33, -33, -34, -34, -35,
-35, -35, -36, -35, -33, -31, -30, -27, -27, -25, -23, -21, -20, -18, -16, -14,
-13, -12, -10, -9, -7, -6, -3, -2, -1, };