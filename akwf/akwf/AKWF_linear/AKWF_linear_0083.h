#define DATA_LENGTH 512
#define DATA AKWF_linear_0083

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 5, 7, 10, 11, 13, 15, 15, 17,
19, 21, 23, 24, 26, 27, 30, 30, 33, 34, 36, 37, 39, 40, 42, 44, 46, 48, 49, 50,
51, 53, 55, 56, 58, 58, 60, 62, 64, 65, 66, 68, 68, 70, 71, 73, 74, 75, 76, 78,
79, 81, 82, 83, 85, 86, 88, 89, 90, 92, 93, 95, 96, 97, 99, 100, 101, 103, 105,
106, 106, 108, 110, 111, 112, 114, 116, 116, 118, 117, 115, 112, 110, 107, 104,
102, 99, 97, 94, 91, 90, 87, 85, 82, 80, 77, 75, 72, 70, 67, 65, 62, 60, 57, 54,
52, 49, 48, 44, 42, 39, 37, 35, 33, 30, 27, 25, 23, 19, 17, 15, 13, 10, 7, 5, 2,
0, -3, -6, -8, -10, -8, -7, -6, -5, -4, -4, -3, -2, -1, 0, 1, 2, 2, 4, 4, 4, 6,
6, 7, 9, 9, 10, 11, 12, 13, 13, 14, 15, 16, 17, 18, 20, 20, 21, 21, 23, 23, 24,
24, 26, 26, 27, 28, 28, 30, 31, 32, 32, 34, 34, 36, 37, 39, 41, 41, 43, 45, 47,
49, 50, 52, 54, 55, 57, 59, 60, 62, 63, 64, 67, 68, 70, 72, 74, 74, 77, 78, 81,
82, 83, 85, 86, 88, 90, 92, 92, 95, 96, 98, 99, 102, 103, 105, 107, 107, 109,
112, 113, 115, 117, 118, 119, 117, 114, 110, 109, 105, 103, 100, 97, 94, 91, 88,
85, 83, 80, 77, 75, 71, 68, 66, 63, 60, 57, 54, 52, 49, 46, 43, 41, 39, 35, 32,
29, 27, 23, 21, 19, 16, 13, 11, 8, 5, 2, 0, -4, -6, -9, -12, -15, -18, -21, -24,
-24, -26, -27, -29, -29, -31, -31, -33, -34, -35, -36, -37, -38, -39, -40, -42,
-43, -44, -45, -46, -47, -48, -49, -51, -51, -53, -55, -55, -56, -57, -59, -60,
-61, -62, -63, -65, -65, -66, -67, -69, -70, -71, -72, -73, -75, -76, -76, -78,
-79, -79, -81, -81, -82, -82, -82, -81, -81, -81, -82, -82, -81, -82, -83, -82,
-83, -82, -83, -82, -83, -82, -83, -82, -83, -83, -83, -84, -84, -83, -84, -84,
-84, -84, -84, -84, -83, -85, -85, -85, -85, -85, -85, -85, -85, -85, -85, -85,
-86, -86, -85, -86, -85, -86, -86, -85, -86, -85, -85, -86, -85, -85, -86, -85,
-85, -85, -85, -85, -84, -85, -85, -85, -85, -85, -85, -85, -85, -84, -84, -84,
-84, -84, -83, -84, -84, -84, -84, -84, -84, -84, -85, -84, -83, -83, -84, -84,
-83, -84, -83, -83, -83, -83, -83, -83, -83, -83, -81, -80, -80, -79, -78, -77,
-76, -76, -75, -74, -73, -72, -71, -70, -69, -69, -68, -66, -66, -65, -65, -63,
-62, -61, -61, -60, -59, -57, -57, -57, -56, -55, -53, -52, -52, -51, -51, -48,
-48, -47, -47, -46, -45, -44, -43, -42, -41, -40, -40, -39, -38, -36, -35, -33,
-30, -29, -27, -25, -23, -23, -21, -20, -18, -16, -15, -12, -11, -9, -8, -6, -4,
-2, 0, };