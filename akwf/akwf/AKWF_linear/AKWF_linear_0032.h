#define DATA_LENGTH 512
#define DATA AKWF_linear_0032

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 12, 16, 18, 22, 24, 26,
29, 33, 35, 37, 39, 42, 44, 46, 49, 51, 54, 56, 58, 61, 63, 65, 69, 70, 72, 75,
78, 80, 81, 84, 87, 89, 92, 94, 97, 98, 101, 103, 105, 108, 111, 113, 116, 117,
116, 116, 115, 115, 114, 114, 113, 113, 112, 112, 111, 111, 110, 109, 109, 108,
107, 107, 107, 105, 106, 105, 105, 104, 104, 103, 102, 101, 101, 100, 100, 99,
99, 99, 97, 97, 95, 93, 91, 88, 85, 83, 80, 78, 76, 73, 70, 68, 65, 62, 59, 57,
55, 52, 50, 47, 45, 41, 39, 37, 34, 31, 29, 27, 24, 22, 20, 16, 14, 12, 9, 7, 5,
6, 8, 11, 13, 14, 17, 19, 21, 23, 25, 27, 29, 31, 33, 35, 36, 39, 41, 43, 44,
47, 49, 51, 53, 54, 56, 59, 61, 62, 64, 67, 69, 71, 72, 75, 77, 76, 74, 73, 71,
70, 68, 67, 65, 63, 62, 61, 58, 57, 55, 53, 51, 51, 48, 47, 44, 43, 42, 40, 38,
36, 36, 33, 31, 30, 28, 27, 25, 23, 22, 20, 19, 17, 14, 10, 8, 5, 2, -1, -5, -8,
-11, -13, -17, -19, -23, -26, -28, -32, -34, -38, -40, -44, -47, -49, -53, -56,
-59, -62, -65, -68, -71, -73, -77, -80, -83, -86, -89, -93, -91, -87, -83, -79,
-74, -70, -66, -61, -58, -53, -49, -45, -40, -36, -32, -28, -23, -19, -15, -10,
-5, -1, 3, 7, 11, 15, 19, 24, 27, 32, 37, 41, 44, 50, 54, 58, 62, 64, 63, 64,
65, 65, 67, 67, 67, 69, 69, 70, 71, 71, 72, 73, 73, 74, 75, 75, 76, 77, 78, 78,
79, 80, 80, 81, 80, 82, 82, 83, 84, 85, 85, 86, 87, 86, 81, 77, 72, 67, 64, 59,
54, 50, 46, 41, 37, 33, 29, 24, 20, 15, 11, 6, 1, -3, -7, -11, -16, -20, -25,
-30, -33, -37, -42, -47, -51, -54, -60, -64, -69, -72, -73, -73, -73, -73, -73,
-73, -73, -72, -72, -72, -72, -71, -71, -71, -71, -71, -71, -71, -70, -70, -70,
-70, -69, -69, -69, -69, -68, -69, -68, -69, -68, -68, -67, -67, -67, -67, -66,
-67, -67, -67, -67, -67, -67, -67, -66, -67, -66, -67, -66, -67, -66, -67, -66,
-66, -66, -66, -67, -66, -66, -66, -66, -65, -66, -67, -66, -65, -65, -66, -65,
-66, -66, -66, -65, -67, -68, -69, -71, -72, -74, -75, -77, -79, -80, -82, -83,
-85, -86, -87, -89, -90, -92, -93, -94, -96, -98, -99, -101, -102, -103, -105,
-106, -108, -109, -111, -112, -114, -115, -116, -119, -118, -117, -116, -115,
-115, -113, -112, -110, -109, -108, -107, -105, -103, -102, -102, -100, -100,
-97, -97, -95, -94, -93, -92, -91, -88, -88, -86, -86, -84, -83, -81, -80, -79,
-77, -76, -75, -74, -72, -69, -66, -63, -61, -58, -54, -52, -49, -47, -44, -41,
-37, -35, -32, -30, -27, -24, -20, -17, -15, -11, -9, -7, -4, -1, };