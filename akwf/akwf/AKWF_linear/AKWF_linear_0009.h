#define DATA_LENGTH 512
#define DATA AKWF_linear_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 4, 7, 9, 11, 14, 17, 19, 20, 22,
25, 26, 30, 31, 33, 36, 38, 41, 42, 44, 45, 46, 47, 48, 49, 50, 52, 53, 55, 55,
57, 58, 60, 60, 62, 62, 64, 66, 66, 69, 69, 70, 71, 73, 74, 75, 76, 77, 78, 80,
82, 82, 83, 85, 85, 87, 87, 88, 89, 89, 90, 91, 91, 92, 93, 94, 94, 94, 95, 96,
97, 97, 97, 98, 99, 100, 101, 102, 102, 103, 104, 104, 104, 105, 106, 107, 107,
107, 109, 110, 110, 111, 111, 111, 111, 111, 111, 112, 111, 113, 112, 114, 113,
113, 113, 114, 114, 114, 115, 114, 114, 115, 115, 116, 116, 116, 116, 116, 117,
117, 116, 117, 118, 117, 118, 118, 119, 118, 118, 118, 118, 118, 118, 118, 118,
118, 117, 117, 117, 117, 116, 116, 116, 116, 116, 115, 116, 115, 115, 115, 114,
114, 115, 114, 114, 114, 113, 113, 113, 114, 113, 113, 112, 112, 112, 113, 112,
111, 110, 110, 109, 110, 109, 109, 108, 107, 107, 106, 105, 106, 105, 104, 104,
104, 104, 103, 102, 102, 101, 101, 100, 100, 100, 100, 99, 99, 98, 98, 97, 97,
96, 95, 94, 93, 92, 91, 89, 89, 88, 87, 85, 84, 83, 81, 81, 79, 78, 76, 76, 75,
73, 72, 71, 70, 69, 68, 66, 65, 65, 62, 61, 61, 59, 58, 58, 56, 55, 54, 52, 49,
48, 46, 43, 41, 39, 37, 35, 32, 30, 28, 26, 24, 21, 19, 17, 15, 14, 10, 8, 7, 4,
2, 0, -3, -4, -6, -9, -11, -13, -16, -18, -20, -23, -25, -26, -29, -31, -34,
-36, -39, -41, -44, -46, -49, -51, -53, -56, -58, -62, -64, -66, -69, -71, -74,
-77, -79, -81, -84, -86, -88, -91, -94, -96, -99, -102, -104, -106, -109, -111,
-113, -116, -117, -117, -117, -117, -118, -117, -117, -118, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -118, -119, -118, -118, -118, -119, -119,
-118, -119, -119, -119, -119, -119, -118, -119, -119, -120, -120, -120, -119,
-119, -118, -119, -118, -118, -118, -118, -117, -117, -116, -116, -116, -116,
-116, -115, -114, -115, -114, -115, -114, -114, -114, -113, -113, -113, -113,
-113, -112, -112, -111, -111, -111, -111, -110, -110, -110, -110, -110, -110,
-109, -110, -109, -110, -109, -109, -110, -110, -109, -110, -109, -109, -110,
-108, -109, -109, -109, -108, -109, -108, -109, -109, -109, -109, -109, -109,
-109, -109, -108, -108, -108, -109, -108, -108, -108, -107, -107, -107, -107,
-106, -106, -106, -105, -105, -105, -104, -104, -104, -103, -102, -102, -102,
-102, -102, -102, -101, -101, -100, -99, -100, -100, -99, -98, -99, -98, -98,
-97, -97, -97, -96, -95, -93, -93, -91, -90, -87, -86, -84, -83, -81, -80, -78,
-76, -75, -72, -72, -70, -68, -67, -65, -64, -63, -61, -59, -58, -56, -55, -53,
-51, -50, -48, -46, -44, -43, -41, -40, -38, -36, -34, -32, -30, -27, -25, -23,
-20, -19, -16, -14, -13, -9, -8, -6, -3, -2, };