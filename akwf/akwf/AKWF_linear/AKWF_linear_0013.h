#define DATA_LENGTH 512
#define DATA AKWF_linear_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 5, 8, 11, 12, 15, 17, 20, 22,
25, 27, 30, 32, 34, 36, 39, 40, 43, 45, 47, 50, 52, 55, 56, 60, 62, 63, 67, 69,
71, 73, 74, 75, 76, 76, 77, 78, 78, 78, 79, 80, 80, 80, 81, 82, 83, 83, 83, 84,
84, 85, 85, 86, 87, 87, 88, 88, 88, 88, 90, 90, 91, 91, 92, 93, 93, 94, 93, 94,
94, 93, 93, 92, 92, 92, 91, 90, 90, 90, 90, 89, 90, 89, 89, 89, 88, 87, 87, 86,
87, 86, 86, 85, 85, 84, 84, 84, 85, 83, 83, 83, 82, 82, 82, 82, 81, 81, 81, 82,
81, 82, 81, 81, 81, 81, 81, 81, 81, 81, 81, 81, 82, 80, 81, 81, 81, 81, 80, 80,
80, 81, 79, 81, 81, 80, 80, 80, 80, 81, 80, 80, 80, 80, 82, 81, 82, 81, 82, 83,
83, 83, 84, 84, 84, 84, 85, 85, 85, 86, 86, 86, 88, 87, 88, 88, 88, 88, 89, 89,
89, 90, 90, 90, 90, 90, 91, 91, 90, 86, 83, 78, 75, 71, 67, 63, 60, 56, 53, 49,
45, 42, 39, 35, 31, 27, 23, 19, 16, 13, 8, 4, 0, -3, -6, -11, -14, -18, -22,
-25, -30, -33, -37, -40, -43, -46, -47, -50, -52, -55, -56, -58, -60, -63, -64,
-67, -69, -70, -74, -75, -77, -80, -81, -83, -85, -87, -89, -91, -93, -96, -97,
-99, -102, -103, -105, -108, -110, -111, -114, -116, -118, -118, -117, -116,
-113, -112, -111, -109, -108, -106, -104, -104, -103, -101, -99, -97, -96, -94,
-93, -91, -90, -88, -87, -85, -83, -82, -81, -80, -77, -76, -75, -72, -72, -70,
-68, -66, -65, -65, -64, -66, -67, -69, -70, -72, -73, -75, -76, -79, -79, -81,
-83, -85, -85, -87, -88, -89, -91, -93, -95, -96, -97, -98, -100, -101, -102,
-104, -106, -107, -108, -111, -111, -113, -115, -116, -116, -117, -117, -117,
-117, -118, -117, -118, -117, -118, -118, -118, -118, -118, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -119, -118, -118, -118, -118, -118, -119,
-119, -119, -119, -118, -118, -119, -119, -119, -117, -117, -116, -114, -113,
-113, -111, -111, -109, -107, -107, -107, -105, -104, -103, -103, -101, -99,
-99, -98, -97, -97, -95, -94, -93, -92, -91, -90, -89, -88, -88, -86, -85, -83,
-84, -82, -78, -74, -70, -66, -63, -59, -56, -51, -48, -44, -41, -36, -32, -29,
-25, -21, -17, -13, -9, -6, -3, 1, 6, 10, 13, 17, 21, 25, 28, 32, 37, 39, 43,
47, 51, 55, 57, 58, 58, 59, 60, 60, 61, 61, 62, 62, 63, 63, 64, 64, 66, 66, 66,
67, 68, 68, 69, 70, 70, 71, 71, 72, 73, 73, 74, 74, 74, 75, 77, 77, 78, 79, 78,
76, 74, 71, 69, 66, 64, 62, 59, 57, 55, 51, 49, 48, 44, 42, 40, 37, 35, 33, 30,
28, 24, 22, 20, 17, 14, 12, 10, 7, 5, 3, 0, -2, -5, -7, -9, -10, -8, -6, -3, -1,
};