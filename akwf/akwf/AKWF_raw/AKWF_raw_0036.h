#define DATA_LENGTH 512
#define DATA AKWF_raw_0036

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 6, 7, 9, 10, 13, 13, 15, 18,
18, 20, 21, 23, 24, 25, 26, 28, 29, 30, 31, 31, 32, 34, 35, 35, 36, 37, 38, 39,
41, 40, 41, 42, 43, 43, 43, 44, 45, 45, 46, 45, 46, 47, 47, 46, 47, 49, 48, 48,
49, 49, 49, 48, 49, 49, 50, 49, 49, 49, 49, 49, 50, 49, 49, 49, 49, 49, 48, 48,
48, 49, 49, 48, 48, 48, 47, 47, 47, 47, 47, 46, 46, 45, 46, 45, 44, 43, 43, 44,
43, 42, 42, 42, 40, 41, 39, 38, 38, 37, 37, 36, 36, 36, 36, 36, 35, 36, 36, 37,
37, 37, 39, 39, 40, 41, 42, 43, 45, 47, 48, 50, 53, 55, 58, 61, 63, 67, 70, 73,
75, 76, 74, 72, 68, 65, 62, 59, 58, 55, 53, 50, 47, 44, 42, 38, 35, 32, 29, 27,
23, 20, 17, 14, 11, 9, 5, 2, -1, -4, -7, -9, -12, -15, -16, -20, -21, -24, -26,
-28, -30, -32, -34, -36, -38, -40, -42, -44, -44, -46, -47, -48, -51, -51, -53,
-53, -54, -55, -56, -56, -58, -58, -60, -59, -59, -60, -61, -61, -61, -62, -61,
-62, -61, -62, -62, -62, -61, -62, -61, -61, -61, -62, -62, -62, -63, -62, -63,
-63, -64, -63, -63, -65, -66, -66, -67, -68, -69, -69, -70, -71, -72, -74, -76,
-77, -78, -80, -82, -82, -81, -82, -82, -81, -80, -80, -80, -79, -78, -77, -77,
-75, -73, -71, -69, -68, -66, -63, -60, -59, -55, -54, -51, -48, -46, -44, -41,
-39, -36, -34, -31, -29, -26, -24, -21, -18, -16, -13, -11, -9, -6, -4, -1, 2,
3, 6, 8, 11, 14, 15, 18, 20, 23, 24, 27, 30, 33, 34, 37, 40, 41, 43, 46, 48, 50,
53, 55, 57, 60, 63, 65, 66, 69, 71, 73, 76, 79, 81, 83, 86, 89, 91, 94, 97, 99,
102, 107, 109, 112, 115, 117, 119, 119, 117, 115, 112, 109, 107, 106, 104, 102,
101, 98, 96, 93, 90, 88, 86, 83, 81, 77, 75, 72, 69, 66, 64, 61, 58, 54, 53, 49,
47, 44, 40, 38, 36, 33, 31, 28, 25, 22, 20, 17, 15, 12, 10, 7, 5, 2, 0, -3, -5,
-7, -10, -12, -14, -16, -18, -21, -22, -24, -25, -28, -29, -31, -32, -35, -36,
-37, -38, -39, -41, -42, -43, -45, -45, -46, -47, -48, -49, -49, -50, -51, -51,
-52, -52, -53, -52, -53, -53, -54, -53, -54, -54, -54, -53, -55, -54, -55, -54,
-54, -54, -54, -54, -54, -55, -54, -55, -54, -56, -55, -56, -56, -57, -57, -57,
-58, -58, -58, -59, -59, -60, -61, -61, -63, -63, -63, -64, -65, -65, -67, -67,
-67, -67, -66, -65, -65, -64, -63, -63, -63, -62, -61, -60, -59, -57, -58, -57,
-55, -53, -53, -52, -50, -49, -48, -46, -45, -43, -42, -41, -38, -38, -36, -34,
-32, -31, -29, -28, -25, -24, -23, -20, -19, -17, -15, -13, -11, -9, -8, -6, -4,
-3, -1, };