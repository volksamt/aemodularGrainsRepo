#define DATA_LENGTH 512
#define DATA AKWF_raw_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 3, 4, 5, 5, 6, 7, 8, 9, 9,
10, 11, 12, 12, 13, 14, 15, 16, 17, 17, 18, 19, 20, 20, 21, 21, 22, 24, 24, 26,
25, 27, 28, 28, 29, 31, 31, 31, 33, 33, 34, 35, 35, 36, 37, 38, 38, 40, 40, 41,
42, 43, 43, 44, 46, 46, 46, 47, 48, 49, 50, 51, 52, 52, 53, 53, 55, 55, 56, 57,
58, 58, 59, 60, 62, 62, 62, 63, 64, 65, 66, 67, 68, 69, 69, 70, 71, 72, 72, 73,
73, 75, 76, 76, 77, 78, 78, 79, 80, 81, 82, 82, 84, 84, 85, 85, 87, 87, 88, 89,
90, 90, 91, 92, 93, 94, 94, 95, 96, 97, 97, 99, 98, 102, 99, 103, 101, 104, 103,
107, 103, 107, 106, 108, 108, 109, 113, 14, -6, 3, -5, 1, -5, -1, -5, -3, -7,
-5, -7, -7, -8, -9, -8, -11, -9, -13, -10, -16, -9, -18, -7, -32, -125, -116,
-117, -116, -113, -114, -110, -112, -109, -109, -107, -107, -103, -105, -102,
-102, -99, -100, -98, -98, -95, -95, -93, -93, -90, -90, -89, -88, -86, -85,
-85, -83, -82, -81, -80, -78, -78, -76, -75, -74, -74, -71, -71, -70, -68, -67,
-66, -65, -63, -63, -61, -61, -59, -59, -57, -55, -55, -53, -52, -51, -50, -50,
-48, -46, -45, -44, -42, -42, -41, -40, -38, -37, -36, -35, -34, -33, -31, -31,
-29, -29, -27, -26, -24, -24, -22, -21, -21, -18, -19, -17, -16, -13, -15, -11,
-12, -8, -11, -6, -9, -3, -7, 2, -7, 12, 113, 109, 108, 109, 105, 107, 103, 105,
102, 103, 99, 101, 97, 99, 95, 96, 94, 95, 91, 91, 90, 89, 88, 87, 86, 85, 84,
83, 83, 80, 79, 79, 78, 76, 76, 76, 73, 72, 71, 70, 69, 69, 68, 66, 65, 65, 63,
63, 61, 60, 60, 59, 57, 56, 56, 54, 53, 51, 50, 50, 49, 48, 47, 46, 45, 45, 43,
42, 41, 41, 38, 38, 37, 35, 35, 33, 33, 32, 30, 29, 28, 28, 26, 25, 24, 23, 22,
21, 20, 19, 18, 17, 16, 15, 14, 13, 11, 12, 9, 8, 7, 7, 5, 5, 4, 2, 1, 1, 0, -2,
-2, -4, -5, -6, -6, -8, -9, -10, -10, -11, -14, -13, -15, -16, -17, -18, -18,
-20, -21, -23, -23, -24, -26, -26, -27, -28, -29, -30, -31, -32, -33, -34, -35,
-37, -38, -39, -40, -40, -42, -43, -44, -44, -46, -47, -48, -49, -49, -52, -52,
-53, -54, -55, -56, -57, -58, -59, -60, -61, -62, -63, -64, -65, -66, -67, -68,
-70, -71, -71, -72, -74, -74, -76, -77, -78, -79, -79, -82, -82, -82, -84, -85,
-86, -87, -88, -89, -90, -91, -92, -93, -95, -95, -96, -96, -99, -99, -100,
-101, -103, -102, -105, -105, -107, -107, -108, -109, -111, -112, -112, -115,
-112, -120, -111, -128, -55, -3, -21, -9, -17, -9, -13, -9, -11, -8, -9, -7, -7,
-5, -4, -4, -3, -3, -2, -1, 0, };