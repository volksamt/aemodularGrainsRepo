#define DATA_LENGTH 512
#define DATA AKWF_raw_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, -11, 45, 127, 109, 115, 107, 108,
103, 102, 97, 95, 93, 89, 87, 83, 81, 76, 75, 71, 69, 64, 63, 58, 56, 53, 52,
47, 46, 42, 39, 37, 34, 31, 27, 25, 22, 19, 16, 13, 9, 8, 4, 2, -1, -4, -8, -10,
-13, -16, -19, -22, -25, -28, -31, -33, -37, -39, -43, -45, -49, -50, -54, -56,
-61, -62, -66, -67, -72, -74, -77, -80, -83, -87, -88, -92, -94, -99, -98, -106,
-103, -114, -105, -127, -63, 10, -7, 7, 2, 9, 8, 14, 15, 18, 20, 23, 26, 28, 30,
33, 37, 38, 42, 43, 46, 48, 52, 53, 57, 59, 61, 64, 68, 69, 73, 74, 78, 79, 83,
85, 88, 89, 93, 96, 98, 100, 103, 106, 108, 112, 110, 124, 57, 24, 36, 26, 32,
26, 29, 24, 27, 23, 24, 21, 21, 19, 19, 17, 17, 16, 14, 14, 11, 11, 11, 10, 7,
7, 6, 5, 4, 3, 2, 1, -1, -1, -2, -4, -9, -9, -8, -6, -6, -5, -4, -3, -1, -1, 1,
1, 2, 4, 5, 5, 7, 7, 8, 9, 10, 12, 13, 14, 14, 15, 17, 18, 18, 19, 20, 21, 23,
23, 24, 26, 27, 28, 28, 30, 30, 33, 29, 16, 17, 16, 16, 14, 14, 12, 12, 12, 10,
11, 9, 9, 8, 8, 7, 6, 5, 5, 3, 3, 2, 1, 0, 1, 0, -2, -2, -3, -3, -3, -4, -5, -6,
-7, -7, -8, -9, -16, -17, -15, -16, -14, -14, -12, -13, -11, -11, -9, -8, -8,
-7, -7, -6, -6, -4, -4, -3, -2, -1, -1, 1, 1, 1, 2, 4, 5, 5, 5, 6, 7, 8, 9, 10,
11, 11, 13, 12, 14, 14, 15, 15, 18, 12, 8, 9, 8, 7, 6, 6, 5, 5, 4, 3, 3, 3, 1,
0, 0, 0, -1, -2, -2, -4, -3, -4, -5, -6, -7, -7, -7, -8, -9, -9, -10, -11, -11,
-12, -13, -14, -13, -14, -15, -17, -15, -18, -33, -33, -31, -31, -29, -29, -27,
-28, -27, -26, -25, -25, -23, -23, -22, -21, -19, -19, -19, -18, -16, -15, -15,
-15, -13, -13, -12, -11, -10, -9, -9, -8, -6, -5, -5, -4, -3, -3, -3, -2, -1, 0,
2, 2, 3, 4, 5, 6, 7, 7, 8, 9, 5, 3, 3, 2, 1, 1, -1, -2, -2, -2, -3, -3, -5, -6,
-6, -7, -8, -10, -9, -11, -10, -12, -12, -14, -13, -15, -16, -17, -17, -18, -19,
-20, -20, -21, -22, -23, -24, -24, -26, -25, -28, -26, -30, -26, -33, -27, -36,
-23, -63, -128, -112, -118, -112, -112, -110, -109, -107, -105, -104, -102,
-101, -99, -98, -95, -95, -92, -92, -89, -89, -86, -85, -82, -82, -80, -79, -77,
-75, -73, -71, -70, -68, -67, -65, -64, -62, -60, -59, -58, -55, -54, -53, -51,
-49, -48, -46, -44, -43, -41, -40, -38, -36, -34, -33, -32, -30, -28, -27, -25,
-23, -21, -20, -19, -17, -15, -13, -12, -11, -9, -8, -6, -5, -3, -1, };