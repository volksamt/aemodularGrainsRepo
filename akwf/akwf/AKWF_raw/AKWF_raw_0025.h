#define DATA_LENGTH 512
#define DATA AKWF_raw_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 7, 9, 13, 15, 19, 21, 25, 27,
30, 34, 37, 39, 42, 46, 49, 51, 54, 58, 60, 64, 66, 70, 72, 76, 79, 83, 83, 89,
85, 68, 68, 66, 64, 63, 61, 59, 57, 56, 54, 53, 51, 50, 48, 46, 44, 44, 41, 39,
37, 36, 35, 32, 31, 29, 27, 27, 25, 23, 22, 19, 19, 16, 15, 13, 11, 9, 7, 6, 5,
2, 2, -1, -2, -4, -5, -7, -8, -10, -12, -14, -15, -17, -19, -20, -22, -23, -25,
-28, -29, -30, -31, -33, -35, -36, -38, -40, -41, -43, -44, -47, -49, -50, -52,
-53, -55, -57, -58, -60, -62, -63, -65, -66, -68, -69, -71, -73, -75, -77, -78,
-79, -82, -83, -84, -87, -87, -91, -91, -94, -93, -97, -98, -100, -100, -104,
-103, -107, -107, -111, -110, -113, -114, -116, -118, -36, -18, -16, -4, 1, 11,
17, 26, 33, 40, 49, 54, 68, 106, 101, 100, 97, 95, 93, 91, 88, 85, 85, 81, 79,
77, 75, 72, 71, 67, 66, 63, 61, 59, 56, 54, 52, 50, 48, 46, 43, 42, 38, 37, 34,
33, 29, 28, 25, 23, 21, 18, 16, 14, 11, 9, 7, 4, 4, 0, -2, -4, -6, -9, -8, -15,
-13, -20, -16, -27, -16, -50, -122, -108, -110, -104, -102, -98, -95, -93, -89,
-86, -82, -80, -75, -74, -69, -67, -63, -61, -57, -55, -51, -49, -44, -42, -38,
-36, -33, -30, -26, -23, -20, -17, -14, -10, -8, -5, -1, 3, 5, 8, 11, 15, 18,
21, 24, 28, 30, 34, 36, 40, 43, 46, 50, 53, 56, 59, 62, 65, 69, 71, 75, 77, 81,
82, 89, 87, 97, 90, 110, 73, 0, 12, 2, 4, -1, -1, -5, -7, -9, -12, -13, -16,
-17, -21, -21, -25, -26, -30, -30, -34, -35, -38, -39, -43, -44, -46, -49, -51,
-53, -56, -57, -59, -62, -64, -67, -68, -72, -72, -76, -78, -80, -81, -85, -86,
-90, -90, -94, -94, -99, -99, -104, -103, -108, -107, -115, -107, -13, -8, -9,
-3, -5, 2, 0, 9, 0, 40, 58, 52, 52, 49, 49, 47, 46, 44, 43, 41, 41, 39, 38, 37,
35, 33, 33, 31, 30, 29, 26, 26, 24, 22, 21, 20, 18, 17, 16, 13, 13, 11, 10, 9,
8, 5, 5, 3, 2, 0, -1, -3, -3, -7, -4, -10, -7, -13, -62, -55, -43, -36, -24,
-18, -5, 0, 13, 18, 33, 36, 58, 95, 88, 86, 83, 81, 79, 75, 72, 69, 67, 65, 62,
58, 57, 54, 51, 48, 46, 43, 40, 37, 34, 32, 30, 27, 24, 21, 18, 16, 14, 10, 7,
5, 3, 0, -3, -6, -8, -11, -14, -16, -20, -21, -24, -27, -30, -32, -36, -37, -42,
-43, -47, -47, -53, -51, -59, -54, -75, -123, -113, -113, -108, -106, -104,
-100, -98, -94, -91, -88, -86, -82, -80, -76, -74, -69, -67, -63, -61, -58, -56,
-52, -49, -46, -43, -40, -37, -35, -31, -28, -25, -23, -20, -16, -13, -11, -8,
-5, -2, };