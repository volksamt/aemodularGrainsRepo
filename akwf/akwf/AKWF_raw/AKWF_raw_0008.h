#define DATA_LENGTH 512
#define DATA AKWF_raw_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 7, 11, 15, 18, 22, 24, 29, 32,
35, 39, 43, 46, 50, 52, 57, 59, 65, 63, 85, 105, 95, 95, 90, 88, 83, 81, 77, 74,
71, 68, 64, 60, 57, 54, 51, 47, 44, 40, 37, 34, 30, 27, 24, 20, 18, 15, 11, 8,
5, 1, -2, -5, -10, -12, -15, -20, -22, -26, -29, -33, -35, -39, -41, -46, -47,
-54, -53, -62, -54, -3, -4, -2, 0, 2, 5, 6, 10, 9, 13, 14, 17, 17, 20, 22, 25,
25, 27, 29, 31, 34, 35, 37, 39, 42, 43, 46, 47, 49, 51, 54, 56, 57, 59, 60, 64,
64, 67, 69, 71, 72, 74, 77, 78, 80, 82, 84, 86, 88, 89, 92, 92, 98, 95, 106, 56,
30, 39, 32, 35, 31, 33, 29, 30, 26, 27, 25, 24, 23, 23, 21, 21, 19, 19, 16, 17,
15, 14, 13, 12, 10, 9, 7, 8, 6, 5, 4, 2, 3, 0, 2, -4, 1, -10, 9, -73, -127,
-107, -117, -105, -111, -104, -105, -100, -99, -95, -94, -90, -88, -86, -83,
-80, -78, -76, -74, -72, -68, -66, -64, -62, -58, -57, -54, -53, -48, -47, -44,
-42, -39, -37, -35, -32, -30, -27, -24, -23, -20, -18, -15, -13, -9, -8, -5, -3,
1, 2, 5, 7, 9, 11, 15, 17, 20, 22, 23, 28, 28, 35, 28, 69, 92, 81, 84, 77, 78,
72, 72, 68, 66, 63, 61, 58, 56, 54, 51, 49, 46, 44, 42, 39, 36, 35, 32, 30, 26,
24, 22, 19, 16, 15, 12, 10, 7, 4, 3, 0, -3, -5, -8, -10, -13, -15, -17, -20,
-23, -25, -27, -30, -33, -35, -38, -39, -43, -45, -48, -50, -52, -55, -58, -60,
-63, -65, -66, -70, -72, -75, -76, -80, -81, -85, -87, -91, -91, -96, -95, -100,
-101, -107, -105, -111, -109, -117, -110, -14, -8, -9, -4, -5, 0, -1, 4, 3, 9,
8, 12, 13, 17, 16, 20, 21, 24, 25, 27, 29, 32, 33, 35, 38, 40, 42, 44, 46, 47,
51, 51, 54, 56, 58, 59, 63, 64, 67, 69, 70, 74, 74, 78, 77, 84, 78, 92, 61, 15,
24, 18, 20, 18, 17, 15, 13, 14, 11, 10, 9, 8, 7, 6, 4, 3, 2, 0, 0, -3, -1, -6,
-3, -10, -4, -15, 2, -51, -121, -101, -108, -100, -102, -96, -95, -92, -90, -88,
-85, -83, -80, -78, -76, -75, -70, -70, -66, -65, -61, -60, -56, -55, -52, -50,
-47, -45, -43, -40, -37, -36, -34, -31, -28, -26, -24, -21, -20, -16, -16, -12,
-10, -7, -5, -2, -1, 3, 4, 8, 8, 13, 13, 18, 16, 27, 73, 68, 64, 59, 55, 51, 47,
44, 38, 36, 30, 27, 22, 20, 15, 11, 7, 3, -1, -5, -10, -13, -18, -21, -25, -30,
-33, -38, -41, -47, -49, -54, -57, -62, -65, -70, -74, -78, -81, -86, -89, -95,
-97, -102, -107, -70, -59, -59, -53, -52, -46, -44, -39, -37, -32, -31, -26,
-24, -20, -16, -12, -9, -6, -2, };