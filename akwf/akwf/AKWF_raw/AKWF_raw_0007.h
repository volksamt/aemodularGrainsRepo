#define DATA_LENGTH 512
#define DATA AKWF_raw_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 8, 10, 12, 14, 16, 18, 20,
21, 24, 27, 27, 31, 31, 34, 35, 39, 38, 44, 42, 50, 44, 63, 122, 114, 114, 110,
107, 107, 103, 101, 98, 97, 93, 91, 89, 87, 83, 82, 78, 76, 72, 71, 68, 66, 63,
61, 58, 56, 54, 51, 49, 47, 43, 40, 39, 36, 33, 31, 28, 25, 24, 20, 18, 16, 13,
11, 9, 6, 4, 1, -1, -4, -7, -9, -12, -14, -17, -19, -22, -24, -26, -30, -31,
-34, -37, -39, -42, -43, -46, -49, -52, -54, -56, -59, -62, -63, -66, -70, -71,
-75, -77, -80, -81, -85, -85, -91, -91, -97, -90, -63, -63, -59, -55, -52, -48,
-46, -42, -40, -35, -33, -30, -26, -23, -19, -16, -13, -9, -6, -3, 0, 4, 6, 10,
14, 17, 20, 23, 27, 30, 34, 37, 40, 42, 47, 49, 54, 56, 60, 62, 67, 68, 74, 75,
81, 82, 87, 89, 93, 95, 100, 102, 107, 109, 113, 118, 42, 25, 30, 24, 27, 20,
23, 18, 19, 15, 16, 12, 12, 9, 9, 6, 5, 3, 1, 0, -2, -3, -6, -7, -9, -10, -12,
-13, -15, -16, -19, -19, -22, -24, -26, -27, -29, -30, -31, -33, -35, -37, -39,
-41, -41, -43, -45, -47, -48, -50, -51, -53, -55, -57, -59, -60, -61, -64, -63,
-46, -44, -44, -42, -40, -37, -37, -35, -35, -32, -30, -29, -28, -25, -25, -22,
-21, -20, -18, -17, -15, -13, -12, -9, -8, -7, -6, -4, -3, -1, 1, 3, 4, 5, 7, 8,
10, 12, 14, 15, 17, 18, 19, 21, 23, 25, 26, 28, 28, 33, 34, 31, 32, 30, 29, 28,
26, 25, 25, 23, 21, 21, 20, 18, 17, 17, 14, 13, 13, 12, 11, 9, 8, 7, 6, 4, 3, 2,
1, 1, -2, -2, -4, -5, -6, -7, -8, -10, -10, -12, -12, -13, -15, -15, -17, -17,
-19, -21, -21, -23, -24, -25, -25, -27, -29, -29, -30, -31, -32, -34, -35, -35,
-37, -38, -39, -40, -42, -41, -44, -35, -28, -29, -26, -27, -25, -25, -23, -22,
-21, -21, -19, -19, -17, -16, -15, -15, -13, -12, -11, -10, -9, -9, -8, -7, -5,
-4, -3, -2, -2, 0, 1, 1, 3, 4, 5, 6, 6, 7, 8, 10, 11, 12, 13, 14, 14, 16, 16,
18, 19, 19, 21, 22, 22, 23, 25, 26, 26, 27, 29, 30, 31, 32, 33, 32, 48, 52, 49,
47, 45, 45, 42, 42, 39, 38, 35, 35, 33, 32, 29, 28, 27, 25, 24, 22, 21, 18, 17,
16, 14, 12, 10, 9, 8, 6, 4, 3, 1, 0, -2, -3, -5, -7, -9, -9, -12, -13, -15, -17,
-19, -20, -21, -25, -22, -30, -20, -72, -106, -90, -97, -89, -90, -85, -86, -82,
-82, -78, -78, -75, -72, -70, -69, -67, -64, -63, -60, -59, -57, -54, -52, -51,
-48, -47, -44, -43, -41, -38, -36, -35, -32, -30, -28, -27, -25, -23, -20, -18,
-16, -14, -12, -10, -8, -6, -5, -2, 0, };