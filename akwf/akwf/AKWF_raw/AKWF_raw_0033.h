#define DATA_LENGTH 512
#define DATA AKWF_raw_0033

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 121, 108, 112, 104, 106, 99, 100,
93, 93, 87, 86, 80, 79, 75, 73, 68, 67, 63, 60, 58, 53, 52, 48, 45, 41, 38, 36,
32, 29, 26, 24, 19, 17, 12, 12, 6, 6, -2, 9, 21, 38, 48, 66, 76, 96, 102, 3, -3,
2, -2, 3, -1, 2, -3, 2, -1, 1, -2, 2, -1, 1, -1, 1, -1, 1, -1, 1, 0, 0, 0, 0, 1,
0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, -1, -1, 0, -1, 0, 1, 0, 0,
0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
1, 0, 0, 0, 0, 0, 1, -1, 0, 0, 1, -1, -1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, -1, 1,
0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 1, -1, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1,
0, -1, 1, -1, 0, 1, 0, -1, -1, 1, 0, 0, -1, 0, 1, 1, -1, 0, 0, 0, 0, 0, 1, 0, 0,
0, 1, 0, -1, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, -1, 0, 0, -1, -1, 0, 0, -1, 0,
1, -1, 0, 0, 1, 1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 1, 0, 0, 0,
0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 0, -1, 1, 0, 1, -1, 0, -1, 1, 0, 1, -1, 1, 0, 0,
0, -1, 1, -1, 2, -3, 4, -7, 14, -67, -128, -105, -115, -103, -107, -98, -99,
-94, -93, -89, -86, -83, -81, -76, -73, -71, -67, -65, -61, -58, -55, -52, -49,
-46, -42, -41, -37, -34, -31, -28, -25, -22, -19, -15, -13, -10, -6, -4, -1,
-25, -35, -61, -68, -103, -69, 12, -5, 3, -2, 1, -1, 0, 0, 0, 1, 0, 0, 0, 0, -1,
1, -1, 1, 0, 0, -1, 1, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 1, 0, 0, 0,
0, 0, 0, 0, 1, -1, 0, 0, 0, 0, -1, -1, 1, 0, 0, -1, -1, 0, 0, 0, 0, 0, 1, 1, -1,
-1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, -1, 0, 0, -1, -1, 0, 1, };