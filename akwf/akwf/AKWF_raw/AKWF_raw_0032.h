#define DATA_LENGTH 512
#define DATA AKWF_raw_0032

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 4, 5, 5, 6, 7, 9, 9, 10,
11, 13, 13, 14, 15, 16, 17, 17, 18, 19, 19, 21, 22, 23, 24, 25, 25, 26, 27, 28,
29, 31, 30, 32, 33, 34, 34, 35, 37, 37, 39, 39, 40, 42, 43, 42, 43, 45, 46, 47,
48, 49, 49, 50, 50, 52, 53, 54, 55, 56, 56, 57, 58, 60, 60, 61, 61, 63, 64, 65,
65, 66, 67, 68, 69, 70, 71, 72, 73, 73, 75, 76, 76, 77, 79, 79, 80, 81, 82, 83,
83, 85, 85, 88, 84, 109, 120, 112, 113, 108, 107, 103, 101, 98, 96, 92, 90, 88,
85, 83, 80, 77, 73, 71, 69, 66, 63, 60, 58, 56, 53, 50, 46, 45, 42, 39, 37, 34,
31, 29, 27, 23, 22, 16, 15, 12, 12, 5, 6, 0, 1, -6, -3, -16, -88, -87, -84, -82,
-78, -78, -74, -74, -71, -70, -66, -65, -62, -61, -57, -57, -53, -53, -50, -48,
-45, -43, -41, -40, -37, -35, -33, -31, -28, -26, -24, -21, -20, -18, -16, -13,
-11, -9, -7, -5, -3, -1, 1, 4, 5, 9, 10, 12, 13, 17, 18, 21, 22, 25, 27, 29, 32,
33, 35, 38, 40, 41, 44, 47, 48, 51, 53, 55, 57, 59, 61, 63, 65, 68, 70, 72, 73,
77, 78, 81, 82, 85, 86, 90, 90, 94, 94, 99, 99, 103, 103, 107, 108, 110, 113,
113, 123, 30, 3, 14, 5, 11, 5, 8, 3, 6, 2, 4, 1, 1, -1, -1, -3, -3, -4, -5, -5,
-6, -8, -9, -9, -11, -12, -12, -14, -15, -15, -17, -16, -18, -19, -20, -20, -21,
-22, -23, -24, -25, -26, -27, -27, -29, -30, -30, -31, -32, -34, -34, -35, -36,
-36, -37, -39, -40, -40, -41, -42, -43, -43, -45, -46, -46, -48, -49, -49, -50,
-51, -52, -53, -54, -55, -56, -57, -57, -59, -60, -60, -61, -62, -63, -64, -64,
-65, -67, -67, -68, -69, -71, -72, -72, -72, -73, -75, -75, -77, -77, -78, -79,
-81, -81, -82, -83, -84, -84, -85, -87, -86, -113, -119, -112, -113, -107, -107,
-103, -101, -97, -95, -93, -90, -87, -84, -82, -79, -76, -73, -71, -68, -66,
-63, -60, -57, -55, -52, -50, -47, -44, -41, -39, -36, -33, -31, -28, -26, -22,
-21, -17, -16, -10, -11, -5, -6, 1, -1, 8, 0, 23, 92, 84, 84, 82, 79, 78, 74,
74, 70, 70, 65, 65, 62, 61, 58, 57, 54, 53, 49, 48, 45, 44, 40, 39, 37, 34, 33,
31, 29, 26, 25, 22, 20, 18, 16, 14, 11, 9, 7, 5, 3, 1, -2, -4, -5, -8, -11, -13,
-15, -17, -18, -20, -24, -25, -28, -28, -31, -34, -36, -39, -40, -42, -45, -46,
-48, -50, -53, -54, -57, -59, -61, -63, -65, -67, -70, -73, -73, -77, -79, -81,
-82, -86, -86, -90, -90, -94, -95, -99, -99, -104, -102, -108, -108, -112, -112,
-116, -117, -20, -7, -12, -6, -11, -5, -9, -3, -5, -2, -3, 0, -1, };