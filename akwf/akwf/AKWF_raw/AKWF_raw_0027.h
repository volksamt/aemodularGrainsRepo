#define DATA_LENGTH 512
#define DATA AKWF_raw_0027

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 3, 3, 4, 6, 6, 7, 8, 10, 11, 11,
12, 13, 14, 15, 16, 17, 18, 18, 20, 21, 22, 23, 24, 25, 26, 26, 27, 28, 29, 31,
31, 32, 34, 34, 36, 36, 37, 38, 40, 41, 42, 42, 44, 44, 46, 46, 48, 49, 49, 50,
51, 52, 53, 54, 55, 55, 58, 58, 59, 60, 60, 62, 62, 64, 65, 66, 67, 68, 68, 70,
70, 72, 72, 73, 74, 75, 76, 78, 79, 80, 80, 82, 81, 82, 84, 85, 85, 87, 88, 89,
89, 91, 92, 93, 94, 96, 96, 97, 98, 98, 99, 101, 102, 103, 104, 105, 106, 106,
108, 108, 110, 110, 112, 112, 114, 113, 116, 116, 118, 117, 80, 73, 72, 67, 65,
60, 59, 53, 52, 48, 46, 41, 39, 35, 32, 29, 25, 23, 19, 16, 13, 10, 6, 3, 0, -4,
-7, -10, -13, -17, -20, -23, -27, -30, -33, -36, -40, -43, -46, -49, -52, -57,
-59, -63, -64, -70, -70, -81, -109, -105, -105, -104, -103, -103, -101, -101,
-100, -100, -98, -98, -95, -96, -94, -95, -93, -92, -91, -90, -90, -89, -87,
-86, -86, -85, -83, -83, -82, -81, -81, -80, -79, -78, -77, -77, -75, -75, -73,
-72, -72, -71, -70, -69, -69, -68, -67, -65, -64, -64, -63, -63, -61, -61, -59,
-59, -59, -57, -56, -55, -54, -53, -53, -52, -51, -50, -48, -48, -46, -46, -45,
-45, -43, -42, -41, -41, -40, -39, -38, -37, -37, -35, -34, -34, -32, -32, -30,
-29, -29, -27, -27, -26, -26, -25, -24, -22, -21, -22, -21, -19, -18, -17, -16,
-16, -14, -14, -13, -13, -12, -10, -9, -8, -7, -6, -6, -5, -4, -2, -1, -1, 0, 2,
2, 3, 4, 5, 5, 6, 7, 9, 9, 10, 11, 12, 13, 14, 15, 15, 17, 17, 18, 19, 21, 20,
22, 23, 24, 25, 25, 27, 28, 28, 30, 30, 31, 32, 33, 34, 34, 35, 37, 38, 38, 39,
39, 41, 41, 42, 43, 43, 45, 45, 47, 47, 47, 48, 50, 50, 50, 52, 52, 53, 54, 55,
56, 57, 57, 59, 59, 60, 60, 62, 62, 64, 63, 67, 65, 68, 66, 70, 67, 73, 118,
116, 110, 108, 102, 100, 94, 92, 86, 84, 78, 76, 70, 67, 62, 59, 55, 51, 46, 42,
38, 34, 31, 27, 23, 19, 15, 11, 7, 2, -1, -5, -9, -13, -16, -21, -25, -29, -33,
-38, -41, -45, -49, -53, -56, -61, -65, -69, -73, -77, -81, -83, -89, -92, -97,
-100, -106, -106, -117, -104, -74, -79, -74, -75, -73, -73, -72, -71, -69, -68,
-67, -66, -66, -64, -64, -62, -61, -61, -60, -59, -58, -57, -56, -55, -54, -53,
-52, -52, -50, -49, -47, -46, -46, -46, -45, -43, -42, -41, -40, -40, -38, -37,
-36, -35, -34, -33, -33, -31, -30, -29, -28, -28, -27, -25, -24, -25, -23, -22,
-21, -21, -19, -18, -17, -16, -15, -15, -12, -12, -12, -10, -10, -8, -8, -6, -5,
-5, -2, -1, -2, 0, };