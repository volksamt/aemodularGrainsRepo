#define DATA_LENGTH 512
#define DATA AKWF_raw_0034

const PROGMEM int8_t DATA[DATA_LENGTH] = {105, 123, 111, 117, 108, 111, 105,
108, 102, 104, 98, 101, 95, 95, 92, 92, 89, 87, 85, 85, 82, 80, 78, 76, 75, 72,
71, 69, 67, 65, 63, 61, 60, 58, 57, 54, 52, 50, 48, 46, 45, 43, 41, 39, 38, 36,
33, 32, 29, 28, 26, 25, 23, 21, 18, 18, 15, 14, 11, 10, 7, 7, 4, 2, 0, -1, -4,
-6, -8, -8, -10, -14, -14, -16, -17, -21, -21, -24, -23, -29, -26, -36, -27,
-55, -101, -88, -89, -84, -82, -78, -74, -71, -67, -65, -61, -58, -53, -51, -47,
-44, -40, -38, -34, -31, -27, -24, -21, -18, -14, -10, -7, -4, 0, 3, 6, 10, 13,
16, 20, 24, 26, 30, 33, 37, 41, 44, 47, 50, 52, 57, 61, 64, 67, 70, 73, 76, 81,
83, 87, 90, 95, 96, 102, 101, 110, 105, 121, 86, -34, -29, 6, -5, -21, -35, -37,
-34, -34, -33, -31, -30, -28, -28, -26, -25, -23, -22, -20, -19, -18, -17, -15,
-14, -14, -12, -11, -10, -8, -6, -5, -4, -2, -2, 1, 0, 3, 2, 9, 1, 27, 58, 46,
47, 42, 40, 36, 34, 31, 28, 24, 22, 19, 15, 13, 10, 8, 3, 1, -3, -5, -8, -12,
-14, -18, -20, -25, -24, -32, -27, -62, -87, -76, -78, -72, -72, -67, -65, -63,
-61, -58, -56, -54, -52, -48, -45, -43, -41, -39, -36, -34, -31, -29, -27, -25,
-21, -19, -16, -15, -11, -10, -7, -5, -2, 0, 3, 5, 7, 11, 13, 15, 17, 21, 21,
25, 27, 30, 32, 36, 36, 41, 41, 45, 46, 51, 46, 5, 1, -6, -12, -18, -25, -31,
-37, -42, -50, -54, -64, -65, -80, -52, -32, -37, -33, -33, -30, -30, -28, -27,
-25, -24, -23, -21, -21, -18, -18, -16, -15, -14, -13, -10, -11, -8, -8, -6, -6,
-4, -3, -1, 0, 1, 4, 3, 8, 1, 38, 57, 45, 47, 42, 40, 35, 34, 30, 28, 24, 21,
19, 15, 13, 9, 7, 3, 0, -4, -5, -10, -11, -16, -18, -22, -25, -27, -32, -28,
-99, -117, -104, -107, -99, -100, -92, -91, -85, -85, -79, -78, -73, -70, -65,
-64, -59, -56, -52, -50, -46, -41, -38, -35, -31, -27, -25, -22, -18, -15, -11,
-8, -4, 0, 3, 6, 9, 13, 16, 21, 23, 27, 29, 35, 36, 43, 42, 51, 43, 7, 9, 6, 5,
4, 3, 3, 0, 0, -1, -2, -5, -4, -7, -6, -8, -9, -11, -11, -13, -14, -16, -16,
-18, -18, -20, -21, -22, -23, -24, -26, -26, -27, -28, -30, -31, -33, -33, -34,
-35, -37, -38, -39, -41, -41, -43, -44, -44, -47, -47, -49, -49, -51, -52, -52,
-54, -55, -56, -58, -59, -59, -60, -62, -63, -64, -66, -67, -68, -68, -70, -71,
-72, -73, -74, -75, -76, -78, -79, -80, -80, -82, -84, -84, -85, -87, -88, -89,
-90, -92, -92, -94, -95, -97, -97, -98, -98, -101, -101, -103, -103, -106, -105,
-108, -108, -108, -111, -111, -117, -48, -8, };