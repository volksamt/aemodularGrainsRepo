#define DATA_LENGTH 512
#define DATA AKWF_raw_0028

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 8, 12, 14, 17, 21, 24, 28, 30,
32, 36, 40, 42, 47, 48, 67, 71, 64, 63, 58, 55, 52, 49, 45, 41, 38, 34, 31, 28,
23, 21, 17, 14, 10, 7, 3, 0, -4, -7, -11, -14, -18, -21, -25, -28, -32, -34,
-39, -42, -46, -48, -53, -56, -60, -63, -67, -70, -42, -36, -37, -34, -35, -31,
-31, -29, -28, -26, -25, -23, -23, -20, -20, -18, -16, -15, -15, -13, -12, -11,
-8, -7, -6, -5, -3, -2, -1, 0, 2, 2, 4, 6, 8, 8, 10, 11, 13, 14, 15, 17, 18, 20,
21, 22, 23, 25, 26, 27, 28, 30, 32, 33, 35, 36, 37, 38, 40, 41, 43, 44, 45, 46,
48, 50, 51, 52, 54, 53, 57, 55, 60, 59, 63, 61, 66, 64, 69, 66, 73, 65, 1, -5,
-5, -11, -12, -16, -18, -22, -25, -27, -31, -32, -37, 25, 78, 64, 68, 61, 62,
58, 57, 54, 52, 49, 48, 46, 43, 42, 40, 37, 35, 34, 31, 29, 26, 25, 22, 20, 17,
16, 13, 11, 10, 8, 5, 3, 1, -3, -3, -10, -15, -12, -12, -10, -10, -9, -8, -6,
-5, -4, -2, -1, 0, 0, 2, 3, 4, 6, 7, 8, 9, 10, 12, 12, 14, 14, 16, 18, 19, 20,
21, 22, 23, 25, 26, 27, 28, 29, 30, 32, 33, 34, 35, 36, 38, 38, 40, 41, 42, 42,
44, 45, 47, 48, 50, 50, 51, 52, 54, 55, 56, 58, 58, 60, 60, 62, 62, 65, 65, 68,
66, 70, 66, 51, 51, 48, 45, 43, 39, 38, 34, 33, 28, 28, 23, 23, 18, 18, 12, 13,
8, 6, 3, 1, -2, -5, -5, -13, -4, -95, -125, -108, -115, -105, -109, -101, -103,
-96, -96, -91, -90, -86, -84, -81, -79, -76, -72, -70, -67, -65, -62, -60, -57,
-54, -51, -49, -45, -44, -40, -38, -35, -33, -30, -27, -24, -22, -19, -16, -14,
-11, -9, -5, -3, 0, 3, 6, 8, 11, 14, 16, 18, 22, 24, 27, 31, 33, 36, 37, 42, 41,
50, 32, 10, 11, 4, 2, -3, -5, -9, -13, -17, -20, -24, -28, -31, -36, -40, -43,
-46, -50, -54, -58, -63, -64, -70, -73, -77, -80, -84, -87, -92, -96, -99, -103,
-106, -111, -112, -121, -63, -44, -50, -42, -44, -38, -38, -33, -32, -27, -27,
-23, -21, -18, -16, -11, -10, -7, -6, -1, -1, 5, 4, 10, 8, 22, 56, 49, 50, 48,
47, 45, 44, 42, 41, 40, 38, 37, 36, 34, 33, 31, 30, 28, 27, 25, 23, 23, 22, 21,
19, 17, 16, 14, 12, 12, 9, 9, 8, 6, 5, 3, 1, 0, -1, -2, -4, -6, -7, -9, -10,
-11, -12, -14, -15, -16, -18, -19, -21, -23, -24, -25, -26, -28, -30, -30, -32,
-34, -35, -37, -38, -39, -40, -42, -44, -45, -46, -48, -48, -51, -73, -71, -66,
-64, -61, -57, -54, -51, -48, -45, -42, -38, -36, -32, -29, -26, -22, -19, -16,
-13, -10, -7, -4, 0, };