#define DATA_LENGTH 512
#define DATA AKWF_raw_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 1, 2, 2, 2, 3, 2, 2, 4, 3, 3,
4, 5, 4, 5, 5, 6, 6, 7, 7, 8, 7, 8, 8, 9, 8, 8, 9, 10, 10, 10, 11, 11, 11, 12,
12, 12, 12, 12, 14, 14, 13, 15, 15, 15, 15, 16, 16, 17, 17, 17, 17, 17, 18, 18,
18, 19, 19, 19, 20, 20, 20, 20, 21, 20, 22, 22, 22, 22, 24, 23, 24, 24, 24, 25,
25, 24, 26, 25, 26, 27, 27, 27, 27, 27, 28, 29, 29, 30, 29, 29, 29, 30, 31, 31,
31, 31, 32, 32, 33, 33, 33, 33, 35, 34, 35, 35, 35, 35, 36, 36, 36, 37, 38, 38,
37, 38, 38, 38, 39, 38, 40, 39, 41, 40, 42, 40, 43, 41, 44, 40, 46, 36, -2, 0,
-3, -3, -4, -6, -7, -8, -8, -10, -10, -13, -12, -15, -15, -17, -17, -19, -19,
-21, -21, -23, -24, -25, -26, -28, -28, -29, -31, -31, -32, -33, -35, -35, -36,
-37, -38, -40, -42, -42, -44, -43, -47, -45, -50, -46, -55, -31, 6, -3, 2, -2,
0, -1, 0, 0, 1, 0, 0, 0, -1, 1, 0, 0, -1, 1, -1, 1, -2, 3, -5, 17, 37, 31, 34,
31, 33, 31, 31, 30, 31, 30, 30, 29, 29, 29, 28, 28, 27, 27, 27, 27, 26, 26, 25,
25, 25, 24, 24, 24, 23, 23, 22, 22, 22, 21, 21, 22, 20, 20, 19, 20, 18, 18, 18,
17, 17, 17, 16, 16, 15, 15, 14, 14, 14, 14, 14, 13, 13, 12, 12, 11, 11, 11, 11,
10, 10, 9, 10, 8, 9, 8, 9, 7, 6, 7, 6, 6, 4, 7, 3, 6, 2, 6, 0, 6, 0, 6, -2, 8,
-8, 14, -16, -127, -99, -94, -79, -69, -57, -45, -35, -22, -11, 0, -4, -5, -10,
-10, -16, -16, -21, -22, -28, -28, -32, -34, -38, -40, -44, -45, -49, -51, -55,
-57, -61, -63, -66, -68, -72, -74, -77, -81, -83, -86, -88, -92, -92, -99, -97,
-106, -101, -114, -103, -128, -87, -1, 29, -12, -65, -43, -56, -46, -51, -48,
-50, -49, -48, -48, -48, -49, -47, -47, -45, -47, -44, -47, -44, -46, -44, -45,
-44, -44, -43, -43, -41, -42, -42, -41, -41, -40, -40, -40, -41, -39, -40, -38,
-39, -38, -38, -37, -38, -37, -37, -37, -36, -36, -35, -35, -35, -34, -34, -34,
-34, -33, -33, -33, -32, -32, -31, -32, -31, -31, -31, -30, -29, -30, -29, -29,
-29, -28, -29, -28, -27, -27, -26, -26, -26, -25, -25, -25, -25, -23, -24, -24,
-23, -23, -22, -22, -23, -21, -22, -21, -21, -20, -20, -20, -20, -19, -19, -18,
-18, -18, -17, -18, -16, -17, -16, -17, -15, -15, -15, -14, -15, -13, -14, -13,
-13, -13, -13, -12, -12, -12, -10, -10, -10, -9, -10, -10, -9, -9, -8, -8, -8,
-8, -8, -7, -7, -6, -6, -6, -5, -5, -5, -4, -4, -4, -4, -3, -3, -2, -2, -2, -1,
0, -1, 0, 0, };