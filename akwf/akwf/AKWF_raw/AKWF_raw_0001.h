#define DATA_LENGTH 512
#define DATA AKWF_raw_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {94, 112, 103, 109, 103, 107, 103, 106,
102, 105, 100, 103, 100, 102, 98, 100, 98, 98, 97, 97, 96, 95, 95, 93, 93, 92,
92, 91, 90, 89, 89, 88, 87, 86, 86, 85, 84, 84, 83, 82, 81, 80, 79, 79, 77, 77,
75, 74, 74, 73, 72, 71, 70, 69, 68, 68, 66, 66, 65, 64, 63, 62, 61, 60, 60, 59,
58, 56, 57, 55, 54, 53, 53, 52, 51, 50, 48, 48, 47, 46, 46, 45, 43, 43, 42, 42,
40, 40, 38, 38, 36, 36, 35, 35, 33, 31, 31, 30, 30, 28, 28, 28, 26, 25, 25, 23,
22, 22, 20, 20, 19, 18, 17, 17, 16, 14, 14, 13, 12, 11, 10, 9, 9, 8, 7, 6, 5, 4,
3, 2, 1, 0, 0, 0, -1, -3, -4, -5, -6, -6, -7, -8, -9, -10, -11, -12, -13, -14,
-15, -16, -16, -17, -18, -19, -20, -21, -21, -21, -24, -24, -24, -26, -27, -28,
-29, -29, -30, -32, -32, -34, -34, -35, -35, -36, -37, -38, -40, -39, -40, -42,
-43, -44, -44, -45, -45, -47, -48, -49, -49, -50, -51, -52, -54, -54, -55, -56,
-57, -58, -58, -59, -60, -61, -62, -63, -64, -64, -65, -66, -67, -69, -69, -70,
-71, -72, -73, -73, -74, -75, -76, -77, -78, -80, -80, -81, -81, -82, -83, -85,
-84, -86, -86, -88, -89, -89, -90, -92, -92, -93, -94, -95, -95, -96, -98, -98,
-99, -99, -101, -100, -104, -102, -106, -103, -109, -103, -114, -41, 81, 76, 77,
76, 75, 74, 72, 73, 70, 71, 69, 69, 66, 67, 65, 66, 63, 63, 61, 61, 60, 59, 57,
58, 56, 55, 54, 53, 53, 52, 51, 50, 49, 49, 48, 46, 46, 44, 43, 42, 42, 40, 39,
39, 37, 36, 35, 35, 34, 33, 32, 31, 29, 30, 29, 27, 26, 26, 25, 24, 22, 23, 21,
20, 18, 18, 17, 16, 15, 14, 13, 13, 12, 10, 10, 9, 8, 6, 6, 4, 4, 3, 2, 1, 1,
-1, -2, -3, -4, -5, -4, -7, -7, -8, -9, -10, -11, -12, -12, -15, -14, -16, -17,
-17, -18, -19, -20, -20, -22, -22, -25, -23, -26, -25, -29, -27, -31, -29, -34,
-30, -35, -31, -39, -33, -41, -34, -44, -65, 40, 39, 35, 39, 33, 36, 31, 35, 30,
32, 27, 31, 26, 28, 24, 26, 22, 23, 21, 22, 20, 20, 19, 17, 17, 15, 15, 14, 12,
11, 10, 10, 9, 8, 8, 5, 6, 4, 4, 2, 2, 1, -1, -1, -3, -3, -5, -4, -6, -7, -7,
-9, -10, -11, -12, -13, -14, -14, -15, -16, -17, -18, -19, -20, -21, -22, -23,
-23, -24, -26, -26, -27, -28, -29, -30, -30, -33, -33, -35, -35, -36, -36, -37,
-39, -39, -40, -41, -42, -43, -44, -46, -46, -47, -48, -48, -50, -50, -52, -52,
-54, -54, -56, -56, -57, -58, -59, -60, -60, -62, -62, -65, -63, -67, -65, -69,
-67, -71, -69, -73, -69, -76, -71, -79, -72, -82, -72, -88, -99, };