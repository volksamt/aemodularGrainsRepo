#define DATA_LENGTH 512
#define DATA AKWF_raw_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 2, 2, 2, 3, 4, 5, 6, 5, 6, 7,
7, 8, 9, 10, 10, 10, 11, 11, 12, 12, 13, 14, 14, 15, 15, 16, 17, 18, 18, 18, 19,
19, 20, 20, 22, 22, 22, 23, 24, 24, 25, 26, 26, 26, 27, 28, 27, 29, 30, 30, 31,
31, 32, 32, 32, 33, 34, 34, 34, 36, 36, 37, 37, 39, 39, 39, 39, 40, 41, 41, 42,
43, 44, 43, 44, 45, 46, 46, 46, 47, 48, 48, 50, 49, 50, 51, 52, 52, 52, 53, 53,
54, 55, 55, 56, 56, 56, 57, 58, 59, 59, 60, 60, 61, 62, 62, 62, 63, 64, 64, 65,
66, 65, 66, 68, 68, 68, 69, 70, 70, 71, 72, 72, 72, 73, 73, 74, 75, 75, 76, 77,
78, 78, 78, 79, 79, 80, 80, 81, 82, 82, 83, 83, 84, 85, 85, 86, 86, 87, 87, 88,
88, 89, 90, 91, 91, 91, 92, 93, 93, 94, 94, 95, 96, 96, 97, 97, 97, 98, 99, 100,
99, 101, 101, 103, 102, 103, 103, 105, 105, 106, 106, 107, 107, 108, 108, 109,
109, 110, 111, 111, 113, 111, 113, 111, 116, 113, 118, 113, 121, 111, 127, 83,
8, 22, 12, 16, 11, 11, 9, 7, 6, 3, 2, 0, -1, -4, -4, -7, -8, -10, -12, -14, -15,
-18, -18, -21, -21, -24, -25, -27, -28, -32, -32, -34, -36, -38, -39, -42, -42,
-45, -46, -49, -49, -52, -52, -55, -55, -60, -59, -61, -63, -65, -67, -67, -71,
-70, -76, -72, -81, -73, -87, -73, -96, -68, -121, -31, 127, 100, 119, 103, 109,
101, 102, 98, 94, 93, 89, 88, 83, 84, 78, 78, 72, 73, 67, 66, 61, 61, 56, 56,
52, 51, 46, 44, 42, 39, 35, 34, 31, 28, 26, 23, 20, 17, 15, 12, 9, 6, 4, 2, -2,
-5, -6, -9, -12, -14, -17, -20, -22, -26, -29, -31, -33, -35, -39, -41, -44,
-47, -50, -51, -55, -57, -60, -62, -65, -68, -71, -73, -76, -78, -81, -84, -86,
-89, -91, -94, -97, -99, -101, -105, -106, -110, -110, -116, -97, -84, -88, -85,
-86, -85, -86, -84, -84, -83, -83, -81, -82, -80, -81, -79, -79, -78, -78, -78,
-77, -76, -76, -75, -75, -74, -73, -73, -72, -72, -70, -70, -70, -70, -68, -68,
-68, -67, -66, -66, -65, -65, -65, -64, -63, -62, -62, -62, -61, -60, -59, -58,
-58, -58, -57, -56, -56, -55, -55, -54, -54, -54, -53, -53, -52, -52, -50, -49,
-49, -49, -48, -48, -47, -47, -46, -45, -44, -44, -44, -43, -42, -42, -40, -41,
-40, -39, -39, -38, -38, -38, -37, -37, -35, -36, -34, -34, -34, -32, -32, -31,
-31, -30, -29, -29, -28, -28, -27, -26, -26, -26, -25, -25, -24, -23, -22, -22,
-21, -21, -21, -19, -19, -20, -18, -18, -17, -16, -16, -16, -14, -13, -14, -13,
-13, -12, -11, -11, -10, -10, -9, -8, -8, -7, -7, -6, -6, -5, -4, -4, -4, -3,
-2, -2, -1, -1, };