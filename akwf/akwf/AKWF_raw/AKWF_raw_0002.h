#define DATA_LENGTH 512
#define DATA AKWF_raw_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 1, 3, 3, 4, 5, 7, 6, 8, 9, 9, 11,
11, 13, 13, 14, 15, 16, 17, 17, 19, 19, 21, 22, 23, 23, 25, 25, 26, 27, 29, 29,
30, 31, 31, 32, 33, 34, 35, 36, 37, 38, 39, 39, 40, 42, 43, 44, 45, 45, 46, 47,
48, 49, 49, 50, 52, 52, 54, 54, 56, 55, 57, 57, 59, 60, 61, 61, 62, 63, 64, 65,
66, 68, 69, 68, 70, 72, 72, 73, 74, 75, 76, 76, 77, 79, 80, 80, 82, 82, 82, 83,
84, 86, 86, 87, 88, 89, 90, 91, 92, 94, 93, 94, 95, 96, 97, 98, 99, 100, 101,
102, 103, 104, 104, 105, 107, 108, 109, 109, 110, 110, 112, 112, 114, 115, 116,
117, 117, 118, 119, 118, 117, 115, 114, 113, 113, 112, 112, 110, 110, 109, 108,
107, 105, 105, 105, 103, 102, 101, 100, 100, 99, 98, 97, 96, 95, 94, 93, 92, 91,
90, 89, 88, 87, 87, 85, 84, 83, 83, 82, 81, 80, 80, 78, 77, 77, 76, 75, 74, 73,
72, 71, 71, 70, 68, 67, 67, 65, 65, 64, 63, 62, 62, 60, 59, 58, 57, 56, 56, 55,
53, 53, 51, 50, 50, 49, 49, 48, 47, 46, 45, 43, 43, 42, 41, 40, 39, 38, 37, 37,
35, 34, 33, 33, 32, 30, 30, 29, 28, 27, 27, 24, 25, 23, 23, 22, 20, 20, 18, 18,
17, 16, 15, 14, 14, 13, 12, 11, 9, 9, 8, 7, 6, 6, 5, 4, 2, 2, 1, 0, -2, -3, -3,
-5, -4, -6, -7, -7, -9, -10, -11, -12, -12, -13, -14, -15, -15, -16, -17, -19,
-20, -20, -22, -22, -22, -24, -26, -26, -27, -28, -29, -29, -31, -31, -33, -32,
-35, -35, -37, -37, -38, -40, -40, -40, -41, -42, -43, -44, -46, -46, -47, -48,
-49, -49, -50, -52, -52, -53, -54, -55, -57, -57, -57, -59, -59, -60, -62, -62,
-63, -64, -65, -66, -67, -68, -70, -69, -71, -72, -72, -74, -74, -76, -77, -77,
-78, -79, -80, -81, -82, -83, -83, -85, -85, -86, -87, -88, -89, -90, -91, -91,
-93, -93, -95, -95, -96, -97, -98, -99, -101, -100, -102, -104, -103, -105,
-105, -107, -107, -108, -109, -110, -110, -112, -112, -114, -114, -117, -115,
-120, -114, -80, -82, -80, -79, -80, -79, -79, -77, -77, -76, -76, -74, -75,
-74, -74, -72, -73, -72, -71, -70, -70, -69, -69, -68, -67, -67, -66, -65, -65,
-65, -64, -63, -62, -62, -62, -60, -60, -59, -59, -58, -57, -57, -56, -55, -55,
-54, -53, -52, -52, -51, -51, -50, -49, -48, -48, -47, -47, -46, -45, -44, -43,
-43, -42, -41, -41, -41, -40, -39, -39, -37, -37, -37, -36, -35, -34, -34, -33,
-33, -31, -31, -30, -30, -29, -28, -28, -27, -26, -25, -25, -24, -23, -23, -21,
-21, -20, -20, -19, -18, -18, -17, -16, -15, -15, -14, -13, -12, -11, -10, -10,
-9, -9, -8, -7, -7, -6, -5, -5, -4, -3, -2, -2, -1, };