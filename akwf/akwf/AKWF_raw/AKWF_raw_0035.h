#define DATA_LENGTH 512
#define DATA AKWF_raw_0035

const PROGMEM int8_t DATA[DATA_LENGTH] = {-9, 25, 124, 108, 110, 105, 103, 100,
96, 94, 89, 88, 83, 81, 77, 75, 70, 68, 63, 62, 58, 55, 51, 49, 45, 42, 38, 35,
31, 29, 25, 23, 19, 15, 12, 8, 6, 2, 1, 4, 7, 8, 12, 13, 16, 18, 21, 23, 26, 28,
31, 33, 36, 38, 41, 43, 46, 48, 51, 53, 55, 59, 60, 64, 66, 69, 70, 74, 74, 79,
79, 83, 85, 89, 90, 93, 94, 97, 100, 102, 106, 105, 112, 107, 127, 43, -13, -45,
-62, -46, -54, -42, -47, -38, -41, -34, -34, -30, -29, -25, -23, -19, -17, -15,
-12, -9, -5, -4, -1, -1, -2, -5, -4, -7, -8, -9, -10, -12, -13, -15, -16, -19,
-19, -22, -22, -23, -24, -27, -27, -29, -30, -33, -32, -36, -36, -37, -39, -40,
-42, -43, -44, -47, -47, -49, -51, -51, -55, -52, -62, -20, 6, -4, 3, -2, 1, 10,
19, 11, 12, 9, 8, 5, 4, 3, 0, 1, 2, 8, 7, 16, 5, 7, -42, -74, -61, -67, -61,
-64, -60, -61, -58, -59, -56, -55, -55, -54, -53, -51, -50, -49, -49, -47, -47,
-45, -45, -44, -43, -40, -39, -39, -38, -36, -36, -34, -34, -33, -31, -31, -30,
-29, -28, -27, -25, -24, -24, -22, -21, -20, -19, -19, -17, -17, -14, -14, -13,
-12, -11, -10, -8, -9, -5, -6, -3, -4, -2, -2, 0, -2, -6, -8, -13, -16, -20,
-23, -28, -29, -35, -35, -42, -40, -49, -46, -59, -52, -68, -53, -13, 39, 127,
109, 114, 106, 104, 102, 98, 95, 91, 90, 84, 82, 76, 76, 69, 69, 63, 63, 56, 55,
51, 49, 45, 42, 37, 34, 32, 28, 25, 21, 18, 15, 11, 8, 5, 1, 2, 3, 7, 9, 12, 13,
17, 19, 22, 23, 27, 29, 32, 34, 36, 39, 42, 43, 46, 48, 51, 53, 56, 59, 61, 64,
66, 70, 70, 75, 76, 80, 79, 85, 85, 89, 89, 96, 95, 99, 100, 105, 106, 108, 113,
110, 124, 32, -14, -49, -60, -47, -53, -43, -47, -39, -40, -34, -35, -28, -29,
-23, -23, -19, -17, -14, -12, -9, -6, -3, 0, -1, -2, -4, -5, -7, -8, -9, -10,
-12, -13, -16, -16, -18, -19, -21, -21, -23, -25, -26, -28, -29, -30, -31, -33,
-34, -36, -37, -38, -39, -41, -42, -45, -44, -47, -47, -50, -51, -52, -53, -54,
-57, -6, 3, -3, 3, -3, 15, 14, 14, 10, 11, 6, 7, 3, 4, 0, 2, 3, 9, 8, 15, 7, -3,
2, -59, -69, -63, -65, -61, -63, -60, -60, -57, -59, -55, -57, -53, -54, -52,
-52, -50, -49, -48, -47, -45, -44, -44, -43, -41, -40, -40, -38, -37, -37, -35,
-34, -34, -31, -31, -30, -29, -27, -27, -26, -24, -23, -22, -22, -20, -19, -18,
-17, -15, -16, -14, -13, -11, -10, -9, -8, -8, -6, -6, -4, -3, -2, -1, 1, -2,
-7, -9, -13, -16, -20, -23, -27, -29, -34, -36, -41, -41, -48, -48, -56, -54,
-64, -54, };