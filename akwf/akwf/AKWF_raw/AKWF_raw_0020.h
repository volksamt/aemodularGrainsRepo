#define DATA_LENGTH 512
#define DATA AKWF_raw_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 6, 6, 8, 9, 11, 12, 14,
14, 16, 16, 18, 20, 21, 22, 23, 24, 25, 27, 28, 29, 30, 32, 33, 34, 35, 37, 37,
40, 40, 43, 41, 46, 40, 62, 91, 79, 80, 75, 72, 69, 66, 62, 59, 56, 52, 48, 44,
42, 38, 36, 31, 28, 24, 22, 17, 15, 12, 8, 5, 1, -2, -6, -9, -12, -16, -19, -22,
-26, -29, -34, -36, -40, -43, -47, -48, -53, -55, -59, -63, -66, -69, -73, -77,
-39, -29, -27, -21, -19, -13, -11, -5, -2, 3, 7, 12, 15, 21, 24, 29, 32, 37, 41,
45, 50, 54, 58, 62, 66, 70, 75, 78, 83, 100, 101, 94, 91, 85, 82, 77, 73, 68,
64, 59, 57, 50, 48, 42, 38, 33, 29, 25, 21, 17, 11, 8, 1, 0, -7, -9, -18, -15,
-29, -18, -62, -119, -89, -83, -63, -54, -36, -24, -8, 4, 20, 33, 48, 62, 77,
89, 48, 41, 37, 29, 25, 17, 13, 6, 1, -6, -11, -18, -24, -31, -35, -41, -47,
-54, -59, -65, -72, -78, -84, -89, -96, -101, -111, -87, -74, -77, -73, -74,
-71, -71, -69, -69, -66, -66, -64, -64, -62, -61, -60, -59, -57, -56, -55, -53,
-52, -51, -50, -49, -47, -46, -45, -44, -43, -41, -40, -39, -37, -36, -35, -34,
-33, -32, -30, -29, -27, -27, -25, -24, -23, -22, -20, -19, -18, -17, -15, -15,
-13, -11, -11, -9, -9, -7, -6, -4, -3, -3, -1, 0, 2, 3, 4, 5, 6, 7, 9, 10, 11,
13, 14, 14, 16, 18, 18, 21, 21, 23, 24, 25, 26, 27, 29, 30, 31, 32, 33, 34, 35,
37, 38, 38, 41, 41, 44, 42, 48, 43, 67, 89, 78, 79, 73, 72, 66, 64, 60, 57, 54,
51, 47, 45, 41, 37, 34, 30, 28, 23, 21, 17, 14, 10, 7, 4, 1, -3, -5, -9, -13,
-16, -19, -22, -26, -29, -32, -34, -39, -41, -46, -47, -53, -54, -60, -60, -66,
-66, -73, -71, -35, -29, -26, -21, -18, -13, -9, -4, -2, 3, 6, 11, 16, 20, 23,
28, 32, 37, 41, 45, 49, 53, 58, 61, 65, 68, 74, 78, 83, 111, 106, 101, 97, 91,
88, 82, 78, 74, 68, 64, 59, 54, 49, 44, 40, 34, 31, 25, 22, 16, 13, 6, 4, -5,
-5, -16, -13, -27, -17, -60, -122, -92, -83, -64, -50, -33, -17, -1, 16, 30, 47,
62, 78, 97, 57, 38, 39, 28, 27, 17, 16, 7, 4, -4, -7, -15, -19, -25, -30, -36,
-42, -47, -53, -58, -64, -68, -75, -79, -86, -90, -97, -101, -108, -111, -82,
-77, -79, -74, -76, -72, -73, -70, -71, -69, -68, -65, -65, -63, -63, -62, -60,
-58, -57, -56, -56, -54, -52, -51, -50, -48, -47, -47, -46, -44, -43, -41, -40,
-39, -38, -36, -35, -34, -32, -32, -30, -30, -28, -26, -25, -24, -23, -22, -20,
-19, -17, -17, -15, -14, -13, -11, -10, -9, -8, -7, -5, -4, -3, -2, 0, };