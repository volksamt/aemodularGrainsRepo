#define DATA_LENGTH 512
#define DATA AKWF_raw_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 1, 1, 1, 1, 2, 3, 2, 4, 2, 6, 3,
6, 3, 7, 3, 8, 4, 9, 4, 11, 3, 15, 116, 113, 102, 98, 88, 86, 75, 71, 60, 57,
47, 43, 34, 28, 20, 13, 5, 0, -8, -15, -22, -29, -35, -43, -49, -57, -62, -72,
-76, -88, -82, -60, -58, -50, -47, -40, -35, -30, -25, -20, -15, -9, -4, 1, 6,
12, 18, 22, 27, 32, 38, 42, 48, 52, 58, 63, 70, 73, 81, 83, 92, 93, 104, 100,
120, 84, 19, 29, 20, 22, 16, 16, 13, 10, 8, 5, 3, -1, -2, -6, -7, -12, -12, -17,
-17, -22, -22, -26, -28, -32, -33, -36, -39, -42, -45, -46, -50, -50, -57, -54,
-66, -35, -6, -13, -7, -9, -6, -6, -4, -3, -2, -1, 1, 1, 4, 5, 6, 7, 8, 9, 10,
12, 13, 14, 16, 17, 17, 19, 20, 22, 21, 24, 24, 26, 25, 30, 16, 4, 8, 5, 6, 4,
6, 3, 4, 2, 3, 1, 1, 0, 1, -1, -1, -3, -2, -3, -3, -4, -3, -5, -4, -6, -6, -7,
-7, -9, -9, -8, -11, -9, -14, -4, -75, -104, -90, -99, -92, -96, -92, -95, -92,
-94, -92, -93, -91, -93, -91, -92, -90, -91, -90, -89, -89, -90, -89, -88, -88,
-88, -88, -87, -88, -87, -87, -86, -87, -86, -85, -85, -84, -85, -84, -84, -83,
-83, -82, -82, -82, -82, -82, -82, -81, -81, -80, -81, -79, -79, -79, -79, -79,
-79, -79, -78, -78, -76, -77, -76, -76, -76, -76, -75, -76, -74, -74, -74, -74,
-73, -73, -73, -72, -72, -72, -72, -72, -72, -71, -71, -70, -70, -70, -69, -69,
-69, -69, -68, -68, -68, -67, -67, -67, -66, -66, -65, -65, -65, -64, -64, -64,
-64, -63, -63, -62, -62, -62, -62, -61, -61, -62, -62, -60, -60, -59, -59, -59,
-59, -58, -58, -58, -58, -57, -57, -57, -57, -56, -56, -55, -55, -55, -54, -55,
-54, -54, -53, -53, -52, -52, -53, -53, -52, -51, -51, -51, -50, -50, -50, -49,
-49, -49, -49, -49, -49, -48, -47, -47, -46, -47, -46, -45, -45, -44, -45, -44,
-44, -44, -43, -43, -44, -42, -43, -42, -42, -41, -41, -41, -41, -40, -41, -40,
-40, -40, -39, -39, -38, -39, -37, -37, -37, -36, -37, -36, -36, -36, -36, -35,
-34, -35, -34, -35, -33, -33, -33, -33, -32, -32, -31, -31, -31, -30, -30, -30,
-30, -29, -29, -28, -29, -28, -28, -28, -28, -27, -27, -26, -26, -26, -26, -26,
-25, -25, -24, -24, -24, -23, -23, -23, -22, -21, -21, -22, -22, -21, -21, -20,
-20, -20, -19, -18, -18, -18, -18, -18, -17, -17, -16, -17, -16, -17, -16, -15,
-15, -14, -15, -15, -13, -14, -13, -14, -13, -12, -13, -12, -12, -11, -10, -11,
-10, -11, -10, -10, -8, -9, -9, -7, -8, -7, -7, -7, -6, -6, -6, -6, -6, -4, -5,
-5, -4, -3, -4, -3, -3, -3, -3, -2, -1, -2, -1, 0, -1, 0, 0, };