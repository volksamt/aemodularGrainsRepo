#define DATA_LENGTH 512
#define DATA AKWF_raw_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 14, 19, 26, 32, 38, 44, 50, 58,
52, 46, 47, 45, 45, 43, 42, 41, 40, 39, 38, 38, 37, 35, 35, 33, 33, 32, 30, 29,
28, 27, 26, 26, 25, 24, 23, 22, 20, 20, 19, 18, 17, 16, 15, 13, 12, 12, 11, 9,
10, 8, 8, 6, 6, 4, 3, 2, 1, 0, 0, -2, -3, -4, -1, 2, 4, 7, 9, 12, 14, 18, 18,
23, 22, 27, 26, 33, 31, 38, 35, 43, 38, 51, 23, -5, 4, -110, -122, -113, -117,
-110, -113, -107, -110, -104, -106, -101, -103, -98, -99, -95, -95, -92, -92,
-89, -87, -86, -84, -82, -81, -79, -78, -75, -74, -73, -70, -70, -68, -66, -64,
-63, -61, -59, -58, -56, -54, -53, -51, -49, -48, -45, -45, -43, -41, -39, -38,
-36, -34, -33, -32, -29, -28, -26, -24, -23, -21, -20, -17, -16, -13, -13, -9,
-12, -5, -9, 0, -8, 16, 68, 58, 62, 60, 59, 59, 59, 58, 56, 57, 56, 56, 54, 55,
54, 53, 52, 52, 51, 51, 51, 50, 49, 49, 48, 48, 46, 47, 46, 45, 45, 44, 44, 44,
43, 42, 41, 41, 40, 39, 40, 38, 38, 38, 38, 36, 35, 35, 34, 34, 33, 33, 32, 33,
32, 31, 31, 30, 29, 28, 29, 28, 28, 26, 26, 25, 25, 25, 24, 23, 23, 22, 21, 21,
21, 20, 20, 19, 19, 17, 17, 17, 16, 16, 16, 15, 14, 14, 13, 13, 12, 12, 11, 11,
10, 10, 9, 9, 8, 8, 8, 7, 7, 6, 5, 5, 4, 4, 4, 3, 3, 2, 2, 1, 0, 1, -1, -1, 0,
-1, -2, -3, -3, -3, -3, -4, -5, -5, -6, -6, -7, -7, -8, -7, -8, -9, -10, -10,
-10, -11, -11, -12, -12, -12, -13, -14, -13, -15, -15, -15, -16, -17, -16, -16,
-17, -18, -18, -18, -19, -19, -20, -20, -21, -21, -21, -22, -22, -22, -23, -23,
-23, -25, -24, -25, -26, -27, -26, -27, -27, -28, -28, -29, -29, -29, -30, -30,
-30, -30, -31, -32, -31, -33, -33, -33, -34, -34, -34, -35, -36, -35, -36, -36,
-36, -37, -37, -38, -37, -38, -39, -39, -40, -40, -40, -41, -42, -41, -42, -43,
-43, -44, -44, -44, -44, -45, -45, -45, -45, -46, -46, -46, -48, -48, -48, -48,
-49, -49, -49, -49, -50, -50, -51, -51, -51, -52, -52, -53, -52, -53, -53, -53,
-54, -54, -55, -55, -55, -56, -56, -56, -56, -57, -57, -58, -58, -58, -59, -59,
-60, -60, -60, -60, -61, -60, -62, -61, -62, -62, -63, -63, -63, -63, -63, -64,
-64, -64, -65, -65, -65, -65, -65, -67, -66, -67, -67, -67, -68, -67, -69, -69,
-69, -70, -70, -70, -71, -70, -71, -71, -71, -71, -72, -72, -72, -72, -72, -73,
-73, -74, -74, -74, -74, -74, -74, -75, -75, -76, -76, -77, -77, -76, -77, -78,
-78, -78, -78, -78, -79, -78, -80, -78, -80, -79, -81, -79, -82, -80, -82, -81,
-83, -80, -83, -80, -84, -79, -8, };