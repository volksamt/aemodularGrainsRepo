#define DATA_LENGTH 512
#define DATA AKWF_raw_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 5, 5, 7, 8, 10, 12, 13, 14,
16, 17, 18, 20, 21, 23, 24, 26, 27, 28, 30, 32, 33, 35, 35, 37, 38, 40, 42, 43,
44, 45, 48, 48, 51, 52, 54, 54, 56, 57, 59, 60, 63, 62, 65, 65, 67, 69, 71, 72,
73, 75, 75, 79, 76, 86, 17, -6, 4, -3, 2, -1, 2, -2, 2, -1, 1, 0, 1, -1, 0, 0,
0, -1, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1,
0, 1, -1, 1, -1, 0, 0, 1, -1, 2, -1, 2, -1, 1, 0, 0, 0, 0, 0, -1, 2, -7, 73, 96,
82, 89, 80, 84, 78, 79, 74, 75, 71, 71, 67, 68, 64, 64, 61, 59, 57, 56, 54, 52,
50, 47, 46, 44, 42, 39, 38, 36, 36, 33, 31, 28, 28, 23, 25, 20, 21, 17, 17, 11,
13, 8, 9, 4, 6, -4, -90, -91, -88, -88, -84, -85, -82, -83, -78, -79, -76, -75,
-72, -72, -69, -69, -66, -65, -63, -63, -59, -58, -57, -56, -53, -53, -50, -49,
-48, -46, -45, -42, -41, -39, -38, -36, -34, -32, -31, -29, -28, -26, -24, -22,
-21, -19, -18, -15, -14, -12, -11, -9, -8, -6, -5, -3, -1, 1, 2, 3, 5, 7, 9, 11,
13, 14, 16, 18, 19, 21, 22, 24, 26, 28, 29, 31, 33, 34, 36, 38, 39, 41, 42, 45,
46, 48, 49, 51, 53, 54, 56, 58, 59, 60, 64, 64, 66, 67, 70, 71, 75, 74, 78, 76,
81, 80, 85, 83, 89, 84, 3, -4, -2, -8, -6, -12, -10, -16, -14, -19, -19, -23,
-22, -26, -26, -30, -31, -34, -35, -37, -39, -40, -43, -45, -47, -48, -51, -52,
-56, -56, -59, -60, -62, -64, -66, -68, -70, -72, -73, -77, -76, -81, -80, -87,
-83, -92, -83, -103, -58, 10, -5, 4, -2, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1,
0, 1, -1, 2, -1, 1, -2, 1, -1, 2, -2, 2, -2, 1, -2, -111, -120, -111, -115,
-107, -109, -101, -103, -96, -99, -92, -93, -87, -88, -83, -83, -79, -77, -73,
-72, -69, -67, -64, -62, -59, -56, -53, -52, -49, -46, -44, -41, -39, -36, -35,
-30, -30, -26, -25, -20, -20, -15, -16, -9, -12, -2, -10, 15, 87, 77, 78, 75,
73, 72, 69, 68, 65, 64, 61, 61, 57, 57, 54, 54, 50, 49, 46, 45, 43, 41, 39, 37,
34, 33, 31, 29, 27, 25, 24, 21, 19, 18, 16, 14, 11, 10, 7, 6, 5, 2, 0, -2, -3,
-6, -8, -9, -12, -13, -16, -18, -19, -21, -23, -25, -27, -29, -31, -33, -34,
-37, -38, -40, -42, -45, -46, -48, -50, -52, -54, -57, -57, -60, -62, -64, -65,
-67, -68, -71, -72, -75, -77, -79, -81, -83, -84, -86, -89, -90, -93, -93, -97,
-96, -102, -100, -107, -104, -111, -106, -116, -108, -123, -100, };