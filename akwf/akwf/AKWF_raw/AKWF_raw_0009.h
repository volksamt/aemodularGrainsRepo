#define DATA_LENGTH 512
#define DATA AKWF_raw_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 3, 4, 5, 6, 8, 7, 10, 9, 12,
11, 15, 13, 18, 13, 21, 10, 43, 108, 94, 100, 94, 94, 92, 91, 90, 88, 87, 85,
85, 82, 81, 79, 79, 77, 75, 73, 73, 70, 69, 67, 67, 65, 63, 62, 61, 59, 58, 57,
55, 53, 51, 50, 49, 47, 46, 44, 43, 42, 40, 39, 38, 36, 34, 34, 32, 31, 29, 29,
26, 24, 23, 21, 20, 18, 18, 17, 14, 13, 11, 10, 9, 7, 6, 5, 3, 1, 1, -2, -3, -4,
-5, -7, -8, -10, -12, -12, -14, -15, -17, -18, -20, -21, -23, -24, -26, -27,
-28, -30, -32, -33, -34, -36, -38, -39, -40, -41, -42, -44, -45, -47, -49, -50,
-52, -52, -55, -56, -58, -58, -59, -62, -63, -65, -67, -67, -68, -71, -73, -75,
-74, -73, -71, -70, -69, -67, -66, -65, -63, -62, -61, -59, -58, -56, -55, -54,
-52, -51, -49, -49, -47, -45, -44, -42, -42, -40, -39, -38, -36, -34, -33, -31,
-31, -30, -28, -27, -25, -23, -22, -21, -20, -19, -17, -16, -15, -13, -11, -10,
-9, -8, -6, -5, -4, -2, -1, 0, 2, 4, 4, 5, 7, 9, 10, 11, 13, 14, 15, 17, 17, 20,
20, 22, 23, 25, 26, 28, 29, 30, 32, 33, 34, 35, 37, 38, 40, 41, 43, 44, 45, 46,
48, 49, 50, 53, 54, 54, 55, 57, 59, 59, 62, 62, 64, 65, 67, 68, 70, 71, 72, 74,
75, 76, 77, 78, 81, 82, 82, 84, 85, 88, 88, 91, 91, 94, 93, 97, 93, 104, 81, 44,
50, 43, 42, 37, 35, 33, 29, 26, 24, 20, 17, 14, 10, 9, 4, 3, -1, -3, -7, -9,
-13, -15, -19, -21, -25, -27, -31, -33, -37, -38, -42, -46, -49, -51, -54, -57,
-60, -63, -65, -70, -68, -107, -121, -113, -115, -110, -110, -106, -106, -103,
-101, -99, -98, -95, -92, -90, -89, -87, -84, -81, -81, -78, -76, -74, -72, -70,
-67, -67, -64, -61, -60, -58, -55, -53, -51, -50, -47, -45, -44, -41, -39, -37,
-35, -33, -31, -29, -26, -24, -23, -20, -18, -16, -15, -12, -11, -8, -5, -4, -2,
0, 2, 4, 6, 7, 10, 13, 15, 16, 19, 20, 23, 24, 27, 28, 31, 32, 36, 36, 39, 40,
44, 45, 48, 48, 20, 15, 14, 9, 7, 3, 1, -4, -6, -10, -12, -16, -19, -22, -26,
-29, -33, -36, -39, -43, -46, -49, -53, -55, -59, -61, -65, -68, -72, -74, -78,
-82, -84, -88, -90, -95, -97, -102, -102, -109, -108, -118, -102, -67, -74, -69,
-71, -68, -68, -67, -66, -65, -63, -63, -61, -60, -58, -59, -58, -56, -56, -54,
-53, -53, -51, -50, -50, -49, -48, -47, -45, -45, -43, -43, -41, -41, -40, -38,
-38, -37, -37, -35, -33, -33, -32, -31, -30, -29, -28, -27, -26, -25, -24, -23,
-22, -20, -21, -19, -18, -18, -16, -15, -14, -13, -12, -12, -10, -9, -8, -7, -6,
-6, -5, -3, -3, -1, -1, };