#define DATA_LENGTH 512
#define DATA AKWF_raw_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 2, 2, 2, 3, 3, 4, 5, 5, 5, 7, 7,
7, 8, 9, 8, 10, 10, 11, 12, 13, 12, 13, 14, 15, 15, 16, 17, 17, 18, 19, 19, 20,
21, 21, 21, 23, 23, 24, 24, 25, 25, 26, 27, 28, 28, 28, 29, 30, 30, 30, 32, 33,
33, 33, 34, 34, 35, 36, 36, 37, 38, 38, 39, 40, 40, 41, 41, 41, 42, 43, 43, 44,
45, 46, 46, 46, 47, 47, 48, 48, 49, 49, 50, 51, 51, 52, 52, 53, 53, 54, 56, 55,
56, 57, 57, 58, 58, 58, 60, 60, 60, 60, 62, 62, 63, 63, 64, 64, 65, 65, 66, 67,
67, 68, 69, 69, 69, 70, 71, 71, 71, 72, 73, 74, 73, 74, 74, 75, 75, 76, 77, 77,
77, 78, 79, 80, 79, 80, 81, 82, 82, 83, 83, 83, 85, 85, 86, 86, 86, 87, 88, 88,
88, 89, 90, 91, 90, 91, 92, 92, 93, 93, 94, 94, 95, 95, 96, 96, 96, 97, 97, 99,
99, 99, 100, 100, 101, 101, 101, 102, 103, 103, 103, 105, 105, 106, 106, 107,
107, 107, 107, 116, 109, 55, -23, -93, -120, -111, -107, -105, -103, -101, -99,
-97, -96, -94, -92, -90, -87, -86, -84, -81, -80, -78, -76, -73, -72, -69, -67,
-65, -64, -60, -59, -57, -55, -53, -51, -50, -48, -45, -43, -41, -40, -38, -35,
-33, -31, -30, -28, -25, -23, -21, -19, -17, -16, -13, -11, -9, -7, -5, -3, 1,
-2, -13, -25, -36, -47, -58, -68, -81, -92, -93, -89, -87, -84, -82, -80, -78,
-75, -74, -71, -70, -68, -66, -64, -61, -59, -57, -56, -53, -51, -49, -47, -44,
-43, -41, -38, -36, -34, -32, -30, -28, -26, -24, -22, -20, -17, -16, -13, -11,
-9, -7, -7, -2, 10, -20, -89, -112, -100, -97, -96, -94, -92, -90, -88, -86,
-84, -83, -81, -79, -77, -75, -74, -72, -71, -68, -66, -65, -63, -61, -59, -57,
-55, -54, -52, -49, -48, -46, -45, -42, -40, -38, -37, -35, -34, -32, -30, -27,
-26, -24, -22, -21, -19, -17, -15, -14, -11, -10, -7, -6, -6, -1, 22, 33, 25,
19, 15, 9, 4, -3, -7, -12, -18, -22, -28, -34, -39, -44, -48, -55, -60, -64,
-70, -75, -80, -87, -97, -82, -35, 53, 115, 119, 115, 113, 114, 112, 110, 109,
107, 105, 104, 102, 101, 100, 99, 96, 95, 95, 93, 91, 90, 88, 87, 85, 84, 83,
81, 80, 78, 77, 76, 75, 72, 72, 70, 69, 67, 66, 64, 62, 62, 60, 58, 57, 55, 55,
53, 51, 50, 48, 47, 46, 44, 42, 41, 40, 38, 36, 35, 34, 33, 31, 29, 28, 27, 25,
24, 22, 21, 20, 18, 16, 15, 14, 12, 10, 10, 8, 6, 5, 4, 3, 1, -2, -2, -4, -5,
-6, -8, -10, -11, -13, -13, -15, -17, -18, -17, -14, -12, -13, -13, -11, -10,
-11, -9, -9, -8, -7, -7, -7, -7, -6, -5, -4, -3, -3, -2, -1, 0, 0, };