#define DATA_LENGTH 512
#define DATA AKWF_raw_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 4, 4, 6, 8, 8, 10, 11, 12,
12, 14, 14, 17, 17, 19, 20, 21, 23, 23, 25, 27, 26, 28, 29, 30, 31, 33, 35, 36,
37, 37, 39, 41, 42, 41, 43, 44, 45, 47, 49, 49, 51, 51, 54, 54, 55, 56, 57, 58,
60, 61, 62, 62, 65, 66, 67, 68, 69, 71, 72, 72, 73, 74, 76, 78, 78, 79, 80, 81,
83, 84, 85, 87, 87, 88, 90, 92, 92, 94, 95, 96, 97, 98, 99, 100, 102, 103, 105,
105, 106, 107, 110, 109, 112, 112, 115, 113, 118, 114, 115, 44, 1, 5, -8, -10,
-21, -22, -34, -35, -46, -47, -60, -61, -73, -73, -87, -84, -101, -94, -119,
-70, 124, 112, 109, 106, 99, 99, 91, 92, 82, 83, 74, 74, 66, 66, 57, 57, 49, 49,
42, 41, 33, 33, 25, 24, 17, 15, 9, 7, 2, -3, -6, -12, -6, -87, -101, -90, -96,
-90, -93, -88, -90, -86, -89, -85, -86, -84, -84, -83, -82, -80, -80, -79, -77,
-77, -75, -74, -73, -73, -72, -71, -71, -70, -69, -68, -66, -66, -64, -64, -63,
-62, -61, -61, -60, -58, -58, -56, -56, -55, -54, -53, -53, -51, -51, -50, -48,
-47, -46, -46, -46, -44, -43, -42, -42, -41, -40, -39, -37, -37, -36, -35, -35,
-34, -33, -32, -31, -30, -29, -29, -27, -28, -26, -26, -25, -24, -22, -22, -21,
-19, -18, -18, -16, -15, -15, -14, -13, -12, -11, -10, -10, -8, -7, -6, -6, -4,
-4, -3, -1, 0, 0, 1, 2, 3, 4, 5, 6, 6, 8, 8, 10, 10, 11, 12, 13, 13, 15, 16, 18,
17, 19, 20, 20, 22, 22, 24, 24, 25, 25, 27, 28, 28, 30, 30, 32, 31, 33, 34, 34,
35, 36, 37, 38, 39, 40, 41, 42, 43, 43, 44, 45, 46, 47, 47, 49, 50, 51, 51, 52,
53, 54, 54, 55, 56, 58, 58, 59, 61, 61, 61, 62, 63, 64, 66, 65, 67, 67, 69, 70,
70, 71, 72, 72, 74, 75, 74, 76, 77, 77, 78, 80, 79, 83, 81, 84, 83, 80, 27, 4,
2, -9, -11, -20, -23, -34, -37, -46, -48, -60, -61, -74, -74, -88, -84, -103,
-93, -124, -48, 127, 107, 111, 103, 101, 97, 92, 90, 83, 81, 75, 73, 66, 65, 57,
58, 50, 50, 41, 41, 32, 32, 24, 23, 16, 15, 7, 7, 0, -1, -8, -10, -11, -110,
-120, -111, -115, -110, -112, -107, -111, -106, -107, -103, -105, -101, -103,
-99, -100, -96, -97, -95, -94, -92, -91, -91, -90, -88, -88, -86, -84, -83, -81,
-82, -80, -79, -78, -77, -75, -74, -73, -72, -71, -69, -69, -67, -66, -65, -64,
-62, -61, -61, -59, -57, -57, -56, -54, -54, -52, -52, -50, -49, -48, -47, -45,
-44, -43, -41, -40, -39, -39, -37, -35, -34, -34, -32, -31, -30, -29, -27, -26,
-25, -24, -22, -22, -21, -20, -19, -17, -16, -15, -14, -12, -12, -11, -10, -8,
-7, -6, -5, -4, -2, -1, };