#define DATA_LENGTH 512
#define DATA AKWF_raw_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 4, 6, 7, 8, 10, 12, 12, 13,
15, 17, 19, 20, 21, 22, 23, 25, 27, 28, 29, 31, 32, 33, 35, 36, 38, 39, 40, 41,
43, 45, 45, 48, 49, 50, 51, 53, 54, 55, 56, 58, 60, 61, 63, 64, 65, 67, 68, 69,
71, 72, 73, 75, 76, 78, 78, 80, 81, 84, 84, 86, 86, 89, 90, 91, 92, 94, 95, 97,
98, 100, 100, 104, 103, 106, 106, 108, 109, 110, 113, 112, 116, 114, 124, 64,
39, 45, 35, 36, 28, 28, 22, 20, 15, 13, 7, 5, 1, -3, -6, -9, -13, -17, -21, -24,
-27, -31, -34, -39, -42, -46, -50, -53, -57, -59, -65, -67, -72, -73, -80, -80,
-88, -86, -96, -92, -106, -90, 5, 1, 4, 6, 8, 10, 11, 14, 14, 18, 18, 22, 22,
26, 26, 31, 31, 35, 34, 39, 38, 43, 41, 48, 33, 7, 9, 2, 0, 0, 6, 7, 15, 16, 15,
15, 14, 13, 11, 11, 10, 9, 8, 7, 5, 5, 4, 5, 2, 3, -1, 1, -6, -23, -20, -21,
-18, -18, -17, -17, -15, -14, -13, -13, -11, -11, -9, -9, -7, -7, -5, -5, -3,
-3, -2, -1, 1, 0, 2, 3, 3, 5, 5, 8, 6, 10, 8, 13, 9, 17, 9, 20, 6, 46, 127, 114,
120, 115, 117, 115, 115, 115, 113, 113, 112, 113, 110, 111, 108, 110, 107, 107,
106, 107, 105, 106, 103, 104, 103, 102, 102, 101, 100, 99, 98, 97, 98, 96, 96,
96, 95, 94, 93, 92, 92, 91, 91, 90, 90, 89, 88, 87, 87, 86, 86, 84, 84, 83, 83,
82, 81, 81, 79, 80, 79, 78, 77, 77, 76, 75, 75, 74, 73, 73, 72, 71, 70, 70, 69,
69, 69, 67, 67, 66, 66, 65, 64, 63, 62, 62, 61, 60, 60, 59, 58, 58, 57, 57, 55,
55, 55, 55, 54, 53, 52, 50, 51, 50, 49, 48, 48, 48, 47, 46, 45, 44, 44, 43, 43,
42, 41, 40, 40, 40, 38, 38, 37, 37, 36, 35, 35, 34, 33, 33, 32, 32, 31, 30, 29,
29, 28, 28, 26, 26, 25, 25, 24, 24, 22, 22, 22, 20, 21, 19, 19, 18, 17, 16, 16,
16, 14, 14, 13, 12, 12, 11, 11, 10, 9, 8, 8, 7, 6, 7, 5, 4, 4, 3, 3, 1, 1, 0, 0,
0, -1, -3, -3, -3, -4, -4, -6, -6, -7, -8, -8, -8, -11, -10, -11, -11, -13, -12,
-13, -13, -15, -14, -17, -16, -18, -18, -19, -20, -19, -24, -15, -88, -114, -99,
-107, -99, -102, -97, -98, -95, -96, -92, -92, -90, -89, -88, -86, -84, -84,
-82, -80, -79, -78, -76, -74, -74, -71, -72, -69, -68, -66, -66, -64, -63, -62,
-60, -58, -58, -55, -55, -53, -52, -50, -49, -48, -47, -45, -44, -42, -41, -40,
-38, -36, -36, -34, -32, -31, -30, -29, -27, -26, -24, -23, -22, -20, -18, -17,
-16, -14, -13, -11, -11, -9, -8, -6, -6, -4, -2, 0, };