#define DATA_LENGTH 512
#define DATA AKWF_raw_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 2, 4, 5, 6, 6, 8, 9, 10, 10,
11, 12, 13, 13, 14, 16, 15, 17, 18, 18, 19, 21, 21, 22, 22, 24, 25, 25, 25, 28,
28, 29, 30, 31, 31, 33, 34, 34, 35, 36, 37, 38, 39, 39, 40, 41, 42, 43, 44, 44,
45, 46, 48, 48, 48, 49, 51, 52, 52, 54, 55, 55, 56, 58, 57, 59, 60, 61, 62, 62,
63, 64, 65, 67, 67, 69, 69, 69, 70, 72, 72, 72, 74, 75, 76, 77, 78, 78, 79, 80,
81, 82, 84, 83, 85, 85, 88, 86, 91, 80, 60, 62, 56, 54, 49, 47, 44, 40, 37, 34,
30, 27, 24, 20, 17, 14, 11, 7, 4, 1, -3, -5, -9, -12, -16, -19, -22, -26, -29,
-32, -36, -40, -41, -46, -48, -57, -59, -55, -54, -51, -49, -45, -43, -41, -38,
-35, -33, -31, -28, -25, -22, -20, -18, -16, -12, -10, -7, -5, -2, -1, 3, 5, 8,
10, 13, 14, 18, 20, 22, 25, 28, 31, 33, 35, 38, 40, 43, 44, 49, 50, 53, 54, 59,
58, 66, 93, 88, 86, 83, 80, 77, 73, 71, 68, 64, 61, 58, 55, 52, 48, 46, 42, 40,
36, 33, 30, 27, 24, 22, 18, 16, 11, 9, 5, 3, 0, -4, -7, -10, -14, -16, -19, -22,
-25, -28, -32, -35, -37, -41, -43, -48, -48, -55, -49, -98, -126, -114, -119,
-113, -114, -111, -112, -109, -108, -106, -107, -105, -104, -103, -101, -100,
-99, -97, -96, -95, -93, -93, -91, -90, -89, -87, -86, -85, -84, -83, -82, -80,
-79, -78, -76, -76, -74, -73, -72, -71, -69, -67, -67, -65, -65, -63, -62, -61,
-60, -58, -56, -56, -54, -53, -53, -51, -49, -48, -47, -46, -44, -44, -42, -41,
-40, -38, -37, -36, -34, -34, -33, -31, -30, -29, -27, -27, -25, -23, -23, -21,
-21, -19, -18, -16, -16, -14, -13, -11, -10, -10, -8, -7, -7, -5, -4, -2, -2, 1,
2, 2, 5, 6, 7, 8, 9, 11, 11, 12, 14, 14, 16, 17, 19, 20, 22, 22, 24, 25, 26, 27,
29, 30, 31, 32, 34, 35, 35, 36, 38, 40, 41, 42, 43, 44, 46, 47, 48, 49, 50, 52,
53, 54, 55, 56, 58, 59, 61, 61, 62, 64, 65, 67, 68, 69, 70, 71, 72, 74, 75, 75,
78, 78, 80, 81, 83, 84, 85, 86, 87, 88, 90, 91, 94, 92, 86, 81, 76, 73, 67, 62,
57, 52, 47, 43, 38, 34, 29, 24, 19, 15, 9, 5, 0, -4, -10, -15, -20, -24, -28,
-34, -39, -43, -48, -53, -57, -63, -66, -72, -76, -82, -85, -94, -94, -104,
-103, -115, -105, -49, -52, -51, -50, -49, -47, -47, -45, -46, -43, -44, -41,
-42, -40, -41, -38, -38, -37, -37, -35, -35, -33, -32, -31, -30, -30, -28, -29,
-27, -26, -25, -24, -24, -22, -21, -21, -19, -19, -18, -17, -16, -15, -14, -13,
-12, -11, -11, -9, -8, -7, -6, -5, -4, -4, -2, -2, -2, 0, };