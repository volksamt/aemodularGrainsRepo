#define DATA_LENGTH 512
#define DATA AKWF_raw_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 2, 3, 4, 5, 5, 6, 6, 7, 8, 9,
9, 10, 11, 11, 12, 13, 13, 14, 14, 16, 15, 17, 17, 17, 18, 19, 20, 21, 22, 22,
23, 23, 24, 25, 26, 26, 27, 27, 29, 29, 30, 30, 31, 32, 32, 33, 34, 34, 35, 36,
37, 38, 38, 38, 39, 40, 40, 42, 41, 42, 44, 43, 45, 45, 46, 47, 47, 48, 49, 49,
50, 51, 52, 52, 53, 53, 54, 55, 56, 56, 58, 58, 58, 59, 60, 61, 62, 61, 63, 63,
64, 64, 66, 66, 67, 67, 68, 69, 69, 70, 71, 71, 72, 73, 73, 74, 75, 75, 76, 77,
78, 78, 79, 79, 80, 80, 81, 82, 84, 83, 84, 86, 86, 87, 88, 88, 88, 89, 90, 91,
91, 91, 92, 93, 94, 94, 95, 95, 97, 98, 98, 99, 99, 100, 100, 102, 101, 103,
103, 104, 104, 106, 107, 107, 108, 108, 109, 108, 112, 109, 113, 110, 116, 111,
119, 108, 127, 80, -7, 9, 0, 4, 1, 3, 1, 0, 0, -1, 0, -3, -2, -4, -3, -4, -4,
-6, -5, -7, -6, -8, -8, -9, -9, -10, -11, -10, -10, -12, -12, -14, -13, -15,
-14, -15, -15, -17, -16, -18, -17, -20, -19, -20, -19, -23, -20, -23, -21, -26,
-107, -109, -105, -107, -101, -104, -100, -100, -96, -97, -94, -94, -91, -91,
-89, -88, -86, -85, -82, -82, -81, -79, -78, -77, -74, -74, -72, -71, -69, -67,
-66, -65, -64, -61, -61, -60, -58, -56, -55, -53, -52, -50, -48, -47, -47, -44,
-43, -42, -41, -38, -37, -36, -34, -33, -31, -30, -29, -28, -26, -25, -23, -22,
-19, -20, -16, -16, -13, -14, -11, -10, -9, -6, -6, -4, -4, 0, -3, 7, -9, 83,
127, 110, 120, 110, 116, 108, 112, 107, 109, 105, 107, 103, 103, 101, 100, 98,
97, 97, 95, 94, 91, 91, 89, 89, 86, 86, 85, 84, 82, 81, 80, 79, 77, 76, 74, 74,
72, 70, 69, 67, 67, 66, 63, 62, 61, 60, 58, 58, 56, 55, 54, 53, 51, 50, 48, 47,
45, 45, 44, 42, 40, 39, 39, 37, 36, 34, 33, 32, 30, 29, 28, 27, 26, 24, 22, 22,
20, 18, 17, 17, 15, 13, 12, 11, 10, 9, 8, 6, 4, 3, 2, 1, 0, -1, -3, -4, -6, -7,
-7, -9, -11, -12, -13, -15, -16, -17, -18, -20, -21, -22, -23, -25, -25, -27,
-28, -30, -31, -33, -34, -35, -37, -38, -39, -41, -41, -43, -44, -45, -47, -47,
-48, -50, -51, -53, -54, -56, -57, -58, -60, -60, -63, -63, -65, -65, -67, -69,
-70, -71, -72, -74, -76, -76, -77, -79, -79, -82, -83, -84, -86, -86, -88, -89,
-91, -92, -93, -94, -94, -99, -97, -101, -99, -104, -101, -108, -101, -115, -86,
-16, -26, -20, -22, -20, -19, -19, -18, -18, -16, -17, -14, -15, -13, -14, -13,
-12, -11, -12, -9, -10, -9, -8, -7, -7, -6, -5, -4, -4, -2, -2, -2, -1, -1, };