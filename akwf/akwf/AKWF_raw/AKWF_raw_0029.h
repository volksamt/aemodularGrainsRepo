#define DATA_LENGTH 512
#define DATA AKWF_raw_0029

const PROGMEM int8_t DATA[DATA_LENGTH] = {103, 119, 102, 105, 92, 93, 81, 81,
70, 69, 59, 56, 48, 45, 37, 32, 28, 19, 18, 4, 12, -55, -96, -74, -77, -64, -64,
-54, -50, -43, -39, -31, -25, -21, -13, -9, -1, 3, 11, 15, 22, 26, 35, 39, 47,
52, 58, 64, 69, 76, 80, 89, 91, 103, 100, 123, 47, -9, 0, -20, -19, -34, -37,
-49, -52, -67, -67, -88, -36, 15, 9, 13, 8, 12, 9, 10, 8, 9, 7, 7, 6, 6, 6, 5,
4, 4, 3, 2, 2, 1, 1, 0, 0, -2, -1, -2, -1, -3, -4, -4, -4, -6, -5, -7, -7, -7,
-8, -9, -9, -9, -10, -11, -12, -11, -12, -7, -4, -5, -3, -3, -3, -2, -3, -2, -1,
-2, 0, 0, 0, 1, 1, 1, 2, 3, 3, 3, 4, 4, 5, 5, 6, 7, 7, 8, 8, 7, 9, 10, 10, 10,
10, 11, 11, 12, 12, 11, 11, 10, 10, 9, 9, 8, 8, 8, 8, 7, 6, 6, 5, 5, 4, 4, 4, 4,
3, 2, 2, 1, 1, 1, 0, 0, 0, -1, -1, -3, -2, -3, -3, -5, -3, -6, -3, -12, -28,
-24, -24, -23, -22, -21, -20, -18, -18, -17, -16, -15, -14, -13, -13, -12, -10,
-10, -8, -8, -7, -6, -5, -4, -3, -2, -1, 0, 1, 1, 3, 3, 4, 6, 7, 6, 8, 9, 11, 9,
3, 4, 3, 2, 2, 2, 1, 0, 0, 0, 0, -2, -2, -3, -4, -4, -5, -5, -7, -6, -8, -7, -8,
-9, -9, -10, -11, -11, -11, -13, -12, -14, -14, -15, -15, -15, -16, -17, -17,
-17, -18, -19, -20, -20, -21, -21, -21, -22, -23, -23, -24, -24, -26, -22, -16,
-18, -16, -16, -16, -16, -15, -15, -15, -15, -14, -13, -12, -12, -12, -12, -11,
-11, -10, -11, -10, -10, -9, -9, -8, -8, -8, -8, -7, -7, -6, -6, -6, -5, -5, -5,
-3, -4, -3, -3, -2, -2, -1, -1, -1, -1, 0, -1, 0, 1, 1, 2, 2, 2, 3, 4, 3, 5, 2,
16, 21, 18, 19, 16, 17, 16, 16, 14, 15, 15, 15, 14, 12, 11, 11, 11, 11, 11, 9,
8, 9, 8, 8, 7, 7, 6, 6, 5, 4, 5, 4, 3, 3, 2, 2, 1, 1, 0, 0, 0, -2, -2, -2, -3,
-4, -4, -5, -5, -5, -5, -7, -8, -7, -9, -8, -9, -10, -10, -11, -12, -12, -12,
-12, -13, -13, -14, -14, -16, -15, -18, -14, -23, -41, -38, -38, -37, -36, -35,
-34, -34, -32, -32, -31, -31, -29, -28, -27, -27, -26, -25, -24, -22, -21, -21,
-20, -20, -18, -17, -16, -16, -15, -14, -14, -13, -13, -12, -10, -9, -8, -8, -7,
-6, -5, -4, -3, -2, -1, -1, 0, 1, 2, 3, 3, 5, 5, 6, 8, 8, 9, 10, 10, 12, 13, 13,
15, 14, 16, 16, 18, 17, 1, -1, -3, -6, -7, -9, -11, -12, -13, -17, -17, -21,
-20, -23, -24, -26, -27, -30, -31, -34, -34, -38, -38, -6, };