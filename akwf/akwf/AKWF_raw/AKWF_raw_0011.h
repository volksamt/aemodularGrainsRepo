#define DATA_LENGTH 512
#define DATA AKWF_raw_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 117, 98, 96, 82, 79, 66, 61, 49,
44, 32, 27, 15, 9, -2, -8, -20, -25, -36, -43, -52, -61, -68, -95, -90, -79,
-72, -63, -54, -45, -36, -27, -19, -11, -1, 6, 17, 25, 34, 41, 51, 59, 69, 76,
87, 93, 107, 106, 70, 65, 57, 51, 45, 37, 32, 24, 19, 10, 6, -3, -8, -16, -22,
-29, -34, -42, -49, -55, -62, -67, -77, -79, -94, -71, -45, -47, -38, -36, -28,
-26, -20, -15, -10, -5, 0, 5, 9, 15, 18, 24, 28, 35, 38, 45, 48, 55, 57, 64, 67,
41, 34, 32, 28, 25, 20, 18, 13, 11, 6, 3, -1, -4, -8, -11, -15, -19, -22, -26,
-28, -34, -35, -41, -42, -50, -42, -24, -25, -21, -19, -16, -13, -11, -8, -6,
-3, 0, 3, 5, 8, 9, 13, 16, 18, 20, 24, 25, 29, 31, 33, 37, 25, 18, 18, 16, 14,
12, 11, 7, 6, 4, 2, 1, -1, -3, -5, -7, -9, -11, -13, -15, -17, -18, -21, -22,
-26, -24, -13, -13, -11, -9, -8, -6, -6, -4, -2, -1, 1, 2, 3, 4, 5, 7, 8, 9, 11,
13, 15, 15, 17, 18, 20, 14, 9, 10, 9, 8, 6, 7, 4, 4, 3, 2, 0, -1, -2, -3, -3,
-4, -6, -6, -8, -9, -10, -10, -12, -13, -8, -8, -7, -5, -5, -4, -3, -3, -2, -1,
0, 0, 1, 1, 2, 3, 4, 4, 6, 6, 6, 7, 9, 9, 9, 10, 8, 3, 4, 4, 2, 2, 2, 1, 1, 0,
0, 0, -1, -2, -3, -4, -3, -4, -4, -5, -6, -6, -7, -7, -8, -6, -5, -4, -4, -4,
-3, -3, -3, -2, -2, -2, 0, -1, 0, 0, 1, 1, 1, 2, 2, 3, 2, 3, 3, 4, 5, 3, 2, 1,
1, 1, 2, 1, 0, 1, 0, 0, 0, -1, -2, -2, -1, -2, -2, -3, -3, -4, -3, -4, -4, -6,
-4, -3, -3, -2, -2, -2, -2, -1, -1, -1, -1, 0, 0, 0, 1, 0, 1, 1, 0, 1, 2, 1, 2,
2, 2, 1, 0, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, -1, -1, -2, -1, -2, -1, -2, -2,
-2, -3, -3, -2, -2, -1, -1, -1, -2, -1, -1, 0, -1, -1, 0, 0, 0, 0, 0, 1, 0, 1,
1, 0, 1, 1, 1, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0,
-1, -2, -1, 0, -1, -1, -2, -1, -1, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0,
0, -1, 0, 1, 1, 0, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 1, -2,
1, -1, 0, -1, 1, -1, -1, 0, -1, 3, -66, -80, -70, -73, -65, -67, -60, -62, -56,
-56, -52, -51, -46, -46, -41, -40, -37, -35, -32, -30, -28, -25, -22, -19, -17,
-14, -13, -9, -7, -5, -2, };