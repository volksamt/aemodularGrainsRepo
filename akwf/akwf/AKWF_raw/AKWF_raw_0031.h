#define DATA_LENGTH 512
#define DATA AKWF_raw_0031

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -4, -5, -9, -11, -14, -112, -110,
-92, -84, -69, -60, -44, -34, -21, -9, 2, 18, 97, 84, 66, 52, 33, 21, 0, -11,
-33, -42, -68, -72, -105, -76, -14, -16, -3, 5, 12, 21, 26, 38, 42, 54, 58, 71,
75, 87, 88, 18, 11, 14, 7, 10, 3, 5, 1, 2, -3, -2, -6, -6, -10, -10, -13, -15,
-16, -18, -19, -23, -16, -11, -11, -10, -8, -8, -7, -6, -5, -4, -3, -1, -1, 1,
2, 3, 3, 6, 6, 8, 9, 10, 10, 13, 11, 16, 27, 24, 21, 18, 15, 12, 9, 7, 4, 0, -2,
-7, -5, -25, -43, -31, -28, -20, -17, -9, -4, 3, 7, 14, 19, 25, 25, 21, 19, 16,
13, 9, 7, 4, 2, -2, -5, -8, -10, -14, -16, -20, -22, -26, -28, -31, -33, -40,
-32, -20, -21, -18, -18, -15, -14, -13, -11, -10, -9, -7, -6, -5, -3, -2, 0, 1,
2, 4, 5, 6, 8, 9, 10, 12, 14, 14, 17, 17, 19, 20, 21, 22, 25, 22, 18, 17, 15,
14, 13, 11, 8, 7, 5, 3, 2, 1, -2, -3, -5, -7, -9, -10, -12, -14, -15, -17, -19,
-20, -15, -11, -9, -5, -3, 1, 3, 7, 10, 14, 15, 28, 31, 27, 24, 20, 18, 13, 11,
7, 4, 0, -1, -6, -7, -12, -17, -13, -7, -4, 0, 3, 8, 12, 18, 19, 27, 24, 4, 5,
2, 0, -3, -4, -7, -9, -10, -12, -15, -16, -12, -12, -9, -9, -6, -6, -3, -2, 0,
0, 5, 2, 16, 28, 21, 20, 17, 16, 12, 9, 7, 4, 2, -1, -3, -7, -8, -14, -23, -19,
-16, -13, -10, -6, -1, 1, 5, 9, 12, 15, 19, 24, 17, 10, 8, 4, 2, -2, -4, -8,
-10, -14, -16, -21, -19, -16, -16, -13, -12, -11, -10, -9, -8, -7, -5, -4, -2,
-1, 0, 2, 3, 4, 5, 7, 9, 8, 11, 10, 31, 30, 23, 20, 13, 9, 4, 0, -8, -9, -25,
-30, -22, -19, -13, -10, -4, 0, 6, 10, 15, 20, 24, 29, 12, 7, 4, -2, -5, -9,
-12, -18, -21, -28, -15, -6, -5, 0, 2, 5, 8, 8, 5, 4, 2, 1, -2, -3, -5, -7, -9,
-12, -11, -9, -8, -6, -4, -3, -1, 0, 2, 4, 4, 17, 22, 17, 17, 14, 13, 10, 10, 7,
5, 3, 2, 0, -1, -4, -4, -8, -8, -11, -38, -38, -33, -31, -26, -25, -20, -18,
-14, -12, -7, -5, -1, 2, 6, 8, 13, 15, 20, 30, 23, 20, 15, 11, 6, 2, -3, -8,
-13, -17, -22, -27, -31, -37, -27, -20, -16, -10, -5, -1, 4, 10, 15, 19, 24, 24,
22, 21, 18, 15, 13, 11, 9, 7, 4, 3, 0, -2, -3, -6, -8, -9, -11, -14, -16, -18,
-20, -23, -19, -14, -15, -12, -10, -8, -6, -4, -3, -1, 1, 3, 4, 7, 8, 10, 12,
14, 16, 17, 20, 21, 24, 25, 22, 20, 16, 13, 11, 8, 4, 2, };