#define DATA_LENGTH 512
#define DATA AKWF_raw_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 10, 13, 16, 19, 23, 26, 30, 31,
36, 39, 43, 46, 49, 53, 54, 110, 118, 106, 105, 95, 93, 84, 81, 73, 70, 63, 58,
51, 47, 40, 36, 30, 24, 19, 13, 8, 2, -4, -9, -14, -21, -26, -32, -37, -43, -48,
-54, -60, -66, -71, -77, -82, -87, -93, -99, -105, -80, -72, -71, -64, -60, -55,
-52, -46, -43, -38, -34, -28, -24, -20, -16, -11, -8, -2, 1, 7, 11, 15, 20, 24,
28, 33, 37, 41, 47, 51, 55, 59, 64, 69, 73, 78, 82, 87, 90, 96, 99, 105, 107,
117, 100, 84, 87, 83, 85, 81, 82, 79, 79, 77, 76, 74, 74, 71, 70, 69, 68, 67,
66, 65, 64, 63, 61, 60, 59, 58, 56, 55, 53, 53, 51, 51, 49, 48, 47, 45, 45, 43,
42, 41, 40, 39, 37, 37, 34, 33, 32, 31, 29, 28, 27, 26, 25, 24, 22, 21, 20, 19,
19, 16, 15, 15, 13, 12, 12, 9, 8, 7, 6, 4, 4, 2, 1, 0, -2, -2, -5, -5, -6, -7,
-9, -9, -11, -12, -13, -14, -16, -18, -18, -20, -20, -23, -23, -25, -25, -27,
-28, -28, -30, -31, -32, -34, -35, -37, -37, -39, -40, -40, -43, -44, -45, -46,
-47, -49, -50, -51, -52, -53, -55, -55, -57, -57, -59, -61, -62, -63, -65, -65,
-66, -68, -68, -71, -71, -73, -74, -76, -75, -80, -90, -84, -80, -75, -70, -67,
-62, -57, -53, -49, -44, -40, -35, -31, -25, -21, -16, -12, -7, -3, 2, 7, 10,
15, 20, 25, 28, 34, 38, 43, 46, 51, 56, 62, 64, 70, 73, 80, 80, 33, 26, 25, 20,
18, 13, 12, 7, 6, 1, -1, -5, -7, -12, -13, -18, -20, -25, -26, -31, -34, -38,
-41, -44, -47, -50, -54, -56, -60, -62, -68, -69, -75, -73, -83, -78, -94, -56,
-12, -23, -14, -18, -14, -14, -12, -11, -10, -9, -8, -7, -6, -4, -4, -2, -1, 1,
1, 4, 2, 5, 6, 7, 8, 9, 10, 12, 13, 14, 15, 17, 17, 18, 20, 21, 22, 23, 25, 26,
27, 27, 30, 29, 19, 18, 16, 14, 12, 11, 10, 8, 7, 6, 4, 3, 1, 0, -2, -4, -5, -7,
-9, -11, -12, -14, -15, -18, -16, -25, -32, -28, -28, -25, -25, -22, -22, -20,
-18, -17, -15, -13, -12, -11, -10, -7, -6, -4, -3, -1, 1, 1, 3, 4, 7, 7, 10, 10,
14, 12, 17, 13, 28, 63, 55, 56, 54, 53, 51, 49, 47, 46, 45, 43, 42, 39, 38, 36,
35, 33, 32, 31, 29, 27, 26, 24, 23, 21, 20, 17, 17, 15, 14, 11, 11, 8, 8, 5, 5,
2, 2, -1, -3, -4, -6, -7, -9, -9, -12, -13, -15, -15, -20, -18, -23, -20, -26,
-22, -32, -22, -51, -117, -103, -104, -98, -96, -93, -89, -86, -82, -80, -76,
-74, -69, -67, -62, -60, -56, -54, -49, -47, -43, -40, -36, -33, -29, -27, -23,
-20, -15, -12, -9, -7, -4, 0, };