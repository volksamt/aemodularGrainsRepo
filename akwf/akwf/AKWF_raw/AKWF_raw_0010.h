#define DATA_LENGTH 512
#define DATA AKWF_raw_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {96, 113, 101, 106, 98, 101, 94, 96,
91, 90, 86, 86, 82, 81, 77, 76, 72, 72, 67, 66, 63, 62, 59, 57, 55, 52, 50, 48,
45, 42, 41, 39, 36, 34, 32, 30, 27, 25, 22, 20, 18, 15, 13, 11, 9, 6, 4, 2, -1,
-2, -5, -7, -10, -12, -15, -17, -19, -21, -24, -26, -29, -31, -32, -35, -38,
-40, -42, -45, -45, -49, -50, -54, -54, -59, -59, -64, -65, -68, -69, -73, -72,
-80, -118, -117, -114, -113, -109, -108, -105, -104, -100, -99, -96, -94, -91,
-90, -87, -86, -83, -80, -78, -76, -73, -72, -68, -67, -65, -63, -60, -57, -55,
-53, -51, -49, -47, -45, -42, -40, -38, -35, -33, -32, -28, -26, -25, -22, -20,
-18, -14, -13, -10, -8, -6, -4, -1, 1, 3, 5, 8, 10, 12, 14, 17, 19, 20, 24, 25,
28, 30, 33, 35, 37, 40, 41, 44, 46, 49, 50, 53, 55, 58, 60, 62, 64, 67, 69, 71,
73, 76, 77, 79, 83, 85, 86, 88, 91, 94, 95, 98, 99, 102, 102, 109, 95, 79, 79,
72, 70, 64, 61, 56, 53, 49, 45, 41, 36, 32, 27, 23, 19, 15, 10, 7, 2, -2, -6,
-10, -15, -19, -24, -27, -31, -36, -39, -44, -47, -53, -56, -61, -64, -70, -72,
-78, -81, -86, -88, -94, -98, -103, -106, -111, -116, -68, -58, -62, -56, -58,
-54, -54, -50, -49, -47, -46, -43, -42, -40, -38, -36, -35, -33, -32, -29, -27,
-26, -24, -22, -20, -19, -17, -15, -13, -11, -10, -8, -6, -4, -3, 0, 1, 3, 4, 6,
9, 10, 12, 13, 15, 17, 19, 20, 22, 24, 26, 28, 29, 31, 34, 35, 37, 39, 41, 42,
44, 46, 48, 49, 51, 52, 54, 56, 58, 59, 62, 62, 66, 66, 69, 71, 73, 74, 77, 77,
81, 80, 87, 110, 106, 104, 102, 100, 99, 97, 96, 93, 93, 90, 89, 87, 86, 84, 82,
80, 79, 77, 75, 73, 73, 70, 68, 67, 66, 64, 61, 61, 59, 57, 55, 53, 52, 50, 49,
47, 45, 43, 41, 39, 38, 37, 35, 33, 32, 30, 29, 27, 25, 24, 21, 20, 18, 17, 15,
13, 11, 10, 8, 6, 4, 3, 1, 0, -2, -4, -5, -7, -9, -11, -13, -14, -15, -18, -19,
-21, -23, -24, -26, -27, -29, -31, -33, -34, -36, -37, -39, -41, -43, -44, -46,
-48, -50, -51, -52, -55, -55, -59, -56, -66, -31, -9, -10, -3, 0, 6, 10, 16, 20,
26, 29, 35, 38, 44, 47, 54, 57, 64, 65, 74, 74, 83, 82, 95, 90, 109, 82, -4, 5,
-1, 1, -2, -3, -3, -6, -5, -9, -9, -12, -12, -15, -15, -6, -1, -3, -1, -1, -1,
0, 1, 2, 2, 3, 3, 1, 0, 0, 0, -1, -1, -4, -1, -6, 4, -56, -84, -70, -75, -67,
-68, -62, -63, -58, -58, -53, -52, -49, -47, -44, -42, -39, -37, -34, -31, -30,
-26, -25, -21, -20, -16, -15, -11, -9, -7, -4, -1, };