#define DATA_LENGTH 512
#define DATA AKWF_oboe_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 5, 6, 7, 8, 10, 11, 13,
13, 15, 16, 17, 18, 20, 22, 23, 24, 26, 27, 29, 30, 32, 33, 34, 35, 37, 38, 39,
40, 42, 43, 45, 47, 48, 50, 50, 53, 53, 55, 57, 58, 60, 61, 63, 64, 66, 66, 68,
69, 71, 72, 73, 75, 76, 77, 78, 79, 81, 82, 82, 83, 85, 86, 87, 88, 89, 90, 91,
92, 93, 94, 95, 96, 96, 98, 98, 99, 100, 101, 102, 102, 103, 103, 103, 104, 105,
106, 106, 106, 106, 106, 107, 106, 107, 106, 106, 107, 107, 106, 106, 106, 106,
105, 105, 106, 105, 104, 104, 102, 101, 101, 100, 99, 99, 97, 96, 95, 95, 94,
92, 90, 90, 89, 88, 87, 85, 84, 82, 81, 80, 78, 77, 75, 73, 72, 70, 68, 66, 64,
63, 61, 59, 57, 55, 52, 50, 48, 46, 44, 40, 38, 35, 32, 31, 26, 24, 22, 19, 17,
13, 11, 9, 6, 2, 0, -3, -5, -9, -12, -15, -18, -20, -23, -26, -30, -32, -35,
-39, -42, -45, -48, -50, -54, -56, -59, -61, -64, -67, -69, -71, -73, -76, -78,
-80, -82, -85, -87, -88, -90, -93, -94, -96, -97, -99, -101, -102, -104, -105,
-106, -108, -109, -110, -111, -112, -113, -113, -113, -114, -115, -115, -116,
-117, -117, -117, -118, -119, -118, -118, -119, -120, -119, -119, -120, -119,
-119, -119, -119, -118, -118, -118, -117, -116, -115, -115, -115, -114, -113,
-111, -111, -109, -108, -107, -105, -104, -103, -102, -101, -99, -98, -96, -95,
-92, -92, -90, -88, -87, -85, -83, -81, -79, -78, -77, -75, -74, -71, -70, -68,
-66, -64, -63, -61, -60, -58, -57, -55, -53, -51, -49, -47, -45, -43, -41, -39,
-38, -36, -34, -33, -30, -27, -26, -25, -23, -22, -19, -18, -16, -15, -14, -12,
-11, -10, -8, -7, -6, -4, -3, -1, 0, 2, 3, 4, 6, 8, 9, 10, 12, 13, 14, 15, 18,
18, 21, 21, 22, 24, 25, 26, 29, 29, 30, 31, 32, 33, 35, 35, 35, 37, 37, 37, 39,
39, 40, 40, 41, 41, 42, 42, 42, 42, 42, 43, 42, 43, 42, 42, 41, 41, 41, 41, 40,
41, 41, 40, 40, 38, 38, 38, 37, 37, 36, 36, 35, 35, 33, 33, 32, 31, 31, 30, 29,
28, 28, 27, 26, 25, 23, 22, 22, 22, 20, 20, 18, 17, 17, 15, 14, 13, 12, 11, 11,
9, 9, 8, 7, 6, 6, 5, 5, 5, 3, 4, 3, 2, 1, 0, 0, 0, -1, -2, -2, -3, -4, -5, -5,
-6, -7, -8, -8, -9, -10, -10, -10, -11, -11, -12, -12, -13, -14, -13, -14, -14,
-15, -15, -15, -15, -16, -16, -16, -16, -17, -17, -16, -17, -17, -17, -16, -16,
-16, -18, -16, -16, -17, -16, -17, -16, -17, -17, -16, -17, -16, -16, -16, -16,
-16, -16, -15, -15, -15, -14, -14, -14, -14, -13, -13, -12, -12, -11, -10, -9,
-9, -8, -7, -6, -4, -5, -3, -2, -1, 0, };