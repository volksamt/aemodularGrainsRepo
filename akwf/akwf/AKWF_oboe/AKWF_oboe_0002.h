#define DATA_LENGTH 512
#define DATA AKWF_oboe_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 15, 19, 24, 28, 33, 39, 44,
49, 55, 60, 65, 68, 73, 78, 83, 87, 91, 94, 97, 99, 103, 105, 108, 110, 112,
113, 115, 117, 117, 117, 118, 118, 118, 120, 119, 119, 117, 118, 115, 114, 113,
112, 109, 108, 105, 103, 100, 96, 94, 90, 86, 82, 78, 74, 69, 64, 59, 54, 48,
43, 37, 32, 26, 21, 16, 10, 5, 0, -6, -9, -14, -18, -22, -25, -28, -31, -34,
-36, -38, -40, -43, -43, -45, -46, -45, -46, -45, -45, -44, -42, -40, -38, -36,
-33, -30, -27, -25, -21, -17, -14, -11, -8, -6, -3, 0, 3, 5, 6, 8, 11, 12, 14,
16, 17, 18, 19, 20, 22, 23, 24, 24, 25, 27, 28, 28, 29, 30, 29, 29, 29, 30, 29,
29, 29, 29, 27, 26, 25, 24, 21, 19, 16, 13, 10, 7, 4, 0, -3, -6, -10, -14, -19,
-22, -25, -29, -33, -35, -39, -42, -45, -47, -50, -52, -54, -57, -58, -60, -62,
-63, -63, -65, -65, -65, -65, -66, -65, -65, -64, -63, -62, -61, -60, -59, -57,
-56, -54, -52, -51, -48, -47, -45, -44, -41, -39, -36, -35, -33, -31, -29, -27,
-24, -22, -20, -17, -16, -13, -11, -8, -6, -3, 0, 2, 4, 7, 9, 10, 12, 14, 17,
18, 20, 21, 24, 24, 26, 27, 28, 29, 29, 31, 30, 31, 31, 31, 30, 31, 30, 29, 29,
28, 27, 26, 25, 24, 23, 21, 21, 20, 18, 18, 16, 16, 14, 13, 12, 12, 11, 10, 9,
8, 7, 5, 6, 4, 3, 2, 0, 0, -1, -2, -2, -3, -4, -5, -5, -5, -5, -6, -6, -7, -7,
-7, -7, -8, -8, -9, -8, -8, -7, -7, -6, -6, -5, -5, -5, -3, -3, -2, -1, -1, 0,
1, 2, 3, 4, 4, 4, 5, 5, 6, 6, 7, 8, 8, 9, 9, 8, 8, 9, 9, 9, 9, 9, 8, 8, 8, 7, 6,
6, 6, 5, 5, 5, 4, 4, 3, 3, 2, 1, 1, -1, -2, -2, -3, -4, -5, -6, -6, -7, -8, -9,
-10, -11, -12, -13, -13, -14, -16, -16, -16, -16, -17, -19, -19, -19, -19, -20,
-20, -20, -20, -21, -21, -20, -20, -20, -20, -21, -20, -20, -19, -20, -18, -19,
-17, -17, -17, -17, -16, -15, -15, -14, -15, -14, -14, -14, -13, -13, -13, -13,
-13, -12, -11, -11, -11, -11, -12, -12, -13, -12, -13, -13, -12, -12, -12, -12,
-12, -11, -13, -12, -12, -12, -12, -12, -12, -12, -12, -12, -11, -11, -11, -11,
-11, -10, -11, -11, -10, -10, -10, -10, -9, -10, -9, -9, -9, -10, -10, -9, -10,
-10, -10, -11, -11, -11, -11, -12, -12, -12, -14, -13, -14, -15, -15, -15, -16,
-17, -18, -17, -18, -19, -19, -20, -21, -21, -23, -23, -24, -24, -25, -25, -27,
-28, -28, -29, -30, -31, -32, -31, -32, -31, -32, -33, -32, -31, -30, -29, -30,
-29, -26, -25, -25, -22, -20, -19, -17, -14, -11, -8, -4, -2, };