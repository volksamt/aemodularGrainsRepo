#define DATA_LENGTH 512
#define DATA AKWF_oboe_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 8, 11, 14, 17, 19, 22, 25,
28, 32, 35, 38, 42, 45, 47, 50, 53, 55, 57, 59, 60, 61, 64, 66, 68, 71, 73, 75,
77, 78, 78, 79, 78, 79, 80, 80, 80, 81, 82, 82, 83, 83, 84, 85, 86, 85, 85, 85,
84, 83, 83, 81, 83, 83, 83, 83, 83, 84, 83, 82, 82, 81, 81, 81, 81, 80, 81, 80,
81, 81, 82, 81, 81, 81, 81, 80, 80, 79, 79, 77, 77, 75, 73, 74, 73, 72, 70, 70,
68, 67, 66, 64, 63, 63, 61, 60, 59, 57, 57, 54, 52, 51, 49, 47, 45, 44, 43, 41,
40, 39, 38, 36, 35, 34, 32, 31, 30, 28, 27, 26, 25, 24, 24, 21, 21, 20, 19, 17,
17, 16, 15, 14, 12, 12, 11, 10, 8, 8, 7, 7, 6, 5, 4, 3, 3, 2, 1, 1, -1, -1, -2,
-2, -2, -3, -3, -5, -5, -6, -7, -8, -9, -10, -10, -10, -11, -11, -12, -12, -13,
-13, -14, -14, -15, -15, -16, -16, -16, -16, -17, -17, -17, -17, -17, -17, -17,
-16, -16, -16, -14, -15, -15, -14, -15, -14, -14, -13, -12, -10, -8, -8, -6, -5,
-3, -1, 0, 1, 2, 4, 5, 6, 7, 8, 9, 10, 10, 11, 12, 11, 13, 14, 14, 14, 14, 15,
15, 15, 16, 16, 16, 16, 16, 17, 17, 17, 18, 19, 20, 20, 22, 23, 25, 27, 28, 30,
33, 35, 36, 40, 42, 45, 47, 49, 52, 54, 57, 60, 63, 66, 70, 73, 76, 79, 81, 85,
85, 88, 89, 91, 92, 94, 94, 96, 97, 97, 98, 98, 97, 98, 97, 96, 96, 95, 93, 92,
90, 90, 88, 86, 83, 82, 79, 77, 74, 72, 70, 68, 66, 66, 64, 63, 61, 60, 59, 56,
56, 55, 53, 53, 51, 52, 51, 49, 48, 48, 49, 47, 47, 46, 46, 46, 44, 44, 44, 43,
42, 42, 40, 38, 37, 35, 33, 32, 30, 27, 25, 24, 21, 18, 16, 14, 12, 10, 7, 4, 1,
-1, -6, -7, -11, -14, -15, -17, -19, -22, -23, -24, -26, -28, -29, -30, -31,
-32, -32, -33, -33, -33, -32, -33, -33, -32, -31, -30, -30, -30, -28, -29, -29,
-27, -28, -27, -27, -27, -27, -25, -26, -26, -26, -27, -28, -28, -28, -30, -31,
-31, -33, -35, -36, -37, -38, -41, -43, -45, -46, -49, -51, -54, -56, -58, -60,
-62, -65, -67, -69, -72, -75, -77, -79, -81, -84, -85, -87, -90, -91, -93, -95,
-96, -98, -100, -100, -102, -104, -105, -106, -107, -108, -110, -111, -111,
-112, -113, -114, -115, -116, -117, -118, -118, -119, -119, -118, -119, -118,
-119, -119, -119, -118, -117, -116, -115, -114, -114, -112, -110, -109, -108,
-107, -104, -104, -103, -101, -100, -100, -100, -99, -98, -97, -95, -92, -90,
-88, -85, -83, -80, -79, -76, -73, -72, -69, -67, -63, -60, -58, -55, -51, -48,
-45, -42, -39, -35, -32, -30, -28, -25, -22, -19, -17, -13, -10, -7, -4, -2, };