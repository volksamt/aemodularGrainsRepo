#define DATA_LENGTH 512
#define DATA AKWF_oboe_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 5, 8, 9, 10, 12, 13, 14, 15,
17, 19, 20, 21, 22, 23, 25, 26, 27, 28, 29, 30, 31, 33, 33, 34, 35, 35, 37, 38,
39, 40, 41, 41, 43, 44, 44, 45, 46, 46, 47, 48, 50, 50, 50, 51, 52, 53, 54, 54,
55, 55, 56, 56, 59, 58, 59, 60, 60, 60, 61, 62, 62, 63, 64, 64, 65, 65, 66, 66,
67, 67, 68, 69, 69, 69, 69, 70, 70, 71, 71, 71, 71, 73, 72, 73, 73, 73, 73, 74,
74, 75, 74, 74, 75, 76, 76, 76, 76, 76, 77, 76, 76, 76, 76, 77, 77, 76, 76, 77,
77, 77, 77, 76, 77, 77, 77, 77, 77, 76, 77, 76, 76, 76, 76, 75, 76, 76, 74, 75,
75, 74, 74, 74, 74, 74, 74, 74, 74, 72, 74, 73, 72, 73, 72, 72, 72, 72, 72, 72,
72, 71, 72, 71, 72, 72, 72, 72, 71, 71, 72, 71, 72, 72, 72, 71, 72, 71, 71, 71,
72, 72, 71, 72, 72, 72, 73, 73, 73, 74, 74, 73, 73, 74, 74, 75, 75, 76, 76, 77,
77, 77, 78, 78, 79, 78, 78, 79, 79, 80, 79, 80, 81, 81, 81, 82, 81, 82, 82, 82,
81, 82, 82, 83, 83, 83, 83, 83, 82, 82, 82, 82, 82, 81, 81, 81, 82, 81, 81, 81,
80, 79, 80, 79, 78, 78, 77, 77, 77, 76, 75, 76, 75, 74, 73, 71, 71, 70, 69, 67,
66, 66, 65, 64, 62, 61, 60, 58, 57, 56, 54, 52, 51, 50, 48, 47, 45, 43, 42, 39,
38, 37, 34, 32, 31, 29, 28, 25, 23, 22, 19, 18, 16, 14, 11, 10, 8, 5, 3, 2, -1,
-3, -5, -6, -9, -11, -12, -15, -16, -19, -20, -22, -24, -25, -28, -29, -30, -34,
-35, -36, -38, -40, -42, -43, -45, -46, -48, -50, -51, -52, -55, -56, -56, -58,
-59, -61, -62, -63, -65, -66, -67, -68, -69, -71, -72, -73, -73, -74, -76, -77,
-77, -78, -79, -80, -80, -81, -82, -83, -84, -84, -85, -86, -87, -88, -89, -89,
-90, -90, -92, -91, -92, -94, -94, -94, -95, -96, -96, -97, -97, -98, -99, -98,
-99, -100, -100, -100, -101, -102, -101, -102, -103, -103, -104, -103, -104,
-105, -105, -105, -107, -107, -108, -108, -109, -110, -110, -110, -110, -111,
-111, -112, -112, -112, -113, -114, -114, -115, -115, -116, -115, -116, -117,
-117, -118, -117, -118, -118, -118, -119, -118, -119, -119, -120, -119, -119,
-120, -119, -119, -119, -118, -118, -118, -117, -116, -116, -117, -115, -115,
-115, -113, -113, -113, -111, -110, -110, -109, -108, -108, -106, -106, -105,
-103, -102, -101, -99, -99, -97, -96, -95, -92, -91, -90, -88, -87, -86, -83,
-82, -81, -78, -77, -75, -73, -72, -69, -68, -65, -65, -62, -61, -58, -56, -54,
-53, -51, -49, -47, -45, -42, -41, -39, -37, -35, -34, -32, -30, -29, -25, -24,
-23, -21, -18, -17, -15, -13, -12, -10, -8, -7, -5, -4, -2, 0, };