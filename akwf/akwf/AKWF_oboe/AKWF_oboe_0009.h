#define DATA_LENGTH 512
#define DATA AKWF_oboe_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 2, 4, 6, 7, 9, 10, 11, 13, 14, 15,
16, 18, 19, 20, 22, 23, 24, 24, 26, 27, 28, 29, 30, 31, 33, 34, 35, 35, 36, 37,
38, 39, 39, 41, 42, 43, 43, 44, 45, 46, 47, 47, 49, 50, 51, 51, 53, 53, 54, 56,
56, 58, 58, 60, 60, 62, 63, 63, 64, 65, 66, 66, 68, 69, 69, 70, 72, 72, 73, 73,
75, 77, 77, 78, 79, 80, 80, 82, 83, 83, 84, 86, 86, 87, 88, 89, 89, 90, 91, 92,
92, 94, 95, 95, 96, 97, 98, 98, 99, 101, 102, 102, 102, 104, 104, 105, 106, 107,
107, 108, 109, 110, 109, 110, 111, 113, 112, 112, 113, 113, 114, 114, 115, 115,
115, 114, 114, 115, 115, 115, 116, 115, 116, 115, 115, 117, 116, 116, 115, 116,
115, 116, 115, 115, 114, 115, 114, 114, 114, 115, 114, 113, 113, 113, 113, 112,
111, 111, 111, 110, 110, 110, 109, 109, 108, 108, 107, 107, 107, 106, 105, 105,
105, 104, 103, 102, 102, 101, 100, 100, 99, 98, 99, 98, 97, 96, 96, 96, 94, 94,
94, 93, 92, 91, 90, 89, 89, 88, 88, 87, 86, 85, 85, 83, 82, 81, 81, 80, 80, 78,
77, 76, 75, 75, 74, 73, 72, 72, 69, 69, 68, 66, 66, 65, 64, 63, 62, 61, 60, 58,
58, 57, 55, 55, 53, 52, 51, 50, 48, 48, 45, 45, 44, 42, 41, 39, 38, 36, 36, 33,
31, 31, 29, 28, 26, 25, 24, 21, 20, 18, 17, 15, 13, 12, 11, 8, 7, 5, 4, 2, 0,
-1, -4, -5, -7, -9, -10, -12, -14, -16, -17, -19, -20, -23, -25, -25, -27, -29,
-31, -32, -34, -36, -38, -38, -40, -42, -44, -45, -47, -48, -50, -51, -53, -55,
-55, -57, -58, -59, -62, -63, -64, -64, -66, -68, -70, -70, -71, -72, -75, -76,
-77, -78, -79, -81, -81, -83, -84, -85, -87, -88, -89, -89, -91, -91, -93, -94,
-95, -95, -96, -97, -98, -99, -98, -99, -101, -101, -102, -103, -104, -105,
-105, -105, -106, -107, -107, -108, -109, -109, -110, -110, -110, -112, -112,
-112, -112, -112, -114, -114, -113, -115, -115, -114, -115, -115, -116, -116,
-117, -117, -117, -117, -117, -118, -117, -119, -118, -118, -119, -118, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -120,
-118, -120, -119, -119, -118, -119, -118, -118, -118, -118, -118, -118, -118,
-117, -116, -116, -117, -115, -115, -114, -114, -114, -114, -113, -113, -112,
-112, -111, -110, -109, -109, -108, -108, -106, -106, -105, -105, -104, -102,
-101, -101, -99, -100, -98, -98, -96, -95, -94, -92, -91, -90, -89, -88, -86,
-85, -83, -83, -81, -80, -79, -77, -76, -74, -73, -71, -69, -68, -66, -64, -63,
-61, -60, -57, -56, -55, -54, -52, -50, -48, -46, -44, -43, -41, -39, -37, -36,
-34, -33, -31, -30, -29, -26, -25, -24, -23, -21, -20, -18, -17, -15, -14, -12,
-10, -8, -6, -6, -4, -2, -1, };