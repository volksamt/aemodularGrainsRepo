#define DATA_LENGTH 512
#define DATA AKWF_oboe_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 12, 18, 22, 28, 33, 39, 44, 50,
56, 62, 67, 72, 77, 83, 88, 92, 97, 100, 104, 107, 110, 112, 114, 116, 117, 117,
118, 119, 119, 118, 119, 117, 116, 116, 114, 113, 112, 110, 108, 107, 104, 101,
100, 97, 94, 91, 88, 84, 81, 76, 71, 66, 61, 56, 52, 46, 40, 34, 27, 21, 14, 9,
3, -3, -10, -16, -21, -28, -32, -37, -41, -45, -49, -52, -55, -57, -59, -60,
-60, -61, -60, -60, -59, -58, -57, -55, -53, -49, -46, -44, -40, -38, -34, -31,
-28, -25, -21, -19, -15, -12, -8, -5, -2, 1, 4, 8, 10, 14, 16, 18, 21, 23, 25,
27, 29, 31, 32, 34, 36, 36, 37, 37, 38, 39, 38, 39, 39, 38, 38, 37, 37, 35, 34,
32, 30, 28, 26, 24, 21, 17, 15, 12, 8, 5, 1, -2, -6, -9, -13, -17, -21, -25,
-29, -32, -37, -39, -43, -46, -49, -52, -55, -57, -59, -61, -63, -63, -64, -65,
-66, -66, -66, -67, -66, -64, -64, -63, -62, -60, -59, -58, -56, -55, -53, -52,
-50, -47, -46, -43, -41, -39, -37, -36, -32, -31, -28, -27, -25, -23, -20, -17,
-15, -12, -10, -8, -5, -3, -2, 0, 3, 5, 7, 9, 12, 14, 15, 17, 18, 19, 21, 22,
23, 24, 25, 25, 26, 26, 26, 27, 26, 26, 27, 26, 25, 26, 25, 24, 23, 22, 21, 21,
20, 18, 18, 17, 15, 15, 12, 11, 11, 10, 8, 8, 6, 5, 4, 4, 2, 1, 0, 0, -2, -3,
-4, -4, -5, -6, -6, -7, -7, -7, -8, -8, -8, -9, -9, -9, -10, -9, -9, -10, -10,
-9, -10, -9, -9, -9, -8, -8, -8, -7, -6, -6, -5, -4, -3, -3, -2, -1, 0, 0, 2, 3,
3, 4, 5, 5, 7, 8, 7, 8, 8, 9, 9, 9, 10, 9, 10, 10, 10, 10, 9, 9, 9, 9, 8, 8, 8,
7, 6, 6, 5, 5, 4, 3, 3, 3, 2, 1, 0, 1, 0, -2, -2, -3, -4, -4, -5, -5, -8, -6,
-8, -9, -10, -11, -11, -12, -13, -13, -14, -15, -16, -16, -16, -17, -17, -17,
-17, -18, -17, -18, -17, -18, -17, -17, -17, -16, -17, -15, -16, -16, -15, -15,
-14, -14, -14, -14, -14, -13, -14, -13, -13, -13, -12, -12, -12, -12, -12, -11,
-11, -12, -12, -12, -11, -11, -12, -11, -11, -11, -10, -10, -9, -9, -10, -10,
-9, -9, -9, -9, -9, -9, -9, -8, -8, -8, -7, -6, -7, -6, -6, -6, -5, -4, -5, -4,
-4, -3, -3, -3, -2, -2, -3, -2, -2, -2, -2, -2, -2, -2, -3, -2, -3, -4, -4, -4,
-4, -6, -6, -6, -6, -7, -7, -8, -9, -10, -11, -12, -14, -15, -16, -16, -18, -20,
-20, -22, -23, -24, -26, -28, -29, -31, -32, -33, -35, -35, -36, -38, -38, -39,
-40, -40, -39, -40, -39, -39, -39, -37, -36, -35, -34, -31, -30, -27, -24, -22,
-19, -16, -12, -9, -6, -1, };