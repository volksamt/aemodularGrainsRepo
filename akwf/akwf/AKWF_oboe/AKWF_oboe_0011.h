#define DATA_LENGTH 512
#define DATA AKWF_oboe_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 9, 13, 16, 21, 24, 29, 34, 38,
43, 49, 53, 60, 63, 69, 73, 78, 83, 86, 90, 94, 97, 101, 104, 107, 109, 112,
113, 116, 117, 117, 117, 120, 119, 119, 119, 119, 117, 117, 116, 115, 114, 112,
110, 109, 107, 104, 102, 100, 96, 93, 90, 86, 83, 79, 74, 70, 66, 62, 56, 53,
47, 42, 37, 32, 27, 23, 18, 13, 9, 5, 1, -5, -8, -12, -16, -19, -22, -25, -28,
-30, -33, -35, -37, -38, -39, -41, -41, -42, -42, -41, -39, -39, -38, -36, -35,
-32, -31, -28, -26, -23, -22, -19, -17, -16, -14, -12, -10, -9, -8, -7, -7, -6,
-5, -5, -4, -3, -2, -2, -2, 0, 0, 1, 2, 2, 4, 4, 6, 7, 7, 6, 7, 8, 8, 8, 7, 6,
6, 6, 5, 3, 2, 2, 1, -1, -3, -4, -5, -8, -9, -11, -14, -16, -17, -19, -22, -24,
-26, -27, -30, -32, -33, -34, -36, -37, -38, -40, -40, -43, -42, -44, -44, -45,
-46, -46, -46, -46, -46, -46, -47, -46, -46, -46, -46, -45, -44, -44, -43, -43,
-42, -42, -41, -40, -39, -38, -37, -37, -36, -35, -34, -32, -30, -29, -28, -26,
-24, -22, -21, -19, -17, -16, -15, -12, -12, -9, -7, -5, -5, -3, -2, 0, 2, 2, 4,
6, 7, 9, 12, 12, 13, 15, 16, 18, 19, 20, 21, 23, 24, 24, 25, 25, 27, 26, 27, 27,
28, 28, 29, 30, 29, 29, 29, 29, 29, 30, 29, 29, 28, 28, 27, 27, 25, 24, 24, 23,
23, 22, 20, 18, 18, 17, 15, 15, 12, 11, 10, 8, 6, 5, 4, 1, 0, -1, -3, -3, -6,
-7, -7, -7, -9, -9, -9, -9, -10, -10, -11, -11, -11, -10, -9, -11, -10, -10,
-10, -10, -10, -9, -10, -9, -9, -9, -9, -9, -8, -8, -9, -8, -6, -7, -6, -5, -5,
-4, -3, -3, -2, -1, -1, 0, 1, 1, 1, 2, 3, 3, 3, 4, 5, 4, 4, 5, 4, 4, 4, 5, 3, 3,
2, 3, 3, 2, 2, 2, 2, 2, 0, 1, 0, -1, -1, -2, -3, -3, -3, -3, -5, -5, -6, -5, -6,
-6, -7, -7, -7, -8, -9, -8, -8, -9, -9, -10, -10, -11, -12, -13, -13, -14, -14,
-15, -16, -16, -16, -17, -18, -19, -19, -19, -20, -21, -21, -21, -22, -22, -22,
-23, -22, -23, -22, -23, -23, -22, -23, -23, -23, -23, -22, -22, -23, -22, -22,
-21, -21, -20, -20, -19, -18, -19, -17, -17, -17, -16, -16, -16, -16, -16, -16,
-15, -15, -14, -15, -14, -14, -13, -14, -14, -14, -13, -12, -12, -12, -11, -11,
-12, -11, -11, -11, -11, -10, -9, -9, -9, -8, -9, -10, -9, -10, -9, -10, -9,
-10, -9, -9, -10, -10, -10, -11, -12, -12, -12, -14, -14, -14, -15, -15, -16,
-17, -18, -18, -19, -19, -19, -21, -21, -21, -21, -22, -21, -22, -21, -20, -20,
-20, -18, -17, -15, -13, -10, -8, -7, -4, -1, };