#define DATA_LENGTH 512
#define DATA AKWF_oboe_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 8, 10, 11, 14, 16, 18, 20,
22, 24, 25, 26, 29, 30, 32, 34, 35, 37, 40, 41, 43, 44, 46, 48, 50, 51, 52, 55,
55, 57, 59, 60, 62, 64, 65, 66, 67, 68, 69, 71, 73, 74, 75, 77, 79, 80, 82, 84,
86, 86, 88, 90, 91, 92, 93, 95, 96, 97, 99, 100, 102, 103, 105, 107, 107, 109,
111, 112, 113, 114, 115, 116, 116, 118, 118, 118, 119, 119, 119, 119, 119, 119,
119, 118, 117, 117, 116, 116, 116, 115, 114, 113, 112, 111, 110, 109, 107, 106,
104, 102, 101, 100, 98, 96, 95, 94, 93, 92, 91, 89, 88, 86, 86, 84, 82, 81, 81,
79, 77, 75, 75, 73, 73, 71, 70, 69, 68, 67, 66, 64, 63, 62, 60, 60, 58, 57, 56,
55, 54, 52, 50, 50, 48, 47, 46, 45, 44, 43, 41, 41, 39, 39, 37, 36, 35, 34, 33,
32, 32, 32, 31, 30, 29, 29, 28, 27, 27, 26, 26, 25, 24, 24, 24, 23, 23, 22, 22,
21, 21, 21, 22, 20, 20, 21, 19, 20, 20, 20, 19, 20, 20, 19, 20, 20, 20, 19, 21,
20, 21, 20, 20, 20, 21, 20, 20, 20, 21, 20, 21, 21, 20, 20, 19, 19, 19, 18, 17,
17, 17, 15, 15, 14, 13, 14, 13, 11, 11, 10, 9, 7, 7, 5, 4, 3, 1, 0, 0, -2, -3,
-5, -5, -6, -7, -8, -9, -9, -11, -12, -13, -13, -15, -15, -16, -17, -18, -18,
-19, -20, -20, -21, -20, -21, -21, -22, -22, -23, -24, -24, -25, -26, -26, -27,
-27, -28, -28, -29, -30, -30, -30, -31, -31, -32, -32, -33, -33, -33, -34, -34,
-35, -36, -35, -37, -38, -38, -38, -38, -39, -39, -40, -39, -40, -40, -41, -41,
-41, -41, -41, -42, -42, -42, -43, -43, -43, -44, -44, -44, -44, -45, -45, -46,
-45, -47, -46, -46, -46, -47, -46, -48, -49, -48, -50, -50, -49, -50, -51, -50,
-50, -50, -51, -50, -49, -50, -50, -49, -49, -49, -49, -48, -49, -48, -48, -47,
-48, -48, -48, -48, -47, -47, -47, -48, -48, -48, -48, -48, -48, -48, -48, -47,
-48, -48, -47, -48, -48, -48, -48, -47, -48, -48, -48, -48, -48, -48, -49, -48,
-49, -49, -48, -49, -49, -49, -49, -49, -49, -50, -50, -50, -51, -51, -51, -51,
-51, -50, -51, -52, -51, -52, -52, -52, -52, -52, -53, -53, -53, -53, -54, -53,
-54, -55, -55, -55, -55, -56, -56, -56, -57, -56, -57, -57, -58, -58, -58, -57,
-58, -59, -59, -59, -60, -60, -60, -60, -61, -61, -60, -61, -61, -62, -62, -62,
-63, -62, -62, -63, -62, -62, -63, -62, -63, -62, -62, -61, -62, -62, -61, -62,
-61, -60, -60, -59, -58, -57, -57, -56, -55, -54, -53, -53, -51, -50, -50, -49,
-47, -46, -44, -44, -42, -40, -39, -37, -35, -34, -32, -30, -29, -27, -24, -23,
-22, -20, -17, -15, -15, -13, -11, -10, -8, -6, -5, -3, -1, };