#define DATA_LENGTH 512
#define DATA AKWF_oboe_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 12, 13, 16, 20, 23, 26, 29,
31, 34, 37, 40, 42, 45, 47, 49, 51, 53, 56, 58, 60, 62, 63, 65, 68, 69, 70, 72,
74, 76, 77, 78, 80, 81, 82, 83, 85, 85, 87, 88, 89, 89, 91, 91, 91, 93, 93, 94,
93, 94, 94, 95, 95, 95, 94, 96, 95, 95, 94, 95, 94, 94, 93, 93, 92, 91, 91, 90,
90, 88, 88, 87, 86, 86, 84, 83, 81, 80, 80, 78, 77, 76, 75, 75, 74, 72, 70, 69,
68, 67, 66, 65, 62, 62, 61, 60, 59, 57, 55, 54, 54, 52, 50, 50, 47, 47, 46, 44,
43, 42, 40, 39, 38, 37, 37, 35, 34, 32, 32, 30, 29, 29, 28, 27, 27, 25, 24, 24,
24, 23, 22, 21, 22, 21, 21, 20, 21, 19, 20, 19, 19, 18, 18, 17, 17, 18, 17, 17,
17, 16, 17, 16, 16, 16, 16, 15, 16, 15, 15, 15, 14, 14, 14, 14, 14, 14, 13, 14,
12, 13, 12, 13, 12, 13, 13, 13, 12, 13, 13, 13, 14, 15, 14, 14, 14, 14, 14, 14,
14, 15, 14, 14, 15, 14, 14, 14, 13, 13, 14, 13, 12, 12, 13, 13, 12, 12, 12, 12,
11, 11, 11, 10, 10, 10, 10, 11, 9, 10, 9, 9, 9, 8, 8, 7, 8, 8, 8, 7, 7, 8, 7, 7,
7, 6, 7, 5, 5, 6, 5, 6, 5, 5, 5, 5, 4, 4, 3, 3, 4, 3, 3, 4, 3, 2, 3, 3, 2, 2, 1,
1, 2, 2, 2, 2, 2, 2, 2, 3, 2, 4, 4, 3, 4, 5, 5, 4, 6, 6, 6, 6, 6, 7, 8, 8, 8, 9,
10, 11, 11, 11, 12, 13, 13, 13, 13, 14, 15, 16, 15, 16, 16, 16, 18, 17, 18, 19,
19, 20, 21, 22, 21, 23, 23, 23, 24, 25, 26, 26, 26, 26, 28, 29, 30, 30, 30, 31,
32, 32, 31, 32, 33, 33, 33, 33, 32, 33, 32, 33, 32, 32, 32, 31, 31, 30, 29, 29,
28, 27, 27, 25, 24, 24, 23, 21, 20, 19, 18, 16, 15, 13, 12, 11, 9, 8, 7, 6, 4,
2, 1, -1, -3, -3, -5, -7, -8, -9, -11, -12, -14, -16, -18, -20, -22, -23, -25,
-27, -31, -32, -35, -37, -38, -42, -44, -46, -49, -50, -53, -56, -58, -60, -63,
-65, -66, -69, -71, -73, -75, -77, -80, -80, -84, -86, -88, -89, -90, -92, -94,
-96, -97, -99, -100, -102, -104, -104, -106, -107, -109, -110, -111, -112, -114,
-115, -116, -117, -117, -118, -119, -120, -119, -120, -119, -118, -119, -118,
-120, -119, -119, -119, -119, -118, -119, -119, -119, -119, -118, -118, -116,
-115, -114, -113, -113, -112, -110, -109, -107, -105, -104, -102, -101, -99,
-98, -96, -95, -92, -91, -89, -87, -85, -83, -80, -78, -77, -74, -72, -70, -67,
-64, -63, -60, -58, -55, -53, -50, -47, -44, -41, -39, -36, -33, -30, -27, -25,
-21, -18, -15, -12, -10, -6, -3, 0, };