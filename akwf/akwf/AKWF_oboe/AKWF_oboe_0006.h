#define DATA_LENGTH 512
#define DATA AKWF_oboe_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 1, 1, 2, 3, 2, 4, 4, 5, 5, 5, 5,
6, 7, 6, 7, 7, 8, 8, 9, 10, 10, 11, 11, 11, 12, 12, 13, 13, 14, 13, 14, 16, 15,
17, 17, 18, 17, 19, 19, 20, 21, 21, 22, 23, 24, 26, 26, 26, 28, 29, 30, 32, 33,
34, 36, 36, 38, 39, 41, 43, 44, 46, 47, 49, 51, 52, 53, 56, 57, 59, 61, 63, 64,
66, 69, 71, 74, 75, 77, 79, 80, 82, 85, 86, 89, 91, 92, 94, 96, 98, 100, 101,
103, 105, 107, 108, 109, 111, 112, 113, 114, 115, 116, 116, 118, 118, 119, 118,
119, 118, 119, 119, 119, 120, 119, 119, 120, 119, 118, 117, 116, 116, 115, 114,
112, 111, 110, 109, 107, 105, 104, 101, 100, 97, 95, 93, 91, 89, 86, 83, 81, 79,
77, 74, 72, 68, 66, 63, 60, 57, 55, 52, 49, 46, 43, 40, 37, 35, 33, 28, 26, 22,
21, 18, 15, 13, 10, 7, 4, 2, 0, -3, -6, -8, -10, -11, -14, -15, -17, -19, -21,
-23, -25, -27, -28, -29, -30, -33, -34, -35, -37, -37, -39, -40, -41, -41, -42,
-43, -44, -44, -45, -46, -47, -48, -48, -49, -50, -49, -50, -50, -50, -51, -51,
-52, -52, -52, -53, -53, -53, -54, -53, -54, -55, -55, -56, -56, -56, -57, -57,
-58, -58, -58, -59, -59, -60, -61, -62, -61, -63, -63, -64, -64, -65, -67, -66,
-68, -69, -68, -70, -70, -72, -72, -73, -73, -74, -75, -76, -77, -79, -79, -79,
-79, -80, -81, -82, -83, -83, -84, -84, -85, -86, -86, -86, -88, -88, -88, -88,
-88, -89, -88, -88, -88, -89, -88, -89, -87, -88, -88, -87, -88, -87, -87, -86,
-85, -85, -84, -84, -83, -82, -81, -80, -78, -77, -77, -75, -75, -73, -72, -71,
-70, -68, -66, -65, -63, -62, -60, -58, -57, -54, -54, -52, -50, -48, -47, -44,
-42, -41, -40, -38, -37, -34, -33, -32, -29, -27, -26, -24, -23, -21, -19, -18,
-16, -14, -13, -12, -9, -8, -7, -5, -3, -2, 0, 2, 2, 4, 5, 6, 8, 9, 9, 11, 12,
14, 14, 15, 16, 17, 17, 18, 19, 19, 20, 20, 20, 22, 21, 22, 22, 23, 22, 23, 24,
24, 24, 24, 25, 24, 24, 24, 24, 24, 24, 25, 24, 24, 23, 24, 23, 23, 23, 23, 22,
21, 21, 20, 20, 18, 19, 18, 17, 15, 15, 15, 14, 13, 13, 12, 11, 10, 10, 9, 8, 7,
6, 5, 5, 4, 3, 3, 1, 1, 0, -1, -3, -2, -4, -5, -5, -6, -7, -8, -9, -9, -10, -11,
-11, -11, -12, -12, -12, -13, -14, -15, -15, -15, -16, -16, -16, -17, -17, -16,
-17, -18, -18, -18, -18, -18, -18, -18, -17, -18, -18, -18, -17, -16, -17, -17,
-16, -15, -16, -16, -16, -14, -14, -14, -13, -12, -12, -12, -11, -10, -9, -10,
-8, -8, -8, -7, -7, -5, -5, -5, -4, -3, -3, -3, -2, -2, -2, -1, -1, };