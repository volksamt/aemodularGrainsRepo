#define DATA_LENGTH 512
#define DATA AKWF_oboe_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 6, 8, 11, 13, 17, 18, 21, 24,
25, 28, 30, 32, 34, 36, 39, 41, 42, 45, 46, 48, 51, 52, 54, 55, 57, 58, 61, 61,
63, 64, 66, 67, 68, 71, 70, 73, 73, 74, 76, 77, 79, 79, 80, 81, 82, 83, 84, 85,
86, 87, 88, 89, 89, 91, 91, 93, 93, 95, 94, 96, 96, 98, 99, 99, 99, 100, 101,
102, 103, 103, 104, 105, 106, 106, 107, 108, 108, 109, 109, 110, 110, 112, 111,
112, 112, 113, 113, 114, 114, 115, 115, 114, 115, 115, 115, 116, 116, 117, 116,
117, 117, 117, 118, 118, 118, 117, 118, 118, 118, 118, 118, 118, 118, 118, 117,
117, 117, 117, 117, 117, 117, 116, 116, 116, 115, 115, 115, 115, 115, 114, 114,
112, 112, 112, 112, 111, 110, 110, 109, 109, 108, 108, 107, 105, 104, 104, 103,
102, 100, 100, 100, 98, 97, 97, 95, 94, 92, 91, 91, 89, 87, 87, 85, 84, 82, 81,
80, 79, 77, 76, 74, 73, 71, 69, 69, 67, 65, 64, 63, 62, 59, 58, 56, 54, 53, 51,
50, 48, 46, 44, 43, 42, 40, 38, 36, 34, 33, 32, 30, 28, 27, 26, 24, 23, 22, 21,
19, 18, 16, 16, 13, 13, 11, 10, 8, 8, 6, 5, 3, 3, 2, 0, 0, -1, -3, -3, -5, -6,
-7, -7, -9, -8, -10, -11, -11, -12, -12, -14, -14, -15, -17, -17, -17, -18, -18,
-19, -19, -20, -21, -21, -21, -22, -22, -22, -23, -24, -24, -25, -26, -26, -26,
-27, -28, -29, -29, -30, -31, -31, -31, -32, -33, -34, -33, -34, -35, -36, -36,
-37, -37, -37, -39, -39, -39, -39, -40, -41, -42, -42, -43, -43, -43, -44, -45,
-44, -45, -46, -46, -46, -46, -46, -48, -47, -47, -49, -49, -49, -48, -49, -49,
-49, -49, -50, -50, -50, -50, -50, -51, -51, -50, -51, -51, -50, -50, -50, -49,
-50, -50, -49, -49, -49, -50, -49, -49, -49, -48, -48, -48, -47, -48, -48, -47,
-47, -47, -47, -47, -47, -46, -47, -46, -46, -47, -47, -46, -46, -46, -46, -46,
-47, -47, -46, -46, -46, -46, -47, -46, -47, -48, -47, -48, -48, -48, -50, -50,
-50, -52, -51, -52, -54, -54, -55, -55, -56, -57, -58, -58, -59, -61, -61, -62,
-62, -63, -65, -66, -67, -67, -68, -70, -71, -72, -74, -75, -76, -77, -79, -81,
-81, -83, -84, -86, -87, -89, -91, -91, -93, -95, -96, -97, -99, -100, -101,
-103, -105, -106, -106, -108, -108, -111, -111, -112, -113, -114, -114, -115,
-115, -116, -117, -117, -118, -118, -118, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -118, -118, -117, -117, -115, -114,
-112, -112, -111, -109, -108, -107, -105, -104, -102, -100, -98, -97, -95, -94,
-92, -89, -87, -85, -83, -80, -78, -75, -73, -71, -68, -65, -63, -60, -58, -55,
-53, -50, -48, -46, -43, -40, -37, -35, -32, -29, -27, -24, -21, -19, -16, -13,
-10, -8, -6, -3, -1, };