#define DATA_LENGTH 512
#define DATA AKWF_blended_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 12, 16, 20, 22, 23, 25, 26, 27,
29, 30, 32, 33, 34, 36, 37, 39, 40, 41, 43, 44, 45, 46, 48, 49, 50, 51, 53, 54,
55, 56, 57, 58, 60, 61, 61, 62, 64, 64, 66, 67, 68, 69, 68, 71, 71, 72, 74, 74,
75, 76, 76, 77, 78, 79, 79, 80, 81, 80, 82, 82, 83, 84, 84, 85, 85, 86, 86, 87,
87, 88, 88, 89, 90, 91, 90, 90, 91, 93, 92, 93, 93, 93, 94, 94, 94, 95, 95, 95,
95, 96, 96, 96, 97, 97, 97, 98, 98, 98, 99, 98, 100, 99, 100, 100, 100, 100,
100, 100, 100, 101, 100, 101, 102, 101, 101, 101, 102, 102, 102, 103, 103, 102,
103, 102, 103, 103, 103, 103, 103, 102, 103, 103, 103, 103, 102, 103, 102, 103,
103, 104, 103, 103, 103, 103, 103, 103, 103, 104, 103, 103, 103, 103, 103, 103,
104, 103, 103, 103, 103, 103, 103, 103, 102, 103, 103, 102, 103, 102, 102, 102,
102, 102, 102, 102, 102, 102, 102, 102, 102, 101, 101, 101, 101, 101, 101, 101,
101, 101, 101, 100, 100, 100, 99, 99, 99, 99, 98, 99, 99, 98, 97, 97, 97, 97,
97, 97, 97, 96, 95, 94, 94, 94, 93, 93, 92, 93, 91, 91, 90, 91, 89, 88, 87, 87,
85, 85, 85, 83, 81, 81, 81, 79, 77, 73, 68, 63, 58, 51, 47, 40, 36, 28, 25, 17,
17, -8, -49, -54, -62, -67, -73, -78, -84, -90, -96, -102, -108, -112, -116,
-117, -117, -117, -117, -119, -118, -120, -118, -119, -118, -118, -119, -118,
-119, -118, -117, -118, -116, -117, -115, -115, -114, -114, -114, -113, -112,
-112, -111, -110, -109, -109, -107, -107, -107, -105, -106, -104, -103, -104,
-102, -102, -101, -101, -101, -99, -99, -98, -97, -97, -96, -96, -95, -94, -94,
-93, -93, -93, -92, -92, -90, -90, -90, -88, -89, -88, -87, -87, -87, -86, -86,
-85, -86, -85, -84, -84, -83, -82, -82, -82, -82, -81, -81, -81, -80, -80, -81,
-79, -79, -79, -79, -79, -79, -78, -78, -77, -77, -77, -76, -77, -76, -77, -76,
-76, -76, -76, -75, -75, -75, -75, -75, -75, -74, -75, -74, -73, -74, -74, -74,
-74, -74, -73, -73, -73, -73, -73, -74, -73, -73, -73, -73, -73, -73, -73, -73,
-73, -72, -73, -73, -72, -72, -73, -72, -72, -73, -73, -72, -73, -72, -73, -72,
-72, -73, -73, -72, -73, -72, -73, -72, -72, -72, -72, -73, -72, -72, -73, -73,
-73, -72, -73, -72, -73, -73, -73, -73, -73, -72, -72, -73, -72, -72, -73, -73,
-72, -72, -73, -72, -73, -72, -73, -73, -73, -72, -73, -73, -72, -72, -72, -71,
-72, -72, -72, -72, -72, -71, -71, -71, -71, -71, -70, -70, -70, -70, -69, -69,
-69, -68, -68, -68, -67, -66, -65, -65, -64, -63, -63, -62, -61, -60, -58, -57,
-54, -48, -44, -37, -33, -26, -22, -16, -12, -4, -2, 8, -11, -39, -31, -29, -24,
-20, -14, -10, -3, };