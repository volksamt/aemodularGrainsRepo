#define DATA_LENGTH 512
#define DATA AKWF_blended_0055

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 2, 3, 3, 3, 4, 5, 5, 5, 5, 6,
7, 7, 8, 8, 9, 9, 10, 10, 10, 11, 11, 12, 12, 12, 14, 14, 15, 15, 15, 16, 16,
16, 16, 18, 19, 18, 19, 19, 20, 21, 21, 21, 22, 22, 23, 23, 24, 24, 25, 26, 26,
26, 27, 27, 27, 29, 29, 29, 30, 29, 31, 31, 31, 32, 33, 32, 33, 34, 35, 35, 36,
36, 36, 38, 38, 38, 38, 39, 39, 40, 40, 41, 41, 42, 43, 42, 44, 44, 44, 45, 45,
46, 46, 47, 47, 48, 48, 49, 50, 50, 50, 50, 51, 51, 52, 53, 53, 53, 53, 54, 55,
55, 56, 56, 57, 58, 57, 58, 59, 58, 59, 60, 60, 61, 61, 62, 62, 63, 63, 64, 64,
65, 66, 65, 67, 67, 67, 68, 68, 68, 69, 70, 70, 71, 71, 72, 72, 73, 73, 74, 74,
75, 74, 75, 76, 76, 76, 78, 77, 78, 79, 80, 80, 80, 82, 82, 82, 82, 83, 83, 84,
84, 85, 85, 86, 86, 87, 87, 88, 88, 89, 89, 89, 90, 90, 91, 91, 92, 93, 93, 93,
94, 94, 95, 95, 95, 96, 98, 97, 98, 98, 99, 99, 100, 100, 101, 101, 101, 102,
102, 103, 104, 104, 105, 105, 105, 106, 106, 107, 107, 108, 107, 109, 108, 110,
109, 112, 110, 113, 111, 114, 113, 114, 114, 115, 115, 115, 117, 115, 119, 114,
123, 109, 127, 32, -51, -23, -38, -27, -34, -28, -31, -29, -29, -28, -28, -28,
-25, -28, -24, -29, -21, -28, -18, -34, -117, -117, -114, -117, -113, -116,
-113, -115, -111, -114, -111, -113, -110, -111, -110, -111, -109, -110, -108,
-108, -107, -107, -106, -106, -105, -105, -105, -104, -103, -103, -103, -101,
-101, -101, -101, -99, -100, -100, -99, -98, -97, -97, -97, -97, -96, -96, -95,
-94, -94, -94, -93, -92, -92, -91, -92, -90, -90, -89, -89, -89, -88, -88, -87,
-87, -86, -86, -86, -85, -84, -83, -83, -83, -82, -81, -82, -80, -80, -79, -80,
-79, -79, -78, -78, -77, -76, -76, -76, -75, -74, -75, -74, -74, -73, -73, -72,
-71, -71, -70, -69, -69, -69, -68, -68, -67, -66, -66, -66, -65, -65, -64, -63,
-64, -63, -63, -63, -62, -61, -60, -61, -60, -59, -59, -58, -58, -58, -57, -57,
-56, -56, -55, -55, -54, -53, -54, -53, -52, -51, -51, -50, -50, -49, -49, -49,
-49, -47, -47, -46, -46, -46, -46, -45, -44, -43, -44, -43, -42, -41, -41, -41,
-41, -40, -40, -40, -39, -37, -38, -37, -37, -36, -36, -35, -35, -33, -34, -33,
-33, -32, -32, -32, -31, -31, -30, -29, -29, -29, -28, -27, -27, -27, -26, -26,
-25, -25, -24, -24, -22, -22, -22, -21, -21, -20, -21, -20, -20, -18, -18, -17,
-18, -16, -16, -16, -16, -15, -15, -14, -13, -12, -12, -12, -12, -12, -11, -11,
-10, -9, -8, -8, -8, -8, -6, -6, -7, -6, -5, -4, -4, -3, -4, -3, -1, -2, -1, -1,
0, };