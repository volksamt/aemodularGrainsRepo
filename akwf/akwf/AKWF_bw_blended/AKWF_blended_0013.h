#define DATA_LENGTH 512
#define DATA AKWF_blended_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 64, 58, 59, 60, 59, 61, 61, 62, 62,
63, 63, 64, 62, 64, 64, 65, 64, 66, 66, 67, 67, 68, 68, 68, 69, 69, 69, 70, 71,
70, 71, 71, 71, 73, 73, 73, 74, 74, 74, 75, 75, 76, 76, 76, 77, 77, 77, 79, 79,
78, 80, 80, 80, 81, 81, 82, 82, 82, 82, 83, 84, 84, 85, 84, 86, 85, 86, 87, 87,
87, 87, 88, 88, 89, 89, 89, 91, 91, 91, 91, 91, 92, 92, 93, 94, 93, 95, 95, 95,
95, 96, 97, 97, 97, 98, 98, 99, 99, 99, 100, 100, 101, 102, 102, 101, 103, 102,
103, 104, 105, 104, 105, 105, 105, 106, 106, 106, 108, 108, 108, 109, 109, 111,
108, 113, 107, 119, 48, -13, 1, -7, 0, -5, -1, -2, 0, -2, 0, 0, 0, 1, 2, 2, 1,
3, 2, 4, 3, 5, 4, 5, 5, 6, 5, 6, 7, 7, 7, 8, 8, 9, 9, 10, 10, 10, 11, 11, 12,
12, 13, 13, 14, 14, 15, 15, 15, 16, 17, 16, 17, 18, 18, 18, 18, 19, 19, 20, 21,
21, 21, 22, 22, 22, 24, 23, 24, 24, 25, 25, 25, 26, 26, 26, 27, 27, 28, 28, 28,
29, 30, 30, 30, 31, 31, 32, 32, 33, 33, 33, 33, 35, 34, 36, 35, 36, 35, 37, 37,
38, 37, 39, 38, 39, 40, 40, 40, 41, 42, 41, 42, 41, 44, 41, 46, 42, 48, 41, 49,
42, 50, 41, 53, 40, 59, 28, -92, -43, -49, -47, -46, -48, -44, -48, -43, -47,
-42, -46, -42, -45, -41, -44, -41, -43, -40, -42, -40, -40, -39, -39, -38, -38,
-38, -37, -37, -36, -36, -35, -36, -34, -35, -34, -34, -33, -33, -32, -32, -32,
-31, -31, -30, -30, -29, -29, -28, -28, -28, -27, -27, -27, -25, -25, -26, -25,
-24, -24, -24, -23, -23, -22, -22, -21, -21, -21, -20, -20, -20, -19, -18, -18,
-17, -17, -16, -16, -16, -16, -15, -15, -14, -14, -14, -13, -13, -12, -13, -12,
-11, -11, -10, -10, -10, -9, -8, -8, -8, -7, -7, -7, -7, -6, -6, -4, -4, -4, -4,
-3, -3, -4, -2, -1, -1, -2, 1, 0, 1, 1, 2, 3, 2, 3, 2, 5, 2, 11, -70, -120,
-106, -113, -107, -111, -107, -111, -107, -109, -107, -107, -106, -106, -106,
-105, -105, -104, -105, -104, -104, -103, -103, -102, -102, -101, -101, -99,
-100, -99, -99, -98, -98, -98, -98, -97, -97, -96, -96, -95, -94, -94, -94, -93,
-93, -92, -92, -92, -91, -91, -91, -89, -89, -89, -89, -89, -88, -88, -87, -86,
-86, -86, -85, -85, -85, -85, -84, -84, -83, -82, -82, -81, -81, -81, -81, -80,
-80, -79, -79, -79, -78, -78, -78, -77, -76, -75, -75, -75, -75, -74, -74, -74,
-73, -73, -72, -72, -71, -71, -70, -70, -69, -69, -69, -69, -68, -67, -67, -67,
-67, -66, -66, -65, -66, -63, -65, -62, -64, -61, -63, -61, -62, -59, -62, -59,
-61, -57, -61, -55, };