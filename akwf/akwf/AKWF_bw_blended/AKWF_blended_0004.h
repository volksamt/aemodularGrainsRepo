#define DATA_LENGTH 512
#define DATA AKWF_blended_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12,
13, 14, 15, 16, 18, 18, 20, 20, 21, 22, 24, 24, 26, 26, 27, 28, 30, 30, 32, 33,
33, 34, 36, 36, 38, 39, 40, 41, 43, 43, 45, 45, 46, 48, 49, 50, 51, 52, 53, 54,
55, 56, 57, 58, 58, 60, 60, 62, 64, 65, 65, 66, 67, 68, 69, 70, 73, 73, 75, 75,
75, 77, 77, 79, 80, 81, 83, 83, 85, 85, 86, 88, 89, 90, 92, 91, 94, 93, 95, 96,
98, 99, 100, 100, 102, 103, 103, 105, 105, 107, 108, 109, 110, 111, 112, 113,
115, 115, 116, 118, 119, 112, 103, 88, 76, 63, 54, 47, 43, 38, 35, 33, 31, 29,
28, 28, 28, 27, 27, 27, 27, 26, 28, 28, 28, 28, 28, 29, 30, 29, 31, 31, 31, 32,
33, 33, 33, 34, 34, 35, 34, 35, 37, 37, 38, 38, 39, 39, 41, 41, 42, 43, 43, 44,
45, 45, 46, 47, 48, 48, 50, 49, 50, 51, 53, 53, 54, 55, 55, 56, 57, 57, 59, 59,
60, 61, 62, 63, 63, 64, 66, 66, 68, 68, 69, 70, 71, 71, 73, 74, 75, 76, 77, 77,
78, 79, 80, 81, 82, 83, 84, 85, 86, 86, 88, 89, 90, 90, 92, 93, 94, 95, 96, 91,
80, 78, 69, 54, 42, 30, 18, 8, -2, -11, -18, -25, -30, -36, -40, -44, -48, -51,
-53, -55, -57, -58, -59, -61, -62, -62, -64, -64, -65, -65, -64, -65, -66, -66,
-66, -66, -66, -66, -65, -65, -65, -65, -64, -64, -63, -63, -63, -62, -62, -61,
-61, -62, -60, -59, -60, -58, -58, -57, -58, -57, -56, -57, -55, -55, -55, -54,
-53, -53, -53, -51, -51, -50, -50, -49, -49, -48, -47, -47, -46, -46, -46, -44,
-44, -42, -43, -42, -41, -39, -39, -38, -38, -37, -37, -35, -35, -34, -34, -33,
-32, -32, -31, -30, -29, -29, -29, -28, -27, -26, -25, -25, -23, -23, -22, -22,
-21, -20, -19, -19, -17, -17, -15, -15, -14, -14, -13, -12, -11, -11, -9, -8,
-8, -7, -6, -5, -4, -4, -3, -2, -1, 0, 1, 2, 2, -6, -15, -31, -44, -55, -63,
-71, -76, -80, -83, -86, -88, -88, -90, -91, -92, -92, -93, -92, -93, -93, -93,
-92, -92, -93, -92, -92, -91, -92, -91, -91, -90, -90, -89, -90, -88, -89, -88,
-88, -86, -86, -86, -85, -85, -84, -84, -83, -83, -82, -81, -81, -81, -80, -79,
-78, -77, -77, -76, -76, -74, -74, -74, -73, -72, -72, -70, -70, -69, -69, -68,
-67, -66, -65, -64, -64, -63, -63, -62, -62, -60, -59, -59, -58, -56, -55, -55,
-54, -53, -53, -52, -51, -49, -50, -48, -47, -45, -46, -44, -44, -43, -42, -41,
-39, -39, -38, -38, -36, -35, -34, -33, -32, -31, -30, -29, -28, -28, -26, -26,
-24, -23, -22, -22, -20, -20, -18, -17, -16, -15, -14, -14, -12, -12, -10, -9,
-8, -7, -7, -5, -4, -3, -3, -1, -1, };