#define DATA_LENGTH 512
#define DATA AKWF_blended_0064

const PROGMEM int8_t DATA[DATA_LENGTH] = {35, 63, 60, 67, 70, 79, 87, 98, 106,
114, 118, 119, 117, 113, 106, 98, 91, 84, 79, 76, 74, 74, 77, 78, 80, 81, 81,
80, 78, 73, 69, 65, 61, 59, 57, 55, 56, 55, 56, 58, 58, 57, 57, 56, 54, 51, 49,
47, 46, 45, 45, 44, 44, 45, 44, 45, 45, 45, 44, 43, 42, 42, 41, 40, 39, 39, 39,
39, 38, 39, 40, 39, 40, 39, 38, 38, 38, 37, 36, 36, 35, 36, 36, 35, 36, 36, 36,
36, 37, 36, 35, 36, 35, 35, 35, 35, 34, 35, 34, 34, 35, 35, 34, 34, 34, 34, 34,
34, 34, 33, 33, 33, 33, 33, 32, 32, 32, 33, 32, 32, 32, 32, 32, 32, 33, 32, 32,
32, 32, 32, 32, 32, 32, 32, 32, 32, 31, 32, 32, 32, 31, 32, 31, 32, 32, 32, 31,
32, 31, 31, 32, 32, 31, 31, 31, 31, 31, 30, 31, 31, 31, 31, 31, 31, 31, 31, 30,
31, 31, 30, 31, 31, 31, 32, 31, 31, 30, 31, 31, 31, 32, 30, 32, 31, 32, 31, 31,
32, 31, 31, 32, 32, 31, 32, 32, 33, 31, 32, 32, 32, 32, 32, 32, 32, 32, 32, 33,
32, 32, 33, 33, 33, 33, 33, 33, 33, 33, 32, 33, 33, 33, 33, 34, 33, 32, 33, 34,
33, 33, 34, 34, 33, 33, 34, 34, 33, 34, 34, 33, 34, 34, 34, 33, 34, 34, 34, 34,
34, 34, 34, 34, 34, 34, 33, 34, 34, 34, 34, 34, 33, 34, 35, 35, 35, 35, 34, 35,
35, 34, 34, 34, 35, 35, 34, 34, 24, -10, -49, -64, -61, -54, -51, -51, -53, -52,
-52, -52, -52, -51, -51, -50, -50, -50, -49, -49, -48, -49, -49, -48, -48, -48,
-47, -48, -47, -47, -46, -46, -46, -46, -46, -45, -46, -46, -46, -45, -45, -44,
-44, -44, -45, -44, -44, -44, -44, -44, -43, -43, -43, -44, -42, -43, -42, -42,
-43, -42, -43, -43, -42, -43, -41, -42, -42, -42, -42, -42, -43, -42, -42, -42,
-42, -42, -42, -42, -42, -41, -42, -41, -41, -42, -41, -41, -42, -41, -40, -40,
-42, -41, -42, -41, -41, -41, -40, -40, -42, -41, -41, -41, -41, -41, -41, -41,
-41, -41, -42, -41, -41, -41, -40, -41, -41, -41, -42, -40, -42, -41, -41, -41,
-41, -41, -40, -42, -41, -42, -42, -41, -41, -41, -42, -42, -42, -41, -42, -42,
-42, -42, -42, -42, -42, -42, -42, -42, -42, -41, -42, -42, -41, -42, -41, -41,
-42, -42, -42, -43, -42, -42, -42, -43, -43, -42, -42, -43, -43, -43, -43, -43,
-43, -43, -43, -43, -44, -43, -44, -44, -44, -43, -44, -44, -44, -43, -44, -45,
-45, -45, -44, -44, -45, -45, -44, -45, -46, -45, -45, -45, -45, -44, -45, -46,
-45, -46, -47, -45, -46, -46, -46, -46, -46, -46, -47, -46, -47, -47, -47, -47,
-48, -47, -47, -48, -47, -48, -47, -49, -47, -48, -48, -49, -48, -49, -48, -51,
-47, -53, -29, };