#define DATA_LENGTH 512
#define DATA AKWF_blended_0036

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 3, 3, 4, 4, 5, 6, 6, 7, 7,
9, 9, 10, 10, 11, 12, 12, 12, 13, 14, 14, 15, 16, 17, 17, 18, 18, 20, 19, 20,
21, 23, 25, 28, 30, 32, 35, 36, 39, 41, 43, 45, 48, 50, 52, 53, 56, 59, 61, 63,
65, 67, 70, 71, 73, 75, 77, 80, 82, 85, 87, 89, 91, 91, 92, 93, 94, 94, 96, 97,
97, 99, 100, 100, 101, 102, 104, 104, 104, 106, 106, 107, 108, 109, 111, 111,
113, 113, 114, 115, 115, 117, 118, 119, 119, 118, 117, 118, 116, 116, 115, 115,
114, 114, 113, 112, 112, 110, 110, 110, 109, 108, 108, 106, 107, 106, 105, 105,
105, 104, 103, 102, 102, 101, 101, 100, 98, 95, 93, 91, 89, 87, 85, 83, 81, 78,
77, 73, 72, 69, 67, 65, 63, 61, 58, 57, 55, 52, 50, 48, 46, 44, 42, 39, 37, 35,
33, 30, 30, 29, 28, 28, 27, 26, 26, 24, 24, 23, 24, 22, 22, 21, 20, 21, 19, 18,
18, 18, 17, 16, 16, 15, 14, 13, 13, 12, 11, 11, 11, 9, 10, 10, 11, 12, 12, 13,
14, 15, 16, 15, 16, 16, 17, 18, 19, 18, 19, 21, 21, 21, 21, 23, 23, 24, 25, 26,
26, 26, 27, 28, 28, 29, 28, 28, 27, 26, 25, 25, 24, 22, 22, 21, 19, 19, 17, 17,
15, 14, 14, 13, 12, 12, 10, 9, 8, 7, 7, 5, 5, 4, 3, 2, 1, 1, -1, -2, -3, -4, -5,
-5, -6, -8, -9, -9, -11, -11, -11, -13, -14, -14, -16, -17, -18, -18, -19, -20,
-21, -22, -22, -23, -26, -25, -27, -28, -29, -30, -29, -29, -28, -27, -28, -27,
-25, -25, -25, -24, -24, -24, -22, -22, -20, -21, -20, -19, -19, -18, -17, -17,
-17, -15, -15, -15, -14, -13, -13, -12, -12, -11, -11, -12, -12, -14, -14, -15,
-15, -15, -16, -16, -17, -18, -19, -19, -20, -20, -21, -22, -23, -23, -23, -24,
-26, -26, -26, -27, -27, -28, -29, -30, -30, -30, -31, -35, -36, -38, -40, -42,
-45, -47, -49, -51, -53, -56, -58, -59, -63, -65, -66, -68, -71, -72, -74, -78,
-80, -81, -83, -86, -87, -90, -93, -95, -97, -98, -99, -100, -101, -101, -102,
-102, -103, -104, -105, -104, -105, -106, -107, -107, -108, -108, -109, -109,
-111, -112, -111, -112, -113, -113, -113, -116, -115, -116, -116, -117, -117,
-118, -118, -117, -117, -115, -115, -114, -113, -112, -110, -109, -109, -108,
-107, -105, -105, -105, -104, -102, -101, -101, -99, -98, -98, -96, -96, -95,
-94, -92, -92, -91, -90, -89, -88, -86, -83, -80, -78, -77, -74, -72, -70, -68,
-66, -63, -61, -58, -57, -54, -53, -50, -49, -46, -45, -42, -40, -37, -35, -34,
-31, -30, -26, -25, -22, -20, -19, -18, -18, -17, -16, -16, -15, -15, -14, -14,
-12, -12, -11, -11, -10, -10, -9, -9, -7, -8, -7, -6, -6, -4, -4, -3, -3, -2,
-2, -2, 0, };