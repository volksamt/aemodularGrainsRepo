#define DATA_LENGTH 512
#define DATA AKWF_blended_0077

const PROGMEM int8_t DATA[DATA_LENGTH] = {21, 38, 37, 42, 41, 45, 45, 48, 50,
51, 53, 55, 57, 58, 61, 61, 63, 65, 67, 69, 70, 72, 74, 75, 77, 79, 80, 81, 83,
85, 86, 87, 88, 89, 91, 92, 93, 95, 95, 97, 98, 99, 100, 101, 102, 102, 103,
105, 105, 106, 106, 107, 107, 107, 109, 109, 110, 111, 111, 113, 113, 114, 115,
115, 115, 115, 117, 117, 117, 118, 118, 119, 119, 119, 117, 117, 117, 117, 116,
115, 114, 113, 113, 111, 110, 109, 109, 108, 106, 106, 104, 102, 101, 100, 99,
97, 95, 94, 93, 92, 89, 88, 86, 85, 83, 81, 79, 77, 75, 74, 71, 70, 66, 65, 62,
62, 60, 58, 54, 53, 50, 49, 47, 43, 41, 40, 37, 38, 89, 103, 95, 96, 92, 92, 88,
88, 83, 82, 78, 77, 74, 72, 69, 67, 65, 63, 61, 58, 56, 53, 51, 48, 46, 44, 42,
40, 38, 36, 34, 31, 29, 26, 25, 23, 21, 19, 18, 15, 13, 11, 10, 7, 6, 3, 1, 0,
-2, -4, -6, -7, -9, -10, -12, -13, -14, -15, -16, -17, -18, -18, -19, -19, -20,
-21, -21, -21, -23, -23, -23, -23, -23, -24, -25, -26, -27, -28, -29, -30, -29,
-31, -31, -32, -32, -33, -33, -34, -35, -35, -35, -36, -36, -37, -37, -37, -37,
-37, -38, -37, -38, -37, -38, -38, -38, -38, -38, -38, -38, -38, -38, -38, -38,
-37, -38, -36, -37, -37, -38, -36, -37, -36, -37, -35, -36, -35, -37, -31, 25,
37, 33, 37, 34, 37, 35, 36, 36, 36, 36, 37, 36, 37, 36, 38, 37, 38, 37, 38, 37,
38, 37, 37, 38, 37, 37, 37, 38, 37, 37, 37, 37, 35, 36, 36, 36, 35, 35, 34, 34,
33, 33, 32, 32, 31, 31, 30, 30, 29, 27, 27, 27, 25, 24, 24, 23, 23, 22, 23, 22,
21, 21, 21, 20, 19, 18, 18, 17, 17, 16, 15, 14, 13, 11, 9, 8, 6, 5, 3, 1, -1,
-2, -4, -7, -9, -10, -12, -14, -15, -18, -20, -21, -24, -26, -28, -30, -33, -33,
-36, -39, -41, -43, -45, -48, -50, -51, -54, -56, -59, -61, -63, -66, -68, -72,
-72, -76, -77, -80, -81, -86, -87, -90, -91, -95, -95, -100, -94, -41, -34, -39,
-39, -44, -44, -48, -49, -52, -54, -56, -57, -60, -62, -64, -66, -68, -71, -72,
-74, -76, -78, -80, -81, -84, -85, -87, -88, -90, -92, -93, -95, -95, -98, -99,
-101, -102, -103, -104, -106, -107, -108, -109, -111, -111, -113, -113, -114,
-114, -115, -116, -117, -118, -117, -119, -119, -118, -119, -118, -118, -117,
-117, -117, -117, -116, -115, -115, -114, -114, -113, -111, -110, -109, -109,
-109, -108, -107, -107, -106, -106, -105, -104, -104, -102, -101, -102, -100,
-99, -98, -98, -96, -95, -93, -92, -91, -90, -88, -87, -86, -84, -83, -82, -80,
-79, -76, -76, -74, -72, -70, -69, -67, -66, -65, -62, -61, -58, -57, -55, -53,
-51, -50, -47, -47, -43, -44, -39, -41, -29, };