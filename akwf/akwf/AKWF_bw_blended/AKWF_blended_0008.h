#define DATA_LENGTH 512
#define DATA AKWF_blended_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 11, 20, 30, 39, 48, 57, 62, 65, 69,
73, 76, 79, 84, 86, 89, 92, 96, 98, 100, 103, 104, 107, 109, 110, 111, 111, 111,
113, 112, 113, 114, 114, 115, 115, 115, 116, 117, 117, 118, 117, 118, 118, 119,
118, 119, 118, 118, 119, 119, 119, 119, 119, 118, 120, 119, 119, 118, 118, 117,
117, 116, 117, 115, 116, 114, 113, 111, 110, 109, 107, 106, 104, 103, 101, 99,
99, 96, 95, 94, 93, 91, 90, 87, 86, 85, 83, 82, 80, 80, 78, 77, 75, 74, 72, 70,
69, 68, 67, 66, 64, 62, 61, 60, 58, 58, 59, 58, 57, 57, 58, 58, 59, 59, 60, 60,
60, 62, 62, 62, 62, 63, 64, 65, 65, 66, 66, 67, 67, 68, 68, 69, 70, 70, 71, 71,
72, 72, 74, 73, 73, 75, 74, 74, 76, 76, 76, 75, 75, 75, 75, 75, 73, 72, 71, 69,
68, 66, 65, 63, 63, 60, 59, 57, 56, 53, 52, 50, 48, 47, 45, 44, 41, 39, 38, 36,
35, 34, 31, 29, 28, 26, 24, 22, 20, 18, 16, 14, 13, 11, 9, 7, 5, 3, 1, 0, -2,
-4, -6, -8, -10, -11, -13, -15, -16, -18, -20, -22, -24, -26, -28, -30, -31,
-34, -35, -36, -38, -40, -42, -43, -44, -46, -48, -49, -51, -52, -54, -56, -57,
-59, -60, -61, -62, -62, -62, -62, -62, -61, -62, -60, -60, -59, -58, -57, -54,
-55, -53, -51, -49, -46, -41, -35, -27, -19, -12, -6, 2, 9, 16, 24, 31, 38, 44,
48, 50, 51, 53, 54, 56, 57, 59, 59, 60, 60, 61, 61, 62, 61, 62, 62, 61, 59, 58,
57, 57, 55, 53, 51, 50, 49, 46, 46, 44, 42, 40, 38, 37, 35, 33, 32, 29, 28, 27,
24, 23, 21, 19, 17, 16, 14, 12, 10, 8, 6, 4, 4, 1, 0, -2, -5, -7, -8, -10, -12,
-14, -16, -18, -20, -21, -24, -26, -27, -29, -30, -32, -34, -36, -37, -39, -41,
-42, -44, -46, -48, -49, -52, -53, -55, -56, -58, -60, -61, -63, -64, -66, -67,
-68, -71, -72, -74, -74, -75, -76, -76, -76, -76, -77, -76, -75, -75, -75, -74,
-73, -73, -73, -73, -72, -71, -71, -70, -70, -69, -69, -68, -67, -66, -67, -66,
-66, -65, -63, -63, -63, -62, -61, -61, -61, -60, -60, -59, -59, -58, -59, -58,
-58, -57, -59, -59, -59, -61, -62, -63, -65, -66, -68, -68, -70, -71, -73, -75,
-76, -77, -78, -81, -81, -84, -84, -86, -87, -90, -90, -92, -93, -95, -96, -98,
-100, -101, -102, -103, -105, -107, -107, -109, -111, -112, -113, -113, -115,
-116, -116, -117, -117, -117, -118, -117, -118, -118, -118, -118, -118, -119,
-119, -118, -117, -118, -118, -118, -118, -117, -117, -116, -116, -117, -116,
-115, -116, -115, -114, -114, -113, -113, -112, -113, -111, -110, -110, -110,
-108, -107, -105, -103, -100, -99, -95, -93, -90, -87, -85, -82, -78, -74, -71,
-66, -64, -58, -51, -42, -33, -23, -15, -5, };