#define DATA_LENGTH 512
#define DATA AKWF_blended_0041

const PROGMEM int8_t DATA[DATA_LENGTH] = {37, 45, 41, 45, 42, 44, 43, 45, 44,
44, 44, 45, 45, 45, 44, 45, 44, 46, 46, 47, 46, 47, 47, 47, 47, 47, 47, 47, 49,
48, 49, 49, 49, 49, 49, 50, 49, 50, 49, 49, 50, 51, 51, 51, 50, 51, 51, 51, 51,
51, 52, 52, 52, 52, 52, 52, 53, 53, 53, 53, 53, 53, 54, 53, 54, 54, 55, 55, 55,
55, 55, 55, 55, 56, 55, 56, 56, 57, 56, 57, 57, 56, 58, 57, 58, 58, 58, 58, 58,
59, 58, 59, 59, 59, 59, 60, 60, 60, 60, 61, 61, 61, 60, 60, 62, 61, 61, 62, 62,
61, 61, 63, 63, 63, 62, 63, 63, 63, 63, 64, 64, 64, 65, 64, 64, 65, 66, 66, 65,
66, 66, 65, 67, 66, 66, 67, 67, 67, 68, 68, 68, 67, 68, 69, 68, 69, 69, 68, 69,
69, 70, 69, 70, 70, 70, 70, 70, 70, 71, 71, 72, 72, 71, 72, 71, 72, 73, 73, 73,
72, 73, 73, 73, 73, 73, 74, 75, 75, 74, 74, 75, 75, 75, 75, 75, 75, 76, 76, 77,
77, 76, 77, 77, 78, 78, 77, 78, 77, 78, 78, 78, 78, 78, 79, 78, 79, 79, 79, 80,
80, 79, 80, 80, 81, 81, 81, 81, 81, 81, 81, 82, 82, 82, 82, 83, 82, 82, 83, 83,
83, 83, 84, 83, 84, 85, 85, 84, 85, 85, 85, 86, 85, 86, 86, 86, 87, 87, 86, 87,
85, 87, 86, 88, 85, 92, 18, -62, -58, -60, -58, -59, -58, -59, -57, -59, -57,
-57, -57, -57, -57, -56, -57, -56, -56, -55, -57, -55, -56, -55, -55, -55, -55,
-55, -55, -55, -54, -54, -54, -54, -53, -53, -54, -53, -52, -53, -53, -52, -53,
-52, -52, -51, -51, -51, -51, -51, -51, -50, -50, -49, -49, -50, -49, -49, -50,
-49, -49, -49, -49, -49, -48, -48, -48, -47, -47, -47, -47, -47, -47, -47, -46,
-47, -46, -46, -45, -46, -45, -45, -46, -45, -45, -45, -44, -43, -44, -44, -43,
-44, -43, -43, -44, -42, -42, -42, -42, -43, -42, -41, -41, -42, -41, -41, -40,
-41, -41, -40, -40, -40, -39, -40, -39, -39, -38, -38, -38, -39, -39, -38, -38,
-38, -38, -37, -38, -37, -37, -37, -37, -36, -36, -36, -36, -35, -35, -35, -35,
-35, -34, -34, -35, -34, -35, -34, -34, -34, -33, -33, -33, -32, -32, -32, -32,
-32, -32, -32, -31, -31, -30, -32, -30, -31, -29, -31, -29, -32, -28, -31, -27,
-32, -26, -33, -22, -44, -124, -117, -119, -119, -118, -118, -117, -118, -117,
-119, -117, -118, -116, -117, -116, -117, -116, -117, -115, -116, -115, -116,
-115, -116, -114, -114, -114, -114, -115, -114, -114, -114, -114, -112, -113,
-113, -113, -112, -112, -111, -112, -112, -111, -111, -111, -111, -111, -111,
-111, -110, -111, -110, -110, -109, -110, -110, -109, -108, -108, -108, -108,
-108, -108, -107, -108, -107, -108, -106, -108, -106, -108, -106, -107, -106,
-106, -105, -106, -104, -106, -105, -30, };