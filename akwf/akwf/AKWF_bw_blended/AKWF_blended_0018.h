#define DATA_LENGTH 512
#define DATA AKWF_blended_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 25, 27, 28, 30, 32, 34, 35, 37, 38,
41, 42, 44, 46, 47, 49, 51, 52, 55, 56, 58, 59, 61, 62, 64, 66, 68, 69, 71, 73,
75, 76, 77, 76, 76, 75, 74, 73, 72, 72, 71, 70, 69, 68, 67, 67, 65, 65, 63, 63,
62, 61, 60, 60, 58, 58, 56, 56, 55, 54, 53, 52, 51, 50, 50, 49, 48, 47, 46, 46,
45, 43, 43, 41, 41, 40, 39, 39, 37, 37, 35, 34, 33, 32, 32, 31, 30, 29, 27, 26,
25, 24, 24, 23, 23, 21, 20, 22, 24, 26, 28, 29, 31, 31, 34, 35, 36, 38, 40, 42,
42, 44, 47, 47, 49, 50, 53, 55, 56, 58, 58, 60, 61, 63, 65, 66, 67, 70, 71, 73,
73, 76, 77, 79, 81, 82, 84, 85, 87, 89, 90, 92, 93, 94, 95, 97, 98, 100, 102,
104, 105, 107, 107, 110, 110, 113, 114, 116, 117, 118, 119, 118, 116, 116, 114,
113, 113, 112, 110, 108, 108, 107, 106, 104, 104, 102, 101, 101, 99, 99, 96, 96,
94, 94, 93, 92, 90, 89, 88, 87, 86, 85, 83, 82, 81, 80, 78, 77, 77, 76, 74, 72,
72, 70, 70, 68, 67, 65, 65, 64, 63, 62, 61, 60, 59, 57, 56, 54, 53, 52, 50, 51,
49, 47, 47, 48, 50, 52, 52, 54, 55, 57, 59, 60, 61, 62, 64, 65, 67, 67, 71, 70,
73, 72, 77, 74, 79, 77, 83, 79, 86, 82, 90, 84, 93, 81, -70, -93, -85, -89, -83,
-87, -80, -83, -77, -80, -74, -77, -72, -74, -70, -71, -68, -68, -65, -65, -63,
-62, -60, -59, -58, -56, -54, -53, -52, -50, -49, -48, -47, -48, -50, -50, -51,
-53, -54, -56, -57, -57, -59, -59, -62, -63, -63, -64, -67, -67, -68, -70, -70,
-72, -73, -74, -76, -76, -77, -79, -79, -81, -81, -83, -84, -86, -87, -88, -88,
-91, -91, -93, -94, -94, -96, -97, -98, -99, -100, -101, -102, -104, -105, -105,
-107, -107, -108, -110, -111, -113, -114, -115, -115, -116, -118, -119, -119,
-118, -117, -114, -113, -111, -110, -109, -106, -105, -104, -102, -101, -99,
-98, -96, -95, -92, -92, -90, -88, -87, -86, -84, -83, -81, -80, -78, -77, -74,
-73, -72, -71, -68, -67, -66, -63, -63, -61, -60, -58, -56, -55, -53, -52, -49,
-49, -48, -45, -44, -41, -41, -39, -37, -36, -35, -33, -30, -30, -28, -27, -24,
-23, -22, -20, -22, -23, -23, -24, -25, -26, -26, -29, -29, -30, -30, -32, -33,
-34, -35, -36, -37, -38, -39, -39, -40, -41, -41, -43, -44, -44, -45, -47, -47,
-49, -50, -50, -50, -51, -53, -54, -54, -55, -56, -57, -58, -59, -60, -60, -61,
-63, -64, -64, -65, -65, -67, -67, -68, -69, -71, -71, -72, -73, -74, -75, -75,
-77, -78, -78, -75, -74, -72, -70, -68, -66, -66, -64, -62, -60, -58, -56, -55,
-53, -52, -50, -48, -47, -44, -43, -41, -39, -38, -37, -34, -33, -30, -30, -26,
-27, -21, };