#define DATA_LENGTH 512
#define DATA AKWF_blended_0028

const PROGMEM int8_t DATA[DATA_LENGTH] = {71, 118, 104, 112, 106, 110, 107, 108,
107, 108, 107, 107, 106, 106, 106, 106, 106, 105, 105, 105, 104, 103, 104, 104,
104, 103, 103, 103, 103, 102, 102, 101, 102, 101, 101, 101, 101, 100, 100, 99,
100, 100, 98, 100, 98, 98, 99, 98, 97, 98, 97, 97, 97, 97, 96, 96, 95, 96, 96,
95, 94, 95, 94, 94, 95, 94, 94, 93, 93, 92, 93, 93, 92, 92, 92, 91, 91, 92, 92,
91, 90, 90, 90, 90, 90, 89, 89, 88, 88, 88, 88, 88, 87, 88, 86, 87, 86, 87, 86,
86, 85, 85, 85, 84, 85, 83, 84, 83, 84, 82, 84, 82, 83, 81, 83, 80, 84, 79, 83,
79, 83, 77, 82, 78, 83, 77, 82, 75, -70, -84, -75, -84, -77, -83, -78, -82, -79,
-83, -80, -84, -80, -83, -81, -83, -83, -84, -83, -84, -83, -84, -84, -84, -85,
-85, -85, -85, -86, -86, -87, -86, -87, -87, -87, -88, -87, -88, -88, -88, -88,
-89, -89, -89, -89, -90, -90, -90, -90, -91, -91, -91, -91, -92, -93, -93, -92,
-92, -92, -94, -94, -94, -94, -94, -94, -94, -95, -95, -95, -95, -96, -96, -97,
-97, -96, -97, -97, -97, -97, -98, -99, -99, -100, -98, -98, -99, -99, -100,
-100, -101, -101, -101, -102, -101, -102, -102, -102, -102, -102, -103, -103,
-103, -104, -103, -104, -103, -105, -104, -106, -105, -106, -105, -106, -105,
-107, -105, -108, -106, -109, -106, -109, -106, -109, -109, -109, -109, -107,
-113, 2, 39, 25, 33, 26, 32, 26, 30, 28, 30, 27, 29, 27, 28, 26, 27, 26, 26, 26,
26, 26, 25, 26, 25, 25, 24, 25, 24, 24, 23, 23, 22, 22, 23, 22, 22, 22, 21, 21,
21, 20, 20, 20, 20, 20, 19, 19, 19, 19, 19, 19, 18, 18, 17, 17, 17, 17, 17, 17,
17, 16, 16, 15, 15, 15, 14, 14, 14, 15, 14, 14, 13, 13, 12, 13, 12, 12, 12, 12,
12, 11, 12, 10, 11, 10, 10, 10, 10, 10, 9, 9, 8, 8, 8, 8, 7, 8, 7, 6, 6, 7, 7,
6, 6, 6, 5, 5, 4, 5, 5, 4, 5, 3, 3, 3, 3, 3, 2, 2, 2, 1, 1, 1, 1, 1, 0, 0, 0,
-1, -1, 0, -1, -1, -1, -2, -2, -2, -3, -2, -3, -4, -4, -4, -4, -4, -5, -5, -4,
-6, -5, -5, -6, -6, -7, -7, -6, -7, -7, -8, -8, -8, -8, -8, -9, -9, -9, -9, -10,
-10, -10, -10, -10, -11, -12, -11, -12, -12, -12, -12, -13, -13, -14, -13, -14,
-14, -13, -14, -15, -14, -15, -15, -16, -16, -17, -16, -16, -16, -17, -17, -17,
-18, -18, -17, -18, -19, -19, -19, -19, -19, -20, -19, -21, -20, -21, -21, -21,
-22, -22, -22, -22, -23, -22, -23, -23, -23, -23, -23, -24, -24, -24, -25, -24,
-25, -26, -25, -26, -26, -26, -27, -27, -27, -27, -28, -27, -30, -28, -29, -28,
-29, -29, -31, -28, -31, -30, -30, -33, };