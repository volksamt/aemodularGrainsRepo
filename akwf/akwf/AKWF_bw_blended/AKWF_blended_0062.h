#define DATA_LENGTH 512
#define DATA AKWF_blended_0062

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 2, 2, 3, 4, 5, 5, 6, 7, 7, 8,
10, 10, 10, 12, 11, 13, 14, 14, 15, 16, 17, 17, 18, 19, 20, 20, 21, 21, 22, 23,
23, 24, 26, 26, 26, 28, 27, 29, 29, 31, 31, 32, 33, 34, 34, 35, 35, 36, 37, 38,
39, 39, 40, 41, 41, 42, 44, 44, 44, 45, 47, 47, 48, 48, 49, 49, 51, 51, 52, 53,
54, 54, 56, 55, 57, 57, 58, 59, 59, 60, 61, 62, 62, 63, 63, 65, 65, 65, 67, 68,
68, 70, 69, 70, 71, 72, 73, 74, 74, 75, 75, 77, 78, 78, 78, 79, 80, 81, 81, 82,
83, 83, 85, 85, 87, 87, 87, 88, 89, 89, 90, 90, 92, 92, 93, 94, 95, 95, 96, 97,
98, 98, 99, 100, 101, 102, 101, 104, 102, 107, 103, 110, 102, 113, 101, 121, 65,
-43, -29, -36, -31, -32, -30, -30, -30, -28, -28, -26, -26, -26, -25, -23, -23,
-21, -22, -21, -21, -19, -19, -18, -17, -17, -17, -15, -14, -13, -14, -11, -13,
-10, -11, -7, -10, -4, -12, 5, -42, -104, -88, -96, -90, -92, -90, -90, -88,
-89, -87, -86, -87, -84, -85, -83, -83, -82, -82, -80, -80, -78, -78, -77, -77,
-75, -75, -75, -74, -73, -72, -71, -72, -70, -69, -68, -68, -68, -67, -66, -64,
-64, -63, -63, -62, -61, -60, -60, -59, -58, -58, -57, -56, -55, -54, -54, -53,
-53, -52, -51, -51, -50, -49, -48, -47, -47, -46, -45, -44, -44, -43, -42, -41,
-41, -40, -39, -38, -38, -37, -37, -35, -35, -34, -33, -32, -32, -32, -30, -30,
-28, -29, -28, -27, -26, -26, -24, -24, -23, -22, -22, -21, -20, -19, -19, -17,
-17, -16, -15, -15, -14, -12, -13, -11, -11, -10, -9, -9, -8, -8, -6, -6, -6,
-4, -3, -2, -2, -1, -1, 0, 1, 2, 2, 2, 4, 4, 5, 6, 6, 7, 8, 8, 10, 10, 11, 12,
12, 13, 14, 15, 16, 17, 16, 17, 19, 19, 19, 20, 22, 22, 22, 24, 24, 25, 26, 27,
27, 27, 28, 30, 30, 30, 33, 33, 33, 34, 34, 36, 36, 37, 37, 39, 39, 40, 41, 42,
42, 43, 44, 45, 45, 47, 47, 48, 47, 50, 49, 50, 51, 53, 52, 53, 53, 55, 56, 56,
57, 58, 60, 58, 61, 59, 64, 59, 69, 57, 78, 6, -91, -71, -80, -74, -78, -74,
-75, -73, -74, -72, -72, -72, -70, -70, -68, -68, -66, -67, -65, -66, -64, -64,
-62, -62, -61, -61, -59, -60, -58, -58, -57, -56, -55, -54, -53, -53, -53, -51,
-52, -51, -49, -48, -47, -46, -47, -45, -45, -44, -43, -43, -42, -40, -41, -39,
-39, -38, -37, -36, -36, -35, -35, -34, -33, -32, -31, -31, -30, -29, -28, -27,
-27, -27, -26, -25, -24, -23, -23, -22, -21, -20, -20, -19, -19, -17, -16, -17,
-15, -14, -13, -13, -13, -11, -10, -10, -9, -8, -8, -6, -5, -5, -6, -5, -4, -2,
-2, -1, 0, };