#define DATA_LENGTH 512
#define DATA AKWF_blended_0078

const PROGMEM int8_t DATA[DATA_LENGTH] = {81, 121, 109, 116, 110, 113, 109, 112,
108, 110, 107, 108, 107, 107, 105, 105, 105, 104, 103, 103, 102, 101, 101, 100,
99, 98, 99, 97, 97, 96, 95, 94, 95, 93, 92, 92, 91, 91, 90, 89, 88, 88, 86, 86,
86, 84, 84, 83, 82, 82, 81, 80, 78, 78, 77, 77, 76, 76, 76, 76, 77, 76, 76, 75,
75, 75, 74, 75, 75, 74, 73, 74, 73, 72, 71, 71, 69, 68, 68, 66, 66, 64, 63, 62,
61, 59, 59, 58, 56, 55, 55, 55, 55, 54, 54, 54, 54, 53, 53, 52, 52, 51, 51, 51,
50, 50, 49, 49, 48, 48, 47, 48, 45, 45, 45, 45, 44, 44, 42, 43, 42, 42, 40, 40,
39, 39, 38, 40, 101, 117, 111, 114, 110, 112, 109, 111, 108, 108, 106, 106, 105,
104, 104, 103, 101, 101, 100, 99, 99, 97, 96, 95, 95, 94, 93, 91, 90, 89, 89,
87, 87, 85, 84, 83, 82, 82, 80, 78, 75, 74, 71, 69, 68, 66, 63, 61, 59, 57, 54,
53, 50, 48, 46, 44, 42, 42, 39, 39, 37, 35, 34, 33, 31, 29, 28, 26, 25, 24, 21,
20, 19, 16, 14, 12, 9, 7, 5, 3, 1, -2, -4, -7, -10, -11, -14, -16, -18, -22,
-24, -26, -27, -30, -33, -35, -37, -41, -42, -45, -47, -50, -53, -54, -56, -60,
-62, -64, -66, -70, -72, -74, -78, -80, -82, -83, -87, -88, -93, -93, -98, -97,
-103, -102, -109, -106, -118, -61, 94, 116, 107, 108, 103, 103, 98, 98, 93, 92,
88, 88, 85, 83, 79, 78, 74, 73, 70, 68, 64, 63, 59, 57, 55, 53, 51, 47, 45, 42,
40, 37, 35, 33, 31, 28, 26, 24, 21, 19, 17, 14, 11, 9, 7, 5, 2, 0, -2, -4, -8,
-10, -12, -14, -16, -18, -20, -21, -24, -25, -26, -28, -29, -31, -33, -34, -35,
-38, -39, -40, -41, -42, -44, -46, -48, -51, -53, -54, -58, -59, -61, -63, -64,
-67, -69, -71, -74, -75, -77, -79, -80, -81, -83, -84, -84, -86, -88, -88, -89,
-91, -91, -93, -94, -94, -95, -96, -97, -98, -98, -100, -101, -101, -103, -103,
-105, -105, -107, -106, -108, -107, -110, -110, -112, -111, -114, -112, -116,
-107, -45, -35, -40, -38, -41, -39, -43, -41, -43, -43, -45, -44, -45, -45, -46,
-46, -47, -47, -47, -49, -49, -49, -50, -51, -51, -51, -51, -52, -52, -53, -53,
-54, -54, -55, -54, -54, -55, -55, -56, -57, -58, -60, -61, -61, -63, -65, -65,
-66, -67, -68, -69, -69, -71, -73, -72, -75, -74, -75, -75, -75, -76, -76, -76,
-77, -76, -76, -76, -77, -77, -77, -78, -77, -78, -79, -79, -80, -81, -81, -81,
-83, -84, -84, -86, -86, -87, -87, -89, -89, -90, -92, -92, -92, -93, -94, -95,
-95, -96, -97, -97, -98, -98, -98, -99, -100, -101, -102, -102, -104, -103,
-105, -104, -105, -105, -107, -108, -108, -108, -109, -110, -110, -112, -112,
-112, -113, -114, -112, -118, -55, };