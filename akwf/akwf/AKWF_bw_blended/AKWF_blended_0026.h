#define DATA_LENGTH 512
#define DATA AKWF_blended_0026

const PROGMEM int8_t DATA[DATA_LENGTH] = {51, 62, 57, 62, 59, 61, 59, 61, 60,
63, 61, 63, 62, 62, 61, 63, 62, 64, 62, 64, 64, 63, 65, 64, 65, 64, 65, 65, 66,
66, 66, 66, 67, 67, 67, 68, 68, 68, 68, 67, 69, 69, 69, 69, 69, 70, 70, 70, 70,
71, 71, 71, 71, 72, 71, 72, 73, 73, 73, 74, 73, 73, 74, 74, 75, 75, 75, 75, 75,
75, 76, 76, 76, 77, 76, 77, 77, 78, 77, 78, 78, 78, 79, 79, 78, 80, 79, 79, 79,
80, 81, 81, 81, 81, 81, 82, 82, 83, 82, 83, 83, 83, 83, 83, 83, 84, 85, 84, 85,
85, 85, 85, 85, 86, 85, 86, 86, 86, 87, 87, 88, 87, 88, 88, 88, 88, 89, 89, 89,
90, 90, 90, 90, 90, 91, 91, 92, 92, 92, 92, 92, 93, 93, 93, 93, 93, 94, 94, 94,
95, 95, 95, 95, 95, 95, 96, 96, 96, 97, 97, 97, 98, 96, 98, 98, 98, 98, 99, 99,
99, 99, 99, 99, 99, 100, 101, 101, 101, 101, 102, 101, 102, 103, 102, 103, 103,
103, 103, 104, 104, 103, 104, 104, 105, 105, 104, 106, 106, 105, 107, 107, 107,
106, 107, 107, 108, 108, 108, 108, 108, 109, 109, 110, 110, 109, 110, 110, 110,
111, 111, 111, 111, 111, 112, 112, 113, 112, 113, 113, 114, 113, 114, 113, 115,
114, 115, 114, 116, 114, 116, 115, 118, 115, 118, 115, 118, 116, 119, 117, 119,
118, 119, 119, 116, 126, -42, -128, -112, -123, -115, -121, -114, -121, -115,
-118, -115, -117, -116, -117, -116, -116, -116, -115, -115, -115, -115, -114,
-115, -114, -115, -112, -114, -112, -113, -112, -112, -111, -113, -112, -111,
-111, -111, -111, -111, -110, -110, -110, -110, -110, -108, -108, -108, -108,
-108, -107, -108, -107, -107, -107, -107, -106, -106, -106, -105, -105, -106,
-105, -104, -104, -105, -105, -104, -104, -103, -103, -103, -103, -102, -102,
-102, -102, -102, -102, -101, -101, -100, -101, -100, -99, -99, -99, -99, -99,
-99, -98, -98, -98, -97, -98, -96, -98, -96, -97, -96, -96, -96, -96, -96, -94,
-95, -94, -94, -95, -94, -94, -93, -93, -93, -93, -93, -91, -92, -91, -91, -90,
-91, -91, -90, -91, -89, -90, -90, -89, -89, -89, -89, -88, -88, -88, -88, -88,
-87, -86, -87, -87, -87, -87, -86, -85, -86, -85, -85, -84, -84, -84, -83, -84,
-83, -84, -83, -82, -82, -82, -82, -82, -81, -81, -81, -81, -81, -80, -80, -79,
-79, -79, -79, -79, -78, -78, -78, -78, -78, -78, -78, -77, -77, -77, -77, -76,
-76, -75, -75, -75, -74, -75, -74, -73, -74, -74, -73, -73, -72, -72, -72, -72,
-72, -73, -72, -71, -71, -71, -71, -70, -69, -70, -70, -70, -70, -70, -69, -69,
-68, -68, -68, -68, -67, -67, -67, -66, -67, -66, -65, -65, -65, -65, -65, -65,
-65, -64, -64, -63, -64, -63, -64, -62, -63, -62, -63, -61, -62, -61, -63, -60,
-62, -60, -62, -59, -61, -59, -61, -57, -2, };