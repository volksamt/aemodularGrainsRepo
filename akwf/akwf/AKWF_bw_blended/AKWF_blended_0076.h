#define DATA_LENGTH 512
#define DATA AKWF_blended_0076

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 9, 14, 19, 23, 27, 31, 36, 41,
44, 49, 53, 58, 61, 64, 69, 72, 76, 79, 82, 86, 88, 92, 94, 98, 100, 102, 104,
107, 109, 110, 112, 114, 114, 116, 116, 117, 117, 119, 119, 119, 119, 119, 119,
118, 117, 117, 117, 116, 114, 114, 113, 111, 110, 108, 106, 105, 103, 101, 100,
98, 95, 93, 91, 88, 87, 84, 82, 80, 77, 75, 73, 71, 69, 67, 63, 62, 61, 58, 56,
54, 52, 50, 49, 47, 45, 44, 42, 40, 39, 37, 37, 36, 35, 34, 34, 33, 33, 32, 32,
31, 32, 31, 32, 31, 32, 32, 32, 34, 34, 34, 35, 36, 37, 38, 38, 40, 41, 42, 43,
44, 46, 47, 48, 49, 51, 52, 54, 54, 56, 58, 58, 59, 61, 62, 64, 64, 65, 66, 68,
67, 68, 69, 69, 70, 71, 70, 71, 71, 71, 71, 70, 70, 69, 70, 68, 68, 67, 66, 65,
64, 62, 61, 60, 58, 55, 54, 52, 50, 48, 45, 42, 40, 38, 35, 33, 30, 27, 24, 22,
19, 16, 12, 9, 6, 3, 0, -4, -7, -9, -13, -15, -19, -22, -25, -27, -31, -34, -37,
-39, -42, -45, -47, -49, -51, -54, -56, -57, -60, -61, -62, -64, -65, -67, -68,
-68, -69, -70, -71, -71, -71, -71, -71, -70, -70, -70, -69, -69, -68, -66, -65,
-63, -61, -59, -58, -56, -55, -52, -50, -47, -45, -42, -40, -37, -35, -32, -28,
-25, -22, -20, -17, -12, -10, -6, -2, 0, 3, 7, 10, 13, 17, 20, 24, 26, 29, 32,
35, 38, 41, 43, 45, 48, 51, 53, 54, 57, 59, 60, 63, 63, 64, 66, 67, 69, 68, 70,
70, 70, 71, 70, 71, 70, 70, 70, 68, 69, 67, 67, 65, 64, 63, 61, 59, 57, 55, 53,
51, 49, 47, 43, 41, 39, 35, 33, 30, 28, 24, 21, 18, 15, 11, 9, 6, 3, 0, -3, -7,
-11, -12, -16, -19, -21, -25, -28, -31, -33, -36, -38, -41, -43, -46, -48, -50,
-53, -54, -57, -59, -59, -61, -63, -64, -65, -67, -68, -67, -69, -69, -70, -70,
-71, -71, -71, -71, -70, -71, -70, -70, -70, -69, -68, -68, -66, -66, -64, -63,
-63, -62, -60, -59, -58, -57, -57, -55, -53, -51, -50, -49, -47, -46, -45, -44,
-42, -42, -41, -39, -38, -37, -36, -36, -35, -34, -33, -33, -32, -33, -31, -31,
-31, -30, -32, -31, -31, -33, -32, -33, -33, -34, -36, -36, -38, -38, -40, -41,
-42, -44, -45, -47, -49, -50, -52, -54, -56, -58, -61, -63, -64, -67, -69, -72,
-74, -77, -78, -80, -82, -85, -88, -90, -92, -94, -96, -98, -100, -102, -103,
-105, -106, -109, -110, -111, -112, -114, -116, -116, -117, -118, -118, -118,
-118, -119, -119, -119, -119, -118, -118, -117, -116, -115, -113, -112, -111,
-109, -108, -106, -103, -101, -99, -96, -93, -91, -88, -85, -82, -78, -75, -71,
-68, -64, -60, -56, -53, -49, -44, -39, -36, -31, -27, -21, -17, -13, -8, -4, };