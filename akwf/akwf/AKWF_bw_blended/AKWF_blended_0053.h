#define DATA_LENGTH 512
#define DATA AKWF_blended_0053

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 3, 4, 4, 5, 5, 7, 8, 7, 9, 9,
10, 12, 12, 12, 13, 14, 15, 15, 15, 17, 18, 18, 19, 19, 21, 21, 22, 23, 23, 24,
25, 25, 27, 28, 28, 28, 29, 31, 32, 31, 33, 33, 33, 35, 35, 37, 36, 38, 38, 39,
40, 41, 42, 43, 43, 43, 44, 45, 45, 46, 48, 48, 49, 50, 50, 52, 52, 52, 53, 55,
55, 56, 56, 57, 58, 58, 60, 60, 61, 61, 62, 62, 64, 65, 65, 65, 67, 67, 68, 69,
70, 70, 72, 72, 73, 74, 74, 76, 75, 76, 77, 78, 78, 80, 80, 82, 82, 83, 83, 83,
85, 86, 86, 87, 87, 87, 90, 90, 90, 91, 93, 92, 94, 95, 95, 95, 96, 97, 98, 100,
99, 101, 100, 103, 102, 105, 103, 107, 104, 109, 104, 110, 106, 111, 107, 113,
110, 114, 113, 113, 116, 111, 127, -80, -128, -107, -125, -109, -122, -110,
-118, -109, -115, -109, -113, -108, -111, -108, -108, -107, -107, -106, -104,
-105, -103, -102, -101, -102, -99, -101, -99, -99, -96, -97, -95, -96, -94, -94,
-93, -93, -92, -91, -90, -89, -89, -88, -87, -86, -85, -84, -85, -83, -82, -82,
-81, -80, -80, -79, -78, -78, -77, -75, -76, -75, -75, -73, -73, -72, -70, -71,
-70, -69, -68, -67, -67, -66, -65, -64, -63, -63, -62, -62, -61, -60, -59, -57,
-57, -57, -56, -56, -55, -53, -52, -52, -51, -52, -50, -50, -48, -48, -48, -47,
-46, -44, -44, -44, -43, -41, -41, -41, -40, -39, -38, -37, -36, -36, -35, -34,
-34, -33, -32, -32, -31, -30, -30, -28, -27, -27, -26, -26, -24, -23, -23, -23,
-22, -21, -20, -19, -19, -18, -17, -17, -16, -15, -15, -13, -13, -12, -11, -10,
-9, -9, -8, -7, -6, -6, -5, -4, -4, -3, -2, -1, 0, 0, 0, 2, 2, 2, 4, 4, 5, 6, 6,
7, 8, 9, 10, 10, 11, 12, 13, 13, 14, 14, 15, 17, 17, 18, 18, 19, 21, 21, 21, 22,
22, 24, 24, 25, 26, 27, 27, 29, 29, 30, 30, 31, 31, 33, 34, 35, 35, 36, 37, 37,
38, 39, 39, 40, 41, 41, 42, 44, 45, 44, 46, 46, 47, 48, 48, 49, 50, 51, 51, 52,
53, 53, 54, 55, 54, 57, 57, 58, 58, 60, 59, 62, 61, 64, 62, 64, 64, 67, 65, 68,
67, 69, 69, 69, 72, 69, 76, 66, 88, -26, -85, -61, -75, -63, -70, -63, -68, -63,
-66, -62, -63, -61, -62, -60, -60, -59, -58, -57, -56, -57, -54, -55, -53, -53,
-52, -52, -50, -51, -50, -49, -47, -47, -46, -45, -44, -44, -43, -43, -42, -42,
-40, -40, -38, -38, -37, -37, -36, -35, -34, -34, -32, -32, -32, -30, -29, -30,
-28, -28, -28, -26, -25, -24, -23, -23, -23, -21, -21, -20, -19, -19, -18, -17,
-16, -16, -16, -15, -13, -13, -12, -11, -10, -9, -9, -9, -7, -6, -6, -6, -5, -3,
-3, -3, -1, -1, -1, };