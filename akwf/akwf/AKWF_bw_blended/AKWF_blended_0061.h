#define DATA_LENGTH 512
#define DATA AKWF_blended_0061

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 2, 3, 4, 5, 6, 6, 6, 8, 9, 9,
10, 11, 12, 13, 14, 14, 15, 17, 17, 18, 19, 20, 20, 21, 21, 24, 23, 24, 25, 26,
27, 27, 28, 29, 29, 31, 31, 33, 34, 34, 36, 36, 37, 38, 38, 39, 40, 41, 41, 42,
43, 44, 45, 46, 47, 47, 48, 48, 50, 50, 52, 52, 53, 54, 55, 55, 57, 57, 58, 58,
60, 60, 62, 62, 63, 63, 65, 65, 66, 67, 68, 69, 70, 70, 71, 71, 73, 73, 75, 75,
76, 78, 77, 79, 80, 81, 81, 83, 83, 84, 84, 85, 86, 88, 88, 89, 89, 91, 91, 93,
92, 95, 94, 96, 96, 97, 98, 98, 100, 99, 102, 100, 105, 101, 108, 101, 111, 99,
122, 50, -66, -45, -55, -47, -50, -47, -48, -45, -45, -46, -43, -44, -41, -42,
-40, -41, -38, -39, -36, -37, -34, -35, -34, -33, -32, -32, -30, -30, -28, -28,
-27, -26, -26, -25, -24, -23, -22, -22, -21, -20, -19, -18, -17, -16, -16, -15,
-13, -13, -13, -12, -11, -10, -10, -8, -8, -7, -6, -5, -4, -3, -2, -2, -1, 0, 0,
1, 3, 3, 4, 6, 6, 6, 8, 8, 8, 10, 10, 11, 12, 13, 14, 15, 15, 16, 17, 18, 19,
20, 21, 21, 23, 22, 24, 24, 26, 26, 27, 27, 29, 29, 31, 31, 32, 32, 33, 36, 33,
39, 33, 48, -30, -70, -53, -62, -54, -59, -54, -57, -53, -54, -51, -53, -50,
-50, -49, -48, -47, -47, -46, -45, -45, -43, -44, -41, -41, -39, -40, -37, -38,
-37, -37, -34, -34, -33, -32, -31, -30, -30, -29, -29, -28, -27, -26, -25, -24,
-24, -22, -22, -22, -20, -20, -18, -18, -17, -16, -16, -14, -14, -13, -12, -11,
-10, -9, -9, -8, -7, -7, -5, -4, -4, -3, -2, -1, -1, 0, 1, 2, 2, 3, 4, 6, 6, 7,
7, 9, 9, 10, 11, 12, 13, 13, 15, 15, 16, 18, 18, 18, 19, 21, 21, 22, 22, 24, 25,
25, 26, 27, 27, 28, 30, 30, 31, 32, 33, 33, 35, 35, 36, 37, 38, 38, 40, 40, 41,
41, 44, 43, 44, 45, 46, 47, 48, 48, 49, 51, 50, 52, 52, 54, 51, 58, 52, 61, 49,
74, -17, -117, -92, -105, -95, -101, -95, -98, -95, -95, -94, -93, -93, -92,
-92, -89, -90, -88, -89, -86, -86, -85, -85, -83, -83, -81, -82, -81, -79, -78,
-78, -77, -76, -74, -75, -73, -73, -72, -70, -71, -69, -68, -68, -67, -66, -65,
-64, -64, -63, -62, -62, -60, -60, -58, -58, -57, -56, -56, -55, -53, -53, -52,
-52, -51, -50, -48, -48, -47, -46, -46, -44, -43, -43, -42, -41, -40, -39, -39,
-38, -37, -37, -35, -35, -34, -33, -32, -32, -31, -30, -29, -28, -28, -27, -26,
-25, -25, -24, -22, -21, -20, -20, -19, -19, -18, -17, -16, -15, -14, -13, -13,
-11, -12, -10, -9, -9, -8, -7, -6, -5, -4, -3, -3, -2, 0, 0, };