#define DATA_LENGTH 512
#define DATA AKWF_blended_0046

const PROGMEM int8_t DATA[DATA_LENGTH] = {46, 122, 118, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 118, 120, 119, 120, 119, 120, 119, 120, 119, 119, 118,
119, 118, 119, 119, 120, 119, 119, 118, 120, 119, 119, 118, 121, 107, 44, 25,
30, 27, 29, 28, 28, 28, 28, 27, 29, 28, 28, 28, 28, 29, 29, 28, 29, 28, 29, 28,
29, 28, 28, 28, 28, 29, 28, 28, 28, 29, 29, 29, 28, 28, 28, 29, 28, 29, 28, 29,
29, 29, 28, 28, 28, 28, 28, 27, 28, 28, 28, 28, 28, 28, 29, 28, 28, 28, 28, 28,
28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 29, 28, 28, 28, 29, 29, 28, 28, 29, 29,
28, 29, 29, 28, 29, 27, 28, 28, 28, 28, 28, 28, 29, 29, 28, 28, 28, 28, 29, 28,
27, 28, 29, 29, 28, 28, 29, 28, 28, 29, 28, 28, 28, 29, 28, 28, 28, 29, 28, 29,
28, 28, 28, 29, 28, 29, 28, 28, 28, 28, 29, 29, 28, 29, 28, 29, 28, 28, 29, 28,
29, 29, 28, 28, 28, 29, 28, 29, 28, 29, 28, 29, 28, 28, 28, 28, 28, 29, 28, 28,
29, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 29, 28, 29, 28, 28, 28, 29, 28,
28, 28, 27, 28, 28, 29, 29, 28, 29, 28, 28, 28, 28, 28, 29, 28, 29, 28, 28, 28,
28, 28, 29, 29, 29, 28, 28, 28, 29, 28, 28, 29, 27, 29, 27, 28, -57, -124, -117,
-121, -118, -119, -118, -120, -118, -120, -118, -119, -118, -119, -119, -120,
-118, -119, -119, -118, -119, -118, -119, -118, -120, -119, -119, -119, -119,
-119, -120, -118, -120, -119, -120, -118, -123, -101, -38, -27, -29, -28, -29,
-27, -29, -28, -29, -28, -29, -29, -29, -28, -28, -28, -28, -27, -28, -28, -28,
-29, -28, -28, -28, -29, -29, -29, -28, -29, -28, -28, -28, -29, -28, -29, -28,
-28, -28, -28, -28, -28, -28, -28, -28, -28, -29, -29, -29, -28, -28, -28, -29,
-28, -28, -28, -29, -28, -28, -28, -29, -29, -28, -28, -28, -28, -29, -29, -28,
-28, -29, -28, -28, -28, -28, -28, -29, -28, -28, -29, -28, -29, -29, -29, -28,
-28, -28, -29, -28, -28, -28, -29, -29, -28, -29, -28, -29, -29, -29, -27, -28,
-28, -28, -29, -28, -28, -28, -28, -28, -28, -29, -28, -28, -28, -28, -28, -29,
-29, -28, -28, -29, -29, -28, -28, -29, -28, -29, -28, -29, -28, -28, -29, -28,
-29, -29, -29, -28, -29, -28, -28, -28, -28, -28, -28, -29, -28, -29, -29, -28,
-28, -28, -28, -28, -28, -28, -28, -28, -28, -28, -28, -28, -29, -28, -28, -29,
-29, -29, -28, -28, -29, -28, -29, -28, -29, -28, -28, -29, -29, -29, -28, -28,
-28, -28, -28, -28, -28, -28, -28, -28, -28, -28, -28, -28, -28, -28, -29, -28,
-28, -28, -29, -29, -29, -29, -28, -28, -28, -28, -28, -29, -28, -29, -28, -29,
-27, -30, -27, -30, -24, };