#define DATA_LENGTH 512
#define DATA AKWF_blended_0047

const PROGMEM int8_t DATA[DATA_LENGTH] = {25, 29, 28, 29, 28, 28, 27, 29, 28,
29, 29, 28, 28, 29, 28, 28, 28, 28, 28, 29, 28, 28, 28, 28, 28, 29, 29, 28, 29,
28, 29, 28, 28, 29, 29, 28, 28, 29, 28, 28, 29, 29, 28, 29, 28, 29, 28, 28, 28,
28, 28, 28, 28, 28, 28, 29, 28, 29, 28, 28, 29, 28, 29, 27, 28, 28, 29, 28, 29,
28, 29, 27, 30, 24, 60, 117, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 119, 120,
118, 119, 119, 119, 119, 119, 119, 119, 118, 120, 118, 119, 119, 120, 119, 119,
119, 119, 119, 118, 120, 119, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119,
119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 118, 118, 119, 119, 120, 119, 120, 119, 120, 119, 119, 118, 118, 119, 119,
119, 119, 118, 119, 119, 119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 120,
120, 119, 119, 119, 118, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119,
119, 118, 119, 118, 120, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120, 120,
120, 118, 119, 119, 118, 119, 119, 120, 119, 120, 119, 119, 120, 118, 119, 120,
119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120, 119, 118,
120, 118, 119, 118, 119, 118, 121, 116, 124, 50, -31, -27, -29, -27, -29, -28,
-28, -29, -29, -29, -29, -29, -28, -28, -28, -28, -27, -29, -28, -29, -28, -29,
-29, -28, -28, -29, -29, -28, -29, -28, -29, -28, -28, -29, -29, -28, -28, -27,
-28, -28, -29, -29, -28, -28, -28, -28, -27, -28, -28, -28, -28, -28, -28, -29,
-29, -28, -29, -28, -28, -29, -28, -29, -28, -28, -28, -28, -29, -27, -29, -28,
-29, -27, -30, -25, -66, -120, -118, -119, -118, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -120, -118, -120, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -118, -119,
-119, -120, -118, -119, -118, -120, -119, -119, -119, -118, -119, -118, -118,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -118,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -120, -119, -120, -119, -120, -119, -119, -119, -118, -119, -119,
-119, -119, -118, -119, -120, -118, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -120, -119, -119, -118, -119, -120, -119, -119, -119, -119, -118,
-119, -119, -120, -120, -120, -120, -119, -119, -118, -119, -119, -119, -120,
-120, -119, -119, -119, -119, -119, -120, -119, -120, -119, -120, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -118, -118, -119,
-119, -120, -118, -120, -118, -120, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -42, };