#define DATA_LENGTH 512
#define DATA AKWF_blended_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 15, 19, 22, 26, 29, 33, 36,
38, 41, 44, 47, 49, 51, 53, 55, 58, 60, 61, 63, 65, 66, 68, 70, 72, 72, 74, 76,
77, 78, 79, 81, 82, 83, 84, 86, 86, 87, 87, 89, 89, 91, 92, 93, 93, 94, 95, 95,
96, 96, 97, 97, 98, 98, 98, 95, 93, 90, 88, 86, 85, 83, 81, 80, 79, 78, 77, 76,
76, 75, 75, 73, 73, 73, 73, 72, 72, 71, 72, 71, 72, 71, 72, 72, 71, 71, 70, 72,
71, 71, 72, 71, 71, 72, 71, 71, 72, 72, 71, 72, 71, 72, 73, 72, 72, 72, 73, 72,
73, 72, 70, 67, 66, 62, 60, 58, 56, 54, 54, 55, 56, 57, 58, 58, 59, 60, 61, 61,
60, 61, 60, 61, 62, 61, 61, 62, 62, 61, 61, 60, 60, 60, 59, 59, 59, 59, 59, 59,
59, 58, 59, 57, 58, 57, 57, 57, 55, 56, 56, 56, 56, 55, 55, 56, 54, 55, 54, 54,
54, 53, 54, 53, 53, 54, 54, 54, 53, 53, 53, 53, 52, 51, 51, 47, 44, 41, 38, 36,
34, 31, 29, 28, 25, 25, 23, 22, 21, 20, 19, 18, 17, 16, 15, 15, 14, 13, 13, 12,
12, 12, 11, 11, 10, 10, 10, 10, 10, 9, 9, 7, 6, 4, 2, 0, -2, -5, -7, -9, -11,
-14, -15, -18, -20, -23, -25, -26, -29, -29, -29, -29, -28, -28, -27, -26, -26,
-25, -23, -20, -15, -12, -9, -7, -4, -2, 0, 3, 3, 6, 7, 8, 8, 10, 10, 11, 12,
13, 13, 14, 15, 14, 15, 16, 16, 16, 15, 15, 16, 15, 16, 16, 15, 16, 16, 15, 15,
15, 15, 15, 14, 15, 14, 13, 14, 14, 13, 13, 13, 12, 12, 12, 12, 11, 12, 12, 11,
11, 10, 9, 10, 9, 6, 4, 0, -3, -6, -8, -10, -12, -15, -18, -18, -21, -22, -24,
-25, -26, -27, -28, -30, -30, -31, -32, -33, -34, -35, -35, -36, -36, -37, -37,
-37, -37, -38, -40, -40, -40, -40, -40, -41, -40, -42, -41, -41, -42, -41, -42,
-42, -43, -44, -43, -44, -44, -44, -44, -44, -46, -48, -50, -53, -55, -58, -60,
-63, -65, -66, -65, -64, -63, -62, -62, -61, -62, -60, -61, -60, -61, -60, -61,
-61, -61, -61, -62, -61, -63, -63, -63, -63, -64, -63, -64, -64, -64, -65, -65,
-66, -66, -66, -66, -67, -68, -68, -68, -68, -69, -70, -70, -70, -70, -70, -71,
-71, -72, -72, -72, -72, -72, -72, -72, -73, -73, -73, -73, -74, -74, -73, -74,
-75, -75, -77, -80, -83, -86, -88, -92, -94, -96, -98, -99, -102, -103, -104,
-105, -107, -108, -109, -110, -111, -112, -112, -113, -114, -115, -115, -115,
-115, -117, -117, -117, -118, -118, -118, -119, -118, -120, -118, -118, -117,
-115, -113, -112, -109, -108, -106, -104, -101, -100, -98, -95, -93, -91, -89,
-87, -85, -82, -79, -74, -69, -65, -61, -57, -53, -49, -43, -36, -31, -23, -17,
-12, -7, -3, };