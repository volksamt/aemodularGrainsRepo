#define DATA_LENGTH 512
#define DATA AKWF_blended_0052

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 2, 2, 3, 3, 4, 5, 5, 6, 7, 8, 9,
8, 10, 11, 10, 12, 12, 13, 13, 14, 14, 16, 16, 17, 17, 19, 19, 20, 21, 21, 22,
22, 22, 23, 24, 26, 26, 27, 27, 28, 28, 29, 30, 30, 31, 32, 33, 33, 33, 34, 35,
36, 37, 38, 38, 39, 40, 40, 40, 41, 42, 43, 43, 44, 44, 45, 46, 46, 47, 48, 48,
50, 49, 51, 51, 51, 52, 53, 54, 55, 55, 55, 57, 58, 58, 59, 59, 60, 61, 62, 63,
63, 64, 63, 65, 65, 66, 67, 68, 68, 69, 70, 70, 71, 71, 73, 73, 74, 74, 75, 75,
76, 77, 78, 78, 79, 79, 81, 80, 82, 83, 82, 85, 85, 86, 86, 87, 86, 88, 89, 89,
89, 90, 91, 92, 93, 93, 93, 94, 95, 96, 96, 97, 98, 98, 99, 99, 101, 100, 102,
102, 104, 102, 105, 105, 107, 106, 109, 107, 109, 109, 110, 110, 111, 113, 112,
114, 113, 116, 112, 121, 110, 126, 104, 127, 11, -119, -79, -101, -86, -95, -88,
-91, -87, -88, -86, -86, -86, -85, -86, -83, -84, -81, -83, -80, -81, -78, -80,
-78, -78, -77, -77, -74, -76, -74, -75, -73, -73, -72, -71, -70, -69, -69, -69,
-68, -67, -67, -66, -65, -64, -64, -62, -63, -61, -61, -61, -59, -59, -58, -57,
-57, -56, -56, -55, -54, -54, -53, -53, -51, -51, -50, -50, -48, -48, -48, -46,
-46, -46, -45, -45, -43, -43, -42, -42, -41, -40, -39, -39, -38, -38, -36, -36,
-36, -35, -34, -33, -33, -33, -32, -30, -30, -30, -28, -28, -27, -26, -26, -25,
-25, -24, -23, -23, -21, -22, -21, -20, -20, -18, -19, -17, -16, -16, -15, -15,
-13, -14, -12, -13, -11, -11, -10, -10, -9, -8, -7, -7, -6, -5, -4, -4, -3, -2,
-2, -2, 0, 1, 1, 2, 2, 3, 3, 4, 6, 5, 6, 7, 7, 8, 9, 10, 10, 11, 11, 13, 13, 14,
15, 15, 15, 16, 18, 18, 19, 18, 20, 20, 21, 22, 23, 23, 25, 24, 26, 26, 26, 27,
28, 29, 29, 29, 30, 32, 31, 33, 33, 35, 33, 37, 34, 37, 36, 39, 36, 41, 38, 43,
40, 43, 41, 44, 43, -77, -91, -81, -88, -80, -86, -79, -84, -80, -82, -79, -80,
-77, -79, -77, -77, -76, -75, -74, -74, -74, -73, -72, -71, -71, -70, -69, -68,
-69, -67, -67, -65, -65, -63, -64, -63, -62, -62, -61, -60, -60, -59, -59, -58,
-56, -57, -56, -55, -54, -54, -53, -52, -52, -51, -50, -50, -50, -48, -47, -47,
-46, -46, -45, -44, -43, -42, -42, -41, -41, -40, -40, -40, -38, -37, -36, -37,
-35, -34, -35, -34, -33, -32, -31, -31, -30, -29, -29, -28, -27, -27, -26, -26,
-25, -24, -23, -23, -22, -21, -21, -20, -20, -19, -18, -18, -17, -16, -16, -14,
-13, -13, -13, -12, -12, -11, -10, -9, -8, -8, -7, -7, -6, -6, -5, -4, -3, -3,
-2, -1, -1, };