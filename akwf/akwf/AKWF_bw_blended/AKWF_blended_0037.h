#define DATA_LENGTH 512
#define DATA AKWF_blended_0037

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 0, 0, 0, 1, 1, 1, 1, 2, 1, 1, 2,
1, 2, 2, 1, 2, 1, 2, 3, 2, 3, 2, 3, 4, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 5, 6, 8,
10, 10, 13, 15, 16, 17, 20, 21, 23, 25, 26, 27, 30, 31, 33, 35, 36, 38, 40, 41,
43, 45, 46, 49, 49, 52, 53, 55, 57, 59, 60, 62, 63, 65, 68, 68, 70, 72, 74, 75,
77, 79, 80, 82, 84, 85, 87, 90, 90, 93, 94, 96, 97, 99, 101, 103, 104, 106, 107,
109, 111, 113, 113, 113, 113, 114, 113, 114, 114, 114, 114, 114, 114, 115, 115,
115, 114, 114, 115, 115, 115, 115, 116, 116, 116, 115, 117, 116, 117, 116, 118,
115, 120, 105, 80, 83, 80, 80, 77, 77, 74, 73, 72, 70, 70, 68, 66, 65, 64, 62,
61, 59, 57, 55, 55, 53, 52, 50, 49, 47, 45, 44, 43, 41, 40, 38, 38, 38, 39, 39,
38, 39, 39, 39, 40, 39, 40, 39, 40, 40, 40, 40, 41, 40, 41, 41, 41, 42, 41, 41,
41, 42, 42, 41, 42, 42, 41, 42, 43, 42, 42, 43, 43, 43, 43, 43, 43, 43, 43, 43,
44, 44, 45, 44, 44, 43, 45, 44, 45, 44, 45, 45, 45, 45, 45, 46, 45, 45, 45, 46,
44, 44, 42, 41, 39, 38, 36, 35, 32, 31, 30, 29, 27, 26, 24, 22, 21, 20, 18, 17,
16, 14, 12, 12, 9, 8, 7, 5, 4, 2, 0, 0, -1, -3, -4, -7, -8, -9, -11, -13, -13,
-15, -15, -19, -19, -21, -22, -23, -25, -27, -28, -29, -30, -33, -34, -35, -36,
-38, -39, -41, -42, -43, -45, -46, -46, -47, -46, -46, -46, -46, -46, -46, -45,
-45, -45, -46, -45, -45, -45, -45, -45, -44, -44, -44, -44, -44, -44, -44, -44,
-43, -44, -43, -43, -43, -43, -43, -43, -44, -42, -42, -43, -42, -42, -42, -42,
-41, -41, -42, -42, -41, -41, -42, -41, -41, -42, -41, -41, -41, -40, -41, -39,
-41, -40, -40, -40, -40, -39, -40, -41, -42, -44, -45, -47, -48, -50, -51, -52,
-53, -56, -57, -58, -60, -61, -63, -63, -66, -67, -69, -70, -71, -73, -73, -75,
-77, -77, -80, -81, -85, -81, -99, -119, -114, -116, -115, -116, -115, -115,
-115, -114, -114, -114, -114, -115, -114, -115, -114, -114, -113, -114, -114,
-114, -114, -113, -113, -113, -112, -113, -113, -112, -112, -112, -113, -110,
-108, -107, -105, -103, -101, -101, -98, -97, -95, -93, -92, -91, -88, -87, -85,
-84, -81, -80, -78, -76, -74, -73, -71, -70, -67, -66, -65, -63, -61, -59, -58,
-56, -54, -52, -51, -49, -48, -45, -45, -43, -42, -40, -37, -36, -34, -32, -31,
-29, -28, -26, -25, -22, -21, -19, -17, -15, -14, -12, -10, -8, -7, -5, -4, -3,
-3, -3, -4, -3, -4, -2, -3, -2, -3, -3, -2, -2, -2, -2, -2, -1, -1, -1, -1, -1,
-1, 0, -1, 0, 0, -1, 0, };