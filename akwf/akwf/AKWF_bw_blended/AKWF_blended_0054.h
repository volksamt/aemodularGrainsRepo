#define DATA_LENGTH 512
#define DATA AKWF_blended_0054

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 1, 1, 2, 2, 2, 2, 3, 3, 5, 6, 6,
6, 7, 7, 7, 8, 9, 9, 10, 10, 10, 11, 12, 11, 13, 13, 13, 13, 15, 15, 16, 16, 16,
17, 18, 18, 19, 19, 19, 20, 20, 21, 21, 21, 22, 23, 23, 24, 25, 24, 24, 25, 26,
27, 27, 27, 28, 29, 30, 29, 30, 30, 30, 31, 32, 33, 33, 33, 34, 34, 35, 36, 36,
37, 37, 37, 37, 38, 39, 39, 40, 41, 41, 41, 41, 42, 44, 43, 44, 45, 45, 45, 46,
46, 47, 47, 47, 49, 48, 49, 49, 51, 51, 51, 52, 51, 53, 53, 53, 54, 54, 56, 55,
56, 56, 57, 58, 58, 58, 60, 59, 60, 60, 61, 61, 62, 62, 63, 63, 64, 64, 66, 65,
66, 66, 67, 67, 67, 68, 68, 69, 69, 70, 71, 71, 71, 72, 72, 73, 74, 74, 74, 75,
76, 76, 77, 77, 78, 78, 78, 79, 79, 79, 80, 81, 82, 81, 83, 83, 83, 84, 84, 85,
86, 86, 86, 87, 87, 88, 88, 90, 89, 89, 90, 91, 91, 92, 92, 94, 93, 93, 94, 95,
94, 96, 96, 97, 97, 97, 99, 99, 99, 99, 100, 101, 101, 101, 102, 102, 104, 104,
104, 104, 106, 106, 106, 106, 107, 107, 108, 109, 108, 110, 109, 112, 109, 112,
110, 115, 109, 117, 108, 125, 81, 9, 26, 17, 24, 20, 23, 22, 24, 23, 24, 25, 25,
26, 26, 27, 27, 28, 27, 30, 29, 30, 28, 33, 29, 33, 29, 35, 30, 38, 29, 41, 27,
49, -1, -128, -114, -121, -116, -117, -116, -116, -117, -114, -116, -113, -115,
-112, -113, -110, -113, -110, -112, -110, -110, -109, -110, -108, -107, -107,
-108, -106, -106, -106, -104, -105, -104, -104, -102, -103, -101, -102, -100,
-100, -100, -99, -99, -98, -97, -97, -97, -97, -97, -95, -94, -94, -94, -93,
-93, -93, -92, -92, -91, -90, -90, -89, -88, -89, -88, -88, -87, -87, -87, -86,
-85, -84, -84, -84, -82, -82, -82, -82, -81, -81, -80, -80, -79, -79, -78, -78,
-78, -77, -76, -75, -75, -75, -75, -73, -73, -73, -73, -71, -71, -71, -71, -70,
-69, -69, -69, -67, -68, -67, -67, -65, -66, -65, -65, -64, -64, -63, -62, -61,
-61, -61, -61, -60, -59, -58, -59, -58, -58, -57, -57, -56, -55, -56, -55, -54,
-53, -53, -53, -52, -52, -52, -50, -50, -50, -49, -49, -48, -48, -48, -47, -46,
-45, -46, -45, -44, -44, -43, -43, -43, -41, -42, -41, -41, -39, -39, -39, -39,
-39, -38, -38, -36, -36, -36, -35, -35, -34, -33, -33, -32, -32, -32, -31, -31,
-31, -29, -29, -29, -28, -28, -27, -27, -26, -26, -25, -25, -24, -23, -24, -22,
-23, -22, -21, -21, -21, -20, -19, -18, -19, -18, -18, -17, -17, -17, -15, -15,
-14, -13, -14, -13, -13, -12, -12, -12, -11, -10, -10, -9, -8, -7, -8, -7, -7,
-6, -5, -5, -5, -5, -3, -3, -3, -2, -2, -1, -1, 0, };