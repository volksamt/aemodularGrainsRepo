#define DATA_LENGTH 512
#define DATA AKWF_blended_0068

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 3, 5, 5, 7, 7, 8, 9, 10,
10, 12, 13, 14, 15, 15, 17, 17, 19, 20, 21, 22, 23, 25, 25, 26, 27, 29, 29, 31,
31, 33, 34, 36, 36, 38, 39, 39, 41, 42, 43, 45, 46, 47, 48, 50, 51, 53, 53, 56,
55, 57, 58, 60, 61, 63, 64, 66, 67, 69, 70, 71, 72, 73, 74, 76, 78, 80, 79, 81,
83, 84, 86, 87, 90, 89, 92, 92, 96, 94, 99, 97, 103, 99, 105, 102, 108, 106,
111, 109, 114, 112, 115, 117, 114, 127, -79, -128, -105, -122, -106, -117, -105,
-113, -104, -109, -101, -105, -100, -101, -97, -99, -95, -94, -93, -91, -91,
-88, -88, -85, -85, -83, -82, -80, -80, -77, -77, -74, -74, -72, -71, -69, -69,
-67, -66, -64, -63, -61, -60, -58, -57, -57, -55, -54, -52, -52, -49, -48, -47,
-47, -46, -45, -42, -42, -41, -39, -37, -37, -36, -34, -34, -32, -31, -30, -28,
-27, -26, -26, -24, -23, -22, -21, -20, -19, -18, -16, -16, -16, -14, -13, -12,
-11, -10, -10, -8, -7, -7, -5, -5, -4, -3, -2, -1, -1, 1, 1, 2, 2, 4, 4, 4, 6,
6, 7, 8, 8, 9, 10, 10, 11, 12, 12, 13, 13, 14, 15, 16, 17, 16, 17, 18, 18, 18,
19, 19, 19, 20, 21, 21, 21, 22, 22, 22, 23, 23, 24, 24, 24, 25, 25, 25, 26, 25,
26, 26, 27, 27, 27, 26, 26, 28, 27, 28, 28, 28, 28, 28, 28, 28, 28, 28, 29, 29,
28, 28, 29, 28, 28, 28, 28, 27, 28, 27, 28, 28, 28, 28, 27, 27, 28, 26, 27, 27,
26, 26, 26, 26, 26, 25, 25, 26, 24, 25, 25, 24, 24, 23, 23, 23, 23, 22, 21, 21,
21, 21, 21, 20, 20, 19, 18, 19, 17, 19, 18, 17, 17, 16, 16, 16, 15, 15, 14, 13,
13, 12, 12, 11, 11, 11, 10, 11, 10, 9, 9, 8, 7, 7, 7, 6, 5, 6, 5, 4, 3, 3, 3, 2,
1, 1, 1, 0, 0, -1, -1, -2, -2, -2, -4, -4, -4, -5, -6, -6, -6, -7, -8, -7, -8,
-9, -9, -9, -10, -11, -11, -12, -12, -13, -13, -14, -14, -14, -15, -15, -16,
-17, -17, -17, -17, -17, -18, -18, -18, -20, -19, -20, -20, -21, -21, -21, -22,
-22, -23, -23, -23, -24, -23, -25, -25, -25, -25, -25, -25, -26, -26, -26, -26,
-27, -27, -26, -28, -27, -27, -28, -28, -28, -29, -28, -28, -28, -29, -28, -29,
-30, -29, -29, -29, -30, -29, -29, -29, -29, -30, -30, -30, -28, -28, -30, -29,
-29, -28, -28, -29, -27, -28, -28, -28, -28, -27, -27, -27, -26, -26, -26, -26,
-25, -25, -25, -25, -24, -24, -23, -23, -23, -23, -22, -21, -21, -21, -20, -19,
-19, -19, -19, -18, -17, -17, -16, -16, -15, -15, -14, -13, -13, -12, -11, -11,
-11, -9, -9, -8, -8, -6, -6, -5, -4, -4, -2, -3, -2, -1, };