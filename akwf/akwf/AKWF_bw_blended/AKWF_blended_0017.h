#define DATA_LENGTH 512
#define DATA AKWF_blended_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 17, 19, 21, 22, 24, 27, 28, 31, 32,
35, 36, 38, 39, 42, 43, 45, 48, 49, 51, 53, 54, 57, 60, 61, 62, 64, 67, 69, 70,
72, 74, 75, 74, 73, 72, 71, 70, 69, 68, 66, 65, 64, 64, 63, 61, 60, 60, 59, 57,
57, 56, 55, 53, 53, 51, 50, 49, 48, 47, 46, 46, 44, 43, 42, 41, 40, 39, 38, 37,
36, 34, 34, 32, 31, 31, 29, 28, 27, 26, 25, 24, 23, 21, 21, 19, 18, 17, 17, 15,
14, 13, 12, 11, 10, 9, 9, 10, 12, 14, 15, 17, 19, 21, 23, 25, 27, 29, 29, 32,
33, 35, 37, 38, 40, 42, 43, 45, 47, 49, 51, 53, 54, 57, 58, 60, 62, 63, 65, 66,
69, 70, 72, 73, 75, 77, 78, 80, 83, 83, 85, 88, 89, 91, 92, 94, 96, 97, 99, 101,
103, 105, 106, 108, 110, 111, 112, 115, 116, 119, 119, 118, 116, 115, 114, 113,
112, 110, 109, 109, 107, 105, 104, 104, 102, 101, 100, 98, 97, 96, 94, 93, 92,
91, 90, 88, 87, 85, 84, 83, 82, 80, 79, 78, 77, 75, 74, 73, 72, 71, 70, 68, 66,
66, 64, 62, 62, 61, 59, 57, 57, 56, 54, 53, 51, 51, 49, 48, 46, 45, 44, 43, 42,
40, 39, 41, 43, 45, 46, 48, 50, 51, 52, 54, 56, 57, 59, 60, 64, 62, 67, 65, 70,
69, 73, 72, 77, 75, 80, 77, 85, 79, 88, 83, 92, 80, -75, -91, -83, -87, -81,
-85, -78, -80, -75, -78, -72, -74, -69, -70, -67, -67, -64, -63, -61, -61, -58,
-57, -55, -53, -51, -50, -49, -46, -45, -43, -43, -41, -40, -40, -43, -43, -45,
-46, -47, -48, -50, -51, -53, -54, -55, -57, -58, -59, -60, -61, -63, -64, -65,
-67, -69, -69, -71, -72, -73, -74, -75, -77, -78, -79, -80, -82, -84, -84, -86,
-87, -88, -89, -91, -92, -92, -94, -95, -97, -98, -100, -100, -101, -102, -104,
-105, -106, -108, -109, -110, -111, -113, -113, -116, -116, -117, -118, -119,
-117, -115, -114, -112, -110, -109, -106, -105, -104, -102, -101, -99, -97, -96,
-93, -91, -90, -88, -86, -85, -83, -82, -80, -77, -76, -74, -73, -71, -69, -67,
-66, -65, -62, -61, -59, -57, -55, -54, -52, -50, -49, -46, -45, -43, -42, -40,
-38, -35, -34, -33, -30, -29, -27, -25, -23, -21, -20, -18, -16, -15, -13, -10,
-10, -9, -9, -11, -12, -13, -14, -15, -16, -18, -18, -20, -21, -21, -22, -23,
-25, -26, -27, -28, -29, -30, -31, -32, -33, -34, -36, -36, -38, -38, -40, -41,
-42, -44, -44, -45, -45, -47, -48, -50, -51, -51, -52, -54, -54, -55, -56, -58,
-59, -60, -61, -62, -62, -63, -64, -66, -66, -68, -68, -69, -70, -72, -73, -74,
-75, -75, -73, -71, -69, -68, -65, -64, -61, -60, -58, -56, -54, -52, -50, -48,
-47, -45, -42, -41, -39, -37, -36, -34, -31, -29, -27, -26, -24, -22, -19, -19,
-14, };