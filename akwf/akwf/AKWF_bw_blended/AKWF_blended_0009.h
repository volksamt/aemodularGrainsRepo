#define DATA_LENGTH 512
#define DATA AKWF_blended_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 15, 20, 24, 29, 33, 37, 41,
45, 49, 54, 58, 62, 66, 69, 73, 77, 80, 83, 87, 89, 92, 95, 98, 100, 102, 105,
106, 109, 109, 112, 113, 114, 116, 117, 118, 118, 119, 119, 119, 119, 119, 119,
119, 118, 118, 116, 116, 115, 113, 112, 110, 109, 108, 107, 104, 103, 102, 99,
96, 94, 93, 91, 88, 86, 84, 82, 80, 76, 74, 73, 70, 68, 66, 64, 61, 60, 57, 56,
53, 52, 50, 48, 46, 44, 44, 42, 40, 39, 39, 37, 36, 35, 35, 34, 33, 32, 32, 31,
31, 32, 31, 31, 31, 32, 32, 32, 33, 33, 34, 35, 35, 37, 36, 38, 39, 40, 42, 43,
44, 46, 47, 48, 49, 50, 52, 53, 55, 56, 57, 58, 60, 61, 63, 63, 64, 65, 66, 66,
68, 68, 69, 70, 69, 70, 71, 70, 71, 71, 71, 70, 70, 70, 69, 68, 67, 67, 65, 64,
63, 61, 61, 58, 57, 55, 53, 51, 49, 47, 44, 43, 39, 37, 34, 32, 29, 26, 23, 20,
18, 14, 11, 8, 6, 2, -1, -4, -7, -11, -13, -16, -20, -22, -26, -29, -31, -35,
-37, -40, -42, -45, -46, -50, -52, -54, -56, -57, -59, -62, -63, -64, -65, -67,
-68, -68, -69, -69, -70, -71, -71, -71, -70, -71, -70, -69, -69, -68, -66, -66,
-64, -63, -62, -60, -58, -56, -54, -53, -50, -47, -45, -42, -40, -37, -34, -32,
-28, -25, -22, -19, -16, -13, -9, -6, -3, 1, 5, 8, 11, 14, 17, 21, 23, 26, 29,
32, 35, 38, 41, 43, 45, 48, 50, 53, 55, 57, 59, 61, 62, 64, 65, 66, 68, 67, 69,
70, 70, 70, 71, 71, 70, 70, 69, 70, 68, 69, 67, 66, 65, 63, 62, 60, 59, 57, 54,
52, 50, 49, 47, 44, 41, 38, 35, 32, 30, 27, 24, 21, 18, 14, 12, 9, 5, 2, -1, -4,
-6, -10, -13, -16, -19, -22, -25, -28, -31, -34, -36, -38, -40, -44, -46, -49,
-51, -53, -54, -56, -58, -60, -61, -63, -64, -65, -66, -66, -67, -68, -70, -70,
-71, -71, -71, -71, -71, -71, -70, -70, -70, -70, -68, -69, -68, -66, -66, -64,
-63, -63, -61, -61, -59, -59, -57, -56, -55, -53, -51, -51, -49, -47, -46, -45,
-44, -42, -42, -40, -39, -38, -37, -36, -35, -35, -34, -34, -33, -32, -32, -32,
-31, -32, -32, -32, -31, -32, -32, -32, -33, -34, -34, -35, -36, -38, -39, -40,
-41, -42, -44, -45, -47, -49, -50, -52, -55, -56, -58, -61, -62, -66, -67, -69,
-71, -73, -76, -79, -80, -82, -84, -87, -89, -91, -93, -95, -97, -100, -102,
-103, -105, -106, -109, -109, -111, -113, -114, -114, -115, -117, -116, -118,
-118, -119, -119, -118, -118, -118, -118, -117, -117, -115, -115, -113, -111,
-111, -109, -107, -105, -103, -101, -99, -96, -94, -91, -88, -84, -81, -78, -74,
-71, -66, -64, -60, -56, -51, -48, -44, -39, -35, -30, -26, -21, -17, -12, -7,
-4, };