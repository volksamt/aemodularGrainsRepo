#define DATA_LENGTH 512
#define DATA AKWF_blended_0031

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 2, 3, 2, 3, 4, 4, 5, 5, 5,
6, 6, 6, 7, 7, 7, 8, 10, 10, 9, 10, 9, 11, 11, 12, 12, 12, 13, 13, 13, 14, 14,
15, 15, 16, 16, 17, 17, 17, 19, 19, 18, 20, 20, 20, 20, 21, 21, 21, 21, 22, 23,
23, 24, 24, 25, 25, 25, 25, 28, 15, 3, 6, 5, 6, 6, 7, 7, 8, 7, 8, 8, 10, 9, 10,
10, 11, 11, 12, 12, 13, 13, 12, 13, 14, 15, 16, 15, 16, 17, 17, 18, 18, 18, 19,
19, 19, 19, 20, 21, 21, 22, 21, 22, 22, 23, 23, 24, 24, 25, 25, 25, 26, 27, 26,
28, 27, 28, 29, 28, 31, 28, 33, 25, 66, 94, 85, 91, 88, 92, 89, 91, 91, 92, 91,
93, 93, 94, 94, 94, 94, 94, 96, 95, 96, 96, 97, 98, 98, 98, 98, 100, 100, 100,
100, 101, 102, 102, 102, 102, 104, 103, 103, 104, 105, 105, 106, 107, 107, 107,
108, 108, 108, 109, 108, 109, 110, 110, 110, 111, 111, 112, 112, 113, 112, 114,
112, 117, 102, 91, 95, 93, 95, 94, 96, 94, 96, 96, 96, 96, 97, 98, 98, 99, 98,
99, 99, 100, 100, 101, 101, 102, 101, 102, 103, 103, 103, 105, 105, 105, 105,
106, 106, 107, 107, 107, 109, 108, 110, 108, 111, 109, 111, 110, 112, 110, 114,
110, 115, 111, 117, 112, 118, 113, 118, 113, 118, 115, 119, 117, 117, 125, -90,
-128, -109, -124, -111, -122, -111, -120, -111, -119, -112, -116, -113, -116,
-111, -114, -111, -113, -111, -112, -111, -110, -111, -110, -110, -108, -109,
-107, -108, -106, -108, -105, -106, -105, -105, -104, -105, -103, -104, -102,
-102, -102, -101, -101, -101, -100, -100, -100, -98, -98, -97, -98, -97, -97,
-96, -96, -96, -96, -96, -94, -95, -93, -93, -90, -105, -116, -113, -114, -112,
-114, -112, -112, -111, -111, -110, -110, -109, -110, -109, -108, -109, -107,
-108, -106, -107, -106, -106, -105, -105, -104, -104, -104, -103, -103, -103,
-101, -102, -101, -100, -100, -100, -99, -99, -98, -97, -98, -97, -97, -96, -96,
-96, -95, -96, -94, -95, -94, -93, -92, -93, -91, -92, -90, -90, -91, -89, -90,
-88, -92, -47, -26, -33, -28, -31, -27, -30, -27, -28, -27, -27, -26, -26, -26,
-25, -25, -24, -24, -23, -23, -23, -22, -22, -22, -20, -20, -20, -19, -19, -19,
-19, -17, -18, -17, -17, -17, -16, -16, -15, -15, -15, -14, -13, -13, -13, -12,
-12, -11, -11, -11, -10, -10, -9, -9, -8, -8, -8, -7, -6, -7, -6, -5, -7, -3,
-19, -28, -25, -26, -24, -26, -24, -25, -23, -23, -23, -22, -23, -21, -21, -21,
-21, -19, -19, -19, -19, -17, -18, -17, -17, -17, -16, -15, -14, -14, -14, -14,
-13, -13, -12, -12, -12, -12, -11, -11, -11, -9, -9, -9, -8, -8, -8, -7, -7, -6,
-6, -6, -4, -4, -5, -3, -3, -3, -3, -2, -2, -1, -1, -1, 0, };