#define DATA_LENGTH 512
#define DATA AKWF_blended_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {64, 117, 102, 110, 104, 108, 105, 107,
104, 105, 104, 104, 105, 104, 103, 104, 104, 102, 103, 102, 103, 101, 102, 101,
101, 100, 101, 100, 100, 99, 100, 99, 99, 99, 98, 98, 98, 98, 97, 98, 96, 97,
96, 96, 96, 96, 96, 95, 95, 94, 95, 94, 94, 94, 93, 93, 93, 93, 92, 93, 91, 92,
89, 94, 73, 58, 63, 59, 62, 59, 60, 60, 60, 59, 60, 59, 58, 59, 58, 58, 57, 57,
57, 57, 56, 56, 55, 56, 55, 56, 54, 55, 54, 54, 53, 54, 54, 53, 52, 52, 52, 52,
52, 52, 51, 51, 50, 50, 51, 49, 50, 49, 49, 47, 50, 48, 49, 47, 49, 46, 48, 46,
48, 45, 48, 44, 47, 43, -41, -49, -44, -49, -44, -49, -45, -48, -47, -49, -47,
-50, -48, -50, -50, -50, -49, -51, -50, -50, -51, -52, -52, -51, -52, -52, -53,
-53, -53, -53, -54, -53, -55, -54, -54, -55, -55, -55, -55, -56, -57, -56, -57,
-57, -57, -57, -57, -57, -59, -58, -59, -60, -59, -60, -59, -60, -60, -60, -62,
-61, -62, -62, -63, -60, -82, -94, -90, -93, -92, -93, -92, -93, -94, -93, -94,
-94, -95, -95, -94, -96, -95, -96, -95, -95, -97, -97, -97, -98, -97, -97, -98,
-98, -99, -98, -99, -99, -99, -100, -100, -101, -100, -101, -101, -101, -102,
-102, -103, -102, -103, -101, -105, -102, -105, -103, -105, -103, -106, -104,
-106, -104, -107, -105, -107, -106, -107, -107, -105, -111, 28, 73, 55, 66, 57,
64, 57, 62, 57, 61, 58, 61, 57, 59, 58, 58, 57, 57, 57, 57, 57, 56, 56, 56, 56,
56, 55, 54, 55, 54, 54, 53, 53, 53, 53, 53, 53, 52, 51, 51, 52, 51, 51, 50, 50,
49, 50, 50, 50, 50, 49, 48, 48, 48, 48, 48, 47, 47, 47, 46, 46, 47, 45, 47, 23,
14, 17, 15, 15, 14, 15, 14, 15, 14, 13, 14, 14, 12, 12, 13, 12, 12, 11, 12, 11,
11, 11, 10, 10, 9, 10, 9, 9, 9, 8, 9, 7, 8, 7, 7, 7, 7, 6, 7, 5, 6, 5, 4, 5, 5,
5, 4, 3, 3, 3, 3, 3, 3, 2, 3, 2, 1, 1, 0, 1, 0, 0, 0, 0, 0, -1, -1, -2, -2, -1,
-2, -3, -3, -4, -3, -4, -4, -3, -4, -4, -5, -5, -6, -6, -6, -6, -5, -7, -7, -7,
-8, -7, -8, -8, -8, -8, -9, -9, -9, -10, -10, -10, -10, -11, -10, -11, -11, -11,
-12, -12, -13, -12, -13, -13, -13, -13, -14, -14, -15, -14, -16, -15, -15, -17,
-15, -17, -15, -40, -48, -45, -48, -46, -47, -46, -48, -47, -48, -49, -49, -49,
-49, -49, -50, -50, -49, -50, -51, -50, -51, -52, -51, -52, -52, -52, -52, -53,
-53, -53, -54, -54, -54, -54, -55, -55, -56, -55, -57, -56, -56, -57, -57, -57,
-57, -57, -58, -59, -58, -59, -58, -61, -58, -62, -59, -62, -59, -62, -59, -63,
-59, -64, -61, };