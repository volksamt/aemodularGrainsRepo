#define DATA_LENGTH 512
#define DATA AKWF_blended_0070

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 5, 6, 8, 9, 10, 11, 13, 14,
16, 17, 18, 19, 20, 22, 24, 24, 26, 28, 28, 30, 31, 33, 34, 36, 37, 39, 39, 41,
42, 44, 44, 46, 47, 49, 51, 52, 52, 54, 56, 57, 58, 59, 60, 62, 63, 64, 65, 68,
69, 70, 71, 73, 74, 75, 76, 78, 79, 81, 82, 84, 83, 86, 87, 89, 90, 91, 92, 93,
95, 97, 98, 99, 101, 101, 104, 103, 107, 105, 111, 107, 114, 108, 119, 109, 127,
89, -26, -11, -16, -12, -11, -10, -8, -8, -4, -6, -2, -4, 0, -2, 4, 1, 6, 4, 9,
6, 12, 10, 14, 12, 16, 15, 19, 19, 20, 23, 20, 34, -84, -120, -100, -111, -100,
-106, -99, -103, -97, -100, -95, -96, -93, -93, -91, -90, -89, -87, -87, -85,
-84, -82, -82, -79, -79, -76, -75, -74, -74, -71, -70, -69, -68, -66, -65, -64,
-62, -61, -60, -58, -57, -56, -54, -53, -52, -50, -49, -48, -46, -45, -44, -42,
-41, -40, -38, -37, -36, -35, -34, -31, -31, -30, -29, -26, -26, -23, -23, -21,
-20, -18, -17, -16, -15, -13, -12, -11, -9, -8, -7, -5, -4, -3, -1, -1, 2, 2, 5,
3, 9, 5, 13, 6, 17, 6, 27, -21, -127, -112, -119, -113, -114, -112, -110, -109,
-107, -107, -104, -105, -102, -102, -99, -99, -97, -97, -94, -94, -92, -91, -89,
-89, -86, -86, -84, -84, -82, -80, -78, -77, -76, -75, -73, -71, -71, -70, -69,
-66, -66, -65, -63, -62, -60, -59, -57, -56, -54, -54, -52, -51, -49, -49, -47,
-45, -45, -43, -42, -40, -39, -37, -36, -35, -34, -33, -31, -30, -28, -28, -26,
-24, -22, -22, -20, -19, -17, -16, -16, -14, -13, -11, -10, -9, -7, -5, -4, -3,
-2, 0, 1, 2, 3, 4, 6, 7, 9, 10, 11, 12, 14, 15, 17, 18, 20, 21, 22, 24, 25, 26,
27, 29, 30, 32, 32, 35, 36, 37, 38, 40, 40, 43, 43, 45, 45, 47, 49, 50, 51, 52,
54, 56, 56, 57, 59, 60, 62, 63, 65, 65, 68, 68, 70, 70, 74, 73, 77, 74, 79, 77,
83, 81, 85, 84, 87, 85, 90, 89, 91, 95, -29, -48, -36, -41, -34, -38, -31, -35,
-30, -32, -28, -28, -25, -26, -23, -23, -21, -20, -18, -17, -15, -14, -13, -11,
-10, -9, -7, -6, -5, -3, -2, -1, 0, 2, 3, 5, 6, 7, 8, 10, 11, 12, 14, 14, 17,
18, 19, 20, 21, 23, 24, 25, 26, 27, 29, 30, 32, 34, 35, 36, 38, 39, 40, 42, 43,
44, 45, 47, 48, 50, 50, 53, 53, 56, 56, 59, 57, 60, 61, 63, 64, 65, 68, 67, 70,
70, 73, 72, 76, 73, 80, 74, 86, 73, 97, 33, -67, -41, -52, -43, -48, -43, -44,
-40, -40, -39, -37, -36, -34, -34, -31, -32, -28, -30, -26, -26, -23, -23, -20,
-21, -19, -17, -16, -15, -13, -12, -10, -9, -8, -7, -6, -4, -3, -1, -1, };