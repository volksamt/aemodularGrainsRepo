#define DATA_LENGTH 512
#define DATA AKWF_blended_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {53, 66, 61, 66, 65, 69, 69, 72, 71,
75, 74, 77, 77, 81, 80, 82, 83, 85, 86, 88, 89, 91, 91, 92, 94, 95, 96, 97, 99,
100, 101, 101, 103, 103, 105, 106, 106, 107, 108, 110, 110, 111, 112, 113, 112,
113, 114, 115, 115, 116, 116, 116, 117, 117, 117, 118, 118, 119, 118, 119, 119,
119, 119, 119, 119, 118, 119, 119, 118, 118, 118, 117, 117, 117, 117, 116, 116,
115, 116, 114, 114, 114, 113, 113, 112, 111, 110, 109, 108, 108, 107, 106, 104,
104, 102, 102, 101, 99, 99, 98, 96, 95, 94, 93, 92, 89, 90, 88, 87, 85, 84, 82,
81, 80, 78, 77, 75, 74, 74, 71, 70, 68, 67, 65, 64, 63, 62, 60, 58, 56, 55, 53,
52, 51, 49, 48, 46, 46, 43, 43, 41, 40, 38, 37, 35, 34, 32, 32, 31, 29, 27, 27,
25, 24, 23, 22, 21, 19, 18, 17, 16, 15, 14, 14, 12, 12, 11, 10, 9, 8, 8, 7, 6,
6, 4, 4, 3, 4, 4, 2, 2, 2, 2, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1,
1, 2, 3, 3, 3, 4, 4, 5, 5, 5, 6, 7, 8, 8, 9, 10, 11, 12, 12, 13, 14, 15, 16, 17,
18, 20, 21, 22, 23, 24, 26, 27, 27, 29, 30, 31, 32, 34, 36, 37, 38, 39, 40, 42,
43, 44, 47, 47, 50, 49, 53, 53, 56, 55, 61, 3, -60, -56, -55, -54, -53, -51,
-50, -49, -46, -45, -44, -43, -41, -40, -38, -38, -35, -34, -33, -31, -30, -29,
-27, -27, -25, -24, -23, -22, -21, -19, -19, -18, -17, -16, -15, -13, -13, -12,
-11, -10, -9, -8, -8, -7, -7, -5, -5, -5, -4, -3, -3, -2, -2, -2, -1, -1, -1,
-1, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, -1, -1, -1, -1, -2, -2, -2, -3, -3, -4, -4,
-5, -5, -5, -7, -7, -9, -9, -10, -10, -10, -12, -13, -14, -14, -15, -17, -18,
-19, -19, -21, -22, -22, -24, -25, -26, -28, -29, -30, -32, -33, -34, -35, -37,
-38, -40, -41, -42, -44, -45, -46, -48, -49, -51, -52, -53, -56, -57, -58, -60,
-61, -62, -63, -65, -66, -68, -70, -72, -73, -74, -76, -76, -78, -80, -81, -83,
-83, -85, -87, -88, -89, -90, -92, -93, -93, -96, -96, -97, -98, -100, -100,
-102, -103, -103, -104, -106, -107, -107, -108, -109, -110, -111, -111, -112,
-112, -114, -114, -114, -115, -115, -116, -117, -117, -118, -118, -118, -118,
-118, -118, -118, -119, -119, -119, -119, -119, -119, -120, -119, -118, -118,
-118, -118, -117, -117, -117, -117, -116, -116, -114, -114, -113, -113, -113,
-111, -111, -110, -110, -108, -109, -107, -107, -105, -104, -103, -103, -101,
-101, -99, -99, -97, -97, -95, -94, -92, -92, -90, -89, -88, -86, -85, -83, -83,
-81, -79, -77, -78, -75, -76, -72, -72, -69, -69, -65, -67, -62, -64, -58, -3,
};