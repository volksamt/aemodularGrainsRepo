#define DATA_LENGTH 512
#define DATA AKWF_blended_0033

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 5, 7, 9, 11, 12, 14, 15, 16,
18, 20, 22, 23, 24, 26, 28, 29, 30, 32, 34, 35, 37, 38, 39, 41, 42, 44, 44, 46,
48, 50, 51, 53, 54, 55, 57, 58, 59, 61, 62, 64, 66, 67, 68, 69, 71, 72, 73, 75,
75, 77, 78, 81, 81, 83, 83, 86, 84, 90, 86, 96, 57, 17, 28, 25, 29, 28, 30, 30,
33, 33, 34, 35, 35, 37, 38, 40, 40, 42, 42, 44, 44, 46, 47, 48, 48, 50, 49, 51,
52, 53, 53, 54, 56, 57, 56, 57, 58, 59, 60, 60, 62, 63, 62, 63, 65, 65, 66, 67,
67, 68, 68, 68, 68, 70, 71, 71, 71, 71, 73, 72, 74, 74, 76, 72, 99, 118, 112,
116, 114, 117, 115, 116, 116, 116, 116, 118, 117, 117, 117, 118, 118, 117, 118,
118, 119, 118, 119, 119, 119, 118, 119, 118, 119, 119, 119, 118, 119, 118, 118,
118, 118, 118, 118, 118, 118, 118, 117, 118, 118, 117, 117, 116, 116, 116, 116,
115, 115, 115, 113, 115, 114, 114, 113, 114, 111, 114, 107, 117, 74, 35, 45, 39,
42, 39, 41, 38, 38, 37, 37, 38, 36, 36, 35, 34, 34, 33, 33, 32, 32, 32, 30, 30,
29, 29, 28, 27, 27, 26, 25, 25, 23, 23, 22, 22, 21, 20, 20, 19, 19, 18, 16, 17,
16, 15, 14, 13, 12, 12, 11, 10, 9, 9, 8, 7, 6, 6, 5, 4, 3, 2, 1, 1, 0, -1, -2,
-3, -3, -4, -5, -6, -6, -8, -8, -9, -9, -11, -11, -12, -12, -13, -14, -14, -15,
-15, -17, -17, -18, -19, -19, -20, -22, -21, -23, -24, -24, -25, -26, -26, -26,
-28, -27, -28, -29, -30, -31, -31, -32, -32, -33, -34, -34, -35, -35, -36, -36,
-38, -38, -38, -39, -39, -40, -39, -42, -40, -44, -37, -83, -116, -107, -114,
-110, -114, -112, -114, -113, -115, -114, -115, -114, -115, -116, -116, -116,
-116, -117, -118, -118, -117, -118, -119, -119, -117, -118, -119, -119, -118,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -118, -120, -119, -119,
-119, -119, -119, -118, -118, -119, -118, -118, -118, -118, -117, -118, -117,
-117, -116, -116, -115, -115, -116, -114, -116, -86, -72, -76, -72, -74, -72,
-73, -71, -72, -70, -71, -69, -70, -69, -68, -68, -67, -67, -66, -64, -64, -64,
-63, -63, -62, -62, -60, -60, -58, -58, -57, -56, -55, -55, -53, -52, -52, -51,
-51, -50, -49, -48, -46, -46, -44, -44, -42, -42, -40, -40, -38, -37, -36, -36,
-34, -34, -33, -31, -31, -28, -29, -26, -28, -19, -67, -96, -86, -90, -85, -86,
-83, -83, -81, -80, -78, -78, -76, -74, -74, -72, -71, -69, -68, -66, -65, -64,
-63, -61, -60, -58, -57, -56, -54, -53, -52, -50, -49, -47, -46, -43, -43, -40,
-39, -37, -36, -35, -34, -32, -31, -30, -28, -26, -24, -23, -22, -19, -18, -17,
-15, -13, -12, -11, -9, -8, -6, -5, -4, -1, 0, };