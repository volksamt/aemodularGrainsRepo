#define DATA_LENGTH 512
#define DATA AKWF_blended_0063

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 48, 49, 48, 50, 50, 52, 51, 53, 54,
55, 54, 56, 56, 58, 58, 59, 60, 60, 61, 62, 62, 63, 64, 64, 66, 66, 66, 67, 68,
69, 70, 70, 72, 72, 72, 73, 75, 74, 75, 77, 77, 77, 78, 78, 80, 80, 81, 81, 82,
82, 84, 84, 85, 86, 86, 86, 87, 88, 89, 89, 90, 90, 91, 92, 92, 93, 92, 94, 94,
94, 95, 97, 97, 97, 98, 98, 99, 100, 99, 100, 101, 101, 101, 102, 102, 103, 104,
104, 104, 104, 105, 107, 107, 107, 108, 107, 108, 108, 108, 109, 109, 110, 110,
110, 111, 112, 112, 112, 112, 112, 112, 113, 113, 113, 114, 114, 115, 115, 115,
115, 115, 115, 116, 116, 116, 116, 117, 117, 117, 117, 117, 117, 117, 118, 118,
119, 118, 118, 118, 118, 118, 119, 119, 118, 119, 118, 119, 119, 118, 119, 119,
119, 118, 119, 119, 120, 119, 119, 119, 120, 119, 119, 119, 118, 119, 119, 119,
119, 118, 117, 117, 119, 118, 118, 117, 117, 118, 117, 117, 117, 117, 118, 117,
116, 116, 116, 116, 116, 115, 115, 115, 115, 114, 114, 114, 114, 114, 113, 113,
113, 112, 112, 112, 112, 112, 111, 111, 110, 110, 110, 109, 109, 109, 109, 108,
108, 108, 107, 107, 107, 107, 105, 106, 105, 106, 105, 105, 104, 104, 103, 103,
102, 103, 102, 101, 101, 100, 100, 99, 100, 98, 100, 97, 100, 96, 99, 96, 97,
95, 97, 93, 97, 93, 96, 89, -53, -99, -90, -98, -93, -98, -93, -98, -95, -98,
-97, -99, -97, -99, -98, -100, -98, -101, -99, -101, -101, -102, -102, -102,
-103, -103, -103, -103, -104, -104, -105, -105, -106, -105, -107, -107, -107,
-108, -108, -108, -108, -108, -109, -110, -109, -110, -110, -110, -111, -110,
-112, -111, -112, -112, -113, -112, -113, -113, -113, -113, -114, -114, -114,
-114, -114, -115, -115, -115, -116, -116, -115, -116, -116, -117, -116, -117,
-117, -117, -117, -118, -118, -118, -118, -118, -118, -118, -118, -118, -119,
-118, -119, -119, -118, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -118, -119, -118, -119, -120, -119, -119, -119,
-119, -118, -118, -119, -118, -117, -117, -117, -117, -118, -117, -118, -117,
-117, -116, -116, -116, -116, -116, -115, -116, -115, -115, -114, -114, -114,
-114, -113, -113, -113, -112, -112, -112, -111, -110, -110, -111, -110, -110,
-110, -110, -109, -109, -108, -108, -107, -107, -106, -107, -105, -105, -104,
-104, -104, -103, -103, -103, -102, -102, -101, -101, -100, -99, -98, -98, -98,
-97, -97, -97, -95, -96, -95, -94, -94, -94, -93, -91, -92, -91, -90, -90, -89,
-88, -88, -87, -87, -85, -85, -84, -83, -83, -83, -82, -81, -80, -79, -80, -78,
-78, -78, -77, -75, -76, -74, -74, -73, -72, -71, -72, -70, -69, -69, -68, -67,
-66, -66, -65, -65, -64, -64, -62, -61, -61, -60, -60, -59, -57, -57, -56, -56,
-54, -55, -52, -54, -50, -52, -50, -51, -46, -51, -40, };