#define DATA_LENGTH 512
#define DATA AKWF_blended_0029

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 2, 4, 4, 4, 5, 7, 7, 7, 9, 9,
10, 10, 11, 11, 12, 13, 14, 14, 16, 15, 17, 16, 19, 18, 20, 18, 23, 18, 30, 70,
70, 71, 71, 73, 73, 73, 75, 74, 76, 76, 78, 77, 79, 79, 80, 80, 82, 81, 83, 83,
85, 85, 86, 87, 88, 87, 89, 90, 90, 90, 91, 92, 92, 94, 94, 95, 96, 96, 97, 97,
98, 99, 100, 100, 101, 101, 102, 103, 103, 105, 104, 106, 106, 108, 107, 110,
108, 110, 109, 113, 110, 116, 105, 49, 46, 49, 48, 51, 50, 52, 51, 54, 53, 56,
54, 56, 56, 58, 57, 59, 59, 60, 60, 61, 62, 62, 62, 64, 64, 66, 66, 66, 68, 68,
69, 69, 70, 71, 72, 72, 73, 73, 76, 75, 77, 75, 78, 77, 79, 79, 81, 81, 81, 82,
83, 84, 83, 86, 84, 88, 83, 92, 83, 97, 79, 112, 15, -113, -80, -97, -85, -93,
-86, -89, -86, -86, -85, -84, -84, -83, -84, -81, -82, -78, -81, -78, -79, -77,
-78, -75, -76, -74, -75, -73, -73, -72, -71, -70, -70, -69, -68, -68, -67, -67,
-65, -65, -64, -63, -63, -62, -62, -60, -59, -59, -58, -57, -58, -56, -56, -54,
-55, -54, -54, -52, -53, -50, -52, -48, -51, -45, -59, -114, -113, -112, -112,
-110, -111, -109, -109, -107, -109, -107, -107, -104, -105, -104, -103, -102,
-102, -101, -100, -99, -99, -98, -97, -97, -97, -96, -94, -94, -93, -93, -93,
-92, -90, -89, -89, -88, -88, -87, -86, -86, -85, -85, -84, -83, -82, -81, -81,
-80, -79, -79, -77, -78, -76, -77, -75, -76, -73, -75, -71, -73, -68, -75, -57,
-20, -22, -20, -20, -19, -19, -18, -18, -17, -15, -16, -15, -14, -13, -13, -12,
-12, -10, -10, -9, -8, -7, -8, -6, -6, -4, -4, -3, -4, -2, -1, 0, 0, 1, 2, 2, 2,
4, 4, 5, 5, 6, 8, 8, 8, 9, 10, 11, 11, 12, 13, 13, 15, 14, 17, 15, 18, 16, 20,
18, 22, 18, 25, 8, -46, -44, -43, -42, -42, -42, -39, -40, -38, -39, -37, -37,
-36, -36, -34, -35, -33, -33, -32, -31, -30, -30, -29, -29, -28, -27, -27, -25,
-25, -23, -23, -22, -23, -21, -20, -21, -20, -18, -17, -18, -17, -16, -16, -14,
-14, -12, -12, -11, -10, -10, -10, -8, -8, -8, -8, -5, -5, -5, -3, -3, -2, -2,
-1, 0, 0, 1, 1, 2, 3, 4, 4, 6, 6, 6, 7, 7, 9, 9, 10, 11, 12, 12, 13, 13, 14, 15,
15, 16, 17, 18, 19, 19, 20, 21, 21, 23, 23, 24, 24, 25, 26, 26, 26, 27, 29, 29,
30, 31, 30, 32, 33, 34, 34, 34, 35, 35, 37, 37, 38, 38, 40, 39, 42, 40, 45, 40,
49, 28, -24, -20, -21, -19, -19, -18, -17, -18, -16, -15, -14, -14, -12, -13,
-11, -12, -10, -10, -9, -9, -7, -7, -6, -6, -5, -5, -3, -3, -2, -1, -1, -1, };