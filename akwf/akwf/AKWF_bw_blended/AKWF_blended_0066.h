#define DATA_LENGTH 512
#define DATA AKWF_blended_0066

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 10, 13, 16, 19, 21, 24, 26, 27,
29, 32, 33, 35, 36, 38, 39, 42, 42, 43, 45, 47, 48, 48, 50, 51, 53, 54, 55, 56,
57, 59, 60, 62, 62, 64, 65, 66, 67, 69, 70, 71, 72, 74, 74, 76, 78, 79, 79, 81,
82, 83, 84, 85, 88, 88, 90, 91, 91, 93, 94, 95, 97, 98, 99, 100, 101, 102, 104,
105, 106, 106, 108, 109, 109, 110, 111, 111, 113, 114, 114, 115, 116, 116, 116,
117, 117, 116, 117, 116, 117, 118, 117, 116, 117, 117, 117, 117, 118, 118, 118,
118, 117, 118, 119, 119, 118, 118, 119, 118, 119, 118, 119, 119, 118, 118, 119,
119, 119, 120, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 118, 119,
119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 118, 118, 118, 118, 118, 119,
119, 118, 118, 119, 118, 117, 118, 118, 117, 118, 118, 118, 117, 118, 117, 117,
117, 116, 117, 117, 115, 115, 116, 116, 115, 114, 113, 113, 112, 113, 111, 110,
109, 109, 108, 107, 106, 104, 103, 102, 101, 101, 98, 98, 96, 95, 94, 93, 92,
91, 89, 88, 88, 86, 84, 84, 82, 81, 79, 78, 77, 77, 75, 73, 72, 71, 70, 68, 68,
66, 65, 64, 63, 61, 60, 59, 58, 57, 55, 54, 53, 52, 50, 49, 48, 46, 46, 45, 44,
42, 41, 39, 39, 37, 36, 35, 34, 33, 32, 31, 30, 28, 23, 17, 11, 5, 1, -4, -7,
-10, -14, -17, -19, -22, -24, -26, -28, -30, -32, -34, -35, -37, -38, -40, -40,
-43, -43, -45, -47, -47, -49, -50, -51, -53, -53, -55, -56, -58, -59, -60, -62,
-63, -64, -66, -66, -67, -68, -70, -71, -72, -74, -75, -76, -77, -79, -80, -81,
-82, -83, -84, -87, -87, -88, -90, -91, -91, -93, -94, -96, -96, -98, -99, -100,
-102, -103, -104, -105, -106, -106, -108, -108, -110, -110, -112, -112, -113,
-114, -114, -115, -115, -116, -115, -116, -116, -116, -116, -117, -117, -117,
-117, -117, -117, -117, -117, -117, -118, -117, -117, -118, -117, -118, -118,
-118, -118, -119, -118, -118, -118, -118, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -118, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -118, -118, -119, -118, -119, -118, -118, -119, -117, -118, -118, -118,
-118, -118, -118, -118, -117, -117, -116, -117, -117, -116, -116, -117, -116,
-116, -116, -116, -116, -115, -114, -113, -112, -112, -112, -111, -110, -108,
-108, -107, -105, -104, -104, -103, -101, -100, -99, -98, -96, -95, -94, -92,
-91, -91, -90, -88, -87, -86, -84, -83, -82, -80, -79, -78, -77, -77, -75, -73,
-73, -71, -70, -68, -67, -66, -64, -64, -63, -62, -60, -60, -58, -56, -56, -54,
-53, -52, -51, -50, -49, -46, -46, -44, -43, -42, -41, -40, -40, -38, -36, -36,
-35, -33, -32, -30, -29, -28, -22, -15, -10, -5, 0, };