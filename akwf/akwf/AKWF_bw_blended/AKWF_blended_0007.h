#define DATA_LENGTH 512
#define DATA AKWF_blended_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 37, 46, 54, 63, 70, 77, 80, 83, 84,
87, 87, 89, 90, 92, 94, 94, 97, 97, 99, 98, 99, 101, 102, 102, 103, 105, 105,
106, 106, 107, 108, 108, 109, 110, 109, 111, 111, 112, 113, 113, 113, 114, 114,
114, 116, 116, 116, 117, 117, 117, 118, 118, 118, 118, 119, 119, 120, 119, 118,
119, 119, 119, 118, 117, 117, 117, 115, 114, 114, 112, 111, 110, 109, 107, 106,
105, 104, 103, 102, 100, 99, 99, 97, 96, 94, 93, 91, 91, 90, 88, 87, 86, 85, 84,
82, 81, 80, 77, 77, 75, 74, 73, 72, 70, 69, 67, 66, 65, 64, 62, 62, 59, 59, 57,
56, 54, 54, 51, 50, 49, 47, 46, 44, 44, 42, 43, 44, 75, 97, 95, 96, 94, 93, 90,
91, 89, 87, 86, 84, 82, 81, 80, 78, 78, 76, 74, 73, 72, 70, 69, 67, 66, 64, 63,
62, 59, 58, 57, 55, 54, 53, 50, 49, 48, 47, 46, 43, 42, 40, 39, 38, 36, 35, 33,
32, 29, 28, 27, 25, 24, 23, 21, 18, 19, 17, 15, 14, 12, 10, 8, 7, 5, 4, 2, 1,
-1, -2, -3, -5, -6, -8, -10, -11, -12, -15, -17, -17, -19, -21, -23, -24, -25,
-27, -28, -30, -31, -33, -34, -35, -38, -39, -40, -42, -42, -45, -45, -47, -48,
-50, -51, -52, -54, -55, -56, -57, -59, -59, -60, -61, -63, -63, -64, -64, -65,
-65, -65, -65, -66, -66, -61, -56, -51, -45, -39, -28, 10, 36, 41, 50, 55, 60,
65, 66, 65, 66, 65, 65, 64, 64, 63, 62, 62, 61, 60, 59, 57, 57, 55, 54, 52, 52,
51, 49, 47, 45, 44, 43, 42, 41, 38, 38, 37, 34, 33, 31, 30, 28, 26, 26, 24, 22,
21, 19, 17, 16, 14, 13, 12, 10, 9, 8, 5, 4, 3, 1, -1, -2, -3, -6, -7, -8, -9,
-11, -12, -14, -16, -18, -18, -21, -22, -23, -26, -27, -28, -30, -31, -32, -34,
-35, -37, -39, -40, -41, -42, -45, -46, -48, -49, -50, -52, -54, -56, -57, -58,
-59, -60, -61, -63, -65, -67, -68, -70, -70, -73, -74, -75, -76, -78, -79, -81,
-82, -84, -85, -88, -87, -90, -90, -92, -95, -95, -96, -97, -92, -60, -42, -44,
-43, -45, -45, -47, -49, -50, -51, -52, -54, -56, -56, -59, -59, -60, -63, -63,
-65, -66, -68, -69, -70, -71, -73, -74, -76, -77, -78, -79, -81, -82, -83, -84,
-85, -86, -88, -88, -90, -91, -93, -94, -96, -96, -98, -98, -100, -100, -103,
-104, -105, -105, -107, -109, -109, -111, -111, -113, -114, -115, -116, -117,
-117, -118, -118, -119, -119, -118, -118, -119, -119, -118, -118, -117, -117,
-118, -117, -116, -117, -115, -116, -114, -114, -113, -113, -113, -112, -111,
-111, -111, -111, -109, -108, -109, -108, -106, -106, -105, -105, -104, -103,
-102, -102, -100, -100, -100, -98, -97, -97, -95, -94, -93, -92, -90, -89, -89,
-86, -84, -82, -81, -77, -73, -64, -58, -48, -42, -25, };