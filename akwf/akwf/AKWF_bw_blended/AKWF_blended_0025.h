#define DATA_LENGTH 512
#define DATA AKWF_blended_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {36, 44, 41, 44, 42, 44, 42, 45, 43,
45, 44, 45, 45, 47, 45, 46, 46, 46, 47, 48, 47, 48, 49, 49, 49, 49, 49, 49, 50,
51, 51, 51, 52, 51, 53, 52, 53, 52, 53, 53, 54, 55, 54, 55, 54, 55, 55, 56, 57,
57, 57, 56, 57, 58, 58, 59, 59, 59, 59, 60, 60, 60, 60, 60, 61, 62, 62, 61, 62,
62, 62, 63, 63, 64, 64, 64, 64, 65, 65, 66, 66, 66, 66, 67, 67, 67, 68, 69, 69,
69, 69, 70, 70, 69, 69, 71, 70, 71, 71, 71, 72, 72, 73, 73, 73, 73, 74, 74, 74,
75, 76, 75, 76, 75, 77, 77, 77, 77, 77, 79, 79, 79, 78, 78, 79, 79, 80, 80, 81,
80, 81, 82, 82, 83, 83, 83, 83, 83, 84, 84, 84, 85, 85, 85, 86, 86, 86, 86, 87,
86, 87, 88, 88, 89, 88, 88, 89, 90, 89, 90, 91, 90, 90, 91, 92, 91, 92, 93, 93,
93, 94, 93, 94, 95, 95, 95, 95, 96, 96, 96, 96, 97, 97, 98, 97, 98, 98, 98, 99,
99, 100, 100, 101, 100, 101, 101, 102, 102, 101, 102, 102, 104, 104, 104, 103,
104, 104, 104, 105, 106, 106, 106, 107, 107, 107, 107, 107, 107, 109, 107, 109,
109, 110, 109, 110, 110, 111, 111, 111, 111, 112, 113, 112, 113, 113, 114, 112,
115, 113, 116, 113, 117, 114, 117, 114, 118, 115, 119, 116, 119, 117, 119, 118,
116, 126, -57, -128, -112, -124, -114, -122, -114, -119, -114, -119, -115, -119,
-115, -116, -114, -115, -114, -114, -114, -114, -113, -113, -114, -112, -113,
-111, -112, -110, -111, -110, -111, -110, -111, -108, -109, -109, -108, -107,
-108, -107, -107, -107, -106, -107, -106, -105, -105, -105, -105, -104, -105,
-104, -103, -103, -102, -103, -102, -102, -101, -101, -100, -101, -100, -100,
-99, -100, -99, -99, -99, -99, -98, -98, -98, -96, -97, -97, -96, -96, -95, -95,
-95, -94, -95, -94, -94, -93, -94, -93, -93, -92, -92, -91, -91, -91, -90, -90,
-91, -90, -90, -89, -89, -88, -88, -88, -88, -87, -87, -87, -87, -86, -87, -86,
-86, -84, -84, -85, -84, -84, -84, -83, -83, -82, -81, -82, -82, -81, -82, -81,
-80, -80, -80, -80, -79, -79, -79, -78, -78, -78, -78, -78, -76, -77, -76, -76,
-75, -75, -75, -74, -74, -74, -73, -73, -73, -73, -73, -72, -72, -71, -71, -71,
-70, -70, -70, -70, -69, -69, -69, -68, -68, -69, -68, -67, -67, -66, -67, -66,
-65, -66, -65, -65, -64, -64, -64, -64, -64, -63, -63, -63, -62, -61, -61, -61,
-60, -60, -60, -59, -60, -59, -60, -58, -59, -58, -57, -57, -57, -57, -56, -56,
-55, -56, -56, -55, -55, -54, -54, -53, -53, -53, -53, -54, -52, -51, -51, -51,
-51, -51, -51, -50, -50, -49, -50, -49, -49, -49, -48, -48, -48, -47, -47, -46,
-46, -46, -46, -45, -45, -43, -45, -43, -44, -43, -43, -42, -44, -41, -42, -40,
-2, };