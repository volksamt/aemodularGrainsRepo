#define DATA_LENGTH 512
#define DATA AKWF_blended_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 3, 5, 5, 6, 7, 8, 9, 9, 11,
11, 13, 14, 14, 16, 16, 17, 17, 19, 19, 21, 22, 22, 23, 25, 25, 26, 27, 28, 29,
30, 31, 32, 33, 34, 35, 36, 36, 38, 39, 40, 40, 42, 42, 43, 44, 45, 46, 46, 48,
49, 50, 51, 51, 52, 53, 54, 56, 56, 56, 57, 59, 60, 61, 61, 62, 63, 64, 65, 67,
67, 68, 69, 70, 71, 72, 74, 74, 74, 76, 77, 78, 78, 79, 80, 81, 82, 83, 84, 85,
86, 87, 88, 89, 89, 90, 92, 92, 93, 94, 95, 97, 97, 98, 98, 99, 101, 101, 102,
104, 104, 106, 106, 107, 108, 109, 110, 111, 111, 112, 113, 114, 116, 116, 117,
119, 119, 119, 119, 118, 118, 118, 117, 117, 118, 119, 118, 117, 118, 118, 118,
118, 118, 118, 117, 118, 118, 118, 117, 118, 117, 117, 118, 118, 117, 117, 117,
117, 116, 117, 117, 116, 117, 117, 117, 116, 117, 116, 117, 117, 116, 117, 116,
115, 116, 116, 116, 116, 116, 116, 116, 116, 117, 116, 116, 116, 115, 116, 115,
115, 115, 116, 116, 115, 115, 116, 115, 115, 116, 115, 115, 115, 115, 115, 116,
115, 115, 115, 115, 116, 115, 114, 115, 116, 115, 115, 114, 114, 115, 115, 114,
116, 114, 114, 113, 114, 113, 115, 114, 115, 114, 115, 115, 114, 115, 112, 114,
113, 115, 112, 115, 111, 116, 111, 116, 111, 117, 109, 118, 108, 119, 107, 121,
98, -111, -117, -110, -118, -110, -117, -111, -118, -111, -117, -112, -117,
-112, -116, -112, -116, -113, -116, -114, -116, -115, -116, -115, -115, -115,
-115, -116, -115, -116, -115, -116, -116, -116, -115, -115, -115, -116, -115,
-116, -115, -116, -116, -115, -115, -116, -116, -116, -116, -117, -117, -116,
-116, -116, -116, -116, -116, -116, -117, -116, -116, -116, -116, -116, -116,
-117, -117, -117, -116, -117, -117, -117, -117, -117, -117, -117, -116, -117,
-117, -117, -117, -117, -117, -117, -117, -117, -117, -117, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -117,
-118, -118, -118, -117, -119, -118, -118, -119, -118, -118, -118, -118, -119,
-119, -119, -118, -119, -118, -119, -120, -119, -118, -119, -119, -119, -118,
-118, -117, -116, -115, -114, -113, -112, -111, -110, -109, -108, -107, -107,
-105, -104, -104, -102, -102, -100, -99, -99, -98, -97, -95, -95, -93, -94, -92,
-91, -91, -89, -88, -88, -87, -85, -84, -84, -83, -82, -81, -80, -79, -78, -77,
-77, -75, -75, -73, -73, -71, -71, -70, -69, -68, -67, -66, -65, -65, -64, -62,
-62, -61, -60, -59, -58, -58, -56, -56, -54, -54, -52, -51, -50, -50, -49, -48,
-47, -45, -45, -44, -43, -42, -41, -40, -40, -38, -38, -36, -36, -35, -33, -33,
-32, -30, -30, -29, -29, -27, -26, -26, -24, -23, -22, -21, -21, -20, -20, -18,
-17, -16, -16, -14, -13, -11, -11, -10, -9, -9, -7, -6, -5, -6, -4, -4, -2, -1,
0, };