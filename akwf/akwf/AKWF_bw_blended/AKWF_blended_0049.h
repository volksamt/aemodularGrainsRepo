#define DATA_LENGTH 512
#define DATA AKWF_blended_0049

const PROGMEM int8_t DATA[DATA_LENGTH] = {26, 30, 27, 29, 27, 29, 28, 29, 28,
29, 29, 29, 28, 29, 28, 28, 28, 28, 28, 28, 29, 28, 29, 28, 28, 28, 29, 28, 28,
28, 28, 29, 28, 28, 29, 29, 29, 29, 27, 30, 27, 77, 122, 118, 120, 118, 120,
119, 118, 119, 119, 119, 118, 120, 119, 120, 119, 119, 118, 119, 119, 120, 118,
119, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 119, 120, 119, 119, 119,
119, 119, 119, 119, 120, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 120, 119,
120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 120,
118, 120, 119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 118, 118, 118, 120,
119, 119, 119, 119, 119, 118, 119, 119, 119, 120, 120, 118, 120, 120, 119, 119,
119, 119, 120, 118, 119, 119, 120, 119, 119, 119, 119, 119, 120, 119, 119, 119,
119, 119, 119, 118, 119, 120, 118, 119, 120, 119, 119, 119, 119, 118, 119, 119,
119, 118, 120, 119, 119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 118, 119,
119, 119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 120, 119, 119, 119, 119,
119, 120, 119, 119, 119, 118, 119, 119, 120, 119, 119, 119, 120, 119, 119, 119,
119, 119, 120, 119, 120, 119, 119, 118, 118, 119, 118, 120, 118, 121, 116, 123,
50, -31, -26, -29, -27, -29, -28, -28, -29, -29, -28, -29, -29, -28, -29, -28,
-29, -28, -29, -28, -29, -28, -28, -28, -28, -29, -28, -28, -28, -29, -28, -29,
-27, -28, -28, -28, -29, -29, -28, -29, -29, -29, -84, -122, -117, -120, -118,
-120, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -118, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-118, -119, -119, -119, -119, -118, -119, -118, -119, -119, -120, -120, -118,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -120, -119, -119, -119, -119, -119, -118,
-120, -119, -119, -119, -120, -119, -120, -119, -120, -120, -119, -119, -120,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -120, -119, -119,
-118, -118, -119, -119, -119, -119, -119, -118, -119, -119, -119, -120, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -118, -119, -120, -119, -119,
-119, -120, -120, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -118, -119, -119, -119, -118,
-119, -119, -119, -119, -120, -119, -119, -119, -118, -119, -119, -119, -118,
-119, -119, -119, -119, -120, -120, -119, -120, -119, -120, -119, -120, -118,
-120, -119, -119, -119, -120, -118, -120, -118, -119, -118, -119, -119, -119,
-119, -42, };