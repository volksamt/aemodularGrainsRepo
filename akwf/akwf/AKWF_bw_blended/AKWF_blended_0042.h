#define DATA_LENGTH 512
#define DATA AKWF_blended_0042

const PROGMEM int8_t DATA[DATA_LENGTH] = {64, 77, 71, 75, 72, 75, 72, 76, 73,
76, 73, 75, 73, 76, 75, 76, 75, 75, 76, 77, 76, 77, 77, 76, 78, 77, 78, 78, 78,
77, 78, 78, 78, 78, 79, 79, 79, 79, 79, 79, 80, 80, 80, 80, 80, 80, 81, 81, 82,
81, 82, 82, 82, 82, 82, 82, 83, 83, 82, 84, 83, 83, 83, 84, 84, 84, 85, 84, 85,
85, 85, 85, 85, 85, 86, 86, 86, 87, 86, 86, 86, 87, 87, 88, 87, 88, 88, 88, 88,
88, 88, 89, 88, 89, 89, 89, 89, 90, 90, 91, 91, 90, 91, 90, 91, 91, 92, 91, 91,
92, 91, 92, 92, 92, 93, 93, 94, 93, 94, 94, 94, 94, 95, 94, 94, 95, 94, 95, 95,
96, 95, 95, 96, 96, 96, 96, 96, 97, 97, 97, 98, 97, 99, 98, 97, 98, 98, 99, 99,
99, 99, 100, 100, 100, 100, 99, 100, 100, 100, 101, 101, 101, 101, 102, 102,
102, 103, 102, 103, 103, 103, 103, 103, 103, 103, 103, 104, 104, 104, 103, 104,
105, 105, 105, 104, 105, 106, 106, 106, 105, 107, 106, 107, 107, 107, 106, 107,
107, 108, 107, 107, 108, 109, 108, 109, 109, 110, 109, 109, 110, 110, 110, 110,
110, 111, 111, 111, 111, 111, 111, 112, 112, 112, 112, 112, 111, 113, 113, 113,
113, 113, 113, 114, 114, 114, 113, 114, 115, 115, 114, 115, 116, 116, 115, 116,
116, 115, 116, 116, 116, 117, 117, 118, 116, 121, 50, -34, -25, -33, -24, -34,
-22, -47, -126, -116, -119, -118, -118, -119, -117, -118, -117, -118, -117,
-118, -117, -117, -116, -117, -115, -117, -115, -116, -115, -115, -115, -115,
-114, -115, -115, -114, -114, -114, -114, -114, -114, -113, -113, -113, -113,
-113, -113, -112, -112, -112, -111, -111, -111, -111, -110, -111, -111, -110,
-110, -110, -110, -109, -109, -110, -109, -109, -108, -109, -109, -107, -108,
-108, -107, -107, -107, -107, -107, -107, -107, -106, -106, -106, -106, -105,
-106, -105, -105, -104, -105, -105, -104, -104, -104, -104, -104, -104, -103,
-103, -103, -103, -102, -103, -102, -102, -102, -103, -101, -101, -101, -102,
-101, -101, -101, -100, -100, -100, -100, -99, -100, -100, -99, -99, -99, -99,
-98, -98, -98, -98, -98, -98, -98, -97, -97, -97, -97, -96, -96, -96, -96, -96,
-96, -95, -96, -95, -95, -95, -94, -94, -93, -94, -94, -94, -93, -93, -94, -93,
-93, -92, -93, -93, -92, -92, -92, -92, -91, -91, -91, -91, -91, -90, -90, -89,
-90, -89, -89, -89, -89, -88, -89, -89, -88, -88, -88, -88, -88, -87, -87, -87,
-87, -87, -86, -87, -87, -86, -86, -86, -85, -86, -85, -85, -85, -85, -84, -85,
-84, -84, -84, -83, -83, -83, -83, -82, -83, -82, -82, -82, -82, -81, -81, -81,
-82, -82, -81, -80, -80, -81, -79, -80, -80, -80, -79, -80, -79, -79, -79, -78,
-79, -78, -78, -77, -79, -77, -78, -77, -78, -76, -77, -76, -78, -76, -78, -74,
-78, -75, -78, -72, -4, };