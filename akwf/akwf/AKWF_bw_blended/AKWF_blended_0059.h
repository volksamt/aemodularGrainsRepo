#define DATA_LENGTH 512
#define DATA AKWF_blended_0059

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 2, 4, 4, 6, 6, 6, 8, 8, 9,
10, 10, 12, 12, 13, 13, 14, 15, 15, 16, 17, 18, 19, 19, 20, 21, 21, 22, 23, 23,
25, 25, 26, 27, 27, 28, 28, 30, 30, 31, 32, 32, 34, 34, 35, 35, 35, 37, 37, 38,
39, 39, 41, 41, 41, 42, 43, 44, 45, 45, 46, 47, 48, 49, 50, 50, 51, 51, 52, 52,
53, 55, 55, 56, 57, 58, 58, 59, 59, 61, 62, 62, 62, 64, 64, 65, 65, 66, 68, 68,
68, 69, 70, 72, 72, 72, 73, 74, 74, 75, 76, 76, 77, 79, 78, 80, 81, 81, 82, 83,
83, 84, 84, 86, 87, 86, 89, 88, 90, 89, 92, 89, 94, 90, 97, 89, 106, 59, -3, 15,
6, 12, 9, 13, 12, 13, 13, 15, 15, 16, 16, 17, 18, 19, 20, 20, 21, 21, 23, 23,
25, 24, 26, 25, 28, 26, 30, 27, 33, 27, 36, 24, 47, -22, -122, -102, -112, -105,
-108, -105, -105, -104, -104, -104, -102, -102, -100, -100, -98, -99, -96, -98,
-96, -97, -94, -95, -92, -93, -92, -91, -90, -90, -89, -88, -87, -87, -85, -85,
-85, -83, -84, -82, -82, -80, -80, -79, -79, -77, -77, -77, -76, -75, -75, -73,
-72, -72, -71, -70, -69, -69, -68, -67, -66, -66, -65, -65, -64, -63, -63, -62,
-62, -61, -60, -59, -58, -58, -56, -56, -56, -55, -54, -53, -52, -52, -51, -49,
-49, -48, -48, -47, -46, -45, -45, -44, -43, -43, -41, -41, -40, -40, -39, -38,
-37, -37, -36, -36, -35, -34, -33, -32, -31, -31, -30, -30, -29, -28, -27, -26,
-26, -25, -25, -23, -23, -22, -21, -21, -20, -19, -18, -17, -17, -17, -15, -15,
-14, -13, -13, -12, -11, -10, -10, -8, -8, -8, -6, -6, -5, -5, -4, -3, -2, -1,
-1, 1, 0, 2, 2, 3, 3, 4, 6, 6, 7, 8, 8, 9, 10, 10, 11, 11, 13, 14, 14, 15, 16,
16, 17, 18, 19, 18, 20, 20, 21, 22, 23, 23, 25, 25, 26, 27, 28, 28, 29, 29, 30,
31, 32, 32, 32, 34, 35, 35, 35, 37, 38, 39, 39, 40, 40, 41, 42, 43, 43, 44, 44,
46, 47, 47, 48, 48, 49, 50, 50, 51, 53, 53, 54, 55, 55, 56, 57, 57, 58, 59, 59,
61, 61, 63, 62, 63, 63, 66, 65, 66, 67, 68, 68, 70, 69, 71, 72, 72, 74, 72, 77,
72, 80, 70, 91, 7, -79, -56, -68, -59, -64, -60, -62, -59, -61, -58, -58, -57,
-56, -56, -54, -55, -52, -52, -51, -52, -49, -50, -48, -49, -46, -47, -46, -45,
-45, -44, -43, -42, -42, -41, -40, -40, -39, -38, -37, -37, -36, -35, -35, -33,
-33, -32, -32, -31, -29, -29, -29, -27, -27, -26, -26, -25, -24, -23, -23, -22,
-21, -20, -19, -19, -18, -17, -17, -16, -14, -13, -13, -13, -12, -12, -11, -10,
-9, -9, -8, -7, -6, -5, -4, -3, -4, -2, -1, -1, 0, };