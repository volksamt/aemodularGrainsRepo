#define DATA_LENGTH 512
#define DATA AKWF_blended_0073

const PROGMEM int8_t DATA[DATA_LENGTH] = {27, 76, 76, 79, 80, 82, 84, 85, 87,
87, 89, 90, 92, 93, 96, 96, 99, 99, 101, 101, 104, 105, 107, 108, 109, 111, 112,
115, 113, 118, 112, 127, 85, 46, 59, 54, 60, 57, 61, 60, 62, 62, 64, 64, 65, 66,
66, 68, 68, 70, 69, 71, 71, 72, 72, 73, 73, 74, 75, 75, 75, 76, 76, 76, 76, 78,
77, 78, 77, 77, 78, 78, 78, 77, 77, 78, 77, 77, 77, 77, 77, 76, 76, 75, 76, 75,
74, 74, 73, 73, 73, 73, 72, 71, 70, 70, 69, 70, 68, 67, 67, 66, 66, 64, 64, 63,
62, 61, 60, 59, 59, 58, 57, 56, 55, 54, 53, 52, 51, 50, 49, 47, 47, 46, 45, 43,
43, 42, 41, 39, 39, 37, 36, 35, 35, 33, 32, 31, 30, 30, 29, 27, 27, 25, 24, 24,
23, 22, 20, 21, 19, 19, 17, 17, 15, 15, 15, 13, 12, 13, 11, 12, 10, 10, 9, 9, 8,
8, 7, 7, 6, 5, 5, 5, 5, 5, 4, 3, 4, 4, 4, 3, 4, 4, 4, 4, 3, 3, 3, 4, 4, 4, 4, 5,
5, 6, 5, 6, 7, 7, 8, 8, 9, 9, 10, 11, 11, 13, 13, 14, 15, 15, 15, 18, 18, 18,
20, 21, 21, 22, 24, 25, 26, 28, 28, 30, 31, 31, 34, 34, 37, 37, 38, 40, 41, 42,
45, 45, 47, 47, 50, 51, 52, 54, 56, 58, 59, 60, 61, 64, 65, 66, 68, 70, 71, 72,
17, -26, -19, -20, -16, -17, -14, -14, -11, -11, -8, -7, -5, -4, -2, -2, 0, 1,
3, 4, 5, 8, 9, 11, 12, 13, 14, 16, 15, 20, 16, 28, -20, -51, -39, -45, -39, -40,
-37, -38, -35, -36, -33, -33, -32, -33, -31, -30, -30, -29, -28, -27, -27, -26,
-26, -25, -24, -24, -23, -22, -23, -22, -22, -22, -22, -21, -21, -20, -20, -21,
-20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -21, -22, -21, -23, -22, -22,
-23, -23, -24, -25, -25, -25, -27, -28, -27, -28, -28, -29, -29, -30, -31, -32,
-33, -33, -34, -35, -37, -38, -38, -38, -40, -41, -42, -42, -44, -44, -46, -47,
-48, -48, -49, -50, -51, -53, -53, -54, -56, -56, -57, -58, -60, -61, -61, -62,
-63, -64, -65, -67, -68, -69, -70, -71, -72, -73, -74, -74, -75, -76, -76, -78,
-79, -79, -81, -82, -82, -82, -84, -84, -85, -85, -87, -87, -88, -88, -90, -90,
-90, -91, -91, -92, -92, -92, -93, -93, -94, -94, -94, -94, -93, -94, -94, -94,
-94, -94, -95, -95, -95, -94, -95, -94, -94, -93, -93, -93, -93, -92, -92, -91,
-91, -91, -90, -89, -89, -89, -88, -87, -87, -87, -85, -85, -83, -83, -82, -80,
-80, -79, -78, -77, -76, -76, -74, -73, -72, -71, -69, -68, -66, -66, -65, -63,
-62, -61, -60, -58, -57, -55, -55, -53, -51, -50, -49, -47, -45, -44, -42, -40,
-40, -37, -37, -34, -34, -31, -31, -27, -29, -22, };