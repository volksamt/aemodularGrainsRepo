#define DATA_LENGTH 512
#define DATA AKWF_blended_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 23, 25, 26, 28, 29, 32, 33, 36, 37,
40, 41, 44, 45, 48, 49, 51, 53, 55, 57, 59, 61, 63, 64, 66, 69, 70, 72, 74, 75,
78, 80, 81, 81, 80, 80, 80, 79, 79, 78, 79, 78, 77, 77, 77, 75, 75, 75, 75, 74,
74, 74, 73, 72, 72, 72, 71, 71, 70, 71, 70, 69, 69, 68, 68, 68, 67, 66, 66, 65,
64, 64, 63, 62, 63, 61, 61, 61, 60, 59, 59, 58, 57, 56, 57, 56, 54, 54, 53, 52,
53, 52, 50, 50, 50, 49, 49, 49, 51, 52, 54, 56, 57, 59, 59, 61, 63, 64, 66, 67,
68, 70, 71, 73, 75, 76, 77, 78, 79, 80, 82, 83, 84, 86, 86, 88, 89, 90, 91, 93,
93, 94, 96, 96, 97, 98, 100, 100, 101, 102, 103, 104, 105, 106, 106, 107, 108,
109, 110, 110, 111, 112, 114, 113, 115, 115, 117, 117, 118, 118, 119, 117, 115,
115, 114, 111, 110, 108, 107, 105, 103, 102, 100, 99, 97, 96, 94, 92, 91, 90,
88, 86, 84, 83, 81, 80, 78, 75, 74, 72, 71, 69, 67, 65, 64, 62, 60, 59, 56, 55,
52, 52, 50, 48, 46, 45, 42, 41, 39, 38, 36, 34, 32, 30, 28, 26, 24, 23, 21, 19,
17, 16, 14, 11, 11, 11, 11, 11, 11, 12, 12, 13, 13, 13, 14, 14, 14, 15, 15, 15,
16, 16, 17, 16, 17, 16, 17, 18, 17, 18, 18, 19, 19, 19, 19, 20, -4, -20, -18,
-20, -18, -19, -18, -17, -18, -17, -17, -17, -16, -16, -15, -15, -15, -15, -14,
-13, -14, -14, -14, -13, -13, -13, -12, -11, -11, -11, -11, -10, -10, -12, -15,
-16, -18, -20, -21, -24, -25, -27, -29, -31, -32, -34, -36, -38, -40, -42, -44,
-46, -48, -49, -51, -53, -55, -56, -58, -59, -61, -63, -65, -67, -69, -70, -72,
-74, -74, -76, -78, -80, -82, -84, -85, -88, -88, -89, -91, -94, -95, -97, -98,
-99, -101, -103, -104, -106, -107, -109, -111, -112, -114, -115, -117, -118,
-119, -118, -117, -117, -116, -115, -114, -114, -113, -111, -111, -111, -110,
-109, -109, -107, -106, -105, -104, -103, -103, -102, -100, -100, -98, -98, -97,
-97, -94, -94, -94, -92, -91, -90, -88, -87, -86, -84, -83, -82, -80, -80, -78,
-77, -75, -74, -73, -72, -70, -69, -67, -66, -65, -63, -62, -61, -59, -58, -56,
-54, -54, -52, -51, -49, -49, -49, -50, -51, -51, -51, -53, -53, -54, -55, -55,
-56, -57, -57, -58, -59, -59, -60, -61, -61, -62, -62, -63, -63, -64, -64, -65,
-66, -66, -67, -67, -68, -68, -69, -69, -69, -70, -70, -71, -71, -72, -72, -73,
-73, -75, -74, -74, -75, -75, -76, -75, -76, -77, -77, -78, -78, -78, -79, -79,
-79, -80, -81, -81, -82, -80, -79, -77, -74, -72, -70, -70, -68, -66, -63, -62,
-60, -58, -56, -54, -53, -50, -48, -47, -44, -43, -40, -39, -37, -35, -32, -31,
-28, -27, -24, -24, -18, };