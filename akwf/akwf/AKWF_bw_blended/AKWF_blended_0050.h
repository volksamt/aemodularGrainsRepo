#define DATA_LENGTH 512
#define DATA AKWF_blended_0050

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 2, 3, 3, 4, 5, 4, 5, 6, 6,
6, 6, 7, 8, 9, 8, 9, 10, 10, 11, 12, 13, 12, 13, 14, 14, 14, 16, 16, 17, 17, 18,
18, 18, 18, 20, 20, 21, 20, 21, 21, 22, 22, 24, 24, 24, 24, 25, 26, 26, 27, 27,
28, 27, 28, 29, 29, 30, 31, 31, 32, 32, 33, 34, 33, 35, 35, 36, 36, 36, 36, 37,
37, 38, 39, 40, 40, 40, 41, 41, 42, 42, 42, 42, 43, 44, 45, 45, 45, 46, 47, 47,
47, 47, 48, 50, 49, 50, 50, 51, 51, 53, 52, 52, 54, 54, 55, 55, 55, 56, 57, 57,
57, 58, 58, 59, 60, 59, 60, 61, 61, 62, 62, 63, 63, 64, 64, 65, 65, 66, 67, 66,
67, 67, 68, 70, 69, 70, 71, 71, 71, 72, 72, 73, 74, 74, 74, 75, 75, 75, 77, 77,
78, 77, 79, 78, 79, 80, 80, 81, 81, 82, 82, 83, 82, 84, 83, 85, 85, 86, 86, 86,
87, 88, 88, 89, 90, 89, 91, 91, 91, 92, 92, 92, 93, 93, 94, 95, 96, 96, 97, 97,
97, 98, 98, 99, 98, 99, 100, 100, 101, 101, 102, 103, 103, 103, 104, 104, 106,
105, 107, 106, 108, 107, 109, 109, 109, 109, 111, 111, 111, 112, 111, 113, 112,
115, 112, 116, 113, 118, 112, 122, 112, 125, 109, 127, 82, -51, -32, -39, -35,
-36, -36, -35, -35, -34, -34, -33, -34, -30, -33, -29, -32, -29, -30, -28, -29,
-28, -28, -27, -26, -26, -25, -25, -25, -24, -24, -22, -23, -22, -22, -20, -22,
-18, -22, -16, -24, -7, -61, -127, -107, -117, -110, -114, -111, -112, -110,
-111, -110, -108, -109, -107, -108, -107, -107, -106, -107, -105, -105, -104,
-104, -103, -103, -102, -102, -101, -101, -100, -101, -99, -99, -98, -98, -98,
-97, -96, -95, -95, -95, -95, -94, -93, -93, -93, -92, -92, -91, -90, -90, -90,
-89, -89, -88, -87, -86, -86, -86, -86, -85, -84, -83, -84, -83, -81, -82, -82,
-82, -81, -80, -80, -79, -79, -78, -77, -76, -76, -75, -76, -75, -75, -73, -73,
-73, -72, -72, -72, -70, -70, -70, -70, -69, -69, -68, -68, -66, -66, -67, -66,
-65, -64, -64, -63, -62, -63, -62, -62, -60, -61, -59, -59, -58, -59, -59, -57,
-58, -56, -56, -56, -56, -54, -54, -53, -53, -52, -51, -52, -50, -51, -51, -50,
-49, -48, -47, -47, -48, -47, -46, -45, -45, -44, -44, -44, -43, -43, -43, -41,
-41, -41, -40, -39, -39, -39, -38, -38, -37, -36, -36, -35, -35, -34, -33, -34,
-33, -32, -32, -32, -31, -30, -30, -30, -29, -28, -27, -27, -27, -27, -26, -25,
-25, -25, -24, -24, -23, -23, -22, -22, -21, -21, -20, -20, -20, -19, -18, -18,
-17, -16, -16, -16, -15, -15, -15, -14, -13, -13, -13, -12, -10, -11, -10, -10,
-10, -9, -9, -7, -8, -7, -6, -6, -6, -5, -4, -3, -3, -3, -2, -2, -1, 0, 0, };