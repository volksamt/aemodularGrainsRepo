#define DATA_LENGTH 512
#define DATA AKWF_blended_0038

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 59, 61, 60, 62, 61, 63, 63, 65, 64,
67, 66, 68, 67, 69, 69, 70, 70, 72, 71, 73, 74, 74, 76, 76, 76, 78, 77, 79, 80,
79, 81, 81, 82, 83, 84, 84, 85, 86, 86, 87, 88, 88, 89, 90, 90, 91, 90, 93, 92,
93, 94, 95, 95, 95, 97, 97, 97, 98, 98, 99, 99, 101, 101, 101, 102, 103, 103,
103, 104, 104, 104, 105, 106, 107, 106, 107, 107, 108, 108, 108, 109, 110, 110,
111, 110, 112, 111, 112, 112, 112, 112, 114, 114, 114, 114, 114, 115, 115, 115,
115, 116, 116, 116, 116, 116, 117, 116, 116, 117, 118, 117, 118, 119, 118, 118,
119, 119, 119, 118, 118, 119, 118, 119, 119, 119, 119, 120, 120, 119, 119, 119,
119, 119, 119, 118, 119, 118, 118, 119, 119, 118, 118, 118, 118, 118, 117, 118,
117, 117, 117, 117, 117, 116, 116, 116, 116, 116, 114, 115, 115, 114, 113, 113,
113, 113, 113, 112, 112, 112, 110, 111, 110, 110, 110, 108, 109, 109, 107, 108,
106, 107, 106, 105, 105, 104, 105, 104, 104, 103, 102, 101, 101, 100, 100, 99,
100, 98, 98, 98, 97, 96, 96, 95, 95, 94, 92, 93, 92, 91, 91, 90, 89, 89, 88, 87,
87, 86, 85, 85, 84, 83, 82, 82, 81, 81, 80, 79, 79, 78, 78, 76, 76, 74, 75, 74,
73, 72, 71, 70, 71, 69, 69, 67, 67, 66, 66, 65, 64, 64, 63, 62, 60, 61, 58, 59,
-9, -64, -58, -62, -60, -63, -62, -64, -63, -65, -65, -67, -66, -68, -69, -69,
-70, -70, -72, -72, -73, -73, -74, -75, -76, -76, -77, -77, -78, -79, -80, -81,
-81, -82, -83, -83, -84, -85, -86, -86, -86, -87, -88, -89, -89, -91, -91, -91,
-91, -93, -93, -94, -94, -95, -96, -96, -97, -97, -98, -98, -99, -99, -100,
-100, -101, -102, -102, -102, -103, -104, -104, -104, -105, -105, -107, -106,
-107, -108, -108, -108, -108, -109, -109, -111, -111, -111, -112, -111, -112,
-113, -113, -113, -113, -113, -114, -114, -115, -114, -115, -115, -116, -116,
-116, -116, -116, -117, -117, -117, -117, -117, -118, -118, -118, -118, -118,
-118, -119, -119, -118, -118, -119, -119, -118, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -118, -119, -118, -118, -118, -118,
-118, -118, -117, -117, -118, -117, -118, -118, -117, -117, -116, -116, -115,
-116, -115, -115, -116, -114, -115, -115, -114, -113, -114, -113, -112, -112,
-112, -112, -111, -111, -111, -111, -110, -109, -109, -108, -108, -108, -108,
-106, -106, -105, -106, -105, -105, -103, -104, -104, -102, -103, -102, -100,
-101, -101, -99, -98, -99, -98, -98, -97, -96, -95, -95, -94, -93, -93, -93,
-92, -91, -90, -90, -90, -88, -88, -87, -86, -86, -85, -84, -85, -84, -82, -82,
-80, -81, -80, -79, -78, -78, -77, -76, -75, -75, -75, -73, -73, -72, -71, -70,
-70, -68, -69, -67, -68, -65, -67, -63, -64, -62, -64, -61, -63, -57, -63, -50,
};