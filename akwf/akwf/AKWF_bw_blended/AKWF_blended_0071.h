#define DATA_LENGTH 512
#define DATA AKWF_blended_0071

const PROGMEM int8_t DATA[DATA_LENGTH] = {40, 95, 93, 95, 96, 96, 97, 98, 99,
98, 100, 100, 102, 102, 104, 104, 106, 106, 108, 107, 108, 109, 111, 111, 112,
113, 112, 116, 112, 120, 110, 127, 64, 1, 21, 11, 19, 15, 20, 18, 21, 20, 21,
22, 23, 24, 24, 25, 26, 28, 28, 29, 29, 31, 31, 32, 32, 34, 35, 36, 36, 38, 37,
39, 40, 40, 42, 42, 43, 44, 45, 45, 46, 46, 48, 48, 50, 50, 51, 52, 53, 53, 54,
55, 56, 56, 57, 59, 59, 60, 62, 62, 62, 64, 64, 65, 65, 66, 67, 69, 69, 71, 71,
71, 73, 73, 74, 74, 76, 76, 78, 77, 80, 79, 81, 80, 83, 83, 85, 83, 87, 85, 89,
86, 91, 88, 93, 88, -9, -15, -9, -14, -9, -12, -6, -9, -5, -7, -4, -6, -3, -4,
-1, -2, 0, 1, 2, 2, 3, 4, 5, 6, 7, 8, 8, 9, 10, 11, 10, 12, 13, 15, 14, 16, 16,
17, 18, 19, 20, 20, 21, 22, 22, 24, 24, 25, 26, 27, 29, 29, 30, 31, 31, 33, 33,
34, 34, 35, 37, 37, 38, 39, 39, 41, 41, 43, 43, 44, 44, 45, 46, 47, 48, 48, 49,
51, 52, 52, 53, 53, 54, 55, 56, 57, 58, 59, 59, 60, 61, 62, 63, 63, 64, 65, 66,
67, 68, 69, 70, 70, 71, 72, 73, 73, 74, 75, 77, 76, 78, 78, 79, 80, 81, 81, 83,
83, 84, 85, 86, 87, 87, 89, 89, 90, 90, 92, 31, -16, -10, -12, -9, -10, -8, -8,
-6, -6, -5, -4, -2, -4, -1, -2, 0, 0, 2, 2, 4, 3, 6, 6, 6, 8, 7, 10, 8, 14, 6,
25, -53, -104, -85, -95, -85, -91, -86, -88, -85, -86, -83, -84, -83, -82, -81,
-80, -79, -78, -78, -76, -77, -74, -75, -73, -73, -72, -71, -69, -70, -68, -68,
-66, -67, -65, -65, -63, -63, -62, -61, -60, -59, -58, -58, -57, -56, -56, -54,
-54, -53, -52, -52, -50, -50, -50, -49, -47, -46, -45, -45, -44, -44, -42, -41,
-41, -40, -39, -38, -37, -37, -36, -35, -34, -33, -32, -31, -31, -29, -29, -28,
-28, -26, -26, -25, -26, -21, -24, -20, -22, -18, -21, -16, -20, -13, -19, -10,
-26, -121, -119, -117, -117, -114, -116, -112, -115, -111, -113, -109, -110,
-108, -109, -107, -107, -105, -105, -103, -103, -102, -102, -101, -99, -100,
-98, -98, -96, -96, -95, -94, -93, -93, -91, -91, -90, -89, -88, -87, -86, -86,
-85, -85, -84, -82, -81, -80, -79, -79, -79, -77, -77, -76, -75, -75, -74, -73,
-72, -71, -70, -69, -69, -68, -67, -66, -65, -65, -64, -63, -62, -61, -61, -60,
-58, -57, -57, -56, -55, -55, -54, -53, -53, -51, -50, -49, -49, -48, -47, -46,
-45, -45, -44, -43, -41, -41, -41, -39, -39, -38, -37, -37, -35, -35, -34, -33,
-33, -31, -31, -29, -28, -28, -27, -26, -25, -25, -24, -24, -22, -22, -20, -20,
-19, -19, -17, -17, -16, -16, -12, };