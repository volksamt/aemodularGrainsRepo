#define DATA_LENGTH 512
#define DATA AKWF_blended_0035

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 13, 17, 19, 21, 24, 27,
30, 33, 36, 39, 42, 45, 48, 51, 53, 56, 60, 62, 65, 68, 71, 73, 76, 79, 81, 81,
82, 84, 86, 86, 88, 90, 90, 92, 93, 95, 96, 97, 98, 99, 100, 101, 103, 104, 105,
107, 108, 109, 111, 111, 112, 114, 115, 116, 118, 119, 118, 115, 113, 112, 109,
107, 105, 103, 101, 99, 98, 95, 92, 90, 88, 87, 84, 83, 80, 78, 76, 74, 72, 70,
68, 66, 64, 62, 59, 57, 55, 52, 50, 47, 44, 40, 38, 35, 33, 30, 27, 24, 21, 18,
15, 12, 9, 6, 4, 1, -2, -5, -8, -11, -13, -16, -19, -22, -25, -29, -31, -34,
-37, -40, -39, -39, -39, -38, -38, -38, -37, -37, -36, -36, -36, -34, -36, -35,
-34, -34, -33, -32, -32, -33, -32, -31, -31, -31, -30, -29, -29, -29, -28, -29,
-27, -26, -25, -23, -21, -18, -17, -15, -12, -9, -8, -6, -4, -2, 0, 3, 4, 7, 9,
11, 13, 14, 17, 19, 21, 24, 24, 28, 29, 31, 33, 35, 38, 39, 39, 37, 36, 34, 34,
32, 31, 29, 28, 28, 26, 25, 24, 23, 21, 20, 18, 17, 16, 14, 14, 12, 11, 10, 8,
8, 6, 4, 3, 2, 1, 0, -1, -3, -4, -5, -7, -8, -8, -10, -11, -13, -14, -15, -17,
-18, -19, -20, -22, -22, -23, -25, -26, -28, -29, -30, -31, -32, -33, -35, -36,
-37, -39, -39, -38, -36, -34, -31, -29, -27, -25, -24, -21, -20, -17, -15, -13,
-10, -9, -7, -5, -2, -1, 2, 3, 6, 8, 10, 12, 14, 17, 17, 20, 23, 25, 26, 26, 27,
27, 27, 28, 29, 30, 30, 30, 30, 31, 31, 32, 32, 33, 33, 33, 34, 34, 35, 35, 34,
36, 37, 37, 37, 37, 38, 39, 39, 39, 39, 37, 33, 31, 28, 25, 22, 19, 15, 14, 10,
7, 4, 1, -2, -5, -7, -11, -13, -16, -19, -22, -24, -27, -30, -34, -36, -39, -41,
-45, -47, -51, -53, -55, -57, -59, -61, -63, -65, -68, -70, -72, -73, -76, -77,
-80, -82, -84, -86, -88, -90, -92, -94, -96, -99, -101, -103, -105, -106, -109,
-111, -113, -115, -117, -119, -118, -117, -116, -114, -112, -111, -110, -110,
-108, -107, -105, -104, -104, -102, -100, -99, -98, -97, -96, -94, -93, -92,
-91, -89, -88, -86, -86, -85, -84, -82, -80, -79, -76, -74, -71, -68, -65, -62,
-58, -56, -53, -50, -47, -43, -41, -38, -36, -33, -30, -27, -24, -20, -18, -14,
-12, -9, -5, -4, 0, 2, 5, 8, 12, 13, 13, 13, 13, 12, 12, 11, 11, 10, 10, 9, 9,
8, 8, 9, 7, 7, 6, 7, 6, 5, 5, 5, 5, 4, 3, 3, 2, 2, 1, 1, 1, 1, 0, 0, 0, -1, -1,
-3, -3, -2, -4, -3, -4, -4, -4, -5, -6, -6, -7, -7, -8, -7, -9, -9, -9, -10, -9,
-10, -11, -12, -12, -13, -13, -12, -9, -7, -3, -1, };