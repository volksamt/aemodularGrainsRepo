#define DATA_LENGTH 512
#define DATA AKWF_blended_0067

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 0, 1, 1, 1, 2, 2, 3, 3, 3, 4, 3,
5, 6, 5, 5, 7, 7, 7, 8, 8, 9, 9, 9, 10, 11, 11, 12, 11, 13, 12, 14, 14, 14, 15,
16, 17, 17, 18, 18, 19, 19, 20, 20, 22, 22, 24, 24, 24, 25, 25, 27, 27, 28, 29,
30, 30, 31, 32, 33, 33, 34, 35, 35, 36, 38, 38, 38, 39, 39, 41, 42, 43, 44, 44,
45, 46, 47, 48, 48, 49, 49, 52, 53, 54, 54, 55, 56, 57, 57, 58, 60, 61, 61, 63,
63, 65, 66, 66, 68, 68, 69, 70, 72, 71, 73, 74, 76, 76, 78, 79, 79, 80, 82, 82,
84, 85, 86, 87, 88, 90, 89, 93, 92, 93, 93, 97, 96, 99, 98, 101, 99, 103, 102,
104, 105, 106, 107, 108, 111, 109, 115, 109, 119, 108, 126, 102, 127, -2, -128,
-102, -126, -108, -119, -109, -115, -108, -111, -107, -108, -107, -104, -104,
-102, -103, -100, -101, -97, -99, -95, -97, -92, -93, -91, -92, -89, -89, -87,
-86, -85, -86, -83, -83, -82, -80, -79, -78, -78, -76, -75, -74, -73, -72, -72,
-70, -70, -68, -68, -65, -65, -65, -64, -63, -62, -61, -59, -58, -58, -57, -56,
-55, -54, -52, -52, -51, -49, -50, -49, -48, -47, -46, -46, -45, -43, -42, -42,
-40, -40, -39, -38, -39, -36, -35, -36, -34, -34, -33, -33, -31, -31, -30, -29,
-28, -28, -27, -26, -26, -24, -24, -23, -24, -23, -22, -21, -20, -21, -19, -19,
-18, -17, -17, -16, -16, -16, -15, -15, -14, -13, -12, -12, -11, -11, -11, -9,
-9, -9, -8, -9, -8, -7, -7, -6, -6, -5, -6, -4, -4, -4, -3, -3, -2, -3, -1, -1,
-1, -1, -1, -1, 0, 1, 1, 1, 1, 2, 2, 3, 1, 1, 2, 2, 3, 3, 4, 4, 4, 4, 4, 3, 5,
5, 4, 5, 5, 5, 5, 5, 5, 5, 5, 5, 7, 6, 5, 6, 5, 7, 6, 6, 6, 6, 6, 6, 7, 6, 6, 7,
5, 7, 7, 7, 6, 6, 5, 6, 6, 6, 5, 6, 6, 6, 5, 5, 5, 5, 5, 5, 5, 5, 5, 6, 5, 5, 4,
5, 4, 4, 4, 4, 4, 4, 3, 3, 3, 3, 2, 2, 2, 2, 2, 2, 2, 2, 1, 2, 1, 2, 1, 1, 0, 0,
-1, 0, 0, -1, 0, 0, -1, -1, -1, -2, -1, -1, -2, -2, -3, -2, -3, -3, -3, -2, -4,
-3, -3, -3, -4, -4, -4, -5, -4, -4, -5, -4, -4, -5, -5, -5, -4, -5, -5, -6, -6,
-6, -6, -6, -6, -7, -7, -6, -6, -7, -7, -7, -6, -7, -7, -7, -7, -7, -7, -7, -7,
-8, -7, -7, -7, -7, -7, -7, -8, -7, -7, -6, -7, -7, -7, -6, -6, -7, -6, -7, -7,
-7, -6, -5, -6, -6, -6, -6, -5, -5, -5, -5, -5, -5, -4, -4, -4, -4, -4, -3, -3,
-3, -2, -3, -3, -2, -2, -1, 0, 0, 0, 0, };