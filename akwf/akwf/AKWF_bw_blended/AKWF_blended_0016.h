#define DATA_LENGTH 512
#define DATA AKWF_blended_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 24, 26, 27, 28, 30, 32, 33, 35, 36,
38, 40, 42, 43, 44, 45, 47, 49, 52, 52, 54, 55, 57, 60, 60, 61, 64, 65, 66, 68,
70, 71, 72, 72, 72, 72, 73, 73, 74, 74, 74, 73, 73, 74, 73, 74, 74, 74, 74, 74,
74, 74, 75, 73, 74, 74, 74, 75, 74, 74, 74, 75, 74, 74, 75, 74, 73, 74, 74, 73,
73, 74, 74, 73, 74, 74, 73, 73, 73, 72, 73, 72, 72, 72, 71, 73, 71, 71, 71, 71,
70, 71, 70, 70, 69, 69, 70, 70, 71, 72, 74, 75, 75, 77, 78, 78, 80, 81, 82, 82,
83, 84, 86, 87, 87, 89, 90, 90, 91, 91, 93, 94, 95, 95, 96, 97, 98, 99, 99, 100,
100, 101, 103, 103, 103, 104, 106, 106, 107, 108, 107, 108, 109, 109, 110, 111,
112, 113, 113, 114, 114, 114, 115, 116, 116, 116, 117, 118, 118, 119, 120, 118,
117, 117, 115, 114, 113, 112, 111, 110, 109, 108, 108, 106, 106, 104, 102, 102,
101, 100, 99, 98, 97, 95, 94, 93, 92, 91, 90, 89, 88, 87, 85, 83, 83, 82, 81,
79, 78, 77, 76, 75, 74, 71, 70, 69, 67, 67, 65, 65, 63, 63, 60, 59, 57, 57, 54,
54, 53, 52, 50, 49, 47, 46, 44, 44, 45, 45, 45, 45, 45, 45, 45, 44, 45, 45, 46,
45, 45, 45, 45, 45, 45, 45, 46, 44, 46, 44, 46, 44, 45, 44, 46, 43, 46, 43, -25,
-46, -43, -46, -43, -46, -44, -46, -44, -45, -45, -45, -44, -46, -44, -45, -44,
-44, -44, -45, -44, -45, -45, -45, -45, -44, -45, -45, -45, -45, -45, -44, -45,
-46, -47, -49, -49, -51, -53, -55, -56, -57, -58, -59, -61, -62, -63, -65, -66,
-68, -69, -69, -71, -72, -73, -75, -76, -77, -79, -80, -81, -82, -83, -85, -86,
-87, -88, -89, -90, -92, -93, -94, -94, -96, -97, -98, -98, -100, -101, -102,
-103, -105, -106, -107, -108, -108, -110, -111, -111, -113, -113, -115, -116,
-116, -118, -119, -118, -118, -119, -118, -117, -116, -115, -116, -115, -114,
-114, -113, -113, -112, -111, -110, -110, -109, -109, -108, -108, -107, -106,
-105, -105, -104, -103, -103, -101, -101, -100, -100, -99, -98, -96, -97, -96,
-95, -94, -93, -92, -92, -90, -90, -88, -87, -87, -86, -85, -85, -83, -82, -81,
-80, -80, -78, -77, -76, -75, -74, -73, -71, -71, -70, -69, -70, -70, -70, -70,
-70, -72, -71, -71, -71, -72, -73, -71, -73, -73, -73, -73, -73, -73, -73, -74,
-74, -74, -74, -74, -74, -74, -75, -74, -75, -75, -74, -74, -74, -74, -75, -74,
-75, -74, -74, -74, -75, -75, -74, -75, -74, -74, -74, -75, -74, -73, -73, -74,
-74, -74, -74, -73, -74, -73, -74, -73, -73, -73, -73, -71, -71, -69, -68, -67,
-65, -62, -62, -59, -58, -56, -55, -53, -53, -50, -48, -47, -46, -44, -43, -41,
-39, -38, -36, -35, -32, -32, -30, -29, -25, -26, -20, };