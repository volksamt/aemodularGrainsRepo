#define DATA_LENGTH 512
#define DATA AKWF_blended_0032

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 3, 2, 3, 4, 5, 5, 6, 7, 8, 8, 8,
10, 10, 11, 12, 14, 13, 14, 14, 16, 16, 17, 17, 20, 19, 21, 19, 23, 20, 30, 68,
68, 68, 69, 69, 71, 70, 73, 73, 74, 74, 76, 75, 77, 77, 78, 79, 79, 80, 81, 81,
83, 83, 84, 84, 86, 87, 87, 87, 89, 89, 90, 90, 91, 91, 93, 93, 93, 95, 96, 97,
97, 98, 99, 99, 100, 101, 101, 103, 103, 104, 103, 106, 105, 107, 106, 109, 109,
110, 109, 112, 110, 116, 104, 45, 44, 46, 45, 47, 47, 48, 48, 50, 50, 52, 51,
53, 53, 54, 54, 56, 56, 56, 57, 58, 58, 60, 61, 61, 62, 63, 63, 64, 65, 66, 67,
67, 69, 68, 70, 69, 71, 71, 72, 71, 75, 73, 76, 75, 77, 77, 79, 78, 80, 80, 81,
82, 81, 85, 82, 88, 82, 91, 81, 96, 77, 110, 15, -112, -79, -95, -83, -91, -85,
-87, -84, -84, -84, -82, -82, -80, -81, -78, -79, -77, -78, -76, -77, -74, -75,
-73, -73, -72, -73, -70, -70, -68, -69, -68, -67, -67, -66, -65, -64, -64, -62,
-62, -61, -61, -60, -59, -58, -58, -56, -56, -55, -54, -54, -53, -53, -51, -52,
-49, -50, -48, -49, -45, -48, -44, -48, -41, -56, -114, -112, -112, -112, -111,
-111, -108, -108, -107, -107, -105, -107, -104, -104, -103, -103, -101, -101,
-100, -100, -98, -98, -98, -97, -96, -95, -94, -94, -93, -92, -92, -91, -90,
-89, -88, -88, -87, -86, -85, -85, -84, -83, -83, -82, -82, -81, -79, -78, -79,
-77, -76, -76, -76, -74, -74, -72, -73, -71, -72, -69, -71, -67, -72, -55, -21,
-23, -21, -21, -20, -20, -19, -18, -17, -17, -16, -15, -15, -13, -13, -11, -12,
-11, -10, -8, -9, -7, -7, -7, -5, -5, -4, -3, -2, -2, -1, 0, 0, 1, 1, 3, 3, 4,
5, 6, 6, 7, 7, 8, 10, 10, 11, 12, 12, 13, 14, 14, 15, 14, 17, 17, 20, 18, 21,
18, 23, 19, 27, 8, -48, -45, -46, -45, -43, -43, -42, -42, -41, -41, -39, -40,
-37, -37, -36, -36, -35, -34, -33, -33, -32, -32, -30, -30, -29, -29, -28, -27,
-27, -25, -25, -23, -23, -23, -21, -21, -20, -19, -19, -17, -18, -17, -15, -15,
-14, -14, -13, -11, -12, -10, -10, -9, -8, -7, -7, -7, -5, -5, -5, -3, -3, -2,
-2, 0, 0, 2, 1, 2, 3, 4, 4, 5, 6, 7, 8, 7, 9, 10, 10, 12, 12, 13, 14, 15, 15,
16, 17, 18, 18, 19, 20, 20, 21, 22, 22, 24, 24, 25, 25, 26, 27, 28, 28, 30, 29,
30, 31, 32, 32, 34, 34, 35, 36, 36, 37, 38, 39, 39, 42, 39, 42, 41, 44, 43, 47,
42, 51, 29, -26, -21, -22, -21, -21, -20, -19, -18, -16, -17, -16, -16, -13,
-14, -12, -13, -12, -11, -10, -9, -8, -7, -7, -6, -5, -5, -4, -4, -2, -2, -1, 0,
};