#define DATA_LENGTH 512
#define DATA AKWF_blended_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 5, 7, 8, 9, 10, 11, 13, 13,
16, 16, 19, 19, 21, 21, 24, 24, 26, 27, 28, 29, 31, 32, 33, 34, 36, 36, 37, 39,
40, 42, 43, 44, 45, 46, 48, 48, 50, 51, 53, 53, 55, 55, 56, 57, 59, 60, 62, 62,
63, 64, 65, 66, 67, 68, 69, 71, 71, 72, 73, 75, 75, 76, 78, 78, 80, 80, 81, 81,
83, 84, 84, 85, 87, 87, 88, 88, 88, 90, 90, 91, 92, 92, 94, 94, 96, 96, 97, 97,
97, 98, 99, 100, 101, 101, 101, 102, 103, 104, 104, 105, 105, 106, 106, 107,
107, 107, 108, 108, 108, 109, 110, 109, 111, 110, 111, 111, 112, 111, 113, 112,
115, 111, 117, 105, 60, 54, 55, 56, 56, 55, 55, 55, 56, 55, 57, 55, 56, 56, 56,
55, 56, 56, 56, 56, 56, 55, 55, 55, 55, 55, 55, 54, 55, 54, 54, 54, 54, 53, 53,
53, 53, 53, 52, 52, 52, 52, 52, 52, 51, 52, 50, 50, 50, 50, 49, 48, 48, 48, 48,
47, 48, 47, 46, 47, 46, 45, 45, 45, 44, 44, 43, 42, 42, 42, 41, 40, 40, 40, 38,
38, 38, 37, 36, 36, 35, 34, 35, 33, 33, 33, 32, 30, 30, 30, 29, 28, 28, 27, 26,
26, 24, 24, 23, 24, 23, 21, 21, 20, 19, 18, 18, 17, 16, 16, 14, 13, 13, 12, 12,
11, 10, 8, 9, 7, 6, 6, 5, 5, 4, 3, 2, 2, 0, 1, -1, -1, -1, -4, -4, -4, -5, -6,
-6, -8, -8, -9, -9, -10, -12, -12, -12, -13, -14, -14, -15, -17, -17, -18, -19,
-19, -20, -21, -22, -22, -23, -24, -24, -25, -25, -27, -28, -28, -29, -29, -29,
-31, -31, -31, -32, -33, -34, -35, -34, -36, -36, -37, -37, -38, -38, -39, -40,
-41, -40, -41, -42, -43, -43, -44, -44, -45, -45, -46, -46, -46, -47, -47, -48,
-49, -49, -49, -49, -49, -50, -50, -51, -51, -52, -52, -52, -53, -53, -53, -53,
-52, -53, -53, -54, -54, -54, -54, -54, -54, -55, -55, -55, -55, -55, -55, -55,
-55, -55, -56, -56, -55, -56, -56, -56, -56, -55, -56, -55, -56, -55, -56, -54,
-56, -52, -57, -51, -68, -110, -113, -113, -112, -112, -112, -112, -112, -111,
-111, -110, -111, -111, -110, -110, -110, -109, -109, -108, -108, -108, -108,
-107, -106, -106, -105, -105, -105, -104, -103, -103, -103, -102, -102, -100,
-100, -99, -99, -98, -97, -97, -95, -95, -94, -93, -92, -92, -92, -90, -88, -89,
-88, -87, -86, -85, -83, -84, -83, -81, -81, -80, -79, -78, -77, -75, -75, -74,
-72, -72, -70, -69, -69, -68, -66, -65, -65, -63, -63, -61, -60, -59, -58, -57,
-55, -54, -53, -53, -52, -50, -48, -47, -46, -45, -44, -43, -42, -41, -39, -38,
-37, -35, -34, -34, -32, -31, -29, -28, -28, -25, -25, -24, -21, -21, -19, -19,
-17, -15, -15, -14, -13, -10, -10, -8, -7, -5, -5, -3, -2, -1, };