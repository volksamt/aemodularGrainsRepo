#define DATA_LENGTH 512
#define DATA AKWF_blended_0074

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 3, 5, 6, 7, 8, 9, 10, 11,
11, 13, 14, 14, 15, 16, 17, 18, 19, 20, 21, 21, 22, 23, 24, 25, 25, 26, 27, 28,
29, 29, 30, 30, 32, 33, 33, 35, 34, 35, 36, 37, 36, 22, 17, 21, 21, 22, 22, 23,
24, 24, 25, 27, 27, 28, 29, 29, 29, 31, 32, 32, 33, 34, 34, 35, 35, 36, 36, 37,
37, 39, 40, 40, 41, 41, 41, 42, 43, 42, 43, 45, 45, 45, 46, 46, 47, 47, 49, 49,
50, 50, 50, 51, 51, 52, 52, 52, 54, 54, 54, 55, 56, 56, 57, 57, 57, 58, 57, 59,
59, 59, 60, 60, 61, 61, 61, 62, 61, 62, 63, 62, 63, 64, 65, 65, 66, 65, 66, 66,
67, 67, 67, 67, 68, 68, 69, 69, 69, 69, 70, 70, 71, 71, 71, 71, 72, 73, 71, 72,
72, 74, 72, 74, 73, 76, 73, 75, 73, 77, 71, 81, 51, -38, -47, -44, -42, -40,
-40, -37, -37, -34, -33, -31, -30, -27, -27, -25, -24, -21, -20, -18, -17, -16,
-15, -13, -11, -10, -9, -8, -6, -5, -3, -1, 0, 1, 3, 4, 6, 7, 8, 9, 11, 11, 14,
14, 16, 18, 20, 21, 22, 23, 24, 25, 27, 28, 30, 30, 32, 32, 34, 35, 36, 38, 38,
40, 40, 42, 43, 44, 46, 47, 48, 50, 50, 51, 52, 54, 54, 55, 56, 58, 58, 60, 61,
62, 63, 65, 66, 65, 51, 31, 13, 0, -9, -15, -19, -21, -24, -27, -27, -29, -29,
-30, -30, -32, -32, -31, -32, -33, -33, -32, -32, -33, -32, -33, -33, -32, -33,
-32, -33, -32, -32, -32, -31, -31, -31, -31, -31, -30, -29, -29, -29, -28, -28,
-28, -27, -28, -30, -45, -47, -44, -45, -44, -43, -42, -43, -42, -41, -41, -40,
-39, -39, -38, -38, -37, -36, -36, -35, -36, -34, -33, -34, -33, -32, -32, -31,
-31, -30, -29, -29, -28, -28, -27, -26, -27, -26, -25, -25, -24, -24, -23, -22,
-22, -22, -22, -21, -21, -20, -20, -18, -19, -18, -18, -17, -17, -16, -16, -14,
-15, -15, -14, -14, -13, -13, -12, -12, -12, -11, -10, -10, -10, -10, -9, -8,
-9, -8, -7, -7, -6, -7, -6, -6, -5, -5, -5, -5, -4, -3, -3, -3, -3, -3, -2, -2,
-2, -1, -1, -1, 0, 0, 1, 1, 1, 1, 1, 2, 3, 1, 3, 2, 4, 2, 4, 2, 6, 0, 11, -30,
-114, -116, -115, -113, -111, -109, -109, -107, -104, -104, -102, -101, -99,
-97, -96, -95, -92, -91, -90, -89, -87, -85, -84, -83, -81, -79, -78, -76, -75,
-74, -72, -71, -70, -68, -67, -65, -65, -63, -62, -59, -59, -58, -56, -55, -54,
-53, -51, -49, -48, -47, -46, -44, -43, -42, -40, -40, -39, -37, -36, -35, -33,
-32, -31, -31, -29, -28, -26, -25, -24, -23, -22, -21, -20, -18, -18, -16, -16,
-14, -14, -12, -11, -9, -9, -7, -7, -6, -5, -4, -2, -2, -1, };