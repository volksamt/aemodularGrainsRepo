#define DATA_LENGTH 512
#define DATA AKWF_blended_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 5, 8, 10, 13, 15, 18, 20, 23,
26, 28, 30, 32, 34, 37, 40, 42, 44, 46, 48, 50, 53, 55, 57, 59, 61, 64, 65, 68,
70, 72, 74, 75, 78, 79, 81, 83, 85, 87, 88, 89, 91, 92, 94, 96, 97, 99, 99, 101,
102, 103, 104, 105, 106, 108, 108, 110, 111, 111, 112, 113, 114, 115, 115, 116,
116, 117, 117, 117, 119, 118, 119, 119, 118, 119, 119, 120, 119, 120, 118, 119,
118, 119, 118, 118, 117, 117, 117, 117, 115, 115, 114, 113, 113, 112, 112, 111,
111, 110, 109, 108, 107, 105, 105, 104, 104, 102, 100, 100, 99, 98, 96, 95, 94,
93, 93, 90, 90, 88, 86, 86, 84, 83, 82, 81, 80, 78, 76, 73, 71, 68, 66, 63, 61,
58, 56, 53, 51, 48, 47, 44, 42, 39, 37, 35, 32, 30, 28, 26, 24, 22, 19, 16, 14,
13, 10, 8, 7, 5, 3, 1, -2, -3, -5, -6, -9, -10, -11, -12, -15, -17, -18, -19,
-21, -23, -23, -25, -27, -28, -28, -29, -31, -32, -33, -34, -34, -35, -36, -37,
-38, -39, -39, -40, -40, -40, -41, -42, -41, -41, -42, -42, -42, -43, -42, -42,
-43, -42, -42, -42, -42, -42, -41, -41, -41, -40, -39, -40, -40, -39, -38, -38,
-36, -36, -35, -35, -33, -33, -32, -31, -31, -29, -29, -27, -26, -25, -25, -23,
-23, -21, -19, -20, -18, -17, -15, -14, -13, -12, -10, -9, -8, -7, -5, -4, -3,
-1, 0, 2, 3, 3, 5, 6, 7, 9, 10, 11, 12, 14, 15, 16, 17, 18, 20, 20, 21, 23, 23,
26, 25, 28, 28, 29, 30, 30, 31, 33, 33, 34, 35, 36, 37, 37, 37, 38, 38, 39, 39,
40, 40, 40, 41, 41, 42, 41, 42, 41, 41, 42, 41, 41, 41, 41, 41, 42, 41, 40, 40,
39, 38, 38, 37, 37, 36, 36, 35, 34, 33, 32, 31, 30, 29, 29, 27, 26, 25, 23, 22,
22, 19, 18, 17, 15, 14, 12, 10, 9, 7, 5, 3, 2, 0, -2, -3, -6, -8, -10, -12, -15,
-16, -18, -20, -22, -24, -27, -29, -32, -34, -36, -39, -41, -43, -46, -48, -51,
-53, -56, -57, -60, -62, -65, -67, -69, -73, -75, -76, -78, -79, -80, -82, -82,
-84, -84, -87, -88, -89, -90, -91, -91, -94, -94, -97, -96, -99, -99, -100,
-101, -103, -103, -104, -105, -106, -107, -107, -109, -109, -110, -111, -111,
-112, -113, -114, -114, -116, -115, -115, -116, -116, -117, -117, -117, -117,
-118, -118, -118, -117, -117, -119, -117, -118, -117, -117, -117, -117, -117,
-116, -116, -115, -114, -114, -113, -112, -112, -111, -110, -110, -110, -107,
-106, -106, -105, -103, -102, -101, -99, -98, -97, -96, -94, -93, -91, -90, -89,
-86, -85, -83, -81, -80, -77, -75, -74, -72, -71, -68, -66, -64, -62, -60, -58,
-56, -54, -52, -49, -47, -45, -42, -40, -38, -36, -33, -31, -29, -26, -24, -20,
-19, -16, -14, -11, -9, -7, -4, -1, };