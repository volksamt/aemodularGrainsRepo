#define DATA_LENGTH 512
#define DATA AKWF_blended_0079

const PROGMEM int8_t DATA[DATA_LENGTH] = {89, 122, 111, 116, 110, 113, 109, 111,
107, 108, 104, 105, 102, 103, 100, 100, 98, 97, 96, 95, 94, 93, 92, 90, 89, 88,
86, 86, 85, 83, 83, 81, 79, 78, 78, 76, 76, 74, 73, 72, 70, 70, 69, 67, 66, 65,
63, 63, 62, 60, 59, 58, 56, 55, 55, 54, 53, 53, 51, 50, 49, 49, 48, 48, 46, 46,
46, 44, 44, 43, 43, 41, 41, 40, 39, 38, 37, 34, 34, 33, 33, 31, 29, 28, 27, 25,
24, 24, 23, 22, 20, 21, 19, 19, 18, 17, 17, 17, 15, 14, 14, 14, 13, 12, 12, 11,
10, 11, 9, 9, 8, 7, 6, 6, 4, 5, 4, 4, 2, 2, 1, 2, 1, -1, -1, -1, -3, -1, 35, 46,
41, 44, 41, 42, 40, 41, 39, 39, 38, 38, 37, 36, 35, 35, 34, 34, 32, 32, 32, 31,
30, 30, 29, 28, 28, 28, 27, 26, 25, 25, 25, 23, 23, 22, 21, 21, 21, 19, 18, 16,
15, 14, 14, 12, 11, 9, 9, 8, 7, 5, 4, 3, 2, 1, -1, -2, -2, -2, -3, -3, -5, -6,
-6, -7, -7, -9, -9, -11, -11, -12, -12, -13, -14, -15, -16, -17, -19, -20, -21,
-22, -24, -25, -26, -28, -28, -29, -31, -32, -32, -34, -35, -37, -37, -39, -39,
-40, -42, -43, -45, -45, -46, -48, -49, -50, -50, -51, -52, -54, -54, -55, -57,
-56, -58, -58, -60, -61, -63, -62, -65, -63, -67, -66, -69, -67, -73, -38, 58,
72, 67, 69, 66, 67, 64, 65, 62, 62, 60, 61, 58, 58, 57, 57, 55, 55, 53, 52, 51,
51, 49, 48, 48, 46, 45, 43, 43, 41, 40, 39, 38, 38, 36, 35, 33, 32, 31, 29, 29,
28, 26, 26, 24, 23, 22, 21, 19, 19, 17, 17, 15, 14, 13, 11, 11, 10, 10, 8, 8, 6,
6, 6, 4, 4, 4, 2, 1, 2, 0, 0, -1, -2, -3, -5, -5, -6, -8, -9, -10, -12, -12,
-14, -15, -16, -16, -19, -19, -20, -21, -22, -23, -23, -23, -25, -25, -26, -27,
-27, -27, -28, -29, -30, -29, -30, -31, -31, -33, -33, -34, -34, -36, -35, -36,
-37, -38, -38, -40, -40, -40, -40, -42, -42, -43, -42, -44, -40, -3, 3, 1, 2, 0,
0, -2, -1, -3, -3, -4, -4, -5, -6, -7, -7, -8, -8, -9, -9, -10, -11, -11, -11,
-13, -14, -14, -14, -15, -16, -16, -18, -18, -19, -20, -20, -20, -20, -22, -23,
-23, -25, -27, -28, -29, -29, -31, -33, -34, -34, -37, -37, -39, -38, -40, -41,
-42, -43, -44, -45, -45, -46, -47, -47, -48, -49, -49, -50, -51, -52, -52, -54,
-53, -55, -56, -57, -58, -61, -61, -62, -64, -64, -66, -67, -68, -69, -70, -71,
-72, -74, -74, -76, -77, -78, -78, -81, -82, -83, -84, -85, -86, -87, -89, -90,
-91, -92, -94, -93, -96, -96, -98, -99, -100, -100, -102, -103, -106, -106,
-108, -107, -110, -111, -112, -112, -114, -116, -78, -29, };