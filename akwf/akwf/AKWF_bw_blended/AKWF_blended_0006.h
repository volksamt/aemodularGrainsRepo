#define DATA_LENGTH 512
#define DATA AKWF_blended_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 20, 35, 44, 54, 61, 68, 74, 79, 83,
87, 90, 93, 96, 98, 100, 102, 103, 104, 106, 107, 108, 110, 110, 112, 112, 111,
113, 113, 114, 113, 115, 116, 115, 115, 116, 116, 116, 117, 116, 117, 118, 117,
118, 118, 118, 117, 117, 118, 118, 118, 118, 119, 118, 118, 119, 119, 119, 119,
119, 118, 119, 116, 106, 96, 91, 87, 84, 82, 81, 79, 78, 77, 77, 78, 77, 77, 77,
77, 77, 77, 77, 78, 77, 76, 77, 77, 77, 76, 76, 77, 77, 77, 76, 77, 77, 77, 77,
77, 76, 77, 77, 77, 77, 77, 77, 77, 76, 76, 77, 78, 77, 76, 77, 76, 77, 77, 77,
77, 76, 77, 76, 77, 77, 72, 62, 57, 61, 63, 64, 63, 61, 61, 59, 58, 56, 56, 55,
55, 54, 52, 52, 51, 52, 51, 50, 50, 50, 50, 50, 50, 49, 49, 49, 50, 50, 49, 49,
49, 49, 49, 49, 48, 49, 49, 49, 49, 49, 50, 49, 49, 48, 49, 49, 49, 49, 49, 48,
50, 49, 49, 49, 49, 49, 49, 49, 49, 49, 49, 50, 46, 34, 27, 21, 16, 14, 12, 10,
10, 8, 9, 7, 7, 7, 6, 8, 7, 6, 6, 6, 6, 7, 6, 7, 7, 6, 7, 6, 7, 6, 6, 6, 6, 7,
7, 7, 6, 7, 6, 7, 7, 6, 7, 7, 7, 6, 6, 6, 6, 6, 7, 6, 7, 7, 7, 6, 7, 4, -1, -10,
-19, -27, -29, -27, -21, -8, 0, 7, 11, 13, 14, 15, 15, 15, 15, 13, 13, 11, 10,
9, 8, 7, 7, 6, 5, 4, 3, 2, 1, 1, 1, 0, 0, -1, -1, -2, -3, -3, -3, -4, -4, -4,
-4, -4, -5, -5, -4, -5, -5, -5, -5, -5, -6, -5, -6, -6, -6, -6, -7, -6, -6, -6,
-6, -6, -7, -6, -7, -5, -10, -22, -30, -35, -39, -41, -44, -45, -46, -47, -47,
-47, -49, -48, -49, -49, -49, -49, -49, -49, -49, -49, -49, -49, -49, -48, -49,
-48, -49, -49, -49, -48, -49, -48, -49, -49, -49, -49, -49, -50, -49, -49, -49,
-48, -49, -49, -50, -49, -49, -49, -49, -49, -49, -50, -49, -49, -49, -49, -48,
-49, -49, -49, -54, -65, -68, -64, -63, -63, -64, -64, -65, -67, -68, -69, -70,
-70, -71, -72, -73, -73, -75, -74, -74, -75, -75, -76, -76, -76, -77, -76, -77,
-77, -76, -76, -76, -76, -77, -76, -77, -76, -77, -77, -77, -77, -77, -77, -77,
-76, -76, -77, -77, -78, -77, -77, -77, -77, -77, -76, -77, -77, -77, -77, -77,
-76, -76, -76, -76, -76, -81, -93, -100, -105, -109, -112, -114, -115, -117,
-117, -118, -118, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-120, -119, -119, -120, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -120, -119, -119, -118, -119,
-119, -119, -119, -120, -119, -119, -119, -118, -119, -116, -109, -101, -92,
-84, -70, -54, -35, -11, };