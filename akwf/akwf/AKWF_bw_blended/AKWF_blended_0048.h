#define DATA_LENGTH 512
#define DATA AKWF_blended_0048

const PROGMEM int8_t DATA[DATA_LENGTH] = {45, 123, 116, 123, 91, 32, 28, 28, 28,
28, 29, 28, 29, 28, 28, 28, 28, 28, 29, 28, 29, 29, 29, 29, 28, 29, 29, 28, 28,
28, 28, 28, 28, 28, 28, 29, 28, 28, 28, 28, 28, 28, 28, 29, 28, 28, 29, 28, 29,
28, 28, 28, 28, 29, 28, 28, 29, 28, 29, 28, 29, 29, 29, 28, 29, 29, 29, 29, 28,
28, 29, 28, 28, 28, 29, 29, 29, 29, 28, 28, 29, 28, 29, 29, 28, 28, 28, 29, 29,
28, 29, 29, 28, 28, 28, 28, 29, 29, 28, 29, 29, 28, 29, 29, 28, 27, 28, 28, 28,
29, 28, 28, 28, 28, 29, 28, 28, 29, 28, 29, 29, 28, 29, 29, 28, 28, 28, 29, 28,
28, 28, 28, 28, 28, 28, 29, 28, 29, 29, 28, 29, 28, 29, 29, 28, 29, 28, 28, 29,
29, 28, 28, 28, 28, 29, 28, 29, 29, 29, 28, 28, 28, 27, 29, 29, 28, 28, 28, 29,
27, 29, 28, 28, 28, 29, 29, 28, 28, 29, 28, 28, 29, 29, 28, 28, 28, 29, 29, 29,
29, 28, 28, 29, 28, 28, 28, 28, 29, 28, 27, 28, 28, 29, 28, 29, 28, 28, 28, 29,
28, 28, 29, 28, 28, 29, 28, 28, 28, 29, 28, 28, 28, 28, 28, 28, 28, 29, 29, 28,
28, 28, 28, 28, 28, 28, 28, 28, 29, 29, 28, 29, 29, 28, 28, 29, 27, 28, 28, 29,
29, 29, 28, 29, 28, 27, 28, -57, -125, -114, -125, -83, -30, -28, -29, -28, -29,
-29, -28, -28, -29, -28, -28, -29, -28, -28, -29, -28, -28, -28, -28, -27, -28,
-28, -27, -28, -28, -29, -28, -28, -28, -28, -28, -29, -28, -28, -28, -28, -28,
-28, -28, -28, -28, -28, -28, -28, -29, -28, -28, -28, -28, -29, -28, -28, -28,
-28, -29, -28, -29, -28, -29, -28, -28, -28, -27, -28, -28, -29, -28, -29, -28,
-29, -28, -28, -28, -28, -28, -29, -28, -28, -28, -28, -28, -29, -28, -29, -29,
-28, -28, -28, -28, -28, -28, -29, -28, -28, -29, -29, -28, -28, -29, -29, -27,
-29, -28, -29, -28, -29, -28, -29, -28, -28, -28, -28, -28, -29, -29, -28, -29,
-28, -28, -28, -29, -28, -28, -28, -28, -29, -28, -27, -28, -29, -28, -28, -29,
-28, -28, -29, -28, -28, -28, -28, -28, -29, -29, -28, -28, -29, -28, -28, -28,
-28, -29, -28, -28, -29, -29, -28, -29, -28, -28, -29, -28, -28, -28, -28, -29,
-29, -28, -27, -28, -28, -28, -28, -29, -28, -29, -28, -28, -29, -29, -28, -28,
-29, -28, -28, -28, -29, -28, -28, -28, -29, -29, -28, -28, -28, -28, -28, -28,
-29, -28, -29, -29, -29, -28, -28, -28, -29, -28, -28, -28, -28, -29, -28, -28,
-28, -28, -28, -28, -27, -29, -28, -28, -29, -28, -28, -28, -28, -28, -28, -28,
-29, -28, -29, -29, -29, -28, -28, -28, -28, -28, -29, -28, -29, -28, -30, -27,
-29, -27, -29, -27, -30, -25, };