#define DATA_LENGTH 512
#define DATA AKWF_blended_0072

const PROGMEM int8_t DATA[DATA_LENGTH] = {30, 77, 76, 79, 80, 82, 83, 84, 87,
88, 89, 90, 93, 92, 96, 96, 98, 99, 102, 102, 105, 105, 107, 109, 109, 112, 111,
115, 113, 119, 112, 127, 79, 32, 49, 41, 48, 44, 48, 47, 50, 50, 52, 53, 54, 54,
54, 56, 56, 58, 58, 59, 59, 61, 61, 61, 62, 63, 62, 64, 64, 65, 64, 65, 65, 66,
66, 67, 67, 67, 67, 67, 67, 67, 67, 66, 66, 67, 66, 67, 67, 66, 67, 66, 65, 66,
65, 65, 64, 64, 63, 63, 62, 62, 62, 61, 61, 60, 59, 59, 58, 57, 57, 56, 55, 55,
54, 52, 53, 52, 51, 50, 49, 49, 47, 47, 46, 45, 44, 43, 42, 41, 40, 39, 38, 38,
36, 36, 35, 33, 33, 32, 31, 30, 30, 28, 28, 26, 26, 25, 24, 23, 22, 21, 20, 19,
19, 17, 17, 16, 16, 14, 14, 13, 13, 11, 11, 11, 9, 9, 9, 8, 7, 7, 6, 6, 5, 6, 6,
4, 4, 4, 4, 3, 3, 3, 3, 3, 3, 2, 2, 2, 2, 2, 2, 3, 3, 3, 3, 2, 3, 4, 4, 4, 5, 5,
5, 6, 6, 7, 7, 8, 9, 9, 10, 11, 11, 13, 13, 13, 14, 16, 16, 17, 19, 19, 21, 20,
22, 23, 24, 25, 27, 27, 30, 30, 31, 32, 34, 35, 37, 38, 39, 40, 42, 42, 45, 46,
47, 49, 50, 51, 53, 54, 56, 57, 58, 60, 62, 63, 65, 66, 68, 70, 71, 74, 22, -17,
-10, -12, -8, -9, -5, -5, -2, -1, 1, 1, 4, 4, 7, 7, 9, 11, 12, 13, 16, 16, 18,
19, 20, 23, 22, 25, 23, 30, 23, 38, -19, -56, -41, -48, -41, -46, -40, -41, -40,
-40, -38, -37, -36, -36, -34, -33, -33, -32, -31, -30, -30, -28, -29, -28, -27,
-26, -26, -26, -25, -25, -25, -24, -24, -23, -23, -22, -23, -22, -23, -22, -22,
-22, -22, -22, -23, -22, -23, -23, -23, -23, -23, -24, -23, -24, -24, -26, -25,
-26, -26, -26, -27, -27, -28, -28, -29, -30, -31, -31, -31, -32, -33, -33, -33,
-34, -36, -37, -38, -37, -39, -39, -41, -41, -42, -43, -44, -44, -46, -47, -47,
-48, -49, -50, -50, -52, -53, -54, -55, -55, -57, -57, -59, -59, -61, -62, -62,
-62, -64, -64, -66, -66, -67, -69, -69, -70, -70, -72, -73, -73, -73, -75, -75,
-76, -77, -77, -79, -78, -79, -80, -81, -81, -82, -82, -83, -83, -84, -84, -85,
-85, -85, -85, -86, -86, -86, -86, -86, -86, -87, -87, -86, -88, -87, -87, -87,
-87, -87, -86, -86, -86, -86, -86, -86, -85, -84, -84, -83, -83, -83, -82, -82,
-82, -81, -81, -80, -79, -78, -77, -76, -76, -75, -74, -73, -72, -70, -70, -69,
-69, -67, -66, -66, -63, -63, -62, -61, -59, -57, -57, -56, -55, -53, -52, -51,
-49, -47, -46, -45, -44, -42, -40, -40, -37, -36, -35, -33, -31, -30, -29, -27,
-26, -24, -23, -22, -19, -19, -14, };