#define DATA_LENGTH 512
#define DATA AKWF_blended_0080

const PROGMEM int8_t DATA[DATA_LENGTH] = {46, 71, 64, 69, 67, 69, 68, 69, 68,
69, 70, 71, 70, 72, 71, 71, 71, 73, 72, 72, 73, 73, 74, 74, 74, 74, 74, 74, 76,
75, 76, 76, 77, 77, 76, 77, 77, 77, 77, 78, 77, 78, 79, 79, 79, 79, 79, 79, 80,
80, 80, 79, 79, 79, 80, 79, 80, 81, 80, 81, 81, 81, 82, 82, 83, 83, 84, 84, 84,
84, 85, 85, 85, 84, 84, 84, 84, 85, 84, 83, 83, 83, 83, 82, 82, 81, 81, 81, 80,
79, 80, 79, 79, 81, 80, 81, 80, 80, 80, 81, 80, 80, 80, 80, 80, 80, 79, 80, 79,
78, 78, 78, 78, 78, 78, 78, 77, 78, 76, 77, 76, 77, 76, 75, 75, 75, 73, 75, 109,
119, 116, 117, 115, 116, 115, 115, 114, 114, 113, 113, 111, 111, 111, 111, 109,
110, 108, 108, 107, 106, 106, 105, 104, 104, 103, 102, 101, 100, 100, 99, 98,
97, 97, 95, 95, 93, 93, 91, 90, 89, 87, 86, 83, 82, 81, 80, 79, 77, 75, 74, 72,
71, 69, 67, 66, 65, 63, 63, 62, 61, 59, 57, 57, 55, 54, 52, 50, 50, 48, 46, 46,
44, 42, 40, 38, 37, 34, 33, 31, 30, 27, 26, 23, 22, 19, 18, 16, 14, 13, 10, 9,
6, 3, 1, 0, -2, -4, -6, -8, -10, -12, -14, -16, -19, -20, -22, -25, -26, -29,
-30, -34, -35, -38, -38, -42, -43, -46, -47, -51, -51, -55, -55, -60, -58, -66,
-34, 52, 65, 59, 60, 55, 55, 51, 50, 47, 46, 42, 41, 38, 36, 35, 32, 31, 28, 26,
25, 22, 20, 17, 16, 14, 12, 10, 7, 5, 3, 2, 0, -2, -5, -6, -8, -10, -13, -14,
-17, -18, -19, -23, -24, -26, -28, -30, -32, -33, -35, -37, -39, -42, -43, -44,
-47, -47, -49, -50, -52, -53, -54, -55, -58, -58, -60, -61, -62, -64, -65, -66,
-67, -69, -70, -71, -74, -75, -75, -78, -79, -80, -83, -83, -85, -87, -88, -90,
-91, -92, -94, -94, -95, -97, -97, -98, -99, -100, -101, -101, -102, -103, -103,
-104, -105, -105, -106, -107, -107, -109, -108, -109, -110, -111, -111, -112,
-112, -113, -112, -114, -114, -115, -114, -117, -115, -117, -116, -119, -114,
-79, -73, -75, -74, -76, -75, -77, -76, -77, -76, -77, -77, -78, -78, -78, -78,
-77, -78, -78, -79, -79, -79, -79, -79, -80, -80, -80, -79, -79, -80, -79, -79,
-80, -80, -80, -80, -79, -79, -80, -79, -80, -81, -81, -82, -81, -82, -83, -82,
-83, -83, -83, -84, -84, -84, -84, -85, -84, -84, -83, -84, -83, -83, -83, -83,
-83, -82, -81, -81, -81, -79, -80, -79, -79, -79, -79, -79, -79, -79, -79, -78,
-78, -78, -79, -78, -79, -78, -79, -78, -78, -77, -77, -77, -76, -77, -77, -76,
-76, -76, -75, -75, -75, -74, -73, -74, -74, -73, -73, -73, -72, -72, -72, -71,
-72, -71, -70, -71, -70, -69, -69, -68, -69, -68, -68, -67, -67, -65, -68, -31,
};