#define DATA_LENGTH 512
#define DATA AKWF_blended_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {65, 111, 99, 107, 102, 105, 102, 106,
104, 106, 104, 105, 106, 106, 106, 106, 106, 107, 107, 107, 107, 107, 108, 107,
108, 108, 108, 107, 108, 108, 108, 109, 108, 108, 109, 109, 109, 109, 109, 110,
110, 110, 110, 111, 110, 110, 110, 111, 110, 110, 111, 111, 111, 111, 112, 112,
111, 112, 111, 112, 112, 112, 112, 112, 112, 113, 113, 112, 113, 114, 113, 113,
114, 113, 113, 113, 113, 114, 113, 114, 114, 115, 114, 114, 115, 115, 115, 115,
114, 115, 115, 115, 115, 115, 116, 116, 116, 116, 115, 117, 115, 117, 116, 117,
115, 118, 114, 121, 97, 66, 67, 59, 58, 52, 51, 48, 46, 43, 40, 38, 36, 34, 32,
30, 29, 27, 25, 23, 22, 20, 18, 18, 16, 14, 13, 12, 11, 10, 9, 7, 7, 6, 4, 3, 3,
1, 1, 1, 0, -1, -2, -3, -3, -4, -4, -5, -5, -5, -6, -7, -7, -7, -7, -8, -8, -9,
-10, -10, -10, -10, -10, -11, -11, -11, -12, -12, -12, -12, -12, -13, -12, -13,
-12, -13, -13, -13, -13, -13, -13, -14, -14, -13, -14, -14, -14, -13, -14, -13,
-14, -14, -14, -14, -14, -13, -13, -13, -13, -14, -13, -13, -13, -12, -12, -12,
-13, -12, -12, -12, -12, -12, -12, -12, -12, -11, -11, -12, -11, -11, -11, -10,
-11, -10, -11, -10, -10, -9, -10, -9, -9, -9, -8, -8, -7, -7, -7, -7, -7, -6,
-6, -6, -5, -5, -6, -4, -4, -4, -4, -4, -3, -3, -3, -2, -2, -2, -1, -1, -1, -1,
0, 0, 1, 0, 1, 1, 2, 2, 2, 3, 2, 2, 4, 4, 4, 4, 4, 4, 5, 5, 5, 6, 5, 6, 6, 6, 7,
7, 7, 7, 8, 8, 8, 7, 8, 9, 8, 8, 9, 9, 10, 9, 9, 10, 9, 11, 11, 11, 11, 12, 12,
12, 12, 12, 13, 12, 13, 13, 14, 13, 13, 14, 14, 14, 15, 15, 15, 15, 16, 14, 16,
15, 16, 16, 17, 16, 17, 17, 17, 17, 17, 17, 18, 18, 19, 19, 19, 19, 20, 19, 19,
20, 18, 22, 18, 25, -4, -30, -29, -38, -37, -44, -45, -48, -50, -53, -54, -57,
-59, -61, -63, -65, -67, -68, -70, -72, -73, -75, -76, -77, -79, -80, -81, -82,
-83, -84, -86, -86, -87, -87, -89, -89, -90, -91, -91, -93, -93, -93, -94, -94,
-95, -96, -96, -96, -97, -97, -98, -98, -98, -99, -99, -99, -99, -100, -100,
-100, -101, -101, -102, -101, -101, -101, -102, -101, -102, -103, -102, -102,
-102, -102, -103, -103, -102, -101, -102, -103, -102, -103, -102, -102, -102,
-102, -102, -102, -102, -102, -102, -101, -102, -102, -102, -101, -101, -101,
-101, -100, -101, -100, -100, -100, -101, -99, -99, -99, -100, -99, -99, -98,
-98, -99, -97, -97, -97, -97, -96, -96, -96, -96, -96, -96, -95, -96, -94, -96,
-94, -94, -93, -93, -93, -93, -92, -91, -92, -91, -92, -90, -91, -88, -91, -87,
-91, -84, -95, -51, };