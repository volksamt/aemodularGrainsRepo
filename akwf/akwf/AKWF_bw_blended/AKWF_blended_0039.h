#define DATA_LENGTH 512
#define DATA AKWF_blended_0039

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 60, 55, 58, 56, 57, 59, 59, 61, 60,
63, 62, 64, 63, 65, 65, 66, 66, 68, 67, 69, 69, 69, 70, 71, 72, 72, 74, 73, 74,
75, 76, 76, 77, 78, 79, 79, 80, 80, 81, 81, 82, 82, 84, 84, 85, 85, 85, 86, 87,
87, 89, 89, 89, 90, 90, 91, 91, 93, 92, 93, 94, 94, 94, 94, 95, 96, 97, 97, 98,
98, 98, 99, 99, 100, 99, 100, 101, 100, 101, 102, 102, 103, 102, 103, 104, 104,
105, 105, 105, 105, 105, 106, 106, 106, 107, 108, 107, 107, 108, 108, 108, 108,
109, 110, 109, 111, 110, 110, 109, 111, 111, 111, 110, 110, 111, 111, 110, 112,
111, 111, 113, 110, 113, 109, 114, 107, 118, 52, -6, 7, -1, 5, 2, 4, 2, 4, 2, 3,
3, 2, 2, 1, 2, 1, 1, 2, 2, 1, 1, 0, 1, 0, 0, 0, 0, -1, -1, -1, -2, -2, -2, -3,
-2, -3, -3, -4, -3, -4, -4, -4, -5, -6, -7, -6, -7, -7, -7, -7, -8, -9, -8, -9,
-9, -10, -11, -12, -12, -12, -13, -13, -14, -14, -15, -15, -16, -16, -17, -17,
-18, -18, -18, -18, -20, -20, -20, -21, -22, -23, -23, -24, -25, -25, -26, -27,
-27, -28, -28, -29, -30, -31, -30, -32, -32, -33, -34, -34, -35, -36, -37, -36,
-36, -38, -39, -40, -39, -42, -41, -43, -42, -44, -43, -45, -45, -46, -47, -47,
-48, -49, -49, -49, -52, -51, -55, -49, -60, 10, 62, 48, 56, 50, 53, 48, 51, 47,
48, 47, 47, 46, 45, 45, 43, 43, 43, 42, 41, 41, 39, 39, 38, 38, 37, 37, 35, 36,
34, 34, 33, 32, 32, 31, 31, 30, 29, 29, 28, 28, 26, 27, 25, 25, 24, 24, 24, 22,
22, 21, 21, 20, 20, 19, 19, 18, 18, 17, 16, 16, 16, 15, 15, 14, 13, 12, 12, 13,
12, 11, 11, 11, 10, 10, 9, 8, 7, 7, 7, 6, 6, 6, 6, 6, 5, 5, 4, 3, 4, 3, 3, 3, 2,
2, 2, 2, 1, 1, 0, 1, 1, 1, -1, 0, -1, 0, -1, -1, -3, -1, -2, -1, -2, -1, -2, -1,
-3, -3, -2, -2, -3, -3, -2, -3, 0, -6, 2, -74, -119, -107, -115, -109, -113,
-110, -113, -110, -112, -111, -112, -111, -111, -111, -111, -111, -110, -111,
-110, -111, -110, -111, -109, -109, -109, -109, -109, -108, -108, -108, -107,
-107, -107, -107, -106, -106, -105, -105, -105, -105, -105, -104, -104, -103,
-103, -102, -102, -102, -102, -101, -100, -100, -100, -100, -99, -98, -98, -97,
-98, -96, -96, -96, -96, -94, -95, -94, -93, -93, -93, -92, -91, -91, -90, -90,
-89, -89, -87, -88, -87, -86, -85, -85, -84, -84, -83, -82, -82, -82, -81, -80,
-79, -78, -78, -77, -77, -76, -76, -75, -74, -74, -73, -72, -71, -71, -71, -69,
-69, -68, -67, -67, -66, -66, -65, -65, -62, -63, -61, -62, -60, -62, -57, -60,
-56, -59, -54, -57, -51, };