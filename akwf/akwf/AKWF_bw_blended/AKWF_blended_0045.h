#define DATA_LENGTH 512
#define DATA AKWF_blended_0045

const PROGMEM int8_t DATA[DATA_LENGTH] = {47, 122, 118, 119, 119, 120, 119, 119,
119, 118, 120, 119, 119, 118, 119, 119, 120, 118, 120, 118, 119, 119, 119, 119,
120, 119, 119, 118, 118, 119, 119, 119, 119, 119, 118, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 119, 119, 119, 118,
119, 119, 119, 119, 118, 119, 119, 119, 119, 120, 119, 119, 119, 118, 119, 120,
119, 120, 120, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 120,
118, 120, 118, 123, 82, 28, 28, 28, 28, 29, 29, 28, 28, 29, 29, 28, 28, 28, 29,
29, 28, 29, 28, 29, 28, 28, 28, 28, 29, 28, 28, 28, 29, 28, 27, 29, 29, 29, 29,
29, 28, 28, 29, 28, 28, 28, 29, 28, 29, 28, 28, 28, 28, 28, 28, 28, 28, 29, 29,
28, 28, 28, 28, 28, 29, 28, 28, 29, 29, 28, 28, 29, 29, 28, 28, 29, 29, 29, 29,
28, 29, 28, 28, 29, 28, 28, 28, 28, 28, 29, 28, 28, 28, 28, 28, 28, 28, 28, 29,
29, 28, 29, 29, 28, 28, 28, 28, 29, 28, 28, 29, 28, 28, 29, 28, 28, 29, 28, 28,
28, 29, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 28, 29, 29, 29, 28, 28, 29, 29,
29, 29, 28, 28, 28, 28, 28, 29, 28, 28, 28, 29, 28, 29, 27, 29, 28, 29, 28, 29,
28, 29, 28, 28, 29, 28, 29, 28, 29, -58, -125, -117, -120, -118, -120, -119,
-119, -118, -120, -119, -120, -119, -119, -119, -119, -119, -118, -120, -119,
-120, -119, -120, -119, -119, -119, -120, -118, -119, -118, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -120, -118, -118, -119, -119, -119, -119, -120, -119, -119,
-119, -120, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -120, -118,
-120, -119, -119, -119, -120, -118, -121, -75, -26, -30, -28, -30, -28, -28,
-28, -28, -28, -28, -29, -28, -28, -27, -28, -28, -28, -28, -28, -28, -29, -29,
-28, -28, -28, -28, -29, -29, -28, -28, -29, -29, -28, -28, -29, -28, -29, -28,
-28, -28, -28, -28, -28, -28, -29, -28, -29, -28, -28, -28, -29, -28, -28, -29,
-29, -29, -28, -29, -27, -28, -28, -28, -28, -28, -28, -28, -29, -29, -29, -29,
-29, -28, -29, -28, -28, -28, -28, -28, -29, -29, -28, -29, -29, -28, -28, -29,
-28, -28, -28, -28, -28, -28, -29, -29, -28, -29, -28, -28, -28, -28, -28, -28,
-29, -28, -28, -29, -28, -27, -28, -28, -29, -29, -28, -28, -29, -29, -29, -28,
-28, -28, -28, -28, -28, -28, -28, -29, -29, -29, -29, -28, -28, -29, -29, -28,
-29, -28, -28, -28, -29, -28, -28, -29, -28, -29, -29, -28, -28, -28, -28, -28,
-28, -29, -28, -29, -28, -28, -27, -29, -28, -29, -28, -31, -24, };