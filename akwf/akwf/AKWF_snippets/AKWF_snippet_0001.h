#define DATA_LENGTH 512
#define DATA AKWF_snippet_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 12, 16, 20, 21, 21, 23, 27, 27,
30, 33, 34, 38, 42, 48, 54, 61, 65, 70, 75, 82, 88, 94, 98, 100, 101, 102, 100,
99, 97, 96, 93, 92, 92, 92, 91, 91, 89, 86, 84, 82, 80, 79, 76, 74, 73, 72, 71,
71, 73, 73, 73, 70, 68, 67, 68, 70, 74, 78, 80, 83, 84, 84, 82, 80, 80, 80, 82,
84, 87, 91, 96, 98, 101, 103, 103, 109, 121, 107, 52, -1, -16, -9, -7, -8, -9,
-8, -8, -10, -13, -15, -16, -19, -19, -19, -19, -20, -22, -23, -24, -25, -25,
-25, -23, -22, -21, -20, -20, -22, -22, -23, -24, -24, -22, -19, -15, -12, -11,
-10, -13, -15, -17, -19, -20, -20, -21, -23, -25, -27, -30, -33, -34, -36, -34,
-34, -33, -35, -36, -38, -39, -42, -42, -43, -44, -44, -44, -44, -46, -46, -47,
-49, -49, -51, -51, -51, -51, -49, -49, -51, -51, -53, -55, -55, -55, -56, -58,
-59, -59, -60, -60, -61, -62, -62, -63, -62, -60, -58, -56, -56, -56, -58, -58,
-58, -59, -58, -59, -60, -60, -60, -59, -57, -58, -59, -62, -63, -64, -64, -63,
-63, -62, -64, -65, -65, -66, -67, -65, -65, -64, -65, -66, -67, -67, -67, -65,
-64, -62, -62, -61, -60, -59, -58, -54, -52, -50, -48, -45, -39, -34, -29, -24,
-21, -21, -22, -22, -23, -25, -26, -28, -30, -29, -28, -28, -29, -30, -33, -34,
-34, -34, -33, -34, -37, -41, -44, -46, -45, -44, -42, -40, -38, -36, -34, -34,
-35, -36, -39, -39, -38, -36, -34, -33, -32, -34, -36, -34, -35, -34, -33, -35,
-36, -37, -37, -36, -33, -29, -25, -22, -19, -17, -17, -17, -16, -15, -13, -8,
-5, -1, 1, 4, 7, 10, 12, 15, 16, 18, 18, 18, 18, 15, 14, 13, 10, 9, 7, 5, 1, -2,
-5, -10, -12, -14, -15, -16, -17, -19, -19, -19, -18, -16, -14, -12, -9, -8, -5,
-3, 0, 2, 7, 10, 13, 14, 16, 17, 19, 19, 20, 19, 20, 20, 19, 21, 23, 26, 28, 29,
31, 31, 31, 31, 29, 29, 28, 29, 29, 32, 33, 36, 35, 35, 33, 33, 31, 29, 29, 27,
25, 26, 27, 27, 28, 26, 25, 21, 17, 13, 7, 4, 1, 0, -1, -1, -1, -2, -2, -2, -4,
-5, -6, -6, -7, -5, -3, 1, 5, 8, 12, 16, 20, 25, 28, 33, 36, 38, 39, 39, 39, 38,
39, 39, 38, 37, 36, 35, 33, 30, 26, 21, 16, 10, 6, 4, 2, 1, -1, -2, -3, -5, -5,
-5, -5, -4, -5, -6, -4, -5, -3, -3, -3, -2, -2, -3, -4, -3, -3, -1, 0, 1, 1, 0,
-2, -2, -1, 1, 3, 5, 6, 7, 8, 9, 11, 13, 16, 18, 20, 21, 23, 22, 24, 24, 25, 26,
28, 28, 27, 27, 27, 26, 25, 24, 23, 21, 18, 15, 12, 10, 9, 8, 8, 7, 5, 4, 0, -3,
-5, -5, -5, -4, -3, -3, -3, -2, 0, };