#define DATA_LENGTH 512
#define DATA AKWF_snippet_0035

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 2, 13, 20, 23, 28, 35, 40, 53, 60,
73, 84, 96, 103, 110, 118, 103, 109, 101, 91, 65, 49, 47, 30, 13, 7, -9, -21,
-33, -45, -59, -70, -81, -88, -97, -99, -92, -86, -76, -62, -29, -28, -21, -6,
5, 17, 27, 42, 45, 58, 64, 74, 75, 74, 83, 75, 68, 58, 46, 19, 7, 4, -16, -24,
-37, -44, -53, -58, -66, -69, -72, -75, -75, -73, -70, -66, -62, -52, -47, -44,
-36, -31, -30, -28, -26, -25, -24, -24, -25, -24, -7, -10, -6, 6, 10, 15, 24,
26, 23, 28, 32, 39, 39, 48, 52, 60, 68, 79, 86, 91, 102, 101, 99, 92, 88, 71,
47, 50, 38, 25, 12, 0, -11, -23, -35, -47, -57, -67, -82, -83, -85, -86, -85,
-71, -58, -65, -43, -34, -21, -7, 4, 17, 26, 38, 47, 58, 64, 75, 81, 79, 75, 77,
61, 46, 42, 33, 16, 5, -8, -19, -29, -38, -46, -52, -61, -66, -67, -70, -68,
-68, -66, -63, -56, -53, -50, -45, -38, -34, -29, -25, -23, -20, -18, -17, -19,
-18, -10, -9, 5, 9, 14, 18, 20, 25, 28, 32, 33, 40, 44, 52, 58, 69, 72, 85, 96,
97, 99, 100, 97, 84, 75, 72, 56, 43, 31, 17, 6, -9, -18, -33, -41, -57, -68,
-76, -83, -90, -93, -89, -90, -90, -81, -72, -61, -47, -36, -11, 1, 5, 27, 37,
44, 58, 65, 71, 78, 82, 80, 78, 76, 72, 60, 51, 36, 22, 8, -6, -17, -30, -39,
-49, -54, -61, -65, -69, -71, -68, -62, -62, -56, -48, -39, -28, -17, -3, 6, 22,
34, 33, 40, 45, 51, 51, 54, 54, 53, 54, 51, 49, 46, 43, 40, 40, 33, 34, 31, 35,
39, 40, 44, 45, 48, 54, 51, 48, 47, 45, 35, 28, 17, 9, 0, -6, -15, -29, -31,
-40, -51, -59, -66, -70, -82, -88, -84, -90, -90, -88, -80, -72, -61, -48, -34,
-20, -5, 10, 22, 36, 45, 58, 62, 73, 78, 82, 84, 83, 80, 73, 68, 54, 47, 26, 3,
2, -15, -25, -36, -45, -52, -59, -65, -72, -71, -74, -71, -69, -63, -57, -48,
-41, -28, -19, -8, 2, 13, 22, 29, 35, 41, 49, 49, 51, 51, 52, 50, 48, 46, 44,
41, 35, 35, 30, 30, 32, 31, 30, 33, 39, 35, 40, 42, 42, 40, 36, 30, 21, 14, 7,
0, -6, -13, -20, -28, -36, -41, -49, -56, -64, -71, -77, -81, -83, -83, -79,
-75, -66, -41, -42, -27, -13, -4, 13, 20, 35, 44, 56, 63, 70, 76, 85, 85, 87,
86, 83, 76, 67, 60, 46, 32, 20, 6, -8, -19, -29, -40, -54, -55, -63, -68, -72,
-73, -71, -72, -59, -59, -56, -44, -38, -30, -22, -11, -2, 6, 15, 24, 30, 31,
39, 39, 43, 42, 43, 42, 40, 42, 35, 41, 9, -8, -19, -34, -42, -53, -57, -58,
-61, -61, -64, -66, -68, -81, -83, -86, -95, -100, -106, -110, -110, -111, -99,
-91, -66, -49, -15, };