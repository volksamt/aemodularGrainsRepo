#define DATA_LENGTH 512
#define DATA AKWF_snippet_0028

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 11, 17, 18, 13, 12, 17, 31, 46, 55,
60, 68, 78, 87, 85, 75, 67, 63, 65, 73, 81, 85, 80, 75, 79, 91, 101, 108, 116,
119, 110, 89, 67, 58, 71, 91, 104, 103, 96, 96, 100, 103, 101, 104, 108, 109,
102, 92, 85, 82, 83, 87, 92, 98, 104, 110, 104, 87, 69, 58, 52, 51, 55, 68, 80,
80, 78, 83, 94, 96, 88, 78, 68, 63, 63, 72, 78, 73, 64, 62, 72, 81, 82, 75, 61,
44, 30, 23, 29, 44, 52, 50, 38, 28, 22, 17, 11, 11, 21, 38, 53, 62, 64, 60, 57,
60, 64, 59, 45, 31, 28, 34, 42, 47, 54, 61, 68, 74, 81, 86, 84, 72, 53, 38, 37,
43, 46, 38, 31, 32, 35, 31, 20, 16, 22, 35, 49, 61, 60, 44, 20, 11, 24, 46, 63,
57, 32, -2, -27, -35, -23, 3, 30, 49, 50, 41, 37, 41, 41, 35, 32, 35, 34, 21, 3,
-6, -4, 3, 10, 13, 6, -15, -39, -56, -66, -70, -66, -54, -39, -33, -37, -41,
-38, -32, -28, -28, -34, -44, -53, -51, -33, -12, -4, -15, -32, -39, -35, -28,
-28, -37, -49, -51, -40, -18, -2, 1, -6, -15, -25, -39, -53, -59, -55, -47, -45,
-48, -46, -33, -13, 0, -3, -16, -26, -28, -30, -28, -22, -13, -6, -3, 4, 13, 20,
23, 22, 15, -2, -19, -24, -15, -6, -6, -7, -4, 5, 15, 23, 28, 29, 27, 28, 34,
37, 41, 43, 40, 33, 27, 28, 35, 42, 41, 36, 38, 44, 58, 69, 68, 60, 51, 47, 52,
58, 59, 53, 46, 41, 48, 60, 64, 58, 49, 41, 38, 40, 49, 56, 55, 44, 34, 33, 37,
42, 46, 50, 48, 39, 28, 25, 27, 27, 27, 24, 21, 15, 12, 16, 20, 23, 22, 17, 12,
18, 4, -25, -21, -10, -1, 3, 5, 3, -3, -5, -2, 0, -1, -2, -2, 3, 4, 3, 3, 5, 3,
-1, -8, -12, -16, -17, -15, -8, -5, -6, -8, -13, -18, -19, -13, -7, -8, -13,
-17, -17, -15, -16, -17, -19, -22, -26, -28, -30, -33, -37, -41, -44, -44, -43,
-41, -41, -45, -46, -45, -43, -42, -40, -40, -44, -50, -55, -55, -54, -56, -60,
-65, -68, -73, -78, -79, -81, -81, -80, -81, -83, -85, -85, -79, -68, -57, -54,
-60, -73, -85, -88, -85, -81, -80, -79, -75, -69, -65, -62, -62, -63, -63, -64,
-64, -63, -66, -74, -86, -95, -93, -80, -65, -56, -59, -67, -74, -80, -84, -87,
-86, -83, -87, -91, -91, -84, -77, -76, -83, -88, -92, -94, -93, -87, -79, -69,
-67, -72, -76, -73, -68, -67, -78, -92, -103, -102, -88, -68, -50, -47, -54,
-64, -73, -82, -95, -106, -108, -102, -95, -89, -86, -77, -66, -61, -65, -67,
-67, -66, -73, -83, -87, -81, -74, -72, -70, -70, -71, -67, -58, -48, -46, -52,
-55, -51, -44, -32, -20, -13, -17, -28, -37, -37, -33, -25, -14, -2, -2, -11,
-19, -17, -7, };