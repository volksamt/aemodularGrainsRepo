#define DATA_LENGTH 512
#define DATA AKWF_snippet_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 17, 21, 33, 38, 43, 46, 46, 59, 60,
58, 66, 71, 74, 81, 104, 119, 113, 97, 86, 93, 93, 102, 108, 105, 106, 102, 99,
98, 96, 98, 94, 90, 85, 87, 87, 85, 82, 79, 80, 82, 82, 77, 77, 76, 73, 74, 72,
73, 71, 68, 63, 60, 55, 46, 41, 36, 32, 28, 23, 19, 14, 10, 10, 7, 4, 2, 2, 0,
-1, -2, -5, -5, -7, -9, -10, -10, -10, -8, -8, -7, -6, -5, -3, 0, 3, 10, 13, 16,
22, 27, 30, 29, 25, 24, 24, 21, 11, 4, 4, -7, -25, -41, -49, -42, -41, -55, -70,
-82, -87, -94, -94, -100, -104, -105, -101, -99, -98, -99, -95, -94, -91, -88,
-85, -85, -82, -80, -80, -77, -79, -72, -86, -18, 12, -2, 12, 7, 15, 11, 17, 19,
24, 23, 26, 29, 35, 33, 34, 39, 39, 39, 42, 39, 39, 43, 40, 39, 39, 43, 39, 36,
36, 40, 39, 41, 40, 38, 43, 39, 37, 42, 41, 39, 40, 41, 38, 40, 37, 27, 26, 27,
25, 19, 21, 20, 19, 20, 17, 20, 23, 29, 27, 29, 30, 25, 26, 25, 29, 31, 25, 22,
27, 31, 20, 24, 29, 21, 31, 27, 16, 30, 29, 17, 26, 26, 20, 22, 22, 21, 15, 15,
12, 13, 13, 4, 10, 12, 6, 1, 6, 8, -2, -5, -2, -7, -12, -11, -10, -5, -7, -13,
-8, -14, -12, -8, -17, -11, -12, -16, -13, -19, -24, -18, -20, -21, -20, -20,
-16, -14, -17, -17, -20, -19, -20, -21, -19, -20, -16, -16, -18, -15, -13, -12,
-14, -17, -18, -18, -21, -21, -21, -23, -24, -22, -20, -22, -21, -24, -21, -20,
-21, -21, -18, -19, -20, -20, -21, -18, -17, -16, -13, -13, -12, -12, -10, -8,
-6, -5, -11, -16, -20, -23, -26, -25, -23, -20, -15, -15, -11, -8, -5, -6, -7,
-7, -9, -11, -10, -7, -5, 1, 8, 13, 10, 8, 6, 2, 5, 8, 12, 18, 19, 21, 14, 11,
10, 18, 22, 18, 22, 27, 32, 34, 40, 39, 34, 38, 42, 44, 39, 36, 44, 37, 35, 47,
45, 45, 45, 43, 47, 51, 52, 49, 45, 37, 28, 30, 33, 31, 29, 23, 12, 12, 5, -13,
-25, -31, -29, -36, -37, -40, -43, -45, -57, -62, -63, -61, -63, -66, -66, -58,
-56, -55, -55, -64, -58, -58, -54, -61, -79, -83, -90, -83, -82, -68, -62, -57,
-14, 20, 21, -19, -37, -24, -15, -13, -25, -25, -17, -28, -42, -35, -42, 0, 60,
16, -33, 10, 43, -26, -64, -72, -68, 21, 50, 35, 34, 26, 36, 35, 38, 30, 27, 30,
26, 22, 14, 17, 14, 14, 13, 8, 9, 3, 1, -6, -10, -11, -11, -27, -75, -103, -99,
-99, -92, -91, -99, -100, -98, -94, -92, -89, -85, -84, -82, -81, -78, -78, -77,
-75, -73, -72, -74, -71, -74, -35, 20, 23, 22, -8, -57, -63, -62, -63, -59, -62,
-63, -59, -55, -46, -34, -30, -18, -6, -2, };