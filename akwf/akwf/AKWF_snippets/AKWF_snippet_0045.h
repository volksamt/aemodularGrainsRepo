#define DATA_LENGTH 512
#define DATA AKWF_snippet_0045

const PROGMEM int8_t DATA[DATA_LENGTH] = {19, 47, 66, 83, 96, 105, 109, 113,
114, 114, 113, 116, 112, 108, 108, 110, 106, 106, 104, 100, 96, 93, 92, 88, 87,
85, 81, 77, 75, 73, 72, 70, 67, 65, 64, 63, 62, 61, 61, 61, 62, 63, 61, 58, 58,
58, 55, 52, 50, 48, 48, 47, 46, 46, 46, 42, 41, 40, 41, 39, 39, 39, 37, 39, 40,
38, 39, 39, 36, 34, 33, 32, 32, 32, 29, 27, 25, 24, 20, 17, 16, 17, 16, 16, 17,
13, 13, 14, 13, 11, 11, 9, 8, 8, 7, 9, 5, 4, 7, 5, 5, 4, 5, 4, 0, -1, -2, -2,
-4, -2, -2, -3, -4, -5, -7, -7, -6, -8, -12, -11, -12, -14, -17, -17, -18, -21,
-22, -19, -20, -22, -22, -24, -23, -24, -24, -24, -24, -24, -23, -26, -26, -27,
-28, -26, -23, -22, -22, -23, -22, -22, -23, -25, -25, -24, -24, -26, -27, -27,
-29, -28, -29, -28, -27, -28, -27, -28, -30, -31, -31, -33, -37, -36, -37, -38,
-35, -37, -38, -37, -39, -44, -46, -45, -46, -48, -50, -51, -52, -54, -52, -50,
-52, -53, -51, -50, -52, -53, -51, -49, -51, -51, -52, -53, -50, -51, -52, -50,
-49, -48, -38, -16, 13, 43, 68, 85, 98, 107, 111, 115, 117, 117, 119, 119, 117,
118, 118, 117, 115, 113, 112, 109, 106, 103, 101, 101, 98, 95, 92, 92, 91, 89,
87, 82, 83, 82, 81, 80, 75, 72, 71, 72, 73, 72, 72, 68, 67, 68, 65, 63, 62, 59,
58, 57, 55, 55, 56, 55, 50, 52, 50, 47, 46, 46, 43, 40, 38, 38, 35, 35, 30, 28,
30, 26, 26, 23, 21, 21, 20, 18, 17, 17, 15, 15, 16, 18, 20, 16, 13, 15, 18, 16,
15, 17, 16, 15, 12, 14, 13, 12, 13, 13, 11, 9, 11, 12, 5, 3, 5, 3, 1, 2, 0, -4,
-6, -3, -6, -7, -5, -6, -10, -12, -13, -16, -16, -17, -19, -21, -21, -20, -20,
-21, -21, -22, -21, -20, -21, -22, -22, -22, -23, -27, -29, -27, -29, -27, -24,
-22, -25, -27, -27, -27, -28, -29, -31, -29, -27, -27, -27, -27, -26, -26, -29,
-30, -28, -29, -26, -26, -30, -31, -31, -33, -39, -42, -39, -38, -36, -36, -37,
-38, -38, -39, -43, -43, -44, -45, -46, -48, -49, -51, -53, -49, -50, -52, -49,
-47, -47, -50, -51, -48, -50, -49, -50, -51, -47, -48, -50, -50, -47, -49, -48,
-50, -53, -51, -47, -49, -51, -52, -52, -55, -55, -53, -53, -52, -52, -50, -51,
-51, -52, -53, -53, -53, -52, -52, -53, -52, -52, -51, -52, -49, -48, -48, -47,
-49, -49, -46, -46, -47, -47, -50, -51, -48, -48, -49, -47, -49, -50, -48, -50,
-51, -51, -52, -52, -51, -52, -53, -51, -52, -55, -55, -54, -57, -58, -59, -58,
-60, -62, -62, -63, -64, -65, -67, -64, -67, -67, -68, -69, -70, -70, -68, -67,
-66, -67, -67, -64, -61, -58, -61, -62, -61, -58, -50, -33, -6, };