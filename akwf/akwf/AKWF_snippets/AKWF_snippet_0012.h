#define DATA_LENGTH 512
#define DATA AKWF_snippet_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 12, 16, 18, 20, 26, 31, 34,
35, 36, 40, 41, 41, 44, 50, 56, 58, 61, 63, 66, 67, 68, 68, 69, 70, 70, 69, 70,
69, 70, 71, 71, 73, 73, 74, 73, 73, 74, 74, 73, 71, 71, 71, 71, 70, 71, 71, 71,
70, 69, 69, 69, 69, 69, 68, 68, 66, 67, 66, 65, 67, 69, 67, 65, 63, 62, 63, 62,
62, 62, 61, 62, 63, 62, 61, 60, 61, 63, 60, 57, 58, 59, 58, 58, 59, 58, 57, 56,
56, 55, 55, 56, 55, 55, 54, 54, 55, 54, 52, 54, 60, 60, 58, 54, 47, 40, 36, 41,
49, 48, 44, 45, 48, 45, 44, 50, 53, 46, 41, 47, 48, 31, 15, 25, 54, 62, 37, 7,
6, 27, 55, 75, 71, 32, -13, -20, 17, 50, 40, 9, -6, 5, 18, 18, 9, 1, 0, 4, 6,
-2, -17, -24, -18, -10, -10, -12, -10, -1, 0, -9, -29, -45, -42, -21, -7, -13,
-38, -61, -63, -41, -8, 2, -28, -65, -67, -36, -23, -49, -75, -65, -42, -50,
-75, -82, -73, -73, -85, -81, -60, -50, -67, -87, -89, -86, -95, -102, -95, -77,
-75, -92, -109, -104, -86, -78, -81, -89, -99, -113, -118, -107, -81, -71, -87,
-120, -84, -28, -31, -27, -25, -19, -15, -11, -10, -7, -4, -1, 0, 1, 2, 3, 4, 5,
6, 7, 7, 7, 7, 7, 8, 8, 10, 10, 12, 12, 12, 11, 12, 13, 15, 16, 17, 18, 19, 20,
20, 22, 24, 27, 28, 30, 31, 30, 29, 30, 32, 34, 34, 35, 35, 35, 36, 36, 37, 37,
39, 40, 40, 39, 39, 39, 38, 37, 37, 37, 37, 36, 36, 37, 36, 36, 35, 36, 34, 32,
32, 32, 31, 31, 29, 30, 28, 26, 26, 26, 24, 21, 19, 19, 18, 16, 13, 12, 12, 9,
7, 5, 5, 2, 1, -1, -3, -4, -5, -5, -6, -10, -11, -13, -16, -16, -17, -18, -19,
-19, -20, -23, -24, -24, -24, -26, -29, -32, -34, -35, -38, -41, -42, -44, -44,
-45, -49, -49, -51, -52, -51, -50, -50, -51, -54, -54, -53, -52, -54, -54, -55,
-56, -57, -57, -58, -56, -55, -53, -50, -45, -43, -39, -34, -29, -22, -19, -14,
-10, -5, -3, -1, 1, 4, 8, 12, 17, 21, 25, 33, 39, 45, 49, 54, 58, 63, 66, 70,
73, 75, 78, 79, 81, 82, 82, 80, 79, 76, 73, 69, 64, 55, 48, 41, 32, 23, 10, -1,
-11, -19, -27, -32, -38, -44, -51, -55, -60, -65, -70, -72, -75, -76, -76, -79,
-80, -81, -82, -84, -86, -87, -87, -86, -88, -89, -88, -89, -89, -89, -88, -88,
-88, -88, -88, -86, -85, -84, -86, -85, -84, -80, -80, -80, -79, -77, -75, -72,
-73, -71, -70, -68, -66, -64, -62, -61, -59, -56, -56, -55, -56, -55, -53, -51,
-49, -50, -49, -46, -44, -42, -41, -41, -38, -36, -34, -31, -31, -30, -30, -29,
-25, -21, -17, -13, -9, -6, -5, -4, -2, };