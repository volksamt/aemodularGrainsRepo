#define DATA_LENGTH 512
#define DATA AKWF_snippet_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 25, 37, 49, 36, 28, 46, 42, 50, 72,
67, 54, 64, 66, 71, 81, 84, 74, 65, 69, 75, 83, 88, 85, 82, 73, 71, 70, 73, 71,
56, 55, 52, 47, 45, 47, 41, 43, 41, 45, 37, 25, 42, 55, 67, 72, 68, 62, 62, 60,
64, 67, 64, 64, 49, 47, 50, 64, 49, 33, 45, 59, 54, 54, 43, 35, 20, -12, 20, 20,
14, -9, -40, -49, -48, -65, -66, -57, -85, -89, -86, -82, -88, -79, -73, -68,
-61, -49, -47, -52, -45, -41, -28, -22, -31, -33, -33, -29, -26, -32, -29, -27,
-15, -18, -17, -12, -8, 3, 24, 20, 9, 20, 22, 16, -14, 6, 19, 0, -21, -19, -26,
-14, 7, -13, -19, -9, 7, 11, 42, 50, 61, 60, 64, 81, 85, 88, 86, 82, 63, 60, 63,
72, 78, 73, 62, 73, 80, 79, 68, 62, 70, 71, 75, 63, 62, 56, 53, 42, 34, 24, 32,
12, 12, 21, 21, 21, 19, 24, 15, 25, 32, 45, 27, 38, 32, 36, 13, 8, 18, 17, -8,
-48, -54, -59, -62, -81, -67, -74, -74, -80, -69, -65, -41, -22, -46, -67, -49,
-67, -106, -96, -101, -100, -113, -117, -119, -107, -107, -91, -74, -76, -69,
-77, -74, -77, -67, -54, -62, -71, -54, -21, -25, -45, -51, -39, -37, -10, -6,
-2, -3, -1, 12, 8, 10, 5, 26, 31, 35, 30, 2, -47, -32, -9, -21, -11, -10, -17,
-27, -49, -61, -48, -26, -7, -3, -7, -37, -21, 8, 27, 40, 51, 34, 1, 3, 16, 23,
28, 38, 50, 67, 75, 78, 71, 65, 37, 33, 29, 37, 61, 62, 71, 76, 82, 82, 78, 64,
65, 66, 63, 64, 56, 51, 49, 46, 46, 47, 33, 31, 31, 45, 60, 64, 67, 70, 71, 78,
81, 73, 76, 79, 72, 68, 71, 69, 68, 64, 68, 63, 63, 62, 53, 55, 53, 52, 47, 49,
47, 44, 26, 27, -3, -23, -29, -28, -28, -58, -64, -88, -91, -98, -103, -103,
-102, -98, -93, -86, -90, -83, -78, -82, -76, -72, -79, -77, -71, -67, -64, -69,
-75, -69, -64, -64, -61, -66, -59, -48, -41, -41, -45, -46, -55, -57, -55, -56,
-65, -64, -71, -72, -67, -63, -64, -71, -63, -59, -32, -36, -38, -28, -17, 6,
33, 28, 15, 43, 37, 53, 57, 56, 63, 64, 65, 68, 77, 76, 75, 71, 73, 76, 72, 69,
64, 62, 59, 50, 49, 41, 39, 30, 17, 10, 7, 3, -3, -6, -8, -7, -5, 1, -1, 1, 7,
15, 21, 24, 22, 16, 14, 20, 25, 26, 22, 15, 13, 13, 14, 12, 10, 11, 16, 21, 27,
13, -3, -10, -18, -26, -25, -16, -61, -95, -90, -74, -74, -76, -62, -95, -98,
-86, -86, -90, -94, -96, -92, -84, -77, -73, -81, -76, -72, -65, -67, -70, -66,
-65, -64, -61, -55, -57, -58, -55, -46, -49, -51, -48, -50, -57, -51, -49, -60,
-58, -57, -62, -59, -44, -55, -50, -36, -28, -19, -17, -16, -32, -11, };