#define DATA_LENGTH 512
#define DATA AKWF_snippet_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {32, 51, 63, 64, 60, 67, 77, 86, 87,
91, 87, 85, 90, 105, 119, 110, 84, 82, 95, 94, 82, 66, 54, 59, 71, 69, 60, 50,
48, 61, 58, 37, 28, 28, 37, 36, 23, 31, 43, 37, 36, 42, 53, 55, 60, 73, 68, 71,
88, 96, 96, 87, 81, 80, 73, 58, 47, 33, 21, 21, 19, 9, -14, -31, -40, -54, -69,
-78, -82, -84, -94, -98, -92, -89, -83, -66, -61, -64, -63, -51, -50, -58, -50,
-38, -28, -27, -25, -13, -9, -11, -14, -11, -9, -7, -3, -5, -10, -10, -11, -5,
-3, -6, 5, 16, 15, 22, 31, 31, 33, 37, 42, 41, 36, 36, 31, 25, 18, 18, 22, 16,
2, -8, -20, -40, -56, -70, -81, -85, -93, -98, -96, -98, -101, -100, -100, -94,
-88, -83, -76, -73, -62, -41, -31, -30, -24, -8, -2, 3, 18, 23, 18, 18, 23, 30,
35, 30, 26, 20, 9, 9, 15, 14, 13, 18, 27, 33, 30, 29, 29, 26, 27, 25, 29, 29,
21, 15, 18, 19, 22, 20, 11, -1, -12, -23, -31, -40, -48, -52, -57, -61, -60,
-57, -57, -58, -62, -62, -65, -65, -60, -56, -52, -45, -33, -23, -24, -17, -6,
2, 8, 6, 8, 14, 15, 14, 12, 8, 8, 13, 17, 12, 5, 6, 10, 10, 2, -1, 4, 3, 0, -5,
-7, 1, 9, 19, 26, 26, 30, 37, 36, 35, 35, 37, 35, 28, 24, 29, 33, 32, 28, 21,
13, 6, -5, -15, -22, -26, -21, -15, -13, -16, -14, -5, -1, -1, -3, -3, 0, 3, 5,
11, 20, 25, 33, 38, 36, 39, 46, 50, 51, 46, 44, 48, 51, 55, 49, 39, 36, 39, 40,
37, 30, 29, 32, 34, 35, 28, 27, 26, 26, 31, 26, 21, 29, 35, 36, 34, 30, 27, 26,
21, 10, 4, 1, -5, -5, -8, -16, -22, -25, -26, -29, -35, -46, -47, -44, -42, -37,
-29, -20, -13, -7, -1, 3, 6, 9, 9, 9, 9, 18, 27, 25, 23, 29, 31, 24, 13, 7, 2,
4, 10, 5, -5, -7, 9, 19, 16, 10, 9, 13, 13, 12, 9, 2, 9, 24, 32, 31, 33, 45, 57,
62, 71, 82, 85, 87, 97, 103, 94, 87, 91, 85, 67, 51, 45, 40, 29, 24, 16, -3,
-28, -43, -57, -78, -93, -94, -90, -97, -103, -98, -93, -92, -92, -85, -83, -86,
-83, -77, -78, -78, -72, -62, -55, -51, -46, -41, -46, -48, -40, -30, -26, -26,
-24, -22, -25, -21, -16, -15, -15, -10, -1, 8, 14, 24, 29, 32, 37, 36, 37, 38,
34, 35, 34, 30, 31, 27, 22, 14, 0, -14, -27, -44, -56, -68, -80, -86, -90, -92,
-95, -102, -106, -105, -106, -104, -101, -95, -92, -90, -81, -72, -70, -69, -61,
-52, -46, -38, -30, -27, -24, -16, -9, -9, -15, -17, -15, -18, -21, -20, -17,
-13, -7, 0, 1, 0, 0, 2, 5, 2, 4, 7, 8, 7, 12, 19, 21, 18, 14, 7, 3, -3, -2, -8,
-14, };