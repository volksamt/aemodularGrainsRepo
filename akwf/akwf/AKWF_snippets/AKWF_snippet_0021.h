#define DATA_LENGTH 512
#define DATA AKWF_snippet_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 23, 49, 72, 80, 79, 83, 102, 104,
89, 84, 76, 79, 61, 48, 46, 38, 33, 30, 23, 9, -4, -10, -7, 1, -8, -25, -26,
-20, -18, -13, -8, -15, -18, -9, 0, -9, -18, -13, -18, -24, -21, -23, -29, -34,
-29, -31, -39, -33, -43, -56, -49, -40, -44, -59, -66, -74, -75, -64, -54, -46,
-44, -48, -51, -50, -45, -31, -23, -22, -25, -24, -15, -4, 2, 12, 28, 41, 58,
67, 64, 58, 61, 76, 67, 63, 57, 56, 61, 52, 56, 59, 63, 67, 65, 62, 52, 44, 49,
48, 49, 38, 31, 38, 39, 40, 42, 37, 27, 27, 32, 32, 19, 19, 22, 20, 22, 27, 22,
17, 17, 19, 17, 8, 3, -11, -15, -13, -12, -24, -51, -71, -81, -87, -91, -94,
-91, -94, -101, -101, -101, -96, -83, -72, -71, -65, -58, -49, -43, -36, -29,
-22, -3, 9, 16, 16, 16, 28, 35, 34, 38, 35, 44, 41, 29, 26, 23, 22, 19, 19, 19,
9, 7, 17, 27, 34, 33, 38, 44, 52, 55, 51, 45, 30, 31, 31, 25, 17, 20, 25, 35,
39, 44, 46, 40, 44, 48, 44, 37, 32, 7, 5, 8, 8, -6, -25, -31, -22, -21, -12, -2,
1, 7, -4, -5, -14, -13, -13, -24, -37, -46, -56, -54, -50, -48, -31, -18, 7, 24,
34, 33, 32, 43, 35, 31, 19, 9, 10, -6, -14, -15, -22, -20, -25, -27, -34, -51,
-47, -55, -45, -45, -57, -43, -37, -33, -20, -11, -18, -9, 2, 11, 15, 10, 18,
18, 14, 14, 17, 9, 11, 7, 5, 11, 7, 3, 1, 15, 22, 14, 5, -4, -7, -7, -4, -1, 6,
11, 9, 4, -2, 7, 15, 3, -5, -7, -25, -11, -16, -10, -5, 13, 59, 62, 76, 67, 48,
16, -31, -53, -65, -106, -119, -107, -106, -110, -111, -88, -68, -39, -2, 33,
53, 90, 107, 87, 65, 47, 18, -26, -32, -20, -41, -49, -39, -17, -5, 5, 27, 17,
27, 40, 44, 29, 15, -5, -29, -29, -28, -26, -13, -11, -22, -21, -21, -21, -12,
-3, -1, -6, -8, 2, 6, 8, 17, 28, 47, 71, 79, 81, 86, 87, 87, 70, 55, 33, 35, 28,
4, -4, -9, -9, -2, 2, 8, 7, 3, 17, 28, 26, 7, -15, -16, -21, -35, -44, -70, -88,
-88, -77, -67, -66, -53, -30, -21, 2, 20, 16, 23, 21, 21, 12, 19, 13, -10, -12,
-12, -15, -32, -53, -69, -78, -68, -55, -44, -28, -24, -21, -15, -10, -3, 20,
34, 32, 27, 23, 27, 28, 23, 22, 16, 27, 44, 38, 34, 33, 53, 59, 57, 51, 37, 45,
31, 18, 24, 20, 10, 14, 10, 4, -14, -21, -17, -22, -16, -26, -28, -18, -13, -3,
0, -4, -3, -2, 11, 23, 11, 9, 11, 0, 9, 14, 2, -7, -16, -20, -30, -22, -30, -44,
-30, -15, -16, -32, -43, -42, -41, -38, -34, -33, -27, -32, -35, -45, -45, -39,
-29, -31, -39, -43, -40, -27, -28, -13, };