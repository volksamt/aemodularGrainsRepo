#define DATA_LENGTH 512
#define DATA AKWF_snippet_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 9, 11, 12, 20, 40, 34, 68, 103,
100, 114, 120, 111, 106, 103, 91, 73, 38, 12, 2, -16, -16, -14, -14, -8, -14,
-12, -9, -10, -4, 21, 36, 27, 38, 40, 29, 43, 44, 31, 29, 9, -10, -33, -46, -57,
-72, -80, -82, -78, -62, -27, -22, 13, 46, 49, 54, 56, 54, 43, 26, 9, -1, -29,
-42, -40, -50, -55, -49, -50, -44, -41, -43, -37, -33, -33, -32, -18, -9, 0, 7,
10, 10, 8, -4, -23, -37, -52, -60, -61, -62, -42, -31, -22, 11, 20, 41, 57, 61,
58, 35, 22, 12, -5, -22, -26, -29, -35, -43, -45, -39, -37, -41, -52, -50, -57,
-66, -60, -42, -18, -2, 20, 49, 51, 55, 65, 67, 74, 63, 48, 30, 6, -13, -20,
-31, -43, -50, -47, -54, -61, -63, -42, -9, -12, 12, 36, 32, 39, 43, 40, 34, 30,
34, 22, -2, -4, -14, -29, -36, -41, -46, -57, -73, -61, -44, -39, -35, -19, 5,
5, 4, 16, 25, 11, 2, 11, -7, -19, -25, -27, -37, -48, -47, -56, -48, -29, -38,
-34, -15, -25, -16, -15, -30, -26, -34, -36, -29, -27, -10, 32, 47, 51, 69, 65,
64, 65, 62, 41, 2, -18, -28, -37, -46, -47, -46, -52, -36, -19, -16, -10, -6,
-1, 0, -12, -5, -6, -11, -2, 9, 29, 35, 40, 66, 70, 61, 72, 78, 55, 41, 23, 6,
-11, -21, -12, -16, -6, -2, 19, 33, 37, 44, 42, 29, 25, 27, 17, 16, 8, 13, 28,
34, 36, 31, 26, 21, 8, -8, -19, -27, -18, -20, -27, -20, 6, 39, 70, 73, 90, 88,
87, 77, 18, 13, -8, -20, -19, -27, -42, -61, -59, -33, -32, -29, -7, -2, -11,
-27, -8, 10, 21, 18, 33, 30, 20, 33, 42, 33, 12, 13, -16, -20, -19, -25, -21,
-12, -14, -24, -11, -18, -30, -33, -32, -26, -23, -24, -21, -23, -19, -13, -17,
-24, -21, -26, -51, -52, -62, -66, -67, -67, -47, -48, -22, -6, 8, 45, 52, 55,
56, 53, 44, 23, 5, -11, -22, -28, -47, -59, -71, -75, -76, -70, -58, -45, -35,
-16, 14, 18, 25, 48, 49, 51, 51, 39, 38, 18, 14, 0, -18, -37, -50, -54, -46,
-42, -41, -11, -3, 17, 55, 63, 64, 79, 67, 73, 73, 58, 43, 38, 24, -5, -21, -46,
-53, -68, -77, -80, -76, -81, -76, -61, -31, -18, -28, -1, 7, 15, 27, 24, 35,
43, 30, 17, 9, -7, -31, -58, -78, -88, -88, -82, -83, -85, -73, -60, -51, -25,
-5, 0, 5, 14, 17, 13, 16, 17, 5, -4, -8, -22, -37, -38, -48, -61, -54, -55, -55,
-44, -26, -2, 16, 33, 57, 61, 71, 72, 69, 57, 37, 35, 21, 0, 3, 5, 1, 27, 28,
32, 42, 26, 27, 24, 14, 11, 13, 14, 5, -4, 8, 12, 13, 16, 15, -2, 5, 28, 35, 59,
89, 82, 81, 100, 91, 89, 85, 76, 45, 10, -5, -13, -18, -11, -5, -7, -5, -1, };