#define DATA_LENGTH 512
#define DATA AKWF_snippet_0036

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 12, 18, 24, 29, 36, 43, 49, 56,
62, 68, 75, 80, 86, 91, 96, 101, 106, 110, 112, 116, 117, 118, 119, 118, 118,
118, 117, 115, 112, 109, 107, 103, 100, 96, 92, 88, 83, 80, 75, 70, 66, 61, 58,
53, 49, 43, 39, 34, 28, 23, 19, 13, 7, 2, -3, -9, -16, -21, -26, -32, -38, -43,
-48, -52, -56, -61, -64, -68, -71, -74, -76, -78, -80, -82, -83, -84, -84, -84,
-84, -84, -83, -82, -81, -79, -77, -75, -72, -70, -68, -64, -60, -56, -53, -51,
-47, -44, -40, -37, -33, -30, -26, -22, -18, -14, -11, -7, -3, 2, 6, 11, 14, 18,
22, 26, 30, 34, 37, 41, 44, 46, 49, 51, 53, 54, 54, 55, 55, 55, 54, 52, 51, 48,
46, 43, 41, 37, 35, 31, 28, 24, 19, 16, 12, 9, 5, 0, -3, -8, -12, -15, -20, -24,
-28, -32, -36, -40, -43, -47, -52, -54, -59, -62, -65, -68, -71, -73, -76, -78,
-80, -82, -83, -85, -85, -86, -87, -87, -87, -87, -86, -87, -86, -84, -83, -82,
-81, -79, -77, -76, -74, -72, -69, -66, -64, -62, -58, -54, -51, -48, -44, -39,
-35, -31, -26, -22, -18, -14, -9, -5, -1, 4, 8, 12, 17, 21, 25, 31, 34, 38, 42,
45, 49, 52, 55, 58, 60, 64, 65, 67, 69, 71, 72, 73, 74, 74, 74, 74, 74, 73, 72,
70, 69, 66, 64, 61, 58, 54, 52, 48, 45, 41, 37, 33, 30, 26, 23, 18, 14, 12, 8,
5, 1, -3, -6, -9, -12, -15, -18, -21, -24, -26, -29, -31, -33, -36, -37, -40,
-42, -43, -44, -46, -47, -48, -49, -50, -50, -50, -50, -50, -51, -49, -49, -49,
-48, -47, -45, -44, -43, -40, -38, -35, -32, -29, -27, -24, -21, -18, -13, -10,
-7, -4, 0, 4, 6, 11, 14, 18, 22, 24, 28, 31, 33, 37, 40, 43, 45, 47, 49, 51, 54,
56, 58, 59, 61, 62, 63, 65, 66, 66, 67, 68, 68, 68, 68, 68, 67, 67, 66, 64, 63,
62, 59, 58, 56, 54, 52, 49, 46, 43, 41, 38, 35, 33, 28, 26, 23, 20, 17, 14, 10,
7, 4, 1, -2, -5, -6, -10, -12, -15, -17, -19, -22, -23, -25, -26, -28, -31, -31,
-32, -35, -37, -39, -42, -45, -48, -49, -50, -51, -53, -52, -53, -53, -53, -53,
-51, -51, -49, -46, -44, -41, -37, -32, -28, -24, -19, -14, -7, -3, 2, 8, 13,
17, 23, 28, 32, 36, 40, 44, 47, 50, 52, 54, 57, 58, 58, 59, 60, 60, 61, 61, 60,
60, 58, 58, 57, 55, 55, 52, 50, 49, 46, 44, 41, 38, 34, 32, 28, 25, 21, 17, 13,
9, 4, -1, -7, -12, -19, -24, -30, -36, -43, -48, -54, -59, -64, -69, -74, -78,
-83, -85, -87, -90, -93, -94, -94, -94, -93, -92, -90, -87, -84, -83, -78, -74,
-71, -67, -63, -59, -54, -51, -46, -41, -38, -34, -29, -25, -20, -17, -12, -8,
-2, };