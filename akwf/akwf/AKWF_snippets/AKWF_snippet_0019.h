#define DATA_LENGTH 512
#define DATA AKWF_snippet_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 14, 27, 42, 55, 60, 59, 53, 50, 51,
56, 60, 60, 53, 41, 27, 17, 14, 16, 23, 28, 31, 35, 46, 60, 77, 85, 83, 77, 73,
71, 72, 73, 71, 69, 66, 65, 62, 61, 60, 63, 68, 73, 72, 71, 70, 75, 87, 98, 103,
99, 85, 73, 68, 74, 89, 107, 117, 119, 115, 108, 101, 94, 82, 70, 64, 64, 73,
83, 86, 84, 82, 83, 85, 88, 87, 85, 89, 97, 106, 111, 111, 108, 110, 112, 105,
90, 66, 40, 28, 31, 39, 47, 48, 44, 42, 42, 44, 44, 40, 34, 31, 30, 31, 32, 32,
34, 37, 41, 46, 49, 49, 45, 38, 31, 28, 27, 27, 24, 20, 18, 18, 22, 25, 24, 17,
6, -3, -7, -9, -6, -2, 3, 6, 10, 11, 12, 11, 8, 6, 7, 8, 8, 8, 4, -2, -11, -20,
-26, -29, -28, -23, -15, -11, -11, -16, -23, -28, -27, -20, -14, -11, -12, -15,
-12, -11, -29, -52, -59, -53, -50, -49, -47, -46, -46, -48, -51, -53, -55, -56,
-60, -63, -66, -72, -75, -77, -77, -76, -75, -74, -70, -65, -60, -55, -51, -50,
-48, -48, -47, -45, -43, -43, -45, -48, -49, -52, -55, -57, -59, -59, -60, -58,
-56, -55, -53, -48, -40, -33, -25, -20, -16, -14, -11, -7, -3, -2, -1, -4, -7,
-10, -13, -16, -19, -23, -26, -28, -28, -28, -28, -29, -29, -25, -20, -10, 1, 7,
14, 18, 24, 30, 36, 41, 45, 49, 52, 52, 49, 45, 40, 41, 44, 43, 42, 36, 30, 26,
26, 24, 24, 23, 24, 27, 32, 35, 39, 44, 49, 57, 66, 74, 81, 88, 96, 100, 97, 91,
82, 77, 74, 68, 58, 50, 42, 36, 34, 27, 15, 5, 2, 9, 28, 44, 55, 60, 62, 65, 72,
76, 71, 62, 47, 35, 29, 23, 15, 6, -4, -11, -12, -11, -11, -12, -17, -19, -15,
-6, 3, 11, 11, 9, 7, 9, 13, 14, 4, -12, -26, -35, -34, -28, -25, -29, -35, -43,
-43, -40, -39, -38, -41, -43, -40, -32, -27, -26, -30, -39, -45, -49, -48, -45,
-37, -28, -23, -24, -33, -48, -55, -55, -52, -50, -51, -59, -63, -62, -59, -58,
-56, -58, -58, -54, -54, -59, -61, -55, -45, -26, -13, -14, -21, -33, -43, -50,
-55, -64, -68, -70, -69, -61, -55, -49, -48, -54, -61, -66, -65, -54, -42, -34,
-36, -49, -58, -52, -41, -26, -18, -23, -34, -40, -43, -43, -43, -48, -54, -57,
-57, -58, -60, -61, -59, -53, -47, -48, -52, -57, -59, -54, -47, -44, -45, -51,
-57, -61, -62, -60, -52, -42, -30, -23, -21, -22, -26, -30, -30, -30, -30, -37,
-48, -58, -64, -66, -61, -57, -57, -56, -54, -45, -30, -18, -9, -6, -9, -18,
-28, -37, -44, -43, -38, -32, -32, -37, -48, -57, -63, -69, -76, -79, -75, -60,
-34, -8, 11, 21, 19, 14, 15, 15, 15, 11, -5, -23, -36, -40, -30, -17, -13, -17,
-33, -48, -50, -39, -24, -6, };