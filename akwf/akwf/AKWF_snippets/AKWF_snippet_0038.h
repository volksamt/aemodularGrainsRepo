#define DATA_LENGTH 512
#define DATA AKWF_snippet_0038

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 4, -5, -7, -6, 1, 8, 12, 21, 22,
19, 20, 24, 18, 20, 27, 25, 24, 20, 23, 23, 22, 34, 30, 29, 33, 33, 37, 37, 35,
40, 43, 41, 38, 43, 41, 42, 50, 40, 46, 53, 52, 50, 49, 53, 48, 46, 56, 58, 63,
63, 56, 63, 57, 59, 67, 61, 52, 43, 45, 53, 56, 57, 60, 59, 52, 55, 68, 60, 50,
54, 49, 47, 55, 57, 53, 60, 65, 59, 49, 52, 54, 55, 59, 66, 64, 56, 56, 58, 60,
59, 68, 66, 67, 78, 75, 73, 61, 61, 57, 58, 62, 54, 61, 64, 75, 68, 64, 66, 67,
74, 76, 80, 72, 85, 89, 88, 87, 90, 91, 90, 96, 93, 94, 96, 98, 96, 103, 109,
103, 104, 107, 108, 104, 102, 105, 97, 96, 110, 109, 108, 104, 109, 106, 108,
106, 107, 105, 95, 104, 103, 103, 106, 110, 103, 102, 107, 104, 96, 98, 96, 92,
94, 94, 90, 85, 93, 87, 85, 90, 88, 75, 75, 77, 72, 71, 66, 64, 71, 76, 61, 57,
57, 61, 61, 55, 58, 58, 65, 69, 80, 69, 64, 67, 62, 56, 54, 59, 53, 64, 62, 60,
56, 52, 51, 44, 58, 66, 60, 52, 54, 55, 48, 50, 51, 50, 59, 62, 59, 49, 54, 60,
54, 57, 51, 47, 40, 49, 60, 65, 62, 55, 60, 57, 57, 58, 57, 55, 49, 44, 49, 47,
47, 51, 49, 46, 38, 46, 43, 37, 35, 38, 41, 38, 42, 33, 31, 39, 32, 32, 27, 25,
25, 14, 14, 15, 12, 22, 25, 23, 21, 14, 23, 20, 13, 17, 21, 13, 10, 5, -3, -10,
-14, -6, -1, 4, -5, -3, -8, -13, -17, -11, -10, -13, -16, -22, -29, -45, -36,
-34, -34, -34, -40, -51, -52, -47, -57, -58, -60, -58, -58, -64, -62, -51, -48,
-44, -52, -58, -61, -65, -67, -67, -73, -74, -70, -72, -70, -77, -74, -69, -78,
-81, -74, -75, -75, -68, -68, -70, -73, -75, -69, -64, -70, -69, -71, -74, -72,
-65, -66, -70, -74, -82, -82, -81, -84, -83, -77, -81, -88, -96, -89, -88, -92,
-89, -89, -92, -91, -92, -95, -100, -105, -109, -93, -87, -100, -98, -97, -101,
-109, -115, -116, -120, -113, -110, -115, -108, -106, -110, -109, -104, -104,
-103, -94, -94, -98, -99, -101, -110, -110, -109, -111, -101, -101, -97, -95,
-93, -97, -105, -105, -107, -112, -104, -111, -116, -110, -115, -113, -114,
-112, -109, -103, -98, -96, -98, -88, -94, -110, -102, -96, -94, -90, -90, -93,
-89, -85, -85, -88, -85, -96, -88, -78, -80, -79, -82, -78, -80, -79, -73, -64,
-62, -64, -75, -76, -68, -68, -69, -65, -67, -71, -66, -67, -67, -71, -72, -75,
-78, -78, -75, -69, -72, -76, -69, -70, -66, -70, -73, -66, -62, -64, -60, -51,
-56, -45, -44, -55, -58, -60, -57, -58, -58, -56, -54, -49, -43, -48, -40, -34,
-33, -32, -36, -35, -28, -19, -16, -10, -7, -7, -16, -11, -2, -5, -2, };