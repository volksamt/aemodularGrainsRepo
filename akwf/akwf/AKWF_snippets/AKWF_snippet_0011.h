#define DATA_LENGTH 512
#define DATA AKWF_snippet_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 16, 19, 22, 28, 31, 39, 43,
51, 63, 71, 77, 76, 75, 79, 81, 73, 65, 67, 66, 60, 56, 60, 68, 71, 68, 67, 72,
73, 61, 52, 47, 43, 37, 31, 29, 24, 20, 18, 12, 7, 6, 9, 10, 12, 10, 12, 12, 7,
5, 3, 3, -1, -6, -7, -4, -5, -8, -7, 1, 8, 8, 8, 15, 16, 16, 13, 13, 12, 6, 1,
4, 3, 1, 0, 2, 9, 10, 10, 9, 11, 16, 16, 15, 14, 21, 25, 16, 8, 8, 7, 6, -5,
-12, -8, -4, -9, -15, -7, 1, 4, 3, 18, 33, 38, 39, 41, 49, 38, 29, 34, 42, 42,
34, 36, 51, 58, 49, 44, 54, 60, 60, 54, 54, 55, 56, 51, 45, 44, 40, 46, 50, 44,
38, 47, 50, 38, 29, 23, 20, 18, 4, -16, -19, -11, -31, -45, -41, -38, -42, -47,
-48, -43, -42, -44, -53, -51, -49, -57, -55, -49, -56, -75, -83, -82, -84, -96,
-104, -93, -80, -78, -89, -80, -60, -56, -60, -60, -44, -31, -33, -48, -46, -31,
-28, -37, -34, -9, -5, -5, 8, 18, 18, 21, 24, 29, 35, 32, 36, 42, 46, 46, 37,
28, 18, 5, -9, -17, -27, -39, -47, -55, -61, -69, -67, -58, -52, -49, -47, -47,
-52, -61, -70, -75, -78, -78, -82, -79, -77, -78, -76, -73, -73, -63, -47, -35,
-31, -24, -11, -5, -3, 0, 3, 5, 1, -1, -1, -11, -16, -13, -6, 0, 3, 9, 21, 29,
31, 33, 36, 38, 41, 40, 34, 30, 28, 30, 27, 27, 29, 33, 34, 33, 34, 34, 36, 39,
45, 52, 54, 49, 44, 43, 39, 37, 33, 29, 35, 40, 41, 41, 44, 53, 58, 59, 62, 68,
70, 70, 64, 58, 49, 48, 49, 45, 40, 36, 39, 42, 38, 36, 34, 37, 40, 41, 42, 40,
39, 35, 29, 24, 14, 7, 3, -9, -16, -12, -7, -4, -3, -1, 11, 11, 2, 1, 5, 3, -8,
-11, -3, -3, -10, -14, -14, -14, -19, -23, -9, 0, -7, -8, 9, 22, 23, 20, 19, 31,
38, 25, 17, 20, 15, 13, 15, 13, 19, 25, 24, 24, 26, 29, 24, 20, 28, 33, 31, 22,
18, 33, 25, -5, -19, -8, 2, -10, -32, -20, 8, 2, -19, -5, 12, 3, -3, -6, 4, 8,
-9, -22, -13, -7, -19, -23, -12, -5, -5, -10, 2, 39, 56, 57, 63, 74, 74, 60, 40,
31, 38, 26, -5, -10, -1, -12, -23, -20, -11, -2, -3, -5, -6, -17, -38, -58, -69,
-76, -83, -91, -97, -101, -111, -118, -118, -115, -116, -113, -101, -89, -83,
-80, -76, -71, -69, -76, -80, -85, -90, -95, -99, -99, -88, -75, -62, -45, -32,
-19, -12, -7, -3, 5, 9, 12, 11, 5, -5, -19, -26, -34, -35, -32, -28, -24, -19,
-18, -15, -10, -6, -4, -4, -2, -5, -11, -26, -36, -44, -52, -58, -60, -56, -52,
-47, -42, -36, -31, -23, -15, -8, -4, -3, -4, -4, -2, -1, };