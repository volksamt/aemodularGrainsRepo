#define DATA_LENGTH 512
#define DATA AKWF_snippet_0040

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 27, 44, 55, 51, 35, 23, 21, 15, 8,
17, 18, 39, 59, 39, 20, 25, 29, 17, 75, 114, 99, 103, 80, 27, 31, 54, 58, 48,
19, -14, -33, -24, -37, -44, -82, -69, -43, -57, -61, -86, -100, -82, -75, -87,
-79, -76, -84, -90, -85, -73, -63, -54, -60, -45, -23, -32, -37, -43, -55, -51,
-31, -37, -55, -54, -44, -29, -38, -44, -43, -42, -31, -14, -4, -1, 17, 22, 34,
45, 35, 33, 29, 43, 35, 38, 21, 8, 27, 31, 26, 16, 23, 15, 0, 1, 19, 7, 7, 10,
36, 53, 17, -23, -36, -24, -20, -28, -41, -39, -27, -5, 14, 28, 17, 9, -9, -1,
-5, 9, 31, 10, 26, 34, 21, 7, 6, 2, 1, 6, 17, 28, 37, 44, 50, 68, 74, 65, 53,
33, 7, 9, 12, 9, 7, 4, 17, 22, 34, 15, -9, 2, 13, 6, -18, -22, -11, -23, -8, 23,
17, 4, 4, 7, 25, 24, 5, -3, -8, 15, 0, -17, -20, -7, 2, 7, 19, 7, 8, 0, -4, 1,
11, 32, 29, 14, 20, 14, 12, 24, 10, 38, 66, 45, 40, 10, -9, -4, -1, -7, -21, -7,
-12, -14, -12, -35, -35, -31, -28, -13, -10, -7, -10, -13, -31, -36, -28, -29,
-35, -40, -42, 3, 16, 9, -13, -32, -7, -23, -28, -22, -21, -22, -24, -29, -47,
-53, -49, -55, -44, -36, -32, -48, -59, -54, -34, -26, -22, -28, -42, -35, -29,
-21, -44, -51, -34, -21, -3, 8, -11, -29, -39, -28, -12, -2, 4, 1, -4, -20, -30,
4, 39, 48, 46, 47, 35, 23, 32, 20, 5, 7, 0, -8, 36, 58, 62, 46, 50, 57, 53, 60,
44, 39, 48, 67, 65, 29, -8, 0, 15, 40, 52, 42, 48, 23, -4, 4, 15, 12, 12, 33,
21, -13, -17, -7, -1, 0, 22, 11, 2, 23, 32, 40, 39, 37, 34, 25, 24, 19, 9, 21,
33, 31, 28, 23, 23, 16, 27, 33, 36, 17, 15, 17, 5, 25, 47, 50, 30, 16, 10, -3,
-35, -32, -28, -35, -21, -10, -33, -51, -34, -53, -64, -63, -66, -70, -70, -53,
-68, -48, -39, -64, -72, -63, -47, -67, -65, -80, -98, -89, -81, -71, -53, -30,
-8, 8, -5, -13, -10, -33, -46, -6, -24, -18, 18, 11, -19, -25, -11, 3, 27, 33,
41, 20, -8, -14, -27, 17, 61, 36, 49, 47, 34, 5, 0, 34, 30, 27, 36, 32, 36, 50,
36, 20, 16, 25, 18, 34, 56, 68, 65, 39, 24, 36, 50, 60, 60, 33, 10, 13, 19, 23,
41, 22, 6, 0, 15, 28, 29, 53, 17, -28, -57, -54, -48, -56, -60, -48, -19, -19,
-33, -16, -17, -8, 7, -5, 12, 20, -26, -78, -63, -27, -21, -44, -61, -113, -100,
-62, -59, -35, -38, -30, -34, -62, -71, -73, -51, -9, 39, 44, 20, 8, -18, 1, 17,
57, 52, 36, 62, 81, 99, 75, 56, 53, 56, 41, 10, 34, 61, 41, 17, 17, 27, 5, -2,
};