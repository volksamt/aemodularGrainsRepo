#define DATA_LENGTH 512
#define DATA AKWF_snippet_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 12, 16, 17, 18, 17, 15, 13,
13, 14, 18, 24, 34, 47, 64, 80, 95, 106, 113, 117, 117, 117, 117, 116, 115, 115,
115, 117, 117, 118, 119, 119, 118, 115, 111, 107, 102, 98, 95, 91, 87, 83, 78,
76, 75, 76, 78, 80, 82, 82, 82, 78, 72, 68, 65, 61, 59, 60, 59, 60, 62, 63, 66,
68, 70, 72, 75, 76, 75, 73, 72, 71, 68, 68, 67, 63, 62, 59, 57, 54, 53, 51, 47,
44, 38, 35, 30, 28, 29, 29, 30, 27, 24, 19, 13, 9, 2, -6, -16, -30, -45, -56,
-65, -69, -73, -77, -79, -82, -81, -79, -77, -77, -79, -81, -83, -84, -84, -83,
-80, -77, -74, -70, -67, -64, -61, -62, -61, -59, -58, -56, -55, -53, -52, -54,
-54, -55, -55, -54, -55, -56, -58, -59, -62, -64, -69, -73, -78, -81, -82, -85,
-85, -83, -83, -79, -76, -73, -69, -67, -64, -59, -55, -48, -44, -38, -33, -29,
-24, -20, -16, -14, -11, -10, -7, -4, 0, 5, 11, 16, 20, 24, 26, 30, 35, 39, 46,
51, 55, 60, 64, 66, 68, 68, 68, 68, 67, 66, 65, 65, 63, 61, 57, 52, 46, 42, 40,
40, 41, 41, 41, 40, 39, 38, 39, 39, 40, 39, 38, 35, 34, 34, 34, 33, 34, 37, 38,
42, 45, 49, 53, 56, 58, 59, 58, 58, 57, 55, 53, 49, 46, 41, 37, 35, 33, 31, 27,
22, 15, 7, -2, -9, -15, -20, -24, -30, -35, -38, -43, -45, -48, -52, -56, -57,
-57, -59, -61, -65, -70, -75, -79, -80, -81, -83, -84, -85, -84, -83, -84, -86,
-87, -88, -88, -88, -87, -86, -86, -85, -85, -83, -86, -88, -88, -87, -83, -77,
-73, -70, -69, -68, -66, -63, -63, -62, -61, -61, -60, -59, -58, -58, -58, -60,
-63, -64, -68, -70, -71, -72, -72, -70, -71, -70, -70, -69, -67, -66, -65, -64,
-66, -66, -66, -64, -60, -57, -54, -53, -51, -50, -48, -45, -42, -40, -38, -38,
-40, -41, -42, -42, -39, -37, -34, -32, -31, -30, -40, -21, 48, 98, 94, 84, 83,
82, 78, 75, 72, 69, 66, 65, 64, 63, 61, 62, 61, 62, 64, 65, 65, 66, 65, 65, 63,
62, 59, 59, 59, 60, 59, 59, 57, 59, 62, 67, 71, 74, 76, 76, 76, 76, 76, 77, 77,
77, 75, 71, 65, 58, 51, 44, 38, 32, 23, 13, 5, -5, -11, -18, -24, -30, -36, -41,
-45, -49, -51, -54, -56, -59, -62, -66, -69, -70, -70, -66, -62, -58, -56, -54,
-51, -49, -45, -43, -39, -34, -30, -25, -21, -19, -17, -15, -14, -11, -9, -7,
-5, -6, -5, -5, -6, -7, -6, -7, -9, -10, -10, -9, -6, -3, -2, -2, -4, -6, -9,
-12, -14, -15, -17, -19, -22, -24, -25, -25, -24, -24, -23, -23, -23, -23, -22,
-21, -20, -18, -17, -17, -17, -17, -17, -16, -15, -14, -12, -10, -8, -6, -4, -2,
-1, -1, -1, -2, -3, -4, -3, 0, };