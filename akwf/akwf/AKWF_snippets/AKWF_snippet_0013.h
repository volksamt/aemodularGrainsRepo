#define DATA_LENGTH 512
#define DATA AKWF_snippet_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 9, 11, 7, 6, 6, 2, 16, 18, 5, 8,
19, 24, 17, 15, 34, 38, 22, 25, 46, 46, 36, 40, 46, 46, 42, 34, 40, 62, 63, 41,
35, 45, 56, 61, 59, 58, 58, 63, 72, 82, 74, 62, 79, 93, 90, 96, 94, 76, 75, 86,
99, 111, 99, 100, 114, 110, 104, 109, 115, 116, 115, 113, 107, 115, 119, 115,
113, 112, 116, 118, 116, 114, 111, 113, 109, 106, 106, 107, 107, 107, 105, 103,
102, 101, 103, 103, 97, 97, 98, 98, 95, 93, 94, 97, 97, 96, 94, 92, 91, 90, 87,
88, 90, 89, 85, 85, 86, 86, 85, 86, 86, 86, 83, 82, 83, 83, 83, 77, 76, 81, 76,
73, 77, 75, 72, 74, 71, 67, 69, 62, 54, 61, 66, 62, 60, 60, 59, 63, 57, 47, 50,
55, 59, 58, 59, 67, 71, 72, 70, 57, 43, 39, 43, 44, 39, 36, 35, 43, 53, 42, 23,
7, 3, 5, -3, -11, -10, -15, -23, -11, -7, -25, -22, -18, -33, -39, -32, -39,
-49, -50, -53, -52, -53, -68, -69, -59, -53, -57, -67, -77, -77, -71, -75, -87,
-92, -83, -81, -86, -82, -77, -85, -92, -87, -80, -87, -94, -91, -85, -89, -94,
-93, -87, -80, -89, -91, -84, -83, -86, -86, -84, -82, -82, -81, -79, -78, -81,
-78, -77, -77, -71, -71, -74, -76, -72, -70, -72, -72, -71, -64, -60, -69, -74,
-69, -70, -69, -64, -64, -67, -67, -67, -69, -65, -65, -68, -68, -68, -66, -64,
-63, -63, -60, -60, -66, -64, -61, -62, -62, -61, -59, -59, -61, -60, -59, -57,
-57, -56, -58, -57, -54, -57, -58, -57, -54, -52, -52, -53, -51, -50, -50, -51,
-48, -47, -49, -46, -48, -46, -36, -32, -33, -31, -31, -19, -12, -18, -13, -3,
5, 0, -7, 8, 18, 3, 1, 22, 24, 14, 18, 30, 28, 19, 19, 22, 22, 20, 27, 30, 28,
33, 34, 41, 47, 38, 37, 43, 49, 47, 43, 47, 56, 57, 60, 38, 25, 36, 40, 33, 23,
22, 35, 35, 24, 29, 28, 18, 17, 22, 31, 24, 13, 19, 25, 22, 13, 13, 15, 15, 16,
10, 12, 16, 9, 2, 2, 5, 4, 2, 7, 6, 7, 7, 4, 12, 15, 12, 11, 13, 8, 2, 11, 11,
1, 1, 12, 14, -2, -11, -1, 2, -2, -8, -18, -16, -6, -9, -11, -7, -6, -6, -15,
-19, -23, -31, -19, -9, -16, -28, -46, -49, -37, -37, -45, -53, -59, -52, -53,
-56, -52, -54, -59, -68, -67, -59, -74, -85, -77, -68, -62, -69, -78, -81, -82,
-69, -67, -76, -74, -72, -72, -73, -74, -72, -71, -71, -69, -66, -69, -67, -65,
-65, -63, -62, -60, -61, -61, -58, -57, -57, -56, -56, -55, -55, -56, -53, -51,
-50, -53, -53, -51, -52, -50, -46, -46, -46, -45, -43, -42, -43, -33, -25, -30,
-33, -29, -27, -23, -25, -24, -8, -5, -12, -11, -11, -13, -6, 2, -5, -19, -8,
14, 10, -7, -7, };