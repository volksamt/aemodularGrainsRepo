#define DATA_LENGTH 512
#define DATA AKWF_snippet_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 14, 9, 18, 25, 26, 33, 33, 31, 45,
44, 33, 45, 50, 41, 45, 45, 36, 40, 43, 42, 44, 49, 49, 52, 61, 67, 65, 71, 71,
67, 75, 75, 72, 77, 69, 62, 63, 54, 50, 49, 40, 37, 28, 10, 15, 14, 2, 7, 5, -9,
-4, -1, -10, -11, -9, -9, -7, -9, -3, 6, -1, -4, 3, 3, -4, -2, 1, 2, -5, -10,
-12, -17, -26, -26, -25, -33, -39, -37, -34, -42, -44, -38, -37, -37, -31, -27,
-25, -23, -21, -17, -14, -7, -5, -1, 8, 15, 14, 13, 20, 24, 26, 25, 30, 34, 30,
32, 35, 27, 22, 25, 23, 18, 16, 13, 4, -3, -6, -9, -10, -10, -21, -22, -21, -32,
-33, -27, -31, -35, -37, -45, -45, -45, -46, -40, -43, -48, -43, -46, -49, -39,
-44, -50, -43, -47, -56, -49, -46, -56, -52, -40, -46, -47, -37, -40, -37, -29,
-29, -23, -14, -16, -9, -2, -7, 2, 12, 6, 11, 20, 18, 24, 31, 31, 36, 42, 37,
43, 52, 46, 38, 44, 39, 38, 44, 37, 34, 38, 26, 21, 23, 16, 6, 10, 8, -2, 1, 6,
-2, -5, -2, -6, -9, -12, -20, -19, -23, -35, -33, -34, -44, -46, -45, -47, -49,
-53, -48, -45, -52, -47, -38, -39, -35, -26, -23, -18, -10, -2, 6, 15, 25, 32,
39, 45, 49, 60, 63, 64, 76, 76, 66, 69, 70, 63, 65, 66, 56, 58, 62, 49, 44, 47,
28, 17, 25, 20, 8, 5, 2, 0, 3, -1, -3, -7, -10, -5, -6, -12, -11, -4, -21, -35,
-13, -7, -41, -40, -17, -37, -44, -33, -40, -41, -38, -47, -47, -47, -51, -49,
-51, -53, -52, -56, -58, -61, -67, -71, -73, -68, -60, -63, -65, -61, -57, -53,
-59, -59, -50, -46, -41, -34, -32, -29, -29, -24, -21, -17, -23, 9, 53, 50, 51,
46, 42, 36, 34, 38, 44, 44, 44, 46, 43, 43, 45, 43, 40, 43, 43, 40, 38, 43, 46,
45, 42, 38, 33, 31, 34, 38, 33, 31, 32, 28, 25, 30, 34, 33, 28, 24, 28, 29, 21,
19, 23, 24, 23, 24, 28, 31, 33, 34, 31, 30, 33, 35, 37, 37, 34, 29, 30, 32, 30,
28, 24, 22, 22, 20, 20, 29, 34, 30, 27, 26, 26, 29, 32, 33, 36, 39, 37, 34, 34,
35, 38, 39, 34, 31, 26, 20, 15, 11, -1, -11, -15, -16, -24, -35, -42, -49, -61,
-70, -76, -84, -94, -103, -106, -105, -114, -119, -114, -111, -112, -113, -116,
-111, -106, -101, -93, -86, -78, -71, -66, -59, -52, -45, -34, -24, -18, -11,
-9, -6, 4, 6, 4, 4, -2, -7, -5, -2, 2, 2, 0, -2, -3, -4, -1, 0, -2, -1, -3, -3,
3, 8, 12, 19, 18, 15, 23, 30, 32, 37, 40, 40, 46, 48, 42, 45, 45, 30, 24, 31,
19, 10, 10, -4, -12, -13, -28, -28, -24, -48, -47, -32, -43, -45, -31, -29, -26,
-23, -27, -14, -3, -9, -5, };