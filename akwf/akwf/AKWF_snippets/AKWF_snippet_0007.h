#define DATA_LENGTH 512
#define DATA AKWF_snippet_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 10, 18, 29, 35, 40, 46, 49, 54, 60,
67, 70, 73, 73, 71, 69, 68, 66, 67, 69, 71, 74, 76, 77, 79, 80, 82, 84, 86, 87,
87, 87, 86, 87, 87, 89, 94, 97, 100, 101, 98, 92, 85, 77, 69, 62, 57, 50, 43,
39, 32, 28, 21, 17, 12, 7, 5, 1, -3, -6, -7, -8, -7, -2, 5, 14, 22, 29, 35, 38,
40, 45, 50, 53, 57, 58, 58, 56, 52, 49, 48, 49, 52, 54, 57, 59, 58, 57, 54, 52,
52, 52, 54, 55, 57, 57, 58, 59, 60, 64, 69, 72, 72, 70, 65, 59, 51, 43, 36, 31,
25, 19, 14, 8, 1, -6, -13, -19, -25, -29, -34, -37, -40, -42, -41, -38, -33,
-26, -18, -10, -5, -1, 2, 4, 9, 14, 21, 25, 26, 25, 21, 17, 12, 9, 6, 5, 4, 5,
3, -1, -7, -13, -16, -18, -20, -22, -22, -26, -27, -31, -32, -34, -31, -29, -26,
-27, -27, -33, -39, -48, -56, -65, -70, -76, -82, -87, -93, -96, -104, -103,
-115, -107, -127, -52, 29, 2, 9, -2, 0, -6, -4, -7, -5, -6, -2, 4, 11, 20, 27,
34, 39, 42, 43, 47, 47, 51, 51, 51, 48, 46, 40, 38, 35, 36, 37, 40, 41, 44, 46,
46, 46, 45, 46, 46, 48, 50, 50, 52, 52, 53, 54, 57, 60, 62, 62, 60, 55, 48, 39,
31, 23, 17, 10, 3, -3, -10, -17, -24, -31, -36, -39, -42, -44, -46, -46, -46,
-44, -42, -39, -32, -25, -18, -11, -6, -4, 0, 0, 1, 2, 2, 2, 0, -8, -18, -27,
-35, -41, -42, -43, -43, -42, -42, -41, -40, -40, -42, -43, -45, -47, -48, -50,
-51, -51, -49, -48, -44, -40, -38, -39, -42, -49, -56, -63, -70, -76, -80, -84,
-89, -92, -94, -99, -101, -102, -105, -106, -107, -108, -109, -110, -108, -104,
-100, -93, -83, -74, -64, -55, -49, -43, -39, -32, -27, -22, -17, -15, -15, -16,
-18, -19, -18, -14, -9, -4, 1, 5, 7, 10, 12, 14, 19, 25, 28, 35, 40, 43, 48, 51,
55, 60, 66, 71, 71, 69, 65, 58, 51, 44, 38, 32, 27, 21, 15, 8, 2, -6, -14, -19,
-24, -27, -30, -32, -34, -35, -34, -33, -30, -25, -20, -15, -12, -10, -12, -14,
-14, -12, -10, -9, -11, -13, -19, -26, -32, -36, -38, -38, -37, -36, -33, -33,
-31, -31, -30, -29, -27, -26, -27, -27, -28, -28, -27, -25, -22, -17, -14, -13,
-15, -18, -24, -31, -38, -44, -49, -54, -59, -64, -68, -72, -75, -78, -80, -80,
-83, -85, -86, -87, -88, -87, -84, -77, -70, -60, -51, -42, -34, -27, -23, -18,
-14, -7, -3, -1, 1, -2, -4, -7, -8, -7, -4, 1, 5, 9, 11, 12, 12, 13, 14, 17, 20,
22, 24, 26, 28, 30, 34, 38, 43, 47, 49, 50, 46, 41, 34, 27, 21, 16, 11, 7, 2,
-1, -4, -8, -10, -13, -16, -17, -18, -18, -19, -19, -15, -12, -6, };