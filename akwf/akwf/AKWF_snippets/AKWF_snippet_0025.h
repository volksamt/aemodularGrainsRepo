#define DATA_LENGTH 512
#define DATA AKWF_snippet_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 12, 14, 16, 20, 21, 24, 30, 32, 38,
47, 58, 67, 70, 70, 68, 65, 55, 40, 28, 22, 26, 36, 53, 73, 85, 84, 69, 49, 32,
18, 8, 5, 6, 15, 34, 55, 70, 71, 61, 48, 35, 24, 22, 16, 10, 11, 11, 12, 20, 12,
-3, 1, 22, 29, 18, 2, -5, -2, 9, 25, 38, 32, 12, -7, -13, -11, -2, 17, 34, 42,
44, 44, 39, 38, 43, 46, 47, 53, 57, 56, 56, 55, 55, 50, 41, 34, 25, 14, 10, 10,
8, 9, 12, 11, 16, 15, 5, -7, -10, -12, -10, -11, -16, -21, -25, -28, -29, -35,
-40, -28, -11, 2, 0, -6, -16, -33, -58, -69, -79, -84, -83, -69, -60, -55, -61,
-73, -91, -114, 14, 80, 66, 84, 81, 84, 75, 72, 67, 70, 67, 61, 49, 39, 35, 36,
36, 31, 28, 27, 29, 31, 34, 36, 35, 24, 13, 2, -7, -16, -21, -21, -14, -5, 2, 6,
4, -5, -25, -51, -75, -89, -82, -61, -34, -15, 1, 15, 21, 17, 3, -15, -29, -32,
-32, -30, -28, -27, -26, -23, -22, -23, -27, -33, -38, -40, -43, -46, -47, -46,
-45, -38, -31, -20, -9, -2, 2, 5, 3, 0, -3, -5, -9, -15, -17, -13, -4, 5, 5, -2,
-9, -17, -22, -23, -22, -21, -22, -19, -16, -9, -4, -5, -11, -22, -31, -33, -28,
-22, -14, -8, -1, 5, 8, -1, -18, -40, -60, -73, -74, -64, -50, -33, -15, 2, 16,
18, 10, -1, -12, -18, -18, -11, 1, 18, 33, 45, 46, 38, 25, 15, 9, 11, 18, 26,
40, 58, 73, 78, 74, 62, 47, 34, 26, 21, 17, 13, 14, 18, 24, 28, 32, 32, 25, 13,
6, 2, 0, -1, -8, -16, -19, -15, -9, -5, -5, -9, -18, -29, -36, -39, -38, -35,
-31, -24, -17, -12, -14, -22, -33, -46, -59, -66, -66, -63, -58, -54, -50, -45,
-36, -24, -14, -14, -20, -27, -28, -26, -21, -13, 0, 15, 28, 32, 25, 10, -7,
-21, -26, -23, -15, 1, 14, 25, 33, 35, 29, 19, 10, 2, 1, 6, 20, 33, 47, 58, 67,
65, 56, 46, 37, 31, 29, 32, 40, 47, 48, 47, 44, 39, 32, 27, 21, 16, 10, 4, -1,
1, 6, 14, 19, 17, 11, 8, 10, 13, 12, 8, 2, -2, -3, -3, -6, -14, -20, -23, -28,
-33, -40, -48, -50, -46, -34, -23, -11, -1, 9, 17, 19, 14, 3, -13, -27, -36,
-39, -39, -33, -23, -10, 2, 11, 12, 9, 5, -5, -16, -23, -24, -18, -6, 8, 21, 27,
21, 11, -5, -18, -25, -23, -12, 2, 18, 26, 33, 34, 27, 13, -4, -21, -30, -27,
-19, -10, -4, -1, -2, -6, -12, -20, -23, -27, -26, -21, -15, -10, -9, -10, -21,
-33, -47, -56, -60, -62, -65, -67, -69, -66, -57, -44, -36, -35, -38, -40, -42,
-43, -43, -38, -30, -21, -18, -22, -29, -36, -39, -39, -34, -33, -31, -27, -24,
-19, -13, -7, -5, 0, };