#define DATA_LENGTH 512
#define DATA AKWF_snippet_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 15, 31, 47, 51, 59, 69, 69, 71, 80,
76, 72, 70, 57, 43, 37, 26, 23, 25, 22, 12, 4, 1, 0, 6, 3, 14, 10, 8, 3, 4, 2,
10, 7, 3, 18, 12, 13, 10, -5, -15, -15, -17, -12, -10, -8, -7, -1, 9, 16, 25,
30, 34, 42, 41, 38, 31, 37, 48, 46, 48, 43, 39, 32, 30, 10, 6, -5, -7, -20, -28,
-31, -38, -20, -28, -23, -34, -47, -59, -59, -58, -51, -48, -54, -67, -80, -60,
-55, -63, -55, -34, -26, -27, -17, -17, -24, -9, -12, -10, -1, -7, -12, 26, 7,
-18, 21, -2, 16, 33, -6, 18, 39, 24, 35, 38, 21, 26, 45, 43, 53, 49, 16, 45, 56,
39, 67, 54, 25, 43, 56, 14, 18, 38, 4, 23, 29, -2, -1, 6, -3, -12, -10, -10, -5,
8, 7, -1, 8, 17, 9, 22, 32, 41, 47, 40, 36, 45, 59, 51, 66, 78, 72, 68, 52, 44,
47, 41, 33, 28, 0, -4, -8, -32, -18, -24, -16, -10, -29, -26, -15, -5, 1, 16,
24, 19, 13, 5, -5, -1, 1, 2, -17, -40, -50, -73, -83, -80, -81, -76, -67, -61,
-46, -35, -30, -22, -16, -3, 14, 15, 26, 30, 36, 38, 21, 10, 5, -6, -23, -32,
-49, -63, -58, -71, -81, -65, -60, -59, -58, -55, -46, -39, -23, -12, -3, 8, 14,
13, 6, 5, 1, 4, 8, -3, 2, 0, -2, -4, -9, 2, 7, 9, 21, 33, 39, 44, 56, 70, 79,
89, 92, 87, 86, 84, 72, 50, 33, 27, 10, 1, 1, -9, -17, -8, 0, -3, 3, -7, -7, 6,
6, 8, 18, 23, 20, 29, 15, -8, -6, -12, -9, 0, -20, -40, -56, -59, -43, -47, -56,
-35, -17, -3, 24, 39, 34, 37, 52, 42, 47, 52, 39, 28, 33, 28, 4, 5, -5, -11,
-20, -25, -20, -22, -12, -23, -12, -1, -3, 7, -3, -4, 7, -11, -9, -5, -10, -5,
-21, -32, -53, -55, -64, -66, -56, -63, -57, -58, -47, -28, -30, -28, -10, -13,
4, 13, 15, 27, 32, 45, 43, 52, 60, 63, 64, 54, 34, 21, 10, 7, -12, -28, -25,
-24, -11, -8, -10, -8, -13, -9, -6, 3, 18, 11, 38, 21, 37, 35, -21, -8, -27,
-10, -27, -35, -13, -26, 0, 8, 7, 11, 23, 46, 68, 80, 75, 40, 45, 35, 27, 27, 3,
15, -7, -47, -32, -47, -42, -19, -12, 33, 25, 19, 27, 37, 31, 35, 7, -40, -30,
-64, -116, -115, -87, -108, -100, -86, -75, -20, -8, 6, 8, 25, 66, 18, -38, -35,
-37, -33, -36, -37, -37, -32, -28, -35, -38, -54, -55, -59, -59, -53, -43, -47,
-52, -45, -41, -34, -34, -35, -34, -30, -34, -32, -25, -10, -1, 5, 8, 10, 3, 0,
-8, -17, -22, -23, -24, -21, -26, -33, -19, -7, 4, 1, 4, -1, -4, 5, 8, 14, 25,
23, 20, 15, 6, 4, 3, 3, 5, 6, -7, -23, -29, -24, -12, -7, -4, };