#define DATA_LENGTH 512
#define DATA AKWF_snippet_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 9, 16, 14, 8, 25, 25, 31, 46, 53,
70, 78, 71, 79, 79, 74, 73, 53, 43, 54, 56, 62, 68, 79, 94, 89, 82, 81, 80, 74,
68, 58, 55, 63, 69, 76, 80, 86, 98, 101, 97, 98, 102, 104, 102, 92, 88, 99, 100,
97, 91, 89, 102, 104, 101, 104, 111, 116, 119, 115, 111, 112, 110, 110, 107, 99,
103, 104, 94, 92, 89, 88, 84, 67, 67, 75, 84, 98, 98, 96, 99, 96, 95, 94, 94,
95, 94, 92, 88, 90, 90, 89, 90, 88, 89, 89, 88, 84, 79, 78, 71, 64, 63, 71, 84,
86, 86, 78, 75, 87, 82, 77, 79, 81, 81, 81, 79, 77, 75, 74, 78, 75, 72, 75, 65,
58, 63, 68, 78, 76, 60, 60, 57, 45, 37, 17, 16, 25, 18, 16, 7, 15, 33, 32, 34,
38, 41, 42, 33, 23, 18, 13, 4, -10, -19, -15, -8, -5, -12, -10, 7, 17, 25, 10,
3, 8, -4, -15, -24, -23, -10, -20, -30, -29, -33, -31, -42, -60, -64, -67, -62,
-62, -65, -52, -36, -36, -46, -47, -46, -44, -49, -64, -62, -55, -42, -25, -23,
-4, 7, -8, -24, -47, -60, -65, -87, -97, -101, -106, -97, -101, -103, -93, -93,
-89, -89, -92, -81, -79, -85, -82, -81, -68, -51, -50, -49, -50, -50, -46, -56,
-61, -63, -71, -81, -90, -96, -97, -92, -96, -96, -96, -99, -100, -101, -99,
-96, -97, -99, -95, -91, -75, -60, -58, -49, -50, -60, -61, -72, -82, -82, -92,
-90, -88, -85, -69, -67, -56, -44, -40, -36, -46, -49, -53, -64, -72, -76, -73,
-68, -62, -59, -61, -58, -60, -63, -72, -78, -77, -79, -74, -67, -62, -54, -47,
-49, -50, -48, -50, -52, -55, -47, -38, -22, 0, 8, 19, 24, 16, 5, -9, -21, -34,
-47, -55, -56, -54, -49, -46, -42, -34, -29, -25, -22, -16, -13, -11, -4, -2, 5,
11, 15, 22, 27, 32, 33, 34, 31, 36, 40, 37, 33, 23, 14, 6, -6, -11, -17, -19,
-11, -13, -12, -5, -6, 1, 2, 5, 21, 35, 50, 60, 59, 66, 70, 63, 56, 41, 29, 21,
7, 3, 16, 32, 53, 64, 67, 74, 68, 59, 45, 25, 16, 12, 10, 18, 26, 44, 59, 57,
56, 53, 52, 45, 34, 28, 25, 28, 36, 42, 43, 47, 52, 44, 40, 31, 39, 42, 49, 62,
72, 89, 99, 98, 90, 108, -27, -109, -91, -94, -79, -82, -68, -73, -74, -80, -73,
-71, -84, -89, -88, -86, -86, -87, -84, -84, -84, -82, -84, -83, -82, -79, -80,
-79, -78, -76, -77, -77, -78, -78, -76, -76, -75, -72, -74, -73, -71, -71, -68,
-69, -71, -71, -69, -72, -68, -67, -67, -66, -61, -47, -39, -39, -35, -38, -38,
-38, -48, -54, -58, -63, -63, -64, -66, -66, -64, -62, -61, -58, -49, -41, -35,
-28, -28, -19, -13, -20, -17, -11, -6, 0, 5, 10, 29, 38, 40, 38, 26, 22, 9, -11,
-8, -16, -13, 1, -6, -2, };