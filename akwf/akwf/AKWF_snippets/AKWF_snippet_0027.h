#define DATA_LENGTH 512
#define DATA AKWF_snippet_0027

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 21, 43, 59, 69, 71, 68, 56, 44, 40,
49, 71, 87, 90, 77, 61, 51, 48, 48, 46, 48, 51, 58, 63, 64, 62, 56, 46, 34, 25,
23, 34, 56, 79, 93, 94, 83, 69, 60, 60, 68, 80, 93, 104, 108, 101, 82, 58, 41,
35, 41, 51, 61, 71, 79, 88, 95, 97, 97, 92, 87, 79, 72, 68, 66, 64, 62, 61, 66,
73, 77, 68, 53, 40, 37, 46, 51, 49, 39, 27, 22, 27, 40, 51, 55, 52, 44, 38, 37,
42, 50, 57, 63, 65, 62, 59, 58, 58, 60, 58, 52, 45, 41, 46, 51, 54, 52, 46, 41,
37, 42, 59, 83, 106, 115, 102, 75, 51, 39, 41, 51, 57, 51, 37, 20, 11, 12, 18,
25, 28, 34, 43, 58, 68, 71, 65, 58, 56, 57, 58, 58, 58, 59, 61, 60, 57, 54, 55,
68, 89, 112, 119, 108, 89, 70, 66, 68, 70, 64, 57, 51, 51, 54, 57, 64, 76, 87,
88, 78, 62, 48, 42, 43, 47, 52, 54, 49, 42, 38, 39, 45, 47, 43, 35, 32, 36, 41,
58, 61, 0, -50, -39, -30, -28, -33, -41, -46, -49, -51, -52, -56, -61, -63, -63,
-61, -56, -52, -49, -48, -46, -47, -48, -51, -54, -53, -54, -54, -53, -49, -43,
-34, -30, -29, -33, -38, -39, -41, -44, -50, -54, -55, -52, -45, -39, -34, -30,
-30, -31, -33, -32, -34, -37, -41, -40, -36, -29, -26, -25, -27, -26, -25, -24,
-24, -24, -22, -19, -18, -19, -20, -21, -22, -20, -16, -9, -3, 2, 2, 0, -5, -11,
-15, -18, -17, -11, 0, 9, 16, 15, 9, 1, -3, -1, 5, 11, 16, 15, 7, 0, -8, -11,
-10, -6, -3, -3, -5, -7, -7, -7, -8, -13, -18, -22, -26, -30, -37, -45, -52,
-54, -51, -44, -39, -36, -35, -36, -35, -37, -37, -38, -37, -36, -37, -42, -48,
-54, -58, -58, -59, -60, -60, -60, -58, -55, -52, -52, -54, -60, -63, -67, -67,
-65, -58, -53, -51, -55, -63, -71, -71, -70, -68, -69, -73, -73, -71, -71, -77,
-88, -96, -95, -86, -77, -71, -70, -67, -65, -66, -72, -80, -82, -81, -78, -76,
-79, -79, -76, -68, -57, -49, -45, -48, -54, -59, -60, -56, -55, -59, -65, -69,
-65, -57, -47, -38, -27, -19, -15, -16, -23, -28, -32, -33, -30, -27, -28, -36,
-47, -57, -57, -47, -32, -23, -19, -20, -22, -24, -25, -26, -28, -31, -33, -32,
-29, -20, -11, -5, -7, -9, -13, -12, -11, -10, -13, -18, -21, -24, -25, -30,
-34, -39, -37, -30, -20, -13, -10, -11, -12, -14, -22, -38, -54, -66, -64, -55,
-47, -46, -47, -45, -39, -29, -27, -32, -45, -55, -56, -50, -40, -31, -23, -15,
-6, 3, 7, 3, -8, -20, -32, -43, -46, -45, -39, -34, -32, -32, -31, -31, -32,
-36, -38, -36, -27, -18, -12, -15, -21, -26, -31, -34, -35, -29, -15, 0, 12, 14,
14, 15, 21, 28, 33, 33, 31, 26, 14, 2, -2, };