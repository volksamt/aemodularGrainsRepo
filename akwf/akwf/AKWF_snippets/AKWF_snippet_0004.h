#define DATA_LENGTH 512
#define DATA AKWF_snippet_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 9, 56, 66, 51, 42, 39, 42, 20, 29,
16, 31, 44, 30, 52, 58, 65, 66, 70, 84, 96, 94, 102, 120, 115, 113, 107, 100,
94, 92, 92, 94, 106, 100, 97, 92, 86, 83, 81, 77, 75, 68, 66, 73, 78, 80, 83,
91, 89, 95, 90, 86, 78, 65, 60, 55, 48, 43, 53, 56, 76, 86, 89, 87, 80, 78, 75,
77, 71, 72, 63, 55, 52, 33, 30, 20, 22, 24, 26, 42, 41, 50, 41, 45, 35, 22, 27,
19, 39, 48, 66, 66, 63, 55, 29, 16, -5, -17, -39, -43, -44, -49, -62, -61, -54,
-58, -65, -51, -35, -32, -23, -24, -1, -16, -27, -42, -47, -52, -71, -50, -66,
-61, -75, -76, -75, -96, -98, -112, -98, -120, -113, -108, -101, -107, -99, -71,
-85, -79, -86, -73, -81, -91, -90, -96, -99, -102, -98, -93, -94, -95, -89, -92,
-78, -87, -87, -80, -82, -84, -83, -81, -82, -81, -81, -81, -80, -81, -76, -73,
-77, -76, -70, -63, -69, -68, -64, -60, -50, -34, -21, -5, 5, -4, -9, -27, -41,
-53, -56, -58, -64, -60, -65, -59, -55, -60, -49, -43, -31, -25, -12, -3, 6, 16,
7, 15, 1, 4, 6, 13, 18, 16, 22, 8, 12, 14, 15, 11, 9, 5, 8, 16, 26, 31, 34, 37,
41, 46, 48, 47, 39, 23, 5, -10, -22, -28, -29, -21, -11, 4, 18, 28, 31, 29, 23,
15, 8, 7, 14, 29, 47, 64, 71, 64, 47, 26, 6, -7, -14, -16, -16, -16, -15, -16,
-21, -25, -28, -28, -23, -10, 11, 28, 40, 43, 40, 27, 5, -13, -23, -22, -12, 3,
13, 17, 18, 14, 5, -6, -15, -24, -28, -27, -17, -5, 4, 10, 15, 18, 16, 11, 5, 1,
-1, -2, -2, -2, -2, -2, 3, 12, 20, 25, 26, 28, 32, 31, 31, 33, 30, 19, 8, -4,
-19, -27, -29, -27, -16, -4, 11, 26, 32, 28, 15, 3, -7, -13, -10, 4, 22, 42, 52,
50, 35, 16, -2, -17, -23, -20, -20, -20, -22, -27, -34, -44, -46, -47, -44, -31,
-14, 2, 15, 23, 25, 20, 6, -4, -10, -5, 11, 30, 46, 55, 59, 59, 55, 48, 38, 32,
25, 23, 27, 37, 45, 51, 53, 52, 56, 54, 51, 54, 54, 53, 50, 41, 29, 24, 23, 31,
46, 55, 59, 61, 66, 63, 56, 49, 39, 27, 16, 4, -8, -11, -12, -14, -18, -15, -9,
0, 8, 8, 8, -1, -6, -13, -19, -13, 3, 16, 29, 34, -11, 0, 2, -52, -78, -59, -52,
-83, -91, -70, -68, -78, -83, -74, -58, -59, -54, -35, -16, -4, 1, -10, 13, -13,
7, -5, -8, 52, 37, 60, 72, 66, 73, 75, 79, 68, 53, 54, 50, 46, 42, 48, 22, -3,
-12, -6, -28, -61, -55, -67, -73, -81, -85, -84, -69, -65, -62, -46, -52, -61,
-53, -60, -63, -54, -51, -57, -67, -72, -72, -79, -84, -77, -82, -71, -58, -42,
-28, -29, -30, -27, -25, -26, -28, -19, };