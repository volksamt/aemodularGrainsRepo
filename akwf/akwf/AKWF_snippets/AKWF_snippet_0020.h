#define DATA_LENGTH 512
#define DATA AKWF_snippet_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 12, 13, 15, 15, 15, 14, 15, 18,
21, 23, 25, 26, 28, 30, 32, 34, 35, 35, 36, 34, 33, 32, 32, 34, 33, 32, 29, 27,
24, 26, 29, 29, 29, 30, 29, 30, 33, 37, 37, 37, 38, 43, 47, 49, 52, 53, 52, 52,
52, 54, 56, 57, 57, 58, 58, 57, 57, 56, 55, 54, 53, 54, 53, 56, 58, 58, 58, 55,
53, 51, 51, 52, 54, 55, 56, 57, 56, 57, 56, 58, 61, 66, 69, 69, 70, 69, 70, 71,
73, 71, 70, 66, 61, 54, 47, 42, 41, 43, 42, 33, 24, 15, 13, 21, 28, 29, 24, 11,
-2, -12, -19, -26, -32, -39, -41, -39, -36, -35, -34, -35, -38, -40, -45, -50,
-50, -48, -46, -46, -46, -45, -45, -44, -28, 7, 29, 26, 20, 22, 24, 24, 22, 21,
22, 25, 28, 30, 29, 27, 28, 30, 32, 34, 32, 33, 33, 36, 39, 42, 43, 43, 41, 41,
41, 41, 41, 39, 36, 34, 32, 32, 31, 31, 28, 26, 24, 22, 20, 18, 15, 12, 9, 8, 6,
5, 2, -1, -5, -8, -9, -9, -9, -9, -9, -6, -5, -2, 3, 5, 5, 6, 3, 1, -1, -2, -1,
1, 1, 1, 1, 3, 3, 7, 9, 11, 14, 16, 19, 20, 20, 21, 22, 24, 24, 25, 26, 27, 29,
32, 33, 34, 33, 33, 31, 31, 32, 32, 32, 31, 30, 30, 32, 35, 38, 40, 40, 38, 38,
40, 44, 50, 52, 56, 59, 62, 64, 65, 67, 67, 70, 71, 72, 73, 72, 71, 71, 70, 71,
69, 69, 68, 67, 67, 67, 65, 63, 62, 61, 59, 57, 54, 51, 48, 45, 42, 41, 38, 33,
32, 30, 31, 30, 29, 25, 21, 18, 17, 17, 17, 17, 16, 15, 13, 12, 9, 6, -1, -6,
-10, -12, -13, -17, -22, -31, -38, -45, -49, -51, -56, -60, -67, -72, -76, -79,
-81, -86, -89, -95, -98, -100, -102, -104, -106, -109, -109, -111, -114, -117,
-119, -120, -117, -113, -109, -108, -109, -111, -112, -110, -106, -103, -102,
-102, -102, -102, -100, -98, -94, -92, -90, -88, -86, -88, -88, -87, -87, -84,
-83, -83, -83, -82, -79, -77, -75, -76, -77, -78, -75, -71, -68, -67, -68, -70,
-70, -70, -67, -65, -64, -64, -64, -66, -65, -63, -60, -57, -58, -58, -57, -56,
-52, -48, -43, -38, -34, -31, -28, -25, -21, -15, -10, -5, -2, -2, -1, 0, 0, 2,
1, 5, 8, 10, 10, 8, 8, 8, 12, 15, 16, 14, 11, 7, 7, 8, 10, 10, 8, 3, 0, -1, -3,
-4, -6, -11, -15, -16, -17, -17, -21, -24, -26, -26, -24, -21, -20, -22, -25,
-27, -28, -27, -27, -28, -27, -28, -28, -29, -28, -28, -28, -28, -28, -28, -28,
-27, -24, -22, -23, -25, -25, -25, -24, -23, -24, -26, -27, -29, -31, -33, -34,
-33, -32, -30, -29, -28, -25, -20, -18, -16, -16, -17, -15, -12, -8, -5, -5, -4,
-2, 1, 3, 2, 0, -1, 0, };