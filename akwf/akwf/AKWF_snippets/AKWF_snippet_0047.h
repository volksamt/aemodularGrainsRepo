#define DATA_LENGTH 512
#define DATA AKWF_snippet_0047

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 6, 39, 42, 41, 38, 56, 113, 104,
104, 103, 99, 95, 82, 59, 54, 42, 44, 34, -55, -79, -79, -83, -83, -82, -84,
-71, -62, -63, -31, -18, -19, -16, -7, -8, -7, -8, -26, -36, -46, -43, -23, -9,
1, 12, 15, 13, 15, 17, 25, 27, 49, 58, 48, 46, 41, 44, 39, 36, 20, 25, -5, -39,
-32, -46, -37, -44, -48, -44, -32, -19, -10, -21, -15, 16, 23, 36, 39, 33, 54,
48, 15, 11, -14, -33, -3, 15, -9, -3, 12, 17, 12, -6, 16, 21, 23, 8, -8, -10,
-16, -13, -21, -15, -29, -25, -47, -71, -65, -58, -47, -42, -9, -10, 7, 19, 24,
36, 52, 86, 78, 68, 63, 54, 43, 37, 34, 34, 27, 11, 7, -27, -46, -39, -32, -34,
-25, -24, -40, -27, -26, -12, -23, -9, 18, 6, 13, 16, 15, 11, 12, 13, 7, 8, 17,
7, -10, -15, -15, -5, -7, 4, 18, 7, 5, 1, -5, -8, -3, -6, -6, -10, -3, -21, -57,
-51, -47, -39, -36, -24, -33, -52, -49, -42, -34, -19, 25, 25, 30, 62, 45, 100,
121, 35, 32, 41, -12, -33, -9, -1, -12, -13, -8, -5, -4, 41, 64, 51, 44, 48, 39,
15, 16, 5, 9, -16, -14, -38, -87, -72, -60, -54, -60, -40, -33, -45, -49, -34,
-27, 3, 68, 76, 66, 66, 57, 78, 105, 99, 72, 49, 17, 8, -42, -80, -68, -69, -79,
-78, -47, -48, -15, -10, -14, 19, 42, 36, 42, 39, 33, 30, -33, -51, -39, -34,
-41, -60, -65, -55, -43, -43, -20, -16, 15, 35, 40, 57, 50, 58, 56, 56, 52, 46,
35, 31, 38, 49, 42, 12, 4, 7, 3, 7, 25, 16, 6, 16, 33, 18, -4, -10, -7, -18,
-22, -28, -90, -104, -93, -92, -82, -84, -84, -77, -64, -57, -45, -47, -9, 27,
22, 20, 25, 28, 10, 22, 18, 24, 34, 49, 54, 39, 45, 47, 56, 52, 62, 65, 64, 55,
53, 61, 70, 58, 38, 29, 26, 2, -17, -16, -27, -26, -47, -40, -44, -52, -52, -51,
-40, -30, -34, -39, -34, -34, -37, -32, -30, -25, -17, -15, -10, -9, -3, -32,
-45, -27, -19, -21, -10, 9, 16, 20, 28, 25, 11, 10, 15, 15, 9, 6, 27, 35, 36,
34, 35, 33, 34, 53, 34, 22, 22, 13, 13, 7, 5, 26, 21, 11, -4, -11, 13, 23, 11,
8, 0, -37, -48, -37, -38, -36, -38, -31, -54, -81, -63, -90, -87, -63, -53, -43,
-38, -20, -11, -8, 6, 19, 26, 26, 38, 26, -6, 5, 39, 44, 43, 41, 54, 74, 61, 63,
74, 107, 102, 79, 82, 73, 62, 45, 34, 13, -10, -12, -34, -39, -51, -65, -75,
-99, -93, -91, -78, -74, -51, -54, -50, -51, -37, -16, -9, 51, 61, 56, 54, 54,
35, 14, 4, 2, 3, -7, -8, -35, -50, -46, -42, -31, -19, 3, 17, 1, 2, 4, 15, 9,
-28, -14, -20, -48, -44, -29, -33, -31, -24, -16, -3, };