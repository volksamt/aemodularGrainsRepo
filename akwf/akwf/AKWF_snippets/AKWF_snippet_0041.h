#define DATA_LENGTH 512
#define DATA AKWF_snippet_0041

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 16, 24, 28, 30, 34, 43, 54, 64,
64, 64, 64, 62, 61, 62, 65, 68, 69, 68, 65, 61, 55, 52, 49, 45, 41, 37, 34, 36,
37, 36, 34, 34, 36, 37, 34, 30, 26, 21, 18, 18, 15, 17, 22, 21, 19, 12, 3, -2,
-6, -11, -14, -16, -18, -22, -25, -31, -36, -36, -35, -33, -33, -35, -39, -42,
-45, -37, -34, -35, -34, -36, -42, -44, -46, -46, -47, -43, -39, -38, -39, -38,
-35, -34, -34, -33, -33, -32, -29, -23, -19, -18, -16, -16, -15, -14, -14, -13,
-13, -12, -11, -12, -12, -11, -7, -3, 1, 7, 10, 17, 22, 25, 31, 36, 38, 37, 37,
34, 31, 27, 23, 23, 23, 24, 23, 22, 24, 23, 21, 20, 19, 19, 18, 13, 11, 11, 12,
10, 10, 12, 13, 10, 8, 13, 17, 19, 22, 23, 25, 22, 18, 16, 16, 13, 11, 11, 6, 3,
3, 4, 5, 5, 5, 1, -2, -1, -5, -7, -10, -16, -22, -24, -25, -25, -22, -17, -13,
-9, -6, -1, 0, -2, -3, -6, -6, -9, -13, -14, -18, -21, -23, -24, -25, -28, -29,
-29, -29, -32, -31, -32, -33, -32, -31, -29, -29, -28, -29, -30, -28, -29, -30,
-30, -30, -28, -26, -23, -18, -13, -9, -7, -8, -8, -6, -6, -3, -3, 0, 4, 4, 6,
9, 10, 11, 12, 12, 11, 8, 6, 5, 3, 2, 1, 4, 8, 9, 10, 12, 13, 13, 16, 16, 17,
17, 17, 17, 17, 14, 12, 9, 8, 5, 3, 4, 1, -2, -2, -3, -4, -3, -3, -4, -8, -9,
-10, -12, -12, -11, -10, -13, -14, -10, -8, -9, -7, -6, -3, 0, 0, 1, 2, 3, 4, 6,
9, 11, 11, 11, 10, 10, 9, 9, 4, 2, -5, 11, 20, 2, 2, 3, 6, 7, 6, 4, 3, 4, 5, 4,
4, 5, 5, 4, 6, 9, 9, 8, 8, 9, 11, 12, 9, 8, 6, 5, 4, 3, 0, -2, -1, 5, 10, -4,
-11, -4, -4, -8, -7, -6, -6, -8, -9, -14, -13, -9, -8, -9, -13, -15, -12, -12,
-11, -14, -17, -12, 8, 23, -3, -8, 3, -6, -7, 0, -17, -10, 55, 58, 5, -41, -27,
15, 25, 21, 21, 26, 17, -8, -13, 18, 24, 12, 9, 11, 14, 9, 11, 9, 20, 17, 8,
-12, -24, -26, -18, 11, -2, -45, -18, 88, 120, 94, -14, -13, 98, 58, -56, -56,
76, 66, 0, 0, 4, -32, -25, 12, 12, 27, 39, 43, 26, 24, 44, 30, 1, 54, 71, 17, 1,
-30, -46, -7, 15, 6, 2, 1, 19, 57, 64, 44, 31, 12, 7, 16, 10, -17, -44, -45,
-40, -28, -16, -18, -28, -36, -36, -36, -36, -39, -46, -46, -44, -43, -48, -53,
-58, -59, -54, -51, -50, -50, -46, -40, -35, -37, -42, -43, -39, -36, -32, -23,
-19, -14, -5, 11, 25, 33, 31, 22, 10, 4, 3, 1, -13, -30, -43, -50, -51, -47,
-43, -37, -27, -18, -13, -10, -4, };