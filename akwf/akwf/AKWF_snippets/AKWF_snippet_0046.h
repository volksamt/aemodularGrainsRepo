#define DATA_LENGTH 512
#define DATA AKWF_snippet_0046

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 32, 52, 68, 80, 85, 84, 78, 67,
52, 34, 17, 0, -14, -24, -29, -31, -32, -30, -28, -27, -27, -29, -33, -39, -43,
-45, -44, -40, -30, -16, 1, 22, 43, 63, 79, 91, 95, 92, 83, 66, 43, 18, -11,
-38, -61, -80, -92, -98, -96, -87, -73, -56, -38, -18, -2, 11, 20, 24, 24, 21,
14, 7, 0, -6, -7, -6, 0, 11, 24, 41, 57, 73, 82, 88, 86, 76, 59, 36, 9, -22,
-51, -77, -99, -111, -116, -113, -100, -79, -52, -23, 7, 33, 53, 67, 72, 70, 59,
44, 27, 11, -3, -12, -17, -15, -8, 1, 16, 30, 43, 52, 57, 57, 50, 39, 24, 5,
-13, -31, -48, -58, -67, -69, -69, -63, -58, -49, -40, -31, -22, -13, -4, 4, 13,
22, 32, 41, 50, 59, 65, 70, 72, 69, 62, 49, 31, 12, -11, -34, -55, -73, -85,
-93, -94, -88, -78, -62, -41, -17, 3, 26, 44, 58, 66, 67, 64, 54, 41, 27, 12,
-3, -14, -22, -26, -28, -26, -22, -18, -13, -9, -6, -5, -4, -6, -7, -10, -12,
-11, -10, -6, -2, 6, 12, 21, 28, 35, 40, 43, 43, 40, 35, 27, 17, 6, -5, -13,
-21, -28, -31, -34, -32, -30, -27, -22, -18, -14, -12, -9, -8, -7, -8, -9, -9,
-9, -7, -3, 2, 7, 15, 23, 30, 37, 41, 44, 44, 42, 37, 30, 20, 9, 0, -11, -21,
-28, -34, -36, -36, -35, -32, -28, -22, -17, -14, -11, -8, -7, -7, -8, -9, -10,
-10, -9, -8, -4, 2, 6, 14, 21, 27, 33, 36, 37, 36, 33, 29, 23, 15, 7, -1, -8,
-16, -20, -23, -25, -25, -23, -20, -15, -11, -6, -3, 1, 3, 5, 5, 4, 2, 2, 0, -1,
-1, 0, 2, 3, 7, 10, 13, 14, 16, 15, 13, 8, 2, -6, -14, -22, -31, -36, -41, -41,
-39, -33, -25, -14, -1, 12, 25, 38, 47, 53, 56, 56, 51, 43, 33, 21, 8, -4, -16,
-27, -33, -38, -41, -42, -41, -38, -35, -31, -28, -26, -22, -17, -12, -6, 1, 11,
22, 32, 44, 54, 62, 67, 68, 65, 57, 46, 29, 12, -7, -25, -40, -52, -61, -63,
-62, -54, -45, -31, -19, -8, 0, 4, 6, 1, -3, -12, -17, -23, -24, -21, -12, -1,
10, 28, 48, 67, 83, 93, 99, 98, 88, 71, 48, 20, -10, -40, -69, -92, -109, -118,
-118, -110, -93, -71, -45, -17, 11, 36, 56, 70, 76, 74, 66, 53, 36, 16, -2, -20,
-34, -44, -49, -48, -42, -32, -22, -9, 3, 14, 22, 28, 30, 29, 26, 21, 16, 10, 5,
2, 1, 1, 2, 4, 9, 11, 13, 13, 12, 8, 3, -3, -10, -17, -23, -28, -31, -31, -29,
-24, -19, -12, -3, 4, 10, 14, 17, 16, 14, 11, 7, 1, -4, -8, -9, -8, -7, -4, 2,
10, 18, 27, 34, 41, 45, 47, 45, 41, 33, 21, 8, -8, -24, -41, -56, -69, -77, -82,
-81, -74, -63, -47, -28, -7, };