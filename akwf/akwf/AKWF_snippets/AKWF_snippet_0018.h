#define DATA_LENGTH 512
#define DATA AKWF_snippet_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 8, 19, 31, 45, 59, 73, 85, 96, 106,
113, 118, 119, 117, 110, 101, 89, 77, 65, 52, 41, 29, 21, 14, 10, 10, 12, 15,
20, 26, 34, 40, 47, 53, 59, 61, 61, 60, 56, 51, 43, 35, 25, 15, 4, -5, -13, -18,
-22, -24, -25, -24, -19, -14, -6, 1, 9, 15, 21, 26, 29, 31, 31, 30, 27, 23, 17,
8, 0, -9, -19, -27, -36, -43, -49, -52, -55, -56, -55, -53, -50, -45, -39, -34,
-27, -22, -17, -14, -11, -10, -11, -13, -16, -22, -27, -33, -39, -45, -50, -54,
-57, -60, -61, -61, -59, -57, -53, -49, -43, -39, -35, -31, -29, -27, -25, -25,
-26, -29, -33, -38, -44, -51, -56, -62, -68, -73, -75, -78, -78, -76, -74, -69,
-63, -56, -51, -44, -38, -34, -28, -26, -23, -22, -22, -23, -25, -30, -34, -39,
-45, -56, -60, -46, -20, -2, -1, -2, 2, 10, 20, 31, 43, 56, 65, 74, 79, 82, 83,
82, 80, 76, 70, 62, 54, 46, 37, 31, 27, 24, 20, 20, 21, 22, 26, 30, 33, 37, 41,
43, 43, 45, 44, 44, 44, 42, 42, 42, 41, 40, 39, 37, 34, 32, 29, 26, 21, 18, 13,
10, 8, 7, 6, 7, 7, 12, 14, 19, 24, 28, 32, 35, 38, 40, 40, 38, 36, 29, 23, 15,
6, -3, -12, -20, -28, -34, -39, -39, -39, -36, -30, -23, -17, -8, 2, 11, 18, 26,
31, 33, 33, 30, 24, 17, 6, -5, -17, -29, -41, -51, -59, -65, -69, -69, -66, -62,
-54, -45, -36, -26, -16, -7, 1, 6, 10, 11, 9, 2, -5, -16, -28, -41, -53, -63,
-73, -79, -82, -83, -80, -74, -64, -51, -36, -21, -6, 7, 16, 21, 23, 20, 12, 1,
-12, -29, -44, -58, -71, -79, -84, -84, -80, -71, -58, -44, -26, -10, 7, 20, 30,
39, 44, 46, 43, 36, 29, 19, 9, -2, -12, -21, -29, -34, -37, -38, -35, -31, -23,
-15, -4, 8, 20, 34, 47, 57, 67, 73, 75, 74, 69, 61, 49, 37, 22, 7, -6, -18, -26,
-31, -33, -29, -23, -12, 1, 15, 32, 47, 62, 75, 85, 94, 99, 98, 93, 87, 75, 63,
50, 36, 22, 9, -2, -12, -19, -24, -25, -25, -20, -14, -8, 0, 8, 16, 22, 27, 31,
34, 34, 30, 25, 19, 11, 3, -7, -14, -22, -29, -34, -37, -38, -37, -37, -34, -32,
-28, -25, -21, -18, -15, -14, -14, -13, -15, -17, -20, -23, -27, -33, -39, -45,
-52, -57, -64, -69, -75, -79, -83, -84, -84, -80, -76, -71, -64, -55, -46, -37,
-28, -20, -13, -6, -2, 2, 3, 4, 1, -3, -10, -17, -26, -33, -42, -49, -57, -62,
-65, -66, -65, -61, -53, -44, -30, -16, -1, 14, 26, 36, 45, 51, 54, 54, 50, 43,
34, 23, 13, 5, -3, -9, -13, -14, -12, -7, 2, 15, 27, 40, 55, 67, 79, 89, 97,
100, 100, 96, 89, 80, 68, 54, 41, 29, 17, 8, 2, -2, -2, };