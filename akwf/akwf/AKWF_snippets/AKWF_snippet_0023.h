#define DATA_LENGTH 512
#define DATA AKWF_snippet_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 6, 4, 4, 4, 7, 12, 17, 17, 12,
5, 1, 2, 7, 14, 16, 15, 12, 15, 21, 31, 36, 34, 27, 20, 17, 19, 26, 33, 40, 43,
46, 45, 48, 54, 62, 70, 73, 74, 74, 77, 81, 86, 91, 94, 95, 97, 99, 96, 95, 92,
93, 96, 96, 94, 89, 83, 80, 75, 71, 68, 66, 65, 63, 61, 60, 62, 65, 68, 69, 69,
66, 66, 68, 73, 77, 79, 78, 77, 78, 78, 80, 81, 82, 80, 73, 67, 65, 68, 72, 74,
70, 63, 56, 53, 52, 57, 62, 65, 64, 62, 59, 59, 61, 64, 67, 69, 68, 67, 67, 69,
70, 73, 71, 69, 68, 71, 76, 81, 86, 88, 89, 89, 89, 89, 89, 88, 88, 89, 88, 87,
85, 84, 84, 84, 85, 84, 85, 84, 83, 84, 84, 84, 84, 84, 83, 82, 79, 79, 79, 78,
78, 78, 77, 76, 76, 76, 75, 76, 75, 74, 73, 74, 75, 75, 76, 75, 74, 73, 72, 72,
73, 73, 73, 73, 71, 70, 69, 68, 66, 67, 67, 67, 66, 64, 62, 63, 64, 65, 66, 65,
63, 62, 62, 62, 61, 61, 61, 63, 64, 65, 64, 62, 61, 59, 58, 61, 63, 63, 58, 52,
49, 50, 53, 52, 47, 43, 40, 35, 29, 26, 25, 29, 33, 36, 41, 46, 51, 54, 52, 49,
47, 47, 47, 49, 49, 47, 44, 43, 40, 43, 46, 48, 48, 48, 47, 47, 47, 46, 44, 38,
30, 20, 13, 16, 22, 28, 33, 37, 35, 31, 23, 14, 9, 13, 21, 29, 33, 32, 32, 33,
34, 35, 34, 32, 25, 17, 10, 6, 6, 7, 2, -7, -23, -33, -38, -37, -34, -32, -33,
-36, -37, -38, -37, -32, -24, -18, -19, -24, -31, -37, -43, -51, -59, -60, -52,
-42, -33, -27, -27, -33, -41, -52, -59, -58, -56, -59, -66, -73, -75, -76, -77,
-79, -79, -76, -73, -74, -81, -89, -94, -94, -89, -85, -87, -94, -101, -104,
-104, -100, -92, -86, -85, -87, -91, -93, -94, -94, -95, -92, -88, -85, -80,
-70, -57, -40, -29, -29, -38, -50, -65, -77, -88, -92, -88, -79, -73, -75, -80,
-84, -79, -66, -57, -55, -59, -65, -67, -68, -70, -73, -72, -69, -64, -62, -61,
-59, -56, -51, -47, -46, -46, -43, -38, -36, -43, -58, -72, -81, -84, -80, -78,
-79, -85, -90, -91, -84, -80, -84, -95, -104, -108, -107, -106, -106, -105,
-106, -106, -104, -102, -97, -93, -94, -96, -100, -102, -104, -106, -107, -107,
-104, -100, -99, -100, -107, -113, -118, -118, -115, -105, -97, -92, -93, -97,
-103, -108, -112, -112, -113, -110, -106, -103, -101, -99, -96, -91, -88, -88,
-91, -93, -93, -92, -90, -93, -96, -96, -95, -94, -91, -89, -88, -87, -88, -83,
-81, -81, -86, -90, -87, -82, -80, -82, -85, -84, -83, -81, -82, -81, -76, -75,
-72, -69, -64, -62, -64, -71, -15, 40, 32, 23, 19, 17, 15, 14, 9, 0, -10, -18,
-21, -20, -16, -10, -2, };