#define DATA_LENGTH 512
#define DATA AKWF_snippet_0034

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 12, 28, 57, 77, 99, 118, 116,
101, 89, 92, 79, 53, 33, 15, 15, 25, 23, 16, 4, -12, 1, 24, 21, -10, -35, -27,
-17, -27, -14, 3, 0, 12, 21, 21, 8, -7, -1, 4, 2, -5, -11, -2, 11, 1, -3, -10,
-40, -50, -47, -45, -63, -96, -90, -71, -67, -71, -77, -83, -77, -59, -56, -61,
-40, 9, 23, -11, -14, 13, 20, 0, -27, -18, 20, 45, 50, 47, 46, 50, 62, 74, 64,
28, 3, -3, -15, -33, -55, -60, -43, -39, -48, -47, -28, -13, -10, 5, 3, -15, 3,
37, 49, 39, 35, 54, 72, 88, 81, 54, 42, 44, 49, 38, 23, 17, 26, 32, 17, 4, 3, 9,
-2, -18, -28, -41, -39, -26, -9, 12, 16, 13, 10, -3, -22, -40, -52, -69, -90,
-106, -109, -106, -101, -94, -78, -57, -55, -48, -32, -33, -34, -37, -46, -51,
-44, -27, -17, -15, -25, -31, -34, -30, -27, -39, -37, -27, -30, -21, 1, 15, 18,
18, 11, -1, -7, -3, 3, -8, -26, -20, -1, 12, 20, 33, 43, 55, 71, 70, 61, 63, 70,
75, 68, 58, 59, 69, 76, 71, 56, 48, 38, 21, 15, 15, -4, -18, -19, -13, -12, -15,
-2, 0, -2, 6, 23, 17, -4, 0, 16, 9, -12, -20, -27, -34, -23, -18, -20, -30, -34,
-20, -9, 0, 2, 1, 6, 14, 24, 33, 24, 7, 12, 23, 17, -5, -15, -1, 4, -10, -19,
-2, 22, 35, 35, 29, 35, 48, 46, 35, 22, 17, 28, 34, 13, -31, -44, -14, -1, -33,
-69, -75, -55, -26, -15, -35, -40, -11, 19, 19, -2, -4, 25, 53, 51, 35, 35, 51,
63, 67, 54, 26, 22, 34, 43, 40, 15, 1, 7, 11, 18, 26, 27, 28, 26, 23, 19, 6, -2,
1, -8, -19, -21, -19, -11, -16, -22, -15, -18, -26, -38, -49, -56, -65, -67,
-57, -48, -44, -40, -34, -25, -13, -7, -10, -19, -22, -9, 2, -2, -10, -3, 20,
32, 26, 20, 22, 22, 20, 7, -8, -20, -19, -12, -21, -39, -41, -13, -4, -25, -30,
-20, -9, -7, -13, -6, 3, 1, -2, 16, 33, 26, 23, 21, 15, 14, 22, 17, 5, 6, 19,
32, 42, 40, 25, 18, 12, 9, 9, -5, 0, 15, 13, 10, 6, 5, 14, -2, -12, -11, -23,
-19, -16, -20, -21, -19, -9, 1, -9, -27, -27, -12, 9, 3, -33, -60, -57, -39,
-42, -53, -58, -46, -15, 3, -22, -44, -21, 9, 7, -30, -57, -43, -17, 0, -10,
-28, -28, -11, 13, 16, -1, -4, 22, 46, 48, 52, 69, 94, 89, 80, 97, 99, 90, 90,
83, 58, 34, 41, 31, 7, 18, 25, 8, -4, 13, 14, -26, -51, -47, -44, -56, -64, -63,
-55, -30, -11, -12, -17, -7, 12, 23, 26, 19, 26, 44, 57, 56, 42, 43, 52, 38, 8,
-5, 10, 21, 19, 8, -3, -11, -23, -25, -38, -64, -76, -84, -82, -75, -64, -57,
-52, -31, -10, -10, -14, -5, };