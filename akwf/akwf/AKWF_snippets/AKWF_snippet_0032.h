#define DATA_LENGTH 512
#define DATA AKWF_snippet_0032

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 11, 17, 14, 12, 12, 14, 18, 18, 17,
14, 12, 16, 23, 30, 33, 31, 30, 34, 43, 55, 63, 63, 59, 51, 46, 41, 37, 31, 24,
21, 24, 30, 37, 41, 42, 45, 49, 53, 57, 58, 58, 53, 46, 40, 34, 30, 27, 23, 18,
16, 19, 26, 38, 51, 60, 62, 60, 56, 55, 58, 62, 65, 63, 57, 50, 46, 49, 58, 68,
76, 81, 84, 87, 91, 94, 95, 94, 91, 93, 96, 102, 104, 101, 93, 83, 74, 69, 70,
77, 88, 100, 110, 116, 118, 119, 116, 111, 104, 96, 92, 89, 87, 85, 82, 81, 80,
83, 87, 89, 91, 92, 91, 86, 81, 77, 76, 80, 89, 97, 105, 108, 108, 106, 102, 98,
95, 94, 95, 99, 104, 108, 109, 106, 102, 97, 91, 87, 81, 78, 76, 79, 84, 89, 92,
89, 84, 75, 67, 64, 65, 68, 68, 64, 59, 53, 53, 59, 66, 71, 78, 74, 35, -11,
-28, -29, -28, -25, -25, -30, -41, -42, -29, -11, 6, 7, -5, -19, -27, -21, -7,
7, 17, 17, 13, 9, 3, -4, -10, -17, -17, -14, -10, -7, -6, -5, -1, 4, 13, 19, 21,
18, 12, 10, 9, 11, 10, 9, 5, 0, -4, -8, -10, -10, -7, -3, 3, 8, 13, 18, 19, 19,
18, 17, 19, 23, 29, 31, 27, 18, 6, -2, -6, -8, -7, -5, -2, 2, 6, 7, 11, 13, 15,
18, 19, 18, 12, 5, -2, -6, -10, -13, -15, -17, -17, -15, -13, -9, -5, -2, 2, 3,
0, -5, -11, -14, -11, -3, 7, 12, 13, 5, -4, -14, -20, -23, -24, -21, -15, -7,
-2, -1, -6, -16, -24, -25, -19, -10, -5, -4, -10, -15, -18, -16, -13, -12, -15,
-23, -32, -38, -41, -41, -41, -43, -49, -55, -56, -50, -40, -27, -21, -21, -28,
-38, -47, -54, -57, -59, -61, -63, -66, -70, -74, -77, -80, -79, -75, -70, -62,
-53, -45, -39, -36, -39, -46, -55, -64, -69, -76, -80, -84, -85, -78, -65, -52,
-43, -47, -57, -68, -76, -77, -78, -81, -82, -79, -71, -62, -60, -66, -80, -94,
-99, -97, -92, -87, -84, -81, -79, -79, -81, -84, -86, -80, -72, -62, -55, -54,
-58, -65, -71, -75, -76, -74, -70, -70, -74, -82, -87, -92, -89, -84, -79, -76,
-74, -74, -77, -79, -77, -69, -53, -40, -34, -41, -58, -76, -90, -96, -96, -95,
-87, -66, -39, -12, -5, -16, -36, -54, -54, -47, -44, -51, -71, -86, -87, -74,
-51, -36, -33, -37, -41, -39, -32, -29, -32, -42, -51, -52, -41, -21, -7, -6,
-17, -39, -57, -65, -60, -45, -27, -12, -8, -16, -35, -54, -68, -70, -61, -49,
-38, -36, -35, -33, -28, -19, -12, -9, -13, -22, -30, -40, -44, -42, -36, -30,
-28, -30, -38, -45, -41, -29, -9, 9, 15, 10, -3, -14, -14, -7, 3, 2, -10, -31,
-52, -58, -53, -39, -25, -14, -4, 6, 14, 19, 16, 8, 1, -4, -4, -5, -9, -15, -18,
-17, -7, };