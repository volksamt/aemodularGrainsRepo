#define DATA_LENGTH 512
#define DATA AKWF_snippet_0044

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 17, 22, 27, 31, 36, 40, 44, 46,
48, 48, 49, 51, 53, 54, 55, 57, 63, 69, 72, 77, 82, 89, 94, 98, 100, 103, 110,
116, 116, 116, 118, 119, 116, 111, 113, 118, 115, 104, 96, 93, 92, 91, 88, 81,
73, 71, 65, 57, 49, 42, 34, 25, 14, 5, -4, -14, -21, -24, -26, -30, -35, -36,
-37, -38, -39, -37, -37, -39, -41, -42, -44, -45, -43, -40, -41, -40, -37, -34,
-32, -31, -31, -33, -35, -38, -41, -45, -48, -51, -52, -51, -51, -48, -48, -44,
-42, -41, -41, -43, -45, -48, -50, -51, -53, -55, -55, -53, -53, -51, -50, -48,
-49, -51, -55, -59, -60, -61, -65, -69, -69, -71, -70, -70, -71, -71, -68, -66,
-65, -65, -65, -64, -62, -59, -54, -47, -40, -33, -28, -21, -15, -7, -1, 2, 5,
5, 5, 5, 4, 2, 2, 2, 0, 0, 0, 4, 9, 13, 19, 24, 29, 36, 41, 46, 49, 52, 54, 57,
59, 62, 65, 69, 72, 77, 80, 83, 84, 86, 87, 87, 87, 84, 80, 76, 71, 66, 63, 60,
57, 54, 52, 49, 48, 44, 40, 35, 30, 24, 19, 13, 11, 8, 5, 4, 2, 3, 3, 3, 4, 4,
5, 6, 6, 7, 7, 6, 6, 7, 6, 7, 7, 6, 6, 4, 2, 0, 0, -2, -3, -5, -7, -8, -9, -11,
-11, -10, -9, -6, -3, 2, 5, 10, 14, 17, 19, 22, 21, 22, 20, 20, 18, 17, 15, 14,
12, 10, 10, 9, 10, 9, 10, 12, 10, 12, 11, 10, 10, 9, 7, 5, 5, 3, 2, 1, 1, 1, 0,
0, 1, 1, 0, 1, 2, 4, 5, 9, 12, 14, 19, 22, 26, 29, 32, 36, 37, 39, 41, 42, 42,
42, 41, 39, 37, 34, 33, 31, 29, 28, 24, 22, 20, 17, 15, 11, 8, 5, 3, 1, -1, -1,
0, 1, 4, 7, 10, 14, 18, 21, 25, 29, 32, 35, 39, 43, 46, 48, 51, 53, 55, 56, 56,
57, 56, 54, 50, 48, 44, 39, 33, 27, 22, 15, 7, 1, -5, -12, -17, -24, -31, -37,
-43, -48, -54, -58, -62, -65, -67, -71, -72, -74, -75, -76, -75, -76, -77, -76,
-75, -73, -71, -70, -68, -65, -63, -59, -57, -55, -54, -51, -49, -48, -46, -46,
-44, -42, -40, -39, -36, -33, -31, -27, -26, -23, -21, -19, -18, -16, -17, -16,
-15, -16, -15, -15, -15, -15, -15, -15, -15, -16, -15, -14, -13, -14, -14, -13,
-13, -13, -14, -14, -15, -16, -16, -16, -16, -16, -14, -14, -13, -13, -11, -10,
-8, -5, -4, -1, 3, 6, 10, 14, 18, 23, 28, 31, 35, 38, 42, 43, 41, 42, 43, 45,
45, 44, 41, 36, 28, 20, 6, -8, -18, -25, -34, -42, -48, -53, -57, -63, -74, -82,
-85, -89, -95, -97, -98, -106, -108, -97, -85, -82, -85, -89, -82, -72, -71,
-68, -60, -51, -37, -32, -31, -28, -19, -17, -18, -20, -24, -26, -23, -22, -20,
-15, -8, -2, };