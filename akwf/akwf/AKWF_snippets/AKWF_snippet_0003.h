#define DATA_LENGTH 512
#define DATA AKWF_snippet_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 12, 12, 21, 11, 17, 31, 29, 44, 52,
64, 80, 72, 77, 82, 75, 75, 56, 46, 56, 57, 64, 69, 85, 95, 88, 82, 82, 79, 73,
65, 56, 61, 69, 76, 81, 84, 98, 101, 98, 99, 104, 104, 101, 91, 92, 101, 100,
97, 90, 94, 105, 103, 103, 109, 115, 120, 117, 112, 112, 111, 111, 108, 99, 103,
104, 94, 92, 88, 89, 80, 67, 71, 80, 92, 100, 96, 99, 98, 95, 96, 94, 95, 95,
93, 90, 91, 91, 89, 90, 88, 91, 90, 89, 84, 79, 78, 69, 65, 67, 81, 87, 87, 83,
75, 85, 84, 79, 80, 82, 84, 82, 80, 78, 75, 76, 79, 75, 76, 74, 63, 62, 68, 74,
80, 68, 61, 59, 49, 41, 22, 20, 28, 22, 19, 10, 22, 38, 34, 39, 40, 45, 42, 30,
24, 19, 12, 0, -13, -13, -6, -1, -7, -8, 9, 21, 28, 14, 6, 10, -3, -13, -21,
-13, -7, -23, -25, -26, -27, -30, -48, -59, -62, -59, -56, -60, -49, -33, -30,
-41, -42, -40, -39, -46, -59, -54, -49, -30, -19, -13, 8, 4, -13, -33, -53, -55,
-75, -91, -94, -99, -90, -93, -96, -86, -87, -81, -85, -85, -73, -75, -78, -75,
-71, -53, -44, -45, -43, -45, -40, -47, -56, -55, -64, -74, -83, -89, -89, -86,
-89, -88, -90, -93, -94, -95, -91, -89, -92, -91, -87, -77, -59, -54, -46, -42,
-54, -55, -66, -75, -76, -85, -82, -83, -76, -62, -60, -46, -37, -33, -34, -44,
-45, -53, -63, -70, -68, -63, -58, -53, -55, -53, -54, -57, -67, -71, -71, -72,
-68, -61, -55, -47, -42, -47, -44, -45, -45, -49, -47, -35, -24, -1, 11, 21, 27,
19, 9, -6, -18, -32, -44, -50, -50, -47, -43, -40, -33, -26, -24, -19, -15, -10,
-8, -2, 1, 7, 14, 17, 23, 30, 33, 35, 36, 34, 40, 41, 39, 34, 21, 15, 4, -4,
-10, -16, -9, -7, -9, -2, -1, 2, 7, 7, 24, 38, 54, 62, 61, 70, 71, 63, 54, 37,
29, 18, 6, 13, 29, 48, 63, 69, 74, 71, 62, 51, 28, 19, 14, 14, 21, 31, 50, 61,
57, 56, 53, 54, 42, 32, 28, 28, 36, 44, 45, 46, 54, 46, 44, 34, 42, 44, 54, 63,
79, 88, 105, 89, 102, 79, -60, -66, -67, -67, -55, -55, -60, -71, -86, -88, -91,
-106, -95, -105, -102, -98, -99, -96, -96, -95, -93, -92, -88, -90, -82, -75,
-69, -64, -66, -70, -73, -64, -73, -81, -83, -81, -80, -82, -78, -78, -77, -76,
-78, -76, -76, -73, -72, -72, -71, -70, -71, -72, -73, -71, -70, -71, -66, -67,
-66, -67, -65, -62, -61, -65, -65, -63, -66, -62, -61, -62, -60, -52, -38, -33,
-32, -31, -35, -32, -39, -47, -51, -56, -57, -58, -59, -60, -58, -56, -55, -52,
-44, -36, -28, -24, -21, -11, -11, -16, -9, -6, 1, 7, 11, 26, 39, 41, 41, 31,
25, 14, -7, -4, -12, -7, 5, -3, };