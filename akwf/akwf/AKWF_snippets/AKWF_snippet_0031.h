#define DATA_LENGTH 512
#define DATA AKWF_snippet_0031

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 9, 13, 17, 21, 22, 22, 20, 20,
20, 21, 27, 33, 42, 52, 58, 59, 56, 51, 44, 38, 30, 26, 26, 29, 35, 34, 30, 24,
21, 25, 33, 42, 48, 51, 52, 53, 51, 46, 44, 43, 45, 50, 55, 58, 64, 70, 74, 77,
78, 77, 76, 77, 77, 76, 75, 73, 70, 70, 70, 73, 77, 79, 80, 79, 78, 81, 83, 86,
82, 80, 74, 72, 72, 71, 71, 69, 66, 62, 59, 57, 57, 56, 56, 54, 52, 55, 57, 60,
57, 53, 48, 46, 47, 48, 49, 48, 46, 45, 49, 52, 54, 57, 57, 59, 59, 61, 64, 64,
63, 59, 56, 55, 53, 50, 43, 37, 32, 29, 27, 31, 20, -34, -73, -68, -58, -55,
-52, -50, -50, -48, -45, -41, -36, -32, -29, -28, -30, -35, -42, -47, -47, -44,
-38, -30, -22, -16, -11, -7, -4, 0, 4, 12, 19, 26, 28, 29, 25, 20, 12, 5, 1, 3,
10, 17, 22, 24, 24, 27, 31, 35, 40, 43, 45, 45, 43, 41, 36, 34, 35, 35, 37, 37,
37, 38, 40, 44, 48, 53, 59, 60, 62, 61, 58, 57, 56, 53, 51, 51, 51, 55, 59, 61,
61, 60, 59, 58, 59, 60, 62, 64, 66, 66, 65, 64, 63, 63, 64, 68, 72, 75, 78, 78,
80, 80, 84, 87, 90, 90, 90, 89, 87, 85, 83, 81, 80, 81, 83, 83, 81, 80, 78, 78,
78, 80, 82, 85, 86, 84, 81, 77, 74, 71, 72, 72, 71, 72, 74, 73, 73, 70, 65, 62,
58, 56, 54, 54, 56, 61, 66, 69, 70, 71, 69, 66, 63, 59, 56, 54, 55, 55, 55, 55,
55, 56, 58, 59, 60, 60, 58, 55, 55, 54, 54, 57, 56, 52, 47, 37, 29, 25, 25, 26,
29, 32, 32, 31, 29, 25, 23, 20, 14, 6, -4, -11, -10, -5, 2, 7, 7, 5, 3, 2, 2, 1,
-2, -7, -12, -18, -24, -29, -31, -31, -32, -34, -40, -46, -49, -43, -34, -23,
-19, -20, -25, -29, -29, -31, -34, -42, -54, -66, -79, -88, -93, -96, -96, -95,
-95, -97, -100, -103, -105, -106, -103, -99, -95, -94, -96, -102, -106, -108,
-107, -104, -102, -103, -106, -110, -113, -115, -119, -119, -118, -116, -112,
-107, -102, -97, -96, -98, -100, -101, -101, -97, -91, -87, -85, -83, -86, -89,
-90, -88, -86, -84, -84, -85, -87, -89, -88, -88, -86, -84, -83, -83, -84, -85,
-87, -87, -86, -83, -81, -79, -76, -76, -76, -78, -80, -81, -80, -80, -81, -83,
-84, -83, -80, -75, -70, -68, -65, -65, -66, -67, -68, -69, -69, -68, -68, -70,
-71, -72, -70, -67, -65, -65, -66, -66, -65, -64, -63, -63, -66, -71, -75, -74,
-67, -58, -51, -51, -62, -77, -89, -95, -96, -92, -86, -79, -73, -70, -71, -78,
-86, -93, -98, -98, -99, -96, -94, -91, -91, -91, -91, -88, -85, -79, -76, -74,
-73, -77, -81, -85, -85, -78, -68, -59, -55, -55, -56, -52, -41, -26, -12, -2,
};