#define DATA_LENGTH 512
#define DATA AKWF_snippet_0029

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 8, 11, 13, 16, 20, 23, 24,
26, 28, 31, 35, 38, 41, 44, 50, 56, 60, 61, 64, 66, 69, 72, 74, 76, 76, 79, 81,
83, 85, 88, 89, 91, 92, 94, 95, 98, 100, 101, 102, 104, 104, 105, 105, 105, 105,
106, 106, 109, 106, 97, 90, 86, 81, 79, 77, 74, 71, 70, 68, 66, 67, 66, 64, 68,
78, 84, 85, 88, 90, 91, 94, 97, 99, 101, 102, 103, 102, 102, 102, 103, 103, 103,
102, 100, 99, 98, 96, 94, 92, 92, 91, 90, 88, 86, 86, 84, 82, 81, 82, 82, 82,
82, 83, 81, 81, 81, 81, 81, 81, 81, 79, 80, 80, 78, 77, 77, 76, 74, 73, 71, 66,
62, 58, 56, 52, 48, 44, 40, 34, 31, 28, 23, 21, 17, 15, 13, 13, 12, 11, 11, 12,
13, 13, 14, 14, 14, 16, 17, 19, 20, 21, 21, 22, 23, 24, 23, 22, 21, 21, 19, 19,
18, 18, 18, 16, 16, 15, 14, 13, 12, 11, 8, 7, 6, 5, 5, 4, 2, 1, -1, -4, -6, -10,
-10, -12, -14, -20, -23, -31, -38, -46, -49, -55, -59, -66, -69, -74, -76, -79,
-82, -86, -89, -92, -105, 18, 78, 53, 63, 54, 56, 48, 47, 41, 39, 33, 32, 28,
26, 24, 21, 20, 19, 18, 15, 14, 12, 12, 11, 12, 10, 10, 11, 12, 12, 13, 12, 11,
12, 11, 10, 10, 9, 8, 7, 7, 5, 4, 4, 2, 2, 1, 0, -1, -2, -2, -4, -6, -7, -11,
-11, -14, -18, -19, -21, -25, -28, -29, -32, -35, -36, -40, -44, -47, -51, -61,
-70, -75, -77, -79, -81, -84, -87, -90, -92, -94, -95, -95, -96, -98, -99, -99,
-100, -100, -102, -102, -101, -102, -103, -104, -104, -105, -104, -102, -101,
-99, -99, -97, -95, -94, -94, -93, -90, -87, -85, -83, -82, -81, -79, -78, -78,
-76, -74, -74, -74, -73, -72, -71, -70, -69, -69, -68, -68, -68, -66, -65, -64,
-64, -62, -62, -59, -56, -55, -51, -47, -44, -42, -37, -38, -44, -48, -47, -46,
-44, -39, -35, -32, -29, -25, -18, -7, 3, 11, 20, 35, 47, 54, 61, 67, 70, 75,
78, 82, 86, 89, 90, 91, 92, 93, 91, 92, 91, 92, 91, 91, 92, 93, 93, 90, 88, 86,
84, 82, 81, 79, 76, 74, 72, 69, 66, 63, 60, 56, 52, 46, 41, 37, 31, 24, 19, 13,
0, -13, -22, -27, -32, -38, -41, -46, -52, -58, -64, -70, -74, -80, -85, -89,
-93, -100, -104, -107, -109, -111, -114, -114, -117, -118, -119, -119, -119,
-117, -116, -117, -115, -113, -112, -111, -110, -107, -108, -107, -105, -103,
-103, -103, -104, -104, -102, -100, -99, -97, -94, -91, -89, -88, -85, -83, -79,
-76, -73, -69, -67, -64, -61, -59, -55, -52, -52, -50, -49, -48, -50, -50, -51,
-51, -52, -51, -51, -51, -51, -53, -54, -54, -53, -52, -50, -48, -43, -40, -37,
-33, -29, -25, -22, -19, -17, -13, -9, -7, -2, };