#define DATA_LENGTH 512
#define DATA AKWF_snippet_0039

const PROGMEM int8_t DATA[DATA_LENGTH] = {14, 38, 24, 16, 44, 31, 20, 35, 53,
59, 25, 23, 42, 27, 57, 68, 41, 73, 81, 84, 95, 80, 84, 103, 110, 103, 93, 96,
104, 112, 106, 101, 110, 110, 110, 110, 110, 110, 110, 110, 110, 111, 110, 111,
111, 110, 109, 110, 110, 110, 108, 107, 110, 110, 110, 110, 110, 109, 110, 111,
109, 110, 110, 110, 110, 110, 109, 110, 110, 110, 110, 110, 110, 110, 110, 109,
110, 110, 110, 110, 109, 110, 109, 110, 110, 109, 109, 109, 110, 110, 110, 109,
109, 110, 109, 110, 109, 110, 109, 109, 110, 109, 109, 109, 109, 109, 109, 109,
109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 108, 109, 109, 109,
109, 110, 110, 109, 109, 108, 109, 110, 109, 109, 109, 109, 109, 109, 108, 108,
109, 110, 109, 108, 109, 109, 108, 108, 109, 109, 108, 109, 109, 109, 108, 108,
108, 108, 109, 108, 109, 108, 109, 109, 109, 108, 108, 108, 108, 108, 109, 109,
109, 108, 108, 109, 108, 108, 108, 108, 108, 109, 108, 109, 108, 109, 108, 108,
108, 108, 108, 108, 108, 108, 107, 107, 108, 108, 108, 109, 109, 108, 109, 108,
108, 108, 107, 108, 108, 108, 108, 107, 108, 107, 108, 108, 108, 107, 107, 108,
108, 108, 108, 107, 109, 108, 108, 108, 108, 108, 109, 107, 108, 107, 108, 106,
109, 106, 100, 107, 108, 97, 97, 97, 98, 111, 93, 80, 78, 92, 77, 71, 64, 45,
43, 14, 8, 8, 23, 38, 57, 44, 30, 20, 34, 32, 13, 31, 24, -5, -5, -11, -52, -70,
-76, -66, -34, -27, -47, -52, -63, -89, -92, -64, -81, -91, -102, -122, -117,
-120, -118, -120, -118, -120, -118, -120, -119, -119, -120, -119, -119, -119,
-119, -118, -120, -118, -119, -118, -119, -118, -119, -118, -120, -118, -119,
-118, -119, -118, -119, -118, -119, -118, -119, -118, -118, -119, -119, -119,
-119, -118, -119, -119, -118, -119, -118, -118, -118, -118, -119, -118, -118,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -118, -118, -118, -118,
-118, -118, -118, -118, -117, -118, -118, -118, -118, -118, -119, -118, -118,
-118, -118, -118, -118, -118, -119, -118, -118, -119, -117, -118, -118, -118,
-117, -118, -118, -117, -118, -118, -118, -118, -118, -118, -117, -117, -118,
-118, -118, -118, -118, -117, -118, -118, -118, -118, -118, -117, -117, -118,
-117, -117, -118, -117, -118, -117, -117, -117, -117, -117, -117, -116, -118,
-118, -117, -117, -117, -117, -118, -117, -118, -117, -118, -117, -117, -116,
-117, -117, -117, -116, -117, -117, -117, -117, -117, -117, -116, -117, -117,
-116, -117, -117, -116, -117, -117, -117, -116, -117, -117, -117, -117, -116,
-116, -117, -117, -117, -117, -117, -117, -117, -117, -117, -117, -116, -117,
-117, -117, -117, -116, -116, -117, -117, -116, -115, -117, -116, -116, -116,
-116, -116, -116, -116, -116, -116, -116, -117, -116, -115, -103, -80, -67, -67,
-89, -83, -54, -46, -35, -21, -31, -70, -70, -67, -33, -1, -1, 1, };