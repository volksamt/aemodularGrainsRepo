#define DATA_LENGTH 512
#define DATA AKWF_snippet_0026

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 79, 103, 87, 73, 67, 68, 66, 65,
63, 63, 59, 57, 55, 53, 52, 53, 53, 53, 54, 57, 58, 59, 60, 60, 61, 61, 62, 64,
67, 68, 71, 73, 72, 73, 72, 71, 69, 65, 61, 56, 51, 47, 45, 41, 40, 39, 36, 34,
31, 26, 20, 15, 8, 1, -5, -11, -15, -18, -19, -20, -20, -18, -17, -14, -10, -6,
-1, 5, 11, 17, 22, 25, 28, 31, 30, 29, 26, 20, 14, 5, -6, -17, -28, -39, -48,
-57, -65, -71, -77, -79, -80, -80, -77, -74, -71, -66, -59, -52, -44, -36, -27,
-19, -13, -10, -10, -14, -20, -28, -39, -51, -64, -76, -86, -94, -100, -103,
-104, -103, -102, -98, -94, -91, -88, -86, -84, -81, -78, -72, -64, -56, -47,
-39, -33, -30, -29, -31, -34, -38, -43, -45, -48, -50, -50, -51, -51, -54, -56,
-61, -66, -71, -74, -77, -80, -82, -84, -86, -86, -86, -85, -82, -77, -74, -70,
-68, -68, -68, -69, -68, -68, -68, -65, -63, -59, -56, -53, -51, -48, -47, -46,
-45, -44, -45, -45, -45, -45, -46, -46, -47, -46, -46, -46, -46, -44, -44, -44,
-43, -41, -42, -42, -41, -40, -39, -36, -33, -28, -24, -19, -15, -11, -7, -2, 2,
5, 8, 10, 13, 14, 14, 13, 10, 5, 1, -4, -7, -8, -9, -6, -4, -3, -1, -2, -3, -5,
-7, -10, -12, -13, -14, -11, -8, -4, 1, 5, 8, 11, 13, 16, 18, 22, 24, 25, 27,
24, 19, 14, 9, 4, -1, -3, -3, -4, -2, -2, 0, 3, 5, 7, 8, 8, 7, 7, 5, 6, 6, 8,
10, 12, 15, 19, 21, 23, 23, 24, 24, 23, 23, 22, 23, 22, 22, 22, 25, 28, 31, 35,
38, 40, 40, 38, 33, 26, 18, 9, 1, -8, -15, -23, -28, -34, -37, -39, -38, -38,
-34, -33, -29, -26, -22, -17, -11, -3, 5, 15, 25, 36, 45, 53, 58, 60, 59, 56,
51, 45, 40, 35, 29, 24, 19, 13, 9, 4, 0, -2, -2, -1, 1, 5, 10, 17, 26, 37, 49,
59, 69, 77, 82, 85, 86, 85, 84, 82, 79, 74, 69, 64, 56, 49, 41, 33, 26, 20, 16,
13, 10, 13, 15, 22, 29, 38, 47, 56, 64, 71, 78, 85, 90, 94, 98, 100, 101, 101,
99, 97, 94, 90, 85, 81, 74, 68, 61, 53, 46, 39, 33, 27, 23, 20, 20, 21, 23, 25,
27, 30, 33, 37, 41, 46, 51, 56, 59, 62, 64, 65, 64, 63, 61, 59, 56, 53, 51, 48,
46, 42, 39, 35, 30, 25, 19, 14, 9, 5, 2, -1, -3, -3, -2, 2, 5, 8, 9, 11, 9, 8,
7, 6, 5, 5, 4, 4, 3, 3, 2, 2, 2, 2, 0, -1, 1, 0, 0, 0, -2, -4, -7, -10, -12,
-15, -17, -20, -25, -29, -35, -41, -45, -51, -54, -58, -60, -64, -65, -67, -66,
-67, -66, -64, -63, -63, -62, -61, -60, -60, -60, -60, -64, -66, -72, -76, -95,
-114, -116, -56, };