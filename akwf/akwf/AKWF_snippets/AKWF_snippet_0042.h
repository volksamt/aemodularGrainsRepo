#define DATA_LENGTH 512
#define DATA AKWF_snippet_0042

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 11, 12, 3, 10, 18, 23, 31, 32, 33,
34, 37, 45, 54, 60, 64, 69, 75, 79, 79, 78, 79, 76, 74, 75, 74, 73, 77, 78, 82,
85, 88, 85, 83, 81, 79, 76, 75, 72, 64, 54, 44, 38, 33, 28, 25, 20, 10, -2, -16,
-25, -28, -27, -23, -17, -6, 3, 10, 16, 21, 22, 23, 26, 27, 22, 15, 3, -15, -31,
-47, -62, -75, -88, -99, -107, -113, -117, -118, -117, -117, -119, -120, -117,
-113, -110, -107, -104, -96, -88, -79, -68, -53, -39, -26, -16, -10, -6, -3, -2,
-1, 1, 2, 2, 3, 4, 3, 1, 1, 4, 5, 4, 3, 4, 5, 6, 7, 6, 4, 2, 3, 5, 9, 13, 15,
20, 25, 29, 34, 41, 46, 50, 54, 57, 60, 60, 61, 62, 62, 63, 64, 64, 64, 61, 58,
55, 51, 44, 36, 28, 18, 8, 1, -3, -5, -7, -6, -6, -5, -2, -1, 2, 6, 8, 9, 9, 8,
7, 6, 5, 3, 2, 2, 4, 4, 3, 1, -2, -9, -16, -24, -31, -38, -42, -44, -44, -42,
-41, -39, -37, -34, -30, -26, -22, -17, -13, -9, -4, -1, 0, 5, 9, 12, 16, 16,
19, 18, 18, 17, 14, 10, 6, 1, -3, -8, -14, -19, -25, -32, -36, -40, -43, -42,
-40, -37, -31, -28, -22, -15, -10, -4, 1, 9, 13, 18, 24, 29, 34, 36, 41, 42, 45,
46, 47, 47, 46, 45, 45, 44, 42, 41, 39, 38, 34, 32, 28, 22, 17, 13, 11, 10, 8,
5, 2, 1, -3, -5, -9, -12, -17, -19, -21, -22, -23, -23, -23, -22, -21, -22, -19,
-20, -20, -18, -18, -19, -18, -18, -18, -17, -18, -18, -19, -13, -11, -11, -8,
-7, -3, -1, 3, 7, 11, 12, 13, 14, 15, 18, 19, 21, 20, 19, 17, 14, 10, 6, 4, 0,
-3, -3, -3, -5, -5, -5, -4, -3, -4, -5, -5, -4, -2, -1, -1, 0, 0, -1, 6, 13, 10,
8, 8, 8, 13, 8, 5, 12, 17, 25, 39, 37, 15, -4, -2, 0, 1, -5, -12, -16, -24, -33,
-41, -50, -54, -54, -51, -46, -46, -45, -44, -40, -36, -27, -15, -10, -11, -10,
-1, 3, 7, 13, 21, 24, 16, 6, 1, 18, 33, 38, 43, 39, 32, 23, 12, 9, 3, -7, -18,
-31, -40, -44, -47, -51, -51, -51, -52, -50, -47, -38, -36, -36, -41, -36, -36,
-41, -37, -38, -37, -34, -8, 3, 0, -7, -19, -4, 16, 36, 59, 58, 50, 49, 54, 66,
78, 74, 64, 51, 42, 48, 46, 38, 30, 19, 4, 1, -5, -6, -11, -21, -28, -31, -41,
-56, -62, -55, -27, -6, -12, -20, -14, -3, 18, 34, 59, 74, 73, 78, 74, 59, 40,
36, 31, 37, 55, 53, 37, 27, 18, 16, 15, -2, -13, -22, -39, -48, -62, -72, -76,
-82, -80, -72, -68, -78, -85, -84, -78, -63, -45, -33, -36, -46, -52, -51, -46,
-47, -49, -53, -53, -49, -39, -25, -12, -6, -2, 0, };