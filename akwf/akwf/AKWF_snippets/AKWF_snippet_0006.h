#define DATA_LENGTH 512
#define DATA AKWF_snippet_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 3, 13, 4, 15, 23, 27, 45, 54, 75,
67, 75, 75, 70, 60, 40, 47, 53, 58, 66, 84, 89, 77, 78, 74, 68, 59, 51, 58, 66,
73, 78, 89, 98, 94, 96, 99, 101, 92, 85, 95, 97, 92, 85, 93, 102, 97, 103, 110,
115, 114, 108, 109, 107, 106, 98, 98, 102, 89, 87, 84, 84, 66, 63, 72, 86, 96,
91, 95, 92, 92, 91, 90, 91, 89, 86, 87, 86, 85, 85, 85, 86, 83, 78, 73, 72, 48,
47, 67, 69, 73, 68, 64, 60, 60, 60, 55, 56, 43, 42, 31, 19, 16, 8, 14, 11, 24,
30, 34, 36, 26, 32, 14, 16, 13, 15, 32, 41, 55, 48, 50, 31, 13, -2, -18, -33,
-47, -48, -50, -57, -67, -60, -58, -63, -64, -45, -40, -32, -32, -21, -10, -29,
-35, -52, -48, -68, -66, -57, -70, -63, -82, -71, -88, -94, -105, -105, -102,
-119, -106, -106, -98, -108, -83, -78, -84, -81, -84, -74, -89, -89, -92, -95,
-101, -100, -96, -91, -96, -90, -92, -87, -80, -90, -84, -81, -83, -83, -83,
-81, -83, -82, -82, -81, -81, -81, -74, -76, -78, -75, -68, -67, -71, -69, -65,
-59, -48, -33, -23, -7, -7, -14, -22, -40, -50, -60, -59, -64, -64, -64, -67,
-57, -62, -59, -49, -43, -33, -27, -14, -10, 2, 2, 1, 3, -10, -1, -3, 8, 5, 9,
9, -2, 2, -13, 2, -10, -3, -7, -9, 3, -2, 23, 26, 45, 55, 64, 77, 73, 70, 62,
59, 61, 43, 48, 62, 62, 73, 88, 100, 93, 92, 87, 84, 84, 82, 102, 103, 99, 101,
99, 101, 88, 91, 93, 96, 98, 99, 113, 109, 106, 103, 104, 102, 102, 99, 97, 98,
96, 97, 94, 96, 91, 89, 92, 91, 87, 85, 81, 74, 73, 73, 78, 78, 82, 84, 84, 84,
81, 83, 82, 82, 82, 80, 78, 74, 75, 74, 73, 75, 75, 69, 69, 66, 58, 61, 53, 51,
44, 39, 42, 43, 50, 60, 67, 69, 67, 66, 64, 50, 35, 26, 19, 14, 11, 18, 31, 33,
28, 20, 13, -1, -9, -16, -14, -8, -12, -9, -9, -14, -22, -29, -30, -38, -36,
-33, -26, -27, -35, -30, -35, -47, -57, -53, -44, -42, -26, -10, -6, -17, -35,
-42, -52, -64, -77, -84, -86, -97, -96, -101, -98, -97, -98, -82, -81, -78, -82,
-81, -78, -81, -77, -74, -77, -78, -77, -64, -69, -76, -96, -101, -105, -117,
-108, -120, -112, -113, -110, -109, -107, -107, -104, -101, -100, -89, -84, -76,
-77, -84, -83, -77, -90, -95, -93, -92, -93, -90, -89, -89, -88, -89, -87, -85,
-85, -85, -82, -82, -82, -84, -83, -82, -82, -78, -79, -78, -76, -75, -72, -76,
-77, -75, -76, -72, -72, -72, -66, -50, -43, -41, -41, -44, -43, -54, -60, -67,
-69, -69, -71, -71, -69, -66, -65, -56, -46, -37, -34, -28, -18, -24, -22, -14,
-9, 0, 4, 25, 34, 36, 27, 18, 7, -16, -13, -21, -9, -8, -9, };