#define DATA_LENGTH 512
#define DATA AKWF_snippet_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 40, 45, 54, 62, 55, 63, 78, 85,
86, 88, 86, 82, 71, 57, 60, 61, 70, 76, 79, 70, 59, 70, 77, 80, 77, 67, 60, 66,
70, 70, 74, 62, 59, 58, 53, 52, 43, 33, 23, 22, 25, 13, 0, 13, 15, 15, 48, 62,
72, 77, 76, 69, 64, 45, 23, 33, 20, 28, 54, 58, 63, 67, 74, 81, 81, 83, 74, 64,
62, 66, 63, 60, 62, 56, 49, 47, 44, 44, 42, 43, 39, 28, 26, 25, 31, 47, 58, 60,
65, 68, 69, 70, 75, 82, 76, 70, 75, 77, 74, 67, 67, 70, 67, 68, 63, 63, 66, 63,
59, 63, 59, 48, 53, 51, 49, 50, 42, 47, 44, 43, 39, 17, 23, 5, -29, -28, -42,
-37, -32, -58, -70, -82, -100, -106, -108, -114, -119, -118, -119, -115, -111,
-108, -101, -105, -103, -92, -93, -95, -93, -85, -87, -93, -92, -86, -82, -80,
-76, -82, -87, -85, -79, -74, -78, -73, -74, -79, -69, -62, -53, -50, -55, -55,
-58, -63, -68, -69, -66, -68, -75, -77, -77, -84, -87, -80, -78, -75, -76, -84,
-76, -76, -66, -40, -45, -50, -43, -34, -24, -3, 21, 34, 16, 10, 38, 38, 36, 58,
52, 52, 59, 59, 64, 62, 65, 74, 76, 75, 75, 69, 70, 74, 75, 71, 68, 65, 60, 60,
55, 48, 46, 41, 35, 33, 25, 15, 8, 1, -1, -3, -9, -12, -15, -16, -15, -15, -10,
-6, -7, -6, -2, 4, 12, 16, 19, 19, 14, 8, 7, 14, 19, 21, 21, 16, 9, 7, 6, 7, 8,
5, 6, 3, 6, 14, 13, 23, 16, -1, -9, -21, -22, -33, -39, -29, -28, -51, -100,
-110, -101, -91, -80, -96, -79, -73, -111, -116, -106, -100, -101, -105, -106,
-110, -110, -106, -99, -92, -87, -89, -95, -91, -87, -82, -77, -82, -82, -80,
-80, -76, -75, -73, -66, -66, -68, -70, -67, -59, -58, -60, -62, -60, -60, -66,
-67, -62, -60, -69, -73, -68, -70, -75, -72, -61, -55, -68, -62, -44, -46, -32,
-28, -27, -20, -38, -37, -16, -2, 17, 31, 39, 44, 29, 21, 42, 39, 38, 54, 69,
73, 53, 55, 64, 62, 69, 74, 84, 83, 73, 64, 64, 71, 75, 83, 87, 86, 83, 80, 72,
68, 70, 67, 74, 69, 55, 53, 51, 51, 44, 40, 45, 40, 38, 38, 38, 40, 41, 30, 20,
35, 47, 56, 69, 69, 66, 63, 60, 59, 58, 60, 66, 64, 62, 62, 49, 44, 44, 50, 62,
52, 33, 30, 46, 56, 55, 50, 49, 39, 27, 25, -13, -15, 22, 12, 10, -2, -35, -50,
-62, -58, -66, -85, -74, -70, -94, -103, -104, -99, -96, -102, -97, -90, -85,
-81, -75, -64, -57, -59, -63, -57, -54, -48, -34, -30, -39, -44, -41, -44, -38,
-33, -41, -40, -40, -36, -25, -25, -26, -26, -20, -18, -12, 7, 20, 16, 4, 8, 21,
16, 12, -18, -18, 15, 6, -5, -26, -33, -26, -39, -21, 0, -12, -26, -28, -16, -1,
0, };