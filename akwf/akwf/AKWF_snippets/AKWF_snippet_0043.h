#define DATA_LENGTH 512
#define DATA AKWF_snippet_0043

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 8, 1, 7, 9, 12, 39, 63, 73, 65,
36, 5, 13, 62, 104, 119, 100, 76, 67, 55, 53, 69, 62, 27, -3, -21, -26, -13, 13,
32, 12, -31, -45, -18, 9, 2, -25, -42, -41, -20, 1, 1, -14, -26, -22, -13, -11,
-19, -18, -8, 1, 2, -7, -19, -24, -14, 7, 32, 47, 47, 46, 47, 39, 29, 31, 36,
36, 28, 12, 5, 13, 30, 53, 69, 67, 53, 36, 16, -2, -17, -28, -35, -38, -45, -54,
-66, -70, -68, -65, -60, -53, -46, -41, -39, -39, -43, -48, -52, -47, -35, -18,
-5, 8, 22, 31, 37, 43, 51, 59, 66, 64, 59, 53, 41, 26, 12, 3, -4, -9, -14, -14,
-16, -22, -25, -26, -25, -26, -30, -34, -34, -31, -29, -27, -27, -30, -33, -33,
-36, -42, -41, -39, -38, -36, -30, -26, -22, -14, -3, 9, 15, 17, 20, 28, 34, 34,
34, 30, 25, 16, 8, 1, -5, -9, -14, -21, -27, -28, -26, -22, -17, -12, -8, -7,
-8, -10, -11, -10, -6, -4, 1, 5, 11, 15, 13, 11, 10, 8, 10, 13, 11, 9, 9, 9, 15,
20, 23, 23, 18, 13, 12, 11, 11, 14, 18, 23, 30, 37, 41, 44, 43, 41, 37, 33, 28,
21, 16, 12, 7, 3, -2, -10, -17, -23, -24, -29, -36, -40, -43, -43, -44, -41,
-40, -41, -41, -41, -42, -41, -33, -25, -16, -8, -1, 4, 12, 22, 27, 32, 36, 40,
45, 46, 45, 41, 40, 36, 31, 28, 26, 24, 22, 23, 22, 20, 20, 19, 19, 14, 9, 5,
-2, -10, -17, -22, -28, -30, -31, -33, -36, -38, -34, -29, -25, -24, -20, -18,
-9, 1, 8, 15, 20, 25, 31, 33, 33, 32, 29, 26, 19, 13, 3, 1, 2, -2, -5, -7, -7,
-7, -6, -5, -4, -1, -1, -2, -3, -2, -2, 1, 5, 8, 7, 5, 4, 4, 5, 4, 4, 5, 7, 11,
12, 13, 12, 13, 14, 14, 14, 11, 11, 9, 9, 10, 10, 10, 11, 11, 10, 11, 10, 11, 9,
9, 10, 10, 5, 0, -2, -4, -9, -16, -20, -23, -27, -29, -33, -38, -42, -44, -45,
-47, -51, -57, -60, -55, -36, -36, -38, -12, -10, -33, -31, -11, -1, 9, 12, 12,
16, 15, 9, 11, 21, 22, 21, 22, 26, 27, 21, 17, 18, 15, 17, 16, 14, 20, 21, 15,
6, 11, 16, 13, 7, -5, -9, -14, -20, -21, -26, -37, -41, -29, -9, -14, 6, 16,
-13, -14, -4, 22, 28, 29, 23, 7, 5, 17, 22, 10, -12, -24, -25, -29, -29, -11,
15, 31, 46, 54, 45, -7, -32, -34, 0, 28, 19, -4, -18, -17, -28, -35, -39, -39,
-29, 4, -36, -60, -29, 5, 11, -9, -17, -29, -21, 8, 31, 29, 38, 62, 76, 64, 55,
54, 41, 25, 20, 27, 32, 27, 17, 0, -22, -25, -19, -14, -21, -34, -45, -58, -72,
-83, -92, -93, -77, -69, -72, -71, -63, -51, -23, 1, -5, -10, -7, -1, };