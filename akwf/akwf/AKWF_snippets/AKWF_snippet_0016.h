#define DATA_LENGTH 512
#define DATA AKWF_snippet_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 23, 25, 22, 20, 26, 32, 32, 34, 41,
42, 35, 35, 39, 38, 33, 36, 43, 41, 32, 22, 17, 17, 22, 32, 44, 58, 69, 79, 82,
74, 69, 78, 96, 102, 99, 97, 96, 94, 92, 88, 81, 80, 81, 75, 68, 67, 66, 53, 50,
56, 57, 47, 37, 24, 8, -2, 0, 4, 5, 14, 26, 33, 34, 35, 35, 37, 42, 51, 58, 67,
73, 68, 59, 55, 55, 60, 65, 64, 56, 48, 40, 30, 20, 17, 23, 34, 41, 47, 45, 36,
20, 8, 7, 3, -1, 8, 22, 23, 14, 12, 13, 7, 4, 14, 28, 34, 32, 27, 17, 11, 15,
28, 34, 24, 11, 8, 17, 22, 17, 8, -1, -5, -5, -6, -10, -17, -25, -31, -36, -38,
-36, -38, -49, -55, -55, -49, -40, -34, -35, -31, -17, -3, -1, -8, -10, -3, 3,
12, 24, 39, 43, 36, 23, 12, 7, 12, 18, 19, 13, 15, 21, 20, 9, 2, 0, 0, 6, 21,
36, 33, 21, 13, 6, -2, -1, 5, 7, 9, 22, 36, 39, 45, 59, 65, 60, 56, 56, 49, 42,
35, 25, 17, 24, 45, 59, 63, 62, 56, 40, 22, 15, 14, 7, -8, -14, -15, -19, -20,
-9, 6, 15, 18, 26, 38, 53, 64, 67, 55, 44, 43, 50, 59, 67, 71, 72, 78, 84, 84,
78, 73, 71, 71, 75, 77, 73, 72, 73, 67, 59, 62, 66, 62, 56, 59, 62, 56, 53, 59,
65, 65, 66, 72, 73, 71, 72, 79, 83, 84, 81, 76, 75, 77, 77, 69, 57, 50, 46, 39,
31, 25, 21, 13, 4, 4, 8, 3, -8, -10, -19, -40, -51, -49, -53, -66, -72, -70,
-70, -63, -49, -36, -34, -30, -28, -30, -31, -30, -36, -41, -39, -41, -43, -36,
-33, -47, -63, -62, -48, -37, -36, -49, -66, -67, -59, -61, -77, -92, -98, -102,
-103, -98, -93, -95, -98, -103, -113, -119, -110, -89, -74, -68, -61, -57, -68,
-74, -61, -45, -43, -45, -44, -49, -56, -52, -43, -44, -49, -40, -29, -31, -37,
-33, -33, -51, -59, -51, -48, -63, -76, -69, -64, -64, -47, -16, 1, 2, 7, 16,
13, 12, 22, 34, 33, 29, 35, 44, 44, 35, 39, 44, 40, -8, -51, -51, -58, -53, -37,
-23, -29, -42, -42, -28, -18, -16, -9, -1, -3, -9, -5, 6, 5, -7, -13, -7, -3,
-3, -6, -19, -41, -57, -55, -42, -41, -58, -74, -72, -70, -80, -90, -97, -106,
-109, -95, -82, -84, -87, -81, -72, -65, -53, -49, -59, -73, -70, -57, -54, -62,
-63, -52, -46, -46, -46, -41, -44, -59, -70, -66, -55, -55, -63, -70, -66, -53,
-42, -38, -35, -35, -38, -40, -42, -49, -55, -53, -50, -49, -47, -41, -32, -21,
-4, 9, 10, 0, -7, -4, 8, 20, 23, 16, 2, -11, -14, -9, -5, -6, -10, -16, -25,
-26, -23, -24, -35, -46, -46, -46, -53, -61, -65, -67, -68, -56, -39, -31, -36,
-34, -25, -23, -19, -4, 11, 5, -8, -5, };