#define DATA_LENGTH 512
#define DATA AKWF_snippet_0033

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 17, 28, 24, 14, 20, 14, 2, 6, 15,
30, 41, 30, 17, 16, 18, 22, 30, 40, 32, 22, 35, 41, 34, 20, 27, 32, 38, 48, 38,
22, 16, 24, 19, 30, 49, 57, 61, 50, 29, 28, 31, 31, 35, 36, 35, 33, 30, 26, 22,
18, 14, 2, -2, -3, -5, 8, 15, 7, 6, -7, -12, -10, -10, 2, -9, -19, -15, -9, -15,
-6, 2, -1, 1, -6, -13, -28, -34, -28, -23, -26, -26, -18, -16, -20, -25, -25,
-22, -35, -50, -35, -41, -28, -19, -24, -4, -2, 6, 4, -5, -7, -16, -13, -16,
-21, -25, -44, -36, -22, -23, -30, -27, -28, -31, -7, -16, -26, -20, -29, -40,
-48, -47, -42, -42, -26, -15, -12, -9, -15, -14, -13, -12, -17, -14, -15, -6,
-1, 5, 14, 13, 2, -8, -1, 12, 16, 7, 7, 7, 3, -6, -8, -16, -11, 2, 18, 13, 13,
23, 26, 26, 18, 21, 20, 27, 13, 5, 17, 10, 3, 8, 17, 22, 26, 33, 23, 10, 12, 25,
41, 42, 42, 30, 29, 36, 31, 22, 17, 13, 17, 26, 19, 13, 10, 6, -4, -3, 4, 6, 8,
14, 25, 38, 38, 38, 37, 23, 16, 16, 14, 14, 19, 20, 11, 9, 7, 8, 9, 21, 23, 7,
3, -1, -1, 2, 6, 4, -5, 2, 2, -14, -11, -16, -17, -12, -14, -8, -9, -11, -6, -3,
-3, -8, -12, -16, -16, -8, -16, -19, -18, -21, -13, -11, -13, -3, -13, -30, -38,
-29, -17, -23, -25, -31, -53, -45, -24, -9, 7, 2, -12, -21, -13, -16, -21, -24,
-31, -33, -19, -16, -9, -8, -7, -3, -11, -11, -14, -16, -19, -7, 1, -3, -14,
-25, -26, -11, 0, 5, 9, -5, -16, -2, 10, 17, 20, 25, 12, -5, -17, -24, -21, -14,
-7, -13, -13, 6, 19, 19, 15, 17, 13, 9, 13, 14, 3, 1, 14, 18, 13, 12, 11, 1, -5,
-12, -3, 2, 11, 18, 7, 8, 22, 24, 9, -3, 0, 9, 11, 20, 20, 7, 17, 20, 15, 25,
31, 12, 6, 15, 19, 13, 9, 12, 15, 54, 83, 71, 50, 37, 26, 5, -12, -28, -27, -29,
-28, -24, -20, -6, -4, -5, 18, 11, 0, -18, -18, 12, 21, 31, 19, 19, 11, -18,
-63, -50, -4, 5, -36, -88, -94, -94, -115, -88, -28, 1, 31, 38, 44, 31, 25, 21,
57, 103, 48, 3, -11, -35, -39, -38, -16, -1, 1, 17, 38, 20, 1, 19, 29, 36, 35,
66, 90, 80, 45, -2, -42, -40, 9, 18, 28, 61, 52, 38, 18, -10, -19, -30, -73,
-87, -33, 25, 58, 73, 59, 26, -6, -13, -45, -87, -74, -52, -42, -39, -24, -3, 1,
-13, -46, -55, -37, -22, -6, -13, -32, -44, -62, -62, -73, -86, -85, -53, -4, 9,
17, 36, 41, 39, 22, -12, -19, -9, -1, -22, -39, -42, -41, -29, -22, -27, -34,
-18, -12, -1, 13, 3, -7, -14, -16, -5, -6, 4, 14, 11, 0, -3, };