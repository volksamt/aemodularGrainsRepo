#define DATA_LENGTH 512
#define DATA AKWF_snippet_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {15, 19, 35, 39, 77, 95, 96, 108, 79,
87, 75, 75, 95, 97, 89, 59, 68, 61, 82, 97, 103, 116, 106, 117, 115, 98, 99, 94,
97, 84, 77, 87, 71, 83, 66, 88, 98, 94, 96, 88, 93, 87, 87, 86, 86, 81, 80, 77,
60, 79, 74, 68, 72, 56, 65, 43, 53, 43, 50, 60, 61, 84, 54, 62, 27, 18, 18, 14,
46, -14, 18, -12, -39, -20, -36, -29, -41, -42, -11, 10, -14, 1, -16, -43, -55,
-47, -22, 0, -25, -6, -46, -76, -46, -67, -82, -73, -58, -87, -89, -101, -76,
-88, -110, -83, -85, -72, -61, -83, -91, -99, -59, -84, -110, -79, -75, -72,
-73, -68, -81, 1, 22, 8, 15, 18, 22, 13, 4, -26, -49, -71, -77, -79, -58, -33,
2, 22, 30, 39, 42, 28, 17, 12, 15, 34, 54, 49, 49, 38, 35, 45, 35, 27, 24, 40,
40, 45, 34, 34, 22, 17, 25, 11, 6, 9, 13, 23, 15, 14, 7, -6, -16, -33, -31, -59,
-30, -66, -31, -21, -101, -60, -88, -71, -73, -81, -10, -26, -4, 25, -8, 26, 79,
53, 75, 77, 65, 65, 15, -14, -61, -49, -67, -98, -64, -89, -77, -56, -56, -41,
-33, -29, -24, -27, -47, -51, -68, -68, -80, -63, -57, -59, -31, -30, -43, -16,
8, -10, 28, 56, 65, 59, 89, 79, 72, 87, 45, 39, 49, 37, 35, 52, 37, 45, 76, 87,
97, 103, 97, 87, 81, 72, 75, 66, 70, 70, 55, 42, 21, 20, 25, 44, 54, 64, 76, 74,
63, 44, 26, 20, 3, 12, 7, 8, -1, -21, -12, -19, -6, -19, 0, 18, 11, 10, 2, -14,
-29, -36, -30, -64, -75, -70, -41, -58, -80, -39, -85, -70, -56, -60, -42, -48,
-70, -47, -66, -99, -83, -100, -101, -103, -100, -95, -94, -87, -84, -80, -78,
-52, -59, -86, -76, -76, -71, -76, -75, -76, -73, -67, -71, -56, -47, -47, -30,
-28, -22, -32, -44, -34, -18, -28, -30, -27, -37, -38, -44, -24, -38, -11, 7,
18, 26, 25, 37, 35, 60, 64, 60, 71, 72, 58, 68, 37, 47, 61, 62, 72, 64, 88, 90,
91, 90, 107, 112, 109, 116, 109, 106, 103, 101, 98, 100, 98, 99, 94, 93, 90, 67,
65, 72, 86, 84, 83, 84, 82, 86, 75, 79, 78, 79, 76, 74, 75, 61, 38, 26, 24, 21,
17, 26, 49, 59, 59, 53, 56, 44, 53, 45, 36, 28, 12, 14, -20, -32, -37, -54, -53,
-43, -45, -40, -31, -21, -27, -35, -47, -29, -40, -44, -45, -57, -60, -75, -72,
-87, -84, -103, -99, -103, -79, -74, -93, -91, -99, -95, -104, -105, -103, -100,
-93, -90, -94, -85, -96, -89, -88, -45, -53, -59, -42, -72, -65, -84, -84, -80,
-82, -76, -82, -79, -72, -81, -75, -67, -66, -59, -38, -40, -46, -42, -58, -56,
-64, -71, -64, -69, -67, -66, -55, -58, -35, -11, -3, 23, 16, 23, 13, 25, 15,
14, 26, 5, 30, 2, 1, 14, -3, };