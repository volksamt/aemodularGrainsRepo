#define DATA_LENGTH 512
#define DATA AKWF_snippet_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 16, 22, 27, 32, 34, 34, 36, 36,
38, 41, 47, 52, 60, 65, 66, 67, 64, 61, 60, 61, 65, 67, 69, 69, 69, 69, 71, 75,
79, 83, 86, 86, 85, 80, 76, 70, 64, 58, 53, 46, 41, 34, 29, 22, 14, 5, -6, -18,
-28, -35, -42, -45, -47, -45, -39, -31, -24, -17, -10, -6, 1, 6, 9, 13, 18, 24,
31, 35, 35, 37, 38, 40, 42, 43, 44, 45, 45, 43, 40, 35, 31, 30, 29, 31, 33, 36,
37, 36, 36, 37, 38, 39, 41, 42, 43, 43, 42, 38, 34, 28, 22, 15, 8, -2, -12, -22,
-31, -40, -47, -55, -61, -68, -71, -75, -78, -82, -84, -85, -86, -84, -81, -77,
-72, -67, -61, -57, -52, -47, -43, -38, -35, -33, -36, -43, -50, -55, -59, -59,
-58, -56, -54, -50, -49, -47, -42, -37, -35, -34, -34, -35, -37, -38, -37, -32,
-27, -17, -5, 10, 24, 36, 46, 52, 54, 52, 49, 45, 41, 35, 29, 24, 18, 9, -2,
-14, -26, -35, -42, -48, -51, -54, -54, -53, -51, -43, -32, -15, 4, 24, 41, 55,
61, 62, 57, 53, 46, 45, 46, 54, 65, 78, 87, 97, 103, 109, 111, 112, 113, 107,
105, 96, 108, 22, -25, -4, -8, 3, 4, 16, 21, 35, 38, 42, 41, 42, 42, 45, 47, 48,
47, 44, 39, 33, 25, 20, 15, 10, 7, 3, -1, -6, -9, -13, -13, -15, -13, -10, -5,
2, 11, 19, 26, 32, 37, 41, 49, 54, 60, 62, 61, 59, 56, 55, 55, 60, 64, 67, 68,
68, 67, 64, 61, 56, 52, 50, 50, 53, 56, 60, 63, 67, 71, 79, 87, 96, 102, 106,
107, 106, 104, 100, 98, 95, 91, 85, 78, 69, 63, 55, 47, 39, 29, 19, 6, -4, -14,
-20, -24, -26, -26, -24, -21, -17, -12, -7, -5, -2, 2, 5, 10, 14, 21, 27, 30,
32, 32, 33, 33, 31, 32, 31, 28, 25, 19, 15, 10, 6, 2, 1, 1, 3, 7, 9, 10, 10, 9,
10, 14, 19, 25, 31, 36, 37, 37, 33, 28, 23, 16, 9, 3, -9, -21, -30, -38, -45,
-51, -57, -62, -69, -74, -80, -84, -89, -92, -94, -94, -91, -88, -84, -80, -74,
-69, -63, -57, -48, -40, -31, -28, -27, -29, -32, -36, -39, -41, -41, -41, -40,
-42, -44, -49, -53, -58, -59, -61, -59, -58, -57, -55, -54, -52, -47, -40, -32,
-24, -19, -18, -18, -21, -26, -31, -37, -41, -47, -50, -55, -59, -64, -69, -74,
-81, -87, -94, -100, -107, -112, -117, -119, -119, -116, -111, -103, -94, -86,
-77, -70, -64, -59, -54, -47, -42, -36, -31, -27, -26, -27, -28, -27, -28, -27,
-26, -26, -27, -31, -36, -39, -43, -43, -40, -37, -32, -29, -26, -24, -22, -19,
-15, -11, -6, -2, 1, 2, 1, -1, -2, -5, -7, -12, -18, -22, -29, -33, -37, -40,
-44, -48, -53, -58, -62, -66, -71, -75, -75, -71, -65, -56, -47, -36, -27, -19,
-12, -4, };