#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 5, 6, 8, 10, 11, 11, 12, 13,
15, 15, 17, 17, 19, 20, 22, 23, 24, 26, 27, 29, 29, 32, 34, 37, 38, 39, 42, 44,
45, 47, 47, 49, 50, 52, 53, 54, 56, 59, 60, 62, 64, 65, 68, 70, 73, 74, 76, 79,
80, 82, 84, 87, 90, 92, 95, 96, 98, 99, 100, 102, 102, 106, 108, 110, 110, 109,
110, 108, 107, 105, 103, 101, 99, 99, 98, 99, 98, 99, 98, 95, 91, 86, 81, 77,
74, 75, 75, 76, 74, 72, 66, 60, 52, 45, 36, 30, 24, 18, 13, 9, 5, 2, -1, -5,
-11, -17, -23, -30, -37, -40, -44, -46, -47, -50, -54, -57, -62, -66, -71, -77,
-82, -89, -97, -102, -108, -112, -114, -115, -115, -115, -114, -115, -116, -117,
-118, -119, -119, -119, -118, -117, -115, -112, -110, -108, -106, -104, -103,
-105, -106, -105, -105, -104, -103, -100, -95, -90, -85, -78, -74, -69, -64,
-58, -54, -49, -45, -41, -36, -31, -27, -22, -17, -12, -9, -7, -4, -2, -2, 1, 4,
8, 12, 15, 19, 24, 29, 33, 37, 41, 43, 47, 49, 52, 53, 56, 58, 59, 61, 62, 64,
64, 64, 64, 62, 63, 62, 63, 63, 64, 64, 64, 64, 64, 65, 66, 66, 67, 66, 64, 64,
61, 60, 60, 59, 57, 56, 54, 53, 51, 51, 48, 47, 46, 44, 42, 40, 38, 37, 36, 36,
36, 36, 35, 34, 33, 31, 31, 28, 28, 27, 26, 24, 24, 23, 22, 22, 21, 22, 22, 21,
20, 19, 17, 15, 13, 12, 11, 10, 9, 8, 7, 7, 7, 6, 6, 5, 3, 3, 0, -1, -1, -2, -4,
-4, -4, -5, -7, -9, -12, -14, -17, -19, -22, -25, -27, -29, -31, -33, -34, -36,
-37, -38, -39, -41, -43, -44, -46, -46, -48, -50, -52, -54, -54, -57, -59, -61,
-63, -65, -68, -70, -72, -73, -75, -75, -75, -75, -75, -75, -75, -73, -73, -72,
-72, -71, -68, -68, -66, -66, -65, -64, -62, -62, -62, -60, -59, -57, -57, -55,
-53, -50, -47, -44, -41, -38, -34, -29, -25, -22, -18, -13, -10, -7, -4, 0, 3,
6, 10, 12, 15, 18, 21, 22, 25, 27, 30, 33, 35, 39, 41, 44, 48, 51, 54, 56, 59,
62, 63, 65, 67, 67, 67, 68, 68, 69, 68, 68, 68, 67, 66, 66, 66, 64, 63, 62, 61,
60, 58, 58, 56, 54, 53, 51, 49, 46, 44, 42, 38, 36, 33, 29, 25, 22, 18, 15, 11,
7, 4, 1, -3, -6, -9, -12, -14, -17, -20, -23, -26, -30, -33, -35, -38, -42, -44,
-46, -48, -50, -53, -55, -57, -59, -61, -63, -66, -67, -68, -70, -71, -71, -72,
-72, -73, -73, -74, -75, -75, -74, -75, -74, -73, -72, -72, -70, -70, -68, -68,
-67, -65, -64, -62, -61, -59, -59, -56, -54, -53, -51, -50, -48, -46, -44, -42,
-41, -39, -36, -34, -32, -28, -26, -24, -21, -19, -17, -15, -13, -10, -9, -7,
-5, -2, -1, };