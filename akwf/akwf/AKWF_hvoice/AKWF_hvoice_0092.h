#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0092

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 2, 2, 3, 4, 5, 6, 7, 8, 8,
11, 12, 13, 14, 15, 15, 15, 15, 15, 16, 16, 17, 16, 17, 16, 17, 18, 17, 17, 16,
17, 16, 14, 14, 13, 11, 11, 11, 10, 10, 11, 11, 12, 12, 13, 12, 14, 13, 13, 13,
14, 14, 15, 16, 16, 18, 18, 18, 20, 20, 21, 22, 24, 23, 23, 24, 24, 24, 22, 23,
22, 23, 24, 25, 25, 27, 27, 28, 29, 29, 29, 30, 32, 31, 32, 34, 35, 36, 39, 40,
42, 44, 45, 47, 47, 49, 50, 51, 52, 52, 53, 52, 52, 52, 53, 51, 51, 51, 51, 49,
49, 48, 46, 44, 44, 42, 41, 40, 40, 39, 38, 37, 36, 36, 35, 35, 35, 36, 35, 33,
34, 34, 32, 33, 32, 32, 32, 33, 32, 31, 31, 29, 27, 24, 22, 19, 18, 16, 14, 12,
11, 11, 11, 10, 9, 9, 5, 0, -6, -12, -22, -29, -36, -44, -51, -57, -62, -67,
-72, -77, -82, -86, -92, -97, -100, -106, -111, -114, -117, -120, -119, -116,
-114, -110, -104, -100, -96, -91, -86, -82, -78, -74, -71, -67, -63, -58, -53,
-47, -41, -35, -29, -26, -21, -15, -13, -13, -11, -10, -10, -10, -9, -9, -8, -5,
-3, -1, 1, 4, 6, 7, 7, 8, 7, 6, 6, 6, 6, 6, 6, 8, 9, 9, 10, 10, 9, 9, 8, 5, 1,
-2, -5, -10, -14, -16, -19, -22, -25, -27, -29, -30, -32, -35, -36, -40, -42,
-44, -46, -48, -47, -48, -47, -45, -43, -41, -39, -35, -32, -30, -27, -25, -22,
-20, -19, -17, -15, -14, -10, -6, -3, -1, 3, 6, 7, 8, 10, 9, 10, 11, 11, 10, 11,
13, 13, 15, 16, 17, 18, 20, 21, 21, 21, 21, 21, 21, 21, 19, 19, 20, 21, 22, 22,
23, 23, 23, 22, 20, 19, 17, 14, 12, 10, 7, 4, 2, 0, -2, -3, -5, -6, -8, -10,
-12, -12, -15, -15, -17, -18, -18, -17, -17, -16, -15, -14, -12, -10, -9, -7,
-6, -5, -3, -2, -1, 1, 1, 2, 3, 4, 4, 6, 6, 8, 8, 9, 10, 9, 9, 9, 8, 8, 8, 8, 8,
8, 8, 10, 9, 10, 10, 10, 10, 11, 11, 11, 10, 11, 12, 12, 12, 12, 11, 11, 11, 11,
10, 11, 10, 8, 7, 6, 4, 3, 1, -1, -2, -4, -4, -5, -6, -8, -9, -10, -11, -13,
-15, -15, -17, -17, -17, -18, -17, -17, -17, -18, -17, -16, -15, -15, -14, -13,
-12, -12, -10, -10, -9, -8, -7, -6, -6, -5, -5, -4, -3, -3, -3, -2, -3, -2, -1,
-2, -1, -1, 0, -1, 0, 0, 1, 1, 2, 2, 1, 3, 3, 3, 4, 4, 5, 5, 4, 5, 5, 4, 4, 4,
3, 3, 2, 2, 1, 0, 0, 0, 0, -1, -1, -3, -2, -4, -3, -3, -4, -5, -6, -6, -7, -6,
-6, -6, -7, -6, -6, -6, -6, -5, -5, -4, -3, -3, -1, -1, 0, };