#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0071

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 3, 4, 5, 6, 6, 6, 6, 6, 7, 7, 7,
8, 8, 10, 11, 12, 13, 14, 15, 15, 16, 15, 14, 14, 13, 12, 12, 11, 10, 10, 11,
11, 10, 12, 11, 12, 11, 11, 10, 9, 9, 8, 7, 7, 7, 7, 9, 9, 10, 11, 12, 13, 14,
15, 16, 15, 17, 16, 18, 18, 19, 21, 22, 23, 24, 25, 27, 28, 28, 29, 29, 29, 30,
29, 28, 28, 29, 29, 28, 27, 27, 26, 25, 26, 26, 26, 25, 26, 24, 24, 24, 21, 21,
20, 18, 17, 17, 15, 15, 15, 15, 13, 15, 13, 15, 15, 16, 16, 16, 16, 18, 17, 16,
16, 17, 17, 16, 16, 16, 17, 17, 18, 18, 19, 18, 16, 14, 10, 8, 4, 1, -2, -4, -5,
-4, 0, 4, 7, 11, 11, 6, -1, -13, -30, -46, -65, -82, -97, -110, -116, -120,
-118, -113, -104, -93, -84, -72, -63, -55, -53, -51, -52, -55, -56, -58, -56,
-51, -43, -32, -17, 0, 16, 31, 44, 54, 59, 61, 59, 53, 45, 37, 27, 18, 11, 6, 3,
3, 3, 5, 5, 5, 3, -1, -10, -19, -30, -41, -51, -62, -70, -77, -78, -78, -75,
-70, -62, -53, -44, -36, -29, -21, -17, -14, -13, -11, -9, -8, -5, -1, 6, 12,
20, 27, 37, 44, 49, 52, 54, 52, 49, 44, 37, 30, 22, 15, 9, 4, 1, -1, -3, -3, -4,
-5, -7, -10, -15, -20, -26, -33, -38, -43, -47, -49, -49, -47, -43, -38, -33,
-26, -21, -15, -9, -5, -2, 0, 2, 4, 6, 8, 11, 12, 17, 21, 24, 30, 34, 38, 40,
42, 42, 39, 36, 32, 26, 19, 14, 8, 4, 0, -4, -5, -7, -8, -9, -9, -12, -12, -15,
-17, -20, -23, -24, -27, -27, -27, -25, -24, -20, -17, -12, -7, -2, 2, 6, 9, 11,
11, 11, 13, 13, 14, 14, 16, 18, 20, 22, 24, 24, 26, 25, 24, 22, 20, 17, 13, 9,
6, 1, -2, -4, -5, -6, -8, -9, -9, -8, -9, -9, -11, -11, -13, -14, -15, -15, -15,
-14, -13, -11, -9, -6, -3, -2, 1, 2, 4, 6, 7, 9, 9, 10, 11, 9, 11, 10, 10, 10,
12, 12, 13, 12, 11, 9, 8, 7, 4, 2, 2, 0, -2, -2, -3, -6, -7, -8, -10, -11, -12,
-13, -13, -14, -15, -14, -15, -14, -14, -13, -12, -10, -7, -5, -4, -2, -1, -1,
0, 1, 0, 1, 1, 2, 2, 3, 4, 6, 6, 7, 8, 9, 10, 9, 8, 7, 6, 5, 3, 1, -2, -3, -4,
-5, -7, -7, -6, -7, -7, -8, -7, -8, -8, -9, -10, -11, -11, -12, -11, -11, -10,
-10, -8, -7, -5, -3, -3, 0, 0, 2, 4, 4, 5, 5, 4, 4, 4, 4, 3, 4, 5, 6, 5, 7, 7,
8, 7, 8, 7, 6, 5, 3, 1, 0, -1, -2, -4, -3, -4, -3, -3, -2, -2, -1, -1, -1, -1,
0, 0, 0, 0, -1, -1, 0, };