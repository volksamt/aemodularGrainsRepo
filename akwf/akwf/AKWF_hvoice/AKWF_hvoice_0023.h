#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 6, 7, 8, 9, 10, 11, 11,
13, 13, 15, 15, 16, 16, 17, 18, 18, 19, 20, 21, 21, 21, 21, 22, 22, 23, 23, 23,
23, 23, 23, 24, 24, 24, 24, 24, 24, 23, 23, 22, 23, 22, 22, 21, 22, 21, 20, 21,
20, 19, 18, 18, 18, 18, 16, 17, 16, 16, 15, 15, 15, 13, 12, 12, 11, 10, 10, 9,
8, 9, 7, 8, 7, 6, 5, 4, 3, 3, 2, 2, 1, 0, 0, 0, -1, -3, -2, -3, -3, -4, -5, -6,
-6, -7, -8, -7, -8, -8, -9, -10, -10, -11, -11, -12, -13, -13, -14, -14, -14,
-15, -15, -16, -16, -16, -17, -18, -17, -18, -18, -18, -19, -20, -20, -20, -20,
-21, -21, -21, -21, -21, -22, -22, -22, -21, -22, -22, -22, -22, -22, -22, -22,
-23, -22, -22, -22, -22, -21, -21, -21, -21, -21, -21, -21, -21, -20, -20, -20,
-20, -20, -19, -19, -18, -18, -17, -17, -16, -16, -15, -14, -14, -13, -13, -12,
-11, -11, -9, -9, -8, -7, -6, -5, -5, -3, -2, -2, -1, 0, 0, 1, 1, 3, 3, 5, 7, 8,
9, 10, 11, 13, 14, 15, 17, 17, 18, 21, 21, 22, 24, 26, 26, 27, 28, 30, 32, 32,
34, 36, 37, 38, 39, 41, 42, 43, 44, 46, 47, 49, 51, 53, 54, 55, 57, 59, 61, 62,
64, 66, 68, 71, 72, 74, 77, 78, 81, 83, 85, 87, 90, 91, 92, 95, 96, 99, 99, 101,
102, 104, 105, 107, 108, 109, 109, 110, 112, 113, 114, 115, 116, 116, 117, 117,
118, 118, 119, 119, 118, 118, 119, 119, 119, 118, 118, 117, 116, 115, 115, 114,
112, 112, 110, 109, 107, 106, 105, 103, 101, 98, 98, 95, 94, 92, 90, 88, 86, 84,
82, 81, 78, 76, 74, 72, 70, 68, 65, 64, 61, 59, 58, 54, 53, 51, 48, 47, 44, 42,
39, 37, 36, 33, 31, 29, 27, 24, 22, 20, 18, 15, 14, 12, 9, 7, 5, 3, 1, -1, -3,
-5, -8, -9, -11, -12, -15, -16, -19, -21, -23, -25, -28, -29, -31, -33, -35,
-38, -40, -42, -44, -46, -47, -50, -51, -53, -55, -58, -59, -61, -63, -65, -66,
-68, -71, -72, -74, -75, -77, -78, -80, -81, -83, -84, -85, -85, -87, -88, -89,
-90, -92, -92, -93, -93, -95, -96, -96, -97, -97, -98, -98, -100, -99, -100,
-100, -100, -101, -101, -101, -101, -100, -100, -101, -100, -100, -100, -99,
-99, -98, -98, -97, -96, -96, -94, -94, -93, -92, -92, -92, -91, -89, -89, -88,
-86, -87, -86, -84, -84, -82, -82, -81, -80, -79, -78, -77, -76, -75, -73, -73,
-71, -70, -69, -67, -67, -66, -65, -63, -62, -60, -59, -57, -57, -55, -53, -54,
-52, -50, -49, -48, -46, -45, -44, -43, -41, -41, -38, -38, -36, -34, -33, -31,
-31, -29, -28, -26, -24, -24, -22, -20, -19, -17, -16, -14, -13, -12, -11, -9,
-7, -6, -5, -4, -3, -2, 0, };