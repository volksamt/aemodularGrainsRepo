#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 6, 9, 14, 15, 18, 21, 25, 28,
30, 32, 35, 38, 40, 42, 43, 43, 43, 48, 49, 48, 45, 45, 44, 46, 45, 45, 46, 46,
44, 39, 37, 39, 40, 41, 40, 40, 42, 43, 40, 37, 39, 50, 60, 60, 53, 48, 52, 59,
62, 63, 66, 69, 71, 69, 67, 69, 74, 78, 80, 82, 82, 75, 64, 60, 65, 72, 72, 70,
72, 73, 71, 65, 59, 57, 59, 62, 60, 58, 57, 58, 58, 54, 52, 53, 54, 57, 59, 60,
65, 69, 70, 67, 63, 61, 61, 60, 56, 54, 51, 47, 39, 24, 1, -24, -41, -52, -56,
-57, -56, -51, -48, -53, -67, -80, -87, -89, -89, -89, -85, -80, -75, -76, -83,
-90, -92, -91, -90, -87, -81, -72, -62, -56, -51, -48, -44, -39, -34, -27, -18,
-9, -3, 4, 10, 15, 17, 15, 13, 15, 17, 16, 15, 15, 15, 14, 11, 9, 9, 8, 7, 4, 5,
7, 9, 9, 11, 17, 25, 32, 36, 37, 40, 43, 44, 43, 43, 44, 44, 47, 49, 51, 52, 54,
56, 61, 64, 64, 63, 66, 69, 72, 72, 71, 69, 68, 65, 59, 52, 45, 38, 30, 23, 16,
10, 3, -3, -10, -16, -22, -28, -34, -40, -44, -44, -45, -49, -51, -52, -53, -53,
-55, -54, -54, -53, -52, -52, -54, -55, -56, -57, -56, -56, -56, -55, -54, -52,
-49, -45, -42, -39, -35, -31, -29, -29, -30, -30, -31, -32, -33, -35, -35, -38,
-38, -38, -39, -39, -39, -40, -38, -36, -34, -31, -27, -22, -16, -11, -6, -1, 4,
9, 14, 17, 22, 26, 30, 32, 34, 38, 41, 42, 47, 50, 54, 55, 56, 57, 57, 58, 59,
61, 62, 62, 64, 64, 63, 61, 58, 54, 49, 46, 42, 37, 32, 27, 24, 19, 16, 12, 8,
6, 5, 3, 2, 0, 0, 1, 1, 1, 0, 0, 0, 0, -2, -3, -4, -6, -8, -10, -11, -14, -14,
-16, -18, -19, -20, -21, -22, -24, -25, -26, -27, -28, -30, -31, -34, -37, -41,
-43, -46, -48, -50, -52, -54, -56, -57, -59, -59, -60, -59, -57, -54, -51, -47,
-43, -39, -35, -31, -27, -22, -18, -14, -10, -6, -3, 0, 3, 6, 8, 10, 13, 16, 18,
19, 22, 24, 25, 27, 28, 29, 30, 32, 32, 34, 34, 34, 34, 32, 32, 30, 29, 28, 27,
24, 25, 23, 22, 22, 21, 22, 22, 22, 23, 24, 26, 27, 29, 31, 32, 32, 32, 31, 31,
31, 30, 29, 27, 25, 22, 19, 15, 12, 8, 6, 2, 0, -3, -6, -8, -10, -14, -15, -18,
-20, -24, -26, -29, -34, -40, -48, -61, -70, -78, -82, -83, -86, -91, -94, -98,
-104, -110, -117, -119, -118, -112, -109, -105, -103, -104, -104, -106, -106,
-104, -102, -99, -96, -91, -86, -85, -85, -87, -87, -83, -79, -73, -67, -61,
-54, -49, -44, -43, -42, -41, -36, -33, -29, -26, -23, -20, -17, -16, -15, -15,
-14, -15, -12, -13, -11, -9, -6, -4, -1, };