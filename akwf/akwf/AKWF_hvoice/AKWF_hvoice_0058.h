#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0058

const PROGMEM int8_t DATA[DATA_LENGTH] = {15, 41, 67, 88, 101, 104, 97, 84, 59,
27, -10, -46, -80, -103, -117, -118, -110, -92, -73, -48, -25, -5, 9, 19, 25,
26, 26, 25, 27, 31, 38, 49, 59, 66, 68, 64, 54, 36, 17, -5, -24, -42, -60, -70,
-75, -70, -60, -47, -33, -21, -11, -3, 1, 3, 5, 7, 12, 14, 19, 24, 32, 41, 49,
53, 49, 42, 28, 14, -1, -15, -28, -39, -45, -48, -46, -40, -32, -24, -17, -13,
-9, -8, -4, -3, 0, 2, 7, 13, 21, 30, 36, 38, 38, 34, 29, 21, 11, -1, -11, -20,
-26, -28, -28, -25, -21, -17, -13, -12, -11, -10, -11, -9, -8, -4, 0, 4, 8, 16,
21, 27, 28, 28, 24, 18, 13, 7, -1, -7, -12, -15, -18, -17, -15, -12, -10, -7,
-6, -9, -11, -11, -11, -9, -5, -2, 1, 5, 10, 16, 19, 20, 19, 17, 12, 6, 3, -2,
-5, -7, -8, -9, -8, -7, -7, -5, -5, -6, -8, -9, -9, -9, -7, -5, -4, 1, 6, 11,
13, 12, 12, 10, 8, 7, 3, 0, -4, -5, -6, -5, -2, -1, 0, 0, -2, -3, -5, -6, -6,
-8, -8, -10, -9, -6, 0, 6, 10, 12, 10, 10, 6, 5, 3, 0, -3, -3, -3, -3, -2, 1, 2,
4, 2, -1, -4, -4, -5, -6, -6, -7, -6, -6, -4, 0, 3, 6, 7, 6, 4, 4, 4, 5, 3, 1,
-2, -4, -3, -1, 0, 0, 0, -1, -3, -3, -5, -5, -3, -2, 0, -1, -2, -2, 0, 4, 6, 5,
3, 2, 1, -1, -1, -1, -1, 0, -1, -2, -3, -2, 1, 2, 2, 0, -1, -3, -5, -6, -3, -2,
1, 2, 2, 2, 5, 5, 5, 3, 2, -1, -1, -3, -4, -4, -4, -3, -1, 2, 3, 4, 4, 2, 2, -2,
-2, -3, -4, -4, -5, -4, -2, 1, 3, 5, 5, 3, 3, 2, 1, 0, -1, -3, -4, -2, -1, 0, 1,
4, 4, 3, 3, 1, 0, -1, -2, -2, -2, -3, -3, -3, 0, 1, 3, 2, 1, 0, 0, 1, 0, 0, 0,
-1, 0, -1, 1, 2, 3, 3, 3, 3, 1, 1, -1, -2, -4, -4, -5, -5, -4, -1, 2, 4, 5, 5,
4, 3, -1, -2, -3, -3, -2, -1, -1, -2, 1, 2, 5, 6, 5, 2, -1, -3, -4, -3, -3, -3,
-3, -2, 0, 2, 5, 5, 5, 1, -1, -4, -4, -2, -2, -1, -3, -1, 1, 3, 5, 6, 5, 2, -1,
-4, -4, -6, -5, -5, -4, -2, 1, 3, 3, 4, 5, 4, 2, -1, -2, -2, -2, 0, 0, 1, 3, 4,
4, 5, 4, 1, -1, -3, -5, -4, -2, 0, 3, 3, 3, 2, 3, 4, 3, 1, -1, -3, -4, -2, 0, 2,
6, 9, 8, 7, 5, 3, 1, 1, 0, -1, -4, -4, -3, -2, 1, 1, 2, 1, -1, -4, -6, -5, -3,
0, 4, 6, 8, 12, 13, 14, 10, 4, -6, -17, -26, -34, -36, -31, -21, -4, };