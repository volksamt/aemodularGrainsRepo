#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 4, 5, 7, 7, 10, 11, 14, 15,
17, 19, 21, 25, 27, 29, 33, 36, 39, 42, 45, 48, 51, 54, 57, 60, 63, 66, 68, 71,
73, 76, 77, 79, 82, 84, 87, 89, 90, 92, 94, 95, 96, 96, 98, 99, 100, 103, 106,
108, 109, 109, 110, 110, 111, 112, 113, 114, 115, 118, 118, 118, 118, 119, 118,
118, 116, 112, 105, 97, 89, 78, 68, 56, 46, 36, 26, 17, 11, 4, -2, -7, -10, -12,
-12, -13, -10, -11, -12, -11, -11, -9, -5, -1, 1, 3, 2, 1, 1, 2, 1, -1, -1, -3,
-8, -12, -17, -22, -28, -32, -38, -42, -48, -52, -54, -59, -62, -65, -67, -69,
-70, -72, -74, -78, -81, -84, -87, -90, -91, -93, -93, -94, -94, -95, -95, -94,
-92, -89, -87, -86, -83, -83, -81, -80, -78, -76, -72, -68, -64, -60, -55, -51,
-47, -43, -38, -34, -30, -27, -25, -24, -22, -20, -20, -19, -18, -14, -14, -12,
-11, -11, -11, -10, -10, -9, -9, -8, -8, -8, -8, -8, -7, -5, -2, 1, 5, 8, 12,
16, 21, 26, 31, 37, 42, 46, 51, 55, 57, 60, 63, 64, 68, 71, 74, 75, 78, 81, 82,
85, 86, 87, 88, 87, 87, 85, 83, 81, 79, 77, 74, 72, 70, 68, 65, 63, 61, 59, 56,
55, 52, 51, 48, 47, 44, 44, 42, 41, 41, 41, 42, 41, 42, 43, 43, 43, 43, 44, 42,
42, 42, 41, 39, 37, 34, 32, 29, 26, 24, 21, 18, 14, 12, 9, 6, 4, 1, -2, -5, -9,
-11, -15, -19, -22, -26, -30, -34, -37, -40, -44, -46, -49, -52, -54, -55, -58,
-59, -61, -62, -63, -63, -64, -65, -64, -65, -64, -65, -63, -62, -61, -59, -57,
-56, -55, -53, -52, -51, -50, -48, -48, -46, -46, -46, -46, -46, -46, -47, -46,
-47, -47, -48, -47, -48, -49, -49, -50, -50, -50, -50, -50, -50, -49, -48, -46,
-43, -42, -38, -34, -32, -28, -24, -20, -16, -12, -8, -5, -2, 2, 4, 8, 11, 14,
17, 19, 23, 25, 27, 29, 30, 32, 33, 34, 35, 37, 36, 37, 37, 37, 37, 36, 37, 37,
37, 37, 36, 36, 37, 37, 36, 37, 38, 38, 38, 38, 37, 38, 40, 40, 41, 42, 43, 45,
45, 47, 47, 49, 49, 50, 50, 51, 50, 51, 50, 49, 49, 48, 47, 47, 45, 44, 42, 41,
40, 36, 33, 29, 23, 20, 15, 11, 6, 1, -3, -6, -10, -14, -17, -20, -25, -27, -30,
-32, -35, -36, -38, -39, -41, -43, -44, -44, -45, -45, -46, -46, -47, -47, -47,
-47, -47, -47, -48, -49, -50, -51, -52, -53, -54, -54, -55, -56, -56, -56, -57,
-57, -59, -61, -61, -61, -62, -64, -64, -65, -66, -67, -68, -67, -68, -68, -68,
-67, -67, -66, -65, -63, -62, -60, -58, -57, -55, -51, -49, -46, -43, -39, -36,
-34, -30, -27, -25, -22, -20, -18, -15, -14, -11, -10, -9, -7, -6, -4, -3, -2,
-1, };