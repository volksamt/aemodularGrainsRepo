#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0078

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 3, 5, 6, 7, 9, 10, 12, 13, 15,
17, 17, 19, 19, 19, 20, 21, 22, 21, 22, 22, 22, 22, 22, 22, 21, 20, 20, 18, 17,
17, 16, 15, 14, 14, 14, 15, 16, 16, 16, 16, 16, 15, 14, 13, 13, 12, 11, 10, 9,
9, 9, 8, 8, 7, 7, 6, 6, 5, 4, 3, 2, 1, 1, 0, 0, 1, 2, 3, 3, 4, 5, 5, 6, 6, 6, 7,
7, 6, 7, 7, 6, 7, 7, 8, 8, 9, 9, 9, 9, 11, 12, 13, 15, 16, 17, 20, 20, 22, 23,
24, 26, 27, 29, 29, 30, 30, 31, 30, 31, 32, 32, 33, 33, 32, 33, 33, 33, 32, 32,
32, 31, 31, 32, 32, 34, 34, 34, 35, 35, 35, 36, 36, 35, 34, 33, 32, 32, 31, 31,
31, 30, 30, 31, 30, 29, 29, 27, 25, 25, 23, 22, 22, 20, 21, 21, 21, 21, 22, 23,
23, 23, 24, 24, 24, 24, 24, 24, 23, 23, 24, 23, 23, 23, 24, 22, 23, 23, 25, 24,
25, 25, 26, 25, 26, 26, 28, 28, 29, 30, 31, 34, 35, 36, 38, 38, 40, 40, 43, 42,
44, 45, 45, 47, 47, 48, 48, 49, 48, 49, 48, 48, 47, 46, 46, 46, 46, 46, 47, 47,
47, 48, 48, 48, 49, 50, 50, 50, 49, 48, 46, 43, 39, 34, 27, 19, 12, 3, -4, -12,
-20, -26, -32, -38, -42, -47, -51, -54, -59, -63, -67, -71, -74, -77, -79, -81,
-83, -84, -85, -87, -88, -90, -91, -95, -98, -101, -104, -108, -110, -113, -115,
-117, -119, -118, -120, -118, -117, -115, -112, -109, -106, -101, -96, -92, -86,
-81, -75, -71, -64, -59, -54, -50, -45, -40, -37, -33, -28, -26, -22, -19, -17,
-15, -12, -10, -7, -4, -1, 3, 6, 11, 14, 19, 22, 26, 31, 36, 38, 42, 45, 47, 49,
50, 51, 50, 50, 49, 48, 46, 44, 43, 40, 37, 34, 31, 28, 24, 21, 18, 14, 12, 8,
5, 2, 1, -1, -2, -5, -5, -8, -10, -13, -16, -17, -22, -25, -29, -32, -36, -40,
-45, -49, -52, -55, -58, -62, -64, -68, -70, -71, -72, -73, -75, -75, -74, -75,
-74, -72, -72, -70, -68, -66, -64, -61, -59, -57, -54, -52, -50, -49, -47, -45,
-43, -41, -41, -38, -36, -34, -32, -27, -24, -20, -17, -13, -9, -5, -2, 1, 5, 8,
11, 14, 17, 20, 24, 26, 30, 32, 34, 35, 38, 39, 40, 40, 40, 40, 40, 40, 40, 38,
38, 39, 38, 38, 38, 38, 36, 37, 36, 36, 35, 34, 33, 31, 31, 29, 29, 27, 24, 24,
21, 19, 16, 14, 12, 8, 6, 2, -2, -4, -7, -9, -12, -14, -15, -16, -18, -19, -18,
-19, -20, -20, -20, -21, -21, -21, -22, -21, -22, -22, -22, -23, -23, -24, -25,
-24, -25, -26, -26, -27, -27, -28, -28, -29, -27, -26, -24, -22, -21, -19, -16,
-14, -12, -10, -9, -7, -6, -5, -4, -1, -1, 0, };