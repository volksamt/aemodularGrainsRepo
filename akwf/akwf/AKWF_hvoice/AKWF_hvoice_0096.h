#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0096

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 1, 1, 0, 0, 1, 0, 0, 2, 2, 2,
2, 1, 2, 0, 0, 2, 1, 2, 2, 1, 2, 1, 0, 1, 1, 1, 1, 1, 3, 4, 4, 4, 4, 3, 5, 5, 7,
9, 9, 9, 7, 6, 6, 6, 5, 6, 9, 13, 16, 19, 19, 16, 11, 4, 2, 2, 6, 13, 18, 20,
20, 16, 15, 14, 15, 16, 17, 19, 20, 20, 22, 20, 20, 19, 19, 21, 25, 27, 29, 28,
24, 19, 16, 15, 18, 22, 26, 30, 28, 28, 28, 28, 28, 29, 27, 25, 25, 25, 27, 30,
31, 29, 27, 26, 26, 29, 32, 33, 34, 32, 28, 26, 23, 23, 22, 23, 25, 27, 30, 31,
31, 28, 27, 26, 26, 27, 27, 26, 24, 22, 21, 19, 21, 21, 22, 25, 29, 33, 35, 33,
24, 13, -2, -13, -13, -8, 8, 24, 33, 35, 28, 20, 20, 25, 36, 45, 33, 1, -43,
-93, -118, -117, -92, -46, -14, 6, 7, -12, -33, -50, -62, -69, -73, -77, -78,
-74, -67, -57, -44, -29, -14, 0, 13, 21, 24, 13, -4, -27, -51, -62, -62, -45,
-14, 15, 39, 49, 40, 26, 4, -15, -29, -39, -45, -50, -52, -51, -44, -35, -25,
-15, -12, -11, -15, -24, -36, -51, -66, -78, -83, -78, -63, -39, -17, 3, 13, 12,
3, -10, -22, -30, -33, -30, -25, -17, -8, 3, 15, 25, 31, 32, 28, 21, 10, 0, -9,
-18, -25, -28, -25, -17, -5, 6, 11, 12, 5, -6, -17, -27, -36, -41, -44, -45,
-40, -33, -23, -13, -6, -2, 0, -1, -2, -6, -11, -16, -22, -25, -24, -16, -6, 7,
17, 24, 29, 28, 25, 19, 10, 2, -6, -11, -12, -10, -3, 6, 16, 21, 23, 20, 14, 4,
-6, -15, -22, -26, -27, -25, -17, -11, -3, 2, 4, 2, 0, -2, -4, -4, -9, -14, -16,
-16, -11, -4, 4, 12, 17, 21, 22, 20, 16, 9, 3, -3, -5, -2, 3, 9, 15, 18, 18, 17,
15, 12, 10, 6, 3, -1, -6, -8, -10, -7, -3, -1, 1, 2, 4, 5, 8, 5, 0, -6, -13,
-16, -13, -7, 1, 7, 8, 7, 6, 3, 4, 7, 9, 13, 11, 8, 3, -3, -4, -1, 4, 12, 18,
19, 17, 10, 2, -3, -5, -3, 1, 6, 9, 8, 5, 0, -4, -6, -6, -4, -1, 2, 3, 3, -1,
-4, -7, -7, -6, -2, 5, 8, 8, 5, -2, -8, -12, -11, -6, 1, 7, 11, 8, 5, 2, -1, -1,
-1, 0, 0, 2, 2, 3, 3, 1, -2, -3, -3, -1, 5, 7, 5, 1, -5, -10, -12, -12, -9, -5,
0, 3, 4, 1, -3, -8, -10, -11, -8, -6, -3, -2, -1, -2, -2, -6, -8, -9, -7, -1, 6,
10, 9, 3, -2, -7, -9, -6, -3, -1, 1, 2, 3, 2, 2, -1, -3, -5, -5, -3, 0, 2, 2, 0,
-3, -3, -3, -4, -3, -1, -1, -1, 1, 0, 0, -1, -2, -3, -2, -1, };