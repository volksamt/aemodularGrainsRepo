#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 6, 7, 9, 11, 12, 13, 15, 17, 19,
22, 24, 27, 30, 33, 36, 38, 40, 41, 42, 42, 42, 41, 42, 43, 43, 45, 45, 47, 49,
51, 53, 55, 58, 58, 61, 63, 65, 68, 71, 74, 77, 80, 83, 86, 88, 91, 93, 95, 96,
97, 99, 100, 101, 102, 103, 104, 105, 107, 107, 109, 110, 112, 113, 114, 116,
116, 116, 116, 116, 116, 115, 115, 114, 114, 115, 116, 118, 118, 119, 119, 118,
116, 114, 110, 105, 100, 94, 89, 83, 79, 74, 70, 68, 65, 63, 61, 59, 57, 56, 54,
52, 52, 49, 49, 48, 48, 47, 46, 44, 45, 44, 43, 43, 42, 41, 42, 40, 39, 37, 33,
31, 28, 23, 21, 17, 14, 9, 6, 3, 0, -5, -8, -11, -15, -20, -23, -28, -31, -34,
-37, -39, -41, -42, -42, -43, -44, -45, -45, -45, -47, -48, -50, -51, -54, -55,
-56, -57, -58, -59, -60, -60, -62, -62, -62, -63, -63, -64, -63, -64, -64, -64,
-65, -65, -67, -70, -72, -75, -78, -81, -83, -86, -89, -91, -93, -94, -94, -93,
-93, -91, -89, -85, -83, -81, -77, -74, -71, -69, -66, -63, -61, -60, -58, -57,
-55, -53, -52, -50, -50, -49, -48, -48, -49, -48, -49, -51, -54, -55, -58, -58,
-60, -62, -63, -64, -63, -63, -64, -64, -63, -62, -61, -60, -58, -56, -55, -53,
-51, -49, -47, -44, -43, -42, -41, -38, -38, -36, -35, -34, -33, -32, -31, -28,
-26, -24, -22, -20, -17, -15, -13, -9, -7, -6, -3, -2, 0, 0, 1, 2, 3, 4, 3, 4,
5, 6, 7, 8, 9, 10, 11, 12, 13, 15, 17, 18, 21, 24, 27, 29, 31, 33, 36, 37, 38,
39, 39, 39, 39, 38, 38, 39, 38, 40, 39, 41, 43, 43, 44, 46, 47, 48, 49, 49, 50,
51, 52, 52, 54, 56, 57, 60, 63, 64, 68, 70, 71, 71, 72, 72, 72, 71, 71, 70, 70,
68, 67, 66, 66, 65, 66, 65, 65, 64, 65, 64, 64, 64, 63, 63, 62, 62, 62, 63, 63,
62, 62, 62, 61, 61, 59, 58, 57, 55, 53, 52, 49, 47, 46, 44, 44, 43, 42, 41, 40,
38, 38, 35, 34, 32, 30, 27, 25, 23, 21, 17, 16, 14, 12, 10, 8, 6, 4, 1, -1, -4,
-6, -11, -14, -17, -19, -23, -25, -28, -28, -29, -30, -32, -32, -34, -35, -37,
-40, -42, -45, -47, -50, -52, -55, -56, -58, -61, -63, -64, -66, -68, -69, -73,
-75, -77, -78, -80, -80, -82, -83, -84, -84, -84, -85, -85, -87, -88, -89, -90,
-92, -95, -96, -97, -99, -100, -102, -102, -102, -103, -103, -103, -102, -102,
-102, -102, -100, -99, -99, -96, -95, -94, -92, -90, -88, -86, -84, -80, -77,
-75, -72, -70, -67, -65, -65, -64, -63, -62, -62, -60, -59, -57, -56, -54, -51,
-49, -46, -44, -43, -41, -39, -38, -36, -35, -33, -31, -29, -27, -24, -22, -19,
-16, -14, -12, -9, -7, -5, -2, 0, };