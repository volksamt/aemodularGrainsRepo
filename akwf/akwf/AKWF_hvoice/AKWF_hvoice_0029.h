#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0029

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 11, 17, 23, 28, 33, 39, 46, 55,
64, 71, 74, 74, 73, 69, 64, 60, 59, 60, 62, 64, 66, 68, 70, 74, 78, 82, 87, 93,
98, 101, 103, 107, 111, 113, 115, 119, 119, 119, 117, 115, 111, 109, 107, 103,
99, 96, 89, 83, 78, 73, 70, 68, 68, 68, 70, 73, 74, 74, 74, 73, 70, 65, 58, 52,
46, 41, 35, 30, 26, 22, 17, 13, 9, 3, 1, -3, -5, -7, -9, -12, -14, -17, -19,
-22, -24, -26, -27, -29, -31, -32, -33, -34, -35, -38, -41, -45, -50, -55, -58,
-61, -61, -60, -58, -56, -55, -53, -51, -51, -50, -50, -49, -49, -48, -48, -48,
-49, -49, -49, -47, -46, -44, -43, -42, -39, -37, -35, -31, -29, -27, -25, -25,
-25, -24, -22, -19, -16, -11, -6, -3, 1, 4, 4, 6, 7, 8, 9, 10, 11, 12, 14, 14,
16, 19, 21, 23, 25, 27, 28, 28, 30, 30, 32, 32, 31, 31, 30, 28, 29, 29, 29, 32,
33, 33, 33, 33, 32, 30, 28, 26, 24, 21, 18, 16, 14, 12, 12, 11, 10, 8, 6, 5, 3,
1, -1, -3, -5, -6, -8, -11, -13, -15, -17, -19, -19, -21, -22, -23, -26, -29,
-32, -34, -37, -40, -43, -45, -47, -49, -50, -49, -50, -49, -49, -49, -48, -49,
-49, -50, -51, -52, -53, -54, -56, -55, -56, -56, -56, -57, -55, -53, -52, -52,
-51, -51, -50, -50, -49, -48, -46, -45, -43, -40, -38, -35, -32, -30, -27, -24,
-22, -20, -20, -19, -17, -15, -13, -12, -12, -9, -8, -5, -2, -1, 2, 6, 9, 9, 12,
13, 15, 15, 17, 18, 20, 20, 23, 24, 26, 27, 29, 30, 30, 30, 30, 31, 30, 30, 29,
29, 29, 29, 29, 30, 30, 32, 33, 34, 34, 33, 32, 31, 29, 29, 26, 26, 24, 21, 20,
18, 18, 19, 19, 18, 18, 16, 15, 14, 11, 9, 8, 6, 4, 3, 0, -1, -3, -5, -6, -7,
-8, -10, -13, -16, -19, -21, -24, -24, -27, -29, -31, -32, -32, -30, -28, -28,
-27, -28, -28, -28, -28, -29, -29, -30, -31, -34, -35, -36, -36, -34, -33, -32,
-32, -30, -31, -29, -28, -27, -25, -25, -23, -22, -22, -20, -18, -16, -13, -9,
-7, -6, -4, -2, -1, 0, 2, 4, 4, 4, 5, 7, 10, 13, 16, 16, 18, 20, 22, 24, 25, 27,
27, 27, 26, 24, 24, 25, 26, 26, 27, 27, 28, 27, 28, 28, 28, 27, 27, 26, 23, 23,
21, 20, 20, 20, 19, 19, 17, 16, 14, 11, 10, 6, 5, 2, -1, -3, -7, -10, -12, -14,
-14, -16, -18, -19, -21, -24, -26, -27, -29, -29, -29, -32, -35, -39, -40, -41,
-40, -40, -40, -40, -41, -43, -45, -46, -46, -45, -45, -46, -49, -51, -52, -51,
-50, -47, -45, -46, -45, -45, -44, -43, -39, -37, -35, -36, -35, -35, -35, -33,
-30, -26, -24, -23, -22, -21, -18, -14, -11, -8, -5, -5, -4, -2, 0, };