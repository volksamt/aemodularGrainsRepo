#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0084

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 4, 5, 10, 14, 17, 20, 25, 28,
30, 35, 38, 43, 46, 49, 53, 57, 59, 63, 66, 70, 71, 76, 78, 80, 83, 85, 88, 90,
93, 94, 97, 98, 100, 102, 104, 106, 107, 109, 111, 113, 113, 115, 115, 117, 118,
118, 118, 119, 119, 119, 119, 119, 119, 118, 117, 116, 114, 112, 111, 109, 107,
106, 102, 100, 96, 93, 90, 87, 84, 79, 76, 72, 68, 64, 60, 56, 53, 49, 45, 42,
38, 33, 30, 27, 23, 19, 16, 13, 10, 7, 5, 1, -1, -3, -6, -8, -9, -11, -13, -15,
-16, -18, -19, -20, -20, -22, -22, -24, -23, -24, -24, -25, -25, -25, -25, -24,
-24, -24, -24, -24, -24, -23, -23, -23, -23, -22, -22, -20, -20, -21, -20, -19,
-19, -18, -18, -17, -16, -16, -15, -14, -13, -13, -13, -11, -10, -10, -9, -8,
-7, -6, -6, -5, -3, -3, -2, -1, 0, 1, 2, 4, 4, 5, 6, 7, 7, 9, 9, 10, 10, 12, 11,
12, 13, 14, 14, 15, 16, 18, 18, 19, 19, 21, 21, 23, 24, 26, 26, 28, 30, 32, 34,
36, 38, 41, 43, 46, 49, 51, 55, 58, 60, 64, 68, 70, 72, 75, 79, 81, 83, 86, 88,
88, 90, 92, 94, 94, 96, 96, 96, 96, 95, 96, 94, 93, 92, 91, 89, 87, 85, 82, 79,
77, 75, 72, 70, 67, 64, 61, 58, 55, 52, 50, 47, 44, 40, 37, 34, 30, 27, 23, 20,
16, 12, 8, 5, 1, -4, -8, -12, -16, -20, -24, -27, -31, -35, -39, -42, -47, -49,
-53, -56, -60, -64, -66, -69, -72, -75, -78, -80, -83, -85, -87, -90, -91, -94,
-95, -96, -98, -99, -101, -102, -103, -106, -106, -107, -109, -110, -112, -113,
-113, -114, -115, -115, -115, -116, -116, -116, -115, -114, -114, -113, -112,
-110, -108, -107, -105, -103, -101, -99, -96, -94, -91, -88, -85, -82, -79, -76,
-73, -69, -65, -62, -60, -55, -53, -49, -46, -43, -40, -37, -34, -31, -29, -25,
-23, -20, -18, -15, -13, -11, -9, -6, -6, -4, -1, -1, 1, 1, 3, 4, 5, 5, 6, 6, 7,
8, 8, 8, 8, 8, 8, 8, 7, 6, 6, 6, 5, 4, 4, 3, 3, 2, 1, 0, 1, 0, -1, -1, -2, -2,
-2, -2, -2, -3, -3, -3, -4, -3, -3, -3, -3, -3, -3, -4, -3, -3, -2, -2, -2, -2,
-2, -2, -3, -1, -2, -2, -2, -2, -2, -2, -2, -1, -1, -2, -1, -2, -1, -2, -1, -3,
-2, -3, -3, -3, -4, -5, -5, -7, -7, -9, -10, -12, -13, -15, -16, -18, -20, -22,
-24, -26, -28, -32, -33, -37, -40, -42, -46, -48, -51, -54, -58, -61, -63, -67,
-69, -70, -72, -74, -76, -78, -79, -80, -82, -82, -82, -83, -83, -83, -82, -81,
-81, -79, -79, -76, -75, -73, -71, -70, -67, -64, -62, -59, -56, -53, -51, -47,
-45, -41, -38, -35, -32, -28, -26, -23, -18, -15, -12, -9, -5, -2, 0, };