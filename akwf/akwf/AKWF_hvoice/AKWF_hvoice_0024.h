#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 9, 11, 12, 15, 16, 17, 18,
17, 16, 17, 17, 17, 17, 18, 17, 18, 19, 21, 20, 21, 23, 24, 24, 26, 26, 26, 27,
28, 28, 28, 30, 30, 31, 32, 31, 31, 33, 32, 32, 33, 33, 33, 33, 33, 33, 34, 34,
33, 34, 34, 35, 35, 35, 36, 36, 35, 34, 34, 33, 32, 32, 31, 29, 29, 29, 28, 28,
27, 27, 27, 26, 24, 25, 23, 23, 23, 24, 22, 23, 23, 23, 24, 25, 23, 24, 24, 24,
24, 23, 23, 23, 24, 22, 22, 22, 21, 20, 18, 15, 14, 12, 10, 8, 7, 5, 6, 5, 5, 4,
4, 3, 2, 1, 2, 1, 0, 2, 3, 2, 5, 5, 6, 6, 7, 7, 7, 7, 7, 7, 7, 6, 7, 7, 6, 6, 6,
5, 3, 2, 1, -1, -2, -3, -4, -4, -3, -3, -1, -1, 0, 0, 1, 1, 1, 1, 1, 1, 1, 2, 2,
2, 1, 1, 1, 1, 0, 0, 2, 2, 3, 5, 5, 7, 8, 9, 10, 11, 11, 12, 11, 12, 11, 12, 11,
11, 12, 12, 12, 13, 16, 17, 17, 19, 20, 21, 21, 24, 26, 29, 31, 37, 40, 44, 49,
53, 55, 57, 59, 59, 60, 62, 61, 62, 63, 63, 64, 65, 65, 65, 65, 63, 62, 60, 59,
58, 58, 59, 60, 62, 64, 69, 73, 75, 80, 82, 84, 87, 89, 91, 94, 96, 99, 102,
105, 108, 110, 110, 111, 110, 109, 106, 104, 102, 101, 99, 98, 97, 96, 96, 94,
94, 93, 90, 89, 88, 88, 87, 87, 88, 89, 92, 93, 95, 97, 98, 99, 99, 99, 99, 99,
98, 98, 99, 98, 98, 98, 97, 95, 94, 90, 87, 83, 79, 76, 73, 71, 68, 66, 64, 61,
59, 57, 53, 50, 48, 46, 44, 43, 42, 43, 41, 42, 43, 43, 42, 41, 41, 38, 36, 34,
32, 30, 28, 25, 23, 22, 19, 17, 14, 10, 6, 2, -2, -5, -9, -12, -15, -17, -20,
-21, -23, -27, -28, -31, -34, -36, -38, -39, -40, -41, -43, -43, -45, -46, -47,
-49, -50, -51, -54, -56, -58, -58, -61, -62, -64, -66, -68, -70, -71, -74, -76,
-79, -82, -85, -88, -89, -91, -93, -94, -96, -97, -100, -101, -103, -105, -106,
-107, -107, -107, -108, -108, -107, -107, -107, -107, -108, -109, -109, -108,
-109, -110, -110, -111, -110, -111, -113, -112, -113, -114, -114, -115, -116,
-117, -118, -119, -119, -119, -119, -119, -119, -118, -118, -118, -119, -119,
-118, -117, -116, -116, -113, -110, -109, -106, -105, -104, -102, -101, -100,
-99, -98, -98, -96, -94, -93, -93, -92, -92, -90, -90, -88, -88, -88, -86, -85,
-85, -84, -83, -81, -79, -78, -76, -74, -73, -70, -68, -68, -66, -64, -62, -60,
-57, -55, -54, -52, -49, -47, -46, -44, -42, -40, -38, -37, -34, -32, -31, -28,
-27, -26, -25, -25, -24, -23, -23, -23, -22, -21, -21, -19, -18, -15, -13, -10,
-9, -8, -6, -3, -2, -1, };