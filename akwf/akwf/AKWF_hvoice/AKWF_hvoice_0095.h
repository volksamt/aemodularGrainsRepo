#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0095

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 7, 13, 12, 14, 12, 8, 8, 9,
10, 14, 14, 15, 13, 11, 8, 8, 7, 8, 7, 11, 13, 17, 21, 18, 17, 10, 4, 3, 3, 8,
15, 18, 20, 19, 16, 16, 15, 15, 18, 18, 20, 21, 22, 22, 21, 20, 20, 20, 23, 25,
28, 29, 27, 24, 20, 16, 17, 21, 24, 28, 29, 29, 30, 29, 30, 30, 29, 27, 26, 26,
27, 29, 31, 32, 30, 27, 26, 29, 31, 34, 35, 34, 33, 29, 26, 24, 22, 23, 24, 26,
30, 31, 33, 31, 30, 29, 28, 27, 29, 28, 26, 25, 23, 22, 22, 21, 23, 23, 27, 32,
34, 37, 31, 23, 11, -7, -11, -13, -4, 15, 24, 34, 35, 24, 21, 24, 27, 44, 47,
20, -5, -60, -106, -112, -120, -80, -39, -18, 7, -3, -21, -35, -56, -65, -72,
-77, -82, -81, -77, -70, -56, -44, -27, -15, 2, 14, 21, 23, 7, -8, -35, -58,
-60, -63, -37, -7, 17, 45, 43, 36, 23, -2, -16, -32, -40, -48, -53, -55, -53,
-43, -36, -24, -15, -14, -13, -21, -28, -43, -57, -70, -85, -82, -80, -61, -34,
-17, 6, 10, 8, 0, -15, -23, -32, -33, -30, -25, -16, -7, 6, 16, 26, 33, 31, 29,
19, 10, -2, -11, -20, -28, -27, -25, -15, -2, 4, 12, 9, 1, -6, -20, -29, -38,
-44, -46, -47, -39, -34, -22, -13, -6, -2, -2, -1, -4, -8, -13, -19, -22, -27,
-22, -15, -5, 10, 17, 27, 29, 28, 25, 17, 10, 1, -6, -11, -13, -6, -2, 9, 19,
22, 25, 18, 12, 2, -8, -15, -24, -27, -28, -24, -17, -10, -1, 1, 2, 1, -1, -2,
-4, -5, -12, -15, -17, -17, -9, -4, 5, 13, 18, 22, 22, 22, 14, 8, 3, -4, -3, -1,
4, 11, 14, 18, 18, 17, 15, 12, 10, 7, 3, -3, -7, -8, -9, -5, -3, -1, 1, 2, 5, 6,
8, 4, -2, -8, -15, -15, -10, -6, 3, 6, 7, 8, 3, 4, 6, 8, 12, 13, 9, 8, 1, -3,
-2, -2, 6, 15, 18, 20, 14, 7, 3, -3, -3, -1, 2, 7, 8, 6, 4, -1, -5, -6, -7, -2,
0, 2, 3, 1, -1, -5, -9, -6, -5, 1, 6, 7, 9, 3, -6, -9, -13, -11, -3, 1, 8, 9, 7,
6, 1, 0, -1, -2, 0, 0, 1, 2, 3, 3, 0, -3, -3, -3, 0, 5, 6, 4, -1, -7, -11, -13,
-13, -8, -5, 1, 2, 1, 1, -5, -9, -10, -12, -9, -6, -3, -2, -1, -2, -3, -7, -8,
-9, -6, 2, 5, 11, 8, 0, -4, -9, -9, -5, -3, -2, 0, 3, 4, 3, 3, -3, -6, -7, -7,
-4, 1, 1, 0, -1, -5, -6, -7, -7, -6, -4, -4, -1, 0, 0, -2, -4, -7, -6, -5, -3,
0, 1, 1, 2, 1, 0, 1, 0, 1, 2, 5, 7, 7, 7, 3, -1, -2, -1, 1, 7, 10, 9, 9, 4, 2,
-1, -1, };