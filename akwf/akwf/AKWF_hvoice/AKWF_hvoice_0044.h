#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0044

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 6, 10, 11, 16, 18, 20, 22, 23,
26, 26, 24, 23, 23, 21, 23, 27, 31, 33, 30, 24, 19, 13, 12, 11, 13, 15, 13, 9,
8, 6, 5, 10, 13, 19, 24, 30, 38, 44, 52, 61, 69, 77, 85, 86, 84, 86, 84, 85, 86,
83, 79, 71, 57, 48, 43, 37, 35, 33, 32, 29, 22, 22, 31, 40, 58, 81, 94, 95, 86,
68, 53, 43, 45, 55, 55, 48, 35, 10, -17, -35, -47, -50, -50, -46, -39, -42, -49,
-57, -66, -74, -75, -76, -77, -83, -90, -95, -100, -102, -101, -102, -109, -113,
-118, -118, -112, -99, -80, -61, -45, -35, -33, -34, -37, -36, -31, -24, -14,
-12, -15, -26, -40, -54, -66, -71, -73, -72, -71, -71, -70, -70, -68, -66, -65,
-63, -63, -63, -64, -64, -62, -57, -53, -51, -51, -55, -62, -63, -60, -51, -37,
-20, -2, 9, 18, 23, 26, 30, 36, 46, 55, 61, 62, 59, 52, 43, 33, 24, 17, 11, 6,
2, -1, -2, -2, -1, 2, 3, 2, 1, -1, -1, 2, 7, 12, 14, 14, 11, 5, 0, -3, -1, 5,
16, 25, 33, 41, 45, 49, 54, 60, 67, 74, 79, 82, 83, 81, 75, 71, 64, 55, 47, 38,
31, 23, 18, 15, 14, 13, 11, 8, 6, 2, 0, 1, 3, 7, 11, 13, 13, 8, 5, 3, 3, 6, 10,
14, 19, 26, 32, 39, 44, 48, 53, 58, 65, 72, 77, 79, 76, 69, 63, 55, 44, 34, 25,
15, 3, -4, -11, -20, -26, -28, -25, -22, -18, -13, -10, -8, -4, 1, 6, 11, 15,
16, 13, 9, 5, 7, 12, 18, 21, 22, 19, 15, 8, 5, 6, 6, 8, 10, 10, 5, -3, -10, -18,
-25, -29, -31, -32, -35, -41, -47, -49, -53, -55, -55, -52, -48, -45, -38, -32,
-26, -23, -22, -22, -25, -27, -27, -26, -25, -25, -24, -22, -25, -28, -32, -32,
-31, -31, -27, -19, -14, -14, -12, -13, -21, -26, -31, -28, -26, -24, -16, -12,
-15, -15, -14, -14, -16, -10, 2, 10, 21, 31, 41, 46, 53, 58, 59, 60, 58, 57, 57,
58, 62, 59, 55, 45, 34, 21, 11, 6, 5, 6, 9, 12, 11, 11, 11, 16, 24, 40, 57, 66,
63, 54, 43, 34, 36, 41, 45, 40, 32, 18, 5, -6, -10, -11, -9, -5, 2, 3, -4, -12,
-23, -26, -26, -23, -25, -31, -41, -51, -60, -67, -68, -69, -70, -71, -70, -71,
-70, -64, -54, -44, -32, -22, -16, -14, -15, -14, -11, -5, 0, 3, 2, -2, -4, -8,
-11, -10, -8, -3, 0, 4, 5, 4, 1, -1, -3, -4, -5, -8, -16, -25, -33, -42, -47,
-50, -54, -55, -58, -55, -52, -49, -44, -37, -30, -21, -12, -4, 2, 5, 10, 15,
19, 22, 24, 25, 25, 23, 23, 22, 21, 20, 20, 20, 21, 22, 20, 17, 14, 11, 6, 2,
-2, -7, -10, -12, -17, -21, -25, -26, -28, -31, -30, -27, -24, -19, -13, -8, -3,
0, };