#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0064

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 1, 0, 2, 1, 1, 2, 2, 3, 3, 4,
4, 5, 4, 5, 4, 4, 5, 4, 5, 4, 5, 3, 3, 3, 2, 2, 2, 2, 1, 1, 1, 1, 1, 0, 1, 0, 0,
1, 0, 1, 1, 0, 1, 0, 1, 1, 1, 1, 2, 3, 2, 3, 3, 3, 4, 4, 4, 4, 5, 4, 5, 4, 5, 5,
4, 4, 4, 5, 6, 7, 9, 10, 13, 16, 19, 21, 24, 27, 30, 32, 34, 35, 34, 33, 33, 31,
31, 29, 29, 28, 27, 26, 23, 21, 19, 18, 16, 15, 14, 12, 12, 12, 12, 10, 11, 10,
11, 11, 13, 14, 15, 15, 15, 15, 15, 14, 13, 12, 12, 12, 12, 11, 10, 10, 10, 10,
10, 11, 13, 14, 16, 18, 19, 20, 22, 22, 25, 26, 28, 30, 31, 32, 34, 35, 35, 36,
37, 38, 37, 38, 39, 38, 37, 37, 37, 36, 36, 35, 36, 34, 34, 34, 33, 32, 33, 32,
31, 32, 31, 31, 32, 31, 32, 31, 31, 30, 31, 31, 31, 31, 32, 31, 31, 31, 31, 31,
30, 28, 27, 25, 23, 21, 20, 19, 17, 15, 15, 15, 15, 16, 17, 18, 19, 21, 23, 26,
29, 29, 28, 24, 18, 9, -3, -15, -29, -44, -55, -68, -78, -87, -95, -102, -108,
-113, -116, -119, -119, -117, -113, -109, -104, -98, -91, -84, -77, -69, -61,
-51, -42, -32, -24, -17, -12, -8, -5, -4, -5, -6, -6, -8, -8, -11, -10, -11,
-10, -8, -6, -3, 1, 5, 8, 12, 15, 18, 22, 25, 28, 31, 33, 33, 34, 34, 33, 29,
27, 22, 17, 10, 3, -5, -14, -26, -34, -43, -51, -58, -63, -68, -69, -71, -72,
-71, -71, -70, -68, -64, -60, -56, -52, -48, -43, -38, -33, -29, -23, -19, -14,
-11, -7, -5, -4, -4, -5, -6, -9, -11, -12, -13, -13, -13, -11, -9, -5, -2, 1, 4,
9, 11, 15, 17, 19, 20, 21, 21, 23, 23, 23, 22, 21, 20, 17, 13, 9, 4, -2, -8,
-13, -19, -25, -29, -33, -38, -41, -43, -44, -44, -43, -42, -40, -36, -33, -30,
-26, -24, -21, -18, -16, -13, -11, -10, -8, -7, -6, -5, -6, -5, -4, -4, -2, -2,
-2, -3, -3, -3, -3, -3, -1, 2, 5, 7, 10, 14, 16, 19, 22, 24, 27, 28, 31, 32, 32,
31, 29, 27, 25, 22, 18, 15, 11, 8, 4, 0, -3, -7, -9, -12, -15, -17, -17, -18,
-18, -18, -17, -17, -14, -11, -10, -7, -4, -2, 0, 1, 1, 2, 1, 2, 1, 2, 2, 2, 1,
1, 1, 0, 0, -1, -2, -2, -2, -1, 0, 0, 2, 2, 4, 6, 7, 9, 10, 11, 13, 14, 14, 14,
14, 14, 12, 11, 9, 7, 5, 3, 2, 0, -2, -3, -3, -5, -6, -8, -9, -9, -10, -10, -11,
-11, -11, -9, -9, -8, -7, -7, -5, -4, -3, -2, -2, 0, -1, -1, -1, -1, -1, -1, -1,
0, -1, 0, 0, };