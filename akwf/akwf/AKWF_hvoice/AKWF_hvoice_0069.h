#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0069

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 0, 0, 0, -1, 0, 0, 0, 1, 2, 3, 2,
3, 5, 4, 6, 5, 6, 6, 7, 8, 7, 9, 9, 9, 10, 9, 9, 11, 12, 12, 13, 14, 13, 15, 15,
15, 16, 16, 15, 15, 17, 17, 18, 19, 20, 20, 22, 22, 23, 24, 24, 25, 24, 23, 23,
22, 22, 20, 19, 20, 19, 20, 20, 21, 22, 23, 24, 26, 28, 29, 29, 30, 31, 32, 32,
32, 32, 32, 33, 33, 34, 35, 34, 37, 37, 39, 40, 43, 45, 46, 48, 49, 51, 52, 53,
54, 54, 53, 55, 55, 56, 56, 56, 58, 58, 59, 60, 61, 62, 64, 65, 66, 66, 68, 68,
68, 68, 68, 67, 65, 64, 63, 62, 61, 61, 60, 60, 60, 60, 60, 59, 60, 60, 59, 60,
59, 58, 57, 56, 54, 53, 51, 50, 48, 46, 44, 44, 41, 39, 38, 37, 35, 34, 33, 33,
32, 31, 29, 26, 23, 18, 11, 3, -5, -15, -25, -36, -46, -56, -65, -72, -80, -86,
-92, -97, -100, -102, -104, -106, -108, -108, -108, -109, -111, -112, -113,
-114, -116, -119, -119, -119, -119, -117, -114, -112, -109, -104, -100, -95,
-89, -85, -80, -75, -71, -66, -62, -60, -57, -55, -53, -52, -52, -50, -49, -48,
-45, -43, -40, -37, -34, -33, -30, -29, -27, -26, -25, -24, -24, -23, -23, -23,
-24, -25, -26, -27, -26, -27, -26, -24, -23, -20, -18, -16, -14, -13, -11, -10,
-10, -9, -8, -7, -8, -8, -8, -9, -9, -9, -9, -10, -9, -8, -8, -6, -5, -4, -3,
-3, -2, -3, -3, -3, -4, -5, -5, -7, -8, -9, -10, -10, -11, -11, -11, -12, -12,
-11, -10, -8, -7, -6, -5, -4, -4, -4, -4, -4, -4, -5, -6, -6, -6, -6, -6, -5,
-5, -4, -3, -2, 0, 1, 3, 4, 5, 6, 7, 6, 7, 6, 7, 5, 5, 6, 6, 7, 7, 8, 9, 9, 10,
10, 11, 13, 13, 13, 14, 14, 14, 14, 14, 13, 13, 12, 12, 12, 12, 12, 12, 12, 12,
12, 12, 11, 10, 9, 9, 8, 7, 7, 7, 6, 6, 6, 6, 6, 5, 5, 5, 4, 5, 4, 4, 4, 3, 3,
4, 3, 4, 3, 3, 2, 2, 2, 1, 1, 0, 0, -1, -1, -3, -2, -2, -2, -1, -1, 0, 1, 2, 3,
3, 3, 4, 3, 3, 1, 1, 1, 0, -1, -2, -2, -3, -3, -2, -2, -1, -1, -1, 0, -1, 1, 0,
1, 0, 0, -1, -1, -2, -3, -6, -6, -7, -7, -7, -8, -7, -7, -6, -7, -6, -6, -6, -5,
-5, -6, -6, -6, -6, -6, -7, -7, -6, -8, -7, -7, -7, -8, -7, -7, -6, -6, -6, -6,
-6, -7, -6, -6, -6, -5, -5, -5, -6, -6, -6, -5, -5, -5, -4, -5, -5, -5, -5, -5,
-4, -4, -5, -5, -3, -5, -5, -5, -4, -4, -5, -4, -5, -4, -4, -5, -4, -4, -5, -5,
-4, -4, -5, -4, -4, -3, -3, -2, -2, 0, };