#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 7, 9, 9, 11, 12, 12, 12, 12,
12, 12, 11, 11, 11, 12, 13, 13, 15, 16, 17, 19, 21, 23, 23, 25, 26, 26, 27, 27,
29, 29, 30, 32, 34, 37, 38, 41, 44, 46, 49, 50, 52, 53, 55, 57, 57, 59, 60, 61,
63, 64, 66, 67, 69, 71, 73, 75, 77, 79, 80, 82, 83, 84, 85, 86, 86, 87, 87, 88,
89, 90, 91, 94, 96, 97, 100, 101, 103, 104, 107, 107, 107, 108, 108, 109, 109,
111, 113, 113, 114, 115, 115, 116, 116, 116, 116, 117, 117, 117, 117, 118, 118,
118, 119, 119, 119, 118, 118, 117, 118, 116, 115, 114, 112, 111, 110, 110, 109,
110, 109, 110, 110, 109, 109, 108, 106, 105, 104, 103, 101, 101, 101, 100, 100,
101, 101, 101, 102, 101, 101, 100, 100, 99, 97, 97, 95, 93, 92, 90, 88, 86, 86,
84, 83, 83, 82, 82, 81, 81, 80, 80, 81, 80, 79, 79, 78, 76, 75, 72, 70, 69, 67,
65, 64, 64, 63, 64, 64, 65, 65, 64, 63, 63, 62, 61, 61, 60, 58, 57, 57, 55, 54,
52, 52, 50, 48, 49, 47, 46, 44, 42, 41, 40, 39, 36, 35, 32, 33, 31, 29, 29, 29,
26, 26, 25, 24, 24, 23, 22, 21, 21, 19, 18, 16, 15, 13, 11, 10, 8, 8, 7, 6, 5,
5, 4, 2, 2, 2, 1, 1, -1, -1, -2, -4, -5, -8, -11, -14, -17, -21, -23, -26, -27,
-29, -30, -32, -32, -34, -35, -35, -37, -39, -39, -40, -42, -44, -45, -47, -49,
-52, -53, -55, -56, -58, -57, -59, -58, -60, -59, -60, -61, -62, -64, -66, -68,
-70, -71, -72, -72, -73, -73, -74, -74, -74, -74, -75, -75, -76, -76, -78, -78,
-82, -84, -86, -90, -92, -93, -94, -95, -94, -94, -93, -91, -90, -88, -88, -87,
-87, -88, -87, -88, -89, -89, -90, -89, -90, -90, -90, -91, -90, -90, -90, -90,
-89, -89, -88, -88, -87, -88, -86, -87, -87, -88, -87, -87, -88, -89, -88, -89,
-89, -88, -88, -87, -86, -85, -84, -84, -82, -82, -81, -82, -82, -83, -83, -84,
-85, -85, -85, -86, -85, -85, -83, -82, -81, -81, -80, -79, -78, -78, -77, -79,
-79, -79, -79, -80, -81, -82, -83, -83, -83, -83, -84, -83, -81, -81, -80, -80,
-80, -81, -80, -82, -82, -82, -83, -82, -83, -84, -83, -83, -83, -81, -80, -79,
-77, -76, -74, -72, -72, -71, -71, -71, -71, -71, -71, -70, -69, -68, -67, -65,
-64, -63, -62, -61, -61, -62, -63, -63, -63, -63, -62, -62, -60, -58, -57, -55,
-53, -53, -53, -52, -53, -53, -52, -52, -52, -51, -49, -48, -45, -44, -41, -40,
-37, -36, -35, -34, -32, -33, -31, -31, -32, -30, -30, -29, -27, -26, -23, -21,
-21, -18, -16, -15, -13, -11, -11, -12, -12, -12, -12, -13, -13, -15, -14, -15,
-13, -12, -12, -10, -8, -6, -6, -4, -4, -3, -3, -3, -3, -3, -2, -2, 0, };