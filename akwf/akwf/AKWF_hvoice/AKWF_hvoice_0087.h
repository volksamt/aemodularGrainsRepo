#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0087

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 6, 6, 7, 8, 8, 10, 11, 12,
13, 14, 15, 16, 16, 18, 19, 19, 21, 22, 22, 24, 24, 26, 26, 28, 28, 30, 30, 32,
33, 34, 35, 36, 36, 37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 47, 47, 48, 49, 49,
50, 51, 52, 54, 54, 55, 56, 56, 57, 57, 58, 60, 60, 61, 62, 62, 63, 65, 65, 65,
66, 68, 68, 69, 70, 70, 72, 73, 74, 74, 76, 76, 79, 79, 80, 82, 82, 84, 84, 86,
87, 88, 90, 91, 92, 94, 95, 96, 98, 99, 101, 101, 103, 104, 105, 106, 107, 108,
110, 110, 111, 112, 113, 114, 115, 116, 116, 116, 117, 119, 119, 119, 119, 118,
120, 119, 119, 118, 118, 119, 117, 116, 116, 115, 114, 113, 112, 111, 109, 108,
106, 105, 103, 101, 99, 98, 95, 92, 90, 88, 85, 82, 79, 77, 74, 71, 67, 66, 61,
59, 55, 52, 48, 45, 42, 38, 35, 31, 28, 24, 21, 17, 14, 10, 7, 3, 0, -4, -7,
-12, -14, -17, -21, -25, -27, -31, -34, -37, -39, -43, -45, -48, -51, -54, -56,
-58, -60, -63, -65, -67, -69, -71, -73, -75, -75, -78, -79, -80, -81, -83, -84,
-85, -86, -86, -87, -88, -89, -90, -89, -91, -90, -90, -90, -91, -91, -91, -91,
-91, -90, -90, -90, -89, -89, -89, -88, -88, -88, -86, -86, -85, -84, -84, -83,
-82, -82, -81, -81, -79, -79, -78, -77, -76, -76, -75, -75, -73, -72, -72, -71,
-71, -70, -68, -68, -67, -67, -65, -65, -64, -63, -63, -62, -61, -60, -59, -59,
-58, -58, -57, -56, -55, -54, -54, -53, -52, -51, -51, -50, -49, -48, -47, -46,
-46, -45, -44, -43, -42, -41, -40, -39, -38, -37, -35, -35, -34, -33, -32, -32,
-30, -29, -28, -26, -25, -24, -24, -22, -21, -19, -18, -17, -17, -16, -13, -13,
-11, -11, -9, -8, -7, -7, -6, -4, -4, -3, -1, 0, 0, 1, 3, 3, 5, 5, 6, 7, 7, 8,
9, 9, 9, 10, 10, 11, 11, 12, 11, 11, 12, 13, 13, 12, 12, 12, 12, 12, 12, 12, 11,
12, 10, 10, 10, 9, 9, 9, 7, 7, 6, 6, 5, 3, 3, 3, 2, 0, 0, -1, -2, -3, -5, -5,
-7, -8, -8, -9, -11, -11, -12, -14, -14, -16, -17, -18, -18, -20, -21, -21, -22,
-24, -24, -24, -25, -27, -27, -29, -29, -30, -31, -32, -32, -33, -34, -35, -34,
-35, -36, -36, -36, -37, -38, -37, -39, -38, -39, -40, -40, -40, -40, -40, -41,
-41, -41, -42, -41, -41, -41, -41, -42, -42, -42, -41, -41, -41, -42, -40, -40,
-41, -40, -40, -40, -39, -39, -39, -39, -38, -38, -37, -36, -36, -35, -35, -35,
-34, -33, -33, -32, -31, -30, -30, -30, -29, -29, -28, -26, -26, -25, -25, -23,
-23, -22, -22, -20, -20, -18, -18, -17, -16, -15, -14, -13, -12, -11, -10, -10,
-8, -7, -6, -5, -4, -3, -2, 0, };