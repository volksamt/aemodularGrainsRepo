#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0099

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 7, 9, 11, 14, 15, 18, 20, 21,
24, 26, 28, 29, 30, 31, 33, 31, 33, 34, 35, 36, 36, 37, 38, 38, 39, 39, 39, 40,
40, 39, 40, 41, 41, 41, 40, 39, 39, 37, 36, 35, 33, 33, 31, 31, 31, 30, 29, 29,
28, 27, 26, 24, 23, 21, 21, 19, 18, 17, 17, 15, 15, 13, 13, 12, 11, 10, 8, 9, 8,
6, 6, 5, 5, 5, 4, 4, 4, 4, 4, 4, 5, 4, 5, 5, 5, 5, 6, 6, 7, 8, 8, 8, 8, 8, 10,
9, 11, 13, 13, 14, 16, 17, 18, 19, 20, 20, 21, 23, 23, 24, 25, 27, 27, 28, 30,
31, 32, 33, 34, 36, 37, 38, 38, 39, 38, 39, 39, 40, 40, 42, 43, 45, 46, 47, 48,
48, 48, 48, 48, 47, 48, 49, 50, 50, 51, 51, 52, 51, 50, 51, 51, 51, 51, 51, 49,
49, 49, 48, 48, 48, 48, 47, 49, 50, 50, 50, 49, 50, 48, 48, 48, 47, 47, 46, 46,
47, 46, 46, 45, 45, 44, 43, 43, 42, 41, 40, 39, 38, 37, 37, 37, 38, 38, 38, 39,
39, 40, 40, 40, 39, 37, 33, 30, 24, 18, 12, 5, -2, -8, -12, -17, -22, -26, -29,
-33, -37, -41, -45, -47, -49, -53, -55, -58, -60, -64, -66, -70, -73, -78, -81,
-85, -88, -92, -96, -100, -103, -107, -112, -114, -117, -118, -119, -119, -118,
-117, -116, -114, -112, -110, -107, -104, -103, -100, -99, -97, -95, -93, -92,
-91, -89, -86, -83, -81, -78, -75, -72, -69, -67, -62, -58, -54, -50, -45, -40,
-36, -31, -26, -22, -17, -12, -8, -2, 3, 6, 10, 12, 14, 15, 16, 18, 19, 21, 23,
25, 26, 29, 31, 32, 34, 36, 37, 38, 40, 40, 41, 41, 42, 41, 41, 39, 38, 36, 35,
32, 30, 27, 25, 22, 19, 17, 13, 11, 8, 5, 3, 0, -3, -5, -8, -10, -13, -15, -17,
-19, -21, -24, -27, -30, -33, -37, -41, -44, -48, -50, -55, -56, -58, -61, -62,
-62, -62, -62, -63, -63, -62, -63, -62, -62, -63, -63, -63, -61, -61, -60, -58,
-56, -55, -53, -51, -51, -49, -47, -46, -45, -44, -42, -40, -37, -35, -32, -29,
-25, -20, -17, -12, -9, -6, -3, -1, 1, 3, 6, 8, 11, 15, 17, 21, 24, 25, 28, 29,
30, 31, 32, 36, 37, 38, 41, 42, 43, 44, 44, 46, 46, 47, 48, 48, 48, 47, 46, 45,
45, 44, 43, 43, 43, 41, 41, 38, 37, 34, 32, 31, 29, 28, 27, 26, 24, 21, 19, 17,
15, 13, 11, 10, 8, 7, 5, 4, 1, -2, -5, -9, -11, -14, -15, -17, -19, -21, -23,
-24, -25, -27, -28, -29, -30, -30, -32, -33, -33, -34, -34, -35, -36, -36, -35,
-35, -35, -36, -36, -37, -38, -38, -38, -37, -37, -36, -35, -33, -32, -31, -30,
-28, -26, -25, -23, -21, -20, -17, -16, -13, -12, -10, -9, -7, -6, -4, -3, -2,
};