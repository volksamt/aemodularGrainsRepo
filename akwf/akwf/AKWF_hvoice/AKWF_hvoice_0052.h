#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0052

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 6, 6, 7, 9, 8, 8, 9, 8, 9, 8,
7, 6, 8, 9, 11, 13, 15, 16, 17, 16, 15, 15, 17, 17, 17, 18, 19, 21, 21, 21, 20,
20, 23, 25, 25, 25, 23, 24, 26, 27, 27, 26, 28, 31, 34, 35, 36, 36, 38, 41, 41,
40, 40, 42, 46, 48, 48, 48, 48, 52, 53, 53, 51, 52, 56, 59, 60, 59, 58, 62, 65,
67, 67, 65, 68, 71, 74, 75, 73, 72, 74, 77, 77, 77, 75, 78, 83, 86, 85, 83, 84,
86, 86, 86, 85, 86, 90, 92, 92, 91, 91, 94, 97, 97, 96, 95, 96, 98, 98, 95, 95,
95, 96, 99, 99, 102, 104, 106, 104, 98, 90, 82, 80, 80, 82, 86, 89, 92, 94, 96,
103, 112, 119, 118, 104, 82, 54, 26, 7, -5, -11, -10, -5, 1, 8, 9, 7, 3, 2, 2,
3, 2, 4, 6, 11, 15, 17, 17, 15, 14, 14, 11, 8, 4, 1, -1, -4, -9, -14, -17, -18,
-21, -26, -30, -31, -31, -33, -34, -36, -36, -37, -37, -39, -42, -42, -40, -39,
-40, -42, -42, -42, -40, -42, -45, -47, -48, -48, -47, -50, -52, -54, -53, -52,
-53, -54, -54, -53, -52, -52, -52, -53, -54, -53, -55, -56, -56, -57, -56, -57,
-56, -54, -54, -54, -55, -55, -56, -55, -55, -56, -55, -54, -53, -52, -53, -55,
-54, -52, -52, -53, -55, -56, -56, -54, -54, -56, -56, -54, -53, -53, -55, -56,
-55, -53, -52, -53, -53, -52, -50, -50, -48, -49, -49, -49, -49, -47, -47, -47,
-46, -44, -45, -45, -46, -46, -46, -45, -45, -43, -43, -43, -42, -40, -39, -38,
-39, -38, -37, -37, -35, -37, -36, -36, -35, -34, -34, -33, -33, -31, -31, -29,
-30, -30, -31, -32, -31, -30, -30, -29, -27, -25, -24, -22, -21, -22, -22, -22,
-23, -22, -23, -23, -22, -19, -17, -17, -17, -18, -17, -18, -18, -19, -19, -19,
-17, -14, -14, -14, -15, -15, -14, -13, -13, -14, -14, -11, -11, -11, -12, -12,
-12, -10, -8, -8, -9, -9, -9, -8, -8, -9, -7, -5, -5, -4, -5, -7, -8, -8, -9,
-8, -7, -6, -5, -5, -4, -5, -4, -5, -5, -6, -4, -3, -3, -2, -3, -3, -4, -4, -5,
-5, -4, -4, -4, -4, -4, -5, -6, -6, -6, -5, -5, -5, -5, -5, -5, -4, -6, -8, -7,
-7, -5, -5, -5, -6, -6, -6, -5, -6, -7, -7, -8, -7, -7, -6, -4, -3, -3, -5, -6,
-7, -7, -7, -8, -8, -10, -10, -9, -8, -7, -6, -7, -7, -8, -9, -10, -10, -10, -9,
-7, -7, -7, -7, -7, -9, -9, -9, -10, -10, -9, -10, -9, -10, -9, -10, -10, -10,
-11, -9, -9, -9, -10, -9, -8, -8, -8, -9, -9, -8, -7, -7, -7, -8, -8, -6, -8,
-8, -8, -7, -7, -6, -6, -7, -6, -6, -5, -5, -6, -6, -6, -8, -7, -7, -4, -3, -3,
-2, -2, -1, -1, -1, -1, 0, };