#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0070

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 7, 9, 9, 10, 11, 12, 13, 14,
13, 13, 14, 16, 16, 17, 18, 17, 17, 16, 16, 15, 14, 14, 14, 13, 13, 12, 11, 11,
9, 9, 9, 9, 9, 9, 8, 7, 6, 5, 4, 3, 2, 3, 3, 3, 3, 2, 1, 1, 1, 0, 0, 0, 0, 1, 2,
3, 4, 3, 3, 4, 5, 5, 6, 7, 7, 7, 8, 8, 9, 11, 11, 11, 12, 12, 12, 14, 16, 16,
17, 16, 17, 18, 19, 20, 22, 21, 23, 22, 23, 23, 23, 23, 23, 24, 25, 25, 27, 27,
28, 28, 29, 29, 30, 30, 30, 30, 30, 30, 31, 31, 32, 33, 32, 32, 33, 32, 33, 33,
34, 35, 37, 37, 37, 38, 38, 39, 39, 40, 39, 39, 40, 40, 41, 42, 43, 44, 43, 43,
42, 42, 41, 41, 40, 41, 40, 41, 40, 40, 38, 38, 38, 37, 37, 37, 37, 35, 35, 34,
33, 32, 31, 32, 30, 29, 29, 27, 28, 28, 27, 24, 22, 20, 16, 13, 14, 13, 13, 12,
13, 11, 10, 12, 13, 11, 9, 3, -7, -16, -23, -29, -36, -36, -38, -45, -49, -53,
-62, -69, -73, -77, -83, -88, -92, -97, -102, -102, -105, -107, -109, -111,
-114, -117, -118, -119, -119, -116, -114, -112, -110, -108, -107, -104, -102,
-100, -96, -91, -87, -81, -75, -70, -66, -60, -55, -51, -45, -41, -36, -30, -24,
-18, -12, -6, 0, 4, 8, 13, 16, 20, 24, 29, 33, 37, 40, 44, 46, 47, 48, 48, 49,
50, 51, 52, 53, 52, 51, 51, 49, 47, 46, 44, 41, 38, 36, 33, 30, 27, 24, 20, 16,
13, 10, 6, 2, -1, -5, -7, -10, -14, -17, -19, -23, -27, -31, -34, -36, -37, -39,
-41, -43, -44, -47, -49, -49, -50, -51, -51, -50, -50, -50, -48, -48, -47, -46,
-43, -42, -39, -37, -35, -31, -30, -27, -24, -21, -18, -15, -11, -9, -5, -2, 1,
4, 5, 9, 12, 15, 19, 22, 25, 28, 30, 31, 32, 34, 35, 37, 38, 40, 41, 42, 43, 43,
44, 42, 42, 41, 39, 39, 37, 37, 37, 36, 33, 31, 28, 26, 22, 21, 18, 17, 15, 13,
11, 8, 5, 1, -2, -5, -7, -11, -12, -14, -15, -17, -18, -20, -21, -22, -25, -27,
-29, -28, -28, -27, -27, -27, -27, -27, -26, -27, -27, -26, -26, -25, -22, -21,
-19, -18, -16, -15, -14, -12, -10, -8, -7, -6, -3, 0, 1, 3, 6, 8, 8, 10, 10, 12,
13, 16, 19, 20, 21, 23, 23, 22, 23, 24, 24, 24, 25, 25, 24, 26, 26, 25, 23, 22,
20, 18, 16, 16, 15, 14, 13, 12, 11, 9, 8, 4, 2, 0, -1, -3, -3, -4, -4, -6, -8,
-10, -12, -14, -16, -17, -19, -19, -21, -22, -22, -22, -23, -24, -24, -26, -26,
-26, -26, -25, -24, -23, -21, -21, -21, -20, -20, -21, -20, -17, -17, -14, -13,
-12, -11, -10, -9, -9, -8, -8, -6, -4, -2, -1, };