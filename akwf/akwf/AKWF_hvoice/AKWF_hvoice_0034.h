#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0034

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 7, 10, 13, 16, 20, 23, 23,
25, 26, 28, 29, 32, 33, 33, 34, 34, 37, 38, 40, 43, 46, 50, 58, 64, 71, 78, 84,
92, 100, 107, 112, 115, 118, 119, 118, 119, 117, 115, 111, 108, 104, 102, 99,
95, 93, 90, 89, 86, 84, 80, 74, 70, 66, 63, 58, 54, 49, 44, 39, 35, 31, 26, 22,
18, 14, 12, 10, 9, 7, 6, 4, 3, 2, 0, 0, 0, -2, -1, -1, 0, -1, -1, -2, -2, -1,
-1, 0, -1, -2, -3, -6, -8, -10, -14, -17, -18, -20, -20, -20, -20, -19, -19,
-17, -16, -13, -11, -10, -7, -6, -3, -1, 2, 3, 4, 5, 7, 10, 13, 15, 17, 20, 22,
26, 30, 33, 37, 41, 45, 50, 53, 54, 55, 54, 53, 51, 49, 47, 44, 41, 39, 35, 33,
30, 27, 24, 20, 18, 14, 11, 8, 4, 0, -2, -6, -8, -12, -13, -15, -17, -18, -20,
-22, -23, -25, -26, -27, -30, -30, -31, -30, -30, -31, -31, -32, -33, -35, -34,
-35, -35, -35, -34, -33, -34, -32, -33, -32, -32, -32, -32, -33, -35, -38, -39,
-41, -43, -44, -45, -44, -45, -43, -41, -40, -39, -37, -36, -34, -32, -29, -27,
-26, -23, -21, -18, -16, -14, -11, -9, -6, -4, -2, 1, 3, 5, 6, 8, 11, 11, 13,
13, 14, 14, 14, 13, 13, 11, 9, 7, 7, 6, 4, 3, 2, 1, 1, -2, -3, -4, -7, -9, -9,
-12, -14, -15, -16, -18, -18, -17, -15, -15, -14, -13, -15, -15, -16, -17, -16,
-15, -14, -14, -14, -16, -17, -20, -21, -21, -21, -21, -22, -23, -24, -27, -29,
-31, -33, -33, -33, -34, -34, -35, -37, -39, -41, -43, -43, -44, -43, -41, -39,
-38, -35, -34, -32, -32, -30, -30, -27, -24, -19, -17, -14, -12, -10, -9, -5,
-2, 1, 3, 8, 10, 12, 13, 14, 15, 16, 15, 17, 17, 17, 18, 18, 17, 17, 17, 17, 17,
17, 17, 17, 18, 19, 20, 21, 22, 22, 22, 22, 20, 19, 19, 19, 19, 20, 19, 20, 19,
18, 16, 15, 13, 12, 10, 9, 9, 7, 3, 0, -3, -6, -8, -11, -13, -16, -17, -19, -22,
-25, -29, -32, -35, -36, -36, -37, -37, -38, -38, -40, -40, -39, -39, -37, -36,
-34, -32, -31, -29, -28, -27, -24, -23, -20, -18, -16, -14, -14, -13, -13, -13,
-13, -12, -10, -10, -9, -7, -7, -8, -7, -8, -7, -7, -7, -5, -4, -3, -5, -5, -5,
-5, -5, -3, -3, -2, -1, -1, -1, 0, 1, 1, 1, 1, 3, 4, 3, 4, 3, 4, 2, 1, 1, -1,
-3, -4, -6, -6, -8, -9, -11, -14, -17, -19, -21, -21, -23, -24, -26, -29, -31,
-34, -36, -37, -36, -35, -33, -32, -34, -35, -38, -39, -38, -37, -34, -33, -32,
-32, -31, -33, -35, -37, -36, -36, -33, -29, -26, -25, -24, -24, -24, -23, -20,
-17, -13, -10, -4, -2, 1, 1, 0, -2, -2, -1, };