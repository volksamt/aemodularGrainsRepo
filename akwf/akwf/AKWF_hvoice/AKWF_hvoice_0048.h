#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0048

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 14, 20, 25, 31, 37, 43, 51, 56,
62, 67, 71, 75, 78, 81, 82, 83, 82, 82, 79, 77, 73, 69, 64, 60, 54, 49, 43, 36,
28, 21, 15, 7, 2, -5, -11, -16, -21, -25, -28, -31, -34, -35, -36, -36, -35,
-34, -33, -32, -29, -27, -23, -20, -15, -11, -7, -2, 1, 6, 11, 15, 18, 22, 25,
28, 30, 32, 34, 35, 37, 37, 40, 40, 40, 40, 40, 39, 39, 38, 38, 39, 37, 37, 35,
34, 34, 32, 31, 31, 31, 31, 31, 30, 30, 28, 27, 25, 25, 24, 23, 21, 19, 18, 17,
15, 13, 12, 11, 9, 8, 7, 5, 5, 4, 4, 4, 4, 5, 7, 9, 11, 14, 16, 18, 20, 22, 23,
24, 26, 25, 26, 25, 24, 22, 19, 18, 15, 13, 11, 9, 7, 2, -3, -9, -15, -23, -30,
-35, -42, -47, -54, -59, -63, -68, -72, -75, -76, -77, -76, -75, -73, -71, -67,
-64, -60, -57, -52, -48, -43, -39, -33, -29, -24, -19, -14, -11, -8, -5, -2, -1,
0, 1, 0, 0, -1, -4, -7, -10, -13, -17, -20, -24, -28, -31, -35, -38, -41, -44,
-48, -52, -55, -57, -61, -63, -65, -66, -68, -67, -68, -67, -66, -65, -63, -61,
-57, -55, -53, -50, -49, -47, -44, -41, -40, -36, -32, -28, -24, -22, -19, -14,
-10, -5, 0, 6, 10, 16, 21, 26, 32, 37, 42, 45, 49, 54, 58, 61, 64, 69, 70, 72,
71, 72, 71, 71, 69, 68, 66, 63, 60, 54, 49, 44, 38, 35, 28, 23, 16, 10, 5, -2,
-6, -10, -15, -18, -23, -27, -30, -31, -32, -33, -32, -32, -30, -29, -26, -23,
-18, -14, -9, -4, 2, 7, 13, 17, 23, 29, 34, 39, 42, 45, 47, 49, 52, 52, 56, 56,
56, 57, 54, 52, 50, 47, 45, 42, 40, 36, 33, 28, 25, 21, 18, 16, 13, 10, 8, 5, 3,
2, -1, -2, -3, -4, -5, -6, -6, -5, -6, -4, -4, -3, -2, -2, -1, 1, 2, 4, 6, 8,
10, 13, 14, 17, 18, 21, 23, 25, 28, 29, 32, 33, 35, 36, 38, 40, 42, 43, 44, 44,
43, 43, 43, 42, 41, 40, 37, 33, 29, 25, 20, 17, 11, 7, 3, -3, -9, -12, -17, -20,
-23, -25, -27, -27, -28, -26, -23, -21, -16, -13, -10, -6, -3, 1, 4, 8, 11, 15,
16, 18, 18, 17, 17, 15, 13, 11, 6, 2, -5, -11, -18, -26, -33, -41, -50, -59,
-68, -75, -83, -91, -98, -102, -107, -111, -114, -117, -119, -119, -119, -117,
-115, -112, -110, -106, -102, -97, -91, -84, -78, -72, -65, -59, -52, -46, -38,
-32, -25, -19, -14, -8, -4, 0, 5, 8, 13, 16, 18, 20, 24, 25, 26, 29, 29, 30, 31,
31, 30, 30, 29, 28, 27, 26, 24, 22, 18, 15, 11, 9, 4, 2, -1, -5, -8, -11, -14,
-16, -19, -20, -22, -23, -25, -25, -25, -24, -24, -23, -21, -19, -16, -13, -9,
-5, -1, };