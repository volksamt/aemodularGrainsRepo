#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 8, 8, 10, 11, 12, 12, 13, 12,
14, 14, 15, 14, 12, 9, 5, 4, 3, 4, 5, 8, 9, 10, 11, 13, 13, 13, 12, 12, 12, 13,
14, 14, 14, 13, 11, 10, 7, 7, 8, 10, 11, 13, 13, 13, 15, 15, 17, 20, 20, 22, 22,
23, 22, 24, 26, 26, 27, 25, 23, 21, 22, 23, 26, 29, 29, 29, 27, 27, 28, 30, 33,
35, 34, 32, 30, 30, 30, 32, 35, 35, 34, 33, 32, 33, 33, 35, 35, 35, 33, 32, 33,
34, 36, 37, 36, 34, 32, 32, 32, 34, 35, 34, 34, 32, 31, 31, 33, 34, 36, 36, 36,
34, 35, 36, 38, 39, 38, 36, 32, 31, 28, 28, 30, 29, 30, 31, 31, 28, 25, 21, 14,
8, 4, 2, 2, 7, 9, 12, 14, 16, 21, 31, 41, 43, 36, 16, -16, -48, -77, -98, -106,
-109, -112, -115, -119, -119, -111, -95, -76, -54, -37, -26, -17, -9, -4, -2,
-3, -10, -23, -35, -44, -49, -46, -41, -35, -28, -22, -16, -7, 3, 13, 23, 29,
28, 25, 17, 6, -7, -22, -38, -54, -69, -81, -88, -87, -84, -78, -71, -65, -61,
-54, -48, -40, -31, -25, -22, -21, -23, -26, -28, -31, -33, -36, -38, -37, -34,
-25, -14, -4, 7, 15, 20, 24, 28, 30, 32, 29, 24, 17, 7, -4, -14, -24, -32, -39,
-44, -46, -47, -42, -37, -30, -25, -19, -17, -14, -12, -11, -10, -11, -14, -17,
-22, -26, -30, -31, -32, -28, -23, -16, -8, 0, 9, 16, 21, 25, 26, 27, 25, 24,
22, 19, 15, 9, 3, -5, -11, -17, -18, -18, -17, -15, -12, -10, -8, -6, -3, -5,
-6, -7, -10, -11, -11, -11, -12, -13, -14, -14, -14, -13, -10, -5, 1, 7, 11, 17,
21, 22, 22, 21, 20, 18, 17, 16, 14, 12, 9, 6, 2, 0, -2, -1, -1, 2, 4, 5, 6, 5,
5, 4, 1, -1, -5, -8, -11, -10, -11, -9, -8, -9, -9, -8, -6, -2, 2, 7, 11, 13,
13, 12, 11, 10, 10, 11, 12, 12, 12, 12, 10, 9, 7, 7, 8, 9, 10, 9, 8, 6, 5, 3, 1,
0, -1, -1, -1, -3, -4, -6, -8, -11, -12, -13, -12, -9, -7, -4, -1, 0, 2, 3, 4,
6, 8, 9, 11, 12, 12, 10, 6, 3, 0, -2, -3, -2, -1, 1, 1, 1, 2, 2, 2, 2, 2, 2, 1,
1, 0, 0, -3, -5, -10, -12, -15, -15, -14, -12, -9, -7, -5, -5, -4, -3, -2, -1,
1, 2, 2, 2, 2, 0, -3, -5, -7, -6, -5, -4, -2, 1, 3, 4, 3, 1, -1, -3, -4, -3, -1,
0, 1, -2, -4, -7, -8, -9, -10, -10, -9, -8, -6, -4, -3, -1, -3, -5, -6, -7, -7,
-4, -2, 0, 1, 0, 0, 0, -2, -3, -3, -3, -2, -1, 1, 2, 3, 2, 0, -1, -1, -2, -1,
-1, 0, 2, 3, 2, 2, 1, 0, -2, -1, 0, };