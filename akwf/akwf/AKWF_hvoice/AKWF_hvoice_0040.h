#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0040

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 17, 27, 34, 39, 44, 50, 52, 49, 46,
47, 54, 62, 71, 76, 78, 74, 68, 65, 67, 72, 74, 76, 78, 84, 89, 92, 94, 92, 89,
87, 88, 92, 95, 98, 94, 89, 84, 80, 75, 69, 64, 58, 54, 50, 46, 41, 37, 30, 24,
17, 11, 3, -3, -12, -19, -23, -26, -31, -38, -46, -55, -62, -68, -73, -75, -78,
-83, -86, -91, -95, -100, -105, -109, -112, -113, -112, -112, -112, -113, -116,
-117, -120, -118, -117, -116, -113, -110, -109, -107, -107, -106, -106, -104,
-103, -99, -94, -90, -87, -85, -83, -82, -80, -78, -75, -70, -66, -62, -58, -55,
-52, -48, -45, -40, -35, -30, -26, -23, -19, -14, -9, -5, -2, 1, 3, 4, 6, 10,
14, 17, 18, 21, 24, 28, 29, 32, 37, 39, 42, 44, 49, 52, 54, 58, 60, 62, 66, 69,
74, 76, 76, 74, 72, 70, 67, 66, 67, 69, 71, 71, 72, 70, 67, 64, 62, 63, 63, 64,
66, 65, 64, 63, 60, 57, 55, 51, 50, 49, 48, 46, 42, 38, 35, 30, 26, 24, 22, 21,
19, 17, 15, 16, 15, 12, 10, 7, 6, 2, 0, -2, -2, 0, 0, -3, -6, -8, -12, -17, -19,
-20, -20, -22, -22, -24, -26, -30, -34, -36, -38, -39, -36, -33, -33, -34, -36,
-37, -40, -41, -42, -39, -36, -32, -30, -29, -28, -28, -28, -29, -26, -21, -16,
-10, -3, 2, 7, 10, 10, 10, 10, 8, 9, 11, 17, 23, 29, 30, 29, 24, 21, 22, 23, 27,
31, 35, 37, 39, 41, 44, 46, 47, 48, 50, 56, 61, 67, 71, 72, 71, 68, 65, 61, 59,
57, 58, 59, 59, 59, 55, 51, 46, 42, 40, 36, 34, 31, 32, 31, 31, 30, 26, 20, 15,
12, 11, 12, 10, 7, 3, -1, -6, -12, -17, -21, -25, -28, -31, -33, -35, -36, -42,
-43, -48, -51, -54, -56, -60, -62, -63, -64, -65, -68, -72, -76, -80, -82, -83,
-83, -83, -83, -84, -85, -86, -88, -90, -90, -91, -90, -88, -86, -85, -84, -83,
-83, -83, -81, -79, -78, -75, -71, -67, -65, -63, -62, -62, -61, -58, -54, -51,
-47, -43, -41, -37, -35, -32, -31, -27, -24, -20, -16, -12, -7, -5, -3, -1, 2,
7, 12, 17, 23, 27, 28, 28, 30, 32, 35, 37, 40, 41, 41, 41, 44, 44, 46, 47, 48,
49, 50, 52, 55, 55, 55, 57, 59, 61, 62, 63, 65, 64, 64, 65, 68, 70, 67, 64, 61,
59, 54, 52, 53, 57, 57, 55, 52, 51, 48, 46, 44, 43, 43, 44, 46, 45, 42, 40, 36,
33, 28, 25, 25, 23, 18, 15, 13, 8, 4, 0, -3, -6, -9, -10, -10, -12, -14, -14,
-13, -14, -17, -19, -21, -24, -26, -27, -25, -24, -24, -24, -26, -26, -29, -31,
-33, -34, -34, -34, -32, -32, -31, -32, -36, -39, -40, -38, -38, -39, -38, -36,
-35, -38, -38, -36, -32, -33, -35, -31, -25, -23, -23, -22, -19, -15, -7, -1, };