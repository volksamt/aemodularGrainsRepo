#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 5, 5, 4, 6, 7, 8, 10, 13, 15,
18, 20, 22, 26, 28, 33, 36, 40, 44, 49, 53, 56, 59, 60, 61, 62, 63, 64, 66, 69,
72, 75, 78, 83, 86, 91, 95, 98, 102, 102, 101, 100, 96, 93, 88, 84, 79, 76, 73,
72, 69, 68, 68, 67, 70, 72, 73, 76, 78, 82, 84, 87, 90, 94, 98, 102, 106, 111,
115, 118, 120, 119, 117, 116, 113, 108, 105, 100, 95, 90, 82, 76, 68, 61, 53,
48, 45, 42, 42, 43, 45, 48, 51, 55, 57, 59, 58, 56, 53, 49, 44, 40, 35, 33, 30,
28, 29, 29, 29, 31, 34, 36, 38, 39, 38, 36, 33, 28, 22, 16, 10, 5, 1, -2, -6,
-8, -11, -12, -13, -14, -15, -16, -17, -17, -17, -19, -20, -22, -22, -23, -23,
-22, -21, -18, -14, -11, -7, -4, 0, 1, 4, 4, 4, 3, 0, -4, -8, -13, -20, -24,
-29, -32, -36, -39, -40, -42, -44, -46, -47, -51, -54, -58, -62, -65, -69, -71,
-73, -72, -71, -67, -62, -57, -52, -46, -40, -36, -31, -29, -27, -27, -27, -28,
-28, -29, -29, -30, -33, -34, -36, -39, -43, -45, -49, -52, -54, -59, -62, -65,
-70, -74, -77, -81, -84, -86, -88, -86, -84, -80, -76, -69, -65, -60, -54, -51,
-49, -45, -43, -43, -43, -44, -47, -51, -54, -57, -60, -61, -62, -62, -63, -64,
-66, -69, -73, -77, -81, -85, -88, -91, -91, -89, -88, -84, -80, -75, -71, -66,
-64, -60, -58, -55, -55, -54, -53, -54, -53, -53, -53, -52, -49, -47, -44, -41,
-39, -35, -34, -32, -31, -30, -31, -33, -35, -36, -39, -41, -42, -44, -45, -44,
-42, -40, -37, -34, -30, -27, -23, -20, -18, -16, -14, -13, -14, -13, -14, -13,
-13, -11, -10, -6, -2, 2, 7, 11, 14, 16, 19, 20, 21, 22, 24, 25, 27, 29, 29, 30,
31, 32, 31, 32, 32, 32, 31, 32, 31, 28, 25, 22, 19, 14, 13, 11, 12, 13, 16, 19,
23, 26, 30, 34, 36, 41, 44, 46, 49, 49, 49, 47, 44, 42, 40, 37, 35, 34, 33, 32,
30, 29, 27, 25, 22, 20, 18, 16, 13, 11, 8, 6, 5, 4, 4, 4, 6, 7, 8, 10, 11, 12,
11, 11, 8, 7, 6, 5, 3, 1, 1, 0, -1, -1, -2, -3, -5, -8, -10, -13, -14, -16, -18,
-21, -22, -24, -26, -28, -31, -32, -34, -34, -36, -35, -36, -36, -35, -34, -31,
-30, -29, -27, -26, -28, -28, -29, -30, -30, -30, -31, -29, -29, -28, -29, -30,
-30, -31, -33, -35, -35, -36, -34, -33, -32, -30, -29, -29, -30, -30, -30, -30,
-31, -31, -30, -31, -31, -34, -37, -41, -44, -48, -49, -52, -52, -51, -51, -49,
-48, -47, -44, -41, -37, -33, -30, -25, -21, -19, -18, -17, -17, -17, -17, -16,
-15, -14, -13, -12, -14, -15, -19, -21, -23, -24, -23, -22, -19, -16, -13, -10,
-9, -7, -6, -5, -3, -2, -1, };