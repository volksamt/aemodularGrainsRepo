#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0093

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 8, 9, 9, 9, 9, 8, 8, 9,
12, 14, 15, 18, 22, 25, 27, 28, 29, 29, 28, 27, 27, 27, 26, 26, 26, 26, 24, 26,
25, 26, 26, 26, 27, 26, 26, 26, 25, 24, 24, 23, 23, 23, 21, 22, 22, 22, 23, 23,
21, 20, 19, 17, 14, 11, 10, 8, 7, 7, 8, 9, 11, 12, 13, 14, 14, 13, 13, 12, 12,
11, 11, 12, 12, 12, 13, 13, 15, 15, 15, 15, 16, 18, 18, 17, 19, 21, 23, 25, 28,
32, 34, 36, 39, 41, 43, 43, 44, 45, 44, 43, 44, 45, 45, 46, 48, 51, 53, 55, 58,
61, 62, 63, 63, 62, 62, 61, 61, 60, 61, 61, 62, 62, 64, 65, 65, 64, 64, 63, 60,
58, 56, 53, 51, 49, 48, 48, 49, 48, 48, 49, 49, 46, 44, 40, 36, 30, 24, 19, 18,
14, 12, 13, 18, 21, 20, 23, 26, 23, 10, -4, -16, -32, -55, -76, -82, -84, -89,
-88, -79, -66, -58, -57, -55, -54, -57, -69, -79, -87, -95, -104, -113, -115,
-116, -118, -118, -114, -111, -110, -109, -107, -107, -109, -112, -116, -115,
-111, -109, -104, -96, -84, -75, -69, -61, -53, -52, -55, -58, -59, -62, -67,
-71, -68, -62, -58, -52, -39, -26, -18, -10, -1, 7, 9, 8, 11, 12, 13, 12, 14,
16, 20, 22, 24, 29, 32, 34, 34, 34, 33, 31, 28, 25, 26, 27, 27, 29, 33, 39, 42,
44, 45, 47, 43, 37, 32, 27, 18, 8, 1, -1, -5, -8, -10, -8, -8, -7, -7, -7, -7,
-9, -12, -14, -18, -22, -26, -30, -32, -36, -39, -41, -44, -46, -47, -49, -50,
-51, -52, -54, -54, -54, -53, -52, -49, -46, -42, -39, -35, -32, -28, -28, -29,
-28, -27, -31, -33, -34, -33, -33, -32, -27, -21, -16, -10, -4, 2, 7, 10, 13,
15, 18, 19, 19, 20, 22, 22, 24, 26, 27, 28, 31, 32, 34, 36, 37, 40, 41, 42, 42,
42, 43, 42, 43, 43, 46, 48, 47, 47, 46, 45, 42, 37, 32, 28, 26, 22, 18, 17, 16,
16, 15, 16, 16, 14, 13, 14, 13, 9, 5, 3, -1, -6, -9, -12, -14, -17, -19, -19,
-20, -21, -22, -24, -25, -26, -27, -29, -30, -30, -30, -31, -30, -29, -28, -27,
-25, -23, -22, -23, -22, -22, -23, -23, -25, -24, -23, -21, -21, -17, -14, -12,
-10, -8, -6, -3, -1, 1, 2, 3, 3, 3, 4, 5, 4, 5, 7, 8, 9, 12, 14, 15, 17, 18, 20,
20, 21, 19, 20, 20, 20, 19, 19, 19, 19, 18, 18, 18, 17, 16, 15, 15, 13, 10, 9,
7, 6, 6, 4, 5, 5, 5, 5, 4, 3, 1, -1, -5, -8, -9, -10, -13, -14, -14, -14, -15,
-16, -16, -17, -19, -20, -20, -20, -21, -22, -21, -21, -22, -22, -22, -21, -22,
-21, -21, -20, -19, -19, -18, -19, -18, -18, -18, -18, -17, -15, -14, -12, -8,
-7, -5, -3, 0, };