#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 10, 14, 18, 23, 28, 32, 37, 41,
46, 49, 53, 58, 61, 65, 69, 73, 77, 80, 85, 87, 91, 94, 98, 101, 104, 107, 108,
111, 112, 113, 116, 117, 117, 119, 119, 118, 119, 119, 118, 118, 117, 116, 115,
114, 112, 111, 109, 108, 105, 103, 101, 98, 96, 93, 91, 88, 85, 81, 78, 75, 72,
69, 65, 62, 58, 54, 51, 46, 43, 39, 34, 30, 27, 22, 17, 13, 8, 3, -1, -5, -10,
-14, -18, -22, -26, -31, -34, -39, -42, -45, -48, -51, -54, -57, -58, -60, -62,
-64, -64, -65, -66, -66, -66, -67, -66, -66, -66, -65, -64, -64, -63, -62, -61,
-61, -60, -60, -59, -58, -58, -57, -57, -56, -56, -55, -55, -54, -54, -52, -53,
-52, -51, -51, -49, -48, -48, -47, -46, -44, -43, -42, -41, -39, -38, -36, -35,
-33, -31, -29, -28, -26, -25, -24, -21, -20, -18, -17, -16, -15, -13, -12, -12,
-10, -10, -10, -9, -9, -9, -9, -8, -8, -9, -10, -9, -10, -11, -11, -12, -12,
-11, -12, -12, -12, -13, -12, -13, -12, -13, -12, -11, -11, -11, -9, -10, -8,
-7, -6, -5, -4, -3, -2, -1, 1, 2, 3, 4, 5, 6, 8, 8, 9, 9, 10, 11, 11, 12, 12,
13, 13, 13, 14, 14, 15, 16, 15, 14, 15, 16, 17, 16, 16, 16, 17, 17, 18, 19, 19,
19, 20, 19, 20, 21, 20, 21, 20, 20, 20, 19, 20, 18, 18, 18, 16, 16, 15, 13, 12,
11, 9, 9, 7, 5, 4, 1, 0, -1, -4, -5, -7, -9, -11, -13, -15, -17, -19, -20, -22,
-24, -27, -28, -30, -31, -34, -35, -37, -39, -41, -42, -44, -46, -48, -49, -50,
-52, -53, -55, -55, -56, -58, -58, -60, -59, -61, -62, -61, -61, -62, -62, -62,
-62, -62, -61, -61, -60, -59, -58, -58, -57, -56, -55, -53, -53, -52, -51, -50,
-48, -46, -45, -43, -42, -40, -39, -37, -34, -32, -30, -27, -25, -24, -22, -18,
-16, -13, -12, -9, -7, -5, -3, -1, 1, 3, 4, 6, 7, 8, 11, 12, 12, 15, 16, 17, 19,
20, 21, 22, 25, 26, 28, 29, 31, 34, 36, 38, 40, 42, 44, 45, 48, 50, 52, 54, 55,
57, 59, 61, 62, 63, 64, 64, 66, 66, 66, 66, 66, 66, 65, 65, 64, 63, 63, 61, 60,
59, 57, 56, 55, 54, 52, 51, 51, 50, 49, 48, 47, 48, 46, 45, 45, 45, 44, 44, 43,
41, 41, 40, 39, 37, 36, 35, 33, 32, 29, 28, 25, 23, 21, 17, 14, 11, 8, 5, 2, -1,
-5, -8, -12, -15, -18, -21, -24, -28, -29, -32, -34, -37, -39, -40, -43, -45,
-47, -49, -49, -51, -53, -54, -54, -56, -57, -58, -60, -60, -61, -63, -64, -65,
-66, -67, -68, -69, -69, -70, -71, -71, -71, -72, -71, -70, -70, -69, -68, -67,
-65, -64, -62, -60, -58, -55, -51, -48, -46, -42, -39, -35, -32, -27, -23, -19,
-15, -11, -6, -1, };