#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0053

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 12, 14, 5, 0, 5, 11, 12, 5, 1, 3,
9, 11, 11, 8, 9, 13, 16, 15, 10, 10, 15, 19, 18, 13, 11, 18, 21, 21, 14, 12, 20,
27, 25, 17, 14, 21, 30, 34, 26, 19, 19, 31, 40, 37, 25, 21, 33, 47, 45, 33, 24,
37, 51, 53, 39, 26, 41, 59, 60, 45, 34, 46, 64, 65, 50, 37, 50, 70, 75, 59, 45,
53, 71, 82, 73, 57, 57, 70, 85, 82, 70, 65, 72, 88, 89, 82, 73, 76, 89, 91, 85,
78, 81, 91, 92, 85, 79, 86, 97, 97, 89, 81, 88, 101, 102, 91, 81, 87, 101, 103,
94, 86, 94, 108, 108, 93, 79, 83, 97, 101, 93, 80, 81, 91, 92, 88, 90, 107, 120,
108, 79, 57, 57, 65, 64, 46, 20, 8, 10, 18, 15, 6, -4, -2, 5, 12, 8, -1, -7, -3,
9, 14, 7, -2, -1, 8, 15, 10, 2, -1, 5, 5, -2, -9, -8, -3, -5, -19, -26, -21,
-12, -14, -32, -39, -34, -21, -22, -40, -49, -42, -26, -26, -44, -57, -53, -32,
-26, -42, -61, -62, -41, -31, -41, -59, -64, -48, -37, -42, -56, -62, -52, -44,
-46, -52, -56, -49, -48, -52, -54, -51, -47, -51, -61, -59, -50, -40, -48, -63,
-65, -53, -39, -44, -61, -67, -58, -41, -42, -57, -68, -59, -42, -40, -53, -69,
-63, -43, -37, -50, -69, -66, -44, -37, -49, -67, -64, -47, -40, -49, -64, -60,
-45, -41, -48, -61, -57, -45, -41, -45, -53, -51, -44, -38, -42, -47, -47, -43,
-39, -40, -43, -44, -43, -41, -40, -39, -39, -39, -40, -39, -37, -36, -35, -38,
-41, -38, -31, -29, -36, -40, -37, -27, -23, -30, -36, -35, -27, -22, -26, -31,
-32, -26, -21, -21, -24, -26, -25, -23, -22, -22, -23, -24, -25, -21, -18, -17,
-23, -25, -19, -14, -13, -19, -21, -19, -14, -10, -12, -15, -18, -15, -9, -6,
-12, -19, -16, -9, -4, -9, -18, -18, -10, -4, -6, -11, -16, -13, -7, -4, -7,
-11, -10, -7, -6, -7, -7, -7, -6, -10, -10, -4, 0, -3, -10, -14, -4, 4, 3, -9,
-14, -4, 5, 5, -7, -13, -5, 3, 4, -6, -11, -7, 0, 1, -4, -9, -8, -3, -1, -4, -6,
-4, -5, -6, -5, -2, 1, -5, -11, -8, 1, 5, -6, -15, -10, 1, 5, -3, -13, -13, -5,
1, -3, -8, -7, -5, -6, -7, -7, -4, -3, -4, -9, -11, -11, -5, -2, -5, -9, -13,
-9, -4, -4, -8, -14, -12, -5, -3, -7, -13, -12, -8, -6, -6, -7, -11, -12, -13,
-10, -7, -7, -10, -14, -14, -10, -7, -6, -10, -14, -14, -9, -3, -4, -12, -18,
-12, -3, 0, -10, -19, -15, -5, 2, -8, -16, -13, -4, 0, -9, -15, -8, -1, 0, -9,
-13, -6, -2, -3, -10, -9, -2, 2, -4, -11, -10, 2, 7, -1, -12, -9, 5, 11, 2, -12,
-11, 4, 13, 7, -7, -9, 3, 12, 10, -2, -3, };