#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0083

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 9, 10, 13, 15, 17, 21, 23,
26, 28, 31, 33, 35, 38, 41, 43, 46, 48, 51, 53, 56, 58, 59, 62, 65, 67, 69, 70,
72, 75, 75, 78, 80, 82, 83, 85, 87, 87, 90, 90, 93, 94, 96, 97, 98, 99, 101,
102, 103, 104, 106, 106, 107, 109, 109, 110, 111, 112, 113, 113, 113, 113, 115,
115, 115, 115, 115, 115, 115, 115, 115, 115, 115, 115, 114, 114, 114, 113, 113,
114, 113, 112, 112, 112, 113, 112, 112, 112, 111, 111, 111, 110, 111, 111, 111,
110, 110, 110, 110, 110, 109, 109, 109, 108, 108, 108, 108, 107, 107, 107, 106,
107, 107, 106, 106, 106, 105, 105, 106, 105, 106, 106, 105, 104, 104, 105, 104,
104, 104, 105, 103, 104, 104, 103, 103, 104, 103, 103, 103, 103, 102, 102, 101,
101, 100, 100, 99, 99, 99, 99, 98, 98, 97, 96, 95, 96, 95, 94, 94, 94, 92, 93,
93, 92, 91, 91, 91, 90, 90, 90, 89, 88, 88, 87, 87, 86, 86, 85, 84, 85, 83, 84,
83, 82, 83, 81, 82, 81, 80, 80, 81, 80, 79, 80, 79, 79, 79, 79, 78, 79, 79, 78,
79, 79, 79, 79, 80, 79, 79, 79, 79, 79, 78, 78, 77, 77, 76, 74, 74, 73, 71, 70,
68, 67, 65, 64, 62, 61, 59, 58, 55, 54, 51, 50, 47, 45, 43, 41, 39, 37, 34, 32,
30, 28, 25, 23, 20, 19, 15, 14, 10, 8, 6, 4, 1, -1, -4, -6, -9, -11, -14, -17,
-19, -22, -25, -27, -30, -33, -36, -38, -40, -44, -45, -48, -50, -52, -55, -58,
-59, -61, -63, -66, -68, -69, -72, -73, -75, -76, -78, -80, -83, -85, -86, -88,
-90, -91, -94, -95, -96, -98, -99, -101, -103, -104, -105, -107, -108, -108,
-111, -112, -113, -114, -115, -116, -117, -118, -118, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -118, -119, -117, -117, -117, -117, -117,
-116, -116, -115, -115, -115, -115, -114, -113, -112, -113, -112, -112, -111,
-111, -111, -110, -110, -110, -110, -108, -108, -108, -108, -108, -107, -106,
-106, -106, -106, -106, -105, -105, -105, -104, -104, -104, -103, -103, -103,
-103, -102, -102, -102, -102, -101, -102, -102, -101, -101, -101, -101, -100,
-101, -100, -100, -100, -100, -99, -99, -99, -99, -98, -98, -99, -97, -97, -97,
-97, -97, -96, -95, -95, -95, -95, -95, -94, -94, -94, -93, -93, -93, -93, -93,
-93, -92, -92, -91, -91, -91, -91, -90, -90, -90, -90, -89, -89, -89, -89, -88,
-87, -87, -87, -86, -86, -85, -85, -84, -83, -83, -83, -83, -83, -83, -82, -82,
-82, -82, -82, -83, -83, -82, -84, -84, -84, -84, -84, -84, -84, -84, -84, -84,
-84, -84, -83, -83, -82, -82, -81, -81, -79, -78, -76, -75, -74, -72, -70, -70,
-67, -65, -62, -61, -59, -55, -54, -51, -48, -46, -44, -41, -38, -36, -34, -32,
-30, -27, -25, -22, -21, -17, -15, -13, -10, -8, -6, -2, -1, };