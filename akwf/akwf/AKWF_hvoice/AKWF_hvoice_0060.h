#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0060

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 32, 52, 73, 89, 101, 103, 100, 86,
68, 39, 8, -25, -57, -84, -104, -116, -118, -112, -99, -80, -58, -36, -17, 0,
10, 15, 14, 11, 6, 0, -4, -4, -1, 7, 19, 32, 47, 61, 72, 78, 80, 75, 65, 48, 29,
7, -12, -29, -44, -53, -59, -59, -57, -50, -41, -33, -25, -21, -19, -17, -17,
-19, -20, -20, -21, -18, -13, -4, 7, 17, 27, 38, 46, 51, 53, 52, 47, 39, 29, 18,
8, -2, -10, -16, -21, -21, -21, -19, -18, -18, -17, -17, -18, -21, -22, -26,
-27, -27, -26, -22, -19, -11, -4, 5, 12, 19, 25, 28, 30, 30, 28, 27, 24, 18, 14,
9, 5, 3, 1, 0, -1, -2, -3, -5, -7, -9, -11, -12, -15, -17, -20, -21, -21, -20,
-17, -14, -10, -6, -2, 2, 6, 10, 13, 15, 15, 15, 13, 12, 11, 11, 11, 9, 8, 6, 5,
6, 5, 3, 2, 0, -3, -6, -10, -11, -14, -14, -15, -15, -15, -14, -12, -9, -7, -5,
-2, -1, 0, 2, 3, 4, 6, 7, 8, 9, 9, 9, 10, 11, 11, 10, 9, 6, 4, 2, 1, -1, -3, -5,
-7, -8, -8, -8, -9, -8, -7, -7, -7, -7, -6, -7, -6, -5, -4, -2, -1, 1, 3, 6, 8,
9, 9, 8, 9, 7, 6, 5, 3, 2, 1, 0, -2, -2, -1, -1, -2, -2, -3, -4, -5, -4, -4, -5,
-5, -5, -5, -5, -5, -4, -3, -1, 0, 1, 2, 3, 1, 2, 3, 4, 4, 3, 3, 1, 1, 1, 1, 1,
0, 1, 0, 0, -1, -1, -1, -1, -2, -3, -3, -3, -3, -3, -3, -1, -2, 0, 0, 1, 1, 1,
1, 1, 1, 2, 0, 0, -1, 0, 0, 1, 0, 2, 2, 2, 2, 2, 2, 2, 2, 0, -2, -2, -3, -4, -3,
-3, -3, -3, -2, -2, 0, 0, 2, 1, 2, 2, 1, 1, 0, 0, 1, 2, 1, 1, 0, 1, 2, 3, 4, 2,
2, 2, 1, 0, -1, -2, -2, -2, -3, -4, -3, -3, -1, 0, 0, 1, -1, -1, -1, -1, 0, 0,
1, 0, -1, -1, -1, 0, 2, 2, 2, 2, 1, 0, 2, 2, 3, 2, 1, 1, 1, 0, -1, -1, -1, -1,
-2, -1, -2, -3, -1, 0, 2, 1, 1, 0, 0, 0, 0, 0, 1, 1, 1, 1, 2, 1, 1, 1, 2, 1, 0,
0, -1, -1, -2, -2, -3, -2, -2, 0, 0, 0, 0, 0, 1, 2, 2, 0, -1, -1, -1, 0, -1, -1,
0, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 0, -1, -1, -1, 0, 1, 2, 1, 2, 3, 4, 4, 4, 4, 4,
2, 1, 0, -1, 0, 0, 0, 1, 2, 4, 4, 4, 4, 4, 5, 4, 3, 0, -1, -1, -1, 0, 0, 1, 2,
1, 1, 2, 3, 2, 1, 0, -1, -1, -2, -2, -1, 1, 4, 6, 6, 7, 5, 3, 1, -4, -9, -14,
-19, -22, -20, -15, -3, };