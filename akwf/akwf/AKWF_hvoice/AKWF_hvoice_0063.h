#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0063

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 36, 62, 85, 104, 116, 120, 117,
107, 91, 68, 42, 15, -8, -27, -35, -37, -33, -29, -24, -21, -17, -16, -20, -29,
-41, -57, -72, -84, -89, -89, -84, -73, -63, -51, -40, -26, -15, -6, -1, -3, -6,
-9, -9, -7, -1, 5, 13, 21, 31, 42, 52, 58, 60, 59, 54, 46, 38, 32, 27, 23, 19,
18, 17, 17, 18, 18, 16, 11, 6, -4, -12, -22, -30, -36, -43, -46, -48, -46, -41,
-37, -33, -31, -29, -27, -27, -29, -30, -30, -29, -27, -24, -22, -14, -7, 2, 7,
13, 17, 20, 22, 23, 21, 21, 21, 21, 21, 21, 23, 25, 27, 28, 27, 26, 24, 22, 18,
14, 9, 5, 2, -2, -5, -6, -8, -8, -9, -10, -12, -14, -16, -19, -19, -19, -20,
-22, -23, -24, -22, -20, -15, -13, -11, -9, -9, -6, -5, -3, -3, -3, -3, -2, 2,
4, 6, 8, 9, 10, 11, 12, 12, 13, 11, 10, 9, 10, 10, 9, 9, 8, 9, 7, 5, 4, 3, 3, 1,
-2, -3, -6, -7, -8, -9, -8, -7, -8, -10, -11, -11, -11, -9, -10, -13, -15, -15,
-14, -11, -9, -8, -6, -4, -3, 0, 1, 2, 3, 2, 0, 1, 1, 1, 2, 2, 3, 5, 9, 11, 13,
13, 12, 11, 8, 5, 3, 0, -1, -2, -2, -1, -1, 1, 2, 2, 1, -1, -3, -5, -5, -7, -8,
-11, -11, -13, -12, -10, -8, -7, -5, -4, -3, -3, -3, -3, -2, -2, -3, -4, -5, -3,
0, 3, 4, 4, 3, 3, 4, 4, 5, 5, 5, 3, 4, 3, 3, 3, 3, 1, 0, 0, 0, 0, -1, -2, -2,
-4, -4, -5, -5, -5, -6, -5, -4, -4, -4, -5, -2, -2, -2, -2, -3, -3, -4, -2, -2,
0, 0, 1, 4, 4, 5, 6, 6, 6, 6, 6, 5, 5, 4, 4, 2, 3, 3, 3, 4, 4, 4, 3, 3, 3, 2, 1,
-1, -1, -2, -2, -2, -4, -4, -3, -2, -3, -3, -3, -2, -1, -1, -1, -3, -3, -4, -2,
0, -1, 0, -1, -1, 1, 2, 2, 1, 1, 0, -1, 1, 1, 0, -1, -1, 0, 1, 3, 4, 4, 4, 4, 3,
3, 3, 3, 2, 1, 1, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 1,
0, 0, -1, -2, -2, -2, -1, -1, -1, -1, -5, -4, -4, -2, -2, -2, -2, -3, -1, 0, 2,
2, 1, 0, -2, -4, -2, -2, 1, 0, 0, 1, 1, 4, 4, 6, 4, 3, 3, 0, 0, -1, -1, 1, 2, 0,
1, 1, 2, 4, 4, 5, 3, 2, 1, 0, 0, 0, 2, 4, 4, 4, 3, 5, 6, 8, 7, 7, 5, 4, 5, 5, 6,
5, 6, 6, 7, 7, 7, 7, 7, 7, 7, 5, 4, 2, 2, 1, 2, 1, 1, 2, 3, 3, 4, 8, 9, 9, 7, 4,
-2, -7, -15, -23, -29, -32, -30, -26, -16, -3, };