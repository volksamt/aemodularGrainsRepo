#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0046

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 11, 12, 16, 20, 20, 20, 24, 33, 40,
45, 50, 59, 68, 73, 74, 71, 70, 68, 69, 75, 84, 91, 90, 83, 76, 71, 71, 72, 76,
79, 79, 79, 80, 80, 81, 79, 76, 74, 77, 81, 83, 83, 78, 72, 64, 58, 56, 53, 50,
43, 36, 30, 23, 17, 8, -1, -6, -11, -16, -22, -29, -37, -45, -53, -58, -62, -67,
-73, -81, -88, -92, -97, -99, -102, -106, -109, -112, -115, -115, -117, -119,
-119, -118, -117, -115, -115, -116, -117, -117, -117, -115, -112, -110, -108,
-106, -106, -105, -104, -103, -102, -100, -98, -95, -93, -88, -86, -83, -81,
-78, -75, -71, -66, -61, -56, -51, -48, -43, -38, -34, -31, -25, -20, -13, -6,
1, 5, 9, 11, 15, 18, 23, 29, 36, 40, 43, 44, 45, 46, 47, 52, 54, 59, 61, 64, 66,
65, 65, 64, 66, 69, 71, 75, 78, 79, 80, 80, 81, 82, 86, 87, 89, 89, 88, 87, 83,
82, 80, 79, 77, 77, 74, 70, 64, 60, 57, 53, 51, 48, 46, 43, 40, 38, 34, 32, 30,
29, 28, 26, 23, 19, 17, 15, 12, 12, 11, 9, 7, 4, 0, -3, -5, -7, -9, -10, -13,
-14, -17, -19, -21, -24, -27, -28, -31, -32, -33, -34, -36, -37, -38, -41, -42,
-42, -43, -44, -43, -44, -45, -47, -47, -48, -48, -46, -46, -45, -46, -44, -41,
-40, -37, -37, -35, -35, -33, -31, -28, -25, -21, -21, -20, -18, -16, -11, -8,
-3, 0, 3, 7, 11, 14, 19, 25, 31, 36, 41, 47, 54, 59, 63, 66, 69, 71, 74, 78, 81,
84, 83, 80, 77, 76, 78, 80, 81, 79, 76, 73, 71, 71, 73, 74, 72, 71, 71, 71, 71,
71, 68, 65, 63, 62, 62, 61, 57, 51, 44, 40, 36, 32, 29, 22, 16, 11, 6, 0, -6,
-13, -19, -25, -30, -34, -39, -46, -53, -61, -66, -70, -73, -79, -82, -87, -91,
-95, -97, -99, -102, -105, -108, -109, -110, -110, -112, -111, -111, -111, -110,
-111, -109, -109, -109, -108, -107, -105, -105, -103, -102, -101, -100, -98,
-96, -94, -91, -89, -86, -83, -81, -76, -72, -68, -64, -58, -54, -49, -44, -40,
-36, -31, -26, -20, -16, -10, -7, -3, 2, 8, 13, 18, 23, 26, 29, 32, 36, 40, 44,
48, 51, 52, 52, 52, 55, 55, 58, 59, 60, 62, 64, 65, 64, 63, 64, 64, 66, 68, 70,
71, 71, 71, 71, 71, 73, 75, 77, 78, 77, 74, 72, 69, 66, 63, 62, 62, 61, 59, 57,
53, 50, 45, 44, 44, 42, 39, 38, 37, 34, 30, 28, 26, 24, 22, 20, 19, 15, 10, 7,
5, 1, -3, -6, -9, -13, -15, -19, -20, -22, -26, -26, -29, -31, -33, -34, -37,
-37, -38, -38, -39, -42, -43, -42, -43, -44, -42, -43, -41, -41, -39, -36, -35,
-36, -35, -36, -37, -36, -33, -28, -26, -24, -24, -22, -20, -21, -21, -20, -18,
-16, -14, -11, -9, -5, -5, -6, -7, -5, -1, };