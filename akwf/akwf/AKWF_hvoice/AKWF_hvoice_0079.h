#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0079

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 8, 14, 19, 22, 24, 24, 23, 22, 20,
18, 17, 15, 15, 15, 18, 22, 25, 32, 38, 42, 45, 48, 49, 49, 48, 48, 47, 45, 43,
43, 42, 44, 48, 52, 55, 59, 63, 65, 67, 68, 68, 67, 66, 66, 64, 63, 62, 63, 64,
65, 69, 72, 75, 78, 80, 81, 82, 83, 81, 81, 79, 78, 76, 74, 74, 75, 75, 77, 79,
82, 83, 86, 88, 89, 90, 91, 90, 88, 86, 83, 82, 81, 79, 79, 79, 79, 80, 82, 85,
86, 88, 90, 90, 90, 89, 87, 84, 82, 79, 77, 76, 74, 73, 73, 74, 76, 77, 79, 81,
83, 83, 83, 81, 79, 77, 74, 71, 70, 66, 64, 63, 62, 63, 64, 66, 67, 69, 70, 70,
70, 70, 70, 69, 65, 63, 58, 56, 52, 51, 48, 47, 48, 47, 48, 50, 51, 51, 53, 52,
51, 50, 48, 45, 43, 40, 38, 36, 35, 34, 35, 34, 34, 34, 34, 35, 33, 32, 31, 29,
28, 25, 25, 23, 24, 23, 23, 23, 23, 23, 22, 21, 21, 19, 18, 16, 14, 12, 11, 12,
11, 12, 13, 15, 15, 16, 18, 17, 16, 17, 15, 13, 10, 8, 6, 4, 2, 2, 3, 4, 5, 8,
10, 13, 14, 16, 17, 18, 18, 16, 15, 13, 11, 11, 10, 10, 10, 11, 12, 14, 16, 19,
20, 22, 23, 24, 23, 22, 21, 22, 22, 23, 24, 27, 30, 32, 34, 35, 36, 37, 38, 38,
37, 38, 38, 38, 39, 41, 44, 48, 52, 54, 55, 54, 50, 47, 41, 37, 35, 34, 35, 36,
40, 43, 47, 54, 58, 63, 65, 64, 59, 52, 43, 34, 27, 22, 20, 21, 25, 28, 33, 39,
43, 47, 49, 51, 48, 42, 34, 23, 15, 8, 4, 2, 4, 7, 10, 13, 16, 19, 19, 19, 17,
14, 9, 1, -6, -12, -17, -17, -17, -15, -12, -9, -7, -8, -9, -12, -16, -21, -27,
-33, -39, -46, -49, -52, -50, -47, -42, -37, -33, -31, -31, -35, -38, -46, -53,
-60, -66, -75, -81, -85, -86, -86, -82, -76, -70, -65, -61, -61, -62, -65, -68,
-74, -80, -87, -93, -99, -104, -106, -107, -104, -101, -98, -94, -91, -90, -89,
-91, -92, -95, -98, -102, -105, -110, -112, -113, -113, -113, -110, -109, -106,
-105, -104, -104, -107, -107, -110, -111, -113, -115, -116, -116, -116, -115,
-113, -111, -108, -104, -103, -104, -104, -105, -107, -109, -112, -115, -116,
-119, -119, -119, -116, -112, -108, -104, -100, -96, -94, -92, -90, -90, -91,
-94, -98, -102, -104, -107, -108, -107, -105, -103, -99, -95, -92, -87, -83,
-81, -78, -77, -79, -79, -81, -81, -83, -84, -84, -83, -83, -82, -80, -78, -76,
-75, -72, -69, -67, -65, -63, -61, -59, -58, -56, -56, -55, -55, -53, -53, -53,
-52, -50, -50, -50, -47, -46, -45, -43, -42, -39, -37, -36, -34, -32, -31, -29,
-27, -24, -22, -19, -19, -17, -16, -16, -15, -14, -14, -13, -13, -13, -12, -11,
-9, -4, };