#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0074

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 7, 7, 9, 11, 12, 12, 13,
15, 14, 16, 17, 19, 19, 20, 22, 23, 23, 25, 26, 27, 27, 28, 28, 29, 30, 30, 31,
32, 33, 34, 35, 35, 36, 37, 37, 38, 38, 39, 39, 39, 38, 39, 39, 38, 39, 38, 38,
38, 38, 38, 37, 37, 37, 37, 36, 37, 36, 36, 36, 37, 36, 36, 36, 36, 37, 37, 37,
37, 37, 37, 35, 35, 35, 34, 33, 32, 33, 32, 32, 32, 32, 31, 30, 29, 28, 28, 27,
26, 25, 25, 25, 27, 27, 26, 26, 27, 27, 26, 27, 26, 26, 26, 26, 26, 26, 26, 26,
27, 27, 26, 27, 27, 26, 27, 27, 27, 28, 29, 29, 29, 30, 31, 31, 32, 33, 34, 34,
35, 36, 37, 39, 39, 40, 40, 42, 43, 43, 44, 44, 45, 46, 47, 48, 48, 48, 50, 50,
50, 51, 52, 53, 54, 54, 56, 57, 58, 58, 59, 60, 59, 60, 60, 60, 60, 60, 61, 61,
61, 62, 61, 62, 61, 61, 60, 60, 60, 59, 59, 57, 56, 54, 50, 46, 42, 37, 32, 27,
21, 17, 11, 6, 1, -4, -10, -15, -21, -27, -32, -37, -42, -46, -49, -53, -56,
-60, -63, -66, -69, -72, -75, -78, -81, -85, -87, -91, -94, -96, -99, -102,
-105, -108, -110, -112, -114, -116, -117, -118, -118, -119, -119, -119, -118,
-118, -117, -115, -114, -112, -109, -107, -105, -103, -100, -97, -94, -91, -89,
-87, -83, -81, -77, -76, -72, -70, -67, -64, -61, -59, -56, -52, -50, -47, -43,
-41, -37, -34, -31, -26, -23, -19, -15, -13, -8, -6, -3, 0, 2, 5, 7, 9, 11, 12,
14, 15, 16, 16, 18, 18, 18, 18, 18, 18, 18, 18, 18, 17, 17, 17, 17, 16, 15, 15,
15, 15, 14, 14, 12, 12, 9, 9, 7, 5, 3, 1, -1, -2, -5, -7, -10, -11, -12, -15,
-16, -19, -21, -22, -24, -25, -27, -27, -29, -30, -31, -31, -32, -33, -35, -35,
-35, -36, -37, -38, -38, -39, -39, -39, -40, -40, -41, -41, -41, -40, -40, -40,
-40, -38, -39, -38, -37, -36, -35, -35, -34, -33, -32, -31, -31, -29, -27, -25,
-24, -22, -19, -19, -17, -15, -14, -12, -11, -10, -7, -6, -4, -3, -2, 0, 0, 2,
2, 4, 5, 7, 8, 10, 11, 12, 14, 14, 15, 16, 17, 18, 19, 20, 21, 23, 23, 25, 25,
26, 26, 27, 26, 27, 27, 28, 28, 28, 28, 28, 28, 27, 28, 26, 26, 25, 24, 23, 23,
22, 21, 21, 21, 20, 20, 18, 18, 17, 16, 15, 14, 12, 10, 9, 9, 7, 7, 5, 4, 4, 2,
1, -1, -3, -4, -5, -8, -9, -11, -12, -13, -15, -16, -16, -17, -18, -18, -19,
-20, -19, -19, -21, -21, -22, -21, -21, -22, -22, -22, -21, -22, -22, -21, -21,
-21, -20, -19, -18, -18, -19, -17, -17, -18, -17, -17, -15, -14, -13, -12, -11,
-10, -8, -8, -6, -5, -3, -2, -1, -1, };