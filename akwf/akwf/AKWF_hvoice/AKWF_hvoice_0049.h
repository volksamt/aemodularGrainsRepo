#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0049

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 16, 27, 43, 64, 84, 96, 98, 103,
109, 110, 102, 86, 70, 59, 48, 31, 12, -5, -15, -23, -30, -39, -46, -52, -55,
-60, -63, -70, -77, -84, -91, -96, -102, -109, -117, -119, -116, -111, -107,
-103, -89, -69, -50, -34, -21, 0, 24, 43, 54, 60, 69, 78, 83, 78, 73, 69, 65,
61, 56, 50, 45, 42, 42, 40, 40, 37, 33, 32, 29, 25, 17, 5, -6, -13, -20, -30,
-42, -50, -52, -50, -49, -49, -46, -35, -23, -11, -3, 5, 17, 28, 35, 37, 37, 36,
38, 35, 29, 20, 14, 10, 7, 2, -2, -5, -6, -7, -6, -7, -10, -15, -18, -21, -27,
-33, -44, -52, -58, -62, -68, -74, -76, -72, -64, -58, -53, -44, -31, -14, -2,
7, 17, 29, 40, 47, 49, 50, 51, 54, 54, 52, 50, 48, 46, 48, 48, 48, 47, 47, 47,
46, 44, 38, 31, 24, 18, 9, -3, -16, -26, -32, -38, -46, -54, -56, -54, -50, -48,
-46, -41, -31, -24, -18, -15, -11, -5, 0, 2, 2, 1, 1, 2, 3, 2, 3, 3, 5, 7, 10,
12, 13, 13, 14, 15, 13, 9, 3, -1, -5, -11, -19, -28, -32, -34, -35, -38, -40,
-37, -32, -26, -21, -17, -9, -2, 6, 10, 14, 18, 22, 26, 27, 28, 27, 29, 29, 30,
32, 32, 32, 34, 36, 38, 38, 38, 36, 34, 32, 26, 18, 9, 3, -4, -12, -22, -31,
-36, -38, -42, -47, -49, -47, -44, -41, -39, -36, -31, -26, -22, -19, -16, -15,
-12, -10, -9, -7, -6, -5, -2, 3, 7, 11, 14, 19, 24, 27, 30, 28, 27, 28, 27, 22,
16, 9, 4, 2, -3, -10, -14, -16, -16, -16, -17, -17, -14, -10, -7, -5, -3, 0, 3,
5, 6, 6, 7, 8, 8, 9, 10, 11, 12, 14, 17, 21, 22, 23, 25, 27, 29, 26, 23, 20, 18,
14, 7, 0, -8, -12, -16, -23, -29, -32, -33, -34, -34, -34, -33, -29, -27, -25,
-23, -20, -18, -16, -13, -12, -10, -9, -7, -5, -2, 2, 5, 8, 12, 18, 21, 24, 26,
29, 32, 33, 31, 29, 26, 25, 22, 16, 12, 7, 4, 1, -2, -6, -7, -7, -8, -7, -7, -6,
-7, -5, -5, -5, -6, -7, -6, -6, -7, -6, -7, -6, -5, -2, 0, 1, 4, 7, 11, 14, 15,
15, 15, 18, 16, 12, 7, 5, 3, -1, -6, -11, -14, -15, -17, -18, -20, -19, -18,
-16, -15, -14, -14, -12, -12, -10, -11, -11, -11, -10, -8, -7, -6, -5, -2, 1, 7,
10, 13, 16, 21, 26, 27, 27, 27, 27, 27, 25, 22, 19, 17, 14, 12, 8, 7, 5, 4, 3,
1, 1, 0, 0, -1, -1, -2, -2, -3, -4, -5, -6, -7, -8, -9, -8, -6, -5, -4, -1, 2,
5, 9, 10, 13, 16, 18, 19, 17, 16, 15, 13, 10, 7, 3, 0, 0, -1, -2, -4, -5, -5,
-5, -6, -7, -10, -16, -21, -22, -23, -26, -28, -28, -19, -5, };