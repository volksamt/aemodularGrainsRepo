#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 4, 5, 6, 6, 6, 5, 6, 5, 6, 5,
5, 5, 4, 5, 5, 4, 5, 6, 5, 5, 5, 6, 6, 5, 6, 6, 6, 6, 7, 6, 7, 9, 9, 11, 11, 14,
15, 17, 19, 20, 23, 24, 26, 29, 30, 33, 35, 36, 38, 39, 39, 39, 41, 40, 40, 40,
40, 39, 39, 40, 40, 41, 41, 41, 41, 43, 43, 43, 43, 44, 44, 45, 46, 46, 46, 46,
48, 48, 50, 50, 52, 54, 55, 57, 60, 61, 63, 65, 66, 67, 68, 68, 69, 69, 70, 71,
72, 73, 75, 77, 78, 80, 81, 83, 84, 85, 85, 84, 84, 82, 80, 77, 75, 72, 69, 66,
61, 58, 54, 50, 46, 40, 35, 29, 24, 17, 11, 5, -2, -8, -16, -22, -28, -34, -39,
-44, -48, -51, -53, -56, -56, -57, -56, -56, -54, -52, -51, -48, -46, -44, -43,
-41, -41, -41, -41, -42, -44, -46, -48, -50, -53, -56, -59, -63, -66, -70, -74,
-77, -82, -85, -90, -93, -97, -101, -104, -108, -110, -113, -115, -116, -117,
-119, -119, -119, -118, -117, -115, -114, -112, -110, -107, -103, -101, -97,
-94, -91, -88, -86, -83, -80, -77, -74, -72, -68, -65, -61, -59, -55, -51, -47,
-43, -38, -33, -28, -22, -17, -11, -6, -1, 4, 8, 13, 16, 20, 23, 25, 28, 29, 30,
31, 33, 33, 33, 34, 34, 34, 35, 34, 34, 34, 34, 34, 34, 33, 34, 36, 37, 38, 40,
41, 43, 46, 49, 51, 54, 58, 62, 64, 70, 73, 76, 80, 85, 88, 91, 95, 96, 97, 99,
100, 101, 100, 100, 99, 97, 97, 95, 93, 90, 88, 86, 82, 79, 75, 71, 67, 64, 60,
57, 52, 50, 46, 42, 38, 34, 31, 27, 23, 18, 15, 11, 7, 3, 1, -2, -4, -5, -5, -6,
-8, -8, -8, -8, -9, -9, -9, -9, -10, -10, -9, -10, -9, -9, -9, -9, -8, -7, -7,
-7, -7, -9, -9, -9, -11, -12, -13, -14, -16, -18, -19, -20, -22, -24, -26, -28,
-29, -32, -33, -36, -39, -42, -43, -46, -47, -49, -52, -53, -53, -55, -55, -56,
-56, -56, -56, -56, -55, -56, -54, -53, -53, -50, -50, -47, -45, -43, -41, -36,
-34, -30, -28, -24, -21, -19, -15, -12, -10, -7, -5, -2, 0, 3, 4, 5, 6, 7, 7, 6,
6, 5, 5, 3, 1, -1, -3, -5, -7, -9, -11, -12, -13, -14, -15, -16, -16, -15, -15,
-14, -15, -13, -12, -12, -10, -9, -7, -6, -5, -2, -2, -1, 0, 1, 2, 2, 2, 3, 3,
3, 3, 3, 3, 2, 3, 2, 2, 2, 1, 0, -1, -2, -3, -4, -5, -5, -7, -8, -8, -9, -10,
-11, -12, -13, -15, -16, -18, -18, -20, -20, -21, -22, -24, -24, -25, -25, -26,
-26, -27, -27, -27, -27, -27, -27, -26, -25, -24, -24, -21, -21, -19, -18, -16,
-14, -13, -12, -11, -10, -10, -9, -10, -8, -8, -8, -7, -6, -6, -5, -4, -3, -2,
-1, };