#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0026

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 6, 8, 10, 11, 13, 15, 18, 21,
23, 25, 28, 30, 33, 35, 37, 38, 39, 42, 44, 44, 44, 45, 46, 46, 47, 48, 49, 48,
48, 50, 51, 51, 50, 51, 52, 53, 53, 54, 54, 55, 57, 57, 58, 59, 60, 62, 64, 67,
70, 74, 77, 81, 84, 88, 91, 95, 99, 101, 104, 106, 108, 109, 111, 113, 114, 116,
118, 118, 119, 119, 119, 118, 118, 116, 115, 113, 111, 107, 104, 101, 97, 94,
90, 86, 82, 78, 73, 67, 64, 59, 56, 51, 47, 43, 39, 35, 30, 26, 22, 18, 15, 11,
7, 3, 0, -5, -8, -11, -14, -18, -22, -26, -30, -33, -38, -41, -44, -46, -49,
-51, -55, -58, -60, -64, -66, -69, -72, -75, -78, -80, -82, -83, -85, -86, -87,
-88, -89, -88, -87, -86, -85, -83, -82, -80, -79, -77, -76, -73, -71, -69, -66,
-65, -62, -59, -58, -55, -52, -50, -48, -45, -44, -42, -41, -39, -38, -37, -37,
-37, -38, -38, -39, -39, -40, -41, -42, -43, -44, -46, -47, -50, -50, -52, -53,
-56, -57, -59, -60, -62, -63, -65, -65, -66, -69, -68, -70, -70, -72, -72, -73,
-74, -75, -75, -75, -75, -75, -75, -75, -75, -75, -74, -74, -74, -75, -74, -74,
-74, -74, -73, -73, -73, -73, -72, -71, -71, -69, -67, -67, -65, -62, -61, -59,
-57, -55, -53, -50, -48, -45, -42, -39, -36, -32, -30, -26, -22, -18, -16, -13,
-9, -5, -1, 2, 5, 9, 11, 13, 16, 18, 21, 22, 25, 25, 28, 28, 28, 28, 29, 29, 28,
29, 28, 26, 26, 24, 23, 23, 22, 21, 19, 18, 17, 15, 13, 13, 11, 9, 7, 7, 5, 3,
2, 1, 0, 1, -1, -1, -2, -2, -2, -3, -2, -4, -3, -5, -5, -6, -6, -6, -7, -7, -9,
-8, -9, -8, -8, -7, -8, -8, -7, -7, -6, -6, -6, -5, -6, -4, -2, -2, -1, 0, 1, 4,
5, 8, 8, 10, 13, 16, 18, 21, 22, 25, 28, 30, 32, 35, 37, 39, 41, 44, 45, 46, 48,
49, 51, 52, 52, 52, 53, 54, 53, 54, 55, 54, 54, 53, 52, 52, 50, 50, 49, 47, 46,
44, 42, 40, 38, 36, 34, 34, 32, 30, 28, 27, 26, 23, 22, 21, 19, 17, 16, 14, 12,
10, 9, 7, 5, 3, 2, 1, -1, -2, -2, -3, -4, -5, -6, -6, -7, -9, -9, -10, -11, -10,
-11, -11, -12, -12, -13, -12, -12, -12, -11, -10, -11, -11, -9, -8, -8, -7, -7,
-6, -5, -4, -3, -2, -2, 0, 1, 2, 2, 3, 4, 4, 4, 4, 5, 5, 5, 5, 5, 4, 4, 5, 4, 3,
2, 1, 1, 0, -2, -3, -5, -6, -8, -10, -11, -12, -14, -15, -16, -17, -18, -20,
-20, -21, -22, -23, -23, -24, -25, -26, -27, -28, -27, -28, -28, -27, -28, -27,
-27, -26, -26, -25, -24, -23, -23, -22, -21, -20, -18, -18, -17, -16, -13, -10,
-9, -7, -5, -4, -1, };