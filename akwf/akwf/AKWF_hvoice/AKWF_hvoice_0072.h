#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0072

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 6, 6, 7, 7, 8, 8, 8, 8, 8,
8, 9, 9, 10, 10, 10, 10, 10, 9, 8, 8, 8, 7, 7, 6, 5, 5, 4, 5, 3, 4, 3, 3, 3, 3,
4, 5, 4, 5, 5, 4, 4, 4, 3, 3, 2, 2, 3, 3, 3, 4, 4, 4, 4, 4, 4, 3, 4, 4, 5, 5, 5,
5, 7, 8, 9, 8, 9, 9, 9, 10, 10, 9, 11, 11, 12, 13, 14, 14, 15, 16, 16, 18, 18,
20, 20, 21, 21, 21, 21, 22, 22, 23, 23, 23, 24, 24, 24, 24, 24, 24, 23, 24, 24,
25, 25, 27, 29, 29, 30, 30, 30, 31, 31, 32, 31, 32, 34, 34, 36, 36, 38, 38, 37,
39, 38, 38, 38, 38, 38, 39, 41, 42, 43, 44, 43, 43, 43, 41, 41, 41, 41, 41, 41,
43, 43, 44, 43, 43, 42, 40, 40, 40, 39, 40, 40, 40, 41, 41, 40, 40, 37, 37, 35,
34, 31, 31, 30, 32, 31, 32, 32, 29, 28, 25, 21, 17, 16, 14, 12, 13, 13, 13, 13,
14, 14, 14, 10, 6, -1, -9, -19, -28, -36, -41, -47, -51, -53, -58, -61, -65,
-71, -77, -85, -93, -99, -104, -108, -111, -112, -113, -113, -114, -115, -115,
-117, -118, -119, -120, -119, -117, -114, -111, -107, -102, -97, -93, -89, -85,
-81, -76, -73, -68, -63, -58, -50, -42, -35, -29, -23, -18, -14, -8, -4, 0, 4,
10, 14, 18, 23, 28, 31, 34, 36, 39, 40, 42, 42, 43, 43, 44, 43, 44, 43, 43, 43,
41, 40, 37, 35, 32, 30, 27, 25, 22, 19, 16, 13, 11, 6, 3, 0, -2, -5, -8, -9,
-11, -14, -17, -19, -22, -26, -28, -30, -32, -34, -35, -36, -37, -37, -37, -38,
-38, -39, -39, -39, -39, -39, -37, -36, -35, -34, -32, -30, -28, -28, -26, -24,
-22, -20, -18, -15, -12, -11, -8, -5, -3, 0, 1, 4, 6, 9, 11, 12, 14, 15, 18, 19,
21, 23, 25, 26, 28, 30, 30, 30, 31, 32, 31, 33, 32, 32, 31, 32, 30, 29, 29, 28,
27, 26, 25, 23, 21, 20, 18, 17, 15, 12, 11, 8, 7, 4, 3, 1, -1, -3, -3, -5, -7,
-7, -9, -9, -11, -12, -13, -14, -15, -16, -16, -17, -18, -18, -17, -17, -17,
-17, -17, -17, -16, -16, -15, -16, -15, -14, -12, -13, -11, -10, -8, -7, -5, -3,
-2, 0, 1, 2, 2, 3, 4, 5, 7, 8, 9, 11, 12, 12, 14, 14, 14, 15, 15, 15, 16, 15,
16, 16, 16, 16, 16, 14, 14, 12, 13, 11, 12, 11, 10, 10, 9, 9, 8, 6, 5, 4, 1, 0,
0, -2, -2, -3, -4, -4, -5, -7, -9, -9, -11, -13, -13, -15, -14, -16, -16, -16,
-16, -17, -18, -18, -18, -18, -18, -18, -19, -18, -18, -18, -17, -17, -16, -16,
-15, -15, -15, -15, -14, -14, -12, -11, -8, -7, -6, -4, -4, -5, -5, -4, -4, -2,
0, };