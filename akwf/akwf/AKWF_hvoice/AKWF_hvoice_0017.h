#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 8, 10, 11, 13, 15, 16, 18,
19, 21, 22, 23, 25, 26, 27, 28, 29, 30, 30, 32, 32, 33, 34, 34, 35, 35, 35, 35,
35, 34, 34, 34, 34, 34, 34, 33, 32, 31, 31, 30, 29, 29, 28, 27, 26, 25, 24, 24,
23, 22, 21, 20, 20, 18, 18, 16, 15, 15, 14, 14, 13, 13, 11, 10, 10, 9, 8, 8, 8,
8, 8, 8, 8, 8, 8, 8, 8, 7, 7, 7, 9, 9, 9, 10, 10, 10, 11, 12, 12, 13, 14, 16,
16, 16, 18, 18, 19, 19, 19, 20, 22, 23, 24, 25, 26, 27, 28, 29, 29, 30, 31, 31,
31, 32, 33, 33, 34, 34, 35, 34, 35, 36, 37, 37, 37, 39, 39, 39, 40, 40, 41, 41,
41, 42, 43, 43, 44, 44, 44, 45, 45, 45, 45, 45, 45, 46, 46, 46, 47, 46, 46, 47,
47, 46, 46, 46, 46, 46, 46, 45, 45, 46, 45, 46, 45, 46, 46, 47, 47, 46, 47, 47,
48, 48, 48, 48, 48, 48, 49, 49, 50, 50, 51, 50, 50, 50, 49, 47, 47, 46, 45, 44,
44, 44, 43, 43, 43, 42, 40, 40, 41, 41, 42, 42, 41, 39, 39, 34, 28, 21, 15, 8,
1, -5, -12, -19, -25, -32, -38, -44, -52, -60, -65, -70, -74, -79, -83, -88,
-91, -96, -99, -102, -103, -107, -108, -108, -108, -108, -109, -109, -109, -110,
-111, -113, -114, -116, -116, -117, -118, -119, -119, -119, -119, -118, -116,
-115, -114, -112, -110, -107, -105, -101, -98, -94, -90, -85, -80, -75, -68,
-63, -57, -51, -45, -39, -34, -29, -25, -20, -16, -12, -9, -6, -1, 1, 4, 8, 11,
14, 16, 19, 22, 24, 25, 27, 28, 29, 31, 32, 33, 36, 37, 39, 40, 41, 44, 44, 45,
45, 45, 45, 45, 42, 41, 39, 37, 35, 33, 30, 27, 25, 22, 19, 16, 11, 7, 4, 1, -4,
-7, -11, -15, -19, -22, -25, -29, -31, -34, -36, -38, -40, -41, -44, -46, -48,
-50, -52, -54, -56, -58, -59, -60, -61, -61, -63, -64, -64, -64, -66, -66, -66,
-66, -65, -66, -65, -64, -62, -62, -60, -58, -56, -54, -52, -49, -47, -43, -40,
-37, -34, -32, -28, -26, -22, -20, -16, -13, -10, -7, -4, -1, 2, 5, 7, 10, 12,
14, 16, 19, 21, 21, 24, 26, 28, 29, 31, 33, 35, 37, 39, 43, 43, 43, 45, 46, 46,
46, 47, 46, 47, 48, 47, 47, 45, 44, 44, 44, 42, 42, 40, 39, 37, 35, 33, 32, 29,
28, 26, 24, 23, 22, 20, 18, 16, 15, 13, 11, 8, 6, 4, 3, 0, -2, -4, -6, -9, -10,
-12, -13, -15, -16, -18, -20, -21, -23, -24, -26, -28, -30, -30, -31, -32, -34,
-35, -35, -35, -36, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -34, -33,
-33, -31, -30, -29, -28, -26, -24, -24, -21, -21, -18, -16, -15, -15, -12, -10,
-9, -8, -7, -5, -4, -1, };