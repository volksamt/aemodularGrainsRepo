#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0100

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 5, 8, 10, 11, 13, 15, 16, 19,
19, 20, 21, 22, 22, 24, 24, 26, 27, 29, 31, 33, 34, 36, 38, 38, 40, 40, 41, 40,
41, 43, 45, 47, 48, 50, 49, 48, 49, 47, 46, 46, 45, 47, 49, 52, 54, 55, 56, 55,
54, 52, 52, 50, 50, 51, 51, 50, 49, 47, 46, 44, 43, 43, 44, 45, 46, 47, 49, 49,
48, 46, 42, 40, 37, 34, 32, 31, 31, 31, 32, 32, 35, 36, 37, 37, 36, 34, 32, 29,
26, 23, 21, 21, 22, 24, 24, 25, 26, 27, 25, 26, 27, 25, 25, 24, 25, 23, 22, 22,
20, 20, 21, 23, 26, 28, 30, 31, 31, 30, 29, 29, 28, 28, 29, 33, 35, 37, 39, 40,
40, 41, 40, 39, 39, 38, 38, 38, 39, 40, 41, 42, 45, 49, 53, 56, 58, 58, 55, 53,
51, 50, 49, 48, 48, 50, 51, 50, 45, 38, 29, 21, 15, 12, 11, 13, 18, 25, 29, 30,
27, 21, 11, 2, -8, -18, -25, -30, -33, -35, -37, -38, -39, -41, -42, -43, -44,
-45, -48, -53, -58, -64, -71, -78, -84, -91, -94, -97, -99, -99, -98, -97, -96,
-95, -94, -95, -96, -99, -102, -106, -112, -115, -117, -119, -119, -119, -118,
-118, -116, -114, -112, -110, -107, -104, -100, -96, -93, -92, -93, -94, -96,
-98, -99, -99, -97, -94, -90, -84, -79, -73, -68, -63, -58, -53, -49, -45, -43,
-42, -43, -42, -43, -45, -45, -44, -39, -31, -24, -17, -9, -2, 3, 6, 8, 8, 8, 8,
8, 8, 9, 10, 12, 14, 15, 18, 20, 23, 27, 30, 33, 36, 38, 39, 40, 40, 39, 39, 37,
36, 33, 31, 28, 27, 27, 27, 29, 32, 34, 38, 39, 40, 38, 35, 31, 28, 24, 20, 16,
14, 11, 9, 7, 7, 8, 10, 12, 12, 13, 11, 10, 6, 1, -6, -10, -14, -15, -17, -17,
-17, -18, -17, -19, -19, -20, -20, -21, -22, -24, -26, -29, -32, -36, -40, -40,
-41, -39, -38, -35, -32, -30, -29, -31, -34, -37, -41, -43, -45, -45, -44, -42,
-40, -36, -32, -30, -29, -28, -29, -30, -31, -32, -32, -32, -31, -29, -26, -23,
-20, -17, -15, -14, -13, -12, -11, -11, -9, -8, -6, -3, -1, 0, 1, 3, 4, 5, 7, 8,
12, 13, 16, 18, 19, 20, 19, 19, 20, 21, 23, 25, 27, 28, 28, 30, 29, 28, 28, 28,
28, 30, 32, 34, 34, 35, 35, 33, 32, 31, 31, 30, 29, 28, 28, 26, 27, 26, 25, 25,
24, 24, 24, 24, 22, 21, 19, 18, 17, 16, 15, 13, 11, 9, 6, 3, 0, -1, -2, -1, 0,
2, 3, 3, 3, 2, -1, -5, -8, -12, -15, -19, -21, -21, -21, -20, -18, -16, -15,
-12, -10, -11, -12, -15, -18, -21, -25, -27, -28, -28, -28, -25, -23, -19, -18,
-16, -15, -15, -14, -15, -16, -16, -18, -18, -18, -18, -16, -14, -12, -10, -8,
-6, -5, -4, -4, -2, 0, };