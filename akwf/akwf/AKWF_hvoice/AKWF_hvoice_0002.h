#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 13, 19, 25, 31, 37, 43, 49, 56,
61, 66, 71, 77, 82, 86, 92, 95, 100, 102, 104, 107, 109, 112, 113, 116, 117,
118, 119, 118, 118, 116, 114, 113, 111, 110, 110, 109, 108, 109, 108, 106, 104,
101, 99, 97, 96, 93, 89, 85, 81, 76, 72, 67, 61, 56, 50, 45, 40, 36, 31, 27, 21,
15, 9, 3, -3, -9, -15, -21, -26, -32, -38, -43, -50, -55, -60, -65, -69, -73,
-75, -79, -81, -85, -88, -91, -94, -96, -97, -98, -97, -99, -98, -99, -99, -100,
-100, -100, -99, -99, -98, -98, -98, -96, -95, -94, -93, -92, -91, -90, -87,
-84, -82, -78, -75, -73, -69, -65, -62, -58, -54, -49, -45, -40, -36, -32, -27,
-22, -19, -15, -10, -5, -2, 3, 6, 10, 12, 16, 19, 22, 26, 29, 31, 35, 37, 40,
42, 45, 47, 50, 52, 54, 56, 59, 61, 63, 65, 68, 70, 72, 75, 77, 79, 81, 82, 84,
85, 87, 86, 87, 85, 87, 86, 86, 85, 84, 83, 81, 79, 77, 76, 73, 72, 70, 68, 65,
62, 59, 58, 55, 52, 49, 47, 43, 41, 38, 35, 31, 29, 25, 21, 18, 15, 11, 7, 3, 0,
-4, -7, -11, -15, -18, -21, -26, -29, -32, -37, -41, -45, -49, -53, -57, -60,
-64, -67, -70, -73, -75, -77, -80, -81, -82, -83, -84, -84, -84, -84, -84, -83,
-83, -82, -81, -80, -78, -77, -76, -74, -72, -71, -70, -67, -65, -63, -61, -58,
-56, -52, -51, -47, -45, -41, -37, -34, -31, -28, -24, -21, -16, -13, -9, -5,
-2, 2, 6, 9, 13, 16, 20, 23, 27, 30, 33, 37, 40, 42, 45, 48, 51, 52, 55, 55, 58,
58, 59, 59, 60, 61, 60, 60, 59, 58, 58, 58, 57, 57, 56, 56, 56, 56, 55, 54, 53,
52, 51, 51, 49, 47, 46, 44, 42, 41, 39, 37, 34, 32, 30, 27, 25, 22, 19, 17, 14,
11, 8, 6, 3, 0, -3, -7, -9, -11, -14, -16, -18, -21, -22, -24, -26, -28, -30,
-32, -35, -36, -38, -40, -41, -43, -43, -45, -47, -47, -49, -50, -51, -52, -54,
-54, -55, -55, -57, -57, -58, -58, -60, -60, -60, -61, -60, -61, -62, -60, -60,
-60, -58, -57, -56, -54, -53, -51, -48, -47, -46, -43, -41, -38, -36, -35, -32,
-30, -27, -24, -22, -19, -16, -15, -12, -10, -8, -5, -3, -1, 1, 4, 5, 8, 10, 11,
13, 14, 16, 19, 20, 22, 22, 24, 26, 26, 27, 28, 29, 30, 30, 30, 31, 32, 31, 30,
30, 29, 28, 27, 27, 26, 24, 21, 20, 16, 15, 12, 9, 8, 5, 3, 1, -2, -4, -7, -8,
-11, -13, -15, -17, -19, -21, -23, -26, -27, -29, -31, -33, -34, -34, -36, -37,
-39, -39, -41, -42, -45, -45, -46, -47, -49, -50, -52, -53, -54, -55, -56, -56,
-56, -57, -56, -56, -56, -54, -53, -53, -50, -49, -46, -44, -40, -37, -33, -30,
-26, -21, -16, -12, -6, -1, };