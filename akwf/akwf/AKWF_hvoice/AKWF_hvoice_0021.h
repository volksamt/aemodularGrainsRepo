#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 14, 17, 18, 18, 15, 13, 8,
6, 8, 12, 16, 18, 17, 13, 10, 8, 6, 7, 10, 12, 13, 14, 13, 11, 10, 7, 4, 2, 2,
2, 6, 9, 13, 13, 12, 10, 8, 6, 6, 5, 6, 9, 12, 14, 15, 14, 14, 12, 12, 14, 16,
19, 21, 21, 21, 20, 20, 19, 19, 20, 22, 25, 29, 32, 35, 34, 32, 28, 27, 26, 27,
32, 37, 41, 42, 40, 37, 34, 32, 31, 32, 36, 40, 43, 42, 42, 38, 35, 34, 34, 38,
44, 48, 50, 50, 47, 45, 41, 39, 38, 39, 42, 45, 49, 50, 51, 49, 47, 45, 44, 44,
46, 46, 47, 44, 42, 40, 40, 39, 42, 43, 47, 50, 52, 51, 48, 42, 37, 32, 30, 32,
35, 36, 39, 39, 40, 41, 42, 39, 35, 29, 20, 13, 9, 10, 15, 20, 23, 25, 25, 26,
31, 40, 44, 42, 28, -4, -39, -73, -96, -95, -80, -58, -33, -23, -26, -34, -48,
-57, -66, -73, -83, -95, -106, -115, -119, -118, -113, -106, -97, -86, -74, -59,
-47, -43, -44, -57, -76, -91, -102, -101, -89, -70, -46, -25, -11, -2, -1, -2,
-2, -2, -4, -5, -8, -12, -14, -16, -15, -10, -4, 3, 12, 20, 27, 29, 26, 16, 0,
-17, -32, -43, -43, -42, -36, -30, -26, -22, -23, -23, -24, -27, -31, -39, -49,
-57, -66, -71, -72, -70, -67, -60, -52, -44, -35, -29, -26, -27, -32, -38, -43,
-47, -47, -43, -37, -30, -21, -10, -1, 7, 13, 17, 19, 16, 13, 10, 7, 4, 4, 5, 8,
13, 20, 26, 30, 33, 33, 31, 27, 23, 17, 9, 3, -3, -5, -4, -2, 1, 2, 3, 2, 2, -1,
-4, -10, -15, -23, -29, -32, -36, -35, -32, -29, -25, -22, -19, -16, -14, -15,
-15, -18, -20, -23, -25, -24, -20, -16, -9, -2, 3, 7, 11, 11, 12, 12, 11, 12,
13, 15, 17, 18, 19, 21, 22, 24, 26, 28, 29, 29, 29, 30, 28, 27, 23, 19, 15, 11,
9, 8, 9, 10, 11, 9, 7, 6, 4, 2, 1, -2, -7, -9, -12, -14, -14, -12, -12, -11,
-11, -13, -13, -12, -12, -11, -10, -10, -10, -11, -10, -10, -8, -7, -3, -1, 1,
2, 3, 5, 7, 9, 11, 13, 12, 11, 11, 10, 12, 14, 16, 18, 21, 22, 21, 21, 20, 17,
16, 15, 14, 11, 10, 8, 8, 5, 3, 1, 2, 1, -1, -1, -2, -2, -3, -7, -9, -14, -18,
-20, -21, -19, -17, -16, -15, -14, -15, -16, -18, -18, -18, -17, -16, -14, -11,
-10, -11, -13, -14, -14, -12, -7, -1, 3, 6, 6, 5, 4, 3, 3, 6, 8, 9, 9, 9, 8, 6,
4, 4, 6, 8, 11, 13, 13, 13, 11, 8, 4, 0, -3, -6, -6, -6, -4, -2, -1, -2, -5,
-10, -11, -12, -12, -11, -11, -13, -16, -17, -18, -18, -17, -15, -12, -11, -9,
-9, -9, -11, -14, -16, -15, -13, -8, -2, };