#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0091

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 3, 4, 5, 5, 6, 7, 7, 8, 9, 8,
8, 9, 8, 9, 9, 9, 10, 11, 11, 12, 15, 15, 16, 18, 18, 19, 19, 20, 19, 21, 20,
20, 20, 20, 20, 19, 18, 17, 16, 15, 15, 15, 15, 15, 15, 14, 16, 16, 16, 16, 18,
17, 18, 18, 18, 18, 19, 18, 19, 19, 18, 19, 19, 18, 18, 18, 17, 17, 17, 17, 17,
17, 18, 19, 19, 21, 22, 22, 23, 24, 25, 27, 28, 29, 31, 31, 33, 34, 34, 36, 36,
38, 40, 40, 42, 42, 44, 44, 45, 46, 48, 50, 50, 52, 54, 55, 56, 57, 58, 58, 59,
60, 60, 61, 62, 63, 62, 63, 63, 63, 63, 62, 63, 61, 61, 62, 61, 61, 62, 61, 61,
61, 60, 59, 58, 56, 55, 53, 52, 52, 51, 49, 48, 48, 46, 44, 41, 39, 34, 31, 28,
26, 24, 22, 22, 21, 22, 22, 21, 22, 21, 15, 8, 2, -10, -23, -32, -39, -46, -52,
-54, -58, -63, -68, -72, -77, -82, -86, -90, -93, -96, -99, -102, -103, -101,
-101, -100, -98, -96, -99, -101, -104, -109, -113, -116, -117, -119, -119, -116,
-115, -112, -108, -105, -103, -99, -96, -93, -91, -87, -82, -77, -72, -66, -58,
-53, -47, -42, -39, -36, -33, -31, -30, -28, -27, -25, -21, -17, -13, -8, -4, 1,
4, 6, 9, 13, 14, 17, 20, 23, 25, 29, 32, 33, 34, 36, 37, 34, 34, 30, 27, 25, 23,
20, 18, 17, 15, 14, 13, 12, 9, 9, 7, 4, 2, 2, -1, -1, -3, -3, -4, -6, -8, -10,
-12, -16, -19, -22, -26, -29, -32, -35, -38, -38, -40, -41, -41, -42, -42, -41,
-43, -41, -41, -39, -38, -37, -36, -33, -32, -32, -31, -30, -29, -27, -26, -25,
-24, -23, -23, -21, -19, -18, -14, -12, -9, -5, -4, 0, 2, 5, 7, 10, 12, 15, 17,
19, 21, 23, 25, 27, 28, 29, 30, 31, 32, 32, 32, 32, 33, 33, 32, 32, 34, 32, 33,
33, 34, 34, 32, 32, 30, 29, 29, 28, 26, 26, 25, 24, 22, 20, 19, 15, 14, 12, 10,
8, 6, 4, 2, 1, 0, -2, -4, -5, -6, -8, -10, -11, -12, -13, -15, -15, -15, -14,
-16, -16, -16, -17, -17, -17, -18, -18, -19, -19, -19, -18, -19, -17, -17, -15,
-15, -14, -13, -13, -13, -12, -11, -10, -9, -7, -5, -4, -4, -2, -1, -1, 0, 1, 2,
3, 3, 4, 5, 6, 6, 6, 7, 8, 9, 10, 11, 12, 13, 13, 13, 14, 12, 12, 11, 11, 11, 9,
9, 9, 9, 7, 7, 6, 5, 5, 3, 4, 2, 2, 0, 0, 0, -3, -3, -4, -5, -4, -5, -6, -7, -8,
-10, -10, -11, -11, -13, -13, -12, -13, -13, -14, -14, -15, -14, -15, -16, -16,
-16, -17, -15, -15, -16, -16, -16, -15, -15, -13, -13, -12, -12, -11, -11, -11,
-10, -9, -9, -9, -8, -7, -6, -6, -4, -3, -2, -1, };