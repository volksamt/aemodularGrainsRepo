#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0097

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 6, 7, 10, 12, 14, 16, 17, 18,
20, 22, 24, 25, 27, 28, 30, 31, 33, 33, 33, 34, 36, 36, 38, 39, 38, 39, 38, 38,
38, 38, 38, 38, 39, 39, 39, 40, 39, 39, 39, 37, 38, 37, 37, 37, 36, 36, 35, 35,
34, 33, 33, 33, 32, 32, 31, 30, 28, 27, 26, 24, 23, 22, 20, 20, 18, 18, 17, 18,
17, 15, 16, 15, 14, 14, 14, 13, 12, 12, 12, 12, 12, 12, 12, 12, 12, 11, 11, 10,
10, 10, 9, 8, 9, 9, 8, 7, 8, 8, 8, 9, 10, 10, 11, 11, 13, 13, 13, 14, 14, 15,
17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 27, 29, 30, 31, 32, 32, 32, 34, 35,
36, 37, 39, 40, 42, 41, 43, 43, 44, 45, 46, 47, 47, 49, 49, 51, 51, 52, 53, 53,
54, 55, 55, 56, 56, 56, 56, 57, 57, 57, 58, 58, 58, 60, 60, 60, 60, 60, 59, 58,
58, 56, 56, 56, 55, 53, 52, 52, 51, 50, 49, 49, 48, 46, 46, 44, 44, 44, 43, 41,
39, 35, 32, 26, 20, 12, 6, -1, -7, -12, -17, -22, -28, -34, -40, -46, -52, -58,
-63, -68, -70, -74, -77, -81, -83, -87, -90, -92, -94, -96, -97, -99, -98, -101,
-102, -105, -106, -110, -111, -114, -115, -116, -116, -118, -119, -119, -118,
-119, -118, -117, -117, -116, -114, -112, -109, -106, -104, -100, -96, -92, -87,
-82, -78, -74, -69, -65, -60, -56, -51, -48, -42, -40, -36, -32, -29, -25, -22,
-19, -16, -13, -9, -6, -3, 0, 2, 6, 9, 11, 15, 18, 22, 25, 29, 31, 34, 37, 40,
42, 43, 45, 46, 48, 47, 47, 49, 48, 47, 48, 47, 45, 43, 42, 40, 38, 34, 32, 30,
28, 24, 23, 20, 18, 16, 13, 11, 9, 7, 5, 4, 2, 0, -3, -6, -8, -10, -14, -16,
-19, -21, -23, -26, -30, -32, -35, -37, -41, -43, -45, -48, -50, -53, -54, -56,
-58, -60, -59, -59, -60, -60, -59, -59, -59, -59, -58, -56, -57, -54, -54, -53,
-52, -50, -49, -49, -47, -45, -43, -41, -40, -37, -36, -34, -32, -30, -29, -27,
-25, -23, -21, -17, -14, -11, -9, -6, -2, 0, 3, 6, 9, 11, 13, 17, 19, 21, 24,
25, 27, 29, 30, 31, 34, 35, 36, 38, 39, 39, 40, 41, 41, 41, 43, 42, 42, 43, 44,
43, 44, 44, 45, 44, 45, 44, 44, 43, 42, 40, 39, 38, 37, 36, 34, 32, 31, 28, 27,
24, 23, 21, 18, 16, 14, 12, 11, 8, 6, 4, 2, -1, -2, -3, -5, -7, -8, -10, -13,
-14, -15, -17, -19, -20, -22, -23, -25, -27, -28, -31, -31, -33, -33, -34, -36,
-36, -37, -38, -39, -40, -40, -40, -40, -39, -38, -38, -39, -37, -36, -35, -35,
-33, -32, -31, -30, -29, -27, -26, -24, -22, -22, -20, -18, -17, -15, -13, -12,
-10, -10, -8, -6, -4, -3, -1, };