#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0061

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 32, 60, 97, 116, 118, 108, 94, 95,
88, 85, 55, 25, -7, -23, -24, -28, -34, -55, -73, -92, -96, -97, -87, -83, -79,
-84, -90, -89, -81, -59, -41, -22, -19, -12, -9, 10, 32, 50, 60, 56, 59, 60, 75,
85, 89, 81, 69, 56, 47, 41, 40, 40, 34, 21, 2, -17, -35, -43, -50, -50, -56,
-62, -68, -70, -66, -61, -55, -59, -61, -67, -59, -44, -21, -3, 4, 3, -2, 3, 11,
30, 39, 46, 49, 53, 61, 61, 57, 52, 46, 44, 38, 28, 25, 20, 19, 11, -4, -15,
-25, -26, -32, -36, -44, -49, -48, -46, -43, -43, -44, -46, -45, -43, -34, -24,
-10, -1, 2, 7, 10, 16, 20, 22, 29, 35, 42, 44, 41, 37, 32, 30, 28, 29, 27, 24,
17, 9, 0, -5, -10, -12, -17, -24, -32, -38, -35, -31, -23, -27, -31, -40, -38,
-28, -19, -10, -15, -14, -14, -4, 5, 13, 17, 18, 18, 16, 21, 25, 29, 29, 28, 26,
24, 20, 17, 13, 13, 11, 7, 1, -7, -8, -9, -5, -10, -16, -26, -32, -29, -25, -18,
-19, -19, -22, -21, -18, -12, -9, -6, -5, -6, -5, -1, 6, 12, 18, 19, 18, 15, 15,
15, 17, 17, 13, 11, 9, 15, 17, 12, 3, -6, -8, -8, -4, -5, -8, -13, -18, -17,
-17, -16, -21, -21, -22, -17, -9, -3, 0, -4, -9, -17, -13, -5, 10, 14, 13, 8, 4,
9, 12, 18, 14, 10, 4, 4, 8, 14, 17, 13, 7, -4, -3, -3, 2, -1, -7, -11, -13, -10,
-9, -9, -9, -8, -9, -9, -12, -8, -5, 0, 0, -4, -6, -8, -4, 0, 5, 10, 14, 13, 10,
3, 0, -1, 6, 9, 11, 8, 4, 4, 4, 3, 0, -2, -1, 0, -1, -2, -6, -3, -3, 1, -3, -9,
-12, -12, -5, -2, 2, -3, -4, -6, -4, -2, -2, -2, 3, 5, 7, 3, 2, 5, 6, 9, 4, 1,
-1, 1, 3, 4, 5, 7, 7, 4, 1, -2, 1, 0, 1, -2, -4, -5, -4, -1, -1, -1, -3, -4, -4,
-2, 1, 2, 1, 0, 1, 1, -1, -1, -1, 3, 7, 5, 2, -4, -2, 2, 7, 8, 6, 2, -1, 0, 1,
3, 1, 0, -4, -4, 2, 7, 10, 3, -1, -5, -1, 2, 0, 0, -2, -1, 0, 3, 3, 3, -1, -3,
-5, -5, -2, 1, 6, 7, 3, -5, -7, -8, -1, 4, 6, 5, 0, 2, 2, 4, 1, -2, -4, -3, 3,
5, 5, 0, -3, -2, -1, 1, 0, 1, 1, 1, 2, -1, -2, -1, -1, -1, -2, -2, -2, 0, 2, 0,
-1, -5, -5, -2, 4, 7, 6, 3, 0, 6, 8, 10, 6, 0, 0, 4, 10, 10, 7, 6, 5, 11, 9, 6,
2, -1, 1, 4, 7, 7, 5, 3, 1, 1, -1, 0, 0, 0, 1, 1, 0, -4, -7, -8, -5, -2, 2, 5,
7, 10, 13, 12, 9, 5, -2, -10, -25, -34, -38, -27, -13, -2, };