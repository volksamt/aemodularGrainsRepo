#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0086

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 3, 5, 4, 7, 8, 9, 11, 11, 12,
12, 12, 11, 10, 11, 12, 15, 19, 22, 24, 25, 25, 25, 24, 23, 21, 23, 23, 25, 27,
27, 27, 25, 25, 23, 23, 24, 25, 28, 30, 32, 32, 31, 30, 28, 27, 25, 26, 26, 25,
25, 25, 24, 24, 24, 24, 26, 27, 29, 29, 29, 27, 24, 19, 17, 16, 14, 16, 17, 19,
22, 22, 22, 20, 19, 17, 16, 16, 15, 15, 15, 14, 14, 13, 11, 10, 8, 8, 8, 8, 10,
10, 11, 12, 12, 13, 13, 12, 11, 10, 7, 6, 4, 2, 1, 2, 4, 6, 10, 12, 12, 12, 12,
11, 10, 9, 8, 9, 9, 10, 12, 10, 10, 9, 9, 8, 10, 10, 12, 14, 16, 18, 18, 20, 20,
20, 19, 18, 17, 16, 16, 14, 15, 16, 18, 21, 24, 26, 27, 29, 29, 30, 28, 28, 28,
28, 27, 27, 28, 27, 28, 30, 31, 35, 37, 39, 40, 40, 40, 39, 39, 38, 38, 39, 40,
43, 44, 45, 45, 45, 44, 44, 44, 44, 45, 46, 48, 52, 54, 54, 53, 53, 52, 51, 51,
51, 51, 52, 52, 53, 55, 56, 56, 57, 59, 60, 61, 61, 60, 58, 57, 55, 55, 53, 53,
54, 55, 57, 58, 59, 59, 59, 59, 58, 58, 58, 56, 57, 57, 57, 56, 54, 51, 47, 39,
30, 24, 17, 15, 14, 17, 22, 31, 37, 40, 37, 27, 16, 5, -7, -17, -24, -26, -23,
-21, -18, -17, -20, -26, -31, -37, -40, -43, -46, -48, -49, -52, -55, -61, -67,
-74, -79, -83, -84, -86, -86, -88, -89, -90, -91, -92, -93, -96, -98, -100,
-102, -105, -110, -113, -117, -119, -119, -119, -119, -117, -116, -115, -115,
-115, -114, -114, -113, -112, -112, -111, -112, -113, -114, -115, -115, -112,
-112, -109, -106, -104, -100, -98, -95, -92, -89, -86, -83, -79, -77, -76, -77,
-78, -77, -75, -73, -70, -65, -59, -53, -48, -44, -42, -39, -37, -34, -32, -30,
-27, -25, -23, -22, -19, -17, -14, -10, -6, -1, 2, 6, 9, 11, 13, 15, 18, 21, 24,
27, 27, 27, 28, 27, 28, 30, 31, 35, 38, 41, 46, 48, 50, 50, 50, 50, 49, 49, 48,
47, 46, 46, 47, 48, 49, 51, 52, 52, 54, 54, 53, 51, 50, 49, 47, 46, 45, 43, 41,
40, 38, 38, 36, 36, 35, 35, 35, 34, 34, 32, 30, 28, 25, 22, 18, 14, 12, 10, 9,
7, 6, 6, 6, 5, 5, 3, 2, 0, -2, -5, -7, -11, -14, -16, -17, -20, -21, -23, -23,
-25, -25, -25, -25, -26, -25, -26, -28, -28, -31, -32, -35, -36, -38, -38, -39,
-40, -40, -41, -39, -40, -39, -37, -37, -35, -34, -34, -34, -35, -37, -38, -40,
-40, -41, -40, -38, -36, -33, -31, -28, -27, -26, -25, -24, -23, -22, -23, -23,
-22, -22, -22, -23, -21, -19, -17, -15, -11, -8, -4, -3, 0, 0, 0, 0, 0, -3, -2,
-3, -2, 0, };