#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 4, 6, 6, 7, 9, 10, 11, 11,
13, 15, 16, 17, 18, 20, 21, 21, 24, 24, 26, 27, 29, 29, 31, 32, 33, 35, 36, 37,
39, 40, 41, 43, 43, 45, 47, 48, 49, 51, 52, 53, 54, 56, 57, 58, 60, 60, 63, 64,
65, 67, 68, 70, 72, 74, 74, 76, 78, 80, 82, 83, 84, 86, 89, 91, 93, 93, 96, 97,
98, 100, 101, 102, 104, 105, 106, 108, 109, 111, 111, 112, 113, 114, 114, 115,
116, 117, 116, 117, 117, 118, 118, 118, 119, 119, 119, 119, 120, 118, 118, 118,
117, 117, 115, 114, 114, 112, 111, 110, 108, 107, 105, 103, 102, 100, 98, 96,
93, 91, 89, 86, 83, 81, 79, 76, 74, 71, 68, 65, 63, 60, 57, 54, 52, 48, 45, 41,
40, 37, 32, 30, 27, 24, 20, 17, 14, 11, 8, 4, 2, -1, -4, -7, -9, -13, -16, -19,
-22, -23, -26, -30, -32, -34, -37, -40, -42, -44, -46, -48, -50, -52, -55, -56,
-57, -60, -61, -63, -64, -66, -67, -69, -70, -71, -73, -73, -75, -76, -77, -79,
-79, -79, -81, -82, -82, -83, -84, -84, -85, -86, -86, -87, -87, -87, -86, -87,
-87, -88, -87, -88, -88, -87, -88, -87, -88, -88, -88, -88, -88, -88, -87, -88,
-88, -88, -87, -87, -87, -87, -86, -87, -86, -86, -85, -85, -86, -86, -85, -84,
-83, -83, -83, -82, -82, -81, -81, -80, -80, -79, -79, -77, -77, -76, -75, -75,
-74, -73, -72, -71, -70, -70, -69, -67, -66, -66, -66, -64, -63, -62, -61, -60,
-59, -58, -56, -55, -54, -53, -51, -49, -48, -47, -45, -43, -42, -40, -39, -37,
-36, -34, -32, -31, -29, -28, -26, -25, -23, -21, -20, -17, -17, -15, -13, -12,
-11, -8, -7, -6, -5, -3, -1, 0, 2, 2, 4, 5, 7, 9, 10, 11, 12, 13, 14, 16, 16,
18, 18, 19, 19, 21, 22, 23, 23, 24, 24, 25, 25, 26, 26, 26, 27, 28, 27, 28, 28,
29, 28, 28, 28, 28, 28, 28, 28, 28, 27, 27, 27, 26, 26, 26, 25, 25, 24, 24, 23,
23, 21, 21, 21, 20, 19, 19, 18, 17, 17, 16, 15, 14, 13, 12, 12, 11, 10, 9, 7, 7,
6, 6, 4, 4, 3, 2, 2, 0, 0, -1, -2, -3, -3, -3, -5, -5, -7, -8, -8, -9, -10, -10,
-11, -12, -13, -13, -15, -15, -15, -16, -17, -18, -18, -20, -19, -20, -22, -22,
-21, -22, -23, -23, -23, -24, -24, -25, -25, -26, -26, -26, -27, -27, -26, -28,
-28, -27, -28, -28, -29, -29, -29, -29, -30, -29, -29, -30, -30, -30, -29, -29,
-30, -29, -29, -30, -29, -29, -28, -28, -28, -28, -27, -28, -27, -27, -26, -27,
-25, -25, -24, -24, -24, -23, -23, -23, -22, -22, -21, -21, -20, -19, -20, -19,
-18, -18, -17, -15, -15, -15, -14, -13, -12, -12, -11, -11, -10, -9, -8, -8, -7,
-5, -4, -3, -3, -2, -1, 0, };