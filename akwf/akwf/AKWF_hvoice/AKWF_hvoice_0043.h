#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0043

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 11, 15, 16, 18, 19, 21, 23, 21,
23, 25, 27, 29, 29, 31, 35, 34, 36, 38, 41, 41, 37, 36, 37, 36, 35, 34, 31, 32,
26, 23, 24, 23, 26, 26, 27, 28, 29, 31, 24, 24, 26, 24, 26, 24, 27, 35, 37, 39,
42, 49, 50, 50, 44, 44, 48, 43, 43, 42, 52, 54, 53, 59, 61, 66, 62, 62, 65, 68,
64, 61, 69, 69, 70, 68, 73, 76, 74, 71, 66, 69, 62, 57, 53, 54, 55, 55, 56, 53,
52, 45, 38, 31, 24, 18, 15, 12, 7, 4, 2, -3, -9, -15, -21, -28, -37, -47, -54,
-59, -65, -69, -72, -73, -77, -81, -84, -90, -97, -104, -107, -109, -111, -113,
-112, -111, -112, -112, -113, -114, -113, -117, -119, -119, -118, -118, -116,
-112, -109, -105, -102, -100, -99, -99, -96, -94, -90, -85, -77, -72, -67, -62,
-57, -54, -51, -49, -46, -42, -39, -37, -30, -25, -20, -15, -10, -5, -2, -1, 1,
4, 8, 11, 15, 22, 30, 34, 38, 42, 45, 48, 49, 50, 52, 54, 55, 57, 59, 61, 64,
66, 66, 65, 64, 62, 61, 58, 55, 54, 53, 53, 53, 53, 50, 48, 46, 44, 40, 37, 35,
32, 28, 26, 25, 24, 21, 19, 17, 16, 15, 12, 8, 10, 9, 8, 9, 11, 13, 14, 14, 15,
15, 14, 14, 15, 16, 18, 20, 24, 26, 30, 33, 36, 38, 38, 37, 38, 40, 43, 47, 51,
55, 55, 55, 54, 51, 49, 49, 48, 47, 45, 42, 42, 40, 38, 38, 38, 38, 35, 33, 30,
30, 30, 27, 26, 26, 22, 16, 8, 4, 3, 3, 3, 5, 7, 7, 3, -3, -8, -12, -15, -18,
-20, -21, -22, -22, -20, -20, -20, -17, -17, -18, -20, -25, -29, -30, -33, -36,
-35, -34, -35, -35, -39, -42, -41, -43, -46, -46, -47, -47, -49, -52, -55, -55,
-55, -54, -52, -50, -52, -49, -47, -47, -47, -45, -44, -44, -44, -46, -43, -39,
-39, -36, -31, -27, -23, -24, -21, -20, -17, -17, -15, -10, -7, -5, -2, 1, 3, 9,
10, 17, 20, 20, 22, 22, 22, 21, 22, 22, 27, 27, 28, 32, 35, 40, 39, 40, 40, 41,
42, 35, 37, 37, 37, 38, 41, 42, 43, 45, 44, 43, 41, 38, 40, 36, 32, 31, 27, 30,
27, 29, 32, 33, 35, 34, 34, 30, 30, 28, 27, 27, 28, 35, 35, 39, 36, 36, 37, 34,
35, 33, 33, 31, 27, 27, 27, 33, 35, 38, 38, 36, 31, 28, 25, 22, 18, 17, 17, 17,
15, 12, 12, 10, 5, 0, -2, -7, -13, -18, -26, -29, -30, -33, -34, -35, -38, -42,
-44, -50, -54, -58, -62, -65, -66, -71, -73, -74, -75, -76, -75, -75, -76, -75,
-77, -79, -79, -79, -77, -75, -73, -72, -71, -71, -74, -74, -72, -71, -69, -67,
-66, -62, -59, -58, -56, -54, -51, -49, -46, -45, -43, -39, -36, -32, -28, -24,
-18, -13, -12, -11, -10, -8, -7, -5, 0, };