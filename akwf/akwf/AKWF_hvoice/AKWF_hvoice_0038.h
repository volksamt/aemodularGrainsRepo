#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0038

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 13, 20, 25, 29, 27, 22, 20, 22, 26,
32, 38, 44, 47, 50, 50, 50, 51, 52, 56, 58, 57, 59, 63, 68, 68, 71, 78, 78, 75,
71, 71, 74, 73, 73, 75, 76, 75, 72, 70, 71, 72, 75, 78, 73, 68, 68, 65, 61, 58,
60, 65, 61, 58, 57, 57, 55, 53, 55, 56, 54, 50, 47, 42, 38, 39, 42, 45, 48, 54,
58, 54, 45, 40, 41, 40, 35, 36, 44, 51, 52, 51, 49, 50, 49, 40, 31, 28, 33, 40,
38, 39, 47, 48, 40, 29, 29, 32, 26, 22, 26, 30, 27, 22, 26, 29, 25, 24, 29, 30,
25, 16, 12, 10, 4, 2, 4, 7, 8, 5, 1, -6, -12, -16, -21, -25, -31, -35, -39, -46,
-51, -56, -60, -61, -63, -65, -70, -75, -81, -87, -96, -102, -102, -104, -108,
-111, -111, -108, -108, -110, -111, -108, -111, -116, -119, -119, -117, -118,
-114, -106, -101, -98, -95, -89, -85, -84, -83, -78, -73, -71, -68, -61, -53,
-46, -39, -32, -25, -17, -14, -14, -12, -9, -3, 1, 5, 12, 17, 20, 20, 22, 27,
29, 29, 29, 30, 29, 28, 26, 27, 28, 28, 30, 32, 30, 31, 28, 26, 25, 22, 21, 18,
16, 13, 12, 10, 11, 13, 14, 12, 10, 7, 4, 1, -1, -2, -4, -4, -1, 3, 7, 8, 9, 10,
10, 10, 9, 11, 14, 15, 16, 16, 17, 17, 15, 19, 22, 24, 28, 36, 42, 37, 30, 31,
31, 23, 19, 25, 34, 36, 36, 41, 46, 44, 38, 35, 33, 30, 28, 29, 33, 33, 34, 37,
37, 30, 25, 26, 27, 24, 23, 28, 28, 22, 14, 11, 7, 3, 1, 5, 9, 7, 7, 7, 2, -3,
-7, -7, -8, -12, -9, -4, -1, -3, 0, 5, 4, -1, -3, -3, -4, -6, 1, 9, 13, 16, 19,
16, 10, 5, 7, 10, 12, 16, 22, 28, 29, 27, 22, 20, 20, 20, 20, 22, 28, 30, 23,
20, 21, 22, 18, 13, 19, 25, 25, 23, 20, 19, 17, 8, 6, 5, 10, 15, 13, 14, 16, 19,
19, 11, 7, 6, 5, 6, 4, 4, 7, 10, 10, 11, 14, 21, 20, 15, 8, -1, 0, 2, 8, 14, 18,
25, 30, 23, 11, 9, 12, 13, 10, 16, 25, 23, 23, 21, 27, 31, 29, 33, 28, 15, 3, 0,
8, 14, 23, 38, 46, 44, 30, 13, 1, -4, -3, 5, 9, 15, 18, 13, 4, -2, 4, 9, 11, 10,
6, 2, -9, -18, -23, -21, -13, -4, -2, -8, -14, -20, -25, -30, -33, -35, -37,
-41, -52, -60, -63, -63, -59, -58, -58, -58, -65, -75, -88, -95, -97, -96, -93,
-91, -91, -92, -94, -96, -97, -97, -97, -97, -100, -104, -108, -107, -101, -96,
-90, -86, -81, -81, -88, -95, -96, -91, -84, -78, -72, -67, -65, -69, -73, -72,
-67, -60, -56, -52, -50, -49, -49, -48, -46, -42, -37, -33, -31, -29, -27, -24,
-18, -14, -9, -7, -4, -5, -9, -8, -3, };