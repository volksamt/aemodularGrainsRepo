#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0080

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 5, 5, 6, 8, 8, 9, 11, 13,
15, 16, 18, 20, 22, 23, 25, 26, 27, 28, 29, 30, 31, 32, 32, 33, 34, 34, 36, 37,
38, 39, 40, 42, 44, 45, 46, 48, 48, 50, 51, 53, 53, 55, 55, 57, 57, 57, 58, 58,
59, 60, 61, 62, 63, 63, 64, 64, 66, 65, 65, 66, 66, 65, 66, 65, 64, 64, 63, 62,
61, 61, 60, 62, 61, 62, 62, 63, 64, 63, 64, 64, 65, 63, 64, 64, 64, 66, 65, 65,
64, 63, 60, 58, 55, 50, 45, 39, 33, 26, 19, 13, 6, 0, -5, -9, -12, -15, -17,
-19, -21, -23, -25, -27, -30, -33, -35, -39, -42, -45, -49, -51, -54, -57, -59,
-61, -63, -64, -66, -68, -72, -74, -79, -83, -86, -91, -96, -99, -103, -107,
-109, -113, -115, -116, -117, -119, -119, -119, -118, -118, -117, -115, -115,
-113, -111, -111, -109, -107, -105, -104, -104, -102, -101, -99, -99, -97, -97,
-96, -94, -93, -91, -91, -89, -89, -87, -85, -83, -82, -81, -77, -76, -73, -70,
-68, -65, -61, -58, -53, -48, -44, -40, -34, -30, -27, -22, -20, -15, -12, -9,
-5, -2, 1, 4, 6, 8, 11, 14, 15, 18, 19, 21, 23, 24, 26, 27, 28, 28, 31, 32, 33,
35, 37, 39, 42, 43, 45, 48, 50, 51, 53, 54, 56, 57, 58, 58, 59, 59, 59, 60, 59,
58, 58, 57, 55, 54, 54, 53, 51, 48, 46, 45, 42, 41, 39, 35, 33, 32, 30, 29, 27,
24, 23, 21, 21, 18, 16, 14, 13, 10, 9, 7, 5, 4, 1, 1, -2, -3, -5, -7, -10, -12,
-14, -17, -20, -23, -27, -31, -33, -35, -39, -41, -43, -45, -46, -48, -49, -50,
-51, -52, -53, -54, -54, -55, -55, -56, -56, -57, -58, -59, -58, -58, -58, -59,
-59, -59, -59, -60, -59, -59, -59, -59, -58, -58, -58, -58, -56, -57, -55, -56,
-54, -53, -52, -52, -51, -48, -48, -46, -44, -42, -40, -38, -35, -32, -30, -27,
-25, -22, -20, -17, -15, -11, -9, -7, -5, -4, -2, 0, 2, 3, 4, 6, 7, 9, 9, 11,
12, 14, 15, 16, 18, 20, 23, 25, 28, 31, 31, 34, 37, 39, 42, 43, 45, 46, 47, 49,
51, 51, 51, 52, 53, 53, 54, 54, 54, 55, 55, 57, 56, 57, 56, 57, 57, 57, 56, 55,
54, 54, 53, 53, 52, 52, 51, 51, 51, 51, 51, 49, 50, 49, 49, 49, 47, 47, 46, 44,
44, 43, 41, 41, 39, 37, 35, 34, 32, 30, 29, 26, 26, 23, 21, 19, 18, 16, 16, 14,
14, 12, 12, 11, 11, 9, 9, 8, 8, 6, 6, 4, 2, 1, -1, -2, -4, -5, -6, -8, -8, -9,
-10, -10, -11, -11, -12, -12, -13, -13, -14, -15, -16, -16, -17, -17, -18, -19,
-19, -18, -18, -18, -17, -16, -15, -14, -13, -12, -10, -10, -9, -9, -9, -8, -8,
-8, -7, -8, -7, -6, -5, -4, -4, -2, -1, };