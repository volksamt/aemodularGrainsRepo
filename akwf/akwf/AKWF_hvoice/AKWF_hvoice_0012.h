#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 6, 8, 10, 12, 14, 15, 16, 18,
20, 21, 23, 24, 26, 28, 29, 31, 32, 33, 34, 36, 38, 40, 42, 44, 45, 47, 49, 50,
52, 54, 55, 57, 59, 61, 62, 65, 65, 67, 69, 70, 72, 74, 75, 77, 78, 81, 83, 85,
86, 89, 90, 91, 92, 94, 96, 96, 98, 99, 100, 100, 101, 101, 102, 102, 102, 103,
104, 103, 101, 98, 95, 91, 86, 84, 82, 82, 81, 80, 79, 77, 72, 68, 62, 55, 50,
46, 43, 43, 42, 41, 39, 35, 30, 24, 17, 9, 0, -8, -15, -21, -25, -28, -30, -32,
-36, -41, -47, -54, -60, -65, -70, -73, -75, -79, -79, -81, -82, -84, -85, -88,
-91, -94, -98, -103, -108, -113, -116, -119, -119, -118, -116, -115, -113, -111,
-110, -108, -107, -107, -106, -105, -103, -100, -97, -93, -89, -84, -79, -75,
-72, -70, -69, -67, -67, -65, -63, -60, -57, -52, -48, -42, -36, -30, -25, -20,
-15, -12, -10, -6, -2, 2, 7, 11, 15, 19, 23, 25, 29, 30, 30, 31, 33, 34, 37, 38,
41, 42, 46, 48, 50, 53, 54, 56, 56, 56, 57, 59, 60, 60, 62, 62, 62, 61, 60, 59,
59, 59, 58, 56, 55, 55, 54, 52, 51, 51, 51, 50, 50, 49, 48, 47, 46, 44, 44, 43,
43, 42, 41, 40, 39, 38, 38, 37, 37, 35, 34, 34, 32, 31, 30, 28, 29, 27, 27, 27,
26, 26, 24, 24, 24, 22, 22, 22, 21, 20, 20, 19, 19, 18, 18, 18, 19, 18, 17, 15,
15, 14, 11, 10, 8, 6, 2, 1, -1, -3, -4, -5, -6, -8, -8, -10, -12, -13, -16, -18,
-20, -21, -23, -24, -25, -27, -28, -30, -33, -35, -39, -42, -46, -50, -52, -55,
-57, -60, -61, -62, -64, -65, -65, -66, -68, -69, -69, -70, -69, -71, -71, -71,
-71, -72, -72, -72, -74, -74, -76, -75, -76, -75, -75, -74, -73, -72, -70, -67,
-65, -64, -61, -58, -54, -51, -49, -46, -43, -39, -37, -33, -30, -27, -25, -22,
-19, -16, -13, -10, -8, -5, -2, 1, 4, 8, 12, 16, 20, 25, 28, 31, 34, 39, 41, 44,
47, 49, 51, 53, 55, 57, 60, 61, 63, 63, 65, 65, 66, 66, 66, 67, 67, 67, 67, 68,
68, 67, 68, 68, 66, 66, 64, 63, 61, 60, 58, 55, 52, 50, 47, 45, 43, 40, 38, 36,
32, 29, 26, 23, 19, 15, 12, 9, 5, 4, 0, -2, -5, -9, -11, -15, -18, -21, -24,
-26, -29, -31, -35, -36, -38, -41, -44, -46, -48, -49, -52, -55, -56, -58, -59,
-61, -63, -63, -64, -66, -66, -66, -67, -67, -66, -67, -67, -66, -65, -65, -65,
-64, -64, -64, -64, -63, -63, -62, -61, -60, -59, -58, -58, -56, -56, -55, -53,
-52, -50, -49, -47, -44, -41, -40, -37, -37, -35, -32, -31, -29, -29, -27, -26,
-24, -24, -21, -20, -19, -18, -17, -15, -15, -13, -12, -10, -8, -7, -5, -4, -2,
0, };