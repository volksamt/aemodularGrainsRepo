#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0062

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 29, 49, 70, 95, 110, 117, 108, 89,
67, 44, 19, -15, -45, -77, -102, -116, -118, -114, -105, -92, -77, -63, -47,
-32, -14, 7, 22, 37, 42, 54, 68, 82, 91, 88, 80, 66, 54, 39, 21, 3, -13, -28,
-40, -50, -55, -56, -57, -56, -59, -59, -56, -46, -34, -19, -8, 3, 14, 24, 38,
46, 50, 49, 45, 41, 38, 33, 28, 21, 12, 3, -3, -10, -19, -32, -41, -49, -49,
-46, -43, -37, -27, -18, -8, -5, 0, 6, 16, 22, 23, 24, 22, 27, 30, 33, 30, 21,
15, 8, 5, -1, -9, -17, -24, -24, -24, -23, -22, -20, -17, -16, -16, -12, -8, -1,
3, 5, 6, 8, 16, 22, 25, 23, 20, 19, 14, 8, 3, -3, -5, -9, -11, -9, -7, -5, -7,
-13, -16, -18, -17, -15, -13, -9, -5, 1, 6, 12, 16, 18, 14, 9, 4, 2, 3, 4, 6, 7,
7, 5, 1, -2, -4, -5, -6, -11, -14, -17, -14, -11, -4, 1, 2, 1, 1, 5, 5, 4, -3,
-6, -4, 0, 8, 9, 10, 9, 7, 6, 3, -1, -5, -10, -11, -9, -6, -2, 0, 0, -1, -3, -3,
-5, -4, -4, -3, -4, -6, -7, 2, 9, 18, 16, 7, 0, -6, -1, -1, 0, -4, -4, -3, -1,
1, 2, 2, 2, -3, -7, -13, -15, -7, -2, 5, 3, 3, 0, 2, 6, 8, 7, 1, -3, -7, -5, -1,
2, 2, 0, -4, -5, -2, 0, 6, 2, -2, -10, -7, -3, 3, 5, 1, -2, -8, -2, 3, 8, 6, 2,
-3, -6, -3, 1, 5, 4, 3, -3, -4, -3, -2, 0, 2, 2, 4, 2, 1, 1, 2, 3, 1, -1, -5,
-5, -4, 0, 3, 5, 2, -1, -3, -3, -2, 0, 1, 1, 1, 0, 1, 0, 1, 2, 4, 3, 0, -1, -2,
1, 0, 0, -1, -3, -3, -1, 2, 3, 3, 0, -2, -4, -1, 0, 1, -1, -4, -3, -4, 0, 1, 4,
2, 1, -1, 1, 2, 9, 11, 8, 2, -5, -5, -3, 2, 2, -3, -9, -9, -4, 2, 8, 8, 6, 0,
-1, -4, -1, 2, 3, -1, -5, -10, -9, -2, 4, 12, 9, 6, -1, 0, 1, 4, 3, -3, -6, -7,
-1, 4, 8, 7, 4, 0, -3, -5, -5, -4, -1, 1, -1, -1, -3, -1, 0, 3, 2, 2, -4, -3,
-2, 3, 9, 9, 7, 0, -3, -5, 0, 1, 1, -4, -9, -8, -6, 1, 2, 2, 2, 3, 7, 5, 2, 0,
0, 2, 1, -2, -1, 1, 5, 4, 2, 0, 0, 1, -1, -3, -5, -6, -3, 0, 3, 2, 2, 2, 0, -1,
1, 2, 5, 6, 5, 5, 6, 7, 4, 1, -2, -3, -2, -4, -7, -8, -6, -2, 3, 8, 11, 11, 8,
4, 0, -1, -1, 1, 1, 1, -1, 1, 6, 11, 14, 7, 1, -9, -10, -9, -6, -4, -6, -4, 0,
10, 16, 19, 19, 15, 6, -6, -16, -25, -31, -36, -36, -32, -18, -3, };