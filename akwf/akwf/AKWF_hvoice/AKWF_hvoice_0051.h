#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0051

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 5, 5, 5, 6, 5, 5, 4, 5, 5, 7,
7, 8, 8, 9, 9, 9, 10, 10, 12, 14, 14, 15, 16, 17, 18, 18, 17, 18, 18, 19, 20,
20, 20, 20, 20, 20, 20, 21, 22, 24, 25, 27, 29, 29, 31, 32, 35, 35, 35, 36, 38,
40, 38, 38, 38, 41, 44, 45, 47, 48, 49, 49, 48, 47, 47, 50, 52, 57, 59, 61, 62,
62, 64, 65, 64, 63, 64, 68, 71, 74, 73, 71, 71, 72, 71, 71, 71, 73, 76, 78, 79,
76, 76, 77, 80, 82, 84, 84, 85, 87, 89, 91, 91, 89, 88, 89, 90, 89, 87, 85, 84,
86, 89, 90, 91, 94, 95, 93, 85, 76, 69, 67, 71, 75, 79, 82, 85, 89, 99, 111,
119, 117, 104, 77, 40, 7, -18, -31, -32, -26, -15, -3, 7, 12, 11, 9, 7, 6, 5, 5,
8, 13, 20, 25, 26, 23, 18, 13, 8, 3, -1, -5, -9, -12, -14, -16, -20, -24, -28,
-30, -30, -31, -32, -32, -29, -26, -24, -27, -31, -33, -32, -32, -34, -36, -36,
-35, -35, -38, -43, -47, -50, -51, -49, -48, -48, -49, -46, -44, -44, -46, -50,
-51, -50, -47, -46, -46, -45, -45, -43, -44, -46, -49, -51, -50, -49, -49, -51,
-51, -52, -51, -52, -55, -57, -56, -54, -51, -50, -49, -48, -47, -47, -47, -49,
-49, -48, -47, -45, -45, -47, -49, -48, -49, -50, -52, -53, -51, -47, -47, -47,
-47, -47, -46, -45, -45, -44, -45, -45, -44, -43, -42, -43, -43, -43, -41, -40,
-39, -40, -40, -39, -38, -38, -37, -38, -37, -36, -35, -35, -34, -34, -34, -32,
-33, -33, -32, -32, -31, -31, -31, -31, -31, -29, -27, -26, -26, -25, -24, -23,
-23, -24, -25, -24, -23, -23, -22, -22, -22, -21, -21, -21, -20, -20, -19, -20,
-21, -21, -19, -17, -16, -15, -16, -14, -14, -12, -11, -14, -14, -15, -15, -14,
-14, -14, -11, -9, -7, -7, -7, -9, -9, -9, -10, -10, -9, -9, -9, -9, -8, -7, -7,
-8, -9, -8, -8, -7, -6, -6, -5, -5, -5, -7, -8, -7, -5, -3, -3, -2, -2, -2, -2,
-2, -4, -7, -7, -6, -5, -5, -5, -4, -5, -4, -4, -6, -8, -8, -6, -4, -3, -3, -4,
-4, -4, -2, -2, -3, -2, -2, -3, -4, -5, -5, -6, -6, -5, -5, -5, -6, -6, -8, -8,
-8, -9, -9, -7, -7, -6, -4, -3, -3, -4, -5, -5, -6, -7, -8, -9, -7, -7, -7, -7,
-6, -7, -8, -9, -11, -12, -12, -11, -9, -7, -7, -6, -7, -8, -9, -10, -10, -10,
-9, -6, -5, -6, -8, -10, -11, -11, -10, -10, -8, -7, -6, -7, -8, -10, -11, -10,
-10, -10, -8, -6, -6, -5, -6, -6, -7, -7, -7, -8, -8, -8, -5, -4, -3, -2, -4,
-5, -3, -3, -4, -5, -7, -6, -5, -5, -3, -2, -1, 0, 2, 1, 0, 0, 1, 1, -1, -2, -1,
-1, 0, -1, -1, };