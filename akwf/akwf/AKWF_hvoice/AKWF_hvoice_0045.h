#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0045

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 9, 16, 18, 22, 21, 22, 25, 26, 31,
39, 46, 44, 43, 41, 32, 27, 22, 22, 28, 32, 33, 33, 28, 25, 18, 13, 21, 26, 30,
37, 36, 36, 34, 26, 26, 28, 35, 38, 38, 40, 41, 38, 43, 52, 61, 80, 91, 93, 93,
86, 82, 85, 96, 109, 119, 115, 99, 77, 59, 50, 44, 41, 40, 35, 25, 12, -3, -20,
-35, -47, -52, -49, -45, -46, -53, -63, -77, -88, -95, -97, -95, -89, -86, -87,
-93, -103, -112, -117, -115, -107, -97, -91, -90, -92, -91, -89, -85, -79, -72,
-62, -53, -44, -39, -39, -39, -40, -39, -34, -28, -24, -23, -25, -29, -33, -38,
-42, -43, -40, -37, -37, -39, -42, -46, -46, -45, -42, -41, -40, -40, -42, -40,
-39, -37, -37, -36, -37, -35, -34, -34, -34, -30, -29, -24, -17, -13, -9, -6,
-5, -2, 2, 7, 13, 19, 27, 32, 36, 38, 38, 38, 42, 43, 46, 47, 47, 46, 46, 44,
44, 44, 41, 38, 36, 35, 32, 29, 27, 26, 22, 19, 16, 15, 14, 11, 9, 8, 6, 5, 5,
6, 5, 5, 5, 6, 8, 10, 11, 12, 15, 15, 18, 21, 24, 28, 30, 33, 31, 29, 28, 27,
25, 25, 23, 24, 22, 18, 17, 15, 14, 13, 12, 12, 14, 14, 15, 15, 14, 13, 12, 10,
7, 6, 5, 2, -2, -6, -10, -13, -17, -21, -23, -25, -27, -30, -28, -28, -28, -28,
-28, -24, -20, -19, -14, -8, -6, -6, -4, -1, 3, 5, 8, 12, 14, 13, 14, 17, 18,
18, 22, 24, 24, 25, 28, 29, 31, 31, 30, 33, 35, 35, 38, 42, 38, 38, 37, 34, 37,
42, 49, 59, 68, 71, 65, 59, 51, 48, 55, 62, 73, 76, 70, 58, 43, 32, 27, 27, 33,
41, 45, 46, 44, 37, 30, 23, 17, 21, 25, 30, 35, 31, 24, 10, -6, -19, -26, -29,
-26, -25, -28, -38, -51, -64, -73, -75, -73, -71, -66, -63, -63, -66, -71, -75,
-75, -73, -69, -64, -60, -60, -62, -65, -65, -65, -66, -66, -64, -64, -61, -57,
-53, -50, -49, -46, -42, -40, -38, -38, -35, -33, -32, -28, -26, -26, -29, -33,
-37, -41, -44, -44, -40, -37, -36, -38, -42, -46, -48, -47, -41, -34, -30, -28,
-29, -31, -32, -32, -29, -25, -20, -17, -14, -12, -13, -13, -13, -11, -7, -2, 6,
12, 17, 21, 23, 23, 22, 24, 30, 35, 41, 43, 44, 41, 35, 32, 30, 30, 29, 30, 29,
26, 25, 23, 24, 23, 23, 25, 25, 25, 26, 29, 31, 32, 31, 31, 32, 30, 32, 32, 34,
34, 32, 28, 24, 22, 21, 21, 20, 20, 18, 18, 17, 19, 22, 26, 27, 30, 33, 37, 39,
41, 41, 39, 36, 30, 26, 23, 20, 16, 12, 5, -4, -11, -18, -22, -24, -25, -25,
-27, -29, -30, -31, -32, -33, -32, -30, -29, -26, -23, -22, -22, -22, -25, -25,
-24, -22, -17, -14, -11, -11, -11, -13, -12, -9, -3, };