#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0085

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 3, 4, 5, 6, 7, 8, 9, 10, 12, 12,
13, 15, 16, 17, 18, 19, 20, 21, 22, 24, 24, 26, 28, 29, 29, 30, 33, 33, 34, 36,
36, 38, 39, 40, 42, 43, 44, 45, 45, 48, 48, 49, 51, 52, 54, 55, 56, 57, 59, 61,
60, 63, 63, 65, 67, 68, 69, 71, 72, 73, 75, 77, 78, 79, 81, 82, 84, 86, 87, 88,
90, 92, 94, 94, 95, 98, 99, 100, 101, 103, 104, 105, 106, 108, 109, 110, 110,
112, 113, 114, 114, 115, 116, 117, 117, 118, 119, 119, 118, 118, 119, 119, 119,
119, 118, 119, 118, 117, 117, 117, 116, 114, 114, 113, 111, 110, 109, 107, 106,
104, 102, 101, 99, 97, 95, 92, 90, 87, 86, 83, 80, 78, 75, 72, 70, 67, 64, 62,
59, 56, 53, 50, 47, 44, 41, 38, 35, 32, 28, 25, 22, 19, 15, 12, 10, 6, 3, 1, -3,
-5, -8, -11, -15, -17, -19, -23, -25, -28, -30, -34, -36, -38, -41, -42, -44,
-47, -49, -51, -53, -55, -57, -59, -60, -63, -65, -65, -67, -69, -71, -72, -73,
-74, -75, -77, -77, -79, -80, -80, -81, -81, -82, -84, -85, -85, -85, -86, -86,
-87, -87, -88, -89, -89, -89, -89, -88, -90, -90, -89, -90, -89, -89, -90, -89,
-90, -90, -90, -90, -90, -89, -89, -89, -89, -89, -87, -87, -88, -87, -88, -86,
-87, -86, -85, -85, -84, -84, -84, -83, -83, -82, -81, -81, -80, -79, -79, -78,
-77, -77, -76, -74, -74, -72, -72, -72, -70, -69, -68, -67, -65, -65, -64, -62,
-61, -60, -59, -58, -56, -56, -54, -53, -51, -50, -48, -47, -46, -44, -42, -41,
-40, -38, -37, -34, -33, -32, -30, -29, -26, -25, -23, -22, -21, -19, -17, -17,
-15, -14, -11, -9, -9, -7, -6, -5, -3, -2, 0, 1, 2, 4, 5, 7, 7, 9, 9, 10, 11,
13, 13, 14, 15, 16, 16, 18, 18, 20, 19, 20, 21, 22, 22, 23, 22, 24, 23, 23, 24,
24, 24, 24, 25, 24, 24, 24, 24, 24, 24, 23, 24, 24, 23, 23, 22, 22, 21, 21, 21,
21, 20, 20, 19, 18, 18, 18, 17, 16, 16, 15, 15, 13, 12, 11, 11, 10, 9, 8, 9, 7,
6, 5, 5, 4, 3, 2, 2, 1, 0, -1, -2, -3, -3, -5, -5, -6, -7, -8, -8, -9, -10, -11,
-12, -13, -14, -15, -15, -16, -17, -18, -18, -19, -20, -20, -22, -22, -22, -24,
-24, -25, -26, -26, -27, -27, -28, -28, -28, -28, -29, -30, -31, -31, -32, -31,
-32, -33, -33, -34, -33, -34, -33, -34, -35, -34, -35, -35, -35, -35, -34, -35,
-35, -34, -34, -35, -35, -33, -34, -34, -33, -33, -32, -32, -31, -31, -31, -31,
-30, -31, -30, -28, -28, -28, -27, -27, -26, -25, -24, -24, -24, -22, -22, -21,
-20, -19, -19, -18, -16, -16, -15, -14, -14, -12, -12, -11, -10, -9, -9, -7, -7,
-6, -4, -3, -2, -1, 0, };