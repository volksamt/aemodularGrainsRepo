#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0057

const PROGMEM int8_t DATA[DATA_LENGTH] = {13, 38, 55, 77, 94, 107, 119, 116,
114, 95, 75, 48, 11, -17, -55, -78, -102, -115, -115, -114, -98, -84, -63, -42,
-25, -6, 1, 7, 5, -2, -9, -23, -32, -43, -49, -50, -48, -32, -18, 7, 34, 55, 80,
91, 103, 104, 101, 93, 75, 59, 35, 14, -7, -26, -37, -50, -49, -47, -38, -25,
-15, -5, 0, 1, 0, -8, -15, -25, -35, -46, -56, -63, -70, -67, -63, -52, -36,
-20, 3, 19, 39, 52, 61, 67, 63, 59, 50, 41, 29, 17, 7, -4, -9, -13, -11, -3, 3,
14, 20, 24, 26, 21, 16, 7, -5, -15, -28, -37, -48, -53, -58, -58, -52, -45, -31,
-18, -3, 11, 19, 27, 29, 31, 28, 23, 19, 9, 3, -3, -8, -10, -10, -7, -3, 8, 18,
28, 38, 40, 42, 37, 27, 20, 9, 0, -12, -21, -31, -38, -40, -43, -40, -37, -27,
-16, -7, 5, 11, 14, 13, 8, 3, -2, -7, -11, -14, -16, -18, -17, -16, -11, -5, 2,
13, 21, 32, 37, 39, 40, 32, 27, 16, 9, 0, -10, -15, -19, -20, -21, -20, -17,
-14, -9, -4, 1, 5, 6, 8, 5, 1, -5, -12, -17, -23, -25, -26, -23, -18, -13, -6,
0, 5, 11, 17, 22, 24, 29, 25, 20, 14, 4, -1, -8, -10, -9, -9, -8, -6, -3, -1, 1,
5, 7, 8, 8, 8, 6, 0, -4, -13, -17, -23, -26, -24, -24, -19, -15, -10, -4, -1, 2,
6, 9, 11, 14, 13, 10, 7, 1, -2, -5, -7, -6, -6, -3, 0, 2, 6, 8, 10, 11, 11, 10,
8, 7, 4, 0, -5, -10, -13, -16, -17, -17, -15, -13, -9, -7, -4, -1, 1, 3, 3, 5,
5, 5, 4, 2, -1, -4, -6, -6, -6, -3, 1, 5, 8, 9, 9, 8, 9, 8, 9, 8, 7, 4, 1, -5,
-8, -11, -12, -10, -9, -7, -5, -3, -1, 1, 3, 4, 6, 6, 5, 4, 0, -1, -4, -7, -6,
-7, -5, -5, -4, -2, 1, 5, 7, 10, 11, 11, 10, 8, 6, 3, 0, -2, -4, -6, -8, -7, -8,
-6, -3, -1, 3, 3, 3, 3, 2, 1, 1, 0, -2, -4, -5, -6, -5, -4, -2, 0, 2, 6, 7, 9,
10, 9, 9, 6, 5, 1, 0, -2, -5, -5, -6, -3, -1, 1, 2, 3, 4, 4, 5, 6, 4, 3, 1, -2,
-3, -5, -6, -8, -8, -6, -5, 0, 3, 6, 8, 8, 9, 8, 6, 6, 5, 3, -1, -4, -7, -9, -9,
-8, -5, -4, -2, 1, 3, 7, 7, 8, 6, 5, 4, 2, 1, -1, -2, -5, -5, -6, -5, -3, 0, 3,
6, 7, 10, 10, 9, 7, 5, 3, 2, 2, 0, -2, -5, -7, -7, -8, -5, -3, 0, 4, 6, 8, 8, 8,
8, 6, 6, 6, 5, 4, 4, 4, 2, 2, 1, 1, 2, 3, 5, 5, 4, 4, 4, 3, 4, 5, 6, 5, 3, 1,
-1, -6, -10, -16, -20, -25, -25, -21, -15, -3, };