#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 8, 10, 12, 15, 17, 18, 20,
21, 23, 24, 26, 27, 30, 32, 34, 36, 37, 39, 41, 42, 44, 44, 45, 45, 46, 46, 47,
46, 46, 48, 49, 49, 50, 51, 53, 56, 58, 62, 65, 68, 73, 76, 80, 84, 86, 89, 91,
92, 94, 94, 96, 97, 97, 99, 99, 100, 101, 102, 104, 106, 108, 109, 110, 110,
112, 112, 113, 114, 115, 116, 116, 117, 117, 118, 118, 119, 119, 118, 119, 119,
118, 118, 117, 115, 113, 109, 105, 100, 93, 87, 80, 73, 67, 60, 55, 51, 48, 46,
45, 45, 44, 45, 47, 47, 47, 48, 49, 48, 49, 48, 48, 46, 45, 44, 42, 40, 38, 36,
34, 32, 29, 28, 24, 21, 18, 13, 10, 4, 0, -6, -10, -15, -20, -23, -28, -29, -31,
-32, -33, -34, -33, -33, -34, -34, -36, -36, -37, -39, -41, -42, -44, -46, -48,
-50, -53, -54, -57, -59, -61, -63, -65, -67, -67, -68, -68, -67, -68, -66, -65,
-64, -65, -64, -64, -63, -64, -65, -66, -69, -70, -73, -77, -80, -84, -86, -89,
-91, -93, -94, -95, -94, -92, -91, -88, -85, -82, -79, -77, -74, -70, -67, -65,
-61, -59, -55, -53, -51, -48, -47, -45, -45, -44, -44, -45, -45, -45, -46, -47,
-48, -50, -51, -53, -55, -57, -59, -61, -61, -61, -62, -61, -59, -57, -55, -52,
-49, -46, -44, -40, -39, -37, -37, -36, -36, -36, -37, -37, -37, -36, -36, -35,
-34, -33, -31, -29, -26, -24, -19, -16, -12, -9, -6, -3, -1, 2, 4, 6, 7, 9, 10,
12, 15, 16, 17, 19, 20, 20, 21, 21, 21, 21, 21, 20, 22, 22, 22, 24, 27, 28, 31,
34, 36, 40, 41, 44, 45, 47, 48, 49, 49, 49, 50, 49, 51, 51, 50, 50, 51, 51, 51,
51, 51, 51, 52, 53, 54, 55, 57, 58, 58, 60, 61, 61, 64, 65, 66, 68, 69, 70, 71,
72, 72, 71, 72, 71, 69, 70, 67, 66, 64, 63, 61, 61, 59, 59, 58, 59, 58, 59, 59,
60, 60, 60, 61, 61, 61, 61, 62, 61, 61, 60, 59, 58, 56, 56, 54, 52, 50, 48, 47,
45, 43, 42, 40, 38, 37, 35, 32, 30, 28, 25, 24, 21, 18, 15, 13, 9, 7, 6, 4, 2,
0, -3, -4, -7, -9, -11, -15, -18, -20, -23, -26, -29, -31, -34, -36, -37, -39,
-41, -44, -46, -47, -48, -51, -54, -56, -58, -61, -63, -66, -67, -69, -70, -72,
-73, -75, -76, -77, -77, -79, -79, -81, -81, -82, -84, -83, -84, -85, -85, -86,
-85, -86, -85, -86, -87, -88, -89, -93, -94, -97, -99, -102, -103, -105, -106,
-107, -106, -106, -105, -103, -102, -99, -96, -95, -91, -90, -87, -86, -84, -83,
-81, -80, -76, -75, -71, -68, -65, -62, -59, -57, -55, -53, -52, -52, -51, -51,
-50, -50, -48, -46, -43, -41, -38, -35, -31, -30, -27, -24, -22, -21, -19, -18,
-15, -14, -12, -11, -10, -8, -5, -4, -1, };