#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 9, 9, 6, 4, 2, 2, 4, 8, 13,
15, 14, 11, 8, 5, 4, 6, 9, 13, 16, 17, 18, 15, 12, 10, 8, 10, 12, 16, 20, 22,
21, 17, 13, 11, 11, 13, 17, 20, 23, 22, 19, 15, 12, 12, 14, 18, 21, 24, 23, 20,
18, 16, 15, 16, 16, 17, 18, 20, 22, 24, 24, 23, 20, 19, 19, 20, 21, 23, 23, 24,
25, 26, 28, 29, 30, 29, 28, 28, 28, 29, 31, 33, 34, 35, 36, 38, 40, 42, 43, 43,
41, 39, 37, 39, 44, 52, 58, 61, 58, 53, 44, 40, 42, 48, 58, 67, 70, 70, 64, 55,
50, 47, 51, 59, 66, 73, 73, 68, 62, 55, 53, 57, 62, 69, 69, 65, 58, 54, 51, 54,
60, 64, 64, 61, 57, 51, 46, 43, 39, 38, 37, 40, 47, 53, 53, 48, 35, 23, 20, 23,
34, 46, 41, 20, -9, -42, -54, -37, -8, 25, 43, 21, -19, -64, -100, -99, -75,
-47, -23, -22, -43, -70, -95, -107, -102, -91, -82, -77, -83, -94, -103, -111,
-112, -108, -102, -97, -95, -96, -101, -110, -115, -119, -116, -105, -91, -79,
-73, -78, -89, -101, -108, -105, -91, -74, -56, -47, -48, -55, -65, -71, -70,
-63, -52, -39, -29, -22, -21, -23, -28, -33, -33, -27, -18, -5, 4, 8, 7, 0, -7,
-7, -5, 4, 14, 20, 21, 16, 8, 5, 4, 7, 16, 22, 24, 22, 14, 7, 2, 0, 4, 10, 15,
16, 13, 6, -2, -8, -11, -9, -7, -4, -2, -4, -10, -15, -21, -21, -21, -18, -16,
-18, -22, -27, -32, -31, -28, -24, -23, -25, -30, -33, -35, -34, -32, -29, -28,
-27, -26, -27, -27, -27, -26, -25, -24, -22, -20, -19, -19, -19, -19, -16, -14,
-9, -4, -1, 0, -1, -5, -7, -8, -5, 3, 9, 14, 16, 15, 13, 12, 11, 11, 13, 14, 17,
20, 23, 24, 24, 23, 22, 22, 23, 24, 24, 24, 23, 19, 18, 18, 20, 24, 26, 27, 25,
20, 15, 10, 8, 11, 15, 20, 22, 20, 15, 9, 3, 0, 1, 3, 8, 8, 6, 4, 0, -2, -4, -5,
-5, -5, -5, -3, -3, -1, -4, -8, -11, -14, -12, -8, -5, -2, -4, -9, -12, -14,
-14, -10, -9, -7, -6, -8, -9, -9, -8, -8, -7, -6, -4, -3, -3, -4, -5, -6, -5,
-4, -2, -1, 1, 0, 2, 3, 4, 4, 2, 1, 2, 3, 4, 5, 6, 5, 6, 7, 7, 8, 5, 3, -1, 0,
1, 4, 9, 12, 10, 8, 2, -3, -6, -7, -4, 0, 5, 7, 9, 4, -1, -8, -13, -13, -11, -4,
0, 2, 0, -5, -11, -12, -12, -10, -6, -6, -8, -12, -14, -15, -12, -9, -5, -5, -7,
-12, -15, -17, -17, -14, -11, -7, -7, -6, -6, -8, -10, -13, -14, -13, -13, -9,
-5, -3, 0, -2, -5, -7, -11, -9, -5, -1, 1, 1, -2, -5, -5, -4, 0, 3, 5, 3, 1, -2,
-3, -2, };