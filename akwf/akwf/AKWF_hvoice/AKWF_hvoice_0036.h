#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0036

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 9, 12, 15, 16, 17, 16, 16, 17,
21, 22, 24, 23, 22, 21, 19, 19, 21, 24, 27, 28, 28, 26, 24, 22, 21, 22, 22, 22,
21, 20, 18, 18, 19, 22, 26, 28, 32, 35, 39, 42, 46, 49, 55, 60, 63, 70, 74, 82,
89, 97, 103, 109, 111, 113, 114, 115, 117, 118, 119, 118, 116, 113, 110, 108,
108, 108, 109, 108, 104, 97, 90, 83, 75, 70, 66, 60, 54, 46, 38, 31, 24, 18, 12,
8, 4, 0, -4, -9, -11, -14, -15, -15, -14, -15, -15, -16, -17, -18, -22, -24,
-24, -26, -24, -23, -22, -19, -17, -14, -13, -12, -11, -12, -11, -11, -9, -9,
-9, -10, -9, -9, -9, -9, -10, -10, -10, -12, -14, -16, -19, -20, -20, -19, -17,
-15, -15, -14, -14, -12, -10, -9, -6, -3, 1, 5, 8, 11, 14, 17, 19, 24, 25, 29,
30, 31, 33, 35, 36, 39, 42, 44, 46, 47, 49, 49, 48, 47, 44, 42, 37, 33, 29, 25,
20, 15, 9, 3, -2, -6, -11, -15, -20, -23, -28, -32, -36, -39, -43, -45, -48,
-50, -52, -55, -58, -60, -63, -64, -65, -64, -64, -63, -62, -61, -59, -58, -56,
-53, -50, -48, -45, -42, -40, -38, -36, -35, -32, -30, -28, -25, -24, -23, -22,
-22, -22, -20, -21, -20, -21, -21, -20, -19, -19, -19, -18, -17, -16, -15, -13,
-12, -12, -12, -11, -10, -9, -8, -7, -6, -5, -4, -1, 1, 4, 6, 9, 13, 16, 19, 23,
25, 27, 27, 29, 30, 31, 31, 30, 29, 26, 24, 22, 21, 19, 18, 16, 14, 12, 7, 5, 0,
-3, -7, -11, -14, -18, -23, -28, -32, -36, -39, -41, -44, -46, -48, -51, -53,
-55, -56, -58, -58, -58, -56, -56, -55, -55, -54, -53, -51, -49, -47, -43, -41,
-39, -37, -34, -32, -30, -27, -25, -22, -22, -19, -18, -17, -15, -15, -13, -11,
-9, -8, -7, -6, -5, -6, -4, -4, -3, -3, -4, -3, -3, -3, -3, -1, -2, 1, 3, 5, 6,
8, 11, 14, 15, 18, 21, 23, 24, 27, 28, 30, 31, 32, 33, 33, 34, 35, 36, 36, 36,
37, 37, 36, 34, 31, 29, 26, 23, 20, 16, 13, 8, 5, 0, -4, -8, -13, -17, -19, -22,
-26, -29, -32, -36, -39, -41, -43, -44, -45, -47, -47, -48, -49, -48, -47, -45,
-43, -42, -40, -39, -36, -34, -31, -29, -26, -23, -20, -18, -16, -14, -10, -8,
-5, -4, -2, 0, 0, 1, 2, 4, 4, 4, 4, 3, 2, 0, -1, -1, -2, -2, -2, -3, -4, -5, -5,
-5, -6, -6, -6, -7, -9, -9, -10, -9, -9, -9, -9, -8, -9, -8, -9, -7, -6, -5, -3,
-3, -2, -3, -4, -6, -5, -5, -6, -6, -8, -9, -11, -14, -15, -15, -16, -17, -18,
-19, -21, -22, -24, -25, -28, -28, -28, -29, -29, -29, -30, -31, -33, -32, -31,
-29, -27, -25, -22, -19, -18, -17, -15, -13, -11, -7, -5, -2, -1, };