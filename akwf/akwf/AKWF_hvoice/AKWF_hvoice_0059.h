#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0059

const PROGMEM int8_t DATA[DATA_LENGTH] = {14, 38, 59, 80, 99, 113, 120, 117,
103, 83, 58, 31, 4, -21, -38, -49, -53, -52, -47, -39, -29, -19, -13, -15, -21,
-34, -46, -59, -71, -80, -84, -83, -75, -62, -46, -29, -11, 4, 18, 23, 25, 23,
19, 16, 12, 10, 11, 13, 20, 29, 39, 49, 56, 60, 59, 55, 48, 36, 26, 13, 3, -6,
-13, -17, -17, -16, -11, -10, -9, -11, -14, -19, -24, -31, -38, -45, -49, -51,
-49, -46, -40, -32, -22, -14, -9, -5, -2, 1, 2, 2, 2, 0, -1, 3, 8, 13, 18, 24,
28, 32, 34, 34, 33, 30, 27, 21, 16, 11, 7, 5, 4, 3, 2, 0, 0, -1, -4, -6, -10,
-13, -16, -20, -23, -25, -25, -24, -23, -22, -21, -19, -17, -14, -12, -8, -7,
-4, -5, -6, -3, -2, 2, 3, 5, 9, 11, 12, 14, 17, 17, 19, 17, 14, 11, 9, 9, 7, 6,
7, 7, 5, 4, 2, 3, 2, 1, -2, -5, -8, -12, -13, -13, -14, -13, -14, -12, -12, -11,
-10, -10, -10, -9, -9, -9, -9, -8, -6, -3, -1, 0, 2, 3, 5, 5, 6, 7, 8, 8, 7, 6,
7, 6, 7, 8, 7, 7, 5, 2, 1, 2, 3, 5, 3, 0, -2, -4, -4, -3, -3, -3, -6, -6, -8,
-8, -7, -7, -4, -5, -7, -9, -8, -7, -4, -2, -2, -3, -5, -5, -5, -2, 0, 0, 0, 0,
0, 1, 2, 3, 4, 3, 3, 2, 2, 4, 5, 4, 3, 3, 3, 3, 3, 3, 2, 1, 1, 0, 0, -1, -1, -1,
-2, -2, -2, -3, -4, -4, -4, -5, -5, -5, -5, -4, -3, -1, 1, 0, -1, 0, 0, 2, 1, 0,
-1, -2, -2, -1, 0, 1, 0, 1, 0, 1, 2, 2, 3, 5, 5, 3, 1, 0, 0, 1, 1, 1, 0, -1, -1,
-1, 0, 2, 2, 1, -1, -1, -1, -1, -2, -2, -2, -2, -1, -2, -1, -1, 1, 2, 1, 1, 1,
2, 1, 1, 0, 1, 2, 3, 4, 3, 1, 1, 2, 5, 4, 3, 1, 0, 0, 1, 1, 2, 3, 2, 2, 2, 1, 1,
2, 1, 0, -3, -5, -5, -2, -1, 1, 2, -1, 0, 1, 2, 1, 2, 1, 0, -2, -1, -2, -1, -1,
0, 1, 0, 0, 0, 3, 4, 5, 3, 0, -1, -2, -1, 1, 2, -1, -1, -1, 0, 1, 3, 3, 3, 1,
-2, -3, -2, -2, -2, -2, -3, -4, -5, -4, -2, 1, 2, 4, 3, 0, -1, 0, 2, 3, 3, 2, 1,
0, 1, 0, 2, 3, 4, 3, 2, 1, 1, 3, 3, 4, 2, 0, -1, -1, -1, 0, 2, 3, 2, 2, 3, 4, 6,
4, 3, 3, 1, 0, 1, 0, 1, 0, 2, 3, 4, 5, 6, 6, 6, 5, 5, 4, 5, 5, 5, 3, 2, 1, 2, 2,
1, 0, -2, -3, -2, -1, 1, 1, 4, 4, 6, 6, 6, 4, 1, -4, -13, -21, -27, -31, -31,
-26, -15, -2, };