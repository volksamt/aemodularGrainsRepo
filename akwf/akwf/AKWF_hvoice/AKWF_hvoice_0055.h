#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0055

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 3, 2, 3, 6, 7, 4, 1, 2, 4, 7, 5,
5, 6, 5, 5, 5, 5, 8, 11, 12, 9, 6, 3, 3, 8, 11, 13, 17, 19, 16, 11, 8, 8, 13,
17, 18, 17, 15, 15, 14, 13, 14, 19, 25, 26, 22, 18, 17, 19, 24, 26, 25, 23, 27,
31, 32, 27, 25, 27, 33, 36, 31, 28, 30, 38, 40, 35, 33, 36, 43, 44, 38, 36, 39,
45, 45, 40, 37, 41, 52, 58, 56, 51, 49, 55, 59, 58, 51, 49, 54, 59, 59, 52, 49,
55, 63, 65, 59, 54, 56, 61, 62, 57, 56, 64, 72, 72, 64, 60, 65, 74, 75, 70, 65,
66, 69, 67, 60, 56, 61, 69, 72, 70, 72, 76, 78, 68, 52, 40, 40, 49, 60, 67, 72,
72, 68, 62, 69, 89, 113, 117, 89, 32, -29, -71, -79, -57, -25, 4, 19, 19, 9, -3,
-3, 17, 48, 76, 81, 63, 32, 3, -15, -21, -17, -6, 8, 14, 1, -20, -38, -41, -31,
-18, -7, 1, 8, 9, -3, -20, -27, -20, -6, 0, -3, -13, -18, -25, -35, -45, -43,
-30, -17, -15, -26, -37, -39, -35, -31, -33, -34, -27, -22, -25, -35, -44, -44,
-37, -31, -31, -34, -33, -32, -36, -42, -43, -39, -32, -31, -35, -39, -40, -41,
-43, -44, -43, -35, -32, -34, -40, -44, -43, -40, -39, -40, -37, -34, -33, -37,
-43, -42, -36, -31, -33, -40, -41, -38, -36, -38, -45, -44, -39, -34, -37, -43,
-43, -38, -34, -36, -42, -39, -33, -28, -30, -35, -38, -37, -35, -36, -36, -34,
-31, -28, -29, -33, -36, -36, -35, -32, -30, -31, -31, -30, -29, -29, -30, -28,
-27, -27, -27, -26, -25, -26, -28, -27, -26, -23, -25, -25, -24, -21, -22, -22,
-25, -25, -23, -24, -24, -23, -21, -18, -16, -15, -15, -16, -17, -19, -19, -18,
-18, -18, -18, -15, -13, -14, -17, -18, -15, -13, -12, -13, -13, -14, -12, -11,
-11, -12, -13, -10, -6, -7, -9, -12, -13, -9, -9, -10, -11, -10, -6, -4, -4, -7,
-10, -11, -8, -8, -6, -3, -1, -2, -5, -9, -10, -8, -8, -7, -6, -2, -2, -4, -7,
-8, -4, -2, -2, -2, -2, -1, -2, -6, -9, -7, -4, -2, -3, -3, -3, -3, -3, -4, -4,
-4, -2, -2, -3, -4, -5, -4, -5, -4, -3, -4, -7, -9, -7, -4, -3, -5, -6, -5, -3,
-4, -5, -6, -7, -8, -8, -7, -3, 0, 0, -3, -8, -9, -8, -5, -4, -4, -5, -7, -7,
-7, -6, -5, -5, -5, -6, -9, -11, -10, -8, -5, -3, -3, -4, -4, -7, -7, -7, -6,
-6, -8, -9, -9, -9, -9, -8, -8, -8, -7, -5, -4, -6, -8, -8, -6, -5, -7, -9, -9,
-6, -3, -4, -6, -7, -5, -2, -6, -8, -7, -3, -2, -7, -9, -8, -3, -3, -4, -4, -3,
-2, -5, -8, -7, -2, 3, 5, 1, -1, -1, 1, -1, -6, -6, -1, 4, 5, 1, -2, -1, };