#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 5, 5, 6, 6, 5, 5, 4, 6, 6, 7, 8,
8, 9, 10, 10, 11, 11, 13, 15, 17, 20, 22, 25, 28, 31, 34, 37, 39, 41, 43, 45,
49, 51, 55, 59, 61, 65, 66, 68, 72, 75, 79, 83, 88, 93, 98, 102, 106, 108, 110,
113, 115, 117, 119, 120, 118, 116, 113, 108, 102, 97, 92, 88, 85, 83, 81, 81,
81, 82, 84, 87, 91, 95, 99, 102, 104, 104, 103, 100, 96, 94, 92, 90, 90, 90, 90,
89, 89, 86, 83, 79, 75, 71, 67, 62, 59, 54, 50, 46, 42, 39, 36, 34, 32, 31, 31,
31, 31, 32, 34, 35, 35, 36, 35, 35, 34, 32, 30, 29, 26, 23, 22, 20, 19, 18, 18,
19, 20, 22, 22, 20, 18, 16, 11, 6, 2, -4, -9, -14, -16, -18, -19, -19, -20, -19,
-18, -18, -18, -18, -18, -18, -18, -18, -18, -19, -20, -22, -23, -24, -26, -26,
-27, -27, -25, -24, -23, -20, -18, -14, -11, -9, -7, -6, -6, -7, -10, -13, -16,
-20, -21, -22, -22, -22, -20, -19, -19, -19, -21, -23, -26, -29, -32, -36, -39,
-42, -44, -45, -46, -45, -44, -41, -37, -31, -25, -20, -15, -12, -11, -12, -13,
-16, -19, -24, -28, -33, -37, -41, -46, -50, -53, -56, -59, -61, -64, -67, -69,
-70, -73, -75, -77, -78, -79, -81, -80, -79, -77, -75, -71, -68, -65, -61, -58,
-54, -51, -49, -47, -47, -46, -48, -49, -52, -55, -57, -60, -62, -64, -67, -70,
-73, -74, -76, -76, -76, -77, -78, -77, -78, -78, -77, -77, -75, -73, -70, -65,
-62, -56, -51, -46, -40, -36, -31, -26, -22, -20, -19, -19, -20, -22, -24, -26,
-27, -29, -30, -30, -31, -30, -29, -27, -25, -21, -17, -14, -9, -6, -3, -2, 1,
2, 2, 4, 5, 7, 9, 10, 13, 15, 17, 18, 20, 20, 20, 20, 18, 19, 17, 16, 16, 16,
16, 15, 16, 17, 17, 19, 20, 22, 25, 27, 28, 30, 31, 31, 31, 31, 29, 27, 27, 25,
24, 24, 23, 23, 22, 22, 22, 22, 23, 23, 21, 20, 17, 16, 13, 10, 8, 6, 6, 5, 5,
6, 6, 6, 7, 6, 6, 6, 5, 5, 5, 5, 5, 6, 7, 9, 8, 9, 8, 7, 5, 2, -2, -5, -8, -12,
-15, -18, -20, -21, -23, -25, -25, -27, -28, -29, -30, -29, -29, -27, -25, -22,
-21, -19, -17, -15, -13, -12, -12, -12, -14, -16, -19, -22, -24, -26, -26, -25,
-25, -24, -23, -22, -23, -22, -21, -20, -18, -17, -15, -14, -13, -13, -14, -14,
-14, -15, -15, -16, -16, -17, -18, -19, -20, -19, -21, -19, -18, -18, -17, -16,
-18, -20, -20, -20, -20, -19, -17, -15, -11, -8, -7, -5, -6, -6, -8, -9, -11,
-11, -14, -14, -14, -15, -15, -14, -15, -14, -14, -15, -15, -16, -19, -19, -21,
-21, -20, -19, -17, -15, -14, -13, -12, -13, -12, -12, -12, -11, -11, -10, -7,
-5, -2, 0, };