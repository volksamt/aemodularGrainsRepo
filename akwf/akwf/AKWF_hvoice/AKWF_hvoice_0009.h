#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 5, 6, 7, 8, 10, 10, 12, 14,
15, 16, 18, 19, 20, 21, 22, 25, 26, 29, 30, 33, 37, 38, 41, 42, 46, 48, 50, 54,
56, 60, 61, 65, 69, 71, 74, 77, 80, 83, 88, 90, 93, 94, 95, 98, 101, 104, 106,
108, 110, 112, 114, 116, 118, 118, 119, 118, 119, 118, 117, 113, 107, 100, 93,
85, 77, 69, 60, 53, 45, 38, 32, 28, 24, 20, 17, 15, 12, 9, 6, 3, 1, 1, 2, 1, 3,
3, 2, 1, 0, -3, -3, -5, -4, -6, -7, -9, -11, -13, -15, -16, -17, -21, -21, -22,
-23, -25, -25, -26, -27, -25, -25, -26, -27, -30, -33, -37, -40, -44, -47, -50,
-52, -57, -59, -63, -66, -68, -71, -73, -75, -76, -79, -81, -83, -87, -90, -92,
-93, -94, -95, -94, -94, -95, -93, -91, -88, -84, -79, -74, -71, -66, -63, -60,
-56, -52, -47, -41, -36, -32, -28, -25, -23, -22, -19, -17, -13, -12, -10, -8,
-8, -7, -7, -5, -4, -3, 0, 1, 2, 4, 6, 8, 10, 13, 17, 18, 22, 22, 23, 24, 24,
23, 24, 25, 25, 27, 27, 28, 29, 30, 31, 34, 37, 39, 40, 43, 44, 46, 47, 49, 50,
52, 53, 56, 57, 58, 61, 63, 65, 67, 69, 71, 72, 74, 73, 73, 74, 72, 72, 71, 70,
68, 66, 64, 61, 59, 55, 53, 49, 46, 43, 39, 36, 32, 29, 25, 22, 19, 17, 14, 12,
10, 8, 7, 6, 6, 5, 5, 5, 5, 4, 3, 1, -1, -2, -5, -7, -9, -11, -14, -16, -19,
-22, -24, -26, -28, -29, -29, -32, -34, -36, -37, -38, -39, -41, -43, -45, -47,
-48, -49, -50, -52, -53, -54, -55, -57, -59, -61, -62, -64, -65, -66, -68, -68,
-69, -69, -70, -69, -70, -69, -68, -66, -65, -64, -62, -60, -58, -56, -54, -53,
-50, -47, -46, -44, -42, -39, -36, -34, -31, -29, -27, -25, -23, -22, -21, -21,
-19, -19, -19, -18, -18, -18, -17, -18, -17, -17, -15, -14, -12, -9, -8, -6, -4,
-2, 1, 3, 5, 6, 7, 10, 12, 13, 16, 18, 20, 22, 23, 24, 26, 29, 29, 31, 33, 34,
35, 37, 37, 39, 38, 40, 41, 43, 43, 44, 46, 46, 47, 48, 48, 48, 48, 47, 47, 45,
45, 44, 42, 41, 40, 37, 36, 35, 33, 31, 31, 28, 26, 24, 21, 17, 13, 10, 8, 5, 3,
-1, -2, -5, -6, -8, -10, -11, -13, -14, -15, -16, -17, -18, -20, -20, -21, -23,
-24, -26, -28, -28, -30, -32, -35, -36, -38, -40, -42, -45, -47, -48, -51, -52,
-55, -57, -58, -58, -60, -61, -62, -62, -63, -63, -63, -64, -64, -64, -65, -65,
-64, -64, -64, -64, -65, -63, -63, -62, -61, -60, -58, -57, -56, -55, -53, -52,
-50, -48, -45, -44, -42, -40, -37, -36, -34, -32, -29, -28, -25, -23, -22, -20,
-19, -16, -15, -13, -11, -9, -9, -8, -6, -5, -4, -3, -3, -1, -1, };