#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 8, 9, 10, 10, 9, 9, 8, 8, 8,
10, 12, 16, 20, 24, 30, 35, 40, 43, 47, 50, 52, 54, 55, 56, 58, 59, 62, 65, 69,
73, 77, 84, 88, 93, 98, 104, 109, 112, 114, 117, 118, 120, 119, 118, 118, 116,
113, 112, 109, 107, 104, 102, 99, 97, 96, 95, 94, 92, 92, 91, 90, 89, 88, 87,
87, 87, 87, 86, 86, 85, 83, 81, 80, 77, 75, 73, 69, 67, 65, 62, 60, 57, 55, 51,
49, 46, 44, 40, 37, 34, 31, 27, 23, 20, 16, 13, 10, 8, 5, 4, 3, 2, 2, 2, 1, 2,
1, 1, 0, -1, -2, -3, -5, -6, -8, -9, -11, -12, -13, -14, -14, -14, -15, -15,
-16, -16, -18, -18, -21, -22, -22, -22, -21, -19, -18, -14, -11, -7, -4, 1, 4,
6, 6, 6, 5, 1, -3, -9, -15, -20, -25, -30, -32, -34, -34, -32, -29, -25, -19,
-13, -8, -2, 4, 9, 13, 16, 19, 19, 20, 20, 18, 17, 15, 13, 12, 10, 9, 8, 6, 6,
5, 3, 3, 3, 2, 1, 1, 1, -1, 0, -1, -1, -3, -4, -6, -7, -10, -12, -16, -18, -21,
-24, -27, -32, -34, -35, -36, -36, -36, -35, -34, -32, -32, -32, -33, -35, -37,
-40, -44, -48, -52, -56, -62, -65, -71, -75, -80, -85, -89, -92, -96, -99, -100,
-102, -102, -102, -100, -100, -96, -94, -89, -86, -82, -79, -76, -71, -69, -66,
-64, -63, -61, -60, -60, -60, -61, -63, -65, -67, -70, -70, -71, -71, -70, -68,
-65, -60, -55, -48, -42, -37, -29, -24, -20, -15, -12, -9, -5, -3, 0, 4, 8, 11,
14, 16, 16, 17, 17, 16, 15, 13, 12, 11, 10, 9, 10, 12, 14, 17, 22, 25, 28, 32,
35, 36, 38, 39, 40, 40, 41, 41, 42, 43, 42, 43, 43, 42, 42, 40, 39, 36, 35, 34,
33, 31, 31, 31, 31, 30, 29, 28, 26, 24, 22, 20, 17, 16, 14, 12, 10, 10, 9, 10,
9, 10, 11, 11, 12, 12, 13, 13, 12, 12, 10, 7, 4, 1, -3, -8, -12, -16, -20, -24,
-27, -28, -31, -31, -32, -32, -32, -32, -33, -33, -34, -36, -38, -40, -41, -43,
-44, -43, -44, -41, -40, -37, -34, -32, -31, -29, -29, -30, -31, -32, -34, -35,
-36, -35, -35, -33, -32, -29, -27, -26, -24, -24, -23, -22, -23, -21, -19, -19,
-17, -15, -12, -9, -7, -3, 0, 2, 4, 6, 8, 10, 10, 12, 12, 11, 12, 11, 11, 10,
10, 9, 9, 7, 8, 7, 5, 4, 4, 5, 4, 5, 6, 7, 8, 9, 8, 8, 8, 7, 6, 6, 7, 6, 6, 6,
5, 4, 2, 1, 0, -1, -2, -4, -3, -4, -5, -4, -4, -4, -3, -3, -3, -4, -7, -11, -15,
-20, -24, -28, -32, -33, -33, -34, -32, -30, -27, -25, -22, -20, -20, -20, -21,
-22, -24, -25, -28, -29, -30, -29, -28, -26, -23, -20, -16, -13, -8, -4, -1, };