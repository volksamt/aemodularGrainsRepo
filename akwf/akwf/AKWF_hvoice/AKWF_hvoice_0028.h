#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0028

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 6, 3, 2, 5, 14, 22, 25, 24, 22,
20, 24, 33, 45, 50, 51, 50, 49, 52, 59, 67, 68, 63, 55, 52, 54, 60, 69, 72, 71,
72, 76, 83, 89, 96, 98, 96, 95, 93, 93, 99, 104, 107, 105, 105, 109, 111, 115,
119, 117, 108, 98, 96, 96, 97, 98, 97, 97, 97, 97, 100, 107, 115, 117, 111, 106,
103, 100, 98, 99, 103, 101, 91, 81, 76, 75, 77, 77, 72, 66, 58, 54, 54, 58, 65,
69, 70, 70, 69, 73, 77, 81, 82, 79, 71, 63, 57, 57, 55, 53, 49, 46, 45, 45, 44,
45, 48, 48, 48, 46, 48, 51, 56, 57, 60, 59, 58, 55, 53, 54, 52, 48, 43, 39, 35,
31, 28, 28, 27, 23, 23, 22, 25, 25, 25, 24, 20, 16, 14, 14, 16, 16, 14, 13, 10,
8, 5, 3, -1, -5, -12, -17, -21, -24, -27, -30, -32, -35, -37, -38, -39, -40,
-40, -40, -42, -45, -47, -49, -50, -51, -54, -55, -58, -63, -66, -69, -71, -74,
-80, -84, -86, -88, -88, -88, -85, -84, -85, -85, -84, -84, -83, -83, -85, -87,
-87, -89, -89, -88, -88, -88, -89, -91, -91, -91, -91, -90, -92, -91, -91, -92,
-90, -86, -83, -81, -79, -77, -76, -73, -71, -70, -68, -67, -66, -67, -66, -64,
-62, -61, -61, -60, -61, -61, -59, -58, -57, -56, -54, -53, -50, -47, -45, -41,
-39, -38, -37, -37, -35, -36, -36, -37, -38, -39, -39, -39, -40, -40, -38, -39,
-38, -39, -37, -37, -37, -36, -36, -34, -34, -34, -34, -33, -33, -33, -34, -35,
-36, -38, -37, -39, -40, -42, -42, -41, -41, -42, -41, -40, -42, -42, -41, -41,
-42, -41, -42, -42, -40, -40, -40, -38, -38, -39, -39, -38, -40, -39, -39, -41,
-41, -41, -40, -39, -39, -37, -36, -35, -33, -32, -29, -28, -24, -20, -16, -11,
-8, -6, -7, -6, -5, -5, -5, -7, -9, -12, -14, -12, -6, -2, 1, 3, 2, 3, 6, 11,
17, 20, 20, 18, 17, 19, 23, 28, 31, 31, 28, 24, 23, 24, 27, 28, 27, 24, 23, 23,
25, 29, 32, 33, 32, 30, 29, 29, 31, 30, 30, 27, 26, 25, 26, 27, 27, 25, 24, 22,
19, 18, 15, 12, 9, 7, 4, 4, 4, 3, 4, 2, 3, 2, 4, 4, 3, 3, 5, 5, 5, 6, 7, 6, 4,
2, -3, -6, -10, -14, -17, -19, -21, -21, -21, -21, -18, -15, -12, -10, -10, -11,
-13, -14, -14, -15, -17, -18, -20, -22, -22, -21, -20, -20, -23, -24, -25, -25,
-24, -22, -20, -20, -20, -20, -19, -18, -16, -16, -16, -19, -21, -22, -20, -18,
-15, -15, -16, -17, -16, -15, -14, -14, -15, -17, -20, -21, -20, -18, -16, -14,
-11, -9, -6, -5, -4, -5, -8, -10, -13, -14, -14, -15, -16, -19, -18, -17, -12,
-7, -2, -1, -2, -4, -2, 1, 2, 3, 3, -1, -5, -8, -7, -3, 2, 3, 1, -3, -3, -2, 0,
};