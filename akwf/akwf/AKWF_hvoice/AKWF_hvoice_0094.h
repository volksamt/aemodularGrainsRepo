#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0094

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 4, 4, 5, 5, 7, 6, 7, 8, 8, 9,
10, 10, 10, 11, 12, 13, 13, 14, 14, 14, 13, 15, 14, 14, 14, 14, 15, 15, 16, 17,
17, 17, 17, 18, 18, 18, 18, 18, 18, 17, 18, 18, 18, 18, 19, 19, 19, 20, 20, 20,
21, 21, 20, 21, 21, 22, 21, 22, 22, 21, 23, 22, 23, 23, 23, 23, 25, 24, 24, 24,
24, 26, 26, 27, 28, 28, 29, 29, 30, 32, 33, 35, 35, 35, 38, 38, 40, 41, 42, 45,
45, 47, 48, 49, 50, 51, 52, 52, 54, 53, 55, 55, 55, 55, 54, 53, 54, 53, 51, 51,
50, 48, 48, 46, 44, 43, 42, 40, 38, 36, 36, 34, 33, 32, 30, 29, 28, 27, 25, 24,
23, 22, 19, 18, 16, 15, 14, 13, 12, 11, 11, 11, 9, 6, 4, -1, -7, -14, -20, -28,
-35, -42, -47, -54, -60, -66, -71, -77, -82, -88, -93, -98, -103, -107, -112,
-116, -117, -119, -119, -118, -114, -111, -109, -102, -98, -93, -88, -84, -80,
-76, -72, -67, -61, -56, -52, -45, -40, -36, -30, -25, -22, -19, -15, -14, -12,
-12, -11, -11, -9, -9, -7, -6, -5, -3, -1, -1, 1, 3, 3, 4, 5, 6, 7, 8, 9, 11,
13, 14, 16, 18, 20, 20, 21, 21, 19, 19, 17, 15, 12, 10, 6, 4, 1, -2, -6, -8,
-12, -16, -17, -21, -26, -30, -32, -37, -39, -42, -44, -46, -47, -47, -46, -45,
-44, -42, -41, -38, -38, -36, -34, -33, -31, -29, -26, -24, -22, -19, -15, -13,
-10, -8, -6, -4, -2, -2, 1, 0, 1, 2, 3, 5, 5, 6, 8, 8, 11, 11, 14, 14, 14, 15,
16, 17, 17, 17, 18, 20, 20, 22, 24, 24, 25, 26, 27, 26, 27, 27, 25, 25, 24, 22,
21, 20, 18, 16, 15, 13, 11, 11, 8, 6, 4, 2, -1, -3, -6, -7, -8, -10, -12, -12,
-12, -13, -15, -13, -13, -13, -14, -14, -12, -12, -13, -12, -10, -10, -9, -7,
-6, -4, -4, -3, -1, -1, 1, 1, 2, 2, 2, 2, 2, 2, 3, 4, 4, 4, 6, 5, 6, 7, 8, 8, 8,
8, 9, 9, 9, 10, 9, 10, 12, 12, 14, 14, 14, 15, 13, 14, 13, 12, 11, 10, 10, 8, 7,
6, 6, 5, 4, 3, 2, 0, -1, -2, -4, -5, -7, -8, -10, -10, -10, -12, -12, -12, -13,
-13, -13, -14, -14, -14, -15, -15, -15, -15, -15, -15, -15, -14, -14, -14, -12,
-12, -11, -11, -11, -11, -11, -10, -10, -10, -9, -9, -8, -8, -5, -5, -5, -3, -3,
-2, -2, -1, 0, 0, 1, 1, 1, 1, 2, 2, 2, 3, 4, 5, 5, 5, 7, 7, 7, 6, 5, 5, 5, 6, 4,
5, 5, 5, 4, 5, 5, 3, 4, 3, 2, 2, 1, 1, 0, -1, -1, -1, -1, -3, -2, -2, -2, -3,
-3, -4, -3, -3, -5, -4, -3, -3, -3, -3, -1, 0, 0, };