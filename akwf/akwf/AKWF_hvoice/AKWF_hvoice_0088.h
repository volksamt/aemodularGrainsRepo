#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0088

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 5, 8, 8, 11, 11, 13, 14,
16, 18, 19, 20, 22, 23, 25, 26, 27, 30, 31, 33, 33, 35, 37, 37, 40, 40, 42, 43,
45, 47, 47, 50, 51, 53, 54, 56, 57, 58, 59, 61, 61, 64, 65, 66, 68, 68, 69, 72,
72, 73, 75, 77, 78, 79, 80, 82, 83, 84, 86, 87, 89, 91, 92, 95, 97, 98, 100,
102, 102, 105, 107, 108, 109, 111, 112, 114, 115, 116, 117, 118, 118, 118, 119,
119, 119, 119, 119, 119, 119, 118, 117, 117, 116, 115, 114, 114, 113, 112, 111,
111, 109, 108, 108, 107, 105, 106, 105, 104, 103, 102, 101, 101, 100, 99, 98,
97, 96, 96, 95, 94, 92, 91, 89, 87, 86, 84, 82, 81, 79, 77, 74, 72, 70, 68, 65,
63, 59, 57, 56, 52, 50, 46, 44, 40, 38, 35, 33, 30, 27, 24, 21, 19, 17, 13, 10,
7, 5, 2, -1, -3, -6, -8, -11, -14, -16, -19, -22, -25, -27, -29, -32, -33, -35,
-38, -40, -42, -44, -46, -48, -50, -51, -53, -55, -56, -59, -60, -61, -63, -66,
-67, -68, -71, -73, -74, -75, -77, -79, -81, -83, -84, -87, -88, -90, -91, -92,
-94, -95, -96, -97, -99, -100, -100, -100, -102, -102, -103, -103, -104, -103,
-103, -102, -103, -103, -102, -102, -101, -100, -99, -99, -98, -97, -96, -96,
-95, -95, -94, -94, -93, -92, -91, -91, -90, -89, -88, -88, -87, -86, -85, -84,
-84, -83, -82, -82, -80, -78, -78, -76, -75, -75, -74, -72, -71, -70, -67, -66,
-65, -63, -61, -60, -58, -57, -55, -53, -51, -49, -49, -45, -43, -42, -41, -38,
-37, -35, -33, -31, -30, -27, -26, -24, -22, -20, -18, -17, -15, -13, -11, -9,
-8, -7, -5, -3, -2, -1, 1, 2, 3, 4, 5, 7, 7, 8, 9, 10, 10, 11, 13, 14, 14, 15,
16, 18, 17, 18, 18, 20, 21, 21, 22, 23, 23, 24, 25, 25, 28, 28, 29, 29, 30, 30,
31, 31, 32, 32, 32, 32, 33, 33, 33, 33, 33, 33, 32, 32, 32, 31, 30, 30, 29, 28,
27, 27, 26, 25, 24, 24, 22, 21, 20, 19, 18, 17, 17, 15, 15, 13, 12, 11, 11, 9,
8, 8, 7, 6, 6, 5, 3, 3, 2, 1, 1, -1, -1, -3, -4, -5, -6, -7, -8, -9, -10, -12,
-12, -13, -15, -17, -18, -19, -20, -22, -23, -24, -25, -27, -27, -29, -30, -31,
-32, -34, -35, -36, -36, -38, -40, -40, -41, -42, -43, -43, -45, -45, -46, -46,
-47, -47, -48, -48, -48, -49, -49, -50, -49, -49, -49, -48, -49, -49, -49, -49,
-48, -48, -47, -47, -47, -47, -47, -47, -46, -46, -46, -46, -45, -46, -45, -44,
-44, -44, -43, -44, -43, -43, -42, -42, -42, -41, -40, -39, -39, -38, -38, -37,
-36, -35, -33, -33, -32, -30, -29, -28, -26, -26, -24, -23, -22, -21, -20, -18,
-17, -15, -14, -12, -10, -9, -7, -6, -5, -3, -2, 0, };