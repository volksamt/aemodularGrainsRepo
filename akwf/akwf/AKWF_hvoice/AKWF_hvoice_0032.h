#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0032

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 7, 12, 17, 22, 24, 26, 30,
33, 37, 41, 41, 42, 45, 45, 44, 43, 45, 46, 45, 44, 45, 51, 56, 60, 63, 65, 64,
64, 66, 69, 66, 62, 59, 56, 52, 53, 52, 50, 52, 57, 64, 76, 91, 103, 111, 116,
118, 119, 118, 114, 106, 96, 87, 82, 77, 74, 68, 59, 52, 50, 50, 50, 49, 46, 41,
37, 35, 35, 33, 28, 24, 25, 23, 20, 16, 11, 4, 0, -1, -1, -2, -5, -11, -18, -27,
-35, -41, -45, -51, -54, -56, -55, -51, -46, -41, -34, -28, -17, -8, -3, -1, -1,
-3, -4, -3, -2, 1, 0, -1, -2, -3, -3, -5, -3, -1, 1, 4, 7, 11, 12, 12, 13, 14,
16, 17, 19, 18, 15, 15, 16, 18, 18, 19, 16, 12, 7, 0, -7, -17, -25, -33, -40,
-44, -48, -51, -56, -57, -58, -57, -54, -53, -53, -53, -53, -52, -52, -51, -52,
-54, -56, -58, -60, -62, -63, -65, -65, -65, -63, -60, -56, -55, -54, -51, -50,
-47, -45, -43, -42, -38, -32, -27, -20, -13, -9, -4, 0, 5, 7, 7, 7, 5, 3, 1, -2,
-5, -7, -12, -13, -15, -17, -18, -18, -20, -19, -18, -16, -14, -14, -14, -16,
-17, -18, -21, -24, -27, -29, -32, -33, -33, -35, -36, -39, -40, -43, -45, -47,
-49, -51, -52, -53, -51, -49, -46, -43, -39, -35, -30, -26, -21, -17, -12, -9,
-6, -4, -1, 0, 1, 0, 1, 1, 1, 1, 2, 3, 5, 7, 10, 13, 16, 18, 20, 21, 23, 22, 22,
22, 21, 21, 21, 21, 20, 19, 18, 15, 13, 10, 6, 2, -2, -7, -10, -14, -18, -21,
-23, -26, -28, -29, -29, -29, -28, -26, -25, -23, -20, -19, -18, -19, -19, -19,
-19, -18, -17, -16, -13, -11, -7, -5, -1, 0, 0, 0, 1, 2, 3, 5, 7, 10, 14, 16,
19, 20, 20, 21, 22, 22, 23, 23, 26, 27, 27, 26, 25, 23, 20, 18, 14, 10, 9, 8, 8,
9, 9, 10, 10, 10, 11, 10, 7, 5, 4, 4, 3, 3, 3, 4, 3, 4, 4, 4, 2, 2, 2, 1, 1, 0,
1, 0, 1, 2, 2, 2, 2, 1, 2, 1, 3, 4, 6, 8, 10, 13, 14, 14, 14, 13, 12, 11, 11, 9,
9, 8, 7, 6, 4, 3, 2, 2, 0, -1, -6, -8, -10, -10, -10, -12, -14, -14, -15, -13,
-12, -12, -14, -14, -12, -11, -9, -10, -12, -13, -14, -16, -18, -20, -24, -27,
-28, -30, -33, -35, -38, -39, -39, -38, -37, -37, -37, -35, -31, -28, -24, -22,
-20, -19, -19, -16, -16, -15, -13, -11, -10, -8, -7, -8, -8, -7, -5, -4, -1, 0,
3, 7, 9, 9, 9, 9, 11, 11, 11, 9, 8, 7, 6, 6, 5, 3, 1, 2, 3, 3, 3, 4, 4, 5, 4, 4,
3, 2, 1, 1, 1, 0, -2, -5, -6, -8, -9, -11, -15, -19, -20, -19, -19, -18, -17,
-17, -15, -9, -2, };