#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0073

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 5, 6, 9, 9, 9, 10, 11, 11,
10, 11, 11, 11, 10, 10, 9, 10, 8, 9, 8, 9, 9, 9, 8, 9, 7, 8, 8, 8, 8, 8, 8, 8,
7, 7, 8, 8, 7, 8, 7, 8, 7, 8, 8, 8, 9, 9, 10, 10, 10, 10, 11, 10, 11, 12, 13,
14, 15, 15, 15, 16, 15, 16, 17, 17, 17, 17, 18, 18, 19, 18, 20, 19, 19, 20, 21,
21, 21, 21, 22, 21, 21, 22, 22, 23, 23, 23, 24, 25, 25, 26, 27, 28, 30, 31, 32,
33, 34, 35, 35, 37, 38, 37, 38, 36, 36, 35, 34, 33, 30, 29, 26, 24, 22, 19, 17,
16, 12, 11, 10, 9, 8, 7, 7, 7, 8, 9, 10, 11, 13, 13, 15, 16, 18, 20, 21, 22, 21,
22, 21, 19, 18, 16, 15, 12, 10, 9, 5, 3, 1, -3, -6, -10, -15, -19, -24, -30,
-36, -43, -51, -59, -66, -74, -82, -90, -97, -103, -108, -112, -116, -118, -119,
-118, -116, -111, -105, -98, -90, -82, -70, -59, -46, -35, -22, -9, 3, 14, 25,
35, 43, 49, 56, 60, 62, 63, 62, 61, 57, 53, 48, 41, 34, 27, 19, 12, 2, -6, -12,
-20, -26, -31, -36, -42, -44, -48, -50, -52, -53, -53, -54, -53, -52, -50, -50,
-48, -45, -43, -41, -38, -35, -32, -29, -25, -21, -18, -13, -8, -4, 1, 6, 11,
15, 20, 25, 29, 33, 36, 40, 41, 44, 45, 45, 46, 45, 42, 39, 36, 33, 29, 23, 18,
12, 6, -2, -8, -14, -21, -26, -33, -37, -41, -45, -48, -49, -50, -50, -50, -47,
-44, -40, -37, -33, -27, -21, -16, -10, -4, 1, 7, 12, 16, 20, 23, 26, 29, 30,
32, 33, 34, 33, 33, 31, 30, 28, 27, 24, 22, 19, 17, 14, 13, 11, 9, 7, 4, 3, 2,
1, 1, -2, -2, -4, -6, -6, -8, -9, -11, -13, -15, -16, -19, -21, -21, -22, -22,
-22, -22, -21, -19, -17, -14, -12, -8, -5, -1, 3, 8, 11, 16, 20, 23, 26, 26, 29,
30, 30, 30, 29, 28, 26, 24, 21, 18, 15, 11, 8, 4, 0, -3, -7, -9, -12, -13, -15,
-15, -16, -17, -16, -16, -15, -14, -12, -10, -9, -8, -6, -5, -3, -1, -1, 0, 1,
2, 2, 2, 3, 2, 2, 2, 2, 1, 0, 0, 1, 1, 0, 1, 2, 2, 2, 3, 2, 3, 4, 4, 3, 3, 2, 2,
1, 1, -1, -2, -4, -5, -7, -9, -9, -12, -13, -14, -15, -15, -14, -15, -13, -13,
-12, -10, -8, -6, -4, -2, 1, 2, 4, 6, 7, 8, 8, 9, 9, 8, 8, 7, 6, 4, 2, 1, -2,
-4, -6, -8, -9, -11, -11, -12, -12, -13, -13, -12, -10, -10, -8, -6, -4, -3, -1,
1, 3, 5, 5, 8, 8, 9, 9, 9, 10, 9, 9, 8, 7, 5, 5, 3, 2, 0, -2, -2, -3, -5, -5,
-6, -6, -6, -6, -5, -4, -2, -1, };