#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0102

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 10, 9, 7, 5, 4, 1, 1, 0,
2, 3, 6, 7, 10, 12, 13, 12, 12, 11, 10, 10, 11, 13, 16, 19, 22, 25, 27, 26, 25,
22, 19, 17, 14, 13, 10, 10, 10, 12, 13, 13, 15, 16, 18, 20, 22, 24, 24, 23, 22,
21, 20, 20, 18, 19, 21, 22, 23, 24, 22, 20, 19, 17, 15, 14, 14, 15, 17, 20, 23,
25, 28, 31, 34, 35, 38, 39, 39, 39, 38, 37, 37, 37, 37, 36, 36, 35, 35, 34, 32,
30, 30, 31, 33, 35, 37, 38, 39, 38, 37, 37, 36, 36, 36, 37, 36, 35, 34, 30, 27,
24, 23, 23, 24, 26, 29, 31, 32, 33, 32, 28, 27, 25, 25, 25, 27, 30, 33, 36, 40,
41, 42, 44, 44, 44, 43, 42, 41, 41, 41, 43, 44, 47, 51, 53, 56, 57, 59, 58, 59,
58, 57, 57, 57, 58, 58, 58, 59, 59, 59, 60, 61, 62, 63, 64, 64, 63, 63, 62, 60,
60, 59, 61, 62, 64, 65, 65, 64, 62, 60, 56, 52, 48, 46, 45, 43, 43, 44, 43, 44,
44, 44, 45, 46, 46, 48, 49, 49, 48, 44, 39, 30, 19, 4, -14, -29, -43, -56, -67,
-78, -88, -95, -104, -110, -113, -118, -118, -119, -116, -114, -110, -107, -105,
-103, -103, -104, -105, -106, -107, -109, -110, -111, -113, -114, -115, -115,
-115, -112, -110, -104, -97, -88, -77, -67, -55, -44, -33, -23, -14, -6, 1, 5,
9, 12, 14, 15, 14, 12, 10, 9, 5, 4, 2, 1, -1, -2, -3, -4, -5, -6, -5, -5, -3,
-1, 0, 1, 0, -2, -7, -14, -22, -30, -38, -45, -51, -56, -60, -63, -66, -69, -73,
-75, -77, -78, -79, -76, -74, -71, -67, -63, -59, -55, -52, -48, -46, -43, -40,
-37, -37, -37, -38, -39, -40, -40, -41, -39, -37, -33, -28, -25, -21, -16, -12,
-10, -7, -5, -2, -1, 1, 4, 5, 7, 8, 9, 9, 8, 5, 1, -3, -8, -12, -16, -19, -20,
-20, -19, -18, -18, -17, -17, -17, -18, -19, -19, -19, -18, -17, -15, -16, -15,
-17, -20, -22, -26, -28, -30, -30, -29, -28, -27, -26, -25, -25, -24, -24, -23,
-21, -18, -16, -12, -8, -5, -3, -2, 1, 3, 2, 3, 3, 5, 5, 4, 4, 3, 3, 3, 3, 6, 7,
9, 10, 12, 13, 14, 14, 15, 16, 17, 18, 19, 19, 20, 19, 18, 17, 15, 14, 13, 10,
6, 3, -1, -4, -7, -8, -10, -9, -6, -3, 0, 3, 5, 7, 8, 7, 7, 5, 4, 3, 1, -1, -3,
-3, -5, -6, -7, -8, -9, -8, -8, -8, -7, -5, -4, -1, 2, 3, 6, 10, 12, 13, 11, 10,
8, 6, 3, 0, -1, -3, -4, -5, -6, -9, -11, -12, -13, -13, -11, -8, -5, -2, 0, 2,
2, 0, -1, -4, -5, -5, -6, -6, -5, -5, -4, -6, -7, -8, -10, -12, -11, -11, -10,
-10, -9, -9, -8, -5, -4, -1, };