#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0081

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 5, 5, 7, 9, 10, 12, 13, 15, 17,
19, 20, 23, 23, 26, 28, 29, 31, 33, 35, 37, 38, 40, 41, 43, 45, 46, 47, 49, 50,
52, 53, 54, 54, 54, 54, 55, 56, 56, 55, 55, 54, 55, 55, 56, 57, 57, 59, 59, 61,
62, 63, 62, 63, 63, 64, 63, 64, 66, 65, 65, 64, 63, 60, 56, 51, 46, 39, 32, 25,
16, 6, -2, -12, -20, -26, -31, -36, -40, -44, -46, -47, -49, -51, -54, -55, -57,
-59, -62, -66, -68, -71, -74, -77, -79, -82, -83, -84, -86, -88, -89, -91, -94,
-97, -100, -103, -106, -108, -112, -113, -116, -117, -119, -120, -118, -118,
-116, -114, -111, -109, -106, -103, -99, -96, -91, -87, -83, -78, -73, -68, -62,
-57, -52, -48, -43, -39, -34, -31, -28, -24, -22, -19, -17, -14, -13, -11, -7,
-5, -3, 0, 3, 6, 9, 12, 15, 19, 23, 27, 31, 35, 40, 44, 47, 51, 55, 58, 61, 63,
65, 67, 68, 70, 71, 71, 72, 72, 72, 70, 70, 68, 66, 63, 61, 58, 55, 51, 48, 45,
42, 40, 36, 34, 33, 31, 30, 28, 27, 25, 23, 22, 20, 18, 16, 13, 11, 8, 4, 1, -2,
-6, -9, -13, -16, -20, -24, -28, -32, -36, -40, -44, -47, -51, -55, -58, -62,
-65, -67, -69, -72, -72, -74, -73, -75, -74, -75, -75, -74, -74, -73, -72, -71,
-70, -69, -67, -66, -66, -65, -64, -63, -62, -61, -60, -59, -58, -58, -56, -55,
-55, -53, -50, -49, -46, -45, -41, -39, -35, -32, -29, -25, -20, -18, -13, -10,
-6, -3, 1, 4, 7, 11, 14, 17, 19, 22, 24, 27, 29, 30, 33, 33, 35, 37, 39, 38, 40,
40, 42, 42, 44, 45, 46, 46, 47, 49, 49, 50, 51, 50, 51, 51, 51, 52, 51, 51, 49,
50, 48, 47, 46, 46, 44, 43, 42, 41, 40, 39, 36, 35, 32, 31, 28, 25, 22, 19, 17,
13, 11, 8, 6, 2, -1, -3, -4, -7, -8, -9, -10, -11, -12, -12, -14, -14, -15, -17,
-17, -19, -20, -22, -25, -25, -27, -29, -29, -31, -32, -32, -34, -33, -33, -34,
-33, -33, -33, -32, -31, -31, -30, -29, -29, -28, -27, -25, -23, -22, -20, -19,
-17, -14, -13, -10, -9, -7, -5, -3, -1, 0, 1, 3, 5, 7, 8, 10, 12, 14, 16, 18,
20, 23, 24, 25, 28, 29, 30, 32, 32, 33, 35, 37, 38, 37, 39, 40, 41, 42, 43, 43,
44, 45, 46, 46, 48, 48, 48, 49, 50, 49, 50, 50, 49, 48, 47, 47, 45, 45, 42, 41,
39, 38, 36, 34, 34, 31, 30, 29, 28, 27, 25, 24, 22, 21, 19, 17, 15, 13, 12, 9,
8, 7, 5, 4, 3, 2, 1, 1, 0, -1, -2, -2, -4, -5, -5, -7, -7, -9, -9, -10, -11,
-12, -13, -14, -14, -14, -13, -14, -15, -14, -14, -14, -12, -12, -11, -10, -10,
-9, -8, -7, -6, -6, -4, -3, -1, 1, };