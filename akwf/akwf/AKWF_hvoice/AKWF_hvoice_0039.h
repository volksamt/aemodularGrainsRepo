#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0039

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 8, 14, 19, 23, 27, 31, 35, 40, 45,
50, 56, 60, 65, 69, 74, 76, 80, 82, 84, 87, 89, 91, 93, 94, 97, 97, 99, 100,
100, 101, 102, 103, 104, 104, 105, 106, 108, 109, 110, 110, 108, 107, 107, 105,
104, 104, 103, 104, 102, 101, 100, 98, 97, 95, 94, 92, 89, 87, 86, 84, 80, 78,
75, 71, 68, 64, 62, 60, 58, 54, 50, 48, 44, 41, 38, 36, 33, 29, 23, 18, 13, 10,
6, 3, 0, -3, -5, -7, -10, -12, -14, -17, -19, -22, -24, -26, -28, -29, -31, -32,
-35, -35, -36, -36, -38, -38, -38, -38, -39, -38, -37, -35, -34, -33, -32, -34,
-33, -35, -35, -35, -34, -33, -31, -28, -26, -24, -22, -20, -20, -18, -16, -15,
-12, -10, -9, -7, -5, -3, -1, 2, 4, 6, 9, 11, 13, 16, 20, 22, 26, 28, 31, 34,
36, 39, 41, 43, 46, 48, 51, 53, 54, 55, 58, 60, 63, 64, 64, 65, 66, 66, 66, 68,
67, 67, 68, 69, 68, 68, 66, 64, 63, 62, 59, 57, 53, 52, 50, 47, 43, 39, 36, 32,
27, 24, 19, 15, 13, 8, 4, 0, -3, -6, -9, -13, -17, -20, -23, -27, -30, -31, -34,
-35, -37, -40, -41, -45, -47, -51, -55, -57, -59, -60, -62, -63, -65, -67, -69,
-72, -75, -75, -78, -81, -83, -84, -87, -88, -89, -92, -93, -94, -95, -98, -100,
-101, -103, -106, -110, -111, -113, -115, -115, -115, -116, -116, -117, -118,
-119, -119, -119, -118, -116, -115, -111, -108, -105, -102, -98, -95, -91, -88,
-85, -80, -77, -73, -69, -65, -61, -56, -51, -47, -42, -36, -33, -30, -25, -21,
-15, -10, -4, 1, 8, 14, 19, 25, 29, 34, 39, 43, 46, 49, 53, 56, 58, 62, 65, 67,
70, 71, 74, 75, 76, 78, 78, 80, 82, 84, 84, 86, 87, 88, 88, 87, 88, 86, 85, 85,
84, 85, 83, 84, 83, 82, 83, 83, 83, 82, 82, 80, 79, 77, 75, 75, 73, 72, 72, 71,
70, 68, 68, 66, 64, 63, 60, 59, 57, 56, 54, 50, 47, 43, 42, 38, 35, 32, 27, 23,
18, 13, 8, 5, 2, 0, -3, -7, -9, -13, -16, -20, -23, -26, -28, -31, -34, -38,
-41, -43, -47, -49, -51, -52, -53, -51, -51, -50, -50, -51, -52, -52, -51, -51,
-49, -49, -48, -47, -45, -43, -41, -36, -34, -28, -24, -22, -19, -17, -16, -14,
-14, -14, -12, -12, -10, -8, -5, -3, -1, 2, 5, 8, 11, 14, 15, 15, 16, 18, 18,
19, 21, 23, 25, 28, 30, 30, 31, 32, 32, 34, 33, 34, 37, 38, 40, 42, 44, 46, 47,
48, 48, 48, 48, 49, 49, 50, 50, 51, 54, 55, 58, 60, 62, 65, 65, 65, 63, 64, 64,
65, 66, 68, 70, 71, 72, 73, 73, 74, 74, 74, 73, 72, 71, 69, 69, 68, 67, 67, 67,
64, 62, 59, 54, 49, 43, 37, 33, 29, 24, 22, 18, 14, 10, 5, 0, };