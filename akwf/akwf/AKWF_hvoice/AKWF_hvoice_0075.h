#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0075

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0,
0, 1, 2, 1, 2, 2, 3, 3, 5, 5, 6, 8, 9, 10, 11, 13, 14, 15, 16, 17, 18, 20, 22,
24, 26, 29, 31, 33, 35, 37, 39, 41, 41, 42, 43, 45, 46, 47, 48, 51, 52, 55, 58,
59, 59, 59, 58, 56, 54, 52, 50, 49, 50, 50, 52, 53, 54, 54, 56, 54, 54, 53, 52,
50, 48, 46, 45, 42, 41, 39, 39, 40, 41, 42, 42, 42, 41, 41, 38, 35, 33, 31, 30,
31, 30, 30, 29, 28, 28, 27, 25, 25, 26, 25, 25, 24, 25, 23, 22, 22, 22, 23, 23,
22, 23, 23, 23, 21, 22, 21, 21, 21, 23, 25, 26, 28, 28, 29, 29, 30, 30, 29, 30,
29, 30, 32, 33, 35, 36, 37, 38, 41, 42, 43, 44, 44, 43, 43, 43, 41, 42, 43, 46,
50, 54, 56, 57, 58, 57, 57, 55, 53, 51, 54, 57, 59, 59, 54, 45, 37, 28, 20, 12,
8, 10, 17, 27, 33, 35, 32, 27, 20, 10, -2, -13, -21, -26, -29, -31, -32, -35,
-38, -40, -41, -42, -43, -45, -48, -52, -57, -63, -70, -77, -83, -88, -92, -93,
-95, -95, -98, -98, -101, -101, -102, -103, -104, -105, -107, -110, -111, -113,
-115, -117, -118, -118, -118, -117, -118, -118, -119, -119, -117, -114, -110,
-107, -103, -99, -97, -96, -96, -96, -96, -96, -94, -93, -90, -88, -83, -80,
-77, -71, -66, -61, -56, -51, -48, -44, -41, -40, -39, -38, -36, -35, -32, -30,
-25, -21, -17, -12, -7, -2, 2, 7, 11, 13, 15, 17, 17, 16, 15, 15, 16, 17, 19,
22, 27, 31, 35, 38, 40, 41, 41, 40, 39, 37, 37, 34, 34, 32, 33, 34, 34, 35, 35,
36, 35, 33, 32, 30, 29, 29, 30, 31, 30, 28, 25, 20, 16, 12, 7, 4, 2, 4, 6, 8, 9,
9, 8, 5, 1, -3, -6, -9, -13, -15, -17, -19, -22, -26, -29, -29, -29, -26, -25,
-23, -21, -20, -21, -25, -31, -37, -41, -44, -46, -47, -46, -44, -41, -38, -35,
-34, -33, -31, -33, -34, -36, -38, -40, -41, -42, -42, -40, -38, -35, -33, -30,
-29, -27, -25, -23, -21, -19, -17, -17, -16, -16, -17, -18, -17, -15, -12, -7,
-4, -1, 0, 2, 2, 3, 4, 5, 8, 11, 14, 18, 20, 20, 16, 14, 14, 13, 13, 13, 15, 19,
22, 25, 26, 28, 29, 29, 29, 29, 29, 27, 26, 22, 19, 17, 16, 17, 18, 18, 21, 24,
25, 25, 25, 23, 22, 20, 18, 17, 14, 12, 10, 7, 5, 4, 4, 5, 7, 9, 11, 13, 11, 10,
7, 3, 1, -1, -3, -3, -4, -5, -4, -3, -2, -2, -1, -2, -2, -2, -3, -4, -5, -7, -6,
-7, -6, -6, -6, -6, -6, -5, -5, -5, -5, -5, -5, -5, -4, -4, -3, -3, -4, -4, -3,
-3, -3, -3, -3, -3, -2, -2, -1, -2, -1, -1, -1, -1, };