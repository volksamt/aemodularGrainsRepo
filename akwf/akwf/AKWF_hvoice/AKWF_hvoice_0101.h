#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0101

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 10, 13, 16, 17, 17, 18, 18,
18, 18, 18, 20, 22, 25, 27, 30, 33, 36, 37, 39, 40, 38, 38, 39, 39, 40, 41, 43,
44, 45, 44, 44, 41, 39, 37, 36, 34, 33, 32, 33, 34, 33, 32, 31, 30, 31, 30, 31,
30, 30, 28, 26, 24, 20, 18, 14, 11, 10, 9, 8, 9, 8, 7, 9, 8, 9, 9, 9, 8, 9, 8,
8, 7, 7, 7, 6, 8, 8, 9, 8, 8, 7, 6, 6, 5, 6, 7, 8, 10, 13, 15, 17, 19, 22, 23,
24, 26, 27, 28, 29, 30, 31, 30, 31, 31, 32, 32, 34, 35, 37, 38, 40, 42, 43, 45,
46, 47, 48, 49, 50, 50, 51, 52, 52, 53, 53, 53, 53, 53, 52, 51, 51, 48, 48, 48,
46, 47, 48, 48, 49, 50, 51, 52, 51, 50, 51, 50, 48, 47, 45, 45, 43, 42, 42, 41,
41, 41, 40, 39, 38, 35, 33, 31, 29, 27, 26, 26, 26, 28, 29, 30, 31, 31, 31, 29,
29, 31, 29, 28, 25, 19, 13, 1, -12, -29, -43, -54, -62, -67, -71, -70, -67, -64,
-63, -61, -61, -63, -66, -68, -71, -73, -76, -81, -86, -92, -97, -104, -109,
-114, -117, -118, -119, -119, -119, -117, -116, -113, -111, -106, -101, -96,
-88, -81, -73, -66, -60, -55, -53, -50, -51, -52, -54, -55, -54, -55, -53, -49,
-43, -37, -28, -20, -11, -3, 4, 11, 18, 23, 27, 30, 32, 35, 35, 35, 34, 34, 33,
32, 30, 29, 27, 27, 25, 25, 24, 24, 24, 26, 27, 30, 31, 34, 35, 37, 37, 32, 28,
20, 12, 3, -6, -14, -22, -27, -31, -35, -38, -39, -41, -41, -42, -41, -41, -41,
-42, -43, -45, -47, -52, -55, -58, -61, -64, -66, -67, -69, -72, -74, -75, -79,
-80, -81, -80, -79, -76, -71, -67, -60, -55, -50, -44, -39, -35, -31, -28, -26,
-26, -24, -25, -26, -27, -26, -25, -21, -18, -13, -8, -2, 4, 10, 16, 21, 26, 30,
34, 37, 38, 39, 39, 39, 39, 39, 40, 39, 40, 40, 40, 39, 38, 37, 35, 35, 34, 35,
37, 38, 39, 40, 40, 39, 37, 33, 30, 25, 20, 15, 10, 6, 2, -2, -5, -8, -10, -11,
-12, -13, -13, -14, -16, -16, -16, -18, -19, -21, -23, -25, -27, -29, -30, -32,
-32, -33, -34, -35, -35, -37, -37, -37, -35, -32, -29, -26, -23, -19, -16, -14,
-11, -10, -10, -9, -7, -6, -5, -5, -4, -3, -2, 0, 2, 4, 7, 10, 14, 16, 18, 20,
20, 20, 21, 21, 22, 24, 26, 28, 31, 33, 34, 32, 32, 29, 27, 23, 19, 17, 15, 13,
12, 12, 12, 13, 13, 14, 14, 15, 13, 13, 10, 9, 4, 2, -2, -5, -8, -11, -14, -17,
-18, -19, -19, -19, -19, -19, -19, -19, -20, -22, -24, -25, -25, -26, -26, -24,
-22, -19, -18, -15, -15, -16, -17, -17, -18, -18, -20, -19, -17, -16, -14, -11,
-9, -6, -3, };