#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 1, 2, 4, 5, 6, 7, 8, 9, 10, 10,
12, 13, 14, 15, 16, 18, 20, 20, 22, 22, 23, 24, 26, 28, 29, 29, 31, 30, 30, 30,
28, 27, 24, 22, 20, 18, 16, 12, 9, 7, 7, 8, 11, 13, 16, 16, 19, 21, 22, 25, 26,
27, 27, 28, 28, 27, 26, 25, 23, 21, 21, 19, 18, 16, 15, 15, 14, 14, 12, 11, 11,
13, 13, 14, 15, 17, 19, 22, 24, 27, 30, 36, 40, 46, 51, 56, 59, 63, 66, 71, 75,
79, 83, 87, 91, 94, 95, 97, 97, 98, 98, 95, 94, 93, 94, 91, 87, 82, 78, 75, 71,
64, 58, 54, 50, 47, 44, 41, 38, 36, 33, 34, 35, 34, 32, 32, 36, 41, 45, 46, 45,
47, 49, 52, 53, 54, 54, 56, 54, 50, 43, 36, 28, 18, 8, 1, -5, -14, -25, -34,
-44, -54, -68, -82, -92, -99, -101, -103, -103, -105, -107, -110, -115, -118,
-120, -117, -115, -112, -107, -101, -96, -91, -89, -87, -86, -83, -79, -74, -65,
-54, -43, -33, -24, -16, -8, -2, 3, 11, 21, 30, 38, 45, 51, 58, 63, 65, 66, 66,
67, 66, 64, 64, 64, 62, 61, 59, 57, 55, 53, 49, 46, 43, 43, 41, 39, 38, 39, 39,
40, 41, 43, 45, 46, 47, 47, 50, 52, 55, 55, 57, 60, 61, 62, 60, 59, 58, 56, 55,
51, 48, 44, 41, 39, 35, 31, 26, 22, 17, 11, 6, 0, -4, -10, -16, -21, -28, -35,
-42, -50, -57, -64, -72, -79, -86, -91, -96, -100, -104, -105, -107, -107, -107,
-106, -104, -99, -97, -92, -87, -81, -75, -69, -63, -57, -50, -45, -39, -34,
-29, -25, -21, -17, -13, -9, -6, -2, 1, 3, 5, 7, 8, 9, 11, 13, 14, 16, 17, 19,
20, 22, 23, 24, 25, 26, 28, 29, 31, 32, 35, 36, 38, 38, 39, 41, 42, 44, 45, 47,
49, 50, 51, 53, 55, 58, 58, 61, 62, 65, 66, 68, 69, 69, 69, 68, 65, 63, 60, 57,
52, 47, 42, 37, 29, 23, 16, 9, 3, -5, -12, -19, -25, -31, -36, -42, -46, -51,
-54, -58, -62, -64, -66, -69, -69, -71, -71, -71, -70, -70, -69, -68, -67, -64,
-62, -61, -58, -56, -53, -49, -47, -45, -40, -38, -35, -33, -30, -28, -26, -23,
-20, -18, -16, -13, -11, -9, -8, -6, -4, -3, -1, 0, 0, -2, -2, -3, -4, -4, -3,
-1, 0, 1, 1, 3, 4, 5, 7, 11, 16, 20, 24, 29, 34, 36, 39, 42, 45, 47, 49, 51, 53,
55, 56, 56, 55, 53, 52, 49, 47, 45, 43, 40, 38, 35, 31, 23, 15, 7, -2, -8, -14,
-21, -29, -36, -44, -52, -62, -72, -80, -86, -90, -94, -96, -99, -101, -103,
-104, -106, -108, -107, -107, -103, -100, -95, -92, -90, -87, -84, -81, -78,
-74, -69, -63, -57, -50, -44, -39, -35, -31, -27, -24, -21, -18, -14, -10, -8,
-5, -2, -2, -1, -1, 0, 0, };