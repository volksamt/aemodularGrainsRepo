#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0035

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 12, 12, 12, 12, 14, 19, 22, 24,
26, 26, 29, 31, 36, 45, 51, 54, 53, 48, 45, 46, 50, 55, 59, 58, 52, 48, 46, 47,
50, 54, 53, 49, 43, 39, 39, 47, 56, 61, 61, 57, 55, 56, 61, 65, 66, 64, 57, 48,
44, 43, 43, 41, 38, 33, 32, 31, 35, 40, 47, 49, 48, 46, 44, 43, 44, 43, 41, 39,
37, 35, 33, 33, 32, 33, 33, 33, 33, 37, 39, 43, 46, 49, 52, 53, 53, 56, 59, 62,
63, 61, 58, 57, 58, 61, 62, 60, 57, 54, 53, 54, 59, 63, 64, 63, 61, 61, 60, 62,
67, 71, 71, 71, 69, 69, 72, 76, 75, 72, 69, 67, 68, 71, 75, 76, 74, 71, 69, 70,
71, 72, 72, 70, 66, 63, 64, 66, 69, 70, 68, 62, 60, 58, 59, 62, 68, 71, 70, 70,
68, 70, 73, 77, 80, 78, 75, 74, 75, 77, 80, 82, 83, 82, 82, 85, 88, 93, 98, 100,
99, 97, 95, 96, 97, 95, 94, 89, 86, 85, 86, 85, 86, 85, 83, 80, 78, 79, 79, 79,
77, 76, 74, 72, 70, 67, 64, 59, 53, 47, 42, 39, 35, 29, 23, 17, 13, 9, 6, 3, -2,
-5, -9, -13, -17, -19, -23, -29, -36, -39, -42, -47, -49, -54, -58, -62, -67,
-71, -74, -76, -77, -79, -82, -85, -87, -90, -92, -93, -94, -97, -103, -107,
-110, -111, -111, -112, -114, -115, -118, -119, -119, -117, -113, -112, -112,
-112, -113, -111, -108, -105, -105, -105, -107, -106, -105, -103, -100, -99,
-98, -96, -94, -90, -86, -82, -78, -75, -73, -69, -66, -62, -58, -55, -55, -53,
-51, -46, -43, -40, -38, -38, -38, -35, -31, -28, -24, -23, -22, -21, -19, -17,
-12, -10, -10, -12, -14, -15, -13, -11, -11, -11, -14, -16, -18, -19, -18, -18,
-18, -20, -23, -24, -25, -25, -25, -27, -29, -33, -37, -39, -42, -43, -45, -48,
-52, -57, -61, -64, -66, -66, -70, -73, -78, -80, -82, -82, -83, -86, -90, -93,
-97, -100, -101, -102, -102, -105, -107, -109, -109, -110, -109, -108, -108,
-107, -105, -104, -104, -103, -101, -100, -99, -97, -96, -95, -93, -91, -89,
-86, -83, -78, -73, -68, -65, -63, -59, -56, -51, -46, -41, -37, -34, -30, -27,
-22, -17, -11, -6, -2, 0, 3, 7, 13, 21, 27, 32, 37, 40, 48, 58, 68, 74, 80, 82,
84, 86, 89, 90, 89, 86, 81, 75, 74, 76, 77, 78, 75, 70, 68, 67, 69, 74, 76, 73,
67, 60, 58, 58, 61, 60, 55, 46, 38, 32, 31, 30, 27, 21, 11, 2, -4, -6, -10, -11,
-17, -24, -31, -36, -38, -39, -41, -44, -51, -57, -61, -60, -59, -57, -57, -59,
-62, -64, -63, -62, -61, -64, -68, -74, -78, -81, -83, -83, -83, -85, -87, -89,
-90, -87, -82, -77, -72, -68, -65, -63, -57, -51, -46, -42, -37, -34, -30, -27,
-23, -20, -17, -16, -15, -16, -16, -15, -14, -11, -9, -6, -1, };