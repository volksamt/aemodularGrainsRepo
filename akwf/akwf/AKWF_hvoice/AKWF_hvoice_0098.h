#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0098

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 5, 7, 7, 8, 8, 8, 8, 8, 7, 8,
7, 7, 8, 9, 9, 9, 9, 8, 6, 4, 2, 1, 1, 1, 4, 5, 7, 8, 8, 7, 6, 5, 2, 2, 2, 2, 3,
4, 4, 4, 5, 5, 4, 4, 5, 6, 6, 8, 9, 10, 12, 14, 15, 17, 18, 19, 20, 20, 23, 23,
23, 25, 25, 24, 23, 23, 21, 20, 19, 17, 17, 17, 16, 16, 18, 17, 19, 20, 19, 20,
21, 20, 21, 21, 23, 23, 24, 25, 26, 25, 24, 24, 24, 24, 26, 25, 27, 29, 29, 31,
31, 33, 35, 38, 39, 42, 43, 44, 45, 45, 46, 47, 48, 51, 51, 50, 48, 45, 39, 36,
35, 35, 34, 35, 37, 36, 34, 32, 29, 27, 27, 28, 29, 32, 34, 35, 35, 35, 36, 35,
35, 33, 33, 31, 28, 26, 25, 23, 23, 27, 29, 31, 32, 33, 27, 19, 14, 9, 4, 6, 12,
14, 19, 25, 27, 34, 39, 34, 32, 20, -9, -37, -58, -85, -104, -106, -105, -107,
-108, -109, -111, -117, -120, -110, -103, -93, -79, -69, -59, -49, -41, -31,
-18, -16, -13, -13, -22, -35, -40, -45, -51, -45, -37, -31, -21, -11, -7, -2, 3,
5, 9, 11, 18, 23, 25, 28, 28, 21, 13, 5, -10, -21, -33, -45, -54, -64, -74, -79,
-81, -84, -79, -72, -67, -61, -55, -53, -52, -47, -43, -37, -33, -26, -22, -20,
-22, -23, -27, -29, -28, -26, -24, -19, -13, -10, -4, 2, 8, 16, 22, 28, 35, 38,
38, 39, 37, 36, 32, 26, 22, 15, 6, -1, -8, -16, -22, -28, -33, -35, -38, -38,
-36, -33, -32, -28, -25, -24, -22, -20, -20, -18, -19, -20, -21, -23, -25, -24,
-24, -23, -20, -19, -15, -11, -7, -2, 5, 11, 17, 23, 27, 30, 34, 37, 39, 38, 37,
35, 31, 25, 19, 14, 8, 4, 2, -2, -2, -1, -2, -2, -1, -1, -2, -2, -3, -4, -5, -4,
-5, -5, -7, -8, -11, -16, -18, -22, -25, -25, -23, -22, -19, -15, -12, -6, -3,
3, 9, 12, 18, 22, 24, 25, 27, 26, 26, 25, 24, 23, 21, 17, 14, 12, 8, 8, 8, 8, 9,
10, 10, 9, 9, 9, 8, 7, 6, 6, 4, 2, -1, -4, -9, -13, -15, -18, -19, -20, -20,
-21, -20, -20, -17, -16, -12, -6, -3, 2, 6, 8, 11, 12, 13, 12, 13, 12, 11, 11,
8, 7, 7, 4, 4, 5, 5, 6, 6, 6, 7, 7, 7, 7, 7, 6, 5, 3, 0, -3, -6, -9, -12, -13,
-15, -16, -17, -18, -17, -17, -18, -16, -15, -14, -13, -11, -11, -10, -7, -5,
-4, -2, 0, 0, -1, -2, -2, -3, -4, -3, -1, 0, 2, 3, 3, 2, 3, 3, 4, 4, 5, 5, 5, 4,
3, 2, 0, -1, -1, -1, -3, -3, -4, -6, -7, -8, -10, -12, -12, -13, -12, -10, -9,
-8, -8, -8, -8, -8, -8, -6, -6, -4, -3, -2, 0, };