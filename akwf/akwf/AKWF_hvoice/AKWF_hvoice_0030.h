#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 6, 5, 2, 4, 6, 10, 14, 15, 14,
11, 11, 12, 15, 18, 21, 22, 21, 21, 22, 24, 28, 34, 42, 44, 46, 43, 44, 45, 48,
50, 52, 49, 43, 36, 32, 33, 40, 47, 52, 54, 57, 65, 78, 96, 111, 119, 118, 110,
99, 89, 83, 79, 75, 68, 59, 53, 50, 58, 68, 76, 81, 81, 78, 80, 86, 96, 105,
110, 108, 102, 93, 84, 78, 76, 74, 68, 58, 48, 40, 35, 31, 30, 30, 32, 32, 35,
38, 43, 47, 50, 47, 41, 32, 23, 14, 8, 5, 2, 1, -1, -2, -7, -10, -12, -14, -15,
-17, -19, -22, -26, -29, -31, -33, -34, -34, -35, -35, -34, -33, -31, -29, -28,
-30, -33, -37, -39, -38, -37, -35, -35, -36, -39, -42, -44, -47, -47, -46, -47,
-47, -46, -43, -36, -29, -21, -14, -10, -6, -4, -4, -3, -3, -5, -8, -13, -18,
-22, -23, -22, -19, -15, -11, -9, -5, 0, 3, 8, 13, 17, 19, 21, 21, 22, 22, 23,
22, 20, 16, 12, 8, 4, 2, -1, -2, -2, -2, 0, 1, 5, 7, 11, 12, 14, 11, 9, 5, 2,
-1, -5, -7, -10, -13, -16, -17, -19, -19, -22, -23, -26, -29, -31, -32, -34,
-36, -36, -38, -40, -40, -39, -39, -38, -38, -40, -40, -42, -44, -45, -46, -47,
-48, -49, -50, -49, -51, -52, -52, -54, -55, -56, -57, -56, -55, -52, -50, -46,
-42, -39, -35, -33, -30, -27, -25, -25, -26, -29, -31, -31, -32, -32, -32, -30,
-28, -25, -23, -19, -16, -11, -7, -4, -2, 1, 4, 8, 11, 13, 13, 14, 14, 13, 11,
11, 11, 10, 9, 8, 9, 9, 11, 14, 17, 20, 22, 25, 26, 28, 28, 28, 27, 26, 25, 25,
25, 23, 21, 19, 17, 15, 14, 13, 13, 11, 8, 6, 5, 5, 6, 8, 8, 6, 6, 5, 3, 3, 2,
0, -3, -6, -10, -13, -15, -15, -14, -14, -16, -18, -18, -20, -21, -22, -24, -25,
-26, -26, -26, -26, -25, -26, -25, -25, -25, -24, -25, -26, -26, -27, -28, -28,
-28, -27, -26, -25, -25, -23, -22, -21, -19, -18, -18, -16, -15, -13, -11, -8,
-6, -3, -1, 1, 2, 3, 3, 3, 2, 2, 2, 3, 3, 5, 7, 8, 10, 12, 16, 19, 21, 25, 26,
28, 28, 28, 27, 27, 26, 26, 26, 25, 23, 22, 20, 18, 20, 21, 23, 23, 23, 23, 23,
24, 28, 31, 32, 32, 30, 27, 24, 23, 23, 22, 18, 14, 9, 4, 1, 2, 2, 2, 0, -2, -5,
-5, -5, -5, -5, -7, -8, -11, -11, -12, -13, -13, -15, -18, -23, -25, -27, -29,
-31, -35, -38, -42, -44, -45, -44, -43, -44, -44, -44, -44, -41, -39, -37, -35,
-37, -38, -39, -39, -38, -39, -38, -40, -41, -45, -45, -45, -43, -43, -41, -41,
-41, -39, -37, -32, -26, -22, -20, -19, -18, -16, -13, -11, -7, -7, -5, -7, -9,
-9, -8, -7, -5, -3, -1, -1, };