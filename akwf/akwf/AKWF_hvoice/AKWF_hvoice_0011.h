#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 4, 5, 6, 6, 7, 8, 9, 12,
12, 15, 16, 19, 22, 25, 28, 31, 35, 38, 41, 45, 49, 52, 56, 59, 63, 66, 69, 72,
75, 79, 81, 84, 85, 87, 89, 92, 93, 93, 95, 94, 95, 97, 97, 97, 97, 98, 99, 99,
98, 100, 101, 102, 103, 106, 108, 110, 111, 114, 115, 117, 118, 119, 119, 119,
118, 117, 114, 111, 105, 100, 92, 81, 71, 60, 48, 36, 24, 13, 3, -4, -10, -16,
-18, -20, -20, -19, -18, -15, -12, -9, -6, -3, 1, 3, 6, 7, 9, 9, 8, 7, 4, 1, -3,
-7, -13, -20, -26, -33, -41, -49, -56, -63, -69, -75, -79, -83, -85, -87, -88,
-88, -89, -89, -88, -89, -89, -90, -91, -91, -91, -92, -91, -90, -90, -89, -88,
-86, -84, -83, -80, -77, -74, -72, -68, -64, -60, -57, -52, -48, -45, -41, -38,
-35, -32, -31, -30, -30, -32, -33, -35, -35, -38, -40, -42, -43, -43, -43, -43,
-41, -40, -38, -34, -31, -28, -23, -17, -12, -5, 1, 6, 14, 20, 27, 34, 41, 46,
53, 57, 61, 65, 67, 68, 68, 69, 68, 66, 64, 63, 62, 60, 58, 57, 56, 56, 54, 55,
54, 55, 55, 55, 55, 57, 58, 58, 59, 61, 63, 63, 65, 67, 67, 68, 69, 69, 70, 70,
68, 67, 67, 65, 63, 62, 60, 58, 57, 55, 54, 53, 51, 49, 48, 45, 44, 42, 40, 38,
35, 32, 28, 25, 21, 17, 14, 10, 5, 3, -1, -5, -9, -11, -13, -16, -18, -20, -23,
-24, -25, -28, -30, -31, -31, -32, -33, -33, -34, -34, -34, -35, -35, -36, -39,
-39, -42, -44, -48, -50, -53, -57, -59, -62, -64, -67, -70, -71, -72, -73, -74,
-74, -75, -74, -75, -74, -72, -72, -70, -69, -68, -65, -63, -62, -59, -57, -56,
-54, -53, -51, -49, -48, -46, -45, -44, -43, -40, -39, -37, -36, -34, -32, -30,
-29, -28, -26, -23, -21, -20, -19, -17, -16, -14, -12, -11, -9, -8, -6, -5, -3,
-1, 0, 3, 4, 6, 7, 10, 12, 15, 16, 19, 21, 24, 27, 30, 33, 36, 39, 42, 44, 45,
48, 50, 50, 52, 53, 53, 54, 54, 54, 53, 53, 52, 51, 50, 50, 48, 46, 45, 44, 43,
41, 40, 40, 39, 39, 37, 37, 37, 37, 36, 34, 33, 32, 30, 28, 27, 26, 24, 22, 20,
19, 16, 14, 12, 9, 8, 6, 4, 1, 0, -3, -5, -7, -8, -11, -13, -15, -18, -20, -22,
-25, -27, -29, -32, -36, -37, -40, -44, -47, -49, -51, -54, -56, -58, -60, -61,
-62, -63, -64, -64, -65, -66, -65, -66, -66, -64, -64, -64, -63, -63, -62, -62,
-62, -62, -61, -61, -61, -62, -61, -61, -62, -62, -62, -60, -61, -60, -58, -58,
-58, -58, -56, -54, -54, -52, -51, -50, -48, -46, -44, -42, -40, -38, -36, -35,
-32, -30, -28, -27, -25, -22, -22, -19, -17, -15, -14, -12, -10, -9, -6, -5, -2,
-1, };