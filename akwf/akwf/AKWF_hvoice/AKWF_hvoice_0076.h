#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0076

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 2, 2, 3, 3, 4, 5, 5, 6, 6, 7, 8,
8, 10, 10, 10, 10, 11, 13, 13, 14, 15, 14, 16, 16, 18, 19, 19, 19, 21, 22, 23,
24, 26, 26, 27, 28, 28, 29, 30, 31, 31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 41,
42, 43, 44, 45, 45, 46, 48, 48, 49, 49, 50, 51, 51, 53, 53, 53, 55, 54, 56, 56,
58, 58, 58, 58, 60, 60, 60, 61, 60, 60, 61, 61, 61, 62, 62, 63, 63, 63, 63, 64,
64, 64, 65, 66, 65, 67, 67, 66, 67, 67, 67, 69, 69, 69, 70, 71, 71, 71, 71, 72,
72, 72, 73, 73, 74, 73, 73, 74, 75, 74, 76, 76, 77, 77, 77, 79, 79, 79, 80, 81,
81, 82, 84, 84, 85, 86, 86, 87, 87, 88, 89, 89, 90, 91, 91, 92, 93, 93, 94, 94,
96, 96, 96, 96, 98, 98, 98, 99, 99, 101, 101, 101, 102, 102, 102, 103, 103, 103,
102, 101, 100, 99, 97, 96, 95, 92, 90, 88, 87, 85, 82, 80, 77, 74, 72, 68, 65,
61, 58, 54, 51, 47, 44, 39, 36, 32, 28, 23, 20, 16, 12, 9, 4, 1, -4, -9, -12,
-17, -22, -27, -30, -35, -38, -43, -46, -50, -53, -57, -60, -64, -67, -70, -73,
-76, -79, -81, -84, -88, -90, -93, -95, -96, -99, -101, -103, -105, -107, -108,
-109, -111, -112, -112, -114, -114, -116, -116, -117, -117, -118, -118, -119,
-119, -119, -119, -119, -118, -118, -117, -117, -117, -115, -115, -114, -113,
-113, -112, -111, -109, -108, -107, -107, -105, -103, -102, -101, -100, -98,
-97, -96, -95, -94, -92, -91, -91, -89, -87, -87, -85, -85, -83, -82, -81, -80,
-79, -77, -76, -75, -74, -72, -71, -70, -68, -68, -67, -65, -64, -63, -62, -61,
-60, -60, -58, -58, -57, -57, -56, -56, -55, -54, -54, -53, -53, -52, -52, -52,
-51, -50, -50, -49, -49, -48, -47, -47, -46, -46, -44, -44, -43, -43, -42, -42,
-41, -40, -39, -38, -38, -37, -37, -36, -35, -35, -34, -34, -33, -33, -32, -31,
-31, -31, -30, -29, -29, -28, -29, -28, -27, -27, -26, -25, -25, -24, -23, -22,
-22, -21, -20, -19, -19, -18, -17, -17, -16, -15, -15, -14, -13, -12, -12, -12,
-11, -10, -10, -9, -9, -7, -6, -7, -5, -5, -5, -4, -4, -3, -2, -2, -1, -1, 1, 1,
1, 1, 2, 2, 2, 4, 3, 4, 4, 4, 5, 4, 5, 6, 6, 6, 7, 6, 6, 7, 7, 7, 7, 7, 6, 8, 7,
8, 8, 9, 8, 8, 9, 9, 9, 9, 9, 9, 9, 8, 9, 8, 8, 8, 7, 6, 6, 6, 4, 5, 4, 4, 3, 3,
2, 2, 1, 0, -1, 0, -1, -2, -2, -2, -2, -2, -2, -2, -2, -3, -2, -2, -2, -3, -2,
-3, -3, -3, -2, -3, -3, -4, -3, -3, -3, -3, -3, -2, -3, -2, -2, -2, -1, -2, -1,
-2, -1, -1, -1, 0, };