#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 3, 3, 4, 3, 5, 6, 6, 7, 7, 8,
9, 9, 9, 11, 10, 11, 11, 12, 12, 12, 13, 14, 15, 15, 15, 14, 13, 12, 12, 10, 10,
11, 13, 13, 14, 15, 15, 15, 15, 15, 15, 14, 13, 14, 14, 14, 15, 16, 17, 17, 16,
16, 16, 16, 17, 19, 19, 18, 18, 19, 19, 20, 21, 21, 21, 21, 21, 22, 22, 25, 26,
28, 28, 29, 28, 28, 30, 32, 33, 34, 35, 35, 35, 36, 37, 39, 41, 41, 42, 43, 43,
44, 45, 48, 50, 52, 54, 53, 52, 52, 52, 54, 55, 56, 56, 56, 57, 55, 55, 55, 56,
58, 59, 60, 60, 58, 56, 55, 54, 54, 54, 53, 52, 50, 50, 51, 51, 52, 52, 50, 47,
46, 44, 43, 44, 43, 43, 41, 39, 39, 38, 38, 38, 37, 33, 29, 25, 23, 21, 21, 23,
24, 23, 22, 22, 25, 29, 34, 32, 23, 9, -11, -29, -41, -47, -49, -48, -52, -58,
-64, -68, -68, -65, -60, -58, -60, -66, -73, -80, -87, -93, -101, -107, -114,
-119, -119, -115, -109, -102, -97, -94, -92, -91, -87, -82, -76, -71, -68, -70,
-71, -75, -75, -73, -68, -62, -55, -47, -42, -36, -30, -25, -19, -13, -9, -6,
-4, -4, -4, -5, -5, -5, -6, -8, -7, -7, -6, -2, 1, 5, 8, 7, 6, 5, 2, 0, -3, -6,
-10, -13, -18, -22, -26, -28, -29, -29, -29, -29, -28, -27, -28, -27, -28, -31,
-32, -34, -37, -39, -41, -44, -44, -44, -44, -41, -40, -38, -36, -33, -30, -26,
-24, -23, -22, -22, -21, -22, -21, -20, -18, -17, -16, -13, -9, -6, -1, 2, 6, 9,
9, 11, 11, 11, 10, 11, 10, 10, 11, 10, 11, 11, 12, 13, 15, 16, 16, 16, 16, 16,
14, 13, 12, 10, 10, 8, 6, 5, 4, 3, 1, 1, -1, 0, 0, 1, 1, 0, -1, -2, -3, -6, -7,
-9, -10, -11, -11, -11, -10, -8, -8, -7, -6, -5, -5, -4, -3, -4, -2, -1, -2, -1,
-1, -2, -2, -2, 0, 3, 4, 6, 8, 9, 10, 10, 11, 11, 11, 12, 11, 11, 12, 13, 14,
13, 12, 12, 12, 13, 14, 15, 15, 15, 13, 10, 8, 6, 5, 6, 6, 6, 6, 6, 4, 5, 3, 3,
2, 4, 3, 4, 4, 1, -1, -2, -4, -5, -5, -6, -6, -6, -5, -6, -5, -4, -4, -4, -5,
-5, -5, -5, -5, -4, -5, -6, -8, -10, -10, -10, -8, -6, -4, -3, -3, -3, -3, -3,
-2, -1, -1, -1, -1, 0, 1, 1, 0, -1, -2, -3, -2, -1, 1, 2, 3, 3, 3, 2, 1, 1, 1,
1, 2, 1, -1, -2, -2, -2, -4, -3, -4, -6, -5, -4, -5, -4, -3, -4, -5, -6, -7, -7,
-7, -8, -9, -9, -10, -10, -9, -10, -9, -10, -9, -10, -10, -9, -8, -8, -7, -7,
-6, -7, -7, -7, -7, -6, -5, -4, -4, -3, -3, -3, -1, 0, };