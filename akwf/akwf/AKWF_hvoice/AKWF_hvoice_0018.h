#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 3, 4, 4, 4, 5, 4, 5, 6, 5, 5,
6, 8, 7, 8, 8, 8, 7, 7, 8, 8, 9, 11, 11, 12, 12, 11, 12, 13, 13, 14, 13, 14, 14,
13, 14, 13, 14, 15, 17, 17, 17, 18, 17, 17, 17, 19, 19, 21, 19, 19, 20, 19, 20,
20, 21, 22, 22, 23, 23, 24, 25, 24, 26, 25, 25, 26, 27, 28, 28, 29, 29, 30, 31,
32, 33, 33, 34, 34, 35, 37, 38, 39, 39, 40, 41, 41, 42, 45, 46, 47, 49, 49, 52,
53, 55, 56, 56, 55, 55, 57, 57, 58, 58, 58, 59, 59, 60, 61, 61, 60, 60, 60, 61,
62, 63, 63, 62, 59, 58, 57, 57, 57, 56, 55, 55, 55, 54, 55, 56, 55, 55, 53, 51,
51, 51, 50, 49, 49, 47, 46, 46, 46, 44, 42, 38, 34, 30, 29, 28, 28, 28, 27, 26,
25, 25, 27, 32, 32, 32, 25, 12, -3, -17, -29, -36, -43, -49, -57, -66, -77, -84,
-89, -91, -90, -88, -88, -90, -90, -90, -92, -91, -94, -98, -104, -110, -114,
-115, -115, -116, -117, -118, -119, -118, -116, -111, -104, -97, -89, -82, -74,
-68, -63, -58, -54, -50, -47, -45, -43, -40, -38, -36, -32, -30, -28, -27, -24,
-22, -17, -12, -7, -1, 3, 5, 7, 8, 8, 7, 8, 7, 5, 2, 0, -4, -6, -9, -13, -15,
-17, -18, -19, -19, -18, -18, -18, -20, -21, -22, -25, -27, -28, -30, -32, -34,
-37, -39, -42, -44, -46, -46, -46, -45, -43, -42, -40, -37, -35, -34, -31, -30,
-29, -27, -27, -25, -24, -23, -20, -19, -18, -16, -16, -13, -12, -10, -8, -5,
-3, 0, 3, 6, 8, 10, 12, 12, 14, 13, 15, 16, 17, 17, 17, 16, 14, 14, 14, 13, 14,
13, 14, 14, 14, 13, 12, 12, 11, 11, 8, 8, 8, 6, 5, 3, 1, -1, -2, -4, -6, -6, -6,
-8, -8, -8, -8, -8, -8, -7, -6, -7, -7, -8, -8, -7, -7, -7, -6, -7, -8, -7, -5,
-4, -3, -1, 0, 1, 3, 4, 5, 7, 8, 9, 10, 12, 12, 13, 13, 13, 13, 13, 13, 12, 12,
14, 14, 14, 15, 16, 15, 15, 14, 14, 15, 14, 13, 12, 11, 10, 9, 8, 7, 6, 4, 4, 3,
3, 2, 2, 1, 0, 0, 0, 0, 0, 0, -1, -1, -3, -4, -4, -6, -6, -7, -8, -8, -7, -8,
-7, -8, -8, -8, -8, -7, -5, -5, -4, -5, -5, -4, -4, -5, -3, -4, -2, -3, -2, -2,
-1, -1, -1, -1, -1, -2, 0, -1, 0, 0, 0, 0, 0, -1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1,
0, -1, -1, -3, -2, -2, -3, -4, -5, -6, -7, -8, -7, -7, -6, -7, -7, -7, -8, -8,
-9, -9, -9, -8, -9, -8, -8, -7, -7, -6, -6, -6, -5, -7, -6, -6, -6, -6, -6, -5,
-6, -7, -6, -6, -4, -4, -4, -3, -3, -2, -1, };