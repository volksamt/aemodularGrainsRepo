#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0104

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 12, 18, 24, 30, 36, 42, 47, 52,
58, 62, 68, 72, 76, 81, 85, 88, 93, 97, 101, 104, 108, 111, 113, 116, 116, 118,
119, 119, 119, 118, 118, 116, 116, 114, 112, 110, 108, 105, 102, 99, 96, 93, 88,
85, 79, 74, 69, 63, 57, 53, 46, 41, 34, 29, 23, 17, 11, 5, 0, -6, -12, -17, -23,
-28, -34, -40, -45, -50, -55, -59, -64, -68, -72, -75, -78, -80, -84, -85, -88,
-90, -91, -93, -94, -95, -96, -96, -96, -97, -97, -96, -94, -94, -92, -90, -87,
-85, -83, -80, -79, -75, -73, -69, -66, -63, -60, -56, -53, -49, -45, -40, -36,
-32, -28, -24, -21, -16, -11, -9, -5, -1, 3, 5, 10, 13, 15, 18, 21, 24, 27, 30,
32, 35, 37, 38, 41, 42, 43, 45, 46, 46, 47, 46, 47, 48, 48, 49, 48, 49, 48, 48,
47, 47, 46, 44, 43, 42, 41, 39, 37, 36, 33, 32, 30, 29, 28, 26, 24, 22, 21, 20,
17, 16, 14, 13, 10, 9, 7, 5, 3, 1, 0, -1, -2, -3, -5, -4, -6, -7, -7, -7, -9,
-9, -10, -10, -11, -11, -11, -13, -13, -12, -12, -11, -11, -11, -10, -9, -9, -8,
-8, -8, -8, -8, -8, -7, -6, -6, -6, -5, -4, -3, -2, -1, 0, -1, -1, 0, 0, 0, -1,
-1, -1, -3, -3, -4, -5, -6, -7, -6, -8, -8, -8, -9, -9, -10, -10, -10, -10, -9,
-8, -7, -6, -5, -4, -3, -2, -1, -1, 1, 2, 2, 2, 2, 4, 4, 4, 4, 5, 4, 4, 4, 3, 4,
5, 4, 4, 4, 4, 4, 3, 3, 2, 1, 1, 0, -1, -1, -2, -1, -2, -2, -2, -3, -3, -5, -5,
-6, -7, -7, -8, -8, -9, -9, -9, -9, -9, -10, -10, -10, -9, -10, -9, -9, -9, -9,
-9, -8, -8, -8, -7, -8, -7, -6, -6, -5, -4, -3, -1, 0, 1, 2, 2, 4, 4, 5, 5, 5,
7, 7, 8, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 17, 18, 17, 17, 18, 17, 17, 17,
18, 17, 17, 16, 16, 17, 16, 15, 15, 15, 14, 14, 13, 12, 11, 10, 9, 7, 8, 6, 5,
5, 4, 4, 3, 3, 2, 1, 0, 0, -2, -1, -3, -5, -5, -5, -5, -6, -6, -7, -7, -8, -8,
-8, -8, -8, -9, -9, -9, -9, -9, -9, -10, -10, -10, -10, -11, -10, -10, -10, -10,
-9, -9, -9, -8, -8, -8, -7, -7, -7, -6, -7, -7, -6, -6, -5, -5, -5, -4, -3, -2,
-3, -2, -3, -2, -2, -2, -2, -3, -3, -4, -4, -4, -4, -4, -4, -5, -5, -3, -3, -4,
-4, -4, -5, -7, -7, -9, -12, -15, -19, -23, -27, -31, -33, -36, -39, -42, -42,
-45, -46, -48, -51, -53, -56, -59, -60, -61, -63, -65, -65, -66, -66, -67, -66,
-65, -64, -62, -60, -57, -55, -53, -50, -46, -44, -40, -37, -32, -29, -23, -20,
-14, -10, -4, };