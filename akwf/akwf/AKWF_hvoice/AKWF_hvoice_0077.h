#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0077

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 5, 7, 8, 10, 11, 13, 13, 15, 16,
18, 21, 23, 25, 27, 29, 31, 33, 34, 35, 35, 36, 36, 37, 37, 36, 36, 35, 36, 37,
38, 38, 40, 40, 40, 41, 40, 40, 40, 40, 39, 39, 38, 38, 37, 37, 36, 35, 33, 32,
31, 29, 28, 28, 26, 25, 23, 23, 21, 20, 19, 16, 17, 15, 15, 14, 14, 14, 14, 14,
14, 14, 12, 10, 10, 8, 6, 6, 5, 5, 4, 5, 6, 7, 9, 9, 9, 9, 9, 10, 11, 11, 12,
12, 12, 14, 16, 17, 19, 20, 23, 24, 26, 28, 28, 30, 31, 32, 32, 32, 33, 34, 35,
35, 36, 39, 41, 42, 44, 45, 47, 48, 50, 49, 50, 51, 51, 51, 52, 52, 53, 53, 55,
54, 54, 55, 55, 54, 55, 54, 55, 55, 53, 55, 53, 54, 54, 53, 53, 52, 52, 51, 50,
49, 47, 45, 43, 42, 41, 40, 39, 38, 37, 35, 35, 35, 34, 34, 34, 34, 34, 34, 33,
33, 30, 24, 17, 8, -2, -13, -24, -34, -43, -52, -58, -64, -67, -68, -69, -70,
-71, -73, -74, -77, -79, -82, -84, -87, -91, -92, -96, -97, -100, -102, -105,
-107, -111, -114, -116, -119, -120, -119, -117, -116, -114, -110, -105, -101,
-96, -91, -85, -79, -73, -67, -62, -57, -52, -47, -42, -39, -36, -33, -30, -28,
-26, -24, -21, -18, -16, -12, -7, -3, 2, 7, 12, 17, 23, 27, 33, 36, 41, 45, 46,
48, 49, 49, 48, 47, 43, 41, 39, 35, 33, 29, 27, 24, 22, 20, 19, 17, 16, 15, 14,
13, 12, 10, 7, 3, -1, -4, -10, -15, -19, -23, -28, -31, -37, -40, -44, -48, -51,
-55, -59, -63, -65, -68, -70, -70, -72, -72, -71, -70, -70, -69, -69, -67, -67,
-67, -66, -67, -66, -65, -65, -65, -65, -64, -62, -62, -60, -57, -53, -50, -46,
-42, -36, -32, -26, -21, -17, -12, -9, -5, -2, 1, 2, 5, 7, 10, 12, 13, 17, 19,
22, 25, 27, 29, 30, 32, 33, 34, 35, 36, 38, 39, 40, 42, 44, 45, 45, 45, 45, 43,
43, 40, 38, 35, 32, 30, 28, 25, 22, 20, 18, 16, 13, 11, 9, 7, 5, 3, 0, -3, -4,
-6, -8, -12, -14, -16, -19, -21, -24, -26, -27, -28, -31, -32, -32, -32, -32,
-33, -33, -33, -32, -31, -31, -30, -30, -31, -30, -30, -29, -28, -28, -26, -24,
-22, -19, -18, -15, -14, -12, -11, -9, -8, -6, -5, -2, 0, 3, 4, 7, 9, 11, 14,
14, 16, 16, 17, 18, 19, 20, 21, 22, 24, 26, 27, 28, 28, 28, 29, 27, 27, 26, 24,
23, 22, 21, 20, 19, 18, 18, 16, 17, 15, 13, 13, 11, 10, 8, 6, 4, 2, 0, -1, -2,
-3, -5, -6, -7, -8, -9, -10, -11, -13, -13, -15, -15, -17, -18, -18, -19, -20,
-20, -19, -19, -17, -18, -17, -17, -17, -17, -16, -15, -13, -14, -11, -9, -7,
-5, -4, -1, };