#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0047

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 6, 10, 14, 16, 17, 18, 18, 20, 24,
26, 31, 33, 35, 37, 40, 43, 48, 53, 64, 76, 86, 102, 114, 119, 118, 108, 100,
93, 91, 93, 96, 88, 77, 59, 40, 25, 14, 8, 2, -4, -8, -12, -19, -27, -33, -37,
-42, -45, -43, -44, -46, -50, -55, -56, -56, -55, -54, -56, -63, -67, -71, -72,
-64, -57, -49, -40, -36, -31, -29, -27, -23, -19, -12, -3, 2, 6, 3, -5, -12,
-21, -28, -30, -32, -36, -40, -46, -52, -56, -58, -56, -53, -52, -51, -48, -46,
-44, -39, -35, -30, -25, -23, -23, -24, -27, -31, -32, -31, -27, -25, -23, -23,
-26, -28, -29, -26, -20, -13, -6, -2, 2, 4, 5, 6, 5, 6, 5, 5, 4, 1, -4, -8, -12,
-15, -16, -17, -19, -19, -19, -16, -13, -7, -1, 6, 11, 14, 18, 19, 23, 23, 25,
26, 26, 26, 23, 21, 16, 11, 6, 4, 3, 1, 0, 0, 0, -2, -3, -2, -1, 2, 4, 7, 10,
12, 16, 18, 18, 16, 14, 11, 9, 8, 7, 7, 9, 12, 15, 18, 19, 21, 22, 22, 26, 30,
38, 43, 46, 46, 44, 40, 33, 28, 24, 19, 16, 14, 12, 9, 2, -3, -9, -13, -16, -15,
-14, -13, -10, -9, -8, -6, -5, -5, -8, -9, -9, -10, -10, -7, -4, -3, -4, -3, -3,
-4, -4, -2, 2, 8, 13, 19, 25, 26, 23, 23, 22, 21, 20, 21, 23, 22, 18, 14, 9, 4,
2, 2, 2, 3, 2, 1, 2, 1, 2, 4, 8, 10, 13, 15, 19, 22, 27, 35, 38, 40, 39, 38, 37,
38, 41, 48, 53, 55, 59, 63, 67, 77, 91, 101, 106, 106, 100, 95, 91, 90, 92, 86,
74, 64, 44, 25, 8, -8, -22, -36, -45, -50, -58, -68, -80, -92, -101, -105, -103,
-99, -96, -94, -94, -96, -93, -87, -82, -80, -80, -79, -77, -72, -66, -61, -54,
-46, -37, -26, -18, -11, -5, -2, 7, 22, 35, 49, 52, 50, 43, 35, 26, 19, 15, 8,
-1, -12, -22, -33, -49, -61, -73, -83, -90, -93, -96, -96, -99, -100, -97, -93,
-85, -79, -75, -72, -68, -62, -54, -45, -34, -27, -21, -17, -14, -8, -4, 4, 13,
25, 36, 49, 58, 63, 66, 66, 69, 72, 78, 82, 81, 77, 70, 59, 47, 34, 23, 10, -3,
-13, -21, -26, -33, -39, -47, -52, -58, -61, -61, -60, -56, -51, -45, -36, -29,
-24, -21, -18, -17, -11, -5, 4, 13, 22, 28, 33, 38, 43, 46, 51, 58, 66, 77, 89,
98, 102, 99, 95, 86, 75, 69, 63, 55, 47, 37, 26, 13, -2, -16, -28, -40, -50,
-53, -54, -54, -53, -49, -46, -44, -41, -35, -30, -26, -18, -10, -1, 4, 11, 16,
17, 16, 16, 15, 17, 19, 25, 30, 33, 35, 34, 31, 27, 24, 23, 24, 26, 25, 25, 21,
14, 3, -5, -13, -21, -24, -23, -25, -30, -32, -34, -36, -37, -33, -28, -24, -19,
-13, -8, -4, -1, };