#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0041

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 9, 9, 13, 19, 21, 19, 28, 37,
38, 41, 50, 52, 43, 40, 40, 37, 30, 32, 35, 32, 30, 29, 27, 24, 32, 52, 78, 99,
116, 117, 100, 76, 59, 52, 51, 54, 52, 41, 23, 3, -17, -32, -41, -46, -50, -52,
-50, -49, -49, -50, -46, -40, -33, -30, -29, -35, -44, -49, -50, -44, -35, -28,
-25, -28, -33, -37, -36, -30, -21, -5, 8, 18, 20, 20, 14, 8, -1, -4, -7, -12,
-18, -27, -37, -43, -47, -48, -48, -49, -52, -54, -55, -53, -48, -39, -29, -21,
-15, -11, -11, -12, -11, -4, 8, 20, 30, 35, 34, 27, 21, 20, 21, 25, 26, 26, 23,
18, 13, 7, 5, 4, -1, -7, -15, -22, -32, -39, -40, -38, -35, -32, -32, -36, -43,
-48, -48, -41, -33, -20, -9, -2, 0, 2, 4, 7, 11, 18, 25, 29, 31, 31, 28, 25, 24,
22, 20, 17, 10, 1, -7, -14, -17, -19, -19, -21, -26, -33, -39, -44, -47, -46,
-40, -33, -27, -21, -17, -16, -15, -13, -9, -4, 0, 6, 11, 15, 16, 18, 21, 24,
25, 25, 25, 23, 20, 19, 17, 15, 14, 10, 5, -1, -9, -17, -21, -26, -28, -28, -27,
-26, -25, -25, -21, -19, -16, -11, -4, 1, 6, 12, 17, 21, 25, 28, 29, 30, 33, 34,
36, 39, 41, 44, 45, 46, 45, 41, 36, 33, 29, 25, 21, 18, 14, 14, 19, 26, 33, 38,
39, 33, 23, 16, 17, 19, 24, 27, 28, 22, 16, 8, 2, -5, -7, -10, -12, -14, -13,
-13, -17, -19, -18, -18, -17, -17, -17, -18, -19, -19, -17, -13, -10, -7, -7,
-11, -14, -15, -14, -12, -5, 1, 6, 12, 13, 13, 11, 11, 10, 8, 8, 9, 9, 7, 7, 8,
7, 7, 8, 7, 4, 2, 3, 3, 2, 6, 9, 10, 8, 8, 6, 6, 13, 25, 49, 73, 90, 94, 87, 71,
53, 42, 42, 44, 45, 41, 28, 12, -6, -18, -30, -38, -41, -44, -45, -47, -47, -45,
-43, -38, -33, -28, -28, -33, -41, -49, -50, -45, -36, -26, -19, -18, -23, -28,
-28, -22, -14, -2, 12, 23, 28, 28, 24, 17, 11, 4, -2, -11, -20, -32, -44, -52,
-56, -57, -56, -56, -58, -63, -65, -63, -59, -48, -35, -23, -14, -9, -7, -10,
-12, -14, -13, -11, -7, -4, -1, 2, 5, 8, 11, 14, 18, 21, 22, 24, 24, 27, 28, 25,
21, 12, -1, -18, -32, -41, -47, -50, -51, -51, -53, -56, -58, -57, -52, -46,
-34, -22, -10, 0, 7, 12, 16, 21, 26, 30, 31, 33, 32, 32, 33, 36, 39, 41, 44, 41,
38, 33, 29, 26, 25, 23, 20, 14, 8, -2, -10, -19, -25, -29, -31, -29, -26, -23,
-21, -18, -13, -8, -2, 4, 9, 13, 18, 20, 23, 24, 25, 24, 24, 21, 16, 12, 8, 6,
2, 3, 5, 6, 6, 7, 7, 6, 6, 7, 9, 9, 10, 9, 6, 3, 0, -3, -5, -2, -1, -1, };