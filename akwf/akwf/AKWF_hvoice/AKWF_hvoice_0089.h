#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0089

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 1, 2, 3, 4, 4, 5, 5, 5, 6, 6,
6, 7, 7, 6, 7, 6, 7, 8, 7, 7, 7, 7, 6, 7, 6, 6, 5, 6, 5, 5, 4, 4, 4, 4, 4, 3, 3,
3, 2, 3, 3, 3, 3, 2, 3, 2, 2, 2, 3, 3, 2, 3, 2, 2, 3, 3, 2, 2, 3, 2, 2, 2, 2, 1,
2, 2, 2, 0, 1, 0, 1, 1, 0, 0, 0, 1, 0, -1, 1, 1, 1, 1, 1, 1, 1, 2, 2, 2, 2, 2,
3, 4, 4, 4, 5, 5, 7, 6, 8, 7, 8, 9, 9, 10, 11, 12, 12, 12, 14, 15, 16, 17, 18,
19, 21, 21, 23, 24, 25, 27, 28, 29, 31, 31, 32, 34, 35, 36, 37, 39, 39, 41, 42,
43, 44, 44, 45, 46, 47, 47, 48, 50, 51, 51, 53, 54, 55, 56, 58, 59, 61, 63, 64,
66, 69, 71, 73, 76, 79, 81, 84, 87, 90, 93, 96, 99, 101, 105, 107, 110, 111,
113, 114, 116, 117, 118, 119, 119, 119, 118, 118, 118, 116, 115, 113, 112, 110,
109, 107, 105, 102, 100, 99, 96, 95, 93, 89, 88, 86, 85, 82, 81, 79, 78, 76, 75,
73, 71, 70, 67, 66, 64, 63, 60, 58, 55, 54, 51, 48, 45, 43, 41, 37, 34, 31, 27,
24, 21, 18, 14, 11, 6, 3, -2, -5, -9, -12, -16, -19, -23, -27, -30, -34, -37,
-41, -44, -48, -51, -53, -56, -58, -60, -64, -66, -67, -70, -70, -73, -74, -75,
-76, -76, -78, -78, -78, -79, -79, -78, -80, -79, -79, -78, -78, -78, -78, -78,
-77, -77, -77, -76, -76, -75, -76, -75, -75, -75, -75, -74, -74, -73, -73, -72,
-72, -70, -70, -69, -67, -66, -64, -62, -61, -59, -56, -54, -52, -50, -47, -45,
-41, -39, -36, -33, -32, -29, -25, -23, -20, -18, -16, -14, -11, -10, -8, -6,
-5, -2, 0, 1, 2, 3, 4, 6, 7, 7, 9, 9, 9, 10, 11, 11, 11, 12, 12, 12, 12, 12, 13,
13, 13, 12, 13, 13, 12, 13, 12, 12, 13, 13, 13, 12, 11, 12, 12, 10, 10, 10, 9,
8, 9, 8, 7, 6, 6, 4, 4, 2, 2, 0, -1, -2, -4, -6, -7, -8, -9, -12, -14, -15, -18,
-19, -20, -23, -25, -27, -28, -30, -32, -34, -36, -37, -39, -40, -41, -42, -43,
-44, -45, -46, -46, -48, -47, -48, -48, -48, -48, -49, -49, -49, -50, -50, -49,
-50, -50, -49, -50, -50, -51, -51, -51, -51, -51, -51, -51, -52, -52, -52, -52,
-52, -52, -52, -52, -52, -51, -50, -51, -50, -49, -50, -49, -48, -48, -46, -46,
-45, -44, -43, -42, -41, -40, -39, -38, -37, -34, -34, -33, -31, -29, -28, -27,
-26, -25, -24, -23, -21, -20, -19, -18, -18, -16, -16, -15, -15, -14, -12, -12,
-12, -11, -10, -10, -10, -8, -8, -8, -7, -7, -6, -6, -5, -5, -4, -4, -3, -3, -3,
-1, -2, -2, 0, 0, };