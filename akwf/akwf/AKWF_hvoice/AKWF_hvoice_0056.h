#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0056

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 20, 38, 51, 60, 67, 79, 89, 94,
91, 82, 76, 71, 62, 51, 36, 25, 18, 14, 7, 0, -4, -7, -9, -11, -14, -20, -27,
-35, -42, -50, -62, -75, -85, -92, -99, -108, -117, -119, -116, -109, -106,
-100, -91, -75, -60, -48, -37, -28, -16, -6, 0, 3, 3, 6, 9, 11, 12, 13, 15, 21,
26, 34, 40, 43, 48, 54, 60, 62, 57, 53, 50, 46, 38, 25, 13, 5, -2, -9, -19, -27,
-29, -27, -25, -24, -23, -18, -11, -5, -1, 1, 3, 5, 6, 6, 3, 1, -1, -1, 0, 4, 5,
7, 12, 20, 28, 34, 37, 41, 46, 51, 49, 43, 38, 34, 28, 19, 7, -4, -11, -16, -24,
-32, -37, -39, -39, -40, -40, -41, -41, -40, -40, -41, -43, -46, -49, -49, -51,
-53, -56, -57, -53, -48, -43, -38, -31, -22, -9, 1, 8, 14, 23, 31, 36, 37, 37,
38, 38, 37, 33, 29, 27, 26, 24, 24, 23, 23, 22, 23, 25, 25, 23, 20, 17, 14, 11,
4, -5, -10, -15, -19, -25, -31, -33, -32, -29, -29, -26, -22, -16, -9, -5, -2,
2, 6, 9, 11, 10, 9, 9, 9, 9, 9, 7, 8, 9, 10, 12, 14, 15, 17, 17, 21, 19, 17, 13,
9, 7, 1, -7, -14, -20, -24, -29, -35, -39, -40, -39, -38, -39, -37, -35, -31,
-28, -25, -23, -20, -18, -16, -16, -14, -14, -14, -12, -8, -6, -4, -1, 3, 10,
16, 20, 24, 29, 34, 38, 39, 38, 36, 37, 34, 30, 25, 20, 17, 14, 11, 7, 5, 3, 4,
3, 3, 2, 2, 1, 0, -1, -3, -7, -9, -11, -13, -16, -20, -22, -22, -20, -19, -19,
-17, -12, -7, -3, -1, 2, 6, 10, 13, 13, 12, 12, 11, 11, 8, 5, 5, 4, 3, 1, 1, 1,
1, 1, 2, 1, 0, 0, -2, -2, -4, -8, -11, -15, -17, -19, -23, -25, -27, -26, -23,
-23, -22, -18, -15, -11, -8, -4, -1, 1, 5, 7, 8, 8, 9, 11, 11, 11, 12, 13, 15,
16, 20, 21, 23, 24, 27, 28, 29, 28, 25, 24, 21, 19, 13, 8, 5, 2, -1, -4, -7, -8,
-8, -7, -8, -8, -8, -6, -5, -5, -5, -6, -7, -7, -7, -9, -9, -9, -9, -9, -8, -7,
-6, -4, -2, 3, 4, 5, 7, 10, 12, 12, 11, 9, 8, 8, 6, 2, 0, -3, -3, -5, -6, -8,
-8, -7, -6, -6, -6, -6, -7, -7, -7, -9, -10, -13, -13, -13, -14, -15, -15, -14,
-11, -9, -8, -6, -3, 1, 5, 7, 9, 11, 15, 17, 17, 17, 17, 18, 18, 19, 19, 19, 19,
20, 22, 22, 23, 22, 22, 22, 22, 21, 20, 19, 17, 15, 14, 11, 8, 6, 5, 3, 1, 0, 0,
1, 1, 1, 2, 3, 5, 5, 5, 5, 6, 4, 4, 4, 2, 2, 0, 1, 2, 2, 2, 4, 5, 8, 9, 8, 6, 2,
0, -1, -5, -10, -16, -17, -12, -8, -3, };