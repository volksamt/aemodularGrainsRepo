#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0054

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 3, 3, 1, 1, 3, 3, 1, 1, 4, 6, 5, 2,
1, 2, 3, 5, 9, 12, 13, 10, 7, 7, 9, 15, 17, 14, 9, 9, 12, 15, 14, 14, 14, 15,
13, 13, 14, 16, 20, 23, 22, 17, 14, 15, 21, 29, 31, 28, 24, 23, 26, 29, 31, 32,
33, 33, 31, 32, 33, 35, 35, 36, 40, 42, 41, 39, 36, 38, 43, 46, 48, 48, 47, 49,
50, 52, 58, 62, 61, 60, 58, 57, 58, 61, 63, 63, 60, 58, 58, 59, 61, 61, 66, 70,
70, 66, 62, 66, 73, 79, 77, 71, 68, 72, 77, 83, 82, 82, 80, 78, 77, 76, 78, 80,
80, 78, 78, 77, 80, 83, 85, 85, 79, 71, 62, 60, 66, 77, 83, 78, 68, 62, 66, 84,
107, 120, 113, 84, 42, 5, -10, -2, 14, 19, 4, -20, -37, -36, -17, 10, 32, 40,
34, 20, 11, 10, 21, 34, 42, 34, 18, -1, -12, -8, 0, 6, 1, -16, -31, -37, -32,
-22, -15, -15, -21, -28, -29, -26, -21, -17, -14, -13, -18, -26, -30, -28, -25,
-21, -23, -30, -39, -47, -46, -40, -36, -39, -46, -51, -52, -49, -48, -45, -41,
-36, -37, -42, -45, -46, -42, -36, -32, -36, -44, -50, -49, -45, -41, -41, -47,
-51, -52, -48, -44, -45, -48, -50, -48, -47, -47, -47, -45, -42, -43, -44, -45,
-44, -45, -45, -43, -42, -44, -48, -51, -48, -43, -42, -44, -47, -48, -45, -41,
-38, -44, -46, -46, -42, -41, -44, -43, -38, -35, -37, -40, -41, -39, -35, -35,
-38, -40, -39, -36, -36, -36, -35, -33, -32, -34, -36, -35, -34, -33, -30, -29,
-30, -32, -34, -33, -30, -27, -25, -27, -30, -30, -27, -24, -24, -27, -27, -24,
-22, -22, -22, -22, -23, -25, -25, -24, -18, -14, -16, -22, -24, -21, -18, -15,
-15, -17, -17, -18, -15, -13, -12, -13, -14, -14, -12, -11, -11, -14, -16, -14,
-10, -10, -12, -14, -12, -8, -6, -8, -11, -10, -7, -6, -7, -11, -10, -10, -9,
-8, -7, -4, -3, -3, -9, -12, -10, -3, 0, -4, -7, -9, -7, -6, -7, -6, -1, 3, 1,
-6, -9, -5, 0, 3, 2, -4, -7, -5, -1, 0, -3, -3, -2, -4, -6, -8, -6, -2, 2, -1,
-8, -10, -6, 1, 2, -2, -5, -5, -4, -5, -8, -5, 0, 2, -1, -9, -10, -6, 0, 0, -4,
-7, -8, -8, -7, -7, -5, -3, -2, -6, -9, -7, -5, -2, -1, -2, -6, -9, -9, -7, -5,
-5, -5, -8, -10, -9, -10, -6, -6, -6, -7, -7, -8, -7, -8, -9, -7, -6, -3, -5,
-7, -10, -8, -4, -4, -7, -10, -10, -8, -7, -7, -8, -8, -7, -8, -9, -9, -8, -3,
-2, -3, -9, -12, -11, -7, -5, -3, -4, -4, -5, -6, -7, -6, -5, -3, -1, -2, -6,
-8, -9, -5, -1, 1, -1, -4, -4, -5, -4, -2, 1, 3, 3, 0, -3, -2, 1, 5, 6, 5, 1,
-2, -1, };