#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0037

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 9, 9, 15, 19, 21, 25, 21, 25,
22, 23, 26, 34, 40, 42, 44, 43, 46, 38, 41, 45, 49, 53, 54, 56, 55, 57, 59, 67,
70, 74, 77, 72, 63, 51, 52, 53, 59, 65, 76, 81, 78, 71, 62, 57, 50, 46, 43, 40,
35, 30, 28, 25, 24, 23, 23, 18, 5, -9, -22, -33, -40, -43, -43, -42, -44, -50,
-58, -68, -75, -80, -84, -89, -92, -98, -103, -109, -110, -110, -108, -106,
-108, -109, -113, -116, -119, -118, -115, -111, -109, -106, -105, -105, -104,
-102, -97, -91, -85, -79, -76, -75, -74, -72, -67, -62, -56, -49, -43, -39, -36,
-30, -25, -20, -13, -7, -4, -3, -2, 1, 3, 9, 16, 24, 29, 32, 34, 34, 34, 33, 37,
38, 39, 41, 41, 41, 43, 43, 46, 48, 48, 46, 44, 39, 36, 33, 32, 34, 34, 36, 34,
32, 29, 27, 25, 23, 22, 20, 18, 16, 12, 10, 10, 10, 10, 11, 10, 8, 5, 4, 2, 2,
2, 4, 3, 3, 3, 3, 4, 5, 5, 8, 10, 11, 11, 12, 13, 15, 18, 20, 21, 24, 25, 25,
26, 28, 32, 35, 35, 37, 38, 39, 40, 39, 41, 42, 46, 46, 47, 48, 48, 49, 49, 51,
54, 55, 57, 56, 53, 49, 45, 43, 43, 44, 46, 47, 49, 47, 44, 41, 37, 34, 28, 23,
20, 17, 14, 12, 12, 11, 10, 8, 3, -1, -8, -16, -22, -25, -28, -30, -31, -32,
-34, -36, -39, -42, -44, -46, -50, -52, -55, -57, -59, -58, -57, -56, -54, -53,
-54, -53, -54, -53, -53, -52, -52, -50, -50, -49, -47, -46, -44, -40, -38, -35,
-33, -31, -31, -29, -28, -26, -24, -22, -21, -18, -15, -14, -12, -10, -5, -3,
-2, 0, -1, 1, -1, 1, 2, 6, 7, 10, 11, 11, 11, 13, 13, 13, 13, 13, 13, 11, 11,
13, 15, 16, 19, 19, 19, 17, 16, 13, 13, 13, 17, 18, 18, 15, 14, 15, 14, 13, 14,
20, 17, 15, 14, 12, 12, 10, 11, 13, 12, 14, 14, 15, 13, 14, 16, 18, 19, 16, 17,
18, 17, 13, 15, 15, 19, 20, 21, 26, 26, 25, 25, 24, 25, 22, 21, 21, 20, 19, 21,
22, 24, 24, 25, 24, 22, 18, 15, 13, 12, 10, 11, 11, 11, 10, 8, 6, 2, 1, 0, -3,
-5, -7, -9, -13, -15, -15, -16, -15, -19, -20, -23, -24, -27, -29, -31, -31,
-31, -33, -34, -36, -36, -36, -36, -36, -36, -34, -37, -38, -38, -39, -38, -37,
-36, -34, -32, -31, -31, -30, -29, -26, -26, -24, -21, -19, -17, -15, -12, -9,
-6, -3, -1, 0, 2, 3, 4, 6, 7, 9, 11, 12, 14, 16, 17, 18, 20, 21, 19, 17, 17, 15,
13, 12, 14, 16, 16, 17, 15, 14, 11, 8, 6, 5, 5, 5, 2, -1, -1, -4, -5, -6, -4,
-1, -1, -6, -5, -10, -11, -16, -15, -8, -6, -7, -8, -3, -5, -4, -8, -3, 2, -1,
};