#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0031

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 5, 8, 12, 17, 21, 24, 27, 29,
31, 34, 39, 42, 42, 42, 45, 46, 44, 44, 45, 46, 45, 45, 44, 46, 50, 57, 59, 63,
64, 64, 64, 64, 67, 68, 65, 61, 60, 57, 54, 52, 52, 51, 50, 52, 58, 64, 75, 88,
99, 108, 113, 116, 119, 118, 117, 113, 106, 97, 89, 83, 80, 76, 72, 65, 57, 51,
49, 50, 49, 49, 47, 44, 39, 35, 34, 35, 34, 28, 25, 24, 24, 21, 18, 14, 8, 3,
-1, -1, 0, -1, -4, -8, -13, -22, -30, -37, -42, -47, -50, -53, -55, -55, -54,
-49, -44, -39, -34, -26, -18, -10, -4, -2, -2, -3, -4, -4, -3, -2, 0, 0, 0, -3,
-3, -4, -5, -4, -2, 0, 1, 4, 8, 10, 11, 12, 12, 13, 14, 16, 18, 18, 17, 15, 14,
15, 16, 18, 18, 18, 15, 11, 7, 2, -6, -13, -21, -29, -36, -41, -45, -48, -51,
-55, -57, -57, -56, -56, -54, -54, -53, -53, -53, -53, -52, -50, -51, -52, -55,
-57, -59, -60, -62, -63, -65, -66, -65, -63, -61, -59, -56, -55, -53, -52, -49,
-47, -45, -44, -42, -39, -36, -31, -26, -20, -14, -9, -5, 0, 2, 6, 7, 8, 7, 5,
3, 0, -1, -3, -6, -10, -11, -14, -16, -17, -18, -19, -18, -19, -18, -17, -15,
-13, -14, -13, -15, -17, -18, -20, -23, -24, -28, -30, -32, -33, -35, -35, -36,
-37, -40, -42, -43, -46, -48, -50, -51, -52, -52, -51, -50, -48, -44, -42, -37,
-34, -30, -25, -21, -18, -14, -11, -8, -4, -2, 0, 0, 1, 1, 1, 0, 0, 0, 2, 2, 3,
5, 8, 11, 12, 15, 18, 20, 21, 22, 21, 22, 22, 21, 22, 21, 21, 21, 20, 19, 18,
17, 15, 13, 10, 7, 2, -1, -5, -9, -12, -16, -18, -21, -23, -25, -28, -29, -29,
-29, -27, -27, -26, -24, -22, -21, -20, -18, -19, -19, -19, -19, -18, -17, -17,
-16, -13, -12, -7, -5, -3, 0, 0, 1, 1, 1, 3, 3, 5, 7, 9, 13, 15, 17, 19, 19, 20,
20, 21, 22, 22, 24, 24, 26, 27, 26, 26, 25, 23, 21, 19, 16, 13, 10, 9, 8, 8, 8,
10, 9, 10, 11, 11, 11, 9, 7, 5, 4, 3, 4, 3, 3, 2, 3, 4, 4, 4, 4, 2, 1, 2, 2, 2,
1, 1, -1, 1, 1, 2, 2, 2, 1, 0, 0, 1, 2, 3, 5, 6, 7, 9, 12, 14, 15, 14, 13, 12,
13, 13, 11, 9, 8, 8, 7, 6, 5, 4, 3, 2, 2, 0, -2, -4, -7, -9, -9, -9, -10, -13,
-13, -15, -15, -13, -12, -13, -14, -15, -13, -12, -9, -9, -10, -11, -12, -14,
-14, -16, -18, -22, -26, -27, -28, -30, -32, -35, -36, -39, -39, -39, -39, -37,
-38, -37, -35, -33, -29, -27, -23, -21, -20, -19, -19, -17, -15, -14, -13, -11,
-10, -8, -8, -7, -9, -9, -8, -5, -4, -2, -1, };