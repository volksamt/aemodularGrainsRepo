#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0050

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 6, 6, 4, 2, 1, 1, 0, 1, 1, 4, 9,
13, 12, 9, 5, 4, 6, 9, 10, 8, 9, 12, 15, 17, 12, 8, 6, 9, 13, 14, 12, 10, 15,
18, 20, 17, 14, 15, 17, 21, 23, 22, 23, 24, 24, 23, 22, 20, 21, 24, 29, 33, 37,
37, 36, 34, 31, 28, 27, 27, 31, 37, 39, 40, 39, 41, 45, 47, 45, 44, 44, 49, 52,
52, 51, 50, 51, 52, 52, 49, 49, 52, 51, 51, 51, 53, 55, 58, 60, 61, 62, 62, 59,
56, 56, 59, 63, 64, 65, 67, 71, 73, 71, 68, 68, 68, 69, 68, 66, 66, 63, 61, 62,
65, 71, 77, 81, 81, 75, 62, 45, 30, 27, 38, 55, 72, 83, 87, 88, 90, 96, 103,
104, 90, 55, 4, -54, -100, -118, -106, -69, -20, 27, 61, 82, 88, 80, 66, 48, 35,
29, 25, 16, 2, -14, -25, -34, -42, -45, -44, -32, -13, 2, 13, 17, 13, 6, 0, -5,
-9, -13, -18, -18, -18, -18, -20, -28, -35, -37, -37, -37, -38, -37, -30, -19,
-12, -12, -20, -28, -29, -33, -37, -46, -49, -45, -37, -31, -35, -43, -47, -45,
-39, -36, -34, -32, -28, -24, -24, -31, -43, -49, -49, -45, -42, -43, -44, -41,
-35, -32, -36, -44, -48, -45, -38, -34, -35, -38, -38, -35, -33, -38, -46, -51,
-47, -38, -33, -33, -39, -40, -38, -36, -37, -40, -45, -45, -39, -34, -32, -32,
-34, -34, -34, -38, -42, -43, -40, -36, -33, -36, -37, -36, -31, -26, -25, -29,
-32, -35, -36, -35, -35, -35, -34, -30, -27, -27, -28, -32, -30, -27, -22, -24,
-27, -29, -27, -25, -24, -26, -26, -26, -22, -20, -19, -22, -24, -24, -21, -20,
-23, -27, -27, -22, -17, -15, -17, -19, -18, -15, -17, -19, -20, -18, -15, -13,
-13, -15, -14, -14, -14, -14, -14, -13, -13, -14, -14, -14, -11, -8, -8, -9,
-10, -10, -11, -13, -13, -11, -9, -7, -7, -9, -10, -10, -9, -8, -8, -7, -5, -4,
-4, -5, -8, -8, -6, -5, -5, -7, -6, -6, -4, -4, -6, -6, -5, -3, -1, -1, -1, 0,
2, 0, -2, -5, -6, -4, -4, -2, -4, -5, -4, -4, -4, -3, -3, -2, -1, 1, 0, 0, 0,
-1, -2, -2, -4, -3, -5, -4, -5, -6, -5, -3, 0, 3, 2, 1, -3, -5, -6, -6, -5, -4,
-4, -1, 0, 0, -2, -4, -4, -3, -3, -5, -6, -2, -1, 0, -3, -5, -7, -7, -8, -8, -6,
-1, 2, 2, -1, -4, -4, -5, -6, -9, -11, -10, -7, -4, -1, 0, 0, 0, -1, -3, -5, -6,
-6, -5, -4, -4, -4, -6, -9, -10, -10, -8, -3, 1, 4, 5, 4, 0, -4, -8, -9, -11,
-10, -5, 0, 3, 5, 4, 1, -4, -7, -8, -8, -6, -3, 2, 4, 4, -1, -6, -9, -8, -6, -2,
4, 9, 12, 10, 6, 1, -2, -4, -4, -3, -1, 3, 7, 8, 7, 4, 2, 0, };