#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0042

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 12, 19, 26, 36, 43, 50, 57, 63, 64,
61, 61, 63, 68, 74, 82, 87, 89, 88, 85, 85, 86, 86, 88, 88, 89, 93, 97, 100,
102, 101, 98, 94, 92, 90, 89, 88, 84, 78, 73, 68, 62, 56, 50, 42, 36, 28, 22,
17, 13, 9, 5, -1, -6, -15, -24, -31, -36, -39, -41, -45, -48, -54, -61, -68,
-73, -78, -82, -84, -88, -90, -94, -98, -103, -107, -112, -115, -116, -116,
-115, -116, -116, -116, -119, -119, -118, -118, -115, -113, -111, -111, -110,
-109, -109, -108, -106, -104, -101, -98, -94, -91, -87, -85, -81, -78, -73, -69,
-67, -63, -60, -56, -51, -47, -41, -35, -30, -27, -26, -23, -20, -18, -15, -11,
-4, 2, 6, 9, 12, 14, 16, 17, 21, 26, 31, 35, 39, 43, 46, 48, 49, 50, 52, 55, 58,
61, 64, 67, 69, 70, 71, 70, 71, 70, 69, 69, 70, 71, 71, 71, 73, 71, 68, 66, 66,
66, 65, 66, 66, 67, 68, 67, 67, 66, 63, 61, 58, 56, 54, 53, 52, 49, 44, 40, 36,
30, 25, 22, 21, 20, 19, 18, 16, 15, 12, 9, 5, 4, 1, 3, 2, 1, -1, -4, -7, -11,
-15, -16, -18, -20, -21, -22, -23, -24, -27, -30, -32, -33, -35, -33, -32, -30,
-30, -30, -32, -30, -30, -33, -37, -38, -36, -35, -33, -30, -25, -23, -25, -27,
-27, -24, -18, -13, -7, 0, 7, 10, 10, 8, 5, 4, 4, 6, 12, 22, 28, 30, 26, 21, 20,
20, 21, 25, 31, 37, 41, 43, 43, 46, 49, 49, 50, 50, 54, 58, 60, 61, 62, 64, 66,
66, 65, 61, 56, 51, 48, 47, 51, 56, 56, 53, 48, 44, 39, 34, 31, 28, 29, 29, 31,
34, 31, 28, 20, 15, 10, 10, 11, 12, 9, 4, -1, -8, -13, -17, -22, -24, -30, -34,
-36, -39, -42, -45, -49, -53, -55, -59, -62, -65, -67, -69, -73, -74, -76, -77,
-81, -85, -87, -87, -88, -89, -90, -91, -92, -94, -95, -97, -97, -96, -96, -95,
-92, -90, -87, -88, -88, -87, -85, -83, -80, -77, -73, -72, -69, -68, -66, -63,
-61, -59, -56, -52, -48, -43, -39, -35, -32, -29, -28, -26, -22, -18, -13, -8,
-4, -2, 1, 4, 5, 7, 12, 16, 21, 25, 28, 29, 30, 31, 34, 37, 40, 45, 48, 48, 50,
52, 52, 54, 56, 59, 60, 62, 65, 67, 67, 67, 67, 68, 70, 70, 70, 71, 72, 71, 70,
69, 69, 68, 67, 63, 62, 59, 57, 54, 53, 53, 52, 52, 51, 49, 47, 44, 44, 44, 44,
45, 45, 42, 39, 35, 30, 28, 25, 22, 21, 16, 13, 10, 5, 0, -4, -6, -9, -12, -13,
-15, -16, -19, -20, -20, -21, -23, -25, -27, -30, -31, -31, -32, -33, -33, -34,
-36, -39, -41, -41, -42, -42, -40, -36, -35, -36, -37, -39, -40, -42, -44, -42,
-39, -35, -34, -33, -33, -32, -34, -37, -36, -31, -28, -23, -20, -16, -11, -10,
-7, -1, };