#define DATA_LENGTH 512
#define DATA AKWF_hvoice_0033

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 12, 15, 21, 26, 31, 37, 39,
41, 42, 42, 39, 38, 35, 35, 35, 36, 39, 42, 45, 48, 52, 56, 58, 61, 62, 63, 64,
64, 65, 65, 66, 68, 69, 70, 72, 74, 74, 74, 74, 74, 74, 75, 77, 81, 87, 92, 96,
101, 104, 107, 106, 105, 104, 104, 104, 105, 104, 106, 107, 109, 112, 114, 116,
119, 119, 119, 118, 115, 113, 110, 109, 109, 108, 110, 110, 110, 109, 107, 105,
104, 101, 99, 97, 95, 94, 92, 91, 89, 87, 85, 84, 83, 81, 80, 77, 76, 75, 74,
72, 73, 71, 69, 67, 64, 62, 57, 53, 49, 46, 43, 43, 41, 40, 39, 38, 37, 34, 33,
31, 29, 26, 23, 21, 18, 16, 14, 11, 9, 6, 5, 1, 0, -2, -5, -8, -10, -12, -14,
-14, -16, -17, -19, -22, -24, -28, -31, -34, -38, -40, -43, -45, -46, -48, -49,
-50, -51, -52, -52, -53, -56, -56, -58, -61, -63, -64, -66, -67, -68, -69, -70,
-71, -72, -74, -75, -76, -76, -75, -76, -77, -76, -77, -77, -78, -79, -80, -80,
-81, -83, -84, -85, -85, -87, -88, -87, -86, -85, -84, -84, -84, -83, -83, -83,
-82, -82, -82, -82, -81, -81, -82, -82, -83, -82, -82, -82, -81, -82, -80, -80,
-79, -77, -76, -75, -73, -72, -71, -69, -69, -68, -68, -70, -70, -70, -71, -69,
-68, -66, -66, -64, -63, -61, -60, -58, -55, -53, -51, -51, -50, -50, -49, -48,
-48, -46, -46, -44, -43, -43, -42, -41, -40, -39, -37, -34, -32, -30, -28, -27,
-26, -25, -24, -22, -21, -20, -19, -18, -18, -17, -16, -16, -15, -13, -11, -9,
-8, -6, -4, -4, -3, -2, 0, 1, 2, 4, 6, 7, 8, 10, 11, 11, 13, 14, 14, 15, 17, 17,
17, 19, 20, 21, 22, 24, 25, 26, 27, 28, 29, 29, 31, 31, 30, 30, 31, 29, 29, 29,
28, 28, 27, 28, 27, 28, 27, 28, 29, 30, 29, 30, 31, 30, 32, 31, 31, 32, 32, 32,
32, 32, 32, 32, 33, 34, 35, 36, 36, 37, 38, 37, 37, 37, 37, 37, 36, 35, 35, 34,
33, 32, 32, 30, 30, 29, 27, 26, 25, 24, 24, 22, 22, 20, 19, 17, 15, 14, 13, 11,
9, 9, 6, 5, 5, 4, 2, 2, 1, 0, -2, -2, -2, -3, -4, -4, -5, -5, -6, -6, -6, -7,
-7, -8, -9, -8, -10, -12, -13, -13, -15, -15, -16, -17, -17, -18, -19, -20, -21,
-21, -20, -20, -20, -22, -22, -23, -25, -25, -26, -28, -29, -30, -32, -33, -33,
-34, -33, -33, -33, -34, -34, -35, -34, -34, -33, -33, -34, -37, -37, -38, -40,
-40, -40, -40, -40, -39, -40, -40, -41, -41, -41, -39, -39, -38, -37, -37, -38,
-40, -42, -45, -47, -49, -48, -48, -46, -47, -44, -45, -44, -42, -42, -39, -37,
-34, -32, -33, -34, -35, -36, -36, -33, -31, -28, -26, -24, -24, -22, -22, -20,
-17, -14, -11, -7, -5, -2, };