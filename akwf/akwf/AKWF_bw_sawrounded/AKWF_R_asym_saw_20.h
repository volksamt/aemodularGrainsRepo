#define DATA_LENGTH 512
#define DATA AKWF_R_asym_saw_20

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 38, 59, 74, 86, 96, 103, 106, 111,
114, 115, 117, 118, 119, 119, 118, 119, 118, 118, 118, 118, 117, 117, 116, 116,
115, 114, 114, 114, 113, 113, 112, 112, 111, 110, 110, 110, 109, 108, 107, 107,
107, 106, 105, 105, 104, 104, 102, 103, 102, 101, 101, 100, 99, 99, 98, 98, 97,
97, 96, 95, 95, 94, 94, 94, 93, 93, 92, 90, 91, 89, 90, 89, 88, 87, 87, 86, 85,
86, 84, 84, 84, 84, 83, 82, 81, 81, 81, 80, 80, 79, 78, 78, 77, 76, 76, 76, 75,
74, 74, 74, 73, 72, 72, 71, 70, 70, 70, 70, 68, 68, 67, 67, 67, 66, 66, 66, 65,
64, 64, 63, 62, 61, 62, 61, 60, 60, 60, 59, 58, 58, 56, 57, 55, 55, 55, 55, 54,
53, 53, 52, 51, 51, 51, 51, 50, 50, 49, 48, 48, 48, 47, 47, 46, 45, 45, 44, 44,
43, 43, 42, 41, 41, 41, 40, 39, 39, 38, 38, 38, 37, 37, 37, 36, 35, 35, 34, 33,
33, 33, 32, 31, 31, 31, 30, 30, 29, 29, 29, 27, 27, 26, 26, 25, 25, 25, 24, 24,
23, 22, 23, 22, 22, 21, 20, 19, 19, 18, 18, 18, 17, 17, 16, 16, 15, 15, 15, 14,
14, 14, 12, 12, 11, 11, 11, 10, 10, 9, 8, 9, 8, 7, 7, 7, 6, 5, 5, 5, 4, 3, 2, 3,
2, 1, 2, 0, 0, 0, -1, -2, -2, -2, -3, -4, -3, -4, -4, -4, -5, -6, -7, -7, -7,
-8, -7, -9, -9, -10, -10, -10, -11, -11, -11, -13, -13, -13, -13, -14, -14, -16,
-15, -16, -16, -16, -18, -18, -18, -19, -18, -20, -20, -20, -21, -21, -22, -22,
-22, -23, -23, -24, -24, -26, -25, -25, -26, -27, -27, -27, -28, -28, -29, -30,
-30, -30, -31, -30, -32, -31, -32, -33, -33, -33, -33, -35, -34, -36, -35, -36,
-36, -38, -37, -38, -39, -39, -39, -40, -40, -40, -42, -42, -41, -42, -43, -43,
-44, -43, -45, -45, -45, -45, -46, -47, -47, -48, -47, -47, -49, -49, -50, -51,
-50, -51, -51, -52, -52, -52, -52, -53, -54, -53, -54, -55, -55, -55, -56, -56,
-56, -57, -58, -58, -58, -58, -59, -60, -59, -60, -60, -61, -61, -62, -62, -63,
-64, -64, -64, -64, -65, -65, -66, -66, -67, -67, -67, -68, -68, -69, -69, -69,
-70, -71, -71, -71, -71, -72, -72, -72, -72, -73, -74, -75, -75, -74, -75, -76,
-76, -76, -76, -77, -77, -79, -78, -79, -79, -80, -80, -80, -81, -81, -81, -82,
-83, -83, -84, -83, -84, -84, -85, -86, -86, -86, -86, -87, -87, -87, -88, -87,
-89, -89, -89, -89, -90, -91, -91, -91, -92, -91, -92, -92, -93, -94, -94, -94,
-94, -95, -95, -95, -96, -97, -97, -98, -97, -98, -98, -99, -99, -100, -100,
-100, -101, -101, -101, -102, -102, -103, -102, -104, -103, -103, -104, -105,
-105, -105, -106, -106, -107, -107, -107, -107, -108, -97, -60, -16, };