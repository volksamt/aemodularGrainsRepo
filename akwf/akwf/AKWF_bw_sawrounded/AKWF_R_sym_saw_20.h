#define DATA_LENGTH 512
#define DATA AKWF_R_sym_saw_20

const PROGMEM int8_t DATA[DATA_LENGTH] = {16, 55, 84, 97, 104, 108, 111, 113,
116, 117, 118, 119, 119, 118, 118, 119, 119, 118, 118, 117, 117, 116, 117, 116,
115, 115, 114, 114, 114, 113, 112, 112, 111, 110, 111, 110, 109, 108, 108, 108,
107, 107, 106, 106, 106, 105, 104, 105, 104, 103, 103, 102, 102, 102, 101, 100,
100, 98, 99, 98, 97, 97, 96, 95, 95, 95, 94, 94, 93, 92, 92, 92, 90, 91, 90, 91,
89, 89, 88, 88, 87, 87, 87, 86, 86, 85, 84, 84, 83, 83, 82, 82, 81, 80, 80, 79,
79, 79, 79, 78, 77, 77, 76, 75, 76, 75, 74, 74, 73, 73, 72, 71, 71, 70, 70, 70,
69, 68, 68, 68, 67, 67, 66, 65, 66, 65, 64, 64, 63, 63, 62, 61, 61, 60, 60, 59,
59, 59, 59, 58, 57, 57, 57, 56, 55, 55, 55, 53, 54, 53, 52, 52, 51, 50, 51, 50,
50, 48, 49, 48, 48, 47, 46, 46, 45, 45, 43, 43, 43, 43, 42, 42, 41, 41, 41, 40,
39, 40, 38, 38, 37, 37, 36, 35, 36, 34, 34, 34, 34, 33, 33, 32, 32, 31, 31, 31,
29, 28, 28, 28, 28, 27, 26, 25, 25, 24, 24, 23, 24, 23, 22, 22, 22, 21, 21, 20,
20, 18, 19, 18, 17, 17, 16, 17, 15, 15, 15, 14, 13, 13, 12, 12, 12, 10, 11, 11,
9, 10, 9, 8, 8, 8, 7, 6, 5, 6, 5, 4, 3, 4, 2, 3, 2, 2, 0, 0, 0, -1, -1, -2, -2,
-3, -2, -4, -5, -5, -5, -5, -7, -7, -7, -7, -9, -9, -9, -9, -10, -10, -11, -11,
-11, -13, -13, -14, -14, -15, -15, -16, -16, -16, -17, -18, -18, -18, -19, -19,
-20, -20, -22, -21, -22, -22, -23, -23, -24, -24, -25, -25, -27, -27, -28, -28,
-29, -28, -29, -29, -30, -31, -31, -31, -31, -32, -33, -33, -34, -34, -35, -36,
-36, -36, -37, -38, -37, -39, -38, -39, -40, -41, -40, -41, -42, -43, -43, -43,
-44, -44, -46, -45, -47, -46, -46, -47, -47, -48, -49, -50, -50, -51, -51, -52,
-52, -52, -53, -53, -54, -55, -54, -55, -56, -56, -57, -57, -58, -58, -59, -59,
-60, -61, -62, -61, -62, -62, -62, -64, -65, -65, -65, -65, -65, -66, -67, -67,
-68, -69, -69, -70, -69, -70, -71, -71, -72, -72, -72, -73, -74, -74, -74, -76,
-76, -76, -76, -77, -78, -77, -80, -79, -79, -81, -81, -81, -82, -82, -84, -83,
-83, -85, -85, -86, -85, -86, -87, -87, -88, -88, -89, -89, -89, -90, -91, -91,
-92, -92, -93, -93, -93, -94, -95, -96, -96, -96, -98, -97, -98, -98, -99, -100,
-100, -100, -101, -102, -103, -102, -103, -103, -104, -105, -105, -105, -106,
-107, -107, -108, -108, -109, -110, -110, -110, -111, -111, -112, -112, -113,
-113, -113, -114, -114, -115, -116, -116, -116, -116, -118, -118, -118, -118,
-119, -119, -119, -119, -119, -119, -117, -117, -116, -114, -112, -108, -103,
-97, -83, -52, -13, };