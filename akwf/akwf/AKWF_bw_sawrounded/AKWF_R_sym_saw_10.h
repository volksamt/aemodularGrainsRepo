#define DATA_LENGTH 512
#define DATA AKWF_R_sym_saw_10

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 9, 15, 22, 28, 36, 42, 49, 55, 61,
69, 75, 82, 88, 96, 101, 104, 107, 108, 109, 110, 110, 112, 112, 113, 113, 115,
114, 115, 116, 116, 117, 117, 118, 118, 118, 119, 119, 118, 119, 119, 119, 119,
119, 119, 120, 120, 119, 119, 118, 118, 119, 118, 119, 117, 117, 117, 117, 117,
116, 116, 116, 116, 115, 115, 114, 114, 114, 114, 113, 111, 112, 112, 111, 110,
110, 110, 109, 109, 107, 108, 107, 107, 106, 106, 105, 105, 105, 103, 103, 103,
102, 102, 101, 100, 99, 99, 98, 98, 97, 97, 96, 95, 95, 95, 94, 93, 92, 92, 92,
90, 90, 90, 89, 88, 88, 88, 87, 86, 85, 84, 85, 84, 83, 82, 82, 81, 80, 80, 79,
78, 78, 78, 76, 77, 76, 75, 74, 74, 74, 73, 73, 71, 71, 70, 69, 69, 68, 67, 68,
66, 66, 65, 65, 63, 64, 63, 63, 61, 61, 60, 59, 59, 59, 58, 58, 56, 56, 54, 55,
53, 53, 53, 53, 51, 51, 50, 49, 49, 48, 47, 47, 47, 46, 45, 45, 44, 43, 43, 42,
41, 41, 39, 39, 39, 38, 38, 37, 37, 35, 35, 34, 33, 33, 32, 32, 31, 31, 29, 29,
29, 28, 27, 27, 27, 26, 25, 25, 23, 23, 22, 22, 21, 20, 20, 20, 19, 18, 18, 16,
16, 15, 15, 15, 13, 13, 12, 11, 10, 10, 9, 9, 8, 8, 7, 7, 6, 6, 4, 4, 4, 3, 2,
1, 1, 0, 0, -1, -2, -3, -2, -3, -4, -4, -5, -6, -7, -8, -8, -9, -9, -10, -11,
-11, -11, -13, -13, -14, -15, -15, -15, -16, -17, -17, -17, -19, -19, -19, -21,
-21, -22, -23, -23, -24, -24, -24, -25, -27, -27, -27, -28, -29, -30, -30, -30,
-31, -32, -33, -33, -33, -35, -34, -36, -36, -37, -38, -39, -39, -39, -41, -41,
-41, -43, -42, -43, -43, -45, -45, -45, -46, -47, -48, -48, -49, -49, -50, -51,
-51, -52, -53, -53, -54, -55, -55, -56, -57, -57, -58, -59, -59, -59, -61, -61,
-61, -63, -62, -63, -64, -65, -65, -65, -66, -67, -68, -69, -68, -70, -71, -71,
-72, -72, -73, -74, -74, -74, -75, -76, -76, -77, -77, -78, -79, -80, -81, -82,
-82, -82, -82, -83, -83, -84, -85, -86, -87, -87, -88, -88, -89, -90, -90, -90,
-92, -92, -93, -92, -93, -95, -94, -95, -96, -96, -97, -98, -98, -99, -100,
-100, -100, -100, -102, -102, -102, -103, -104, -104, -105, -106, -106, -107,
-106, -107, -108, -108, -108, -109, -110, -110, -110, -111, -111, -112, -112,
-113, -113, -113, -114, -115, -115, -116, -115, -115, -116, -116, -116, -117,
-118, -117, -118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -118, -118, -119, -118, -118, -119, -118, -118, -118, -117,
-116, -116, -115, -115, -114, -114, -113, -112, -111, -111, -110, -109, -108,
-107, -105, -100, -95, -88, -82, -75, -68, -61, -54, -47, -41, -34, -28, -22,
-15, -9, -3, };