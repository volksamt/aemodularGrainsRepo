#define DATA_LENGTH 512
#define DATA AKWF_R_asym_saw_06

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 8, 11, 12, 14, 17, 19, 21,
23, 25, 27, 29, 31, 33, 35, 36, 39, 40, 42, 44, 45, 47, 48, 49, 50, 52, 54, 55,
56, 57, 59, 59, 61, 62, 63, 64, 66, 66, 67, 68, 69, 70, 71, 71, 71, 72, 74, 74,
75, 75, 76, 77, 77, 78, 79, 79, 79, 79, 81, 81, 81, 82, 81, 83, 82, 83, 84, 84,
85, 85, 85, 85, 85, 86, 85, 86, 86, 87, 85, 86, 86, 86, 87, 86, 87, 86, 86, 87,
87, 86, 86, 86, 86, 86, 87, 86, 86, 86, 86, 86, 85, 85, 85, 85, 84, 84, 84, 84,
83, 84, 84, 83, 83, 83, 82, 82, 82, 82, 81, 81, 81, 80, 80, 80, 80, 79, 79, 78,
77, 77, 77, 77, 77, 76, 75, 75, 74, 74, 74, 73, 73, 73, 71, 71, 71, 71, 71, 70,
69, 69, 68, 68, 68, 68, 66, 67, 65, 65, 65, 64, 64, 64, 62, 62, 62, 62, 61, 60,
60, 59, 58, 58, 58, 56, 57, 56, 56, 55, 55, 54, 53, 53, 52, 51, 51, 50, 50, 49,
49, 48, 47, 47, 46, 45, 45, 44, 44, 44, 42, 42, 41, 41, 40, 40, 40, 38, 39, 38,
36, 36, 36, 35, 35, 35, 34, 32, 32, 31, 31, 31, 29, 29, 29, 28, 27, 27, 26, 26,
25, 24, 24, 23, 22, 22, 21, 20, 20, 20, 19, 18, 17, 17, 17, 16, 16, 14, 15, 14,
13, 12, 12, 11, 11, 9, 10, 8, 8, 7, 7, 6, 5, 5, 4, 3, 3, 2, 1, 1, 1, 0, -1, -1,
-2, -3, -3, -5, -5, -5, -5, -7, -7, -7, -9, -9, -9, -10, -10, -12, -12, -13,
-13, -14, -15, -14, -15, -16, -16, -17, -18, -19, -20, -20, -21, -21, -22, -23,
-23, -25, -25, -25, -25, -26, -27, -28, -28, -29, -29, -29, -31, -31, -31, -32,
-33, -33, -35, -35, -35, -36, -37, -38, -37, -38, -39, -39, -41, -41, -41, -41,
-43, -43, -44, -43, -45, -46, -46, -47, -48, -48, -48, -49, -50, -49, -51, -51,
-52, -52, -53, -54, -55, -55, -55, -56, -57, -57, -59, -59, -59, -59, -60, -61,
-62, -62, -62, -63, -64, -64, -65, -65, -67, -66, -67, -67, -69, -69, -69, -70,
-70, -72, -72, -73, -73, -73, -74, -74, -75, -76, -77, -78, -77, -78, -79, -79,
-81, -81, -81, -82, -82, -83, -83, -84, -85, -85, -86, -86, -86, -87, -87, -89,
-89, -90, -90, -90, -91, -92, -92, -93, -94, -94, -95, -96, -96, -97, -97, -97,
-98, -98, -99, -99, -101, -101, -102, -102, -103, -103, -103, -105, -104, -106,
-105, -106, -107, -107, -108, -108, -108, -110, -110, -110, -111, -111, -112,
-112, -114, -114, -115, -115, -116, -116, -117, -117, -118, -118, -119, -119,
-119, -117, -115, -112, -109, -106, -103, -99, -94, -91, -86, -83, -78, -74,
-71, -67, -63, -59, -56, -52, -48, -45, -41, -39, -35, -31, -28, -25, -22, -19,
-16, -12, -10, -7, -4, -1, };