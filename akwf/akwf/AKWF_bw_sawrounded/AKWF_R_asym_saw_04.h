#define DATA_LENGTH 512
#define DATA AKWF_R_asym_saw_04

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 6, 9, 10, 11, 13, 14, 16, 18,
19, 20, 21, 23, 24, 26, 28, 28, 29, 31, 33, 34, 34, 35, 37, 39, 39, 40, 41, 42,
44, 45, 45, 47, 47, 48, 49, 50, 50, 52, 52, 53, 54, 55, 56, 56, 57, 59, 59, 59,
60, 61, 61, 62, 62, 63, 64, 64, 65, 66, 66, 67, 67, 68, 67, 68, 69, 70, 70, 70,
69, 71, 71, 71, 71, 71, 73, 73, 72, 73, 73, 73, 74, 74, 74, 75, 75, 75, 75, 75,
75, 75, 76, 76, 76, 77, 75, 76, 76, 75, 77, 76, 76, 76, 77, 77, 76, 75, 77, 76,
76, 76, 76, 76, 76, 76, 76, 75, 76, 76, 76, 74, 75, 75, 74, 75, 74, 74, 74, 74,
73, 74, 74, 72, 73, 72, 72, 72, 72, 71, 71, 71, 71, 71, 70, 70, 70, 69, 69, 68,
69, 68, 67, 67, 68, 67, 67, 66, 66, 66, 66, 64, 65, 64, 64, 63, 63, 63, 61, 62,
61, 61, 60, 60, 60, 59, 59, 59, 58, 58, 57, 57, 57, 56, 55, 55, 55, 54, 53, 53,
52, 52, 51, 51, 50, 50, 50, 49, 48, 48, 48, 46, 47, 46, 45, 44, 44, 44, 43, 42,
42, 41, 41, 41, 40, 39, 39, 37, 38, 37, 37, 35, 35, 36, 34, 34, 33, 33, 31, 31,
30, 29, 29, 29, 28, 28, 27, 26, 26, 25, 25, 24, 23, 23, 23, 21, 22, 20, 19, 19,
19, 18, 17, 17, 16, 15, 15, 14, 14, 13, 12, 11, 11, 11, 10, 9, 9, 8, 8, 6, 5, 5,
5, 3, 4, 3, 1, 1, 0, -1, -1, -1, -1, -3, -4, -4, -4, -6, -6, -7, -7, -9, -8, -9,
-10, -11, -11, -11, -13, -13, -14, -15, -15, -16, -17, -17, -18, -19, -19, -20,
-20, -22, -21, -23, -23, -24, -25, -26, -26, -26, -27, -28, -29, -29, -30, -31,
-31, -32, -33, -34, -35, -35, -35, -36, -36, -38, -38, -39, -40, -39, -42, -42,
-42, -43, -44, -45, -45, -46, -46, -47, -48, -49, -50, -50, -51, -51, -52, -53,
-53, -54, -55, -56, -56, -57, -57, -58, -59, -60, -61, -61, -62, -62, -64, -63,
-65, -65, -65, -67, -66, -68, -68, -69, -70, -71, -70, -72, -73, -73, -74, -74,
-75, -76, -77, -77, -78, -78, -79, -80, -81, -82, -82, -83, -83, -85, -85, -85,
-86, -87, -88, -89, -89, -90, -90, -91, -92, -92, -94, -94, -94, -95, -97, -97,
-98, -98, -98, -99, -99, -100, -101, -101, -103, -103, -104, -105, -106, -106,
-107, -108, -107, -109, -109, -110, -110, -112, -112, -113, -114, -114, -114,
-116, -116, -117, -117, -118, -119, -118, -119, -118, -118, -116, -115, -113,
-112, -109, -107, -105, -103, -99, -97, -95, -93, -89, -87, -84, -82, -78, -76,
-73, -70, -68, -66, -63, -60, -58, -56, -52, -50, -47, -45, -43, -41, -39, -36,
-34, -32, -29, -27, -26, -23, -21, -19, -17, -15, -12, -10, -10, -7, -5, -4, -1,
-1, };