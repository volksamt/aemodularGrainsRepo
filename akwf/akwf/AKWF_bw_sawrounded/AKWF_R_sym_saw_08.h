#define DATA_LENGTH 512
#define DATA AKWF_R_sym_saw_08

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 15, 20, 25, 31, 35, 39, 44,
49, 54, 58, 64, 69, 74, 79, 84, 88, 93, 97, 102, 105, 109, 110, 111, 112, 113,
113, 114, 114, 115, 115, 116, 116, 117, 117, 118, 118, 117, 118, 118, 118, 119,
119, 119, 119, 119, 118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 117, 118, 118, 118, 117, 117, 116, 116, 116, 115, 115, 116, 115, 114,
114, 113, 113, 114, 113, 112, 111, 111, 111, 111, 110, 110, 109, 109, 108, 108,
107, 107, 107, 106, 105, 105, 105, 104, 103, 103, 103, 101, 101, 100, 100, 99,
99, 99, 98, 98, 97, 96, 96, 95, 94, 94, 93, 93, 93, 92, 91, 90, 89, 89, 89, 88,
87, 86, 86, 85, 85, 84, 83, 83, 82, 81, 81, 80, 79, 79, 78, 77, 77, 76, 75, 74,
74, 73, 73, 73, 72, 70, 71, 69, 69, 69, 68, 67, 67, 65, 65, 64, 64, 62, 62, 61,
60, 60, 59, 59, 58, 58, 56, 55, 55, 55, 54, 53, 53, 52, 51, 50, 50, 49, 49, 47,
47, 46, 46, 45, 45, 44, 43, 43, 41, 41, 41, 40, 39, 39, 37, 38, 36, 35, 35, 35,
33, 33, 32, 32, 30, 30, 29, 29, 27, 27, 26, 26, 25, 24, 24, 23, 22, 22, 21, 20,
19, 19, 18, 18, 16, 16, 15, 15, 14, 12, 12, 12, 11, 10, 10, 10, 8, 7, 6, 6, 5,
5, 4, 4, 2, 2, 1, 1, -1, -1, -2, -2, -3, -3, -5, -5, -6, -7, -8, -8, -9, -10,
-10, -10, -12, -12, -13, -14, -15, -16, -16, -16, -17, -17, -18, -20, -20, -20,
-21, -22, -24, -23, -25, -25, -25, -26, -27, -27, -28, -29, -30, -30, -31, -32,
-32, -33, -34, -35, -36, -36, -37, -37, -38, -38, -39, -40, -41, -41, -43, -43,
-44, -44, -46, -46, -46, -47, -48, -49, -49, -50, -51, -52, -52, -53, -54, -54,
-55, -56, -56, -57, -57, -58, -59, -60, -60, -61, -62, -62, -63, -64, -65, -66,
-66, -66, -68, -68, -68, -69, -70, -71, -71, -72, -72, -74, -73, -74, -76, -75,
-77, -77, -78, -78, -80, -80, -81, -82, -81, -82, -83, -83, -84, -85, -86, -86,
-86, -87, -88, -88, -89, -90, -91, -91, -91, -92, -93, -94, -94, -94, -95, -96,
-96, -97, -97, -97, -99, -99, -100, -100, -100, -101, -102, -103, -104, -103,
-104, -104, -105, -105, -106, -107, -107, -107, -108, -108, -109, -109, -110,
-110, -111, -111, -112, -113, -112, -113, -113, -113, -114, -114, -114, -114,
-115, -115, -116, -115, -116, -116, -117, -117, -117, -118, -118, -118, -118,
-118, -118, -119, -118, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-120, -119, -119, -118, -118, -119, -118, -118, -117, -117, -117, -117, -116,
-116, -116, -115, -114, -114, -113, -114, -113, -112, -111, -110, -108, -105,
-102, -98, -92, -88, -83, -78, -73, -68, -63, -58, -53, -49, -44, -39, -35, -30,
-24, -20, -15, -11, -6, -2, };