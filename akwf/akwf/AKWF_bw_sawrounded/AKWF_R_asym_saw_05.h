#define DATA_LENGTH 512
#define DATA AKWF_R_asym_saw_05

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 7, 9, 10, 12, 13, 16, 18, 19,
22, 22, 25, 26, 28, 30, 31, 32, 34, 35, 37, 39, 40, 41, 42, 44, 44, 46, 47, 48,
50, 51, 51, 52, 54, 54, 56, 57, 58, 58, 60, 60, 61, 62, 63, 63, 64, 65, 66, 66,
67, 68, 68, 69, 70, 70, 70, 72, 71, 73, 73, 74, 74, 74, 75, 75, 76, 76, 76, 77,
77, 78, 77, 78, 79, 79, 78, 79, 80, 80, 80, 80, 80, 81, 80, 81, 81, 81, 80, 81,
81, 81, 81, 82, 80, 82, 80, 81, 81, 80, 81, 80, 81, 81, 81, 81, 80, 81, 80, 80,
80, 80, 80, 80, 80, 79, 80, 80, 79, 79, 78, 79, 79, 78, 77, 77, 76, 77, 77, 76,
76, 76, 76, 75, 75, 74, 74, 74, 74, 73, 72, 73, 72, 72, 72, 70, 71, 71, 70, 70,
70, 69, 69, 69, 67, 68, 67, 66, 65, 66, 66, 65, 64, 64, 63, 62, 62, 62, 61, 61,
61, 60, 59, 59, 59, 57, 58, 57, 57, 57, 56, 55, 54, 54, 53, 53, 53, 52, 52, 51,
51, 50, 50, 49, 49, 48, 48, 47, 46, 46, 45, 45, 44, 44, 43, 42, 41, 42, 41, 40,
40, 38, 39, 38, 38, 37, 37, 35, 35, 34, 34, 34, 32, 31, 31, 32, 31, 30, 29, 28,
28, 28, 26, 26, 26, 25, 24, 24, 23, 22, 22, 21, 20, 20, 19, 19, 18, 18, 17, 17,
16, 15, 14, 14, 13, 13, 11, 11, 11, 10, 9, 9, 8, 7, 7, 7, 5, 6, 5, 4, 3, 2, 2,
1, 0, 0, -1, -2, -2, -3, -4, -3, -4, -5, -6, -6, -7, -8, -8, -9, -10, -10, -11,
-12, -12, -13, -13, -15, -15, -16, -16, -18, -18, -18, -18, -20, -21, -20, -21,
-22, -23, -23, -24, -24, -25, -26, -26, -26, -28, -28, -29, -30, -30, -30, -32,
-32, -33, -34, -34, -35, -35, -35, -37, -37, -38, -38, -40, -40, -40, -41, -41,
-42, -42, -43, -44, -45, -46, -46, -47, -48, -49, -49, -50, -51, -52, -51, -52,
-54, -53, -55, -54, -55, -55, -57, -57, -58, -58, -59, -60, -60, -61, -62, -62,
-63, -63, -64, -64, -65, -66, -66, -67, -67, -68, -69, -70, -69, -71, -71, -72,
-73, -74, -74, -74, -75, -75, -76, -78, -78, -78, -79, -79, -81, -80, -82, -83,
-83, -83, -84, -85, -85, -87, -86, -87, -88, -89, -89, -90, -90, -90, -91, -93,
-93, -93, -94, -94, -95, -96, -96, -97, -97, -98, -98, -99, -100, -100, -101,
-102, -103, -103, -104, -105, -105, -105, -105, -106, -107, -108, -108, -109,
-110, -110, -111, -111, -112, -113, -113, -114, -114, -115, -114, -116, -117,
-117, -117, -119, -119, -118, -119, -118, -116, -114, -112, -109, -107, -104,
-100, -97, -94, -92, -88, -84, -82, -78, -75, -71, -69, -65, -63, -60, -56, -53,
-50, -46, -44, -41, -39, -36, -33, -31, -28, -25, -22, -20, -17, -15, -13, -10,
-8, -6, -3, -2, };