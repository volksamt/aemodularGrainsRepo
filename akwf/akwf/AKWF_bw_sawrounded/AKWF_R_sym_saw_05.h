#define DATA_LENGTH 512
#define DATA AKWF_R_sym_saw_05

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 10, 12, 15, 18, 21, 23, 27,
29, 31, 35, 37, 40, 43, 46, 49, 52, 55, 58, 60, 63, 66, 69, 72, 74, 77, 80, 83,
87, 90, 92, 95, 97, 101, 103, 106, 108, 110, 112, 115, 116, 117, 118, 118, 119,
119, 119, 119, 119, 119, 118, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119,
119, 118, 119, 118, 119, 118, 118, 117, 117, 117, 116, 117, 117, 117, 117, 116,
116, 115, 116, 115, 114, 115, 115, 114, 114, 113, 114, 113, 112, 112, 112, 111,
111, 110, 110, 109, 109, 108, 108, 107, 108, 107, 107, 106, 106, 104, 105, 104,
103, 104, 103, 102, 102, 101, 101, 100, 100, 99, 99, 98, 98, 96, 96, 95, 95, 94,
93, 93, 93, 92, 92, 90, 91, 90, 89, 89, 88, 87, 86, 87, 85, 85, 85, 84, 82, 82,
81, 82, 80, 79, 79, 78, 78, 77, 77, 75, 76, 75, 74, 73, 73, 72, 71, 70, 69, 68,
67, 67, 67, 65, 64, 63, 63, 63, 62, 61, 60, 60, 59, 58, 57, 57, 57, 55, 55, 53,
53, 53, 52, 51, 51, 50, 49, 48, 47, 45, 45, 44, 44, 43, 43, 41, 41, 40, 39, 38,
37, 36, 36, 35, 35, 33, 33, 32, 31, 30, 30, 29, 28, 27, 27, 26, 25, 24, 23, 23,
21, 21, 19, 20, 19, 18, 17, 16, 14, 15, 13, 13, 12, 11, 10, 10, 9, 7, 7, 6, 6,
5, 4, 3, 2, 1, 0, -1, -1, -2, -3, -3, -4, -5, -6, -7, -8, -9, -9, -10, -12, -11,
-13, -13, -15, -15, -16, -17, -17, -19, -19, -20, -21, -21, -23, -23, -24, -24,
-25, -26, -27, -28, -29, -30, -30, -31, -33, -33, -34, -34, -34, -37, -37, -38,
-39, -40, -40, -41, -42, -42, -43, -43, -45, -45, -46, -47, -47, -48, -50, -50,
-51, -52, -52, -53, -54, -55, -55, -56, -57, -58, -58, -59, -60, -61, -61, -62,
-63, -63, -65, -65, -65, -66, -67, -68, -69, -69, -71, -71, -71, -72, -72, -74,
-74, -75, -76, -76, -76, -77, -79, -79, -79, -80, -82, -82, -82, -82, -84, -84,
-86, -85, -86, -87, -88, -87, -89, -89, -90, -90, -91, -92, -91, -93, -94, -95,
-94, -96, -96, -96, -97, -97, -98, -99, -99, -100, -100, -101, -101, -101, -103,
-102, -103, -104, -105, -105, -106, -106, -107, -106, -107, -107, -108, -108,
-109, -109, -110, -111, -111, -111, -110, -112, -112, -112, -112, -113, -113,
-113, -114, -113, -114, -114, -115, -116, -115, -116, -116, -117, -116, -116,
-117, -117, -117, -118, -117, -118, -118, -119, -118, -118, -119, -118, -119,
-119, -119, -120, -119, -118, -119, -120, -119, -119, -119, -120, -120, -119,
-118, -118, -119, -118, -118, -116, -116, -115, -112, -111, -107, -106, -103,
-100, -99, -96, -93, -89, -87, -83, -82, -78, -76, -72, -69, -67, -63, -61, -58,
-55, -52, -49, -46, -43, -40, -38, -34, -32, -29, -26, -24, -21, -17, -15, -12,
-9, -6, -3, -1, };