#define DATA_LENGTH 512
#define DATA AKWF_R_sym_saw_06

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 12, 14, 18, 21, 24, 28, 32,
35, 39, 42, 45, 48, 53, 56, 59, 62, 67, 70, 74, 76, 80, 84, 88, 91, 93, 97, 100,
103, 106, 109, 111, 113, 115, 116, 117, 116, 116, 117, 117, 117, 117, 117, 118,
118, 118, 119, 118, 119, 119, 120, 119, 120, 119, 119, 119, 119, 120, 119, 119,
119, 119, 118, 119, 118, 118, 118, 118, 118, 117, 117, 118, 117, 116, 116, 116,
116, 115, 116, 115, 114, 114, 114, 113, 114, 113, 113, 112, 112, 112, 111, 111,
111, 111, 110, 110, 109, 108, 108, 108, 107, 106, 105, 106, 105, 105, 104, 104,
103, 102, 102, 101, 101, 101, 100, 100, 99, 99, 98, 97, 97, 96, 95, 95, 94, 94,
93, 93, 92, 91, 92, 90, 89, 89, 88, 88, 87, 87, 86, 85, 84, 83, 84, 83, 82, 81,
81, 80, 79, 78, 78, 77, 77, 76, 75, 74, 74, 73, 73, 72, 71, 70, 70, 69, 68, 67,
67, 66, 65, 64, 64, 63, 62, 62, 61, 60, 59, 59, 59, 58, 56, 56, 55, 55, 54, 52,
52, 51, 50, 50, 50, 49, 48, 47, 46, 46, 44, 45, 43, 42, 41, 41, 40, 40, 39, 38,
37, 36, 35, 35, 35, 34, 33, 32, 30, 30, 29, 29, 27, 28, 26, 26, 25, 24, 23, 22,
21, 21, 20, 19, 19, 17, 18, 16, 15, 15, 14, 14, 12, 12, 11, 10, 9, 8, 8, 7, 6,
5, 5, 3, 3, 2, 1, 0, 0, -2, -1, -3, -4, -4, -5, -6, -7, -7, -8, -9, -10, -11,
-12, -12, -12, -14, -15, -15, -16, -18, -18, -18, -19, -20, -21, -21, -22, -24,
-24, -24, -26, -26, -27, -28, -29, -29, -30, -31, -32, -32, -33, -34, -35, -35,
-37, -37, -38, -38, -39, -41, -42, -42, -42, -43, -44, -45, -45, -47, -47, -48,
-49, -49, -51, -51, -51, -52, -54, -53, -54, -54, -56, -57, -58, -58, -58, -60,
-61, -61, -61, -63, -63, -64, -65, -65, -66, -67, -68, -68, -68, -70, -70, -71,
-72, -73, -73, -73, -75, -75, -76, -77, -76, -78, -79, -80, -80, -81, -81, -82,
-82, -84, -84, -84, -85, -86, -86, -87, -87, -88, -89, -89, -90, -91, -91, -92,
-93, -92, -93, -94, -95, -96, -96, -97, -98, -97, -98, -99, -100, -100, -100,
-101, -101, -102, -103, -103, -104, -104, -105, -105, -106, -106, -107, -106,
-108, -108, -109, -109, -109, -110, -110, -111, -111, -111, -111, -112, -113,
-112, -113, -113, -114, -114, -115, -115, -115, -116, -115, -115, -117, -116,
-117, -117, -116, -118, -117, -118, -118, -118, -118, -119, -119, -118, -119,
-119, -119, -118, -120, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -118, -119, -119, -118, -118, -118, -117, -117, -117, -116, -116,
-116, -114, -113, -112, -109, -107, -103, -100, -97, -93, -90, -87, -83, -80,
-77, -72, -69, -66, -62, -59, -55, -52, -48, -46, -41, -38, -35, -32, -28, -25,
-21, -18, -15, -11, -8, -4, -1, };