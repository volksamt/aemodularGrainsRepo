#define DATA_LENGTH 512
#define DATA AKWF_R_sym_saw_03

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 5, 7, 8, 11, 12, 15, 16, 18, 21,
22, 24, 26, 28, 30, 32, 34, 37, 39, 40, 43, 43, 46, 48, 50, 52, 54, 56, 57, 60,
62, 64, 66, 68, 71, 72, 74, 76, 79, 80, 81, 85, 86, 88, 90, 92, 94, 95, 97, 99,
102, 103, 104, 106, 107, 109, 110, 111, 114, 115, 116, 116, 117, 117, 119, 119,
119, 119, 119, 119, 118, 118, 117, 118, 117, 117, 117, 117, 117, 116, 115, 115,
115, 115, 114, 114, 114, 113, 112, 113, 112, 112, 112, 111, 110, 110, 110, 109,
109, 108, 108, 108, 108, 107, 106, 106, 106, 106, 104, 104, 104, 103, 103, 102,
101, 101, 100, 99, 99, 98, 99, 98, 97, 97, 97, 96, 95, 95, 93, 93, 93, 92, 91,
91, 90, 89, 89, 88, 89, 87, 87, 86, 85, 85, 84, 85, 83, 83, 81, 82, 80, 79, 79,
79, 77, 77, 77, 76, 75, 74, 74, 73, 72, 72, 72, 70, 70, 68, 68, 68, 67, 66, 66,
65, 64, 63, 63, 61, 61, 60, 59, 59, 57, 57, 57, 55, 55, 54, 53, 52, 53, 51, 50,
49, 49, 48, 47, 46, 46, 45, 44, 44, 43, 42, 41, 40, 40, 39, 38, 37, 35, 35, 35,
33, 33, 33, 32, 31, 30, 29, 28, 27, 26, 26, 25, 24, 23, 23, 22, 21, 21, 19, 18,
18, 17, 15, 15, 15, 13, 13, 13, 11, 10, 9, 9, 8, 7, 7, 5, 4, 3, 2, 2, 1, 0, 0,
-1, -2, -2, -4, -4, -6, -6, -8, -8, -9, -9, -10, -11, -13, -13, -14, -15, -15,
-16, -17, -18, -18, -20, -20, -20, -21, -23, -24, -24, -25, -27, -26, -28, -29,
-30, -30, -30, -31, -33, -32, -34, -35, -36, -37, -37, -38, -39, -40, -41, -41,
-42, -42, -43, -44, -45, -46, -47, -47, -49, -48, -50, -51, -51, -52, -53, -53,
-54, -55, -56, -57, -57, -58, -59, -60, -61, -61, -62, -62, -64, -65, -65, -65,
-67, -67, -67, -69, -69, -70, -70, -71, -71, -72, -73, -74, -75, -75, -76, -77,
-77, -78, -79, -79, -80, -81, -81, -82, -83, -83, -84, -84, -84, -86, -86, -87,
-87, -88, -88, -90, -90, -91, -92, -92, -92, -93, -93, -94, -95, -95, -96, -96,
-97, -98, -98, -99, -99, -99, -100, -101, -101, -102, -102, -103, -103, -104,
-103, -105, -105, -105, -106, -106, -107, -108, -107, -108, -108, -109, -109,
-111, -110, -111, -111, -111, -112, -113, -113, -113, -113, -114, -114, -114,
-115, -115, -115, -116, -116, -115, -117, -117, -117, -117, -117, -117, -117,
-119, -119, -119, -119, -119, -119, -118, -118, -117, -116, -116, -114, -113,
-112, -111, -109, -108, -106, -104, -103, -101, -99, -97, -95, -93, -92, -90,
-88, -86, -84, -82, -80, -77, -76, -74, -72, -70, -68, -66, -64, -62, -60, -58,
-56, -55, -52, -50, -48, -46, -43, -42, -40, -37, -36, -34, -32, -31, -28, -27,
-25, -22, -21, -18, -16, -14, -12, -11, -8, -7, -4, -2, -1, };