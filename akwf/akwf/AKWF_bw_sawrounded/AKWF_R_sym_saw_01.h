#define DATA_LENGTH 512
#define DATA AKWF_R_sym_saw_01

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 6, 6, 9, 9, 11, 13, 14, 16,
17, 18, 21, 22, 24, 25, 26, 28, 29, 31, 32, 34, 35, 37, 39, 40, 41, 44, 45, 46,
48, 49, 50, 51, 54, 54, 57, 59, 60, 61, 62, 64, 66, 67, 68, 69, 71, 72, 75, 75,
76, 79, 81, 81, 83, 84, 85, 86, 88, 89, 90, 92, 93, 94, 95, 97, 98, 99, 100,
102, 102, 104, 105, 106, 107, 108, 109, 110, 111, 111, 113, 113, 115, 115, 116,
116, 116, 117, 118, 118, 119, 119, 118, 119, 119, 119, 119, 119, 118, 118, 118,
117, 117, 116, 115, 115, 114, 113, 114, 112, 112, 111, 110, 110, 110, 110, 108,
108, 107, 106, 105, 105, 105, 103, 104, 102, 102, 101, 101, 101, 100, 99, 98,
98, 97, 96, 95, 94, 93, 94, 93, 92, 91, 91, 89, 89, 88, 88, 86, 87, 85, 85, 84,
83, 82, 82, 80, 80, 79, 79, 77, 77, 77, 76, 75, 73, 73, 73, 71, 71, 70, 69, 69,
68, 67, 66, 66, 65, 63, 64, 62, 61, 60, 60, 59, 58, 58, 57, 55, 55, 55, 53, 53,
53, 52, 50, 49, 48, 48, 47, 46, 45, 44, 43, 43, 42, 41, 40, 40, 39, 38, 36, 36,
35, 34, 34, 33, 32, 31, 30, 30, 29, 28, 26, 26, 25, 24, 23, 22, 22, 21, 20, 19,
19, 18, 16, 15, 15, 14, 13, 13, 12, 11, 10, 8, 8, 7, 6, 6, 4, 3, 3, 2, 1, 0, 0,
0, -2, -3, -3, -5, -6, -6, -7, -8, -9, -10, -11, -12, -12, -13, -14, -15, -16,
-17, -17, -18, -19, -20, -21, -22, -23, -23, -24, -25, -27, -26, -29, -29, -29,
-31, -31, -31, -32, -34, -35, -35, -36, -37, -38, -38, -40, -40, -41, -42, -42,
-44, -45, -45, -47, -47, -49, -49, -49, -50, -51, -52, -53, -54, -54, -56, -56,
-57, -58, -59, -59, -60, -61, -62, -62, -63, -64, -65, -66, -66, -67, -68, -69,
-69, -70, -72, -72, -73, -73, -75, -75, -76, -77, -77, -78, -79, -79, -80, -80,
-81, -82, -83, -84, -85, -85, -86, -86, -88, -88, -89, -90, -90, -91, -92, -92,
-92, -94, -94, -96, -96, -97, -96, -98, -98, -100, -100, -100, -101, -102, -102,
-103, -104, -105, -105, -106, -107, -107, -108, -108, -109, -109, -110, -111,
-112, -112, -113, -113, -114, -115, -114, -115, -116, -117, -117, -118, -117,
-118, -119, -119, -119, -119, -118, -119, -119, -119, -118, -117, -117, -117,
-115, -115, -115, -115, -113, -112, -112, -110, -110, -109, -109, -107, -106,
-105, -104, -103, -102, -100, -99, -98, -97, -95, -94, -93, -92, -90, -89, -88,
-86, -85, -83, -83, -80, -79, -78, -76, -76, -74, -72, -70, -70, -68, -67, -65,
-64, -62, -61, -60, -58, -57, -55, -54, -52, -50, -49, -47, -47, -44, -42, -42,
-40, -39, -38, -35, -34, -33, -31, -29, -28, -26, -25, -23, -22, -19, -19, -17,
-16, -14, -13, -12, -10, -8, -6, -6, -4, -1, -1, };