#define DATA_LENGTH 512
#define DATA AKWF_R_sym_saw_02

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 6, 8, 9, 11, 12, 15, 16, 17,
20, 22, 23, 25, 26, 27, 30, 32, 33, 35, 36, 39, 40, 41, 43, 45, 47, 49, 50, 52,
54, 56, 57, 58, 60, 62, 64, 65, 68, 68, 71, 73, 75, 76, 77, 79, 81, 83, 83, 86,
88, 89, 90, 92, 94, 95, 96, 99, 99, 101, 102, 104, 105, 107, 108, 110, 110, 112,
112, 113, 115, 115, 116, 116, 118, 118, 118, 119, 118, 120, 119, 119, 118, 118,
117, 117, 117, 116, 117, 115, 115, 115, 114, 114, 113, 113, 112, 112, 112, 112,
110, 111, 110, 110, 109, 108, 108, 107, 107, 106, 105, 106, 105, 103, 103, 103,
102, 102, 101, 102, 100, 100, 100, 98, 98, 97, 98, 96, 95, 95, 93, 95, 93, 93,
92, 91, 91, 90, 89, 88, 87, 87, 87, 87, 86, 85, 85, 83, 83, 82, 81, 80, 80, 79,
78, 78, 77, 77, 76, 75, 75, 73, 73, 73, 72, 72, 71, 70, 69, 68, 68, 67, 66, 65,
64, 64, 64, 62, 62, 61, 60, 59, 59, 57, 57, 57, 55, 54, 54, 54, 52, 52, 52, 50,
50, 49, 48, 47, 47, 45, 45, 44, 43, 42, 42, 41, 40, 39, 39, 38, 36, 36, 36, 34,
33, 33, 32, 31, 30, 29, 28, 27, 26, 26, 25, 24, 24, 22, 21, 22, 20, 20, 19, 17,
17, 16, 15, 14, 14, 12, 12, 11, 10, 9, 9, 8, 8, 6, 6, 5, 4, 3, 2, 1, 0, -1, -1,
-2, -3, -4, -5, -6, -7, -7, -8, -9, -10, -11, -11, -12, -13, -14, -14, -16, -16,
-17, -19, -19, -20, -20, -21, -22, -22, -24, -24, -25, -26, -26, -27, -29, -29,
-29, -31, -32, -33, -33, -35, -36, -35, -36, -37, -38, -39, -40, -41, -41, -43,
-42, -44, -45, -45, -47, -47, -48, -49, -49, -50, -50, -52, -53, -53, -54, -54,
-56, -55, -58, -58, -59, -59, -60, -61, -62, -62, -64, -64, -64, -65, -66, -66,
-68, -68, -69, -70, -71, -72, -72, -73, -74, -74, -74, -75, -77, -77, -78, -78,
-78, -79, -80, -81, -81, -82, -83, -83, -85, -85, -85, -87, -86, -87, -88, -88,
-89, -90, -91, -91, -91, -93, -93, -95, -95, -94, -96, -95, -97, -98, -97, -98,
-99, -100, -101, -101, -101, -102, -102, -103, -103, -104, -104, -105, -106,
-106, -107, -107, -108, -109, -109, -109, -109, -110, -111, -111, -112, -112,
-113, -114, -114, -113, -114, -115, -115, -115, -116, -116, -117, -117, -118,
-118, -119, -119, -119, -119, -119, -118, -119, -119, -117, -116, -116, -115,
-115, -113, -112, -111, -110, -109, -108, -107, -105, -104, -102, -102, -100,
-99, -97, -95, -94, -92, -90, -89, -87, -85, -83, -82, -81, -79, -78, -76, -74,
-73, -70, -69, -67, -65, -64, -62, -60, -59, -57, -55, -54, -52, -51, -49, -47,
-45, -44, -41, -40, -38, -37, -34, -33, -31, -29, -28, -26, -25, -23, -22, -19,
-18, -16, -14, -13, -10, -9, -8, -5, -4, -2, 0, };