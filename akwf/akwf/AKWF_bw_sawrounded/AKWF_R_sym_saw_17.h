#define DATA_LENGTH 512
#define DATA AKWF_R_sym_saw_17

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 32, 55, 76, 90, 96, 101, 105, 107,
109, 111, 114, 116, 116, 117, 117, 119, 118, 119, 119, 119, 119, 119, 119, 119,
118, 118, 118, 117, 116, 117, 116, 115, 115, 115, 115, 115, 114, 113, 113, 112,
112, 110, 110, 110, 109, 108, 108, 108, 107, 107, 106, 105, 105, 105, 104, 104,
103, 103, 103, 102, 101, 100, 100, 100, 99, 98, 98, 98, 97, 97, 96, 95, 95, 94,
94, 93, 93, 92, 92, 92, 91, 90, 89, 90, 89, 88, 87, 86, 86, 86, 85, 85, 84, 84,
83, 83, 82, 81, 82, 80, 80, 79, 79, 79, 78, 77, 76, 76, 77, 76, 74, 75, 74, 73,
73, 71, 71, 72, 70, 70, 69, 70, 68, 68, 67, 67, 67, 66, 65, 64, 64, 64, 63, 64,
63, 62, 61, 61, 60, 60, 60, 59, 58, 58, 57, 57, 56, 56, 55, 54, 55, 54, 53, 53,
52, 51, 50, 50, 50, 49, 49, 49, 48, 47, 47, 46, 45, 45, 45, 44, 44, 44, 42, 43,
41, 41, 41, 40, 40, 39, 38, 39, 38, 36, 37, 37, 35, 35, 35, 34, 33, 33, 32, 32,
31, 31, 30, 30, 30, 29, 29, 28, 27, 27, 26, 26, 25, 24, 24, 24, 22, 22, 22, 22,
21, 20, 20, 19, 19, 18, 18, 17, 17, 17, 16, 16, 15, 14, 14, 14, 12, 12, 11, 11,
10, 9, 10, 9, 8, 8, 7, 6, 6, 5, 5, 5, 5, 4, 4, 2, 3, 2, 1, 0, 0, -1, -1, -1, -2,
-2, -3, -3, -5, -5, -5, -6, -6, -7, -7, -8, -9, -8, -9, -10, -11, -11, -12, -12,
-12, -12, -13, -14, -14, -15, -15, -16, -17, -17, -18, -18, -18, -19, -20, -20,
-20, -21, -21, -22, -23, -23, -23, -25, -25, -24, -26, -27, -27, -27, -28, -29,
-29, -29, -30, -31, -31, -31, -32, -32, -34, -33, -34, -34, -36, -35, -36, -37,
-37, -37, -38, -38, -39, -40, -39, -40, -40, -41, -42, -43, -43, -43, -45, -45,
-45, -47, -46, -47, -47, -48, -48, -49, -50, -50, -50, -50, -52, -52, -53, -53,
-54, -54, -55, -55, -55, -56, -57, -57, -58, -58, -58, -59, -60, -61, -60, -62,
-62, -62, -63, -64, -64, -64, -65, -66, -66, -66, -67, -67, -69, -69, -68, -70,
-70, -70, -71, -72, -72, -73, -73, -74, -75, -74, -76, -76, -77, -78, -78, -78,
-79, -79, -79, -80, -80, -81, -81, -82, -82, -82, -84, -84, -86, -85, -86, -86,
-86, -88, -88, -88, -89, -90, -89, -91, -91, -91, -93, -93, -94, -93, -95, -94,
-95, -96, -97, -97, -98, -98, -99, -99, -100, -101, -100, -101, -101, -102,
-103, -103, -104, -103, -106, -106, -106, -107, -106, -107, -108, -108, -110,
-110, -110, -110, -111, -112, -111, -112, -113, -113, -114, -114, -115, -116,
-115, -116, -116, -117, -117, -118, -118, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -118, -118, -118, -116, -115, -113, -112, -110, -107, -104,
-101, -96, -91, -75, -54, -31, -8, };