#define DATA_LENGTH 512
#define DATA AKWF_R_sym_saw_15

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 21, 36, 51, 67, 82, 93, 100, 103,
106, 108, 109, 112, 113, 114, 114, 115, 117, 118, 118, 118, 118, 119, 119, 119,
119, 118, 118, 119, 118, 118, 118, 118, 117, 117, 117, 117, 117, 116, 115, 115,
115, 114, 114, 113, 113, 112, 111, 110, 112, 110, 110, 109, 108, 108, 108, 108,
107, 107, 105, 105, 105, 104, 103, 103, 102, 102, 101, 101, 101, 100, 100, 99,
99, 97, 97, 96, 97, 96, 95, 94, 94, 93, 93, 92, 91, 91, 90, 90, 89, 89, 89, 88,
87, 88, 87, 85, 86, 84, 84, 83, 83, 83, 81, 81, 81, 81, 80, 79, 79, 78, 77, 77,
76, 76, 75, 74, 74, 74, 73, 74, 73, 72, 71, 71, 70, 69, 69, 68, 67, 68, 67, 67,
65, 65, 64, 65, 63, 63, 62, 62, 62, 61, 61, 60, 60, 59, 58, 57, 57, 57, 56, 56,
55, 55, 54, 54, 52, 52, 51, 52, 50, 50, 49, 49, 49, 49, 48, 48, 46, 45, 46, 45,
44, 43, 43, 42, 42, 42, 42, 41, 40, 39, 39, 39, 38, 38, 37, 37, 35, 34, 35, 35,
34, 33, 32, 32, 31, 31, 30, 30, 29, 29, 29, 28, 27, 26, 26, 26, 26, 24, 24, 23,
23, 22, 22, 21, 20, 20, 19, 19, 19, 18, 17, 18, 16, 16, 15, 14, 14, 14, 14, 13,
12, 12, 12, 11, 10, 9, 8, 8, 8, 7, 6, 6, 5, 5, 4, 4, 4, 3, 3, 2, 1, 0, 1, 0, -1,
-1, -2, -2, -3, -3, -5, -5, -6, -6, -7, -7, -7, -8, -8, -8, -9, -10, -11, -11,
-12, -12, -12, -14, -14, -14, -15, -15, -16, -16, -17, -18, -18, -19, -19, -20,
-21, -21, -21, -22, -22, -23, -24, -24, -24, -25, -26, -25, -26, -26, -27, -28,
-29, -29, -30, -30, -31, -31, -32, -32, -33, -34, -33, -34, -35, -35, -36, -36,
-37, -38, -38, -39, -39, -41, -41, -41, -42, -42, -43, -43, -44, -45, -46, -46,
-46, -46, -48, -47, -48, -49, -49, -50, -50, -51, -52, -51, -52, -53, -54, -54,
-55, -55, -55, -55, -57, -57, -58, -58, -59, -58, -60, -60, -61, -62, -61, -63,
-63, -64, -65, -64, -66, -66, -67, -67, -68, -68, -69, -69, -70, -70, -71, -71,
-72, -72, -72, -74, -73, -74, -75, -75, -76, -77, -77, -78, -78, -78, -79, -80,
-80, -81, -81, -82, -83, -84, -84, -85, -84, -85, -86, -86, -87, -88, -88, -89,
-89, -90, -89, -91, -91, -92, -92, -93, -93, -94, -95, -95, -96, -96, -97, -97,
-98, -98, -99, -100, -100, -100, -101, -101, -102, -102, -103, -103, -104, -105,
-106, -106, -106, -107, -108, -108, -108, -109, -109, -110, -110, -110, -112,
-112, -113, -113, -113, -114, -114, -115, -115, -115, -115, -117, -116, -117,
-118, -118, -118, -118, -119, -120, -118, -119, -119, -119, -119, -119, -118,
-119, -119, -118, -117, -116, -116, -115, -113, -112, -110, -109, -107, -105,
-103, -100, -94, -81, -65, -50, -35, -20, -5, };