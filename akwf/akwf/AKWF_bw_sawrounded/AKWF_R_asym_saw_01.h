#define DATA_LENGTH 512
#define DATA AKWF_R_asym_saw_01

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 5, 7, 7, 8, 9, 10, 12, 13,
13, 15, 15, 16, 17, 19, 20, 21, 23, 22, 24, 25, 26, 26, 27, 28, 29, 30, 31, 32,
33, 34, 35, 35, 37, 37, 38, 39, 39, 40, 40, 41, 42, 43, 44, 45, 45, 45, 46, 47,
47, 48, 48, 49, 49, 51, 51, 52, 52, 53, 53, 54, 54, 54, 56, 57, 56, 57, 58, 58,
59, 59, 59, 60, 60, 60, 61, 61, 61, 62, 62, 63, 63, 64, 63, 64, 64, 65, 66, 66,
66, 66, 67, 67, 67, 67, 67, 67, 69, 68, 68, 69, 69, 69, 69, 70, 69, 70, 71, 70,
70, 70, 71, 71, 71, 71, 70, 71, 71, 71, 71, 71, 72, 72, 71, 71, 71, 72, 71, 71,
72, 71, 72, 71, 71, 71, 71, 72, 70, 71, 71, 71, 71, 71, 70, 70, 70, 71, 70, 70,
70, 70, 70, 69, 69, 68, 69, 69, 69, 68, 68, 67, 68, 67, 67, 67, 67, 66, 67, 66,
66, 66, 65, 65, 65, 64, 64, 64, 63, 63, 63, 62, 62, 62, 62, 60, 61, 60, 60, 60,
59, 59, 58, 58, 58, 57, 57, 56, 56, 55, 55, 55, 54, 54, 54, 53, 52, 53, 52, 51,
51, 50, 50, 50, 48, 48, 48, 47, 47, 46, 45, 46, 45, 44, 44, 43, 42, 42, 41, 41,
40, 40, 39, 39, 38, 36, 36, 36, 35, 35, 34, 34, 32, 32, 32, 30, 31, 29, 28, 29,
29, 27, 26, 26, 24, 24, 24, 23, 22, 22, 21, 20, 19, 18, 18, 17, 17, 16, 16, 14,
14, 12, 13, 11, 11, 10, 10, 9, 8, 7, 6, 5, 6, 4, 3, 2, 1, 1, 0, -1, -2, -2, -3,
-3, -5, -5, -7, -7, -8, -9, -9, -10, -11, -12, -14, -13, -15, -17, -16, -17,
-17, -19, -21, -20, -22, -22, -24, -25, -25, -26, -27, -28, -29, -30, -31, -32,
-32, -33, -34, -36, -36, -37, -38, -39, -40, -40, -42, -42, -44, -45, -46, -46,
-47, -48, -49, -49, -52, -52, -53, -55, -55, -56, -57, -58, -60, -60, -61, -61,
-63, -64, -64, -66, -67, -69, -68, -70, -71, -72, -73, -74, -75, -76, -77, -78,
-79, -80, -82, -82, -83, -84, -86, -86, -87, -88, -90, -90, -92, -92, -94, -95,
-95, -97, -97, -99, -100, -101, -101, -103, -104, -105, -107, -108, -109, -109,
-110, -111, -113, -114, -115, -115, -117, -117, -118, -118, -119, -119, -119,
-119, -118, -119, -119, -118, -117, -118, -116, -116, -115, -114, -114, -112,
-111, -110, -109, -108, -107, -106, -105, -103, -102, -100, -100, -98, -96, -95,
-94, -92, -91, -89, -88, -87, -85, -84, -82, -81, -79, -78, -76, -74, -73, -71,
-70, -68, -66, -66, -63, -62, -61, -59, -58, -56, -54, -53, -51, -49, -49, -47,
-44, -43, -42, -40, -40, -38, -37, -35, -33, -31, -31, -30, -28, -26, -26, -24,
-23, -21, -19, -18, -17, -16, -14, -14, -11, -11, -10, -8, -7, -6, -4, -3, -3,
-1, };