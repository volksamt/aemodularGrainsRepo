#define DATA_LENGTH 512
#define DATA AKWF_R_sym_saw_07

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 10, 14, 18, 21, 25, 29, 34, 37,
41, 46, 50, 54, 59, 63, 67, 70, 74, 79, 83, 88, 91, 96, 99, 103, 107, 110, 111,
113, 113, 113, 114, 114, 115, 115, 116, 117, 117, 117, 118, 117, 118, 118, 118,
119, 118, 118, 118, 119, 120, 119, 118, 118, 119, 120, 118, 120, 119, 119, 119,
119, 119, 119, 119, 118, 118, 118, 117, 117, 117, 117, 117, 117, 116, 115, 116,
115, 114, 115, 115, 115, 114, 113, 113, 112, 113, 112, 111, 110, 110, 111, 110,
110, 109, 108, 108, 108, 107, 107, 106, 105, 105, 105, 104, 104, 103, 103, 102,
102, 100, 100, 100, 100, 99, 98, 98, 97, 96, 96, 95, 95, 95, 93, 93, 93, 92, 91,
91, 90, 89, 89, 88, 88, 87, 86, 86, 86, 84, 84, 83, 83, 82, 82, 81, 80, 79, 78,
78, 77, 76, 76, 75, 75, 74, 73, 72, 71, 72, 70, 70, 69, 68, 68, 67, 67, 65, 64,
64, 63, 62, 62, 61, 61, 59, 58, 59, 58, 57, 56, 56, 55, 54, 53, 53, 52, 50, 50,
50, 50, 49, 47, 47, 47, 46, 44, 45, 43, 42, 41, 41, 40, 40, 38, 39, 38, 37, 36,
35, 35, 34, 33, 33, 31, 31, 30, 29, 30, 27, 27, 26, 25, 25, 24, 24, 22, 22, 21,
21, 20, 19, 19, 17, 16, 16, 15, 14, 13, 13, 12, 11, 11, 10, 10, 9, 8, 7, 6, 5,
5, 4, 3, 3, 2, 1, 1, 0, -1, -1, -2, -3, -4, -5, -6, -6, -7, -8, -9, -9, -11,
-11, -12, -13, -13, -14, -15, -15, -16, -17, -18, -17, -19, -19, -21, -22, -22,
-22, -24, -25, -25, -25, -27, -28, -27, -28, -29, -30, -30, -31, -32, -33, -33,
-34, -36, -37, -37, -38, -38, -40, -40, -40, -41, -42, -42, -44, -44, -45, -46,
-46, -47, -48, -48, -50, -50, -51, -51, -52, -52, -54, -54, -56, -56, -57, -56,
-58, -59, -59, -60, -61, -61, -63, -63, -63, -64, -64, -65, -67, -67, -68, -69,
-69, -70, -71, -71, -72, -73, -73, -74, -74, -76, -76, -77, -77, -78, -78, -79,
-80, -81, -80, -81, -82, -84, -85, -84, -85, -85, -87, -87, -87, -88, -89, -89,
-91, -92, -91, -91, -92, -93, -94, -95, -94, -96, -96, -96, -97, -97, -99, -98,
-100, -100, -101, -101, -102, -102, -103, -102, -104, -105, -105, -105, -106,
-106, -106, -107, -108, -109, -109, -109, -109, -109, -111, -110, -111, -111,
-112, -112, -112, -113, -113, -114, -114, -114, -115, -114, -116, -116, -116,
-116, -116, -117, -117, -117, -117, -117, -118, -118, -118, -118, -119, -118,
-118, -119, -118, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -118, -118, -118, -117, -118, -118, -118, -117, -116, -117, -116,
-115, -115, -115, -114, -114, -113, -113, -111, -108, -106, -102, -99, -95, -91,
-86, -82, -79, -74, -70, -67, -61, -58, -53, -50, -46, -41, -37, -34, -29, -25,
-21, -18, -13, -10, -5, -2, };