#define DATA_LENGTH 512
#define DATA AKWF_R_asym_saw_16

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 16, 30, 43, 53, 62, 70, 77, 85, 89,
94, 98, 101, 105, 108, 109, 111, 113, 115, 116, 116, 118, 118, 119, 118, 120,
119, 119, 119, 119, 119, 119, 119, 118, 118, 118, 117, 116, 116, 115, 115, 115,
114, 114, 113, 112, 112, 112, 111, 110, 109, 110, 108, 109, 107, 106, 105, 106,
105, 104, 104, 103, 102, 102, 101, 101, 100, 99, 99, 99, 97, 97, 97, 96, 95, 94,
95, 93, 93, 93, 92, 92, 91, 90, 90, 89, 89, 88, 87, 86, 85, 85, 85, 85, 84, 83,
82, 82, 82, 81, 80, 80, 78, 79, 78, 77, 77, 77, 75, 75, 75, 74, 73, 73, 72, 71,
72, 70, 69, 69, 68, 68, 68, 66, 66, 67, 65, 65, 65, 63, 63, 63, 62, 61, 60, 60,
60, 59, 59, 58, 57, 56, 57, 55, 55, 55, 53, 54, 53, 53, 52, 51, 51, 50, 50, 49,
48, 48, 48, 46, 47, 46, 46, 45, 44, 43, 44, 43, 42, 41, 40, 41, 39, 39, 38, 38,
38, 37, 36, 35, 35, 35, 35, 34, 33, 33, 32, 31, 31, 31, 30, 30, 28, 29, 29, 28,
26, 27, 26, 25, 25, 24, 24, 23, 22, 23, 22, 21, 21, 19, 20, 19, 18, 18, 17, 17,
16, 16, 15, 14, 15, 14, 13, 14, 12, 11, 11, 11, 10, 10, 10, 8, 8, 8, 7, 7, 7, 6,
5, 5, 4, 4, 3, 3, 2, 2, 1, 1, 0, -1, -2, -2, -2, -3, -3, -3, -4, -4, -5, -5, -7,
-6, -7, -7, -8, -8, -9, -9, -10, -10, -10, -12, -11, -12, -12, -14, -13, -14,
-14, -16, -15, -16, -16, -17, -17, -17, -18, -19, -20, -20, -20, -21, -21, -22,
-22, -22, -23, -24, -25, -24, -25, -26, -26, -26, -26, -27, -29, -28, -30, -29,
-31, -31, -30, -31, -32, -32, -32, -33, -34, -34, -35, -35, -35, -35, -37, -37,
-37, -38, -38, -39, -40, -40, -40, -40, -41, -41, -43, -43, -43, -44, -43, -44,
-45, -45, -46, -47, -46, -47, -47, -48, -48, -49, -49, -50, -50, -51, -51, -51,
-52, -53, -52, -53, -54, -55, -55, -55, -55, -56, -56, -57, -57, -58, -58, -59,
-59, -59, -59, -60, -61, -61, -62, -62, -63, -64, -63, -65, -64, -65, -65, -66,
-66, -66, -67, -67, -68, -68, -68, -69, -70, -70, -70, -72, -71, -72, -72, -72,
-73, -74, -75, -74, -76, -76, -75, -76, -76, -77, -77, -78, -78, -79, -79, -80,
-80, -80, -81, -81, -81, -83, -82, -83, -83, -84, -84, -85, -85, -85, -86, -86,
-87, -87, -87, -88, -88, -88, -89, -89, -90, -90, -91, -91, -92, -92, -93, -93,
-93, -94, -94, -95, -95, -96, -96, -97, -96, -97, -98, -98, -98, -99, -99, -99,
-99, -100, -100, -100, -101, -102, -102, -102, -103, -104, -104, -105, -104,
-105, -106, -106, -107, -107, -107, -107, -107, -108, -109, -109, -109, -110,
-109, -110, -111, -111, -112, -112, -113, -112, -113, -114, -113, -103, -81,
-56, -33, -12, };