#define DATA_LENGTH 512
#define DATA AKWF_R_asym_saw_07

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 7, 9, 13, 16, 18, 21, 23, 26,
28, 30, 33, 35, 37, 39, 42, 44, 45, 47, 49, 51, 53, 54, 56, 57, 59, 61, 62, 64,
65, 67, 67, 69, 69, 72, 72, 73, 74, 75, 76, 77, 77, 79, 79, 80, 81, 82, 83, 83,
84, 84, 86, 86, 86, 86, 87, 87, 88, 88, 89, 89, 89, 89, 89, 91, 90, 91, 91, 90,
91, 91, 91, 92, 91, 92, 91, 92, 92, 92, 92, 92, 92, 92, 91, 91, 91, 92, 92, 92,
90, 91, 91, 90, 91, 90, 89, 90, 89, 89, 89, 89, 89, 89, 88, 88, 87, 87, 86, 87,
87, 86, 86, 85, 84, 85, 84, 84, 83, 83, 83, 82, 82, 81, 81, 81, 80, 80, 79, 79,
79, 78, 78, 77, 77, 76, 76, 74, 75, 74, 73, 72, 73, 72, 71, 72, 71, 71, 69, 69,
69, 67, 68, 67, 66, 66, 65, 65, 64, 64, 63, 63, 62, 61, 61, 61, 60, 59, 59, 58,
58, 56, 56, 55, 55, 54, 54, 54, 53, 52, 52, 52, 50, 50, 49, 48, 48, 47, 47, 46,
46, 45, 45, 44, 44, 43, 42, 42, 41, 40, 40, 40, 38, 38, 37, 37, 36, 36, 35, 34,
35, 33, 33, 32, 31, 31, 30, 29, 29, 29, 28, 27, 26, 26, 25, 25, 24, 24, 24, 23,
22, 21, 20, 19, 20, 19, 19, 17, 17, 16, 15, 15, 14, 13, 13, 13, 12, 12, 11, 10,
10, 9, 8, 8, 7, 6, 7, 6, 5, 4, 4, 3, 3, 1, 2, 0, 0, 0, -1, -2, -3, -2, -4, -4,
-5, -5, -7, -7, -7, -8, -8, -9, -10, -11, -11, -11, -12, -13, -13, -14, -15,
-16, -16, -17, -17, -18, -19, -19, -20, -20, -21, -21, -21, -22, -23, -24, -24,
-24, -25, -25, -26, -27, -28, -28, -28, -30, -30, -30, -32, -32, -32, -33, -33,
-34, -34, -35, -36, -36, -37, -38, -38, -38, -39, -39, -40, -41, -41, -42, -42,
-43, -44, -44, -45, -46, -46, -46, -47, -48, -48, -49, -49, -49, -50, -51, -52,
-52, -53, -54, -53, -54, -55, -55, -56, -56, -57, -57, -58, -59, -60, -60, -60,
-62, -62, -62, -63, -64, -64, -64, -65, -65, -66, -67, -68, -68, -68, -69, -69,
-70, -71, -71, -71, -72, -73, -73, -74, -74, -74, -75, -76, -77, -76, -77, -79,
-79, -79, -80, -80, -80, -81, -81, -83, -83, -83, -83, -84, -85, -86, -86, -87,
-87, -88, -87, -88, -89, -89, -90, -90, -92, -92, -92, -93, -93, -94, -95, -95,
-95, -96, -97, -97, -97, -99, -99, -99, -100, -100, -101, -101, -102, -101,
-102, -103, -103, -104, -105, -105, -106, -106, -107, -107, -108, -108, -109,
-109, -109, -110, -111, -111, -112, -113, -113, -113, -114, -115, -115, -116,
-115, -116, -116, -118, -118, -119, -119, -119, -118, -116, -112, -109, -104,
-100, -95, -89, -85, -80, -75, -70, -65, -61, -56, -52, -47, -43, -40, -35, -31,
-27, -24, -20, -16, -12, -9, -5, -2, };