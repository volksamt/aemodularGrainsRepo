#define DATA_LENGTH 512
#define DATA AKWF_R_asym_saw_13

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 12, 22, 30, 37, 44, 51, 57, 62, 68,
72, 77, 81, 84, 88, 91, 94, 96, 98, 101, 102, 105, 106, 107, 109, 110, 112, 112,
113, 114, 114, 115, 116, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117,
116, 117, 115, 115, 115, 116, 115, 115, 114, 114, 113, 112, 112, 112, 111, 111,
110, 110, 109, 109, 108, 108, 107, 107, 106, 106, 105, 104, 105, 102, 102, 103,
102, 101, 100, 100, 99, 98, 98, 98, 97, 96, 96, 95, 95, 94, 94, 93, 92, 91, 90,
90, 89, 89, 88, 87, 87, 87, 87, 84, 85, 85, 84, 82, 82, 82, 80, 80, 80, 79, 78,
77, 77, 77, 75, 75, 74, 75, 74, 73, 72, 72, 70, 71, 70, 70, 69, 68, 68, 67, 67,
66, 65, 64, 64, 63, 62, 62, 62, 62, 61, 60, 60, 58, 58, 58, 57, 56, 55, 55, 55,
54, 54, 54, 52, 52, 51, 51, 49, 50, 48, 48, 48, 46, 47, 46, 44, 44, 44, 43, 42,
42, 42, 41, 41, 40, 39, 39, 39, 37, 37, 37, 36, 35, 34, 34, 33, 33, 33, 32, 31,
31, 29, 29, 28, 28, 28, 27, 27, 26, 25, 26, 25, 25, 24, 23, 22, 22, 21, 20, 20,
20, 19, 19, 18, 17, 17, 16, 16, 15, 15, 15, 14, 13, 12, 12, 12, 11, 10, 10, 9,
9, 8, 7, 7, 7, 7, 6, 5, 4, 4, 4, 3, 2, 1, 2, 1, 0, -1, -1, -2, -2, -3, -3, -5,
-4, -5, -6, -7, -6, -7, -8, -8, -9, -9, -9, -10, -11, -11, -12, -12, -12, -14,
-14, -14, -15, -15, -16, -16, -16, -17, -18, -19, -19, -19, -20, -20, -21, -21,
-23, -23, -24, -23, -23, -25, -25, -26, -26, -26, -27, -27, -28, -29, -29, -30,
-30, -30, -31, -32, -32, -33, -34, -33, -35, -34, -34, -36, -37, -37, -37, -38,
-39, -39, -39, -40, -40, -41, -42, -41, -42, -43, -44, -43, -44, -45, -46, -46,
-46, -46, -48, -48, -49, -49, -50, -49, -50, -50, -51, -52, -52, -52, -53, -53,
-54, -54, -55, -55, -55, -57, -57, -58, -58, -59, -59, -59, -60, -61, -61, -61,
-62, -62, -63, -64, -64, -64, -64, -65, -65, -66, -66, -66, -68, -69, -68, -69,
-69, -71, -70, -71, -71, -72, -72, -72, -73, -74, -74, -75, -75, -76, -76, -77,
-77, -77, -78, -79, -78, -80, -79, -81, -80, -81, -81, -81, -82, -82, -84, -83,
-84, -84, -84, -86, -86, -87, -88, -87, -87, -88, -89, -89, -89, -90, -90, -91,
-92, -92, -92, -93, -93, -94, -94, -94, -95, -96, -96, -96, -96, -98, -97, -98,
-98, -98, -99, -100, -100, -101, -101, -101, -102, -102, -103, -103, -104, -104,
-104, -105, -106, -105, -106, -107, -108, -108, -107, -109, -108, -109, -110,
-110, -111, -111, -112, -112, -113, -112, -113, -114, -114, -113, -115, -114,
-116, -116, -117, -118, -118, -118, -119, -118, -120, -119, -112, -99, -84, -69,
-53, -41, -28, -16, -5, };