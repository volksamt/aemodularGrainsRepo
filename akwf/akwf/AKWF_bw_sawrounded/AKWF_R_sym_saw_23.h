#define DATA_LENGTH 512
#define DATA AKWF_R_sym_saw_23

const PROGMEM int8_t DATA[DATA_LENGTH] = {26, 81, 106, 112, 116, 118, 119, 119,
119, 119, 118, 119, 118, 117, 117, 116, 115, 116, 115, 115, 115, 114, 113, 113,
112, 111, 111, 111, 109, 110, 110, 108, 108, 108, 107, 106, 106, 106, 105, 105,
103, 104, 104, 102, 103, 101, 101, 101, 100, 101, 99, 99, 98, 98, 96, 98, 96,
96, 96, 95, 95, 95, 93, 93, 92, 92, 91, 90, 91, 90, 90, 89, 89, 88, 88, 86, 86,
87, 85, 85, 84, 84, 83, 83, 83, 82, 82, 81, 81, 80, 81, 79, 80, 78, 78, 78, 77,
76, 75, 76, 75, 74, 74, 73, 73, 72, 72, 72, 71, 71, 71, 70, 69, 69, 68, 67, 67,
67, 65, 66, 65, 65, 64, 64, 63, 62, 62, 61, 61, 61, 61, 60, 60, 59, 58, 58, 58,
57, 56, 57, 56, 56, 54, 54, 53, 53, 52, 52, 52, 51, 51, 51, 50, 49, 49, 49, 48,
48, 46, 47, 46, 45, 45, 45, 44, 43, 43, 43, 43, 42, 41, 41, 40, 39, 39, 38, 38,
38, 37, 36, 36, 35, 36, 34, 35, 33, 33, 33, 32, 32, 31, 32, 30, 30, 30, 29, 29,
27, 27, 27, 26, 26, 25, 25, 24, 25, 24, 23, 23, 22, 22, 21, 21, 21, 21, 19, 20,
19, 19, 18, 17, 17, 16, 15, 15, 15, 14, 14, 14, 12, 12, 11, 11, 10, 10, 10, 10,
8, 9, 8, 7, 6, 6, 6, 6, 5, 5, 4, 4, 3, 3, 2, 2, 1, 1, 0, -1, 0, -1, -2, -1, -3,
-3, -4, -5, -4, -5, -6, -6, -7, -7, -7, -7, -8, -9, -9, -10, -11, -11, -12, -12,
-12, -13, -13, -14, -15, -15, -16, -15, -16, -17, -16, -17, -18, -19, -19, -20,
-20, -21, -21, -22, -22, -22, -23, -23, -25, -25, -24, -25, -26, -27, -26, -28,
-28, -28, -28, -28, -29, -30, -31, -31, -32, -32, -33, -33, -34, -33, -35, -34,
-36, -36, -36, -37, -37, -37, -38, -38, -39, -40, -40, -41, -42, -42, -43, -42,
-44, -44, -44, -45, -44, -45, -46, -47, -47, -48, -48, -48, -49, -50, -50, -50,
-51, -51, -51, -52, -53, -53, -53, -54, -55, -56, -55, -56, -56, -57, -57, -58,
-58, -60, -59, -60, -60, -61, -62, -62, -62, -62, -63, -63, -65, -64, -65, -66,
-66, -67, -68, -68, -68, -68, -69, -70, -70, -71, -71, -71, -72, -72, -73, -74,
-74, -75, -74, -75, -76, -77, -77, -77, -78, -78, -79, -80, -80, -80, -80, -81,
-82, -82, -83, -83, -84, -85, -84, -85, -86, -86, -87, -87, -87, -88, -89, -89,
-89, -90, -90, -91, -92, -92, -93, -93, -94, -94, -95, -95, -95, -96, -97, -97,
-97, -98, -98, -99, -100, -99, -100, -100, -101, -102, -103, -103, -104, -104,
-104, -105, -106, -106, -105, -106, -107, -107, -108, -108, -109, -109, -110,
-111, -111, -112, -113, -113, -113, -114, -114, -115, -115, -115, -117, -116,
-116, -117, -118, -119, -118, -119, -119, -119, -118, -117, -116, -112, -105,
-78, -23, };