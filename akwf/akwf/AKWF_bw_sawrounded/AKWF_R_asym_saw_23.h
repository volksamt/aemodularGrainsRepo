#define DATA_LENGTH 512
#define DATA AKWF_R_asym_saw_23

const PROGMEM int8_t DATA[DATA_LENGTH] = {34, 72, 90, 105, 110, 115, 117, 119,
119, 119, 119, 119, 118, 117, 118, 116, 116, 116, 115, 115, 114, 113, 112, 112,
112, 111, 111, 110, 110, 109, 109, 108, 108, 107, 107, 105, 106, 105, 104, 103,
103, 102, 102, 101, 101, 100, 100, 100, 99, 97, 98, 97, 96, 95, 95, 95, 94, 93,
92, 93, 93, 91, 90, 90, 90, 89, 88, 88, 87, 87, 87, 86, 85, 85, 84, 84, 83, 83,
82, 82, 81, 81, 80, 80, 79, 79, 79, 77, 77, 76, 75, 76, 75, 74, 74, 72, 73, 72,
72, 71, 70, 70, 70, 69, 69, 68, 68, 67, 66, 66, 65, 65, 65, 64, 63, 63, 62, 62,
61, 61, 61, 60, 59, 59, 58, 58, 57, 56, 57, 55, 55, 54, 54, 54, 53, 53, 52, 51,
51, 51, 50, 50, 50, 49, 48, 48, 48, 47, 47, 45, 46, 44, 43, 44, 44, 43, 41, 42,
41, 40, 40, 39, 39, 39, 38, 38, 37, 36, 36, 36, 35, 34, 34, 35, 34, 32, 33, 32,
31, 31, 30, 30, 29, 28, 28, 29, 28, 27, 26, 26, 25, 25, 25, 24, 24, 23, 23, 22,
22, 21, 20, 20, 20, 20, 19, 19, 19, 18, 17, 16, 17, 16, 15, 15, 15, 14, 14, 13,
12, 13, 12, 11, 11, 10, 10, 10, 8, 9, 8, 8, 8, 6, 6, 6, 5, 4, 5, 4, 3, 3, 3, 2,
2, 2, 1, 0, 0, -1, -1, -1, -1, -2, -3, -3, -4, -5, -5, -5, -5, -7, -6, -7, -7,
-9, -8, -9, -9, -9, -10, -10, -11, -12, -12, -13, -13, -13, -13, -14, -15, -15,
-16, -16, -15, -17, -17, -17, -19, -18, -19, -19, -19, -20, -21, -22, -21, -21,
-22, -23, -24, -23, -23, -24, -25, -25, -25, -27, -26, -27, -27, -28, -29, -29,
-29, -29, -30, -30, -30, -32, -32, -32, -32, -33, -33, -34, -34, -35, -35, -35,
-36, -35, -37, -38, -38, -38, -39, -39, -39, -40, -39, -40, -41, -41, -41, -42,
-42, -43, -44, -44, -43, -45, -45, -45, -46, -46, -46, -47, -48, -48, -49, -49,
-49, -50, -49, -51, -51, -51, -51, -51, -52, -52, -53, -53, -54, -54, -55, -55,
-55, -56, -56, -56, -57, -58, -58, -58, -59, -59, -59, -59, -61, -61, -60, -61,
-62, -62, -63, -63, -63, -64, -64, -65, -65, -66, -65, -66, -67, -67, -67, -67,
-68, -68, -68, -69, -70, -69, -71, -71, -71, -72, -72, -71, -73, -73, -73, -74,
-75, -74, -75, -76, -75, -76, -76, -76, -77, -77, -79, -78, -78, -78, -79, -79,
-80, -80, -81, -81, -81, -82, -82, -83, -83, -83, -83, -85, -85, -85, -85, -86,
-86, -86, -87, -87, -88, -88, -89, -89, -88, -90, -89, -90, -91, -90, -91, -91,
-92, -92, -92, -92, -93, -94, -94, -93, -95, -94, -95, -95, -96, -96, -97, -97,
-98, -98, -98, -99, -99, -100, -100, -100, -101, -101, -100, -102, -102, -102,
-102, -104, -102, -104, -103, -105, -104, -105, -75, -12, };