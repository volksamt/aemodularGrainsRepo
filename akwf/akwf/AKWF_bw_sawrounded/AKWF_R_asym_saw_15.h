#define DATA_LENGTH 512
#define DATA AKWF_R_asym_saw_15

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 22, 33, 44, 52, 61, 68, 74, 79, 85,
90, 93, 98, 101, 103, 106, 108, 109, 112, 113, 114, 116, 116, 117, 118, 118,
119, 119, 119, 120, 119, 119, 119, 118, 119, 119, 118, 117, 118, 117, 116, 116,
116, 116, 115, 114, 114, 113, 113, 113, 112, 111, 111, 110, 109, 109, 108, 108,
107, 106, 106, 106, 105, 104, 104, 104, 102, 102, 101, 101, 100, 99, 99, 98, 98,
97, 97, 95, 95, 95, 94, 94, 93, 92, 92, 91, 90, 90, 89, 89, 88, 88, 87, 86, 86,
85, 85, 84, 83, 83, 82, 81, 81, 81, 80, 79, 79, 78, 77, 77, 76, 76, 74, 74, 73,
74, 73, 72, 72, 71, 70, 70, 69, 69, 68, 67, 67, 67, 66, 65, 65, 64, 63, 63, 62,
61, 61, 60, 60, 59, 59, 58, 57, 57, 56, 56, 55, 54, 54, 54, 53, 53, 52, 52, 51,
50, 50, 49, 48, 48, 48, 47, 46, 46, 45, 44, 44, 44, 43, 43, 42, 42, 42, 41, 40,
39, 39, 38, 38, 37, 36, 36, 35, 35, 34, 34, 33, 32, 33, 31, 31, 30, 30, 30, 29,
28, 28, 28, 27, 25, 26, 25, 24, 24, 24, 22, 23, 22, 22, 21, 20, 20, 19, 18, 18,
18, 17, 17, 16, 15, 15, 14, 14, 13, 13, 12, 12, 11, 10, 10, 9, 9, 9, 8, 7, 6, 6,
6, 5, 4, 4, 4, 4, 3, 2, 1, 2, 1, 1, 0, 0, -2, -2, -2, -3, -4, -4, -4, -4, -6,
-6, -6, -6, -8, -8, -8, -9, -9, -10, -11, -10, -11, -12, -12, -12, -13, -13,
-14, -16, -16, -16, -17, -16, -18, -17, -19, -19, -20, -20, -20, -21, -22, -22,
-22, -22, -23, -24, -24, -24, -25, -26, -26, -27, -27, -28, -28, -29, -30, -30,
-30, -31, -31, -32, -32, -32, -33, -34, -35, -35, -36, -35, -36, -36, -37, -38,
-38, -38, -38, -40, -40, -40, -41, -41, -41, -43, -43, -43, -44, -44, -44, -44,
-46, -46, -46, -47, -48, -48, -49, -49, -49, -49, -50, -51, -50, -52, -52, -52,
-53, -54, -54, -55, -54, -55, -55, -56, -57, -57, -58, -58, -57, -59, -59, -60,
-61, -60, -61, -61, -63, -63, -63, -63, -63, -64, -64, -65, -66, -66, -66, -67,
-68, -68, -69, -68, -70, -70, -70, -70, -71, -72, -72, -72, -73, -73, -73, -74,
-75, -75, -75, -76, -76, -77, -77, -78, -78, -79, -79, -79, -80, -81, -80, -81,
-81, -82, -81, -82, -83, -83, -84, -84, -85, -85, -85, -86, -87, -87, -87, -88,
-88, -88, -90, -90, -90, -91, -90, -91, -92, -92, -92, -93, -94, -94, -93, -94,
-95, -96, -97, -96, -96, -97, -97, -99, -98, -99, -99, -100, -100, -101, -101,
-101, -101, -103, -103, -102, -104, -104, -104, -104, -105, -106, -106, -106,
-106, -107, -108, -107, -108, -108, -109, -109, -109, -110, -111, -111, -112,
-112, -113, -113, -114, -113, -114, -114, -114, -115, -116, -116, -111, -94,
-74, -53, -34, -17, -3, };