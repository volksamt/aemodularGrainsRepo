#define DATA_LENGTH 512
#define DATA AKWF_R_asym_saw_03

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 5, 7, 8, 9, 10, 11, 13, 14,
16, 17, 19, 20, 20, 22, 23, 24, 25, 26, 28, 29, 30, 31, 32, 33, 34, 34, 36, 36,
37, 39, 39, 41, 42, 43, 43, 44, 44, 46, 47, 47, 47, 48, 50, 50, 51, 52, 52, 52,
53, 54, 54, 56, 56, 56, 57, 58, 59, 59, 59, 60, 61, 61, 62, 62, 62, 63, 63, 63,
64, 64, 65, 65, 65, 65, 67, 66, 67, 67, 67, 68, 68, 69, 69, 69, 69, 69, 70, 70,
70, 70, 70, 70, 71, 71, 71, 71, 71, 72, 72, 72, 72, 72, 72, 72, 71, 73, 72, 73,
73, 72, 73, 73, 72, 72, 73, 73, 72, 73, 72, 72, 73, 72, 72, 71, 72, 72, 72, 72,
71, 72, 71, 71, 72, 71, 71, 70, 70, 70, 70, 69, 70, 70, 69, 69, 69, 69, 68, 68,
68, 68, 68, 67, 67, 66, 66, 66, 66, 66, 65, 65, 65, 65, 65, 64, 63, 64, 63, 63,
62, 62, 61, 61, 60, 60, 60, 60, 59, 59, 59, 58, 58, 57, 57, 56, 57, 55, 55, 55,
55, 54, 53, 52, 53, 52, 52, 52, 51, 50, 49, 49, 49, 49, 48, 47, 47, 47, 46, 46,
45, 45, 44, 43, 43, 42, 41, 41, 41, 41, 39, 40, 39, 38, 38, 37, 36, 36, 35, 34,
33, 34, 32, 33, 32, 32, 30, 30, 30, 29, 28, 27, 27, 27, 26, 25, 25, 24, 23, 23,
22, 22, 21, 20, 19, 19, 19, 18, 18, 16, 16, 15, 15, 15, 13, 12, 12, 11, 11, 10,
10, 8, 9, 8, 8, 6, 5, 4, 4, 3, 3, 1, 0, 0, 0, -1, -1, -2, -2, -4, -4, -4, -5,
-6, -7, -7, -8, -8, -9, -11, -11, -11, -13, -13, -14, -15, -15, -15, -17, -17,
-19, -19, -20, -21, -21, -22, -22, -23, -24, -25, -26, -26, -26, -28, -29, -29,
-30, -31, -31, -32, -32, -34, -34, -36, -36, -37, -38, -38, -38, -39, -41, -41,
-41, -43, -44, -44, -44, -46, -46, -47, -47, -49, -50, -51, -50, -51, -52, -53,
-54, -54, -54, -56, -56, -57, -58, -59, -60, -60, -61, -62, -63, -63, -65, -65,
-66, -67, -67, -68, -69, -70, -70, -71, -72, -73, -73, -73, -75, -76, -77, -78,
-78, -79, -80, -80, -80, -81, -83, -83, -84, -84, -86, -86, -87, -88, -89, -90,
-90, -92, -91, -93, -93, -93, -94, -95, -96, -98, -98, -99, -99, -101, -101,
-102, -103, -104, -104, -105, -106, -107, -108, -109, -109, -109, -111, -111,
-112, -113, -113, -115, -115, -116, -117, -118, -118, -119, -120, -118, -119,
-119, -117, -117, -116, -114, -112, -111, -109, -108, -106, -104, -102, -99,
-97, -96, -94, -92, -89, -87, -85, -82, -80, -78, -76, -74, -72, -69, -67, -66,
-64, -61, -59, -56, -54, -52, -50, -49, -46, -44, -41, -41, -38, -36, -35, -32,
-30, -29, -27, -26, -23, -22, -20, -18, -16, -15, -14, -12, -10, -8, -7, -5, -4,
-2, 0, };