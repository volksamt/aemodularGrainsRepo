#define DATA_LENGTH 512
#define DATA AKWF_R_asym_saw_14

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 13, 24, 33, 42, 50, 57, 64, 69, 75,
80, 85, 88, 93, 96, 99, 101, 104, 106, 108, 110, 111, 112, 114, 114, 116, 116,
117, 117, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 118, 118, 117,
118, 117, 117, 116, 116, 115, 115, 114, 114, 114, 113, 113, 112, 112, 112, 111,
110, 110, 108, 108, 108, 107, 106, 106, 106, 105, 104, 104, 104, 102, 102, 101,
101, 100, 100, 98, 98, 97, 97, 96, 95, 95, 95, 93, 92, 93, 92, 92, 90, 89, 89,
89, 89, 88, 87, 86, 86, 86, 85, 84, 84, 83, 82, 82, 81, 80, 80, 79, 78, 78, 77,
77, 76, 76, 74, 75, 74, 74, 73, 71, 71, 70, 70, 70, 68, 69, 68, 67, 66, 66, 65,
65, 64, 64, 63, 62, 62, 61, 61, 60, 59, 59, 59, 58, 58, 57, 56, 56, 55, 55, 53,
53, 52, 52, 51, 51, 50, 50, 50, 49, 47, 47, 47, 46, 46, 44, 45, 44, 43, 43, 41,
41, 41, 40, 40, 39, 39, 38, 38, 38, 37, 36, 36, 34, 35, 34, 33, 32, 32, 31, 31,
30, 30, 29, 29, 29, 27, 27, 26, 26, 26, 25, 25, 24, 23, 23, 23, 21, 21, 21, 19,
19, 19, 18, 18, 16, 17, 16, 16, 15, 14, 14, 14, 12, 13, 11, 11, 10, 10, 10, 9,
8, 9, 8, 7, 5, 7, 5, 4, 4, 5, 2, 2, 2, 1, 1, 0, 1, 0, -1, -1, -1, -2, -4, -4,
-4, -5, -5, -6, -7, -7, -7, -8, -9, -8, -10, -10, -10, -11, -11, -13, -12, -13,
-14, -14, -15, -16, -16, -16, -17, -17, -18, -19, -19, -19, -20, -20, -21, -21,
-22, -21, -23, -23, -23, -25, -24, -25, -26, -26, -27, -27, -27, -29, -29, -29,
-30, -30, -31, -31, -32, -32, -33, -33, -34, -34, -34, -36, -36, -36, -37, -38,
-37, -38, -39, -40, -40, -40, -41, -41, -42, -42, -43, -43, -43, -43, -45, -45,
-45, -46, -47, -47, -47, -48, -48, -49, -50, -50, -50, -51, -52, -51, -52, -53,
-53, -54, -54, -55, -55, -56, -56, -56, -57, -58, -58, -58, -58, -59, -60, -61,
-61, -61, -61, -63, -63, -63, -64, -64, -64, -64, -66, -66, -66, -67, -67, -68,
-69, -69, -69, -69, -70, -71, -70, -71, -72, -72, -74, -73, -74, -73, -74, -75,
-75, -76, -77, -78, -78, -78, -78, -79, -79, -80, -80, -80, -81, -81, -82, -82,
-83, -84, -84, -84, -85, -85, -85, -86, -86, -87, -88, -87, -88, -89, -89, -90,
-91, -90, -91, -91, -92, -92, -92, -93, -94, -94, -94, -95, -95, -96, -96, -96,
-96, -98, -97, -98, -99, -98, -99, -99, -101, -100, -102, -102, -102, -102,
-103, -103, -103, -105, -105, -104, -105, -106, -106, -106, -108, -107, -108,
-109, -109, -109, -110, -110, -111, -111, -112, -112, -112, -113, -112, -114,
-113, -115, -114, -115, -115, -116, -116, -117, -116, -117, -117, -119, -116,
-104, -87, -69, -52, -35, -21, -8, };