#define DATA_LENGTH 512
#define DATA AKWF_R_sym_saw_25

const PROGMEM int8_t DATA[DATA_LENGTH] = {43, 102, 112, 118, 118, 119, 119, 118,
118, 117, 117, 117, 117, 116, 115, 115, 114, 114, 114, 113, 113, 111, 111, 111,
110, 110, 109, 109, 108, 108, 108, 107, 106, 105, 106, 105, 105, 105, 104, 103,
102, 102, 102, 101, 102, 100, 100, 99, 99, 98, 98, 97, 96, 97, 95, 95, 95, 95,
93, 93, 93, 93, 92, 91, 91, 90, 89, 90, 89, 89, 89, 87, 87, 87, 86, 86, 85, 84,
84, 84, 83, 83, 83, 82, 81, 81, 80, 80, 80, 80, 79, 78, 78, 77, 77, 76, 75, 75,
74, 75, 74, 74, 73, 73, 72, 71, 71, 71, 70, 70, 69, 69, 68, 68, 66, 67, 66, 66,
64, 64, 64, 63, 64, 63, 63, 62, 62, 61, 61, 60, 60, 59, 58, 58, 57, 57, 57, 57,
56, 55, 55, 54, 53, 52, 52, 53, 52, 51, 51, 51, 50, 49, 49, 49, 49, 48, 47, 46,
46, 45, 45, 45, 44, 44, 44, 43, 43, 42, 41, 41, 40, 40, 40, 40, 39, 38, 37, 37,
37, 36, 36, 36, 35, 34, 33, 32, 33, 32, 32, 31, 31, 31, 30, 29, 29, 29, 28, 28,
28, 27, 26, 26, 26, 25, 24, 25, 24, 24, 23, 22, 22, 21, 21, 21, 19, 19, 18, 19,
18, 17, 16, 16, 15, 15, 15, 15, 13, 13, 13, 12, 11, 12, 11, 10, 11, 9, 10, 9, 8,
8, 7, 7, 7, 7, 6, 6, 4, 4, 4, 4, 3, 2, 2, 1, 0, 0, 0, -1, -1, -2, -2, -2, -3,
-4, -3, -5, -5, -6, -6, -6, -6, -8, -8, -8, -9, -10, -9, -11, -10, -11, -12,
-12, -13, -13, -14, -13, -15, -15, -16, -16, -17, -16, -18, -18, -18, -19, -19,
-19, -20, -20, -21, -21, -22, -23, -23, -23, -24, -24, -25, -25, -26, -27, -26,
-27, -28, -28, -29, -29, -30, -30, -31, -31, -31, -31, -32, -33, -33, -34, -34,
-35, -35, -35, -36, -37, -37, -38, -38, -39, -39, -39, -41, -40, -41, -42, -42,
-43, -43, -43, -44, -44, -45, -46, -46, -47, -47, -46, -47, -48, -48, -50, -49,
-49, -50, -50, -51, -52, -51, -53, -54, -54, -55, -55, -55, -56, -56, -57, -57,
-58, -58, -59, -59, -60, -60, -61, -60, -61, -63, -62, -62, -63, -63, -65, -65,
-65, -65, -66, -67, -66, -68, -68, -68, -69, -69, -71, -71, -71, -72, -72, -72,
-73, -73, -74, -74, -74, -75, -76, -76, -77, -77, -78, -78, -78, -79, -79, -79,
-81, -81, -82, -83, -83, -82, -84, -83, -85, -85, -86, -86, -87, -87, -87, -88,
-88, -89, -89, -90, -90, -91, -91, -91, -91, -92, -93, -94, -93, -94, -94, -96,
-97, -97, -98, -97, -97, -98, -99, -99, -100, -100, -100, -101, -102, -103,
-103, -103, -103, -104, -104, -105, -105, -106, -106, -107, -107, -108, -109,
-109, -110, -109, -110, -110, -111, -111, -113, -113, -114, -114, -114, -115,
-115, -116, -116, -116, -118, -118, -118, -119, -119, -119, -119, -118, -113,
-100, -38, };