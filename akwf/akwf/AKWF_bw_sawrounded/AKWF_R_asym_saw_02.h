#define DATA_LENGTH 512
#define DATA AKWF_R_asym_saw_02

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 3, 5, 7, 8, 9, 10, 11, 12,
14, 15, 16, 17, 17, 19, 20, 22, 22, 24, 25, 26, 27, 28, 28, 29, 30, 31, 31, 33,
33, 35, 36, 36, 37, 38, 39, 39, 40, 41, 42, 42, 43, 44, 45, 45, 46, 47, 48, 48,
49, 50, 50, 51, 52, 52, 52, 53, 55, 54, 55, 55, 57, 57, 57, 58, 57, 59, 59, 59,
60, 60, 60, 60, 61, 62, 63, 63, 64, 64, 63, 64, 65, 64, 65, 65, 65, 66, 67, 66,
67, 67, 68, 68, 68, 68, 68, 68, 69, 69, 69, 69, 69, 69, 69, 70, 70, 70, 69, 70,
70, 71, 71, 70, 71, 71, 70, 71, 70, 70, 71, 72, 71, 71, 70, 71, 70, 71, 71, 70,
71, 70, 70, 70, 71, 71, 71, 71, 70, 70, 70, 70, 69, 69, 69, 69, 69, 69, 69, 68,
68, 68, 68, 68, 67, 67, 66, 67, 67, 67, 66, 66, 65, 64, 65, 65, 65, 64, 63, 64,
63, 63, 63, 63, 62, 61, 62, 61, 61, 61, 61, 59, 59, 60, 59, 59, 58, 58, 57, 57,
56, 56, 55, 55, 54, 54, 55, 53, 52, 53, 52, 52, 51, 51, 51, 50, 49, 49, 49, 48,
47, 48, 47, 47, 45, 45, 45, 44, 43, 43, 42, 42, 42, 40, 40, 40, 40, 39, 38, 37,
37, 37, 36, 36, 35, 35, 34, 33, 33, 32, 31, 30, 30, 30, 29, 28, 28, 27, 27, 26,
26, 25, 23, 23, 23, 22, 22, 20, 20, 20, 19, 19, 18, 17, 17, 16, 14, 14, 14, 13,
13, 11, 11, 10, 9, 9, 8, 7, 7, 6, 6, 4, 5, 3, 3, 3, 1, 0, 0, -1, -2, -3, -4, -4,
-4, -6, -6, -7, -8, -9, -9, -10, -11, -11, -12, -14, -13, -15, -15, -16, -17,
-18, -18, -19, -19, -20, -21, -22, -23, -24, -25, -26, -26, -27, -28, -28, -29,
-30, -31, -32, -33, -33, -34, -34, -36, -37, -38, -38, -39, -41, -41, -42, -42,
-43, -44, -45, -46, -46, -47, -48, -49, -49, -51, -52, -52, -53, -54, -55, -56,
-57, -57, -58, -58, -60, -60, -62, -63, -63, -64, -65, -65, -67, -68, -68, -69,
-71, -71, -73, -73, -74, -74, -76, -77, -78, -78, -80, -80, -81, -81, -83, -84,
-85, -85, -86, -87, -89, -89, -89, -90, -92, -92, -94, -94, -95, -96, -97, -97,
-98, -100, -101, -102, -102, -103, -104, -105, -105, -106, -107, -109, -109,
-110, -111, -112, -114, -114, -116, -116, -117, -118, -119, -118, -120, -119,
-119, -118, -118, -118, -117, -117, -115, -114, -112, -112, -111, -110, -108,
-106, -105, -104, -102, -100, -98, -97, -95, -92, -92, -89, -88, -87, -85, -83,
-81, -78, -78, -75, -73, -72, -69, -68, -67, -65, -62, -61, -58, -57, -55, -53,
-52, -50, -48, -46, -45, -43, -41, -40, -38, -36, -35, -34, -32, -30, -28, -27,
-26, -24, -22, -20, -18, -18, -17, -14, -13, -12, -10, -9, -7, -6, -4, -4, -2,
-1, };