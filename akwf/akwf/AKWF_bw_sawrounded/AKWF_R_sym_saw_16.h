#define DATA_LENGTH 512
#define DATA AKWF_R_sym_saw_16

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 28, 46, 66, 83, 92, 98, 101, 105,
106, 109, 110, 113, 114, 115, 116, 117, 118, 118, 118, 118, 119, 119, 119, 120,
119, 119, 119, 119, 118, 118, 118, 117, 117, 116, 116, 115, 115, 114, 114, 113,
113, 112, 112, 112, 112, 111, 110, 109, 109, 109, 109, 107, 106, 107, 106, 105,
104, 104, 104, 103, 103, 101, 102, 101, 100, 100, 100, 99, 99, 97, 97, 97, 97,
97, 96, 95, 94, 95, 94, 93, 92, 92, 91, 91, 90, 90, 88, 88, 87, 88, 86, 86, 85,
85, 85, 84, 83, 83, 83, 82, 82, 81, 80, 80, 79, 80, 78, 77, 77, 77, 76, 76, 75,
75, 74, 73, 73, 73, 72, 71, 71, 71, 70, 69, 68, 68, 68, 67, 67, 66, 65, 65, 65,
64, 63, 63, 63, 62, 62, 62, 61, 60, 59, 59, 59, 58, 57, 56, 56, 55, 55, 54, 54,
54, 53, 52, 52, 51, 51, 49, 50, 49, 49, 48, 47, 48, 47, 46, 45, 45, 45, 44, 44,
43, 43, 42, 41, 41, 40, 41, 40, 39, 39, 38, 37, 36, 35, 35, 36, 35, 34, 33, 33,
32, 32, 31, 31, 30, 30, 29, 29, 28, 27, 26, 27, 26, 25, 25, 24, 24, 24, 23, 22,
21, 21, 21, 20, 20, 19, 20, 19, 17, 17, 17, 16, 15, 15, 15, 13, 14, 13, 12, 12,
11, 11, 10, 10, 9, 8, 9, 7, 7, 7, 7, 5, 5, 4, 3, 4, 3, 2, 2, 1, 1, 1, 0, -1, -1,
-1, -2, -3, -4, -4, -5, -5, -6, -6, -6, -8, -8, -8, -8, -10, -10, -10, -11, -12,
-11, -12, -13, -13, -14, -14, -15, -15, -17, -17, -17, -18, -18, -18, -19, -19,
-20, -21, -22, -22, -22, -23, -24, -24, -25, -24, -26, -25, -27, -27, -28, -28,
-29, -28, -30, -30, -31, -31, -32, -32, -33, -34, -34, -35, -35, -35, -36, -37,
-37, -38, -38, -39, -39, -40, -40, -41, -41, -42, -42, -44, -44, -45, -45, -44,
-46, -46, -47, -47, -47, -48, -48, -49, -50, -50, -51, -51, -51, -52, -53, -54,
-54, -54, -56, -56, -56, -56, -57, -58, -59, -59, -59, -60, -60, -60, -61, -62,
-63, -63, -63, -63, -64, -66, -66, -67, -67, -67, -67, -68, -69, -69, -69, -71,
-71, -72, -72, -73, -73, -73, -74, -75, -75, -76, -76, -77, -76, -78, -79, -79,
-79, -80, -80, -82, -81, -82, -83, -83, -84, -84, -85, -85, -86, -86, -86, -87,
-88, -88, -89, -89, -90, -91, -91, -92, -92, -93, -93, -94, -95, -95, -95, -97,
-97, -96, -97, -98, -99, -98, -100, -101, -101, -101, -102, -103, -103, -103,
-104, -104, -104, -105, -106, -107, -107, -108, -108, -109, -110, -109, -110,
-111, -111, -111, -112, -113, -113, -113, -114, -114, -115, -116, -117, -116,
-117, -117, -118, -117, -118, -118, -118, -119, -118, -119, -119, -119, -118,
-119, -119, -118, -118, -116, -116, -115, -114, -113, -110, -109, -106, -104,
-101, -97, -92, -82, -64, -45, -25, -7, };