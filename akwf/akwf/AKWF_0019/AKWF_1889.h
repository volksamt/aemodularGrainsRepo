#define DATA_LENGTH 512
#define DATA AKWF_1889

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 13, 16, 19, 23, 26, 28,
32, 35, 38, 41, 44, 48, 50, 54, 57, 61, 64, 66, 69, 72, 76, 78, 81, 84, 86, 89,
91, 94, 96, 98, 100, 101, 103, 106, 107, 109, 110, 111, 112, 114, 115, 116, 117,
117, 118, 118, 119, 119, 119, 119, 119, 118, 118, 117, 117, 117, 115, 114, 113,
113, 112, 110, 108, 107, 105, 104, 102, 101, 99, 97, 95, 93, 90, 88, 86, 84, 82,
80, 77, 75, 72, 69, 67, 65, 63, 60, 58, 55, 52, 50, 48, 45, 43, 40, 37, 35, 34,
31, 28, 27, 25, 23, 21, 19, 16, 14, 13, 11, 11, 9, 6, 4, 4, 2, 0, 0, -2, -2, -3,
-5, -6, -6, -7, -7, -8, -9, -9, -9, -10, -11, -11, -11, -11, -11, -11, -10, -10,
-10, -10, -11, -9, -9, -8, -8, -8, -7, -7, -6, -5, -5, -4, -3, -3, -2, -2, -1,
0, 0, 1, 2, 3, 3, 4, 5, 5, 6, 7, 8, 9, 9, 11, 10, 12, 11, 13, 13, 13, 14, 15,
15, 15, 15, 16, 17, 17, 18, 17, 17, 17, 18, 18, 18, 19, 18, 18, 18, 17, 17, 18,
17, 17, 17, 17, 17, 16, 15, 15, 14, 15, 15, 14, 13, 12, 12, 12, 11, 10, 9, 9, 8,
7, 7, 6, 5, 6, 4, 4, 3, 1, 1, 1, 0, 0, -2, -3, -3, -3, -4, -5, -5, -6, -7, -7,
-8, -9, -8, -9, -10, -10, -11, -12, -12, -12, -13, -14, -14, -13, -14, -14, -14,
-15, -15, -16, -15, -16, -16, -16, -17, -17, -16, -17, -17, -17, -17, -17, -17,
-17, -17, -17, -17, -17, -16, -17, -16, -16, -16, -16, -15, -16, -15, -15, -15,
-14, -15, -14, -14, -14, -14, -14, -13, -13, -14, -13, -12, -12, -13, -12, -11,
-11, -12, -12, -12, -12, -11, -12, -11, -11, -11, -11, -11, -11, -11, -10, -11,
-11, -11, -11, -11, -11, -11, -11, -11, -11, -13, -12, -13, -12, -12, -13, -13,
-13, -13, -14, -14, -14, -16, -16, -15, -16, -16, -17, -17, -18, -18, -18, -19,
-19, -20, -21, -21, -21, -23, -23, -24, -24, -25, -25, -26, -25, -27, -28, -28,
-29, -30, -30, -31, -31, -32, -32, -34, -34, -34, -35, -35, -37, -36, -37, -39,
-39, -39, -40, -40, -41, -41, -43, -42, -43, -44, -44, -45, -46, -46, -46, -47,
-49, -49, -50, -51, -50, -52, -51, -52, -53, -54, -54, -54, -55, -55, -56, -56,
-57, -57, -58, -58, -58, -60, -60, -60, -61, -61, -61, -62, -62, -63, -62, -63,
-63, -63, -65, -65, -64, -65, -65, -65, -66, -66, -67, -66, -67, -66, -68, -67,
-68, -67, -68, -68, -68, -67, -67, -67, -67, -67, -68, -66, -66, -66, -65, -65,
-65, -65, -64, -63, -63, -62, -62, -61, -60, -60, -58, -57, -56, -55, -54, -52,
-51, -49, -49, -48, -45, -44, -42, -40, -39, -36, -34, -33, -30, -28, -25, -23,
-20, -18, -15, -13, -10, -7, -4, -2, };