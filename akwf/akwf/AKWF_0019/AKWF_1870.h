#define DATA_LENGTH 512
#define DATA AKWF_1870

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 11, 14, 17, 20, 24, 27, 30,
33, 36, 39, 42, 46, 49, 53, 55, 59, 61, 65, 68, 71, 74, 76, 79, 82, 84, 87, 90,
91, 94, 95, 98, 101, 103, 104, 106, 107, 108, 110, 111, 113, 114, 114, 116, 117,
118, 117, 119, 118, 118, 119, 119, 119, 119, 119, 118, 117, 118, 116, 116, 116,
114, 114, 113, 111, 111, 110, 108, 107, 106, 105, 103, 101, 100, 98, 97, 95, 93,
92, 89, 88, 86, 85, 83, 80, 78, 78, 75, 73, 71, 70, 67, 66, 65, 62, 60, 58, 58,
55, 55, 53, 51, 50, 49, 47, 45, 44, 42, 41, 41, 40, 38, 37, 37, 36, 35, 34, 33,
33, 32, 32, 31, 31, 31, 30, 30, 30, 30, 30, 30, 30, 30, 30, 31, 31, 31, 32, 32,
32, 33, 33, 34, 35, 35, 36, 36, 38, 38, 39, 41, 41, 42, 43, 44, 45, 46, 47, 48,
49, 50, 52, 52, 53, 54, 55, 56, 58, 58, 60, 60, 61, 62, 64, 64, 66, 66, 67, 68,
70, 69, 71, 71, 72, 73, 74, 75, 75, 75, 76, 77, 77, 77, 78, 78, 78, 79, 79, 78,
79, 79, 79, 79, 80, 79, 79, 79, 80, 78, 79, 77, 77, 77, 76, 75, 75, 74, 73, 73,
72, 71, 70, 69, 68, 67, 65, 64, 63, 61, 61, 58, 58, 55, 53, 51, 49, 48, 46, 43,
42, 38, 37, 34, 32, 30, 27, 23, 22, 18, 17, 13, 11, 8, 4, 2, -1, -5, -8, -11,
-14, -17, -20, -23, -28, -30, -34, -37, -40, -43, -47, -49, -53, -55, -58, -62,
-65, -68, -71, -74, -76, -79, -82, -84, -87, -89, -92, -94, -96, -98, -100,
-102, -104, -106, -108, -108, -110, -112, -112, -114, -115, -116, -116, -117,
-117, -118, -119, -118, -119, -120, -119, -118, -119, -118, -118, -118, -117,
-116, -116, -115, -114, -113, -112, -110, -110, -109, -107, -105, -105, -102,
-101, -100, -98, -96, -95, -93, -91, -90, -88, -86, -84, -83, -80, -79, -76,
-75, -73, -71, -69, -67, -66, -65, -63, -61, -59, -57, -56, -54, -53, -51, -49,
-48, -47, -45, -44, -44, -42, -41, -39, -38, -37, -36, -36, -34, -34, -33, -32,
-33, -32, -32, -31, -30, -30, -29, -29, -30, -29, -30, -30, -30, -30, -31, -31,
-32, -31, -32, -33, -32, -34, -33, -35, -35, -36, -37, -37, -39, -39, -40, -42,
-42, -44, -44, -46, -45, -47, -48, -49, -51, -51, -52, -54, -55, -55, -57, -57,
-58, -59, -61, -61, -63, -64, -65, -66, -66, -68, -68, -69, -69, -71, -71, -73,
-73, -74, -74, -76, -75, -76, -76, -77, -77, -78, -79, -78, -79, -79, -79, -79,
-79, -79, -79, -80, -80, -79, -79, -78, -78, -78, -77, -77, -77, -77, -77, -75,
-75, -73, -73, -71, -71, -70, -69, -68, -66, -65, -64, -63, -61, -60, -58, -56,
-56, -53, -51, -49, -47, -45, -44, -42, -39, -36, -33, -32, -29, -26, -24, -21,
-19, -15, -12, -10, -6, -4, -1, };