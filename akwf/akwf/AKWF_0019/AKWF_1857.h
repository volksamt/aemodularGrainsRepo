#define DATA_LENGTH 512
#define DATA AKWF_1857

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 17, 20, 25, 28, 30, 33, 34,
37, 39, 41, 42, 43, 43, 44, 43, 44, 44, 43, 43, 43, 42, 41, 40, 39, 37, 36, 35,
33, 31, 30, 28, 27, 26, 24, 23, 22, 20, 20, 19, 18, 16, 16, 15, 14, 14, 13, 12,
12, 11, 11, 10, 9, 9, 8, 9, 7, 7, 7, 7, 6, 6, 5, 5, 5, 5, 4, 4, 4, 4, 4, 3, 3,
3, 3, 3, 3, 2, 2, 3, 2, 2, 2, 2, 3, 1, 2, 1, 2, 2, 2, 1, 2, 1, 1, 1, 1, 0, 2, 1,
1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 0, -1, 0, 1, 1,
0, 1, 1, -1, 0, 0, 1, 1, 1, 0, 0, 0, -1, 1, 1, 0, 0, 1, 1, 1, 0, 0, 1, 0, 0, 0,
0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 0, 0, 0, 1, 0, 1, 0, 0, 1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, -1, 0, -1,
-1, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, -1, -1, 0, -1, 0, 1, 0, 0,
0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0,
0, 0, 0, 0, -1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0,
0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 1, 1, 0, 0, 0, -1, 1, 0, 0,
-1, 0, 0, 0, 1, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, -1, 0, 0,
0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 1, 0,
0, -1, 0, 0, -1, 0, 0, 1, 1, 0, 1, -1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 1, 0, -1, 0, 1, -1, 1, 0, 0, 0, 0,
-1, 1, 0, 0, 0, 0, -1, 0, -1, -2, -2, -3, -4, -3, -5, -6, -7, -8, -8, -9, -11,
-12, -13, -14, -15, -15, -18, -18, -20, -22, -23, -24, -25, -27, -28, -30, -31,
-33, -34, -36, -38, -38, -40, -42, -43, -45, -48, -49, -50, -52, -53, -55, -57,
-59, -61, -62, -63, -65, -67, -69, -70, -72, -74, -76, -77, -80, -81, -83, -85,
-86, -88, -91, -91, -93, -95, -97, -99, -100, -102, -105, -105, -107, -109,
-111, -113, -116, -117, -119, -119, -114, -105, -92, -81, -70, -58, -49, -39,
-31, -24, -16, -9, -3, };