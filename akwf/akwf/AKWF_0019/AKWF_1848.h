#define DATA_LENGTH 512
#define DATA AKWF_1848

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 13, 18, 22, 27, 31, 35, 40, 44,
48, 51, 54, 58, 61, 63, 65, 68, 70, 73, 74, 76, 77, 80, 82, 83, 84, 85, 85, 87,
87, 88, 88, 89, 88, 88, 88, 88, 88, 88, 88, 87, 87, 87, 86, 85, 84, 82, 82, 81,
80, 79, 77, 77, 75, 73, 72, 71, 70, 67, 65, 64, 63, 61, 59, 57, 55, 54, 51, 49,
48, 46, 44, 42, 40, 38, 36, 34, 32, 31, 29, 28, 25, 23, 18, 11, 3, -4, -11, -17,
-26, -32, -39, -46, -55, -63, -72, -78, -85, -91, -97, -103, -107, -111, -115,
-117, -118, -119, -119, -119, -117, -116, -115, -112, -110, -107, -104, -101,
-96, -92, -89, -84, -80, -76, -71, -66, -62, -56, -51, -45, -40, -35, -30, -25,
-19, -14, -9, -3, 0, 5, 10, 14, 17, 21, 25, 29, 32, 34, 38, 40, 42, 45, 46, 48,
50, 52, 53, 55, 56, 57, 58, 59, 60, 61, 61, 61, 61, 62, 62, 62, 63, 65, 65, 67,
68, 69, 71, 73, 74, 74, 77, 77, 78, 80, 80, 82, 83, 83, 84, 85, 86, 86, 87, 88,
89, 88, 89, 89, 89, 90, 89, 89, 89, 89, 88, 88, 88, 87, 87, 85, 85, 84, 84, 83,
81, 80, 78, 77, 76, 75, 73, 72, 71, 69, 67, 65, 64, 62, 60, 57, 55, 54, 53, 55,
57, 62, 64, 68, 72, 76, 79, 83, 86, 88, 90, 91, 90, 91, 89, 87, 84, 83, 81, 79,
75, 74, 73, 74, 76, 77, 79, 80, 82, 84, 85, 86, 88, 89, 93, 95, 97, 98, 97, 95,
93, 90, 85, 81, 75, 69, 62, 55, 47, 38, 29, 21, 13, 4, -4, -12, -20, -27, -35,
-41, -47, -53, -59, -64, -68, -72, -77, -80, -85, -88, -90, -93, -95, -98, -99,
-100, -102, -104, -105, -107, -107, -108, -109, -110, -110, -109, -110, -110,
-110, -109, -109, -110, -109, -108, -108, -107, -106, -105, -104, -104, -102,
-100, -99, -99, -97, -96, -94, -93, -91, -90, -88, -86, -84, -82, -81, -79, -77,
-75, -73, -72, -71, -69, -69, -68, -67, -67, -66, -66, -66, -66, -66, -67, -66,
-66, -66, -66, -66, -66, -66, -67, -66, -67, -67, -67, -66, -66, -66, -66, -66,
-66, -65, -65, -64, -65, -64, -64, -63, -62, -61, -61, -61, -60, -59, -58, -56,
-56, -55, -54, -53, -53, -51, -50, -49, -47, -46, -45, -44, -43, -40, -40, -38,
-37, -35, -34, -33, -30, -30, -28, -26, -25, -23, -21, -19, -18, -17, -14, -13,
-12, -11, -9, -7, -6, -4, -3, -2, 0, 1, 3, 4, 5, 7, 7, 7, 9, 10, 12, 13, 13, 14,
15, 16, 16, 18, 18, 18, 19, 19, 20, 20, 21, 21, 21, 19, 13, 6, -2, -8, -12, -18,
-23, -26, -30, -34, -36, -39, -42, -45, -47, -49, -52, -54, -57, -59, -60, -61,
-63, -64, -65, -64, -64, -64, -62, -61, -60, -57, -55, -51, -49, -45, -41, -37,
-33, -28, -24, -17, -12, -7, -2, };