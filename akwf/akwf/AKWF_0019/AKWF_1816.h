#define DATA_LENGTH 512
#define DATA AKWF_1816

const PROGMEM int8_t DATA[DATA_LENGTH] = {68, 50, 42, 46, 39, 43, 37, 42, 37,
41, 38, 41, 38, 40, 38, 41, 39, 40, 40, 41, 41, 41, 41, 42, 43, 42, 43, 43, 44,
44, 46, 44, 45, 46, 47, 47, 48, 49, 49, 49, 51, 52, 52, 52, 55, 55, 55, 57, 58,
59, 60, 61, 63, 63, 65, 67, 69, 70, 72, 74, 75, 77, 80, 81, 84, 87, 89, 91, 94,
97, 100, 103, 105, 108, 111, 114, 116, 118, 119, 119, 119, 115, 113, 107, 98,
89, 78, 65, 51, 37, 22, 8, -6, -18, -29, -38, -46, -53, -60, -63, -68, -71, -73,
-74, -75, -76, -76, -76, -76, -76, -76, -76, -75, -75, -74, -73, -72, -71, -71,
-69, -69, -68, -67, -67, -65, -65, -63, -63, -61, -61, -60, -60, -58, -58, -56,
-56, -55, -54, -53, -52, -52, -51, -50, -49, -48, -46, -46, -46, -44, -43, -44,
-42, -41, -40, -39, -38, -37, -37, -36, -35, -34, -33, -33, -32, -31, -32, -32,
-33, -33, -35, -36, -36, -37, -38, -38, -40, -41, -42, -42, -44, -45, -46, -47,
-48, -49, -49, -52, -52, -52, -54, -56, -56, -57, -58, -59, -61, -62, -63, -64,
-65, -65, -66, -68, -69, -69, -70, -71, -71, -73, -72, -73, -74, -73, -75, -74,
-74, -74, -74, -74, -74, -74, -74, -74, -74, -73, -71, -71, -71, -71, -70, -69,
-67, -67, -66, -65, -64, -64, -62, -61, -60, -59, -57, -57, -54, -53, -51, -50,
-48, -47, -43, -41, -37, -35, -31, -28, -25, -21, -19, -15, -12, -9, -5, -1, 2,
5, 9, 13, 16, 18, 22, 25, 28, 31, 33, 36, 38, 40, 42, 45, 45, 47, 49, 50, 51,
53, 54, 55, 55, 56, 56, 55, 57, 56, 56, 55, 55, 56, 54, 54, 53, 52, 52, 50, 49,
49, 47, 45, 44, 43, 42, 40, 38, 37, 35, 33, 31, 30, 29, 26, 25, 24, 23, 21, 19,
19, 18, 17, 16, 13, 14, 12, 12, 11, 12, 12, 12, 11, 11, 12, 12, 13, 13, 14, 16,
17, 18, 21, 21, 23, 25, 27, 30, 32, 34, 36, 40, 43, 46, 49, 52, 55, 57, 60, 64,
66, 70, 73, 75, 78, 81, 84, 86, 88, 91, 93, 94, 97, 99, 100, 101, 103, 104, 105,
106, 107, 108, 109, 108, 109, 110, 110, 110, 111, 110, 110, 110, 111, 110, 110,
109, 108, 108, 108, 106, 106, 105, 103, 101, 100, 97, 94, 91, 89, 85, 81, 76,
71, 66, 61, 54, 47, 40, 33, 25, 16, 8, 0, -8, -17, -24, -32, -38, -44, -50, -55,
-60, -64, -67, -70, -71, -74, -74, -75, -76, -77, -76, -76, -76, -75, -75, -74,
-73, -73, -72, -72, -70, -70, -69, -67, -67, -66, -66, -66, -64, -64, -64, -63,
-63, -62, -63, -61, -62, -62, -61, -61, -61, -61, -61, -62, -62, -63, -63, -63,
-64, -64, -64, -65, -65, -66, -66, -67, -68, -68, -69, -70, -71, -71, -71, -74,
-73, -74, -73, -76, -73, -76, -74, -76, -72, -77, -70, -78, -61, };