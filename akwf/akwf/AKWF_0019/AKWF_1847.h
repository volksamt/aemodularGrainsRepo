#define DATA_LENGTH 512
#define DATA AKWF_1847

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 2, 4, 4, 4, 5, 6, 6, 7, 8, 8,
9, 10, 10, 10, 12, 11, 13, 13, 13, 13, 15, 16, 16, 16, 17, 18, 20, 25, 31, 38,
46, 55, 62, 71, 77, 83, 90, 94, 99, 104, 106, 109, 112, 113, 115, 116, 117, 119,
118, 118, 120, 120, 119, 119, 117, 117, 118, 116, 116, 115, 114, 114, 113, 112,
111, 109, 110, 108, 108, 106, 105, 105, 103, 102, 102, 101, 100, 98, 98, 96, 94,
94, 92, 92, 92, 90, 90, 89, 87, 86, 85, 84, 84, 82, 82, 80, 79, 79, 77, 77, 75,
74, 74, 73, 71, 71, 70, 69, 68, 67, 66, 65, 65, 63, 62, 61, 60, 59, 58, 58, 57,
57, 56, 54, 54, 52, 52, 50, 50, 50, 49, 48, 47, 46, 44, 44, 43, 42, 42, 41, 40,
39, 38, 38, 37, 36, 36, 34, 33, 33, 32, 31, 31, 30, 27, 22, 16, 8, 1, -8, -15,
-24, -31, -37, -42, -49, -53, -57, -60, -63, -66, -69, -71, -72, -73, -74, -75,
-75, -75, -75, -75, -75, -75, -75, -74, -75, -74, -74, -73, -73, -72, -72, -71,
-70, -69, -70, -69, -68, -68, -67, -65, -65, -64, -63, -63, -63, -62, -61, -60,
-60, -58, -58, -57, -56, -56, -55, -55, -54, -54, -53, -52, -52, -51, -50, -49,
-49, -48, -47, -47, -46, -46, -45, -44, -43, -42, -42, -42, -41, -40, -40, -39,
-38, -38, -37, -37, -36, -36, -35, -34, -34, -33, -33, -32, -31, -30, -30, -30,
-29, -28, -28, -28, -27, -26, -26, -26, -25, -25, -24, -23, -23, -23, -22, -21,
-20, -20, -19, -19, -19, -18, -18, -18, -18, -19, -23, -25, -26, -27, -28, -28,
-29, -29, -29, -29, -28, -28, -28, -28, -28, -28, -27, -27, -26, -25, -25, -25,
-24, -23, -23, -22, -21, -22, -20, -19, -19, -19, -18, -17, -16, -16, -16, -15,
-15, -14, -14, -13, -13, -12, -12, -11, -10, -10, -10, -9, -8, -8, -8, -7, -7,
-6, -6, -5, -4, -4, -4, -4, -4, -3, -3, -2, -1, -1, -1, 0, 0, 0, 1, 1, 2, 2, 2,
3, 4, 4, 4, 4, 5, 4, 5, 5, 5, 6, 7, 7, 8, 7, 8, 8, 8, 8, 9, 10, 10, 11, 10, 11,
11, 11, 11, 11, 11, 12, 12, 11, 12, 12, 13, 14, 13, 13, 14, 14, 14, 14, 14, 15,
14, 15, 15, 15, 15, 12, 9, 3, -4, -12, -18, -25, -32, -39, -44, -49, -53, -58,
-61, -64, -66, -68, -69, -71, -72, -72, -72, -71, -72, -71, -71, -71, -70, -68,
-68, -67, -66, -65, -64, -63, -62, -61, -61, -58, -57, -56, -56, -54, -53, -53,
-50, -49, -49, -48, -46, -45, -45, -42, -42, -41, -40, -38, -37, -36, -36, -34,
-34, -32, -31, -30, -29, -28, -27, -26, -25, -25, -23, -23, -21, -21, -20, -18,
-17, -16, -16, -15, -14, -13, -12, -12, -11, -10, -9, -8, -7, -7, -6, -4, -4,
-3, -3, -1, -1, 0, };