#define DATA_LENGTH 512
#define DATA AKWF_1858

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 15, 23, 32, 39, 46, 53, 59, 65, 71,
76, 80, 85, 88, 92, 96, 99, 101, 104, 106, 109, 111, 112, 113, 114, 116, 117,
117, 117, 119, 120, 119, 119, 119, 119, 119, 118, 118, 117, 116, 116, 115, 114,
113, 112, 110, 110, 108, 107, 106, 105, 103, 102, 99, 99, 96, 95, 94, 91, 90,
88, 86, 84, 83, 81, 79, 76, 75, 73, 70, 69, 67, 65, 64, 61, 59, 57, 55, 53, 51,
48, 47, 44, 42, 40, 38, 36, 34, 32, 30, 29, 28, 26, 26, 24, 23, 21, 20, 19, 18,
18, 16, 16, 14, 14, 13, 14, 12, 11, 11, 11, 9, 9, 10, 8, 8, 8, 7, 7, 7, 6, 6, 5,
5, 5, 5, 4, 5, 4, 4, 5, 4, 3, 3, 3, 3, 3, 3, 2, 2, 2, 1, 2, 3, 1, 3, 1, 2, 1, 1,
1, 1, 1, 1, 1, 2, 0, 0, 0, 0, 1, 1, 1, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 1, 0, 1,
0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, -1, 0, 0, 1, 1, 0, 0, 0,
1, 1, 0, 0, 0, 0, 1, 0, -1, 0, 0, -1, 0, 1, 1, 1, -1, 0, -1, 0, 1, 0, 0, 0, 0,
0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, -1, 0, 0,
0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0,
-1, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 1, 0, 0, 0, -1, 0, -1, 0, 0, -1, 0, 0, 1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, -1, 1, 0,
0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0,
-1, 0, 0, 0, 1, -1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0,
0, 0, 0, -1, 1, 0, 0, -1, -1, 0, 1, 0, 1, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0,
0, 1, -1, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, -1, 0, 1,
0, 1, 1, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, -1, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, -1, -3, -9,
-15, -16, -13, -3, };