#define DATA_LENGTH 512
#define DATA AKWF_1898

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 2, 2, 4, 4, 5, 5, 7, 7, 7, 8,
8, 8, 9, 9, 10, 10, 11, 11, 11, 12, 12, 12, 12, 13, 13, 15, 14, 15, 16, 15, 15,
16, 16, 18, 17, 18, 18, 19, 19, 19, 20, 20, 20, 21, 22, 22, 23, 23, 24, 23, 24,
25, 26, 26, 26, 27, 28, 27, 28, 29, 29, 29, 29, 31, 30, 31, 31, 32, 32, 33, 33,
33, 34, 33, 34, 35, 35, 35, 36, 36, 37, 38, 38, 39, 38, 39, 40, 39, 40, 41, 42,
41, 42, 42, 43, 42, 43, 45, 45, 45, 45, 46, 46, 46, 46, 48, 47, 48, 48, 49, 50,
50, 51, 51, 51, 52, 53, 52, 52, 54, 54, 54, 55, 55, 55, 56, 56, 56, 57, 57, 57,
58, 59, 59, 59, 60, 60, 60, 62, 61, 62, 63, 62, 63, 64, 64, 64, 65, 65, 65, 66,
67, 67, 67, 68, 68, 68, 69, 70, 69, 70, 70, 71, 71, 71, 72, 74, 74, 73, 74, 74,
75, 75, 76, 75, 76, 77, 78, 78, 78, 78, 79, 80, 80, 80, 80, 81, 81, 82, 82, 83,
83, 84, 84, 85, 85, 85, 86, 86, 87, 87, 87, 87, 89, 89, 88, 88, 87, 88, 88, 88,
87, 88, 87, 86, 88, 88, 88, 89, 91, 92, 94, 96, 99, 102, 103, 106, 109, 112,
114, 116, 117, 117, 118, 117, 117, 116, 113, 112, 107, 103, 98, 93, 87, 80, 73,
67, 58, 51, 44, 35, 25, 17, 9, 0, -9, -19, -28, -38, -47, -56, -66, -74, -82,
-91, -97, -104, -110, -114, -118, -119, -119, -120, -119, -118, -119, -119,
-118, -116, -112, -109, -107, -103, -101, -97, -96, -93, -92, -91, -90, -90,
-90, -90, -88, -89, -89, -90, -90, -90, -90, -91, -90, -90, -90, -89, -89, -89,
-89, -88, -88, -88, -87, -86, -86, -86, -86, -85, -84, -84, -83, -82, -82, -81,
-82, -80, -80, -79, -79, -79, -79, -77, -77, -77, -77, -76, -76, -75, -76, -75,
-74, -74, -73, -72, -73, -72, -71, -70, -72, -71, -70, -69, -68, -68, -68, -67,
-67, -67, -66, -65, -66, -65, -64, -64, -64, -63, -62, -62, -62, -62, -61, -61,
-60, -60, -59, -59, -59, -58, -58, -57, -57, -56, -56, -55, -55, -54, -55, -54,
-54, -53, -53, -52, -52, -51, -51, -51, -50, -50, -49, -49, -48, -48, -47, -47,
-47, -46, -46, -46, -45, -45, -44, -44, -44, -43, -43, -42, -41, -41, -40, -40,
-40, -39, -39, -38, -38, -38, -37, -37, -37, -36, -35, -35, -34, -34, -33, -33,
-33, -33, -32, -32, -31, -31, -31, -30, -29, -30, -29, -28, -28, -28, -27, -26,
-27, -26, -25, -25, -25, -24, -24, -23, -23, -22, -22, -21, -20, -21, -21, -21,
-20, -19, -19, -19, -18, -16, -16, -16, -16, -15, -15, -15, -14, -14, -14, -12,
-13, -12, -12, -12, -12, -11, -9, -9, -9, -8, -9, -9, -8, -7, -7, -6, -7, -6,
-5, -5, -4, -3, -2, -1, -1, 1, };