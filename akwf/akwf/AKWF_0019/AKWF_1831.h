#define DATA_LENGTH 512
#define DATA AKWF_1831

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 12, 16, 19, 22, 26, 28, 33,
35, 38, 42, 44, 48, 51, 54, 57, 60, 63, 66, 68, 70, 74, 77, 78, 81, 83, 85, 87,
90, 91, 94, 96, 98, 99, 101, 102, 104, 104, 106, 108, 109, 110, 111, 112, 113,
114, 115, 116, 116, 116, 117, 117, 117, 118, 119, 119, 119, 119, 120, 119, 119,
118, 119, 118, 118, 118, 118, 118, 116, 117, 116, 114, 114, 114, 114, 112, 111,
111, 110, 110, 108, 108, 106, 106, 105, 103, 103, 102, 101, 99, 98, 97, 97, 95,
94, 93, 92, 91, 89, 88, 87, 85, 84, 83, 82, 81, 79, 78, 77, 75, 75, 73, 72, 71,
70, 68, 67, 66, 65, 64, 62, 62, 60, 59, 59, 57, 56, 54, 54, 52, 50, 49, 48, 47,
46, 45, 43, 43, 40, 40, 38, 37, 34, 34, 32, 31, 29, 28, 27, 25, 24, 22, 20, 19,
18, 16, 14, 12, 11, 9, 7, 6, 5, 1, -1, -2, -3, -6, -8, -9, -11, -13, -16, -16,
-19, -21, -23, -25, -27, -29, -30, -32, -34, -36, -38, -40, -41, -43, -44, -47,
-47, -49, -51, -53, -54, -54, -56, -57, -58, -60, -61, -62, -63, -64, -65, -65,
-66, -67, -67, -68, -68, -68, -70, -69, -69, -70, -69, -70, -70, -69, -70, -69,
-68, -68, -66, -67, -65, -65, -65, -63, -62, -60, -60, -59, -57, -56, -54, -53,
-52, -50, -48, -46, -45, -43, -41, -39, -38, -36, -33, -31, -28, -27, -24, -23,
-21, -19, -16, -14, -13, -9, -8, -5, -4, -1, 2, 3, 5, 6, 8, 11, 13, 14, 17, 18,
20, 22, 23, 24, 26, 27, 29, 30, 31, 33, 34, 35, 36, 36, 37, 39, 39, 41, 41, 41,
43, 44, 44, 44, 44, 44, 43, 45, 44, 45, 44, 44, 44, 44, 43, 43, 43, 42, 41, 41,
40, 39, 39, 38, 37, 36, 35, 35, 33, 32, 32, 30, 29, 27, 27, 26, 25, 23, 22, 21,
20, 18, 17, 16, 14, 13, 11, 10, 9, 7, 6, 5, 4, 1, 0, -1, -3, -4, -5, -6, -8,
-10, -10, -12, -14, -15, -16, -18, -19, -20, -22, -23, -24, -25, -26, -28, -29,
-30, -31, -31, -33, -33, -34, -36, -36, -38, -39, -40, -40, -42, -42, -43, -44,
-44, -45, -46, -47, -48, -48, -49, -50, -51, -52, -53, -53, -55, -55, -56, -56,
-57, -58, -59, -60, -61, -62, -62, -63, -64, -66, -66, -67, -68, -70, -70, -71,
-72, -73, -74, -75, -76, -77, -78, -79, -80, -81, -82, -82, -84, -86, -87, -86,
-88, -89, -90, -91, -92, -92, -94, -95, -96, -96, -97, -97, -98, -98, -98, -99,
-99, -100, -100, -100, -101, -100, -101, -100, -100, -100, -100, -99, -99, -99,
-98, -97, -98, -97, -95, -96, -93, -93, -92, -90, -89, -88, -86, -85, -83, -81,
-79, -77, -76, -73, -71, -69, -67, -64, -62, -59, -57, -54, -52, -48, -45, -43,
-39, -37, -34, -31, -27, -25, -20, -18, -15, -11, -8, -4, -1, };