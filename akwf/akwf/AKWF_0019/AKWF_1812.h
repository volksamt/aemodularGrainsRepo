#define DATA_LENGTH 512
#define DATA AKWF_1812

const PROGMEM int8_t DATA[DATA_LENGTH] = {51, 59, 57, 58, 56, 57, 57, 57, 57,
58, 57, 57, 57, 58, 57, 59, 54, 111, 122, 116, 121, 118, 120, 118, 120, 118,
119, 118, 120, 116, 121, 115, 126, 77, 51, 60, 53, 58, 54, 58, 56, 57, 56, 57,
57, 55, 57, 55, 58, 54, 57, 55, 58, 55, 58, 55, 57, 56, -29, -42, -35, -41, -35,
-39, -36, -39, -36, -39, -37, -40, -36, -39, -38, -38, -37, -38, -39, -38, -38,
-38, -38, -38, -38, -38, -39, -37, -39, -35, -17, -17, -18, -17, -18, -18, -18,
-18, -19, -18, -18, -17, -18, -17, -18, -18, -17, -18, -18, -18, -17, -18, -18,
-18, -18, -19, -18, -19, -17, -18, -18, -18, -18, -17, -18, -18, -18, -18, -17,
-17, -17, -18, -17, -17, -18, -18, -17, -18, -17, -18, -18, -18, -18, -18, -17,
-17, -17, -18, -17, -17, -18, -18, -18, -18, -18, -18, -17, -18, -17, -17, -17,
-18, -17, -17, -18, -18, -17, -18, -18, -17, -18, -17, -17, -17, -18, -18, -18,
-18, -17, -18, -18, -18, -17, -18, -18, -17, -17, -17, -18, -17, -17, -18, -17,
-17, -17, -16, -18, -17, -17, -17, -19, -30, -29, -29, -29, -31, -30, -30, -29,
-29, -30, -29, -30, -30, -30, -29, -29, -30, -30, -29, -29, -30, -29, -31, -26,
-15, -18, -16, -18, -16, -18, -18, -17, -18, -18, -17, -17, -18, -17, -17, -16,
-17, -16, -17, -17, -17, -16, -17, -16, -18, -17, -17, -35, -37, -36, -36, -37,
-36, -37, -37, -36, -36, -37, -37, -37, -37, -36, -36, -36, -36, -35, -37, -36,
-38, -34, -40, -31, -48, 17, 69, 52, 62, 54, 61, 56, 60, 55, 59, 56, 58, 57, 58,
58, 57, 58, 57, 58, 57, 59, 56, 59, 55, 60, 54, 62, 50, 83, 127, 115, 121, 118,
120, 118, 119, 119, 118, 119, 119, 118, 118, 119, 119, 119, 118, 118, 119, 118,
119, 115, 125, 87, 47, 62, 53, 60, 53, 60, 52, 61, 45, -21, -17, -18, -18, -18,
-17, -19, -16, -30, -41, -37, -39, -37, -39, -37, -38, -38, -36, -30, -30, -30,
-31, -30, -30, -31, -30, -30, -30, -31, -31, -31, -30, -31, -31, -30, -32, -24,
-16, -19, -18, -19, -17, -18, -17, -18, -18, -18, -18, -18, -18, -17, -18, -17,
-18, -17, -18, -18, -18, -18, -17, -18, -18, -19, -17, -18, -17, -18, -17, -18,
-17, -18, -17, -17, -17, -17, -18, -17, -18, -18, -18, -18, -18, -17, -18, -18,
-17, -18, -18, -18, -17, -18, -18, -17, -18, -17, -18, -17, -17, -17, -18, -18,
-18, -17, -19, -31, -30, -30, -29, -30, -30, -30, -30, -30, -31, -29, -30, -30,
-30, -30, -31, -29, -30, -30, -31, -30, -30, -30, -30, -30, -30, -29, -29, -29,
-30, -29, -30, -29, -30, -29, -17, -17, -17, -17, -17, -17, -17, -17, -17, -17,
-18, -17, -17, -17, -18, -17, -17, -16, -18, -17, -18, -16, -18, -15, -24, -39,
-35, -38, -36, -38, -35, -39, -35, -39, -31, };