#define DATA_LENGTH 512
#define DATA AKWF_1836

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 16, 13, 14, 13, 14, 14, 14, 17,
20, 19, 20, 19, 20, 20, 19, 22, 27, 27, 28, 29, 28, 29, 28, 30, 35, 35, 36, 36,
36, 37, 35, 40, 44, 43, 44, 43, 45, 31, 37, 100, 120, 112, 116, 113, 115, 113,
115, 114, 116, 116, 117, 116, 117, 116, 116, 118, 120, 118, 116, 114, 114, 113,
115, 114, 115, 115, 115, 114, 115, 115, 114, 115, 115, 115, 115, 115, 115, 113,
109, 107, 109, 109, 109, 109, 109, 109, 108, 109, 109, 110, 110, 110, 109, 110,
109, 110, 111, 107, 103, 102, 104, 102, 103, 103, 110, 106, 110, 106, 110, 103,
114, 69, -11, -6, -10, -7, -10, -19, -26, -15, -8, -11, -9, -10, -9, -10, -9,
-9, -8, -10, -8, -9, -8, -9, -9, -8, -11, -23, -25, -25, -25, -24, -24, -20,
-18, -19, -19, -19, -18, -19, -18, -14, -13, -13, -13, -14, -23, -31, -31, -28,
-24, -26, -25, -25, -25, -25, -25, -25, -23, -23, -24, -23, -23, -23, -22, -24,
-30, -35, -34, -34, -34, -35, -34, -28, -26, -26, -26, -26, -26, -27, -26, -26,
-25, -25, -25, -29, -34, -36, -35, -34, -33, -35, -34, -34, -35, -34, -33, -30,
-29, -29, -28, -29, -29, -29, -29, -31, -34, -33, -33, -33, -33, -33, -33, -32,
-32, -32, -32, -32, -32, -32, -32, -33, -32, -32, -32, -33, -34, -33, -33, -32,
-33, -33, -32, -33, -32, -33, -32, -28, -26, -27, -28, -27, -28, -26, -27, -24,
-23, -24, -22, -22, -23, -24, -24, -20, -17, -17, -17, -17, -17, -17, -18, -14,
-10, -9, -9, -10, -11, -9, -11, -8, -3, -2, -2, -2, -2, -2, -3, 3, 6, 5, 6, 6,
5, 6, 5, 7, 9, 8, 8, 8, 9, 8, 8, 9, 11, 10, 10, 10, 10, 9, 9, 12, 13, 13, 13,
12, 13, 13, 13, 12, 13, 14, 14, 13, 14, 14, 14, 15, 14, 14, 15, 14, 13, 29, 59,
71, 69, 70, 69, 69, 69, 70, 69, 70, 70, 71, 71, 71, 70, 70, 70, 73, 71, 46, 19,
17, 19, 18, 18, 20, 25, 22, 25, 21, 26, 19, 31, -26, -99, -88, -94, -90, -93,
-92, -92, -80, -75, -77, -76, -76, -75, -76, -75, -75, -74, -75, -74, -74, -74,
-74, -74, -74, -72, -72, -72, -73, -72, -73, -73, -68, -66, -67, -67, -67, -67,
-67, -67, -63, -61, -61, -61, -61, -61, -61, -61, -57, -55, -56, -55, -55, -55,
-54, -56, -53, -53, -54, -52, -52, -52, -53, -53, -51, -51, -51, -51, -51, -51,
-51, -51, -45, -42, -43, -43, -42, -43, -44, -43, -42, -41, -43, -42, -42, -42,
-42, -43, -41, -41, -41, -41, -40, -42, -41, -41, -37, -37, -36, -36, -36, -36,
-37, -35, -35, -35, -35, -35, -35, -35, -36, -35, -34, -34, -35, -34, -34, -33,
-34, -34, -34, -34, -34, -34, -34, -34, -34, -33, -33, -33, -33, -33, -33, -33,
-32, -32, -28, -28, -27, -28, -27, -28, -25, -8, };