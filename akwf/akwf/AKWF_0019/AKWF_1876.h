#define DATA_LENGTH 512
#define DATA AKWF_1876

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 2, 3, 4, 4, 5, 5, 7, 7, 8, 9, 9,
10, 11, 11, 13, 14, 13, 15, 15, 15, 14, 15, 16, 16, 16, 16, 17, 17, 18, 18, 18,
18, 19, 19, 20, 20, 19, 20, 21, 21, 22, 22, 22, 22, 23, 23, 23, 23, 24, 24, 25,
26, 25, 26, 26, 27, 27, 28, 29, 29, 30, 31, 33, 33, 34, 34, 35, 36, 37, 38, 39,
40, 41, 42, 43, 45, 45, 46, 48, 49, 51, 52, 53, 54, 56, 58, 59, 61, 63, 63, 65,
66, 67, 69, 70, 71, 72, 72, 74, 74, 75, 75, 77, 78, 80, 80, 80, 80, 81, 81, 81,
81, 81, 81, 81, 80, 80, 81, 80, 80, 80, 79, 79, 78, 77, 77, 75, 75, 74, 73, 72,
71, 70, 70, 68, 67, 64, 62, 61, 58, 57, 56, 54, 53, 52, 52, 51, 51, 51, 49, 46,
42, 36, 29, 23, 16, 9, 4, -3, -9, -16, -21, -27, -31, -35, -39, -44, -47, -53,
-59, -65, -70, -78, -84, -91, -96, -101, -106, -109, -112, -113, -116, -118,
-118, -118, -119, -118, -118, -117, -117, -117, -117, -117, -116, -115, -112,
-109, -107, -104, -99, -95, -91, -86, -82, -77, -72, -68, -64, -60, -57, -54,
-51, -49, -46, -44, -42, -39, -36, -33, -30, -27, -25, -22, -21, -20, -20, -19,
-19, -19, -19, -20, -22, -24, -26, -27, -28, -28, -30, -30, -31, -31, -34, -33,
-35, -35, -37, -40, -41, -42, -45, -46, -46, -48, -49, -50, -51, -49, -50, -49,
-48, -47, -46, -46, -45, -44, -44, -42, -41, -40, -40, -38, -36, -35, -32, -30,
-27, -24, -22, -19, -17, -15, -12, -11, -9, -8, -6, -4, -4, -1, 0, 2, 2, 4, 6,
7, 7, 9, 10, 10, 11, 11, 12, 12, 12, 12, 11, 10, 10, 9, 8, 8, 7, 6, 6, 7, 5, 5,
4, 3, 3, 1, -1, -1, -3, -3, -3, -5, -5, -6, -5, -6, -5, -5, -6, -6, -5, -5, -5,
-5, -5, -4, -5, -4, -3, -3, -3, -2, -1, 0, 1, 2, 3, 4, 5, 6, 6, 7, 9, 9, 10, 10,
11, 12, 12, 12, 13, 14, 15, 16, 16, 15, 16, 14, 14, 14, 14, 13, 13, 13, 13, 12,
12, 11, 11, 10, 10, 10, 10, 9, 8, 8, 7, 5, 5, 4, 2, 3, 1, 1, 1, 0, -1, 0, -2,
-2, -3, -2, -2, -3, -3, -4, -4, -5, -6, -6, -6, -7, -7, -6, -5, -6, -6, -6, -5,
-6, -5, -5, -4, -4, -4, -4, -4, -3, -3, -3, -3, -3, -3, -2, -1, -1, -1, -1, -1,
0, 0, 0, 0, 1, 0, 0, 0, -2, 0, -1, -2, -2, -3, -2, -2, -3, -3, -4, -4, -3, -4,
-6, -5, -6, -6, -7, -8, -8, -8, -9, -10, -9, -10, -10, -10, -10, -10, -11, -11,
-11, -10, -10, -11, -11, -10, -10, -10, -9, -11, -10, -9, -8, -8, -8, -7, -6,
-6, -5, -4, -4, -4, -2, -1, -1, 0, };