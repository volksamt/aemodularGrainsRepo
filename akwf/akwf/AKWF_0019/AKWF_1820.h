#define DATA_LENGTH 512
#define DATA AKWF_1820

const PROGMEM int8_t DATA[DATA_LENGTH] = {56, 112, 118, 114, 103, 96, 88, 82,
77, 74, 70, 69, 65, 64, 61, 61, 58, 59, 56, 57, 53, 56, 52, 54, 49, 57, 24, -19,
42, 53, 51, 54, 52, 55, 54, 56, 55, 58, 59, 61, 61, 64, 65, 69, 70, 75, 79, 83,
89, 96, 105, 113, 118, 100, 40, -24, -45, -42, -33, -24, -17, -10, -8, -8, -8,
-8, -9, -8, -9, -8, -8, -8, -8, -8, -8, -8, -9, -9, -8, -8, -8, -7, -8, -8, -8,
-8, -8, -8, -7, -7, -8, -7, -8, -8, -9, -8, -8, -9, -9, -8, -9, -8, -8, -8, -7,
-8, -8, -9, -9, -8, -8, -8, -8, -8, -8, -8, -9, -8, -9, -9, -8, -8, -8, -8, -8,
-7, -8, -7, -8, -7, -8, -8, -9, -8, -8, -8, -8, -8, -9, -7, -9, -8, -8, -8, -7,
-8, -8, -8, -8, -7, -8, -8, -8, -8, -8, -8, -8, -8, -8, -8, -8, -8, -9, -8, -8,
-7, -8, -8, -8, -8, -8, -7, -8, -8, -8, -8, -8, -8, -8, -8, -8, -9, -8, -8, -8,
-8, -7, -7, -8, -8, -8, -8, -8, -7, -8, -7, -8, -8, -8, -8, -8, -8, -8, -8, -7,
-8, -8, -8, -8, -7, -8, -8, -7, -8, -7, -7, -8, -8, -8, -7, -8, -8, -8, -8, -7,
-8, -8, -8, -8, -7, -8, -8, -8, -8, -8, -8, -8, -8, -7, -7, -8, -9, -8, -8, -8,
-7, -8, -8, -8, -8, -8, -7, -8, -8, -8, -9, -8, -8, -8, -7, -8, -9, -8, -8, -8,
-7, -8, -7, -7, -8, -8, -8, -8, -8, -7, -8, -8, -8, -8, -8, -8, -8, -7, -8, -8,
-7, -8, -7, -8, -7, -8, -8, -8, -8, -8, -8, -8, -7, -7, -8, -8, -7, -7, -7, -8,
-8, -7, -7, -8, -7, -7, -8, -7, -8, -7, -8, -7, -8, -8, -8, -8, -8, -8, -7, -7,
-7, -8, -7, -8, -7, -7, -8, -8, -7, -8, -8, -7, -8, -8, -8, -7, -7, -7, -8, -7,
-8, -7, -8, -7, -7, -8, -7, -8, -8, -7, -7, -8, -7, -7, -8, -7, -7, -7, -8, -8,
-7, -7, -8, -7, -8, -7, -7, -7, -7, -8, -8, -8, -8, -7, -7, -7, -7, -7, -8, -7,
-7, -7, -7, -7, -7, -7, -7, -8, -7, -7, -7, -8, -7, -7, -8, -7, -7, -7, -7, -7,
-7, -7, -7, -7, -8, -8, -7, -7, -8, -7, -7, -7, -7, -8, -7, -7, -7, -7, -7, -7,
-7, -7, -8, -7, -7, -7, -7, -7, -8, -8, -7, -7, -7, -7, -7, -7, -7, -8, -7, -6,
-7, -7, -7, -7, -7, -7, -8, -7, -8, -8, -7, -7, -7, -7, -7, -7, -8, -7, -8, -7,
-7, -7, -7, -7, -8, -7, -7, -7, -7, -7, -7, -7, -7, -8, -7, -8, -8, -8, -8, -7,
-7, -7, -7, -8, -7, -7, -7, -7, -7, -6, -7, -6, -7, -7, -7, -7, -7, -6, -7, -6,
-13, -18, -28, -36, -45, -36, -1, };