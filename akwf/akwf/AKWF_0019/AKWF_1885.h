#define DATA_LENGTH 512
#define DATA AKWF_1885

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 11, 18, 25, 31, 38, 43, 49, 54, 59,
63, 66, 70, 73, 77, 80, 82, 85, 88, 90, 93, 95, 96, 99, 100, 101, 103, 105, 106,
107, 108, 110, 110, 111, 112, 113, 114, 115, 114, 115, 116, 117, 117, 117, 118,
119, 118, 119, 118, 113, 105, 99, 91, 85, 79, 72, 67, 61, 57, 51, 47, 43, 39,
36, 33, 30, 26, 24, 22, 19, 17, 15, 14, 12, 10, 9, 7, 6, 5, 3, 2, 1, 1, 0, -1,
-2, -2, -4, -4, -5, -6, -5, -6, -7, -6, -7, -8, -8, -9, -8, -8, -9, -10, -10,
-10, -9, -10, -10, -10, -9, -10, -10, -10, -10, -10, -10, -11, -11, -10, -11,
-9, -10, -10, -10, -11, -11, -10, -11, -10, -11, -10, -10, -10, -10, -10, -10,
-10, -9, -11, -10, -9, -10, -10, -9, -10, -10, -9, -9, -9, -9, -10, -9, -9, -9,
-9, -9, -9, -9, -9, -9, -9, -8, -8, -8, -9, -9, -9, -9, -10, -9, -8, -9, -9, -9,
-9, -9, -9, -10, -9, -9, -8, -9, -9, -9, -8, -8, -9, -9, -9, -9, -8, -9, -8, -9,
-9, -8, -8, -8, -8, -8, -8, -9, -8, -8, -8, -9, -9, -9, -9, -8, -9, -9, -9, -9,
-9, -9, -9, -8, -8, -10, -8, -9, -9, -9, -8, -9, -8, -9, -8, -8, -8, -8, -8, -9,
-9, -9, -8, -9, -8, -8, -9, -8, -9, -8, -9, -9, -9, -9, -8, -9, -8, -8, -9, -8,
-9, -8, -9, -9, -8, -9, -9, -9, -8, -9, -9, -9, -8, -9, -9, -9, -8, -9, -8, -8,
-9, -8, -9, -8, -8, -9, -8, -9, -8, -9, -8, -9, -8, -9, -9, -8, -8, -8, -9, -9,
-8, -8, -8, -8, -9, -8, -9, -8, -8, -9, -9, -8, -8, -9, -9, -9, -9, -8, -9, -9,
-8, -9, -10, -9, -9, -9, -8, -9, -9, -8, -8, -8, -8, -9, -9, -8, -8, -8, -8, -8,
-8, -9, -9, -8, -9, -9, -9, -9, -9, -10, -9, -9, -10, -9, -9, -9, -9, -9, -10,
-10, -9, -10, -10, -10, -10, -11, -10, -10, -10, -11, -11, -11, -11, -11, -11,
-11, -11, -11, -11, -11, -10, -12, -11, -11, -12, -11, -11, -12, -11, -11, -12,
-12, -11, -11, -11, -12, -11, -12, -11, -12, -12, -12, -11, -11, -11, -13, -12,
-11, -12, -11, -11, -11, -11, -11, -12, -12, -12, -11, -12, -12, -12, -11, -12,
-12, -12, -12, -12, -12, -12, -13, -12, -13, -12, -13, -13, -13, -13, -13, -12,
-13, -13, -13, -13, -14, -13, -14, -14, -14, -15, -14, -14, -15, -15, -14, -15,
-14, -16, -15, -16, -15, -15, -16, -15, -15, -15, -16, -15, -15, -15, -15, -15,
-14, -15, -14, -14, -16, -17, -21, -26, -32, -40, -47, -52, -57, -64, -68, -73,
-74, -77, -75, -73, -68, -64, -61, -57, -55, -52, -48, -46, -43, -41, -39, -37,
-35, -34, -33, -32, -30, -29, -28, -26, -26, -25, -24, -23, -20, -13, -3, };