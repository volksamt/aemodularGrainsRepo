#define DATA_LENGTH 512
#define DATA AKWF_1896

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 13, 23, 34, 44, 54, 61, 70, 75, 81,
85, 88, 91, 93, 95, 95, 96, 97, 96, 96, 96, 96, 96, 96, 96, 96, 98, 99, 99, 101,
100, 102, 103, 104, 105, 106, 107, 108, 109, 110, 110, 111, 111, 112, 112, 114,
114, 114, 115, 116, 116, 117, 117, 117, 117, 118, 118, 119, 119, 119, 119, 119,
119, 119, 118, 119, 119, 119, 119, 119, 118, 117, 117, 117, 117, 116, 116, 116,
114, 114, 114, 112, 113, 112, 111, 111, 110, 109, 108, 107, 105, 104, 105, 104,
102, 101, 100, 100, 98, 97, 97, 95, 93, 93, 92, 90, 88, 87, 86, 85, 84, 81, 81,
79, 78, 77, 76, 74, 73, 72, 71, 68, 66, 66, 64, 63, 62, 61, 58, 57, 55, 54, 52,
51, 50, 48, 48, 46, 44, 42, 42, 40, 38, 37, 36, 34, 33, 32, 31, 30, 28, 27, 25,
24, 23, 22, 22, 20, 19, 18, 17, 16, 15, 13, 14, 12, 10, 10, 9, 8, 8, 7, 6, 6, 5,
4, 4, 4, 2, 3, 2, 1, 1, 1, 0, 0, -1, -1, -1, -2, -1, -1, 0, -1, -1, -1, 0, 0, 0,
-1, -1, 0, 1, 1, 1, 1, 2, 3, 3, 3, 3, 3, 4, 4, 4, 5, 5, 6, 7, 8, 10, 11, 11, 13,
15, 17, 18, 21, 22, 25, 27, 28, 30, 32, 33, 35, 37, 37, 38, 39, 39, 39, 39, 39,
38, 38, 37, 35, 33, 32, 30, 27, 25, 22, 18, 16, 11, 8, 4, -1, -5, -10, -15, -20,
-24, -28, -33, -36, -40, -43, -45, -47, -48, -49, -49, -48, -47, -46, -44, -42,
-39, -37, -34, -32, -29, -27, -24, -21, -20, -18, -16, -16, -14, -14, -12, -12,
-11, -10, -10, -9, -9, -9, -8, -7, -6, -7, -6, -5, -4, -5, -4, -4, -3, -3, -3,
-2, -1, -2, -1, -1, -1, -1, -1, -1, -1, -1, -2, -2, -1, -2, -2, -2, -2, -2, -3,
-3, -4, -4, -5, -5, -6, -7, -7, -8, -8, -9, -10, -10, -11, -12, -14, -14, -15,
-16, -17, -18, -19, -20, -21, -22, -23, -25, -25, -26, -28, -29, -30, -31, -32,
-34, -35, -37, -37, -39, -41, -42, -43, -45, -46, -48, -49, -51, -51, -53, -55,
-55, -57, -59, -60, -61, -63, -64, -66, -67, -69, -70, -72, -73, -75, -76, -77,
-78, -80, -81, -82, -84, -85, -86, -88, -89, -90, -91, -93, -93, -95, -96, -98,
-98, -99, -101, -102, -102, -104, -104, -105, -106, -107, -108, -108, -109,
-110, -112, -112, -112, -113, -113, -114, -114, -114, -116, -117, -116, -117,
-117, -118, -118, -119, -119, -118, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -118, -119, -117, -118, -118, -117, -116, -116, -116, -116,
-114, -113, -112, -112, -111, -109, -109, -108, -106, -105, -103, -102, -101,
-101, -100, -100, -99, -100, -99, -100, -101, -101, -103, -104, -105, -107,
-106, -106, -106, -106, -103, -100, -96, -92, -85, -79, -70, -62, -52, -42, -30,
-20, -8, };