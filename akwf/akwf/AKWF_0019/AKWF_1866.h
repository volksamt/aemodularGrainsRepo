#define DATA_LENGTH 512
#define DATA AKWF_1866

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 8, 14, 19, 23, 27, 31, 35, 38, 43,
45, 49, 52, 54, 57, 60, 62, 65, 67, 69, 71, 73, 75, 77, 78, 80, 81, 83, 84, 85,
85, 87, 88, 89, 91, 91, 92, 93, 94, 94, 95, 95, 96, 97, 97, 98, 98, 99, 99, 100,
101, 100, 101, 102, 101, 103, 102, 103, 103, 102, 102, 104, 103, 104, 104, 103,
104, 105, 105, 105, 105, 105, 105, 106, 105, 106, 106, 105, 106, 106, 105, 106,
106, 106, 105, 107, 107, 106, 106, 107, 106, 106, 107, 107, 105, 106, 107, 106,
106, 106, 107, 106, 106, 106, 106, 106, 106, 106, 106, 106, 107, 106, 106, 106,
107, 106, 107, 106, 107, 106, 106, 106, 106, 106, 105, 106, 107, 106, 105, 107,
106, 106, 106, 106, 106, 107, 106, 106, 106, 105, 106, 105, 106, 105, 106, 106,
106, 105, 105, 105, 106, 106, 100, 84, 63, 51, 39, 25, 17, 11, 4, -2, -9, -14,
-19, -25, -29, -34, -39, -42, -47, -50, -55, -57, -62, -64, -66, -70, -71, -75,
-76, -79, -81, -84, -85, -87, -89, -90, -91, -94, -95, -96, -98, -99, -99, -101,
-102, -103, -104, -105, -106, -106, -107, -107, -108, -109, -109, -110, -111,
-111, -111, -112, -112, -113, -113, -114, -114, -114, -115, -115, -115, -115,
-116, -116, -116, -116, -117, -117, -117, -117, -118, -117, -117, -117, -118,
-118, -118, -118, -119, -119, -118, -118, -119, -118, -118, -119, -118, -119,
-118, -118, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -120, -119, -118, -119, -119, -120, -119, -120, -119, -119, -119, -118,
-119, -119, -119, -119, -118, -119, -119, -118, -119, -119, -118, -119, -119,
-119, -119, -118, -118, -119, -119, -118, -119, -119, -118, -118, -118, -118,
-119, -118, -114, -104, -93, -84, -74, -64, -55, -47, -40, -32, -25, -18, -13,
-6, -1, 6, 10, 16, 20, 25, 29, 33, 37, 39, 44, 47, 50, 53, 56, 59, 61, 64, 66,
68, 70, 71, 74, 76, 77, 78, 80, 82, 82, 84, 85, 86, 88, 89, 90, 91, 92, 92, 93,
93, 95, 96, 97, 97, 97, 98, 98, 99, 99, 99, 100, 101, 101, 101, 101, 102, 102,
102, 103, 104, 103, 103, 104, 104, 104, 104, 105, 105, 105, 105, 104, 105, 105,
105, 106, 106, 105, 106, 106, 106, 106, 106, 106, 106, 106, 107, 106, 107, 106,
106, 106, 107, 101, 90, 79, 70, 59, 51, 42, 35, 26, 19, 12, 6, -1, -7, -12, -17,
-23, -27, -32, -36, -41, -45, -49, -52, -56, -59, -62, -65, -67, -71, -73, -75,
-78, -79, -81, -83, -86, -87, -88, -90, -91, -93, -95, -95, -97, -97, -99, -100,
-101, -102, -103, -103, -104, -105, -106, -107, -107, -108, -109, -109, -110,
-110, -110, -111, -112, -111, -112, -112, -112, -113, -113, -113, -114, -114,
-114, -115, -115, -115, -115, -115, -115, -115, -115, -116, -116, -116, -117,
-116, -117, -115, -106, -95, -84, -75, -66, -57, -48, -41, -34, -27, -20, -13,
-7, -2, };