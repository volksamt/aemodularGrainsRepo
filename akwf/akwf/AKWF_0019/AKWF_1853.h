#define DATA_LENGTH 512
#define DATA AKWF_1853

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 7, 9, 11, 14, 17, 18, 21,
24, 26, 28, 32, 34, 36, 40, 43, 45, 48, 50, 53, 56, 58, 61, 63, 66, 68, 71, 73,
74, 76, 79, 80, 82, 84, 85, 87, 88, 90, 91, 92, 93, 94, 95, 95, 97, 97, 97, 97,
98, 97, 98, 98, 98, 97, 96, 96, 94, 95, 94, 93, 91, 90, 87, 87, 85, 83, 81, 80,
78, 75, 73, 71, 69, 67, 64, 61, 59, 56, 54, 51, 47, 45, 42, 40, 36, 33, 31, 27,
25, 21, 18, 14, 11, 8, 4, 0, -2, -7, -9, -12, -17, -21, -24, -29, -32, -36, -40,
-44, -48, -51, -55, -58, -63, -66, -70, -73, -77, -80, -84, -87, -90, -93, -96,
-99, -100, -103, -106, -108, -109, -111, -112, -114, -114, -115, -115, -116,
-116, -116, -117, -117, -115, -115, -115, -113, -112, -110, -109, -107, -106,
-104, -102, -98, -96, -93, -91, -88, -85, -82, -79, -75, -72, -69, -66, -61,
-58, -55, -51, -47, -42, -39, -35, -31, -27, -23, -20, -16, -13, -9, -6, -2, 0,
4, 7, 11, 14, 17, 19, 22, 24, 26, 29, 31, 33, 36, 38, 40, 42, 43, 46, 47, 48,
49, 50, 53, 54, 55, 55, 57, 58, 58, 59, 60, 60, 61, 62, 61, 61, 61, 62, 61, 62,
61, 61, 60, 59, 58, 58, 57, 56, 55, 54, 54, 52, 51, 51, 50, 49, 48, 47, 46, 45,
45, 45, 44, 44, 44, 43, 43, 44, 43, 44, 43, 44, 45, 45, 46, 47, 48, 47, 48, 50,
49, 52, 53, 54, 55, 55, 56, 58, 59, 61, 62, 62, 64, 66, 67, 69, 70, 71, 73, 74,
74, 76, 77, 78, 78, 79, 79, 80, 80, 80, 80, 80, 78, 78, 78, 76, 74, 73, 71, 69,
67, 65, 62, 59, 57, 53, 50, 47, 44, 41, 37, 34, 30, 26, 22, 18, 14, 10, 7, 1,
-2, -6, -10, -14, -18, -22, -26, -31, -34, -38, -43, -46, -49, -53, -57, -61,
-64, -68, -71, -75, -78, -81, -84, -87, -89, -93, -95, -98, -100, -103, -105,
-107, -109, -111, -111, -113, -114, -115, -117, -117, -117, -118, -119, -118,
-119, -119, -119, -118, -118, -117, -117, -116, -116, -115, -114, -113, -112,
-110, -109, -107, -106, -104, -104, -101, -101, -98, -96, -95, -92, -89, -88,
-85, -82, -81, -78, -76, -72, -70, -67, -65, -62, -58, -56, -53, -50, -47, -44,
-40, -38, -34, -32, -28, -25, -23, -19, -16, -14, -11, -8, -6, -4, -1, 1, 2, 5,
7, 9, 11, 12, 13, 14, 15, 15, 17, 18, 19, 19, 19, 20, 20, 20, 20, 21, 21, 20,
20, 20, 20, 20, 20, 19, 18, 18, 17, 16, 16, 15, 14, 14, 14, 12, 11, 10, 9, 9, 7,
7, 6, 5, 4, 3, 2, 1, 0, -1, -3, -3, -4, -4, -5, -6, -6, -8, -8, -9, -9, -9, -10,
-10, -9, -9, -9, -10, -10, -9, -10, -9, -8, -8, -8, -8, -6, -6, -5, -4, -4, -2,
-1, };