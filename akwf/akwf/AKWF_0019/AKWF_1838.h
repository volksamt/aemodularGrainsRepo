#define DATA_LENGTH 512
#define DATA AKWF_1838

const PROGMEM int8_t DATA[DATA_LENGTH] = {46, 76, 69, 74, 71, 73, 70, 74, 49,
37, 40, 38, 39, 38, 40, 44, 47, 46, 46, 46, 47, 46, 47, 46, 46, 45, 45, 45, 44,
44, 46, 49, 52, 51, 52, 51, 52, 52, 52, 51, 58, 62, 61, 61, 61, 60, 61, 64, 61,
60, 60, 60, 61, 60, 61, 61, 58, 58, 58, 57, 58, 58, 58, 58, 57, 56, 56, 57, 56,
56, 56, 56, 65, 71, 70, 71, 70, 71, 71, 78, 103, 104, 104, 104, 105, 104, 104,
105, 104, 106, 105, 106, 105, 105, 105, 106, 107, 106, 106, 106, 106, 106, 105,
107, 64, 42, 49, 44, 48, 45, 48, 46, 47, 44, 46, 44, 47, 45, 47, 41, -6, -14,
-12, -13, -13, -13, -13, 0, 37, 45, 43, 45, 44, 43, 44, 43, 47, 47, 47, 47, 47,
48, 44, 18, 10, 15, 13, 15, 14, 14, 14, 15, 20, 21, 20, 20, 20, 20, 20, 19, 18,
18, 18, 18, 18, 18, 18, 18, 16, 16, 16, 16, 16, 16, 16, 13, 5, 2, 2, 1, 2, 1, 2,
3, 11, 13, 13, 12, 12, 12, 13, 8, -13, -18, -16, -17, -17, -18, -18, -18, -23,
-26, -26, -26, -25, -25, -27, -33, -41, -41, -41, -40, -41, -40, -42, -36, -9,
-5, -7, -6, -7, -6, -7, -13, -4, 2, 0, 1, 1, 1, 0, 1, -6, -8, -7, -8, -8, -7,
-8, -10, -26, -33, -31, -32, -32, -32, -31, -34, -58, -59, -60, -59, -59, -58,
-61, -53, 42, 64, 56, 62, 57, 60, 57, 60, 33, 26, 26, 26, 26, 26, 26, 23, 23,
23, 23, 23, 23, 24, 23, 23, 22, 21, 21, 21, 21, 21, 22, 20, 19, 19, 19, 19, 20,
19, 18, 18, 26, 29, 28, 29, 28, 28, 29, 23, 13, 12, 12, 12, 13, 12, 13, 12, 9,
9, 10, 9, 9, 9, 9, 8, 2, 1, 0, 1, 0, 1, 0, 2, 12, 17, 14, 17, 14, 17, 13, 19,
41, 42, 41, 41, 42, 41, 42, 42, 41, 42, 42, 43, 43, 41, 42, 40, 40, 39, 40, 39,
40, 39, 40, 37, -8, -24, -18, -23, -18, -21, -19, -39, -57, -59, -57, -60, -56,
-60, -56, -67, -113, -117, -116, -117, -116, -117, -116, -114, -102, -101, -100,
-100, -101, -100, -101, -100, -98, -96, -96, -96, -97, -96, -97, -95, -88, -84,
-86, -85, -85, -85, -87, -84, -80, -79, -80, -79, -79, -79, -78, -76, -75, -74,
-75, -75, -74, -75, -74, -75, -76, -77, -77, -77, -77, -77, -77, -72, -73, -76,
-75, -76, -75, -75, -75, -74, -65, -65, -65, -66, -65, -66, -64, -64, -76, -79,
-77, -79, -77, -78, -77, -78, -85, -86, -86, -85, -85, -87, -85, -84, -85, -86,
-86, -86, -87, -86, -88, -80, -53, -52, -52, -52, -52, -52, -52, -39, -17, -15,
-16, -15, -16, -15, -16, -16, -23, -25, -23, -24, -24, -24, -23, -18, -27, -32,
-30, -31, -30, -31, -30, -36, -59, -58, -59, -58, -60, -57, -61, -43, };