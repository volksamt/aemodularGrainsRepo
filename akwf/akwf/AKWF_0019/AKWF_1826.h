#define DATA_LENGTH 512
#define DATA AKWF_1826

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 6, 10, 12, 14, 17, 18, 21, 23,
25, 26, 29, 30, 31, 32, 32, 34, 34, 35, 36, 37, 37, 38, 38, 39, 38, 39, 38, 38,
39, 39, 39, 39, 39, 39, 38, 39, 38, 38, 37, 37, 37, 36, 36, 36, 36, 35, 34, 34,
33, 32, 32, 32, 31, 31, 31, 30, 30, 29, 28, 29, 27, 26, 24, 22, 20, 18, 17, 16,
15, 13, 11, 11, 10, 9, 8, 7, 7, 6, 5, 4, 3, 3, 2, 1, 1, 0, 0, 0, -1, -2, -3, -2,
-3, -3, -3, -3, -4, -5, -5, -6, -6, -6, -6, -6, -7, -7, -7, -6, -8, -7, -7, -8,
-9, -8, -8, -8, -7, -7, -7, -7, -7, -7, -7, -6, -6, -6, -5, -4, -3, -4, -2, 0,
1, 2, 3, 5, 7, 10, 11, 13, 16, 19, 23, 26, 30, 34, 37, 43, 48, 52, 57, 62, 67,
73, 79, 83, 89, 93, 98, 102, 107, 110, 113, 115, 116, 118, 119, 119, 118, 117,
116, 113, 111, 107, 104, 101, 96, 92, 88, 83, 79, 74, 69, 64, 59, 54, 51, 46,
41, 37, 33, 30, 25, 21, 18, 15, 11, 7, 5, 1, -2, -4, -6, -9, -12, -14, -16, -18,
-20, -22, -24, -25, -28, -28, -31, -33, -33, -34, -37, -37, -39, -39, -40, -40,
-41, -42, -41, -42, -42, -43, -42, -42, -42, -42, -41, -41, -40, -39, -37, -37,
-35, -35, -33, -32, -31, -30, -28, -26, -25, -23, -21, -20, -17, -15, -14, -11,
-10, -7, -5, -3, -1, 0, 1, 3, 5, 5, 6, 6, 6, 6, 5, 4, 1, -1, -3, -8, -10, -15,
-20, -24, -30, -34, -38, -44, -48, -51, -53, -56, -58, -59, -59, -60, -58, -59,
-56, -56, -54, -53, -51, -50, -48, -45, -43, -40, -39, -36, -35, -30, -31, -26,
-28, -22, -26, -16, -32, 44, 87, -23, -27, -22, -21, -17, -18, -14, -14, -12,
-12, -9, -9, -6, -5, -2, -2, 2, 2, 5, 6, 10, 11, 15, 17, 20, 22, 25, 29, 32, 36,
38, 43, 46, 49, 51, 54, 55, 57, 56, 55, 54, 51, 49, 47, 43, 38, 35, 32, 26, 22,
18, 14, 9, 6, 2, -1, -4, -7, -9, -12, -13, -14, -15, -17, -18, -17, -19, -19,
-18, -18, -18, -17, -15, -15, -14, -13, -12, -11, -10, -8, -7, -6, -4, -3, -1,
0, 1, 2, 3, 4, 6, 7, 8, 9, 11, 11, 12, 12, 13, 13, 13, 14, 15, 14, 15, 15, 15,
14, 14, 13, 14, 13, 13, 12, 11, 10, 9, 9, 8, 7, 6, 5, 4, 4, 2, 1, -1, -2, -3,
-5, -7, -9, -11, -12, -14, -17, -19, -22, -25, -28, -31, -35, -39, -44, -47,
-51, -56, -61, -65, -71, -75, -81, -86, -91, -95, -99, -103, -107, -110, -111,
-115, -115, -117, -116, -117, -116, -114, -112, -109, -106, -103, -99, -94, -90,
-85, -81, -77, -70, -66, -60, -55, -51, -45, -41, -35, -31, -26, -22, -18, -15,
-10, -6, -3, };