#define DATA_LENGTH 512
#define DATA AKWF_1830

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 31, 48, 63, 75, 86, 92, 98, 102,
104, 103, 102, 101, 99, 95, 92, 88, 86, 82, 77, 74, 70, 67, 65, 62, 58, 56, 53,
51, 48, 46, 44, 42, 40, 38, 36, 34, 32, 31, 30, 27, 26, 26, 23, 22, 22, 20, 20,
19, 18, 17, 15, 15, 14, 13, 13, 12, 11, 11, 10, 9, 9, 8, 8, 7, 6, 6, 5, 5, 5, 4,
3, 3, 3, 3, 1, 2, 1, 1, 0, 0, 1, 0, 0, 0, -1, -1, -1, -1, -2, -2, -1, -2, -2,
-3, -3, -3, -3, -3, -3, -3, -4, -4, -4, -5, -5, -4, -5, -5, -5, -5, -5, -5, -5,
-5, -5, -5, -5, -6, -6, -5, -6, -5, -6, -5, -5, -5, -6, -5, -5, -5, -6, -5, -5,
-6, -6, -6, -5, -6, -6, -5, -6, -5, -6, -5, -5, -6, -5, -6, -6, -6, -6, -5, -6,
-6, -5, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -5, -6, -6, -5, -6, -6,
-5, -6, -5, -5, -5, -5, -5, -6, -5, -6, -5, -5, -5, -5, -6, -6, -5, -5, -5, -5,
-5, -5, -5, -5, -5, -5, -6, -5, -4, -4, -5, -5, -5, -5, -4, -4, -5, -4, -4, -4,
-4, -3, -3, -3, -4, -3, -3, -4, -3, -4, -3, -4, -3, -3, -3, -3, -3, -3, -2, -3,
-3, -2, -2, -3, -2, -3, -2, -2, -3, -2, -2, -2, -3, -2, -3, -2, -2, -2, -1, -2,
-2, -1, -2, -2, -1, -1, -1, -1, -2, -1, -1, -1, -1, -1, -1, -1, 0, 0, -1, -1,
-1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 1, 1, 0, 1, 1, 1, 1, 1, 1, 0, 1, 1, 0, 0,
1, 2, 2, 1, 1, 1, 1, 1, 1, 1, 1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 2, 2, 3, 3, 3, 3,
3, 3, 2, 2, 4, 3, 3, 3, 3, 4, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 5, 4, 5, 4, 4, 5,
5, 5, 5, 5, 5, 6, 5, 5, 6, 6, 6, 6, 7, 6, 5, 6, 7, 7, 7, 6, 7, 7, 8, 8, 8, 8, 9,
7, 8, 8, 8, 9, 8, 9, 9, 10, 10, 10, 10, 11, 11, 11, 10, 11, 12, 12, 13, 13, 13,
14, 14, 14, 16, 15, 16, 16, 16, 16, 17, 18, 18, 19, 20, 20, 21, 22, 22, 24, 24,
25, 27, 27, 28, 30, 30, 32, 33, 35, 36, 38, 39, 42, 43, 46, 47, 49, 50, 53, 54,
55, 57, 56, 56, 53, 50, 43, 35, 23, 9, -7, -24, -42, -59, -75, -88, -99, -107,
-112, -118, -119, -119, -118, -116, -114, -111, -107, -104, -101, -96, -92, -88,
-85, -82, -78, -75, -72, -68, -66, -64, -62, -61, -61, -61, -61, -62, -63, -63,
-65, -66, -67, -69, -70, -71, -73, -75, -76, -77, -78, -79, -78, -75, -72, -66,
-59, -47, -34, -18, -2, };