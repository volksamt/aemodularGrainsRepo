#define DATA_LENGTH 512
#define DATA AKWF_1863

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 11, 13, 16, 20, 23, 26, 29,
33, 36, 39, 42, 46, 48, 52, 55, 59, 61, 64, 67, 71, 74, 77, 79, 82, 84, 87, 89,
92, 93, 94, 96, 98, 99, 100, 101, 101, 101, 102, 101, 101, 101, 101, 100, 100,
99, 98, 99, 97, 96, 96, 95, 93, 93, 91, 89, 89, 86, 85, 84, 82, 80, 79, 77, 74,
72, 70, 68, 66, 64, 61, 58, 55, 52, 50, 46, 44, 40, 36, 33, 29, 25, 22, 18, 13,
10, 5, 2, -2, -6, -11, -14, -18, -23, -27, -30, -34, -38, -42, -45, -48, -51,
-55, -58, -61, -65, -68, -71, -73, -77, -79, -82, -84, -88, -89, -92, -94, -96,
-98, -99, -101, -102, -104, -104, -105, -106, -107, -108, -108, -108, -110,
-110, -111, -111, -112, -113, -113, -114, -114, -115, -115, -116, -116, -116,
-117, -117, -117, -119, -118, -119, -119, -119, -119, -119, -119, -119, -120,
-118, -118, -118, -118, -118, -117, -116, -116, -115, -115, -114, -113, -113,
-111, -110, -109, -109, -108, -106, -105, -103, -103, -100, -100, -97, -96, -94,
-92, -90, -88, -85, -83, -81, -78, -77, -73, -71, -68, -66, -62, -61, -57, -54,
-52, -50, -46, -43, -40, -37, -34, -31, -28, -25, -21, -19, -15, -12, -9, -6,
-2, 2, 4, 8, 12, 15, 18, 21, 24, 27, 30, 33, 36, 40, 42, 44, 48, 50, 53, 54, 56,
59, 62, 64, 65, 68, 70, 71, 73, 74, 76, 77, 79, 80, 81, 81, 83, 83, 83, 84, 84,
84, 84, 84, 83, 84, 84, 83, 82, 80, 80, 79, 79, 76, 75, 74, 72, 71, 69, 68, 66,
64, 62, 60, 58, 57, 54, 52, 50, 47, 45, 43, 41, 39, 37, 35, 32, 30, 29, 26, 24,
22, 20, 18, 16, 14, 13, 11, 10, 8, 6, 5, 4, 3, 1, -1, -2, -2, -4, -4, -5, -6,
-6, -7, -7, -7, -9, -8, -8, -8, -9, -9, -9, -8, -9, -8, -7, -7, -6, -7, -6, -5,
-4, -4, -3, -3, -2, 0, 0, 1, 1, 2, 3, 4, 5, 6, 7, 8, 8, 10, 11, 11, 13, 13, 14,
14, 14, 16, 16, 18, 17, 18, 18, 19, 20, 19, 20, 21, 21, 22, 21, 22, 22, 22, 22,
22, 22, 22, 23, 22, 22, 21, 21, 22, 21, 21, 21, 21, 20, 20, 20, 19, 19, 18, 18,
17, 17, 16, 15, 15, 15, 14, 13, 13, 11, 11, 10, 9, 8, 8, 7, 6, 6, 4, 4, 4, 3, 2,
1, 1, 0, 0, -1, -2, -3, -2, -3, -4, -4, -5, -6, -5, -6, -6, -7, -7, -7, -7, -8,
-8, -9, -8, -8, -8, -8, -8, -8, -8, -8, -8, -8, -7, -8, -8, -8, -9, -8, -8, -8,
-9, -9, -9, -9, -9, -9, -10, -10, -11, -11, -11, -12, -12, -13, -13, -13, -15,
-15, -16, -16, -17, -17, -18, -19, -19, -19, -19, -19, -20, -20, -20, -20, -19,
-18, -18, -17, -16, -14, -13, -11, -8, -7, -5, -3, 0, };