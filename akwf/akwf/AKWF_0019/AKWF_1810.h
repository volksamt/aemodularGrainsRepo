#define DATA_LENGTH 512
#define DATA AKWF_1810

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 17, 21, 23, 24, 27, 31, 39, 48,
59, 69, 80, 89, 96, 99, 96, 89, 80, 71, 64, 63, 64, 71, 79, 87, 93, 94, 90, 84,
78, 74, 73, 74, 77, 78, 82, 83, 83, 79, 77, 71, 65, 57, 51, 43, 38, 31, 29, 27,
30, 38, 48, 59, 75, 90, 104, 112, 115, 113, 111, 109, 106, 101, 93, 87, 84, 84,
87, 87, 83, 74, 64, 53, 43, 35, 31, 30, 31, 34, 38, 40, 43, 46, 46, 45, 45, 42,
39, 37, 34, 34, 35, 37, 41, 43, 45, 47, 51, 53, 54, 54, 54, 53, 53, 55, 58, 62,
66, 70, 74, 77, 77, 75, 72, 68, 62, 57, 51, 45, 37, 27, 16, 6, 0, -3, -3, 0, 2,
4, 6, 10, 12, 17, 22, 25, 27, 27, 26, 23, 19, 15, 10, 6, 3, 1, -1, -2, -5, -6,
-8, -9, -12, -14, -16, -20, -24, -28, -33, -38, -42, -47, -52, -58, -62, -67,
-70, -74, -78, -82, -83, -83, -83, -83, -83, -82, -81, -80, -78, -77, -75, -75,
-74, -74, -72, -72, -70, -67, -65, -62, -60, -60, -59, -60, -60, -60, -60, -60,
-59, -59, -57, -56, -56, -55, -55, -53, -52, -50, -50, -52, -51, -47, -45, -43,
-42, -40, -38, -36, -33, -33, -32, -31, -28, -24, -21, -17, -14, -11, -8, -6,
-3, -1, 3, 5, 10, 12, 16, 19, 23, 24, 26, 26, 27, 29, 29, 31, 33, 36, 39, 41,
42, 46, 48, 51, 54, 55, 57, 58, 59, 60, 61, 62, 62, 64, 64, 66, 67, 69, 70, 70,
71, 73, 72, 72, 73, 74, 77, 79, 79, 79, 80, 79, 80, 79, 76, 75, 73, 72, 70, 68,
68, 68, 66, 64, 60, 59, 57, 58, 58, 57, 55, 53, 51, 51, 49, 48, 47, 48, 48, 46,
44, 42, 39, 37, 35, 33, 34, 35, 35, 33, 32, 29, 29, 31, 30, 28, 28, 27, 26, 26,
24, 20, 17, 16, 18, 19, 19, 16, 15, 17, 20, 20, 17, 13, 8, 9, 12, 14, 15, 16,
17, 18, 16, 8, 1, -3, -1, 2, 2, -1, -4, -5, -5, -4, -7, -9, -9, -6, -5, -7, -14,
-19, -24, -27, -26, -23, -21, -21, -23, -26, -27, -26, -23, -21, -21, -25, -31,
-37, -41, -46, -48, -49, -46, -41, -34, -31, -32, -37, -42, -46, -50, -57, -67,
-75, -74, -67, -57, -52, -51, -55, -59, -66, -76, -89, -99, -99, -90, -78, -69,
-67, -69, -70, -74, -79, -87, -93, -98, -100, -102, -108, -114, -118, -116,
-110, -99, -88, -80, -77, -79, -85, -93, -101, -109, -113, -116, -115, -110,
-104, -97, -91, -86, -81, -78, -79, -83, -93, -105, -113, -118, -119, -117,
-114, -110, -106, -97, -87, -80, -75, -72, -72, -71, -73, -75, -79, -78, -73,
-64, -58, -53, -56, -63, -69, -76, -80, -80, -78, -71, -62, -52, -41, -32, -24,
-13, -4, 3, 5, 2, -5, -12, -19, -24, -25, -26, -27, -30, -34, -36, -35, -28,
-20, -10, -2, };