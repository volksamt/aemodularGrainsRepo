#define DATA_LENGTH 512
#define DATA AKWF_1879

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 13, 16, 21, 26, 29, 33, 37,
39, 43, 47, 50, 54, 58, 60, 62, 64, 66, 66, 68, 71, 72, 75, 75, 77, 78, 79, 80,
81, 81, 83, 85, 85, 86, 85, 85, 83, 83, 80, 79, 77, 74, 72, 68, 64, 62, 57, 52,
48, 43, 38, 32, 28, 22, 17, 10, 4, -3, -9, -15, -20, -27, -34, -39, -45, -51,
-56, -62, -67, -72, -76, -82, -85, -89, -92, -96, -98, -102, -104, -106, -109,
-110, -112, -114, -115, -116, -117, -118, -119, -118, -119, -119, -119, -119,
-118, -117, -117, -115, -114, -113, -111, -109, -106, -105, -102, -100, -97,
-94, -90, -87, -84, -79, -75, -71, -67, -62, -57, -53, -48, -43, -39, -35, -30,
-25, -20, -15, -10, -7, -2, 2, 6, 10, 14, 19, 23, 26, 30, 33, 36, 39, 42, 46,
48, 52, 55, 57, 59, 62, 65, 68, 70, 74, 76, 77, 80, 80, 82, 83, 83, 84, 84, 85,
84, 84, 82, 81, 80, 79, 78, 76, 75, 73, 71, 69, 67, 65, 64, 61, 59, 56, 54, 52,
50, 47, 46, 43, 41, 39, 37, 34, 31, 29, 26, 24, 21, 19, 16, 14, 11, 9, 6, 3, 1,
-2, -4, -7, -9, -11, -14, -16, -18, -21, -22, -24, -27, -29, -30, -32, -34, -35,
-37, -39, -39, -40, -42, -41, -43, -43, -43, -44, -44, -43, -43, -43, -42, -42,
-41, -39, -39, -38, -37, -35, -33, -31, -30, -28, -25, -23, -20, -17, -14, -11,
-8, -5, 0, 4, 8, 12, 17, 21, 25, 29, 33, 38, 41, 47, 50, 52, 55, 58, 60, 63, 65,
67, 68, 70, 71, 72, 73, 74, 75, 77, 76, 77, 77, 78, 78, 78, 78, 78, 78, 78, 77,
76, 74, 72, 69, 68, 65, 62, 59, 57, 53, 49, 45, 40, 35, 31, 26, 22, 17, 12, 6,
1, -5, -10, -16, -21, -26, -32, -37, -42, -47, -52, -58, -62, -67, -71, -75,
-79, -82, -86, -90, -93, -95, -98, -101, -102, -105, -106, -108, -108, -110,
-111, -112, -113, -113, -114, -114, -113, -114, -113, -112, -111, -110, -109,
-108, -105, -104, -102, -98, -96, -93, -90, -87, -83, -80, -76, -72, -68, -63,
-59, -55, -51, -46, -41, -36, -32, -27, -23, -18, -13, -8, -5, 0, 4, 8, 12, 16,
19, 23, 26, 29, 33, 35, 38, 41, 43, 46, 47, 50, 52, 55, 57, 59, 60, 62, 64, 66,
68, 69, 71, 72, 73, 75, 75, 74, 75, 76, 75, 75, 75, 75, 74, 72, 71, 70, 68, 67,
67, 65, 63, 62, 60, 59, 56, 55, 53, 51, 49, 46, 45, 42, 39, 37, 34, 31, 28, 26,
22, 19, 16, 13, 10, 8, 4, 2, -1, -4, -6, -8, -11, -14, -17, -18, -20, -23, -25,
-26, -28, -30, -31, -32, -33, -34, -34, -35, -36, -36, -37, -37, -37, -36, -37,
-36, -35, -35, -34, -34, -33, -32, -31, -31, -30, -28, -27, -26, -25, -24, -22,
-22, -20, -17, -15, -13, -11, -8, -6, -4, 0, };