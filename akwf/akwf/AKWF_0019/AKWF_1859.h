#define DATA_LENGTH 512
#define DATA AKWF_1859

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 6, 11, 18, 23, 27, 32, 36, 40, 44,
48, 51, 55, 58, 61, 64, 67, 70, 72, 75, 76, 78, 81, 83, 85, 87, 88, 89, 90, 93,
94, 95, 96, 98, 98, 99, 100, 101, 103, 103, 104, 104, 104, 106, 107, 108, 107,
108, 109, 109, 110, 110, 111, 111, 112, 112, 112, 113, 114, 113, 114, 114, 114,
115, 115, 114, 115, 115, 115, 115, 116, 115, 116, 116, 116, 117, 117, 116, 117,
117, 117, 117, 117, 117, 117, 118, 117, 118, 118, 117, 118, 118, 117, 118, 118,
118, 118, 118, 118, 118, 118, 118, 119, 119, 119, 118, 119, 119, 119, 118, 119,
119, 119, 119, 118, 119, 118, 119, 118, 118, 119, 119, 120, 119, 119, 118, 120,
118, 119, 119, 119, 119, 119, 119, 119, 118, 120, 119, 118, 119, 119, 120, 119,
119, 118, 119, 119, 118, 119, 118, 119, 119, 119, 120, 119, 119, 119, 119, 119,
119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119,
119, 119, 119, 118, 119, 119, 120, 118, 119, 119, 118, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118,
119, 119, 118, 119, 118, 119, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 117, 110, 99, 89, 79, 69, 59, 51, 42, 34, 27, 19, 12, 5, 0, -6,
-12, -17, -22, -28, -32, -36, -41, -44, -48, -52, -55, -58, -61, -64, -67, -70,
-71, -74, -77, -79, -80, -83, -84, -86, -88, -90, -92, -92, -94, -95, -96, -97,
-98, -99, -101, -102, -102, -103, -105, -105, -105, -107, -107, -107, -108,
-109, -109, -109, -111, -111, -111, -111, -111, -112, -113, -112, -114, -113,
-114, -114, -113, -114, -115, -115, -115, -116, -116, -117, -116, -116, -117,
-117, -117, -116, -117, -116, -116, -117, -117, -118, -118, -117, -117, -117,
-118, -118, -118, -118, -118, -118, -118, -118, -118, -119, -118, -118, -118,
-118, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -120, -119,
-119, -118, -118, -119, -119, -118, -118, -119, -119, -118, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-118, -119, -119, -118, -118, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -120, -119, -118, -120, -119, -118, -119, -119, -119, -119, -118, -118,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -120, -118,
-120, -120, -119, -119, -119, -119, -120, -119, -120, -119, -118, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -120, -120, -119, -120,
-119, -119, -120, -119, -118, -119, -119, -120, -120, -119, -119, -119, -119,
-116, -110, -99, -88, -78, -68, -58, -49, -41, -33, -26, -19, -11, -4, };