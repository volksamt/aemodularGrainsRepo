#define DATA_LENGTH 512
#define DATA AKWF_1892

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 7, 9, 13, 15, 17, 19, 21, 24,
25, 26, 29, 31, 31, 34, 35, 37, 38, 39, 40, 43, 44, 45, 47, 48, 49, 50, 51, 54,
55, 56, 58, 59, 60, 61, 63, 63, 65, 66, 67, 68, 69, 70, 71, 72, 74, 73, 75, 75,
77, 77, 78, 79, 80, 80, 80, 82, 82, 82, 82, 83, 83, 83, 83, 84, 83, 84, 85, 84,
85, 85, 85, 86, 87, 86, 86, 87, 88, 88, 89, 90, 89, 91, 92, 92, 93, 93, 94, 94,
95, 95, 97, 98, 98, 99, 100, 102, 103, 103, 104, 105, 105, 108, 108, 108, 109,
110, 111, 111, 113, 113, 113, 114, 116, 116, 116, 117, 118, 118, 118, 119, 118,
120, 119, 119, 119, 118, 119, 119, 118, 119, 119, 119, 120, 119, 118, 118, 117,
117, 116, 116, 114, 114, 113, 112, 111, 111, 109, 108, 107, 105, 104, 102, 102,
100, 99, 97, 95, 92, 91, 90, 87, 85, 83, 81, 80, 76, 75, 73, 70, 67, 65, 62, 60,
58, 56, 54, 50, 48, 46, 43, 41, 38, 35, 33, 30, 27, 25, 22, 19, 17, 15, 11, 9,
6, 5, 2, -1, -4, -6, -8, -10, -13, -16, -18, -19, -22, -24, -27, -29, -31, -32,
-34, -36, -38, -39, -41, -42, -42, -45, -46, -47, -48, -49, -50, -50, -51, -52,
-51, -53, -53, -53, -52, -53, -52, -52, -53, -51, -52, -51, -51, -50, -49, -48,
-47, -46, -46, -44, -44, -42, -42, -41, -39, -38, -36, -35, -34, -32, -32, -31,
-29, -28, -27, -25, -24, -23, -21, -21, -20, -18, -18, -16, -15, -14, -13, -12,
-12, -11, -11, -9, -9, -8, -7, -7, -6, -5, -6, -5, -4, -5, -3, -4, -3, -3, -3,
-3, -3, -3, -3, -3, -4, -4, -3, -4, -3, -3, -3, -4, -4, -4, -5, -5, -5, -5, -6,
-7, -7, -7, -8, -8, -9, -10, -11, -11, -11, -13, -12, -14, -14, -15, -16, -17,
-17, -19, -19, -21, -22, -23, -23, -25, -25, -27, -28, -28, -30, -31, -32, -32,
-34, -34, -35, -36, -37, -38, -39, -40, -41, -41, -42, -43, -43, -44, -44, -45,
-45, -46, -46, -47, -47, -47, -48, -49, -48, -48, -49, -50, -50, -50, -50, -52,
-51, -52, -52, -52, -53, -54, -55, -55, -56, -57, -57, -58, -59, -60, -62, -63,
-64, -65, -67, -67, -70, -70, -71, -73, -74, -75, -77, -78, -80, -81, -83, -85,
-86, -89, -89, -91, -93, -94, -95, -97, -97, -99, -101, -102, -103, -103, -105,
-106, -107, -108, -109, -110, -110, -111, -112, -113, -113, -112, -114, -113,
-113, -113, -113, -113, -114, -113, -112, -113, -113, -112, -113, -113, -111,
-111, -111, -110, -110, -109, -108, -108, -106, -105, -105, -104, -102, -101,
-99, -98, -97, -95, -94, -92, -90, -88, -86, -85, -83, -81, -79, -76, -75, -73,
-70, -68, -67, -64, -62, -59, -57, -55, -53, -50, -48, -45, -44, -41, -39, -37,
-34, -31, -28, -26, -22, -20, -17, -15, -12, -9, -6, -3, -1, };