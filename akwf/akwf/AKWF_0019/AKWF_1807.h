#define DATA_LENGTH 512
#define DATA AKWF_1807

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 13, 12, 11, 11, 12, 9, 11, 9, 9,
9, 8, 9, 10, 9, 11, 10, 10, 11, 10, 11, 11, 11, 12, 12, 12, 13, 12, 13, 13, 13,
13, 13, 14, 13, 14, 14, 13, 13, 13, 13, 14, 14, 15, 15, 14, 15, 14, 15, 16, 15,
16, 16, 16, 17, 16, 16, 18, 17, 18, 18, 18, 18, 19, 19, 19, 19, 20, 19, 20, 20,
20, 21, 21, 21, 22, 22, 22, 22, 22, 23, 23, 23, 23, 24, 24, 23, 23, 24, 24, 25,
25, 26, 25, 26, 25, 26, 26, 27, 27, 28, 28, 28, 28, 27, 28, 29, 29, 28, 29, 29,
30, 29, 30, 31, 30, 31, 31, 31, 31, 31, 32, 32, 32, 33, 33, 33, 33, 34, 33, 33,
32, 33, 32, 32, 31, 31, 31, 31, 30, 30, 30, 30, 30, 30, 29, 28, 29, 28, 29, 27,
29, 26, 28, 26, 27, 25, 28, 24, 28, 23, 29, 21, 34, 116, 117, 114, 115, 113,
113, 110, 112, 109, 110, 107, 108, 105, 105, 103, 103, 101, 102, 100, 99, 97,
97, 96, 94, 93, 93, 91, 90, 89, 88, 87, 86, 85, 84, 83, 82, 81, 79, 79, 77, 76,
75, 74, 74, 72, 71, 69, 68, 67, 66, 65, 64, 62, 62, 61, 59, 58, 57, 56, 55, 53,
52, 52, 51, 49, 48, 46, 46, 44, 43, 42, 41, 40, 38, 38, 37, 35, 35, 34, 31, 31,
30, 30, 27, 27, 24, 25, 22, 23, 19, 19, 15, -18, -18, -17, -18, -17, -18, -17,
-18, -17, -16, -16, -17, -16, -16, -15, -16, -15, -15, -14, -14, -14, -13, -14,
-14, -13, -13, -14, -13, -14, -15, -15, -14, -15, -15, -15, -16, -14, -13, -13,
-13, -14, -14, -15, -15, -15, -14, -15, -15, -16, -16, -16, -16, -16, -16, -17,
-17, -18, -18, -18, -18, -19, -18, -19, -19, -19, -20, -19, -20, -20, -20, -20,
-21, -21, -22, -21, -21, -22, -22, -22, -23, -22, -23, -24, -24, -24, -23, -24,
-24, -25, -25, -24, -25, -25, -26, -25, -26, -26, -26, -27, -26, -27, -28, -28,
-28, -27, -29, -29, -29, -29, -29, -30, -30, -31, -30, -30, -31, -30, -31, -32,
-31, -32, -32, -33, -32, -33, -32, -32, -33, -33, -33, -32, -32, -33, -32, -32,
-31, -32, -31, -31, -30, -31, -31, -31, -29, -29, -29, -29, -29, -28, -28, -28,
-27, -28, -27, -27, -28, -27, -27, -26, -27, -23, -29, -22, -31, -14, -66, -124,
-110, -116, -111, -113, -109, -111, -109, -109, -107, -106, -105, -103, -104,
-101, -101, -99, -99, -97, -96, -96, -95, -93, -94, -91, -91, -89, -89, -88,
-87, -86, -84, -82, -82, -81, -79, -79, -78, -77, -75, -74, -72, -71, -71, -70,
-68, -68, -67, -65, -63, -63, -62, -60, -59, -59, -57, -56, -55, -53, -52, -51,
-50, -49, -48, -47, -46, -45, -44, -43, -41, -40, -38, -37, -36, -35, -34, -32,
-31, -30, -29, -28, -27, -24, -22, -21, -17, -17, -14, -14, -9, };