#define DATA_LENGTH 512
#define DATA AKWF_1883

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 0, 1, 1, 2, 3, 2, 3, 3, 4, 4, 4,
6, 6, 6, 6, 7, 6, 8, 7, 7, 8, 8, 9, 8, 9, 9, 8, 9, 9, 9, 9, 8, 9, 9, 8, 9, 9, 8,
8, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 7, 6, 6, 6, 7, 12, 20, 26, 33, 39, 44, 49, 55,
60, 64, 67, 72, 75, 78, 82, 85, 87, 90, 92, 95, 97, 99, 101, 102, 103, 105, 107,
108, 109, 111, 112, 113, 113, 114, 112, 107, 102, 98, 93, 90, 86, 83, 80, 77,
75, 72, 73, 77, 81, 85, 86, 89, 91, 93, 95, 98, 99, 101, 102, 104, 106, 107,
108, 110, 111, 111, 112, 113, 115, 116, 115, 115, 117, 117, 118, 118, 120, 117,
107, 96, 84, 74, 63, 52, 43, 33, 23, 15, 6, -1, -8, -14, -20, -26, -33, -37,
-42, -46, -50, -55, -57, -61, -65, -67, -70, -73, -75, -77, -80, -81, -84, -85,
-87, -89, -90, -92, -92, -94, -94, -96, -97, -97, -99, -99, -100, -101, -101,
-101, -100, -97, -95, -93, -90, -89, -87, -85, -85, -87, -88, -89, -91, -93,
-93, -94, -96, -97, -98, -99, -100, -99, -101, -101, -102, -103, -104, -103,
-104, -104, -105, -105, -106, -106, -106, -107, -106, -107, -107, -107, -107,
-108, -108, -108, -108, -108, -109, -108, -108, -109, -108, -108, -108, -108,
-108, -109, -109, -109, -109, -108, -108, -108, -109, -108, -106, -104, -100,
-94, -91, -88, -82, -78, -73, -69, -63, -59, -55, -50, -47, -42, -40, -36, -33,
-31, -27, -26, -23, -22, -20, -17, -15, -13, -13, -11, -10, -8, -7, -5, -5, -3,
-4, -2, -1, 0, 1, 1, 3, 2, 3, 3, 4, 4, 4, 6, 6, 6, 6, 7, 7, 8, 8, 8, 8, 9, 9, 9,
8, 10, 10, 9, 10, 10, 10, 10, 10, 10, 11, 13, 18, 23, 27, 30, 34, 37, 37, 36,
34, 32, 32, 30, 29, 27, 27, 26, 24, 23, 23, 22, 22, 20, 20, 19, 19, 19, 18, 18,
17, 17, 17, 16, 17, 15, 15, 15, 15, 15, 14, 14, 14, 14, 14, 14, 13, 13, 13, 13,
13, 14, 13, 13, 12, 13, 13, 12, 13, 13, 12, 12, 12, 12, 12, 12, 12, 13, 13, 12,
12, 12, 9, 8, 8, 7, 6, 6, 7, 8, 8, 8, 9, 9, 8, 9, 9, 9, 10, 10, 9, 9, 10, 10,
10, 10, 10, 11, 11, 10, 11, 12, 12, 12, 12, 11, 12, 12, 11, 11, 11, 12, 13, 12,
12, 12, 12, 12, 11, 12, 11, 13, 11, 12, 12, 13, 12, 13, 13, 13, 13, 13, 13, 13,
14, 14, 13, 13, 13, 14, 13, 13, 14, 14, 13, 13, 13, 13, 14, 13, 13, 13, 12, 12,
13, 12, 12, 13, 12, 12, 12, 12, 12, 12, 12, 12, 13, 11, 12, 11, 10, 10, 10, 9,
8, 7, 7, 7, 6, 4, 5, 4, 2, 1, 2, 1, 0, 1, 0, -1, 0, 1, };