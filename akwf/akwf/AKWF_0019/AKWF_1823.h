#define DATA_LENGTH 512
#define DATA AKWF_1823

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 19, 33, 44, 54, 62, 69, 76, 79, 82,
85, 85, 86, 85, 85, 83, 83, 81, 79, 78, 76, 74, 72, 70, 68, 66, 64, 63, 61, 59,
58, 57, 54, 53, 51, 50, 49, 48, 45, 44, 44, 42, 42, 41, 40, 39, 37, 36, 36, 33,
33, 33, 32, 31, 30, 30, 28, 28, 28, 27, 26, 25, 25, 24, 24, 23, 23, 22, 21, 21,
21, 20, 19, 19, 19, 18, 18, 17, 17, 16, 16, 15, 15, 15, 14, 14, 14, 14, 14, 12,
13, 12, 12, 11, 12, 11, 11, 11, 11, 10, 9, 10, 10, 8, 9, 9, 7, 8, 8, 8, 7, 7, 7,
7, 7, 7, 7, 6, 7, 5, 6, 5, 5, 5, 4, 4, 4, 4, 4, 4, 3, 4, 4, 4, 4, 4, 3, 2, 3, 3,
2, 2, 2, 2, 2, 3, 2, 1, 2, 1, 1, 2, 2, 1, 2, 2, 1, 1, 1, 1, 1, 0, 0, 1, 0, 0, 0,
0, 1, 0, 1, 1, 1, 0, 1, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 2, 0, 3, 0, 3, 1, 4, 1, 4,
2, 5, 2, 5, 4, 6, 7, 13, 18, 27, 42, 67, 71, -80, -112, -78, -80, -120, -52, 83,
57, 41, 22, 19, 10, 9, 5, 5, 4, 4, 3, 2, 3, 2, 2, 0, 3, 0, 2, 0, 2, 0, 1, 0, 2,
0, 1, 0, 0, 1, 1, 0, 1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 2, 1,
2, 2, 1, 2, 1, 3, 2, 1, 1, 2, 2, 2, 2, 3, 2, 3, 4, 3, 4, 4, 4, 3, 4, 4, 4, 5, 5,
5, 5, 5, 6, 4, 6, 6, 6, 6, 6, 7, 6, 7, 6, 7, 7, 7, 8, 8, 7, 8, 8, 9, 10, 8, 9,
9, 10, 10, 10, 12, 11, 11, 11, 12, 11, 12, 13, 12, 14, 13, 14, 15, 15, 15, 15,
15, 16, 17, 16, 17, 18, 18, 18, 19, 19, 21, 20, 21, 22, 22, 22, 24, 23, 24, 24,
25, 26, 27, 27, 28, 29, 29, 30, 30, 32, 33, 34, 34, 36, 36, 37, 38, 39, 40, 41,
42, 44, 45, 46, 47, 48, 50, 52, 54, 54, 56, 58, 59, 62, 63, 65, 67, 68, 71, 73,
75, 76, 77, 80, 81, 83, 83, 83, 84, 82, 83, 80, 76, 72, 66, 59, 50, 39, 27, 13,
-1, -17, -31, -45, -60, -72, -82, -92, -100, -106, -111, -114, -117, -118, -119,
-120, -118, -117, -116, -115, -113, -112, -110, -108, -105, -104, -102, -100,
-99, -96, -95, -93, -91, -89, -88, -86, -85, -84, -82, -81, -80, -78, -76, -75,
-74, -73, -72, -72, -74, -75, -76, -78, -78, -79, -80, -82, -83, -85, -87, -87,
-90, -91, -93, -94, -96, -97, -99, -101, -104, -106, -107, -109, -111, -113,
-114, -116, -116, -117, -117, -117, -116, -114, -111, -107, -101, -95, -86, -76,
-64, -51, -37, -22, -7, };