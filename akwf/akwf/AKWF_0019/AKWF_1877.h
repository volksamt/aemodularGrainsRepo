#define DATA_LENGTH 512
#define DATA AKWF_1877

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 6, 8, 9, 10, 12, 14, 17, 19,
22, 25, 27, 30, 32, 34, 38, 40, 42, 44, 43, 44, 45, 46, 47, 49, 51, 53, 56, 60,
65, 71, 77, 83, 89, 93, 95, 97, 99, 99, 99, 98, 97, 96, 96, 95, 97, 98, 99, 100,
101, 104, 105, 108, 112, 115, 117, 118, 120, 119, 119, 118, 117, 115, 113, 109,
105, 102, 99, 95, 91, 89, 86, 83, 84, 81, 80, 81, 79, 77, 75, 71, 67, 63, 60,
56, 52, 48, 45, 41, 37, 34, 30, 26, 24, 19, 16, 11, 9, 5, 0, -2, -6, -8, -12,
-14, -16, -18, -20, -21, -22, -24, -27, -28, -30, -31, -33, -34, -36, -38, -40,
-40, -43, -45, -46, -47, -49, -51, -51, -49, -49, -47, -46, -43, -41, -38, -36,
-34, -33, -31, -31, -30, -30, -30, -31, -30, -30, -29, -28, -26, -25, -23, -21,
-19, -15, -13, -11, -7, -5, -3, 0, 2, 4, 5, 6, 6, 6, 7, 6, 5, 5, 4, 4, 4, 3, 5,
5, 5, 5, 7, 8, 7, 7, 7, 6, 5, 3, 3, 1, -2, -3, -5, -6, -8, -10, -12, -14, -16,
-18, -21, -23, -26, -27, -29, -32, -33, -35, -36, -37, -39, -41, -42, -44, -45,
-47, -48, -50, -51, -53, -54, -56, -57, -58, -60, -62, -63, -64, -66, -66, -67,
-67, -66, -65, -65, -64, -63, -62, -60, -58, -58, -57, -55, -55, -53, -54, -54,
-53, -53, -51, -50, -49, -48, -45, -44, -41, -38, -36, -33, -30, -27, -24, -22,
-19, -17, -13, -12, -10, -8, -8, -6, -4, -3, -2, -1, 1, 1, 3, 5, 7, 9, 12, 13,
14, 17, 19, 19, 21, 22, 22, 23, 24, 24, 23, 23, 23, 22, 23, 22, 20, 20, 19, 18,
18, 18, 17, 16, 16, 16, 15, 14, 14, 12, 10, 9, 7, 6, 3, 3, 0, -1, -3, -4, -6,
-8, -9, -10, -12, -13, -15, -17, -18, -19, -21, -22, -23, -23, -25, -25, -26,
-27, -28, -29, -29, -29, -30, -31, -32, -31, -32, -32, -32, -32, -32, -31, -31,
-30, -30, -29, -28, -26, -25, -24, -22, -21, -19, -18, -15, -14, -13, -12, -11,
-10, -9, -9, -7, -5, -3, -2, -1, 2, 4, 6, 9, 11, 13, 14, 16, 17, 18, 21, 22, 22,
23, 24, 24, 24, 25, 25, 25, 27, 27, 26, 28, 29, 29, 30, 32, 33, 33, 34, 33, 33,
34, 33, 32, 31, 30, 28, 26, 24, 24, 22, 20, 19, 16, 16, 14, 12, 11, 9, 9, 6, 4,
4, 1, 0, -2, -4, -6, -8, -10, -13, -15, -17, -20, -24, -25, -29, -31, -33, -35,
-37, -38, -40, -41, -42, -43, -44, -44, -45, -47, -47, -47, -48, -48, -49, -51,
-52, -53, -54, -54, -54, -55, -55, -55, -55, -55, -54, -52, -51, -50, -48, -47,
-44, -43, -40, -39, -36, -35, -33, -33, -31, -30, -28, -26, -25, -23, -22, -19,
-18, -16, -15, -14, -12, -10, -8, -6, -6, -4, -2, -1, };