#define DATA_LENGTH 512
#define DATA AKWF_1842

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 15, 25, 34, 43, 52, 59, 66, 71, 76,
81, 86, 90, 92, 95, 98, 101, 102, 105, 107, 108, 109, 111, 111, 113, 114, 114,
114, 115, 115, 116, 117, 117, 117, 117, 118, 118, 118, 117, 118, 118, 119, 118,
119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119, 119,
120, 118, 119, 119, 119, 120, 120, 119, 119, 119, 118, 120, 119, 120, 120, 119,
119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 120, 119, 120, 119, 119,
119, 119, 119, 119, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119,
117, 115, 111, 108, 103, 99, 95, 91, 87, 83, 80, 77, 74, 71, 68, 67, 65, 63, 61,
60, 59, 58, 56, 55, 55, 53, 52, 52, 52, 52, 51, 52, 50, 50, 51, 50, 50, 49, 49,
49, 49, 49, 48, 49, 49, 49, 49, 49, 49, 48, 48, 48, 48, 48, 48, 49, 47, 49, 48,
48, 49, 48, 49, 48, 48, 49, 48, 48, 49, 49, 48, 48, 48, 48, 48, 49, 48, 48, 49,
48, 48, 48, 48, 48, 48, 49, 48, 48, 48, 48, 49, 49, 48, 48, 48, 49, 47, 49, 48,
48, 48, 48, 49, 48, 48, 48, 49, 48, 48, 48, 48, 49, 48, 48, 48, 48, 48, 48, 49,
49, 48, 48, 48, 49, 50, 53, 56, 60, 66, 70, 74, 77, 78, 77, 72, 66, 59, 52, 45,
37, 30, 22, 16, 9, 4, -2, -6, -10, -14, -18, -22, -25, -27, -30, -31, -34, -34,
-37, -38, -40, -40, -42, -42, -42, -43, -45, -44, -45, -45, -46, -46, -46, -47,
-46, -47, -47, -48, -48, -47, -47, -47, -48, -48, -48, -47, -48, -49, -48, -48,
-48, -48, -48, -48, -48, -48, -48, -49, -49, -48, -49, -49, -48, -48, -48, -48,
-49, -48, -48, -48, -48, -49, -49, -48, -48, -49, -49, -48, -49, -47, -48, -48,
-47, -48, -48, -49, -48, -47, -48, -48, -49, -48, -49, -48, -48, -48, -48, -48,
-48, -48, -48, -48, -48, -48, -49, -48, -48, -49, -49, -48, -48, -48, -48, -48,
-48, -48, -49, -50, -53, -56, -60, -64, -68, -73, -76, -80, -84, -88, -91, -94,
-96, -99, -102, -104, -105, -107, -107, -109, -110, -111, -112, -113, -114,
-114, -115, -115, -116, -116, -116, -116, -117, -117, -117, -118, -117, -119,
-118, -118, -118, -118, -119, -119, -118, -118, -118, -119, -119, -119, -119,
-119, -118, -119, -119, -120, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -118, -120, -119, -118, -118, -119, -119, -119,
-119, -119, -119, -119, -118, -120, -119, -118, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -120, -120, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -116, -110, -100, -88, -75, -60, -46, -33,
-19, -6, };