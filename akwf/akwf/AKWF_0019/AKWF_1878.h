#define DATA_LENGTH 512
#define DATA AKWF_1878

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 5, 6, 8, 9, 11, 12, 14, 16, 19,
22, 24, 26, 28, 29, 31, 34, 36, 38, 41, 42, 44, 47, 49, 51, 54, 58, 60, 62, 63,
63, 64, 64, 65, 67, 70, 73, 73, 74, 76, 75, 74, 73, 72, 71, 69, 66, 65, 62, 61,
59, 57, 55, 50, 46, 41, 35, 29, 24, 18, 13, 9, 3, -3, -9, -15, -20, -27, -33,
-39, -44, -51, -57, -63, -69, -73, -78, -82, -87, -91, -95, -100, -103, -106,
-109, -110, -113, -114, -116, -117, -118, -119, -119, -118, -118, -117, -115,
-114, -113, -111, -108, -107, -103, -100, -98, -94, -90, -86, -82, -77, -73,
-68, -64, -60, -56, -52, -47, -43, -38, -33, -28, -23, -18, -15, -10, -7, -3, 1,
4, 8, 11, 14, 17, 20, 22, 26, 28, 29, 31, 32, 33, 33, 34, 34, 36, 36, 37, 37,
36, 36, 36, 35, 34, 35, 33, 32, 31, 29, 28, 27, 27, 26, 25, 24, 23, 20, 20, 19,
18, 17, 16, 15, 15, 14, 14, 14, 14, 13, 13, 13, 13, 14, 14, 16, 16, 17, 18, 19,
20, 22, 22, 23, 26, 27, 28, 30, 31, 32, 33, 35, 37, 38, 39, 42, 43, 44, 45, 47,
49, 50, 52, 53, 54, 55, 55, 56, 57, 56, 57, 57, 58, 58, 59, 58, 57, 57, 57, 54,
52, 52, 49, 47, 45, 43, 42, 39, 38, 36, 33, 29, 25, 22, 19, 15, 11, 8, 4, 2, -2,
-5, -9, -12, -15, -20, -22, -26, -29, -33, -35, -39, -40, -43, -44, -46, -48,
-49, -51, -52, -53, -54, -55, -56, -56, -57, -57, -57, -57, -56, -56, -54, -54,
-52, -53, -51, -50, -48, -48, -45, -44, -42, -40, -40, -38, -36, -34, -31, -29,
-27, -26, -24, -23, -20, -19, -17, -16, -13, -12, -10, -7, -5, -4, -2, -2, -1,
0, 1, 3, 4, 4, 6, 7, 8, 10, 10, 11, 11, 11, 13, 13, 14, 14, 14, 14, 14, 16, 15,
17, 17, 17, 17, 17, 17, 16, 17, 17, 17, 17, 17, 17, 17, 17, 17, 18, 18, 19, 18,
19, 20, 20, 19, 20, 20, 20, 22, 22, 23, 24, 24, 25, 24, 25, 25, 25, 26, 26, 26,
26, 27, 27, 27, 28, 27, 27, 26, 26, 26, 25, 23, 23, 24, 22, 21, 19, 19, 17, 17,
16, 14, 13, 10, 9, 7, 5, 3, 2, -1, -2, -4, -6, -8, -10, -12, -15, -17, -18, -20,
-22, -23, -24, -27, -28, -29, -30, -31, -33, -35, -35, -36, -37, -38, -38, -39,
-39, -39, -39, -38, -38, -37, -38, -37, -37, -35, -34, -32, -31, -30, -28, -26,
-24, -23, -21, -20, -17, -15, -14, -12, -10, -8, -7, -4, -2, 0, 1, 3, 3, 6, 6,
7, 7, 8, 9, 11, 10, 11, 12, 12, 12, 11, 11, 10, 10, 9, 9, 8, 7, 6, 5, 5, 4, 4,
3, 3, 2, 0, -1, -3, -3, -4, -3, -4, -5, -4, -5, -5, -4, -4, -3, -3, -3, -2, 0,
};