#define DATA_LENGTH 512
#define DATA AKWF_1839

const PROGMEM int8_t DATA[DATA_LENGTH] = {22, 34, 32, 33, 32, 33, 32, 33, 24,
19, 22, 21, 20, 21, 23, 29, 34, 33, 33, 33, 33, 33, 33, 33, 33, 32, 33, 33, 33,
32, 33, 39, 45, 43, 44, 44, 44, 44, 44, 44, 46, 48, 48, 48, 47, 48, 47, 54, 60,
60, 60, 60, 60, 61, 60, 60, 59, 59, 58, 60, 59, 60, 58, 59, 61, 62, 61, 61, 61,
61, 62, 62, 65, 67, 66, 66, 66, 67, 67, 72, 82, 84, 83, 84, 83, 83, 83, 84, 84,
83, 84, 84, 84, 84, 84, 84, 86, 86, 87, 86, 86, 86, 86, 86, 70, 62, 65, 63, 64,
64, 64, 63, 65, 65, 65, 64, 65, 66, 65, 63, 46, 43, 43, 44, 44, 44, 42, 63, 110,
118, 115, 117, 116, 116, 116, 116, 117, 117, 118, 118, 117, 118, 111, 72, 52,
57, 56, 56, 56, 57, 55, 57, 58, 58, 58, 58, 59, 58, 58, 57, 56, 57, 56, 56, 56,
55, 56, 55, 56, 55, 56, 55, 56, 56, 55, 51, 46, 44, 44, 44, 44, 44, 43, 44, 48,
47, 48, 48, 47, 48, 49, 42, 27, 26, 26, 26, 26, 26, 26, 25, 23, 23, 22, 22, 22,
23, 21, 10, 2, 3, 3, 3, 2, 3, 3, 5, 15, 16, 16, 16, 15, 16, 15, 3, -1, 2, 1, 1,
1, 1, 2, 0, -1, -1, -3, -2, -2, -2, -2, -6, -16, -20, -18, -20, -19, -19, -19,
-20, -28, -28, -29, -28, -30, -29, -29, -27, 6, 15, 12, 14, 12, 13, 13, 14, 3,
0, 1, 1, 0, 1, 1, -2, -3, -3, -3, -3, -3, -3, -3, -4, -4, -5, -4, -4, -4, -5,
-4, -6, -6, -7, -6, -7, -6, -7, -7, -6, -4, -4, -3, -4, -3, -3, -3, -8, -15,
-15, -15, -15, -15, -16, -16, -15, -17, -16, -16, -16, -17, -16, -16, -19, -23,
-24, -23, -24, -24, -24, -24, -24, -20, -18, -19, -18, -19, -18, -21, -21, -14,
-14, -14, -13, -14, -14, -15, -14, -13, -14, -14, -14, -14, -14, -14, -16, -18,
-17, -17, -17, -17, -17, -18, -18, -35, -41, -38, -39, -39, -39, -39, -67, -95,
-95, -96, -96, -95, -96, -95, -99, -116, -117, -116, -117, -116, -116, -115,
-114, -108, -106, -106, -106, -106, -105, -106, -106, -104, -104, -104, -104,
-104, -104, -104, -101, -98, -97, -98, -96, -97, -97, -97, -96, -95, -95, -95,
-95, -95, -95, -94, -89, -86, -87, -87, -86, -87, -87, -87, -87, -88, -88, -87,
-87, -88, -88, -87, -81, -75, -76, -76, -76, -76, -77, -76, -76, -73, -73, -73,
-72, -72, -72, -72, -69, -67, -67, -67, -68, -67, -67, -68, -68, -70, -71, -70,
-70, -71, -71, -69, -67, -67, -67, -67, -67, -68, -67, -68, -65, -55, -55, -55,
-54, -55, -55, -53, -39, -24, -25, -24, -25, -24, -25, -24, -25, -27, -27, -27,
-27, -27, -27, -27, -18, -15, -17, -16, -17, -17, -17, -17, -19, -28, -28, -28,
-27, -28, -27, -28, -18, };