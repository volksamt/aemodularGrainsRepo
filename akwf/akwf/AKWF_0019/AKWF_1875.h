#define DATA_LENGTH 512
#define DATA AKWF_1875

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 2, 3, 5, 7, 9, 10, 11, 13, 14, 16,
17, 19, 20, 21, 22, 23, 25, 26, 26, 27, 28, 29, 29, 30, 30, 31, 31, 32, 33, 32,
33, 33, 32, 32, 31, 32, 32, 31, 32, 31, 30, 30, 29, 29, 28, 28, 28, 27, 26, 25,
24, 24, 23, 22, 22, 21, 21, 20, 18, 18, 18, 17, 16, 17, 15, 15, 15, 15, 14, 14,
14, 14, 13, 12, 13, 13, 13, 14, 13, 13, 14, 14, 14, 13, 14, 15, 15, 15, 17, 17,
18, 18, 18, 19, 20, 21, 21, 23, 23, 23, 24, 25, 26, 27, 28, 28, 29, 30, 30, 31,
32, 32, 33, 34, 34, 35, 35, 37, 37, 37, 37, 39, 39, 40, 40, 41, 41, 42, 44, 43,
44, 44, 46, 45, 46, 47, 47, 47, 47, 48, 49, 49, 49, 49, 49, 49, 49, 50, 50, 51,
50, 51, 50, 51, 52, 51, 51, 51, 51, 51, 52, 52, 51, 52, 53, 53, 53, 53, 54, 53,
54, 54, 55, 55, 55, 55, 55, 54, 55, 54, 54, 54, 54, 54, 53, 53, 53, 52, 53, 51,
51, 51, 51, 51, 50, 51, 49, 49, 48, 46, 44, 42, 39, 36, 33, 30, 26, 22, 17, 12,
7, 3, -2, -8, -13, -18, -23, -29, -33, -39, -44, -49, -54, -57, -62, -66, -70,
-74, -77, -80, -83, -86, -89, -92, -94, -97, -100, -102, -104, -106, -108, -110,
-112, -114, -116, -116, -117, -118, -118, -119, -120, -118, -119, -117, -117,
-117, -114, -112, -111, -107, -104, -102, -99, -95, -92, -88, -85, -80, -76,
-71, -68, -64, -61, -56, -51, -48, -45, -41, -36, -33, -29, -25, -21, -19, -14,
-12, -9, -6, -3, 0, 2, 5, 8, 10, 13, 15, 18, 20, 23, 24, 25, 27, 29, 30, 30, 31,
31, 32, 31, 32, 31, 30, 29, 28, 28, 26, 24, 22, 20, 18, 15, 13, 10, 8, 5, 2, 0,
-2, -6, -8, -10, -14, -16, -18, -20, -23, -26, -28, -31, -33, -36, -39, -41,
-42, -44, -46, -49, -50, -51, -53, -54, -57, -58, -59, -59, -61, -61, -62, -61,
-62, -62, -63, -61, -61, -61, -60, -58, -57, -56, -54, -53, -51, -49, -47, -45,
-43, -39, -38, -35, -33, -31, -28, -26, -23, -20, -18, -15, -14, -10, -7, -5,
-2, 0, 2, 5, 7, 9, 12, 14, 16, 18, 21, 23, 24, 27, 29, 29, 32, 33, 35, 36, 37,
39, 39, 39, 41, 40, 41, 42, 42, 41, 41, 41, 40, 40, 39, 39, 38, 37, 37, 35, 34,
33, 32, 30, 29, 28, 26, 24, 23, 20, 20, 17, 16, 14, 12, 11, 9, 7, 6, 3, 2, -1,
-2, -4, -6, -8, -9, -12, -13, -15, -16, -18, -20, -20, -21, -24, -24, -25, -27,
-27, -28, -28, -29, -31, -31, -31, -32, -32, -32, -32, -32, -33, -33, -32, -31,
-30, -31, -29, -29, -28, -27, -26, -25, -24, -23, -21, -20, -19, -18, -17, -15,
-14, -12, -11, -9, -8, -5, -4, -2, -1, };