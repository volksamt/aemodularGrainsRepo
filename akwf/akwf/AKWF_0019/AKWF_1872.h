#define DATA_LENGTH 512
#define DATA AKWF_1872

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 10, 15, 19, 24, 28, 34, 37, 42,
46, 51, 55, 60, 63, 67, 71, 74, 78, 81, 84, 87, 90, 93, 96, 98, 101, 103, 105,
106, 109, 110, 111, 113, 114, 115, 116, 117, 116, 117, 118, 118, 118, 118, 117,
117, 116, 114, 113, 112, 110, 109, 108, 106, 105, 103, 101, 99, 97, 95, 92, 90,
87, 85, 82, 80, 77, 74, 72, 69, 66, 63, 60, 57, 54, 52, 48, 45, 43, 41, 38, 34,
31, 28, 27, 24, 21, 17, 14, 12, 9, 5, 2, -1, -5, -8, -11, -15, -18, -22, -25,
-28, -32, -36, -39, -42, -47, -50, -53, -57, -60, -63, -66, -69, -73, -75, -78,
-82, -84, -87, -90, -92, -95, -97, -98, -101, -103, -104, -106, -108, -110,
-111, -112, -113, -114, -116, -116, -116, -118, -118, -119, -118, -118, -119,
-119, -119, -119, -118, -118, -117, -116, -115, -115, -114, -113, -112, -111,
-109, -107, -106, -104, -103, -101, -99, -98, -95, -94, -92, -90, -88, -87, -84,
-83, -79, -78, -76, -74, -72, -70, -67, -66, -63, -62, -59, -57, -56, -53, -51,
-49, -46, -45, -42, -39, -36, -33, -30, -28, -24, -22, -19, -15, -12, -9, -6,
-2, 1, 4, 7, 10, 14, 16, 20, 24, 27, 30, 32, 35, 38, 42, 44, 48, 50, 52, 55, 57,
60, 62, 65, 67, 69, 71, 73, 75, 76, 78, 79, 80, 82, 82, 84, 84, 86, 86, 88, 87,
88, 88, 88, 88, 88, 89, 88, 87, 87, 87, 87, 85, 84, 83, 83, 82, 81, 80, 79, 77,
76, 75, 73, 71, 70, 67, 66, 64, 63, 61, 60, 58, 56, 54, 52, 51, 48, 47, 45, 43,
40, 39, 37, 36, 34, 31, 30, 28, 26, 23, 22, 21, 19, 18, 16, 14, 14, 12, 11, 10,
8, 7, 6, 5, 4, 3, 1, 1, 0, -1, -1, -2, -2, -3, -3, -4, -4, -4, -4, -5, -5, -4,
-4, -4, -4, -4, -4, -2, -2, -2, -2, -1, 0, 0, 0, 1, 2, 3, 4, 4, 5, 7, 7, 8, 9,
10, 11, 12, 13, 15, 16, 17, 18, 18, 20, 21, 22, 23, 25, 25, 27, 28, 28, 30, 30,
32, 32, 33, 35, 35, 36, 38, 38, 38, 39, 40, 41, 42, 43, 43, 43, 45, 45, 46, 47,
47, 48, 47, 47, 48, 48, 49, 49, 49, 49, 48, 48, 48, 47, 46, 45, 44, 43, 41, 40,
39, 37, 35, 33, 31, 29, 26, 23, 21, 18, 15, 11, 9, 6, 3, 0, -4, -7, -10, -14,
-17, -20, -24, -27, -31, -34, -38, -41, -44, -48, -51, -54, -58, -61, -64, -67,
-70, -72, -76, -79, -82, -84, -87, -90, -92, -94, -96, -99, -100, -102, -104,
-106, -108, -109, -109, -111, -112, -113, -115, -116, -116, -116, -117, -117,
-118, -117, -117, -117, -117, -116, -115, -114, -113, -111, -109, -107, -104,
-102, -99, -96, -94, -91, -86, -83, -80, -76, -72, -68, -64, -60, -56, -51, -47,
-42, -37, -32, -28, -24, -18, -14, -9, -4, };