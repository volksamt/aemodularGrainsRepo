#define DATA_LENGTH 512
#define DATA AKWF_1891

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 6, 7, 8, 10, 10, 11, 11,
12, 13, 14, 15, 17, 17, 18, 20, 21, 21, 23, 24, 25, 27, 27, 28, 29, 30, 32, 33,
33, 34, 36, 36, 38, 39, 40, 40, 42, 43, 43, 45, 46, 48, 50, 52, 53, 56, 56, 59,
60, 61, 63, 64, 66, 67, 69, 70, 71, 73, 74, 76, 77, 79, 79, 82, 83, 84, 86, 88,
89, 91, 93, 94, 95, 97, 98, 99, 101, 102, 102, 102, 103, 104, 105, 106, 106,
107, 108, 109, 110, 110, 111, 111, 112, 113, 114, 115, 116, 117, 117, 118, 118,
118, 119, 119, 119, 119, 117, 117, 117, 116, 115, 114, 114, 114, 113, 112, 111,
111, 110, 110, 109, 109, 108, 107, 106, 106, 105, 105, 104, 103, 102, 101, 102,
100, 99, 97, 96, 94, 92, 90, 88, 87, 86, 84, 82, 81, 79, 78, 76, 75, 74, 72, 71,
69, 67, 66, 64, 62, 61, 60, 58, 57, 55, 54, 51, 50, 48, 46, 45, 44, 42, 42, 42,
40, 39, 39, 37, 37, 36, 34, 34, 33, 32, 31, 30, 29, 28, 27, 26, 26, 25, 24, 24,
22, 21, 19, 20, 19, 19, 18, 19, 18, 19, 19, 19, 18, 18, 18, 18, 18, 18, 18, 17,
17, 18, 17, 17, 17, 17, 16, 17, 17, 16, 17, 16, 16, 16, 16, 16, 17, 16, 16, 16,
16, 15, 14, 13, 13, 13, 12, 11, 11, 11, 9, 9, 9, 8, 8, 7, 7, 7, 5, 5, 4, 3, 4,
3, 1, 1, 1, -1, 0, -2, -3, -4, -4, -5, -7, -7, -7, -9, -9, -11, -11, -12, -13,
-13, -14, -15, -15, -16, -17, -18, -19, -19, -20, -21, -22, -23, -23, -24, -24,
-25, -26, -28, -27, -28, -27, -28, -27, -27, -27, -27, -29, -29, -29, -29, -30,
-30, -30, -30, -31, -30, -31, -31, -31, -32, -31, -33, -32, -33, -33, -33, -33,
-33, -33, -33, -33, -34, -33, -34, -35, -35, -36, -38, -38, -39, -39, -40, -40,
-41, -42, -43, -43, -44, -45, -45, -45, -47, -47, -48, -49, -49, -50, -51, -51,
-52, -53, -54, -56, -57, -58, -60, -62, -64, -65, -67, -68, -70, -71, -73, -74,
-75, -76, -78, -80, -81, -81, -83, -84, -86, -87, -87, -90, -91, -92, -93, -96,
-97, -98, -99, -102, -102, -103, -104, -104, -105, -107, -106, -108, -108, -108,
-108, -109, -110, -110, -110, -112, -112, -112, -113, -113, -113, -115, -114,
-115, -116, -116, -117, -116, -117, -116, -116, -117, -115, -115, -114, -113,
-112, -112, -111, -110, -108, -107, -107, -105, -105, -104, -103, -103, -101,
-100, -99, -99, -98, -97, -95, -95, -93, -93, -91, -91, -89, -88, -87, -84, -83,
-81, -79, -77, -75, -74, -72, -70, -68, -67, -65, -63, -62, -61, -58, -57, -54,
-52, -52, -50, -48, -45, -44, -42, -41, -39, -37, -35, -33, -30, -30, -28, -26,
-25, -23, -22, -22, -20, -18, -17, -16, -15, -14, -13, -11, -9, -7, -7, -6, -4,
-3, -2, 0, };