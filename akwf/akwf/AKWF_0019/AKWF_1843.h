#define DATA_LENGTH 512
#define DATA AKWF_1843

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 29, 46, 59, 69, 79, 86, 92, 97,
101, 104, 107, 110, 111, 112, 114, 115, 115, 116, 116, 117, 117, 118, 118, 118,
119, 118, 119, 118, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 120,
118, 119, 119, 120, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 118, 119, 119, 118, 118, 119,
119, 119, 118, 118, 118, 118, 118, 118, 118, 118, 118, 119, 118, 119, 119, 118,
118, 118, 119, 118, 118, 118, 118, 118, 118, 119, 118, 119, 118, 117, 118, 119,
118, 119, 118, 119, 118, 117, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118,
118, 118, 117, 118, 119, 118, 118, 118, 118, 118, 118, 119, 118, 118, 117, 118,
118, 118, 117, 118, 118, 117, 118, 118, 117, 118, 117, 117, 118, 117, 118, 118,
118, 117, 117, 117, 117, 118, 117, 117, 118, 117, 117, 117, 117, 117, 117, 118,
117, 116, 117, 118, 117, 116, 116, 117, 116, 117, 117, 117, 117, 116, 117, 117,
118, 116, 117, 116, 117, 117, 118, 116, 117, 117, 117, 117, 116, 116, 117, 117,
116, 117, 117, 116, 116, 117, 117, 117, 117, 116, 117, 116, 116, 117, 117, 117,
116, 117, 117, 116, 117, 116, 116, 116, 116, 116, 116, 117, 116, 116, 116, 116,
116, 116, 116, 116, 116, 116, 116, 115, 116, 116, 116, 115, 116, 117, 117, 115,
117, 116, 117, 115, 116, 105, 67, 32, 5, -18, -36, -51, -63, -74, -82, -88, -93,
-98, -102, -105, -108, -110, -111, -113, -114, -116, -116, -116, -117, -117,
-117, -118, -119, -118, -119, -118, -119, -119, -119, -120, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -120, -120, -119, -119, -119, -119, -119, -119, -119, -118, -118, -119,
-119, -118, -119, -118, -119, -119, -118, -119, -119, -119, -118, -119, -118,
-118, -119, -118, -119, -119, -119, -119, -118, -118, -119, -119, -119, -118,
-119, -118, -119, -118, -118, -118, -118, -118, -118, -118, -117, -118, -118,
-119, -118, -118, -118, -117, -118, -118, -118, -118, -118, -117, -118, -118,
-117, -118, -118, -117, -118, -117, -119, -118, -118, -118, -118, -118, -117,
-118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -117, -117, -117,
-117, -118, -118, -117, -118, -118, -118, -117, -118, -118, -118, -117, -117,
-117, -117, -117, -117, -118, -117, -117, -117, -117, -117, -118, -117, -117,
-117, -117, -117, -118, -117, -117, -118, -117, -117, -117, -117, -117, -118,
-118, -117, -118, -117, -116, -117, -117, -117, -117, -117, -117, -117, -117,
-117, -116, -116, -117, -116, -117, -116, -117, -116, -117, -116, -117, -116,
-116, -116, -116, -117, -117, -116, -116, -116, -117, -116, -116, -116, -116,
-116, -117, -116, -116, -116, -116, -117, -116, -115, -117, -117, -116, -116,
-116, -116, -116, -116, -117, -116, -116, -116, -116, -116, -116, -116, -117,
-115, -116, -115, -116, -116, -117, -116, -116, -109, -75, -38, -11, };