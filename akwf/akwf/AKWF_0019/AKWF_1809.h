#define DATA_LENGTH 512
#define DATA AKWF_1809

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 12, 18, 24, 30, 36, 40, 43, 44, 46,
51, 58, 64, 72, 79, 86, 93, 97, 99, 99, 97, 93, 91, 87, 83, 77, 68, 58, 49, 43,
41, 42, 47, 52, 57, 62, 66, 74, 82, 90, 97, 103, 107, 109, 111, 109, 106, 104,
102, 101, 101, 101, 103, 103, 102, 103, 103, 102, 101, 99, 97, 94, 90, 88, 85,
81, 76, 71, 66, 61, 57, 52, 47, 43, 40, 36, 35, 35, 35, 33, 33, 32, 32, 33, 34,
33, 34, 32, 31, 31, 29, 30, 30, 29, 30, 28, 27, 25, 22, 20, 17, 15, 14, 13, 12,
11, 12, 11, 11, 9, 10, 11, 12, 11, 10, 9, 10, 12, 12, 13, 13, 16, 19, 21, 23,
23, 24, 24, 28, 30, 32, 34, 37, 40, 42, 44, 46, 48, 50, 50, 51, 51, 52, 54, 56,
56, 58, 60, 61, 62, 63, 63, 64, 66, 67, 68, 70, 72, 74, 76, 79, 80, 80, 80, 80,
80, 81, 80, 81, 82, 82, 85, 86, 86, 87, 86, 86, 86, 85, 84, 84, 86, 87, 87, 87,
86, 85, 85, 83, 80, 77, 75, 72, 71, 69, 69, 68, 68, 64, 61, 58, 58, 58, 58, 57,
55, 52, 50, 49, 47, 45, 43, 44, 45, 43, 40, 37, 34, 31, 28, 25, 25, 25, 25, 23,
19, 17, 16, 15, 15, 13, 11, 9, 9, 8, 5, 0, -4, -6, -5, -4, -5, -8, -11, -13,
-12, -12, -17, -23, -30, -32, -29, -26, -26, -26, -24, -23, -25, -29, -39, -43,
-42, -36, -33, -36, -40, -43, -43, -43, -44, -47, -48, -45, -42, -42, -47, -54,
-59, -62, -61, -57, -54, -52, -52, -54, -56, -55, -52, -48, -47, -51, -56, -62,
-67, -71, -74, -75, -71, -64, -55, -48, -46, -48, -52, -53, -56, -61, -69, -77,
-78, -69, -56, -46, -42, -44, -48, -51, -59, -72, -83, -85, -74, -59, -45, -38,
-36, -35, -35, -38, -44, -50, -54, -56, -57, -61, -67, -72, -73, -65, -54, -40,
-29, -23, -22, -27, -34, -44, -51, -57, -59, -58, -52, -45, -36, -28, -21, -15,
-11, -10, -14, -24, -37, -50, -57, -59, -58, -56, -52, -49, -41, -31, -23, -17,
-17, -16, -18, -20, -27, -34, -37, -37, -31, -24, -21, -24, -33, -44, -54, -62,
-67, -68, -64, -56, -47, -38, -30, -21, -12, -4, 2, 4, -2, -11, -24, -36, -46,
-53, -58, -63, -70, -78, -87, -90, -89, -83, -76, -71, -66, -62, -59, -57, -59,
-62, -64, -64, -59, -53, -46, -36, -29, -22, -18, -20, -27, -37, -52, -66, -76,
-81, -80, -74, -66, -55, -50, -48, -52, -60, -66, -72, -74, -73, -69, -67, -64,
-62, -64, -68, -72, -78, -84, -92, -98, -104, -111, -116, -118, -118, -115,
-107, -95, -79, -62, -42, -26, -14, -8, -9, -11, -12, -14, -20, -27, -32, -33,
-31, -27, -25, -27, -34, -42, -53, -63, -71, -74, -74, -68, -63, -56, -49, -43,
-37, -32, -28, -26, -25, -24, -23, -22, -17, -14, -6, 0, };