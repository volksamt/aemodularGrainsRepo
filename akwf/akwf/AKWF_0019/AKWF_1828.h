#define DATA_LENGTH 512
#define DATA AKWF_1828

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 3, 4, 5, 5, 5, 5, 7, 7, 9, 8,
9, 10, 11, 10, 11, 13, 12, 13, 13, 13, 14, 14, 14, 15, 15, 15, 16, 16, 16, 16,
17, 16, 18, 18, 17, 18, 19, 19, 20, 19, 19, 20, 20, 19, 19, 20, 20, 19, 20, 20,
20, 20, 20, 20, 20, 21, 21, 20, 20, 20, 21, 20, 21, 20, 20, 20, 21, 21, 20, 21,
20, 21, 20, 20, 20, 20, 19, 21, 20, 20, 20, 20, 20, 19, 19, 20, 20, 20, 19, 19,
19, 19, 18, 19, 18, 19, 18, 19, 18, 18, 18, 18, 18, 18, 18, 18, 18, 18, 17, 17,
18, 17, 17, 17, 17, 16, 16, 16, 16, 17, 17, 16, 16, 16, 16, 16, 16, 16, 16, 15,
15, 15, 15, 15, 16, 15, 15, 15, 14, 14, 14, 14, 14, 14, 14, 14, 13, 13, 13, 14,
13, 13, 14, 13, 13, 13, 13, 12, 13, 12, 12, 12, 12, 12, 13, 11, 13, 11, 11, 12,
11, 11, 12, 11, 11, 11, 11, 11, 11, 11, 11, 11, 10, 10, 10, 11, 10, 11, 4, 10,
49, 72, 79, 84, 83, 84, 81, 80, 77, 76, 73, 71, 69, 67, 66, 64, 62, 61, 58, 56,
55, 53, 51, 50, 49, 48, 46, 45, 43, 42, 41, 40, 38, 38, 36, 35, 34, 33, 31, 30,
30, 29, 28, 27, 27, 25, 25, 24, 23, 22, 23, 21, 20, 19, 19, 28, 61, 77, 64, 55,
50, 48, 45, 43, 43, 41, 40, 39, 38, 37, 36, 35, 35, 33, 33, 33, 32, 31, 29, 29,
29, 29, 27, 27, 26, 26, 26, 25, 24, 23, 23, 23, 22, 23, 22, 21, 21, 20, 20, 20,
20, 19, 19, 18, 19, 19, 17, 18, 17, 18, 17, 17, 17, 17, 16, 16, 16, 16, 15, 16,
16, 15, 15, 16, 16, 15, 15, 15, 15, 15, 15, 15, 15, 15, 15, 15, 15, 14, 14, 14,
15, 15, 15, 15, 14, 15, 15, 15, 15, 15, 15, 15, 15, 15, 15, 14, 14, 14, 14, 14,
14, 14, 13, 13, 13, 12, 12, 12, 12, 11, 11, 11, 10, 10, 9, 8, 8, 6, 6, 5, 4, 2,
2, 1, 0, -1, -2, -5, -6, -8, -9, -11, -13, -14, -17, -19, -21, -23, -26, -28,
-31, -34, -36, -39, -42, -45, -48, -52, -54, -57, -60, -63, -66, -70, -73, -76,
-79, -81, -85, -88, -91, -94, -96, -99, -101, -103, -105, -107, -108, -111,
-112, -113, -115, -116, -117, -118, -118, -119, -119, -119, -118, -118, -118,
-118, -118, -116, -116, -115, -114, -114, -111, -111, -109, -108, -106, -104,
-103, -101, -98, -97, -95, -92, -91, -88, -88, -85, -83, -81, -79, -77, -75,
-72, -70, -68, -66, -65, -62, -59, -57, -55, -55, -52, -50, -49, -46, -44, -42,
-41, -39, -38, -36, -34, -32, -31, -29, -27, -26, -25, -23, -21, -20, -18, -17,
-16, -15, -15, -13, -12, -10, -9, -8, -7, -6, -5, -4, -3, -3, -1, 0, };