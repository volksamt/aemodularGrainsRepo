#define DATA_LENGTH 512
#define DATA AKWF_1855

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 5, 7, 8, 10, 12, 13, 15, 16,
17, 18, 20, 21, 23, 24, 25, 26, 28, 28, 29, 30, 32, 32, 34, 35, 35, 37, 38, 39,
39, 41, 42, 43, 43, 44, 45, 46, 47, 48, 49, 49, 50, 50, 52, 52, 53, 53, 55, 55,
55, 56, 57, 58, 59, 60, 60, 61, 61, 62, 62, 63, 64, 65, 65, 66, 66, 66, 68, 68,
68, 68, 70, 70, 70, 71, 71, 72, 72, 73, 73, 74, 75, 75, 76, 76, 77, 77, 77, 77,
79, 78, 79, 79, 80, 79, 80, 81, 81, 82, 82, 83, 83, 83, 84, 84, 84, 85, 86, 85,
86, 86, 87, 87, 87, 88, 88, 89, 89, 90, 89, 91, 91, 91, 92, 92, 91, 93, 92, 94,
93, 94, 94, 94, 95, 95, 96, 96, 96, 96, 97, 97, 98, 97, 98, 98, 98, 99, 99, 100,
100, 100, 100, 101, 100, 102, 102, 101, 103, 101, 102, 103, 103, 103, 104, 103,
105, 104, 104, 105, 105, 105, 106, 105, 106, 106, 107, 107, 108, 107, 108, 108,
108, 108, 109, 108, 108, 109, 109, 110, 110, 110, 111, 110, 111, 112, 111, 112,
112, 113, 113, 113, 113, 113, 113, 113, 114, 114, 114, 114, 114, 115, 114, 114,
115, 115, 115, 115, 116, 116, 116, 116, 116, 117, 117, 117, 118, 118, 117, 118,
118, 118, 118, 118, 119, 119, 119, 119, 119, 119, 116, 108, 96, 83, 72, 62, 53,
43, 34, 26, 18, 11, 4, -3, -9, -15, -21, -26, -32, -36, -41, -44, -48, -52, -55,
-59, -63, -65, -68, -71, -73, -77, -79, -81, -82, -84, -86, -87, -89, -90, -92,
-94, -94, -95, -96, -97, -99, -99, -99, -101, -100, -101, -102, -103, -104,
-103, -104, -105, -105, -104, -105, -105, -105, -106, -106, -106, -107, -106,
-106, -107, -106, -107, -106, -106, -107, -106, -107, -107, -106, -107, -105,
-106, -105, -106, -106, -106, -105, -104, -104, -104, -104, -104, -104, -104,
-104, -103, -103, -103, -103, -102, -102, -101, -102, -101, -101, -100, -100,
-100, -99, -99, -99, -99, -98, -99, -97, -98, -97, -98, -96, -96, -96, -96, -95,
-95, -95, -94, -93, -94, -94, -93, -92, -92, -92, -92, -92, -91, -90, -91, -90,
-90, -89, -89, -88, -89, -88, -87, -87, -86, -87, -86, -86, -86, -84, -84, -84,
-84, -84, -83, -82, -82, -81, -81, -80, -81, -81, -80, -79, -79, -79, -77, -77,
-77, -77, -76, -76, -76, -76, -75, -75, -74, -73, -73, -72, -73, -71, -71, -71,
-70, -70, -69, -69, -69, -68, -68, -67, -66, -67, -65, -65, -65, -64, -63, -63,
-62, -62, -62, -61, -61, -59, -60, -59, -58, -58, -58, -57, -56, -55, -55, -55,
-54, -54, -53, -52, -52, -51, -50, -49, -49, -48, -48, -48, -46, -45, -45, -44,
-44, -43, -43, -41, -41, -40, -39, -38, -38, -37, -35, -35, -35, -33, -32, -31,
-30, -30, -28, -27, -26, -24, -23, -21, -20, -18, -15, -14, -12, -10, -9, -7,
-6, -4, -2, 0, };