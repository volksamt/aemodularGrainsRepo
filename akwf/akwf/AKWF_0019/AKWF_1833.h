#define DATA_LENGTH 512
#define DATA AKWF_1833

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 7, 10, 14, 16, 19, 22, 24, 27,
29, 32, 35, 37, 40, 43, 45, 48, 50, 52, 55, 57, 59, 63, 64, 67, 68, 71, 73, 75,
77, 79, 81, 82, 84, 86, 88, 89, 91, 93, 94, 96, 97, 99, 99, 102, 103, 103, 104,
105, 107, 107, 108, 109, 111, 111, 111, 112, 114, 114, 115, 115, 115, 116, 117,
117, 117, 117, 117, 118, 118, 118, 119, 118, 118, 119, 120, 119, 120, 119, 119,
119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 118, 117, 118, 118, 118,
118, 118, 118, 118, 117, 117, 116, 116, 116, 116, 115, 115, 115, 114, 114, 114,
113, 114, 113, 113, 112, 112, 112, 111, 110, 110, 109, 108, 108, 107, 106, 106,
105, 105, 104, 103, 102, 101, 100, 100, 98, 98, 96, 95, 93, 94, 92, 91, 90, 88,
87, 86, 85, 83, 83, 80, 79, 77, 76, 74, 73, 71, 69, 68, 65, 63, 61, 60, 59, 57,
55, 53, 51, 49, 47, 45, 42, 41, 38, 36, 34, 32, 30, 28, 27, 24, 22, 20, 19, 17,
15, 12, 9, 8, 6, 4, 2, 0, -2, -5, -6, -8, -9, -12, -14, -15, -17, -19, -20, -22,
-24, -25, -27, -29, -30, -31, -32, -34, -35, -36, -38, -38, -39, -41, -41, -42,
-44, -44, -45, -45, -46, -46, -46, -46, -46, -47, -47, -47, -47, -47, -47, -47,
-47, -46, -45, -46, -45, -45, -44, -43, -43, -43, -43, -41, -40, -40, -39, -39,
-38, -37, -37, -36, -35, -35, -34, -33, -32, -32, -32, -30, -30, -30, -28, -28,
-27, -26, -26, -25, -26, -25, -24, -24, -23, -23, -22, -22, -21, -21, -21, -21,
-21, -20, -20, -19, -20, -19, -19, -19, -19, -19, -20, -19, -19, -20, -20, -20,
-19, -20, -20, -20, -21, -22, -22, -22, -22, -23, -23, -23, -25, -25, -26, -26,
-27, -27, -27, -29, -30, -30, -31, -32, -32, -33, -35, -35, -36, -36, -38, -38,
-39, -40, -41, -41, -42, -43, -44, -44, -45, -46, -46, -48, -47, -48, -49, -50,
-49, -50, -50, -50, -51, -51, -51, -52, -52, -52, -52, -51, -52, -51, -52, -51,
-52, -51, -51, -52, -50, -51, -51, -51, -50, -51, -50, -50, -49, -49, -50, -50,
-50, -49, -50, -50, -49, -50, -49, -50, -50, -49, -50, -50, -49, -50, -50, -50,
-50, -50, -50, -51, -51, -51, -50, -51, -51, -52, -52, -52, -54, -54, -53, -54,
-55, -54, -56, -55, -55, -56, -57, -56, -57, -58, -59, -58, -59, -60, -60, -60,
-61, -61, -62, -62, -63, -63, -63, -64, -65, -65, -67, -66, -67, -67, -68, -68,
-68, -69, -70, -69, -70, -70, -71, -71, -71, -73, -72, -72, -72, -72, -72, -73,
-73, -73, -72, -72, -72, -72, -71, -71, -70, -71, -69, -69, -68, -66, -66, -66,
-64, -63, -62, -61, -60, -58, -57, -56, -53, -52, -50, -48, -46, -45, -43, -41,
-39, -37, -34, -33, -30, -28, -26, -24, -21, -18, -16, -13, -11, -8, -5, -3, 0,
};