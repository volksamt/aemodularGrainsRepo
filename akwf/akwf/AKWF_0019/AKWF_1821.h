#define DATA_LENGTH 512
#define DATA AKWF_1821

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 23, 47, 69, 86, 99, 109, 114, 117,
119, 119, 117, 115, 113, 109, 106, 104, 101, 98, 96, 93, 89, 88, 86, 83, 81, 79,
77, 75, 75, 72, 70, 70, 68, 67, 66, 64, 63, 62, 61, 60, 60, 58, 57, 56, 56, 55,
54, 53, 52, 53, 52, 51, 51, 50, 50, 49, 48, 48, 47, 47, 47, 47, 46, 45, 44, 44,
43, 44, 43, 43, 43, 42, 41, 42, 41, 42, 41, 40, 40, 39, 40, 39, 39, 38, 39, 37,
39, 37, 38, 36, 38, 35, 38, 35, 38, 35, 38, 34, 40, 20, -50, 8, 42, 33, 39, 34,
38, 35, 37, 35, 38, 36, 38, 37, 38, 37, 39, 38, 38, 39, 39, 39, 40, 39, 41, 41,
40, 41, 40, 42, 41, 42, 42, 43, 43, 43, 43, 44, 45, 45, 45, 45, 46, 47, 47, 48,
48, 48, 50, 50, 50, 51, 52, 51, 53, 53, 54, 55, 56, 56, 58, 58, 59, 60, 62, 62,
63, 65, 66, 67, 68, 70, 71, 72, 75, 77, 79, 80, 82, 84, 87, 90, 93, 94, 97, 101,
103, 106, 109, 111, 114, 115, 115, 115, 112, 105, 96, 84, 68, 46, 24, 0, -22,
-40, -55, -67, -74, -79, -82, -81, -81, -78, -76, -73, -70, -68, -64, -62, -59,
-56, -53, -51, -49, -46, -44, -42, -40, -39, -37, -37, -37, -36, -36, -36, -36,
-36, -37, -36, -37, -36, -36, -35, -37, -36, -36, -37, -36, -35, -35, -36, -35,
-35, -36, -36, -37, -37, -36, -36, -37, -35, -36, -36, -37, -36, -36, -36, -36,
-36, -36, -35, -36, -36, -36, -36, -35, -35, -36, -35, -36, -35, -36, -35, -36,
-36, -35, -36, -35, -36, -35, -36, -36, -35, -35, -35, -35, -36, -35, -36, -35,
-36, -35, -36, -36, -35, -36, -36, -35, -36, -36, -36, -36, -36, -35, -35, -35,
-35, -35, -36, -35, -35, -35, -35, -36, -35, -35, -35, -34, -35, -35, -35, -35,
-35, -35, -35, -35, -35, -35, -35, -36, -35, -36, -35, -35, -35, -35, -35, -35,
-35, -35, -34, -35, -34, -35, -34, -34, -34, -35, -35, -35, -35, -35, -34, -34,
-34, -35, -34, -34, -35, -35, -35, -35, -34, -35, -35, -34, -35, -35, -34, -34,
-34, -35, -35, -34, -34, -34, -34, -35, -34, -34, -34, -34, -35, -35, -35, -34,
-34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -33, -34, -34, -34, -34,
-35, -34, -34, -35, -34, -34, -34, -34, -33, -34, -34, -33, -34, -34, -34, -34,
-35, -34, -34, -34, -34, -33, -34, -34, -34, -34, -34, -33, -34, -34, -33, -34,
-33, -34, -34, -34, -35, -34, -34, -34, -33, -33, -33, -34, -33, -34, -34, -34,
-33, -33, -33, -33, -33, -33, -34, -34, -33, -33, -33, -34, -33, -33, -34, -34,
-34, -33, -34, -34, -33, -33, -33, -33, -33, -34, -35, -37, -39, -41, -43, -46,
-48, -51, -53, -55, -59, -61, -64, -67, -70, -72, -75, -76, -78, -77, -75, -70,
-62, -50, -36, -16, };