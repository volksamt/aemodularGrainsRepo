#define DATA_LENGTH 512
#define DATA AKWF_1840

const PROGMEM int8_t DATA[DATA_LENGTH] = {81, 119, 107, 114, 108, 112, 110, 113,
102, 101, 100, 101, 100, 101, 100, 101, 103, 104, 103, 104, 103, 103, 104, 103,
104, 103, 104, 103, 103, 103, 103, 96, 89, 89, 90, 90, 90, 90, 90, 89, 92, 93,
93, 93, 93, 92, 93, 87, 74, 74, 75, 74, 74, 74, 75, 74, 73, 73, 73, 72, 74, 72,
73, 65, 44, 41, 42, 42, 42, 41, 42, 42, 44, 46, 46, 47, 46, 46, 46, 45, 42, 38,
38, 38, 38, 38, 39, 39, 39, 38, 38, 38, 39, 38, 38, 29, 21, 22, 21, 21, 21, 21,
21, 21, 7, 1, 3, 1, 2, 2, 3, -2, -8, -8, -7, -8, -8, -8, -8, -9, -24, -27, -25,
-27, -27, -27, -25, -31, -35, -36, -36, -36, -36, -35, -36, -36, -35, -34, -34,
-35, -34, -35, -34, -37, -47, -52, -50, -50, -51, -50, -51, -50, -49, -48, -48,
-49, -49, -48, -49, -58, -65, -64, -65, -65, -65, -64, -65, -65, -65, -65, -65,
-66, -65, -65, -66, -71, -80, -80, -80, -80, -80, -81, -80, -81, -76, -77, -77,
-78, -76, -77, -77, -84, -102, -106, -105, -106, -106, -106, -106, -105, -108,
-109, -109, -109, -109, -108, -108, -110, -117, -119, -119, -119, -119, -118,
-118, -118, -109, -108, -108, -107, -107, -108, -107, -92, -75, -76, -76, -75,
-75, -76, -76, -75, -78, -79, -78, -78, -78, -78, -79, -76, -76, -78, -77, -77,
-78, -78, -77, -79, -86, -86, -86, -85, -86, -86, -87, -80, -43, -34, -37, -35,
-37, -36, -36, -35, -44, -47, -46, -46, -47, -46, -47, -37, -8, 1, -2, 0, -1, 0,
-1, -1, -1, -1, -2, -1, -1, -1, -1, 3, 4, 5, 5, 5, 5, 4, 5, 5, 8, 8, 8, 8, 8, 8,
8, 10, 11, 10, 10, 11, 11, 12, 11, 10, 10, 10, 11, 10, 10, 10, 10, 11, 13, 13,
13, 13, 13, 13, 13, 14, 16, 18, 18, 19, 17, 19, 18, 21, 32, 32, 32, 33, 32, 32,
32, 32, 33, 32, 33, 32, 32, 32, 33, 38, 40, 40, 40, 39, 40, 40, 40, 39, 25, 20,
21, 20, 22, 21, 22, 27, 35, 35, 35, 35, 35, 34, 35, 31, 17, 16, 16, 16, 16, 17,
16, 21, 32, 34, 35, 34, 33, 34, 33, 34, 35, 36, 35, 35, 36, 35, 36, 38, 48, 52,
50, 51, 50, 50, 50, 51, 52, 52, 52, 53, 53, 53, 54, 61, 66, 65, 65, 64, 65, 65,
65, 64, 64, 64, 64, 64, 64, 65, 64, 51, 37, 36, 37, 36, 36, 37, 37, 37, 40, 39,
40, 39, 41, 38, 40, 27, 4, 1, 2, 2, 2, 2, 2, 1, 0, -2, -1, -2, -1, -2, 1, -13,
-49, -57, -55, -55, -56, -55, -56, -53, -46, -44, -45, -45, -45, -45, -46, -56,
-58, -56, -57, -56, -56, -56, -57, -57, -59, -60, -59, -59, -59, -59, -59, -63,
-70, -72, -70, -72, -70, -72, -70, -74, -79, -81, -79, -80, -81, -80, -79, -26,
};