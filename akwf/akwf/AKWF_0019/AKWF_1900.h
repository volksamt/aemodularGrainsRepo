#define DATA_LENGTH 512
#define DATA AKWF_1900

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 22, 33, 46, 57, 68, 78, 86, 94,
100, 106, 110, 114, 116, 118, 119, 119, 120, 119, 118, 118, 118, 118, 117, 115,
114, 115, 114, 113, 113, 112, 112, 110, 110, 110, 109, 109, 108, 106, 107, 107,
106, 105, 104, 104, 103, 104, 105, 105, 104, 104, 103, 103, 103, 102, 102, 101,
101, 99, 98, 96, 94, 91, 90, 87, 86, 83, 81, 78, 76, 74, 72, 71, 69, 66, 66, 64,
64, 62, 62, 61, 61, 60, 59, 60, 59, 60, 60, 59, 59, 58, 58, 59, 59, 59, 58, 59,
59, 59, 58, 59, 58, 58, 58, 59, 58, 58, 58, 58, 58, 57, 57, 58, 57, 56, 56, 55,
54, 53, 53, 50, 48, 45, 42, 37, 34, 29, 24, 18, 11, 6, 0, -7, -13, -19, -26,
-31, -37, -41, -46, -50, -53, -55, -57, -59, -61, -61, -62, -63, -62, -61, -61,
-61, -60, -59, -59, -60, -59, -59, -59, -60, -59, -59, -60, -59, -60, -59, -61,
-60, -60, -61, -61, -61, -62, -61, -61, -62, -63, -63, -62, -63, -63, -64, -65,
-65, -66, -67, -68, -69, -71, -71, -73, -75, -77, -80, -81, -84, -86, -88, -90,
-92, -94, -96, -99, -99, -102, -102, -104, -105, -105, -106, -105, -106, -106,
-105, -106, -105, -106, -105, -105, -105, -105, -106, -107, -108, -108, -109,
-110, -111, -112, -113, -115, -116, -116, -117, -119, -118, -119, -119, -119,
-119, -119, -118, -119, -118, -117, -116, -116, -113, -112, -109, -105, -102,
-97, -92, -86, -79, -71, -64, -54, -44, -35, -24, -14, -3, 8, 18, 28, 37, 46,
54, 61, 66, 70, 73, 76, 78, 78, 78, 77, 76, 75, 72, 70, 68, 66, 64, 62, 61, 60,
58, 58, 57, 57, 57, 57, 57, 56, 57, 57, 57, 57, 57, 57, 57, 57, 56, 55, 55, 55,
55, 54, 53, 52, 52, 52, 49, 49, 48, 47, 46, 44, 43, 42, 40, 38, 36, 34, 31, 30,
27, 25, 24, 21, 20, 17, 16, 15, 13, 12, 12, 11, 10, 10, 9, 10, 10, 9, 10, 10, 9,
10, 10, 10, 9, 9, 9, 9, 9, 9, 8, 9, 9, 7, 8, 7, 7, 7, 6, 6, 6, 5, 5, 4, 5, 4, 4,
4, 3, 3, 3, 3, 2, 2, 1, 1, 0, 1, 0, 0, -1, 0, -1, -2, -2, -1, -2, -2, -2, -2,
-3, -4, -3, -4, -4, -4, -4, -5, -5, -5, -6, -7, -7, -7, -7, -8, -8, -8, -8, -8,
-8, -8, -10, -10, -9, -10, -9, -9, -9, -9, -9, -9, -9, -10, -11, -10, -10, -11,
-12, -13, -13, -13, -14, -15, -16, -18, -18, -20, -21, -22, -23, -25, -26, -27,
-29, -30, -32, -34, -35, -38, -40, -42, -43, -45, -48, -50, -51, -53, -54, -55,
-56, -57, -56, -57, -57, -56, -56, -55, -55, -54, -53, -53, -53, -53, -54, -54,
-55, -56, -58, -60, -63, -66, -70, -74, -75, -80, -82, -84, -86, -85, -85, -83,
-81, -76, -70, -64, -56, -47, -36, -25, -13, -1, };