#define DATA_LENGTH 512
#define DATA AKWF_1882

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 12, 15, 18, 21, 24, 25, 27,
30, 33, 35, 37, 38, 39, 41, 42, 44, 44, 46, 46, 47, 46, 46, 48, 49, 51, 53, 53,
55, 55, 57, 59, 60, 61, 60, 60, 59, 59, 59, 58, 57, 56, 55, 53, 54, 54, 55, 54,
54, 55, 54, 54, 54, 53, 53, 52, 52, 51, 51, 50, 49, 48, 48, 47, 47, 47, 47, 48,
50, 50, 50, 52, 53, 54, 56, 57, 57, 58, 59, 60, 60, 62, 62, 63, 63, 64, 63, 64,
64, 65, 66, 66, 67, 68, 69, 69, 70, 71, 71, 73, 74, 74, 75, 77, 76, 76, 77, 78,
78, 78, 80, 80, 81, 81, 80, 81, 82, 81, 82, 81, 81, 81, 81, 82, 81, 81, 81, 81,
79, 78, 79, 79, 79, 79, 80, 80, 80, 81, 81, 82, 83, 82, 83, 84, 84, 85, 86, 87,
87, 88, 89, 91, 91, 93, 94, 96, 97, 99, 99, 100, 101, 101, 103, 103, 102, 102,
102, 102, 103, 102, 102, 101, 102, 101, 100, 100, 99, 99, 97, 96, 95, 94, 92,
91, 88, 86, 83, 81, 78, 75, 71, 67, 64, 60, 56, 52, 48, 45, 41, 37, 33, 28, 25,
21, 17, 12, 8, 4, -1, -6, -11, -14, -19, -23, -28, -32, -36, -40, -44, -48, -52,
-56, -59, -62, -67, -70, -74, -76, -80, -84, -88, -90, -93, -96, -99, -102,
-105, -106, -109, -110, -111, -113, -114, -115, -117, -116, -118, -117, -118,
-119, -119, -119, -119, -119, -118, -118, -117, -116, -116, -113, -112, -110,
-108, -106, -105, -102, -100, -97, -96, -93, -91, -89, -85, -83, -81, -78, -76,
-74, -70, -67, -65, -62, -60, -57, -56, -52, -50, -48, -46, -44, -42, -41, -38,
-37, -35, -33, -33, -33, -32, -32, -31, -29, -28, -30, -30, -30, -29, -29, -30,
-29, -30, -30, -31, -34, -34, -35, -37, -38, -40, -42, -45, -47, -48, -51, -53,
-56, -59, -61, -63, -65, -67, -70, -73, -75, -78, -81, -83, -86, -89, -92, -93,
-95, -98, -100, -101, -103, -105, -105, -107, -108, -109, -110, -111, -110,
-111, -111, -111, -111, -111, -110, -109, -109, -108, -106, -104, -104, -101,
-99, -98, -95, -93, -88, -85, -83, -80, -76, -73, -70, -66, -62, -58, -54, -50,
-47, -42, -38, -33, -29, -25, -20, -14, -8, -3, 4, 10, 15, 20, 26, 31, 36, 42,
44, 48, 51, 53, 56, 58, 61, 63, 64, 66, 66, 67, 69, 70, 71, 72, 73, 73, 72, 72,
72, 71, 71, 69, 67, 65, 63, 62, 59, 56, 53, 50, 45, 41, 38, 35, 31, 27, 22, 18,
14, 10, 6, 2, -3, -7, -11, -15, -18, -21, -25, -27, -31, -34, -37, -39, -40,
-43, -46, -49, -53, -55, -58, -60, -63, -66, -69, -71, -73, -75, -76, -76, -76,
-77, -76, -75, -74, -73, -71, -69, -67, -65, -63, -62, -58, -55, -53, -52, -49,
-47, -44, -43, -40, -38, -37, -34, -32, -29, -26, -24, -21, -18, -16, -13, -10,
-8, -6, -3, -1, };