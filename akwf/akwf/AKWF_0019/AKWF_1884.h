#define DATA_LENGTH 512
#define DATA AKWF_1884

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 1, 2, 2, 2, 3, 3, 3, 4, 4, 6,
6, 6, 5, 7, 7, 7, 7, 8, 8, 9, 9, 10, 11, 11, 11, 11, 11, 12, 13, 12, 14, 14, 14,
15, 14, 16, 15, 16, 16, 17, 18, 17, 17, 18, 19, 19, 20, 19, 20, 21, 20, 21, 21,
22, 23, 23, 23, 24, 23, 24, 25, 25, 25, 26, 26, 27, 26, 27, 27, 28, 28, 28, 28,
29, 29, 29, 30, 31, 31, 31, 32, 31, 32, 33, 33, 33, 33, 33, 34, 34, 35, 35, 34,
35, 35, 36, 37, 36, 37, 37, 37, 37, 38, 38, 39, 38, 40, 39, 41, 40, 41, 41, 41,
41, 42, 42, 43, 43, 42, 43, 44, 44, 44, 44, 45, 46, 45, 45, 45, 46, 46, 47, 47,
47, 48, 48, 48, 48, 48, 50, 50, 50, 51, 50, 50, 51, 51, 52, 52, 52, 53, 52, 54,
54, 54, 54, 54, 55, 55, 56, 56, 57, 57, 57, 57, 58, 58, 58, 58, 59, 59, 59, 60,
61, 60, 61, 61, 60, 62, 62, 61, 62, 62, 62, 63, 63, 63, 63, 64, 64, 65, 65, 64,
65, 66, 65, 67, 65, 66, 66, 66, 68, 68, 67, 68, 68, 68, 69, 69, 69, 69, 70, 69,
70, 70, 70, 71, 71, 71, 71, 71, 72, 72, 71, 72, 72, 72, 73, 73, 73, 73, 73, 74,
73, 73, 74, 74, 74, 73, 74, 75, 73, 70, 62, 53, 41, 29, 18, 9, -2, -11, -20,
-28, -35, -42, -49, -56, -61, -66, -72, -76, -81, -85, -89, -92, -96, -99, -102,
-105, -106, -109, -111, -113, -115, -117, -118, -118, -118, -119, -118, -117,
-115, -112, -110, -108, -105, -102, -99, -97, -94, -91, -88, -86, -82, -79, -77,
-74, -72, -69, -67, -66, -64, -62, -61, -59, -57, -56, -55, -53, -53, -52, -51,
-50, -50, -49, -48, -47, -47, -46, -45, -44, -44, -44, -43, -43, -43, -42, -42,
-42, -41, -40, -41, -41, -40, -40, -40, -39, -40, -39, -39, -40, -39, -40, -38,
-40, -38, -38, -39, -38, -39, -39, -38, -38, -38, -38, -38, -38, -37, -38, -38,
-37, -37, -38, -37, -37, -38, -38, -38, -37, -37, -37, -36, -37, -37, -36, -37,
-37, -36, -38, -36, -37, -36, -36, -36, -36, -36, -36, -36, -36, -36, -35, -35,
-35, -34, -34, -35, -34, -35, -35, -34, -33, -34, -33, -33, -33, -33, -32, -32,
-31, -31, -31, -31, -31, -31, -30, -30, -29, -29, -29, -29, -29, -29, -28, -28,
-27, -28, -27, -27, -26, -26, -26, -26, -26, -25, -25, -25, -25, -24, -25, -23,
-23, -24, -24, -23, -22, -22, -21, -22, -21, -21, -21, -20, -20, -19, -19, -19,
-19, -18, -19, -17, -18, -18, -17, -17, -17, -17, -16, -16, -16, -14, -15, -15,
-14, -14, -14, -13, -13, -12, -11, -12, -12, -10, -10, -9, -9, -9, -9, -8, -8,
-8, -8, -6, -7, -6, -6, -6, -5, -4, -4, -3, -4, -2, -4, -2, -2, -2, 0, -1, 0, };