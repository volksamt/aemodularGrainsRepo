#define DATA_LENGTH 512
#define DATA AKWF_1886

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 8, 10, 14, 17, 19, 22, 25, 26,
27, 29, 31, 33, 34, 35, 36, 38, 39, 40, 41, 43, 43, 44, 45, 46, 46, 46, 47, 47,
48, 47, 48, 48, 48, 49, 49, 48, 49, 50, 49, 50, 50, 49, 50, 50, 51, 50, 51, 50,
50, 51, 51, 51, 50, 50, 51, 50, 50, 50, 51, 51, 50, 49, 50, 49, 50, 49, 50, 48,
49, 49, 49, 49, 49, 49, 49, 48, 48, 49, 48, 48, 48, 47, 47, 47, 47, 47, 47, 47,
47, 47, 47, 47, 47, 46, 47, 46, 46, 46, 46, 46, 46, 46, 46, 46, 46, 45, 45, 45,
46, 45, 45, 45, 45, 44, 45, 45, 45, 44, 46, 45, 45, 45, 44, 45, 44, 44, 45, 44,
44, 44, 43, 44, 43, 44, 43, 43, 44, 44, 43, 43, 43, 43, 42, 42, 42, 42, 43, 42,
42, 42, 42, 42, 41, 42, 41, 41, 41, 40, 41, 41, 40, 40, 40, 41, 41, 40, 40, 40,
39, 40, 40, 41, 40, 40, 40, 40, 39, 40, 40, 40, 39, 40, 39, 39, 39, 39, 40, 40,
40, 39, 39, 40, 39, 38, 39, 39, 39, 38, 38, 38, 38, 38, 38, 38, 38, 38, 38, 38,
38, 37, 37, 36, 37, 37, 37, 37, 37, 37, 37, 37, 37, 36, 36, 36, 35, 36, 35, 35,
36, 36, 36, 36, 36, 36, 35, 35, 35, 35, 35, 35, 35, 34, 35, 35, 34, 34, 35, 34,
34, 34, 34, 34, 33, 33, 34, 33, 33, 32, 33, 33, 32, 32, 32, 33, 33, 32, 32, 32,
32, 32, 31, 32, 32, 31, 30, 31, 30, 31, 30, 31, 31, 30, 31, 30, 29, 30, 29, 30,
29, 29, 29, 29, 29, 28, 28, 28, 28, 28, 27, 27, 27, 28, 27, 26, 26, 27, 26, 25,
25, 25, 26, 25, 25, 25, 24, 24, 24, 24, 24, 24, 23, 23, 22, 22, 21, 21, 21, 21,
20, 20, 20, 19, 19, 18, 17, 17, 17, 16, 16, 15, 15, 15, 13, 13, 13, 11, 11, 10,
9, 9, 7, 6, 6, 4, 3, 2, 1, -1, -2, -2, -4, -5, -7, -9, -10, -12, -13, -14, -16,
-17, -19, -20, -22, -23, -25, -28, -30, -32, -35, -37, -40, -43, -45, -49, -52,
-54, -56, -58, -61, -63, -65, -67, -69, -71, -73, -75, -77, -79, -81, -83, -85,
-86, -88, -90, -91, -92, -94, -95, -97, -97, -99, -100, -101, -103, -103, -104,
-106, -106, -106, -107, -108, -109, -109, -110, -110, -111, -111, -111, -113,
-113, -114, -114, -113, -115, -115, -115, -115, -115, -115, -116, -116, -117,
-116, -117, -117, -118, -118, -117, -117, -118, -117, -118, -117, -118, -118,
-119, -118, -118, -118, -118, -118, -118, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -118, -119, -119, -119, -119, -120, -119, -119,
-111, -100, -90, -80, -70, -63, -55, -46, -40, -34, -27, -22, -17, -12, -7, -3,
};