#define DATA_LENGTH 512
#define DATA AKWF_1822

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 45, 77, 99, 113, 119, 119, 117,
113, 108, 103, 100, 96, 92, 89, 85, 83, 80, 78, 75, 74, 71, 69, 68, 67, 65, 64,
62, 62, 61, 59, 58, 58, 56, 56, 55, 54, 54, 54, 52, 52, 52, 51, 51, 50, 50, 49,
50, 48, 48, 47, 48, 46, 48, 45, 48, 44, 48, 43, 49, 26, -33, 26, 49, 42, 47, 44,
48, 44, 47, 45, 48, 46, 48, 47, 49, 48, 49, 49, 50, 51, 51, 52, 52, 52, 53, 54,
55, 55, 56, 56, 57, 58, 60, 61, 62, 63, 64, 65, 66, 68, 70, 72, 73, 76, 78, 82,
84, 87, 90, 94, 98, 102, 107, 111, 115, 117, 117, 110, 97, 74, 41, 6, -23, -44,
-56, -59, -60, -57, -52, -48, -44, -40, -35, -32, -28, -26, -24, -21, -19, -21,
-20, -19, -20, -20, -20, -20, -20, -19, -19, -20, -19, -21, -20, -20, -20, -20,
-20, -19, -20, -20, -19, -20, -19, -20, -20, -20, -20, -20, -20, -19, -20, -20,
-20, -19, -20, -20, -20, -19, -19, -20, -19, -19, -20, -19, -19, -20, -20, -20,
-19, -20, -20, -20, -19, -20, -20, -19, -19, -19, -20, -20, -20, -19, -19, -19,
-20, -20, -20, -20, -19, -20, -19, -19, -20, -20, -19, -20, -20, -19, -19, -20,
-20, -19, -19, -19, -20, -20, -19, -20, -19, -20, -19, -20, -19, -20, -20, -20,
-20, -19, -19, -19, -20, -19, -19, -19, -19, -19, -20, -20, -19, -19, -19, -19,
-20, -19, -20, -19, -19, -19, -19, -19, -19, -19, -19, -19, -19, -19, -20, -18,
-19, -19, -19, -19, -19, -19, -19, -19, -20, -20, -19, -19, -19, -19, -18, -19,
-19, -19, -18, -19, -19, -18, -20, -18, -19, -18, -19, -19, -19, -19, -19, -19,
-19, -18, -18, -19, -19, -19, -19, -19, -18, -19, -18, -19, -19, -19, -18, -19,
-19, -18, -19, -18, -19, -18, -18, -19, -19, -18, -18, -18, -18, -19, -19, -19,
-19, -19, -19, -19, -19, -18, -18, -18, -18, -19, -18, -18, -18, -19, -19, -18,
-18, -18, -18, -18, -19, -18, -18, -18, -19, -18, -19, -18, -19, -18, -19, -19,
-18, -19, -18, -18, -18, -18, -19, -19, -18, -18, -18, -19, -18, -18, -19, -18,
-18, -17, -18, -18, -18, -18, -19, -17, -19, -18, -18, -19, -18, -18, -18, -18,
-18, -18, -19, -18, -18, -19, -17, -18, -17, -18, -18, -18, -18, -18, -19, -17,
-18, -17, -19, -18, -18, -18, -18, -18, -18, -18, -18, -18, -18, -17, -19, -18,
-18, -18, -18, -19, -18, -17, -19, -18, -17, -19, -19, -18, -17, -18, -17, -18,
-18, -18, -18, -18, -17, -18, -18, -19, -18, -18, -18, -17, -18, -18, -18, -18,
-17, -17, -18, -18, -17, -18, -18, -18, -18, -18, -18, -17, -17, -17, -17, -18,
-18, -18, -19, -18, -18, -18, -18, -18, -18, -18, -18, -18, -18, -17, -18, -17,
-18, -18, -17, -19, -22, -25, -27, -31, -35, -39, -43, -47, -50, -55, -57, -56,
-51, -39, -14, };