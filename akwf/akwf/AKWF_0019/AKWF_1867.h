#define DATA_LENGTH 512
#define DATA AKWF_1867

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 5, 6, 7, 8, 8, 9, 10, 12,
12, 14, 13, 14, 15, 15, 17, 16, 17, 17, 18, 18, 18, 19, 20, 20, 20, 20, 20, 21,
21, 22, 22, 21, 21, 23, 22, 23, 23, 22, 22, 24, 23, 23, 23, 23, 24, 24, 24, 24,
24, 24, 25, 24, 24, 24, 24, 25, 25, 25, 25, 25, 24, 25, 25, 25, 25, 25, 24, 25,
25, 25, 24, 25, 25, 25, 25, 25, 25, 26, 28, 30, 33, 35, 37, 39, 40, 43, 44, 45,
47, 48, 50, 50, 52, 53, 54, 55, 56, 57, 59, 59, 59, 61, 61, 62, 62, 62, 64, 64,
64, 65, 66, 66, 67, 67, 66, 67, 67, 68, 68, 68, 68, 69, 69, 70, 69, 70, 71, 71,
71, 70, 71, 71, 71, 72, 71, 72, 72, 72, 72, 71, 71, 72, 72, 72, 72, 72, 72, 72,
73, 73, 73, 72, 73, 72, 73, 73, 73, 73, 72, 73, 73, 73, 73, 73, 73, 72, 73, 73,
73, 73, 73, 73, 74, 76, 78, 81, 83, 85, 87, 88, 90, 91, 93, 94, 96, 98, 99, 100,
101, 102, 103, 104, 104, 106, 106, 107, 108, 108, 109, 109, 110, 111, 111, 112,
112, 113, 113, 113, 114, 114, 114, 115, 115, 115, 115, 116, 116, 116, 117, 116,
117, 118, 117, 118, 118, 118, 119, 118, 117, 118, 119, 118, 119, 118, 119, 119,
119, 119, 119, 119, 115, 104, 93, 81, 71, 61, 52, 43, 34, 26, 18, 11, 4, -2, -9,
-13, -19, -25, -30, -34, -39, -43, -48, -52, -55, -60, -62, -66, -69, -71, -74,
-76, -79, -81, -83, -85, -87, -89, -92, -93, -94, -96, -98, -99, -100, -101,
-103, -104, -106, -105, -106, -107, -108, -109, -110, -110, -112, -112, -113,
-113, -114, -114, -115, -116, -116, -117, -117, -117, -116, -114, -112, -109,
-108, -106, -104, -103, -101, -101, -99, -98, -97, -96, -95, -93, -93, -93, -91,
-90, -90, -88, -88, -88, -87, -86, -85, -85, -84, -83, -83, -82, -83, -82, -82,
-82, -81, -81, -80, -80, -79, -79, -80, -79, -78, -78, -78, -77, -78, -78, -78,
-77, -77, -77, -76, -76, -77, -77, -76, -76, -76, -76, -76, -76, -75, -76, -76,
-76, -75, -75, -76, -75, -75, -74, -75, -74, -75, -75, -75, -75, -74, -74, -75,
-74, -75, -74, -74, -74, -74, -74, -73, -74, -74, -74, -74, -72, -68, -66, -65,
-62, -60, -58, -57, -55, -54, -52, -50, -50, -47, -47, -45, -45, -44, -42, -42,
-41, -40, -39, -38, -38, -37, -37, -36, -34, -35, -33, -34, -32, -32, -33, -32,
-31, -30, -30, -30, -30, -30, -29, -29, -29, -28, -28, -28, -28, -27, -28, -27,
-27, -27, -27, -26, -27, -26, -26, -26, -26, -26, -25, -26, -25, -25, -26, -26,
-25, -25, -24, -25, -24, -24, -25, -25, -25, -24, -25, -24, -24, -24, -25, -24,
-24, -24, -24, -24, -23, -25, -24, -24, -22, -21, -18, -15, -14, -12, -11, -9,
-6, -5, -3, -2, -1, };