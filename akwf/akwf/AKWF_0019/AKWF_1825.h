#define DATA_LENGTH 512
#define DATA AKWF_1825

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 8, 14, 20, 27, 33, 38, 44, 50, 54,
58, 62, 67, 69, 73, 76, 78, 81, 83, 84, 86, 87, 89, 90, 91, 92, 92, 92, 92, 94,
94, 94, 94, 94, 94, 94, 94, 93, 92, 93, 91, 91, 90, 90, 89, 89, 88, 87, 87, 84,
84, 82, 81, 81, 80, 78, 77, 76, 74, 73, 73, 71, 69, 68, 67, 66, 65, 65, 63, 62,
62, 59, 59, 59, 58, 58, 56, 57, 55, 55, 55, 54, 55, 55, 55, 56, 56, 57, 56, 57,
58, 59, 60, 61, 62, 63, 64, 66, 67, 69, 71, 72, 74, 75, 77, 77, 80, 79, 80, 81,
80, 81, 79, 78, 76, 74, 72, 69, 66, 62, 59, 54, 50, 46, 42, 40, 36, 33, 30, 28,
25, 22, 20, 19, 18, 16, 14, 13, 13, 11, 10, 9, 9, 8, 8, 8, 8, 6, 9, 5, 9, 5, 11,
-1, 38, 75, 14, 4, 8, 7, 8, 7, 8, 7, 8, 7, 9, 8, 9, 10, 11, 10, 12, 12, 15, 15,
18, 18, 21, 23, 25, 28, 30, 34, 37, 40, 43, 48, 51, 55, 58, 63, 67, 69, 72, 74,
76, 78, 78, 78, 79, 78, 79, 78, 77, 76, 74, 73, 72, 70, 68, 67, 65, 64, 62, 61,
59, 58, 58, 56, 56, 54, 54, 53, 52, 53, 53, 53, 52, 53, 53, 53, 53, 54, 54, 55,
55, 56, 56, 58, 59, 59, 60, 61, 63, 64, 64, 66, 68, 67, 69, 70, 71, 73, 74, 75,
76, 77, 79, 79, 80, 80, 82, 83, 83, 84, 85, 86, 86, 87, 87, 88, 88, 88, 89, 89,
89, 89, 89, 89, 88, 88, 87, 87, 87, 85, 85, 84, 82, 81, 79, 78, 76, 74, 71, 69,
66, 63, 59, 55, 50, 47, 42, 36, 31, 25, 18, 13, 5, -2, -9, -14, -22, -29, -36,
-43, -49, -56, -62, -67, -73, -78, -83, -87, -92, -96, -100, -103, -105, -108,
-110, -111, -113, -115, -116, -117, -118, -119, -119, -119, -120, -119, -119,
-119, -119, -117, -117, -117, -116, -115, -116, -115, -113, -113, -112, -110,
-110, -110, -109, -108, -107, -105, -105, -103, -103, -102, -101, -101, -100,
-99, -98, -97, -95, -95, -94, -93, -93, -92, -92, -91, -88, -89, -88, -87, -86,
-85, -84, -84, -84, -82, -82, -81, -80, -80, -79, -78, -77, -78, -77, -75, -75,
-75, -74, -74, -73, -72, -72, -72, -70, -70, -70, -70, -71, -70, -71, -72, -72,
-73, -73, -74, -75, -75, -76, -75, -76, -77, -78, -77, -78, -78, -80, -80, -81,
-81, -83, -83, -84, -84, -85, -86, -86, -88, -88, -89, -89, -90, -91, -92, -92,
-93, -94, -95, -96, -96, -97, -98, -99, -100, -101, -101, -103, -104, -105,
-105, -106, -106, -106, -107, -109, -110, -110, -111, -111, -112, -113, -113,
-113, -113, -114, -114, -114, -115, -114, -114, -114, -113, -112, -111, -110,
-109, -107, -105, -103, -101, -98, -94, -92, -88, -84, -80, -74, -70, -63, -58,
-53, -46, -39, -32, -26, -19, -12, -4, };