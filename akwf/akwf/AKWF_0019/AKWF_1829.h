#define DATA_LENGTH 512
#define DATA AKWF_1829

const PROGMEM int8_t DATA[DATA_LENGTH] = {31, 104, 118, 110, 107, 102, 100, 96,
94, 90, 89, 85, 82, 79, 77, 75, 73, 70, 68, 66, 64, 70, 57, 10, -13, -35, -53,
-60, -66, -69, -72, -74, -75, -76, -78, -79, -79, -79, -81, -81, -82, -80, -81,
-81, -81, -81, -81, -79, -79, -78, -78, -77, -76, -75, -74, -74, -71, -71, -69,
-68, -67, -67, -64, -63, -62, -60, -59, -58, -56, -56, -53, -52, -51, -48, -48,
-46, -45, -43, -43, -41, -40, -39, -38, -35, -33, -32, -32, -30, -30, -28, -26,
-25, -24, -24, -22, -21, -20, -18, -17, -16, -15, -15, -13, -13, -11, -10, -11,
-8, -8, -7, -7, -6, -6, -3, -4, -3, -2, -1, -1, 0, 1, 1, 2, 3, 3, 3, 4, 5, 5, 5,
7, 7, 7, 8, 8, 9, 8, 9, 10, 9, 10, 11, 10, 10, 11, 12, 12, 12, 12, 13, 12, 13,
13, 14, 14, 13, 14, 14, 14, 14, 15, 15, 14, 15, 15, 16, 15, 15, 16, 15, 16, 16,
16, 16, 16, 16, 16, 16, 15, 16, 16, 16, 16, 16, 16, 15, 16, 16, 16, 16, 16, 15,
15, 16, 15, 16, 16, 16, 16, 15, 14, 16, 15, 15, 14, 15, 15, 15, 15, 15, 15, 14,
15, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 13, 12, 13, 13, 13, 14, 12,
12, 13, 13, 13, 12, 13, 12, 12, 12, 12, 11, 12, 11, 12, 12, 11, 12, 11, 11, 11,
10, 10, 11, 10, 10, 11, 11, 10, 10, 10, 10, 11, 10, 10, 9, 10, 9, 10, 9, 9, 9,
9, 10, 8, 9, 8, 8, 9, 9, 8, 8, 8, 8, 7, 8, 8, 8, 8, 7, 8, 7, 7, 7, 7, 7, 7, 7,
7, 7, 7, 6, 6, 6, 7, 6, 6, 6, 6, 6, 5, 5, 6, 6, 6, 5, 5, 6, 6, 6, 5, 5, 6, 5, 5,
5, 5, 5, 5, 4, 4, 5, 4, 5, 4, 4, 5, 5, 4, 4, 4, 4, 3, 4, 4, 4, 3, 4, 3, 3, 4, 3,
3, 3, 4, 4, 3, 4, 3, 3, 3, 3, 3, 3, 2, 3, 2, 3, 3, 3, 3, 3, 3, 2, 2, 3, 2, 2, 2,
2, 2, 3, 2, 2, 3, 1, 2, 1, 2, 1, 2, 2, 2, 1, 1, 1, 2, 2, 1, 1, 2, 2, 1, 1, 2, 1,
1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 0, 1, 1, 1, 0, 2, 0, 1, 1, 1, 0, 0, 1, 0, 0, 0, 0,
0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, -1, 0, 0, -1, -1,
0, 0, -1, 0, 0, 0, 1, -1, -1, -1, -1, 0, 0, -1, -1, 0, 0, 0, -1, 0, -1, -1, -1,
0, -1, 0, 0, 0, -1, -1, -1, -1, 0, -1, -1, 0, -1, 0, -1, -1, -1, -1, -1, -1, -1,
-1, -1, -1, 0, -1, 0, -2, -1, };