#define DATA_LENGTH 512
#define DATA AKWF_1845

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 4, 5, 6, 7, 8, 9, 9, 10,
12, 12, 13, 14, 14, 16, 16, 17, 18, 19, 20, 21, 22, 22, 24, 23, 25, 25, 26, 27,
28, 28, 29, 30, 31, 32, 32, 33, 33, 35, 35, 37, 38, 38, 39, 39, 40, 41, 42, 42,
43, 43, 45, 45, 45, 45, 47, 47, 48, 48, 49, 50, 51, 52, 52, 52, 53, 53, 54, 55,
55, 56, 57, 57, 57, 58, 59, 59, 60, 60, 61, 61, 62, 63, 63, 64, 64, 64, 66, 65,
66, 66, 66, 68, 68, 68, 68, 69, 69, 70, 70, 71, 72, 72, 72, 73, 73, 74, 74, 74,
74, 74, 75, 76, 76, 76, 77, 78, 77, 77, 77, 78, 78, 79, 79, 79, 80, 80, 80, 81,
81, 81, 82, 82, 81, 82, 82, 83, 83, 83, 84, 84, 84, 84, 84, 84, 85, 85, 86, 85,
85, 86, 86, 86, 86, 86, 87, 86, 87, 87, 87, 86, 87, 88, 87, 88, 87, 88, 88, 88,
88, 88, 88, 88, 88, 89, 89, 89, 89, 90, 89, 89, 89, 89, 88, 90, 90, 89, 89, 89,
89, 89, 89, 89, 89, 89, 89, 89, 89, 90, 89, 89, 89, 89, 89, 89, 90, 89, 89, 89,
89, 89, 89, 89, 89, 89, 88, 89, 88, 88, 88, 89, 88, 88, 87, 87, 87, 87, 87, 88,
88, 87, 88, 87, 87, 86, 86, 86, 86, 86, 86, 86, 86, 85, 85, 86, 86, 85, 85, 85,
77, 76, 74, 69, 70, 67, 66, 63, 60, 57, 54, 50, 47, 42, 39, 34, 31, 27, 22, 18,
13, 9, 4, 0, -5, -8, -13, -16, -21, -25, -29, -33, -37, -40, -43, -46, -50, -54,
-56, -59, -61, -64, -66, -69, -71, -75, -77, -78, -81, -82, -84, -86, -88, -89,
-91, -93, -95, -95, -96, -98, -100, -101, -102, -103, -104, -105, -106, -106,
-107, -109, -109, -110, -111, -111, -112, -113, -113, -113, -115, -115, -115,
-115, -116, -117, -117, -117, -117, -118, -117, -118, -118, -118, -118, -119,
-118, -119, -119, -120, -119, -120, -119, -119, -119, -119, -118, -119, -119,
-118, -118, -117, -118, -118, -117, -117, -117, -117, -116, -116, -116, -116,
-115, -114, -114, -113, -113, -112, -112, -112, -112, -111, -110, -110, -110,
-109, -109, -108, -107, -107, -105, -105, -106, -104, -104, -103, -102, -102,
-102, -100, -100, -99, -98, -97, -97, -97, -96, -95, -95, -94, -92, -92, -91,
-90, -90, -89, -88, -88, -87, -85, -85, -85, -83, -83, -81, -81, -80, -79, -78,
-77, -76, -75, -75, -74, -73, -72, -71, -70, -69, -69, -68, -66, -66, -64, -64,
-62, -62, -62, -60, -58, -57, -57, -55, -54, -55, -52, -53, -51, -50, -50, -49,
-47, -46, -46, -44, -44, -43, -41, -40, -40, -38, -38, -37, -36, -35, -33, -33,
-31, -32, -30, -29, -28, -27, -26, -25, -23, -24, -22, -21, -20, -19, -19, -18,
-16, -16, -14, -14, -13, -12, -11, -10, -8, -8, -7, -6, -6, -4, -3, -2, -2, -1,
0, };