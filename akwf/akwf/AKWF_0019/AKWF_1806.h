#define DATA_LENGTH 512
#define DATA AKWF_1806

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 4, 5, 6, 8, 9, 10, 12, 12,
15, 13, 16, 14, 32, 46, 42, 44, 42, 45, 43, 45, 44, 44, 44, 44, 44, 44, 45, 44,
44, 45, 44, 45, 44, 45, 45, 45, 45, 45, 45, 45, 45, 45, 46, 46, 45, 45, 45, 46,
45, 45, 46, 46, 45, 46, 46, 46, 45, 46, 46, 46, 47, 46, 46, 47, 47, 46, 47, 46,
47, 47, 48, 47, 47, 48, 47, 48, 49, 48, 48, 48, 48, 49, 47, 50, 49, 50, 49, 50,
49, 50, 49, 51, 49, 50, 51, 51, 107, 120, 116, 117, 114, 116, 113, 114, 111,
111, 108, 108, 105, 104, 102, 101, 100, 98, 96, 95, 93, 92, 92, 90, 89, 87, 87,
85, 85, 83, 83, 82, 82, 80, 80, 80, 79, 77, 77, 76, 76, 76, 75, 75, 74, 72, 72,
71, 69, 69, 68, 68, 67, 66, 64, 65, 64, 63, 62, 62, 61, 61, 60, 60, 59, 59, 59,
57, 56, 57, 57, 56, 56, 55, 54, 55, 54, 54, 52, 52, 52, 53, 52, 51, 51, 50, 51,
50, 50, 49, 49, 49, 49, 48, 48, 48, 48, 47, 48, 47, 47, 46, 47, 47, 45, 46, 45,
44, 46, 45, 44, 44, 44, 43, 43, 44, 43, 43, 44, 42, 43, 42, 42, 42, 41, 41, 41,
40, 41, 41, 41, 39, 39, 39, 39, 40, 39, 38, 39, 39, 37, 38, 37, 37, 38, 38, 36,
36, 36, 36, 37, 37, 36, 35, 36, 35, 35, 34, 35, 34, 35, 33, 34, 33, 34, 32, 34,
33, 33, 32, 36, 56, 19, 1, 6, 0, 2, -1, 0, -4, -2, -5, -5, -6, -8, -9, -10, -11,
-13, -14, -14, -16, -18, -17, -19, -20, -21, -22, -24, -24, -25, -27, -28, -29,
-30, -31, -33, -34, -34, -35, -36, -38, -38, -39, -41, -42, -44, -44, -46, -47,
-48, -49, -50, -51, -52, -53, -54, -56, -56, -58, -59, -60, -61, -62, -64, -64,
-65, -67, -67, -69, -69, -71, -71, -73, -74, -75, -76, -78, -78, -79, -81, -81,
-82, -84, -85, -85, -87, -88, -88, -90, -90, -91, -92, -93, -94, -96, -96, -97,
-97, -99, -100, -100, -102, -102, -103, -104, -105, -106, -107, -108, -109,
-109, -111, -110, -111, -112, -113, -113, -114, -114, -115, -115, -115, -116,
-117, -116, -117, -118, -118, -118, -117, -116, -113, -112, -110, -108, -106,
-104, -102, -99, -98, -95, -94, -91, -89, -86, -84, -81, -79, -76, -75, -71,
-70, -66, -64, -60, -59, -54, -53, -48, -46, -42, -41, -38, -35, -33, -30, -29,
-25, -26, -15, -67, -93, -83, -88, -82, -84, -80, -81, -78, -79, -76, -75, -75,
-73, -71, -70, -69, -69, -67, -66, -64, -63, -62, -62, -60, -58, -57, -56, -55,
-53, -53, -51, -50, -50, -47, -46, -45, -44, -42, -42, -40, -39, -38, -36, -36,
-33, -32, -32, -30, -29, -28, -26, -25, -24, -22, -21, -20, -19, -18, -16, -15,
-14, -12, -11, -9, -9, -7, -6, -5, -3, -2, -1, };