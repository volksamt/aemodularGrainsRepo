#define DATA_LENGTH 512
#define DATA AKWF_1852

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 13, 15, 18, 20, 23, 26,
29, 32, 35, 38, 41, 43, 46, 50, 52, 54, 58, 61, 63, 66, 68, 71, 74, 76, 79, 82,
83, 87, 89, 91, 93, 96, 98, 100, 103, 104, 106, 107, 109, 110, 113, 114, 115,
115, 117, 118, 118, 118, 119, 119, 119, 119, 119, 119, 118, 118, 117, 116, 115,
115, 113, 111, 111, 109, 107, 106, 104, 103, 101, 100, 98, 95, 94, 92, 90, 89,
86, 85, 82, 80, 79, 77, 74, 72, 70, 68, 66, 65, 63, 61, 59, 58, 55, 53, 52, 49,
47, 46, 44, 42, 41, 39, 38, 37, 35, 34, 32, 31, 30, 29, 27, 26, 25, 24, 23, 22,
21, 20, 18, 18, 18, 15, 15, 14, 13, 12, 10, 9, 9, 7, 6, 4, 4, 2, 1, 0, -1, -2,
-2, -4, -5, -6, -6, -7, -8, -9, -10, -10, -12, -12, -12, -12, -12, -13, -14,
-14, -14, -14, -14, -15, -14, -14, -15, -14, -14, -15, -15, -15, -14, -14, -14,
-15, -14, -14, -15, -14, -15, -14, -14, -15, -14, -15, -15, -15, -14, -14, -14,
-14, -14, -13, -12, -13, -12, -11, -11, -11, -11, -10, -9, -9, -9, -7, -7, -7,
-6, -6, -5, -5, -4, -4, -4, -3, -3, -2, -2, -2, -2, -1, -2, -2, -2, -1, -2, -2,
-1, -2, -2, -3, -3, -3, -4, -4, -4, -5, -5, -5, -6, -6, -7, -8, -9, -10, -10,
-12, -12, -12, -14, -15, -16, -17, -19, -19, -20, -21, -22, -23, -24, -26, -26,
-27, -28, -29, -30, -31, -33, -34, -34, -36, -36, -38, -39, -40, -41, -41, -42,
-43, -45, -46, -47, -49, -49, -50, -50, -52, -54, -54, -55, -57, -57, -59, -59,
-61, -62, -63, -63, -63, -64, -65, -66, -66, -68, -67, -67, -68, -68, -68, -68,
-68, -68, -67, -67, -66, -66, -65, -64, -64, -62, -61, -61, -59, -58, -58, -55,
-54, -54, -53, -51, -49, -50, -47, -47, -45, -44, -42, -41, -40, -38, -36, -36,
-34, -33, -32, -30, -29, -27, -27, -24, -24, -22, -20, -20, -17, -16, -15, -14,
-13, -11, -11, -9, -9, -7, -6, -5, -4, -3, -2, -2, -1, 0, 2, 2, 3, 4, 4, 5, 6,
6, 6, 7, 7, 7, 7, 9, 9, 9, 10, 10, 10, 10, 11, 11, 11, 11, 12, 12, 12, 12, 13,
13, 12, 13, 13, 12, 12, 12, 12, 11, 12, 11, 10, 10, 9, 8, 6, 7, 5, 5, 3, 1, 1,
-1, -1, -3, -4, -6, -8, -9, -11, -12, -13, -15, -17, -20, -20, -23, -25, -27,
-29, -30, -32, -34, -36, -38, -41, -42, -44, -46, -48, -50, -51, -53, -54, -56,
-57, -58, -60, -61, -62, -63, -64, -64, -64, -65, -65, -66, -65, -65, -65, -65,
-65, -64, -63, -62, -61, -60, -59, -58, -58, -56, -55, -53, -51, -51, -48, -47,
-45, -44, -42, -40, -39, -37, -35, -33, -31, -29, -27, -25, -23, -21, -20, -16,
-15, -13, -10, -8, -5, -3, -1, };