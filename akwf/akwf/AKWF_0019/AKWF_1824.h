#define DATA_LENGTH 512
#define DATA AKWF_1824

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 22, 33, 43, 52, 60, 66, 72, 76, 81,
83, 85, 87, 87, 86, 86, 86, 86, 85, 83, 82, 81, 79, 77, 76, 74, 73, 72, 69, 68,
66, 64, 63, 62, 61, 59, 57, 56, 54, 53, 53, 51, 50, 48, 48, 47, 46, 44, 44, 42,
42, 41, 40, 39, 39, 37, 37, 36, 35, 34, 33, 33, 32, 32, 31, 29, 30, 29, 29, 28,
28, 26, 26, 26, 26, 25, 25, 24, 23, 22, 22, 22, 21, 20, 20, 20, 20, 20, 19, 19,
18, 19, 18, 18, 16, 17, 17, 17, 16, 15, 16, 15, 15, 14, 14, 13, 13, 14, 12, 13,
12, 12, 11, 12, 11, 11, 10, 11, 10, 9, 10, 10, 10, 10, 9, 9, 9, 9, 9, 8, 8, 8,
8, 8, 8, 7, 7, 6, 7, 7, 6, 6, 6, 6, 6, 6, 5, 5, 6, 5, 5, 4, 4, 5, 4, 5, 5, 4, 3,
4, 3, 5, 4, 3, 3, 4, 2, 3, 2, 3, 2, 4, 2, 2, 1, 2, 2, 1, 1, 1, 1, 1, 2, 0, 2,
-1, 2, -1, 3, -2, 3, -2, 5, -2, 5, -3, 9, -3, 27, 2, -128, -7, 31, -4, 9, -3, 7,
-2, 5, -2, 4, -2, 3, -1, 2, 0, 3, 1, 1, 1, 2, 2, 2, 2, 2, 2, 2, 3, 2, 3, 3, 3,
3, 3, 3, 3, 2, 4, 3, 3, 3, 4, 4, 4, 5, 4, 5, 4, 5, 4, 6, 5, 5, 5, 5, 6, 6, 6, 6,
6, 6, 7, 7, 7, 7, 7, 7, 7, 8, 8, 7, 8, 8, 8, 8, 9, 9, 9, 10, 10, 10, 10, 11, 10,
11, 11, 11, 11, 12, 11, 13, 12, 13, 12, 13, 13, 14, 14, 14, 14, 15, 15, 16, 15,
16, 16, 17, 16, 18, 18, 17, 18, 19, 19, 20, 20, 20, 20, 21, 22, 21, 23, 23, 23,
24, 24, 25, 26, 25, 26, 26, 27, 28, 28, 29, 29, 30, 30, 31, 31, 33, 33, 33, 34,
35, 37, 37, 39, 38, 40, 41, 42, 42, 44, 43, 45, 45, 47, 48, 49, 50, 52, 52, 54,
56, 57, 58, 59, 61, 63, 64, 66, 67, 68, 71, 71, 74, 75, 77, 79, 80, 80, 82, 83,
84, 83, 84, 85, 83, 82, 80, 77, 73, 70, 64, 57, 50, 41, 31, 20, 8, -4, -18, -30,
-42, -53, -65, -75, -84, -92, -99, -104, -109, -113, -115, -116, -118, -119,
-119, -119, -118, -117, -117, -115, -115, -112, -111, -109, -108, -107, -105,
-103, -101, -100, -98, -97, -95, -93, -92, -91, -90, -88, -86, -85, -84, -83,
-82, -81, -79, -79, -77, -76, -76, -74, -74, -73, -72, -73, -74, -75, -75, -76,
-77, -78, -79, -80, -82, -83, -83, -85, -86, -88, -89, -89, -91, -93, -94, -96,
-98, -99, -100, -102, -103, -105, -106, -108, -110, -111, -112, -114, -114,
-115, -116, -116, -117, -116, -115, -115, -112, -110, -104, -100, -95, -89, -79,
-71, -59, -50, -37, -25, -12, 0, };