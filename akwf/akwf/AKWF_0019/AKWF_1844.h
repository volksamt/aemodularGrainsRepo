#define DATA_LENGTH 512
#define DATA AKWF_1844

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 5, 9, 11, 13, 14, 16, 17, 17, 19,
19, 19, 20, 20, 21, 21, 21, 20, 21, 21, 21, 21, 21, 21, 21, 22, 22, 21, 21, 22,
21, 21, 24, 29, 36, 42, 45, 50, 53, 56, 58, 60, 60, 61, 63, 64, 64, 65, 66, 66,
66, 65, 66, 67, 67, 66, 67, 67, 67, 67, 67, 68, 68, 67, 67, 67, 67, 67, 68, 67,
67, 66, 67, 66, 67, 66, 67, 66, 67, 67, 67, 67, 67, 66, 67, 67, 67, 67, 68, 67,
67, 67, 67, 68, 67, 67, 66, 67, 67, 66, 66, 67, 66, 67, 66, 67, 69, 73, 79, 86,
90, 94, 98, 101, 103, 104, 106, 107, 108, 109, 110, 110, 111, 111, 111, 112,
112, 112, 112, 112, 112, 112, 111, 112, 112, 112, 112, 112, 112, 113, 113, 112,
112, 112, 112, 112, 112, 112, 112, 112, 113, 113, 112, 112, 112, 113, 112, 112,
112, 112, 112, 112, 112, 111, 111, 111, 112, 112, 112, 111, 112, 111, 112, 111,
112, 111, 112, 111, 111, 112, 111, 112, 111, 112, 111, 112, 111, 112, 112, 112,
111, 111, 111, 111, 112, 111, 111, 111, 112, 112, 111, 111, 111, 111, 111, 111,
112, 112, 111, 112, 111, 112, 111, 110, 112, 112, 111, 111, 111, 110, 111, 112,
112, 110, 108, 102, 96, 90, 86, 82, 78, 76, 74, 73, 71, 70, 69, 68, 68, 68, 68,
66, 66, 65, 66, 65, 65, 66, 65, 65, 65, 65, 64, 65, 65, 65, 65, 65, 65, 65, 64,
65, 64, 59, 45, 25, 6, -8, -20, -30, -37, -45, -49, -54, -57, -61, -66, -72,
-81, -88, -93, -99, -102, -105, -107, -110, -112, -113, -114, -115, -116, -116,
-117, -117, -117, -118, -119, -119, -118, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -120, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -118, -118, -119, -119, -119, -119, -119, -120, -118, -118,
-119, -119, -118, -119, -119, -119, -118, -119, -118, -118, -118, -118, -118,
-118, -118, -118, -118, -119, -118, -118, -118, -118, -118, -118, -118, -119,
-118, -118, -118, -118, -118, -118, -118, -119, -118, -118, -118, -118, -118,
-118, -119, -118, -119, -118, -118, -117, -119, -117, -117, -117, -114, -108,
-102, -95, -91, -89, -85, -83, -81, -79, -78, -77, -75, -75, -75, -74, -73, -74,
-73, -73, -72, -73, -71, -72, -72, -72, -72, -71, -72, -71, -71, -72, -71, -72,
-71, -72, -72, -72, -72, -71, -72, -72, -72, -70, -72, -71, -72, -72, -72, -71,
-71, -71, -71, -71, -71, -71, -71, -71, -71, -71, -71, -71, -71, -71, -71, -71,
-71, -72, -71, -70, -71, -72, -71, -71, -72, -71, -70, -66, -60, -54, -49, -44,
-41, -37, -35, -33, -32, -30, -30, -29, -28, -28, -27, -27, -26, -26, -26, -25,
-26, -25, -25, -25, -26, -25, -25, -25, -25, -25, -25, -24, -25, -25, -24, -23,
-17, -11, -5, 0, };