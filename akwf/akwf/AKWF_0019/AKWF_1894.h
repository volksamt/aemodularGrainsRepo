#define DATA_LENGTH 512
#define DATA AKWF_1894

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 20, 35, 51, 65, 79, 92, 102, 112,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 115, 112, 108, 105,
103, 101, 100, 99, 99, 99, 99, 99, 100, 101, 101, 102, 103, 103, 103, 105, 105,
104, 105, 105, 105, 106, 105, 105, 105, 106, 105, 106, 106, 106, 105, 104, 105,
104, 105, 106, 105, 105, 104, 104, 105, 104, 105, 105, 105, 105, 105, 104, 105,
105, 105, 105, 104, 104, 105, 105, 104, 104, 104, 105, 104, 104, 104, 104, 105,
104, 104, 104, 104, 105, 104, 104, 105, 105, 104, 104, 105, 104, 105, 104, 104,
104, 104, 104, 105, 104, 104, 104, 104, 104, 104, 104, 103, 103, 103, 103, 104,
104, 105, 104, 104, 103, 104, 104, 104, 103, 104, 104, 103, 104, 104, 104, 104,
104, 103, 103, 104, 104, 103, 104, 103, 103, 103, 104, 103, 103, 104, 103, 104,
104, 104, 103, 104, 104, 103, 104, 103, 103, 102, 104, 104, 104, 104, 103, 103,
103, 104, 104, 102, 103, 103, 103, 103, 103, 103, 103, 104, 104, 103, 102, 103,
102, 104, 103, 103, 103, 102, 103, 103, 103, 103, 104, 103, 103, 104, 103, 102,
103, 103, 102, 103, 102, 103, 103, 102, 102, 101, 100, 101, 99, 99, 98, 99, 99,
98, 98, 99, 100, 100, 100, 103, 105, 107, 110, 111, 114, 116, 116, 117, 116,
116, 116, 116, 117, 117, 114, 108, 102, 95, 88, 79, 69, 59, 49, 39, 28, 17, 7,
-4, -14, -24, -33, -40, -48, -56, -63, -70, -76, -82, -87, -92, -96, -100, -103,
-106, -110, -112, -113, -115, -117, -116, -117, -117, -116, -116, -114, -113,
-112, -110, -108, -106, -105, -104, -102, -102, -101, -100, -99, -99, -98, -99,
-99, -99, -100, -100, -101, -102, -102, -102, -102, -103, -103, -103, -103,
-102, -103, -103, -103, -103, -104, -104, -104, -103, -102, -103, -103, -102,
-103, -103, -103, -103, -102, -103, -103, -102, -102, -103, -102, -103, -102,
-102, -102, -103, -103, -103, -103, -103, -102, -102, -102, -102, -103, -102,
-102, -102, -103, -102, -102, -103, -102, -102, -102, -102, -102, -103, -103,
-101, -103, -103, -102, -102, -103, -102, -102, -102, -101, -103, -102, -102,
-102, -103, -102, -102, -101, -102, -102, -102, -102, -102, -103, -102, -102,
-102, -102, -102, -102, -102, -103, -103, -101, -102, -102, -102, -102, -102,
-102, -101, -102, -102, -102, -102, -101, -102, -102, -101, -102, -101, -101,
-102, -101, -102, -101, -101, -102, -102, -101, -102, -101, -102, -101, -101,
-101, -102, -101, -101, -102, -101, -101, -101, -100, -102, -101, -101, -101,
-101, -100, -101, -102, -101, -101, -102, -101, -101, -101, -102, -101, -101,
-101, -101, -101, -101, -101, -101, -102, -101, -100, -101, -100, -100, -100,
-100, -100, -100, -100, -100, -101, -101, -101, -100, -100, -101, -99, -99, -99,
-99, -99, -99, -99, -100, -100, -100, -101, -101, -103, -104, -106, -108, -110,
-112, -114, -114, -114, -115, -114, -114, -114, -113, -109, -103, -97, -88, -78,
-66, -54, -38, -25, -8, };