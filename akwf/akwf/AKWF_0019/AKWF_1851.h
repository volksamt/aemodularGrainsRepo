#define DATA_LENGTH 512
#define DATA AKWF_1851

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 10, 13, 16, 18, 19, 21, 22, 23,
24, 25, 26, 26, 26, 26, 28, 28, 28, 29, 28, 27, 29, 28, 29, 29, 29, 29, 29, 29,
29, 29, 29, 29, 28, 29, 30, 29, 29, 29, 29, 29, 29, 30, 30, 29, 29, 29, 29, 29,
29, 29, 29, 29, 29, 29, 29, 29, 29, 29, 29, 30, 29, 29, 29, 29, 29, 30, 29, 29,
30, 29, 29, 29, 29, 29, 29, 28, 30, 30, 29, 29, 29, 30, 30, 29, 29, 29, 30, 29,
29, 29, 28, 29, 29, 29, 28, 28, 29, 29, 29, 29, 28, 29, 29, 29, 28, 29, 29, 30,
29, 29, 29, 29, 29, 29, 29, 29, 29, 29, 28, 29, 29, 29, 28, 28, 29, 29, 29, 29,
29, 29, 28, 29, 29, 29, 29, 29, 29, 29, 28, 28, 28, 29, 29, 28, 29, 28, 29, 29,
29, 29, 28, 29, 29, 29, 29, 28, 29, 29, 29, 28, 29, 29, 28, 29, 28, 28, 29, 29,
29, 29, 29, 29, 29, 29, 29, 29, 29, 29, 28, 29, 29, 29, 29, 28, 29, 29, 29, 29,
28, 29, 29, 29, 28, 28, 29, 28, 28, 29, 29, 29, 29, 29, 28, 29, 28, 29, 29, 28,
29, 29, 28, 29, 29, 36, 51, 65, 78, 85, 86, 85, 86, 85, 85, 86, 85, 85, 86, 85,
85, 85, 85, 86, 86, 85, 85, 86, 85, 86, 85, 85, 86, 86, 85, 85, 85, 86, 85, 85,
85, 84, 67, 43, 23, 7, -6, -19, -29, -38, -45, -52, -57, -62, -64, -68, -70,
-73, -75, -77, -78, -79, -79, -81, -82, -82, -82, -83, -83, -84, -84, -85, -84,
-87, -96, -102, -108, -114, -118, -118, -105, -93, -84, -75, -69, -62, -57, -52,
-49, -46, -43, -41, -39, -37, -36, -36, -34, -33, -32, -33, -31, -31, -30, -31,
-29, -30, -29, -30, -30, -29, -29, -29, -29, -29, -29, -29, -30, -29, -28, -29,
-29, -29, -29, -28, -28, -28, -29, -28, -29, -28, -29, -29, -28, -28, -29, -28,
-29, -29, -29, -29, -28, -28, -29, -28, -29, -28, -29, -28, -28, -27, -28, -28,
-28, -28, -28, -28, -29, -28, -28, -28, -28, -28, -28, -29, -29, -29, -28, -29,
-28, -28, -28, -28, -28, -28, -29, -28, -28, -28, -29, -28, -28, -28, -28, -28,
-28, -28, -28, -28, -28, -29, -28, -27, -29, -29, -28, -28, -28, -28, -28, -28,
-28, -29, -28, -28, -28, -28, -28, -29, -28, -29, -28, -29, -28, -28, -28, -27,
-28, -28, -28, -29, -28, -29, -28, -28, -28, -28, -28, -29, -28, -28, -28, -27,
-28, -28, -28, -28, -28, -28, -28, -28, -28, -28, -28, -28, -28, -28, -28, -28,
-28, -28, -28, -29, -28, -28, -28, -27, -28, -28, -28, -28, -27, -28, -27, -28,
-27, -28, -28, -28, -28, -28, -28, -29, -27, -28, -28, -28, -29, -28, -28, -28,
-28, -28, -28, -28, -28, -28, -28, -28, -27, -27, -28, -28, -28, -28, -28, -28,
-28, -27, -21, -12, -7, -1, };