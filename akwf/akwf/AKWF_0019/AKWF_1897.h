#define DATA_LENGTH 512
#define DATA AKWF_1897

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 12, 18, 22, 27, 31, 36, 42, 47,
51, 56, 60, 65, 69, 73, 77, 80, 84, 87, 92, 94, 97, 100, 102, 105, 106, 108,
110, 111, 113, 112, 114, 114, 114, 113, 114, 112, 112, 112, 111, 110, 109, 109,
107, 108, 107, 106, 106, 106, 106, 106, 105, 106, 107, 106, 106, 106, 107, 108,
109, 108, 109, 111, 111, 112, 113, 113, 115, 117, 118, 118, 118, 120, 119, 119,
119, 119, 118, 118, 116, 115, 113, 112, 110, 108, 106, 103, 100, 97, 95, 91, 88,
84, 81, 77, 73, 69, 65, 60, 57, 52, 48, 44, 40, 36, 33, 30, 28, 26, 24, 23, 22,
21, 21, 22, 22, 24, 25, 25, 26, 28, 30, 30, 32, 32, 33, 34, 35, 35, 36, 36, 35,
35, 36, 36, 35, 35, 35, 36, 34, 34, 35, 35, 36, 36, 36, 36, 37, 36, 36, 36, 37,
37, 37, 37, 37, 38, 38, 38, 38, 39, 38, 38, 39, 38, 39, 39, 40, 40, 39, 40, 41,
40, 41, 41, 41, 41, 41, 42, 42, 41, 42, 42, 43, 42, 43, 43, 43, 43, 43, 44, 43,
44, 44, 44, 45, 44, 46, 45, 45, 45, 45, 46, 46, 46, 46, 46, 47, 46, 46, 46, 47,
46, 47, 46, 46, 47, 47, 47, 47, 49, 48, 48, 49, 49, 50, 51, 50, 50, 51, 52, 52,
52, 53, 52, 53, 54, 54, 55, 56, 57, 57, 58, 58, 59, 59, 60, 58, 58, 55, 54, 50,
47, 42, 36, 31, 23, 16, 8, 0, -10, -18, -28, -37, -46, -54, -60, -68, -74, -79,
-83, -86, -89, -91, -92, -93, -93, -93, -92, -91, -91, -90, -89, -87, -87, -87,
-86, -86, -84, -85, -85, -84, -84, -83, -83, -83, -82, -82, -82, -82, -81, -80,
-80, -80, -80, -79, -79, -79, -79, -78, -79, -79, -79, -79, -79, -80, -78, -79,
-77, -77, -78, -78, -78, -77, -77, -77, -77, -77, -76, -77, -76, -75, -75, -76,
-75, -74, -75, -74, -75, -74, -73, -73, -74, -74, -74, -73, -73, -72, -72, -72,
-72, -72, -72, -71, -72, -72, -71, -71, -71, -71, -70, -70, -70, -70, -70, -70,
-69, -69, -69, -69, -69, -69, -68, -68, -67, -68, -68, -67, -67, -67, -67, -67,
-67, -66, -66, -65, -65, -65, -65, -65, -65, -64, -65, -65, -64, -63, -64, -63,
-63, -63, -63, -63, -63, -62, -62, -62, -62, -61, -61, -61, -61, -60, -60, -60,
-60, -61, -60, -59, -59, -60, -59, -59, -59, -59, -59, -58, -59, -58, -58, -58,
-57, -57, -58, -57, -56, -56, -56, -56, -56, -55, -56, -55, -55, -55, -54, -55,
-55, -54, -55, -53, -54, -54, -53, -54, -53, -52, -53, -53, -52, -51, -52, -51,
-52, -51, -51, -50, -49, -49, -48, -48, -48, -47, -48, -47, -46, -47, -47, -48,
-49, -49, -50, -51, -50, -52, -53, -53, -54, -54, -55, -55, -55, -55, -54, -53,
-52, -50, -48, -46, -44, -41, -38, -35, -32, -28, -25, -22, -17, -14, -9, -5,
-1, };