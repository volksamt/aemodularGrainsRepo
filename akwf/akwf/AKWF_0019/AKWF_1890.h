#define DATA_LENGTH 512
#define DATA AKWF_1890

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 3, 2, 3, 4, 4, 4, 4, 5, 5,
5, 6, 5, 6, 6, 7, 8, 9, 9, 9, 9, 11, 11, 11, 12, 13, 13, 13, 14, 14, 15, 15, 15,
16, 16, 18, 16, 16, 16, 15, 16, 15, 16, 16, 17, 18, 18, 19, 20, 20, 21, 21, 22,
23, 23, 23, 25, 24, 25, 25, 26, 27, 27, 28, 27, 26, 21, 20, 18, 19, 18, 20, 20,
22, 23, 24, 25, 26, 26, 27, 28, 28, 30, 30, 30, 29, 31, 31, 31, 32, 33, 32, 32,
34, 32, 28, 29, 30, 30, 30, 32, 36, 39, 42, 42, 44, 44, 45, 46, 46, 47, 47, 48,
48, 48, 48, 49, 49, 49, 50, 50, 51, 51, 51, 51, 53, 52, 54, 54, 61, 73, 79, 83,
85, 86, 87, 87, 87, 88, 88, 87, 88, 88, 88, 88, 89, 89, 88, 88, 90, 89, 90, 89,
90, 91, 92, 93, 91, 99, 109, 108, 110, 110, 110, 110, 109, 107, 108, 109, 108,
108, 107, 107, 106, 106, 105, 105, 104, 105, 105, 105, 106, 106, 107, 107, 107,
108, 109, 109, 109, 110, 110, 111, 109, 104, 102, 102, 102, 102, 101, 97, 95,
92, 89, 88, 88, 87, 87, 87, 87, 88, 87, 89, 88, 90, 90, 90, 91, 91, 92, 92, 92,
91, 87, 89, 89, 90, 90, 83, 69, 60, 52, 48, 47, 46, 45, 45, 45, 45, 46, 45, 47,
47, 47, 47, 49, 49, 50, 50, 50, 50, 51, 51, 52, 53, 51, 58, 12, -35, -50, -60,
-63, -67, -67, -67, -68, -66, -67, -67, -66, -65, -66, -64, -65, -64, -63, -62,
-62, -61, -62, -60, -61, -60, -58, -61, -54, -105, -124, -114, -120, -115, -118,
-115, -119, -117, -120, -117, -119, -117, -118, -117, -116, -115, -114, -114,
-113, -113, -112, -112, -111, -111, -110, -111, -110, -109, -108, -108, -108,
-108, -106, -105, -108, -113, -114, -116, -114, -115, -114, -113, -111, -109,
-109, -109, -108, -106, -106, -106, -105, -104, -105, -104, -103, -103, -103,
-103, -102, -102, -101, -101, -100, -101, -105, -104, -103, -103, -104, -100,
-98, -95, -92, -90, -90, -88, -88, -87, -87, -86, -85, -85, -85, -85, -84, -84,
-83, -82, -82, -81, -81, -81, -81, -80, -79, -79, -78, -79, -70, -57, -52, -49,
-47, -46, -45, -45, -44, -45, -44, -44, -43, -43, -43, -43, -41, -42, -41, -41,
-40, -40, -39, -39, -38, -38, -38, -36, -37, -27, -19, -22, -19, -20, -18, -19,
-19, -20, -21, -21, -21, -21, -19, -20, -18, -19, -18, -17, -17, -16, -17, -16,
-15, -15, -14, -14, -13, -13, -12, -12, -11, -10, -11, -10, -13, -17, -18, -19,
-19, -18, -18, -18, -17, -17, -17, -17, -16, -15, -15, -14, -14, -14, -13, -12,
-12, -11, -11, -11, -10, -10, -9, -9, -8, -10, -14, -12, -12, -12, -11, -11,
-11, -10, -10, -10, -8, -8, -8, -7, -7, -6, -6, -5, -5, -5, -5, -4, -3, -3, -2,
-3, -1, -1, -1, -1, };