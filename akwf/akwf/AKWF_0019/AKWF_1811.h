#define DATA_LENGTH 512
#define DATA AKWF_1811

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 6, 6, 6, 5, 6, 7, 6, 6, 5, 6, 4, 8,
2, 21, 45, 38, 41, 39, 42, 39, 41, 39, 43, 71, 72, 70, 72, 70, 72, 70, 73, 68,
89, 100, 97, 98, 98, 97, 98, 96, 100, 120, 119, 119, 119, 119, 118, 118, 119,
118, 119, 119, 119, 119, 119, 119, 118, 119, 117, 121, 108, 93, 99, 94, 69, 72,
54, 33, 44, -1, -31, -22, -18, -14, -12, -10, -12, -11, -11, -14, -17, -15, -17,
-15, -22, -26, -23, -25, -23, -26, -18, -15, -16, -16, -17, -16, -16, -16, -16,
-11, -11, -11, -11, -12, -12, -11, -12, -11, -11, -10, -12, -14, -15, -15, -16,
-14, -17, -23, -23, -22, -22, -23, -23, -21, -28, -34, -30, -34, -31, -33, -31,
-34, -30, 3, 6, 3, 6, 2, 8, 37, 41, 37, 41, 36, 43, 67, 72, 68, 73, 67, 74, 96,
97, 95, 97, 94, 100, 118, 118, 118, 118, 117, 118, 118, 117, 118, 117, 118, 117,
118, 117, 118, 116, 99, 92, 100, 81, 67, 69, 40, 33, -13, -38, -25, -25, -15,
-16, -14, -12, -12, -13, -13, -18, -17, -18, -17, -16, -18, -26, -25, -25, -26,
-26, -25, -25, -26, -19, -16, -17, -17, -17, -17, -17, -17, -17, -18, -15, -12,
-12, -12, -12, -12, -13, -13, -13, -13, -12, -11, -12, -12, -12, -12, -12, -12,
-11, -12, -12, -15, -16, -16, -16, -16, -15, -16, -16, -16, -16, -15, -16, -15,
-16, -14, -19, -24, -22, -24, -23, -23, -24, -23, -23, -24, -22, -23, -23, -24,
-24, -23, -23, -23, -22, -22, -23, -23, -23, -24, -22, -24, -21, -25, -34, -33,
-33, -32, -33, -32, -33, -32, -33, -32, -32, -33, -33, -32, -32, -33, -33, -33,
-33, -33, -33, -32, -32, -33, -32, -32, -33, -32, -32, -33, -32, -32, -33, -32,
-32, -32, -32, -32, -32, -32, -33, -33, -32, -32, -32, -33, -33, -33, -32, -33,
-32, -33, -32, -32, -33, -33, -32, -32, -33, -33, -32, -32, -32, -33, -33, -33,
-32, -32, -32, -31, -32, -32, -33, -31, -32, -31, -32, -32, -33, -30, -22, -22,
-22, -22, -21, -22, -22, -22, -23, -22, -22, -22, -22, -22, -22, -21, -21, -21,
-22, -21, -22, -21, -22, -21, -22, -22, -22, -22, -22, -22, -22, -22, -23, -22,
-21, -22, -22, -22, -22, -21, -23, -22, -23, -22, -22, -22, -22, -21, -22, -21,
-21, -22, -21, -21, -22, -21, -21, -22, -22, -22, -21, -22, -15, -14, -15, -14,
-15, -13, -14, -13, -14, -14, -14, -14, -14, -13, -14, -14, -13, -14, -13, -14,
-13, -14, -14, -13, -13, -14, -14, -14, -13, -14, -13, -14, -14, -14, -14, -13,
-13, -16, -23, -21, -21, -21, -21, -21, -22, -21, -22, -21, -21, -21, -22, -22,
-21, -21, -21, -22, -21, -22, -21, -22, -21, -22, -21, -21, -21, -21, -21, -22,
-21, -22, -21, -23, -31, -31, -31, -31, -31, -32, -30, -32, -30, -32, -29, -31,
-29, -32, -30, -33, -26, };