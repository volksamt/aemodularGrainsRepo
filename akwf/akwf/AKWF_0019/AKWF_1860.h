#define DATA_LENGTH 512
#define DATA AKWF_1860

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 11, 14, 19, 24, 27, 32, 36, 41,
45, 50, 55, 59, 64, 68, 72, 77, 80, 85, 89, 92, 95, 97, 101, 104, 106, 107, 109,
112, 114, 115, 116, 117, 117, 119, 118, 119, 118, 119, 118, 118, 118, 115, 115,
114, 112, 110, 107, 105, 103, 100, 97, 93, 90, 87, 84, 80, 76, 73, 69, 66, 63,
60, 56, 53, 50, 48, 44, 41, 40, 36, 35, 32, 31, 29, 27, 26, 23, 23, 21, 20, 19,
19, 18, 18, 17, 18, 17, 18, 18, 17, 19, 19, 19, 20, 20, 21, 22, 23, 22, 23, 24,
24, 25, 26, 26, 26, 25, 26, 26, 26, 24, 24, 25, 24, 23, 23, 22, 21, 19, 18, 16,
15, 13, 11, 9, 7, 5, 3, 0, -2, -5, -7, -11, -13, -16, -18, -21, -24, -28, -30,
-33, -37, -39, -43, -45, -49, -51, -53, -56, -58, -62, -64, -66, -68, -70, -72,
-73, -75, -77, -78, -79, -79, -80, -80, -80, -80, -81, -81, -80, -80, -79, -78,
-77, -77, -76, -74, -72, -71, -70, -67, -66, -63, -61, -60, -57, -54, -52, -49,
-47, -43, -40, -38, -36, -32, -29, -27, -23, -20, -17, -15, -12, -9, -5, -2, 0,
3, 5, 9, 11, 15, 17, 19, 21, 23, 26, 29, 31, 33, 36, 38, 39, 42, 43, 46, 48, 50,
50, 53, 54, 55, 57, 57, 58, 59, 60, 61, 61, 61, 63, 62, 63, 64, 63, 63, 63, 62,
62, 61, 61, 60, 60, 59, 57, 57, 56, 56, 53, 52, 51, 49, 48, 46, 45, 44, 41, 40,
38, 37, 34, 33, 31, 29, 28, 25, 23, 22, 20, 18, 16, 14, 11, 9, 8, 6, 3, 2, 0,
-3, -4, -5, -7, -8, -11, -12, -13, -15, -17, -18, -19, -21, -22, -24, -24, -25,
-27, -28, -29, -30, -31, -32, -33, -34, -35, -36, -37, -38, -38, -38, -39, -41,
-41, -41, -43, -43, -44, -44, -45, -46, -46, -46, -47, -48, -48, -49, -50, -49,
-51, -51, -52, -52, -52, -53, -53, -53, -54, -54, -54, -55, -55, -55, -55, -54,
-55, -54, -54, -53, -54, -53, -53, -53, -52, -51, -51, -50, -50, -50, -49, -47,
-47, -46, -45, -43, -42, -41, -40, -39, -38, -36, -35, -34, -32, -30, -30, -28,
-27, -25, -24, -23, -21, -20, -19, -16, -16, -14, -14, -12, -11, -9, -9, -7, -7,
-6, -5, -4, -3, -3, -2, -2, -1, 0, 1, 1, 0, 1, 1, 0, 1, 1, 0, 0, 0, 0, -1, 0,
-1, -2, -2, -4, -4, -5, -5, -6, -6, -7, -8, -8, -9, -11, -11, -13, -13, -14,
-15, -15, -17, -18, -19, -20, -20, -21, -22, -23, -24, -25, -26, -27, -28, -28,
-31, -30, -32, -33, -34, -34, -36, -37, -38, -38, -40, -40, -41, -42, -43, -44,
-44, -45, -45, -45, -46, -47, -47, -47, -47, -48, -48, -47, -47, -47, -46, -45,
-45, -43, -42, -42, -39, -38, -36, -35, -31, -30, -27, -24, -22, -20, -16, -13,
-10, -7, -4, 0, };