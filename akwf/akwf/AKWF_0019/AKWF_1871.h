#define DATA_LENGTH 512
#define DATA AKWF_1871

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 10, 13, 16, 21, 25, 29, 32, 36,
40, 44, 48, 52, 55, 59, 62, 66, 69, 73, 76, 78, 82, 85, 88, 90, 92, 94, 98, 100,
102, 104, 106, 108, 110, 110, 112, 114, 114, 116, 116, 118, 117, 119, 118, 119,
120, 119, 119, 119, 118, 118, 117, 117, 116, 114, 114, 112, 111, 110, 108, 107,
105, 104, 102, 100, 98, 97, 94, 93, 90, 88, 86, 83, 81, 79, 77, 75, 72, 70, 68,
65, 63, 61, 58, 56, 54, 52, 49, 48, 45, 42, 40, 38, 37, 34, 33, 31, 28, 28, 26,
23, 21, 20, 18, 17, 16, 15, 14, 13, 11, 10, 9, 10, 8, 8, 7, 6, 6, 5, 6, 5, 5, 6,
6, 5, 5, 6, 6, 7, 7, 6, 8, 8, 8, 10, 10, 12, 12, 13, 14, 15, 16, 18, 19, 20, 21,
22, 23, 25, 26, 27, 29, 30, 31, 33, 34, 36, 37, 38, 39, 41, 42, 44, 44, 46, 47,
50, 50, 52, 53, 55, 56, 56, 57, 58, 59, 61, 61, 63, 64, 64, 64, 66, 66, 67, 68,
68, 69, 70, 69, 70, 71, 71, 71, 71, 71, 71, 72, 72, 71, 71, 71, 71, 72, 71, 70,
70, 71, 70, 69, 70, 69, 68, 68, 68, 67, 66, 65, 64, 64, 63, 62, 62, 61, 61, 60,
58, 58, 57, 56, 56, 54, 54, 54, 53, 52, 51, 49, 49, 48, 47, 46, 45, 45, 44, 44,
43, 42, 41, 40, 41, 39, 39, 38, 37, 38, 37, 36, 36, 34, 33, 32, 30, 29, 28, 26,
24, 22, 20, 18, 15, 13, 10, 8, 6, 3, 1, -3, -5, -8, -12, -15, -19, -20, -25,
-26, -30, -33, -37, -41, -43, -46, -49, -53, -56, -58, -62, -64, -68, -71, -74,
-77, -79, -82, -84, -86, -89, -92, -93, -95, -97, -100, -101, -103, -105, -107,
-107, -109, -111, -112, -113, -113, -114, -115, -115, -116, -116, -117, -117,
-118, -117, -117, -117, -118, -116, -116, -117, -116, -115, -114, -113, -113,
-111, -111, -110, -109, -108, -106, -105, -103, -103, -101, -99, -98, -97, -95,
-94, -92, -91, -90, -87, -86, -83, -82, -81, -79, -77, -75, -74, -71, -71, -69,
-67, -65, -64, -62, -61, -59, -58, -57, -55, -54, -52, -51, -51, -49, -48, -46,
-46, -44, -43, -42, -42, -41, -40, -39, -38, -38, -38, -37, -36, -37, -36, -35,
-35, -34, -34, -34, -34, -34, -34, -35, -34, -34, -34, -34, -34, -35, -36, -36,
-36, -36, -36, -37, -37, -38, -39, -39, -40, -40, -41, -42, -42, -44, -44, -45,
-45, -46, -47, -47, -48, -49, -49, -50, -52, -52, -53, -54, -55, -55, -55, -57,
-57, -58, -59, -60, -60, -62, -62, -63, -63, -64, -64, -66, -65, -66, -66, -66,
-68, -68, -68, -68, -69, -69, -70, -70, -71, -71, -71, -71, -71, -71, -72, -71,
-70, -70, -68, -68, -65, -65, -63, -60, -58, -57, -54, -51, -49, -46, -44, -40,
-38, -35, -31, -27, -23, -21, -17, -14, -9, -5, -2, };