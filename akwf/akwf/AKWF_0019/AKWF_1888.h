#define DATA_LENGTH 512
#define DATA AKWF_1888

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 6, 7, 9, 9, 10, 11, 11,
13, 13, 14, 13, 14, 15, 15, 16, 16, 17, 17, 17, 17, 18, 18, 18, 19, 19, 20, 20,
20, 21, 21, 22, 23, 24, 24, 25, 25, 27, 27, 27, 29, 30, 30, 31, 31, 33, 33, 34,
34, 36, 36, 37, 37, 38, 39, 38, 40, 41, 41, 41, 42, 43, 42, 43, 44, 44, 45, 46,
47, 47, 47, 48, 49, 50, 49, 50, 51, 52, 53, 53, 54, 55, 55, 57, 57, 58, 60, 60,
61, 62, 63, 64, 65, 66, 67, 69, 70, 70, 72, 72, 73, 74, 75, 75, 77, 78, 78, 79,
80, 81, 82, 82, 82, 84, 84, 85, 87, 87, 87, 88, 89, 90, 91, 92, 92, 93, 94, 94,
96, 97, 97, 97, 98, 99, 99, 100, 101, 102, 103, 104, 105, 105, 106, 108, 108,
109, 109, 111, 112, 112, 113, 113, 114, 115, 116, 116, 117, 117, 118, 118, 119,
118, 118, 118, 119, 119, 119, 119, 118, 119, 119, 118, 118, 118, 117, 117, 116,
115, 115, 114, 113, 112, 111, 109, 109, 108, 107, 106, 104, 104, 102, 102, 100,
98, 97, 95, 93, 92, 91, 89, 88, 85, 85, 83, 82, 81, 78, 77, 75, 74, 72, 71, 69,
67, 66, 65, 64, 62, 61, 60, 58, 57, 56, 54, 52, 52, 51, 49, 47, 47, 45, 44, 43,
41, 39, 38, 36, 35, 33, 31, 30, 28, 26, 24, 22, 20, 19, 16, 15, 13, 12, 10, 7,
6, 4, 2, 1, -1, -3, -5, -5, -8, -8, -10, -11, -12, -15, -15, -17, -18, -19, -20,
-21, -22, -24, -24, -25, -27, -27, -28, -29, -30, -31, -31, -31, -33, -34, -34,
-35, -36, -36, -37, -38, -38, -39, -40, -41, -42, -42, -43, -43, -45, -45, -45,
-45, -46, -47, -48, -49, -48, -49, -50, -51, -51, -52, -52, -52, -54, -54, -55,
-56, -56, -57, -58, -58, -58, -59, -61, -61, -62, -63, -62, -63, -63, -65, -65,
-66, -67, -67, -68, -68, -69, -70, -69, -71, -72, -72, -73, -73, -73, -75, -75,
-75, -76, -76, -77, -77, -79, -79, -79, -81, -80, -82, -83, -84, -85, -85, -86,
-86, -88, -88, -89, -90, -91, -92, -92, -93, -93, -94, -94, -96, -97, -98, -99,
-99, -100, -100, -101, -102, -103, -103, -102, -103, -104, -103, -104, -105,
-105, -105, -104, -105, -105, -105, -104, -104, -106, -104, -106, -105, -104,
-104, -104, -104, -104, -104, -103, -103, -103, -103, -104, -103, -103, -102,
-102, -102, -102, -102, -101, -100, -100, -100, -100, -99, -99, -98, -99, -98,
-97, -97, -97, -96, -96, -95, -95, -95, -93, -92, -92, -90, -90, -89, -88, -86,
-85, -85, -83, -82, -81, -79, -79, -77, -76, -75, -73, -71, -71, -69, -68, -67,
-65, -65, -64, -62, -60, -58, -56, -55, -54, -53, -50, -49, -47, -46, -44, -41,
-40, -39, -37, -34, -33, -31, -30, -27, -26, -24, -23, -21, -19, -17, -15, -13,
-11, -9, -8, -6, -4, -3, -2, 0, };