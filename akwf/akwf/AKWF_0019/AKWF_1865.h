#define DATA_LENGTH 512
#define DATA AKWF_1865

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 12, 14, 17, 21, 24, 26, 30,
31, 33, 36, 38, 42, 45, 47, 50, 53, 54, 57, 59, 63, 65, 69, 71, 73, 75, 78, 80,
82, 84, 86, 87, 89, 91, 92, 94, 96, 96, 98, 99, 100, 101, 102, 102, 104, 104,
105, 106, 107, 107, 109, 109, 109, 110, 111, 111, 111, 112, 112, 113, 114, 113,
114, 115, 114, 114, 115, 116, 115, 115, 116, 116, 116, 116, 116, 117, 117, 117,
118, 118, 118, 117, 117, 117, 117, 118, 117, 118, 118, 118, 118, 118, 118, 118,
118, 119, 118, 119, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 118, 119,
119, 120, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 119, 120, 119,
119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119, 119, 119, 118,
119, 118, 119, 119, 119, 119, 119, 119, 118, 119, 119, 118, 118, 116, 115, 114,
113, 112, 110, 108, 106, 105, 103, 102, 101, 100, 97, 95, 93, 91, 89, 87, 86,
85, 82, 80, 80, 78, 76, 74, 72, 70, 68, 66, 63, 60, 58, 55, 51, 49, 45, 42, 38,
35, 30, 26, 22, 19, 13, 9, 5, 2, -4, -9, -13, -17, -21, -25, -29, -32, -37, -41,
-45, -48, -52, -54, -58, -62, -65, -67, -69, -70, -73, -73, -74, -76, -77, -78,
-79, -80, -80, -81, -81, -80, -80, -80, -80, -80, -79, -80, -78, -76, -76, -75,
-74, -73, -71, -71, -70, -69, -68, -68, -67, -68, -69, -69, -70, -70, -70, -70,
-71, -71, -71, -71, -73, -72, -72, -73, -73, -73, -72, -73, -72, -72, -71, -70,
-69, -69, -68, -65, -65, -62, -61, -60, -59, -57, -56, -53, -50, -48, -47, -45,
-43, -42, -41, -39, -38, -37, -35, -33, -33, -32, -31, -32, -32, -32, -32, -33,
-33, -35, -36, -38, -40, -42, -45, -47, -49, -53, -54, -58, -61, -63, -67, -69,
-71, -74, -76, -78, -80, -82, -84, -85, -88, -89, -91, -92, -94, -95, -96, -97,
-99, -99, -100, -101, -103, -102, -103, -105, -106, -106, -106, -108, -109,
-109, -109, -109, -110, -110, -111, -110, -108, -109, -108, -107, -105, -105,
-104, -101, -99, -97, -95, -92, -90, -87, -85, -81, -79, -74, -72, -69, -66,
-64, -60, -58, -56, -53, -51, -49, -48, -45, -43, -42, -40, -39, -37, -36, -35,
-35, -34, -35, -34, -35, -34, -36, -36, -36, -37, -39, -38, -40, -40, -41, -43,
-42, -44, -46, -47, -49, -48, -49, -49, -49, -49, -50, -50, -50, -49, -50, -50,
-51, -51, -51, -51, -51, -52, -51, -51, -52, -51, -52, -52, -51, -52, -52, -52,
-54, -54, -55, -57, -58, -58, -59, -60, -61, -62, -64, -66, -68, -69, -70, -72,
-73, -73, -75, -76, -76, -79, -79, -80, -81, -82, -83, -83, -84, -84, -84, -84,
-83, -83, -82, -83, -81, -80, -78, -76, -73, -71, -68, -66, -62, -59, -56, -53,
-49, -45, -42, -39, -35, -32, -28, -24, -20, -16, -12, -9, -6, -3, -1, };