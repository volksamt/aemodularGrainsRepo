#define DATA_LENGTH 512
#define DATA AKWF_1893

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 3, 4, 5, 6, 6, 8, 9, 10, 10, 11,
12, 12, 14, 14, 15, 14, 16, 16, 17, 18, 18, 19, 20, 20, 21, 21, 22, 23, 24, 25,
26, 26, 27, 27, 28, 29, 30, 30, 31, 31, 33, 34, 33, 34, 35, 36, 36, 37, 38, 39,
39, 40, 40, 41, 42, 43, 43, 45, 45, 45, 46, 47, 48, 49, 49, 50, 51, 50, 52, 52,
53, 54, 54, 55, 56, 56, 57, 58, 58, 59, 60, 61, 61, 62, 63, 64, 64, 64, 66, 67,
66, 68, 69, 70, 69, 70, 71, 73, 73, 74, 74, 74, 75, 75, 77, 76, 76, 77, 78, 77,
77, 77, 77, 77, 78, 79, 80, 81, 82, 84, 86, 89, 91, 93, 96, 99, 101, 105, 108,
109, 112, 114, 114, 115, 115, 114, 113, 110, 108, 104, 100, 96, 91, 86, 80, 73,
66, 59, 51, 44, 36, 28, 19, 11, 1, -8, -18, -28, -38, -48, -58, -68, -77, -85,
-92, -100, -106, -113, -116, -120, -119, -119, -119, -120, -118, -119, -119,
-116, -112, -108, -105, -101, -98, -95, -92, -90, -88, -87, -85, -84, -83, -82,
-83, -82, -82, -82, -81, -81, -83, -82, -81, -81, -81, -80, -80, -80, -79, -78,
-77, -76, -76, -75, -74, -73, -73, -72, -71, -70, -69, -69, -68, -68, -67, -65,
-65, -64, -64, -63, -62, -62, -60, -60, -60, -59, -58, -58, -57, -56, -56, -54,
-54, -53, -52, -52, -51, -50, -49, -49, -48, -48, -47, -47, -45, -44, -45, -42,
-43, -42, -40, -40, -40, -39, -38, -37, -37, -36, -35, -34, -34, -33, -32, -33,
-31, -31, -29, -29, -28, -27, -28, -26, -25, -24, -24, -24, -23, -22, -21, -20,
-20, -19, -18, -18, -18, -16, -16, -15, -14, -13, -13, -12, -12, -11, -10, -9,
-8, -8, -8, -6, -6, -5, -5, -3, -3, -2, -2, -1, 0, 1, 1, 2, 3, 3, 4, 5, 6, 6, 6,
7, 8, 10, 9, 10, 11, 12, 13, 14, 14, 14, 15, 16, 16, 18, 18, 19, 20, 20, 21, 22,
22, 22, 24, 24, 25, 26, 27, 27, 28, 29, 30, 30, 31, 32, 32, 33, 33, 34, 35, 36,
36, 36, 37, 38, 38, 38, 38, 39, 39, 39, 40, 40, 42, 42, 43, 45, 46, 47, 50, 51,
53, 55, 57, 59, 61, 63, 65, 66, 66, 68, 68, 67, 66, 67, 65, 64, 62, 59, 58, 55,
52, 49, 45, 40, 37, 32, 29, 24, 18, 13, 8, 4, -4, -9, -15, -22, -28, -33, -40,
-46, -50, -54, -59, -61, -64, -67, -68, -70, -69, -68, -69, -67, -64, -62, -60,
-58, -56, -54, -50, -48, -46, -44, -44, -43, -41, -40, -39, -38, -38, -38, -37,
-36, -37, -36, -36, -36, -35, -35, -33, -34, -33, -33, -32, -31, -30, -29, -29,
-28, -27, -26, -26, -25, -25, -24, -24, -23, -21, -21, -20, -19, -19, -19, -17,
-16, -17, -16, -15, -14, -13, -13, -12, -12, -9, -9, -7, -7, -6, -5, -3, -3, -1,
0, };