#define DATA_LENGTH 512
#define DATA AKWF_1841

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 28, 44, 58, 69, 79, 86, 92, 97,
101, 105, 107, 109, 111, 113, 114, 115, 115, 116, 116, 117, 118, 117, 117, 118,
119, 119, 119, 118, 119, 120, 118, 119, 119, 118, 119, 119, 118, 119, 118, 120,
119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 120,
119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
118, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 118, 119,
119, 119, 120, 119, 118, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 113, 114, 114, 115, 116, 117, 117, 117, 118, 119, 117, 118, 118,
118, 118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 113, 80, 41, 14, -11,
-31, -44, -39, -32, -26, -22, -18, -14, -12, -10, -7, -6, -5, -5, -4, -2, -2,
-2, -2, -1, -1, -1, -1, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, -1, 0, 1, 0,
0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0,
0, 0, 0, 0, 11, 29, 45, 59, 69, 79, 86, 92, 97, 101, 104, 106, 110, 111, 112,
113, 114, 115, 116, 117, 117, 118, 118, 118, 118, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 120, 120, 119, 118, 120, 118, 119, 120, 119, 120, 119, 119, 119, 118,
119, 119, 119, 120, 119, 97, 57, 26, -1, -22, -40, -54, -66, -76, -83, -90, -95,
-99, -103, -106, -108, -111, -112, -113, -114, -115, -115, -116, -117, -118,
-118, -118, -118, -118, -118, -118, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -115, -87, -65, -56, -45, -36, -31, -24, -20, -16, -23,
-41, -55, -66, -76, -85, -90, -94, -66, -31, -4, 1, -10, -7, -7, -5, -4, -3, -3,
-3, -2, -2, -2, -1, -1, -1, 0, 0, -1, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 1, 0, 0,
-1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, -1, 0, 1, -1, 0, -1, 0,
1, 1, -9, -29, -43, -41, -33, -27, -23, -18, -15, -12, -10, -9, -7, -6, -4, -3,
-3, -2, -2, -2, -2, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0,
-1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0,
-1, 0, 0, 0, -1, 0, 0, 0, 0, };