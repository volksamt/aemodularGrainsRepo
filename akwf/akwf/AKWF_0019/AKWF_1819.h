#define DATA_LENGTH 512
#define DATA AKWF_1819

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 21, 32, 43, 52, 60, 68, 74, 79, 83,
86, 88, 90, 91, 91, 91, 90, 89, 89, 87, 86, 85, 83, 83, 81, 79, 77, 76, 74, 73,
71, 69, 68, 67, 65, 64, 62, 61, 59, 59, 57, 55, 54, 53, 52, 50, 50, 49, 49, 47,
46, 45, 44, 44, 42, 42, 41, 40, 39, 38, 37, 37, 36, 36, 35, 34, 34, 33, 32, 31,
31, 30, 30, 29, 29, 28, 27, 27, 27, 27, 26, 25, 26, 24, 24, 24, 24, 23, 22, 23,
21, 22, 21, 20, 20, 20, 20, 20, 19, 19, 18, 18, 18, 18, 17, 17, 16, 17, 16, 16,
16, 16, 15, 15, 14, 15, 14, 14, 14, 14, 13, 13, 13, 12, 13, 12, 12, 12, 12, 12,
11, 11, 11, 11, 10, 10, 9, 11, 10, 10, 9, 10, 9, 9, 9, 9, 9, 8, 8, 8, 8, 8, 8,
7, 8, 7, 8, 7, 7, 6, 7, 6, 7, 5, 6, 6, 6, 7, 5, 5, 4, 5, 5, 6, 4, 5, 4, 5, 4, 5,
4, 4, 4, 3, 4, 3, 4, 2, 7, 0, 10, -65, -63, 10, 0, 6, 1, 5, 3, 5, 3, 4, 5, 5, 5,
5, 5, 4, 6, 4, 6, 4, 6, 5, 5, 6, 6, 5, 6, 5, 5, 5, 6, 7, 6, 7, 7, 6, 7, 7, 7, 8,
7, 8, 8, 8, 8, 8, 9, 9, 9, 8, 8, 9, 10, 10, 10, 10, 10, 10, 10, 10, 11, 11, 11,
11, 11, 11, 11, 11, 12, 12, 12, 12, 13, 13, 13, 14, 14, 14, 15, 15, 15, 15, 16,
16, 16, 16, 17, 17, 16, 17, 18, 18, 18, 19, 19, 20, 19, 20, 20, 21, 20, 21, 21,
22, 21, 22, 23, 23, 24, 24, 25, 25, 25, 26, 26, 27, 27, 28, 29, 29, 30, 30, 30,
31, 32, 32, 33, 33, 34, 35, 35, 36, 37, 38, 38, 39, 40, 41, 42, 43, 44, 44, 46,
46, 47, 48, 49, 51, 51, 53, 54, 55, 56, 58, 58, 60, 62, 63, 64, 65, 67, 69, 71,
72, 73, 75, 76, 78, 80, 81, 83, 84, 85, 86, 88, 88, 87, 88, 87, 86, 85, 82, 80,
75, 70, 64, 57, 49, 39, 29, 18, 5, -7, -20, -33, -45, -57, -68, -77, -86, -93,
-100, -105, -109, -113, -115, -117, -118, -119, -120, -118, -118, -117, -116,
-115, -114, -113, -111, -109, -108, -106, -104, -103, -101, -100, -98, -96, -95,
-94, -92, -91, -90, -88, -86, -85, -85, -82, -82, -81, -80, -77, -77, -75, -75,
-75, -74, -72, -70, -71, -72, -71, -71, -70, -72, -71, -71, -70, -71, -71, -71,
-70, -71, -71, -71, -71, -71, -73, -73, -75, -75, -76, -77, -79, -80, -81, -82,
-83, -84, -86, -88, -89, -89, -91, -92, -93, -95, -97, -99, -100, -101, -102,
-104, -106, -107, -109, -111, -112, -113, -114, -115, -116, -116, -117, -116,
-115, -114, -111, -109, -105, -100, -95, -89, -80, -72, -60, -50, -39, -26, -13,
-2, };