#define DATA_LENGTH 512
#define DATA AKWF_1861

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 8, 11, 12, 15, 18, 21, 24,
25, 28, 30, 33, 35, 38, 39, 42, 43, 46, 46, 50, 52, 53, 54, 55, 58, 59, 61, 62,
63, 65, 66, 68, 68, 71, 72, 72, 74, 74, 76, 78, 79, 80, 81, 82, 84, 85, 86, 87,
89, 91, 92, 93, 96, 97, 98, 99, 101, 103, 104, 106, 107, 108, 109, 109, 110,
111, 112, 111, 112, 113, 113, 113, 113, 113, 113, 112, 112, 112, 111, 112, 111,
110, 110, 109, 108, 108, 107, 106, 106, 105, 104, 103, 102, 102, 99, 99, 98, 96,
95, 94, 94, 92, 90, 89, 89, 87, 86, 86, 85, 83, 83, 81, 81, 81, 79, 78, 78, 78,
76, 75, 73, 72, 73, 72, 69, 69, 69, 67, 67, 66, 65, 65, 64, 64, 62, 62, 62, 61,
61, 60, 61, 60, 60, 59, 59, 59, 59, 59, 59, 59, 58, 58, 58, 58, 57, 56, 54, 54,
54, 53, 52, 51, 50, 48, 48, 45, 45, 43, 42, 40, 39, 37, 36, 34, 32, 32, 29, 27,
26, 25, 23, 22, 21, 20, 18, 17, 17, 15, 15, 14, 14, 14, 12, 12, 13, 13, 12, 13,
13, 12, 13, 13, 14, 14, 14, 15, 15, 16, 16, 16, 16, 16, 17, 17, 17, 16, 17, 18,
17, 18, 17, 17, 18, 19, 19, 20, 19, 19, 21, 20, 21, 21, 21, 21, 21, 21, 22, 21,
22, 22, 22, 21, 22, 20, 20, 19, 19, 19, 17, 16, 16, 15, 13, 12, 11, 10, 8, 7, 7,
5, 4, 3, 1, 0, -1, -2, -4, -5, -6, -7, -7, -9, -10, -10, -12, -12, -13, -14,
-15, -16, -17, -18, -18, -20, -20, -21, -22, -23, -23, -23, -24, -24, -24, -26,
-27, -27, -27, -27, -29, -29, -30, -31, -31, -32, -33, -34, -35, -36, -37, -38,
-40, -42, -43, -46, -47, -49, -51, -53, -54, -56, -58, -60, -61, -63, -64, -67,
-68, -69, -70, -71, -72, -72, -72, -72, -72, -71, -71, -70, -69, -68, -65, -64,
-62, -60, -57, -55, -52, -50, -47, -45, -43, -40, -38, -36, -34, -32, -31, -30,
-29, -28, -28, -27, -27, -27, -28, -28, -29, -30, -31, -31, -32, -33, -34, -35,
-37, -39, -40, -42, -43, -45, -47, -49, -51, -53, -56, -57, -60, -62, -64, -66,
-69, -70, -72, -75, -75, -78, -79, -80, -83, -85, -86, -88, -88, -90, -92, -93,
-94, -95, -96, -97, -98, -100, -101, -103, -103, -105, -105, -106, -108, -110,
-110, -111, -112, -113, -114, -114, -116, -118, -118, -117, -119, -119, -119,
-119, -119, -118, -119, -118, -118, -117, -117, -116, -115, -115, -114, -113,
-111, -110, -109, -107, -106, -104, -102, -101, -99, -97, -95, -93, -91, -88,
-87, -84, -82, -79, -78, -76, -73, -72, -70, -69, -66, -65, -63, -62, -60, -58,
-57, -56, -54, -52, -51, -50, -49, -47, -45, -44, -42, -41, -40, -37, -35, -34,
-33, -31, -29, -28, -27, -25, -23, -20, -19, -17, -15, -13, -11, -10, -7, -5,
-4, -1, };