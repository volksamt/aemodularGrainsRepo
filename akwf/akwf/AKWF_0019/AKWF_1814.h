#define DATA_LENGTH 512
#define DATA AKWF_1814

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 12, 19, 26, 32, 37, 43, 48, 53, 58,
63, 68, 71, 76, 78, 82, 84, 88, 91, 93, 95, 98, 100, 101, 104, 105, 106, 107,
109, 110, 111, 112, 114, 115, 114, 115, 116, 116, 117, 117, 118, 119, 119, 119,
118, 119, 119, 119, 119, 119, 119, 118, 118, 119, 119, 118, 117, 117, 118, 116,
116, 115, 115, 115, 114, 114, 113, 112, 111, 111, 110, 109, 108, 107, 105, 104,
103, 102, 100, 99, 97, 96, 94, 93, 91, 87, 87, 84, 82, 80, 78, 75, 73, 70, 67,
64, 61, 58, 56, 53, 49, 47, 43, 40, 37, 34, 30, 26, 24, 19, 17, 14, 11, 8, 4, 1,
-1, -5, -8, -11, -14, -16, -18, -22, -24, -27, -29, -31, -34, -37, -39, -41,
-44, -45, -47, -48, -50, -51, -54, -55, -57, -57, -59, -60, -61, -63, -62, -64,
-64, -65, -64, -64, -64, -64, -63, -63, -62, -61, -60, -59, -57, -56, -54, -53,
-51, -48, -46, -44, -40, -38, -36, -32, -29, -26, -23, -19, -17, -13, -9, -6,
-2, 0, 4, 7, 11, 13, 18, 20, 23, 26, 28, 31, 33, 37, 40, 42, 44, 46, 48, 49, 50,
52, 53, 54, 56, 57, 58, 58, 59, 60, 59, 60, 61, 62, 61, 61, 60, 60, 59, 59, 58,
58, 57, 56, 55, 54, 53, 53, 51, 51, 50, 48, 47, 46, 44, 44, 43, 41, 41, 39, 38,
36, 36, 35, 34, 33, 32, 31, 30, 29, 28, 28, 27, 25, 24, 22, 22, 21, 18, 17, 16,
14, 13, 11, 9, 7, 6, 3, 2, -1, -4, -7, -10, -13, -16, -19, -23, -28, -31, -36,
-40, -45, -49, -55, -59, -64, -65, -64, -62, -60, -59, -57, -55, -55, -53, -52,
-50, -49, -48, -48, -45, -45, -45, -44, -44, -43, -43, -43, -42, -42, -43, -42,
-43, -42, -43, -42, -43, -43, -43, -43, -43, -43, -43, -43, -43, -43, -44, -42,
-43, -44, -43, -43, -42, -43, -42, -43, -42, -42, -42, -42, -42, -43, -42, -41,
-42, -42, -42, -43, -42, -42, -41, -41, -42, -41, -41, -41, -41, -42, -43, -42,
-42, -42, -42, -42, -42, -42, -42, -42, -43, -43, -42, -42, -42, -42, -43, -43,
-43, -44, -44, -43, -44, -44, -44, -45, -45, -45, -46, -45, -46, -46, -46, -47,
-47, -46, -48, -47, -47, -48, -47, -47, -47, -47, -48, -47, -47, -48, -47, -47,
-46, -47, -47, -47, -46, -46, -46, -46, -45, -45, -45, -44, -45, -45, -45, -44,
-45, -44, -45, -44, -44, -44, -44, -43, -43, -43, -43, -43, -43, -44, -44, -44,
-43, -43, -44, -43, -44, -44, -44, -44, -44, -43, -44, -44, -45, -45, -44, -44,
-45, -45, -45, -45, -44, -45, -44, -44, -45, -45, -45, -44, -44, -43, -44, -42,
-43, -43, -42, -41, -42, -41, -41, -40, -39, -40, -39, -40, -39, -40, -39, -40,
-40, -40, -41, -43, -44, -44, -45, -48, -49, -51, -52, -54, -56, -58, -61, -61,
-54, -46, -38, -31, -22, -15, -7, -1, };