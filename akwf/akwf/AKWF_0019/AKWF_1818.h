#define DATA_LENGTH 512
#define DATA AKWF_1818

const PROGMEM int8_t DATA[DATA_LENGTH] = {96, 115, 106, 114, 108, 113, 107, 111,
108, 111, 109, 111, 110, 111, 110, 112, 111, 111, 110, 111, 111, 111, 110, 110,
111, 111, 111, 111, 111, 111, 112, 110, 111, 111, 111, 112, 111, 111, 110, 111,
103, 100, 102, 101, 101, 101, 100, 100, 100, 100, 101, 101, 100, 101, 100, 100,
100, 100, 100, 100, 101, 100, 101, 99, 101, 99, 101, 97, 102, 98, 102, 97, 103,
96, 104, 93, -37, -44, -38, -43, -38, -43, -39, -43, -39, -42, -39, -42, -40,
-42, -40, -42, -39, -41, -40, -41, -41, -41, -40, -40, -41, -40, -41, -41, -41,
-41, -41, -40, -41, -40, -40, -40, -41, -41, -41, -41, -40, -40, -41, -41, -40,
-41, -40, -41, -41, -41, -40, -40, -41, -40, -40, -40, -40, -41, -39, -40, -40,
-39, -40, -40, -40, -39, -40, -40, -39, -40, -40, -40, -40, -40, -40, -40, -40,
-40, -40, -40, -39, -40, -40, -39, -40, -39, -40, -40, -39, -39, -39, -40, -40,
-39, -39, -40, -39, -40, -39, -40, -40, -39, -39, -39, -39, -39, -39, -39, -40,
-40, -39, -40, -39, -38, -39, -40, -38, -38, -39, -39, -39, -39, -39, -39, -38,
-38, -39, -38, -39, -39, -39, -39, -39, -38, -38, -39, -38, -39, -38, -38, -38,
-38, -38, -38, -39, -39, -39, -38, -38, -39, -38, -38, -38, -39, -38, -39, -38,
-38, -38, -38, -39, -37, -38, -37, -38, -38, -40, -38, -39, -37, -39, -37, -39,
-37, -38, -38, -38, -38, -37, -38, -37, -40, -35, -41, -33, -44, -27, -57, 41,
127, 109, 125, 113, 122, 117, 120, 117, 119, 119, 119, 119, 118, 119, 118, 120,
118, 120, 118, 120, 119, 120, 119, 119, 119, 118, 119, 119, 120, 117, 121, 116,
92, 92, 93, 91, 93, 90, 93, 90, 92, 91, 93, 91, 91, 90, 91, 91, 91, 91, 91, 91,
91, 92, 90, 92, 89, 94, 86, 97, 82, 106, 40, -57, -34, -46, -38, -43, -40, -41,
-41, -41, -42, -41, -41, -41, -42, -40, -42, -40, -43, -41, -43, -41, -42, -41,
-41, -41, -41, -40, -41, -40, -41, -41, -41, -41, -40, -41, -40, -42, -40, -41,
-40, -41, -40, -41, -41, -41, -41, -41, -40, -41, -41, -41, -40, -41, -41, -41,
-41, -40, -41, -40, -40, -40, -41, -40, -41, -41, -40, -39, -40, -41, -40, -40,
-40, -40, -41, -41, -41, -40, -40, -40, -39, -40, -40, -40, -40, -40, -40, -40,
-40, -40, -40, -40, -41, -41, -40, -40, -40, -40, -39, -39, -40, -39, -40, -40,
-40, -39, -39, -40, -39, -40, -39, -39, -39, -39, -40, -39, -39, -39, -39, -40,
-38, -39, -39, -40, -38, -40, -39, -39, -39, -39, -39, -40, -39, -38, -39, -39,
-39, -39, -38, -38, -39, -39, -39, -39, -39, -39, -39, -38, -38, -39, -38, -39,
-39, -38, -39, -38, -39, -38, -38, -38, -39, -38, -39, -38, -38, -38, -39, -38,
-38, -38, -38, -38, -37, -39, -38, -39, -37, -39, -38, -39, -36, -40, -36, -40,
-32, };