#define DATA_LENGTH 512
#define DATA AKWF_1854

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 7, 9, 11, 13, 14, 17, 19, 22,
24, 25, 27, 29, 32, 35, 37, 40, 41, 44, 45, 48, 49, 52, 55, 57, 58, 61, 63, 65,
68, 70, 71, 73, 75, 77, 79, 81, 82, 85, 86, 88, 90, 92, 93, 94, 96, 98, 99, 101,
102, 103, 104, 106, 107, 108, 110, 110, 111, 112, 113, 115, 115, 115, 116, 117,
117, 118, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 118,
117, 116, 116, 116, 114, 114, 113, 112, 110, 109, 109, 107, 105, 104, 103, 101,
101, 98, 97, 95, 93, 91, 89, 88, 85, 84, 82, 80, 77, 76, 73, 71, 70, 67, 66, 63,
61, 59, 57, 55, 53, 50, 49, 46, 45, 42, 40, 39, 37, 35, 34, 31, 30, 28, 26, 25,
22, 21, 18, 17, 16, 14, 12, 10, 9, 6, 5, 3, 1, 0, -2, -4, -5, -7, -9, -10, -12,
-14, -14, -16, -17, -20, -22, -23, -25, -26, -27, -28, -29, -31, -32, -34, -35,
-36, -37, -39, -40, -41, -42, -43, -44, -45, -46, -47, -48, -49, -49, -50, -52,
-52, -53, -53, -54, -55, -56, -56, -56, -57, -57, -59, -58, -59, -59, -59, -59,
-60, -60, -60, -60, -60, -60, -61, -61, -62, -61, -61, -61, -61, -61, -62, -61,
-61, -61, -62, -61, -61, -61, -62, -61, -61, -61, -61, -61, -61, -61, -61, -61,
-60, -61, -61, -60, -60, -60, -60, -59, -60, -59, -59, -58, -58, -58, -57, -57,
-56, -56, -55, -55, -54, -54, -52, -52, -52, -51, -52, -50, -50, -50, -48, -48,
-47, -47, -46, -46, -45, -44, -43, -43, -42, -41, -40, -39, -39, -37, -37, -35,
-36, -33, -33, -31, -31, -31, -30, -29, -27, -26, -26, -25, -23, -22, -22, -20,
-19, -18, -17, -16, -16, -14, -13, -13, -12, -11, -11, -10, -8, -8, -7, -7, -5,
-5, -4, -3, -3, -2, -2, 0, -1, 0, 1, 1, 2, 2, 3, 4, 4, 4, 5, 5, 5, 5, 7, 7, 6,
7, 7, 8, 7, 7, 8, 8, 7, 7, 7, 7, 7, 5, 5, 4, 5, 4, 2, 3, 2, 1, 1, 0, 0, -1, -1,
-3, -3, -3, -5, -5, -6, -6, -6, -8, -8, -8, -10, -9, -10, -10, -11, -11, -11,
-12, -13, -14, -14, -14, -15, -15, -15, -16, -17, -17, -17, -17, -18, -19, -19,
-19, -20, -21, -21, -22, -23, -23, -24, -24, -25, -26, -26, -27, -27, -28, -29,
-29, -29, -30, -31, -31, -32, -33, -34, -35, -34, -35, -37, -36, -37, -38, -39,
-40, -41, -40, -41, -42, -43, -43, -44, -45, -45, -45, -45, -46, -46, -46, -47,
-47, -47, -46, -47, -48, -48, -47, -47, -47, -47, -46, -46, -45, -45, -45, -44,
-43, -43, -42, -42, -42, -40, -39, -39, -38, -37, -36, -36, -35, -34, -33, -33,
-31, -30, -29, -28, -28, -27, -26, -25, -24, -24, -21, -21, -20, -19, -18, -17,
-15, -14, -12, -12, -10, -8, -6, -5, -4, -3, -1, };