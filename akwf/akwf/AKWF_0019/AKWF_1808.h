#define DATA_LENGTH 512
#define DATA AKWF_1808

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 0, 0, 2, 1, 2, 1, 1, 0, 1, 1, 2,
1, 1, 2, 3, 3, 3, 4, 3, 3, 3, 4, 4, 4, 3, 5, 6, 6, 6, 6, 7, 8, 8, 9, 9, 9, 9, 9,
10, 10, 11, 11, 11, 12, 13, 14, 15, 15, 16, 16, 16, 18, 19, 21, 23, 24, 25, 25,
28, 29, 30, 31, 32, 33, 34, 37, 39, 42, 45, 64, 100, 121, 106, 74, 54, 58, 76,
91, 93, 86, 78, 79, 86, 93, 94, 93, 92, 92, 94, 97, 96, 96, 95, 95, 96, 98, 98,
98, 98, 99, 99, 99, 99, 98, 98, 99, 99, 98, 98, 98, 98, 96, 96, 95, 94, 92, 92,
90, 90, 88, 87, 85, 83, 82, 81, 79, 78, 76, 75, 73, 71, 68, 68, 65, 63, 60, 58,
56, 53, 51, 48, 47, 43, 42, 40, 37, 34, 32, 30, 27, 24, 22, 20, 17, 15, 12, 10,
8, 5, 2, 0, -3, -5, -8, -10, -12, -13, -16, -18, -21, -22, -25, -26, -29, -31,
-33, -35, -36, -39, -41, -44, -45, -47, -48, -50, -52, -53, -54, -55, -57, -58,
-61, -62, -62, -65, -65, -67, -67, -68, -70, -70, -71, -72, -73, -73, -75, -77,
-77, -77, -78, -79, -79, -80, -80, -80, -81, -81, -81, -81, -82, -82, -81, -82,
-82, -82, -81, -81, -82, -81, -81, -81, -80, -80, -80, -79, -80, -79, -79, -78,
-78, -77, -76, -76, -74, -74, -73, -72, -71, -70, -68, -68, -67, -67, -65, -64,
-64, -63, -61, -61, -59, -58, -57, -56, -55, -53, -52, -51, -49, -49, -47, -45,
-44, -42, -41, -39, -38, -36, -36, -34, -33, -31, -31, -29, -29, -27, -27, -24,
-23, -22, -20, -19, -18, -16, -15, -13, -13, -12, -10, -8, -7, -6, -4, -2, -1,
0, 2, 3, 3, 3, 4, 3, 5, 7, 7, 8, 9, 9, 9, 10, 11, 10, 9, 9, 7, 6, -14, -50, -65,
-45, -11, 8, 3, -14, -26, -25, -16, -9, -9, -13, -19, -19, -18, -14, -14, -15,
-16, -15, -13, -12, -12, -12, -12, -12, -12, -11, -12, -12, -10, -11, -11, -10,
-10, -10, -9, -9, -8, -8, -8, -8, -7, -7, -7, -6, -6, -6, -5, -5, -5, -4, -4,
-3, -3, -2, -2, -1, -2, 0, -1, 0, 0, 1, 2, 2, 1, 2, 2, 2, 3, 4, 4, 5, 5, 6, 5,
6, 5, 6, 7, 6, 7, 6, 6, 6, 8, 7, 7, 7, 8, 8, 6, 7, 8, 8, 8, 9, 9, 9, 9, 9, 8, 9,
7, 8, 7, 8, 8, 8, 6, 5, 5, 6, 7, 6, 6, 5, 4, 4, 4, 4, 3, 4, 4, 3, 3, 4, 3, 3, 3,
2, 2, 3, 3, 3, 2, 3, 3, 3, 4, 4, 5, 4, 4, 4, 5, 4, 4, 3, 2, 2, 2, 2, 3, 2, 3, 4,
4, 5, 4, 3, 3, 3, 2, 2, 2, 2, 2, 3, 2, 3, 2, 2, 1, 1, 0, 0, 0, -1, -2, -1, 0, };