#define DATA_LENGTH 512
#define DATA AKWF_1850

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 4, 7, 12, 19, 26, 30, 34, 37,
40, 43, 44, 46, 48, 49, 50, 52, 52, 53, 53, 53, 55, 54, 55, 55, 55, 56, 55, 55,
55, 56, 56, 55, 56, 56, 56, 56, 56, 56, 56, 57, 56, 61, 67, 72, 77, 79, 82, 85,
87, 89, 91, 91, 92, 94, 95, 95, 96, 96, 96, 97, 98, 97, 98, 98, 99, 99, 98, 99,
99, 98, 94, 88, 84, 80, 76, 73, 71, 68, 66, 64, 64, 63, 61, 60, 59, 59, 59, 58,
58, 57, 58, 56, 57, 57, 57, 55, 57, 56, 56, 55, 56, 56, 56, 56, 57, 55, 57, 63,
68, 73, 77, 79, 83, 86, 88, 89, 91, 92, 93, 95, 95, 95, 96, 96, 97, 97, 98, 98,
97, 97, 99, 98, 98, 98, 99, 98, 99, 98, 98, 99, 99, 98, 99, 99, 99, 99, 98, 92,
87, 82, 78, 74, 72, 69, 68, 65, 64, 62, 61, 60, 59, 58, 58, 58, 57, 56, 57, 56,
57, 55, 56, 55, 56, 55, 56, 55, 55, 56, 55, 55, 56, 54, 55, 55, 54, 55, 55, 54,
55, 54, 54, 55, 54, 55, 55, 55, 55, 54, 49, 44, 39, 35, 32, 28, 26, 23, 22, 20,
19, 17, 16, 16, 14, 14, 14, 14, 13, 12, 13, 12, 12, 12, 12, 11, 11, 12, 12, 12,
11, 12, 12, 11, 12, 11, 11, 11, 11, 15, 20, 26, 29, 27, 23, 22, 21, 19, 18, 18,
15, 15, 15, 15, 20, 26, 30, 34, 38, 40, 42, 44, 45, 47, 48, 49, 48, 42, 38, 34,
30, 27, 24, 23, 21, 20, 17, 17, 16, 14, 14, 15, 14, 13, 12, 13, 12, 12, 12, 12,
11, 11, 12, 12, 11, 11, 11, 11, 12, 10, 11, 11, 11, 11, 12, 11, 11, 8, 4, -3,
-12, -22, -30, -36, -43, -48, -52, -55, -59, -61, -64, -66, -67, -74, -81, -86,
-92, -96, -100, -103, -105, -108, -109, -111, -112, -114, -114, -115, -116,
-116, -117, -117, -118, -117, -118, -118, -119, -118, -118, -119, -119, -119,
-119, -118, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -118, -116,
-110, -105, -100, -97, -94, -91, -88, -86, -85, -83, -82, -81, -80, -79, -78,
-78, -78, -78, -76, -77, -76, -76, -76, -76, -76, -76, -75, -75, -75, -75, -76,
-75, -75, -76, -75, -76, -75, -75, -75, -75, -75, -75, -75, -75, -75, -75, -74,
-75, -75, -75, -74, -75, -75, -74, -75, -75, -75, -75, -75, -75, -75, -75, -75,
-74, -74, -74, -75, -75, -75, -74, -75, -75, -75, -75, -74, -74, -75, -75, -75,
-75, -74, -75, -75, -75, -75, -74, -74, -75, -73, -74, -74, -75, -75, -74, -75,
-74, -74, -75, -74, -75, -74, -69, -64, -58, -54, -50, -47, -46, -43, -41, -40,
-38, -37, -37, -35, -34, -35, -34, -33, -33, -32, -32, -32, -32, -32, -32, -30,
-23, -17, -14, -9, -6, -2, 0, };