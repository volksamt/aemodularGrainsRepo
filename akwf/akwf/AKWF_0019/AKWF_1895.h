#define DATA_LENGTH 512
#define DATA AKWF_1895

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 3, 2, 3, 4, 5, 6, 7, 7, 8,
10, 12, 12, 14, 15, 17, 18, 20, 21, 23, 24, 27, 28, 30, 31, 32, 33, 35, 37, 38,
39, 41, 42, 44, 45, 46, 48, 48, 51, 51, 53, 55, 56, 57, 59, 59, 61, 63, 64, 65,
66, 67, 67, 69, 70, 72, 73, 74, 76, 76, 77, 79, 80, 81, 83, 83, 84, 85, 87, 88,
88, 90, 90, 91, 92, 93, 94, 95, 96, 97, 97, 99, 99, 100, 101, 101, 102, 104,
104, 105, 105, 106, 106, 108, 108, 109, 109, 110, 111, 110, 111, 112, 113, 113,
114, 113, 114, 115, 116, 116, 115, 116, 116, 117, 117, 118, 117, 118, 118, 119,
118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 119, 118,
119, 119, 119, 119, 118, 118, 118, 117, 117, 117, 116, 116, 116, 116, 114, 114,
114, 114, 113, 113, 113, 111, 111, 111, 110, 110, 109, 109, 108, 107, 106, 106,
105, 104, 104, 104, 102, 102, 100, 101, 100, 98, 98, 97, 96, 94, 94, 93, 92, 91,
90, 90, 88, 88, 86, 86, 85, 84, 83, 82, 81, 78, 78, 77, 75, 75, 73, 72, 71, 70,
69, 67, 66, 65, 63, 62, 61, 60, 59, 58, 56, 54, 53, 51, 50, 50, 47, 47, 45, 44,
42, 42, 39, 38, 37, 36, 33, 33, 32, 30, 29, 27, 26, 24, 23, 21, 20, 18, 16, 15,
13, 12, 11, 9, 8, 6, 5, 3, 2, 1, -2, -3, -5, -6, -7, -8, -10, -11, -13, -15,
-16, -17, -19, -20, -22, -24, -25, -26, -28, -30, -31, -31, -34, -35, -36, -38,
-39, -41, -42, -43, -45, -46, -47, -49, -50, -52, -52, -55, -55, -56, -58, -59,
-60, -62, -63, -65, -66, -67, -68, -69, -71, -72, -72, -74, -76, -77, -77, -78,
-80, -80, -82, -83, -84, -84, -86, -87, -88, -90, -90, -91, -93, -93, -94, -95,
-96, -97, -98, -99, -99, -100, -101, -102, -103, -103, -103, -104, -105, -106,
-107, -107, -108, -108, -109, -110, -110, -111, -111, -112, -112, -113, -113,
-113, -114, -114, -114, -115, -116, -116, -117, -116, -117, -117, -117, -117,
-118, -118, -118, -118, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -118, -119, -119, -119, -118, -119, -118, -118, -118, -118, -118, -117,
-118, -118, -116, -116, -117, -116, -116, -115, -115, -114, -113, -113, -112,
-113, -112, -111, -111, -110, -110, -109, -108, -107, -107, -106, -106, -104,
-105, -103, -103, -102, -102, -101, -99, -99, -98, -97, -96, -95, -94, -93, -93,
-92, -91, -90, -88, -89, -86, -85, -85, -84, -82, -82, -80, -80, -78, -77, -75,
-75, -73, -73, -71, -70, -68, -68, -66, -65, -64, -62, -61, -60, -59, -57, -56,
-55, -54, -52, -51, -50, -48, -47, -45, -45, -43, -41, -40, -39, -37, -36, -35,
-32, -31, -30, -29, -27, -26, -24, -22, -20, -18, -17, -16, -14, -13, -11, -10,
-9, -7, -7, -5, -3, -3, -2, -1, -1, };