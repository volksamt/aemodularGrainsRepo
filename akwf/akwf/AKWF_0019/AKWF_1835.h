#define DATA_LENGTH 512
#define DATA AKWF_1835

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 7, 10, 11, 13, 16, 18, 20,
21, 23, 25, 26, 27, 28, 30, 31, 32, 33, 34, 35, 36, 37, 39, 38, 39, 40, 41, 42,
42, 42, 43, 43, 43, 44, 43, 43, 44, 44, 43, 43, 44, 44, 44, 43, 43, 43, 43, 43,
42, 42, 42, 41, 40, 40, 40, 39, 39, 39, 38, 37, 36, 37, 36, 36, 35, 34, 34, 33,
33, 33, 31, 30, 30, 30, 29, 29, 28, 28, 26, 26, 25, 25, 25, 24, 23, 22, 23, 21,
21, 21, 20, 19, 19, 18, 18, 17, 18, 17, 16, 16, 16, 15, 15, 15, 14, 13, 13, 13,
13, 14, 13, 13, 13, 13, 12, 12, 13, 13, 13, 14, 13, 15, 15, 15, 16, 16, 17, 17,
18, 18, 19, 20, 21, 22, 22, 24, 25, 26, 27, 28, 29, 30, 33, 34, 36, 37, 38, 41,
42, 45, 46, 48, 50, 52, 53, 56, 58, 61, 62, 64, 67, 69, 71, 73, 76, 77, 79, 82,
84, 87, 89, 90, 92, 94, 96, 98, 100, 101, 103, 105, 106, 107, 109, 110, 111,
113, 113, 115, 114, 115, 117, 117, 118, 118, 119, 119, 118, 119, 119, 119, 120,
119, 118, 118, 118, 118, 117, 116, 116, 115, 114, 114, 113, 111, 111, 110, 108,
108, 107, 106, 105, 103, 102, 102, 100, 99, 97, 96, 95, 93, 92, 91, 89, 88, 86,
84, 83, 81, 79, 78, 77, 76, 74, 73, 71, 69, 68, 66, 64, 63, 61, 60, 58, 57, 55,
53, 51, 49, 49, 47, 45, 43, 41, 41, 38, 37, 35, 34, 33, 31, 30, 28, 27, 25, 24,
23, 21, 19, 19, 17, 16, 14, 14, 11, 11, 10, 8, 6, 5, 4, 3, 2, 1, -1, -2, -3, -4,
-5, -7, -8, -8, -9, -11, -12, -13, -14, -15, -16, -17, -18, -20, -21, -22, -23,
-24, -25, -27, -27, -28, -29, -30, -30, -32, -33, -33, -34, -35, -36, -37, -38,
-38, -39, -40, -41, -41, -42, -43, -43, -44, -45, -46, -47, -47, -47, -48, -48,
-49, -50, -51, -51, -51, -52, -52, -52, -54, -54, -54, -54, -55, -56, -57, -56,
-58, -59, -59, -60, -61, -61, -62, -63, -64, -65, -65, -66, -67, -67, -70, -69,
-71, -71, -72, -74, -75, -77, -77, -78, -79, -79, -80, -83, -83, -84, -85, -86,
-87, -88, -89, -90, -91, -92, -94, -94, -95, -97, -97, -98, -99, -100, -102,
-102, -103, -103, -105, -106, -107, -108, -109, -109, -110, -111, -111, -112,
-113, -114, -115, -115, -115, -115, -116, -116, -116, -117, -117, -117, -118,
-118, -118, -117, -117, -117, -118, -117, -117, -116, -117, -115, -116, -114,
-114, -113, -113, -112, -112, -111, -110, -109, -108, -107, -106, -106, -104,
-104, -102, -101, -100, -98, -97, -96, -94, -93, -91, -90, -88, -87, -84, -83,
-81, -79, -78, -76, -73, -72, -69, -67, -64, -62, -60, -58, -54, -53, -50, -48,
-46, -43, -40, -38, -34, -32, -29, -26, -23, -21, -18, -16, -14, -11, -9, -6,
-4, -1, };