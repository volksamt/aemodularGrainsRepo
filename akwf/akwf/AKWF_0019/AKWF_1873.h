#define DATA_LENGTH 512
#define DATA AKWF_1873

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 8, 11, 13, 16, 19, 23, 25, 28,
31, 34, 37, 40, 42, 45, 48, 51, 54, 57, 60, 62, 66, 68, 70, 73, 75, 78, 80, 83,
85, 88, 90, 92, 95, 97, 99, 100, 102, 104, 105, 107, 108, 110, 110, 112, 113,
114, 115, 116, 117, 117, 118, 118, 119, 119, 119, 119, 119, 119, 119, 118, 118,
118, 118, 117, 117, 116, 115, 115, 114, 113, 111, 110, 109, 108, 107, 106, 104,
104, 102, 101, 100, 99, 97, 97, 94, 93, 92, 90, 90, 87, 87, 86, 84, 83, 82, 80,
79, 78, 76, 75, 75, 74, 72, 71, 69, 69, 68, 66, 66, 65, 64, 63, 62, 61, 59, 59,
57, 57, 56, 56, 55, 53, 53, 51, 50, 50, 48, 48, 46, 45, 45, 44, 42, 41, 39, 38,
37, 35, 34, 33, 32, 30, 29, 26, 25, 24, 22, 21, 19, 17, 15, 14, 12, 10, 8, 8, 6,
3, 1, -1, -1, -4, -5, -6, -9, -10, -13, -13, -15, -17, -17, -20, -21, -23, -24,
-25, -27, -27, -29, -30, -31, -32, -34, -34, -36, -37, -37, -39, -40, -40, -40,
-41, -42, -43, -43, -44, -43, -44, -44, -45, -45, -45, -46, -46, -46, -45, -46,
-45, -45, -44, -45, -45, -45, -43, -44, -43, -43, -42, -42, -42, -41, -40, -41,
-40, -38, -39, -37, -37, -36, -36, -35, -34, -33, -32, -31, -30, -29, -29, -27,
-27, -26, -24, -23, -22, -21, -20, -19, -17, -16, -14, -12, -12, -10, -8, -6,
-5, -3, -1, 0, 2, 3, 6, 8, 10, 11, 13, 15, 16, 19, 21, 22, 24, 25, 28, 30, 31,
33, 35, 37, 38, 40, 41, 43, 45, 46, 47, 48, 49, 50, 52, 53, 53, 55, 55, 56, 56,
57, 57, 58, 58, 58, 58, 58, 58, 58, 58, 57, 57, 56, 56, 54, 55, 53, 53, 51, 50,
49, 48, 46, 44, 43, 42, 41, 39, 37, 35, 34, 32, 30, 28, 26, 24, 23, 20, 18, 17,
15, 12, 10, 8, 6, 4, 2, 0, -2, -5, -6, -8, -10, -12, -13, -16, -18, -20, -21,
-22, -24, -27, -28, -29, -31, -33, -34, -36, -37, -38, -41, -41, -43, -44, -46,
-46, -47, -49, -50, -50, -52, -53, -55, -56, -57, -57, -58, -60, -61, -63, -63,
-65, -65, -66, -68, -68, -70, -71, -73, -74, -76, -76, -78, -79, -81, -81, -82,
-84, -84, -86, -87, -88, -90, -91, -92, -94, -95, -96, -98, -98, -99, -100,
-101, -102, -103, -104, -104, -106, -106, -107, -107, -109, -109, -110, -110,
-111, -110, -110, -112, -112, -112, -112, -111, -111, -112, -111, -112, -112,
-111, -110, -110, -109, -108, -108, -108, -107, -106, -105, -104, -104, -102,
-101, -100, -99, -98, -96, -95, -94, -92, -91, -90, -88, -87, -85, -84, -82,
-80, -79, -77, -75, -73, -72, -69, -68, -66, -64, -62, -61, -59, -56, -54, -52,
-51, -48, -45, -44, -42, -39, -37, -35, -33, -30, -29, -25, -23, -21, -19, -17,
-13, -11, -8, -6, -4, 0, };