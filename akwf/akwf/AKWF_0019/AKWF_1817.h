#define DATA_LENGTH 512
#define DATA AKWF_1817

const PROGMEM int8_t DATA[DATA_LENGTH] = {13, 37, 56, 69, 77, 84, 87, 88, 87,
86, 85, 83, 80, 78, 74, 71, 68, 64, 62, 59, 55, 53, 50, 48, 46, 43, 42, 39, 38,
37, 36, 34, 33, 32, 31, 29, 28, 27, 26, 26, 24, 25, 24, 22, 22, 21, 20, 19, 18,
18, 17, 16, 15, 16, 15, 13, 13, 13, 13, 12, 12, 12, 12, 12, 11, 11, 11, 10, 9,
9, 9, 8, 7, 7, 7, 7, 6, 5, 5, 6, 6, 5, 5, 5, 5, 4, 5, 4, 4, 4, 3, 2, 2, 2, 1, 1,
2, 2, 1, 1, 1, 2, 1, 3, 2, 2, 3, 4, 4, 4, 4, 5, 4, 5, 5, 5, 5, 5, 6, 6, 6, 6, 7,
7, 8, 8, 8, 9, 9, 10, 10, 11, 11, 11, 12, 12, 12, 12, 13, 13, 13, 14, 15, 14,
15, 15, 16, 17, 18, 19, 19, 20, 20, 21, 21, 23, 24, 25, 26, 27, 28, 29, 31, 33,
34, 36, 38, 39, 41, 43, 45, 47, 49, 51, 53, 55, 58, 60, 63, 66, 69, 71, 73, 78,
80, 82, 85, 85, 86, 85, 81, 73, 60, 42, 19, -9, -38, -63, -83, -99, -108, -115,
-118, -119, -119, -117, -116, -113, -112, -109, -106, -103, -100, -97, -94, -91,
-88, -85, -82, -80, -79, -76, -75, -73, -71, -73, -73, -74, -75, -76, -76, -77,
-78, -80, -81, -83, -85, -86, -89, -91, -96, -98, -102, -106, -109, -113, -116,
-117, -118, -117, -112, -106, -96, -83, -65, -44, -21, 2, 24, 44, 60, 72, 80,
85, 87, 88, 87, 84, 83, 81, 77, 74, 72, 69, 67, 64, 61, 59, 56, 53, 50, 48, 46,
43, 41, 40, 38, 36, 35, 33, 32, 31, 30, 28, 28, 27, 25, 26, 24, 23, 22, 22, 21,
21, 19, 19, 18, 17, 17, 16, 15, 15, 15, 14, 14, 13, 13, 12, 12, 13, 11, 10, 10,
9, 10, 9, 9, 8, 8, 7, 8, 7, 7, 7, 5, 6, 5, 5, 6, 5, 5, 4, 4, 4, 3, 4, 3, 3, 3,
2, 3, 2, 2, 2, 3, 3, 3, 3, 2, 2, 3, 4, 2, 4, 4, 4, 4, 4, 4, 4, 4, 5, 6, 5, 5, 6,
7, 6, 8, 7, 8, 7, 9, 9, 10, 9, 10, 10, 11, 11, 12, 13, 13, 13, 13, 14, 14, 15,
15, 16, 16, 17, 17, 18, 19, 20, 21, 21, 21, 22, 24, 24, 24, 26, 26, 28, 28, 29,
31, 32, 34, 34, 36, 37, 39, 41, 43, 46, 47, 51, 53, 55, 59, 61, 64, 66, 70, 72,
75, 79, 80, 83, 85, 86, 87, 85, 82, 75, 65, 52, 34, 13, -9, -33, -54, -74, -90,
-102, -111, -116, -120, -119, -118, -115, -112, -109, -105, -102, -98, -94, -92,
-89, -87, -84, -83, -82, -79, -78, -77, -76, -75, -73, -73, -72, -74, -76, -77,
-78, -80, -83, -85, -88, -90, -93, -96, -99, -101, -104, -107, -110, -112, -115,
-116, -117, -117, -114, -110, -100, -83, -62, -36, -8, };