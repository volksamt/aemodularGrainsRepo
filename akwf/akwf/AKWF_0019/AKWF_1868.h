#define DATA_LENGTH 512
#define DATA AKWF_1868

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 2, 2, 3, 4, 3, 5, 5, 5, 6, 6,
6, 7, 7, 8, 9, 9, 10, 10, 11, 11, 12, 12, 12, 13, 13, 15, 15, 15, 15, 16, 17,
18, 18, 18, 19, 19, 20, 20, 21, 21, 22, 22, 22, 23, 24, 24, 25, 26, 26, 26, 28,
27, 28, 28, 28, 30, 30, 31, 31, 31, 33, 33, 34, 34, 34, 34, 36, 36, 37, 36, 37,
38, 38, 39, 38, 40, 40, 41, 41, 42, 42, 43, 43, 43, 44, 44, 45, 45, 46, 46, 47,
48, 47, 48, 50, 50, 50, 50, 51, 52, 52, 53, 54, 53, 54, 55, 55, 55, 56, 56, 58,
57, 59, 59, 59, 59, 60, 61, 61, 62, 62, 63, 63, 63, 64, 65, 65, 66, 66, 67, 67,
67, 68, 68, 69, 69, 70, 71, 71, 71, 72, 73, 72, 74, 74, 75, 75, 76, 77, 76, 77,
78, 79, 78, 79, 79, 80, 80, 81, 81, 82, 83, 83, 84, 84, 84, 85, 86, 86, 86, 87,
87, 88, 89, 89, 90, 90, 90, 90, 90, 91, 92, 93, 93, 95, 95, 95, 95, 95, 96, 97,
97, 98, 98, 99, 99, 99, 100, 100, 101, 102, 102, 102, 104, 104, 103, 104, 105,
106, 106, 107, 108, 108, 108, 109, 109, 110, 110, 110, 112, 111, 112, 113, 112,
114, 113, 114, 115, 116, 116, 116, 117, 117, 118, 118, 119, 119, 112, 99, 89,
78, 66, 57, 47, 38, 31, 23, 15, 8, 1, -6, -11, -17, -24, -28, -32, -37, -41,
-45, -49, -52, -57, -60, -62, -65, -69, -70, -73, -75, -77, -78, -82, -83, -84,
-87, -87, -89, -89, -90, -93, -93, -94, -95, -96, -96, -97, -98, -97, -98, -98,
-98, -99, -99, -100, -101, -100, -100, -100, -100, -100, -100, -100, -100, -101,
-100, -100, -100, -100, -99, -99, -99, -99, -98, -99, -98, -98, -98, -97, -97,
-96, -96, -95, -95, -95, -95, -94, -95, -94, -93, -93, -91, -91, -91, -92, -90,
-89, -90, -89, -88, -88, -87, -87, -86, -87, -86, -85, -85, -84, -84, -84, -83,
-82, -81, -81, -81, -80, -80, -80, -79, -79, -78, -77, -77, -76, -76, -75, -75,
-74, -74, -73, -73, -73, -72, -71, -71, -70, -70, -69, -69, -68, -68, -67, -66,
-66, -65, -65, -64, -64, -63, -63, -63, -62, -61, -61, -60, -60, -59, -58, -58,
-58, -57, -56, -56, -56, -55, -54, -53, -53, -54, -52, -52, -51, -51, -49, -49,
-49, -48, -48, -47, -48, -47, -47, -46, -45, -45, -44, -43, -43, -42, -42, -41,
-41, -40, -39, -38, -39, -38, -37, -37, -36, -36, -35, -35, -34, -34, -33, -32,
-32, -32, -32, -31, -31, -30, -29, -28, -28, -27, -27, -26, -26, -26, -25, -24,
-24, -24, -23, -22, -22, -21, -20, -21, -20, -20, -18, -19, -17, -18, -16, -16,
-15, -15, -15, -15, -13, -12, -12, -12, -11, -11, -10, -9, -9, -8, -9, -8, -8,
-7, -6, -5, -5, -4, -5, -3, -3, -2, -2, -2, -1, -1, };