#define DATA_LENGTH 512
#define DATA AKWF_1813

const PROGMEM int8_t DATA[DATA_LENGTH] = {31, 37, 34, 37, 35, 37, 35, 36, 35,
36, 36, 37, 36, 37, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36,
36, 36, 35, 37, 36, 35, 36, 37, 36, 35, 36, 36, 36, 35, 36, 36, 36, 36, 35, 35,
35, 35, 35, 35, 36, 35, 35, 35, 36, 35, 35, 35, 35, 34, 35, 35, 35, 35, 36, 35,
34, 35, 35, 35, 35, 35, 35, 35, 35, 35, 34, 35, 35, 35, 34, 34, 34, 34, 33, 34,
35, 35, 35, 35, 34, 34, 35, 34, 34, 34, 34, 34, 34, 35, 34, 34, 34, 34, 34, 34,
34, 34, 34, 34, 34, 34, 34, 34, 33, 34, 34, 33, 34, 34, 33, 32, 33, 33, 33, 34,
33, 34, 34, 33, 33, 33, 32, 34, 33, 33, 33, 33, 33, 33, 33, 33, 33, 32, 33, 33,
33, 33, 33, 32, 32, 33, 33, 33, 32, 33, 32, 33, 33, 32, 33, 31, 33, 32, 33, 32,
33, 32, 33, 32, 32, 32, 32, 33, 32, 32, 32, 32, 31, 31, 32, 32, 32, 31, 32, 32,
32, 32, 32, 31, 32, 32, 31, 31, 31, 32, 32, 31, 31, 31, 31, 31, 31, 31, 31, 32,
31, 31, 30, 31, 32, 30, 30, 31, 31, 30, 31, 31, 31, 31, 31, 31, 31, 31, 30, 31,
30, 31, 30, 30, 30, 30, 31, 31, 31, 30, 30, 30, 30, 30, 29, 30, 30, 30, 30, 30,
30, 30, 29, 30, 30, 31, 29, 29, 30, 31, 30, 30, 29, 29, 29, 29, 29, 30, 29, 29,
30, 29, 29, 30, 29, 28, 29, 29, 31, 28, 31, 27, 31, 27, 33, 25, 38, 3, -64, -50,
-58, -52, -56, -53, -54, -52, -49, -50, -48, -52, -48, -53, -46, -55, -41, -79,
-127, -115, -121, -118, -119, -119, -118, -119, -117, -119, -118, -119, -118,
-120, -118, -119, -118, -119, -117, -119, -118, -119, -118, -117, -123, -61,
-44, -52, -46, -50, -47, -50, -47, -50, -47, -49, -47, -48, -48, -55, -52, -54,
-53, -55, -53, -54, -52, -54, -53, -55, -52, -55, -53, -54, -52, 29, 36, 31, 35,
32, 35, 32, 35, 33, 34, 32, 35, 33, 34, 33, 34, 34, 34, 33, 34, 34, 34, 33, 33,
33, 34, 34, 34, 33, 33, 33, 33, 32, 35, 33, 34, 33, 35, 33, 35, 31, 35, 31, 35,
31, 37, 27, -54, -54, -53, -55, -52, -55, -52, -55, -53, -54, -52, -55, -53,
-54, -53, -54, -53, -53, -53, -54, -53, -54, -53, -54, -53, -52, -53, -54, -54,
-54, -53, -54, -53, -53, -53, -53, -53, -54, -52, -54, -53, -53, -54, -54, -54,
-52, -53, -54, -53, -53, -53, -53, -52, -53, -52, -53, -53, -53, -53, -53, -53,
-53, -53, -52, -53, -53, -53, -53, -53, -52, -53, -52, -53, -52, -52, -53, -52,
-52, -53, -51, -52, -52, -52, -53, -52, -53, -52, -52, -52, -53, -53, -53, -52,
-53, -52, -53, -52, -53, -51, -53, -51, -55, -49, -55, -44, };