#define DATA_LENGTH 512
#define DATA AKWF_1804

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 0, 0, 2, 1, 2, 2, 2, 3, 3, 3, 3,
3, 3, 4, 4, 5, 4, 6, 5, 6, 6, 7, 7, 7, 7, 9, 9, 9, 11, 11, 13, 14, 14, 15, 16,
18, 18, 20, 21, 22, 25, 26, 27, 28, 30, 32, 34, 36, 38, 41, 43, 45, 47, 50, 52,
55, 57, 61, 63, 66, 69, 71, 74, 77, 80, 82, 86, 88, 92, 94, 96, 98, 100, 103,
105, 107, 109, 111, 113, 114, 115, 115, 117, 117, 118, 118, 119, 119, 119, 119,
119, 119, 119, 118, 118, 117, 117, 115, 115, 115, 112, 113, 111, 110, 110, 108,
107, 105, 103, 101, 98, 96, 91, 88, 87, 83, 80, 78, 74, 72, 69, 67, 63, 61, 58,
56, 53, 51, 49, 46, 44, 42, 40, 38, 35, 33, 33, 31, 30, 28, 27, 25, 25, 23, 24,
22, 23, 21, 21, 22, 21, 21, 22, 23, 23, 23, 23, 24, 25, 26, 27, 28, 28, 29, 30,
30, 31, 33, 34, 35, 36, 37, 37, 39, 39, 39, 40, 41, 41, 43, 42, 43, 43, 44, 44,
44, 45, 44, 44, 44, 44, 43, 44, 42, 42, 41, 41, 41, 39, 39, 38, 38, 36, 36, 34,
34, 32, 32, 31, 29, 28, 27, 25, 25, 23, 22, 21, 19, 18, 17, 16, 15, 13, 12, 11,
10, 9, 7, 6, 5, 4, 3, 2, 1, 0, -1, -1, -2, -3, -4, -5, -4, -6, -6, -6, -7, -8,
-8, -8, -8, -9, -9, -9, -10, -10, -10, -10, -9, -10, -10, -10, -10, -10, -10,
-10, -10, -10, -10, -10, -10, -10, -11, -10, -10, -12, -12, -11, -12, -12, -13,
-13, -14, -14, -15, -15, -16, -17, -18, -19, -20, -21, -22, -23, -24, -26, -26,
-27, -29, -30, -32, -34, -36, -37, -38, -40, -42, -44, -45, -47, -49, -50, -52,
-54, -56, -58, -61, -62, -64, -67, -68, -70, -72, -74, -76, -79, -81, -83, -85,
-87, -89, -91, -92, -95, -96, -98, -99, -101, -102, -104, -105, -106, -107,
-108, -110, -111, -111, -112, -113, -114, -113, -114, -115, -115, -115, -116,
-115, -115, -115, -114, -114, -113, -113, -112, -112, -110, -107, -105, -102,
-99, -97, -94, -91, -88, -85, -82, -79, -77, -73, -71, -69, -66, -64, -62, -59,
-57, -55, -54, -51, -50, -49, -48, -46, -46, -44, -43, -42, -42, -41, -40, -40,
-39, -39, -38, -39, -39, -39, -40, -39, -39, -39, -39, -40, -40, -39, -40, -40,
-40, -40, -40, -40, -40, -40, -39, -40, -40, -40, -41, -39, -39, -39, -39, -39,
-39, -38, -38, -38, -37, -36, -37, -36, -36, -35, -35, -35, -34, -33, -33, -32,
-31, -31, -29, -28, -27, -27, -25, -24, -24, -22, -21, -19, -18, -17, -15, -14,
-12, -11, -9, -8, -7, -6, -5, -3, -2, -1, 1, 1, 3, 5, 6, 7, 8, 7, 10, 10, 11,
11, 13, 13, 14, 13, 16, 12, -13, -13, -11, -10, -9, -9, -7, -7, -4, -5, -4, -4,
-2, -2, -1, -2, -1, 0, };