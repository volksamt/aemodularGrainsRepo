#define DATA_LENGTH 512
#define DATA AKWF_1837

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 6, 8, 6, 7, 6, 8, 24, 27, 25,
27, 25, 27, 24, 31, 62, 70, 67, 69, 67, 69, 67, 71, 85, 88, 87, 88, 86, 88, 86,
91, 110, 116, 113, 113, 114, 114, 114, 114, 116, 118, 117, 117, 117, 117, 117,
115, 104, 100, 101, 100, 100, 99, 100, 99, 94, 90, 91, 90, 91, 89, 90, 93, 93,
92, 93, 92, 93, 92, 91, 91, 83, 80, 81, 81, 80, 80, 80, 79, 72, 68, 70, 69, 69,
68, 70, 69, 63, 59, 61, 60, 62, 60, 62, 53, 30, 25, 26, 25, 25, 25, 25, 25, 22,
20, 21, 21, 20, 22, 20, 36, 67, 69, 68, 69, 69, 69, 68, 68, 62, 61, 62, 62, 61,
63, 60, 75, 96, 96, 97, 96, 97, 96, 96, 96, 92, 92, 93, 92, 93, 92, 93, 90, 44,
13, 17, 15, 16, 16, 16, 16, 10, 6, 9, 7, 8, 7, 8, 8, 21, 31, 30, 30, 31, 30, 30,
30, 29, 27, 27, 28, 28, 27, 28, 25, -20, -49, -43, -45, -44, -46, -44, -45, -46,
-47, -47, -47, -47, -47, -47, -51, -93, -117, -113, -115, -113, -115, -114,
-114, -118, -119, -119, -118, -119, -119, -119, -117, -109, -105, -106, -105,
-105, -105, -105, -105, -104, -104, -104, -104, -105, -104, -104, -103, -100,
-99, -99, -100, -100, -100, -99, -99, -95, -93, -94, -93, -94, -93, -94, -91,
-76, -72, -74, -72, -73, -72, -73, -69, -57, -54, -55, -55, -55, -54, -56, -54,
-48, -48, -49, -48, -49, -47, -49, -45, -30, -28, -29, -28, -30, -27, -31, -21,
12, 17, 15, 17, 16, 17, 15, 20, 35, 36, 35, 36, 35, 35, 34, 38, 47, 48, 47, 48,
47, 47, 48, 47, 50, 52, 52, 51, 51, 51, 52, 40, 10, 4, 6, 5, 6, 4, 6, 5, -2, -5,
-3, -5, -4, -4, -6, 8, 31, 32, 31, 31, 31, 31, 32, 31, 22, 20, 21, 20, 21, 20,
20, 20, 15, 13, 13, 13, 14, 13, 13, 12, 5, 4, 5, 4, 5, 4, 5, 5, -1, -2, -1, -1,
-1, -1, -1, -2, -6, -7, -6, -6, -7, -7, -7, -6, -5, -6, -6, -5, -5, -6, -5, -6,
-11, -12, -12, -13, -12, -13, -12, -13, -15, -14, -15, -15, -14, -14, -14, -16,
-18, -18, -19, -19, -18, -19, -18, -21, -33, -33, -33, -33, -33, -32, -32, -33,
-39, -43, -41, -42, -41, -41, -42, -41, -46, -47, -46, -47, -47, -48, -46, -47,
-49, -50, -49, -49, -49, -50, -50, -49, -53, -53, -54, -53, -53, -54, -52, -54,
-55, -56, -55, -55, -56, -55, -55, -54, -52, -49, -50, -50, -49, -50, -50, -49,
-54, -55, -54, -54, -54, -54, -53, -52, -40, -36, -37, -36, -37, -37, -36, -36,
-35, -36, -35, -36, -35, -35, -34, -36, -46, -48, -48, -48, -49, -48, -49, -47,
-42, -42, -43, -41, -43, -41, -42, -41, -37, -38, -39, -38, -39, -37, -39, -35,
-21, -21, -21, -20, -22, -20, -23, -14, };