#define DATA_LENGTH 512
#define DATA AKWF_1862

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 6, 8, 9, 12, 12, 15, 18, 20,
21, 24, 27, 29, 32, 34, 36, 38, 40, 42, 44, 44, 47, 48, 49, 50, 51, 52, 53, 53,
54, 54, 54, 54, 54, 54, 54, 54, 53, 54, 52, 52, 52, 52, 52, 52, 52, 51, 51, 51,
52, 53, 54, 55, 56, 56, 58, 59, 60, 63, 64, 66, 68, 70, 73, 76, 77, 80, 83, 85,
87, 90, 92, 95, 96, 99, 102, 103, 105, 106, 108, 109, 111, 113, 114, 115, 116,
117, 117, 119, 119, 119, 119, 118, 120, 118, 118, 118, 117, 117, 117, 116, 116,
115, 116, 114, 114, 113, 112, 112, 111, 110, 110, 109, 107, 108, 106, 106, 105,
104, 103, 103, 101, 100, 100, 98, 97, 96, 95, 94, 92, 91, 90, 89, 87, 86, 85,
83, 82, 81, 80, 79, 78, 77, 77, 76, 76, 75, 74, 75, 75, 74, 74, 74, 75, 75, 76,
75, 76, 76, 77, 77, 77, 77, 78, 79, 78, 78, 77, 78, 78, 77, 76, 76, 75, 74, 73,
72, 71, 69, 67, 66, 64, 63, 61, 58, 57, 55, 53, 51, 49, 47, 45, 43, 40, 38, 36,
34, 32, 30, 28, 26, 24, 22, 20, 19, 17, 15, 14, 12, 11, 9, 9, 7, 5, 5, 4, 3, 3,
2, 0, 0, -1, -2, -3, -4, -5, -5, -6, -7, -7, -9, -10, -10, -10, -11, -11, -11,
-12, -12, -13, -12, -13, -13, -14, -13, -13, -13, -13, -13, -13, -13, -13, -14,
-13, -13, -14, -14, -15, -14, -15, -15, -16, -15, -15, -16, -17, -17, -18, -18,
-19, -19, -19, -20, -21, -22, -25, -25, -27, -28, -31, -32, -35, -37, -41, -42,
-45, -47, -49, -52, -54, -57, -59, -62, -64, -66, -68, -70, -71, -73, -75, -75,
-76, -77, -79, -78, -79, -80, -78, -79, -79, -79, -79, -78, -78, -77, -77, -77,
-76, -76, -75, -75, -75, -74, -73, -74, -73, -74, -73, -72, -72, -72, -71, -70,
-70, -70, -69, -69, -68, -68, -67, -67, -67, -67, -66, -67, -66, -66, -66, -66,
-67, -66, -66, -66, -67, -66, -67, -66, -66, -66, -66, -66, -65, -65, -65, -64,
-63, -62, -62, -61, -61, -61, -61, -59, -59, -60, -59, -59, -59, -58, -58, -59,
-58, -60, -61, -60, -61, -63, -64, -66, -67, -70, -71, -74, -76, -78, -82, -83,
-87, -90, -91, -95, -98, -99, -102, -104, -107, -108, -109, -111, -112, -113,
-114, -115, -115, -114, -113, -112, -111, -107, -104, -103, -99, -95, -92, -89,
-85, -81, -76, -72, -68, -64, -60, -56, -52, -49, -46, -44, -42, -41, -40, -38,
-38, -37, -38, -38, -39, -41, -41, -41, -43, -44, -45, -46, -46, -47, -48, -49,
-50, -50, -50, -51, -51, -52, -53, -53, -53, -53, -54, -54, -54, -54, -54, -54,
-53, -53, -51, -50, -49, -48, -46, -44, -43, -40, -38, -36, -34, -32, -31, -29,
-28, -26, -25, -23, -22, -21, -19, -18, -17, -16, -15, -13, -13, -12, -10, -9,
-8, -6, -5, -3, -2, };