#define DATA_LENGTH 512
#define DATA AKWF_1846

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 8, 11, 14, 16, 19, 23, 26, 28,
31, 35, 38, 39, 42, 45, 46, 50, 51, 53, 55, 58, 60, 62, 63, 66, 67, 68, 70, 72,
73, 74, 77, 78, 79, 80, 82, 84, 84, 86, 88, 87, 89, 90, 91, 93, 93, 94, 95, 96,
97, 97, 99, 100, 100, 101, 101, 102, 102, 104, 103, 105, 106, 107, 106, 106,
107, 108, 109, 109, 109, 110, 110, 110, 111, 111, 111, 112, 112, 112, 113, 112,
113, 113, 113, 114, 114, 114, 114, 114, 115, 114, 115, 114, 115, 115, 115, 116,
115, 116, 115, 115, 116, 115, 115, 115, 116, 115, 115, 115, 115, 115, 115, 114,
114, 114, 114, 113, 114, 114, 113, 113, 113, 113, 112, 112, 112, 111, 111, 111,
111, 110, 110, 111, 109, 110, 109, 108, 109, 108, 108, 107, 107, 106, 106, 106,
105, 105, 104, 103, 104, 103, 103, 102, 102, 101, 100, 101, 100, 100, 100, 99,
97, 97, 98, 96, 96, 95, 95, 94, 93, 93, 92, 92, 92, 91, 91, 90, 89, 89, 88, 88,
88, 87, 86, 85, 85, 84, 84, 83, 82, 82, 82, 81, 80, 79, 79, 78, 77, 77, 77, 76,
75, 75, 73, 74, 73, 72, 72, 70, 71, 69, 69, 68, 67, 67, 66, 66, 65, 65, 65, 63,
63, 62, 61, 61, 60, 59, 59, 58, 57, 57, 56, 56, 54, 54, 53, 53, 52, 51, 52, 50,
49, 46, 47, 45, 42, 41, 38, 37, 35, 31, 30, 27, 24, 20, 18, 14, 12, 8, 5, 1, -1,
-4, -8, -11, -14, -18, -21, -24, -27, -31, -33, -35, -39, -41, -44, -47, -49,
-52, -54, -55, -58, -60, -63, -64, -66, -68, -71, -72, -74, -76, -77, -78, -80,
-82, -83, -85, -86, -88, -88, -90, -91, -92, -93, -94, -95, -96, -98, -98, -99,
-101, -102, -102, -103, -104, -104, -105, -106, -107, -108, -107, -109, -109,
-110, -110, -111, -111, -112, -112, -113, -113, -114, -114, -114, -114, -116,
-116, -115, -116, -117, -117, -117, -117, -118, -117, -118, -118, -119, -118,
-118, -119, -118, -118, -118, -118, -118, -120, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -118, -118, -118, -118, -118, -118, -118,
-118, -118, -117, -117, -117, -116, -117, -116, -117, -115, -115, -115, -114,
-114, -114, -115, -113, -113, -114, -113, -112, -112, -112, -111, -110, -110,
-110, -110, -109, -109, -108, -108, -108, -108, -107, -106, -106, -105, -104,
-105, -103, -103, -103, -102, -103, -102, -101, -100, -101, -100, -99, -98, -99,
-97, -96, -96, -96, -95, -94, -94, -93, -93, -92, -92, -92, -91, -90, -90, -89,
-87, -87, -87, -86, -85, -85, -84, -83, -83, -82, -83, -82, -80, -80, -79, -78,
-77, -78, -77, -76, -76, -75, -75, -74, -73, -72, -71, -70, -71, -70, -69, -68,
-68, -67, -66, -66, -65, -64, -63, -63, -62, -62, -62, -60, -60, -56, -56, -56,
-53, -51, -50, -47, -44, -42, -40, -37, -33, -31, -28, -24, -21, -18, -16, -13,
-8, -6, -2, };