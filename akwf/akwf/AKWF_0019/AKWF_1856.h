#define DATA_LENGTH 512
#define DATA AKWF_1856

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 13, 18, 23, 28, 33, 38, 41, 45,
49, 53, 55, 58, 61, 64, 67, 68, 71, 74, 75, 76, 78, 81, 82, 84, 84, 85, 87, 88,
88, 89, 90, 91, 91, 92, 92, 94, 93, 94, 94, 94, 94, 95, 94, 96, 95, 96, 94, 95,
95, 95, 95, 94, 94, 94, 94, 93, 93, 92, 92, 92, 92, 92, 91, 91, 91, 90, 90, 89,
89, 89, 88, 87, 88, 87, 86, 86, 85, 85, 84, 83, 83, 83, 83, 82, 82, 81, 80, 79,
78, 78, 78, 78, 77, 76, 76, 75, 75, 74, 74, 73, 72, 72, 71, 71, 70, 69, 69, 68,
67, 67, 66, 66, 65, 65, 64, 64, 63, 63, 62, 61, 60, 60, 59, 59, 59, 58, 57, 56,
56, 55, 54, 53, 53, 52, 51, 51, 50, 51, 49, 48, 48, 47, 47, 47, 45, 44, 44, 44,
44, 43, 42, 41, 41, 40, 40, 38, 39, 37, 36, 37, 36, 35, 35, 34, 34, 32, 32, 31,
30, 30, 30, 29, 29, 28, 27, 27, 26, 25, 25, 24, 23, 23, 22, 21, 20, 21, 20, 19,
19, 18, 17, 16, 16, 15, 15, 15, 14, 13, 13, 12, 12, 10, 10, 10, 9, 8, 8, 7, 8,
7, 7, 6, 6, 6, 6, 5, 5, 4, 4, 4, 4, 4, 4, 3, 3, 3, 3, 2, 2, 3, 2, 3, 2, 2, 2, 3,
2, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 1, 0, 1, 0, 1,
0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, -1, -1, -1, -1, -2, -2, -2, -2, -2, -4, -3, -3, -4, -5, -5, -5, -6, -7, -7,
-8, -8, -9, -9, -10, -9, -10, -11, -12, -12, -13, -13, -14, -14, -15, -15, -16,
-16, -17, -18, -18, -19, -19, -20, -21, -21, -21, -22, -22, -23, -24, -24, -25,
-26, -26, -26, -27, -28, -29, -29, -30, -31, -31, -32, -32, -34, -33, -34, -34,
-35, -36, -36, -37, -37, -38, -39, -39, -40, -41, -41, -42, -42, -43, -43, -45,
-44, -45, -46, -47, -48, -48, -48, -49, -50, -50, -50, -51, -52, -53, -53, -55,
-55, -55, -56, -57, -57, -58, -58, -60, -59, -61, -61, -62, -62, -63, -64, -64,
-64, -65, -66, -67, -67, -68, -68, -69, -70, -70, -71, -71, -71, -72, -73, -73,
-74, -75, -76, -76, -76, -78, -78, -79, -79, -79, -80, -81, -81, -82, -83, -83,
-85, -85, -86, -86, -87, -87, -88, -89, -90, -90, -90, -91, -91, -92, -93, -94,
-94, -95, -96, -96, -97, -98, -98, -98, -99, -100, -100, -101, -102, -102, -103,
-103, -104, -104, -105, -106, -106, -107, -107, -108, -109, -110, -110, -111,
-112, -112, -113, -113, -114, -115, -115, -116, -117, -117, -118, -118, -119,
-119, -113, -105, -93, -82, -71, -61, -52, -42, -34, -26, -19, -11, -4, };