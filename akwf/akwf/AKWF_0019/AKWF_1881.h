#define DATA_LENGTH 512
#define DATA AKWF_1881

const PROGMEM int8_t DATA[DATA_LENGTH] = {-15, -50, -77, -96, -110, -116, -119,
-118, -115, -108, -101, -93, -83, -74, -66, -56, -48, -40, -34, -26, -20, -15,
-11, -6, -3, 0, 1, 3, 4, 6, 7, 7, 8, 8, 7, 8, 7, 7, 7, 7, 6, 6, 5, 6, 6, 4, 4,
4, 4, 4, 3, 4, 4, 4, 3, 3, 3, 3, 3, 3, 4, 3, 3, 3, 2, 3, 4, 3, 3, 3, 2, 4, 3, 3,
3, 3, 3, 3, 4, 4, 3, 3, 3, 3, 3, 3, 4, 4, 3, 4, 3, 3, 3, 2, 3, 3, 3, 3, 3, 3, 2,
4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 4, 3, 4, 2, 4,
3, 2, 3, 3, 2, 3, 4, 4, 4, 3, 3, 4, 3, 3, 3, 4, 3, 3, 3, 3, 2, 3, 3, 3, 4, 3, 4,
3, 3, 3, 3, 4, 3, 4, 3, 3, 3, 3, 4, 4, 3, 3, 3, 3, 3, 4, 3, 3, 3, 3, 3, 3, 3, 3,
3, 3, 3, 3, 4, 4, 3, 4, 3, 3, 3, 3, 3, 3, 3, 3, 4, 3, 4, 3, 4, 3, 3, 3, 3, 3, 3,
4, 3, 3, 3, 4, 3, 3, 3, 4, 3, 3, 2, 4, 3, 3, 3, 4, 3, 4, 3, 3, 2, 3, 3, 3, 3, 3,
4, 3, 3, 3, 3, 4, 4, 3, 4, 2, 3, 3, 4, 3, 3, 4, 3, 4, 2, 3, 3, 3, 3, 4, 3, 4, 3,
3, 3, 3, 3, 2, 3, 3, 4, 4, 3, 3, 3, 3, 3, 3, 4, 3, 4, 3, 2, 3, 4, 3, 3, 4, 4, 4,
3, 3, 3, 4, 3, 3, 3, 3, 3, 4, 3, 4, 3, 3, 3, 4, 4, 4, 2, 2, 4, 3, 4, 3, 3, 3, 3,
2, 3, 3, 3, 4, 3, 3, 3, 3, 3, 4, 3, 3, 3, 3, 3, 3, 4, 3, 3, 4, 3, 3, 3, 3, 4, 3,
4, 3, 3, 3, 3, 3, 3, 4, 3, 4, 3, 4, 3, 4, 3, 3, 4, 2, 4, 3, 3, 4, 3, 3, 4, 3, 3,
4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 4, 3, 4, 3, 3, 3, 3, 3, 3, 2,
3, 3, 4, 4, 3, 3, 2, 3, 4, 3, 3, 3, 3, 4, 4, 3, 3, 3, 3, 3, 4, 4, 4, 3, 3, 4, 4,
4, 3, 3, 3, 3, 3, 4, 2, 3, 3, 3, 4, 3, 3, 3, 3, 4, 3, 2, 3, 3, 3, 4, 3, 3, 3, 4,
3, 3, 4, 3, 3, 4, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 4, 3, 3, 4, 3, 3, 3, 3, 4, 3, 3,
4, 3, 3, 3, 3, 4, 3, 3, 4, 4, 3, 3, 3, 4, 2, 4, 3, 3, 3, 3, 3, 3, 3, 4, 3, 3, 3,
4, 3, 3, 3, 3, 3, };