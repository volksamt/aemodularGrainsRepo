#define DATA_LENGTH 512
#define DATA AKWF_1815

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 4, 5, 5, 6, 7, 8, 9, 10, 12,
12, 14, 14, 16, 17, 19, 19, 20, 22, 23, 24, 26, 26, 28, 29, 31, 32, 33, 35, 37,
38, 40, 42, 43, 45, 46, 50, 51, 52, 56, 58, 60, 61, 63, 67, 68, 71, 73, 75, 78,
81, 83, 86, 87, 90, 92, 94, 97, 98, 100, 102, 104, 107, 107, 109, 110, 112, 113,
114, 116, 116, 117, 118, 118, 118, 119, 119, 118, 119, 119, 118, 118, 117, 116,
115, 115, 113, 112, 109, 108, 106, 104, 102, 100, 97, 95, 92, 89, 85, 82, 80,
77, 73, 70, 67, 64, 61, 59, 56, 52, 51, 49, 46, 44, 41, 40, 38, 36, 35, 32, 31,
29, 27, 26, 26, 24, 22, 21, 19, 17, 17, 16, 14, 13, 12, 11, 9, 8, 8, 6, 5, 3, 3,
1, 0, -1, -2, -4, -5, -6, -8, -9, -10, -12, -12, -14, -15, -16, -18, -19, -20,
-21, -23, -23, -26, -26, -27, -29, -29, -30, -32, -32, -34, -34, -35, -36, -36,
-37, -38, -39, -40, -41, -41, -41, -42, -42, -43, -43, -43, -44, -44, -44, -43,
-44, -45, -44, -44, -45, -45, -45, -45, -44, -44, -45, -45, -44, -45, -45, -44,
-45, -44, -45, -44, -44, -44, -43, -43, -43, -44, -43, -43, -43, -43, -41, -42,
-43, -42, -41, -41, -41, -41, -40, -40, -40, -39, -39, -39, -39, -38, -39, -38,
-37, -37, -38, -37, -37, -37, -36, -37, -36, -37, -36, -36, -36, -36, -37, -36,
-36, -36, -36, -36, -36, -35, -35, -35, -35, -34, -35, -34, -33, -33, -33, -32,
-32, -31, -31, -30, -30, -29, -28, -29, -28, -27, -26, -26, -26, -24, -24, -24,
-23, -23, -23, -21, -21, -21, -21, -20, -20, -19, -20, -18, -18, -17, -17, -16,
-16, -15, -14, -15, -14, -13, -13, -12, -12, -11, -11, -9, -9, -8, -8, -7, -7,
-6, -5, -4, -4, -3, -3, -1, -1, -1, 0, 1, 1, 1, 2, 3, 3, 3, 2, 3, 3, 4, 3, 3, 2,
3, 3, 3, 3, 2, 3, 2, 2, 2, 1, 2, 1, 1, 0, 0, -1, -1, -2, -2, -2, -3, -4, -4, -5,
-5, -6, -7, -7, -8, -8, -9, -10, -10, -11, -12, -13, -14, -14, -15, -16, -15,
-16, -16, -17, -18, -18, -19, -18, -19, -19, -20, -20, -20, -21, -20, -20, -21,
-21, -21, -21, -21, -20, -21, -21, -21, -21, -21, -21, -21, -21, -22, -21, -22,
-22, -22, -22, -23, -24, -23, -24, -25, -25, -26, -26, -27, -27, -29, -29, -28,
-30, -30, -30, -31, -31, -32, -32, -32, -32, -33, -33, -33, -34, -34, -33, -34,
-34, -33, -33, -32, -33, -32, -32, -31, -32, -31, -30, -30, -30, -29, -29, -29,
-29, -28, -28, -27, -26, -26, -25, -25, -24, -23, -24, -23, -22, -22, -22, -22,
-20, -20, -19, -19, -18, -18, -17, -16, -16, -15, -15, -15, -14, -13, -12, -11,
-10, -9, -8, -7, -6, -6, -4, -3, -2, -1, -1, };