#define DATA_LENGTH 512
#define DATA AKWF_1864

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 4, 5, 6, 7, 7, 9, 10, 10, 11,
13, 13, 13, 14, 15, 15, 15, 16, 17, 17, 17, 17, 18, 19, 18, 19, 20, 20, 20, 20,
21, 21, 22, 21, 21, 22, 22, 23, 22, 22, 23, 23, 23, 23, 23, 22, 23, 24, 24, 23,
23, 23, 23, 24, 24, 24, 24, 24, 24, 25, 24, 24, 25, 24, 25, 24, 25, 24, 25, 24,
25, 24, 25, 24, 25, 25, 25, 24, 25, 25, 25, 25, 25, 25, 26, 25, 25, 25, 24, 25,
25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 25, 24, 26, 25, 25, 26, 25, 24, 25,
25, 25, 25, 25, 25, 25, 26, 25, 24, 25, 25, 25, 25, 25, 25, 25, 26, 24, 25, 25,
25, 24, 25, 25, 25, 25, 25, 25, 25, 25, 24, 25, 25, 26, 25, 25, 25, 25, 25, 24,
24, 24, 25, 25, 25, 25, 25, 26, 25, 24, 25, 25, 25, 24, 24, 25, 25, 24, 24, 24,
25, 25, 24, 24, 25, 25, 24, 25, 25, 25, 25, 24, 24, 25, 24, 25, 25, 25, 24, 24,
25, 25, 25, 25, 24, 24, 25, 25, 25, 25, 25, 24, 25, 24, 24, 25, 25, 24, 25, 25,
25, 25, 25, 25, 25, 24, 25, 25, 24, 25, 24, 24, 24, 23, 25, 24, 24, 25, 24, 25,
24, 25, 24, 24, 24, 24, 24, 24, 25, 24, 24, 25, 24, 24, 24, 24, 24, 24, 24, 24,
24, 25, 25, 24, 25, 24, 24, 24, 24, 25, 24, 25, 25, 24, 24, 24, 23, 25, 24, 24,
24, 24, 24, 23, 24, 24, 24, 23, 25, 24, 25, 24, 23, 24, 24, 24, 23, 24, 24, 23,
23, 24, 24, 25, 24, 23, 24, 24, 24, 24, 24, 24, 23, 24, 23, 24, 24, 23, 23, 24,
24, 24, 24, 24, 23, 19, 11, 8, 6, 3, 0, -3, -5, -6, -10, -13, -11, -12, -15,
-17, -18, -19, -21, -20, -19, -24, -25, -26, -27, -28, -28, -30, -31, -34, -38,
-38, -38, -38, -39, -39, -39, -41, -43, -40, -39, -40, -40, -40, -42, -42, -41,
-38, -39, -43, -42, -42, -42, -42, -43, -43, -44, -49, -51, -55, -58, -61, -63,
-66, -67, -71, -73, -75, -76, -78, -80, -82, -83, -85, -87, -88, -89, -90, -91,
-91, -93, -94, -95, -95, -96, -100, -107, -115, -119, -117, -115, -110, -96,
-84, -76, -72, -67, -62, -58, -53, -49, -47, -42, -39, -35, -34, -29, -27, -24,
-22, -20, -18, -15, -13, -11, -9, -8, -6, -5, -4, -2, -1, 2, 0, -2, -4, -6, -4,
-7, -12, -13, -15, -16, -17, -19, -20, -23, -24, -23, -24, -24, -26, -27, -28,
-28, -28, -27, -29, -31, -32, -33, -33, -34, -34, -35, -37, -37, -36, -36, -37,
-37, -37, -37, -39, -41, -40, -38, -38, -39, -39, -39, -39, -39, -37, -38, -41,
-40, -40, -38, -34, -32, -30, -26, -23, -21, -18, -17, -15, -12, -10, -8, -7,
-6, -3, -3, -1, };