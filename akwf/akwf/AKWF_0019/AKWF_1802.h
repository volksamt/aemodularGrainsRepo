#define DATA_LENGTH 512
#define DATA AKWF_1802

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 5, 6, 8, 9, 10, 11, 12,
12, 14, 15, 16, 16, 17, 19, 19, 20, 22, 23, 23, 24, 24, 26, 27, 28, 29, 29, 29,
31, 30, 33, 32, 34, 33, 36, 35, 37, 36, 11, 10, 12, 12, 14, 14, 15, 16, 17, 17,
18, 18, 19, 20, 22, 21, 23, 23, 23, 24, 25, 25, 26, 27, 26, 28, 29, 29, 29, 29,
30, 31, 31, 32, 32, 33, 33, 34, 34, 35, 34, 35, 35, 35, 36, 37, 36, 37, 37, 37,
39, 39, 38, 39, 40, 40, 39, 40, 40, 40, 41, 41, 40, 41, 41, 41, 41, 41, 41, 42,
43, 42, 42, 43, 43, 42, 43, 42, 43, 43, 43, 43, 43, 43, 44, 44, 43, 43, 43, 44,
44, 43, 44, 44, 43, 44, 43, 44, 45, 44, 43, 44, 44, 45, 44, 45, 45, 44, 45, 45,
45, 44, 45, 44, 45, 45, 45, 45, 46, 46, 46, 46, 46, 46, 46, 47, 47, 47, 47, 48,
47, 47, 47, 47, 46, 47, 46, 46, 47, 46, 46, 45, 46, 45, 45, 45, 45, 44, 45, 45,
45, 45, 44, 44, 44, 45, 45, 45, 45, 44, 44, 44, 45, 45, 45, 45, 44, 45, 44, 44,
44, 44, 43, 45, 44, 44, 44, 43, 44, 43, 44, 43, 43, 43, 44, 44, 43, 43, 43, 43,
43, 42, 43, 43, 42, 42, 42, 42, 42, 42, 42, 42, 41, 41, 41, 40, 41, 42, 41, 41,
40, 40, 39, 40, 40, 40, 40, 39, 39, 38, 38, 38, 38, 37, 37, 37, 37, 35, 36, 35,
35, 34, 35, 34, 33, 33, 33, 32, 32, 32, 31, 31, 30, 30, 29, 29, 29, 28, 27, 26,
25, 25, 25, 24, 23, 22, 22, 22, 21, 20, 19, 19, 18, 17, 16, 15, 15, 14, 13, 12,
11, 11, 10, 9, 8, 7, 6, 6, 4, 4, 2, 2, 1, 0, -1, -1, -3, -3, -5, -6, -8, -8, -9,
-10, -11, -13, -14, -14, -15, -17, -18, -18, -19, -21, -23, -23, -24, -26, -26,
-28, -29, -30, -31, -33, -34, -34, -36, -37, -39, -40, -42, -43, -43, -45, -46,
-48, -49, -49, -50, -53, -52, -54, -56, -57, -58, -60, -61, -63, -64, -65, -67,
-67, -69, -70, -71, -72, -74, -74, -76, -78, -79, -80, -82, -83, -84, -85, -87,
-88, -89, -90, -92, -93, -95, -95, -96, -97, -99, -100, -101, -102, -104, -104,
-106, -107, -109, -110, -111, -112, -113, -115, -115, -117, -118, -119, -118,
-117, -116, -115, -114, -113, -112, -109, -108, -107, -106, -105, -103, -102,
-101, -99, -98, -97, -95, -94, -92, -90, -89, -88, -86, -84, -83, -82, -80, -80,
-78, -76, -75, -74, -72, -70, -69, -67, -67, -65, -63, -62, -60, -58, -57, -55,
-55, -53, -52, -50, -48, -47, -45, -44, -44, -41, -39, -38, -37, -36, -34, -32,
-32, -29, -28, -27, -25, -25, -23, -22, -20, -18, -17, -17, -14, -13, -12, -12,
-11, -9, -8, -6, -5, -4, -3, -1, -1, };