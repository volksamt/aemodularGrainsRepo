#define DATA_LENGTH 512
#define DATA AKWF_1827

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 4, 5, 5, 7, 7, 8, 9, 9,
10, 11, 10, 12, 10, 19, 58, 86, 95, 101, 100, 102, 100, 98, 96, 92, 90, 89, 87,
83, 81, 80, 79, 75, 74, 72, 70, 68, 67, 66, 64, 62, 61, 59, 58, 56, 54, 54, 52,
51, 50, 48, 46, 46, 45, 43, 42, 41, 40, 40, 39, 38, 36, 36, 34, 34, 32, 33, 32,
31, 30, 29, 28, 28, 27, 27, 26, 25, 24, 24, 23, 22, 23, 22, 21, 21, 20, 20, 19,
19, 18, 18, 18, 17, 17, 17, 17, 16, 15, 16, 15, 14, 14, 13, 14, 14, 14, 13, 13,
13, 12, 12, 12, 11, 11, 11, 12, 11, 11, 10, 10, 10, 9, 10, 10, 9, 9, 9, 9, 8, 8,
8, 8, 8, 8, 8, 8, 8, 8, 7, 8, 7, 8, 7, 7, 6, 8, 8, 8, 7, 7, 7, 7, 6, 10, -2,
-21, -13, -7, -5, -3, -3, -2, -2, -2, -2, -1, -2, -2, -1, -1, -1, 0, -1, 0, -1,
-1, -1, 0, 0, 0, -1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 0, 0, 2, 1, 0, 1, 1,
1, 1, 0, 2, 1, 2, 2, 2, 1, 1, 1, 2, 3, 1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 3, 2, 2,
3, 3, 3, 3, 2, 3, 2, 3, 3, 3, 4, 3, 4, 3, 4, 4, 3, 3, 3, 4, 4, 4, 4, 3, 4, 4, 4,
3, 5, 4, 5, 4, 4, 5, 5, 4, 4, 5, 5, 5, 5, 5, 5, 5, 6, 5, 6, 5, 6, 6, 5, 7, 6, 6,
6, 6, 6, 7, 7, 6, 7, 6, 7, 7, 6, 8, 7, 7, 8, 7, 7, 8, 7, 9, 8, 9, 8, 9, 8, 9, 9,
9, 10, 9, 10, 9, 10, 9, 10, 11, 10, 11, 11, 11, 11, 11, 11, 12, 12, 12, 13, 13,
12, 13, 12, 14, 13, 13, 15, 14, 14, 14, 15, 14, 15, 15, 15, 16, 16, 15, 16, 16,
17, 17, 17, 18, 17, 18, 18, 18, 18, 19, 20, 20, 19, 20, 21, 21, 20, 21, 21, 21,
21, 21, 22, 22, 22, 22, 22, 22, 22, 22, 22, 22, 21, 21, 21, 20, 20, 20, 19, 18,
17, 17, 16, 14, 14, 13, 11, 10, 8, 6, 4, 2, 0, -2, -5, -8, -10, -14, -16, -19,
-23, -26, -30, -34, -38, -43, -46, -51, -56, -60, -63, -69, -72, -77, -81, -85,
-89, -93, -96, -99, -102, -105, -108, -110, -112, -114, -116, -117, -117, -118,
-119, -120, -119, -118, -118, -118, -117, -115, -114, -113, -112, -110, -108,
-106, -104, -103, -100, -97, -96, -92, -91, -89, -86, -84, -81, -78, -76, -73,
-71, -69, -66, -64, -62, -59, -57, -55, -52, -49, -47, -46, -43, -42, -39, -37,
-35, -33, -31, -29, -28, -26, -24, -23, -21, -20, -18, -16, -14, -13, -11, -10,
-10, -7, -7, -5, -5, -3, -2, -1, 0, };