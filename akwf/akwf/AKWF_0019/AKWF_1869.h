#define DATA_LENGTH 512
#define DATA AKWF_1869

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 10, 14, 18, 22, 25, 29, 32, 36,
37, 40, 42, 43, 45, 47, 48, 49, 50, 51, 51, 51, 51, 50, 51, 49, 49, 49, 47, 46,
44, 44, 43, 42, 40, 39, 38, 37, 37, 36, 35, 34, 33, 31, 31, 30, 30, 30, 29, 29,
28, 28, 28, 28, 27, 28, 29, 29, 30, 30, 31, 31, 32, 34, 34, 34, 36, 38, 40, 40,
42, 43, 45, 45, 48, 49, 51, 53, 55, 56, 58, 60, 62, 63, 65, 67, 68, 71, 73, 75,
76, 78, 79, 82, 84, 85, 88, 89, 91, 92, 94, 96, 98, 99, 100, 102, 103, 105, 106,
107, 108, 109, 111, 112, 113, 113, 114, 115, 116, 116, 116, 118, 117, 118, 119,
119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 118, 117, 117, 117, 116, 116,
115, 115, 113, 113, 112, 111, 111, 110, 109, 108, 107, 106, 106, 103, 103, 101,
101, 100, 99, 98, 96, 96, 94, 93, 91, 91, 90, 88, 87, 86, 85, 84, 82, 81, 81,
79, 79, 78, 77, 76, 75, 74, 74, 73, 71, 72, 70, 70, 70, 69, 67, 68, 67, 66, 66,
66, 66, 65, 65, 65, 64, 64, 65, 64, 63, 64, 64, 65, 64, 64, 64, 65, 65, 65, 64,
65, 64, 65, 64, 65, 65, 65, 65, 64, 64, 65, 64, 64, 64, 64, 63, 63, 61, 60, 60,
58, 57, 56, 53, 52, 50, 47, 44, 42, 39, 36, 34, 30, 27, 22, 19, 16, 11, 7, 3,
-1, -7, -10, -14, -18, -23, -26, -30, -32, -36, -37, -40, -43, -44, -46, -48,
-49, -49, -50, -50, -51, -51, -50, -50, -50, -50, -49, -48, -47, -46, -45, -44,
-43, -41, -40, -39, -39, -37, -36, -36, -35, -33, -33, -32, -31, -31, -30, -29,
-30, -28, -29, -28, -28, -28, -28, -29, -28, -29, -30, -30, -31, -31, -33, -33,
-34, -35, -36, -39, -40, -41, -42, -43, -45, -47, -47, -50, -51, -53, -54, -56,
-58, -60, -62, -63, -65, -67, -69, -71, -73, -75, -76, -78, -80, -82, -84, -86,
-87, -90, -91, -92, -95, -96, -97, -99, -101, -102, -103, -105, -106, -108,
-108, -109, -111, -112, -112, -114, -114, -115, -115, -117, -117, -117, -118,
-118, -118, -119, -119, -119, -119, -119, -118, -118, -119, -118, -118, -119,
-118, -118, -117, -115, -116, -115, -115, -114, -113, -112, -111, -110, -110,
-109, -108, -107, -106, -104, -103, -103, -102, -100, -100, -98, -98, -96, -95,
-94, -93, -91, -89, -89, -88, -87, -86, -85, -83, -83, -82, -81, -79, -79, -78,
-77, -75, -75, -75, -73, -72, -72, -71, -70, -70, -69, -68, -69, -67, -66, -67,
-66, -65, -66, -64, -65, -65, -64, -65, -65, -63, -63, -64, -64, -64, -63, -64,
-64, -65, -63, -64, -64, -64, -65, -64, -64, -65, -65, -65, -65, -65, -65, -64,
-64, -64, -64, -63, -62, -62, -62, -60, -59, -58, -57, -55, -53, -50, -49, -47,
-44, -42, -39, -36, -33, -30, -26, -22, -19, -15, -11, -7, -2, };