#define DATA_LENGTH 512
#define DATA AKWF_1834

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 6, 9, 13, 15, 19, 23, 26, 29,
33, 37, 40, 43, 47, 51, 54, 58, 61, 65, 69, 71, 74, 77, 82, 84, 86, 91, 93, 95,
97, 100, 102, 105, 106, 108, 110, 112, 114, 114, 116, 117, 118, 118, 118, 119,
118, 120, 119, 118, 117, 117, 115, 115, 113, 111, 110, 109, 105, 104, 102, 99,
97, 94, 92, 88, 86, 82, 79, 76, 74, 70, 66, 63, 60, 56, 52, 49, 46, 43, 39, 36,
32, 30, 27, 23, 22, 18, 16, 15, 12, 9, 7, 5, 4, 2, 0, -1, -2, -4, -5, -7, -7,
-8, -8, -9, -10, -10, -11, -11, -12, -11, -10, -11, -11, -11, -10, -10, -10, -9,
-9, -8, -9, -8, -9, -8, -8, -8, -7, -7, -6, -6, -7, -6, -7, -8, -8, -9, -10,
-10, -11, -12, -14, -15, -18, -19, -20, -23, -25, -27, -30, -31, -34, -37, -39,
-42, -44, -47, -50, -53, -56, -59, -62, -64, -67, -71, -72, -75, -77, -80, -82,
-85, -87, -88, -90, -91, -93, -95, -96, -97, -98, -99, -99, -100, -101, -100,
-100, -99, -99, -99, -97, -97, -96, -95, -94, -91, -91, -88, -86, -84, -82, -80,
-78, -76, -73, -70, -68, -65, -63, -59, -57, -54, -51, -48, -45, -42, -39, -35,
-32, -30, -27, -23, -21, -17, -15, -12, -9, -7, -4, -3, 1, 2, 4, 6, 8, 11, 12,
14, 14, 18, 17, 19, 20, 22, 22, 24, 24, 24, 25, 24, 26, 26, 25, 25, 26, 26, 25,
26, 25, 25, 25, 23, 23, 23, 22, 21, 21, 20, 20, 18, 18, 17, 17, 16, 16, 15, 14,
13, 13, 12, 11, 10, 11, 10, 9, 9, 8, 8, 7, 8, 7, 7, 7, 7, 6, 6, 6, 6, 6, 7, 7,
7, 6, 8, 8, 8, 8, 7, 8, 8, 8, 9, 9, 10, 9, 10, 10, 11, 10, 9, 11, 10, 10, 10,
10, 10, 10, 10, 10, 10, 9, 9, 10, 9, 9, 9, 8, 7, 8, 7, 6, 6, 5, 5, 4, 3, 3, 3,
2, 1, 0, -1, -2, -2, -3, -4, -4, -5, -7, -7, -7, -9, -9, -10, -11, -11, -13,
-14, -14, -15, -15, -15, -16, -17, -18, -18, -19, -20, -20, -19, -20, -21, -21,
-22, -23, -22, -22, -23, -23, -23, -23, -23, -24, -24, -24, -24, -24, -24, -24,
-25, -24, -24, -24, -25, -24, -25, -25, -25, -25, -24, -25, -25, -25, -25, -24,
-24, -24, -24, -24, -23, -24, -24, -23, -23, -23, -22, -22, -22, -22, -21, -22,
-21, -21, -20, -21, -21, -20, -20, -19, -20, -20, -19, -18, -20, -18, -19, -19,
-19, -19, -19, -19, -18, -18, -18, -18, -18, -18, -19, -19, -20, -19, -19, -20,
-20, -20, -21, -21, -21, -22, -23, -22, -23, -24, -24, -24, -25, -25, -26, -26,
-27, -27, -28, -28, -29, -28, -28, -29, -30, -30, -30, -28, -28, -29, -29, -28,
-28, -27, -26, -26, -24, -23, -22, -21, -19, -18, -15, -15, -12, -10, -7, -5,
-1, };