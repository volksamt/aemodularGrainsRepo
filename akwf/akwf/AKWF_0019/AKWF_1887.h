#define DATA_LENGTH 512
#define DATA AKWF_1887

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 5, 7, 8, 10, 11, 12, 13,
15, 16, 17, 19, 20, 21, 22, 24, 25, 26, 27, 28, 30, 31, 32, 34, 35, 37, 37, 38,
40, 40, 42, 43, 44, 46, 47, 48, 48, 50, 51, 52, 53, 55, 56, 56, 58, 59, 60, 61,
62, 64, 64, 65, 65, 67, 67, 69, 70, 71, 73, 73, 74, 75, 75, 76, 77, 78, 79, 80,
81, 82, 82, 83, 85, 85, 86, 87, 88, 89, 89, 90, 91, 91, 92, 93, 94, 95, 96, 97,
98, 98, 98, 99, 101, 101, 102, 103, 102, 104, 105, 104, 106, 106, 107, 108, 108,
109, 110, 110, 110, 112, 112, 112, 112, 113, 114, 114, 115, 115, 115, 115, 117,
116, 117, 117, 117, 117, 118, 118, 118, 118, 118, 119, 119, 119, 119, 119, 119,
119, 119, 120, 119, 119, 119, 119, 118, 118, 118, 118, 118, 118, 117, 117, 116,
117, 115, 115, 115, 113, 113, 113, 112, 112, 111, 110, 109, 109, 108, 108, 106,
105, 104, 104, 102, 102, 102, 100, 98, 98, 97, 96, 94, 93, 91, 91, 89, 87, 87,
85, 84, 83, 81, 79, 78, 77, 76, 73, 73, 70, 69, 67, 65, 64, 63, 60, 59, 57, 56,
54, 53, 50, 48, 47, 44, 42, 42, 39, 37, 35, 33, 32, 29, 28, 27, 25, 22, 22, 19,
18, 16, 13, 12, 10, 8, 7, 5, 4, 2, 0, -2, -3, -5, -6, -7, -9, -11, -13, -14,
-15, -16, -17, -19, -21, -22, -23, -25, -25, -27, -28, -29, -30, -31, -32, -34,
-34, -36, -37, -38, -39, -39, -41, -42, -42, -43, -44, -45, -46, -46, -47, -48,
-48, -50, -50, -51, -52, -52, -52, -53, -54, -54, -55, -55, -56, -57, -58, -58,
-58, -59, -59, -60, -60, -62, -62, -61, -62, -63, -64, -64, -64, -66, -67, -67,
-67, -68, -69, -69, -69, -70, -70, -71, -72, -72, -72, -74, -74, -75, -75, -76,
-77, -78, -78, -79, -79, -80, -81, -82, -82, -83, -83, -84, -85, -85, -86, -87,
-88, -89, -89, -90, -91, -91, -91, -92, -93, -93, -94, -95, -95, -96, -96, -97,
-98, -99, -98, -100, -99, -100, -101, -101, -101, -102, -102, -103, -102, -103,
-103, -104, -104, -104, -103, -104, -104, -104, -104, -105, -105, -105, -104,
-105, -105, -105, -105, -104, -105, -104, -104, -105, -104, -104, -103, -104,
-103, -103, -103, -102, -102, -101, -101, -101, -100, -100, -99, -99, -98, -98,
-97, -97, -96, -96, -96, -94, -94, -94, -93, -93, -92, -90, -91, -90, -89, -89,
-88, -87, -86, -86, -85, -85, -85, -83, -83, -82, -80, -80, -79, -79, -78, -76,
-75, -75, -75, -73, -72, -71, -70, -70, -69, -68, -67, -66, -65, -64, -63, -62,
-61, -60, -59, -57, -56, -55, -55, -53, -51, -52, -50, -49, -47, -47, -45, -44,
-43, -41, -40, -39, -37, -37, -35, -35, -32, -32, -30, -28, -28, -26, -25, -23,
-23, -21, -19, -18, -17, -15, -13, -12, -11, -9, -9, -7, -5, -3, -2, -1, };