#define DATA_LENGTH 512
#define DATA AKWF_1880

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 11, 23, 34, 44, 54, 64, 73, 81, 85,
88, 88, 87, 84, 78, 72, 65, 57, 49, 41, 32, 23, 14, 5, -3, -13, -22, -31, -41,
-50, -61, -72, -81, -90, -99, -106, -112, -117, -120, -118, -116, -112, -106,
-97, -86, -74, -62, -49, -37, -26, -14, -4, 6, 14, 21, 28, 31, 35, 38, 40, 44,
45, 48, 50, 49, 50, 51, 50, 48, 44, 40, 36, 30, 24, 16, 8, 1, -5, -11, -16, -20,
-21, -22, -21, -19, -17, -13, -8, -4, 1, 6, 11, 15, 16, 19, 20, 20, 20, 19, 18,
16, 14, 12, 10, 10, 7, 5, 3, 0, -3, -6, -11, -17, -22, -28, -35, -42, -48, -55,
-60, -63, -66, -67, -67, -66, -63, -58, -53, -47, -39, -31, -23, -15, -7, -1, 7,
13, 18, 23, 27, 31, 35, 39, 42, 46, 49, 50, 53, 55, 56, 55, 54, 52, 48, 45, 39,
33, 26, 19, 11, 4, -3, -9, -14, -20, -24, -26, -29, -29, -29, -28, -27, -27,
-25, -24, -21, -19, -19, -17, -15, -14, -13, -12, -10, -8, -7, -4, -2, 0, 2, 3,
4, 5, 5, 3, 2, 0, -2, -6, -10, -14, -17, -22, -26, -27, -29, -30, -31, -31, -29,
-26, -23, -21, -17, -13, -10, -6, -1, 2, 5, 8, 12, 15, 17, 21, 24, 27, 29, 32,
35, 37, 39, 40, 41, 42, 40, 38, 35, 32, 28, 23, 16, 10, 5, 0, -7, -13, -17, -21,
-25, -28, -30, -32, -33, -34, -34, -34, -32, -31, -31, -29, -28, -27, -26, -24,
-22, -20, -16, -13, -10, -6, -2, 1, 6, 8, 11, 14, 15, 15, 15, 15, 13, 11, 9, 7,
4, 2, -1, -2, -4, -6, -7, -6, -7, -6, -5, -5, -4, -2, -1, -1, 1, 1, 3, 3, 5, 7,
8, 11, 12, 14, 17, 18, 20, 23, 24, 26, 26, 26, 27, 25, 22, 19, 17, 13, 9, 5, 0,
-3, -8, -12, -15, -18, -20, -22, -24, -25, -25, -26, -26, -26, -25, -25, -25,
-24, -21, -21, -19, -17, -14, -11, -8, -5, -2, 2, 6, 9, 13, 15, 17, 20, 22, 23,
22, 23, 21, 21, 20, 17, 16, 14, 11, 10, 9, 7, 6, 5, 4, 3, 2, 2, 1, -1, -2, -3,
-3, -3, -4, -4, -4, -4, -3, -2, 0, 1, 2, 4, 6, 7, 9, 11, 10, 10, 10, 10, 9, 7,
5, 3, 0, -1, -4, -7, -8, -10, -11, -12, -13, -14, -15, -14, -15, -15, -16, -16,
-16, -16, -16, -16, -15, -14, -12, -11, -9, -6, -3, -1, 3, 7, 9, 12, 15, 17, 19,
20, 21, 22, 22, 22, 22, 21, 20, 20, 19, 17, 16, 15, 14, 13, 12, 11, 10, 9, 8, 6,
4, 3, 3, 1, 0, -1, -1, -1, -1, 0, 0, 2, 3, 5, 6, 9, 10, 11, 13, 14, 14, 14, 14,
13, 12, 12, 10, 10, 9, 7, 7, 4, 4, 3, 0, -2, -4, -7, -10, -13, -15, -18, -18,
-16, -13, -9, -4, };