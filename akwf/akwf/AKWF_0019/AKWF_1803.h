#define DATA_LENGTH 512
#define DATA AKWF_1803

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 2, 4, 5, 6, 7, 7, 8, 8, 9, 9,
9, 11, 11, 12, 11, 12, 13, 13, 14, 13, 15, 15, 16, 16, 16, 17, 17, 18, 18, 18,
18, 19, 18, 19, 19, 19, 19, 19, 19, 19, 19, 19, 18, 19, 19, 20, 19, 19, 20, 20,
19, 21, 21, 22, 23, 23, 24, 25, 25, 28, 29, 30, 32, 33, 35, 37, 39, 40, 42, 45,
46, 48, 51, 53, 56, 58, 60, 62, 65, 66, 69, 71, 73, 75, 77, 79, 81, 82, 84, 87,
88, 90, 91, 94, 95, 96, 98, 100, 102, 103, 104, 106, 107, 108, 110, 110, 112,
114, 115, 116, 118, 119, 118, 118, 118, 117, 116, 116, 115, 114, 113, 112, 111,
111, 108, 108, 106, 106, 104, 103, 101, 100, 100, 99, 97, 96, 96, 96, 94, 93,
92, 90, 89, 88, 87, 86, 84, 83, 82, 81, 80, 78, 78, 77, 75, 74, 74, 72, 72, 70,
69, 69, 67, 67, 66, 65, 64, 63, 62, 62, 61, 59, 59, 57, 56, 55, 55, 53, 52, 51,
50, 49, 48, 48, 46, 45, 45, 44, 43, 43, 42, 41, 41, 40, 38, 38, 38, 37, 36, 35,
34, 33, 32, 32, 31, 31, 30, 29, 28, 27, 26, 25, 25, 24, 23, 22, 21, 21, 20, 19,
18, 17, 16, 16, 14, 14, 13, 12, 11, 11, 11, 9, 9, 8, 7, 6, 5, 4, 3, 3, 1, 0, -1,
-1, -2, -2, -3, -4, -5, -6, -7, -9, -9, -9, -11, -13, -13, -14, -15, -16, -17,
-17, -19, -19, -20, -22, -23, -23, -25, -26, -26, -27, -28, -29, -30, -31, -31,
-32, -33, -34, -36, -36, -37, -38, -39, -41, -41, -41, -43, -43, -44, -46, -45,
-47, -47, -48, -50, -50, -50, -51, -52, -53, -53, -54, -55, -56, -57, -57, -58,
-58, -59, -59, -60, -61, -62, -63, -64, -64, -66, -66, -67, -69, -69, -70, -70,
-72, -72, -73, -74, -74, -75, -75, -75, -76, -77, -78, -78, -79, -80, -81, -81,
-82, -81, -83, -84, -84, -85, -85, -86, -87, -88, -88, -89, -90, -91, -91, -92,
-93, -93, -93, -94, -94, -95, -95, -96, -96, -96, -96, -95, -94, -94, -92, -90,
-90, -87, -87, -86, -85, -84, -83, -82, -82, -81, -81, -79, -78, -77, -77, -77,
-75, -74, -73, -73, -73, -72, -71, -70, -69, -68, -68, -68, -67, -67, -67, -66,
-65, -66, -65, -64, -64, -64, -64, -63, -63, -63, -63, -62, -62, -61, -60, -60,
-60, -59, -60, -57, -58, -56, -55, -55, -54, -53, -52, -52, -52, -51, -51, -50,
-48, -48, -47, -47, -45, -45, -44, -43, -43, -41, -40, -40, -38, -37, -36, -34,
-33, -32, -30, -30, -28, -26, -24, -23, -21, -19, -18, -15, -14, -12, -10, -9,
-7, -6, -3, -3, -1, 1, 2, 3, 5, 5, 7, 8, 10, 10, 12, 12, 14, 15, 15, 16, 17, 18,
19, 19, 19, 24, -6, -14, -8, -11, -7, -8, -6, -6, -3, -4, -2, -3, -1, -1, };