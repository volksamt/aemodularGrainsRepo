#define DATA_LENGTH 512
#define DATA AKWF_1849

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 27, 40, 51, 61, 70, 77, 84, 89, 94,
98, 100, 104, 106, 107, 110, 112, 112, 113, 114, 115, 116, 116, 117, 117, 117,
117, 118, 118, 118, 118, 118, 118, 119, 118, 119, 120, 119, 119, 120, 120, 119,
118, 118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119,
119, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119,
118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 120, 118, 119,
119, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118,
119, 119, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119,
119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119,
120, 119, 120, 118, 119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 120,
119, 119, 118, 120, 118, 118, 119, 120, 119, 119, 119, 119, 118, 119, 119, 119,
119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 118, 118, 118, 119, 119, 119, 119, 119, 118, 119, 119, 118, 119, 119,
118, 119, 119, 118, 119, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119,
119, 119, 120, 119, 118, 119, 119, 119, 119, 119, 119, 119, 120, 120, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 118, 114, 103, 81, 54, 25, 0, -18, -35,
-47, -57, -66, -74, -81, -88, -92, -95, -99, -103, -105, -107, -108, -111, -111,
-113, -114, -115, -115, -116, -116, -117, -117, -117, -117, -117, -118, -118,
-118, -118, -118, -118, -118, -119, -118, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -118, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -118, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-118, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -120, -119, -118, -119, -120, -119, -119, -119, -118, -120, -120,
-119, -119, -120, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -120, -120, -119, -119, -119, -119, -118, -119, -120,
-119, -119, -118, -119, -120, -119, -118, -119, -119, -119, -120, -119, -119,
-120, -119, -120, -119, -120, -119, -120, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -120, -120, -119, -119, -119, -120, -120,
-118, -119, -119, -119, -119, -119, -120, -118, -119, -119, -118, -119, -119,
-119, -118, -119, -119, -120, -119, -119, -119, -120, -119, -119, -119, -119,
-118, -119, -119, -119, -119, -118, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -118, -119, -120, -119, -119, -119, -120, -119, -119, -119, -119,
-120, -119, -119, -116, -107, -90, -64, -35, -9, };