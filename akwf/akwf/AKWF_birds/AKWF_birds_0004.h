#define DATA_LENGTH 512
#define DATA AKWF_birds_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 20, 32, 46, 58, 70, 81, 92, 99,
106, 111, 115, 118, 119, 119, 120, 118, 115, 112, 108, 102, 96, 89, 82, 74, 66,
58, 48, 40, 28, 19, 7, -5, -15, -27, -38, -48, -58, -67, -75, -82, -87, -92,
-95, -96, -97, -96, -93, -90, -86, -81, -75, -69, -61, -54, -47, -38, -30, -23,
-13, -5, 4, 14, 22, 30, 40, 48, 58, 66, 74, 80, 85, 91, 94, 97, 97, 97, 95, 93,
88, 83, 77, 69, 61, 52, 43, 33, 25, 14, 7, -3, -11, -19, -27, -33, -41, -47,
-53, -59, -64, -69, -73, -76, -79, -80, -82, -82, -80, -79, -75, -72, -67, -61,
-54, -47, -38, -29, -20, -11, -1, 7, 16, 23, 31, 38, 44, 49, 54, 57, 59, 63, 64,
65, 66, 65, 64, 64, 61, 57, 54, 50, 44, 39, 32, 24, 17, 8, -2, -12, -20, -31,
-41, -50, -59, -67, -73, -80, -85, -88, -92, -92, -93, -92, -90, -89, -84, -80,
-75, -70, -64, -57, -49, -43, -34, -26, -17, -9, 0, 10, 19, 30, 40, 50, 60, 69,
78, 86, 92, 98, 102, 104, 106, 106, 104, 101, 97, 90, 83, 76, 67, 58, 49, 39,
31, 24, 21, 21, 22, 25, 30, 34, 41, 48, 54, 61, 67, 74, 79, 85, 90, 93, 96, 98,
99, 99, 96, 92, 88, 82, 75, 67, 59, 50, 40, 31, 21, 12, 2, -6, -14, -24, -31,
-38, -44, -50, -56, -61, -66, -71, -74, -76, -78, -79, -78, -78, -76, -73, -70,
-64, -59, -51, -44, -34, -24, -13, -3, 9, 20, 31, 41, 50, 60, 69, 77, 83, 89,
95, 99, 102, 106, 108, 110, 109, 109, 108, 106, 104, 101, 97, 93, 87, 80, 75,
67, 57, 48, 38, 27, 18, 7, -4, -13, -22, -31, -39, -47, -52, -58, -63, -65, -68,
-69, -70, -70, -68, -67, -64, -62, -58, -53, -49, -43, -37, -31, -23, -16, -7,
1, 10, 20, 30, 40, 50, 58, 68, 75, 82, 88, 95, 98, 103, 104, 105, 105, 103, 102,
99, 94, 90, 84, 79, 73, 65, 59, 51, 43, 35, 26, 16, 8, -2, -11, -21, -33, -41,
-51, -61, -68, -76, -83, -89, -93, -96, -98, -98, -98, -96, -92, -89, -84, -78,
-71, -65, -57, -48, -41, -32, -23, -14, -7, 2, 12, 20, 29, 37, 46, 54, 62, 70,
76, 82, 86, 91, 93, 94, 95, 93, 91, 87, 81, 76, 68, 61, 51, 41, 30, 20, 9, -2,
-13, -22, -32, -42, -51, -59, -68, -76, -84, -91, -100, -106, -110, -114, -116,
-118, -119, -119, -119, -119, -117, -114, -108, -98, -89, -80, -69, -58, -45,
-34, -21, -8, 4, 15, 27, 36, 46, 55, 63, 70, 77, 82, 87, 93, 97, 99, 101, 102,
101, 100, 97, 95, 90, 85, 77, 70, 60, 51, 39, 27, 14, 1, -11, -25, -37, -48,
-60, -70, -78, -87, -94, -99, -105, -107, -111, -112, -113, -113, -113, -111,
-108, -104, -99, -94, -87, -81, -73, -63, -53, -42, -31, -17, -4, };