#define DATA_LENGTH 512
#define DATA AKWF_birds_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 12, 19, 25, 31, 39, 48, 56, 63, 70,
76, 84, 88, 95, 99, 104, 108, 111, 114, 117, 118, 119, 119, 118, 116, 113, 110,
105, 102, 97, 91, 85, 79, 72, 66, 59, 52, 45, 38, 32, 26, 19, 12, 5, -1, -8,
-15, -22, -28, -34, -40, -45, -50, -54, -57, -61, -65, -68, -70, -74, -76, -78,
-80, -81, -81, -81, -80, -78, -75, -73, -70, -66, -62, -56, -51, -46, -40, -34,
-29, -23, -19, -14, -8, -4, 0, 6, 10, 13, 19, 22, 26, 29, 33, 36, 39, 41, 45,
46, 48, 50, 51, 52, 53, 52, 53, 52, 50, 50, 48, 45, 43, 39, 36, 32, 28, 23, 18,
13, 8, 3, -2, -7, -11, -16, -20, -24, -28, -32, -36, -40, -46, -50, -54, -59,
-62, -67, -71, -75, -78, -82, -85, -87, -89, -91, -93, -93, -93, -93, -92, -91,
-89, -87, -83, -81, -77, -73, -68, -64, -58, -53, -47, -41, -36, -30, -26, -20,
-14, -8, -3, 2, 7, 12, 17, 21, 26, 30, 34, 41, 46, 51, 56, 60, 65, 69, 73, 75,
78, 80, 81, 81, 81, 81, 80, 79, 77, 75, 72, 70, 66, 63, 60, 56, 52, 47, 44, 38,
34, 30, 26, 21, 17, 13, 8, 4, 0, -4, -7, -10, -15, -19, -22, -25, -28, -31, -34,
-36, -39, -39, -41, -42, -42, -44, -44, -43, -43, -43, -42, -41, -40, -39, -36,
-34, -32, -31, -27, -25, -22, -19, -16, -14, -12, -9, -7, -5, -3, -2, 0, 0, 2,
2, 2, 5, 5, 7, 8, 10, 11, 13, 15, 16, 17, 19, 20, 20, 20, 21, 20, 19, 18, 17,
14, 11, 9, 6, 2, -1, -5, -8, -12, -14, -18, -22, -24, -27, -29, -32, -34, -38,
-40, -41, -44, -46, -49, -51, -55, -58, -61, -63, -67, -69, -73, -74, -76, -77,
-78, -78, -78, -78, -76, -75, -73, -70, -67, -63, -59, -56, -52, -48, -44, -39,
-35, -28, -24, -18, -11, -5, 0, 7, 12, 17, 23, 27, 32, 36, 42, 45, 49, 53, 56,
61, 63, 66, 69, 72, 74, 77, 78, 80, 81, 81, 81, 80, 79, 76, 73, 71, 67, 64, 61,
57, 52, 49, 44, 40, 37, 31, 27, 23, 19, 14, 9, 5, 1, -4, -9, -14, -17, -22, -25,
-29, -32, -36, -39, -42, -44, -46, -49, -50, -51, -53, -53, -54, -55, -57, -58,
-58, -59, -58, -58, -57, -55, -53, -51, -49, -47, -44, -40, -37, -33, -30, -27,
-23, -21, -16, -13, -10, -6, -3, 1, 5, 8, 12, 14, 17, 22, 23, 27, 31, 34, 37,
41, 44, 46, 49, 49, 50, 51, 50, 49, 49, 47, 46, 45, 41, 40, 37, 34, 31, 27, 24,
20, 16, 11, 8, 3, -2, -6, -12, -17, -23, -28, -34, -40, -46, -53, -58, -64, -70,
-76, -80, -86, -89, -93, -96, -99, -103, -104, -105, -106, -106, -105, -103,
-102, -99, -97, -94, -90, -86, -81, -75, -68, -60, -52, -44, -37, -29, -24, -17,
-13, -9, -6, -4, };