#define DATA_LENGTH 512
#define DATA AKWF_birds_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 18, 28, 39, 50, 59, 70, 81, 89, 97,
104, 110, 114, 117, 119, 118, 117, 113, 109, 101, 93, 84, 73, 62, 50, 38, 25,
14, 1, -10, -20, -31, -42, -51, -62, -70, -78, -87, -94, -99, -104, -107, -109,
-109, -108, -106, -101, -96, -88, -81, -70, -60, -48, -36, -23, -11, 2, 14, 24,
36, 46, 56, 65, 73, 82, 90, 96, 103, 107, 110, 113, 115, 114, 113, 110, 105, 99,
91, 81, 72, 60, 48, 36, 23, 10, -3, -15, -26, -37, -47, -56, -65, -74, -81, -86,
-93, -98, -101, -104, -105, -106, -106, -104, -99, -95, -88, -80, -72, -61, -50,
-39, -27, -13, -2, 11, 23, 34, 45, 56, 65, 75, 82, 90, 98, 103, 109, 113, 117,
119, 119, 118, 117, 112, 106, 100, 90, 81, 69, 57, 43, 29, 14, 0, -13, -27, -39,
-51, -61, -69, -78, -85, -92, -97, -101, -105, -108, -108, -109, -108, -105,
-102, -98, -92, -87, -80, -70, -62, -51, -40, -28, -16, -4, 7, 19, 31, 41, 52,
60, 68, 77, 85, 92, 99, 104, 109, 112, 114, 115, 114, 112, 108, 104, 95, 87, 76,
64, 51, 37, 22, 7, -7, -22, -36, -48, -61, -72, -80, -88, -93, -99, -103, -106,
-108, -109, -108, -106, -104, -100, -95, -90, -82, -74, -65, -55, -45, -32, -19,
-6, 6, 20, 33, 45, 56, 66, 75, 83, 90, 97, 101, 104, 107, 109, 110, 109, 108,
105, 101, 97, 91, 84, 76, 67, 57, 46, 33, 21, 7, -6, -19, -33, -46, -56, -67,
-76, -84, -91, -96, -101, -104, -106, -108, -107, -107, -103, -100, -95, -89,
-82, -76, -67, -57, -46, -33, -21, -6, 7, 22, 36, 49, 61, 73, 84, 94, 101, 108,
112, 115, 117, 117, 117, 115, 112, 107, 102, 96, 89, 81, 73, 64, 53, 42, 30, 17,
4, -10, -25, -37, -51, -62, -73, -83, -92, -97, -102, -105, -107, -106, -105,
-101, -97, -92, -87, -82, -75, -68, -63, -56, -52, -45, -41, -37, -32, -28, -24,
-19, -19, -21, -22, -10, 15, 52, 88, 110, 118, 117, 111, 108, 105, 103, 99, 93,
88, 81, 73, 66, 58, 48, 39, 28, 18, 5, -7, -19, -31, -43, -55, -65, -76, -85,
-92, -97, -101, -104, -104, -104, -102, -99, -94, -89, -82, -74, -67, -59, -49,
-40, -29, -20, -10, 2, 13, 24, 35, 47, 57, 68, 76, 86, 94, 100, 104, 109, 110,
110, 110, 107, 104, 98, 93, 86, 78, 70, 61, 51, 42, 33, 22, 12, 2, -10, -20,
-33, -42, -54, -65, -73, -82, -90, -95, -100, -103, -104, -105, -103, -100, -96,
-91, -84, -76, -67, -58, -49, -39, -29, -19, -8, 2, 13, 25, 36, 48, 60, 71, 80,
89, 98, 105, 111, 114, 117, 118, 117, 114, 109, 103, 97, 88, 78, 68, 56, 45, 34,
23, 11, 1, -10, -21, -31, -41, -50, -61, -70, -79, -86, -92, -98, -102, -105,
-106, -106, -105, -102, -96, -90, -83, -74, -66, -56, -45, -34, -23, -12, -2, };