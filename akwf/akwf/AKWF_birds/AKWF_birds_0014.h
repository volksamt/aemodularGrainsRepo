#define DATA_LENGTH 512
#define DATA AKWF_birds_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 12, 15, 17, 20, 21, 24, 24,
27, 26, 27, 28, 28, 29, 28, 27, 27, 26, 25, 24, 22, 21, 19, 17, 16, 14, 12, 9,
8, 6, 3, 2, -1, -3, -5, -6, -8, -9, -11, -11, -12, -13, -15, -15, -15, -16, -15,
-15, -14, -14, -13, -12, -12, -11, -9, -7, -5, -4, -2, 0, 2, 4, 6, 9, 11, 13,
16, 18, 20, 22, 25, 27, 28, 31, 33, 34, 36, 37, 39, 41, 42, 42, 43, 44, 44, 44,
44, 43, 44, 43, 42, 41, 39, 38, 37, 35, 33, 31, 27, 25, 23, 19, 17, 14, 9, 6, 2,
-2, -5, -9, -12, -17, -20, -24, -29, -32, -35, -39, -43, -46, -49, -52, -56,
-57, -60, -63, -65, -67, -70, -71, -73, -73, -74, -75, -74, -76, -75, -75, -75,
-74, -73, -72, -71, -69, -68, -67, -65, -62, -59, -57, -54, -52, -49, -47, -43,
-40, -38, -35, -32, -29, -26, -24, -21, -18, -16, -14, -11, -9, -7, -5, -4, -1,
0, 1, 3, 4, 5, 5, 5, 6, 6, 7, 7, 6, 6, 6, 6, 5, 4, 3, 3, 2, 1, 0, -2, -3, -3,
-5, -6, -8, -8, -10, -11, -11, -13, -13, -15, -15, -16, -17, -17, -18, -19, -18,
-19, -20, -20, -20, -20, -21, -20, -20, -19, -20, -19, -20, -19, -18, -17, -17,
-17, -16, -15, -15, -14, -13, -12, -11, -10, -9, -9, -8, -8, -7, -7, -6, -6, -7,
-7, -7, -7, -7, -7, -8, -9, -9, -10, -12, -13, -14, -16, -17, -19, -21, -23,
-25, -26, -30, -32, -35, -37, -40, -44, -48, -51, -54, -56, -61, -63, -67, -71,
-74, -78, -82, -84, -87, -91, -94, -97, -100, -103, -105, -107, -109, -111,
-113, -114, -115, -118, -118, -119, -119, -119, -119, -118, -119, -117, -117,
-115, -114, -112, -110, -110, -107, -104, -102, -100, -97, -94, -92, -88, -85,
-82, -78, -76, -72, -69, -66, -63, -60, -56, -54, -51, -48, -47, -44, -41, -39,
-36, -35, -33, -31, -30, -27, -26, -25, -25, -24, -25, -24, -23, -23, -23, -24,
-24, -24, -25, -25, -27, -27, -29, -30, -30, -32, -34, -35, -37, -38, -40, -42,
-44, -44, -46, -48, -50, -52, -52, -55, -55, -56, -58, -59, -60, -61, -61, -62,
-64, -63, -64, -63, -63, -63, -63, -62, -62, -61, -60, -58, -59, -57, -55, -54,
-51, -49, -48, -46, -44, -41, -39, -37, -36, -33, -31, -28, -26, -23, -21, -19,
-18, -15, -14, -12, -10, -8, -7, -6, -5, -5, -4, -4, -4, -4, -3, -5, -5, -7, -8,
-10, -12, -13, -16, -18, -21, -24, -27, -30, -34, -38, -41, -45, -50, -53, -57,
-62, -65, -69, -74, -77, -82, -85, -88, -92, -95, -99, -102, -104, -106, -109,
-110, -112, -115, -116, -117, -117, -118, -119, -119, -119, -119, -118, -115,
-114, -112, -110, -108, -105, -102, -99, -95, -92, -87, -83, -78, -74, -69, -64,
-60, -55, -50, -45, -41, -34, -30, -26, -21, -17, -12, -7, -5, -1, };