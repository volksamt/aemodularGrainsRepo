#define DATA_LENGTH 512
#define DATA AKWF_birds_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 10, 13, 17, 23, 28, 34, 40,
44, 50, 55, 60, 65, 69, 73, 76, 78, 82, 83, 85, 86, 86, 87, 88, 88, 89, 88, 88,
89, 89, 89, 90, 90, 91, 92, 94, 94, 94, 95, 96, 97, 97, 98, 99, 99, 100, 101,
101, 102, 102, 103, 103, 104, 104, 105, 105, 106, 106, 107, 107, 107, 108, 108,
109, 108, 109, 109, 109, 110, 110, 110, 111, 111, 110, 111, 111, 111, 110, 111,
111, 111, 111, 111, 111, 111, 110, 111, 110, 111, 110, 110, 111, 111, 110, 110,
110, 109, 109, 109, 108, 108, 108, 107, 108, 107, 106, 107, 107, 105, 105, 105,
104, 103, 104, 102, 102, 102, 100, 100, 100, 98, 99, 98, 97, 96, 96, 94, 94, 94,
93, 92, 91, 90, 90, 89, 88, 87, 86, 85, 84, 84, 83, 82, 81, 80, 79, 78, 77, 76,
74, 75, 73, 72, 71, 70, 68, 68, 66, 65, 64, 63, 62, 61, 61, 59, 58, 57, 55, 54,
52, 51, 51, 49, 48, 46, 46, 44, 43, 41, 40, 39, 38, 37, 35, 34, 33, 32, 30, 28,
27, 26, 25, 22, 21, 21, 19, 17, 16, 15, 14, 12, 12, 9, 8, 7, 6, 4, 3, 1, 0, -1,
-3, -5, -6, -7, -9, -10, -12, -13, -14, -16, -17, -18, -19, -21, -23, -24, -25,
-27, -28, -29, -31, -32, -34, -35, -37, -37, -40, -41, -43, -44, -45, -46, -48,
-49, -51, -52, -53, -54, -56, -56, -59, -59, -60, -61, -63, -64, -65, -66, -68,
-69, -70, -71, -73, -74, -75, -75, -77, -78, -79, -81, -81, -82, -83, -84, -86,
-87, -87, -89, -89, -90, -91, -92, -94, -95, -95, -95, -97, -97, -98, -99, -100,
-101, -101, -103, -103, -104, -105, -104, -106, -107, -107, -107, -108, -109,
-109, -110, -110, -111, -111, -112, -113, -113, -114, -114, -114, -115, -115,
-115, -116, -116, -116, -117, -117, -117, -117, -118, -118, -117, -118, -119,
-118, -119, -119, -119, -119, -119, -120, -119, -120, -118, -118, -119, -119,
-118, -119, -119, -119, -118, -118, -118, -118, -117, -118, -118, -117, -116,
-116, -116, -116, -115, -115, -114, -114, -113, -113, -112, -112, -111, -110,
-110, -109, -109, -108, -107, -107, -107, -107, -106, -104, -104, -104, -102,
-101, -101, -100, -100, -98, -97, -96, -95, -94, -93, -93, -91, -91, -90, -88,
-87, -86, -85, -84, -83, -81, -79, -79, -78, -76, -76, -73, -73, -71, -69, -67,
-67, -66, -64, -63, -61, -59, -58, -57, -55, -53, -52, -50, -48, -48, -46, -44,
-43, -41, -40, -39, -36, -36, -33, -33, -31, -30, -28, -27, -26, -25, -23, -22,
-20, -19, -18, -17, -16, -15, -13, -12, -12, -10, -8, -8, -8, -6, -5, -4, -4,
-3, -3, -1, -1, -1, 0, 0, 1, 2, 3, 3, 2, 3, 4, 4, 4, 4, 4, 4, 5, 6, 6, 6, 6, 6,
6, 6, 7, 6, 6, 6, 5, 5, 4, 3, 3, 1, 0, -1, -2, -2, -4, -4, -3, -3, -2, -1, };