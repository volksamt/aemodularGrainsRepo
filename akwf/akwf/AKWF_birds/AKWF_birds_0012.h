#define DATA_LENGTH 512
#define DATA AKWF_birds_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 5, 7, 10, 13, 16, 19, 23, 27,
30, 33, 37, 40, 42, 45, 47, 49, 49, 50, 52, 53, 53, 54, 55, 56, 58, 58, 60, 61,
62, 62, 64, 66, 67, 68, 70, 70, 72, 73, 74, 76, 76, 77, 79, 80, 82, 83, 84, 85,
87, 87, 89, 89, 91, 92, 92, 94, 95, 96, 96, 98, 99, 100, 101, 101, 102, 104,
103, 105, 105, 107, 107, 108, 108, 108, 110, 110, 111, 111, 111, 112, 113, 113,
113, 114, 115, 116, 116, 116, 116, 117, 118, 117, 118, 118, 118, 118, 119, 119,
119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119,
118, 119, 120, 119, 119, 118, 118, 118, 118, 117, 117, 116, 116, 115, 116, 115,
114, 115, 114, 113, 113, 113, 112, 111, 110, 110, 110, 109, 109, 108, 108, 106,
106, 105, 105, 104, 103, 102, 101, 100, 99, 99, 98, 97, 96, 94, 94, 93, 92, 91,
90, 89, 88, 86, 85, 85, 83, 81, 80, 79, 78, 76, 75, 74, 73, 71, 69, 68, 67, 66,
64, 63, 61, 60, 59, 56, 56, 54, 53, 52, 49, 48, 46, 44, 43, 42, 41, 38, 36, 35,
34, 32, 30, 29, 27, 25, 24, 22, 21, 19, 17, 16, 14, 13, 11, 9, 8, 6, 4, 2, 1,
-1, -2, -4, -6, -8, -9, -11, -12, -14, -15, -17, -18, -20, -21, -23, -24, -26,
-28, -30, -31, -33, -34, -36, -38, -39, -40, -42, -44, -44, -46, -47, -50, -51,
-52, -54, -56, -57, -58, -59, -60, -62, -64, -65, -67, -68, -68, -70, -70, -72,
-74, -74, -75, -76, -78, -79, -79, -81, -82, -83, -85, -86, -86, -88, -89, -90,
-91, -92, -93, -93, -94, -95, -96, -96, -98, -98, -99, -100, -101, -102, -102,
-104, -104, -104, -105, -106, -106, -107, -108, -109, -108, -110, -110, -111,
-111, -112, -113, -113, -113, -115, -115, -114, -115, -116, -116, -117, -117,
-117, -118, -118, -118, -118, -118, -118, -118, -119, -118, -118, -119, -120,
-118, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -120, -119,
-118, -120, -119, -119, -118, -118, -119, -118, -118, -117, -117, -117, -118,
-117, -116, -116, -116, -115, -114, -115, -114, -113, -113, -111, -111, -111,
-110, -109, -109, -109, -108, -107, -106, -106, -105, -104, -104, -102, -102,
-101, -100, -99, -99, -97, -97, -96, -94, -94, -93, -91, -91, -89, -88, -88,
-86, -85, -84, -82, -82, -81, -80, -78, -77, -76, -73, -73, -71, -70, -69, -68,
-65, -64, -62, -60, -60, -58, -56, -55, -53, -52, -50, -48, -46, -45, -43, -42,
-40, -38, -36, -35, -33, -32, -30, -28, -27, -26, -23, -21, -20, -19, -18, -16,
-15, -13, -12, -12, -10, -8, -7, -6, -5, -4, -4, -3, -1, -1, 0, 1, 2, 2, 3, 3,
4, 4, 4, 4, 5, 5, 6, 6, 6, 6, 6, 7, 6, 6, 6, 7, 7, 6, 6, 5, 5, 4, 3, 2, 2, 1, 1,
0, 0, 0, };