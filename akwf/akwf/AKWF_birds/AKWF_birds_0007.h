#define DATA_LENGTH 512
#define DATA AKWF_birds_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 9, 12, 15, 19, 21, 24, 26, 27,
28, 30, 31, 33, 35, 37, 38, 40, 42, 44, 46, 49, 50, 53, 54, 56, 59, 60, 62, 65,
66, 69, 69, 71, 72, 74, 76, 77, 79, 80, 81, 82, 84, 85, 86, 88, 89, 90, 90, 92,
92, 94, 95, 95, 96, 97, 99, 99, 99, 100, 101, 102, 103, 104, 104, 104, 105, 106,
106, 106, 108, 108, 108, 108, 109, 109, 109, 110, 110, 111, 110, 110, 112, 111,
112, 113, 113, 113, 113, 114, 113, 114, 115, 115, 115, 116, 115, 116, 117, 117,
116, 117, 117, 117, 118, 117, 118, 118, 118, 119, 119, 119, 119, 119, 120, 119,
119, 119, 118, 118, 118, 118, 118, 118, 117, 118, 117, 116, 116, 116, 115, 115,
114, 114, 113, 112, 112, 111, 110, 109, 109, 108, 107, 106, 105, 103, 102, 101,
100, 98, 96, 96, 94, 92, 91, 90, 88, 87, 84, 82, 81, 78, 78, 75, 74, 72, 69, 68,
65, 63, 62, 60, 57, 56, 54, 52, 50, 48, 46, 44, 41, 39, 38, 36, 34, 32, 30, 28,
26, 24, 22, 20, 19, 17, 14, 14, 11, 10, 8, 6, 4, 3, 2, 1, -1, -2, -4, -4, -6,
-7, -8, -9, -10, -11, -12, -12, -13, -14, -15, -15, -16, -17, -18, -19, -19,
-19, -19, -20, -20, -21, -21, -22, -22, -22, -23, -23, -24, -23, -24, -25, -25,
-25, -24, -25, -25, -25, -25, -26, -26, -26, -27, -26, -27, -27, -26, -27, -26,
-27, -27, -28, -28, -29, -30, -30, -31, -30, -31, -32, -32, -33, -34, -35, -35,
-35, -36, -37, -39, -40, -40, -41, -42, -43, -44, -45, -45, -47, -47, -49, -49,
-51, -51, -52, -53, -55, -56, -56, -58, -59, -60, -61, -63, -64, -65, -66, -67,
-68, -69, -70, -73, -73, -74, -75, -77, -78, -79, -79, -81, -82, -82, -84, -85,
-85, -87, -88, -89, -90, -90, -92, -92, -93, -94, -94, -96, -97, -98, -98, -98,
-99, -100, -101, -101, -102, -102, -102, -103, -102, -103, -104, -105, -104,
-104, -105, -104, -105, -104, -106, -106, -106, -106, -105, -105, -104, -104,
-105, -104, -105, -104, -103, -103, -103, -102, -103, -102, -102, -102, -101,
-100, -100, -99, -99, -98, -98, -98, -97, -96, -96, -96, -94, -95, -94, -93,
-92, -92, -91, -91, -90, -89, -89, -88, -87, -88, -86, -85, -85, -85, -84, -84,
-84, -82, -82, -81, -82, -81, -80, -80, -80, -80, -80, -78, -78, -78, -77, -77,
-76, -76, -77, -75, -75, -74, -74, -73, -73, -73, -72, -72, -72, -71, -71, -71,
-70, -70, -69, -68, -68, -68, -67, -67, -67, -66, -65, -66, -65, -64, -63, -62,
-61, -60, -59, -59, -57, -57, -55, -54, -52, -52, -51, -49, -48, -46, -45, -44,
-42, -40, -38, -37, -36, -34, -33, -31, -29, -28, -27, -25, -24, -22, -21, -20,
-18, -18, -16, -15, -14, -12, -12, -11, -10, -10, -9, -8, -7, -6, -5, -5, -5,
-5, -5, -5, -4, -5, -4, -2, -1, };