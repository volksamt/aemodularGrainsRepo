#define DATA_LENGTH 512
#define DATA AKWF_birds_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 16, 21, 27, 31, 37, 43, 50, 56,
63, 68, 75, 80, 84, 88, 92, 93, 96, 96, 96, 97, 97, 96, 93, 92, 90, 87, 84, 82,
78, 73, 69, 65, 59, 55, 50, 44, 40, 34, 29, 25, 20, 16, 12, 7, 3, 0, -4, -8,
-11, -13, -16, -18, -20, -23, -24, -26, -27, -28, -28, -29, -29, -30, -29, -30,
-29, -29, -30, -28, -28, -27, -26, -24, -24, -22, -22, -21, -19, -19, -17, -17,
-15, -15, -13, -12, -13, -11, -11, -9, -9, -8, -7, -8, -6, -7, -5, -4, -5, -3,
-3, -3, -3, -3, -3, -3, -3, -3, -4, -4, -5, -6, -7, -8, -9, -10, -11, -12, -13,
-15, -16, -18, -19, -20, -22, -24, -25, -27, -26, -28, -29, -30, -30, -31, -31,
-32, -32, -32, -31, -30, -29, -29, -27, -26, -25, -24, -23, -22, -20, -20, -18,
-16, -15, -14, -13, -11, -10, -8, -6, -5, -3, -3, -1, 0, 1, 2, 3, 5, 6, 8, 8,
10, 11, 11, 13, 13, 13, 14, 14, 14, 15, 16, 16, 16, 16, 16, 17, 18, 18, 19, 19,
20, 20, 21, 22, 22, 24, 26, 25, 27, 29, 30, 32, 33, 34, 36, 38, 39, 40, 42, 43,
44, 45, 46, 46, 46, 45, 45, 44, 44, 43, 42, 41, 39, 37, 35, 33, 31, 26, 24, 21,
17, 14, 10, 7, 3, 0, -4, -7, -11, -14, -18, -20, -24, -27, -29, -31, -34, -37,
-40, -42, -43, -47, -48, -50, -50, -52, -54, -55, -56, -57, -58, -58, -59, -59,
-58, -58, -58, -59, -58, -57, -56, -56, -54, -53, -51, -48, -46, -44, -41, -38,
-35, -33, -29, -25, -21, -18, -14, -10, -6, -2, 1, 6, 8, 12, 16, 18, 22, 25, 28,
31, 33, 36, 37, 39, 41, 44, 44, 45, 47, 46, 47, 48, 49, 47, 48, 47, 47, 46, 46,
45, 43, 42, 40, 39, 36, 34, 31, 30, 27, 23, 19, 16, 11, 7, 2, -2, -7, -11, -16,
-21, -26, -30, -34, -39, -43, -46, -50, -54, -58, -60, -63, -65, -68, -69, -71,
-71, -71, -71, -70, -69, -66, -64, -61, -59, -56, -52, -50, -47, -43, -40, -36,
-33, -30, -25, -22, -18, -15, -12, -8, -5, -2, 2, 5, 9, 11, 14, 16, 19, 22, 25,
27, 29, 31, 34, 35, 37, 40, 43, 44, 46, 49, 50, 52, 54, 55, 57, 58, 59, 61, 62,
62, 64, 65, 65, 66, 66, 67, 67, 67, 67, 68, 68, 69, 69, 69, 69, 69, 69, 69, 69,
69, 67, 65, 64, 62, 60, 56, 53, 50, 45, 41, 37, 31, 26, 21, 15, 9, 2, -5, -12,
-20, -27, -34, -43, -50, -57, -65, -72, -78, -85, -90, -96, -100, -104, -108,
-111, -112, -115, -117, -117, -118, -119, -118, -119, -118, -118, -117, -115,
-114, -112, -110, -107, -103, -101, -97, -93, -90, -85, -81, -76, -72, -66, -62,
-55, -51, -45, -41, -36, -31, -27, -23, -21, -17, -13, -12, -9, -8, -6, -6, -4,
-1, };