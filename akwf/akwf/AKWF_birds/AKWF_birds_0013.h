#define DATA_LENGTH 512
#define DATA AKWF_birds_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 10, 15, 21, 27, 32, 37, 43, 48,
53, 58, 63, 67, 72, 75, 80, 84, 86, 91, 93, 96, 98, 101, 104, 105, 107, 109,
111, 112, 114, 114, 116, 117, 118, 119, 118, 118, 119, 118, 119, 118, 119, 118,
117, 116, 114, 113, 112, 110, 109, 108, 105, 103, 102, 100, 97, 94, 92, 89, 87,
84, 81, 79, 76, 73, 71, 67, 65, 62, 59, 56, 54, 51, 48, 46, 43, 40, 37, 35, 33,
29, 27, 25, 23, 20, 18, 16, 14, 12, 9, 7, 6, 5, 3, 1, -1, -1, -2, -4, -5, -6,
-6, -9, -8, -10, -10, -10, -10, -11, -11, -11, -11, -12, -11, -12, -11, -11,
-10, -11, -11, -11, -11, -11, -12, -12, -13, -13, -13, -14, -15, -15, -16, -17,
-18, -19, -20, -21, -22, -24, -26, -27, -28, -31, -32, -34, -36, -37, -39, -41,
-42, -44, -46, -48, -50, -52, -53, -55, -57, -60, -61, -62, -64, -66, -67, -68,
-70, -72, -74, -74, -76, -77, -78, -79, -81, -81, -82, -82, -83, -84, -85, -84,
-85, -85, -84, -83, -83, -81, -81, -80, -78, -77, -75, -73, -71, -70, -68, -65,
-63, -59, -57, -54, -50, -48, -45, -42, -38, -35, -32, -29, -26, -23, -21, -18,
-15, -13, -10, -8, -7, -5, -4, -2, -1, -1, 0, 1, 0, 1, 1, 1, 0, 0, 0, -1, -2,
-3, -3, -4, -5, -6, -7, -7, -7, -8, -8, -9, -9, -9, -8, -8, -8, -7, -6, -5, -3,
-2, 0, 2, 3, 5, 8, 10, 12, 15, 18, 20, 23, 25, 28, 30, 34, 36, 38, 41, 44, 46,
48, 50, 52, 54, 55, 58, 59, 60, 63, 64, 65, 66, 67, 67, 69, 68, 70, 71, 70, 70,
71, 70, 70, 70, 70, 70, 69, 68, 67, 68, 67, 65, 64, 64, 62, 61, 60, 58, 57, 56,
53, 52, 50, 48, 46, 45, 42, 41, 38, 38, 35, 34, 33, 31, 30, 29, 27, 27, 25, 24,
25, 25, 24, 24, 25, 26, 27, 27, 29, 32, 33, 36, 38, 39, 42, 45, 47, 51, 53, 57,
59, 61, 64, 66, 68, 71, 73, 74, 75, 77, 77, 78, 78, 77, 77, 76, 75, 73, 71, 68,
65, 63, 58, 55, 51, 47, 42, 37, 31, 27, 22, 15, 10, 5, -1, -7, -13, -19, -24,
-30, -34, -40, -45, -50, -55, -60, -63, -68, -72, -77, -81, -84, -88, -90, -93,
-95, -99, -102, -103, -105, -107, -108, -110, -111, -114, -115, -116, -116,
-117, -118, -118, -118, -118, -118, -117, -117, -116, -116, -114, -113, -112,
-110, -108, -106, -104, -102, -100, -98, -96, -93, -90, -89, -85, -83, -81, -77,
-75, -73, -70, -67, -66, -63, -60, -58, -57, -54, -53, -51, -49, -48, -47, -46,
-45, -44, -43, -42, -41, -40, -40, -39, -39, -38, -38, -38, -38, -38, -37, -36,
-37, -36, -35, -35, -35, -34, -33, -33, -32, -31, -31, -30, -30, -29, -28, -27,
-26, -25, -25, -23, -22, -20, -19, -16, -14, -9, -6, -2, };