#define DATA_LENGTH 512
#define DATA AKWF_birds_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 14, 25, 39, 50, 63, 73, 80, 86, 88,
91, 92, 92, 93, 95, 96, 98, 101, 103, 105, 107, 108, 110, 111, 113, 114, 115,
117, 117, 118, 118, 119, 119, 120, 119, 119, 118, 118, 116, 116, 114, 113, 112,
110, 107, 106, 103, 101, 99, 96, 93, 90, 88, 84, 82, 79, 75, 72, 69, 66, 63, 59,
58, 54, 52, 48, 45, 43, 40, 37, 34, 32, 29, 27, 24, 21, 19, 18, 15, 12, 10, 8,
7, 4, 3, 0, -2, -4, -4, -6, -8, -9, -11, -12, -12, -13, -14, -15, -16, -16, -17,
-16, -17, -17, -17, -17, -17, -16, -16, -15, -15, -14, -13, -13, -12, -12, -11,
-11, -11, -10, -10, -11, -10, -10, -11, -11, -11, -12, -12, -13, -15, -15, -18,
-19, -20, -21, -23, -25, -27, -28, -31, -32, -35, -37, -39, -40, -42, -45, -46,
-48, -50, -53, -54, -55, -57, -59, -61, -62, -64, -66, -66, -68, -70, -71, -72,
-74, -75, -76, -78, -78, -80, -81, -81, -83, -83, -83, -83, -84, -84, -84, -84,
-83, -82, -82, -81, -79, -78, -77, -75, -72, -70, -68, -64, -62, -59, -56, -52,
-49, -45, -42, -38, -35, -31, -27, -22, -19, -16, -12, -9, -6, -2, 0, 3, 5, 7,
9, 10, 12, 12, 14, 14, 14, 13, 14, 14, 12, 12, 9, 9, 7, 6, 4, 2, 1, 0, -2, -4,
-6, -6, -8, -8, -10, -10, -10, -12, -11, -10, -10, -10, -8, -7, -5, -5, -2, 0,
3, 4, 7, 10, 12, 16, 19, 23, 24, 28, 31, 34, 38, 40, 42, 46, 48, 50, 53, 55, 58,
60, 61, 64, 64, 67, 66, 68, 69, 70, 70, 71, 71, 72, 72, 71, 72, 71, 70, 71, 70,
70, 69, 69, 68, 67, 66, 64, 64, 62, 61, 60, 59, 57, 55, 53, 52, 49, 47, 46, 43,
42, 39, 37, 34, 32, 29, 27, 25, 23, 21, 19, 17, 16, 14, 13, 12, 12, 11, 10, 11,
10, 11, 13, 14, 16, 17, 20, 22, 25, 28, 31, 35, 38, 42, 46, 50, 53, 57, 61, 64,
67, 71, 73, 76, 78, 79, 81, 82, 83, 83, 83, 83, 81, 79, 76, 74, 71, 67, 63, 58,
52, 47, 43, 36, 30, 23, 18, 12, 5, -1, -8, -15, -21, -28, -35, -41, -47, -53,
-58, -63, -68, -73, -77, -82, -85, -90, -92, -96, -98, -101, -104, -106, -109,
-110, -112, -114, -115, -117, -118, -118, -119, -120, -119, -119, -120, -119,
-119, -118, -117, -117, -117, -115, -115, -112, -111, -109, -107, -105, -103,
-101, -98, -96, -93, -90, -87, -83, -80, -77, -73, -70, -68, -64, -61, -58, -54,
-52, -49, -46, -44, -42, -39, -37, -35, -33, -33, -31, -30, -29, -29, -27, -27,
-26, -27, -27, -26, -25, -26, -26, -27, -27, -26, -27, -27, -28, -28, -27, -28,
-28, -28, -28, -28, -28, -27, -26, -26, -25, -25, -24, -22, -22, -22, -21, -19,
-17, -16, -15, -15, -14, -14, -14, -15, -16, -16, -14, -10, -3, };