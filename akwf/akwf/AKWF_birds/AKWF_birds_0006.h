#define DATA_LENGTH 512
#define DATA AKWF_birds_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 8, 11, 15, 18, 22, 25, 27, 29,
31, 32, 32, 34, 36, 36, 37, 39, 40, 42, 44, 45, 46, 48, 50, 51, 52, 55, 57, 58,
61, 62, 63, 66, 66, 69, 69, 71, 72, 75, 75, 76, 78, 80, 81, 82, 84, 86, 87, 88,
89, 89, 91, 92, 93, 95, 95, 97, 98, 99, 100, 100, 102, 103, 103, 104, 105, 106,
107, 108, 108, 110, 109, 111, 110, 112, 112, 112, 114, 114, 115, 114, 116, 116,
115, 116, 117, 117, 117, 117, 118, 118, 118, 118, 119, 119, 119, 119, 119, 119,
119, 119, 120, 119, 119, 119, 119, 119, 118, 119, 119, 118, 117, 118, 117, 117,
117, 117, 117, 116, 115, 116, 115, 114, 115, 113, 114, 113, 113, 112, 112, 111,
111, 111, 109, 110, 109, 108, 107, 108, 107, 106, 105, 104, 105, 104, 104, 103,
102, 101, 100, 99, 99, 98, 98, 97, 96, 95, 95, 94, 93, 93, 91, 91, 90, 89, 88,
88, 86, 85, 84, 84, 83, 81, 81, 80, 80, 79, 77, 76, 76, 75, 73, 72, 71, 70, 69,
69, 67, 66, 65, 64, 63, 62, 61, 60, 59, 57, 56, 55, 55, 53, 51, 51, 49, 49, 47,
46, 45, 43, 42, 41, 41, 39, 38, 36, 35, 35, 33, 31, 30, 30, 28, 27, 26, 23, 23,
21, 20, 18, 17, 15, 14, 13, 12, 11, 10, 8, 7, 5, 3, 2, 2, 0, -1, -3, -3, -5, -7,
-8, -9, -9, -11, -13, -14, -15, -16, -18, -19, -20, -20, -22, -24, -24, -25,
-26, -27, -29, -29, -31, -32, -33, -34, -35, -35, -37, -38, -38, -39, -40, -41,
-42, -42, -43, -44, -45, -45, -46, -46, -47, -47, -49, -48, -49, -49, -50, -50,
-51, -52, -52, -52, -53, -53, -52, -54, -54, -54, -54, -55, -55, -55, -55, -55,
-55, -55, -56, -56, -57, -56, -57, -57, -57, -57, -57, -58, -58, -57, -58, -59,
-57, -58, -58, -58, -58, -58, -58, -59, -58, -59, -59, -59, -59, -60, -60, -60,
-59, -61, -60, -61, -60, -61, -61, -61, -63, -62, -62, -63, -62, -64, -64, -64,
-65, -65, -66, -65, -65, -67, -67, -67, -68, -68, -68, -69, -69, -70, -71, -70,
-70, -71, -72, -72, -72, -73, -72, -73, -74, -74, -74, -75, -74, -75, -75, -76,
-76, -76, -77, -77, -77, -76, -78, -77, -79, -78, -78, -78, -78, -78, -79, -79,
-79, -78, -78, -79, -79, -79, -79, -79, -79, -79, -78, -77, -77, -78, -77, -76,
-76, -76, -75, -74, -75, -75, -74, -74, -73, -72, -73, -72, -70, -70, -69, -68,
-68, -67, -66, -65, -64, -64, -62, -62, -61, -60, -58, -57, -56, -55, -54, -53,
-52, -50, -49, -47, -46, -44, -43, -41, -41, -39, -38, -36, -35, -33, -32, -30,
-29, -27, -27, -25, -24, -23, -22, -20, -19, -18, -17, -16, -16, -14, -13, -12,
-12, -10, -10, -10, -8, -8, -7, -6, -5, -5, -5, -5, -4, -3, -4, -5, -5, -5, -4,
-4, -3, -3, -1, };