#define DATA_LENGTH 512
#define DATA AKWF_birds_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 11, 16, 20, 26, 30, 35, 40, 44,
50, 54, 59, 62, 67, 72, 76, 80, 83, 87, 89, 93, 96, 99, 101, 104, 107, 108, 110,
112, 113, 114, 116, 116, 116, 117, 117, 116, 114, 115, 113, 112, 110, 108, 106,
103, 101, 98, 94, 91, 88, 84, 80, 76, 72, 68, 63, 59, 54, 49, 44, 39, 33, 28,
23, 18, 12, 7, 1, -5, -10, -15, -21, -26, -31, -37, -43, -47, -52, -57, -61,
-67, -72, -75, -79, -84, -87, -90, -95, -98, -101, -104, -106, -109, -111, -113,
-114, -116, -118, -118, -119, -119, -119, -120, -119, -119, -118, -116, -115,
-113, -111, -110, -108, -104, -102, -100, -96, -93, -90, -86, -84, -80, -75,
-71, -67, -63, -58, -54, -49, -45, -40, -36, -30, -26, -21, -17, -12, -7, -3, 2,
8, 12, 16, 20, 26, 30, 33, 38, 41, 45, 49, 52, 56, 59, 63, 66, 69, 71, 73, 76,
78, 80, 81, 84, 84, 86, 86, 87, 87, 89, 88, 88, 88, 88, 87, 87, 86, 85, 84, 83,
82, 80, 79, 77, 75, 73, 71, 69, 68, 66, 63, 59, 58, 55, 53, 50, 47, 44, 42, 38,
36, 32, 30, 27, 25, 21, 19, 15, 12, 11, 8, 4, 2, -1, -3, -6, -8, -10, -13, -15,
-17, -20, -21, -23, -25, -27, -29, -30, -32, -33, -34, -36, -37, -38, -39, -40,
-42, -42, -43, -43, -45, -45, -46, -46, -46, -47, -47, -47, -47, -48, -48, -48,
-48, -48, -48, -48, -48, -48, -48, -48, -48, -46, -47, -47, -46, -46, -45, -44,
-44, -43, -43, -41, -40, -40, -39, -39, -38, -36, -36, -35, -33, -33, -31, -30,
-29, -28, -28, -26, -25, -23, -22, -21, -19, -18, -16, -15, -13, -11, -10, -8,
-7, -5, -3, -1, 0, 2, 5, 6, 9, 10, 12, 14, 17, 19, 21, 23, 25, 27, 30, 33, 35,
36, 39, 41, 43, 45, 47, 49, 50, 51, 54, 56, 58, 59, 60, 61, 62, 64, 66, 67, 67,
68, 69, 69, 70, 70, 71, 71, 70, 71, 71, 70, 69, 70, 69, 68, 67, 66, 64, 62, 62,
60, 58, 56, 53, 51, 49, 47, 44, 41, 39, 35, 33, 30, 27, 23, 20, 16, 12, 8, 5, 2,
-2, -6, -10, -14, -17, -21, -25, -29, -33, -37, -40, -44, -48, -52, -56, -59,
-63, -66, -69, -73, -76, -79, -82, -84, -88, -90, -93, -95, -98, -100, -102,
-104, -105, -107, -109, -110, -112, -113, -113, -114, -114, -115, -116, -115,
-115, -115, -114, -114, -114, -113, -111, -110, -110, -109, -107, -106, -104,
-102, -101, -99, -97, -95, -94, -92, -89, -87, -85, -82, -79, -76, -74, -70,
-67, -63, -60, -55, -51, -46, -44, -40, -36, -34, -33, -30, -30, -30, -31, -33,
-36, -39, -43, -48, -54, -59, -64, -71, -76, -82, -87, -91, -95, -98, -100,
-100, -101, -102, -100, -98, -96, -93, -90, -86, -81, -77, -72, -68, -63, -59,
-54, -50, -45, -40, -36, -31, -27, -22, -16, -13, -8, -2, };