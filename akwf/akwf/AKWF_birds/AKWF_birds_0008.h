#define DATA_LENGTH 512
#define DATA AKWF_birds_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 9, 15, 21, 27, 34, 38, 42, 45,
47, 48, 49, 50, 51, 52, 54, 56, 58, 59, 61, 63, 65, 66, 68, 70, 71, 73, 73, 75,
77, 79, 80, 82, 83, 84, 85, 86, 88, 89, 89, 91, 92, 93, 94, 95, 95, 96, 96, 96,
98, 99, 100, 100, 101, 101, 102, 102, 103, 103, 103, 104, 105, 105, 106, 106,
107, 108, 109, 109, 109, 110, 110, 110, 111, 112, 111, 112, 112, 112, 113, 113,
114, 114, 115, 115, 115, 115, 115, 116, 116, 116, 118, 117, 117, 118, 118, 119,
118, 119, 119, 118, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119,
120, 119, 120, 119, 119, 118, 119, 118, 118, 117, 116, 116, 114, 113, 113, 112,
111, 109, 110, 108, 107, 105, 104, 103, 101, 100, 98, 96, 95, 93, 92, 89, 88,
87, 84, 83, 80, 79, 77, 75, 72, 70, 67, 66, 62, 60, 58, 56, 54, 51, 48, 45, 43,
40, 38, 35, 34, 30, 28, 26, 23, 21, 18, 16, 14, 12, 10, 8, 5, 3, 1, -1, -3, -3,
-6, -8, -10, -11, -14, -15, -17, -19, -21, -20, -22, -23, -25, -26, -28, -29,
-29, -30, -31, -32, -32, -34, -34, -34, -36, -36, -37, -36, -37, -37, -36, -37,
-38, -38, -37, -37, -37, -38, -37, -37, -37, -36, -36, -36, -36, -36, -35, -36,
-35, -35, -35, -34, -34, -34, -34, -34, -33, -33, -33, -33, -33, -33, -32, -33,
-32, -32, -32, -32, -32, -32, -31, -32, -32, -32, -32, -32, -33, -33, -33, -34,
-34, -35, -35, -35, -36, -36, -37, -38, -38, -40, -40, -40, -41, -42, -42, -43,
-44, -46, -46, -46, -47, -48, -49, -49, -50, -52, -53, -53, -54, -55, -57, -57,
-57, -59, -61, -61, -61, -62, -63, -65, -66, -66, -68, -68, -69, -70, -71, -73,
-72, -74, -75, -76, -76, -78, -78, -78, -80, -80, -81, -82, -83, -82, -84, -85,
-85, -85, -86, -86, -87, -88, -89, -89, -90, -90, -90, -91, -92, -92, -91, -92,
-92, -91, -92, -92, -93, -93, -93, -93, -92, -93, -92, -92, -92, -93, -91, -91,
-92, -92, -91, -91, -91, -91, -91, -90, -90, -90, -89, -89, -89, -89, -89, -88,
-87, -86, -86, -86, -86, -85, -85, -84, -84, -83, -83, -82, -82, -82, -81, -80,
-81, -80, -79, -79, -78, -78, -77, -77, -77, -77, -76, -76, -76, -75, -75, -75,
-74, -74, -73, -73, -72, -72, -72, -73, -71, -72, -71, -71, -71, -70, -70, -70,
-69, -69, -68, -68, -67, -67, -67, -66, -66, -66, -65, -65, -64, -63, -63, -63,
-63, -61, -61, -60, -60, -59, -59, -57, -58, -57, -56, -54, -54, -53, -53, -51,
-50, -48, -48, -46, -45, -43, -42, -40, -39, -38, -36, -34, -32, -31, -30, -28,
-25, -25, -22, -21, -19, -17, -16, -15, -14, -12, -10, -10, -8, -7, -6, -6, -5,
-3, -3, -2, -2, -2, 0, 0, 0, 0, 1, 1, 2, 0, 0, -1, -3, -3, -3, -2, };