#define DATA_LENGTH 512
#define DATA AKWF_birds_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 14, 23, 33, 40, 48, 53, 57, 59, 61,
61, 61, 62, 62, 64, 65, 67, 69, 70, 72, 74, 75, 76, 77, 79, 80, 81, 83, 83, 85,
86, 86, 88, 89, 90, 92, 92, 93, 93, 94, 96, 96, 97, 98, 99, 99, 100, 101, 101,
102, 103, 104, 104, 104, 106, 106, 106, 107, 107, 107, 107, 108, 109, 108, 110,
110, 111, 112, 112, 111, 112, 112, 113, 114, 114, 114, 114, 115, 115, 115, 116,
116, 117, 117, 117, 117, 117, 117, 117, 118, 118, 118, 119, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 118, 118, 118, 119, 118, 119, 118, 118, 117, 118,
118, 117, 117, 116, 116, 115, 115, 114, 114, 113, 112, 112, 111, 110, 109, 109,
108, 106, 107, 104, 103, 103, 102, 100, 99, 98, 97, 96, 94, 93, 91, 90, 89, 87,
85, 83, 81, 80, 78, 76, 74, 73, 71, 69, 68, 65, 63, 61, 59, 58, 55, 54, 50, 49,
47, 45, 42, 40, 38, 35, 34, 31, 29, 27, 25, 24, 22, 19, 16, 15, 13, 11, 10, 8,
6, 5, 3, 2, -1, -1, -4, -4, -6, -8, -9, -10, -11, -13, -14, -15, -15, -16, -18,
-19, -19, -20, -21, -21, -22, -23, -23, -23, -24, -24, -26, -25, -25, -25, -25,
-25, -26, -25, -25, -24, -25, -24, -24, -24, -24, -24, -22, -23, -22, -22, -22,
-21, -21, -21, -21, -20, -20, -20, -19, -19, -18, -18, -19, -18, -17, -18, -18,
-18, -18, -18, -17, -17, -18, -17, -18, -17, -18, -18, -18, -18, -18, -18, -19,
-18, -19, -19, -21, -21, -21, -22, -23, -23, -24, -25, -25, -27, -28, -29, -30,
-30, -32, -32, -34, -35, -36, -37, -39, -40, -41, -42, -44, -44, -46, -48, -49,
-51, -52, -52, -54, -55, -57, -58, -60, -62, -61, -63, -64, -65, -67, -68, -70,
-71, -73, -74, -74, -75, -77, -78, -80, -81, -82, -83, -84, -86, -86, -87, -89,
-90, -90, -91, -92, -93, -94, -94, -95, -97, -97, -97, -98, -98, -99, -100,
-100, -101, -102, -101, -103, -102, -102, -104, -103, -104, -104, -105, -104,
-105, -104, -105, -105, -105, -105, -105, -105, -104, -105, -104, -105, -104,
-104, -104, -103, -103, -102, -102, -102, -101, -100, -100, -100, -100, -99,
-99, -98, -98, -97, -97, -97, -97, -96, -95, -94, -94, -94, -93, -93, -93, -91,
-91, -91, -90, -90, -90, -90, -88, -88, -88, -88, -87, -87, -86, -86, -86, -86,
-85, -84, -84, -84, -83, -84, -83, -83, -82, -81, -81, -82, -82, -81, -80, -80,
-79, -79, -79, -79, -79, -78, -77, -77, -77, -77, -77, -77, -75, -75, -74, -74,
-74, -74, -73, -72, -72, -71, -70, -69, -70, -69, -68, -68, -67, -67, -65, -65,
-64, -63, -62, -61, -60, -59, -59, -58, -57, -56, -55, -54, -53, -52, -51, -49,
-48, -47, -45, -44, -43, -41, -40, -38, -36, -36, -34, -32, -30, -28, -26, -25,
-23, -21, -20, -19, -18, -18, -18, -17, -15, -11, -6, -1, };