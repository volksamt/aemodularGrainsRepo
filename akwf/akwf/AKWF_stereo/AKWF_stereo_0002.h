#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -16, 4, -22, 9, -26, 12, -30, 17,
-33, 20, -37, 23, -41, 27, -46, 31, -49, 35, -54, 38, -58, 41, -63, 45, -67, 48,
-71, 51, -75, 54, -79, 58, -84, 61, -88, 64, -93, 67, -96, 70, -96, 72, -94, 74,
-94, 77, -94, 79, -94, 78, -93, 77, -92, 76, -92, 77, -92, 75, -91, 76, -91, 75,
-90, 74, -91, 75, -90, 74, -90, 74, -90, 73, -90, 73, -88, 72, -88, 73, -88, 73,
-89, 72, -88, 72, -88, 71, -89, 72, -88, 71, -88, 71, -87, 72, -88, 71, -88, 71,
-87, 71, -87, 71, -87, 71, -87, 70, -87, 71, -86, 70, -86, 70, -87, 70, -87, 70,
-87, 70, -87, 70, -87, 70, -86, 70, -87, 70, -87, 70, -87, 69, -86, 70, -87, 70,
-87, 70, -86, 70, -86, 69, -86, 69, -87, 70, -86, 69, -87, 70, -86, 69, -86, 70,
-87, 70, -87, 70, -86, 70, -85, 69, -86, 70, -86, 70, -86, 70, -86, 70, -86, 69,
-86, 69, -86, 70, -86, 69, -86, 70, -86, 69, -86, 70, -86, 70, -86, 69, -86, 69,
-86, 70, -86, 70, -86, 69, -86, 69, -87, 69, -86, 70, -86, 69, -86, 70, -86, 68,
-86, 71, -86, 69, -86, 70, -86, 69, -86, 70, -86, 68, -86, 71, -86, 69, -86, 71,
-86, 69, -86, 71, -86, 68, -86, 71, -85, 68, -87, 71, -85, 68, -86, 70, -85, 70,
-87, 69, -85, 72, -88, 65, -82, 80, -94, 3, -29, 45, 85, 82, 89, 62, 88, 76, 87,
66, 85, 74, 84, 67, 82, 73, 82, 68, 80, 72, 80, 68, 78, 72, 78, 69, 77, 71, 77,
70, 75, 70, 74, 69, 74, 70, 73, 71, 73, 69, 73, 70, 72, 70, 71, 71, 71, 69, 71,
70, 71, 69, 70, 70, 70, 70, 70, 71, 69, 70, 69, 71, 69, 70, 68, 70, 68, 70, 68,
70, 68, 70, 68, 71, 67, 70, 67, 70, 67, 70, 67, 69, 66, 69, 66, 70, 66, 69, 66,
69, 66, 69, 66, 69, 66, 70, 66, 70, 65, 69, 65, 68, 65, 69, 65, 68, 65, 69, 64,
68, 64, 68, 64, 68, 65, 69, 65, 68, 63, 69, 64, 68, 64, 68, 64, 68, 64, 68, 64,
68, 63, 68, 63, 67, 63, 68, 64, 68, 62, 68, 62, 67, 63, 68, 63, 67, 63, 68, 63,
66, 62, 67, 63, 66, 62, 68, 62, 68, 63, 66, 62, 68, 62, 67, 62, 67, 62, 66, 62,
67, 62, 67, 61, 66, 62, 67, 62, 66, 61, 66, 61, 66, 61, 66, 62, 67, 61, 67, 61,
66, 61, 66, 62, 66, 61, 66, 60, 66, 61, 66, 61, 66, 60, 65, 61, 65, 60, 66, 60,
65, 60, 66, 61, 66, 60, 65, 60, 65, 60, 65, 60, 64, 60, 65, 60, 64, 60, 64, 60,
64, 59, 64, 60, 65, 59, 64, 59, 64, 59, 64, 59, 64, 59, 65, 59, 64, 59, 64, 59,
64, 59, 64, 59, 65, 58, 64, 59, 64, 58, 64, 59, 63, 59, 64, 58, 64, 59, 64, 58,
64, 58, 63, 58, 62, 58, 63, 59, 63, 58, 64, 58, 63, 58, 63, 57, 62, 57, 63, 57,
63, 59, 62, 57, 64, 58, 61, 56, 65, 59, 61, 55, 69, 64, -31, -19, -118, -121,
-108, -115, -110, -115, -104, -111, -105, -108, -100, -106, -100, -105, -97,
-103, -96, -101, -95, -101, -94, -98, -92, -99, -92, -96, -91, -96, -89, -94,
-88, -93, -87, -91, -87, -92, -86, -90, -86, -90, -84, -89, -84, -90, -83, -88,
-84, -88, -83, -87, -83, -88, -82, -87, -82, -86, -81, -86, -81, -86, -81, -86,
-81, -86, -81, -85, -81, -85, -80, -86, -79, -85, -79, -84, -80, -85, -80, -84,
-80, -85, -79, -84, -79, -85, -79, -84, -78, -84, -79, -84, -78, -83, -78, -83,
-78, -83, -78, -83, -78, -83, -78, -84, -78, -83, -78, -84, -77, -82, -77, -83,
-77, -83, -78, -83, -78, -83, -78, -83, -77, -83, -78, -83, -77, -83, -77, -82,
-77, -79, -78, -73, -77, -68, -78, -63, -77, -58, -77, -54, -77, -49, -78, -45,
-78, -41, -77, -37, -77, -32, -78, -28, -77, -24, -78, -19, -77, -16, -77, -11,
-77, -7, -77, -3, -77, 0, -77, 5, -77, 8, -77, 12, -77, 15, -77, 19, -77, 22,
-76, 26, -77, 30, -78, 32, -78, 36, -77, 39, -77, 41, -77, 46, -77, 48, -77, 51,
-76, 55, -77, 58, -76, 60, -78, 62, -77, 65, -77, 69, -78, 69, -77, 69, -77, 68,
-77, 69, -76, 67, -76, 67, -77, 67, -77, 66, -77, 66, -77, 66, -77, 66, -77, 65,
-76, 64, -77, 64, -77, 64, -76, 63, -78, 64, -78, 63, -77, 64, -77, 63, -77, 63,
-78, 62, -77, 62, -78, 63, -77, 62, -77, 62, -78, 63, -78, 61, -77, 62, -77, 62,
-77, 62, -77, 61, -77, 62, -77, 62, -77, 61, -77, 61, -78, 62, -78, 61, -77, 60,
-77, 60, -78, 60, -77, 61, -76, 61, -77, 61, -77, 61, -77, 61, -77, 61, -77, 61,
-78, 61, -77, 60, -78, 61, -77, 61, -78, 61, -77, 60, -77, 61, -77, 61, -77, 61,
-78, 61, -77, 61, -78, 61, -78, 60, -77, 61, -77, 60, -77, 60, -77, 61, -77, 61,
-77, 60, -78, 61, -76, 61, -77, 61, -77, 61, -77, 61, -78, 60, -77, 61, -78, 60,
-78, 61, -77, 60, -78, 60, -78, 60, -78, 60, -78, 61, -77, 62, -77, 61, -77, 61,
-77, 61, -77, 60, -77, 61, -77, 60, -77, 60, -77, 61, -77, 61, -77, 61, -78, 60,
-77, 60, -77, 60, -77, 61, -77, 61, -78, 61, -77, 61, -78, 60, -78, 62, -77, 61,
-78, 61, -78, 61, -78, 62, -78, 60, -78, 60, -78, 61, -79, 61, -77, 59, -78, 55,
-78, 52, -77, 48, -76, 44, -70, 41, -66, 38, -60, 34, -56, 32, -52, 27, -46, 24,
-43, 20, -38, 17, -33, 13, -28, 10, -24, 4, -20, 2, -15, -3, -11, -6, -7, -11,
-2, -12, };