#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0038

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 63, 7, 75, 11, 71, 15, 77, 19, 75,
21, 80, 24, 78, 26, 82, 28, 80, 30, 83, 31, 84, 32, 87, 34, 86, 36, 90, 38, 89,
39, 90, 41, 91, 43, 92, 43, 92, 45, 92, 45, 91, 47, 92, 48, 91, 50, 89, 52, 88,
52, 88, 54, 86, 55, 85, 55, 84, 57, 81, 58, 79, 59, 78, 61, 76, 62, 72, 65, 69,
65, 63, 68, 59, 69, 54, 71, 50, 73, 46, 75, 43, 77, 39, 78, 35, 80, 31, 81, 28,
82, 25, 84, 19, 85, 15, 87, 11, 89, 6, 91, 0, 92, -4, 94, -10, 97, -16, 98, -22,
100, -26, 102, -33, 105, -37, 107, -43, 108, -47, 110, -53, 111, -58, 113, -62,
115, -65, 115, -68, 115, -71, 116, -74, 117, -76, 117, -78, 117, -80, 118, -82,
118, -84, 119, -87, 119, -89, 119, -89, 120, -91, 119, -91, 119, -90, 119, -90,
118, -88, 117, -85, 118, -84, 118, -84, 117, -83, 116, -83, 115, -83, 114, -81,
113, -81, 113, -81, 112, -81, 112, -80, 111, -79, 111, -78, 109, -76, 108, -74,
107, -70, 106, -67, 105, -63, 104, -58, 102, -55, 101, -50, 99, -46, 98, -41,
97, -37, 95, -33, 94, -29, 93, -25, 93, -19, 91, -15, 91, -12, 90, -7, 89, -4,
89, -1, 88, 3, 86, 8, 86, 11, 86, 16, 85, 21, 84, 26, 82, 29, 82, 32, 82, 34,
81, 37, 81, 39, 81, 42, 80, 45, 79, 49, 79, 52, 79, 56, 80, 60, 80, 64, 80, 70,
81, 75, 80, 79, 80, 86, 79, 90, 79, 96, 79, 100, 79, 104, 79, 107, 80, 108, 79,
111, 80, 112, 80, 113, 79, 113, 81, 115, 81, 115, 82, 115, 82, 116, 83, 115, 81,
114, 82, 116, 82, 114, 81, 115, 81, 115, 81, 114, 82, 113, 81, 112, 81, 112, 81,
110, 80, 107, 79, 105, 79, 102, 77, 100, 77, 97, 76, 96, 75, 95, 75, 93, 72, 91,
72, 88, 71, 87, 68, 85, 67, 83, 65, 80, 64, 77, 63, 74, 62, 71, 60, 67, 60, 63,
58, 58, 57, 54, 56, 51, 56, 47, 54, 44, 52, 42, 51, 41, 49, 38, 48, 36, 46, 34,
45, 32, 42, 30, 40, 30, 39, 28, 38, 26, 36, 24, 35, 21, 33, 19, 32, 17, 29, 15,
28, 13, 26, 10, 24, 8, 23, 7, 23, 6, 20, 5, 19, 5, 18, 4, 17, 3, 16, 1, 14, 1,
13, 1, 12, -1, 11, -1, 10, -3, 8, -4, 7, -6, 6, -9, 6, -10, 5, -12, 3, -14, 2,
-16, 2, -17, 0, -19, 0, -21, -2, -22, -2, -24, -3, -25, -4, -28, -5, -30, -6,
-33, -7, -35, -7, -36, -9, -38, -9, -41, -9, -44, -9, -46, -10, -47, -12, -49,
-12, -51, -12, -53, -13, -54, -14, -56, -14, -57, -15, -59, -16, -61, -17, -65,
-16, -68, -18, -70, -20, -74, -20, -78, -21, -81, -23, -84, -23, -87, -25, -89,
-26, -93, -26, -96, -29, -98, -30, -102, -30, -103, -33, -107, -35, -110, -35,
-112, -37, -113, -38, -115, -40, -116, -41, -118, -42, -118, -43, -119, -44,
-118, -46, -119, -46, -118, -47, -119, -48, -118, -48, -116, -49, -117, -51,
-118, -51, -117, -52, -116, -53, -116, -54, -116, -54, -117, -55, -117, -56,
-118, -57, -117, -57, -117, -57, -118, -59, -117, -59, -115, -59, -115, -59,
-111, -59, -109, -59, -107, -59, -104, -59, -102, -58, -98, -58, -96, -57, -92,
-56, -89, -54, -85, -53, -82, -51, -78, -49, -74, -48, -70, -47, -66, -45, -62,
-44, -58, -43, -53, -44, -49, -43, -44, -43, -41, -43, -38, -42, -35, -42, -32,
-42, -29, -44, -26, -43, -23, -43, -20, -44, -16, -43, -14, -44, -10, -44, -8,
-44, -3, -46, 1, -46, 6, -47, 10, -48, 15, -48, 20, -49, 24, -50, 29, -51, 33,
-51, 37, -52, 41, -53, 44, -55, 47, -55, 49, -58, 52, -57, 55, -59, 57, -60, 60,
-63, 60, -64, 62, -66, 63, -68, 64, -69, 65, -72, 65, -74, 65, -76, 66, -78, 67,
-80, 67, -82, 67, -82, 66, -84, 66, -85, 65, -85, 64, -87, 62, -86, 61, -86, 60,
-88, 58, -88, 56, -88, 53, -88, 52, -88, 48, -89, 46, -90, 44, -89, 41, -88, 37,
-87, 33, -88, 30, -87, 25, -86, 22, -86, 19, -84, 15, -83, 11, -82, 8, -81, 4,
-78, 0, -79, -3, -77, -7, -75, -10, -74, -14, -73, -16, -72, -19, -71, -22, -69,
-23, -67, -25, -67, -27, -66, -29, -64, -31, -62, -32, -60, -33, -59, -35, -57,
-37, -55, -39, -53, -42, -51, -42, -50, -44, -48, -44, -47, -44, -46, -45, -45,
-44, -43, -44, -42, -42, -41, -43, -40, -42, -39, -41, -38, -40, -37, -38, -36,
-37, -36, -36, -36, -35, -36, -34, -35, -34, -34, -33, -35, -33, -36, -33, -35,
-32, -36, -31, -36, -31, -37, -29, -37, -28, -37, -27, -38, -26, -38, -25, -37,
-24, -38, -23, -38, -23, -40, -22, -39, -21, -39, -20, -38, -19, -40, -18, -41,
-17, -43, -18, -43, -17, -45, -17, -47, -16, -48, -15, -50, -15, -51, -16, -52,
-15, -54, -16, -56, -16, -58, -17, -59, -18, -61, -18, -63, -19, -65, -18, -66,
-19, -69, -19, -71, -19, -74, -18, -75, -18, -77, -18, -79, -16, -81, -16, -83,
-13, -84, -12, -87, -10, -88, -10, -89, -8, -91, -8, -92, -8, -94, -7, -95, -5,
-96, -3, -97, -2, -99, -2, -100, 0, -101, 2, -102, 3, -104, 5, -105, 5, -107, 7,
-107, 7, -107, 9, -106, 10, -106, 11, -105, 12, -103, 14, -102, 17, -100, 17,
-99, 18, -97, 20, -94, 23, -93, 24, -91, 27, -88, 30, -85, 31, -82, 34, -78, 37,
-76, 39, -73, 40, -69, 42, -64, 44, -61, 46, -58, 47, -53, 48, -49, 48, -45, 50,
-42, 50, -38, 53, -34, 54, -30, 58, -26, 58, -24, 63, -21, 63, -17, 67, -14, 64,
-10, 71, -7, 66, -3, 75, 0, 61, };