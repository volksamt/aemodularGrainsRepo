#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0151

const PROGMEM int8_t DATA[DATA_LENGTH] = {97, 104, 115, 123, 106, 113, 112, 120,
106, 113, 111, 118, 105, 112, 109, 115, 105, 112, 108, 114, 103, 111, 107, 112,
102, 108, 105, 110, 103, 109, 103, 108, 101, 107, 102, 108, 101, 105, 100, 105,
100, 104, 99, 104, 99, 103, 97, 103, 98, 101, 96, 101, 96, 100, 95, 99, 95, 99,
94, 98, 94, 98, 93, 97, 93, 96, 92, 94, 92, 94, 91, 93, 90, 93, 90, 92, 90, 91,
89, 91, 88, 90, 87, 88, 88, 89, 87, 88, 86, 87, 86, 86, 85, 85, 85, 85, 84, 84,
83, 83, 83, 83, 82, 81, 82, 81, 80, 80, 80, 80, 80, 79, 79, 78, 79, 78, 79, 76,
77, 77, 77, 75, 76, 74, 76, 74, 75, 73, 75, 73, 74, 71, 74, 71, 73, 70, 72, 69,
72, 68, 71, 68, 71, 67, 70, 66, 70, 65, 69, 65, 68, 65, 69, 63, 67, 64, 67, 62,
67, 62, 66, 61, 65, 60, 64, 59, 64, 58, 64, 57, 63, 57, 63, 57, 61, 56, 62, 54,
61, 54, 60, 54, 59, 52, 59, 53, 58, 51, 58, 50, 57, 49, 57, 48, 57, 48, 55, 47,
55, 47, 55, 46, 54, 46, 53, 45, 53, 44, 52, 43, 52, 42, 51, 42, 50, 41, 50, 40,
50, 40, 49, 39, 49, 38, 47, 37, 47, 36, 46, 36, 46, 35, 45, 34, 45, 33, 44, 33,
44, 32, 43, 31, 43, 30, 42, 30, 42, 29, 40, 28, 40, 28, 40, 27, 39, 26, 39, 25,
38, 25, 37, 24, 37, 23, 36, 22, 36, 22, 35, 21, 35, 21, 34, 20, 34, 19, 33, 20,
33, 20, 33, 19, 33, 19, 32, 19, 33, 18, 32, 18, 32, 18, 31, 17, 31, 18, 31, 18,
31, 17, 29, 16, 29, 17, 28, 17, 28, 17, 28, 16, 28, 17, 27, 15, 27, 16, 28, 16,
27, 15, 26, 14, 26, 15, 25, 15, 26, 14, 25, 14, 25, 15, 24, 14, 24, 14, 23, 13,
23, 14, 23, 14, 22, 14, 23, 13, 22, 13, 21, 13, 21, 12, 21, 12, 20, 11, 20, 12,
20, 12, 19, 11, 19, 11, 19, 11, 19, 11, 18, 10, 18, 11, 17, 10, 17, 10, 17, 10,
16, 10, 16, 10, 16, 10, 16, 9, 14, 9, 14, 9, 14, 8, 13, 8, 14, 8, 14, 8, 13, 7,
12, 8, 12, 7, 12, 7, 12, 7, 12, 7, 12, 7, 10, 6, 11, 7, 11, 6, 10, 6, 9, 5, 9,
5, 8, 6, 9, 4, 8, 4, 8, 4, 8, 5, 6, 4, 8, 3, 6, 4, 6, 3, 6, 4, 6, 3, 5, 3, 5, 3,
4, 2, 5, 3, 4, 2, 3, 2, 3, 1, 3, 1, 2, 1, 2, 1, 1, 1, 1, 1, 1, 0, 1, 1, 0, 1, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, -1, 0, -1, 0, 0, -1, -1, 0, -2, -1, -2,
-1, -2, -1, -2, -1, -3, -2, -3, -2, -3, -2, -4, -2, -3, -2, -4, -2, -4, -2, -5,
-3, -5, -3, -6, -3, -6, -3, -6, -4, -7, -3, -7, -4, -7, -4, -7, -4, -8, -5, -9,
-5, -9, -5, -9, -6, -9, -5, -10, -5, -10, -6, -11, -6, -11, -7, -11, -6, -12,
-7, -11, -7, -13, -7, -12, -7, -12, -8, -13, -7, -14, -8, -13, -8, -14, -9, -15,
-9, -16, -8, -15, -9, -15, -9, -15, -9, -16, -10, -16, -10, -17, -10, -17, -10,
-18, -11, -17, -10, -19, -11, -18, -11, -19, -11, -18, -10, -19, -11, -20, -11,
-20, -12, -21, -11, -21, -12, -21, -12, -21, -13, -21, -12, -22, -13, -23, -13,
-23, -13, -23, -14, -24, -13, -24, -14, -25, -14, -24, -14, -25, -14, -25, -14,
-25, -15, -25, -16, -26, -15, -27, -16, -27, -15, -27, -17, -27, -16, -28, -16,
-28, -16, -28, -17, -29, -17, -30, -17, -30, -17, -29, -17, -30, -17, -31, -18,
-31, -18, -32, -18, -31, -19, -32, -19, -31, -19, -32, -19, -33, -20, -33, -19,
-34, -20, -34, -20, -34, -19, -35, -20, -35, -21, -35, -22, -36, -22, -37, -23,
-37, -24, -38, -25, -38, -25, -40, -26, -39, -27, -40, -27, -41, -28, -42, -29,
-42, -29, -42, -30, -43, -31, -44, -32, -44, -33, -44, -33, -45, -35, -46, -34,
-46, -36, -47, -37, -48, -37, -47, -38, -49, -38, -49, -39, -49, -40, -50, -41,
-51, -41, -51, -42, -53, -42, -53, -44, -53, -45, -54, -45, -54, -46, -54, -47,
-55, -47, -56, -48, -56, -49, -58, -50, -58, -51, -58, -50, -59, -52, -58, -53,
-60, -53, -61, -55, -62, -54, -62, -56, -63, -56, -63, -57, -63, -57, -64, -58,
-65, -59, -65, -60, -66, -60, -66, -61, -67, -62, -68, -63, -68, -63, -69, -64,
-69, -65, -69, -66, -70, -66, -70, -67, -71, -68, -72, -69, -72, -69, -73, -70,
-74, -71, -75, -72, -75, -72, -75, -73, -75, -74, -77, -75, -77, -76, -77, -76,
-78, -76, -79, -77, -79, -78, -79, -79, -81, -79, -81, -80, -81, -81, -82, -82,
-82, -83, -84, -82, -84, -83, -85, -84, -84, -85, -85, -86, -86, -87, -87, -88,
-87, -88, -87, -90, -89, -90, -89, -90, -89, -91, -89, -92, -90, -93, -91, -93,
-91, -94, -92, -95, -93, -96, -93, -97, -94, -97, -94, -97, -95, -98, -96, -99,
-97, -99, -97, -101, -98, -101, -98, -102, -98, -103, -99, -104, -99, -103,
-101, -105, -100, -105, -101, -107, -101, -106, -104, -109, -102, -107, -104,
-111, -103, -109, -105, -113, -105, -111, -106, -114, -105, -113, -108, -115,
-107, -114, -110, -116, -107, -116, -108, -117, -110, -118, -108, -116, -115,
-125, -17, -18, 7, 8, };