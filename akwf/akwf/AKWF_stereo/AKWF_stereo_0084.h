#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0084

const PROGMEM int8_t DATA[DATA_LENGTH] = {31, 23, 49, 35, 55, 39, 62, 46, 64,
49, 68, 56, 70, 60, 73, 66, 75, 71, 78, 76, 79, 79, 81, 83, 82, 86, 84, 89, 84,
91, 87, 91, 87, 92, 89, 94, 89, 96, 91, 98, 92, 99, 92, 101, 94, 103, 95, 105,
95, 108, 96, 109, 97, 111, 98, 110, 98, 112, 99, 112, 99, 111, 100, 111, 101,
113, 101, 112, 102, 113, 104, 114, 103, 115, 104, 116, 105, 116, 106, 116, 106,
117, 107, 117, 108, 117, 108, 117, 108, 117, 110, 117, 110, 117, 109, 116, 110,
116, 111, 116, 111, 116, 111, 116, 111, 116, 113, 116, 113, 115, 112, 116, 113,
115, 113, 114, 112, 114, 114, 114, 113, 112, 114, 112, 114, 111, 114, 111, 113,
110, 113, 110, 113, 109, 112, 108, 112, 108, 112, 107, 111, 107, 112, 106, 111,
105, 110, 103, 109, 103, 109, 103, 109, 101, 107, 101, 106, 99, 105, 98, 104,
98, 104, 97, 103, 96, 102, 95, 101, 95, 100, 93, 99, 92, 100, 91, 98, 90, 98,
89, 95, 88, 95, 86, 94, 85, 91, 84, 91, 83, 89, 82, 87, 81, 86, 79, 85, 79, 82,
78, 82, 77, 81, 75, 79, 74, 77, 73, 75, 71, 74, 70, 72, 69, 72, 68, 69, 67, 69,
65, 66, 64, 65, 62, 64, 62, 63, 60, 60, 60, 59, 57, 57, 57, 56, 56, 54, 54, 53,
54, 52, 51, 50, 50, 49, 48, 48, 48, 46, 47, 45, 45, 43, 45, 42, 42, 41, 41, 40,
40, 38, 39, 37, 37, 36, 37, 33, 34, 33, 34, 32, 33, 30, 31, 29, 30, 28, 28, 27,
27, 25, 25, 25, 24, 23, 23, 21, 22, 21, 21, 20, 20, 19, 17, 17, 16, 16, 16, 14,
15, 14, 12, 13, 12, 12, 11, 10, 9, 10, 7, 9, 6, 7, 5, 6, 3, 5, 3, 4, 1, 4, 0, 2,
-1, 0, -3, -1, -4, -1, -5, -3, -6, -5, -9, -5, -8, -6, -10, -7, -11, -8, -12,
-10, -14, -11, -15, -12, -16, -14, -17, -14, -18, -16, -20, -17, -21, -17, -23,
-19, -24, -20, -25, -22, -26, -23, -27, -23, -28, -25, -29, -26, -30, -27, -32,
-29, -32, -31, -33, -31, -36, -33, -36, -34, -38, -35, -39, -35, -39, -37, -41,
-39, -41, -40, -43, -40, -44, -43, -45, -40, -46, -33, -48, -34, -50, -34, -51,
-37, -51, -38, -53, -41, -54, -42, -55, -45, -55, -47, -56, -49, -58, -51, -58,
-53, -60, -55, -60, -57, -61, -59, -62, -60, -63, -62, -64, -63, -65, -65, -66,
-66, -67, -68, -68, -69, -68, -69, -69, -72, -70, -72, -71, -73, -72, -75, -73,
-76, -74, -77, -75, -78, -75, -79, -76, -80, -77, -81, -78, -81, -79, -82, -79,
-83, -80, -84, -81, -85, -82, -86, -83, -87, -84, -88, -85, -88, -85, -90, -86,
-89, -86, -91, -87, -91, -88, -92, -89, -92, -89, -93, -90, -94, -91, -94, -91,
-95, -92, -96, -93, -97, -93, -96, -93, -98, -95, -98, -95, -98, -96, -99, -96,
-101, -97, -101, -97, -101, -98, -101, -98, -102, -99, -102, -99, -103, -101,
-104, -101, -103, -101, -105, -102, -105, -102, -106, -103, -104, -102, -103,
-101, -104, -103, -105, -102, -107, -105, -107, -105, -108, -107, -109, -108,
-110, -109, -110, -109, -111, -110, -111, -110, -111, -111, -112, -110, -113,
-111, -112, -111, -112, -111, -112, -110, -112, -111, -112, -111, -113, -111,
-113, -112, -114, -112, -114, -113, -113, -113, -114, -113, -114, -114, -115,
-113, -115, -114, -116, -115, -116, -115, -116, -115, -117, -115, -117, -115,
-117, -115, -118, -115, -117, -116, -118, -115, -118, -116, -118, -116, -118,
-116, -118, -116, -118, -117, -118, -116, -118, -117, -119, -117, -118, -116,
-118, -116, -119, -116, -120, -117, -120, -117, -119, -117, -119, -117, -119,
-117, -119, -117, -120, -117, -120, -116, -118, -117, -119, -117, -119, -116,
-119, -117, -119, -117, -119, -116, -119, -117, -119, -117, -118, -116, -119,
-116, -118, -116, -118, -115, -118, -116, -117, -116, -117, -116, -117, -116,
-117, -115, -117, -115, -117, -114, -117, -115, -117, -114, -116, -114, -116,
-114, -115, -114, -115, -114, -115, -113, -114, -113, -114, -112, -114, -112,
-115, -113, -114, -112, -114, -111, -114, -111, -113, -111, -113, -111, -112,
-110, -112, -110, -112, -110, -110, -110, -110, -109, -111, -109, -110, -109,
-110, -107, -109, -107, -109, -107, -108, -108, -108, -107, -108, -106, -108,
-106, -107, -106, -106, -104, -106, -104, -106, -104, -106, -104, -105, -102,
-104, -103, -103, -102, -103, -101, -102, -101, -102, -101, -101, -99, -100,
-99, -100, -99, -99, -99, -99, -98, -99, -96, -99, -97, -98, -96, -98, -95, -96,
-95, -97, -94, -93, -94, -91, -93, -90, -93, -90, -92, -89, -92, -89, -92, -89,
-90, -88, -90, -88, -90, -87, -89, -87, -88, -87, -87, -87, -86, -86, -85, -85,
-85, -85, -85, -85, -83, -84, -83, -85, -83, -83, -81, -83, -81, -82, -80, -81,
-80, -82, -79, -80, -79, -80, -78, -79, -77, -79, -76, -78, -75, -77, -75, -76,
-73, -76, -73, -75, -71, -74, -71, -74, -71, -73, -69, -72, -69, -72, -69, -70,
-68, -70, -66, -69, -65, -68, -64, -66, -65, -66, -63, -65, -63, -65, -62, -64,
-61, -63, -61, -63, -60, -62, -58, -61, -57, -59, -56, -60, -56, -58, -55, -57,
-54, -57, -53, -55, -53, -55, -52, -54, -51, -53, -50, -52, -49, -51, -49, -50,
-47, -49, -46, -48, -46, -47, -44, -46, -44, -46, -43, -44, -42, -44, -41, -43,
-40, -41, -39, -41, -39, -40, -38, -40, -36, -38, -35, -37, -35, -36, -34, -35,
-33, -35, -32, -34, -31, -32, -30, -31, -30, -30, -28, -30, -27, -29, -27, -27,
-25, -27, -24, -26, -24, -25, -22, -24, -22, -23, -21, -22, -20, -20, -19, -19,
-18, -19, -17, -18, -15, -17, -15, -16, -14, -16, -13, -15, -13, -13, -11, -12,
-10, -12, -9, -10, -8, -9, -8, -8, -6, -7, -5, -6, -5, -6, -4, -5, -3, -4, -2,
-2, 0, };