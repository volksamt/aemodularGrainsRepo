#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0069

const PROGMEM int8_t DATA[DATA_LENGTH] = {83, 80, 117, 113, 87, 79, 82, 75, 65,
61, 61, 65, 48, 64, 47, 74, 38, 77, 38, 86, 33, 87, 34, 89, 32, 86, 31, 83, 31,
79, 30, 75, 29, 72, 28, 71, 28, 71, 27, 73, 26, 76, 25, 79, 26, 82, 24, 83, 24,
85, 24, 83, 25, 81, 23, 77, 25, 75, 24, 72, 26, 69, 25, 67, 27, 67, 27, 68, 28,
71, 29, 71, 31, 74, 32, 74, 33, 76, 34, 78, 35, 76, 36, 75, 38, 74, 39, 73, 40,
71, 41, 70, 42, 71, 44, 71, 44, 70, 45, 72, 47, 72, 48, 73, 49, 73, 50, 74, 51,
74, 52, 73, 53, 72, 53, 71, 54, 71, 54, 71, 55, 70, 56, 70, 55, 71, 56, 70, 57,
70, 57, 70, 57, 71, 58, 70, 58, 70, 58, 70, 58, 69, 58, 69, 58, 68, 57, 68, 58,
67, 56, 66, 56, 66, 55, 66, 55, 65, 54, 65, 54, 65, 53, 63, 53, 63, 52, 63, 50,
63, 50, 62, 50, 62, 49, 60, 47, 60, 46, 59, 45, 58, 44, 59, 43, 57, 42, 57, 41,
56, 41, 56, 40, 55, 39, 54, 38, 53, 37, 54, 35, 52, 34, 53, 34, 52, 32, 51, 32,
51, 30, 49, 30, 49, 30, 48, 28, 48, 28, 48, 27, 47, 27, 47, 26, 46, 25, 46, 25,
45, 24, 45, 23, 44, 23, 43, 22, 44, 22, 44, 22, 43, 22, 42, 20, 42, 22, 42, 20,
40, 21, 40, 20, 40, 23, 41, 39, 40, 39, 39, 34, 39, 32, 39, 29, 39, 26, 38, 26,
38, 24, 37, 23, 37, 23, 38, 21, 37, 20, 36, 21, 36, 20, 36, 19, 35, 19, 36, 20,
35, 19, 35, 20, 35, 19, 35, 20, 35, 20, 35, 21, 33, 21, 33, 20, 33, 21, 34, 22,
33, 21, 33, 22, 33, 22, 32, 22, 31, 22, 31, 22, 31, 22, 31, 22, 31, 22, 29, 22,
30, 21, 30, 22, 29, 22, 28, 22, 28, 22, 28, 22, 28, 21, 28, 21, 27, 22, 27, 21,
26, 20, 25, 21, 25, 20, 26, 20, 26, 19, 25, 19, 24, 19, 24, 18, 23, 18, 23, 17,
22, 18, 22, 18, 21, 17, 22, 16, 21, 16, 20, 16, 20, 15, 20, 15, 19, 14, 19, 14,
18, 14, 18, 13, 17, 12, 17, 12, 17, 11, 17, 11, 17, 10, 15, 10, 15, 10, 15, 10,
14, 9, 14, 9, 14, 9, 13, 8, 12, 7, 12, 8, 12, 7, 12, 6, 11, 6, 11, 6, 10, 5, 11,
5, 10, 4, 9, 4, 9, 4, 8, 4, 9, 4, 8, 3, 8, 3, 7, 2, 7, 3, 7, 2, 6, 3, 6, 3, 5,
2, 5, 2, 4, 2, 5, 1, 5, 1, 5, 1, 4, 1, 4, 1, 2, 1, 3, 1, 3, 1, 2, 1, 2, 1, 2, 1,
2, -1, 1, 0, 0, 0, 0, 1, -1, 0, -1, 0, 0, -1, -1, 0, -1, 0, -2, 0, -2, 0, -3,
-1, -3, 0, -4, -1, -2, -1, -3, -1, -3, -2, -4, -2, -4, -2, -5, -2, -5, -2, -5,
-2, -5, -3, -7, -2, -6, -3, -7, -2, -7, -3, -7, -4, -8, 7, 16, 11, 24, 3, 9, 0,
0, -4, -10, -7, -16, -10, -22, -11, -25, -12, -26, -10, -25, -10, -24, -10, -22,
-9, -19, -8, -17, -7, -15, -7, -13, -6, -12, -6, -11, -6, -10, -6, -11, -7, -11,
-8, -12, -8, -12, -9, -14, -8, -15, -9, -15, -9, -17, -10, -17, -10, -19, -11,
-18, -11, -18, -11, -19, -11, -19, -12, -19, -11, -19, -13, -19, -13, -20, -13,
-20, -13, -20, -13, -21, -13, -21, -14, -21, -13, -22, -14, -22, -14, -23, -16,
-23, -14, -23, -17, -23, -8, -24, 25, -24, 21, -24, 12, -25, 7, -25, 0, -25, -4,
-26, -8, -26, -10, -26, -13, -26, -15, -27, -18, -27, -18, -27, -20, -28, -21,
-28, -21, -29, -22, -29, -22, -28, -22, -29, -24, -29, -24, -30, -23, -30, -23,
-31, -23, -31, -25, -31, -24, -31, -25, -32, -24, -31, -25, -32, -24, -32, -24,
-33, -24, -32, -24, -34, -24, -34, -25, -33, -25, -34, -25, -34, -26, -35, -26,
-35, -25, -35, -26, -35, -25, -35, -26, -36, -26, -36, -25, -37, -26, -36, -25,
-38, -25, -37, -27, -38, -26, -38, -27, -39, -26, -39, -26, -38, -26, -40, -27,
-40, -27, -40, -27, -40, -27, -41, -28, -41, -27, -41, -27, -41, -28, -42, -28,
-42, -28, -42, -28, -43, -29, -43, -28, -42, -29, -43, -29, -45, -30, -44, -30,
-45, -30, -45, -30, -45, -30, -45, -30, -45, -31, -45, -30, -46, -30, -46, -31,
-46, -31, -48, -31, -48, -32, -48, -32, -47, -32, -49, -33, -48, -32, -49, -33,
-50, -32, -49, -33, -50, -32, -51, -33, -50, -34, -51, -34, -51, -34, -51, -34,
-52, -34, -52, -33, -51, -34, -53, -35, -52, -35, -53, -34, -53, -35, -54, -35,
-53, -36, -54, -36, -54, -35, -54, -36, -56, -35, -55, -37, -55, -36, -56, -36,
-56, -37, -56, -37, -57, -36, -57, -37, -57, -38, -57, -37, -58, -38, -58, -38,
-59, -38, -58, -38, -59, -39, -60, -38, -59, -39, -60, -40, -60, -39, -60, -40,
-60, -39, -60, -39, -62, -35, -61, -34, -61, -36, -62, -37, -62, -38, -62, -39,
-62, -39, -63, -40, -64, -41, -64, -41, -63, -42, -64, -41, -64, -42, -64, -43,
-65, -43, -65, -42, -65, -43, -65, -44, -66, -43, -66, -43, -66, -44, -66, -44,
-67, -44, -67, -44, -67, -44, -69, -45, -68, -46, -69, -45, -69, -45, -69, -45,
-69, -46, -69, -46, -70, -46, -71, -46, -70, -46, -71, -46, -71, -46, -70, -47,
-71, -47, -71, -48, -72, -46, -71, -47, -72, -47, -72, -48, -73, -47, -72, -48,
-74, -47, -73, -48, -74, -48, -74, -48, -74, -48, -74, -49, -75, -49, -75, -49,
-75, -50, -76, -50, -76, -50, -76, -49, -76, -50, -78, -49, -76, -52, -80, -47,
-74, -55, -85, -22, -41, };