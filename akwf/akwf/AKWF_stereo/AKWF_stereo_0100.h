#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0100

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 103, 3, 125, 4, 114, 6, 120, 8,
114, 8, 118, 10, 113, 11, 117, 13, 114, 14, 118, 16, 112, 18, 114, 20, 115, 20,
115, 21, 111, 22, 113, 21, 112, 21, 111, 21, 109, 22, 106, 24, 102, 25, 102, 27,
98, 27, 95, 29, 94, 29, 94, 31, 93, 32, 91, 33, 89, 36, 89, 38, 86, 38, 82, 38,
83, 39, 83, 39, 84, 39, 80, 38, 78, 38, 78, 39, 76, 37, 74, 38, 73, 39, 71, 38,
67, 36, 66, 35, 65, 36, 63, 35, 61, 34, 57, 34, 56, 34, 56, 32, 54, 33, 52, 32,
50, 33, 47, 31, 44, 31, 44, 32, 43, 30, 39, 31, 36, 31, 34, 32, 30, 32, 28, 33,
28, 33, 26, 33, 23, 35, 21, 36, 20, 36, 21, 37, 23, 38, 22, 37, 21, 38, 22, 40,
21, 40, 22, 40, 21, 41, 22, 43, 21, 43, 23, 47, 22, 49, 21, 50, 22, 51, 22, 51,
21, 52, 20, 52, 17, 52, 16, 54, 16, 54, 13, 54, 9, 54, 7, 57, 6, 57, 4, 59, 2,
61, 0, 62, -1, 64, -3, 63, -5, 63, -4, 64, -5, 65, -6, 65, -7, 64, -6, 65, -8,
65, -8, 66, -10, 68, -11, 70, -11, 72, -13, 73, -13, 76, -12, 78, -14, 80, -14,
82, -16, 81, -19, 83, -21, 85, -22, 85, -25, 85, -28, 86, -31, 86, -33, 87, -35,
87, -38, 89, -42, 89, -43, 89, -46, 90, -49, 90, -52, 92, -57, 93, -59, 95, -62,
96, -63, 99, -65, 100, -66, 100, -66, 101, -68, 102, -71, 102, -71, 102, -71,
102, -74, 103, -76, 102, -75, 103, -79, 104, -81, 104, -82, 104, -83, 105, -83,
103, -84, 103, -86, 103, -86, 102, -89, 103, -90, 102, -91, 101, -95, 102, -98,
102, -99, 101, -101, 102, -100, 103, -102, 100, -105, 100, -105, 99, -104, 98,
-105, 96, -106, 95, -107, 93, -106, 92, -104, 91, -104, 90, -105, 92, -106, 91,
-105, 90, -103, 90, -105, 89, -103, 90, -103, 89, -105, 89, -105, 91, -104, 92,
-103, 90, -99, 89, -101, 90, -100, 92, -99, 91, -101, 91, -101, 89, -100, 87,
-101, 87, -100, 87, -99, 87, -100, 85, -100, 85, -100, 84, -100, 83, -100, 80,
-98, 80, -98, 80, -97, 79, -97, 77, -98, 73, -95, 75, -92, 74, -93, 73, -92, 73,
-93, 71, -92, 72, -91, 72, -91, 73, -91, 73, -90, 73, -89, 72, -88, 71, -86, 71,
-85, 69, -89, 69, -85, 68, -86, 68, -87, 67, -89, 67, -90, 66, -91, 67, -91, 68,
-92, 66, -94, 66, -95, 66, -93, 65, -95, 65, -94, 65, -93, 63, -95, 63, -95, 63,
-96, 63, -94, 61, -95, 60, -96, 61, -98, 61, -98, 61, -99, 60, -100, 60, -101,
62, -101, 62, -101, 63, -104, 64, -102, 63, -102, 63, -103, 64, -103, 62, -101,
61, -103, 62, -105, 61, -105, 61, -106, 60, -106, 59, -106, 60, -106, 59, -108,
59, -109, 59, -108, 57, -107, 54, -106, 53, -109, 52, -110, 51, -111, 49, -111,
47, -110, 45, -108, 44, -104, 40, -102, 38, -100, 36, -98, 34, -96, 32, -93, 30,
-91, 28, -90, 25, -90, 21, -89, 19, -89, 16, -88, 14, -88, 10, -87, 8, -86, 6,
-88, 3, -86, 2, -84, 0, -84, -2, -82, -3, -82, -4, -82, -9, -82, -10, -80, -11,
-77, -13, -76, -16, -77, -22, -79, -25, -79, -26, -78, -30, -79, -32, -78, -35,
-76, -38, -73, -41, -73, -41, -71, -44, -66, -47, -65, -47, -63, -50, -62, -52,
-60, -53, -57, -55, -54, -55, -51, -57, -48, -58, -45, -60, -45, -59, -43, -60,
-41, -60, -41, -60, -42, -61, -43, -62, -42, -63, -43, -65, -42, -65, -41, -64,
-41, -67, -41, -69, -40, -71, -39, -72, -38, -74, -37, -77, -34, -77, -33, -77,
-33, -79, -29, -81, -26, -82, -24, -82, -24, -81, -22, -82, -20, -82, -18, -83,
-18, -82, -16, -83, -15, -82, -13, -85, -13, -84, -12, -85, -11, -86, -12, -85,
-11, -85, -10, -87, -9, -88, -9, -87, -10, -87, -9, -87, -8, -89, -9, -91, -9,
-91, -9, -94, -7, -96, -3, -98, -2, -100, -2, -100, -2, -102, 1, -103, 3, -102,
5, -102, 7, -103, 9, -102, 11, -102, 14, -103, 16, -103, 17, -103, 21, -103, 25,
-103, 27, -104, 30, -105, 31, -107, 36, -106, 39, -108, 43, -111, 45, -111, 47,
-110, 48, -111, 48, -112, 50, -114, 51, -114, 50, -114, 51, -115, 53, -116, 55,
-117, 58, -118, 57, -119, 60, -117, 62, -116, 63, -116, 65, -119, 66, -118, 68,
-117, 70, -116, 74, -117, 76, -117, 75, -117, 77, -118, 78, -117, 80, -117, 83,
-117, 84, -117, 84, -117, 86, -116, 89, -115, 91, -114, 93, -113, 94, -113, 95,
-110, 96, -110, 97, -107, 97, -106, 98, -107, 98, -105, 98, -106, 100, -106,
100, -105, 103, -105, 105, -106, 103, -106, 105, -105, 104, -106, 99, -105, 97,
-102, 96, -100, 93, -99, 93, -98, 91, -97, 87, -95, 87, -93, 87, -92, 88, -91,
89, -90, 87, -89, 86, -88, 87, -87, 88, -86, 88, -84, 87, -83, 88, -81, 88, -80,
89, -78, 90, -76, 92, -75, 91, -74, 91, -75, 92, -73, 94, -72, 94, -73, 92, -72,
92, -73, 92, -74, 90, -72, 89, -72, 86, -72, 86, -71, 88, -71, 87, -69, 85, -70,
88, -70, 87, -70, 86, -70, 85, -70, 87, -70, 87, -70, 89, -69, 89, -67, 89, -64,
91, -64, 89, -64, 91, -62, 93, -61, 92, -59, 92, -58, 93, -56, 92, -55, 95, -53,
99, -51, 101, -50, 103, -49, 105, -46, 109, -44, 112, -43, 112, -42, 113, -41,
116, -40, 115, -40, 115, -37, 114, -36, 114, -34, 114, -33, 111, -32, 110, -30,
110, -28, 108, -25, 106, -23, 106, -21, 109, -19, 107, -16, 110, -14, 110, -14,
114, -14, 112, -11, 117, -11, 113, -11, 118, -10, 113, -8, 122, -4, 113, -1,
125, -1, 100, };