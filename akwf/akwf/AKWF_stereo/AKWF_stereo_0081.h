#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0081

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 4, 10, 6, 13, 10, 18, 13, 21,
16, 25, 19, 28, 22, 32, 25, 35, 28, 39, 31, 42, 33, 46, 37, 50, 40, 53, 42, 56,
45, 59, 48, 62, 51, 65, 53, 68, 55, 71, 58, 74, 61, 76, 62, 79, 65, 82, 67, 84,
69, 86, 72, 87, 73, 90, 74, 92, 76, 94, 79, 96, 79, 97, 81, 99, 83, 100, 84,
102, 85, 103, 86, 104, 87, 105, 88, 106, 89, 107, 89, 107, 90, 106, 90, 107, 91,
107, 91, 107, 91, 107, 92, 107, 93, 107, 94, 107, 93, 108, 95, 107, 95, 108, 96,
108, 96, 108, 97, 107, 97, 107, 98, 108, 98, 108, 99, 107, 99, 108, 99, 107,
100, 107, 100, 108, 101, 108, 101, 108, 101, 107, 102, 107, 101, 107, 102, 107,
103, 107, 102, 107, 103, 106, 103, 107, 103, 106, 103, 107, 103, 106, 104, 107,
102, 106, 103, 106, 102, 106, 102, 107, 102, 106, 102, 106, 101, 105, 101, 105,
101, 105, 100, 105, 101, 106, 101, 105, 100, 104, 100, 104, 100, 104, 99, 105,
99, 104, 98, 104, 99, 103, 98, 103, 97, 103, 97, 103, 97, 102, 96, 103, 95, 102,
95, 101, 94, 102, 94, 101, 93, 100, 93, 101, 93, 100, 92, 100, 92, 100, 92, 100,
91, 99, 90, 99, 91, 99, 89, 99, 89, 98, 88, 99, 88, 98, 88, 98, 88, 97, 87, 97,
87, 97, 86, 96, 86, 96, 86, 95, 86, 95, 85, 94, 85, 95, 84, 94, 85, 93, 83, 93,
83, 93, 83, 93, 83, 92, 83, 92, 82, 91, 81, 91, 82, 91, 82, 90, 81, 90, 81, 89,
80, 88, 81, 89, 81, 88, 80, 88, 79, 87, 79, 86, 79, 86, 80, 86, 80, 85, 79, 84,
78, 84, 78, 83, 78, 83, 78, 82, 78, 82, 77, 81, 78, 82, 77, 80, 77, 80, 77, 79,
76, 78, 76, 78, 76, 78, 76, 77, 75, 77, 75, 76, 75, 74, 75, 75, 73, 74, 73, 74,
73, 73, 72, 72, 72, 71, 72, 71, 72, 70, 70, 69, 70, 69, 69, 68, 69, 68, 69, 66,
67, 67, 68, 65, 67, 65, 66, 65, 65, 64, 64, 63, 64, 62, 64, 62, 63, 61, 61, 60,
61, 59, 61, 58, 60, 58, 59, 57, 58, 57, 58, 55, 56, 56, 56, 55, 54, 54, 54, 52,
53, 51, 52, 51, 52, 50, 50, 49, 50, 48, 49, 48, 48, 47, 47, 46, 46, 46, 45, 45,
44, 44, 42, 43, 42, 42, 41, 41, 39, 41, 39, 40, 37, 39, 37, 39, 36, 37, 36, 36,
34, 36, 34, 35, 33, 33, 31, 33, 30, 32, 30, 31, 28, 31, 26, 30, 27, 29, 25, 28,
24, 28, 23, 26, 22, 26, 21, 25, 20, 24, 20, 23, 19, 21, 17, 21, 17, 21, 16, 20,
14, 19, 13, 18, 13, 16, 12, 15, 11, 15, 10, 14, 9, 13, 9, 11, 8, 12, 7, 11, 7,
10, 5, 8, 4, 7, 4, 7, 4, 6, 3, 5, 2, 4, 2, 3, 1, 2, 0, 1, -1, 0, -1, 0, -2, -2,
-4, -3, -4, -4, -5, -5, -6, -5, -6, -7, -7, -7, -8, -8, -8, -10, -9, -11, -10,
-12, -11, -12, -12, -14, -13, -14, -14, -15, -14, -16, -15, -17, -16, -18, -17,
-19, -17, -21, -19, -21, -19, -22, -20, -23, -21, -24, -22, -26, -24, -26, -23,
-26, -25, -28, -26, -30, -27, -30, -27, -31, -28, -31, -30, -33, -31, -33, -30,
-34, -31, -35, -32, -37, -33, -37, -34, -38, -35, -40, -35, -40, -38, -40, -38,
-42, -38, -43, -39, -43, -40, -44, -41, -45, -41, -46, -42, -47, -44, -48, -45,
-49, -45, -50, -46, -51, -47, -52, -47, -52, -48, -53, -50, -54, -49, -55, -52,
-56, -51, -57, -53, -57, -54, -58, -55, -59, -55, -60, -56, -61, -56, -62, -57,
-62, -58, -64, -59, -65, -60, -66, -61, -67, -61, -67, -62, -69, -62, -68, -63,
-70, -65, -71, -65, -71, -66, -72, -66, -72, -67, -74, -68, -75, -69, -76, -69,
-76, -70, -76, -70, -78, -71, -78, -72, -79, -72, -80, -74, -80, -74, -81, -74,
-82, -74, -83, -75, -84, -76, -84, -77, -84, -78, -85, -78, -85, -78, -87, -79,
-87, -79, -88, -81, -89, -82, -89, -81, -90, -82, -91, -83, -91, -83, -92, -84,
-93, -84, -93, -85, -94, -86, -94, -86, -96, -86, -96, -87, -97, -87, -97, -88,
-98, -89, -98, -90, -99, -90, -100, -89, -100, -91, -101, -91, -100, -91, -101,
-93, -102, -93, -102, -92, -103, -93, -104, -94, -104, -94, -105, -95, -106,
-95, -106, -96, -106, -96, -107, -96, -107, -97, -107, -98, -108, -98, -108,
-98, -109, -99, -109, -99, -110, -100, -110, -101, -110, -100, -111, -101, -111,
-101, -111, -101, -111, -102, -113, -103, -113, -103, -112, -103, -113, -104,
-113, -104, -113, -104, -114, -104, -114, -105, -115, -105, -114, -105, -115,
-106, -116, -106, -116, -106, -116, -107, -117, -107, -116, -108, -117, -108,
-116, -109, -117, -108, -117, -108, -117, -109, -118, -109, -117, -109, -119,
-110, -118, -110, -119, -109, -118, -111, -118, -110, -118, -110, -118, -110,
-119, -111, -118, -111, -118, -112, -119, -111, -118, -112, -118, -111, -120,
-112, -120, -112, -118, -112, -119, -112, -119, -112, -119, -112, -119, -112,
-119, -111, -119, -111, -119, -111, -119, -111, -119, -111, -118, -110, -118,
-111, -118, -109, -117, -109, -118, -109, -117, -109, -116, -107, -116, -107,
-115, -106, -114, -105, -114, -105, -113, -104, -112, -102, -112, -101, -110,
-100, -109, -99, -107, -97, -106, -95, -104, -94, -103, -93, -101, -92, -99,
-89, -98, -87, -95, -86, -94, -84, -92, -82, -89, -79, -87, -78, -84, -75, -83,
-72, -79, -70, -77, -69, -74, -65, -72, -62, -69, -61, -66, -58, -63, -55, -60,
-52, -57, -50, -53, -46, -50, -44, -47, -41, -43, -38, -40, -36, -37, -33, -33,
-29, -30, -26, -26, -23, -22, -20, -19, -17, -15, -14, -11, -10, -7, -7, -4, -5,
-1, -1, 2, };