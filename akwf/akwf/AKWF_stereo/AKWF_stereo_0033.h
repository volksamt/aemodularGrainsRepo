#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0033

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, -48, 15, -58, 23, -56, 32, -60, 41,
-59, 49, -62, 56, -61, 64, -63, 70, -61, 76, -62, 83, -60, 87, -61, 92, -60, 96,
-61, 100, -60, 104, -61, 108, -60, 111, -61, 113, -60, 116, -60, 117, -59, 118,
-58, 118, -57, 118, -56, 119, -53, 116, -52, 116, -49, 114, -48, 110, -46, 109,
-43, 105, -40, 104, -38, 101, -35, 98, -33, 95, -31, 93, -29, 91, -27, 88, -27,
86, -26, 84, -25, 83, -26, 81, -27, 80, -27, 79, -27, 77, -28, 76, -28, 77, -28,
76, -27, 77, -26, 78, -25, 77, -23, 78, -22, 81, -19, 83, -18, 83, -15, 86, -14,
88, -12, 90, -11, 93, -10, 96, -9, 99, -8, 102, -7, 105, -5, 108, -4, 110, -3,
112, -3, 115, -2, 116, -2, 118, -2, 119, -3, 118, -4, 118, -6, 119, -9, 118,
-11, 115, -14, 114, -18, 112, -21, 108, -25, 106, -28, 102, -30, 99, -31, 96,
-32, 91, -32, 87, -33, 83, -31, 78, -28, 74, -25, 68, -19, 64, -15, 59, -10, 54,
-3, 49, 3, 43, 11, 39, 19, 33, 26, 28, 36, 23, 45, 18, 53, 14, 62, 9, 69, 5, 76,
-1, 83, -6, 89, -11, 94, -15, 98, -20, 102, -25, 104, -28, 108, -32, 110, -35,
113, -39, 115, -41, 117, -43, 117, -45, 118, -47, 119, -49, 119, -50, 118, -51,
117, -51, 115, -53, 112, -52, 109, -53, 105, -53, 101, -52, 97, -51, 91, -50,
87, -49, 82, -46, 78, -44, 74, -43, 69, -39, 67, -37, 63, -34, 60, -32, 58, -29,
56, -28, 54, -25, 51, -23, 50, -22, 49, -21, 48, -19, 47, -18, 48, -17, 47, -15,
47, -15, 48, -14, 51, -13, 52, -13, 55, -11, 59, -10, 62, -10, 66, -10, 69, -11,
73, -10, 76, -10, 78, -9, 80, -9, 82, -8, 83, -9, 82, -9, 82, -10, 81, -9, 80,
-10, 78, -10, 76, -11, 73, -12, 69, -12, 66, -14, 62, -16, 59, -17, 54, -18, 51,
-21, 47, -23, 43, -25, 38, -26, 35, -28, 32, -31, 27, -33, 25, -36, 21, -39, 18,
-41, 16, -45, 13, -49, 11, -51, 9, -54, 7, -57, 4, -62, 2, -64, 0, -66, -3, -69,
-4, -72, -7, -75, -9, -77, -12, -79, -14, -80, -17, -81, -20, -82, -25, -84,
-28, -85, -34, -85, -38, -86, -44, -88, -49, -88, -54, -89, -60, -91, -64, -92,
-69, -93, -74, -94, -78, -95, -81, -96, -86, -97, -88, -98, -90, -99, -92, -101,
-93, -102, -94, -101, -94, -103, -94, -104, -92, -104, -91, -105, -89, -106,
-86, -106, -82, -107, -78, -109, -74, -110, -68, -110, -64, -110, -59, -111,
-54, -112, -50, -114, -46, -114, -43, -116, -40, -117, -39, -116, -37, -116,
-36, -116, -35, -115, -34, -112, -32, -110, -32, -108, -32, -104, -32, -98, -31,
-95, -31, -89, -32, -85, -32, -79, -33, -73, -34, -66, -35, -59, -35, -52, -39,
-45, -40, -36, -43, -28, -46, -20, -47, -11, -49, -2, -53, 7, -54, 16, -56, 23,
-59, 33, -60, 42, -60, 50, -61, 57, -62, 64, -61, 70, -62, 77, -61, 83, -61, 88,
-61, 93, -60, 97, -61, 100, -61, 105, -60, 107, -61, 111, -60, 113, -60, 116,
-60, 116, -59, 118, -58, 119, -56, 119, -54, 117, -54, 117, -51, 115, -50, 113,
-47, 111, -46, 108, -43, 105, -40, 103, -38, 100, -36, 98, -32, 95, -31, 93,
-29, 91, -28, 88, -27, 87, -25, 83, -26, 82, -26, 81, -26, 79, -27, 78, -27, 77,
-28, 76, -28, 77, -28, 77, -28, 77, -26, 77, -25, 79, -23, 80, -22, 80, -19, 82,
-17, 85, -16, 86, -14, 88, -12, 91, -11, 94, -9, 96, -8, 99, -8, 102, -6, 106,
-5, 107, -4, 111, -3, 113, -2, 115, -3, 117, -2, 118, -2, 119, -3, 119, -5, 118,
-6, 117, -9, 117, -12, 115, -15, 114, -18, 112, -22, 108, -25, 106, -28, 102,
-29, 98, -32, 95, -33, 91, -33, 86, -32, 82, -29, 78, -26, 73, -24, 68, -20, 63,
-15, 58, -8, 53, -3, 49, 4, 43, 11, 39, 19, 33, 28, 27, 37, 23, 46, 18, 54, 14,
62, 9, 70, 4, 77, -2, 84, -7, 88, -11, 95, -16, 99, -20, 101, -24, 105, -29,
109, -32, 111, -35, 113, -39, 115, -41, 117, -43, 118, -46, 118, -47, 119, -49,
119, -49, 118, -50, 117, -51, 114, -52, 112, -53, 108, -52, 105, -52, 100, -52,
96, -51, 91, -49, 87, -48, 82, -46, 77, -44, 73, -42, 69, -39, 66, -36, 63, -33,
60, -32, 58, -28, 56, -27, 54, -25, 52, -24, 50, -21, 49, -20, 47, -19, 47, -17,
47, -17, 47, -16, 48, -15, 49, -14, 50, -13, 53, -12, 55, -11, 59, -11, 62, -10,
67, -10, 69, -9, 73, -10, 76, -10, 79, -9, 80, -9, 82, -9, 81, -9, 82, -8, 83,
-9, 81, -9, 79, -10, 78, -10, 75, -12, 72, -11, 69, -14, 66, -15, 63, -16, 58,
-18, 55, -19, 51, -21, 47, -22, 42, -25, 38, -27, 34, -29, 31, -32, 27, -33, 23,
-36, 20, -39, 18, -42, 16, -44, 13, -48, 11, -52, 9, -55, 7, -58, 4, -61, 2,
-65, 0, -66, -3, -70, -4, -72, -7, -75, -9, -76, -12, -79, -14, -81, -18, -82,
-21, -82, -25, -84, -29, -84, -33, -86, -39, -87, -45, -88, -48, -90, -55, -89,
-60, -91, -65, -92, -70, -92, -74, -95, -78, -95, -81, -96, -86, -98, -88, -97,
-90, -100, -93, -100, -94, -101, -94, -102, -94, -104, -94, -103, -93, -105,
-91, -106, -89, -106, -86, -108, -81, -108, -77, -108, -73, -109, -68, -110,
-63, -110, -58, -111, -55, -113, -50, -113, -46, -115, -43, -116, -40, -117,
-38, -117, -37, -117, -35, -115, -34, -115, -34, -112, -34, -110, -32, -107,
-32, -102, -32, -99, -32, -95, -32, -89, -32, -83, -33, -78, -32, -72, -34, -65,
-34, -59, -37, -51, -38, -44, -42, -35, -42, -28, -46, -19, -46, -10, -53, -2,
-45, };