#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0192

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -4, 4, -1, 7, 3, 10, 6, 15, 10, 19,
13, 22, 18, 26, 22, 30, 25, 33, 29, 37, 32, 41, 36, 45, 40, 48, 43, 51, 48, 56,
51, 58, 55, 62, 58, 65, 61, 69, 65, 72, 68, 74, 71, 77, 74, 80, 77, 83, 81, 86,
83, 89, 85, 91, 87, 94, 89, 96, 92, 98, 93, 101, 97, 103, 98, 104, 99, 107, 102,
109, 103, 109, 104, 111, 105, 112, 105, 113, 106, 114, 108, 116, 108, 117, 108,
117, 108, 118, 108, 118, 108, 119, 107, 120, 107, 119, 106, 119, 105, 119, 104,
119, 102, 119, 101, 118, 100, 117, 98, 117, 96, 116, 94, 115, 91, 114, 89, 113,
87, 112, 85, 111, 82, 109, 78, 107, 75, 106, 72, 104, 69, 102, 66, 100, 62, 98,
59, 96, 56, 94, 51, 92, 49, 90, 45, 88, 41, 86, 36, 84, 33, 81, 30, 79, 26, 76,
22, 74, 17, 72, 14, 70, 10, 67, 6, 64, 2, 62, -2, 59, -5, 57, -8, 54, -12, 52,
-15, 49, -18, 47, -21, 44, -24, 42, -29, 39, -31, 37, -34, 35, -37, 33, -39, 29,
-41, 27, -44, 25, -46, 22, -48, 20, -50, 18, -51, 16, -53, 14, -55, 11, -57, 10,
-58, 7, -59, 5, -61, 3, -61, 0, -61, -1, -63, -3, -63, -5, -64, -7, -64, -9,
-65, -11, -65, -12, -64, -14, -64, -16, -64, -18, -63, -21, -63, -22, -63, -24,
-62, -26, -62, -28, -60, -30, -59, -32, -59, -33, -58, -36, -57, -36, -55, -39,
-55, -41, -54, -42, -53, -43, -52, -45, -50, -46, -49, -49, -47, -51, -47, -52,
-45, -53, -43, -55, -42, -56, -41, -57, -39, -59, -38, -60, -37, -62, -36, -63,
-34, -65, -34, -65, -33, -67, -31, -68, -30, -69, -29, -70, -28, -72, -27, -72,
-26, -73, -25, -74, -23, -76, -23, -76, -22, -77, -21, -78, -20, -78, -19, -79,
-20, -79, -18, -81, -18, -81, -18, -82, -17, -82, -18, -83, -17, -84, -16, -84,
-17, -84, -16, -84, -16, -85, -16, -84, -17, -85, -17, -85, -16, -85, -17, -85,
-18, -85, -18, -85, -18, -85, -19, -86, -19, -85, -19, -85, -20, -85, -21, -85,
-22, -84, -22, -85, -23, -85, -24, -84, -25, -84, -26, -85, -27, -84, -27, -84,
-29, -84, -29, -84, -31, -83, -32, -83, -32, -83, -34, -84, -35, -83, -35, -83,
-37, -83, -38, -83, -39, -82, -40, -81, -41, -81, -42, -81, -44, -81, -44, -81,
-45, -81, -46, -81, -48, -80, -48, -80, -49, -79, -50, -78, -50, -78, -51, -78,
-52, -78, -53, -77, -53, -76, -54, -76, -54, -75, -54, -74, -54, -74, -55, -73,
-54, -71, -54, -71, -54, -70, -54, -68, -53, -68, -53, -67, -53, -65, -52, -64,
-52, -63, -51, -60, -50, -59, -49, -57, -49, -56, -47, -55, -46, -52, -45, -51,
-43, -48, -42, -46, -40, -44, -38, -42, -35, -40, -33, -37, -32, -35, -29, -33,
-27, -30, -25, -28, -23, -25, -20, -23, -18, -20, -15, -16, -12, -13, -9, -10,
-7, -8, -4, -4, -1, 0, 2, 2, 4, 5, 8, 8, 10, 13, 13, 14, 17, 18, 20, 21, 22, 25,
25, 27, 28, 31, 32, 34, 35, 38, 38, 41, 40, 43, 43, 46, 46, 49, 48, 51, 51, 55,
53, 58, 56, 60, 59, 63, 60, 65, 63, 68, 64, 69, 66, 72, 68, 74, 70, 76, 70, 78,
72, 79, 74, 82, 74, 82, 76, 85, 76, 86, 77, 87, 78, 88, 78, 89, 78, 90, 79, 91,
79, 92, 78, 93, 78, 92, 78, 93, 77, 94, 77, 94, 76, 94, 75, 94, 74, 94, 72, 94,
71, 93, 70, 93, 68, 93, 66, 92, 64, 91, 63, 91, 60, 91, 59, 90, 57, 89, 54, 89,
51, 87, 50, 86, 48, 85, 45, 84, 42, 83, 40, 82, 37, 80, 33, 80, 32, 79, 29, 77,
26, 76, 24, 75, 21, 74, 18, 72, 16, 71, 14, 70, 11, 68, 8, 67, 5, 65, 3, 64, 1,
64, -1, 61, -3, 60, -6, 59, -7, 57, -9, 57, -11, 56, -13, 53, -14, 53, -16, 52,
-17, 50, -18, 49, -20, 47, -20, 47, -21, 46, -21, 44, -23, 43, -23, 43, -24, 42,
-24, 40, -25, 39, -24, 38, -24, 36, -24, 36, -25, 35, -23, 34, -24, 33, -23, 32,
-22, 30, -22, 29, -20, 28, -20, 27, -19, 27, -19, 25, -17, 23, -17, 22, -15, 21,
-14, 20, -12, 20, -11, 18, -10, 16, -8, 14, -8, 13, -5, 11, -3, 11, -3, 9, -1,
7, -1, 6, 2, 6, 4, 3, 5, 2, 6, 1, 7, 0, 9, -3, 11, -5, 11, -6, 13, -8, 14, -9,
15, -11, 16, -12, 17, -14, 18, -15, 19, -17, 20, -19, 21, -20, 21, -21, 23, -24,
22, -24, 24, -27, 23, -28, 25, -29, 24, -32, 25, -33, 25, -34, 24, -36, 25, -37,
25, -37, 25, -39, 24, -41, 24, -43, 23, -43, 22, -45, 22, -47, 22, -47, 21, -49,
21, -49, 19, -51, 18, -51, 17, -52, 17, -54, 15, -55, 14, -56, 12, -57, 12, -58,
10, -58, 8, -59, 7, -60, 5, -61, 5, -61, 2, -63, 0, -63, -2, -63, -3, -63, -4,
-64, -7, -65, -9, -66, -11, -67, -12, -67, -15, -68, -16, -68, -19, -69, -21,
-70, -23, -69, -24, -70, -26, -71, -28, -70, -30, -71, -33, -71, -35, -71, -36,
-72, -38, -72, -39, -72, -41, -73, -42, -72, -44, -73, -47, -73, -47, -73, -48,
-73, -51, -73, -52, -72, -52, -73, -54, -72, -55, -71, -56, -72, -57, -71, -58,
-70, -59, -70, -59, -69, -60, -69, -61, -69, -61, -67, -60, -66, -60, -66, -60,
-64, -60, -63, -60, -62, -59, -60, -59, -59, -58, -58, -57, -57, -56, -55, -56,
-53, -54, -51, -52, -49, -50, -47, -50, -45, -47, -43, -46, -40, -44, -38, -41,
-35, -39, -33, -36, -30, -34, -28, -32, -24, -29, -22, -27, -18, -23, -15, -20,
-13, -18, -9, -14, -5, -11, -3, -7, };