#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0171

const PROGMEM int8_t DATA[DATA_LENGTH] = {18, 17, 40, 22, 86, 27, 82, 26, 84,
23, 84, 23, 84, 20, 86, 20, 85, 18, 87, 17, 86, 14, 87, 14, 86, 11, 87, 9, 85,
8, 86, 6, 84, 6, 86, 4, 85, 2, 86, 0, 84, -2, 84, -4, 83, -4, 83, -6, 83, -8,
82, -9, 82, -11, 81, -13, 80, -15, 79, -17, 79, -19, 77, -21, 76, -22, 76, -24,
75, -25, 74, -26, 73, -24, 72, -23, 70, -22, 69, -24, 68, -24, 67, -25, 66, -25,
64, -27, 63, -29, 62, -30, 61, -31, 59, -32, 59, -35, 57, -36, 54, -37, 54, -40,
52, -41, 51, -42, 49, -43, 49, -44, 47, -46, 47, -47, 45, -48, 44, -49, 44, -50,
41, -52, 40, -53, 39, -55, 38, -55, 37, -57, 35, -56, 35, -55, 33, -55, 33, -53,
33, -53, 34, -53, 33, -54, 34, -54, 33, -55, 34, -55, 32, -56, 31, -57, 30, -59,
29, -59, 29, -61, 27, -61, 27, -64, 28, -64, 28, -66, 29, -66, 30, -68, 29, -69,
29, -70, 29, -71, 28, -72, 27, -74, 26, -73, 26, -78, 25, -74, 24, -86, 23, -48,
23, -21, 22, 19, 21, 40, 20, 30, 18, 39, 18, 34, 17, 40, 16, 36, 15, 40, 15, 38,
13, 42, 13, 42, 12, 45, 10, 45, 9, 46, 8, 46, 7, 47, 6, 47, 5, 46, 5, 47, 7, 46,
11, 47, 14, 47, 15, 48, 16, 47, 17, 48, 18, 46, 18, 47, 17, 45, 17, 46, 17, 43,
16, 45, 16, 43, 15, 45, 14, 46, 13, 49, 12, 49, 12, 49, 11, 50, 10, 49, 9, 49,
9, 49, 8, 48, 6, 47, 6, 46, 5, 45, 3, 45, 3, 44, 2, 44, 2, 42, -1, 41, 0, 41,
-1, 40, -3, 39, -4, 38, -5, 38, -5, 38, -7, 39, -8, 42, -9, 45, -9, 46, -10, 46,
-11, 46, -13, 46, -14, 45, -14, 45, -16, 44, -16, 43, -17, 42, -19, 42, -20, 40,
-21, 39, -22, 38, -22, 37, -23, 36, -22, 36, -19, 36, -16, 34, -14, 34, -13, 33,
-13, 33, -13, 31, -13, 31, -14, 29, -14, 27, -15, 27, -15, 26, -16, 24, -17, 23,
-18, 22, -19, 21, -17, 20, -15, 19, -14, 18, -12, 17, -11, 16, -10, 14, -10, 13,
-10, 12, -11, 11, -10, 9, -11, 7, -12, 6, -13, 5, -14, 4, -14, 3, -15, 1, -16,
-1, -17, -3, -18, -4, -19, -5, -19, -8, -20, -8, -20, -8, -23, -6, -21, -4, -25,
-3, -24, -4, -27, -5, -25, -5, -28, -7, -28, -6, -31, -8, -28, -8, -9, -7, 4,
-5, 24, -3, 21, -5, 21, -5, 21, -7, 22, -7, 21, -8, 21, -10, 22, -11, 20, -13,
20, -14, 20, -15, 20, -17, 18, -19, 18, -20, 18, -21, 17, -23, 16, -26, 16, -26,
14, -28, 14, -30, 13, -32, 13, -34, 12, -36, 11, -38, 10, -40, 8, -41, 8, -44,
7, -44, 6, -45, 5, -43, 4, -42, 2, -43, 2, -42, 1, -41, 1, -39, 1, -38, 1, -36,
1, -34, -1, -34, 0, -33, -1, -34, -2, -35, -4, -36, -4, -38, -5, -39, -7, -40,
-8, -42, -8, -43, -10, -45, -10, -46, -12, -48, -12, -48, -14, -48, -15, -50,
-16, -49, -18, -50, -19, -51, -20, -53, -20, -55, -22, -56, -22, -58, -25, -60,
-26, -61, -27, -62, -28, -63, -29, -66, -30, -67, -31, -69, -33, -70, -34, -71,
-35, -73, -36, -74, -38, -77, -39, -78, -40, -79, -41, -80, -42, -83, -43, -85,
-45, -86, -46, -86, -46, -85, -48, -80, -49, -76, -50, -71, -52, -66, -53, -62,
-53, -61, -54, -59, -55, -59, -56, -60, -58, -59, -59, -60, -59, -60, -60, -61,
-62, -62, -63, -63, -64, -66, -65, -66, -66, -68, -67, -68, -68, -70, -70, -71,
-71, -72, -72, -74, -74, -75, -76, -77, -77, -78, -78, -80, -80, -81, -81, -83,
-83, -83, -84, -82, -85, -81, -86, -78, -89, -79, -89, -79, -91, -80, -93, -80,
-94, -81, -94, -81, -94, -83, -93, -83, -92, -85, -91, -85, -91, -86, -89, -87,
-91, -89, -90, -90, -91, -91, -92, -93, -93, -93, -94, -96, -95, -97, -97, -99,
-97, -99, -99, -102, -99, -102, -102, -103, -102, -101, -105, -103, -104, -101,
-107, -104, -106, -102, -110, -106, -109, -103, -113, -107, -111, -105, -114,
-109, -113, -107, -117, -111, -116, -111, -117, -111, -123, -117, -69, -59, -39,
-26, 23, 36, 31, 46, 25, 41, 32, 49, 28, 45, 33, 51, 29, 47, 34, 51, 30, 48, 35,
51, 32, 49, 34, 51, 32, 49, 35, 51, 31, 49, 33, 51, 32, 49, 32, 50, 31, 49, 32,
48, 31, 47, 31, 47, 29, 46, 29, 47, 28, 46, 27, 45, 27, 44, 25, 43, 25, 43, 23,
41, 24, 41, 21, 39, 22, 39, 21, 36, 21, 37, 21, 35, 23, 36, 23, 33, 23, 35, 23,
31, 23, 32, 24, 30, 26, 31, 26, 28, 27, 30, 27, 26, 27, 27, 26, 23, 26, 24, 26,
19, 24, 20, 24, 54, 23, 74, 22, 108, 21, 108, 20, 106, 18, 109, 17, 106, 17,
109, 18, 106, 18, 108, 19, 106, 20, 108, 22, 106, 22, 107, 23, 106, 23, 106, 23,
104, 21, 105, 22, 103, 21, 104, 20, 102, 19, 101, 19, 100, 17, 100, 16, 99, 15,
97, 14, 97, 13, 94, 12, 94, 10, 93, 9, 91, 8, 90, 8, 90, 6, 89, 5, 88, 3, 88, 2,
88, 1, 86, 0, 86, -1, 84, -3, 83, -4, 81, -5, 81, -6, 79, -8, 77, -9, 76, -9,
74, -10, 73, -9, 72, -8, 70, -7, 69, -6, 67, -5, 65, -5, 65, -5, 63, -6, 61, -6,
60, -7, 58, -8, 56, -9, 54, -9, 52, -10, 51, -12, 49, -12, 47, -15, 45, -16, 44,
-17, 41, -17, 40, -17, 39, -18, 38, -17, 35, -18, 34, -18, 31, -20, 31, -20, 28,
-23, 27, -22, 24, -25, 23, -25, 21, -28, 19, -27, 17, -32, 16, -26, 11, };