#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0093

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 12, 3, 20, 8, 22, 11, 26, 14, 30,
18, 34, 22, 38, 25, 42, 29, 44, 30, 48, 34, 51, 37, 54, 39, 57, 42, 60, 46, 63,
48, 66, 51, 68, 53, 71, 55, 73, 57, 76, 59, 77, 60, 80, 63, 81, 63, 83, 64, 84,
66, 86, 66, 86, 66, 87, 67, 88, 67, 89, 66, 89, 66, 89, 65, 89, 65, 89, 64, 88,
63, 88, 62, 87, 62, 86, 60, 85, 59, 83, 58, 81, 57, 81, 57, 77, 55, 76, 55, 73,
54, 71, 53, 70, 53, 67, 52, 65, 52, 62, 50, 60, 51, 56, 50, 55, 49, 52, 48, 49,
48, 48, 48, 45, 47, 42, 47, 40, 46, 38, 46, 36, 45, 34, 45, 32, 43, 29, 43, 28,
42, 25, 41, 24, 41, 23, 40, 22, 39, 20, 38, 19, 38, 17, 37, 16, 35, 15, 34, 15,
33, 14, 31, 13, 30, 12, 28, 12, 28, 12, 25, 11, 24, 11, 22, 11, 21, 11, 21, 11,
18, 11, 17, 12, 14, 11, 14, 12, 11, 11, 11, 12, 10, 13, 9, 14, 9, 14, 8, 15, 7,
15, 8, 16, 8, 16, 8, 18, 9, 19, 10, 19, 11, 20, 12, 21, 14, 22, 17, 23, 19, 25,
20, 25, 23, 27, 24, 27, 27, 28, 29, 30, 32, 31, 34, 31, 36, 33, 38, 34, 39, 35,
41, 36, 43, 37, 44, 38, 44, 38, 45, 39, 45, 39, 46, 41, 45, 41, 46, 41, 45, 42,
44, 42, 44, 43, 42, 43, 40, 44, 39, 43, 37, 43, 36, 42, 34, 43, 30, 42, 29, 42,
27, 41, 24, 40, 22, 40, 19, 38, 16, 37, 14, 35, 11, 34, 8, 32, 4, 31, 0, 28, -2,
25, -5, 23, -9, 20, -10, 17, -14, 15, -16, 11, -18, 8, -19, 5, -20, 1, -22, -2,
-22, -6, -22, -9, -22, -12, -21, -15, -21, -19, -20, -22, -19, -25, -18, -28,
-16, -30, -14, -32, -12, -35, -10, -36, -9, -38, -8, -40, -4, -41, -3, -42, -1,
-43, 0, -43, 2, -44, 3, -44, 4, -46, 4, -46, 4, -46, 4, -47, 3, -47, 3, -48, 1,
-48, -1, -48, -4, -50, -6, -51, -9, -52, -13, -52, -17, -54, -21, -56, -24, -58,
-29, -60, -34, -62, -40, -64, -44, -66, -50, -69, -56, -72, -61, -75, -67, -77,
-72, -81, -78, -84, -83, -87, -88, -90, -92, -94, -97, -95, -101, -98, -105,
-101, -109, -105, -113, -107, -115, -109, -116, -111, -118, -113, -119, -114,
-119, -116, -119, -117, -117, -117, -117, -117, -115, -117, -114, -117, -113,
-118, -112, -116, -110, -114, -107, -114, -105, -111, -103, -110, -101, -108,
-98, -105, -96, -103, -94, -99, -90, -96, -88, -92, -86, -91, -82, -86, -79,
-83, -77, -79, -74, -75, -71, -72, -67, -67, -65, -63, -62, -59, -58, -54, -55,
-50, -52, -46, -48, -42, -45, -37, -41, -33, -37, -29, -34, -23, -30, -20, -26,
-15, -22, -10, -18, -6, -15, -2, -10, 2, -7, 6, -3, 10, 0, 15, 4, 19, 8, 23, 11,
27, 15, 31, 18, 34, 21, 37, 24, 41, 28, 45, 32, 47, 35, 52, 38, 54, 40, 58, 43,
60, 46, 63, 49, 67, 51, 69, 53, 71, 55, 73, 57, 76, 59, 77, 61, 80, 62, 82, 64,
84, 64, 84, 66, 85, 66, 87, 66, 88, 66, 89, 66, 89, 66, 89, 65, 89, 66, 89, 64,
89, 64, 89, 63, 88, 62, 87, 60, 85, 60, 85, 59, 83, 58, 81, 57, 79, 56, 79, 55,
75, 54, 73, 54, 71, 54, 70, 53, 66, 52, 65, 52, 62, 50, 60, 50, 58, 50, 55, 49,
52, 49, 49, 49, 46, 48, 44, 47, 43, 47, 40, 46, 38, 46, 35, 45, 34, 45, 32, 45,
29, 43, 27, 43, 25, 42, 24, 41, 22, 40, 21, 39, 20, 38, 19, 37, 17, 36, 17, 35,
16, 33, 15, 33, 14, 32, 13, 30, 12, 29, 12, 28, 12, 26, 11, 24, 11, 23, 11, 21,
10, 20, 11, 18, 11, 16, 11, 15, 12, 13, 11, 13, 12, 11, 13, 10, 13, 9, 13, 9,
13, 8, 15, 8, 15, 8, 16, 8, 17, 9, 18, 10, 19, 10, 19, 12, 20, 14, 21, 15, 23,
17, 24, 18, 25, 20, 26, 22, 27, 26, 28, 28, 30, 30, 31, 32, 31, 34, 33, 36, 33,
38, 34, 40, 35, 41, 36, 42, 37, 44, 38, 44, 39, 46, 39, 45, 40, 46, 40, 46, 42,
46, 42, 45, 43, 45, 42, 44, 42, 41, 43, 40, 42, 39, 43, 37, 43, 35, 42, 33, 43,
31, 43, 28, 42, 26, 41, 24, 40, 21, 39, 19, 38, 16, 38, 14, 35, 9, 34, 7, 32, 3,
30, 0, 28, -3, 25, -6, 22, -9, 19, -11, 18, -13, 15, -16, 11, -17, 7, -20, 4,
-20, 1, -22, -2, -22, -6, -22, -9, -22, -13, -22, -16, -21, -19, -20, -21, -18,
-24, -17, -27, -16, -30, -15, -32, -13, -35, -10, -36, -9, -38, -7, -39, -5,
-41, -2, -41, -1, -43, 0, -44, 1, -44, 3, -45, 4, -45, 4, -46, 4, -46, 5, -47,
3, -48, 2, -48, 0, -48, -1, -49, -3, -50, -7, -51, -10, -52, -13, -54, -16, -54,
-21, -56, -25, -58, -30, -60, -34, -63, -39, -65, -45, -67, -51, -70, -56, -72,
-62, -76, -67, -78, -73, -81, -78, -84, -84, -87, -88, -91, -93, -93, -98, -97,
-102, -100, -106, -102, -110, -104, -112, -107, -115, -110, -117, -112, -118,
-113, -119, -115, -119, -116, -119, -117, -118, -117, -117, -117, -116, -118,
-114, -116, -113, -117, -111, -116, -109, -115, -107, -113, -105, -111, -103,
-110, -100, -107, -97, -105, -95, -102, -92, -98, -90, -96, -88, -93, -85, -89,
-82, -86, -79, -82, -77, -79, -74, -75, -70, -71, -67, -67, -64, -63, -61, -58,
-58, -54, -55, -50, -51, -46, -48, -42, -44, -37, -40, -32, -37, -27, -34, -23,
-29, -19, -26, -15, -21, -10, -18, -6, -14, -1, -10, 2, -7, 7, -2, 10, };