#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0074

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 2, 5, 4, 7, 6, 8, 7, 10, 9, 12,
10, 13, 12, 15, 13, 16, 14, 19, 15, 20, 18, 21, 19, 22, 21, 24, 22, 27, 24, 27,
26, 29, 27, 31, 28, 32, 30, 34, 32, 35, 33, 37, 35, 39, 37, 40, 39, 42, 39, 44,
41, 45, 43, 46, 44, 47, 46, 50, 47, 51, 49, 52, 50, 54, 51, 56, 53, 57, 54, 59,
55, 60, 57, 62, 58, 63, 60, 65, 61, 66, 63, 68, 64, 69, 65, 71, 67, 71, 69, 73,
70, 75, 71, 75, 72, 77, 73, 78, 75, 79, 75, 80, 78, 82, 78, 84, 80, 84, 81, 86,
82, 86, 83, 88, 84, 89, 85, 91, 86, 91, 87, 92, 89, 93, 89, 95, 91, 96, 92, 96,
92, 97, 93, 99, 95, 100, 95, 100, 96, 101, 97, 102, 98, 103, 99, 104, 99, 104,
101, 106, 101, 106, 102, 107, 103, 108, 103, 108, 104, 109, 105, 110, 105, 110,
106, 111, 107, 111, 107, 112, 107, 113, 108, 114, 109, 113, 109, 114, 110, 115,
111, 115, 111, 115, 111, 116, 111, 116, 111, 117, 112, 118, 112, 117, 113, 117,
112, 118, 114, 119, 114, 118, 114, 118, 114, 119, 113, 118, 115, 119, 115, 119,
115, 120, 114, 119, 115, 118, 115, 119, 115, 118, 115, 120, 115, 118, 114, 119,
116, 119, 115, 119, 115, 119, 114, 118, 115, 118, 114, 118, 114, 118, 114, 118,
114, 118, 113, 117, 114, 117, 113, 117, 113, 117, 112, 117, 113, 116, 111, 116,
113, 116, 111, 116, 111, 115, 111, 114, 111, 114, 111, 114, 109, 113, 110, 114,
109, 113, 110, 112, 109, 112, 108, 111, 108, 110, 108, 110, 107, 109, 107, 109,
106, 109, 105, 109, 105, 107, 105, 107, 104, 107, 104, 106, 103, 106, 103, 105,
102, 104, 101, 104, 101, 104, 100, 102, 100, 103, 99, 102, 99, 101, 98, 100, 97,
100, 97, 99, 96, 98, 95, 97, 95, 97, 94, 96, 93, 95, 93, 95, 92, 93, 92, 93, 91,
93, 90, 91, 89, 91, 90, 89, 88, 90, 88, 89, 87, 88, 86, 88, 85, 86, 84, 86, 84,
85, 83, 84, 82, 84, 81, 83, 80, 82, 80, 80, 79, 80, 79, 79, 78, 78, 75, 77, 76,
76, 74, 75, 74, 74, 73, 73, 72, 72, 71, 72, 70, 70, 68, 70, 68, 68, 67, 68, 66,
66, 66, 66, 65, 64, 63, 63, 62, 62, 62, 61, 61, 60, 59, 59, 58, 57, 57, 56, 56,
56, 55, 55, 55, 53, 52, 52, 52, 52, 51, 50, 50, 48, 48, 47, 46, 46, 46, 45, 45,
44, 43, 43, 43, 41, 41, 40, 40, 39, 38, 37, 36, 36, 35, 35, 35, 33, 33, 32, 32,
31, 30, 28, 29, 27, 28, 26, 27, 25, 26, 24, 24, 22, 22, 21, 21, 19, 19, 18, 19,
16, 17, 15, 15, 13, 14, 11, 12, 10, 11, 9, 9, 7, 9, 6, 6, 3, 5, 2, 4, 1, 1, -1,
0, -1, -1, -4, -2, -5, -4, -6, -6, -9, -7, -10, -9, -12, -10, -13, -12, -15,
-13, -16, -15, -18, -16, -19, -18, -21, -20, -23, -20, -24, -22, -26, -25, -27,
-25, -30, -28, -31, -29, -32, -31, -34, -31, -36, -33, -37, -35, -39, -37, -40,
-37, -41, -40, -44, -41, -46, -43, -46, -44, -48, -46, -50, -48, -50, -49, -52,
-50, -54, -51, -56, -52, -57, -54, -59, -56, -60, -57, -62, -59, -64, -60, -64,
-61, -66, -63, -67, -64, -69, -66, -69, -67, -71, -68, -73, -70, -75, -71, -75,
-73, -76, -74, -79, -74, -80, -76, -81, -77, -82, -79, -83, -80, -84, -81, -86,
-82, -88, -84, -87, -84, -88, -86, -90, -86, -91, -87, -92, -89, -94, -91, -95,
-91, -96, -91, -96, -92, -97, -94, -99, -95, -99, -95, -100, -97, -102, -97,
-102, -97, -103, -98, -104, -101, -105, -101, -106, -102, -106, -102, -107,
-103, -107, -103, -108, -104, -110, -105, -110, -106, -111, -106, -111, -107,
-112, -107, -112, -108, -113, -109, -113, -109, -114, -110, -114, -111, -115,
-110, -115, -111, -116, -111, -116, -111, -116, -111, -117, -111, -117, -112,
-117, -113, -118, -113, -118, -114, -118, -113, -118, -113, -118, -114, -119,
-114, -119, -114, -119, -114, -119, -115, -119, -114, -119, -115, -119, -115,
-119, -114, -119, -115, -119, -115, -120, -115, -119, -114, -119, -114, -119,
-115, -119, -115, -119, -114, -118, -113, -118, -115, -118, -114, -118, -113,
-117, -113, -118, -114, -118, -113, -118, -113, -117, -113, -117, -112, -117,
-112, -116, -112, -116, -111, -115, -111, -115, -111, -115, -110, -114, -111,
-113, -110, -113, -110, -113, -108, -113, -109, -112, -108, -112, -108, -111,
-108, -111, -108, -111, -106, -110, -106, -109, -105, -109, -106, -108, -105,
-107, -104, -107, -104, -106, -103, -107, -103, -105, -103, -105, -103, -105,
-101, -104, -101, -103, -101, -103, -100, -102, -99, -101, -98, -101, -97, -100,
-98, -100, -97, -98, -96, -99, -96, -97, -95, -96, -94, -95, -93, -95, -93, -95,
-92, -94, -91, -94, -91, -92, -90, -92, -89, -92, -88, -90, -88, -89, -87, -89,
-86, -88, -86, -88, -85, -87, -84, -86, -84, -84, -83, -84, -82, -83, -81, -83,
-80, -81, -80, -80, -78, -80, -78, -78, -76, -78, -76, -77, -76, -76, -74, -75,
-73, -74, -72, -73, -71, -72, -71, -72, -70, -70, -69, -69, -69, -68, -68, -67,
-66, -67, -65, -66, -65, -65, -63, -63, -62, -62, -62, -61, -61, -59, -59, -59,
-58, -58, -56, -56, -56, -56, -54, -55, -54, -53, -52, -53, -52, -50, -51, -50,
-49, -49, -48, -47, -46, -47, -45, -46, -44, -44, -43, -42, -42, -41, -40, -40,
-39, -39, -38, -36, -37, -36, -36, -35, -34, -33, -33, -31, -31, -31, -30, -29,
-30, -28, -28, -26, -26, -25, -25, -24, -24, -22, -22, -19, -20, -18, -19, -18,
-17, -15, -16, -15, -16, -13, -13, -11, -13, -10, -10, -8, -9, -7, -8, -5, -6,
-4, -5, -1, -3, -1, -1, 1, -1, 2, };