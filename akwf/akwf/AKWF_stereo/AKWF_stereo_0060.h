#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0060

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 67, 33, 85, 49, 83, 60, 90, 69, 88,
76, 93, 80, 92, 85, 96, 89, 95, 92, 98, 94, 97, 97, 100, 98, 98, 101, 100, 102,
100, 104, 101, 105, 101, 106, 101, 106, 101, 107, 102, 108, 101, 108, 101, 109,
101, 109, 102, 110, 102, 111, 102, 110, 102, 110, 102, 110, 103, 112, 102, 111,
103, 111, 103, 111, 103, 112, 102, 111, 104, 111, 103, 111, 103, 112, 103, 110,
103, 111, 103, 111, 103, 110, 103, 110, 103, 110, 103, 110, 104, 109, 103, 109,
103, 109, 103, 109, 103, 108, 104, 108, 103, 107, 104, 107, 103, 106, 103, 105,
103, 106, 102, 105, 103, 104, 103, 103, 103, 103, 103, 102, 102, 101, 102, 100,
103, 100, 102, 98, 102, 98, 101, 97, 101, 95, 100, 96, 100, 93, 100, 93, 100,
91, 100, 91, 99, 89, 99, 89, 97, 87, 98, 87, 97, 85, 97, 84, 96, 83, 95, 81, 94,
80, 95, 79, 93, 77, 94, 76, 93, 75, 92, 73, 91, 72, 90, 69, 89, 68, 89, 66, 88,
66, 87, 64, 86, 63, 85, 61, 84, 58, 83, 56, 83, 55, 82, 52, 80, 51, 79, 50, 78,
48, 77, 46, 76, 45, 74, 43, 74, 41, 72, 39, 71, 37, 70, 35, 68, 34, 67, 30, 65,
29, 63, 28, 62, 25, 60, 23, 59, 21, 58, 19, 55, 18, 53, 15, 51, 14, 49, 12, 46,
10, 44, 9, 39, 7, 37, 7, 32, 5, 27, 10, 4, 12, -10, 10, -13, 9, -17, 7, -19, 5,
-24, 3, -24, 2, -27, 0, -30, -2, -32, -4, -34, -6, -35, -8, -37, -9, -39, -11,
-40, -13, -42, -15, -43, -17, -45, -19, -46, -20, -47, -23, -49, -24, -50, -26,
-52, -27, -53, -29, -55, -31, -55, -33, -57, -35, -58, -36, -59, -37, -59, -40,
-61, -40, -62, -43, -64, -44, -64, -45, -66, -47, -67, -48, -68, -50, -68, -51,
-69, -52, -71, -53, -71, -55, -73, -56, -74, -59, -74, -60, -76, -62, -77, -61,
-78, -63, -79, -64, -79, -66, -79, -67, -80, -68, -82, -70, -82, -71, -83, -71,
-84, -73, -84, -75, -86, -75, -86, -76, -87, -78, -87, -78, -88, -79, -89, -80,
-90, -82, -90, -82, -92, -83, -92, -84, -92, -85, -93, -85, -94, -87, -94, -88,
-95, -88, -96, -89, -96, -89, -97, -91, -97, -91, -98, -92, -97, -93, -99, -94,
-100, -94, -100, -95, -101, -95, -101, -96, -101, -98, -102, -98, -102, -98,
-103, -98, -103, -99, -104, -100, -104, -100, -105, -101, -105, -102, -105,
-102, -106, -103, -106, -104, -107, -104, -107, -104, -107, -105, -108, -106,
-108, -105, -108, -105, -108, -106, -108, -107, -110, -107, -109, -107, -110,
-108, -111, -109, -111, -109, -111, -109, -111, -109, -112, -111, -112, -110,
-112, -111, -112, -111, -113, -111, -112, -112, -113, -112, -113, -113, -114,
-113, -114, -113, -115, -113, -114, -113, -115, -114, -114, -114, -115, -114,
-115, -114, -115, -114, -115, -115, -115, -115, -115, -114, -116, -116, -117,
-115, -117, -115, -116, -116, -117, -116, -117, -116, -117, -116, -117, -117,
-117, -117, -118, -116, -117, -116, -117, -117, -117, -118, -117, -118, -118,
-117, -117, -117, -118, -118, -118, -118, -118, -117, -118, -118, -118, -118,
-118, -118, -118, -118, -119, -118, -119, -118, -118, -118, -119, -117, -119,
-118, -118, -118, -119, -118, -118, -118, -119, -118, -120, -117, -119, -118,
-120, -118, -119, -118, -119, -118, -119, -118, -119, -119, -119, -118, -119,
-118, -119, -118, -119, -118, -119, -119, -119, -117, -119, -118, -119, -118,
-119, -117, -118, -118, -118, -118, -119, -117, -119, -118, -119, -118, -119,
-117, -119, -117, -119, -117, -119, -117, -119, -117, -118, -117, -118, -116,
-118, -117, -118, -116, -118, -116, -118, -116, -118, -116, -118, -116, -118,
-116, -117, -115, -118, -115, -118, -115, -118, -116, -118, -115, -118, -115,
-117, -114, -118, -114, -117, -114, -118, -115, -118, -115, -117, -114, -116,
-113, -117, -113, -117, -113, -115, -113, -116, -113, -116, -112, -116, -111,
-115, -112, -116, -111, -114, -111, -115, -111, -115, -111, -114, -111, -114,
-110, -115, -110, -114, -109, -114, -109, -114, -109, -114, -109, -114, -108,
-114, -108, -113, -107, -113, -107, -112, -106, -112, -107, -113, -107, -113,
-106, -113, -106, -112, -106, -111, -105, -112, -105, -112, -104, -111, -104,
-110, -103, -110, -103, -111, -103, -110, -103, -110, -102, -109, -102, -109,
-101, -109, -101, -108, -100, -108, -99, -108, -99, -108, -99, -107, -99, -107,
-98, -107, -98, -106, -96, -106, -96, -107, -96, -106, -96, -105, -95, -105,
-94, -104, -94, -105, -94, -105, -93, -103, -93, -104, -91, -104, -92, -103,
-90, -102, -91, -102, -89, -103, -90, -102, -88, -102, -88, -101, -87, -101,
-87, -100, -86, -100, -86, -100, -85, -99, -84, -99, -83, -98, -84, -98, -82,
-97, -81, -97, -81, -96, -80, -97, -80, -97, -79, -96, -79, -96, -78, -95, -77,
-95, -77, -93, -75, -93, -74, -93, -75, -92, -74, -92, -73, -92, -73, -92, -71,
-92, -70, -90, -70, -90, -69, -89, -68, -88, -67, -88, -67, -88, -66, -88, -65,
-87, -64, -87, -64, -86, -63, -86, -62, -85, -62, -84, -61, -84, -59, -83, -58,
-83, -58, -82, -57, -82, -56, -82, -56, -81, -55, -80, -54, -79, -53, -78, -52,
-78, -52, -78, -50, -77, -49, -77, -49, -76, -47, -76, -46, -74, -45, -75, -45,
-73, -44, -72, -43, -73, -42, -71, -41, -71, -40, -70, -39, -70, -38, -69, -37,
-69, -36, -67, -36, -67, -34, -66, -33, -65, -33, -65, -31, -63, -30, -63, -30,
-62, -29, -62, -29, -61, -27, -60, -26, -59, -25, -59, -25, -58, -23, -57, -22,
-55, -20, -55, -20, -54, -20, -54, -18, -52, -17, -52, -17, -51, -16, -49, -15,
-49, -13, -47, -13, -47, -11, -45, -10, -45, -11, -42, -8, -42, -8, -39, -7,
-40, -7, -36, -5, -38, -5, -33, -4, -35, -3, -29, -2, -31, -1, -24, -1, -27, 0,
-18, -2, -16, -7, 8, -7, 8, -3, 4, -7, 51, };