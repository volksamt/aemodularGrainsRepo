#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0141

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, -45, 16, -46, 24, -34, 30, -31, 40,
-22, 47, -19, 55, -12, 60, -11, 65, -8, 67, -10, 68, -10, 67, -19, 63, -27, 61,
-34, 59, -34, 57, -34, 56, -29, 55, -23, 54, -22, 52, -21, 52, -23, 49, -24, 44,
-25, 42, -26, 38, -22, 35, -21, 31, -21, 26, -25, 22, -32, 18, -37, 17, -38, 16,
-39, 14, -44, 11, -48, 8, -52, 5, -51, 5, -51, 4, -49, 5, -44, 5, -38, 5, -30,
7, -21, 12, -13, 19, 3, 27, 17, 34, 27, 37, 35, 41, 41, 44, 47, 47, 50, 50, 51,
54, 50, 55, 51, 55, 54, 56, 57, 55, 62, 54, 64, 53, 68, 51, 71, 48, 74, 46, 73,
42, 73, 40, 73, 38, 72, 38, 73, 37, 71, 39, 71, 38, 71, 39, 72, 41, 76, 45, 79,
48, 82, 50, 82, 53, 83, 56, 86, 59, 87, 62, 87, 62, 87, 63, 85, 63, 86, 63, 88,
64, 91, 64, 94, 64, 100, 66, 104, 69, 108, 71, 110, 75, 111, 75, 110, 74, 106,
72, 103, 70, 102, 68, 101, 68, 101, 69, 101, 72, 101, 75, 102, 76, 102, 77, 100,
77, 99, 76, 97, 75, 98, 75, 99, 76, 101, 79, 104, 84, 107, 88, 108, 93, 110, 96,
111, 97, 112, 98, 112, 98, 112, 98, 111, 96, 105, 94, 100, 93, 94, 92, 90, 92,
87, 92, 86, 91, 87, 90, 89, 90, 93, 91, 96, 90, 97, 91, 97, 91, 99, 95, 102, 96,
106, 99, 109, 101, 110, 104, 111, 103, 112, 106, 113, 105, 110, 104, 108, 105,
108, 103, 105, 102, 104, 100, 100, 99, 95, 93, 87, 92, 82, 88, 80, 91, 81, 87,
81, 91, 85, 88, 83, 91, 83, 86, 78, 88, 79, 83, 75, 86, 78, 82, 80, 86, 83, 80,
80, 83, 75, 76, 65, -62, -37, -76, -92, -69, -104, -75, -112, -70, -114, -77,
-119, -71, -116, -77, -118, -71, -115, -74, -114, -69, -110, -71, -110, -65,
-105, -66, -104, -59, -99, -57, -94, -51, -88, -48, -84, -42, -80, -37, -78,
-29, -77, -21, -77, -14, -77, -6, -75, 3, -71, 13, -64, 19, -56, 26, -49, 29,
-44, 32, -36, 32, -31, 33, -29, 28, -29, 23, -29, 17, -30, 13, -29, 8, -32, 6,
-31, 3, -28, 4, -21, 8, -12, 14, -2, 19, 8, 23, 17, 27, 26, 30, 33, 32, 38, 34,
41, 36, 46, 38, 48, 39, 50, 41, 56, 43, 60, 44, 67, 47, 72, 48, 78, 49, 83, 51,
86, 53, 85, 53, 86, 53, 83, 51, 80, 49, 78, 48, 76, 47, 76, 47, 76, 50, 79, 52,
79, 52, 78, 50, 76, 48, 76, 44, 77, 40, 80, 40, 83, 40, 87, 45, 91, 52, 94, 57,
96, 62, 95, 67, 98, 71, 101, 72, 101, 73, 102, 72, 100, 70, 96, 67, 88, 65, 83,
64, 81, 63, 78, 65, 78, 66, 82, 70, 89, 73, 95, 76, 98, 77, 98, 79, 99, 79, 101,
83, 104, 86, 107, 91, 110, 94, 112, 97, 113, 98, 112, 101, 112, 102, 112, 104,
112, 106, 112, 107, 111, 107, 111, 105, 108, 104, 102, 98, 94, 94, 88, 88, 84,
89, 86, 86, 88, 89, 91, 86, 87, 88, 84, 82, 78, 86, 80, 80, 79, 86, 83, 80, 84,
86, 87, 76, 84, 84, 81, 67, 68, -78, -34, -82, -87, -79, -100, -85, -109, -82,
-109, -87, -114, -82, -110, -86, -112, -81, -111, -85, -111, -83, -110, -86,
-110, -83, -109, -87, -111, -86, -110, -88, -109, -85, -107, -87, -108, -86,
-108, -86, -109, -86, -108, -86, -109, -83, -110, -81, -109, -81, -107, -79,
-105, -78, -103, -78, -102, -79, -100, -80, -99, -82, -98, -84, -97, -89, -98,
-91, -98, -95, -99, -95, -99, -96, -99, -96, -98, -95, -97, -93, -94, -90, -90,
-87, -86, -86, -85, -86, -86, -86, -85, -85, -84, -83, -84, -82, -85, -83, -87,
-83, -87, -82, -87, -82, -86, -82, -82, -81, -76, -81, -68, -79, -63, -78, -58,
-77, -54, -77, -52, -78, -53, -79, -59, -80, -64, -83, -68, -83, -69, -82, -68,
-81, -68, -79, -64, -76, -64, -75, -62, -75, -62, -75, -63, -76, -61, -77, -58,
-78, -55, -78, -52, -75, -50, -71, -47, -67, -47, -63, -46, -59, -42, -52, -36,
-49, -31, -45, -31, -43, -31, -43, -36, -44, -43, -44, -43, -44, -43, -44, -43,
-42, -40, -39, -34, -34, -24, -29, -12, -24, -4, -22, -1, -18, 3, -11, 11, 0,
21, 9, 31, 19, 43, 26, 50, 31, 56, 37, 64, 45, 71, 50, 77, 55, 79, 57, 83, 58,
84, 57, 82, 50, 75, 40, 68, 30, 59, 22, 53, 16, 53, 15, 57, 12, 62, 12, 66, 7,
65, 6, 67, 0, 67, 4, 70, 0, 69, 7, 73, 4, 72, 8, 73, -2, 64, 2, 64, -17, 46,
-114, -55, -113, -97, -112, -109, -114, -116, -112, -116, -113, -120, -111,
-117, -112, -118, -108, -114, -110, -114, -106, -109, -108, -106, -105, -101,
-106, -99, -102, -94, -102, -94, -101, -91, -101, -93, -100, -93, -100, -95,
-98, -96, -96, -98, -94, -98, -92, -100, -90, -97, -86, -93, -83, -88, -79, -84,
-78, -81, -75, -74, -74, -71, -72, -68, -75, -67, -77, -69, -80, -71, -82, -73,
-84, -76, -86, -77, -87, -79, -88, -79, -88, -78, -88, -75, -88, -73, -87, -72,
-86, -70, -85, -67, -82, -65, -81, -65, -80, -71, -79, -77, -79, -80, -81, -81,
-80, -82, -79, -82, -79, -79, -77, -74, -76, -68, -74, -63, -73, -59, -73, -59,
-76, -64, -77, -66, -78, -68, -76, -66, -74, -66, -71, -65, -67, -64, -63, -65,
-62, -70, -63, -75, -68, -78, -70, -79, -73, -79, -75, -79, -74, -76, -70, -74,
-66, -71, -59, -69, -54, -67, -49, -68, -47, -69, -46, -71, -48, -74, -49, -79,
-51, -86, -53, -92, -54, -94, -54, -97, -53, -98, -49, -97, -45, -93, -40, -93,
-35, -86, -33, -86, -31, -82, -28, -81, -22, -72, -13, -71, -4, -51, };