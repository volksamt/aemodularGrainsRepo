#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0176

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 50, 3, 59, 7, 52, 10, 54, 12, 49,
14, 51, 17, 46, 20, 47, 20, 41, 23, 42, 27, 37, 29, 36, 30, 32, 32, 30, 35, 26,
37, 24, 39, 20, 40, 17, 42, 13, 45, 10, 46, 6, 48, 4, 50, 0, 51, -3, 53, -6, 55,
-10, 57, -13, 58, -16, 60, -19, 61, -23, 62, -25, 64, -29, 65, -31, 67, -35, 68,
-37, 69, -40, 70, -43, 72, -45, 72, -47, 73, -50, 75, -52, 75, -55, 75, -58, 75,
-58, 76, -62, 76, -64, 76, -65, 76, -67, 76, -69, 75, -71, 74, -72, 74, -74, 73,
-74, 72, -76, 71, -77, 71, -78, 70, -78, 69, -79, 67, -80, 67, -82, 65, -82, 65,
-83, 64, -83, 63, -84, 63, -84, 61, -84, 60, -85, 59, -86, 59, -87, 58, -87, 57,
-87, 56, -87, 55, -87, 55, -88, 54, -87, 53, -88, 53, -87, 52, -87, 52, -86, 50,
-86, 50, -85, 48, -84, 48, -83, 48, -81, 45, -80, 45, -80, 44, -78, 43, -76, 42,
-73, 41, -71, 39, -68, 39, -67, 38, -64, 35, -61, 35, -58, 34, -54, 32, -52, 32,
-49, 29, -46, 28, -42, 27, -39, 26, -38, 25, -34, 24, -31, 22, -30, 21, -28, 21,
-25, 18, -22, 17, -18, 16, -15, 15, -12, 14, -9, 14, -6, 13, -3, 11, -1, 10, 2,
9, 4, 9, 8, 8, 9, 7, 11, 6, 14, 5, 16, 5, 18, 5, 21, 4, 23, 3, 25, 2, 27, 1, 28,
1, 31, 0, 33, 0, 35, -1, 37, -2, 39, -2, 40, -3, 41, -4, 42, -5, 44, -6, 45, -8,
46, -9, 46, -9, 48, -12, 49, -13, 49, -14, 49, -16, 51, -19, 51, -20, 51, -21,
52, -23, 52, -24, 52, -27, 54, -28, 54, -30, 54, -32, 53, -33, 53, -35, 54, -35,
53, -38, 52, -39, 53, -39, 52, -40, 52, -41, 51, -44, 51, -44, 51, -46, 51, -47,
49, -48, 49, -49, 49, -49, 48, -50, 45, -51, 45, -51, 44, -51, 42, -52, 41, -52,
41, -52, 38, -52, 37, -52, 35, -53, 34, -51, 33, -51, 32, -51, 30, -50, 30, -51,
29, -50, 28, -49, 27, -48, 26, -47, 25, -48, 24, -46, 23, -45, 21, -45, 20, -44,
19, -43, 17, -43, 17, -42, 15, -42, 13, -42, 12, -41, 11, -41, 9, -41, 7, -40,
7, -40, 5, -39, 4, -39, 2, -39, 1, -38, -1, -37, -2, -37, -3, -35, -3, -34, -6,
-32, -6, -32, -7, -29, -8, -27, -9, -27, -9, -23, -10, -22, -10, -20, -10, -17,
-11, -14, -11, -12, -11, -9, -11, -8, -12, -5, -11, -1, -11, 1, -10, 4, -11, 7,
-10, 10, -10, 12, -10, 15, -10, 17, -10, 19, -9, 22, -9, 24, -8, 27, -7, 30, -7,
31, -7, 33, -7, 35, -5, 36, -6, 37, -5, 38, -5, 40, -4, 41, -5, 42, -5, 42, -5,
44, -6, 44, -6, 46, -6, 46, -6, 46, -7, 48, -7, 47, -8, 47, -8, 48, -8, 48, -8,
48, -10, 49, -9, 48, -10, 48, -10, 49, -10, 49, -10, 49, -11, 49, -10, 49, -11,
48, -10, 49, -10, 48, -9, 49, -8, 48, -8, 48, -7, 47, -6, 47, -6, 47, -4, 47,
-3, 46, -3, 45, -2, 44, -2, 43, -1, 43, 0, 42, 0, 41, -1, 39, 0, 37, 0, 34, 1,
34, 0, 30, 0, 29, 0, 26, -1, 23, -2, 21, -3, 18, -5, 15, -6, 10, -8, 8, -10, 4,
-11, 0, -13, -4, -16, -8, -18, -12, -20, -17, -22, -21, -25, -25, -26, -30, -29,
-35, -31, -38, -33, -42, -36, -46, -38, -51, -40, -55, -42, -58, -46, -62, -47,
-64, -50, -68, -53, -72, -54, -74, -56, -77, -57, -80, -59, -83, -61, -84, -62,
-88, -63, -89, -65, -91, -65, -93, -66, -95, -68, -96, -69, -98, -69, -100, -70,
-101, -71, -102, -71, -104, -72, -105, -72, -106, -73, -107, -73, -108, -73,
-110, -75, -111, -75, -112, -77, -113, -77, -113, -78, -114, -79, -115, -81,
-116, -82, -117, -83, -117, -85, -118, -87, -119, -88, -119, -90, -118, -91,
-119, -92, -119, -93, -118, -95, -118, -97, -118, -98, -117, -99, -116, -100,
-115, -100, -113, -101, -111, -101, -108, -100, -107, -99, -104, -99, -100, -98,
-98, -98, -95, -96, -91, -95, -87, -93, -84, -92, -79, -91, -75, -88, -70, -86,
-66, -84, -62, -81, -56, -79, -52, -77, -47, -74, -43, -71, -38, -69, -33, -65,
-30, -63, -25, -60, -21, -57, -18, -56, -15, -54, -10, -51, -6, -48, -3, -44, 1,
-42, 6, -39, 8, -37, 12, -33, 15, -31, 17, -28, 21, -27, 24, -24, 27, -22, 30,
-20, 33, -17, 35, -15, 39, -13, 41, -11, 44, -9, 46, -6, 49, -5, 52, -2, 53, 1,
56, 3, 58, 6, 61, 9, 64, 11, 66, 14, 67, 17, 69, 21, 71, 23, 73, 27, 75, 30, 76,
33, 76, 37, 77, 40, 78, 43, 78, 46, 79, 50, 79, 53, 78, 56, 78, 59, 78, 63, 76,
65, 76, 67, 75, 70, 74, 72, 72, 74, 70, 77, 69, 78, 66, 81, 65, 82, 63, 82, 60,
83, 58, 85, 55, 86, 53, 87, 50, 88, 49, 89, 46, 90, 43, 92, 40, 92, 37, 94, 34,
94, 31, 95, 28, 96, 25, 96, 22, 97, 19, 97, 16, 98, 13, 100, 10, 100, 7, 100, 3,
100, 1, 101, -3, 102, -4, 102, -7, 103, -9, 104, -11, 104, -14, 105, -16, 105,
-18, 105, -20, 106, -21, 106, -22, 107, -24, 106, -25, 105, -27, 106, -29, 105,
-30, 105, -30, 104, -31, 104, -32, 103, -33, 103, -34, 102, -34, 101, -36, 101,
-36, 100, -36, 99, -37, 97, -37, 95, -37, 94, -38, 93, -38, 91, -38, 90, -38,
89, -37, 88, -36, 85, -37, 85, -36, 83, -34, 82, -33, 80, -32, 78, -30, 77, -29,
77, -27, 73, -25, 73, -22, 70, -20, 70, -17, 66, -14, 68, -13, 63, -9, 66, -7,
59, -4, 64, 0, 51, };