#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0026

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 98, 6, 117, 11, 109, 16, 114, 22,
108, 27, 111, 33, 105, 38, 105, 42, 97, 47, 95, 51, 88, 56, 86, 59, 80, 62, 78,
64, 74, 67, 75, 69, 75, 70, 76, 73, 76, 75, 76, 76, 73, 76, 70, 78, 65, 78, 59,
81, 53, 84, 45, 86, 39, 90, 32, 92, 26, 95, 21, 97, 18, 98, 16, 99, 13, 99, 13,
98, 10, 97, 7, 95, 3, 94, -2, 91, -6, 88, -12, 87, -18, 86, -24, 84, -30, 85,
-38, 85, -45, 85, -52, 86, -58, 86, -63, 86, -68, 88, -73, 89, -77, 91, -80, 92,
-82, 94, -83, 94, -85, 94, -85, 94, -84, 92, -84, 92, -81, 91, -79, 91, -77, 89,
-73, 88, -69, 87, -67, 84, -63, 81, -59, 76, -57, 68, -55, 62, -52, 54, -50, 47,
-49, 41, -49, 35, -48, 29, -48, 23, -47, 16, -46, 12, -47, 5, -47, -1, -48, -7,
-49, -14, -50, -21, -49, -27, -48, -35, -47, -42, -44, -49, -41, -57, -37, -65,
-35, -73, -31, -79, -29, -84, -26, -91, -24, -97, -22, -103, -19, -107, -16,
-109, -11, -112, -5, -114, 0, -114, 6, -115, 13, -115, 21, -116, 29, -115, 37,
-116, 46, -117, 56, -118, 65, -119, 72, -119, 80, -119, 84, -117, 86, -115, 86,
-112, 84, -109, 82, -106, 79, -102, 76, -98, 71, -95, 68, -91, 63, -88, 59, -84,
55, -81, 52, -77, 48, -75, 48, -71, 46, -68, 48, -63, 48, -61, 49, -58, 50, -53,
49, -50, 50, -47, 50, -42, 49, -39, 49, -35, 48, -32, 48, -29, 47, -25, 48, -22,
48, -19, 49, -16, 51, -13, 53, -11, 55, -10, 59, -9, 62, -8, 66, -7, 67, -7, 69,
-7, 71, -6, 70, -6, 69, -5, 68, -2, 66, 1, 65, 5, 65, 11, 66, 16, 66, 23, 69,
29, 72, 35, 73, 41, 75, 46, 76, 51, 76, 56, 75, 60, 72, 65, 69, 67, 62, 71, 54,
75, 45, 77, 35, 80, 24, 82, 12, 84, 4, 87, -5, 88, -13, 87, -19, 90, -24, 90,
-29, 90, -33, 90, -34, 90, -35, 90, -36, 89, -36, 89, -38, 87, -38, 85, -38, 81,
-41, 77, -42, 72, -43, 68, -44, 63, -44, 58, -43, 53, -42, 49, -40, 43, -40, 38,
-38, 33, -38, 28, -40, 23, -40, 18, -42, 15, -45, 13, -48, 10, -51, 6, -55, 4,
-58, 3, -61, 1, -64, 1, -68, 0, -70, -2, -72, -4, -73, -8, -74, -10, -72, -15,
-71, -18, -70, -22, -71, -25, -70, -28, -71, -30, -73, -32, -74, -33, -76, -33,
-79, -33, -82, -31, -86, -30, -88, -26, -91, -24, -92, -22, -92, -19, -90, -17,
-88, -17, -84, -16, -80, -16, -76, -16, -71, -17, -68, -19, -64, -18, -63, -19,
-63, -19, -64, -19, -65, -18, -66, -17, -70, -15, -72, -12, -73, -11, -74, -9,
-74, -7, -74, -4, -74, -2, -72, 1, -71, 4, -68, 8, -68, 10, -67, 12, -65, 14,
-65, 15, -65, 17, -63, 20, -62, 21, -60, 25, -57, 28, -53, 31, -50, 34, -47, 37,
-42, 40, -38, 45, -33, 48, -27, 53, -21, 58, -16, 64, -9, 69, -3, 74, 3, 78, 10,
81, 16, 84, 23, 86, 27, 87, 31, 87, 34, 89, 36, 89, 39, 88, 41, 88, 44, 86, 46,
84, 48, 81, 49, 79, 50, 76, 51, 73, 53, 69, 55, 68, 55, 66, 56, 65, 59, 65, 59,
64, 61, 63, 61, 63, 62, 63, 62, 63, 61, 63, 60, 63, 58, 63, 58, 63, 56, 63, 56,
63, 56, 62, 56, 62, 56, 61, 56, 60, 59, 59, 59, 57, 58, 55, 58, 52, 57, 50, 56,
46, 56, 43, 58, 41, 62, 39, 67, 36, 73, 34, 80, 34, 86, 33, 93, 34, 98, 33, 103,
32, 106, 30, 107, 27, 109, 25, 107, 21, 105, 17, 102, 13, 99, 8, 93, 2, 89, -4,
83, -10, 80, -16, 75, -23, 70, -30, 65, -36, 59, -41, 50, -47, 40, -52, 34, -56,
26, -59, 22, -64, 19, -68, 16, -70, 14, -74, 14, -77, 15, -81, 14, -83, 17, -87,
20, -89, 22, -92, 25, -95, 28, -97, 31, -98, 33, -99, 35, -100, 37, -101, 38,
-101, 39, -101, 40, -103, 39, -103, 38, -102, 36, -102, 32, -101, 30, -100, 28,
-99, 23, -97, 18, -94, 12, -92, 8, -90, 3, -87, 1, -84, -2, -80, -2, -77, -1,
-73, 0, -69, 1, -65, 0, -61, -2, -57, -5, -52, -10, -46, -14, -42, -20, -36,
-25, -31, -30, -27, -35, -24, -40, -21, -44, -19, -48, -16, -51, -13, -54, -10,
-55, -8, -58, -5, -59, -1, -61, 4, -61, 6, -60, 9, -60, 11, -58, 14, -57, 16,
-54, 18, -52, 21, -50, 22, -49, 22, -48, 23, -47, 23, -47, 23, -48, 23, -49, 24,
-49, 24, -50, 25, -51, 25, -53, 26, -52, 27, -52, 29, -53, 30, -54, 32, -58, 33,
-61, 35, -67, 36, -71, 38, -77, 40, -82, 41, -88, 42, -92, 43, -95, 44, -98, 43,
-102, 42, -103, 41, -105, 38, -107, 35, -108, 32, -110, 30, -110, 26, -111, 22,
-112, 16, -113, 11, -113, 4, -114, -3, -116, -8, -118, -12, -118, -17, -119,
-21, -118, -25, -114, -28, -110, -31, -105, -34, -100, -39, -94, -41, -89, -46,
-84, -49, -80, -54, -77, -59, -73, -62, -70, -67, -66, -71, -62, -74, -58, -78,
-53, -80, -48, -82, -45, -84, -41, -85, -38, -84, -36, -85, -34, -85, -33, -86,
-30, -85, -29, -85, -26, -85, -22, -85, -20, -84, -15, -85, -11, -85, -5, -86,
-1, -86, 5, -86, 10, -86, 18, -86, 24, -84, 32, -82, 38, -81, 46, -77, 53, -75,
60, -72, 66, -69, 73, -66, 77, -63, 81, -61, 85, -58, 89, -56, 92, -56, 95, -54,
97, -54, 98, -53, 99, -51, 99, -52, 101, -52, 101, -52, 102, -52, 100, -48, 102,
-45, 100, -39, 103, -32, 101, -28, 106, -22, 103, -20, 109, -16, 105, -14, 113,
-11, 106, -6, 119, -2, 95, };