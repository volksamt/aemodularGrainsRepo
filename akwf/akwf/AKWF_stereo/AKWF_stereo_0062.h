#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0062

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 39, 1, 49, 3, 46, 5, 49, 5, 49, 7,
53, 8, 52, 10, 54, 11, 55, 13, 57, 15, 56, 15, 59, 17, 59, 19, 60, 20, 61, 21,
63, 23, 64, 24, 65, 26, 65, 27, 67, 29, 68, 31, 69, 32, 71, 34, 71, 35, 73, 37,
73, 38, 74, 41, 75, 41, 76, 43, 77, 45, 78, 47, 79, 49, 80, 50, 81, 52, 82, 53,
83, 55, 84, 57, 84, 59, 85, 60, 86, 62, 87, 63, 88, 65, 89, 66, 91, 68, 92, 70,
91, 71, 93, 74, 94, 75, 95, 77, 95, 78, 96, 79, 98, 82, 98, 83, 99, 84, 99, 86,
100, 87, 101, 88, 102, 90, 103, 91, 104, 93, 105, 94, 104, 95, 105, 96, 107, 98,
106, 99, 108, 100, 109, 101, 108, 103, 109, 104, 110, 104, 110, 105, 111, 107,
112, 108, 112, 108, 113, 110, 113, 110, 114, 111, 115, 111, 114, 112, 116, 114,
115, 114, 115, 114, 116, 115, 116, 116, 117, 116, 117, 117, 118, 117, 118, 117,
118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 119, 118, 119, 119, 119, 118,
119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119, 118, 119, 118, 118, 117,
120, 117, 119, 116, 119, 116, 119, 116, 118, 115, 118, 115, 118, 113, 118, 113,
117, 112, 117, 112, 117, 111, 117, 110, 117, 109, 116, 109, 115, 107, 116, 107,
114, 105, 115, 104, 114, 103, 114, 102, 114, 102, 112, 101, 112, 98, 112, 97,
111, 97, 110, 95, 110, 94, 110, 93, 110, 91, 109, 89, 108, 88, 108, 86, 107, 86,
106, 84, 106, 82, 106, 80, 105, 80, 104, 78, 104, 76, 103, 75, 102, 73, 102, 72,
100, 70, 100, 68, 99, 67, 97, 65, 98, 63, 97, 63, 96, 60, 96, 59, 94, 57, 93,
56, 93, 55, 92, 52, 91, 51, 90, 49, 90, 47, 88, 46, 87, 45, 86, 43, 86, 41, 85,
40, 85, 37, 83, 36, 81, 35, 81, 33, 79, 32, 78, 30, 79, 28, 77, 28, 76, 26, 75,
24, 74, 23, 72, 21, 72, 20, 70, 19, 69, 17, 68, 15, 66, 15, 65, 14, 64, 12, 63,
10, 62, 10, 59, 8, 59, 7, 57, 7, 55, 6, 54, 3, 51, 2, 50, 2, 47, 1, 46, 0, 43,
-1, 40, -1, 37, 0, 32, -2, 30, 6, 8, 12, -10, 11, -12, 12, -18, 11, -19, 11,
-24, 11, -26, 10, -28, 9, -30, 8, -33, 7, -34, 5, -36, 5, -37, 4, -39, 2, -40,
1, -41, 0, -43, -1, -44, -3, -45, -3, -47, -5, -49, -6, -49, -7, -51, -8, -52,
-10, -52, -11, -54, -12, -56, -13, -56, -15, -57, -17, -58, -17, -59, -19, -60,
-20, -62, -21, -61, -23, -63, -24, -64, -25, -65, -26, -66, -28, -66, -29, -68,
-30, -69, -31, -69, -32, -70, -33, -70, -35, -72, -35, -72, -37, -73, -37, -74,
-39, -74, -40, -75, -41, -76, -42, -76, -43, -78, -44, -78, -46, -79, -46, -80,
-47, -80, -48, -80, -49, -81, -51, -82, -51, -82, -51, -82, -53, -83, -53, -83,
-54, -83, -55, -84, -55, -84, -57, -85, -56, -85, -58, -86, -58, -86, -58, -86,
-59, -87, -60, -87, -60, -87, -61, -88, -61, -88, -61, -89, -62, -89, -62, -89,
-62, -89, -63, -89, -63, -89, -63, -89, -63, -89, -64, -89, -64, -90, -64, -90,
-64, -90, -64, -91, -64, -90, -64, -90, -64, -90, -64, -90, -64, -90, -64, -90,
-63, -89, -63, -90, -64, -90, -63, -91, -63, -90, -62, -90, -62, -90, -62, -91,
-62, -90, -61, -89, -60, -90, -61, -90, -60, -89, -60, -89, -59, -89, -59, -89,
-58, -89, -59, -89, -58, -89, -56, -88, -56, -89, -56, -88, -55, -88, -55, -87,
-54, -87, -55, -88, -54, -88, -53, -87, -52, -87, -52, -87, -52, -87, -52, -87,
-51, -87, -51, -87, -51, -86, -49, -86, -50, -86, -49, -86, -49, -85, -49, -86,
-48, -85, -48, -85, -48, -85, -47, -85, -47, -85, -46, -85, -46, -85, -46, -86,
-47, -85, -46, -86, -46, -85, -46, -85, -45, -85, -45, -86, -46, -84, -45, -85,
-46, -85, -46, -85, -46, -85, -46, -85, -46, -85, -46, -85, -46, -85, -47, -86,
-47, -85, -46, -86, -47, -85, -47, -86, -47, -86, -48, -87, -48, -87, -48, -87,
-48, -87, -49, -88, -49, -87, -49, -87, -50, -87, -50, -88, -51, -88, -51, -88,
-52, -88, -52, -88, -52, -88, -52, -89, -53, -90, -54, -89, -55, -89, -55, -89,
-55, -90, -55, -90, -56, -90, -57, -90, -57, -90, -57, -91, -58, -91, -58, -91,
-59, -91, -60, -91, -60, -91, -60, -91, -60, -91, -61, -92, -60, -91, -62, -91,
-61, -92, -62, -92, -62, -92, -62, -92, -62, -92, -63, -93, -63, -92, -64, -92,
-63, -91, -64, -92, -63, -92, -64, -93, -63, -92, -63, -92, -63, -92, -62, -92,
-63, -92, -63, -91, -63, -91, -62, -91, -62, -91, -63, -91, -63, -90, -62, -90,
-62, -90, -61, -90, -61, -90, -60, -90, -60, -89, -60, -89, -59, -88, -59, -88,
-58, -88, -58, -88, -58, -87, -57, -87, -56, -87, -56, -86, -55, -87, -54, -86,
-53, -86, -53, -85, -51, -84, -50, -84, -50, -84, -48, -83, -48, -83, -47, -82,
-46, -82, -45, -81, -44, -81, -43, -80, -42, -79, -41, -79, -40, -78, -38, -78,
-39, -77, -37, -77, -35, -76, -35, -76, -33, -75, -33, -74, -31, -74, -31, -73,
-30, -72, -27, -71, -27, -70, -27, -70, -25, -70, -23, -68, -23, -68, -21, -67,
-20, -66, -19, -65, -18, -65, -16, -62, -15, -62, -15, -61, -12, -60, -12, -59,
-11, -58, -10, -57, -8, -55, -8, -54, -6, -53, -5, -52, -5, -51, -3, -48, -2,
-45, -2, -41, 0, -38, 1, -34, 1, -30, 2, -27, 1, -22, 2, -20, -6, -2, -11, 14,
-11, 16, -11, 22, -11, 22, -10, 28, -9, 28, -9, 33, -7, 32, -7, 36, -6, 36, -5,
39, -4, 38, -2, 44, -2, 36, };