#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0163

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 40, 2, 48, 3, 46, 4, 48, 6, 44, 7,
47, 9, 45, 11, 47, 11, 46, 13, 49, 14, 48, 16, 51, 17, 50, 19, 53, 21, 52, 22,
56, 24, 56, 25, 57, 28, 59, 29, 59, 30, 61, 31, 63, 34, 64, 35, 65, 37, 67, 38,
68, 39, 69, 41, 71, 42, 71, 44, 73, 45, 73, 47, 72, 47, 68, 48, 63, 50, 58, 49,
53, 52, 49, 52, 48, 53, 48, 55, 47, 56, 48, 58, 48, 60, 48, 60, 49, 62, 51, 64,
51, 65, 53, 66, 55, 68, 56, 70, 57, 71, 58, 73, 59, 74, 61, 76, 61, 77, 63, 78,
65, 80, 67, 82, 68, 84, 69, 85, 69, 86, 71, 87, 71, 88, 70, 90, 70, 91, 70, 93,
70, 93, 71, 95, 71, 96, 72, 98, 73, 99, 74, 98, 76, 97, 77, 94, 77, 92, 79, 90,
80, 88, 82, 88, 83, 89, 84, 89, 85, 89, 86, 91, 88, 92, 89, 93, 90, 94, 92, 96,
93, 97, 94, 98, 95, 100, 94, 101, 94, 102, 93, 104, 93, 104, 93, 106, 94, 108,
95, 110, 96, 110, 96, 112, 97, 113, 97, 115, 99, 116, 100, 118, 100, 118, 102,
115, 98, 74, 64, -6, -4, -66, -54, -76, -65, -63, -56, -52, -47, -51, -46, -53,
-47, -53, -48, -53, -48, -51, -46, -49, -45, -48, -44, -47, -43, -46, -42, -45,
-41, -44, -41, -42, -40, -41, -38, -39, -38, -38, -37, -36, -35, -35, -35, -34,
-35, -32, -33, -31, -32, -30, -31, -27, -30, -27, -29, -24, -27, -23, -26, -22,
-25, -20, -23, -19, -22, -16, -21, -16, -19, -15, -18, -17, -17, -20, -15, -20,
-15, -21, -13, -21, -12, -20, -11, -21, -9, -23, -9, -24, -7, -24, -6, -23, -5,
-23, -4, -22, -2, -20, -1, -19, 1, -17, -2, -17, -31, -20, -78, -20, -107, -18,
-111, -16, -105, -15, -99, -14, -98, -13, -99, -12, -100, -13, -99, -14, -98,
-16, -97, -18, -96, -20, -96, -21, -95, -21, -94, -20, -93, -19, -93, -19, -92,
-18, -91, -16, -91, -15, -89, -14, -88, -12, -87, -11, -87, -10, -85, -9, -84,
-7, -84, -6, -83, -5, -81, -4, -79, -3, -79, 0, -78, 1, -78, 1, -80, 4, -79, 5,
-79, 6, -78, 8, -78, 10, -77, 10, -76, 12, -75, 13, -74, 14, -73, 17, -71, 17,
-71, 18, -69, 18, -68, 17, -67, 16, -67, 14, -64, 12, -63, 10, -61, 10, -61, 9,
-59, 10, -59, 10, -56, 11, -55, 13, -55, 13, -53, 15, -52, 16, -51, 17, -49, 19,
-48, 21, -47, 21, -46, 23, -45, 22, -44, 22, -43, 20, -41, 20, -40, 19, -39, 20,
-38, 22, -36, 22, -35, 23, -34, 24, -32, 25, -31, 26, -31, 28, -29, 29, -28, 30,
-26, 21, -25, -23, -25, -77, -22, -104, -22, -104, -21, -94, -19, -90, -19, -90,
-18, -93, -16, -92, -15, -91, -15, -89, -13, -90, -12, -89, -11, -88, -9, -86,
-9, -85, -8, -85, -6, -84, -5, -83, -4, -83, -3, -81, -3, -80, -1, -79, 0, -79,
1, -77, 2, -77, 3, -75, 4, -74, 5, -72, 6, -71, 7, -69, 7, -69, 9, -68, 11, -66,
12, -65, 12, -64, 11, -63, 10, -62, 9, -60, 9, -59, 9, -59, 9, -58, 10, -56, 10,
-55, 11, -54, 12, -52, 13, -51, 14, -49, 14, -48, 15, -47, 16, -46, 17, -44, 17,
-43, 18, -42, 19, -40, 19, -39, 21, -38, 22, -37, 23, -34, 24, -34, 24, -33, 25,
-31, 26, -30, 27, -27, 28, -27, 29, -25, 30, -24, 28, -23, 27, -22, 27, -21, 26,
-22, 26, -25, 27, -26, 28, -26, 28, -27, 29, -26, 30, -25, 29, -24, 30, -24, 31,
-22, 32, -21, 33, -20, 34, -20, 35, -21, 36, -22, 37, -23, 37, -22, 38, -21, 39,
-21, 40, -20, 40, -20, 42, -18, 43, -17, 43, -17, 45, -16, 45, -14, 43, -15, 25,
-16, -12, -17, -39, -16, -45, -15, -38, -13, -34, -12, -33, -12, -35, -10, -34,
-10, -35, -8, -35, -7, -36, -5, -37, -5, -38, -4, -38, -3, -39, -1, -39, 0, -37,
1, -38, 2, -37, 2, -36, -2, -35, -6, -35, -8, -34, -11, -33, -12, -33, -11, -32,
-12, -31, -11, -29, -11, -29, -11, -28, -9, -27, -9, -27, -9, -27, -7, -28, -6,
-29, -5, -30, -4, -29, -3, -30, -2, -29, -1, -29, 1, -28, 2, -27, 3, -26, 4,
-26, 5, -25, 7, -25, 8, -23, 9, -23, 11, -22, 11, -21, 13, -20, 13, -20, 16,
-19, 16, -17, 17, -17, 18, -16, 20, -16, 21, -18, 21, -20, 23, -21, 24, -22, 26,
-22, 26, -21, 27, -21, 28, -20, 30, -19, 31, -18, 32, -19, 33, -16, 35, -16, 36,
-15, 37, -14, 38, -14, 39, -12, 38, -11, 35, -11, 32, -10, 28, -9, 25, -7, 24,
-6, 26, -5, 25, -4, 26, -3, 26, -2, 28, -2, 28, -1, 29, 1, 29, 1, 31, 2, 33, 3,
33, 4, 32, 5, 29, 6, 27, 7, 25, 9, 24, 9, 25, 10, 24, 12, 25, 12, 26, 14, 27,
14, 28, 14, 28, 16, 30, 17, 30, 17, 31, 18, 33, 18, 33, 20, 34, 21, 36, 22, 37,
22, 38, 23, 40, 23, 41, 23, 42, 21, 43, 20, 44, 20, 44, 20, 46, 20, 47, 21, 48,
21, 49, 22, 50, 23, 41, 24, 7, 23, -34, 24, -53, 25, -52, 25, -44, 26, -40, 26,
-40, 28, -42, 28, -41, 31, -40, 31, -39, 32, -39, 32, -38, 34, -37, 34, -35, 37,
-34, 37, -34, 39, -32, 40, -31, 41, -30, 42, -29, 43, -27, 44, -26, 46, -25, 47,
-24, 48, -22, 50, -20, 51, -19, 51, -18, 53, -16, 53, -16, 50, -15, 46, -14, 45,
-11, 44, -11, 44, -10, 44, -11, 41, -13, 39, -13, 37, -13, 37, -13, 36, -11, 37,
-11, 36, -11, 39, -9, 37, -8, 40, -7, 39, -4, 43, -4, 41, -1, 47, -1, 38, };