#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0199

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -11, 12, -5, 24, 6, 34, 14, 44, 22,
53, 31, 60, 38, 68, 46, 74, 52, 81, 57, 85, 63, 88, 67, 91, 71, 93, 75, 95, 77,
95, 79, 94, 81, 93, 81, 92, 82, 89, 82, 86, 82, 83, 79, 79, 79, 75, 77, 71, 75,
67, 73, 63, 71, 59, 69, 56, 66, 54, 64, 50, 61, 49, 61, 46, 58, 44, 56, 44, 55,
44, 53, 44, 53, 44, 52, 46, 51, 48, 51, 50, 50, 52, 51, 55, 51, 59, 52, 63, 53,
65, 54, 69, 55, 72, 55, 74, 57, 77, 58, 79, 58, 82, 60, 82, 61, 84, 61, 86, 61,
86, 62, 85, 62, 84, 61, 83, 62, 82, 61, 79, 60, 77, 59, 73, 58, 71, 57, 67, 56,
64, 54, 61, 53, 58, 51, 55, 50, 52, 49, 48, 48, 46, 46, 43, 46, 40, 45, 39, 43,
36, 42, 34, 41, 33, 41, 32, 41, 32, 40, 31, 40, 32, 41, 32, 41, 33, 42, 36, 43,
36, 43, 39, 43, 40, 44, 41, 44, 43, 46, 43, 46, 45, 45, 43, 46, 44, 45, 44, 45,
43, 44, 42, 43, 40, 43, 39, 41, 37, 40, 35, 38, 31, 37, 30, 36, 28, 32, 24, 31,
20, 29, 17, 27, 13, 23, 10, 21, 7, 19, 4, 17, 1, 14, -1, 12, -3, 9, -5, 8, -6,
6, -7, 4, -8, 2, -8, 0, -8, -1, -8, -2, -7, -4, -6, -4, -4, -5, -3, -6, -1, -7,
0, -7, 2, -8, 5, -7, 6, -8, 7, -9, 9, -8, 10, -8, 12, -8, 11, -9, 13, -9, 12,
-9, 10, -9, 10, -10, 9, -9, 7, -10, 5, -9, 3, -10, -1, -10, -3, -10, -6, -10,
-10, -10, -12, -11, -15, -10, -19, -10, -22, -10, -24, -9, -27, -8, -28, -7,
-30, -6, -31, -5, -33, -3, -33, -3, -32, -1, -32, 0, -31, 2, -29, 4, -28, 6,
-25, 7, -22, 9, -19, 11, -16, 12, -11, 14, -7, 16, -3, 17, 4, 20, 7, 21, 12, 21,
17, 22, 21, 23, 25, 21, 27, 21, 31, 20, 33, 19, 35, 18, 37, 16, 38, 13, 38, 12,
38, 9, 40, 7, 39, 4, 38, 1, 38, -2, 37, -4, 36, -8, 36, -10, 33, -12, 33, -14,
31, -17, 31, -18, 30, -19, 29, -20, 29, -21, 30, -21, 30, -21, 31, -21, 32, -20,
33, -20, 35, -18, 36, -16, 39, -14, 41, -12, 43, -11, 45, -10, 48, -7, 50, -5,
52, -2, 53, -2, 55, 0, 55, 2, 56, 3, 56, 4, 56, 4, 55, 3, 53, 4, 50, 3, 47, 1,
43, -1, 38, -2, 32, -4, 28, -7, 21, -11, 16, -13, 8, -17, 2, -20, -5, -24, -13,
-28, -20, -32, -26, -35, -33, -38, -39, -41, -44, -43, -49, -45, -52, -46, -56,
-48, -58, -48, -60, -49, -59, -48, -60, -46, -58, -44, -56, -41, -53, -37, -48,
-34, -44, -29, -37, -25, -32, -18, -25, -14, -16, -6, -8, 0, 1, 8, 10, 16, 19,
23, 28, 30, 37, 37, 44, 43, 51, 51, 57, 56, 63, 61, 67, 66, 70, 70, 73, 73, 76,
77, 77, 80, 76, 81, 77, 82, 74, 82, 72, 82, 69, 81, 65, 79, 62, 78, 56, 75, 51,
71, 45, 69, 38, 65, 32, 61, 25, 57, 19, 52, 12, 48, 6, 42, 1, 38, -5, 35, -9,
30, -13, 26, -17, 22, -20, 18, -22, 14, -24, 11, -25, 7, -26, 4, -25, 2, -25, 1,
-24, 0, -22, -2, -21, -3, -18, -5, -14, -5, -12, -5, -10, -5, -6, -6, -5, -6,
-3, -6, -1, -6, 1, -7, 2, -7, 5, -8, 5, -6, 4, -8, 4, -9, 4, -10, 2, -10, 1,
-12, -1, -12, -2, -14, -6, -16, -9, -18, -12, -19, -14, -20, -17, -22, -21, -23,
-23, -24, -26, -25, -28, -27, -30, -27, -32, -29, -33, -28, -34, -29, -34, -30,
-34, -30, -34, -30, -34, -29, -33, -29, -30, -28, -29, -27, -27, -25, -24, -23,
-20, -20, -17, -18, -13, -17, -10, -15, -7, -13, -3, -12, -1, -9, 2, -8, 3, -7,
5, -5, 5, -4, 6, -4, 6, -3, 7, -3, 6, -2, 6, -2, 6, -2, 5, -1, 4, -2, 2, -2, 0,
-2, -3, -3, -5, -4, -6, -5, -9, -7, -12, -7, -13, -8, -15, -9, -17, -10, -17,
-10, -18, -10, -19, -11, -20, -11, -19, -12, -19, -13, -18, -12, -17, -13, -15,
-12, -14, -12, -12, -12, -10, -11, -8, -10, -7, -10, -4, -10, -2, -8, -1, -7, 1,
-6, 2, -6, 3, -6, 3, -6, 4, -5, 4, -4, 2, -3, 1, -3, -1, -3, -3, -2, -6, -2, -8,
-3, -12, -2, -14, -1, -19, -2, -23, -1, -27, -3, -32, -2, -36, -3, -41, -2, -45,
-2, -49, -2, -52, -1, -56, -1, -59, 1, -61, 1, -63, 2, -66, 2, -67, 3, -67, 3,
-69, 4, -68, 5, -68, 6, -68, 7, -66, 7, -65, 8, -64, 8, -61, 9, -58, 10, -57,
10, -53, 10, -49, 9, -48, 9, -44, 8, -43, 7, -42, 5, -40, 2, -39, 0, -38, -4,
-39, -7, -40, -10, -39, -14, -40, -18, -42, -22, -43, -27, -45, -31, -47, -36,
-49, -40, -52, -44, -54, -49, -56, -52, -58, -56, -62, -61, -63, -63, -65, -66,
-67, -69, -68, -71, -69, -74, -70, -75, -70, -77, -70, -77, -69, -77, -68, -77,
-66, -77, -65, -77, -63, -76, -61, -76, -59, -75, -57, -73, -55, -72, -52, -71,
-50, -70, -47, -69, -47, -67, -45, -67, -44, -67, -44, -67, -43, -67, -44, -68,
-46, -67, -47, -69, -49, -71, -53, -72, -55, -74, -60, -77, -64, -80, -69, -82,
-74, -86, -79, -89, -84, -92, -89, -95, -95, -97, -100, -101, -104, -105, -108,
-106, -112, -109, -115, -110, -117, -112, -118, -111, -119, -112, -119, -111,
-117, -109, -116, -107, -112, -103, -109, -101, -104, -96, -98, -92, -91, -86,
-84, -80, -75, -72, -65, -67, -55, -58, -44, -49, -33, -39, -21, -32, -8, -18,
};