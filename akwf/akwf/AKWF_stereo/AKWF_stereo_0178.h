#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0178

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -1, 3, -1, 4, 0, 6, 1, 7, 0, 9, 2,
11, 3, 12, 3, 14, 3, 16, 5, 18, 5, 19, 6, 21, 7, 22, 7, 24, 8, 25, 10, 27, 10,
29, 11, 31, 12, 32, 13, 34, 14, 35, 15, 37, 16, 38, 18, 40, 18, 41, 19, 43, 20,
44, 22, 46, 22, 48, 24, 48, 25, 50, 27, 52, 27, 52, 30, 53, 31, 55, 32, 56, 34,
57, 35, 59, 36, 60, 36, 62, 38, 63, 40, 65, 41, 66, 43, 67, 44, 68, 47, 69, 47,
70, 48, 71, 51, 72, 52, 73, 54, 73, 55, 74, 56, 75, 59, 76, 60, 77, 61, 77, 63,
77, 64, 78, 65, 79, 66, 80, 68, 79, 71, 80, 72, 80, 73, 81, 76, 81, 76, 82, 78,
83, 79, 82, 80, 83, 82, 83, 84, 83, 85, 83, 87, 84, 88, 84, 89, 84, 91, 83, 91,
83, 93, 84, 94, 85, 96, 84, 97, 85, 98, 83, 100, 84, 101, 84, 102, 84, 103, 83,
103, 83, 105, 83, 106, 83, 107, 82, 108, 82, 109, 82, 110, 82, 110, 82, 111, 82,
112, 80, 113, 81, 114, 80, 114, 80, 114, 80, 115, 80, 116, 79, 117, 79, 116, 78,
117, 78, 117, 78, 118, 77, 118, 77, 119, 77, 118, 77, 119, 76, 119, 75, 119, 76,
119, 76, 119, 74, 119, 75, 118, 73, 118, 74, 118, 73, 118, 73, 118, 72, 117, 73,
117, 72, 116, 72, 116, 71, 115, 71, 115, 70, 114, 70, 114, 71, 112, 69, 111, 70,
110, 69, 110, 70, 108, 68, 108, 68, 107, 69, 106, 68, 106, 68, 105, 68, 104, 67,
103, 67, 101, 67, 99, 67, 98, 66, 97, 66, 95, 66, 93, 66, 92, 65, 90, 66, 89,
66, 88, 66, 86, 65, 84, 65, 82, 65, 80, 65, 79, 64, 76, 64, 75, 64, 72, 64, 70,
65, 68, 64, 66, 64, 65, 64, 63, 64, 60, 64, 57, 63, 56, 64, 54, 63, 51, 63, 50,
63, 47, 63, 46, 63, 43, 63, 41, 62, 39, 63, 37, 62, 35, 62, 33, 62, 30, 62, 27,
62, 25, 62, 24, 62, 21, 61, 19, 60, 18, 61, 15, 61, 13, 60, 10, 59, 9, 60, 7,
59, 4, 59, 2, 59, 1, 58, -2, 59, -4, 57, -6, 57, -7, 56, -9, 56, -11, 55, -13,
55, -15, 54, -17, 54, -20, 54, -21, 53, -22, 52, -24, 51, -26, 51, -28, 51, -29,
49, -32, 48, -33, 48, -33, 47, -36, 47, -37, 45, -40, 45, -40, 43, -42, 42, -43,
42, -44, 42, -46, 40, -47, 39, -48, 39, -50, 37, -51, 36, -52, 35, -53, 34, -54,
33, -54, 32, -56, 31, -57, 30, -58, 28, -59, 28, -60, 27, -61, 25, -61, 24, -63,
22, -64, 21, -64, 20, -65, 19, -66, 16, -66, 15, -67, 14, -68, 13, -68, 11, -70,
9, -69, 7, -70, 6, -70, 5, -71, 4, -72, 2, -71, 1, -73, 0, -72, -4, -72, -4,
-74, -6, -73, -8, -74, -9, -73, -11, -74, -12, -75, -13, -74, -16, -75, -17,
-75, -19, -75, -19, -75, -22, -75, -23, -76, -25, -76, -27, -75, -28, -76, -30,
-76, -31, -76, -34, -76, -35, -76, -36, -76, -38, -77, -41, -76, -42, -76, -43,
-77, -46, -77, -46, -76, -48, -77, -51, -76, -51, -77, -52, -77, -54, -77, -57,
-77, -58, -77, -59, -78, -60, -77, -62, -77, -63, -77, -65, -77, -67, -77, -67,
-77, -70, -77, -70, -77, -71, -77, -73, -78, -75, -77, -75, -77, -77, -77, -79,
-77, -79, -78, -81, -78, -82, -78, -83, -78, -83, -77, -85, -78, -86, -78, -87,
-78, -88, -78, -89, -77, -89, -78, -90, -78, -92, -78, -92, -78, -93, -79, -94,
-78, -93, -78, -95, -78, -95, -78, -96, -77, -96, -78, -97, -78, -97, -77, -98,
-78, -98, -78, -99, -78, -99, -78, -99, -77, -100, -78, -100, -78, -100, -77,
-99, -77, -99, -76, -100, -77, -100, -76, -100, -76, -100, -76, -100, -75, -99,
-75, -99, -74, -99, -73, -99, -74, -98, -74, -98, -73, -99, -72, -98, -71, -98,
-71, -96, -69, -97, -70, -96, -69, -95, -68, -94, -68, -94, -68, -93, -67, -92,
-66, -92, -65, -91, -65, -90, -64, -90, -64, -88, -63, -87, -62, -88, -61, -86,
-60, -85, -60, -84, -59, -84, -58, -82, -57, -82, -57, -80, -56, -80, -55, -78,
-53, -78, -51, -76, -51, -75, -50, -75, -50, -73, -48, -72, -47, -72, -46, -70,
-45, -70, -44, -68, -43, -68, -41, -66, -42, -65, -40, -64, -40, -63, -38, -62,
-36, -60, -36, -60, -35, -58, -34, -58, -33, -57, -31, -57, -30, -55, -30, -55,
-28, -53, -28, -54, -26, -52, -24, -51, -25, -51, -23, -49, -22, -49, -22, -49,
-20, -48, -19, -47, -18, -47, -17, -45, -16, -45, -15, -44, -15, -45, -15, -44,
-13, -43, -12, -42, -10, -41, -10, -41, -8, -39, -7, -38, -7, -39, -5, -38, -4,
-39, -4, -39, -3, -38, -3, -38, -3, -38, -3, -39, -2, -38, -2, -38, -1, -37, -1,
-38, -1, -39, -1, -38, 0, -39, 0, -38, 1, -38, 0, -39, 0, -38, 1, -39, 1, -38,
1, -39, 1, -39, 1, -39, 2, -39, 2, -39, 1, -39, 2, -39, 2, -39, 2, -40, 2, -40,
1, -40, 1, -40, 1, -40, 1, -40, 1, -41, 1, -40, 2, -41, 2, -40, 1, -40, 1, -40,
0, -40, 1, -39, 0, -40, -1, -40, 0, -40, 0, -39, 0, -40, -1, -39, 0, -39, 0,
-39, 0, -39, 0, -38, 0, -38, -1, -38, -1, -37, -2, -36, -1, -36, -1, -35, -2,
-35, -2, -35, -3, -34, -3, -33, -3, -33, -3, -31, -3, -30, -4, -31, -4, -29, -4,
-29, -5, -28, -5, -27, -5, -26, -5, -24, -5, -23, -4, -23, -5, -21, -4, -21, -5,
-20, -5, -18, -5, -18, -4, -15, -4, -15, -4, -14, -4, -12, -4, -11, -3, -10, -3,
-8, -3, -6, -3, -5, -2, -4, -2, -2, -2, -1, -1, };