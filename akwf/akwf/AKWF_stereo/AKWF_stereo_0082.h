#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0082

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 1, 5, 1, 6, 1, 7, 2, 7, 2, 8, 2,
8, 3, 9, 3, 7, 2, 9, 3, 8, 4, 8, 5, 8, 5, 9, 5, 10, 5, 11, 6, 11, 7, 12, 6, 11,
7, 12, 7, 13, 7, 13, 8, 14, 9, 14, 9, 13, 10, 13, 9, 13, 10, 14, 11, 15, 11, 15,
11, 16, 11, 16, 11, 16, 12, 16, 13, 17, 12, 17, 12, 17, 13, 17, 13, 18, 12, 17,
13, 18, 13, 18, 14, 18, 14, 18, 15, 19, 14, 19, 15, 19, 14, 21, 12, 21, 16, 20,
17, 20, 16, 20, 17, 21, 18, 21, 17, 20, 18, 21, 18, 21, 17, 22, 18, 22, 17, 22,
18, 22, 18, 22, 18, 23, 18, 23, 18, 23, 19, 24, 18, 23, 18, 24, 18, 24, 18, 24,
18, 24, 18, 24, 18, 24, 18, 25, 18, 25, 18, 24, 19, 25, 19, 25, 18, 25, 19, 25,
19, 25, 19, 26, 19, 25, 19, 26, 19, 25, 19, 27, 20, 26, 19, 26, 20, 26, 19, 26,
19, 27, 20, 27, 19, 27, 19, 28, 20, 27, 20, 28, 19, 28, 20, 27, 20, 28, 20, 28,
20, 28, 20, 28, 20, 28, 20, 28, 17, 29, 16, 29, 17, 29, 18, 29, 18, 29, 19, 30,
20, 28, 20, 30, 20, 30, 20, 29, 21, 30, 20, 30, 22, 30, 21, 30, 21, 29, 21, 30,
22, 30, 22, 30, 21, 30, 22, 30, 22, 30, 23, 30, 23, 30, 22, 31, 23, 31, 23, 31,
24, 30, 23, 31, 22, 31, 23, 31, 23, 32, 23, 32, 24, 31, 24, 32, 24, 31, 24, 32,
24, 31, 24, 31, 24, 31, 24, 32, 24, 32, 24, 32, 24, 33, 25, 32, 25, 32, 25, 33,
25, 32, 24, 33, 25, 33, 26, 33, 24, 32, 25, 33, 23, 33, 26, 32, 23, 33, 29, 32,
5, 35, 12, 34, 30, 32, 25, 33, 31, 31, 27, 33, 30, 33, 28, 33, 30, 33, 28, 33,
29, 32, 29, 33, 29, 32, 27, 33, 27, 32, 27, 33, 27, 33, 27, 33, 27, 33, 27, 33,
27, 33, 27, 34, 26, 34, 27, 33, 25, 34, 26, 34, 25, 34, 26, 33, 25, 34, 25, 34,
26, 34, 26, 34, 25, 34, 25, 33, 25, 34, 25, 33, 26, 35, 25, 33, 25, 34, 24, 34,
24, 34, 25, 34, 25, 34, 25, 34, 25, 33, 25, 34, 25, 33, 25, 34, 25, 34, 26, 35,
25, 34, 26, 34, 24, 33, 26, 35, 23, 32, 28, 37, 16, 27, -9, 4, -6, 5, -7, 4, -5,
5, -5, 4, -5, 2, -4, 0, -3, -2, -2, -4, -3, -6, -2, -7, -3, -8, -3, -8, -2, -8,
-2, -7, -8, -14, -3, -7, -2, -5, -1, -5, -2, -6, -2, -7, -1, -9, -2, -10, -2,
-11, -3, -13, -3, -12, -5, -13, -4, -14, -5, -13, -5, -12, -6, -13, -6, -12, -6,
-13, -6, -13, -6, -14, -5, -14, -7, -14, -6, -14, -7, -14, -7, -15, -7, -15, -8,
-15, -8, -15, -8, -15, -8, -16, -9, -16, -10, -15, -9, -16, -9, -16, -10, -17,
-11, -16, -11, -17, -11, -17, -11, -17, -12, -17, -12, -17, -13, -18, -13, -17,
-13, -17, -13, -18, -14, -18, -15, -18, -14, -18, -15, -18, -15, -18, -14, -19,
-16, -18, -15, -19, -15, -19, -15, -20, -16, -19, -16, -20, -16, -20, -17, -20,
-16, -20, -17, -20, -17, -20, -18, -20, -17, -20, -16, -21, -17, -20, -18, -20,
-17, -21, -17, -20, -17, -21, -17, -21, -17, -21, -19, -21, -19, -21, -18, -20,
-18, -21, -18, -21, -18, -22, -18, -21, -18, -21, -17, -21, -17, -21, -16, -22,
-18, -21, -17, -22, -17, -22, -16, -22, -17, -22, -16, -22, -17, -22, -16, -22,
-16, -22, -16, -22, -16, -23, -16, -22, -16, -22, -16, -23, -16, -23, -16, -22,
-15, -22, -16, -23, -16, -23, -16, -23, -16, -23, -16, -22, -16, -23, -16, -23,
-16, -23, -16, -23, -16, -23, -16, -23, -16, -23, -16, -23, -17, -24, -16, -24,
-17, -23, -16, -23, -17, -24, -17, -23, -17, -24, -16, -24, -17, -24, -17, -24,
-17, -24, -16, -23, -18, -24, -17, -25, -18, -24, -27, -23, -18, -24, -17, -24,
-16, -25, -17, -25, -17, -25, -16, -24, -17, -25, -16, -24, -17, -25, -17, -25,
-17, -24, -17, -25, -18, -25, -18, -25, -18, -25, -17, -25, -18, -25, -18, -25,
-19, -26, -18, -25, -19, -25, -19, -25, -19, -25, -19, -25, -19, -25, -19, -25,
-19, -25, -19, -25, -19, -26, -20, -25, -19, -25, -20, -25, -20, -26, -20, -25,
-20, -26, -19, -25, -20, -26, -19, -26, -20, -26, -20, -25, -20, -25, -20, -26,
-20, -26, -20, -26, -20, -26, -19, -26, -20, -26, -20, -27, -20, -26, -20, -26,
-20, -25, -20, -25, -19, -26, -21, -27, -20, -26, -26, -25, -30, -24, -27, -25,
-27, -26, -25, -25, -24, -25, -24, -25, -22, -25, -23, -26, -22, -26, -21, -25,
-21, -26, -19, -26, -20, -26, -20, -26, -20, -26, -19, -26, -19, -26, -19, -25,
-19, -26, -18, -26, -18, -26, -18, -26, -18, -27, -18, -26, -19, -26, -19, -26,
-18, -26, -18, -26, -18, -27, -17, -26, -20, -27, -17, -25, -19, -26, -18, -26,
-20, -28, -18, -25, -20, -27, -18, -26, -20, -27, -18, -25, -20, -27, -18, -27,
-18, -27, -18, -26, -18, -25, -20, -27, -18, -25, -21, -27, -17, -24, -22, -29,
-16, -24, -24, -31, -13, -20, -29, -34, -3, -12, -65, -67, -87, -87, -15, -23,
-30, -38, -12, -24, -18, -31, -10, -26, -13, -29, -9, -26, -11, -26, -9, -22,
-9, -21, -8, -18, -7, -13, -8, -12, -7, -10, -9, -12, -7, -10, -7, -11, -5, -9,
-6, -10, -4, -8, -5, -8, -3, -6, -4, -6, -3, -4, -2, -3, -2, 0, -3, 0, -1, 2,
-2, 2, -3, 1, -3, 2, -2, 1, -3, 1, -2, 1, -1, 2, -1, 1, 0, 2, 0, 2, };