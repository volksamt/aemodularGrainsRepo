#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0168

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 56, 2, 68, 4, 64, 6, 69, 7, 65, 9,
70, 11, 66, 13, 70, 15, 68, 18, 71, 18, 70, 20, 72, 22, 71, 24, 73, 25, 72, 27,
73, 29, 74, 31, 74, 32, 75, 34, 76, 36, 75, 37, 76, 39, 76, 41, 76, 42, 77, 44,
77, 45, 78, 46, 77, 48, 77, 50, 79, 51, 78, 53, 79, 54, 80, 56, 79, 56, 81, 58,
82, 59, 81, 60, 82, 61, 82, 63, 83, 64, 83, 65, 83, 66, 84, 68, 85, 69, 84, 70,
85, 72, 85, 72, 84, 73, 84, 75, 84, 74, 84, 76, 84, 77, 84, 78, 84, 80, 83, 81,
83, 81, 83, 82, 82, 82, 82, 84, 82, 84, 80, 86, 81, 86, 80, 88, 80, 88, 80, 88,
80, 90, 80, 91, 80, 91, 81, 92, 80, 93, 79, 93, 80, 95, 80, 96, 79, 97, 79, 97,
80, 98, 80, 98, 78, 99, 79, 100, 78, 102, 77, 102, 78, 103, 78, 104, 78, 104,
77, 105, 78, 106, 76, 106, 76, 107, 76, 108, 77, 108, 76, 108, 78, 109, 78, 110,
79, 109, 81, 111, 83, 111, 85, 111, 86, 112, 88, 112, 89, 113, 92, 113, 94, 113,
97, 115, 98, 114, 99, 115, 102, 116, 104, 116, 106, 117, 107, 118, 109, 118,
111, 118, 113, 119, 116, 119, 116, 118, 118, 118, 117, 116, 118, 116, 117, 115,
117, 114, 115, 114, 115, 112, 114, 110, 111, 109, 111, 108, 109, 107, 107, 105,
107, 104, 105, 102, 103, 101, 102, 99, 101, 97, 99, 96, 97, 94, 96, 93, 95, 91,
92, 90, 92, 90, 91, 88, 89, 87, 87, 84, 87, 83, 85, 82, 84, 81, 82, 79, 81, 77,
80, 76, 79, 76, 78, 75, 77, 72, 75, 71, 74, 70, 73, 69, 72, 67, 71, 66, 71, 65,
69, 63, 70, 63, 68, 61, 67, 60, 68, 58, 66, 58, 66, 55, 64, 55, 64, 53, 62, 52,
62, 50, 60, 49, 59, 47, 58, 47, 57, 46, 54, 44, 52, 44, 50, 43, 47, 41, 45, 40,
43, 40, 41, 38, 38, 38, 35, 36, 34, 35, 32, 35, 29, 33, 26, 32, 25, 32, 22, 31,
21, 30, 18, 29, 16, 28, 14, 27, 11, 27, 9, 25, 7, 25, 5, 24, 4, 24, 1, 23, -2,
21, -3, 21, -6, 20, -6, 19, -9, 19, -11, 18, -12, 18, -14, 17, -17, 17, -18, 16,
-19, 14, -22, 14, -23, 13, -24, 13, -27, 12, -28, 11, -29, 11, -30, 10, -31, 10,
-34, 9, -34, 10, -36, 10, -36, 9, -37, 9, -39, 8, -40, 8, -41, 8, -42, 9, -42,
8, -44, 8, -45, 9, -45, 8, -45, 9, -47, 9, -48, 9, -48, 9, -49, 9, -49, 9, -50,
9, -52, 9, -52, 8, -52, 9, -53, 9, -55, 9, -54, 9, -56, 9, -57, 8, -57, 9, -58,
8, -58, 8, -60, 9, -59, 9, -60, 8, -60, 8, -62, 7, -62, 6, -63, 5, -63, 3, -64,
2, -64, 0, -65, -2, -66, -3, -67, -5, -67, -7, -68, -10, -69, -11, -70, -12,
-70, -14, -71, -16, -72, -18, -72, -20, -72, -22, -73, -24, -73, -25, -74, -28,
-75, -29, -74, -30, -76, -32, -76, -34, -76, -36, -77, -37, -77, -39, -77, -41,
-78, -42, -79, -44, -78, -45, -80, -47, -79, -49, -79, -49, -80, -52, -80, -52,
-80, -53, -81, -56, -81, -56, -82, -58, -82, -59, -83, -61, -82, -61, -84, -62,
-84, -64, -84, -65, -85, -66, -86, -67, -85, -69, -85, -70, -86, -72, -86, -72,
-86, -73, -86, -75, -86, -75, -86, -77, -86, -78, -86, -79, -85, -80, -85, -80,
-85, -82, -84, -83, -84, -83, -84, -84, -83, -85, -83, -86, -83, -86, -82, -88,
-82, -88, -83, -90, -82, -90, -81, -90, -81, -92, -82, -93, -82, -93, -82, -94,
-82, -96, -81, -96, -81, -96, -81, -97, -81, -98, -81, -99, -81, -99, -81, -100,
-80, -102, -80, -103, -80, -103, -80, -103, -80, -105, -79, -106, -78, -106,
-78, -107, -78, -107, -77, -107, -77, -108, -78, -108, -79, -110, -80, -111,
-79, -111, -81, -112, -83, -112, -84, -112, -86, -112, -88, -113, -90, -114,
-92, -113, -93, -114, -96, -115, -98, -115, -100, -115, -102, -116, -104, -117,
-105, -118, -107, -118, -109, -118, -111, -118, -114, -118, -114, -120, -118,
-118, -118, -119, -119, -118, -119, -118, -119, -117, -119, -116, -118, -115,
-117, -114, -116, -112, -114, -111, -114, -110, -113, -108, -111, -108, -109,
-106, -107, -104, -105, -103, -105, -101, -103, -100, -101, -98, -100, -98, -98,
-95, -97, -94, -95, -93, -94, -91, -93, -90, -92, -89, -90, -86, -88, -85, -87,
-85, -87, -84, -85, -82, -84, -81, -82, -79, -81, -78, -80, -76, -79, -75, -78,
-74, -77, -72, -76, -70, -74, -70, -74, -68, -73, -67, -73, -66, -71, -65, -71,
-64, -70, -61, -69, -61, -68, -59, -68, -58, -66, -57, -65, -55, -65, -54, -64,
-53, -63, -51, -63, -50, -60, -49, -59, -47, -58, -47, -55, -45, -54, -44, -51,
-43, -49, -43, -47, -42, -44, -40, -42, -39, -40, -38, -36, -37, -36, -36, -32,
-36, -30, -34, -28, -33, -26, -32, -24, -31, -21, -30, -18, -30, -17, -29, -15,
-28, -13, -28, -10, -27, -8, -26, -6, -26, -4, -24, -2, -23, 0, -23, 1, -23, 3,
-22, 6, -21, 7, -20, 9, -19, 11, -18, 14, -17, 14, -18, 16, -16, 18, -17, 20,
-15, 21, -16, 23, -15, 25, -13, 26, -12, 27, -12, 28, -12, 30, -11, 32, -11, 33,
-11, 34, -11, 35, -10, 36, -11, 37, -9, 38, -10, 40, -10, 40, -10, 41, -10, 42,
-10, 42, -11, 44, -10, 44, -10, 44, -10, 46, -10, 47, -10, 47, -10, 47, -11, 49,
-10, 49, -11, 50, -10, 51, -10, 53, -10, 53, -10, 53, -10, 54, -10, 54, -11, 56,
-10, 56, -10, 57, -9, 57, -10, 58, -10, 57, -10, 60, -9, 58, -9, 62, -7, 59, -6,
64, -5, 60, -3, 67, -2, 54, };