#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0158

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 2, 23, 14, 75, 46, 115, 67, 120,
70, 117, 69, 117, 69, 116, 68, 114, 67, 114, 67, 114, 67, 113, 67, 112, 66, 111,
66, 111, 66, 111, 65, 110, 65, 109, 66, 108, 64, 109, 64, 108, 63, 106, 63, 106,
63, 105, 62, 105, 62, 104, 62, 103, 62, 103, 61, 102, 60, 102, 61, 101, 60, 101,
60, 101, 59, 100, 59, 99, 59, 99, 59, 96, 57, 74, 44, 20, 13, -20, -10, -23,
-13, -23, -12, -22, -12, -22, -11, -22, -11, -21, -12, -21, -11, -22, -11, -22,
-11, -21, -11, -21, -10, -22, -10, -21, -10, -21, -10, -21, -10, -21, -10, -21,
-11, -20, -10, -20, -10, -20, -10, -19, -10, -20, -10, -19, -9, -20, -9, -19,
-9, -19, -9, -19, -9, -19, -9, -19, -9, -19, -10, -18, -9, -19, -9, -19, -9,
-18, -9, -18, -8, -18, -8, -18, -9, -18, -8, -18, -8, -18, -8, -17, -8, -18, -8,
-17, -9, -18, -8, -18, -8, -17, -7, -17, -8, -17, -7, -17, -7, -17, -8, -17, -8,
-17, -7, -16, -7, -16, -8, -16, -8, -16, -7, -16, -7, -16, -7, -15, -6, -16, -7,
-16, -7, -15, -6, -16, -6, -15, -7, -16, -7, -16, -6, -15, -6, -15, -6, -15, -5,
-14, -6, -15, -5, -15, -5, -14, -5, -14, -6, -14, -5, -14, -6, -15, -5, -14, -5,
-14, -6, -14, -5, -14, -5, -14, -5, -13, -5, -13, -4, -13, -4, -13, -5, -13, -4,
-13, -4, -13, -4, -12, -4, -13, -4, -13, -4, -12, -4, -12, -3, -12, -3, -11, -3,
-13, -3, -12, -3, -12, -3, -11, -4, -12, -3, -11, -3, -11, -3, -12, -3, -12, -3,
-11, -3, -12, -2, -10, -2, -12, -2, -10, -3, -11, -2, -11, -2, -10, -2, -10, -3,
-11, -2, -10, -2, -11, -2, -11, -2, -10, -2, -10, -2, -9, -2, -10, -2, -10, -1,
-10, -1, -9, -2, -10, -1, -9, -1, -9, 0, -9, -1, -9, 0, -9, 0, -9, 0, -9, 0, -9,
0, -9, 0, -9, -1, -9, 0, -8, 1, -8, 0, -8, 1, -8, 1, -8, 1, -8, 0, -9, 0, -8, 1,
-7, 0, -8, 1, -8, 1, -8, 1, -8, 1, -7, 1, -7, 1, -8, 1, -7, 1, -7, 2, -7, 1, -7,
2, -7, 2, -6, 2, -6, 2, -7, 3, -7, 2, -7, 2, -6, 2, -6, 3, -6, 2, -6, 3, -6, 3,
-6, 2, -6, 3, -6, 3, -6, 3, -6, 3, -5, 2, -5, 3, -5, 3, -6, 3, -5, 4, -5, 3, -5,
4, -5, 4, -5, 3, -4, 3, -5, 4, -5, 3, -5, 5, -5, 4, -4, 4, -4, 4, -5, 5, -4, 4,
-4, 5, -4, 5, -5, 4, -4, 5, -4, 5, -4, 5, -3, 6, -3, 5, -4, 6, -3, 6, -3, 6, -3,
5, -3, 6, -3, 6, -4, 7, -3, 6, -3, 6, -3, 7, -3, 7, -3, 6, -2, 7, -3, 7, -3, 7,
-3, 7, -2, 7, -2, 7, -3, 7, -2, 7, -2, 7, -3, 7, -2, 8, -3, 8, -2, 8, -1, 7, -1,
8, -1, 8, -1, 8, -1, 8, -1, 8, -1, 8, -1, 8, -1, 9, -1, 9, 0, 9, 0, 8, -1, 9,
-1, 9, -1, 8, -1, 9, -1, 9, 0, 10, -1, 10, 0, 10, 0, 9, -1, 9, 0, 10, 0, 10, -1,
10, 1, 10, 1, 10, 0, 10, 1, 10, 0, 10, 0, 11, 1, 10, 1, 12, 0, 10, 0, 11, 0, 11,
1, 11, 1, 11, 1, 12, 1, 12, 2, 12, 1, 11, 2, 12, 1, 12, 1, 12, 2, 13, 1, 13, 2,
12, 1, 12, 1, 12, 2, 13, 2, 12, 2, 12, 2, 13, 2, 13, 3, 13, 3, 13, 3, 14, 2, 13,
2, 14, 3, 14, 3, 13, 3, 13, 2, 15, 2, 14, 2, 15, 2, 15, 4, 15, 3, 15, 3, 15, 3,
15, 3, 15, 4, 15, 3, 16, 3, 16, 3, 15, 3, 15, 4, 15, 4, 17, 5, 16, 4, 16, 4, 16,
4, 16, 4, 16, 5, 16, 4, 17, 4, 17, 4, 17, 5, 17, 5, 17, 4, 17, 5, 17, 5, 18, 5,
17, 6, 17, 5, 18, 5, 19, 4, 18, 5, 19, 5, 18, 5, 19, 6, 18, 6, 19, 6, 19, 5, 18,
6, 19, 6, 20, 5, 19, 6, 19, 6, 19, 6, 20, 7, 20, 6, 20, 6, 20, 6, 20, 7, 21, 6,
20, 7, 21, 7, 21, 7, 22, 7, 21, 7, 22, 7, 21, 7, 22, 7, 23, 8, 22, 8, 22, 7, 23,
7, 23, 7, 23, 8, 22, 8, 22, 8, 22, 7, 23, 9, 23, 8, 23, 9, 23, 9, 24, 8, 24, 8,
24, 9, 24, 9, 25, 9, 25, 9, 24, 9, 25, 8, 25, 9, 25, 9, 25, 10, 25, 9, 25, 9,
25, 9, 25, 9, 25, 10, 25, 9, 26, 10, 27, 9, 26, 10, 26, 10, 27, 10, 28, 10, 26,
9, 28, 11, 27, 10, 27, 11, 27, 10, 27, 10, 28, 10, 28, 10, 28, 10, 29, 10, 28,
11, 28, 11, 29, 12, 29, 12, 29, 11, 29, 11, 30, 11, 30, 12, 30, 11, 30, 12, 30,
12, 31, 12, 30, 12, 31, 13, 30, 12, 31, 12, 31, 13, 32, 13, 33, 7, 17, -15, -33,
-32, -73, -36, -82, -37, -81, -36, -83, -36, -84, -37, -84, -37, -84, -37, -85,
-38, -85, -37, -86, -38, -86, -38, -87, -38, -87, -38, -88, -39, -88, -39, -89,
-38, -88, -39, -89, -40, -90, -40, -91, -41, -92, -40, -92, -40, -92, -40, -92,
-41, -93, -41, -94, -41, -95, -42, -95, -42, -96, -42, -96, -43, -96, -43, -97,
-43, -97, -43, -99, -43, -99, -43, -100, -44, -100, -44, -100, -44, -102, -45,
-102, -44, -103, -45, -104, -45, -103, -45, -105, -45, -105, -45, -105, -46,
-105, -46, -107, -46, -108, -47, -108, -47, -108, -48, -109, -47, -109, -49,
-111, -41, -96, -20, -47, -4, -8, };