#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 3, 4, 4, 6, 6, 9, 7, 10, 9,
12, 9, 14, 10, 16, 11, 18, 14, 20, 15, 23, 16, 24, 17, 26, 17, 28, 19, 31, 21,
32, 22, 33, 23, 35, 24, 37, 25, 39, 26, 40, 28, 42, 29, 44, 30, 45, 31, 47, 33,
49, 34, 50, 35, 53, 36, 54, 37, 54, 38, 57, 40, 59, 40, 59, 41, 61, 42, 63, 43,
63, 45, 65, 46, 66, 47, 68, 49, 69, 50, 70, 51, 71, 53, 72, 53, 74, 53, 75, 55,
76, 56, 77, 57, 79, 58, 80, 60, 81, 61, 82, 62, 83, 63, 84, 65, 85, 65, 86, 67,
86, 67, 88, 69, 89, 69, 90, 70, 91, 71, 92, 73, 92, 75, 93, 75, 94, 77, 95, 77,
96, 79, 97, 80, 97, 81, 99, 82, 99, 84, 100, 85, 100, 86, 100, 87, 101, 87, 103,
88, 104, 90, 104, 91, 105, 92, 105, 93, 106, 95, 106, 95, 107, 96, 107, 97, 109,
99, 108, 100, 109, 102, 109, 104, 110, 104, 111, 105, 111, 106, 111, 108, 112,
108, 112, 109, 113, 110, 113, 111, 113, 111, 114, 112, 114, 113, 114, 113, 115,
114, 115, 114, 115, 115, 116, 115, 116, 116, 116, 116, 117, 117, 116, 116, 117,
117, 117, 117, 117, 118, 118, 118, 117, 118, 118, 119, 118, 119, 119, 119, 118,
119, 118, 119, 118, 119, 119, 120, 119, 118, 119, 118, 119, 118, 119, 119, 118,
119, 120, 118, 119, 118, 119, 118, 119, 117, 120, 118, 120, 117, 119, 116, 119,
116, 119, 116, 119, 114, 119, 113, 119, 112, 119, 112, 118, 111, 118, 111, 118,
110, 118, 109, 118, 108, 117, 108, 117, 107, 117, 107, 118, 106, 117, 106, 117,
105, 116, 105, 116, 103, 115, 103, 116, 103, 115, 102, 115, 102, 115, 101, 114,
100, 114, 99, 114, 99, 113, 99, 114, 98, 112, 97, 111, 96, 111, 95, 112, 95,
111, 94, 110, 94, 110, 93, 110, 92, 109, 91, 109, 90, 108, 89, 107, 90, 107, 89,
106, 88, 106, 87, 105, 86, 104, 84, 104, 84, 103, 83, 103, 83, 101, 81, 101, 81,
101, 80, 100, 78, 100, 77, 99, 77, 98, 75, 97, 76, 96, 74, 96, 73, 95, 72, 94,
72, 93, 70, 91, 69, 91, 68, 90, 67, 89, 66, 88, 65, 87, 64, 87, 63, 86, 62, 84,
61, 83, 60, 82, 58, 81, 57, 81, 57, 79, 56, 78, 54, 77, 53, 75, 53, 75, 52, 73,
49, 72, 49, 71, 48, 69, 47, 68, 46, 67, 45, 65, 44, 64, 42, 62, 41, 62, 40, 61,
38, 58, 37, 56, 36, 55, 35, 53, 33, 53, 32, 51, 32, 49, 30, 48, 29, 46, 28, 44,
27, 43, 25, 41, 24, 39, 23, 38, 22, 36, 22, 35, 20, 32, 18, 31, 18, 29, 16, 26,
15, 25, 13, 23, 12, 22, 11, 19, 11, 17, 8, 16, 8, 13, 7, 11, 4, 10, 4, 8, 3, 5,
1, 4, 0, 2, -2, -1, -3, -2, -4, -4, -4, -6, -6, -9, -7, -11, -8, -12, -9, -14,
-11, -17, -12, -19, -13, -20, -14, -22, -15, -24, -17, -26, -18, -28, -19, -30,
-21, -32, -22, -34, -23, -36, -23, -37, -25, -39, -27, -41, -28, -42, -29, -45,
-29, -46, -31, -47, -33, -49, -34, -50, -35, -52, -36, -54, -37, -55, -39, -57,
-40, -58, -41, -59, -42, -61, -42, -62, -43, -64, -45, -65, -46, -67, -47, -68,
-48, -69, -49, -71, -51, -72, -51, -73, -53, -74, -54, -75, -55, -77, -56, -78,
-58, -79, -59, -79, -59, -81, -60, -82, -62, -83, -63, -84, -64, -85, -65, -86,
-67, -87, -68, -88, -68, -89, -70, -90, -72, -91, -72, -92, -73, -93, -74, -94,
-75, -95, -76, -94, -78, -96, -79, -97, -80, -97, -81, -99, -81, -99, -83, -100,
-84, -101, -85, -102, -86, -101, -88, -103, -89, -103, -91, -104, -92, -105,
-92, -105, -93, -105, -94, -106, -96, -106, -97, -107, -98, -107, -100, -108,
-100, -109, -102, -110, -104, -110, -105, -110, -106, -111, -106, -111, -108,
-112, -108, -112, -109, -112, -109, -112, -110, -114, -111, -114, -111, -114,
-112, -114, -114, -115, -113, -115, -115, -115, -115, -115, -116, -116, -116,
-116, -117, -116, -116, -117, -118, -118, -117, -117, -117, -118, -117, -118,
-118, -118, -119, -118, -119, -118, -118, -119, -119, -119, -119, -118, -119,
-118, -119, -118, -119, -118, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -118, -119, -119, -118, -119, -117, -119, -118, -119, -117, -119, -117,
-119, -116, -119, -116, -119, -114, -119, -114, -118, -113, -119, -112, -118,
-112, -119, -111, -119, -110, -118, -110, -118, -108, -118, -109, -118, -108,
-118, -107, -117, -107, -117, -107, -117, -106, -117, -105, -116, -105, -115,
-103, -116, -104, -116, -103, -116, -103, -115, -101, -114, -101, -115, -100,
-114, -100, -113, -99, -114, -99, -112, -97, -112, -97, -112, -97, -112, -96,
-111, -95, -111, -94, -110, -93, -110, -92, -110, -92, -108, -91, -108, -91,
-107, -89, -107, -89, -107, -88, -107, -86, -105, -87, -105, -86, -105, -85,
-104, -84, -103, -83, -103, -82, -102, -81, -101, -80, -100, -79, -100, -79,
-99, -78, -98, -76, -98, -76, -97, -75, -97, -74, -95, -73, -94, -72, -93, -72,
-92, -70, -92, -69, -92, -68, -90, -67, -89, -66, -88, -64, -87, -63, -86, -63,
-85, -62, -85, -61, -83, -59, -81, -58, -82, -58, -80, -57, -79, -55, -78, -54,
-77, -53, -75, -52, -74, -51, -73, -50, -72, -48, -70, -47, -69, -47, -68, -45,
-66, -44, -65, -42, -63, -42, -62, -40, -61, -40, -60, -39, -59, -37, -56, -36,
-55, -35, -54, -34, -52, -33, -51, -31, -49, -30, -48, -29, -45, -28, -44, -27,
-42, -25, -41, -24, -39, -23, -37, -21, -36, -21, -35, -19, -33, -19, -30, -18,
-28, -16, -27, -15, -25, -13, -23, -12, -21, -11, -19, -9, -17, -8, -15, -7,
-13, -6, -11, -5, -9, -4, -8, -2, -6, -1, -4, -1, -2, 1, };