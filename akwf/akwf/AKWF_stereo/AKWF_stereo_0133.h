#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0133

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -3, 4, -2, 7, 1, 8, 4, 11, 7, 14,
9, 16, 12, 18, 15, 21, 19, 25, 20, 27, 25, 31, 28, 35, 31, 37, 35, 41, 39, 46,
42, 49, 46, 53, 49, 56, 53, 59, 56, 62, 59, 65, 62, 68, 66, 71, 68, 74, 70, 75,
72, 78, 75, 80, 76, 82, 79, 84, 81, 85, 82, 87, 85, 89, 87, 90, 87, 90, 89, 93,
91, 93, 93, 95, 94, 95, 96, 96, 96, 98, 98, 98, 98, 98, 98, 99, 99, 98, 99, 98,
100, 98, 99, 98, 99, 98, 100, 97, 99, 97, 99, 97, 99, 96, 97, 95, 96, 95, 96,
95, 95, 93, 93, 92, 92, 92, 90, 90, 89, 89, 88, 87, 86, 87, 85, 85, 84, 84, 82,
83, 82, 81, 80, 80, 79, 79, 77, 78, 76, 76, 74, 76, 73, 74, 72, 72, 72, 71, 70,
70, 68, 70, 68, 68, 66, 67, 66, 66, 65, 64, 63, 63, 63, 63, 61, 61, 60, 61, 59,
59, 59, 59, 58, 57, 56, 56, 55, 56, 55, 54, 53, 53, 52, 53, 51, 51, 50, 49, 50,
49, 48, 47, 47, 47, 46, 46, 45, 46, 44, 44, 43, 43, 43, 42, 41, 41, 42, 40, 40,
40, 39, 39, 39, 38, 38, 37, 38, 37, 37, 37, 37, 36, 37, 35, 38, 35, 37, 35, 37,
36, 38, 36, 38, 37, 38, 37, 39, 37, 40, 37, 40, 37, 40, 38, 40, 38, 40, 38, 40,
37, 40, 37, 39, 36, 39, 36, 37, 35, 38, 34, 36, 33, 36, 31, 34, 30, 34, 29, 32,
27, 31, 25, 29, 24, 28, 21, 26, 20, 24, 18, 22, 15, 21, 14, 19, 12, 17, 10, 15,
7, 12, 5, 9, 2, 7, -1, 4, -4, 2, -6, 0, -9, -5, -11, -7, -15, -10, -18, -13,
-21, -16, -25, -20, -28, -22, -32, -27, -34, -30, -38, -34, -40, -38, -45, -40,
-47, -45, -51, -48, -55, -52, -58, -55, -61, -58, -64, -61, -68, -65, -71, -68,
-73, -71, -76, -74, -79, -77, -81, -79, -85, -83, -87, -85, -88, -88, -92, -90,
-94, -92, -95, -94, -98, -96, -99, -97, -101, -100, -103, -102, -104, -103,
-105, -105, -107, -106, -108, -107, -109, -109, -110, -111, -112, -110, -112,
-112, -112, -113, -113, -114, -113, -114, -114, -115, -115, -116, -115, -117,
-115, -117, -115, -118, -116, -118, -116, -119, -117, -119, -116, -119, -117,
-119, -116, -118, -115, -119, -116, -119, -115, -117, -114, -117, -112, -116,
-112, -114, -109, -114, -108, -112, -106, -109, -104, -108, -101, -105, -99,
-104, -95, -100, -91, -97, -88, -94, -84, -90, -81, -87, -77, -82, -73, -79,
-69, -76, -65, -72, -62, -69, -58, -66, -54, -61, -51, -58, -47, -56, -43, -52,
-39, -49, -36, -46, -33, -43, -29, -39, -26, -36, -22, -33, -19, -29, -17, -27,
-14, -25, -11, -22, -8, -19, -6, -15, -3, -14, -2, -11, 1, -9, 3, -7, 4, -5, 6,
-2, 8, 0, 10, 2, 12, 4, 13, 5, 15, 6, 17, 9, 18, 11, 19, 12, 20, 12, 22, 14, 23,
16, 23, 16, 24, 17, 24, 17, 25, 19, 26, 19, 26, 19, 27, 20, 26, 20, 26, 21, 26,
21, 26, 22, 27, 21, 27, 22, 27, 22, 28, 22, 27, 23, 28, 24, 27, 23, 29, 23, 28,
25, 29, 24, 29, 25, 31, 26, 31, 26, 31, 27, 31, 28, 32, 28, 33, 29, 34, 30, 35,
30, 35, 31, 37, 33, 37, 34, 38, 35, 39, 35, 39, 36, 41, 38, 42, 38, 42, 39, 44,
40, 44, 41, 45, 41, 46, 43, 47, 44, 48, 46, 49, 47, 50, 48, 51, 50, 54, 50, 54,
51, 55, 52, 57, 55, 58, 56, 61, 58, 62, 61, 64, 62, 66, 63, 68, 66, 71, 69, 74,
72, 75, 74, 78, 76, 79, 78, 81, 80, 83, 82, 84, 83, 86, 86, 88, 87, 89, 89, 90,
90, 92, 91, 93, 93, 94, 95, 94, 95, 96, 95, 96, 96, 96, 97, 96, 96, 97, 97, 96,
97, 96, 97, 96, 96, 95, 96, 94, 96, 93, 96, 92, 93, 92, 93, 90, 92, 88, 91, 87,
90, 85, 89, 83, 87, 82, 86, 78, 83, 78, 83, 76, 80, 73, 78, 72, 76, 68, 74, 66,
72, 64, 69, 60, 66, 57, 63, 55, 61, 51, 59, 49, 55, 45, 51, 42, 49, 39, 46, 35,
42, 31, 40, 27, 36, 24, 32, 20, 28, 16, 25, 12, 21, 8, 18, 4, 14, 1, 10, -3, 6,
-7, 3, -12, 0, -15, -5, -18, -8, -22, -12, -26, -17, -30, -19, -33, -24, -36,
-27, -40, -30, -43, -33, -47, -36, -49, -40, -53, -44, -57, -47, -58, -50, -63,
-53, -64, -55, -68, -58, -70, -61, -73, -63, -75, -65, -78, -68, -79, -69, -82,
-72, -84, -73, -87, -76, -88, -77, -89, -79, -91, -80, -91, -81, -92, -83, -92,
-83, -92, -85, -93, -85, -92, -86, -93, -85, -92, -85, -92, -84, -90, -84, -90,
-83, -89, -82, -88, -82, -87, -80, -85, -80, -84, -79, -84, -78, -83, -77, -83,
-76, -82, -76, -80, -74, -80, -74, -79, -72, -77, -72, -77, -72, -76, -71, -74,
-70, -73, -69, -72, -70, -72, -68, -72, -68, -71, -68, -71, -67, -71, -67, -69,
-65, -69, -66, -69, -65, -68, -64, -68, -64, -66, -64, -66, -63, -66, -64, -66,
-63, -65, -63, -65, -63, -65, -63, -65, -64, -66, -63, -65, -64, -65, -64, -65,
-64, -66, -64, -66, -65, -65, -64, -66, -65, -65, -65, -65, -66, -64, -66, -65,
-67, -65, -68, -65, -67, -64, -67, -65, -68, -64, -67, -63, -67, -63, -67, -62,
-67, -62, -66, -62, -66, -61, -65, -59, -64, -57, -63, -56, -61, -56, -59, -54,
-59, -52, -56, -50, -56, -49, -53, -47, -52, -45, -49, -42, -48, -41, -46, -38,
-44, -36, -42, -34, -40, -31, -38, -29, -35, -27, -34, -25, -30, -22, -29, -20,
-26, -17, -24, -15, -22, -13, -20, -10, -17, -8, -15, -6, -12, -3, -10, -1, -6,
};