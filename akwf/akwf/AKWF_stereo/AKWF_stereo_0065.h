#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0065

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 42, 6, 53, 10, 53, 14, 57, 20, 57,
23, 62, 27, 62, 31, 66, 36, 67, 40, 70, 43, 69, 46, 73, 50, 73, 54, 76, 58, 77,
62, 79, 64, 80, 68, 83, 71, 83, 74, 84, 76, 85, 79, 87, 82, 88, 84, 89, 86, 90,
89, 92, 92, 92, 93, 94, 95, 94, 97, 95, 99, 96, 101, 97, 103, 98, 103, 100, 106,
100, 107, 101, 108, 101, 109, 102, 110, 103, 111, 103, 112, 104, 113, 105, 114,
104, 114, 105, 115, 106, 115, 106, 115, 106, 116, 107, 116, 108, 117, 108, 116,
108, 116, 108, 116, 109, 116, 109, 116, 109, 116, 109, 116, 109, 115, 109, 115,
109, 114, 108, 114, 110, 112, 109, 112, 109, 112, 110, 110, 109, 109, 109, 109,
109, 107, 109, 107, 109, 105, 108, 104, 107, 102, 107, 102, 107, 101, 108, 100,
107, 98, 107, 97, 107, 95, 106, 93, 105, 93, 105, 90, 105, 88, 105, 87, 105, 86,
103, 84, 103, 82, 102, 79, 102, 78, 101, 76, 101, 75, 100, 73, 99, 70, 98, 69,
98, 67, 97, 66, 96, 63, 96, 61, 95, 60, 94, 57, 93, 57, 92, 54, 92, 52, 91, 50,
89, 48, 89, 46, 89, 44, 88, 42, 87, 41, 86, 39, 85, 38, 84, 36, 84, 34, 82, 32,
81, 30, 80, 29, 78, 27, 78, 25, 77, 24, 76, 22, 75, 20, 74, 19, 73, 18, 72, 16,
70, 16, 70, 15, 68, 13, 68, 12, 67, 11, 65, 11, 64, 10, 63, 8, 62, 8, 61, 7, 60,
6, 58, 5, 58, 5, 57, 3, 57, 3, 55, 3, 54, 3, 55, 1, 53, 1, 53, 1, 52, 1, 52, 0,
52, 1, 51, 0, 50, 0, 50, 0, 49, 0, 49, -1, 49, 0, 49, -1, 50, -1, 50, -1, 50,
-1, 50, 0, 50, 0, 50, 0, 50, -1, 50, 0, 49, 0, 50, 1, 51, 0, 52, 1, 51, 1, 50,
1, 51, 1, 51, 1, 51, 2, 52, 1, 52, 2, 53, 3, 52, 3, 53, 3, 53, 3, 53, 4, 53, 4,
53, 5, 54, 4, 53, 4, 54, 5, 53, 6, 53, 5, 53, 5, 53, 6, 53, 5, 54, 6, 54, 5, 53,
6, 53, 6, 53, 6, 54, 6, 53, 5, 53, 6, 52, 6, 52, 6, 52, 6, 52, 6, 52, 5, 52, 5,
52, 5, 51, 6, 51, 5, 49, 5, 50, 4, 49, 4, 50, 5, 49, 4, 49, 4, 49, 3, 48, 3, 48,
3, 47, 2, 47, 2, 46, 2, 45, 2, 45, 1, 44, 1, 44, 1, 43, 1, 43, 0, 42, 0, 42, 0,
41, -2, 41, -1, 40, -2, 40, -2, 39, -3, 39, -2, 38, -3, 37, -4, 37, -3, 36, -4,
35, -4, 35, -5, 34, -5, 32, -5, 32, -6, 30, -6, 30, -5, 29, -5, 27, -6, 26, -6,
24, -5, 24, -6, 22, -6, 19, -5, 17, -5, 14, 1, 3, 6, -12, 7, -16, 7, -18, 8,
-20, 8, -23, 8, -23, 8, -24, 8, -26, 8, -28, 8, -29, 8, -30, 8, -31, 7, -32, 7,
-32, 8, -33, 7, -34, 6, -35, 6, -36, 6, -36, 5, -37, 5, -37, 4, -38, 3, -39, 4,
-40, 3, -40, 3, -41, 3, -41, 2, -42, 2, -43, 2, -44, 2, -43, 1, -44, 1, -44, 1,
-45, 0, -45, -1, -46, -1, -46, -2, -46, -1, -47, -3, -47, -3, -48, -3, -48, -3,
-48, -3, -49, -4, -50, -4, -49, -4, -50, -5, -50, -5, -49, -5, -50, -4, -51, -4,
-50, -6, -50, -6, -51, -5, -51, -5, -50, -6, -50, -5, -50, -6, -51, -5, -51, -5,
-51, -6, -50, -6, -49, -5, -50, -5, -50, -5, -49, -5, -49, -4, -49, -5, -48, -5,
-48, -4, -48, -4, -49, -4, -48, -3, -48, -3, -47, -3, -46, -2, -47, -2, -46, -2,
-46, -2, -46, -1, -45, -1, -45, 0, -44, 0, -43, 0, -43, 1, -44, 0, -44, 1, -42,
2, -42, 1, -41, 2, -42, 2, -41, 3, -40, 2, -41, 2, -41, 3, -40, 3, -40, 2, -39,
3, -41, 3, -39, 3, -40, 3, -39, 3, -40, 3, -40, 3, -41, 3, -40, 4, -41, 3, -41,
2, -43, 2, -43, 3, -44, 2, -44, 2, -45, 1, -46, 0, -47, 1, -47, 0, -48, -1, -49,
-1, -51, -2, -52, -3, -53, -4, -53, -4, -55, -5, -56, -6, -56, -6, -57, -9, -59,
-10, -59, -10, -61, -12, -61, -13, -62, -14, -64, -16, -64, -18, -66, -19, -67,
-20, -68, -21, -70, -24, -71, -25, -72, -27, -72, -28, -73, -29, -75, -31, -76,
-33, -77, -36, -78, -37, -79, -39, -80, -42, -81, -43, -82, -46, -83, -47, -84,
-49, -85, -50, -86, -53, -87, -56, -87, -58, -89, -59, -89, -61, -91, -63, -92,
-64, -92, -67, -94, -69, -95, -71, -96, -73, -96, -74, -97, -77, -98, -78, -99,
-81, -100, -82, -101, -85, -101, -85, -102, -88, -103, -89, -103, -91, -104,
-93, -106, -94, -105, -96, -106, -97, -107, -99, -108, -100, -108, -102, -109,
-103, -109, -105, -110, -105, -111, -106, -111, -108, -112, -109, -112, -110,
-113, -112, -113, -112, -114, -113, -115, -114, -115, -114, -115, -115, -115,
-117, -115, -117, -115, -117, -116, -118, -116, -118, -117, -118, -117, -119,
-117, -118, -117, -120, -116, -119, -117, -119, -117, -119, -117, -120, -117,
-119, -116, -118, -116, -118, -116, -117, -116, -116, -116, -116, -115, -116,
-115, -114, -114, -113, -114, -111, -114, -111, -113, -110, -112, -108, -112,
-107, -111, -105, -110, -103, -109, -103, -109, -100, -109, -98, -107, -97,
-106, -94, -105, -92, -105, -89, -103, -87, -102, -84, -101, -82, -100, -79,
-98, -77, -97, -73, -95, -69, -94, -66, -93, -63, -91, -60, -88, -56, -86, -53,
-86, -49, -83, -46, -81, -42, -79, -37, -76, -34, -73, -30, -71, -26, -68, -22,
-65, -19, -62, -15, -58, -10, -51, -7, -47, -5, -38, -13, -10, -19, 21, -16, 25,
-14, 35, -9, 35, -6, 45, -1, 38, };