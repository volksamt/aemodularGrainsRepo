#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0132

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -2, 3, 0, 5, 3, 7, 6, 12, 9, 14,
12, 17, 15, 19, 17, 22, 20, 25, 21, 27, 25, 29, 27, 32, 29, 34, 32, 36, 33, 39,
37, 42, 38, 44, 41, 46, 43, 50, 46, 52, 48, 54, 50, 57, 53, 60, 55, 61, 57, 64,
60, 66, 62, 69, 64, 72, 67, 74, 69, 77, 72, 79, 75, 82, 77, 85, 79, 86, 82, 88,
85, 91, 87, 94, 89, 97, 92, 99, 95, 101, 98, 103, 100, 105, 102, 108, 104, 111,
107, 113, 108, 114, 111, 117, 113, 118, 115, 119, 115, 119, 116, 119, 115, 119,
115, 117, 115, 116, 115, 115, 113, 112, 111, 110, 110, 107, 107, 102, 104, 97,
99, 93, 94, 87, 90, 83, 85, 77, 81, 71, 76, 66, 71, 61, 68, 56, 64, 51, 60, 46,
56, 42, 51, 37, 47, 33, 44, 29, 40, 23, 37, 19, 33, 15, 29, 12, 25, 9, 22, 4,
18, 1, 14, -2, 12, -6, 9, -7, 6, -11, 2, -13, 0, -16, -4, -19, -7, -21, -9, -23,
-11, -25, -15, -28, -17, -29, -20, -33, -22, -34, -25, -37, -27, -39, -30, -40,
-32, -43, -35, -45, -36, -46, -38, -48, -40, -50, -41, -51, -42, -52, -43, -53,
-45, -54, -45, -54, -46, -54, -46, -54, -47, -55, -48, -55, -48, -55, -48, -55,
-49, -55, -48, -54, -48, -54, -48, -54, -49, -53, -49, -54, -49, -53, -49, -53,
-49, -54, -49, -54, -48, -52, -49, -53, -49, -53, -49, -54, -49, -53, -49, -53,
-49, -53, -49, -52, -49, -52, -49, -52, -49, -53, -49, -51, -49, -50, -49, -51,
-48, -50, -47, -49, -48, -49, -47, -48, -46, -48, -46, -48, -46, -46, -44, -46,
-45, -46, -45, -45, -44, -44, -44, -44, -44, -44, -44, -44, -44, -45, -45, -44,
-44, -45, -45, -44, -46, -46, -47, -46, -48, -49, -49, -50, -50, -51, -52, -53,
-53, -55, -55, -56, -57, -57, -59, -60, -60, -61, -62, -62, -62, -62, -63, -62,
-65, -63, -64, -63, -65, -62, -64, -62, -65, -61, -64, -62, -64, -61, -63, -60,
-62, -59, -61, -57, -59, -57, -59, -55, -58, -54, -56, -52, -55, -51, -53, -49,
-52, -47, -50, -45, -48, -43, -47, -42, -46, -40, -43, -38, -41, -35, -40, -34,
-38, -33, -37, -29, -36, -29, -34, -27, -32, -26, -31, -24, -29, -22, -27, -21,
-26, -18, -25, -16, -22, -16, -19, -13, -17, -11, -15, -8, -13, -6, -10, -4, -8,
-1, -6, 2, -3, 5, 0, 8, 3, 11, 6, 14, 9, 17, 12, 21, 14, 24, 17, 27, 21, 31, 25,
33, 27, 37, 31, 40, 33, 43, 37, 46, 40, 49, 43, 53, 46, 55, 50, 57, 53, 61, 56,
64, 59, 66, 61, 69, 64, 71, 67, 73, 69, 74, 72, 78, 75, 80, 76, 81, 79, 83, 80,
85, 81, 86, 84, 87, 85, 90, 86, 90, 87, 92, 89, 92, 89, 94, 90, 95, 91, 95, 91,
95, 91, 93, 91, 92, 90, 90, 89, 89, 87, 87, 86, 85, 85, 82, 82, 79, 80, 77, 77,
73, 75, 70, 71, 66, 67, 62, 64, 58, 60, 56, 56, 53, 53, 49, 49, 46, 46, 43, 43,
42, 41, 40, 39, 37, 36, 35, 34, 33, 31, 31, 29, 29, 27, 27, 25, 24, 23, 24, 21,
22, 20, 20, 19, 19, 19, 18, 18, 18, 17, 16, 17, 17, 15, 15, 14, 16, 13, 15, 13,
15, 13, 14, 12, 14, 11, 15, 11, 15, 11, 15, 11, 16, 11, 16, 12, 18, 13, 17, 13,
18, 15, 18, 16, 19, 17, 19, 17, 21, 19, 21, 20, 22, 22, 23, 23, 23, 24, 25, 25,
25, 27, 26, 28, 26, 29, 27, 31, 28, 31, 28, 32, 29, 32, 28, 32, 28, 32, 29, 32,
27, 32, 28, 31, 27, 31, 27, 30, 26, 31, 25, 29, 24, 28, 25, 28, 23, 26, 22, 25,
22, 24, 19, 23, 18, 21, 17, 20, 16, 19, 13, 18, 13, 16, 11, 15, 10, 14, 9, 14,
8, 13, 7, 13, 5, 11, 4, 10, 4, 10, 3, 9, 2, 7, 1, 5, 0, 4, -1, 3, -3, 2, -4, 0,
-5, -1, -6, -2, -6, -5, -7, -5, -10, -8, -11, -10, -12, -12, -14, -14, -17, -17,
-19, -19, -22, -23, -26, -26, -29, -29, -33, -32, -36, -37, -39, -39, -42, -42,
-46, -45, -48, -47, -50, -49, -51, -51, -53, -52, -54, -55, -55, -55, -55, -55,
-55, -56, -55, -56, -57, -57, -55, -56, -56, -57, -55, -58, -54, -57, -55, -58,
-55, -58, -53, -57, -53, -58, -52, -57, -52, -58, -51, -57, -51, -57, -49, -57,
-49, -56, -47, -56, -47, -55, -46, -54, -46, -53, -44, -53, -43, -50, -43, -49,
-43, -48, -42, -48, -41, -46, -41, -46, -41, -44, -41, -43, -40, -43, -39, -41,
-39, -39, -38, -38, -38, -37, -37, -37, -37, -36, -36, -35, -35, -35, -35, -34,
-35, -34, -35, -33, -34, -33, -35, -33, -34, -32, -34, -32, -32, -31, -32, -32,
-32, -32, -32, -30, -31, -31, -31, -30, -30, -30, -29, -30, -28, -30, -28, -28,
-28, -28, -26, -27, -26, -26, -26, -25, -24, -25, -23, -23, -23, -23, -20, -20,
-20, -19, -18, -18, -18, -16, -16, -16, -15, -14, -13, -13, -13, -11, -12, -10,
-10, -8, -10, -7, -9, -7, -8, -6, -7, -5, -7, -5, -7, -5, -6, -6, -7, -5, -7,
-5, -8, -7, -8, -7, -9, -9, -10, -10, -12, -11, -13, -13, -15, -16, -18, -18,
-21, -22, -24, -24, -26, -27, -29, -29, -32, -32, -34, -34, -36, -35, -38, -37,
-40, -39, -42, -40, -43, -41, -43, -42, -44, -43, -45, -42, -44, -44, -45, -45,
-44, -44, -45, -44, -43, -44, -43, -45, -42, -43, -41, -43, -39, -41, -39, -41,
-37, -41, -36, -39, -35, -38, -33, -36, -32, -35, -30, -34, -29, -33, -27, -31,
-25, -30, -22, -27, -20, -25, -19, -24, -16, -21, -14, -19, -11, -16, -10, -14,
-7, -11, -4, -8, -2, -5, };