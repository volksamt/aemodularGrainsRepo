#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0134

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, -2, 7, 1, 11, 5, 15, 9, 18, 13, 22,
17, 27, 22, 31, 25, 36, 30, 40, 34, 44, 38, 48, 42, 51, 47, 55, 50, 59, 55, 63,
58, 67, 62, 70, 65, 74, 70, 78, 72, 80, 76, 83, 79, 87, 82, 90, 84, 92, 88, 95,
90, 97, 93, 100, 95, 102, 97, 104, 100, 107, 103, 108, 104, 110, 106, 113, 108,
114, 109, 115, 111, 116, 112, 117, 113, 118, 113, 118, 114, 119, 115, 119, 115,
118, 115, 118, 115, 118, 114, 117, 114, 116, 113, 115, 112, 113, 111, 110, 109,
108, 108, 107, 105, 104, 102, 101, 100, 99, 98, 96, 95, 94, 92, 90, 88, 86, 85,
82, 81, 79, 78, 74, 73, 70, 69, 66, 66, 62, 61, 58, 58, 53, 54, 48, 49, 44, 47,
40, 42, 37, 38, 33, 35, 29, 32, 25, 28, 21, 26, 18, 23, 15, 21, 12, 18, 9, 16,
7, 13, 5, 12, 3, 9, 2, 8, 0, 6, -1, 5, -3, 4, -4, 3, -5, 2, -6, 1, -7, 1, -7, 0,
-8, 0, -8, -1, -9, 0, -9, -2, -9, -2, -10, -2, -10, -3, -10, -3, -11, -3, -12,
-4, -12, -4, -11, -4, -13, -5, -13, -6, -14, -6, -14, -6, -14, -7, -15, -7, -15,
-8, -15, -8, -16, -9, -17, -9, -18, -10, -18, -11, -17, -11, -18, -13, -18, -12,
-20, -14, -20, -15, -20, -15, -20, -16, -21, -16, -22, -17, -23, -17, -23, -18,
-23, -19, -24, -19, -25, -19, -25, -21, -26, -21, -27, -22, -27, -22, -27, -23,
-29, -24, -29, -24, -29, -24, -30, -26, -31, -28, -32, -29, -32, -30, -33, -30,
-34, -32, -35, -33, -37, -35, -38, -36, -39, -38, -40, -39, -42, -41, -43, -43,
-44, -45, -48, -48, -49, -49, -51, -51, -53, -53, -55, -56, -57, -57, -58, -59,
-61, -62, -63, -63, -64, -65, -66, -68, -67, -69, -69, -71, -70, -72, -71, -74,
-73, -75, -74, -76, -74, -78, -75, -78, -75, -79, -75, -79, -75, -80, -75, -79,
-74, -79, -74, -79, -73, -78, -71, -78, -71, -77, -69, -76, -67, -75, -67, -74,
-65, -71, -64, -71, -63, -69, -60, -67, -59, -65, -57, -63, -55, -61, -53, -59,
-51, -56, -49, -55, -47, -52, -45, -50, -43, -48, -42, -47, -41, -44, -39, -42,
-38, -40, -36, -37, -34, -36, -31, -35, -30, -33, -29, -31, -27, -29, -25, -27,
-23, -25, -21, -23, -20, -22, -18, -20, -16, -18, -14, -16, -12, -14, -10, -12,
-7, -9, -5, -8, -3, -6, 0, -3, 3, -1, 5, 2, 7, 5, 11, 8, 13, 9, 16, 12, 19, 15,
22, 18, 25, 21, 28, 24, 29, 28, 33, 31, 35, 32, 38, 37, 41, 39, 43, 42, 45, 43,
47, 46, 49, 48, 51, 49, 52, 53, 53, 54, 54, 54, 55, 56, 56, 57, 57, 57, 57, 58,
56, 57, 56, 57, 57, 56, 55, 55, 54, 54, 52, 52, 50, 50, 49, 48, 46, 45, 44, 44,
40, 41, 38, 37, 34, 34, 31, 32, 28, 27, 24, 25, 20, 22, 16, 18, 13, 15, 9, 10,
6, 8, 2, 5, -1, 1, -5, -2, -7, -6, -10, -8, -12, -11, -14, -13, -16, -15, -18,
-17, -19, -20, -21, -21, -21, -22, -22, -24, -24, -24, -24, -26, -23, -25, -23,
-27, -24, -26, -23, -26, -22, -26, -22, -25, -21, -24, -20, -23, -19, -23, -18,
-20, -16, -20, -15, -18, -12, -17, -11, -15, -8, -12, -6, -10, -5, -9, -2, -6,
-1, -4, 1, -1, 4, 1, 7, 4, 9, 7, 12, 10, 15, 13, 18, 16, 20, 18, 23, 21, 26, 23,
28, 26, 30, 30, 33, 33, 37, 36, 39, 38, 41, 40, 44, 43, 46, 45, 49, 49, 51, 51,
53, 53, 56, 56, 58, 57, 61, 60, 63, 62, 65, 63, 67, 65, 68, 67, 70, 69, 72, 71,
72, 72, 75, 74, 76, 74, 77, 76, 78, 77, 79, 78, 80, 80, 82, 80, 82, 81, 82, 82,
83, 83, 84, 84, 84, 84, 84, 84, 82, 84, 84, 84, 82, 83, 82, 81, 80, 81, 78, 80,
77, 79, 74, 77, 72, 74, 70, 73, 68, 69, 64, 66, 59, 62, 56, 59, 52, 55, 47, 51,
43, 47, 37, 42, 32, 36, 28, 32, 21, 28, 17, 22, 12, 18, 7, 13, 1, 7, -3, 3, -9,
-1, -13, -6, -19, -10, -23, -14, -26, -18, -30, -23, -34, -26, -37, -28, -39,
-32, -42, -34, -44, -37, -47, -38, -49, -40, -49, -43, -50, -44, -52, -46, -52,
-47, -54, -48, -54, -49, -54, -50, -54, -51, -54, -51, -55, -52, -54, -52, -54,
-53, -53, -52, -54, -54, -53, -54, -53, -53, -53, -53, -53, -54, -51, -53, -52,
-52, -51, -52, -51, -50, -51, -50, -49, -49, -48, -48, -48, -46, -47, -46, -46,
-45, -46, -44, -44, -44, -44, -42, -44, -40, -43, -40, -42, -40, -42, -38, -41,
-38, -40, -37, -40, -36, -39, -35, -39, -35, -39, -34, -38, -34, -37, -34, -37,
-33, -37, -33, -36, -32, -36, -33, -36, -33, -35, -32, -35, -32, -34, -32, -34,
-32, -33, -32, -33, -30, -32, -31, -32, -30, -31, -30, -30, -30, -30, -29, -31,
-29, -29, -28, -30, -28, -29, -28, -28, -27, -28, -26, -28, -26, -27, -27, -28,
-27, -28, -27, -29, -28, -29, -28, -29, -28, -30, -28, -31, -31, -33, -31, -33,
-33, -35, -33, -36, -36, -38, -38, -40, -39, -42, -41, -44, -44, -45, -45, -48,
-48, -49, -49, -51, -51, -53, -54, -55, -56, -58, -58, -58, -60, -60, -61, -61,
-63, -63, -65, -64, -65, -66, -67, -66, -67, -67, -69, -68, -69, -68, -69, -68,
-69, -67, -70, -68, -69, -66, -68, -66, -66, -64, -67, -62, -65, -61, -65, -60,
-63, -59, -62, -56, -60, -54, -58, -52, -57, -49, -54, -47, -52, -44, -50, -42,
-47, -40, -46, -37, -43, -34, -40, -32, -37, -28, -35, -25, -32, -22, -28, -19,
-26, -15, -22, -11, -18, -8, -15, -4, -11, -1, -6, };