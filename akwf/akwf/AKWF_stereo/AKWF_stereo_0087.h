#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0087

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 1, 4, 2, 5, 3, 6, 4, 7, 5, 7, 5,
8, 6, 9, 7, 10, 8, 10, 9, 11, 10, 13, 11, 13, 11, 14, 13, 14, 13, 15, 14, 16,
15, 17, 16, 18, 17, 19, 18, 19, 18, 21, 19, 22, 20, 22, 21, 23, 22, 24, 23, 25,
24, 25, 24, 26, 25, 27, 26, 27, 27, 29, 27, 30, 28, 31, 29, 31, 29, 33, 30, 33,
31, 34, 32, 35, 33, 36, 34, 36, 36, 37, 35, 38, 36, 38, 38, 39, 39, 40, 39, 41,
40, 42, 42, 43, 42, 43, 43, 44, 44, 45, 44, 45, 45, 47, 46, 48, 47, 48, 49, 49,
51, 50, 52, 51, 53, 51, 54, 52, 55, 53, 56, 53, 56, 55, 57, 55, 58, 56, 59, 57,
60, 57, 61, 58, 61, 59, 62, 61, 63, 61, 64, 62, 64, 63, 65, 63, 66, 64, 67, 64,
67, 66, 69, 67, 69, 68, 70, 68, 71, 68, 72, 70, 72, 71, 73, 72, 73, 72, 74, 73,
75, 74, 76, 75, 77, 76, 78, 77, 79, 78, 79, 78, 80, 79, 81, 80, 81, 80, 82, 81,
83, 83, 83, 83, 85, 84, 84, 85, 85, 86, 87, 87, 88, 88, 87, 87, 89, 89, 90, 90,
90, 91, 92, 91, 92, 91, 93, 92, 94, 93, 94, 94, 95, 96, 97, 96, 97, 97, 98, 97,
99, 98, 100, 99, 100, 100, 101, 101, 102, 102, 103, 102, 103, 104, 105, 105,
105, 106, 106, 106, 107, 108, 108, 108, 109, 108, 109, 110, 111, 110, 112, 111,
112, 112, 113, 113, 114, 113, 114, 115, 115, 115, 116, 116, 117, 117, 117, 118,
116, 115, 114, 114, 111, 114, 110, 113, 110, 112, 108, 112, 108, 111, 106, 110,
106, 108, 106, 107, 104, 106, 102, 105, 101, 104, 101, 103, 100, 102, 100, 101,
99, 100, 98, 99, 98, 98, 97, 98, 96, 95, 95, 95, 94, 95, 94, 93, 93, 92, 92, 90,
91, 90, 90, 88, 89, 87, 88, 86, 88, 86, 87, 84, 87, 84, 86, 83, 85, 82, 83, 80,
83, 79, 82, 78, 82, 77, 80, 76, 79, 75, 78, 74, 78, 73, 76, 72, 75, 71, 74, 69,
73, 68, 72, 67, 71, 67, 70, 65, 69, 64, 68, 63, 67, 62, 66, 61, 64, 60, 64, 60,
63, 58, 61, 56, 61, 56, 60, 55, 58, 54, 57, 53, 56, 51, 55, 51, 54, 50, 52, 49,
52, 47, 50, 47, 49, 46, 48, 44, 47, 43, 45, 42, 44, 41, 43, 40, 43, 39, 41, 38,
39, 36, 38, 37, 38, 35, 35, 33, 34, 33, 34, 31, 33, 31, 32, 30, 30, 29, 29, 27,
28, 26, 28, 26, 25, 25, 24, 23, 24, 22, 22, 22, 21, 21, 21, 19, 18, 19, 17, 17,
17, 16, 15, 15, 15, 14, 14, 13, 12, 12, 11, 11, 10, 11, 9, 9, 9, 8, 8, 6, 6, 6,
5, 5, 5, 3, 4, 3, 2, 1, 2, 1, 0, -1, -1, -2, -1, -3, -2, -4, -3, -5, -4, -6, -5,
-7, -6, -8, -6, -9, -7, -10, -8, -11, -10, -13, -10, -13, -12, -14, -12, -15,
-14, -17, -14, -17, -15, -18, -16, -19, -18, -20, -18, -21, -19, -22, -20, -24,
-22, -24, -22, -26, -23, -27, -24, -28, -26, -28, -27, -29, -28, -31, -28, -32,
-30, -33, -31, -34, -32, -34, -33, -36, -33, -37, -35, -38, -36, -39, -37, -41,
-38, -41, -39, -42, -41, -43, -41, -44, -42, -45, -44, -46, -44, -47, -45, -47,
-46, -49, -47, -50, -49, -52, -49, -53, -51, -53, -52, -54, -53, -55, -54, -56,
-56, -58, -56, -58, -58, -60, -59, -61, -60, -62, -61, -62, -62, -63, -62, -64,
-64, -66, -65, -67, -66, -67, -67, -68, -69, -70, -69, -71, -71, -72, -72, -74,
-72, -74, -74, -75, -75, -76, -76, -78, -77, -77, -78, -79, -80, -79, -79, -80,
-81, -82, -83, -83, -84, -84, -85, -85, -85, -85, -86, -87, -88, -88, -89, -90,
-90, -89, -92, -91, -93, -92, -95, -93, -96, -94, -97, -95, -99, -95, -99, -98,
-100, -98, -102, -99, -103, -100, -104, -101, -105, -102, -106, -103, -107,
-104, -108, -105, -109, -106, -110, -107, -111, -108, -111, -109, -113, -111,
-114, -111, -115, -113, -116, -113, -116, -114, -118, -116, -119, -116, -119,
-118, -116, -117, -115, -116, -114, -115, -113, -115, -112, -114, -111, -113,
-110, -112, -108, -112, -108, -111, -108, -110, -107, -109, -105, -108, -105,
-107, -104, -105, -105, -106, -104, -105, -102, -104, -102, -103, -102, -102,
-102, -102, -100, -100, -99, -100, -99, -100, -99, -98, -99, -97, -97, -97, -97,
-95, -96, -94, -95, -94, -96, -93, -94, -93, -95, -92, -93, -91, -93, -90, -92,
-89, -92, -88, -91, -87, -90, -87, -89, -86, -88, -84, -89, -83, -87, -84, -86,
-82, -86, -81, -86, -81, -84, -80, -84, -80, -83, -79, -82, -79, -81, -77, -81,
-76, -80, -75, -79, -74, -78, -73, -77, -72, -76, -71, -75, -70, -74, -70, -72,
-69, -73, -69, -71, -67, -71, -67, -70, -65, -68, -65, -68, -64, -66, -63, -66,
-62, -66, -62, -64, -60, -63, -59, -62, -59, -61, -58, -60, -57, -59, -55, -58,
-54, -57, -55, -57, -53, -55, -53, -55, -52, -54, -51, -53, -51, -51, -50, -50,
-49, -49, -47, -48, -46, -48, -46, -46, -45, -46, -45, -45, -43, -44, -42, -43,
-42, -41, -41, -41, -40, -39, -38, -39, -38, -38, -38, -37, -37, -36, -36, -36,
-34, -35, -35, -34, -33, -32, -32, -32, -31, -31, -31, -31, -30, -30, -29, -29,
-29, -28, -27, -28, -26, -26, -25, -26, -25, -26, -24, -24, -23, -23, -22, -23,
-22, -22, -20, -21, -19, -20, -19, -19, -18, -19, -18, -18, -17, -17, -15, -17,
-15, -16, -14, -15, -13, -14, -12, -14, -12, -12, -11, -12, -10, -11, -10, -9,
-8, -9, -7, -9, -7, -7, -6, -7, -5, -7, -4, -5, -3, -5, -2, -4, -1, -4, -1, -3,
0, -2, 1, -1, 1, -1, 1, };