#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0032

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 65, 4, 74, 7, 64, 9, 65, 13, 57,
17, 55, 20, 46, 25, 41, 30, 32, 34, 28, 37, 19, 41, 13, 44, 5, 47, 0, 49, -5,
51, -9, 52, -14, 54, -17, 55, -20, 57, -23, 59, -27, 60, -33, 62, -37, 63, -42,
63, -44, 63, -46, 62, -43, 62, -41, 60, -39, 61, -37, 60, -34, 60, -32, 61, -31,
60, -29, 60, -27, 59, -25, 60, -25, 59, -27, 60, -28, 60, -30, 60, -33, 62, -37,
63, -39, 65, -41, 65, -42, 66, -42, 66, -42, 68, -40, 69, -37, 70, -35, 70, -33,
72, -32, 73, -31, 73, -32, 73, -30, 72, -30, 72, -30, 73, -30, 72, -31, 72, -33,
73, -33, 73, -33, 75, -33, 76, -30, 78, -26, 78, -23, 78, -20, 79, -15, 77, -13,
77, -12, 76, -11, 73, -12, 71, -14, 67, -16, 65, -19, 64, -23, 64, -26, 63, -29,
63, -31, 61, -32, 60, -29, 58, -25, 57, -19, 55, -12, 54, -3, 52, 6, 52, 16, 51,
24, 51, 30, 51, 35, 51, 41, 53, 45, 54, 50, 54, 54, 56, 56, 57, 58, 58, 59, 59,
59, 60, 58, 62, 58, 63, 57, 65, 57, 68, 57, 69, 59, 73, 60, 76, 62, 79, 63, 82,
64, 84, 63, 87, 61, 88, 59, 90, 58, 90, 57, 91, 54, 90, 52, 91, 50, 92, 49, 93,
48, 93, 48, 93, 48, 91, 50, 88, 52, 85, 55, 81, 56, 77, 59, 75, 61, 72, 61, 70,
61, 69, 59, 67, 56, 66, 55, 66, 52, 65, 51, 65, 49, 65, 45, 65, 43, 65, 42, 65,
42, 64, 43, 62, 43, 62, 43, 62, 43, 63, 41, 63, 39, 64, 37, 64, 33, 65, 30, 63,
25, 62, 20, 62, 16, 61, 11, 60, 7, 59, 4, 59, 1, 58, -1, 58, -2, 57, -2, 57, -1,
57, 0, 58, 3, 57, 3, 57, 4, 57, 5, 56, 6, 54, 5, 52, 5, 51, 4, 49, 3, 48, 2, 46,
3, 44, 4, 41, 7, 38, 10, 36, 11, 33, 13, 30, 13, 28, 14, 26, 14, 24, 12, 23, 11,
22, 9, 21, 6, 20, 3, 18, 2, 17, -1, 17, -5, 16, -7, 15, -10, 16, -12, 15, -14,
15, -15, 15, -17, 16, -19, 16, -22, 14, -25, 12, -28, 12, -30, 12, -32, 13, -33,
13, -33, 13, -33, 14, -34, 16, -35, 17, -36, 18, -39, 17, -42, 18, -47, 19, -51,
19, -56, 21, -60, 22, -63, 22, -65, 22, -65, 21, -64, 20, -64, 18, -61, 15, -61,
14, -59, 12, -57, 9, -57, 8, -56, 6, -56, 4, -56, 2, -55, 1, -54, 0, -55, -1,
-55, -3, -56, -5, -59, -6, -63, -7, -70, -8, -76, -9, -84, -11, -91, -13, -98,
-17, -105, -20, -111, -25, -114, -29, -117, -33, -118, -38, -119, -41, -119,
-45, -118, -49, -119, -51, -117, -51, -117, -51, -118, -50, -117, -48, -118,
-44, -117, -41, -118, -36, -113, -32, -104, -29, -93, -25, -85, -23, -76, -19,
-67, -17, -61, -15, -55, -14, -50, -13, -45, -13, -41, -13, -38, -12, -37, -12,
-37, -13, -38, -13, -39, -13, -41, -14, -44, -13, -45, -14, -48, -15, -50, -15,
-52, -16, -55, -17, -57, -17, -58, -19, -58, -19, -60, -19, -59, -20, -61, -20,
-61, -21, -59, -22, -57, -22, -53, -22, -48, -20, -44, -19, -39, -18, -35, -18,
-32, -16, -29, -16, -26, -18, -23, -18, -20, -20, -15, -21, -10, -24, -3, -26,
4, -29, 11, -33, 17, -35, 24, -37, 32, -39, 38, -40, 44, -42, 49, -43, 53, -45,
56, -47, 59, -50, 60, -53, 61, -55, 62, -58, 61, -61, 62, -62, 60, -64, 58, -65,
55, -66, 53, -68, 48, -69, 44, -71, 40, -71, 36, -71, 33, -71, 27, -68, 22, -68,
17, -66, 11, -64, 8, -62, 4, -62, 0, -60, -2, -60, -5, -59, -6, -59, -7, -58,
-6, -59, -6, -59, -4, -58, -2, -57, 1, -57, 5, -57, 6, -57, 6, -57, 7, -57, 6,
-56, 5, -54, 3, -53, 2, -53, 1, -51, 1, -50, 1, -49, 0, -48, -1, -47, -2, -45,
-5, -45, -7, -43, -8, -41, -9, -39, -7, -37, -6, -35, -5, -34, -5, -33, -6, -32,
-7, -30, -11, -29, -14, -27, -17, -26, -20, -24, -22, -23, -23, -23, -22, -22,
-20, -21, -17, -21, -16, -22, -15, -22, -15, -24, -15, -25, -14, -26, -14, -26,
-12, -27, -8, -28, -5, -28, -2, -27, 1, -28, 3, -26, 5, -26, 10, -26, 12, -25,
13, -25, 15, -25, 16, -25, 17, -26, 18, -26, 18, -27, 19, -28, 18, -29, 16, -31,
14, -31, 11, -34, 7, -37, 3, -38, -1, -40, -4, -41, -6, -41, -8, -41, -10, -42,
-12, -41, -13, -40, -14, -38, -14, -37, -15, -36, -15, -35, -14, -34, -13, -33,
-10, -29, -7, -27, -4, -24, -2, -22, 1, -26, 3, -36, 4, -45, 4, -53, 5, -57, 5,
-63, 5, -66, 6, -69, 8, -72, 8, -74, 9, -76, 8, -79, 7, -81, 5, -84, 4, -87, 2,
-90, 0, -94, 0, -97, 1, -102, 3, -104, 6, -108, 9, -111, 11, -113, 14, -115, 18,
-116, 20, -118, 20, -119, 20, -119, 18, -119, 17, -118, 14, -116, 13, -113, 11,
-110, 11, -106, 12, -101, 14, -98, 17, -94, 22, -91, 26, -87, 30, -86, 34, -83,
38, -80, 40, -77, 43, -73, 44, -68, 43, -64, 43, -59, 44, -54, 45, -48, 47, -43,
49, -38, 47, -32, 46, -28, 44, -25, 43, -23, 42, -19, 41, -18, 39, -17, 40, -15,
39, -14, 40, -12, 41, -13, 43, -13, 44, -14, 46, -14, 47, -16, 49, -16, 50, -17,
51, -17, 51, -18, 53, -18, 52, -20, 53, -22, 56, -23, 59, -24, 62, -24, 66, -23,
69, -23, 73, -21, 75, -20, 75, -19, 77, -18, 75, -17, 76, -16, 74, -14, 75, -12,
74, -11, 75, -10, 75, -8, 79, -7, 78, -6, 83, -6, 80, -5, 86, -3, 78, -2, 85,
-1, 66, };