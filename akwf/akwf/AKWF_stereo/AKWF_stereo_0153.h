#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0153

const PROGMEM int8_t DATA[DATA_LENGTH] = {19, 55, 47, 79, 100, 104, 71, 89, 51,
75, 28, 62, 23, 56, 26, 57, 22, 53, 24, 54, 21, 50, 22, 50, 19, 47, 20, 48, 19,
44, 20, 44, 17, 41, 19, 40, 15, 38, 16, 37, 14, 36, 16, 34, 13, 31, 13, 30, 12,
29, 12, 27, 10, 25, 10, 23, 10, 22, 9, 20, 9, 19, 7, 17, 7, 16, 6, 13, 6, 12, 5,
11, 4, 10, 3, 8, 3, 6, 2, 4, 1, 3, 0, 2, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 1, 0, 0, 0, 1, 1, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0, -1,
1, 0, -1, 0, 0, -1, 0, 0, 0, -1, 0, -1, -1, 1, 0, 0, 0, 1, -1, -1, 0, -1, 0, 0,
0, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
-1, 0, 0, 0, 0, 0, -1, 1, 1, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0,
0, 0, 0, -1, 0, 0, 1, 0, 0, 1, 0, 1, 0, 1, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0,
0, 0, 1, 1, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 1,
0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, -1, 0, 0, 0, 1, 0,
0, 1, 0, 1, 1, 0, 0, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
0, 0, -1, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, -1, 0, 1, 0, 0, 1, 0, 0, 0, -1, 1, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, -1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 1, 1, 1, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0,
1, 0, 0, 0, 1, 0, 0, 0, 1, 0, -1, 0, 0, 1, -1, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 1, 0, 1,
-1, 0, -1, 0, -1, -1, 0, 0, 0, 0, -1, 0, -1, 0, -1, 0, 0, 0, -1, 0, 1, 0, 0, 0,
0, 1, 0, 1, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1,
0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, -1,
0, 1, 0, 0, 0, -1, 1, 1, 0, 0, 1, -1, 0, 0, 0, -1, 0, 0, 0, 1, -1, -1, 0, 1, -1,
1, 0, 1, 0, 0, 1, 0, 1, 0, 0, -1, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0, -1, 1, 0, 0, -1, 0,
0, 0, 0, -1, 0, 0, 1, 0, 0, -1, 0, -1, 1, 0, 0, 0, 0, 0, 1, 1, 0, 0, -1, 0, 0,
0, 0, 0, 0, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, -1, 0, 0, 0,
1, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0,
1, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0,
0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 0,
1, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0,
0, -1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -2, -1,
-3, -1, -3, -1, -3, -1, -4, -2, -5, -3, -6, -3, -7, -3, -7, -4, -8, -5, -8, -5,
-9, -6, -10, -6, -11, -6, -12, -7, -13, -7, -13, -7, -14, -8, -15, -8, -17, -9,
-17, -10, -18, -9, -18, -10, -20, -11, -19, -12, -20, -12, -21, -12, -23, -13,
-23, -13, -23, -14, -24, -14, -25, -15, -26, -15, -27, -16, -27, -15, -28, -16,
-28, -17, -29, -17, -30, -18, -30, -18, -32, -19, -32, -19, -33, -19, -33, -20,
-35, -21, -36, -21, -37, -22, -37, -22, -38, -22, -39, -23, -39, -23, -40, -23,
-41, -24, -42, -24, -42, -25, -43, -26, -43, -26, -45, -26, -45, -26, -46, -27,
-47, -28, -48, -29, -48, -29, -50, -29, -50, -29, -51, -29, -51, -30, -52, -30,
-52, -31, -54, -30, -54, -32, -55, -32, -56, -33, -57, -32, -58, -35, -60, -37,
-61, -38, -62, -41, -63, -42, -65, -45, -67, -47, -69, -50, -69, -51, -71, -53,
-72, -55, -74, -57, -75, -59, -77, -61, -78, -63, -79, -66, -80, -67, -82, -69,
-84, -72, -86, -74, -87, -75, -88, -78, -90, -79, -91, -81, -93, -85, -94, -86,
-97, -89, -96, -89, -98, -93, -99, -93, -102, -97, -101, -97, -106, -102, -104,
-100, -109, -106, -106, -104, -112, -110, -109, -108, -115, -113, -112, -114,
-118, -118, -115, -120, -100, -66, -75, -40, };