#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0029

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 56, 1, 67, 2, 64, 3, 69, 4, 66, 5,
70, 6, 68, 7, 71, 7, 70, 8, 72, 9, 70, 10, 71, 10, 69, 12, 69, 13, 68, 13, 69,
15, 67, 17, 65, 17, 65, 18, 64, 19, 62, 21, 62, 22, 61, 23, 59, 24, 60, 25, 58,
26, 57, 26, 57, 27, 56, 28, 54, 28, 53, 28, 50, 30, 50, 31, 49, 31, 47, 32, 45,
33, 43, 33, 42, 34, 39, 34, 37, 35, 36, 36, 34, 35, 33, 36, 32, 36, 30, 38, 29,
39, 27, 38, 25, 39, 23, 40, 21, 41, 20, 43, 17, 45, 15, 46, 12, 47, 10, 49, 8,
51, 6, 52, 2, 55, 1, 56, -2, 58, -4, 60, -6, 61, -7, 63, -9, 65, -11, 66, -12,
69, -13, 70, -15, 71, -15, 72, -17, 74, -17, 76, -18, 75, -19, 77, -20, 78, -21,
79, -22, 80, -23, 81, -23, 81, -23, 83, -23, 84, -24, 84, -24, 85, -24, 86, -25,
85, -24, 86, -25, 86, -25, 88, -25, 88, -25, 88, -25, 88, -25, 89, -25, 89, -25,
91, -25, 91, -24, 92, -22, 91, -21, 93, -19, 93, -17, 93, -15, 95, -13, 95, -10,
96, -9, 97, -6, 99, -3, 100, -1, 101, 1, 102, 2, 103, 5, 104, 6, 106, 8, 107, 9,
108, 9, 110, 10, 110, 11, 112, 12, 113, 13, 114, 14, 114, 13, 117, 15, 117, 15,
117, 16, 119, 16, 118, 17, 119, 16, 120, 17, 118, 17, 119, 18, 118, 18, 118, 18,
117, 19, 117, 21, 115, 21, 114, 22, 113, 21, 111, 23, 111, 23, 109, 24, 106, 25,
105, 25, 104, 25, 100, 26, 99, 25, 97, 25, 95, 24, 93, 24, 91, 24, 89, 24, 87,
23, 85, 24, 83, 23, 81, 24, 80, 24, 78, 25, 76, 23, 75, 23, 73, 22, 72, 22, 70,
22, 69, 20, 68, 20, 65, 19, 65, 18, 63, 17, 62, 15, 61, 14, 60, 13, 59, 12, 57,
10, 56, 9, 55, 8, 55, 7, 54, 6, 53, 5, 53, 4, 52, 2, 51, 1, 50, 1, 49, -1, 49,
-3, 47, -3, 46, -3, 45, -4, 45, -4, 43, -4, 42, -5, 40, -3, 39, -3, 38, -3, 37,
-2, 35, -2, 35, -1, 33, -1, 33, -2, 31, -2, 31, -2, 30, -2, 29, -2, 29, -3, 28,
-3, 27, -4, 26, -4, 27, -4, 25, -4, 26, -4, 25, -5, 26, -5, 25, -5, 24, -6, 24,
-7, 24, -8, 24, -8, 25, -9, 25, -9, 25, -10, 26, -10, 25, -11, 25, -12, 25, -12,
26, -13, 26, -13, 25, -14, 24, -16, 25, -16, 23, -17, 23, -19, 23, -20, 22, -22,
21, -23, 20, -25, 19, -27, 18, -29, 18, -31, 16, -35, 14, -37, 14, -41, 13, -44,
11, -46, 8, -50, 8, -53, 6, -55, 5, -58, 2, -62, 0, -64, -2, -68, -4, -71, -7,
-74, -8, -78, -10, -80, -13, -83, -15, -86, -18, -90, -20, -92, -21, -94, -24,
-97, -25, -99, -27, -99, -29, -102, -29, -102, -32, -103, -32, -105, -33, -105,
-34, -107, -34, -108, -35, -109, -36, -110, -37, -110, -37, -111, -37, -111,
-38, -111, -38, -112, -39, -112, -39, -112, -39, -113, -39, -113, -40, -114,
-41, -114, -41, -114, -42, -116, -44, -117, -43, -116, -45, -117, -46, -118,
-47, -118, -47, -119, -49, -119, -49, -119, -51, -119, -53, -119, -53, -118,
-54, -118, -55, -118, -57, -116, -58, -115, -59, -114, -60, -112, -61, -110,
-62, -107, -62, -105, -63, -102, -65, -99, -65, -95, -66, -92, -66, -88, -68,
-84, -68, -81, -69, -77, -69, -73, -70, -68, -71, -64, -72, -61, -72, -56, -73,
-51, -73, -48, -74, -44, -74, -40, -74, -37, -74, -33, -74, -29, -74, -25, -75,
-23, -75, -19, -75, -15, -75, -13, -74, -11, -75, -7, -75, -6, -74, -3, -75, -1,
-74, 1, -74, 2, -75, 3, -75, 5, -74, 5, -74, 5, -74, 6, -74, 7, -73, 7, -74, 6,
-73, 8, -73, 8, -73, 8, -73, 8, -73, 10, -72, 10, -73, 11, -74, 11, -73, 12,
-73, 12, -73, 11, -72, 12, -71, 11, -72, 12, -71, 11, -71, 11, -70, 11, -70, 11,
-69, 12, -69, 12, -68, 12, -68, 13, -67, 13, -66, 13, -66, 14, -64, 13, -64, 12,
-63, 12, -62, 12, -61, 11, -60, 10, -59, 10, -58, 9, -56, 8, -55, 7, -55, 6,
-54, 6, -53, 5, -52, 4, -51, 4, -50, 4, -49, 3, -47, 3, -47, 3, -45, 4, -45, 4,
-44, 4, -43, 5, -42, 4, -41, 4, -41, 4, -40, 4, -40, 4, -40, 4, -40, 4, -40, 4,
-40, 5, -39, 5, -40, 6, -41, 7, -41, 6, -42, 7, -43, 8, -44, 8, -44, 9, -46, 9,
-47, 10, -47, 10, -47, 11, -48, 12, -48, 13, -48, 14, -50, 15, -51, 16, -50, 17,
-51, 19, -52, 21, -51, 22, -52, 25, -53, 26, -53, 29, -53, 30, -53, 32, -53, 34,
-52, 35, -53, 36, -52, 39, -53, 40, -53, 41, -53, 42, -54, 43, -54, 45, -55, 46,
-56, 46, -56, 47, -57, 48, -58, 48, -59, 48, -60, 47, -61, 47, -63, 46, -63, 46,
-64, 46, -64, 45, -66, 44, -66, 44, -67, 43, -67, 43, -68, 42, -69, 41, -69, 42,
-70, 42, -70, 42, -71, 41, -71, 42, -70, 41, -71, 43, -70, 42, -71, 42, -70, 42,
-70, 43, -69, 44, -69, 43, -68, 44, -66, 45, -66, 46, -65, 47, -63, 48, -62, 48,
-60, 50, -59, 50, -58, 51, -57, 53, -55, 52, -54, 53, -53, 54, -51, 54, -50, 55,
-47, 55, -46, 55, -43, 55, -42, 54, -41, 54, -39, 52, -37, 52, -35, 51, -33, 51,
-31, 49, -29, 49, -27, 48, -26, 48, -25, 46, -22, 47, -21, 47, -20, 47, -19, 47,
-17, 47, -16, 47, -15, 48, -14, 49, -14, 48, -12, 50, -11, 51, -11, 53, -9, 52,
-7, 56, -7, 55, -6, 60, -5, 57, -4, 63, -2, 59, -2, 67, -1, 54, };