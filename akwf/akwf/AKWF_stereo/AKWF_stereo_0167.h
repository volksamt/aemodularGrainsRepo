#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0167

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -72, 4, -89, 7, -83, 11, -86, 15,
-78, 20, -76, 24, -68, 29, -66, 31, -61, 33, -62, 37, -56, 40, -57, 42, -55, 45,
-57, 48, -53, 51, -52, 56, -46, 60, -41, 65, -34, 69, -27, 75, -18, 79, -9, 84,
-1, 88, 6, 91, 15, 94, 21, 96, 22, 97, 25, 100, 30, 102, 34, 103, 37, 106, 41,
107, 47, 109, 54, 109, 58, 110, 63, 111, 68, 111, 76, 111, 82, 112, 90, 114, 98,
115, 107, 114, 114, 114, 115, 113, 117, 112, 118, 110, 115, 108, 111, 106, 107,
103, 104, 99, 101, 96, 95, 92, 90, 88, 88, 84, 85, 81, 84, 78, 83, 74, 84, 72,
85, 69, 85, 63, 80, 60, 74, 53, 67, 47, 59, 42, 53, 37, 46, 33, 40, 28, 34, 22,
30, 16, 28, 12, 26, 7, 26, 3, 27, -3, 28, -6, 30, -10, 31, -14, 33, -17, 33,
-22, 31, -25, 29, -30, 25, -33, 22, -37, 19, -40, 16, -45, 13, -48, 11, -52, 7,
-56, 2, -58, 0, -61, -1, -64, -3, -67, -3, -69, -3, -71, -4, -73, -3, -76, -4,
-78, -8, -81, -13, -83, -18, -85, -25, -87, -31, -89, -37, -91, -42, -94, -49,
-94, -55, -97, -61, -98, -65, -97, -66, -98, -68, -98, -69, -97, -67, -97, -66,
-96, -65, -96, -66, -94, -66, -92, -68, -90, -70, -87, -72, -87, -73, -86, -75,
-84, -77, -82, -79, -81, -81, -78, -82, -75, -82, -72, -80, -71, -78, -69, -76,
-66, -74, -65, -73, -63, -69, -60, -67, -56, -62, -54, -60, -52, -58, -50, -58,
-48, -58, -46, -59, -43, -58, -39, -57, -34, -55, -30, -53, -27, -51, -23, -48,
-20, -45, -17, -43, -15, -42, -12, -40, -10, -38, -8, -37, -5, -37, -1, -37, 2,
-36, 7, -35, 11, -32, 16, -30, 22, -28, 27, -28, 32, -27, 35, -26, 39, -25, 41,
-26, 41, -28, 40, -31, 41, -33, 40, -35, 41, -36, 42, -35, 43, -35, 43, -36, 45,
-36, 45, -37, 46, -37, 48, -35, 50, -35, 52, -34, 55, -33, 57, -35, 57, -35, 57,
-36, 57, -36, 59, -35, 58, -34, 58, -32, 58, -28, 58, -23, 57, -18, 56, -16, 55,
-14, 54, -12, 52, -11, 51, -12, 49, -11, 49, -9, 48, -8, 46, -8, 43, -7, 41, -6,
39, -3, 37, 1, 35, 5, 34, 7, 31, 10, 30, 15, 28, 19, 26, 22, 25, 25, 22, 28, 20,
31, 19, 34, 18, 38, 17, 43, 16, 49, 16, 55, 17, 60, 17, 64, 17, 68, 17, 72, 19,
77, 20, 82, 20, 87, 20, 94, 20, 98, 19, 101, 19, 103, 18, 103, 17, 104, 16, 105,
16, 104, 15, 105, 15, 104, 14, 103, 14, 103, 12, 101, 11, 102, 10, 101, 9, 103,
8, 104, 6, 106, 5, 107, 4, 108, 2, 105, 2, 103, 1, 101, -1, 100, -2, 97, -2, 92,
-2, 91, -2, 91, 0, 90, 1, 91, 1, 93, 0, 94, -1, 94, -2, 96, -4, 95, -4, 94, -6,
93, -7, 93, -9, 89, -11, 87, -11, 84, -12, 81, -13, 79, -14, 79, -14, 79, -14,
80, -14, 78, -14, 79, -15, 80, -17, 80, -17, 82, -18, 85, -19, 86, -20, 84, -22,
83, -23, 82, -23, 78, -23, 74, -23, 68, -25, 63, -26, 57, -27, 50, -28, 44, -29,
39, -29, 33, -30, 28, -29, 23, -29, 19, -29, 13, -29, 9, -29, 5, -28, -1, -28,
-8, -28, -17, -29, -26, -30, -34, -31, -42, -33, -49, -34, -57, -35, -63, -37,
-67, -40, -72, -42, -79, -44, -84, -45, -88, -46, -92, -47, -96, -47, -99, -47,
-103, -46, -104, -46, -106, -45, -107, -43, -109, -43, -108, -42, -108, -40,
-109, -39, -110, -39, -109, -38, -110, -35, -111, -33, -112, -31, -112, -30,
-113, -29, -115, -27, -114, -27, -116, -26, -116, -23, -117, -22, -117, -21,
-117, -18, -119, -17, -119, -15, -118, -12, -118, -9, -119, -6, -119, -2, -118,
1, -117, 3, -117, 5, -117, 8, -115, 9, -114, 11, -113, 12, -113, 15, -111, 17,
-111, 21, -109, 22, -109, 24, -108, 25, -108, 28, -107, 30, -105, 32, -103, 35,
-100, 37, -98, 39, -97, 40, -96, 41, -95, 42, -94, 42, -95, 43, -93, 42, -92,
42, -91, 42, -90, 42, -88, 41, -87, 40, -86, 38, -86, 37, -84, 36, -81, 34, -78,
34, -76, 34, -72, 34, -68, 36, -64, 35, -62, 36, -58, 35, -55, 36, -52, 37, -48,
36, -44, 37, -38, 37, -32, 37, -25, 38, -18, 39, -10, 39, -1, 40, 6, 41, 13, 42,
20, 42, 27, 43, 34, 43, 39, 45, 44, 46, 48, 47, 53, 49, 57, 49, 60, 48, 64, 48,
68, 48, 72, 48, 74, 46, 77, 44, 81, 43, 85, 42, 91, 40, 94, 38, 98, 36, 101, 34,
102, 32, 104, 29, 104, 26, 103, 25, 103, 22, 102, 18, 103, 15, 101, 10, 101, 7,
100, 2, 97, 0, 96, -4, 96, -5, 96, -8, 95, -10, 94, -13, 92, -15, 91, -17, 90,
-20, 88, -24, 85, -27, 82, -29, 80, -31, 78, -34, 76, -35, 76, -36, 76, -38, 75,
-40, 72, -42, 69, -44, 66, -46, 64, -48, 61, -52, 58, -54, 56, -56, 53, -58, 52,
-60, 50, -61, 48, -63, 46, -64, 45, -65, 44, -64, 43, -66, 42, -66, 40, -68, 39,
-68, 34, -71, 30, -73, 26, -76, 19, -79, 13, -82, 9, -84, 4, -85, 2, -84, 0,
-84, -3, -83, -6, -83, -10, -81, -11, -79, -14, -78, -16, -77, -21, -76, -25,
-76, -27, -74, -29, -74, -33, -73, -37, -73, -38, -71, -39, -70, -39, -71, -41,
-71, -44, -70, -45, -67, -46, -66, -48, -67, -53, -64, -54, -61, -55, -58, -57,
-56, -61, -54, -62, -51, -62, -45, -59, -42, -58, -41, -61, -39, -62, -36, -61,
-33, -62, -31, -63, -28, -62, -24, -60, -20, -57, -19, -60, -16, -58, -15, -62,
-13, -62, -12, -69, -10, -67, -8, -72, -5, -67, -4, -81, -1, -68, };