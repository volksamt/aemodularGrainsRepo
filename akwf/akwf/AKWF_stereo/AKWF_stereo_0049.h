#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0049

const PROGMEM int8_t DATA[DATA_LENGTH] = {55, 70, 120, 91, 116, 68, 112, 70,
105, 65, 108, 68, 113, 66, 118, 70, 118, 68, 113, 70, 107, 69, 104, 70, 106, 71,
108, 71, 109, 71, 106, 71, 100, 71, 96, 70, 96, 70, 97, 70, 99, 71, 99, 70, 96,
71, 94, 70, 93, 71, 94, 71, 96, 72, 98, 70, 98, 71, 97, 70, 96, 72, 97, 71, 98,
70, 101, 71, 101, 70, 101, 71, 102, 71, 101, 71, 102, 71, 103, 71, 104, 71, 104,
70, 104, 71, 103, 71, 103, 71, 102, 71, 103, 71, 103, 71, 103, 71, 102, 72, 102,
70, 101, 71, 102, 71, 102, 71, 101, 70, 100, 71, 100, 70, 100, 71, 100, 70, 99,
71, 100, 71, 100, 70, 99, 71, 100, 71, 99, 71, 99, 71, 100, 71, 101, 71, 100,
71, 100, 71, 101, 71, 100, 71, 101, 70, 101, 70, 101, 71, 102, 71, 101, 71, 101,
70, 101, 70, 101, 71, 102, 71, 101, 71, 101, 71, 102, 71, 101, 71, 102, 70, 100,
71, 101, 71, 101, 70, 101, 71, 101, 71, 101, 71, 101, 71, 100, 71, 101, 72, 100,
71, 100, 70, 101, 71, 100, 71, 101, 71, 100, 71, 101, 71, 101, 71, 101, 70, 101,
71, 100, 71, 100, 71, 101, 71, 101, 71, 100, 70, 101, 71, 100, 71, 101, 71, 101,
71, 102, 71, 101, 71, 101, 72, 101, 71, 101, 71, 100, 71, 101, 71, 101, 72, 101,
70, 101, 71, 101, 71, 100, 71, 101, 71, 101, 71, 100, 70, 101, 71, 101, 71, 101,
71, 101, 71, 101, 71, 100, 71, 101, 71, 101, 72, 100, 70, 100, 71, 101, 71, 100,
71, 100, 71, 101, 71, 100, 70, 100, 71, 101, 71, 100, 71, 101, 71, 101, 71, 101,
71, 101, 71, 101, 71, 101, 72, 101, 71, 101, 72, 101, 71, 100, 71, 100, 71, 100,
72, 100, 71, 101, 71, 100, 71, 101, 71, 101, 72, 101, 71, 101, 71, 100, 70, 102,
71, 100, 70, 101, 71, 101, 70, 101, 70, 101, 70, 101, 71, 101, 71, 101, 71, 101,
70, 101, 71, 102, 71, 101, 71, 101, 71, 101, 71, 101, 71, 101, 71, 100, 70, 101,
71, 101, 72, 101, 71, 102, 70, 101, 70, 101, 72, 100, 71, 101, 71, 101, 70, 100,
71, 101, 71, 101, 71, 101, 71, 101, 71, 101, 71, 100, 71, 101, 71, 101, 71, 102,
72, 101, 70, 103, 72, 100, 70, 102, 72, 100, 70, 102, 72, 100, 69, 102, 72, 100,
69, 102, 72, 100, 70, 102, 72, 101, 69, 102, 72, 100, 70, 101, 72, 101, 70, 100,
70, 103, 72, 97, 68, 102, 71, -65, -81, -127, -97, -109, -60, -116, -75, -99,
-62, -112, -71, -111, -64, -121, -71, -116, -66, -114, -72, -105, -67, -106,
-72, -105, -68, -109, -72, -108, -69, -105, -71, -100, -70, -96, -71, -96, -70,
-98, -70, -100, -71, -98, -70, -96, -71, -92, -71, -93, -72, -94, -71, -96, -71,
-98, -70, -99, -71, -97, -71, -97, -71, -97, -70, -99, -71, -100, -70, -102,
-71, -101, -71, -101, -70, -102, -71, -102, -71, -103, -71, -104, -71, -104,
-70, -104, -71, -103, -71, -104, -71, -103, -70, -103, -71, -103, -71, -103,
-71, -103, -71, -101, -71, -102, -71, -102, -70, -102, -71, -102, -70, -102,
-70, -101, -71, -100, -71, -101, -71, -100, -71, -100, -71, -100, -71, -100,
-71, -100, -71, -100, -72, -100, -71, -100, -71, -100, -71, -100, -72, -101,
-71, -101, -71, -101, -70, -101, -71, -101, -71, -101, -70, -101, -71, -101,
-70, -101, -71, -102, -70, -102, -70, -101, -71, -102, -70, -101, -71, -101,
-71, -101, -70, -101, -70, -101, -71, -102, -71, -101, -71, -101, -70, -101,
-71, -101, -71, -102, -70, -102, -71, -100, -71, -101, -71, -100, -71, -100,
-71, -100, -71, -101, -71, -101, -71, -101, -71, -101, -71, -100, -71, -101,
-71, -100, -71, -101, -72, -100, -70, -101, -71, -101, -71, -101, -70, -101,
-70, -100, -71, -101, -71, -101, -71, -102, -71, -100, -71, -100, -72, -101,
-71, -100, -70, -101, -71, -101, -71, -101, -72, -101, -71, -101, -71, -102,
-71, -101, -71, -101, -72, -101, -70, -102, -70, -100, -71, -102, -71, -101,
-71, -101, -71, -101, -71, -101, -71, -100, -71, -100, -71, -101, -71, -100,
-71, -101, -70, -101, -71, -101, -72, -101, -71, -101, -71, -101, -71, -101,
-71, -101, -71, -101, -70, -101, -70, -101, -70, -101, -71, -101, -71, -100,
-71, -102, -71, -101, -70, -101, -70, -101, -71, -101, -71, -101, -71, -100,
-71, -101, -71, -101, -71, -101, -71, -101, -71, -101, -71, -101, -70, -101,
-72, -101, -70, -101, -71, -100, -70, -102, -71, -101, -70, -100, -71, -101,
-71, -101, -71, -101, -71, -101, -72, -101, -71, -100, -70, -101, -71, -102,
-72, -101, -71, -100, -71, -101, -71, -101, -71, -100, -71, -101, -70, -101,
-71, -101, -71, -101, -70, -100, -71, -101, -72, -100, -70, -101, -71, -101,
-71, -101, -71, -101, -71, -101, -72, -101, -71, -101, -71, -101, -71, -101,
-72, -101, -72, -100, -71, -102, -71, -101, -70, -100, -70, -101, -71, -101,
-71, -101, -72, -101, -71, -101, -71, -102, -71, -101, -71, -101, -72, -101,
-71, -100, -71, -100, -71, -101, -71, -101, -71, -102, -71, -101, -71, -101,
-71, -101, -71, -100, -71, -101, -72, -101, -72, -101, -71, -101, -71, -101,
-71, -101, -70, -100, -70, -101, -71, -101, -71, -101, -71, -101, -71, -101,
-72, -101, -72, -101, -71, -101, -71, -101, -70, -101, -72, -101, -71, -101,
-71, -101, -71, -101, -70, -100, -71, -101, -72, -101, -71, -100, -71, -101,
-71, -101, -71, -101, -70, -102, -71, -101, -70, -101, -71, -101, -71, -102,
-71, -101, -71, -101, -72, -100, -71, -101, -70, -101, -71, -102, -71, -101,
-71, -101, -70, -101, -70, -101, -71, -101, -71, -100, -72, -101, -72, -101,
-70, -102, -71, -100, -70, -102, -72, -100, -70, -103, -72, -100, -70, -103,
-72, -99, -70, -104, -73, -98, -69, -104, -73, -97, -68, -107, -75, -86, -60, };