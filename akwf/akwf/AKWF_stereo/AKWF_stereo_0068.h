#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0068

const PROGMEM int8_t DATA[DATA_LENGTH] = {30, 92, 73, 97, 85, 80, 89, 83, 90,
75, 91, 80, 91, 75, 91, 80, 91, 76, 91, 79, 90, 76, 90, 78, 90, 76, 90, 76, 91,
75, 91, 76, 91, 76, 90, 76, 91, 75, 90, 76, 90, 75, 91, 75, 90, 76, 90, 75, 90,
76, 90, 75, 90, 76, 90, 75, 90, 76, 90, 75, 91, 76, 91, 76, 90, 77, 90, 76, 90,
77, 91, 77, 91, 78, 90, 78, 91, 78, 91, 79, 91, 78, 91, 79, 92, 78, 91, 80, 91,
79, 91, 80, 91, 79, 91, 82, 92, 79, 91, 82, 93, 79, 92, 83, 92, 80, 92, 83, 93,
81, 93, 83, 92, 81, 92, 83, 93, 83, 93, 83, 93, 86, 94, 81, 92, 92, 104, -15,
61, -34, 17, -4, 7, -7, 2, 6, 3, 1, 0, 7, 3, 3, 1, 7, 3, 4, 1, 8, 2, 7, 2, 10,
2, 9, 2, 11, 4, 10, 3, 12, 4, 11, 3, 12, 3, 11, 4, 12, 4, 13, 4, 13, 4, 13, 4,
13, 4, 13, 4, 13, 4, 14, 5, 13, 3, 14, 5, 14, 4, 14, 3, 13, 4, 13, 5, 13, 4, 14,
5, 13, 4, 14, 4, 13, 4, 13, 4, 13, 4, 13, 3, 13, 4, 12, 3, 12, 4, 11, 4, 11, 3,
12, 4, 11, 3, 10, 3, 10, 3, 11, 3, 10, 3, 10, 3, 9, 3, 9, 3, 9, 2, 9, 2, 8, 2,
8, 3, 8, 3, 8, 2, 8, 2, 8, 2, 7, 2, 7, 2, 6, 2, 6, 2, 4, 1, 6, 1, 5, 1, 4, 1, 4,
1, 4, 1, 4, 1, 4, 1, 4, 1, 3, 1, 2, 0, 3, 0, 2, 0, 2, 0, 1, 1, 2, 0, 2, 0, 2, 1,
1, 0, 1, 0, 1, 1, 1, 0, 1, 0, -1, -1, 1, 0, -1, 0, 3, 0, -2, -1, 6, 4, -30, -10,
-54, -34, -38, -41, -40, -44, -33, -44, -35, -45, -33, -44, -34, -45, -33, -45,
-34, -45, -34, -45, -33, -45, -33, -45, -33, -44, -33, -45, -33, -44, -33, -45,
-33, -45, -33, -44, -32, -45, -33, -45, -32, -45, -33, -45, -32, -44, -33, -45,
-31, -44, -33, -45, -32, -45, -33, -44, -32, -44, -32, -45, -33, -45, -32, -45,
-34, -45, -31, -44, -34, -45, -31, -44, -35, -45, -29, -43, -39, -49, -7, -38,
21, -12, 5, -4, 6, -1, 0, -1, 1, 0, -1, 0, 1, 0, -1, 0, 0, -1, -1, 0, -1, -1,
-1, 0, -3, -1, -1, -1, -2, -1, -3, -1, -3, -1, -3, -1, -4, -1, -3, -1, -4, -2,
-3, -2, -5, -1, -4, -2, -4, -2, -4, -1, -4, -1, -3, -1, -4, -2, -4, -1, -5, -1,
-4, -1, -5, -1, -5, -1, -4, -2, -4, -2, -5, -1, -5, -1, -5, -1, -5, -1, -4, -2,
-5, -1, -5, -2, -4, -1, -4, -1, -4, -1, -4, -2, -3, -1, -4, -1, -4, -1, -4, -1,
-3, -1, -4, -1, -3, -1, -4, -1, -3, -1, -4, -1, -3, -1, -3, -1, -3, -1, 12, 6,
13, 13, 9, 14, 10, 15, 8, 15, 9, 15, 8, 14, 9, 15, 8, 16, 9, 14, 9, 15, 9, 15,
8, 15, 9, 15, 8, 15, 9, 15, 9, 15, 9, 15, 9, 15, 9, 15, 9, 15, 9, 15, 9, 15, 9,
15, 9, 15, 10, 15, 9, 16, 10, 17, -4, 10, -8, 3, -2, 1, -4, 1, 0, 0, -2, -1, 0,
0, -1, 0, -1, -1, -1, 0, 0, 1, -1, 0, 1, 0, -1, 1, 1, 0, -1, 0, 0, 0, 0, -1, 0,
0, 1, 0, 1, 0, 2, 1, 0, 1, 2, 1, -1, 0, 4, 2, -4, -3, 11, 9, -56, -16, -91, -55,
-63, -66, -67, -70, -56, -70, -59, -71, -54, -71, -59, -71, -55, -70, -57, -71,
-55, -71, -55, -70, -55, -71, -55, -71, -55, -70, -54, -70, -54, -71, -54, -70,
-54, -71, -53, -70, -54, -70, -53, -70, -53, -70, -52, -70, -53, -70, -53, -69,
-53, -70, -52, -70, -54, -70, -54, -70, -53, -70, -53, -70, -54, -70, -53, -70,
-54, -71, -53, -70, -53, -71, -55, -71, -54, -71, -55, -70, -54, -70, -54, -71,
-56, -70, -54, -71, -55, -71, -56, -71, -55, -71, -56, -72, -56, -71, -57, -71,
-57, -72, -56, -72, -57, -71, -57, -71, -57, -72, -57, -71, -58, -71, -58, -72,
-58, -72, -58, -72, -59, -72, -59, -73, -59, -72, -60, -72, -60, -71, -61, -72,
-60, -72, -60, -72, -60, -73, -61, -73, -61, -72, -62, -73, -62, -72, -62, -72,
-62, -72, -62, -73, -62, -72, -62, -72, -63, -72, -62, -73, -62, -73, -63, -73,
-63, -73, -64, -72, -63, -73, -63, -74, -63, -73, -64, -73, -64, -74, -64, -73,
-64, -73, -65, -73, -64, -73, -64, -73, -64, -74, -63, -73, -64, -73, -64, -73,
-65, -74, -64, -74, -65, -74, -65, -73, -64, -74, -65, -73, -65, -74, -65, -73,
-65, -74, -64, -74, -64, -74, -64, -74, -65, -73, -64, -73, -65, -73, -64, -74,
-66, -74, -64, -74, -66, -73, -65, -73, -66, -74, -65, -74, -64, -74, -66, -74,
-64, -73, -66, -74, -64, -74, -66, -74, -63, -73, -67, -75, -62, -73, -70, -75,
-58, -71, -75, -81, -27, -66, 31, -23, 3, -10, 4, -3, -6, -3, -4, -2, -8, -2,
-6, -2, -6, -3, -6, -2, -7, -3, -8, -2, -8, -3, -8, -3, -8, -2, -10, -2, -8, -3,
-9, -4, -9, -3, -11, -3, -10, -3, -10, -3, -9, -3, -11, -3, -9, -3, -11, -3, -9,
-4, -10, -3, -9, -3, -10, -2, -9, -2, -11, -3, -10, -3, -10, -2, -9, -2, -10,
-2, -9, -2, -9, -2, -9, -2, -9, -3, -9, -2, -8, -2, -8, -2, -7, -2, -8, -2, -7,
-3, -9, -2, -6, -3, -9, -2, -5, -2, -9, -2, -4, -2, -9, -3, -3, -1, -9, -3, -2,
-1, -11, -2, 0, -1, -11, -1, 2, 0, -13, -3, 7, -11, 96, };