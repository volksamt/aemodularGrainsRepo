#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {33, 42, 96, 120, 95, 103, 100, 84,
101, 66, 106, 58, 112, 72, 118, 86, 119, 91, 116, 84, 114, 82, 109, 79, 85, 45,
25, -26, -1, -44, -6, -22, -11, -2, -15, 6, -26, -7, -36, -26, -40, -32, -37,
-26, -36, -23, -37, -27, -36, -31, -34, -27, -30, -21, -27, -18, -26, -19, -25,
-19, -21, -16, -18, -12, -16, -11, -15, -13, -14, -12, -11, -10, -8, -8, -7, -8,
-6, -8, -3, -8, -3, -6, 0, -6, 0, -6, 1, -7, 3, -6, 3, -5, 4, -6, 5, -6, 5, -6,
6, -6, 7, -6, 7, -7, 7, -8, 8, -7, 8, -7, 8, -7, 8, -8, 8, -8, 8, -9, 8, -9, 8,
-10, 8, -10, 9, -10, 8, -11, 7, -11, 7, -11, 7, -13, 6, -12, 7, -13, 6, -14, 5,
-14, 5, -14, 5, -15, 4, -15, 3, -15, 3, -15, 3, -15, 2, -16, 1, -16, 1, -16, 1,
-17, 1, -17, 0, -16, -1, -18, -2, -17, -2, -18, -3, -17, -4, -17, -3, -17, -4,
-18, -4, -18, -5, -18, -6, -19, -6, -19, -6, -18, -7, -19, -7, -19, -9, -19, -8,
-19, -9, -20, -9, -19, -10, -19, -9, -20, -11, -20, -11, -19, -11, -19, -12,
-20, -12, -19, -12, -19, -13, -19, -12, -19, -13, -19, -12, -20, -14, -19, -14,
-19, -14, -19, -14, -20, -15, -19, -14, -19, -16, -20, -15, -20, -16, -20, -15,
-19, -16, -20, -17, -19, -17, -19, -16, -19, -17, -20, -18, -19, -17, -19, -17,
-20, -18, -19, -17, -20, -17, -19, -18, -19, -18, -19, -18, -19, -19, -19, -19,
-18, -18, -19, -18, -19, -19, -19, -18, -18, -20, -18, -19, -18, -19, -18, -20,
-18, -20, -18, -20, -19, -20, -17, -19, -18, -19, -18, -19, -18, -20, -17, -19,
-17, -19, -18, -20, -17, -20, -18, -19, -17, -19, -17, -19, -18, -19, -17, -19,
-16, -20, -17, -19, -16, -20, -17, -19, -16, -20, -16, -19, -16, -19, -16, -19,
-15, -18, -16, -20, -15, -19, -15, -19, -15, -18, -15, -18, -15, -19, -15, -19,
-14, -19, -15, -19, -15, -19, -14, -18, -14, -18, -14, -18, -13, -17, -14, -17,
-14, -18, -13, -17, -14, -17, -14, -18, -12, -18, -13, -17, -12, -17, -13, -17,
-13, -17, -11, -17, -12, -17, -11, -16, -11, -17, -12, -16, -11, -16, -10, -16,
-11, -16, -10, -16, -11, -15, -10, -16, -10, -15, -10, -16, -9, -15, -9, -15,
-8, -14, -9, -15, -8, -15, -9, -14, -8, -14, -8, -14, -7, -14, -7, -13, -7, -13,
-8, -13, -7, -13, -7, -13, -7, -13, -6, -13, -7, -13, -5, -13, -6, -13, -5, -13,
-5, -13, -6, -12, -5, -12, -4, -12, -5, -11, -5, -11, -4, -11, -3, -12, -4, -12,
-4, -11, -4, -11, -2, -11, -3, -12, -3, -10, -2, -10, -2, -10, -2, -11, -2, -11,
-2, -10, -1, -10, -2, -10, -1, -10, -1, -10, -1, -10, -1, -9, -1, -9, 0, -9, 0,
-9, 0, -8, 0, -9, 1, -9, 0, -9, 1, -8, 1, -9, 0, -8, 1, -9, 1, -8, 1, -8, 1, -8,
1, -8, 1, -8, 2, -8, 2, -8, 3, -8, 3, -7, 2, -7, 3, -8, 2, -7, 3, -7, 3, -7, 3,
-7, 3, -6, 3, -7, 3, -6, 3, -6, 3, -7, 4, -6, 4, -6, 4, -6, 3, -6, 4, -6, 4, -5,
5, -5, 5, -6, 5, -6, 5, -5, 6, -6, 5, -6, 5, -5, 6, -5, 5, -6, 5, -4, 6, -5, 5,
-5, 6, -6, 6, -5, 6, -5, 6, -4, 7, -4, 6, -4, 6, -5, 7, -4, 7, -4, 6, -4, 7, -4,
7, -4, 7, -4, 8, -5, 7, -4, 7, -4, 7, -3, 7, -3, 7, -3, 7, -3, 8, -4, 8, -4, 8,
-4, 8, -3, 8, -3, 8, -3, 8, -3, 8, -2, 8, -3, 8, -3, 7, -4, 9, -2, 8, -3, 9, -2,
8, -3, 8, -2, 8, -3, 9, -2, 9, -2, 8, -3, 8, -2, 9, -3, 9, -3, 9, -2, 8, -2, 9,
-2, 9, -3, 9, -3, 8, -2, 10, -1, 9, -2, 9, -1, 8, -2, 10, -2, 9, -1, 9, -1, 9,
-1, 9, -2, 9, -1, 9, -1, 9, -1, 9, -1, 8, -1, 8, -1, 9, -1, 9, -2, 9, -1, 9, -1,
9, -1, 8, -1, 9, -1, 9, -2, 9, 0, 9, -1, 9, -2, 9, -1, 9, -1, 9, 0, 8, 0, 9, 0,
8, -1, 9, 0, 8, -1, 9, 0, 9, -1, 8, -1, 8, -1, 8, -1, 9, -1, 9, -1, 8, -1, 8, 0,
9, -1, 9, -1, 8, -1, 8, 0, 8, 0, 9, -1, 8, -1, 8, 0, 8, -1, 9, 0, 8, 0, 8, 0, 8,
-1, 8, -1, 8, 0, 8, 0, 8, 0, 8, 0, 7, 0, 7, 0, 7, 0, 8, 0, 7, -1, 7, 0, 6, -1,
7, 0, 6, -1, 7, 0, 6, 0, 7, 0, 7, 0, 6, 0, 6, 0, 6, 0, 6, -1, 5, -1, 6, 0, 7, 0,
6, 0, 6, 0, 6, 0, 6, 0, 6, 0, 6, 0, 6, 0, 5, 0, 5, 0, 5, -1, 5, 0, 5, -1, 5, 0,
5, 0, 5, 0, 4, 0, 4, -1, 4, -1, 4, 0, 4, -1, 5, 0, 4, 0, 3, 0, 4, 0, 4, 0, 4, 0,
4, -1, 3, -1, 4, -1, 3, 0, 2, -1, 2, -1, 3, 0, 3, 0, 3, 0, 2, 0, 3, -1, 3, -1,
2, 0, 3, 0, 2, 0, 1, 0, 2, 0, 2, 0, 1, -1, 2, -1, 2, -1, 1, -1, 1, -1, 1, 0, 2,
0, 2, 0, 1, 0, 0, 0, 1, 0, 1, 0, 1, -1, 0, -1, 1, 0, -1, 0, 0, 0, 0, -1, 0, 0,
0, 0, 0, 0, 0, 0, -1, -1, 0, -1, 0, -1, 0, 0, 0, -1, -1, 0, -1, 0, -2, 0, -1,
-1, 0, -1, -1, 0, -1, -1, -2, -1, -3, };