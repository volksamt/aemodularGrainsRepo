#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0050

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, -18, 24, -8, 42, 5, 55, 12, 66, 21,
72, 26, 76, 32, 75, 37, 74, 45, 73, 52, 72, 61, 70, 67, 71, 74, 71, 78, 71, 83,
71, 87, 70, 89, 68, 90, 65, 89, 61, 88, 55, 89, 52, 90, 49, 94, 48, 98, 49, 101,
52, 104, 55, 105, 59, 104, 62, 101, 63, 97, 60, 89, 55, 80, 48, 72, 39, 64, 32,
57, 24, 51, 18, 45, 13, 40, 10, 36, 7, 34, 8, 31, 9, 29, 12, 28, 16, 29, 21, 31,
26, 35, 32, 40, 39, 47, 48, 56, 60, 67, 71, 77, 83, 87, 92, 95, 101, 103, 109,
109, 116, 115, 119, 118, 119, 119, 115, 117, 108, 113, 99, 106, 86, 98, 71, 87,
55, 77, 39, 68, 23, 58, 9, 51, -2, 43, -10, 36, -18, 29, -23, 22, -25, 17, -26,
13, -26, 7, -24, 4, -23, -1, -22, -5, -20, -10, -19, -16, -20, -21, -21, -25,
-22, -30, -23, -35, -25, -40, -28, -46, -31, -50, -33, -52, -35, -55, -36, -57,
-36, -58, -37, -58, -36, -56, -33, -55, -31, -53, -28, -52, -26, -51, -24, -49,
-24, -49, -24, -48, -24, -48, -25, -48, -27, -49, -29, -50, -33, -50, -37, -53,
-40, -55, -44, -58, -48, -61, -52, -64, -56, -67, -60, -70, -64, -72, -66, -75,
-68, -78, -69, -79, -70, -80, -70, -81, -69, -81, -68, -81, -65, -80, -62, -78,
-59, -78, -55, -78, -53, -75, -50, -73, -47, -71, -44, -69, -40, -67, -38, -64,
-35, -62, -34, -60, -31, -56, -29, -53, -26, -50, -24, -46, -23, -43, -20, -41,
-20, -40, -19, -37, -18, -35, -17, -32, -18, -31, -17, -28, -17, -24, -16, -21,
-14, -19, -13, -18, -13, -17, -11, -15, -12, -13, -10, -12, -10, -13, -10, -12,
-11, -11, -10, -9, -9, -8, -9, -6, -7, -6, -8, -7, -6, -4, -5, -2, -3, -1, 0,
-2, 0, -1, 0, 1, 1, 4, 4, 5, 6, 5, 8, 6, 9, 8, 9, 10, 11, 14, 14, 14, 16, 15,
16, 15, 16, 18, 17, 19, 18, 18, 17, 18, 17, 19, 17, 21, 16, 22, 16, 22, 16, 21,
16, 23, 15, 23, 16, 23, 15, 22, 15, 22, 14, 22, 13, 21, 13, 22, 13, 21, 12, 19,
11, 19, 10, 18, 10, 18, 10, 18, 10, 16, 10, 15, 9, 14, 8, 12, 7, 12, 6, 9, 4, 7,
3, 5, 1, 4, 0, 4, 0, 4, 0, 3, -1, 3, 0, 3, 1, 2, 0, 2, 1, 2, 2, 2, 3, 1, 2, 2,
3, 2, 4, 3, 5, 5, 7, 5, 7, 4, 7, 6, 7, 7, 8, 7, 8, 6, 7, 5, 6, 5, 4, 5, 4, 6, 4,
4, 2, 2, 2, 2, 0, 2, -1, 3, 0, 3, 1, 2, 0, 2, -1, 3, 0, 4, 1, 3, 0, 2, 1, 1, 0,
3, 1, 5, 3, 5, 4, 5, 3, 3, 3, 3, 3, 3, 3, 4, 3, 4, 4, 3, 3, 3, 3, 3, 2, 3, 3, 2,
3, 1, 2, 1, 1, 3, 1, 5, 2, 5, 4, 6, 4, 7, 6, 8, 7, 9, 8, 8, 10, 8, 9, 8, 8, 10,
10, 13, 11, 13, 12, 13, 13, 12, 10, 12, 9, 13, 10, 13, 11, 13, 11, 12, 9, 12, 7,
12, 7, 14, 7, 12, 9, 12, 8, 9, 5, 8, 4, 7, 4, 9, 4, 11, 5, 9, 5, 9, 5, 8, 5, 9,
5, 11, 9, 13, 10, 12, 11, 7, 7, 5, 5, 6, 4, 8, 5, 6, 5, 3, 3, 4, 1, 6, 2, 11, 5,
10, 6, 5, 5, 1, 2, 0, 1, 2, 0, 4, 2, 3, 1, 1, 0, -1, -2, 1, -2, 2, 0, 2, 1, -1,
0, -2, 0, 1, 0, 4, 2, 7, 6, 7, 7, 6, 7, 5, 7, 2, 4, 1, 2, -2, 0, -3, -2, -2, -3,
-1, -4, -2, -6, -3, -6, -3, -6, -2, -4, 1, -1, 5, 3, 5, 6, 7, 8, 8, 8, 7, 8, 5,
9, 1, 7, -1, 2, -4, -4, -7, -7, -5, -9, -1, -8, 1, -6, 1, -4, -1, -4, -1, -2, 2,
0, 3, 4, 1, 4, -4, 1, -9, -4, -9, -6, -2, -4, 4, 0, 6, 6, 8, 7, 11, 10, 15, 14,
18, 18, 12, 17, 1, 11, -8, -1, -11, -9, -11, -13, -10, -16, -14, -20, -13, -21,
-11, -21, -7, -17, -4, -11, -3, -6, -4, -1, -3, 1, -1, 4, 1, 7, 2, 8, 1, 8, -2,
6, -3, 2, -5, -1, -4, -2, -2, -2, 4, 3, 12, 8, 16, 14, 21, 19, 23, 25, 23, 27,
22, 27, 18, 25, 12, 19, 6, 11, 2, 0, -1, -7, -2, -11, -2, -14, 0, -14, 3, -12,
8, -7, 13, 2, 20, 12, 26, 21, 29, 28, 27, 31, 26, 32, 24, 30, 24, 28, 21, 23,
15, 16, 9, 7, 3, -4, 0, -11, -4, -16, -11, -22, -17, -28, -22, -34, -27, -38,
-28, -39, -30, -38, -31, -35, -29, -33, -26, -26, -18, -17, -6, -3, 9, 14, 22,
31, 34, 48, 43, 61, 50, 71, 53, 76, 54, 79, 57, 79, 56, 73, 56, 65, 50, 53, 43,
40, 34, 24, 23, 9, 12, -6, 4, -21, -2, -32, -9, -41, -14, -47, -20, -52, -28,
-57, -35, -59, -41, -62, -46, -62, -49, -61, -52, -61, -55, -60, -56, -57, -57,
-53, -59, -50, -62, -48, -64, -46, -67, -46, -67, -44, -68, -42, -66, -39, -64,
-35, -64, -35, -65, -34, -67, -35, -70, -38, -73, -40, -75, -43, -76, -46, -75,
-48, -72, -48, -66, -45, -57, -38, -46, -27, -34, -15, -22, -2, -12, 10, -3, 20,
4, 29, 9, 33, 11, 36, 13, 34, 14, 30, 15, 25, 17, 19, 17, 14, 15, 8, 8, -3, -2,
-14, -15, -28, -29, -44, -42, -60, -57, -75, -69, -91, -83, -104, -91, -114,
-97, -118, -98, -118, -98, -111, -94, -101, -90, -88, -81, -73, -74, -54, -59,
-34, -51, -12, -29, };