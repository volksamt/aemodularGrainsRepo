#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0085

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 2, 6, 4, 7, 5, 8, 6, 10, 7, 12,
9, 12, 10, 13, 10, 15, 12, 17, 13, 18, 14, 19, 13, 21, 15, 23, 17, 25, 17, 25,
18, 27, 18, 28, 19, 29, 20, 30, 21, 31, 22, 32, 22, 33, 23, 34, 23, 36, 24, 36,
25, 37, 26, 38, 26, 39, 27, 40, 28, 41, 29, 42, 29, 43, 30, 44, 30, 44, 31, 45,
32, 45, 32, 46, 32, 47, 33, 48, 34, 49, 35, 50, 35, 49, 35, 50, 37, 52, 33, 53,
35, 54, 39, 53, 39, 54, 40, 55, 40, 56, 41, 55, 41, 56, 41, 57, 42, 58, 43, 58,
43, 58, 44, 59, 44, 59, 44, 60, 45, 60, 45, 61, 45, 61, 46, 61, 46, 62, 47, 62,
46, 64, 47, 64, 47, 63, 48, 64, 48, 64, 48, 66, 49, 66, 48, 66, 49, 66, 49, 67,
49, 67, 50, 67, 50, 68, 50, 68, 50, 68, 51, 69, 51, 69, 50, 69, 52, 70, 46, 70,
44, 71, 47, 71, 47, 71, 49, 72, 48, 71, 50, 71, 50, 72, 51, 72, 52, 72, 52, 71,
53, 72, 53, 73, 54, 72, 54, 73, 54, 73, 55, 73, 55, 74, 55, 74, 56, 73, 55, 73,
56, 74, 56, 74, 56, 74, 56, 75, 56, 74, 57, 75, 56, 76, 56, 75, 56, 75, 56, 76,
57, 76, 56, 75, 56, 75, 57, 75, 56, 76, 57, 76, 57, 76, 57, 76, 56, 77, 57, 76,
57, 76, 57, 76, 56, 77, 57, 77, 57, 77, 58, 77, 56, 77, 57, 77, 58, 77, 57, 77,
57, 78, 57, 77, 58, 77, 58, 77, 58, 77, 57, 77, 57, 76, 57, 77, 57, 77, 57, 78,
58, 77, 57, 77, 58, 77, 57, 77, 58, 78, 58, 77, 58, 77, 57, 77, 58, 78, 57, 77,
60, 76, 55, 77, 27, 81, 48, 78, 63, 76, 59, 76, 62, 76, 62, 77, 63, 76, 62, 76,
63, 76, 62, 76, 61, 76, 61, 77, 61, 75, 61, 76, 60, 76, 59, 76, 59, 77, 58, 76,
59, 75, 58, 76, 58, 76, 58, 75, 58, 76, 57, 75, 57, 75, 57, 75, 57, 75, 57, 75,
58, 76, 57, 75, 57, 75, 55, 73, 56, 75, 55, 72, 57, 76, 55, 73, 57, 75, 53, 73,
58, 76, 46, 66, -17, 11, -15, 10, -13, 11, -12, 8, -9, 8, -9, 3, -6, 0, -6, -6,
-3, -9, -5, -14, -3, -15, -4, -18, -4, -17, -4, -18, -4, -16, -4, -16, -3, -15,
-5, -16, -5, -17, -6, -19, -5, -20, -6, -23, -6, -24, -6, -26, -6, -27, -7, -27,
-7, -28, -8, -27, -8, -26, -9, -26, -9, -24, -11, -30, -15, -34, -10, -25, -10,
-24, -10, -25, -10, -27, -12, -28, -13, -29, -14, -30, -16, -31, -15, -32, -17,
-32, -18, -32, -19, -32, -19, -33, -20, -33, -22, -33, -22, -33, -21, -34, -23,
-35, -23, -35, -23, -34, -24, -35, -24, -35, -26, -35, -26, -35, -26, -35, -27,
-35, -27, -35, -29, -36, -29, -35, -28, -36, -30, -36, -30, -36, -30, -37, -31,
-37, -31, -38, -31, -37, -31, -38, -32, -37, -32, -39, -32, -38, -33, -38, -32,
-37, -33, -38, -33, -38, -33, -38, -33, -38, -33, -38, -33, -38, -34, -39, -33,
-39, -32, -39, -33, -39, -32, -39, -33, -39, -36, -39, -36, -39, -35, -39, -34,
-39, -33, -39, -33, -39, -32, -40, -33, -39, -31, -40, -32, -39, -32, -40, -31,
-40, -31, -39, -30, -39, -30, -39, -31, -40, -30, -39, -30, -40, -29, -40, -30,
-40, -29, -40, -28, -40, -29, -40, -28, -40, -27, -40, -28, -39, -28, -40, -28,
-40, -28, -40, -28, -40, -27, -39, -28, -40, -28, -40, -27, -40, -27, -40, -27,
-39, -28, -40, -27, -39, -27, -40, -26, -40, -27, -40, -26, -40, -27, -40, -26,
-40, -28, -39, -27, -40, -28, -39, -27, -39, -27, -40, -27, -40, -27, -40, -28,
-40, -28, -39, -28, -39, -28, -40, -28, -40, -27, -39, -28, -39, -29, -39, -29,
-39, -28, -40, -28, -40, -29, -39, -29, -40, -29, -39, -29, -40, -30, -40, -28,
-40, -29, -39, -29, -39, -30, -39, -28, -39, -36, -39, -40, -37, -29, -40, -29,
-39, -29, -39, -29, -39, -28, -39, -29, -39, -29, -40, -29, -39, -29, -39, -29,
-39, -29, -39, -29, -39, -30, -38, -29, -38, -30, -38, -30, -38, -29, -39, -30,
-38, -30, -39, -30, -38, -30, -39, -30, -38, -30, -38, -29, -38, -29, -39, -29,
-38, -29, -38, -29, -37, -29, -38, -29, -38, -30, -37, -28, -38, -29, -38, -29,
-37, -30, -36, -27, -38, -29, -37, -26, -37, -39, -35, -51, -33, -44, -35, -43,
-35, -39, -35, -38, -36, -35, -36, -33, -36, -32, -35, -30, -35, -29, -35, -28,
-36, -27, -35, -27, -36, -26, -36, -25, -36, -25, -36, -25, -36, -25, -35, -24,
-36, -25, -35, -24, -35, -23, -35, -23, -35, -23, -35, -24, -35, -23, -35, -23,
-35, -23, -35, -23, -34, -22, -34, -23, -35, -23, -35, -24, -34, -23, -34, -23,
-34, -22, -33, -23, -34, -23, -33, -23, -34, -22, -33, -23, -34, -22, -33, -23,
-34, -23, -33, -23, -33, -23, -33, -23, -33, -24, -33, -23, -32, -23, -33, -22,
-33, -24, -33, -22, -32, -23, -33, -23, -31, -24, -32, -22, -31, -23, -33, -22,
-31, -24, -33, -23, -31, -23, -33, -22, -31, -23, -32, -22, -30, -23, -31, -22,
-30, -23, -31, -22, -30, -23, -29, -23, -30, -21, -30, -115, -114, -88, -89,
-23, -34, -31, -41, -17, -31, -19, -36, -13, -32, -15, -35, -11, -31, -14, -32,
-12, -28, -13, -25, -11, -21, -12, -19, -12, -17, -12, -15, -11, -14, -11, -14,
-10, -15, -10, -15, -9, -15, -9, -16, -9, -14, -8, -13, -8, -12, -6, -9, -8, -8,
-6, -6, -6, -5, -6, -4, -6, -3, -4, -3, -5, -3, -4, -3, -4, -4, -5, -4, -4, -4,
-4, -4, -3, -2, -4, -1, -3, 0, -2, 1, };