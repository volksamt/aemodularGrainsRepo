#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0154

const PROGMEM int8_t DATA[DATA_LENGTH] = {46, 50, 116, 118, 114, 116, 102, 110,
96, 107, 92, 104, 88, 101, 86, 99, 84, 96, 83, 94, 82, 92, 79, 90, 79, 88, 76,
85, 75, 83, 73, 80, 72, 79, 69, 76, 68, 74, 65, 72, 64, 70, 62, 68, 62, 67, 59,
65, 58, 63, 56, 62, 54, 60, 53, 60, 52, 58, 52, 56, 50, 56, 50, 56, 49, 55, 48,
53, 47, 53, 47, 52, 46, 51, 44, 51, 45, 50, 44, 50, 44, 50, 44, 50, 44, 49, 44,
49, 43, 49, 43, 48, 43, 49, 43, 48, 43, 48, 43, 48, 43, 49, 43, 48, 43, 47, 44,
48, 44, 48, 43, 48, 43, 48, 44, 49, 43, 48, 43, 48, 43, 47, 44, 48, 44, 48, 43,
48, 43, 48, 43, 48, 43, 48, 43, 47, 43, 48, 43, 47, 43, 48, 44, 47, 43, 47, 43,
46, 43, 46, 43, 47, 43, 47, 43, 47, 41, 46, 43, 45, 41, 46, 41, 45, 41, 45, 42,
45, 41, 45, 41, 44, 41, 45, 41, 44, 40, 44, 40, 43, 40, 43, 39, 43, 39, 43, 38,
42, 38, 42, 39, 42, 38, 41, 38, 41, 38, 42, 38, 41, 37, 41, 37, 40, 36, 41, 37,
40, 36, 39, 35, 39, 36, 39, 36, 38, 35, 39, 34, 38, 35, 38, 35, 38, 34, 38, 34,
38, 35, 36, 34, 36, 34, 36, 33, 37, 33, 37, 33, 36, 33, 36, 32, 36, 32, 35, 32,
35, 31, 35, 32, 34, 31, 34, 31, 34, 31, 33, 30, 33, 30, 33, 30, 33, 29, 33, 30,
32, 29, 32, 30, 32, 28, 32, 29, 32, 28, 32, 28, 31, 28, 31, 28, 30, 28, 30, 28,
31, 27, 30, 27, 30, 27, 29, 27, 29, 27, 28, 26, 28, 26, 28, 26, 28, 25, 28, 26,
28, 25, 27, 25, 26, 24, 26, 24, 27, 25, 26, 24, 26, 23, 26, 23, 25, 23, 25, 24,
25, 23, 25, 23, 24, 22, 24, 22, 24, 22, 24, 22, 23, 21, 23, 21, 22, 20, 23, 20,
23, 21, 21, 19, 21, 20, 21, 18, 21, 19, 21, 19, 21, 19, 20, 18, 20, 18, 20, 17,
19, 17, 19, 17, 19, 17, 18, 17, 19, 16, 18, 16, 17, 16, 18, 16, 17, 15, 18, 15,
17, 15, 16, 15, 16, 15, 16, 14, 16, 14, 16, 14, 15, 13, 15, 14, 15, 13, 14, 13,
15, 12, 13, 13, 14, 12, 14, 12, 13, 12, 13, 12, 13, 12, 12, 11, 12, 11, 12, 11,
11, 10, 11, 10, 11, 10, 11, 10, 11, 10, 10, 9, 10, 8, 10, 9, 9, 8, 9, 8, 8, 7,
9, 7, 9, 8, 8, 7, 7, 7, 7, 6, 6, 6, 7, 7, 7, 5, 6, 6, 6, 5, 6, 5, 5, 6, 6, 5, 4,
4, 5, 5, 5, 4, 4, 3, 3, 3, 4, 2, 4, 3, 3, 2, 2, 2, 2, 2, 3, 1, 2, 1, 1, 2, 2, 2,
1, 1, 1, 0, 1, 0, 0, 0, -1, 0, 0, -1, 0, -1, -1, 0, -1, -1, -1, -1, -1, -2, -2,
-1, -2, -2, -2, -2, -2, -3, -3, -3, -4, -3, -3, -3, -4, -3, -4, -4, -4, -4, -4,
-4, -5, -5, -5, -5, -5, -6, -6, -5, -5, -5, -6, -6, -7, -6, -6, -7, -7, -7, -7,
-7, -7, -8, -8, -8, -8, -8, -8, -8, -8, -8, -8, -9, -9, -8, -9, -9, -10, -9,
-10, -9, -11, -9, -10, -9, -11, -10, -10, -10, -12, -10, -11, -10, -11, -12,
-12, -11, -12, -12, -12, -12, -12, -12, -14, -12, -14, -12, -14, -13, -15, -14,
-14, -14, -14, -14, -14, -13, -15, -14, -15, -14, -15, -14, -16, -14, -16, -15,
-17, -15, -16, -16, -17, -15, -17, -17, -17, -16, -17, -16, -18, -17, -17, -17,
-18, -17, -19, -18, -18, -18, -20, -18, -20, -18, -19, -18, -19, -19, -21, -18,
-20, -19, -21, -20, -21, -19, -22, -20, -21, -21, -22, -20, -22, -21, -22, -21,
-23, -21, -23, -21, -23, -22, -23, -22, -24, -22, -24, -23, -24, -23, -25, -23,
-25, -23, -26, -23, -25, -23, -26, -24, -25, -23, -26, -24, -26, -25, -27, -24,
-27, -25, -27, -26, -27, -25, -27, -25, -28, -26, -28, -26, -29, -26, -29, -26,
-29, -27, -29, -27, -29, -27, -29, -28, -30, -28, -31, -28, -30, -28, -30, -28,
-31, -28, -32, -28, -32, -29, -32, -30, -32, -30, -32, -30, -33, -31, -33, -31,
-33, -30, -33, -31, -33, -31, -33, -32, -34, -32, -35, -31, -34, -32, -34, -32,
-35, -33, -35, -32, -35, -32, -35, -33, -35, -34, -36, -33, -36, -34, -36, -34,
-37, -35, -37, -34, -36, -34, -38, -35, -37, -35, -39, -35, -38, -36, -39, -35,
-40, -36, -39, -36, -40, -37, -40, -37, -40, -36, -40, -36, -40, -37, -41, -37,
-41, -38, -41, -37, -41, -38, -42, -38, -42, -39, -42, -39, -43, -39, -43, -39,
-43, -40, -44, -40, -43, -40, -44, -40, -44, -40, -44, -40, -43, -41, -45, -41,
-45, -42, -46, -42, -45, -43, -46, -43, -46, -43, -46, -42, -46, -43, -46, -43,
-46, -43, -47, -43, -47, -44, -46, -42, -47, -44, -47, -43, -47, -44, -47, -44,
-47, -43, -48, -44, -48, -44, -48, -43, -49, -44, -48, -43, -48, -43, -48, -43,
-48, -43, -48, -44, -48, -43, -48, -43, -48, -44, -47, -43, -48, -44, -48, -43,
-48, -42, -49, -43, -49, -43, -49, -44, -48, -44, -48, -43, -49, -44, -49, -44,
-49, -44, -49, -44, -50, -44, -50, -45, -50, -45, -50, -45, -50, -46, -51, -46,
-52, -46, -53, -48, -54, -48, -54, -49, -55, -51, -56, -51, -57, -53, -58, -54,
-59, -54, -61, -56, -62, -58, -64, -59, -65, -60, -68, -62, -69, -64, -71, -65,
-72, -68, -74, -69, -76, -71, -78, -73, -81, -74, -84, -76, -85, -78, -88, -79,
-90, -82, -92, -83, -95, -85, -97, -86, -98, -89, -102, -91, -104, -97, -107,
-102, -110, -116, -116, -113, -116, -41, -44, };