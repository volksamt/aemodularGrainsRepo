#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 18, 1, 23, 0, 22, 2, 24, 1, 22, 1,
24, 3, 24, 3, 25, 3, 25, 4, 25, 4, 26, 5, 26, 5, 26, 5, 27, 5, 27, 6, 28, 6, 27,
6, 29, 6, 28, 7, 29, 7, 29, 8, 29, 7, 30, 8, 30, 8, 30, 8, 30, 9, 31, 10, 32, 9,
32, 10, 31, 11, 32, 10, 32, 10, 32, 11, 32, 12, 33, 11, 32, 12, 33, 12, 33, 11,
34, 13, 34, 12, 33, 12, 34, 13, 34, 13, 34, 14, 34, 13, 34, 13, 34, 13, 35, 14,
34, 14, 35, 14, 34, 14, 35, 14, 35, 15, 34, 14, 35, 14, 35, 15, 35, 15, 35, 14,
34, 14, 35, 15, 34, 14, 34, 15, 35, 15, 34, 15, 35, 14, 34, 25, 45, 68, 91, 103,
118, 113, 120, 116, 118, 116, 113, 115, 111, 118, 117, 119, 120, 119, 119, 119,
120, 117, 119, 117, 119, 115, 119, 111, 117, 107, 114, 104, 113, 104, 114, 101,
112, 98, 110, 96, 108, 94, 108, 94, 107, 92, 107, 91, 105, 89, 104, 88, 103, 88,
105, 87, 104, 87, 104, 87, 103, 86, 104, 88, 103, 87, 104, 87, 103, 88, 103, 89,
104, 89, 105, 89, 103, 89, 104, 90, 103, 92, 105, 92, 104, 92, 105, 93, 106, 95,
105, 94, 105, 95, 106, 96, 106, 96, 106, 97, 106, 99, 107, 99, 107, 101, 107,
100, 108, 102, 108, 102, 107, 103, 108, 103, 107, 105, 107, 105, 108, 105, 107,
105, 108, 106, 106, 107, 107, 107, 106, 106, 106, 108, 106, 108, 105, 107, 106,
107, 105, 108, 106, 107, 105, 108, 104, 108, 104, 108, 103, 108, 103, 108, 103,
108, 103, 108, 102, 108, 101, 108, 100, 108, 101, 107, 99, 107, 99, 107, 98,
106, 97, 106, 97, 106, 95, 105, 96, 104, 95, 104, 93, 103, 92, 103, 92, 102, 91,
101, 90, 100, 88, 100, 88, 101, 88, 99, 87, 99, 86, 98, 84, 97, 84, 98, 83, 97,
82, 96, 81, 95, 80, 95, 79, 94, 78, 93, 78, 92, 76, 92, 75, 91, 75, 90, 74, 89,
73, 89, 71, 88, 71, 86, 69, 85, 68, 84, 67, 84, 66, 83, 65, 83, 64, 81, 62, 81,
61, 80, 61, 78, 59, 78, 59, 77, 57, 76, 57, 75, 56, 74, 55, 75, 54, 73, 53, 72,
51, 72, 51, 71, 50, 70, 48, 70, 48, 69, 46, 68, 46, 67, 45, 65, 44, 65, 43, 64,
41, 62, 40, 63, 40, 61, 38, 61, 38, 60, 36, 58, 36, 58, 34, 57, 34, 56, 32, 56,
31, 55, 31, 53, 30, 53, 29, 52, 27, 50, 27, 50, 27, 49, 25, 49, 24, 47, 24, 47,
23, 45, 21, 45, 21, 44, 19, 43, 19, 42, 18, 41, 17, 41, 16, 40, 16, 38, 14, 38,
15, 37, 13, 36, 13, 36, 11, 35, 11, 35, 11, 33, 10, 33, 8, 32, 8, 31, 8, 30, 6,
30, 6, 29, 5, 29, 5, 27, 3, 28, 3, 26, 2, 26, 2, 25, 0, 25, 0, 24, -1, 22, -1,
11, -16, -32, -60, -64, -88, -73, -90, -77, -86, -77, -82, -78, -82, -83, -88,
-86, -95, -87, -97, -85, -95, -84, -95, -84, -96, -83, -97, -80, -95, -77, -92,
-74, -91, -75, -91, -74, -91, -70, -90, -68, -88, -68, -89, -67, -90, -66, -89,
-64, -87, -64, -88, -64, -88, -64, -89, -64, -89, -65, -89, -65, -89, -66, -90,
-66, -91, -66, -91, -67, -91, -68, -93, -69, -93, -70, -94, -71, -94, -72, -95,
-73, -97, -74, -97, -76, -98, -77, -98, -78, -99, -80, -100, -81, -100, -82,
-101, -83, -102, -83, -102, -85, -102, -86, -103, -87, -104, -89, -105, -89,
-105, -91, -106, -92, -106, -92, -107, -94, -107, -95, -107, -96, -108, -96,
-108, -97, -109, -98, -109, -98, -109, -99, -109, -100, -110, -101, -110, -102,
-109, -101, -110, -102, -111, -102, -110, -104, -111, -103, -110, -103, -109,
-104, -109, -104, -110, -104, -109, -104, -109, -105, -109, -104, -108, -104,
-109, -104, -109, -104, -109, -104, -109, -105, -108, -105, -108, -104, -107,
-105, -107, -104, -107, -104, -106, -105, -106, -103, -106, -104, -104, -104,
-104, -103, -104, -102, -104, -103, -102, -102, -102, -100, -101, -100, -101,
-100, -100, -100, -99, -99, -98, -99, -98, -99, -98, -98, -96, -97, -96, -96,
-95, -97, -94, -95, -94, -96, -92, -95, -92, -93, -92, -94, -91, -93, -89, -92,
-89, -92, -89, -90, -87, -90, -87, -90, -86, -88, -85, -88, -84, -88, -84, -86,
-82, -86, -81, -85, -81, -83, -79, -84, -78, -83, -78, -82, -77, -82, -75, -81,
-75, -80, -74, -79, -73, -79, -72, -77, -71, -77, -70, -76, -69, -75, -69, -74,
-68, -74, -67, -74, -65, -72, -65, -72, -64, -71, -63, -69, -63, -69, -61, -68,
-60, -68, -59, -66, -58, -66, -56, -65, -56, -64, -54, -64, -54, -62, -53, -61,
-52, -61, -51, -60, -50, -60, -50, -59, -48, -58, -48, -57, -47, -56, -46, -56,
-44, -55, -44, -55, -43, -54, -42, -52, -40, -52, -39, -51, -39, -51, -38, -50,
-37, -49, -36, -48, -35, -47, -34, -46, -33, -45, -32, -44, -30, -44, -30, -43,
-29, -41, -28, -41, -27, -41, -26, -41, -26, -40, -25, -39, -24, -38, -23, -37,
-22, -36, -21, -36, -20, -35, -20, -34, -18, -33, -18, -33, -17, -32, -16, -32,
-15, -30, -14, -29, -13, -29, -13, -29, -12, -27, -11, -27, -10, -26, -9, -26,
-8, -25, -7, -24, -7, -24, -6, -23, -4, -22, -3, -21, -3, -21, -3, -20, -2, -19,
-1, -18, -1, -19, 1, -17, 0, -17, 2, -16, 3, -16, 3, -16, 4, -15, 5, -14, 5,
-14, 6, -13, 7, -13, 7, -12, 8, -11, 9, -11, 9, -10, 10, -10, 11, -8, 11, -9,
12, -8, 13, -7, 13, -7, 14, -7, 15, -6, 14, -5, 16, -5, 16, -5, 16, -4, 16, -4,
18, -3, 18, -2, 20, -2, 19, -2, 20, 0, 19, 0, 22, -1, 17, };