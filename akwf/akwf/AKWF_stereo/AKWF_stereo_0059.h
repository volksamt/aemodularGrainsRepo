#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0059

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 32, 5, 41, 8, 40, 11, 45, 14, 45,
17, 50, 20, 50, 22, 54, 25, 54, 28, 58, 31, 59, 34, 62, 38, 62, 39, 65, 43, 67,
45, 67, 49, 69, 52, 71, 54, 73, 57, 75, 59, 76, 61, 78, 64, 79, 67, 81, 69, 82,
72, 84, 74, 85, 77, 86, 79, 88, 81, 89, 83, 91, 85, 91, 88, 93, 89, 94, 92, 96,
94, 97, 95, 98, 97, 99, 99, 99, 101, 101, 102, 102, 104, 103, 105, 104, 107,
104, 108, 105, 109, 106, 111, 106, 111, 107, 113, 107, 113, 109, 115, 109, 115,
110, 116, 110, 117, 111, 118, 111, 117, 112, 117, 111, 119, 112, 119, 111, 119,
112, 119, 112, 119, 113, 119, 112, 119, 112, 118, 112, 118, 112, 117, 113, 117,
113, 116, 112, 116, 111, 115, 111, 114, 110, 113, 110, 112, 109, 111, 110, 109,
109, 108, 109, 107, 107, 105, 106, 103, 105, 102, 104, 100, 103, 98, 102, 95,
101, 93, 101, 90, 98, 88, 98, 86, 96, 83, 94, 79, 92, 77, 91, 74, 89, 70, 87,
68, 85, 63, 83, 61, 81, 56, 79, 53, 77, 49, 75, 45, 72, 41, 69, 37, 66, 33, 63,
29, 60, 24, 54, 19, 52, 16, 44, 11, 41, 15, 11, 11, 5, 6, 15, 6, 12, 4, 19, 5,
18, 4, 21, 4, 20, 3, 23, 4, 23, 4, 25, 4, 24, 3, 26, 4, 26, 4, 28, 4, 28, 3, 28,
4, 30, 3, 29, 2, 31, 3, 30, 3, 31, 3, 32, 3, 32, 2, 33, 3, 33, 4, 34, 2, 34, 2,
34, 3, 34, 2, 34, 2, 35, 2, 35, 2, 36, 2, 36, 2, 36, 3, 36, 3, 36, 3, 37, 3, 37,
3, 37, 3, 38, 3, 38, 3, 37, 3, 37, 2, 38, 3, 39, 3, 39, 4, 38, 4, 39, 4, 39, 3,
39, 3, 40, 4, 40, 5, 40, 4, 40, 5, 40, 4, 40, 5, 40, 5, 40, 5, 41, 5, 41, 5, 41,
6, 42, 6, 41, 6, 41, 7, 42, 6, 42, 7, 42, 7, 43, 8, 42, 8, 43, 9, 43, 8, 43, 9,
44, 8, 44, 9, 44, 9, 45, 9, 45, 11, 45, 11, 45, 11, 46, 12, 45, 11, 46, 12, 47,
12, 46, 13, 47, 13, 47, 13, 47, 15, 48, 14, 48, 15, 49, 16, 49, 15, 49, 15, 50,
16, 50, 17, 50, 18, 51, 17, 51, 17, 51, 19, 52, 19, 52, 19, 53, 20, 52, 20, 53,
20, 53, 20, 53, 21, 54, 22, 54, 21, 54, 22, 55, 23, 54, 24, 55, 23, 56, 24, 55,
25, 56, 25, 56, 25, 57, 26, 57, 26, 57, 26, 58, 27, 58, 27, 59, 27, 59, 27, 59,
28, 59, 28, 60, 29, 60, 29, 60, 29, 61, 30, 61, 30, 61, 30, 61, 31, 61, 31, 62,
31, 62, 31, 61, 32, 62, 31, 62, 32, 62, 33, 62, 33, 63, 33, 64, 32, 63, 33, 64,
33, 64, 33, 64, 34, 63, 34, 64, 34, 64, 34, 65, 34, 64, 33, 65, 35, 65, 34, 66,
35, 65, 35, 65, 35, 65, 34, 66, 35, 65, 35, 65, 35, 65, 34, 65, 35, 66, 34, 66,
34, 66, 34, 64, 34, 65, 34, 65, 34, 66, 35, 65, 34, 65, 34, 65, 34, 65, 33, 65,
33, 64, 33, 65, 33, 65, 33, 64, 33, 64, 32, 64, 32, 64, 31, 63, 31, 63, 31, 63,
31, 63, 31, 62, 30, 62, 29, 62, 29, 61, 30, 62, 28, 62, 28, 60, 28, 61, 27, 61,
27, 59, 26, 59, 25, 59, 25, 58, 24, 58, 24, 57, 24, 58, 23, 56, 22, 56, 21, 55,
21, 56, 21, 54, 20, 54, 19, 53, 17, 52, 17, 52, 16, 51, 16, 51, 15, 50, 14, 48,
14, 48, 13, 48, 12, 46, 11, 45, 10, 45, 9, 43, 9, 43, 8, 41, 7, 40, 7, 38, 6,
37, 5, 35, 3, 35, 2, 33, 2, 31, 1, 28, 1, 26, 0, 22, 1, 20, 2, 10, 7, -11, 7,
-15, 7, -18, 6, -21, 5, -23, 4, -27, 3, -28, 2, -29, 1, -31, 0, -33, -1, -34,
-2, -36, -4, -37, -5, -39, -5, -39, -7, -42, -8, -42, -10, -43, -12, -45, -12,
-46, -13, -47, -14, -48, -16, -49, -17, -51, -18, -53, -20, -53, -22, -54, -22,
-55, -24, -56, -26, -56, -27, -57, -29, -59, -29, -59, -30, -61, -31, -61, -34,
-63, -34, -64, -36, -65, -37, -66, -38, -66, -40, -67, -42, -68, -42, -69, -44,
-70, -45, -70, -47, -71, -47, -72, -49, -73, -50, -74, -51, -75, -52, -76, -54,
-77, -55, -77, -56, -77, -57, -79, -59, -80, -60, -80, -61, -81, -62, -81, -63,
-82, -64, -83, -65, -84, -66, -84, -67, -84, -68, -85, -70, -85, -71, -87, -71,
-87, -72, -88, -73, -89, -74, -89, -75, -90, -76, -90, -76, -91, -77, -91, -78,
-92, -78, -91, -80, -93, -80, -92, -80, -93, -81, -94, -82, -94, -82, -94, -83,
-94, -84, -94, -84, -96, -84, -96, -85, -96, -86, -97, -86, -97, -86, -96, -87,
-97, -87, -97, -86, -97, -87, -98, -88, -97, -87, -97, -87, -98, -88, -98, -87,
-97, -87, -98, -87, -98, -87, -99, -87, -98, -86, -98, -86, -98, -86, -97, -86,
-98, -86, -97, -85, -98, -85, -98, -85, -97, -85, -96, -83, -96, -83, -97, -83,
-96, -81, -96, -81, -95, -81, -96, -79, -94, -79, -94, -78, -93, -77, -93, -76,
-93, -75, -92, -74, -91, -73, -90, -72, -90, -71, -90, -69, -88, -67, -88, -66,
-87, -65, -86, -63, -85, -61, -85, -60, -83, -58, -82, -57, -81, -55, -80, -53,
-80, -51, -78, -50, -77, -48, -75, -46, -74, -44, -73, -42, -72, -40, -70, -37,
-68, -35, -66, -33, -66, -30, -64, -29, -61, -26, -59, -24, -57, -21, -55, -19,
-52, -16, -50, -13, -47, -12, -44, -9, -40, -7, -35, -5, -29, -6, -15, -12, 13,
-10, 17, -7, 24, -5, 25, -3, 33, 0, 30, };