#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0123

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -5, 4, -6, 5, -4, 7, -3, 10, -2,
11, -1, 13, 0, 15, 1, 18, 1, 20, 3, 22, 4, 25, 4, 27, 4, 28, 4, 30, 6, 32, 7,
33, 9, 37, 10, 38, 14, 41, 15, 44, 18, 46, 21, 49, 23, 53, 27, 57, 31, 60, 34,
64, 39, 69, 44, 70, 47, 73, 51, 76, 54, 78, 58, 80, 61, 83, 64, 84, 67, 87, 70,
88, 72, 90, 73, 91, 75, 93, 77, 95, 78, 96, 80, 99, 81, 102, 82, 105, 83, 108,
86, 110, 87, 113, 90, 115, 92, 116, 93, 118, 97, 119, 98, 119, 99, 119, 101,
117, 102, 115, 103, 114, 104, 112, 104, 110, 106, 109, 106, 107, 107, 104, 108,
101, 108, 98, 107, 95, 106, 93, 106, 90, 103, 87, 101, 86, 99, 84, 97, 82, 95,
81, 93, 79, 91, 79, 89, 78, 88, 78, 86, 78, 85, 78, 83, 78, 83, 78, 82, 77, 82,
76, 82, 75, 81, 73, 80, 72, 78, 69, 78, 67, 79, 66, 78, 63, 79, 62, 79, 62, 81,
61, 81, 59, 81, 55, 79, 50, 75, 43, 68, 36, 64, 30, 57, 24, 52, 19, 48, 14, 43,
10, 40, 5, 35, 1, 31, -2, 27, -5, 24, -9, 20, -11, 16, -15, 12, -19, 8, -22, 4,
-25, 0, -29, -3, -32, -6, -36, -10, -38, -13, -41, -16, -44, -20, -47, -23, -50,
-27, -53, -30, -56, -33, -59, -35, -63, -37, -64, -41, -67, -43, -69, -45, -73,
-48, -76, -51, -79, -54, -81, -57, -83, -59, -84, -62, -87, -66, -88, -69, -89,
-72, -90, -76, -91, -78, -91, -80, -91, -82, -91, -83, -90, -85, -91, -85, -90,
-86, -89, -87, -89, -87, -88, -88, -87, -87, -85, -86, -84, -87, -82, -86, -80,
-84, -76, -82, -73, -78, -70, -75, -67, -72, -65, -70, -64, -67, -62, -64, -63,
-64, -62, -63, -63, -64, -62, -64, -63, -65, -64, -65, -63, -67, -63, -66, -63,
-67, -62, -69, -60, -69, -58, -68, -57, -68, -54, -67, -51, -66, -50, -64, -47,
-62, -44, -60, -42, -58, -40, -56, -38, -53, -36, -51, -34, -48, -33, -46, -32,
-45, -31, -43, -30, -41, -28, -39, -29, -37, -29, -36, -30, -35, -31, -34, -30,
-34, -31, -34, -31, -34, -31, -34, -29, -33, -28, -32, -27, -30, -24, -29, -22,
-29, -21, -28, -18, -28, -15, -28, -13, -28, -11, -27, -8, -25, -7, -24, -5,
-23, -3, -21, -2, -19, 0, -16, 1, -15, 0, -13, 1, -11, 2, -9, 2, -8, 2, -5, 3,
-3, 2, 0, 3, 1, 1, 3, -2, 1, -6, -1, -10, -5, -15, -7, -18, -10, -22, -12, -24,
-14, -26, -16, -28, -17, -30, -18, -31, -20, -33, -21, -34, -22, -35, -24, -35,
-26, -35, -26, -35, -27, -35, -29, -34, -29, -34, -29, -33, -29, -33, -29, -32,
-31, -31, -31, -31, -32, -30, -30, -27, -30, -24, -27, -21, -24, -18, -22, -17,
-20, -15, -19, -14, -17, -12, -16, -11, -16, -9, -15, -8, -13, -6, -11, -4, -10,
-1, -9, 2, -7, 5, -5, 8, -4, 11, -2, 14, 0, 17, 1, 20, 2, 22, 2, 23, 3, 25, 4,
25, 6, 28, 9, 31, 11, 33, 14, 36, 17, 39, 19, 41, 22, 46, 25, 48, 28, 51, 32,
55, 36, 58, 39, 60, 43, 63, 47, 66, 50, 69, 53, 71, 56, 72, 59, 74, 61, 75, 63,
76, 64, 77, 66, 78, 68, 79, 68, 81, 69, 83, 70, 84, 71, 87, 73, 90, 73, 91, 74,
95, 76, 97, 78, 98, 79, 101, 81, 102, 81, 103, 84, 103, 85, 104, 87, 103, 88,
102, 88, 101, 88, 99, 89, 97, 89, 96, 90, 94, 90, 91, 90, 90, 91, 87, 90, 85,
91, 83, 91, 80, 88, 77, 88, 74, 86, 72, 84, 70, 81, 67, 78, 66, 77, 65, 75, 66,
74, 65, 72, 65, 71, 65, 70, 65, 68, 65, 68, 66, 67, 65, 67, 65, 67, 64, 66, 63,
66, 62, 66, 60, 65, 60, 66, 59, 66, 58, 65, 57, 67, 57, 68, 56, 68, 54, 68, 51,
67, 45, 64, 40, 59, 33, 54, 27, 49, 22, 45, 18, 42, 14, 39, 10, 36, 6, 34, 5,
31, 2, 28, -2, 25, -4, 22, -7, 19, -8, 16, -10, 14, -13, 9, -14, 7, -16, 5, -18,
2, -20, 0, -22, -4, -24, -5, -26, -7, -28, -10, -31, -13, -32, -15, -34, -16,
-37, -18, -39, -20, -41, -22, -44, -23, -48, -25, -51, -27, -53, -29, -55, -32,
-58, -34, -60, -37, -62, -40, -64, -44, -66, -47, -68, -50, -68, -53, -69, -56,
-70, -58, -71, -60, -70, -62, -70, -63, -69, -65, -70, -66, -70, -67, -70, -68,
-71, -68, -70, -68, -70, -68, -70, -68, -69, -69, -69, -69, -68, -68, -66, -66,
-66, -65, -64, -63, -63, -62, -63, -61, -62, -59, -63, -59, -64, -58, -64, -59,
-65, -60, -66, -61, -65, -63, -67, -64, -66, -66, -66, -68, -65, -68, -65, -71,
-63, -71, -63, -72, -62, -72, -61, -72, -59, -72, -59, -72, -57, -71, -57, -71,
-56, -69, -56, -69, -55, -68, -56, -68, -57, -67, -58, -66, -58, -66, -59, -65,
-60, -64, -61, -63, -61, -63, -63, -63, -64, -62, -65, -62, -66, -62, -66, -62,
-67, -64, -66, -63, -65, -64, -65, -64, -63, -64, -60, -63, -58, -62, -56, -62,
-53, -61, -49, -60, -46, -58, -44, -57, -40, -55, -37, -52, -35, -49, -32, -46,
-31, -44, -29, -41, -27, -38, -26, -35, -24, -31, -22, -28, -20, -24, -19, -21,
-18, -20, -18, -19, -19, -19, -22, -20, -24, -21, -25, -21, -26, -23, -28, -23,
-29, -23, -30, -23, -32, -24, -33, -24, -34, -26, -34, -27, -35, -28, -36, -29,
-37, -30, -36, -30, -36, -31, -35, -30, -35, -32, -34, -32, -33, -32, -32, -31,
-31, -31, -30, -33, -28, -32, -27, -31, -25, -30, -21, -27, -17, -24, -14, -20,
-10, -17, -8, -14, -6, -12, -4, -9, -1, -9, -1, -7, };