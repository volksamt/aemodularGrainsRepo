#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 45, 4, 56, 6, 53, 9, 58, 12, 56,
14, 61, 16, 60, 17, 63, 21, 64, 23, 68, 26, 67, 29, 70, 31, 70, 33, 73, 34, 75,
37, 77, 39, 78, 41, 80, 43, 82, 45, 85, 47, 86, 48, 87, 50, 89, 53, 91, 55, 93,
56, 94, 58, 97, 60, 98, 62, 100, 64, 100, 65, 100, 67, 100, 68, 101, 70, 101,
71, 101, 72, 100, 74, 100, 76, 100, 77, 100, 78, 99, 80, 98, 81, 97, 82, 96, 84,
95, 85, 95, 86, 92, 87, 91, 89, 89, 89, 88, 91, 87, 92, 85, 93, 84, 94, 83, 94,
81, 96, 79, 97, 76, 98, 75, 99, 74, 100, 71, 101, 69, 102, 67, 102, 66, 103, 63,
103, 61, 104, 60, 105, 58, 105, 55, 106, 54, 107, 52, 107, 50, 108, 49, 109, 46,
109, 45, 110, 43, 110, 41, 111, 39, 112, 38, 112, 37, 112, 36, 112, 33, 113, 33,
113, 31, 115, 30, 115, 29, 115, 28, 115, 28, 115, 27, 116, 26, 117, 26, 116, 26,
116, 26, 118, 25, 118, 26, 117, 26, 118, 28, 118, 28, 118, 28, 118, 29, 119, 30,
119, 32, 119, 33, 119, 33, 120, 36, 119, 37, 119, 40, 119, 42, 119, 45, 119, 46,
119, 48, 119, 50, 119, 52, 118, 55, 118, 56, 118, 59, 119, 61, 118, 61, 118, 64,
117, 65, 117, 67, 117, 69, 117, 70, 116, 72, 116, 75, 116, 76, 116, 78, 115, 80,
115, 82, 114, 84, 114, 86, 114, 89, 114, 90, 113, 91, 113, 94, 113, 96, 113, 97,
113, 99, 112, 101, 111, 102, 111, 104, 110, 105, 111, 107, 111, 108, 110, 110,
110, 110, 110, 111, 109, 112, 108, 114, 108, 115, 107, 115, 108, 116, 107, 116,
106, 118, 106, 117, 105, 118, 104, 118, 105, 118, 104, 118, 104, 119, 103, 120,
102, 119, 102, 120, 102, 119, 101, 119, 100, 118, 100, 118, 100, 118, 98, 117,
98, 117, 97, 117, 96, 117, 97, 116, 96, 115, 95, 115, 94, 114, 93, 113, 92, 112,
92, 113, 92, 111, 90, 110, 89, 109, 89, 108, 88, 107, 87, 105, 87, 104, 86, 103,
85, 101, 85, 99, 83, 98, 83, 97, 81, 96, 81, 95, 79, 94, 79, 92, 79, 91, 77, 89,
77, 88, 75, 86, 74, 85, 74, 84, 73, 81, 72, 80, 70, 77, 70, 76, 68, 73, 68, 72,
67, 69, 66, 68, 65, 65, 63, 63, 62, 61, 62, 59, 61, 58, 60, 55, 59, 53, 58, 51,
58, 49, 55, 46, 55, 44, 54, 43, 53, 40, 51, 37, 52, 35, 50, 33, 49, 30, 49, 28,
47, 25, 45, 23, 44, 20, 43, 18, 43, 16, 40, 13, 40, 10, 38, 8, 37, 4, 35, 2, 34,
0, 33, -3, 32, -5, 31, -7, 30, -11, 28, -12, 26, -15, 24, -18, 23, -21, 22, -23,
19, -26, 18, -28, 16, -29, 13, -32, 13, -35, 10, -37, 8, -39, 7, -41, 5, -44, 2,
-46, 1, -48, -2, -50, -4, -53, -6, -54, -9, -56, -11, -57, -15, -60, -16, -60,
-18, -63, -21, -64, -24, -66, -25, -68, -28, -69, -31, -72, -32, -73, -35, -75,
-37, -77, -38, -78, -41, -81, -44, -82, -45, -84, -47, -86, -50, -88, -51, -90,
-53, -92, -55, -93, -56, -95, -59, -96, -60, -98, -62, -99, -63, -100, -65,
-101, -67, -101, -69, -101, -71, -101, -72, -101, -73, -101, -74, -100, -76,
-100, -77, -100, -78, -98, -80, -98, -82, -97, -82, -97, -84, -95, -84, -94,
-86, -93, -87, -91, -89, -89, -89, -88, -92, -86, -92, -85, -93, -83, -94, -82,
-95, -80, -96, -78, -97, -76, -98, -75, -99, -73, -100, -71, -100, -69, -101,
-66, -102, -65, -103, -64, -103, -62, -104, -59, -105, -58, -106, -55, -106,
-54, -107, -52, -107, -50, -109, -48, -109, -47, -109, -45, -110, -42, -110,
-41, -110, -40, -112, -38, -111, -37, -113, -35, -113, -33, -113, -33, -113,
-31, -114, -29, -115, -29, -115, -28, -116, -27, -115, -26, -116, -27, -116,
-27, -117, -26, -116, -27, -118, -26, -118, -27, -117, -27, -118, -27, -118,
-28, -118, -29, -118, -30, -119, -31, -119, -32, -119, -33, -120, -35, -119,
-36, -119, -37, -119, -40, -119, -43, -119, -44, -119, -47, -120, -48, -119,
-50, -119, -53, -118, -55, -119, -57, -118, -59, -118, -60, -118, -61, -117,
-64, -118, -66, -118, -66, -117, -69, -117, -71, -117, -73, -117, -74, -116,
-76, -116, -79, -115, -80, -115, -82, -114, -85, -115, -86, -114, -89, -114,
-90, -114, -93, -113, -94, -113, -96, -113, -98, -112, -98, -112, -101, -111,
-103, -111, -104, -111, -105, -110, -106, -111, -108, -110, -110, -110, -111,
-109, -111, -108, -113, -108, -113, -108, -115, -107, -115, -107, -116, -106,
-116, -106, -117, -106, -118, -105, -119, -105, -118, -104, -119, -105, -119,
-104, -119, -103, -119, -103, -119, -102, -118, -101, -118, -101, -119, -101,
-118, -100, -119, -99, -118, -99, -117, -97, -117, -97, -117, -97, -116, -95,
-116, -96, -115, -95, -115, -95, -114, -93, -113, -92, -113, -92, -112, -91,
-111, -91, -110, -90, -109, -89, -108, -88, -107, -87, -105, -87, -104, -86,
-102, -85, -101, -84, -99, -83, -98, -82, -97, -81, -96, -80, -94, -80, -92,
-78, -91, -78, -90, -77, -89, -76, -88, -74, -86, -75, -85, -74, -83, -72, -81,
-71, -79, -70, -78, -70, -75, -69, -74, -68, -71, -67, -70, -66, -67, -65, -65,
-64, -63, -63, -61, -62, -59, -60, -57, -60, -55, -59, -53, -58, -50, -58, -49,
-57, -46, -55, -43, -54, -42, -53, -39, -52, -37, -51, -34, -50, -32, -48, -29,
-47, -27, -47, -25, -45, -23, -44, -20, -43, -17, -42, -15, -41, -13, -40, -10,
-39, -7, -37, -5, -36, -2, -34, 0, -33, 2, -32, 5, -30, 8, -29, 11, -27, 13,
-26, 15, -24, 18, -23, 20, -21, 23, -20, 25, -17, 29, -16, 28, -13, 33, -12, 33,
-10, 38, -8, 39, -7, 44, -4, 43, -2, 49, 0, 42, };