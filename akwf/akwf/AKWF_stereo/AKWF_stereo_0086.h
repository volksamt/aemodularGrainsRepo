#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0086

const PROGMEM int8_t DATA[DATA_LENGTH] = {42, 13, 118, 102, 101, 85, 90, 76, 78,
74, 66, 75, 58, 85, 51, 92, 44, 105, 41, 110, 28, 118, 22, 117, 25, 118, 25,
111, 28, 106, 30, 104, 39, 106, 32, 101, 30, 97, 26, 91, 23, 96, 21, 99, 21,
104, 22, 107, 22, 107, 22, 107, 21, 108, 24, 107, 25, 106, 40, 103, 52, 99, 50,
98, 47, 98, 44, 99, 42, 101, 40, 103, 39, 105, 38, 108, 37, 109, 37, 110, 36,
107, 39, 110, 36, 103, 43, 110, 20, 78, 5, 56, 13, 67, 13, 65, 19, 69, 20, 67,
25, 69, 25, 66, 29, 65, 30, 64, 33, 64, 34, 62, 36, 64, 36, 62, 41, 63, 47, 62,
42, 59, 45, 63, 41, 63, 45, 66, 42, 62, 48, 70, 31, 48, 7, 18, 17, 29, 16, 27,
20, 30, 21, 28, 35, 26, 27, 25, 20, 24, 24, 23, 16, 22, 15, 23, 15, 21, 20, 23,
18, 22, 21, 25, 14, 19, 20, 25, 17, 20, 32, 38, 50, 62, 59, 66, 51, 50, 18, 12,
20, 20, 19, 22, 18, 25, 18, 27, 17, 27, 18, 28, 17, 25, 17, 24, 14, 21, 15, 20,
13, 19, 17, 25, 12, 24, 9, 23, 9, 21, 7, 22, 6, 19, 5, 20, 5, 19, 4, 20, 5, 19,
4, 19, 5, 18, 3, 18, 8, 18, 15, 17, 15, 17, 9, 18, -2, 22, 0, 21, 0, 22, -1, 22,
0, 24, -1, 22, 2, 23, -1, 20, 3, 23, -1, 17, 23, 47, 26, 51, -6, 9, 0, 21, -15,
3, -33, -19, -31, -17, -27, -13, -24, -12, -20, -14, -28, -13, -28, -15, -21,
-19, -19, -22, -17, -24, -10, -25, 0, -24, -1, -28, -3, -24, -9, -22, -9, -23,
-9, -22, -8, -20, -6, -20, -9, -18, -9, -19, -9, -19, -6, -20, -6, -21, -3, -22,
-7, -21, -15, -20, -11, -19, -10, -18, -8, -19, -7, -19, -5, -17, -6, -19, -3,
-19, -3, -20, -1, -20, -4, -24, 6, -13, 52, 45, 64, 61, 57, 51, 54, 51, 47, 49,
42, 53, 38, 57, 36, 62, 33, 64, 33, 68, 31, 68, 30, 69, 29, 67, 29, 65, 28, 62,
29, 62, 28, 63, 23, 60, 24, 58, 20, 55, 24, 61, 19, 58, 27, 69, 7, 46, -14, 21,
-5, 31, -6, 29, -3, 30, 6, 26, 49, 18, 54, 14, 42, 13, 36, 13, 27, 13, 24, 14,
18, 15, 16, 19, 11, 20, 9, 24, 0, 20, 3, 23, 1, 21, 3, 24, 2, 22, -27, -19, -27,
-21, -23, -15, -21, -16, -19, -13, -19, -16, -16, -16, -15, -18, -13, -18, -12,
-21, -11, -20, -11, -22, -9, -20, -8, -21, -2, -20, -1, -24, -3, -24, -3, -22,
-4, -22, -4, -20, -4, -19, -4, -20, -3, -19, -4, -19, -4, -19, -4, -20, -5, -20,
-5, -20, -4, -19, -17, -18, -16, -17, -14, -18, -11, -19, -10, -19, -10, -20,
-9, -21, -9, -21, -7, -21, -9, -21, -6, -20, -8, -22, 54, 57, 92, 105, 86, 95,
56, 62, 31, 38, 36, 55, 26, 54, 31, 67, 16, 58, -5, 35, -20, 33, -16, 37, -13,
32, -8, 30, -6, 22, 2, 26, 12, 33, 6, 26, 4, 21, 1, 16, -2, 16, -5, 16, -4, 18,
-4, 18, -4, 19, -4, 20, -4, 21, -1, 18, 0, 19, 10, 15, 14, 15, 17, 14, 7, 17, 1,
18, 4, 21, 4, 21, 5, 24, 4, 25, 6, 26, 5, 25, 5, 24, 6, 24, 5, 20, 11, 26, -16,
-10, -27, -27, -19, -16, -20, -20, -15, -15, -14, -17, -11, -16, -11, -20, -8,
-19, -7, -21, -6, -21, -6, -22, -4, -22, -4, -23, -1, -21, 0, -22, -2, -25, -3,
-20, -7, -22, -2, -17, -5, -22, 2, -14, -19, -42, -38, -66, -28, -56, -29, -58,
-24, -54, -23, -57, -11, -58, -20, -60, -24, -61, -22, -62, -30, -62, -31, -63,
-29, -64, -26, -62, -26, -63, -24, -62, -31, -67, -25, -61, -28, -65, 1, -30,
42, 21, 41, 16, 38, 11, 33, 8, 28, 9, 22, 12, 20, 15, 17, 20, 14, 23, 11, 26, 8,
26, 7, 26, 7, 25, 7, 22, 5, 20, 7, 20, 4, 19, 1, 17, 0, 13, 0, 15, 0, 16, 0, 18,
0, 21, 0, 24, 0, 24, 0, 25, 1, 24, 0, 24, 10, 20, 23, 17, 19, 16, 15, 16, 12,
16, 9, 16, 7, 19, 5, 19, 4, 21, 1, 20, 3, 23, 0, 20, 2, 23, -1, 18, 27, 52, 22,
47, -8, 10, 2, 22, -19, -1, -32, -19, -30, -16, -26, -13, -24, -12, -20, -12,
-28, -14, -26, -15, -20, -19, -17, -22, -16, -24, -4, -24, 11, -24, 6, -28, 4,
-25, 1, -24, -1, -24, -3, -21, -2, -19, -2, -19, -2, -18, -2, -19, -2, -18, -1,
-21, -3, -20, 0, -21, -6, -21, -15, -19, -9, -20, -10, -19, -7, -18, -7, -19,
-5, -17, -5, -19, -3, -18, -4, -21, -1, -19, -5, -24, 4, -13, 25, 14, 32, 20,
26, 11, -8, -27, -10, -26, -7, -20, -8, -18, -7, -14, -8, -15, -7, -13, -8, -17,
-6, -18, -8, -22, -6, -23, -8, -24, -5, -19, -7, -18, -11, -19, -11, -19, -13,
-21, -12, -19, -16, -23, -9, -15, -33, -46, -49, -68, -41, -58, -41, -61, -39,
-58, -29, -62, -3, -66, -2, -68, -9, -68, -23, -65, -26, -66, -26, -65, -29,
-65, -27, -63, -37, -61, -41, -59, -47, -64, -42, -60, -41, -64, -35, -59, -40,
-67, -68, -106, -63, -103, -61, -100, -58, -100, -56, -99, -55, -100, -51, -101,
-51, -103, -49, -104, -48, -106, -48, -106, -47, -107, -47, -106, -46, -106,
-43, -105, -43, -109, -44, -109, -48, -105, -47, -105, -46, -104, -45, -104,
-44, -105, -45, -104, -44, -105, -43, -105, -44, -105, -45, -104, -45, -105,
-46, -104, -57, -104, -55, -101, -54, -104, -51, -102, -51, -106, -49, -103,
-49, -108, -47, -103, -49, -110, -45, -102, -50, -113, -41, -91, };