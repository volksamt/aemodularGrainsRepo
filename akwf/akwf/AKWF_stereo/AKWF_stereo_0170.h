#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0170

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 73, 1, 87, 2, 80, 2, 84, 3, 81, 3,
84, 4, 81, 6, 83, 6, 80, 9, 81, 13, 78, 18, 81, 23, 79, 27, 79, 32, 78, 38, 78,
43, 76, 48, 77, 52, 75, 59, 74, 65, 73, 69, 74, 75, 72, 79, 72, 80, 71, 83, 70,
85, 70, 87, 68, 89, 68, 91, 68, 93, 67, 93, 66, 95, 65, 98, 64, 97, 64, 99, 63,
100, 63, 101, 62, 103, 62, 104, 62, 104, 61, 106, 60, 106, 58, 107, 59, 108, 59,
108, 59, 109, 59, 110, 58, 110, 59, 111, 59, 112, 59, 112, 59, 112, 59, 113, 59,
113, 59, 114, 59, 114, 60, 115, 60, 115, 60, 115, 60, 115, 58, 115, 57, 115, 56,
116, 54, 116, 53, 116, 51, 118, 49, 116, 48, 117, 47, 118, 44, 117, 42, 118, 41,
117, 40, 119, 39, 118, 37, 118, 37, 118, 36, 119, 36, 119, 35, 118, 34, 118, 35,
120, 35, 119, 35, 119, 35, 119, 36, 119, 35, 119, 36, 119, 35, 119, 36, 118, 36,
119, 36, 119, 36, 119, 36, 118, 35, 118, 36, 119, 35, 119, 34, 119, 34, 119, 34,
119, 34, 119, 34, 119, 34, 119, 35, 120, 35, 119, 35, 119, 36, 119, 39, 119, 44,
119, 48, 119, 53, 119, 58, 119, 62, 119, 67, 119, 72, 119, 77, 119, 82, 119, 88,
119, 93, 120, 99, 118, 102, 119, 105, 117, 106, 116, 108, 116, 109, 116, 110,
115, 111, 114, 112, 113, 112, 112, 113, 111, 112, 108, 109, 104, 105, 99, 100,
93, 95, 89, 90, 83, 84, 78, 78, 72, 73, 66, 66, 60, 60, 52, 54, 46, 46, 38, 39,
32, 34, 28, 29, 25, 27, 22, 25, 19, 22, 17, 20, 15, 18, 11, 17, 10, 15, 7, 14,
6, 13, 3, 12, 2, 10, 1, 9, -1, 7, -3, 7, -4, 6, -5, 5, -7, 3, -7, 3, -8, 1, -10,
2, -12, 0, -12, 0, -14, 0, -15, 0, -15, 0, -17, -1, -18, 0, -19, -1, -20, -1,
-22, -1, -23, -2, -24, -3, -26, -2, -27, -2, -29, -4, -28, -5, -30, -5, -31, -6,
-32, -10, -33, -14, -33, -18, -33, -23, -34, -27, -34, -31, -33, -36, -33, -41,
-33, -45, -34, -50, -33, -54, -33, -59, -33, -64, -33, -68, -34, -70, -35, -72,
-35, -76, -36, -77, -35, -79, -35, -81, -36, -82, -36, -84, -36, -85, -36, -86,
-36, -88, -36, -89, -35, -89, -35, -91, -35, -93, -35, -93, -35, -93, -34, -94,
-34, -94, -34, -95, -33, -96, -33, -97, -33, -97, -33, -98, -33, -98, -33, -98,
-33, -99, -32, -98, -31, -99, -31, -98, -31, -99, -30, -98, -31, -98, -30, -97,
-30, -98, -27, -97, -26, -96, -24, -95, -22, -95, -20, -95, -18, -94, -17, -93,
-14, -93, -13, -92, -11, -92, -9, -92, -7, -91, -6, -91, -6, -90, -5, -90, -4,
-90, -5, -89, -4, -89, -4, -90, -4, -89, -4, -89, -3, -89, -3, -89, -4, -88, -4,
-88, -4, -88, -6, -89, -6, -88, -6, -88, -8, -88, -8, -86, -10, -87, -12, -86,
-14, -85, -17, -85, -22, -85, -28, -84, -33, -84, -38, -83, -42, -83, -48, -81,
-53, -81, -58, -80, -63, -80, -68, -79, -74, -78, -78, -78, -83, -76, -85, -76,
-87, -75, -89, -74, -91, -73, -93, -73, -95, -72, -96, -71, -97, -72, -98, -71,
-100, -70, -102, -69, -103, -68, -103, -68, -105, -67, -107, -66, -107, -65,
-107, -65, -108, -65, -110, -64, -110, -64, -111, -64, -112, -63, -112, -63,
-112, -64, -113, -64, -114, -63, -115, -64, -115, -64, -115, -64, -116, -64,
-116, -65, -117, -65, -118, -65, -117, -65, -118, -64, -118, -64, -118, -63,
-118, -62, -119, -60, -119, -59, -119, -58, -119, -56, -119, -55, -118, -52,
-119, -50, -119, -50, -119, -47, -119, -46, -119, -44, -120, -43, -120, -42,
-120, -41, -120, -41, -119, -40, -119, -40, -120, -39, -119, -39, -119, -40,
-118, -40, -120, -40, -119, -40, -120, -39, -119, -40, -120, -41, -120, -41,
-119, -41, -118, -41, -120, -40, -119, -40, -119, -40, -120, -39, -119, -40,
-118, -40, -120, -39, -120, -39, -119, -38, -118, -38, -119, -39, -118, -39,
-119, -40, -119, -40, -119, -41, -119, -44, -119, -48, -119, -53, -119, -58,
-119, -63, -119, -67, -119, -72, -119, -78, -119, -82, -119, -87, -119, -92,
-119, -97, -119, -103, -119, -107, -118, -110, -118, -111, -120, -113, -119,
-114, -118, -115, -118, -116, -117, -116, -117, -117, -115, -117, -115, -116,
-111, -114, -107, -110, -101, -104, -97, -100, -91, -94, -85, -88, -80, -83,
-75, -77, -69, -71, -62, -64, -56, -57, -49, -50, -41, -43, -36, -38, -32, -35,
-29, -32, -27, -30, -23, -27, -21, -26, -18, -23, -16, -22, -14, -20, -12, -20,
-9, -18, -8, -17, -6, -15, -4, -14, -4, -13, -2, -12, 0, -11, 0, -10, 2, -8, 3,
-8, 5, -7, 6, -7, 6, -7, 8, -6, 9, -5, 10, -6, 11, -5, 13, -5, 14, -4, 15, -5,
17, -4, 18, -4, 19, -3, 20, -3, 21, -2, 22, -3, 25, -1, 26, -2, 26, 0, 27, 3,
28, 5, 28, 10, 28, 14, 29, 19, 29, 22, 30, 26, 30, 31, 30, 35, 30, 40, 29, 44,
29, 49, 29, 54, 30, 59, 29, 63, 29, 66, 30, 68, 31, 69, 31, 72, 31, 74, 31, 76,
32, 77, 32, 79, 32, 80, 31, 82, 32, 83, 32, 83, 31, 85, 31, 86, 30, 86, 30, 88,
30, 89, 30, 89, 29, 89, 29, 91, 29, 91, 29, 91, 29, 93, 28, 93, 28, 93, 28, 93,
28, 93, 28, 94, 28, 94, 27, 93, 27, 93, 27, 94, 26, 93, 26, 93, 24, 93, 23, 92,
21, 91, 20, 90, 18, 90, 15, 89, 14, 89, 13, 89, 10, 88, 9, 88, 7, 86, 5, 86, 3,
86, 2, 87, 1, 85, 1, 86, 0, 84, 0, 87, 1, 82, -1, 86, -1, 81, 0, 87, 0, 80, 0,
88, -1, 71, };