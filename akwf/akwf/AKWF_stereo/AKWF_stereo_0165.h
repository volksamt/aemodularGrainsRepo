#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0165

const PROGMEM int8_t DATA[DATA_LENGTH] = {14, 82, 35, 95, 35, 86, 35, 90, 36,
84, 39, 88, 39, 84, 41, 87, 42, 83, 43, 86, 44, 84, 45, 85, 47, 84, 48, 85, 49,
84, 50, 85, 51, 84, 52, 86, 54, 85, 54, 84, 56, 83, 58, 83, 58, 82, 59, 82, 59,
82, 61, 82, 62, 81, 62, 82, 63, 82, 64, 82, 65, 83, 65, 83, 68, 83, 68, 84, 68,
84, 70, 85, 70, 87, 71, 87, 73, 88, 73, 89, 74, 89, 75, 91, 76, 91, 77, 91, 76,
92, 77, 93, 78, 93, 79, 90, 80, 88, 80, 83, 80, 79, 81, 75, 81, 73, 82, 71, 82,
70, 83, 69, 84, 68, 85, 67, 85, 67, 85, 67, 86, 66, 87, 66, 87, 66, 88, 66, 89,
67, 89, 67, 90, 67, 90, 69, 91, 70, 92, 70, 94, 71, 95, 72, 96, 73, 97, 72, 98,
74, 99, 74, 100, 75, 101, 73, 102, 72, 103, 71, 103, 71, 104, 70, 105, 71, 107,
70, 107, 70, 108, 70, 109, 71, 108, 71, 108, 71, 106, 70, 105, 72, 103, 72, 102,
72, 101, 73, 101, 75, 101, 73, 101, 81, 101, 100, 102, 106, 101, 106, 103, 108,
103, 108, 104, 111, 103, 111, 104, 111, 104, 110, 105, 110, 106, 111, 106, 112,
106, 112, 106, 114, 107, 115, 108, 114, 109, 116, 108, 116, 110, 118, 108, 116,
114, 120, 110, 115, 123, 127, 66, 71, 7, 11, 11, 11, 3, 3, 4, 4, 0, -2, -1, -2,
-4, -6, -4, -8, -7, -9, -8, -11, -11, -12, -12, -13, -12, -15, -15, -14, -15,
-15, -17, -17, -17, -17, -18, -18, -18, -18, -20, -20, -20, -20, -20, -21, -21,
-21, -21, -22, -21, -23, -22, -23, -21, -23, -21, -23, -22, -24, -22, -24, -22,
-23, -22, -25, -23, -23, -23, -22, -22, -21, -24, -21, -25, -20, -28, -20, -30,
-18, -31, -19, -32, -18, -33, -18, -35, -17, -36, -18, -38, -17, -39, -16, -40,
-16, -41, -15, -41, -16, -40, -14, -40, -16, -39, -9, -37, -58, -36, -91, -35,
-88, -33, -94, -33, -94, -33, -98, -32, -98, -33, -101, -33, -101, -34, -102,
-35, -103, -36, -104, -39, -105, -41, -108, -42, -108, -42, -108, -41, -109,
-40, -110, -39, -110, -38, -111, -39, -112, -37, -112, -38, -113, -37, -113,
-36, -113, -37, -112, -36, -113, -35, -114, -35, -114, -35, -113, -34, -114,
-34, -113, -33, -114, -34, -115, -32, -116, -31, -117, -32, -117, -30, -116,
-30, -116, -29, -116, -29, -115, -29, -115, -29, -115, -28, -115, -28, -114,
-28, -114, -27, -113, -29, -114, -12, -114, 2, -113, 1, -112, -1, -111, 0, -110,
0, -111, 0, -109, 1, -109, 2, -108, 2, -109, 3, -108, 4, -107, 5, -107, 5, -106,
6, -106, 7, -106, 9, -106, 10, -105, 9, -105, 10, -104, 8, -103, 8, -102, 6,
-103, 7, -101, 6, -101, 8, -101, 7, -100, 8, -101, 8, -99, 9, -99, 7, -97, 10,
-94, 8, -93, 11, -91, 8, -91, -54, -89, -74, -87, -73, -86, -76, -85, -76, -83,
-79, -82, -79, -80, -83, -79, -83, -78, -85, -78, -85, -76, -87, -75, -87, -75,
-89, -74, -88, -74, -90, -72, -90, -71, -91, -71, -91, -69, -92, -69, -93, -67,
-93, -66, -94, -65, -94, -64, -94, -63, -95, -61, -96, -61, -95, -60, -95, -59,
-95, -59, -95, -57, -94, -56, -94, -56, -95, -55, -95, -56, -95, -57, -94, -58,
-95, -57, -95, -58, -95, -58, -95, -58, -94, -58, -94, -58, -94, -57, -94, -56,
-93, -56, -94, -56, -92, -53, -92, -51, -92, -48, -92, -45, -90, -42, -91, -40,
-90, -39, -89, -37, -88, -36, -88, -35, -88, -34, -88, -32, -87, -31, -87, -30,
-86, -29, -86, -28, -85, -28, -85, -27, -85, -26, -83, -27, -83, -27, -83, -29,
-83, -29, -84, -28, -85, -29, -86, -29, -88, -28, -87, -27, -87, -27, -88, -27,
-87, -25, -87, -24, -87, -23, -86, -21, -85, -20, -86, -19, -88, -19, -89, -18,
-89, -18, -88, -16, -89, -15, -88, -15, -86, -14, -84, -14, -83, -12, -83, -13,
-81, -10, -80, -13, -80, -5, -80, -37, -79, -73, -79, -70, -78, -75, -78, -74,
-77, -76, -76, -76, -75, -78, -76, -78, -75, -78, -75, -79, -74, -80, -73, -82,
-73, -83, -71, -83, -72, -85, -70, -85, -70, -86, -69, -85, -69, -86, -70, -85,
-74, -86, -74, -84, -79, -88, -58, -67, -25, -33, -24, -30, -22, -26, -20, -24,
-19, -22, -17, -20, -16, -18, -13, -16, -12, -16, -10, -15, -8, -15, -7, -15,
-6, -14, -3, -14, -4, -12, -1, -11, 0, -11, 1, -10, 1, -9, 3, -7, 4, -6, 6, -5,
7, -4, 8, -3, 8, -2, 9, -1, 11, 0, 11, 0, 12, 1, 13, 2, 15, 3, 15, 3, 17, 2, 17,
1, 18, 0, 20, -1, 22, -1, 24, -1, 26, -1, 27, -1, 29, 0, 30, 0, 33, 2, 34, 1,
36, 2, 37, 2, 38, 3, 40, 4, 41, 5, 41, 4, 40, 6, 39, 5, 37, 25, 34, 50, 34, 51,
34, 53, 33, 55, 33, 56, 32, 58, 34, 60, 35, 61, 35, 63, 37, 64, 38, 66, 40, 67,
41, 68, 43, 69, 41, 71, 40, 72, 39, 73, 39, 74, 38, 76, 37, 76, 38, 77, 38, 78,
39, 79, 39, 80, 39, 81, 40, 82, 39, 83, 41, 83, 41, 84, 42, 85, 42, 85, 43, 86,
43, 88, 44, 89, 45, 89, 45, 90, 45, 89, 46, 89, 46, 88, 47, 89, 47, 88, 48, 89,
47, 89, 50, 89, 48, 90, 52, 90, 47, 90, 2, 91, -10, 90, -8, 91, -11, 90, -11,
91, -12, 91, -12, 92, -13, 92, -13, 92, -14, 92, -14, 93, -16, 94, -15, 94, -16,
94, -16, 95, -17, 96, -16, 96, -17, 96, -17, 97, -17, 98, -16, 98, -14, 100,
-13, 99, -13, 101, -13, 99, -12, 102, -12, 100, -12, 103, -11, 101, -11, 104,
-11, 97, -10, 100, -9, 92, -9, 101, -7, 80, };