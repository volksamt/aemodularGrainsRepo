#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0080

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 1, 5, 4, 7, 5, 8, 6, 11, 9, 12,
11, 14, 12, 16, 14, 18, 16, 19, 17, 21, 19, 24, 20, 25, 22, 26, 23, 29, 25, 31,
27, 33, 29, 34, 30, 36, 32, 38, 34, 40, 35, 41, 37, 44, 39, 45, 39, 48, 41, 48,
43, 51, 45, 53, 47, 53, 48, 55, 50, 57, 51, 59, 54, 60, 54, 62, 57, 64, 58, 65,
59, 67, 61, 70, 62, 70, 63, 73, 64, 74, 66, 75, 67, 77, 69, 78, 71, 79, 71, 81,
73, 82, 74, 84, 75, 85, 77, 87, 78, 88, 79, 89, 80, 91, 81, 91, 82, 93, 84, 94,
85, 95, 86, 96, 87, 97, 88, 99, 89, 100, 90, 101, 91, 102, 92, 103, 93, 103, 94,
104, 95, 105, 95, 106, 96, 107, 97, 108, 97, 110, 98, 110, 98, 110, 99, 112, 99,
112, 101, 113, 101, 114, 101, 114, 102, 114, 103, 115, 103, 115, 103, 116, 103,
117, 104, 116, 104, 118, 105, 118, 105, 118, 106, 119, 106, 118, 106, 118, 106,
119, 107, 118, 106, 119, 106, 119, 107, 119, 106, 118, 107, 119, 107, 119, 106,
119, 106, 119, 107, 118, 107, 119, 106, 118, 106, 118, 106, 117, 107, 117, 106,
117, 106, 117, 105, 116, 105, 116, 105, 116, 105, 115, 105, 114, 104, 113, 104,
113, 103, 113, 103, 113, 102, 111, 102, 111, 101, 110, 101, 110, 100, 109, 100,
108, 99, 107, 99, 107, 97, 106, 97, 104, 96, 104, 95, 103, 95, 101, 93, 100, 92,
99, 92, 98, 91, 97, 89, 96, 88, 95, 88, 93, 87, 92, 85, 91, 84, 89, 84, 89, 83,
87, 81, 85, 80, 84, 78, 83, 78, 82, 76, 79, 75, 78, 74, 78, 72, 75, 72, 74, 69,
72, 68, 70, 66, 68, 66, 67, 63, 65, 62, 63, 60, 61, 59, 60, 57, 58, 56, 55, 54,
54, 52, 52, 51, 51, 49, 49, 48, 47, 45, 44, 44, 42, 42, 41, 41, 39, 40, 37, 38,
35, 36, 33, 34, 32, 33, 29, 31, 28, 30, 26, 29, 24, 27, 23, 25, 21, 24, 19, 22,
17, 20, 16, 19, 14, 16, 11, 16, 9, 14, 8, 12, 6, 9, 5, 8, 3, 6, 1, 5, -1, 4, -2,
2, -4, 1, -7, -1, -8, -2, -9, -4, -11, -6, -13, -7, -14, -9, -15, -10, -17, -12,
-19, -13, -20, -15, -22, -16, -23, -17, -25, -20, -27, -21, -28, -23, -29, -23,
-31, -25, -32, -26, -34, -27, -35, -28, -37, -31, -37, -31, -38, -32, -40, -34,
-41, -34, -43, -36, -44, -37, -45, -39, -46, -39, -47, -40, -48, -41, -50, -44,
-51, -43, -51, -44, -53, -46, -53, -46, -54, -48, -55, -48, -55, -50, -57, -50,
-57, -51, -59, -52, -60, -54, -61, -54, -62, -54, -62, -56, -62, -57, -63, -57,
-64, -58, -65, -59, -65, -60, -65, -60, -67, -60, -67, -61, -68, -61, -69, -62,
-69, -62, -70, -63, -70, -63, -70, -64, -71, -65, -71, -65, -71, -65, -72, -65,
-72, -65, -73, -66, -73, -67, -73, -66, -72, -67, -73, -68, -73, -67, -73, -67,
-73, -68, -73, -68, -75, -68, -74, -69, -74, -69, -74, -69, -74, -69, -74, -69,
-74, -69, -74, -69, -74, -69, -74, -69, -73, -69, -74, -68, -73, -68, -73, -68,
-73, -68, -72, -69, -73, -68, -73, -68, -72, -67, -72, -68, -72, -67, -72, -67,
-72, -67, -71, -67, -70, -66, -70, -66, -69, -65, -69, -65, -69, -64, -68, -65,
-67, -65, -68, -64, -67, -63, -67, -62, -66, -63, -65, -61, -65, -61, -64, -61,
-63, -61, -63, -61, -62, -59, -63, -59, -61, -58, -61, -58, -61, -57, -60, -56,
-60, -56, -58, -55, -57, -55, -58, -55, -56, -54, -55, -53, -55, -52, -54, -52,
-54, -52, -53, -51, -52, -50, -51, -50, -51, -49, -50, -48, -49, -48, -49, -49,
-48, -47, -48, -47, -47, -47, -46, -45, -46, -45, -46, -45, -44, -45, -45, -44,
-43, -43, -43, -42, -43, -42, -42, -42, -41, -41, -41, -40, -41, -41, -40, -39,
-39, -39, -39, -39, -39, -39, -38, -38, -38, -37, -38, -37, -37, -37, -36, -37,
-36, -36, -36, -35, -36, -35, -35, -35, -35, -35, -34, -33, -33, -34, -33, -33,
-32, -32, -33, -33, -33, -31, -32, -30, -31, -31, -31, -30, -31, -30, -30, -28,
-30, -28, -28, -28, -28, -28, -28, -26, -28, -28, -28, -27, -28, -26, -27, -28,
-27, -27, -27, -28, -28, -27, -28, -28, -28, -28, -28, -28, -28, -29, -29, -29,
-29, -29, -29, -29, -30, -30, -31, -31, -31, -31, -31, -31, -33, -32, -33, -32,
-33, -33, -33, -33, -34, -33, -35, -34, -35, -34, -36, -35, -36, -35, -38, -36,
-39, -36, -38, -36, -40, -38, -41, -38, -42, -39, -43, -39, -43, -40, -44, -40,
-45, -42, -45, -41, -46, -42, -47, -43, -47, -43, -48, -45, -49, -44, -50, -45,
-51, -46, -51, -46, -53, -47, -53, -48, -54, -47, -54, -49, -55, -48, -55, -49,
-56, -49, -57, -50, -57, -50, -57, -51, -59, -51, -58, -51, -58, -52, -60, -53,
-60, -53, -61, -53, -61, -55, -62, -54, -62, -54, -61, -54, -63, -55, -62, -56,
-63, -56, -63, -55, -64, -56, -63, -56, -64, -56, -64, -56, -65, -56, -64, -57,
-64, -56, -65, -57, -64, -57, -64, -57, -64, -57, -63, -57, -63, -56, -64, -57,
-64, -56, -62, -56, -63, -55, -63, -55, -62, -55, -61, -55, -61, -54, -60, -54,
-60, -53, -60, -53, -60, -52, -57, -52, -58, -51, -56, -51, -56, -50, -55, -49,
-54, -48, -53, -48, -52, -46, -51, -46, -50, -45, -50, -44, -48, -42, -47, -42,
-45, -41, -44, -40, -43, -38, -41, -37, -40, -36, -38, -34, -37, -33, -35, -32,
-34, -31, -32, -29, -31, -28, -29, -27, -28, -26, -26, -24, -24, -22, -22, -21,
-21, -20, -20, -18, -18, -17, -16, -15, -14, -14, -13, -12, -11, -11, -9, -8,
-7, -7, -6, -6, -4, -4, -3, -3, 0, -1, 0, };