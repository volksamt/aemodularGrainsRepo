#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0083

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, -28, 12, -31, 13, -24, 13, -22, 12,
-14, 13, -8, 13, 1, 13, 8, 14, 17, 15, 21, 15, 26, 16, 29, 17, 30, 18, 30, 19,
31, 20, 31, 21, 33, 20, 33, 20, 36, 21, 39, 22, 43, 23, 46, 25, 49, 30, 53, 32,
54, 31, 55, 32, 56, 33, 56, 34, 56, 35, 55, 36, 56, 37, 58, 39, 57, 39, 60, 41,
62, 42, 64, 44, 65, 45, 68, 47, 68, 49, 70, 49, 69, 52, 70, 52, 70, 54, 71, 54,
71, 57, 71, 57, 71, 60, 73, 61, 72, 63, 74, 63, 75, 66, 76, 66, 76, 68, 77, 69,
77, 71, 77, 72, 77, 74, 78, 75, 77, 76, 77, 77, 78, 76, 78, 80, 79, 66, 79, 68,
83, 64, 77, 78, 88, 33, 53, -15, 18, -6, 22, -14, 14, -7, 14, -10, 8, -6, 5, -8,
-2, -5, -6, -6, -13, -6, -16, -6, -19, -5, -22, -7, -23, -7, -23, -7, -23, -8,
-23, -8, -23, -10, -25, -6, -26, -7, -29, -7, -32, -9, -35, -10, -37, -12, -39,
-14, -40, -15, -42, -16, -42, -19, -42, -18, -41, -20, -42, -22, -41, -24, -42,
-25, -43, -27, -44, -27, -45, -29, -46, -30, -48, -33, -49, -34, -49, -36, -50,
-38, -51, -39, -51, -40, -51, -41, -52, -43, -52, -44, -52, -45, -52, -47, -52,
-48, -53, -50, -54, -51, -55, -52, -55, -53, -56, -54, -57, -56, -57, -56, -56,
-58, -57, -57, -57, -59, -57, -58, -56, -61, -58, -58, -57, -67, -58, -74, -55,
-74, -57, -70, -54, -77, -60, -62, -52, -22, -25, -23, -25, -18, -20, -17, -19,
-15, -15, -14, -12, -13, -9, -11, -6, -10, -3, -9, 0, -9, 2, -8, 4, -8, 4, -6,
4, -8, 2, -7, 4, -7, 3, -5, 5, -6, 5, -6, 7, -5, 7, -4, 9, -2, 11, 0, 13, 0, 14,
2, 15, 3, 15, 4, 14, 5, 15, 7, 15, 7, 15, 8, 15, 10, 16, 11, 17, 12, 18, 13, 18,
14, 19, 15, 20, 17, 20, 18, 21, 19, 22, 20, 22, 21, 22, 22, 23, 23, 22, 23, 24,
25, 23, 25, 24, 26, 24, 28, 25, 28, 25, 28, 26, 29, 26, 30, 27, 31, 26, 31, 27,
32, 28, 32, 27, 34, 27, 32, 28, 35, 28, 31, 29, 39, 28, 66, 25, 64, 26, 61, 26,
57, 24, 53, 26, 51, 26, 49, 27, 48, 29, 46, 30, 45, 31, 43, 32, 43, 31, 41, 33,
41, 33, 38, 33, 38, 32, 37, 33, 37, 33, 34, 32, 34, 33, 33, 33, 33, 33, 32, 33,
32, 33, 33, 33, 33, 33, 33, 33, 32, 33, 31, 33, 30, 34, 30, 35, 30, 34, 29, 33,
30, 34, 28, 35, 29, 35, 28, 35, 29, 35, 27, 34, 28, 34, 28, 35, 27, 35, 28, 34,
28, 34, 28, 35, 27, 35, 27, 35, 27, 35, 26, 36, 26, 36, 27, 35, 27, 35, 27, 35,
27, 35, 27, 35, 26, 34, 34, 40, 36, 42, 37, 42, 36, 42, 37, 41, 37, 43, 37, 43,
36, 45, 32, 45, 33, 46, 34, 46, 34, 46, 16, 48, 15, 48, 17, 47, 24, 53, 32, 56,
30, 52, 32, 52, 32, 49, 34, 48, 33, 46, 34, 45, 34, 44, 36, 45, 37, 44, 38, 45,
39, 45, 41, 46, 42, 46, 43, 48, 47, 47, 47, 48, 48, 48, 48, 49, 48, 48, 49, 49,
50, 49, 50, 49, 50, 50, 49, 49, 49, 48, 50, 48, 49, 48, 50, 48, 50, 49, 50, 49,
51, 49, 50, 49, 51, 48, 51, 49, 51, 49, 51, 48, 51, 48, 51, 49, 51, 49, 51, 49,
51, 49, 52, 50, 52, 49, 51, 49, 51, 49, 52, 49, 52, 49, 51, 49, 52, 49, 51, 50,
51, 50, 51, 50, 51, 50, 51, 50, 51, 49, 51, 50, 50, 50, 51, 50, 47, 50, 47, 51,
46, 51, 47, 50, 46, 50, 56, 49, 61, 48, 59, 50, 57, 48, 52, 43, 53, 46, 52, 46,
54, 49, 53, 49, 54, 51, 53, 52, 53, 52, 54, 53, 53, 53, 52, 52, 51, 52, 51, 52,
50, 51, 50, 51, 47, 51, 48, 51, 46, 50, 48, 51, 46, 49, 47, 50, 48, 50, 48, 50,
47, 49, 48, 50, 47, 50, 47, 51, 48, 50, 48, 51, 47, 50, 48, 51, 49, 50, 47, 50,
50, 51, 45, 48, 53, 55, 17, 27, -13, 7, -7, 10, -14, 5, -10, 6, -13, 0, -11, -1,
-13, -7, -11, -9, -14, -13, -13, -15, -14, -18, -13, -20, -14, -20, -14, -20,
-14, -20, -15, -20, -15, -20, -16, -21, -15, -23, -17, -23, -17, -25, -19, -27,
-12, -29, -7, -32, -10, -32, -10, -34, -12, -33, -13, -33, -15, -32, -17, -33,
-17, -32, -16, -30, -17, -31, -19, -32, -21, -33, -23, -35, -25, -36, -26, -38,
-28, -39, -29, -40, -30, -40, -31, -40, -32, -39, -32, -39, -32, -39, -33, -39,
-33, -39, -33, -39, -35, -40, -35, -40, -36, -41, -37, -41, -38, -41, -38, -42,
-39, -43, -39, -41, -40, -43, -39, -41, -42, -43, -41, -41, -42, -42, -41, -41,
-44, -43, -43, -41, -46, -44, -40, -40, -53, -49, -91, -76, -92, -76, -95, -79,
-94, -79, -96, -82, -95, -84, -95, -87, -96, -91, -97, -94, -97, -97, -97, -97,
-97, -100, -96, -101, -96, -102, -97, -101, -98, -101, -98, -102, -99, -102,
-98, -102, -101, -104, -101, -104, -102, -105, -102, -107, -105, -108, -110,
-109, -109, -110, -110, -110, -109, -110, -108, -110, -108, -111, -106, -110,
-107, -110, -105, -111, -106, -111, -105, -112, -107, -112, -106, -113, -106,
-114, -105, -114, -105, -115, -106, -116, -107, -116, -107, -116, -106, -116,
-105, -117, -107, -116, -106, -117, -106, -116, -108, -117, -107, -117, -108,
-118, -107, -117, -110, -118, -109, -118, -111, -118, -109, -118, -112, -119,
-110, -118, -112, -119, -110, -118, -113, -119, -110, -118, -114, -119, -111,
-118, -114, -119, -111, -119, -116, -119, -110, -119, -10, -40, };