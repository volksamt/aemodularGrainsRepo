#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0055

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 2, 3, 4, 4, 6, 6, 7, 6, 8, 7,
10, 9, 12, 9, 14, 12, 16, 12, 17, 14, 18, 14, 21, 15, 22, 17, 24, 18, 24, 19,
27, 20, 28, 21, 30, 23, 32, 23, 33, 25, 34, 26, 36, 27, 38, 28, 39, 30, 41, 30,
42, 31, 44, 33, 45, 34, 47, 35, 49, 36, 50, 37, 51, 38, 53, 39, 54, 41, 56, 42,
56, 42, 58, 43, 59, 45, 62, 46, 62, 46, 64, 48, 65, 49, 66, 50, 67, 51, 69, 52,
71, 53, 71, 54, 73, 54, 74, 55, 76, 57, 76, 57, 77, 59, 78, 59, 80, 59, 82, 61,
82, 62, 83, 62, 85, 64, 86, 65, 87, 65, 88, 66, 89, 66, 89, 67, 90, 69, 92, 69,
93, 69, 93, 70, 95, 71, 95, 72, 96, 73, 97, 74, 98, 74, 99, 74, 100, 75, 100,
75, 101, 77, 101, 77, 103, 78, 103, 78, 104, 79, 104, 79, 105, 80, 106, 81, 107,
82, 107, 82, 108, 83, 108, 82, 110, 83, 109, 84, 111, 84, 111, 84, 111, 85, 111,
86, 111, 86, 112, 86, 113, 86, 113, 86, 114, 87, 114, 87, 114, 88, 115, 88, 115,
89, 116, 88, 115, 89, 116, 89, 116, 89, 116, 89, 117, 89, 117, 90, 118, 90, 117,
91, 118, 90, 119, 90, 118, 91, 118, 91, 118, 91, 118, 91, 119, 91, 119, 91, 120,
92, 118, 91, 119, 91, 119, 91, 119, 91, 119, 91, 119, 91, 120, 91, 119, 91, 119,
91, 119, 92, 119, 91, 119, 91, 119, 91, 118, 91, 119, 91, 119, 91, 118, 90, 118,
90, 118, 90, 118, 90, 117, 90, 117, 89, 117, 90, 117, 89, 116, 88, 116, 90, 115,
89, 115, 89, 115, 88, 115, 88, 114, 87, 114, 88, 114, 86, 113, 86, 112, 86, 112,
85, 111, 86, 112, 85, 112, 85, 110, 85, 110, 84, 109, 83, 109, 83, 108, 83, 108,
82, 106, 82, 106, 82, 105, 81, 104, 80, 104, 80, 104, 80, 102, 79, 102, 78, 101,
78, 101, 76, 100, 76, 98, 76, 99, 74, 97, 73, 96, 73, 95, 73, 94, 72, 94, 71,
93, 71, 92, 69, 91, 70, 91, 68, 89, 68, 88, 67, 87, 66, 87, 66, 85, 64, 84, 64,
84, 63, 82, 62, 81, 61, 79, 60, 78, 59, 78, 59, 77, 57, 75, 57, 74, 55, 73, 55,
72, 54, 71, 53, 69, 53, 69, 52, 66, 52, 65, 49, 65, 49, 64, 48, 62, 47, 60, 47,
59, 45, 57, 45, 57, 42, 55, 42, 53, 42, 52, 40, 51, 40, 50, 38, 48, 37, 48, 35,
44, 35, 43, 33, 42, 33, 41, 31, 39, 30, 38, 29, 36, 28, 35, 27, 33, 25, 32, 25,
30, 24, 28, 23, 27, 21, 25, 20, 23, 19, 22, 18, 21, 17, 19, 16, 17, 14, 16, 13,
14, 11, 13, 11, 11, 10, 10, 9, 8, 8, 6, 7, 5, 5, 3, 3, 1, 3, 0, 1, -2, 0, -3,
-1, -5, -2, -7, -2, -8, -4, -10, -6, -11, -6, -13, -8, -15, -9, -16, -10, -17,
-11, -20, -13, -21, -13, -23, -14, -25, -16, -26, -18, -27, -18, -29, -19, -30,
-20, -33, -22, -34, -23, -35, -24, -37, -25, -38, -26, -39, -27, -41, -28, -42,
-30, -44, -31, -45, -32, -47, -34, -48, -34, -50, -35, -51, -36, -53, -38, -53,
-39, -55, -39, -56, -41, -58, -41, -59, -42, -61, -44, -63, -45, -63, -47, -65,
-46, -66, -48, -68, -48, -68, -50, -70, -51, -71, -52, -72, -52, -74, -54, -75,
-55, -75, -55, -77, -56, -78, -58, -79, -59, -80, -60, -81, -60, -83, -61, -84,
-62, -85, -62, -85, -63, -86, -65, -87, -65, -88, -67, -90, -67, -90, -68, -91,
-68, -92, -69, -93, -69, -94, -70, -94, -71, -96, -72, -96, -72, -98, -73, -98,
-75, -99, -74, -100, -75, -100, -76, -101, -77, -102, -77, -103, -78, -103, -78,
-103, -79, -105, -79, -105, -79, -106, -80, -107, -81, -107, -81, -107, -82,
-107, -82, -108, -82, -110, -83, -110, -83, -110, -85, -111, -85, -110, -85,
-112, -85, -112, -86, -112, -86, -112, -87, -113, -86, -114, -87, -114, -88,
-114, -88, -114, -88, -115, -89, -115, -88, -116, -89, -115, -90, -115, -90,
-116, -89, -115, -90, -117, -90, -116, -89, -117, -90, -117, -90, -118, -91,
-117, -91, -117, -91, -117, -91, -117, -90, -117, -92, -117, -92, -118, -92,
-118, -92, -117, -91, -117, -91, -117, -91, -117, -91, -117, -91, -117, -91,
-118, -91, -117, -91, -117, -91, -117, -92, -117, -91, -116, -91, -116, -91,
-116, -90, -116, -90, -116, -91, -116, -90, -116, -90, -115, -90, -116, -90,
-115, -90, -115, -90, -115, -88, -114, -88, -113, -88, -113, -88, -113, -88,
-112, -88, -113, -88, -112, -87, -112, -86, -111, -87, -112, -85, -110, -86,
-109, -85, -110, -85, -108, -84, -109, -84, -108, -84, -107, -83, -107, -83,
-106, -82, -105, -82, -105, -81, -105, -81, -104, -81, -104, -80, -102, -80,
-102, -79, -102, -78, -100, -78, -100, -77, -99, -76, -99, -76, -98, -75, -97,
-75, -97, -74, -96, -74, -94, -74, -94, -72, -93, -71, -92, -70, -91, -70, -90,
-70, -90, -68, -89, -68, -87, -67, -86, -65, -86, -65, -85, -65, -84, -63, -83,
-63, -82, -62, -80, -62, -79, -60, -79, -60, -78, -58, -76, -58, -75, -57, -74,
-56, -72, -54, -71, -53, -70, -53, -69, -52, -68, -51, -67, -51, -66, -50, -65,
-48, -64, -47, -62, -47, -61, -46, -60, -44, -59, -44, -58, -43, -56, -42, -55,
-41, -53, -40, -53, -39, -51, -38, -49, -36, -48, -35, -47, -34, -45, -34, -44,
-32, -43, -31, -41, -30, -39, -30, -38, -29, -36, -27, -36, -26, -34, -25, -33,
-24, -31, -23, -30, -22, -29, -20, -26, -19, -25, -17, -23, -16, -22, -16, -20,
-14, -20, -12, -17, -12, -16, -11, -15, -9, -13, -9, -11, -8, -9, -6, -8, -5,
-6, -4, -4, -2, -3, -1, -2, -1, 0, };