#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0174

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 51, 2, 62, 4, 57, 5, 61, 6, 59, 8,
62, 10, 61, 11, 64, 13, 61, 14, 64, 16, 63, 17, 65, 19, 65, 21, 67, 23, 66, 24,
67, 25, 67, 27, 68, 28, 70, 30, 70, 33, 70, 34, 70, 36, 71, 37, 71, 38, 72, 41,
73, 42, 73, 44, 72, 46, 74, 47, 74, 49, 75, 50, 75, 52, 76, 54, 75, 56, 76, 57,
76, 58, 77, 60, 77, 62, 77, 62, 77, 64, 77, 66, 78, 67, 78, 68, 78, 70, 78, 71,
80, 73, 79, 74, 79, 75, 80, 77, 80, 77, 79, 79, 80, 80, 80, 82, 80, 83, 80, 83,
81, 84, 80, 86, 80, 87, 81, 88, 80, 89, 80, 90, 80, 91, 80, 91, 79, 93, 80, 94,
79, 94, 80, 95, 79, 95, 79, 96, 79, 96, 79, 97, 79, 97, 79, 97, 78, 98, 78, 99,
78, 100, 79, 100, 78, 100, 77, 101, 77, 101, 77, 100, 76, 102, 77, 102, 76, 103,
75, 102, 76, 102, 75, 102, 74, 102, 74, 102, 74, 102, 74, 102, 74, 102, 73, 103,
72, 102, 72, 101, 71, 102, 71, 103, 71, 101, 70, 102, 71, 101, 69, 101, 69, 101,
69, 101, 69, 101, 69, 102, 68, 102, 69, 101, 68, 101, 67, 101, 68, 100, 67, 100,
66, 100, 66, 99, 66, 99, 66, 99, 66, 99, 65, 98, 65, 98, 64, 98, 64, 97, 64, 98,
63, 98, 63, 97, 63, 97, 63, 96, 63, 96, 63, 96, 62, 95, 62, 95, 62, 96, 61, 94,
62, 94, 61, 95, 62, 94, 61, 94, 61, 94, 60, 94, 61, 94, 61, 93, 60, 93, 61, 93,
60, 93, 60, 92, 59, 93, 59, 92, 59, 93, 59, 93, 59, 92, 59, 92, 59, 91, 58, 91,
58, 91, 58, 91, 58, 91, 58, 91, 58, 90, 58, 90, 57, 90, 58, 90, 57, 89, 57, 89,
57, 89, 57, 90, 56, 89, 56, 89, 56, 88, 55, 88, 56, 88, 56, 88, 54, 87, 54, 87,
55, 86, 55, 86, 54, 86, 54, 86, 54, 86, 52, 84, 52, 83, 52, 83, 52, 82, 51, 81,
51, 81, 49, 80, 49, 81, 48, 80, 47, 79, 47, 79, 47, 77, 46, 77, 45, 77, 45, 76,
43, 76, 42, 75, 42, 72, 41, 72, 40, 72, 39, 71, 39, 70, 37, 69, 37, 68, 36, 67,
36, 66, 33, 64, 33, 63, 33, 63, 31, 61, 30, 59, 29, 58, 29, 57, 27, 56, 25, 56,
24, 54, 24, 53, 22, 52, 22, 49, 19, 48, 18, 47, 18, 45, 17, 44, 15, 42, 14, 40,
13, 40, 11, 38, 10, 36, 10, 35, 8, 34, 6, 32, 5, 30, 4, 29, 3, 28, 1, 26, 0, 24,
-1, 23, -2, 21, -4, 19, -4, 18, -6, 17, -7, 17, -9, 15, -10, 13, -11, 12, -13,
11, -14, 10, -15, 7, -16, 5, -17, 4, -19, 3, -21, 2, -21, 0, -23, -1, -24, -2,
-25, -4, -27, -5, -28, -7, -30, -7, -29, -9, -32, -11, -33, -11, -34, -13, -35,
-13, -37, -15, -38, -16, -38, -17, -40, -19, -41, -20, -43, -21, -44, -22, -45,
-24, -46, -24, -47, -26, -48, -27, -49, -28, -51, -29, -53, -30, -53, -31, -54,
-32, -55, -33, -57, -34, -57, -35, -58, -36, -60, -38, -61, -38, -61, -39, -63,
-40, -64, -41, -66, -42, -67, -44, -67, -44, -69, -45, -69, -45, -71, -46, -71,
-47, -72, -49, -74, -49, -75, -51, -76, -51, -77, -52, -77, -53, -79, -54, -80,
-55, -81, -56, -82, -57, -83, -57, -83, -58, -85, -59, -85, -60, -87, -61, -87,
-62, -88, -62, -89, -65, -90, -66, -91, -66, -92, -67, -93, -68, -94, -69, -95,
-70, -95, -71, -96, -72, -97, -73, -98, -74, -98, -74, -99, -75, -100, -76,
-101, -77, -102, -78, -103, -79, -103, -80, -103, -82, -104, -83, -105, -84,
-105, -84, -107, -86, -108, -87, -108, -88, -109, -89, -109, -89, -109, -91,
-109, -92, -110, -92, -111, -93, -112, -94, -111, -95, -112, -96, -113, -97,
-113, -99, -114, -99, -114, -100, -114, -101, -114, -101, -115, -102, -115,
-104, -114, -105, -115, -105, -115, -106, -116, -106, -116, -107, -116, -108,
-115, -109, -117, -110, -115, -110, -116, -111, -116, -112, -116, -113, -115,
-114, -116, -114, -115, -114, -115, -115, -115, -115, -114, -116, -114, -116,
-113, -117, -113, -116, -113, -117, -113, -118, -112, -118, -111, -119, -111,
-118, -110, -118, -110, -118, -109, -119, -109, -119, -108, -118, -108, -119,
-106, -119, -106, -119, -105, -118, -103, -119, -103, -119, -102, -119, -101,
-118, -99, -119, -99, -118, -99, -118, -97, -118, -95, -117, -95, -117, -93,
-116, -93, -115, -91, -115, -89, -115, -88, -114, -87, -113, -86, -113, -84,
-112, -82, -112, -82, -111, -79, -111, -78, -110, -77, -108, -75, -108, -73,
-106, -72, -106, -70, -105, -69, -104, -67, -103, -65, -103, -64, -102, -62,
-101, -61, -100, -59, -98, -58, -98, -55, -97, -54, -96, -53, -94, -50, -94,
-49, -93, -47, -91, -45, -90, -43, -89, -42, -89, -40, -87, -38, -86, -37, -85,
-36, -84, -34, -82, -32, -82, -30, -81, -28, -79, -27, -78, -25, -77, -23, -76,
-21, -75, -19, -74, -18, -72, -17, -72, -15, -70, -14, -69, -13, -69, -11, -67,
-9, -66, -7, -65, -6, -63, -5, -64, -2, -62, -1, -61, 0, -60, 2, -60, 2, -58, 4,
-57, 5, -56, 6, -55, 8, -54, 9, -54, 10, -52, 12, -51, 13, -51, 15, -49, 16,
-48, 17, -48, 18, -46, 19, -46, 21, -45, 21, -44, 23, -42, 24, -42, 24, -41, 25,
-40, 26, -38, 27, -37, 30, -37, 30, -36, 31, -35, 32, -34, 33, -33, 34, -33, 36,
-31, 36, -31, 37, -29, 38, -27, 39, -27, 40, -25, 41, -24, 41, -23, 43, -22, 44,
-21, 44, -20, 45, -19, 45, -18, 48, -16, 48, -15, 49, -14, 48, -12, 51, -11, 50,
-10, 53, -9, 52, -8, 54, -6, 52, -4, 57, -3, 53, -1, 60, 0, 49, };