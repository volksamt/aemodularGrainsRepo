#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 12, 0, 15, 0, 14, 1, 15, 0, 15, 0,
15, 1, 15, 1, 16, 2, 15, 1, 17, 1, 15, 2, 16, 2, 16, 2, 17, 3, 16, 3, 16, 3, 18,
2, 18, 3, 18, 4, 18, 3, 18, 3, 18, 3, 18, 4, 19, 4, 18, 4, 18, 4, 19, 4, 18, 5,
19, 4, 19, 4, 19, 5, 19, 4, 19, 6, 19, 5, 18, 4, 20, 5, 19, 4, 20, 5, 20, 5, 20,
6, 20, 5, 19, 6, 20, 6, 19, 5, 20, 5, 20, 6, 20, 6, 19, 6, 20, 6, 21, 6, 20, 6,
21, 6, 20, 6, 20, 6, 20, 5, 20, 6, 19, 6, 20, 7, 20, 6, 20, 5, 20, 5, 20, 6, 20,
6, 20, 6, 20, 7, 21, 6, 20, 6, 19, 7, 19, 7, 20, 6, 19, 6, 20, 7, 19, 7, 19, 6,
19, 6, 19, 7, 19, 7, 19, 7, 19, 6, 19, 6, 19, 6, 19, 7, 19, 6, 19, 6, 18, 6, 18,
6, 18, 6, 18, 6, 19, 5, 17, 5, 17, 6, 18, 6, 17, 6, 17, 6, 18, 5, 17, 6, 17, 6,
17, 6, 16, 5, 17, 5, 16, 6, 16, 5, 16, 6, 15, 6, 15, 5, 15, 6, 15, 6, 15, 5, 16,
5, 14, 5, 14, 5, 15, 5, 15, 4, 14, 5, 14, 6, 14, 5, 14, 4, 14, 5, 14, 5, 13, 4,
13, 4, 13, 3, 12, 4, 13, 4, 12, 4, 11, 4, 12, 4, 11, 4, 11, 4, 12, 6, 14, 37,
52, 84, 103, 106, 119, 112, 113, 113, 104, 111, 98, 113, 100, 118, 111, 119,
115, 116, 113, 113, 108, 110, 109, 109, 109, 105, 106, 101, 101, 97, 98, 96, 97,
93, 98, 91, 95, 87, 92, 85, 91, 85, 91, 83, 91, 81, 89, 80, 87, 78, 87, 77, 88,
78, 88, 77, 88, 76, 87, 76, 87, 76, 87, 76, 86, 75, 86, 76, 87, 77, 87, 77, 88,
77, 88, 78, 88, 79, 88, 80, 89, 81, 89, 81, 90, 81, 90, 83, 91, 84, 91, 85, 92,
86, 91, 86, 91, 86, 91, 88, 92, 89, 92, 90, 92, 91, 93, 92, 93, 92, 94, 93, 94,
93, 93, 94, 93, 95, 93, 95, 94, 96, 93, 96, 94, 97, 93, 98, 93, 98, 94, 98, 93,
99, 93, 99, 92, 100, 93, 99, 92, 100, 92, 100, 92, 101, 92, 100, 92, 99, 88, 71,
52, 20, -4, -7, -23, -15, -18, -17, -8, -14, 0, -16, -6, -23, -18, -25, -23,
-21, -21, -15, -17, -14, -16, -12, -20, -9, -16, -2, -12, 2, -9, 3, -10, 5, -11,
8, -9, 12, -6, 14, -5, 13, -7, 14, -7, 16, -7, 19, -6, 18, -7, 18, -8, 18, -10,
17, -10, 17, -10, 17, -11, 16, -13, 16, -14, 15, -15, 14, -16, 13, -18, 11, -19,
10, -21, 9, -21, 6, -23, 5, -25, 3, -25, 1, -27, -1, -29, -2, -30, -4, -32, -6,
-33, -8, -35, -10, -36, -12, -37, -13, -38, -16, -40, -18, -42, -18, -42, -21,
-43, -23, -45, -25, -46, -27, -47, -27, -47, -29, -50, -31, -50, -33, -51, -34,
-52, -35, -53, -37, -55, -38, -55, -39, -57, -40, -57, -42, -57, -42, -58, -44,
-59, -45, -59, -45, -61, -46, -61, -47, -63, -48, -63, -50, -63, -51, -63, -51,
-63, -52, -64, -52, -65, -53, -65, -53, -66, -54, -66, -54, -66, -55, -66, -56,
-66, -56, -67, -56, -67, -57, -67, -57, -66, -57, -67, -58, -67, -58, -67, -58,
-67, -58, -67, -58, -68, -59, -67, -60, -67, -59, -67, -59, -67, -59, -67, -60,
-67, -59, -67, -59, -66, -59, -67, -59, -67, -59, -68, -59, -67, -59, -66, -60,
-66, -59, -65, -58, -66, -59, -65, -59, -65, -58, -64, -58, -65, -58, -65, -58,
-63, -57, -63, -57, -64, -58, -63, -57, -63, -57, -63, -57, -63, -57, -62, -56,
-62, -56, -61, -56, -61, -56, -61, -55, -60, -55, -60, -54, -59, -55, -59, -54,
-59, -54, -57, -53, -58, -53, -58, -52, -56, -53, -57, -52, -56, -51, -55, -52,
-56, -51, -55, -51, -55, -51, -54, -50, -54, -50, -54, -50, -53, -49, -52, -48,
-52, -49, -52, -48, -51, -48, -51, -48, -50, -47, -51, -47, -49, -46, -49, -46,
-48, -46, -48, -45, -47, -45, -47, -45, -46, -44, -46, -44, -46, -44, -45, -44,
-44, -43, -44, -42, -44, -42, -43, -42, -43, -41, -43, -40, -41, -41, -40, -41,
-41, -40, -40, -40, -40, -40, -39, -39, -39, -39, -38, -39, -38, -38, -38, -38,
-37, -37, -37, -37, -36, -36, -35, -36, -35, -35, -34, -36, -33, -35, -33, -35,
-33, -34, -32, -34, -32, -33, -30, -33, -31, -32, -30, -33, -29, -32, -30, -31,
-29, -31, -27, -31, -28, -30, -27, -30, -26, -30, -26, -29, -26, -29, -26, -29,
-24, -29, -25, -28, -23, -27, -24, -27, -22, -27, -22, -26, -22, -26, -21, -26,
-20, -25, -20, -24, -20, -24, -19, -24, -19, -24, -17, -23, -18, -23, -17, -22,
-16, -22, -16, -23, -16, -22, -15, -22, -15, -21, -15, -21, -13, -20, -13, -19,
-12, -20, -12, -19, -13, -19, -11, -19, -12, -18, -10, -19, -11, -17, -10, -17,
-9, -16, -9, -16, -8, -16, -9, -15, -7, -16, -7, -16, -7, -14, -6, -16, -5, -15,
-5, -14, -5, -14, -5, -14, -4, -14, -3, -13, -3, -12, -3, -13, -3, -12, -2, -11,
-2, -12, -1, -11, 0, -10, 0, -10, 0, -10, 0, -10, 2, -9, 2, -9, 1, -9, 2, -9, 3,
-9, 2, -8, 4, -8, 3, -7, 4, -8, 4, -8, 4, -7, 4, -7, 5, -6, 5, -6, 5, -5, 7, -6,
7, -5, 6, -5, 7, -5, 8, -5, 8, -5, 9, -5, 9, -4, 9, -4, 8, -3, 9, -3, 10, -2,
10, -4, 9, -3, 10, -2, 11, -2, 11, -2, 11, -2, 11, -2, 11, -2, 12, -2, 11, -1,
13, -1, 13, 0, 13, -1, 12, 0, 14, 0, 12, };