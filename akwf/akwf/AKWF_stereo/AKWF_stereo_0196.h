#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0196

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 0, 5, 3, 8, 8, 12, 11, 15, 15, 19,
17, 22, 21, 24, 24, 27, 27, 30, 29, 32, 32, 34, 35, 38, 37, 40, 40, 41, 42, 43,
45, 46, 47, 47, 49, 49, 50, 51, 53, 52, 55, 53, 56, 55, 58, 57, 59, 58, 61, 61,
63, 62, 64, 64, 66, 65, 67, 67, 69, 69, 71, 70, 72, 72, 74, 74, 76, 75, 77, 76,
78, 79, 79, 80, 80, 82, 82, 83, 83, 84, 84, 86, 86, 86, 87, 88, 87, 89, 89, 90,
89, 91, 90, 91, 91, 93, 91, 92, 92, 93, 92, 93, 93, 93, 92, 94, 93, 94, 92, 94,
92, 93, 92, 93, 92, 93, 92, 93, 92, 92, 92, 92, 92, 92, 91, 92, 90, 91, 91, 90,
90, 90, 89, 90, 89, 90, 89, 89, 88, 89, 87, 88, 87, 89, 87, 89, 86, 89, 86, 89,
86, 89, 86, 89, 85, 89, 85, 89, 85, 90, 85, 89, 85, 89, 84, 89, 83, 90, 83, 91,
84, 91, 82, 90, 83, 91, 82, 90, 82, 90, 81, 90, 81, 89, 81, 89, 80, 89, 79, 89,
79, 88, 79, 88, 78, 87, 77, 87, 77, 87, 76, 85, 75, 85, 75, 84, 74, 84, 73, 83,
73, 82, 72, 82, 72, 81, 72, 80, 71, 80, 71, 80, 69, 79, 68, 79, 67, 78, 67, 77,
67, 77, 66, 78, 66, 78, 66, 78, 66, 77, 66, 76, 65, 77, 64, 76, 64, 76, 62, 76,
62, 76, 62, 75, 61, 76, 62, 76, 62, 75, 61, 75, 61, 75, 61, 75, 60, 75, 60, 74,
59, 73, 58, 73, 58, 73, 58, 72, 57, 73, 57, 72, 57, 72, 56, 72, 56, 71, 56, 71,
56, 71, 55, 71, 56, 71, 56, 71, 56, 71, 55, 72, 56, 72, 55, 72, 56, 73, 55, 73,
56, 75, 56, 75, 56, 75, 56, 76, 55, 77, 56, 77, 57, 77, 56, 78, 56, 79, 56, 80,
56, 80, 55, 81, 55, 82, 55, 82, 55, 83, 54, 83, 54, 83, 53, 83, 52, 83, 51, 84,
51, 84, 50, 83, 49, 83, 48, 83, 47, 82, 46, 82, 45, 81, 43, 81, 42, 80, 41, 79,
40, 80, 39, 78, 37, 79, 36, 77, 35, 76, 35, 76, 33, 75, 32, 74, 31, 74, 30, 73,
30, 73, 30, 73, 28, 72, 28, 72, 27, 71, 27, 71, 26, 71, 26, 71, 25, 70, 24, 70,
24, 69, 24, 69, 24, 69, 24, 69, 23, 68, 23, 67, 23, 67, 22, 66, 22, 65, 22, 65,
21, 63, 21, 63, 21, 61, 21, 60, 20, 58, 20, 57, 19, 55, 18, 54, 18, 52, 17, 51,
18, 50, 18, 47, 17, 45, 16, 44, 16, 43, 16, 41, 16, 40, 15, 39, 16, 38, 16, 36,
16, 35, 16, 34, 17, 33, 16, 33, 17, 31, 17, 31, 18, 30, 18, 30, 20, 28, 21, 28,
21, 28, 22, 27, 24, 27, 24, 28, 24, 27, 25, 27, 27, 27, 27, 27, 27, 26, 28, 26,
29, 25, 30, 25, 30, 24, 31, 24, 31, 24, 31, 23, 31, 22, 32, 21, 31, 19, 30, 18,
30, 17, 29, 15, 28, 15, 28, 13, 27, 12, 26, 9, 24, 8, 23, 6, 23, 5, 21, 2, 20,
2, 18, -1, 17, -2, 16, -3, 15, -4, 13, -6, 12, -8, 11, -8, 9, -10, 8, -11, 6,
-12, 6, -13, 3, -15, 2, -15, 1, -16, 0, -17, -1, -18, -2, -18, -4, -19, -5, -20,
-6, -20, -8, -22, -9, -22, -10, -24, -12, -24, -13, -25, -15, -27, -15, -28,
-17, -30, -18, -29, -20, -31, -22, -33, -23, -34, -24, -36, -26, -37, -28, -39,
-29, -41, -31, -43, -32, -44, -34, -46, -35, -48, -37, -49, -39, -51, -41, -52,
-42, -53, -45, -54, -45, -56, -47, -58, -48, -58, -49, -60, -51, -61, -52, -62,
-53, -63, -53, -63, -55, -63, -55, -64, -57, -64, -57, -65, -57, -65, -57, -66,
-58, -66, -59, -66, -59, -66, -60, -66, -59, -66, -59, -68, -59, -67, -60, -67,
-60, -67, -60, -68, -61, -69, -61, -69, -61, -70, -61, -70, -62, -71, -61, -72,
-61, -72, -61, -73, -61, -73, -62, -74, -61, -76, -62, -76, -63, -76, -62, -78,
-62, -79, -62, -80, -62, -81, -62, -81, -63, -83, -63, -84, -63, -84, -63, -84,
-63, -86, -64, -85, -63, -87, -64, -88, -64, -88, -64, -89, -64, -90, -63, -90,
-63, -90, -63, -92, -64, -91, -64, -92, -63, -92, -64, -93, -64, -93, -63, -94,
-64, -95, -63, -96, -63, -95, -63, -97, -64, -97, -64, -99, -65, -100, -64,
-101, -64, -101, -66, -103, -65, -103, -65, -103, -66, -105, -65, -105, -67,
-106, -67, -107, -67, -107, -67, -109, -67, -108, -68, -109, -68, -110, -68,
-110, -69, -111, -68, -112, -69, -112, -69, -113, -69, -113, -70, -113, -70,
-112, -70, -113, -71, -113, -71, -113, -71, -113, -72, -113, -72, -113, -72,
-112, -73, -113, -73, -113, -73, -112, -75, -112, -76, -113, -77, -113, -77,
-113, -79, -113, -80, -113, -81, -113, -82, -113, -82, -114, -84, -114, -86,
-114, -87, -114, -88, -114, -90, -115, -91, -115, -93, -116, -95, -117, -96,
-116, -98, -117, -99, -117, -100, -118, -102, -119, -103, -119, -104, -119,
-105, -119, -107, -119, -107, -119, -108, -119, -110, -118, -110, -118, -110,
-117, -111, -117, -111, -117, -111, -116, -112, -116, -112, -114, -112, -114,
-112, -112, -112, -112, -112, -111, -111, -109, -112, -109, -110, -107, -111,
-107, -110, -105, -109, -105, -109, -103, -109, -102, -107, -100, -107, -99,
-106, -98, -105, -97, -105, -96, -103, -96, -103, -94, -102, -93, -100, -92,
-99, -90, -98, -90, -97, -88, -96, -87, -95, -86, -93, -83, -92, -83, -89, -81,
-87, -80, -84, -77, -83, -75, -81, -72, -78, -71, -76, -68, -73, -66, -70, -62,
-66, -59, -63, -56, -60, -53, -55, -49, -53, -45, -48, -42, -44, -38, -40, -34,
-36, -30, -33, -27, -27, -21, -23, -17, -20, -13, -15, -10, -12, -6, -8, -2, -4,
};