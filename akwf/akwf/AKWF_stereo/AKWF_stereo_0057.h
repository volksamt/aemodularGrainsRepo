#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0057

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 0, 0, 1, 0, 2, 1, 2, 0, 2, 0,
3, 1, 3, 1, 3, 1, 3, 2, 4, 1, 5, 1, 5, 2, 5, 2, 5, 2, 6, 2, 7, 2, 7, 3, 7, 2, 7,
3, 7, 2, 8, 3, 9, 3, 9, 3, 9, 3, 10, 3, 10, 4, 11, 3, 11, 4, 11, 3, 12, 5, 12,
5, 13, 5, 12, 5, 13, 5, 14, 5, 14, 5, 15, 6, 15, 5, 15, 5, 16, 5, 16, 6, 16, 5,
17, 6, 18, 5, 18, 6, 18, 6, 18, 7, 19, 6, 19, 7, 20, 7, 20, 7, 20, 7, 22, 7, 21,
8, 22, 7, 23, 9, 23, 8, 23, 7, 23, 8, 24, 8, 25, 9, 25, 8, 25, 9, 25, 9, 25, 9,
27, 10, 27, 10, 27, 9, 27, 9, 28, 10, 29, 10, 28, 11, 30, 10, 30, 11, 30, 11,
31, 11, 31, 11, 31, 11, 32, 12, 33, 12, 33, 12, 33, 12, 34, 13, 34, 12, 35, 14,
34, 13, 35, 14, 36, 14, 37, 13, 37, 14, 38, 14, 38, 14, 38, 14, 39, 15, 39, 15,
39, 15, 39, 15, 41, 15, 42, 16, 41, 15, 42, 17, 42, 16, 43, 17, 44, 16, 44, 17,
44, 17, 44, 18, 46, 18, 46, 18, 46, 18, 47, 18, 48, 19, 48, 19, 48, 20, 49, 20,
49, 19, 50, 20, 50, 20, 51, 21, 52, 21, 52, 21, 53, 22, 53, 22, 53, 22, 53, 22,
55, 22, 56, 23, 55, 24, 56, 24, 56, 23, 57, 24, 58, 25, 59, 24, 58, 25, 59, 25,
61, 26, 60, 26, 61, 26, 62, 27, 62, 28, 62, 27, 63, 28, 64, 28, 64, 28, 65, 29,
66, 29, 65, 29, 66, 30, 67, 30, 67, 30, 68, 30, 68, 31, 69, 33, 70, 31, 70, 33,
71, 33, 72, 32, 72, 34, 72, 34, 73, 35, 74, 34, 74, 35, 75, 36, 75, 37, 76, 37,
76, 38, 77, 37, 77, 38, 78, 39, 79, 40, 79, 39, 79, 40, 80, 40, 81, 40, 81, 42,
81, 42, 82, 42, 83, 42, 83, 43, 84, 44, 84, 44, 85, 45, 86, 45, 86, 46, 87, 47,
88, 47, 88, 47, 88, 49, 89, 49, 89, 50, 90, 50, 90, 50, 90, 51, 91, 52, 92, 53,
92, 54, 92, 54, 94, 55, 94, 55, 94, 56, 95, 55, 95, 56, 96, 57, 97, 58, 96, 59,
97, 59, 97, 61, 98, 61, 98, 62, 99, 63, 100, 63, 100, 64, 101, 64, 101, 66, 101,
65, 101, 67, 102, 68, 102, 69, 103, 68, 104, 70, 104, 70, 105, 71, 104, 72, 105,
73, 105, 73, 105, 75, 106, 76, 106, 76, 107, 77, 108, 77, 107, 79, 108, 79, 108,
81, 110, 81, 109, 83, 110, 82, 109, 84, 111, 85, 110, 86, 111, 87, 112, 88, 111,
88, 113, 90, 112, 92, 113, 92, 113, 94, 115, 93, 113, 96, 115, 95, 114, 99, 117,
96, 113, 101, 117, 98, 113, 104, 118, 100, 114, 106, 120, 101, 113, 108, 121,
104, 114, 110, 121, 106, 114, 112, 121, 109, 115, 114, 121, 113, 118, -74, -94,
-96, -121, -82, -105, -92, -117, -81, -106, -88, -116, -81, -106, -87, -114,
-80, -106, -84, -112, -78, -106, -82, -111, -77, -106, -80, -110, -75, -105,
-77, -109, -74, -106, -74, -107, -73, -105, -73, -106, -73, -104, -72, -104,
-71, -105, -69, -104, -69, -103, -68, -102, -68, -103, -66, -101, -67, -102,
-65, -101, -65, -101, -64, -100, -63, -100, -61, -99, -62, -99, -61, -98, -61,
-98, -60, -97, -59, -98, -58, -96, -57, -95, -56, -96, -56, -96, -56, -94, -55,
-94, -53, -94, -55, -94, -53, -93, -53, -93, -52, -92, -52, -91, -50, -90, -50,
-91, -49, -89, -49, -88, -48, -89, -47, -87, -47, -87, -47, -87, -45, -86, -45,
-85, -46, -85, -44, -85, -44, -84, -44, -84, -43, -84, -42, -83, -42, -82, -41,
-82, -41, -81, -41, -80, -40, -80, -40, -80, -39, -80, -39, -79, -38, -77, -38,
-77, -37, -77, -37, -76, -37, -75, -36, -75, -35, -74, -35, -74, -34, -73, -34,
-73, -34, -72, -33, -72, -34, -71, -33, -71, -31, -70, -32, -69, -31, -69, -31,
-69, -30, -68, -31, -68, -29, -67, -30, -66, -29, -65, -28, -66, -28, -65, -27,
-64, -28, -64, -26, -62, -27, -63, -26, -62, -26, -62, -26, -61, -26, -60, -25,
-60, -25, -59, -24, -58, -25, -59, -24, -58, -23, -58, -23, -57, -23, -56, -23,
-56, -23, -55, -22, -54, -22, -54, -22, -53, -22, -54, -21, -52, -21, -52, -20,
-52, -21, -50, -20, -50, -19, -49, -19, -50, -19, -49, -20, -48, -18, -49, -18,
-47, -18, -46, -18, -46, -18, -46, -17, -45, -17, -45, -17, -45, -17, -45, -17,
-44, -17, -43, -15, -42, -15, -41, -16, -41, -15, -41, -15, -40, -15, -40, -15,
-40, -15, -39, -14, -38, -14, -38, -14, -38, -13, -37, -13, -36, -14, -37, -13,
-36, -13, -35, -13, -35, -13, -34, -12, -34, -12, -33, -11, -34, -12, -32, -12,
-33, -12, -32, -11, -32, -11, -32, -11, -31, -10, -31, -11, -29, -11, -29, -10,
-30, -10, -29, -10, -27, -10, -27, -10, -27, -9, -26, -9, -27, -8, -25, -9, -26,
-9, -25, -9, -25, -8, -25, -9, -24, -9, -24, -8, -23, -8, -22, -8, -22, -8, -22,
-7, -21, -7, -21, -7, -20, -7, -20, -7, -19, -7, -19, -7, -18, -6, -19, -6, -18,
-6, -18, -6, -17, -6, -17, -6, -17, -6, -17, -6, -16, -5, -16, -5, -14, -5, -14,
-5, -15, -5, -14, -5, -14, -5, -13, -4, -12, -4, -12, -4, -12, -3, -11, -3, -12,
-4, -11, -4, -10, -4, -10, -3, -9, -3, -9, -2, -9, -3, -8, -3, -9, -3, -8, -3,
-7, -2, -8, -2, -7, -2, -7, -2, -6, -1, -5, -2, -5, -1, -4, -1, -4, -1, -3, -2,
-4, 0, -3, 0, -2, -1, -1, -1, -1, 0, -1, 0, -1, 0, 0, 0, 0, };