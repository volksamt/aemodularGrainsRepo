#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0034

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 46, 10, 50, 16, 41, 22, 41, 29, 35,
34, 34, 39, 29, 45, 28, 50, 24, 55, 25, 59, 23, 63, 25, 67, 24, 70, 26, 73, 27,
76, 29, 79, 31, 81, 34, 83, 36, 85, 40, 86, 41, 87, 44, 89, 47, 89, 48, 90, 50,
90, 52, 89, 52, 89, 51, 89, 50, 88, 48, 87, 45, 86, 41, 85, 38, 84, 32, 83, 26,
82, 20, 80, 14, 79, 7, 78, 0, 77, -8, 76, -15, 74, -22, 74, -27, 73, -34, 73,
-40, 73, -44, 73, -49, 73, -54, 73, -58, 73, -62, 72, -66, 74, -68, 74, -71, 75,
-73, 76, -76, 76, -78, 78, -80, 78, -81, 80, -83, 81, -85, 81, -85, 83, -87, 84,
-88, 85, -89, 86, -90, 87, -91, 88, -93, 89, -93, 90, -95, 91, -95, 92, -96, 92,
-97, 93, -98, 94, -98, 95, -99, 94, -99, 95, -100, 95, -99, 96, -98, 96, -97,
95, -94, 96, -92, 95, -90, 95, -87, 96, -82, 95, -77, 95, -72, 93, -67, 94, -61,
94, -55, 92, -47, 92, -40, 90, -33, 90, -27, 88, -19, 86, -12, 84, -4, 84, 2,
82, 8, 80, 15, 79, 22, 76, 28, 75, 34, 74, 41, 73, 47, 71, 54, 71, 60, 69, 64,
68, 69, 67, 74, 66, 79, 65, 83, 64, 85, 65, 88, 64, 90, 65, 91, 65, 92, 65, 92,
65, 91, 67, 90, 68, 89, 70, 87, 70, 84, 71, 81, 72, 79, 73, 75, 76, 71, 77, 69,
78, 66, 78, 63, 80, 60, 82, 57, 83, 55, 83, 53, 85, 52, 86, 52, 86, 52, 86, 52,
88, 54, 88, 56, 88, 57, 89, 60, 89, 63, 89, 67, 89, 72, 90, 76, 90, 81, 91, 86,
90, 90, 90, 94, 90, 100, 91, 104, 90, 108, 91, 112, 90, 114, 91, 116, 91, 118,
91, 119, 90, 118, 89, 118, 89, 116, 90, 113, 89, 111, 89, 106, 89, 103, 89, 98,
90, 94, 90, 90, 91, 85, 91, 81, 91, 76, 92, 73, 93, 68, 93, 64, 93, 62, 93, 58,
93, 56, 93, 53, 94, 50, 95, 48, 94, 45, 93, 43, 93, 40, 92, 39, 91, 35, 89, 33,
88, 31, 87, 27, 85, 24, 82, 21, 80, 18, 77, 14, 73, 11, 71, 7, 66, 3, 63, -1,
58, -5, 53, -10, 49, -15, 44, -20, 38, -24, 33, -29, 27, -34, 21, -38, 15, -43,
9, -46, 3, -50, -3, -53, -9, -56, -15, -58, -21, -60, -27, -62, -32, -62, -38,
-62, -42, -61, -47, -61, -53, -61, -58, -58, -62, -57, -67, -55, -72, -52, -76,
-51, -81, -48, -85, -47, -89, -45, -92, -43, -96, -42, -99, -40, -101, -38,
-104, -37, -105, -35, -108, -34, -108, -31, -110, -30, -110, -29, -109, -28,
-109, -27, -109, -27, -107, -26, -107, -27, -105, -27, -103, -27, -100, -30,
-98, -32, -95, -34, -92, -36, -89, -40, -84, -43, -81, -47, -77, -51, -72, -55,
-67, -60, -63, -64, -58, -68, -53, -72, -50, -76, -45, -81, -41, -84, -36, -88,
-32, -90, -30, -91, -26, -94, -22, -93, -20, -95, -17, -94, -14, -92, -12, -91,
-10, -89, -8, -86, -6, -82, -6, -78, -5, -74, -5, -69, -4, -64, -4, -57, -4,
-51, -5, -47, -5, -42, -6, -35, -7, -30, -9, -25, -11, -22, -11, -18, -13, -16,
-16, -14, -19, -12, -21, -11, -23, -13, -25, -12, -29, -14, -32, -17, -34, -20,
-37, -23, -39, -26, -42, -30, -44, -34, -47, -36, -49, -40, -51, -43, -52, -46,
-54, -49, -56, -51, -56, -53, -58, -55, -59, -56, -59, -58, -60, -58, -61, -58,
-60, -59, -61, -60, -61, -59, -61, -60, -61, -61, -61, -61, -60, -60, -60, -60,
-59, -60, -58, -60, -59, -60, -59, -62, -57, -62, -57, -62, -57, -63, -56, -63,
-55, -64, -54, -66, -56, -66, -54, -68, -55, -69, -55, -70, -54, -71, -54, -73,
-54, -73, -53, -73, -53, -75, -53, -74, -53, -74, -53, -73, -53, -72, -53, -69,
-53, -67, -54, -66, -53, -62, -54, -59, -55, -54, -55, -50, -55, -46, -56, -41,
-57, -36, -57, -32, -59, -27, -61, -22, -61, -18, -63, -15, -64, -11, -65, -7,
-66, -3, -67, 1, -68, 4, -70, 7, -70, 11, -71, 14, -73, 18, -74, 20, -74, 22,
-74, 25, -75, 25, -74, 27, -74, 27, -75, 27, -75, 28, -74, 26, -73, 24, -72, 22,
-70, 19, -69, 17, -68, 12, -67, 8, -64, 5, -63, 0, -62, -4, -60, -9, -58, -13,
-56, -18, -54, -22, -53, -26, -50, -30, -49, -34, -47, -36, -45, -38, -44, -39,
-42, -41, -41, -40, -40, -40, -39, -40, -38, -38, -37, -36, -37, -33, -35, -29,
-35, -25, -34, -20, -33, -16, -32, -10, -32, -4, -31, 0, -30, 7, -30, 12, -29,
17, -29, 22, -29, 27, -28, 31, -27, 33, -26, 37, -26, 39, -26, 40, -26, 40, -25,
41, -25, 40, -24, 38, -24, 37, -23, 34, -21, 32, -20, 31, -20, 28, -19, 26, -18,
24, -16, 22, -15, 20, -14, 20, -13, 18, -12, 18, -10, 17, -10, 17, -9, 16, -7,
18, -7, 18, -5, 17, -5, 19, -6, 19, -5, 20, -5, 20, -5, 21, -5, 20, -5, 22, -6,
22, -8, 22, -9, 22, -11, 21, -13, 21, -15, 19, -17, 18, -20, 18, -23, 16, -26,
15, -29, 13, -33, 13, -37, 11, -40, 8, -45, 8, -48, 7, -53, 5, -56, 4, -60, 4,
-65, 3, -69, 4, -73, 4, -77, 6, -82, 6, -85, 9, -88, 12, -91, 15, -95, 18, -99,
22, -101, 26, -104, 30, -106, 35, -109, 39, -111, 44, -113, 47, -115, 53, -117,
56, -117, 61, -118, 65, -119, 69, -118, 72, -118, 76, -118, 80, -117, 84, -117,
87, -114, 90, -112, 94, -111, 96, -107, 99, -104, 101, -101, 103, -97, 103, -93,
105, -89, 104, -84, 105, -78, 102, -73, 102, -67, 98, -61, 97, -55, 92, -49, 91,
-42, 84, -35, 83, -29, 75, -22, 73, -15, 63, -8, 65, -2, 48, };