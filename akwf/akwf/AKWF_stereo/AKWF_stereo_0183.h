#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0183

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 36, 2, 43, 3, 39, 4, 42, 5, 37, 6,
39, 7, 38, 8, 38, 9, 36, 11, 36, 11, 34, 13, 35, 13, 33, 15, 32, 16, 31, 16, 31,
17, 30, 18, 29, 19, 28, 19, 27, 19, 27, 21, 25, 20, 24, 21, 23, 23, 22, 23, 21,
23, 20, 23, 19, 24, 18, 24, 17, 24, 16, 24, 14, 25, 13, 24, 12, 24, 12, 25, 10,
25, 10, 25, 9, 24, 8, 24, 8, 24, 7, 25, 5, 24, 6, 24, 5, 24, 4, 23, 3, 22, 3,
22, 2, 22, 2, 22, 2, 21, 1, 21, 1, 20, 0, 19, 0, 20, 0, 19, 0, 19, -1, 17, -2,
18, -2, 16, -2, 16, -3, 15, -3, 14, -3, 14, -4, 13, -5, 14, -6, 13, -6, 12, -7,
13, -8, 12, -8, 11, -10, 10, -11, 10, -11, 10, -12, 10, -12, 9, -13, 10, -14,
10, -14, 10, -16, 10, -16, 11, -17, 11, -17, 11, -18, 13, -18, 13, -18, 13, -19,
15, -18, 15, -19, 16, -19, 17, -20, 19, -19, 20, -20, 20, -20, 22, -20, 22, -20,
24, -20, 26, -19, 26, -19, 27, -20, 29, -19, 30, -19, 30, -19, 32, -19, 32, -20,
33, -19, 34, -19, 34, -19, 35, -19, 35, -20, 36, -20, 35, -21, 36, -21, 36, -21,
36, -21, 35, -22, 36, -22, 35, -22, 34, -23, 34, -24, 34, -24, 33, -24, 33, -25,
31, -24, 30, -24, 30, -25, 29, -26, 28, -25, 27, -25, 26, -26, 25, -26, 26, -26,
25, -27, 23, -26, 23, -25, 21, -26, 21, -25, 20, -25, 19, -25, 19, -25, 18, -24,
18, -24, 18, -23, 17, -22, 17, -22, 17, -21, 17, -20, 17, -21, 17, -19, 17, -18,
17, -18, 18, -16, 18, -16, 18, -15, 20, -13, 20, -12, 21, -10, 21, -9, 22, -8,
23, -7, 24, -5, 25, -5, 25, -3, 27, -2, 28, 0, 29, 1, 30, 2, 32, 4, 32, 5, 34,
7, 35, 8, 36, 10, 37, 11, 38, 13, 39, 14, 40, 16, 42, 17, 42, 19, 44, 20, 45,
21, 46, 23, 46, 24, 47, 25, 48, 27, 50, 29, 50, 30, 51, 31, 52, 33, 53, 35, 53,
35, 55, 38, 55, 40, 56, 41, 57, 43, 59, 44, 60, 46, 61, 48, 62, 51, 63, 53, 64,
54, 66, 56, 66, 59, 67, 61, 69, 64, 69, 66, 71, 68, 72, 70, 73, 73, 75, 75, 75,
78, 77, 81, 77, 83, 79, 86, 80, 87, 82, 89, 82, 92, 83, 93, 84, 97, 85, 99, 86,
100, 87, 102, 88, 104, 89, 105, 89, 108, 90, 109, 91, 111, 92, 112, 92, 113, 93,
114, 94, 115, 94, 116, 94, 116, 94, 117, 96, 118, 96, 118, 95, 118, 96, 119, 97,
118, 97, 119, 97, 120, 97, 119, 97, 119, 97, 118, 97, 117, 97, 117, 96, 117, 95,
115, 95, 115, 94, 113, 93, 113, 92, 110, 91, 109, 90, 107, 87, 105, 85, 103, 84,
101, 82, 98, 79, 95, 76, 91, 74, 89, 70, 85, 67, 81, 63, 78, 59, 74, 54, 69, 50,
65, 46, 60, 40, 56, 36, 51, 32, 46, 26, 41, 21, 37, 16, 32, 10, 28, 7, 23, 2,
18, -4, 15, -7, 11, -11, 5, -16, 2, -19, -2, -23, -6, -26, -10, -29, -12, -32,
-15, -35, -19, -37, -21, -38, -23, -41, -26, -42, -27, -44, -30, -44, -32, -46,
-33, -47, -35, -47, -37, -48, -37, -49, -39, -49, -41, -49, -43, -49, -43, -49,
-44, -49, -45, -49, -45, -49, -46, -49, -46, -48, -48, -48, -48, -48, -49, -48,
-49, -47, -50, -47, -49, -46, -51, -46, -51, -45, -51, -45, -51, -45, -51, -44,
-51, -44, -52, -43, -51, -43, -52, -42, -51, -42, -52, -41, -52, -41, -52, -40,
-52, -39, -52, -39, -52, -39, -52, -39, -51, -38, -51, -37, -52, -38, -52, -37,
-51, -37, -52, -36, -51, -35, -52, -36, -52, -34, -51, -34, -51, -34, -51, -34,
-51, -33, -51, -32, -51, -32, -51, -32, -50, -31, -51, -30, -50, -29, -49, -29,
-49, -28, -48, -28, -48, -26, -48, -26, -47, -24, -46, -23, -46, -23, -46, -21,
-45, -20, -45, -19, -45, -18, -44, -16, -42, -16, -42, -15, -41, -14, -41, -12,
-39, -10, -39, -9, -39, -8, -38, -8, -37, -7, -36, -5, -35, -4, -35, -3, -34,
-3, -34, -3, -32, -1, -32, 0, -31, 0, -30, 0, -31, 1, -29, 1, -29, 2, -29, 1,
-28, 2, -28, 2, -28, 2, -28, 1, -26, 1, -28, 1, -27, 1, -27, 0, -27, 0, -28, -2,
-28, -3, -27, -4, -28, -5, -27, -5, -29, -7, -29, -8, -29, -11, -29, -13, -30,
-14, -30, -16, -30, -18, -32, -20, -33, -22, -34, -24, -34, -26, -35, -29, -37,
-33, -37, -35, -39, -37, -41, -40, -41, -43, -44, -46, -45, -49, -47, -53, -47,
-55, -49, -58, -51, -62, -53, -66, -55, -68, -56, -71, -59, -75, -61, -77, -62,
-80, -63, -85, -65, -87, -67, -90, -69, -93, -71, -96, -71, -98, -73, -100, -74,
-103, -75, -104, -75, -107, -77, -108, -77, -110, -77, -112, -77, -113, -77,
-114, -77, -115, -76, -116, -76, -117, -75, -117, -75, -117, -73, -117, -73,
-117, -71, -116, -70, -116, -70, -116, -67, -116, -66, -115, -64, -113, -63,
-114, -60, -112, -58, -111, -57, -110, -54, -108, -52, -106, -50, -104, -48,
-102, -45, -101, -44, -100, -41, -97, -38, -95, -36, -93, -33, -91, -31, -89,
-28, -86, -25, -84, -22, -81, -20, -77, -17, -74, -14, -72, -12, -69, -9, -66,
-6, -64, -4, -61, -1, -59, 2, -55, 4, -54, 6, -51, 8, -48, 11, -46, 13, -42, 15,
-41, 18, -38, 20, -36, 22, -35, 23, -33, 25, -31, 27, -28, 29, -26, 30, -24, 31,
-24, 33, -22, 34, -20, 36, -19, 36, -18, 38, -16, 38, -14, 40, -12, 39, -11, 41,
-10, 40, -8, 41, -8, 40, -7, 42, -6, 40, -4, 43, -2, 40, -1, 44, -1, 35, };