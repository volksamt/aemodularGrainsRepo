#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0114

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -2, 2, -4, 3, -6, 4, -9, 6, -11, 7,
-14, 9, -17, 11, -20, 12, -22, 13, -25, 14, -27, 16, -30, 17, -33, 19, -35, 21,
-37, 22, -40, 23, -42, 24, -45, 26, -47, 28, -49, 29, -52, 30, -53, 32, -55, 33,
-57, 35, -58, 36, -59, 37, -61, 38, -63, 40, -65, 42, -64, 42, -66, 44, -68, 45,
-68, 46, -68, 47, -70, 49, -69, 50, -70, 51, -70, 52, -69, 53, -69, 55, -69, 55,
-70, 57, -69, 57, -67, 58, -67, 58, -66, 60, -65, 62, -65, 61, -64, 62, -63, 64,
-62, 65, -61, 65, -60, 66, -58, 67, -56, 68, -55, 68, -54, 69, -52, 70, -50, 70,
-49, 72, -46, 72, -44, 73, -43, 73, -40, 73, -38, 74, -36, 75, -33, 77, -31, 77,
-29, 77, -25, 78, -23, 79, -20, 80, -18, 81, -14, 81, -11, 81, -8, 83, -6, 83,
-3, 84, 0, 84, 4, 85, 8, 86, 10, 87, 14, 87, 18, 86, 21, 88, 25, 89, 27, 89, 32,
90, 35, 90, 40, 90, 43, 91, 47, 92, 49, 93, 54, 94, 57, 94, 60, 95, 64, 96, 66,
97, 70, 97, 73, 98, 76, 100, 80, 100, 83, 101, 85, 101, 88, 102, 91, 103, 93,
104, 95, 104, 97, 106, 98, 107, 101, 107, 103, 107, 104, 109, 106, 109, 107,
110, 109, 112, 110, 112, 111, 113, 113, 113, 114, 114, 115, 114, 117, 115, 118,
116, 118, 116, 119, 117, 119, 117, 119, 117, 119, 117, 119, 117, 119, 118, 118,
118, 118, 118, 118, 118, 117, 117, 115, 117, 114, 117, 113, 116, 113, 117, 111,
116, 110, 114, 108, 115, 107, 114, 105, 114, 103, 112, 101, 112, 99, 110, 96,
108, 94, 108, 92, 107, 88, 106, 86, 106, 83, 103, 80, 103, 77, 101, 74, 100, 71,
99, 68, 98, 65, 96, 61, 95, 59, 93, 55, 93, 52, 92, 48, 90, 45, 88, 40, 88, 36,
87, 33, 86, 29, 85, 25, 83, 22, 83, 18, 81, 14, 81, 10, 80, 7, 79, 2, 78, 0, 78,
-4, 77, -8, 75, -12, 75, -15, 74, -19, 74, -23, 73, -26, 73, -29, 72, -33, 71,
-37, 70, -40, 70, -44, 69, -46, 69, -50, 69, -52, 69, -55, 68, -58, 67, -59, 67,
-62, 66, -65, 66, -67, 65, -68, 64, -72, 65, -74, 63, -75, 63, -78, 62, -79, 61,
-81, 60, -83, 61, -83, 59, -85, 58, -86, 58, -86, 57, -88, 56, -88, 55, -89, 54,
-91, 53, -91, 52, -90, 52, -90, 50, -90, 50, -90, 48, -89, 47, -88, 46, -88, 44,
-86, 44, -85, 43, -84, 41, -82, 40, -81, 39, -78, 37, -77, 37, -76, 36, -74, 35,
-73, 33, -70, 32, -68, 30, -66, 29, -63, 27, -61, 27, -58, 25, -56, 24, -53, 23,
-50, 22, -47, 20, -45, 19, -42, 17, -40, 15, -36, 14, -34, 12, -30, 12, -28, 10,
-25, 9, -22, 7, -19, 7, -15, 5, -12, 3, -8, 3, -4, 1, -2, -1, 2, -2, 5, -4, 9,
-5, 12, -6, 16, -8, 19, -9, 22, -11, 25, -12, 28, -13, 31, -15, 34, -16, 37,
-17, 40, -18, 42, -19, 46, -21, 48, -23, 51, -24, 52, -26, 56, -26, 58, -28, 61,
-29, 63, -31, 67, -33, 69, -33, 70, -34, 72, -36, 74, -37, 76, -37, 78, -39, 79,
-40, 81, -41, 82, -42, 84, -44, 85, -45, 86, -46, 87, -47, 88, -48, 89, -49, 90,
-50, 90, -51, 91, -53, 90, -53, 90, -54, 89, -55, 89, -56, 88, -57, 88, -58, 87,
-59, 86, -60, 85, -60, 83, -62, 81, -61, 81, -63, 80, -63, 78, -64, 75, -64, 73,
-65, 71, -66, 69, -66, 67, -66, 65, -67, 62, -67, 59, -68, 57, -68, 55, -69, 52,
-69, 49, -70, 46, -69, 43, -70, 40, -71, 36, -72, 33, -72, 30, -73, 26, -74, 22,
-75, 19, -74, 15, -76, 11, -77, 8, -77, 5, -78, 1, -78, -4, -80, -7, -81, -11,
-82, -14, -83, -18, -84, -21, -84, -25, -85, -29, -86, -34, -87, -37, -89, -40,
-91, -44, -92, -47, -93, -51, -94, -55, -95, -59, -97, -62, -97, -65, -99, -69,
-100, -71, -102, -75, -103, -77, -104, -80, -105, -84, -106, -87, -107, -90,
-108, -92, -109, -94, -110, -97, -111, -99, -112, -101, -112, -103, -113, -104,
-115, -108, -114, -109, -115, -109, -115, -112, -116, -112, -116, -114, -117,
-115, -117, -115, -117, -117, -117, -117, -118, -118, -118, -119, -118, -119,
-117, -119, -117, -119, -118, -119, -116, -119, -117, -118, -116, -118, -115,
-117, -114, -117, -114, -115, -113, -114, -113, -112, -111, -111, -111, -110,
-110, -109, -109, -107, -109, -106, -108, -104, -107, -102, -106, -100, -106,
-98, -104, -96, -103, -95, -102, -92, -101, -90, -101, -88, -100, -85, -99, -82,
-98, -80, -98, -76, -97, -73, -97, -71, -96, -67, -95, -63, -95, -60, -94, -56,
-92, -54, -93, -50, -91, -46, -91, -43, -90, -38, -89, -36, -89, -32, -89, -28,
-88, -24, -87, -21, -86, -18, -87, -14, -86, -10, -85, -7, -85, -4, -84, 1, -84,
3, -83, 6, -81, 9, -82, 11, -80, 16, -79, 18, -79, 20, -78, 23, -77, 26, -76,
29, -75, 31, -75, 34, -75, 36, -73, 38, -72, 40, -72, 42, -72, 44, -71, 46, -70,
48, -70, 50, -69, 52, -68, 54, -68, 55, -68, 57, -66, 58, -66, 60, -65, 61, -64,
61, -63, 63, -61, 64, -62, 65, -60, 65, -59, 66, -59, 67, -58, 67, -56, 68, -55,
68, -54, 69, -54, 70, -53, 70, -52, 70, -50, 70, -48, 69, -48, 69, -46, 69, -46,
69, -43, 67, -43, 66, -41, 66, -39, 63, -38, 63, -36, 61, -35, 60, -35, 59, -32,
57, -31, 56, -30, 53, -29, 51, -28, 48, -26, 46, -24, 45, -24, 43, -21, 40, -20,
38, -20, 36, -17, 33, -16, 30, -14, 28, -14, 25, -12, 22, -10, 20, -8, 17, -7,
14, -7, 12, -5, 9, -4, 6, -2, 3, -1, 1, };