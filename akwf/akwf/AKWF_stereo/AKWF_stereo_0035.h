#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0035

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -5, 7, -19, 14, -22, 11, -23, 6,
-19, 5, -23, 5, -29, 3, -25, 2, -20, 2, -20, -1, -14, -2, -18, -1, -23, 2, -36,
-1, -46, 7, -48, 13, -59, 13, -66, 32, -51, 27, -36, 20, -18, 20, -4, 21, -4,
23, -11, 21, -24, 18, -20, 18, -13, 19, -8, 19, -11, 22, -14, 25, -6, 33, -15,
37, -27, 40, -46, 45, -62, 46, -71, 44, -77, 40, -69, 40, -59, 38, -58, 44, -58,
53, -61, 57, -55, 53, -30, 52, -26, 56, -32, 52, -50, 45, -54, 44, -41, 45, -39,
48, -38, 51, -51, 53, -59, 54, -64, 51, -62, 55, -49, 59, -35, 61, -29, 60, -16,
60, 1, 57, 9, 48, 12, 43, 7, 41, 3, 38, -9, 26, -20, 18, -23, 18, -26, 21, -29,
34, -33, 41, -39, 43, -33, 41, -30, 36, -32, 36, -35, 36, -30, 32, -7, 33, 19,
33, 42, 30, 59, 27, 66, 28, 69, 32, 70, 32, 64, 33, 65, 41, 69, 48, 72, 52, 72,
55, 68, 52, 63, 54, 51, 54, 42, 59, 35, 58, 24, 53, 22, 54, 25, 63, 27, 66, 40,
73, 56, 73, 66, 74, 67, 77, 58, 79, 50, 83, 48, 80, 41, 76, 42, 73, 45, 65, 42,
65, 45, 70, 45, 81, 50, 91, 58, 88, 67, 82, 76, 74, 73, 67, 73, 58, 73, 50, 78,
48, 88, 48, 90, 51, 83, 53, 81, 57, 75, 56, 72, 56, 78, 56, 77, 53, 79, 53, 84,
55, 69, 58, 43, 55, 47, 51, 53, 51, 67, 46, 71, 43, 72, 53, 73, 59, 63, 63, 65,
68, 53, 71, 44, 64, 38, 56, 33, 57, 36, 59, 35, 59, 35, 61, 40, 63, 39, 62, 42,
62, 45, 58, 46, 55, 49, 50, 49, 50, 57, 51, 67, 58, 69, 60, 67, 77, 65, 79, 60,
72, 59, 67, 53, 59, 38, 59, 21, 56, 18, 58, 33, 58, 55, 61, 63, 57, 60, 54, 69,
53, 73, 55, 64, 57, 55, 60, 41, 67, 37, 69, 32, 69, 21, 69, 10, 65, -5, 63, -6,
60, -5, 64, -10, 68, -14, 65, -14, 65, 0, 71, 7, 76, 10, 78, 15, 71, 18, 63, 17,
55, 8, 51, -5, 55, -9, 60, -7, 63, -4, 62, -2, 67, -1, 70, -6, 69, -11, 72, -22,
69, -23, 66, -26, 61, -33, 58, -40, 57, -55, 55, -57, 53, -54, 52, -45, 47, -36,
46, -25, 46, -21, 41, -17, 30, -19, 25, -16, 28, -19, 32, -26, 34, -20, 33, -25,
30, -29, 26, -34, 21, -25, 16, -23, 16, -24, 16, -33, 17, -38, 22, -47, 25, -60,
30, -69, 33, -81, 26, -91, 13, -98, 2, -102, -3, -115, -7, -119, -9, -110, -8,
-103, -5, -95, -3, -86, -3, -81, -9, -74, -15, -69, -15, -72, -10, -75, -1, -80,
4, -85, 11, -83, 20, -95, 25, -94, 30, -103, 29, -47, 30, -1, 36, -11, 35, -2,
33, -5, 26, 6, 21, -3, 15, 2, 8, 0, 3, -2, 0, -3, 0, -7, 2, -12, 4, -21, 4, -21,
1, -24, 3, -31, 3, -32, 3, -33, 3, -39, 4, -44, 6, -45, 4, -38, 5, -31, 1, -28,
-4, -23, -3, -16, -2, -24, -2, -28, 1, -28, 5, -15, 9, 0, 11, 13, 8, 19, 8, 9,
9, 1, 9, 1, 9, 3, 6, -4, 4, -14, -1, -7, -8, 7, -14, 26, -22, 41, -22, 50, -27,
51, -13, 50, 6, 63, 5, 68, 3, 65, -4, 68, -9, 67, -11, 60, -16, 57, -22, 53,
-23, 57, -25, 59, -25, 56, -26, 51, -25, 49, -21, 47, -22, 36, -22, 37, -23, 32,
-28, 14, -33, 1, -35, -6, -32, -16, -27, -26, -24, -27, -20, -30, -17, -23, -16,
-11, -16, -2, -15, -5, -18, -2, -20, 4, -25, 4, -34, -1, -37, -4, -35, -14, -28,
-10, -23, -1, -27, 10, -34, 9, -31, -9, -30, -23, -28, -37, -26, -40, -25, -38,
-19, -43, -18, -48, -20, -38, -29, -30, -42, -27, -41, -23, -39, -23, -37, -22,
-35, -20, -33, -20, -28, -24, -24, -19, -22, -2, -18, 3, -18, 1, -21, -5, -24,
-20, -27, -37, -21, -51, -22, -58, -25, -55, -30, -54, -34, -51, -33, -42, -30,
-37, -30, -23, -28, -11, -29, -12, -30, -39, -40, -55, -50, -63, -53, -73, -53,
-68, -45, -59, -41, -48, -35, -47, -31, -45, -32, -45, -33, -39, -33, -28, -40,
-22, -44, -12, -45, -11, -46, -23, -49, -23, -48, -25, -46, -27, -49, -24, -53,
-16, -54, -14, -53, -18, -55, -28, -52, -32, -52, -40, -63, -50, -69, -43, -71,
-45, -73, -45, -76, -37, -78, -35, -75, -37, -71, -30, -71, -24, -69, -23, -71,
-36, -67, -32, -68, -26, -64, -18, -64, -15, -58, -11, -52, -11, -46, -15, -49,
-16, -53, -15, -53, -5, -113, -23, -118, -41, -107, -48, -109, -50, -101, -38,
-100, -23, -94, -19, -91, -29, -90, -41, -93, -44, -93, -47, -95, -55, -97, -57,
-105, -47, -107, -34, -111, -21, -115, -11, -116, 1, -112, 8, -112, 6, -112, 12,
-115, 17, -115, 20, -118, 27, -118, 18, -111, 0, -109, -15, -109, -11, -105, -3,
-93, -12, -82, -19, -76, -11, -68, 8, -67, 32, -75, 44, -77, 35, -77, 29, -74,
25, -79, 28, -81, 34, -78, 32, -81, 26, -77, 13, -73, 15, -68, 26, -62, 32, -52,
45, -38, 49, -35, 44, -38, 38, -40, 31, -43, 27, -44, 30, -46, 31, -45, 26, -42,
17, -40, 14, -41, 19, -45, 13, -48, 13, -51, 12, -51, 16, -48, 24, -50, 27, -53,
27, -50, 30, -49, 29, -57, 26, -63, 26, -70, 28, -74, 34, -67, 46, -55, 64, -52,
83, -47, 93, -39, 86, -38, 69, -41, 62, -45, 57, -47, 49, -46, 41, -42, 41, -39,
41, -35, 46, -36, 51, -39, 58, -41, 62, -43, 66, -44, 69, -47, 75, -48, 82, -48,
51, -48, 32, -49, 23, -43, 16, -34, 12, -27, 5, -20, 12, -11, 9, -4, 2, };