#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0113

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 2, 3, 4, 6, 6, 8, 8, 11, 8, 13,
11, 16, 12, 20, 14, 22, 16, 25, 17, 27, 20, 30, 22, 31, 25, 34, 27, 36, 28, 39,
30, 40, 32, 44, 34, 46, 36, 49, 39, 51, 40, 55, 42, 57, 44, 60, 46, 62, 48, 66,
50, 68, 52, 70, 53, 72, 55, 75, 56, 76, 58, 79, 61, 81, 62, 84, 63, 86, 65, 90,
67, 92, 68, 95, 70, 97, 70, 99, 72, 102, 73, 104, 75, 106, 75, 108, 77, 110, 77,
112, 78, 113, 80, 113, 80, 115, 81, 116, 83, 116, 83, 115, 84, 115, 85, 115, 85,
114, 86, 114, 86, 114, 86, 114, 87, 115, 87, 114, 89, 115, 89, 115, 90, 115, 90,
115, 92, 115, 93, 116, 94, 115, 95, 114, 96, 114, 97, 114, 100, 113, 101, 113,
103, 114, 104, 114, 105, 114, 107, 114, 108, 114, 110, 115, 110, 114, 111, 113,
112, 113, 113, 112, 114, 110, 114, 108, 116, 107, 116, 106, 116, 104, 118, 103,
118, 100, 118, 98, 117, 97, 118, 96, 118, 95, 119, 93, 119, 92, 119, 90, 119,
89, 118, 87, 118, 84, 117, 82, 118, 79, 116, 75, 117, 72, 116, 68, 115, 62, 113,
58, 113, 54, 113, 50, 112, 45, 110, 41, 109, 37, 109, 34, 107, 30, 105, 27, 105,
23, 104, 21, 103, 17, 102, 15, 100, 13, 100, 11, 99, 8, 98, 7, 96, 5, 95, 3, 94,
1, 94, 0, 92, -1, 90, -3, 90, -4, 88, -5, 87, -6, 86, -7, 85, -7, 84, -8, 82,
-9, 82, -11, 80, -11, 80, -13, 78, -14, 77, -15, 76, -15, 75, -17, 73, -17, 73,
-19, 73, -19, 72, -20, 71, -20, 69, -19, 69, -21, 68, -20, 67, -18, 66, -19, 65,
-17, 64, -18, 64, -15, 63, -15, 63, -15, 62, -14, 62, -13, 61, -11, 61, -11, 61,
-10, 60, -8, 60, -7, 59, -6, 60, -5, 59, -2, 59, -1, 59, 1, 59, 2, 59, 3, 60, 6,
59, 7, 61, 9, 60, 11, 61, 12, 60, 14, 61, 14, 62, 16, 61, 18, 61, 19, 60, 20,
61, 22, 61, 22, 61, 23, 60, 25, 61, 25, 60, 26, 59, 27, 58, 27, 58, 28, 58, 29,
56, 30, 55, 29, 54, 30, 54, 30, 52, 30, 51, 32, 49, 32, 47, 33, 47, 33, 45, 34,
43, 34, 41, 35, 39, 35, 37, 36, 36, 35, 35, 35, 32, 35, 31, 34, 29, 34, 27, 34,
25, 33, 24, 33, 22, 33, 21, 31, 20, 31, 18, 30, 17, 28, 15, 27, 14, 26, 14, 25,
12, 23, 13, 22, 11, 22, 11, 21, 11, 20, 11, 19, 9, 17, 10, 17, 10, 15, 9, 13,
10, 13, 9, 12, 9, 10, 9, 9, 9, 7, 9, 5, 8, 3, 9, 2, 7, 1, 7, 0, 6, -1, 6, -3, 5,
-4, 5, -5, 5, -4, 4, -5, 4, -6, 3, -5, 3, -5, 2, -4, 2, -4, 1, -3, 1, -1, 0, 0,
-1, 1, -1, 1, -1, 3, -2, 3, -2, 4, -4, 4, -4, 5, -4, 5, -3, 4, -5, 5, -5, 4, -5,
3, -5, 2, -6, 2, -6, 0, -8, 0, -8, -2, -8, -3, -8, -6, -9, -7, -9, -9, -8, -11,
-9, -11, -10, -13, -9, -14, -9, -15, -10, -16, -9, -18, -10, -19, -10, -19, -11,
-21, -11, -21, -12, -22, -13, -23, -13, -24, -14, -26, -16, -28, -16, -28, -18,
-30, -20, -31, -21, -31, -23, -32, -24, -33, -25, -33, -28, -34, -28, -34, -31,
-35, -33, -35, -34, -35, -36, -35, -38, -35, -40, -35, -41, -35, -44, -34, -45,
-34, -47, -34, -48, -32, -49, -32, -51, -31, -52, -30, -53, -30, -54, -30, -55,
-29, -56, -28, -57, -29, -58, -29, -59, -28, -58, -27, -59, -25, -60, -24, -60,
-24, -60, -24, -60, -23, -61, -21, -62, -20, -61, -18, -61, -17, -61, -17, -61,
-14, -60, -13, -60, -12, -61, -11, -60, -9, -60, -7, -59, -6, -60, -5, -59, -2,
-59, -1, -60, 1, -59, 3, -60, 4, -60, 6, -59, 7, -60, 8, -60, 9, -60, 10, -61,
11, -62, 13, -61, 14, -63, 15, -62, 16, -64, 16, -64, 17, -66, 17, -65, 18, -66,
19, -68, 19, -68, 20, -70, 20, -71, 19, -71, 19, -72, 19, -73, 18, -73, 18, -74,
17, -76, 16, -77, 14, -78, 14, -80, 12, -80, 11, -81, 10, -83, 9, -84, 8, -85,
7, -86, 6, -87, 6, -88, 5, -90, 4, -91, 3, -91, 2, -94, 0, -94, -1, -95, -3,
-97, -4, -97, -7, -99, -8, -99, -11, -101, -13, -102, -16, -104, -19, -105, -21,
-105, -23, -106, -27, -107, -30, -108, -34, -110, -38, -110, -42, -111, -46,
-113, -51, -113, -55, -114, -59, -115, -63, -116, -68, -116, -71, -117, -76,
-117, -79, -118, -82, -119, -85, -119, -87, -118, -89, -119, -91, -119, -92,
-119, -93, -119, -95, -119, -96, -119, -97, -118, -98, -118, -100, -117, -103,
-117, -104, -116, -106, -115, -107, -115, -109, -114, -110, -114, -112, -112,
-113, -112, -113, -111, -114, -109, -115, -109, -115, -107, -114, -106, -114,
-104, -113, -102, -113, -100, -113, -98, -113, -98, -113, -96, -114, -95, -114,
-94, -114, -93, -115, -92, -115, -90, -116, -90, -115, -89, -115, -89, -115,
-88, -114, -86, -115, -87, -114, -87, -114, -85, -115, -85, -115, -84, -116,
-84, -115, -83, -116, -81, -115, -82, -115, -80, -115, -79, -114, -78, -112,
-78, -112, -77, -110, -76, -109, -74, -106, -73, -104, -72, -102, -70, -100,
-69, -98, -68, -95, -67, -93, -64, -89, -63, -87, -62, -84, -60, -82, -58, -80,
-57, -77, -55, -75, -54, -72, -52, -69, -50, -67, -48, -64, -46, -62, -44, -60,
-41, -57, -40, -54, -37, -51, -36, -49, -34, -45, -32, -43, -30, -41, -27, -39,
-26, -37, -24, -34, -21, -31, -20, -29, -18, -27, -16, -24, -14, -22, -13, -20,
-11, -15, -9, -14, -8, -10, -6, -8, -4, -5, -2, -3, -1, 0, };