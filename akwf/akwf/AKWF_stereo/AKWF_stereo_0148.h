#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0148

const PROGMEM int8_t DATA[DATA_LENGTH] = {69, 40, 117, 68, 103, 61, 111, 65,
105, 62, 109, 64, 105, 62, 108, 62, 105, 61, 105, 62, 104, 61, 104, 62, 104, 61,
103, 61, 103, 61, 103, 61, 103, 60, 101, 59, 102, 60, 100, 60, 101, 59, 99, 58,
99, 59, 98, 59, 99, 58, 98, 58, 97, 58, 97, 57, 97, 57, 95, 57, 96, 56, 95, 57,
94, 57, 94, 55, 93, 55, 92, 56, 92, 55, 93, 55, 91, 55, 91, 54, 91, 55, 91, 54,
90, 54, 90, 53, 88, 54, 88, 52, 87, 53, 87, 52, 86, 52, 86, 52, 86, 52, 86, 52,
85, 51, 85, 51, 84, 50, 84, 51, 84, 50, 83, 50, 83, 51, 82, 51, 81, 50, 81, 49,
81, 49, 81, 49, 81, 49, 80, 49, 78, 49, 78, 48, 78, 49, 77, 48, 77, 48, 78, 48,
77, 48, 76, 47, 76, 48, 76, 47, 75, 47, 75, 48, 74, 47, 74, 47, 73, 47, 73, 46,
73, 47, 73, 47, 72, 46, 71, 46, 71, 46, 71, 46, 70, 46, 71, 46, 70, 46, 70, 46,
69, 45, 68, 45, 68, 45, 67, 45, 67, 45, 66, 46, 66, 45, 65, 46, 65, 45, 65, 45,
64, 45, 64, 45, 64, 45, 64, 45, 64, 45, 64, 45, 63, 45, 62, 45, 62, 44, 62, 45,
61, 45, 62, 44, 60, 45, 60, 45, 60, 44, 60, 45, 59, 45, 59, 46, 58, 45, 59, 45,
59, 44, 58, 44, 57, 45, 57, 45, 57, 44, 56, 45, 56, 45, 55, 44, 56, 45, 55, 45,
54, 45, 55, 46, 55, 45, 54, 45, 53, 46, 53, 45, 52, 45, 53, 46, 52, 46, 52, 46,
51, 46, 52, 46, 51, 46, 50, 46, 50, 47, 50, 46, 51, 46, 50, 46, 49, 46, 49, 46,
50, 47, 50, 47, 48, 47, 49, 48, 48, 47, 47, 47, 47, 47, 48, 48, 47, 48, 47, 48,
46, 48, 46, 48, 45, 49, 45, 49, 45, 49, 44, 50, 45, 49, 45, 49, 44, 50, 44, 49,
44, 51, 44, 50, 43, 50, 43, 50, 43, 50, 43, 50, 43, 51, 43, 52, 42, 51, 41, 51,
42, 51, 42, 52, 41, 53, 41, 52, 40, 53, 40, 53, 40, 54, 40, 54, 39, 54, 40, 54,
40, 55, 39, 54, 39, 55, 39, 55, 39, 56, 39, 56, 38, 55, 39, 56, 38, 56, 37, 57,
37, 58, 37, 57, 37, 58, 37, 58, 37, 58, 37, 58, 36, 58, 37, 60, 35, 59, 35, 59,
36, 60, 35, 60, 35, 61, 35, 60, 34, 61, 34, 61, 34, 62, 34, 62, 34, 62, 34, 62,
34, 63, 33, 63, 33, 62, 32, 63, 33, 63, 32, 64, 32, 65, 32, 65, 32, 65, 33, 65,
31, 65, 32, 65, 31, 66, 31, 66, 32, 66, 30, 66, 31, 67, 30, 67, 30, 67, 31, 68,
31, 68, 30, 68, 29, 69, 30, 69, 29, 69, 30, 69, 29, 70, 28, 70, 28, 70, 28, 70,
28, 70, 27, 71, 27, 71, 28, 70, 28, 71, 27, 72, 27, 72, 26, 72, 28, 73, 26, 73,
26, 73, 26, 74, 26, 73, 26, 74, 26, 74, 26, 74, 26, 74, 26, 75, 24, 76, 25, 75,
25, 76, 24, 75, 24, 76, 24, 76, 24, 77, 24, 77, 23, 77, 23, 76, 15, 59, -12, -3,
-45, -79, -61, -116, -60, -111, -53, -97, -51, -91, -51, -91, -52, -93, -53,
-92, -53, -92, -52, -91, -52, -89, -53, -88, -52, -88, -52, -87, -52, -87, -52,
-86, -52, -85, -52, -85, -52, -84, -52, -83, -51, -82, -52, -82, -52, -81, -52,
-80, -51, -80, -52, -79, -52, -79, -52, -78, -51, -77, -52, -76, -52, -76, -53,
-76, -52, -76, -52, -74, -52, -74, -52, -73, -52, -72, -53, -73, -52, -72, -52,
-71, -52, -71, -53, -71, -52, -70, -53, -69, -52, -69, -53, -69, -53, -69, -53,
-68, -53, -68, -54, -67, -53, -67, -53, -67, -54, -65, -54, -65, -54, -65, -53,
-65, -54, -65, -55, -65, -55, -63, -54, -64, -54, -63, -54, -63, -55, -62, -56,
-63, -55, -63, -55, -63, -55, -61, -56, -61, -56, -61, -57, -61, -56, -61, -56,
-61, -56, -60, -57, -60, -57, -59, -57, -59, -57, -59, -57, -59, -58, -58, -58,
-59, -58, -59, -58, -58, -58, -59, -59, -58, -59, -57, -59, -58, -60, -58, -59,
-57, -60, -58, -60, -57, -60, -57, -60, -56, -60, -56, -60, -56, -60, -56, -61,
-56, -61, -56, -61, -55, -62, -55, -62, -55, -62, -55, -62, -54, -62, -55, -62,
-55, -62, -55, -62, -54, -63, -54, -63, -54, -63, -55, -63, -54, -63, -54, -64,
-54, -64, -53, -65, -53, -64, -53, -64, -53, -66, -52, -65, -53, -65, -52, -66,
-53, -66, -53, -66, -52, -66, -53, -66, -53, -67, -52, -67, -52, -67, -52, -68,
-52, -67, -52, -67, -52, -68, -52, -68, -51, -68, -51, -68, -51, -69, -52, -69,
-51, -69, -52, -70, -51, -70, -51, -70, -50, -70, -51, -70, -51, -70, -51, -71,
-51, -71, -50, -71, -50, -71, -50, -72, -51, -73, -51, -73, -51, -73, -50, -73,
-50, -73, -50, -73, -51, -74, -50, -74, -51, -74, -50, -74, -50, -74, -50, -74,
-51, -75, -50, -75, -50, -76, -50, -76, -51, -75, -50, -76, -50, -76, -50, -77,
-50, -76, -51, -78, -50, -77, -51, -77, -50, -78, -51, -78, -51, -78, -51, -79,
-51, -78, -50, -79, -50, -79, -51, -79, -50, -79, -50, -80, -51, -81, -51, -80,
-50, -81, -51, -81, -50, -81, -51, -81, -51, -82, -51, -83, -51, -83, -51, -83,
-50, -83, -51, -83, -51, -82, -51, -84, -52, -83, -52, -84, -51, -84, -52, -85,
-52, -85, -52, -86, -51, -86, -52, -86, -52, -86, -52, -86, -53, -87, -52, -87,
-52, -87, -52, -88, -53, -88, -53, -89, -52, -88, -52, -89, -53, -88, -53, -88,
-53, -89, -53, -89, -53, -90, -53, -90, -52, -91, -54, -90, -53, -91, -53, -90,
-53, -93, -55, -90, -52, -94, -56, -88, -51, -101, -58, -55, -32, };