#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0054

const PROGMEM int8_t DATA[DATA_LENGTH] = {17, 1, 29, 1, 26, 2, 29, 3, 28, 3, 29,
3, 29, 4, 30, 5, 31, 6, 31, 6, 32, 7, 32, 8, 33, 8, 32, 9, 33, 9, 33, 11, 34,
10, 34, 11, 35, 12, 35, 13, 36, 13, 36, 14, 36, 15, 38, 15, 37, 15, 38, 16, 38,
16, 39, 18, 39, 18, 39, 19, 40, 19, 41, 20, 41, 21, 42, 21, 42, 22, 42, 22, 43,
23, 43, 23, 43, 24, 44, 24, 44, 26, 45, 25, 46, 27, 46, 28, 47, 27, 47, 27, 47,
29, 48, 29, 48, 30, 48, 30, 49, 31, 50, 32, 50, 32, 51, 33, 51, 33, 51, 34, 52,
35, 53, 35, 53, 35, 53, 36, 54, 37, 54, 37, 55, 38, 55, 39, 56, 40, 56, 40, 57,
40, 57, 41, 57, 42, 58, 43, 59, 43, 59, 44, 60, 45, 60, 45, 60, 46, 61, 46, 62,
46, 62, 47, 63, 47, 62, 47, 64, 49, 64, 50, 65, 50, 65, 50, 65, 50, 66, 52, 66,
52, 67, 53, 67, 54, 68, 54, 69, 54, 68, 55, 69, 56, 71, 56, 70, 57, 70, 56, 71,
58, 71, 58, 73, 59, 73, 59, 73, 60, 73, 61, 73, 61, 74, 61, 75, 62, 76, 63, 75,
63, 76, 64, 77, 65, 77, 65, 78, 65, 78, 66, 78, 67, 80, 67, 79, 68, 80, 68, 80,
69, 81, 70, 81, 70, 81, 71, 83, 72, 83, 71, 83, 72, 84, 73, 85, 73, 85, 73, 84,
74, 86, 74, 86, 76, 86, 76, 87, 77, 88, 78, 87, 77, 88, 78, 89, 78, 89, 79, 89,
79, 90, 80, 90, 81, 91, 81, 92, 82, 91, 83, 93, 83, 92, 83, 92, 84, 93, 84, 94,
85, 94, 86, 95, 86, 95, 86, 95, 87, 96, 88, 97, 88, 96, 88, 96, 89, 98, 89, 98,
90, 98, 90, 99, 91, 100, 92, 100, 92, 100, 93, 100, 94, 101, 93, 101, 94, 101,
95, 101, 95, 102, 96, 103, 96, 103, 96, 103, 97, 104, 98, 104, 98, 104, 98, 104,
100, 105, 100, 105, 100, 106, 101, 107, 101, 107, 101, 107, 102, 107, 102, 108,
104, 108, 103, 109, 104, 109, 104, 110, 105, 109, 106, 110, 106, 110, 106, 111,
108, 111, 107, 112, 108, 112, 109, 113, 109, 111, 109, 113, 110, 112, 110, 113,
111, 114, 111, 115, 112, 114, 112, 115, 113, 115, 113, 115, 114, 116, 114, 117,
115, 116, 116, 117, 116, 118, 115, 117, 117, 118, 118, 117, 116, 120, 118, 118,
117, 120, 121, 113, 113, 104, 102, 108, 107, 105, 102, 106, 104, 105, 102, 105,
103, 104, 102, 104, 102, 104, 101, 103, 98, 104, 97, 103, 95, 103, 92, 103, 88,
104, 85, 104, 82, 103, 80, 103, 76, 104, 75, 102, 71, 103, 72, 103, 68, 104, 68,
102, 66, 103, 66, 102, 64, 102, 64, 101, 62, 98, 60, 89, 56, 81, 53, 75, 51, 71,
48, 69, 47, 66, 44, 60, 41, 22, -11, 6, -33, -1, -45, -9, -61, -8, -61, -13,
-68, -14, -68, -21, -74, -25, -74, -31, -76, -33, -74, -36, -75, -38, -73, -41,
-74, -44, -74, -53, -78, -61, -82, -68, -85, -75, -88, -80, -91, -85, -93, -89,
-95, -92, -96, -93, -95, -96, -97, -98, -97, -101, -99, -103, -99, -106, -100,
-107, -102, -110, -102, -111, -103, -112, -102, -112, -103, -114, -103, -114,
-104, -115, -103, -114, -104, -116, -103, -116, -103, -117, -104, -117, -105,
-118, -104, -119, -104, -118, -104, -119, -103, -119, -104, -119, -104, -119,
-104, -119, -103, -118, -103, -118, -104, -118, -103, -119, -103, -119, -102,
-119, -103, -118, -102, -118, -102, -119, -102, -118, -102, -118, -101, -118,
-101, -118, -101, -118, -101, -117, -101, -117, -100, -117, -100, -116, -100,
-117, -100, -116, -99, -117, -99, -115, -99, -116, -99, -116, -98, -115, -98,
-115, -97, -115, -97, -115, -96, -114, -96, -114, -97, -113, -96, -113, -95,
-113, -95, -112, -94, -113, -95, -111, -94, -111, -93, -110, -93, -111, -92,
-110, -92, -110, -92, -109, -91, -109, -91, -108, -91, -108, -90, -107, -89,
-108, -89, -107, -88, -107, -89, -105, -88, -105, -88, -105, -86, -105, -86,
-104, -86, -103, -86, -103, -86, -102, -85, -102, -84, -102, -84, -101, -83,
-100, -83, -101, -82, -99, -82, -99, -81, -99, -81, -99, -81, -98, -80, -97,
-80, -97, -79, -96, -79, -96, -78, -95, -78, -95, -78, -94, -77, -94, -76, -94,
-76, -93, -75, -93, -76, -92, -75, -92, -74, -91, -74, -91, -73, -90, -72, -89,
-72, -90, -72, -88, -71, -89, -71, -87, -70, -87, -69, -87, -69, -87, -68, -85,
-68, -84, -67, -85, -66, -84, -67, -83, -66, -83, -65, -83, -65, -82, -64, -81,
-64, -81, -63, -81, -62, -80, -62, -80, -63, -79, -61, -79, -60, -78, -60, -78,
-59, -76, -59, -76, -59, -76, -58, -76, -58, -75, -57, -74, -57, -74, -56, -73,
-56, -73, -55, -72, -54, -71, -54, -72, -53, -71, -53, -70, -52, -70, -52, -69,
-51, -68, -50, -68, -50, -68, -49, -67, -49, -67, -48, -66, -47, -65, -48, -65,
-47, -64, -46, -64, -46, -64, -45, -63, -44, -62, -44, -61, -43, -61, -43, -61,
-42, -60, -41, -60, -41, -59, -41, -58, -40, -58, -39, -57, -39, -56, -38, -56,
-37, -56, -38, -55, -36, -55, -36, -54, -35, -53, -34, -53, -35, -53, -33, -51,
-33, -51, -32, -51, -32, -50, -31, -49, -30, -49, -29, -48, -29, -48, -29, -47,
-28, -47, -27, -45, -28, -45, -26, -46, -26, -45, -25, -44, -24, -44, -24, -43,
-23, -42, -23, -42, -22, -41, -21, -41, -21, -40, -21, -40, -20, -39, -18, -38,
-18, -37, -18, -37, -17, -38, -17, -37, -15, -36, -14, -36, -15, -35, -14, -33,
-14, -33, -13, -33, -12, -32, -11, -32, -10, -31, -10, -31, -10, -30, -9, -30,
-8, -30, -8, -28, -7, -28, -6, -27, -6, -27, -6, -27, -4, -26, -4, -26, -2, -25,
-2, -25, -2, -22, -2, -25, 0, -13, 0, };