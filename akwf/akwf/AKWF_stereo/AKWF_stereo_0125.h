#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0125

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -20, 5, -20, 8, -15, 11, -13, 14,
-9, 18, -7, 23, -2, 26, 0, 28, 4, 33, 7, 37, 11, 40, 13, 43, 17, 47, 20, 50, 23,
53, 26, 57, 31, 60, 34, 63, 37, 67, 40, 70, 44, 73, 47, 76, 50, 79, 53, 81, 56,
84, 60, 87, 63, 89, 66, 91, 69, 95, 72, 97, 75, 98, 78, 101, 80, 103, 83, 104,
85, 107, 87, 108, 90, 110, 93, 110, 94, 112, 96, 114, 98, 114, 100, 115, 102,
116, 103, 116, 104, 117, 105, 118, 107, 119, 108, 118, 109, 119, 110, 119, 110,
118, 112, 119, 113, 119, 112, 118, 113, 118, 114, 119, 114, 118, 114, 117, 114,
117, 114, 117, 115, 117, 115, 116, 114, 115, 114, 115, 113, 114, 113, 114, 114,
113, 113, 113, 114, 112, 114, 111, 114, 112, 113, 111, 113, 111, 113, 111, 112,
110, 112, 108, 112, 108, 111, 108, 111, 108, 110, 107, 110, 106, 109, 105, 109,
105, 109, 104, 109, 104, 108, 103, 108, 101, 107, 100, 106, 99, 105, 98, 105,
97, 103, 95, 102, 94, 102, 92, 101, 90, 100, 88, 98, 86, 97, 84, 95, 83, 93, 79,
93, 78, 90, 75, 89, 72, 86, 69, 84, 67, 82, 64, 80, 61, 78, 58, 75, 54, 72, 51,
69, 47, 67, 44, 65, 41, 61, 36, 58, 33, 55, 29, 51, 25, 49, 22, 46, 18, 42, 13,
38, 9, 35, 5, 30, 1, 27, -3, 23, -7, 20, -11, 17, -15, 13, -19, 9, -23, 5, -26,
2, -30, -2, -33, -5, -37, -9, -39, -13, -43, -16, -47, -19, -50, -23, -52, -26,
-55, -29, -58, -33, -60, -36, -63, -38, -64, -41, -66, -44, -69, -47, -70, -49,
-73, -52, -75, -55, -77, -56, -79, -60, -80, -61, -81, -64, -83, -66, -84, -68,
-86, -71, -87, -72, -89, -74, -89, -76, -91, -77, -93, -79, -93, -81, -94, -83,
-95, -84, -96, -86, -96, -87, -97, -88, -98, -90, -99, -91, -99, -92, -100, -92,
-100, -93, -100, -95, -101, -95, -101, -96, -101, -96, -101, -97, -101, -97,
-100, -98, -101, -99, -100, -98, -100, -98, -100, -99, -99, -99, -99, -99, -99,
-99, -99, -98, -98, -98, -97, -99, -97, -99, -97, -98, -97, -98, -95, -98, -94,
-97, -94, -97, -93, -97, -93, -96, -91, -95, -91, -95, -90, -94, -90, -92, -88,
-92, -88, -92, -86, -92, -86, -90, -84, -89, -85, -89, -84, -88, -82, -87, -81,
-86, -80, -85, -78, -84, -77, -83, -76, -82, -75, -81, -75, -80, -73, -78, -72,
-78, -70, -77, -69, -75, -68, -73, -67, -72, -65, -71, -63, -71, -62, -69, -60,
-68, -59, -67, -57, -64, -55, -63, -54, -62, -52, -61, -50, -59, -49, -58, -47,
-56, -45, -56, -43, -53, -40, -52, -39, -50, -37, -48, -33, -46, -31, -45, -29,
-43, -27, -41, -25, -39, -21, -37, -19, -35, -16, -33, -13, -31, -11, -28, -8,
-25, -5, -23, -2, -21, 0, -19, 3, -17, 7, -13, 11, -12, 14, -8, 17, -6, 20, -2,
22, 0, 27, 2, 30, 6, 33, 8, 37, 12, 40, 15, 44, 17, 46, 21, 50, 24, 53, 27, 55,
30, 59, 34, 63, 37, 66, 40, 68, 43, 72, 46, 75, 50, 78, 53, 80, 55, 83, 59, 86,
61, 88, 65, 90, 69, 93, 71, 95, 74, 97, 77, 100, 79, 101, 82, 104, 85, 105, 87,
107, 90, 108, 91, 109, 93, 110, 95, 112, 97, 112, 99, 113, 100, 114, 102, 114,
104, 115, 106, 116, 106, 116, 108, 116, 108, 116, 109, 116, 110, 116, 111, 117,
112, 116, 112, 116, 112, 115, 112, 115, 113, 115, 114, 115, 113, 114, 114, 114,
113, 113, 114, 112, 113, 111, 113, 111, 113, 110, 112, 109, 111, 110, 111, 108,
111, 107, 110, 107, 110, 105, 110, 105, 108, 103, 107, 103, 107, 102, 107, 102,
106, 100, 105, 100, 104, 98, 103, 97, 103, 97, 102, 95, 101, 94, 101, 93, 99,
93, 98, 91, 97, 90, 96, 89, 95, 87, 94, 85, 93, 84, 91, 82, 91, 81, 88, 78, 88,
76, 86, 74, 85, 72, 84, 71, 81, 67, 79, 65, 77, 62, 76, 60, 74, 58, 72, 54, 69,
51, 67, 48, 65, 46, 62, 42, 60, 39, 57, 35, 54, 32, 51, 28, 49, 26, 46, 22, 44,
18, 41, 16, 37, 12, 34, 8, 31, 5, 28, 0, 25, -3, 21, -6, 18, -10, 16, -14, 12,
-17, 8, -21, 6, -25, 1, -28, -2, -32, -5, -36, -8, -38, -12, -42, -15, -45, -19,
-48, -22, -51, -26, -54, -28, -56, -31, -59, -34, -63, -38, -65, -41, -67, -43,
-69, -46, -71, -49, -74, -51, -76, -54, -79, -57, -79, -59, -82, -62, -84, -63,
-86, -66, -86, -68, -89, -71, -90, -72, -91, -74, -93, -76, -94, -77, -96, -80,
-97, -82, -99, -83, -100, -85, -101, -87, -103, -90, -103, -90, -104, -92, -105,
-94, -106, -95, -106, -98, -108, -98, -109, -100, -110, -101, -109, -102, -110,
-103, -111, -105, -111, -106, -112, -106, -112, -108, -112, -108, -112, -109,
-112, -110, -112, -109, -113, -111, -113, -112, -113, -111, -112, -111, -112,
-112, -112, -113, -112, -112, -111, -112, -111, -113, -110, -112, -111, -112,
-110, -112, -111, -112, -109, -112, -108, -112, -108, -112, -107, -111, -107,
-111, -107, -111, -107, -110, -105, -109, -104, -109, -103, -109, -104, -108,
-103, -108, -102, -108, -102, -107, -100, -105, -101, -105, -99, -105, -99,
-103, -97, -102, -96, -101, -97, -100, -95, -100, -95, -98, -93, -99, -93, -97,
-90, -96, -90, -95, -90, -94, -87, -93, -87, -91, -85, -92, -83, -89, -82, -88,
-81, -87, -80, -86, -78, -85, -76, -83, -74, -82, -73, -80, -71, -79, -69, -78,
-67, -76, -65, -74, -63, -73, -60, -71, -59, -70, -55, -68, -54, -66, -52, -64,
-49, -62, -45, -59, -43, -58, -41, -55, -37, -54, -34, -51, -32, -49, -28, -45,
-25, -44, -22, -41, -18, -38, -16, -34, -12, -33, -10, -28, -6, -28, -3, -21, };