#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0111

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 22, 6, 29, 10, 26, 14, 29, 22, 35,
30, 42, 35, 42, 39, 42, 44, 44, 51, 51, 54, 51, 52, 41, 46, 26, 44, 28, 45, 44,
47, 68, 43, 79, -1, 36, -51, -24, -65, -41, -65, -41, -64, -41, -64, -42, -64,
-42, -63, -42, -64, -42, -65, -43, -66, -44, -66, -44, -66, -44, -68, -45, -71,
-48, -73, -49, -73, -49, -76, -50, -80, -54, -84, -57, -86, -59, -89, -60, -93,
-62, -99, -69, -104, -76, -108, -77, -110, -75, -113, -78, -117, -85, -119, -85,
-116, -75, -111, -62, -109, -63, -108, -79, -108, -103, -103, -113, -64, -73,
-14, -17, -1, 1, 12, 15, 63, 72, 103, 113, 109, 104, 108, 78, 109, 63, 110, 62,
115, 73, 119, 85, 117, 85, 113, 79, 109, 75, 108, 76, 104, 76, 100, 70, 93, 63,
89, 60, 87, 60, 83, 58, 80, 54, 77, 50, 74, 50, 73, 50, 71, 49, 68, 45, 66, 44,
66, 44, 66, 45, 64, 43, 63, 42, 63, 42, 63, 42, 64, 41, 64, 41, 64, 40, 64, 42,
53, 25, 2, -34, -42, -79, -47, -69, -44, -44, -45, -28, -46, -27, -51, -39, -54,
-51, -50, -51, -45, -44, -39, -41, -34, -43, -30, -43, -23, -36, -15, -29, -9,
-27, -5, -27, -1, -25, 5, -20, 10, -18, 13, -18, 16, -18, 19, -17, 23, -14, 25,
-13, 27, -15, 29, -15, 31, -15, 33, -14, 34, -14, 34, -15, 36, -15, 36, -17, 37,
-15, 37, -17, 36, -17, 36, -18, 36, -19, 36, -19, 36, -21, 35, -21, 33, -22, 33,
-22, 33, -24, 32, -24, 31, -26, 30, -27, 29, -27, 27, -27, 26, -29, 24, -28, 23,
-29, 21, -30, 20, -30, 19, -31, 17, -32, 17, -32, 15, -33, 14, -33, 12, -34, 12,
-34, 10, -35, 9, -34, 9, -36, 6, -36, 6, -37, 5, -37, 3, -37, 2, -37, 1, -38, 1,
-38, 0, -38, -1, -39, -2, -39, -3, -39, -4, -40, -5, -40, -6, -40, -7, -40, -7,
-41, -7, -40, -7, -41, -9, -40, -10, -41, -11, -41, -11, -42, -12, -42, -12,
-42, -12, -42, -14, -42, -14, -41, -13, -42, -14, -43, -15, -42, -16, -42, -15,
-42, -17, -42, -16, -42, -17, -42, -17, -42, -18, -42, -18, -43, -18, -43, -19,
-43, -19, -44, -19, -42, -18, -43, -19, -43, -19, -42, -20, -42, -20, -42, -21,
-42, -20, -42, -20, -43, -21, -42, -21, -41, -21, -42, -21, -41, -21, -41, -22,
-43, -21, -42, -21, -41, -21, -41, -21, -41, -21, -41, -21, -41, -21, -41, -21,
-41, -21, -40, -22, -40, -21, -40, -21, -39, -20, -39, -20, -40, -21, -40, -21,
-39, -21, -39, -20, -39, -20, -38, -21, -39, -21, -38, -19, -38, -20, -37, -20,
-38, -20, -36, -19, -36, -19, -36, -19, -36, -20, -36, -18, -35, -19, -35, -19,
-34, -18, -33, -18, -34, -18, -33, -18, -33, -18, -32, -17, -32, -17, -31, -17,
-31, -16, -31, -17, -30, -16, -30, -16, -29, -16, -29, -15, -28, -16, -28, -14,
-28, -15, -28, -14, -26, -14, -26, -14, -26, -14, -25, -13, -25, -13, -24, -13,
-24, -13, -24, -13, -23, -12, -22, -11, -22, -11, -21, -11, -21, -11, -21, -11,
-19, -10, -20, -9, -18, -11, -18, -9, -17, -9, -17, -8, -17, -8, -16, -9, -15,
-8, -15, -7, -15, -7, -15, -7, -13, -6, -13, -6, -12, -6, -12, -5, -11, -5, -10,
-5, -10, -5, -9, -4, -9, -4, -8, -4, -7, -4, -7, -4, -6, -4, -6, -3, -6, -2, -4,
-2, -4, -2, -3, -2, -2, -1, -2, -1, -2, -1, -2, 0, 0, 0, -1, 1, 1, 1, 1, 1, 1,
0, 2, 2, 3, 2, 4, 2, 4, 2, 5, 3, 5, 3, 6, 3, 6, 4, 7, 5, 7, 4, 9, 5, 9, 4, 9, 5,
10, 5, 11, 6, 10, 6, 12, 7, 12, 7, 13, 8, 13, 8, 14, 9, 14, 7, 15, 8, 15, 8, 16,
8, 16, 9, 16, 10, 17, 10, 18, 10, 18, 10, 19, 11, 19, 11, 20, 11, 21, 11, 22,
13, 22, 13, 22, 13, 23, 12, 23, 13, 24, 13, 25, 13, 25, 13, 25, 14, 26, 15, 27,
14, 27, 15, 28, 16, 28, 15, 28, 16, 29, 17, 29, 16, 29, 16, 29, 17, 31, 16, 31,
17, 31, 18, 31, 18, 32, 17, 33, 17, 33, 18, 34, 19, 34, 19, 34, 18, 35, 19, 35,
19, 36, 19, 36, 20, 37, 19, 36, 19, 37, 20, 37, 20, 37, 20, 37, 20, 38, 21, 38,
20, 39, 20, 39, 20, 39, 21, 39, 21, 39, 20, 39, 21, 39, 21, 40, 21, 40, 21, 40,
21, 40, 21, 41, 21, 41, 22, 41, 21, 40, 21, 42, 20, 41, 21, 42, 21, 41, 22, 42,
21, 41, 21, 42, 21, 42, 21, 42, 21, 42, 20, 42, 21, 42, 20, 42, 20, 43, 20, 42,
19, 43, 20, 43, 19, 43, 20, 42, 19, 43, 18, 43, 18, 43, 19, 43, 18, 43, 17, 42,
17, 42, 17, 42, 16, 42, 17, 42, 16, 42, 15, 43, 15, 42, 15, 42, 14, 42, 14, 43,
13, 42, 13, 42, 11, 42, 11, 42, 10, 41, 10, 41, 10, 42, 8, 41, 8, 41, 8, 40, 7,
41, 6, 40, 6, 40, 5, 40, 4, 40, 3, 39, 2, 38, 1, 38, 0, 38, -1, 38, -2, 38, -3,
38, -5, 37, -4, 37, -5, 37, -7, 36, -8, 35, -9, 34, -11, 35, -11, 34, -12, 34,
-14, 34, -15, 32, -16, 32, -18, 32, -20, 31, -20, 30, -23, 30, -24, 29, -25, 28,
-26, 28, -27, 27, -28, 26, -30, 26, -31, 25, -32, 25, -33, 24, -34, 24, -35, 22,
-35, 21, -35, 21, -36, 20, -36, 19, -36, 19, -37, 17, -37, 16, -36, 15, -36, 15,
-34, 16, -35, 15, -34, 14, -33, 13, -30, 16, -29, 15, -27, 14, -25, 13, -23, 16,
-19, 17, -15, 18, -13, 16, -8, 20, -3, 19, };