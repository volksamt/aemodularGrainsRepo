#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0070

const PROGMEM int8_t DATA[DATA_LENGTH] = {-11, -4, -104, -92, -119, -108, -105,
-94, -96, -87, -84, -81, -77, -84, -68, -84, -63, -92, -56, -97, -53, -103, -49,
-106, -48, -111, -45, -110, -46, -110, -45, -107, -45, -106, -44, -104, -44,
-105, -42, -105, -41, -108, -41, -110, -40, -112, -39, -114, -38, -115, -38,
-115, -37, -115, -37, -114, -38, -112, -39, -109, -39, -106, -40, -105, -40,
-103, -41, -103, -41, -102, -42, -104, -42, -105, -44, -106, -44, -107, -44,
-107, -45, -107, -47, -107, -47, -105, -47, -103, -49, -102, -50, -101, -51,
-100, -52, -99, -53, -98, -54, -97, -54, -97, -55, -97, -56, -97, -57, -97, -57,
-97, -58, -97, -59, -95, -59, -94, -59, -92, -60, -91, -61, -90, -61, -89, -62,
-88, -61, -87, -62, -87, -63, -86, -62, -85, -62, -85, -61, -84, -62, -82, -62,
-81, -61, -81, -60, -80, -61, -78, -60, -77, -59, -76, -58, -74, -59, -73, -58,
-73, -57, -72, -56, -71, -55, -69, -54, -68, -54, -68, -53, -66, -51, -65, -50,
-64, -51, -62, -55, -60, -53, -59, -52, -58, -49, -57, -48, -56, -46, -55, -43,
-54, -41, -52, -39, -52, -38, -51, -36, -49, -35, -48, -33, -48, -31, -47, -30,
-46, -28, -43, -28, -42, -27, -42, -25, -41, -24, -40, -22, -39, -22, -38, -21,
-37, -20, -36, -18, -35, -17, -34, -16, -32, -15, -32, -15, -30, -13, -29, -13,
-29, -12, -28, -11, -27, -11, -26, -10, -25, -10, -25, -9, -24, -9, -22, -8,
-21, -7, -22, -7, -20, -6, -19, -6, -18, -6, -18, -6, -17, -5, -16, -6, -15, -5,
-16, -5, -14, -5, -14, -5, -12, -4, -12, -4, -12, -4, -11, -3, -10, -4, -10, -3,
-9, -4, -8, -4, -7, -3, -7, -4, -7, -4, -6, -4, -5, -3, -5, -4, -4, -5, -4, -3,
-3, -4, -2, -4, -2, -4, -2, -4, -1, -4, -1, -3, 0, -3, 1, -3, 2, -3, 2, -3, 3,
-3, 2, -2, 3, -2, 4, -3, 5, -3, 4, -2, 5, -2, 6, -2, 7, -2, 7, -2, 8, -1, 9, -2,
8, -1, 10, 0, 10, -1, 10, 0, 10, 1, 11, 1, 10, 1, 12, 1, 12, 3, 12, 3, 13, 3,
13, 3, 13, 4, 14, 4, 15, 5, 14, 5, 15, 5, 16, 6, 16, 7, 17, 7, 18, 9, 18, 7, 18,
12, 18, -19, 23, -49, 27, -37, 26, -30, 25, -20, 24, -13, 24, -7, 23, -2, 23, 2,
24, 6, 24, 9, 23, 11, 24, 13, 23, 15, 24, 16, 23, 18, 24, 19, 24, 21, 24, 20,
25, 22, 25, 22, 25, 23, 25, 23, 26, 23, 26, 23, 27, 25, 27, 24, 26, 24, 28, 25,
27, 25, 27, 26, 27, 25, 28, 25, 28, 25, 28, 26, 28, 25, 29, 25, 29, 26, 29, 25,
30, 25, 30, 25, 29, 25, 30, 25, 30, 24, 30, 25, 30, 25, 30, 25, 31, 25, 30, 25,
31, 25, 31, 24, 32, 24, 32, 23, 32, 24, 31, 23, 32, 24, 32, 24, 32, 23, 32, 24,
33, 23, 33, 23, 32, 23, 33, 22, 33, 22, 33, 22, 33, 23, 33, 23, 33, 23, 34, 22,
34, 22, 34, 22, 35, 22, 33, 17, 10, 16, 6, 18, 17, 20, 26, 22, 36, 23, 41, 24,
46, 24, 48, 26, 50, 24, 48, 25, 48, 24, 45, 23, 42, 23, 39, 22, 39, 20, 37, 19,
35, 20, 33, 19, 33, 19, 33, 20, 33, 21, 33, 21, 34, 21, 35, 21, 35, 22, 36, 22,
36, 23, 37, 22, 37, 23, 38, 23, 38, 23, 38, 23, 38, 24, 38, 23, 38, 23, 37, 23,
37, 23, 37, 22, 36, 23, 36, 23, 36, 24, 37, 24, 37, 23, 37, 23, 36, 24, 37, 23,
37, 23, 37, 23, 37, 23, 37, 23, 38, 24, 37, 24, 36, 23, 37, 23, 38, 23, 37, 23,
37, 23, 36, 23, 36, 23, 37, 23, 37, 23, 38, 24, 37, 23, 37, 23, 37, 22, 37, 23,
37, 23, 37, 23, 37, 23, 37, 22, 37, 23, 37, 23, 36, 23, 36, 22, 36, 21, 37, 22,
36, 23, 36, 23, 36, 21, 36, 22, 36, 21, 36, 22, 36, 21, 36, 22, 36, 22, 36, 21,
36, 21, 35, 21, 36, 21, 35, 22, 36, 21, 36, 21, 36, 21, 35, 21, 35, 21, 35, 20,
35, 20, 35, 21, 35, 21, 35, 20, 35, 20, 35, 20, 35, 20, 35, 20, 35, 19, 34, 20,
34, 20, 34, 20, 35, 20, 35, 21, 34, 20, 34, 20, 34, 20, 34, 20, 33, 19, 34, 20,
34, 19, 34, 19, 34, 20, 33, 20, 34, 20, 33, 20, 34, 20, 33, 20, 34, 20, 33, 20,
33, 18, 33, 3, 35, -1, 35, 3, 34, 6, 35, 9, 34, 11, 33, 13, 33, 14, 33, 16, 32,
17, 33, 18, 32, 19, 32, 19, 32, 19, 32, 20, 31, 20, 31, 20, 31, 21, 31, 21, 32,
21, 31, 21, 31, 20, 31, 21, 30, 21, 31, 20, 30, 21, 30, 21, 31, 21, 29, 21, 30,
21, 29, 20, 31, 21, 29, 21, 30, 21, 29, 20, 30, 21, 29, 20, 29, 20, 29, 20, 29,
20, 28, 20, 28, 20, 28, 19, 28, 19, 28, 19, 28, 19, 27, 19, 28, 19, 27, 19, 29,
19, 27, 19, 28, 19, 27, 19, 28, 18, 27, 18, 27, 18, 27, 18, 27, 17, 27, 18, 26,
17, 27, 18, 26, 18, 27, 17, 26, 17, 25, 17, 26, 17, 26, 17, 25, 17, 25, 17, 25,
16, 25, 16, 25, 16, 25, 16, 25, 16, 25, 16, 24, 16, 24, 16, 24, 16, 25, 16, 24,
16, 24, 15, 24, 15, 24, 15, 23, 15, 24, 15, 24, 15, 24, 14, 24, 14, 24, 13, 23,
13, 23, 13, 23, 14, 22, 14, 22, 15, 23, 14, 23, 14, 23, 14, 23, 13, 21, 13, 23,
13, 21, 14, 22, 13, 21, 14, 22, 13, 20, 14, 22, 13, 21, 14, 23, 13, 20, 14, 22,
12, 19, 13, 21, 13, 20, };