#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0161

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 3, 3, 5, 5, 6, 6, 8, 6, 11,
7, 13, 9, 15, 10, 16, 11, 17, 12, 19, 13, 21, 15, 24, 16, 25, 16, 27, 18, 28,
19, 31, 20, 31, 21, 33, 21, 35, 23, 36, 23, 39, 25, 39, 25, 41, 26, 43, 27, 44,
28, 45, 29, 47, 30, 48, 31, 49, 32, 51, 32, 51, 33, 53, 33, 54, 35, 56, 36, 56,
36, 58, 37, 60, 38, 60, 39, 62, 39, 63, 40, 64, 41, 64, 41, 66, 42, 67, 42, 67,
42, 68, 43, 69, 44, 71, 44, 71, 46, 72, 46, 72, 46, 74, 47, 75, 48, 75, 48, 76,
48, 77, 49, 78, 49, 78, 51, 79, 51, 80, 50, 81, 51, 82, 51, 81, 52, 82, 51, 83,
52, 83, 53, 83, 54, 85, 54, 86, 54, 85, 54, 86, 54, 87, 55, 87, 55, 87, 55, 88,
56, 88, 57, 89, 57, 89, 57, 89, 56, 90, 56, 90, 56, 91, 57, 91, 58, 91, 57, 91,
58, 92, 58, 92, 59, 93, 59, 93, 60, 93, 59, 93, 59, 93, 59, 93, 60, 94, 59, 94,
61, 95, 60, 95, 60, 95, 59, 95, 60, 95, 60, 95, 61, 95, 60, 96, 61, 97, 60, 96,
61, 96, 62, 96, 62, 97, 62, 97, 62, 96, 62, 97, 63, 98, 63, 98, 64, 98, 65, 99,
65, 99, 66, 100, 66, 99, 67, 100, 68, 101, 68, 101, 70, 101, 71, 101, 71, 102,
72, 102, 73, 103, 75, 103, 75, 103, 76, 105, 76, 105, 79, 104, 79, 105, 80, 106,
81, 107, 82, 107, 83, 108, 85, 108, 86, 108, 87, 109, 88, 110, 89, 110, 90, 112,
92, 113, 93, 113, 94, 113, 95, 113, 97, 114, 98, 115, 98, 116, 100, 115, 101,
116, 103, 117, 104, 118, 105, 118, 106, 118, 107, 119, 109, 119, 108, 118, 109,
119, 110, 118, 112, 119, 111, 119, 112, 118, 113, 118, 114, 118, 114, 117, 115,
117, 115, 116, 115, 116, 115, 114, 115, 114, 116, 113, 116, 111, 116, 110, 116,
110, 115, 108, 115, 107, 115, 106, 114, 104, 114, 103, 114, 101, 114, 99, 113,
99, 112, 96, 112, 95, 111, 92, 109, 91, 108, 89, 107, 87, 106, 85, 104, 82, 104,
81, 102, 78, 100, 76, 99, 73, 96, 71, 95, 69, 94, 67, 91, 65, 90, 61, 88, 59,
86, 57, 84, 54, 82, 53, 81, 52, 79, 49, 77, 46, 75, 45, 73, 43, 71, 42, 68, 40,
66, 38, 65, 38, 63, 36, 62, 34, 60, 33, 58, 31, 56, 31, 55, 30, 53, 28, 52, 28,
49, 27, 48, 26, 47, 25, 45, 24, 43, 23, 41, 22, 40, 22, 38, 22, 37, 21, 35, 20,
34, 21, 33, 20, 32, 21, 31, 20, 30, 20, 28, 20, 26, 19, 25, 20, 24, 19, 23, 19,
22, 19, 21, 18, 20, 18, 18, 20, 17, 19, 16, 19, 16, 19, 14, 19, 13, 20, 12, 19,
10, 19, 10, 19, 8, 18, 7, 19, 6, 18, 5, 18, 4, 17, 3, 17, 1, 16, 0, 16, -2, 15,
-3, 14, -4, 14, -5, 12, -7, 11, -8, 10, -10, 10, -11, 9, -13, 7, -14, 6, -15, 5,
-17, 3, -18, 2, -19, 1, -21, -1, -22, -1, -24, -4, -26, -5, -27, -6, -28, -8,
-30, -9, -31, -10, -32, -12, -35, -13, -35, -15, -36, -16, -38, -18, -39, -20,
-42, -22, -42, -23, -43, -25, -44, -27, -46, -28, -48, -29, -48, -32, -50, -32,
-50, -34, -52, -35, -54, -37, -55, -39, -56, -40, -57, -42, -58, -43, -59, -45,
-60, -46, -61, -47, -62, -49, -63, -50, -64, -52, -65, -53, -66, -55, -66, -56,
-68, -57, -69, -58, -69, -60, -71, -61, -71, -63, -72, -63, -72, -65, -74, -66,
-74, -66, -74, -69, -76, -70, -76, -70, -77, -71, -77, -73, -78, -74, -78, -75,
-79, -75, -79, -77, -80, -77, -80, -78, -81, -79, -82, -81, -81, -81, -82, -82,
-82, -83, -82, -83, -84, -85, -83, -85, -84, -86, -84, -87, -84, -87, -84, -88,
-85, -88, -85, -89, -84, -89, -86, -90, -86, -92, -86, -91, -86, -92, -86, -92,
-86, -93, -87, -93, -87, -94, -87, -95, -86, -95, -86, -95, -87, -96, -86, -96,
-87, -97, -87, -97, -87, -97, -86, -99, -86, -99, -86, -98, -86, -99, -87, -100,
-87, -99, -85, -101, -87, -99, -86, -100, -86, -101, -85, -101, -85, -100, -85,
-101, -86, -101, -85, -101, -85, -101, -85, -102, -85, -102, -84, -102, -84,
-102, -84, -103, -84, -103, -84, -103, -83, -102, -83, -102, -83, -102, -83,
-102, -83, -103, -83, -102, -82, -103, -82, -103, -82, -103, -81, -102, -81,
-103, -81, -103, -80, -103, -80, -103, -80, -103, -80, -103, -80, -102, -79,
-103, -79, -103, -79, -103, -78, -103, -78, -104, -78, -103, -77, -102, -77,
-102, -76, -102, -77, -102, -76, -102, -76, -103, -76, -103, -75, -102, -75,
-102, -76, -102, -75, -102, -74, -101, -74, -102, -73, -101, -74, -101, -74,
-101, -73, -102, -72, -101, -73, -101, -72, -100, -72, -101, -71, -101, -71,
-100, -71, -101, -70, -100, -70, -100, -69, -100, -70, -99, -69, -99, -68, -99,
-68, -100, -68, -99, -69, -99, -68, -98, -67, -99, -67, -99, -67, -98, -67, -99,
-66, -98, -66, -98, -66, -98, -66, -97, -65, -97, -65, -98, -65, -97, -64, -97,
-63, -96, -63, -95, -63, -95, -62, -95, -61, -93, -61, -92, -60, -92, -60, -91,
-58, -90, -57, -89, -57, -88, -56, -86, -54, -85, -54, -84, -53, -82, -51, -81,
-51, -79, -50, -78, -49, -76, -47, -73, -46, -72, -45, -71, -44, -69, -43, -67,
-42, -64, -40, -63, -38, -61, -37, -58, -35, -57, -35, -54, -34, -53, -32, -49,
-30, -49, -29, -45, -28, -44, -26, -42, -25, -39, -24, -36, -23, -36, -21, -33,
-20, -31, -18, -28, -17, -26, -15, -24, -14, -22, -13, -20, -11, -18, -10, -15,
-8, -13, -7, -12, -6, -9, -5, -7, -3, -5, -2, -3, -1, 0, };