#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 26, 12, 37, 16, 37, 16, 38, 17, 37,
21, 42, 23, 43, 23, 44, 23, 41, 24, 42, 25, 43, 25, 44, 25, 42, 25, 43, 25, 43,
25, 44, 25, 43, 25, 42, 24, 43, 24, 43, 25, 43, 25, 44, 25, 43, 25, 44, 25, 44,
25, 45, 26, 44, 26, 44, 27, 46, 26, 45, 28, 46, 27, 46, 28, 46, 29, 46, 30, 48,
29, 48, 30, 48, 30, 48, 32, 49, 33, 49, 33, 51, 34, 50, 35, 52, 36, 51, 38, 53,
37, 53, 39, 54, 39, 54, 42, 56, 40, 54, 46, 60, 1, 10, -99, -99, -87, -72, -57,
-9, -45, 22, -23, 48, -27, 29, -22, 13, -11, 14, 13, 36, 29, 49, 38, 50, 43, 48,
55, 59, 66, 72, 73, 77, 74, 75, 76, 73, 78, 78, 83, 82, 83, 82, 82, 78, 82, 78,
83, 80, 85, 82, 84, 79, 83, 77, 83, 76, 83, 77, 83, 76, 83, 75, 81, 74, 81, 74,
80, 75, 81, 74, 80, 73, 80, 72, 80, 72, 80, 73, 80, 72, 80, 72, 80, 72, 81, 72,
81, 73, 82, 73, 81, 73, 82, 73, 83, 73, 84, 73, 84, 73, 86, 74, 86, 75, 88, 75,
88, 75, 88, 73, 79, 63, 72, 55, 65, 50, 57, 43, 51, 41, 42, 33, 35, 29, 24, 19,
20, 18, -8, -11, -8, -7, 7, 15, -1, 8, 8, 16, 6, 10, 9, 9, 10, 8, 19, 15, 23,
17, 27, 19, 30, 19, 35, 22, 39, 25, 43, 29, 46, 28, 48, 29, 51, 31, 53, 32, 56,
33, 58, 33, 59, 34, 61, 34, 63, 36, 63, 35, 65, 35, 64, 34, 68, 37, 66, 34, 72,
39, -20, -60, -73, -109, -57, -77, -67, -69, -60, -47, -69, -54, -78, -70, -86,
-85, -83, -82, -81, -77, -78, -76, -80, -82, -78, -82, -74, -77, -69, -69, -68,
-70, -68, -73, -66, -73, -64, -68, -61, -66, -62, -68, -63, -70, -62, -70, -61,
-69, -55, -61, 51, 54, 112, 116, 95, 77, 102, 59, 98, 34, 103, 38, 114, 61, 119,
77, 116, 73, 110, 61, 106, 58, 106, 62, 101, 62, 93, 50, 83, 39, 78, 36, 76, 38,
69, 34, 61, 27, 55, 22, 52, 21, 49, 22, 44, 20, 39, 15, 35, 13, 33, 14, 32, 15,
27, 12, 25, 10, 23, 11, 23, 12, 22, 12, 19, 11, 19, 10, 19, 11, 18, 13, 18, 13,
19, 12, 19, 14, 20, 14, 21, 15, 20, 15, 22, 16, 23, 17, 24, 18, 25, 19, 26, 19,
28, 21, 29, 21, 30, 23, 32, 24, 34, 25, 36, 25, 38, 27, 39, 27, 41, 28, 42, 28,
44, 31, 45, 31, 48, 32, 50, 33, 52, 34, 54, 35, 54, 33, 46, 23, 39, 15, 31, 10,
25, 4, 20, 0, 11, -7, 5, -10, -6, -21, -7, -19, -66, -86, -98, -118, -74, -77,
-71, -61, -57, -38, -54, -39, -54, -50, -51, -57, -37, -48, -24, -35, -15, -30,
-9, -30, -1, -27, 8, -17, 16, -9, 21, -8, 23, -11, 21, -13, 18, -18, 16, -20,
10, -27, 3, -31, -3, -36, -7, -39, -15, -45, -23, -51, -29, -57, -36, -61, -42,
-66, -48, -71, -54, -77, -61, -81, -66, -86, -65, -83, -60, -75, -57, -71, -51,
-67, -47, -65, -42, -62, -35, -59, -29, -54, -22, -48, -15, -44, -10, -41, -5,
-36, 0, -32, 7, -28, 10, -25, 13, -23, 17, -20, 19, -16, 23, -14, 26, -11, 28,
-9, 30, -8, 33, -5, 35, -3, 34, -5, 29, -9, 29, -10, 24, -11, 22, -10, 18, -13,
17, -12, -15, -44, -71, -102, -59, -80, -48, -51, -44, -37, -37, -29, -43, -40,
-42, -48, -40, -47, -31, -38, -27, -34, -25, -34, -25, -35, -20, -30, -17, -24,
-16, -23, -17, -25, -18, -25, -17, -23, -17, -22, -17, -22, -19, -24, -20, -24,
-20, -23, -21, -21, -22, -23, -23, -24, -24, -24, -24, -24, -25, -23, -25, -24,
-26, -25, -27, -24, -27, -24, -27, -24, -29, -24, -28, -24, -29, -24, -29, -23,
-29, -23, -29, -23, -29, -23, -29, -23, -28, -22, -29, -22, -29, -22, -28, -21,
-28, -22, -28, -21, -28, -21, -28, -20, -27, -20, -27, -19, -26, -19, -27, -19,
-26, -19, -25, -18, -25, -18, -24, -17, -24, -16, -24, -17, -23, -16, -23, -16,
-22, -15, -22, -15, -22, -15, -20, -14, -22, -13, -21, -13, -19, -13, -18, -13,
-19, -13, -17, -11, -18, -12, -17, -11, -18, -11, -16, -10, -16, -10, -15, -9,
-15, -10, -15, -8, -15, -9, -14, -8, -14, -7, -12, -7, -14, -7, -12, -6, -12,
-6, -11, -5, -11, -4, -10, -5, -10, -4, -10, -5, -10, -4, -76, -78, -104, -104,
-91, -77, -97, -69, -91, -51, -98, -59, -102, -69, -106, -78, -101, -73, -98,
-67, -95, -66, -95, -69, -92, -68, -88, -62, -82, -56, -80, -56, -79, -56, -76,
-54, -73, -49, -70, -47, -70, -47, -68, -47, -67, -47, -66, -44, -59, -36, 3,
31, 33, 59, 22, 32, 26, 24, 23, 11, 27, 15, 34, 27, 37, 36, 34, 33, 29, 27, 26,
25, 24, 28, 22, 27, 16, 21, 10, 15, 7, 14, 5, 16, 1, 14, -3, 10, -6, 7, -8, 8,
-10, 9, -13, 7, -15, 4, -18, 4, -17, 5, -20, 5, -21, 5, -23, 3, -24, 3, -25, 4,
-25, 3, -26, 4, -26, 4, -27, 5, -26, 4, -27, 5, -27, 5, -27, 5, -28, 6, -27, 7,
-26, 7, -27, 8, -26, 8, -26, 9, -26, 10, -25, 10, -25, 10, -24, 11, -24, 12,
-24, 12, -22, 12, -23, 13, -21, 15, -21, 13, -20, 15, -20, 16, -19, 16, -19, 16,
-19, 16, -17, 17, -16, 17, -16, 17, -15, 17, -15, 19, -14, 18, -13, 20, -13, 19,
-12, 21, -13, 19, -11, 22, -12, 18, -9, 23, -56, -33, -92, -70, -68, -30, -59,
-6, -47, 12, -42, 16, -40, 6, -38, 2, -28, 7, -16, 19, -9, 20, -5, 23, -1, 20,
};