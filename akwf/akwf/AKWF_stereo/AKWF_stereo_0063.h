#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0063

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 44, 5, 55, 8, 53, 11, 60, 15, 58,
18, 63, 22, 64, 25, 68, 30, 69, 33, 71, 35, 73, 39, 76, 43, 76, 46, 78, 50, 80,
52, 82, 56, 82, 59, 84, 62, 85, 66, 87, 68, 89, 71, 90, 75, 92, 78, 92, 80, 94,
83, 95, 85, 97, 88, 98, 90, 99, 92, 100, 94, 100, 97, 102, 99, 103, 101, 104,
103, 104, 105, 105, 107, 106, 108, 107, 109, 108, 111, 109, 112, 109, 114, 110,
114, 110, 115, 111, 116, 111, 116, 111, 117, 111, 118, 112, 119, 111, 118, 113,
120, 113, 119, 113, 118, 112, 119, 113, 118, 112, 118, 113, 118, 112, 118, 112,
117, 112, 116, 112, 116, 111, 115, 111, 113, 112, 112, 110, 111, 110, 110, 110,
108, 109, 107, 109, 106, 108, 104, 107, 101, 107, 100, 106, 98, 105, 96, 105,
93, 103, 91, 102, 90, 101, 87, 100, 84, 100, 82, 98, 79, 97, 77, 96, 74, 95, 71,
93, 67, 92, 65, 91, 61, 90, 58, 88, 55, 87, 53, 86, 49, 84, 46, 83, 42, 81, 38,
79, 35, 77, 32, 76, 29, 72, 26, 71, 22, 68, 18, 67, 16, 62, 13, 61, 10, 56, 8,
53, 6, 47, 3, 44, 8, 25, 18, -10, 17, -17, 16, -24, 13, -28, 11, -32, 8, -34, 6,
-37, 3, -40, -1, -42, -2, -44, -5, -46, -8, -47, -10, -50, -12, -50, -14, -53,
-17, -54, -20, -56, -22, -56, -23, -58, -25, -59, -28, -60, -29, -61, -32, -62,
-33, -62, -35, -64, -37, -65, -38, -66, -39, -67, -41, -67, -43, -67, -44, -68,
-44, -70, -46, -70, -47, -72, -48, -71, -50, -71, -51, -72, -52, -73, -52, -74,
-53, -75, -54, -76, -54, -76, -55, -76, -55, -77, -57, -78, -57, -78, -58, -79,
-58, -79, -58, -79, -58, -81, -60, -81, -60, -81, -59, -82, -60, -82, -61, -83,
-61, -83, -61, -84, -62, -83, -62, -85, -62, -85, -63, -86, -64, -87, -63, -86,
-63, -87, -63, -88, -64, -88, -64, -88, -64, -89, -64, -89, -64, -89, -64, -90,
-64, -90, -65, -90, -66, -91, -66, -92, -66, -92, -65, -92, -66, -93, -66, -93,
-66, -93, -66, -93, -66, -94, -67, -94, -67, -94, -68, -95, -67, -95, -67, -95,
-67, -96, -68, -96, -68, -96, -68, -96, -67, -96, -67, -96, -68, -97, -67, -96,
-68, -96, -68, -97, -68, -96, -67, -97, -67, -97, -68, -97, -68, -97, -67, -97,
-67, -97, -66, -96, -65, -96, -65, -96, -64, -95, -64, -95, -64, -95, -63, -94,
-62, -94, -61, -94, -61, -93, -59, -93, -59, -92, -58, -91, -57, -91, -55, -90,
-54, -89, -53, -88, -51, -88, -50, -87, -49, -86, -46, -85, -46, -83, -44, -82,
-43, -83, -40, -80, -37, -79, -36, -78, -34, -76, -32, -75, -30, -74, -28, -72,
-24, -70, -22, -68, -20, -66, -17, -63, -15, -60, -13, -58, -11, -55, -8, -52,
-6, -47, -3, -43, -3, -36, -1, -29, -13, 7, -17, 26, -14, 27, -12, 35, -9, 38,
-7, 44, -3, 46, 0, 50, 4, 51, 7, 55, 10, 56, 14, 59, 17, 61, 20, 64, 24, 64, 27,
67, 31, 69, 34, 71, 37, 72, 40, 74, 44, 77, 47, 78, 50, 79, 53, 81, 56, 82, 59,
84, 62, 85, 65, 85, 67, 88, 70, 89, 73, 90, 75, 91, 77, 92, 80, 93, 81, 94, 84,
95, 85, 95, 88, 97, 90, 98, 92, 98, 92, 99, 95, 100, 96, 100, 97, 101, 98, 102,
100, 103, 101, 102, 101, 103, 102, 104, 102, 104, 103, 104, 104, 104, 104, 103,
104, 104, 104, 104, 104, 104, 104, 105, 104, 104, 103, 104, 103, 105, 103, 104,
102, 105, 101, 104, 101, 104, 100, 103, 99, 103, 97, 102, 95, 102, 95, 101, 94,
100, 92, 100, 89, 100, 89, 98, 87, 98, 84, 97, 82, 97, 80, 96, 79, 95, 76, 94,
73, 93, 71, 92, 68, 91, 66, 90, 64, 89, 60, 87, 57, 85, 55, 85, 52, 84, 49, 83,
46, 80, 43, 79, 39, 76, 36, 75, 33, 74, 31, 72, 27, 68, 24, 67, 21, 64, 18, 63,
15, 60, 11, 57, 9, 53, 6, 49, 5, 43, 3, 37, 5, 23, 16, -12, 16, -23, 14, -27,
11, -32, 9, -35, 7, -38, 3, -40, 2, -43, -2, -45, -4, -47, -7, -48, -10, -51,
-12, -52, -15, -54, -18, -55, -19, -58, -22, -58, -24, -59, -27, -61, -28, -62,
-30, -63, -33, -64, -35, -65, -37, -66, -38, -67, -41, -67, -42, -68, -43, -69,
-45, -70, -47, -71, -47, -72, -50, -72, -51, -74, -51, -73, -52, -75, -53, -75,
-54, -76, -56, -77, -56, -77, -57, -78, -58, -78, -58, -78, -60, -78, -61, -80,
-61, -80, -61, -81, -62, -81, -62, -81, -63, -81, -63, -82, -64, -82, -64, -83,
-64, -83, -64, -83, -64, -85, -65, -84, -64, -85, -65, -86, -65, -86, -65, -86,
-66, -87, -65, -87, -65, -87, -65, -88, -65, -87, -66, -88, -65, -89, -66, -89,
-66, -89, -66, -89, -65, -90, -65, -91, -65, -90, -66, -92, -65, -91, -66, -91,
-66, -91, -65, -92, -66, -92, -65, -92, -65, -93, -65, -92, -65, -92, -65, -93,
-65, -93, -65, -94, -65, -94, -65, -94, -65, -93, -64, -95, -65, -94, -64, -94,
-64, -94, -65, -95, -64, -94, -63, -95, -64, -95, -64, -95, -63, -95, -64, -95,
-64, -95, -63, -95, -63, -94, -62, -94, -62, -94, -61, -94, -61, -94, -61, -94,
-60, -94, -59, -93, -58, -93, -57, -93, -56, -92, -56, -92, -56, -92, -55, -91,
-54, -90, -53, -90, -51, -88, -51, -88, -49, -87, -48, -87, -47, -86, -46, -84,
-43, -84, -42, -83, -40, -82, -39, -80, -36, -79, -35, -78, -33, -77, -32, -75,
-29, -74, -27, -72, -25, -70, -23, -69, -20, -66, -18, -65, -15, -62, -14, -59,
-11, -57, -9, -53, -8, -42, -4, -35, -3, -25, -12, 4, -15, 22, -13, 26, -13, 35,
-10, 35, -7, 45, -4, 38, };