#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0127

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, -23, 5, -25, 6, -22, 8, -23, 8,
-14, 11, -9, 11, -9, 14, -7, 23, -5, 24, -3, 24, 1, 24, 9, 24, 5, 26, 6, 28, 9,
33, 11, 41, 14, 45, 13, 48, 16, 50, 20, 55, 25, 59, 29, 65, 32, 75, 35, 74, 48,
76, 54, 77, 61, 76, 68, 76, 69, 73, 71, 73, 73, 70, 78, 70, 79, 69, 83, 71, 84,
72, 89, 75, 95, 76, 90, 85, 92, 93, 97, 96, 99, 112, 104, 118, 104, 119, 105,
117, 103, 115, 103, 113, 102, 110, 104, 106, 101, 109, 101, 105, 101, 98, 106,
98, 110, 92, 104, 90, 102, 85, 100, 80, 97, 74, 94, 71, 91, 67, 100, 64, 98, 60,
96, 56, 92, 56, 91, 48, 94, 48, 86, 45, 82, 43, 77, 41, 73, 38, 67, 35, 63, 31,
58, 27, 57, 25, 48, 22, 39, 20, 32, 16, 21, 19, 19, 25, 12, 29, 13, 24, 11, 19,
5, 18, 1, 18, -1, 12, -2, 1, -2, -1, -4, -10, -3, -11, -3, -11, -3, -14, -2,
-16, -3, -18, -1, -19, 1, -18, -1, -11, -1, -12, -12, -7, -17, -4, -12, -1, -10,
-1, -16, -1, -18, 0, -19, 1, -21, 6, -19, 8, -19, 11, -18, 4, -20, -5, -23, -7,
-26, -9, -25, -11, -22, 2, -19, 3, -20, -8, -21, -6, -22, -9, -21, -9, -19, -10,
-17, -9, -14, -10, -20, -8, -27, -6, -25, -3, -25, -2, -21, -2, -19, 0, -10, 3,
-3, 13, -2, 17, 1, 20, 11, 21, 15, 24, 13, 27, 18, 20, 20, 21, 23, 20, 25, 20,
26, 20, 29, 21, 31, 25, 35, 27, 38, 34, 40, 33, 43, 29, 46, 29, 50, 29, 56, 28,
60, 26, 53, 33, 44, 27, 44, 21, 40, 20, 38, 13, 33, 11, 29, 5, 27, 1, 26, -3,
22, -4, 21, -5, 15, -5, 6, -10, 5, -10, -1, -14, -6, -25, -10, -24, -13, -27,
-15, -27, -18, -26, -19, -25, -21, -25, -21, -24, -19, -25, -19, -28, -21, -30,
-21, -28, -24, -31, -26, -39, -27, -40, -28, -41, -31, -42, -43, -42, -48, -42,
-49, -40, -51, -40, -50, -40, -51, -41, -52, -41, -52, -43, -53, -43, -53, -44,
-55, -46, -56, -47, -57, -47, -53, -48, -54, -49, -60, -51, -60, -64, -61, -68,
-61, -65, -62, -63, -61, -60, -60, -60, -60, -59, -59, -62, -60, -62, -59, -64,
-59, -65, -59, -65, -58, -63, -58, -64, -57, -63, -57, -59, -58, -62, -58, -67,
-59, -65, -70, -66, -76, -64, -78, -62, -81, -62, -82, -64, -82, -64, -80, -64,
-79, -65, -76, -64, -74, -66, -72, -63, -70, -61, -68, -57, -65, -55, -62, -52,
-58, -53, -51, -49, -46, -52, -45, -58, -43, -52, -37, -46, -34, -36, -31, -33,
-30, -27, -29, -20, -24, -16, -22, -11, -18, -9, -16, -7, -13, -2, -9, -1, -11,
-2, -13, -3, -14, -7, -13, -7, -13, -5, -13, -1, -9, 1, -8, 3, -8, 6, -12, 7,
-15, 7, -16, 5, -20, 8, -18, 10, -17, 11, -17, 10, -17, 8, -18, 8, -17, 9, -15,
7, -15, 5, -15, 2, -16, 2, -14, 1, -13, 0, -12, 1, -11, 1, -10, 4, -11, 4, -10,
5, -10, 2, -10, -2, -11, -4, -11, -2, -11, 0, -7, 1, 2, 1, 0, -1, 2, -2, 1, -3,
1, -6, 1, -6, 1, -9, 0, -9, 1, -12, -1, -9, -3, -1, -4, 0, -7, 2, -9, -1, -12,
-4, -13, -9, -15, -11, -16, -14, -20, -13, -22, -14, -25, -16, -21, -19, -11,
-21, -10, -19, -6, -18, -5, -18, -3, -21, -4, -24, -4, -24, -5, -28, -6, -30,
-8, -33, -9, -28, -10, -17, -9, -16, -10, -17, -13, -18, -13, -19, -14, -19,
-13, -17, -12, -14, -7, -15, -7, -18, -8, -17, -7, -14, -7, -9, -1, -7, 5, -3,
8, 4, 12, 7, 14, 9, 15, 11, 16, 13, 16, 15, 16, 17, 17, 17, 18, 19, 20, 21, 22,
21, 22, 31, 24, 37, 23, 41, 25, 45, 26, 52, 32, 61, 38, 66, 43, 70, 44, 70, 45,
71, 44, 71, 45, 70, 43, 69, 44, 67, 41, 64, 44, 61, 51, 60, 50, 59, 51, 58, 50,
57, 51, 56, 51, 56, 51, 54, 51, 54, 50, 53, 50, 53, 51, 53, 53, 54, 57, 51, 59,
50, 60, 57, 59, 57, 57, 58, 58, 58, 56, 55, 53, 51, 51, 46, 50, 42, 49, 38, 47,
36, 42, 34, 41, 35, 42, 36, 43, 37, 40, 39, 40, 37, 37, 34, 42, 33, 45, 30, 43,
27, 41, 23, 37, 18, 32, 16, 31, 10, 26, 1, 20, -6, 16, -11, 13, -15, 13, -18,
12, -24, 8, -26, 5, -27, 7, -30, 9, -21, 9, -18, 9, -23, 8, -28, 3, -33, -1,
-36, -3, -40, -6, -40, -9, -42, -13, -43, -16, -48, -20, -56, -26, -61, -32,
-64, -37, -69, -42, -72, -46, -75, -51, -77, -54, -79, -48, -81, -45, -82, -49,
-83, -49, -83, -52, -80, -54, -78, -46, -77, -42, -75, -44, -75, -42, -71, -41,
-68, -39, -64, -40, -64, -37, -63, -38, -62, -39, -62, -41, -53, -42, -48, -44,
-37, -44, -34, -45, -33, -42, -30, -38, -25, -36, -21, -31, -15, -31, -10, -29,
-8, -30, -5, -20, -4, -15, -3, -14, -1, -11, 0, -9, -1, -7, -1, -7, -1, -5, -2,
-5, -6, -7, -10, -6, -14, -8, -8, -5, -6, -2, -5, 3, -4, 4, -6, 5, -6, 5, -8, 3,
-9, 2, -11, 0, -13, -3, -13, -7, -14, -11, -13, -14, -12, -7, -10, -6, -9, -7,
-9, -8, -9, -10, -9, -13, -12, -16, -16, -18, -21, -21, -24, -24, -27, -28, -29,
-31, -33, -35, -30, -38, -24, -40, -25, -41, -24, -43, -26, -45, -27, -47, -27,
-49, -28, -51, -29, -53, -29, -52, -27, -54, -26, -52, -27, -51, -29, -60, -32,
-60, -33, -54, -31, -49, -28, -51, -22, -47, -17, -44, -13, -35, -9, -34, -3,
-24, };