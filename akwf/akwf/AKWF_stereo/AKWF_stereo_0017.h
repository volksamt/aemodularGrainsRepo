#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 24, 5, 30, 7, 30, 9, 34, 12, 35,
14, 39, 18, 41, 19, 44, 22, 46, 25, 48, 26, 50, 29, 52, 31, 55, 34, 58, 35, 61,
38, 63, 40, 65, 42, 67, 45, 68, 46, 70, 48, 73, 51, 75, 53, 77, 55, 79, 58, 81,
59, 82, 61, 84, 62, 86, 64, 87, 67, 89, 68, 91, 71, 92, 72, 93, 75, 95, 78, 97,
79, 100, 82, 101, 84, 103, 86, 104, 87, 105, 90, 106, 91, 107, 93, 109, 95, 109,
96, 111, 98, 112, 99, 113, 101, 115, 102, 115, 103, 115, 105, 116, 107, 117,
108, 118, 108, 117, 110, 118, 110, 118, 112, 119, 111, 118, 113, 119, 114, 118,
115, 119, 115, 118, 116, 118, 116, 118, 117, 117, 117, 116, 118, 116, 118, 115,
118, 115, 119, 114, 119, 113, 120, 113, 119, 111, 119, 110, 119, 109, 118, 107,
118, 107, 117, 105, 117, 104, 117, 103, 117, 101, 116, 99, 115, 98, 115, 97,
113, 94, 113, 92, 111, 91, 110, 89, 109, 86, 109, 85, 106, 81, 105, 79, 103, 77,
102, 75, 101, 73, 100, 71, 99, 69, 99, 67, 97, 65, 97, 63, 95, 61, 94, 59, 94,
58, 93, 55, 91, 53, 90, 52, 90, 50, 88, 48, 87, 46, 85, 44, 84, 43, 83, 41, 81,
39, 80, 37, 78, 35, 77, 33, 75, 31, 72, 29, 71, 28, 68, 25, 67, 24, 64, 21, 62,
19, 60, 17, 58, 14, 55, 12, 53, 10, 51, 8, 49, 6, 47, 3, 45, 2, 42, 0, 39, -2,
37, -4, 34, -6, 32, -9, 30, -10, 27, -13, 26, -15, 23, -17, 20, -20, 17, -22,
14, -24, 12, -26, 10, -29, 7, -30, 4, -32, 2, -35, 0, -36, -3, -38, -6, -41, -9,
-44, -11, -46, -13, -47, -15, -49, -19, -53, -21, -54, -23, -57, -25, -58, -27,
-60, -29, -62, -31, -63, -33, -65, -35, -66, -37, -68, -38, -71, -40, -71, -41,
-71, -42, -74, -44, -75, -47, -77, -49, -78, -50, -79, -51, -80, -54, -81, -55,
-83, -57, -85, -58, -86, -60, -87, -61, -88, -63, -90, -64, -90, -65, -93, -68,
-93, -70, -94, -71, -95, -72, -97, -73, -98, -75, -99, -77, -100, -79, -100,
-80, -101, -81, -103, -82, -103, -83, -104, -84, -105, -85, -105, -85, -107,
-87, -106, -88, -107, -89, -109, -90, -109, -91, -110, -93, -111, -93, -112,
-95, -113, -96, -113, -97, -114, -98, -114, -99, -115, -99, -115, -100, -116,
-102, -117, -102, -117, -103, -118, -103, -118, -105, -119, -105, -119, -105,
-119, -106, -119, -106, -118, -106, -119, -107, -119, -106, -119, -106, -118,
-106, -118, -105, -117, -105, -116, -104, -116, -104, -116, -102, -115, -101,
-114, -100, -112, -99, -112, -98, -110, -96, -109, -95, -108, -94, -106, -92,
-105, -91, -102, -89, -101, -87, -99, -86, -98, -84, -96, -83, -94, -81, -92,
-80, -90, -77, -88, -76, -86, -74, -84, -72, -82, -71, -80, -68, -77, -67, -75,
-65, -72, -63, -70, -61, -68, -59, -66, -57, -64, -55, -62, -53, -59, -52, -57,
-49, -54, -48, -53, -46, -50, -44, -47, -42, -45, -41, -43, -38, -41, -37, -39,
-36, -36, -34, -34, -31, -32, -30, -30, -29, -28, -27, -26, -25, -24, -23, -23,
-22, -20, -20, -18, -19, -16, -17, -15, -16, -13, -15, -12, -14, -10, -13, -8,
-11, -6, -9, -3, -7, -1, -6, 1, -3, 2, -2, 5, 0, 6, 2, 7, 4, 9, 6, 11, 7, 12, 9,
14, 10, 16, 12, 17, 14, 18, 14, 19, 16, 21, 17, 23, 19, 24, 19, 24, 20, 25, 23,
26, 23, 28, 24, 29, 25, 30, 26, 31, 27, 32, 27, 32, 28, 33, 29, 34, 30, 35, 30,
35, 30, 35, 32, 36, 32, 37, 33, 37, 33, 37, 34, 37, 34, 38, 34, 37, 34, 37, 34,
38, 35, 39, 35, 38, 34, 38, 34, 37, 34, 37, 33, 37, 33, 37, 34, 36, 33, 36, 33,
36, 33, 35, 31, 34, 31, 34, 31, 34, 31, 33, 29, 32, 29, 31, 28, 31, 27, 30, 27,
29, 26, 28, 25, 28, 25, 27, 24, 26, 25, 26, 24, 26, 23, 25, 24, 24, 23, 25, 23,
25, 22, 24, 22, 22, 22, 23, 22, 23, 22, 22, 22, 22, 21, 21, 20, 21, 21, 21, 19,
21, 20, 21, 19, 20, 19, 19, 17, 19, 17, 18, 16, 19, 16, 18, 16, 17, 14, 17, 14,
17, 12, 15, 11, 16, 10, 16, 10, 15, 8, 15, 8, 15, 8, 14, 6, 14, 6, 13, 5, 13, 3,
12, 3, 11, 2, 11, 1, 10, -1, 11, -2, 10, -3, 9, -4, 8, -5, 7, -7, 6, -7, 6, -9,
6, -11, 5, -12, 5, -13, 3, -14, 3, -16, 2, -18, 2, -19, 0, -20, 0, -22, -1, -23,
-2, -24, -2, -26, -5, -27, -4, -28, -5, -30, -5, -31, -6, -31, -7, -33, -8, -33,
-8, -34, -9, -35, -9, -35, -10, -36, -10, -37, -11, -37, -11, -38, -12, -39,
-12, -39, -13, -40, -14, -41, -14, -41, -14, -43, -14, -43, -15, -43, -16, -44,
-16, -45, -17, -46, -17, -47, -18, -48, -18, -49, -19, -49, -19, -50, -19, -51,
-20, -52, -21, -53, -21, -53, -22, -53, -22, -55, -22, -54, -23, -55, -23, -56,
-23, -56, -24, -57, -23, -57, -24, -57, -25, -58, -25, -58, -26, -58, -26, -59,
-27, -59, -27, -60, -27, -60, -27, -60, -27, -61, -28, -62, -27, -61, -28, -61,
-28, -63, -28, -62, -29, -62, -29, -63, -30, -63, -29, -63, -29, -63, -30, -64,
-30, -64, -30, -63, -29, -63, -30, -63, -29, -62, -27, -61, -27, -60, -27, -59,
-26, -58, -26, -57, -25, -54, -24, -54, -24, -52, -22, -50, -21, -49, -19, -47,
-18, -45, -17, -43, -14, -40, -13, -39, -11, -37, -9, -35, -7, -33, -6, -31, -3,
-28, -2, -25, 0, -24, 2, -21, 5, -19, 6, -17, 8, -15, 10, -13, 14, -10, 14, -8,
17, -5, 18, -2, 24, 0, 21, };