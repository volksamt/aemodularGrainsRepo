#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 44, 2, 55, 2, 54, 3, 60, 4, 60, 5,
65, 5, 64, 7, 67, 7, 67, 8, 70, 9, 70, 11, 72, 11, 74, 13, 77, 14, 80, 15, 83,
16, 85, 18, 88, 19, 90, 20, 91, 21, 93, 22, 94, 23, 95, 25, 94, 26, 97, 27, 98,
28, 99, 30, 100, 31, 101, 32, 102, 33, 103, 33, 105, 35, 106, 34, 106, 35, 108,
36, 108, 37, 108, 37, 108, 38, 109, 39, 108, 40, 109, 41, 109, 41, 108, 42, 108,
43, 108, 44, 109, 46, 109, 46, 110, 47, 112, 48, 113, 50, 115, 51, 116, 52, 117,
53, 118, 54, 119, 55, 118, 56, 119, 57, 119, 57, 119, 59, 118, 60, 118, 60, 118,
61, 116, 62, 117, 63, 115, 64, 114, 63, 115, 64, 115, 64, 114, 66, 113, 68, 113,
69, 113, 71, 113, 73, 113, 75, 113, 76, 112, 77, 110, 79, 111, 80, 110, 81, 111,
82, 111, 84, 112, 85, 113, 87, 115, 88, 114, 89, 116, 91, 115, 91, 115, 93, 113,
95, 113, 96, 111, 98, 110, 100, 107, 101, 106, 103, 104, 104, 104, 105, 103,
106, 102, 108, 101, 109, 101, 110, 100, 111, 99, 112, 96, 112, 95, 113, 92, 114,
89, 114, 87, 115, 84, 115, 82, 117, 79, 116, 76, 117, 74, 118, 71, 119, 68, 118,
66, 119, 62, 119, 58, 119, 55, 119, 51, 118, 48, 118, 45, 118, 43, 117, 40, 119,
38, 118, 36, 117, 34, 117, 32, 116, 30, 115, 28, 116, 26, 115, 23, 115, 21, 116,
18, 115, 15, 115, 12, 114, 10, 114, 7, 114, 3, 114, 0, 113, -5, 113, -10, 114,
-14, 113, -21, 113, -26, 113, -32, 111, -39, 111, -45, 111, -50, 110, -55, 109,
-60, 108, -65, 107, -69, 106, -73, 105, -77, 105, -81, 104, -86, 103, -90, 103,
-96, 103, -100, 102, -105, 102, -108, 103, -109, 102, -111, 102, -111, 102,
-112, 102, -113, 101, -112, 101, -113, 100, -112, 100, -112, 100, -111, 98,
-111, 98, -111, 97, -110, 95, -109, 94, -109, 93, -109, 92, -108, 91, -108, 91,
-108, 89, -107, 88, -108, 87, -108, 85, -108, 84, -108, 84, -107, 82, -106, 82,
-105, 80, -105, 81, -104, 79, -104, 78, -104, 78, -103, 77, -102, 75, -101, 75,
-101, 75, -101, 74, -99, 73, -98, 72, -98, 71, -97, 69, -97, 69, -94, 68, -92,
67, -89, 65, -84, 63, -81, 62, -77, 62, -74, 59, -70, 58, -66, 58, -62, 55, -60,
54, -57, 52, -53, 51, -51, 50, -48, 48, -45, 45, -43, 44, -41, 42, -39, 40, -37,
38, -35, 38, -34, 36, -32, 34, -30, 32, -30, 30, -29, 29, -30, 27, -31, 26, -31,
25, -32, 23, -33, 22, -35, 21, -35, 19, -35, 19, -36, 18, -37, 17, -37, 15, -36,
14, -35, 13, -34, 13, -33, 12, -31, 10, -30, 9, -29, 8, -29, 7, -30, 7, -32, 6,
-33, 5, -35, 4, -38, 3, -41, 2, -43, 1, -47, 0, -48, -1, -51, -2, -53, -3, -56,
-3, -58, -4, -61, -5, -63, -6, -65, -6, -66, -8, -68, -8, -69, -10, -70, -10,
-72, -12, -75, -13, -77, -15, -79, -16, -82, -17, -85, -18, -88, -18, -89, -20,
-92, -22, -93, -22, -93, -24, -95, -25, -95, -26, -96, -27, -97, -28, -98, -30,
-99, -31, -101, -33, -102, -33, -103, -34, -105, -34, -106, -35, -107, -36,
-108, -36, -108, -37, -109, -38, -108, -39, -109, -39, -108, -40, -108, -41,
-109, -43, -108, -43, -108, -43, -108, -44, -109, -46, -109, -47, -110, -47,
-112, -48, -113, -50, -114, -52, -117, -53, -117, -54, -117, -55, -119, -56,
-119, -56, -119, -57, -119, -59, -118, -59, -118, -59, -117, -61, -117, -61,
-116, -62, -117, -63, -115, -63, -114, -63, -114, -64, -115, -64, -113, -66,
-113, -68, -113, -70, -113, -71, -112, -73, -112, -75, -112, -76, -111, -78,
-111, -78, -111, -80, -111, -82, -111, -83, -111, -85, -113, -85, -113, -87,
-115, -88, -115, -89, -115, -90, -115, -92, -114, -94, -114, -96, -113, -97,
-112, -99, -110, -100, -108, -101, -107, -103, -105, -104, -103, -106, -103,
-108, -102, -108, -102, -110, -100, -110, -99, -111, -98, -111, -96, -113, -94,
-113, -91, -113, -89, -114, -86, -114, -84, -115, -81, -116, -78, -117, -75,
-118, -73, -118, -70, -118, -68, -119, -66, -119, -62, -119, -58, -119, -54,
-119, -50, -119, -48, -119, -45, -119, -42, -118, -40, -118, -38, -118, -35,
-117, -34, -117, -32, -116, -30, -116, -28, -115, -25, -116, -22, -115, -20,
-115, -17, -114, -15, -115, -12, -115, -9, -114, -7, -115, -2, -114, 0, -114, 6,
-114, 10, -113, 16, -114, 21, -114, 27, -112, 34, -112, 40, -111, 46, -111, 51,
-110, 56, -108, 61, -108, 64, -106, 69, -107, 74, -105, 78, -105, 82, -103, 87,
-103, 91, -104, 95, -103, 101, -103, 105, -102, 107, -102, 109, -102, 110, -102,
112, -102, 111, -101, 112, -101, 113, -101, 112, -100, 112, -100, 111, -100,
111, -98, 112, -97, 110, -96, 110, -96, 109, -94, 109, -94, 108, -92, 108, -91,
108, -90, 108, -90, 109, -88, 109, -88, 109, -87, 109, -85, 108, -85, 107, -84,
106, -82, 105, -81, 105, -79, 104, -79, 105, -79, 103, -77, 103, -77, 102, -76,
101, -75, 101, -74, 100, -74, 100, -73, 99, -72, 97, -72, 98, -70, 96, -69, 94,
-68, 91, -66, 89, -66, 84, -64, 81, -63, 78, -61, 74, -60, 69, -59, 66, -57, 63,
-55, 60, -54, 57, -52, 55, -50, 52, -49, 49, -48, 46, -46, 44, -44, 42, -42, 39,
-41, 38, -39, 36, -38, 34, -35, 32, -34, 31, -32, 30, -31, 30, -30, 30, -28, 30,
-26, 31, -25, 32, -23, 33, -21, 34, -21, 35, -20, 35, -18, 37, -17, 36, -16, 37,
-15, 36, -14, 35, -13, 34, -12, 33, -12, 31, -10, 30, -9, 29, -8, 30, -7, 30,
-6, 32, -6, 33, -6, 38, -5, 38, -4, 43, -2, 42, -1, 49, -1, 41, };