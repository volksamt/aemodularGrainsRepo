#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0193

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, -8, 12, -1, 21, 9, 30, 19, 40, 28,
48, 37, 56, 47, 64, 55, 72, 62, 79, 71, 84, 78, 90, 85, 95, 92, 100, 97, 104,
102, 106, 105, 108, 109, 110, 112, 111, 115, 111, 116, 113, 118, 112, 118, 112,
119, 110, 119, 109, 119, 107, 118, 105, 117, 104, 118, 102, 116, 100, 116, 98,
115, 95, 114, 93, 114, 90, 114, 88, 113, 86, 112, 84, 112, 81, 111, 79, 110, 78,
109, 76, 108, 74, 107, 73, 105, 70, 104, 69, 104, 68, 102, 67, 101, 65, 99, 65,
97, 63, 95, 64, 92, 63, 90, 63, 88, 63, 84, 62, 82, 62, 80, 62, 77, 62, 74, 61,
70, 62, 68, 61, 65, 61, 62, 61, 58, 61, 55, 61, 54, 60, 50, 59, 47, 58, 43, 57,
40, 55, 36, 54, 32, 51, 30, 50, 25, 47, 21, 45, 16, 42, 12, 39, 8, 35, 3, 33,
-1, 30, -5, 26, -10, 23, -15, 20, -19, 17, -24, 14, -28, 12, -32, 9, -35, 7,
-38, 6, -41, 4, -44, 1, -47, 1, -49, -2, -50, -2, -52, -3, -54, -5, -55, -5,
-55, -5, -56, -7, -56, -8, -57, -9, -57, -10, -57, -11, -57, -12, -58, -14, -57,
-15, -58, -17, -59, -19, -59, -22, -60, -24, -61, -27, -62, -28, -63, -31, -64,
-33, -66, -35, -66, -36, -67, -39, -69, -41, -69, -42, -70, -43, -70, -44, -71,
-45, -71, -46, -72, -47, -70, -47, -70, -47, -69, -48, -68, -48, -68, -48, -67,
-47, -65, -48, -64, -48, -63, -49, -62, -49, -61, -49, -60, -51, -59, -52, -59,
-53, -58, -55, -59, -56, -58, -59, -58, -61, -59, -63, -61, -66, -61, -69, -61,
-72, -63, -74, -64, -76, -65, -78, -65, -81, -66, -82, -67, -84, -67, -85, -67,
-85, -67, -87, -66, -87, -65, -86, -64, -85, -61, -85, -60, -83, -57, -82, -55,
-80, -51, -77, -48, -75, -44, -71, -41, -69, -36, -67, -32, -63, -29, -60, -27,
-57, -22, -54, -19, -51, -16, -48, -13, -46, -12, -44, -10, -42, -8, -38, -7,
-37, -5, -36, -5, -33, -4, -33, -4, -31, -3, -29, -4, -28, -4, -27, -4, -27, -5,
-26, -4, -24, -5, -24, -4, -23, -5, -21, -4, -21, -4, -20, -3, -20, -2, -19, -2,
-19, 0, -17, 0, -17, 2, -16, 3, -16, 5, -15, 6, -14, 8, -14, 9, -13, 10, -12,
12, -11, 14, -11, 15, -9, 17, -8, 18, -7, 20, -6, 21, -5, 21, -4, 23, -3, 23,
-1, 24, 0, 25, 1, 26, 2, 26, 4, 26, 4, 26, 4, 26, 5, 25, 5, 25, 5, 24, 4, 23, 3,
21, 2, 19, 1, 17, -1, 14, -5, 12, -7, 8, -10, 5, -13, 2, -18, -1, -21, -5, -24,
-9, -29, -14, -34, -19, -36, -23, -40, -27, -43, -30, -46, -34, -49, -38, -50,
-40, -52, -42, -52, -44, -52, -45, -51, -47, -50, -46, -46, -45, -43, -43, -41,
-41, -35, -38, -30, -34, -24, -29, -18, -25, -12, -19, -4, -13, 2, -7, 9, 0, 17,
5, 23, 12, 30, 17, 37, 23, 42, 30, 48, 34, 53, 39, 58, 43, 61, 46, 64, 50, 67,
51, 68, 53, 70, 55, 69, 55, 69, 56, 70, 55, 69, 54, 67, 53, 65, 52, 63, 50, 61,
47, 58, 45, 54, 43, 52, 41, 48, 38, 45, 36, 42, 33, 38, 32, 35, 29, 33, 27, 30,
25, 27, 24, 23, 23, 22, 22, 19, 20, 18, 19, 15, 18, 13, 17, 12, 15, 11, 14, 9,
13, 8, 12, 8, 11, 7, 9, 7, 9, 7, 7, 7, 6, 8, 5, 9, 3, 9, 1, 10, 0, 11, 0, 13,
-2, 14, -3, 15, -4, 16, -6, 18, -6, 20, -6, 22, -7, 24, -8, 25, -9, 26, -9, 26,
-10, 27, -10, 28, -10, 28, -11, 29, -11, 29, -13, 29, -13, 29, -13, 28, -15, 26,
-15, 27, -16, 26, -18, 25, -19, 24, -19, 23, -20, 23, -22, 21, -22, 21, -22, 21,
-23, 21, -23, 20, -23, 21, -22, 21, -22, 22, -22, 23, -20, 24, -19, 25, -17, 26,
-15, 26, -12, 29, -9, 30, -6, 31, -3, 32, -1, 34, 2, 34, 6, 35, 9, 36, 12, 37,
15, 36, 17, 37, 20, 37, 22, 36, 24, 36, 25, 35, 27, 35, 29, 34, 30, 33, 31, 32,
32, 31, 33, 30, 33, 29, 34, 29, 35, 28, 36, 28, 37, 27, 38, 26, 38, 26, 39, 27,
40, 27, 43, 27, 44, 28, 45, 27, 46, 28, 47, 28, 49, 27, 50, 27, 52, 26, 52, 26,
52, 23, 53, 22, 53, 21, 52, 18, 52, 16, 51, 13, 50, 9, 48, 7, 45, 4, 44, -1, 41,
-5, 39, -9, 35, -13, 32, -17, 29, -20, 26, -24, 23, -27, 20, -30, 18, -33, 16,
-36, 12, -38, 11, -40, 10, -41, 8, -42, 6, -43, 6, -44, 5, -43, 5, -42, 5, -43,
6, -41, 7, -40, 6, -40, 6, -39, 7, -37, 8, -37, 8, -35, 7, -34, 7, -33, 7, -33,
7, -33, 5, -32, 4, -32, 1, -32, -1, -33, -3, -33, -6, -33, -9, -34, -12, -34,
-15, -35, -19, -35, -23, -37, -26, -38, -29, -39, -33, -39, -35, -40, -38, -41,
-42, -43, -44, -42, -46, -45, -48, -45, -50, -45, -51, -46, -52, -47, -54, -47,
-55, -47, -55, -48, -55, -49, -56, -49, -55, -50, -56, -49, -55, -49, -55, -49,
-55, -48, -54, -48, -54, -47, -55, -46, -54, -46, -53, -45, -53, -44, -52, -43,
-52, -41, -51, -40, -51, -39, -49, -37, -49, -35, -48, -35, -48, -34, -49, -33,
-47, -33, -48, -32, -48, -32, -47, -32, -48, -33, -48, -34, -48, -34, -50, -37,
-51, -38, -52, -40, -54, -42, -56, -45, -58, -47, -60, -49, -62, -52, -64, -55,
-67, -57, -68, -59, -69, -60, -72, -61, -72, -61, -72, -63, -72, -61, -71, -59,
-70, -58, -68, -55, -65, -50, -62, -46, -57, -42, -53, -35, -46, -28, -40, -21,
-32, -13, -25, -3, -15, };