#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0099

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 77, 3, 81, 5, 72, 6, 78, 8, 82, 10,
82, 8, 77, 10, 81, 11, 83, 13, 90, 13, 97, 12, 114, 15, 103, 17, 97, 19, 93, 23,
100, 25, 91, 28, 93, 32, 85, 36, 83, 38, 80, 38, 73, 41, 74, 40, 64, 40, 63, 45,
58, 45, 57, 43, 56, 43, 47, 42, 40, 44, 37, 42, 16, 47, 7, 55, 11, 61, 14, 62,
9, 55, 3, 50, -3, 46, -8, 45, -6, 42, -10, 43, -11, 48, -13, 45, -13, 44, -19,
44, -23, 48, -19, 47, -19, 47, -18, 46, -14, 44, -3, 48, -6, 45, -5, 48, -3, 45,
-12, 44, -12, 39, -16, 35, -11, 37, -5, 34, -11, 31, -15, 29, -18, 34, -18, 34,
-22, 33, -22, 31, -26, 28, -32, 26, -31, 23, -33, 22, -38, 21, -37, 20, -36, 18,
-33, 16, -34, 20, -39, 21, -32, 19, -32, 16, -19, 16, -11, 20, -6, 17, -5, 14,
-13, 12, -14, 11, -15, 12, -15, 16, -11, 18, 5, 19, 14, 20, 11, 20, 11, 21, 10,
27, 15, 30, 27, 30, 23, 36, 24, 34, 15, 41, 18, 43, 16, 40, 14, 39, 10, 38, 19,
37, 25, 36, 44, 38, 75, 38, 73, 36, 79, 40, 72, 42, 61, 43, 45, 49, 45, 51, 33,
57, 32, 65, 47, 66, 55, 67, 54, 70, 43, 68, 36, 66, 28, 63, 21, 63, 21, 66, 27,
65, 22, 67, 29, 66, 25, 70, 35, 71, 52, 70, 50, 68, 53, 68, 60, 72, 63, 74, 61,
72, 52, 68, 50, 66, 50, 63, 39, 64, 25, 63, 8, 64, 1, 64, 0, 63, -6, 61, -9, 58,
-2, 55, 2, 58, -13, 57, -22, 50, -25, 48, -28, 42, -29, 43, -32, 44, -30, 43,
-33, 42, -29, 41, -30, 44, -23, 43, -31, 41, -41, 41, -53, 37, -67, 36, -73, 35,
-80, 35, -76, 35, -76, 35, -55, 36, -44, 34, -45, 32, -40, 30, -38, 30, -22, 29,
-22, 26, -23, 23, -21, 19, -23, 16, -24, 12, -34, 9, -44, 7, -59, 4, -71, 3,
-81, 1, -80, 1, -86, 5, -92, 8, -91, 16, -81, 16, -76, 13, -76, 9, -72, 6, -75,
1, -78, -4, -87, -10, -92, -12, -96, -12, -95, -15, -92, -16, -88, -14, -82,
-17, -86, -18, -86, -21, -75, -26, -78, -29, -79, -33, -76, -32, -79, -29, -79,
-25, -79, -22, -64, -20, -55, -16, -62, -16, -76, -17, -75, -20, -79, -22, -80,
-25, -74, -25, -81, -27, -82, -23, -91, -20, -99, -16, -111, -15, -108, -14,
-103, -13, -109, -12, -103, -12, -102, -7, -97, 0, -101, 1, -102, 6, -99, 7,
-99, 5, -97, 4, -96, 0, -87, -1, -74, -3, -78, -3, -78, -2, -79, -2, -81, -3,
-79, -3, -72, 0, -62, -1, -69, -5, -68, -8, -67, -5, -61, -3, -52, -3, -59, -2,
-62, -3, -66, 2, -67, 1, -76, 0, -82, -1, -87, -7, -102, -8, -102, -6, -99, -7,
-101, -8, -100, -6, -99, -6, -98, -7, -104, -6, -100, -6, -97, -7, -91, -2, -79,
-6, -76, -8, -74, -7, -66, -8, -62, -10, -62, -6, -56, -4, -53, -6, -53, -7,
-51, -6, -46, -3, -44, -4, -36, 1, -25, 10, -22, 12, -14, 13, -11, 9, -11, 7,
-15, 5, -19, 3, -28, 3, -32, 0, -32, 2, -37, 6, -33, 5, -29, 1, -29, 1, -26, -2,
-25, -6, -27, -3, -29, -4, -24, -8, -15, -11, 0, -14, 8, -16, 12, -15, 22, -14,
25, -16, 27, -17, 27, -19, 31, -18, 45, -15, 60, -10, 74, -5, 74, -7, 68, -6,
67, -7, 64, -13, 57, -19, 42, -20, 35, -24, 29, -29, 24, -31, 9, -34, 10, -33,
15, -34, 16, -35, 13, -37, 2, -39, -7, -40, -18, -40, -8, -39, -15, -38, -8,
-35, -7, -31, -2, -26, 3, -30, 8, -31, 11, -31, 6, -31, 0, -31, 5, -32, 14, -31,
4, -31, 0, -29, -3, -21, 0, -16, -1, -16, -2, -16, -10, -20, -5, -22, -3, -22,
4, -23, 4, -24, -8, -24, -13, -24, -14, -24, -11, -22, -15, -23, -16, -23, -23,
-23, -20, -24, -21, -22, -20, -25, -25, -26, -22, -26, -20, -27, -27, -27, -27,
-28, -29, -28, -29, -27, -28, -28, -26, -24, -21, -20, -15, -18, -14, -16, -13,
-19, -13, -19, -7, -19, -5, -20, 3, -15, 10, -5, 40, -2, 69, 0, 70, 0, 69, -2,
58, -6, 48, -9, 53, -9, 60, -8, 51, -8, 46, -9, 42, -7, 44, -9, 40, -11, 39,
-10, 38, -12, 34, -16, 37, -18, 32, -21, 50, -23, 55, -30, 42, -34, 43, -32, 47,
-32, 52, -27, 52, -23, 56, -22, 56, -20, 54, -17, 57, -16, 49, -15, 54, -15, 58,
-18, 60, -21, 69, -21, 70, -22, 65, -23, 68, -23, 66, -26, 56, -25, 57, -23, 70,
-27, 62, -21, 74, -19, 85, -21, 70, -24, 78, -27, 73, -31, 71, -32, 72, -34, 63,
-36, 56, -38, 48, -39, 35, -34, 38, -36, 40, -36, 29, -35, 25, -34, 22, -32, 24,
-32, 22, -34, 18, -33, 21, -33, 26, -35, 14, -32, 26, -33, 37, -32, 39, -31, 43,
-35, 35, -35, 34, -38, 30, -39, 31, -40, 24, -40, 22, -33, 33, -28, 42, -26, 39,
-26, 33, -26, 28, -27, 23, -30, 12, -31, 0, -36, -2, -32, -1, -31, -1, -36, -2,
-39, 0, -44, 9, -45, 16, -48, 30, -44, 39, -40, 41, -37, 49, -38, 48, -38, 43,
-39, 39, -42, 29, -43, 24, -44, 27, -46, 27, -46, 28, -46, 27, -45, 25, -46, 27,
-49, 29, -48, 23, -48, 17, -36, 31, -31, 40, -32, 41, -34, 43, -37, 46, -39, 47,
-42, 39, -42, 36, -43, 32, -41, 29, -41, 25, -43, 19, -41, 33, -44, 52, -42, 58,
-40, 57, -43, 58, -42, 55, -39, 59, -32, 62, -32, 70, -33, 81, -32, 90, -29, 92,
-27, 113, -24, 119, -16, 118, -9, 110, -8, 105, -7, 97, -7, 101, -5, 73, };