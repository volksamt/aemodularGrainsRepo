#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0172

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 41, 1, 51, 3, 48, 6, 52, 7, 51, 8,
54, 10, 54, 12, 57, 13, 58, 15, 60, 16, 60, 18, 63, 20, 62, 22, 65, 24, 65, 25,
67, 27, 68, 28, 70, 30, 70, 31, 71, 33, 73, 34, 73, 36, 75, 38, 76, 38, 76, 41,
78, 42, 79, 45, 80, 45, 80, 47, 82, 48, 83, 49, 84, 51, 85, 52, 85, 55, 88, 56,
88, 57, 89, 59, 90, 60, 90, 61, 92, 63, 93, 64, 93, 65, 94, 66, 94, 68, 95, 69,
96, 70, 97, 71, 98, 73, 98, 74, 100, 76, 100, 76, 100, 77, 101, 79, 102, 80,
103, 81, 103, 81, 103, 83, 105, 84, 105, 85, 107, 86, 108, 87, 107, 87, 108, 90,
109, 91, 109, 91, 110, 93, 110, 93, 111, 95, 111, 94, 112, 96, 112, 96, 112, 97,
113, 98, 113, 99, 114, 99, 114, 100, 115, 102, 115, 101, 115, 103, 116, 103,
116, 103, 116, 104, 116, 105, 117, 105, 117, 106, 117, 107, 117, 106, 117, 107,
118, 107, 118, 109, 119, 109, 118, 109, 119, 110, 118, 110, 117, 110, 118, 111,
119, 111, 118, 112, 118, 112, 119, 112, 118, 113, 117, 113, 117, 114, 117, 113,
117, 115, 118, 115, 117, 115, 117, 114, 117, 114, 116, 115, 116, 116, 116, 115,
116, 116, 116, 116, 116, 116, 114, 115, 114, 117, 114, 116, 114, 116, 113, 117,
113, 116, 113, 116, 113, 117, 112, 117, 111, 117, 111, 117, 110, 117, 109, 116,
109, 116, 108, 116, 108, 116, 108, 117, 106, 116, 106, 115, 105, 115, 105, 115,
104, 115, 103, 115, 102, 115, 102, 114, 101, 114, 101, 113, 99, 114, 98, 114,
98, 114, 96, 113, 95, 112, 94, 112, 93, 111, 93, 111, 92, 110, 90, 110, 89, 109,
88, 110, 88, 108, 86, 108, 85, 107, 83, 107, 82, 107, 82, 105, 80, 105, 79, 104,
78, 104, 76, 103, 75, 103, 74, 102, 73, 100, 72, 101, 70, 100, 68, 98, 67, 98,
65, 97, 65, 96, 63, 95, 62, 95, 61, 93, 59, 93, 57, 91, 55, 92, 54, 91, 53, 89,
51, 89, 50, 88, 48, 87, 47, 86, 45, 85, 44, 84, 43, 84, 41, 82, 40, 82, 39, 81,
37, 80, 35, 79, 34, 78, 33, 77, 31, 76, 30, 76, 28, 74, 27, 73, 26, 73, 25, 72,
24, 70, 22, 70, 20, 68, 19, 67, 18, 67, 17, 65, 15, 64, 14, 63, 12, 61, 10, 61,
10, 60, 8, 59, 7, 57, 5, 56, 4, 55, 3, 54, 2, 54, 0, 52, -1, 52, -2, 50, -4, 49,
-5, 47, -7, 46, -8, 44, -9, 44, -11, 43, -12, 40, -12, 39, -14, 38, -16, 36,
-17, 36, -19, 34, -20, 33, -20, 31, -22, 29, -23, 28, -25, 27, -26, 26, -28, 24,
-28, 22, -31, 20, -31, 20, -32, 18, -35, 17, -35, 15, -37, 14, -37, 12, -40, 10,
-40, 9, -41, 7, -42, 5, -44, 4, -45, 1, -47, 0, -48, -2, -49, -3, -50, -5, -52,
-6, -53, -8, -54, -10, -55, -11, -57, -13, -58, -14, -59, -16, -60, -18, -63,
-20, -64, -21, -65, -24, -66, -24, -67, -26, -69, -27, -69, -30, -71, -31, -72,
-33, -74, -34, -75, -35, -75, -38, -77, -38, -77, -40, -78, -43, -80, -43, -81,
-45, -82, -47, -82, -48, -83, -50, -84, -51, -86, -52, -87, -54, -87, -55, -89,
-56, -90, -58, -90, -60, -91, -61, -92, -62, -92, -63, -94, -64, -94, -66, -95,
-67, -96, -68, -98, -71, -98, -71, -98, -73, -100, -75, -99, -75, -101, -77,
-102, -78, -102, -79, -102, -80, -103, -80, -105, -82, -104, -83, -106, -84,
-106, -85, -107, -86, -107, -88, -108, -88, -109, -89, -108, -90, -110, -91,
-110, -92, -111, -92, -111, -94, -112, -95, -112, -96, -113, -97, -113, -98,
-113, -99, -114, -98, -114, -99, -115, -100, -115, -102, -116, -102, -116, -103,
-117, -102, -117, -104, -117, -104, -117, -105, -117, -105, -117, -106, -118,
-108, -118, -107, -118, -109, -119, -108, -119, -109, -119, -110, -119, -110,
-119, -110, -119, -111, -118, -112, -119, -112, -118, -112, -119, -113, -119,
-113, -120, -113, -119, -114, -119, -113, -118, -115, -119, -115, -118, -115,
-118, -115, -118, -115, -118, -116, -117, -116, -118, -116, -117, -116, -117,
-117, -116, -117, -116, -117, -116, -116, -115, -117, -115, -116, -116, -118,
-115, -117, -114, -117, -114, -117, -113, -118, -113, -118, -112, -117, -113,
-117, -111, -118, -111, -117, -110, -118, -110, -117, -109, -117, -109, -117,
-107, -117, -107, -116, -107, -117, -106, -117, -106, -117, -105, -116, -103,
-116, -103, -116, -102, -115, -102, -115, -101, -116, -100, -114, -99, -114,
-98, -115, -97, -113, -96, -112, -96, -113, -94, -112, -93, -113, -93, -112,
-92, -111, -91, -111, -90, -110, -87, -110, -87, -109, -86, -109, -85, -108,
-84, -107, -83, -106, -81, -107, -80, -105, -80, -105, -78, -104, -77, -104,
-75, -102, -74, -102, -73, -101, -71, -101, -69, -100, -68, -99, -66, -99, -66,
-98, -64, -97, -63, -96, -62, -95, -60, -94, -58, -94, -58, -93, -56, -91, -55,
-90, -52, -89, -52, -89, -50, -87, -48, -87, -47, -86, -46, -85, -45, -84, -43,
-84, -41, -83, -40, -82, -39, -81, -38, -80, -36, -79, -34, -79, -33, -77, -32,
-76, -31, -75, -29, -74, -28, -73, -27, -73, -25, -73, -25, -72, -23, -70, -22,
-69, -21, -68, -19, -68, -18, -66, -17, -65, -15, -64, -14, -63, -12, -61, -10,
-62, -10, -61, -8, -58, -7, -57, -6, -56, -4, -55, -2, -53, -1, -53, 0, -52, 2,
-50, 2, -48, 4, -48, 5, -47, 6, -45, 9, -43, 9, -42, 12, -42, 12, -40, 14, -38,
14, -37, 16, -36, 18, -34, 19, -33, 20, -31, 21, -31, 23, -28, 24, -28, 25, -26,
26, -24, 29, -23, 29, -22, 31, -20, 32, -19, 33, -17, 34, -16, 35, -14, 36, -12,
38, -11, 39, -9, 42, -7, 40, -6, 44, -4, 42, -3, 48, -1, 39, };