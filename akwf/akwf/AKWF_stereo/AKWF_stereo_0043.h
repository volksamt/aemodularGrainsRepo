#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0043

const PROGMEM int8_t DATA[DATA_LENGTH] = {43, 32, 90, 77, 107, 105, 120, 121,
117, 118, 119, 118, 116, 116, 116, 117, 115, 115, 114, 115, 114, 114, 114, 114,
113, 114, 112, 113, 112, 112, 111, 112, 111, 111, 110, 111, 110, 110, 109, 109,
109, 108, 108, 107, 108, 108, 107, 106, 106, 107, 105, 105, 106, 106, 104, 104,
104, 104, 104, 103, 104, 103, 103, 102, 101, 102, 102, 101, 100, 100, 99, 101,
99, 99, 99, 99, 98, 98, 97, 98, 97, 97, 97, 97, 96, 97, 95, 96, 94, 93, 80, 75,
59, 46, 50, 33, 50, 32, 48, 33, 49, 32, 48, 32, 48, 32, 48, 32, 48, 31, 47, 31,
47, 30, 47, 31, 46, 31, 46, 31, 46, 31, 46, 31, 46, 30, 45, 30, 45, 29, 45, 29,
44, 30, 44, 28, 44, 29, 44, 28, 44, 29, 44, 28, 42, 28, 43, 27, 43, 27, 42, 28,
42, 28, 42, 27, 41, 27, 41, 27, 41, 27, 40, 26, 40, 26, 41, 27, 40, 26, 40, 26,
39, 26, 39, 26, 39, 25, 39, 26, 38, 25, 38, 25, 37, 25, 37, 24, 38, 24, 38, 24,
36, 24, 36, 24, 36, 24, 36, 23, 36, 23, 36, 23, 35, 23, 36, 23, 34, 22, 35, 23,
34, 23, 34, 22, 34, 21, 34, 22, 33, 22, 33, 22, 33, 22, 33, 21, 32, 21, 32, 21,
32, 21, 31, 21, 31, 21, 30, 21, 30, 20, 30, 19, 30, 20, 30, 20, 29, 20, 29, 19,
30, 20, 29, 18, 29, 19, 29, 18, 28, 19, 28, 19, 28, 18, 27, 18, 27, 18, 27, 18,
26, 18, 27, 18, 27, 18, 26, 18, 26, 17, 25, 17, 25, 16, 25, 17, 25, 16, 24, 16,
24, 16, 23, 16, 24, 16, 24, 15, 23, 16, 23, 14, 22, 15, 23, 15, 23, 15, 23, 15,
23, 14, 22, 14, 21, 15, 21, 14, 21, 14, 21, 13, 21, 13, 21, 13, 21, 13, 20, 13,
20, 13, 19, 12, 19, 12, 19, 13, 19, 12, 18, 13, 19, 11, 18, 11, 18, 11, 17, 11,
18, 12, 17, 12, 17, 11, 17, 11, 17, 11, 16, 10, 17, 10, 17, 10, 15, 10, 15, 10,
15, 9, 15, 9, 15, 9, 15, 9, 14, 10, 14, 9, 14, 8, 13, 9, 13, 8, 13, 9, 13, 8,
13, 8, 12, 8, 12, 7, 12, 8, 12, 7, 11, 7, 12, 7, 11, 7, 11, 7, 11, 7, 10, 7, 11,
6, 10, 6, 10, 5, 10, 5, 9, 6, 9, 5, 9, 6, 9, 6, 8, 6, 9, 5, 8, 5, 8, 4, 6, -1,
4, -8, 3, -11, 2, -11, 3, -12, 2, -11, 2, -11, 2, -12, 1, -11, 1, -11, 1, -12,
2, -12, 1, -12, 1, -12, 1, -11, 0, -12, 1, -12, 1, -11, 1, -12, 0, -11, -1, -13,
-1, -12, 0, -12, 0, -13, -1, -12, -1, -12, -2, -12, -2, -13, -8, -15, -15, -18,
-18, -19, -18, -18, -20, -18, -19, -19, -19, -18, -20, -19, -19, -19, -19, -20,
-20, -19, -20, -19, -20, -19, -19, -19, -19, -19, -21, -19, -19, -19, -19, -19,
-19, -19, -21, -19, -21, -20, -21, -19, -20, -20, -21, -20, -20, -19, -21, -20,
-20, -20, -21, -19, -21, -19, -20, -19, -21, -19, -21, -20, -21, -20, -21, -20,
-22, -19, -22, -19, -21, -20, -21, -20, -22, -20, -22, -20, -22, -20, -22, -20,
-22, -20, -22, -20, -22, -21, -23, -20, -22, -20, -22, -20, -23, -20, -23, -20,
-23, -20, -23, -20, -23, -20, -23, -20, -24, -20, -24, -20, -23, -21, -24, -21,
-23, -21, -24, -20, -24, -20, -24, -20, -24, -21, -24, -20, -24, -21, -25, -21,
-24, -20, -25, -20, -25, -20, -25, -20, -24, -20, -25, -20, -25, -21, -25, -21,
-25, -21, -26, -20, -25, -21, -25, -20, -25, -20, -26, -20, -25, -21, -26, -20,
-26, -21, -26, -21, -26, -21, -26, -22, -26, -21, -26, -21, -26, -20, -27, -21,
-26, -20, -27, -22, -27, -22, -27, -21, -26, -22, -27, -21, -27, -21, -28, -21,
-28, -21, -28, -22, -28, -21, -27, -22, -28, -21, -28, -22, -28, -22, -29, -22,
-29, -21, -29, -22, -28, -22, -28, -22, -28, -22, -29, -22, -29, -22, -29, -22,
-29, -23, -29, -22, -29, -22, -29, -21, -29, -22, -30, -23, -29, -22, -29, -22,
-29, -23, -30, -23, -31, -22, -30, -23, -30, -22, -30, -23, -29, -22, -30, -23,
-30, -23, -31, -23, -31, -23, -30, -22, -31, -23, -31, -23, -30, -23, -31, -23,
-31, -22, -31, -23, -31, -23, -32, -23, -32, -23, -31, -23, -32, -23, -32, -23,
-32, -24, -32, -23, -31, -24, -33, -23, -31, -24, -32, -23, -33, -23, -32, -23,
-33, -23, -32, -23, -33, -23, -33, -23, -33, -23, -33, -23, -33, -24, -34, -24,
-33, -24, -33, -23, -33, -24, -33, -24, -34, -24, -34, -24, -33, -24, -33, -23,
-34, -24, -34, -23, -34, -25, -34, -24, -34, -24, -35, -24, -34, -24, -35, -24,
-36, -24, -35, -24, -36, -24, -35, -24, -35, -25, -35, -24, -35, -24, -36, -24,
-36, -24, -35, -25, -35, -24, -36, -24, -36, -25, -36, -25, -37, -25, -36, -24,
-36, -24, -37, -25, -37, -25, -36, -25, -36, -25, -37, -25, -37, -25, -36, -26,
-37, -25, -37, -26, -37, -25, -37, -25, -38, -25, -37, -25, -37, -26, -38, -26,
-38, -25, -38, -25, -38, -26, -38, -25, -38, -25, -38, -25, -38, -26, -47, -33,
-62, -49, -71, -57, -73, -58, -72, -59, -73, -59, -73, -59, -74, -60, -74, -60,
-74, -61, -74, -61, -74, -60, -75, -61, -76, -61, -76, -61, -76, -61, -77, -63,
-77, -62, -77, -62, -77, -62, -77, -63, -78, -62, -78, -63, -77, -63, -79, -64,
-79, -63, -80, -64, -80, -65, -81, -64, -79, -65, -80, -65, -81, -66, -81, -66,
-82, -66, -82, -66, -82, -67, -82, -66, -83, -68, -83, -68, -84, -68, -83, -68,
-85, -69, -83, -68, -85, -70, -74, -60, -65, -49, -31, -23, };