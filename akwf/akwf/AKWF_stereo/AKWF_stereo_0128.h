#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0128

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 9, 2, 11, 3, 12, 5, 13, 6, 13, 8,
14, 10, 17, 11, 18, 13, 19, 15, 22, 16, 22, 17, 23, 17, 24, 18, 25, 19, 26, 19,
27, 19, 27, 19, 29, 20, 29, 21, 30, 21, 31, 22, 31, 23, 33, 25, 33, 26, 35, 28,
36, 29, 38, 31, 39, 31, 40, 32, 41, 33, 41, 34, 43, 34, 43, 36, 44, 37, 45, 37,
46, 38, 46, 39, 48, 39, 48, 41, 49, 42, 50, 45, 51, 46, 52, 47, 54, 47, 54, 48,
53, 48, 54, 51, 54, 51, 55, 53, 57, 54, 57, 55, 58, 58, 60, 59, 62, 61, 64, 63,
67, 66, 68, 68, 71, 69, 72, 71, 74, 73, 76, 75, 78, 77, 80, 80, 82, 82, 85, 85,
86, 86, 89, 88, 92, 90, 92, 92, 96, 94, 97, 96, 98, 98, 100, 99, 101, 101, 102,
102, 105, 103, 105, 105, 106, 106, 107, 108, 109, 109, 109, 109, 110, 110, 111,
111, 112, 112, 113, 112, 113, 111, 114, 111, 114, 111, 114, 110, 114, 109, 113,
109, 113, 108, 113, 108, 113, 107, 112, 107, 111, 105, 111, 106, 110, 105, 109,
104, 107, 103, 107, 104, 106, 104, 107, 105, 106, 104, 106, 105, 107, 106, 106,
107, 108, 109, 107, 109, 108, 110, 109, 109, 109, 108, 109, 108, 109, 109, 109,
110, 110, 111, 110, 110, 111, 111, 112, 112, 112, 112, 113, 113, 112, 112, 113,
111, 112, 111, 112, 110, 111, 110, 110, 110, 110, 111, 110, 111, 111, 112, 112,
113, 112, 115, 115, 116, 115, 117, 116, 118, 117, 119, 118, 119, 118, 118, 118,
119, 119, 118, 118, 117, 117, 117, 117, 115, 117, 115, 117, 114, 115, 113, 115,
112, 113, 110, 112, 109, 111, 108, 111, 107, 110, 107, 108, 106, 107, 105, 106,
104, 104, 102, 103, 101, 102, 100, 100, 99, 98, 97, 97, 96, 96, 95, 95, 94, 94,
93, 92, 92, 91, 92, 91, 91, 90, 89, 88, 89, 87, 88, 87, 88, 86, 87, 86, 87, 85,
88, 86, 89, 85, 88, 85, 88, 84, 88, 83, 89, 84, 88, 83, 89, 83, 89, 83, 89, 82,
87, 80, 87, 79, 86, 79, 86, 78, 84, 77, 84, 76, 84, 75, 83, 75, 83, 75, 82, 74,
81, 73, 79, 72, 78, 71, 77, 70, 76, 68, 74, 67, 72, 65, 69, 62, 67, 61, 66, 59,
66, 59, 64, 57, 64, 56, 63, 55, 62, 55, 61, 54, 61, 53, 61, 52, 59, 52, 59, 52,
57, 50, 57, 50, 55, 48, 53, 47, 50, 44, 48, 43, 46, 39, 45, 38, 43, 36, 41, 33,
39, 31, 36, 30, 35, 28, 32, 25, 31, 24, 31, 22, 29, 21, 29, 21, 28, 19, 28, 19,
27, 19, 26, 19, 25, 18, 25, 16, 23, 16, 21, 15, 19, 14, 17, 12, 16, 11, 15, 10,
14, 10, 14, 9, 13, 8, 12, 7, 11, 6, 10, 4, 7, 3, 4, 0, 3, -3, 0, -5, -1, -6, -2,
-8, -4, -9, -3, -10, -4, -11, -4, -11, -4, -12, -5, -13, -5, -13, -5, -13, -5,
-14, -6, -13, -8, -13, -7, -14, -9, -14, -9, -15, -11, -15, -10, -16, -11, -16,
-12, -17, -13, -17, -13, -17, -14, -19, -16, -19, -16, -20, -17, -20, -18, -23,
-19, -24, -22, -26, -23, -28, -24, -30, -26, -32, -29, -35, -31, -37, -33, -40,
-35, -42, -38, -44, -39, -47, -42, -49, -44, -51, -46, -53, -49, -55, -51, -58,
-53, -60, -56, -61, -58, -63, -60, -67, -62, -69, -65, -70, -67, -72, -69, -74,
-71, -77, -72, -79, -74, -79, -76, -80, -75, -81, -77, -82, -77, -82, -78, -83,
-79, -84, -79, -84, -79, -86, -79, -86, -79, -86, -81, -87, -81, -87, -81, -87,
-81, -89, -83, -89, -83, -89, -84, -90, -86, -91, -86, -92, -87, -94, -90, -96,
-93, -97, -94, -99, -95, -100, -96, -99, -96, -101, -96, -101, -97, -101, -96,
-101, -97, -101, -96, -100, -96, -100, -95, -100, -96, -100, -97, -100, -97,
-100, -98, -100, -99, -100, -101, -102, -102, -103, -102, -104, -103, -105,
-103, -105, -105, -106, -105, -107, -107, -109, -108, -111, -111, -113, -111,
-114, -113, -116, -112, -116, -112, -116, -112, -116, -113, -116, -112, -115,
-111, -114, -111, -114, -111, -115, -112, -114, -112, -114, -113, -114, -113,
-114, -114, -114, -114, -113, -113, -112, -112, -111, -112, -111, -111, -109,
-111, -110, -110, -109, -110, -109, -109, -108, -111, -109, -111, -110, -110,
-110, -110, -110, -109, -110, -109, -108, -108, -108, -108, -108, -108, -107,
-106, -106, -105, -106, -105, -105, -104, -104, -104, -103, -105, -105, -105,
-105, -107, -105, -108, -106, -108, -106, -108, -106, -110, -107, -111, -107,
-111, -108, -112, -108, -113, -109, -113, -108, -115, -109, -114, -109, -115,
-109, -115, -109, -116, -110, -117, -111, -117, -111, -117, -111, -117, -111,
-118, -113, -119, -112, -117, -112, -118, -112, -118, -113, -118, -113, -118,
-113, -117, -114, -119, -115, -119, -115, -118, -115, -118, -115, -118, -115,
-118, -115, -118, -115, -118, -116, -117, -115, -117, -114, -117, -115, -115,
-113, -114, -112, -113, -110, -111, -108, -109, -106, -107, -105, -105, -104,
-104, -102, -101, -101, -100, -99, -98, -96, -95, -94, -92, -92, -90, -90, -88,
-88, -85, -85, -83, -83, -81, -81, -78, -79, -76, -76, -74, -74, -73, -73, -72,
-72, -71, -70, -70, -68, -68, -66, -66, -63, -64, -61, -60, -58, -58, -56, -55,
-51, -53, -50, -50, -46, -48, -44, -45, -40, -42, -38, -40, -35, -38, -32, -35,
-29, -32, -27, -31, -26, -30, -24, -27, -23, -26, -21, -24, -18, -23, -18, -21,
-16, -20, -15, -19, -13, -17, -12, -16, -10, -14, -9, -13, -8, -11, -6, -10, -4,
-9, -4, -8, -1, -7, -1, -6, 1, -6, 1, -6, 3, -5, 3, -4, 5, -3, 4, -3, 6, -3, 5,
-3, 7, -1, 8, -1, 9, -1, 9, 0, 10, 0, 10, 0, 10, -1, 9, -1, 9, -2, 8, -1, 10, 0,
8, };