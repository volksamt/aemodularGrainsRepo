#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0067

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 38, 3, 46, 4, 44, 5, 48, 7, 48, 9,
51, 9, 50, 11, 53, 13, 53, 14, 56, 15, 55, 18, 57, 19, 57, 19, 59, 22, 60, 24,
61, 25, 61, 26, 64, 27, 63, 29, 65, 30, 66, 31, 66, 34, 68, 35, 68, 36, 69, 37,
70, 38, 71, 40, 71, 42, 74, 43, 74, 45, 75, 45, 75, 46, 77, 48, 76, 49, 78, 51,
78, 52, 78, 53, 80, 54, 81, 56, 82, 56, 82, 58, 83, 59, 83, 60, 85, 62, 85, 63,
85, 64, 87, 65, 87, 66, 87, 67, 88, 68, 88, 70, 89, 70, 91, 72, 91, 72, 92, 74,
91, 75, 93, 76, 94, 77, 94, 78, 95, 79, 96, 80, 95, 80, 96, 82, 97, 82, 97, 83,
98, 84, 99, 85, 99, 85, 99, 87, 100, 88, 101, 88, 101, 89, 101, 90, 101, 91,
102, 92, 103, 92, 104, 94, 104, 94, 104, 95, 105, 95, 105, 96, 105, 97, 106, 98,
107, 97, 107, 99, 107, 100, 107, 100, 108, 101, 108, 100, 108, 101, 109, 103,
109, 103, 110, 103, 110, 104, 110, 104, 111, 105, 111, 105, 112, 106, 112, 106,
113, 106, 112, 107, 113, 108, 113, 109, 113, 109, 114, 109, 113, 110, 114, 110,
114, 111, 115, 111, 116, 111, 115, 111, 115, 111, 115, 112, 116, 112, 117, 112,
117, 113, 116, 113, 117, 113, 117, 113, 117, 113, 117, 114, 118, 113, 118, 114,
118, 115, 118, 114, 118, 116, 118, 114, 118, 115, 119, 115, 119, 115, 118, 115,
119, 115, 119, 115, 119, 115, 119, 116, 119, 115, 119, 115, 118, 115, 119, 114,
118, 114, 119, 115, 118, 114, 118, 113, 118, 113, 118, 112, 118, 112, 117, 112,
117, 110, 116, 109, 116, 110, 115, 109, 116, 108, 116, 108, 115, 106, 115, 106,
113, 105, 114, 104, 114, 103, 113, 102, 113, 102, 112, 101, 112, 100, 112, 99,
111, 98, 111, 97, 110, 97, 111, 95, 109, 94, 108, 93, 109, 93, 109, 91, 108, 90,
107, 90, 107, 88, 107, 86, 106, 86, 105, 85, 105, 84, 105, 83, 104, 82, 103, 80,
103, 79, 102, 78, 101, 76, 101, 75, 100, 74, 100, 73, 99, 72, 98, 70, 98, 70,
97, 68, 96, 66, 96, 66, 95, 63, 94, 62, 94, 61, 93, 60, 92, 58, 91, 57, 90, 56,
89, 54, 89, 53, 88, 52, 88, 50, 87, 49, 87, 46, 85, 46, 84, 44, 84, 43, 82, 41,
82, 39, 81, 38, 79, 36, 79, 34, 78, 33, 77, 31, 76, 30, 75, 29, 73, 27, 73, 26,
71, 25, 70, 23, 69, 22, 68, 20, 66, 18, 66, 17, 64, 15, 63, 14, 60, 12, 60, 11,
58, 10, 57, 8, 55, 6, 53, 6, 51, 4, 49, 2, 46, 2, 45, 1, 41, 1, 39, -1, 34, 0,
30, 1, 21, 11, -5, 12, -15, 11, -18, 12, -22, 11, -25, 9, -28, 8, -29, 7, -32,
5, -35, 5, -37, 3, -38, 2, -40, 0, -41, -2, -43, -3, -44, -4, -46, -5, -47, -7,
-48, -9, -50, -10, -51, -12, -52, -13, -54, -15, -54, -16, -56, -18, -56, -19,
-58, -20, -59, -22, -60, -23, -62, -25, -62, -26, -63, -27, -64, -30, -65, -31,
-66, -32, -66, -34, -69, -35, -69, -37, -70, -37, -71, -38, -71, -40, -72, -42,
-73, -43, -74, -44, -74, -46, -75, -47, -77, -48, -77, -49, -78, -51, -79, -52,
-80, -53, -80, -55, -81, -55, -81, -57, -83, -58, -83, -59, -83, -61, -84, -62,
-85, -63, -85, -63, -87, -64, -87, -66, -88, -67, -88, -69, -89, -70, -89, -70,
-90, -71, -92, -72, -91, -74, -92, -75, -93, -76, -93, -76, -94, -78, -95, -79,
-96, -79, -96, -81, -97, -81, -96, -83, -97, -84, -98, -84, -98, -85, -98, -86,
-99, -87, -99, -87, -100, -89, -101, -89, -102, -91, -101, -91, -103, -92, -102,
-93, -104, -94, -103, -94, -104, -94, -104, -95, -105, -96, -105, -96, -107,
-97, -107, -99, -107, -99, -107, -99, -108, -100, -108, -101, -107, -102, -109,
-101, -109, -103, -109, -103, -110, -103, -110, -104, -111, -105, -111, -106,
-111, -106, -112, -106, -112, -106, -113, -107, -113, -107, -113, -108, -114,
-108, -113, -108, -113, -110, -114, -109, -114, -110, -114, -110, -114, -111,
-115, -110, -115, -112, -116, -112, -116, -112, -116, -113, -115, -113, -116,
-113, -117, -113, -116, -113, -117, -114, -117, -114, -117, -113, -118, -114,
-117, -114, -117, -115, -118, -115, -117, -115, -118, -115, -118, -116, -118,
-115, -119, -114, -119, -116, -118, -116, -119, -115, -118, -115, -118, -116,
-119, -115, -119, -115, -118, -115, -118, -115, -118, -114, -119, -114, -118,
-114, -118, -114, -117, -113, -117, -112, -117, -112, -117, -111, -116, -110,
-116, -110, -116, -109, -116, -109, -115, -107, -115, -107, -114, -106, -114,
-105, -114, -105, -114, -104, -113, -103, -113, -103, -113, -102, -112, -100,
-112, -100, -111, -99, -112, -99, -111, -97, -110, -96, -110, -95, -109, -94,
-109, -93, -109, -92, -109, -91, -108, -90, -107, -89, -106, -88, -105, -87,
-106, -86, -105, -86, -105, -83, -104, -83, -104, -81, -103, -80, -102, -78,
-102, -77, -101, -76, -100, -75, -99, -74, -100, -73, -99, -72, -98, -70, -97,
-68, -97, -67, -96, -66, -95, -65, -95, -64, -94, -62, -93, -61, -93, -60, -92,
-58, -91, -58, -90, -55, -90, -54, -89, -53, -89, -51, -87, -49, -87, -48, -86,
-47, -86, -45, -84, -44, -84, -42, -82, -41, -82, -40, -81, -38, -80, -37, -79,
-35, -78, -32, -77, -32, -76, -30, -74, -28, -74, -27, -72, -26, -71, -24, -70,
-22, -69, -21, -68, -20, -67, -18, -65, -17, -64, -15, -63, -14, -60, -12, -59,
-11, -58, -9, -56, -8, -54, -6, -53, -6, -51, -4, -50, -3, -46, -2, -44, -1,
-42, 1, -39, 1, -34, 1, -30, -2, -18, -11, 7, -12, 15, -12, 18, -12, 24, -10,
25, -9, 30, -8, 29, -7, 34, -5, 34, -4, 38, -3, 37, -2, 42, 0, 35, };