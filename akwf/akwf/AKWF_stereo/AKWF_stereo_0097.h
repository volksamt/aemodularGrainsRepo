#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0097

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 49, 5, 47, 8, 31, 12, 24, 16, 11,
20, 5, 24, -2, 28, -5, 31, -11, 35, -10, 40, -12, 46, -10, 52, -6, 60, 2, 70, 7,
78, 14, 86, 18, 93, 24, 100, 29, 106, 37, 111, 44, 115, 50, 117, 56, 119, 59,
119, 62, 118, 61, 117, 58, 113, 52, 109, 45, 104, 37, 101, 32, 96, 26, 90, 23,
84, 24, 78, 25, 71, 29, 64, 33, 57, 38, 50, 42, 41, 42, 33, 42, 25, 42, 18, 43,
10, 42, 5, 40, -1, 36, -5, 30, -10, 22, -13, 14, -16, 6, -19, -2, -20, -10, -22,
-12, -23, -10, -25, -5, -27, 1, -31, 10, -36, 16, -41, 21, -49, 23, -57, 19,
-64, 16, -71, 11, -76, 4, -79, -4, -82, -14, -82, -25, -84, -35, -86, -47, -85,
-60, -85, -72, -83, -81, -81, -86, -77, -89, -74, -89, -67, -84, -63, -78, -55,
-71, -49, -64, -43, -59, -39, -56, -36, -53, -33, -52, -30, -54, -27, -59, -23,
-65, -18, -73, -14, -79, -8, -84, -4, -91, -1, -98, 1, -101, 3, -103, 5, -102,
6, -99, 8, -92, 11, -81, 13, -67, 14, -52, 11, -34, 6, -16, 1, 1, -4, 14, -10,
22, -17, 27, -23, 30, -28, 32, -33, 35, -36, 39, -39, 41, -40, 44, -39, 45, -37,
48, -35, 52, -29, 56, -24, 58, -19, 61, -12, 62, -8, 60, -2, 59, 1, 57, 4, 53,
5, 48, 3, 41, 1, 33, -3, 23, -4, 13, -8, 3, -11, -7, -14, -13, -19, -15, -22,
-13, -26, -11, -30, -5, -34, 2, -36, 8, -37, 16, -39, 26, -36, 35, -33, 40, -30,
43, -25, 45, -20, 44, -14, 41, -8, 36, 1, 29, 12, 21, 20, 11, 30, 3, 37, -7, 42,
-18, 48, -29, 52, -38, 55, -46, 55, -52, 57, -52, 57, -51, 57, -46, 56, -40, 55,
-31, 57, -20, 58, -8, 59, 5, 60, 21, 60, 34, 61, 49, 59, 63, 59, 78, 60, 91, 60,
101, 62, 109, 62, 111, 62, 112, 63, 109, 63, 106, 65, 100, 66, 91, 67, 84, 70,
72, 70, 62, 68, 47, 64, 30, 60, 14, 51, -3, 42, -19, 32, -34, 21, -46, 9, -54,
0, -60, -10, -65, -17, -68, -23, -72, -27, -73, -29, -73, -31, -71, -33, -68,
-31, -62, -31, -55, -27, -44, -26, -34, -25, -23, -25, -16, -26, -11, -27, -6,
-31, -2, -33, 0, -38, 0, -43, -3, -47, -7, -50, -14, -53, -24, -55, -35, -57,
-44, -58, -53, -60, -61, -61, -69, -63, -77, -63, -83, -63, -87, -60, -89, -58,
-90, -54, -90, -51, -90, -49, -88, -47, -84, -47, -81, -49, -78, -49, -71, -51,
-63, -51, -52, -54, -42, -55, -30, -55, -19, -56, -10, -55, -1, -53, 6, -50, 13,
-45, 20, -39, 27, -33, 32, -26, 37, -20, 39, -14, 43, -8, 46, -4, 53, 0, 59, 4,
63, 6, 67, 7, 68, 5, 71, 4, 72, 1, 74, 0, 74, -1, 72, -1, 67, 1, 62, 3, 53, 4,
43, 8, 32, 12, 20, 16, 12, 20, 3, 24, -2, 28, -7, 32, -10, 36, -12, 41, -12, 46,
-10, 53, -5, 61, 0, 70, 7, 79, 12, 88, 18, 94, 23, 100, 29, 107, 36, 111, 43,
115, 51, 117, 55, 118, 58, 119, 62, 118, 62, 116, 56, 112, 52, 109, 45, 104, 38,
99, 33, 95, 27, 90, 24, 84, 24, 77, 26, 70, 31, 64, 34, 56, 38, 49, 42, 40, 42,
32, 41, 24, 42, 16, 43, 9, 41, 3, 39, -2, 35, -6, 28, -11, 22, -14, 13, -18, 4,
-20, -3, -22, -10, -23, -12, -23, -10, -25, -5, -27, 2, -31, 11, -36, 17, -42,
21, -50, 23, -58, 19, -64, 14, -70, 10, -75, 4, -79, -5, -82, -14, -83, -25,
-84, -36, -85, -49, -85, -62, -84, -72, -83, -80, -80, -86, -77, -89, -73, -88,
-68, -84, -61, -77, -54, -72, -49, -64, -44, -60, -39, -56, -36, -55, -32, -54,
-31, -56, -27, -61, -24, -67, -18, -75, -13, -82, -7, -86, -4, -94, -1, -99, 1,
-103, 3, -103, 4, -101, 6, -98, 9, -90, 11, -78, 13, -66, 13, -48, 10, -31, 5,
-12, 0, 4, -5, 15, -11, 23, -16, 28, -23, 30, -28, 33, -32, 35, -35, 39, -38,
41, -40, 42, -39, 44, -38, 47, -33, 52, -29, 56, -24, 58, -18, 61, -13, 61, -7,
59, -2, 59, 2, 56, 4, 52, 4, 46, 3, 39, 0, 32, -2, 23, -6, 13, -9, 2, -11, -6,
-15, -12, -20, -14, -23, -13, -27, -8, -31, -2, -35, 3, -37, 10, -39, 18, -38,
28, -36, 37, -32, 41, -29, 44, -26, 46, -20, 45, -13, 41, -6, 36, 3, 28, 12, 20,
21, 9, 31, 0, 36, -9, 43, -20, 47, -31, 52, -40, 54, -48, 55, -52, 56, -52, 56,
-50, 55, -45, 56, -39, 56, -29, 57, -18, 58, -5, 60, 9, 60, 23, 61, 37, 60, 52,
59, 66, 59, 82, 60, 94, 61, 103, 61, 110, 63, 112, 63, 112, 64, 110, 64, 106,
65, 99, 66, 92, 69, 82, 70, 72, 70, 60, 68, 46, 65, 29, 58, 12, 50, -5, 41, -21,
31, -35, 20, -46, 8, -55, -2, -62, -11, -66, -19, -69, -24, -72, -29, -74, -30,
-74, -32, -71, -32, -68, -32, -62, -30, -54, -28, -43, -27, -32, -25, -23, -26,
-16, -26, -11, -28, -6, -30, -1, -34, 1, -39, 0, -44, -4, -47, -9, -50, -16,
-53, -27, -55, -37, -58, -47, -59, -55, -59, -63, -61, -72, -63, -80, -64, -84,
-64, -89, -61, -89, -58, -91, -54, -90, -51, -90, -49, -87, -48, -85, -48, -80,
-49, -76, -48, -70, -51, -61, -52, -49, -54, -39, -55, -29, -55, -18, -56, -8,
-55, 0, -53, 8, -49, 15, -45, 21, -38, 27, -32, 32, -26, 38, -19, 39, -14, 43,
-8, 47, -3, 54, 1, 59, 4, 64, 6, 67, 6, 71, 4, 69, 3, 74, 1, 72, -1, 74, -1, 68,
-1, 71, 0, 54, };