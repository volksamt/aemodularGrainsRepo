#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0180

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, -8, 9, -7, 15, -2, 20, 0, 26, 4,
31, 7, 35, 10, 39, 13, 45, 17, 49, 18, 53, 21, 57, 24, 61, 28, 64, 29, 68, 32,
71, 33, 74, 35, 76, 37, 79, 39, 81, 40, 83, 42, 84, 43, 87, 45, 88, 45, 89, 45,
91, 46, 91, 47, 93, 47, 94, 48, 93, 48, 94, 48, 95, 49, 95, 48, 95, 49, 95, 50,
94, 50, 95, 49, 94, 50, 94, 51, 94, 52, 94, 52, 93, 53, 92, 53, 91, 55, 91, 55,
91, 57, 89, 58, 88, 60, 88, 62, 86, 64, 86, 66, 85, 68, 83, 70, 83, 72, 82, 76,
81, 77, 80, 80, 79, 82, 77, 84, 76, 88, 75, 90, 73, 93, 73, 94, 72, 97, 70, 99,
69, 101, 67, 104, 66, 104, 65, 107, 64, 108, 63, 110, 61, 111, 59, 112, 58, 113,
57, 114, 56, 114, 54, 116, 52, 115, 51, 116, 49, 117, 48, 117, 47, 117, 44, 117,
44, 117, 42, 116, 41, 115, 39, 115, 36, 113, 35, 113, 35, 113, 32, 112, 31, 110,
29, 109, 27, 108, 25, 107, 25, 105, 22, 104, 22, 101, 19, 100, 17, 98, 15, 97,
14, 94, 12, 92, 10, 90, 9, 88, 6, 85, 5, 84, 2, 81, 1, 78, -1, 76, -3, 73, -5,
71, -6, 68, -8, 65, -9, 62, -11, 60, -12, 56, -12, 53, -14, 50, -14, 48, -16,
45, -17, 41, -17, 38, -15, 35, -16, 32, -15, 29, -15, 25, -14, 22, -12, 18, -11,
16, -9, 12, -8, 9, -5, 6, -3, 3, 0, 0, 2, -3, 5, -7, 8, -10, 10, -14, 14, -17,
15, -21, 19, -24, 21, -27, 23, -30, 26, -32, 28, -36, 31, -38, 34, -41, 36, -44,
38, -48, 40, -50, 41, -53, 43, -55, 46, -58, 47, -61, 48, -64, 49, -65, 50, -67,
50, -69, 52, -72, 52, -75, 53, -76, 54, -77, 55, -78, 56, -80, 56, -81, 57, -82,
57, -83, 58, -85, 58, -85, 59, -87, 59, -88, 59, -87, 60, -88, 61, -88, 61, -89,
60, -89, 61, -90, 62, -90, 62, -90, 63, -90, 62, -90, 62, -91, 63, -90, 63, -91,
62, -91, 62, -90, 62, -91, 61, -91, 61, -91, 61, -91, 61, -91, 61, -91, 60, -91,
60, -91, 59, -92, 58, -91, 57, -91, 57, -91, 55, -91, 55, -91, 54, -91, 53, -91,
52, -91, 52, -91, 51, -90, 49, -90, 49, -90, 47, -89, 47, -89, 46, -87, 44, -88,
43, -86, 42, -86, 42, -84, 39, -83, 39, -81, 37, -79, 36, -78, 35, -74, 33, -73,
32, -70, 31, -67, 29, -63, 28, -60, 27, -56, 25, -53, 23, -50, 22, -45, 21, -41,
20, -37, 17, -33, 16, -28, 15, -24, 13, -20, 11, -15, 10, -11, 7, -7, 7, -3, 5,
2, 3, 5, 2, 10, 1, 13, -1, 16, -2, 21, -4, 24, -6, 28, -8, 30, -9, 33, -9, 36,
-12, 38, -13, 42, -14, 43, -15, 45, -17, 47, -19, 50, -20, 52, -21, 53, -24, 54,
-25, 57, -27, 58, -28, 58, -30, 60, -31, 61, -34, 63, -34, 62, -37, 64, -37, 64,
-39, 65, -41, 66, -43, 66, -45, 66, -47, 67, -49, 67, -50, 68, -52, 67, -54, 67,
-55, 68, -57, 67, -58, 68, -62, 67, -63, 67, -64, 66, -66, 65, -68, 66, -70, 65,
-71, 65, -74, 65, -74, 63, -76, 62, -78, 61, -80, 60, -81, 59, -82, 58, -84, 58,
-86, 56, -86, 55, -87, 53, -89, 52, -88, 51, -89, 50, -90, 48, -91, 47, -90, 45,
-91, 43, -90, 41, -91, 39, -91, 38, -91, 35, -92, 33, -90, 31, -90, 28, -90, 27,
-89, 24, -88, 22, -89, 20, -88, 17, -88, 15, -86, 13, -86, 11, -85, 9, -85, 6,
-83, 3, -82, 1, -81, 0, -80, -2, -78, -5, -77, -6, -76, -8, -74, -10, -72, -11,
-69, -13, -68, -14, -65, -16, -63, -16, -61, -17, -58, -17, -56, -19, -51, -20,
-48, -19, -46, -20, -42, -21, -38, -21, -36, -20, -31, -21, -28, -21, -24, -22,
-20, -22, -17, -22, -13, -22, -9, -23, -5, -22, -1, -22, 3, -23, 7, -23, 11,
-24, 14, -24, 18, -24, 21, -25, 25, -26, 28, -26, 30, -27, 34, -28, 36, -28, 39,
-30, 42, -30, 44, -32, 47, -33, 49, -33, 51, -34, 53, -35, 54, -36, 55, -37, 57,
-39, 58, -39, 60, -40, 60, -41, 61, -42, 61, -43, 62, -44, 62, -44, 62, -44, 62,
-44, 61, -45, 62, -45, 61, -45, 60, -44, 60, -45, 60, -44, 59, -44, 57, -44, 56,
-43, 55, -43, 53, -42, 52, -42, 51, -41, 49, -40, 48, -40, 45, -39, 44, -38, 40,
-37, 39, -36, 37, -35, 34, -35, 31, -33, 29, -33, 26, -33, 23, -32, 21, -31, 18,
-31, 15, -31, 11, -31, 8, -30, 5, -30, 2, -30, -1, -30, -5, -30, -9, -30, -12,
-30, -15, -30, -18, -29, -21, -31, -25, -30, -29, -30, -32, -30, -35, -32, -38,
-31, -41, -31, -45, -31, -47, -32, -51, -32, -54, -33, -57, -32, -60, -33, -63,
-33, -65, -33, -69, -33, -71, -33, -73, -33, -77, -32, -79, -33, -81, -33, -84,
-33, -87, -33, -89, -32, -91, -32, -94, -32, -95, -33, -98, -33, -100, -32,
-101, -32, -104, -32, -106, -33, -107, -33, -108, -33, -110, -32, -111, -33,
-113, -33, -115, -33, -116, -33, -117, -34, -117, -33, -118, -35, -119, -34,
-119, -35, -118, -35, -119, -35, -119, -36, -118, -36, -118, -37, -118, -37,
-116, -37, -116, -38, -115, -38, -113, -38, -112, -39, -111, -40, -109, -40,
-108, -40, -106, -42, -105, -42, -103, -42, -101, -44, -100, -44, -98, -45, -96,
-45, -94, -45, -92, -47, -90, -46, -88, -47, -86, -47, -83, -48, -82, -48, -79,
-48, -76, -47, -73, -46, -71, -46, -67, -45, -64, -45, -60, -43, -56, -41, -52,
-39, -48, -38, -43, -36, -38, -33, -34, -30, -29, -28, -23, -25, -17, -22, -13,
-19, -7, -16, 0, -11, };