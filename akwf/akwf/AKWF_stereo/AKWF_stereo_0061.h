#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0061

const PROGMEM int8_t DATA[DATA_LENGTH] = {19, 78, 40, 94, 52, 89, 62, 95, 68,
92, 75, 97, 80, 94, 83, 99, 87, 96, 91, 99, 92, 97, 95, 101, 97, 99, 98, 101,
100, 100, 101, 101, 103, 100, 104, 101, 104, 101, 106, 101, 106, 100, 106, 100,
107, 101, 108, 101, 108, 101, 108, 100, 108, 101, 109, 100, 109, 102, 109, 101,
109, 101, 109, 101, 108, 101, 109, 101, 108, 101, 109, 102, 109, 102, 108, 101,
108, 101, 108, 101, 108, 101, 107, 102, 108, 102, 107, 102, 107, 101, 107, 103,
107, 102, 106, 102, 105, 102, 105, 103, 104, 103, 104, 103, 104, 102, 102, 103,
102, 103, 101, 103, 100, 102, 101, 102, 99, 102, 98, 103, 98, 102, 96, 103, 96,
101, 95, 102, 95, 101, 93, 102, 92, 102, 91, 101, 89, 101, 89, 101, 88, 101, 88,
100, 86, 100, 85, 99, 83, 98, 82, 99, 80, 99, 79, 98, 78, 97, 76, 96, 75, 97,
73, 95, 72, 96, 71, 95, 69, 94, 68, 93, 66, 93, 65, 93, 64, 92, 61, 91, 60, 90,
57, 90, 57, 89, 55, 88, 53, 87, 51, 86, 49, 86, 47, 84, 45, 83, 44, 82, 42, 82,
40, 80, 38, 79, 36, 79, 34, 77, 32, 76, 31, 74, 28, 72, 27, 72, 24, 71, 23, 68,
20, 67, 18, 65, 17, 65, 16, 62, 13, 60, 12, 59, 10, 57, 8, 54, 7, 51, 5, 49, 4,
45, 2, 43, 2, 36, 1, 32, 9, 8, 15, -12, 14, -14, 14, -22, 11, -23, 10, -28, 8,
-29, 7, -31, 5, -33, 3, -36, 1, -37, 0, -40, -2, -41, -4, -43, -6, -44, -8, -46,
-10, -48, -11, -49, -13, -51, -15, -52, -17, -53, -18, -55, -21, -55, -21, -58,
-24, -58, -26, -59, -28, -61, -28, -62, -30, -63, -33, -63, -34, -64, -36, -65,
-37, -67, -39, -67, -41, -68, -41, -70, -43, -71, -45, -71, -46, -72, -47, -73,
-49, -74, -51, -75, -51, -76, -54, -76, -55, -78, -56, -79, -57, -79, -59, -81,
-60, -81, -62, -81, -63, -82, -64, -84, -65, -83, -66, -84, -68, -86, -69, -85,
-70, -88, -70, -87, -72, -89, -73, -89, -73, -89, -74, -90, -76, -92, -76, -92,
-78, -93, -79, -93, -79, -93, -81, -94, -82, -95, -82, -95, -83, -96, -83, -97,
-84, -98, -85, -98, -87, -98, -86, -99, -88, -99, -89, -100, -89, -100, -90,
-101, -91, -101, -92, -101, -93, -102, -93, -102, -93, -104, -94, -103, -95,
-103, -95, -105, -96, -105, -97, -104, -98, -106, -98, -106, -99, -106, -99,
-107, -100, -108, -99, -108, -101, -108, -100, -109, -101, -107, -102, -109,
-101, -109, -103, -109, -102, -110, -103, -109, -103, -110, -103, -110, -104,
-110, -105, -111, -106, -111, -106, -112, -106, -112, -107, -112, -106, -112,
-107, -113, -108, -113, -108, -114, -108, -113, -108, -114, -109, -114, -109,
-114, -108, -114, -110, -114, -110, -114, -111, -115, -110, -115, -110, -115,
-110, -115, -110, -116, -112, -115, -111, -115, -111, -115, -111, -117, -112,
-117, -112, -116, -112, -117, -112, -117, -112, -117, -112, -117, -113, -117,
-113, -117, -113, -118, -113, -118, -113, -118, -113, -117, -114, -118, -114,
-118, -113, -118, -114, -118, -113, -118, -114, -119, -114, -119, -114, -119,
-113, -118, -114, -118, -113, -118, -115, -118, -114, -118, -113, -119, -115,
-119, -115, -119, -114, -119, -115, -119, -114, -119, -115, -119, -114, -119,
-114, -119, -114, -119, -115, -119, -114, -119, -115, -119, -114, -119, -114,
-119, -114, -119, -115, -119, -114, -118, -114, -118, -114, -119, -114, -119,
-113, -120, -115, -119, -113, -118, -114, -118, -113, -119, -113, -119, -113,
-119, -113, -118, -113, -119, -113, -118, -113, -119, -113, -119, -113, -118,
-112, -118, -112, -118, -112, -119, -112, -118, -112, -118, -112, -119, -111,
-118, -111, -118, -111, -117, -112, -118, -111, -118, -111, -118, -110, -118,
-110, -117, -110, -118, -110, -117, -110, -117, -109, -118, -110, -117, -109,
-116, -109, -116, -108, -116, -108, -116, -109, -116, -108, -115, -107, -116,
-108, -116, -107, -116, -106, -115, -105, -115, -106, -115, -106, -116, -106,
-114, -106, -114, -105, -114, -105, -115, -104, -114, -104, -113, -103, -114,
-103, -113, -102, -113, -103, -113, -102, -113, -102, -113, -101, -113, -101,
-113, -101, -112, -100, -112, -100, -112, -100, -111, -100, -112, -99, -111,
-98, -112, -98, -111, -98, -110, -97, -111, -97, -110, -96, -110, -96, -110,
-95, -109, -96, -110, -94, -109, -95, -108, -94, -109, -94, -108, -92, -108,
-92, -108, -92, -108, -90, -107, -91, -107, -90, -106, -90, -107, -90, -106,
-89, -106, -88, -105, -87, -106, -86, -105, -86, -104, -85, -105, -86, -105,
-84, -104, -84, -103, -83, -104, -83, -103, -82, -102, -81, -103, -82, -102,
-80, -102, -80, -100, -80, -102, -78, -101, -77, -100, -78, -100, -77, -99, -76,
-99, -76, -100, -75, -98, -74, -98, -73, -97, -73, -97, -72, -96, -70, -97, -71,
-95, -69, -96, -69, -96, -67, -95, -68, -95, -66, -95, -65, -94, -65, -94, -64,
-93, -63, -93, -63, -92, -62, -91, -61, -91, -61, -90, -60, -90, -59, -90, -58,
-90, -58, -89, -56, -88, -55, -88, -54, -88, -54, -87, -53, -87, -52, -86, -51,
-85, -51, -85, -49, -85, -49, -84, -48, -83, -47, -83, -47, -82, -45, -82, -45,
-82, -44, -81, -43, -79, -42, -80, -41, -80, -39, -78, -38, -78, -38, -78, -37,
-77, -36, -76, -35, -75, -34, -75, -34, -74, -32, -74, -31, -74, -30, -72, -29,
-71, -28, -71, -27, -70, -26, -71, -25, -69, -25, -68, -24, -67, -22, -67, -21,
-65, -21, -65, -20, -64, -19, -64, -17, -62, -17, -62, -16, -61, -15, -59, -15,
-60, -13, -58, -12, -57, -11, -56, -10, -56, -9, -54, -8, -54, -8, -52, -6, -52,
-6, -50, -5, -50, -4, -47, -3, -47, -2, -45, -1, -45, -1, -42, 0, -40, 1, -39,
2, -37, 1, -36, 2, -32, 2, -32, 3, -26, 2, -26, 1, -13, -8, 1, -11, 19, -2, -8,
-15, 66, -5, 78, };