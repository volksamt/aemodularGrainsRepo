#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 42, 2, 48, 4, 42, 6, 42, 8, 37, 10,
38, 13, 34, 15, 34, 17, 29, 19, 30, 23, 27, 24, 27, 27, 24, 30, 24, 34, 26, 39,
27, 42, 28, 47, 31, 52, 33, 55, 35, 59, 38, 63, 39, 66, 41, 69, 43, 70, 44, 74,
45, 77, 48, 80, 50, 82, 52, 85, 54, 87, 56, 89, 58, 91, 60, 93, 62, 95, 64, 96,
66, 97, 68, 100, 70, 101, 72, 102, 73, 104, 75, 104, 77, 106, 79, 107, 80, 109,
82, 108, 84, 110, 86, 111, 86, 111, 87, 112, 90, 113, 91, 113, 92, 114, 92, 114,
94, 115, 95, 115, 96, 117, 97, 116, 98, 117, 99, 117, 100, 118, 101, 117, 101,
118, 102, 119, 103, 118, 103, 119, 103, 118, 104, 119, 104, 118, 105, 119, 104,
119, 104, 119, 104, 119, 105, 119, 105, 118, 104, 118, 104, 118, 103, 118, 103,
118, 103, 117, 102, 117, 102, 117, 101, 117, 100, 117, 99, 116, 98, 116, 97,
115, 95, 114, 94, 114, 93, 113, 92, 112, 91, 112, 88, 111, 87, 111, 85, 110, 83,
110, 81, 109, 79, 107, 77, 106, 74, 105, 72, 104, 69, 103, 68, 102, 65, 101, 62,
100, 60, 99, 57, 99, 55, 97, 52, 96, 48, 95, 47, 93, 43, 92, 42, 92, 39, 91, 35,
89, 34, 89, 31, 87, 29, 87, 28, 86, 25, 86, 24, 85, 21, 84, 20, 83, 18, 82, 15,
82, 13, 81, 12, 80, 10, 80, 8, 79, 8, 78, 6, 79, 5, 78, 4, 77, 3, 77, 2, 77, 1,
78, 0, 77, 0, 77, 0, 77, 1, 76, 0, 77, 0, 77, 1, 77, 2, 78, 2, 77, 3, 78, 4, 79,
5, 80, 6, 80, 8, 81, 9, 81, 12, 83, 13, 83, 15, 84, 17, 84, 19, 86, 21, 87, 22,
86, 24, 88, 26, 89, 28, 88, 30, 89, 31, 89, 30, 88, 26, 88, 26, 88, 24, 86, 21,
85, 19, 85, 18, 86, 20, 86, 21, 87, 21, 88, 23, 88, 24, 89, 25, 89, 27, 89, 27,
89, 28, 90, 28, 90, 29, 90, 29, 90, 30, 90, 30, 90, 30, 90, 31, 89, 31, 90, 31,
89, 30, 89, 32, 89, 30, 88, 30, 88, 30, 88, 30, 87, 29, 86, 28, 85, 26, 84, 25,
83, 23, 81, 22, 80, 19, 79, 17, 77, 14, 74, 11, 73, 8, 70, 4, 68, 0, 67, -3, 64,
-8, 60, -11, 57, -15, 53, -20, 50, -23, 47, -27, 43, -31, 38, -35, 34, -38, 29,
-42, 25, -46, 20, -49, 14, -53, 10, -56, 5, -59, -1, -62, -7, -64, -11, -67,
-16, -69, -20, -71, -24, -74, -28, -75, -32, -77, -35, -79, -37, -80, -39, -82,
-42, -83, -44, -84, -46, -84, -47, -84, -46, -83, -47, -82, -48, -82, -46, -80,
-46, -78, -44, -77, -43, -75, -42, -72, -41, -70, -40, -68, -38, -66, -36, -63,
-35, -60, -32, -56, -30, -53, -28, -49, -25, -46, -22, -41, -20, -36, -17, -32,
-14, -27, -11, -23, -6, -17, -4, -12, -1, -6, 3, -1, 7, 5, 9, 9, 12, 14, 15, 17,
17, 22, 20, 26, 22, 29, 24, 33, 26, 36, 27, 37, 29, 40, 25, 41, 27, 43, 28, 45,
23, 46, 25, 47, 24, 49, 23, 49, 21, 50, 21, 51, 19, 51, 17, 52, 13, 53, 10, 52,
7, 52, 2, 53, -2, 52, -7, 52, -12, 52, -17, 52, -22, 51, -26, 51, -31, 49, -35,
49, -40, 48, -45, 48, -48, 46, -53, 43, -56, 43, -60, 41, -63, 41, -67, 39, -73,
31, -78, 25, -82, 20, -85, 14, -88, 6, -92, -1, -95, -8, -98, -13, -100, -18,
-102, -24, -105, -27, -106, -32, -108, -36, -109, -40, -110, -44, -112, -47,
-112, -50, -113, -53, -114, -57, -114, -58, -116, -61, -115, -62, -117, -65,
-117, -66, -118, -67, -118, -68, -118, -70, -119, -70, -118, -71, -119, -71,
-118, -72, -119, -72, -119, -70, -119, -71, -119, -71, -118, -71, -119, -70,
-118, -70, -119, -69, -119, -68, -119, -68, -118, -66, -118, -64, -118, -60,
-118, -58, -117, -55, -116, -53, -116, -50, -115, -47, -115, -45, -114, -41,
-114, -39, -113, -38, -113, -37, -112, -35, -113, -34, -111, -33, -112, -30,
-111, -29, -110, -26, -109, -17, -107, -11, -106, -7, -105, -4, -104, 2, -102,
9, -101, 10, -100, 13, -99, 15, -98, 18, -98, 21, -96, 24, -95, 27, -94, 30,
-93, 31, -91, 35, -90, 36, -88, 37, -87, 39, -86, 41, -86, 42, -85, 43, -84, 44,
-83, 45, -82, 45, -82, 46, -80, 46, -80, 47, -80, 47, -80, 46, -79, 46, -79, 46,
-78, 45, -79, 45, -79, 44, -79, 43, -79, 42, -80, 41, -79, 38, -80, 25, -81, 10,
-81, 2, -82, -12, -83, -25, -83, -37, -83, -46, -85, -53, -84, -60, -85, -67,
-84, -71, -85, -78, -85, -82, -85, -87, -85, -93, -86, -96, -86, -100, -86,
-103, -85, -106, -86, -109, -86, -110, -86, -112, -87, -113, -87, -115, -87,
-117, -87, -118, -86, -118, -87, -119, -86, -119, -86, -118, -85, -119, -84,
-119, -85, -118, -84, -119, -83, -118, -82, -117, -83, -116, -82, -115, -82,
-115, -82, -114, -81, -113, -80, -111, -80, -110, -79, -107, -79, -106, -79,
-105, -79, -104, -78, -101, -77, -99, -78, -97, -77, -95, -76, -93, -76, -91,
-76, -88, -75, -85, -76, -83, -74, -81, -74, -78, -73, -73, -73, -69, -72, -65,
-71, -61, -71, -57, -70, -52, -69, -48, -68, -43, -68, -38, -67, -33, -66, -27,
-64, -22, -64, -16, -63, -10, -62, -3, -60, 3, -59, 9, -57, 15, -56, 20, -56,
24, -54, 29, -52, 33, -51, 36, -49, 40, -48, 44, -46, 46, -44, 48, -42, 51, -40,
53, -39, 56, -37, 57, -34, 58, -33, 59, -30, 60, -29, 62, -27, 63, -24, 63, -23,
62, -21, 63, -20, 62, -18, 63, -16, 60, -14, 61, -13, 58, -11, 59, -9, 55, -7,
56, -5, 51, -3, 54, -1, 43, };