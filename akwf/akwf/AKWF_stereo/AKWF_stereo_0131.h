#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0131

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 27, 2, 33, 3, 32, 5, 34, 6, 34, 8,
37, 9, 37, 10, 39, 11, 40, 13, 43, 14, 44, 16, 45, 18, 46, 20, 47, 21, 49, 23,
51, 23, 51, 25, 53, 26, 55, 27, 55, 29, 56, 30, 58, 32, 59, 34, 60, 35, 62, 36,
64, 37, 64, 39, 66, 40, 66, 42, 68, 43, 69, 43, 69, 45, 71, 47, 72, 47, 73, 49,
75, 51, 76, 52, 78, 53, 79, 54, 79, 55, 80, 56, 81, 58, 82, 58, 83, 59, 84, 60,
85, 61, 85, 63, 86, 64, 87, 66, 88, 66, 89, 68, 90, 69, 91, 70, 92, 71, 93, 71,
94, 73, 94, 74, 95, 75, 96, 76, 97, 77, 98, 78, 99, 79, 100, 81, 101, 82, 102,
83, 103, 84, 103, 85, 104, 87, 104, 88, 105, 88, 107, 89, 107, 91, 107, 92, 108,
93, 109, 93, 110, 93, 111, 94, 111, 96, 111, 97, 111, 96, 112, 98, 112, 98, 112,
98, 111, 99, 112, 99, 113, 100, 113, 100, 113, 101, 114, 102, 115, 103, 115,
104, 115, 104, 115, 104, 115, 104, 115, 105, 115, 106, 115, 105, 116, 107, 116,
107, 115, 109, 116, 108, 117, 109, 116, 110, 117, 110, 118, 111, 117, 111, 117,
111, 116, 112, 117, 113, 116, 112, 117, 113, 117, 113, 118, 114, 117, 114, 118,
114, 118, 115, 118, 115, 117, 116, 118, 116, 117, 116, 117, 117, 117, 117, 116,
116, 117, 116, 116, 117, 115, 116, 115, 116, 115, 116, 114, 116, 113, 116, 114,
116, 113, 114, 112, 114, 111, 114, 111, 114, 110, 113, 109, 114, 108, 113, 107,
113, 107, 113, 107, 112, 107, 112, 105, 111, 105, 112, 104, 111, 103, 111, 102,
111, 102, 109, 100, 109, 99, 108, 99, 107, 97, 107, 96, 106, 96, 106, 95, 106,
94, 104, 95, 105, 93, 104, 92, 104, 91, 103, 90, 103, 89, 102, 88, 101, 87, 101,
86, 100, 86, 100, 85, 100, 85, 99, 83, 98, 83, 98, 82, 97, 81, 96, 81, 96, 79,
95, 77, 95, 77, 94, 76, 94, 75, 92, 74, 93, 73, 92, 73, 91, 72, 89, 70, 89, 68,
87, 67, 86, 66, 85, 64, 84, 63, 82, 62, 81, 60, 81, 59, 80, 58, 79, 57, 79, 56,
77, 55, 76, 54, 76, 53, 75, 52, 74, 50, 72, 49, 71, 46, 70, 46, 69, 45, 68, 42,
67, 42, 66, 40, 65, 40, 65, 38, 62, 38, 62, 36, 60, 35, 58, 33, 57, 32, 56, 31,
55, 28, 54, 27, 52, 26, 50, 25, 49, 24, 49, 22, 48, 22, 47, 19, 45, 18, 44, 16,
42, 15, 40, 13, 39, 11, 38, 10, 36, 7, 35, 6, 33, 5, 32, 3, 30, 1, 30, 0, 28, 0,
26, -3, 24, -4, 23, -6, 21, -7, 21, -10, 18, -11, 17, -12, 15, -14, 14, -15, 13,
-17, 11, -18, 9, -20, 7, -21, 6, -22, 5, -25, 2, -26, 1, -27, 1, -29, -2, -30,
-3, -32, -4, -34, -6, -35, -8, -36, -8, -37, -9, -38, -11, -41, -13, -41, -15,
-44, -15, -44, -17, -46, -18, -47, -20, -48, -21, -50, -22, -52, -23, -53, -24,
-52, -26, -55, -26, -56, -28, -55, -29, -58, -31, -57, -32, -60, -32, -60, -35,
-62, -35, -63, -37, -64, -38, -66, -39, -67, -40, -69, -42, -69, -44, -70, -44,
-71, -45, -73, -47, -75, -48, -75, -50, -76, -50, -78, -52, -77, -52, -79, -54,
-80, -55, -81, -56, -83, -57, -83, -59, -83, -61, -85, -62, -85, -63, -87, -64,
-87, -65, -88, -65, -89, -67, -90, -68, -91, -69, -91, -70, -91, -70, -93, -72,
-94, -73, -94, -74, -94, -74, -96, -76, -98, -77, -98, -78, -98, -79, -99, -79,
-99, -80, -99, -81, -101, -82, -102, -83, -103, -84, -103, -84, -103, -86, -104,
-86, -104, -88, -104, -89, -105, -89, -106, -91, -106, -91, -107, -93, -108,
-93, -109, -95, -109, -96, -110, -96, -111, -98, -112, -98, -112, -99, -112,
-100, -113, -101, -113, -101, -114, -102, -114, -102, -114, -103, -115, -104,
-116, -105, -116, -105, -117, -107, -117, -108, -118, -108, -118, -109, -119,
-110, -119, -110, -119, -110, -119, -111, -120, -111, -118, -112, -119, -112,
-119, -112, -119, -112, -119, -114, -118, -113, -119, -114, -119, -114, -119,
-114, -119, -114, -118, -113, -118, -114, -117, -113, -117, -113, -116, -113,
-116, -113, -115, -112, -116, -113, -114, -114, -115, -113, -114, -113, -114,
-114, -115, -114, -114, -114, -113, -114, -112, -114, -112, -114, -112, -113,
-113, -113, -111, -114, -110, -114, -111, -115, -110, -114, -109, -114, -110,
-114, -110, -114, -109, -114, -108, -113, -107, -112, -107, -112, -106, -110,
-105, -110, -104, -110, -103, -110, -102, -110, -102, -109, -101, -109, -100,
-108, -99, -109, -99, -108, -99, -108, -97, -107, -96, -107, -96, -105, -94,
-104, -93, -104, -92, -103, -91, -101, -90, -102, -88, -101, -88, -101, -87,
-99, -87, -99, -85, -98, -85, -98, -83, -96, -81, -95, -80, -94, -80, -93, -78,
-92, -78, -92, -75, -91, -75, -91, -74, -89, -73, -90, -71, -89, -71, -88, -70,
-87, -67, -85, -67, -85, -66, -83, -64, -83, -62, -82, -63, -82, -62, -80, -60,
-80, -59, -80, -58, -79, -58, -77, -56, -76, -54, -75, -53, -75, -52, -73, -52,
-72, -50, -72, -49, -70, -48, -69, -47, -69, -46, -69, -45, -68, -44, -66, -43,
-66, -41, -65, -40, -64, -40, -64, -38, -62, -37, -61, -35, -60, -33, -59, -33,
-57, -31, -56, -30, -56, -28, -54, -27, -53, -25, -52, -25, -50, -23, -49, -22,
-47, -20, -46, -19, -45, -16, -43, -15, -41, -14, -41, -13, -38, -11, -38, -9,
-36, -8, -35, -7, -34, -7, -33, -5, -32, -3, -31, -2, -29, 0, -28, 1, -27, 2,
-26, 3, -24, 4, -22, 6, -21, 8, -20, 9, -18, 10, -18, 12, -16, 14, -15, 16, -13,
16, -12, 18, -10, 18, -11, 20, -9, 20, -7, 24, -6, 23, -5, 26, -4, 25, -1, 30,
0, 25, };