#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {31, 73, 88, 117, 112, 114, 117, 96,
116, 61, 111, 47, 107, 48, 103, 60, 91, 60, 81, 62, 71, 61, 61, 63, 49, 57, 36,
48, 24, 37, 13, 32, 7, 29, 3, 28, 1, 29, -1, 27, -2, 28, -6, 25, -9, 23, -16,
17, -20, 16, -20, 17, -22, 18, -21, 20, -22, 20, -22, 19, -26, 16, -30, 12, -32,
13, -26, 17, -20, 25, -15, 28, -9, 31, -4, 32, -1, 31, 0, 29, -2, 27, 0, 27, 0,
27, 0, 28, -3, 27, -2, 27, -4, 26, -7, 24, -7, 22, -6, 24, -2, 28, 2, 29, 2, 28,
2, 25, 4, 25, 6, 26, 7, 27, 10, 28, 8, 26, 6, 23, 2, 19, -1, 19, -7, 13, -4, 17,
12, 32, 25, 43, 37, 50, 44, 48, 47, 44, 50, 41, 53, 40, 53, 40, 53, 40, 58, 46,
59, 49, 61, 49, 58, 45, 56, 42, 52, 39, 47, 35, 44, 35, 44, 35, 47, 39, 47, 40,
48, 39, 44, 35, 41, 32, 37, 27, 34, 25, 32, 26, 31, 27, 33, 28, 31, 28, 30, 25,
26, 21, 19, 16, 18, 16, 22, 20, 27, 26, 31, 28, 36, 31, 40, 31, 40, 30, 39, 26,
37, 24, 36, 23, 36, 22, 34, 22, 30, 20, 32, 24, 35, 27, 34, 25, 32, 24, 32, 22,
34, 23, 34, 22, 32, 21, 30, 18, 26, 14, 21, 12, 15, 9, 15, 10, 12, 9, 8, 8, 2,
2, -1, 1, -10, -6, -4, 1, 22, 26, 39, 39, 52, 43, 56, 38, 59, 30, 60, 26, 63,
30, 64, 31, 64, 32, 63, 32, 62, 33, 60, 33, 57, 29, 54, 28, 50, 25, 44, 22, 41,
20, 40, 21, 46, 27, 52, 33, 54, 33, 53, 29, 49, 22, 43, 16, 37, 13, 35, 14, 32,
14, 32, 16, 29, 15, 26, 14, 19, 7, 13, 3, 11, 2, 14, 6, 18, 12, 21, 13, 25, 15,
28, 15, 28, 13, 27, 9, 24, 6, 23, 6, 22, 5, 19, 5, 15, 3, 13, 2, 10, 1, 5, -3,
2, -4, 3, -3, 5, 0, 6, 1, 6, -1, 3, -5, 4, -5, 5, -5, 4, -6, 4, -5, 1, -8, -3,
-10, -8, -15, -11, -17, -19, -23, -17, -18, -3, -4, 9, 7, 20, 12, 25, 10, 28, 6,
29, 1, 32, 2, 29, 1, 28, 0, 33, 6, 35, 9, 34, 8, 30, 3, 27, 0, 21, -4, 15, -7,
12, -8, 11, -6, 12, -4, 12, -4, 12, -5, 8, -9, 4, -14, -1, -17, -5, -20, -6,
-19, -6, -17, 1, -9, 4, -5, 4, -8, 0, -15, -6, -22, -8, -23, -5, -20, -1, -13,
-1, -12, 2, -9, 4, -10, 5, -12, 2, -15, -2, -20, -4, -21, -8, -22, -10, -22,
-14, -24, -17, -26, -21, -27, -26, -30, -29, -32, -29, -31, -27, -27, -26, -27,
-28, -29, -30, -32, -34, -36, -37, -40, -42, -42, -42, -40, -45, -41, -47, -42,
-54, -47, -56, -47, -67, -56, -54, -42, -7, 1, 21, 21, 41, 26, 43, 11, 41, -5,
39, -13, 40, -9, 39, -5, 36, -3, 33, 0, 31, 1, 29, 2, 24, -1, 21, -4, 16, -9,
11, -12, 8, -13, 9, -11, 9, -9, 10, -8, 10, -9, 6, -12, 2, -15, -2, -20, -6,
-21, -8, -19, -10, -20, -9, -17, -11, -19, -13, -21, -19, -26, -25, -29, -25,
-28, -23, -24, -18, -18, -16, -16, -9, -13, 2, -7, 8, -4, 10, -7, 9, -11, 8,
-14, 6, -15, 2, -16, -1, -17, -5, -17, -9, -19, -15, -22, -18, -23, -19, -21,
-16, -18, -16, -18, -16, -20, -20, -24, -19, -24, -19, -23, -19, -23, -18, -23,
-22, -25, -25, -28, -29, -32, -32, -33, -39, -38, -36, -32, -23, -17, -9, -8, 1,
-2, 7, -5, 11, -8, 12, -11, 15, -10, 13, -12, 12, -11, 17, -6, 20, -2, 20, -2,
16, -7, 12, -9, 8, -12, 4, -15, 0, -16, 0, -15, 2, -10, 2, -11, 2, -11, -1, -15,
-5, -18, -9, -22, -13, -24, -14, -21, -16, -21, -14, -19, -15, -20, -17, -22,
-23, -27, -28, -31, -28, -30, -26, -24, -20, -19, -17, -18, -13, -16, -9, -15,
-8, -15, -10, -20, -12, -21, -13, -22, -14, -23, -18, -23, -19, -24, -17, -19,
-14, -16, -16, -18, -17, -20, -18, -22, -16, -19, -16, -19, -17, -21, -21, -24,
-24, -27, -30, -30, -34, -31, -35, -30, -39, -32, -42, -33, -48, -37, -51, -38,
-61, -45, -52, -35, -26, -10, -11, 2, 2, 6, 6, -1, 9, -8, 10, -11, 15, -7, 14,
-5, 14, -4, 12, -3, 12, -2, 9, -1, 5, -5, 3, -6, -2, -10, -6, -12, -11, -13,
-11, -11, -5, -3, 2, 2, 4, 3, 2, -3, -3, -8, -8, -14, -13, -16, -15, -14, -18,
-13, -18, -11, -22, -12, -25, -13, -31, -19, -37, -23, -38, -22, -36, -18, -31,
-12, -29, -10, -25, -8, -22, -8, -22, -10, -23, -12, -25, -15, -26, -14, -29,
-15, -31, -15, -34, -16, -36, -16, -39, -18, -43, -21, -46, -22, -46, -19, -43,
-16, -43, -15, -43, -16, -46, -20, -45, -20, -45, -20, -45, -18, -45, -18, -48,
-21, -51, -23, -56, -28, -60, -29, -67, -34, -63, -27, -49, -12, -39, -3, -27,
3, -23, 0, -19, -4, -19, -8, -17, -7, -19, -9, -20, -7, -16, -3, -14, 1, -15, 1,
-19, -2, -23, -6, -28, -9, -33, -12, -37, -12, -36, -10, -36, -8, -36, -7, -38,
-8, -41, -12, -45, -16, -49, -18, -53, -21, -54, -19, -56, -19, -56, -17, -58,
-18, -60, -18, -66, -25, -71, -28, -72, -27, -69, -21, -65, -16, -62, -15, -58,
-12, -55, -12, -55, -14, -57, -18, -59, -21, -60, -21, -61, -20, -65, -20, -69,
-22, -71, -24, -74, -24, -79, -29, -81, -29, -82, -28, -78, -23, -79, -24, -79,
-24, -82, -31, -84, -31, -89, -38, -92, -36, -94, -37, -97, -36, -100, -40,
-106, -41, -107, -46, -118, -48, -50, 5, };