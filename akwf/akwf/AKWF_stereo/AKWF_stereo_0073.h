#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0073

const PROGMEM int8_t DATA[DATA_LENGTH] = {48, 23, 118, 103, 99, 85, 88, 77, 75,
75, 66, 77, 57, 85, 49, 93, 44, 105, 39, 112, 37, 118, 34, 118, 34, 119, 32,
112, 32, 108, 32, 100, 33, 97, 32, 93, 32, 94, 31, 95, 30, 99, 29, 104, 28, 109,
28, 112, 27, 114, 27, 114, 28, 113, 28, 111, 30, 107, 30, 103, 31, 99, 32, 98,
32, 97, 34, 98, 34, 99, 34, 102, 34, 103, 36, 106, 36, 108, 38, 108, 38, 107,
39, 106, 40, 105, 41, 102, 42, 102, 43, 100, 44, 100, 46, 99, 46, 100, 47, 101,
48, 101, 48, 103, 49, 103, 50, 103, 51, 103, 51, 102, 52, 102, 54, 102, 53, 100,
54, 99, 55, 99, 55, 98, 56, 98, 56, 98, 57, 99, 56, 100, 57, 99, 57, 100, 57,
99, 57, 98, 57, 99, 58, 98, 58, 97, 57, 97, 57, 96, 57, 95, 57, 95, 56, 95, 56,
96, 56, 95, 56, 95, 55, 95, 55, 94, 54, 94, 54, 94, 54, 93, 53, 92, 57, 91, 59,
90, 57, 90, 55, 91, 52, 89, 52, 89, 50, 90, 49, 88, 48, 89, 47, 89, 46, 89, 46,
88, 44, 88, 42, 87, 42, 86, 42, 85, 41, 85, 41, 86, 40, 85, 39, 85, 39, 84, 38,
83, 38, 84, 37, 83, 37, 82, 36, 82, 36, 82, 34, 81, 35, 80, 35, 80, 33, 79, 34,
79, 34, 78, 33, 79, 33, 78, 33, 77, 32, 77, 31, 76, 32, 76, 32, 75, 31, 76, 31,
75, 31, 73, 32, 73, 31, 73, 31, 73, 31, 72, 31, 71, 31, 71, 31, 71, 31, 70, 32,
69, 31, 69, 31, 68, 31, 68, 32, 68, 32, 67, 32, 67, 31, 66, 32, 66, 32, 65, 32,
65, 32, 64, 32, 63, 32, 63, 32, 63, 32, 62, 32, 62, 32, 60, 32, 61, 32, 60, 33,
59, 32, 59, 32, 59, 31, 58, 32, 57, 31, 57, 31, 56, 32, 55, 31, 55, 30, 55, 31,
54, 31, 54, 30, 53, 30, 53, 31, 51, 29, 51, 30, 51, 30, 51, 29, 50, 28, 49, 28,
49, 29, 48, 28, 48, 26, 47, 27, 45, 27, 46, 26, 44, 26, 44, 25, 44, 25, 43, 24,
43, 23, 42, 22, 41, 23, 41, 22, 40, 22, 39, 21, 39, 21, 38, 20, 37, 21, 37, 17,
36, 27, 34, 69, 28, 69, 27, 56, 28, 47, 29, 39, 29, 35, 29, 28, 29, 25, 29, 20,
29, 18, 28, 15, 28, 14, 28, 11, 28, 11, 28, 9, 27, 8, 27, 8, 25, 7, 26, 5, 25,
6, 23, 5, 23, 4, 22, 4, 23, 3, 22, 3, 20, 3, 20, 3, 20, 2, 20, 3, 19, 3, 17, 3,
17, 2, 16, 2, 15, 2, 15, 2, 14, 1, 14, 2, 13, 1, 12, 1, 12, 1, 11, 1, 11, 2, 10,
1, 9, 1, 9, 0, 8, 0, 7, 0, 7, 1, 5, 0, 5, 0, 5, -1, 3, 0, 3, -1, 2, 0, 1, -1, 1,
-1, 0, -1, 0, -1, -1, -2, -2, -2, -2, -1, -3, -2, -3, -3, -4, -3, -4, -3, -5,
-3, -5, -3, -6, -3, -7, -5, -8, -4, -8, -5, -10, -1, -2, 3, 8, 0, 2, -3, -6, -5,
-11, -7, -16, -9, -20, -10, -22, -11, -24, -11, -24, -10, -24, -11, -24, -10,
-22, -10, -22, -9, -21, -9, -20, -6, -19, -7, -20, -7, -21, -8, -20, -9, -21,
-10, -22, -10, -23, -11, -23, -12, -25, -12, -26, -13, -26, -13, -28, -14, -28,
-13, -30, -15, -30, -15, -31, -15, -31, -16, -31, -16, -33, -16, -33, -17, -33,
-17, -34, -17, -34, -17, -35, -18, -35, -18, -36, -18, -37, -19, -37, -19, -38,
-19, -38, -19, -39, -19, -40, -20, -40, -20, -41, -21, -41, -22, -41, -21, -43,
-22, -43, -22, -44, -22, -44, -22, -45, -23, -46, -23, -46, -23, -47, -24, -47,
-25, -48, -23, -48, -24, -48, -24, -49, -25, -50, -25, -51, -25, -51, -25, -52,
-25, -52, -26, -52, -26, -54, -27, -54, -27, -54, -28, -55, -27, -55, -28, -55,
-28, -56, -28, -57, -28, -58, -29, -58, -29, -59, -29, -59, -29, -60, -30, -61,
-30, -61, -30, -61, -30, -62, -31, -63, -31, -63, -30, -64, -32, -64, -31, -65,
-32, -66, -32, -66, -32, -66, -32, -67, -33, -67, -33, -67, -33, -68, -34, -69,
-34, -69, -34, -69, -34, -70, -34, -71, -34, -72, -35, -72, -34, -72, -36, -73,
-35, -73, -36, -74, -36, -74, -36, -74, -36, -75, -37, -75, -37, -75, -37, -76,
-37, -76, -37, -76, -38, -77, -37, -77, -39, -78, -39, -79, -39, -79, -39, -80,
-39, -80, -39, -80, -40, -80, -31, -82, -20, -85, -23, -85, -27, -84, -30, -84,
-33, -84, -36, -84, -37, -84, -38, -84, -40, -85, -41, -86, -42, -85, -43, -86,
-43, -86, -44, -87, -44, -87, -44, -87, -45, -88, -46, -88, -46, -89, -46, -88,
-46, -89, -46, -89, -47, -89, -46, -90, -46, -89, -47, -90, -47, -90, -47, -91,
-46, -91, -47, -91, -47, -92, -48, -92, -48, -93, -48, -93, -48, -93, -48, -93,
-48, -93, -47, -94, -49, -95, -48, -94, -47, -95, -49, -94, -48, -95, -48, -96,
-49, -95, -48, -96, -49, -97, -49, -96, -49, -96, -49, -97, -49, -98, -49, -98,
-50, -98, -50, -98, -49, -98, -49, -99, -50, -99, -49, -99, -50, -99, -49, -99,
-50, -99, -50, -100, -50, -99, -50, -100, -51, -100, -50, -100, -50, -101, -50,
-100, -51, -100, -50, -101, -50, -102, -51, -102, -51, -102, -51, -102, -50,
-102, -51, -102, -51, -102, -50, -102, -51, -102, -52, -103, -51, -102, -52,
-103, -51, -102, -51, -103, -51, -102, -52, -103, -51, -103, -51, -104, -50,
-104, -52, -104, -51, -104, -51, -104, -52, -104, -50, -103, -51, -104, -51,
-103, -52, -104, -52, -104, -52, -105, -51, -104, -52, -105, -51, -103, -53,
-106, -51, -103, -54, -106, -51, -102, -53, -107, -51, -101, -53, -108, -50,
-100, -56, -111, -44, -89, };