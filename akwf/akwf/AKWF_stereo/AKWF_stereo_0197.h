#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0197

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 0, 11, 10, 19, 18, 26, 28, 32, 36,
38, 43, 44, 51, 47, 56, 51, 61, 53, 66, 55, 69, 56, 71, 56, 73, 56, 74, 55, 74,
54, 74, 52, 73, 51, 72, 49, 71, 47, 70, 45, 68, 43, 67, 41, 67, 40, 65, 38, 65,
38, 64, 36, 64, 34, 65, 34, 65, 33, 64, 32, 66, 32, 65, 32, 65, 32, 64, 33, 65,
31, 64, 33, 63, 33, 63, 34, 62, 33, 61, 34, 60, 36, 58, 36, 55, 37, 54, 37, 51,
38, 49, 39, 46, 39, 43, 40, 40, 41, 38, 42, 36, 43, 34, 44, 32, 45, 30, 46, 29,
47, 28, 48, 28, 49, 28, 50, 28, 52, 30, 53, 30, 54, 32, 55, 34, 58, 36, 59, 39,
61, 42, 63, 44, 64, 47, 67, 51, 68, 54, 70, 57, 73, 60, 74, 62, 75, 64, 77, 67,
78, 68, 79, 70, 79, 72, 80, 72, 81, 74, 81, 74, 81, 75, 81, 75, 80, 75, 81, 75,
80, 76, 80, 77, 80, 77, 80, 77, 80, 78, 79, 78, 78, 79, 78, 80, 77, 79, 78, 80,
76, 80, 77, 81, 76, 81, 76, 81, 76, 79, 75, 79, 74, 78, 73, 77, 72, 75, 70, 73,
69, 71, 67, 68, 66, 65, 65, 62, 62, 58, 60, 55, 59, 51, 58, 47, 57, 45, 57, 42,
56, 40, 56, 38, 57, 37, 58, 36, 61, 37, 64, 38, 68, 40, 71, 43, 75, 47, 80, 51,
85, 55, 90, 61, 95, 66, 100, 72, 104, 78, 108, 82, 111, 88, 114, 93, 116, 97,
118, 100, 118, 103, 118, 106, 117, 108, 117, 108, 115, 107, 113, 108, 110, 106,
106, 105, 103, 104, 100, 101, 96, 99, 92, 97, 88, 95, 84, 93, 81, 92, 77, 90,
74, 88, 72, 88, 69, 87, 66, 86, 64, 87, 63, 87, 62, 87, 60, 88, 59, 88, 59, 89,
59, 90, 59, 90, 59, 91, 60, 91, 61, 91, 61, 91, 63, 90, 63, 89, 65, 89, 67, 88,
68, 86, 69, 84, 71, 83, 73, 81, 74, 78, 75, 76, 76, 73, 78, 70, 78, 68, 80, 65,
82, 64, 83, 62, 83, 60, 85, 59, 86, 57, 88, 56, 88, 55, 88, 56, 90, 55, 91, 55,
92, 55, 92, 56, 93, 56, 94, 57, 94, 57, 94, 58, 94, 57, 94, 57, 94, 56, 94, 55,
93, 55, 92, 54, 91, 53, 89, 51, 88, 48, 84, 46, 82, 43, 80, 40, 76, 38, 73, 34,
70, 32, 67, 28, 64, 26, 60, 22, 57, 20, 53, 17, 49, 15, 46, 13, 42, 10, 39, 8,
36, 7, 32, 5, 29, 3, 25, 3, 22, 0, 19, 0, 16, -2, 14, -4, 10, -5, 8, -6, 5, -8,
2, -9, -1, -13, -5, -14, -8, -18, -11, -21, -14, -22, -17, -26, -18, -29, -20,
-30, -22, -31, -23, -34, -23, -34, -22, -34, -21, -33, -19, -32, -16, -30, -13,
-27, -8, -22, -3, -17, 2, -11, 8, -5, 16, 2, 21, 10, 28, 17, 35, 25, 42, 32, 47,
40, 52, 47, 56, 52, 58, 58, 61, 63, 63, 66, 64, 69, 64, 71, 64, 73, 62, 72, 60,
72, 58, 71, 55, 70, 51, 67, 47, 65, 43, 62, 38, 58, 34, 54, 29, 51, 25, 48, 20,
44, 17, 42, 12, 39, 9, 36, 5, 33, 1, 31, -2, 29, -6, 27, -8, 25, -10, 23, -12,
20, -14, 18, -18, 16, -20, 14, -21, 12, -23, 8, -24, 6, -27, 1, -28, -1, -29,
-6, -30, -10, -31, -15, -32, -18, -34, -24, -35, -28, -36, -32, -37, -37, -39,
-42, -39, -45, -41, -50, -42, -53, -43, -56, -44, -60, -44, -62, -45, -64, -46,
-65, -47, -66, -47, -68, -47, -67, -48, -68, -48, -67, -47, -65, -47, -65, -47,
-63, -47, -61, -46, -60, -47, -58, -46, -57, -46, -55, -45, -54, -46, -52, -46,
-51, -46, -51, -47, -51, -47, -50, -48, -49, -49, -49, -50, -50, -51, -50, -52,
-52, -53, -52, -55, -53, -56, -54, -59, -54, -60, -56, -62, -56, -64, -58, -65,
-57, -68, -58, -68, -59, -70, -60, -72, -60, -73, -61, -75, -61, -76, -62, -78,
-62, -79, -63, -81, -64, -83, -67, -84, -67, -85, -70, -87, -73, -90, -75, -93,
-78, -95, -81, -97, -86, -100, -90, -103, -93, -106, -98, -107, -102, -109,
-106, -111, -109, -112, -112, -113, -116, -113, -116, -112, -118, -111, -119,
-109, -119, -108, -119, -104, -116, -101, -114, -97, -110, -93, -106, -88, -101,
-84, -96, -79, -90, -75, -85, -70, -80, -67, -74, -63, -69, -60, -64, -58, -60,
-57, -58, -57, -54, -57, -52, -58, -50, -61, -50, -62, -50, -65, -49, -68, -52,
-72, -53, -76, -54, -81, -57, -85, -60, -89, -62, -93, -63, -97, -66, -100, -67,
-104, -68, -106, -70, -109, -70, -112, -71, -113, -71, -114, -70, -116, -69,
-118, -70, -117, -67, -118, -67, -118, -66, -118, -65, -117, -64, -116, -62,
-115, -62, -115, -62, -114, -62, -112, -62, -110, -62, -108, -62, -106, -64,
-103, -64, -101, -66, -99, -67, -98, -69, -96, -71, -93, -73, -92, -75, -90,
-76, -87, -78, -85, -80, -83, -81, -81, -82, -80, -84, -78, -84, -75, -85, -73,
-85, -71, -84, -70, -84, -67, -83, -65, -82, -64, -80, -62, -78, -60, -77, -58,
-75, -56, -74, -55, -74, -53, -73, -52, -70, -51, -71, -50, -70, -50, -69, -49,
-70, -49, -69, -50, -70, -50, -71, -51, -73, -53, -73, -54, -77, -56, -78, -58,
-80, -60, -81, -61, -82, -64, -84, -65, -85, -67, -88, -70, -88, -71, -88, -74,
-90, -75, -90, -77, -90, -78, -90, -80, -90, -81, -90, -82, -89, -83, -89, -83,
-89, -84, -88, -85, -87, -87, -87, -87, -87, -88, -88, -90, -88, -90, -88, -91,
-88, -92, -89, -93, -90, -93, -91, -93, -91, -94, -92, -93, -92, -91, -92, -90,
-91, -87, -89, -85, -86, -80, -83, -76, -80, -71, -75, -64, -69, -57, -62, -49,
-56, -41, -47, -32, -38, -23, -28, -14, -18, -5, -8, };