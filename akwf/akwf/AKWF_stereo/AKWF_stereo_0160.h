#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0160

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -24, 2, -27, 3, -22, 4, -22, 6,
-19, 7, -18, 8, -14, 11, -13, 12, -10, 13, -9, 15, -6, 16, -5, 18, -1, 19, 0,
22, 3, 23, 5, 25, 7, 26, 10, 29, 12, 30, 15, 31, 17, 33, 18, 34, 21, 36, 23, 38,
25, 40, 28, 42, 29, 43, 32, 44, 34, 47, 36, 48, 38, 51, 41, 52, 44, 53, 45, 55,
47, 57, 49, 58, 51, 60, 54, 61, 56, 64, 58, 65, 60, 67, 62, 69, 63, 70, 65, 71,
67, 72, 69, 74, 71, 75, 73, 77, 74, 78, 76, 79, 78, 81, 79, 82, 81, 83, 82, 85,
84, 86, 86, 87, 87, 88, 89, 89, 91, 90, 91, 91, 93, 92, 95, 94, 95, 95, 97, 95,
98, 96, 100, 96, 100, 98, 101, 99, 103, 99, 104, 100, 105, 101, 106, 102, 107,
102, 107, 103, 109, 103, 109, 104, 110, 105, 110, 105, 111, 105, 112, 107, 113,
106, 113, 107, 113, 107, 115, 108, 115, 108, 115, 108, 116, 109, 116, 109, 116,
109, 116, 109, 117, 109, 117, 109, 118, 110, 118, 109, 119, 111, 119, 110, 119,
110, 119, 109, 119, 109, 120, 109, 119, 110, 119, 109, 118, 109, 119, 109, 119,
109, 119, 108, 119, 109, 119, 108, 119, 108, 119, 108, 118, 107, 118, 108, 118,
106, 118, 106, 117, 107, 116, 105, 117, 105, 116, 105, 115, 104, 115, 104, 114,
102, 114, 103, 115, 103, 113, 102, 113, 101, 114, 101, 113, 100, 112, 100, 111,
100, 110, 98, 110, 98, 110, 97, 109, 97, 109, 96, 108, 95, 108, 95, 107, 93,
106, 93, 105, 92, 105, 92, 104, 91, 104, 91, 102, 89, 102, 89, 101, 88, 101, 87,
101, 87, 100, 86, 99, 85, 98, 84, 97, 84, 96, 83, 95, 83, 95, 80, 94, 81, 93,
80, 92, 79, 92, 78, 91, 77, 90, 76, 89, 76, 90, 75, 89, 74, 87, 73, 86, 73, 85,
72, 85, 70, 84, 69, 82, 69, 82, 69, 82, 67, 80, 66, 80, 66, 78, 65, 78, 64, 77,
64, 76, 61, 76, 61, 75, 60, 74, 59, 74, 59, 73, 58, 72, 56, 71, 56, 71, 56, 70,
54, 69, 54, 68, 54, 66, 52, 67, 52, 65, 51, 65, 49, 64, 49, 63, 48, 63, 48, 62,
47, 61, 46, 59, 45, 60, 44, 59, 44, 57, 43, 58, 42, 56, 42, 55, 40, 54, 40, 53,
39, 54, 38, 54, 37, 52, 36, 50, 35, 50, 34, 48, 33, 48, 31, 47, 30, 47, 29, 44,
29, 43, 27, 41, 26, 41, 25, 39, 22, 38, 22, 36, 19, 35, 18, 33, 16, 31, 15, 31,
14, 29, 12, 27, 9, 25, 8, 24, 6, 21, 5, 20, 2, 17, 0, 15, -1, 14, -4, 11, -5,
10, -8, 8, -9, 6, -12, 4, -13, 2, -15, 0, -18, -2, -20, -4, -21, -6, -23, -8,
-25, -11, -28, -12, -29, -14, -32, -16, -33, -18, -35, -21, -38, -21, -39, -23,
-41, -25, -43, -28, -45, -29, -46, -32, -48, -33, -50, -35, -53, -37, -54, -38,
-55, -39, -57, -41, -58, -44, -60, -45, -62, -47, -63, -48, -66, -49, -66, -51,
-68, -52, -69, -54, -71, -55, -72, -57, -74, -58, -75, -59, -76, -60, -78, -62,
-79, -63, -79, -64, -81, -65, -82, -66, -84, -67, -84, -68, -86, -68, -86, -70,
-87, -70, -88, -71, -89, -72, -90, -72, -91, -73, -91, -75, -92, -74, -92, -76,
-93, -76, -94, -76, -95, -77, -95, -78, -96, -78, -96, -79, -96, -79, -97, -80,
-98, -80, -98, -80, -98, -80, -98, -80, -99, -80, -99, -80, -99, -80, -100, -80,
-99, -80, -100, -81, -100, -81, -100, -80, -100, -81, -100, -80, -99, -80, -99,
-80, -99, -79, -99, -79, -99, -80, -99, -79, -99, -79, -99, -79, -99, -78, -99,
-77, -98, -77, -98, -77, -98, -76, -96, -76, -97, -76, -96, -75, -96, -75, -96,
-74, -96, -73, -94, -72, -94, -72, -93, -71, -92, -70, -92, -70, -91, -69, -92,
-68, -90, -68, -90, -66, -89, -66, -89, -65, -88, -65, -87, -64, -87, -63, -87,
-62, -86, -61, -85, -60, -84, -59, -83, -58, -83, -57, -82, -57, -81, -56, -80,
-55, -79, -55, -79, -53, -78, -52, -77, -51, -76, -50, -76, -49, -74, -48, -74,
-47, -73, -46, -72, -45, -72, -45, -70, -43, -71, -41, -70, -42, -69, -40, -67,
-39, -66, -38, -65, -37, -65, -37, -64, -37, -64, -35, -63, -36, -62, -35, -62,
-35, -60, -34, -60, -35, -59, -35, -59, -35, -59, -35, -57, -35, -58, -36, -58,
-36, -57, -37, -56, -37, -56, -37, -56, -38, -56, -39, -55, -40, -55, -41, -54,
-42, -54, -43, -54, -45, -53, -45, -53, -47, -53, -47, -53, -50, -53, -51, -52,
-52, -53, -54, -52, -55, -53, -55, -52, -58, -52, -59, -51, -61, -52, -63, -52,
-64, -52, -66, -52, -68, -51, -70, -51, -70, -51, -73, -52, -75, -51, -76, -51,
-78, -51, -80, -51, -82, -51, -83, -50, -85, -51, -87, -51, -89, -51, -90, -51,
-92, -51, -93, -51, -95, -51, -97, -50, -99, -51, -98, -50, -101, -50, -102,
-49, -103, -49, -104, -50, -104, -50, -105, -49, -105, -49, -106, -48, -106,
-47, -107, -48, -106, -47, -107, -46, -107, -47, -107, -45, -107, -46, -107,
-45, -107, -44, -106, -44, -105, -43, -105, -42, -105, -42, -105, -42, -103,
-41, -103, -40, -102, -39, -101, -38, -100, -39, -99, -37, -99, -38, -97, -36,
-96, -35, -95, -34, -94, -33, -93, -34, -91, -32, -90, -32, -89, -31, -88, -30,
-86, -30, -85, -29, -84, -28, -82, -28, -80, -26, -80, -26, -78, -25, -76, -24,
-76, -24, -73, -23, -72, -22, -71, -21, -69, -21, -68, -21, -67, -20, -65, -19,
-64, -18, -62, -17, -61, -16, -59, -16, -58, -16, -56, -15, -55, -14, -54, -13,
-52, -13, -51, -12, -49, -11, -48, -11, -46, -9, -45, -8, -43, -8, -42, -7, -40,
-5, -38, -5, -36, -4, -35, -3, -31, -1, -32, 0, -25, };