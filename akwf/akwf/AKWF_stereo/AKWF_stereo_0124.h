#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0124

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -2, 2, -2, 4, -2, 6, -1, 8, -1, 9,
1, 11, 2, 13, 3, 15, 3, 15, 5, 18, 7, 19, 8, 21, 10, 22, 11, 23, 13, 25, 15, 27,
16, 29, 18, 31, 20, 34, 23, 35, 24, 37, 26, 40, 28, 41, 30, 44, 33, 45, 34, 47,
36, 49, 39, 51, 41, 53, 44, 56, 48, 58, 50, 59, 52, 62, 54, 63, 55, 66, 58, 66,
59, 68, 61, 70, 63, 71, 64, 73, 64, 74, 67, 75, 67, 77, 69, 78, 70, 79, 72, 80,
74, 81, 74, 83, 75, 85, 77, 87, 77, 87, 79, 90, 80, 91, 81, 93, 83, 94, 85, 96,
86, 98, 87, 99, 89, 101, 91, 102, 92, 103, 93, 104, 94, 105, 97, 107, 97, 108,
98, 109, 99, 110, 101, 111, 103, 112, 103, 113, 104, 114, 105, 115, 107, 117,
107, 117, 108, 119, 110, 119, 109, 118, 110, 119, 109, 118, 109, 118, 109, 116,
110, 116, 109, 114, 110, 113, 110, 111, 111, 110, 110, 105, 108, 99, 104, 89,
97, 81, 90, 73, 85, 64, 78, 56, 73, 49, 68, 41, 63, 34, 58, 28, 53, 21, 49, 15,
43, 9, 39, 2, 35, -3, 29, -8, 25, -14, 20, -17, 16, -22, 12, -26, 8, -29, 4,
-34, 1, -36, -3, -40, -7, -43, -11, -46, -14, -48, -18, -52, -21, -53, -23, -56,
-27, -58, -29, -60, -32, -61, -35, -65, -37, -66, -40, -68, -43, -71, -45, -72,
-47, -74, -50, -75, -52, -77, -55, -77, -56, -79, -58, -78, -60, -80, -61, -79,
-63, -80, -64, -80, -66, -80, -67, -80, -67, -80, -68, -81, -68, -80, -70, -79,
-70, -80, -70, -79, -71, -81, -71, -79, -71, -81, -73, -81, -72, -80, -72, -80,
-72, -80, -71, -80, -71, -80, -71, -80, -72, -80, -71, -81, -72, -81, -73, -82,
-73, -80, -74, -82, -75, -81, -75, -81, -76, -80, -75, -80, -76, -80, -77, -79,
-76, -79, -76, -79, -77, -79, -77, -79, -77, -78, -78, -79, -77, -77, -78, -78,
-78, -78, -78, -78, -78, -78, -78, -77, -79, -78, -79, -78, -80, -78, -80, -79,
-81, -78, -81, -78, -82, -78, -83, -78, -83, -77, -83, -78, -84, -78, -84, -79,
-85, -79, -84, -79, -85, -77, -85, -77, -85, -75, -84, -75, -84, -75, -83, -74,
-82, -73, -82, -71, -81, -70, -80, -69, -78, -69, -77, -67, -76, -67, -74, -65,
-71, -64, -70, -61, -69, -60, -67, -59, -66, -57, -65, -55, -63, -54, -63, -52,
-60, -50, -59, -47, -57, -44, -55, -42, -53, -39, -52, -38, -50, -36, -48, -34,
-47, -32, -44, -31, -43, -29, -41, -28, -39, -26, -39, -25, -37, -24, -35, -23,
-34, -21, -33, -19, -30, -19, -29, -17, -27, -16, -26, -13, -24, -11, -23, -10,
-22, -8, -21, -6, -18, -4, -17, -2, -15, 0, -13, 3, -11, 5, -10, 7, -8, 9, -6,
12, -3, 15, -1, 16, 2, 18, 4, 20, 6, 22, 9, 23, 10, 25, 13, 26, 14, 28, 16, 29,
18, 30, 20, 31, 22, 33, 24, 34, 26, 35, 28, 36, 29, 36, 30, 38, 30, 39, 32, 39,
34, 40, 35, 40, 36, 42, 37, 42, 37, 42, 38, 43, 38, 43, 38, 43, 38, 43, 38, 43,
37, 41, 38, 40, 36, 40, 37, 38, 36, 36, 36, 34, 35, 31, 35, 29, 34, 28, 33, 25,
31, 23, 30, 21, 28, 19, 27, 16, 25, 16, 23, 14, 21, 13, 18, 12, 16, 12, 14, 11,
12, 11, 11, 11, 9, 12, 8, 12, 8, 12, 7, 12, 6, 12, 6, 11, 5, 10, 5, 9, 5, 9, 5,
8, 5, 8, 4, 8, 3, 8, 5, 7, 5, 8, 6, 8, 7, 8, 7, 8, 6, 9, 6, 8, 6, 9, 5, 10, 6,
11, 6, 12, 6, 13, 7, 14, 8, 15, 9, 17, 10, 18, 10, 21, 12, 21, 13, 22, 14, 23,
16, 23, 17, 24, 18, 24, 20, 23, 21, 23, 23, 23, 24, 24, 25, 23, 26, 23, 28, 21,
29, 21, 30, 21, 32, 21, 32, 20, 33, 20, 33, 19, 34, 19, 34, 19, 33, 18, 33, 16,
31, 15, 30, 15, 29, 15, 28, 14, 28, 13, 25, 12, 25, 11, 24, 10, 22, 8, 21, 7,
19, 5, 19, 3, 17, 2, 16, 1, 15, -1, 14, -2, 12, -3, 11, -5, 9, -7, 8, -8, 7,
-10, 5, -10, 3, -12, 3, -13, 1, -14, -2, -14, -3, -15, -5, -16, -6, -16, -7,
-18, -9, -19, -11, -19, -13, -20, -15, -22, -16, -22, -18, -24, -21, -25, -21,
-25, -23, -26, -24, -28, -26, -28, -27, -29, -29, -31, -31, -32, -33, -34, -33,
-33, -35, -34, -35, -34, -35, -33, -36, -33, -35, -32, -35, -31, -35, -29, -35,
-29, -34, -28, -34, -26, -32, -25, -31, -24, -31, -23, -30, -20, -29, -20, -29,
-18, -28, -16, -28, -16, -28, -15, -27, -15, -27, -13, -26, -12, -25, -11, -24,
-9, -23, -8, -23, -6, -21, -5, -21, -4, -20, -3, -19, -1, -18, -1, -15, 0, -15,
1, -13, 2, -12, 2, -10, 3, -9, 4, -7, 3, -5, 3, -4, 3, -1, 3, 0, 2, 1, 2, 2, 1,
3, 1, 4, 2, 5, 0, 5, 1, 5, 1, 5, 0, 5, 0, 6, 0, 6, -1, 5, -1, 5, -1, 5, -1, 4,
0, 3, 0, 3, 0, 3, 0, 3, 1, 3, 2, 2, 1, 2, 2, 3, 2, 3, 3, 4, 2, 4, 3, 5, 4, 6, 4,
6, 5, 6, 5, 7, 5, 8, 6, 8, 6, 8, 5, 9, 6, 10, 5, 10, 6, 10, 5, 10, 6, 10, 7, 9,
6, 8, 6, 8, 6, 9, 6, 7, 5, 7, 5, 6, 6, 6, 5, 6, 5, 5, 6, 4, 5, 3, 4, 2, 3, 1, 2,
0, 2, -1, -1, -2, 0, -3, -2, -3, -3, -5, -5, -4, -5, -5, -5, -5, -6, -5, -5, -4,
-5, -4, -4, -4, -3, -5, -3, -5, -2, -4, -2, -3, 0, -3, };