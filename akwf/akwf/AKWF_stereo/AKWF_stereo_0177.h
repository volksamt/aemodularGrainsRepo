#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0177

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 39, 2, 48, 5, 44, 8, 48, 11, 46,
12, 48, 15, 46, 17, 49, 19, 48, 23, 51, 26, 51, 28, 52, 31, 50, 34, 52, 37, 51,
41, 53, 45, 54, 48, 54, 50, 54, 53, 54, 55, 55, 59, 55, 62, 56, 63, 55, 67, 56,
69, 56, 72, 55, 75, 56, 78, 56, 81, 57, 83, 57, 84, 56, 86, 56, 88, 57, 89, 57,
91, 56, 92, 56, 93, 55, 95, 56, 96, 55, 98, 56, 99, 57, 99, 56, 99, 58, 100, 58,
102, 60, 102, 60, 102, 60, 102, 60, 103, 61, 103, 61, 103, 62, 103, 63, 102, 64,
103, 63, 102, 65, 103, 67, 103, 67, 104, 68, 103, 68, 104, 69, 104, 70, 104, 71,
105, 72, 104, 73, 105, 72, 105, 72, 106, 73, 105, 73, 106, 75, 106, 75, 106, 74,
107, 75, 107, 74, 108, 74, 108, 74, 108, 74, 109, 74, 109, 74, 110, 74, 110, 74,
110, 75, 111, 74, 112, 75, 112, 74, 112, 75, 113, 76, 112, 75, 112, 76, 111, 76,
112, 76, 111, 76, 111, 76, 110, 77, 109, 78, 109, 78, 109, 80, 108, 81, 107, 83,
106, 85, 105, 87, 105, 87, 104, 88, 103, 88, 101, 89, 99, 89, 98, 91, 96, 92,
95, 94, 94, 96, 93, 98, 90, 99, 89, 98, 87, 100, 85, 100, 84, 100, 82, 101, 80,
99, 78, 98, 76, 98, 75, 98, 73, 98, 71, 98, 69, 98, 67, 97, 65, 95, 64, 92, 61,
89, 60, 88, 57, 86, 55, 83, 54, 82, 53, 79, 51, 76, 50, 74, 47, 72, 45, 69, 42,
65, 41, 62, 39, 60, 39, 56, 38, 54, 36, 50, 34, 46, 34, 44, 31, 40, 30, 37, 29,
35, 27, 33, 26, 29, 26, 27, 25, 26, 26, 23, 25, 23, 24, 20, 22, 18, 22, 16, 22,
16, 22, 15, 22, 14, 21, 13, 22, 13, 22, 13, 23, 12, 24, 13, 23, 12, 23, 10, 24,
11, 24, 12, 26, 12, 27, 14, 29, 13, 29, 13, 30, 15, 32, 15, 34, 17, 35, 17, 37,
18, 38, 18, 38, 17, 40, 16, 41, 15, 41, 14, 43, 14, 43, 14, 44, 14, 44, 14, 45,
11, 45, 9, 44, 6, 44, 4, 44, 1, 45, 0, 45, -2, 44, -5, 44, -8, 42, -12, 43, -15,
41, -17, 41, -18, 40, -21, 39, -25, 38, -28, 37, -31, 36, -35, 35, -37, 32, -40,
30, -44, 28, -47, 27, -49, 26, -51, 25, -52, 24, -55, 21, -57, 21, -57, 20, -59,
20, -59, 18, -60, 19, -60, 18, -59, 18, -58, 18, -59, 18, -57, 20, -56, 19, -55,
19, -54, 18, -52, 18, -51, 18, -50, 19, -47, 20, -45, 20, -44, 21, -43, 21, -41,
23, -41, 22, -39, 22, -37, 22, -35, 23, -33, 23, -31, 22, -32, 22, -31, 20, -32,
18, -32, 18, -32, 17, -33, 16, -33, 15, -33, 13, -34, 11, -35, 9, -37, 7, -37,
5, -39, 3, -38, 0, -40, -2, -41, -5, -44, -7, -45, -9, -47, -13, -49, -15, -51,
-18, -52, -23, -55, -26, -57, -30, -58, -32, -60, -35, -61, -39, -62, -43, -64,
-45, -65, -48, -65, -51, -66, -54, -67, -57, -66, -59, -67, -62, -67, -64, -68,
-65, -67, -69, -68, -71, -68, -73, -68, -74, -67, -76, -66, -77, -67, -80, -67,
-84, -68, -85, -68, -86, -66, -86, -65, -87, -64, -89, -65, -91, -64, -91, -64,
-92, -64, -92, -64, -93, -64, -94, -66, -96, -67, -96, -68, -96, -68, -96, -68,
-97, -70, -97, -69, -96, -70, -97, -72, -98, -74, -98, -74, -98, -76, -97, -77,
-97, -77, -96, -76, -96, -78, -95, -79, -96, -80, -96, -82, -97, -84, -97, -84,
-98, -85, -98, -86, -98, -88, -98, -88, -98, -89, -98, -90, -99, -90, -99, -91,
-100, -92, -101, -93, -102, -93, -101, -94, -102, -92, -102, -92, -102, -92,
-103, -93, -104, -92, -104, -92, -104, -91, -104, -92, -104, -93, -105, -93,
-105, -94, -107, -95, -108, -94, -109, -93, -110, -94, -110, -93, -110, -96,
-110, -97, -111, -97, -111, -98, -111, -99, -111, -99, -112, -101, -111, -102,
-112, -102, -112, -103, -112, -104, -112, -106, -111, -108, -111, -110, -111,
-113, -110, -113, -109, -113, -108, -114, -107, -113, -106, -114, -104, -115,
-104, -116, -102, -117, -101, -118, -100, -118, -98, -119, -96, -118, -95, -118,
-93, -117, -91, -117, -88, -117, -86, -115, -85, -114, -82, -113, -81, -112,
-79, -109, -76, -108, -75, -105, -73, -102, -70, -100, -69, -98, -66, -95, -65,
-92, -63, -88, -61, -86, -59, -82, -58, -79, -56, -76, -54, -73, -52, -69, -51,
-65, -49, -62, -49, -59, -48, -57, -47, -55, -45, -52, -45, -48, -43, -44, -41,
-40, -40, -36, -38, -33, -38, -30, -39, -28, -38, -26, -38, -24, -37, -22, -36,
-20, -37, -19, -36, -16, -35, -15, -34, -11, -33, -9, -33, -8, -33, -7, -34, -7,
-35, -7, -36, -6, -35, -5, -35, -4, -35, -3, -35, -4, -34, -2, -34, -2, -34, -1,
-35, 0, -35, 1, -36, 1, -36, 3, -36, 3, -35, 5, -36, 7, -35, 8, -34, 8, -35, 8,
-33, 9, -34, 10, -34, 12, -34, 14, -34, 15, -34, 17, -33, 18, -33, 20, -33, 23,
-31, 25, -30, 28, -30, 29, -31, 31, -31, 32, -30, 35, -29, 38, -29, 40, -28, 44,
-28, 48, -27, 49, -27, 52, -26, 54, -26, 55, -25, 58, -24, 60, -24, 61, -23, 64,
-22, 66, -22, 68, -22, 69, -21, 71, -22, 71, -21, 73, -21, 72, -20, 72, -21, 72,
-20, 71, -21, 71, -19, 70, -19, 70, -18, 71, -18, 70, -20, 68, -20, 66, -21, 65,
-20, 62, -20, 63, -20, 61, -19, 61, -20, 59, -19, 58, -20, 56, -19, 55, -19, 54,
-19, 52, -20, 52, -19, 51, -18, 49, -18, 46, -17, 46, -17, 44, -16, 45, -14, 44,
-14, 46, -13, 45, -11, 45, -11, 43, -9, 44, -8, 43, -6, 45, -4, 43, -2, 48, -1,
38, };