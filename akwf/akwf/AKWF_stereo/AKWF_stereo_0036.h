#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0036

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -48, 5, -58, 9, -54, 11, -57, 14,
-54, 17, -57, 21, -54, 24, -57, 27, -55, 30, -57, 33, -56, 37, -57, 39, -56, 42,
-58, 46, -57, 49, -58, 52, -58, 55, -58, 57, -58, 61, -57, 64, -58, 67, -58, 69,
-58, 71, -57, 74, -58, 77, -58, 79, -57, 81, -58, 83, -57, 86, -58, 88, -57, 91,
-57, 92, -56, 95, -56, 97, -56, 98, -55, 100, -56, 102, -56, 103, -55, 105, -54,
107, -54, 108, -53, 110, -52, 111, -52, 112, -51, 113, -51, 114, -50, 115, -49,
115, -48, 116, -47, 117, -46, 118, -46, 118, -45, 119, -43, 118, -42, 119, -41,
119, -40, 119, -38, 119, -38, 119, -37, 119, -34, 118, -35, 117, -33, 118, -31,
117, -29, 117, -28, 116, -26, 115, -25, 114, -24, 113, -22, 111, -20, 111, -18,
109, -16, 108, -15, 107, -12, 106, -11, 104, -9, 102, -7, 100, -5, 98, -3, 96,
-1, 95, 2, 94, 3, 91, 5, 89, 8, 87, 10, 86, 13, 83, 15, 81, 17, 79, 20, 76, 21,
73, 24, 71, 27, 69, 29, 67, 31, 64, 33, 61, 36, 59, 39, 56, 41, 53, 43, 51, 46,
48, 48, 46, 50, 44, 53, 40, 55, 38, 58, 34, 60, 33, 63, 29, 65, 26, 67, 24, 69,
21, 72, 19, 73, 16, 75, 14, 78, 11, 80, 8, 81, 6, 84, 2, 85, 0, 87, -3, 89, -5,
91, -7, 93, -10, 94, -12, 96, -15, 97, -18, 98, -20, 100, -23, 101, -25, 102,
-27, 104, -29, 104, -32, 105, -33, 106, -36, 107, -38, 108, -40, 108, -42, 109,
-44, 109, -46, 110, -47, 110, -50, 110, -52, 111, -54, 110, -56, 110, -58, 110,
-59, 110, -62, 110, -63, 109, -65, 109, -67, 107, -68, 107, -69, 107, -71, 105,
-72, 104, -73, 103, -75, 102, -77, 100, -78, 100, -79, 98, -80, 97, -81, 96,
-83, 93, -83, 92, -85, 89, -86, 88, -87, 86, -87, 84, -87, 82, -89, 80, -90, 77,
-91, 75, -92, 73, -92, 70, -92, 67, -93, 65, -93, 62, -95, 59, -95, 57, -96, 53,
-95, 51, -95, 48, -97, 45, -96, 41, -97, 39, -96, 34, -96, 32, -98, 28, -97, 26,
-96, 22, -97, 19, -96, 15, -96, 12, -96, 8, -96, 5, -96, 2, -95, -2, -94, -6,
-94, -9, -93, -13, -93, -16, -92, -19, -91, -23, -91, -26, -90, -30, -88, -33,
-87, -35, -88, -39, -86, -43, -86, -45, -84, -49, -83, -52, -81, -55, -80, -57,
-80, -62, -78, -64, -77, -67, -76, -71, -74, -72, -73, -75, -71, -78, -70, -80,
-68, -83, -67, -86, -65, -89, -63, -91, -62, -93, -60, -94, -58, -97, -56, -99,
-54, -100, -52, -102, -50, -104, -48, -106, -46, -108, -44, -110, -42, -110,
-41, -111, -37, -113, -36, -113, -34, -115, -31, -116, -29, -116, -27, -117,
-25, -117, -22, -117, -20, -119, -17, -118, -14, -118, -12, -119, -11, -120, -7,
-119, -4, -119, -2, -119, 1, -118, 3, -118, 5, -118, 8, -117, 10, -116, 12,
-116, 14, -115, 17, -114, 20, -113, 22, -112, 24, -111, 27, -109, 30, -108, 32,
-107, 34, -106, 37, -104, 39, -102, 42, -101, 44, -99, 46, -97, 49, -94, 50,
-93, 53, -91, 55, -89, 58, -87, 60, -85, 62, -82, 64, -80, 65, -77, 68, -75, 69,
-72, 72, -70, 74, -68, 75, -65, 77, -63, 78, -59, 80, -57, 82, -54, 83, -51, 85,
-49, 86, -46, 87, -43, 89, -40, 89, -37, 90, -33, 92, -31, 93, -29, 95, -25, 95,
-22, 96, -20, 98, -17, 98, -14, 99, -11, 99, -7, 100, -4, 101, -2, 102, 2, 101,
4, 103, 7, 102, 10, 103, 13, 103, 16, 103, 19, 103, 21, 103, 24, 104, 27, 103,
29, 102, 31, 102, 35, 102, 38, 102, 40, 101, 42, 101, 45, 100, 47, 100, 50, 99,
51, 98, 54, 96, 56, 97, 57, 95, 61, 95, 63, 93, 64, 93, 66, 91, 68, 89, 70, 89,
72, 87, 73, 86, 75, 84, 76, 83, 78, 81, 80, 81, 81, 78, 82, 76, 84, 75, 84, 73,
85, 71, 86, 69, 88, 67, 89, 65, 88, 64, 89, 62, 89, 59, 91, 58, 91, 54, 91, 53,
91, 51, 92, 49, 93, 47, 92, 44, 92, 42, 92, 40, 93, 37, 92, 36, 92, 33, 92, 31,
91, 29, 91, 27, 91, 24, 91, 23, 91, 20, 90, 18, 88, 16, 89, 13, 88, 11, 87, 8,
86, 6, 85, 4, 84, 2, 84, -1, 83, -3, 81, -4, 80, -7, 79, -10, 78, -11, 76, -15,
75, -16, 74, -19, 72, -20, 71, -23, 70, -25, 68, -27, 67, -30, 64, -32, 63, -33,
62, -36, 60, -38, 58, -40, 57, -42, 56, -44, 53, -47, 51, -49, 50, -51, 48, -52,
47, -55, 44, -57, 42, -59, 41, -61, 40, -62, 38, -64, 36, -66, 34, -69, 32, -70,
30, -71, 29, -74, 27, -76, 25, -76, 24, -79, 22, -81, 19, -81, 19, -84, 16, -85,
15, -86, 14, -88, 11, -90, 10, -91, 7, -92, 7, -93, 5, -95, 3, -96, 1, -97, 0,
-98, -2, -99, -3, -101, -4, -101, -7, -103, -7, -103, -8, -104, -10, -104, -11,
-106, -12, -105, -15, -106, -16, -107, -17, -107, -18, -108, -19, -108, -21,
-107, -22, -109, -23, -108, -24, -109, -25, -107, -26, -107, -27, -107, -29,
-108, -30, -108, -30, -107, -31, -106, -32, -106, -33, -105, -33, -104, -35,
-104, -36, -103, -36, -102, -37, -101, -39, -100, -39, -100, -39, -98, -40, -97,
-41, -95, -41, -94, -42, -92, -42, -92, -42, -90, -43, -88, -44, -87, -44, -85,
-46, -83, -45, -80, -45, -79, -46, -76, -47, -75, -46, -72, -48, -70, -48, -68,
-48, -66, -48, -63, -49, -62, -49, -59, -49, -56, -49, -53, -50, -51, -51, -48,
-50, -46, -51, -44, -51, -40, -52, -37, -51, -34, -53, -32, -51, -28, -54, -25,
-52, -22, -54, -19, -52, -17, -55, -13, -52, -10, -56, -7, -52, -3, -58, -1,
-47, };