#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0078

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 13, 2, 19, 3, 20, 6, 22, 7, 23, 8,
26, 9, 27, 11, 29, 13, 31, 16, 32, 17, 35, 18, 36, 19, 38, 21, 40, 23, 42, 24,
43, 26, 45, 27, 46, 29, 48, 30, 50, 33, 51, 33, 53, 35, 54, 37, 56, 38, 58, 39,
59, 41, 60, 43, 62, 44, 63, 46, 64, 47, 67, 48, 67, 50, 69, 52, 70, 52, 71, 53,
73, 54, 75, 55, 76, 58, 77, 58, 77, 59, 78, 60, 80, 61, 82, 62, 82, 63, 83, 63,
85, 65, 86, 65, 87, 67, 88, 67, 88, 68, 89, 69, 92, 70, 91, 71, 94, 72, 94, 73,
95, 73, 96, 73, 97, 73, 98, 74, 99, 74, 99, 75, 100, 75, 101, 76, 101, 77, 102,
77, 103, 77, 103, 77, 105, 78, 105, 78, 105, 80, 107, 79, 108, 79, 108, 80, 109,
80, 109, 81, 110, 81, 111, 81, 111, 81, 112, 82, 112, 82, 113, 83, 113, 83, 112,
82, 113, 82, 114, 83, 115, 83, 115, 84, 116, 83, 115, 84, 116, 84, 117, 84, 116,
83, 117, 85, 117, 85, 117, 84, 117, 84, 117, 85, 119, 85, 117, 86, 119, 86, 119,
85, 118, 86, 120, 86, 120, 86, 118, 87, 119, 87, 119, 87, 120, 82, 116, 76, 110,
74, 108, 71, 105, 70, 103, 68, 101, 67, 99, 66, 97, 66, 94, 64, 92, 63, 90, 63,
88, 62, 86, 61, 83, 61, 82, 59, 81, 58, 79, 58, 78, 57, 76, 56, 75, 56, 74, 56,
71, 54, 70, 54, 68, 53, 67, 52, 65, 52, 63, 51, 63, 50, 61, 50, 60, 48, 59, 48,
57, 47, 57, 46, 55, 45, 54, 45, 53, 44, 52, 43, 49, 43, 48, 42, 48, 40, 46, 40,
46, 40, 44, 38, 43, 37, 42, 37, 40, 35, 40, 35, 38, 33, 36, 33, 36, 32, 35, 31,
34, 35, 32, 34, 32, 34, 30, 34, 29, 33, 27, 32, 26, 30, 25, 29, 24, 28, 23, 27,
22, 25, 21, 23, 20, 23, 20, 22, 18, 19, 18, 18, 16, 17, 16, 16, 15, 15, 14, 13,
13, 13, 12, 11, 11, 11, 10, 9, 9, 9, 8, 8, 7, 7, 6, 6, 6, 4, 5, 4, 3, 2, 3, 2,
2, 1, 1, 0, 0, 0, 0, -2, -2, -2, -3, -3, -3, -4, -5, -5, -5, -6, -5, -6, -7, -8,
-7, -8, -9, -8, -10, -9, -10, -10, -11, -10, -13, -10, -12, -12, -13, -12, -14,
-12, -14, -13, -16, -13, -16, -13, -17, -14, -18, -15, -19, -15, -20, -15, -20,
-16, -21, -17, -23, -17, -23, -18, -24, -18, -25, -19, -25, -19, -26, -19, -26,
-20, -28, -21, -27, -20, -29, -20, -30, -20, -30, -20, -29, -21, -31, -21, -31,
-23, -32, -23, -34, -24, -34, -25, -35, -26, -37, -25, -37, -26, -38, -27, -39,
-28, -39, -28, -41, -29, -42, -29, -41, -29, -41, -30, -43, -30, -43, -31, -44,
-30, -45, -32, -45, -32, -46, -32, -46, -33, -46, -33, -48, -34, -49, -35, -49,
-36, -50, -35, -51, -37, -51, -37, -52, -38, -53, -39, -52, -39, -54, -39, -54,
-40, -56, -41, -56, -41, -56, -41, -56, -42, -57, -43, -57, -43, -58, -44, -59,
-45, -59, -45, -60, -46, -61, -46, -62, -46, -62, -47, -62, -47, -63, -48, -64,
-49, -64, -49, -65, -49, -65, -50, -67, -50, -67, -51, -67, -51, -68, -52, -68,
-52, -68, -52, -69, -53, -70, -53, -71, -54, -72, -55, -72, -55, -72, -55, -73,
-55, -74, -56, -75, -57, -74, -57, -75, -56, -76, -57, -76, -58, -76, -59, -77,
-58, -77, -60, -78, -63, -78, -64, -79, -64, -79, -65, -80, -65, -81, -65, -81,
-65, -81, -66, -82, -66, -83, -65, -83, -65, -83, -65, -83, -66, -84, -65, -84,
-66, -86, -66, -86, -66, -86, -66, -86, -67, -87, -67, -87, -67, -88, -67, -88,
-67, -89, -67, -89, -68, -90, -68, -91, -68, -91, -68, -91, -69, -91, -70, -92,
-69, -92, -69, -93, -68, -92, -66, -91, -66, -90, -66, -91, -65, -91, -66, -91,
-67, -90, -66, -91, -66, -92, -66, -91, -66, -92, -67, -92, -67, -92, -67, -92,
-69, -92, -68, -92, -69, -93, -69, -94, -68, -93, -68, -93, -67, -94, -67, -95,
-67, -95, -68, -95, -69, -95, -69, -95, -69, -96, -69, -96, -69, -95, -71, -98,
-70, -97, -70, -97, -71, -98, -71, -98, -72, -98, -72, -98, -73, -99, -73, -99,
-74, -100, -74, -100, -74, -101, -75, -102, -75, -102, -75, -103, -75, -102,
-76, -102, -76, -103, -76, -102, -76, -103, -77, -102, -76, -103, -76, -103,
-76, -104, -77, -104, -77, -104, -78, -105, -78, -105, -79, -106, -78, -105,
-80, -106, -79, -106, -79, -106, -79, -107, -80, -108, -79, -107, -80, -108,
-80, -108, -80, -108, -80, -109, -80, -109, -81, -109, -81, -109, -82, -110,
-81, -110, -81, -110, -81, -111, -82, -112, -82, -111, -82, -111, -83, -111,
-82, -112, -83, -112, -83, -112, -83, -112, -83, -113, -83, -113, -83, -113,
-84, -114, -84, -114, -84, -114, -84, -114, -84, -114, -85, -115, -84, -115,
-85, -114, -85, -115, -85, -115, -85, -116, -86, -115, -85, -116, -86, -116,
-87, -116, -86, -116, -86, -116, -86, -116, -86, -117, -87, -117, -87, -116,
-87, -117, -86, -117, -87, -117, -87, -117, -87, -118, -87, -117, -87, -117,
-87, -118, -88, -117, -87, -118, -88, -118, -88, -118, -88, -118, -88, -118,
-87, -118, -88, -118, -88, -118, -89, -117, -88, -118, -89, -118, -88, -118,
-89, -119, -85, -115, -72, -104, -66, -99, -63, -95, -58, -91, -55, -87, -53,
-83, -51, -79, -48, -75, -47, -70, -45, -65, -43, -62, -40, -57, -39, -54, -37,
-51, -36, -48, -34, -45, -33, -43, -32, -39, -30, -38, -28, -35, -27, -32, -25,
-29, -24, -27, -22, -23, -20, -20, -19, -17, -18, -15, -17, -13, -15, -10, -13,
-8, -12, -6, -11, -5, -10, -1, -8, 0, -6, 3, -5, 5, -5, 7, -3, 9, -2, 12, -1,
12, };