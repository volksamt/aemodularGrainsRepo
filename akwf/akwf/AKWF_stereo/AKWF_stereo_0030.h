#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -21, 2, -28, 3, -28, 3, -30, 5,
-31, 5, -32, 7, -33, 7, -35, 9, -35, 10, -37, 11, -37, 11, -38, 13, -39, 13,
-39, 15, -40, 15, -41, 16, -40, 17, -41, 17, -40, 19, -40, 19, -40, 20, -39, 21,
-40, 21, -38, 22, -38, 23, -37, 23, -37, 25, -35, 25, -34, 25, -33, 26, -32, 27,
-30, 27, -28, 27, -26, 27, -24, 28, -23, 29, -21, 29, -19, 30, -17, 30, -15, 30,
-13, 31, -10, 31, -9, 31, -7, 32, -5, 32, -3, 32, -1, 32, 1, 32, 4, 33, 5, 32,
7, 33, 10, 33, 12, 32, 14, 32, 15, 32, 18, 31, 19, 31, 21, 32, 23, 32, 24, 32,
27, 31, 28, 31, 31, 31, 33, 30, 35, 30, 37, 30, 40, 30, 42, 30, 44, 30, 46, 29,
48, 29, 49, 29, 52, 28, 53, 29, 55, 30, 57, 29, 58, 28, 60, 28, 62, 28, 63, 28,
66, 28, 67, 28, 69, 28, 71, 29, 73, 28, 74, 29, 76, 29, 78, 29, 80, 29, 81, 30,
82, 31, 84, 30, 85, 31, 86, 32, 86, 33, 87, 34, 90, 35, 90, 35, 91, 36, 91, 38,
93, 39, 94, 40, 95, 42, 94, 44, 95, 44, 96, 46, 95, 48, 95, 49, 95, 52, 96, 53,
94, 54, 95, 56, 93, 59, 93, 60, 93, 62, 93, 63, 92, 66, 92, 67, 92, 69, 92, 72,
91, 73, 91, 76, 89, 77, 89, 78, 89, 81, 87, 82, 85, 83, 85, 85, 83, 87, 81, 88,
79, 90, 78, 92, 76, 93, 74, 94, 72, 95, 70, 96, 68, 98, 65, 98, 64, 99, 61, 101,
58, 101, 56, 102, 53, 102, 50, 103, 47, 104, 44, 104, 40, 104, 37, 105, 33, 105,
30, 105, 27, 106, 24, 106, 21, 106, 17, 106, 13, 106, 9, 105, 6, 105, 2, 105,
-1, 105, -4, 105, -9, 105, -12, 105, -16, 105, -20, 104, -23, 104, -28, 104,
-32, 104, -36, 104, -39, 103, -43, 104, -48, 103, -51, 103, -55, 103, -58, 103,
-61, 103, -65, 102, -69, 102, -73, 102, -76, 102, -79, 101, -83, 101, -86, 100,
-89, 100, -92, 99, -95, 99, -98, 98, -101, 98, -103, 98, -106, 96, -108, 96,
-110, 96, -111, 94, -113, 94, -113, 94, -115, 92, -116, 92, -117, 91, -117, 90,
-118, 89, -119, 88, -119, 86, -119, 86, -118, 84, -119, 84, -118, 82, -118, 80,
-117, 79, -116, 77, -115, 76, -113, 75, -112, 73, -110, 71, -108, 70, -107, 68,
-105, 66, -103, 65, -100, 63, -98, 62, -95, 60, -93, 58, -91, 56, -88, 55, -85,
53, -82, 50, -78, 49, -76, 47, -72, 45, -70, 43, -67, 41, -62, 39, -58, 38, -55,
35, -52, 33, -48, 31, -44, 29, -41, 28, -37, 27, -34, 24, -30, 23, -27, 22, -22,
20, -19, 18, -16, 16, -13, 15, -10, 14, -7, 12, -4, 11, 0, 10, 2, 7, 6, 6, 9, 5,
12, 3, 15, 2, 17, 2, 21, 0, 23, -2, 25, -2, 29, -4, 30, -4, 33, -5, 35, -5, 37,
-6, 39, -6, 40, -8, 41, -9, 43, -9, 43, -10, 45, -11, 45, -11, 47, -12, 48, -13,
48, -13, 48, -14, 49, -14, 48, -14, 49, -15, 49, -16, 49, -15, 49, -15, 49, -15,
49, -15, 48, -16, 47, -16, 46, -16, 46, -16, 45, -16, 45, -16, 43, -16, 42, -16,
41, -16, 41, -16, 40, -15, 37, -16, 37, -16, 35, -16, 33, -15, 31, -15, 29, -16,
27, -15, 25, -15, 23, -15, 20, -14, 17, -15, 16, -15, 13, -15, 9, -15, 7, -15,
5, -14, 3, -15, 0, -14, -3, -13, -6, -14, -8, -14, -10, -14, -13, -14, -15, -14,
-18, -14, -20, -14, -22, -14, -25, -14, -28, -13, -29, -14, -32, -15, -34, -14,
-37, -14, -38, -15, -40, -15, -43, -16, -46, -17, -47, -17, -50, -18, -51, -20,
-53, -20, -55, -21, -57, -21, -58, -22, -61, -24, -62, -26, -64, -26, -65, -27,
-67, -29, -68, -30, -70, -31, -72, -33, -73, -35, -76, -36, -78, -39, -79, -40,
-80, -42, -81, -44, -83, -45, -84, -47, -85, -50, -87, -51, -88, -53, -89, -54,
-90, -57, -91, -59, -91, -60, -92, -63, -93, -64, -93, -66, -93, -69, -94, -71,
-95, -72, -95, -74, -95, -76, -95, -78, -95, -81, -95, -81, -94, -84, -95, -86,
-93, -88, -94, -89, -93, -91, -93, -92, -91, -94, -90, -96, -89, -97, -89, -99,
-87, -101, -87, -102, -86, -103, -84, -104, -83, -105, -83, -106, -80, -107,
-79, -108, -77, -110, -76, -111, -73, -111, -72, -112, -69, -114, -67, -114,
-65, -114, -63, -115, -60, -115, -58, -116, -55, -117, -53, -116, -50, -118,
-47, -118, -43, -118, -41, -118, -38, -118, -36, -118, -32, -118, -28, -119,
-24, -119, -22, -120, -18, -119, -14, -119, -10, -118, -7, -118, -3, -118, 1,
-117, 4, -118, 9, -117, 12, -117, 18, -115, 20, -116, 25, -115, 28, -114, 32,
-113, 37, -113, 40, -112, 44, -111, 47, -110, 50, -109, 53, -108, 57, -107, 60,
-107, 62, -106, 66, -104, 69, -103, 71, -102, 74, -100, 76, -100, 79, -99, 81,
-98, 83, -96, 85, -95, 87, -93, 89, -92, 91, -91, 92, -88, 93, -87, 95, -86, 96,
-85, 97, -82, 98, -82, 99, -80, 99, -80, 100, -79, 101, -78, 101, -77, 101, -75,
102, -74, 102, -72, 101, -72, 101, -69, 101, -67, 101, -67, 100, -66, 100, -64,
98, -64, 97, -62, 97, -60, 95, -59, 95, -57, 93, -56, 92, -54, 90, -53, 89, -53,
85, -52, 84, -49, 81, -48, 78, -46, 77, -46, 73, -44, 70, -42, 68, -40, 64, -39,
61, -37, 59, -36, 55, -35, 52, -33, 49, -31, 45, -31, 43, -28, 40, -27, 36, -26,
33, -25, 30, -23, 26, -21, 23, -20, 20, -19, 16, -17, 13, -15, 10, -13, 7, -12,
4, -10, 0, -10, -2, -8, -6, -7, -8, -6, -12, -5, -13, -4, -17, -3, -18, -2, -22,
0, -19, };