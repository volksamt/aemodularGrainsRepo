#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 13, 6, 19, 10, 21, 15, 26, 21, 30,
34, 45, 40, 46, 44, 47, 47, 47, 50, 48, 52, 52, 54, 55, 57, 60, 57, 60, 58, 61,
58, 64, 59, 66, 58, 67, 59, 66, 58, 67, 59, 68, 58, 70, 60, 70, 59, 70, 59, 71,
59, 72, 60, 72, 60, 73, 62, 74, 63, 76, 63, 76, 65, 77, 66, 77, 67, 77, 69, 79,
71, 79, 71, 81, 74, 81, 74, 83, 76, 83, 79, 85, 81, 86, 81, 87, 84, 88, 86, 89,
87, 90, 88, 91, 90, 92, 92, 93, 93, 94, 95, 95, 96, 96, 97, 96, 98, 97, 100, 99,
100, 99, 102, 100, 104, 101, 105, 102, 106, 103, 106, 104, 107, 105, 110, 104,
110, 105, 111, 105, 113, 107, 113, 107, 115, 107, 116, 109, 116, 110, 117, 110,
117, 111, 118, 111, 119, 111, 120, 113, 118, 112, 120, 113, 119, 114, 120, 113,
119, 114, 119, 114, 119, 115, 119, 116, 119, 116, 119, 116, 119, 116, 120, 115,
119, 116, 118, 117, 120, 116, 119, 118, 119, 117, 118, 118, 120, 118, 119, 118,
119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 118,
120, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 120, 118,
118, 120, 119, 119, 119, 118, 119, 119, 118, 119, 118, 118, 119, 118, 118, 117,
120, 117, 120, 118, 118, 117, 119, 118, 119, 118, 119, 117, 120, 116, 119, 116,
120, 115, 120, 115, 119, 116, 119, 114, 118, 114, 119, 114, 119, 114, 119, 113,
119, 112, 119, 112, 119, 111, 119, 111, 119, 111, 119, 110, 118, 109, 119, 108,
118, 108, 119, 107, 119, 107, 119, 106, 118, 106, 119, 106, 119, 106, 120, 104,
119, 104, 118, 102, 118, 103, 118, 102, 117, 101, 116, 101, 116, 99, 116, 99,
116, 99, 114, 97, 113, 97, 113, 96, 112, 94, 111, 95, 111, 93, 110, 92, 110, 92,
109, 92, 108, 90, 107, 89, 107, 89, 106, 89, 106, 88, 104, 87, 104, 86, 104, 85,
103, 84, 102, 83, 101, 83, 101, 82, 100, 80, 98, 79, 99, 79, 97, 77, 98, 77, 95,
76, 95, 74, 94, 74, 94, 73, 92, 72, 91, 71, 91, 71, 90, 69, 89, 68, 89, 67, 87,
66, 86, 66, 86, 65, 85, 64, 84, 63, 83, 62, 82, 61, 81, 60, 81, 59, 80, 58, 79,
57, 77, 56, 77, 56, 76, 54, 74, 54, 73, 52, 72, 50, 72, 50, 71, 49, 70, 47, 69,
47, 67, 46, 67, 44, 65, 43, 65, 42, 63, 42, 62, 41, 60, 40, 60, 38, 59, 37, 58,
36, 57, 35, 55, 35, 54, 32, 53, 32, 52, 31, 50, 29, 49, 29, 48, 27, 47, 26, 46,
24, 45, 23, 42, 22, 41, 20, 40, 20, 38, 18, 36, 17, 35, 16, 33, 15, 32, 13, 29,
11, 28, 9, 27, 8, 25, 7, 22, 5, 21, 3, 19, 2, 17, 0, 15, -2, 12, -3, 10, -6, 7,
-8, 5, -10, 2, -12, -1, -15, -5, -18, -9, -21, -14, -26, -20, -29, -33, -42,
-41, -48, -44, -47, -49, -47, -51, -47, -54, -51, -55, -55, -58, -59, -59, -60,
-59, -63, -60, -63, -61, -67, -62, -68, -62, -69, -64, -69, -64, -71, -64, -72,
-65, -73, -65, -75, -66, -74, -67, -77, -68, -77, -69, -79, -69, -79, -69, -80,
-71, -81, -71, -81, -72, -83, -74, -83, -75, -84, -75, -85, -76, -86, -79, -86,
-79, -86, -81, -87, -82, -88, -83, -89, -85, -90, -85, -91, -87, -91, -89, -92,
-89, -93, -91, -93, -92, -94, -94, -95, -95, -96, -97, -97, -97, -98, -99, -98,
-100, -98, -101, -99, -102, -100, -103, -100, -104, -101, -106, -101, -107,
-103, -108, -103, -109, -104, -110, -104, -111, -105, -111, -105, -113, -105,
-114, -107, -115, -107, -115, -107, -117, -108, -117, -109, -118, -109, -118,
-111, -120, -111, -119, -112, -119, -112, -120, -112, -119, -113, -119, -113,
-119, -114, -119, -115, -118, -116, -118, -115, -118, -116, -119, -117, -119,
-117, -119, -117, -119, -118, -119, -117, -119, -117, -120, -118, -120, -118,
-119, -118, -119, -119, -119, -119, -119, -118, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -120, -119, -120, -119, -119, -118, -119,
-118, -120, -118, -120, -119, -120, -118, -119, -118, -120, -117, -120, -117,
-119, -117, -118, -117, -119, -116, -119, -116, -118, -117, -119, -116, -118,
-116, -119, -115, -119, -115, -119, -114, -119, -114, -120, -113, -119, -112,
-120, -112, -119, -112, -119, -112, -118, -111, -119, -111, -119, -109, -119,
-109, -119, -109, -119, -108, -120, -108, -120, -107, -119, -106, -118, -106,
-119, -106, -119, -105, -119, -105, -119, -104, -119, -104, -117, -102, -117,
-102, -116, -100, -116, -101, -116, -99, -114, -99, -114, -97, -113, -97, -112,
-96, -112, -96, -110, -95, -111, -94, -109, -93, -109, -93, -109, -92, -108,
-91, -107, -90, -107, -89, -106, -88, -105, -87, -104, -87, -103, -87, -102,
-84, -103, -84, -101, -83, -101, -83, -100, -81, -100, -80, -98, -80, -98, -79,
-96, -78, -95, -76, -95, -75, -94, -75, -94, -73, -93, -72, -92, -71, -91, -70,
-90, -70, -88, -69, -89, -68, -88, -67, -86, -66, -85, -64, -83, -64, -83, -63,
-82, -63, -82, -60, -80, -59, -80, -59, -79, -58, -78, -56, -77, -56, -76, -55,
-74, -53, -74, -53, -72, -52, -71, -51, -70, -48, -69, -48, -68, -46, -67, -46,
-66, -44, -65, -43, -63, -42, -63, -42, -61, -40, -60, -39, -60, -38, -58, -36,
-56, -36, -55, -34, -54, -34, -52, -33, -52, -31, -50, -30, -49, -29, -47, -28,
-46, -25, -44, -25, -43, -23, -42, -21, -40, -20, -40, -19, -38, -17, -35, -17,
-34, -15, -33, -14, -30, -12, -29, -10, -27, -8, -26, -7, -23, -5, -22, -4, -19,
-2, -17, 0, -14, 1, -13, 3, -10, 5, -7, 7, -4, 11, -2, 10, };