#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0089

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, -25, 27, -17, 41, -3, 53, 5, 63,
18, 71, 26, 77, 37, 80, 44, 81, 53, 82, 59, 81, 67, 80, 73, 79, 80, 77, 85, 76,
90, 74, 95, 70, 98, 67, 100, 64, 101, 60, 102, 57, 102, 53, 100, 48, 99, 42, 96,
36, 94, 32, 93, 27, 91, 25, 90, 22, 90, 21, 91, 21, 91, 22, 93, 23, 95, 25, 97,
26, 98, 28, 99, 30, 99, 30, 99, 31, 99, 30, 97, 26, 95, 25, 95, 23, 92, 22, 92,
21, 92, 21, 91, 22, 91, 22, 91, 22, 90, 23, 89, 24, 87, 23, 85, 22, 81, 20, 77,
16, 72, 10, 67, 6, 60, 1, 56, -2, 51, -3, 48, 0, 46, 4, 47, 10, 47, 17, 48, 24,
50, 32, 50, 40, 50, 47, 49, 55, 48, 61, 46, 65, 43, 66, 39, 67, 36, 66, 32, 65,
30, 64, 27, 64, 25, 62, 24, 59, 22, 55, 21, 50, 17, 45, 14, 37, 9, 29, 4, 22, 0,
14, -6, 7, -11, -1, -16, -7, -21, -14, -25, -18, -27, -20, -28, -19, -29, -18,
-27, -16, -26, -15, -25, -13, -24, -12, -25, -12, -25, -11, -26, -12, -28, -13,
-30, -15, -32, -19, -36, -23, -38, -27, -42, -30, -45, -35, -48, -38, -50, -39,
-52, -42, -54, -43, -57, -46, -59, -48, -62, -50, -64, -52, -66, -54, -70, -58,
-73, -60, -75, -64, -80, -66, -82, -65, -83, -62, -82, -53, -80, -43, -73, -30,
-65, -15, -55, 0, -45, 14, -33, 29, -22, 42, -11, 54, 0, 63, 8, 71, 15, 77, 22,
80, 29, 82, 34, 83, 39, 82, 43, 81, 48, 78, 53, 73, 57, 68, 60, 62, 63, 55, 65,
47, 66, 40, 66, 33, 66, 25, 64, 17, 62, 9, 59, -1, 55, -12, 50, -20, 46, -26,
44, -32, 42, -34, 41, -35, 42, -33, 42, -32, 45, -27, 47, -22, 49, -17, 50, -10,
50, -7, 51, -3, 50, -2, 48, -3, 46, -6, 43, -9, 39, -14, 38, -15, 35, -18, 34,
-17, 32, -19, 30, -18, 27, -19, 25, -19, 21, -21, 15, -23, 10, -25, 6, -29, -1,
-32, -6, -36, -11, -39, -17, -39, -20, -36, -21, -30, -22, -19, -18, -7, -13, 6,
-8, 20, 0, 35, 7, 50, 15, 63, 22, 77, 28, 88, 34, 98, 39, 106, 43, 112, 47, 116,
49, 118, 52, 119, 56, 119, 59, 117, 62, 115, 65, 112, 66, 106, 69, 99, 71, 93,
70, 84, 71, 76, 70, 67, 67, 57, 64, 47, 61, 36, 56, 25, 52, 16, 48, 8, 44, 3,
42, -1, 41, -1, 41, -2, 42, 1, 44, 2, 46, 4, 48, 5, 49, 6, 50, 7, 51, 6, 49, 4,
49, 1, 46, -4, 43, -9, 40, -13, 38, -15, 35, -17, 33, -17, 30, -19, 28, -21, 27,
-24, 23, -26, 19, -30, 15, -33, 10, -37, 4, -42, -2, -45, -7, -50, -14, -53,
-18, -53, -22, -50, -23, -45, -23, -35, -20, -25, -16, -13, -8, -1, 0, 11, 7,
21, 16, 31, 24, 39, 31, 46, 37, 53, 42, 56, 48, 59, 52, 60, 56, 61, 59, 62, 62,
63, 65, 63, 69, 62, 72, 61, 74, 58, 75, 55, 77, 50, 76, 47, 76, 43, 75, 38, 71,
33, 69, 26, 64, 18, 59, 10, 54, 3, 50, -3, 47, -7, 43, -10, 42, -9, 42, -8, 42,
-5, 43, -2, 45, 4, 47, 8, 49, 13, 50, 17, 51, 19, 49, 19, 47, 17, 45, 13, 42,
10, 38, 5, 34, 3, 33, 0, 30, -1, 27, -3, 26, -5, 24, -7, 21, -10, 18, -14, 15,
-17, 10, -22, 4, -26, 0, -30, -6, -36, -11, -39, -17, -41, -22, -40, -25, -38,
-28, -35, -28, -28, -30, -22, -28, -16, -28, -11, -28, -5, -27, 1, -28, 6, -31,
12, -33, 16, -37, 22, -40, 24, -46, 27, -50, 28, -53, 29, -56, 31, -59, 31, -62,
30, -63, 29, -65, 27, -66, 22, -67, 18, -69, 12, -71, 7, -73, 0, -75, -8, -78,
-14, -82, -22, -85, -29, -90, -34, -91, -39, -92, -41, -93, -43, -93, -44, -92,
-47, -91, -49, -89, -52, -88, -53, -87, -56, -87, -59, -86, -61, -87, -62, -89,
-62, -90, -63, -92, -62, -94, -62, -96, -61, -97, -60, -98, -59, -98, -60, -99,
-61, -101, -64, -101, -68, -102, -72, -104, -74, -105, -77, -107, -79, -109,
-81, -110, -81, -112, -82, -114, -82, -115, -80, -113, -75, -110, -68, -104,
-59, -98, -48, -88, -36, -77, -25, -66, -14, -54, -1, -44, 10, -35, 20, -27, 28,
-20, 35, -15, 38, -11, 39, -9, 39, -8, 39, -6, 38, -5, 36, -2, 34, 0, 33, 2, 31,
4, 28, 4, 24, 4, 18, 2, 11, -1, 3, -6, -6, -10, -15, -16, -25, -21, -33, -26,
-42, -32, -47, -35, -52, -38, -51, -39, -50, -38, -48, -38, -46, -35, -45, -32,
-44, -31, -43, -29, -44, -29, -44, -29, -45, -29, -45, -31, -45, -33, -47, -37,
-47, -40, -47, -43, -48, -47, -48, -49, -48, -51, -47, -53, -47, -54, -49, -56,
-51, -57, -53, -59, -55, -61, -56, -64, -57, -67, -59, -70, -61, -74, -63, -77,
-63, -81, -63, -83, -59, -82, -53, -79, -43, -74, -32, -68, -20, -59, -8, -49,
5, -40, 17, -30, 29, -23, 39, -15, 48, -10, 54, -6, 57, -2, 58, -1, 56, 0, 54,
1, 51, 2, 49, 4, 46, 6, 43, 8, 39, 9, 34, 10, 28, 9, 22, 7, 13, 3, 5, -1, -5,
-5, -14, -11, -23, -16, -32, -22, -41, -27, -46, -32, -50, -34, -49, -35, -48,
-35, -46, -35, -43, -33, -42, -31, -42, -30, -43, -28, -43, -28, -46, -29, -47,
-29, -48, -31, -50, -34, -50, -37, -53, -41, -52, -45, -53, -48, -53, -51, -51,
-54, -51, -55, -52, -57, -53, -58, -56, -59, -57, -60, -60, -62, -62, -64, -64,
-68, -66, -71, -68, -77, -71, -79, -71, -84, -69, -83, -64, -83, -56, -78, -44,
-72, -31, -60, -14, -53, -1, -33, };