#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0027

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 57, 2, 71, 3, 67, 6, 71, 6, 69, 8,
74, 9, 72, 10, 76, 12, 75, 13, 78, 14, 78, 15, 81, 17, 81, 18, 81, 19, 81, 21,
82, 21, 83, 24, 83, 25, 85, 26, 85, 26, 85, 28, 85, 30, 86, 30, 86, 31, 85, 33,
85, 33, 84, 34, 83, 36, 84, 38, 82, 38, 83, 40, 82, 41, 81, 42, 80, 44, 81, 45,
80, 46, 80, 46, 79, 48, 79, 49, 79, 49, 78, 52, 78, 52, 77, 53, 77, 55, 76, 55,
77, 56, 76, 58, 75, 59, 74, 60, 73, 60, 72, 62, 71, 62, 69, 64, 69, 65, 68, 65,
67, 67, 67, 67, 66, 69, 66, 70, 65, 71, 66, 70, 66, 72, 65, 73, 66, 73, 65, 76,
66, 77, 65, 78, 65, 81, 64, 82, 64, 84, 64, 86, 64, 87, 64, 88, 64, 90, 64, 93,
65, 95, 65, 96, 66, 98, 65, 99, 66, 100, 65, 102, 66, 103, 65, 103, 65, 104, 64,
104, 63, 106, 63, 106, 61, 108, 60, 108, 59, 109, 58, 109, 57, 110, 57, 110, 56,
110, 54, 110, 53, 111, 52, 111, 51, 110, 48, 110, 47, 109, 46, 110, 43, 109, 40,
108, 38, 107, 36, 107, 33, 107, 32, 105, 28, 105, 26, 103, 24, 102, 22, 101, 21,
100, 18, 99, 16, 98, 15, 96, 14, 95, 13, 93, 12, 92, 12, 91, 11, 89, 11, 87, 11,
85, 10, 84, 10, 83, 9, 82, 9, 80, 10, 79, 8, 78, 9, 76, 8, 74, 8, 72, 6, 72, 6,
71, 6, 70, 5, 67, 5, 67, 4, 66, 2, 64, 2, 64, 1, 62, 0, 62, -1, 60, -3, 59, -4,
59, -5, 59, -7, 59, -7, 57, -8, 57, -8, 56, -9, 56, -8, 56, -10, 54, -8, 54, -9,
54, -8, 53, -7, 52, -7, 52, -7, 52, -5, 53, -5, 52, -3, 52, -3, 52, -2, 52, -1,
53, 1, 52, 2, 53, 3, 52, 4, 53, 6, 53, 7, 54, 8, 54, 9, 53, 10, 54, 11, 54, 12,
54, 12, 54, 14, 54, 13, 54, 14, 54, 15, 53, 14, 53, 14, 53, 14, 52, 14, 51, 12,
51, 12, 51, 10, 50, 10, 49, 10, 49, 9, 48, 8, 47, 7, 47, 5, 46, 4, 45, 3, 44, 2,
43, 1, 43, -1, 42, -2, 42, -3, 41, -5, 41, -5, 40, -7, 40, -9, 40, -10, 39, -12,
39, -14, 38, -15, 38, -17, 38, -20, 37, -22, 38, -24, 37, -26, 37, -29, 37, -31,
37, -34, 38, -37, 38, -40, 38, -43, 38, -46, 39, -50, 39, -54, 40, -56, 40, -61,
42, -63, 43, -67, 44, -69, 45, -73, 46, -76, 47, -79, 48, -81, 50, -85, 50, -89,
51, -91, 51, -94, 52, -96, 54, -100, 54, -102, 55, -105, 55, -107, 55, -109, 54,
-112, 55, -114, 55, -115, 55, -117, 55, -117, 54, -118, 55, -119, 54, -119, 55,
-120, 54, -119, 53, -119, 54, -118, 53, -117, 52, -118, 52, -116, 52, -116, 52,
-115, 51, -114, 50, -113, 50, -112, 49, -111, 48, -112, 48, -111, 47, -111, 46,
-110, 44, -110, 44, -110, 43, -110, 43, -108, 42, -110, 41, -108, 39, -108, 39,
-106, 37, -106, 35, -105, 34, -105, 34, -103, 33, -103, 31, -101, 31, -98, 28,
-97, 27, -95, 26, -94, 25, -93, 24, -91, 22, -88, 20, -87, 18, -85, 16, -83, 13,
-80, 11, -79, 9, -76, 6, -75, 3, -73, 1, -70, -3, -67, -5, -65, -9, -63, -13,
-61, -15, -58, -19, -56, -22, -53, -25, -50, -28, -49, -32, -46, -34, -44, -38,
-41, -40, -38, -43, -36, -45, -34, -48, -32, -50, -29, -53, -26, -55, -24, -56,
-21, -58, -19, -59, -17, -60, -15, -61, -12, -62, -11, -63, -9, -63, -6, -64,
-5, -64, -3, -65, 0, -65, 2, -65, 3, -64, 6, -64, 8, -65, 9, -64, 10, -64, 13,
-64, 14, -64, 16, -63, 16, -63, 18, -62, 20, -62, 21, -62, 21, -62, 22, -61, 23,
-62, 24, -61, 25, -61, 25, -61, 26, -62, 27, -62, 28, -62, 29, -64, 30, -64, 30,
-64, 32, -65, 31, -66, 33, -67, 33, -67, 34, -69, 33, -69, 34, -71, 36, -71, 36,
-72, 38, -73, 39, -75, 40, -76, 41, -77, 41, -78, 42, -78, 44, -80, 44, -82, 45,
-82, 45, -83, 46, -84, 46, -85, 46, -86, 45, -87, 46, -87, 46, -89, 46, -90, 45,
-90, 45, -91, 45, -92, 44, -93, 45, -93, 44, -95, 44, -95, 43, -96, 43, -98, 41,
-98, 41, -100, 39, -100, 37, -100, 35, -101, 34, -102, 31, -103, 29, -103, 27,
-104, 26, -105, 24, -105, 20, -105, 18, -106, 16, -107, 14, -108, 11, -109, 8,
-110, 6, -110, 3, -112, 0, -113, -3, -113, -5, -115, -8, -116, -12, -116, -14,
-116, -15, -116, -17, -117, -19, -117, -20, -117, -21, -118, -22, -118, -22,
-118, -24, -119, -24, -119, -25, -119, -26, -119, -27, -120, -28, -119, -30,
-119, -31, -118, -33, -119, -33, -118, -36, -118, -37, -117, -39, -117, -40,
-116, -42, -115, -43, -114, -45, -114, -45, -113, -46, -112, -46, -110, -46,
-109, -47, -108, -47, -107, -47, -105, -48, -105, -49, -104, -49, -103, -50,
-102, -51, -102, -51, -102, -51, -102, -51, -101, -52, -100, -51, -99, -52, -99,
-52, -99, -51, -99, -51, -98, -50, -98, -50, -97, -50, -97, -50, -98, -48, -97,
-48, -97, -46, -97, -46, -95, -44, -95, -43, -93, -41, -93, -39, -92, -35, -91,
-33, -90, -31, -88, -28, -87, -25, -86, -22, -84, -19, -83, -15, -81, -13, -79,
-9, -77, -7, -75, -3, -74, 0, -70, 4, -69, 5, -66, 9, -65, 12, -62, 16, -59, 17,
-57, 22, -55, 24, -52, 27, -49, 29, -46, 32, -44, 35, -41, 36, -38, 39, -36, 41,
-33, 43, -31, 43, -27, 46, -26, 46, -24, 50, -21, 50, -18, 53, -17, 52, -14, 56,
-11, 55, -9, 60, -8, 58, -6, 63, -4, 60, -3, 67, 0, 56, };