#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0072

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 5, 10, 4, 11, 5, 12, 5, 13, 6,
14, 5, 13, 5, 12, 5, 12, 5, 11, 4, 10, 2, 10, 3, 10, 3, 10, 2, 9, 3, 10, 4, 10,
4, 10, 5, 11, 5, 11, 4, 12, 6, 12, 6, 14, 7, 13, 7, 15, 7, 14, 7, 15, 7, 16, 7,
14, 7, 15, 7, 16, 8, 16, 8, 17, 8, 16, 8, 17, 9, 17, 8, 17, 9, 17, 9, 17, 9, 18,
10, 19, 9, 18, 10, 19, 9, 19, 10, 20, 10, 20, 10, 20, 10, 21, 10, 21, 10, 21,
10, 22, 11, 21, 11, 22, 11, 23, 12, 23, 11, 23, 11, 24, 11, 24, 13, 24, 11, 25,
12, 25, 11, 26, 13, 25, 12, 26, 12, 25, 12, 25, 13, 27, 13, 27, 13, 28, 13, 27,
12, 28, 13, 28, 13, 29, 14, 29, 13, 29, 13, 29, 14, 30, 14, 30, 14, 30, 14, 30,
14, 31, 15, 31, 15, 31, 15, 32, 14, 31, 15, 32, 15, 33, 15, 33, 16, 33, 16, 34,
15, 33, 16, 34, 16, 34, 16, 35, 16, 35, 16, 36, 16, 35, 17, 36, 17, 36, 17, 36,
17, 36, 17, 37, 18, 37, 18, 37, 17, 38, 18, 38, 17, 38, 18, 39, 18, 39, 18, 39,
18, 39, 19, 40, 19, 40, 19, 41, 19, 41, 19, 41, 20, 42, 19, 42, 20, 41, 19, 42,
20, 42, 19, 43, 22, 43, 13, 45, 4, 47, 21, 44, 11, 46, 8, 47, 15, 46, 18, 46,
18, 46, 18, 46, 20, 47, 21, 47, 22, 47, 22, 47, 23, 47, 23, 48, 24, 48, 23, 49,
24, 48, 24, 49, 25, 48, 25, 49, 25, 50, 25, 50, 26, 50, 25, 51, 25, 51, 25, 51,
26, 51, 26, 51, 26, 52, 26, 52, 26, 53, 26, 52, 26, 53, 27, 53, 26, 53, 27, 53,
26, 54, 26, 55, 27, 54, 27, 55, 27, 55, 28, 56, 27, 56, 28, 56, 28, 57, 28, 57,
28, 57, 28, 58, 28, 58, 29, 58, 28, 58, 28, 58, 28, 59, 29, 59, 28, 59, 29, 60,
28, 60, 28, 60, 29, 61, 29, 61, 29, 61, 29, 62, 30, 62, 29, 62, 30, 61, 30, 62,
30, 63, 30, 63, 30, 63, 31, 64, 31, 64, 31, 64, 31, 65, 31, 65, 32, 65, 31, 65,
32, 65, 32, 67, 31, 66, 32, 67, 32, 67, 32, 67, 32, 67, 33, 67, 32, 68, 33, 67,
32, 69, 31, 68, 34, 70, 32, 68, 34, 71, 33, 68, 35, 72, 31, 69, 36, 72, 33, 68,
36, 73, 32, 70, 36, 73, 33, 70, 36, 74, 33, 70, 36, 74, 34, 73, 35, 73, 35, 74,
33, 72, 39, 78, 32, 70, 42, 82, 25, 62, 57, 102, -75, -64, -49, -33, 9, 39, -93,
-93, -65, -67, -44, -49, -32, -45, -42, -71, -30, -66, -28, -74, -24, -75, -24,
-80, -21, -78, -21, -77, -21, -73, -20, -69, -21, -66, -19, -64, -20, -65, -18,
-63, -19, -67, -17, -67, -18, -72, -17, -72, -17, -76, -15, -75, -17, -76, -15,
-71, -17, -72, -17, -67, -18, -67, -18, -64, -19, -64, -19, -62, -20, -63, -20,
-65, -20, -65, -21, -66, -21, -68, -21, -68, -22, -68, -23, -68, -23, -66, -24,
-66, -24, -64, -25, -64, -25, -62, -26, -63, -27, -62, -28, -62, -27, -62, -29,
-64, -29, -64, -29, -64, -29, -64, -31, -63, -30, -62, -31, -62, -31, -60, -32,
-60, -32, -60, -33, -59, -33, -59, -33, -60, -33, -59, -33, -60, -34, -59, -34,
-59, -34, -59, -33, -59, -34, -59, -34, -58, -34, -57, -34, -56, -33, -56, -34,
-56, -33, -56, -34, -56, -34, -55, -33, -55, -32, -55, -31, -54, -32, -54, -32,
-54, -30, -54, -31, -53, -29, -53, -36, -52, -33, -51, -29, -52, -34, -50, -32,
-51, -30, -50, -29, -50, -28, -50, -27, -50, -26, -50, -26, -49, -25, -49, -23,
-48, -23, -48, -23, -48, -22, -47, -22, -47, -21, -48, -20, -46, -20, -47, -20,
-46, -20, -46, -19, -45, -19, -44, -18, -45, -18, -45, -18, -44, -18, -43, -17,
-43, -17, -43, -16, -43, -16, -43, -16, -41, -16, -42, -16, -41, -15, -41, -16,
-40, -16, -41, -15, -40, -15, -40, -14, -40, -14, -39, -15, -38, -15, -39, -15,
-38, -15, -38, -14, -37, -15, -37, -14, -37, -15, -37, -15, -36, -15, -37, -15,
-36, -15, -35, -15, -36, -15, -34, -15, -35, -15, -34, -16, -34, -15, -33, -16,
-34, -16, -33, -15, -33, -16, -32, -16, -33, -15, -32, -15, -31, -16, -31, -16,
-32, -16, -30, -15, -31, -16, -30, -15, -30, -16, -30, -16, -30, -15, -30, -15,
-29, -15, -29, -15, -28, -16, -27, -16, -27, -16, -28, -15, -27, -16, -26, -15,
-27, -15, -26, -14, -26, -15, -26, -15, -25, -15, -25, -15, -24, -15, -24, -13,
-24, -14, -23, -13, -24, -13, -23, -13, -22, -12, -23, -14, -22, -12, -21, -13,
-21, -10, -21, -13, -20, -11, -20, -12, -20, -9, -20, -13, -20, -9, -19, -12,
-18, -8, -18, -13, -17, -6, -18, -16, -17, -58, -10, -13, -16, -27, -14, -45,
-11, -26, -13, -18, -14, -16, -14, -18, -14, -11, -14, -10, -14, -8, -13, -8,
-13, -4, -14, -5, -14, -2, -13, -3, -12, -2, -13, -2, -12, -1, -12, -1, -12, -1,
-11, -1, -10, 0, -10, 0, -10, 0, -10, 0, -10, 0, -9, 1, -9, 0, -9, 0, -8, 0, -9,
0, -8, 1, -8, 1, -7, 1, -7, 1, -6, 1, -6, 1, -5, 0, -5, 1, -6, 1, -6, 1, -5, 0,
-5, 0, -4, 1, -4, 0, -4, 1, -3, 1, -3, 1, -2, 0, -2, 1, -3, 1, -1, 1, -2, 2, -1,
1, -1, 2, 1, 1, 0, 1, 1, 1, 1, 2, 1, 1, 2, 1, 2, 2, 3, 1, 2, 2, 4, 1, 2, 2, 4,
2, 2, 2, 5, 2, 3, 4, 7, -2, -5, -4, -8, 3, 8, -1, -2, 0, 0, };