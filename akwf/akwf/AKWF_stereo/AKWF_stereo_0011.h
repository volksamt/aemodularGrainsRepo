#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 30, 42, 85, 102, 108, 120, 109,
99, 108, 78, 109, 66, 112, 73, 117, 86, 118, 93, 115, 89, 111, 84, 108, 83, 107,
84, 103, 81, 96, 75, 91, 69, 88, 68, 86, 68, 82, 65, 78, 60, 75, 59, 74, 58, 72,
59, 71, 55, 68, 54, 66, 53, 66, 53, 65, 53, 64, 53, 63, 52, 63, 51, 64, 53, 63,
52, 63, 52, 64, 51, 64, 50, 34, 14, -23, -50, -48, -70, -46, -46, -44, -24, -45,
-13, -48, -20, -54, -34, -54, -41, -48, -36, -41, -31, -38, -30, -33, -32, -28,
-28, -20, -20, -12, -15, -7, -14, -3, -14, 2, -10, 7, -7, 12, -3, 14, -5, 17,
-4, 21, -3, 24, -1, 26, -1, 29, -1, 30, -1, 31, 0, 33, 1, 35, 0, 34, -1, 36, -2,
36, -2, 36, -2, 36, -3, 36, -3, 36, -4, 37, -4, 35, -5, 35, -7, 34, -7, 34, -8,
33, -8, 32, -9, 30, -10, 29, -10, 28, -11, 28, -11, 27, -13, 24, -14, 23, -14,
23, -14, 20, -15, 19, -16, 18, -16, 17, -17, 15, -17, 15, -18, 13, -18, 11, -19,
10, -19, 10, -19, 8, -20, 7, -20, 6, -21, 4, -21, 3, -22, 2, -22, 1, -22, 0,
-22, -1, -22, -2, -24, -2, -24, -4, -25, -4, -24, -6, -24, -6, -25, -8, -25, -8,
-25, -8, -25, -10, -26, -11, -26, -11, -26, -11, -27, -12, -26, -13, -27, -13,
-26, -14, -27, -15, -27, -16, -27, -16, -27, -17, -28, -17, -28, -18, -28, -18,
-27, -18, -28, -19, -29, -20, -28, -19, -28, -20, -28, -20, -29, -21, -29, -21,
-29, -21, -28, -22, -29, -22, -28, -22, -30, -23, -29, -23, -28, -23, -29, -23,
-29, -24, -30, -24, -29, -23, -30, -24, -30, -25, -30, -24, -30, -24, -30, -25,
-30, -25, -30, -26, -30, -25, -30, -25, -30, -26, -29, -27, -30, -26, -30, -27,
-31, -26, -30, -26, -29, -27, -30, -27, -31, -27, -30, -26, -30, -25, -30, -27,
-30, -27, -30, -26, -29, -26, -29, -27, -29, -27, -30, -27, -29, -27, -29, -27,
-29, -27, -29, -27, -29, -26, -29, -26, -29, -26, -29, -26, -28, -26, -29, -26,
-28, -26, -29, -25, -28, -26, -28, -25, -28, -25, -27, -26, -26, -25, -26, -26,
-27, -25, -26, -26, -26, -25, -26, -25, -26, -25, -25, -25, -25, -24, -25, -25,
-25, -24, -25, -24, -25, -23, -25, -24, -24, -23, -24, -24, -22, -23, -23, -23,
-23, -23, -23, -23, -23, -23, -22, -23, -22, -21, -21, -23, -21, -22, -22, -22,
-21, -21, -20, -21, -19, -22, -19, -21, -20, -22, -19, -20, -20, -21, -18, -21,
-18, -20, -18, -20, -18, -20, -17, -20, -17, -19, -17, -19, -17, -19, -16, -19,
-15, -18, -15, -19, -15, -19, -15, -18, -14, -18, -15, -19, -14, -17, -14, -18,
-14, -18, -14, -16, -12, -16, -13, -17, -12, -16, -12, -17, -11, -17, -11, -16,
-10, -16, -11, -16, -10, -15, -10, -15, -10, -15, -9, -15, -9, -15, -8, -15, -9,
-15, -8, -14, -8, -14, -8, -15, -7, -15, -8, -14, -8, -14, -7, -14, -7, -13, -6,
-14, -6, -14, -6, -13, -5, -12, -5, -13, -4, -14, -5, -13, -4, -12, -5, -12, -3,
-13, -3, -13, -3, -12, -3, -12, -2, -12, -2, -12, -2, -12, -2, -12, -1, -11, -1,
-12, -1, -11, -1, -11, -1, -11, -1, -11, 0, -11, 0, -11, 0, -10, 0, -10, 1, -10,
0, -10, 1, -10, 2, -10, 2, -10, 2, -9, 2, -9, 3, -9, 2, -8, 3, -8, 3, -9, 3, -8,
4, -9, 4, -8, 4, -8, 4, -8, 4, -8, 5, -8, 4, -7, 5, -8, 6, -7, 6, -7, 6, -7, 6,
-8, 6, -7, 7, -7, 6, -7, 6, -7, 7, -7, 7, -6, 8, -6, 7, -7, 7, -7, 8, -6, 8, -6,
9, -7, 9, -6, 9, -6, 9, -6, 9, -6, 9, -5, 9, -5, 9, -5, 9, -6, 10, -5, 10, -5,
10, -5, 11, -5, 10, -5, 10, -5, 11, -5, 12, -5, 12, -5, 12, -4, 11, -5, 12, -5,
12, -4, 12, -5, 12, -4, 12, -4, 12, -4, 13, -4, 13, -4, 13, -4, 13, -4, 13, -4,
13, -3, 13, -3, 13, -3, 14, -3, 13, -4, 13, -3, 14, -3, 13, -3, 14, -3, 14, -3,
15, -2, 14, -3, 14, -2, 14, -2, 15, -3, 14, -2, 14, -2, 15, -3, 14, -2, 15, -2,
15, -3, 15, -1, 15, -2, 15, -2, 15, -1, 15, -2, 16, -2, 15, -2, 15, -1, 15, -2,
15, -2, 15, -1, 16, -1, 16, -2, 16, -2, 15, -2, 16, -2, 16, -2, 15, -1, 15, -1,
16, -2, 16, -1, 15, -1, 16, -1, 15, -1, 15, -1, 16, 0, 16, -1, 16, 0, 16, 0, 15,
-1, 16, 0, 16, -1, 15, 0, 15, 0, 16, -1, 15, 0, 15, 0, 15, 0, 16, 0, 16, 0, 15,
-1, 14, 0, 16, -1, 15, 0, 15, -1, 15, -1, 15, -1, 15, -1, 15, 0, 15, 0, 14, 0,
14, 0, 14, 0, 15, 1, 15, -1, 15, 0, 14, 0, 14, 0, 14, 0, 15, -1, 14, 1, 13, 0,
15, 0, 14, 0, 15, 0, 14, -1, 13, 0, 14, 0, 13, 0, 13, 0, 14, -1, 13, 0, 13, 1,
13, -1, 13, 1, 12, 0, 13, 0, 13, -1, 12, 0, 12, 0, 12, 1, 11, -1, 11, -1, 12, 0,
12, 0, 11, 0, 12, -1, 10, 0, 11, 0, 11, 0, 11, 0, 11, 0, 10, -1, 10, 0, 10, 0,
9, -1, 9, 0, 10, -1, 10, 0, 10, 1, 9, -1, 9, 0, 9, 0, 9, 0, 8, 0, 8, 0, 9, 0, 8,
0, 8, -1, 8, 0, 8, 0, 8, 0, 8, 0, 8, 0, 8, 0, 7, 0, 7, 0, 7, -1, 7, 0, 7, -1, 6,
-1, 7, -1, 6, 0, 6, -1, 6, -1, 5, 0, 5, -1, 6, -1, 4, };