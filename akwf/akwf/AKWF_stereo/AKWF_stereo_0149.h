#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0149

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 2, 3, 2, 4, 3, 5, 3, 6, 4,
7, 4, 7, 5, 8, 5, 9, 6, 9, 6, 10, 6, 11, 7, 12, 8, 12, 7, 13, 8, 14, 9, 14, 9,
16, 9, 15, 10, 17, 10, 18, 11, 18, 10, 19, 12, 19, 13, 19, 13, 21, 13, 20, 12,
21, 14, 22, 14, 22, 15, 23, 15, 23, 15, 24, 15, 24, 16, 25, 16, 26, 16, 25, 17,
27, 17, 26, 18, 28, 18, 28, 18, 28, 19, 29, 19, 29, 19, 29, 19, 30, 20, 30, 21,
31, 22, 32, 22, 31, 22, 33, 22, 32, 23, 34, 23, 33, 23, 35, 23, 34, 24, 35, 24,
35, 25, 36, 25, 36, 26, 37, 27, 37, 26, 38, 27, 38, 27, 39, 28, 39, 28, 40, 28,
39, 29, 41, 29, 40, 29, 42, 29, 42, 29, 42, 31, 42, 31, 43, 31, 43, 32, 43, 32,
44, 32, 44, 33, 45, 33, 45, 33, 45, 34, 46, 34, 46, 35, 47, 35, 47, 36, 48, 35,
49, 35, 48, 37, 48, 37, 49, 37, 50, 38, 50, 38, 50, 38, 50, 39, 52, 39, 52, 40,
51, 40, 53, 40, 53, 41, 53, 41, 55, 42, 55, 42, 54, 42, 55, 42, 55, 43, 55, 43,
56, 44, 56, 44, 57, 45, 57, 46, 58, 46, 57, 45, 58, 46, 58, 46, 59, 47, 59, 48,
60, 48, 60, 48, 61, 49, 61, 49, 61, 50, 61, 50, 61, 50, 63, 51, 62, 51, 64, 51,
64, 52, 64, 52, 65, 52, 65, 54, 66, 53, 65, 53, 66, 55, 66, 55, 66, 55, 67, 56,
67, 56, 68, 56, 68, 56, 68, 57, 69, 58, 68, 58, 70, 58, 70, 58, 70, 58, 71, 59,
70, 59, 71, 59, 71, 61, 72, 61, 73, 61, 73, 62, 73, 62, 73, 63, 74, 63, 74, 63,
75, 64, 75, 64, 74, 64, 75, 65, 76, 65, 77, 66, 76, 66, 77, 67, 77, 68, 78, 68,
78, 68, 79, 68, 79, 69, 79, 70, 79, 70, 79, 70, 80, 71, 81, 71, 82, 71, 81, 72,
81, 72, 82, 72, 82, 72, 83, 73, 82, 74, 83, 73, 83, 74, 84, 74, 84, 75, 85, 76,
84, 76, 85, 75, 86, 77, 86, 77, 86, 77, 87, 77, 87, 77, 87, 78, 87, 79, 88, 79,
88, 79, 89, 79, 89, 80, 89, 81, 89, 81, 89, 81, 90, 81, 90, 82, 90, 82, 90, 83,
91, 82, 91, 83, 91, 83, 91, 83, 92, 84, 92, 84, 92, 84, 93, 85, 93, 85, 93, 85,
93, 85, 93, 86, 93, 86, 94, 87, 94, 88, 94, 87, 95, 87, 96, 88, 96, 87, 96, 88,
96, 88, 96, 88, 96, 89, 97, 89, 97, 89, 97, 89, 97, 89, 98, 90, 97, 91, 98, 90,
98, 91, 98, 92, 99, 92, 99, 92, 99, 92, 98, 92, 99, 93, 99, 93, 100, 93, 100,
93, 100, 93, 100, 94, 100, 94, 100, 94, 101, 94, 101, 95, 101, 94, 102, 91, 92,
73, 49, 49, -7, 35, -40, 36, -39, 40, -29, 30, -30, -17, -58, -83, -98, -116,
-117, -115, -116, -103, -109, -96, -105, -97, -105, -98, -106, -98, -105, -98,
-105, -97, -104, -95, -104, -95, -103, -95, -103, -93, -101, -94, -101, -93,
-101, -91, -99, -91, -99, -91, -99, -90, -99, -89, -97, -88, -97, -88, -97, -88,
-97, -87, -95, -86, -95, -85, -95, -85, -94, -85, -93, -84, -93, -84, -92, -83,
-92, -82, -92, -82, -91, -81, -90, -81, -90, -79, -89, -79, -89, -79, -89, -79,
-88, -78, -88, -77, -87, -78, -87, -77, -87, -76, -86, -75, -85, -75, -86, -75,
-84, -74, -84, -74, -84, -73, -84, -73, -83, -72, -83, -71, -82, -71, -82, -71,
-81, -70, -82, -69, -80, -69, -80, -69, -80, -68, -79, -69, -78, -67, -79, -67,
-78, -67, -77, -66, -77, -66, -77, -66, -77, -65, -76, -64, -76, -65, -76, -63,
-76, -64, -75, -63, -74, -62, -74, -63, -74, -63, -73, -61, -73, -61, -72, -61,
-72, -60, -72, -60, -72, -60, -71, -59, -70, -59, -70, -59, -70, -59, -69, -57,
-69, -58, -69, -57, -69, -56, -68, -56, -68, -56, -66, -56, -67, -55, -66, -56,
-66, -54, -66, -54, -66, -53, -65, -54, -65, -53, -64, -52, -64, -52, -63, -51,
-63, -51, -63, -51, -63, -50, -62, -50, -62, -50, -61, -49, -61, -50, -60, -48,
-60, -48, -60, -48, -60, -47, -59, -48, -59, -48, -58, -47, -59, -46, -58, -46,
-57, -45, -56, -45, -56, -45, -56, -44, -56, -43, -55, -44, -55, -44, -55, -43,
-54, -43, -54, -42, -53, -42, -53, -42, -53, -41, -53, -41, -52, -41, -52, -39,
-52, -40, -51, -39, -51, -39, -50, -39, -50, -39, -49, -38, -50, -37, -49, -38,
-49, -37, -48, -37, -47, -37, -48, -36, -47, -36, -46, -35, -47, -36, -46, -34,
-46, -34, -45, -34, -46, -33, -44, -33, -45, -32, -44, -32, -43, -31, -44, -32,
-43, -31, -42, -31, -42, -32, -42, -30, -41, -30, -40, -30, -41, -30, -40, -29,
-39, -29, -40, -28, -38, -28, -38, -28, -38, -27, -38, -26, -37, -26, -37, -27,
-37, -26, -37, -25, -36, -25, -35, -25, -35, -24, -35, -24, -34, -24, -33, -24,
-33, -23, -33, -24, -32, -22, -31, -23, -32, -22, -31, -21, -31, -20, -30, -21,
-30, -20, -30, -21, -30, -20, -29, -19, -28, -19, -29, -19, -27, -18, -28, -19,
-27, -17, -27, -18, -26, -17, -26, -17, -25, -17, -24, -16, -24, -16, -23, -16,
-22, -14, -23, -15, -22, -15, -23, -15, -22, -14, -21, -13, -21, -13, -20, -13,
-20, -13, -20, -12, -19, -12, -18, -11, -18, -10, -17, -10, -16, -11, -16, -10,
-16, -10, -15, -9, -15, -10, -15, -9, -15, -8, -14, -8, -13, -7, -12, -7, -11,
-7, -11, -6, -10, -6, -10, -5, -9, -5, -8, -5, -8, -4, -7, -5, -7, -3, -6, -3,
-5, -3, -4, -2, -4, -2, -3, 0, -2, -1, -1, 0, 0, };