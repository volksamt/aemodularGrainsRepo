#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0187

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -17, 2, -18, 4, -16, 5, -15, 6,
-14, 7, -14, 9, -10, 10, -10, 11, -8, 13, -8, 13, -6, 15, -5, 16, -4, 18, -2,
19, -2, 20, 0, 21, 1, 23, 2, 23, 4, 25, 6, 27, 7, 28, 7, 28, 9, 30, 10, 31, 13,
33, 12, 33, 14, 35, 16, 36, 17, 38, 18, 39, 19, 39, 21, 41, 22, 42, 23, 43, 25,
44, 26, 45, 28, 47, 29, 47, 30, 49, 32, 50, 33, 51, 33, 52, 35, 53, 37, 55, 37,
55, 39, 57, 40, 58, 41, 59, 43, 61, 44, 61, 45, 62, 46, 63, 48, 64, 48, 66, 50,
66, 51, 68, 53, 68, 53, 69, 55, 70, 56, 71, 57, 72, 59, 74, 59, 75, 61, 75, 62,
76, 63, 76, 64, 78, 65, 79, 67, 79, 68, 81, 68, 81, 70, 82, 70, 83, 72, 84, 72,
85, 73, 86, 75, 86, 76, 87, 76, 88, 78, 88, 79, 89, 80, 90, 81, 91, 83, 91, 83,
92, 84, 93, 85, 94, 85, 94, 86, 94, 87, 95, 88, 95, 89, 97, 89, 97, 91, 98, 91,
98, 92, 99, 93, 99, 94, 100, 95, 100, 96, 100, 96, 101, 97, 101, 98, 102, 98,
102, 99, 102, 99, 104, 101, 103, 100, 104, 101, 104, 102, 105, 103, 106, 103,
106, 103, 106, 105, 106, 104, 106, 104, 107, 105, 107, 106, 108, 107, 107, 106,
108, 106, 107, 107, 108, 108, 109, 108, 109, 109, 109, 110, 109, 109, 109, 109,
108, 110, 109, 110, 109, 110, 109, 110, 109, 111, 110, 111, 109, 111, 109, 112,
109, 111, 108, 112, 109, 111, 108, 111, 109, 112, 109, 111, 108, 112, 109, 111,
108, 112, 108, 112, 108, 111, 107, 112, 108, 111, 107, 112, 107, 112, 108, 111,
106, 111, 106, 111, 106, 110, 106, 111, 105, 111, 105, 110, 104, 110, 104, 110,
104, 109, 104, 108, 102, 109, 102, 108, 102, 108, 102, 108, 100, 108, 100, 107,
99, 107, 100, 106, 100, 106, 98, 105, 97, 104, 97, 105, 97, 104, 96, 103, 95,
103, 94, 102, 94, 102, 93, 101, 93, 100, 92, 101, 91, 99, 90, 98, 90, 98, 89,
97, 88, 96, 87, 96, 86, 95, 86, 95, 85, 94, 84, 93, 83, 92, 82, 91, 81, 90, 80,
90, 79, 89, 78, 89, 78, 87, 77, 87, 76, 85, 74, 85, 73, 84, 73, 83, 71, 82, 70,
81, 70, 80, 68, 79, 68, 78, 66, 77, 65, 76, 64, 76, 63, 74, 61, 73, 61, 72, 59,
72, 58, 71, 57, 70, 56, 68, 55, 68, 53, 66, 52, 65, 52, 65, 50, 63, 48, 62, 48,
61, 46, 60, 44, 58, 43, 58, 42, 55, 41, 55, 40, 54, 38, 52, 38, 51, 36, 51, 34,
49, 33, 48, 32, 47, 30, 45, 29, 44, 28, 43, 26, 42, 25, 40, 24, 40, 22, 38, 21,
37, 20, 36, 19, 35, 17, 34, 15, 32, 14, 31, 12, 30, 12, 30, 11, 28, 9, 26, 7,
25, 6, 24, 4, 23, 4, 22, 2, 20, 1, 18, 0, 17, -2, 16, -4, 15, -5, 14, -7, 12,
-8, 11, -10, 10, -10, 8, -12, 7, -13, 5, -14, 4, -16, 3, -18, 2, -19, -1, -21,
-1, -22, -2, -24, -4, -24, -5, -27, -7, -28, -8, -29, -10, -30, -11, -31, -13,
-34, -14, -35, -16, -36, -17, -38, -19, -39, -20, -41, -21, -42, -23, -43, -24,
-45, -25, -46, -27, -48, -28, -50, -31, -51, -32, -52, -33, -53, -35, -54, -36,
-56, -38, -58, -40, -59, -40, -60, -43, -62, -44, -63, -45, -64, -46, -65, -48,
-67, -49, -69, -51, -69, -53, -70, -53, -72, -55, -73, -57, -75, -58, -76, -60,
-77, -61, -78, -62, -79, -63, -81, -65, -82, -66, -83, -69, -84, -69, -85, -71,
-85, -71, -87, -74, -88, -75, -89, -76, -90, -77, -92, -78, -92, -79, -94, -80,
-94, -81, -95, -83, -96, -84, -97, -84, -98, -86, -98, -87, -100, -88, -101,
-90, -101, -91, -102, -92, -103, -92, -103, -94, -105, -95, -105, -96, -105,
-97, -106, -97, -107, -99, -107, -100, -108, -101, -109, -101, -110, -102, -110,
-103, -110, -103, -111, -104, -112, -105, -112, -106, -112, -107, -113, -108,
-114, -108, -114, -109, -114, -109, -115, -110, -115, -111, -115, -111, -116,
-112, -117, -112, -115, -114, -116, -113, -117, -115, -117, -114, -116, -115,
-117, -115, -117, -115, -117, -117, -117, -116, -119, -117, -118, -117, -118,
-117, -118, -117, -118, -118, -117, -118, -118, -118, -117, -119, -117, -118,
-118, -119, -117, -118, -118, -118, -117, -119, -117, -119, -117, -119, -117,
-119, -116, -118, -116, -119, -116, -119, -116, -119, -115, -119, -115, -119,
-114, -118, -114, -119, -115, -118, -113, -118, -113, -118, -113, -118, -112,
-117, -111, -117, -112, -116, -110, -116, -110, -116, -110, -116, -109, -116,
-109, -115, -108, -115, -108, -113, -106, -114, -107, -113, -105, -113, -105,
-112, -104, -112, -103, -111, -102, -111, -101, -109, -101, -110, -99, -109,
-100, -108, -99, -107, -99, -108, -97, -106, -96, -106, -96, -106, -94, -105,
-93, -104, -92, -102, -92, -102, -91, -100, -89, -100, -88, -100, -88, -98, -87,
-98, -86, -97, -85, -96, -84, -95, -83, -95, -81, -93, -81, -92, -79, -92, -79,
-90, -78, -90, -76, -89, -75, -89, -74, -87, -73, -87, -72, -84, -70, -84, -70,
-83, -69, -82, -67, -81, -67, -80, -65, -79, -63, -77, -62, -77, -60, -76, -59,
-75, -58, -74, -57, -72, -56, -72, -55, -70, -54, -68, -52, -68, -52, -66, -49,
-65, -48, -65, -47, -63, -46, -62, -45, -61, -44, -60, -42, -59, -41, -59, -40,
-57, -39, -56, -38, -55, -37, -53, -35, -52, -33, -51, -33, -50, -32, -49, -30,
-48, -29, -46, -27, -45, -26, -44, -25, -44, -24, -42, -22, -41, -21, -40, -20,
-38, -18, -38, -17, -36, -16, -35, -15, -35, -13, -33, -13, -32, -12, -31, -10,
-29, -9, -29, -8, -27, -6, -26, -4, -24, -3, -24, -3, -22, -1, -22, -1, -17, };