#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0198

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -5, 6, -3, 10, 2, 14, 7, 18, 13,
23, 17, 27, 21, 31, 26, 35, 30, 38, 34, 43, 38, 46, 41, 50, 46, 53, 49, 58, 53,
61, 57, 64, 60, 67, 62, 70, 66, 73, 69, 76, 72, 79, 75, 81, 77, 83, 80, 87, 82,
88, 84, 92, 87, 94, 88, 96, 91, 98, 92, 100, 93, 101, 95, 103, 97, 105, 98, 106,
99, 108, 101, 109, 100, 110, 102, 111, 103, 113, 103, 114, 103, 114, 103, 115,
104, 116, 104, 116, 104, 116, 104, 116, 102, 117, 102, 117, 103, 117, 101, 117,
101, 117, 100, 116, 100, 115, 98, 116, 97, 114, 95, 114, 94, 113, 93, 112, 92,
110, 90, 109, 88, 108, 86, 106, 85, 104, 83, 103, 81, 101, 79, 99, 77, 98, 74,
96, 73, 94, 71, 92, 69, 91, 67, 89, 66, 87, 64, 84, 61, 83, 59, 81, 57, 79, 55,
77, 54, 76, 52, 74, 50, 71, 49, 70, 47, 68, 44, 66, 42, 64, 42, 62, 40, 60, 38,
57, 36, 56, 35, 53, 32, 51, 32, 49, 30, 47, 30, 46, 28, 44, 27, 41, 25, 39, 24,
38, 24, 35, 22, 34, 21, 31, 19, 29, 19, 27, 18, 25, 17, 24, 16, 21, 16, 20, 16,
17, 14, 16, 15, 14, 14, 12, 13, 10, 13, 8, 12, 7, 13, 6, 13, 4, 11, 2, 11, 1,
11, -1, 12, -2, 12, -4, 12, -4, 11, -6, 12, -8, 12, -8, 12, -9, 12, -11, 13,
-11, 13, -12, 13, -13, 12, -14, 13, -15, 12, -15, 14, -16, 13, -17, 13, -19, 13,
-19, 14, -19, 14, -20, 14, -21, 14, -22, 14, -23, 14, -24, 14, -24, 14, -25, 13,
-24, 13, -25, 13, -26, 13, -26, 12, -26, 12, -27, 12, -27, 11, -28, 10, -28, 9,
-28, 9, -28, 8, -29, 8, -29, 6, -28, 6, -29, 5, -29, 4, -29, 3, -28, 1, -29, 0,
-29, -1, -28, -2, -28, -4, -28, -6, -29, -7, -28, -9, -29, -10, -28, -12, -27,
-14, -28, -16, -29, -18, -28, -20, -29, -22, -30, -25, -29, -26, -29, -28, -29,
-31, -29, -33, -30, -35, -30, -38, -31, -40, -32, -43, -32, -45, -32, -48, -33,
-49, -33, -52, -35, -55, -36, -57, -36, -59, -37, -62, -37, -64, -38, -66, -39,
-69, -40, -71, -40, -72, -41, -74, -40, -76, -42, -78, -43, -79, -42, -81, -43,
-82, -43, -83, -44, -85, -44, -86, -44, -87, -45, -88, -44, -89, -45, -89, -45,
-89, -45, -90, -45, -90, -45, -90, -45, -90, -44, -90, -44, -90, -45, -90, -45,
-90, -43, -89, -43, -87, -43, -87, -43, -86, -42, -85, -42, -83, -41, -81, -40,
-80, -39, -78, -39, -77, -37, -75, -37, -73, -35, -70, -34, -67, -32, -65, -32,
-63, -29, -60, -29, -56, -27, -54, -25, -50, -22, -48, -21, -43, -19, -40, -17,
-37, -15, -34, -12, -29, -9, -26, -7, -21, -4, -18, -2, -15, 1, -10, 5, -6, 7,
-2, 10, 3, 13, 7, 17, 11, 19, 14, 23, 17, 26, 22, 29, 26, 31, 30, 34, 33, 36,
36, 39, 40, 42, 42, 44, 46, 46, 49, 49, 52, 51, 55, 52, 59, 55, 60, 57, 63, 59,
66, 61, 68, 63, 70, 66, 72, 67, 74, 69, 75, 70, 77, 71, 78, 73, 80, 74, 81, 75,
82, 76, 83, 77, 84, 79, 85, 79, 85, 80, 86, 80, 86, 81, 87, 82, 87, 82, 87, 81,
85, 83, 87, 83, 86, 83, 85, 83, 85, 83, 83, 83, 83, 82, 82, 82, 80, 82, 80, 82,
79, 81, 77, 80, 76, 80, 74, 78, 73, 76, 72, 76, 70, 75, 69, 74, 66, 73, 64, 71,
63, 69, 60, 68, 59, 65, 56, 64, 54, 62, 52, 60, 49, 58, 47, 56, 45, 54, 43, 52,
41, 50, 38, 49, 36, 47, 34, 44, 32, 43, 30, 41, 29, 40, 26, 38, 24, 36, 22, 34,
21, 32, 19, 31, 17, 29, 15, 27, 14, 25, 11, 23, 11, 22, 9, 21, 8, 19, 6, 17, 5,
16, 4, 13, 2, 12, 1, 11, 1, 9, -1, 6, -2, 5, -3, 3, -3, 1, -4, 0, -4, -2, -5,
-4, -6, -5, -6, -7, -7, -8, -7, -10, -7, -12, -9, -13, -8, -16, -8, -16, -8,
-18, -8, -19, -8, -21, -9, -22, -8, -24, -8, -26, -8, -27, -8, -29, -8, -30, -6,
-31, -7, -32, -6, -34, -7, -34, -6, -36, -5, -36, -4, -38, -4, -39, -4, -40, -3,
-41, -3, -42, -3, -43, -2, -45, -2, -45, -1, -46, -1, -47, -1, -49, 0, -49, 1,
-50, 2, -51, 1, -53, 1, -53, 2, -54, 1, -55, 2, -56, 2, -57, 2, -58, 2, -60, 2,
-60, 2, -60, 1, -62, 0, -62, 1, -64, 0, -63, -1, -65, -1, -66, -2, -66, -3, -67,
-5, -67, -4, -68, -7, -69, -7, -70, -8, -70, -9, -71, -11, -71, -12, -72, -13,
-73, -15, -73, -16, -74, -19, -74, -20, -74, -22, -76, -24, -76, -26, -76, -28,
-77, -30, -78, -33, -78, -35, -80, -38, -79, -40, -80, -42, -80, -45, -81, -47,
-82, -50, -82, -52, -83, -55, -84, -58, -86, -61, -86, -63, -88, -66, -88, -69,
-89, -71, -90, -74, -91, -76, -92, -80, -94, -83, -93, -85, -94, -87, -96, -90,
-96, -94, -97, -95, -98, -97, -98, -100, -99, -102, -100, -104, -100, -106,
-100, -107, -101, -109, -101, -110, -101, -112, -101, -113, -101, -115, -101,
-115, -101, -116, -101, -118, -101, -118, -101, -118, -100, -118, -100, -119,
-99, -119, -99, -119, -98, -119, -97, -119, -97, -117, -95, -117, -95, -117,
-94, -116, -92, -115, -91, -113, -89, -112, -88, -111, -86, -108, -85, -107,
-83, -105, -82, -103, -80, -100, -78, -98, -76, -95, -73, -92, -71, -90, -68,
-87, -66, -84, -62, -80, -60, -76, -57, -73, -54, -70, -50, -65, -48, -61, -43,
-57, -40, -53, -36, -48, -32, -45, -28, -39, -23, -35, -20, -29, -15, -25, -11,
-20, -7, -15, -2, -9, };