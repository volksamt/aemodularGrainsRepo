#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0045

const PROGMEM int8_t DATA[DATA_LENGTH] = {66, 93, 118, 112, 105, 81, 106, 89,
96, 79, 102, 85, 104, 80, 111, 84, 107, 81, 102, 85, 96, 83, 94, 85, 95, 83, 98,
84, 96, 83, 93, 83, 88, 82, 85, 82, 85, 81, 86, 82, 86, 81, 84, 80, 83, 81, 80,
79, 79, 80, 79, 78, 81, 80, 81, 78, 82, 79, 80, 77, 80, 77, 80, 76, 81, 76, 81,
76, 82, 75, 82, 75, 81, 75, 81, 74, 80, 74, 81, 73, 81, 73, 81, 72, 80, 72, 80,
72, 79, 71, 79, 72, 79, 71, 78, 71, 78, 70, 76, 70, 75, 69, 74, 69, 75, 68, 74,
68, 73, 68, 73, 67, 72, 67, 71, 67, 71, 66, 71, 66, 70, 66, 69, 65, 69, 64, 69,
65, 68, 64, 68, 64, 67, 63, 67, 63, 66, 62, 67, 62, 66, 61, 65, 61, 65, 61, 65,
60, 64, 60, 64, 61, 64, 59, 64, 59, 64, 58, 64, 58, 63, 58, 63, 57, 62, 57, 62,
57, 61, 56, 61, 57, 60, 56, 59, 55, 60, 54, 59, 54, 59, 54, 58, 53, 57, 54, 57,
52, 56, 52, 56, 52, 56, 52, 55, 51, 54, 51, 54, 50, 55, 50, 54, 50, 54, 50, 53,
49, 53, 50, 52, 48, 52, 48, 52, 47, 51, 48, 51, 47, 50, 47, 51, 47, 50, 46, 49,
45, 48, 45, 48, 45, 48, 45, 47, 44, 47, 43, 47, 43, 47, 44, 47, 42, 46, 41, 45,
42, 44, 41, 44, 41, 45, 41, 44, 40, 43, 40, 42, 40, 42, 39, 42, 39, 42, 38, 41,
38, 40, 38, 40, 37, 40, 37, 40, 36, 39, 37, 38, 36, 38, 36, 39, 35, 38, 35, 38,
35, 36, 34, 37, 33, 37, 34, 35, 33, 35, 32, 35, 33, 34, 33, 33, 32, 34, 32, 33,
31, 33, 31, 33, 30, 32, 30, 31, 29, 32, 29, 31, 29, 30, 29, 30, 28, 30, 28, 31,
28, 30, 27, 29, 27, 28, 26, 28, 26, 28, 25, 27, 26, 28, 25, 26, 25, 26, 25, 26,
23, 25, 24, 25, 23, 25, 23, 24, 23, 24, 23, 24, 23, 23, 22, 23, 21, 22, 21, 22,
21, 22, 21, 21, 20, 21, 20, 21, 19, 20, 19, 20, 19, 20, 18, 19, 17, 20, 18, 18,
17, 18, 16, 18, 16, 17, 16, 17, 16, 17, 15, 17, 15, 16, 15, 16, 14, 15, 15, 15,
14, 14, 14, 14, 13, 14, 13, 13, 12, 13, 12, 13, 11, 12, 11, 12, 10, 11, 11, 11,
10, 11, 10, 11, 9, 10, 10, 10, 9, 10, 9, 9, 8, 9, 8, 8, 8, 8, 7, 8, 7, 8, 7, 8,
7, 6, 6, 6, 6, 6, 5, 6, 5, 5, 5, 5, 4, 4, 4, 4, 4, 3, 3, 3, 4, 3, 3, 2, 3, 2, 2,
3, 2, 2, 2, 1, 1, 1, 1, 1, 0, 0, 0, 0, 1, -1, -1, 0, -1, 0, -1, -2, -1, -2, -2,
-2, -2, -2, -3, -3, -2, -4, -3, -3, -3, -4, -4, -5, -4, -5, -3, -5, -4, -6, -5,
-6, -5, -6, -5, -6, -5, -6, -6, -8, -7, -8, -7, -7, -7, -9, -7, -8, -7, -9, -8,
-9, -9, -10, -9, -10, -9, -11, -9, -10, -10, -11, -10, -12, -10, -11, -10, -12,
-11, -13, -12, -13, -11, -13, -11, -13, -12, -13, -13, -14, -13, -14, -12, -14,
-14, -15, -13, -15, -14, -16, -14, -16, -15, -17, -15, -16, -16, -17, -16, -17,
-16, -18, -17, -18, -17, -19, -17, -18, -17, -18, -18, -19, -18, -20, -18, -20,
-19, -20, -18, -20, -19, -20, -19, -21, -19, -21, -20, -22, -20, -22, -20, -23,
-21, -23, -22, -24, -21, -23, -22, -24, -22, -24, -22, -24, -23, -25, -23, -25,
-22, -26, -23, -26, -24, -26, -24, -27, -24, -26, -25, -27, -25, -27, -25, -29,
-25, -27, -27, -28, -25, -28, -26, -29, -26, -29, -27, -30, -27, -29, -28, -30,
-28, -30, -28, -31, -28, -31, -29, -32, -29, -31, -30, -32, -29, -32, -30, -33,
-31, -33, -31, -33, -30, -34, -31, -35, -31, -34, -32, -35, -32, -36, -32, -36,
-33, -36, -33, -36, -33, -37, -34, -36, -33, -37, -34, -38, -34, -38, -35, -37,
-35, -38, -35, -39, -36, -38, -36, -39, -36, -39, -36, -40, -36, -40, -38, -40,
-38, -41, -38, -42, -38, -41, -38, -42, -38, -42, -38, -43, -39, -42, -40, -43,
-39, -43, -40, -43, -39, -44, -41, -44, -40, -44, -41, -44, -41, -44, -41, -46,
-41, -45, -42, -46, -43, -47, -42, -46, -43, -46, -44, -47, -43, -47, -44, -47,
-44, -47, -44, -48, -45, -49, -46, -49, -45, -50, -45, -49, -45, -50, -46, -51,
-46, -51, -47, -50, -46, -51, -47, -51, -47, -52, -47, -52, -48, -52, -49, -53,
-49, -53, -48, -54, -49, -54, -50, -54, -50, -54, -49, -53, -50, -55, -50, -55,
-50, -55, -51, -56, -51, -55, -51, -55, -52, -56, -52, -57, -53, -57, -53, -57,
-53, -57, -53, -58, -54, -58, -54, -58, -53, -59, -54, -59, -54, -59, -55, -60,
-55, -59, -55, -60, -55, -60, -55, -61, -56, -60, -55, -60, -57, -62, -57, -61,
-57, -62, -57, -62, -58, -63, -57, -64, -59, -63, -59, -64, -58, -64, -58, -64,
-59, -64, -60, -65, -60, -65, -61, -66, -60, -66, -61, -66, -61, -66, -61, -66,
-62, -67, -62, -68, -62, -68, -62, -68, -63, -69, -62, -69, -63, -69, -63, -69,
-63, -70, -64, -69, -64, -70, -64, -69, -64, -70, -65, -70, -65, -71, -65, -71,
-65, -72, -66, -71, -66, -72, -66, -72, -66, -72, -67, -73, -68, -73, -68, -73,
-67, -73, -68, -74, -68, -74, -69, -74, -69, -75, -69, -75, -69, -75, -69, -75,
-70, -75, -70, -77, -70, -76, -70, -77, -71, -77, -71, -78, -71, -77, -71, -77,
-72, -77, -72, -78, -72, -78, -73, -78, -73, -80, -74, -79, -73, -80, -73, -79,
-74, -80, -74, -78, -73, -82, -75, -80, -73, -83, -77, -78, -71, -89, -83, -48,
-35, };