#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0173

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, -28, 5, -38, 10, -37, 16, -41, 22,
-40, 29, -40, 36, -39, 44, -37, 52, -33, 60, -30, 67, -26, 73, -22, 78, -17, 84,
-13, 87, -7, 89, -3, 91, 2, 92, 6, 93, 12, 93, 17, 92, 21, 91, 26, 91, 30, 90,
35, 91, 40, 91, 44, 91, 48, 93, 52, 94, 56, 97, 61, 99, 65, 101, 68, 102, 72,
104, 75, 105, 77, 106, 79, 105, 80, 104, 81, 101, 82, 98, 81, 94, 80, 89, 76,
83, 71, 78, 63, 71, 56, 64, 46, 58, 38, 51, 27, 46, 19, 41, 11, 36, 3, 32, -4,
29, -9, 26, -11, 25, -13, 23, -12, 21, -10, 20, -5, 19, -1, 18, 4, 15, 10, 13,
16, 9, 21, 5, 23, 1, 27, -4, 28, -10, 28, -16, 28, -23, 25, -28, 21, -33, 18,
-39, 13, -43, 8, -48, 4, -52, 1, -55, -4, -58, -8, -61, -12, -63, -14, -66, -16,
-67, -19, -69, -20, -73, -22, -75, -23, -79, -26, -83, -28, -88, -30, -91, -33,
-96, -36, -100, -41, -105, -45, -107, -50, -111, -54, -114, -59, -117, -63,
-118, -67, -119, -70, -119, -74, -117, -74, -116, -75, -113, -76, -109, -73,
-103, -70, -98, -65, -91, -60, -84, -53, -77, -45, -70, -38, -63, -28, -57, -22,
-53, -14, -47, -8, -44, -2, -42, 3, -39, 5, -39, 7, -38, 7, -38, 6, -38, 4, -39,
1, -38, -3, -36, -6, -36, -11, -34, -15, -35, -18, -35, -23, -35, -26, -37, -28,
-37, -32, -37, -33, -38, -34, -38, -35, -37, -36, -36, -34, -34, -34, -31, -33,
-26, -32, -22, -30, -16, -27, -8, -25, -1, -23, 9, -19, 17, -16, 26, -12, 35,
-9, 43, -5, 51, -1, 60, 4, 65, 7, 71, 11, 76, 14, 79, 18, 82, 19, 84, 21, 85,
23, 85, 22, 83, 22, 83, 22, 80, 19, 79, 18, 76, 14, 74, 11, 72, 7, 69, 4, 66,
-2, 66, -5, 65, -9, 62, -12, 61, -15, 59, -18, 59, -19, 57, -21, 56, -21, 55,
-21, 55, -21, 54, -18, 55, -17, 53, -15, 53, -12, 52, -9, 53, -5, 52, -1, 53, 2,
53, 6, 53, 9, 53, 13, 54, 18, 55, 21, 56, 25, 57, 28, 57, 30, 58, 33, 59, 36,
59, 38, 58, 39, 57, 40, 55, 41, 53, 41, 49, 40, 44, 38, 39, 36, 32, 35, 25, 31,
16, 25, 9, 21, 0, 14, -8, 9, -16, 4, -24, -3, -30, -9, -36, -14, -40, -18, -44,
-21, -47, -23, -47, -24, -47, -23, -46, -20, -44, -16, -42, -10, -39, -4, -36,
2, -32, 7, -29, 13, -26, 18, -24, 23, -22, 28, -21, 32, -19, 37, -19, 41, -18,
44, -18, 47, -20, 51, -21, 54, -23, 57, -26, 59, -27, 61, -29, 63, -32, 63, -33,
64, -36, 64, -37, 63, -39, 60, -41, 58, -43, 55, -45, 50, -46, 47, -48, 40, -49,
35, -50, 28, -51, 21, -51, 16, -52, 9, -52, 4, -50, -1, -49, -4, -47, -7, -43,
-7, -41, -7, -38, -5, -34, -2, -29, 3, -24, 8, -19, 16, -14, 24, -9, 31, -3, 39,
2, 47, 6, 55, 11, 61, 16, 67, 19, 71, 21, 75, 24, 78, 24, 79, 26, 79, 25, 77,
23, 75, 22, 70, 19, 64, 16, 57, 14, 50, 8, 41, 5, 33, 1, 24, -3, 16, -8, 7, -11,
0, -14, -8, -16, -15, -19, -22, -20, -28, -21, -33, -20, -39, -21, -42, -20,
-46, -17, -50, -15, -52, -12, -54, -9, -56, -6, -57, -2, -56, 1, -57, 5, -57, 8,
-56, 12, -55, 14, -53, 17, -49, 21, -46, 23, -42, 26, -37, 30, -33, 32, -29, 34,
-22, 36, -18, 37, -15, 38, -11, 38, -9, 39, -9, 39, -9, 37, -11, 35, -14, 33,
-19, 30, -26, 27, -33, 24, -40, 19, -48, 15, -58, 10, -66, 5, -76, 0, -84, -5,
-92, -11, -98, -15, -105, -19, -110, -23, -113, -27, -115, -29, -117, -31, -117,
-33, -117, -33, -115, -34, -113, -33, -110, -32, -105, -30, -101, -27, -96, -26,
-91, -23, -86, -21, -81, -19, -75, -16, -68, -13, -61, -9, -53, -4, -46, -1,
-38, 3, -32, 8, -24, 12, -17, 16, -11, 21, -5, 25, -1, 29, 3, 32, 5, 34, 7, 35,
8, 36, 8, 37, 9, 36, 7, 35, 5, 33, 3, 29, -1, 25, -3, 21, -8, 14, -11, 9, -15,
2, -18, -5, -22, -11, -24, -17, -26, -22, -28, -27, -29, -30, -30, -32, -28,
-33, -26, -33, -24, -32, -21, -30, -17, -27, -12, -22, -6, -16, 0, -12, 5, -5,
12, 2, 18, 7, 26, 14, 31, 20, 38, 27, 42, 33, 48, 38, 53, 44, 57, 48, 62, 52,
67, 56, 70, 58, 75, 61, 79, 62, 83, 64, 86, 64, 90, 64, 94, 63, 96, 61, 97, 59,
99, 55, 99, 52, 97, 45, 95, 40, 92, 33, 89, 26, 84, 18, 78, 9, 73, 2, 68, -6,
62, -13, 56, -19, 52, -25, 48, -30, 44, -34, 42, -36, 39, -37, 38, -38, 36, -37,
35, -36, 33, -34, 32, -32, 31, -30, 29, -27, 27, -24, 24, -22, 22, -19, 21, -17,
17, -15, 15, -13, 13, -14, 10, -13, 8, -13, 7, -14, 7, -14, 7, -15, 8, -16, 10,
-17, 12, -18, 14, -20, 17, -22, 20, -24, 22, -27, 25, -30, 27, -34, 29, -38, 29,
-42, 29, -48, 29, -52, 26, -57, 24, -62, 19, -67, 15, -72, 9, -76, 1, -81, -6,
-84, -14, -86, -22, -89, -31, -90, -39, -91, -48, -91, -54, -90, -60, -88, -65,
-86, -69, -82, -71, -78, -72, -73, -73, -67, -71, -62, -69, -57, -67, -51, -64,
-46, -62, -41, -60, -37, -57, -33, -56, -29, -56, -27, -55, -25, -54, -23, -55,
-20, -55, -19, -53, -18, -52, -16, -50, -15, -48, -14, -45, -10, -40, -8, -34,
-3, -26, -1, -19, 0, -15, 1, -10, 1, -9, 1, -5, 0, -7, -1, -6, -2, -10, -2, -11,
-3, -18, -2, -19, -3, -27, -1, -25, };