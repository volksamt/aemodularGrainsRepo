#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 48, 9, 62, 14, 61, 18, 68, 22, 68,
26, 73, 29, 72, 31, 77, 34, 75, 37, 79, 38, 78, 42, 80, 43, 80, 45, 82, 47, 81,
50, 82, 51, 82, 53, 82, 55, 82, 57, 82, 60, 83, 61, 84, 64, 84, 67, 85, 70, 87,
74, 88, 76, 89, 79, 90, 82, 92, 84, 94, 87, 95, 89, 96, 91, 97, 94, 98, 95, 100,
97, 101, 100, 103, 102, 104, 103, 104, 104, 106, 105, 107, 107, 107, 108, 108,
109, 110, 110, 111, 110, 112, 112, 113, 113, 113, 113, 114, 114, 114, 114, 115,
114, 115, 116, 115, 116, 115, 117, 116, 117, 117, 117, 116, 117, 117, 118, 117,
118, 117, 118, 117, 117, 118, 118, 118, 119, 118, 118, 117, 118, 118, 118, 118,
118, 117, 119, 118, 118, 117, 119, 116, 118, 117, 118, 117, 118, 117, 117, 116,
118, 116, 118, 116, 117, 115, 117, 115, 117, 114, 118, 114, 117, 114, 117, 114,
118, 114, 117, 112, 116, 111, 117, 112, 117, 112, 117, 111, 117, 111, 117, 111,
116, 111, 116, 111, 116, 111, 116, 112, 116, 111, 116, 110, 117, 111, 116, 111,
116, 110, 117, 111, 116, 111, 116, 110, 115, 110, 115, 110, 116, 110, 115, 110,
114, 109, 114, 108, 114, 108, 113, 107, 112, 107, 111, 106, 111, 106, 110, 106,
110, 104, 108, 104, 107, 103, 106, 102, 104, 101, 103, 100, 102, 98, 101, 97,
100, 96, 98, 95, 96, 93, 93, 92, 92, 89, 90, 88, 88, 85, 86, 84, 83, 82, 79, 79,
77, 76, 75, 74, 73, 73, 70, 69, 67, 67, 65, 65, 62, 62, 60, 59, 56, 55, 54, 53,
52, 48, 49, 46, 45, 42, 43, 37, 40, 34, 37, 29, 35, 25, 33, 21, 31, 16, 29, 12,
26, 9, 26, 5, 25, 1, 24, -2, 24, -4, 23, -7, 24, -8, 24, -10, 25, -12, 26, -11,
27, -11, 28, -12, 30, -12, 31, -12, 33, -10, 35, -9, 37, -7, 40, -4, 38, -7, 38,
-8, 39, -6, 39, -7, 40, -7, 40, -6, 42, -2, 45, 2, 47, 7, 50, 13, 53, 19, 57,
25, 59, 30, 62, 35, 64, 41, 68, 46, 70, 51, 71, 55, 76, 60, 78, 65, 79, 69, 82,
72, 84, 76, 87, 80, 87, 83, 90, 85, 91, 87, 93, 90, 93, 92, 95, 92, 95, 94, 96,
96, 97, 96, 97, 96, 97, 97, 98, 97, 98, 96, 98, 97, 98, 97, 98, 96, 97, 96, 97,
95, 96, 94, 96, 93, 95, 92, 95, 91, 94, 89, 93, 88, 93, 86, 91, 85, 90, 83, 90,
80, 89, 79, 88, 76, 86, 74, 86, 73, 85, 70, 82, 68, 80, 64, 79, 61, 78, 58, 76,
54, 74, 50, 71, 46, 69, 42, 66, 37, 63, 33, 61, 27, 57, 22, 52, 15, 50, 11, 46,
5, 42, -1, 38, -7, 34, -11, 33, -14, 30, -16, 28, -19, 26, -21, 24, -22, 22,
-23, 20, -24, 19, -25, 18, -25, 17, -25, 16, -26, 15, -25, 16, -24, 16, -22, 16,
-21, 17, -19, 17, -18, 19, -15, 19, -12, 21, -9, 24, -6, 26, -2, 28, 3, 30, 7,
33, 13, 36, 17, 39, 23, 41, 27, 44, 32, 48, 37, 50, 41, 53, 45, 57, 49, 59, 53,
61, 57, 65, 61, 65, 64, 66, 65, 69, 68, 69, 71, 70, 74, 73, 76, 73, 79, 75, 81,
75, 83, 78, 83, 76, 85, 77, 86, 78, 88, 77, 88, 76, 89, 76, 90, 75, 90, 74, 90,
73, 91, 71, 90, 69, 90, 68, 90, 64, 90, 62, 89, 59, 89, 56, 88, 51, 86, 47, 84,
42, 84, 36, 82, 31, 80, 23, 76, 11, 72, 1, 69, -9, 65, -20, 60, -29, 54, -38,
48, -44, 44, -51, 38, -56, 32, -61, 25, -64, 20, -70, 13, -72, 7, -76, -2, -78,
-9, -82, -14, -84, -21, -86, -28, -89, -33, -90, -37, -93, -43, -94, -48, -95,
-53, -97, -57, -99, -61, -99, -64, -101, -68, -102, -72, -102, -75, -103, -78,
-105, -80, -105, -84, -106, -85, -106, -87, -107, -90, -108, -90, -109, -92,
-108, -94, -109, -96, -110, -96, -110, -97, -110, -98, -110, -98, -110, -98,
-110, -99, -111, -100, -111, -100, -111, -100, -111, -100, -111, -101, -111,
-100, -112, -102, -112, -103, -112, -104, -113, -103, -113, -104, -115, -106,
-114, -106, -115, -107, -115, -106, -116, -106, -116, -107, -116, -107, -115,
-107, -116, -107, -117, -107, -117, -109, -117, -108, -118, -108, -117, -108,
-118, -109, -118, -109, -118, -109, -118, -110, -119, -110, -118, -110, -119,
-111, -119, -111, -119, -111, -119, -111, -119, -111, -119, -111, -120, -111,
-119, -112, -118, -112, -119, -112, -119, -112, -119, -111, -118, -112, -118,
-111, -118, -111, -119, -111, -119, -112, -120, -112, -118, -112, -118, -111,
-118, -112, -119, -111, -118, -112, -118, -112, -118, -114, -118, -114, -118,
-115, -118, -116, -117, -117, -117, -116, -117, -117, -117, -117, -116, -117,
-116, -118, -116, -118, -116, -118, -116, -118, -115, -118, -115, -119, -115,
-119, -115, -120, -114, -119, -113, -119, -113, -118, -113, -119, -113, -119,
-112, -119, -112, -119, -111, -119, -111, -119, -111, -119, -109, -118, -109,
-119, -108, -118, -107, -118, -107, -118, -106, -118, -106, -117, -104, -118,
-104, -117, -104, -116, -103, -117, -103, -116, -103, -116, -103, -115, -102,
-116, -101, -115, -101, -115, -100, -115, -100, -114, -99, -113, -99, -114, -99,
-114, -99, -113, -99, -113, -98, -112, -97, -113, -97, -113, -97, -113, -97,
-111, -97, -112, -96, -111, -95, -110, -96, -110, -94, -110, -94, -109, -93,
-109, -93, -107, -92, -108, -91, -106, -90, -105, -88, -105, -87, -104, -87,
-102, -85, -101, -84, -100, -82, -97, -81, -96, -79, -93, -76, -90, -76, -88,
-73, -85, -71, -82, -69, -77, -65, -74, -64, -69, -60, -63, -58, -58, -54, -51,
-52, -45, -48, -37, -45, -30, -40, -20, -37, -12, -34, -1, -29, 8, -25, 19, -19,
25, -16, 36, -11, 38, -6, 49, 0, 44, };