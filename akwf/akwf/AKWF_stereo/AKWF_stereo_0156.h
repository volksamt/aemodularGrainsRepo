#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0156

const PROGMEM int8_t DATA[DATA_LENGTH] = {80, 51, 108, 90, 114, 112, 120, 120,
115, 117, 119, 119, 116, 117, 119, 118, 116, 115, 118, 117, 115, 115, 118, 116,
115, 114, 117, 116, 116, 114, 116, 115, 115, 114, 117, 113, 116, 114, 115, 113,
115, 113, 115, 112, 115, 113, 115, 111, 115, 111, 114, 111, 115, 111, 114, 109,
114, 110, 114, 109, 114, 110, 113, 108, 115, 108, 114, 108, 114, 108, 113, 107,
114, 107, 113, 107, 113, 106, 112, 106, 113, 106, 113, 105, 113, 105, 112, 105,
112, 104, 112, 105, 112, 104, 112, 104, 112, 104, 112, 103, 111, 102, 112, 103,
112, 102, 111, 102, 110, 102, 111, 102, 110, 102, 111, 101, 111, 100, 109, 100,
110, 100, 111, 100, 111, 100, 109, 99, 110, 99, 109, 99, 109, 99, 109, 98, 109,
98, 109, 97, 109, 97, 109, 97, 109, 96, 109, 97, 109, 95, 108, 95, 108, 95, 108,
95, 108, 96, 108, 95, 108, 94, 108, 95, 108, 94, 108, 94, 107, 94, 108, 93, 107,
93, 107, 93, 107, 92, 107, 93, 107, 92, 106, 92, 106, 92, 107, 91, 106, 91, 107,
91, 106, 91, 106, 90, 106, 90, 105, 90, 105, 89, 106, 89, 105, 89, 105, 88, 105,
89, 104, 88, 105, 88, 105, 88, 105, 88, 104, 87, 104, 87, 104, 86, 104, 88, 104,
87, 105, 86, 104, 86, 105, 85, 103, 85, 104, 85, 104, 85, 103, 85, 103, 85, 104,
85, 103, 84, 103, 83, 103, 85, 103, 84, 103, 83, 103, 83, 103, 83, 102, 82, 102,
83, 102, 82, 103, 82, 103, 82, 102, 81, 102, 81, 102, 81, 101, 82, 102, 81, 98,
71, 86, 42, 74, 15, 71, 9, 71, 10, 72, 11, 72, 12, 73, 12, 72, 11, 72, 12, 72,
12, 72, 12, 72, 13, 73, 13, 72, 13, 73, 14, 73, 14, 73, 14, 72, 14, 73, 14, 73,
14, 73, 14, 73, 15, 73, 15, 73, 15, 74, 14, 74, 16, 73, 15, 74, 16, 74, 16, 74,
16, 74, 16, 74, 16, 74, 16, 75, 17, 74, 16, 75, 18, 75, 17, 74, 18, 74, 18, 75,
18, 75, 18, 75, 18, 75, 19, 75, 19, 75, 20, 75, 19, 75, 19, 75, 20, 75, 20, 76,
19, 75, 20, 75, 20, 77, 20, 76, 21, 76, 21, 76, 21, 77, 21, 77, 21, 77, 21, 76,
22, 76, 21, 77, 21, 77, 22, 76, 22, 76, 23, 76, 22, 76, 23, 77, 22, 77, 22, 77,
23, 77, 23, 77, 24, 76, 24, 77, 24, 77, 24, 77, 25, 77, 23, 78, 24, 77, 25, 77,
24, 77, 24, 78, 25, 78, 24, 78, 26, 79, 26, 78, 26, 77, 25, 78, 26, 79, 26, 77,
26, 79, 26, 78, 26, 79, 26, 79, 27, 80, 28, 78, 27, 80, 27, 79, 27, 79, 28, 79,
28, 79, 28, 79, 27, 80, 29, 78, 27, 80, 28, 78, 29, 79, 28, 79, 28, 80, 29, 79,
28, 79, 29, 79, 29, 80, 29, 80, 30, 79, 30, 80, 30, 79, 30, 81, 30, 79, 28, 81,
31, 79, 29, 82, 32, 78, 30, 83, 32, 78, 29, 84, 33, 76, 29, 84, 33, 76, 28, 86,
34, 74, 27, 91, 37, 57, 19, -104, -77, -97, -72, -97, -72, -99, -73, -97, -72,
-100, -73, -95, -71, -100, -73, -95, -70, -100, -72, -96, -70, -99, -72, -96,
-70, -100, -72, -96, -70, -99, -72, -97, -70, -98, -71, -96, -70, -99, -71, -96,
-70, -98, -70, -96, -70, -97, -70, -97, -70, -97, -70, -97, -70, -98, -70, -97,
-70, -97, -69, -97, -70, -96, -69, -97, -69, -96, -68, -97, -69, -96, -68, -97,
-68, -97, -68, -97, -68, -96, -67, -97, -69, -97, -67, -97, -68, -96, -68, -96,
-68, -96, -68, -96, -67, -96, -67, -96, -67, -96, -68, -96, -67, -95, -68, -96,
-67, -95, -67, -95, -67, -96, -67, -95, -66, -95, -66, -95, -67, -96, -66, -95,
-66, -95, -66, -95, -66, -96, -66, -95, -66, -96, -66, -95, -66, -95, -65, -95,
-66, -95, -66, -95, -65, -95, -66, -95, -65, -94, -66, -95, -65, -95, -65, -95,
-64, -95, -64, -95, -64, -95, -64, -95, -65, -96, -64, -95, -64, -95, -65, -94,
-64, -95, -64, -94, -64, -94, -63, -95, -64, -94, -64, -94, -63, -95, -63, -94,
-64, -95, -64, -94, -64, -95, -64, -94, -64, -94, -63, -93, -63, -94, -63, -93,
-62, -94, -63, -94, -63, -95, -63, -95, -62, -95, -63, -93, -62, -94, -62, -94,
-62, -93, -63, -94, -62, -94, -62, -94, -62, -94, -63, -94, -62, -94, -62, -94,
-62, -93, -62, -94, -62, -93, -62, -94, -61, -93, -61, -93, -61, -93, -61, -93,
-61, -93, -61, -93, -61, -93, -60, -93, -61, -93, -61, -93, -60, -94, -61, -93,
-61, -93, -61, -93, -60, -92, -60, -94, -61, -94, -59, -92, -61, -93, -60, -93,
-60, -93, -60, -93, -60, -93, -60, -93, -59, -92, -59, -92, -60, -92, -60, -93,
-60, -92, -59, -93, -59, -92, -59, -93, -59, -92, -60, -92, -60, -92, -58, -92,
-60, -92, -59, -92, -58, -92, -59, -92, -59, -92, -58, -92, -59, -93, -59, -92,
-59, -92, -59, -93, -59, -93, -59, -92, -58, -92, -58, -91, -58, -92, -58, -93,
-58, -93, -58, -92, -59, -93, -58, -92, -58, -92, -58, -92, -58, -92, -58, -92,
-58, -92, -58, -91, -58, -92, -58, -91, -58, -91, -58, -92, -58, -91, -57, -92,
-57, -92, -57, -91, -58, -92, -58, -92, -57, -91, -58, -91, -58, -92, -57, -92,
-57, -92, -57, -92, -57, -92, -57, -92, -57, -92, -58, -91, -56, -92, -57, -91,
-57, -91, -56, -90, -56, -91, -56, -91, -56, -92, -56, -90, -57, -92, -56, -92,
-56, -91, -56, -91, -56, -91, -56, -91, -56, -91, -56, -92, -56, -90, -56, -92,
-56, -91, -56, -92, -55, -90, -56, -92, -56, -91, -55, -91, -56, -90, -54, -93,
-56, -89, -55, -92, -56, -89, -55, -94, -56, -88, -54, -94, -57, -88, -53, -96,
-59, -78, -47, };