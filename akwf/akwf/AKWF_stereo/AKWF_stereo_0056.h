#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0056

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1,
2, 2, 1, 2, 2, 2, 3, 3, 2, 3, 4, 3, 2, 3, 3, 2, 3, 4, 4, 4, 4, 4, 5, 4, 4, 5, 5,
4, 5, 4, 5, 5, 5, 5, 5, 5, 5, 5, 6, 5, 5, 5, 6, 5, 6, 6, 6, 7, 6, 6, 6, 6, 7, 6,
7, 7, 7, 6, 7, 7, 8, 7, 8, 8, 7, 7, 8, 8, 8, 8, 8, 8, 9, 8, 8, 8, 9, 8, 8, 8, 9,
9, 9, 9, 10, 9, 9, 10, 9, 9, 10, 9, 10, 9, 10, 9, 10, 10, 11, 10, 10, 10, 10,
11, 10, 10, 10, 11, 11, 10, 11, 11, 11, 10, 10, 11, 12, 11, 11, 12, 12, 11, 12,
12, 11, 12, 12, 11, 12, 12, 12, 12, 12, 12, 12, 12, 13, 12, 13, 14, 13, 12, 13,
13, 13, 13, 13, 13, 13, 14, 13, 13, 14, 14, 13, 14, 13, 13, 14, 14, 14, 13, 14,
13, 14, 14, 14, 14, 14, 14, 15, 14, 15, 14, 15, 15, 14, 15, 15, 14, 15, 15, 15,
15, 15, 15, 15, 15, 16, 16, 15, 15, 15, 16, 15, 16, 15, 16, 15, 15, 16, 16, 16,
15, 16, 16, 16, 16, 16, 16, 15, 16, 16, 16, 16, 17, 16, 16, 17, 16, 16, 16, 16,
17, 17, 17, 16, 17, 16, 17, 16, 16, 17, 17, 17, 17, 17, 17, 18, 17, 18, 17, 18,
17, 18, 18, 17, 17, 17, 17, 17, 18, 18, 18, 18, 17, 18, 18, 18, 18, 18, 18, 18,
18, 17, 17, 18, 17, 17, 18, 19, 18, 18, 17, 18, 18, 18, 18, 18, 19, 17, 18, 18,
19, 19, 18, 18, 18, 19, 19, 18, 18, 19, 18, 18, 18, 18, 19, 18, 19, 19, 19, 19,
19, 19, 19, 18, 19, 19, 18, 19, 19, 19, 19, 19, 19, 20, 19, 20, 19, 19, 18, 18,
19, 20, 18, 19, 19, 19, 19, 19, 19, 20, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19,
19, 19, 20, 20, 19, 19, 19, 20, 19, 20, 19, 19, 20, 20, 19, 19, 20, 20, 19, 20,
20, 20, 19, 19, 20, 20, 19, 19, 20, 20, 20, 20, 19, 19, 19, 20, 20, 20, 19, 19,
20, 19, 20, 20, 20, 19, 20, 20, 20, 20, 19, 20, 19, 19, 20, 20, 21, 20, 20, 20,
20, 19, 21, 20, 19, 20, 20, 21, 20, 21, 20, 20, 20, 20, 19, 20, 19, 20, 20, 20,
20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 19, 20, 19, 21, 20, 20, 20, 21, 20,
20, 20, 20, 20, 20, 20, 19, 20, 20, 20, 21, 20, 20, 20, 20, 20, 20, 21, 20, 20,
20, 20, 19, 19, 20, 20, 20, 20, 20, 20, 20, 19, 20, 20, 20, 19, 20, 20, 20, 19,
20, 20, 20, 20, 20, 21, 20, 20, 21, 20, 19, 20, 21, 19, 20, 20, 20, 19, 20, 20,
20, 19, 20, 20, 19, 19, 20, 20, 19, 19, 21, 20, 18, 19, 22, 21, 16, 17, 24, 23,
10, 12, 68, 43, 122, 85, 80, 61, 64, 59, 38, 50, 26, 47, 13, 43, 8, 39, 4, 37,
2, 36, -1, 35, 0, 31, -1, 31, 0, 29, 0, 28, 0, 26, 1, 25, 1, 23, 2, 22, 2, 19,
3, 18, 1, 16, 2, 15, 1, 13, 1, 12, 1, 10, -1, 8, -2, 6, -1, 5, -2, 3, -3, 1, -4,
-1, -5, -3, -5, -3, -6, -5, -7, -6, -8, -9, -9, -11, -10, -11, -10, -13, -12,
-14, -13, -16, -13, -18, -14, -18, -15, -20, -16, -21, -17, -22, -17, -23, -18,
-24, -19, -25, -20, -25, -20, -27, -21, -28, -21, -29, -23, -30, -24, -30, -24,
-31, -25, -32, -25, -32, -27, -34, -27, -34, -27, -34, -28, -36, -28, -36, -29,
-37, -30, -38, -30, -38, -30, -37, -30, -38, -31, -38, -31, -40, -31, -39, -32,
-40, -33, -39, -33, -40, -33, -41, -33, -40, -33, -41, -34, -41, -34, -41, -35,
-41, -34, -41, -35, -42, -34, -42, -35, -41, -36, -42, -35, -42, -36, -42, -36,
-42, -36, -42, -35, -42, -36, -42, -36, -42, -36, -41, -36, -41, -37, -40, -36,
-41, -36, -41, -37, -40, -35, -41, -35, -40, -35, -40, -36, -40, -36, -40, -35,
-41, -36, -40, -35, -39, -35, -39, -35, -39, -35, -39, -35, -38, -34, -38, -35,
-38, -34, -37, -34, -37, -34, -36, -34, -37, -33, -36, -33, -36, -34, -36, -33,
-36, -33, -35, -32, -35, -32, -36, -32, -35, -32, -34, -31, -34, -32, -34, -31,
-33, -31, -34, -30, -32, -30, -33, -31, -32, -30, -32, -29, -31, -30, -30, -28,
-30, -28, -30, -29, -30, -29, -29, -29, -30, -28, -29, -28, -29, -28, -28, -26,
-27, -27, -27, -26, -28, -26, -27, -26, -26, -26, -26, -25, -26, -25, -26, -24,
-25, -24, -25, -23, -25, -24, -25, -23, -23, -23, -24, -23, -23, -22, -23, -22,
-23, -22, -22, -21, -22, -21, -22, -21, -21, -20, -21, -20, -21, -20, -20, -19,
-20, -20, -20, -19, -19, -19, -19, -19, -18, -19, -19, -17, -18, -18, -17, -17,
-17, -17, -17, -16, -16, -16, -16, -16, -15, -16, -16, -16, -16, -16, -14, -15,
-15, -15, -14, -14, -14, -14, -13, -13, -13, -13, -13, -13, -13, -13, -13, -13,
-12, -13, -12, -11, -12, -12, -11, -12, -11, -11, -11, -11, -11, -11, -10, -10,
-10, -10, -10, -10, -10, -10, -10, -9, -9, -9, -9, -9, -8, -9, -8, -9, -7, -8,
-7, -8, -7, -7, -7, -7, -7, -7, -6, -6, -7, -6, -5, -6, -5, -5, -5, -6, -5, -5,
-5, -5, -5, -5, -5, -4, -4, -5, -4, -4, -3, -4, -3, -4, -3, -4, -3, -3, -3, -4,
-2, -3, -2, -3, -3, -2, -2, -2, -1, -2, -2, -2, -1, -2, 0, -1, -1, 0, 0, -1, 0,
-1, 0, 0, 1, 0, 0, };