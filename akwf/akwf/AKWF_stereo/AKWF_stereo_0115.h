#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0115

const PROGMEM int8_t DATA[DATA_LENGTH] = {37, 36, 45, 43, 40, 40, 43, 43, 41,
41, 44, 42, 42, 41, 44, 42, 42, 40, 43, 42, 42, 41, 44, 41, 41, 41, 44, 43, 49,
48, 52, 51, 51, 50, 52, 51, 51, 50, 52, 50, 52, 50, 51, 51, 51, 50, 51, 51, 51,
50, 52, 51, 53, 51, 52, 50, 55, 53, 57, 55, 69, 67, 75, 74, 75, 72, 75, 73, 75,
73, 75, 73, 74, 73, 75, 73, 75, 73, 75, 74, 74, 73, 75, 72, 75, 73, 76, 74, 81,
78, 81, 79, 82, 80, 81, 79, 80, 79, 81, 79, 82, 80, 82, 80, 81, 80, 81, 80, 81,
80, 82, 79, 81, 79, 81, 79, 81, 79, 82, 81, 85, 82, 86, 83, 88, 85, 86, 84, 88,
86, 86, 84, 89, 86, 96, 94, 98, 95, 97, 95, 97, 96, 98, 95, 98, 95, 97, 96, 98,
95, 97, 96, 97, 96, 98, 96, 97, 95, 97, 95, 98, 95, 97, 95, 97, 95, 98, 96, 100,
98, 101, 99, 103, 99, 103, 100, 102, 100, 102, 100, 103, 100, 102, 100, 103,
100, 102, 100, 103, 100, 103, 100, 103, 100, 102, 100, 103, 100, 102, 101, 102,
100, 103, 100, 102, 100, 102, 101, 103, 101, 102, 100, 103, 99, 102, 100, 102,
100, 108, 106, 119, 116, 119, 116, 119, 116, 119, 116, 119, 115, 118, 116, 119,
116, 119, 116, 120, 117, 120, 116, 119, 116, 118, 116, 118, 116, 120, 115, 119,
116, 119, 117, 119, 116, 119, 116, 120, 116, 119, 116, 119, 117, 119, 115, 119,
117, 119, 116, 119, 116, 119, 116, 119, 116, 119, 117, 119, 116, 118, 116, 119,
117, 119, 116, 118, 116, 119, 116, 119, 116, 118, 115, 109, 106, 102, 99, 103,
100, 103, 100, 102, 100, 103, 99, 103, 100, 103, 100, 102, 100, 102, 100, 102,
101, 103, 99, 103, 100, 103, 100, 103, 101, 102, 100, 103, 100, 102, 100, 103,
100, 103, 100, 102, 99, 103, 100, 102, 100, 103, 100, 103, 101, 101, 99, 99, 96,
97, 96, 98, 96, 97, 95, 97, 96, 98, 96, 98, 96, 98, 96, 98, 96, 98, 95, 98, 95,
99, 95, 98, 96, 98, 95, 97, 95, 98, 96, 96, 93, 88, 87, 86, 85, 87, 86, 87, 86,
87, 84, 86, 84, 82, 81, 81, 80, 82, 80, 82, 79, 81, 80, 81, 80, 81, 79, 81, 80,
81, 80, 81, 79, 81, 79, 82, 79, 81, 80, 82, 79, 81, 79, 82, 80, 80, 79, 79, 77,
75, 74, 74, 73, 75, 73, 74, 72, 75, 73, 75, 73, 74, 73, 75, 73, 76, 73, 75, 73,
75, 73, 75, 74, 69, 68, 60, 59, 56, 54, 51, 50, 52, 51, 51, 51, 52, 50, 52, 50,
52, 50, 52, 50, 52, 50, 52, 50, 52, 50, 52, 50, 52, 50, 52, 51, 50, 49, 44, 42,
42, 40, 43, 42, 42, 42, 43, 41, 42, 41, 43, 42, 42, 42, 43, 41, 42, 40, 43, 42,
42, 41, 44, 42, 23, 23, -27, -26, -44, -42, -42, -41, -43, -42, -42, -41, -42,
-42, -43, -42, -42, -42, -42, -42, -43, -42, -42, -41, -43, -41, -42, -40, -44,
-43, -50, -49, -52, -51, -51, -50, -52, -51, -51, -51, -51, -51, -52, -50, -52,
-50, -52, -50, -51, -51, -52, -51, -52, -50, -52, -51, -52, -51, -55, -54, -60,
-59, -70, -68, -76, -73, -74, -72, -76, -73, -75, -73, -75, -73, -75, -73, -74,
-73, -76, -73, -75, -72, -76, -73, -74, -73, -77, -74, -78, -76, -80, -78, -82,
-80, -81, -79, -82, -79, -81, -79, -81, -80, -81, -80, -81, -79, -81, -79, -82,
-79, -81, -79, -81, -80, -81, -79, -82, -80, -81, -79, -81, -79, -83, -81, -86,
-84, -87, -85, -86, -85, -87, -85, -87, -85, -89, -88, -97, -94, -98, -95, -98,
-95, -98, -96, -97, -96, -98, -96, -98, -95, -97, -96, -98, -96, -97, -96, -98,
-95, -98, -96, -97, -96, -98, -95, -98, -96, -97, -96, -99, -96, -102, -99,
-103, -101, -102, -99, -103, -101, -103, -100, -103, -100, -103, -100, -102,
-100, -102, -100, -103, -99, -102, -100, -104, -100, -103, -100, -102, -100,
-102, -100, -102, -100, -102, -101, -103, -100, -102, -101, -103, -100, -102,
-100, -103, -100, -102, -100, -103, -101, -102, -100, -110, -107, -119, -115,
-119, -116, -118, -115, -119, -116, -118, -116, -119, -116, -119, -117, -119,
-116, -119, -116, -119, -116, -119, -116, -119, -116, -118, -116, -119, -115,
-119, -116, -120, -117, -119, -115, -119, -116, -119, -117, -118, -117, -119,
-115, -118, -116, -119, -116, -118, -116, -119, -116, -120, -116, -119, -116,
-119, -116, -119, -116, -119, -116, -119, -116, -119, -115, -119, -116, -118,
-116, -119, -116, -118, -116, -108, -106, -102, -99, -103, -100, -103, -99,
-102, -100, -103, -101, -103, -100, -102, -100, -103, -99, -103, -100, -102,
-100, -103, -101, -103, -100, -103, -100, -103, -100, -103, -99, -102, -99,
-103, -100, -102, -100, -102, -99, -102, -99, -103, -101, -103, -101, -103,
-100, -101, -99, -101, -98, -99, -97, -98, -95, -98, -96, -97, -95, -98, -95,
-98, -95, -98, -96, -98, -96, -98, -95, -98, -95, -98, -95, -97, -95, -98, -95,
-98, -96, -98, -96, -97, -96, -96, -93, -88, -86, -87, -85, -88, -85, -87, -85,
-88, -86, -85, -84, -84, -81, -82, -80, -81, -79, -81, -80, -82, -80, -81, -80,
-82, -78, -82, -79, -81, -80, -81, -79, -81, -79, -81, -80, -82, -78, -81, -79,
-81, -78, -81, -80, -80, -79, -76, -74, -75, -72, -75, -73, -74, -72, -75, -73,
-75, -74, -75, -74, -75, -73, -75, -73, -75, -72, -76, -73, -75, -73, -76, -73,
-67, -66, -56, -55, -55, -54, -52, -50, -52, -51, -51, -51, -52, -50, -51, -50,
-51, -51, -51, -51, -51, -50, -53, -50, -52, -50, -52, -51, -51, -51, -53, -51,
-48, -47, -44, -43, -42, -41, -43, -43, -43, -41, -44, -43, -42, -41, -44, -42,
-42, -41, -43, -42, -42, -40, -44, -43, -41, -40, -46, -45, -36, -35, };