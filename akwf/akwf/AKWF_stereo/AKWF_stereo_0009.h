#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 16, 0, 19, 0, 18, 2, 19, 2, 18, 2,
20, 2, 19, 2, 20, 3, 20, 3, 20, 2, 21, 3, 21, 4, 22, 4, 21, 5, 22, 5, 22, 4, 23,
6, 22, 5, 23, 6, 24, 6, 24, 6, 24, 5, 23, 6, 24, 6, 25, 7, 25, 7, 25, 8, 25, 7,
25, 8, 26, 7, 26, 8, 27, 8, 26, 8, 26, 8, 26, 9, 27, 9, 27, 9, 27, 9, 27, 8, 27,
9, 27, 8, 27, 9, 28, 9, 28, 9, 28, 10, 28, 10, 27, 10, 28, 10, 28, 10, 28, 10,
28, 11, 29, 10, 28, 11, 27, 11, 29, 10, 28, 11, 28, 11, 29, 11, 28, 10, 28, 12,
28, 11, 28, 11, 29, 11, 29, 11, 28, 11, 29, 11, 28, 12, 29, 11, 28, 11, 28, 11,
28, 11, 28, 11, 28, 12, 28, 12, 27, 11, 28, 11, 28, 12, 28, 11, 27, 11, 27, 11,
28, 11, 28, 12, 27, 11, 27, 12, 27, 11, 26, 11, 27, 11, 26, 11, 26, 12, 26, 11,
26, 10, 25, 11, 26, 11, 26, 11, 25, 11, 25, 11, 25, 10, 25, 11, 25, 10, 24, 11,
24, 10, 24, 10, 25, 11, 24, 10, 23, 10, 22, 10, 23, 10, 23, 9, 22, 20, 35, 63,
81, 99, 115, 110, 118, 113, 111, 112, 104, 113, 102, 115, 108, 119, 117, 118,
118, 115, 114, 113, 112, 112, 112, 111, 112, 106, 109, 102, 104, 99, 101, 98,
102, 95, 101, 92, 99, 89, 95, 88, 96, 87, 95, 85, 95, 82, 93, 82, 91, 81, 92,
81, 92, 80, 92, 79, 91, 79, 90, 79, 90, 79, 90, 79, 90, 79, 91, 80, 91, 80, 91,
80, 91, 80, 91, 81, 92, 81, 92, 83, 92, 83, 92, 83, 93, 84, 92, 85, 93, 86, 93,
86, 94, 88, 94, 88, 94, 89, 94, 89, 93, 90, 94, 91, 94, 92, 94, 93, 95, 94, 95,
94, 95, 95, 95, 96, 95, 95, 95, 96, 95, 96, 95, 97, 94, 99, 94, 98, 95, 98, 94,
98, 93, 98, 94, 99, 92, 99, 92, 99, 92, 99, 92, 100, 91, 100, 91, 100, 90, 99,
90, 100, 90, 100, 89, 100, 88, 101, 89, 100, 88, 99, 88, 100, 87, 100, 87, 98,
85, 99, 84, 98, 84, 98, 83, 98, 83, 97, 82, 98, 82, 96, 80, 95, 79, 95, 79, 95,
78, 95, 77, 94, 76, 94, 75, 93, 75, 93, 74, 93, 72, 92, 72, 91, 70, 90, 70, 90,
69, 90, 68, 89, 68, 87, 66, 87, 66, 86, 66, 86, 64, 85, 64, 84, 63, 83, 62, 83,
62, 82, 60, 81, 60, 79, 58, 79, 58, 79, 57, 78, 56, 77, 55, 76, 54, 75, 53, 74,
53, 74, 51, 73, 50, 62, 38, 20, -10, -17, -43, -29, -47, -34, -43, -33, -37,
-34, -36, -38, -44, -43, -52, -43, -55, -41, -53, -39, -51, -39, -53, -38, -53,
-34, -51, -31, -48, -29, -47, -29, -49, -27, -49, -24, -47, -23, -46, -22, -47,
-22, -48, -21, -47, -20, -46, -20, -47, -20, -48, -21, -49, -21, -49, -21, -50,
-21, -51, -22, -51, -24, -53, -24, -53, -25, -55, -26, -56, -28, -57, -29, -59,
-30, -59, -32, -60, -34, -62, -35, -63, -35, -64, -38, -65, -39, -66, -41, -68,
-43, -69, -44, -71, -47, -71, -48, -72, -49, -74, -51, -75, -52, -76, -54, -76,
-55, -78, -57, -78, -58, -79, -60, -81, -61, -80, -62, -82, -64, -83, -64, -83,
-66, -85, -67, -86, -69, -85, -69, -87, -69, -87, -71, -87, -72, -87, -73, -89,
-74, -88, -74, -89, -76, -90, -76, -89, -76, -90, -77, -91, -78, -91, -78, -91,
-79, -91, -80, -92, -80, -91, -80, -91, -81, -92, -81, -92, -81, -91, -82, -91,
-82, -92, -82, -91, -82, -92, -83, -92, -82, -91, -83, -91, -82, -91, -82, -90,
-82, -90, -83, -89, -82, -89, -82, -89, -82, -90, -82, -89, -82, -88, -81, -89,
-81, -89, -81, -88, -81, -88, -81, -87, -81, -87, -81, -86, -81, -85, -81, -85,
-80, -84, -79, -85, -80, -84, -80, -83, -79, -83, -78, -83, -78, -83, -77, -82,
-77, -80, -76, -80, -76, -80, -76, -79, -75, -79, -75, -78, -74, -77, -74, -77,
-74, -77, -73, -76, -72, -75, -72, -75, -72, -74, -70, -74, -71, -73, -70, -73,
-69, -71, -70, -71, -68, -70, -69, -70, -68, -69, -67, -69, -67, -67, -66, -68,
-65, -67, -64, -66, -64, -64, -64, -64, -63, -63, -63, -63, -62, -63, -62, -61,
-61, -61, -60, -60, -60, -60, -59, -59, -59, -59, -58, -57, -58, -57, -58, -57,
-57, -55, -57, -54, -56, -54, -55, -53, -54, -53, -54, -52, -53, -52, -53, -50,
-52, -51, -51, -49, -51, -48, -50, -47, -50, -46, -49, -46, -48, -44, -48, -44,
-47, -44, -47, -43, -46, -42, -46, -42, -46, -40, -45, -40, -44, -40, -44, -38,
-43, -38, -42, -37, -41, -37, -42, -35, -41, -35, -40, -34, -40, -34, -40, -33,
-38, -32, -38, -31, -38, -31, -38, -30, -36, -28, -35, -27, -36, -27, -34, -28,
-33, -26, -34, -25, -33, -25, -33, -23, -32, -23, -32, -22, -31, -22, -30, -21,
-30, -20, -29, -20, -28, -19, -28, -18, -27, -18, -27, -17, -26, -17, -27, -16,
-26, -15, -25, -14, -24, -14, -24, -13, -23, -13, -23, -12, -22, -11, -23, -11,
-22, -10, -22, -9, -21, -9, -20, -9, -19, -7, -19, -7, -19, -6, -17, -5, -18,
-5, -17, -4, -16, -3, -16, -3, -15, -3, -16, -2, -14, -2, -14, -1, -14, -1, -13,
0, -13, 1, -12, 1, -12, 3, -11, 3, -11, 4, -11, 4, -11, 4, -10, 5, -9, 6, -9, 6,
-9, 6, -9, 8, -7, 8, -8, 8, -8, 8, -7, 8, -7, 9, -6, 10, -6, 10, -5, 11, -5, 11,
-4, 12, -4, 12, -4, 13, -4, 13, -3, 14, -3, 13, -3, 15, -3, 15, -2, 15, -1, 15,
-1, 16, 0, 15, 0, 18, 0, 15, };