#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0119

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -15, 5, -17, 9, -13, 13, -13, 16,
-10, 19, -8, 24, -6, 28, -4, 32, -1, 35, 2, 39, 6, 42, 9, 47, 13, 50, 16, 54,
20, 58, 24, 62, 28, 66, 32, 69, 36, 72, 39, 75, 42, 79, 45, 82, 49, 85, 51, 88,
54, 90, 57, 95, 60, 97, 63, 100, 66, 104, 69, 106, 73, 111, 75, 113, 77, 114,
80, 115, 82, 116, 83, 116, 85, 118, 88, 118, 89, 118, 91, 119, 93, 119, 95, 119,
97, 118, 98, 118, 101, 117, 103, 118, 104, 117, 105, 116, 106, 115, 108, 113,
109, 112, 110, 112, 112, 110, 112, 109, 111, 107, 111, 105, 111, 103, 110, 101,
109, 99, 107, 96, 106, 93, 104, 90, 103, 87, 100, 85, 97, 81, 96, 77, 93, 73,
90, 71, 87, 66, 84, 63, 81, 59, 78, 55, 76, 51, 73, 47, 70, 43, 67, 39, 65, 35,
62, 31, 59, 27, 54, 23, 53, 20, 50, 17, 46, 14, 44, 10, 41, 8, 38, 4, 35, 1, 32,
-3, 27, -6, 24, -9, 21, -13, 16, -16, 13, -19, 9, -22, 5, -25, 2, -28, -1, -30,
-5, -33, -9, -37, -13, -39, -16, -43, -20, -46, -23, -49, -27, -51, -30, -55,
-33, -57, -36, -59, -39, -61, -43, -63, -44, -66, -47, -69, -48, -72, -50, -75,
-52, -78, -55, -80, -57, -83, -60, -85, -61, -89, -65, -91, -67, -94, -70, -96,
-73, -97, -75, -101, -79, -103, -81, -105, -84, -107, -87, -109, -91, -110, -92,
-109, -94, -109, -94, -109, -95, -109, -96, -108, -97, -107, -98, -106, -99,
-105, -98, -105, -99, -105, -98, -103, -99, -101, -98, -100, -97, -98, -96, -97,
-95, -95, -93, -94, -92, -92, -92, -90, -90, -88, -90, -85, -88, -83, -85, -79,
-84, -78, -81, -75, -79, -71, -77, -68, -75, -67, -74, -63, -72, -60, -70, -56,
-68, -52, -66, -49, -64, -45, -62, -42, -59, -37, -57, -34, -54, -30, -51, -26,
-49, -22, -45, -18, -42, -16, -39, -11, -34, -7, -32, -4, -28, -1, -25, 3, -20,
7, -17, 8, -15, 12, -11, 14, -8, 16, -6, 18, -3, 20, -1, 23, 2, 25, 4, 27, 7,
29, 8, 32, 10, 34, 12, 35, 13, 37, 16, 39, 17, 41, 19, 43, 21, 45, 23, 47, 25,
48, 27, 50, 29, 51, 29, 52, 31, 52, 32, 54, 33, 54, 35, 53, 36, 54, 38, 54, 39,
55, 41, 55, 43, 55, 43, 54, 45, 54, 45, 51, 44, 49, 44, 46, 43, 44, 43, 43, 41,
40, 41, 38, 39, 36, 38, 33, 36, 31, 35, 28, 33, 25, 31, 22, 29, 19, 25, 16, 23,
12, 20, 9, 19, 5, 17, 2, 14, -1, 12, -5, 9, -8, 7, -12, 4, -15, 2, -19, -1, -24,
-4, -27, -7, -31, -10, -35, -13, -39, -18, -42, -19, -46, -23, -49, -27, -53,
-30, -58, -33, -61, -37, -65, -40, -68, -44, -72, -47, -75, -50, -79, -54, -81,
-58, -85, -61, -87, -65, -90, -70, -93, -74, -93, -75, -93, -76, -91, -77, -91,
-76, -89, -76, -88, -76, -87, -76, -86, -76, -84, -77, -82, -77, -80, -76, -79,
-76, -76, -75, -74, -74, -72, -72, -69, -71, -67, -70, -64, -67, -61, -66, -59,
-64, -56, -62, -54, -61, -52, -59, -49, -57, -47, -55, -44, -53, -42, -50, -40,
-48, -37, -46, -36, -45, -33, -42, -32, -40, -29, -38, -27, -37, -24, -34, -22,
-33, -20, -30, -18, -29, -16, -27, -14, -24, -13, -22, -11, -21, -8, -18, -7,
-16, -6, -16, -5, -13, -2, -11, -1, -8, -1, -8, -2, -8, -3, -9, -4, -8, -5, -9,
-5, -9, -6, -8, -7, -8, -6, -8, -6, -7, -5, -6, -5, -5, -4, -5, -3, -5, -3, -5,
-2, -5, -1, -5, 0, -5, 1, -4, 2, -4, 5, -3, 6, -1, 9, 0, 11, 0, 13, 2, 15, 3,
17, 5, 19, 6, 21, 8, 23, 10, 26, 12, 28, 14, 31, 17, 33, 19, 35, 21, 36, 23, 39,
24, 41, 27, 43, 29, 46, 32, 49, 34, 52, 36, 54, 39, 58, 41, 61, 44, 65, 46, 66,
50, 70, 52, 73, 55, 76, 57, 80, 61, 83, 64, 86, 67, 90, 69, 93, 72, 96, 75, 98,
77, 98, 80, 100, 82, 101, 84, 103, 86, 104, 87, 105, 89, 106, 92, 106, 94, 105,
95, 104, 95, 103, 95, 104, 95, 101, 95, 101, 94, 100, 95, 98, 93, 98, 94, 95,
93, 94, 94, 93, 94, 92, 93, 91, 91, 88, 90, 86, 88, 84, 87, 82, 84, 80, 83, 78,
83, 76, 81, 74, 79, 72, 79, 70, 76, 67, 74, 65, 73, 62, 71, 59, 68, 56, 67, 53,
64, 52, 63, 49, 60, 46, 58, 42, 55, 40, 53, 37, 50, 33, 48, 29, 44, 26, 42, 23,
39, 19, 36, 15, 34, 13, 30, 9, 27, 6, 25, 3, 21, -1, 18, -3, 16, -5, 13, -8, 10,
-9, 8, -11, 6, -14, 3, -16, 0, -18, -1, -19, -4, -21, -7, -24, -9, -26, -12,
-29, -13, -31, -17, -33, -17, -34, -19, -37, -21, -37, -22, -39, -24, -40, -26,
-43, -29, -44, -31, -46, -33, -48, -35, -50, -37, -52, -39, -54, -41, -57, -43,
-58, -45, -60, -47, -62, -49, -63, -50, -63, -51, -65, -53, -66, -55, -67, -56,
-67, -57, -68, -59, -69, -59, -68, -59, -68, -60, -69, -62, -68, -62, -68, -62,
-69, -62, -68, -62, -68, -62, -70, -61, -69, -60, -70, -61, -70, -60, -71, -60,
-72, -59, -73, -59, -74, -60, -75, -60, -75, -59, -73, -60, -73, -60, -73, -60,
-73, -60, -71, -60, -71, -60, -70, -60, -70, -62, -68, -60, -66, -59, -64, -59,
-61, -57, -59, -55, -57, -53, -55, -52, -52, -49, -50, -48, -46, -47, -44, -44,
-42, -43, -40, -42, -38, -39, -37, -37, -34, -35, -33, -34, -30, -32, -27, -30,
-26, -28, -24, -27, -21, -25, -20, -24, -17, -23, -15, -22, -13, -21, -10, -22,
-7, -19, -4, -19, -1, -15, };