#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0117

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, -15, 7, -15, 10, -10, 15, -8, 19,
-3, 24, -1, 29, 4, 34, 7, 37, 12, 42, 16, 47, 20, 51, 23, 55, 27, 58, 31, 64,
36, 67, 39, 71, 44, 74, 47, 77, 51, 80, 55, 83, 59, 86, 62, 88, 65, 89, 69, 91,
72, 92, 74, 93, 77, 94, 80, 95, 82, 95, 83, 95, 84, 95, 86, 95, 88, 95, 89, 93,
88, 92, 88, 91, 89, 90, 89, 87, 87, 87, 87, 86, 86, 83, 84, 82, 83, 80, 82, 79,
81, 77, 79, 75, 77, 74, 76, 74, 75, 71, 74, 71, 71, 70, 69, 69, 68, 68, 67, 67,
66, 66, 65, 66, 65, 66, 64, 65, 64, 66, 63, 66, 64, 67, 63, 69, 64, 69, 64, 70,
65, 71, 65, 73, 66, 74, 68, 76, 69, 78, 71, 80, 72, 83, 75, 85, 76, 87, 78, 90,
79, 93, 82, 96, 85, 98, 87, 101, 89, 103, 91, 105, 94, 107, 97, 109, 99, 110,
102, 111, 103, 113, 106, 114, 107, 114, 109, 113, 110, 113, 111, 113, 113, 111,
113, 109, 112, 108, 112, 104, 113, 101, 111, 98, 109, 94, 108, 90, 106, 86, 103,
82, 100, 77, 98, 72, 94, 67, 90, 62, 87, 57, 83, 53, 79, 48, 75, 44, 69, 39, 65,
35, 60, 31, 57, 27, 53, 23, 49, 20, 45, 18, 42, 16, 37, 13, 34, 11, 32, 10, 28,
9, 26, 8, 24, 7, 22, 7, 20, 7, 19, 7, 17, 7, 17, 8, 16, 9, 15, 10, 15, 11, 15,
12, 15, 13, 16, 15, 16, 17, 17, 18, 17, 21, 17, 22, 18, 24, 20, 25, 21, 27, 22,
29, 23, 31, 25, 33, 25, 34, 27, 34, 28, 36, 30, 37, 31, 37, 32, 39, 33, 39, 34,
39, 35, 38, 36, 38, 37, 38, 37, 37, 38, 36, 37, 34, 38, 33, 37, 32, 37, 30, 36,
27, 36, 26, 35, 24, 33, 20, 31, 18, 29, 16, 27, 13, 25, 10, 22, 7, 20, 5, 17, 2,
15, -1, 12, -4, 9, -6, 6, -9, 3, -11, 0, -13, -1, -15, -5, -17, -7, -18, -9,
-20, -12, -22, -14, -23, -16, -24, -17, -25, -19, -25, -20, -25, -21, -25, -22,
-26, -23, -25, -23, -25, -23, -24, -23, -23, -23, -21, -22, -20, -22, -19, -21,
-17, -21, -15, -19, -12, -18, -10, -16, -7, -14, -4, -12, -1, -10, 0, -8, 4, -6,
6, -3, 10, -1, 12, 2, 15, 3, 16, 6, 19, 9, 21, 11, 22, 13, 24, 15, 24, 17, 24,
18, 25, 20, 25, 21, 24, 23, 23, 22, 23, 24, 21, 23, 18, 22, 16, 21, 14, 21, 11,
19, 7, 18, 5, 16, 1, 14, -4, 11, -7, 8, -11, 5, -14, 2, -18, -1, -22, -4, -25,
-7, -28, -11, -30, -15, -33, -17, -36, -20, -38, -24, -40, -26, -41, -28, -42,
-31, -43, -33, -43, -34, -43, -35, -43, -36, -42, -37, -41, -37, -40, -38, -39,
-38, -37, -38, -34, -37, -33, -36, -31, -36, -28, -35, -25, -33, -22, -32, -19,
-30, -16, -28, -13, -25, -11, -23, -8, -21, -4, -19, -1, -16, 1, -14, 5, -11, 7,
-8, 10, -6, 13, -3, 17, -1, 18, 2, 21, 5, 23, 8, 24, 10, 26, 13, 28, 15, 29, 17,
30, 19, 31, 22, 32, 23, 32, 26, 31, 27, 31, 28, 31, 29, 30, 30, 30, 29, 29, 29,
27, 30, 26, 29, 24, 29, 23, 28, 21, 27, 19, 25, 17, 25, 16, 23, 13, 21, 12, 19,
10, 18, 7, 15, 7, 13, 4, 12, 4, 11, 2, 7, 1, 7, 0, 5, -1, 4, -2, 1, -2, 1, -2,
0, -3, -2, -3, -2, -2, -3, -2, -3, -2, -4, -3, -4, -1, -3, 0, -3, 1, -3, 1, -2,
4, -1, 5, 0, 7, 1, 9, 1, 11, 4, 13, 5, 14, 7, 17, 9, 19, 10, 21, 12, 24, 13, 26,
16, 27, 18, 30, 20, 32, 22, 33, 23, 35, 26, 36, 26, 37, 29, 37, 30, 37, 32, 37,
32, 35, 34, 34, 33, 33, 35, 31, 34, 29, 33, 25, 32, 22, 31, 19, 30, 14, 28, 10,
26, 5, 23, 1, 20, -5, 16, -10, 12, -15, 8, -21, 4, -26, 0, -32, -5, -38, -10,
-44, -15, -49, -20, -54, -24, -58, -30, -63, -35, -66, -39, -71, -44, -75, -48,
-78, -53, -82, -56, -84, -60, -86, -64, -88, -67, -89, -69, -91, -72, -92, -75,
-93, -78, -94, -79, -94, -80, -94, -82, -94, -82, -93, -83, -92, -84, -91, -85,
-90, -86, -89, -84, -87, -85, -86, -85, -84, -84, -83, -84, -82, -83, -80, -82,
-78, -81, -78, -80, -76, -79, -75, -78, -73, -77, -71, -76, -71, -74, -70, -74,
-69, -72, -68, -72, -68, -71, -68, -69, -68, -69, -69, -68, -69, -67, -70, -67,
-70, -67, -72, -67, -73, -67, -74, -67, -76, -68, -78, -69, -80, -70, -82, -71,
-84, -72, -86, -75, -88, -76, -92, -79, -94, -81, -96, -83, -100, -85, -102,
-88, -103, -90, -105, -93, -108, -96, -110, -98, -111, -100, -113, -103, -114,
-106, -116, -107, -116, -109, -117, -112, -119, -113, -119, -115, -119, -116,
-119, -117, -119, -117, -119, -118, -117, -118, -116, -118, -115, -118, -113,
-117, -112, -117, -109, -117, -108, -115, -105, -114, -102, -112, -100, -109,
-96, -108, -93, -105, -89, -102, -85, -100, -81, -98, -77, -94, -73, -90, -68,
-87, -64, -84, -60, -80, -56, -77, -52, -72, -48, -69, -42, -65, -39, -60, -35,
-57, -32, -54, -29, -49, -27, -47, -24, -43, -22, -39, -21, -37, -18, -34, -18,
-33, -18, -31, -17, -28, -17, -27, -18, -26, -18, -25, -20, -24, -21, -24, -21,
-23, -23, -24, -25, -25, -25, -26, -27, -27, -29, -28, -30, -29, -31, -29, -32,
-31, -34, -33, -34, -34, -35, -34, -35, -35, -35, -36, -34, -36, -34, -37, -32,
-37, -31, -37, -28, -36, -26, -34, -24, -35, -22, -33, -19, -31, -16, -29, -13,
-28, -9, -24, -5, -24, -1, -16, };