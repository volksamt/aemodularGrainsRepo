#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0058

const PROGMEM int8_t DATA[DATA_LENGTH] = {37, 93, 77, 104, 86, 90, 91, 93, 91,
86, 92, 92, 92, 87, 93, 91, 92, 88, 92, 90, 92, 88, 92, 90, 92, 87, 92, 89, 92,
87, 92, 89, 91, 87, 92, 87, 91, 88, 93, 88, 91, 88, 92, 88, 92, 88, 92, 88, 92,
89, 92, 89, 93, 90, 92, 89, 92, 90, 93, 89, 93, 91, 93, 91, 93, 91, 93, 91, 93,
92, 94, 91, 93, 92, 94, 92, 94, 93, 94, 93, 94, 93, 94, 93, 94, 94, 95, 94, 95,
94, 95, 95, 95, 95, 95, 95, 95, 96, 95, 97, 95, 96, 96, 97, 96, 97, 96, 98, 96,
98, 96, 98, 96, 98, 97, 99, 96, 98, 97, 100, 97, 100, 97, 100, 97, 100, 98, 100,
98, 100, 97, 101, 97, 101, 97, 102, 97, 102, 98, 102, 98, 102, 98, 102, 98, 103,
98, 103, 98, 103, 98, 103, 99, 103, 98, 104, 99, 103, 99, 104, 98, 104, 99, 104,
99, 104, 99, 104, 98, 105, 99, 104, 99, 105, 99, 105, 99, 105, 99, 106, 99, 105,
98, 105, 99, 105, 100, 105, 100, 105, 99, 105, 99, 106, 100, 106, 99, 105, 99,
106, 99, 104, 100, 108, 102, 112, 105, 111, 107, 111, 107, 110, 107, 110, 107,
110, 106, 111, 106, 110, 106, 110, 106, 110, 106, 110, 106, 111, 106, 110, 107,
109, 106, 111, 106, 109, 107, 110, 106, 109, 106, 109, 106, 109, 106, 109, 106,
110, 107, 109, 106, 110, 106, 110, 107, 110, 106, 109, 106, 109, 106, 109, 106,
109, 106, 109, 107, 110, 106, 110, 106, 109, 106, 109, 106, 108, 106, 110, 106,
109, 106, 109, 106, 109, 107, 108, 106, 108, 106, 109, 106, 109, 106, 109, 106,
108, 107, 109, 107, 109, 106, 108, 106, 109, 106, 109, 106, 109, 106, 109, 106,
109, 106, 109, 106, 108, 106, 109, 107, 108, 106, 109, 106, 109, 106, 109, 105,
109, 106, 109, 107, 108, 107, 109, 106, 109, 106, 108, 106, 109, 106, 109, 106,
109, 106, 109, 107, 108, 106, 109, 106, 109, 106, 109, 106, 108, 106, 108, 106,
109, 107, 108, 106, 109, 106, 109, 107, 109, 106, 109, 106, 110, 106, 108, 105,
109, 106, 108, 105, 110, 106, 108, 106, 109, 106, 107, 106, 110, 106, 108, 106,
109, 107, 108, 106, 110, 106, 107, 106, 110, 106, 109, 106, 109, 107, 111, 95,
34, 55, 29, 25, 43, 17, 42, 14, 50, 15, 47, 14, 51, 14, 48, 14, 50, 14, 49, 15,
51, 15, 49, 14, 52, 15, 51, 15, 53, 16, 52, 16, 52, 16, 53, 16, 53, 15, 53, 16,
53, 15, 54, 16, 53, 16, 54, 17, 54, 16, 54, 16, 54, 17, 54, 16, 54, 17, 54, 15,
54, 16, 54, 16, 53, 16, 53, 16, 53, 16, 53, 16, 53, 16, 53, 16, 54, 16, 53, 16,
53, 15, 52, 15, 52, 16, 52, 16, 51, 15, 52, 15, 52, 15, 51, 15, 50, 15, 50, 15,
51, 15, 49, 15, 51, 14, 49, 15, 49, 14, 48, 14, 49, 14, 48, 14, 48, 14, 49, 14,
48, 14, 47, 14, 48, 13, 47, 13, 47, 13, 47, 13, 47, 13, 47, 13, 46, 13, 46, 13,
45, 12, 46, 13, 45, 12, 45, 13, 44, 12, 45, 12, 45, 12, 46, 12, 43, 12, 44, 12,
42, 12, 44, 12, 43, 12, 44, 11, 43, 12, 43, 12, 43, 12, 43, 12, 43, 12, 42, 12,
43, 11, 41, 12, 44, 12, 41, 10, 44, 12, 39, 10, 46, 12, 36, 10, 50, 12, 32, 8,
61, 18, -25, -4, -128, -60, -96, -77, -104, -84, -90, -85, -95, -86, -89, -85,
-92, -86, -90, -86, -90, -85, -91, -85, -89, -85, -89, -85, -88, -84, -88, -85,
-88, -84, -89, -84, -87, -84, -88, -84, -86, -84, -87, -84, -86, -83, -87, -84,
-85, -84, -86, -84, -85, -84, -86, -84, -85, -84, -87, -84, -85, -84, -86, -84,
-86, -84, -86, -84, -86, -84, -86, -84, -87, -85, -86, -85, -87, -85, -87, -84,
-86, -84, -87, -85, -88, -84, -86, -84, -88, -84, -87, -85, -88, -86, -88, -85,
-89, -85, -89, -86, -89, -85, -90, -86, -90, -85, -90, -86, -90, -85, -90, -86,
-91, -85, -91, -85, -91, -87, -91, -87, -91, -86, -92, -86, -92, -86, -93, -86,
-93, -87, -92, -87, -93, -88, -92, -87, -93, -88, -93, -87, -94, -87, -94, -87,
-94, -88, -95, -88, -95, -88, -95, -88, -95, -88, -95, -88, -96, -88, -95, -88,
-96, -89, -97, -88, -97, -89, -96, -89, -96, -89, -97, -88, -97, -89, -97, -89,
-98, -89, -97, -88, -98, -89, -99, -89, -97, -90, -98, -90, -98, -90, -98, -89,
-98, -89, -98, -89, -98, -90, -99, -90, -98, -89, -99, -89, -98, -90, -100, -93,
-117, -104, -117, -110, -114, -110, -113, -111, -112, -111, -112, -111, -112,
-111, -112, -110, -111, -111, -112, -111, -111, -111, -112, -112, -111, -111,
-111, -111, -111, -111, -111, -110, -112, -111, -111, -111, -110, -111, -111,
-110, -111, -111, -110, -111, -111, -111, -111, -112, -112, -110, -110, -110,
-111, -111, -110, -111, -111, -111, -111, -110, -111, -110, -110, -111, -111,
-111, -111, -110, -110, -111, -110, -111, -111, -110, -112, -110, -109, -110,
-112, -111, -109, -111, -112, -111, -109, -111, -113, -111, -109, -110, -114,
-111, -108, -110, -115, -112, -108, -110, -116, -111, -105, -109, -121, -114,
-88, -97, 29, -40, 8, -14, 4, -6, -4, -4, -7, -4, -7, -4, -9, -3, -6, -3, -9,
-4, -7, -3, -10, -4, -8, -4, -12, -5, -10, -4, -12, -5, -10, -6, -13, -6, -11,
-6, -14, -6, -12, -6, -15, -6, -13, -6, -14, -6, -12, -6, -14, -6, -13, -6, -15,
-6, -14, -6, -14, -6, -13, -6, -14, -6, -14, -6, -13, -6, -15, -5, -12, -6, -15,
-6, -11, -5, -15, -6, -11, -5, -15, -5, -9, -5, -15, -5, -8, -6, -16, -5, -7,
-5, -16, -4, -6, -4, -17, -4, -4, -4, -18, -5, 2, -2, 91, };