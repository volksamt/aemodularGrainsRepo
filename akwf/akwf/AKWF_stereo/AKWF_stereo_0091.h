#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0091

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 68, 14, 82, 15, 76, 14, 81, 13, 79,
14, 82, 14, 81, 15, 85, 15, 83, 15, 87, 17, 86, 17, 88, 19, 88, 20, 89, 21, 89,
23, 89, 24, 90, 25, 91, 28, 90, 28, 90, 30, 91, 31, 91, 32, 92, 33, 93, 34, 93,
35, 93, 36, 93, 38, 94, 39, 95, 40, 94, 40, 94, 42, 94, 43, 95, 42, 95, 44, 95,
45, 95, 44, 96, 46, 95, 46, 96, 46, 96, 47, 96, 48, 95, 48, 97, 49, 96, 48, 97,
49, 96, 49, 96, 50, 96, 59, 96, 57, 95, 50, 96, 50, 97, 50, 97, 51, 96, 51, 96,
52, 97, 51, 96, 52, 97, 51, 97, 51, 96, 51, 96, 50, 96, 50, 96, 49, 96, 49, 97,
48, 97, 48, 97, 48, 97, 47, 97, 47, 96, 47, 96, 46, 97, 46, 96, 45, 96, 45, 97,
44, 95, 44, 97, 43, 96, 44, 97, 43, 96, 42, 96, 42, 97, 42, 96, 41, 96, 41, 95,
40, 96, 38, 96, 39, 96, 40, 95, 40, 96, 40, 96, 40, 96, 39, 95, 40, 96, 38, 96,
40, 96, 39, 95, 39, 96, 38, 95, 39, 96, 39, 96, 39, 96, 39, 95, 39, 96, 39, 95,
39, 96, 40, 96, 40, 96, 41, 97, 39, 96, 35, 92, -61, 13, -64, 7, 9, 62, 15, 65,
17, 63, 8, 50, 5, 41, -3, 29, -4, 22, -9, 14, -11, 10, -14, 4, -15, 1, -16, -3,
-17, -7, -18, -10, -17, -15, -16, -19, -16, -26, -16, -30, -14, -35, -14, -38,
-15, -43, -14, -45, -13, -48, -12, -51, -13, -52, -13, -54, -13, -55, -13, -57,
-13, -60, -13, -62, -13, -63, -12, -67, -13, -69, -13, -71, -14, -73, -13, -74,
-14, -75, -14, -77, -15, -77, -15, -78, -17, -77, -16, -79, -19, -80, -16, -82,
-21, -81, -17, -83, -27, -84, 9, -90, 59, -98, 5, -90, -18, -88, -19, -89, -18,
-89, -13, -91, -13, -91, -11, -93, -12, -94, -12, -94, -14, -94, -14, -95, -17,
-95, -18, -95, -21, -95, -21, -95, -25, -96, -26, -96, -29, -96, -31, -96, -33,
-96, -35, -96, -36, -95, -39, -96, -41, -96, -41, -97, -43, -96, -44, -97, -46,
-97, -46, -96, -48, -96, -50, -97, -50, -96, -50, -96, -52, -97, -52, -96, -52,
-97, -61, -94, -61, -96, -54, -96, -55, -97, -54, -97, -56, -97, -55, -96, -57,
-96, -57, -97, -56, -96, -56, -95, -56, -96, -56, -96, -56, -96, -56, -96, -55,
-95, -55, -96, -54, -96, -53, -96, -52, -96, -52, -96, -51, -96, -52, -95, -51,
-95, -49, -96, -50, -96, -49, -96, -48, -96, -48, -95, -48, -96, -47, -95, -46,
-95, -47, -95, -46, -97, -41, -77, -40, -76, -45, -96, -45, -99, -45, -102, -44,
-100, -44, -99, -43, -98, -43, -96, -43, -96, -42, -95, -42, -94, -42, -95, -42,
-95, -41, -95, -40, -96, -37, -95, -40, -96, -41, -96, -41, -97, -40, -96, -40,
-96, -40, -97, -40, -96, -41, -97, -41, -97, -41, -97, -40, -96, -41, -97, -40,
-97, -41, -96, -42, -96, -42, -96, -41, -96, -42, -96, -43, -96, -43, -96, -43,
-96, -43, -96, -44, -96, -44, -96, -44, -97, -44, -97, -45, -96, -44, -96, -45,
-97, -45, -96, -46, -97, -45, -97, -46, -97, -46, -96, -46, -97, -46, -97, -48,
-97, -47, -97, -47, -97, -47, -97, -46, -97, -47, -97, -48, -96, -47, -97, -47,
-97, -48, -97, -47, -97, -48, -97, -47, -97, -48, -97, -46, -96, -48, -97, -47,
-97, -48, -96, -46, -97, -48, -97, -46, -97, -48, -96, -45, -97, -49, -96, -43,
-97, -70, -92, -123, -85, -83, -91, -53, -95, -53, -95, -53, -95, -59, -95, -60,
-95, -63, -95, -63, -94, -64, -93, -63, -93, -63, -94, -62, -95, -62, -93, -60,
-94, -59, -94, -57, -94, -56, -94, -54, -95, -53, -96, -52, -95, -50, -95, -50,
-95, -48, -96, -47, -95, -46, -95, -46, -96, -44, -96, -43, -96, -42, -96, -42,
-97, -41, -96, -40, -96, -39, -97, -39, -97, -40, -97, -38, -97, -38, -97, -38,
-97, -37, -97, -37, -98, -37, -97, -36, -97, -37, -97, -37, -97, -37, -97, -37,
-97, -36, -97, -37, -97, -13, -100, -12, -101, -33, -97, -34, -98, -36, -97,
-32, -98, -32, -98, -31, -99, -31, -99, -31, -98, -30, -98, -31, -98, -31, -99,
-31, -98, -33, -98, -32, -98, -32, -98, -33, -97, -35, -98, -35, -97, -36, -98,
-36, -97, -40, -113, -42, -119, -38, -99, -38, -93, -37, -91, -38, -93, -38,
-93, -40, -94, -40, -96, -42, -96, -42, -97, -42, -97, -42, -97, -42, -97, -42,
-98, -45, -96, -46, -97, -46, -96, -44, -96, -44, -96, -44, -96, -44, -95, -45,
-95, -45, -95, -44, -95, -45, -95, -45, -96, -46, -96, -45, -96, -45, -96, -45,
-95, -45, -96, -46, -96, -45, -96, -45, -97, -45, -97, -46, -96, -45, -96, -45,
-96, -45, -97, -45, -96, -44, -97, -45, -96, -44, -96, -44, -96, -44, -96, -44,
-97, -44, -96, -44, -96, -43, -96, -44, -97, -44, -96, -44, -97, -45, -96, -44,
-97, -43, -95, -44, -96, -43, -95, -44, -96, -43, -96, -44, -97, -43, -96, -43,
-97, -43, -96, -45, -96, -42, -96, -43, -97, -44, -97, -43, -96, -43, -97, -44,
-97, -44, -96, -43, -96, -44, -97, -43, -96, -43, -97, -43, -95, -44, -97, -42,
-95, -44, -97, -43, -96, -45, -97, -43, -95, -45, -97, -42, -96, -45, -98, -41,
-95, -46, -99, -41, -94, -51, -102, -16, -74, 87, 12, 32, -29, -21, -70, -18,
-65, -18, -60, -7, -46, -6, -38, 2, -27, 4, -20, 9, -12, 11, -8, 14, -3, 14, 1,
16, 5, 16, 8, 18, 12, 16, 16, 17, 22, 15, 27, 15, 31, 16, 37, 15, 42, 14, 44,
14, 48, 14, 49, 13, 52, 14, 53, 14, 55, 15, 56, 14, 59, 14, 59, 14, 64, 14, 63,
15, 70, 15, 68, 14, 75, 15, 71, -3, 83, -11, 68, };