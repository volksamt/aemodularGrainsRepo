#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0190

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, -8, 12, -1, 22, 10, 33, 17, 42, 28,
51, 36, 60, 47, 69, 54, 76, 63, 83, 70, 90, 78, 97, 85, 101, 91, 106, 96, 110,
101, 112, 106, 116, 109, 117, 111, 118, 115, 119, 116, 119, 117, 118, 118, 119,
119, 118, 118, 115, 119, 114, 118, 112, 118, 111, 117, 108, 116, 105, 116, 103,
116, 101, 115, 98, 113, 96, 114, 93, 112, 91, 112, 89, 111, 87, 110, 85, 110,
83, 110, 81, 109, 79, 108, 77, 107, 76, 106, 74, 104, 73, 103, 71, 101, 69, 99,
69, 97, 68, 95, 67, 92, 67, 90, 66, 88, 65, 85, 65, 83, 66, 79, 65, 77, 65, 74,
65, 71, 66, 67, 66, 65, 65, 62, 65, 58, 65, 56, 64, 52, 64, 50, 63, 47, 62, 43,
60, 39, 58, 36, 58, 32, 55, 29, 52, 24, 50, 20, 47, 16, 44, 11, 40, 8, 38, 2,
34, -3, 31, -7, 28, -11, 24, -16, 21, -20, 17, -24, 15, -28, 12, -32, 10, -36,
8, -40, 5, -42, 4, -45, 2, -47, -1, -50, -1, -51, -2, -54, -3, -55, -4, -56, -6,
-57, -6, -57, -7, -57, -9, -57, -9, -58, -10, -58, -11, -58, -13, -58, -14, -59,
-18, -59, -19, -61, -21, -61, -23, -60, -25, -62, -28, -63, -30, -63, -33, -64,
-35, -66, -37, -67, -39, -68, -41, -68, -43, -70, -44, -70, -45, -71, -47, -71,
-48, -72, -49, -71, -50, -71, -50, -71, -50, -70, -50, -69, -50, -69, -50, -67,
-50, -66, -51, -64, -51, -63, -51, -62, -52, -62, -53, -61, -54, -60, -54, -59,
-56, -58, -58, -58, -60, -58, -63, -58, -65, -59, -68, -60, -70, -60, -73, -61,
-76, -62, -78, -63, -81, -65, -83, -65, -85, -66, -87, -66, -89, -67, -90, -66,
-91, -67, -92, -66, -93, -65, -91, -63, -90, -61, -89, -59, -88, -56, -86, -53,
-85, -51, -82, -47, -79, -44, -77, -40, -74, -35, -71, -33, -67, -28, -64, -25,
-61, -21, -57, -18, -54, -16, -51, -13, -49, -10, -47, -9, -44, -7, -42, -6,
-40, -4, -37, -4, -35, -4, -34, -3, -33, -3, -31, -4, -30, -3, -28, -3, -28, -4,
-28, -4, -26, -5, -25, -4, -25, -5, -23, -4, -23, -3, -23, -3, -22, -3, -20, -1,
-20, -1, -19, 1, -18, 2, -18, 3, -17, 5, -16, 7, -16, 8, -14, 10, -14, 11, -13,
13, -12, 14, -11, 16, -10, 18, -9, 18, -8, 19, -6, 21, -5, 22, -3, 23, -3, 24,
-1, 25, 0, 25, 1, 26, 2, 26, 4, 25, 4, 27, 5, 26, 5, 25, 5, 25, 4, 24, 5, 23, 4,
22, 3, 20, 0, 17, -2, 15, -4, 12, -8, 10, -11, 7, -14, 3, -18, -1, -22, -6, -27,
-10, -31, -13, -35, -18, -39, -22, -43, -27, -46, -30, -49, -34, -52, -38, -54,
-39, -55, -43, -55, -45, -55, -46, -55, -45, -52, -46, -49, -44, -47, -43, -43,
-40, -37, -38, -32, -33, -27, -29, -20, -24, -12, -20, -5, -13, 2, -8, 11, -2,
18, 4, 25, 12, 31, 18, 39, 23, 45, 28, 52, 34, 57, 38, 61, 42, 65, 45, 68, 48,
71, 51, 72, 54, 74, 55, 75, 56, 75, 55, 74, 55, 73, 54, 71, 52, 69, 50, 67, 49,
64, 47, 62, 44, 59, 42, 55, 40, 51, 37, 48, 35, 44, 33, 40, 31, 38, 28, 35, 28,
32, 25, 28, 24, 26, 23, 23, 21, 20, 20, 19, 20, 16, 18, 14, 16, 13, 15, 11, 14,
10, 14, 8, 12, 8, 11, 8, 10, 8, 8, 7, 7, 7, 6, 9, 4, 9, 3, 10, 1, 11, 0, 12, -2,
13, -3, 14, -4, 16, -5, 18, -6, 19, -7, 21, -8, 23, -8, 24, -9, 26, -10, 27,
-10, 29, -11, 29, -11, 29, -12, 30, -12, 31, -13, 31, -13, 30, -14, 30, -14, 30,
-16, 29, -16, 28, -17, 27, -19, 26, -19, 25, -21, 24, -22, 24, -22, 23, -23, 23,
-24, 21, -25, 22, -24, 22, -24, 22, -24, 22, -23, 22, -23, 24, -21, 26, -19, 26,
-17, 28, -16, 28, -13, 30, -10, 32, -8, 32, -4, 34, -1, 36, 1, 37, 5, 38, 8, 39,
11, 39, 14, 40, 17, 39, 19, 40, 21, 39, 24, 38, 25, 38, 27, 37, 29, 36, 30, 35,
30, 33, 32, 33, 33, 32, 33, 30, 35, 30, 35, 30, 36, 29, 36, 28, 38, 28, 38, 28,
40, 28, 41, 28, 43, 29, 43, 29, 45, 29, 47, 28, 48, 29, 49, 29, 50, 27, 52, 27,
53, 27, 53, 25, 54, 24, 54, 21, 54, 20, 53, 17, 52, 13, 50, 10, 49, 7, 47, 3,
45, -1, 42, -5, 40, -9, 36, -13, 34, -18, 31, -21, 27, -25, 24, -29, 22, -32,
19, -36, 16, -38, 14, -40, 11, -42, 10, -44, 8, -45, 8, -46, 7, -46, 6, -46, 7,
-45, 7, -45, 6, -45, 7, -44, 7, -42, 8, -41, 8, -41, 9, -39, 9, -38, 8, -37, 9,
-36, 8, -35, 7, -34, 6, -35, 4, -34, 2, -34, 0, -34, -3, -35, -6, -35, -8, -37,
-11, -36, -15, -38, -19, -38, -22, -39, -26, -40, -29, -41, -32, -42, -35, -42,
-38, -44, -41, -45, -44, -46, -46, -47, -48, -47, -50, -48, -51, -49, -52, -49,
-54, -50, -54, -50, -55, -51, -55, -51, -55, -51, -56, -52, -55, -52, -55, -52,
-56, -52, -55, -52, -55, -51, -55, -51, -54, -50, -54, -49, -53, -47, -52, -47,
-51, -45, -52, -44, -51, -42, -50, -41, -49, -40, -49, -38, -48, -38, -49, -36,
-48, -35, -48, -34, -48, -34, -47, -34, -48, -35, -49, -35, -49, -35, -49, -37,
-50, -39, -52, -40, -53, -43, -55, -46, -56, -48, -59, -50, -60, -53, -62, -55,
-64, -58, -66, -60, -68, -62, -69, -65, -71, -66, -72, -66, -72, -65, -72, -65,
-71, -64, -70, -61, -68, -59, -66, -54, -62, -50, -57, -44, -53, -38, -47, -30,
-41, -21, -33, -13, -26, -5, -15, };