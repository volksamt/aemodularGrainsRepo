#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {22, 43, 94, 120, 82, 95, 89, 92, 90,
81, 93, 82, 101, 100, 105, 110, 108, 115, 104, 110, 106, 111, 105, 114, 107,
119, 104, 115, 101, 112, 97, 110, 98, 113, 95, 112, 92, 110, 86, 105, 86, 105,
84, 106, 83, 105, 78, 102, 77, 99, 75, 99, 74, 100, 72, 98, 70, 96, 70, 95, 69,
95, 69, 94, 72, 96, 75, 98, 73, 96, 73, 94, 72, 93, 73, 93, 74, 92, 76, 94, 75,
94, 76, 93, 76, 92, 77, 93, 78, 94, 80, 94, 81, 94, 81, 94, 83, 95, 83, 94, 85,
95, 86, 96, 88, 96, 89, 97, 90, 97, 92, 98, 94, 99, 94, 100, 96, 100, 97, 100,
98, 100, 99, 101, 101, 102, 101, 103, 102, 103, 103, 104, 105, 104, 106, 105,
106, 106, 108, 106, 109, 106, 109, 106, 110, 107, 110, 107, 111, 108, 111, 107,
112, 108, 112, 108, 112, 108, 112, 108, 113, 108, 113, 108, 114, 108, 114, 108,
114, 108, 113, 108, 113, 108, 114, 108, 113, 108, 114, 107, 113, 107, 113, 106,
112, 106, 113, 107, 112, 106, 112, 106, 112, 106, 111, 105, 111, 104, 111, 105,
110, 103, 110, 103, 110, 103, 110, 102, 110, 103, 109, 101, 108, 101, 108, 101,
107, 100, 107, 99, 106, 98, 105, 97, 103, 97, 104, 97, 104, 95, 102, 96, 102,
94, 101, 93, 101, 93, 101, 91, 99, 91, 99, 90, 98, 90, 97, 89, 97, 88, 96, 87,
97, 86, 94, 86, 94, 85, 94, 84, 93, 84, 92, 83, 92, 81, 92, 81, 90, 80, 90, 79,
89, 77, 88, 76, 87, 76, 86, 74, 86, 74, 85, 73, 85, 72, 83, 72, 83, 71, 82, 69,
82, 68, 81, 68, 80, 67, 79, 65, 78, 65, 78, 64, 77, 62, 75, 62, 76, 60, 75, 60,
74, 59, 73, 57, 72, 57, 71, 56, 70, 55, 70, 55, 69, 53, 68, 52, 67, 51, 66, 50,
65, 48, 65, 48, 64, 46, 63, 46, 62, 46, 62, 44, 61, 43, 60, 43, 60, 41, 59, 40,
59, 39, 57, 38, 57, 38, 57, 37, 55, 36, 55, 35, 54, 34, 54, 33, 53, 32, 52, 32,
51, 31, 50, 29, 49, 28, 49, 27, 47, 27, 47, 25, 47, 26, 46, 24, 45, 23, 44, 22,
43, 22, 43, 20, 42, 20, 39, 17, 36, 13, 32, 11, 30, 9, 28, 7, 25, 5, 22, 3, 20,
1, 17, -2, 15, -4, 14, -5, 12, -6, 11, -7, 9, -10, 9, -11, 7, -12, 7, -13, 7,
-13, 7, -14, 7, -14, 7, -15, 7, -15, 7, -15, 7, -15, 8, -15, 9, -15, 8, -15, 8,
-15, 9, -15, 9, -15, 10, -16, 11, -15, 10, -15, 11, -14, 11, -14, 11, -13, 11,
-15, 12, -14, 12, -14, 13, -13, 12, -14, 13, -13, 13, -14, 13, -13, 12, -13, 13,
-13, 12, -13, 13, -13, 13, -13, 12, -13, 11, -12, 11, -13, 13, -11, 9, -14, 14,
-10, 6, -17, 21, -3, -42, -66, -103, -128, -87, -98, -96, -95, -95, -82, -101,
-86, -106, -103, -111, -114, -111, -116, -110, -112, -109, -112, -110, -117,
-110, -119, -106, -116, -102, -111, -99, -109, -98, -113, -95, -111, -91, -108,
-87, -103, -85, -103, -82, -103, -80, -102, -76, -98, -73, -95, -72, -94, -71,
-95, -68, -92, -66, -90, -65, -89, -64, -88, -63, -87, -62, -87, -61, -85, -61,
-84, -62, -83, -61, -84, -62, -83, -62, -82, -62, -82, -64, -83, -65, -83, -66,
-83, -67, -82, -68, -83, -69, -84, -69, -84, -71, -84, -72, -85, -74, -86, -75,
-85, -77, -86, -78, -87, -80, -88, -81, -88, -82, -89, -83, -89, -84, -90, -86,
-90, -87, -91, -88, -91, -89, -92, -90, -93, -91, -93, -92, -94, -93, -94, -94,
-95, -95, -95, -96, -96, -97, -96, -96, -97, -97, -97, -98, -97, -98, -97, -100,
-98, -100, -98, -100, -98, -101, -99, -101, -99, -101, -99, -102, -99, -102,
-99, -102, -99, -103, -100, -102, -99, -102, -99, -103, -99, -103, -99, -103,
-99, -101, -98, -103, -98, -101, -98, -102, -98, -102, -98, -102, -97, -104,
-100, -106, -103, -109, -104, -109, -104, -111, -104, -113, -106, -113, -107,
-116, -107, -117, -108, -118, -110, -118, -109, -119, -110, -120, -110, -120,
-110, -118, -109, -118, -110, -117, -108, -118, -109, -116, -108, -115, -108,
-115, -107, -114, -106, -113, -105, -111, -104, -110, -104, -109, -102, -108,
-101, -106, -100, -107, -98, -106, -97, -104, -97, -103, -95, -102, -95, -102,
-93, -99, -92, -99, -91, -98, -89, -97, -89, -96, -88, -94, -87, -94, -86, -92,
-84, -92, -83, -91, -81, -90, -80, -90, -79, -88, -78, -88, -77, -88, -76, -87,
-75, -86, -73, -84, -73, -85, -72, -85, -70, -83, -70, -83, -69, -82, -67, -81,
-67, -81, -67, -81, -66, -80, -64, -79, -64, -78, -62, -79, -62, -78, -61, -77,
-60, -76, -59, -76, -58, -76, -57, -75, -56, -74, -55, -73, -54, -73, -53, -72,
-53, -72, -52, -71, -52, -70, -50, -71, -50, -69, -48, -70, -48, -69, -47, -68,
-46, -68, -46, -67, -45, -66, -44, -66, -43, -65, -43, -64, -42, -64, -42, -64,
-41, -63, -40, -62, -39, -61, -38, -61, -37, -60, -37, -59, -36, -59, -35, -58,
-33, -58, -33, -57, -32, -57, -32, -56, -32, -56, -31, -55, -31, -55, -29, -54,
-29, -54, -28, -51, -26, -50, -25, -49, -24, -48, -24, -47, -24, -46, -22, -45,
-21, -44, -20, -43, -19, -43, -17, -41, -17, -40, -16, -39, -15, -38, -14, -37,
-13, -37, -12, -35, -11, -34, -11, -34, -10, -34, -9, -32, -9, -32, -8, -31, -8,
-31, -6, -30, -6, -29, -5, -29, -4, -27, -3, -26, -3, -26, -3, -26, -1, -25, -1,
-24, -1, -24, 1, -23, 1, -22, 2, -22, 3, -21, 3, -21, 3, -20, 4, -19, 5, -18, 5,
-18, 6, -17, 6, -18, 6, -16, 8, -16, 8, -16, 8, -15, 10, -15, 8, -13, 11, -15,
8, -11, 14, -17, 2, };