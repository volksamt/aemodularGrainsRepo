#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0182

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 49, 1, 57, 1, 51, 2, 53, 2, 49, 3,
49, 3, 46, 4, 46, 5, 43, 4, 42, 5, 39, 6, 39, 6, 36, 6, 34, 7, 31, 8, 31, 8, 27,
9, 26, 10, 23, 10, 21, 10, 19, 11, 17, 11, 14, 11, 12, 13, 9, 13, 7, 14, 5, 15,
1, 16, -1, 16, -5, 17, -6, 18, -9, 19, -12, 19, -14, 21, -17, 21, -21, 23, -23,
23, -26, 25, -28, 25, -31, 27, -33, 28, -36, 30, -39, 30, -41, 32, -44, 34, -47,
35, -49, 36, -52, 37, -54, 39, -56, 40, -58, 42, -60, 44, -62, 45, -65, 47, -67,
48, -70, 49, -72, 50, -74, 52, -74, 55, -77, 56, -79, 57, -79, 58, -82, 60, -83,
61, -84, 63, -86, 64, -87, 65, -88, 67, -89, 68, -90, 70, -91, 72, -92, 73, -93,
74, -93, 75, -95, 76, -95, 77, -95, 78, -96, 81, -96, 82, -96, 83, -97, 83, -96,
85, -97, 87, -97, 87, -97, 88, -97, 89, -96, 91, -97, 91, -97, 92, -96, 92, -95,
94, -95, 95, -95, 96, -94, 97, -93, 97, -92, 97, -92, 99, -91, 100, -90, 101,
-89, 101, -87, 102, -86, 101, -86, 102, -85, 103, -83, 103, -82, 103, -80, 104,
-78, 104, -78, 105, -76, 104, -75, 104, -73, 104, -71, 104, -70, 104, -68, 103,
-66, 104, -65, 103, -64, 103, -62, 102, -60, 102, -58, 101, -56, 101, -54, 100,
-53, 99, -51, 99, -49, 97, -47, 96, -46, 95, -44, 93, -43, 93, -41, 92, -39, 89,
-39, 89, -36, 87, -35, 85, -34, 83, -32, 82, -30, 79, -28, 78, -28, 76, -26, 74,
-24, 72, -23, 69, -21, 67, -20, 64, -19, 62, -17, 60, -15, 56, -14, 54, -12, 52,
-11, 49, -9, 46, -8, 43, -6, 40, -4, 37, -4, 33, -1, 31, 1, 27, 2, 24, 4, 21, 5,
17, 7, 14, 9, 11, 10, 7, 13, 4, 15, 0, 16, -3, 18, -7, 20, -10, 22, -13, 24,
-17, 26, -20, 27, -23, 30, -27, 31, -31, 33, -34, 35, -38, 38, -41, 39, -43, 41,
-47, 43, -49, 45, -54, 46, -56, 48, -59, 49, -62, 51, -65, 52, -68, 54, -70, 55,
-73, 57, -76, 59, -79, 59, -82, 61, -83, 62, -85, 63, -88, 65, -90, 65, -91, 65,
-93, 67, -96, 68, -97, 68, -99, 69, -101, 69, -102, 70, -104, 70, -104, 70,
-106, 70, -107, 69, -109, 70, -109, 71, -110, 70, -111, 70, -111, 70, -113, 69,
-112, 69, -112, 69, -114, 68, -115, 67, -113, 67, -114, 67, -114, 67, -113, 66,
-113, 66, -113, 65, -112, 65, -111, 63, -110, 64, -110, 63, -109, 62, -108, 61,
-107, 61, -105, 60, -102, 60, -103, 60, -100, 59, -98, 58, -95, 58, -93, 58,
-92, 57, -90, 58, -87, 57, -84, 57, -82, 56, -79, 56, -76, 56, -73, 57, -70, 56,
-66, 56, -63, 57, -60, 57, -56, 58, -53, 57, -49, 57, -45, 58, -42, 58, -37, 59,
-34, 59, -30, 59, -26, 59, -22, 60, -18, 60, -15, 61, -10, 61, -6, 62, -2, 62,
3, 64, 6, 65, 12, 65, 16, 66, 19, 66, 24, 68, 28, 68, 32, 69, 36, 70, 40, 70,
43, 71, 48, 72, 52, 72, 56, 73, 60, 73, 63, 75, 66, 75, 70, 75, 73, 76, 77, 77,
80, 77, 84, 77, 86, 78, 90, 77, 92, 79, 95, 78, 98, 78, 101, 79, 103, 79, 105,
79, 107, 78, 110, 79, 112, 78, 114, 78, 115, 77, 118, 77, 119, 76, 119, 75, 119,
74, 119, 73, 119, 72, 119, 71, 119, 71, 119, 68, 119, 67, 119, 66, 119, 63, 118,
61, 119, 60, 119, 58, 119, 55, 119, 53, 118, 51, 119, 49, 119, 47, 119, 44, 120,
42, 118, 39, 119, 37, 119, 33, 119, 30, 119, 28, 119, 26, 119, 23, 119, 19, 119,
17, 118, 13, 119, 11, 118, 9, 118, 6, 116, 2, 115, 0, 113, -4, 111, -6, 108,
-10, 105, -13, 103, -15, 100, -17, 97, -21, 94, -23, 91, -26, 88, -29, 84, -31,
81, -33, 77, -36, 73, -39, 69, -42, 67, -44, 61, -46, 58, -48, 54, -50, 49, -52,
44, -55, 40, -57, 36, -60, 31, -61, 27, -64, 23, -65, 18, -67, 13, -69, 8, -71,
4, -73, 0, -74, -5, -76, -9, -77, -14, -79, -19, -81, -23, -81, -28, -84, -32,
-85, -36, -87, -40, -87, -44, -89, -48, -91, -52, -92, -56, -93, -60, -94, -63,
-95, -66, -97, -70, -97, -74, -97, -77, -98, -80, -99, -83, -100, -86, -101,
-89, -101, -91, -101, -94, -101, -97, -103, -99, -102, -102, -103, -103, -103,
-106, -102, -107, -102, -109, -102, -112, -101, -113, -101, -115, -100, -116,
-99, -117, -99, -119, -99, -119, -97, -119, -97, -119, -96, -119, -94, -119,
-92, -118, -91, -119, -89, -119, -87, -120, -86, -119, -83, -118, -81, -119,
-79, -119, -78, -120, -75, -119, -72, -119, -69, -119, -66, -119, -64, -119,
-61, -119, -58, -119, -55, -119, -51, -119, -49, -119, -45, -119, -42, -119,
-38, -119, -34, -118, -31, -117, -27, -115, -24, -114, -21, -112, -17, -111,
-13, -109, -10, -108, -6, -105, -3, -104, 1, -101, 4, -100, 8, -98, 11, -95, 15,
-94, 19, -91, 22, -89, 25, -87, 28, -85, 31, -83, 34, -81, 37, -78, 40, -76, 43,
-74, 45, -73, 48, -69, 50, -68, 53, -65, 55, -63, 58, -62, 59, -60, 61, -57, 63,
-56, 66, -54, 67, -51, 68, -50, 70, -48, 71, -46, 73, -44, 74, -42, 75, -40, 76,
-39, 77, -37, 78, -36, 79, -34, 79, -32, 79, -32, 81, -30, 80, -29, 81, -27, 80,
-26, 81, -25, 81, -23, 81, -22, 81, -21, 80, -20, 81, -19, 80, -18, 80, -17, 79,
-16, 79, -14, 78, -14, 77, -13, 76, -11, 76, -10, 75, -10, 74, -9, 72, -8, 73,
-7, 70, -7, 70, -5, 68, -5, 69, -4, 65, -3, 66, -3, 62, -3, 64, -1, 58, -1, 63,
0, 49, };