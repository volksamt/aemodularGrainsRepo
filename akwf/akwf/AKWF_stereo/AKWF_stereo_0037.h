#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0037

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 104, 2, 124, 5, 116, 7, 121, 9,
115, 12, 120, 15, 116, 17, 121, 19, 116, 21, 120, 23, 116, 24, 117, 25, 112, 27,
112, 28, 109, 29, 108, 30, 105, 31, 103, 33, 99, 35, 99, 37, 97, 39, 96, 39, 94,
40, 91, 41, 89, 42, 87, 43, 86, 45, 84, 46, 83, 47, 82, 48, 81, 49, 79, 50, 78,
51, 75, 52, 73, 53, 70, 54, 67, 55, 62, 57, 60, 58, 54, 59, 50, 60, 45, 61, 41,
62, 37, 63, 34, 64, 30, 64, 27, 65, 24, 68, 20, 69, 17, 70, 13, 71, 7, 74, 2,
75, -3, 77, -8, 80, -13, 82, -17, 84, -20, 86, -23, 90, -27, 91, -29, 93, -29,
94, -31, 97, -33, 99, -37, 99, -41, 101, -44, 103, -48, 104, -50, 106, -54, 107,
-57, 109, -61, 109, -65, 111, -67, 113, -70, 114, -73, 115, -76, 117, -78, 118,
-78, 119, -79, 119, -78, 119, -79, 119, -79, 119, -77, 119, -76, 119, -74, 119,
-73, 117, -72, 117, -71, 117, -70, 116, -68, 116, -64, 115, -63, 114, -60, 113,
-56, 113, -54, 112, -51, 111, -49, 110, -46, 109, -45, 107, -44, 106, -42, 104,
-39, 103, -36, 101, -34, 100, -32, 99, -32, 98, -29, 96, -27, 95, -26, 93, -23,
92, -20, 90, -17, 88, -13, 86, -11, 85, -9, 84, -5, 81, -4, 81, 0, 79, 3, 78, 5,
76, 8, 75, 9, 74, 13, 74, 15, 72, 17, 72, 18, 72, 21, 71, 22, 72, 25, 72, 27,
72, 30, 71, 33, 71, 37, 70, 39, 71, 42, 69, 43, 70, 45, 70, 45, 70, 46, 68, 47,
68, 49, 68, 52, 69, 54, 70, 57, 70, 58, 71, 60, 71, 63, 72, 65, 73, 69, 73, 72,
75, 75, 74, 79, 77, 83, 77, 87, 78, 89, 78, 92, 79, 93, 81, 94, 82, 95, 83, 95,
84, 95, 86, 96, 88, 97, 89, 98, 91, 98, 93, 99, 93, 97, 94, 95, 95, 93, 97, 92,
97, 92, 98, 89, 99, 88, 99, 88, 99, 85, 100, 84, 101, 82, 100, 79, 101, 75, 101,
74, 101, 71, 101, 68, 100, 66, 101, 64, 102, 63, 102, 61, 101, 60, 100, 58, 100,
55, 99, 52, 97, 50, 96, 47, 94, 43, 93, 38, 90, 33, 89, 29, 88, 23, 86, 20, 84,
16, 81, 13, 80, 10, 77, 6, 75, 3, 73, -1, 70, -5, 66, -8, 63, -10, 60, -13, 57,
-14, 53, -16, 50, -18, 48, -20, 45, -23, 41, -25, 38, -28, 35, -32, 33, -34, 30,
-37, 26, -39, 24, -41, 22, -42, 19, -44, 16, -45, 14, -46, 11, -48, 5, -51, 3,
-52, -2, -54, -3, -54, -6, -55, -8, -58, -10, -60, -11, -63, -13, -66, -15, -69,
-17, -71, -19, -75, -21, -76, -22, -78, -23, -79, -25, -80, -27, -81, -28, -81,
-30, -84, -31, -85, -32, -86, -33, -89, -34, -89, -35, -89, -36, -92, -37, -94,
-38, -96, -39, -96, -40, -96, -40, -96, -42, -96, -42, -95, -43, -94, -44, -92,
-46, -91, -48, -90, -49, -90, -50, -89, -53, -88, -54, -88, -55, -88, -57, -88,
-59, -88, -59, -88, -61, -88, -63, -87, -64, -85, -65, -84, -67, -85, -68, -83,
-70, -84, -72, -81, -73, -79, -75, -76, -78, -74, -80, -70, -81, -66, -82, -63,
-84, -59, -87, -55, -89, -52, -90, -49, -91, -44, -93, -40, -94, -38, -95, -36,
-96, -33, -96, -31, -98, -30, -99, -28, -100, -27, -100, -25, -101, -23, -100,
-21, -101, -20, -101, -19, -101, -19, -102, -19, -102, -19, -102, -18, -103,
-18, -102, -18, -102, -16, -101, -15, -101, -13, -100, -11, -99, -9, -98, -7,
-98, -5, -97, -2, -95, 0, -94, 2, -92, 4, -91, 5, -90, 6, -89, 9, -87, 10, -85,
10, -84, 10, -83, 11, -82, 10, -82, 8, -80, 6, -80, 5, -79, 4, -79, 2, -79, 2,
-78, 1, -78, 1, -77, 1, -78, 0, -77, 0, -77, 0, -77, 1, -77, 1, -77, 1, -76, 1,
-77, 0, -78, 1, -77, 3, -78, 6, -78, 7, -78, 7, -78, 7, -78, 6, -79, 6, -79, 6,
-79, 5, -80, 4, -81, 3, -81, 2, -83, -1, -84, -4, -85, -6, -86, -9, -87, -13,
-89, -16, -90, -18, -90, -20, -92, -25, -93, -28, -92, -30, -95, -31, -95, -34,
-95, -35, -95, -36, -96, -38, -96, -40, -98, -41, -98, -42, -98, -44, -98, -46,
-98, -48, -99, -49, -99, -51, -97, -52, -97, -55, -97, -56, -97, -57, -97, -58,
-96, -60, -96, -61, -95, -63, -93, -65, -92, -67, -91, -69, -91, -71, -89, -72,
-88, -73, -86, -75, -85, -77, -83, -77, -81, -77, -81, -77, -79, -76, -78, -75,
-75, -73, -75, -70, -73, -66, -71, -65, -69, -63, -67, -62, -67, -62, -64, -62,
-62, -60, -60, -60, -59, -59, -57, -59, -55, -58, -54, -57, -52, -56, -51, -54,
-49, -54, -47, -51, -45, -50, -43, -49, -41, -45, -40, -42, -39, -39, -38, -36,
-36, -34, -35, -32, -33, -31, -33, -30, -32, -29, -33, -27, -31, -26, -32, -25,
-30, -24, -30, -24, -30, -21, -28, -20, -28, -17, -28, -16, -28, -14, -28, -11,
-28, -9, -28, -8, -27, -6, -27, -3, -26, -2, -27, -1, -26, 0, -26, 1, -26, 3,
-26, 4, -26, 6, -27, 8, -27, 9, -28, 11, -28, 12, -29, 13, -30, 15, -30, 16,
-32, 18, -32, 18, -32, 19, -33, 21, -34, 22, -35, 22, -36, 23, -37, 24, -38, 25,
-39, 28, -39, 30, -40, 32, -40, 36, -41, 40, -42, 43, -41, 46, -42, 49, -42, 53,
-42, 57, -42, 60, -42, 62, -42, 66, -42, 67, -41, 72, -42, 74, -42, 78, -41, 80,
-41, 83, -42, 84, -42, 87, -41, 90, -41, 92, -40, 93, -39, 95, -38, 96, -35, 96,
-34, 97, -32, 96, -30, 100, -28, 98, -26, 101, -25, 99, -24, 104, -21, 103, -19,
108, -16, 105, -15, 111, -13, 107, -10, 116, -7, 109, -4, 124, -2, 100, };