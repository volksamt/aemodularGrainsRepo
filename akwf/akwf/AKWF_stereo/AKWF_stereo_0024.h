#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 57, 1, 69, 3, 64, 6, 66, 9, 60, 11,
60, 15, 56, 18, 57, 22, 55, 25, 59, 27, 59, 30, 58, 34, 52, 40, 49, 47, 44, 51,
42, 54, 37, 55, 33, 55, 28, 57, 24, 57, 22, 58, 22, 60, 24, 60, 21, 61, 16, 61,
7, 59, -1, 59, -9, 58, -15, 58, -19, 58, -21, 57, -20, 55, -15, 54, -7, 55, -4,
59, -8, 62, -14, 66, -22, 70, -27, 75, -30, 77, -32, 78, -36, 77, -41, 78, -47,
78, -54, 80, -59, 82, -62, 87, -64, 92, -66, 95, -65, 99, -61, 100, -58, 104,
-55, 105, -52, 106, -46, 106, -39, 107, -35, 109, -32, 110, -32, 111, -29, 111,
-27, 109, -23, 108, -20, 104, -19, 101, -18, 98, -18, 96, -17, 97, -14, 98, -10,
101, -7, 102, -3, 104, 2, 105, 5, 105, 5, 103, 4, 102, 1, 98, -5, 93, -12, 86,
-19, 83, -25, 82, -28, 85, -30, 87, -31, 89, -30, 87, -27, 84, -23, 81, -19, 78,
-13, 76, -4, 73, 5, 72, 16, 71, 26, 70, 34, 69, 39, 70, 42, 68, 43, 66, 41, 67,
38, 67, 36, 68, 34, 71, 36, 71, 37, 70, 40, 67, 43, 69, 45, 69, 47, 69, 46, 71,
45, 74, 42, 76, 40, 80, 41, 83, 41, 84, 41, 88, 39, 94, 39, 98, 39, 101, 37,
100, 33, 97, 27, 94, 22, 92, 18, 91, 15, 93, 13, 92, 11, 92, 12, 89, 12, 85, 15,
82, 19, 76, 23, 71, 25, 68, 27, 66, 27, 68, 27, 70, 24, 71, 23, 74, 21, 75, 21,
77, 24, 82, 29, 85, 31, 87, 31, 87, 31, 86, 30, 85, 32, 83, 34, 79, 35, 78, 36,
76, 34, 76, 34, 76, 31, 76, 26, 77, 22, 76, 15, 71, 7, 67, -1, 60, -6, 57, -10,
52, -12, 55, -14, 99, -14, 116, -10, 111, -6, 111, -4, 108, -3, 110, -1, 110, 0,
111, 2, 109, 3, 108, 2, 106, 3, 107, 5, 109, 8, 111, 8, 113, 6, 116, 2, 118, 0,
120, 0, 118, -1, 116, 0, 114, 0, 113, -1, 111, -4, 109, -7, 108, -9, 106, -6,
107, -2, 106, -1, 105, -4, 100, -7, 92, -7, 85, -9, 79, -12, 75, -20, 72, -29,
72, -34, 72, -36, 73, -38, 74, -42, 73, -44, 69, -48, 64, -51, 56, -50, 52, -46,
47, -45, 45, -45, 39, -47, 37, -47, 34, -47, 32, -46, 31, -46, 30, -45, 31, -47,
30, -51, 29, -56, 31, -60, 32, -63, 33, -65, 33, -66, 31, -64, 33, -64, 33, -62,
31, -61, 28, -62, 24, -60, 21, -60, 20, -59, 20, -59, 21, -61, 22, -63, 23, -63,
24, -62, 24, -66, 22, -74, 21, -79, 17, -86, 13, -91, 11, -95, 8, -102, 7, -107,
4, -111, 1, -114, -5, -116, -13, -118, -18, -119, -25, -118, -28, -117, -32,
-117, -34, -118, -36, -118, -40, -117, -42, -114, -41, -110, -38, -108, -35,
-105, -33, -101, -31, -97, -29, -93, -26, -93, -26, -82, -28, -47, -31, -35,
-35, -30, -36, -22, -38, -18, -39, -10, -41, -7, -43, -4, -46, -3, -48, -3, -49,
-6, -49, -8, -52, -11, -52, -12, -54, -14, -55, -13, -56, -10, -56, -6, -57, -5,
-58, -8, -57, -16, -56, -24, -56, -29, -55, -30, -54, -27, -56, -25, -56, -26,
-58, -30, -58, -29, -59, -26, -58, -19, -56, -12, -54, -4, -53, 3, -54, 8, -56,
12, -59, 16, -60, 19, -62, 19, -63, 16, -66, 16, -71, 20, -75, 24, -78, 27, -81,
30, -86, 33, -89, 39, -90, 46, -88, 49, -88, 50, -87, 51, -88, 54, -89, 56, -91,
57, -93, 56, -97, 55, -102, 53, -107, 49, -112, 43, -113, 36, -112, 30, -109,
24, -109, 21, -108, 17, -109, 14, -106, 15, -102, 16, -96, 17, -89, 18, -86, 19,
-86, 20, -87, 20, -87, 19, -85, 15, -84, 12, -81, 7, -78, -3, -78, -12, -79,
-19, -80, -27, -80, -32, -80, -34, -79, -30, -79, -26, -79, -24, -81, -24, -84,
-28, -85, -32, -87, -33, -87, -34, -85, -36, -83, -36, -83, -33, -86, -29, -86,
-28, -87, -29, -88, -30, -89, -34, -92, -39, -94, -45, -95, -50, -94, -47, -95,
-41, -96, -34, -95, -29, -95, -27, -94, -28, -91, -31, -86, -35, -84, -37, -84,
-40, -86, -42, -86, -42, -86, -41, -83, -41, -78, -40, -73, -39, -67, -41, -63,
-43, -64, -46, -66, -46, -69, -46, -71, -43, -71, -35, -71, -28, -71, -21, -71,
-20, -71, -17, -70, -14, -69, -11, -68, -9, -68, -8, -67, -11, -67, -14, -66,
-16, -66, -14, -66, -11, -70, -11, -74, -9, -77, -7, -76, -7, -77, -6, -76, -5,
-77, -6, -79, -7, -79, -6, -79, -7, -79, -8, -78, -8, -77, -8, -76, -9, -75, -9,
-72, -13, -71, -18, -69, -20, -69, -21, -66, -18, -63, -13, -62, -9, -57, -4,
-52, 0, -45, 3, -43, 7, -37, 7, -66, 5, -99, -1, -92, -8, -88, -12, -84, -14,
-81, -11, -79, -7, -79, -4, -77, -3, -78, -2, -80, 0, -80, 1, -82, 0, -84, -2,
-87, -2, -92, 1, -95, 7, -97, 13, -99, 19, -102, 20, -104, 23, -106, 25, -108,
27, -106, 30, -104, 34, -100, 35, -98, 29, -98, 24, -98, 23, -95, 23, -92, 19,
-86, 17, -83, 21, -78, 27, -76, 37, -76, 45, -75, 52, -72, 59, -72, 65, -74, 70,
-73, 73, -71, 74, -65, 70, -59, 62, -54, 56, -48, 53, -38, 55, -29, 56, -21, 56,
-15, 54, -13, 51, -12, 49, -11, 48, -10, 49, -10, 48, -9, 47, -9, 48, -6, 51,
-5, 57, -5, 63, -5, 70, -7, 77, -8, 86, -9, 96, -8, 101, -4, 104, 2, 108, 8,
108, 12, 106, 15, 104, 16, 101, 17, 100, 19, 100, 20, 105, 22, 108, 24, 112, 24,
112, 22, 114, 18, 113, 14, 112, 9, 108, 4, 108, 1, 104, 1, 79, 2, 58, 2, 66, 0,
60, -2, 68, -1, 54, };