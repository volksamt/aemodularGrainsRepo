#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0064

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 57, 14, 72, 24, 71, 34, 77, 42, 77,
49, 81, 54, 79, 60, 83, 65, 82, 68, 84, 71, 83, 74, 83, 76, 83, 79, 84, 80, 84,
81, 85, 83, 84, 84, 85, 85, 85, 87, 86, 88, 86, 90, 86, 91, 88, 93, 88, 95, 90,
97, 89, 98, 92, 100, 91, 102, 92, 103, 93, 104, 96, 106, 96, 108, 96, 109, 98,
110, 98, 111, 98, 112, 98, 113, 99, 113, 99, 114, 100, 114, 100, 114, 100, 115,
100, 115, 101, 114, 102, 115, 102, 114, 101, 114, 102, 113, 102, 113, 102, 112,
103, 112, 103, 112, 104, 111, 103, 111, 104, 111, 105, 110, 105, 110, 106, 109,
106, 110, 106, 109, 107, 110, 107, 109, 108, 109, 108, 109, 109, 108, 108, 108,
109, 108, 110, 107, 110, 106, 109, 104, 109, 104, 108, 103, 108, 101, 107, 99,
106, 97, 105, 96, 104, 92, 103, 90, 103, 87, 101, 84, 101, 82, 100, 79, 99, 77,
98, 75, 97, 72, 97, 70, 97, 68, 97, 66, 96, 64, 96, 62, 96, 62, 95, 60, 96, 60,
95, 58, 96, 58, 95, 55, 93, 55, 92, 52, 92, 51, 89, 48, 89, 45, 85, 42, 83, 38,
79, 34, 76, 30, 71, 24, 66, 20, 60, 14, 51, 11, 39, 23, -10, 22, -30, 15, -33,
10, -41, 4, -42, 0, -45, -5, -45, -7, -47, -10, -47, -12, -48, -13, -45, -13,
-45, -14, -44, -12, -43, -12, -41, -11, -40, -10, -38, -7, -36, -6, -34, -5,
-34, -3, -33, -2, -33, -2, -35, -1, -35, -1, -37, -2, -39, -3, -41, -4, -44, -6,
-47, -9, -49, -12, -51, -15, -54, -18, -56, -21, -58, -23, -59, -26, -61, -28,
-62, -30, -64, -31, -63, -33, -64, -34, -64, -35, -63, -34, -62, -33, -61, -32,
-60, -31, -59, -28, -57, -26, -54, -24, -54, -21, -51, -18, -49, -15, -47, -12,
-45, -10, -44, -7, -42, -5, -42, -4, -41, -2, -41, -1, -42, -1, -43, -1, -45,
-1, -46, -2, -48, -3, -49, -4, -52, -5, -54, -7, -55, -8, -56, -9, -57, -10,
-58, -11, -58, -11, -58, -12, -58, -12, -57, -12, -56, -11, -54, -10, -53, -9,
-52, -7, -50, -6, -47, -3, -46, -3, -44, -1, -42, 0, -40, 1, -40, 3, -39, 4,
-40, 4, -41, 3, -44, 4, -46, 3, -48, 1, -52, 1, -54, -1, -57, -3, -60, -5, -61,
-8, -64, -10, -65, -11, -66, -15, -67, -16, -68, -17, -67, -17, -67, -18, -66,
-18, -66, -18, -64, -17, -62, -16, -61, -14, -59, -12, -56, -10, -53, -8, -51,
-6, -48, -4, -45, -2, -43, -1, -41, 1, -40, 2, -40, 4, -40, 4, -42, 4, -44, 4,
-47, 2, -50, 2, -53, 0, -55, -3, -58, -5, -60, -7, -62, -9, -64, -12, -66, -14,
-66, -16, -66, -17, -65, -17, -65, -18, -64, -18, -63, -16, -60, -14, -57, -12,
-52, -9, -49, -8, -41, -4, -36, -8, -13, -17, 26, -15, 38, -11, 47, -7, 50, -3,
54, 2, 57, 7, 58, 10, 59, 12, 60, 14, 61, 15, 59, 15, 59, 16, 58, 15, 56, 14,
54, 12, 52, 11, 49, 9, 46, 8, 44, 5, 41, 3, 38, 1, 36, -2, 33, -3, 32, -4, 32,
-5, 32, -5, 33, -6, 36, -5, 38, -5, 41, -4, 43, -3, 47, 0, 49, 1, 52, 4, 54, 5,
56, 9, 58, 10, 59, 12, 59, 14, 59, 15, 60, 15, 60, 15, 58, 16, 58, 15, 56, 15,
55, 13, 53, 12, 50, 9, 48, 8, 46, 5, 44, 4, 41, 2, 40, 0, 36, -2, 35, -2, 35,
-4, 34, -5, 34, -5, 35, -5, 38, -6, 40, -5, 42, -3, 45, -1, 48, 0, 50, 2, 53, 4,
55, 5, 56, 7, 56, 8, 58, 9, 59, 10, 59, 12, 58, 11, 58, 12, 58, 12, 56, 11, 56,
10, 54, 9, 53, 8, 52, 7, 51, 5, 50, 4, 49, 3, 48, 3, 48, 2, 49, 3, 50, 2, 52, 3,
55, 5, 56, 6, 59, 8, 62, 10, 64, 12, 67, 17, 69, 19, 71, 23, 73, 26, 74, 29, 76,
31, 77, 33, 78, 35, 78, 36, 77, 38, 77, 38, 76, 38, 75, 38, 75, 36, 72, 35, 71,
34, 70, 32, 67, 29, 65, 26, 64, 23, 60, 20, 59, 18, 56, 15, 55, 12, 54, 11, 53,
9, 52, 7, 52, 7, 52, 7, 54, 7, 55, 7, 56, 9, 58, 10, 60, 11, 61, 13, 62, 14, 65,
17, 64, 17, 67, 19, 65, 19, 66, 19, 64, 20, 64, 19, 60, 16, 59, 15, 53, 12, 51,
10, 43, 6, 38, 7, 15, 21, -34, 16, -44, 10, -54, 4, -58, -4, -63, -10, -67, -15,
-70, -21, -72, -27, -74, -31, -77, -35, -77, -39, -79, -42, -79, -44, -80, -47,
-80, -48, -80, -50, -80, -52, -81, -53, -80, -54, -81, -55, -81, -56, -83, -57,
-84, -59, -84, -60, -85, -63, -87, -65, -87, -66, -89, -69, -91, -73, -92, -75,
-94, -78, -95, -81, -96, -83, -98, -86, -98, -89, -100, -91, -101, -93, -102,
-96, -102, -97, -103, -100, -103, -100, -104, -102, -105, -104, -105, -105,
-105, -106, -106, -107, -106, -107, -106, -108, -106, -108, -106, -108, -107,
-108, -107, -109, -107, -109, -109, -110, -109, -110, -108, -111, -109, -112,
-110, -112, -111, -113, -111, -114, -111, -114, -112, -115, -113, -116, -113,
-116, -114, -117, -114, -117, -115, -118, -115, -119, -115, -119, -116, -118,
-116, -118, -116, -119, -115, -118, -117, -119, -116, -118, -116, -118, -115,
-118, -115, -115, -114, -114, -114, -115, -115, -113, -113, -112, -114, -110,
-112, -108, -112, -107, -111, -106, -112, -105, -110, -103, -110, -101, -109,
-99, -110, -99, -108, -97, -109, -95, -109, -94, -108, -93, -107, -91, -107,
-90, -106, -89, -106, -86, -104, -84, -103, -82, -103, -80, -99, -76, -98, -73,
-94, -68, -93, -63, -86, -58, -85, -52, -76, -43, -74, -36, -60, -26, -56, -27,
-16, -32, 33, -23, 54, -9, 50, };