#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0191

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -12, 4, -10, 10, -5, 14, -2, 19, 4,
24, 8, 29, 13, 34, 16, 39, 23, 43, 26, 48, 31, 52, 35, 56, 40, 62, 44, 66, 49,
70, 54, 74, 58, 78, 62, 82, 67, 85, 70, 88, 74, 93, 78, 95, 82, 98, 86, 100, 89,
103, 92, 106, 95, 108, 97, 110, 100, 112, 104, 113, 105, 114, 107, 116, 110,
116, 112, 117, 112, 118, 113, 119, 114, 119, 115, 119, 116, 119, 117, 119, 117,
118, 117, 117, 117, 116, 117, 116, 116, 115, 115, 113, 114, 112, 112, 109, 111,
109, 109, 107, 108, 105, 105, 102, 103, 100, 101, 98, 97, 96, 95, 93, 92, 90,
88, 87, 85, 85, 82, 82, 78, 80, 75, 77, 71, 74, 67, 70, 63, 68, 59, 65, 55, 62,
51, 58, 47, 56, 43, 54, 38, 51, 34, 47, 30, 45, 25, 43, 21, 41, 16, 38, 13, 36,
9, 34, 5, 32, 2, 29, -2, 27, -6, 26, -10, 23, -14, 22, -17, 20, -20, 19, -22,
17, -25, 16, -28, 14, -31, 12, -34, 11, -36, 10, -38, 9, -41, 7, -42, 7, -44, 5,
-46, 3, -48, 3, -50, 1, -50, 1, -52, -1, -55, -2, -55, -3, -56, -5, -57, -6,
-57, -7, -58, -8, -59, -10, -60, -11, -61, -13, -61, -15, -62, -17, -61, -17,
-62, -20, -62, -22, -62, -23, -63, -26, -62, -28, -63, -31, -63, -33, -63, -35,
-63, -37, -63, -38, -63, -41, -63, -44, -63, -47, -63, -49, -62, -51, -63, -54,
-63, -56, -63, -58, -63, -61, -63, -63, -63, -65, -63, -68, -62, -70, -63, -72,
-62, -75, -62, -77, -62, -79, -62, -80, -63, -82, -62, -85, -62, -86, -61, -87,
-61, -88, -61, -90, -61, -90, -60, -92, -59, -93, -59, -94, -59, -94, -57, -93,
-57, -94, -56, -94, -56, -94, -54, -94, -54, -94, -52, -93, -52, -92, -50, -92,
-49, -91, -47, -90, -47, -88, -45, -87, -44, -85, -42, -83, -40, -81, -39, -79,
-37, -78, -35, -76, -34, -74, -31, -71, -30, -68, -27, -67, -26, -64, -24, -62,
-21, -59, -19, -56, -18, -53, -15, -51, -13, -48, -11, -45, -9, -42, -8, -39,
-5, -38, -3, -35, -2, -32, 0, -30, 3, -27, 4, -25, 7, -24, 7, -21, 9, -20, 11,
-18, 13, -16, 13, -14, 14, -13, 16, -13, 17, -11, 18, -9, 19, -10, 19, -9, 20,
-8, 20, -7, 21, -7, 20, -8, 20, -7, 21, -7, 21, -8, 20, -8, 20, -8, 20, -9, 19,
-10, 18, -10, 17, -12, 16, -12, 16, -12, 14, -14, 14, -15, 12, -16, 12, -17, 10,
-18, 9, -20, 7, -19, 6, -21, 5, -23, 5, -23, 2, -24, 1, -25, 1, -26, -2, -26,
-3, -27, -4, -28, -5, -28, -6, -28, -7, -28, -9, -29, -9, -27, -11, -28, -10,
-28, -11, -28, -11, -27, -13, -25, -12, -25, -13, -24, -13, -22, -13, -22, -13,
-21, -13, -18, -13, -17, -12, -15, -12, -13, -10, -11, -11, -8, -10, -6, -8, -4,
-8, -3, -7, 0, -5, 3, -4, 5, -3, 8, -1, 11, 0, 13, 2, 15, 4, 17, 5, 20, 7, 23,
8, 25, 11, 28, 12, 30, 14, 32, 16, 35, 18, 37, 19, 39, 21, 41, 22, 42, 24, 44,
25, 45, 27, 48, 28, 48, 29, 51, 30, 51, 31, 52, 32, 53, 32, 53, 34, 53, 34, 54,
35, 54, 36, 54, 35, 54, 35, 53, 35, 54, 35, 53, 35, 53, 35, 51, 35, 51, 33, 50,
33, 49, 31, 47, 29, 47, 29, 45, 28, 43, 27, 42, 25, 40, 23, 39, 21, 38, 19, 35,
18, 34, 16, 32, 14, 31, 11, 30, 9, 27, 8, 26, 5, 24, 3, 23, 1, 21, 0, 20, -3,
18, -5, 18, -7, 16, -9, 15, -11, 14, -12, 13, -15, 13, -17, 12, -18, 12, -20,
12, -22, 10, -22, 10, -24, 11, -24, 11, -26, 12, -26, 13, -27, 13, -27, 14, -28,
14, -28, 15, -28, 16, -29, 16, -28, 18, -28, 20, -28, 21, -27, 22, -25, 24, -25,
26, -23, 27, -22, 29, -21, 30, -20, 33, -18, 34, -17, 36, -15, 37, -13, 39, -11,
40, -10, 41, -7, 43, -5, 45, -3, 46, 0, 46, 1, 47, 4, 49, 6, 49, 9, 50, 12, 51,
13, 51, 16, 52, 18, 52, 20, 52, 22, 52, 25, 53, 26, 52, 29, 51, 31, 51, 33, 50,
34, 48, 36, 48, 38, 47, 39, 44, 39, 43, 41, 42, 43, 40, 44, 38, 44, 37, 45, 34,
46, 32, 47, 29, 47, 28, 48, 25, 48, 23, 47, 20, 48, 18, 47, 15, 47, 12, 46, 9,
47, 6, 46, 4, 44, 1, 44, -2, 44, -5, 43, -6, 41, -10, 40, -11, 40, -13, 38, -17,
37, -19, 35, -21, 34, -23, 33, -26, 31, -27, 30, -29, 28, -31, 27, -33, 25, -34,
23, -35, 23, -37, 20, -39, 19, -39, 18, -41, 16, -41, 14, -42, 12, -43, 11, -43,
9, -43, 8, -44, 7, -44, 5, -45, 3, -45, 3, -44, 1, -45, -1, -44, -2, -45, -3,
-45, -5, -44, -6, -44, -7, -44, -9, -43, -10, -44, -11, -43, -12, -43, -13, -43,
-15, -42, -17, -42, -17, -42, -18, -43, -19, -42, -21, -41, -23, -42, -23, -42,
-25, -42, -25, -43, -27, -43, -28, -44, -30, -43, -31, -44, -32, -44, -34, -45,
-34, -47, -37, -47, -38, -48, -40, -48, -41, -49, -43, -50, -44, -51, -44, -52,
-46, -54, -49, -55, -50, -55, -51, -56, -52, -58, -55, -59, -55, -60, -57, -61,
-58, -62, -58, -63, -60, -64, -62, -64, -62, -66, -63, -65, -65, -66, -65, -66,
-66, -67, -65, -67, -67, -67, -67, -67, -68, -66, -67, -66, -66, -66, -67, -65,
-67, -64, -66, -63, -65, -62, -65, -61, -65, -59, -63, -57, -62, -55, -60, -53,
-58, -50, -57, -47, -54, -45, -52, -43, -50, -39, -47, -36, -44, -32, -42, -28,
-38, -24, -36, -20, -33, -17, -30, -12, -24, -8, -22, -3, -15, };