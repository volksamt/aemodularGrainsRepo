#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 10, 7, 12, 12, 7, 13, 3, 14, -1,
15, -1, 13, 3, 13, 6, 13, 4, 14, 5, 16, 9, 18, 14, 17, 16, 15, 19, 14, 21, 12,
26, 12, 30, 12, 28, 15, 29, 18, 29, 20, 27, 22, 30, 20, 31, 17, 32, 17, 35, 16,
42, 17, 53, 19, 63, 25, 67, 31, 67, 34, 67, 35, 66, 35, 63, 34, 58, 34, 57, 33,
55, 32, 56, 34, 57, 36, 59, 36, 64, 37, 70, 38, 76, 40, 79, 43, 81, 46, 78, 47,
73, 48, 64, 49, 58, 54, 53, 60, 46, 66, 42, 71, 39, 76, 36, 83, 30, 88, 20, 92,
8, 94, 0, 95, -5, 95, -13, 97, -21, 100, -26, 103, -27, 106, -30, 107, -29, 109,
-28, 109, -28, 109, -31, 108, -36, 107, -42, 106, -50, 106, -59, 106, -61, 104,
-60, 102, -50, 100, -33, 100, -21, 98, -15, 97, -14, 94, -14, 94, -11, 95, -6,
94, -4, 93, -3, 92, -5, 90, -9, 90, -17, 91, -25, 93, -31, 95, -39, 98, -45, 99,
-47, 98, -46, 99, -42, 100, -38, 103, -34, 106, -30, 109, -20, 110, -14, 114,
-12, 115, -16, 114, -20, 113, -17, 110, -13, 111, -13, 110, -15, 109, -18, 109,
-23, 108, -25, 109, -23, 110, -18, 111, -12, 113, -4, 113, 7, 112, 15, 110, 21,
107, 23, 105, 26, 103, 25, 99, 22, 93, 18, 88, 15, 84, 11, 84, 4, 87, -5, 88,
-7, 90, -5, 90, -3, 89, 3, 86, 14, 86, 29, 85, 48, 85, 64, 84, 78, 82, 91, 80,
97, 79, 101, 78, 99, 77, 98, 79, 99, 80, 103, 83, 105, 83, 105, 85, 104, 88,
102, 92, 100, 94, 97, 95, 95, 98, 92, 99, 91, 101, 91, 101, 95, 103, 102, 103,
111, 104, 114, 105, 112, 106, 108, 108, 104, 107, 100, 106, 96, 105, 93, 103,
91, 103, 91, 102, 88, 103, 87, 104, 86, 104, 87, 104, 92, 101, 96, 98, 102, 91,
107, 84, 111, 78, 117, 74, 119, 75, 118, 74, 114, 73, 108, 72, 103, 72, 98, 71,
95, 71, 98, 71, 99, 71, 95, 73, 91, 72, 91, 71, 93, 71, 100, 69, 104, 66, 107,
66, 106, 65, 103, 65, 103, 65, 98, 65, 95, 62, 90, 59, 83, 56, 73, 55, 66, 53,
61, 52, 57, 52, 55, 52, 55, 52, 58, 53, 60, 52, 62, 49, 64, 47, 69, 47, 74, 46,
80, 47, 81, 46, 80, 45, 76, 44, 75, 43, 73, 43, 70, 42, 65, 41, 62, 41, 64, 41,
72, 41, 78, 38, 83, 37, 88, 36, 92, 35, 90, 34, 88, 35, 82, 36, 77, 37, 74, 37,
69, 36, 63, 34, 57, 33, 55, 32, 54, 34, 54, 37, 49, 39, 45, 40, 41, 42, 41, 41,
41, 38, 39, 34, 37, 29, 35, 25, 31, 20, 24, 18, 20, 16, 20, 15, 20, 15, 21, 18,
26, 22, 30, 27, 31, 31, 24, 34, 18, 37, 13, 37, 7, 36, -1, 37, -10, 37, -15, 38,
-15, 39, -13, 36, -11, 30, -5, 25, 1, 20, 5, 12, 8, 5, 10, 0, 10, -3, 10, -4,
11, -4, 9, -4, 6, -4, 5, -4, 10, -6, 11, -8, 10, -12, 7, -16, 1, -22, -7, -27,
-18, -32, -30, -35, -44, -35, -54, -41, -64, -47, -70, -54, -76, -59, -78, -64,
-75, -67, -71, -70, -67, -72, -64, -74, -61, -76, -57, -81, -56, -82, -57, -82,
-58, -81, -62, -80, -65, -79, -65, -76, -67, -72, -68, -67, -68, -64, -69, -63,
-72, -60, -72, -58, -70, -57, -67, -59, -62, -60, -60, -62, -59, -64, -60, -64,
-63, -66, -66, -66, -70, -67, -75, -69, -83, -68, -88, -71, -94, -74, -96, -75,
-96, -76, -96, -78, -97, -79, -101, -80, -105, -80, -104, -79, -102, -78, -100,
-78, -97, -77, -93, -78, -96, -79, -98, -79, -95, -80, -85, -79, -76, -77, -68,
-77, -63, -77, -60, -78, -60, -79, -59, -81, -55, -81, -52, -82, -52, -83, -49,
-85, -42, -87, -31, -91, -18, -95, -8, -98, -1, -101, 2, -101, 8, -100, 16,
-103, 19, -104, 23, -106, 27, -107, 26, -108, 25, -110, 22, -114, 21, -117, 19,
-118, 19, -119, 15, -117, 11, -116, 7, -113, 1, -113, -3, -114, -8, -115, -15,
-116, -22, -119, -25, -119, -30, -117, -35, -114, -40, -112, -46, -111, -50,
-111, -52, -112, -56, -109, -59, -108, -60, -107, -60, -108, -60, -109, -59,
-110, -56, -110, -53, -111, -48, -111, -41, -111, -33, -112, -26, -113, -25,
-113, -28, -113, -33, -112, -38, -111, -40, -108, -45, -104, -52, -102, -51,
-99, -48, -99, -48, -98, -49, -97, -52, -95, -56, -93, -62, -92, -66, -90, -72,
-87, -75, -84, -69, -82, -62, -80, -58, -79, -56, -79, -60, -79, -66, -76, -75,
-73, -84, -72, -90, -73, -95, -72, -96, -72, -92, -72, -87, -71, -78, -70, -71,
-68, -67, -65, -66, -65, -67, -68, -69, -71, -73, -75, -73, -76, -67, -76, -59,
-77, -50, -78, -44, -78, -42, -77, -39, -75, -38, -74, -36, -73, -29, -74, -28,
-75, -31, -75, -33, -76, -32, -76, -32, -77, -33, -80, -34, -80, -36, -80, -38,
-81, -45, -79, -53, -77, -59, -78, -68, -79, -74, -77, -79, -76, -80, -73, -77,
-72, -76, -72, -74, -72, -73, -71, -71, -69, -72, -67, -74, -66, -72, -65, -69,
-65, -65, -64, -60, -60, -53, -54, -46, -48, -41, -43, -41, -41, -39, -39, -32,
-33, -33, -29, -38, -28, -40, -27, -42, -27, -39, -30, -35, -30, -32, -29, -34,
-28, -35, -29, -36, -30, -39, -33, -44, -34, -50, -39, -53, -42, -52, -46, -44,
-49, -37, -53, -30, -55, -22, -54, -19, -55, -15, -56, -11, -57, -11, -56, -7,
-56, -9, -56, -21, -57, -33, -55, -38, -54, -38, -49, -39, -44, -41, -38, -39,
-33, -32, -29, -22, -27, -9, -27, -3, -29, 1, -29, 3, -28, 7, -27, 11, -23, 14,
-21, 13, -20, 5, -18, -1, -15, -3, -10, 2, -4, 6, };