#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0105

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 7, 3, 12, 5, 14, 7, 16, 8, 16, 9,
18, 11, 19, 12, 20, 13, 22, 14, 23, 16, 24, 16, 26, 19, 28, 18, 29, 18, 28, 19,
31, 19, 30, 19, 31, 19, 30, 18, 30, 19, 31, 20, 32, 21, 34, 20, 34, 21, 37, 22,
36, 22, 37, 22, 37, 23, 39, 23, 38, 21, 37, 21, 37, 20, 35, 21, 36, 22, 39, 22,
39, 22, 39, 22, 40, 26, 43, 25, 43, 24, 43, 23, 40, 22, 38, 22, 38, 24, 40, 23,
38, 23, 39, 23, 39, 24, 40, 24, 41, 24, 42, 20, 38, 18, 37, 22, 41, 21, 39, 21,
38, 20, 36, 20, 35, 20, 35, 20, 34, 20, 34, 20, 33, 21, 34, 22, 34, 24, 35, 23,
35, 23, 36, 25, 36, 26, 36, 27, 38, 29, 39, 29, 40, 31, 42, 33, 43, 36, 47, 35,
45, 40, 49, 52, 62, 52, 62, 54, 62, 54, 63, 55, 63, 55, 65, 57, 65, 56, 66, 58,
65, 60, 67, 61, 68, 61, 70, 62, 69, 62, 69, 62, 69, 62, 70, 63, 69, 61, 67, 62,
68, 64, 70, 64, 70, 64, 69, 63, 70, 64, 70, 65, 70, 65, 72, 62, 69, 62, 68, 66,
71, 67, 71, 68, 74, 68, 71, 69, 71, 70, 72, 71, 72, 71, 72, 72, 73, 73, 74, 73,
74, 74, 75, 74, 76, 75, 75, 75, 77, 76, 77, 77, 77, 77, 78, 79, 78, 79, 78, 80,
80, 81, 78, 81, 78, 80, 78, 80, 78, 81, 78, 81, 78, 82, 79, 82, 79, 84, 81, 88,
83, 89, 84, 90, 84, 91, 86, 91, 85, 91, 86, 92, 86, 91, 86, 93, 87, 94, 88, 95,
90, 97, 90, 98, 93, 100, 94, 103, 96, 105, 100, 104, 99, 106, 101, 106, 100,
108, 103, 108, 102, 110, 105, 112, 106, 114, 108, 115, 111, 115, 110, 116, 111,
114, 108, 115, 111, 114, 108, 109, 104, 108, 103, 108, 103, 109, 105, 109, 107,
111, 107, 111, 108, 112, 110, 113, 110, 114, 112, 113, 112, 113, 111, 112, 112,
112, 111, 111, 111, 111, 110, 110, 109, 110, 110, 110, 109, 110, 108, 110, 108,
109, 109, 109, 108, 109, 107, 106, 105, 105, 103, 102, 101, 102, 101, 99, 97,
97, 97, 96, 95, 97, 96, 97, 96, 96, 95, 95, 94, 93, 92, 92, 90, 91, 90, 86, 85,
87, 86, 94, 95, 92, 91, 91, 90, 91, 89, 88, 86, 86, 86, 85, 83, 82, 81, 80, 78,
77, 74, 73, 72, 70, 67, 69, 67, 67, 65, 65, 64, 67, 64, 65, 65, 66, 66, 65, 65,
65, 63, 63, 62, 62, 60, 60, 56, 58, 55, 55, 51, 52, 49, 50, 46, 47, 44, 45, 42,
43, 39, 41, 38, 38, 36, 37, 35, 35, 33, 32, 30, 31, 28, 28, 25, 25, 24, 23, 20,
21, 19, 20, 16, 19, 16, 18, 14, 16, 13, 15, 12, 14, 11, 13, 8, 10, 6, 8, 4, 6,
1, 4, -2, 1, -4, 0, -5, -2, -7, -1, -7, -2, -8, -3, -9, -4, -10, -3, -10, -4,
-13, -7, -15, -9, -15, -12, -19, -13, -21, -11, -21, -13, -23, -14, -22, -15,
-23, -15, -23, -14, -23, -15, -23, -17, -27, -20, -30, -20, -31, -21, -32, -21,
-32, -23, -36, -23, -36, -24, -38, -25, -37, -25, -37, -25, -37, -23, -37, -24,
-36, -22, -36, -22, -35, -23, -35, -21, -35, -20, -34, -20, -33, -20, -34, -19,
-32, -18, -32, -17, -31, -16, -29, -17, -30, -17, -31, -17, -30, -17, -30, -18,
-31, -19, -32, -20, -33, -19, -34, -18, -32, -18, -32, -19, -32, -19, -31, -20,
-31, -20, -32, -20, -31, -21, -32, -21, -32, -24, -35, -24, -35, -28, -37, -28,
-36, -27, -36, -28, -36, -28, -37, -28, -35, -28, -34, -29, -35, -29, -35, -32,
-37, -34, -40, -31, -37, -36, -42, -57, -67, -59, -66, -59, -67, -61, -69, -60,
-68, -62, -69, -60, -68, -62, -69, -61, -67, -62, -69, -61, -69, -64, -70, -64,
-70, -64, -72, -66, -72, -67, -73, -68, -73, -68, -75, -68, -76, -70, -76, -71,
-78, -72, -79, -73, -79, -73, -80, -74, -79, -74, -80, -75, -80, -74, -79, -72,
-77, -73, -78, -74, -80, -73, -78, -74, -78, -74, -77, -75, -78, -75, -79, -76,
-78, -75, -77, -76, -78, -77, -79, -75, -78, -75, -77, -75, -77, -75, -78, -76,
-78, -77, -78, -77, -77, -78, -78, -81, -81, -81, -82, -80, -81, -81, -81, -82,
-82, -83, -84, -85, -84, -88, -86, -87, -87, -91, -88, -96, -93, -96, -93, -97,
-91, -96, -92, -96, -93, -96, -93, -96, -93, -96, -93, -96, -94, -97, -95, -98,
-95, -99, -96, -100, -97, -101, -98, -102, -100, -104, -101, -106, -102, -106,
-102, -106, -102, -107, -104, -107, -104, -107, -105, -108, -104, -109, -106,
-111, -108, -112, -109, -113, -112, -114, -111, -116, -114, -116, -114, -117,
-115, -115, -112, -113, -112, -114, -112, -114, -113, -115, -115, -114, -114,
-115, -116, -118, -117, -118, -119, -118, -119, -119, -119, -118, -119, -117,
-119, -116, -118, -114, -117, -112, -113, -112, -115, -112, -116, -112, -114,
-111, -113, -111, -112, -110, -113, -107, -110, -104, -106, -102, -103, -99,
-101, -97, -100, -95, -97, -95, -97, -92, -94, -94, -99, -96, -102, -95, -100,
-96, -99, -94, -98, -94, -97, -93, -96, -92, -94, -90, -92, -88, -90, -87, -89,
-85, -86, -83, -85, -83, -82, -81, -82, -80, -79, -79, -79, -77, -76, -75, -74,
-73, -72, -71, -70, -69, -67, -66, -65, -64, -63, -62, -60, -60, -59, -59, -58,
-58, -57, -57, -56, -57, -54, -55, -53, -54, -51, -51, -48, -48, -44, -44, -42,
-43, -41, -41, -37, -37, -34, -37, -32, -36, -32, -35, -32, -34, -31, -32, -27,
-29, -25, -27, -23, -25, -21, -23, -19, -21, -16, -20, -16, -18, -14, -19, -14,
-18, -13, -18, -13, -17, -12, -14, -11, -14, -9, -11, -6, -9, -2, -7, 1, -4, 4,
-1, 5, };