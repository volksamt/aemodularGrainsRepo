#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0103

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 6, 3, 10, 6, 11, 7, 13, 9, 14, 10,
16, 12, 18, 14, 19, 15, 21, 17, 23, 18, 26, 20, 28, 23, 30, 24, 33, 25, 34, 27,
37, 28, 38, 29, 39, 30, 41, 30, 40, 30, 41, 30, 42, 30, 42, 30, 43, 29, 42, 29,
43, 29, 44, 27, 43, 27, 42, 27, 42, 26, 42, 24, 41, 24, 41, 24, 40, 22, 40, 22,
40, 22, 39, 22, 39, 21, 39, 21, 40, 20, 40, 20, 39, 20, 38, 19, 38, 19, 38, 20,
38, 20, 37, 19, 37, 20, 37, 20, 37, 21, 37, 22, 37, 23, 37, 24, 37, 25, 38, 26,
37, 25, 36, 26, 36, 26, 37, 27, 35, 27, 35, 28, 33, 28, 33, 29, 32, 30, 32, 29,
31, 30, 30, 30, 30, 29, 28, 30, 28, 30, 27, 30, 26, 30, 25, 30, 25, 30, 25, 30,
25, 31, 24, 31, 25, 32, 25, 32, 26, 31, 26, 33, 26, 33, 27, 34, 28, 33, 29, 34,
29, 35, 30, 35, 31, 36, 32, 36, 33, 36, 33, 36, 36, 37, 36, 37, 37, 36, 38, 37,
38, 38, 40, 38, 41, 39, 43, 39, 44, 39, 45, 40, 46, 40, 47, 41, 47, 41, 49, 40,
48, 41, 50, 41, 50, 41, 51, 43, 50, 42, 51, 41, 52, 43, 52, 43, 52, 43, 52, 43,
51, 44, 52, 44, 52, 45, 51, 46, 52, 47, 53, 49, 54, 51, 55, 53, 56, 55, 56, 56,
58, 58, 58, 60, 60, 62, 61, 65, 63, 66, 63, 68, 65, 70, 67, 72, 68, 74, 69, 76,
71, 77, 72, 79, 73, 81, 74, 83, 75, 83, 76, 84, 77, 85, 79, 85, 79, 87, 81, 88,
82, 89, 83, 90, 84, 91, 86, 92, 87, 93, 89, 93, 90, 93, 91, 95, 92, 95, 94, 96,
95, 96, 96, 96, 96, 97, 98, 97, 99, 97, 101, 98, 102, 98, 104, 98, 105, 99, 105,
99, 106, 99, 107, 98, 108, 99, 108, 98, 109, 98, 109, 98, 109, 97, 109, 97, 109,
96, 109, 96, 109, 95, 109, 93, 108, 92, 107, 90, 104, 88, 103, 86, 101, 85, 99,
84, 97, 81, 95, 80, 93, 78, 91, 77, 88, 76, 87, 74, 85, 73, 83, 72, 80, 71, 79,
70, 77, 69, 75, 68, 74, 68, 71, 68, 70, 67, 70, 66, 68, 66, 66, 65, 66, 65, 64,
63, 63, 64, 62, 62, 60, 61, 58, 61, 57, 59, 56, 59, 55, 58, 54, 57, 53, 56, 54,
56, 53, 56, 53, 55, 52, 54, 52, 53, 52, 53, 51, 52, 50, 51, 49, 49, 49, 48, 49,
48, 48, 46, 49, 45, 49, 45, 48, 44, 49, 44, 49, 42, 49, 43, 50, 41, 49, 40, 49,
40, 50, 39, 50, 40, 50, 39, 50, 38, 50, 38, 50, 36, 50, 36, 48, 33, 47, 32, 45,
30, 42, 28, 40, 25, 37, 23, 34, 21, 31, 19, 29, 16, 26, 14, 23, 11, 19, 9, 16,
7, 13, 5, 9, 2, 7, 0, 3, -2, 0, -4, -3, -6, -7, -8, -9, -9, -13, -11, -15, -12,
-18, -14, -20, -14, -22, -15, -24, -16, -27, -18, -28, -19, -30, -19, -33, -20,
-35, -21, -36, -20, -37, -21, -38, -21, -39, -21, -41, -20, -40, -21, -40, -20,
-41, -21, -42, -21, -41, -21, -43, -22, -42, -21, -43, -22, -44, -22, -44, -22,
-44, -22, -42, -21, -42, -20, -41, -20, -41, -20, -40, -20, -40, -19, -39, -19,
-38, -18, -37, -17, -36, -16, -34, -15, -33, -14, -31, -13, -30, -12, -28, -10,
-27, -9, -26, -8, -25, -8, -23, -6, -22, -6, -22, -5, -22, -4, -20, -4, -20, -4,
-20, -3, -20, -4, -20, -3, -20, -3, -20, -4, -21, -4, -21, -4, -22, -4, -23, -6,
-24, -6, -25, -7, -25, -8, -27, -7, -28, -9, -28, -9, -30, -9, -30, -11, -32,
-12, -32, -13, -33, -13, -34, -13, -36, -14, -36, -16, -37, -17, -37, -18, -38,
-18, -39, -19, -38, -20, -39, -20, -38, -21, -39, -20, -39, -21, -39, -22, -39,
-21, -39, -22, -38, -21, -38, -21, -38, -21, -36, -21, -35, -21, -34, -20, -35,
-21, -34, -21, -33, -21, -33, -22, -32, -21, -32, -22, -31, -23, -32, -24, -31,
-25, -32, -26, -32, -26, -32, -28, -32, -29, -33, -30, -33, -32, -34, -33, -35,
-34, -35, -36, -36, -38, -37, -39, -37, -40, -39, -42, -40, -44, -42, -45, -43,
-46, -45, -48, -46, -51, -48, -53, -49, -55, -51, -57, -53, -58, -55, -61, -57,
-63, -59, -65, -61, -66, -63, -68, -65, -71, -67, -73, -69, -75, -71, -77, -74,
-80, -76, -81, -78, -84, -80, -86, -82, -87, -83, -91, -86, -93, -89, -95, -91,
-97, -94, -100, -96, -102, -99, -104, -101, -107, -103, -108, -105, -110, -107,
-112, -109, -113, -110, -115, -111, -116, -113, -117, -114, -118, -115, -119,
-115, -119, -116, -119, -116, -119, -116, -119, -115, -119, -115, -118, -115,
-118, -115, -116, -114, -115, -113, -115, -113, -114, -111, -113, -112, -113,
-110, -111, -109, -110, -108, -109, -108, -108, -107, -107, -106, -105, -105,
-104, -103, -102, -103, -101, -101, -100, -100, -97, -99, -97, -98, -96, -97,
-95, -96, -93, -95, -91, -95, -90, -93, -89, -93, -87, -92, -86, -90, -84, -89,
-82, -88, -80, -86, -80, -87, -78, -84, -76, -84, -76, -83, -74, -82, -73, -81,
-73, -80, -71, -78, -71, -78, -70, -76, -70, -75, -70, -73, -68, -74, -69, -73,
-69, -74, -70, -73, -70, -73, -73, -74, -73, -73, -72, -72, -72, -72, -73, -73,
-74, -72, -73, -71, -72, -70, -73, -69, -71, -68, -71, -67, -71, -66, -70, -64,
-69, -62, -68, -60, -67, -58, -64, -56, -63, -54, -61, -51, -58, -49, -56, -47,
-54, -44, -53, -42, -50, -39, -48, -37, -45, -35, -43, -32, -40, -29, -37, -27,
-35, -25, -32, -22, -29, -19, -26, -16, -23, -14, -20, -11, -17, -8, -15, -6,
-12, -4, -10, -2, -7, 0, -4, 1, -3, 4, -1, 4, };