#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {79, -3, 118, 18, 105, 27, 109, 30,
100, 28, 101, 24, 95, 24, 95, 23, 90, 25, 89, 27, 86, 29, 85, 27, 83, 28, 81,
26, 78, 26, 77, 24, 75, 25, 74, 25, 72, 27, 71, 27, 70, 27, 68, 26, 68, 28, 66,
29, 65, 30, 64, 31, 64, 32, 63, 33, 63, 35, 62, 35, 61, 37, 60, 38, 60, 40, 59,
40, 59, 42, 58, 42, 58, 44, 57, 45, 57, 46, 57, 48, 55, 48, 56, 50, 56, 51, 54,
53, 55, 53, 54, 54, 54, 55, 53, 57, 52, 57, 51, 58, 52, 60, 51, 60, 52, 61, 50,
62, 51, 63, 50, 63, 50, 65, 50, 65, 49, 66, 49, 67, 49, 67, 48, 68, 48, 68, 48,
69, 48, 70, 48, 70, 46, 72, 47, 72, 46, 72, 46, 72, 45, 74, 45, 75, 45, 73, 45,
75, 44, 76, 44, 76, 44, 77, 43, 77, 43, 77, 43, 78, 43, 78, 43, 79, 43, 79, 42,
79, 42, 80, 42, 81, 41, 81, 41, 81, 42, 81, 41, 82, 40, 82, 40, 82, 40, 83, 41,
83, 39, 83, 39, 84, 40, 85, 39, 85, 38, 85, 39, 86, 38, 86, 39, 87, 38, 87, 38,
87, 38, 87, 38, 88, 37, 88, 36, 88, 36, 89, 37, 89, 36, 89, 36, 90, 36, 90, 36,
90, 36, 91, 36, 91, 36, 90, 35, 92, 35, 92, 34, 92, 34, 92, 34, 93, 34, 93, 34,
94, 34, 94, 33, 94, 34, 93, 33, 94, 33, 94, 33, 95, 33, 94, 33, 95, 33, 96, 32,
96, 33, 96, 32, 96, 32, 97, 31, 97, 32, 97, 31, 98, 31, 98, 31, 98, 30, 98, 30,
99, 30, 99, 30, 100, 30, 99, 30, 100, 30, 99, 30, 100, 29, 101, 30, 100, 29,
101, 28, 101, 29, 101, 28, 102, 28, 102, 28, 102, 28, 103, 28, 103, 27, 103, 27,
103, 27, 104, 27, 103, 27, 105, 27, 104, 27, 104, 26, 104, 26, 105, 26, 106, 26,
105, 26, 105, 25, 107, 25, 106, 25, 106, 25, 106, 25, 107, 25, 108, 24, 108, 25,
109, 24, 108, 24, 108, 24, 109, 24, 108, 24, 110, 23, 110, 24, 110, 23, 109, 24,
110, 23, 109, 22, 111, 21, 111, 22, 111, 22, 112, 23, 112, 21, 111, 23, 112, 21,
111, 21, 112, 21, 112, 21, 112, 21, 114, 20, 113, 20, 113, 20, 113, 20, 113, 18,
114, 21, 115, 18, 114, 21, 115, 16, 113, 21, 117, 16, 112, 22, 117, 13, 112, 28,
121, -6, 101, -55, 73, -34, 86, -51, 76, -47, 79, -53, 76, -52, 77, -54, 75,
-55, 77, -53, 71, -51, 57, -49, 56, -49, 44, -43, 29, -41, 17, -34, 5, -33, -8,
-29, -17, -27, -27, -23, -33, -22, -41, -19, -46, -19, -50, -18, -54, -16, -57,
-16, -60, -16, -62, -15, -63, -14, -65, -13, -65, -14, -67, -13, -67, -13, -68,
-14, -69, -13, -69, -14, -71, -13, -70, -13, -72, -13, -72, -14, -72, -14, -73,
-14, -73, -13, -72, -15, -74, -13, -73, -15, -74, -14, -74, -14, -75, -14, -74,
-14, -75, -15, -74, -16, -74, -16, -75, -16, -75, -15, -75, -16, -75, -16, -75,
-16, -75, -17, -76, -17, -75, -17, -76, -17, -76, -17, -76, -18, -77, -18, -76,
-18, -77, -18, -77, -19, -76, -19, -76, -20, -77, -19, -77, -20, -77, -19, -77,
-20, -77, -20, -77, -20, -78, -21, -77, -20, -78, -21, -77, -21, -77, -21, -77,
-22, -78, -21, -78, -22, -79, -23, -78, -23, -78, -23, -79, -23, -78, -23, -78,
-23, -78, -24, -78, -24, -79, -24, -79, -25, -79, -24, -79, -24, -78, -24, -79,
-25, -79, -24, -79, -25, -79, -26, -79, -25, -79, -26, -79, -26, -80, -27, -80,
-26, -79, -26, -80, -27, -79, -27, -79, -27, -79, -27, -79, -28, -79, -27, -78,
-27, -79, -28, -79, -28, -79, -29, -79, -27, -79, -28, -79, -28, -79, -29, -79,
-29, -79, -29, -79, -29, -79, -29, -78, -29, -78, -30, -78, -29, -79, -29, -78,
-30, -78, -29, -78, -31, -78, -30, -78, -30, -78, -30, -78, -31, -77, -31, -78,
-31, -78, -31, -78, -31, -77, -31, -78, -31, -77, -31, -77, -32, -77, -32, -77,
-32, -76, -32, -77, -32, -77, -33, -76, -32, -75, -33, -76, -33, -76, -33, -75,
-32, -75, -32, -75, -34, -75, -33, -75, -33, -75, -34, -75, -33, -75, -33, -74,
-33, -74, -34, -74, -35, -74, -35, -74, -34, -74, -34, -74, -35, -74, -34, -73,
-34, -73, -34, -73, -35, -73, -36, -72, -35, -72, -35, -71, -35, -72, -35, -72,
-36, -72, -36, -72, -35, -71, -35, -72, -35, -70, -36, -71, -35, -71, -36, -70,
-37, -70, -36, -70, -37, -69, -36, -69, -37, -68, -37, -70, -37, -68, -37, -68,
-36, -68, -38, -68, -37, -67, -37, -67, -37, -68, -37, -67, -37, -66, -37, -67,
-37, -66, -38, -66, -38, -66, -38, -65, -38, -65, -37, -64, -38, -64, -38, -64,
-39, -65, -38, -64, -38, -64, -39, -63, -38, -63, -39, -63, -39, -62, -39, -62,
-40, -62, -40, -61, -39, -62, -40, -62, -39, -62, -40, -60, -39, -61, -40, -60,
-40, -60, -40, -59, -40, -60, -40, -59, -40, -59, -40, -59, -40, -59, -40, -58,
-40, -57, -40, -58, -41, -57, -40, -57, -41, -57, -41, -56, -40, -56, -40, -56,
-41, -56, -41, -55, -40, -55, -41, -55, -41, -55, -40, -55, -41, -53, -41, -54,
-40, -53, -42, -52, -42, -53, -41, -52, -42, -52, -42, -52, -40, -51, -41, -51,
-41, -51, -42, -51, -41, -50, -42, -50, -42, -50, -41, -49, -41, -49, -41, -48,
-41, -48, -41, -48, -42, -48, -41, -47, -42, -46, -41, -46, -42, -47, -41, -46,
-42, -46, -42, -45, -42, -45, -42, -44, -41, -45, -41, -44, -43, -44, -41, -44,
-42, -43, -42, -42, -42, -41, -42, -42, -42, -41, -41, -41, -43, -40, -42, -42,
-42, -40, -43, -41, -41, -39, -43, -40, -40, -37, -46, -42, -17, -28, };