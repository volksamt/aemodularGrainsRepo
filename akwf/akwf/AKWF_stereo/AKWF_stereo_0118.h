#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0118

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 5, 2, 7, 2, 8, 5, 8, 5, 8, 10,
10, 11, 15, 14, 16, 13, 13, 9, 16, 7, 20, 9, 18, 7, 13, 1, 9, -9, 8, -11, 14,
-2, 9, -6, 72, 63, 109, 105, 62, 62, 34, 31, 17, 13, 16, 13, 12, 9, 11, 8, 12,
5, 12, 5, 6, 4, 4, 8, 9, 16, 15, 20, 10, 18, -3, 17, -2, 14, 1, 9, -1, 7, -4, 8,
-4, 10, -6, 9, -5, 10, -5, 10, -5, 8, -4, 6, 0, 0, 1, -6, 1, -2, 0, 2, 0, 3, 1,
2, 5, -2, 10, -2, 9, 2, 4, 1, 0, -5, 0, -7, -1, -3, 2, 2, 2, 6, 2, 6, 0, 5, -3,
2, -4, 1, -2, 2, 1, 1, 1, 2, -4, 3, -10, 4, -7, 2, -3, 0, 0, -4, 2, -4, 4, -1,
5, 1, 4, 3, 4, 2, 1, 2, -4, 0, -3, -2, -3, -4, -3, -6, -3, -13, -4, -15, -3, -6,
1, 4, 7, 8, 6, 10, 1, 5, -3, -2, -5, -3, -4, -1, -4, -1, -4, -2, -7, -6, -9, -8,
-11, -9, -12, -8, -6, -4, 2, -2, 2, -1, -2, 4, -4, 6, -4, 6, 0, 5, 4, 4, 7, 5,
7, 7, 6, 9, 7, 4, 9, -2, 8, -4, 7, 0, 8, 5, 8, 7, 5, 8, 5, 6, 9, 3, 13, 1, 12,
3, 6, 8, 0, 9, -5, 6, -9, 2, -11, 0, -5, -2, 0, -3, 2, -3, 4, -1, 3, 1, 1, 3, 2,
2, 4, 2, 4, 1, 2, 1, -1, -1, -1, -5, -1, -7, -4, -4, -4, 5, -2, 11, 1, 12, 5, 9,
4, 5, -2, 2, -5, 0, -5, -1, -5, -2, -7, -4, -8, -9, -7, -12, -4, -9, 2, -5, 8,
-1, 6, 5, 4, 5, 1, 0, -3, -1, -2, 1, -1, 3, -2, 0, -1, -1, -1, -3, 1, -5, 1, -8,
2, -5, 3, 0, 0, 5, -5, 6, -5, 5, -4, 3, -3, 0, -3, -2, -3, -2, -4, -2, -4, -3,
-9, -5, -9, -6, -5, -7, -3, -6, 0, -6, 1, -5, 4, -4, 6, -2, 4, -3, 2, -4, 2, -2,
2, 2, 0, 2, -1, 0, -4, -4, -7, -10, -7, -12, -12, -12, -7, 0, -7, 5, -11, 0,
-13, -3, -8, 1, -6, -1, 0, 1, -8, 3, -2, 13, -54, -39, -119, -98, -78, -64, -35,
-27, -8, -7, 1, -6, 2, -4, 1, -2, -2, -1, 7, 0, 11, -2, 9, -1, 0, -4, -5, -4, 0,
-1, 6, -2, 4, -2, 5, 1, 6, 2, 3, 4, -2, 12, -5, 12, -8, 1, -9, -8, -9, -7, -7,
-4, -7, -6, -6, -6, -6, -9, -5, -10, -5, -9, -1, -6, 10, 1, 6, 2, 0, -3, -2, -6,
-4, -7, -1, -8, -2, -7, -2, -7, -1, -7, 1, -8, 1, -8, 2, -8, 6, -4, 6, 10, 1,
15, -3, 10, -3, 4, -3, -3, -1, -4, -2, -4, -3, -2, -6, -3, -8, -5, -11, -7, -10,
-5, -11, -3, -4, -3, 8, -3, 10, -3, 8, -3, 6, -2, 6, -1, 7, -1, 5, -4, 1, -8,
-6, -11, -5, -11, 0, -8, 5, -5, 7, -2, 6, -2, 7, 8, 4, 10, 1, 7, 4, 7, 7, 10, 8,
12, 4, 9, 0, 9, -2, 9, 0, 3, 1, -1, 3, 1, 5, 2, 2, 6, -2, 7, 7, 4, 16, 1, 12, 0,
7, 1, 2, 1, 1, 1, -1, 0, -2, 0, 0, 2, 8, -1, 6, 1, 2, 8, -1, 8, 0, 2, 2, -1, 3,
0, 4, 8, 5, 19, 6, 15, 6, 10, 3, 5, 2, 4, 5, 8, 10, 12, 10, 12, 8, 12, 8, 11, 7,
11, 5, 10, 4, 10, 7, 9, 7, 8, 5, 7, 11, 2, 19, 0, 12, -1, 4, 2, 2, 4, 1, 6, 1,
7, 1, 4, 1, -1, 0, -5, -5, -6, -6, -3, -6, 0, -8, 2, -9, -2, -10, -6, -7, -3,
-2, -6, 0, -2, -3, 8, -4, 6, -2, 5, 3, 6, 9, 4, 12, 3, 7, 0, 2, 0, 0, -2, -1,
-3, 0, -3, 1, -1, 1, 1, 4, 2, 9, 3, 7, 3, 4, 3, 1, 1, 8, 1, 12, 0, 5, 2, 2, 3,
2, 2, 1, -1, 0, -1, 3, 2, 7, 2, 8, 2, 7, 0, 5, 2, 3, 8, 3, 11, 5, 7, 1, 4, 0, 1,
-1, -3, -3, -3, 0, 1, 0, 5, 2, 11, 0, 16, -1, 15, -2, 1, -4, -7, -6, -7, -6,
-10, -4, -10, -5, -8, -9, -7, -12, -6, -11, -6, -7, -5, 0, -4, -7, -4, -18, -4,
-18, -5, -14, -9, -9, -12, -9, -14, -8, -9, -5, -6, -3, -5, -1, -6, 0, -6, 2,
-14, 4, -19, 5, -7, 6, 7, 8, 10, 9, 5, 10, 4, 9, 5, 8, 5, 7, 7, 4, 10, 0, 7,
-14, 2, -19, -2, -10, 0, 0, 5, 10, 8, 15, 10, 14, 9, 8, 6, 4, 7, 5, 8, 7, 5, 6,
0, 0, -2, -4, -13, -6, -19, -4, -12, -1, -5, 0, 1, 0, 7, 1, 11, 1, 9, 0, 5, 0,
2, -1, -1, -2, 0, -2, 2, -6, 1, -16, 1, -15, 0, -10, 0, -5, -1, -2, 1, 1, 1, -4,
-1, -9, -4, -10, -5, -11, -4, -11, -4, -10, -2, -7, -2, -6, -2, -4, -12, -4,
-18, -4, -14, -8, -12, -15, -9, -14, -11, -8, -11, -4, -13, -3, -17, -5, -16,
-8, -12, -9, -9, -7, -9, -7, -12, -5, -15, -11, -12, -17, -5, -11, 4, -7, 6, -5,
1, -4, -3, -2, -5, 2, -6, 3, -5, -4, -4, -10, -5, -11, -9, -8, -9, -5, -6, -1,
-4, -1, -2, -1, -1, -3, -11, -6, -12, -8, -8, -3, -5, -1, -4, -4, -8, -8, -13,
-11, -12, -10, -10, -10, -9, -8, -7, -3, -4, 6, -3, 3, -1, 0, -3, 2, -8, -5,
-10, -16, -7, -15, -3, -5, 0, 0, 2, };