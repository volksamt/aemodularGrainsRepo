#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0094

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -10, 1, -9, 4, -5, 5, -3, 8, 1, 9,
3, 10, 7, 11, 9, 12, 13, 12, 15, 14, 19, 15, 21, 14, 24, 15, 27, 16, 29, 17, 32,
17, 34, 16, 37, 17, 39, 18, 42, 18, 43, 18, 45, 18, 48, 18, 49, 18, 51, 18, 53,
18, 53, 19, 55, 18, 57, 19, 58, 19, 60, 19, 60, 21, 61, 21, 62, 22, 62, 22, 64,
23, 66, 23, 66, 24, 66, 26, 67, 27, 68, 28, 68, 29, 68, 30, 69, 31, 69, 32, 71,
34, 70, 35, 70, 36, 71, 37, 71, 38, 72, 40, 72, 41, 71, 44, 72, 45, 72, 46, 72,
47, 72, 49, 73, 49, 73, 52, 73, 52, 73, 54, 73, 55, 73, 56, 73, 58, 74, 58, 74,
59, 73, 61, 74, 61, 73, 63, 74, 64, 73, 64, 73, 65, 73, 66, 73, 66, 73, 68, 73,
68, 72, 68, 73, 68, 72, 68, 71, 68, 71, 69, 71, 70, 70, 69, 70, 70, 69, 69, 69,
70, 69, 69, 68, 68, 67, 69, 68, 68, 67, 67, 67, 67, 66, 67, 65, 67, 65, 67, 63,
66, 63, 66, 63, 66, 62, 66, 62, 65, 61, 65, 60, 65, 60, 65, 60, 65, 59, 64, 59,
64, 58, 64, 57, 63, 57, 64, 57, 63, 56, 63, 55, 63, 55, 63, 54, 63, 55, 63, 53,
63, 54, 63, 53, 62, 53, 63, 53, 63, 52, 63, 51, 62, 52, 63, 51, 63, 51, 64, 51,
63, 51, 63, 50, 63, 50, 63, 49, 64, 50, 63, 51, 63, 50, 62, 49, 63, 49, 62, 50,
62, 50, 62, 49, 62, 48, 62, 49, 61, 49, 62, 49, 62, 49, 61, 48, 60, 48, 60, 48,
59, 48, 60, 48, 58, 47, 58, 48, 58, 47, 58, 46, 57, 46, 56, 46, 57, 46, 56, 45,
55, 44, 55, 45, 54, 45, 54, 43, 53, 44, 53, 44, 53, 43, 52, 42, 51, 42, 52, 42,
51, 41, 50, 41, 51, 41, 50, 41, 50, 39, 49, 40, 49, 39, 48, 38, 49, 38, 48, 37,
48, 37, 48, 37, 47, 36, 47, 36, 48, 36, 50, 34, 52, 33, 53, 32, 53, 32, 54, 32,
55, 32, 55, 31, 55, 30, 55, 30, 57, 30, 57, 30, 58, 29, 58, 29, 59, 29, 58, 29,
59, 28, 58, 29, 59, 28, 58, 29, 58, 28, 57, 28, 56, 29, 56, 29, 55, 29, 54, 29,
53, 30, 52, 30, 51, 31, 49, 31, 49, 31, 47, 32, 46, 32, 43, 32, 42, 33, 41, 32,
39, 34, 38, 35, 36, 34, 34, 35, 33, 35, 31, 35, 30, 36, 28, 36, 27, 35, 26, 36,
24, 36, 23, 36, 21, 36, 19, 36, 19, 36, 17, 36, 16, 36, 15, 36, 15, 36, 14, 35,
12, 35, 11, 35, 11, 33, 11, 35, 9, 33, 10, 34, 8, 33, 9, 32, 8, 31, 8, 31, 8,
31, 8, 30, 7, 29, 7, 29, 7, 28, 7, 28, 7, 27, 7, 26, 7, 26, 7, 26, 7, 25, 8, 24,
8, 24, 7, 23, 8, 23, 9, 22, 9, 21, 8, 20, 8, 20, 8, 20, 9, 19, 9, 18, 10, 19,
10, 17, 10, 18, 10, 17, 10, 17, 10, 17, 11, 16, 11, 16, 11, 15, 11, 15, 12, 14,
11, 15, 12, 15, 12, 16, 11, 15, 13, 15, 12, 14, 12, 14, 13, 15, 13, 15, 13, 14,
12, 15, 12, 15, 13, 15, 13, 15, 13, 15, 13, 15, 14, 16, 13, 15, 13, 16, 14, 16,
13, 15, 13, 16, 13, 16, 13, 15, 14, 17, 14, 16, 13, 16, 14, 16, 13, 16, 14, 16,
13, 16, 13, 17, 13, 16, 12, 16, 12, 15, 12, 15, 12, 15, 12, 15, 11, 15, 10, 14,
10, 14, 10, 14, 9, 14, 9, 13, 8, 13, 8, 12, 8, 12, 6, 11, 5, 9, 5, 10, 4, 9, 3,
9, 3, 8, 1, 7, 1, 7, 0, 5, -1, 4, -3, 3, -3, 2, -5, 1, -6, 0, -7, -1, -9, -2,
-10, -4, -11, -4, -12, -6, -13, -8, -15, -8, -15, -11, -18, -12, -19, -13, -21,
-15, -21, -16, -23, -18, -24, -20, -26, -21, -28, -23, -29, -25, -30, -27, -31,
-29, -32, -30, -34, -32, -37, -34, -37, -36, -39, -37, -40, -39, -41, -42, -43,
-43, -44, -46, -46, -48, -47, -50, -48, -52, -50, -54, -51, -56, -52, -57, -54,
-60, -55, -61, -56, -63, -57, -65, -60, -68, -60, -70, -61, -72, -61, -74, -62,
-75, -63, -78, -64, -80, -65, -82, -66, -84, -67, -86, -67, -87, -68, -89, -70,
-91, -71, -92, -72, -95, -72, -96, -74, -97, -75, -100, -75, -101, -78, -102,
-78, -104, -79, -105, -81, -106, -82, -108, -83, -109, -85, -110, -85, -111,
-87, -112, -88, -113, -90, -113, -90, -114, -93, -115, -94, -115, -94, -116,
-96, -116, -97, -116, -98, -117, -99, -118, -101, -119, -102, -119, -104, -119,
-105, -119, -105, -119, -106, -120, -108, -119, -109, -119, -109, -119, -110,
-118, -111, -119, -111, -118, -112, -118, -112, -118, -114, -119, -113, -117,
-114, -117, -114, -118, -114, -116, -114, -117, -114, -115, -114, -115, -114,
-115, -114, -114, -114, -114, -113, -112, -113, -111, -113, -112, -113, -110,
-112, -110, -111, -109, -111, -109, -110, -107, -109, -108, -108, -106, -108,
-105, -106, -104, -106, -104, -105, -103, -104, -102, -103, -101, -102, -100,
-101, -99, -101, -98, -99, -97, -98, -96, -96, -95, -95, -93, -93, -94, -93,
-92, -92, -91, -89, -89, -90, -89, -87, -88, -86, -86, -85, -85, -84, -84, -83,
-83, -82, -82, -80, -81, -79, -79, -76, -78, -77, -77, -74, -76, -73, -75, -72,
-73, -72, -72, -71, -70, -69, -70, -68, -69, -66, -67, -65, -66, -64, -64, -63,
-64, -61, -62, -61, -61, -57, -60, -54, -57, -49, -57, -45, -55, -43, -53, -40,
-51, -37, -50, -35, -47, -32, -45, -29, -43, -26, -40, -23, -37, -20, -35, -18,
-32, -15, -29, -11, -25, -9, -24, -7, -20, -3, -19, -2, -13, };