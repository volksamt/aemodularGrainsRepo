#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0195

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 23, 5, 32, 10, 33, 13, 38, 16, 41,
19, 46, 21, 48, 25, 52, 28, 55, 31, 57, 33, 59, 36, 63, 38, 66, 40, 68, 43, 71,
45, 73, 46, 76, 49, 77, 51, 80, 53, 82, 54, 83, 56, 85, 58, 87, 60, 90, 62, 91,
63, 93, 65, 94, 66, 95, 68, 98, 68, 98, 71, 99, 72, 100, 72, 102, 74, 103, 75,
104, 76, 105, 77, 105, 79, 106, 79, 107, 80, 107, 82, 108, 83, 109, 83, 109, 84,
109, 84, 110, 86, 110, 87, 110, 87, 111, 89, 110, 89, 110, 89, 110, 90, 110, 91,
109, 91, 110, 92, 109, 93, 109, 93, 108, 94, 108, 94, 108, 94, 107, 95, 107, 95,
106, 96, 105, 97, 106, 96, 105, 96, 104, 97, 103, 97, 103, 98, 103, 98, 102, 99,
102, 99, 101, 99, 101, 99, 101, 100, 100, 100, 100, 101, 99, 101, 99, 101, 99,
102, 99, 102, 97, 101, 97, 101, 98, 102, 97, 103, 96, 103, 97, 103, 96, 104, 96,
103, 96, 104, 96, 104, 96, 105, 96, 104, 96, 105, 96, 105, 95, 105, 95, 106, 96,
106, 96, 107, 96, 107, 97, 107, 97, 107, 96, 108, 96, 107, 96, 108, 97, 109, 96,
109, 98, 109, 98, 109, 98, 110, 97, 109, 98, 109, 99, 110, 98, 110, 98, 111, 99,
111, 99, 112, 99, 111, 99, 111, 100, 111, 99, 112, 100, 111, 101, 112, 101, 112,
101, 112, 100, 113, 101, 112, 101, 113, 102, 113, 101, 113, 102, 113, 102, 113,
102, 113, 103, 113, 103, 114, 103, 113, 103, 113, 103, 113, 104, 114, 104, 113,
104, 114, 104, 113, 105, 113, 105, 112, 105, 114, 105, 113, 106, 113, 106, 113,
105, 114, 106, 114, 105, 113, 106, 114, 106, 113, 106, 114, 106, 113, 106, 114,
106, 114, 106, 113, 106, 113, 106, 113, 106, 113, 106, 112, 105, 113, 106, 113,
106, 112, 105, 112, 105, 112, 105, 111, 104, 111, 105, 111, 103, 111, 103, 111,
102, 110, 101, 109, 101, 109, 101, 109, 100, 109, 99, 107, 99, 108, 99, 108, 98,
107, 96, 105, 96, 105, 95, 105, 94, 103, 93, 103, 93, 103, 93, 102, 92, 101, 90,
100, 90, 100, 89, 98, 87, 98, 87, 97, 86, 96, 85, 96, 83, 94, 83, 93, 82, 92,
80, 92, 79, 91, 78, 90, 77, 89, 76, 87, 75, 86, 73, 85, 71, 85, 71, 84, 69, 83,
67, 82, 67, 80, 65, 79, 63, 78, 61, 76, 61, 74, 60, 74, 57, 72, 55, 71, 54, 69,
52, 67, 51, 66, 49, 64, 47, 63, 45, 61, 44, 60, 42, 59, 40, 57, 38, 56, 37, 54,
35, 53, 33, 51, 31, 49, 29, 47, 27, 46, 26, 44, 23, 42, 21, 41, 20, 39, 18, 37,
16, 36, 14, 33, 12, 32, 10, 30, 9, 28, 7, 26, 5, 25, 3, 22, 1, 20, -1, 18, -2,
17, -4, 14, -6, 12, -8, 10, -10, 8, -13, 6, -14, 4, -16, 2, -18, -1, -19, -2,
-21, -4, -23, -5, -24, -8, -27, -10, -28, -11, -29, -14, -31, -16, -32, -17,
-34, -19, -35, -21, -37, -23, -38, -25, -39, -27, -41, -28, -43, -30, -44, -32,
-46, -33, -47, -35, -48, -37, -50, -39, -51, -40, -53, -42, -55, -44, -56, -45,
-57, -47, -58, -48, -60, -50, -62, -51, -63, -53, -64, -54, -66, -56, -68, -58,
-69, -59, -70, -60, -72, -62, -74, -62, -74, -64, -76, -66, -77, -67, -80, -68,
-81, -69, -82, -71, -83, -71, -85, -73, -87, -73, -87, -74, -89, -76, -91, -77,
-92, -77, -93, -78, -95, -79, -96, -79, -98, -81, -99, -82, -99, -82, -101, -83,
-103, -84, -103, -85, -104, -86, -105, -87, -107, -88, -107, -87, -109, -89,
-109, -89, -111, -90, -111, -90, -113, -91, -112, -91, -113, -92, -113, -92,
-115, -93, -115, -94, -116, -94, -115, -95, -117, -95, -117, -95, -117, -95,
-118, -96, -119, -97, -119, -96, -118, -97, -118, -97, -119, -98, -118, -97,
-119, -99, -119, -99, -118, -99, -119, -99, -118, -99, -119, -100, -118, -100,
-118, -100, -118, -101, -117, -101, -117, -102, -117, -101, -116, -102, -116,
-102, -115, -102, -115, -102, -114, -102, -114, -103, -113, -103, -112, -103,
-111, -103, -111, -104, -110, -104, -109, -104, -108, -104, -107, -105, -107,
-106, -106, -105, -104, -106, -104, -106, -103, -106, -102, -106, -101, -105,
-101, -107, -100, -107, -100, -107, -98, -107, -97, -108, -96, -109, -96, -109,
-95, -109, -95, -109, -94, -109, -94, -110, -92, -110, -92, -111, -92, -111,
-91, -110, -91, -112, -90, -111, -90, -112, -89, -112, -88, -112, -89, -112,
-88, -113, -87, -113, -87, -113, -87, -113, -87, -112, -87, -113, -86, -114,
-87, -113, -87, -113, -85, -114, -87, -113, -86, -114, -86, -113, -86, -114,
-86, -113, -86, -113, -85, -112, -86, -112, -85, -113, -86, -112, -85, -112,
-85, -112, -87, -112, -87, -112, -87, -112, -88, -110, -88, -110, -88, -111,
-88, -110, -89, -110, -88, -110, -89, -111, -90, -110, -90, -110, -90, -110,
-91, -110, -91, -108, -92, -109, -92, -109, -92, -108, -92, -108, -93, -109,
-93, -108, -94, -108, -94, -107, -95, -107, -95, -108, -95, -107, -95, -107,
-95, -107, -96, -107, -97, -106, -97, -107, -98, -106, -97, -106, -98, -106,
-97, -106, -97, -105, -98, -105, -98, -105, -97, -106, -98, -105, -97, -104,
-97, -104, -97, -104, -97, -104, -96, -103, -96, -103, -96, -102, -94, -102,
-95, -101, -94, -101, -93, -99, -93, -100, -92, -98, -91, -98, -90, -96, -89,
-95, -87, -95, -85, -94, -85, -93, -83, -92, -82, -90, -79, -89, -78, -88, -76,
-86, -75, -84, -73, -82, -70, -81, -67, -80, -66, -78, -64, -75, -61, -74, -58,
-71, -56, -70, -52, -67, -49, -64, -47, -62, -43, -59, -40, -57, -36, -54, -34,
-50, -30, -48, -27, -44, -23, -40, -19, -36, -14, -34, -12, -29, -6, -26, -3,
-21, 3, -16, 7, -12, 12, -9, 14, -4, 21, -1, 19, };