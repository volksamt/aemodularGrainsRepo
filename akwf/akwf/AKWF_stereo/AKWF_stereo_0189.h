#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0189

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, -5, 5, -4, 7, 1, 12, 3, 15, 6, 17,
9, 20, 13, 23, 16, 26, 19, 29, 22, 32, 26, 35, 29, 38, 31, 40, 34, 43, 37, 46,
40, 47, 42, 51, 45, 52, 47, 55, 50, 56, 53, 59, 54, 62, 56, 64, 58, 66, 61, 67,
63, 70, 65, 71, 67, 72, 69, 74, 69, 76, 71, 77, 73, 79, 74, 79, 75, 80, 77, 82,
77, 84, 79, 84, 79, 85, 80, 85, 81, 86, 81, 87, 82, 87, 82, 88, 82, 88, 83, 89,
83, 88, 83, 88, 83, 88, 83, 89, 83, 89, 82, 88, 81, 89, 81, 88, 81, 87, 80, 87,
79, 87, 78, 85, 77, 85, 75, 84, 75, 83, 73, 83, 72, 82, 71, 80, 69, 79, 68, 79,
67, 77, 65, 76, 63, 75, 61, 73, 61, 72, 57, 70, 56, 69, 54, 68, 52, 67, 49, 66,
48, 63, 46, 62, 45, 60, 41, 59, 39, 57, 38, 55, 36, 54, 34, 52, 31, 50, 29, 49,
26, 47, 25, 46, 22, 43, 20, 42, 18, 41, 15, 38, 14, 37, 12, 36, 9, 35, 7, 33, 6,
32, 4, 30, 1, 29, 0, 27, -2, 26, -3, 25, -5, 24, -8, 23, -9, 22, -11, 20, -12,
20, -12, 19, -14, 18, -15, 17, -16, 16, -17, 16, -19, 15, -19, 14, -20, 14, -21,
14, -20, 14, -21, 13, -23, 13, -22, 13, -22, 13, -23, 13, -23, 13, -22, 14, -22,
14, -23, 14, -22, 15, -21, 16, -21, 17, -21, 17, -19, 18, -19, 18, -17, 19, -16,
21, -16, 21, -14, 23, -13, 23, -12, 25, -10, 26, -9, 28, -7, 28, -5, 30, -4, 33,
-1, 34, 0, 35, 2, 37, 4, 38, 6, 40, 8, 41, 10, 44, 13, 46, 15, 47, 18, 49, 20,
51, 22, 53, 25, 55, 28, 57, 30, 60, 33, 61, 35, 63, 38, 65, 41, 67, 44, 69, 46,
71, 49, 72, 51, 76, 54, 78, 57, 78, 58, 81, 61, 83, 64, 85, 67, 86, 70, 89, 71,
90, 75, 91, 76, 93, 79, 95, 81, 96, 84, 98, 86, 99, 87, 101, 91, 102, 93, 104,
94, 104, 96, 106, 98, 107, 100, 108, 101, 109, 103, 110, 103, 111, 105, 112,
106, 112, 109, 112, 109, 113, 111, 115, 111, 115, 112, 115, 113, 115, 114, 115,
114, 116, 115, 115, 116, 116, 116, 115, 117, 114, 117, 114, 117, 114, 117, 113,
116, 113, 116, 112, 117, 112, 116, 111, 115, 109, 115, 109, 114, 107, 113, 107,
113, 105, 111, 104, 110, 103, 109, 102, 108, 99, 107, 98, 105, 96, 104, 94, 102,
92, 101, 91, 98, 88, 97, 86, 94, 83, 92, 82, 90, 78, 88, 77, 86, 73, 83, 70, 81,
68, 78, 66, 76, 63, 73, 60, 70, 58, 67, 55, 65, 52, 61, 48, 58, 45, 54, 42, 52,
38, 48, 36, 44, 32, 42, 28, 39, 26, 35, 22, 31, 19, 28, 16, 25, 13, 22, 9, 18,
6, 15, 2, 11, -1, 7, -5, 4, -8, 0, -10, -3, -14, -6, -17, -10, -20, -13, -23,
-16, -26, -19, -29, -23, -31, -25, -34, -28, -37, -32, -40, -33, -43, -37, -45,
-39, -47, -42, -50, -45, -52, -47, -55, -49, -57, -53, -60, -54, -61, -57, -64,
-60, -66, -61, -68, -63, -70, -65, -72, -67, -73, -70, -75, -70, -76, -72, -78,
-75, -79, -75, -81, -76, -82, -78, -83, -79, -84, -80, -85, -81, -86, -82, -87,
-82, -87, -83, -88, -84, -89, -84, -89, -85, -90, -86, -90, -85, -90, -85, -91,
-85, -90, -85, -91, -85, -91, -85, -90, -85, -90, -85, -90, -83, -90, -83, -89,
-82, -89, -81, -88, -80, -87, -79, -87, -79, -86, -77, -86, -76, -85, -75, -83,
-73, -83, -72, -81, -70, -81, -70, -80, -67, -79, -65, -78, -64, -75, -63, -74,
-61, -73, -58, -72, -57, -71, -54, -69, -52, -67, -50, -65, -48, -64, -45, -63,
-44, -60, -41, -59, -40, -57, -37, -56, -35, -54, -33, -53, -31, -50, -29, -49,
-26, -47, -24, -45, -21, -44, -20, -43, -17, -41, -16, -40, -13, -38, -12, -36,
-9, -35, -8, -33, -5, -33, -3, -31, -2, -29, 0, -28, 2, -27, 4, -25, 5, -24, 7,
-23, 8, -22, 10, -21, 11, -20, 11, -20, 12, -20, 14, -18, 15, -18, 16, -17, 18,
-17, 18, -16, 19, -15, 19, -16, 20, -15, 20, -15, 20, -15, 20, -15, 20, -16, 20,
-15, 19, -15, 20, -16, 20, -17, 19, -17, 19, -17, 18, -17, 18, -19, 17, -19, 17,
-20, 15, -22, 15, -22, 13, -24, 12, -24, 10, -26, 10, -27, 7, -29, 6, -30, 5,
-31, 3, -33, 2, -34, -1, -36, -2, -37, -5, -39, -7, -41, -9, -42, -11, -44, -14,
-46, -16, -48, -18, -50, -20, -52, -22, -54, -26, -55, -28, -58, -31, -59, -33,
-62, -36, -63, -38, -66, -41, -68, -42, -69, -46, -72, -49, -73, -52, -76, -53,
-77, -56, -80, -59, -81, -61, -84, -64, -85, -67, -87, -69, -89, -72, -91, -74,
-92, -77, -94, -79, -95, -81, -97, -84, -98, -86, -100, -88, -102, -91, -103,
-93, -104, -94, -105, -96, -107, -98, -108, -101, -109, -102, -110, -104, -111,
-105, -112, -107, -113, -108, -114, -109, -115, -111, -115, -112, -116, -112,
-116, -114, -116, -115, -117, -116, -118, -116, -117, -117, -117, -118, -117,
-118, -117, -118, -118, -118, -116, -119, -117, -120, -116, -119, -115, -119,
-115, -119, -115, -118, -113, -118, -114, -117, -112, -118, -111, -115, -110,
-116, -108, -114, -107, -114, -106, -113, -104, -112, -102, -110, -101, -109,
-100, -108, -97, -106, -96, -104, -94, -102, -92, -101, -90, -99, -87, -97, -85,
-95, -84, -93, -81, -90, -79, -88, -76, -85, -72, -83, -70, -81, -67, -77, -65,
-75, -62, -72, -59, -69, -55, -66, -52, -63, -50, -60, -47, -57, -44, -54, -40,
-50, -37, -47, -33, -44, -30, -40, -27, -36, -24, -33, -20, -29, -17, -26, -15,
-23, -11, -20, -7, -16, -4, -13, -1, -9, };