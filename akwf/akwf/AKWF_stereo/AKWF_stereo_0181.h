#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0181

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 6, 2, 9, -1, 12, -3, 15, -6, 19,
-8, 21, -11, 25, -12, 28, -15, 32, -16, 36, -18, 38, -20, 42, -22, 45, -23, 48,
-25, 51, -27, 53, -28, 56, -30, 59, -32, 62, -32, 64, -34, 66, -36, 69, -37, 71,
-38, 73, -40, 74, -41, 75, -42, 78, -43, 80, -43, 80, -45, 82, -46, 83, -47, 84,
-48, 85, -48, 87, -49, 88, -49, 89, -50, 90, -50, 92, -50, 93, -51, 93, -50, 95,
-50, 95, -49, 96, -49, 97, -49, 98, -48, 99, -47, 100, -46, 101, -46, 102, -44,
103, -43, 103, -41, 105, -40, 105, -38, 107, -37, 106, -34, 107, -32, 107, -30,
108, -28, 109, -26, 109, -23, 110, -21, 111, -18, 110, -16, 111, -13, 111, -11,
112, -8, 112, -5, 111, -4, 112, -2, 112, -1, 111, 2, 111, 4, 112, 5, 112, 7,
111, 9, 111, 10, 111, 11, 111, 12, 110, 13, 110, 13, 110, 14, 108, 14, 108, 14,
108, 14, 107, 14, 106, 14, 105, 13, 104, 14, 102, 12, 101, 13, 100, 12, 99, 11,
97, 10, 95, 10, 95, 10, 92, 9, 91, 7, 88, 6, 86, 6, 84, 5, 81, 4, 79, 3, 76, 2,
73, 2, 71, 1, 68, 1, 65, 0, 62, 1, 59, -1, 56, -1, 53, -2, 48, -1, 44, -1, 41,
-2, 37, -2, 32, -2, 29, -1, 26, -1, 21, -1, 16, 0, 12, 0, 9, 1, 4, 2, 0, 3, -4,
4, -8, 5, -13, 6, -17, 6, -22, 9, -25, 9, -29, 11, -33, 12, -37, 13, -41, 14,
-46, 16, -50, 17, -53, 18, -57, 19, -62, 21, -64, 21, -68, 22, -72, 23, -75, 24,
-79, 24, -82, 24, -85, 25, -89, 25, -92, 25, -94, 25, -97, 24, -100, 24, -102,
24, -104, 23, -108, 21, -110, 21, -112, 21, -113, 20, -116, 19, -115, 18, -115,
16, -115, 16, -115, 14, -115, 15, -115, 13, -116, 13, -115, 12, -115, 12, -115,
11, -116, 11, -115, 10, -116, 9, -115, 10, -115, 9, -115, 9, -115, 9, -115, 9,
-116, 9, -115, 10, -116, 10, -115, 11, -115, 10, -115, 12, -115, 11, -116, 12,
-115, 14, -116, 15, -116, 15, -114, 16, -115, 16, -114, 18, -112, 18, -110, 20,
-108, 21, -106, 22, -104, 23, -101, 24, -99, 26, -97, 27, -94, 27, -91, 29, -89,
31, -87, 31, -83, 34, -81, 34, -78, 35, -75, 36, -72, 37, -68, 39, -66, 41, -62,
43, -59, 45, -55, 46, -52, 47, -48, 50, -44, 51, -41, 53, -36, 55, -32, 56, -28,
60, -24, 62, -20, 64, -15, 65, -11, 68, -7, 71, -2, 72, 2, 75, 6, 77, 12, 79,
15, 81, 20, 84, 24, 86, 28, 88, 32, 90, 37, 91, 41, 94, 44, 97, 49, 98, 53, 99,
57, 101, 60, 103, 64, 104, 66, 105, 70, 107, 73, 108, 76, 109, 79, 109, 82, 110,
85, 109, 86, 110, 89, 110, 92, 110, 93, 109, 96, 108, 98, 109, 100, 108, 101,
106, 103, 105, 104, 104, 106, 102, 107, 100, 108, 99, 109, 97, 110, 94, 111, 92,
111, 90, 112, 88, 113, 84, 112, 81, 113, 79, 113, 77, 113, 73, 113, 70, 114, 68,
113, 64, 114, 61, 113, 58, 113, 55, 113, 51, 111, 48, 111, 45, 110, 42, 111, 38,
110, 35, 109, 32, 108, 28, 107, 25, 105, 22, 105, 19, 103, 16, 101, 13, 101, 10,
99, 6, 98, 5, 96, 1, 95, -2, 92, -5, 91, -9, 89, -11, 87, -14, 85, -17, 84, -19,
82, -23, 80, -25, 78, -27, 76, -31, 74, -34, 72, -36, 70, -39, 67, -42, 66, -45,
63, -47, 61, -50, 59, -54, 57, -55, 55, -58, 52, -62, 51, -65, 47, -67, 45, -70,
44, -73, 40, -76, 38, -77, 36, -80, 33, -82, 31, -84, 29, -88, 26, -89, 25, -91,
21, -93, 19, -96, 16, -98, 15, -101, 11, -102, 9, -103, 7, -105, 4, -107, 3,
-109, -1, -110, -3, -111, -5, -113, -9, -113, -12, -115, -15, -116, -17, -116,
-20, -117, -23, -118, -24, -118, -27, -119, -30, -118, -33, -118, -35, -120,
-38, -119, -40, -118, -43, -118, -46, -119, -48, -118, -50, -117, -52, -117,
-54, -116, -56, -115, -58, -114, -61, -113, -61, -111, -63, -111, -65, -109,
-66, -108, -67, -106, -68, -104, -69, -103, -70, -101, -71, -99, -71, -98, -72,
-96, -72, -94, -72, -92, -73, -90, -73, -89, -73, -86, -72, -84, -73, -82, -73,
-80, -73, -78, -73, -75, -71, -72, -71, -70, -71, -68, -70, -64, -70, -61, -69,
-59, -68, -56, -68, -53, -68, -50, -67, -47, -65, -43, -65, -40, -64, -38, -64,
-34, -64, -30, -63, -28, -61, -25, -61, -21, -60, -19, -60, -15, -60, -12, -60,
-10, -61, -7, -60, -4, -60, -2, -60, 0, -59, 3, -60, 5, -60, 6, -60, 8, -59, 10,
-59, 12, -60, 12, -61, 14, -61, 16, -60, 17, -60, 18, -61, 18, -61, 19, -61, 20,
-61, 21, -61, 21, -61, 21, -61, 22, -61, 22, -61, 23, -62, 23, -62, 24, -61, 24,
-62, 24, -61, 25, -62, 25, -61, 25, -60, 26, -59, 26, -59, 27, -58, 27, -58, 27,
-57, 28, -57, 29, -57, 30, -56, 30, -56, 31, -54, 31, -55, 32, -53, 34, -53, 35,
-52, 36, -52, 36, -51, 38, -50, 39, -50, 40, -51, 40, -50, 42, -50, 43, -50, 45,
-49, 46, -49, 47, -49, 49, -48, 50, -48, 51, -48, 52, -48, 53, -48, 55, -48, 56,
-47, 57, -48, 58, -48, 59, -48, 60, -48, 60, -47, 62, -47, 62, -46, 63, -48, 64,
-46, 65, -47, 65, -46, 65, -46, 66, -46, 65, -46, 65, -46, 65, -45, 64, -46, 64,
-44, 62, -44, 62, -43, 61, -43, 59, -43, 57, -42, 56, -40, 54, -39, 53, -39, 50,
-37, 48, -36, 45, -34, 42, -32, 40, -30, 37, -28, 35, -26, 32, -24, 29, -22, 26,
-19, 23, -16, 20, -13, 17, -10, 14, -7, 12, -4, 8, -1, 5, };