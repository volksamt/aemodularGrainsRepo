#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0107

const PROGMEM int8_t DATA[DATA_LENGTH] = {17, 57, 46, 108, 46, 98, 50, 93, 51,
82, 54, 83, 57, 89, 61, 99, 62, 100, 62, 98, 63, 96, 61, 95, 53, 79, 31, 42, 21,
33, 22, 44, 21, 54, 20, 58, 17, 51, 15, 44, 16, 40, 18, 44, 19, 45, 20, 45, 21,
42, 23, 46, 25, 49, 28, 50, 30, 51, 30, 50, 33, 51, 35, 54, 36, 55, 37, 54, 39,
54, 41, 55, 43, 57, 44, 56, 39, 46, 43, 51, 77, 97, 89, 111, 85, 105, 89, 107,
89, 106, 92, 107, 92, 107, 93, 107, 93, 106, 95, 106, 96, 105, 98, 105, 98, 105,
99, 104, 101, 103, 102, 103, 102, 102, 104, 102, 105, 101, 105, 98, 104, 97,
106, 96, 107, 96, 107, 96, 108, 96, 108, 95, 110, 95, 111, 95, 112, 96, 112, 95,
112, 96, 113, 95, 114, 96, 114, 96, 114, 96, 115, 96, 115, 95, 117, 96, 115, 95,
113, 92, 113, 91, 113, 91, 114, 92, 114, 94, 114, 94, 113, 94, 115, 95, 116, 95,
114, 95, 114, 96, 115, 96, 115, 97, 116, 98, 116, 99, 116, 99, 117, 101, 116,
101, 116, 103, 115, 101, 112, 99, 112, 99, 113, 101, 113, 103, 113, 104, 114,
106, 114, 107, 115, 108, 115, 109, 115, 110, 115, 111, 116, 113, 117, 113, 117,
114, 118, 115, 117, 114, 118, 116, 120, 115, 118, 115, 113, 108, 110, 103, 111,
104, 110, 105, 111, 105, 110, 106, 108, 105, 111, 106, 109, 105, 109, 106, 110,
105, 109, 106, 110, 106, 109, 106, 110, 106, 109, 107, 108, 106, 108, 106, 108,
107, 104, 103, 98, 96, 95, 92, 96, 93, 94, 93, 93, 93, 93, 92, 92, 92, 90, 91,
91, 91, 89, 90, 88, 90, 88, 90, 86, 90, 86, 89, 85, 90, 84, 88, 83, 88, 82, 88,
82, 88, 76, 79, 71, 73, 70, 73, 69, 72, 68, 71, 69, 71, 67, 70, 67, 69, 67, 67,
66, 67, 66, 66, 65, 65, 65, 64, 64, 63, 63, 63, 63, 62, 62, 61, 62, 60, 62, 60,
60, 57, 55, 50, 52, 47, 52, 46, 52, 45, 51, 45, 51, 45, 49, 44, 49, 44, 49, 43,
48, 43, 47, 43, 46, 44, 45, 43, 45, 42, 44, 42, 44, 43, 42, 42, 43, 42, 42, 42,
39, 37, 36, 33, 35, 32, 34, 32, 33, 32, 32, 30, 33, 30, 32, 30, 32, 29, 32, 29,
31, 28, 30, 27, 30, 26, 30, 26, 29, 25, 29, 24, 28, 24, 28, 23, 28, 23, 27, 21,
25, 19, 24, 17, 24, 17, 23, 14, 23, 15, 22, 13, 22, 13, 21, 11, 20, 11, 19, 10,
19, 9, 17, 7, 17, 6, 16, 5, 15, 2, 15, 3, 13, -1, 15, 0, 10, -7, 15, 1, -14,
-47, -11, -42, 0, -24, -22, -63, -18, -57, -14, -53, -13, -54, -18, -64, -16,
-64, -17, -69, -18, -71, -20, -74, -20, -76, -22, -78, -24, -79, -25, -80, -26,
-81, -28, -82, -30, -83, -31, -85, -32, -86, -33, -89, -35, -92, -35, -92, -37,
-94, -37, -95, -38, -97, -39, -97, -40, -98, -42, -97, -43, -99, -44, -98, -45,
-100, -45, -100, -47, -100, -47, -102, -48, -103, -49, -104, -50, -105, -51,
-107, -52, -106, -53, -107, -54, -108, -55, -109, -57, -109, -57, -110, -58,
-111, -59, -112, -61, -113, -62, -113, -63, -114, -64, -115, -65, -115, -66,
-116, -67, -115, -68, -116, -69, -116, -69, -115, -71, -115, -71, -114, -73,
-115, -74, -115, -76, -113, -75, -112, -77, -111, -77, -110, -77, -110, -79,
-108, -80, -106, -80, -106, -80, -104, -81, -102, -82, -100, -82, -99, -82, -98,
-83, -97, -85, -94, -84, -93, -84, -91, -86, -90, -86, -90, -85, -88, -86, -86,
-87, -85, -88, -84, -87, -84, -88, -83, -89, -81, -88, -80, -89, -79, -90, -79,
-90, -78, -89, -77, -89, -77, -89, -76, -88, -77, -89, -77, -89, -77, -82, -66,
-65, -44, -59, -37, -61, -39, -60, -39, -60, -40, -61, -39, -60, -40, -61, -40,
-61, -41, -61, -41, -61, -41, -60, -41, -61, -41, -61, -41, -60, -42, -61, -41,
-61, -42, -60, -42, -61, -45, -75, -63, -90, -83, -90, -83, -90, -83, -89, -84,
-89, -84, -89, -83, -89, -84, -89, -84, -88, -83, -88, -83, -88, -84, -88, -84,
-87, -84, -87, -85, -86, -84, -86, -85, -86, -86, -86, -85, -85, -86, -86, -86,
-85, -87, -84, -86, -84, -87, -83, -87, -83, -87, -82, -87, -82, -87, -82, -86,
-82, -87, -81, -86, -81, -86, -81, -85, -80, -84, -80, -84, -80, -84, -79, -84,
-80, -83, -80, -83, -80, -82, -79, -82, -79, -81, -79, -81, -79, -80, -80, -79,
-80, -79, -80, -79, -80, -77, -80, -78, -80, -76, -81, -76, -81, -75, -80, -74,
-80, -74, -81, -73, -81, -72, -81, -72, -81, -71, -81, -70, -81, -69, -81, -68,
-81, -67, -82, -66, -82, -64, -81, -63, -81, -61, -80, -60, -80, -58, -80, -57,
-80, -56, -80, -55, -79, -54, -79, -52, -80, -52, -78, -50, -79, -50, -78, -49,
-78, -47, -78, -47, -80, -46, -78, -46, -80, -45, -89, -43, -80, -44, -83, -43,
-86, -43, -83, -43, -82, -43, -81, -43, -80, -42, -79, -43, -80, -42, -79, -41,
-78, -41, -77, -42, -78, -40, -78, -41, -78, -40, -77, -39, -77, -38, -77, -39,
-75, -38, -76, -37, -75, -36, -75, -35, -74, -35, -72, -33, -73, -33, -71, -32,
-71, -31, -70, -30, -68, -30, -68, -28, -67, -27, -65, -25, -65, -25, -64, -23,
-63, -22, -62, -21, -61, -20, -60, -20, -58, -18, -58, -17, -57, -17, -55, -16,
-54, -16, -53, -15, -51, -15, -50, -14, -49, -13, -47, -13, -46, -13, -44, -13,
-43, -12, -42, -12, -41, -11, -39, -11, -38, -10, -37, -10, -35, -9, -34, -8,
-33, -7, -32, -6, -31, -6, -30, -5, -28, -3, -28, -1, -26, -1, -25, 1, -24, 2,
-23, 5, -22, 3, -21, 8, -20, 4, -19, 7, -17, 9, -15, 13, -5, 20, };