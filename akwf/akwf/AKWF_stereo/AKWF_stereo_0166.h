#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0166

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 1, 7, 2, 7, 3, 8, 4, 9, 5, 10,
6, 11, 7, 11, 9, 12, 9, 14, 12, 14, 12, 16, 14, 15, 15, 18, 18, 18, 18, 19, 20,
18, 22, 18, 23, 20, 24, 21, 26, 22, 25, 23, 27, 25, 28, 26, 28, 29, 30, 29, 29,
44, 31, 62, 32, 63, 33, 68, 32, 69, 33, 73, 32, 74, 31, 77, 31, 79, 31, 79, 32,
81, 32, 83, 33, 85, 35, 86, 35, 87, 36, 89, 36, 91, 37, 91, 37, 93, 37, 94, 37,
95, 38, 96, 38, 97, 37, 98, 36, 99, 36, 99, 36, 100, 36, 101, 35, 102, 34, 102,
35, 103, 35, 104, 35, 105, 35, 106, 35, 107, 35, 107, 35, 107, 35, 108, 36, 109,
36, 109, 35, 111, 35, 110, 35, 111, 34, 111, 34, 111, 34, 112, 35, 110, 35, 111,
36, 111, 36, 111, 37, 111, 37, 110, 39, 111, 37, 111, 38, 111, 34, 111, 16, 111,
13, 111, 12, 111, 10, 111, 9, 111, 8, 112, 8, 111, 6, 111, 7, 111, 5, 112, 5,
111, 4, 111, 6, 111, 7, 112, 7, 112, 7, 112, 8, 111, 9, 112, 9, 112, 10, 112,
11, 111, 12, 111, 12, 112, 14, 111, 15, 111, 17, 110, 18, 111, 41, 110, 54, 110,
54, 110, 59, 107, 60, 107, 62, 107, 63, 105, 65, 105, 67, 104, 68, 102, 68, 101,
70, 101, 70, 100, 72, 100, 72, 98, 73, 97, 75, 97, 75, 97, 76, 96, 77, 97, 78,
95, 79, 95, 81, 94, 80, 94, 82, 94, 82, 94, 83, 94, 83, 92, 85, 92, 84, 91, 85,
90, 87, 91, 87, 90, 87, 90, 88, 89, 89, 89, 89, 90, 89, 91, 89, 92, 91, 91, 91,
91, 91, 91, 92, 91, 93, 91, 93, 91, 93, 91, 93, 91, 94, 91, 93, 91, 94, 90, 95,
91, 95, 90, 96, 90, 96, 90, 96, 88, 97, 88, 96, 86, 96, 83, 97, 80, 96, 79, 97,
78, 96, 76, 98, 75, 97, 75, 98, 74, 98, 73, 98, 73, 98, 73, 98, 73, 99, 73, 100,
72, 100, 72, 101, 72, 102, 72, 102, 72, 103, 72, 102, 71, 102, 71, 103, 70, 103,
70, 103, 70, 103, 71, 103, 70, 104, 70, 105, 71, 106, 69, 106, 68, 106, 68, 105,
68, 105, 67, 106, 68, 106, 67, 105, 67, 106, 68, 105, 70, 104, 68, 103, 77, 102,
92, 101, 92, 100, 94, 99, 95, 98, 96, 97, 97, 97, 97, 97, 99, 96, 99, 96, 100,
94, 101, 95, 102, 94, 103, 94, 103, 93, 102, 92, 101, 91, 100, 91, 100, 89, 98,
89, 98, 89, 97, 91, 97, 90, 95, 90, 95, 89, 93, 89, 93, 88, 92, 86, 89, 85, 88,
82, 84, 81, 83, 48, 51, 34, 36, 33, 36, 27, 30, 26, 29, 22, 24, 20, 22, 16, 19,
15, 16, 12, 14, 10, 12, 8, 10, 6, 9, 4, 7, 3, 5, 1, 3, 0, 1, -2, 0, -3, -1, -4,
-4, -6, -5, -7, -6, -7, -8, -10, -9, -11, -10, -12, -12, -12, -12, -13, -12,
-14, -13, -15, -13, -16, -14, -17, -14, -18, -16, -19, -16, -20, -18, -20, -18,
-22, -19, -24, -20, -24, -21, -26, -22, -28, -24, -29, -25, -30, -27, -31, -28,
-30, -30, -31, -31, -30, -32, -31, -33, -30, -35, -30, -37, -31, -39, -31, -41,
-32, -44, -32, -67, -32, -75, -32, -77, -32, -81, -32, -82, -32, -85, -33, -86,
-34, -89, -33, -90, -32, -92, -34, -93, -34, -95, -35, -97, -35, -98, -37, -99,
-37, -100, -38, -102, -38, -104, -38, -104, -38, -105, -39, -105, -39, -106,
-40, -107, -40, -109, -40, -109, -40, -110, -40, -111, -39, -111, -40, -111,
-40, -111, -39, -112, -40, -112, -40, -113, -39, -113, -39, -115, -39, -113,
-38, -114, -38, -115, -37, -115, -35, -116, -20, -115, -11, -117, -11, -117, -9,
-117, -8, -117, -6, -117, -6, -118, -5, -118, -6, -118, -6, -118, -6, -118, -7,
-118, -7, -119, -7, -119, -8, -119, -7, -118, -7, -119, -8, -119, -8, -119, -8,
-119, -7, -119, -9, -119, -9, -120, -8, -120, -9, -118, -9, -119, -10, -119,
-10, -118, -13, -118, -14, -118, -15, -116, -16, -116, -16, -115, -17, -114,
-19, -114, -19, -113, -20, -111, -19, -110, -22, -109, -22, -108, -24, -107,
-25, -107, -34, -106, -59, -105, -62, -105, -65, -105, -68, -104, -70, -103,
-72, -103, -74, -103, -76, -102, -77, -102, -80, -101, -81, -100, -82, -100,
-84, -99, -85, -98, -85, -97, -88, -97, -88, -96, -90, -96, -90, -96, -92, -95,
-93, -95, -93, -94, -94, -93, -96, -93, -95, -94, -97, -93, -97, -93, -98, -93,
-98, -92, -99, -92, -99, -92, -101, -91, -100, -90, -101, -91, -102, -90, -102,
-91, -103, -91, -103, -91, -103, -90, -103, -89, -104, -87, -104, -85, -104,
-83, -105, -81, -105, -79, -105, -78, -105, -77, -105, -77, -106, -76, -106,
-74, -106, -74, -105, -73, -106, -73, -106, -72, -106, -71, -107, -72, -107,
-71, -107, -70, -108, -70, -108, -70, -107, -69, -107, -69, -106, -69, -107,
-68, -107, -68, -107, -68, -107, -68, -107, -69, -107, -67, -108, -68, -108,
-67, -110, -67, -110, -66, -110, -66, -110, -65, -110, -65, -110, -65, -110,
-64, -109, -63, -109, -64, -108, -63, -107, -63, -107, -63, -107, -64, -105,
-62, -106, -63, -105, -63, -105, -63, -104, -63, -104, -63, -104, -62, -102,
-63, -102, -63, -102, -62, -102, -65, -102, -64, -101, -80, -100, -87, -100,
-86, -99, -87, -97, -86, -96, -87, -96, -87, -96, -88, -94, -86, -93, -87, -91,
-86, -91, -87, -89, -85, -88, -86, -83, -82, -85, -84, -60, -59, -39, -37, -38,
-37, -32, -31, -31, -30, -28, -25, -28, -23, -26, -22, -25, -20, -23, -16, -21,
-15, -20, -12, -18, -12, -17, -10, -14, -8, -14, -6, -12, -5, -11, -4, -10, -3,
-8, -3, -7, -1, -6, -1, -5, 0, -3, 2, -3, 3, -1, 3, -1, 4, };