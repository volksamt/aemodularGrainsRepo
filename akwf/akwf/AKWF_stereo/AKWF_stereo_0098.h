#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0098

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, -28, 3, -35, 5, -31, 7, -31, 9,
-30, 11, -30, 13, -28, 15, -29, 17, -27, 19, -28, 22, -26, 22, -26, 25, -25, 27,
-26, 29, -25, 30, -25, 32, -24, 33, -25, 36, -24, 37, -24, 40, -23, 42, -23, 43,
-22, 45, -22, 47, -22, 49, -22, 50, -21, 53, -20, 53, -22, 56, -21, 57, -20, 59,
-20, 61, -20, 62, -20, 64, -20, 66, -18, 66, -19, 68, -18, 68, -18, 71, -17, 72,
-17, 73, -17, 74, -16, 75, -16, 76, -16, 77, -15, 77, -15, 78, -15, 79, -14, 79,
-14, 80, -13, 81, -13, 81, -13, 82, -12, 82, -12, 81, -12, 83, -11, 82, -11, 83,
-11, 83, -9, 84, -8, 83, -8, 83, -7, 83, -7, 83, -4, 83, -4, 82, -3, 83, -1, 82,
-1, 83, 1, 81, 1, 81, 3, 81, 5, 81, 7, 80, 8, 79, 9, 79, 11, 78, 13, 76, 14, 77,
14, 76, 17, 75, 19, 75, 19, 74, 21, 73, 23, 73, 23, 71, 25, 70, 27, 69, 28, 67,
29, 67, 31, 65, 32, 64, 34, 63, 35, 61, 36, 60, 38, 59, 39, 58, 40, 56, 41, 55,
43, 53, 42, 52, 44, 51, 44, 50, 46, 48, 46, 46, 47, 46, 47, 43, 47, 42, 48, 41,
49, 38, 49, 37, 48, 35, 49, 33, 49, 32, 49, 30, 48, 29, 48, 26, 48, 25, 47, 23,
47, 22, 45, 19, 46, 18, 43, 16, 42, 14, 42, 11, 40, 10, 40, 8, 38, 5, 36, 4, 35,
1, 33, 1, 31, -1, 30, -4, 28, -5, 26, -7, 24, -10, 21, -12, 20, -13, 16, -17,
14, -18, 12, -20, 9, -22, 6, -24, 3, -26, -1, -28, -4, -30, -5, -33, -9, -35,
-12, -37, -14, -39, -18, -41, -21, -44, -23, -46, -27, -48, -29, -51, -33, -53,
-36, -54, -38, -57, -42, -58, -45, -61, -48, -63, -51, -65, -54, -66, -56, -69,
-60, -71, -63, -72, -66, -74, -68, -76, -70, -78, -73, -80, -77, -81, -78, -83,
-80, -84, -83, -85, -86, -87, -88, -89, -90, -90, -91, -91, -94, -92, -94, -93,
-96, -94, -97, -95, -99, -96, -101, -97, -102, -98, -104, -100, -104, -99, -106,
-100, -107, -101, -107, -102, -107, -101, -109, -102, -109, -102, -109, -103,
-109, -103, -110, -103, -110, -103, -110, -103, -111, -103, -110, -103, -110,
-102, -109, -102, -109, -102, -110, -101, -109, -101, -109, -101, -109, -100,
-108, -99, -108, -98, -106, -97, -106, -97, -105, -96, -105, -95, -103, -94,
-103, -93, -102, -92, -101, -90, -99, -89, -98, -88, -98, -87, -96, -85, -94,
-85, -93, -83, -91, -82, -90, -79, -89, -78, -86, -77, -85, -74, -83, -74, -82,
-72, -80, -70, -77, -68, -75, -67, -73, -64, -71, -62, -68, -61, -67, -59, -64,
-57, -62, -56, -60, -53, -58, -51, -55, -49, -53, -47, -51, -45, -49, -42, -46,
-40, -44, -38, -42, -36, -39, -35, -36, -32, -34, -30, -31, -29, -28, -26, -27,
-24, -23, -22, -21, -21, -17, -18, -15, -16, -12, -15, -9, -13, -7, -11, -3,
-10, -1, -8, 2, -6, 5, -5, 8, -2, 11, -1, 14, 0, 17, 3, 20, 4, 22, 6, 26, 7, 29,
7, 32, 10, 35, 11, 36, 12, 40, 14, 42, 16, 44, 16, 47, 19, 49, 20, 52, 20, 54,
22, 56, 23, 59, 24, 62, 26, 64, 27, 67, 28, 69, 29, 71, 30, 73, 32, 76, 33, 78,
34, 81, 34, 83, 36, 86, 37, 88, 39, 90, 40, 91, 40, 94, 41, 96, 42, 98, 45, 99,
46, 102, 46, 104, 47, 106, 48, 107, 49, 108, 49, 110, 51, 111, 51, 112, 52, 114,
53, 115, 53, 115, 54, 117, 56, 117, 56, 118, 56, 118, 56, 118, 58, 119, 58, 119,
58, 118, 59, 119, 59, 119, 59, 118, 60, 118, 61, 119, 61, 119, 60, 118, 62, 118,
61, 117, 61, 116, 62, 115, 62, 115, 62, 114, 62, 112, 62, 111, 61, 110, 61, 108,
62, 107, 63, 104, 62, 103, 62, 101, 62, 99, 62, 98, 61, 95, 60, 92, 60, 91, 61,
89, 60, 85, 59, 84, 58, 81, 59, 79, 59, 77, 57, 74, 58, 70, 56, 68, 55, 65, 55,
64, 54, 61, 53, 59, 52, 56, 52, 54, 51, 51, 50, 49, 48, 47, 47, 45, 46, 42, 46,
40, 45, 37, 43, 36, 41, 33, 41, 30, 39, 28, 37, 25, 36, 24, 34, 22, 32, 19, 31,
18, 29, 15, 28, 12, 26, 10, 24, 9, 23, 6, 21, 5, 18, 2, 17, 0, 14, -1, 13, -4,
12, -6, 9, -7, 8, -9, 5, -11, 4, -13, 2, -14, 0, -15, -2, -18, -3, -19, -6, -20,
-8, -21, -10, -23, -12, -23, -13, -25, -15, -26, -17, -27, -18, -29, -20, -30,
-23, -31, -25, -31, -25, -32, -27, -34, -30, -35, -30, -36, -32, -37, -34, -37,
-36, -39, -37, -40, -39, -40, -40, -42, -42, -43, -43, -45, -45, -45, -46, -46,
-48, -47, -49, -49, -51, -50, -51, -50, -53, -53, -54, -53, -55, -53, -56, -54,
-57, -54, -58, -55, -59, -56, -60, -57, -60, -56, -61, -56, -62, -58, -62, -58,
-64, -57, -64, -58, -65, -59, -65, -60, -65, -60, -65, -59, -66, -60, -67, -61,
-67, -60, -67, -61, -67, -63, -66, -61, -68, -63, -68, -63, -68, -63, -68, -65,
-68, -65, -68, -65, -67, -65, -67, -65, -67, -66, -67, -67, -67, -67, -66, -66,
-66, -67, -65, -67, -64, -66, -63, -66, -63, -66, -63, -66, -62, -64, -61, -65,
-60, -64, -58, -62, -58, -63, -57, -62, -56, -62, -55, -61, -54, -60, -52, -59,
-51, -59, -50, -59, -49, -58, -48, -56, -46, -56, -44, -55, -43, -54, -42, -53,
-41, -52, -38, -52, -38, -51, -37, -50, -35, -50, -34, -49, -32, -49, -30, -47,
-28, -46, -26, -46, -26, -43, -23, -44, -22, -43, -21, -43, -18, -42, -17, -42,
-15, -39, -13, -41, -11, -38, -9, -38, -7, -36, -6, -37, -3, -34, -2, -36, 0,
-29, };