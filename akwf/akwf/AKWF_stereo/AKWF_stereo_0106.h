#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0106

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 2, 6, 5, 8, 6, 11, 7, 12, 10,
13, 11, 15, 12, 17, 15, 19, 15, 22, 17, 23, 19, 26, 21, 28, 23, 31, 26, 34, 27,
37, 29, 39, 32, 41, 33, 44, 35, 46, 37, 48, 39, 50, 41, 52, 42, 54, 44, 57, 45,
59, 48, 61, 49, 62, 49, 63, 52, 67, 53, 67, 54, 69, 55, 71, 56, 72, 56, 73, 58,
74, 58, 75, 59, 76, 59, 77, 60, 78, 60, 78, 60, 78, 59, 78, 60, 78, 60, 79, 61,
79, 60, 80, 60, 80, 61, 81, 60, 81, 61, 80, 60, 81, 61, 81, 61, 81, 62, 80, 61,
82, 61, 81, 61, 81, 62, 82, 62, 82, 61, 82, 62, 82, 62, 83, 63, 83, 62, 82, 62,
83, 63, 83, 63, 83, 63, 83, 62, 82, 62, 82, 63, 83, 62, 82, 62, 81, 63, 81, 62,
82, 63, 83, 64, 83, 66, 84, 67, 85, 69, 87, 71, 89, 73, 91, 73, 92, 75, 95, 76,
95, 78, 96, 79, 97, 80, 98, 81, 99, 83, 100, 83, 101, 84, 102, 85, 103, 86, 104,
87, 104, 88, 105, 89, 106, 90, 106, 90, 105, 90, 106, 90, 108, 91, 108, 91, 107,
92, 108, 93, 108, 93, 107, 92, 107, 93, 107, 92, 106, 92, 106, 92, 104, 92, 104,
91, 103, 90, 103, 90, 102, 90, 102, 89, 100, 89, 100, 89, 99, 88, 97, 87, 97,
87, 96, 87, 96, 87, 95, 87, 95, 86, 95, 87, 94, 87, 94, 87, 93, 88, 93, 87, 93,
88, 93, 88, 93, 88, 94, 89, 94, 89, 94, 90, 94, 90, 94, 91, 94, 92, 95, 92, 94,
91, 94, 92, 95, 92, 95, 92, 94, 92, 94, 92, 94, 93, 95, 93, 95, 94, 94, 94, 94,
94, 96, 95, 95, 95, 95, 96, 97, 97, 97, 98, 98, 99, 98, 100, 100, 100, 100, 102,
100, 103, 102, 103, 102, 104, 104, 106, 106, 106, 107, 107, 106, 109, 108, 110,
109, 110, 110, 111, 111, 113, 112, 114, 112, 114, 113, 115, 114, 115, 115, 115,
115, 116, 114, 115, 115, 115, 115, 114, 115, 115, 115, 113, 115, 113, 114, 113,
114, 113, 114, 112, 115, 113, 115, 112, 114, 111, 114, 110, 113, 110, 112, 109,
112, 109, 113, 108, 112, 108, 112, 107, 111, 106, 110, 105, 110, 105, 109, 104,
109, 102, 108, 101, 107, 101, 107, 99, 106, 99, 105, 98, 103, 96, 102, 95, 100,
93, 99, 92, 97, 90, 95, 89, 93, 86, 91, 85, 90, 83, 87, 81, 85, 79, 83, 77, 81,
74, 78, 72, 75, 70, 73, 67, 70, 65, 67, 63, 64, 61, 63, 59, 61, 57, 58, 55, 55,
53, 52, 51, 50, 48, 47, 46, 45, 44, 44, 43, 41, 41, 40, 39, 38, 38, 35, 36, 33,
34, 31, 32, 30, 30, 27, 28, 24, 26, 23, 25, 21, 22, 17, 20, 16, 18, 13, 15, 10,
13, 8, 11, 6, 9, 3, 7, 1, 5, -1, 2, -3, 0, -6, -2, -9, -5, -11, -7, -14, -9,
-16, -11, -18, -13, -21, -15, -23, -17, -26, -20, -28, -22, -31, -24, -33, -26,
-35, -28, -37, -30, -39, -31, -41, -33, -42, -34, -44, -35, -46, -38, -48, -39,
-50, -40, -51, -41, -52, -42, -54, -44, -56, -45, -58, -46, -59, -47, -60, -48,
-62, -49, -63, -50, -65, -50, -65, -51, -67, -52, -68, -53, -69, -54, -71, -55,
-72, -55, -73, -58, -75, -58, -77, -59, -77, -60, -79, -60, -80, -61, -81, -62,
-82, -63, -83, -64, -83, -63, -83, -63, -84, -63, -84, -63, -85, -63, -85, -63,
-84, -63, -85, -63, -85, -62, -85, -62, -85, -62, -84, -62, -84, -61, -84, -61,
-84, -61, -82, -61, -83, -60, -82, -60, -81, -60, -81, -59, -80, -60, -81, -59,
-80, -59, -80, -60, -80, -61, -79, -61, -80, -61, -80, -62, -79, -62, -79, -63,
-80, -64, -80, -64, -80, -64, -80, -66, -81, -66, -81, -67, -81, -67, -82, -68,
-82, -70, -84, -72, -85, -73, -86, -75, -88, -75, -90, -78, -92, -80, -94, -81,
-95, -83, -96, -86, -100, -87, -102, -88, -103, -89, -103, -90, -104, -90, -104,
-91, -104, -91, -105, -90, -104, -91, -104, -90, -104, -90, -104, -90, -104,
-91, -104, -91, -104, -91, -104, -90, -103, -91, -104, -91, -104, -92, -104,
-92, -103, -91, -103, -91, -103, -91, -104, -91, -103, -92, -102, -92, -102,
-91, -102, -92, -102, -90, -101, -91, -101, -92, -101, -90, -100, -91, -100,
-91, -99, -90, -98, -90, -98, -90, -98, -89, -97, -89, -96, -89, -96, -89, -95,
-89, -95, -89, -95, -89, -94, -89, -93, -89, -93, -90, -93, -90, -93, -91, -94,
-91, -93, -91, -93, -93, -94, -93, -94, -95, -95, -95, -96, -96, -97, -97, -97,
-98, -98, -99, -98, -100, -99, -100, -99, -101, -100, -101, -100, -101, -101,
-102, -102, -103, -103, -104, -103, -105, -104, -105, -104, -106, -105, -107,
-106, -107, -107, -106, -107, -107, -106, -108, -108, -108, -108, -108, -107,
-109, -109, -110, -109, -110, -110, -111, -111, -111, -112, -112, -112, -112,
-114, -112, -114, -113, -115, -114, -116, -114, -117, -115, -117, -115, -118,
-116, -118, -115, -118, -115, -119, -115, -120, -116, -119, -116, -119, -114,
-119, -115, -118, -114, -118, -114, -118, -112, -116, -111, -116, -111, -115,
-109, -113, -108, -112, -107, -111, -104, -109, -104, -107, -102, -106, -100,
-103, -98, -102, -96, -100, -95, -98, -93, -96, -91, -94, -89, -93, -88, -91,
-86, -90, -86, -88, -84, -87, -83, -85, -80, -84, -80, -82, -77, -79, -75, -78,
-73, -75, -71, -74, -70, -72, -68, -70, -66, -67, -64, -65, -63, -63, -61, -62,
-59, -59, -57, -57, -55, -55, -53, -53, -51, -51, -49, -48, -46, -45, -45, -43,
-43, -40, -40, -38, -38, -36, -36, -33, -33, -32, -31, -28, -29, -27, -27, -23,
-24, -21, -22, -20, -19, -17, -18, -15, -16, -12, -13, -10, -12, -8, -10, -6,
-7, -4, -5, -2, -3, 1, -1, 2, };