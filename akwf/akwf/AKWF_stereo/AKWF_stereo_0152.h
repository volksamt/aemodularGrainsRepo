#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0152

const PROGMEM int8_t DATA[DATA_LENGTH] = {97, 104, 115, 122, 105, 111, 111, 117,
104, 108, 108, 112, 102, 105, 105, 107, 101, 103, 103, 104, 99, 98, 100, 99, 97,
95, 98, 94, 95, 91, 95, 91, 94, 88, 93, 86, 91, 85, 90, 82, 89, 80, 89, 78, 87,
77, 86, 75, 85, 73, 84, 70, 83, 69, 82, 67, 81, 65, 79, 63, 78, 61, 77, 58, 77,
57, 75, 55, 75, 54, 73, 51, 72, 50, 71, 47, 69, 46, 70, 44, 68, 42, 67, 40, 66,
38, 65, 38, 65, 38, 65, 37, 65, 38, 64, 37, 64, 36, 64, 37, 62, 37, 63, 36, 62,
37, 62, 36, 62, 35, 61, 36, 60, 36, 60, 35, 60, 34, 59, 35, 60, 35, 59, 35, 59,
35, 58, 35, 59, 33, 59, 33, 57, 34, 57, 34, 57, 33, 57, 33, 56, 33, 56, 33, 56,
33, 56, 33, 55, 32, 55, 32, 54, 32, 55, 32, 54, 31, 53, 31, 53, 31, 53, 31, 52,
31, 52, 30, 52, 30, 51, 31, 51, 30, 50, 30, 50, 30, 49, 29, 50, 29, 49, 29, 49,
28, 49, 28, 48, 28, 47, 28, 48, 28, 47, 27, 47, 27, 46, 27, 47, 27, 46, 27, 46,
27, 45, 26, 45, 27, 45, 26, 44, 26, 44, 25, 43, 25, 43, 25, 42, 25, 42, 24, 43,
25, 42, 25, 41, 24, 42, 24, 41, 23, 41, 24, 41, 24, 40, 24, 39, 23, 39, 22, 40,
22, 38, 23, 38, 23, 37, 22, 37, 22, 37, 21, 36, 21, 36, 22, 36, 21, 35, 21, 35,
20, 35, 21, 35, 20, 35, 21, 34, 21, 34, 20, 33, 19, 34, 20, 33, 20, 33, 19, 32,
18, 31, 18, 31, 18, 31, 19, 31, 18, 30, 17, 30, 17, 30, 18, 30, 17, 29, 17, 29,
17, 29, 17, 28, 16, 28, 17, 28, 15, 28, 16, 27, 15, 26, 16, 26, 16, 26, 15, 26,
15, 25, 15, 25, 14, 24, 14, 24, 14, 24, 14, 23, 14, 23, 14, 23, 13, 22, 14, 22,
14, 21, 13, 22, 13, 21, 12, 21, 12, 20, 12, 20, 12, 20, 12, 20, 11, 19, 12, 19,
11, 19, 11, 17, 10, 18, 10, 17, 10, 17, 10, 17, 10, 17, 10, 16, 10, 16, 9, 16,
10, 15, 9, 15, 9, 15, 9, 14, 8, 14, 9, 14, 8, 13, 7, 12, 8, 12, 7, 13, 7, 12, 7,
12, 6, 11, 6, 12, 6, 11, 6, 10, 6, 9, 7, 9, 5, 8, 5, 9, 5, 9, 5, 8, 5, 9, 4, 7,
4, 7, 4, 6, 4, 7, 3, 6, 4, 6, 3, 5, 3, 5, 3, 4, 2, 4, 3, 4, 2, 4, 3, 4, 1, 3, 2,
2, 2, 3, 2, 2, 2, 1, 1, 1, 1, 1, 1, 1, 0, 1, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0,
0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 1, -1, 0, -1, 0, 0, 1, 0, 0,
0, 0, 0, -1, 0, -1, 0, 1, 0, 0, -1, 0, -1, 0, 0, -1, -1, 0, -1, 0, 1, 0, 0, 0,
-1, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, -2, -1, -1, -1, -2, -2, -2, -1,
-2, -2, -3, -1, -4, -2, -3, -1, -4, -2, -5, -2, -5, -3, -5, -3, -6, -4, -6, -3,
-7, -3, -6, -4, -6, -4, -7, -4, -7, -4, -7, -4, -7, -4, -8, -5, -9, -5, -9, -5,
-9, -5, -10, -5, -10, -6, -11, -6, -10, -6, -11, -6, -11, -6, -12, -6, -12, -7,
-12, -8, -12, -7, -14, -8, -14, -8, -13, -8, -14, -8, -15, -8, -14, -8, -15, -9,
-15, -9, -15, -9, -16, -9, -16, -10, -17, -10, -17, -10, -17, -10, -18, -10,
-18, -11, -18, -11, -19, -11, -19, -10, -19, -11, -20, -11, -20, -12, -21, -11,
-21, -12, -21, -12, -22, -12, -22, -12, -21, -13, -22, -13, -22, -13, -23, -13,
-23, -14, -24, -14, -24, -15, -25, -15, -25, -15, -26, -14, -25, -14, -25, -14,
-26, -16, -26, -15, -26, -16, -27, -15, -27, -16, -27, -16, -29, -16, -28, -16,
-29, -17, -29, -17, -29, -17, -30, -17, -30, -17, -31, -17, -30, -18, -31, -18,
-31, -18, -32, -18, -32, -18, -33, -19, -33, -19, -33, -19, -33, -20, -34, -21,
-35, -20, -34, -20, -35, -20, -35, -21, -35, -21, -35, -21, -36, -21, -36, -21,
-36, -21, -37, -21, -37, -21, -38, -22, -38, -22, -39, -23, -40, -23, -39, -23,
-40, -23, -39, -24, -40, -23, -41, -24, -41, -24, -41, -24, -41, -24, -42, -25,
-42, -25, -42, -24, -43, -25, -43, -25, -43, -25, -44, -26, -44, -26, -45, -26,
-45, -26, -45, -26, -45, -26, -45, -27, -46, -26, -47, -27, -47, -27, -47, -28,
-47, -27, -48, -28, -48, -29, -49, -28, -49, -29, -50, -29, -49, -28, -49, -30,
-50, -29, -51, -29, -51, -30, -51, -31, -52, -30, -52, -31, -52, -31, -53, -31,
-54, -31, -53, -32, -54, -31, -53, -31, -53, -31, -54, -31, -55, -33, -56, -32,
-56, -32, -56, -33, -56, -33, -57, -33, -57, -33, -58, -33, -57, -33, -58, -33,
-57, -33, -58, -34, -59, -34, -59, -35, -60, -34, -60, -35, -60, -35, -60, -35,
-61, -36, -61, -35, -62, -36, -62, -36, -62, -36, -62, -37, -62, -37, -64, -37,
-64, -38, -63, -37, -64, -37, -65, -37, -65, -38, -65, -38, -66, -39, -66, -39,
-67, -42, -68, -43, -70, -45, -70, -47, -72, -50, -73, -51, -75, -53, -75, -54,
-76, -57, -77, -59, -78, -61, -79, -62, -81, -64, -82, -66, -83, -68, -84, -70,
-85, -72, -86, -74, -87, -76, -88, -78, -88, -80, -91, -83, -91, -83, -94, -86,
-92, -87, -95, -90, -94, -91, -98, -94, -97, -95, -100, -98, -99, -98, -102,
-102, -102, -102, -104, -107, -103, -106, -106, -110, -106, -110, -107, -113,
-109, -116, -108, -115, -116, -125, -17, -18, 7, 7, };