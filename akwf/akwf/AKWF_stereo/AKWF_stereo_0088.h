#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0088

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 13, 3, 17, 5, 18, 9, 20, 12, 22,
16, 25, 20, 26, 23, 29, 27, 30, 31, 33, 36, 36, 40, 39, 45, 41, 48, 45, 52, 47,
55, 50, 57, 53, 58, 54, 59, 56, 61, 59, 62, 59, 63, 61, 64, 64, 66, 65, 69, 66,
70, 68, 72, 69, 75, 70, 77, 73, 78, 74, 80, 76, 81, 77, 82, 79, 82, 81, 82, 81,
83, 83, 83, 85, 83, 87, 84, 87, 85, 89, 87, 90, 90, 92, 90, 92, 91, 92, 89, 92,
88, 92, 85, 90, 83, 90, 82, 90, 82, 92, 83, 92, 86, 93, 90, 94, 93, 96, 98, 97,
101, 99, 105, 100, 108, 101, 111, 103, 112, 104, 114, 106, 116, 107, 117, 109,
118, 111, 119, 112, 120, 113, 119, 113, 117, 114, 116, 114, 115, 113, 112, 113,
110, 112, 108, 111, 104, 110, 102, 109, 97, 107, 94, 104, 89, 103, 85, 101, 82,
97, 79, 95, 75, 92, 73, 88, 71, 85, 70, 82, 68, 79, 68, 76, 66, 73, 66, 70, 65,
68, 63, 64, 62, 62, 61, 60, 59, 58, 59, 55, 56, 52, 55, 50, 54, 46, 53, 42, 52,
40, 52, 37, 49, 34, 49, 32, 46, 29, 44, 25, 43, 23, 41, 21, 39, 19, 37, 17, 35,
14, 33, 12, 29, 10, 27, 7, 23, 5, 20, 2, 18, -1, 14, -3, 11, -6, 7, -9, 4, -11,
0, -15, -4, -18, -7, -21, -12, -24, -16, -27, -20, -30, -26, -34, -30, -37, -34,
-41, -38, -45, -41, -47, -45, -51, -47, -53, -48, -55, -49, -58, -51, -60, -52,
-62, -53, -65, -54, -67, -56, -68, -58, -71, -60, -73, -62, -75, -66, -77, -70,
-79, -73, -81, -76, -83, -80, -83, -83, -86, -84, -87, -84, -88, -85, -89, -85,
-90, -84, -90, -82, -91, -82, -90, -80, -90, -80, -91, -79, -90, -79, -88, -79,
-88, -79, -86, -79, -85, -80, -84, -79, -84, -79, -83, -79, -81, -80, -81, -79,
-80, -78, -79, -78, -79, -77, -77, -76, -76, -75, -76, -75, -75, -74, -74, -73,
-73, -72, -71, -72, -71, -71, -70, -70, -69, -71, -68, -70, -67, -70, -66, -70,
-65, -69, -64, -69, -64, -68, -62, -68, -61, -67, -61, -68, -59, -68, -59, -66,
-57, -65, -57, -64, -56, -62, -54, -59, -53, -57, -52, -54, -50, -52, -48, -49,
-48, -47, -45, -45, -45, -43, -43, -42, -42, -39, -40, -37, -39, -35, -38, -32,
-37, -30, -35, -28, -34, -24, -32, -22, -31, -21, -30, -18, -28, -18, -27, -16,
-26, -16, -25, -14, -24, -15, -21, -13, -19, -11, -17, -9, -16, -6, -14, -4,
-11, -1, -9, 1, -7, 3, -6, 5, -4, 6, -2, 6, -1, 7, 0, 6, 2, 6, 3, 6, 4, 6, 4, 6,
6, 6, 7, 7, 9, 8, 10, 10, 11, 11, 12, 12, 14, 13, 15, 14, 16, 14, 19, 13, 20,
13, 22, 14, 23, 14, 23, 16, 24, 18, 24, 20, 26, 22, 25, 24, 27, 25, 27, 26, 27,
28, 28, 30, 30, 33, 31, 35, 32, 37, 33, 39, 34, 41, 37, 42, 38, 43, 39, 42, 41,
42, 42, 41, 43, 40, 45, 37, 46, 35, 47, 32, 47, 31, 48, 29, 50, 28, 50, 27, 51,
26, 52, 26, 53, 26, 53, 25, 54, 27, 54, 27, 56, 29, 56, 30, 57, 32, 57, 34, 59,
37, 60, 40, 60, 43, 60, 44, 62, 47, 62, 48, 63, 48, 63, 48, 64, 47, 63, 45, 63,
44, 63, 42, 62, 39, 61, 36, 59, 35, 58, 31, 56, 28, 55, 26, 51, 23, 49, 21, 46,
17, 43, 13, 41, 11, 37, 6, 35, 4, 32, 0, 28, -3, 25, -5, 23, -8, 19, -10, 15,
-10, 13, -11, 10, -11, 8, -11, 6, -10, 4, -11, 2, -10, 1, -11, -1, -12, -3, -14,
-5, -13, -5, -14, -7, -14, -9, -14, -11, -12, -12, -11, -13, -8, -15, -6, -15,
-3, -17, -1, -18, 1, -17, 3, -18, 3, -19, 4, -20, 4, -20, 2, -20, 1, -21, -1,
-20, -2, -21, -3, -22, -5, -22, -5, -21, -6, -23, -6, -24, -6, -24, -6, -25, -5,
-25, -3, -25, -3, -24, -1, -26, -2, -25, -1, -25, -3, -25, -5, -27, -5, -27, -9,
-27, -11, -28, -14, -30, -17, -31, -19, -32, -21, -33, -24, -35, -26, -36, -28,
-36, -30, -37, -31, -39, -33, -39, -34, -40, -35, -41, -36, -41, -38, -43, -39,
-45, -40, -45, -42, -45, -44, -47, -45, -48, -46, -49, -47, -50, -48, -50, -50,
-51, -51, -52, -52, -53, -53, -54, -53, -53, -54, -55, -54, -56, -55, -57, -55,
-57, -54, -57, -53, -58, -53, -59, -52, -59, -51, -60, -51, -60, -51, -59, -51,
-60, -51, -60, -51, -60, -51, -61, -50, -60, -49, -60, -48, -59, -46, -59, -45,
-60, -43, -59, -41, -58, -39, -58, -38, -57, -37, -56, -36, -55, -35, -54, -34,
-54, -34, -52, -33, -52, -31, -50, -31, -49, -31, -48, -30, -48, -30, -47, -29,
-45, -29, -44, -29, -43, -29, -43, -29, -42, -29, -41, -29, -40, -29, -39, -29,
-38, -29, -37, -29, -36, -29, -35, -29, -34, -28, -33, -28, -32, -27, -31, -26,
-30, -25, -28, -24, -27, -23, -25, -21, -24, -20, -22, -19, -21, -18, -19, -17,
-18, -15, -16, -14, -15, -14, -14, -13, -12, -13, -11, -14, -11, -15, -11, -16,
-10, -16, -10, -17, -9, -16, -10, -16, -9, -15, -9, -15, -8, -16, -7, -15, -7,
-16, -6, -16, -5, -17, -5, -19, -5, -20, -4, -23, -5, -25, -5, -28, -6, -29, -6,
-30, -7, -32, -7, -32, -7, -31, -7, -31, -7, -29, -8, -28, -6, -26, -6, -24, -6,
-22, -6, -21, -6, -19, -6, -18, -7, -18, -6, -18, -7, -17, -7, -18, -7, -17, -7,
-18, -7, -17, -7, -17, -5, -16, -5, -14, -3, -14, -3, -13, -1, -13, -1, -12, 0,
-12, 1, -12, 2, -12, 3, -12, 5, -10, 6, -9, 7, -7, 8, -6, 12, -2, 10, };