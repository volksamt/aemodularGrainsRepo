#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0184

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -52, 1, -62, 1, -57, 2, -61, 2,
-58, 3, -61, 4, -57, 4, -60, 4, -58, 5, -59, 6, -57, 6, -58, 8, -56, 9, -56, 10,
-56, 10, -55, 12, -54, 13, -53, 14, -51, 15, -51, 16, -49, 18, -48, 18, -46, 21,
-45, 21, -43, 22, -43, 24, -41, 26, -39, 27, -37, 29, -35, 31, -34, 33, -31, 33,
-29, 34, -27, 36, -25, 39, -22, 41, -21, 41, -19, 44, -15, 46, -14, 47, -11, 49,
-9, 51, -6, 52, -3, 54, -1, 56, 1, 57, 4, 59, 6, 61, 9, 63, 12, 63, 15, 65, 17,
67, 19, 69, 22, 70, 25, 71, 27, 73, 30, 75, 32, 76, 34, 77, 38, 78, 40, 79, 42,
80, 45, 82, 47, 83, 49, 84, 51, 85, 53, 86, 55, 87, 58, 87, 60, 88, 61, 88, 64,
89, 65, 90, 67, 91, 69, 91, 71, 92, 73, 93, 75, 93, 76, 92, 78, 93, 79, 94, 81,
93, 82, 94, 83, 93, 85, 93, 86, 93, 87, 93, 89, 93, 90, 93, 90, 92, 91, 91, 92,
90, 93, 90, 94, 90, 95, 90, 96, 88, 96, 88, 97, 87, 97, 86, 98, 85, 99, 84, 99,
84, 100, 83, 100, 82, 100, 80, 100, 79, 101, 78, 101, 77, 100, 76, 101, 74, 101,
73, 101, 72, 101, 71, 101, 70, 101, 68, 100, 67, 100, 65, 100, 63, 99, 63, 99,
61, 99, 59, 99, 59, 99, 57, 98, 55, 97, 55, 97, 52, 96, 52, 96, 49, 96, 47, 95,
47, 94, 45, 94, 44, 94, 43, 92, 41, 91, 40, 90, 38, 90, 38, 89, 35, 88, 34, 88,
33, 85, 32, 85, 31, 85, 30, 84, 28, 82, 27, 81, 25, 81, 25, 79, 24, 78, 23, 76,
21, 75, 20, 75, 19, 73, 19, 72, 17, 72, 16, 70, 16, 69, 15, 67, 14, 66, 13, 65,
12, 63, 13, 63, 12, 61, 11, 60, 11, 60, 10, 58, 10, 56, 9, 55, 9, 54, 8, 53, 8,
52, 8, 51, 7, 49, 7, 49, 7, 47, 6, 45, 6, 44, 5, 43, 6, 42, 6, 41, 5, 39, 5, 38,
5, 36, 5, 35, 5, 33, 4, 32, 4, 31, 4, 30, 4, 28, 5, 27, 4, 26, 4, 25, 5, 24, 4,
23, 4, 21, 5, 20, 4, 19, 5, 17, 4, 16, 5, 15, 4, 15, 5, 14, 4, 12, 5, 12, 4, 11,
4, 9, 5, 8, 4, 7, 5, 7, 5, 5, 6, 4, 5, 3, 5, 2, 5, 1, 6, 1, 5, -1, 5, -2, 5, -3,
5, -5, 5, -5, 5, -6, 5, -7, 4, -8, 5, -9, 5, -10, 4, -12, 5, -13, 4, -13, 3,
-14, 4, -16, 3, -17, 4, -18, 4, -19, 3, -20, 2, -21, 2, -23, 2, -24, 1, -25, 0,
-26, 0, -27, 0, -28, -1, -30, -1, -31, -2, -32, -2, -33, -3, -35, -4, -36, -5,
-38, -5, -39, -6, -41, -7, -42, -7, -43, -9, -45, -9, -46, -11, -47, -12, -49,
-12, -50, -13, -52, -15, -54, -16, -55, -16, -57, -18, -58, -18, -60, -20, -62,
-22, -63, -22, -65, -24, -66, -25, -67, -27, -69, -27, -71, -29, -72, -31, -73,
-32, -75, -33, -77, -35, -78, -35, -79, -38, -81, -40, -82, -41, -84, -42, -84,
-44, -86, -46, -88, -47, -89, -48, -91, -50, -93, -52, -94, -54, -95, -55, -96,
-56, -98, -58, -99, -59, -100, -61, -102, -63, -103, -64, -103, -65, -104, -68,
-106, -69, -108, -71, -108, -72, -109, -74, -110, -76, -110, -78, -112, -80,
-112, -80, -114, -82, -115, -84, -114, -85, -115, -87, -115, -88, -116, -89,
-116, -91, -118, -92, -118, -92, -118, -94, -118, -95, -118, -97, -119, -98,
-119, -99, -119, -100, -119, -101, -120, -102, -119, -102, -118, -103, -118,
-105, -119, -105, -118, -106, -118, -107, -117, -108, -116, -108, -115, -109,
-115, -108, -114, -109, -114, -110, -112, -109, -111, -110, -111, -110, -109,
-110, -108, -110, -107, -110, -106, -109, -105, -109, -104, -109, -101, -109,
-99, -109, -99, -108, -96, -107, -95, -106, -92, -105, -92, -106, -90, -104,
-87, -103, -86, -102, -83, -102, -81, -100, -78, -100, -75, -97, -74, -96, -72,
-95, -69, -94, -67, -92, -63, -90, -61, -88, -58, -87, -56, -85, -53, -83, -50,
-82, -47, -80, -44, -78, -41, -75, -38, -74, -35, -72, -33, -70, -29, -66, -27,
-65, -23, -62, -20, -60, -17, -58, -14, -56, -12, -53, -10, -51, -6, -50, -3,
-47, 0, -45, 3, -42, 4, -42, 8, -41, 8, -40, 10, -38, 12, -36, 14, -33, 18, -31,
21, -28, 23, -27, 26, -25, 27, -23, 30, -21, 32, -19, 34, -17, 37, -15, 40, -13,
41, -11, 44, -10, 44, -8, 46, -6, 49, -4, 51, -4, 53, -2, 54, 1, 55, 1, 56, 3,
58, 5, 59, 6, 60, 7, 61, 8, 63, 10, 64, 10, 64, 12, 65, 13, 66, 15, 67, 16, 68,
15, 68, 17, 69, 18, 69, 18, 69, 19, 70, 20, 69, 20, 70, 21, 70, 21, 69, 21, 69,
22, 69, 22, 69, 23, 68, 24, 67, 23, 67, 23, 67, 23, 65, 22, 64, 24, 64, 24, 64,
23, 62, 23, 60, 23, 59, 23, 58, 21, 57, 22, 56, 22, 55, 21, 52, 21, 51, 21, 49,
21, 47, 20, 46, 20, 44, 19, 43, 19, 41, 18, 39, 18, 36, 17, 35, 16, 33, 16, 31,
15, 28, 15, 27, 14, 24, 14, 22, 14, 19, 13, 18, 11, 17, 11, 13, 10, 11, 10, 9,
10, 7, 9, 5, 8, 2, 8, 0, 7, -2, 7, -5, 7, -6, 6, -9, 5, -11, 4, -14, 4, -15, 4,
-17, 3, -20, 2, -21, 2, -23, 1, -26, 2, -27, 1, -29, -1, -30, 1, -33, 0, -34, 0,
-36, -1, -39, -2, -39, -1, -42, -1, -43, -2, -44, -2, -46, -2, -47, -2, -48, -2,
-50, -2, -50, -2, -53, -2, -51, -2, -54, -2, -54, -1, -58, -2, -55, -1, -59, -1,
-55, 0, -61, -1, -50, };