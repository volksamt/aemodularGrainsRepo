#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0121

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, -11, 7, -10, 12, -6, 17, -3, 22, 2,
28, 5, 32, 9, 38, 13, 44, 19, 49, 22, 54, 27, 59, 31, 64, 36, 70, 40, 74, 45,
79, 50, 83, 53, 88, 57, 92, 61, 96, 65, 100, 69, 103, 73, 105, 77, 107, 79, 110,
83, 112, 86, 114, 88, 116, 91, 117, 94, 118, 95, 118, 98, 119, 99, 119, 100,
120, 101, 120, 103, 119, 104, 117, 104, 117, 105, 115, 106, 114, 105, 112, 105,
111, 105, 109, 104, 107, 104, 105, 104, 103, 101, 100, 101, 99, 100, 96, 98, 95,
97, 92, 96, 89, 94, 86, 92, 84, 91, 81, 88, 79, 87, 76, 85, 73, 83, 71, 81, 68,
79, 66, 77, 63, 75, 61, 72, 59, 70, 57, 68, 53, 65, 52, 63, 50, 62, 46, 60, 45,
57, 44, 56, 41, 53, 39, 52, 38, 49, 36, 48, 33, 46, 32, 45, 30, 43, 29, 41, 28,
40, 26, 39, 25, 37, 23, 35, 21, 35, 20, 33, 19, 31, 18, 31, 17, 29, 16, 28, 15,
27, 15, 26, 14, 25, 13, 24, 12, 24, 11, 23, 10, 22, 9, 21, 9, 20, 8, 20, 7, 19,
6, 18, 6, 17, 6, 16, 5, 15, 4, 15, 3, 13, 2, 12, 1, 11, 0, 11, -1, 10, -1, 9,
-3, 8, -4, 7, -5, 6, -6, 4, -7, 3, -8, 1, -9, 1, -10, 0, -12, -2, -13, -4, -14,
-5, -16, -6, -17, -7, -19, -10, -19, -10, -22, -12, -23, -13, -25, -15, -25,
-15, -28, -18, -28, -19, -30, -20, -31, -21, -33, -23, -34, -24, -36, -25, -37,
-28, -39, -29, -39, -30, -42, -31, -41, -32, -43, -34, -45, -35, -45, -37, -46,
-37, -47, -38, -48, -40, -49, -40, -51, -42, -51, -43, -52, -43, -52, -44, -53,
-45, -54, -47, -55, -48, -55, -49, -55, -49, -55, -50, -56, -51, -56, -51, -57,
-52, -57, -53, -57, -54, -58, -54, -58, -54, -58, -54, -58, -56, -57, -56, -58,
-56, -57, -56, -57, -56, -57, -56, -56, -57, -55, -57, -55, -57, -54, -56, -53,
-56, -52, -57, -52, -56, -50, -56, -49, -55, -49, -54, -47, -53, -45, -52, -44,
-51, -42, -51, -42, -49, -39, -47, -37, -46, -36, -45, -33, -43, -32, -42, -30,
-40, -28, -38, -27, -36, -24, -34, -22, -33, -20, -30, -18, -28, -16, -25, -14,
-24, -12, -22, -10, -20, -8, -18, -6, -15, -5, -13, -1, -11, 0, -9, 2, -8, 3,
-4, 5, -3, 6, -1, 7, 0, 9, 3, 10, 4, 11, 5, 11, 6, 13, 9, 14, 10, 15, 10, 15,
11, 15, 13, 15, 13, 15, 14, 16, 14, 17, 15, 16, 15, 16, 16, 16, 16, 17, 16, 15,
15, 16, 15, 16, 16, 15, 15, 15, 15, 15, 15, 15, 14, 14, 14, 14, 13, 14, 13, 13,
12, 12, 11, 12, 10, 12, 10, 12, 9, 12, 8, 11, 7, 11, 6, 11, 6, 11, 6, 11, 5, 12,
4, 11, 3, 11, 4, 11, 3, 11, 3, 12, 2, 13, 3, 12, 2, 13, 3, 15, 3, 15, 4, 16, 3,
16, 4, 17, 4, 17, 5, 18, 5, 19, 6, 20, 7, 20, 8, 21, 8, 22, 10, 23, 11, 24, 11,
24, 12, 25, 13, 26, 14, 25, 16, 26, 16, 27, 18, 26, 19, 26, 19, 27, 20, 27, 21,
26, 22, 26, 23, 26, 24, 26, 24, 26, 25, 26, 25, 25, 25, 25, 26, 23, 27, 23, 26,
22, 27, 20, 26, 20, 26, 18, 26, 17, 25, 16, 26, 15, 26, 14, 25, 12, 24, 11, 24,
9, 23, 9, 22, 7, 21, 4, 21, 3, 20, 1, 19, 0, 17, -2, 16, -3, 16, -4, 14, -5, 13,
-8, 12, -9, 10, -11, 8, -12, 7, -14, 6, -16, 4, -17, 3, -18, 1, -20, 0, -21, -3,
-23, -4, -23, -6, -24, -7, -26, -9, -27, -9, -27, -11, -29, -13, -29, -15, -31,
-15, -32, -17, -33, -19, -33, -20, -34, -22, -34, -23, -35, -24, -34, -26, -34,
-27, -34, -27, -35, -28, -34, -28, -35, -30, -34, -31, -34, -32, -33, -32, -33,
-32, -33, -33, -32, -33, -31, -33, -31, -35, -30, -35, -30, -35, -28, -34, -28,
-34, -27, -34, -26, -34, -25, -34, -25, -33, -24, -33, -24, -33, -22, -33, -22,
-33, -21, -32, -20, -31, -20, -30, -19, -30, -19, -29, -19, -29, -18, -29, -17,
-28, -17, -27, -17, -27, -17, -26, -16, -25, -15, -25, -15, -24, -15, -24, -15,
-23, -15, -22, -14, -23, -13, -22, -13, -21, -13, -21, -12, -19, -12, -19, -12,
-17, -12, -17, -11, -17, -10, -17, -10, -16, -9, -14, -9, -14, -8, -13, -8, -12,
-7, -10, -6, -10, -5, -9, -4, -8, -3, -8, -4, -7, -2, -6, -2, -4, -1, -4, 0, -3,
0, -2, 1, -1, 1, 0, 2, 0, 3, 2, 3, 2, 3, 3, 2, 4, 3, 3, 2, 3, 3, 3, 3, 4, 3, 5,
3, 4, 2, 4, 1, 4, 2, 4, 1, 5, -1, 3, -1, 3, -1, 3, -2, 1, -4, 1, -4, 1, -6, 0,
-7, -2, -7, -2, -9, -3, -10, -4, -11, -6, -12, -6, -14, -8, -15, -9, -16, -10,
-17, -11, -19, -13, -20, -14, -22, -15, -22, -17, -24, -18, -25, -19, -25, -20,
-26, -21, -28, -22, -29, -24, -31, -26, -31, -27, -33, -28, -33, -29, -34, -30,
-35, -31, -36, -32, -37, -32, -37, -34, -38, -35, -40, -36, -40, -35, -40, -37,
-41, -37, -42, -38, -42, -39, -43, -39, -44, -40, -44, -41, -45, -41, -45, -42,
-47, -43, -48, -42, -47, -43, -49, -43, -49, -44, -50, -44, -50, -45, -50, -46,
-50, -46, -51, -47, -51, -46, -51, -47, -51, -47, -51, -47, -51, -48, -51, -47,
-51, -47, -50, -47, -49, -48, -49, -46, -48, -46, -47, -46, -45, -45, -43, -44,
-42, -43, -40, -43, -38, -40, -35, -39, -31, -36, -29, -36, -26, -33, -23, -31,
-19, -28, -14, -27, -11, -23, -6, -21, -1, -14, };