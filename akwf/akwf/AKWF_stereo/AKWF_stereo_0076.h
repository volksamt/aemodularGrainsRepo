#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0076

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 7, 58, 55, 106, 102, 110, 108, 99,
100, 90, 98, 82, 99, 77, 102, 71, 108, 68, 112, 65, 117, 63, 118, 60, 119, 60,
118, 59, 114, 57, 111, 57, 106, 57, 104, 57, 101, 56, 101, 55, 101, 55, 103, 54,
104, 53, 107, 53, 108, 52, 109, 52, 108, 52, 108, 51, 104, 52, 103, 52, 100, 52,
98, 52, 97, 52, 95, 53, 95, 53, 95, 53, 96, 54, 98, 54, 98, 55, 98, 55, 98, 56,
96, 55, 96, 55, 95, 52, 94, 47, 93, 45, 93, 48, 92, 51, 90, 53, 90, 55, 90, 55,
90, 56, 90, 58, 90, 59, 90, 60, 89, 60, 88, 61, 87, 61, 87, 62, 85, 62, 84, 62,
85, 62, 83, 62, 83, 63, 83, 62, 83, 62, 83, 63, 82, 62, 83, 62, 81, 62, 81, 61,
80, 60, 79, 60, 80, 60, 78, 60, 77, 60, 77, 59, 76, 59, 77, 58, 76, 57, 75, 57,
75, 56, 75, 56, 75, 56, 73, 55, 73, 54, 73, 54, 73, 56, 71, 56, 71, 56, 70, 54,
70, 52, 70, 51, 69, 50, 68, 49, 69, 48, 68, 47, 68, 46, 67, 46, 67, 45, 66, 43,
65, 43, 65, 42, 64, 42, 64, 42, 64, 41, 63, 41, 63, 40, 63, 39, 63, 39, 62, 38,
62, 38, 61, 38, 60, 36, 60, 36, 60, 36, 59, 36, 59, 36, 59, 35, 58, 35, 59, 34,
58, 35, 57, 34, 56, 33, 57, 34, 56, 34, 55, 32, 56, 32, 55, 33, 55, 33, 54, 32,
54, 31, 54, 32, 54, 32, 53, 32, 52, 32, 52, 31, 52, 32, 52, 32, 52, 31, 51, 32,
50, 32, 50, 32, 50, 31, 50, 32, 49, 32, 49, 32, 48, 32, 48, 32, 48, 31, 47, 32,
48, 32, 47, 32, 46, 32, 46, 32, 46, 16, 32, -32, -17, -80, -64, -83, -70, -70,
-62, -62, -60, -55, -61, -50, -64, -44, -70, -42, -75, -39, -81, -36, -82, -35,
-83, -33, -82, -33, -79, -32, -75, -32, -71, -31, -67, -31, -67, -31, -67, -30,
-67, -29, -68, -29, -70, -29, -74, -28, -75, -27, -75, -28, -76, -28, -74, -28,
-73, -28, -70, -30, -67, -29, -66, -30, -64, -30, -64, -31, -63, -31, -64, -32,
-66, -33, -67, -33, -68, -34, -68, -34, -68, -34, -68, -36, -67, -35, -66, -27,
-65, -12, -66, -5, -67, -12, -65, -19, -65, -24, -63, -29, -62, -33, -64, -37,
-63, -39, -62, -41, -63, -43, -63, -44, -61, -45, -61, -47, -60, -47, -59, -47,
-58, -48, -58, -49, -57, -49, -57, -49, -57, -50, -57, -50, -58, -49, -57, -49,
-57, -49, -57, -49, -57, -49, -57, -48, -56, -48, -55, -48, -54, -48, -54, -48,
-54, -47, -53, -46, -53, -46, -53, -46, -53, -45, -53, -45, -53, -44, -53, -43,
-52, -43, -51, -42, -51, -42, -50, -43, -51, -44, -50, -44, -49, -42, -49, -41,
-49, -39, -49, -38, -48, -37, -48, -36, -49, -35, -48, -34, -47, -34, -48, -33,
-47, -32, -47, -31, -46, -31, -46, -30, -46, -29, -46, -30, -46, -28, -45, -28,
-45, -27, -44, -27, -44, -26, -45, -26, -44, -26, -43, -25, -43, -25, -42, -22,
-39, -19, -34, -20, -35, -22, -39, -23, -41, -24, -43, -25, -44, -25, -46, -26,
-46, -26, -45, -26, -45, -25, -45, -24, -43, -24, -42, -22, -40, -22, -39, -21,
-38, -21, -37, -21, -38, -20, -38, -21, -37, -21, -37, -21, -38, -22, -36, -22,
-37, -23, -36, -23, -36, -23, -36, -24, -37, -24, -37, -24, -37, -23, -37, -23,
-36, -24, -36, -24, -36, -24, -35, -24, -35, -23, -35, -24, -34, -24, -34, -23,
-34, -24, -33, -24, -33, -24, -33, -24, -33, -24, -34, -25, -33, -24, -32, -24,
-32, -25, -31, -25, -32, -24, -32, -24, -31, -24, -31, -24, -31, -24, -31, -24,
-31, -24, -30, -23, -30, -24, -31, -23, -30, -23, -30, -23, -29, -22, -30, -22,
-30, -22, -29, -22, -29, -22, -29, -22, -29, -21, -28, -21, -28, -20, -27, -21,
-28, -20, -28, -20, -28, -20, -27, -19, -27, -19, -27, -20, -27, -19, -26, -18,
-27, -19, -27, -18, -26, -18, -26, -28, -25, -43, -22, -49, -21, -42, -21, -36,
-23, -31, -22, -26, -23, -23, -24, -21, -24, -19, -24, -16, -24, -15, -23, -14,
-24, -13, -24, -11, -23, -10, -23, -10, -23, -10, -23, -10, -23, -9, -23, -9,
-23, -9, -22, -10, -22, -9, -22, -9, -22, -9, -22, -8, -22, -9, -21, -8, -21,
-9, -21, -9, -21, -9, -22, -9, -21, -9, -21, -9, -21, -9, -20, -9, -20, -9, -21,
-9, -20, -9, -20, -10, -20, -9, -20, -9, -19, -9, -19, -4, -20, 2, -20, 2, -21,
-2, -20, -3, -19, -5, -19, -7, -19, -8, -19, -9, -18, -8, -17, -9, -17, -10,
-18, -10, -18, -11, -17, -11, -17, -11, -17, -12, -16, -12, -17, -12, -17, -12,
-17, -13, -16, -12, -16, -12, -16, -12, -16, -12, -15, -13, -16, -12, -15, -12,
-16, -14, -20, -17, -24, -15, -22, -14, -18, -11, -15, -10, -13, -9, -11, -8,
-10, -8, -10, -8, -10, -9, -10, -9, -10, -8, -11, -9, -12, -10, -13, -10, -13,
-12, -14, -12, -14, -12, -14, -11, -15, -11, -14, -10, -14, -10, -14, -9, -13,
-9, -13, -9, -12, -9, -12, -9, -11, -8, -11, -8, -11, -8, -11, -7, -10, -7, -12,
-7, -10, -7, -11, -7, -12, -8, -11, -7, -11, -7, -12, -7, -11, -6, -12, -7, -11,
-7, -11, -7, -11, -7, -10, -7, -10, -7, -10, -7, -10, -7, -10, -7, -10, -6, -10,
-6, -9, -6, -9, -6, -9, -5, -9, -6, -9, -6, -9, -6, -9, -6, -9, -6, -9, -6, -8,
-5, -9, -5, -9, -4, -9, -5, -9, -5, -8, -6, -8, -6, -8, -5, -8, -6, -8, -5, -7,
-5, -8, -6, -9, -5, -7, -4, -7, -5, -8, -5, -8, -5, -7, -5, -8, -5, -7, -6, -8,
-5, -7, -5, -8, -4, -5, };