#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0188

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -14, 1, -15, 2, -13, 3, -12, 5, -9,
7, -10, 8, -8, 8, -8, 10, -6, 11, -5, 12, -4, 13, -4, 14, -2, 15, -1, 17, 0, 18,
1, 19, 3, 20, 3, 20, 4, 22, 5, 24, 7, 24, 7, 26, 9, 26, 10, 28, 11, 29, 12, 30,
14, 31, 14, 33, 16, 34, 17, 34, 18, 35, 20, 36, 21, 38, 22, 38, 24, 39, 25, 40,
26, 42, 27, 42, 29, 44, 29, 45, 31, 46, 32, 47, 33, 49, 34, 49, 35, 51, 37, 52,
38, 52, 39, 53, 40, 55, 40, 55, 42, 57, 44, 58, 44, 59, 45, 59, 46, 61, 47, 62,
49, 64, 50, 65, 51, 66, 52, 67, 53, 68, 54, 70, 56, 70, 56, 71, 57, 73, 58, 74,
60, 74, 61, 75, 62, 77, 64, 78, 64, 78, 66, 80, 67, 81, 68, 82, 69, 82, 71, 83,
71, 84, 73, 84, 73, 86, 75, 87, 75, 88, 76, 87, 78, 90, 79, 91, 80, 90, 80, 91,
81, 93, 82, 92, 83, 93, 83, 94, 84, 94, 85, 95, 87, 96, 87, 97, 87, 97, 88, 98,
89, 98, 89, 99, 90, 100, 91, 100, 91, 101, 92, 101, 93, 102, 93, 102, 95, 103,
95, 103, 95, 103, 97, 103, 97, 104, 98, 104, 98, 105, 99, 105, 100, 105, 99,
106, 100, 105, 100, 105, 101, 106, 102, 106, 102, 107, 103, 107, 103, 106, 103,
106, 103, 107, 103, 107, 104, 107, 103, 107, 105, 107, 104, 107, 105, 107, 104,
106, 105, 107, 105, 107, 105, 106, 106, 107, 106, 107, 106, 106, 107, 105, 105,
105, 107, 106, 107, 106, 107, 106, 108, 106, 108, 106, 108, 106, 108, 107, 110,
106, 110, 106, 111, 107, 111, 106, 111, 106, 111, 106, 112, 106, 112, 106, 113,
107, 113, 107, 113, 107, 113, 107, 114, 107, 114, 107, 114, 106, 115, 107, 114,
106, 115, 106, 115, 106, 115, 107, 115, 106, 115, 105, 115, 105, 114, 104, 114,
103, 114, 103, 113, 103, 113, 103, 113, 102, 113, 100, 112, 100, 111, 100, 111,
100, 110, 98, 110, 97, 109, 96, 109, 96, 108, 95, 107, 93, 106, 93, 105, 92,
104, 91, 105, 90, 103, 89, 103, 87, 102, 87, 101, 86, 100, 84, 99, 84, 98, 82,
97, 81, 96, 80, 94, 80, 93, 78, 93, 77, 92, 75, 90, 74, 89, 73, 87, 71, 86, 70,
85, 69, 84, 68, 82, 66, 80, 64, 79, 64, 78, 62, 76, 61, 75, 60, 74, 59, 72, 57,
71, 56, 69, 54, 67, 53, 65, 51, 65, 49, 63, 48, 61, 47, 60, 46, 58, 44, 57, 43,
55, 42, 54, 40, 53, 39, 50, 37, 49, 35, 48, 34, 47, 32, 44, 32, 44, 30, 42, 28,
41, 26, 39, 25, 38, 23, 37, 22, 35, 21, 34, 20, 33, 17, 31, 15, 30, 14, 28, 13,
27, 11, 26, 9, 24, 8, 23, 6, 21, 4, 19, 4, 18, 2, 16, 1, 15, -1, 14, -2, 12, -5,
11, -6, 9, -8, 8, -9, 6, -10, 5, -11, 3, -14, 2, -15, 1, -16, -1, -18, -1, -19,
-4, -21, -5, -22, -6, -23, -7, -26, -8, -26, -11, -27, -12, -29, -12, -30, -14,
-32, -15, -34, -15, -35, -17, -36, -18, -37, -20, -38, -21, -40, -22, -41, -24,
-43, -25, -44, -25, -45, -27, -46, -28, -47, -28, -48, -30, -50, -31, -51, -32,
-52, -33, -53, -34, -54, -35, -55, -36, -57, -37, -58, -38, -59, -40, -60, -40,
-61, -41, -62, -42, -64, -44, -64, -44, -65, -47, -66, -47, -67, -49, -68, -49,
-68, -50, -70, -51, -71, -53, -71, -53, -72, -54, -73, -56, -73, -57, -75, -58,
-76, -59, -76, -60, -76, -61, -78, -63, -79, -63, -79, -64, -80, -65, -80, -66,
-81, -68, -82, -68, -83, -69, -84, -69, -85, -71, -85, -72, -86, -72, -87, -73,
-87, -74, -88, -76, -89, -76, -90, -77, -91, -78, -91, -79, -92, -81, -92, -80,
-93, -82, -95, -83, -95, -83, -95, -83, -96, -85, -97, -86, -97, -86, -98, -86,
-97, -88, -98, -89, -99, -90, -99, -90, -100, -91, -100, -91, -100, -92, -100,
-93, -101, -93, -101, -94, -102, -94, -102, -94, -103, -95, -101, -96, -103,
-97, -103, -97, -104, -98, -103, -98, -103, -98, -102, -98, -104, -100, -103,
-100, -104, -100, -104, -101, -103, -101, -104, -101, -104, -102, -104, -102,
-105, -104, -105, -105, -105, -105, -106, -106, -106, -106, -107, -106, -107,
-108, -107, -109, -108, -109, -108, -110, -109, -112, -109, -112, -110, -112,
-110, -113, -110, -114, -110, -115, -112, -115, -112, -116, -111, -117, -112,
-117, -113, -117, -112, -118, -113, -119, -113, -119, -112, -119, -112, -119,
-113, -119, -113, -120, -112, -119, -112, -119, -112, -119, -111, -119, -112,
-119, -111, -119, -110, -118, -111, -117, -109, -118, -109, -118, -109, -117,
-108, -117, -108, -117, -107, -117, -107, -117, -106, -117, -106, -115, -105,
-115, -105, -114, -103, -114, -102, -113, -103, -114, -102, -113, -101, -112,
-100, -111, -99, -110, -98, -111, -98, -109, -96, -109, -95, -108, -94, -107,
-93, -106, -92, -104, -91, -103, -90, -103, -89, -102, -88, -101, -86, -99, -86,
-99, -85, -98, -83, -97, -82, -96, -81, -95, -79, -93, -79, -92, -77, -91, -76,
-89, -75, -88, -73, -87, -73, -86, -71, -85, -70, -83, -68, -82, -67, -80, -65,
-80, -64, -79, -63, -77, -62, -76, -61, -76, -60, -74, -58, -72, -55, -72, -55,
-70, -54, -70, -52, -68, -50, -67, -50, -65, -48, -63, -47, -64, -46, -62, -44,
-61, -43, -60, -42, -58, -41, -56, -39, -56, -38, -55, -37, -54, -36, -52, -35,
-50, -33, -48, -32, -49, -31, -47, -29, -47, -29, -44, -28, -43, -26, -43, -25,
-42, -24, -39, -23, -39, -22, -38, -21, -37, -20, -36, -19, -34, -17, -34, -16,
-32, -15, -31, -13, -30, -13, -29, -12, -28, -12, -27, -9, -25, -8, -25, -7,
-22, -7, -22, -5, -20, -4, -20, -3, -17, -2, -18, 0, -14, };