#define DATA_LENGTH 512
#define DATA AKWF_stereo_0110

const PROGMEM int8_t DATA[DATA_LENGTH] = {38, 46, 42, 45, 43, 44, 43, 45, 43,
45, 44, 44, 44, 44, 48, 55, 53, 53, 52, 54, 53, 54, 53, 53, 53, 53, 53, 52, 53,
53, 64, 76, 75, 76, 76, 75, 76, 75, 76, 75, 76, 75, 76, 74, 79, 82, 81, 82, 82,
82, 82, 82, 82, 81, 81, 82, 81, 82, 81, 82, 82, 85, 88, 88, 87, 88, 86, 93, 99,
98, 98, 98, 98, 97, 98, 98, 98, 98, 98, 98, 98, 98, 98, 98, 97, 101, 103, 103,
103, 103, 103, 103, 102, 103, 103, 103, 103, 102, 103, 103, 103, 103, 103, 103,
103, 102, 102, 103, 103, 103, 117, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 120, 119, 119, 119, 119, 119, 118, 119, 118, 119, 119, 119, 119, 119, 118,
118, 119, 118, 119, 119, 119, 118, 120, 118, 120, 116, 101, 103, 103, 102, 102,
102, 103, 102, 102, 103, 102, 102, 102, 102, 102, 102, 102, 101, 102, 102, 102,
102, 102, 102, 103, 99, 97, 98, 97, 97, 97, 98, 97, 97, 97, 97, 97, 97, 97, 98,
97, 98, 91, 85, 87, 85, 87, 87, 83, 80, 81, 79, 81, 80, 80, 80, 81, 80, 80, 81,
80, 80, 80, 80, 80, 81, 75, 73, 74, 73, 74, 75, 73, 73, 73, 74, 74, 74, 74, 61,
56, 50, 50, 51, 50, 51, 50, 51, 50, 51, 50, 50, 51, 50, 50, 44, 39, 42, 40, 42,
40, 42, 41, 41, 41, 41, 42, 40, 41, -11, -47, -42, -45, -44, -45, -43, -45, -44,
-44, -44, -44, -45, -43, -49, -54, -53, -53, -53, -53, -53, -53, -53, -52, -54,
-53, -54, -52, -55, -59, -66, -78, -76, -76, -76, -76, -76, -76, -76, -75, -76,
-76, -76, -74, -80, -83, -82, -82, -83, -82, -82, -82, -81, -82, -82, -82, -82,
-82, -82, -82, -82, -86, -89, -87, -88, -88, -86, -94, -100, -97, -98, -98, -98,
-97, -98, -97, -98, -98, -98, -99, -98, -98, -99, -98, -101, -103, -103, -103,
-102, -103, -103, -102, -103, -103, -103, -103, -103, -103, -102, -103, -102,
-103, -102, -103, -102, -103, -103, -102, -102, -103, -117, -119, -118, -119,
-120, -119, -119, -119, -119, -119, -120, -120, -119, -119, -118, -119, -119,
-119, -120, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -120, -118, -121, -114, -101, -103, -102, -102, -102, -103,
-103, -103, -103, -102, -103, -102, -102, -102, -103, -102, -102, -102, -102,
-101, -103, -101, -102, -102, -102, -99, -97, -97, -97, -97, -97, -97, -96, -97,
-98, -98, -97, -97, -97, -97, -97, -98, -90, -86, -87, -86, -87, -86, -88, -81,
-80, -81, -80, -80, -80, -81, -80, -80, -80, -80, -81, -80, -80, -80, -80, -77,
-73, -74, -74, -74, -74, -74, -73, -74, -73, -74, -73, -74, -73, -60, -56, -50,
-51, -50, -50, -51, -50, -51, -51, -51, -50, -51, -51, -51, -51, -43, -40, -43,
-41, -42, -40, -42, -40, -42, -40, -43, -39, -43, -35, };