#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0039

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 27, 5, 32, 9, 29, 13, 32, 18, 30,
23, 31, 26, 29, 30, 30, 35, 28, 39, 29, 44, 28, 47, 27, 51, 26, 54, 26, 59, 25,
62, 23, 66, 22, 69, 21, 72, 21, 76, 20, 79, 19, 82, 17, 85, 16, 87, 16, 90, 15,
92, 13, 94, 13, 96, 11, 99, 10, 101, 9, 103, 8, 104, 7, 105, 6, 108, 4, 108, 4,
110, 3, 111, 1, 112, 0, 114, -1, 114, -1, 115, -2, 115, -4, 117, -5, 117, -5,
119, -7, 119, -9, 118, -10, 119, -10, 118, -12, 119, -13, 119, -14, 118, -15,
119, -16, 119, -17, 118, -19, 119, -21, 118, -21, 117, -24, 116, -24, 116, -25,
115, -26, 113, -26, 114, -28, 112, -29, 111, -30, 109, -31, 109, -32, 108, -33,
108, -34, 106, -35, 105, -35, 104, -36, 103, -37, 102, -38, 100, -38, 99, -38,
97, -39, 96, -39, 95, -40, 94, -38, 93, -39, 90, -39, 88, -38, 87, -38, 86, -36,
84, -36, 83, -35, 81, -35, 79, -33, 78, -31, 77, -30, 75, -28, 74, -25, 71, -24,
71, -22, 69, -20, 68, -17, 66, -15, 65, -13, 64, -10, 62, -8, 61, -5, 59, -1,
59, 1, 57, 4, 56, 6, 55, 9, 54, 13, 53, 17, 52, 20, 50, 23, 50, 27, 49, 29, 49,
34, 48, 37, 47, 41, 47, 44, 45, 47, 45, 51, 46, 54, 44, 57, 45, 61, 44, 63, 44,
67, 43, 70, 43, 74, 43, 77, 43, 80, 42, 83, 43, 85, 42, 88, 42, 92, 42, 93, 42,
96, 43, 99, 42, 101, 42, 104, 43, 106, 43, 107, 42, 109, 43, 110, 44, 113, 44,
113, 45, 114, 45, 115, 46, 116, 47, 118, 47, 117, 48, 119, 48, 119, 50, 119, 51,
119, 52, 118, 53, 117, 54, 117, 55, 116, 55, 115, 57, 113, 58, 112, 58, 110, 60,
108, 61, 105, 62, 103, 63, 100, 64, 98, 65, 95, 66, 92, 67, 88, 68, 84, 69, 82,
70, 78, 71, 74, 72, 70, 72, 66, 72, 62, 73, 58, 72, 54, 73, 49, 73, 46, 73, 41,
74, 36, 74, 33, 72, 28, 72, 23, 72, 19, 72, 15, 71, 10, 71, 6, 72, 1, 70, -3,
70, -7, 71, -10, 71, -14, 70, -19, 69, -23, 68, -26, 69, -31, 68, -35, 68, -38,
66, -42, 67, -46, 65, -50, 65, -53, 64, -55, 63, -59, 63, -62, 62, -65, 61, -68,
61, -71, 59, -74, 58, -76, 58, -79, 56, -82, 56, -84, 55, -86, 54, -88, 53, -90,
52, -92, 51, -94, 50, -94, 49, -95, 49, -97, 47, -98, 46, -98, 45, -99, 44, -98,
43, -99, 42, -99, 41, -99, 40, -99, 39, -98, 38, -98, 36, -97, 35, -97, 35, -97,
33, -96, 32, -95, 32, -94, 30, -92, 28, -92, 27, -91, 27, -90, 25, -89, 25, -88,
23, -86, 22, -85, 20, -84, 19, -83, 18, -81, 18, -80, 15, -79, 14, -78, 13, -76,
13, -74, 11, -73, 10, -71, 10, -70, 8, -68, 8, -67, 6, -64, 5, -62, 4, -61, 4,
-58, 2, -57, 2, -55, 0, -53, -1, -51, -2, -48, -2, -47, -3, -45, -4, -42, -5,
-40, -5, -38, -6, -37, -6, -35, -8, -32, -8, -32, -9, -29, -10, -27, -11, -26,
-11, -24, -13, -22, -13, -21, -14, -19, -14, -17, -15, -16, -15, -15, -15, -13,
-16, -12, -17, -12, -18, -9, -18, -9, -19, -7, -18, -7, -20, -6, -20, -4, -20,
-4, -21, -2, -21, -1, -21, 1, -21, 2, -22, 4, -22, 6, -23, 8, -22, 10, -22, 11,
-23, 14, -23, 15, -23, 17, -23, 20, -23, 23, -24, 24, -24, 26, -23, 28, -23, 30,
-23, 34, -24, 35, -23, 37, -23, 40, -24, 43, -25, 45, -26, 46, -25, 48, -26, 50,
-26, 51, -27, 52, -28, 54, -29, 54, -28, 55, -30, 56, -30, 57, -31, 57, -32, 57,
-34, 58, -34, 58, -35, 58, -36, 58, -37, 58, -39, 58, -40, 57, -41, 58, -42, 57,
-43, 58, -43, 56, -46, 56, -46, 57, -48, 55, -48, 55, -50, 55, -52, 54, -53, 53,
-55, 52, -56, 51, -57, 50, -58, 48, -60, 47, -62, 46, -64, 44, -66, 43, -67, 41,
-69, 40, -72, 37, -73, 36, -75, 33, -77, 31, -79, 28, -80, 25, -83, 22, -84, 20,
-85, 17, -88, 13, -90, 10, -92, 7, -93, 4, -96, 0, -97, -4, -99, -7, -101, -11,
-102, -14, -105, -19, -105, -22, -107, -25, -109, -29, -110, -32, -111, -36,
-112, -38, -113, -41, -114, -43, -115, -47, -115, -49, -115, -52, -116, -54,
-117, -56, -117, -59, -118, -60, -117, -62, -118, -63, -118, -65, -118, -67,
-117, -68, -118, -69, -118, -70, -118, -72, -118, -72, -117, -73, -117, -74,
-117, -75, -116, -76, -116, -76, -115, -77, -113, -77, -112, -78, -113, -77,
-111, -78, -110, -77, -108, -77, -109, -77, -107, -76, -107, -76, -105, -76,
-104, -75, -103, -74, -103, -73, -102, -72, -101, -70, -100, -69, -99, -67, -99,
-66, -98, -64, -98, -62, -96, -60, -97, -57, -96, -54, -95, -53, -96, -50, -95,
-47, -95, -45, -96, -41, -96, -39, -97, -36, -97, -32, -97, -29, -97, -25, -99,
-22, -99, -19, -99, -16, -100, -13, -101, -10, -102, -7, -103, -5, -104, -2,
-105, 0, -105, 3, -106, 5, -107, 8, -107, 10, -108, 12, -109, 13, -109, 16,
-110, 18, -110, 19, -110, 21, -110, 22, -111, 23, -111, 25, -111, 27, -111, 28,
-111, 29, -111, 30, -110, 32, -110, 33, -109, 34, -108, 36, -106, 36, -107, 37,
-105, 38, -104, 39, -103, 40, -101, 40, -100, 42, -98, 41, -97, 42, -96, 43,
-94, 43, -93, 43, -91, 43, -88, 43, -87, 43, -85, 43, -83, 42, -79, 42, -77, 42,
-74, 41, -71, 41, -68, 42, -66, 40, -62, 40, -59, 39, -56, 39, -52, 39, -49, 39,
-45, 37, -41, 38, -36, 35, -34, 37, -29, 34, -26, 35, -21, 33, -16, 35, -12, 32,
-8, 35, -3, 27, };