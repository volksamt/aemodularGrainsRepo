#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0047

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 37, 101, 122, 115, 101, 78, 58,
78, 71, 92, 90, 90, 75, 85, 66, 97, 83, 93, 83, 81, 72, 78, 77, 88, 86, 84, 79,
82, 74, 85, 83, 83, 83, 73, 75, 75, 79, 81, 84, 79, 79, 76, 76, 79, 82, 78, 81,
73, 76, 74, 79, 79, 83, 79, 79, 78, 77, 80, 82, 79, 82, 76, 77, 79, 79, 82, 83,
81, 79, 79, 78, 82, 81, 83, 80, 80, 78, 81, 80, 85, 82, 83, 79, 81, 79, 84, 82,
83, 80, 81, 78, 81, 80, 84, 81, 82, 80, 80, 79, 82, 82, 81, 81, 80, 78, 81, 80,
82, 81, 80, 79, 80, 79, 82, 82, 81, 80, 79, 78, 80, 80, 82, 82, 80, 79, 79, 79,
81, 82, 81, 81, 80, 78, 81, 80, 82, 81, 80, 79, 80, 79, 81, 81, 81, 81, 80, 79,
81, 79, 82, 81, 81, 79, 80, 80, 81, 81, 81, 80, 80, 78, 81, 80, 82, 81, 81, 79,
81, 79, 82, 81, 81, 80, 80, 78, 81, 81, 81, 81, 80, 79, 80, 80, 81, 80, 80, 80,
80, 79, 80, 81, 81, 81, 80, 79, 80, 80, 81, 80, 80, 80, 80, 78, 81, 80, 81, 81,
80, 79, 80, 79, 81, 81, 81, 81, 80, 79, 81, 81, 81, 81, 80, 80, 81, 79, 81, 81,
80, 80, 80, 79, 81, 80, 81, 80, 81, 79, 81, 79, 81, 80, 80, 79, 80, 79, 81, 80,
81, 80, 80, 78, 80, 80, 81, 80, 81, 80, 81, 79, 81, 81, 82, 80, 80, 79, 81, 80,
81, 80, 81, 79, 80, 80, 82, 80, 81, 80, 80, 80, 81, 79, 81, 81, 80, 79, 80, 79,
81, 80, 81, 81, 80, 79, 80, 80, 80, 80, 80, 80, 81, 80, 81, 80, 81, 80, 81, 79,
81, 80, 81, 80, 81, 80, 81, 79, 81, 80, 81, 80, 80, 80, 80, 80, 81, 81, 81, 79,
80, 79, 82, 80, 81, 80, 81, 80, 81, 80, 81, 80, 80, 80, 80, 80, 80, 81, 81, 80,
80, 80, 81, 80, 81, 80, 80, 81, 81, 80, 81, 80, 81, 80, 81, 80, 81, 80, 81, 81,
80, 80, 81, 79, 81, 81, 81, 79, 80, 80, 81, 80, 80, 80, 81, 80, 80, 79, 81, 80,
81, 80, 80, 79, 80, 80, 81, 80, 81, 80, 81, 80, 82, 80, 81, 80, 81, 80, 81, 80,
81, 80, 81, 80, 81, 79, 81, 81, 81, 80, 81, 80, 80, 80, 81, 79, 80, 79, 81, 80,
80, 80, 80, 80, 81, 81, 80, 79, 81, 80, 80, 79, 81, 80, 81, 80, 81, 80, 81, 80,
81, 81, 81, 80, 81, 80, 80, 80, 81, 81, 81, 80, 81, 80, 81, 81, 81, 80, 81, 80,
81, 79, 81, 80, 80, 80, 80, 80, 80, 80, 81, 80, 80, 79, 81, 81, 81, 80, 80, 79,
81, 79, 80, 80, 81, 80, 81, 80, 82, 79, 81, 79, 81, 80, 81, 80, 81, 80, 80, 80,
81, 80, 81, 81, 81, 79, 81, 81, 81, 80, 81, 80, 80, 81, 81, 80, 81, 80, 81, 80,
81, 80, 81, 80, 80, 80, 81, 80, 81, 80, 81, 80, 81, 80, 81, 80, 81, 79, 80, 79,
81, 80, 81, 80, 81, 80, 80, 80, 81, 80, 80, 80, 81, 80, 80, 80, 80, 80, 80, 80,
80, 80, 80, 81, 81, 81, 81, 80, 81, 79, 80, 81, 80, 80, 81, 79, 81, 80, 81, 81,
81, 80, 80, 79, 81, 80, 81, 80, 80, 79, 80, 80, 80, 80, 81, 80, 81, 80, 81, 80,
80, 80, 81, 80, 80, 80, 80, 79, 80, 80, 80, 80, 82, 80, 80, 80, 81, 79, 80, 80,
81, 79, 81, 80, 80, 80, 81, 80, 80, 80, 80, 80, 82, 80, 81, 80, 80, 80, 81, 80,
82, 80, 80, 80, 80, 80, 81, 80, 81, 80, 80, 80, 81, 80, 81, 81, 81, 80, 81, 79,
81, 80, 80, 80, 81, 79, 81, 80, 82, 80, 81, 79, 80, 80, 82, 81, 81, 80, 81, 80,
81, 80, 81, 81, 80, 79, 80, 80, 81, 80, 81, 80, 80, 79, 80, 81, 81, 80, 80, 79,
81, 80, 81, 81, 80, 80, 80, 80, 81, 81, 82, 80, 80, 79, 80, 80, 81, 81, 80, 80,
80, 79, 81, 81, 81, 80, 81, 79, 81, 80, 82, 82, 80, 79, 80, 79, 81, 81, 81, 81,
80, 79, 81, 80, 81, 82, 80, 79, 80, 78, 80, 79, 81, 79, 80, 79, 80, 80, 80, 80,
80, 79, 79, 78, 80, 80, 80, 80, 79, 78, 80, 79, 80, 80, 79, 79, 79, 78, 80, 79,
80, 80, 78, 78, 80, 79, 80, 80, 80, 78, 80, 79, 81, 79, 80, 80, 79, 78, 80, 79,
80, 80, 79, 78, 79, 78, 80, 80, 80, 78, 79, 78, 80, 79, 81, 80, 80, 77, 78, 79,
81, 81, 81, 79, 79, 77, 80, 80, 81, 81, 79, 78, 79, 78, 81, 80, 80, 80, 79, 77,
80, 80, 81, 81, 78, 77, 78, 78, 81, 81, 80, 79, 79, 77, 80, 80, 81, 81, 79, 78,
78, 78, 81, 81, 81, 79, 78, 77, 81, 80, 81, 80, 78, 76, 79, 78, 81, 82, 80, 78,
78, 76, 80, 81, 82, 80, 78, 76, 79, 79, 82, 82, 80, 78, 78, 77, 80, 81, 81, 81,
77, 75, 79, 79, 82, 83, 79, 77, 77, 76, 82, 83, 82, 81, 77, 74, 78, 79, 84, 84,
79, 76, 76, 75, 83, 84, 83, 82, 75, 72, 79, 80, 86, 87, 78, 74, 72, 71, 86, 90,
85, 84, 68, 61, 78, 81, 105, 112, 66, 52, -42, -72, -114, -123, -102, -85, -77,
-60, -82, -78, -91, -84, -90, -72, -92, -72, -98, -82, -91, -79, -81, -75, -83,
-80, -86, -81, -86, -78, -86, -79, -84, -79, -79, -80, -77, -80, -76, -79, -77,
-79, -79, -81, -81, -81, -74, -76, -75, -80, -76, -84, -76, -79, -72, -73, -83,
-86, -82, -84, -71, -66, -70, -77, -101, -110, -65, -59, };