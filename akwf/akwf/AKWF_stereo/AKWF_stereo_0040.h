#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0040

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 8, 3, 4, 7, -3, 9, -7, 13, -12, 15,
-16, 19, -21, 21, -23, 23, -27, 26, -29, 28, -29, 30, -29, 31, -30, 32, -29, 33,
-28, 35, -26, 35, -23, 36, -22, 36, -19, 38, -20, 38, -20, 39, -20, 41, -21, 41,
-20, 43, -20, 44, -19, 45, -17, 47, -15, 47, -13, 47, -12, 50, -11, 50, -11, 50,
-10, 50, -10, 50, -10, 50, -11, 50, -11, 50, -12, 50, -11, 50, -10, 50, -10, 50,
-10, 49, -8, 50, -7, 50, -4, 51, -1, 51, 3, 51, 7, 52, 9, 53, 10, 53, 11, 53,
11, 55, 11, 55, 10, 56, 11, 57, 9, 57, 8, 57, 6, 59, 4, 60, 0, 61, -3, 62, -6,
64, -9, 65, -11, 66, -12, 68, -13, 69, -12, 72, -12, 73, -10, 75, -7, 77, -6,
78, -4, 80, -2, 82, -1, 83, 2, 85, 3, 87, 5, 89, 7, 91, 8, 92, 9, 94, 11, 95,
12, 97, 14, 97, 15, 97, 15, 98, 17, 99, 16, 100, 16, 101, 15, 104, 14, 104, 11,
106, 10, 108, 8, 109, 7, 110, 9, 111, 8, 111, 7, 111, 6, 111, 6, 113, 8, 113, 8,
113, 10, 114, 11, 114, 10, 115, 11, 115, 12, 115, 14, 113, 13, 112, 14, 111, 14,
111, 13, 111, 13, 111, 13, 111, 14, 111, 15, 110, 18, 110, 19, 109, 20, 109, 22,
109, 25, 108, 28, 108, 33, 108, 35, 107, 40, 108, 43, 108, 45, 108, 48, 109, 49,
110, 51, 110, 52, 110, 55, 111, 59, 110, 61, 109, 65, 109, 68, 108, 72, 107, 75,
107, 77, 107, 79, 105, 80, 105, 82, 103, 82, 103, 82, 103, 81, 102, 79, 101, 78,
101, 76, 100, 75, 99, 74, 98, 74, 98, 74, 98, 75, 98, 77, 98, 80, 97, 83, 96,
84, 95, 87, 94, 89, 94, 90, 93, 93, 92, 94, 91, 96, 91, 98, 90, 99, 90, 97, 91,
96, 90, 95, 88, 93, 88, 89, 88, 86, 88, 82, 88, 78, 87, 76, 88, 73, 87, 69, 87,
66, 87, 61, 85, 57, 85, 52, 85, 48, 84, 44, 85, 40, 85, 37, 84, 34, 84, 31, 84,
27, 84, 24, 83, 20, 82, 14, 81, 7, 81, 1, 79, -5, 78, -13, 78, -19, 78, -26, 77,
-34, 75, -40, 74, -46, 71, -51, 70, -55, 68, -57, 66, -59, 64, -62, 63, -62, 61,
-64, 58, -66, 57, -68, 55, -70, 54, -71, 52, -73, 51, -74, 49, -76, 49, -79, 48,
-79, 46, -77, 45, -77, 44, -77, 42, -75, 40, -75, 38, -74, 36, -76, 34, -76, 34,
-76, 31, -76, 29, -76, 27, -77, 25, -78, 23, -79, 21, -79, 20, -81, 18, -82, 17,
-85, 17, -86, 14, -89, 13, -90, 12, -90, 11, -87, 11, -83, 9, -79, 9, -73, 7,
-69, 8, -65, 6, -62, 4, -58, 4, -54, 4, -50, 2, -47, 2, -43, 1, -41, 0, -39, -1,
-37, -3, -34, -4, -33, -6, -32, -9, -32, -11, -31, -15, -28, -18, -26, -21, -27,
-24, -27, -27, -27, -31, -26, -33, -25, -36, -25, -38, -24, -40, -23, -42, -21,
-45, -17, -47, -14, -49, -11, -52, -8, -54, -7, -57, -5, -59, -3, -61, -3, -63,
-3, -65, -3, -67, -2, -69, -2, -71, -1, -73, 1, -76, 0, -78, 2, -80, 3, -81, 3,
-83, 5, -84, 8, -85, 8, -87, 9, -88, 8, -92, 8, -92, 7, -95, 6, -97, 5, -98, 6,
-100, 5, -100, 3, -101, 5, -102, 6, -102, 6, -102, 5, -103, 1, -105, -1, -105,
-3, -104, -5, -105, -7, -103, -10, -101, -13, -101, -16, -100, -19, -100, -24,
-98, -29, -97, -32, -98, -36, -97, -39, -94, -41, -92, -41, -90, -40, -88, -40,
-86, -37, -84, -36, -81, -35, -79, -34, -77, -35, -75, -36, -73, -37, -70, -38,
-67, -37, -64, -36, -62, -33, -59, -29, -57, -27, -56, -25, -54, -23, -53, -24,
-53, -24, -53, -25, -52, -25, -50, -26, -50, -25, -50, -25, -50, -25, -50, -26,
-49, -27, -48, -26, -47, -27, -47, -28, -47, -28, -47, -27, -47, -27, -48, -26,
-49, -25, -49, -24, -50, -21, -52, -18, -52, -18, -54, -17, -55, -17, -57, -19,
-59, -18, -60, -18, -62, -20, -63, -23, -64, -24, -65, -25, -66, -25, -66, -27,
-66, -28, -67, -31, -67, -32, -68, -34, -69, -34, -68, -36, -70, -37, -69, -37,
-69, -38, -69, -39, -69, -41, -69, -43, -71, -47, -75, -50, -77, -54, -79, -57,
-81, -62, -82, -66, -85, -70, -86, -74, -87, -80, -88, -85, -88, -90, -89, -94,
-91, -98, -91, -101, -91, -104, -92, -105, -94, -107, -93, -107, -93, -108, -94,
-108, -94, -107, -96, -105, -98, -103, -100, -102, -102, -101, -103, -101, -105,
-101, -107, -100, -107, -99, -109, -98, -110, -97, -110, -94, -110, -91, -111,
-84, -112, -79, -113, -75, -114, -70, -114, -65, -116, -60, -117, -56, -118,
-52, -119, -48, -119, -44, -118, -40, -117, -35, -114, -30, -112, -25, -108,
-22, -106, -21, -103, -18, -101, -17, -98, -17, -95, -15, -92, -12, -89, -8,
-85, -3, -82, 2, -80, 7, -77, 14, -74, 18, -71, 23, -69, 27, -67, 31, -65, 33,
-62, 35, -59, 37, -56, 40, -54, 44, -52, 48, -51, 53, -49, 57, -48, 62, -46, 66,
-44, 70, -44, 76, -44, 79, -42, 82, -42, 85, -41, 87, -41, 90, -39, 93, -37, 94,
-39, 94, -38, 95, -39, 95, -41, 97, -42, 98, -43, 100, -44, 102, -46, 104, -47,
105, -49, 106, -51, 107, -51, 108, -52, 110, -52, 111, -53, 114, -53, 115, -53,
117, -53, 118, -53, 119, -52, 119, -51, 118, -49, 116, -48, 115, -47, 113, -46,
110, -45, 108, -44, 105, -44, 103, -42, 101, -41, 98, -41, 95, -39, 92, -38, 87,
-36, 82, -33, 77, -32, 73, -31, 68, -30, 67, -29, 63, -26, 63, -24, 60, -22, 57,
-20, 53, -18, 48, -16, 43, -13, 39, -12, 33, -9, 29, -6, 24, -4, 20, -2, 13, };