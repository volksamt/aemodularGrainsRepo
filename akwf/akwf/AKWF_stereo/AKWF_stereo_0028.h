#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0028

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 76, 3, 91, 6, 85, 9, 91, 11, 89,
13, 94, 17, 91, 19, 96, 22, 94, 23, 98, 27, 97, 28, 100, 31, 97, 33, 98, 35, 96,
36, 94, 39, 92, 42, 88, 44, 85, 47, 82, 50, 79, 53, 75, 57, 73, 61, 70, 65, 70,
68, 69, 71, 67, 75, 68, 77, 69, 80, 70, 83, 70, 86, 71, 88, 72, 92, 72, 93, 72,
96, 71, 97, 71, 99, 68, 100, 67, 101, 66, 103, 64, 103, 62, 104, 61, 106, 59,
108, 58, 108, 58, 111, 58, 112, 58, 113, 57, 115, 57, 117, 57, 118, 56, 118, 55,
118, 54, 119, 51, 119, 51, 119, 48, 118, 46, 119, 44, 119, 41, 118, 40, 118, 38,
117, 37, 116, 35, 115, 33, 115, 32, 115, 33, 114, 31, 113, 30, 113, 28, 112, 26,
112, 25, 113, 24, 113, 22, 114, 21, 113, 20, 113, 20, 112, 21, 112, 20, 112, 21,
112, 21, 111, 22, 111, 22, 110, 22, 109, 23, 108, 22, 107, 21, 106, 20, 105, 19,
103, 16, 101, 13, 100, 11, 99, 9, 96, 6, 95, 4, 93, 2, 91, -1, 90, -3, 88, -4,
86, -5, 85, -6, 84, -8, 83, -10, 82, -10, 82, -11, 81, -13, 81, -14, 81, -15,
80, -16, 81, -16, 81, -18, 81, -19, 81, -20, 81, -21, 82, -21, 82, -22, 82, -23,
83, -23, 82, -24, 82, -24, 82, -24, 83, -24, 82, -24, 82, -23, 81, -22, 81, -21,
81, -19, 80, -17, 78, -16, 77, -13, 77, -11, 77, -9, 76, -7, 76, -5, 76, -3, 76,
-1, 75, 0, 75, 0, 75, 1, 74, 2, 75, 2, 74, 2, 73, 3, 72, 3, 72, 3, 71, 4, 69, 4,
67, 6, 65, 7, 63, 8, 61, 9, 59, 10, 57, 11, 55, 12, 54, 13, 53, 15, 51, 16, 50,
18, 50, 20, 50, 24, 49, 27, 50, 30, 49, 33, 50, 37, 51, 41, 51, 42, 52, 45, 53,
47, 53, 48, 54, 49, 55, 49, 56, 48, 58, 47, 58, 45, 58, 44, 59, 40, 60, 39, 60,
36, 59, 33, 59, 32, 58, 30, 57, 29, 56, 27, 55, 26, 54, 25, 52, 23, 52, 21, 50,
19, 49, 16, 48, 14, 48, 12, 49, 9, 49, 7, 49, 4, 50, 3, 50, 0, 50, -2, 52, -3,
51, -5, 50, -6, 49, -9, 48, -11, 46, -13, 44, -17, 42, -21, 40, -23, 38, -26,
35, -29, 33, -32, 32, -36, 30, -38, 28, -41, 27, -43, 26, -46, 26, -48, 23, -49,
23, -52, 23, -53, 22, -55, 22, -57, 22, -60, 22, -61, 23, -63, 24, -64, 24, -67,
26, -71, 27, -73, 27, -77, 30, -82, 32, -85, 33, -89, 35, -95, 37, -98, 39,
-103, 41, -107, 42, -110, 43, -114, 45, -115, 46, -117, 47, -118, 48, -118, 49,
-119, 49, -119, 49, -118, 50, -118, 49, -118, 50, -118, 50, -118, 49, -117, 49,
-117, 48, -117, 48, -116, 46, -116, 45, -116, 44, -115, 42, -115, 41, -115, 40,
-113, 39, -112, 36, -112, 36, -110, 34, -109, 34, -107, 33, -105, 32, -103, 31,
-101, 30, -99, 29, -97, 29, -95, 27, -93, 27, -91, 26, -87, 25, -85, 23, -81,
22, -79, 20, -75, 19, -74, 17, -71, 16, -68, 14, -66, 12, -65, 10, -64, 8, -63,
5, -63, 4, -61, 2, -62, 0, -62, 0, -60, -2, -60, -4, -59, -6, -57, -8, -56, -9,
-55, -11, -53, -12, -50, -13, -47, -16, -45, -18, -43, -21, -41, -25, -38, -28,
-35, -31, -34, -34, -32, -39, -31, -42, -30, -46, -29, -49, -28, -53, -27, -57,
-26, -61, -26, -64, -25, -66, -23, -69, -23, -72, -20, -73, -20, -76, -18, -78,
-16, -79, -14, -80, -12, -81, -10, -82, -7, -83, -5, -85, -2, -86, 1, -88, 3,
-90, 6, -92, 8, -93, 12, -96, 14, -96, 16, -98, 20, -100, 21, -101, 24, -102,
26, -102, 28, -103, 29, -104, 30, -104, 32, -104, 34, -105, 35, -106, 36, -105,
38, -107, 40, -107, 42, -109, 45, -108, 47, -108, 50, -109, 53, -108, 56, -108,
59, -108, 61, -106, 63, -106, 65, -104, 67, -103, 68, -102, 70, -100, 70, -99,
71, -99, 70, -99, 72, -100, 71, -101, 70, -101, 70, -102, 69, -103, 67, -104,
66, -103, 64, -104, 63, -102, 61, -102, 59, -101, 57, -100, 56, -100, 55, -100,
53, -100, 52, -99, 52, -99, 52, -99, 52, -98, 52, -98, 52, -97, 52, -97, 52,
-96, 53, -95, 52, -96, 52, -95, 52, -94, 50, -94, 49, -94, 48, -93, 47, -94, 45,
-94, 43, -95, 41, -96, 38, -97, 35, -98, 32, -101, 30, -102, 26, -104, 23, -105,
18, -106, 14, -108, 9, -109, 5, -110, -2, -111, -6, -109, -12, -110, -16, -110,
-21, -109, -26, -110, -31, -109, -34, -108, -38, -109, -43, -109, -46, -108,
-49, -108, -52, -109, -54, -109, -56, -109, -59, -109, -62, -110, -63, -110,
-65, -109, -67, -110, -70, -109, -71, -110, -72, -109, -73, -107, -74, -107,
-75, -107, -75, -106, -76, -105, -75, -103, -74, -102, -72, -100, -71, -99, -70,
-97, -69, -95, -69, -92, -68, -91, -69, -89, -70, -88, -70, -86, -70, -86, -70,
-84, -71, -85, -70, -85, -69, -84, -68, -83, -68, -85, -66, -84, -64, -86, -63,
-86, -61, -86, -59, -86, -58, -87, -56, -86, -54, -86, -53, -86, -52, -86, -49,
-84, -46, -83, -43, -82, -39, -81, -35, -80, -30, -80, -26, -79, -20, -80, -14,
-79, -9, -78, -4, -78, 2, -78, 7, -78, 13, -77, 18, -77, 21, -76, 25, -76, 29,
-76, 32, -75, 34, -73, 38, -74, 41, -72, 45, -70, 49, -70, 54, -67, 57, -65, 60,
-63, 64, -63, 67, -60, 69, -59, 71, -57, 71, -55, 72, -52, 72, -51, 71, -48, 70,
-45, 68, -42, 67, -39, 65, -37, 64, -34, 62, -31, 65, -27, 64, -25, 67, -23, 67,
-20, 71, -18, 71, -15, 76, -12, 75, -10, 82, -8, 78, -5, 88, -2, 72, };