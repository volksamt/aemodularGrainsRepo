#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0157

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 2, 32, 19, 86, 51, 117, 69, 118,
69, 117, 69, 115, 68, 115, 68, 114, 67, 114, 67, 113, 67, 113, 66, 112, 67, 111,
66, 110, 65, 110, 65, 110, 65, 109, 65, 109, 64, 107, 63, 108, 63, 106, 64, 106,
63, 105, 63, 104, 61, 105, 62, 103, 62, 103, 61, 102, 61, 102, 60, 101, 60, 100,
60, 99, 60, 98, 59, 98, 58, 98, 58, 98, 57, 97, 58, 96, 57, 96, 57, 96, 57, 95,
57, 94, 57, 94, 56, 92, 56, 92, 55, 92, 55, 91, 54, 91, 55, 91, 55, 91, 54, 89,
54, 89, 54, 88, 53, 87, 53, 88, 53, 86, 52, 86, 52, 85, 52, 85, 52, 85, 51, 84,
51, 84, 51, 83, 50, 83, 50, 82, 49, 83, 49, 81, 49, 77, 47, 48, 30, -8, -3, -39,
-20, -40, -22, -39, -21, -39, -20, -39, -21, -39, -20, -38, -21, -38, -20, -38,
-20, -37, -20, -38, -19, -38, -19, -36, -19, -37, -19, -36, -20, -37, -20, -37,
-20, -36, -18, -36, -19, -35, -18, -36, -19, -35, -18, -35, -18, -35, -18, -34,
-17, -35, -18, -35, -17, -34, -18, -34, -16, -34, -17, -33, -17, -33, -17, -33,
-17, -33, -17, -34, -16, -33, -16, -32, -16, -32, -15, -32, -15, -32, -15, -31,
-16, -32, -15, -31, -15, -30, -16, -31, -15, -31, -14, -31, -15, -30, -15, -30,
-14, -31, -14, -30, -14, -29, -14, -29, -14, -29, -14, -29, -14, -29, -13, -28,
-14, -29, -13, -29, -13, -28, -13, -28, -13, -28, -13, -27, -12, -28, -12, -27,
-13, -27, -12, -27, -12, -26, -12, -27, -11, -27, -11, -26, -12, -26, -11, -26,
-12, -26, -11, -26, -11, -26, -11, -26, -10, -25, -10, -26, -10, -25, -10, -25,
-11, -24, -10, -25, -10, -24, -10, -24, -10, -23, -9, -23, -10, -23, -9, -23,
-10, -24, -9, -24, -10, -23, -9, -23, -8, -23, -9, -22, -9, -23, -9, -22, -8,
-22, -8, -22, -8, -22, -8, -22, -8, -21, -8, -21, -8, -20, -7, -20, -7, -21, -7,
-21, -8, -20, -7, -20, -7, -20, -6, -20, -7, -20, -7, -20, -6, -20, -7, -20, -7,
-19, -5, -19, -6, -19, -6, -19, -6, -19, -6, -19, -6, -18, -5, -18, -5, -18, -5,
-18, -5, -18, -5, -18, -4, -17, -5, -17, -5, -18, -4, -17, -4, -18, -4, -17, -4,
-17, -4, -17, -4, -16, -4, -17, -3, -17, -3, -15, -4, -16, -3, -16, -3, -16, -3,
-16, -2, -15, -2, -15, -3, -15, -2, -15, -2, -15, -2, -15, -2, -15, -2, -15, -2,
-14, -2, -14, -1, -14, -2, -14, -2, -14, -1, -14, -1, -13, -1, -13, -1, -13, -1,
-13, -1, -14, 0, -13, -1, -13, 0, -13, 0, -12, 0, -12, 0, -13, 0, -12, 0, -12,
1, -12, 0, -12, 0, -11, 1, -11, 0, -11, 1, -11, 1, -11, 1, -11, 1, -11, 1, -11,
1, -11, 1, -10, 3, -11, 2, -11, 2, -11, 3, -10, 3, -9, 3, -11, 3, -10, 2, -9, 3,
-9, 4, -10, 3, -9, 3, -10, 4, -9, 3, -9, 3, -9, 3, -9, 5, -8, 5, -9, 5, -8, 4,
-9, 4, -8, 4, -7, 5, -8, 5, -7, 5, -7, 5, -8, 4, -8, 5, -7, 6, -8, 5, -7, 6, -7,
6, -6, 5, -7, 7, -7, 7, -7, 6, -6, 7, -7, 6, -7, 7, -6, 7, -6, 7, -6, 8, -6, 7,
-6, 7, -5, 7, -5, 7, -6, 8, -4, 9, -5, 7, -5, 8, -5, 8, -5, 7, -5, 9, -5, 9, -5,
9, -4, 10, -4, 9, -5, 9, -5, 9, -3, 9, -4, 9, -3, 9, -3, 10, -3, 9, -3, 10, -3,
10, -2, 11, -3, 11, -2, 10, -3, 11, -3, 11, -3, 12, -3, 11, -3, 12, -2, 10, -2,
11, -2, 12, -1, 11, -2, 12, -2, 12, -1, 12, -1, 12, -2, 12, -1, 12, -1, 12, -1,
13, -2, 13, -1, 13, -1, 14, -1, 13, -1, 13, -1, 13, 0, 14, -1, 14, 0, 14, 0, 14,
0, 14, 0, 14, -1, 14, 0, 15, 0, 15, 0, 14, 0, 15, 0, 15, 1, 15, 0, 16, 1, 16, 1,
15, 1, 16, 1, 16, 1, 16, 1, 16, 2, 17, 2, 16, 2, 16, 2, 16, 2, 17, 3, 17, 2, 18,
2, 17, 3, 17, 3, 17, 3, 18, 3, 18, 3, 18, 3, 18, 3, 19, 3, 19, 2, 19, 3, 18, 4,
19, 4, 18, 4, 19, 4, 20, 4, 19, 4, 20, 4, 20, 5, 20, 4, 21, 4, 20, 5, 21, 5, 21,
5, 21, 5, 21, 5, 20, 6, 21, 4, 22, 5, 22, 5, 23, 6, 22, 6, 23, 6, 22, 6, 22, 6,
22, 6, 22, 6, 23, 6, 23, 6, 23, 6, 23, 6, 23, 7, 23, 6, 24, 6, 24, 7, 24, 7, 24,
7, 24, 8, 25, 7, 25, 7, 24, 8, 25, 7, 25, 8, 26, 8, 25, 8, 25, 8, 25, 8, 26, 9,
26, 8, 26, 8, 27, 9, 26, 9, 27, 9, 27, 8, 27, 9, 28, 9, 28, 9, 28, 8, 28, 9, 29,
10, 28, 9, 29, 9, 29, 9, 28, 9, 29, 10, 29, 10, 30, 9, 29, 10, 29, 10, 30, 11,
30, 11, 30, 11, 33, 4, 16, -16, -33, -34, -74, -37, -83, -37, -83, -38, -84,
-38, -85, -38, -84, -39, -85, -39, -85, -39, -86, -38, -86, -40, -86, -39, -87,
-40, -88, -40, -89, -41, -89, -41, -89, -40, -89, -41, -91, -40, -91, -41, -92,
-42, -93, -41, -92, -42, -94, -42, -93, -42, -94, -42, -95, -42, -95, -42, -95,
-43, -96, -43, -97, -44, -97, -43, -99, -44, -98, -44, -99, -44, -100, -45,
-100, -45, -100, -44, -101, -45, -101, -45, -102, -46, -103, -46, -104, -46,
-104, -45, -105, -46, -105, -48, -106, -47, -107, -47, -108, -47, -108, -48,
-108, -49, -109, -48, -109, -48, -110, -49, -113, -42, -97, -22, -47, -4, -8, };