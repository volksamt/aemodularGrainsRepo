#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0136

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -3, 4, -1, 8, 3, 10, 6, 13, 8, 16,
11, 19, 13, 21, 16, 24, 18, 26, 21, 29, 24, 32, 26, 34, 29, 36, 31, 40, 33, 41,
36, 42, 37, 45, 40, 48, 42, 49, 43, 51, 45, 52, 47, 54, 49, 56, 51, 58, 53, 59,
55, 61, 55, 62, 57, 63, 58, 64, 60, 65, 61, 66, 62, 67, 62, 68, 63, 69, 64, 69,
65, 70, 66, 71, 67, 70, 67, 72, 67, 72, 67, 71, 68, 72, 69, 73, 69, 73, 69, 73,
70, 73, 70, 73, 70, 74, 69, 74, 69, 72, 69, 74, 69, 72, 70, 72, 69, 73, 70, 72,
70, 72, 70, 72, 70, 72, 69, 71, 69, 71, 68, 71, 69, 71, 68, 70, 69, 70, 69, 70,
68, 69, 68, 69, 67, 69, 68, 69, 67, 68, 67, 68, 67, 68, 67, 67, 67, 67, 66, 68,
67, 67, 66, 66, 66, 66, 66, 66, 66, 66, 65, 65, 65, 66, 65, 65, 65, 65, 65, 65,
65, 64, 65, 64, 64, 63, 65, 63, 64, 63, 65, 63, 64, 62, 64, 62, 63, 61, 62, 61,
63, 61, 62, 60, 63, 59, 62, 59, 61, 57, 60, 57, 59, 57, 59, 56, 58, 54, 58, 53,
56, 53, 56, 50, 54, 50, 54, 48, 52, 46, 51, 45, 50, 44, 49, 43, 46, 40, 45, 39,
44, 36, 42, 35, 40, 33, 38, 31, 36, 28, 34, 27, 32, 24, 30, 21, 27, 19, 25, 16,
22, 13, 19, 10, 17, 8, 13, 5, 11, 2, 9, -2, 5, -5, 2, -7, -1, -11, -4, -14, -8,
-18, -10, -20, -14, -23, -17, -28, -20, -31, -24, -35, -27, -37, -30, -41, -34,
-45, -38, -47, -41, -51, -44, -54, -48, -57, -51, -61, -54, -64, -58, -68, -61,
-71, -64, -75, -67, -76, -71, -80, -74, -83, -76, -86, -80, -88, -82, -91, -85,
-94, -87, -96, -90, -98, -93, -100, -94, -102, -97, -105, -99, -107, -102, -109,
-104, -110, -105, -112, -107, -113, -108, -114, -110, -115, -112, -116, -113,
-117, -113, -118, -115, -118, -115, -118, -115, -119, -116, -120, -117, -120,
-117, -119, -116, -119, -116, -118, -116, -117, -116, -117, -115, -116, -114,
-115, -113, -114, -112, -112, -111, -110, -110, -108, -109, -106, -107, -104,
-105, -103, -104, -100, -103, -98, -100, -95, -98, -93, -96, -91, -94, -89, -91,
-86, -89, -83, -86, -80, -84, -78, -82, -75, -79, -72, -76, -70, -73, -65, -71,
-63, -69, -61, -65, -57, -62, -54, -60, -51, -57, -49, -54, -45, -52, -42, -49,
-39, -45, -36, -43, -33, -40, -31, -38, -29, -35, -26, -33, -24, -30, -21, -27,
-17, -25, -15, -23, -13, -21, -10, -18, -7, -16, -5, -14, -3, -12, -1, -9, 0,
-7, 4, -5, 5, -3, 6, -1, 8, 1, 10, 3, 13, 4, 14, 5, 16, 8, 17, 10, 19, 11, 20,
12, 23, 15, 24, 16, 24, 18, 25, 18, 27, 20, 29, 21, 30, 23, 31, 23, 31, 25, 34,
26, 35, 27, 36, 29, 37, 30, 38, 31, 39, 33, 40, 34, 41, 35, 42, 36, 43, 36, 44,
39, 44, 39, 46, 40, 47, 41, 48, 43, 49, 45, 50, 45, 50, 46, 52, 48, 53, 49, 53,
49, 55, 51, 55, 51, 57, 53, 57, 54, 58, 56, 60, 56, 60, 57, 60, 59, 62, 60, 62,
60, 63, 62, 64, 63, 65, 64, 66, 65, 66, 66, 67, 67, 67, 67, 68, 68, 68, 69, 69,
69, 70, 71, 71, 72, 71, 73, 72, 72, 72, 73, 71, 74, 73, 74, 73, 75, 73, 76, 73,
76, 73, 76, 73, 76, 73, 76, 74, 77, 73, 76, 73, 76, 71, 76, 72, 76, 71, 76, 71,
75, 70, 75, 69, 74, 68, 73, 68, 72, 68, 72, 66, 71, 66, 70, 64, 69, 63, 68, 61,
67, 61, 66, 59, 65, 58, 63, 57, 61, 55, 60, 53, 59, 53, 58, 51, 56, 48, 54, 47,
52, 45, 50, 43, 48, 41, 47, 40, 44, 37, 42, 35, 40, 34, 39, 32, 36, 29, 35, 27,
33, 25, 30, 24, 27, 21, 25, 19, 23, 17, 21, 15, 19, 12, 18, 11, 15, 9, 13, 7,
11, 5, 9, 2, 7, 0, 3, -1, 2, -4, 0, -6, -2, -8, -4, -9, -6, -11, -7, -13, -10,
-15, -11, -15, -13, -18, -15, -19, -16, -21, -18, -22, -19, -23, -21, -25, -22,
-25, -23, -26, -24, -28, -26, -29, -27, -29, -27, -30, -28, -32, -29, -32, -29,
-33, -31, -33, -31, -33, -32, -33, -31, -33, -32, -34, -33, -35, -31, -34, -31,
-33, -32, -34, -32, -33, -31, -33, -32, -33, -31, -33, -30, -32, -31, -32, -30,
-30, -29, -30, -29, -29, -28, -29, -27, -28, -27, -28, -26, -26, -26, -27, -24,
-26, -24, -25, -24, -24, -22, -23, -22, -24, -22, -22, -20, -21, -20, -21, -20,
-20, -18, -21, -18, -19, -18, -19, -18, -21, -17, -20, -17, -20, -17, -19, -17,
-20, -17, -19, -18, -20, -17, -20, -18, -21, -17, -22, -19, -21, -19, -22, -19,
-23, -20, -23, -21, -24, -21, -25, -22, -25, -24, -27, -24, -28, -25, -30, -26,
-30, -27, -31, -29, -32, -30, -34, -31, -35, -33, -36, -34, -38, -35, -39, -37,
-41, -39, -42, -40, -44, -41, -45, -43, -47, -44, -48, -46, -50, -47, -51, -49,
-52, -50, -53, -53, -55, -53, -56, -55, -58, -57, -59, -57, -59, -58, -61, -60,
-62, -61, -63, -63, -64, -63, -65, -64, -66, -66, -67, -67, -67, -67, -67, -67,
-68, -68, -68, -69, -69, -70, -69, -70, -69, -69, -69, -69, -69, -69, -69, -70,
-69, -69, -69, -69, -67, -68, -67, -68, -66, -68, -65, -67, -63, -65, -63, -64,
-61, -64, -60, -62, -59, -61, -58, -60, -56, -58, -54, -57, -52, -55, -50, -53,
-48, -51, -46, -50, -43, -47, -41, -45, -39, -42, -36, -41, -34, -39, -31, -36,
-29, -33, -26, -30, -23, -27, -20, -25, -18, -22, -15, -20, -12, -17, -9, -15,
-6, -11, -3, -9, 0, -5, };