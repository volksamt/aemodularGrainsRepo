#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0142

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -49, 4, -56, 6, -48, 10, -48, 12,
-43, 15, -42, 17, -37, 19, -35, 22, -31, 25, -28, 27, -23, 28, -20, 30, -14, 31,
-11, 33, -4, 33, 4, 35, 12, 36, 17, 38, 23, 41, 26, 43, 30, 45, 33, 47, 37, 49,
41, 51, 44, 53, 49, 55, 52, 57, 56, 59, 58, 62, 61, 64, 64, 65, 65, 69, 69, 71,
70, 72, 72, 75, 74, 76, 76, 78, 79, 79, 79, 80, 81, 82, 82, 83, 84, 85, 85, 85,
88, 88, 89, 88, 90, 89, 92, 90, 94, 92, 95, 93, 98, 95, 99, 96, 99, 97, 102, 98,
102, 99, 103, 100, 105, 102, 107, 102, 108, 103, 108, 104, 109, 104, 110, 105,
110, 106, 110, 106, 111, 106, 111, 107, 112, 107, 112, 108, 112, 109, 113, 109,
114, 109, 114, 109, 115, 110, 116, 111, 115, 112, 116, 113, 116, 112, 117, 113,
117, 114, 117, 114, 117, 114, 116, 114, 116, 114, 117, 115, 117, 115, 117, 116,
116, 115, 117, 116, 118, 118, 118, 118, 118, 118, 119, 118, 118, 118, 119, 118,
119, 118, 118, 118, 118, 119, 118, 118, 118, 119, 119, 119, 119, 118, 118, 119,
118, 119, 118, 118, 116, 114, 112, 111, 109, 113, 108, 113, 108, 112, 107, 113,
108, 113, 108, 112, 107, 111, 106, 112, 107, 112, 106, 112, 105, 111, 105, 111,
105, 110, 104, 110, 103, 109, 103, 109, 103, 108, 102, 108, 100, 108, 99, 108,
98, 107, 98, 107, 97, 106, 96, 107, 97, 106, 96, 105, 95, 106, 95, 105, 96, 105,
95, 105, 94, 104, 93, 103, 92, 102, 91, 103, 90, 101, 90, 101, 88, 99, 88, 100,
88, 99, 87, 99, 85, 99, 85, 98, 85, 97, 84, 97, 83, 97, 82, 96, 84, 100, 86,
102, 88, 102, 89, 101, 90, 101, 89, 99, 89, 100, 89, 101, 88, 100, 89, 99, 88,
99, 89, 99, 89, 100, 90, 99, 89, 100, 89, 99, 89, 100, 90, 99, 90, 99, 90, 100,
90, 99, 90, 98, 91, 98, 91, 99, 92, 98, 92, 97, 93, 97, 93, 97, 92, 97, 93, 97,
93, 96, 92, 97, 93, 96, 93, 96, 93, 96, 94, 96, 94, 96, 94, 96, 93, 96, 93, 95,
93, 95, 94, 95, 94, 94, 93, 94, 94, 94, 95, 94, 96, 94, 96, 93, 95, 93, 96, 92,
96, 92, 97, 92, 97, 92, 98, 90, 99, 90, 98, 89, 98, 89, 98, 88, 98, 89, 98, 88,
98, 87, 97, 87, 98, 86, 97, 84, 97, 84, 96, 82, 96, 81, 96, 81, 96, 80, 96, 79,
95, 78, 95, 77, 94, 76, 94, 76, 93, 75, 93, 74, 93, 73, 91, 71, 91, 70, 90, 68,
90, 67, 88, 66, 88, 64, 87, 62, 86, 61, 86, 60, 85, 58, 84, 56, 85, 54, 83, 52,
82, 50, 81, 48, 80, 45, 79, 43, 77, 41, 76, 38, 74, 36, 72, 33, 71, 30, 70, 27,
66, 25, 66, 21, 64, 19, 62, 16, 59, 12, 55, 8, 53, 4, 50, 1, 47, -3, 45, -5, 42,
-8, 39, -12, 35, -15, 32, -17, 28, -19, 24, -21, 20, -23, 15, -24, 11, -26, 6,
-28, -2, -29, -9, -30, -16, -32, -22, -34, -28, -36, -32, -37, -35, -40, -40,
-42, -43, -44, -46, -46, -50, -48, -52, -51, -54, -53, -57, -55, -59, -59, -61,
-60, -63, -62, -64, -64, -66, -65, -69, -68, -71, -70, -73, -72, -75, -74, -78,
-76, -80, -78, -81, -80, -83, -81, -85, -82, -86, -85, -88, -86, -90, -88, -92,
-90, -93, -92, -96, -92, -97, -94, -98, -95, -99, -96, -99, -96, -101, -97,
-101, -98, -102, -99, -103, -100, -105, -101, -106, -102, -108, -103, -109,
-103, -109, -105, -111, -106, -111, -107, -111, -107, -112, -108, -113, -109,
-112, -109, -113, -110, -113, -109, -113, -110, -113, -111, -113, -112, -114,
-112, -113, -112, -113, -112, -113, -111, -114, -112, -114, -113, -114, -113,
-115, -114, -114, -114, -116, -114, -116, -115, -115, -115, -115, -116, -115,
-116, -115, -116, -115, -117, -115, -116, -116, -117, -115, -116, -113, -115,
-112, -112, -110, -112, -108, -111, -107, -112, -106, -111, -106, -111, -106,
-111, -106, -111, -105, -111, -106, -112, -106, -111, -105, -112, -105, -111,
-106, -111, -104, -111, -104, -111, -103, -110, -102, -110, -102, -109, -101,
-109, -100, -109, -99, -108, -98, -109, -97, -108, -96, -108, -97, -108, -96,
-108, -96, -106, -95, -107, -95, -107, -95, -107, -95, -106, -95, -107, -95,
-106, -95, -106, -95, -105, -95, -105, -94, -105, -92, -105, -93, -104, -91,
-104, -91, -104, -91, -103, -90, -104, -90, -103, -90, -103, -90, -103, -90,
-103, -90, -103, -91, -103, -92, -107, -93, -110, -95, -109, -96, -109, -96,
-107, -96, -106, -95, -106, -95, -107, -94, -106, -94, -105, -94, -106, -94,
-105, -94, -106, -93, -105, -93, -106, -94, -106, -94, -106, -93, -106, -93,
-105, -93, -104, -95, -105, -95, -105, -96, -105, -96, -104, -96, -104, -96,
-103, -97, -104, -96, -104, -96, -103, -96, -104, -96, -103, -97, -103, -97,
-104, -97, -104, -96, -104, -97, -102, -98, -103, -97, -102, -97, -102, -99,
-102, -98, -102, -99, -103, -99, -102, -100, -101, -99, -102, -99, -102, -100,
-102, -100, -100, -100, -100, -100, -99, -101, -100, -101, -99, -101, -100,
-102, -99, -102, -99, -102, -99, -101, -99, -102, -98, -101, -98, -102, -97,
-102, -97, -101, -95, -102, -95, -101, -95, -102, -94, -102, -93, -102, -93,
-103, -91, -102, -90, -102, -90, -102, -89, -102, -88, -101, -87, -101, -87,
-100, -87, -100, -85, -100, -84, -98, -83, -98, -81, -96, -81, -97, -79, -96,
-78, -97, -77, -95, -76, -95, -74, -94, -74, -93, -72, -93, -71, -93, -69, -92,
-68, -91, -65, -90, -63, -90, -61, -88, -60, -87, -57, -86, -55, -84, -52, -84,
-50, -83, -47, -82, -45, -79, -42, -80, -39, -76, -36, -77, -31, -72, -27, -72,
-24, -67, -20, -68, -17, -63, -13, -65, -9, -59, -6, -63, -2, -49, };