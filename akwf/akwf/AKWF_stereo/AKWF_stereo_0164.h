#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0164

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 67, 0, 81, 1, 75, 2, 80, 3, 76, 4,
80, 5, 77, 6, 80, 6, 76, 6, 78, 7, 75, 7, 77, 8, 75, 7, 77, 8, 74, 8, 75, 9, 73,
9, 74, 10, 75, 11, 74, 12, 74, 13, 74, 14, 75, 14, 75, 16, 76, 17, 76, 18, 76,
19, 76, 20, 77, 21, 76, 23, 77, 24, 77, 25, 77, 27, 78, 28, 78, 30, 78, 31, 78,
33, 79, 34, 79, 34, 80, 37, 81, 37, 82, 39, 82, 40, 83, 43, 85, 43, 85, 45, 85,
46, 86, 48, 87, 50, 88, 52, 88, 53, 90, 54, 90, 56, 90, 58, 91, 59, 91, 61, 89,
62, 88, 63, 87, 65, 85, 66, 84, 67, 82, 67, 82, 70, 80, 71, 79, 72, 78, 73, 78,
74, 77, 75, 77, 77, 77, 78, 76, 80, 76, 81, 76, 82, 76, 84, 76, 86, 76, 87, 76,
88, 77, 89, 77, 91, 78, 92, 78, 94, 78, 94, 79, 96, 80, 97, 80, 99, 80, 100, 80,
100, 81, 102, 80, 103, 80, 105, 80, 106, 81, 107, 80, 108, 80, 109, 81, 109, 81,
109, 82, 109, 81, 109, 83, 108, 83, 108, 84, 108, 84, 108, 84, 108, 85, 108, 86,
108, 86, 108, 86, 109, 86, 109, 87, 109, 88, 109, 88, 110, 88, 110, 90, 111, 88,
111, 89, 111, 88, 113, 89, 113, 90, 114, 90, 115, 89, 116, 89, 117, 89, 117, 89,
118, 91, 118, 90, 119, 90, 117, 89, 107, 78, 90, 64, 76, 50, 63, 39, 52, 29, 42,
20, 33, 12, 26, 6, 20, -1, 15, -5, 9, -11, 4, -13, 0, -19, -4, -22, -9, -26,
-11, -29, -15, -32, -18, -34, -19, -37, -23, -39, -24, -40, -26, -42, -27, -43,
-28, -44, -29, -44, -29, -46, -30, -47, -30, -47, -31, -47, -31, -48, -30, -47,
-30, -49, -30, -49, -30, -48, -30, -49, -30, -49, -30, -49, -30, -48, -31, -48,
-32, -48, -32, -47, -32, -48, -33, -46, -34, -47, -35, -46, -35, -47, -36, -46,
-37, -45, -38, -45, -37, -44, -38, -43, -38, -42, -39, -45, -39, -52, -39, -62,
-40, -69, -40, -75, -40, -81, -40, -87, -39, -91, -39, -95, -39, -98, -39, -101,
-40, -103, -40, -106, -41, -108, -42, -109, -42, -111, -43, -113, -44, -114,
-43, -115, -44, -116, -43, -117, -44, -118, -43, -118, -43, -119, -42, -119,
-42, -119, -42, -120, -41, -118, -41, -118, -39, -118, -39, -119, -39, -119,
-38, -117, -36, -117, -37, -118, -36, -118, -35, -117, -33, -117, -33, -117,
-31, -117, -30, -117, -29, -116, -28, -116, -27, -115, -26, -115, -25, -114,
-23, -113, -23, -113, -22, -113, -21, -111, -21, -110, -21, -110, -21, -108,
-21, -108, -22, -107, -21, -106, -22, -105, -22, -104, -22, -103, -21, -101,
-22, -101, -21, -99, -20, -98, -20, -97, -20, -96, -18, -95, -18, -93, -17, -93,
-16, -92, -16, -90, -16, -89, -17, -88, -16, -87, -15, -85, -15, -84, -15, -83,
-15, -81, -14, -80, -13, -79, -13, -78, -12, -76, -11, -74, -12, -73, -14, -71,
-25, -70, -37, -69, -47, -67, -54, -66, -62, -64, -69, -63, -74, -61, -78, -60,
-82, -59, -86, -57, -89, -56, -92, -54, -94, -53, -96, -52, -99, -50, -101, -48,
-103, -48, -104, -46, -105, -44, -107, -43, -107, -41, -108, -40, -108, -39,
-109, -37, -109, -35, -108, -35, -108, -33, -108, -32, -109, -31, -108, -29,
-107, -27, -107, -27, -106, -24, -106, -24, -105, -23, -104, -21, -104, -20,
-103, -19, -102, -20, -102, -18, -100, -18, -100, -17, -99, -17, -98, -16, -97,
-15, -96, -14, -94, -13, -93, -12, -93, -11, -92, -10, -91, -9, -89, -8, -89,
-6, -87, -6, -85, -5, -84, -4, -83, -2, -81, -1, -80, -1, -78, 1, -77, 2, -76,
4, -74, 4, -72, 5, -71, 6, -70, 7, -68, 8, -67, 10, -64, 10, -63, 11, -62, 11,
-61, 12, -61, 12, -60, 13, -60, 13, -58, 14, -58, 15, -57, 16, -55, 16, -54, 18,
-53, 18, -52, 19, -52, 20, -50, 22, -49, 22, -49, 24, -48, 25, -47, 25, -47, 27,
-46, 27, -45, 28, -44, 29, -44, 31, -43, 31, -41, 32, -40, 32, -39, 28, -39, 20,
-39, 14, -37, 9, -37, 5, -36, 0, -34, -4, -33, -6, -32, -8, -31, -10, -30, -13,
-29, -14, -27, -16, -26, -19, -25, -21, -24, -22, -23, -24, -21, -25, -20, -26,
-19, -27, -18, -28, -18, -29, -18, -29, -19, -29, -18, -30, -19, -29, -18, -30,
-19, -29, -18, -28, -19, -28, -18, -28, -18, -27, -17, -27, -17, -27, -17, -27,
-16, -27, -14, -27, -14, -26, -14, -26, -12, -26, -12, -26, -11, -26, -10, -25,
-8, -25, -7, -23, -7, -23, -5, -22, -4, -22, -2, -21, -1, -20, -1, -20, 0, -19,
2, -18, 4, -18, 5, -17, 7, -15, 8, -15, 10, -14, 10, -13, 13, -13, 14, -14, 15,
-13, 17, -13, 18, -12, 20, -12, 22, -11, 22, -12, 24, -10, 26, -9, 27, -9, 29,
-7, 31, -7, 31, -6, 32, -5, 33, -4, 36, -4, 35, -2, 36, -1, 36, 0, 36, 0, 35, 3,
36, 3, 36, 4, 36, 6, 36, 7, 37, 8, 37, 9, 38, 10, 39, 12, 39, 13, 40, 14, 41,
15, 40, 17, 41, 18, 41, 20, 41, 22, 40, 23, 40, 24, 41, 25, 41, 26, 40, 28, 41,
29, 42, 30, 42, 32, 42, 33, 45, 33, 45, 35, 46, 36, 47, 37, 48, 38, 47, 40, 49,
41, 50, 43, 52, 42, 52, 44, 53, 44, 54, 45, 56, 46, 57, 46, 57, 47, 59, 47, 59,
47, 60, 48, 61, 49, 59, 50, 51, 50, 44, 51, 37, 52, 31, 52, 26, 53, 22, 53, 19,
55, 15, 56, 13, 56, 10, 57, 8, 58, 6, 59, 5, 60, 3, 60, 2, 63, 1, 63, -1, 65,
-1, 63, -2, 67, -3, 66, -2, 70, -3, 69, -2, 73, -2, 69, -2, 74, -1, 71, -2, 80,
0, 65, };