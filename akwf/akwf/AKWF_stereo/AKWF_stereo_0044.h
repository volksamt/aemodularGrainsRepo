#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0044

const PROGMEM int8_t DATA[DATA_LENGTH] = {12, 8, 44, 48, 73, 98, 82, 118, 83,
118, 83, 118, 84, 118, 84, 118, 85, 117, 85, 117, 87, 117, 87, 117, 88, 117, 88,
116, 88, 117, 89, 117, 90, 117, 90, 117, 91, 116, 91, 116, 92, 116, 92, 116, 92,
116, 94, 116, 94, 116, 95, 116, 96, 116, 96, 116, 95, 115, 97, 115, 97, 115, 97,
114, 98, 115, 98, 115, 99, 115, 99, 114, 99, 114, 101, 114, 101, 115, 102, 114,
102, 114, 102, 114, 103, 114, 103, 114, 102, 110, 90, 81, 72, 38, 64, 17, 65,
17, 66, 18, 66, 18, 67, 20, 67, 20, 68, 21, 68, 21, 70, 20, 70, 22, 70, 22, 71,
22, 71, 23, 72, 23, 73, 23, 74, 24, 74, 24, 74, 25, 75, 25, 76, 26, 76, 25, 77,
26, 77, 27, 78, 27, 78, 27, 79, 28, 80, 27, 80, 29, 81, 29, 82, 30, 82, 29, 82,
30, 83, 31, 83, 31, 84, 32, 85, 32, 85, 32, 85, 32, 87, 33, 86, 33, 87, 33, 87,
33, 88, 34, 89, 34, 89, 35, 90, 35, 89, 35, 90, 35, 91, 36, 92, 36, 92, 36, 92,
36, 92, 36, 93, 37, 93, 37, 94, 37, 94, 39, 95, 39, 95, 38, 96, 39, 95, 39, 96,
39, 96, 40, 97, 40, 97, 40, 97, 41, 98, 41, 98, 41, 99, 41, 99, 42, 100, 43,
100, 43, 100, 43, 101, 43, 101, 43, 102, 43, 102, 44, 103, 44, 102, 45, 104, 45,
103, 45, 104, 45, 103, 45, 104, 46, 104, 46, 105, 46, 106, 47, 106, 47, 106, 47,
107, 48, 107, 47, 107, 47, 108, 47, 109, 48, 109, 48, 109, 48, 109, 49, 110, 49,
110, 49, 110, 49, 111, 50, 111, 50, 110, 50, 111, 50, 110, 50, 111, 51, 112, 51,
112, 51, 113, 51, 112, 51, 113, 52, 113, 52, 113, 51, 113, 53, 114, 52, 114, 52,
115, 53, 115, 53, 115, 54, 115, 54, 115, 54, 115, 54, 116, 54, 116, 53, 116, 54,
116, 55, 116, 54, 117, 55, 118, 55, 117, 55, 118, 56, 117, 55, 117, 55, 114, 53,
113, 53, 111, 52, 109, 52, 107, 50, 107, 48, 104, 48, 102, 48, 101, 46, 100, 46,
98, 45, 97, 44, 94, 44, 93, 43, 92, 42, 90, 41, 87, 40, 87, 38, 85, 38, 83, 38,
82, 37, 81, 36, 79, 35, 78, 34, 77, 34, 74, 33, 74, 32, 72, 32, 71, 30, 69, 30,
67, 29, 66, 28, 64, 27, 63, 27, 62, 26, 61, 25, 59, 25, 58, 23, 55, 23, 55, 22,
49, 15, 40, 6, 36, 1, 34, 1, 33, 0, 32, -1, 31, 0, 30, -2, 28, -2, 27, -2, 26,
-3, 24, -4, 24, -4, 23, -5, 22, -4, 20, -6, 19, -6, 19, -8, 17, -7, 16, -9, 15,
-8, 14, -9, 13, -9, 11, -10, 11, -10, 10, -11, 8, -12, 5, -12, -5, -14, -20,
-17, -25, -19, -26, -19, -27, -19, -28, -21, -29, -20, -30, -21, -31, -22, -32,
-21, -33, -23, -33, -22, -34, -22, -35, -23, -35, -23, -36, -24, -37, -25, -38,
-25, -39, -25, -39, -26, -39, -27, -41, -27, -42, -26, -42, -27, -42, -27, -43,
-28, -45, -29, -45, -29, -46, -29, -46, -29, -47, -30, -47, -30, -49, -31, -49,
-31, -50, -32, -51, -32, -51, -31, -51, -33, -53, -33, -52, -33, -54, -34, -54,
-34, -55, -34, -56, -34, -56, -35, -57, -35, -58, -36, -58, -36, -59, -36, -59,
-37, -59, -37, -60, -36, -61, -38, -61, -37, -61, -38, -63, -38, -63, -39, -64,
-39, -64, -39, -65, -40, -66, -40, -66, -40, -67, -40, -67, -40, -67, -41, -67,
-40, -69, -41, -69, -41, -69, -42, -70, -42, -71, -42, -71, -43, -71, -43, -71,
-43, -72, -43, -74, -44, -73, -44, -74, -44, -75, -45, -75, -45, -75, -45, -76,
-45, -76, -46, -77, -46, -78, -46, -77, -47, -78, -46, -78, -46, -79, -47, -80,
-46, -79, -47, -79, -48, -80, -48, -81, -48, -82, -48, -82, -49, -82, -49, -82,
-49, -83, -49, -83, -50, -84, -50, -84, -49, -85, -49, -84, -50, -85, -50, -85,
-50, -85, -50, -86, -51, -86, -50, -87, -52, -87, -51, -87, -51, -87, -52, -88,
-52, -88, -52, -89, -52, -88, -52, -89, -52, -90, -52, -90, -53, -90, -54, -90,
-53, -91, -53, -91, -53, -91, -54, -91, -54, -92, -54, -92, -54, -92, -54, -93,
-55, -92, -54, -93, -54, -93, -55, -94, -55, -94, -55, -94, -55, -94, -55, -95,
-56, -95, -55, -95, -56, -95, -56, -96, -56, -96, -56, -95, -56, -97, -56, -97,
-56, -96, -57, -97, -56, -97, -57, -98, -57, -97, -57, -97, -57, -98, -57, -98,
-57, -99, -57, -99, -57, -98, -57, -99, -57, -99, -58, -99, -57, -99, -58, -100,
-58, -99, -58, -101, -57, -100, -58, -101, -58, -100, -58, -100, -58, -100, -59,
-100, -58, -101, -58, -102, -59, -101, -59, -102, -59, -101, -59, -102, -58,
-102, -59, -102, -59, -102, -59, -102, -59, -103, -59, -103, -60, -102, -60,
-102, -60, -102, -61, -102, -60, -102, -59, -100, -59, -99, -57, -97, -57, -95,
-55, -92, -54, -92, -53, -90, -52, -88, -52, -86, -52, -85, -50, -82, -49, -81,
-47, -79, -47, -78, -46, -76, -45, -75, -43, -71, -43, -70, -42, -68, -42, -67,
-41, -66, -40, -64, -38, -62, -37, -60, -37, -59, -36, -57, -35, -56, -34, -54,
-33, -52, -32, -51, -32, -67, -38, -100, -48, -118, -54, -118, -55, -118, -55,
-116, -53, -115, -52, -114, -51, -114, -51, -111, -50, -111, -50, -110, -49,
-109, -49, -108, -49, -107, -46, -106, -47, -105, -47, -104, -45, -102, -45,
-103, -45, -101, -44, -101, -43, -100, -43, -99, -42, -98, -42, -97, -41, -96,
-40, -95, -40, -94, -39, -93, -38, -93, -38, -92, -38, -90, -36, -90, -37, -89,
-36, -89, -35, -87, -34, -87, -34, -85, -33, -85, -33, -85, -33, -84, -32, -84,
-32, -83, -32, -63, -25, -30, -12, -6, -3, };