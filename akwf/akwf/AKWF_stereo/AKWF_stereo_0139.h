#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0139

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 4, 3, 7, 4, 10, 7, 12, 10, 15,
11, 18, 14, 20, 15, 22, 17, 25, 20, 28, 22, 30, 22, 33, 25, 36, 27, 37, 29, 39,
30, 42, 33, 43, 34, 45, 36, 48, 38, 49, 38, 51, 40, 53, 41, 54, 44, 56, 45, 58,
46, 60, 48, 62, 49, 63, 51, 65, 52, 66, 54, 68, 56, 69, 57, 71, 57, 72, 59, 73,
60, 75, 62, 76, 63, 78, 64, 78, 65, 80, 66, 80, 67, 82, 69, 82, 70, 84, 70, 85,
72, 86, 72, 86, 74, 88, 75, 89, 75, 89, 76, 90, 78, 91, 78, 92, 79, 92, 80, 94,
80, 95, 82, 94, 83, 96, 83, 96, 84, 97, 85, 97, 86, 98, 85, 99, 87, 99, 88, 100,
88, 101, 88, 102, 90, 102, 90, 103, 91, 102, 91, 103, 92, 105, 92, 104, 93, 105,
95, 105, 94, 106, 96, 106, 95, 106, 96, 107, 96, 106, 96, 108, 97, 108, 98, 109,
98, 109, 99, 109, 99, 110, 99, 110, 99, 110, 100, 111, 101, 111, 101, 111, 101,
112, 101, 111, 102, 111, 103, 113, 103, 113, 103, 112, 104, 113, 104, 113, 103,
113, 104, 114, 105, 114, 105, 114, 104, 115, 106, 115, 105, 115, 106, 114, 106,
115, 106, 116, 107, 115, 107, 116, 107, 116, 107, 116, 108, 116, 108, 116, 108,
116, 108, 116, 109, 116, 109, 117, 109, 117, 109, 116, 109, 118, 109, 117, 109,
117, 109, 118, 109, 117, 109, 117, 109, 118, 110, 118, 109, 118, 111, 118, 110,
118, 110, 118, 110, 119, 110, 118, 111, 118, 110, 118, 110, 119, 111, 119, 111,
118, 111, 118, 110, 118, 111, 119, 111, 118, 111, 119, 112, 119, 111, 119, 112,
119, 112, 119, 111, 118, 111, 118, 112, 120, 111, 119, 112, 118, 112, 119, 112,
119, 112, 119, 111, 119, 112, 119, 112, 119, 111, 119, 112, 119, 111, 119, 111,
119, 112, 120, 112, 119, 112, 120, 112, 119, 111, 120, 111, 118, 111, 119, 112,
119, 111, 119, 112, 119, 111, 119, 112, 120, 112, 119, 111, 118, 111, 119, 112,
119, 111, 118, 111, 118, 111, 119, 111, 118, 111, 119, 111, 119, 111, 119, 111,
118, 111, 119, 111, 118, 111, 119, 111, 118, 111, 118, 110, 118, 110, 118, 110,
118, 111, 118, 110, 117, 109, 118, 110, 118, 110, 118, 110, 117, 110, 118, 110,
118, 109, 117, 109, 117, 109, 117, 110, 118, 109, 118, 109, 117, 109, 117, 109,
116, 109, 117, 109, 117, 109, 117, 109, 117, 109, 117, 108, 116, 109, 117, 108,
116, 108, 116, 108, 116, 108, 117, 108, 117, 108, 115, 107, 117, 108, 116, 108,
116, 107, 115, 107, 116, 107, 115, 106, 116, 107, 115, 106, 115, 106, 114, 105,
115, 107, 114, 106, 116, 107, 114, 106, 115, 106, 114, 105, 114, 106, 114, 106,
113, 105, 114, 106, 114, 104, 115, 105, 112, 104, 114, 105, 113, 103, 115, 105,
112, 102, 115, 105, 111, 101, 116, 105, 109, 101, 116, 106, 109, 99, 116, 105,
108, 100, 116, 106, 109, 99, 115, 105, 109, 99, 114, 103, 110, 101, -97, -89,
-122, -114, -107, -99, -120, -111, -109, -101, -119, -109, -111, -102, -119,
-109, -112, -103, -118, -109, -112, -104, -118, -109, -113, -105, -117, -109,
-114, -106, -117, -109, -114, -106, -116, -108, -116, -107, -117, -108, -115,
-107, -116, -109, -116, -108, -116, -108, -116, -109, -116, -107, -117, -109,
-115, -108, -117, -108, -116, -108, -117, -109, -116, -109, -118, -110, -117,
-109, -118, -110, -117, -109, -118, -110, -117, -109, -117, -110, -117, -110,
-118, -110, -118, -110, -117, -110, -118, -110, -119, -110, -118, -110, -118,
-109, -118, -110, -118, -111, -118, -111, -117, -111, -118, -111, -118, -111,
-118, -111, -119, -110, -118, -111, -119, -110, -119, -111, -118, -111, -118,
-111, -119, -111, -118, -112, -119, -112, -119, -111, -119, -111, -119, -112,
-118, -112, -119, -111, -119, -111, -119, -112, -119, -111, -119, -111, -119,
-111, -118, -112, -119, -111, -119, -112, -118, -111, -119, -112, -120, -111,
-120, -112, -120, -112, -120, -112, -119, -111, -120, -111, -118, -112, -119,
-113, -118, -111, -120, -111, -119, -111, -120, -112, -120, -112, -119, -112,
-119, -111, -119, -112, -119, -111, -119, -112, -118, -111, -119, -111, -119,
-111, -119, -111, -118, -111, -119, -111, -119, -112, -118, -111, -118, -111,
-118, -111, -118, -111, -118, -110, -119, -111, -118, -110, -118, -110, -117,
-110, -118, -110, -118, -110, -118, -110, -118, -109, -118, -109, -118, -110,
-117, -109, -117, -109, -117, -109, -116, -109, -117, -110, -118, -109, -117,
-108, -116, -108, -116, -109, -116, -108, -117, -108, -115, -108, -116, -108,
-116, -108, -115, -107, -116, -107, -116, -107, -115, -106, -115, -106, -115,
-106, -114, -106, -115, -106, -115, -106, -115, -104, -114, -105, -114, -105,
-114, -104, -113, -103, -114, -104, -113, -104, -113, -103, -112, -103, -112,
-102, -111, -102, -111, -101, -111, -102, -111, -101, -110, -100, -111, -100,
-109, -100, -109, -100, -109, -99, -109, -99, -108, -99, -109, -98, -108, -97,
-108, -97, -107, -96, -107, -95, -106, -95, -105, -95, -106, -94, -105, -94,
-104, -93, -104, -93, -104, -91, -103, -91, -103, -91, -102, -91, -100, -90,
-100, -89, -100, -88, -99, -87, -98, -88, -98, -87, -98, -85, -97, -84, -96,
-84, -95, -83, -94, -82, -95, -81, -93, -81, -92, -80, -92, -79, -91, -78, -91,
-77, -90, -77, -89, -74, -88, -74, -87, -74, -86, -72, -84, -72, -84, -71, -83,
-69, -81, -69, -81, -67, -78, -65, -78, -65, -77, -64, -75, -62, -75, -62, -73,
-59, -72, -59, -70, -57, -69, -56, -68, -55, -66, -53, -65, -53, -63, -50, -62,
-49, -61, -48, -58, -47, -56, -45, -54, -44, -52, -42, -51, -40, -49, -39, -47,
-37, -45, -35, -43, -33, -41, -31, -39, -30, -37, -29, -35, -27, -32, -25, -30,
-22, -28, -21, -26, -19, -23, -17, -20, -15, -18, -13, -15, -11, -13, -9, -9,
-7, -7, -4, -5, -3, -1, -1, };