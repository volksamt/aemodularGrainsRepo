#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0126

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -21, 5, -29, 10, -27, 16, -26, 25,
-21, 36, -17, 47, -9, 57, -1, 65, 5, 69, 11, 69, 18, 69, 22, 67, 26, 68, 32, 68,
38, 69, 42, 70, 48, 69, 51, 68, 52, 67, 52, 70, 54, 78, 57, 86, 63, 95, 72, 103,
81, 99, 81, 93, 79, 90, 76, 84, 72, 80, 66, 73, 60, 63, 52, 56, 44, 51, 42, 55,
48, 65, 63, 73, 71, 87, 86, 90, 90, 85, 85, 84, 81, 81, 78, 80, 76, 77, 76, 75,
78, 75, 77, 75, 78, 72, 78, 69, 77, 65, 73, 57, 68, 48, 63, 41, 58, 36, 53, 33,
52, 29, 54, 30, 59, 27, 63, 24, 66, 21, 67, 15, 65, 10, 61, 4, 54, -2, 46, -12,
36, -22, 21, -31, 12, -38, 5, -43, -1, -43, -6, -44, -11, -46, -16, -47, -21,
-50, -29, -54, -32, -59, -36, -63, -38, -70, -40, -77, -45, -86, -53, -94, -60,
-103, -68, -107, -75, -96, -65, -86, -55, -75, -46, -63, -36, -50, -25, -51,
-26, -64, -37, -78, -48, -91, -57, -104, -70, -118, -87, -119, -88, -117, -90,
-117, -93, -118, -96, -117, -100, -112, -104, -104, -107, -97, -108, -87, -104,
-76, -102, -69, -96, -63, -91, -56, -88, -49, -83, -40, -76, -33, -69, -27, -60,
-22, -53, -21, -49, -21, -48, -24, -49, -27, -50, -27, -46, -29, -43, -29, -39,
-28, -36, -27, -32, -24, -32, -20, -31, -16, -28, -12, -24, -11, -23, -7, -23,
-3, -23, 0, -26, 5, -28, 10, -28, 16, -25, 26, -22, 37, -17, 48, -9, 57, -1, 65,
5, 69, 11, 69, 18, 69, 22, 68, 26, 68, 32, 67, 37, 69, 42, 70, 48, 69, 52, 67,
52, 67, 52, 70, 55, 78, 58, 87, 64, 97, 73, 104, 82, 99, 80, 94, 79, 88, 76, 84,
71, 79, 65, 72, 60, 63, 51, 55, 45, 50, 41, 55, 48, 66, 63, 73, 72, 88, 87, 91,
90, 85, 84, 83, 81, 80, 77, 79, 76, 77, 76, 74, 78, 75, 78, 75, 77, 71, 78, 69,
76, 64, 72, 57, 67, 48, 62, 41, 58, 37, 54, 33, 52, 31, 53, 29, 59, 27, 63, 23,
66, 20, 68, 14, 65, 9, 61, 5, 54, -3, 45, -13, 34, -23, 22, -31, 11, -38, 4,
-42, -2, -43, -7, -44, -10, -46, -15, -48, -21, -51, -29, -53, -33, -59, -35,
-63, -37, -71, -40, -77, -45, -86, -54, -94, -60, -103, -69, -107, -74, -95,
-65, -85, -55, -74, -45, -62, -36, -49, -24, -52, -25, -65, -37, -78, -48, -91,
-57, -105, -72, -120, -88, -118, -88, -116, -90, -117, -93, -118, -97, -118,
-100, -112, -104, -105, -107, -97, -108, -86, -104, -77, -102, -69, -96, -62,
-91, -55, -87, -48, -82, -39, -75, -34, -68, -26, -61, -22, -53, -21, -49, -20,
-47, -24, -50, -26, -49, -27, -46, -28, -42, -30, -38, -29, -35, -27, -33, -24,
-33, -20, -31, -16, -28, -12, -24, -10, -23, -7, -22, -3, -22, 1, -26, 6, -28,
10, -28, 17, -26, 26, -22, 38, -16, 48, -9, 58, -1, 66, 5, 69, 12, 69, 18, 69,
23, 67, 27, 67, 32, 67, 38, 69, 44, 69, 48, 69, 52, 66, 51, 68, 53, 71, 54, 79,
58, 88, 64, 97, 74, 104, 82, 98, 79, 93, 79, 88, 76, 84, 71, 79, 65, 72, 59, 62,
51, 55, 44, 51, 42, 56, 49, 67, 64, 74, 73, 89, 87, 90, 89, 85, 84, 84, 81, 80,
77, 79, 77, 77, 77, 75, 78, 76, 78, 74, 77, 72, 78, 68, 77, 63, 73, 56, 68, 48,
62, 41, 56, 36, 53, 34, 52, 30, 54, 29, 60, 26, 64, 24, 66, 20, 67, 14, 65, 9,
60, 3, 53, -3, 46, -13, 34, -24, 21, -33, 10, -39, 5, -43, -2, -43, -6, -44,
-10, -46, -16, -48, -22, -50, -28, -54, -33, -59, -35, -64, -37, -70, -41, -78,
-46, -87, -54, -94, -61, -104, -70, -107, -74, -95, -64, -85, -54, -74, -44,
-61, -36, -50, -24, -52, -27, -65, -38, -80, -50, -92, -58, -106, -74, -119,
-88, -119, -88, -118, -90, -118, -93, -118, -96, -117, -101, -111, -105, -105,
-107, -97, -108, -85, -104, -76, -101, -70, -95, -63, -90, -55, -87, -48, -82,
-40, -76, -33, -68, -27, -60, -23, -53, -21, -49, -21, -48, -24, -50, -26, -49,
-26, -46, -29, -42, -29, -38, -29, -35, -26, -33, -24, -32, -21, -30, -15, -28,
-12, -24, -10, -23, -7, -22, -4, -23, 0, -26, 6, -29, 11, -28, 17, -25, 27, -22,
38, -15, 49, -8, 58, -2, 66, 6, 70, 13, 70, 19, 69, 23, 67, 27, 68, 33, 67, 39,
69, 44, 70, 49, 69, 52, 67, 52, 67, 52, 71, 55, 80, 58, 88, 65, 98, 74, 104, 82,
98, 80, 93, 78, 88, 77, 84, 71, 79, 65, 72, 59, 62, 50, 54, 44, 50, 42, 57, 50,
67, 63, 74, 73, 89, 88, 91, 89, 85, 83, 83, 81, 80, 77, 79, 76, 76, 77, 75, 78,
76, 77, 74, 77, 72, 79, 68, 77, 63, 72, 56, 67, 48, 61, 41, 57, 36, 54, 33, 52,
29, 54, 29, 60, 27, 65, 23, 65, 19, 67, 14, 65, 9, 60, 3, 53, -4, 46, -13, 33,
-24, 20, -33, 9, -38, 4, -43, -2, -44, -7, -44, -11, -46, -16, -48, -22, -51,
-28, -54, -33, -59, -36, -64, -37, -71, -41, -78, -46, -87, -54, -94, -61, -105,
-70, -108, -74, -95, -62, -84, -53, -73, -43, -61, -35, -49, -24, -53, -27, -67,
-39, -79, -49, -92, -60, -107, -74, -119, -88, -117, -87, -118, -91, -117, -93,
-117, -97, -117, -100, -110, -105, -104, -107, -96, -108, -85, -105, -75, -100,
-69, -95, -62, -90, -55, -86, -48, -82, -39, -75, -32, -67, -26, -59, -23, -52,
-21, -49, -21, -46, -24, -49, -27, -49, -27, -45, -29, -42, -29, -38, -28, -34,
-26, -32, -24, -32, -20, -31, -15, -27, -12, -26, -10, -22, -8, -24, -3, -19, };