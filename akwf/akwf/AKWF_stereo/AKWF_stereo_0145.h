#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0145

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, -9, 3, -9, 6, -7, 7, -6, 9, -3, 10,
-3, 12, -1, 14, 1, 15, 2, 17, 4, 19, 6, 21, 7, 22, 9, 23, 10, 26, 12, 28, 14,
29, 16, 30, 16, 32, 18, 34, 19, 35, 21, 37, 22, 38, 23, 39, 25, 41, 26, 42, 29,
44, 30, 45, 31, 46, 32, 48, 34, 50, 34, 51, 35, 53, 37, 54, 38, 56, 40, 57, 41,
58, 42, 59, 43, 61, 44, 62, 46, 63, 46, 64, 48, 65, 48, 66, 50, 67, 51, 69, 52,
69, 54, 71, 54, 72, 56, 73, 56, 74, 58, 74, 59, 76, 60, 77, 60, 78, 62, 79, 62,
81, 64, 81, 64, 82, 64, 82, 67, 84, 67, 85, 69, 86, 70, 87, 70, 87, 71, 88, 72,
90, 73, 90, 74, 91, 74, 92, 75, 92, 75, 93, 76, 94, 76, 94, 77, 95, 79, 96, 79,
96, 80, 98, 82, 98, 82, 98, 83, 99, 83, 100, 84, 101, 84, 101, 86, 102, 85, 102,
87, 103, 87, 103, 89, 105, 88, 105, 89, 106, 90, 106, 91, 106, 90, 106, 91, 107,
92, 108, 93, 108, 93, 108, 93, 109, 94, 109, 95, 110, 95, 110, 95, 110, 96, 111,
97, 112, 97, 111, 97, 112, 98, 112, 98, 112, 99, 113, 99, 113, 99, 113, 100,
113, 100, 113, 100, 114, 101, 114, 102, 115, 102, 114, 101, 115, 102, 115, 102,
115, 103, 115, 102, 115, 103, 115, 102, 115, 104, 115, 104, 116, 104, 115, 103,
116, 104, 116, 105, 116, 105, 116, 104, 115, 105, 116, 104, 115, 106, 115, 105,
115, 106, 116, 105, 115, 106, 115, 105, 114, 105, 115, 105, 115, 106, 115, 105,
115, 105, 114, 106, 114, 105, 114, 104, 113, 105, 113, 106, 113, 105, 112, 105,
113, 105, 112, 104, 113, 104, 112, 104, 111, 104, 110, 103, 111, 103, 110, 104,
110, 104, 109, 104, 108, 102, 109, 102, 108, 102, 107, 102, 107, 102, 106, 101,
107, 102, 106, 101, 106, 100, 104, 100, 104, 100, 104, 99, 103, 98, 102, 99,
102, 98, 101, 97, 101, 98, 99, 96, 99, 95, 99, 96, 98, 95, 97, 94, 96, 94, 95,
93, 94, 93, 94, 91, 93, 90, 92, 90, 91, 89, 90, 88, 89, 88, 89, 88, 88, 87, 87,
86, 86, 85, 84, 85, 84, 84, 84, 83, 82, 83, 81, 82, 80, 81, 79, 80, 79, 80, 77,
78, 75, 77, 75, 77, 75, 75, 73, 75, 72, 73, 71, 72, 70, 72, 68, 70, 67, 69, 66,
69, 65, 68, 63, 67, 62, 65, 62, 64, 60, 63, 58, 61, 58, 60, 56, 59, 54, 58, 52,
57, 52, 56, 50, 54, 49, 53, 48, 52, 46, 50, 44, 50, 43, 48, 41, 48, 40, 47, 39,
45, 37, 43, 35, 42, 34, 41, 32, 40, 30, 38, 29, 36, 27, 35, 26, 34, 24, 33, 23,
32, 21, 29, 20, 28, 17, 27, 16, 25, 13, 24, 12, 22, 10, 21, 9, 19, 7, 18, 5, 17,
3, 15, 2, 12, 0, 12, -2, 10, -4, 9, -6, 8, -8, 6, -9, 4, -10, 2, -11, 0, -14,
-1, -16, -3, -16, -5, -18, -6, -21, -7, -22, -8, -24, -10, -25, -12, -27, -14,
-28, -15, -30, -17, -31, -18, -33, -19, -35, -21, -35, -21, -38, -23, -38, -24,
-39, -26, -41, -27, -43, -29, -44, -30, -46, -31, -46, -32, -48, -34, -49, -35,
-50, -37, -52, -37, -53, -39, -54, -39, -56, -41, -57, -42, -58, -44, -59, -45,
-61, -46, -62, -48, -63, -49, -64, -50, -66, -50, -67, -52, -68, -53, -69, -54,
-70, -54, -71, -55, -72, -57, -74, -58, -74, -59, -75, -60, -77, -61, -77, -63,
-79, -63, -80, -64, -81, -66, -83, -66, -83, -67, -85, -68, -84, -69, -86, -71,
-87, -71, -88, -72, -89, -73, -90, -73, -91, -75, -92, -76, -93, -77, -93, -77,
-94, -78, -94, -79, -95, -80, -97, -81, -97, -82, -98, -83, -98, -83, -99, -84,
-101, -84, -101, -85, -102, -87, -103, -87, -103, -88, -104, -89, -104, -89,
-105, -90, -105, -91, -107, -91, -107, -91, -108, -93, -109, -94, -108, -94,
-110, -95, -109, -95, -110, -96, -110, -96, -111, -97, -112, -97, -112, -98,
-112, -98, -113, -99, -113, -100, -113, -101, -114, -100, -114, -101, -114,
-101, -115, -101, -116, -102, -116, -102, -116, -103, -116, -103, -116, -104,
-117, -105, -117, -105, -118, -105, -117, -105, -118, -106, -118, -106, -118,
-106, -119, -106, -118, -107, -119, -106, -119, -106, -119, -108, -119, -107,
-119, -108, -119, -108, -119, -107, -119, -108, -119, -107, -119, -109, -119,
-109, -118, -109, -119, -109, -118, -109, -118, -109, -119, -108, -118, -109,
-118, -109, -118, -109, -118, -109, -118, -108, -117, -109, -118, -108, -117,
-109, -117, -109, -117, -109, -116, -109, -116, -108, -116, -108, -116, -108,
-115, -108, -115, -107, -114, -107, -113, -107, -114, -106, -113, -106, -114,
-106, -113, -106, -112, -106, -112, -105, -111, -104, -111, -104, -110, -103,
-110, -103, -108, -104, -109, -103, -108, -102, -107, -101, -106, -101, -106,
-101, -106, -101, -104, -100, -104, -98, -103, -98, -102, -98, -102, -98, -101,
-98, -101, -96, -99, -95, -98, -95, -98, -94, -97, -94, -97, -92, -96, -91, -94,
-91, -93, -90, -92, -89, -92, -89, -91, -88, -89, -87, -87, -86, -87, -85, -86,
-85, -85, -84, -84, -82, -84, -81, -82, -80, -80, -80, -80, -79, -78, -78, -77,
-78, -76, -76, -74, -75, -74, -74, -72, -72, -71, -71, -70, -71, -68, -69, -67,
-69, -65, -68, -64, -66, -63, -65, -61, -63, -60, -63, -58, -61, -58, -61, -55,
-60, -54, -57, -53, -57, -51, -56, -50, -54, -48, -53, -47, -50, -45, -50, -44,
-48, -43, -47, -40, -45, -39, -44, -37, -43, -36, -41, -34, -40, -32, -38, -31,
-37, -29, -36, -26, -34, -25, -33, -23, -31, -21, -29, -20, -28, -19, -26, -17,
-25, -15, -24, -12, -23, -10, -20, -10, -20, -8, -16, -6, -16, -4, -14, -2, -13,
-1, -10, };