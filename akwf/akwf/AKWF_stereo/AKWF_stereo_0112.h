#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0112

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 3, 3, 5, 3, 6, 4, 7, 6, 9, 9,
11, 10, 13, 10, 15, 13, 17, 15, 17, 16, 20, 16, 22, 19, 23, 20, 25, 21, 27, 22,
28, 23, 30, 26, 32, 27, 34, 28, 35, 29, 36, 31, 38, 32, 40, 34, 42, 35, 43, 36,
45, 38, 46, 39, 47, 40, 49, 41, 51, 42, 52, 44, 54, 46, 54, 48, 57, 48, 58, 49,
59, 51, 61, 51, 63, 53, 64, 54, 65, 56, 67, 57, 67, 58, 69, 59, 70, 60, 70, 61,
72, 62, 74, 63, 75, 64, 76, 65, 76, 66, 78, 68, 80, 69, 80, 70, 81, 71, 83, 72,
84, 73, 85, 74, 86, 74, 86, 76, 87, 77, 88, 78, 89, 78, 90, 81, 91, 81, 92, 82,
93, 83, 94, 83, 95, 84, 96, 86, 96, 86, 97, 87, 98, 88, 99, 89, 99, 89, 100, 90,
100, 91, 101, 91, 102, 93, 102, 93, 104, 95, 104, 95, 105, 96, 104, 97, 106, 98,
105, 99, 107, 99, 107, 99, 107, 101, 108, 101, 108, 103, 108, 103, 109, 104,
109, 104, 111, 105, 111, 106, 111, 106, 112, 107, 113, 109, 112, 108, 113, 109,
114, 110, 113, 110, 115, 112, 114, 111, 116, 115, 114, 111, 122, 121, 99, 90,
83, 70, 86, 85, 77, 86, 79, 97, 74, 93, 73, 88, 70, 80, 71, 81, 72, 81, 74, 80,
74, 79, 75, 78, 78, 79, 79, 80, 81, 80, 81, 78, 83, 80, 85, 80, 88, 82, 89, 80,
90, 81, 93, 82, 95, 84, 95, 82, 98, 82, 98, 83, 101, 85, 101, 84, 102, 81, 103,
81, 103, 81, 104, 81, 101, 73, 101, 68, 95, 64, 98, 74, 89, 74, 91, 90, 75, 71,
49, 38, 57, 47, 53, 42, 56, 46, 55, 44, 56, 47, 56, 46, 57, 47, 57, 47, 58, 48,
57, 48, 58, 48, 58, 49, 58, 49, 59, 49, 59, 49, 59, 51, 59, 50, 60, 51, 60, 51,
60, 52, 60, 51, 60, 52, 60, 52, 60, 53, 61, 53, 60, 53, 60, 53, 61, 53, 60, 53,
61, 54, 61, 53, 61, 54, 61, 54, 61, 54, 62, 55, 63, 56, 63, 55, 63, 55, 63, 56,
63, 56, 63, 56, 64, 57, 63, 55, 65, 58, 64, 56, 65, 58, 64, 56, 66, 58, 65, 57,
66, 58, 65, 58, 67, 59, 66, 58, 66, 58, 66, 58, 66, 57, 67, 59, 66, 57, 68, 60,
67, 57, 69, 62, 66, 57, 71, 64, 65, 54, 74, 67, 60, 51, 81, 74, 40, 25, 18, 0,
38, 40, 6, 15, 19, 38, 6, 22, 7, 18, -1, 5, 1, 9, 0, 9, 0, 6, -1, 1, -3, -2, -1,
1, -2, 0, -1, 1, -3, -4, -1, -3, -2, -2, 1, 0, -2, -4, 0, -3, 0, -4, 2, -2, 0,
-3, 1, -2, 0, -4, 2, -2, 1, -2, 2, -2, 2, -2, 2, -2, 2, -2, 2, -1, 2, 0, 1, -1,
1, -1, 1, -1, 1, 0, 0, 0, 1, 1, 0, 0, 0, 1, -1, 1, -1, 1, -1, 2, -2, 1, -2, 1,
-2, 2, -1, 1, -3, 2, -2, 3, -2, 3, 0, 3, -1, 2, -1, 3, -1, 1, 1, 4, 0, 2, 1, 3,
-1, 0, 2, 2, 1, 2, 4, 5, 1, 0, 3, -1, 1, -2, 3, 2, 3, -1, 1, -6, 0, -9, -2, -8,
0, -6, -7, -17, -6, -24, -19, -37, -8, -14, -40, -41, -16, 3, -45, -32, -80,
-74, -61, -51, -74, -66, -64, -55, -71, -63, -65, -55, -70, -62, -66, -57, -68,
-60, -66, -57, -67, -59, -66, -58, -67, -59, -66, -58, -66, -58, -66, -58, -65,
-58, -67, -58, -65, -58, -66, -57, -65, -57, -65, -57, -63, -56, -64, -57, -64,
-55, -65, -58, -63, -55, -63, -57, -63, -55, -63, -56, -62, -54, -63, -56, -62,
-55, -61, -55, -62, -54, -61, -54, -61, -54, -61, -53, -61, -54, -61, -53, -60,
-52, -61, -53, -60, -52, -61, -53, -61, -52, -60, -52, -59, -52, -60, -52, -58,
-51, -59, -50, -59, -50, -59, -51, -59, -50, -59, -50, -58, -49, -58, -50, -58,
-49, -58, -49, -57, -48, -56, -47, -56, -47, -56, -46, -56, -45, -54, -45, -55,
-46, -54, -43, -57, -47, -50, -37, -78, -75, -91, -90, -89, -75, -98, -74, -95,
-63, -101, -69, -101, -74, -105, -82, -103, -81, -103, -81, -102, -82, -102,
-84, -101, -85, -99, -83, -98, -82, -95, -82, -95, -84, -92, -82, -91, -81, -88,
-81, -87, -82, -85, -81, -84, -80, -81, -79, -81, -81, -79, -80, -77, -80, -76,
-77, -74, -78, -73, -81, -72, -82, -72, -80, -71, -81, -74, -88, -75, -93, -79,
-97, -77, -85, -86, -86, -82, -69, -101, -94, -121, -120, -114, -110, -117,
-115, -114, -111, -116, -113, -113, -109, -113, -110, -113, -109, -113, -109,
-112, -108, -112, -108, -111, -106, -110, -106, -110, -105, -109, -105, -110,
-104, -109, -103, -109, -103, -107, -101, -108, -102, -106, -99, -107, -100,
-106, -98, -105, -97, -106, -97, -104, -97, -103, -95, -103, -94, -102, -93,
-102, -92, -100, -92, -100, -91, -100, -91, -99, -89, -99, -89, -98, -88, -97,
-88, -96, -86, -96, -86, -94, -84, -94, -83, -92, -82, -92, -82, -92, -81, -90,
-80, -89, -78, -89, -78, -87, -77, -87, -76, -85, -75, -85, -75, -84, -73, -83,
-72, -81, -71, -81, -70, -79, -68, -78, -68, -77, -66, -76, -65, -75, -64, -74,
-64, -72, -61, -72, -61, -69, -59, -69, -59, -68, -58, -65, -56, -65, -55, -63,
-54, -62, -53, -60, -51, -59, -50, -58, -49, -56, -48, -55, -47, -53, -46, -52,
-44, -50, -43, -49, -42, -47, -40, -46, -38, -45, -37, -43, -36, -41, -35, -40,
-33, -38, -33, -37, -31, -35, -29, -34, -28, -32, -27, -31, -25, -28, -24, -27,
-23, -24, -21, -23, -20, -21, -18, -20, -16, -18, -15, -16, -14, -14, -12, -13,
-11, -11, -9, -9, -7, -8, -6, -6, -5, -3, -3, -2, -2, 0, -1, };