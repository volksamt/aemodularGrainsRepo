#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0186

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 4, 15, 14, 24, 24, 33, 33, 42, 43,
51, 51, 60, 61, 67, 68, 75, 74, 81, 82, 87, 88, 93, 93, 97, 98, 102, 102, 105,
104, 109, 107, 112, 111, 113, 112, 115, 113, 115, 114, 116, 114, 117, 115, 116,
114, 116, 113, 116, 112, 114, 112, 114, 112, 112, 110, 110, 108, 109, 108, 107,
106, 105, 104, 104, 102, 102, 101, 100, 99, 98, 97, 95, 96, 93, 93, 91, 92, 88,
89, 87, 87, 84, 85, 82, 83, 80, 80, 78, 78, 75, 76, 73, 73, 71, 70, 69, 66, 67,
64, 65, 60, 62, 58, 60, 55, 59, 52, 57, 50, 55, 48, 54, 45, 53, 42, 52, 40, 51,
37, 50, 35, 49, 34, 48, 32, 47, 30, 48, 28, 46, 28, 47, 27, 46, 27, 46, 26, 46,
27, 46, 26, 46, 26, 48, 26, 47, 26, 48, 27, 48, 27, 48, 28, 48, 27, 48, 28, 49,
29, 49, 29, 49, 30, 49, 32, 48, 31, 50, 32, 49, 32, 49, 33, 48, 33, 48, 33, 49,
33, 48, 34, 47, 34, 48, 34, 47, 34, 46, 34, 46, 33, 45, 34, 45, 33, 45, 34, 43,
33, 43, 33, 42, 32, 40, 32, 40, 32, 39, 32, 38, 30, 37, 30, 36, 30, 34, 29, 34,
29, 32, 28, 32, 28, 31, 27, 29, 25, 27, 26, 26, 25, 25, 24, 23, 23, 23, 22, 22,
21, 21, 20, 19, 19, 18, 18, 18, 17, 16, 17, 16, 15, 14, 15, 14, 15, 12, 14, 11,
13, 11, 13, 9, 13, 8, 12, 8, 12, 6, 12, 5, 12, 4, 12, 4, 12, 2, 12, 1, 12, 0,
12, 0, 13, 0, 13, -1, 13, -2, 13, -2, 14, -3, 13, -4, 14, -3, 14, -5, 13, -5,
13, -4, 13, -5, 14, -4, 13, -4, 13, -3, 12, -3, 13, -2, 12, -1, 11, -1, 11, -1,
10, 1, 10, 2, 10, 3, 9, 3, 8, 5, 8, 5, 7, 6, 7, 7, 7, 8, 7, 9, 7, 9, 7, 9, 8,
11, 7, 11, 7, 12, 9, 13, 8, 12, 8, 13, 10, 12, 11, 11, 11, 11, 12, 11, 13, 10,
15, 9, 14, 8, 16, 7, 17, 6, 17, 5, 18, 5, 18, 3, 20, 2, 20, 2, 21, 1, 22, 0, 22,
-1, 23, -1, 23, -1, 23, -1, 24, -1, 24, -1, 25, -3, 25, -2, 25, -2, 26, -2, 26,
-2, 26, 0, 26, 0, 27, 0, 27, 0, 28, 0, 28, 2, 29, 1, 28, 2, 28, 2, 28, 3, 29, 4,
29, 5, 30, 4, 30, 5, 30, 6, 30, 6, 30, 6, 29, 7, 31, 8, 29, 7, 30, 9, 30, 8, 29,
9, 29, 9, 28, 9, 27, 9, 27, 9, 27, 10, 26, 10, 26, 10, 24, 10, 23, 9, 22, 9, 22,
10, 21, 8, 19, 9, 19, 8, 19, 7, 18, 7, 17, 6, 16, 6, 14, 4, 14, 4, 12, 4, 12, 3,
12, 1, 11, 1, 9, -1, 9, -1, 7, -2, 6, -3, 5, -4, 4, -5, 3, -6, 2, -7, 1, -7, -1,
-8, -1, -8, -2, -9, -4, -9, -5, -9, -7, -9, -7, -9, -9, -9, -10, -9, -11, -8,
-12, -9, -13, -8, -14, -7, -15, -8, -16, -7, -17, -6, -17, -5, -19, -5, -19, -5,
-20, -4, -19, -4, -20, -2, -20, -1, -20, 0, -21, 0, -20, 1, -20, 2, -20, 3, -20,
4, -20, 5, -20, 5, -19, 6, -18, 7, -18, 7, -19, 9, -19, 9, -18, 11, -18, 11,
-17, 11, -18, 12, -17, 12, -17, 14, -17, 14, -16, 15, -16, 15, -16, 15, -15, 16,
-15, 16, -14, 18, -13, 17, -14, 18, -13, 18, -12, 19, -11, 20, -10, 20, -10, 19,
-9, 20, -9, 19, -8, 19, -7, 19, -7, 20, -5, 19, -5, 18, -4, 18, -4, 17, -3, 16,
-3, 15, -1, 14, 0, 13, 0, 12, 0, 10, 1, 10, 1, 8, 2, 6, 3, 5, 2, 3, 2, 1, 3, -1,
3, -2, 3, -4, 3, -6, 3, -7, 2, -9, 3, -11, 3, -12, 3, -13, 3, -15, 2, -16, 2,
-17, 3, -19, 3, -19, 3, -21, 2, -22, 2, -22, 3, -23, 2, -24, 2, -25, 2, -24, 2,
-25, 1, -26, 1, -25, 1, -26, 1, -26, 0, -27, -2, -27, -1, -27, -2, -27, -2, -28,
-4, -28, -4, -28, -4, -29, -6, -29, -7, -29, -7, -29, -9, -31, -10, -30, -10,
-32, -11, -32, -12, -33, -12, -33, -13, -33, -13, -35, -14, -35, -15, -35, -15,
-36, -16, -36, -17, -36, -16, -36, -16, -37, -17, -37, -18, -38, -17, -39, -18,
-40, -18, -40, -18, -41, -20, -40, -21, -42, -21, -42, -22, -42, -22, -43, -24,
-44, -25, -44, -26, -45, -28, -46, -30, -46, -32, -48, -33, -49, -34, -49, -35,
-49, -37, -50, -39, -50, -40, -51, -42, -51, -41, -52, -43, -51, -44, -52, -45,
-53, -46, -54, -48, -55, -48, -54, -49, -55, -50, -55, -50, -56, -51, -57, -52,
-57, -52, -58, -52, -59, -53, -61, -53, -61, -54, -62, -55, -64, -55, -64, -56,
-66, -57, -67, -58, -68, -59, -70, -60, -69, -61, -71, -62, -72, -63, -74, -65,
-74, -66, -76, -68, -76, -70, -78, -71, -78, -73, -79, -75, -79, -76, -80, -78,
-80, -79, -82, -81, -81, -83, -82, -85, -82, -86, -82, -88, -83, -89, -83, -91,
-82, -92, -83, -93, -83, -94, -82, -95, -84, -96, -83, -98, -83, -99, -83, -100,
-84, -100, -83, -101, -83, -102, -83, -103, -84, -104, -84, -105, -85, -106,
-85, -107, -85, -107, -86, -109, -88, -110, -88, -111, -88, -112, -90, -113,
-90, -114, -92, -115, -91, -116, -93, -117, -94, -117, -95, -118, -95, -118,
-95, -119, -97, -119, -97, -118, -97, -119, -97, -118, -96, -116, -96, -114,
-94, -113, -93, -111, -91, -109, -89, -104, -87, -100, -83, -96, -80, -91, -75,
-85, -70, -79, -64, -72, -57, -65, -51, -56, -42, -47, -35, -38, -29, -31, -22,
-24, -13, -14, -3, -3, };