#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0071

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 2, 4, 0, 4, 1, 4, 0, 4, 1, 4, 2,
5, 2, 5, 2, 5, 3, 5, 2, 5, 3, 6, 3, 6, 3, 6, 2, 6, 2, 6, 3, 6, 3, 7, 3, 6, 3, 6,
3, 7, 3, 7, 3, 7, 4, 7, 4, 7, 3, 6, 4, 6, 3, 7, 4, 8, 4, 8, 4, 8, 5, 8, 3, 8, 4,
8, 3, 8, 4, 8, 4, 9, 4, 8, 4, 9, 5, 9, 4, 9, 4, 9, 5, 9, 4, 10, 5, 9, 4, 9, 4,
9, 4, 9, 4, 10, 5, 10, 5, 11, 4, 11, 5, 10, 5, 10, 4, 10, 5, 11, 5, 11, 5, 12,
5, 12, 5, 12, 5, 11, 6, 11, 5, 11, 5, 11, 6, 11, 5, 12, 5, 12, 5, 13, 6, 12, 5,
12, 6, 13, 6, 13, 5, 13, 6, 13, 6, 13, 6, 13, 6, 14, 6, 15, 6, 14, 6, 14, 6, 15,
6, 15, 6, 14, 7, 14, 7, 15, 7, 15, 6, 15, 6, 15, 6, 15, 7, 15, 7, 15, 7, 16, 7,
15, 7, 15, 7, 16, 7, 16, 7, 15, 7, 16, 7, 17, 7, 17, 8, 17, 7, 17, 8, 17, 7, 17,
9, 17, 7, 17, 9, 17, 6, 17, 9, 17, 7, 18, 10, 18, 2, 19, -8, 19, 11, 17, 3, 19,
2, 19, 5, 19, 7, 19, 7, 19, 7, 19, 8, 19, 8, 19, 9, 19, 9, 19, 9, 19, 9, 20, 9,
19, 9, 20, 10, 19, 10, 20, 10, 20, 10, 21, 10, 20, 10, 20, 11, 21, 10, 20, 11,
21, 11, 21, 10, 21, 10, 21, 11, 22, 11, 22, 11, 21, 10, 22, 10, 22, 10, 22, 10,
22, 11, 22, 11, 22, 11, 23, 11, 23, 11, 23, 11, 23, 11, 23, 11, 23, 12, 23, 12,
24, 11, 23, 11, 24, 11, 24, 11, 24, 12, 24, 11, 24, 12, 24, 11, 25, 12, 24, 12,
25, 12, 25, 11, 25, 12, 24, 12, 25, 12, 26, 12, 26, 11, 26, 12, 25, 12, 26, 12,
26, 12, 27, 12, 26, 12, 27, 12, 26, 12, 27, 12, 27, 13, 28, 13, 27, 12, 28, 12,
27, 12, 28, 13, 27, 13, 28, 13, 28, 13, 29, 13, 28, 13, 27, 13, 29, 13, 28, 13,
29, 12, 28, 14, 30, 11, 28, 14, 30, 12, 28, 13, 30, 12, 28, 15, 31, 11, 28, 16,
32, 12, 29, 16, 32, 12, 29, 15, 32, 13, 29, 15, 32, 13, 30, 15, 31, 14, 30, 14,
31, 15, 32, 13, 30, 17, 34, 11, 28, 21, 39, 4, 20, 35, 54, -76, -68, -47, -38,
21, 35, -47, -43, -26, -25, -20, -25, -7, -16, -18, -36, -8, -29, -11, -36, -5,
-34, -9, -36, -6, -33, -6, -33, -5, -29, -6, -27, -6, -28, -5, -25, -5, -27, -4,
-26, -6, -30, -3, -29, -5, -33, -3, -31, -5, -34, -3, -31, -5, -32, -3, -30, -4,
-29, -3, -27, -5, -27, -5, -25, -5, -26, -5, -26, -6, -26, -6, -27, -6, -28, -6,
-28, -6, -29, -8, -29, -8, -28, -7, -28, -8, -28, -9, -27, -10, -26, -9, -25,
-10, -26, -10, -25, -11, -26, -12, -27, -11, -25, -11, -27, -12, -26, -13, -26,
-13, -27, -13, -26, -13, -26, -14, -25, -13, -25, -14, -25, -14, -24, -14, -24,
-15, -24, -15, -24, -15, -25, -15, -24, -16, -25, -15, -24, -14, -25, -15, -24,
-15, -24, -14, -23, -14, -24, -14, -24, -14, -23, -15, -24, -14, -22, -15, -23,
-14, -22, -15, -22, -14, -23, -14, -23, -14, -23, -13, -23, -13, -22, -14, -22,
-11, -22, -18, -20, -15, -21, -11, -22, -15, -20, -12, -21, -12, -20, -11, -20,
-12, -21, -10, -21, -11, -20, -10, -20, -10, -20, -10, -20, -9, -20, -8, -20,
-8, -19, -9, -20, -8, -19, -8, -18, -8, -19, -8, -19, -6, -18, -8, -18, -7, -18,
-7, -18, -7, -18, -7, -18, -7, -17, -6, -17, -6, -17, -5, -17, -6, -17, -6, -17,
-5, -17, -6, -17, -6, -17, -5, -16, -5, -17, -5, -17, -5, -16, -6, -16, -5, -16,
-6, -16, -5, -15, -6, -15, -6, -16, -6, -16, -6, -15, -5, -15, -5, -15, -5, -15,
-6, -15, -5, -15, -5, -15, -6, -14, -6, -14, -6, -14, -6, -14, -6, -14, -6, -15,
-6, -14, -7, -14, -6, -13, -7, -13, -6, -14, -7, -13, -7, -13, -7, -14, -6, -13,
-7, -12, -7, -13, -7, -12, -7, -12, -7, -12, -6, -12, -6, -12, -6, -12, -7, -11,
-7, -12, -7, -12, -7, -11, -7, -11, -6, -12, -7, -11, -7, -10, -7, -11, -7, -10,
-7, -10, -7, -10, -7, -10, -6, -10, -7, -10, -5, -10, -6, -10, -6, -10, -6, -9,
-6, -10, -5, -9, -6, -8, -5, -9, -7, -8, -4, -9, -6, -8, -4, -9, -6, -8, -3, -8,
-6, -8, -3, -8, -7, -8, -2, -8, -6, -7, -1, -8, -8, -7, -51, 0, -3, -7, -10, -6,
-23, -3, -12, -5, -8, -6, -6, -5, -8, -6, -3, -6, -5, -5, -1, -5, -3, -5, -1,
-5, -2, -6, 0, -6, -1, -6, 1, -6, 0, -5, 1, -5, 0, -5, 1, -5, 0, -5, 0, -5, 1,
-5, 0, -4, 1, -4, 1, -5, 0, -4, 0, -4, 1, -3, 1, -4, 1, -3, 1, -4, 1, -3, 0, -3,
1, -3, 1, -3, 1, -2, 1, -2, 1, -2, 1, -3, 1, -2, 0, -2, 0, -3, 0, -2, 0, -2, 1,
-2, 0, -1, 1, -1, 0, -1, 0, -1, 1, -1, 1, -1, 0, -1, 1, 0, 0, -1, 1, 1, 1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 0, 1, 1, 0, 1, 1, 2, 0, 0, 1, 3, 0, -1, 3, 4, -4,
-6, -6, -9, 3, 7, -1, -1, 0, 1, 2, 4, 3, 6, 3, 5, 3, 6, 3, 6, 3, 5, 2, 5, 2, 5,
1, 4, 2, 3, 2, 4, -2, 2, };