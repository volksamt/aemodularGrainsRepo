#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0143

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, -57, 7, -66, 11, -58, 16, -59, 21,
-53, 25, -53, 28, -47, 32, -47, 35, -41, 39, -39, 43, -31, 47, -29, 50, -20, 53,
-6, 56, 9, 57, 17, 59, 24, 61, 30, 61, 35, 62, 40, 64, 44, 65, 46, 66, 50, 67,
53, 69, 55, 68, 58, 70, 60, 70, 61, 71, 64, 71, 67, 72, 68, 72, 70, 73, 72, 75,
74, 76, 77, 77, 79, 79, 81, 81, 85, 82, 86, 85, 89, 86, 91, 88, 94, 90, 96, 91,
99, 94, 100, 94, 101, 95, 103, 97, 105, 97, 106, 97, 106, 97, 108, 98, 108, 97,
109, 96, 110, 96, 111, 96, 111, 95, 111, 94, 113, 94, 113, 94, 113, 93, 113, 94,
114, 94, 114, 95, 115, 95, 114, 96, 114, 95, 115, 95, 115, 96, 115, 95, 116, 96,
116, 95, 116, 96, 118, 96, 118, 96, 118, 97, 118, 96, 119, 95, 119, 96, 119, 95,
119, 93, 116, 93, 116, 92, 114, 91, 113, 90, 112, 90, 111, 88, 109, 87, 109, 87,
108, 86, 107, 85, 106, 84, 106, 84, 106, 84, 105, 83, 105, 84, 104, 83, 105, 83,
104, 84, 103, 85, 104, 86, 104, 88, 104, 88, 103, 88, 102, 88, 101, 88, 100, 87,
97, 85, 95, 84, 92, 84, 90, 83, 87, 81, 85, 81, 83, 80, 80, 79, 80, 77, 77, 76,
76, 74, 74, 72, 74, 71, 72, 70, 71, 69, 69, 69, 67, 67, 64, 66, 62, 65, 59, 62,
57, 61, 53, 57, 49, 54, 45, 51, 39, 47, 36, 42, 31, 37, 27, 31, 22, 27, 18, 23,
15, 19, 12, 17, 10, 17, 10, 17, 11, 19, 12, 20, 13, 21, 15, 20, 13, 20, 13, 17,
10, 16, 4, 12, -3, 8, -10, 3, -20, -1, -35, -4, -49, -7, -56, -9, -60, -8, -62,
-8, -61, -8, -60, -7, -59, -6, -56, -5, -54, -4, -52, -5, -49, -4, -45, -3, -35,
-2, -24, 2, -14, 6, -6, 10, 3, 15, 11, 20, 19, 27, 26, 31, 32, 35, 39, 40, 44,
43, 48, 45, 51, 47, 55, 47, 57, 47, 59, 49, 61, 50, 62, 52, 65, 53, 67, 54, 70,
56, 73, 57, 77, 58, 79, 59, 81, 59, 84, 60, 85, 61, 87, 61, 88, 60, 88, 59, 88,
59, 88, 57, 88, 57, 88, 55, 88, 54, 88, 54, 87, 55, 87, 55, 88, 55, 88, 56, 89,
57, 89, 57, 88, 56, 88, 54, 89, 54, 87, 53, 88, 51, 86, 50, 86, 48, 86, 48, 85,
47, 84, 47, 85, 47, 85, 45, 85, 45, 85, 43, 85, 42, 85, 41, 86, 40, 86, 40, 86,
40, 87, 40, 87, 40, 86, 41, 86, 40, 85, 40, 85, 38, 83, 37, 82, 36, 81, 35, 80,
34, 79, 33, 78, 31, 78, 30, 77, 31, 76, 30, 76, 30, 76, 29, 74, 28, 73, 26, 73,
24, 71, 23, 70, 20, 68, 20, 67, 19, 66, 18, 63, 18, 61, 19, 55, 18, 45, 18, 38,
18, 32, 17, 29, 17, 23, 16, 19, 14, 15, 12, 11, 10, 7, 6, 1, 3, -3, 1, -8, -3,
-12, -6, -15, -9, -20, -12, -24, -14, -26, -16, -30, -19, -33, -21, -37, -23,
-40, -26, -43, -28, -48, -29, -51, -30, -56, -32, -59, -33, -62, -35, -65, -37,
-68, -40, -72, -43, -73, -46, -77, -49, -79, -53, -82, -55, -84, -59, -86, -62,
-88, -63, -90, -65, -91, -66, -93, -68, -94, -70, -97, -70, -98, -73, -100, -74,
-100, -74, -102, -76, -104, -77, -105, -79, -107, -80, -106, -80, -108, -81,
-108, -80, -109, -81, -109, -80, -108, -81, -108, -81, -109, -81, -108, -81,
-110, -81, -110, -81, -111, -82, -111, -84, -113, -84, -113, -84, -114, -86,
-114, -86, -115, -88, -116, -89, -115, -90, -116, -91, -117, -91, -116, -92,
-117, -93, -116, -93, -116, -93, -117, -92, -116, -92, -116, -91, -115, -90,
-115, -89, -114, -88, -113, -88, -112, -87, -111, -87, -110, -87, -110, -87,
-109, -87, -109, -86, -107, -86, -107, -86, -106, -85, -106, -85, -104, -84,
-102, -84, -101, -83, -100, -83, -99, -82, -98, -80, -96, -79, -96, -77, -94,
-76, -93, -73, -91, -71, -89, -69, -88, -66, -86, -63, -83, -62, -82, -60, -79,
-59, -76, -57, -74, -55, -71, -55, -66, -53, -63, -50, -59, -47, -54, -45, -49,
-42, -42, -38, -37, -35, -29, -31, -21, -28, -13, -25, 0, -23, 16, -21, 28, -21,
35, -22, 39, -23, 42, -25, 42, -27, 40, -28, 36, -30, 36, -30, 37, -29, 38, -29,
42, -27, 48, -25, 53, -21, 58, -18, 63, -15, 66, -13, 69, -13, 72, -12, 74, -14,
75, -15, 75, -17, 75, -20, 74, -22, 74, -26, 74, -28, 72, -30, 71, -32, 68, -34,
67, -35, 65, -35, 64, -36, 61, -36, 60, -36, 58, -38, 56, -38, 54, -39, 50, -41,
47, -44, 43, -47, 37, -50, 23, -53, 5, -55, -10, -56, -20, -57, -27, -59, -32,
-61, -37, -60, -42, -61, -45, -62, -49, -60, -50, -61, -53, -59, -54, -58, -56,
-57, -57, -55, -57, -54, -58, -52, -58, -51, -59, -52, -59, -52, -61, -53, -63,
-55, -66, -57, -69, -60, -72, -62, -74, -64, -77, -66, -78, -67, -81, -68, -82,
-69, -84, -70, -85, -72, -86, -72, -87, -73, -89, -76, -90, -77, -92, -78, -94,
-79, -95, -80, -97, -80, -98, -80, -99, -80, -100, -78, -100, -78, -102, -77,
-102, -78, -101, -76, -103, -77, -103, -77, -104, -77, -105, -77, -105, -78,
-106, -77, -106, -78, -107, -78, -108, -77, -108, -78, -109, -78, -109, -78,
-108, -79, -108, -80, -106, -79, -107, -79, -104, -77, -103, -76, -103, -75,
-101, -72, -99, -70, -99, -68, -98, -67, -98, -66, -98, -66, -97, -65, -97, -65,
-98, -64, -97, -64, -96, -63, -96, -62, -95, -61, -95, -59, -94, -57, -93, -56,
-91, -53, -91, -50, -88, -47, -88, -44, -84, -40, -85, -36, -80, -31, -81, -25,
-75, -19, -77, -13, -70, -8, -75, -2, -57, };