#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0122

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -5, 2, -6, 2, -4, 4, -3, 6, -2, 7,
-1, 9, 1, 9, 1, 11, 3, 13, 5, 14, 5, 16, 7, 17, 8, 19, 10, 20, 11, 22, 13, 24,
14, 26, 16, 28, 18, 29, 19, 31, 21, 33, 22, 35, 24, 37, 26, 39, 28, 41, 30, 42,
31, 45, 33, 46, 34, 49, 38, 50, 39, 54, 41, 55, 43, 56, 45, 59, 46, 62, 49, 63,
51, 67, 53, 68, 55, 70, 57, 72, 59, 75, 61, 77, 63, 79, 65, 81, 67, 83, 70, 86,
71, 88, 73, 90, 76, 92, 78, 93, 80, 96, 82, 98, 84, 99, 85, 102, 88, 104, 90,
105, 91, 107, 93, 108, 95, 110, 96, 110, 98, 113, 100, 113, 102, 114, 103, 115,
105, 116, 104, 117, 106, 118, 108, 118, 107, 119, 109, 119, 111, 120, 111, 119,
111, 118, 112, 119, 112, 118, 113, 119, 112, 118, 114, 117, 114, 117, 114, 117,
113, 115, 113, 115, 113, 114, 113, 113, 112, 111, 111, 110, 111, 109, 110, 108,
110, 107, 109, 105, 107, 103, 107, 102, 106, 100, 105, 98, 103, 96, 102, 94,
101, 92, 100, 90, 98, 88, 96, 85, 95, 84, 94, 81, 92, 79, 90, 76, 87, 74, 85,
71, 84, 69, 82, 66, 81, 64, 78, 63, 75, 59, 74, 57, 72, 55, 70, 51, 67, 49, 65,
46, 62, 44, 60, 40, 57, 38, 56, 37, 53, 34, 52, 31, 49, 27, 47, 26, 44, 23, 41,
20, 40, 18, 37, 15, 35, 12, 32, 10, 30, 7, 27, 5, 25, 2, 22, 0, 20, -3, 17, -5,
15, -8, 12, -10, 10, -12, 8, -15, 5, -18, 3, -19, 1, -21, -1, -24, -4, -26, -7,
-28, -8, -30, -12, -32, -13, -34, -16, -37, -18, -39, -20, -41, -22, -43, -25,
-46, -27, -47, -29, -48, -31, -51, -33, -52, -35, -54, -37, -55, -40, -57, -41,
-59, -43, -61, -46, -63, -47, -64, -48, -67, -50, -67, -53, -68, -55, -70, -57,
-71, -58, -74, -59, -74, -61, -75, -63, -77, -65, -78, -66, -79, -67, -80, -69,
-81, -70, -83, -71, -83, -72, -83, -74, -84, -75, -84, -77, -86, -77, -86, -78,
-88, -80, -88, -80, -88, -82, -88, -82, -89, -83, -89, -83, -90, -85, -90, -85,
-91, -85, -90, -86, -90, -87, -90, -88, -91, -88, -91, -88, -91, -89, -90, -88,
-90, -89, -90, -89, -90, -88, -90, -88, -88, -89, -89, -89, -88, -89, -87, -88,
-87, -88, -86, -88, -86, -87, -84, -88, -83, -86, -83, -87, -81, -86, -81, -86,
-80, -85, -79, -83, -79, -83, -77, -83, -75, -82, -75, -81, -74, -79, -72, -79,
-71, -78, -69, -77, -69, -75, -66, -75, -66, -73, -64, -72, -62, -71, -61, -69,
-59, -68, -58, -67, -56, -65, -55, -64, -53, -63, -51, -62, -50, -60, -48, -58,
-47, -56, -44, -56, -43, -53, -42, -52, -40, -51, -39, -49, -37, -47, -35, -46,
-34, -45, -33, -43, -30, -41, -29, -40, -28, -38, -27, -37, -24, -36, -23, -34,
-21, -32, -20, -30, -19, -29, -18, -28, -16, -26, -15, -25, -13, -25, -12, -22,
-11, -22, -10, -19, -9, -19, -8, -18, -6, -17, -6, -16, -4, -14, -3, -13, -2,
-12, -1, -11, -1, -11, 0, -9, 0, -9, 2, -7, 2, -6, 4, -6, 5, -5, 6, -4, 6, -3,
7, -2, 8, -1, 8, -1, 8, 0, 9, 0, 10, 2, 10, 3, 12, 3, 12, 3, 13, 5, 12, 5, 14,
5, 14, 7, 15, 7, 15, 7, 16, 8, 16, 8, 16, 9, 17, 10, 17, 10, 18, 11, 18, 12, 19,
12, 19, 13, 20, 14, 21, 13, 21, 15, 22, 15, 21, 16, 22, 16, 22, 16, 23, 17, 23,
17, 23, 18, 24, 19, 23, 20, 23, 20, 24, 21, 25, 21, 24, 21, 24, 21, 24, 22, 25,
22, 25, 22, 24, 23, 24, 23, 25, 24, 24, 25, 24, 24, 24, 24, 24, 24, 23, 25, 24,
24, 23, 24, 24, 25, 22, 25, 22, 25, 22, 24, 22, 25, 21, 25, 21, 25, 21, 24, 20,
25, 20, 24, 20, 23, 19, 23, 18, 24, 17, 23, 17, 23, 16, 22, 16, 21, 14, 21, 14,
21, 13, 20, 12, 19, 11, 19, 10, 18, 10, 17, 9, 17, 8, 16, 7, 16, 7, 15, 6, 14,
5, 12, 5, 12, 4, 12, 2, 11, 1, 10, 1, 8, 0, 7, -2, 7, -3, 5, -4, 5, -3, 4, -6,
2, -6, 2, -7, 1, -8, 0, -9, -1, -9, -3, -10, -3, -11, -4, -11, -5, -12, -6, -13,
-7, -14, -8, -15, -8, -16, -10, -16, -10, -16, -11, -17, -12, -18, -12, -18,
-13, -19, -14, -19, -16, -19, -16, -21, -17, -21, -18, -22, -19, -21, -19, -22,
-20, -23, -20, -23, -21, -24, -22, -24, -22, -25, -22, -24, -23, -25, -23, -25,
-24, -25, -25, -26, -24, -26, -26, -26, -26, -26, -27, -27, -27, -28, -27, -27,
-27, -28, -26, -27, -27, -28, -28, -27, -27, -28, -28, -29, -29, -29, -28, -28,
-29, -28, -28, -29, -28, -28, -29, -29, -29, -29, -30, -28, -29, -29, -29, -28,
-29, -29, -29, -29, -29, -29, -29, -29, -29, -29, -28, -28, -29, -27, -29, -28,
-28, -28, -28, -27, -27, -27, -28, -27, -28, -27, -27, -27, -28, -27, -27, -26,
-27, -26, -27, -26, -27, -27, -26, -26, -27, -26, -26, -25, -27, -27, -27, -25,
-26, -25, -26, -26, -26, -25, -25, -25, -25, -25, -25, -25, -26, -24, -25, -24,
-24, -24, -25, -24, -25, -23, -25, -23, -24, -23, -24, -23, -24, -22, -24, -22,
-23, -22, -24, -23, -23, -21, -23, -21, -23, -21, -23, -21, -23, -21, -23, -20,
-22, -20, -21, -19, -22, -20, -21, -18, -20, -18, -20, -18, -20, -17, -19, -16,
-19, -16, -19, -15, -19, -14, -18, -14, -18, -14, -17, -12, -16, -12, -16, -10,
-15, -10, -15, -9, -14, -9, -14, -6, -12, -6, -12, -5, -11, -4, -10, -3, -9, -2,
-8, -1, -6, };