#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 14, 0, 15, 2, 17, 1, 16, 4, 19, 2,
15, 10, 23, 75, 90, 86, 98, 86, 88, 90, 83, 88, 75, 94, 82, 95, 94, 99, 100, 98,
99, 97, 98, 96, 98, 96, 103, 94, 102, 92, 99, 87, 96, 87, 97, 86, 98, 85, 98,
81, 94, 80, 94, 80, 94, 81, 95, 78, 94, 78, 92, 76, 91, 77, 93, 77, 93, 78, 92,
77, 92, 78, 92, 80, 94, 80, 93, 81, 94, 81, 94, 84, 95, 85, 96, 86, 96, 88, 97,
88, 97, 90, 98, 92, 99, 93, 100, 94, 100, 96, 100, 97, 101, 98, 102, 99, 103,
100, 104, 102, 104, 103, 104, 104, 106, 106, 106, 106, 106, 108, 108, 109, 108,
110, 109, 112, 110, 112, 110, 112, 111, 114, 111, 114, 112, 115, 113, 116, 114,
117, 113, 117, 114, 118, 114, 119, 115, 119, 115, 119, 116, 119, 116, 119, 116,
119, 117, 119, 117, 118, 117, 119, 117, 120, 117, 119, 117, 119, 118, 118, 117,
119, 117, 119, 118, 118, 118, 120, 119, 119, 118, 119, 118, 119, 118, 120, 118,
120, 118, 119, 119, 119, 118, 119, 118, 119, 118, 119, 117, 119, 117, 119, 118,
119, 117, 119, 117, 119, 117, 119, 116, 119, 115, 120, 115, 119, 115, 119, 114,
118, 114, 118, 114, 120, 113, 119, 113, 119, 112, 118, 111, 119, 111, 119, 111,
119, 111, 118, 110, 119, 109, 118, 109, 117, 108, 116, 107, 116, 107, 115, 107,
114, 106, 113, 106, 114, 105, 113, 104, 112, 104, 112, 103, 111, 101, 109, 101,
109, 100, 108, 98, 108, 98, 108, 98, 107, 97, 106, 96, 104, 96, 105, 94, 104,
94, 103, 93, 102, 92, 102, 91, 101, 89, 100, 89, 99, 88, 98, 87, 97, 87, 96, 86,
96, 85, 96, 84, 94, 83, 94, 83, 93, 81, 92, 80, 90, 78, 90, 77, 89, 76, 88, 76,
86, 74, 85, 73, 84, 72, 84, 72, 82, 70, 81, 69, 81, 68, 80, 67, 79, 66, 78, 65,
77, 64, 76, 62, 75, 62, 74, 61, 72, 60, 72, 58, 71, 56, 70, 56, 69, 55, 68, 53,
66, 52, 65, 52, 64, 50, 63, 49, 62, 48, 61, 46, 60, 46, 59, 44, 58, 44, 57, 42,
56, 41, 55, 41, 53, 39, 52, 38, 51, 37, 51, 35, 50, 34, 49, 34, 47, 33, 47, 31,
46, 30, 45, 29, 44, 28, 43, 27, 42, 26, 40, 25, 40, 24, 39, 22, 37, 22, 36, 21,
35, 20, 34, 18, 33, 17, 33, 17, 31, 15, 31, 15, 30, 14, 28, 13, 27, 12, 26, 10,
26, 9, 25, 9, 24, 8, 23, 8, 22, 7, 21, 6, 21, 4, 19, 4, 19, 3, 18, 2, 16, 1, 16,
0, 15, 0, 14, -2, 14, -2, 11, -4, 11, -3, 10, -5, 10, -6, 9, -6, 9, -6, 7, -7,
6, -8, 5, -9, 5, -10, 4, -11, 4, -12, 4, -12, 2, -12, 1, -13, 1, -14, 1, -13,
-1, -16, 0, -15, -2, -17, -1, -16, -4, -19, -2, -16, -7, -20, -1, -15, -17, -31,
-82, -95, -86, -97, -88, -90, -90, -82, -89, -75, -94, -84, -97, -95, -100,
-102, -98, -99, -98, -99, -96, -99, -98, -104, -95, -102, -92, -100, -89, -97,
-87, -98, -87, -99, -86, -98, -82, -95, -81, -94, -80, -95, -81, -97, -79, -95,
-78, -93, -78, -92, -78, -94, -79, -94, -78, -93, -78, -93, -80, -93, -81, -94,
-81, -95, -82, -95, -83, -95, -85, -96, -86, -97, -87, -97, -88, -98, -90, -98,
-92, -99, -93, -100, -93, -100, -95, -101, -97, -102, -98, -103, -99, -103,
-101, -104, -103, -105, -104, -106, -103, -106, -105, -106, -107, -108, -107,
-108, -109, -109, -110, -109, -112, -110, -112, -112, -113, -112, -113, -112,
-115, -112, -115, -114, -117, -114, -117, -114, -118, -114, -119, -116, -119,
-116, -119, -116, -119, -117, -119, -117, -119, -118, -119, -118, -119, -118,
-119, -118, -120, -118, -119, -118, -119, -118, -119, -118, -119, -118, -120,
-119, -119, -119, -120, -119, -119, -119, -120, -119, -119, -120, -118, -119,
-119, -119, -119, -119, -119, -119, -120, -118, -119, -119, -120, -119, -119,
-119, -120, -118, -119, -118, -119, -118, -118, -117, -118, -118, -119, -118,
-119, -117, -120, -116, -119, -115, -119, -115, -119, -116, -119, -115, -119,
-114, -119, -114, -119, -113, -120, -113, -120, -113, -119, -112, -119, -112,
-119, -111, -119, -111, -119, -111, -117, -109, -118, -109, -117, -108, -117,
-108, -117, -108, -116, -107, -115, -107, -115, -106, -114, -105, -113, -104,
-112, -103, -111, -102, -111, -102, -111, -101, -110, -100, -109, -99, -108,
-99, -107, -98, -107, -97, -106, -96, -105, -95, -105, -94, -104, -93, -103,
-93, -103, -92, -101, -91, -101, -90, -100, -89, -100, -88, -99, -88, -98, -86,
-97, -86, -96, -84, -95, -84, -95, -82, -94, -82, -92, -81, -91, -79, -90, -79,
-89, -77, -88, -77, -87, -75, -86, -74, -85, -73, -84, -72, -83, -71, -82, -70,
-82, -69, -81, -68, -80, -66, -78, -66, -78, -64, -76, -64, -76, -62, -75, -62,
-74, -60, -73, -58, -72, -58, -70, -57, -70, -56, -69, -55, -67, -54, -66, -52,
-65, -50, -64, -50, -63, -49, -62, -48, -61, -46, -60, -45, -60, -45, -58, -43,
-57, -42, -55, -42, -55, -40, -54, -39, -53, -37, -51, -36, -51, -35, -49, -34,
-48, -33, -48, -32, -46, -31, -45, -31, -44, -29, -44, -28, -43, -27, -42, -26,
-40, -25, -39, -24, -38, -23, -37, -22, -36, -21, -35, -20, -35, -18, -34, -18,
-32, -17, -31, -16, -30, -15, -29, -14, -29, -13, -28, -11, -27, -12, -25, -11,
-26, -10, -24, -8, -24, -8, -21, -7, -22, -6, -20, -5, -20, -4, -19, -3, -18,
-2, -17, -2, -15, 0, -15, 0, -14, 2, -13, 3, -13, 3, -11, 4, -12, 4, -10, 6,
-10, 7, -8, 7, -8, 7, -7, 8, -6, 9, -5, 8, -5, 10, -4, 10, -4, 11, -3, 11, -1,
14, -2, 13, 0, 15, 0, 12, };