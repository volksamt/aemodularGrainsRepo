#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0053

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 11, 4, 15, 6, 16, 8, 19, 11, 20,
14, 21, 16, 23, 18, 25, 20, 26, 22, 27, 24, 29, 26, 31, 28, 33, 29, 34, 31, 35,
33, 36, 35, 39, 37, 39, 40, 44, 44, 57, 46, 57, 48, 58, 50, 60, 51, 61, 53, 63,
54, 65, 55, 66, 58, 67, 59, 70, 60, 71, 62, 73, 62, 73, 64, 75, 66, 76, 67, 78,
68, 79, 69, 81, 71, 81, 72, 83, 73, 83, 74, 85, 75, 86, 76, 87, 77, 88, 78, 89,
80, 90, 80, 91, 81, 92, 82, 93, 83, 94, 84, 95, 84, 95, 85, 96, 87, 96, 87, 98,
87, 98, 88, 99, 88, 99, 89, 100, 90, 100, 90, 102, 91, 101, 91, 102, 92, 103,
92, 103, 93, 104, 93, 103, 94, 104, 94, 105, 94, 105, 94, 105, 95, 105, 96, 106,
95, 106, 95, 106, 96, 107, 95, 106, 95, 108, 96, 107, 95, 106, 96, 107, 96, 107,
96, 108, 96, 108, 96, 108, 96, 107, 96, 108, 96, 108, 97, 108, 96, 108, 97, 107,
96, 108, 96, 108, 97, 108, 96, 108, 95, 107, 96, 107, 95, 108, 96, 107, 95, 108,
95, 106, 94, 107, 95, 107, 95, 106, 95, 106, 94, 106, 94, 105, 94, 106, 94, 106,
93, 104, 93, 104, 92, 103, 93, 103, 92, 104, 91, 103, 91, 103, 91, 103, 90, 101,
90, 101, 89, 101, 90, 101, 88, 100, 88, 99, 88, 99, 87, 98, 87, 99, 87, 98, 86,
98, 85, 97, 85, 95, 85, 95, 84, 95, 83, 95, 82, 94, 81, 93, 82, 92, 81, 92, 80,
91, 79, 91, 79, 90, 78, 89, 78, 88, 76, 88, 77, 86, 76, 86, 76, 85, 75, 85, 74,
84, 74, 84, 73, 83, 72, 82, 72, 82, 71, 81, 70, 80, 70, 80, 68, 79, 68, 78, 67,
77, 68, 76, 66, 76, 65, 75, 65, 75, 64, 73, 64, 73, 63, 73, 62, 71, 62, 70, 61,
69, 60, 69, 59, 68, 59, 67, 58, 67, 57, 65, 56, 64, 55, 63, 54, 63, 54, 63, 54,
60, 52, 60, 52, 60, 51, 57, 50, 58, 48, 56, 48, 56, 48, 55, 47, 53, 46, 53, 45,
52, 44, 51, 43, 50, 43, 50, 41, 48, 42, 48, 40, 46, 39, 46, 39, 44, 38, 44, 37,
43, 37, 42, 35, 41, 34, 40, 33, 38, 32, 38, 32, 36, 31, 36, 30, 34, 30, 33, 29,
34, 28, 32, 28, 32, 26, 30, 26, 31, 23, 21, 21, 14, 20, 16, 19, 14, 19, 14, 18,
13, 17, 13, 17, 13, 17, 13, 17, 12, 16, 12, 15, 11, 15, 10, 14, 10, 13, 10, 14,
10, 13, 9, 13, 10, 12, 8, 11, 8, 11, 8, 10, 8, 10, 7, 9, 7, 9, 7, 8, 7, 8, 7, 7,
6, 7, 6, 7, 5, 6, 5, 7, 4, 6, 4, 5, 4, 5, 4, 5, 3, 4, 4, 4, 3, 3, 3, 2, 2, 2, 3,
2, 2, 2, 2, 1, 2, 0, 2, 1, 0, -1, 0, -1, 1, -2, 0, -2, 0, -2, -1, -3, -1, -3,
-2, -3, -1, -5, -2, -4, -2, -5, -3, -5, -2, -6, -4, -5, -3, -7, -4, -10, -16,
-12, -18, -12, -18, -13, -19, -13, -19, -14, -21, -14, -21, -15, -22, -16, -22,
-16, -23, -16, -23, -17, -25, -17, -25, -19, -25, -19, -26, -20, -26, -20, -28,
-20, -28, -21, -30, -22, -29, -22, -30, -22, -30, -23, -32, -23, -32, -25, -33,
-24, -34, -26, -35, -26, -36, -27, -37, -28, -37, -29, -38, -29, -39, -30, -40,
-31, -41, -32, -42, -32, -42, -34, -43, -34, -44, -35, -45, -36, -46, -36, -47,
-37, -48, -39, -49, -39, -49, -40, -50, -41, -52, -42, -53, -43, -53, -43, -54,
-44, -56, -46, -56, -46, -58, -47, -58, -47, -58, -49, -59, -50, -61, -50, -62,
-51, -62, -52, -64, -53, -65, -54, -66, -55, -67, -56, -68, -57, -69, -58, -70,
-59, -71, -60, -72, -60, -73, -62, -73, -62, -74, -63, -75, -63, -76, -64, -77,
-66, -78, -66, -79, -68, -79, -68, -81, -69, -82, -70, -82, -71, -83, -71, -84,
-72, -84, -73, -86, -74, -87, -75, -87, -75, -88, -76, -89, -77, -90, -78, -91,
-80, -91, -80, -93, -81, -93, -82, -94, -82, -96, -83, -96, -84, -97, -84, -98,
-85, -98, -86, -99, -87, -100, -88, -100, -88, -101, -89, -102, -90, -103, -91,
-103, -92, -103, -92, -105, -93, -106, -93, -106, -94, -107, -95, -108, -95,
-108, -96, -109, -97, -110, -97, -110, -99, -111, -99, -111, -99, -111, -101,
-112, -101, -113, -101, -114, -102, -113, -102, -114, -103, -115, -103, -116,
-105, -116, -104, -116, -104, -117, -104, -117, -105, -118, -106, -118, -105,
-118, -106, -118, -107, -118, -107, -119, -106, -119, -107, -119, -107, -119,
-107, -119, -108, -119, -107, -119, -107, -119, -107, -118, -107, -120, -108,
-119, -107, -119, -107, -118, -107, -118, -107, -118, -107, -118, -107, -117,
-106, -118, -106, -117, -106, -117, -105, -116, -105, -115, -105, -116, -105,
-114, -105, -114, -104, -114, -103, -113, -102, -113, -102, -112, -102, -112,
-100, -110, -99, -110, -100, -109, -98, -108, -97, -106, -96, -105, -95, -104,
-95, -104, -94, -103, -92, -102, -91, -101, -91, -99, -90, -98, -89, -97, -87,
-96, -86, -94, -85, -93, -83, -92, -82, -91, -80, -89, -79, -87, -78, -86, -77,
-84, -74, -83, -73, -80, -72, -80, -71, -77, -69, -76, -67, -74, -65, -72, -64,
-70, -62, -68, -61, -67, -58, -65, -57, -64, -55, -61, -53, -59, -52, -57, -49,
-55, -47, -53, -45, -51, -43, -48, -42, -46, -40, -45, -34, -32, -31, -27, -30,
-27, -27, -24, -26, -24, -24, -21, -23, -19, -20, -18, -19, -17, -17, -14, -15,
-13, -13, -11, -11, -10, -9, -8, -7, -7, -6, -6, -3, -4, -2, -3, 0, -1, 0, 1, 5,
3, -24, -7, -38, -11, -26, -5, -24, -4, -17, 0, -15, 2, -10, 4, -7, 5, -4, 9,
-1, 10, };