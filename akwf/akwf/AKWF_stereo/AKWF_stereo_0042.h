#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0042

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 7, 9, 10, 12, 14, 17, 18, 20,
20, 23, 24, 26, 27, 30, 30, 33, 33, 35, 35, 39, 39, 41, 40, 43, 43, 47, 45, 48,
46, 50, 47, 53, 49, 54, 50, 56, 51, 56, 51, 57, 51, 58, 52, 59, 52, 59, 52, 61,
52, 61, 53, 61, 52, 60, 52, 59, 52, 60, 52, 60, 51, 60, 51, 60, 51, 59, 50, 59,
50, 58, 50, 58, 50, 57, 50, 58, 49, 57, 49, 57, 49, 57, 48, 56, 48, 57, 48, 56,
48, 56, 48, 56, 47, 55, 48, 56, 48, 55, 47, 55, 48, 55, 48, 55, 48, 55, 48, 55,
49, 55, 49, 55, 50, 56, 52, 57, 53, 58, 55, 59, 56, 60, 57, 60, 59, 61, 61, 63,
63, 63, 65, 64, 67, 66, 69, 67, 71, 68, 73, 70, 74, 71, 77, 72, 78, 74, 80, 76,
82, 78, 85, 80, 86, 81, 88, 84, 91, 86, 93, 87, 95, 90, 96, 92, 98, 94, 100, 96,
101, 97, 104, 100, 105, 101, 108, 103, 108, 105, 110, 107, 112, 109, 114, 109,
114, 112, 115, 113, 117, 114, 116, 116, 119, 117, 119, 118, 118, 118, 119, 118,
119, 119, 118, 119, 118, 119, 117, 119, 116, 119, 115, 118, 114, 119, 113, 118,
111, 117, 110, 118, 108, 117, 108, 116, 105, 117, 104, 115, 103, 114, 102, 114,
101, 114, 99, 113, 97, 113, 96, 112, 95, 111, 94, 110, 92, 109, 91, 109, 90,
107, 88, 106, 86, 104, 86, 102, 83, 100, 81, 99, 80, 98, 79, 96, 77, 95, 76, 93,
74, 92, 73, 89, 72, 88, 72, 86, 70, 84, 68, 83, 69, 82, 69, 82, 68, 80, 67, 80,
67, 79, 69, 79, 70, 78, 69, 77, 70, 78, 70, 77, 72, 77, 73, 77, 74, 76, 74, 77,
75, 77, 76, 76, 76, 75, 79, 75, 78, 75, 79, 76, 80, 75, 81, 76, 82, 75, 83, 75,
83, 75, 83, 75, 84, 74, 85, 74, 86, 75, 86, 74, 87, 74, 88, 74, 89, 75, 89, 75,
90, 76, 90, 75, 90, 76, 92, 77, 92, 78, 92, 78, 93, 79, 93, 80, 94, 81, 93, 81,
93, 82, 93, 83, 92, 82, 92, 82, 91, 82, 90, 82, 88, 83, 87, 82, 86, 82, 85, 82,
84, 81, 82, 81, 80, 81, 78, 80, 78, 81, 76, 80, 74, 79, 73, 79, 72, 80, 70, 78,
69, 78, 68, 77, 66, 76, 64, 76, 63, 76, 62, 76, 60, 74, 59, 74, 57, 73, 55, 71,
54, 71, 53, 70, 51, 69, 50, 68, 48, 67, 47, 67, 45, 65, 44, 64, 42, 63, 40, 62,
39, 61, 39, 60, 37, 58, 36, 57, 35, 55, 35, 54, 34, 53, 34, 50, 33, 49, 33, 48,
33, 45, 32, 44, 32, 43, 31, 41, 32, 38, 31, 37, 30, 35, 29, 34, 30, 31, 29, 30,
28, 29, 27, 27, 26, 24, 26, 23, 25, 21, 24, 20, 24, 18, 23, 16, 23, 14, 22, 13,
20, 11, 20, 8, 19, 7, 19, 5, 18, 4, 17, 2, 16, 0, 15, -2, 13, -5, 13, -5, 11,
-8, 11, -9, 9, -10, 7, -12, 7, -14, 5, -16, 3, -19, 1, -20, -1, -23, -4, -25,
-6, -27, -9, -29, -12, -31, -13, -33, -17, -35, -19, -35, -21, -38, -23, -38,
-25, -39, -27, -40, -29, -40, -31, -41, -33, -42, -34, -43, -36, -43, -38, -44,
-39, -44, -42, -45, -43, -47, -46, -46, -47, -47, -48, -48, -50, -48, -51, -48,
-53, -49, -54, -49, -55, -50, -56, -49, -58, -50, -59, -51, -60, -51, -62, -52,
-63, -52, -64, -52, -64, -52, -65, -52, -65, -53, -66, -52, -65, -52, -66, -51,
-66, -51, -66, -50, -64, -50, -64, -49, -62, -48, -62, -47, -60, -48, -59, -46,
-58, -46, -57, -45, -56, -45, -56, -45, -56, -44, -54, -45, -53, -44, -52, -45,
-51, -46, -52, -45, -51, -46, -50, -47, -50, -48, -50, -49, -50, -50, -49, -50,
-49, -51, -49, -53, -49, -54, -49, -54, -48, -55, -49, -57, -49, -58, -49, -59,
-49, -60, -49, -61, -49, -62, -49, -63, -50, -64, -51, -65, -51, -67, -52, -69,
-53, -70, -55, -72, -56, -74, -58, -76, -60, -78, -62, -80, -63, -81, -66, -84,
-68, -86, -71, -89, -73, -90, -75, -93, -77, -95, -80, -96, -82, -99, -84, -101,
-86, -102, -89, -104, -91, -106, -93, -107, -94, -109, -96, -111, -99, -112,
-101, -114, -102, -115, -103, -115, -104, -117, -106, -118, -108, -117, -108,
-118, -110, -117, -112, -118, -112, -118, -113, -117, -114, -118, -114, -117,
-116, -117, -116, -116, -117, -116, -117, -116, -117, -115, -118, -115, -118,
-114, -118, -113, -117, -112, -116, -111, -116, -111, -114, -108, -113, -107,
-111, -107, -111, -105, -109, -104, -108, -102, -106, -102, -105, -100, -104,
-99, -102, -98, -100, -96, -99, -95, -97, -93, -96, -93, -94, -92, -93, -90,
-92, -90, -91, -88, -91, -87, -90, -87, -87, -85, -87, -85, -86, -84, -85, -83,
-83, -82, -82, -81, -81, -81, -81, -81, -80, -80, -80, -80, -79, -81, -78, -80,
-78, -80, -77, -81, -76, -82, -77, -83, -77, -83, -77, -84, -77, -85, -79, -87,
-79, -89, -80, -89, -81, -90, -83, -92, -84, -94, -85, -95, -88, -97, -89, -98,
-90, -100, -91, -101, -94, -103, -95, -104, -96, -107, -98, -107, -99, -109,
-100, -110, -102, -110, -102, -111, -103, -112, -104, -113, -106, -114, -106,
-114, -108, -114, -108, -116, -109, -116, -109, -117, -110, -116, -110, -118,
-111, -117, -110, -117, -111, -117, -110, -116, -111, -117, -111, -116, -110,
-115, -109, -115, -108, -115, -108, -113, -108, -111, -106, -109, -104, -107,
-102, -105, -100, -104, -98, -100, -95, -97, -92, -93, -88, -89, -85, -85, -82,
-81, -77, -77, -73, -73, -70, -70, -66, -65, -61, -61, -57, -57, -53, -52, -49,
-49, -46, -45, -41, -40, -37, -37, -33, -32, -29, -28, -25, -24, -22, -19, -17,
-16, -13, -12, -10, -8, -6, -4, -3, -1, 1, };