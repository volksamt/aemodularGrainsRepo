#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0137

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -69, 4, -80, 7, -72, 9, -73, 11,
-67, 15, -67, 16, -62, 19, -63, 22, -57, 25, -56, 27, -51, 30, -50, 33, -46, 35,
-44, 37, -40, 40, -39, 43, -35, 46, -32, 48, -30, 50, -27, 52, -24, 55, -22, 57,
-18, 60, -16, 62, -13, 65, -10, 67, -7, 68, -4, 72, -2, 73, 1, 76, 3, 78, 6, 80,
8, 82, 11, 83, 13, 85, 16, 87, 18, 89, 21, 91, 23, 93, 26, 94, 27, 95, 29, 98,
31, 100, 34, 101, 36, 102, 38, 104, 40, 106, 42, 107, 44, 108, 45, 109, 48, 111,
49, 112, 51, 113, 52, 115, 54, 116, 55, 116, 57, 117, 59, 118, 60, 119, 61, 119,
63, 119, 63, 120, 64, 119, 65, 119, 65, 118, 66, 118, 66, 118, 67, 117, 67, 117,
67, 116, 67, 115, 67, 114, 67, 113, 67, 111, 66, 110, 66, 109, 67, 107, 66, 107,
65, 105, 64, 103, 64, 101, 63, 100, 62, 98, 62, 96, 61, 94, 60, 92, 59, 90, 58,
88, 57, 87, 57, 84, 54, 81, 54, 79, 53, 77, 51, 76, 51, 73, 50, 71, 48, 68, 47,
66, 45, 64, 44, 62, 42, 60, 42, 57, 41, 56, 40, 54, 38, 51, 37, 48, 35, 47, 35,
44, 32, 42, 31, 39, 31, 38, 30, 36, 27, 34, 27, 31, 25, 30, 24, 27, 23, 25, 22,
23, 21, 22, 20, 19, 18, 18, 17, 16, 16, 14, 15, 13, 14, 10, 13, 9, 11, 7, 11, 5,
10, 3, 8, 1, 7, 1, 7, -2, 6, -3, 5, -4, 3, -6, 2, -7, 2, -9, 0, -11, 0, -12, 0,
-13, -2, -15, -3, -15, -3, -17, -5, -19, -5, -20, -5, -20, -7, -22, -6, -23, -8,
-24, -9, -25, -8, -26, -9, -27, -10, -28, -11, -30, -11, -31, -11, -31, -12,
-32, -13, -33, -13, -33, -15, -35, -14, -35, -14, -36, -15, -37, -15, -37, -16,
-38, -15, -39, -16, -40, -17, -40, -17, -41, -17, -41, -18, -42, -18, -42, -18,
-43, -19, -43, -19, -43, -18, -44, -19, -45, -20, -45, -20, -45, -20, -46, -21,
-47, -20, -47, -21, -46, -21, -47, -21, -48, -20, -48, -20, -47, -20, -48, -21,
-48, -21, -48, -21, -49, -20, -49, -21, -49, -22, -49, -21, -50, -21, -50, -21,
-49, -21, -50, -22, -50, -22, -49, -21, -50, -22, -49, -21, -50, -22, -50, -22,
-49, -21, -50, -21, -50, -20, -50, -21, -50, -20, -49, -20, -49, -20, -50, -19,
-49, -20, -49, -21, -50, -20, -50, -20, -49, -19, -48, -18, -48, -19, -48, -19,
-49, -19, -48, -18, -48, -18, -48, -18, -48, -18, -47, -18, -47, -17, -47, -17,
-47, -17, -47, -17, -46, -16, -46, -16, -46, -16, -46, -15, -45, -15, -46, -15,
-45, -15, -45, -15, -45, -13, -45, -14, -44, -14, -44, -13, -43, -13, -44, -12,
-43, -12, -43, -12, -42, -12, -42, -11, -42, -11, -41, -11, -41, -11, -41, -10,
-41, -10, -40, -10, -41, -9, -40, -9, -40, -9, -39, -8, -38, -8, -39, -8, -38,
-7, -37, -7, -38, -6, -37, -6, -37, -6, -36, -6, -36, -5, -36, -4, -37, -5, -36,
-4, -35, -4, -35, -3, -34, -3, -34, -2, -34, -2, -33, -2, -33, -2, -33, -2, -32,
-1, -32, 0, -32, 0, -31, 0, -31, 0, -30, 0, -30, 1, -31, 2, -30, 2, -29, 3, -29,
3, -29, 2, -29, 4, -27, 4, -28, 4, -27, 5, -28, 4, -27, 5, -26, 5, -26, 7, -26,
6, -25, 7, -25, 7, -25, 8, -24, 8, -24, 9, -23, 9, -24, 9, -23, 10, -23, 9, -23,
10, -22, 10, -22, 11, -21, 11, -22, 11, -21, 12, -20, 12, -21, 13, -20, 13, -19,
13, -19, 14, -19, 14, -19, 15, -18, 15, -18, 15, -18, 15, -17, 16, -17, 17, -17,
17, -16, 17, -16, 18, -15, 19, -15, 19, -16, 18, -15, 19, -15, 19, -15, 20, -14,
20, -14, 21, -14, 21, -12, 21, -12, 22, -12, 22, -12, 23, -12, 22, -12, 23, -10,
23, -11, 24, -10, 24, -10, 25, -10, 25, -9, 25, -9, 26, -9, 26, -9, 27, -9, 27,
-7, 27, -7, 27, -7, 29, -7, 28, -6, 29, -7, 29, -6, 30, -6, 30, -6, 30, -5, 30,
-5, 32, -5, 32, -5, 32, -4, 33, -4, 32, -4, 33, -3, 34, -3, 34, -3, 34, -2, 34,
-2, 35, -3, 36, -2, 37, -1, 36, -1, 37, -1, 37, -1, 38, 0, 38, -1, 39, 0, 39, 1,
39, 1, 40, 2, 40, 2, 40, 1, 41, 1, 41, 2, 42, 2, 42, 3, 43, 2, 43, 4, 43, 3, 44,
4, 44, 4, 44, 4, 45, 4, 45, 4, 46, 5, 46, 5, 47, 6, 47, 6, 47, 6, 48, 6, 48, 6,
49, 7, 49, 6, 48, 6, 48, 7, 48, 7, 48, 8, 48, 7, 47, 6, 46, 7, 46, 6, 45, 6, 44,
6, 42, 5, 42, 5, 40, 4, 39, 4, 38, 4, 36, 3, 35, 2, 33, 3, 31, 2, 30, 1, 28, 0,
26, 0, 24, 0, 22, -1, 20, -2, 17, -3, 14, -4, 12, -4, 10, -5, 8, -6, 5, -6, 3,
-8, 1, -8, -2, -9, -5, -10, -7, -11, -10, -12, -13, -13, -15, -14, -19, -14,
-21, -16, -24, -16, -27, -18, -29, -19, -33, -20, -35, -21, -38, -21, -41, -22,
-44, -24, -47, -25, -50, -25, -52, -27, -55, -27, -58, -29, -61, -29, -63, -29,
-66, -31, -69, -32, -73, -34, -75, -34, -78, -34, -80, -36, -83, -36, -87, -37,
-89, -39, -92, -40, -94, -40, -96, -41, -99, -42, -101, -42, -102, -42, -104,
-42, -107, -42, -107, -43, -109, -41, -110, -42, -109, -41, -111, -41, -112,
-40, -111, -40, -112, -38, -111, -37, -111, -36, -111, -35, -110, -34, -109,
-32, -108, -30, -107, -29, -107, -27, -104, -25, -105, -23, -101, -21, -102,
-19, -97, -17, -98, -14, -93, -12, -95, -9, -89, -7, -91, -5, -82, -4, -89, 0,
-69, };