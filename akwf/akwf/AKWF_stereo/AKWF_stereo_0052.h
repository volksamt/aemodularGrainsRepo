#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0052

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -3, 3, -1, 4, 4, 3, 7, 3, 8, 5, 9,
8, 14, 10, 18, 14, 18, 16, 17, 17, 16, 17, 14, 19, 17, 23, 22, 26, 27, 28, 27,
29, 27, 28, 27, 27, 29, 29, 31, 32, 35, 36, 38, 37, 43, 38, 47, 39, 54, 43, 61,
48, 69, 54, 75, 61, 78, 66, 83, 71, 87, 77, 95, 86, 102, 94, 102, 101, 102, 106,
99, 108, 98, 111, 102, 114, 104, 118, 107, 119, 107, 117, 105, 114, 104, 109,
106, 107, 110, 106, 113, 104, 115, 101, 116, 96, 116, 92, 118, 90, 119, 89, 118,
89, 114, 87, 109, 84, 104, 81, 103, 79, 104, 79, 105, 78, 102, 78, 96, 74, 92,
71, 90, 69, 88, 69, 87, 68, 84, 66, 80, 64, 78, 61, 76, 58, 75, 57, 75, 57, 75,
57, 73, 55, 70, 54, 66, 52, 64, 52, 63, 52, 62, 52, 59, 51, 57, 50, 55, 48, 54,
47, 55, 46, 55, 47, 54, 47, 51, 45, 48, 43, 47, 42, 48, 41, 49, 41, 48, 41, 46,
40, 41, 37, 38, 35, 34, 32, 32, 31, 28, 29, 25, 25, 24, 22, 23, 17, 23, 15, 25,
14, 27, 13, 25, 12, 25, 10, 24, 8, 23, 8, 23, 10, 24, 12, 23, 12, 22, 13, 22,
14, 23, 16, 23, 19, 24, 21, 23, 24, 21, 24, 20, 24, 20, 25, 22, 27, 25, 28, 28,
31, 30, 32, 30, 31, 31, 32, 33, 33, 35, 34, 39, 37, 41, 39, 43, 40, 46, 43, 50,
44, 53, 47, 53, 51, 50, 52, 48, 51, 45, 51, 43, 51, 43, 49, 42, 49, 43, 47, 41,
44, 42, 41, 42, 39, 42, 35, 41, 32, 39, 28, 36, 26, 36, 24, 34, 21, 32, 17, 30,
16, 26, 13, 24, 10, 21, 8, 18, 6, 16, 4, 12, 2, 10, 1, 8, -2, 7, -3, 6, -4, 4,
-5, 1, -5, -1, -7, -3, -9, -6, -9, -9, -10, -12, -11, -13, -14, -15, -14, -15,
-15, -17, -17, -17, -17, -18, -18, -21, -19, -25, -21, -27, -23, -29, -24, -31,
-26, -31, -26, -32, -29, -33, -30, -34, -31, -35, -32, -34, -34, -35, -33, -36,
-35, -38, -36, -39, -36, -41, -37, -41, -38, -43, -38, -46, -40, -49, -41, -53,
-44, -55, -46, -57, -48, -57, -49, -57, -51, -59, -53, -58, -55, -57, -57, -55,
-57, -54, -56, -53, -56, -55, -55, -55, -56, -56, -54, -56, -52, -56, -51, -56,
-48, -56, -47, -54, -46, -53, -44, -52, -43, -51, -41, -50, -39, -49, -37, -48,
-36, -47, -35, -45, -33, -44, -31, -41, -30, -41, -29, -40, -28, -39, -28, -38,
-26, -35, -25, -35, -24, -33, -23, -33, -23, -32, -23, -30, -22, -31, -22, -31,
-22, -32, -23, -32, -24, -33, -24, -32, -26, -33, -27, -32, -27, -32, -29, -31,
-30, -32, -31, -31, -32, -31, -33, -30, -32, -32, -33, -34, -34, -35, -34, -38,
-35, -39, -36, -39, -35, -40, -37, -41, -37, -41, -39, -42, -40, -41, -39, -40,
-39, -39, -39, -37, -38, -36, -37, -36, -36, -39, -36, -42, -35, -45, -35, -46,
-36, -45, -33, -43, -33, -39, -34, -37, -33, -37, -33, -40, -33, -44, -34, -49,
-36, -52, -36, -51, -37, -49, -38, -46, -39, -43, -40, -42, -42, -45, -43, -49,
-45, -52, -46, -57, -48, -57, -49, -56, -50, -55, -51, -54, -52, -52, -52, -52,
-54, -54, -54, -58, -55, -61, -55, -64, -57, -66, -57, -65, -58, -63, -58, -60,
-58, -58, -56, -55, -56, -53, -55, -53, -53, -55, -51, -57, -50, -59, -49, -60,
-48, -58, -45, -55, -43, -50, -41, -46, -38, -44, -37, -43, -34, -44, -33, -44,
-31, -43, -29, -41, -26, -37, -25, -33, -23, -29, -21, -26, -19, -24, -17, -25,
-15, -26, -14, -26, -13, -25, -13, -23, -11, -20, -11, -18, -9, -16, -10, -14,
-9, -13, -9, -12, -9, -11, -9, -11, -8, -10, -8, -9, -7, -7, -8, -6, -7, -5, -6,
-4, -6, -2, -4, 0, -4, 3, -1, 5, 1, 6, 3, 6, 4, 5, 4, 4, 6, 2, 7, 2, 8, 3, 8, 6,
10, 9, 10, 11, 12, 13, 12, 12, 11, 10, 11, 10, 12, 7, 12, 6, 11, 7, 11, 8, 9,
10, 9, 10, 8, 9, 7, 7, 5, 5, 3, 1, 2, -1, 0, -3, -3, -3, -4, -3, -5, -2, -8, -2,
-9, -2, -10, -5, -13, -9, -15, -14, -16, -17, -18, -18, -19, -20, -20, -19, -21,
-17, -22, -17, -24, -17, -24, -19, -24, -21, -24, -23, -25, -25, -24, -25, -24,
-24, -23, -21, -22, -21, -21, -20, -21, -20, -19, -20, -17, -21, -16, -21, -15,
-21, -14, -20, -12, -18, -11, -15, -9, -14, -9, -14, -8, -13, -7, -15, -6, -16,
-6, -16, -6, -17, -6, -16, -7, -13, -7, -11, -6, -8, -7, -6, -7, -7, -7, -7, -7,
-9, -7, -10, -8, -10, -7, -9, -7, -7, -7, -6, -6, -2, -6, -1, -5, -1, -4, -3,
-4, -5, -4, -7, -5, -6, -3, -3, -1, 0, 0, 3, 1, 3, 0, 3, 0, 2, 2, 2, 3, 2, 5, 2,
5, 3, 5, 3, 6, 5, 6, 7, 7, 8, 8, 7, 8, 6, 9, 6, 9, 6, 8, 5, 8, 5, 8, 4, 8, 3, 6,
2, 5, 2, 3, 2, 3, 3, 2, 3, 1, 2, 0, -1, -3, -6, -6, -8, -8, -9, -8, -7, -10, -6,
-10, -4, -11, -7, -14, -9, -15, -13, -18, -16, -18, -19, -19, -21, -20, -21,
-21, -17, -22, -12, -21, -9, -20, -11, -19, -17, -21, -24, -21, -29, -22, -30,
-21, -26, -19, -21, -18, -18, -18, -17, -19, -18, -20, -20, -20, -23, -18, -27,
-18, -32, -19, -35, -21, -34, -23, -28, -22, -20, -20, -16, -19, -14, -19, -17,
-20, -20, -20, -24, -20, -26, -18, -23, -16, -21, -14, -16, -13, -12, -13, -7,
-10, -2, -7, -1, -3, -2, -1, -7, 0, -13, -1, -18, -2, -19, -1, -9, };