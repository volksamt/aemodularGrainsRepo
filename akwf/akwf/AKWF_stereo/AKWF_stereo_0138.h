#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0138

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 7, 4, 13, 9, 19, 15, 25, 19, 30,
23, 37, 28, 41, 33, 46, 36, 50, 39, 54, 43, 58, 47, 62, 50, 66, 53, 69, 56, 72,
60, 75, 62, 77, 65, 80, 66, 82, 69, 84, 71, 86, 74, 88, 76, 91, 77, 91, 79, 93,
81, 95, 82, 96, 83, 97, 85, 98, 86, 100, 87, 101, 88, 102, 89, 102, 91, 104, 93,
104, 93, 105, 95, 106, 95, 107, 96, 108, 97, 107, 97, 108, 99, 108, 98, 109, 99,
110, 99, 110, 101, 111, 101, 112, 101, 111, 103, 112, 102, 112, 102, 113, 104,
113, 104, 113, 103, 113, 104, 115, 105, 114, 105, 114, 105, 115, 105, 115, 106,
116, 106, 115, 107, 115, 108, 116, 107, 116, 108, 115, 107, 116, 107, 116, 107,
117, 107, 116, 108, 116, 108, 116, 109, 117, 108, 117, 108, 117, 108, 118, 109,
117, 110, 118, 110, 118, 109, 118, 110, 118, 110, 118, 109, 117, 109, 117, 109,
118, 110, 118, 109, 117, 111, 118, 110, 118, 110, 118, 110, 119, 111, 118, 111,
118, 110, 118, 110, 119, 111, 118, 110, 119, 110, 118, 111, 118, 111, 119, 111,
119, 111, 118, 111, 118, 112, 119, 112, 119, 112, 119, 111, 119, 111, 119, 111,
119, 111, 118, 112, 119, 112, 119, 111, 119, 112, 119, 112, 120, 111, 119, 111,
119, 112, 119, 112, 118, 111, 119, 112, 119, 112, 119, 112, 119, 112, 119, 112,
119, 111, 119, 111, 120, 112, 119, 112, 119, 112, 119, 112, 119, 112, 119, 112,
119, 112, 119, 112, 119, 112, 120, 111, 120, 111, 119, 112, 119, 112, 119, 112,
118, 112, 119, 111, 120, 112, 119, 112, 119, 112, 118, 112, 119, 111, 118, 112,
119, 112, 119, 112, 118, 111, 119, 111, 119, 112, 119, 112, 119, 111, 118, 111,
119, 111, 118, 111, 119, 111, 119, 112, 119, 111, 118, 110, 118, 112, 118, 111,
118, 110, 118, 110, 118, 111, 118, 111, 118, 110, 118, 111, 118, 111, 118, 110,
118, 110, 118, 110, 117, 110, 118, 110, 117, 110, 117, 110, 117, 109, 117, 109,
118, 110, 117, 110, 117, 109, 118, 109, 116, 108, 116, 109, 116, 108, 116, 108,
117, 108, 115, 108, 115, 108, 116, 107, 116, 107, 115, 106, 115, 107, 115, 106,
114, 106, 115, 105, 115, 106, 115, 105, 114, 105, 113, 104, 114, 104, 113, 104,
112, 104, 112, 102, 112, 102, 112, 102, 111, 102, 111, 101, 111, 101, 111, 100,
109, 100, 110, 99, 109, 98, 108, 98, 108, 97, 107, 97, 106, 96, 105, 95, 104,
94, 104, 93, 104, 92, 103, 91, 102, 90, 101, 89, 100, 88, 98, 86, 97, 85, 96,
84, 95, 82, 93, 80, 91, 79, 90, 77, 87, 75, 86, 73, 84, 70, 82, 70, 80, 66, 77,
64, 75, 62, 71, 58, 69, 56, 64, 53, 62, 50, 58, 47, 54, 43, 50, 40, 45, 36, 41,
31, 35, 27, 30, 23, 25, 19, 18, 14, 13, 9, 6, 5, -1, -1, -7, -5, -14, -10, -20,
-14, -25, -20, -31, -24, -36, -28, -42, -32, -46, -37, -50, -40, -55, -44, -59,
-48, -62, -50, -66, -53, -69, -56, -72, -60, -76, -62, -77, -64, -80, -66, -82,
-69, -84, -71, -87, -74, -89, -76, -90, -78, -92, -79, -93, -81, -95, -82, -96,
-83, -98, -85, -98, -87, -101, -88, -101, -89, -102, -90, -103, -91, -103, -92,
-105, -93, -105, -94, -107, -95, -107, -96, -107, -96, -108, -98, -108, -99,
-109, -99, -109, -99, -110, -100, -110, -100, -110, -101, -111, -102, -112,
-102, -112, -103, -112, -103, -113, -103, -113, -104, -113, -104, -113, -104,
-113, -105, -114, -106, -114, -105, -115, -105, -114, -106, -115, -106, -115,
-106, -116, -107, -115, -107, -116, -107, -116, -108, -116, -108, -116, -108,
-116, -107, -117, -107, -117, -108, -117, -109, -116, -109, -117, -108, -118,
-108, -117, -109, -117, -109, -117, -109, -116, -110, -118, -110, -117, -109,
-118, -110, -117, -110, -118, -110, -117, -110, -118, -110, -119, -110, -117,
-111, -118, -110, -118, -110, -118, -110, -119, -111, -118, -110, -119, -110,
-118, -111, -119, -111, -118, -111, -118, -111, -119, -110, -118, -111, -119,
-111, -118, -111, -118, -111, -119, -111, -119, -111, -119, -112, -119, -111,
-118, -112, -119, -111, -118, -112, -119, -111, -118, -111, -119, -111, -118,
-111, -119, -111, -119, -111, -119, -111, -119, -111, -119, -111, -119, -111,
-119, -111, -119, -111, -119, -112, -119, -112, -119, -112, -119, -112, -119,
-112, -120, -111, -119, -111, -120, -111, -119, -111, -118, -111, -118, -112,
-120, -112, -118, -113, -119, -112, -119, -112, -119, -111, -119, -111, -119,
-112, -119, -112, -119, -111, -120, -111, -118, -112, -120, -112, -119, -112,
-120, -111, -119, -111, -119, -112, -119, -111, -119, -111, -120, -111, -119,
-112, -118, -111, -118, -111, -118, -111, -119, -111, -118, -111, -119, -110,
-119, -110, -119, -111, -118, -111, -118, -111, -118, -110, -119, -110, -119,
-111, -119, -111, -118, -111, -118, -110, -119, -109, -118, -110, -118, -110,
-118, -109, -118, -110, -117, -110, -117, -110, -118, -109, -118, -110, -118,
-110, -117, -109, -117, -108, -117, -109, -117, -108, -116, -109, -117, -108,
-117, -108, -116, -108, -116, -108, -115, -108, -115, -107, -116, -108, -115,
-108, -115, -107, -116, -108, -115, -107, -115, -106, -115, -106, -114, -106,
-114, -105, -113, -105, -114, -105, -113, -105, -114, -104, -113, -103, -112,
-103, -112, -103, -112, -102, -112, -103, -112, -101, -112, -102, -111, -100,
-110, -100, -110, -100, -109, -99, -109, -99, -109, -98, -108, -97, -107, -96,
-107, -96, -105, -94, -105, -93, -104, -93, -103, -92, -103, -91, -102, -89,
-101, -89, -100, -88, -98, -86, -97, -85, -96, -83, -94, -82, -93, -80, -91,
-78, -90, -76, -88, -75, -86, -73, -84, -71, -82, -69, -80, -67, -76, -64, -74,
-61, -71, -58, -68, -56, -65, -52, -62, -50, -57, -47, -53, -42, -49, -39, -45,
-35, -40, -31, -35, -27, -30, -23, -24, -18, -18, -14, -12, -10, -4, -3, };