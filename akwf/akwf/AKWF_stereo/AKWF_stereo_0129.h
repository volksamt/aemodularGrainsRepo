#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0129

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, -9, 7, -7, 12, -2, 16, 2, 19, 5,
23, 9, 28, 13, 31, 16, 34, 19, 39, 22, 42, 25, 45, 28, 47, 32, 50, 33, 51, 37,
54, 38, 56, 41, 58, 44, 61, 46, 62, 49, 64, 51, 66, 54, 67, 56, 70, 57, 72, 61,
74, 63, 76, 66, 79, 68, 81, 70, 83, 73, 86, 76, 87, 78, 89, 80, 92, 81, 93, 85,
95, 86, 98, 88, 99, 89, 101, 90, 101, 91, 103, 93, 104, 93, 103, 93, 102, 93,
102, 92, 102, 91, 100, 90, 99, 90, 99, 89, 98, 88, 96, 88, 95, 87, 94, 86, 91,
84, 88, 82, 84, 79, 81, 77, 78, 75, 76, 73, 72, 72, 70, 69, 68, 68, 65, 66, 63,
64, 60, 63, 57, 61, 55, 59, 51, 56, 49, 53, 46, 51, 43, 48, 40, 44, 36, 41, 34,
38, 31, 35, 27, 32, 22, 29, 19, 25, 16, 22, 11, 18, 8, 14, 3, 10, -2, 6, -6, 2,
-10, -2, -14, -6, -19, -11, -24, -13, -27, -18, -31, -21, -36, -25, -39, -29,
-42, -32, -46, -34, -49, -36, -51, -39, -53, -41, -54, -43, -57, -45, -59, -48,
-62, -50, -65, -51, -66, -53, -67, -55, -69, -57, -71, -59, -73, -61, -74, -64,
-77, -66, -78, -67, -80, -71, -83, -73, -86, -76, -88, -78, -91, -81, -93, -84,
-96, -86, -97, -88, -100, -90, -102, -92, -104, -94, -106, -96, -109, -99, -111,
-101, -113, -102, -114, -104, -116, -105, -117, -107, -118, -109, -118, -110,
-118, -110, -119, -111, -118, -110, -118, -110, -117, -110, -116, -110, -115,
-109, -114, -110, -113, -109, -111, -108, -109, -107, -108, -107, -107, -106,
-106, -105, -105, -104, -104, -104, -103, -104, -102, -103, -101, -101, -100,
-100, -99, -99, -97, -97, -96, -96, -94, -94, -93, -93, -91, -92, -90, -90, -88,
-88, -86, -86, -84, -84, -81, -82, -79, -80, -75, -77, -72, -74, -68, -71, -65,
-68, -61, -66, -58, -62, -55, -59, -51, -56, -48, -52, -44, -49, -41, -46, -38,
-43, -34, -39, -32, -37, -29, -34, -27, -30, -24, -28, -22, -26, -20, -23, -18,
-21, -15, -18, -13, -17, -11, -14, -9, -12, -7, -9, -4, -7, -1, -5, 1, -3, 3, 0,
5, 2, 7, 5, 10, 7, 12, 10, 14, 13, 17, 15, 19, 19, 22, 23, 25, 26, 28, 29, 31,
31, 34, 34, 38, 37, 40, 40, 43, 42, 46, 44, 48, 47, 50, 50, 52, 52, 53, 53, 55,
55, 57, 56, 58, 58, 60, 60, 61, 61, 61, 62, 62, 63, 62, 64, 62, 64, 63, 66, 64,
67, 62, 67, 63, 67, 63, 68, 63, 68, 62, 69, 61, 68, 61, 68, 60, 68, 61, 68, 60,
69, 60, 69, 60, 70, 60, 70, 59, 70, 60, 70, 59, 71, 60, 71, 59, 70, 59, 70, 60,
70, 59, 70, 58, 68, 58, 67, 56, 65, 55, 63, 51, 62, 50, 60, 46, 58, 44, 55, 41,
52, 38, 50, 35, 48, 33, 44, 29, 43, 26, 40, 23, 37, 20, 34, 17, 30, 14, 27, 11,
25, 7, 22, 5, 19, 2, 17, -1, 14, -3, 10, -4, 9, -7, 7, -9, 4, -11, 2, -13, 0,
-16, -2, -17, -5, -19, -6, -22, -9, -22, -11, -24, -13, -25, -15, -28, -17, -31,
-20, -32, -22, -34, -25, -38, -27, -40, -31, -43, -33, -45, -36, -48, -39, -50,
-40, -51, -42, -52, -43, -54, -44, -55, -45, -54, -46, -54, -45, -54, -46, -53,
-46, -53, -46, -52, -44, -50, -43, -47, -41, -45, -39, -43, -37, -40, -34, -37,
-33, -34, -30, -31, -27, -28, -25, -26, -22, -22, -20, -19, -18, -16, -16, -13,
-14, -11, -11, -8, -10, -6, -7, -3, -6, 0, -4, 3, -1, 6, 2, 8, 3, 11, 6, 15, 9,
18, 10, 20, 13, 23, 16, 25, 19, 27, 21, 29, 23, 32, 27, 35, 29, 37, 32, 41, 36,
44, 40, 49, 44, 52, 48, 55, 51, 58, 55, 62, 58, 65, 61, 67, 64, 70, 67, 73, 69,
74, 71, 77, 74, 79, 75, 81, 77, 83, 77, 83, 79, 85, 79, 84, 80, 84, 79, 84, 79,
84, 78, 84, 78, 83, 77, 83, 77, 82, 77, 81, 75, 80, 75, 79, 74, 79, 75, 77, 72,
76, 73, 75, 72, 74, 72, 74, 72, 74, 72, 74, 72, 74, 73, 74, 74, 75, 73, 74, 74,
75, 76, 76, 75, 77, 77, 78, 77, 77, 77, 78, 76, 79, 76, 78, 75, 78, 75, 77, 74,
76, 72, 75, 70, 74, 69, 72, 66, 71, 65, 69, 63, 68, 62, 66, 61, 64, 60, 62, 59,
60, 57, 59, 56, 57, 56, 55, 53, 53, 52, 51, 51, 50, 50, 48, 50, 48, 49, 46, 48,
45, 47, 44, 45, 43, 45, 42, 44, 40, 43, 38, 41, 36, 40, 34, 37, 33, 35, 31, 33,
28, 31, 25, 28, 23, 25, 20, 21, 16, 19, 13, 15, 10, 12, 7, 8, 3, 4, -2, 0, -5,
-4, -8, -7, -12, -11, -15, -13, -19, -17, -21, -19, -24, -22, -28, -24, -31,
-27, -33, -29, -35, -32, -38, -33, -39, -36, -41, -37, -42, -38, -44, -40, -46,
-42, -47, -43, -49, -45, -49, -46, -52, -48, -53, -50, -54, -51, -56, -53, -56,
-56, -59, -57, -60, -59, -63, -61, -64, -63, -66, -66, -67, -68, -69, -71, -71,
-73, -73, -75, -75, -77, -76, -80, -79, -82, -80, -84, -82, -87, -84, -87, -86,
-90, -88, -91, -89, -93, -90, -94, -92, -95, -92, -96, -93, -96, -93, -96, -93,
-95, -92, -96, -91, -95, -91, -94, -89, -93, -87, -93, -86, -92, -84, -90, -83,
-90, -81, -88, -78, -87, -76, -85, -74, -83, -72, -83, -71, -82, -70, -82, -69,
-81, -67, -80, -67, -79, -66, -79, -64, -79, -62, -77, -61, -76, -59, -75, -56,
-73, -54, -71, -51, -67, -49, -65, -45, -62, -43, -59, -40, -56, -36, -53, -33,
-49, -29, -44, -25, -40, -21, -36, -18, -31, -12, -28, -8, -22, -4, -18, 1, -12,
};