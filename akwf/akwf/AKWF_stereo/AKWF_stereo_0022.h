#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 27, 9, 29, 16, 24, 22, 27, 28, 29,
33, 32, 36, 32, 38, 34, 37, 34, 40, 37, 45, 37, 48, 38, 52, 36, 58, 37, 60, 36,
60, 37, 60, 39, 60, 41, 62, 39, 62, 38, 63, 36, 62, 35, 61, 35, 58, 40, 54, 48,
50, 59, 42, 70, 35, 76, 31, 80, 33, 81, 35, 76, 35, 72, 38, 69, 43, 63, 48, 57,
51, 53, 55, 54, 60, 52, 66, 45, 71, 38, 73, 30, 74, 29, 74, 24, 75, 18, 76, 11,
78, 3, 80, -1, 84, -6, 87, -8, 90, -7, 88, -10, 86, -16, 84, -21, 82, -29, 83,
-36, 82, -42, 83, -42, 83, -37, 81, -26, 80, -14, 81, -3, 81, 3, 83, 9, 84, 13,
85, 19, 88, 24, 89, 22, 89, 18, 89, 16, 89, 11, 89, 8, 88, 4, 89, 0, 93, -2, 95,
-3, 94, 1, 92, 4, 88, 7, 88, 7, 86, 6, 86, 10, 85, 17, 85, 21, 86, 23, 83, 21,
80, 19, 76, 20, 74, 21, 73, 22, 76, 21, 78, 13, 79, 1, 80, -6, 82, -7, 85, -2,
90, -2, 92, 1, 92, 7, 92, 10, 88, 15, 84, 20, 81, 24, 79, 24, 73, 26, 71, 28,
71, 29, 75, 27, 82, 18, 87, 7, 91, 0, 94, -2, 96, -2, 99, 0, 102, 6, 104, 14,
104, 22, 101, 30, 97, 38, 92, 50, 85, 57, 79, 59, 75, 59, 72, 60, 73, 65, 76,
68, 76, 68, 75, 68, 77, 70, 78, 73, 80, 72, 82, 70, 83, 67, 82, 63, 82, 57, 80,
53, 78, 49, 76, 48, 75, 49, 72, 50, 69, 51, 69, 49, 69, 49, 69, 48, 65, 48, 63,
48, 60, 46, 55, 46, 51, 45, 48, 45, 48, 45, 51, 45, 52, 47, 49, 51, 48, 58, 45,
63, 43, 65, 45, 68, 45, 66, 48, 60, 51, 53, 54, 49, 58, 43, 63, 42, 66, 39, 69,
41, 73, 37, 78, 30, 83, 21, 84, 13, 85, 10, 84, 5, 82, 1, 80, -5, 82, -8, 83,
-10, 85, -12, 85, -15, 84, -18, 82, -24, 79, -30, 78, -35, 77, -41, 76, -47, 75,
-50, 75, -54, 73, -51, 68, -39, 66, -25, 65, -13, 62, -6, 58, -1, 57, 4, 56, 8,
55, 12, 50, 13, 49, 12, 46, 11, 44, 10, 42, 8, 38, 8, 37, 11, 33, 14, 33, 18,
30, 24, 28, 32, 26, 41, 26, 46, 27, 49, 28, 52, 30, 54, 33, 53, 33, 49, 30, 42,
23, 37, 18, 37, 16, 35, 17, 32, 22, 27, 27, 19, 28, 12, 28, 8, 27, 7, 26, 7, 24,
6, 21, 7, 19, 8, 16, 6, 13, 1, 9, 0, 6, -1, 3, -4, 0, -6, -3, -6, -4, -7, -3,
-10, 2, -18, 6, -23, 8, -25, 8, -23, 7, -22, 4, -19, 1, -11, -1, -2, -4, 8, -10,
15, -15, 24, -19, 30, -23, 31, -26, 31, -28, 32, -29, 34, -30, 36, -26, 35, -23,
32, -19, 27, -13, 25, -9, 23, -5, 18, -1, 15, 0, 16, 1, 15, 0, 13, 0, 6, -1, 0,
-1, -6, 1, -13, 1, -21, -2, -30, -5, -37, -10, -38, -16, -37, -20, -33, -24,
-27, -26, -23, -27, -21, -30, -20, -33, -21, -36, -24, -37, -26, -40, -24, -43,
-18, -48, -11, -54, -5, -56, 0, -57, 5, -57, 5, -54, 2, -51, 3, -50, 5, -51, 3,
-54, 3, -56, 3, -58, 6, -59, 4, -60, 0, -62, -4, -63, -7, -65, -9, -66, -14,
-68, -18, -71, -25, -73, -31, -75, -34, -74, -38, -73, -41, -72, -43, -76, -47,
-78, -49, -78, -52, -77, -54, -78, -56, -76, -57, -75, -57, -75, -55, -76, -48,
-75, -38, -72, -30, -68, -21, -65, -13, -62, -9, -62, -5, -59, 0, -59, -2, -58,
-4, -59, -5, -59, -3, -62, 2, -67, 9, -72, 15, -76, 21, -78, 28, -82, 33, -84,
38, -87, 42, -91, 40, -95, 42, -100, 42, -102, 44, -106, 46, -110, 46, -112, 45,
-116, 44, -119, 42, -119, 41, -117, 39, -114, 36, -110, 27, -109, 16, -110, 6,
-110, 1, -111, -3, -111, -6, -111, -11, -107, -13, -104, -17, -103, -16, -102,
-16, -104, -15, -105, -16, -103, -13, -101, -9, -96, -6, -91, -5, -88, -11, -84,
-16, -82, -21, -81, -20, -77, -20, -74, -16, -71, -15, -67, -16, -67, -20, -70,
-23, -72, -23, -74, -20, -75, -18, -78, -20, -78, -19, -79, -15, -80, -12, -77,
-12, -77, -15, -77, -18, -76, -17, -74, -15, -73, -19, -74, -20, -72, -18, -72,
-17, -72, -21, -75, -25, -78, -35, -79, -44, -78, -52, -79, -56, -82, -57, -84,
-59, -85, -56, -86, -51, -87, -47, -86, -41, -87, -38, -88, -37, -90, -36, -94,
-37, -96, -38, -96, -39, -97, -39, -95, -34, -95, -26, -91, -19, -86, -16, -81,
-15, -76, -17, -74, -22, -70, -24, -66, -22, -63, -24, -59, -25, -57, -28, -54,
-27, -50, -32, -46, -38, -43, -46, -40, -55, -40, -62, -39, -74, -37, -84, -35,
-94, -35, -100, -32, -104, -28, -106, -26, -106, -25, -107, -24, -108, -24,
-109, -24, -109, -22, -112, -21, -115, -20, -118, -19, -118, -22, -114, -26,
-101, -26, -86, -23, -72, -18, -64, -15, -62, -13, -59, -12, -55, -11, -49, -10,
-49, -9, -51, -10, -54, -14, -54, -17, -52, -20, -46, -21, -43, -22, -43, -22,
-43, -24, -41, -26, -37, -29, -35, -31, -34, -32, -31, -34, -23, -36, -15, -39,
-11, -43, -9, -46, -8, -52, -8, -56, -4, -57, -5, -57, -4, -55, -8, -52, -16,
-52, -27, -53, -36, -53, -39, -52, -38, -47, -38, -40, -36, -32, -32, -27, -27,
-26, -22, -29, -17, -31, -15, -34, -18, -38, -19, -43, -18, -46, -18, -47, -20,
-44, -26, -41, -33, -38, -32, -35, -28, -32, -19, -31, -7, -31, 3, -29, 12, -29,
15, -28, 18, -28, 22, -29, 28, -26, 28, -22, 28, -20, 26, -16, 32, -14, 33, -10,
37, -8, 34, -5, 36, -1, 28, };