#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0095

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -8, 2, -8, 5, -7, 6, -6, 8, -6, 10,
-5, 11, -4, 13, -4, 14, -2, 15, -2, 17, -1, 18, 0, 20, 1, 20, 2, 20, 4, 21, 4,
22, 5, 23, 7, 24, 8, 23, 9, 23, 9, 23, 11, 23, 11, 22, 13, 23, 15, 23, 15, 21,
16, 22, 18, 21, 19, 20, 21, 20, 20, 20, 22, 18, 23, 18, 24, 17, 25, 16, 27, 16,
27, 17, 28, 16, 30, 16, 30, 16, 31, 16, 33, 17, 34, 18, 35, 18, 36, 18, 37, 19,
39, 20, 40, 21, 41, 22, 43, 24, 43, 26, 45, 29, 46, 30, 48, 32, 49, 36, 51, 37,
53, 40, 54, 43, 55, 46, 58, 49, 59, 51, 60, 54, 61, 57, 65, 61, 66, 64, 67, 67,
69, 69, 72, 73, 74, 76, 75, 79, 78, 81, 80, 84, 82, 86, 84, 88, 86, 91, 89, 92,
91, 95, 92, 96, 94, 98, 96, 99, 98, 100, 100, 101, 101, 102, 103, 103, 105, 103,
107, 103, 108, 103, 110, 103, 111, 103, 113, 103, 114, 102, 114, 101, 116, 101,
116, 100, 117, 98, 117, 98, 119, 96, 119, 96, 119, 94, 119, 93, 119, 91, 120,
89, 119, 89, 119, 88, 118, 86, 118, 85, 117, 84, 116, 83, 116, 82, 114, 81, 114,
81, 113, 80, 111, 80, 111, 79, 110, 80, 108, 80, 106, 79, 105, 80, 104, 80, 102,
80, 102, 81, 99, 81, 98, 82, 96, 81, 95, 83, 94, 84, 92, 85, 91, 84, 89, 86, 88,
86, 86, 87, 85, 88, 84, 89, 83, 89, 81, 89, 79, 90, 78, 91, 78, 92, 75, 91, 75,
91, 74, 90, 73, 90, 71, 90, 71, 90, 69, 89, 69, 88, 67, 87, 66, 86, 65, 84, 64,
83, 63, 81, 62, 79, 60, 77, 60, 75, 58, 73, 57, 71, 57, 69, 55, 66, 54, 63, 53,
61, 51, 58, 51, 56, 49, 53, 47, 51, 47, 48, 45, 45, 43, 42, 42, 40, 40, 38, 40,
35, 38, 34, 36, 31, 35, 29, 34, 26, 33, 25, 30, 24, 29, 21, 28, 21, 26, 19, 25,
18, 23, 18, 22, 16, 21, 16, 18, 15, 17, 13, 15, 14, 14, 14, 12, 13, 11, 13, 9,
13, 8, 13, 8, 12, 5, 13, 4, 13, 4, 14, 2, 13, 1, 13, 1, 14, -1, 14, -3, 13, -3,
14, -4, 13, -6, 13, -7, 13, -7, 12, -7, 11, -9, 11, -9, 11, -9, 10, -11, 10,
-11, 8, -13, 7, -14, 6, -14, 5, -15, 4, -16, 1, -15, 0, -17, -2, -17, -3, -19,
-5, -19, -6, -20, -9, -20, -10, -21, -12, -23, -13, -22, -15, -24, -18, -25,
-19, -25, -21, -26, -23, -27, -24, -28, -26, -29, -27, -31, -28, -31, -29, -32,
-30, -33, -31, -34, -32, -35, -33, -37, -34, -37, -35, -38, -35, -39, -36, -40,
-35, -41, -35, -42, -36, -42, -35, -43, -35, -45, -35, -45, -35, -47, -34, -47,
-34, -48, -34, -48, -33, -49, -32, -49, -32, -50, -31, -51, -31, -51, -30, -53,
-30, -53, -30, -52, -30, -53, -30, -53, -29, -53, -30, -54, -29, -54, -30, -55,
-30, -55, -31, -56, -31, -56, -32, -56, -33, -55, -33, -56, -35, -55, -37, -57,
-38, -57, -39, -56, -41, -57, -42, -58, -44, -57, -46, -58, -48, -57, -50, -58,
-52, -58, -55, -58, -56, -58, -58, -59, -60, -59, -62, -59, -64, -59, -66, -58,
-69, -59, -69, -60, -71, -60, -73, -60, -75, -60, -75, -60, -76, -61, -77, -60,
-78, -60, -78, -60, -78, -61, -79, -61, -80, -60, -79, -61, -79, -60, -79, -61,
-79, -60, -77, -61, -76, -59, -75, -60, -73, -59, -73, -59, -72, -57, -69, -57,
-68, -57, -66, -56, -64, -55, -62, -54, -60, -53, -58, -53, -56, -52, -55, -50,
-53, -50, -50, -49, -48, -47, -46, -46, -45, -45, -44, -44, -42, -43, -41, -41,
-39, -40, -39, -38, -37, -38, -36, -36, -36, -34, -34, -34, -35, -32, -34, -31,
-34, -30, -34, -29, -35, -28, -36, -27, -36, -26, -37, -26, -38, -25, -39, -24,
-39, -23, -41, -23, -41, -22, -42, -22, -44, -22, -46, -22, -47, -21, -48, -21,
-50, -22, -51, -23, -52, -23, -53, -22, -54, -23, -55, -23, -56, -24, -56, -24,
-57, -25, -59, -25, -59, -27, -59, -27, -59, -28, -59, -28, -59, -29, -59, -30,
-58, -31, -57, -32, -56, -33, -56, -33, -55, -35, -54, -35, -53, -37, -52, -38,
-50, -38, -48, -38, -46, -40, -45, -41, -44, -42, -42, -42, -40, -43, -39, -42,
-38, -44, -36, -43, -34, -44, -32, -45, -31, -44, -28, -44, -28, -44, -28, -45,
-26, -44, -25, -44, -24, -45, -23, -44, -22, -44, -22, -45, -22, -45, -22, -44,
-22, -43, -22, -43, -22, -43, -23, -43, -22, -42, -24, -42, -24, -42, -25, -41,
-26, -41, -26, -41, -29, -41, -29, -40, -31, -40, -32, -39, -32, -40, -34, -40,
-35, -39, -37, -40, -38, -39, -40, -39, -40, -39, -41, -40, -42, -39, -43, -39,
-43, -38, -44, -38, -44, -38, -46, -39, -44, -38, -46, -39, -46, -38, -45, -39,
-45, -39, -45, -38, -45, -38, -44, -39, -43, -38, -43, -38, -41, -38, -40, -38,
-40, -37, -38, -38, -36, -37, -35, -38, -35, -37, -33, -37, -31, -38, -30, -37,
-29, -37, -28, -35, -26, -36, -25, -35, -23, -33, -21, -34, -21, -33, -20, -33,
-20, -31, -18, -31, -17, -32, -17, -30, -16, -29, -16, -29, -15, -29, -15, -27,
-15, -27, -15, -26, -15, -25, -15, -25, -15, -25, -16, -24, -16, -24, -17, -24,
-17, -23, -17, -21, -18, -21, -19, -21, -19, -20, -20, -20, -21, -19, -21, -19,
-22, -19, -22, -18, -23, -17, -23, -17, -23, -17, -23, -17, -24, -17, -24, -16,
-23, -16, -23, -16, -23, -16, -23, -15, -22, -15, -21, -15, -20, -14, -19, -14,
-18, -14, -16, -13, -16, -13, -15, -13, -13, -13, -12, -12, -10, -12, -7, -11,
-7, -12, -4, -10, -3, -11, -1, -7, };