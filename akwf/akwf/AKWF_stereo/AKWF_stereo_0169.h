#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0169

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 33, 2, 42, 3, 41, 4, 45, 4, 46, 6,
50, 7, 50, 8, 54, 10, 56, 11, 58, 11, 59, 12, 63, 13, 64, 14, 66, 15, 67, 16,
71, 17, 72, 17, 74, 18, 74, 18, 76, 20, 78, 20, 79, 21, 80, 22, 80, 23, 81, 23,
82, 24, 82, 25, 83, 25, 83, 26, 85, 27, 86, 28, 86, 29, 87, 30, 87, 31, 88, 32,
90, 33, 91, 34, 92, 34, 92, 36, 93, 37, 93, 38, 94, 39, 95, 41, 96, 40, 96, 41,
98, 43, 98, 43, 99, 44, 100, 45, 101, 46, 101, 47, 103, 48, 102, 49, 104, 50,
105, 51, 105, 52, 107, 53, 107, 53, 108, 54, 109, 55, 110, 55, 111, 57, 111, 58,
113, 57, 113, 59, 114, 59, 115, 60, 115, 61, 115, 62, 116, 63, 116, 62, 117, 64,
117, 63, 117, 65, 117, 65, 116, 67, 116, 67, 117, 67, 116, 69, 115, 69, 114, 71,
115, 70, 114, 72, 114, 71, 114, 72, 113, 73, 113, 74, 112, 74, 111, 75, 112, 75,
111, 77, 110, 76, 110, 77, 109, 79, 109, 79, 108, 79, 108, 81, 108, 81, 107, 81,
107, 82, 107, 83, 106, 84, 106, 84, 105, 85, 106, 85, 104, 86, 104, 87, 104, 87,
103, 88, 103, 89, 103, 90, 102, 90, 102, 90, 101, 92, 100, 92, 99, 92, 101, 94,
100, 94, 100, 95, 100, 95, 100, 97, 100, 97, 101, 98, 101, 99, 102, 100, 103,
101, 103, 101, 104, 102, 104, 102, 105, 103, 106, 104, 106, 105, 106, 106, 107,
107, 108, 107, 108, 109, 109, 109, 110, 109, 110, 110, 111, 110, 111, 111, 110,
112, 111, 112, 111, 112, 110, 112, 109, 112, 109, 112, 108, 112, 108, 111, 106,
111, 106, 111, 104, 110, 104, 110, 102, 109, 102, 109, 100, 108, 99, 107, 98,
106, 98, 105, 97, 104, 96, 103, 94, 102, 93, 102, 92, 101, 92, 99, 90, 99, 89,
98, 87, 97, 87, 96, 86, 96, 84, 94, 84, 94, 82, 92, 82, 91, 80, 90, 80, 90, 79,
88, 78, 87, 77, 86, 75, 86, 75, 84, 74, 83, 73, 83, 72, 81, 72, 79, 70, 79, 69,
78, 68, 77, 68, 76, 67, 75, 65, 74, 65, 72, 64, 71, 63, 71, 62, 69, 60, 67, 58,
67, 57, 66, 55, 64, 54, 64, 52, 63, 51, 62, 48, 60, 47, 59, 45, 59, 44, 57, 43,
56, 41, 54, 39, 53, 38, 51, 35, 50, 34, 50, 32, 49, 31, 47, 30, 46, 29, 46, 26,
44, 25, 43, 24, 41, 22, 41, 20, 39, 18, 38, 18, 36, 16, 35, 15, 35, 12, 33, 10,
32, 9, 31, 7, 29, 6, 28, 4, 27, 2, 26, 1, 24, -1, 23, -2, 21, -3, 20, -5, 19,
-6, 18, -8, 17, -10, 15, -11, 13, -12, 13, -14, 11, -16, 10, -17, 10, -18, 7,
-20, 7, -22, 6, -23, 5, -25, 4, -27, 3, -29, 2, -31, 1, -33, -1, -35, -1, -38,
-2, -40, -4, -43, -4, -44, -6, -47, -7, -49, -8, -51, -9, -54, -10, -56, -10,
-59, -11, -61, -13, -63, -15, -64, -15, -67, -15, -68, -16, -71, -18, -72, -19,
-74, -19, -76, -20, -77, -20, -78, -21, -80, -21, -81, -22, -81, -23, -81, -24,
-84, -24, -83, -25, -84, -27, -85, -27, -86, -27, -87, -29, -88, -30, -89, -31,
-89, -32, -90, -32, -91, -33, -92, -35, -92, -35, -94, -36, -94, -37, -94, -39,
-96, -40, -96, -40, -98, -42, -98, -42, -100, -44, -100, -44, -100, -45, -101,
-46, -102, -47, -103, -48, -104, -49, -104, -50, -105, -51, -106, -52, -107,
-53, -107, -54, -109, -55, -109, -54, -110, -56, -111, -56, -111, -58, -112,
-59, -114, -59, -115, -59, -115, -60, -115, -61, -117, -62, -116, -63, -118,
-63, -117, -64, -119, -64, -119, -65, -119, -66, -119, -67, -119, -68, -119,
-67, -118, -69, -118, -70, -118, -69, -117, -71, -117, -71, -116, -72, -116,
-73, -116, -73, -115, -73, -115, -74, -115, -76, -115, -76, -113, -76, -114,
-77, -112, -78, -112, -79, -112, -79, -112, -80, -110, -80, -111, -80, -110,
-81, -109, -83, -109, -83, -109, -83, -108, -84, -109, -84, -108, -85, -108,
-86, -107, -86, -107, -87, -106, -88, -105, -89, -105, -90, -105, -91, -104,
-91, -104, -92, -104, -92, -103, -92, -102, -94, -102, -94, -102, -95, -102,
-95, -102, -95, -102, -97, -102, -98, -103, -98, -103, -99, -104, -100, -104,
-101, -104, -102, -105, -102, -105, -103, -107, -104, -106, -105, -108, -105,
-108, -106, -109, -107, -109, -108, -110, -109, -110, -109, -111, -110, -112,
-111, -112, -112, -112, -112, -113, -113, -113, -113, -113, -113, -112, -114,
-112, -113, -111, -113, -110, -113, -109, -112, -109, -113, -108, -113, -107,
-112, -107, -112, -105, -112, -104, -111, -104, -110, -102, -109, -101, -108,
-101, -108, -100, -106, -98, -106, -96, -105, -96, -104, -95, -103, -94, -103,
-93, -102, -92, -100, -91, -100, -90, -98, -89, -97, -87, -97, -87, -96, -85,
-95, -84, -93, -83, -92, -82, -92, -81, -91, -80, -90, -80, -88, -79, -88, -79,
-87, -77, -85, -76, -85, -75, -84, -74, -82, -73, -82, -73, -80, -71, -80, -70,
-78, -69, -77, -69, -76, -67, -74, -67, -73, -65, -72, -64, -71, -63, -70, -61,
-69, -59, -68, -59, -67, -56, -66, -56, -65, -54, -64, -52, -63, -51, -62, -49,
-61, -47, -58, -45, -59, -44, -57, -42, -55, -41, -54, -40, -54, -38, -52, -36,
-51, -35, -50, -33, -49, -31, -47, -30, -47, -28, -46, -27, -44, -25, -43, -24,
-42, -23, -41, -21, -40, -19, -39, -17, -37, -16, -36, -14, -35, -12, -33, -11,
-32, -9, -31, -8, -30, -6, -28, -5, -27, -3, -25, -1, -24, 0, -23, 1, -23, 4,
-20, 4, -20, 6, -18, 7, -17, 9, -16, 10, -14, 12, -13, 13, -12, 15, -11, 15,
-10, 19, -8, 19, -8, 22, -7, 22, -4, 26, -4, 26, -3, 30, -2, 30, -1, 35, 0, 31,
};