#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0048

const PROGMEM int8_t DATA[DATA_LENGTH] = {15, 32, 115, 99, 119, 71, 113, 70,
109, 68, 106, 67, 110, 67, 113, 68, 116, 70, 110, 68, 106, 71, 100, 69, 103, 72,
102, 69, 104, 72, 99, 70, 98, 72, 93, 70, 92, 71, 92, 70, 94, 72, 94, 71, 93,
72, 91, 72, 90, 70, 92, 70, 93, 71, 96, 71, 96, 71, 95, 71, 94, 71, 96, 71, 97,
71, 99, 71, 100, 71, 101, 71, 100, 70, 100, 71, 100, 71, 101, 71, 101, 70, 102,
72, 101, 70, 101, 70, 100, 71, 100, 70, 100, 71, 100, 70, 100, 72, 99, 70, 99,
71, 98, 71, 99, 71, 99, 71, 98, 71, 98, 70, 97, 70, 97, 71, 97, 72, 97, 71, 98,
71, 98, 71, 97, 71, 97, 70, 98, 70, 97, 71, 98, 71, 98, 72, 98, 71, 98, 70, 98,
70, 98, 71, 99, 72, 98, 71, 99, 71, 99, 71, 99, 71, 99, 70, 99, 71, 99, 71, 99,
71, 99, 71, 99, 71, 98, 71, 99, 71, 99, 71, 99, 71, 99, 71, 98, 71, 99, 71, 98,
71, 99, 70, 99, 70, 98, 70, 99, 71, 98, 71, 97, 71, 98, 70, 98, 70, 98, 71, 99,
71, 98, 70, 99, 71, 98, 71, 98, 71, 98, 71, 98, 71, 98, 70, 98, 71, 98, 71, 99,
71, 99, 71, 99, 71, 98, 71, 99, 71, 98, 71, 99, 70, 99, 71, 99, 71, 99, 71, 99,
71, 98, 71, 99, 71, 98, 71, 98, 71, 98, 71, 99, 71, 98, 71, 99, 71, 99, 70, 99,
71, 97, 71, 99, 71, 98, 71, 99, 71, 98, 71, 98, 71, 98, 71, 99, 71, 98, 71, 99,
71, 98, 70, 98, 71, 98, 72, 99, 71, 99, 70, 99, 72, 99, 71, 98, 71, 99, 71, 98,
71, 98, 71, 99, 70, 98, 71, 99, 71, 98, 71, 98, 72, 98, 70, 98, 71, 98, 72, 99,
71, 99, 72, 99, 71, 98, 71, 98, 71, 98, 72, 98, 71, 98, 71, 99, 71, 98, 71, 97,
71, 99, 71, 98, 71, 98, 71, 99, 71, 98, 71, 98, 70, 98, 71, 99, 71, 99, 71, 98,
71, 99, 71, 99, 72, 98, 71, 99, 72, 98, 71, 98, 71, 98, 71, 99, 72, 99, 71, 98,
71, 98, 71, 98, 71, 99, 72, 99, 72, 98, 71, 98, 71, 98, 70, 98, 71, 99, 70, 98,
71, 99, 71, 98, 71, 98, 71, 98, 71, 99, 70, 99, 71, 99, 71, 98, 71, 98, 71, 98,
70, 98, 71, 99, 71, 98, 72, 98, 71, 99, 71, 98, 71, 98, 72, 99, 72, 99, 70, 98,
71, 98, 70, 99, 71, 98, 71, 99, 71, 98, 71, 98, 70, 99, 71, 98, 71, 98, 71, 98,
71, 98, 71, 99, 71, 98, 71, 98, 71, 98, 71, 98, 71, 98, 71, 98, 71, 99, 71, 98,
70, 99, 71, 99, 70, 98, 71, 98, 71, 98, 71, 98, 71, 98, 70, 98, 71, 98, 71, 98,
71, 98, 71, 98, 72, 99, 70, 99, 71, 98, 70, 99, 71, 98, 72, 98, 71, 98, 71, 98,
71, 98, 71, 99, 71, 98, 71, 97, 71, 99, 72, 99, 70, 98, 71, 98, 71, 98, 70, 98,
71, 99, 71, 98, 71, 98, 70, 98, 70, 99, 71, 99, 71, 98, 70, 98, 72, 99, 71, 98,
71, 98, 71, 98, 71, 98, 70, 98, 71, 99, 71, 98, 71, 99, 71, 98, 71, 98, 71, 98,
71, 98, 71, 99, 72, 98, 71, 98, 71, 98, 71, 98, 70, 98, 71, 98, 71, 99, 72, 98,
71, 99, 71, 99, 71, 99, 70, 99, 71, 98, 72, 98, 70, 98, 71, 98, 71, 98, 71, 98,
71, 98, 71, 98, 70, 98, 72, 98, 71, 98, 70, 99, 71, 99, 71, 98, 71, 99, 71, 98,
71, 98, 71, 98, 71, 98, 71, 99, 71, 98, 71, 98, 71, 99, 71, 98, 71, 98, 71, 98,
71, 99, 71, 99, 72, 99, 71, 97, 71, 98, 71, 99, 71, 99, 70, 99, 71, 99, 71, 98,
71, 98, 71, 98, 71, 98, 71, 98, 70, 99, 71, 99, 71, 98, 71, 98, 71, 98, 72, 98,
71, 99, 71, 98, 71, 98, 71, 99, 71, 99, 70, 98, 71, 99, 70, 98, 70, 98, 70, 98,
71, 98, 71, 98, 72, 99, 71, 98, 71, 99, 71, 98, 71, 98, 71, 98, 70, 98, 71, 98,
70, 98, 71, 98, 70, 99, 70, 99, 72, 99, 71, 98, 71, 98, 71, 99, 71, 99, 71, 98,
70, 98, 71, 98, 71, 99, 70, 99, 71, 99, 71, 98, 71, 98, 70, 98, 71, 98, 71, 98,
71, 98, 71, 99, 71, 98, 71, 98, 71, 98, 71, 98, 70, 98, 70, 99, 71, 99, 71, 98,
71, 98, 71, 99, 70, 98, 71, 99, 71, 98, 71, 98, 70, 99, 71, 98, 72, 98, 71, 98,
70, 98, 71, 98, 72, 99, 71, 98, 70, 98, 71, 98, 71, 98, 71, 99, 70, 98, 70, 98,
71, 99, 71, 99, 71, 99, 71, 98, 71, 99, 71, 98, 72, 98, 70, 98, 71, 98, 71, 98,
71, 98, 71, 98, 71, 99, 71, 98, 71, 98, 72, 99, 71, 99, 71, 99, 71, 99, 71, 99,
71, 97, 70, 98, 71, 98, 71, 98, 71, 98, 71, 99, 71, 98, 71, 98, 71, 98, 71, 99,
71, 98, 71, 99, 71, 99, 71, 98, 71, 99, 70, 98, 72, 98, 72, 98, 71, 99, 71, 98,
70, 98, 72, 98, 70, 99, 72, 98, 71, 99, 72, 97, 70, 99, 71, 97, 69, 99, 72, 97,
70, 99, 72, 97, 69, 99, 71, 98, 70, 98, 71, 99, 70, 98, 70, 99, 71, 97, 70, 100,
73, 95, 67, 103, 76, 90, 63, 108, 82, -36, -58, -128, -107, -106, -59, -115,
-77, -98, -60, -108, -71, -108, -63, -118, -71, -114, -66, -112, -71, -103, -69,
-103, -71, -102, -69, -106, -71, -105, -70, -103, -72, -97, -70, -95, -71, -93,
-70, -96, -71, -96, -71, -98, -72, -92, -70, -93, -72, -86, -69, -97, -74, -80,
-60, };