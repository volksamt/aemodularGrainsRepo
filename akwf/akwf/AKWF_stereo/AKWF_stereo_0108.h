#define DATA_LENGTH 512
#define DATA AKWF_stereo_0108

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 14, 17, 20, 25, 28, 32, 35,
38, 42, 46, 48, 51, 54, 57, 60, 64, 65, 68, 70, 72, 73, 75, 77, 78, 81, 83, 85,
86, 88, 89, 92, 93, 94, 96, 96, 99, 100, 101, 102, 103, 103, 105, 105, 106, 107,
108, 108, 109, 110, 112, 112, 114, 114, 114, 116, 116, 116, 117, 117, 118, 117,
118, 118, 117, 117, 118, 118, 117, 117, 117, 117, 117, 118, 119, 119, 119, 119,
118, 119, 120, 118, 119, 119, 118, 117, 117, 117, 117, 117, 116, 117, 115, 115,
114, 114, 113, 114, 112, 113, 112, 111, 112, 111, 111, 110, 110, 110, 110, 109,
109, 109, 109, 109, 109, 108, 107, 108, 107, 106, 106, 105, 106, 105, 105, 105,
103, 103, 102, 102, 101, 100, 101, 98, 98, 97, 96, 95, 95, 93, 93, 91, 90, 89,
88, 88, 86, 85, 85, 84, 83, 83, 82, 81, 80, 78, 78, 77, 75, 74, 73, 72, 71, 70,
69, 69, 67, 67, 66, 65, 65, 64, 64, 64, 63, 64, 64, 64, 64, 65, 65, 64, 66, 66,
66, 67, 67, 66, 66, 66, 65, 66, 65, 66, 66, 66, 66, 66, 66, 66, 65, 65, 65, 64,
64, 63, 63, 62, 61, 60, 59, 58, 57, 56, 55, 54, 52, 51, 49, 48, 46, 44, 41, 39,
37, 35, 33, 31, 29, 27, 23, 21, 19, 17, 16, 15, 13, 13, 11, 10, 10, 8, 7, 7, 6,
4, 3, 1, 0, -1, -3, -4, -4, -6, -7, -8, -9, -9, -9, -11, -12, -13, -13, -14,
-16, -17, -18, -19, -19, -20, -21, -21, -23, -22, -23, -25, -25, -27, -28, -30,
-31, -32, -33, -35, -36, -37, -39, -41, -42, -43, -45, -47, -48, -50, -52, -54,
-55, -57, -58, -59, -62, -61, -63, -64, -63, -65, -65, -65, -65, -65, -66, -65,
-65, -64, -64, -64, -63, -63, -62, -62, -62, -62, -61, -61, -62, -61, -60, -60,
-60, -60, -60, -61, -60, -60, -61, -61, -61, -63, -62, -62, -62, -63, -63, -64,
-65, -64, -64, -65, -65, -66, -66, -67, -66, -66, -66, -66, -66, -66, -67, -67,
-67, -68, -68, -68, -69, -69, -71, -72, -73, -74, -74, -76, -78, -79, -79, -80,
-81, -82, -83, -83, -83, -83, -84, -84, -84, -84, -85, -85, -86, -86, -87, -88,
-89, -90, -91, -90, -91, -93, -93, -94, -95, -94, -96, -96, -96, -96, -98, -98,
-99, -99, -100, -101, -102, -103, -103, -104, -104, -104, -104, -104, -105,
-106, -105, -105, -105, -105, -105, -105, -105, -105, -106, -105, -106, -106,
-107, -108, -107, -107, -108, -108, -107, -107, -107, -106, -106, -106, -106,
-105, -104, -104, -104, -103, -103, -102, -101, -100, -99, -99, -96, -97, -96,
-94, -93, -91, -90, -89, -87, -86, -84, -83, -82, -81, -80, -78, -76, -75, -74,
-72, -70, -69, -67, -66, -63, -63, -59, -58, -57, -54, -53, -52, -50, -48, -47,
-44, -42, -40, -37, -35, -32, -30, -27, -26, -22, -18, -16, -13, -10, -7, -4,
-1, };