#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0079

const PROGMEM int8_t DATA[DATA_LENGTH] = {45, 29, 54, 34, 43, 29, 43, 29, 37,
28, 38, 30, 34, 30, 36, 32, 33, 33, 32, 35, 31, 35, 32, 35, 30, 34, 30, 33, 28,
32, 28, 30, 27, 29, 27, 29, 26, 28, 27, 28, 26, 28, 25, 29, 25, 29, 25, 30, 25,
29, 25, 29, 24, 27, 21, 27, 13, 26, 10, 26, 24, 22, 26, 21, 23, 21, 23, 20, 21,
19, 21, 18, 20, 18, 20, 19, 19, 18, 19, 18, 17, 17, 18, 16, 18, 15, 18, 14, 17,
14, 17, 14, 17, 13, 16, 13, 17, 13, 18, 13, 19, 14, 17, 12, 13, 9, 12, 9, 13, 8,
13, 9, 13, 9, 12, 8, 12, 8, 12, 7, 13, 8, 11, 7, 11, 7, 11, 6, 12, 6, 11, 6, 11,
5, 9, 4, 8, 5, 7, 3, 8, 3, 7, 3, 6, 3, 6, 2, 6, 2, 6, 2, 5, 1, 5, 2, 4, 0, 4, 0,
4, 1, 4, 1, 3, 0, 4, 1, 2, -1, 4, 0, -1, -1, 8, 2, -3, -5, 30, 16, 66, 38, 50,
30, 50, 31, 44, 28, 43, 29, 39, 30, 38, 32, 36, 33, 35, 34, 33, 34, 29, 31, 30,
32, 33, 35, 32, 34, 30, 31, 29, 30, 27, 27, 27, 28, 24, 27, 25, 27, 23, 27, 23,
28, 22, 27, 23, 27, 21, 27, 20, 27, 19, 25, 20, 24, 19, 23, 19, 23, 18, 22, 18,
21, 17, 20, 18, 19, 16, 19, 15, 19, 15, 19, 14, 19, 13, 19, 13, 18, 12, 17, 11,
16, 11, 16, 11, 15, 10, 14, 10, 14, 10, 14, 11, 12, 10, 12, 9, 12, 11, 11, 10,
11, 10, 11, 11, 10, 10, 10, 10, 9, 12, 8, 12, 8, 11, 6, 12, 6, 12, 6, 13, 6, 14,
4, 13, 4, 14, 4, 15, 4, 15, 3, 15, 3, 15, 4, 14, 2, 14, 3, 14, 2, 14, 1, 13, 2,
12, 1, 12, 1, 11, 0, 10, 1, 9, 0, 8, 0, 7, 1, 6, 1, 6, 0, 4, 1, 5, 0, 4, 0, 6,
-1, 8, -2, 9, -1, 6, 0, 0, 0, 1, 0, 0, -1, 1, 0, 0, -1, 0, 0, -1, -1, -1, 0, 0,
0, 0, -1, -1, 0, -1, 0, -2, 0, -1, -1, -3, -1, -2, 0, -3, 0, -2, -1, -4, -1, 1,
-1, 12, -2, 7, -2, 6, -2, 3, -1, 1, -2, 0, -1, -2, -2, -2, -1, -4, -1, -3, -1,
-6, -1, -5, 0, -6, 0, -6, 0, -6, 0, -6, -1, -6, 0, -6, -1, -6, 0, -6, -1, -6, 0,
-6, -1, -6, 0, -5, -1, -6, 0, -5, 0, -5, 0, -8, 0, -10, 0, -8, 0, -1, -1, -3,
-1, -3, -1, -3, -1, -2, -1, -3, -1, -7, -3, -13, -7, -19, -10, -26, -15, -32,
-19, -38, -24, -46, -29, -53, -35, -60, -40, -67, -47, -74, -53, -80, -60, -87,
-65, -92, -71, -98, -78, -102, -82, -107, -88, -111, -92, -113, -96, -115, -99,
-118, -102, -118, -105, -119, -107, -119, -109, -118, -110, -115, -109, -109,
-107, -100, -103, -91, -99, -81, -93, -73, -86, -62, -80, -53, -74, -43, -66,
-35, -59, -25, -50, -15, -40, -11, -36, -4, -29, -2, -24, 4, -19, 5, -16, 7,
-11, 6, -9, 7, -5, 5, -5, 3, -4, -1, -3, -2, -3, -4, -1, -5, -1, -5, 0, -8, -1,
23, 10, 41, 21, 56, 35, 7, 6, -24, -9, -13, -1, -20, -2, -16, 3, -20, 2, -17, 4,
-20, 2, -19, 1, -21, 0, -20, -1, -21, -2, -20, -3, -21, -3, -20, -3, -19, -3,
-20, -1, -19, 0, -19, 1, -18, 1, -18, 1, -16, 1, -18, 0, -15, 0, -16, -1, -14,
-1, -15, -3, -13, -2, -13, -1, -11, -1, -10, -1, -9, 0, -9, -1, -8, 1, -8, 0,
-7, 0, -6, 0, -4, 0, -6, 0, -4, -1, -4, -1, -2, -1, -1, -1, -1, -1, 1, 1, -1,
-1, 3, 1, -5, -4, -27, -17, -56, -35, -8, -8, 19, 7, 8, 0, 14, 1, 9, -3, 11, -2,
8, -4, 10, -1, 8, -3, 10, -1, 10, 0, 11, 2, 10, 2, 11, 2, 11, 1, 11, 1, 10, 1,
9, 0, 11, 0, 13, 2, 12, 1, 10, 0, 9, 0, 8, -1, 6, 0, 5, -1, 6, 0, 5, 0, 4, 0, 3,
0, 3, 0, 2, 0, 2, -1, 2, -1, 3, -1, 3, -1, 4, 0, 1, 0, 0, 0, 0, 1, -1, 0, -1, 1,
-2, 1, -3, 0, -2, -1, -3, 0, -3, 0, -3, -1, -4, -1, -4, 0, -5, -1, -5, 0, -5, 0,
-5, 0, -5, -1, -5, -1, -7, 0, -2, 0, -1, -1, -3, -1, -3, 0, -5, -1, -4, -1, -4,
-1, -4, -1, -5, -1, -5, 0, -5, -1, -5, -1, -5, 0, -5, 0, -5, 0, -4, 0, -5, 0,
-5, 0, -5, -1, -5, 0, -3, 0, -4, 0, -4, 0, -3, -1, -3, 0, -4, 0, -3, 0, -2, 0,
-3, 0, -4, -1, -2, -1, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -2, 0, -4,
0, -5, 0, -5, 0, -6, 1, -6, 1, -7, 1, -8, 1, -8, 1, -8, 1, -8, 2, -7, 1, -7, 0,
-8, 1, -6, 1, -7, 1, -5, 1, -4, 1, -4, 1, -3, 0, -2, 0, -1, 1, 1, 0, 2, 0, 3, 0,
5, 0, 8, -1, 10, -1, 12, -2, 14, -1, 15, -1, 16, -1, 17, -2, 17, -2, 17, -2, 17,
-1, 17, -2, 16, -2, 15, -1, 15, -2, 13, -2, 12, -1, 10, -1, 8, -1, 7, -2, 4, -1,
2, 0, 2, 0, 0, 0, 1, -1, -2, 0, 2, -1, 10, -2, 13, -2, 11, -1, -7, -1, -6, 0,
-6, 0, -6, 0, -5, 0, -6, 0, -5, 0, -6, -1, -5, -1, -5, 0, -4, 0, -4, 0, -5, 0,
-4, 1, -5, 0, -5, 0, -5, -1, -5, -1, -4, 0, -8, -3, };