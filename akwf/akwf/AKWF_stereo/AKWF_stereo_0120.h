#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0120

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, -12, 4, -12, 8, -13, 8, -13, 10,
-12, 11, -11, 13, -10, 15, -9, 18, -6, 22, -4, 26, 2, 30, 4, 34, 7, 34, 9, 35,
11, 35, 16, 37, 18, 38, 22, 42, 24, 46, 29, 48, 29, 50, 32, 50, 35, 52, 37, 53,
37, 55, 37, 55, 39, 55, 39, 55, 40, 56, 43, 62, 45, 65, 49, 67, 54, 67, 56, 68,
52, 69, 55, 68, 56, 68, 56, 72, 59, 74, 61, 73, 64, 76, 71, 77, 73, 81, 74, 82,
77, 79, 80, 79, 87, 78, 89, 80, 87, 80, 85, 79, 83, 78, 85, 80, 86, 80, 87, 78,
87, 78, 86, 77, 81, 75, 79, 73, 77, 70, 76, 69, 73, 66, 71, 65, 71, 67, 71, 68,
72, 66, 73, 63, 73, 58, 71, 51, 68, 46, 61, 42, 60, 39, 58, 36, 55, 31, 53, 28,
53, 27, 52, 23, 49, 20, 46, 19, 42, 16, 41, 13, 37, 12, 35, 8, 35, 6, 32, 7, 32,
10, 31, 14, 30, 14, 28, 13, 26, 12, 23, 12, 22, 11, 19, 11, 17, 10, 15, 5, 14,
6, 12, 6, 12, 4, 12, 3, 12, 2, 10, 2, 6, -1, 4, -4, 2, -3, 1, -5, -2, -5, -3,
-4, -2, -3, 0, -2, -4, -1, -7, -3, -8, -3, -5, -10, -9, -12, -14, -9, -11, -13,
-15, -13, -17, -13, -19, -13, -19, -13, -16, -12, -14, -14, -13, -14, -15, -16,
-19, -21, -23, -23, -26, -24, -23, -25, -22, -25, -24, -25, -22, -24, -23, -24,
-23, -25, -23, -22, -23, -21, -24, -21, -25, -23, -25, -20, -23, -16, -21, -14,
-20, -14, -20, -13, -19, -12, -16, -9, -16, -6, -14, -6, -15, -4, -14, -6, -13,
-7, -4, -7, 2, -7, 2, -7, 4, -5, 4, -5, 5, -6, 3, -9, 4, -11, 3, -19, 1, -23,
-1, -22, -3, -17, 0, -13, 1, -12, 2, -11, 2, -14, -1, -16, -2, -18, -2, -18, -6,
-19, -9, -21, -13, -25, -17, -28, -20, -30, -21, -32, -20, -33, -17, -37, -22,
-39, -23, -42, -26, -46, -30, -52, -35, -57, -37, -62, -40, -65, -41, -67, -44,
-69, -46, -72, -47, -71, -50, -67, -53, -66, -55, -66, -58, -64, -60, -64, -62,
-62, -62, -59, -62, -58, -62, -56, -63, -52, -63, -50, -64, -49, -66, -48, -65,
-46, -67, -45, -62, -45, -58, -46, -58, -40, -55, -37, -54, -34, -54, -33, -54,
-35, -50, -36, -48, -36, -48, -36, -49, -37, -49, -37, -49, -38, -48, -39, -43,
-37, -40, -33, -40, -33, -41, -34, -41, -35, -42, -36, -44, -40, -45, -41, -45,
-41, -47, -42, -48, -41, -48, -43, -47, -45, -49, -47, -48, -51, -49, -53, -49,
-56, -52, -57, -48, -59, -52, -61, -54, -64, -57, -67, -60, -71, -58, -71, -57,
-71, -54, -71, -55, -69, -57, -68, -59, -71, -60, -70, -60, -70, -60, -69, -60,
-65, -55, -63, -56, -54, -55, -50, -53, -45, -49, -42, -47, -34, -41, -30, -36,
-16, -22, -22, -31, -19, -29, 6, -9, 4, -13, 7, -10, 8, -12, 13, -7, 13, -12,
14, -10, 12, -14, 20, -7, 15, -9, 34, 10, 69, 42, 65, 39, 72, 44, 70, 42, 72,
47, 70, 48, 70, 48, 68, 47, 70, 48, 70, 47, 69, 50, 70, 54, 72, 57, 70, 58, 69,
58, 67, 58, 68, 57, 72, 56, 70, 57, 71, 58, 69, 57, 71, 58, 70, 60, 72, 62, 73,
60, 72, 61, 73, 59, 73, 57, 69, 59, 68, 60, 67, 58, 67, 58, 69, 57, 70, 59, 69,
61, 67, 62, 65, 62, 64, 63, 63, 64, 60, 62, 55, 59, 53, 57, 52, 56, 49, 56, 47,
55, 45, 54, 44, 51, 41, 49, 38, 47, 35, 45, 34, 42, 33, 40, 32, 37, 30, 35, 29,
34, 28, 33, 29, 32, 28, 32, 26, 31, 24, 28, 23, 26, 21, 24, 19, 21, 17, 19, 19,
20, 20, 25, 21, 28, 23, 31, 24, 30, 23, 29, 20, 28, 20, 29, 19, 32, 19, 32, 20,
32, 21, 33, 23, 32, 26, 34, 29, 38, 34, 40, 37, 41, 36, 42, 35, 41, 37, 40, 40,
39, 40, 40, 41, 41, 42, 41, 44, 44, 45, 47, 50, 50, 49, 47, 56, 56, 41, 43, 19,
23, 21, 26, 21, 28, 26, 30, 26, 27, 28, 30, 26, 33, 24, 33, 20, 32, 19, 29, 17,
27, 14, 25, 14, 21, 13, 19, 12, 17, 11, 16, 9, 17, 9, 17, 9, 15, 10, 13, 10, 12,
6, 8, 6, 6, 4, 3, 3, 3, 3, 6, 4, 9, 5, 10, 5, 8, 5, 8, 3, 6, 0, 4, -7, 1, -10,
-2, -11, -4, -14, -6, -15, -6, -15, -7, -14, -4, -15, -4, -15, -6, -17, -7, -19,
-10, -21, -12, -24, -12, -27, -12, -29, -13, -33, -17, -34, -21, -36, -23, -39,
-26, -41, -28, -44, -29, -49, -30, -54, -33, -58, -37, -61, -42, -65, -46, -68,
-49, -72, -51, -75, -53, -79, -56, -84, -59, -87, -62, -90, -68, -93, -74, -97,
-78, -99, -82, -102, -86, -102, -87, -103, -90, -105, -93, -107, -96, -108, -96,
-112, -98, -114, -103, -118, -104, -118, -104, -119, -110, -118, -108, -117,
-106, -114, -106, -111, -104, -109, -107, -105, -108, -100, -107, -101, -110,
-101, -108, -95, -106, -96, -111, -90, -102, -95, -108, -57, -73, -30, -49, -35,
-54, -28, -47, -28, -49, -23, -44, -25, -46, -4, -29, 2, -26, 2, -25, 5, -23, 7,
-19, 13, -13, 15, -11, 17, -9, 19, -6, 20, -5, 16, -3, 17, 2, 16, 2, 15, 2, 12,
3, 11, 7, 9, 7, 10, 8, 7, 7, 6, 6, 4, 4, 3, 5, 6, 6, 6, 6, 6, 7, 6, 8, 8, 9, 8,
11, 5, 9, 4, 8, 2, 6, 1, 4, 0, 2, 0, 2, 0, 1, 0, 3, -1, 5, -4, 5, -2, 3, 0, 0,
0, -3, -3, -6, -4, -6, -6, -9, -7, -12, -8, -14, -7, -14, -6, -15, -4, -11, };