#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0046

const PROGMEM int8_t DATA[DATA_LENGTH] = {14, 38, 115, 114, 119, 83, 111, 80,
107, 79, 105, 78, 114, 78, 116, 78, 120, 81, 113, 80, 110, 82, 104, 81, 106, 82,
107, 81, 110, 83, 105, 82, 102, 83, 96, 82, 96, 84, 97, 81, 99, 83, 98, 82, 97,
82, 94, 81, 93, 83, 93, 83, 95, 82, 98, 83, 98, 83, 97, 83, 97, 82, 97, 83, 98,
83, 101, 82, 101, 82, 102, 83, 102, 82, 102, 82, 101, 82, 103, 83, 103, 82, 103,
82, 103, 82, 103, 83, 103, 82, 103, 83, 103, 82, 103, 83, 102, 82, 103, 83, 103,
83, 101, 83, 102, 82, 101, 82, 101, 82, 101, 82, 100, 82, 100, 82, 100, 82, 99,
82, 100, 83, 99, 83, 100, 82, 100, 83, 100, 82, 100, 83, 100, 83, 100, 82, 100,
83, 101, 82, 100, 83, 100, 82, 101, 83, 101, 82, 101, 82, 101, 82, 101, 83, 101,
83, 101, 83, 101, 82, 102, 82, 101, 83, 101, 82, 102, 82, 101, 83, 101, 82, 101,
83, 100, 83, 101, 83, 101, 82, 101, 82, 100, 83, 101, 82, 100, 83, 101, 83, 101,
83, 101, 82, 101, 83, 101, 83, 100, 82, 101, 82, 100, 82, 101, 83, 100, 82, 100,
82, 101, 83, 101, 83, 101, 82, 101, 82, 100, 82, 101, 82, 100, 83, 101, 82, 102,
83, 101, 83, 101, 82, 101, 82, 101, 83, 100, 83, 101, 82, 100, 82, 101, 82, 101,
83, 102, 83, 101, 83, 101, 83, 101, 82, 102, 83, 101, 82, 102, 83, 101, 83, 101,
83, 101, 83, 101, 83, 102, 83, 101, 83, 100, 82, 101, 83, 101, 83, 101, 82, 101,
82, 101, 83, 101, 83, 100, 83, 101, 83, 101, 83, 101, 83, 101, 83, 101, 82, 101,
82, 101, 83, 102, 82, 101, 82, 101, 82, 101, 82, 101, 83, 101, 82, 100, 82, 101,
83, 101, 82, 101, 82, 101, 82, 102, 83, 101, 82, 101, 83, 100, 83, 100, 82, 101,
83, 102, 83, 101, 83, 101, 83, 101, 82, 101, 83, 101, 82, 102, 82, 101, 83, 101,
82, 101, 83, 101, 83, 100, 83, 101, 83, 101, 83, 100, 82, 101, 83, 102, 83, 101,
83, 101, 83, 101, 83, 101, 82, 101, 82, 100, 83, 101, 82, 101, 82, 101, 83, 101,
82, 101, 82, 101, 82, 101, 83, 102, 83, 101, 82, 101, 82, 101, 82, 102, 83, 101,
83, 101, 82, 101, 82, 101, 83, 100, 83, 101, 83, 101, 82, 102, 82, 102, 83, 101,
83, 101, 83, 100, 82, 101, 83, 100, 82, 102, 84, 100, 83, 101, 82, 101, 82, 100,
83, 101, 83, 101, 83, 101, 83, 101, 82, 101, 83, 102, 83, 101, 83, 100, 82, 102,
83, 100, 82, 101, 82, 101, 82, 101, 82, 100, 82, 101, 83, 101, 82, 101, 84, 101,
81, 101, 83, 101, 81, 102, 83, 100, 82, 101, 84, 100, 82, 101, 83, 101, 82, 101,
82, 102, 83, 101, 83, 101, 84, 100, 82, 101, 83, 100, 81, 102, 83, -22, -48,
-123, -117, -115, -79, -114, -83, -105, -76, -108, -80, -111, -76, -118, -80,
-118, -79, -114, -81, -108, -80, -105, -82, -105, -82, -108, -82, -109, -82,
-106, -82, -101, -83, -96, -82, -96, -83, -97, -82, -99, -83, -99, -83, -97,
-83, -94, -82, -93, -83, -93, -82, -96, -82, -97, -82, -98, -83, -97, -81, -96,
-82, -97, -82, -98, -83, -100, -82, -101, -82, -102, -82, -101, -82, -101, -83,
-102, -83, -103, -82, -104, -83, -104, -83, -104, -83, -103, -82, -103, -83,
-103, -82, -103, -82, -103, -83, -103, -82, -103, -82, -102, -82, -101, -82,
-102, -83, -100, -83, -102, -83, -101, -83, -101, -82, -100, -82, -100, -82,
-100, -83, -100, -82, -100, -83, -100, -82, -99, -83, -99, -82, -99, -82, -100,
-82, -100, -82, -100, -82, -101, -83, -100, -82, -100, -83, -101, -82, -101,
-83, -101, -83, -102, -82, -102, -82, -101, -83, -101, -83, -101, -83, -101,
-83, -101, -82, -102, -83, -101, -82, -101, -82, -101, -82, -102, -83, -102,
-83, -101, -82, -101, -83, -101, -82, -101, -83, -101, -82, -101, -82, -101,
-82, -100, -83, -101, -82, -100, -83, -101, -82, -101, -83, -101, -83, -101,
-83, -101, -83, -100, -82, -101, -83, -101, -83, -100, -83, -101, -82, -101,
-83, -101, -82, -101, -82, -101, -82, -101, -83, -101, -83, -101, -82, -101,
-83, -101, -82, -101, -83, -101, -82, -100, -83, -101, -83, -101, -82, -101,
-83, -101, -83, -100, -83, -101, -82, -101, -82, -101, -83, -100, -83, -101,
-82, -101, -83, -101, -83, -101, -82, -101, -83, -101, -83, -101, -82, -101,
-82, -100, -83, -101, -83, -100, -82, -102, -83, -101, -83, -101, -82, -101,
-83, -101, -82, -101, -83, -101, -82, -101, -83, -102, -83, -101, -83, -101,
-82, -101, -82, -101, -83, -101, -82, -101, -83, -101, -82, -101, -83, -101,
-82, -102, -82, -101, -83, -101, -82, -101, -82, -101, -83, -101, -82, -102,
-83, -101, -82, -101, -83, -102, -83, -101, -82, -101, -82, -101, -82, -101,
-83, -101, -82, -101, -82, -102, -82, -100, -83, -102, -83, -101, -83, -100,
-82, -101, -83, -101, -83, -100, -82, -101, -83, -101, -82, -101, -83, -101,
-82, -101, -83, -101, -82, -100, -83, -101, -83, -101, -82, -102, -83, -101,
-82, -101, -83, -101, -83, -101, -83, -101, -83, -101, -82, -100, -82, -101,
-83, -102, -83, -101, -83, -100, -82, -101, -82, -101, -83, -101, -82, -101,
-83, -101, -83, -101, -83, -101, -83, -101, -82, -101, -83, -101, -83, -101,
-82, -100, -83, -101, -83, -102, -83, -100, -83, -101, -82, -102, -83, -102,
-82, -101, -82, -101, -83, -101, -83, -100, -83, -101, -83, -102, -82, -101,
-82, -100, -82, -101, -82, -101, -82, -101, -83, -101, -83, -102, -83, -102,
-83, -101, -83, -101, -83, -101, -82, -101, -82, -100, -83, -101, -82, -101,
-82, -102, -83, -100, -82, -102, -83, -99, -82, -102, -84, -100, -81, -103, -84,
-98, -81, -103, -84, -99, -80, -104, -85, -96, -79, -107, -87, -85, -70, };