#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 20, 2, 25, 4, 25, 3, 27, 5, 27, 6,
29, 7, 28, 7, 31, 9, 31, 11, 33, 12, 33, 12, 35, 13, 35, 14, 37, 14, 37, 17, 38,
17, 39, 19, 41, 19, 42, 20, 41, 22, 43, 22, 43, 23, 45, 23, 46, 25, 46, 26, 48,
26, 48, 28, 50, 29, 51, 29, 52, 31, 52, 32, 53, 33, 55, 32, 55, 34, 55, 35, 56,
37, 57, 37, 58, 37, 58, 39, 59, 39, 60, 41, 60, 41, 62, 42, 62, 43, 64, 44, 64,
44, 65, 45, 66, 47, 66, 47, 67, 48, 68, 49, 68, 49, 69, 51, 70, 51, 71, 52, 71,
52, 71, 54, 72, 54, 73, 54, 74, 56, 74, 55, 75, 57, 75, 57, 75, 59, 77, 59, 76,
60, 77, 60, 78, 61, 77, 63, 79, 62, 79, 63, 80, 64, 81, 65, 81, 65, 81, 66, 81,
66, 81, 67, 82, 67, 83, 68, 83, 69, 83, 69, 83, 70, 84, 70, 84, 71, 85, 72, 85,
73, 86, 73, 87, 74, 87, 74, 87, 74, 87, 75, 88, 75, 88, 77, 88, 77, 88, 77, 89,
78, 89, 78, 89, 78, 89, 80, 90, 80, 90, 80, 90, 80, 91, 81, 90, 81, 90, 81, 91,
82, 91, 83, 91, 83, 92, 84, 92, 84, 92, 85, 92, 85, 93, 85, 93, 86, 93, 86, 94,
87, 94, 87, 93, 88, 94, 88, 94, 89, 94, 88, 94, 90, 95, 89, 95, 91, 95, 90, 95,
91, 95, 91, 94, 92, 95, 91, 94, 92, 96, 93, 96, 92, 95, 94, 95, 94, 96, 93, 95,
94, 95, 94, 95, 94, 96, 94, 96, 95, 95, 96, 96, 96, 96, 97, 96, 96, 96, 96, 96,
97, 97, 98, 96, 98, 96, 98, 97, 99, 97, 98, 95, 98, 96, 99, 95, 99, 95, 100, 96,
99, 96, 99, 96, 99, 96, 100, 96, 101, 97, 101, 95, 101, 96, 101, 97, 103, 96,
102, 95, 102, 95, 103, 96, 103, 96, 103, 96, 104, 96, 104, 96, 104, 96, 104, 97,
104, 96, 104, 96, 106, 95, 104, 96, 105, 95, 105, 96, 106, 95, 106, 95, 106, 95,
106, 95, 106, 96, 107, 95, 107, 95, 108, 95, 108, 95, 107, 95, 108, 95, 109, 95,
109, 95, 109, 96, 110, 95, 109, 95, 110, 95, 110, 95, 110, 95, 110, 94, 111, 95,
111, 95, 111, 95, 111, 95, 111, 94, 112, 94, 113, 96, 112, 94, 113, 95, 112, 94,
113, 95, 113, 95, 113, 95, 113, 95, 114, 95, 114, 95, 114, 93, 115, 95, 114, 94,
116, 96, 115, 94, 116, 96, 114, 94, 117, 98, 115, 94, 118, 97, 115, 93, 119, 98,
115, 92, 119, 97, 115, 92, 120, 97, 116, 93, 119, 97, 118, 94, 118, 94, 123,
101, 50, 10, 57, 34, 35, 23, 26, 22, 35, 38, 21, 18, 19, 14, 10, 1, 17, 7, 13,
2, 16, 3, 10, -7, 14, -4, 13, -5, 16, -2, 13, -8, 14, -9, 13, -12, 14, -8, 14,
-11, 13, -13, 12, -15, 13, -16, 13, -17, 11, -18, 10, -20, 9, -23, 9, -22, 7,
-25, 7, -26, 4, -28, 3, -30, 2, -32, 0, -33, -3, -35, -3, -36, -5, -40, -6, -40,
-9, -42, -11, -45, -13, -46, -15, -48, -16, -50, -19, -52, -21, -54, -23, -55,
-26, -57, -27, -59, -30, -61, -33, -63, -34, -64, -36, -66, -39, -67, -41, -70,
-44, -70, -45, -72, -47, -73, -49, -75, -51, -77, -54, -79, -56, -81, -59, -82,
-60, -84, -62, -84, -64, -86, -65, -87, -67, -89, -68, -90, -70, -90, -72, -91,
-74, -94, -76, -95, -77, -96, -79, -97, -79, -99, -82, -100, -84, -101, -85,
-102, -86, -102, -87, -103, -89, -104, -89, -105, -91, -106, -92, -107, -93,
-108, -95, -109, -95, -110, -96, -110, -98, -111, -98, -111, -98, -112, -100,
-112, -101, -114, -101, -113, -103, -114, -103, -114, -103, -115, -105, -115,
-105, -116, -106, -116, -106, -117, -107, -117, -108, -117, -108, -118, -109,
-118, -109, -118, -109, -118, -110, -119, -110, -119, -110, -118, -111, -119,
-112, -119, -112, -118, -112, -119, -111, -119, -113, -119, -113, -119, -113,
-120, -113, -119, -112, -118, -113, -118, -113, -119, -112, -117, -113, -118,
-114, -117, -112, -118, -113, -117, -113, -117, -112, -117, -113, -117, -113,
-117, -113, -116, -112, -116, -112, -115, -113, -114, -112, -115, -112, -114,
-111, -114, -112, -114, -112, -113, -112, -113, -111, -112, -111, -112, -110,
-111, -110, -110, -109, -110, -109, -109, -109, -108, -108, -108, -108, -107,
-107, -107, -106, -106, -106, -106, -106, -105, -106, -105, -105, -104, -105,
-103, -104, -103, -104, -102, -104, -101, -104, -100, -103, -100, -102, -99,
-102, -99, -101, -98, -101, -96, -101, -96, -100, -94, -99, -94, -98, -94, -97,
-92, -96, -92, -96, -91, -95, -90, -94, -89, -94, -88, -93, -87, -92, -86, -92,
-85, -91, -84, -90, -83, -89, -83, -89, -82, -89, -81, -88, -79, -87, -78, -86,
-78, -85, -77, -85, -76, -84, -76, -84, -74, -82, -74, -82, -72, -81, -70, -80,
-70, -78, -68, -78, -67, -77, -66, -76, -65, -75, -64, -75, -63, -74, -62, -72,
-61, -72, -60, -71, -58, -70, -58, -69, -57, -69, -55, -67, -54, -66, -54, -66,
-52, -65, -51, -64, -50, -63, -49, -62, -47, -61, -47, -60, -45, -59, -44, -58,
-43, -57, -42, -56, -40, -55, -39, -54, -37, -53, -37, -52, -35, -50, -34, -49,
-33, -50, -32, -48, -31, -47, -30, -46, -29, -45, -28, -44, -26, -44, -25, -42,
-24, -42, -23, -40, -21, -39, -20, -38, -19, -37, -18, -36, -16, -35, -16, -34,
-14, -33, -13, -32, -12, -31, -11, -30, -10, -29, -9, -28, -7, -27, -6, -26, -5,
-25, -3, -23, -3, -22, -2, -21, 0, -20, 1, -19, 3, -18, 3, -17, 4, -15, 6, -14,
7, -14, 8, -12, 8, -11, 10, -11, 10, -10, 12, -8, 14, -7, 16, -6, 16, -5, 17,
-4, 17, -3, 20, -1, 19, -1, 22, 0, 20, };