#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0135

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, -8, 7, -7, 10, -3, 14, 0, 17, 5,
21, 6, 24, 11, 27, 14, 31, 18, 33, 21, 36, 24, 39, 26, 43, 29, 46, 33, 48, 35,
51, 39, 54, 41, 56, 44, 58, 47, 60, 49, 63, 51, 66, 55, 67, 57, 70, 58, 72, 60,
74, 63, 75, 65, 77, 67, 79, 68, 80, 71, 81, 73, 83, 73, 84, 75, 85, 76, 87, 78,
88, 79, 88, 80, 89, 82, 89, 82, 90, 83, 92, 85, 91, 85, 93, 86, 92, 86, 94, 87,
93, 88, 94, 89, 94, 90, 94, 90, 94, 90, 95, 91, 96, 91, 95, 91, 95, 91, 95, 92,
95, 92, 96, 93, 95, 92, 95, 93, 94, 92, 94, 93, 94, 93, 93, 93, 94, 93, 92, 93,
92, 92, 93, 92, 92, 92, 91, 92, 90, 92, 90, 92, 90, 90, 90, 90, 89, 89, 88, 90,
87, 90, 87, 88, 86, 87, 84, 87, 84, 86, 82, 85, 81, 85, 80, 84, 79, 83, 78, 82,
76, 80, 75, 79, 74, 78, 72, 76, 70, 75, 69, 73, 66, 72, 65, 69, 63, 68, 60, 65,
59, 64, 56, 62, 53, 60, 52, 58, 50, 56, 47, 54, 45, 52, 42, 50, 40, 46, 37, 43,
35, 42, 32, 39, 30, 37, 26, 33, 24, 31, 22, 29, 18, 26, 16, 23, 12, 20, 10, 17,
7, 14, 4, 12, 1, 9, -2, 5, -5, 3, -7, -1, -11, -4, -14, -7, -17, -9, -21, -12,
-23, -16, -27, -19, -29, -23, -34, -26, -36, -29, -38, -31, -42, -34, -45, -37,
-48, -41, -51, -43, -55, -46, -57, -50, -60, -53, -62, -54, -64, -58, -67, -60,
-70, -63, -72, -66, -75, -68, -77, -70, -80, -73, -82, -76, -84, -78, -86, -79,
-87, -82, -90, -84, -91, -85, -93, -87, -94, -89, -96, -90, -97, -92, -99, -93,
-99, -94, -100, -95, -100, -95, -101, -97, -102, -97, -102, -98, -103, -99,
-103, -99, -102, -99, -103, -100, -103, -99, -102, -98, -102, -98, -102, -98,
-100, -97, -99, -97, -99, -96, -98, -95, -97, -94, -96, -93, -95, -92, -93, -91,
-92, -90, -90, -88, -90, -88, -88, -87, -86, -85, -86, -84, -84, -83, -83, -81,
-81, -80, -80, -79, -79, -77, -77, -76, -76, -74, -74, -73, -72, -71, -70, -70,
-69, -68, -68, -67, -67, -67, -66, -65, -64, -63, -63, -62, -61, -61, -60, -59,
-59, -58, -57, -57, -56, -56, -55, -54, -54, -53, -52, -52, -51, -51, -50, -50,
-48, -49, -48, -48, -46, -48, -45, -46, -44, -45, -43, -44, -42, -43, -40, -42,
-40, -40, -38, -40, -37, -39, -36, -38, -35, -38, -34, -37, -33, -36, -32, -35,
-31, -34, -29, -32, -28, -32, -27, -31, -26, -29, -25, -28, -24, -28, -23, -25,
-22, -25, -21, -23, -18, -23, -17, -22, -17, -20, -16, -19, -13, -17, -13, -17,
-11, -14, -10, -13, -8, -12, -7, -10, -5, -9, -5, -7, -2, -6, -1, -5, 1, -4, 2,
-2, 4, 0, 5, 1, 7, 3, 9, 5, 10, 7, 12, 8, 13, 9, 15, 12, 17, 14, 19, 16, 21, 18,
22, 19, 24, 20, 26, 23, 27, 25, 30, 26, 31, 29, 33, 31, 35, 32, 37, 34, 39, 37,
40, 38, 42, 41, 44, 42, 45, 44, 47, 45, 49, 48, 50, 50, 51, 52, 54, 54, 55, 55,
57, 57, 58, 59, 60, 60, 61, 61, 62, 63, 63, 64, 64, 65, 65, 67, 66, 67, 66, 68,
66, 68, 68, 69, 69, 70, 69, 72, 70, 72, 71, 73, 70, 73, 71, 74, 72, 74, 71, 74,
71, 75, 72, 75, 72, 76, 73, 75, 72, 75, 73, 75, 72, 75, 72, 75, 72, 75, 72, 75,
71, 75, 71, 75, 71, 74, 71, 74, 71, 74, 69, 73, 70, 73, 69, 72, 69, 71, 68, 71,
68, 70, 68, 71, 66, 70, 66, 69, 67, 68, 66, 68, 64, 67, 64, 66, 63, 65, 63, 64,
62, 63, 62, 63, 61, 61, 60, 62, 59, 61, 58, 59, 58, 60, 57, 58, 57, 57, 56, 57,
54, 57, 54, 55, 54, 53, 52, 54, 51, 53, 50, 52, 50, 50, 50, 50, 48, 49, 47, 48,
47, 47, 46, 46, 46, 46, 44, 45, 44, 44, 44, 44, 43, 44, 41, 43, 42, 42, 40, 42,
40, 41, 40, 40, 39, 39, 38, 38, 37, 38, 38, 38, 37, 37, 37, 36, 35, 37, 36, 36,
35, 36, 35, 36, 35, 36, 35, 36, 34, 35, 34, 35, 34, 34, 33, 34, 32, 33, 32, 32,
32, 33, 30, 33, 31, 32, 30, 31, 29, 30, 29, 30, 28, 30, 28, 29, 27, 29, 26, 28,
25, 27, 23, 25, 23, 25, 21, 24, 19, 23, 18, 21, 17, 20, 16, 19, 14, 18, 13, 16,
11, 14, 9, 13, 8, 12, 6, 9, 4, 8, 2, 6, 0, 4, -3, 2, -5, 0, -7, -3, -9, -5, -12,
-8, -14, -9, -17, -11, -18, -14, -21, -16, -24, -19, -26, -22, -29, -23, -32,
-26, -35, -30, -37, -32, -39, -35, -42, -37, -45, -39, -47, -43, -50, -45, -53,
-48, -56, -50, -58, -54, -61, -57, -64, -59, -66, -62, -69, -64, -71, -68, -75,
-70, -77, -73, -80, -75, -82, -77, -84, -80, -87, -82, -89, -85, -92, -88, -94,
-90, -96, -92, -99, -95, -100, -97, -102, -98, -104, -101, -106, -102, -107,
-105, -109, -106, -111, -108, -113, -110, -113, -111, -114, -112, -115, -114,
-116, -115, -117, -116, -118, -117, -118, -118, -118, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -118, -118, -117, -118, -115, -118,
-114, -117, -114, -115, -112, -114, -110, -114, -108, -112, -107, -110, -104,
-109, -103, -107, -100, -105, -97, -103, -95, -101, -93, -99, -89, -96, -86,
-93, -83, -90, -80, -88, -77, -84, -74, -82, -70, -79, -67, -76, -64, -72, -60,
-69, -56, -66, -52, -62, -49, -60, -45, -55, -41, -53, -37, -49, -34, -46, -30,
-42, -26, -38, -23, -33, -18, -31, -15, -27, -10, -24, -7, -20, -3, -17, 0, -11,
};