#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0104

const PROGMEM int8_t DATA[DATA_LENGTH] = {13, 6, 35, 29, 27, 19, 31, 29, 32, 34,
22, 22, 20, 18, 23, 24, 13, 17, 12, 16, 27, 34, 37, 42, 20, 27, 25, 36, 62, 77,
68, 81, 78, 90, 77, 94, 76, 90, 77, 93, 77, 91, 81, 95, 80, 93, 72, 86, 61, 74,
74, 82, 76, 89, 67, 81, 63, 77, 60, 72, 62, 80, 62, 84, 63, 86, 66, 89, 64, 86,
62, 83, 60, 78, 60, 79, 55, 74, 52, 73, 50, 67, 51, 66, 56, 71, 56, 73, 60, 75,
59, 71, 61, 74, 61, 74, 59, 76, 60, 77, 51, 65, 47, 61, 49, 67, 52, 75, 56, 76,
61, 81, 67, 89, 68, 94, 86, 112, 87, 110, 75, 95, 74, 99, 70, 100, 66, 94, 59,
87, 57, 87, 51, 84, 56, 88, 63, 93, 63, 92, 57, 87, 59, 91, 62, 90, 64, 89, 60,
82, 55, 81, 45, 69, 62, 85, 44, 64, -9, 7, -4, 16, -10, 9, -3, 15, 0, 17, 9, 29,
9, 27, 15, 33, 38, 52, 40, 54, 45, 60, 41, 51, 40, 50, 39, 44, 36, 40, 37, 40,
38, 43, 38, 43, 36, 41, 35, 37, 32, 32, 28, 30, 23, 27, 25, 27, 27, 26, 31, 31,
35, 38, 41, 44, 42, 44, 47, 46, 44, 44, 42, 46, 40, 48, 32, 34, 29, 31, 26, 30,
25, 33, 24, 30, 27, 30, 29, 33, 41, 49, 54, 74, 56, 72, 57, 73, 57, 74, 59, 79,
58, 76, 55, 71, 52, 68, 49, 69, 57, 81, 55, 81, 55, 79, 51, 75, 55, 87, 57, 91,
58, 91, 54, 87, 46, 79, 46, 82, 58, 93, 35, 63, 4, 25, 6, 29, -2, 18, -5, 11,
-11, 4, -12, 3, -12, 3, -12, 4, -12, 5, -15, 1, -15, 1, -17, -4, -18, -4, -13,
2, -11, 2, -10, 2, -9, -1, -8, 2, -11, 0, -13, -5, -19, -15, -31, -28, -32, -27,
-35, -31, -36, -34, -39, -44, -37, -40, -36, -40, -36, -38, -28, -37, -27, -37,
-31, -35, -37, -42, -40, -46, -46, -60, -47, -61, -48, -61, -50, -63, -49, -66,
-48, -65, -47, -61, -48, -60, -45, -55, -45, -60, -44, -57, -43, -53, -41, -49,
-41, -53, -39, -56, -34, -48, -34, -47, -29, -44, -27, -47, -27, -47, -27, -47,
-28, -47, -29, -51, -37, -64, -34, -65, -37, -60, -34, -57, -30, -56, -23, -50,
-19, -47, -13, -41, -9, -39, -8, -38, -5, -37, -6, -41, -2, -38, -5, -41, -3,
-38, -6, -43, -11, -49, -6, -47, -1, -41, 2, -36, 1, -40, 5, -38, 7, -37, 8,
-32, 14, -28, -1, -43, -13, -57, -12, -56, -9, -50, -10, -53, -11, -57, -5, -54,
-5, -48, 11, -35, 24, -25, 12, -42, 11, -42, 16, -33, 16, -34, 13, -36, 12, -37,
12, -32, 13, -31, 23, -24, 21, -29, 15, -33, 15, -31, 24, -20, 23, -25, 16, -33,
12, -33, 5, -34, 7, -32, 11, -29, 2, -35, 6, -22, 70, 53, 81, 66, 77, 62, 82,
72, 80, 69, 78, 69, 66, 54, 61, 49, 55, 44, 53, 42, 48, 40, 47, 40, 43, 37, 44,
38, 31, 24, 37, 33, 52, 54, 51, 52, 48, 50, 47, 50, 48, 53, 42, 51, 40, 48, 42,
51, 46, 56, 49, 63, 51, 66, 54, 67, 52, 64, 66, 79, 78, 98, 57, 73, 52, 66, 48,
63, 46, 68, 39, 64, 34, 57, 30, 55, 30, 55, 37, 65, 32, 56, 24, 46, 21, 41, 24,
47, 21, 46, 15, 37, 9, 30, 3, 26, 12, 42, 17, 45, 12, 39, 12, 40, 12, 45, 18,
50, 18, 49, 18, 47, 4, 34, 6, 40, 22, 55, 17, 48, 12, 37, 8, 37, 2, 33, -2, 31,
-6, 29, -7, 27, -7, 28, -8, 27, -9, 29, -12, 24, -15, 22, -19, 15, -21, 12, -21,
12, -19, 14, -16, 16, -14, 13, -9, 18, -8, 18, -5, 22, -9, 14, -12, 11, -11, 11,
-22, -1, -24, -2, -27, -9, -49, -35, -57, -44, -49, -31, -50, -37, -43, -31,
-23, -10, -21, -8, -23, -10, -29, -20, -31, -24, -36, -29, -43, -35, -47, -43,
-55, -52, -47, -43, -44, -38, -47, -39, -54, -51, -52, -50, -47, -45, -49, -44,
-53, -50, -68, -70, -69, -72, -62, -64, -67, -68, -72, -78, -80, -88, -84, -91,
-86, -89, -87, -90, -91, -92, -92, -92, -101, -94, -106, -92, -103, -91, -101,
-87, -102, -89, -100, -88, -94, -84, -88, -76, -84, -72, -83, -71, -80, -70,
-80, -70, -77, -66, -79, -67, -88, -75, -87, -78, -83, -73, -110, -102, -117,
-107, -108, -99, -105, -99, -96, -87, -88, -81, -81, -71, -80, -72, -81, -75,
-81, -74, -81, -73, -83, -77, -82, -83, -78, -77, -73, -71, -68, -66, -60, -59,
-55, -53, -46, -44, -44, -41, -40, -37, -37, -37, -32, -34, -29, -29, -32, -32,
-28, -33, -25, -31, -20, -26, -19, -24, -21, -27, -22, -29, -20, -27, -17, -20,
-24, -25, -29, -34, -22, -28, -17, -21, -11, -12, -7, -9, -8, -16, -4, -14, -4,
-17, -6, -19, -3, -16, -5, -16, -5, -17, -8, -19, -6, -17, -8, -16, -12, -19,
-9, -17, -4, -12, 0, -7, 1, -1, 4, 0, 3, 1, 4, 1, 8, 4, -1, -2, -13, -12, -13,
-12, -12, -17, -10, -14, -11, -15, -9, -14, -8, -17, -1, -12, 13, 3, 3, -3, -4,
-13, -5, -21, -4, -18, -7, -22, -9, -23, -19, -37, -26, -47, -20, -41, -23, -44,
-30, -52, -35, -58, -28, -54, -28, -53, -35, -57, -39, -64, -42, -69, -40, -65,
-36, -60, -40, -63, -40, -67, -35, -60, -32, -58, -32, -58, -35, -66, -38, -71,
-41, -74, -40, -75, -42, -80, -51, -93, -51, -92, -50, -90, -48, -85, -46, -82,
-41, -75, -37, -72, -36, -71, -32, -66, -32, -65, -31, -60, -35, -64, -34, -63,
-40, -69, -42, -67, -38, -61, -35, -59, -33, -58, -30, -54, -27, -46, -26, -44,
-23, -43, -17, -39, -41, -61, -41, -54, };