#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0102

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -36, 6, -42, 13, -39, 19, -42, 24,
-39, 30, -41, 33, -39, 35, -41, 37, -41, 39, -43, 42, -45, 43, -49, 45, -50, 47,
-55, 49, -56, 51, -59, 52, -60, 55, -62, 54, -62, 55, -63, 55, -64, 56, -65, 58,
-66, 59, -66, 60, -66, 62, -65, 63, -64, 64, -62, 66, -61, 67, -61, 66, -61, 67,
-62, 68, -63, 70, -64, 71, -64, 74, -67, 79, -68, 83, -69, 88, -72, 92, -72, 95,
-72, 97, -71, 99, -70, 102, -69, 103, -67, 104, -66, 105, -65, 104, -63, 104,
-61, 102, -57, 101, -51, 101, -44, 100, -39, 101, -32, 101, -26, 101, -22, 103,
-20, 104, -19, 104, -18, 105, -16, 106, -14, 108, -12, 109, -8, 109, -6, 110,
-3, 112, 0, 112, 1, 112, 3, 113, 6, 111, 7, 111, 11, 110, 14, 108, 18, 106, 21,
103, 25, 100, 29, 97, 30, 94, 33, 90, 34, 89, 36, 85, 35, 82, 35, 80, 35, 78,
34, 76, 33, 75, 31, 73, 29, 72, 26, 71, 25, 72, 25, 71, 24, 69, 23, 68, 23, 67,
21, 66, 18, 65, 17, 63, 12, 61, 8, 60, 4, 58, -3, 56, -9, 55, -14, 53, -20, 52,
-26, 50, -31, 50, -36, 48, -39, 48, -42, 47, -42, 46, -41, 45, -39, 44, -36, 43,
-33, 41, -30, 41, -25, 40, -23, 38, -19, 38, -16, 36, -14, 36, -14, 36, -14, 36,
-14, 37, -16, 38, -17, 38, -19, 39, -21, 41, -23, 41, -26, 42, -28, 42, -30, 42,
-32, 42, -32, 41, -32, 39, -32, 36, -30, 31, -27, 27, -23, 21, -20, 17, -17, 11,
-13, 7, -9, 3, -7, -2, -4, -6, -2, -10, 1, -14, 1, -17, 4, -21, 6, -24, 8, -27,
9, -31, 11, -34, 12, -38, 13, -41, 14, -45, 14, -48, 14, -51, 13, -54, 11, -56,
8, -60, 6, -62, 4, -63, 2, -65, -2, -65, -6, -65, -7, -65, -11, -64, -15, -63,
-18, -62, -20, -63, -23, -62, -24, -62, -26, -61, -26, -61, -27, -59, -29, -60,
-30, -60, -30, -60, -29, -60, -28, -59, -25, -59, -23, -59, -23, -58, -22, -57,
-21, -57, -21, -55, -20, -54, -19, -53, -20, -52, -20, -52, -21, -51, -24, -51,
-25, -50, -26, -49, -27, -47, -27, -46, -29, -45, -30, -44, -30, -46, -32, -48,
-34, -51, -35, -53, -35, -57, -35, -59, -34, -61, -32, -63, -32, -67, -31, -70,
-31, -73, -29, -75, -28, -77, -27, -79, -26, -82, -25, -84, -24, -85, -22, -86,
-24, -88, -23, -89, -25, -90, -25, -90, -26, -93, -27, -93, -27, -94, -27, -96,
-27, -96, -26, -96, -24, -97, -23, -97, -23, -100, -22, -101, -23, -103, -26,
-104, -28, -105, -32, -106, -36, -107, -38, -109, -41, -111, -43, -112, -44,
-115, -46, -115, -45, -117, -45, -118, -44, -119, -42, -119, -39, -118, -37,
-118, -33, -116, -30, -113, -28, -110, -25, -107, -22, -105, -18, -102, -15,
-100, -11, -98, -7, -97, -3, -95, 0, -94, 3, -94, 5, -93, 8, -93, 11, -93, 13,
-92, 16, -92, 18, -91, 21, -89, 25, -87, 29, -83, 32, -79, 37, -73, 41, -68, 45,
-62, 50, -58, 53, -52, 55, -45, 59, -40, 62, -34, 64, -27, 68, -21, 70, -16, 74,
-10, 79, -5, 85, -2, 90, 2, 96, 6, 103, 11, 108, 16, 113, 22, 116, 27, 118, 32,
118, 37, 120, 40, 118, 44, 115, 46, 113, 48, 111, 51, 107, 54, 103, 56, 99, 57,
94, 60, 89, 60, 83, 61, 79, 63, 72, 64, 67, 63, 61, 65, 57, 64, 51, 62, 45, 62,
38, 62, 32, 61, 26, 60, 20, 61, 15, 61, 13, 62, 12, 63, 12, 63, 13, 62, 14, 63,
15, 63, 15, 63, 15, 64, 16, 66, 17, 68, 19, 72, 21, 74, 22, 76, 23, 78, 21, 78,
19, 79, 15, 77, 12, 77, 8, 75, 6, 72, 2, 69, -2, 65, -4, 63, -7, 59, -7, 55, -7,
53, -7, 50, -6, 46, -4, 44, -3, 42, -1, 39, 2, 37, 3, 36, 5, 36, 6, 36, 7, 36,
8, 37, 9, 38, 9, 39, 8, 40, 9, 40, 10, 40, 12, 40, 13, 39, 14, 38, 16, 38, 17,
37, 19, 35, 19, 33, 21, 31, 23, 30, 23, 29, 24, 28, 26, 28, 26, 27, 26, 26, 27,
24, 26, 21, 25, 18, 25, 16, 24, 15, 23, 13, 22, 11, 22, 11, 23, 10, 22, 10, 24,
9, 25, 8, 27, 9, 28, 9, 29, 9, 31, 9, 31, 11, 32, 11, 32, 13, 30, 15, 31, 15,
31, 16, 30, 16, 30, 15, 29, 14, 27, 13, 27, 12, 24, 13, 24, 12, 24, 13, 24, 12,
25, 10, 28, 9, 29, 7, 31, 5, 34, 3, 36, 2, 39, 2, 41, 0, 44, -1, 44, -4, 46, -5,
48, -7, 49, -8, 50, -9, 49, -11, 47, -12, 44, -13, 40, -15, 38, -16, 36, -18,
33, -18, 32, -18, 31, -20, 32, -20, 32, -20, 32, -20, 32, -20, 31, -19, 31, -19,
30, -17, 27, -16, 25, -14, 22, -14, 20, -14, 18, -15, 17, -17, 15, -17, 14, -16,
12, -17, 10, -16, 8, -16, 7, -15, 5, -15, 6, -14, 6, -13, 7, -14, 9, -14, 9,
-15, 8, -15, 7, -17, 5, -17, 3, -19, 0, -20, 0, -20, -3, -20, -5, -19, -7, -18,
-8, -17, -9, -18, -9, -19, -9, -22, -8, -24, -8, -28, -6, -32, -3, -37, -2, -42,
1, -49, 2, -55, 4, -61, 5, -67, 7, -71, 8, -76, 10, -79, 12, -83, 14, -87, 16,
-91, 17, -93, 17, -96, 16, -99, 16, -99, 14, -100, 12, -102, 10, -102, 8, -102,
6, -101, 4, -101, 1, -98, -2, -98, -4, -98, -7, -97, -11, -97, -14, -96, -18,
-94, -21, -90, -23, -86, -26, -82, -27, -76, -29, -72, -28, -69, -27, -65, -27,
-60, -28, -56, -27, -51, -29, -45, -28, -40, -31, -35, -30, -29, -35, -25, -34,
-20, -38, -15, -37, -11, -41, -4, -34, };