#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0066

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 41, 0, 50, 1, 46, 1, 49, 3, 47, 2,
49, 2, 47, 3, 50, 4, 50, 4, 51, 4, 50, 4, 51, 4, 50, 5, 52, 5, 52, 5, 53, 6, 52,
5, 52, 7, 52, 6, 52, 7, 53, 7, 53, 6, 52, 6, 52, 6, 53, 7, 53, 7, 53, 6, 54, 7,
52, 7, 53, 7, 53, 7, 52, 7, 52, 7, 52, 7, 52, 6, 53, 6, 53, 6, 53, 7, 52, 6, 52,
6, 52, 6, 52, 7, 53, 6, 52, 5, 53, 5, 52, 5, 51, 5, 52, 5, 52, 5, 51, 5, 52, 5,
51, 5, 52, 5, 51, 5, 51, 5, 51, 5, 51, 4, 51, 4, 51, 4, 51, 4, 51, 5, 52, 4, 51,
3, 52, 3, 51, 4, 52, 4, 52, 3, 52, 3, 52, 4, 52, 4, 52, 3, 53, 4, 53, 4, 53, 5,
53, 5, 53, 5, 54, 5, 54, 5, 54, 5, 53, 5, 54, 6, 54, 6, 54, 6, 55, 6, 56, 6, 56,
7, 57, 7, 56, 7, 57, 8, 57, 8, 58, 9, 58, 8, 59, 10, 59, 9, 59, 10, 60, 10, 60,
10, 60, 11, 61, 12, 62, 12, 62, 12, 63, 13, 63, 14, 62, 15, 64, 14, 64, 14, 63,
15, 64, 16, 64, 16, 64, 17, 64, 17, 65, 19, 66, 18, 67, 19, 66, 20, 67, 20, 67,
21, 67, 21, 68, 22, 68, 22, 68, 22, 69, 24, 69, 23, 69, 23, 70, 25, 70, 25, 71,
25, 71, 26, 71, 26, 71, 26, 71, 27, 71, 27, 71, 27, 72, 28, 72, 29, 73, 29, 73,
29, 73, 30, 73, 30, 72, 30, 74, 31, 73, 31, 73, 31, 74, 31, 73, 32, 75, 32, 75,
32, 73, 32, 73, 32, 74, 33, 75, 33, 75, 33, 75, 33, 76, 33, 75, 33, 74, 34, 75,
33, 74, 34, 76, 34, 75, 34, 75, 33, 75, 34, 75, 34, 76, 34, 76, 35, 75, 35, 76,
35, 76, 34, 76, 34, 76, 34, 76, 34, 76, 35, 76, 35, 76, 35, 77, 35, 76, 34, 76,
35, 76, 35, 76, 35, 77, 35, 76, 35, 77, 35, 77, 35, 78, 36, 77, 35, 77, 35, 77,
35, 77, 36, 77, 37, 78, 36, 78, 36, 78, 36, 78, 36, 79, 36, 78, 36, 79, 37, 79,
37, 79, 38, 79, 37, 79, 38, 79, 38, 79, 38, 80, 37, 79, 39, 80, 38, 79, 39, 81,
39, 80, 39, 80, 39, 80, 40, 80, 40, 82, 40, 82, 40, 81, 40, 81, 41, 81, 41, 82,
41, 82, 42, 82, 42, 82, 42, 83, 43, 83, 43, 82, 43, 83, 43, 83, 43, 83, 44, 84,
44, 84, 45, 84, 45, 84, 45, 84, 45, 85, 45, 84, 46, 83, 45, 80, 43, 79, 41, 77,
39, 76, 36, 72, 33, 71, 30, 67, 27, 67, 25, 63, 20, 61, 17, 57, 15, 53, 11, 48,
8, 40, 4, 33, 14, -6, 19, -34, 14, -41, 10, -49, 5, -53, 0, -59, -6, -62, -11,
-66, -17, -69, -22, -72, -27, -74, -32, -77, -37, -79, -41, -82, -47, -84, -51,
-85, -54, -87, -58, -88, -62, -91, -66, -92, -71, -94, -74, -94, -77, -95, -81,
-96, -84, -98, -87, -99, -90, -101, -92, -101, -95, -102, -99, -103, -100, -103,
-102, -104, -105, -106, -107, -106, -108, -108, -111, -107, -112, -108, -114,
-109, -115, -109, -116, -109, -116, -109, -117, -109, -119, -110, -118, -110,
-119, -109, -119, -109, -119, -109, -119, -109, -119, -109, -118, -109, -118,
-109, -117, -108, -115, -107, -115, -107, -113, -106, -112, -106, -110, -105,
-109, -105, -107, -103, -104, -102, -103, -100, -101, -100, -98, -99, -95, -98,
-93, -97, -90, -95, -86, -93, -83, -93, -80, -91, -76, -90, -73, -88, -70, -87,
-66, -85, -61, -83, -58, -82, -53, -80, -50, -79, -45, -76, -41, -74, -37, -72,
-33, -70, -30, -67, -26, -65, -21, -62, -18, -59, -14, -56, -11, -53, -9, -49,
-5, -45, -4, -38, -1, -32, -11, 0, -18, 22, -15, 24, -13, 30, -11, 31, -9, 34,
-6, 36, -5, 39, -2, 39, 0, 40, 0, 41, 2, 42, 3, 42, 4, 43, 6, 43, 6, 43, 7, 43,
7, 42, 8, 42, 8, 42, 7, 42, 7, 41, 8, 41, 7, 40, 6, 40, 6, 39, 4, 37, 4, 36, 3,
35, 2, 34, 0, 33, -1, 31, -2, 30, -2, 28, -3, 25, -5, 24, -6, 20, -7, 19, -7,
12, -8, 11, -2, -7, 7, -33, 7, -38, 7, -44, 6, -46, 5, -49, 4, -51, 3, -53, 2,
-54, 1, -55, 0, -56, -2, -57, -3, -58, -4, -60, -5, -60, -7, -60, -7, -61, -8,
-61, -9, -61, -10, -62, -10, -61, -11, -62, -11, -61, -12, -61, -12, -61, -12,
-61, -14, -61, -13, -61, -14, -60, -13, -60, -14, -60, -13, -60, -14, -60, -14,
-59, -13, -58, -13, -58, -12, -57, -12, -56, -12, -56, -12, -56, -11, -55, -11,
-55, -11, -54, -10, -54, -9, -52, -9, -53, -8, -52, -8, -51, -8, -50, -7, -50,
-6, -50, -6, -49, -6, -48, -6, -48, -4, -48, -4, -47, -3, -46, -2, -47, -2, -46,
-3, -45, -2, -44, -1, -44, -1, -44, -1, -44, -1, -43, 0, -43, 1, -42, 1, -42, 1,
-42, 1, -41, 3, -40, 3, -40, 3, -41, 2, -39, 3, -40, 3, -40, 3, -39, 2, -39, 4,
-39, 4, -38, 4, -38, 4, -37, 4, -36, 4, -36, 4, -36, 4, -36, 5, -35, 4, -35, 5,
-34, 5, -34, 5, -32, 5, -32, 6, -31, 6, -30, 5, -30, 6, -28, 7, -27, 6, -26, 6,
-24, 6, -23, 6, -20, 4, -18, 4, -13, -4, 3, -7, 14, -7, 17, -9, 20, -9, 22, -9,
24, -9, 25, -9, 26, -8, 28, -8, 30, -7, 30, -7, 33, -8, 34, -7, 34, -7, 35, -6,
36, -6, 37, -5, 39, -5, 38, -5, 40, -4, 40, -4, 42, -3, 41, -3, 44, -2, 42, -2,
46, 0, 42, -1, 48, 0, 40, };