#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0185

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, -28, 6, -29, 10, -23, 14, -20, 17,
-14, 21, -12, 25, -7, 28, -2, 32, 2, 35, 5, 39, 11, 43, 13, 46, 19, 49, 23, 52,
27, 56, 30, 59, 35, 62, 37, 64, 42, 67, 45, 70, 48, 73, 51, 75, 55, 78, 59, 79,
61, 82, 63, 84, 67, 86, 69, 88, 71, 89, 74, 90, 76, 93, 78, 93, 80, 95, 82, 96,
83, 97, 85, 97, 87, 99, 88, 99, 89, 99, 90, 100, 92, 101, 93, 102, 93, 101, 95,
102, 95, 102, 95, 102, 96, 102, 97, 102, 97, 101, 96, 101, 97, 101, 97, 100, 96,
101, 96, 101, 95, 99, 96, 99, 95, 98, 95, 97, 94, 96, 94, 95, 92, 94, 92, 94,
91, 93, 90, 91, 88, 90, 88, 89, 86, 87, 86, 86, 84, 85, 83, 83, 82, 82, 80, 80,
79, 79, 78, 77, 76, 76, 74, 74, 72, 73, 71, 70, 70, 69, 68, 67, 67, 65, 65, 63,
64, 62, 61, 60, 59, 58, 57, 57, 57, 54, 54, 53, 53, 50, 50, 48, 49, 46, 47, 44,
46, 42, 43, 40, 42, 38, 40, 37, 38, 35, 36, 32, 35, 31, 32, 28, 31, 26, 29, 24,
26, 22, 24, 19, 22, 18, 21, 16, 20, 14, 17, 12, 15, 10, 13, 8, 12, 6, 10, 5, 8,
3, 7, 1, 5, 0, 4, -2, 2, -4, 0, -6, -2, -7, -4, -9, -5, -10, -6, -12, -8, -13,
-9, -14, -11, -16, -12, -18, -13, -19, -14, -20, -15, -21, -17, -21, -18, -23,
-18, -23, -20, -24, -20, -25, -21, -26, -22, -27, -22, -27, -23, -28, -24, -28,
-24, -28, -25, -29, -24, -29, -25, -29, -26, -30, -25, -30, -26, -29, -25, -30,
-26, -30, -25, -30, -25, -29, -24, -28, -24, -28, -24, -27, -23, -27, -23, -26,
-21, -24, -21, -25, -20, -24, -20, -22, -18, -21, -17, -20, -16, -19, -14, -18,
-13, -16, -12, -14, -10, -13, -7, -12, -7, -9, -5, -7, -4, -6, -2, -5, 1, -2, 3,
0, 4, 2, 6, 4, 10, 6, 12, 8, 13, 10, 15, 13, 18, 13, 20, 17, 22, 18, 25, 21, 27,
23, 30, 24, 32, 26, 35, 28, 36, 30, 39, 32, 41, 34, 43, 36, 45, 37, 47, 39, 49,
40, 51, 42, 53, 45, 55, 46, 56, 46, 58, 49, 60, 50, 61, 51, 63, 53, 65, 54, 66,
55, 67, 56, 70, 57, 70, 59, 72, 59, 73, 61, 74, 62, 74, 64, 76, 64, 78, 64, 79,
66, 80, 67, 81, 67, 81, 69, 82, 69, 83, 71, 83, 70, 84, 71, 85, 73, 85, 73, 87,
73, 87, 75, 87, 75, 87, 76, 87, 76, 88, 78, 89, 78, 89, 79, 89, 80, 90, 80, 89,
80, 90, 80, 90, 82, 90, 81, 90, 82, 89, 83, 89, 82, 89, 83, 90, 84, 89, 84, 89,
84, 88, 84, 89, 84, 89, 84, 88, 84, 88, 84, 88, 84, 87, 84, 87, 84, 86, 84, 85,
84, 85, 84, 85, 84, 83, 82, 83, 82, 82, 82, 81, 81, 81, 82, 80, 81, 79, 80, 77,
79, 77, 79, 76, 78, 75, 78, 74, 78, 72, 76, 71, 75, 71, 75, 69, 74, 68, 73, 67,
72, 65, 71, 64, 70, 62, 68, 60, 68, 58, 66, 58, 66, 56, 65, 54, 63, 53, 62, 52,
60, 50, 59, 48, 58, 46, 56, 44, 55, 42, 55, 40, 52, 39, 52, 37, 49, 35, 49, 34,
47, 31, 45, 29, 43, 29, 42, 26, 40, 23, 40, 21, 37, 21, 36, 19, 34, 17, 32, 14,
30, 13, 28, 10, 26, 9, 24, 7, 23, 5, 21, 4, 19, 1, 17, 0, 15, -3, 12, -5, 10,
-6, 8, -9, 5, -11, 5, -13, 1, -13, 0, -15, -3, -18, -5, -19, -7, -21, -9, -23,
-11, -23, -13, -25, -16, -27, -18, -29, -20, -29, -22, -31, -24, -32, -26, -33,
-29, -34, -30, -36, -33, -36, -34, -37, -36, -38, -37, -39, -40, -40, -41, -40,
-42, -40, -44, -41, -45, -41, -48, -42, -49, -42, -50, -43, -51, -43, -53, -43,
-53, -43, -55, -42, -56, -44, -57, -43, -58, -43, -59, -43, -61, -43, -62, -43,
-63, -43, -64, -43, -64, -43, -66, -43, -67, -42, -67, -42, -69, -42, -70, -42,
-71, -42, -72, -42, -73, -43, -73, -42, -74, -43, -75, -43, -76, -42, -77, -43,
-78, -43, -80, -44, -80, -43, -82, -43, -82, -44, -83, -44, -84, -45, -85, -45,
-85, -46, -85, -45, -87, -47, -88, -47, -89, -48, -89, -48, -90, -48, -91, -50,
-92, -50, -93, -52, -93, -52, -94, -54, -95, -54, -96, -55, -97, -56, -98, -56,
-98, -58, -99, -60, -100, -60, -101, -62, -101, -63, -102, -64, -102, -66, -103,
-67, -104, -68, -105, -70, -104, -70, -106, -72, -106, -73, -107, -74, -107,
-76, -108, -77, -109, -79, -109, -80, -110, -82, -110, -83, -110, -84, -111,
-86, -110, -87, -112, -88, -112, -89, -112, -91, -113, -92, -114, -93, -114,
-95, -114, -95, -114, -96, -114, -98, -114, -99, -114, -99, -114, -100, -114,
-102, -114, -102, -115, -103, -113, -105, -114, -105, -113, -107, -114, -107,
-114, -108, -114, -108, -113, -110, -112, -111, -112, -111, -113, -112, -111,
-112, -111, -113, -111, -114, -111, -114, -109, -115, -109, -115, -109, -116,
-109, -116, -107, -117, -107, -117, -106, -118, -105, -117, -104, -118, -104,
-118, -103, -119, -102, -118, -101, -119, -100, -119, -100, -120, -98, -119,
-97, -118, -96, -118, -95, -119, -93, -118, -93, -119, -92, -118, -91, -118,
-90, -118, -88, -117, -87, -117, -86, -117, -85, -116, -83, -116, -82, -115,
-81, -114, -79, -113, -78, -112, -77, -112, -76, -110, -74, -110, -72, -108,
-71, -107, -69, -107, -67, -105, -65, -103, -64, -101, -62, -99, -60, -98, -58,
-96, -56, -93, -54, -92, -51, -89, -49, -86, -46, -83, -43, -82, -40, -78, -38,
-76, -35, -72, -32, -70, -29, -65, -25, -63, -22, -58, -19, -56, -15, -51, -12,
-49, -9, -41, -5, -41, -1, -30, };