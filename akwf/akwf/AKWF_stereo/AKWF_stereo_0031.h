#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0031

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 90, 4, 108, 6, 100, 7, 107, 10,
101, 11, 106, 12, 101, 14, 106, 16, 102, 18, 106, 19, 102, 22, 105, 24, 103, 25,
105, 27, 103, 28, 104, 29, 102, 32, 104, 33, 104, 36, 104, 36, 104, 38, 104, 40,
104, 41, 103, 43, 102, 45, 103, 46, 102, 47, 102, 49, 102, 51, 101, 52, 102, 54,
101, 55, 101, 56, 100, 58, 101, 59, 100, 61, 99, 62, 98, 63, 98, 66, 98, 67, 97,
68, 96, 69, 95, 71, 94, 73, 94, 75, 93, 76, 92, 78, 90, 79, 89, 81, 89, 82, 87,
83, 87, 85, 84, 86, 84, 88, 82, 89, 81, 91, 80, 92, 77, 93, 76, 94, 76, 95, 74,
96, 72, 97, 71, 99, 70, 100, 68, 102, 67, 103, 66, 104, 64, 105, 63, 107, 62,
106, 61, 108, 60, 108, 58, 108, 58, 110, 55, 109, 56, 110, 54, 110, 53, 110, 52,
111, 50, 111, 50, 111, 47, 112, 47, 111, 46, 111, 45, 111, 44, 111, 42, 110, 42,
110, 41, 110, 40, 110, 39, 110, 38, 110, 37, 109, 37, 108, 35, 109, 35, 108, 35,
108, 32, 108, 32, 107, 32, 107, 30, 107, 30, 107, 28, 106, 28, 106, 27, 105, 26,
107, 25, 105, 24, 106, 22, 106, 22, 107, 22, 107, 20, 106, 21, 107, 18, 107, 18,
108, 18, 107, 17, 107, 15, 109, 15, 109, 14, 109, 13, 109, 12, 109, 11, 109, 11,
110, 10, 110, 9, 110, 8, 111, 7, 110, 7, 110, 6, 110, 5, 110, 4, 111, 3, 111, 3,
110, 3, 111, 2, 110, 1, 110, 1, 110, 1, 109, 0, 109, -1, 108, -1, 108, -2, 107,
-1, 107, -1, 106, -2, 105, -2, 105, -2, 104, -2, 103, -3, 102, -3, 102, -2, 101,
-2, 101, -2, 100, -3, 100, -3, 98, -3, 97, -3, 97, -3, 97, -2, 95, -2, 95, -3,
94, -4, 94, -4, 93, -4, 93, -4, 91, -6, 91, -7, 90, -7, 90, -8, 89, -9, 88, -10,
88, -12, 87, -13, 87, -15, 87, -16, 86, -18, 87, -20, 86, -21, 86, -23, 86, -26,
85, -27, 85, -30, 85, -32, 84, -34, 84, -35, 84, -37, 84, -40, 83, -42, 82, -44,
83, -47, 82, -48, 80, -51, 80, -53, 80, -54, 79, -56, 78, -58, 77, -59, 78, -61,
76, -63, 76, -65, 75, -67, 74, -68, 73, -69, 72, -70, 71, -73, 69, -75, 68, -75,
67, -77, 67, -78, 64, -80, 64, -81, 62, -83, 61, -83, 61, -85, 58, -86, 57, -87,
56, -88, 54, -90, 53, -90, 52, -91, 50, -92, 49, -94, 47, -95, 46, -96, 45, -97,
44, -98, 42, -99, 42, -101, 40, -101, 39, -103, 38, -103, 36, -105, 35, -105,
34, -106, 33, -107, 32, -108, 30, -109, 30, -110, 27, -111, 27, -113, 26, -113,
24, -114, 22, -114, 22, -115, 20, -117, 20, -118, 18, -118, 18, -118, 16, -119,
15, -119, 13, -119, 12, -119, 10, -119, 9, -119, 8, -119, 6, -119, 5, -118, 4,
-118, 2, -117, 1, -117, -1, -116, -2, -115, -3, -114, -5, -114, -6, -113, -7,
-112, -9, -111, -11, -110, -12, -109, -14, -108, -15, -108, -16, -105, -18,
-105, -20, -104, -21, -102, -23, -101, -25, -100, -26, -98, -27, -97, -28, -95,
-31, -94, -33, -92, -34, -91, -36, -89, -37, -89, -39, -86, -40, -86, -42, -84,
-43, -83, -45, -81, -46, -80, -48, -79, -50, -78, -51, -77, -53, -75, -54, -74,
-55, -73, -56, -73, -58, -72, -59, -71, -61, -70, -62, -68, -64, -68, -64, -66,
-66, -66, -67, -64, -68, -63, -69, -63, -70, -62, -72, -61, -73, -59, -74, -59,
-75, -58, -76, -57, -78, -56, -79, -55, -79, -55, -81, -54, -82, -52, -82, -51,
-83, -51, -85, -50, -85, -48, -86, -47, -87, -45, -88, -45, -89, -44, -90, -42,
-91, -40, -92, -40, -93, -38, -93, -36, -95, -35, -96, -34, -97, -32, -98, -31,
-98, -29, -99, -28, -100, -27, -101, -24, -102, -24, -103, -22, -104, -21, -105,
-19, -105, -18, -106, -16, -107, -15, -108, -14, -109, -12, -110, -11, -109,
-11, -111, -9, -111, -9, -112, -8, -113, -7, -113, -7, -114, -6, -114, -5, -115,
-4, -115, -4, -115, -3, -116, -3, -116, -3, -116, -2, -117, -3, -117, -2, -117,
-3, -117, -2, -117, -2, -118, -2, -118, -2, -118, -3, -118, -3, -118, -2, -118,
-2, -118, -3, -118, -2, -119, -3, -118, -3, -119, -4, -119, -4, -119, -4, -119,
-3, -119, -3, -118, -3, -119, -4, -119, -3, -119, -2, -120, -2, -119, -2, -119,
-2, -119, -1, -120, -1, -119, -1, -118, -2, -119, -2, -119, -2, -118, -2, -120,
-1, -119, -2, -119, -1, -119, -1, -119, -1, -120, -2, -118, -1, -119, -1, -119,
-2, -119, -2, -118, -2, -118, -1, -118, -1, -117, -1, -117, -1, -117, 0, -116,
0, -116, 0, -116, 0, -115, 0, -115, 1, -113, 2, -113, 2, -113, 2, -111, 2, -111,
3, -110, 4, -110, 4, -108, 4, -107, 5, -107, 5, -106, 7, -105, 7, -103, 8, -103,
8, -102, 9, -101, 10, -99, 10, -99, 12, -97, 13, -97, 13, -95, 14, -94, 15, -92,
16, -91, 16, -91, 18, -89, 18, -89, 20, -88, 21, -86, 22, -85, 24, -84, 24, -83,
26, -81, 27, -81, 29, -80, 29, -78, 32, -77, 33, -76, 35, -76, 37, -74, 38, -73,
40, -72, 42, -71, 44, -70, 46, -69, 49, -68, 50, -67, 51, -66, 54, -64, 56, -62,
59, -63, 61, -61, 63, -60, 66, -59, 67, -58, 69, -56, 71, -55, 73, -54, 75, -53,
76, -52, 79, -50, 80, -49, 82, -48, 83, -47, 85, -46, 86, -45, 87, -43, 89, -42,
90, -39, 91, -38, 92, -37, 93, -35, 94, -34, 95, -32, 95, -30, 96, -28, 96, -27,
98, -25, 97, -23, 100, -22, 99, -20, 101, -18, 99, -17, 102, -14, 99, -13, 103,
-11, 99, -9, 104, -7, 99, -6, 106, -4, 99, -3, 109, 0, 88, };