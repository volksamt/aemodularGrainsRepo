#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0159

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 2, 1, 2,
2, 2, 3, 2, 2, 4, 3, 4, 3, 3, 3, 4, 3, 4, 4, 5, 4, 4, 4, 5, 4, 5, 4, 6, 4, 5, 4,
6, 4, 6, 4, 6, 5, 7, 5, 7, 5, 7, 5, 7, 5, 7, 5, 7, 6, 8, 6, 8, 6, 8, 6, 8, 6, 9,
6, 9, 6, 9, 7, 9, 7, 9, 7, 9, 8, 9, 6, 10, 7, 11, 7, 11, 8, 11, 8, 11, 8, 11, 8,
11, 8, 12, 8, 12, 8, 11, 8, 12, 8, 12, 9, 12, 8, 12, 8, 12, 8, 13, 9, 12, 10,
13, 9, 12, 9, 13, 10, 13, 10, 14, 10, 14, 10, 13, 10, 14, 10, 14, 10, 15, 10,
15, 11, 68, 41, 101, 61, 101, 61, 105, 63, 104, 63, 108, 65, 107, 65, 109, 65,
110, 65, 111, 66, 112, 68, 113, 68, 113, 68, 115, 69, 116, 69, 115, 70, 116, 70,
117, 70, 117, 71, 117, 70, 118, 71, 119, 72, 118, 72, 118, 72, 119, 72, 118, 72,
119, 72, 119, 73, 119, 72, 119, 73, 120, 72, 119, 72, 119, 73, 118, 72, 118, 72,
117, 71, 118, 71, 118, 71, 118, 71, 117, 70, 117, 70, 116, 70, 115, 71, 115, 70,
115, 70, 114, 70, 114, 69, 113, 69, 112, 69, 111, 69, 111, 68, 110, 68, 110, 67,
109, 67, 109, 66, 108, 67, 108, 66, 107, 65, 106, 65, 106, 65, 104, 65, 104, 64,
103, 64, 103, 64, 102, 63, 101, 63, 100, 63, 99, 61, 99, 61, 98, 61, 98, 60, 96,
60, 96, 59, 95, 59, 94, 58, 93, 59, 92, 58, 92, 57, 91, 57, 90, 56, 88, 55, 88,
56, 87, 55, 87, 54, 85, 55, 85, 53, 85, 53, 82, 53, 82, 52, 81, 52, 80, 51, 80,
51, 79, 50, 78, 49, 77, 49, 77, 49, 75, 48, 74, 47, 73, 47, 73, 47, 72, 47, 71,
46, 70, 47, 69, 45, 69, 45, 68, 44, 68, 44, 66, 43, 65, 43, 64, 42, 64, 41, 63,
42, 62, 42, 61, 40, 60, 41, 60, 40, 58, 39, 57, 39, 57, 39, 56, 38, 55, 39, 55,
37, 54, 37, 53, 37, 52, 37, 52, 36, 51, 36, 50, 36, 49, 34, 48, 35, 48, 34, 47,
33, 46, 33, 46, 33, 44, 32, 44, 32, 43, 31, 43, 31, 42, 31, 42, 31, 41, 29, 40,
30, 39, 30, 39, 29, 38, 29, 37, 29, 37, 29, 37, 28, 36, 28, 35, 27, 34, 27, 34,
26, 33, 26, 32, 26, 31, 25, 31, 25, 30, 25, 30, 24, 28, 24, 29, 23, 28, 24, 27,
23, 27, 23, 27, 23, 25, 22, 25, 22, 24, 22, 24, 22, 23, 21, 22, 21, 23, 21, 22,
20, 21, 21, 21, 20, 20, 20, 20, 19, 19, 19, 18, 19, 18, 19, 18, 19, 17, 19, 17,
17, 16, 18, 16, 17, 16, 18, 14, 17, 15, 18, 13, 17, 13, 17, 12, 16, 12, 17, 12,
15, 12, 16, 11, 15, 11, 16, 10, 15, 9, 15, 9, 14, 8, 15, 8, 14, 7, 14, 8, 14, 7,
14, 7, 14, 6, 14, 6, 14, 6, 13, 6, 13, 5, 12, 5, 13, 4, 12, 4, 12, 4, 12, 4, 11,
3, 12, 3, 12, 2, 12, 2, 11, -1, 10, -18, 0, -60, -24, -97, -46, -105, -51, -106,
-51, -107, -52, -108, -52, -110, -53, -111, -53, -111, -54, -112, -54, -113,
-55, -113, -55, -115, -56, -115, -56, -115, -56, -116, -57, -116, -56, -117,
-56, -117, -57, -117, -56, -117, -56, -117, -56, -117, -57, -117, -56, -117,
-56, -117, -56, -117, -55, -116, -56, -117, -55, -116, -55, -115, -55, -115,
-54, -115, -54, -113, -54, -114, -53, -113, -53, -113, -53, -112, -51, -111,
-51, -111, -52, -110, -51, -109, -50, -109, -51, -108, -49, -108, -49, -107,
-49, -106, -49, -105, -47, -105, -47, -104, -47, -103, -46, -102, -45, -101,
-45, -101, -44, -100, -43, -99, -43, -98, -43, -97, -42, -96, -42, -95, -41,
-95, -40, -93, -40, -92, -39, -92, -39, -92, -38, -90, -36, -90, -36, -88, -36,
-87, -35, -86, -35, -85, -34, -84, -34, -83, -32, -82, -32, -82, -31, -80, -32,
-79, -30, -78, -29, -78, -29, -76, -28, -76, -28, -75, -27, -74, -26, -73, -26,
-72, -26, -71, -24, -70, -24, -68, -22, -68, -22, -67, -22, -66, -21, -65, -21,
-63, -20, -64, -20, -63, -19, -61, -18, -60, -17, -60, -16, -59, -15, -57, -15,
-57, -15, -56, -14, -54, -14, -54, -12, -54, -12, -53, -12, -52, -10, -50, -11,
-50, -10, -49, -8, -47, -9, -47, -8, -46, -8, -46, -7, -44, -6, -44, -6, -43,
-5, -42, -4, -41, -3, -40, -3, -39, -3, -39, -2, -38, -1, -37, -1, -36, -1, -36,
-1, -35, 0, -33, 2, -33, 1, -32, 2, -32, 3, -31, 3, -30, 4, -29, 4, -29, 5, -28,
5, -28, 5, -27, 7, -26, 7, -25, 8, -24, 9, -23, 9, -23, 8, -23, 9, -22, 10, -21,
11, -20, 11, -20, 12, -19, 12, -18, 13, -17, 13, -17, 13, -17, 14, -16, 15, -15,
16, -14, 16, -14, 15, -13, 17, -13, 17, -12, 18, -12, 18, -11, 19, -11, 19, -9,
19, -9, 22, -15, 4, -36, -46, -54, -87, -57, -97, -58, -97, -56, -98, -57, -97,
-56, -99, -57, -98, -55, -99, -56, -98, -56, -98, -55, -100, -55, -99, -55, -99,
-55, -100, -54, -100, -54, -100, -54, -101, -54, -101, -54, -101, -53, -102,
-54, -103, -53, -102, -53, -103, -52, -103, -53, -104, -52, -103, -52, -104,
-52, -104, -51, -105, -52, -105, -52, -105, -51, -106, -51, -106, -52, -106,
-52, -107, -51, -107, -51, -107, -51, -107, -51, -108, -51, -108, -50, -109,
-51, -110, -50, -110, -51, -111, -51, -111, -51, -111, -51, -112, -50, -113,
-49, -112, -51, -113, -50, -113, -51, -115, -50, -115, -51, -117, -44, -100,
-21, -49, -3, -8, };