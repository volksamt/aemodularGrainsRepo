#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0077

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 10, 55, 58, 105, 105, 112, 109,
102, 101, 94, 99, 88, 99, 84, 103, 80, 107, 77, 113, 75, 116, 73, 118, 72, 119,
71, 117, 70, 114, 69, 110, 69, 107, 67, 103, 66, 101, 66, 101, 65, 100, 65, 103,
64, 105, 64, 107, 63, 108, 62, 109, 63, 108, 63, 108, 62, 105, 62, 102, 61, 100,
62, 98, 62, 96, 62, 95, 62, 94, 62, 95, 63, 97, 62, 97, 63, 97, 63, 97, 63, 98,
64, 97, 64, 96, 65, 94, 65, 94, 65, 92, 66, 90, 65, 90, 66, 90, 66, 89, 67, 89,
67, 89, 67, 89, 67, 89, 67, 89, 68, 89, 68, 88, 68, 86, 68, 86, 68, 86, 68, 84,
68, 83, 68, 82, 68, 82, 69, 82, 68, 83, 68, 83, 68, 83, 67, 82, 68, 81, 68, 80,
67, 80, 66, 80, 66, 78, 65, 77, 65, 76, 65, 77, 64, 77, 64, 75, 64, 76, 64, 75,
62, 74, 61, 74, 61, 74, 61, 74, 61, 73, 59, 72, 59, 72, 61, 71, 61, 70, 60, 69,
59, 69, 58, 68, 56, 69, 56, 68, 54, 68, 53, 68, 52, 67, 51, 67, 51, 66, 50, 66,
49, 65, 48, 65, 48, 64, 47, 64, 46, 64, 45, 63, 45, 63, 45, 62, 43, 61, 43, 62,
43, 61, 27, 47, -28, -1, -79, -47, -83, -53, -71, -45, -62, -44, -55, -44, -50,
-48, -44, -53, -41, -58, -38, -63, -38, -66, -35, -66, -34, -65, -34, -62, -32,
-59, -32, -54, -32, -52, -30, -50, -30, -51, -30, -52, -29, -53, -28, -55, -28,
-58, -28, -60, -27, -61, -27, -60, -27, -60, -26, -57, -26, -55, -27, -53, -27,
-50, -27, -50, -27, -49, -27, -49, -28, -49, -28, -51, -28, -52, -28, -53, -29,
-54, -30, -54, -30, -53, -30, -52, -31, -52, -31, -50, -31, -49, -31, -48, -31,
-48, -32, -48, -33, -48, -32, -48, -34, -47, -34, -49, -33, -49, -35, -48, -35,
-49, -35, -48, -36, -48, -36, -47, -36, -47, -36, -45, -36, -45, -37, -44, -37,
-45, -37, -45, -37, -44, -37, -46, -37, -45, -38, -46, -38, -46, -37, -44, -38,
-44, -37, -44, -37, -43, -37, -43, -37, -43, -37, -41, -37, -42, -37, -42, -36,
-42, -36, -41, -36, -42, -36, -42, -36, -42, -34, -42, -35, -41, -35, -41, -34,
-40, -27, -41, -11, -42, -3, -43, -9, -43, -15, -41, -18, -40, -21, -40, -24,
-39, -26, -38, -27, -38, -29, -38, -30, -38, -29, -36, -30, -38, -31, -36, -30,
-35, -30, -36, -30, -36, -31, -35, -30, -34, -29, -35, -29, -35, -29, -35, -29,
-35, -28, -33, -27, -34, -27, -34, -27, -33, -27, -33, -27, -33, -26, -34, -25,
-32, -25, -32, -25, -32, -24, -33, -24, -32, -24, -31, -24, -31, -23, -32, -24,
-31, -23, -31, -23, -32, -23, -30, -22, -31, -23, -30, -23, -29, -22, -30, -23,
-30, -23, -30, -22, -30, -22, -29, -22, -29, -22, -29, -21, -29, -21, -30, -22,
-29, -22, -29, -22, -29, -22, -28, -22, -28, -22, -28, -22, -28, -21, -28, -21,
-28, -21, -28, -22, -27, -22, -27, -22, -26, -22, -26, -22, -27, -22, -26, -21,
-26, -19, -22, -17, -18, -16, -18, -19, -22, -21, -24, -22, -27, -24, -29, -24,
-29, -24, -30, -24, -30, -24, -29, -23, -27, -23, -28, -22, -27, -21, -25, -20,
-25, -20, -23, -19, -23, -19, -22, -18, -22, -18, -22, -18, -22, -18, -22, -18,
-22, -19, -22, -19, -23, -19, -22, -19, -23, -18, -23, -18, -23, -19, -22, -18,
-22, -18, -22, -17, -21, -18, -22, -17, -21, -17, -21, -17, -21, -17, -21, -18,
-20, -27, -20, -44, -17, -49, -16, -42, -17, -36, -17, -31, -17, -26, -18, -23,
-18, -20, -19, -18, -19, -16, -19, -14, -19, -13, -19, -11, -19, -11, -19, -10,
-19, -10, -19, -10, -18, -9, -18, -8, -18, -8, -19, -8, -19, -8, -17, -8, -18,
-7, -17, -8, -18, -8, -19, -8, -17, -8, -18, -7, -17, -8, -17, -8, -17, -8, -17,
-8, -16, -8, -17, -8, -16, -7, -17, -8, -17, -8, -17, -8, -16, -8, -16, -8, -16,
-9, -15, -8, -15, -8, -15, -9, -16, -8, -15, -8, -15, -9, -15, -8, -15, -9, -15,
-9, -15, -9, -15, -9, -15, -9, -15, -9, -15, -8, -14, -10, -15, -9, -14, -9,
-14, -9, -14, -8, -14, -9, -13, -10, -13, -10, -13, -9, -13, -10, -12, -9, -13,
-9, -12, -9, -13, -10, -13, -9, -13, -12, -18, -15, -20, -14, -20, -11, -15,
-10, -13, -8, -10, -7, -9, -6, -7, -6, -8, -5, -7, -5, -8, -6, -8, -7, -9, -8,
-9, -8, -10, -8, -11, -4, -12, 1, -12, 2, -13, 0, -13, -4, -12, -4, -12, -6,
-12, -6, -11, -7, -11, -8, -11, -8, -10, -7, -10, -7, -10, -8, -9, -9, -9, -8,
-10, -8, -10, -8, -10, -8, -9, -8, -9, -8, -9, -8, -10, -7, -9, -8, -9, -8, -9,
-7, -9, -8, -9, -8, -9, -7, -8, -8, -9, -7, -9, -7, -8, -7, -9, -7, -8, -6, -8,
-7, -8, -7, -8, -7, -8, -7, -8, -7, -8, -7, -8, -6, -7, -7, -7, -6, -7, -6, -8,
-6, -8, -6, -7, -6, -8, -6, -7, -6, -7, -5, -7, -6, -7, -6, -7, -5, -6, -5, -7,
-5, -7, -5, -6, -5, -7, -5, -6, -5, -7, -5, -6, -5, -6, -6, -6, -6, -6, -5, -7,
-6, -6, -4, -6, -5, -6, -4, -7, -5, -6, -4, -6, -5, -6, -5, -6, -4, -6, -5, -6,
-4, -6, -4, -5, -5, -5, -4, -6, -5, -6, -4, -5, -4, -5, -5, -6, -4, -6, -5, -5,
-5, -5, -4, -5, -4, -4, -3, -6, -4, -5, -3, -5, -4, -5, -3, -4, -4, -4, -3, -4,
-4, -4, -3, -5, -4, -4, -4, -4, -4, -5, -3, -4, -3, -4, -3, -3, -4, -4, -4, -4,
-3, -5, -3, -4, -3, -4, -3, -4, -2, -3, -3, -3, -3, -3, };