#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0101

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 17, 15, 4, 21, -16, 30, -24, 46,
-26, 65, -25, 83, -29, 93, -26, 99, -13, 92, 3, 77, 11, 62, 8, 48, 1, 42, -6,
40, -18, 38, -20, 38, -7, 37, 18, 36, 38, 47, 48, 51, 63, 51, 78, 47, 78, 37,
69, 28, 64, 18, 48, 8, 32, -3, 20, -9, 15, -10, 20, -8, 17, -6, 11, -5, 4, -8,
-8, -14, -33, -26, -56, -35, -77, -41, -85, -39, -78, -35, -80, -32, -77, -33,
-66, -31, -48, -22, -33, -12, -23, 1, -10, 11, 5, 20, 20, 23, 33, 23, 43, 25,
41, 23, 25, 14, 12, 3, 2, -17, 2, -31, -1, -34, -1, -24, 6, -4, 23, 14, 39, 34,
55, 48, 77, 55, 96, 49, 107, 39, 102, 21, 83, 5, 55, -11, 29, -24, 0, -26, -23,
-17, -46, -4, -71, 13, -86, 29, -87, 38, -83, 37, -68, 33, -58, 22, -50, 12,
-41, 1, -24, -14, -1, -17, 19, -16, 25, -14, 19, -15, 18, -16, 9, -24, 9, -33,
22, -51, 46, -62, 61, -66, 70, -68, 67, -65, 53, -59, 48, -54, 37, -54, 32, -51,
35, -53, 40, -43, 36, -29, 28, -14, 21, 6, 8, 21, -18, 30, -44, 30, -55, 25,
-50, 15, -46, 9, -45, 6, -49, 4, -63, 9, -80, 15, -94, 26, -90, 41, -85, 46,
-85, 46, -81, 47, -74, 53, -60, 48, -44, 48, -28, 43, -8, 38, 17, 41, 36, 37,
44, 35, 50, 29, 51, 17, 46, 8, 42, 2, 36, -7, 36, -11, 36, -11, 41, -8, 41, -8,
33, -3, 20, -3, 4, 2, -5, 11, -11, 17, -16, 17, -26, 13, -34, 5, -44, -3, -54,
-3, -64, -9, -67, -14, -76, -25, -81, -37, -83, -53, -81, -66, -72, -63, -62,
-48, -51, -29, -34, -12, -11, 0, 10, 9, 32, 9, 49, 0, 58, -11, 60, -16, 54, -16,
45, -8, 40, 0, 36, 6, 37, 16, 37, 20, 34, 27, 20, 41, 2, 57, -14, 60, -22, 60,
-23, 61, -25, 49, -20, 37, -15, 21, -21, 7, -40, -6, -65, -22, -82, -36, -83,
-41, -72, -40, -52, -28, -33, -14, -10, 3, 9, 18, 26, 22, 37, 20, 51, 20, 62,
14, 71, 2, 75, -10, 71, -18, 75, -18, 83, -13, 98, -8, 107, -1, 115, 5, 106, 4,
96, 5, 84, 1, 66, -2, 46, 0, 23, 1, 3, 0, -11, -7, -16, -17, -30, -29, -39, -40,
-49, -54, -41, -70, -35, -86, -32, -100, -29, -100, -18, -86, -20, -67, -31,
-43, -46, -23, -60, -5, -58, 6, -44, 13, -21, 16, -5, 18, 6, 19, 8, 16, 17, 12,
22, 10, 22, 9, 15, 11, 8, 17, -2, 26, -10, 30, -19, 34, -30, 38, -27, 41, -27,
44, -25, 36, -23, 23, -20, 9, -22, -5, -20, -16, -20, -17, -17, -13, -20, -7,
-27, -2, -34, -2, -40, -9, -57, -22, -85, -39, -108, -46, -119, -38, -99, -25,
-66, -8, -38, 9, -19, 18, -7, 17, -6, 14, 0, 13, 7, 15, 8, 18, 10, 22, 15, 29,
17, 36, 14, 40, 17, 50, 11, 60, 14, 71, 23, 85, 37, 94, 62, 95, 76, 83, 85, 63,
94, 39, 93, 17, 78, -2, 59, -11, 48, -17, 37, -17, 24, -14, 1, -9, -29, -5, -51,
2, -63, 4, -61, 1, -46, -3, -26, -12, -13, -26, -3, -34, 1, -45, -4, -49, -8,
-49, -11, -46, -24, -24, -17, 3, -14, 25, -18, 45, -16, 60, -9, 65, 1, 65, 15,
58, 29, 50, 39, 37, 46, 23, 43, 12, 45, 1, 43, -4, 33, -6, 24, -2, 25, 3, 16, 7,
13, 10, 10, 10, 5, 6, -4, 3, -20, 0, -25, -4, -26, -5, -24, -4, -28, -5, -25,
-7, -32, -16, -46, -28, -61, -44, -78, -49, -84, -43, -71, -31, -61, -17, -48,
-1, -26, 15, -7, 21, 7, 20, 10, 19, 12, 18, 14, 26, 4, 33, -10, 34, -19, 27,
-31, 15, -39, -6, -41, -21, -31, -21, -15, -12, 0, 4, 18, 18, 33, 37, 34, 47,
27, 48, 9, 39, -10, 33, -22, 23, -32, 15, -39, 5, -38, -4, -27, -25, -9, -49, 8,
-76, 18, -85, 31, -74, 48, -56, 60, -32, 68, -12, 77, 6, 82, 6, 82, -3, 77, -13,
68, -16, 46, -16, 13, -16, -25, -18, -52, -19, -58, -23, -49, -26, -38, -29,
-26, -28, -13, -29, -10, -18, -20, -7, -30, -1, -37, -1, -40, -13, -40, -32,
-31, -53, -3, -62, 16, -61, 24, -53, 33, -54, 47, -52, 56, -58, 59, -59, 61,
-59, 59, -54, 60, -44, 52, -31, 46, -17, 42, -12, 38, -4, 33, 3, 30, 11, 33, 14,
40, 17, 56, 21, 61, 23, 64, 21, 60, 22, 51, 22, 31, 20, 12, 14, -1, 18, -14, 24,
-22, 27, -30, 24, -30, 23, -30, 17, -20, 15, -6, 16, 11, 12, 32, 10, 57, 4, 79,
-9, 99, -28, 103, -40, 91, -32, 67, -8, 45, 22, 25, 46, 6, 65, -8, 69, -23, 61,
-35, 49, -44, 35, -46, 28, -48, 20, -41, 10, -42, -3, -49, -4, -60, -8, -74,
-15, -87, -13, -100, -11, -99, -3, -93, 0, -88, 9, -79, 19, -71, 22, -68, 13,
-67, 0, -61, -7, -48, -18, -33, -30, -19, -43, -9, -42, 0, -36, 0, -30, -2, -22,
0, -8, 2, 7, 4, 10, 9, 10, 11, 8, 10, 0, 17, -8, 17, -19, 19, -22, 7, -26, -6,
-34, -20, -41, -26, -42, -21, -31, -12, -25, -3, -24, 2, -27, 2, -28, -8, -36,
-22, -45, -35, -47, -38, -47, -30, -51, -23, -56, -17, -59, -10, -62, -4, -58,
10, -61, 27, -55, 46, -44, 55, -32, 66, -20, 63, -9, 50, -2, 23, -1, -17, 0,
-45, -6, -65, -9, -50, -9, -21, -12, 19, -15, 56, -10, 92, -15, 98, -21, 87,
-21, 65, -15, 34, 3, 21, 22, 21, 33, 26, 48, 26, 58, 25, 55, 23, 48, 25, 31, 27,
18, 35, 3, 45, -6, 43, -9, 41, -2, 27, };