#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0162

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, -28, 5, -31, 8, -26, 10, -24, 13,
-20, 15, -19, 17, -14, 21, -12, 24, -8, 26, -6, 29, -3, 32, 0, 34, 4, 36, 6, 38,
9, 42, 12, 44, 15, 46, 17, 49, 21, 51, 23, 53, 25, 55, 28, 58, 31, 61, 33, 63,
36, 65, 38, 67, 40, 70, 44, 71, 47, 74, 49, 76, 51, 78, 53, 80, 55, 82, 58, 84,
60, 86, 62, 87, 65, 90, 67, 90, 69, 92, 71, 94, 73, 96, 75, 98, 76, 99, 78, 101,
80, 102, 83, 103, 84, 105, 86, 106, 87, 108, 90, 109, 91, 111, 93, 112, 94, 113,
97, 114, 98, 115, 100, 116, 100, 116, 101, 117, 102, 117, 104, 117, 105, 119,
106, 118, 107, 119, 107, 119, 109, 120, 108, 119, 110, 118, 110, 120, 111, 119,
112, 119, 112, 118, 112, 118, 113, 118, 114, 117, 114, 117, 114, 115, 115, 115,
115, 114, 115, 113, 115, 112, 115, 111, 115, 111, 115, 109, 115, 109, 115, 107,
115, 106, 116, 106, 115, 104, 115, 102, 115, 102, 115, 101, 115, 100, 115, 99,
114, 98, 114, 97, 114, 95, 114, 93, 114, 92, 113, 91, 113, 90, 113, 89, 113, 87,
113, 86, 112, 86, 111, 84, 111, 83, 111, 82, 111, 80, 111, 79, 110, 78, 110, 77,
109, 75, 108, 74, 108, 73, 108, 72, 107, 70, 107, 70, 106, 68, 106, 67, 106, 67,
106, 66, 105, 65, 104, 63, 105, 62, 105, 61, 103, 60, 104, 59, 103, 58, 102, 57,
103, 56, 101, 55, 101, 55, 101, 53, 101, 52, 100, 51, 101, 51, 100, 50, 99, 49,
100, 49, 98, 48, 98, 47, 98, 46, 98, 45, 97, 45, 97, 43, 97, 43, 97, 43, 96, 42,
96, 41, 95, 40, 96, 40, 95, 39, 95, 39, 94, 37, 93, 37, 93, 37, 93, 36, 93, 36,
93, 36, 92, 35, 92, 35, 92, 34, 92, 34, 92, 33, 91, 32, 92, 31, 91, 31, 91, 31,
90, 31, 90, 30, 91, 30, 90, 30, 89, 29, 89, 29, 89, 28, 89, 28, 89, 28, 89, 28,
88, 27, 87, 26, 86, 26, 86, 25, 86, 24, 84, 25, 84, 23, 83, 22, 81, 21, 80, 21,
79, 20, 78, 19, 76, 18, 74, 17, 73, 16, 71, 14, 69, 14, 67, 13, 65, 12, 63, 10,
62, 9, 60, 8, 58, 7, 56, 6, 54, 5, 52, 3, 50, 2, 48, 0, 45, 0, 42, -2, 42, -3,
38, -4, 37, -5, 34, -7, 32, -8, 30, -10, 27, -11, 25, -11, 23, -14, 20, -14, 18,
-16, 15, -18, 14, -18, 11, -20, 9, -20, 8, -21, 5, -23, 4, -23, 2, -25, 1, -25,
-1, -26, -2, -26, -3, -27, -4, -28, -6, -28, -6, -28, -8, -28, -8, -29, -9, -29,
-9, -29, -10, -29, -10, -29, -11, -30, -11, -29, -11, -29, -11, -29, -11, -29,
-10, -29, -11, -29, -10, -29, -10, -29, -10, -27, -10, -27, -9, -26, -8, -26,
-8, -26, -8, -25, -7, -25, -5, -25, -5, -23, -4, -23, -4, -23, -3, -22, -2, -21,
-1, -20, 0, -20, 0, -19, 2, -19, 3, -18, 4, -17, 5, -16, 7, -16, 8, -15, 9, -15,
9, -14, 9, -13, 10, -13, 10, -13, 11, -13, 11, -13, 12, -13, 12, -11, 12, -13,
11, -12, 11, -12, 12, -13, 12, -12, 12, -11, 11, -12, 12, -11, 11, -12, 10, -12,
8, -13, 8, -13, 8, -13, 7, -14, 6, -13, 6, -14, 4, -14, 4, -15, 3, -15, 1, -16,
0, -17, 0, -17, -2, -18, -3, -19, -4, -19, -7, -19, -7, -20, -9, -21, -9, -21,
-12, -22, -12, -23, -13, -24, -15, -24, -17, -24, -18, -25, -19, -27, -21, -27,
-22, -28, -23, -29, -24, -29, -26, -30, -27, -30, -29, -32, -30, -32, -33, -33,
-33, -34, -34, -34, -36, -35, -37, -35, -39, -35, -40, -37, -42, -38, -42, -38,
-43, -40, -45, -39, -47, -40, -48, -41, -49, -42, -50, -42, -52, -43, -53, -43,
-55, -43, -56, -45, -57, -45, -58, -46, -59, -47, -60, -46, -62, -48, -62, -49,
-64, -48, -65, -49, -66, -49, -67, -49, -67, -50, -69, -51, -70, -51, -71, -52,
-72, -53, -73, -53, -74, -52, -75, -54, -75, -54, -76, -55, -78, -54, -78, -55,
-79, -56, -80, -56, -81, -56, -81, -56, -82, -57, -83, -57, -84, -57, -84, -58,
-85, -58, -85, -59, -86, -59, -87, -60, -88, -59, -88, -60, -89, -61, -89, -60,
-89, -61, -90, -60, -91, -61, -91, -62, -92, -61, -92, -62, -93, -61, -93, -61,
-94, -63, -94, -62, -94, -62, -95, -63, -95, -62, -96, -62, -97, -63, -97, -63,
-98, -64, -97, -63, -97, -64, -98, -64, -98, -63, -99, -63, -98, -63, -99, -64,
-100, -64, -100, -64, -100, -64, -100, -65, -101, -64, -101, -64, -101, -65,
-101, -65, -102, -64, -102, -65, -102, -65, -102, -64, -102, -65, -103, -65,
-103, -65, -102, -65, -102, -65, -103, -65, -104, -65, -103, -65, -103, -66,
-103, -65, -103, -65, -104, -65, -103, -65, -103, -66, -104, -65, -104, -65,
-105, -65, -104, -64, -105, -65, -104, -65, -105, -65, -105, -65, -104, -65,
-104, -65, -104, -64, -104, -65, -104, -64, -105, -64, -104, -65, -104, -64,
-105, -64, -105, -65, -105, -65, -105, -63, -104, -64, -105, -64, -104, -65,
-104, -64, -104, -65, -104, -63, -104, -64, -105, -63, -103, -64, -104, -64,
-105, -64, -104, -64, -104, -63, -104, -64, -104, -63, -105, -63, -104, -64,
-104, -63, -104, -62, -103, -62, -104, -64, -104, -63, -104, -63, -103, -62,
-104, -63, -104, -62, -104, -62, -102, -61, -102, -61, -101, -60, -100, -59,
-99, -58, -99, -57, -97, -56, -95, -54, -94, -53, -93, -52, -90, -49, -90, -49,
-88, -46, -86, -45, -84, -43, -82, -41, -79, -40, -77, -37, -76, -35, -73, -33,
-71, -30, -67, -28, -66, -26, -63, -22, -60, -20, -56, -18, -55, -16, -52, -14,
-50, -11, -45, -7, -45, -6, -39, -3, -39, 0, -30, };