#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 29, 2, 34, 3, 34, 4, 36, 5, 36, 7,
38, 8, 38, 9, 40, 11, 41, 12, 42, 13, 43, 15, 44, 15, 45, 17, 45, 18, 47, 19,
49, 21, 48, 23, 50, 24, 51, 25, 52, 26, 53, 27, 54, 28, 55, 29, 56, 30, 57, 31,
58, 33, 60, 34, 60, 35, 62, 36, 62, 38, 63, 39, 64, 40, 65, 41, 66, 42, 67, 44,
67, 45, 69, 46, 69, 47, 71, 48, 71, 50, 72, 51, 73, 53, 74, 53, 75, 54, 76, 56,
77, 56, 77, 58, 78, 59, 79, 60, 80, 61, 81, 62, 81, 63, 83, 64, 83, 66, 83, 66,
85, 67, 85, 69, 86, 69, 87, 71, 87, 72, 89, 73, 88, 74, 90, 75, 91, 76, 91, 78,
92, 79, 92, 80, 94, 81, 94, 82, 95, 82, 95, 84, 96, 85, 97, 87, 98, 86, 98, 87,
99, 89, 99, 90, 100, 91, 100, 92, 101, 93, 102, 93, 101, 95, 103, 96, 103, 97,
104, 96, 104, 98, 106, 99, 106, 100, 107, 100, 106, 102, 108, 102, 108, 103,
109, 104, 108, 106, 109, 106, 110, 106, 111, 108, 111, 108, 111, 110, 111, 110,
112, 112, 113, 111, 111, 113, 115, 112, 111, 116, 117, 112, 110, 122, 123, 90,
79, 68, 51, 72, 72, 59, 71, 62, 87, 55, 80, 53, 74, 49, 61, 50, 61, 51, 61, 52,
60, 52, 56, 53, 53, 55, 55, 56, 57, 57, 56, 58, 53, 59, 52, 60, 53, 62, 54, 63,
52, 65, 51, 64, 51, 66, 52, 66, 52, 67, 51, 68, 50, 68, 52, 69, 50, 69, 51, 69,
49, 69, 50, 69, 49, 70, 49, 69, 49, 70, 47, 69, 48, 70, 47, 69, 47, 69, 46, 68,
46, 68, 45, 67, 45, 67, 43, 66, 44, 65, 43, 65, 43, 64, 42, 63, 42, 63, 41, 62,
40, 61, 39, 61, 38, 61, 38, 60, 37, 59, 38, 59, 36, 58, 36, 58, 35, 57, 35, 56,
33, 56, 33, 54, 32, 55, 32, 54, 32, 53, 31, 52, 31, 51, 29, 50, 29, 50, 29, 50,
28, 49, 28, 48, 27, 48, 26, 48, 25, 47, 24, 47, 25, 46, 25, 46, 25, 45, 23, 46,
24, 45, 21, 47, 22, 44, 20, 46, 23, 44, 20, 45, 22, 43, 19, 45, 21, 42, 18, 45,
20, 43, 19, 44, 20, 43, 17, 43, 18, 44, 18, 44, 17, 44, 19, 43, 15, 45, 18, 41,
15, 47, 20, 40, 13, 49, 23, 39, 9, 53, 26, 33, 4, 62, 37, 6, -33, -26, -68, 3,
-12, -42, -49, -22, -15, -42, -39, -39, -44, -49, -62, -47, -56, -48, -57, -49,
-61, -50, -67, -50, -71, -47, -68, -48, -67, -46, -68, -48, -74, -44, -72, -44,
-73, -41, -69, -42, -74, -39, -71, -41, -74, -36, -69, -36, -72, -35, -71, -36,
-73, -32, -70, -33, -71, -30, -70, -31, -71, -29, -70, -30, -69, -28, -69, -28,
-69, -28, -69, -29, -68, -29, -69, -28, -67, -29, -67, -28, -68, -29, -68, -30,
-67, -29, -68, -30, -67, -31, -68, -31, -67, -33, -67, -32, -67, -34, -67, -34,
-67, -34, -67, -35, -68, -36, -68, -37, -68, -38, -68, -39, -68, -39, -68, -40,
-69, -41, -68, -42, -68, -42, -69, -42, -68, -44, -68, -44, -68, -45, -69, -46,
-69, -46, -68, -47, -68, -47, -68, -47, -69, -49, -68, -49, -69, -49, -68, -50,
-69, -51, -68, -50, -69, -51, -69, -51, -69, -50, -68, -52, -69, -52, -67, -51,
-68, -52, -67, -51, -67, -52, -67, -52, -67, -51, -67, -51, -66, -51, -65, -50,
-64, -50, -64, -50, -65, -50, -64, -49, -62, -50, -64, -49, -63, -48, -63, -48,
-61, -48, -61, -48, -61, -47, -60, -46, -59, -46, -58, -46, -58, -44, -57, -44,
-57, -44, -56, -43, -55, -42, -54, -42, -54, -40, -53, -40, -52, -40, -51, -39,
-50, -38, -50, -37, -49, -37, -48, -36, -47, -35, -46, -33, -45, -33, -44, -32,
-43, -32, -43, -30, -41, -30, -41, -28, -38, -28, -38, -26, -36, -27, -36, -24,
-34, -25, -35, -23, -32, -23, -33, -22, -30, -20, -30, -19, -27, -18, -28, -17,
-26, -17, -25, -15, -24, -15, -23, -13, -22, -11, -20, -12, -20, -8, -16, -12,
-20, -1, -7, -41, -58, -59, -79, -57, -58, -70, -58, -66, -42, -72, -49, -74,
-55, -78, -66, -75, -64, -76, -65, -75, -63, -76, -69, -73, -69, -71, -67, -70,
-65, -68, -65, -67, -66, -65, -64, -64, -63, -62, -61, -61, -62, -60, -61, -60,
-61, -58, -58, -57, -58, -55, -56, -55, -57, -54, -56, -53, -55, -52, -53, -52,
-54, -51, -53, -50, -52, -50, -50, -49, -51, -50, -50, -50, -49, -49, -48, -48,
-48, -48, -47, -49, -46, -49, -47, -48, -45, -48, -44, -49, -43, -49, -43, -49,
-43, -50, -41, -49, -42, -50, -41, -50, -41, -50, -40, -50, -40, -51, -39, -50,
-39, -51, -37, -51, -37, -52, -37, -52, -37, -51, -36, -51, -35, -51, -35, -53,
-35, -53, -35, -53, -33, -53, -33, -53, -33, -54, -31, -53, -31, -53, -31, -54,
-30, -54, -29, -54, -29, -54, -29, -53, -28, -53, -26, -53, -27, -53, -26, -53,
-25, -53, -25, -52, -24, -54, -23, -53, -24, -53, -23, -53, -21, -53, -21, -52,
-21, -51, -20, -51, -19, -51, -19, -50, -18, -51, -18, -51, -17, -50, -17, -50,
-15, -49, -15, -48, -14, -48, -13, -48, -13, -47, -11, -46, -11, -45, -10, -44,
-9, -44, -8, -44, -8, -44, -7, -42, -6, -41, -6, -41, -6, -41, -4, -40, -3, -39,
-2, -38, -2, -37, -1, -36, -1, -35, 1, -34, 1, -34, 2, -32, 4, -31, 4, -31, 5,
-30, 6, -29, 8, -28, 8, -27, 9, -25, 10, -25, 10, -23, 12, -22, 13, -22, 14,
-20, 14, -20, 15, -18, 16, -16, 17, -16, 19, -15, 20, -14, 20, -13, 21, -11, 23,
-11, 22, -9, 24, -8, 25, -6, 27, -5, 27, -3, 29, -2, 28, -2, 33, 0, 27, };