#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0075

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 5, 3, 6, 4, 8, 6, 9, 8, 10,
9, 12, 11, 13, 12, 15, 13, 17, 15, 18, 16, 19, 18, 20, 19, 22, 21, 24, 22, 25,
23, 26, 25, 28, 26, 29, 28, 31, 29, 32, 30, 33, 31, 35, 32, 36, 34, 38, 36, 39,
37, 40, 38, 42, 39, 43, 42, 45, 42, 45, 43, 48, 45, 49, 46, 50, 48, 51, 49, 53,
50, 54, 51, 56, 53, 57, 54, 58, 55, 59, 56, 61, 57, 62, 59, 63, 61, 65, 61, 66,
63, 67, 64, 68, 65, 70, 66, 70, 67, 72, 69, 73, 69, 75, 72, 75, 73, 76, 73, 77,
74, 79, 75, 79, 76, 82, 77, 82, 79, 83, 80, 84, 81, 85, 81, 87, 83, 87, 83, 88,
84, 89, 85, 90, 87, 91, 87, 92, 89, 93, 89, 94, 89, 95, 91, 95, 92, 96, 93, 98,
93, 99, 94, 99, 95, 100, 96, 100, 96, 102, 98, 103, 98, 103, 99, 103, 99, 105,
100, 105, 101, 105, 102, 107, 103, 108, 103, 107, 104, 108, 104, 109, 105, 110,
105, 110, 106, 111, 107, 112, 107, 112, 108, 113, 108, 113, 108, 114, 110, 114,
109, 113, 110, 114, 110, 115, 111, 115, 111, 116, 111, 116, 112, 116, 112, 117,
112, 117, 113, 118, 113, 117, 114, 117, 114, 117, 113, 118, 114, 117, 114, 118,
114, 118, 115, 119, 114, 119, 115, 118, 114, 119, 115, 119, 114, 119, 116, 119,
116, 119, 115, 119, 115, 119, 115, 119, 115, 119, 115, 118, 115, 119, 116, 118,
115, 119, 115, 118, 116, 118, 115, 119, 115, 117, 114, 118, 114, 118, 114, 118,
113, 118, 114, 117, 114, 117, 113, 116, 113, 116, 113, 116, 113, 116, 113, 116,
113, 115, 112, 115, 112, 114, 110, 113, 110, 114, 111, 113, 110, 112, 110, 112,
108, 112, 109, 112, 107, 111, 107, 109, 107, 110, 107, 109, 106, 108, 105, 107,
105, 107, 103, 106, 103, 105, 101, 106, 101, 104, 101, 103, 100, 102, 100, 102,
99, 101, 98, 100, 98, 100, 96, 98, 95, 98, 95, 97, 95, 96, 93, 95, 93, 94, 91,
93, 90, 92, 89, 91, 89, 90, 88, 89, 87, 89, 86, 88, 85, 86, 84, 85, 83, 84, 82,
83, 80, 81, 80, 81, 79, 80, 77, 78, 77, 77, 75, 76, 75, 76, 73, 74, 73, 74, 71,
71, 71, 71, 69, 69, 68, 68, 67, 68, 65, 66, 65, 64, 63, 63, 62, 62, 61, 61, 59,
60, 59, 57, 57, 57, 56, 55, 55, 54, 53, 53, 52, 51, 51, 50, 49, 48, 48, 47, 47,
45, 45, 44, 45, 43, 43, 41, 41, 41, 41, 39, 38, 38, 37, 36, 36, 35, 35, 33, 34,
33, 32, 31, 32, 29, 30, 28, 28, 26, 27, 25, 25, 23, 24, 22, 23, 20, 21, 19, 20,
17, 18, 16, 17, 14, 16, 14, 13, 11, 12, 11, 11, 9, 10, 8, 8, 5, 8, 4, 5, 2, 4,
1, 2, 0, 1, -2, 0, -3, -1, -5, -3, -7, -5, -7, -6, -9, -7, -10, -10, -12, -11,
-13, -12, -14, -14, -16, -15, -18, -16, -20, -17, -21, -19, -23, -21, -24, -22,
-25, -24, -27, -25, -29, -26, -29, -27, -30, -28, -32, -30, -33, -32, -35, -33,
-36, -35, -38, -35, -39, -37, -40, -38, -42, -40, -43, -40, -45, -42, -46, -44,
-47, -46, -49, -46, -49, -48, -51, -48, -53, -50, -54, -52, -56, -53, -56, -55,
-58, -55, -60, -56, -61, -58, -61, -59, -63, -60, -65, -62, -66, -63, -67, -65,
-68, -64, -70, -66, -71, -67, -72, -68, -73, -70, -74, -71, -75, -73, -77, -73,
-78, -74, -79, -76, -80, -76, -81, -77, -82, -79, -83, -79, -85, -81, -85, -81,
-87, -82, -87, -84, -88, -85, -90, -86, -90, -87, -91, -87, -93, -88, -93, -90,
-94, -90, -95, -91, -97, -92, -97, -93, -98, -94, -99, -94, -100, -95, -101,
-97, -101, -97, -102, -98, -102, -99, -103, -99, -104, -100, -105, -101, -106,
-101, -106, -103, -108, -103, -108, -103, -108, -104, -109, -105, -109, -105,
-110, -106, -111, -106, -112, -107, -112, -108, -112, -108, -113, -108, -114,
-109, -114, -110, -114, -110, -114, -110, -115, -110, -115, -111, -115, -112,
-116, -112, -116, -112, -116, -112, -117, -112, -117, -112, -117, -113, -117,
-114, -118, -114, -117, -115, -117, -114, -118, -114, -119, -115, -118, -114,
-118, -114, -119, -115, -119, -115, -119, -115, -119, -114, -118, -115, -120,
-115, -118, -116, -119, -115, -118, -116, -119, -115, -119, -116, -119, -115,
-119, -115, -119, -116, -119, -116, -119, -115, -118, -115, -119, -115, -119,
-115, -118, -114, -118, -114, -118, -114, -118, -114, -117, -113, -117, -113,
-116, -113, -117, -113, -116, -112, -115, -112, -115, -111, -114, -112, -115,
-112, -114, -111, -114, -111, -114, -110, -113, -109, -113, -109, -112, -109,
-112, -108, -111, -108, -111, -108, -110, -107, -109, -106, -108, -105, -108,
-105, -107, -105, -107, -104, -106, -103, -105, -102, -104, -101, -104, -100,
-103, -101, -102, -99, -102, -99, -100, -97, -100, -98, -99, -97, -99, -95, -98,
-95, -96, -94, -96, -93, -95, -92, -94, -91, -92, -90, -92, -89, -91, -89, -90,
-88, -89, -87, -88, -85, -86, -84, -86, -84, -85, -83, -84, -82, -83, -81, -81,
-80, -81, -79, -79, -77, -79, -77, -77, -76, -76, -75, -76, -74, -74, -72, -73,
-72, -71, -69, -71, -69, -70, -68, -68, -66, -67, -65, -65, -64, -64, -62, -63,
-62, -62, -61, -61, -59, -60, -59, -57, -57, -57, -56, -56, -55, -54, -53, -53,
-52, -51, -51, -50, -49, -48, -48, -47, -47, -47, -46, -45, -45, -44, -43, -42,
-41, -40, -40, -39, -39, -38, -38, -37, -36, -35, -35, -33, -33, -31, -32, -31,
-31, -29, -29, -27, -28, -26, -27, -24, -26, -23, -23, -22, -22, -20, -22, -19,
-19, -17, -18, -16, -17, -14, -15, -13, -13, -11, -13, -10, -11, -8, -10, -7,
-8, -6, -7, -4, -5, -2, -4, -2, -3, 1, -1, 2, };