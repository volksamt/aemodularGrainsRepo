#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0194

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 18, 7, 27, 12, 29, 16, 35, 19, 39,
23, 44, 27, 47, 32, 53, 35, 55, 38, 61, 41, 64, 45, 67, 47, 71, 51, 74, 53, 79,
57, 82, 60, 85, 63, 87, 65, 91, 67, 93, 69, 96, 72, 99, 74, 100, 76, 102, 77,
104, 79, 106, 81, 108, 83, 110, 84, 111, 86, 113, 87, 114, 89, 115, 90, 116, 91,
117, 92, 118, 93, 119, 94, 119, 95, 119, 96, 118, 96, 119, 96, 120, 98, 119, 98,
118, 98, 118, 99, 118, 99, 116, 99, 115, 99, 115, 100, 112, 100, 111, 99, 111,
99, 109, 99, 106, 99, 105, 99, 103, 98, 102, 98, 98, 98, 97, 97, 94, 97, 92, 96,
90, 96, 87, 94, 85, 94, 82, 93, 80, 92, 77, 91, 74, 91, 71, 90, 69, 88, 66, 87,
63, 87, 60, 84, 58, 84, 54, 82, 51, 81, 49, 79, 45, 78, 42, 76, 39, 75, 36, 72,
33, 71, 30, 69, 27, 68, 24, 67, 21, 64, 18, 63, 17, 60, 13, 59, 11, 56, 8, 55,
6, 53, 3, 50, 0, 49, -2, 46, -4, 45, -6, 43, -8, 40, -11, 39, -14, 37, -16, 35,
-18, 33, -19, 29, -22, 28, -23, 26, -25, 23, -27, 21, -29, 19, -31, 17, -32, 14,
-34, 12, -36, 10, -37, 8, -39, 6, -41, 3, -42, 1, -43, -1, -44, -4, -45, -6,
-48, -8, -48, -10, -50, -12, -51, -14, -51, -16, -53, -18, -53, -20, -54, -20,
-54, -23, -55, -24, -55, -27, -55, -27, -56, -29, -55, -30, -56, -31, -57, -33,
-56, -34, -56, -35, -56, -36, -55, -37, -54, -37, -54, -39, -53, -39, -53, -40,
-52, -41, -51, -41, -50, -40, -49, -41, -47, -42, -47, -41, -46, -41, -44, -40,
-43, -41, -41, -40, -40, -40, -39, -40, -37, -38, -36, -38, -34, -38, -33, -37,
-31, -37, -28, -36, -27, -36, -25, -34, -23, -33, -21, -32, -20, -31, -17, -30,
-16, -29, -14, -29, -11, -28, -10, -27, -8, -26, -6, -25, -5, -25, -3, -24, -2,
-24, 0, -23, 1, -23, 4, -22, 5, -22, 6, -20, 7, -21, 8, -20, 9, -20, 12, -19,
12, -19, 13, -18, 14, -18, 15, -19, 17, -18, 17, -18, 18, -18, 20, -18, 20, -18,
21, -18, 20, -18, 21, -19, 21, -19, 21, -19, 22, -19, 23, -20, 23, -20, 23, -20,
23, -20, 24, -21, 24, -22, 24, -22, 24, -22, 24, -22, 23, -23, 22, -23, 23, -24,
22, -24, 22, -24, 21, -24, 21, -25, 20, -26, 20, -26, 19, -26, 19, -26, 19, -26,
18, -26, 16, -27, 16, -27, 16, -27, 14, -28, 15, -28, 13, -28, 12, -28, 13, -28,
11, -28, 10, -27, 11, -28, 10, -27, 8, -27, 8, -28, 7, -27, 7, -27, 7, -26, 6,
-26, 5, -25, 5, -25, 4, -25, 4, -24, 3, -23, 3, -23, 3, -22, 2, -22, 2, -22, 2,
-20, 0, -20, 0, -19, 1, -18, 1, -17, -1, -17, 0, -17, -1, -15, -1, -14, -2, -14,
-2, -14, -2, -13, -2, -13, -3, -12, -3, -11, -4, -11, -3, -10, -4, -9, -5, -9,
-4, -8, -6, -8, -6, -7, -7, -7, -7, -6, -7, -5, -8, -6, -8, -6, -8, -4, -10, -3,
-11, -3, -10, -4, -11, -3, -13, -3, -12, -2, -14, -1, -14, -2, -15, -1, -17, 0,
-17, 0, -17, 0, -18, 0, -19, 1, -19, 1, -21, 1, -22, 2, -22, 2, -22, 3, -23, 4,
-24, 5, -25, 5, -26, 5, -25, 6, -26, 7, -26, 7, -27, 8, -28, 9, -28, 10, -28,
11, -28, 11, -29, 12, -29, 13, -29, 14, -28, 15, -29, 16, -28, 18, -28, 19, -27,
19, -28, 21, -27, 22, -26, 24, -25, 25, -25, 26, -24, 28, -23, 28, -22, 31, -21,
32, -20, 33, -18, 35, -17, 37, -16, 39, -14, 40, -12, 41, -10, 44, -8, 45, -7,
47, -4, 49, -2, 51, -1, 53, 1, 55, 3, 56, 6, 58, 9, 59, 10, 61, 12, 61, 15, 64,
17, 64, 18, 66, 21, 67, 23, 67, 25, 68, 27, 69, 30, 70, 31, 70, 33, 72, 35, 72,
37, 73, 39, 73, 41, 73, 43, 73, 45, 74, 47, 75, 48, 74, 51, 73, 51, 73, 53, 72,
55, 73, 55, 71, 57, 71, 58, 70, 60, 70, 60, 69, 60, 68, 61, 67, 62, 67, 62, 66,
62, 64, 62, 62, 62, 60, 62, 58, 63, 56, 61, 55, 62, 53, 61, 51, 61, 49, 60, 47,
60, 45, 59, 43, 57, 41, 57, 39, 56, 37, 55, 34, 53, 32, 51, 29, 50, 26, 48, 24,
47, 21, 45, 19, 43, 17, 41, 13, 39, 10, 37, 8, 35, 7, 33, 3, 30, 1, 28, -2, 26,
-4, 23, -7, 21, -10, 18, -13, 16, -15, 12, -18, 9, -20, 7, -22, 4, -26, 1, -28,
-2, -32, -5, -34, -9, -35, -11, -39, -14, -42, -17, -44, -20, -46, -23, -49,
-27, -53, -30, -55, -32, -56, -36, -59, -39, -61, -41, -64, -45, -67, -48, -69,
-50, -71, -54, -73, -56, -75, -59, -77, -62, -79, -65, -82, -68, -84, -69, -85,
-72, -87, -75, -90, -77, -91, -80, -93, -82, -94, -84, -96, -87, -98, -89, -100,
-91, -101, -94, -103, -95, -104, -98, -106, -100, -106, -101, -108, -103, -109,
-105, -110, -106, -112, -108, -112, -110, -114, -111, -114, -112, -116, -113,
-116, -113, -116, -115, -117, -115, -118, -116, -119, -117, -119, -117, -119,
-118, -118, -118, -118, -118, -118, -118, -118, -118, -117, -117, -117, -117,
-117, -116, -117, -116, -116, -115, -116, -113, -114, -113, -113, -111, -112,
-111, -111, -110, -109, -107, -107, -104, -106, -104, -104, -101, -102, -98,
-100, -96, -98, -93, -95, -91, -93, -88, -91, -84, -88, -81, -84, -77, -82, -74,
-79, -70, -75, -66, -71, -62, -68, -58, -63, -54, -59, -49, -55, -45, -51, -40,
-47, -35, -42, -29, -37, -24, -32, -19, -28, -13, -22, -8, -18, -4, -13, 3, -9,
5, -5, 13, -1, 13, };