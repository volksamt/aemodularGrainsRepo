#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0150

const PROGMEM int8_t DATA[DATA_LENGTH] = {-96, -91, -120, -111, -92, -92, -97,
-97, -91, -92, -98, -96, -94, -93, -97, -96, -95, -93, -97, -95, -94, -92, -96,
-93, -93, -91, -93, -92, -90, -90, -89, -90, -88, -88, -87, -88, -86, -86, -84,
-86, -83, -85, -81, -83, -79, -82, -78, -82, -77, -81, -75, -80, -74, -79, -74,
-77, -72, -77, -70, -75, -70, -75, -68, -75, -67, -74, -66, -73, -66, -73, -64,
-71, -64, -71, -62, -70, -62, -69, -61, -69, -60, -69, -60, -68, -59, -67, -58,
-67, -57, -66, -57, -66, -56, -65, -56, -64, -55, -64, -54, -63, -54, -63, -54,
-63, -54, -62, -53, -62, -53, -62, -52, -61, -51, -61, -51, -61, -51, -60, -51,
-60, -50, -60, -49, -59, -49, -59, -49, -58, -49, -58, -48, -58, -48, -57, -48,
-57, -48, -57, -47, -56, -48, -56, -47, -55, -47, -55, -47, -55, -46, -54, -46,
-55, -46, -55, -45, -54, -45, -53, -44, -53, -45, -52, -44, -52, -44, -53, -43,
-51, -44, -51, -43, -51, -43, -51, -42, -51, -43, -50, -42, -50, -43, -50, -41,
-50, -41, -49, -40, -49, -42, -48, -40, -48, -40, -48, -40, -47, -40, -47, -40,
-46, -39, -46, -39, -46, -38, -46, -38, -45, -38, -45, -39, -45, -38, -45, -37,
-44, -36, -44, -36, -44, -37, -43, -37, -43, -36, -43, -36, -43, -35, -42, -36,
-42, -35, -41, -35, -41, -34, -40, -35, -40, -34, -39, -34, -40, -34, -40, -33,
-39, -33, -38, -32, -38, -33, -38, -32, -37, -32, -38, -31, -37, -31, -37, -31,
-36, -30, -36, -30, -36, -29, -36, -30, -35, -29, -36, -29, -35, -30, -35, -28,
-34, -28, -34, -28, -33, -28, -33, -28, -33, -26, -33, -27, -31, -26, -32, -27,
-32, -26, -31, -26, -31, -25, -31, -26, -30, -25, -29, -24, -30, -25, -30, -25,
-29, -24, -29, -24, -28, -24, -28, -23, -29, -23, -27, -23, -26, -23, -27, -22,
-26, -22, -26, -22, -26, -21, -25, -21, -25, -20, -24, -21, -25, -20, -24, -20,
-24, -20, -23, -20, -24, -19, -23, -19, -22, -19, -23, -19, -21, -18, -21, -19,
-21, -18, -21, -17, -20, -17, -20, -18, -20, -16, -19, -17, -19, -16, -18, -15,
-19, -16, -18, -15, -18, -16, -18, -14, -17, -15, -17, -14, -17, -13, -16, -14,
-16, -13, -16, -12, -15, -12, -15, -12, -15, -12, -15, -12, -15, -12, -14, -11,
-14, -11, -13, -11, -13, -11, -13, -10, -13, -10, -12, -10, -12, -10, -12, -10,
-11, -10, -10, -9, -10, -9, -11, -9, -9, -8, -9, -8, -9, -8, -9, -8, -9, -6, -9,
-7, -8, -6, -8, -7, -8, -6, -6, -6, -7, -5, -7, -5, -6, -5, -5, -4, -5, -5, -5,
-4, -5, -4, -4, -4, -4, -4, -3, -3, -3, -2, -3, -2, -4, -3, -2, -2, -1, -2, -2,
-2, -1, -1, -1, -1, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 2, 1, 2, 1, 2,
2, 3, 2, 3, 2, 3, 3, 3, 3, 4, 3, 4, 4, 4, 3, 4, 4, 5, 5, 6, 5, 6, 5, 5, 5, 6, 6,
7, 6, 7, 6, 8, 5, 8, 6, 8, 7, 8, 7, 9, 8, 8, 7, 9, 7, 9, 8, 10, 8, 11, 9, 10, 9,
11, 9, 10, 9, 11, 10, 11, 10, 12, 9, 12, 11, 12, 11, 12, 10, 14, 12, 13, 12, 14,
12, 14, 12, 13, 13, 15, 13, 14, 13, 16, 13, 15, 13, 15, 13, 16, 14, 16, 14, 17,
15, 17, 14, 17, 14, 18, 15, 18, 15, 18, 16, 19, 17, 18, 16, 20, 17, 19, 17, 20,
17, 21, 17, 21, 17, 21, 18, 21, 18, 21, 18, 22, 19, 23, 18, 22, 19, 22, 20, 23,
20, 23, 19, 24, 20, 25, 21, 24, 21, 25, 21, 25, 21, 25, 21, 25, 22, 26, 22, 26,
22, 27, 23, 26, 23, 27, 23, 28, 23, 27, 24, 28, 24, 28, 24, 30, 24, 29, 26, 29,
25, 30, 26, 30, 25, 31, 26, 30, 26, 31, 26, 32, 27, 32, 27, 33, 27, 32, 28, 33,
28, 33, 28, 33, 28, 33, 29, 34, 29, 34, 29, 35, 29, 35, 30, 35, 30, 35, 31, 35,
31, 36, 31, 37, 31, 38, 32, 37, 32, 37, 32, 37, 33, 38, 33, 38, 33, 38, 33, 38,
33, 39, 33, 39, 34, 40, 34, 40, 34, 41, 34, 41, 35, 41, 35, 41, 36, 42, 37, 42,
37, 43, 36, 44, 36, 43, 37, 44, 37, 44, 37, 43, 38, 45, 38, 45, 38, 45, 39, 45,
39, 45, 39, 47, 39, 46, 39, 47, 39, 47, 40, 47, 40, 47, 40, 48, 40, 49, 41, 49,
41, 49, 41, 49, 42, 50, 42, 50, 43, 50, 42, 51, 43, 51, 43, 51, 43, 52, 45, 52,
44, 52, 45, 53, 45, 52, 45, 53, 46, 54, 46, 54, 46, 54, 45, 55, 47, 54, 47, 55,
48, 55, 47, 55, 47, 56, 48, 57, 47, 56, 48, 57, 48, 56, 49, 58, 49, 57, 49, 58,
50, 59, 49, 59, 49, 59, 50, 59, 50, 59, 50, 59, 51, 60, 51, 61, 52, 61, 51, 62,
53, 61, 53, 61, 53, 63, 53, 62, 53, 63, 54, 63, 53, 63, 54, 64, 54, 64, 55, 64,
54, 65, 55, 65, 55, 65, 55, 66, 56, 66, 56, 67, 57, 66, 57, 68, 57, 67, 57, 68,
57, 68, 58, 68, 59, 69, 58, 70, 59, 69, 59, 69, 59, 70, 59, 70, 60, 71, 60, 72,
60, 71, 61, 72, 61, 72, 61, 72, 62, 73, 62, 72, 62, 74, 62, 72, 63, 74, 62, 73,
64, 76, 63, 73, 63, 77, 63, 74, 64, 77, 64, 75, 64, 78, 64, 76, 65, 77, 65, 76,
65, 78, 65, 78, 66, 78, 66, 79, 65, 77, 68, 81, 66, 76, 69, 85, 65, 74, 72, 92,
64, 70, 83, 119, 43, 21, 6, -64, 28, -17, 18, -38, 27, -22, 20, -32, 25, -24,
22, -29, 26, -26, 20, -23, };