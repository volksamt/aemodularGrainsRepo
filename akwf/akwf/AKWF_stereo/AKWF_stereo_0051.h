#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0051

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 2, 5, 4, 8, 8, 10, 11, 12, 14,
12, 17, 17, 18, 18, 22, 20, 25, 26, 29, 28, 32, 27, 33, 29, 34, 34, 36, 36, 39,
35, 38, 35, 37, 38, 37, 41, 38, 42, 37, 42, 37, 43, 36, 46, 37, 49, 39, 54, 42,
56, 45, 58, 48, 60, 49, 61, 52, 59, 53, 61, 54, 66, 57, 70, 59, 68, 59, 66, 56,
67, 56, 69, 55, 67, 55, 67, 53, 69, 51, 70, 50, 68, 49, 70, 50, 74, 54, 79, 60,
85, 66, 92, 75, 100, 84, 103, 92, 106, 101, 109, 108, 113, 114, 116, 118, 118,
119, 120, 119, 119, 115, 117, 110, 115, 104, 115, 99, 116, 93, 115, 88, 114, 80,
111, 74, 105, 67, 100, 62, 100, 59, 101, 56, 100, 56, 99, 54, 95, 52, 92, 51,
88, 51, 85, 52, 84, 53, 85, 54, 84, 53, 78, 52, 74, 51, 74, 53, 75, 55, 72, 55,
69, 54, 65, 51, 60, 47, 56, 44, 52, 42, 52, 41, 53, 40, 52, 38, 47, 34, 41, 29,
37, 26, 30, 21, 23, 15, 19, 9, 15, 2, 11, -5, 6, -11, 3, -15, -2, -18, -4, -21,
-6, -21, -7, -22, -7, -20, -7, -17, -8, -13, -6, -6, -2, 0, 1, 8, 2, 13, 1, 16,
1, 19, -1, 21, -1, 21, 1, 21, 3, 22, 5, 21, 6, 19, 6, 17, 4, 14, 4, 12, 2, 9, 2,
6, 2, 3, 1, 0, 1, -3, 2, -3, 2, -4, 3, -4, 4, -3, 6, -1, 6, -1, 4, -1, 4, 1, 4,
2, 6, 4, 7, 6, 8, 6, 9, 7, 8, 7, 6, 8, 6, 8, 7, 8, 8, 10, 10, 9, 10, 9, 8, 9, 7,
8, 4, 6, 0, 3, -2, -1, -5, -6, -10, -12, -15, -20, -20, -27, -24, -34, -28, -39,
-32, -44, -35, -49, -40, -54, -44, -58, -48, -60, -51, -61, -53, -61, -54, -61,
-57, -60, -60, -60, -63, -58, -64, -57, -65, -54, -66, -52, -67, -51, -68, -51,
-70, -50, -72, -51, -74, -52, -77, -53, -77, -54, -80, -58, -82, -60, -83, -63,
-86, -66, -87, -68, -89, -71, -88, -71, -89, -73, -88, -73, -88, -74, -90, -74,
-90, -73, -91, -72, -91, -71, -90, -71, -89, -70, -89, -69, -87, -68, -87, -66,
-84, -64, -81, -61, -79, -57, -75, -53, -72, -49, -69, -46, -67, -41, -64, -37,
-62, -34, -59, -31, -56, -30, -55, -29, -54, -29, -53, -30, -53, -31, -52, -33,
-52, -36, -52, -39, -53, -43, -53, -46, -55, -50, -55, -52, -56, -54, -57, -56,
-57, -59, -58, -59, -58, -60, -59, -59, -60, -58, -58, -56, -58, -54, -57, -52,
-56, -50, -58, -49, -58, -47, -59, -46, -60, -46, -60, -45, -61, -46, -62, -47,
-63, -49, -65, -50, -65, -52, -66, -53, -67, -54, -67, -55, -69, -57, -70, -58,
-72, -60, -74, -61, -75, -63, -76, -65, -77, -67, -79, -69, -81, -70, -82, -72,
-83, -71, -82, -73, -82, -71, -81, -70, -81, -68, -79, -66, -78, -62, -76, -59,
-73, -54, -72, -50, -69, -46, -66, -43, -63, -38, -61, -36, -58, -32, -55, -29,
-53, -27, -50, -25, -48, -25, -47, -24, -46, -23, -44, -24, -42, -25, -41, -26,
-39, -26, -38, -27, -36, -27, -34, -27, -33, -26, -30, -26, -27, -24, -25, -22,
-23, -19, -21, -17, -19, -15, -16, -13, -15, -10, -14, -8, -12, -7, -10, -5, -9,
-4, -7, -2, -5, -2, -5, -1, -3, 0, -2, 0, -1, 0, -1, 1, -1, 0, -2, 1, -1, -2,
-2, -3, -4, -5, -4, -7, -6, -9, -7, -12, -9, -14, -11, -17, -13, -19, -14, -22,
-16, -24, -17, -25, -20, -27, -21, -28, -22, -29, -24, -29, -23, -29, -23, -27,
-24, -25, -24, -23, -23, -22, -22, -19, -22, -16, -21, -14, -22, -12, -21, -10,
-22, -9, -21, -8, -20, -8, -20, -8, -18, -8, -18, -7, -16, -6, -15, -6, -13, -5,
-11, -3, -9, -1, -8, 0, -7, 1, -6, 1, -5, 2, -4, 2, -3, 3, -1, 4, 1, 4, 2, 4, 5,
5, 7, 7, 9, 9, 12, 12, 13, 14, 15, 16, 16, 16, 17, 18, 19, 19, 21, 21, 23, 22,
23, 23, 26, 24, 27, 24, 29, 26, 30, 27, 31, 28, 32, 29, 32, 29, 33, 27, 33, 27,
31, 26, 31, 25, 30, 22, 29, 20, 29, 19, 30, 18, 29, 18, 31, 17, 31, 18, 31, 19,
30, 19, 31, 21, 31, 22, 31, 22, 29, 22, 29, 22, 27, 22, 27, 22, 29, 23, 29, 23,
28, 23, 28, 23, 27, 22, 28, 22, 30, 24, 29, 25, 30, 25, 28, 24, 27, 24, 27, 23,
27, 24, 28, 23, 29, 22, 28, 22, 27, 21, 27, 21, 27, 21, 28, 23, 28, 22, 28, 23,
28, 21, 27, 21, 27, 21, 27, 21, 28, 21, 28, 22, 29, 22, 30, 23, 30, 24, 29, 24,
32, 26, 34, 29, 35, 30, 36, 32, 35, 32, 34, 32, 34, 32, 35, 32, 36, 32, 35, 32,
34, 30, 34, 28, 35, 27, 34, 27, 35, 27, 33, 25, 32, 23, 31, 21, 30, 20, 31, 21,
30, 18, 27, 18, 25, 16, 23, 13, 22, 12, 22, 12, 22, 11, 20, 10, 19, 9, 17, 7,
16, 7, 16, 7, 16, 8, 16, 9, 14, 9, 12, 8, 11, 8, 11, 9, 12, 11, 14, 12, 13, 13,
11, 12, 10, 11, 8, 10, 8, 10, 8, 9, 7, 9, 5, 5, 2, 2, -1, -3, -2, -5, -2, -5,
-4, -8, -7, -11, -9, -15, -11, -18, -13, -20, -15, -21, -15, -20, -16, -21, -18,
-23, -19, -23, -19, -22, -20, -22, -20, -19, -18, -16, -17, -14, -17, -12, -17,
-10, -17, -8, -16, -7, -17, -3, -15, -3, -14, -2, -14, -2, -13, -2, -12, -2,
-10, 0, -9, 0, -9, 1, -9, -1, -11, -2, -10, -4, -9, -4, -7, -3, -7, -2, -5, -2,
-4, -2, -4, -2, -2, -1, -1, 0, 0, };