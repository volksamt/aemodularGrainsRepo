#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0092

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 1, 5, 3, 5, 2, 6, 4, 7, 5, 9, 7,
10, 7, 10, 7, 12, 9, 12, 10, 13, 11, 15, 12, 16, 12, 16, 14, 18, 14, 18, 15, 20,
17, 20, 18, 21, 18, 22, 19, 23, 21, 24, 21, 26, 23, 26, 24, 26, 25, 28, 26, 29,
27, 30, 28, 31, 29, 32, 30, 33, 30, 34, 32, 35, 33, 36, 34, 38, 35, 38, 36, 38,
37, 40, 38, 41, 40, 42, 41, 43, 43, 43, 43, 45, 45, 46, 45, 46, 46, 48, 47, 48,
49, 50, 51, 51, 52, 51, 53, 53, 55, 54, 57, 54, 58, 56, 59, 57, 61, 58, 62, 58,
64, 59, 64, 60, 66, 62, 68, 62, 69, 62, 70, 64, 72, 65, 74, 66, 75, 67, 76, 68,
76, 68, 78, 69, 79, 71, 81, 72, 82, 73, 83, 73, 85, 74, 86, 75, 86, 77, 89, 78,
89, 79, 91, 79, 91, 81, 93, 82, 93, 83, 95, 83, 96, 84, 97, 85, 99, 86, 99, 87,
101, 88, 101, 89, 102, 90, 104, 91, 105, 93, 106, 93, 107, 94, 108, 94, 110, 96,
110, 97, 112, 98, 113, 100, 113, 100, 114, 101, 116, 102, 116, 104, 118, 104,
117, 105, 118, 104, 117, 106, 117, 106, 118, 107, 118, 108, 119, 108, 119, 108,
119, 109, 119, 109, 119, 109, 119, 110, 119, 110, 119, 111, 119, 111, 118, 111,
118, 111, 119, 110, 118, 111, 118, 112, 118, 111, 118, 112, 118, 111, 118, 110,
117, 111, 117, 110, 117, 109, 116, 110, 116, 110, 115, 109, 115, 109, 116, 109,
115, 108, 114, 108, 114, 108, 114, 108, 113, 107, 113, 106, 113, 105, 112, 105,
111, 104, 111, 105, 110, 103, 109, 103, 109, 102, 108, 102, 108, 101, 107, 100,
106, 99, 106, 99, 105, 98, 104, 97, 103, 96, 102, 95, 101, 95, 100, 93, 100, 93,
98, 91, 98, 91, 98, 90, 97, 88, 95, 88, 95, 87, 94, 86, 92, 85, 91, 83, 91, 82,
89, 81, 88, 81, 87, 80, 86, 77, 85, 77, 84, 76, 84, 75, 82, 73, 82, 72, 81, 71,
78, 70, 78, 70, 77, 69, 77, 68, 75, 66, 74, 66, 73, 64, 72, 63, 71, 61, 70, 61,
69, 60, 68, 58, 66, 58, 66, 57, 64, 55, 63, 55, 62, 53, 61, 53, 60, 52, 59, 50,
58, 50, 57, 49, 55, 48, 54, 48, 53, 46, 53, 45, 51, 45, 51, 44, 49, 43, 47, 42,
47, 41, 46, 40, 44, 39, 43, 39, 43, 37, 41, 36, 41, 35, 38, 34, 38, 34, 37, 33,
36, 32, 35, 31, 33, 30, 32, 29, 31, 28, 29, 26, 29, 26, 28, 24, 27, 24, 26, 23,
24, 22, 24, 21, 22, 21, 21, 18, 19, 19, 19, 17, 18, 16, 17, 14, 16, 14, 15, 13,
14, 13, 12, 12, 11, 10, 11, 9, 9, 8, 8, 7, 8, 6, 7, 6, 6, 4, 5, 4, 4, 2, 3, 0,
2, 0, 0, -2, 0, -2, 0, -3, -2, -4, -2, -5, -4, -7, -4, -7, -4, -9, -6, -10, -6,
-10, -8, -11, -8, -12, -10, -13, -11, -15, -11, -16, -12, -17, -14, -18, -15,
-19, -16, -20, -17, -21, -18, -22, -19, -22, -19, -23, -21, -24, -21, -25, -22,
-26, -24, -28, -25, -28, -26, -30, -28, -30, -29, -31, -29, -33, -29, -33, -31,
-34, -33, -35, -33, -37, -35, -37, -35, -38, -37, -39, -37, -41, -38, -40, -40,
-42, -41, -43, -43, -44, -44, -44, -44, -46, -46, -46, -46, -48, -48, -49, -49,
-50, -51, -51, -53, -52, -54, -52, -55, -53, -57, -54, -58, -56, -59, -56, -61,
-57, -62, -58, -64, -59, -66, -60, -67, -61, -68, -62, -69, -64, -71, -64, -72,
-65, -73, -66, -75, -67, -76, -68, -77, -69, -79, -70, -79, -71, -81, -72, -82,
-73, -84, -73, -84, -75, -86, -75, -88, -77, -88, -78, -89, -78, -91, -79, -91,
-81, -93, -82, -94, -83, -95, -83, -96, -85, -97, -86, -99, -87, -99, -88, -101,
-89, -102, -90, -103, -90, -104, -91, -105, -92, -106, -93, -107, -94, -108,
-96, -109, -95, -111, -97, -111, -99, -112, -99, -114, -100, -114, -101, -116,
-102, -117, -103, -117, -104, -117, -105, -117, -106, -117, -105, -118, -106,
-118, -107, -118, -107, -118, -108, -119, -109, -119, -109, -119, -109, -119,
-110, -119, -109, -118, -110, -119, -110, -118, -110, -118, -111, -119, -111,
-118, -110, -118, -111, -118, -110, -119, -111, -118, -111, -117, -111, -117,
-110, -117, -111, -117, -110, -117, -110, -116, -109, -116, -110, -116, -110,
-115, -109, -115, -109, -115, -109, -114, -108, -114, -107, -113, -108, -112,
-106, -112, -106, -112, -105, -112, -106, -111, -104, -111, -104, -110, -104,
-110, -102, -109, -102, -108, -101, -108, -101, -107, -100, -106, -99, -106,
-99, -104, -97, -103, -96, -103, -97, -102, -95, -102, -95, -100, -93, -101,
-92, -99, -92, -98, -90, -97, -89, -97, -89, -95, -88, -95, -86, -93, -86, -92,
-84, -91, -83, -90, -83, -89, -81, -89, -80, -88, -79, -86, -78, -86, -76, -84,
-76, -82, -75, -82, -73, -81, -72, -80, -72, -79, -70, -77, -69, -77, -69, -76,
-67, -75, -65, -74, -65, -74, -64, -72, -63, -70, -62, -70, -61, -68, -60, -68,
-59, -67, -57, -66, -56, -64, -56, -63, -55, -62, -54, -61, -53, -59, -52, -59,
-51, -57, -50, -57, -49, -56, -48, -54, -47, -52, -45, -52, -45, -51, -44, -50,
-44, -49, -43, -47, -42, -46, -40, -45, -40, -45, -39, -43, -38, -42, -37, -42,
-36, -39, -35, -39, -34, -37, -34, -36, -33, -36, -32, -34, -30, -33, -29, -31,
-28, -31, -28, -30, -26, -28, -26, -27, -25, -27, -24, -26, -22, -25, -22, -23,
-21, -22, -20, -21, -20, -20, -18, -19, -17, -18, -17, -17, -15, -16, -14, -14,
-14, -13, -12, -13, -11, -12, -10, -10, -9, -9, -8, -8, -7, -7, -5, -6, -5, -6,
-3, -5, -3, -4, -1, -4, 0, -3, 0, -2, 1, -1, 2, };