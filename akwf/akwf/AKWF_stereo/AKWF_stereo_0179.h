#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0179

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 27, 15, 43, 25, 53, 34, 65, 42, 74,
49, 81, 54, 86, 59, 91, 63, 94, 66, 99, 69, 100, 71, 100, 73, 101, 75, 100, 75,
101, 76, 100, 78, 99, 79, 99, 79, 98, 80, 96, 80, 94, 80, 93, 80, 93, 80, 90,
80, 88, 79, 86, 78, 84, 78, 82, 77, 79, 77, 77, 76, 73, 75, 70, 75, 68, 73, 64,
73, 61, 72, 58, 72, 53, 71, 50, 70, 46, 70, 43, 69, 39, 68, 35, 67, 33, 66, 31,
64, 29, 64, 28, 62, 29, 61, 30, 60, 32, 59, 35, 57, 39, 55, 43, 55, 48, 53, 53,
52, 58, 51, 63, 50, 68, 48, 74, 48, 79, 48, 85, 46, 90, 47, 95, 45, 101, 45,
105, 45, 109, 45, 112, 44, 115, 44, 117, 43, 118, 42, 118, 40, 119, 41, 119, 39,
119, 38, 117, 37, 117, 35, 116, 34, 114, 33, 113, 32, 111, 31, 110, 31, 108, 29,
107, 28, 105, 29, 103, 28, 102, 27, 100, 27, 99, 27, 97, 26, 95, 26, 94, 26, 93,
26, 91, 24, 90, 24, 89, 24, 88, 24, 87, 24, 86, 24, 87, 24, 85, 24, 85, 24, 85,
23, 84, 23, 83, 24, 82, 21, 79, 21, 78, 21, 78, 18, 75, 17, 73, 15, 71, 13, 69,
11, 66, 9, 63, 5, 61, 2, 59, -1, 57, -5, 53, -8, 51, -13, 48, -17, 44, -20, 41,
-24, 38, -28, 34, -31, 31, -33, 27, -36, 22, -38, 19, -39, 15, -38, 10, -37, 7,
-35, 3, -32, -1, -28, -6, -22, -9, -16, -13, -10, -17, -4, -21, 3, -24, 7, -29,
12, -32, 16, -37, 18, -42, 20, -47, 22, -51, 23, -56, 23, -60, 23, -65, 21, -69,
21, -73, 20, -78, 19, -82, 18, -85, 17, -89, 16, -92, 15, -95, 14, -99, 14,
-101, 13, -104, 13, -107, 11, -109, 9, -111, 9, -113, 9, -114, 9, -116, 7, -116,
8, -116, 8, -115, 8, -114, 8, -113, 9, -111, 8, -110, 9, -109, 9, -106, 8, -105,
7, -104, 7, -103, 6, -103, 5, -102, 4, -101, 4, -101, 4, -100, 3, -101, 4, -101,
5, -100, 7, -99, 8, -100, 9, -99, 11, -99, 12, -100, 14, -98, 15, -100, 16,
-100, 17, -99, 18, -99, 18, -100, 18, -100, 18, -101, 18, -100, 18, -101, 18,
-102, 17, -102, 16, -103, 16, -103, 15, -103, 15, -103, 15, -104, 14, -105, 14,
-107, 13, -107, 13, -109, 12, -111, 12, -112, 10, -114, 10, -114, 10, -116, 9,
-116, 8, -117, 8, -117, 7, -117, 8, -114, 7, -113, 7, -110, 6, -107, 7, -103, 7,
-98, 5, -91, 6, -84, 6, -75, 6, -66, 5, -55, 7, -44, 6, -32, 6, -22, 7, -11, 7,
-1, 6, 8, 8, 18, 8, 25, 8, 33, 8, 38, 8, 44, 8, 49, 9, 55, 9, 58, 10, 61, 11,
65, 11, 69, 12, 70, 13, 74, 14, 75, 15, 77, 16, 79, 18, 81, 18, 84, 20, 85, 19,
86, 21, 87, 21, 90, 21, 90, 20, 91, 20, 93, 20, 93, 19, 95, 17, 95, 16, 97, 15,
98, 14, 100, 12, 101, 10, 103, 7, 104, 5, 106, 4, 107, 1, 109, 0, 109, -3, 110,
-5, 111, -8, 110, -10, 111, -13, 110, -15, 110, -17, 109, -20, 109, -22, 109,
-25, 108, -28, 107, -29, 105, -33, 104, -35, 103, -37, 103, -39, 103, -42, 101,
-44, 100, -48, 99, -50, 96, -52, 96, -55, 94, -57, 93, -59, 91, -61, 89, -62,
86, -64, 84, -64, 82, -65, 80, -65, 77, -64, 75, -63, 72, -63, 70, -62, 66, -62,
62, -61, 59, -62, 56, -61, 52, -61, 47, -61, 43, -62, 38, -62, 34, -63, 29, -65,
24, -66, 18, -67, 14, -68, 8, -70, 3, -71, -2, -72, -6, -73, -12, -74, -17, -76,
-21, -77, -25, -79, -30, -80, -36, -81, -40, -83, -44, -85, -48, -85, -51, -85,
-55, -86, -56, -84, -57, -82, -55, -79, -53, -75, -49, -70, -46, -64, -40, -59,
-34, -53, -29, -46, -24, -41, -19, -36, -15, -30, -12, -26, -9, -21, -7, -16,
-7, -11, -5, -6, -5, -1, -6, 5, -6, 9, -7, 15, -8, 21, -10, 25, -12, 29, -14,
33, -17, 37, -19, 39, -22, 42, -24, 44, -28, 46, -31, 48, -34, 49, -37, 51, -41,
52, -46, 53, -48, 54, -53, 55, -56, 56, -60, 58, -63, 60, -67, 61, -70, 61, -73,
63, -76, 64, -79, 66, -81, 67, -83, 68, -85, 69, -87, 71, -87, 72, -88, 73, -88,
75, -87, 75, -86, 76, -84, 77, -81, 77, -75, 78, -71, 79, -66, 79, -60, 78, -55,
79, -49, 78, -44, 78, -38, 77, -33, 76, -28, 75, -26, 75, -23, 73, -20, 72, -19,
71, -18, 69, -17, 66, -18, 65, -18, 63, -19, 60, -20, 57, -22, 54, -24, 51, -25,
47, -28, 43, -31, 39, -33, 35, -36, 31, -39, 27, -43, 22, -45, 18, -49, 13, -52,
9, -55, 4, -59, -1, -61, -5, -64, -9, -67, -14, -70, -19, -71, -23, -73, -27,
-75, -31, -76, -36, -76, -40, -76, -43, -75, -47, -74, -51, -72, -53, -70, -56,
-68, -59, -66, -63, -63, -65, -60, -67, -57, -69, -54, -71, -53, -74, -51, -75,
-49, -77, -47, -79, -46, -81, -44, -83, -43, -85, -43, -87, -43, -90, -42, -91,
-41, -93, -41, -95, -41, -98, -41, -100, -42, -103, -41, -104, -41, -105, -40,
-108, -40, -109, -40, -111, -40, -113, -40, -115, -39, -115, -38, -116, -39,
-116, -38, -116, -38, -115, -37, -113, -37, -110, -37, -105, -35, -101, -35,
-97, -36, -93, -35, -88, -35, -83, -35, -79, -35, -75, -36, -73, -36, -70, -37,
-69, -39, -68, -40, -68, -41, -67, -44, -68, -45, -69, -47, -71, -49, -71, -51,
-73, -53, -75, -56, -76, -57, -78, -60, -79, -62, -80, -63, -81, -65, -82, -65,
-80, -64, -79, -62, -76, -59, -72, -55, -67, -49, -59, -40, -51, -31, -41, -20,
-29, -9, -18, 8, -6, 15, };