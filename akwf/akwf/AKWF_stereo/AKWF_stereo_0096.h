#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0096

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 15, 111, 112, 103, 103, 96, 95, 92,
93, 88, 92, 86, 97, 81, 104, 91, 114, 86, 116, 90, 120, 86, 118, 88, 118, 86,
114, 86, 111, 84, 107, 84, 103, 85, 100, 84, 101, 85, 101, 87, 103, 89, 107, 90,
109, 92, 111, 92, 114, 91, 114, 93, 115, 91, 112, 99, 116, 96, 112, 95, 111, 89,
105, 91, 107, 85, 100, 92, 109, 80, 97, 98, 117, 39, 62, -28, -2, 1, 26, 2, 25,
15, 34, 18, 30, 22, 27, 23, 21, 23, 15, 22, 9, 21, 7, 19, 5, 20, 6, 17, 9, 18,
13, 16, 14, 20, 19, 15, 18, 20, 22, 14, 15, 21, 20, 12, 8, 21, 15, 8, 0, 26, 15,
6, -5, 32, 21, -8, -16, -60, -65, 10, 4, -40, -44, -18, -23, -16, -22, 32, 14,
32, 12, 20, 0, 23, 0, 12, -8, 17, -2, 5, -8, 17, 4, -4, -5, -9, 0, -3, 4, 6, 14,
9, 12, 15, 17, 14, 13, 17, 14, 15, 9, 18, 9, 15, 5, 14, 6, 12, 5, 10, 6, 9, 8,
7, 9, 6, 11, 4, 10, 4, 12, 2, 8, 4, 10, 1, 6, 4, 7, 0, 4, 3, 6, -1, 3, 6, 9, -6,
0, -44, -38, -36, -28, -36, -27, -31, -23, -31, -25, -27, -24, -34, -33, -9,
-10, 20, 13, 5, -2, 8, 1, -3, -5, 1, 0, -3, 0, 1, 6, -1, 8, 2, 13, 2, 14, 5, 14,
4, 13, 3, 11, 4, 9, 1, 5, 4, 4, 1, 1, 4, 4, 1, 1, 7, 8, -1, 1, 21, 23, 54, 56,
47, 49, 42, 47, 45, 48, 33, 41, 51, 54, 36, 36, 0, 6, 7, 17, 1, 12, 5, 14, 2,
10, 1, 9, 0, 6, 1, 2, 2, 0, 1, 1, 2, 1, 3, 1, 6, 4, 7, 6, 9, 9, 9, 10, 11, 12,
10, 13, 11, 12, 10, 11, 10, 9, 8, 7, 7, 6, 7, 6, 7, 4, 7, 5, 7, 4, 8, 6, 8, 8,
9, 8, 9, 9, 8, 10, 9, 9, 9, 8, 9, 9, 8, 7, 10, 8, 7, 5, 10, 7, 8, 4, 10, 7, 7,
6, 10, 8, 6, 5, 11, 9, 3, 5, 1, 4, 5, 7, -68, -65, -86, -82, -52, -49, -29, -29,
-17, -23, -28, -39, -26, -39, -29, -45, -8, -26, 28, 5, 18, -8, 12, -7, 7, -7,
4, -3, 4, 2, 0, 6, 1, 11, 1, 13, 4, 14, 3, 12, 5, 11, 4, 8, 4, 6, 3, 2, 6, 2, 3,
1, 8, 4, 13, 9, 10, 10, 8, 11, 7, 12, 4, 12, 5, 12, -2, 8, -6, 5, -2, 5, -1, 4,
1, 5, 2, 5, 3, 4, 5, 6, 5, 7, 8, 9, 7, 8, 8, 12, 6, 10, 4, 14, -2, 9, 7, 16,
-16, -7, -46, -39, -35, -28, -36, -31, -30, -26, -32, -30, -26, -28, -32, -36,
5, -2, 20, 10, 8, -2, 11, 1, 5, -3, 7, 2, 3, 2, 6, 8, 4, 8, 7, 13, 6, 12, 7, 13,
6, 11, 7, 9, 6, 7, 7, 4, 3, 5, 4, 1, 7, 6, 1, 1, 16, 17, 53, 51, 52, 45, 48, 46,
63, 54, 58, 54, 51, 51, 42, 47, 41, 50, 2, 14, -14, 1, -5, 11, -5, 9, 0, 10, 0,
8, 4, 8, 4, 6, 7, 5, 7, 4, 8, 3, 8, 4, 10, 6, 10, 8, 10, 10, 9, 11, 9, 12, 8,
12, 8, 12, 6, 10, 7, 9, 6, 6, 6, 6, 4, 3, 7, 5, 4, 3, 6, 6, 5, 4, 7, 8, 3, 7, 9,
12, 1, 6, -10, 0, -6, 1, 2, 6, 4, 4, 12, 10, 12, 6, 17, 11, 14, 9, 15, 10, 15,
12, -97, -95, -106, -102, -89, -84, -90, -88, -79, -82, -82, -91, -78, -92, -82,
-104, -80, -106, -84, -114, -83, -114, -84, -115, -83, -111, -85, -109, -84,
-104, -83, -100, -80, -97, -95, -106, -80, -97, -86, -102, -84, -102, -81, -104,
-77, -104, -75, -103, -81, -107, -80, -107, -84, -109, -81, -106, -85, -107,
-83, -102, -87, -103, -85, -100, -88, -102, -86, -101, -88, -103, -87, -103,
-88, -106, -87, -106, -86, -107, -87, -107, -86, -106, -87, -106, -86, -104,
-87, -104, -86, -102, -88, -103, -86, -100, -89, -103, -87, -101, -91, -104,
-88, -103, -92, -105, -89, -103, -92, -106, -89, -103, -91, -106, -90, -102,
-92, -104, -98, -107, -97, -105, -96, -104, -89, -100, -99, -110, 8, -6, 33, 16,
10, -8, 21, 2, 2, -10, 4, -2, -7, -4, -3, 7, -10, 8, -10, 16, -11, 15, -6, 17,
-6, 13, -5, 12, -6, 7, -4, 4, -4, 2, -1, 1, 3, 1, 2, 3, 4, 6, 3, 8, 4, 13, 2,
14, 4, 17, 9, 20, 7, 18, 3, 13, 2, 11, -2, 7, -2, 5, -6, 1, -12, -2, -8, 0, -5,
3, -1, 6, 1, 8, 5, 11, 6, 12, 8, 14, 8, 12, 9, 14, 7, 10, 9, 10, 7, 8, 8, 8, 8,
7, -32, -31, -38, -36, -29, -27, -30, -29, -23, -25, -28, -29, -18, -25, 20, 11,
18, 6, 12, 0, 13, -1, 6, -3, 9, 1, 6, 1, 9, 7, 7, 8, 11, 14, 9, 13, 13, 15, 13,
11, 14, 12, 11, 6, 14, 7, 10, 2, 13, 3, 10, 2, 12, 5, 11, 5, 12, 7, 50, 47, 58,
54, 47, 45, 51, 50, 33, 37, 30, 40, 30, 39, -2, 6, 3, 12, 6, 17, 10, 17, 18, 19,
17, 18, 26, 20, 20, 14, 16, 10, 10, 4, 7, 3, 5, 2, 1, 3, 0, 4, -1, 6, 1, 8, 1,
9, 3, 10, 4, 11, 3, 10, 4, 9, 5, 9, 4, 7, 4, 7, 5, 6, 5, 6, 6, 6, 5, 8, 6, 8, 6,
9, 6, 10, 6, 11, 5, 10, 5, 10, 5, 10, 5, 8, 5, 7, 4, 7, 4, 6, 4, 7, 4, 7, 4, 8,
4, 8, 6, 9, 5, 8, 7, 10, 6, 9, };