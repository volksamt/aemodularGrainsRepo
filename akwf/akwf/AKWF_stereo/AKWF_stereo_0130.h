#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0130

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 26, 4, 33, 4, 32, 5, 34, 6, 34, 8,
37, 8, 36, 9, 39, 11, 39, 13, 42, 15, 43, 17, 46, 19, 47, 21, 49, 22, 49, 25,
51, 25, 52, 26, 52, 27, 53, 29, 54, 30, 55, 32, 58, 34, 59, 37, 62, 38, 63, 40,
66, 42, 68, 43, 69, 45, 71, 46, 71, 47, 74, 48, 74, 50, 77, 51, 78, 53, 80, 54,
80, 55, 82, 58, 83, 59, 85, 60, 86, 62, 88, 63, 88, 64, 89, 66, 89, 67, 91, 68,
91, 69, 93, 70, 94, 72, 95, 73, 97, 75, 97, 76, 98, 76, 99, 76, 99, 77, 99, 79,
100, 80, 100, 80, 102, 80, 101, 81, 103, 81, 103, 81, 103, 82, 104, 83, 104, 84,
105, 85, 106, 85, 107, 87, 107, 88, 107, 89, 108, 90, 108, 91, 110, 93, 111, 93,
112, 95, 113, 97, 113, 97, 113, 99, 113, 100, 114, 100, 114, 101, 116, 102, 115,
101, 115, 102, 116, 103, 115, 103, 116, 103, 116, 104, 116, 104, 117, 105, 117,
105, 117, 105, 117, 106, 116, 105, 118, 106, 117, 106, 117, 106, 116, 106, 116,
107, 116, 107, 116, 108, 117, 108, 116, 109, 117, 110, 118, 109, 117, 110, 117,
110, 117, 110, 116, 109, 115, 110, 115, 110, 113, 109, 114, 110, 114, 110, 113,
111, 113, 111, 113, 110, 113, 112, 113, 111, 113, 112, 112, 112, 112, 112, 112,
111, 112, 112, 112, 112, 112, 112, 112, 113, 112, 113, 113, 114, 112, 114, 112,
114, 113, 114, 112, 115, 112, 116, 113, 114, 112, 116, 111, 116, 112, 115, 110,
115, 110, 114, 110, 114, 109, 113, 109, 114, 108, 114, 108, 114, 107, 114, 106,
114, 107, 114, 106, 114, 105, 114, 104, 113, 104, 113, 104, 112, 102, 111, 102,
110, 100, 110, 100, 111, 99, 108, 97, 108, 97, 108, 96, 106, 94, 105, 93, 103,
90, 101, 90, 100, 88, 99, 87, 98, 86, 96, 85, 97, 83, 96, 82, 96, 82, 95, 81,
96, 80, 95, 80, 95, 78, 94, 78, 93, 76, 91, 74, 92, 73, 90, 72, 89, 71, 88, 70,
88, 69, 87, 68, 86, 67, 85, 64, 83, 63, 82, 62, 80, 58, 79, 58, 76, 56, 75, 55,
73, 53, 72, 51, 70, 49, 69, 47, 67, 46, 65, 43, 63, 41, 61, 39, 59, 36, 57, 35,
56, 33, 54, 32, 53, 30, 52, 30, 51, 28, 50, 26, 49, 25, 47, 24, 45, 21, 44, 19,
41, 17, 39, 14, 38, 13, 37, 11, 35, 9, 34, 7, 31, 6, 30, 4, 29, 3, 27, 2, 26, 0,
24, -2, 23, -3, 21, -5, 20, -6, 20, -6, 19, -8, 18, -10, 16, -10, 16, -12, 15,
-14, 14, -14, 13, -16, 11, -17, 10, -18, 9, -19, 8, -20, 7, -21, 7, -22, 6, -23,
5, -23, 5, -24, 4, -26, 3, -26, 3, -26, 3, -27, 2, -27, 1, -28, 1, -29, 1, -30,
0, -31, -1, -32, -2, -32, -2, -34, -4, -34, -5, -35, -7, -38, -8, -38, -8, -39,
-10, -40, -11, -41, -13, -43, -15, -44, -15, -45, -17, -45, -18, -46, -19, -48,
-19, -48, -21, -49, -21, -50, -22, -51, -23, -52, -25, -54, -25, -54, -26, -54,
-26, -54, -27, -54, -26, -54, -26, -54, -27, -54, -27, -55, -27, -55, -28, -57,
-31, -57, -32, -59, -33, -61, -35, -62, -37, -64, -38, -64, -39, -66, -40, -66,
-41, -67, -43, -69, -42, -69, -44, -70, -46, -71, -47, -73, -49, -75, -50, -76,
-52, -77, -54, -78, -55, -79, -55, -79, -56, -79, -55, -79, -56, -80, -58, -80,
-59, -81, -60, -82, -61, -82, -62, -82, -63, -84, -64, -84, -64, -86, -65, -85,
-66, -87, -67, -88, -68, -88, -68, -89, -69, -90, -71, -90, -72, -91, -74, -92,
-75, -93, -77, -94, -77, -95, -78, -95, -79, -96, -79, -96, -80, -96, -81, -97,
-82, -98, -83, -99, -84, -98, -85, -99, -85, -100, -86, -100, -86, -99, -87,
-100, -87, -100, -88, -100, -88, -100, -88, -100, -89, -100, -89, -100, -90,
-101, -90, -101, -91, -101, -90, -101, -91, -101, -91, -101, -92, -101, -92,
-101, -93, -101, -94, -102, -94, -102, -95, -103, -97, -103, -97, -104, -99,
-104, -99, -104, -100, -104, -100, -105, -100, -105, -101, -105, -101, -105,
-103, -106, -102, -106, -103, -106, -104, -106, -103, -106, -104, -106, -104,
-106, -104, -106, -104, -106, -105, -105, -104, -104, -105, -103, -104, -103,
-105, -103, -106, -103, -105, -102, -106, -102, -106, -102, -106, -103, -106,
-102, -108, -103, -108, -103, -109, -103, -110, -104, -111, -105, -112, -106,
-113, -106, -112, -107, -113, -108, -115, -108, -114, -108, -116, -108, -116,
-107, -116, -109, -117, -108, -117, -109, -119, -109, -118, -109, -119, -110,
-119, -109, -119, -108, -119, -108, -119, -108, -119, -107, -118, -106, -119,
-106, -117, -104, -118, -104, -119, -104, -119, -103, -118, -103, -118, -102,
-117, -102, -116, -101, -115, -100, -115, -99, -113, -98, -113, -98, -112, -97,
-111, -97, -110, -95, -109, -93, -109, -93, -107, -92, -107, -91, -106, -91,
-105, -89, -105, -87, -103, -86, -103, -84, -101, -81, -99, -81, -98, -79, -97,
-77, -95, -75, -95, -73, -93, -72, -92, -72, -91, -69, -90, -68, -88, -66, -85,
-65, -83, -62, -82, -60, -80, -58, -78, -56, -76, -55, -76, -54, -75, -52, -74,
-52, -73, -49, -72, -48, -70, -47, -70, -46, -68, -44, -67, -43, -66, -41, -64,
-39, -63, -39, -62, -38, -61, -36, -60, -35, -59, -33, -59, -33, -57, -32, -55,
-30, -54, -28, -52, -26, -49, -24, -48, -22, -46, -21, -44, -18, -43, -17, -42,
-14, -39, -14, -38, -12, -37, -10, -36, -8, -33, -6, -33, -5, -31, -4, -29, -1,
-28, -1, -26, 2, -26, 2, -24, 3, -24, 4, -22, 6, -21, 7, -19, 8, -18, 10, -16,
10, -15, 12, -13, 14, -13, 15, -11, 15, -11, 17, -10, 18, -9, 21, -8, 20, -6,
24, -4, 24, -1, 28, -1, 24, };