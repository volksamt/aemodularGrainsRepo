#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0140

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -39, 3, -44, 7, -38, 10, -39, 13,
-33, 16, -32, 19, -27, 20, -25, 23, -20, 26, -17, 28, -11, 31, -6, 33, 6, 36,
19, 38, 29, 41, 35, 44, 41, 46, 45, 48, 49, 51, 51, 53, 54, 55, 57, 57, 60, 59,
62, 61, 64, 63, 65, 65, 67, 69, 70, 70, 72, 73, 74, 74, 75, 76, 78, 78, 80, 80,
80, 81, 82, 83, 83, 84, 85, 86, 85, 86, 86, 87, 88, 89, 89, 89, 90, 90, 91, 91,
92, 93, 93, 94, 94, 95, 94, 96, 95, 97, 96, 98, 97, 99, 98, 100, 99, 100, 99,
101, 99, 101, 101, 103, 101, 103, 102, 103, 102, 105, 102, 105, 103, 106, 104,
107, 104, 107, 104, 108, 105, 107, 106, 109, 106, 109, 107, 109, 107, 110, 108,
110, 109, 112, 109, 112, 109, 113, 108, 112, 109, 114, 110, 114, 110, 114, 111,
115, 110, 114, 112, 115, 111, 115, 111, 115, 112, 116, 111, 117, 113, 118, 113,
117, 113, 117, 113, 119, 114, 119, 112, 118, 113, 118, 113, 119, 114, 118, 114,
119, 113, 120, 114, 119, 114, 119, 114, 120, 114, 119, 114, 119, 114, 119, 114,
119, 114, 119, 114, 119, 114, 119, 115, 118, 114, 118, 113, 119, 114, 118, 113,
118, 114, 118, 114, 118, 113, 118, 113, 118, 112, 117, 113, 117, 112, 117, 112,
117, 112, 117, 112, 117, 111, 116, 112, 117, 112, 117, 111, 117, 111, 117, 111,
117, 111, 117, 110, 118, 110, 116, 110, 117, 110, 118, 110, 116, 110, 116, 109,
117, 109, 117, 109, 117, 109, 116, 109, 116, 108, 117, 108, 116, 107, 117, 108,
116, 108, 116, 108, 116, 108, 115, 108, 115, 107, 115, 107, 115, 108, 114, 106,
114, 107, 114, 106, 113, 106, 114, 106, 114, 106, 114, 106, 114, 107, 113, 106,
113, 106, 112, 107, 114, 107, 113, 106, 112, 107, 113, 106, 112, 106, 112, 106,
113, 106, 112, 106, 111, 105, 112, 106, 111, 105, 110, 105, 110, 105, 110, 106,
110, 105, 110, 104, 109, 105, 109, 106, 109, 105, 109, 104, 107, 104, 108, 105,
108, 104, 108, 104, 107, 104, 107, 104, 106, 104, 107, 104, 106, 104, 104, 104,
104, 103, 104, 105, 104, 104, 103, 104, 103, 104, 102, 103, 102, 103, 102, 103,
101, 102, 99, 103, 100, 102, 99, 102, 98, 102, 98, 101, 97, 100, 95, 100, 94,
100, 93, 100, 92, 99, 91, 99, 90, 99, 89, 99, 89, 97, 88, 98, 86, 97, 87, 97,
85, 97, 84, 95, 83, 95, 82, 95, 81, 94, 80, 94, 79, 93, 79, 92, 77, 92, 76, 91,
74, 90, 74, 90, 71, 88, 70, 88, 69, 88, 67, 87, 66, 86, 64, 86, 62, 85, 61, 83,
59, 82, 57, 81, 56, 81, 53, 79, 51, 77, 50, 77, 48, 75, 45, 73, 42, 72, 39, 71,
36, 69, 34, 66, 30, 66, 28, 63, 25, 61, 22, 60, 17, 57, 14, 55, 10, 52, 6, 50,
3, 47, -1, 45, -4, 43, -6, 40, -10, 37, -13, 34, -16, 31, -18, 27, -20, 25, -23,
20, -26, 16, -29, 11, -31, 5, -34, -7, -37, -20, -38, -30, -42, -36, -45, -41,
-46, -45, -48, -47, -51, -52, -54, -54, -55, -56, -57, -60, -59, -62, -61, -64,
-64, -67, -66, -68, -69, -69, -71, -72, -73, -73, -75, -75, -77, -78, -78, -79,
-80, -81, -81, -83, -83, -83, -83, -84, -85, -85, -86, -86, -87, -87, -88, -89,
-90, -90, -91, -91, -92, -92, -93, -93, -94, -94, -96, -95, -97, -96, -97, -95,
-98, -97, -100, -98, -99, -98, -100, -99, -101, -100, -102, -100, -103, -101,
-103, -101, -104, -102, -104, -103, -104, -103, -105, -104, -106, -105, -107,
-105, -108, -106, -108, -105, -109, -106, -109, -107, -109, -107, -110, -107,
-111, -108, -111, -108, -112, -109, -112, -109, -112, -109, -114, -110, -114,
-110, -113, -110, -115, -110, -114, -111, -115, -111, -116, -112, -116, -112,
-116, -112, -117, -113, -117, -112, -117, -113, -117, -112, -118, -113, -118,
-113, -118, -114, -119, -114, -119, -113, -119, -114, -119, -113, -120, -114,
-118, -114, -119, -113, -119, -114, -119, -114, -119, -114, -118, -115, -119,
-114, -118, -114, -119, -113, -119, -114, -118, -114, -118, -114, -117, -114,
-118, -114, -118, -113, -118, -114, -117, -113, -118, -113, -118, -113, -117,
-113, -117, -113, -117, -112, -116, -112, -117, -112, -117, -111, -116, -111,
-117, -112, -117, -111, -117, -110, -116, -111, -116, -110, -117, -110, -117,
-110, -117, -109, -117, -109, -117, -110, -118, -109, -117, -109, -116, -108,
-117, -109, -117, -108, -117, -109, -117, -108, -117, -108, -117, -108, -116,
-108, -116, -108, -116, -108, -116, -107, -115, -107, -115, -106, -114, -107,
-115, -106, -114, -106, -114, -107, -113, -106, -113, -106, -113, -105, -113,
-106, -113, -106, -114, -106, -113, -106, -113, -106, -114, -107, -114, -106,
-113, -107, -113, -106, -112, -106, -112, -106, -113, -106, -113, -105, -111,
-106, -112, -106, -111, -106, -111, -105, -110, -105, -110, -105, -110, -106,
-110, -104, -109, -105, -109, -104, -108, -104, -109, -105, -108, -104, -108,
-105, -108, -104, -107, -104, -107, -104, -107, -103, -107, -103, -107, -104,
-106, -103, -106, -104, -106, -103, -104, -104, -105, -104, -104, -104, -104,
-104, -104, -103, -102, -103, -101, -103, -101, -102, -101, -102, -99, -102,
-99, -102, -98, -102, -97, -101, -97, -100, -97, -101, -95, -100, -94, -99, -92,
-100, -92, -99, -92, -99, -90, -98, -89, -98, -89, -98, -87, -97, -87, -97, -86,
-96, -85, -97, -84, -96, -83, -95, -82, -95, -80, -94, -79, -93, -79, -93, -77,
-93, -76, -92, -75, -92, -74, -91, -73, -89, -72, -90, -69, -87, -68, -88, -67,
-86, -66, -86, -63, -84, -62, -84, -61, -83, -58, -82, -57, -81, -56, -80, -52,
-78, -52, -78, -49, -76, -47, -75, -44, -73, -42, -72, -38, -70, -36, -68, -33,
-67, -31, -64, -28, -64, -24, -60, -21, -60, -17, -56, -13, -56, -9, -50, -6,
-53, -2, -40, };