#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0116

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -17, 4, -17, 7, -14, 11, -11, 14,
-8, 16, -5, 18, -3, 22, -1, 25, 3, 28, 5, 30, 8, 32, 11, 35, 13, 39, 16, 41, 19,
44, 22, 46, 24, 48, 27, 51, 29, 53, 32, 56, 34, 58, 36, 60, 39, 62, 42, 65, 44,
67, 46, 69, 49, 70, 51, 73, 53, 75, 55, 76, 58, 78, 60, 79, 61, 81, 64, 83, 66,
85, 68, 87, 69, 88, 72, 90, 73, 90, 75, 92, 77, 94, 79, 93, 80, 95, 82, 96, 83,
98, 84, 97, 86, 98, 87, 99, 89, 100, 90, 101, 90, 102, 92, 101, 93, 102, 94,
103, 96, 104, 95, 102, 96, 103, 97, 102, 98, 103, 98, 103, 99, 103, 99, 102, 99,
102, 100, 102, 100, 101, 100, 101, 100, 100, 101, 100, 101, 98, 100, 98, 100,
98, 99, 96, 99, 95, 100, 95, 99, 93, 98, 92, 98, 91, 97, 90, 96, 89, 95, 88, 94,
86, 94, 85, 92, 83, 91, 82, 90, 80, 90, 79, 89, 77, 87, 75, 86, 74, 84, 72, 84,
70, 82, 68, 80, 66, 78, 65, 77, 63, 75, 60, 73, 59, 72, 57, 71, 55, 68, 54, 67,
51, 65, 49, 63, 47, 61, 45, 60, 43, 57, 40, 55, 38, 53, 37, 50, 35, 49, 33, 47,
30, 45, 28, 43, 26, 41, 24, 38, 21, 37, 20, 35, 18, 33, 15, 30, 14, 27, 11, 26,
9, 24, 8, 22, 6, 21, 3, 19, 1, 16, 0, 14, -1, 12, -4, 10, -5, 8, -7, 6, -8, 4,
-9, 3, -11, 0, -13, 0, -15, -3, -15, -5, -18, -6, -18, -7, -20, -9, -21, -10,
-22, -12, -24, -13, -25, -15, -27, -16, -26, -18, -27, -19, -29, -20, -30, -21,
-31, -23, -32, -23, -33, -25, -33, -25, -33, -25, -34, -26, -34, -28, -34, -28,
-35, -28, -35, -30, -36, -30, -36, -30, -36, -31, -36, -31, -36, -32, -37, -32,
-37, -32, -37, -32, -37, -32, -37, -33, -35, -33, -36, -33, -36, -33, -37, -33,
-36, -33, -35, -33, -35, -33, -35, -33, -35, -32, -34, -32, -34, -32, -33, -32,
-33, -32, -33, -31, -32, -31, -31, -32, -31, -31, -30, -30, -29, -30, -29, -30,
-28, -29, -28, -29, -28, -29, -27, -28, -26, -28, -25, -28, -25, -26, -25, -26,
-24, -25, -23, -25, -22, -24, -21, -23, -20, -23, -18, -23, -19, -22, -18, -21,
-17, -20, -15, -20, -15, -19, -13, -18, -13, -18, -11, -17, -11, -16, -10, -16,
-9, -15, -7, -14, -7, -14, -6, -13, -4, -12, -3, -10, -3, -10, -1, -10, 0, -8,
0, -7, 2, -7, 3, -5, 5, -5, 6, -4, 7, -2, 9, -1, 9, 0, 11, 1, 12, 2, 14, 3, 15,
4, 17, 6, 18, 7, 20, 8, 21, 9, 22, 11, 23, 12, 25, 13, 28, 15, 28, 17, 30, 18,
31, 19, 33, 20, 35, 22, 37, 23, 38, 25, 40, 26, 40, 28, 42, 30, 43, 31, 46, 32,
47, 35, 48, 35, 51, 37, 52, 38, 54, 41, 55, 43, 57, 44, 58, 45, 59, 47, 61, 49,
63, 51, 65, 52, 65, 54, 67, 55, 69, 57, 69, 58, 71, 60, 71, 61, 74, 62, 74, 63,
75, 65, 76, 67, 78, 69, 78, 69, 80, 70, 79, 72, 82, 73, 82, 74, 82, 75, 83, 75,
84, 77, 84, 78, 85, 79, 85, 79, 85, 81, 85, 81, 85, 82, 86, 81, 85, 83, 86, 83,
86, 84, 85, 84, 84, 84, 85, 84, 84, 84, 84, 84, 83, 84, 82, 84, 82, 84, 81, 83,
80, 83, 79, 83, 78, 82, 77, 82, 76, 81, 75, 81, 74, 79, 72, 79, 71, 77, 69, 76,
68, 75, 67, 75, 65, 73, 64, 72, 62, 70, 60, 70, 58, 69, 56, 66, 55, 65, 53, 64,
51, 62, 49, 60, 47, 59, 46, 57, 43, 56, 41, 54, 39, 52, 37, 50, 35, 48, 32, 46,
30, 45, 28, 42, 25, 40, 23, 38, 22, 37, 19, 34, 17, 32, 15, 31, 12, 28, 10, 26,
9, 24, 7, 22, 4, 20, 2, 18, 0, 16, -3, 13, -4, 11, -7, 9, -9, 7, -11, 5, -14, 3,
-15, 1, -17, -1, -18, -3, -20, -5, -23, -7, -25, -9, -27, -11, -29, -13, -30,
-16, -32, -17, -35, -19, -36, -20, -38, -23, -40, -25, -41, -26, -42, -28, -44,
-30, -46, -32, -47, -33, -50, -36, -51, -37, -53, -39, -54, -40, -56, -42, -57,
-44, -58, -46, -59, -47, -61, -48, -63, -50, -64, -51, -65, -53, -67, -54, -68,
-56, -70, -58, -71, -59, -71, -62, -73, -63, -74, -64, -76, -65, -77, -66, -77,
-68, -79, -69, -80, -70, -82, -71, -83, -73, -84, -74, -85, -75, -85, -76, -87,
-78, -88, -79, -88, -80, -90, -82, -91, -83, -91, -84, -93, -85, -94, -86, -94,
-87, -96, -88, -96, -90, -97, -90, -98, -92, -99, -92, -100, -93, -100, -95,
-101, -95, -103, -96, -103, -98, -104, -98, -105, -100, -105, -100, -107, -102,
-108, -103, -108, -103, -109, -105, -110, -105, -110, -106, -112, -107, -113,
-109, -113, -108, -113, -109, -114, -111, -115, -111, -115, -112, -116, -113,
-117, -113, -117, -113, -117, -115, -117, -115, -117, -115, -118, -115, -118,
-116, -119, -116, -120, -117, -120, -118, -119, -117, -118, -117, -119, -118,
-118, -118, -118, -117, -118, -118, -118, -118, -118, -117, -118, -118, -116,
-117, -116, -116, -115, -117, -114, -116, -114, -116, -112, -115, -112, -115,
-109, -113, -109, -113, -108, -112, -106, -111, -105, -110, -104, -109, -102,
-109, -101, -107, -99, -106, -98, -104, -95, -102, -94, -102, -92, -100, -90,
-98, -87, -96, -85, -96, -84, -94, -81, -91, -79, -89, -77, -87, -74, -86, -72,
-84, -69, -82, -67, -80, -64, -77, -61, -75, -59, -72, -55, -70, -53, -67, -50,
-66, -47, -64, -45, -62, -42, -58, -39, -56, -36, -53, -34, -51, -30, -48, -27,
-46, -25, -42, -21, -41, -18, -37, -15, -35, -13, -31, -10, -30, -7, -26, -3,
-25, -1, -18, };