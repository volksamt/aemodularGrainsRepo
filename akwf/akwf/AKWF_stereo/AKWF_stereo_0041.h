#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0041

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 5, 6, 7, 9, 10, 12, 13, 14, 16,
16, 18, 18, 20, 21, 22, 23, 25, 24, 26, 26, 28, 28, 30, 30, 31, 30, 33, 32, 34,
33, 35, 35, 37, 34, 39, 35, 40, 36, 40, 36, 41, 37, 42, 37, 42, 38, 43, 37, 44,
38, 43, 37, 43, 38, 44, 37, 44, 37, 44, 38, 44, 37, 44, 37, 44, 36, 43, 35, 44,
35, 43, 35, 43, 35, 43, 35, 42, 34, 42, 35, 42, 35, 42, 34, 41, 34, 42, 34, 41,
35, 41, 35, 41, 35, 41, 35, 42, 36, 42, 36, 42, 36, 43, 38, 42, 38, 43, 39, 43,
40, 45, 42, 45, 42, 46, 44, 47, 46, 47, 46, 49, 48, 50, 51, 50, 53, 52, 54, 54,
55, 56, 58, 57, 60, 59, 62, 59, 63, 62, 67, 64, 68, 66, 71, 68, 73, 69, 75, 71,
77, 72, 80, 74, 81, 77, 84, 78, 87, 82, 88, 83, 91, 85, 93, 87, 95, 89, 97, 91,
98, 93, 101, 94, 102, 97, 104, 98, 106, 100, 107, 102, 108, 104, 109, 105, 111,
107, 111, 108, 112, 110, 114, 111, 115, 112, 115, 113, 114, 114, 115, 115, 115,
115, 115, 117, 116, 118, 116, 118, 114, 118, 114, 119, 114, 118, 113, 118, 112,
119, 112, 119, 110, 119, 110, 118, 109, 117, 107, 117, 107, 117, 105, 117, 104,
115, 103, 115, 101, 113, 99, 113, 99, 112, 97, 111, 95, 110, 94, 109, 92, 108,
90, 107, 90, 106, 89, 105, 87, 103, 86, 102, 85, 100, 84, 100, 82, 98, 82, 96,
81, 95, 80, 95, 79, 93, 78, 92, 78, 90, 77, 89, 77, 88, 76, 88, 76, 86, 76, 86,
75, 84, 75, 83, 75, 83, 75, 81, 75, 80, 75, 79, 76, 79, 77, 79, 77, 77, 77, 76,
78, 76, 78, 76, 79, 75, 79, 74, 79, 73, 80, 73, 80, 73, 81, 73, 82, 73, 82, 72,
83, 72, 83, 72, 83, 72, 83, 71, 84, 71, 84, 71, 85, 71, 85, 71, 85, 71, 85, 71,
85, 71, 85, 70, 85, 70, 85, 70, 84, 70, 85, 70, 84, 70, 83, 70, 82, 69, 81, 69,
81, 69, 80, 69, 78, 68, 78, 69, 77, 68, 75, 67, 74, 68, 74, 67, 72, 67, 70, 66,
69, 65, 67, 65, 65, 64, 63, 64, 61, 63, 60, 63, 59, 62, 56, 62, 56, 60, 53, 60,
51, 60, 50, 59, 48, 57, 47, 57, 45, 56, 44, 56, 41, 55, 40, 53, 38, 54, 37, 52,
36, 51, 34, 50, 33, 50, 31, 49, 30, 47, 28, 46, 28, 45, 27, 45, 26, 44, 25, 43,
24, 43, 24, 41, 23, 40, 23, 40, 23, 39, 21, 37, 22, 37, 21, 35, 20, 34, 21, 33,
21, 32, 21, 31, 21, 30, 20, 30, 20, 28, 21, 26, 20, 26, 21, 25, 21, 24, 21, 23,
22, 21, 22, 20, 21, 19, 21, 18, 22, 17, 22, 16, 22, 15, 22, 14, 22, 12, 21, 11,
21, 10, 21, 8, 21, 7, 20, 7, 20, 6, 19, 3, 18, 3, 19, 2, 18, 0, 17, -1, 15, -3,
15, -4, 14, -5, 11, -6, 11, -8, 10, -9, 8, -11, 7, -11, 6, -13, 4, -13, 2, -15,
0, -16, -1, -18, -4, -18, -4, -20, -7, -20, -8, -22, -10, -22, -13, -23, -14,
-25, -16, -25, -18, -27, -20, -27, -22, -28, -24, -28, -26, -29, -28, -31, -29,
-31, -32, -32, -33, -32, -34, -33, -35, -33, -37, -34, -39, -34, -40, -35, -42,
-35, -43, -36, -44, -35, -45, -36, -46, -36, -47, -36, -48, -37, -48, -36, -49,
-36, -50, -37, -50, -38, -50, -37, -50, -37, -51, -38, -51, -37, -51, -38, -51,
-37, -51, -38, -51, -37, -51, -38, -51, -38, -51, -38, -51, -38, -51, -39, -49,
-39, -49, -39, -49, -39, -49, -39, -48, -41, -47, -41, -48, -41, -47, -42, -48,
-43, -47, -44, -47, -44, -46, -46, -47, -46, -47, -47, -47, -49, -46, -49, -47,
-50, -47, -52, -47, -53, -47, -54, -48, -56, -50, -58, -49, -59, -51, -61, -51,
-62, -52, -65, -54, -66, -54, -68, -56, -70, -57, -72, -58, -73, -60, -76, -62,
-77, -63, -79, -66, -81, -66, -83, -70, -85, -71, -87, -72, -90, -74, -92, -77,
-93, -79, -96, -81, -97, -83, -99, -86, -101, -87, -102, -90, -104, -92, -106,
-94, -107, -96, -109, -97, -110, -100, -111, -102, -112, -104, -113, -105, -115,
-107, -116, -108, -116, -109, -117, -111, -118, -112, -118, -114, -118, -114,
-119, -116, -119, -117, -119, -117, -119, -118, -119, -118, -119, -119, -118,
-118, -117, -119, -118, -118, -117, -119, -115, -118, -115, -118, -115, -117,
-113, -118, -113, -116, -111, -116, -110, -115, -108, -113, -107, -112, -107,
-112, -105, -110, -103, -109, -103, -107, -100, -105, -99, -104, -98, -103, -97,
-101, -95, -100, -93, -97, -91, -97, -90, -94, -89, -93, -88, -92, -87, -90,
-85, -88, -84, -86, -83, -85, -83, -83, -82, -83, -80, -81, -79, -79, -79, -79,
-77, -78, -78, -77, -77, -75, -77, -75, -77, -75, -76, -73, -75, -73, -75, -73,
-75, -72, -75, -71, -76, -72, -77, -72, -77, -73, -78, -73, -77, -73, -78, -73,
-79, -73, -80, -74, -80, -74, -81, -76, -83, -76, -83, -76, -84, -78, -85, -78,
-85, -79, -86, -80, -86, -81, -88, -82, -88, -83, -89, -83, -90, -84, -91, -85,
-91, -86, -92, -87, -94, -87, -94, -88, -93, -89, -95, -89, -95, -90, -95, -90,
-95, -91, -95, -91, -94, -90, -94, -90, -93, -89, -93, -89, -92, -89, -91, -88,
-91, -88, -90, -86, -89, -85, -87, -85, -86, -83, -84, -81, -83, -80, -81, -79,
-79, -76, -76, -75, -74, -72, -72, -70, -69, -67, -67, -65, -65, -62, -61, -60,
-58, -56, -56, -54, -53, -50, -51, -48, -47, -45, -45, -42, -42, -39, -38, -36,
-34, -32, -32, -30, -28, -25, -24, -22, -22, -20, -19, -16, -16, -13, -12, -10,
-10, -7, -6, -5, -3, 0, 0, 2, };