#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0146

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -7, 14, -1, 26, 11, 36, 17, 46, 27,
54, 33, 62, 40, 70, 46, 76, 52, 82, 58, 88, 64, 92, 69, 96, 74, 99, 77, 102, 80,
104, 84, 108, 89, 110, 92, 111, 96, 113, 100, 114, 102, 115, 105, 115, 106, 116,
109, 117, 110, 118, 112, 118, 113, 119, 115, 117, 116, 117, 117, 112, 115, 99,
109, 98, 106, 96, 103, 94, 103, 91, 103, 89, 101, 88, 99, 85, 98, 83, 97, 81,
95, 79, 93, 75, 91, 73, 90, 69, 86, 66, 84, 57, 79, 37, 66, 31, 56, 27, 51, 23,
45, 19, 41, 16, 37, 12, 32, 9, 28, 6, 24, 3, 20, 0, 16, -4, 12, -5, 9, -10, 4,
-9, 3, -32, -10, -44, -26, -42, -31, -47, -35, -49, -37, -53, -40, -56, -41,
-60, -46, -63, -48, -65, -51, -68, -53, -69, -56, -69, -57, -70, -59, -69, -60,
-70, -61, -70, -64, -71, -66, -75, -70, -78, -75, -82, -79, -83, -82, -86, -85,
-87, -90, -89, -91, -89, -94, -89, -94, -87, -95, -86, -95, -83, -95, -84, -94,
-80, -93, -84, -94, -97, -102, -95, -104, -95, -105, -93, -104, -91, -103, -88,
-101, -86, -99, -82, -97, -77, -93, -72, -91, -66, -87, -61, -83, -54, -78, -50,
-74, -43, -70, -48, -69, -56, -73, -51, -73, -47, -70, -44, -66, -41, -59, -38,
-55, -36, -50, -34, -45, -33, -40, -31, -34, -28, -28, -27, -23, -22, -16, -19,
-9, -11, -1, -23, -3, -27, -7, -16, -5, -9, 1, 2, 9, 10, 16, 18, 22, 26, 28, 33,
33, 37, 38, 43, 40, 47, 45, 53, 50, 57, 55, 63, 59, 66, 63, 67, 67, 72, 69, 76,
75, 78, 79, 80, 83, 82, 87, 85, 91, 86, 94, 88, 96, 92, 99, 93, 101, 96, 103,
96, 105, 99, 107, 100, 109, 103, 110, 99, 109, 85, 102, 87, 99, 86, 98, 87, 96,
88, 96, 87, 95, 89, 95, 88, 93, 89, 93, 88, 92, 88, 90, 86, 90, 86, 88, 83, 87,
82, 85, 72, 78, 61, 68, 59, 62, 58, 57, 57, 56, 56, 53, 55, 51, 55, 48, 54, 45,
53, 42, 51, 39, 50, 36, 48, 34, 48, 31, 44, 29, 44, 26, 23, 13, 10, -3, 8, -11,
1, -15, -4, -19, -11, -23, -17, -26, -26, -30, -32, -35, -37, -39, -43, -41,
-48, -44, -53, -47, -56, -49, -58, -52, -61, -53, -64, -55, -69, -58, -76, -64,
-82, -69, -88, -75, -91, -79, -97, -85, -99, -88, -102, -91, -103, -94, -105,
-96, -105, -98, -105, -99, -103, -99, -106, -100, -105, -101, -110, -103, -121,
-111, -118, -114, -119, -114, -119, -114, -117, -113, -116, -112, -114, -110,
-112, -108, -108, -106, -104, -103, -100, -99, -95, -96, -88, -91, -84, -87,
-78, -82, -79, -82, -85, -84, -78, -83, -74, -80, -68, -76, -64, -70, -58, -66,
-54, -61, -49, -55, -45, -50, -40, -43, -35, -38, -30, -32, -21, -24, -15, -17,
-2, -7, -17, -12, -12, -14, 5, -7, 14, 0, 27, 11, 37, 19, 47, 27, 55, 34, 64,
41, 69, 46, 76, 53, 82, 59, 88, 64, 93, 69, 96, 74, 100, 77, 102, 81, 105, 85,
108, 89, 110, 93, 111, 97, 114, 100, 114, 103, 115, 105, 116, 107, 116, 109,
117, 110, 118, 112, 118, 114, 119, 115, 117, 115, 118, 117, 110, 115, 99, 109,
98, 105, 96, 103, 93, 103, 91, 102, 89, 101, 87, 99, 86, 99, 83, 97, 81, 95, 79,
93, 75, 90, 73, 89, 68, 87, 66, 84, 54, 78, 35, 65, 32, 56, 27, 50, 24, 45, 18,
40, 15, 37, 12, 32, 9, 28, 6, 24, 1, 19, -1, 16, -4, 11, -6, 9, -10, 4, -10, 4,
-32, -12, -43, -25, -43, -31, -47, -35, -49, -38, -53, -40, -57, -42, -61, -46,
-62, -48, -66, -52, -67, -54, -69, -56, -69, -58, -70, -59, -70, -60, -69, -62,
-69, -63, -72, -67, -75, -71, -78, -75, -81, -79, -84, -84, -86, -87, -87, -89,
-89, -92, -89, -93, -88, -95, -86, -95, -85, -96, -82, -95, -83, -96, -79, -93,
-86, -95, -97, -103, -94, -105, -96, -106, -93, -103, -91, -102, -87, -101, -85,
-98, -82, -96, -76, -93, -72, -90, -65, -86, -60, -83, -54, -78, -49, -74, -43,
-69, -49, -70, -55, -73, -49, -73, -47, -69, -43, -65, -41, -59, -38, -54, -36,
-49, -33, -45, -33, -39, -31, -34, -28, -28, -26, -22, -22, -15, -18, -9, -10,
-1, -22, -3, -26, -8, -16, -3, -8, 2, 3, 10, 11, 16, 20, 23, 25, 27, 33, 33, 37,
37, 44, 42, 48, 46, 54, 51, 58, 56, 62, 60, 66, 64, 68, 67, 71, 70, 77, 75, 78,
79, 80, 84, 83, 87, 85, 91, 88, 94, 89, 97, 91, 99, 93, 100, 96, 104, 96, 105,
100, 107, 99, 109, 103, 111, 97, 110, 85, 102, 87, 99, 87, 97, 88, 96, 87, 95,
88, 95, 87, 94, 88, 94, 88, 93, 87, 91, 87, 90, 86, 89, 86, 89, 83, 86, 81, 84,
70, 77, 60, 67, 59, 61, 58, 57, 58, 55, 56, 53, 55, 50, 55, 48, 54, 45, 53, 41,
51, 39, 50, 37, 48, 33, 47, 31, 44, 28, 44, 26, 20, 10, 10, -4, 8, -10, 1, -16,
-4, -19, -12, -24, -18, -27, -26, -30, -31, -35, -39, -39, -43, -42, -49, -45,
-52, -47, -55, -49, -58, -51, -61, -54, -65, -55, -70, -60, -77, -65, -82, -71,
-88, -75, -92, -80, -96, -83, -98, -87, -102, -91, -103, -94, -105, -96, -105,
-98, -105, -98, -104, -100, -105, -101, -104, -100, -112, -104, -120, -111,
-118, -113, -119, -114, -118, -114, -117, -113, -116, -112, -113, -110, -110,
-108, -107, -106, -104, -102, -99, -99, -94, -95, -88, -91, -83, -86, -78, -82,
-80, -81, -85, -84, -78, -83, -74, -80, -68, -75, -63, -69, -58, -65, -54, -60,
-49, -54, -45, -49, -40, -44, -34, -37, -29, -31, -21, -23, -14, -17, -2, -6,
-18, -14, -10, -12, };