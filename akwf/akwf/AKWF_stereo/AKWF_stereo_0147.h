#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0147

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 11, 14, 20, 21, 28, 29, 36, 35,
43, 42, 50, 48, 57, 54, 62, 59, 66, 62, 69, 66, 73, 68, 77, 71, 81, 74, 85, 77,
88, 80, 92, 84, 95, 86, 98, 91, 102, 93, 105, 97, 108, 100, 109, 103, 111, 106,
114, 109, 116, 110, 117, 113, 118, 114, 119, 115, 119, 117, 119, 118, 118, 118,
118, 119, 116, 118, 115, 118, 112, 117, 110, 117, 108, 117, 105, 115, 103, 114,
101, 113, 99, 113, 97, 112, 95, 111, 91, 110, 88, 108, 85, 104, 81, 102, 76,
100, 71, 95, 66, 91, 61, 87, 56, 82, 50, 77, 45, 73, 39, 66, 33, 62, 27, 56, 20,
50, 14, 44, 8, 39, 2, 32, -3, 28, -6, 23, -10, 19, -12, 15, -13, 12, -12, 11,
-13, 9, -14, 7, -14, 5, -14, 2, -14, 1, -15, -2, -16, -5, -16, -8, -17, -11,
-19, -13, -20, -15, -21, -18, -24, -21, -25, -23, -28, -24, -30, -27, -32, -28,
-35, -31, -36, -31, -38, -33, -40, -36, -41, -38, -44, -40, -46, -41, -47, -44,
-48, -47, -50, -48, -50, -51, -51, -55, -51, -56, -50, -59, -50, -61, -47, -62,
-45, -63, -42, -64, -38, -63, -36, -64, -31, -63, -28, -61, -25, -60, -21, -59,
-17, -58, -14, -56, -12, -55, -9, -53, -7, -50, -5, -49, -2, -47, 1, -45, 3,
-41, 5, -39, 6, -36, 7, -33, 8, -31, 7, -28, 6, -25, 6, -22, 5, -20, 4, -17, 5,
-15, 5, -11, 5, -9, 6, -6, 7, -2, 8, 0, 10, 4, 12, 8, 13, 11, 16, 14, 20, 16,
20, 19, 24, 22, 26, 24, 29, 25, 31, 27, 33, 29, 33, 32, 35, 33, 36, 35, 38, 35,
38, 37, 38, 38, 39, 39, 41, 40, 40, 42, 40, 43, 41, 44, 41, 45, 40, 44, 39, 43,
39, 44, 38, 42, 36, 41, 34, 40, 32, 38, 30, 36, 28, 35, 27, 34, 24, 33, 22, 31,
21, 31, 21, 30, 19, 29, 18, 28, 17, 28, 17, 26, 16, 25, 14, 23, 13, 21, 13, 19,
12, 16, 11, 14, 12, 12, 10, 9, 9, 6, 7, 3, 5, -2, 2, -4, -2, -9, -6, -13, -9,
-17, -14, -20, -17, -24, -20, -27, -23, -29, -26, -32, -28, -34, -29, -36, -31,
-38, -32, -39, -34, -40, -35, -41, -37, -43, -38, -44, -41, -46, -43, -47, -46,
-49, -49, -51, -52, -53, -55, -55, -58, -57, -62, -58, -65, -59, -68, -61, -72,
-62, -74, -63, -79, -64, -81, -67, -83, -69, -86, -70, -89, -72, -93, -75, -94,
-77, -97, -79, -100, -81, -101, -83, -103, -86, -104, -88, -106, -91, -107, -92,
-107, -94, -108, -95, -107, -94, -107, -94, -106, -93, -105, -92, -103, -92,
-101, -88, -99, -86, -95, -84, -94, -81, -90, -78, -87, -75, -83, -71, -79, -68,
-74, -63, -70, -60, -65, -55, -60, -50, -55, -45, -49, -41, -45, -37, -39, -33,
-36, -29, -33, -26, -30, -23, -24, -20, -19, -16, -11, -12, -5, -6, 4, 1, 12, 6,
19, 13, 27, 19, 34, 25, 40, 29, 44, 34, 49, 37, 53, 39, 57, 43, 60, 45, 64, 48,
67, 51, 72, 55, 76, 58, 79, 62, 83, 65, 86, 68, 89, 72, 93, 74, 96, 78, 98, 82,
101, 85, 103, 87, 104, 89, 106, 92, 108, 93, 109, 95, 108, 96, 108, 96, 106, 96,
106, 95, 104, 96, 103, 95, 100, 95, 99, 95, 97, 94, 96, 93, 93, 93, 92, 92, 89,
91, 88, 90, 86, 88, 81, 87, 79, 85, 75, 82, 71, 79, 67, 76, 62, 72, 57, 68, 52,
62, 47, 59, 42, 53, 37, 48, 32, 43, 26, 38, 19, 32, 13, 28, 8, 22, 4, 17, -1,
13, -4, 10, -7, 5, -8, 3, -10, 2, -11, 0, -11, -1, -10, -1, -9, -1, -9, -1, -8,
-2, -8, -3, -7, -4, -8, -5, -9, -6, -9, -8, -10, -9, -12, -10, -13, -11, -15,
-12, -17, -13, -19, -14, -22, -15, -22, -15, -24, -16, -26, -16, -28, -18, -29,
-19, -30, -20, -31, -21, -32, -23, -32, -25, -34, -26, -35, -29, -35, -31, -35,
-33, -34, -35, -32, -35, -31, -37, -28, -37, -24, -37, -20, -37, -16, -36, -12,
-35, -8, -32, -3, -32, 0, -29, 4, -27, 7, -25, 9, -23, 12, -21, 14, -19, 16,
-16, 18, -13, 19, -10, 21, -7, 22, -5, 23, -1, 23, 1, 22, 5, 22, 7, 20, 11, 19,
12, 18, 14, 17, 17, 17, 19, 16, 21, 16, 24, 16, 26, 16, 28, 17, 30, 18, 32, 19,
35, 21, 37, 23, 38, 25, 40, 26, 42, 29, 43, 30, 45, 32, 46, 33, 46, 34, 47, 35,
48, 36, 48, 36, 48, 36, 49, 36, 49, 36, 49, 37, 49, 36, 49, 36, 49, 36, 49, 35,
48, 34, 46, 33, 45, 32, 44, 29, 42, 27, 39, 25, 35, 22, 33, 19, 30, 16, 27, 14,
25, 10, 21, 8, 19, 6, 16, 3, 14, 2, 12, -1, 10, -2, 9, -4, 6, -4, 4, -6, 1, -8,
-2, -10, -5, -11, -9, -12, -13, -13, -17, -14, -19, -15, -23, -16, -27, -18,
-30, -20, -35, -23, -38, -26, -43, -29, -47, -33, -50, -36, -55, -39, -57, -41,
-61, -44, -63, -46, -65, -48, -68, -48, -68, -49, -70, -51, -71, -52, -73, -53,
-75, -54, -74, -55, -76, -57, -77, -59, -79, -61, -80, -64, -81, -66, -82, -70,
-84, -72, -85, -75, -86, -77, -88, -81, -89, -82, -90, -87, -91, -88, -91, -92,
-92, -93, -93, -96, -94, -98, -95, -100, -97, -102, -98, -104, -100, -105, -101,
-107, -104, -109, -104, -109, -106, -111, -106, -110, -107, -111, -108, -110,
-109, -110, -108, -109, -107, -107, -105, -106, -103, -104, -101, -101, -98,
-99, -95, -96, -91, -92, -88, -89, -84, -84, -80, -80, -75, -75, -71, -69, -65,
-64, -60, -58, -54, -53, -49, -47, -43, -42, -37, -36, -32, -32, -26, -27, -22,
-24, -18, -18, -12, -12, -6, -3, 0, };