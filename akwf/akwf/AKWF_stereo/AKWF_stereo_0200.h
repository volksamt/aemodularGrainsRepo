#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0200

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -25, 3, -29, 4, -26, 5, -26, 7,
-24, 7, -23, 9, -21, 10, -21, 12, -19, 13, -19, 14, -16, 15, -15, 17, -14, 19,
-13, 20, -11, 21, -10, 22, -7, 23, -6, 26, -6, 26, -4, 28, -3, 30, -2, 31, 1,
33, 1, 34, 3, 35, 4, 37, 7, 38, 8, 40, 10, 42, 12, 45, 14, 45, 16, 48, 17, 49,
20, 51, 21, 53, 25, 55, 26, 57, 28, 59, 31, 60, 33, 63, 35, 64, 37, 67, 40, 68,
44, 71, 46, 73, 48, 74, 51, 76, 54, 78, 56, 81, 59, 83, 61, 84, 64, 85, 66, 87,
69, 88, 71, 89, 73, 91, 76, 91, 78, 92, 79, 93, 81, 95, 83, 95, 86, 97, 88, 97,
90, 98, 91, 98, 93, 99, 94, 99, 96, 100, 97, 100, 98, 101, 100, 101, 100, 101,
102, 101, 102, 101, 103, 102, 103, 103, 104, 102, 105, 103, 106, 103, 106, 103,
107, 103, 107, 104, 108, 104, 109, 104, 109, 104, 109, 104, 110, 105, 111, 105,
110, 106, 111, 107, 111, 106, 111, 107, 113, 108, 112, 107, 114, 109, 114, 109,
115, 109, 115, 110, 115, 111, 115, 111, 116, 112, 116, 112, 117, 112, 117, 112,
118, 114, 117, 113, 118, 115, 118, 114, 119, 114, 119, 114, 119, 114, 120, 115,
119, 114, 119, 114, 118, 113, 117, 113, 117, 112, 117, 112, 116, 111, 116, 111,
115, 109, 115, 109, 113, 107, 113, 105, 111, 104, 110, 103, 109, 101, 107, 99,
106, 97, 104, 95, 102, 93, 100, 91, 99, 88, 97, 86, 94, 84, 92, 82, 90, 79, 88,
76, 86, 74, 83, 72, 81, 69, 78, 66, 75, 63, 74, 61, 71, 58, 68, 55, 66, 52, 63,
50, 60, 47, 59, 45, 56, 43, 53, 40, 50, 37, 48, 36, 45, 33, 44, 31, 41, 28, 39,
27, 37, 24, 34, 23, 32, 20, 30, 18, 28, 16, 27, 15, 24, 13, 22, 10, 20, 9, 18,
7, 17, 5, 14, 3, 12, 2, 10, 0, 8, -2, 6, -3, 5, -5, 3, -6, 1, -8, -1, -10, -2,
-12, -4, -13, -4, -15, -8, -15, -9, -16, -10, -19, -12, -19, -14, -22, -14, -22,
-16, -24, -18, -26, -19, -27, -21, -28, -23, -29, -24, -31, -26, -32, -27, -33,
-28, -34, -29, -35, -30, -36, -33, -37, -34, -39, -35, -39, -36, -39, -39, -42,
-39, -42, -41, -44, -43, -44, -44, -44, -46, -46, -47, -46, -49, -47, -49, -48,
-52, -49, -53, -49, -54, -51, -55, -51, -57, -51, -59, -52, -60, -52, -61, -52,
-63, -52, -64, -54, -66, -54, -67, -54, -68, -55, -70, -56, -71, -56, -73, -56,
-74, -56, -75, -56, -76, -57, -77, -57, -78, -58, -79, -58, -80, -58, -82, -59,
-83, -59, -83, -60, -84, -59, -85, -61, -86, -61, -87, -62, -87, -61, -89, -62,
-88, -62, -89, -63, -89, -63, -89, -64, -90, -64, -90, -64, -90, -65, -91, -65,
-90, -67, -91, -67, -90, -67, -90, -68, -90, -68, -90, -69, -90, -70, -90, -69,
-90, -69, -90, -70, -90, -72, -89, -71, -89, -72, -89, -72, -89, -72, -88, -73,
-87, -74, -87, -74, -86, -74, -86, -74, -86, -74, -85, -74, -84, -74, -84, -73,
-84, -75, -84, -73, -83, -74, -82, -74, -81, -73, -80, -73, -79, -72, -78, -71,
-77, -70, -76, -70, -76, -69, -74, -68, -73, -66, -72, -65, -70, -64, -69, -63,
-67, -62, -65, -60, -63, -59, -62, -57, -60, -56, -58, -53, -56, -52, -54, -49,
-51, -48, -50, -46, -46, -44, -45, -42, -43, -41, -40, -39, -38, -37, -36, -36,
-34, -34, -31, -33, -29, -31, -27, -30, -25, -29, -23, -27, -20, -26, -19, -25,
-17, -24, -16, -23, -14, -23, -11, -22, -9, -21, -8, -21, -7, -20, -6, -20, -5,
-19, -4, -20, -4, -19, -2, -20, -1, -20, -1, -20, -1, -20, 0, -20, 0, -21, 0,
-22, 1, -21, 1, -23, 0, -22, 0, -23, 0, -24, 1, -25, 0, -25, 0, -26, 0, -26, 0,
-26, -1, -27, 0, -27, 0, -28, 0, -27, 0, -27, 0, -28, -1, -27, 0, -27, 0, -27,
0, -27, 0, -27, 0, -26, 1, -27, 0, -26, 1, -26, 1, -26, 1, -26, 1, -25, 2, -25,
2, -25, 2, -25, 2, -25, 4, -24, 4, -23, 4, -22, 4, -23, 4, -23, 4, -23, 5, -22,
4, -24, 4, -23, 4, -23, 3, -24, 4, -24, 3, -24, 2, -25, 2, -25, 2, -26, 2, -26,
1, -27, 1, -27, 0, -28, 0, -28, -1, -28, -1, -29, -3, -29, -3, -31, -3, -31, -4,
-30, -5, -31, -5, -32, -6, -32, -6, -31, -7, -33, -8, -33, -9, -33, -10, -33,
-10, -33, -11, -34, -12, -34, -12, -34, -13, -33, -13, -34, -13, -34, -15, -34,
-15, -34, -15, -34, -15, -33, -16, -34, -16, -33, -17, -32, -17, -32, -17, -33,
-17, -32, -18, -32, -18, -32, -18, -31, -17, -31, -18, -30, -18, -31, -18, -31,
-18, -29, -19, -29, -19, -29, -18, -29, -18, -29, -18, -28, -18, -27, -18, -28,
-18, -27, -18, -28, -18, -28, -18, -28, -18, -27, -19, -28, -18, -28, -17, -28,
-19, -28, -19, -28, -18, -29, -19, -29, -19, -30, -19, -31, -19, -31, -20, -32,
-20, -31, -20, -32, -20, -33, -21, -33, -21, -33, -20, -34, -22, -34, -22, -34,
-23, -35, -23, -35, -24, -36, -24, -36, -25, -36, -25, -37, -26, -38, -26, -37,
-27, -38, -29, -38, -29, -39, -31, -39, -30, -39, -31, -40, -32, -38, -32, -40,
-34, -39, -34, -39, -35, -39, -37, -38, -37, -38, -38, -38, -38, -37, -39, -37,
-40, -37, -41, -36, -41, -35, -42, -34, -42, -33, -43, -32, -43, -32, -43, -31,
-43, -29, -43, -29, -43, -28, -44, -26, -43, -26, -43, -24, -44, -22, -43, -22,
-43, -20, -42, -19, -42, -17, -41, -16, -40, -14, -39, -13, -39, -11, -38, -9,
-38, -8, -36, -7, -36, -6, -34, -5, -35, -3, -32, -1, -33, -1, -27, };