#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0090

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 2, 5, 3, 9, 6, 11, 8, 15, 9, 18,
11, 20, 12, 24, 13, 26, 15, 29, 17, 33, 19, 35, 20, 38, 23, 40, 24, 43, 25, 46,
27, 48, 29, 50, 30, 52, 32, 55, 33, 56, 34, 60, 36, 61, 38, 63, 39, 66, 41, 68,
42, 69, 44, 71, 44, 73, 46, 75, 49, 77, 50, 78, 52, 80, 52, 81, 53, 83, 56, 84,
57, 86, 58, 87, 60, 88, 61, 89, 63, 91, 63, 91, 66, 93, 67, 94, 68, 95, 69, 96,
71, 97, 72, 98, 73, 99, 75, 99, 76, 100, 77, 101, 78, 101, 80, 103, 81, 102, 81,
104, 83, 104, 84, 105, 85, 104, 87, 106, 86, 106, 87, 107, 89, 107, 89, 108, 90,
108, 90, 107, 92, 108, 91, 109, 92, 109, 93, 109, 94, 110, 94, 110, 94, 110, 94,
110, 95, 110, 96, 110, 95, 111, 95, 111, 96, 110, 96, 109, 96, 110, 97, 110, 96,
111, 97, 110, 96, 110, 96, 109, 96, 110, 97, 110, 96, 110, 96, 110, 97, 109, 96,
109, 96, 110, 96, 109, 96, 109, 95, 109, 95, 109, 94, 109, 95, 109, 93, 108, 94,
108, 93, 108, 92, 108, 92, 108, 91, 107, 90, 106, 89, 106, 88, 104, 88, 105, 87,
104, 86, 103, 84, 102, 84, 101, 83, 100, 81, 100, 80, 98, 79, 97, 77, 96, 75,
94, 73, 93, 72, 92, 70, 90, 69, 88, 67, 86, 65, 85, 64, 83, 62, 80, 59, 79, 57,
78, 55, 75, 54, 73, 51, 70, 49, 67, 48, 66, 46, 63, 44, 61, 41, 58, 39, 54, 36,
52, 34, 49, 32, 46, 30, 44, 28, 41, 26, 37, 23, 34, 21, 32, 19, 29, 17, 25, 15,
22, 13, 18, 11, 16, 10, 11, 7, 8, 5, 5, 4, 3, 2, -1, 0, -4, -2, -7, -2, -11, -4,
-13, -6, -16, -7, -19, -8, -23, -10, -26, -12, -28, -14, -31, -14, -34, -15,
-36, -16, -39, -18, -41, -20, -44, -21, -46, -22, -50, -24, -53, -25, -54, -26,
-57, -27, -58, -29, -61, -31, -63, -32, -66, -33, -68, -34, -69, -36, -71, -37,
-73, -39, -75, -41, -77, -41, -79, -43, -81, -44, -82, -46, -84, -47, -85, -50,
-87, -50, -88, -53, -89, -54, -90, -56, -91, -57, -92, -58, -94, -61, -95, -63,
-96, -64, -97, -66, -98, -66, -99, -69, -100, -70, -101, -73, -101, -74, -102,
-75, -103, -77, -104, -77, -104, -80, -105, -81, -105, -82, -107, -84, -107,
-85, -107, -86, -108, -88, -107, -88, -109, -90, -108, -91, -109, -92, -110,
-94, -111, -94, -111, -94, -111, -96, -110, -97, -111, -98, -112, -98, -111,
-98, -112, -99, -112, -100, -113, -100, -112, -101, -113, -101, -114, -102,
-113, -102, -113, -103, -113, -104, -113, -104, -113, -103, -114, -103, -114,
-104, -113, -104, -114, -105, -114, -104, -114, -105, -115, -104, -114, -104,
-115, -104, -115, -105, -114, -105, -115, -104, -115, -103, -114, -104, -114,
-104, -114, -104, -115, -103, -114, -104, -114, -104, -115, -103, -115, -103,
-114, -102, -116, -103, -115, -103, -114, -102, -115, -103, -115, -103, -115,
-102, -115, -103, -115, -102, -115, -102, -115, -102, -115, -102, -115, -101,
-115, -102, -115, -102, -116, -102, -116, -101, -115, -101, -116, -101, -116,
-101, -116, -101, -116, -101, -115, -102, -116, -102, -115, -102, -115, -101,
-116, -101, -116, -102, -116, -101, -117, -102, -116, -102, -116, -102, -115,
-101, -116, -102, -116, -102, -116, -102, -116, -102, -116, -102, -116, -103,
-116, -102, -116, -103, -117, -103, -117, -103, -116, -103, -116, -104, -116,
-104, -116, -105, -117, -106, -116, -106, -116, -106, -116, -106, -116, -107,
-117, -107, -116, -108, -116, -108, -117, -108, -117, -108, -116, -110, -116,
-110, -116, -110, -117, -110, -116, -110, -117, -111, -116, -111, -116, -111,
-116, -112, -116, -113, -116, -113, -117, -113, -117, -113, -116, -114, -117,
-114, -117, -114, -116, -114, -116, -115, -116, -115, -117, -115, -116, -115,
-117, -115, -116, -115, -117, -115, -116, -115, -117, -115, -116, -115, -117,
-115, -117, -115, -117, -115, -118, -114, -117, -113, -117, -114, -117, -113,
-118, -112, -118, -113, -118, -112, -118, -111, -118, -111, -117, -110, -117,
-109, -117, -109, -117, -109, -117, -108, -117, -108, -118, -107, -118, -106,
-118, -105, -118, -105, -118, -104, -118, -103, -118, -104, -119, -102, -118,
-101, -119, -101, -118, -100, -118, -100, -119, -99, -119, -99, -119, -99, -119,
-98, -119, -97, -119, -96, -119, -96, -119, -97, -119, -95, -119, -95, -119,
-95, -118, -94, -118, -94, -119, -94, -119, -93, -118, -94, -119, -93, -119,
-93, -119, -94, -119, -93, -119, -93, -119, -93, -118, -92, -118, -93, -119,
-93, -119, -92, -118, -92, -118, -93, -118, -92, -118, -92, -118, -92, -118,
-92, -117, -92, -117, -93, -118, -92, -117, -92, -117, -92, -117, -94, -116,
-93, -117, -93, -116, -94, -117, -93, -116, -94, -115, -93, -115, -95, -116,
-94, -115, -94, -115, -94, -115, -93, -115, -94, -115, -93, -114, -95, -114,
-94, -113, -94, -114, -94, -113, -95, -114, -95, -113, -94, -113, -95, -113,
-94, -113, -95, -113, -95, -113, -95, -112, -94, -112, -95, -112, -95, -111,
-94, -111, -93, -111, -94, -111, -95, -111, -94, -110, -94, -110, -94, -109,
-94, -110, -94, -109, -93, -109, -93, -109, -94, -109, -93, -108, -93, -108,
-93, -108, -93, -107, -92, -108, -91, -107, -91, -106, -90, -106, -90, -106,
-89, -105, -89, -105, -88, -104, -88, -103, -86, -103, -86, -102, -85, -100,
-83, -100, -82, -100, -81, -99, -80, -97, -78, -96, -77, -95, -76, -93, -74,
-91, -72, -90, -70, -88, -70, -88, -68, -85, -66, -84, -64, -81, -63, -79, -60,
-77, -58, -75, -56, -73, -53, -70, -52, -68, -50, -66, -47, -63, -46, -61, -43,
-58, -42, -56, -38, -53, -37, -50, -33, -47, -31, -44, -30, -41, -27, -39, -24,
-35, -22, -32, -20, -29, -18, -25, -16, -22, -13, -19, -12, -15, -10, -13, -7,
-10, -5, -6, -4, -3, -2, -1, };