#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0144

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -5, 3, -3, 4, 0, 7, 2, 9, 3, 9, 5,
12, 8, 14, 10, 16, 12, 17, 13, 19, 16, 22, 18, 23, 21, 24, 21, 26, 24, 27, 25,
29, 26, 29, 27, 30, 28, 31, 29, 31, 29, 32, 30, 33, 31, 34, 32, 35, 32, 36, 34,
37, 34, 37, 35, 38, 35, 38, 37, 39, 37, 39, 37, 40, 38, 39, 38, 40, 38, 40, 39,
41, 39, 40, 39, 41, 40, 41, 39, 42, 39, 41, 39, 42, 40, 42, 40, 43, 39, 43, 40,
43, 39, 43, 38, 43, 39, 44, 39, 44, 39, 44, 38, 44, 39, 44, 37, 45, 38, 44, 37,
44, 37, 44, 37, 44, 37, 44, 36, 44, 36, 44, 36, 44, 36, 44, 35, 45, 34, 45, 34,
45, 34, 45, 33, 45, 32, 45, 32, 45, 32, 45, 32, 45, 31, 46, 31, 47, 31, 46, 30,
47, 30, 47, 30, 47, 30, 47, 29, 46, 30, 48, 29, 48, 28, 48, 29, 48, 29, 49, 29,
50, 29, 50, 29, 51, 29, 51, 29, 52, 29, 51, 30, 52, 30, 53, 31, 54, 30, 55, 31,
55, 31, 55, 31, 56, 33, 57, 33, 59, 33, 59, 33, 59, 35, 60, 36, 60, 35, 61, 36,
62, 37, 64, 38, 64, 39, 65, 40, 65, 41, 67, 43, 68, 43, 69, 44, 70, 44, 70, 46,
71, 47, 72, 49, 73, 49, 74, 50, 76, 51, 76, 52, 78, 54, 79, 55, 79, 57, 80, 58,
81, 59, 82, 60, 84, 61, 85, 63, 86, 64, 86, 66, 87, 66, 89, 69, 89, 69, 90, 70,
91, 71, 92, 73, 93, 74, 93, 76, 93, 77, 94, 78, 95, 79, 96, 80, 97, 81, 97, 82,
98, 83, 99, 84, 99, 86, 100, 86, 100, 87, 100, 88, 101, 90, 102, 89, 103, 91,
103, 92, 103, 93, 104, 94, 104, 94, 105, 95, 105, 96, 106, 97, 105, 97, 105, 98,
106, 99, 107, 100, 107, 100, 107, 101, 107, 100, 108, 101, 107, 102, 107, 102,
107, 102, 108, 103, 107, 103, 108, 105, 107, 104, 107, 105, 107, 105, 107, 105,
107, 105, 107, 106, 107, 105, 106, 105, 106, 105, 106, 105, 105, 106, 105, 106,
106, 106, 105, 106, 104, 106, 104, 105, 103, 105, 103, 105, 103, 104, 101, 105,
101, 104, 101, 104, 100, 104, 99, 104, 99, 103, 98, 103, 98, 102, 98, 102, 97,
101, 96, 100, 96, 101, 94, 99, 93, 99, 92, 98, 92, 98, 92, 97, 90, 96, 90, 95,
88, 95, 88, 95, 87, 94, 86, 93, 85, 92, 84, 91, 83, 89, 83, 89, 81, 88, 81, 87,
79, 86, 78, 85, 78, 85, 76, 83, 75, 82, 75, 80, 73, 80, 73, 78, 72, 77, 70, 75,
70, 74, 68, 73, 67, 72, 66, 70, 64, 69, 63, 67, 62, 66, 62, 65, 60, 64, 58, 62,
58, 61, 56, 59, 55, 58, 55, 57, 52, 55, 52, 54, 51, 52, 50, 51, 48, 49, 47, 47,
46, 46, 45, 43, 44, 43, 43, 40, 41, 40, 40, 37, 38, 37, 37, 35, 36, 33, 34, 31,
32, 31, 32, 29, 31, 27, 28, 26, 28, 25, 27, 23, 25, 21, 23, 19, 22, 17, 20, 16,
19, 14, 18, 13, 17, 12, 15, 10, 14, 8, 13, 6, 11, 5, 9, 4, 8, 1, 6, 1, 4, -1, 3,
-2, 1, -4, -1, -6, -1, -6, -3, -8, -5, -9, -6, -10, -7, -12, -8, -14, -10, -15,
-12, -16, -14, -16, -14, -17, -16, -18, -17, -19, -19, -21, -19, -22, -20, -23,
-23, -23, -23, -24, -25, -25, -26, -25, -27, -27, -29, -27, -29, -29, -32, -29,
-32, -30, -33, -32, -36, -32, -36, -33, -38, -33, -39, -34, -40, -35, -42, -35,
-43, -36, -45, -36, -45, -37, -46, -37, -47, -39, -49, -39, -50, -40, -52, -41,
-52, -42, -53, -42, -55, -42, -56, -43, -57, -44, -59, -44, -59, -45, -60, -46,
-62, -46, -62, -47, -63, -48, -65, -49, -66, -49, -66, -49, -67, -50, -69, -50,
-70, -52, -71, -52, -72, -53, -73, -53, -74, -54, -76, -55, -75, -56, -77, -56,
-78, -57, -79, -57, -80, -58, -80, -58, -82, -59, -83, -61, -84, -61, -85, -62,
-86, -62, -87, -63, -87, -64, -88, -65, -89, -66, -90, -67, -91, -67, -92, -68,
-93, -69, -93, -70, -95, -71, -96, -71, -96, -73, -97, -73, -99, -74, -98, -75,
-99, -76, -100, -76, -100, -77, -101, -78, -103, -80, -102, -80, -103, -81,
-104, -82, -105, -82, -105, -84, -105, -84, -106, -85, -107, -86, -108, -87,
-109, -88, -109, -89, -110, -89, -110, -90, -110, -91, -111, -91, -112, -92,
-113, -94, -113, -94, -114, -94, -113, -95, -114, -97, -114, -97, -115, -98,
-116, -99, -116, -99, -115, -100, -116, -100, -117, -101, -117, -101, -117,
-102, -117, -103, -118, -103, -118, -104, -118, -105, -119, -105, -119, -106,
-118, -106, -119, -106, -119, -107, -118, -107, -118, -108, -119, -108, -118,
-109, -118, -109, -118, -109, -119, -110, -118, -110, -119, -110, -118, -110,
-119, -111, -118, -110, -117, -110, -117, -110, -117, -111, -117, -111, -117,
-111, -116, -110, -116, -111, -116, -111, -116, -110, -114, -110, -114, -110,
-113, -109, -114, -110, -112, -110, -112, -109, -111, -109, -110, -108, -109,
-108, -109, -107, -108, -107, -107, -107, -106, -106, -105, -106, -104, -105,
-104, -104, -103, -103, -101, -102, -99, -102, -98, -101, -98, -100, -97, -99,
-95, -98, -94, -97, -93, -96, -90, -94, -89, -94, -88, -92, -87, -92, -86, -90,
-84, -89, -82, -87, -80, -87, -79, -85, -78, -83, -75, -82, -74, -81, -72, -79,
-71, -77, -69, -76, -67, -74, -65, -73, -63, -70, -62, -68, -59, -67, -57, -64,
-55, -62, -53, -61, -51, -59, -49, -57, -47, -55, -45, -53, -42, -51, -40, -49,
-38, -47, -36, -45, -33, -42, -32, -40, -30, -38, -27, -35, -25, -34, -23, -31,
-21, -28, -19, -25, -17, -24, -14, -22, -12, -19, -9, -16, -7, -15, -4, -10, -3,
-10, 0, -6, };