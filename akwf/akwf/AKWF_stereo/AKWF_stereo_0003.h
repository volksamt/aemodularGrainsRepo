#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, -72, 9, -85, 15, -79, 19, -83, 22,
-78, 26, -81, 28, -77, 31, -79, 34, -76, 36, -78, 39, -74, 41, -76, 43, -74, 46,
-74, 49, -72, 51, -73, 53, -71, 55, -71, 57, -69, 58, -69, 61, -68, 62, -67, 64,
-67, 65, -66, 67, -66, 69, -65, 71, -64, 72, -64, 74, -63, 75, -61, 77, -61, 79,
-60, 80, -60, 81, -59, 83, -58, 85, -58, 86, -58, 87, -56, 87, -55, 90, -55, 91,
-54, 91, -53, 93, -53, 93, -52, 94, -51, 95, -50, 97, -49, 98, -50, 98, -49, 99,
-47, 101, -47, 101, -45, 102, -45, 102, -44, 103, -44, 104, -43, 105, -43, 105,
-42, 105, -41, 106, -41, 107, -39, 108, -39, 108, -38, 108, -38, 108, -37, 109,
-37, 110, -35, 110, -35, 110, -35, 110, -34, 111, -32, 111, -32, 112, -32, 111,
-32, 111, -31, 111, -29, 111, -30, 112, -29, 112, -28, 111, -28, 111, -27, 111,
-27, 112, -26, 111, -25, 110, -25, 110, -23, 111, -23, 109, -23, 110, -23, 109,
-21, 108, -21, 108, -20, 108, -19, 107, -19, 106, -19, 107, -17, 105, -18, 105,
-17, 104, -16, 103, -15, 103, -15, 102, -15, 102, -14, 101, -14, 100, -13, 100,
-13, 99, -12, 98, -11, 97, -10, 96, -10, 96, -9, 95, -9, 93, -8, 92, -8, 92, -7,
90, -7, 89, -7, 89, -6, 87, -5, 86, -5, 85, -4, 84, -5, 83, -4, 82, -3, 80, -3,
79, -2, 78, -2, 77, -1, 75, 0, 74, 9, 73, 14, 71, 17, 70, 21, 68, 25, 67, 27,
65, 30, 64, 33, 63, 34, 61, 38, 60, 39, 59, 42, 57, 44, 56, 47, 54, 48, 53, 51,
51, 53, 49, 55, 48, 56, 47, 59, 45, 59, 44, 62, 41, 64, 40, 65, 38, 67, 36, 69,
35, 71, 33, 71, 32, 74, 30, 75, 29, 77, 28, 78, 25, 80, 24, 81, 21, 82, 20, 84,
18, 85, 16, 86, 16, 88, 14, 89, 12, 90, 10, 90, 8, 93, 7, 93, 5, 94, 4, 95, 1,
97, -1, 97, -1, 98, -4, 99, -5, 100, -7, 101, -8, 101, -11, 103, -12, 102, -14,
104, -15, 104, -17, 105, -18, 105, -20, 107, -22, 107, -23, 107, -25, 108, -26,
108, -28, 109, -29, 109, -31, 109, -33, 111, -35, 111, -37, 110, -37, 110, -39,
111, -40, 112, -42, 111, -44, 111, -45, 111, -47, 112, -48, 112, -49, 111, -51,
112, -52, 111, -54, 112, -55, 111, -56, 111, -59, 111, -59, 111, -61, 111, -62,
111, -64, 109, -65, 109, -66, 109, -68, 109, -69, 109, -70, 108, -71, 108, -72,
107, -74, 106, -74, 107, -77, 105, -78, 104, -79, 104, -79, 104, -81, 103, -83,
102, -84, 102, -84, 101, -86, 100, -86, 98, -88, 98, -89, 97, -89, 96, -90, 95,
-92, 95, -92, 94, -94, 93, -95, 91, -95, 91, -97, 89, -97, 89, -99, 87, -99, 86,
-100, 85, -100, 85, -101, 82, -102, 81, -103, 80, -104, 78, -104, 77, -105, 76,
-106, 75, -107, 74, -107, 72, -107, 72, -108, 70, -109, 69, -109, 67, -110, 65,
-110, 65, -111, 62, -111, 61, -112, 60, -113, 59, -113, 57, -113, 55, -113, 53,
-114, 51, -115, 51, -115, 49, -116, 48, -116, 45, -116, 44, -116, 42, -116, 41,
-117, 39, -117, 38, -117, 36, -118, 35, -118, 33, -119, 32, -118, 30, -118, 27,
-119, 26, -118, 24, -119, 23, -119, 21, -119, 19, -119, 17, -119, 16, -119, 14,
-120, 14, -119, 11, -120, 10, -119, 8, -118, 5, -119, 5, -119, 3, -119, 0, -119,
-1, -119, -2, -119, -3, -118, -6, -118, -8, -118, -10, -118, -11, -118, -13,
-118, -14, -118, -15, -118, -17, -117, -19, -116, -21, -117, -22, -116, -24,
-116, -26, -116, -28, -115, -29, -116, -31, -115, -32, -114, -34, -114, -36,
-113, -37, -112, -38, -113, -40, -113, -42, -112, -43, -112, -45, -111, -46,
-111, -48, -111, -49, -110, -50, -110, -52, -110, -53, -108, -56, -108, -56,
-108, -57, -108, -59, -107, -60, -106, -61, -106, -63, -106, -64, -105, -65,
-105, -67, -104, -69, -104, -69, -103, -71, -103, -72, -102, -74, -100, -75,
-101, -76, -100, -78, -99, -79, -99, -80, -99, -81, -98, -81, -96, -83, -97,
-84, -96, -85, -95, -86, -94, -87, -94, -89, -93, -89, -93, -91, -91, -91, -91,
-92, -90, -94, -90, -93, -89, -95, -89, -95, -88, -98, -87, -98, -87, -98, -86,
-99, -85, -101, -85, -100, -84, -102, -83, -103, -82, -103, -81, -105, -81,
-104, -80, -106, -80, -106, -79, -106, -78, -108, -78, -108, -76, -109, -76,
-109, -76, -110, -75, -110, -74, -110, -73, -111, -72, -111, -72, -113, -71,
-112, -70, -113, -70, -113, -69, -115, -69, -114, -68, -114, -67, -115, -66,
-116, -65, -116, -65, -116, -63, -116, -63, -116, -63, -117, -62, -117, -61,
-118, -60, -117, -59, -117, -59, -117, -58, -119, -58, -118, -56, -118, -56,
-118, -55, -119, -54, -119, -53, -118, -53, -119, -53, -119, -51, -119, -50,
-119, -50, -120, -50, -119, -48, -119, -48, -119, -47, -118, -47, -119, -46,
-119, -46, -119, -44, -118, -44, -118, -43, -119, -44, -118, -42, -117, -41,
-118, -40, -117, -39, -117, -39, -118, -38, -117, -38, -117, -37, -116, -36,
-116, -36, -116, -35, -116, -35, -116, -34, -115, -33, -115, -32, -114, -31,
-114, -32, -113, -31, -113, -30, -113, -29, -112, -28, -113, -28, -111, -27,
-111, -27, -111, -25, -110, -25, -110, -25, -110, -24, -109, -23, -108, -23,
-108, -22, -107, -21, -107, -22, -107, -20, -106, -20, -106, -20, -105, -19,
-105, -19, -104, -17, -104, -17, -102, -16, -102, -16, -102, -15, -101, -14,
-101, -15, -101, -14, -99, -14, -99, -13, -98, -12, -98, -12, -97, -11, -96,
-10, -96, -10, -95, -9, -95, -9, -93, -8, -93, -7, -92, -7, -93, -6, -90, -7,
-92, -5, -89, -5, -90, -5, -88, -5, -90, -4, -85, -4, -89, -3, -83, -2, -87, -2,
-82, -2, -89, -1, -71, };