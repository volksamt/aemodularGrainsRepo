#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 17, 1, 21, 1, 20, 3, 21, 2, 21, 4,
24, 4, 24, 6, 25, 6, 25, 7, 26, 7, 27, 9, 27, 9, 28, 10, 30, 12, 30, 12, 30, 12,
31, 13, 32, 14, 33, 14, 34, 15, 34, 16, 35, 17, 36, 18, 37, 18, 36, 19, 38, 20,
39, 21, 39, 21, 39, 23, 40, 23, 42, 23, 41, 24, 43, 26, 43, 25, 44, 26, 45, 28,
45, 28, 46, 28, 46, 28, 47, 30, 47, 30, 48, 32, 48, 32, 49, 33, 50, 33, 50, 33,
52, 35, 51, 34, 52, 35, 52, 36, 53, 37, 54, 38, 54, 38, 55, 38, 54, 39, 55, 39,
56, 41, 57, 40, 56, 41, 58, 42, 58, 42, 58, 43, 58, 43, 59, 43, 59, 45, 59, 44,
60, 45, 61, 46, 60, 46, 60, 47, 61, 48, 61, 48, 61, 48, 62, 49, 62, 50, 63, 49,
63, 51, 63, 50, 64, 51, 63, 51, 64, 52, 64, 52, 65, 53, 65, 53, 65, 53, 66, 54,
66, 54, 66, 55, 66, 55, 66, 55, 66, 56, 67, 57, 67, 57, 67, 57, 68, 56, 67, 58,
68, 58, 68, 58, 68, 59, 69, 59, 68, 60, 68, 59, 69, 60, 68, 60, 69, 61, 68, 61,
69, 62, 69, 62, 69, 62, 69, 62, 69, 63, 68, 63, 69, 62, 70, 63, 69, 63, 70, 64,
70, 64, 69, 64, 70, 64, 70, 65, 69, 65, 69, 66, 69, 66, 69, 66, 70, 66, 70, 66,
69, 66, 69, 67, 70, 66, 70, 67, 69, 67, 69, 67, 69, 68, 69, 68, 69, 68, 69, 68,
69, 68, 69, 68, 68, 68, 68, 68, 67, 68, 67, 68, 68, 68, 67, 69, 67, 69, 67, 70,
67, 70, 67, 69, 66, 69, 66, 69, 67, 70, 66, 70, 67, 69, 66, 70, 67, 71, 66, 69,
66, 71, 66, 70, 66, 71, 65, 70, 66, 71, 65, 71, 65, 70, 65, 71, 64, 71, 64, 70,
63, 71, 64, 71, 63, 71, 64, 71, 63, 71, 63, 71, 63, 71, 62, 71, 61, 71, 62, 72,
61, 71, 62, 72, 61, 71, 60, 71, 61, 71, 61, 71, 60, 71, 60, 72, 60, 71, 60, 71,
60, 71, 59, 72, 58, 71, 58, 71, 58, 71, 58, 72, 58, 72, 57, 72, 58, 71, 57, 72,
57, 72, 56, 71, 56, 72, 57, 72, 55, 72, 56, 72, 56, 71, 55, 72, 55, 72, 54, 71,
54, 72, 54, 71, 54, 71, 53, 72, 54, 72, 53, 72, 53, 72, 52, 72, 52, 72, 52, 71,
52, 71, 51, 71, 51, 71, 51, 71, 51, 72, 51, 72, 51, 71, 50, 71, 49, 71, 50, 72,
49, 72, 49, 71, 50, 71, 49, 71, 48, 72, 48, 72, 48, 71, 48, 72, 48, 72, 47, 72,
47, 72, 47, 72, 46, 72, 46, 71, 46, 71, 45, 71, 45, 71, 46, 71, 45, 71, 44, 72,
45, 72, 45, 71, 45, 71, 44, 71, 44, 71, 44, 72, 44, 71, 44, 71, 44, 72, 43, 72,
44, 72, 43, 71, 42, 71, 43, 72, 44, 71, 43, 72, 43, 71, 42, 71, 42, 71, 42, 72,
43, 72, 43, 71, 42, 71, 41, 72, 42, 71, 42, 71, 43, 72, 42, 71, 41, 71, 42, 72,
41, 71, 41, 71, 42, 71, 42, 71, 42, 72, 41, 72, 41, 68, 37, 53, 20, 24, -10, -7,
-36, -33, -52, -52, -61, -64, -66, -75, -74, -85, -84, -94, -94, -101, -102,
-108, -109, -112, -114, -117, -117, -119, -119, -118, -119, -117, -116, -112,
-113, -105, -109, -97, -104, -86, -99, -77, -95, -69, -91, -61, -89, -56, -87,
-53, -87, -52, -87, -51, -86, -52, -87, -51, -86, -50, -85, -48, -83, -46, -81,
-44, -80, -40, -77, -36, -75, -34, -75, -34, -75, -32, -75, -34, -76, -36, -77,
-38, -78, -41, -81, -44, -83, -47, -83, -50, -84, -52, -84, -54, -85, -55, -85,
-55, -85, -55, -86, -57, -86, -59, -87, -60, -88, -63, -89, -64, -91, -67, -92,
-70, -93, -72, -93, -74, -95, -78, -96, -79, -97, -81, -97, -81, -97, -83, -98,
-83, -97, -85, -98, -87, -99, -87, -98, -88, -99, -89, -99, -90, -101, -92,
-101, -93, -102, -95, -102, -95, -102, -96, -102, -96, -101, -97, -102, -98,
-102, -98, -101, -98, -101, -98, -101, -97, -100, -97, -99, -98, -99, -98, -99,
-98, -99, -99, -99, -99, -98, -98, -98, -99, -98, -98, -97, -98, -96, -99, -96,
-97, -96, -97, -94, -96, -95, -96, -93, -96, -93, -95, -93, -94, -91, -94, -91,
-94, -91, -93, -90, -93, -88, -92, -88, -91, -88, -91, -87, -90, -86, -90, -85,
-89, -84, -88, -84, -87, -82, -87, -81, -86, -82, -85, -79, -85, -80, -83, -79,
-83, -78, -82, -77, -81, -76, -81, -75, -81, -75, -80, -73, -79, -73, -78, -71,
-77, -71, -76, -70, -76, -69, -76, -68, -75, -67, -74, -66, -73, -66, -71, -64,
-71, -64, -71, -63, -70, -62, -69, -61, -68, -60, -67, -59, -68, -57, -66, -58,
-66, -57, -64, -55, -63, -55, -63, -54, -62, -53, -61, -52, -61, -51, -60, -50,
-59, -50, -58, -49, -58, -48, -57, -47, -56, -46, -55, -45, -56, -44, -54, -44,
-53, -42, -52, -41, -51, -41, -50, -40, -49, -38, -49, -37, -48, -36, -47, -36,
-47, -34, -46, -33, -45, -32, -44, -32, -43, -31, -43, -31, -43, -29, -41, -28,
-40, -28, -40, -26, -39, -25, -38, -25, -38, -24, -37, -23, -37, -22, -35, -21,
-34, -20, -34, -20, -33, -18, -32, -17, -31, -16, -31, -16, -30, -14, -29, -15,
-29, -13, -27, -12, -27, -12, -26, -11, -27, -9, -26, -9, -25, -8, -23, -7, -23,
-6, -22, -5, -22, -4, -20, -4, -19, -3, -18, -2, -18, -1, -17, 0, -16, 1, -16,
2, -15, 2, -14, 3, -13, 4, -12, 5, -12, 5, -11, 6, -10, 8, -9, 8, -9, 10, -8, 9,
-7, 11, -6, 12, -5, 12, -5, 12, -5, 15, -3, 14, -2, 17, -2, 16, -2, 20, -1, 15,
};