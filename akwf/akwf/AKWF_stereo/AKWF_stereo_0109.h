#define DATA_LENGTH 512
#define DATA AKWF_stereo_0109

const PROGMEM int8_t DATA[DATA_LENGTH] = {15, 18, 19, 21, 22, 24, 27, 29, 30,
33, 34, 39, 40, 42, 43, 45, 48, 49, 51, 52, 54, 57, 58, 59, 61, 61, 64, 66, 67,
68, 69, 71, 73, 74, 75, 76, 78, 79, 80, 81, 82, 83, 84, 85, 84, 86, 85, 87, 87,
87, 88, 87, 89, 90, 89, 89, 90, 89, 90, 90, 90, 90, 90, 91, 90, 90, 90, 91, 90,
90, 90, 89, 90, 90, 90, 89, 90, 88, 89, 89, 88, 89, 89, 89, 89, 90, 88, 89, 88,
88, 87, 88, 86, 89, 100, 99, 101, 100, 100, 101, 100, 101, 101, 101, 101, 102,
102, 102, 101, 101, 101, 102, 101, 101, 102, 102, 102, 102, 100, 100, 101, 100,
99, 100, 100, 99, 99, 99, 98, 98, 100, 98, 98, 98, 97, 99, 99, 99, 97, 98, 97,
97, 97, 96, 95, 95, 95, 94, 93, 93, 93, 92, 91, 91, 90, 91, 91, 91, 90, 90, 91,
90, 91, 90, 91, 90, 90, 90, 90, 90, 89, 90, 90, 90, 91, 90, 90, 92, 92, 93, 93,
93, 94, 94, 95, 94, 94, 93, 97, 104, 103, 103, 102, 103, 103, 102, 103, 104,
103, 103, 103, 103, 103, 102, 102, 101, 101, 101, 100, 100, 99, 98, 99, 97, 97,
97, 95, 94, 95, 93, 93, 91, 91, 90, 89, 87, 88, 86, 87, 83, 83, 82, 83, 81, 81,
80, 79, 78, 78, 78, 77, 77, 75, 77, 74, 76, 72, 75, 68, 75, 66, 75, 64, 75, 60,
82, 35, -127, -112, -118, -116, -116, -118, -115, -117, -115, -118, -116, -120,
-116, -118, -116, -118, -116, -119, -116, -118, -116, -118, -117, -117, -116,
-116, -117, -117, -118, -117, -118, -117, -118, -117, -119, -118, -119, -119,
-119, -118, -118, -118, -120, -119, -118, -119, -118, -119, -118, -118, -118,
-119, -118, -118, -117, -117, -117, -117, -116, -117, -116, -117, -116, -116,
-115, -115, -115, -107, -104, -105, -103, -104, -103, -102, -101, -102, -101,
-101, -100, -101, -99, -99, -98, -98, -98, -97, -97, -97, -96, -95, -96, -95,
-95, -94, -93, -93, -91, -91, -90, -90, -89, -88, -87, -86, -86, -84, -83, -82,
-82, -80, -79, -79, -79, -78, -79, -78, -77, -78, -78, -79, -79, -78, -78, -79,
-78, -77, -76, -76, -75, -74, -74, -72, -71, -73, -72, -72, -71, -72, -73, -73,
-74, -74, -74, -74, -74, -74, -74, -74, -73, -73, -73, -73, -73, -74, -75, -75,
-76, -76, -78, -78, -80, -77, -62, -63, -64, -63, -64, -62, -64, -64, -63, -62,
-64, -63, -63, -64, -64, -64, -65, -65, -65, -66, -66, -67, -67, -66, -65, -65,
-64, -64, -64, -65, -64, -63, -63, -63, -62, -62, -62, -60, -61, -60, -60, -58,
-57, -57, -55, -55, -54, -53, -52, -52, -52, -51, -50, -50, -50, -50, -50, -48,
-49, -48, -48, -47, -46, -44, -44, -42, -43, -41, -40, -40, -39, -39, -38, -37,
-37, -38, -37, -36, -34, -33, -32, -32, -30, -28, -27, -26, -24, -22, -18, -19,
-16, -17, -13, };