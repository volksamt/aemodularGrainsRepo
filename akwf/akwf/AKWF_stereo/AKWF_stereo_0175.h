#define DATA_LENGTH 1024
#define DATA AKWF_stereo_0175

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 83, 4, 97, 6, 88, 9, 91, 11, 84,
13, 86, 17, 80, 20, 80, 21, 75, 24, 76, 26, 70, 28, 70, 30, 66, 32, 66, 35, 62,
36, 61, 38, 58, 39, 56, 40, 53, 42, 51, 43, 48, 45, 47, 45, 44, 46, 42, 48, 41,
48, 38, 49, 35, 51, 34, 51, 32, 53, 29, 53, 27, 53, 24, 53, 22, 54, 19, 56, 16,
56, 13, 57, 11, 59, 7, 59, 4, 60, 1, 61, -4, 62, -6, 61, -11, 62, -14, 63, -17,
64, -20, 66, -23, 65, -26, 66, -29, 67, -32, 67, -35, 69, -37, 70, -39, 71, -41,
71, -43, 73, -44, 72, -46, 73, -48, 74, -49, 74, -50, 76, -50, 75, -51, 76, -53,
76, -53, 77, -54, 76, -55, 77, -55, 76, -56, 78, -56, 78, -56, 77, -57, 77, -58,
77, -59, 76, -58, 76, -58, 75, -58, 75, -59, 74, -59, 74, -59, 74, -58, 72, -58,
72, -57, 72, -56, 71, -55, 71, -53, 70, -53, 70, -52, 69, -49, 70, -48, 68, -47,
69, -45, 69, -44, 68, -43, 68, -42, 69, -40, 68, -39, 68, -38, 68, -36, 68, -36,
67, -34, 67, -33, 67, -32, 67, -31, 66, -29, 66, -28, 66, -26, 66, -24, 66, -22,
65, -21, 65, -20, 64, -18, 64, -16, 64, -15, 62, -13, 61, -11, 61, -9, 60, -7,
59, -6, 58, -3, 57, -1, 56, 0, 53, 3, 52, 4, 51, 6, 49, 7, 47, 9, 45, 10, 42,
12, 40, 11, 38, 11, 36, 13, 34, 15, 31, 15, 29, 16, 26, 18, 23, 19, 21, 19, 19,
20, 17, 21, 16, 21, 13, 24, 12, 24, 10, 24, 8, 24, 7, 25, 6, 27, 5, 27, 4, 27,
4, 29, 1, 29, 1, 29, 1, 31, 1, 31, 0, 32, 0, 33, -1, 34, -1, 35, -2, 35, -3, 37,
-4, 36, -5, 37, -5, 37, -6, 37, -8, 37, -10, 37, -11, 37, -13, 37, -14, 37, -16,
37, -18, 36, -19, 36, -21, 35, -22, 36, -24, 36, -25, 35, -27, 35, -28, 33, -30,
33, -30, 32, -31, 32, -31, 30, -33, 30, -34, 29, -34, 28, -34, 28, -35, 26, -35,
27, -34, 25, -34, 24, -35, 24, -34, 24, -34, 22, -33, 23, -32, 22, -31, 22, -31,
22, -29, 20, -29, 20, -28, 21, -27, 21, -26, 21, -25, 20, -22, 21, -20, 22, -20,
23, -18, 24, -16, 24, -14, 26, -12, 26, -10, 28, -7, 28, -6, 29, -4, 29, -1, 29,
0, 29, 2, 29, 4, 29, 5, 28, 7, 28, 9, 28, 10, 27, 11, 26, 12, 25, 14, 24, 14,
23, 16, 22, 17, 22, 18, 20, 18, 20, 19, 18, 20, 18, 21, 17, 21, 15, 22, 15, 23,
14, 24, 14, 25, 14, 26, 14, 28, 13, 30, 13, 31, 14, 31, 14, 33, 15, 35, 15, 37,
17, 39, 16, 41, 17, 42, 18, 44, 19, 46, 19, 48, 20, 51, 20, 51, 20, 53, 21, 55,
22, 56, 23, 57, 24, 59, 24, 61, 25, 61, 26, 63, 27, 64, 27, 63, 29, 64, 29, 63,
29, 64, 29, 63, 29, 62, 29, 62, 29, 60, 28, 59, 28, 57, 26, 55, 26, 54, 24, 52,
23, 50, 22, 48, 20, 45, 18, 43, 16, 40, 14, 38, 12, 35, 8, 32, 6, 29, 4, 26, 2,
24, -1, 21, -4, 18, -7, 16, -9, 12, -10, 11, -13, 8, -14, 6, -15, 5, -17, 2,
-18, -1, -19, -3, -19, -5, -20, -8, -21, -10, -21, -12, -22, -14, -23, -17, -24,
-19, -25, -21, -26, -24, -27, -27, -28, -30, -28, -32, -31, -35, -31, -39, -33,
-41, -35, -45, -37, -49, -40, -52, -42, -56, -43, -60, -47, -64, -50, -69, -53,
-73, -56, -77, -59, -81, -63, -84, -67, -88, -70, -91, -73, -95, -75, -99, -79,
-100, -82, -104, -85, -107, -88, -109, -90, -111, -92, -112, -95, -114, -98,
-116, -100, -116, -102, -117, -105, -118, -107, -119, -109, -119, -110, -119,
-113, -119, -113, -118, -115, -119, -117, -119, -117, -118, -117, -118, -118,
-116, -117, -116, -119, -115, -119, -115, -119, -115, -119, -114, -119, -113,
-118, -112, -119, -111, -119, -111, -118, -110, -118, -109, -118, -108, -118,
-107, -117, -106, -117, -105, -117, -103, -118, -102, -117, -101, -117, -99,
-117, -97, -117, -95, -118, -94, -118, -91, -118, -89, -118, -86, -118, -84,
-118, -82, -119, -80, -118, -77, -118, -75, -118, -72, -118, -69, -117, -67,
-117, -63, -115, -61, -114, -58, -112, -55, -110, -52, -108, -49, -107, -47,
-104, -43, -102, -40, -99, -38, -96, -34, -93, -31, -91, -28, -88, -25, -86,
-23, -83, -19, -80, -16, -77, -13, -74, -12, -71, -9, -68, -6, -66, -4, -63, -2,
-59, 0, -58, 3, -54, 4, -51, 5, -50, 4, -49, 5, -47, 7, -44, 8, -41, 10, -39,
10, -37, 11, -33, 11, -30, 11, -28, 11, -25, 12, -23, 11, -20, 11, -17, 9, -15,
8, -13, 9, -10, 7, -7, 6, -5, 5, -3, 4, -1, 4, 3, 2, 5, 2, 7, 2, 11, 1, 13, 1,
17, 1, 19, 0, 23, 0, 26, -1, 30, -2, 32, -2, 35, -3, 39, -4, 42, -4, 45, -5, 48,
-6, 51, -7, 55, -8, 57, -9, 59, -10, 62, -11, 66, -14, 68, -15, 70, -16, 72,
-19, 75, -22, 76, -23, 77, -26, 79, -28, 80, -31, 82, -33, 82, -35, 83, -36, 83,
-38, 84, -39, 85, -41, 85, -42, 86, -43, 87, -44, 88, -45, 89, -45, 91, -45, 92,
-46, 93, -44, 93, -45, 96, -45, 97, -43, 98, -43, 100, -42, 101, -41, 101, -41,
103, -40, 105, -39, 107, -39, 106, -37, 109, -36, 109, -36, 111, -34, 110, -32,
112, -33, 112, -31, 114, -30, 114, -30, 114, -29, 114, -28, 114, -27, 115, -26,
114, -25, 115, -25, 113, -23, 113, -21, 112, -20, 112, -20, 110, -18, 111, -16,
108, -15, 110, -13, 104, -12, 107, -9, 101, -6, 105, -5, 96, -3, 105, -1, 83, };