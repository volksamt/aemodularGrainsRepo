#define DATA_LENGTH 512
#define DATA AKWF_1319

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 1, 2, 2, 3, 3, 4, 3, 4, 4, 5,
5, 6, 5, 6, 6, 7, 8, 8, 8, 8, 10, 9, 10, 10, 11, 11, 12, 12, 12, 13, 14, 14, 15,
14, 15, 16, 17, 17, 17, 18, 18, 19, 20, 20, 21, 21, 22, 22, 22, 23, 23, 24, 25,
25, 25, 25, 26, 27, 28, 28, 28, 29, 30, 30, 31, 32, 32, 32, 33, 33, 34, 34, 34,
35, 36, 36, 37, 37, 38, 38, 39, 39, 40, 41, 41, 41, 41, 43, 43, 43, 43, 43, 45,
45, 46, 46, 46, 47, 48, 48, 49, 49, 50, 49, 51, 51, 50, 51, 51, 52, 53, 53, 53,
54, 55, 54, 56, 56, 56, 56, 57, 57, 58, 58, 58, 58, 59, 60, 59, 60, 61, 61, 62,
62, 62, 62, 63, 63, 63, 64, 63, 64, 64, 65, 65, 65, 66, 66, 67, 67, 68, 69, 68,
68, 68, 69, 69, 69, 70, 70, 70, 70, 71, 72, 71, 71, 72, 71, 72, 72, 72, 73, 72,
73, 72, 73, 71, 72, 71, 71, 71, 70, 71, 70, 70, 69, 70, 69, 70, 67, 70, 67, 70,
65, 71, 61, 79, 17, -85, -102, -119, -117, -121, -118, -118, -114, -112, -109,
-109, -106, -102, -102, -98, -98, -95, -93, -90, -88, -87, -84, -82, -80, -79,
-77, -75, -73, -72, -69, -67, -67, -64, -64, -59, -73, -83, -79, -77, -74, -72,
-70, -69, -65, -64, -62, -60, -59, -57, -56, -54, -52, -50, -48, -47, -45, -44,
-42, -41, -40, -38, -36, -35, -35, -33, -33, -31, -30, -27, -25, -24, -23, -22,
-20, -20, -20, -20, -20, -20, -19, -20, -18, -34, -43, -38, -37, -34, -34, -32,
-32, -30, -30, -28, -27, -26, -27, -26, -26, -25, -26, -25, -25, -26, -28, -28,
-30, -30, -32, -31, -32, -33, -34, -34, -34, -35, -35, -36, -36, -37, -37, -37,
-38, -38, -37, -37, -38, -38, -38, -38, -39, -38, -39, -39, -39, -38, -39, -39,
-40, -39, -39, -40, -39, -39, -40, -40, -40, -41, -42, -41, -42, -41, -42, -43,
-42, -43, -42, -43, -43, -43, -43, -43, -43, -44, -44, -44, -43, -44, -45, -45,
-45, -46, -46, -45, -46, -45, -46, -47, -47, -47, -45, -45, -44, -45, -45, -45,
-44, -44, -44, -43, -44, -43, -44, -44, -44, -42, -40, -39, -37, -35, -35, -33,
-32, -32, -32, -30, -30, -30, -29, -30, -26, -59, -72, -64, -64, -59, -57, -53,
-53, -48, -48, -46, -44, -42, -41, -40, -40, -40, -38, -38, -36, -37, -39, -41,
-42, -42, -43, -45, -45, -46, -47, -48, -48, -48, -49, -49, -50, -50, -51, -50,
-51, -51, -52, -52, -52, -52, -52, -51, -51, -50, -47, -45, -43, -39, -33, -29,
-26, -23, -19, -17, -13, -12, -10, -7, -5, -4, -1, 0, 3, 4, 6, 7, 9, 10, 12, 12,
13, 15, 15, 18, 15, 24, -40, -73, -59, -59, -49, -49, -41, -41, -34, -33, -29,
-26, -23, -21, -18, -14, -11, -7, -3, -1, };