#define DATA_LENGTH 512
#define DATA AKWF_1313

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 4, 6, 7, 9, 10, 11, 11, 13,
15, 16, 17, 18, 19, 21, 22, 23, 24, 26, 27, 28, 29, 30, 31, 32, 33, 35, 35, 37,
38, 39, 40, 41, 42, 43, 43, 44, 46, 46, 48, 48, 49, 51, 51, 52, 53, 54, 55, 56,
57, 57, 59, 60, 60, 61, 61, 62, 63, 64, 65, 65, 66, 68, 68, 68, 69, 69, 71, 71,
72, 73, 73, 74, 74, 75, 76, 76, 78, 77, 79, 79, 80, 80, 80, 82, 82, 82, 83, 83,
84, 84, 85, 86, 86, 87, 88, 88, 88, 89, 90, 90, 90, 91, 92, 92, 93, 93, 93, 94,
94, 95, 95, 95, 95, 96, 97, 97, 98, 98, 98, 99, 99, 100, 100, 100, 100, 101,
102, 102, 103, 103, 103, 103, 104, 104, 104, 105, 105, 106, 105, 106, 106, 106,
106, 107, 108, 108, 108, 108, 106, 104, 102, 100, 97, 95, 93, 90, 87, 85, 83,
80, 78, 76, 74, 72, 70, 66, 65, 63, 61, 59, 57, 55, 52, 50, 49, 47, 44, 43, 41,
39, 37, 35, 34, 31, 30, 28, 27, 26, 23, 21, 20, 19, 17, 14, 13, 12, 11, 10, 11,
12, 13, 15, 16, 16, 18, 19, 21, 22, 23, 24, 25, 27, 27, 29, 30, 31, 32, 33, 34,
35, 36, 37, 39, 40, 41, 42, 43, 44, 44, 46, 47, 47, 49, 49, 50, 51, 51, 53, 54,
55, 56, 56, 57, 58, 60, 60, 61, 61, 63, 63, 64, 65, 64, 65, 67, 67, 68, 69, 70,
71, 71, 72, 72, 73, 74, 75, 75, 76, 76, 78, 78, 79, 79, 80, 80, 81, 82, 81, 82,
83, 84, 84, 85, 85, 86, 86, 87, 87, 88, 89, 89, 89, 90, 91, 90, 91, 91, 93, 92,
94, 93, 94, 95, 94, 95, 95, 96, 97, 97, 98, 97, 98, 99, 99, 99, 99, 100, 100,
101, 102, 102, 102, 103, 103, 103, 103, 104, 104, 105, 104, 106, 106, 106, 107,
107, 106, 107, 107, 107, 108, 109, 109, 108, 109, 110, 111, 110, 111, 111, 111,
111, 111, 112, 112, 112, 113, 113, 113, 113, 114, 114, 114, 114, 115, 115, 115,
115, 116, 115, 116, 116, 116, 117, 117, 117, 116, 117, 117, 117, 118, 118, 118,
118, 119, 119, 119, 118, 116, 114, 112, 109, 108, 103, 101, 100, 97, 95, 91, 89,
88, 85, 82, 80, 78, 76, 74, 71, 69, 67, 65, 62, 61, 58, 57, 54, 53, 50, 48, 47,
44, 42, 41, 39, 37, 35, 33, 32, 30, 28, 26, 24, 23, 21, 20, 18, 17, 15, 14, 12,
9, 8, 6, 5, 4, 2, 0, 0, -2, -4, -5, -7, -7, -8, -10, -11, -13, -15, -16, -17,
-18, -19, -21, -22, -23, -24, -25, -27, -27, -28, -30, -31, -32, -32, -34, -35,
-35, -36, -35, -35, -35, -35, -33, -33, -31, -32, -31, -29, -28, -27, -26, -25,
-24, -22, -21, -20, -18, -17, -16, -14, -13, -12, -11, -9, -8, -7, -5, -3, -3,
-1, };