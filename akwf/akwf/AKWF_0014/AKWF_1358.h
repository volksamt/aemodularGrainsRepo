#define DATA_LENGTH 512
#define DATA AKWF_1358

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 27, 38, 47, 54, 61, 66, 70, 76, 79,
84, 87, 91, 94, 97, 99, 102, 104, 106, 108, 109, 111, 114, 114, 115, 116, 117,
119, 119, 118, 119, 118, 119, 118, 119, 119, 118, 118, 117, 116, 116, 115, 114,
113, 113, 112, 109, 109, 108, 108, 106, 105, 103, 102, 101, 99, 98, 97, 95, 94,
92, 91, 89, 88, 87, 85, 84, 82, 80, 79, 78, 75, 75, 73, 71, 70, 69, 67, 66, 64,
62, 61, 59, 59, 57, 55, 54, 53, 51, 50, 48, 48, 46, 44, 42, 41, 40, 39, 37, 36,
35, 34, 32, 30, 29, 28, 27, 26, 24, 23, 22, 20, 18, 18, 16, 15, 14, 13, 11, 11,
9, 8, 7, 4, 3, 3, 2, 1, -1, -2, -3, -4, -6, -7, -7, -9, -9, -12, -13, -14, -15,
-16, -16, -19, -19, -20, -22, -22, -24, -25, -26, -27, -28, -30, -31, -32, -32,
-34, -35, -36, -37, -38, -39, -41, -42, -42, -43, -44, -45, -46, -48, -48, -50,
-50, -52, -52, -53, -55, -55, -56, -57, -58, -59, -60, -61, -62, -63, -64, -64,
-66, -67, -68, -68, -69, -71, -72, -72, -73, -75, -75, -76, -77, -79, -79, -80,
-81, -81, -83, -83, -84, -85, -85, -87, -87, -88, -88, -90, -91, -91, -92, -92,
-93, -94, -95, -95, -96, -96, -98, -98, -100, -100, -100, -101, -101, -103,
-103, -103, -103, -104, -105, -106, -106, -108, -107, -107, -108, -109, -110,
-110, -110, -111, -111, -112, -111, -112, -113, -113, -113, -114, -114, -114,
-115, -115, -116, -116, -116, -116, -116, -117, -117, -118, -117, -118, -118,
-119, -119, -118, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -120, -119, -118, -118, -118, -119, -118, -118, -119, -117,
-118, -118, -117, -117, -117, -117, -117, -117, -117, -116, -116, -115, -116,
-115, -115, -114, -114, -114, -113, -114, -113, -112, -112, -111, -111, -111,
-110, -110, -110, -109, -108, -109, -109, -108, -107, -107, -106, -106, -106,
-105, -104, -104, -103, -104, -102, -101, -101, -101, -100, -100, -99, -98, -99,
-98, -97, -96, -96, -95, -95, -95, -93, -93, -93, -92, -91, -91, -90, -89, -88,
-88, -87, -87, -86, -86, -85, -85, -84, -84, -83, -82, -82, -81, -80, -80, -79,
-79, -78, -77, -76, -76, -76, -74, -74, -73, -72, -72, -72, -71, -70, -70, -69,
-68, -68, -67, -66, -66, -65, -64, -63, -62, -62, -62, -61, -60, -60, -59, -58,
-58, -57, -57, -56, -55, -55, -53, -53, -53, -52, -51, -51, -50, -49, -48, -48,
-47, -47, -46, -46, -45, -45, -44, -43, -42, -41, -41, -41, -40, -38, -39, -38,
-38, -37, -36, -35, -35, -34, -34, -32, -33, -32, -31, -30, -30, -29, -29, -28,
-27, -27, -25, -25, -24, -24, -23, -23, -22, -22, -21, -20, -20, -20, -18, -18,
-16, -16, -16, -15, -15, -14, -13, -13, -12, -11, -11, -10, -10, -10, -9, -8,
-7, -7, -7, -6, -4, -4, -4, -3, -3, -1, -1, -1, -1, 0, 1, };