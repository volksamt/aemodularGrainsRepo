#define DATA_LENGTH 512
#define DATA AKWF_1391

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 8, 15, 21, 27, 34, 40, 45, 52, 58,
63, 69, 74, 79, 85, 89, 93, 97, 99, 103, 106, 109, 112, 114, 116, 117, 117, 118,
119, 120, 120, 119, 118, 118, 118, 116, 115, 113, 112, 110, 107, 104, 101, 98,
94, 91, 88, 84, 79, 75, 70, 65, 61, 56, 51, 46, 41, 36, 31, 26, 19, 15, 10, 4,
0, -7, -11, -16, -21, -26, -31, -35, -41, -44, -49, -53, -57, -61, -65, -68,
-72, -75, -78, -81, -83, -86, -88, -91, -92, -94, -96, -96, -98, -98, -100, -99,
-99, -100, -100, -99, -98, -98, -97, -95, -95, -93, -91, -90, -88, -85, -83,
-81, -78, -76, -73, -70, -67, -64, -60, -57, -53, -50, -47, -43, -40, -35, -31,
-28, -24, -21, -17, -13, -9, -6, -2, 1, 5, 8, 12, 16, 19, 22, 25, 28, 31, 34,
37, 40, 42, 45, 47, 49, 51, 54, 56, 57, 59, 60, 61, 63, 64, 64, 65, 66, 67, 68,
67, 68, 67, 68, 67, 68, 67, 66, 66, 64, 64, 63, 63, 60, 60, 58, 56, 55, 53, 51,
50, 48, 46, 43, 41, 40, 37, 35, 33, 30, 29, 26, 23, 21, 19, 17, 14, 12, 10, 8,
5, 2, 1, -1, -4, -6, -8, -10, -12, -14, -15, -18, -19, -22, -23, -25, -27, -29,
-29, -31, -32, -34, -34, -36, -37, -38, -39, -40, -39, -41, -41, -41, -42, -42,
-42, -43, -42, -42, -42, -43, -43, -42, -41, -41, -41, -41, -40, -39, -38, -39,
-37, -36, -35, -34, -34, -32, -32, -31, -30, -29, -27, -26, -26, -25, -23, -22,
-20, -19, -18, -17, -16, -14, -12, -12, -11, -9, -8, -7, -6, -4, -3, -2, 0, 0,
1, 3, 3, 5, 6, 7, 7, 8, 10, 11, 12, 13, 13, 14, 15, 15, 15, 16, 16, 17, 17, 17,
18, 19, 18, 19, 18, 20, 19, 19, 20, 20, 19, 18, 19, 19, 18, 19, 18, 18, 18, 17,
17, 16, 16, 15, 15, 15, 15, 14, 14, 13, 12, 12, 12, 12, 10, 10, 9, 8, 8, 8, 7,
7, 5, 6, 5, 5, 4, 4, 3, 2, 1, 2, 0, 0, 0, 0, -2, -2, -2, -3, -3, -3, -3, -4, -4,
-4, -4, -5, -5, -5, -6, -5, -5, -5, -5, -6, -6, -6, -5, -6, -5, -5, -6, -5, -5,
-5, -6, -6, -5, -5, -5, -5, -4, -4, -4, -3, -4, -4, -4, -4, -3, -2, -3, -3, -3,
-3, -1, -1, -2, -1, -2, -2, -1, -1, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0,
0, 0, 0, 0, 0, 1, -1, -1, 0, 0, -1, 0, -1, -1, -2, -2, -2, -2, -2, -3, -3, -3,
-3, -3, -4, -3, -4, -4, -4, -4, -4, -4, -4, -5, -4, -5, -5, -5, -5, -11, -28,
-51, -66, -73, -76, -81, -86, -92, -96, -98, -99, -99, -97, -94, -92, -89, -87,
-84, -78, -74, -69, -64, -59, -54, -48, -42, -36, -29, -23, -16, -10, -4, };