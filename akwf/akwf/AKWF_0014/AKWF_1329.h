#define DATA_LENGTH 512
#define DATA AKWF_1329

const PROGMEM int8_t DATA[DATA_LENGTH] = {93, 108, 101, 107, 102, 107, 102, 106,
103, 106, 103, 105, 103, 106, 103, 105, 104, 105, 104, 104, 104, 104, 104, 104,
104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 105, 104, 105, 104, 104, 104,
105, 104, 104, 104, 104, 104, 104, 105, 104, 105, 104, 104, 104, 104, 104, 104,
104, 104, 104, 104, 104, 104, 105, 104, 104, 104, 103, 104, 104, 104, 104, 104,
104, 104, 104, 104, 104, 104, 104, 104, 105, 104, 105, 104, 104, 104, 104, 104,
104, 104, 104, 104, 104, 105, 105, 104, 103, 104, 104, 105, 103, 104, 104, 104,
104, 104, 104, 104, 104, 105, 104, 105, 104, 104, 104, 104, 105, 104, 105, 103,
105, 102, 107, 100, 114, 61, 16, 31, 23, 28, 25, 28, 25, 27, 26, 26, 26, 26, 27,
26, 27, 27, 27, 26, 27, 26, 27, 26, 27, 26, 27, 26, 27, 26, 26, 26, 26, 26, 26,
27, 26, 26, 26, 27, 26, 26, 26, 26, 26, 26, 25, 27, 26, 27, 26, 27, 27, 26, 26,
26, 26, 26, 26, 26, 26, 26, 25, 27, 26, 26, 26, 27, 26, 26, 26, 27, 26, 27, 27,
26, 26, 25, 26, 27, 26, 26, 27, 26, 26, 26, 26, 26, 26, 26, 26, 27, 27, 26, 26,
27, 25, 26, 26, 26, 27, 27, 26, 26, 26, 26, 25, 27, 26, 27, 26, 26, 26, 25, 27,
26, 28, 26, 27, 24, 28, 24, 29, 24, 29, 24, 28, 23, 29, 23, 31, 16, -109, -111,
-107, -111, -107, -112, -106, -111, -107, -111, -108, -111, -108, -110, -108,
-111, -108, -109, -108, -109, -109, -110, -108, -109, -110, -109, -109, -109,
-109, -110, -109, -109, -110, -108, -109, -109, -109, -109, -109, -109, -109,
-109, -109, -110, -109, -109, -109, -109, -109, -110, -109, -110, -109, -110,
-110, -109, -109, -109, -109, -109, -109, -109, -109, -109, -109, -109, -110,
-109, -109, -110, -109, -109, -110, -109, -109, -109, -110, -109, -110, -110,
-110, -109, -109, -109, -109, -109, -109, -109, -109, -109, -109, -109, -110,
-109, -109, -110, -108, -109, -109, -109, -109, -109, -109, -109, -109, -110,
-110, -109, -109, -109, -109, -108, -111, -108, -109, -109, -110, -108, -110,
-109, -109, -110, -108, -110, -107, -111, -106, -114, -101, -126, -60, 8, -13,
-1, -10, -3, -8, -4, -7, -5, -6, -6, -7, -5, -5, -7, -6, -6, -5, -7, -5, -6, -5,
-6, -5, -6, -6, -7, -5, -6, -6, -6, -6, -5, -6, -6, -5, -5, -6, -6, -5, -7, -5,
-6, -5, -6, -6, -5, -6, -6, -6, -6, -6, -6, -6, -5, -6, -6, -6, -6, -6, -5, -6,
-5, -5, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -5, -6,
-6, -6, -6, -5, -6, -6, -5, -6, -6, -6, -6, -6, -6, -5, -6, -6, -6, -5, -6, -6,
-6, -5, -5, -6, -5, -5, -5, -6, -6, -6, -6, -6, -5, -6, -6, -7, -5, -6, -6, -6,
-6, -6, -5, };