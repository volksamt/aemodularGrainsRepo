#define DATA_LENGTH 512
#define DATA AKWF_1301

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 87, 85, 82, 81, 78, 77, 73, 73, 68,
69, 64, 63, 59, 59, 55, 55, 51, 51, 48, 47, 43, 42, 39, 37, 34, 32, 31, 29, 27,
23, 22, 19, 18, 16, 13, 11, 9, 6, 5, 2, 2, 2, 3, 2, 3, 3, 2, 2, 2, 1, 2, 2, 2,
2, 2, 2, 2, 2, 2, 2, 2, 3, 3, 2, 3, 2, 2, 2, 1, 2, 2, 2, 2, 1, -1, -3, -4, -7,
-9, -10, -13, -15, -16, -18, -20, -22, -23, -25, -27, -29, -31, -32, -35, -36,
-39, -41, -42, -43, -46, -49, -50, -51, -54, -56, -57, -59, -61, -63, -64, -67,
-69, -71, -73, -72, -71, -68, -66, -65, -63, -61, -59, -58, -55, -53, -51, -49,
-48, -45, -44, -42, -40, -38, -36, -35, -33, -31, -29, -27, -25, -24, -21, -19,
-18, -15, -14, -12, -10, -8, -7, -5, -3, 0, 2, 3, 3, 2, 2, 2, 2, 4, 6, 7, 9, 10,
10, 12, 13, 15, 17, 18, 19, 21, 21, 23, 25, 26, 26, 28, 29, 31, 33, 33, 35, 36,
38, 39, 41, 42, 43, 44, 46, 47, 49, 50, 51, 53, 54, 55, 56, 51, 47, 42, 37, 33,
28, 25, 20, 17, 10, 8, 2, 0, -7, -9, -17, -15, -30, 5, 36, 24, 30, 23, 25, 21,
23, 18, 20, 14, 18, 12, 16, 10, 13, 5, 11, 2, 10, -9, -122, -115, -113, -110,
-105, -105, -99, -98, -93, -93, -86, -86, -81, -81, -76, -74, -70, -68, -64,
-61, -58, -55, -52, -49, -46, -43, -40, -36, -34, -30, -28, -24, -21, -19, -16,
-13, -10, -6, -3, 1, 5, 7, 8, 10, 11, 13, 15, 16, 18, 19, 21, 24, 25, 26, 27,
30, 31, 32, 35, 35, 37, 39, 41, 42, 43, 45, 47, 48, 51, 52, 53, 55, 57, 58, 59,
61, 63, 64, 66, 65, 63, 63, 61, 58, 59, 55, 62, 55, 40, 43, 42, 42, 44, 43, 41,
40, 38, 36, 36, 32, 32, 29, 28, 27, 25, 23, 22, 21, 19, 17, 15, 14, 12, 11, 7,
10, 2, 12, -29, -66, -52, -58, -51, -53, -48, -49, -45, -46, -42, -42, -40, -39,
-38, -36, -36, -33, -33, -31, -32, -27, -29, -24, -28, -20, -28, -11, -49, -45,
-1, -16, -7, -15, -11, -14, -13, -15, -14, -16, -16, -17, -17, -18, -19, -18,
-20, -20, -20, -16, -18, -16, -16, -14, -14, -13, -13, -12, -11, -10, -10, -8,
-8, -7, -7, -6, -5, -5, -3, -3, -2, -1, -1, 1, 1, 2, 3, 4, 3, 6, 3, -2, -1, -1,
1, 1, 2, 5, 10, 7, 9, 7, 9, 7, 8, 6, 8, 7, 7, 6, 5, 6, 5, 7, 4, 8, 2, 8, 1, 9,
-2, 13, -6, 19, -32, -61, 21, 4, 8, 8, -7, -50, -39, -39, -35, -30, -29, -21,
-21, -14, -14, -6, -6, 3, 3, 10, 10, 17, 20, 23, 32, -12, -27, -19, -22, -16,
-17, -12, -13, -9, -9, -6, -6, -3, -2, };