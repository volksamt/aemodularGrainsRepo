#define DATA_LENGTH 512
#define DATA AKWF_1351

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0,
1, 1, 1, 1, 1, 0, 1, 2, 1, 2, 2, 2, 2, 2, 2, 2, 3, 3, 2, 3, 4, 3, 4, 3, 4, 4, 4,
5, 4, 5, 5, 6, 6, 6, 6, 6, 7, 7, 8, 7, 8, 8, 8, 9, 9, 9, 9, 9, 10, 11, 11, 11,
11, 12, 11, 12, 13, 13, 13, 13, 14, 14, 15, 15, 15, 16, 16, 16, 17, 17, 17, 18,
19, 18, 19, 19, 20, 20, 20, 20, 21, 21, 22, 22, 23, 23, 24, 24, 24, 24, 25, 25,
25, 26, 26, 26, 26, 26, 26, 27, 28, 28, 28, 29, 29, 29, 30, 30, 30, 30, 31, 30,
32, 32, 32, 32, 32, 33, 32, 33, 33, 34, 33, 33, 34, 34, 34, 35, 35, 35, 34, 35,
35, 36, 35, 36, 35, 36, 35, 36, 37, 35, 35, 36, 36, 36, 36, 36, 36, 36, 35, 36,
36, 35, 36, 35, 35, 35, 35, 36, 35, 34, 34, 34, 33, 35, 34, 33, 33, 33, 33, 33,
32, 32, 32, 31, 30, 30, 30, 29, 29, 30, 28, 28, 28, 27, 26, 26, 26, 25, 24, 23,
23, 23, 22, 21, 21, 21, 20, 19, 19, 18, 18, 17, 16, 15, 15, 13, 13, 13, 11, 11,
10, 8, 8, 8, 7, 6, 4, 4, 3, 2, 1, 0, 0, -1, -2, -3, -4, -5, -6, -8, -8, -9, -10,
-11, -12, -14, -14, -15, -17, -18, -18, -19, -21, -22, -23, -23, -25, -25, -27,
-29, -29, -30, -31, -32, -34, -34, -35, -37, -37, -39, -40, -41, -42, -44, -44,
-45, -47, -48, -49, -50, -51, -51, -53, -54, -55, -56, -57, -57, -58, -60, -61,
-61, -62, -63, -64, -65, -66, -68, -67, -68, -69, -70, -72, -71, -73, -73, -74,
-74, -75, -76, -76, -77, -77, -78, -79, -79, -79, -81, -81, -81, -81, -82, -82,
-83, -83, -83, -84, -84, -84, -84, -84, -83, -84, -83, -83, -84, -83, -84, -83,
-84, -83, -83, -83, -82, -81, -82, -81, -80, -79, -79, -78, -79, -77, -77, -75,
-75, -74, -74, -73, -72, -70, -69, -69, -67, -66, -64, -64, -62, -61, -60, -59,
-57, -55, -54, -53, -52, -49, -48, -46, -45, -43, -42, -39, -38, -36, -34, -32,
-30, -28, -26, -25, -22, -20, -18, -16, -14, -12, -9, -7, -5, -3, 0, 3, 5, 7, 9,
11, 14, 16, 19, 20, 22, 26, 28, 29, 32, 36, 38, 39, 42, 45, 47, 49, 52, 53, 56,
59, 61, 63, 66, 68, 69, 72, 74, 77, 78, 80, 83, 84, 86, 88, 90, 91, 94, 95, 97,
99, 100, 102, 103, 104, 106, 107, 109, 110, 112, 112, 112, 114, 114, 115, 115,
116, 118, 118, 118, 118, 119, 119, 120, 119, 120, 119, 118, 118, 118, 118, 117,
116, 114, 114, 114, 112, 111, 110, 109, 107, 105, 104, 102, 101, 99, 97, 94, 93,
90, 88, 84, 84, 80, 78, 74, 73, 68, 68, 61, 64, 48, };