#define DATA_LENGTH 512
#define DATA AKWF_1323

const PROGMEM int8_t DATA[DATA_LENGTH] = {91, 104, 96, 101, 96, 100, 96, 101,
97, 100, 97, 99, 98, 99, 98, 99, 98, 98, 99, 99, 98, 99, 99, 99, 99, 99, 98, 98,
98, 98, 98, 98, 99, 99, 99, 99, 98, 98, 99, 98, 99, 99, 99, 99, 98, 98, 99, 99,
99, 99, 98, 98, 98, 99, 98, 98, 99, 99, 99, 99, 99, 98, 99, 99, 99, 99, 98, 99,
99, 99, 99, 98, 99, 99, 99, 99, 99, 98, 98, 99, 98, 98, 99, 98, 98, 98, 99, 98,
98, 99, 99, 99, 99, 99, 98, 99, 98, 99, 99, 98, 98, 98, 98, 98, 99, 98, 98, 98,
99, 98, 98, 98, 99, 98, 98, 98, 99, 98, 99, 99, 99, 99, 98, 99, 98, 99, 98, 99,
98, 99, 98, 99, 99, 99, 98, 99, 98, 98, 99, 99, 99, 99, 98, 99, 100, 97, 99, 97,
101, 95, 103, 92, 111, 71, 3, 20, 12, 17, 13, 15, 14, 15, 15, 14, 15, 14, 15,
14, 16, 14, 16, 15, 15, 14, 15, 15, 16, 14, 15, 14, 15, 14, 14, 15, 15, 15, 15,
14, 15, 15, 14, 15, 15, 15, 15, 15, 15, 15, 15, 16, 15, 15, 15, 15, 15, 15, 15,
15, 16, 15, 15, 15, 16, 15, 15, 15, 15, 14, 14, 15, 15, 15, 15, 15, 15, 15, 15,
15, 15, 15, 15, 15, 15, 15, 15, 16, 15, 15, 15, 15, 15, 15, 15, 14, 15, 15, 15,
15, 15, 15, 15, 14, 15, 15, 14, 15, 15, 15, 15, 16, 15, 15, 14, 14, 15, 15, 15,
15, 15, 15, 14, 15, 15, 15, 15, 14, 14, 15, 15, 15, 14, 15, 15, 15, 15, 15, 15,
15, 15, 15, 15, 16, 14, 15, 15, 15, 15, 14, 15, 15, 15, 15, 15, 15, 15, 15, 14,
15, 15, 15, 15, 14, 15, 14, 15, 14, 15, 13, 16, 14, 16, 13, 16, 13, 17, 6, -78,
-102, -99, -102, -99, -102, -99, -101, -99, -100, -99, -101, -100, -100, -99,
-100, -100, -100, -100, -100, -99, -100, -100, -100, -100, -100, -101, -100,
-101, -101, -101, -100, -100, -99, -101, -100, -99, -99, -101, -100, -100, -100,
-100, -100, -100, -100, -100, -100, -101, -100, -100, -100, -100, -100, -100,
-100, -100, -100, -100, -100, -100, -100, -100, -100, -99, -100, -100, -100,
-100, -100, -100, -100, -100, -100, -99, -100, -100, -99, -99, -100, -100, -100,
-100, -100, -100, -99, -100, -100, -100, -100, -100, -100, -101, -99, -100,
-100, -100, -100, -100, -101, -100, -100, -100, -100, -99, -100, -100, -101,
-100, -100, -100, -100, -100, -100, -100, -101, -99, -100, -101, -101, -100,
-99, -100, -100, -100, -100, -100, -100, -100, -100, -100, -100, -100, -100,
-100, -101, -100, -100, -101, -100, -100, -100, -99, -99, -100, -100, -100, -99,
-99, -100, -100, -101, -99, -100, -100, -100, -99, -100, -100, -100, -100, -101,
-100, -101, -101, -100, -100, -100, -101, -100, -101, -98, -101, -98, -101, -98,
-102, -97, -102, -97, -103, -96, -105, -95, -108, -101, };