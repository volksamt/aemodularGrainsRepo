#define DATA_LENGTH 512
#define DATA AKWF_1360

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 4, 5, 6, 8, 9, 10, 11, 13,
13, 14, 16, 16, 18, 19, 20, 21, 22, 23, 24, 26, 26, 28, 29, 31, 31, 33, 34, 36,
37, 38, 39, 40, 42, 44, 45, 45, 48, 48, 50, 51, 53, 53, 55, 57, 59, 59, 61, 64,
64, 66, 66, 69, 71, 72, 73, 74, 76, 77, 78, 80, 82, 82, 84, 85, 86, 88, 89, 91,
92, 93, 94, 96, 97, 98, 99, 101, 102, 104, 104, 105, 106, 108, 107, 108, 110,
111, 112, 112, 113, 114, 115, 115, 116, 116, 117, 117, 117, 118, 118, 119, 118,
119, 119, 119, 119, 118, 118, 119, 118, 119, 119, 118, 117, 117, 117, 116, 116,
115, 115, 114, 114, 113, 113, 112, 111, 111, 109, 108, 107, 106, 104, 105, 103,
102, 101, 100, 98, 97, 96, 94, 93, 92, 91, 89, 89, 86, 86, 84, 82, 81, 79, 77,
77, 75, 74, 73, 71, 70, 69, 66, 66, 64, 63, 61, 59, 58, 57, 55, 54, 52, 51, 49,
48, 47, 45, 44, 43, 41, 39, 39, 38, 36, 35, 34, 33, 31, 30, 28, 28, 26, 25, 23,
23, 21, 19, 19, 17, 17, 15, 14, 14, 12, 11, 10, 10, 8, 7, 5, 5, 3, 3, 1, 1, 0,
-2, -3, -3, -5, -6, -7, -8, -9, -10, -11, -12, -13, -14, -15, -16, -18, -19,
-19, -20, -22, -23, -23, -25, -25, -27, -27, -29, -30, -31, -32, -32, -34, -34,
-36, -36, -37, -39, -39, -40, -41, -42, -43, -44, -45, -46, -47, -48, -48, -49,
-51, -51, -52, -53, -54, -55, -55, -56, -57, -57, -57, -58, -60, -61, -61, -61,
-62, -62, -63, -63, -63, -64, -64, -65, -65, -65, -66, -66, -66, -66, -67, -67,
-67, -67, -67, -67, -67, -68, -67, -68, -66, -66, -66, -67, -66, -66, -67, -66,
-65, -66, -66, -65, -65, -65, -64, -63, -63, -63, -62, -61, -61, -61, -60, -60,
-60, -59, -58, -59, -58, -57, -58, -56, -57, -55, -56, -55, -55, -55, -54, -54,
-54, -53, -53, -53, -53, -51, -51, -52, -51, -51, -50, -50, -50, -51, -50, -51,
-50, -49, -50, -50, -50, -50, -50, -50, -50, -50, -50, -50, -50, -51, -50, -51,
-52, -52, -52, -53, -52, -53, -53, -53, -54, -54, -55, -55, -56, -55, -56, -57,
-58, -57, -58, -58, -58, -59, -59, -60, -60, -60, -61, -62, -62, -62, -63, -62,
-63, -64, -64, -64, -64, -64, -65, -66, -66, -65, -65, -65, -66, -66, -66, -66,
-65, -66, -66, -66, -66, -66, -66, -66, -65, -65, -65, -65, -65, -64, -64, -64,
-63, -62, -63, -61, -61, -61, -59, -60, -59, -58, -58, -56, -57, -56, -56, -55,
-54, -53, -52, -51, -51, -50, -49, -48, -47, -46, -45, -44, -43, -42, -42, -41,
-39, -39, -38, -37, -35, -35, -33, -33, -31, -31, -30, -28, -28, -26, -26, -25,
-23, -22, -21, -21, -20, -18, -18, -16, -15, -14, -13, -11, -11, -9, -7, -5, -5,
-3, -3, -1, 0, };