#define DATA_LENGTH 512
#define DATA AKWF_1394

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 7, 10, 11, 15, 17, 19, 21,
24, 26, 28, 31, 33, 35, 37, 40, 42, 45, 47, 49, 51, 54, 55, 58, 61, 62, 64, 66,
69, 70, 73, 76, 78, 79, 82, 83, 85, 88, 89, 92, 94, 96, 98, 99, 101, 102, 103,
104, 106, 106, 107, 108, 109, 110, 110, 111, 111, 113, 113, 113, 114, 114, 114,
114, 115, 114, 116, 116, 115, 116, 116, 116, 117, 117, 117, 117, 117, 117, 117,
117, 117, 117, 118, 118, 118, 118, 118, 119, 117, 118, 118, 119, 118, 119, 118,
117, 118, 118, 118, 119, 118, 119, 118, 118, 119, 118, 118, 119, 118, 118, 119,
118, 119, 119, 118, 119, 118, 119, 119, 118, 119, 118, 118, 119, 119, 118, 119,
118, 119, 119, 119, 118, 119, 118, 118, 118, 119, 119, 119, 119, 119, 119, 119,
118, 118, 118, 118, 118, 119, 119, 118, 118, 118, 118, 119, 118, 118, 118, 118,
118, 118, 119, 118, 119, 118, 118, 117, 117, 118, 117, 118, 117, 116, 117, 117,
117, 116, 117, 116, 116, 117, 116, 116, 115, 115, 115, 114, 115, 114, 114, 114,
113, 112, 112, 111, 112, 111, 110, 109, 109, 108, 107, 107, 106, 105, 103, 103,
101, 99, 99, 97, 95, 94, 92, 90, 87, 86, 83, 82, 80, 78, 76, 73, 71, 69, 68, 66,
64, 61, 60, 58, 56, 53, 52, 50, 48, 45, 43, 41, 39, 38, 35, 34, 31, 30, 28, 25,
23, 22, 19, 18, 16, 14, 11, 10, 8, 6, 4, 3, -1, -2, -4, -6, -8, -9, -11, -13,
-15, -17, -19, -22, -24, -25, -27, -30, -31, -33, -35, -38, -39, -41, -44, -46,
-48, -50, -51, -54, -56, -58, -59, -62, -64, -67, -69, -71, -72, -75, -77, -79,
-81, -83, -85, -88, -89, -92, -94, -97, -98, -99, -100, -102, -104, -105, -106,
-107, -107, -109, -110, -111, -111, -112, -111, -112, -113, -113, -114, -114,
-115, -115, -115, -116, -116, -116, -116, -116, -116, -117, -117, -117, -118,
-118, -117, -117, -118, -118, -117, -118, -118, -118, -118, -119, -119, -119,
-119, -118, -118, -118, -119, -118, -119, -119, -119, -119, -118, -119, -119,
-118, -120, -119, -119, -119, -118, -119, -119, -119, -120, -119, -118, -120,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -120, -119, -119, -119,
-118, -119, -119, -118, -119, -118, -118, -119, -119, -119, -119, -118, -119,
-118, -119, -118, -119, -119, -119, -118, -118, -119, -118, -118, -118, -118,
-118, -117, -118, -118, -117, -118, -117, -117, -116, -116, -116, -116, -116,
-115, -116, -115, -114, -114, -114, -113, -114, -112, -112, -112, -110, -110,
-110, -109, -108, -106, -105, -104, -103, -102, -99, -99, -96, -94, -93, -91,
-88, -86, -84, -83, -80, -78, -76, -73, -71, -69, -67, -64, -62, -60, -57, -55,
-53, -51, -49, -47, -43, -42, -39, -37, -35, -33, -29, -27, -25, -23, -20, -18,
-16, -13, -11, -9, -6, -3, -2, };