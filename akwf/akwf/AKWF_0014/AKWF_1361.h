#define DATA_LENGTH 512
#define DATA AKWF_1361

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 5, 7, 7, 10, 10, 12, 14,
15, 15, 17, 18, 19, 21, 23, 24, 26, 27, 30, 31, 32, 34, 35, 37, 39, 40, 41, 45,
46, 48, 50, 51, 53, 54, 57, 58, 59, 62, 64, 66, 68, 70, 71, 73, 74, 76, 79, 80,
81, 84, 85, 87, 88, 90, 92, 94, 95, 97, 98, 100, 101, 103, 103, 105, 106, 108,
108, 109, 111, 111, 112, 113, 114, 115, 116, 116, 117, 117, 117, 118, 118, 118,
119, 119, 119, 119, 119, 119, 119, 118, 119, 117, 117, 117, 117, 115, 115, 114,
114, 113, 112, 110, 110, 109, 107, 107, 105, 104, 104, 101, 100, 99, 97, 96, 94,
92, 91, 89, 88, 86, 84, 83, 80, 79, 77, 76, 74, 72, 70, 68, 66, 64, 63, 61, 59,
58, 55, 54, 52, 50, 48, 46, 45, 42, 42, 39, 38, 36, 34, 33, 32, 29, 28, 26, 24,
22, 22, 19, 18, 17, 15, 14, 12, 11, 11, 8, 7, 6, 5, 3, 3, 2, 0, 0, -2, -3, -4,
-6, -6, -7, -8, -9, -10, -11, -11, -12, -13, -13, -16, -15, -17, -17, -18, -19,
-20, -21, -22, -22, -23, -24, -24, -26, -26, -27, -28, -28, -30, -29, -31, -31,
-32, -33, -34, -34, -36, -37, -37, -38, -38, -39, -40, -40, -42, -42, -43, -43,
-43, -45, -45, -46, -47, -48, -48, -50, -49, -50, -51, -52, -53, -53, -53, -55,
-55, -55, -55, -56, -57, -58, -58, -57, -59, -59, -59, -60, -59, -59, -60, -60,
-60, -60, -60, -61, -60, -60, -61, -60, -59, -60, -59, -59, -58, -59, -59, -58,
-58, -57, -57, -56, -56, -54, -54, -53, -53, -52, -52, -51, -50, -48, -48, -47,
-47, -45, -44, -43, -43, -41, -40, -40, -38, -37, -36, -35, -34, -33, -32, -31,
-29, -28, -28, -27, -25, -25, -22, -22, -21, -20, -19, -18, -17, -16, -15, -15,
-14, -13, -12, -12, -11, -11, -9, -9, -8, -8, -8, -7, -7, -7, -7, -6, -7, -6,
-5, -6, -5, -6, -6, -5, -5, -7, -6, -6, -7, -8, -7, -8, -9, -10, -10, -11, -10,
-11, -13, -14, -14, -15, -15, -17, -18, -18, -19, -19, -21, -23, -22, -23, -25,
-27, -27, -28, -30, -30, -31, -33, -34, -35, -36, -37, -38, -39, -40, -42, -42,
-43, -44, -46, -45, -47, -48, -49, -49, -50, -51, -52, -52, -53, -54, -54, -55,
-56, -56, -57, -58, -57, -58, -59, -59, -58, -59, -59, -59, -59, -59, -60, -60,
-60, -60, -59, -59, -59, -59, -59, -58, -58, -59, -58, -57, -57, -56, -56, -56,
-56, -55, -54, -54, -54, -53, -52, -52, -50, -50, -50, -49, -48, -48, -47, -46,
-44, -45, -44, -43, -42, -41, -41, -40, -39, -38, -38, -37, -36, -35, -35, -33,
-32, -32, -31, -30, -30, -30, -28, -27, -27, -26, -26, -25, -24, -23, -22, -22,
-21, -20, -20, -18, -18, -18, -16, -15, -14, -13, -13, -12, -11, -11, -9, -8,
-8, -6, -5, -4, -2, -1, };