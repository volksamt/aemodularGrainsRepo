#define DATA_LENGTH 512
#define DATA AKWF_1307

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 4, 5, 7, 10, 11, 14, 16, 18, 20,
24, 26, 29, 33, 38, 41, 42, 45, 47, 49, 52, 54, 57, 60, 62, 65, 67, 70, 71, 74,
76, 78, 81, 83, 85, 86, 89, 91, 92, 94, 96, 97, 100, 101, 103, 104, 106, 107,
108, 109, 111, 112, 113, 114, 115, 116, 116, 116, 118, 118, 119, 119, 119, 119,
119, 119, 119, 119, 118, 117, 116, 115, 114, 113, 111, 109, 107, 104, 101, 96,
94, 92, 90, 86, 83, 79, 77, 73, 70, 65, 61, 55, 47, 41, 40, 36, 33, 29, 24, 21,
17, 13, 9, 5, 1, -3, -6, -9, -13, -16, -19, -23, -26, -28, -31, -34, -37, -40,
-41, -44, -46, -49, -51, -53, -55, -57, -59, -60, -61, -64, -65, -67, -68, -69,
-70, -72, -73, -74, -75, -75, -76, -77, -77, -79, -79, -80, -80, -81, -82, -82,
-84, -84, -85, -84, -86, -86, -87, -87, -87, -88, -88, -89, -89, -90, -89, -91,
-90, -92, -92, -92, -93, -93, -93, -93, -94, -94, -95, -94, -95, -95, -96, -95,
-96, -95, -96, -96, -96, -97, -97, -96, -97, -96, -95, -95, -96, -95, -95, -95,
-94, -94, -94, -92, -92, -91, -90, -91, -89, -88, -86, -84, -83, -81, -81, -77,
-74, -71, -70, -70, -67, -65, -63, -61, -59, -57, -55, -53, -50, -48, -45, -43,
-40, -36, -33, -31, -30, -27, -25, -24, -21, -20, -17, -15, -12, -10, -7, -6,
-5, -2, 0, 1, 3, 6, 7, 10, 11, 14, 16, 18, 20, 23, 25, 28, 30, 32, 36, 38, 40,
43, 44, 46, 48, 51, 53, 54, 56, 58, 60, 62, 64, 66, 67, 70, 70, 72, 74, 75, 77,
77, 79, 81, 82, 83, 84, 85, 87, 88, 88, 89, 91, 92, 92, 94, 94, 95, 96, 96, 97,
98, 98, 98, 98, 99, 100, 99, 99, 100, 99, 99, 99, 98, 97, 98, 96, 97, 95, 95,
94, 94, 92, 91, 90, 88, 89, 86, 84, 83, 83, 81, 79, 77, 75, 74, 70, 68, 66, 63,
60, 58, 54, 51, 44, 39, 39, 36, 34, 31, 27, 25, 22, 19, 16, 13, 10, 8, 6, 3, 0,
-2, -5, -7, -8, -10, -12, -14, -17, -18, -20, -22, -24, -26, -26, -29, -30, -32,
-33, -34, -36, -37, -38, -40, -41, -42, -44, -45, -46, -47, -49, -48, -49, -50,
-51, -53, -53, -55, -56, -56, -57, -58, -58, -60, -60, -60, -62, -62, -63, -64,
-65, -65, -65, -66, -67, -68, -68, -68, -69, -69, -70, -70, -71, -72, -71, -72,
-73, -73, -73, -73, -73, -73, -73, -73, -73, -73, -74, -74, -74, -74, -73, -73,
-73, -72, -72, -71, -70, -70, -69, -68, -68, -66, -66, -64, -63, -61, -60, -56,
-54, -52, -52, -50, -48, -47, -46, -45, -43, -42, -41, -39, -37, -36, -35, -33,
-32, -31, -30, -29, -27, -26, -25, -25, -24, -22, -22, -20, -20, -18, -18, -17,
-16, -15, -14, -13, -12, -11, -10, -9, -8, -6, -5, -4, -2, -1, 0, };