#define DATA_LENGTH 512
#define DATA AKWF_1311

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 4, 6, 8, 10, 11, 12, 13, 15,
16, 18, 18, 20, 21, 22, 23, 25, 27, 27, 28, 30, 30, 31, 32, 34, 35, 36, 36, 39,
39, 40, 41, 42, 43, 44, 44, 46, 47, 48, 49, 50, 50, 52, 52, 53, 54, 54, 55, 56,
57, 58, 60, 59, 61, 61, 63, 63, 64, 65, 66, 66, 67, 67, 68, 70, 70, 71, 71, 72,
72, 73, 75, 74, 75, 76, 77, 77, 77, 78, 79, 80, 81, 80, 82, 82, 83, 83, 84, 84,
85, 85, 86, 87, 87, 87, 88, 89, 90, 90, 90, 90, 92, 92, 92, 92, 92, 93, 93, 94,
95, 96, 96, 96, 96, 97, 98, 98, 99, 99, 100, 99, 100, 100, 101, 100, 102, 101,
101, 102, 102, 103, 104, 104, 104, 105, 105, 105, 105, 106, 106, 106, 107, 107,
108, 108, 108, 108, 108, 109, 109, 109, 109, 110, 109, 111, 111, 112, 112, 112,
111, 111, 113, 113, 113, 113, 113, 114, 114, 114, 114, 114, 115, 114, 116, 115,
115, 116, 117, 116, 117, 117, 116, 117, 117, 118, 118, 118, 118, 118, 119, 118,
118, 119, 118, 117, 116, 113, 111, 108, 105, 102, 100, 98, 95, 93, 90, 89, 86,
83, 80, 79, 76, 75, 72, 70, 67, 66, 63, 61, 59, 58, 55, 53, 51, 49, 47, 46, 43,
42, 39, 38, 36, 34, 32, 31, 28, 27, 25, 24, 22, 21, 19, 18, 16, 14, 12, 11, 10,
7, 6, 4, 3, 2, 0, -1, -4, -4, -6, -7, -9, -11, -11, -13, -13, -14, -16, -17,
-18, -20, -21, -23, -23, -24, -26, -27, -28, -30, -30, -31, -33, -34, -35, -36,
-37, -37, -39, -41, -41, -42, -43, -44, -45, -47, -48, -47, -49, -50, -50, -52,
-53, -54, -54, -56, -56, -56, -57, -59, -59, -60, -60, -62, -62, -63, -65, -65,
-66, -66, -66, -67, -68, -69, -70, -70, -71, -71, -73, -74, -75, -75, -75, -75,
-77, -77, -78, -78, -80, -79, -80, -81, -81, -82, -83, -84, -84, -84, -85, -85,
-86, -86, -87, -88, -88, -89, -89, -90, -90, -91, -91, -92, -91, -93, -93, -94,
-94, -94, -95, -96, -95, -97, -97, -97, -97, -98, -99, -99, -100, -99, -100,
-100, -100, -100, -101, -102, -102, -102, -103, -103, -103, -104, -104, -104,
-105, -105, -105, -105, -106, -106, -106, -107, -107, -107, -108, -108, -108,
-109, -110, -110, -109, -110, -110, -111, -111, -110, -112, -111, -112, -112,
-112, -113, -113, -113, -113, -114, -114, -114, -115, -115, -114, -115, -115,
-116, -115, -116, -117, -116, -116, -116, -117, -117, -117, -117, -119, -118,
-118, -118, -118, -119, -119, -119, -118, -116, -115, -112, -110, -108, -106,
-103, -100, -97, -95, -92, -90, -88, -85, -84, -80, -79, -76, -75, -71, -69,
-68, -66, -63, -60, -60, -58, -55, -53, -51, -49, -47, -45, -43, -40, -40, -38,
-35, -33, -32, -30, -29, -27, -24, -24, -22, -20, -18, -17, -16, -14, -12, -11,
-9, -8, -6, -5, -2, -1, 0, };