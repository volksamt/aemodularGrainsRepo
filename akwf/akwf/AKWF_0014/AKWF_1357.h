#define DATA_LENGTH 512
#define DATA AKWF_1357

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 30, 42, 51, 59, 64, 72, 76, 81, 85,
90, 92, 96, 98, 102, 103, 106, 108, 109, 111, 112, 113, 114, 116, 116, 117, 117,
118, 119, 119, 120, 119, 119, 118, 118, 119, 118, 119, 118, 117, 116, 116, 116,
115, 114, 113, 113, 112, 111, 110, 109, 107, 106, 106, 104, 104, 102, 101, 100,
98, 97, 96, 94, 94, 92, 90, 89, 87, 86, 84, 83, 82, 80, 78, 77, 75, 74, 73, 71,
70, 68, 67, 66, 64, 62, 61, 59, 57, 57, 54, 53, 52, 50, 49, 47, 46, 43, 43, 41,
39, 38, 36, 35, 34, 32, 31, 29, 28, 26, 26, 23, 22, 21, 19, 18, 16, 16, 15, 12,
12, 9, 9, 7, 5, 4, 3, 2, 1, -1, -2, -4, -5, -6, -7, -9, -9, -11, -12, -14, -15,
-17, -18, -20, -21, -22, -23, -24, -24, -26, -27, -29, -30, -30, -33, -34, -34,
-36, -37, -38, -40, -41, -42, -43, -43, -46, -47, -46, -48, -50, -51, -51, -52,
-55, -55, -57, -57, -58, -60, -60, -61, -62, -63, -65, -66, -67, -68, -69, -69,
-71, -72, -72, -73, -75, -75, -76, -77, -78, -79, -80, -81, -82, -83, -83, -84,
-86, -87, -87, -88, -89, -89, -90, -90, -91, -92, -93, -94, -95, -95, -97, -98,
-98, -99, -99, -99, -100, -102, -101, -102, -102, -103, -103, -104, -106, -105,
-106, -106, -107, -107, -108, -109, -109, -110, -110, -111, -110, -111, -111,
-112, -113, -112, -113, -114, -113, -114, -115, -115, -115, -115, -115, -116,
-115, -116, -116, -116, -117, -116, -118, -117, -118, -117, -118, -118, -118,
-118, -119, -118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -119, -119, -119, -119, -118, -119, -118, -119, -119, -118,
-118, -118, -118, -119, -119, -118, -118, -117, -117, -117, -117, -117, -116,
-116, -116, -117, -116, -116, -114, -114, -114, -115, -114, -113, -114, -113,
-113, -113, -113, -112, -111, -111, -111, -110, -110, -111, -110, -110, -108,
-108, -108, -108, -108, -107, -107, -106, -105, -105, -105, -104, -103, -104,
-103, -102, -101, -101, -101, -101, -99, -99, -98, -98, -97, -98, -96, -97, -95,
-96, -95, -94, -94, -92, -92, -92, -92, -90, -90, -90, -89, -88, -88, -87, -87,
-85, -85, -85, -84, -83, -82, -82, -81, -80, -79, -79, -78, -78, -77, -77, -76,
-75, -75, -74, -74, -72, -72, -72, -71, -70, -69, -69, -68, -68, -67, -66, -65,
-65, -64, -64, -63, -63, -62, -62, -60, -59, -59, -58, -57, -57, -55, -55, -54,
-54, -52, -53, -52, -51, -50, -50, -49, -49, -47, -47, -46, -45, -45, -44, -44,
-43, -42, -41, -40, -39, -40, -39, -38, -37, -37, -35, -35, -34, -34, -33, -32,
-32, -31, -30, -29, -29, -28, -28, -27, -26, -25, -25, -25, -23, -23, -21, -22,
-20, -20, -20, -19, -17, -17, -17, -16, -15, -14, -14, -14, -13, -13, -12, -11,
-10, -10, -9, -8, -7, -8, -6, -6, -4, -4, -4, -3, -2, -2, -1, 0, 1, 1, };