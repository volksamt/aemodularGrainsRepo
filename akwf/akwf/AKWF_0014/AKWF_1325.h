#define DATA_LENGTH 512
#define DATA AKWF_1325

const PROGMEM int8_t DATA[DATA_LENGTH] = {98, 118, 110, 117, 111, 116, 111, 115,
112, 115, 112, 114, 112, 115, 112, 113, 112, 114, 114, 114, 114, 114, 113, 114,
114, 113, 113, 114, 115, 113, 114, 113, 114, 114, 114, 113, 114, 113, 114, 114,
114, 114, 113, 113, 114, 113, 114, 114, 114, 113, 113, 113, 113, 113, 113, 113,
113, 114, 114, 114, 113, 113, 113, 113, 114, 114, 114, 113, 114, 113, 114, 114,
113, 114, 114, 114, 114, 114, 114, 114, 113, 115, 113, 113, 114, 113, 113, 114,
114, 113, 114, 113, 114, 113, 114, 113, 113, 114, 113, 113, 114, 113, 114, 114,
113, 114, 113, 113, 113, 114, 114, 114, 114, 113, 114, 114, 114, 114, 114, 114,
114, 113, 113, 113, 114, 113, 114, 113, 114, 114, 114, 113, 113, 114, 114, 114,
114, 114, 114, 114, 113, 115, 112, 114, 112, 117, 109, 123, 77, 28, 40, 33, 38,
35, 37, 35, 36, 35, 36, 35, 36, 36, 36, 36, 36, 37, 35, 36, 35, 36, 36, 36, 35,
36, 36, 36, 35, 37, 35, 36, 36, 36, 36, 36, 35, 36, 35, 35, 36, 36, 36, 36, 36,
35, 35, 36, 36, 36, 36, 36, 36, 35, 36, 36, 36, 36, 36, 36, 37, 35, 35, 35, 36,
36, 35, 35, 36, 36, 36, 35, 35, 36, 36, 36, 36, 36, 36, 36, 36, 36, 35, 37, 35,
36, 36, 37, 36, 36, 36, 37, 36, 37, 36, 36, 35, 37, 35, 36, 36, 35, 36, 36, 37,
34, 38, 33, 40, 28, 51, -52, -128, -112, -125, -115, -121, -117, -121, -118,
-119, -118, -119, -118, -119, -120, -119, -119, -119, -119, -118, -119, -118,
-119, -118, -120, -119, -120, -119, -119, -118, -119, -120, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -120, -118, -120,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -118, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -118, -120, -119, -119, -118, -119, -119, -118, -119, -119,
-120, -120, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -118,
-118, -118, -119, -119, -119, -119, -119, -119, -119, -120, -120, -119, -119,
-119, -119, -119, -119, -118, -118, -119, -118, -120, -118, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -120, -120, -113,
-39, -8, -18, -11, -16, -12, -15, -13, -14, -13, -14, -14, -15, -14, -14, -14,
-14, -15, -14, -14, -13, -15, -14, -14, -13, -14, -14, -15, -14, -14, -14, -15,
-14, -15, -15, -14, -14, -14, -14, -14, -14, -15, -14, -14, -14, -14, -14, -14,
-15, -14, -14, -14, -14, -14, -14, -14, -15, -14, -15, -14, -14, -14, -14, -14,
-15, -15, -14, -15, -13, -14, -14, -14, -14, -14, -14, -14, -15, -14, -14, -14,
-14, -15, -14, -14, -14, -14, -15, -13, -14, -14, -14, -14, -14, -15, -14, -14,
-14, -14, -15, -14, -14, -14, -15, -15, -14, -14, -14, -14, -15, -14, -14, -13,
-15, -13, };