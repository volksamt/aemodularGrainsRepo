#define DATA_LENGTH 512
#define DATA AKWF_1359

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 4, 6, 7, 8, 9, 10, 11, 12,
13, 15, 16, 17, 18, 19, 21, 22, 23, 24, 25, 27, 27, 29, 31, 31, 33, 34, 35, 35,
37, 38, 39, 41, 42, 43, 44, 46, 48, 48, 49, 51, 52, 53, 54, 55, 57, 58, 60, 61,
62, 63, 64, 65, 66, 68, 69, 70, 72, 74, 73, 76, 77, 78, 79, 80, 81, 83, 84, 85,
86, 87, 88, 90, 92, 91, 93, 94, 96, 96, 97, 98, 99, 100, 101, 102, 103, 104,
105, 106, 107, 108, 109, 109, 110, 111, 112, 112, 113, 113, 114, 115, 116, 115,
116, 116, 117, 117, 118, 118, 118, 118, 118, 119, 118, 119, 119, 119, 119, 120,
119, 119, 118, 118, 118, 119, 118, 117, 117, 116, 116, 115, 115, 115, 114, 114,
114, 113, 112, 111, 111, 110, 109, 108, 108, 106, 105, 105, 104, 103, 102, 102,
100, 99, 98, 97, 96, 95, 94, 93, 92, 90, 89, 88, 86, 86, 85, 84, 82, 82, 80, 79,
77, 76, 75, 74, 73, 72, 70, 69, 67, 66, 65, 64, 62, 62, 60, 58, 57, 56, 55, 54,
52, 52, 49, 49, 48, 46, 45, 44, 43, 41, 40, 39, 37, 36, 36, 33, 33, 31, 31, 30,
28, 26, 25, 24, 23, 22, 21, 19, 18, 17, 16, 14, 13, 12, 12, 10, 9, 8, 7, 6, 4,
3, 2, 1, 0, -3, -4, -5, -5, -7, -8, -9, -10, -12, -12, -14, -15, -17, -17, -19,
-20, -21, -22, -23, -26, -26, -27, -28, -30, -30, -32, -33, -34, -35, -37, -37,
-39, -39, -41, -42, -43, -44, -45, -46, -48, -48, -50, -51, -51, -52, -54, -55,
-56, -56, -58, -58, -59, -60, -61, -62, -63, -63, -64, -65, -65, -66, -68, -69,
-68, -69, -69, -71, -71, -72, -73, -73, -73, -73, -74, -74, -75, -75, -76, -76,
-76, -77, -77, -77, -77, -78, -78, -79, -78, -79, -79, -79, -79, -79, -80, -80,
-80, -80, -80, -80, -80, -80, -80, -80, -80, -79, -80, -80, -80, -80, -79, -79,
-80, -80, -80, -80, -79, -79, -79, -78, -78, -79, -79, -79, -79, -78, -78, -79,
-79, -79, -78, -78, -79, -77, -78, -79, -78, -78, -78, -78, -78, -78, -77, -78,
-78, -79, -77, -78, -78, -79, -79, -79, -78, -78, -79, -78, -79, -78, -78, -79,
-79, -78, -79, -79, -79, -79, -79, -79, -79, -79, -79, -79, -79, -79, -79, -79,
-79, -79, -79, -79, -78, -79, -79, -79, -79, -78, -78, -79, -77, -78, -78, -78,
-78, -77, -76, -75, -77, -76, -75, -75, -75, -75, -73, -73, -73, -73, -72, -72,
-71, -70, -70, -69, -69, -67, -67, -67, -66, -65, -64, -64, -62, -62, -61, -60,
-60, -58, -58, -56, -56, -54, -53, -53, -52, -51, -50, -49, -47, -46, -46, -45,
-44, -43, -41, -40, -39, -39, -38, -36, -34, -34, -33, -31, -30, -29, -27, -27,
-25, -23, -23, -22, -20, -19, -18, -15, -13, -11, -10, -7, -6, -5, -3, -2, -1,
0, 0, };