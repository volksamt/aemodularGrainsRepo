#define DATA_LENGTH 512
#define DATA AKWF_1330

const PROGMEM int8_t DATA[DATA_LENGTH] = {103, 125, 115, 122, 116, 122, 117,
121, 117, 121, 118, 121, 118, 120, 118, 119, 119, 120, 119, 120, 119, 119, 119,
119, 119, 119, 120, 119, 120, 119, 120, 119, 120, 119, 119, 118, 119, 119, 120,
118, 119, 120, 119, 120, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119,
119, 118, 119, 120, 119, 120, 120, 118, 119, 119, 120, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119,
119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 118,
119, 118, 119, 118, 119, 118, 120, 118, 119, 119, 119, 118, 119, 119, 118, 120,
117, 121, 116, 125, 110, 127, 37, -45, -18, -35, -23, -31, -24, -30, -26, -28,
-27, -28, -27, -28, -27, -27, -28, -27, -28, -27, -29, -27, -28, -27, -28, -27,
-28, -27, -27, -27, -27, -27, -28, -28, -28, -28, -28, -27, -27, -28, -27, -28,
-27, -28, -27, -27, -27, -28, -27, -27, -27, -28, -27, -27, -28, -28, -28, -27,
-27, -28, -28, -27, -28, -28, -28, -28, -27, -28, -28, -27, -27, -28, -27, -28,
-28, -28, -28, -27, -28, -27, -28, -28, -27, -27, -27, -27, -27, -27, -28, -28,
-27, -28, -27, -28, -27, -28, -27, -28, -27, -27, -28, -28, -27, -28, -28, -28,
-27, -27, -28, -27, -28, -27, -27, -27, -27, -27, -28, -27, -28, -26, -29, -25,
-28, -25, -29, -25, -30, -25, -31, -25, -26, -111, -115, -112, -115, -112, -116,
-112, -115, -112, -115, -113, -116, -113, -115, -113, -115, -113, -114, -114,
-114, -114, -113, -114, -113, -115, -113, -114, -113, -115, -113, -114, -114,
-114, -114, -114, -114, -114, -114, -115, -114, -114, -114, -114, -114, -114,
-113, -114, -114, -114, -114, -115, -115, -114, -114, -114, -114, -115, -114,
-114, -113, -113, -114, -114, -114, -115, -114, -114, -114, -115, -113, -114,
-114, -113, -115, -114, -114, -114, -115, -114, -114, -114, -114, -115, -114,
-114, -114, -114, -114, -114, -113, -114, -115, -113, -114, -115, -114, -114,
-114, -113, -114, -114, -115, -114, -115, -113, -115, -114, -115, -113, -114,
-113, -115, -114, -115, -113, -114, -113, -114, -114, -113, -115, -111, -118,
-108, -127, -35, 19, -4, 11, 1, 8, 2, 7, 3, 6, 4, 6, 4, 6, 5, 6, 5, 5, 5, 5, 5,
5, 5, 4, 5, 5, 5, 4, 6, 5, 5, 4, 6, 5, 5, 4, 5, 5, 5, 5, 4, 5, 5, 5, 5, 5, 5, 4,
6, 5, 5, 4, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 4, 5, 5, 5, 5, 5,
5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 5, 6, 5, 5, 4, 5, 5, 4, 4, 5, 5, 6,
4, 6, 5, 5, 4, 5, 6, 5, 5, 6, 5, 5, 5, 5, 5, 4, 5, 5, 4, 5, 5, 5, 6, 5, 5, 4, 5,
5, -4, };