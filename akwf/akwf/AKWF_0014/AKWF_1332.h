#define DATA_LENGTH 512
#define DATA AKWF_1332

const PROGMEM int8_t DATA[DATA_LENGTH] = {103, 109, 100, 107, 101, 106, 101,
106, 103, 106, 102, 105, 102, 105, 102, 104, 103, 104, 104, 105, 104, 104, 104,
103, 104, 104, 104, 103, 104, 103, 104, 104, 105, 103, 105, 104, 105, 104, 103,
103, 104, 103, 104, 104, 104, 104, 104, 104, 103, 104, 104, 103, 104, 104, 103,
103, 103, 103, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104,
104, 104, 104, 104, 104, 104, 104, 104, 103, 104, 103, 104, 104, 104, 103, 104,
104, 104, 104, 104, 103, 104, 104, 103, 103, 104, 104, 104, 105, 104, 105, 104,
104, 103, 104, 104, 104, 103, 104, 104, 105, 104, 103, 103, 103, 105, 103, 104,
104, 104, 102, 105, 101, 108, 83, 49, 52, 50, 51, 49, 51, 50, 51, 51, 51, 50,
50, 50, 50, 51, 50, 51, 50, 51, 51, 51, 50, 50, 50, 50, 50, 51, 50, 50, 50, 51,
51, 50, 50, 51, 51, 51, 51, 51, 50, 51, 50, 51, 51, 51, 50, 50, 51, 50, 50, 50,
51, 50, 50, 50, 51, 50, 50, 51, 51, 50, 50, 50, 50, 51, 51, 51, 51, 50, 50, 50,
51, 51, 50, 50, 51, 50, 50, 50, 50, 50, 50, 51, 51, 50, 51, 51, 51, 51, 51, 49,
50, 51, 51, 50, 50, 50, 50, 50, 51, 51, 50, 50, 50, 50, 51, 50, 50, 51, 50, 51,
51, 51, 50, 51, 50, 52, 50, 51, 49, 51, 49, 52, 49, 51, 50, 52, 48, 53, 46, -7,
-5, -3, -6, -3, -6, -4, -5, -3, -5, -4, -5, -3, -5, -4, -4, -3, -4, -4, -5, -4,
-5, -4, -5, -5, -5, -5, -4, -5, -4, -5, -4, -5, -4, -5, -4, -5, -4, -5, -4, -5,
-4, -5, -5, -4, -5, -4, -5, -4, -5, -4, -5, -4, -5, -5, -5, -5, -5, -5, -5, -4,
-5, -4, -5, -4, -5, -5, -5, -4, -4, -5, -4, -5, -4, -4, -4, -5, -5, -5, -4, -5,
-5, -4, -4, -4, -4, -4, -5, -4, -4, -4, -5, -4, -5, -4, -5, -4, -4, -4, -5, -4,
-5, -6, -5, -5, -4, -5, -4, -4, -4, -4, -5, -5, -4, -4, -4, -4, -5, -5, -5, -4,
-5, -3, -6, 0, -31, -61, -57, -60, -58, -60, -58, -59, -58, -59, -59, -60, -59,
-58, -58, -59, -59, -59, -59, -59, -59, -59, -59, -58, -59, -59, -59, -59, -59,
-59, -58, -59, -58, -59, -58, -59, -59, -59, -59, -59, -58, -59, -59, -59, -59,
-59, -59, -58, -58, -59, -59, -59, -58, -59, -59, -59, -59, -58, -59, -58, -59,
-59, -59, -59, -59, -59, -59, -59, -58, -58, -59, -59, -59, -59, -58, -59, -59,
-58, -59, -59, -60, -59, -59, -59, -60, -59, -58, -59, -59, -59, -59, -59, -59,
-59, -59, -59, -59, -59, -59, -58, -58, -59, -59, -59, -59, -59, -58, -59, -58,
-59, -59, -59, -59, -58, -59, -59, -58, -59, -58, -59, -58, -60, -57, -60, -58,
-60, -58, -61, -57, -62, -49, };