#define DATA_LENGTH 512
#define DATA AKWF_1347

const PROGMEM int8_t DATA[DATA_LENGTH] = {49, -20, 60, 98, 109, 122, 115, 119,
109, 109, 97, 95, 83, 82, 70, 68, 58, 54, 46, 43, 35, 30, 24, 20, 14, 9, 4, 0,
-4, -9, -12, -17, -20, -24, -27, -31, -33, -37, -39, -43, -45, -49, -50, -54,
-55, -58, -60, -63, -65, -67, -69, -70, -72, -73, -76, -77, -79, -81, -82, -84,
-86, -86, -88, -89, -91, -91, -93, -94, -95, -96, -96, -98, -99, -100, -101,
-101, -102, -103, -104, -105, -105, -106, -106, -108, -107, -109, -109, -110,
-110, -111, -111, -112, -112, -113, -113, -114, -114, -114, -114, -115, -115,
-115, -116, -116, -116, -116, -117, -117, -116, -117, -118, -117, -118, -118,
-118, -119, -118, -119, -119, -119, -119, -119, -118, -119, -119, -119, -120,
-118, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -118, -119, -118, -118, -118, -118, -119, -118, -118,
-118, -117, -118, -116, -117, -117, -116, -117, -117, -116, -117, -116, -116,
-115, -115, -115, -115, -115, -115, -114, -114, -114, -114, -114, -114, -114,
-113, -113, -113, -113, -113, -112, -112, -111, -111, -111, -111, -110, -110,
-110, -109, -109, -110, -109, -108, -109, -108, -108, -109, -107, -108, -107,
-107, -107, -106, -107, -107, -106, -105, -105, -105, -106, -105, -103, -104,
-104, -103, -103, -103, -102, -102, -103, -101, -101, -102, -100, -100, -99,
-100, -100, -99, -98, -99, -98, -99, -98, -98, -98, -97, -97, -96, -97, -95,
-96, -95, -95, -95, -94, -95, -94, -94, -94, -94, -93, -93, -92, -92, -92, -92,
-92, -91, -90, -90, -89, -90, -90, -89, -89, -88, -89, -88, -87, -88, -86, -86,
-87, -86, -85, -85, -85, -85, -85, -84, -83, -83, -83, -82, -82, -83, -82, -81,
-81, -82, -81, -81, -80, -80, -80, -80, -79, -79, -79, -78, -77, -77, -78, -77,
-77, -77, -76, -76, -75, -76, -75, -75, -75, -74, -74, -73, -74, -73, -73, -73,
-73, -72, -72, -71, -71, -71, -70, -70, -70, -69, -69, -69, -68, -69, -68, -68,
-68, -68, -67, -66, -67, -66, -65, -65, -65, -65, -64, -64, -64, -64, -63, -63,
-63, -62, -62, -62, -62, -62, -61, -61, -61, -61, -60, -60, -59, -60, -59, -60,
-58, -59, -58, -58, -57, -57, -57, -56, -56, -56, -56, -55, -55, -55, -55, -55,
-54, -53, -54, -54, -54, -53, -53, -52, -52, -51, -52, -50, -51, -50, -51, -50,
-50, -49, -49, -48, -49, -49, -48, -48, -48, -48, -48, -47, -47, -47, -47, -46,
-46, -45, -45, -45, -44, -45, -44, -43, -43, -43, -43, -43, -43, -42, -42, -42,
-41, -41, -41, -41, -41, -41, -40, -40, -40, -39, -39, -38, -38, -38, -38, -38,
-37, -37, -37, -37, -37, -36, -36, -35, -36, -35, -35, -35, -35, -34, -34, -34,
-34, -33, -33, -33, -32, -32, -33, -32, -32, -32, -31, -31, -31, -30, -30, -30,
-30, -30, -29, -30, -29, -28, -28, -28, -28, -27, -27, -27, -28, -26, -27, -26,
-27, -25, -26, -25, -25, -24, -25, -23, -26, -21, };