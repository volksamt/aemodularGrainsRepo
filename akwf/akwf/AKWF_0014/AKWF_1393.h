#define DATA_LENGTH 512
#define DATA AKWF_1393

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 3, 5, 5, 7, 8, 9, 9, 9, 10,
12, 13, 14, 16, 16, 16, 18, 19, 19, 20, 20, 22, 21, 22, 23, 22, 23, 23, 24, 25,
27, 27, 29, 28, 30, 31, 31, 31, 33, 33, 33, 33, 34, 35, 36, 37, 38, 38, 40, 40,
40, 40, 42, 42, 42, 43, 44, 46, 46, 46, 47, 48, 49, 49, 50, 50, 51, 51, 52, 52,
53, 54, 54, 55, 56, 57, 57, 58, 58, 59, 59, 59, 59, 60, 61, 62, 63, 63, 64, 65,
65, 66, 65, 65, 66, 66, 66, 67, 68, 68, 68, 70, 69, 70, 71, 71, 71, 71, 72, 72,
72, 71, 71, 72, 72, 73, 74, 74, 74, 75, 74, 75, 76, 75, 76, 75, 76, 76, 76, 76,
77, 77, 77, 77, 77, 76, 77, 78, 77, 77, 78, 78, 77, 78, 78, 78, 79, 79, 79, 78,
79, 78, 78, 79, 79, 79, 79, 78, 79, 79, 79, 79, 79, 79, 79, 79, 79, 78, 78, 79,
79, 78, 78, 77, 77, 77, 78, 76, 77, 76, 76, 76, 76, 75, 74, 74, 75, 74, 74, 74,
73, 73, 72, 72, 72, 71, 71, 70, 70, 70, 69, 69, 68, 67, 68, 68, 67, 67, 66, 65,
65, 65, 64, 64, 63, 63, 62, 62, 62, 61, 61, 60, 60, 59, 59, 58, 58, 57, 58, 57,
57, 56, 57, 53, 42, 34, 28, 21, 16, 11, 7, 5, 1, -1, -3, -4, -4, -5, -5, -5, -5,
-5, -4, -2, -1, 1, 2, 5, 7, 10, 11, 13, 16, 18, 20, 21, 24, 27, 29, 31, 33, 34,
35, 37, 39, 40, 42, 43, 43, 43, 44, 44, 44, 45, 44, 44, 43, 43, 40, 40, 38, 36,
34, 33, 31, 29, 26, 25, 23, 20, 18, 15, 13, 10, 8, 5, 3, 0, -3, -6, -9, -12,
-15, -18, -20, -24, -26, -29, -32, -35, -38, -41, -45, -48, -50, -53, -57, -59,
-63, -65, -68, -71, -73, -76, -78, -81, -85, -86, -88, -91, -93, -96, -98, -101,
-102, -105, -106, -108, -108, -109, -110, -112, -112, -113, -114, -115, -114,
-115, -116, -117, -118, -118, -117, -118, -118, -119, -119, -120, -118, -120,
-119, -118, -120, -119, -119, -119, -119, -120, -119, -118, -119, -120, -118,
-118, -119, -118, -118, -117, -117, -117, -116, -115, -115, -115, -113, -114,
-113, -113, -112, -112, -111, -111, -110, -109, -109, -109, -108, -107, -106,
-106, -105, -103, -101, -100, -100, -98, -97, -96, -95, -94, -93, -93, -92, -90,
-88, -87, -85, -84, -83, -81, -80, -77, -76, -75, -73, -72, -70, -70, -68, -67,
-67, -66, -64, -64, -63, -62, -62, -61, -60, -59, -58, -58, -56, -55, -53, -51,
-50, -50, -48, -47, -46, -47, -45, -44, -43, -42, -41, -40, -38, -36, -37, -34,
-33, -33, -32, -31, -30, -29, -30, -28, -26, -24, -22, -21, -21, -20, -19, -17,
-17, -16, -16, -15, -14, -14, -13, -13, -12, -12, -11, -10, -7, -7, -5, -5, -3,
-3, -1, -2, 0, 0, };