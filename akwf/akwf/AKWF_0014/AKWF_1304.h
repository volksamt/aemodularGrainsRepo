#define DATA_LENGTH 512
#define DATA AKWF_1304

const PROGMEM int8_t DATA[DATA_LENGTH] = {-14, -21, 80, 59, 68, 65, 66, 66, 65,
67, 64, 67, 63, 68, 63, 70, 61, 72, 58, 80, 25, 33, 83, 62, 73, 65, 71, 66, 69,
65, 67, 65, 64, 64, 63, 62, 62, 63, 61, 61, 61, 62, 60, 61, 63, 63, 62, 64, 63,
64, 64, 65, 65, 66, 66, 66, 66, 66, 66, 66, 67, 66, 66, 66, 66, 65, 66, 66, 66,
65, 66, 66, 66, 65, 66, 66, 66, 66, 65, 66, 65, 65, 65, 66, 66, 65, 65, 64, 64,
65, 65, 65, 65, 65, 64, 64, 64, 64, 64, 64, 64, 64, 64, 64, 64, 64, 65, 64, 64,
64, 63, 64, 63, 63, 63, 64, 64, 63, 64, 63, 63, 63, 64, 64, 64, 63, 63, 64, 63,
62, 63, 63, 63, 63, 63, 63, 63, 62, 62, 63, 63, 62, 62, 62, 62, 63, 62, 61, 63,
62, 62, 63, 62, 61, 61, 62, 62, 62, 61, 61, 62, 61, 61, 61, 61, 60, 60, 59, 59,
58, 58, 58, 57, 55, 55, 54, 53, 54, 52, 52, 51, 52, 49, 49, 46, 43, 39, 34, 22,
17, 21, -12, -18, -15, -17, -16, -18, -17, -18, -17, -18, -19, -18, -19, -20,
-19, -20, -19, -20, -21, -21, -21, -22, -22, -22, -23, -22, -23, -23, -24, -23,
-24, -24, -25, -25, -25, -24, -26, -25, -26, -24, -25, -23, -23, -18, -18, -8,
-4, 14, 9, 16, 58, 53, 56, 54, 55, 55, 55, 55, 55, 55, 55, 55, 55, 56, 54, 55,
55, 56, 54, 55, 56, 55, 55, 56, 56, 55, 56, 56, 56, 56, 57, 55, 57, 56, 56, 56,
56, 56, 56, 56, 57, 57, 56, 56, 56, 57, 57, 56, 57, 56, 57, 57, 57, 58, 57, 58,
59, 57, 57, 57, 57, 57, 56, 57, 56, 56, 56, 56, 57, 57, 57, 55, 56, 56, 56, 56,
56, 56, 56, 56, 55, 56, 56, 56, 55, 55, 55, 55, 55, 55, 55, 55, 56, 56, 55, 55,
55, 55, 56, 55, 54, 55, 55, 55, 54, 54, 54, 54, 54, 54, 54, 54, 54, 54, 54, 54,
54, 53, 53, 53, 54, 53, 53, 53, 53, 53, 53, 53, 53, 53, 53, 53, 53, 52, 52, 52,
53, 52, 52, 51, 51, 50, 51, 50, 51, 57, 46, 41, 45, 45, 46, 47, 46, 46, 45, 45,
44, 42, 41, 41, 40, 39, 37, 36, 33, 33, 30, 29, 26, 26, 22, 21, 17, 16, 12, 9,
4, -43, -49, -51, -57, -61, -69, -73, -81, -86, -90, -92, -101, -96, -98, -94,
-95, -92, -93, -90, -90, -88, -88, -86, -86, -84, -84, -82, -80, -111, -78, -70,
-75, -72, -76, -72, -77, -74, -76, -75, -77, -75, -77, -76, -77, -77, -78, -78,
-79, -78, -79, -79, -79, -80, -79, -80, -80, -81, -81, -81, -81, -81, -82, -82,
-83, -83, -83, -83, -84, -85, -84, -84, -85, -86, -85, -86, -87, -86, -87, -87,
-87, -87, -87, -87, -87, -87, -86, -85, -82, -79, -74, -67, -55, -39, -14, };