#define DATA_LENGTH 512
#define DATA AKWF_1377

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 1, 1, 0, 0, 1, 1, 1, 1, 1, 2,
1, 3, 1, 7, 14, 14, 14, 14, 15, 15, 15, 15, 15, 15, 15, 15, 15, 16, 16, 16, 15,
16, 15, 16, 16, 16, 17, 16, 17, 16, 15, 16, 15, 16, 16, 15, 16, 16, 16, 16, 17,
17, 16, 16, 16, 16, 16, 17, 17, 17, 17, 18, 17, 18, 18, 18, 17, 18, 17, 19, 18,
18, 17, 19, 18, 18, 18, 18, 19, 19, 18, 19, 19, 19, 20, 19, 19, 20, 19, 20, 20,
20, 20, 20, 21, 20, 21, 20, 20, 21, 20, 20, 20, 21, 21, 22, 21, 22, 21, 21, 22,
22, 21, 22, 22, 21, 22, 21, 22, 22, 23, 21, 23, 23, 23, 22, 23, 22, 23, 23, 23,
23, 23, 23, 23, 24, 23, 23, 23, 23, 23, 23, 23, 23, 23, 24, 24, 24, 23, 24, 23,
24, 25, 25, 24, 25, 24, 24, 25, 24, 26, 25, 26, 24, 26, 25, 26, 25, 26, 25, 26,
26, 26, 25, 25, 26, 25, 27, 25, 27, 24, 28, 23, 28, 23, 30, 24, 29, 23, 31, 22,
30, 23, 32, 100, 17, 59, 91, 94, 106, 99, 106, 97, 100, 91, 93, 84, 85, 77, 77,
69, 69, 62, 61, 56, 54, 50, 47, 44, 42, 40, 36, 35, 31, 30, 26, 25, 22, 21, 18,
17, 15, 14, 11, 10, 9, 7, 5, 4, 3, 1, 0, -1, -2, -4, -4, -4, -5, -8, -8, -8, -9,
-10, -11, -12, -14, -14, -15, -16, -16, -17, -17, -19, -18, -20, -19, -20, -21,
-21, -21, -23, -23, -23, -24, -24, -24, -25, -25, -25, -27, -26, -26, -27, -27,
-27, -27, -28, -28, -28, -29, -29, -29, -30, -30, -30, -30, -31, -31, -30, -31,
-31, -31, -31, -32, -31, -32, -32, -32, -32, -32, -32, -32, -32, -31, -32, -32,
-32, -32, -33, -33, -33, -33, -33, -33, -32, -32, -32, -33, -32, -33, -32, -32,
-32, -32, -33, -33, -33, -33, -33, -32, -32, -32, -32, -32, -32, -32, -33, -32,
-33, -32, -32, -31, -32, -33, -32, -31, -32, -31, -32, -31, -31, -31, -32, -31,
-31, -31, -30, -30, -31, -30, -31, -31, -30, -30, -31, -30, -29, -30, -31, -30,
-29, -30, -29, -29, -29, -28, -28, -29, -28, -28, -29, -28, -28, -28, -28, -28,
-28, -28, -27, -28, -28, -27, -27, -27, -27, -26, -27, -27, -26, -26, -26, -26,
-27, -26, -26, -25, -26, -26, -26, -25, -25, -25, -25, -25, -25, -23, -25, -24,
-24, -24, -24, -23, -23, -23, -22, -23, -23, -23, -22, -22, -23, -23, -22, -22,
-22, -22, -21, -21, -21, -22, -22, -22, -21, -21, -22, -21, -21, -22, -20, -21,
-20, -20, -20, -20, -20, -21, -20, -20, -20, -20, -20, -19, -19, -19, -11, -2,
-3, -4, -4, -3, -3, -4, -3, -3, -2, -3, -2, -2, -3, -2, -2, -3, -2, -2, -2, -1,
-2, -1, -2, -2, -1, 0, -1, 0, 0, 0, -1, -1, -1, };