#define DATA_LENGTH 512
#define DATA AKWF_1336

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 2, 5, 9, 14, 18, 22, 27, 31, 37,
44, 49, 57, 62, 67, 69, 71, 72, 74, 76, 77, 76, 76, 74, 74, 74, 73, 71, 70, 68,
68, 66, 66, 69, 72, 76, 78, 83, 83, 80, 77, 75, 73, 71, 69, 66, 64, 61, 59, 57,
58, 59, 62, 65, 68, 69, 59, 52, 43, 35, 26, 22, 25, 26, 29, 31, 33, 34, 31, 29,
27, 25, 23, 21, 19, 16, 14, 13, 9, 10, 15, 18, 22, 25, 30, 33, 34, 37, 39, 41,
42, 46, 50, 53, 58, 62, 66, 63, 55, 50, 43, 37, 30, 30, 34, 36, 38, 40, 44, 44,
44, 46, 46, 46, 46, 47, 48, 49, 49, 50, 51, 49, 49, 49, 48, 47, 47, 48, 51, 53,
56, 57, 60, 62, 63, 64, 67, 68, 70, 68, 67, 65, 64, 62, 61, 61, 61, 61, 61, 61,
62, 63, 63, 65, 64, 66, 67, 67, 68, 69, 70, 72, 72, 71, 69, 67, 65, 62, 60, 61,
64, 65, 67, 68, 69, 75, 79, 86, 91, 96, 101, 101, 104, 104, 105, 106, 108, 110,
111, 114, 115, 117, 120, 120, 119, 119, 119, 119, 118, 116, 114, 112, 110, 109,
106, 107, 107, 107, 106, 106, 106, 99, 94, 89, 83, 73, 66, 59, 52, 45, 37, 32,
32, 32, 34, 35, 34, 36, 35, 35, 34, 33, 32, 30, 30, 28, 27, 26, 24, 23, 22, 21,
20, 19, 18, 17, 15, 12, 9, 7, 4, 2, -2, -5, -10, -13, -17, -20, -23, -26, -27,
-30, -32, -35, -40, -45, -50, -55, -60, -64, -64, -65, -67, -69, -70, -71, -72,
-73, -73, -73, -74, -74, -73, -71, -69, -68, -67, -65, -61, -57, -53, -50, -47,
-43, -39, -35, -32, -28, -24, -20, -15, -11, -8, -4, 1, 2, 0, 0, -1, -3, -3, -3,
0, 2, 4, 6, 10, 9, 4, 1, -4, -9, -13, -16, -19, -22, -25, -28, -32, -34, -35,
-36, -38, -39, -40, -44, -49, -53, -60, -65, -70, -73, -74, -77, -80, -82, -84,
-85, -88, -91, -93, -95, -97, -96, -90, -86, -82, -77, -72, -71, -70, -69, -68,
-67, -65, -63, -63, -61, -60, -58, -58, -57, -57, -57, -56, -57, -57, -57, -57,
-57, -58, -58, -57, -54, -53, -50, -48, -47, -47, -48, -49, -49, -50, -51, -52,
-55, -56, -58, -61, -62, -62, -61, -61, -60, -59, -59, -59, -58, -60, -60, -60,
-60, -58, -56, -53, -50, -48, -45, -44, -42, -42, -40, -38, -38, -38, -40, -41,
-43, -44, -46, -48, -50, -53, -54, -57, -59, -59, -58, -57, -57, -57, -57, -60,
-64, -69, -72, -76, -80, -84, -88, -94, -97, -103, -107, -106, -107, -106, -106,
-106, -106, -105, -103, -102, -101, -100, -99, -99, -98, -98, -98, -96, -96,
-92, -90, -88, -84, -81, -80, -80, -81, -80, -81, -81, -81, -80, -80, -79, -79,
-79, -77, -73, -67, -63, -58, -54, -50, -50, -47, -47, -46, -45, -43, -36, -30,
-24, -18, -13, -8, -7, -5, -3, -1, };