#define DATA_LENGTH 512
#define DATA AKWF_1381

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 12, 18, 23, 29, 36, 40, 44, 50, 53,
57, 60, 64, 66, 68, 71, 71, 73, 73, 74, 74, 72, 72, 71, 69, 67, 65, 64, 60, 58,
54, 51, 48, 45, 40, 37, 32, 29, 25, 20, 18, 13, 9, 5, 1, -2, -7, -10, -14, -16,
-20, -22, -25, -28, -31, -32, -34, -37, -37, -38, -40, -40, -42, -42, -42, -41,
-42, -41, -40, -40, -39, -38, -36, -35, -33, -32, -29, -28, -26, -24, -21, -20,
-17, -15, -13, -10, -8, -6, -4, -1, 0, 4, 5, 7, 10, 11, 13, 14, 16, 18, 19, 19,
21, 22, 22, 22, 24, 24, 24, 24, 24, 23, 23, 23, 23, 22, 21, 21, 20, 19, 19, 17,
16, 16, 13, 12, 11, 10, 8, 7, 6, 5, 3, 2, 1, 0, -2, -4, -4, -4, -6, -7, -8, -9,
-9, -10, -11, -12, -11, -13, -13, -13, -13, -14, -14, -14, -14, -13, -13, -14,
-13, -12, -12, -11, -11, -10, -10, -9, -9, -8, -7, -7, -6, -5, -4, -4, -3, -2,
-1, 0, 1, 1, 2, 3, 3, 3, 4, 5, 5, 6, 6, 7, 7, 7, 8, 8, 8, 8, 9, 7, 8, 8, 8, 8,
7, 7, 7, 7, 7, 7, 6, 5, 5, 4, 4, 4, 4, 3, 3, 3, 2, 2, 0, 1, 1, 0, -1, -1, -2,
-2, -2, -2, -3, -3, -3, -4, -4, -5, -4, -4, -4, -4, -4, -5, -5, -4, -5, -5, -4,
-4, -4, -4, -4, -4, -3, -3, -3, -3, -2, -3, -3, -3, -2, -2, -2, -1, -1, -1, 0,
-1, -1, 0, 0, 1, 0, 1, 1, 1, 2, 2, 1, 2, 2, 3, 2, 2, 2, 2, 3, 3, 3, 2, 2, 3, 3,
2, 2, 3, 2, 2, 2, 2, 2, 2, 2, 1, 2, 1, 1, 1, 1, 0, 0, 0, 1, 0, 0, 0, -1, -1, -1,
0, -1, -1, -2, -1, -1, -1, -1, -1, -2, -2, -2, -1, -2, -1, -2, -1, -2, -1, -1,
-1, -1, -1, -2, -1, -1, -1, -1, -1, -1, -1, -1, 0, -1, -1, 1, 0, -1, 0, 1, 0, 1,
0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 2, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1, 1,
0, 1, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, -1, 0, 1, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0,
-1, -1, 0, -1, 0, -1, 0, 0, 0, 0, 0, -1, -1, 0, -1, -1, 0, -1, 0, 0, 0, 0, 0, 0,
0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 1, 0, 0, 0, 0, 1, -1, 0, 0, 0,
0, 0, 0, 1, 0, 1, -1, 1, 0, 1, -1, 1, 0, 1, -1, 0, 0, 0, 0, -2, 2, -3, 4, -6,
14, -75, -128, -105, -115, -100, -102, -90, -89, -80, -77, -68, -62, -55, -48,
-41, -34, -27, -20, -14, -5, -1, };