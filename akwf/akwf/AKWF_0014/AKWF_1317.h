#define DATA_LENGTH 512
#define DATA AKWF_1317

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 113, 119, 112, 117, 112,
114, 110, 112, 108, 110, 107, 108, 106, 105, 104, 104, 102, 102, 100, 99, 98,
98, 97, 96, 94, 93, 93, 92, 92, 90, 89, 88, 87, 87, 85, 84, 84, 82, 82, 81, 80,
78, 78, 77, 76, 76, 74, 73, 73, 71, 71, 69, 68, 67, 66, 65, 65, 64, 63, 62, 61,
61, 60, 58, 57, 56, 55, 55, 54, 53, 52, 51, 49, 49, 48, 47, 46, 45, 44, 43, 42,
42, 40, 40, 38, 38, 37, 36, 35, 34, 33, 32, 31, 30, 29, 29, 27, 26, 26, 25, 24,
23, 22, 20, 21, 19, 18, 17, 16, 16, 14, 14, 13, 12, 10, 10, 9, 8, 7, 6, 5, 5, 4,
3, 1, 1, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0,
1, 0, 2, 1, 1, 1, 2, 2, 1, 2, 2, 3, 3, 3, 3, 4, 3, 4, 2, 0, 0, 0, 1, 0, 1, 1, 0,
0, 0, 1, 1, 1, 0, 1, 0, 0, 1, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, -1, 0, 1, -1, 0, 0, 0, -1, 0, -1, 1, -7, -12, -10, -12, -11, -11, -11,
-12, -13, -11, -13, -12, -12, -13, -13, -13, -14, -13, -13, -13, -13, -14, -14,
-14, -14, -15, -15, -15, -15, -15, -15, -15, -16, -16, -15, -17, -17, -17, -17,
-17, -16, -17, -17, -17, -17, -18, -18, -18, -18, -18, -18, -18, -18, -19, -19,
-19, -18, -19, -19, -20, -20, -20, -20, -20, -21, -20, -22, -21, -21, -21, -21,
-21, -21, -21, -21, -22, -25, -24, -24, -25, -25, -24, -26, -25, -26, -26, -26,
-26, -25, -47, -52, -50, -51, -50, -53, -52, -53, -53, -53, -52, -54, -54, -54,
-54, -56, -55, -56, -56, -56, -56, -57, -57, -57, -59, -60, -61, -61, -62, -62,
-62, -63, -63, -63, -63, -64, -63, -64, -65, -65, -65, -66, -66, -67, -67, -67,
-67, -68, -67, -67, -69, -69, -69, -69, -70, -70, -71, -71, -71, -72, -72, -72,
-72, -73, -73, -74, -74, -75, -75, -74, -75, -75, -72, -73, -74, -74, -74, -75,
-75, -75, -76, -76, -75, -76, -76, -77, -78, -77, -78, -78, -79, -78, -78, -79,
-79, -80, -80, -81, -81, -81, -82, -82, -82, -83, -83, -84, -83, -84, -84, -84,
-85, -85, -85, -86, -87, -86, -87, -87, -87, -88, -88, -88, -89, -88, -89, -89,
-90, -91, -90, -91, -91, -92, -92, -92, -92, -93, -92, -93, -94, -95, -94, -95,
-95, -95, -95, -95, -97, -96, -98, -97, -98, -98, -98, -98, -100, -99, -100,
-99, -101, -99, -102, -99, -104, -97, -52, -53, -54, -54, -54, -53, -54, -54,
-55, -54, -55, -54, -55, -53, -50, -51, -51, -52, -51, -53, -51, -52, -52, -52,
-53, -51, -57, -11, 4, -3, 2, -2, 2, -1, 1, -1, 1, -1, 0, 0, 0, };