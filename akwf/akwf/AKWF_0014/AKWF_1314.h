#define DATA_LENGTH 512
#define DATA AKWF_1314

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 1, 3, 4, 4, 5, 5, 7, 8, 8, 10,
11, 11, 11, 13, 13, 14, 16, 16, 17, 18, 19, 20, 22, 22, 22, 24, 24, 26, 26, 28,
29, 29, 29, 31, 32, 33, 33, 35, 36, 37, 38, 38, 39, 41, 41, 42, 43, 44, 44, 46,
47, 48, 49, 50, 51, 52, 53, 53, 55, 55, 57, 57, 59, 60, 61, 62, 63, 64, 65, 66,
67, 67, 69, 69, 70, 71, 72, 73, 73, 75, 77, 77, 78, 80, 80, 81, 81, 83, 84, 85,
85, 88, 87, 90, 89, 91, 90, 92, 93, 95, 95, 96, 97, 99, 99, 100, 102, 102, 104,
103, 106, 104, 109, 106, 111, 107, 113, 108, 116, 110, 119, 112, 121, 114, 122,
113, -106, -125, -111, -122, -111, -119, -110, -117, -107, -114, -106, -112,
-105, -108, -104, -107, -103, -105, -101, -101, -100, -100, -99, -97, -97, -96,
-95, -94, -94, -92, -91, -90, -90, -87, -87, -86, -85, -84, -84, -82, -81, -80,
-79, -78, -78, -76, -75, -74, -74, -73, -71, -71, -69, -69, -68, -67, -66, -64,
-63, -63, -61, -60, -59, -59, -58, -57, -56, -55, -54, -53, -52, -51, -50, -49,
-48, -48, -46, -46, -44, -44, -43, -41, -40, -39, -38, -38, -37, -36, -36, -34,
-32, -31, -32, -29, -28, -28, -27, -26, -24, -25, -23, -23, -21, -21, -20, -19,
-19, -17, -16, -15, -14, -13, -13, -11, -10, -10, -10, -9, -8, -7, -6, -6, -4,
-3, -2, -3, -2, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0,
0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1,
0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 1, -1, 0, 1, -1, 0, 0, 0,
-1, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1,
0, 1, 0, 0, 0, 0, 0, 0, 0, -1, -1, 1, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, -1, -1,
0, 0, 1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0,
0, 0, 0, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, -1, -1, 0, 0,
0, 0, 0, 0, -1, 0, 1, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, -1, 0, 0, 1, 1, 0, 0,
1, 1, 0, 1, 0, 0, };