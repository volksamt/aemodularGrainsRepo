#define DATA_LENGTH 512
#define DATA AKWF_1386

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 8, 11, 13, 16, 19, 20, 25, 27,
29, 32, 35, 36, 38, 41, 43, 46, 48, 51, 54, 56, 58, 60, 62, 64, 67, 69, 71, 73,
75, 77, 79, 80, 82, 83, 86, 87, 88, 89, 91, 92, 94, 95, 96, 97, 97, 99, 99, 100,
100, 100, 101, 101, 102, 102, 103, 102, 102, 102, 102, 101, 100, 101, 100, 100,
100, 99, 99, 98, 97, 96, 95, 95, 94, 94, 92, 91, 91, 89, 89, 88, 87, 86, 85, 84,
82, 81, 81, 80, 78, 77, 77, 75, 75, 73, 73, 72, 71, 71, 70, 69, 68, 67, 66, 65,
65, 65, 65, 63, 63, 63, 63, 62, 61, 60, 61, 59, 59, 59, 58, 58, 59, 58, 57, 57,
57, 57, 56, 57, 55, 56, 56, 56, 55, 55, 55, 54, 54, 53, 54, 54, 54, 54, 54, 54,
53, 54, 53, 53, 54, 53, 53, 53, 53, 53, 53, 53, 53, 53, 52, 53, 53, 53, 52, 52,
53, 53, 53, 53, 52, 53, 52, 54, 52, 55, 46, 30, 34, 31, 32, 32, 32, 34, 34, 35,
36, 37, 38, 39, 40, 41, 41, 42, 44, 44, 45, 46, 47, 48, 48, 50, 51, 52, 53, 53,
54, 56, 56, 57, 58, 59, 58, 60, 60, 60, 61, 60, 61, 60, 61, 60, 61, 59, 60, 59,
58, 41, 39, 39, 37, 39, 36, 39, 33, 46, -13, -50, -42, -52, -47, -49, -45, -46,
-41, -39, -36, -33, -29, -26, -22, -20, -16, -13, -10, -6, -3, 1, 5, 8, 12, 15,
18, 22, 25, 28, 31, 32, 35, 38, 39, 42, 42, 43, 44, 43, 43, 43, 42, 41, 41, 39,
37, 34, 32, 30, 27, 24, 21, 18, 14, 11, 7, 3, 0, -4, -8, -11, -15, -19, -23,
-26, -30, -33, -37, -40, -44, -47, -51, -53, -57, -60, -63, -66, -68, -71, -74,
-77, -80, -82, -83, -87, -88, -90, -92, -94, -97, -98, -100, -101, -103, -105,
-106, -107, -109, -110, -112, -112, -114, -113, -114, -116, -116, -116, -118,
-118, -118, -118, -119, -118, -118, -118, -118, -117, -116, -115, -115, -114,
-113, -113, -112, -110, -110, -109, -107, -108, -107, -106, -104, -103, -103,
-101, -101, -100, -99, -98, -97, -97, -96, -95, -95, -94, -93, -93, -92, -91,
-90, -90, -90, -90, -89, -87, -87, -88, -86, -86, -85, -85, -85, -85, -83, -83,
-83, -83, -83, -83, -81, -81, -81, -80, -80, -80, -80, -80, -79, -79, -78, -77,
-78, -77, -77, -77, -76, -75, -75, -75, -75, -73, -74, -73, -73, -72, -72, -71,
-70, -72, -70, -71, -68, -69, -67, -69, -66, -70, -63, -69, -61, -72, -48, 28,
24, 30, 29, 31, 29, 26, 24, 20, 18, 14, 13, 8, 5, 1, 0, -7, -8, -14, -15, -22,
-23, -30, -31, -37, -38, -44, -46, -52, -53, -59, -59, -65, -65, -68, -70, -70,
-74, -71, -78, -65, -90, -3, -18, -61, -37, -53, -41, -49, -40, -43, -35, -36,
-30, -29, -24, -22, -18, -14, -11, -7, -5, -1, };