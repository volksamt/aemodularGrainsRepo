#define DATA_LENGTH 512
#define DATA AKWF_1387

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 5, 7, 8, 9, 11, 12, 13, 15,
16, 17, 19, 20, 22, 23, 24, 26, 27, 27, 29, 31, 31, 32, 34, 34, 36, 36, 38, 38,
39, 41, 41, 43, 43, 44, 45, 46, 47, 47, 48, 49, 50, 50, 51, 52, 52, 53, 54, 54,
54, 55, 56, 56, 57, 58, 58, 58, 60, 60, 60, 61, 61, 61, 62, 62, 62, 62, 63, 64,
64, 65, 65, 65, 66, 66, 66, 67, 68, 69, 69, 70, 70, 70, 70, 70, 72, 72, 73, 73,
74, 74, 74, 75, 76, 77, 77, 77, 77, 79, 80, 81, 82, 82, 84, 85, 86, 88, 88, 90,
91, 93, 95, 95, 97, 98, 100, 101, 104, 105, 105, 108, 109, 110, 110, 112, 113,
115, 115, 116, 117, 118, 118, 119, 119, 119, 119, 119, 119, 118, 117, 117, 116,
115, 114, 112, 112, 110, 108, 105, 103, 102, 99, 97, 94, 92, 90, 87, 84, 82, 79,
77, 73, 71, 69, 65, 63, 60, 58, 55, 53, 51, 48, 46, 45, 44, 42, 41, 39, 39, 38,
37, 37, 36, 35, 35, 35, 35, 34, 35, 35, 36, 36, 35, 35, 36, 37, 36, 37, 36, 38,
37, 38, 37, 37, 38, 37, 37, 37, 36, 35, 34, 33, 32, 31, 28, 26, 25, 23, 21, 18,
15, 13, 11, 8, 5, 2, -1, -5, -9, -11, -15, -18, -22, -24, -27, -31, -34, -37,
-39, -42, -46, -48, -50, -52, -54, -56, -58, -60, -60, -62, -63, -65, -65, -67,
-67, -67, -68, -69, -68, -69, -70, -69, -69, -69, -69, -68, -69, -68, -68, -67,
-67, -67, -65, -65, -64, -64, -63, -63, -63, -62, -62, -62, -61, -61, -61, -61,
-61, -60, -60, -61, -61, -60, -61, -61, -61, -60, -61, -62, -63, -63, -64, -64,
-64, -65, -65, -66, -67, -67, -67, -69, -69, -69, -71, -72, -72, -72, -73, -74,
-75, -75, -76, -77, -78, -78, -79, -79, -80, -80, -81, -81, -82, -83, -83, -83,
-84, -83, -84, -85, -85, -86, -87, -87, -87, -89, -88, -90, -89, -90, -91, -91,
-92, -92, -93, -93, -93, -95, -95, -94, -95, -96, -96, -96, -96, -95, -95, -96,
-96, -96, -95, -94, -93, -92, -93, -91, -90, -90, -88, -87, -85, -85, -82, -82,
-80, -79, -77, -75, -73, -71, -70, -68, -66, -64, -62, -60, -57, -55, -55, -52,
-50, -48, -47, -45, -42, -40, -39, -37, -35, -34, -33, -31, -29, -27, -27, -25,
-25, -23, -22, -22, -20, -19, -19, -18, -17, -17, -16, -15, -16, -15, -16, -15,
-15, -14, -14, -14, -14, -15, -14, -14, -15, -15, -15, -16, -17, -17, -17, -18,
-18, -19, -19, -20, -21, -21, -21, -22, -22, -24, -23, -23, -24, -25, -25, -26,
-27, -26, -26, -27, -27, -27, -28, -27, -29, -29, -28, -29, -28, -29, -28, -28,
-28, -28, -28, -28, -26, -27, -26, -26, -24, -25, -24, -23, -22, -22, -20, -21,
-19, -18, -17, -16, -14, -13, -13, -11, -10, -10, -8, -6, -5, -4, -2, 0, };