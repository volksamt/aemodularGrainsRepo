#define DATA_LENGTH 512
#define DATA AKWF_1318

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 6, 10, 13, 15, 19, 22, 25, 28,
31, 34, 37, 40, 44, 46, 49, 52, 54, 58, 60, 63, 66, 70, 72, 74, 77, 79, 83, 86,
88, 91, 94, 96, 98, 101, 103, 105, 106, 109, 110, 113, 114, 115, 116, 117, 118,
118, 118, 118, 119, 119, 118, 119, 118, 117, 116, 114, 114, 112, 111, 109, 107,
106, 104, 102, 99, 98, 96, 94, 91, 90, 86, 85, 83, 79, 77, 74, 72, 70, 68, 64,
63, 60, 57, 54, 51, 49, 47, 45, 42, 40, 38, 36, 32, 30, 28, 26, 23, 21, 19, 16,
14, 12, 9, 7, 5, 3, 1, -2, -3, -5, -8, -9, -11, -14, -15, -18, -20, -21, -23,
-26, -28, -29, -32, -34, -35, -37, -40, -41, -43, -44, -47, -48, -51, -51, -53,
-55, -56, -58, -60, -61, -63, -64, -67, -68, -69, -70, -71, -72, -74, -75, -75,
-75, -77, -77, -77, -76, -77, -77, -77, -77, -76, -76, -75, -74, -74, -73, -72,
-72, -70, -69, -68, -66, -65, -64, -62, -60, -59, -57, -57, -55, -53, -51, -51,
-49, -46, -45, -43, -42, -40, -40, -38, -37, -34, -34, -33, -31, -31, -29, -28,
-28, -26, -26, -26, -25, -24, -23, -22, -22, -20, -20, -20, -20, -18, -18, -17,
-17, -16, -16, -11, 6, 15, 22, 27, 30, 34, 34, 34, 33, 31, 29, 26, 23, 21, 18,
15, 11, 9, 5, 4, 1, -3, -5, -7, -10, -11, -14, -16, -18, -19, -21, -22, -23,
-23, -24, -26, -27, -28, -28, -29, -30, -30, -32, -33, -33, -32, -34, -33, -34,
-34, -33, -33, -32, -31, -30, -29, -29, -28, -27, -25, -23, -22, -20, -18, -17,
-15, -13, -11, -8, -7, -5, -3, -1, 1, 3, 5, 6, 8, 10, 11, 13, 14, 15, 16, 18,
20, 21, 21, 22, 23, 24, 25, 26, 26, 27, 27, 27, 27, 26, 26, 26, 25, 24, 23, 21,
20, 18, 17, 16, 13, 11, 9, 8, 6, 3, 2, -1, -2, -4, -6, -8, -9, -10, -13, -14,
-16, -18, -19, -20, -22, -24, -25, -26, -28, -29, -31, -32, -34, -35, -36, -37,
-39, -39, -42, -43, -44, -45, -45, -46, -46, -47, -48, -48, -49, -49, -48, -48,
-47, -48, -48, -48, -48, -47, -46, -47, -46, -47, -47, -46, -46, -47, -46, -46,
-46, -45, -45, -44, -44, -43, -42, -42, -41, -41, -39, -38, -38, -37, -36, -35,
-34, -33, -32, -31, -29, -28, -28, -27, -26, -25, -24, -24, -24, -22, -21, -20,
-20, -19, -19, -17, -17, -17, -15, -14, -13, -13, -13, -12, -11, -10, -9, -9,
-8, -8, -7, -7, -7, -8, -8, -9, -11, -12, -14, -15, -17, -20, -22, -24, -26,
-29, -30, -33, -35, -36, -39, -40, -42, -44, -45, -48, -48, -50, -51, -51, -52,
-53, -53, -53, -53, -54, -54, -54, -54, -54, -54, -54, -54, -53, -53, -51, -50,
-50, -48, -48, -47, -45, -44, -42, -40, -39, -36, -34, -32, -29, -26, -23, -19,
-17, -13, -9, -5, -1, };