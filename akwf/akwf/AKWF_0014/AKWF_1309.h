#define DATA_LENGTH 512
#define DATA AKWF_1309

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 7, 10, 11, 14, 16, 17, 19,
21, 23, 25, 27, 28, 29, 32, 33, 35, 36, 37, 39, 40, 41, 43, 43, 44, 45, 46, 47,
48, 49, 49, 50, 51, 51, 52, 52, 53, 53, 54, 54, 54, 55, 54, 55, 55, 54, 55, 55,
55, 54, 54, 54, 54, 53, 54, 52, 52, 52, 51, 50, 51, 50, 49, 48, 48, 47, 46, 45,
44, 44, 43, 43, 42, 40, 40, 39, 39, 38, 37, 37, 36, 35, 34, 34, 33, 33, 33, 32,
31, 31, 30, 30, 30, 29, 29, 28, 28, 28, 29, 28, 28, 28, 28, 29, 29, 29, 29, 30,
29, 31, 31, 32, 34, 31, 27, 27, 27, 27, 28, 28, 27, 27, 27, 26, 25, 25, 24, 22,
23, 22, 21, 20, 20, 19, 18, 16, 16, 14, 13, 12, 11, 9, 8, 6, 5, 4, 2, -1, -2,
-3, -6, -8, -10, -12, -13, -17, -19, -20, -23, -24, -27, -29, -32, -35, -37,
-39, -42, -44, -46, -49, -52, -55, -57, -59, -62, -66, -42, -38, -56, -56, -58,
-57, -57, -58, -58, -58, -58, -58, -59, -59, -60, -61, -60, -60, -61, -62, -61,
-63, -63, -63, -63, -64, -63, -63, -64, -63, -64, -64, -64, -64, -63, -64, -63,
-63, -62, -62, -62, -62, -61, -60, -59, -57, -57, -56, -56, -55, -53, -51, -49,
-49, -47, -46, -44, -42, -40, -38, -36, -33, -31, -29, -40, -44, -38, -37, -34,
-34, -33, -33, -34, -33, -32, -32, -32, -31, -30, -30, -30, -29, -29, -29, -28,
-28, -27, -26, -26, -26, -24, -24, -23, -23, -22, -21, -20, -20, -19, -18, -17,
-16, -16, -15, -13, -13, -13, -11, -10, -10, -9, -8, -7, -6, -5, -4, -3, -1, 1,
1, 2, 3, 5, 6, 6, 9, 10, 10, 12, 13, 14, 15, 17, 18, 20, 21, 22, 23, 24, 26, 27,
28, 30, 31, 33, 33, 34, 36, 37, 37, 39, 40, 41, 41, 42, 43, 44, 44, 46, 47, 47,
48, 48, 49, 49, 49, 49, 51, 51, 50, 51, 51, 51, 51, 51, 51, 51, 50, 50, 49, 49,
49, 48, 46, 46, 45, 45, 43, 43, 41, 40, 40, 38, 36, 35, 34, 32, 31, 29, 28, 25,
24, 22, 19, 18, 16, 14, 11, 9, 7, 4, 2, -1, -3, -6, -8, -11, -13, -15, -19, -22,
-24, -27, -30, -32, -36, -39, -42, -44, -47, -50, -53, -57, -59, -62, -66, -68,
-70, -74, -77, -79, -83, -85, -87, -91, -93, -96, -98, -102, -104, -107, -108,
-111, -113, -116, -116, -86, -87, -105, -103, -105, -102, -103, -102, -100,
-100, -99, -98, -97, -97, -96, -96, -95, -94, -94, -93, -92, -91, -89, -90, -89,
-88, -87, -87, -86, -85, -84, -83, -82, -81, -80, -79, -78, -77, -75, -74, -73,
-71, -72, -70, -69, -67, -66, -65, -64, -63, -62, -60, -59, -58, -57, -56, -54,
-53, -52, -51, -50, -49, -49, -47, -33, -25, -27, -27, -25, -22, -20, -16, -14,
-11, -9, -6, -3, -1, };