#define DATA_LENGTH 512
#define DATA AKWF_1302

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 3, 5, 8, 9, 12, 15, 17, 19, 22,
24, 27, 28, 32, 34, 38, 40, 43, 45, 48, 52, 55, 58, 62, 67, 70, 74, 77, 81, 84,
87, 90, 92, 94, 96, 98, 99, 101, 103, 104, 104, 106, 111, 110, 107, 106, 105,
102, 100, 98, 96, 94, 91, 90, 87, 86, 84, 82, 80, 78, 76, 74, 72, 70, 68, 66,
64, 61, 58, 55, 52, 49, 47, 43, 38, 36, 34, 28, 25, 27, 24, 10, 8, 19, 12, -2,
-5, -8, -11, -14, -17, -19, -22, -26, -28, -33, -35, -40, -43, -48, -51, -55,
-59, -64, -68, -72, -75, -79, -82, -84, -86, -89, -89, -90, -93, -95, -95, -97,
-101, -104, -102, -98, -96, -94, -92, -90, -87, -84, -82, -80, -77, -74, -72,
-69, -65, -63, -59, -57, -54, -51, -48, -45, -41, -38, -35, -32, -31, -29, -26,
-23, -21, -20, -18, -17, -15, -13, -9, -8, -8, -9, -9, -9, -9, -10, -10, -10,
-10, -10, -10, -10, -10, -11, -10, -11, -11, -11, -11, -12, -12, -12, -12, -13,
-12, -13, -14, -15, -15, -16, -17, -17, -18, -18, -20, -19, -20, -18, -18, -18,
-16, -16, -13, -13, -11, -9, -9, -10, -8, -4, 0, 2, 6, 9, 14, 18, 22, 26, 31,
34, 39, 44, 49, 54, 59, 64, 70, 75, 80, 84, 88, 92, 95, 98, 101, 103, 104, 106,
108, 109, 109, 115, 119, 118, 115, 112, 108, 106, 102, 99, 95, 92, 89, 85, 81,
77, 74, 69, 66, 62, 59, 55, 51, 47, 44, 41, 38, 34, 32, 30, 27, 26, 23, 22, 19,
16, 12, 12, 11, 12, 12, 12, 12, 13, 12, 13, 13, 13, 14, 15, 14, 14, 15, 15, 15,
15, 15, 16, 16, 16, 16, 17, 17, 17, 18, 19, 18, 20, 19, 20, 20, 21, 20, 22, 21,
29, 27, 12, 16, 18, 19, 21, 21, 22, 22, 22, 20, 22, 21, 22, 19, 18, 18, 17, 15,
15, 13, 12, 12, 11, 10, 7, 9, 4, 7, 0, 10, -27, -65, -53, -59, -54, -57, -53,
-56, -54, -54, -53, -54, -53, -52, -52, -51, -52, -50, -53, -50, -52, -49, -52,
-48, -53, -45, -56, -40, -73, -78, -33, -49, -42, -49, -48, -51, -53, -55, -57,
-59, -62, -64, -67, -68, -72, -73, -78, -79, -83, -84, -87, -88, -91, -92, -94,
-95, -96, -97, -99, -99, -99, -101, -104, -106, -104, -104, -101, -101, -99,
-98, -97, -95, -94, -93, -91, -89, -89, -88, -85, -83, -82, -81, -80, -78, -75,
-76, -73, -72, -69, -70, -67, -66, -64, -63, -61, -59, -57, -55, -54, -52, -51,
-47, -47, -43, -44, -38, -40, -32, -37, -27, -34, -20, -34, -10, -47, -87, -2,
-18, -9, -13, -10, -9, -10, -7, -9, -6, -9, -7, -10, -7, -10, -8, -10, -8, -10,
-8, -10, -10, -10, -10, -11, -11, -11, -12, -13, -13, -14, -14, -14, -15, -14,
-16, -15, -15, -14, -14, -13, -12, -11, -11, -10, -10, -10, -8, -6, -5, -2, };