#define DATA_LENGTH 512
#define DATA AKWF_1338

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 1, 1, 2, 1, 3, 2, 3, 3, 3, 4,
4, 4, 4, 4, 4, 5, 4, 5, 5, 4, 6, 5, 5, 5, 6, 6, 6, 6, 6, 6, 7, 7, 7, 8, 10, 11,
13, 15, 17, 19, 21, 23, 24, 27, 28, 31, 32, 35, 36, 39, 40, 42, 44, 46, 48, 51,
50, 42, 35, 28, 20, 12, 5, -2, -10, -17, -25, -32, -40, -48, -56, -63, -70, -77,
-84, -92, -100, -108, -118, -111, -100, -92, -81, -72, -62, -53, -44, -35, -25,
-15, -6, 3, 13, 22, 32, 41, 50, 59, 69, 78, 89, 94, 89, 82, 76, 69, 63, 57, 50,
43, 38, 31, 24, 19, 12, 5, 0, -7, -14, -21, -27, -33, -40, -46, -50, -47, -44,
-40, -37, -35, -32, -27, -25, -21, -18, -15, -12, -9, -6, -1, 1, 5, 8, 11, 15,
17, 23, 23, 21, 21, 20, 18, 17, 16, 15, 14, 13, 13, 11, 11, 9, 9, 8, 6, 4, 5, 3,
2, 2, 1, 0, -1, -1, -1, -2, -3, -3, -4, -4, -5, -5, -6, -7, -6, -7, -8, -8, -8,
-9, -9, -9, -11, -11, -9, -7, -6, -5, -4, -2, -1, 0, 1, 3, 4, 6, 6, 8, 10, 11,
11, 13, 15, 15, 18, 19, 18, 17, 15, 12, 11, 10, 8, 6, 5, 3, 2, 0, -1, -3, -4,
-7, -8, -10, -12, -13, -15, -16, -17, -17, -16, -14, -14, -11, -10, -9, -7, -6,
-4, -3, -1, 0, 1, 3, 4, 5, 7, 9, 10, 11, 14, 15, 13, 12, 11, 10, 9, 7, 7, 6, 5,
3, 2, 1, -1, -1, -3, -4, -5, -7, -7, -9, -9, -11, -11, -10, -9, -8, -8, -6, -6,
-5, -5, -3, -3, -2, -2, 0, 0, 1, 2, 3, 3, 4, 5, 6, 7, 6, 5, 6, 6, 4, 4, 5, 3, 3,
3, 2, 2, 1, 1, 1, -1, -1, 0, -1, -1, -2, -2, -3, -3, -2, -2, -2, -2, -2, -2, -1,
-1, -1, -2, -1, 0, -1, -1, -1, -1, 1, 0, 0, 0, 1, 1, 1, 0, 1, 1, 1, 1, 0, 1, 0,
1, 1, 1, 1, 1, 1, 1, 1, 0, 2, 2, 1, 1, 1, 1, 0, 1, 1, 0, 0, 1, 0, 0, -1, -1, -1,
-1, -1, -1, -1, -1, -1, -1, -2, -2, -1, -2, -2, -1, -1, -2, -1, -1, -1, -1, 0,
0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 2, 2, 1, 1, 1, 1, 1, 0, 0, 0, -1, 0, 0, -1,
0, 0, -1, -2, -2, -2, -2, -2, -2, -2, -1, -2, -2, -1, -2, -2, -2, -1, -1, -1,
-1, -1, -1, 0, -1, -1, 0, 0, 0, 0, 1, 1, 0, 0, -1, -1, 0, 0, 0, -1, 0, -1, 0,
-1, -1, -1, -1, -2, -1, -2, -2, -2, -2, -2, -1, -2, -1, -2, -1, -1, -2, -2, -1,
-1, -1, -1, -1, -1, 0, -1, 0, 0, -1, 0, 0, 0, };