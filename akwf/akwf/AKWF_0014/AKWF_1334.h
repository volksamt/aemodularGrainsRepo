#define DATA_LENGTH 512
#define DATA AKWF_1334

const PROGMEM int8_t DATA[DATA_LENGTH] = {105, 124, 115, 123, 116, 121, 117,
120, 116, 121, 118, 120, 118, 120, 118, 120, 119, 120, 119, 119, 119, 119, 120,
119, 120, 118, 120, 119, 120, 119, 119, 119, 120, 118, 119, 119, 119, 120, 120,
118, 120, 119, 120, 119, 118, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119,
120, 119, 119, 120, 119, 118, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120,
120, 119, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119, 119, 118, 119, 119,
118, 119, 119, 120, 120, 119, 119, 118, 119, 119, 118, 118, 119, 119, 118, 119,
119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 120, 119, 119,
119, 119, 120, 120, 119, 118, 119, 119, 119, 119, 118, 119, 118, 120, 118, 120,
119, 119, 119, 119, 118, 120, 118, 120, 118, 119, 118, 120, 119, 118, 119, 117,
122, -8, -78, -67, -75, -69, -74, -70, -73, -70, -73, -70, -73, -71, -72, -71,
-72, -71, -71, -71, -72, -71, -71, -72, -72, -71, -71, -72, -71, -72, -72, -72,
-71, -71, -72, -72, -71, -71, -71, -72, -71, -72, -71, -72, -71, -71, -71, -72,
-71, -71, -71, -71, -71, -72, -71, -70, -71, -71, -72, -71, -71, -71, -71, -71,
-71, -72, -72, -72, -72, -71, -71, -72, -72, -71, -71, -71, -71, -72, -71, -71,
-71, -72, -71, -72, -72, -71, -71, -72, -71, -72, -72, -72, -71, -71, -72, -71,
-72, -71, -71, -71, -72, -71, -72, -72, -72, -71, -72, -71, -72, -72, -72, -72,
-71, -71, -72, -72, -71, -71, -71, -71, -71, -71, -72, -71, -72, -71, -72, -71,
-71, -72, -71, -72, -71, -72, -72, -72, -71, -72, -72, -71, -72, -72, -71, -71,
-71, -71, -72, -72, -71, -71, -71, -71, -71, -71, -71, -71, -71, -72, -71, -72,
-71, -71, -72, -71, -71, -71, -72, -71, -71, -71, -72, -71, -72, -71, -72, -70,
-48, -47, -48, -48, -48, -47, -47, -47, -48, -48, -48, -47, -48, -48, -48, -48,
-48, -48, -48, -48, -47, -48, -47, -48, -48, -47, -47, -47, -48, -48, -48, -47,
-48, -47, -47, -48, -47, -48, -47, -47, -47, -48, -48, -47, -48, -48, -48, -49,
-48, -48, -47, -47, -48, -48, -47, -47, -48, -48, -47, -47, -47, -47, -49, -48,
-48, -48, -48, -47, -48, -48, -48, -48, -47, -48, -48, -47, -47, -48, -48, -47,
-48, -47, -48, -47, -48, -47, -48, -48, -48, -47, -48, -47, -47, -48, -48, -48,
-48, -47, -48, -48, -48, -47, -47, -48, -47, -48, -47, -47, -47, -47, -48, -48,
-47, -47, -47, -47, -48, -48, -48, -48, -47, -48, -47, -48, -47, -48, -48, -47,
-47, -48, -47, -48, -47, -48, -48, -48, -48, -47, -48, -47, -48, -47, -48, -48,
-49, -48, -48, -47, -48, -48, -48, -47, -48, -48, -47, -48, -47, -48, -48, -48,
-46, -49, -46, -49, -46, -50, -45, -52, -53, };