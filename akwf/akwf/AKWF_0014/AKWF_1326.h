#define DATA_LENGTH 512
#define DATA AKWF_1326

const PROGMEM int8_t DATA[DATA_LENGTH] = {103, 125, 115, 122, 117, 120, 116,
121, 116, 120, 117, 119, 117, 120, 118, 120, 118, 118, 118, 119, 119, 120, 118,
118, 118, 119, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 118, 119, 118, 119, 118, 120, 117, 119,
118, 120, 116, 120, 118, 121, 117, 120, 117, 19, 7, 13, 7, 13, 8, 13, 8, 13, 9,
11, 9, 12, 10, 11, 9, 11, 10, 11, 10, 11, 11, 10, 10, 11, 11, 10, 11, 10, 11,
10, 11, 10, 10, 10, 10, 10, 11, 10, 11, 10, 11, 10, 11, 10, 12, 11, 11, 11, 10,
11, 10, 10, 10, 12, 9, 11, 8, 12, 9, 13, 9, 13, 8, 13, 8, 13, 8, 13, 12, -114,
-122, -116, -122, -117, -122, -116, -122, -117, -120, -117, -121, -117, -120,
-118, -119, -118, -120, -119, -119, -119, -120, -119, -118, -120, -119, -120,
-118, -120, -118, -120, -118, -118, -118, -119, -119, -120, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -120, -119, -119, -119, -119,
-119, -119, -120, -119, -120, -118, -120, -119, -120, -119, -120, -118, -120,
-117, -121, -119, -120, -119, -119, -119, -118, -120, -117, -122, -113, -128,
-29, 25, 3, 18, 8, 15, 9, 14, 10, 13, 10, 12, 11, 13, 12, 12, 12, 11, 12, 12,
13, 11, 13, 11, 13, 11, 12, 12, 12, 12, 12, 12, 12, 11, 12, 12, 12, 12, 12, 12,
12, 12, 12, 12, 11, 13, 12, 12, 12, 12, 11, 12, 12, 13, 12, 12, 11, 12, 12, 13,
11, 13, 12, 12, 11, 12, 11, 12, 12, 12, 12, 11, 12, 11, 13, 11, 13, 10, 14, 9,
16, 8, 17, 4, 37, 124, 112, 117, 115, 116, 115, 115, 116, 115, 116, 114, 116,
114, 117, 115, 116, 114, 116, 114, 116, 114, 116, 115, 116, 115, 116, 115, 115,
116, 115, 115, 114, 116, 115, 115, 115, 116, 114, 115, 115, 117, 115, 116, 115,
116, 115, 116, 115, 116, 115, 115, 115, 114, 116, 114, 117, 114, 117, 113, 119,
110, 122, 105, 127, 54, -56, -28, -42, -33, -39, -35, -39, -36, -37, -37, -36,
-38, -36, -37, -36, -38, -35, -38, -36, -38, -37, -38, -37, -37, -37, -37, -36,
-37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -36, -37, -37, -37,
-37, -37, -37, -36, -38, -37, -38, -37, -37, -37, -38, -37, -38, -36, -38, -37,
-38, -36, -38, -37, -37, -37, -35, -99, -113, -105, -110, -106, -109, -107,
-109, -108, -109, -108, -109, -107, -109, -107, -109, -108, -109, -109, -108,
-108, -108, -107, -109, -108, -108, -108, -108, -108, -107, -109, -109, -108,
-108, -108, -108, -108, -108, -109, -108, -108, -109, -109, -109, -108, -108,
-109, -108, -108, -109, -109, -108, -108, -108, -108, -108, -109, -108, -109,
-107, -108, -107, -108, -108, -108, -108, -108, -109, -107, -109, -107, -109,
-108, -110, -106, -110, -106, -111, -106, -112, -103, -115, -92, };