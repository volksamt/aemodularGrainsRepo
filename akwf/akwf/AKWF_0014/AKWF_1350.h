#define DATA_LENGTH 512
#define DATA AKWF_1350

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1,
1, 0, 0, 1, 1, 2, 1, 2, 1, 2, 2, 2, 2, 2, 3, 3, 3, 3, 4, 4, 3, 4, 4, 5, 5, 5, 5,
6, 6, 6, 6, 7, 7, 8, 7, 8, 8, 8, 9, 9, 10, 10, 11, 11, 11, 11, 12, 12, 13, 13,
14, 14, 15, 14, 14, 15, 15, 16, 17, 17, 17, 18, 19, 19, 18, 19, 20, 21, 21, 21,
22, 21, 22, 23, 23, 24, 25, 25, 25, 25, 26, 26, 27, 27, 28, 28, 29, 29, 29, 30,
29, 30, 30, 31, 31, 32, 32, 33, 33, 33, 33, 33, 35, 35, 35, 36, 36, 36, 36, 37,
37, 37, 39, 38, 39, 39, 40, 39, 40, 40, 40, 40, 41, 41, 41, 42, 42, 42, 42, 43,
43, 44, 43, 42, 43, 43, 43, 43, 44, 44, 45, 44, 45, 45, 44, 45, 44, 45, 45, 45,
45, 46, 45, 45, 45, 45, 45, 45, 45, 45, 45, 45, 44, 44, 45, 44, 44, 44, 43, 44,
44, 43, 43, 42, 42, 42, 42, 42, 41, 41, 40, 41, 41, 40, 40, 39, 38, 38, 37, 38,
38, 37, 37, 36, 36, 35, 34, 34, 33, 33, 32, 31, 31, 31, 30, 30, 29, 29, 28, 27,
27, 26, 26, 25, 24, 23, 23, 22, 21, 21, 20, 19, 18, 17, 16, 16, 15, 13, 14, 12,
12, 11, 10, 9, 8, 7, 7, 5, 5, 3, 2, 2, 1, 1, -1, -3, -2, -4, -4, -6, -7, -8, -9,
-10, -11, -12, -14, -14, -15, -16, -17, -18, -20, -20, -22, -23, -24, -25, -26,
-27, -29, -28, -31, -31, -32, -34, -35, -35, -37, -38, -39, -40, -41, -43, -43,
-45, -46, -47, -48, -49, -50, -52, -52, -53, -54, -56, -57, -58, -59, -60, -62,
-62, -64, -64, -65, -67, -67, -68, -70, -71, -72, -73, -73, -75, -76, -78, -78,
-79, -80, -81, -82, -83, -84, -86, -87, -87, -88, -88, -90, -90, -92, -92, -92,
-94, -94, -96, -96, -98, -98, -98, -100, -100, -102, -102, -102, -104, -104,
-105, -106, -106, -107, -106, -108, -109, -109, -110, -111, -111, -112, -112,
-112, -113, -113, -115, -114, -114, -114, -116, -115, -116, -116, -117, -117,
-117, -117, -118, -117, -118, -118, -118, -118, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -118, -119, -118, -118, -118, -119, -118, -117,
-117, -117, -117, -117, -116, -116, -115, -115, -115, -115, -114, -113, -113,
-113, -113, -112, -111, -111, -109, -110, -109, -109, -107, -107, -106, -105,
-104, -103, -103, -102, -102, -101, -100, -99, -98, -97, -95, -95, -94, -93,
-92, -91, -90, -89, -88, -86, -85, -84, -83, -82, -80, -79, -78, -77, -75, -74,
-72, -71, -70, -69, -67, -66, -64, -63, -61, -60, -59, -56, -55, -54, -52, -51,
-50, -48, -47, -44, -43, -40, -39, -38, -36, -34, -32, -31, -29, -27, -25, -24,
-22, -20, -18, -17, -15, -12, -11, -9, -7, -5, -3, -1, };