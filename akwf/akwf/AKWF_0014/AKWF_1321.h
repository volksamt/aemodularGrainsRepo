#define DATA_LENGTH 512
#define DATA AKWF_1321

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, -1, -2, 1, 4, 6, 7, 9, 12, 14, 15,
18, 20, 21, 23, 25, 26, 28, 29, 31, 32, 33, 35, 36, 38, 39, 41, 42, 43, 44, 45,
46, 48, 48, 49, 49, 52, 52, 52, 53, 54, 55, 56, 56, 57, 57, 58, 59, 58, 59, 60,
59, 60, 61, 61, 61, 62, 61, 62, 63, 63, 62, 64, 63, 63, 63, 64, 64, 64, 65, 64,
64, 64, 65, 65, 65, 66, 64, 65, 65, 65, 65, 66, 65, 65, 65, 66, 66, 66, 67, 66,
66, 67, 67, 67, 67, 68, 67, 67, 66, 68, 68, 67, 68, 69, 68, 69, 68, 69, 69, 70,
70, 70, 70, 70, 71, 71, 71, 72, 72, 72, 73, 73, 73, 74, 74, 75, 75, 76, 75, 76,
76, 77, 77, 77, 78, 78, 79, 79, 80, 81, 81, 81, 82, 83, 83, 84, 83, 84, 84, 83,
84, 85, 84, 84, 85, 85, 85, 85, 85, 85, 84, 84, 85, 85, 84, 85, 84, 85, 84, 84,
84, 83, 82, 82, 82, 81, 81, 81, 79, 79, 78, 77, 76, 76, 76, 75, 73, 73, 72, 71,
70, 69, 67, 67, 65, 64, 64, 62, 61, 60, 58, 57, 57, 55, 53, 52, 50, 50, 48, 47,
45, 44, 42, 40, 39, 39, 36, 34, 34, 32, 31, 29, 28, 26, 25, 24, 23, 21, 20, 17,
16, 15, 14, 12, 11, 9, 9, 7, 5, 4, 3, 2, 0, -1, -2, -4, -4, -6, -7, -8, -9, -11,
-12, -13, -14, -14, -16, -17, -18, -19, -19, -21, -21, -22, -23, -24, -25, -26,
-26, -28, -27, -29, -29, -29, -30, -32, -33, -33, -33, -33, -33, -35, -36, -36,
-36, -37, -37, -38, -38, -38, -39, -39, -40, -39, -40, -40, -41, -41, -42, -42,
-42, -41, -43, -43, -43, -43, -42, -43, -44, -43, -43, -43, -44, -44, -45, -45,
-45, -45, -45, -45, -46, -46, -46, -46, -46, -46, -46, -46, -46, -46, -47, -47,
-46, -48, -47, -47, -47, -48, -47, -48, -48, -49, -48, -49, -49, -50, -49, -50,
-50, -51, -51, -51, -52, -52, -51, -52, -52, -53, -54, -53, -54, -54, -55, -55,
-55, -56, -56, -57, -57, -57, -58, -58, -60, -60, -61, -62, -63, -63, -65, -65,
-66, -67, -69, -69, -70, -71, -72, -72, -74, -75, -76, -77, -78, -80, -81, -81,
-83, -84, -85, -86, -88, -89, -90, -91, -93, -94, -95, -97, -99, -99, -101,
-103, -105, -105, -106, -109, -109, -109, -111, -113, -113, -113, -114, -114,
-115, -115, -115, -116, -116, -117, -118, -118, -119, -118, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -118, -118, -119, -117, -117, -116, -116,
-115, -115, -114, -113, -112, -112, -111, -109, -108, -107, -106, -105, -103,
-101, -100, -98, -98, -96, -94, -93, -92, -89, -88, -86, -84, -82, -80, -79,
-77, -74, -72, -71, -69, -66, -64, -62, -60, -57, -56, -53, -51, -49, -47, -44,
-42, -40, -37, -35, -32, -30, -28, -26, -24, -21, -19, -17, -14, -13, -10, -8,
-5, };