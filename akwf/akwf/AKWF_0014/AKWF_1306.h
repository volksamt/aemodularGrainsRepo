#define DATA_LENGTH 512
#define DATA AKWF_1306

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 13, 17, 23, 28, 33, 37, 42, 46,
49, 54, 57, 60, 64, 67, 71, 73, 77, 80, 82, 84, 87, 90, 92, 94, 96, 99, 101,
102, 104, 105, 106, 107, 109, 111, 112, 113, 113, 115, 115, 115, 116, 117, 117,
118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 118,
117, 117, 117, 116, 116, 115, 114, 114, 114, 112, 113, 112, 111, 111, 110, 109,
109, 108, 107, 106, 105, 104, 103, 102, 102, 100, 99, 98, 97, 97, 95, 94, 93,
92, 91, 90, 89, 87, 86, 84, 84, 82, 81, 79, 77, 76, 74, 73, 71, 70, 68, 66, 65,
62, 60, 57, 55, 52, 48, 46, 46, 44, 43, 41, 39, 37, 35, 33, 31, 30, 28, 27, 25,
24, 23, 21, 21, 19, 18, 17, 16, 15, 15, 14, 13, 13, 12, 11, 10, 10, 9, 9, 9, 8,
8, 7, 7, 7, 7, 6, 6, 5, 6, 5, 5, 5, 4, 3, 3, 2, 2, 2, 2, 2, 2, 2, 2, 2, 1, 2, 0,
1, 1, 1, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, -1, -1, -1,
-2, -1, -1, -2, -1, -2, -1, -2, -1, -2, -2, -2, -2, -2, -3, -2, -2, -2, -3, -3,
-4, -3, -4, -4, -3, -4, -5, -4, -4, -5, -5, -6, -6, -6, -6, -6, -6, -6, -7, -7,
-8, -7, -8, -9, -9, -9, -9, -10, -11, -11, -11, -11, -11, -12, -12, -13, -13,
-14, -14, -15, -16, -16, -16, -18, -17, -18, -19, -19, -20, -20, -21, -21, -22,
-22, -23, -25, -25, -26, -27, -27, -28, -29, -29, -30, -31, -32, -32, -33, -33,
-35, -35, -36, -37, -37, -38, -39, -39, -41, -41, -42, -42, -42, -44, -44, -46,
-46, -47, -48, -48, -49, -49, -50, -51, -50, -52, -53, -54, -54, -54, -54, -55,
-57, -56, -57, -57, -57, -59, -60, -59, -60, -60, -61, -62, -62, -63, -63, -63,
-64, -65, -65, -65, -66, -66, -66, -66, -67, -67, -66, -67, -67, -67, -67, -67,
-68, -67, -67, -67, -66, -66, -65, -65, -65, -64, -63, -62, -61, -59, -57, -53,
-53, -53, -54, -53, -51, -50, -49, -47, -47, -46, -45, -43, -42, -42, -42, -40,
-40, -39, -39, -39, -38, -37, -37, -36, -36, -36, -36, -35, -35, -35, -35, -34,
-35, -34, -35, -34, -33, -33, -34, -35, -34, -34, -34, -35, -35, -34, -34, -34,
-35, -34, -35, -34, -35, -36, -36, -36, -36, -36, -36, -38, -37, -36, -38, -38,
-38, -40, -40, -39, -40, -40, -41, -41, -42, -42, -43, -43, -44, -44, -45, -45,
-46, -46, -47, -48, -49, -49, -49, -50, -51, -51, -53, -53, -54, -54, -56, -56,
-57, -58, -59, -60, -61, -63, -63, -65, -65, -67, -67, -69, -70, -71, -71, -73,
-73, -76, -77, -77, -79, -81, -82, -83, -84, -86, -87, -90, -86, -28, -9, -35,
-41, -43, -39, -32, -24, -18, -11, -5, };