#define DATA_LENGTH 512
#define DATA AKWF_1384

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 2, 3, 3, 3, 3, 4, 4, 4, 5,
4, 5, 5, 5, 5, 6, 6, 7, 6, 6, 7, 7, 6, 7, 7, 7, 8, 7, 8, 7, 7, 7, 8, 8, 7, 8, 8,
7, 7, 7, 8, 8, 7, 7, 7, 7, 7, 7, 7, 6, 6, 7, 6, 6, 6, 6, 6, 7, 6, 7, 5, 6, 14,
18, 20, 23, 24, 26, 27, 29, 29, 30, 30, 31, 31, 30, 31, 32, 32, 32, 31, 32, 32,
31, 30, 28, 29, 27, 27, 26, 26, 24, 23, 23, 21, 21, 20, 18, 18, 17, 16, 16, 14,
13, 12, 12, 12, 11, 10, 11, 10, 11, 10, 11, 11, 11, 11, 11, 13, 12, 14, 14, 14,
16, 16, 17, 18, 19, 20, 21, 21, 23, 25, 25, 27, 28, 28, 31, 31, 33, 34, 36, 36,
38, 40, 40, 42, 43, 44, 46, 48, 47, 49, 49, 48, 49, 49, 48, 50, 50, 49, 51, 50,
51, 50, 52, 51, 53, 52, 53, 52, 54, 54, 55, 55, 57, 57, 57, 58, 58, 60, 60, 62,
60, 64, 62, 66, 63, 71, 61, 80, 28, -38, -26, -38, -33, -36, -31, -28, -23, -18,
-12, -4, 1, 9, 15, 25, 31, 38, 43, 50, 55, 61, 65, 70, 74, 80, 83, 88, 91, 96,
99, 104, 107, 109, 113, 115, 117, 118, 119, 118, 119, 118, 116, 114, 113, 109,
107, 103, 99, 94, 89, 84, 78, 72, 67, 61, 55, 49, 44, 39, 34, 28, 22, 18, 12, 7,
1, -3, -8, -13, -18, -23, -26, -30, -35, -39, -42, -46, -50, -53, -58, -60, -63,
-67, -69, -73, -76, -77, -79, -82, -84, -86, -88, -89, -90, -91, -93, -93, -95,
-95, -96, -95, -97, -97, -96, -96, -96, -96, -96, -95, -94, -94, -92, -92, -91,
-90, -88, -88, -86, -85, -84, -82, -81, -79, -78, -75, -75, -79, -79, -80, -79,
-79, -78, -77, -77, -75, -74, -73, -71, -69, -68, -65, -63, -61, -59, -57, -54,
-52, -51, -49, -45, -43, -40, -38, -35, -33, -30, -28, -25, -23, -21, -19, -16,
-13, -12, -9, -7, -6, -4, -2, -1, 1, 1, 2, 3, 3, 5, 4, 5, 4, 4, 4, 4, 4, 4, 3,
3, 2, 2, 0, 0, -2, -2, -2, -4, -5, -6, -7, -7, -9, -10, -11, -11, -12, -13, -14,
-16, -16, -17, -18, -20, -21, -21, -22, -22, -24, -24, -24, -25, -26, -27, -27,
-28, -29, -29, -30, -30, -30, -31, -32, -32, -32, -33, -33, -34, -34, -34, -35,
-35, -35, -36, -36, -35, -35, -37, -36, -37, -37, -37, -37, -37, -38, -37, -36,
-37, -36, -36, -36, -36, -37, -36, -35, -35, -34, -34, -34, -33, -32, -31, -31,
-31, -30, -30, -28, -29, -28, -27, -26, -26, -25, -24, -23, -22, -22, -22, -20,
-19, -19, -18, -17, -17, -16, -15, -15, -14, -13, -12, -11, -10, -10, -9, -9,
-8, -8, -7, -7, -5, -5, -5, -5, -3, -3, -2, -2, -2, -1, 0, 1, };