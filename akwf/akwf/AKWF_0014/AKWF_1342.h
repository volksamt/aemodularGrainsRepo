#define DATA_LENGTH 512
#define DATA AKWF_1342

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 5, 7, 9, 10, 13, 13, 15, 17,
19, 21, 22, 25, 26, 28, 29, 30, 33, 35, 36, 39, 39, 40, 43, 44, 46, 48, 48, 51,
52, 54, 55, 57, 58, 60, 62, 64, 65, 67, 67, 69, 70, 71, 73, 75, 76, 78, 78, 80,
81, 83, 83, 85, 86, 88, 89, 90, 91, 93, 94, 94, 96, 96, 97, 98, 99, 100, 101,
102, 104, 104, 105, 105, 106, 107, 107, 109, 110, 109, 111, 112, 112, 113, 112,
113, 114, 115, 115, 115, 116, 116, 117, 117, 117, 118, 118, 118, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 118, 119, 118, 118, 118,
117, 116, 117, 116, 115, 115, 115, 114, 114, 113, 114, 113, 111, 111, 111, 110,
109, 109, 109, 107, 107, 106, 105, 105, 104, 103, 101, 100, 100, 98, 98, 97, 96,
95, 94, 92, 91, 90, 88, 88, 87, 85, 85, 83, 81, 81, 80, 77, 76, 75, 74, 72, 71,
69, 67, 66, 65, 63, 63, 61, 60, 58, 57, 54, 53, 52, 50, 48, 46, 45, 43, 42, 40,
38, 36, 35, 33, 31, 29, 27, 26, 25, 23, 21, 19, 17, 17, 15, 12, 10, 10, 8, 6, 4,
2, 0, -2, -2, -5, -6, -9, -10, -11, -14, -16, -17, -19, -21, -22, -23, -26, -28,
-29, -31, -32, -35, -36, -38, -39, -41, -42, -45, -46, -47, -49, -50, -51, -54,
-55, -56, -59, -60, -62, -62, -65, -66, -67, -69, -70, -72, -72, -75, -76, -77,
-78, -79, -81, -82, -83, -85, -86, -87, -89, -90, -90, -92, -93, -94, -95, -96,
-97, -98, -99, -100, -101, -102, -103, -103, -104, -105, -107, -107, -108, -108,
-109, -110, -110, -111, -112, -112, -112, -113, -114, -114, -114, -115, -116,
-115, -116, -116, -117, -118, -118, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -118, -117, -118,
-118, -117, -117, -117, -116, -116, -116, -115, -114, -114, -113, -113, -112,
-112, -112, -111, -110, -110, -108, -108, -106, -106, -105, -104, -104, -103,
-101, -101, -100, -99, -97, -96, -96, -95, -94, -93, -91, -90, -89, -88, -87,
-85, -84, -83, -81, -80, -79, -78, -76, -74, -74, -72, -71, -70, -68, -67, -65,
-64, -62, -61, -59, -58, -56, -54, -53, -52, -50, -49, -47, -46, -44, -42, -40,
-38, -37, -36, -34, -32, -30, -29, -26, -25, -24, -22, -20, -18, -16, -14, -12,
-11, -10, -8, -6, -4, -2, -1, 1, 3, 4, 6, 8, 9, 12, 13, 15, 17, 18, 20, 22, 24,
25, 27, 29, 31, 32, 34, 35, 37, 38, 41, 41, 44, 45, 47, 49, 50, 52, 53, 55, 57,
57, 60, 61, 63, 63, 65, 67, 68, 70, 71, 73, 73, 75, 76, 78, 80, 81, 82, 83, 85,
86, 86, 88, 89, 91, 91, 94, 94, 95, 96, 97, 97, 98, 100, 101, 103, 102, 105,
103, 106, 104, 108, 106, 110, 107, 112, 107, 115, 107, 119, 96, };