#define DATA_LENGTH 512
#define DATA AKWF_1343

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 1, 0,
1, 1, 1, 1, 1, 2, 1, 2, 2, 1, 1, 3, 2, 3, 2, 3, 3, 3, 4, 4, 5, 5, 4, 6, 5, 6, 7,
6, 7, 7, 7, 7, 8, 8, 8, 9, 10, 11, 11, 11, 12, 13, 12, 14, 13, 14, 14, 15, 15,
16, 16, 16, 17, 18, 18, 20, 20, 20, 21, 21, 22, 22, 23, 24, 24, 25, 25, 26, 27,
28, 29, 29, 30, 30, 31, 32, 33, 34, 34, 35, 35, 36, 37, 38, 39, 40, 40, 41, 41,
43, 43, 44, 46, 45, 47, 48, 48, 49, 50, 51, 52, 53, 54, 55, 55, 57, 58, 59, 59,
60, 61, 62, 63, 64, 64, 65, 66, 66, 67, 68, 71, 71, 72, 73, 73, 75, 76, 76, 77,
78, 79, 80, 80, 81, 82, 83, 84, 86, 86, 87, 87, 89, 90, 90, 92, 92, 93, 93, 94,
95, 96, 98, 98, 98, 100, 100, 100, 102, 103, 104, 104, 105, 106, 107, 107, 107,
108, 108, 109, 110, 111, 111, 112, 112, 113, 113, 114, 114, 115, 115, 115, 116,
116, 117, 117, 117, 117, 117, 118, 119, 118, 119, 118, 119, 119, 120, 119, 119,
119, 119, 119, 119, 118, 119, 118, 118, 117, 118, 118, 116, 117, 116, 116, 116,
115, 114, 113, 114, 113, 113, 111, 111, 110, 109, 108, 108, 107, 105, 105, 105,
103, 102, 101, 99, 98, 97, 96, 94, 93, 92, 90, 89, 88, 85, 84, 84, 81, 80, 78,
76, 75, 73, 71, 70, 68, 65, 64, 62, 59, 58, 56, 54, 51, 50, 47, 45, 43, 40, 39,
36, 34, 31, 29, 27, 24, 21, 20, 17, 15, 12, 9, 7, 4, 3, 0, -4, -5, -8, -10, -14,
-15, -18, -21, -24, -26, -29, -31, -33, -35, -38, -41, -44, -45, -48, -51, -54,
-56, -58, -61, -63, -65, -67, -70, -71, -74, -76, -79, -81, -83, -85, -87, -89,
-91, -92, -94, -96, -98, -100, -101, -102, -103, -105, -106, -108, -109, -111,
-112, -112, -113, -115, -115, -115, -116, -117, -117, -118, -118, -119, -119,
-119, -119, -118, -118, -118, -118, -119, -118, -117, -117, -116, -115, -115,
-114, -112, -111, -110, -108, -108, -106, -105, -102, -101, -99, -99, -96, -94,
-92, -90, -87, -85, -83, -80, -78, -75, -73, -70, -66, -65, -61, -58, -56, -53,
-49, -46, -43, -40, -37, -33, -29, -26, -23, -19, -15, -12, -9, -5, -2, 2, 6,
10, 13, 16, 20, 23, 27, 31, 34, 38, 40, 45, 48, 51, 54, 58, 61, 64, 68, 70, 73,
76, 80, 82, 84, 88, 90, 92, 94, 97, 98, 101, 103, 105, 106, 108, 110, 112, 113,
114, 115, 116, 116, 118, 118, 118, 119, 118, 119, 119, 119, 118, 117, 118, 116,
116, 114, 113, 112, 111, 108, 107, 105, 103, 101, 100, 97, 94, 91, 89, 86, 82,
80, 76, 74, 70, 67, 64, 60, 56, 52, 48, 44, 40, 36, 33, 28, 23, 20, 14, 11, 6,
};