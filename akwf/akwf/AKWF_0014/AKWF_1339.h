#define DATA_LENGTH 512
#define DATA AKWF_1339

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 18, 30, 42, 53, 66, 73, 72, 71, 69,
68, 65, 64, 63, 62, 60, 59, 58, 56, 55, 53, 53, 46, 38, 30, 23, 15, 7, -1, -8,
-16, -24, -31, -40, -48, -56, -62, -71, -70, -64, -59, -54, -50, -44, -39, -34,
-29, -24, -18, -14, -9, -4, 1, 8, 11, 12, 15, 18, 21, 23, 26, 28, 30, 33, 36,
37, 41, 42, 45, 47, 43, 37, 33, 27, 23, 17, 12, 7, 2, -3, -8, -11, -17, -22,
-28, -31, -30, -29, -28, -27, -25, -25, -23, -22, -22, -21, -20, -18, -18, -17,
-15, -14, -11, -9, -6, -2, 0, 3, 5, 9, 12, 15, 17, 21, 24, 26, 31, 28, 25, 24,
21, 19, 16, 15, 13, 10, 7, 5, 2, 1, -2, -4, -6, -6, -7, -7, -9, -9, -10, -11,
-11, -12, -12, -13, -14, -15, -15, -16, -16, -14, -12, -10, -8, -6, -5, -3, 0,
1, 3, 5, 7, 8, 12, 13, 14, 13, 13, 11, 11, 11, 9, 10, 8, 7, 6, 6, 5, 5, 4, 3, 3,
1, 1, 0, -2, -2, -3, -5, -5, -6, -8, -8, -9, -10, -11, -12, -11, -10, -9, -9,
-7, -7, -5, -5, -3, -2, -1, 0, 2, 2, 3, 4, 5, 5, 5, 4, 5, 6, 5, 5, 5, 6, 5, 5,
6, 6, 6, 5, 4, 3, 3, 2, 1, 1, 0, -1, -1, -2, -2, -4, -4, -5, -6, -6, -5, -5, -4,
-5, -3, -3, -3, -3, -2, -2, -2, -1, -1, -1, -1, -1, 1, 1, 1, 2, 2, 2, 2, 2, 3,
4, 3, 4, 4, 5, 5, 4, 4, 3, 3, 3, 2, 2, 1, 0, 1, 1, 0, -2, -1, -2, -2, -2, -2,
-2, -2, -2, -2, -2, -3, -2, -2, -3, -2, -3, -3, -2, -1, -2, -1, -1, -1, 0, 0, 0,
0, 0, 0, 1, 1, 1, 2, 3, 2, 1, 3, 2, 1, 2, 1, 1, 1, 0, 1, 0, 0, 0, 0, 0, -1, 0,
-1, 0, -2, -1, -1, -1, -2, -1, -1, -1, -2, -2, -2, -3, -2, -2, -3, -2, -2, -2,
-2, -1, -1, -1, 0, -1, 0, -1, -1, 0, 0, -1, 0, 1, 0, 0, 0, -1, -1, 0, 0, 0, 0,
-1, 0, 0, 0, 0, 0, -1, -1, -1, -1, -2, -2, -2, -2, -3, -2, -3, -3, -2, -2, -2,
-3, -2, -1, -2, -2, -2, -1, -1, -1, -1, -1, -2, 0, -1, 0, 0, 1, 0, 1, 1, 2, 2,
2, 3, 3, 4, 4, 4, 4, 4, 4, 4, 5, 4, 3, 3, 4, 3, 3, 3, 3, 2, 2, 3, 4, 7, 8, 11,
12, 15, 17, 19, 20, 22, 24, 27, 28, 30, 31, 33, 34, 35, 35, 36, 36, 37, 38, 37,
38, 39, 40, 40, 40, 41, 43, 38, 27, 18, 6, -3, -14, -23, -34, -45, -54, -64,
-75, -85, -96, -105, -116, -118, -110, -104, -98, -91, -84, -78, -71, -64, -58,
-52, -46, -38, -32, -25, -16, -8, };