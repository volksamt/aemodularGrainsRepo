#define DATA_LENGTH 512
#define DATA AKWF_1312

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 2, 3, 4, 5, 5, 6, 6, 7, 8, 7,
8, 9, 10, 10, 11, 11, 12, 13, 14, 15, 15, 16, 16, 17, 17, 18, 19, 20, 20, 21,
22, 22, 23, 23, 24, 24, 26, 27, 26, 27, 28, 28, 30, 30, 31, 32, 33, 32, 34, 34,
35, 35, 36, 37, 37, 38, 38, 40, 40, 42, 41, 41, 43, 44, 45, 44, 46, 47, 47, 47,
49, 49, 50, 51, 52, 52, 53, 52, 54, 55, 55, 56, 57, 58, 58, 59, 59, 60, 61, 61,
62, 63, 63, 64, 65, 66, 66, 68, 68, 68, 70, 71, 71, 71, 73, 72, 73, 74, 75, 76,
76, 77, 77, 78, 78, 80, 81, 81, 81, 82, 83, 84, 84, 85, 86, 87, 88, 88, 88, 90,
90, 90, 91, 92, 92, 94, 95, 95, 96, 96, 97, 97, 99, 99, 101, 101, 102, 103, 103,
104, 104, 105, 106, 106, 107, 109, 109, 109, 110, 110, 112, 113, 113, 113, 114,
115, 115, 117, 117, 118, 118, 119, 119, 116, 113, 110, 108, 104, 102, 99, 96,
92, 90, 87, 85, 81, 79, 76, 74, 70, 68, 66, 63, 61, 58, 56, 53, 51, 48, 47, 44,
42, 40, 37, 36, 33, 31, 29, 27, 26, 24, 22, 19, 18, 16, 14, 12, 11, 9, 7, 5, 4,
2, 0, -2, -2, -4, -6, -7, -9, -10, -12, -13, -14, -16, -17, -18, -20, -21, -22,
-24, -24, -26, -27, -27, -29, -30, -31, -32, -33, -35, -36, -36, -38, -38, -39,
-41, -42, -42, -43, -44, -44, -46, -47, -47, -48, -49, -50, -50, -51, -52, -52,
-53, -54, -54, -55, -55, -56, -56, -57, -57, -58, -59, -60, -60, -61, -61, -61,
-62, -62, -63, -63, -64, -63, -64, -64, -64, -65, -65, -65, -66, -66, -66, -67,
-67, -67, -68, -67, -68, -68, -69, -68, -69, -69, -69, -69, -69, -69, -70, -70,
-70, -69, -70, -71, -71, -70, -71, -70, -70, -71, -71, -70, -70, -70, -71, -70,
-71, -70, -70, -70, -71, -71, -70, -71, -70, -69, -69, -69, -70, -70, -69, -69,
-69, -69, -68, -68, -69, -68, -68, -69, -67, -67, -67, -67, -66, -67, -67, -66,
-66, -66, -66, -65, -66, -65, -65, -64, -64, -64, -64, -64, -64, -62, -63, -62,
-61, -62, -61, -61, -60, -60, -59, -59, -58, -59, -59, -58, -58, -58, -57, -56,
-57, -56, -56, -55, -54, -54, -54, -54, -53, -52, -52, -52, -51, -51, -51, -51,
-49, -49, -49, -48, -48, -48, -47, -46, -46, -46, -46, -45, -45, -44, -44, -43,
-43, -42, -41, -41, -41, -40, -40, -39, -39, -38, -37, -38, -36, -36, -36, -35,
-34, -33, -34, -33, -32, -32, -30, -30, -30, -30, -30, -28, -27, -27, -27, -27,
-26, -26, -24, -24, -24, -23, -22, -22, -22, -21, -20, -20, -19, -18, -18, -17,
-17, -16, -16, -16, -14, -14, -13, -13, -12, -11, -10, -10, -10, -10, -8, -8,
-8, -6, -6, -6, -5, -4, -4, -4, -2, -1, 0, -1, 1, };