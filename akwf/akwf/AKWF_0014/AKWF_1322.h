#define DATA_LENGTH 512
#define DATA AKWF_1322

const PROGMEM int8_t DATA[DATA_LENGTH] = {81, 98, 91, 97, 92, 96, 92, 96, 93,
95, 93, 95, 94, 95, 94, 95, 93, 95, 94, 95, 94, 94, 94, 94, 95, 94, 95, 94, 94,
94, 94, 94, 94, 94, 94, 95, 94, 94, 95, 94, 94, 94, 94, 94, 94, 95, 94, 95, 94,
95, 94, 93, 95, 94, 94, 94, 94, 95, 95, 94, 94, 94, 94, 94, 94, 94, 94, 95, 94,
94, 94, 94, 94, 94, 94, 95, 95, 94, 95, 94, 95, 94, 95, 94, 94, 95, 94, 94, 94,
94, 94, 94, 94, 95, 94, 94, 94, 94, 94, 94, 94, 95, 94, 94, 95, 95, 94, 95, 95,
94, 94, 95, 94, 94, 94, 94, 95, 94, 94, 94, 94, 95, 94, 94, 94, 94, 95, 94, 94,
94, 94, 94, 94, 94, 94, 94, 94, 95, 93, 94, 94, 95, 91, 81, 80, 80, 80, 80, 80,
80, 80, 80, 80, 81, 81, 81, 80, 80, 79, 81, 80, 80, 80, 80, 80, 80, 80, 80, 80,
80, 79, 80, 81, 81, 80, 80, 80, 80, 81, 80, 81, 80, 81, 80, 81, 80, 81, 81, 81,
80, 81, 80, 81, 81, 80, 80, 80, 81, 80, 80, 80, 80, 80, 80, 80, 80, 80, 81, 80,
80, 79, 81, 80, 80, 81, 80, 80, 79, 80, 80, 80, 80, 81, 80, 80, 80, 80, 79, 81,
80, 80, 80, 81, 80, 80, 80, 80, 81, 81, 81, 80, 80, 80, 81, 79, 81, 81, 81, 80,
80, 80, 80, 79, 81, 79, 80, 80, 80, 80, 80, 81, 80, 82, 79, 81, 80, 82, 79, 82,
78, 82, 78, 83, 78, 83, 77, 83, 77, 83, 79, 82, 79, 80, 84, -94, -122, -104,
-118, -106, -116, -107, -115, -108, -114, -109, -113, -110, -113, -110, -112,
-110, -113, -111, -111, -111, -112, -112, -112, -112, -110, -112, -111, -112,
-111, -111, -111, -112, -111, -111, -111, -112, -111, -112, -111, -112, -112,
-112, -111, -112, -112, -112, -111, -112, -111, -111, -111, -111, -111, -112,
-112, -111, -112, -111, -112, -111, -111, -111, -111, -112, -111, -111, -112,
-111, -112, -112, -111, -111, -111, -110, -111, -111, -111, -111, -112, -111,
-112, -111, -111, -111, -111, -111, -112, -112, -111, -111, -112, -112, -111,
-111, -111, -111, -111, -111, -112, -111, -111, -112, -111, -111, -112, -111,
-111, -112, -111, -112, -110, -114, -101, -66, -60, -62, -60, -61, -60, -61,
-60, -61, -61, -60, -61, -61, -60, -60, -61, -61, -61, -61, -62, -61, -61, -61,
-61, -61, -61, -60, -61, -61, -61, -61, -61, -61, -60, -61, -61, -61, -61, -61,
-61, -60, -61, -61, -60, -61, -60, -60, -61, -60, -61, -61, -60, -61, -60, -61,
-61, -61, -61, -61, -61, -61, -61, -61, -61, -61, -61, -61, -60, -61, -61, -60,
-61, -61, -61, -61, -61, -61, -61, -60, -61, -60, -60, -61, -60, -61, -61, -60,
-61, -61, -62, -61, -61, -60, -61, -62, -61, -61, -61, -61, -60, -61, -60, -61,
-59, -62, -60, -62, -59, -62, -58, -63, -58, -66, -60, };