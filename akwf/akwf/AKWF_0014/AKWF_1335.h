#define DATA_LENGTH 512
#define DATA AKWF_1335

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 121, 113, 119, 114, 119, 114,
119, 115, 118, 115, 118, 115, 117, 115, 117, 116, 117, 116, 117, 116, 117, 117,
116, 116, 117, 117, 117, 116, 117, 117, 116, 117, 117, 117, 116, 117, 117, 117,
116, 117, 117, 117, 116, 117, 117, 116, 117, 116, 117, 116, 117, 116, 117, 117,
116, 116, 116, 116, 116, 116, 116, 116, 117, 117, 117, 116, 118, 117, 116, 117,
117, 117, 117, 116, 116, 117, 117, 117, 116, 117, 117, 117, 117, 116, 116, 117,
117, 117, 116, 117, 116, 117, 117, 116, 116, 117, 117, 117, 117, 117, 117, 117,
116, 116, 116, 117, 117, 116, 116, 116, 117, 116, 117, 116, 116, 116, 116, 116,
117, 116, 116, 117, 116, 117, 117, 116, 117, 116, 116, 116, 117, 116, 116, 116,
116, 116, 117, 117, 116, 117, 117, 116, 117, 117, 117, 118, 116, 118, 116, 118,
116, 117, 116, 118, 116, 118, 116, 118, 116, 117, 115, 118, 117, 117, 118, 115,
119, 112, 123, 105, 127, -17, -116, -80, -103, -87, -98, -90, -97, -91, -95,
-92, -95, -93, -94, -94, -93, -94, -93, -94, -92, -94, -93, -94, -92, -94, -92,
-95, -92, -94, -93, -93, -94, -94, -93, -94, -93, -93, -93, -93, -93, -93, -94,
-93, -93, -93, -93, -94, -94, -94, -94, -93, -94, -94, -93, -93, -93, -93, -93,
-93, -94, -93, -93, -93, -93, -93, -93, -94, -94, -93, -93, -93, -93, -94, -92,
-93, -93, -94, -93, -93, -93, -93, -94, -93, -93, -93, -93, -93, -93, -93, -93,
-93, -93, -94, -93, -93, -93, -93, -93, -93, -93, -94, -94, -93, -93, -94, -93,
-93, -93, -93, -93, -93, -94, -94, -93, -93, -94, -93, -93, -93, -94, -93, -94,
-93, -93, -92, -94, -93, -93, -93, -93, -93, -93, -93, -93, -92, -93, -94, -93,
-93, -93, -93, -94, -93, -93, -93, -93, -93, -94, -94, -93, -93, -94, -93, -93,
-93, -93, -93, -94, -94, -94, -93, -94, -93, -93, -93, -94, -89, -73, -69, -70,
-69, -70, -70, -70, -71, -70, -70, -70, -70, -70, -70, -70, -69, -69, -70, -70,
-70, -70, -69, -70, -70, -70, -70, -70, -70, -70, -70, -69, -70, -70, -71, -69,
-69, -70, -70, -70, -70, -70, -70, -70, -69, -70, -70, -69, -70, -71, -70, -69,
-70, -69, -70, -70, -69, -70, -71, -70, -70, -69, -70, -70, -70, -69, -71, -70,
-70, -70, -70, -69, -70, -70, -70, -70, -70, -70, -70, -70, -70, -70, -69, -70,
-70, -70, -70, -69, -70, -71, -70, -70, -70, -69, -70, -70, -70, -70, -70, -70,
-70, -70, -69, -70, -69, -70, -70, -70, -71, -70, -71, -69, -69, -70, -70, -69,
-69, -69, -70, -70, -70, -71, -71, -70, -70, -69, -70, -70, -70, -70, -70, -70,
-70, -70, -71, -70, -70, -71, -69, -70, -70, -70, -70, -70, -70, -70, -71, -69,
-70, -70, -69, -70, -69, -70, -70, -69, -70, -70, -71, -68, -71, -69, -71, -68,
-71, -68, -72, -68, -72, -68, -73, -66, -76, -73, };