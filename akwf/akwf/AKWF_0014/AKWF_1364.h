#define DATA_LENGTH 512
#define DATA AKWF_1364

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 8, 11, 14, 16, 19, 22, 25,
28, 30, 34, 36, 39, 43, 45, 48, 50, 53, 56, 60, 62, 65, 68, 70, 72, 75, 78, 81,
83, 85, 88, 90, 92, 94, 96, 98, 101, 103, 104, 105, 107, 109, 111, 112, 113,
114, 115, 116, 116, 117, 117, 118, 118, 119, 119, 119, 119, 119, 118, 118, 117,
117, 117, 116, 115, 113, 112, 111, 111, 109, 107, 105, 105, 102, 100, 99, 96,
94, 92, 90, 87, 85, 83, 81, 79, 76, 74, 71, 68, 65, 62, 59, 57, 53, 51, 48, 45,
42, 39, 37, 35, 31, 28, 25, 22, 20, 17, 13, 11, 8, 5, 3, 0, -3, -4, -7, -9, -11,
-15, -17, -19, -21, -24, -25, -27, -30, -32, -33, -35, -37, -38, -41, -41, -43,
-45, -46, -47, -48, -50, -50, -52, -53, -53, -55, -56, -56, -57, -58, -59, -59,
-60, -61, -61, -62, -62, -62, -63, -64, -64, -64, -64, -65, -65, -65, -65, -65,
-65, -66, -66, -66, -66, -66, -66, -66, -66, -66, -67, -67, -67, -68, -68, -68,
-67, -67, -67, -67, -67, -68, -68, -67, -68, -68, -68, -68, -68, -68, -68, -68,
-69, -68, -69, -68, -68, -69, -68, -68, -68, -67, -67, -68, -67, -67, -67, -66,
-67, -66, -65, -65, -66, -64, -64, -63, -63, -62, -61, -61, -59, -59, -58, -57,
-56, -55, -53, -52, -51, -50, -49, -46, -46, -44, -43, -41, -39, -37, -35, -33,
-31, -29, -28, -25, -22, -20, -17, -16, -14, -10, -9, -5, -3, 0, 2, 5, 8, 10,
12, 16, 19, 21, 24, 27, 29, 32, 35, 38, 40, 43, 46, 48, 52, 54, 57, 59, 62, 64,
67, 69, 72, 74, 76, 78, 80, 82, 84, 86, 88, 89, 92, 93, 95, 96, 97, 99, 100,
101, 101, 103, 103, 104, 104, 103, 105, 104, 104, 105, 105, 104, 104, 103, 102,
102, 102, 101, 100, 98, 97, 96, 95, 94, 92, 90, 89, 86, 85, 82, 81, 79, 77, 75,
72, 69, 67, 64, 62, 60, 58, 55, 52, 50, 46, 45, 42, 38, 36, 33, 31, 27, 24, 22,
19, 16, 13, 11, 8, 5, 2, 0, -3, -5, -8, -10, -13, -15, -18, -20, -22, -25, -27,
-29, -31, -33, -35, -37, -39, -40, -42, -43, -45, -47, -49, -50, -51, -53, -54,
-55, -55, -58, -58, -59, -60, -62, -61, -61, -63, -64, -64, -65, -64, -65, -65,
-66, -66, -67, -67, -67, -67, -68, -68, -68, -68, -68, -68, -68, -68, -69, -69,
-68, -69, -68, -68, -68, -67, -68, -68, -68, -68, -68, -67, -68, -67, -68, -67,
-67, -68, -66, -67, -67, -67, -67, -66, -66, -66, -66, -67, -66, -65, -66, -65,
-65, -65, -65, -64, -65, -64, -64, -64, -63, -63, -62, -62, -62, -61, -61, -61,
-60, -60, -59, -59, -58, -58, -56, -55, -54, -54, -52, -52, -51, -49, -48, -46,
-45, -45, -43, -41, -40, -38, -36, -34, -33, -31, -29, -27, -25, -24, -21, -20,
-16, -14, -11, -6, -2, };