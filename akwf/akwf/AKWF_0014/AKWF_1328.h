#define DATA_LENGTH 512
#define DATA AKWF_1328

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 13, 11, 12, 12, 12, 12, 12, 11, 12,
11, 12, 12, 12, 12, 12, 11, 11, 12, 12, 11, 12, 11, 12, 12, 12, 13, 12, 12, 12,
11, 12, 11, 11, 12, 12, 11, 12, 11, 11, 12, 12, 11, 11, 12, 11, 12, 12, 12, 11,
12, 11, 11, 12, 12, 12, 11, 13, 12, 11, 12, 11, 12, 11, 11, 12, 11, 11, 11, 12,
11, 11, 12, 12, 12, 12, 12, 12, 11, 12, 11, 11, 12, 12, 12, 12, 12, 12, 12, 12,
11, 11, 11, 11, 11, 12, 11, 12, 11, 12, 12, 11, 12, 12, 12, 12, 12, 12, 12, 12,
12, 12, 12, 12, 12, 12, 12, 12, 11, 11, 12, 11, 12, 11, 12, 10, 14, 9, 15, 6,
63, 119, 105, 113, 107, 111, 109, 110, 109, 110, 110, 110, 110, 109, 109, 109,
110, 109, 110, 110, 110, 109, 109, 110, 109, 109, 110, 110, 110, 109, 109, 110,
110, 110, 110, 110, 109, 110, 110, 110, 110, 110, 110, 110, 110, 110, 110, 110,
110, 110, 109, 110, 110, 109, 109, 110, 109, 109, 110, 109, 109, 109, 110, 109,
110, 109, 109, 109, 110, 110, 110, 110, 110, 109, 110, 109, 110, 109, 110, 109,
109, 109, 110, 110, 109, 109, 110, 110, 109, 110, 109, 111, 109, 110, 109, 110,
110, 110, 109, 110, 110, 110, 110, 109, 110, 109, 109, 109, 110, 110, 111, 108,
110, 108, 111, 108, 112, 108, 111, 106, 112, 107, 113, 106, 114, 109, -28, -35,
-29, -35, -29, -34, -30, -34, -29, -34, -31, -34, -31, -33, -31, -33, -31, -34,
-32, -32, -33, -33, -32, -32, -33, -32, -32, -32, -33, -32, -32, -33, -33, -32,
-33, -31, -32, -32, -33, -32, -32, -32, -32, -32, -32, -32, -33, -33, -33, -32,
-33, -32, -32, -33, -33, -32, -32, -32, -32, -32, -33, -32, -32, -33, -32, -32,
-33, -32, -33, -33, -32, -33, -32, -33, -32, -33, -32, -32, -32, -32, -33, -32,
-33, -33, -32, -32, -32, -33, -32, -32, -32, -32, -32, -33, -32, -32, -33, -32,
-33, -33, -32, -33, -32, -32, -32, -32, -32, -33, -33, -32, -33, -31, -33, -33,
-32, -32, -32, -33, -32, -33, -31, -33, -31, -33, -30, -35, -29, -37, -23, -56,
-112, -100, -106, -102, -105, -102, -104, -104, -104, -104, -103, -104, -102,
-104, -103, -104, -103, -104, -102, -104, -103, -103, -103, -103, -103, -103,
-102, -104, -103, -103, -103, -104, -104, -103, -103, -104, -104, -104, -103,
-103, -104, -104, -103, -103, -103, -103, -104, -103, -103, -103, -104, -103,
-103, -104, -103, -104, -103, -104, -103, -103, -104, -104, -103, -103, -103,
-103, -103, -103, -103, -103, -103, -103, -103, -104, -103, -103, -104, -103,
-104, -104, -103, -103, -104, -104, -104, -103, -103, -104, -103, -104, -103,
-104, -103, -104, -103, -104, -103, -104, -104, -104, -104, -104, -103, -104,
-103, -103, -104, -103, -103, -103, -104, -103, -104, -102, -105, -102, -106,
-102, -106, -101, -106, -100, -107, -98, -110, -96, };