#define DATA_LENGTH 512
#define DATA AKWF_1308

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 21, 19, 20, 21, 23, 25, 28, 31, 34,
37, 39, 42, 45, 48, 50, 53, 55, 58, 60, 62, 65, 67, 69, 71, 73, 75, 77, 79, 81,
83, 84, 85, 87, 89, 91, 92, 93, 95, 97, 98, 98, 100, 102, 103, 104, 105, 105,
107, 107, 108, 109, 110, 111, 111, 112, 113, 113, 114, 114, 114, 115, 115, 116,
116, 116, 116, 116, 117, 117, 118, 118, 118, 118, 119, 117, 118, 118, 119, 119,
119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 119,
117, 118, 118, 117, 117, 116, 117, 117, 115, 115, 115, 115, 114, 114, 113, 113,
112, 112, 111, 110, 110, 108, 108, 107, 107, 106, 105, 104, 103, 102, 101, 99,
98, 96, 94, 93, 92, 91, 90, 89, 87, 86, 84, 84, 81, 80, 79, 78, 77, 76, 74, 72,
71, 70, 69, 68, 67, 66, 65, 64, 62, 61, 61, 58, 57, 56, 55, 54, 52, 52, 50, 49,
48, 46, 45, 45, 42, 42, 40, 39, 38, 37, 36, 34, 33, 31, 31, 30, 28, 28, 26, 25,
24, 23, 22, 21, 20, 19, 17, 17, 15, 15, 14, 13, 12, 11, 10, 9, 8, 7, 6, 5, 5, 3,
2, 2, 1, -1, -1, -3, -4, -4, -5, -6, -8, -9, -9, -10, -11, -12, -13, -14, -15,
-16, -17, -17, -18, -18, -19, -19, -20, -21, -21, -22, -23, -23, -24, -25, -25,
-26, -27, -27, -29, -29, -30, -30, -31, -32, -32, -34, -34, -35, -36, -36, -38,
-38, -39, -39, -40, -41, -42, -43, -44, -44, -45, -45, -46, -48, -48, -48, -49,
-50, -50, -52, -52, -52, -54, -54, -56, -56, -56, -57, -58, -59, -59, -59, -60,
-61, -61, -61, -62, -63, -63, -64, -65, -65, -65, -66, -66, -67, -67, -68, -69,
-68, -69, -69, -70, -70, -70, -71, -71, -71, -72, -72, -72, -72, -73, -73, -72,
-73, -74, -73, -73, -74, -74, -73, -74, -74, -74, -74, -74, -75, -74, -75, -75,
-75, -75, -75, -76, -75, -76, -76, -76, -76, -76, -77, -77, -76, -78, -76, -77,
-76, -77, -78, -77, -77, -77, -77, -77, -77, -77, -77, -77, -77, -77, -77, -77,
-77, -76, -75, -76, -76, -75, -75, -75, -74, -74, -73, -73, -72, -70, -70, -69,
-68, -69, -67, -68, -67, -66, -65, -65, -64, -63, -63, -62, -61, -61, -61, -60,
-60, -58, -58, -58, -57, -57, -57, -55, -56, -55, -55, -55, -54, -54, -53, -53,
-52, -51, -51, -50, -50, -49, -49, -49, -48, -47, -47, -46, -47, -46, -45, -45,
-44, -43, -43, -43, -42, -41, -42, -41, -40, -40, -39, -39, -39, -38, -37, -37,
-36, -35, -36, -35, -33, -33, -34, -33, -32, -31, -31, -31, -30, -30, -29, -27,
-27, -27, -27, -25, -25, -24, -24, -23, -23, -22, -22, -21, -20, -20, -19, -18,
-18, -17, -16, -16, -15, -14, -14, -13, -13, -12, -11, -10, -9, -9, -8, -8, -8,
-7, -6, -7, -5, -5, -5, -5, -3, -4, -3, };