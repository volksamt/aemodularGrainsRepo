#define DATA_LENGTH 512
#define DATA AKWF_1340

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 5, 6, 9, 11, 14, 17, 20, 24,
28, 31, 36, 40, 45, 49, 53, 58, 63, 68, 72, 78, 82, 86, 90, 95, 99, 102, 105,
109, 110, 113, 115, 116, 117, 118, 119, 119, 118, 118, 118, 117, 116, 114, 113,
110, 108, 106, 104, 102, 100, 97, 95, 93, 89, 87, 85, 84, 81, 79, 76, 75, 74,
72, 71, 70, 69, 67, 66, 65, 64, 64, 63, 63, 62, 61, 61, 60, 59, 59, 59, 59, 57,
56, 56, 55, 53, 53, 52, 50, 48, 48, 45, 43, 40, 38, 36, 33, 31, 27, 24, 21, 17,
15, 11, 8, 4, 1, -2, -4, -7, -10, -14, -16, -19, -22, -23, -25, -27, -28, -29,
-30, -32, -32, -32, -33, -32, -32, -33, -33, -32, -32, -32, -31, -31, -31, -30,
-30, -29, -29, -29, -28, -28, -28, -27, -27, -27, -28, -27, -27, -27, -27, -27,
-28, -28, -28, -29, -29, -29, -30, -30, -31, -32, -32, -32, -34, -35, -35, -37,
-37, -38, -40, -41, -42, -44, -45, -47, -49, -50, -52, -54, -56, -58, -59, -62,
-63, -65, -65, -66, -66, -68, -67, -67, -68, -66, -67, -65, -65, -62, -61, -59,
-57, -55, -52, -49, -47, -44, -41, -37, -34, -32, -27, -24, -22, -19, -15, -13,
-10, -6, -4, -1, 1, 3, 6, 8, 10, 12, 13, 15, 16, 17, 17, 19, 19, 19, 20, 20, 20,
20, 20, 20, 20, 19, 19, 19, 18, 17, 17, 15, 15, 13, 14, 13, 13, 12, 11, 11, 10,
10, 9, 10, 9, 8, 8, 8, 8, 9, 8, 9, 9, 8, 9, 9, 8, 9, 8, 7, 8, 7, 7, 6, 3, 2, 1,
-1, -2, -5, -7, -9, -11, -14, -17, -20, -23, -25, -28, -32, -34, -37, -41, -43,
-46, -48, -50, -53, -55, -56, -58, -60, -60, -61, -63, -63, -64, -64, -63, -63,
-62, -61, -61, -60, -59, -58, -56, -55, -53, -52, -50, -48, -46, -44, -43, -40,
-40, -38, -36, -35, -33, -31, -30, -30, -28, -28, -26, -25, -24, -23, -23, -23,
-22, -22, -23, -22, -23, -23, -24, -27, -28, -28, -30, -32, -34, -35, -37, -39,
-41, -43, -46, -47, -50, -51, -52, -53, -55, -55, -56, -56, -57, -57, -57, -56,
-56, -55, -54, -53, -51, -50, -48, -47, -46, -43, -40, -39, -36, -35, -33, -30,
-29, -27, -25, -23, -22, -20, -18, -18, -16, -15, -14, -13, -12, -11, -12, -11,
-10, -11, -11, -10, -10, -11, -10, -10, -10, -10, -11, -11, -12, -12, -13, -13,
-13, -14, -15, -15, -16, -15, -16, -16, -17, -16, -16, -16, -15, -15, -15, -15,
-13, -12, -11, -11, -10, -8, -6, -4, -4, -2, -1, 1, 3, 5, 6, 8, 10, 12, 13, 14,
16, 17, 17, 19, 20, 20, 21, 22, 22, 22, 22, 23, 23, 22, 22, 22, 21, 20, 19, 19,
17, 17, 16, 14, 13, 12, 11, 9, 9, 7, 6, 4, 3, 2, 1, 1, 0, -1, -1, -2, -1, -2,
-3, -2, -2, -1, };