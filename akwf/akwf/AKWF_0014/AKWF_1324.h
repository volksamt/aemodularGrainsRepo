#define DATA_LENGTH 512
#define DATA AKWF_1324

const PROGMEM int8_t DATA[DATA_LENGTH] = {78, 91, 84, 90, 85, 89, 85, 88, 85,
88, 85, 87, 86, 87, 86, 88, 86, 87, 86, 87, 87, 86, 87, 86, 87, 86, 87, 86, 87,
86, 87, 87, 87, 86, 86, 86, 87, 87, 86, 87, 87, 87, 87, 87, 86, 87, 86, 86, 86,
87, 87, 86, 87, 87, 86, 87, 86, 87, 87, 86, 87, 87, 87, 87, 87, 87, 87, 86, 87,
87, 87, 87, 87, 87, 87, 86, 87, 87, 87, 87, 87, 86, 87, 86, 87, 87, 86, 87, 87,
87, 87, 86, 86, 87, 87, 86, 86, 87, 86, 87, 86, 87, 87, 86, 86, 86, 86, 86, 86,
87, 87, 87, 87, 86, 86, 87, 87, 86, 87, 86, 87, 87, 86, 87, 87, 87, 87, 87, 86,
86, 87, 86, 87, 87, 87, 87, 87, 86, 87, 86, 87, 85, 88, 78, 73, 75, 74, 74, 74,
74, 73, 74, 73, 73, 74, 74, 73, 73, 74, 74, 73, 74, 73, 74, 74, 73, 74, 74, 74,
74, 74, 74, 75, 74, 73, 73, 74, 74, 73, 74, 75, 74, 74, 74, 73, 74, 74, 74, 74,
73, 73, 73, 75, 74, 75, 74, 73, 74, 74, 74, 74, 74, 74, 74, 74, 74, 74, 73, 73,
74, 74, 74, 74, 74, 74, 74, 74, 73, 74, 74, 73, 74, 74, 74, 74, 74, 75, 73, 74,
74, 74, 74, 74, 74, 73, 73, 74, 74, 74, 74, 73, 73, 74, 74, 74, 74, 74, 74, 73,
74, 73, 74, 73, 74, 73, 74, 74, 73, 74, 74, 74, 74, 74, 73, 75, 73, 75, 73, 76,
71, 76, 71, 76, 71, 75, 71, 76, 70, 76, 71, 75, 72, 73, 77, -94, -113, -95,
-108, -97, -107, -98, -106, -98, -106, -100, -105, -100, -104, -101, -103, -101,
-103, -102, -102, -102, -102, -103, -102, -102, -102, -103, -102, -103, -102,
-103, -101, -103, -102, -103, -102, -103, -102, -103, -102, -102, -102, -102,
-102, -103, -103, -102, -102, -103, -102, -102, -102, -102, -102, -103, -102,
-102, -102, -102, -102, -102, -102, -102, -102, -102, -103, -103, -103, -101,
-102, -102, -103, -102, -103, -102, -103, -102, -102, -103, -102, -103, -102,
-102, -103, -102, -103, -102, -103, -103, -102, -103, -103, -102, -102, -102,
-101, -103, -102, -102, -103, -102, -102, -103, -102, -102, -102, -102, -102,
-102, -103, -101, -103, -100, -105, -72, -51, -59, -54, -57, -54, -57, -55, -56,
-56, -56, -56, -56, -56, -56, -56, -56, -56, -55, -57, -56, -56, -56, -56, -56,
-55, -56, -57, -56, -56, -55, -56, -56, -55, -55, -56, -55, -56, -56, -56, -56,
-57, -57, -56, -56, -56, -56, -55, -56, -55, -56, -56, -55, -56, -55, -55, -56,
-56, -56, -56, -56, -56, -55, -55, -56, -56, -56, -56, -56, -56, -55, -56, -56,
-56, -56, -56, -55, -56, -55, -56, -55, -56, -56, -56, -56, -56, -56, -57, -56,
-56, -56, -56, -56, -56, -56, -56, -56, -56, -55, -56, -57, -56, -56, -55, -57,
-55, -57, -55, -57, -54, -57, -54, -59, -47, };