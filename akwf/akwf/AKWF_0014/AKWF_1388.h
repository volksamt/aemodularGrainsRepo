#define DATA_LENGTH 512
#define DATA AKWF_1388

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 12, 15, 19, 22, 25, 28,
30, 35, 37, 40, 44, 60, 77, 90, 100, 107, 111, 114, 116, 118, 118, 117, 117,
116, 114, 112, 111, 108, 107, 103, 100, 97, 94, 91, 88, 84, 80, 76, 73, 69, 66,
62, 58, 55, 52, 48, 45, 42, 40, 37, 36, 34, 32, 31, 30, 28, 30, 28, 28, 29, 28,
29, 29, 31, 31, 33, 34, 35, 36, 38, 39, 41, 43, 46, 46, 49, 50, 52, 53, 55, 56,
58, 60, 60, 62, 64, 65, 66, 67, 69, 69, 71, 72, 73, 72, 74, 75, 74, 76, 76, 76,
77, 76, 77, 77, 78, 76, 79, 76, 50, 28, 12, 1, -5, -9, -10, -12, -11, -10, -7,
-5, -1, 2, 7, 10, 14, 18, 23, 27, 30, 34, 37, 41, 43, 46, 49, 51, 54, 56, 57,
59, 62, 63, 65, 65, 66, 66, 66, 66, 65, 64, 62, 59, 57, 54, 52, 47, 44, 41, 37,
33, 28, 24, 20, 15, 12, 6, 3, -3, -7, -11, -16, -21, -25, -29, -34, -39, -43,
-46, -51, -54, -58, -61, -64, -69, -71, -74, -77, -80, -83, -85, -88, -90, -92,
-96, -97, -98, -100, -102, -104, -106, -107, -108, -110, -110, -110, -112, -113,
-113, -114, -116, -116, -117, -117, -118, -118, -118, -118, -117, -118, -119,
-118, -118, -117, -118, -113, -95, -82, -71, -64, -60, -58, -58, -57, -59, -59,
-61, -64, -65, -67, -69, -71, -72, -75, -77, -78, -79, -82, -83, -85, -87, -89,
-91, -93, -94, -95, -97, -99, -100, -102, -104, -104, -105, -105, -106, -105,
-106, -105, -105, -104, -103, -102, -101, -99, -105, -112, -117, -118, -118,
-118, -117, -115, -113, -109, -105, -101, -97, -94, -89, -85, -80, -76, -70,
-65, -61, -56, -51, -46, -41, -36, -31, -27, -23, -19, -14, -11, -7, -4, -2, 2,
4, 6, 9, 10, 11, 13, 15, 15, 16, 16, 17, 16, 17, 17, 17, 16, 15, 14, 13, 13, 11,
10, 9, 8, 6, 5, 4, 1, 0, -2, -2, -4, -6, -7, -9, -11, -11, -13, -14, -15, -16,
-18, -20, -20, -22, -23, -24, -25, -26, -27, -28, -28, -30, -31, -31, -31, -32,
-33, -33, -34, -35, -36, -36, -37, -36, -37, -38, -38, -38, -38, -38, -39, -39,
-40, -40, -39, -39, -38, -39, -38, -38, -38, -38, -38, -37, -37, -37, -36, -35,
-36, -35, -34, -34, -33, -31, -32, -32, -30, -30, -28, -27, -27, -27, -25, -26,
-23, -24, -23, -22, -21, -21, -20, -19, -19, -18, -17, -16, -16, -14, -14, -13,
-12, -11, -11, -10, -7, -6, -5, -2, -1, 2, 4, 6, 7, 9, 11, 13, 13, 15, 16, 17,
19, 18, 21, 21, 21, 22, 23, 23, 24, 24, 24, 24, 25, 25, 24, 24, 25, 24, 24, 24,
23, 23, 22, 23, 23, 22, 21, 21, 20, 20, 20, 20, 20, 19, 19, 19, 19, 20, 19, 19,
18, 9, 1, -7, -11, -15, -16, -16, -16, -15, -14, -11, -10, -8, -6, -3, -2, };