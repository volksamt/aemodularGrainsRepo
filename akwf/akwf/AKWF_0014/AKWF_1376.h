#define DATA_LENGTH 512
#define DATA AKWF_1376

const PROGMEM int8_t DATA[DATA_LENGTH] = {13, 36, 6, 12, 16, 20, 27, 30, 36, 39,
43, 45, 50, 50, 54, 56, 58, 60, 63, 63, 66, 66, 68, 69, 71, 71, 71, 73, 72, 73,
73, 73, 73, 74, 74, 74, 75, 75, 74, 75, 75, 76, 75, 76, 75, 76, 76, 76, 75, 76,
76, 76, 76, 76, 76, 76, 76, 77, 77, 77, 79, 78, 80, 80, 81, 81, 83, 83, 84, 84,
85, 85, 85, 86, 86, 86, 86, 86, 85, 85, 84, 84, 83, 83, 83, 82, 82, 80, 79, 79,
78, 77, 75, 75, 73, 72, 70, 69, 68, 67, 65, 64, 62, 59, 58, 56, 54, 51, 49, 46,
44, 42, 39, 36, 33, 30, 28, 26, 23, 21, 19, 17, 15, 12, 11, 9, 9, 6, 6, 5, 3, 2,
1, 1, 0, -1, -2, -2, -3, -2, -3, -3, -3, -3, -5, -4, -5, -5, -5, -6, -5, -6, -5,
-6, -6, -5, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -6, -7, -7, -7, -7, -8, -8,
-10, -9, -10, -11, -11, -12, -13, -13, -13, -14, -14, -15, -14, -15, -15, -14,
-15, -15, -14, -14, -14, -13, -12, -12, -12, -10, -10, -9, -8, -8, -7, -6, -7,
-5, -6, -4, -5, -3, -3, -2, 0, 1, 2, 2, 3, 4, 7, 9, 10, 10, 12, 13, 16, 17, 18,
19, 22, 23, 24, 25, 26, 27, 28, 29, 31, 31, 32, 32, 33, 34, 34, 35, 36, 37, 37,
39, 39, 40, 42, 43, 44, 45, 46, 47, 48, 49, 51, 52, 52, 53, 54, 54, 55, 55, 55,
55, 56, 55, 55, 55, 54, 54, 54, 53, 52, 52, 53, 52, 65, 73, 71, 72, 71, 71, 70,
71, 70, 70, 70, 69, 69, 69, 68, 69, 68, 66, 66, 65, 64, 63, 63, 62, 61, 60, 57,
58, 56, 55, 53, 52, 51, 51, 49, 49, 48, 47, 46, 46, 44, 45, 44, 43, 41, 40, 40,
38, 38, 36, 35, 47, 51, 48, 48, 45, 44, 43, 41, 40, 38, 37, 35, 34, 33, 32, 32,
31, 30, 29, 27, 26, 26, 25, 23, 22, 22, 21, 19, 17, 16, 14, 13, 12, 10, 9, 6, 5,
4, 2, 0, -1, -3, -4, -6, -7, -9, -10, -10, -12, -13, -15, -15, -17, -17, -18,
-19, -22, -22, -23, -24, -26, -28, -29, -30, -33, -35, -37, -38, -40, -43, -44,
-47, -48, -50, -52, -53, -55, -56, -56, -58, -59, -60, -61, -62, -63, -63, -65,
-65, -65, -66, -67, -69, -69, -70, -70, -72, -71, -73, -74, -75, -75, -78, -77,
-79, -80, -80, -80, -82, -82, -82, -82, -82, -83, -82, -83, -84, -83, -83, -83,
-83, -83, -82, -83, -83, -84, -85, -87, -89, -91, -94, -97, -100, -102, -105,
-107, -111, -113, -115, -115, -117, -118, -118, -119, -119, -120, -119, -119,
-118, -117, -116, -115, -113, -111, -109, -107, -103, -102, -98, -95, -93, -90,
-87, -83, -80, -76, -73, -69, -63, -60, -55, -49, -44, -39, -34, -28, -23, -18,
-14, -8, -5, };