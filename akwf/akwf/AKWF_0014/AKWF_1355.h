#define DATA_LENGTH 512
#define DATA AKWF_1355

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 33, 46, 55, 63, 69, 76, 80, 85, 88,
91, 95, 99, 100, 103, 105, 107, 109, 110, 112, 112, 114, 115, 116, 116, 117,
118, 118, 119, 119, 120, 120, 119, 119, 119, 119, 118, 118, 118, 118, 117, 117,
116, 115, 115, 114, 112, 112, 111, 110, 110, 108, 108, 107, 106, 105, 104, 103,
101, 101, 99, 98, 97, 95, 93, 93, 92, 91, 89, 89, 86, 84, 84, 82, 81, 79, 78,
77, 75, 73, 73, 70, 69, 67, 66, 65, 63, 62, 60, 58, 57, 55, 54, 53, 51, 49, 48,
46, 45, 44, 41, 41, 38, 37, 35, 34, 33, 31, 29, 27, 26, 24, 23, 22, 20, 18, 17,
15, 14, 12, 10, 9, 8, 7, 5, 3, 3, 0, -1, -2, -4, -5, -8, -9, -10, -12, -13, -14,
-15, -17, -18, -20, -21, -23, -23, -25, -27, -28, -29, -29, -32, -33, -34, -35,
-36, -38, -40, -40, -42, -43, -44, -44, -47, -48, -49, -50, -52, -52, -54, -55,
-56, -56, -58, -59, -60, -61, -63, -64, -65, -65, -67, -68, -69, -69, -70, -71,
-73, -73, -75, -75, -76, -77, -78, -79, -80, -80, -82, -82, -83, -84, -85, -85,
-87, -88, -88, -89, -90, -90, -91, -92, -92, -93, -93, -95, -96, -96, -96, -98,
-97, -98, -100, -100, -100, -101, -102, -103, -103, -103, -104, -105, -106,
-106, -106, -107, -107, -107, -109, -109, -110, -109, -109, -111, -110, -110,
-111, -112, -112, -113, -112, -114, -113, -113, -114, -114, -114, -114, -115,
-116, -116, -116, -117, -117, -117, -117, -117, -118, -118, -117, -117, -118,
-118, -118, -118, -118, -119, -119, -119, -118, -118, -118, -119, -119, -118,
-118, -119, -119, -119, -119, -119, -119, -120, -118, -119, -119, -118, -119,
-118, -119, -118, -118, -118, -118, -118, -119, -118, -117, -117, -117, -116,
-117, -117, -117, -116, -116, -117, -116, -116, -115, -115, -116, -115, -114,
-114, -115, -114, -114, -114, -113, -113, -112, -111, -112, -111, -111, -110,
-111, -109, -110, -109, -109, -109, -108, -108, -108, -107, -107, -107, -106,
-106, -105, -104, -104, -104, -103, -103, -102, -103, -102, -101, -101, -100,
-99, -99, -99, -98, -98, -98, -97, -96, -96, -95, -95, -94, -94, -93, -92, -92,
-92, -91, -90, -89, -89, -89, -89, -88, -87, -87, -86, -85, -84, -83, -83, -83,
-83, -82, -81, -80, -80, -79, -79, -78, -77, -77, -76, -76, -75, -74, -74, -72,
-72, -71, -71, -70, -69, -69, -69, -67, -67, -66, -65, -65, -64, -64, -63, -62,
-62, -61, -59, -60, -58, -58, -57, -57, -56, -55, -55, -55, -54, -53, -52, -50,
-51, -49, -49, -49, -47, -46, -46, -45, -44, -44, -42, -42, -42, -41, -41, -39,
-39, -39, -38, -36, -35, -35, -34, -34, -33, -32, -31, -30, -30, -29, -29, -28,
-27, -26, -26, -24, -24, -23, -22, -22, -22, -20, -19, -19, -18, -17, -16, -16,
-14, -15, -14, -13, -12, -12, -11, -10, -9, -8, -8, -6, -6, -5, -4, -4, -4, -1,
-2, 0, 0, 0, 1, };