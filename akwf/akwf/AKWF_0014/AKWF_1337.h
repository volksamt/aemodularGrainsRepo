#define DATA_LENGTH 512
#define DATA AKWF_1337

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 57, 57, 56, 58, 57, 58, 56, 58, 55,
58, 56, 58, 57, 58, 56, 58, 57, 54, 49, 46, 45, 43, 36, 27, 18, 10, 0, -3, 0, 1,
3, 5, 8, 9, 11, 12, 13, 15, 16, 18, 19, 19, 21, 21, 23, 24, 25, 26, 27, 28, 28,
30, 30, 32, 32, 33, 33, 35, 35, 36, 37, 37, 37, 39, 40, 40, 41, 41, 41, 42, 42,
43, 43, 44, 44, 45, 45, 47, 46, 46, 47, 48, 47, 49, 49, 49, 49, 50, 50, 50, 50,
50, 52, 51, 51, 51, 51, 52, 52, 53, 53, 53, 52, 54, 53, 52, 53, 53, 53, 53, 53,
53, 53, 53, 53, 53, 53, 54, 53, 54, 54, 54, 53, 54, 54, 54, 55, 54, 54, 54, 54,
55, 55, 54, 55, 54, 55, 54, 55, 55, 55, 55, 55, 55, 54, 55, 54, 55, 55, 55, 55,
55, 55, 55, 55, 55, 56, 54, 55, 55, 55, 55, 55, 55, 55, 55, 55, 55, 55, 55, 55,
55, 56, 55, 56, 55, 56, 55, 55, 55, 56, 56, 55, 56, 54, 56, 54, 60, 28, -45,
-111, -122, -117, -121, -117, -120, -118, -120, -118, -120, -118, -120, -118,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -120, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -118, -119, -118, -120, -119, -119, -119, -119, -119, -119, -118, -118,
-120, -119, -118, -118, -118, -118, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-118, -119, -118, -119, -117, -108, -100, -89, -77, -64, -54, -42, -35, -32,
-28, -25, -23, -20, -20, -15, -12, -9, -7, -3, -1, 2, 3, 5, 7, 9, 12, 13, 15,
17, 18, 19, 22, 22, 24, 25, 26, 27, 29, 30, 31, 31, 33, 34, 35, 35, 37, 37, 38,
39, 39, 40, 41, 42, 42, 43, 43, 44, 45, 45, 46, 46, 46, 46, 47, 48, 48, 48, 48,
50, 50, 50, 50, 50, 51, 51, 51, 52, 51, 52, 52, 52, 52, 52, 53, 53, 53, 54, 53,
53, 53, 54, 54, 54, 54, 53, 53, 53, 54, 54, 53, 54, 53, 54, 54, 54, 54, 54, 54,
55, 55, 55, 54, 54, 55, 56, 55, 54, 55, 55, 54, 55, 55, 55, 55, 54, 55, 55, 55,
55, 56, 55, 55, 56, 56, 55, 55, 55, 56, 56, 55, 56, 55, 55, 55, 55, 55, 55, 56,
56, 55, 55, 56, 56, 56, 55, 56, 56, 56, 55, 57, 55, 55, 56, 56, 55, 56, 56, 56,
55, 57, 55, 57, 55, 56, 56, 56, 56, 56, 56, 56, 57, 56, 57, 56, 58, 54, 60, 34,
-38, -107, -123, -117, -120, -118, -119, -118, -119, -119, -118, -118, -119,
-119, -118, -119, -119, -119, -119, -119, -118, -120, -119, -120, -118, -120,
-119, -119, -119, -120, -118, -118, -119, -119, -119, -118, -120, -117, -120,
-117, -120, -117, -121, -116, -121, -115, -123, -114, -127, -100, };