#define DATA_LENGTH 512
#define DATA AKWF_1303

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 3, 3, 5, 5, 7, 9, 9, 10, 12,
12, 14, 16, 16, 18, 19, 20, 22, 22, 23, 25, 26, 27, 28, 28, 30, 31, 33, 34, 34,
35, 36, 37, 38, 39, 39, 40, 39, 40, 41, 42, 42, 43, 44, 44, 45, 45, 45, 45, 46,
46, 47, 47, 48, 48, 49, 49, 48, 48, 49, 49, 49, 48, 48, 49, 48, 48, 48, 46, 47,
47, 46, 46, 47, 46, 45, 45, 45, 44, 44, 44, 45, 44, 44, 44, 44, 44, 44, 45, 45,
45, 46, 45, 45, 47, 47, 47, 47, 47, 47, 48, 49, 48, 49, 50, 51, 51, 52, 51, 53,
53, 54, 55, 54, 55, 56, 56, 57, 58, 57, 57, 58, 59, 59, 60, 61, 60, 61, 63, 63,
63, 63, 65, 65, 66, 66, 66, 67, 68, 67, 68, 69, 69, 68, 69, 69, 71, 71, 71, 71,
71, 72, 72, 73, 74, 73, 74, 74, 74, 74, 74, 75, 75, 74, 75, 76, 75, 77, 77, 77,
76, 77, 77, 77, 78, 78, 77, 78, 77, 77, 77, 77, 77, 77, 77, 76, 77, 76, 75, 75,
75, 74, 75, 74, 73, 73, 73, 71, 71, 71, 70, 69, 69, 69, 68, 66, 66, 64, 64, 62,
65, 66, 55, 53, 55, 52, 53, 52, 51, 50, 48, 47, 44, 43, 41, 39, 37, 35, 33, 31,
28, 26, 23, 22, 18, 17, 13, 11, 7, 8, 3, 5, -3, -39, -39, -40, -41, -42, -45,
-45, -47, -47, -49, -50, -53, -52, -55, -54, -56, -56, -58, -57, -59, -57, -60,
-57, -62, -58, -61, -58, -64, -87, -54, -56, -58, -57, -60, -58, -61, -60, -62,
-62, -64, -63, -65, -64, -66, -66, -66, -66, -68, -68, -68, -67, -68, -68, -69,
-70, -70, -70, -70, -70, -70, -71, -71, -71, -71, -72, -71, -72, -71, -71, -71,
-71, -71, -71, -71, -72, -71, -70, -70, -70, -70, -70, -69, -70, -68, -68, -67,
-68, -68, -67, -68, -67, -66, -65, -65, -64, -65, -63, -64, -63, -64, -62, -63,
-60, -64, -60, -63, -60, -62, -59, -61, -60, -60, -59, -56, -107, -62, -50, -58,
-51, -57, -52, -56, -52, -57, -52, -55, -52, -53, -50, -52, -50, -49, -49, -47,
-45, -45, -45, -44, -43, -44, -43, -42, -43, -41, -41, -40, -41, -40, -39, -40,
-39, -39, -39, -38, -39, -38, -38, -38, -39, -37, -38, -39, -39, -40, -39, -41,
-41, -41, -40, -41, -42, -42, -42, -42, -43, -43, -43, -44, -44, -45, -44, -44,
-44, -44, -45, -44, -44, -44, -44, -43, -44, -44, -44, -43, -43, -44, -42, -42,
-42, -42, -42, -41, -40, -41, -41, -40, -40, -39, -38, -39, -38, -39, -38, -37,
-36, -36, -35, -35, -34, -34, -33, -33, -32, -32, -31, -30, -30, -29, -28, -27,
-27, -26, -25, -24, -24, -23, -22, -22, -20, -19, -19, -17, -17, -16, -15, -15,
-14, -14, -13, -12, -12, -10, -9, -9, -7, -7, -5, -5, -4, -4, -4, -2, -2, -1,
-1, -1, 0, };