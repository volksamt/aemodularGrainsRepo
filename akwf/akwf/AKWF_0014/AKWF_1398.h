#define DATA_LENGTH 512
#define DATA AKWF_1398

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 3, 4, 5, 5, 6, 7, 8, 9, 11, 11,
12, 13, 14, 15, 16, 17, 19, 19, 20, 21, 23, 24, 25, 26, 27, 28, 29, 30, 32, 33,
33, 35, 35, 37, 38, 40, 41, 42, 43, 46, 46, 47, 49, 50, 51, 51, 54, 55, 56, 57,
58, 59, 60, 62, 62, 63, 66, 65, 68, 69, 69, 71, 73, 73, 75, 76, 77, 78, 79, 81,
82, 83, 85, 86, 87, 89, 90, 92, 93, 93, 95, 98, 99, 100, 102, 102, 103, 104,
105, 107, 107, 107, 109, 110, 111, 111, 111, 112, 113, 113, 114, 114, 115, 115,
116, 116, 116, 116, 116, 117, 118, 118, 118, 117, 118, 117, 118, 118, 119, 118,
118, 118, 119, 119, 118, 120, 118, 120, 118, 120, 117, 121, 117, 121, 115, 121,
114, 126, 100, 12, 4, -6, -4, -4, -5, -4, -7, -5, -7, -6, -8, -7, -9, -8, -10,
-10, -11, -10, -12, -13, -14, -14, -16, -16, -17, -17, -18, -17, -18, -19, -20,
-21, -21, -22, -23, -24, -24, -25, -25, -26, -26, -27, -28, -27, -28, -28, -29,
-30, -31, -32, -31, -33, -32, -33, -34, -35, -35, -36, -36, -36, -37, -38, -38,
-39, -39, -40, -40, -40, -42, -42, -42, -43, -44, -43, -44, -44, -45, -45, -46,
-46, -48, -47, -48, -48, -49, -50, -49, -50, -51, -51, -52, -51, -52, -53, -53,
-54, -55, -54, -55, -56, -57, -58, -58, -58, -58, -58, -59, -60, -60, -61, -61,
-62, -62, -64, -64, -65, -65, -66, -66, -67, -67, -68, -68, -70, -70, -68, -72,
-72, -74, -72, -76, -72, -78, -71, -81, -69, -86, -54, 12, 61, 127, 110, 119,
115, 117, 115, 115, 115, 114, 115, 113, 114, 111, 113, 110, 112, 109, 110, 108,
109, 107, 107, 106, 105, 105, 103, 102, 102, 99, 98, 98, 96, 96, 94, 92, 91, 89,
88, 86, 84, 83, 82, 79, 77, 76, 75, 72, 70, 69, 66, 64, 61, 60, 57, 55, 52, 51,
46, 46, 41, 41, 35, 37, 28, 32, 22, 31, 1, -83, -73, -78, -76, -77, -78, -77,
-77, -77, -78, -75, -78, -76, -77, -76, -78, -77, -77, -75, -77, -76, -77, -76,
-77, -76, -77, -75, -76, -76, -76, -76, -74, -76, -75, -74, -74, -74, -74, -75,
-74, -75, -74, -74, -74, -74, -73, -73, -73, -73, -73, -73, -73, -72, -72, -72,
-71, -70, -71, -70, -71, -71, -70, -70, -69, -69, -68, -68, -67, -67, -67, -67,
-66, -66, -65, -64, -64, -63, -63, -62, -62, -61, -60, -60, -59, -58, -59, -58,
-57, -56, -56, -54, -54, -54, -53, -52, -51, -50, -50, -50, -49, -47, -48, -46,
-45, -45, -44, -43, -42, -42, -40, -40, -39, -39, -38, -37, -36, -35, -34, -33,
-33, -32, -32, -30, -29, -29, -29, -28, -27, -27, -25, -25, -24, -24, -23, -22,
-22, -21, -20, -20, -19, -18, -18, -16, -17, -15, -15, -14, -14, -12, -12, -10,
-9, -8, -9, -6, -5, -5, -4, -2, -2, -1, 0, };