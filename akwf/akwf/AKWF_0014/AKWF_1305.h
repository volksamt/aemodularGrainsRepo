#define DATA_LENGTH 512
#define DATA AKWF_1305

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 11, 15, 20, 24, 27, 32, 35, 37,
41, 43, 46, 49, 52, 54, 55, 57, 59, 60, 62, 63, 65, 67, 68, 68, 69, 71, 71, 72,
74, 74, 75, 76, 76, 76, 79, 79, 79, 80, 81, 80, 81, 82, 83, 83, 84, 83, 84, 85,
85, 85, 86, 86, 86, 87, 87, 87, 87, 87, 88, 88, 88, 88, 88, 89, 89, 88, 89, 89,
88, 88, 88, 89, 89, 89, 89, 89, 89, 89, 89, 89, 89, 89, 89, 88, 89, 89, 90, 88,
88, 88, 89, 88, 89, 89, 88, 88, 88, 89, 88, 88, 88, 89, 88, 88, 88, 89, 89, 89,
87, 88, 87, 88, 88, 88, 88, 88, 87, 88, 87, 88, 87, 88, 87, 87, 87, 87, 87, 88,
87, 87, 87, 87, 86, 87, 87, 87, 87, 87, 86, 86, 86, 86, 86, 86, 86, 86, 85, 85,
85, 86, 85, 85, 84, 84, 84, 83, 83, 82, 82, 81, 81, 80, 81, 80, 79, 79, 78, 76,
75, 74, 71, 67, 62, 61, 61, 45, 42, 45, 45, 44, 39, 36, 32, 29, 26, 23, 19, 16,
14, 12, 8, 7, 5, 2, 0, -1, -3, -5, -7, -8, -11, -10, -13, -13, -15, -16, -17,
-18, -20, -21, -22, -22, -23, -25, -24, -26, -25, -25, -24, -23, -21, -18, -11,
-15, -10, 9, 5, 1, 2, 4, 8, 11, 15, 18, 22, 24, 29, 30, 32, 36, 38, 40, 43, 45,
46, 48, 49, 52, 52, 54, 55, 56, 57, 58, 59, 61, 62, 62, 63, 64, 65, 65, 66, 67,
67, 67, 68, 70, 70, 70, 71, 71, 71, 72, 72, 72, 73, 74, 73, 74, 74, 74, 74, 76,
74, 75, 76, 75, 76, 76, 76, 76, 76, 76, 76, 75, 76, 77, 76, 76, 76, 77, 77, 77,
76, 76, 76, 77, 76, 76, 76, 76, 77, 76, 76, 75, 76, 76, 76, 77, 77, 75, 76, 75,
76, 77, 75, 76, 76, 76, 76, 75, 75, 76, 75, 75, 75, 75, 75, 75, 74, 75, 75, 75,
74, 75, 75, 74, 75, 75, 74, 74, 75, 74, 74, 73, 73, 74, 73, 73, 72, 73, 73, 72,
73, 73, 72, 72, 71, 71, 71, 71, 70, 70, 69, 70, 69, 69, 68, 68, 67, 67, 66, 66,
65, 64, 63, 62, 61, 60, 59, 58, 57, 55, 54, 51, 50, 49, 46, 45, 42, 39, 36, 33,
29, 25, 21, 17, 13, 6, 2, -1, -7, -12, -15, -16, -21, -25, -29, -33, -38, -41,
-44, -48, -51, -54, -57, -59, -62, -65, -67, -70, -71, -74, -75, -77, -79, -81,
-83, -84, -86, -87, -88, -90, -91, -92, -93, -95, -95, -96, -97, -98, -99, -100,
-101, -101, -103, -103, -104, -105, -106, -106, -107, -107, -108, -109, -110,
-110, -111, -112, -111, -112, -114, -114, -115, -115, -115, -115, -116, -117,
-117, -118, -117, -118, -119, -118, -120, -119, -120, -118, -117, -114, -112,
-104, -98, -84, -95, -78, -41, -55, -58, -56, -51, -45, -37, -30, -23, -16, -10,
-4, };