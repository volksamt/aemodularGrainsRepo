#define DATA_LENGTH 512
#define DATA AKWF_1316

const PROGMEM int8_t DATA[DATA_LENGTH] = {74, 88, 81, 85, 80, 84, 80, 83, 79,
81, 77, 79, 76, 77, 75, 75, 74, 74, 74, 73, 72, 71, 70, 70, 69, 68, 68, 67, 67,
65, 66, 64, 64, 63, 63, 62, 61, 60, 60, 60, 58, 58, 57, 56, 56, 55, 54, 53, 53,
53, 52, 51, 50, 49, 49, 48, 48, 47, 47, 45, 45, 45, 45, 43, 42, 41, 41, 40, 40,
39, 37, 39, 36, 37, 34, 37, 33, 36, 31, 35, 29, 36, 16, -46, -40, -40, -39, -37,
-37, -36, -36, -33, -34, -31, -32, -30, -30, -28, -29, -26, -26, -24, -24, -23,
-22, -21, -19, -19, -18, -18, -17, -16, -14, -14, -12, -14, -9, 7, 7, 6, 5, 3,
4, 3, 3, 1, 1, 1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0,
0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
0, 0, 1, 0, 0, 1, 0, 0, 0, 1, -1, 0, 1, 0, 0, -1, 0, 0, -1, 1, 0, 0, 0, 0, 0, 0,
0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, -1, 0, 0, -1, 0, 1,
-1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, -1,
0, 0, 0, 0, 0, -1, 0, 0, 1, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1,
0, 0, 0, 0, 0, 0, 0, 1, 0, 1, -1, 1, 0, 0, 0, -1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0,
0, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, -1,
0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, -1, 0, 0, 0, 0, -2, -3, -3, -5, -5, -7, -8, -8, -9, -11, -11, -12, -12, -14,
-15, -16, -17, -17, -19, -20, -20, -22, -23, -23, -25, -25, -26, -27, -28, -29,
-30, -31, -32, -33, -33, -34, -35, -36, -37, -39, -39, -40, -41, -42, -43, -44,
-45, -46, -46, -48, -49, -50, -51, -52, -52, -53, -55, -56, -56, -58, -58, -59,
-59, -61, -61, -63, -63, -64, -66, -67, -68, -68, -69, -70, -72, -72, -73, -73,
-75, -75, -76, -77, -79, -80, -81, -81, -82, -83, -85, -84, -87, -87, -89, -88,
-90, -91, -91, -92, -94, -94, -96, -96, -98, -98, -99, -100, -100, -102, -102,
-104, -104, -106, -106, -108, -107, -109, -109, -112, -110, -115, -111, -117,
-112, -120, -112, -126, -102, };