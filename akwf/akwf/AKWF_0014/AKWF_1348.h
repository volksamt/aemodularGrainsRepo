#define DATA_LENGTH 512
#define DATA AKWF_1348

const PROGMEM int8_t DATA[DATA_LENGTH] = {-104, -124, -115, -122, -116, -121,
-116, -122, -117, -121, -117, -121, -118, -120, -118, -121, -118, -119, -118,
-119, -119, -119, -119, -119, -120, -119, -120, -118, -120, -118, -119, -119,
-119, -119, -120, -119, -119, -119, -118, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -120, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -118, -119, -118, -119, -120, -119, -118, -119, -119, -119, -119, -120,
-119, -120, -118, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-120, -118, -119, -119, -119, -119, -119, -118, -118, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -118, -119, -118, -119, -118,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -120, -118, -119, -119, -119, -119, -120, -118, -119, -119, -120, -119,
-120, -118, -119, -119, -119, -118, -120, -119, -120, -119, -118, -120, -118,
-120, -119, -120, -117, -121, -117, -122, -116, -124, -112, -128, -81, 13, -6,
3, -2, 1, 0, 0, 0, -1, 0, -1, 0, -1, 0, -1, 1, -1, 1, -1, 1, 0, 0, 0, 1, 0, 0,
1, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, -1, -1, 0, 0, 0, 0, 0,
0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0,
0, 0, 0, 0, 1, 0, 0, 0, 0, -1, -1, 0, 1, 0, 1, 0, 0, -1, 0, -1, 1, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0,
0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 1, 0, 1, 0, 0, 1, 0, 0, 0, -1, 0, 0, -1, 0, 0,
-1, 0, 0, 1, 0, 0, -1, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, -1, 0, 0,
-1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0,
-1, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 1, -1, 1, 0, 1, -1, 1, -2, 2, -2, 2, -1, 3, -2, 3, -3, 5, 115,
123, 117, 121, 117, 121, 118, 121, 117, 121, 117, 120, 118, 120, 118, 120, 118,
119, 118, 120, 119, 119, 120, 119, 120, 119, 120, 118, 119, 119, 120, 119, 119,
118, 120, 119, 119, 118, 119, 119, 118, 119, 118, 119, 118, 120, 118, 120, 118,
121, 117, 121, 116, 122, 117, 123, 114, 126, 101, };