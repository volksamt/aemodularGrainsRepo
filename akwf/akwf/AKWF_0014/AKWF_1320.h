#define DATA_LENGTH 512
#define DATA AKWF_1320

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 10, 13, 16, 20, 24, 29, 32, 36,
39, 42, 46, 49, 53, 56, 59, 62, 65, 68, 71, 73, 77, 79, 82, 85, 87, 90, 92, 95,
98, 100, 102, 104, 106, 108, 110, 113, 115, 117, 120, 118, 117, 116, 115, 114,
112, 111, 110, 109, 108, 108, 106, 105, 104, 101, 96, 93, 88, 84, 79, 75, 72,
67, 63, 59, 56, 51, 48, 45, 40, 38, 34, 31, 27, 24, 20, 18, 14, 11, 9, 6, 2, 0,
-3, -5, -8, -10, -14, -16, -17, -20, -22, -24, -27, -29, -31, -32, -35, -37,
-39, -41, -42, -44, -44, -46, -45, -46, -46, -47, -48, -49, -49, -49, -50, -50,
-50, -51, -51, -52, -52, -51, -52, -52, -53, -54, -54, -54, -54, -55, -55, -55,
-55, -56, -56, -56, -57, -57, -57, -57, -57, -57, -57, -58, -57, -57, -58, -58,
-58, -57, -58, -57, -52, -48, -45, -42, -37, -34, -31, -27, -24, -21, -17, -14,
-11, -7, -4, -1, 2, 4, 8, 11, 13, 15, 18, 20, 23, 25, 28, 30, 32, 34, 36, 38,
39, 41, 42, 44, 45, 47, 49, 49, 50, 51, 52, 53, 54, 54, 55, 55, 53, 53, 51, 50,
48, 46, 44, 44, 42, 40, 38, 37, 35, 34, 32, 29, 28, 26, 25, 23, 20, 19, 17, 15,
14, 12, 10, 9, 7, 5, 4, 2, 0, -3, -6, -9, -12, -15, -17, -20, -23, -26, -27,
-30, -31, -35, -36, -38, -40, -41, -43, -44, -45, -46, -48, -48, -50, -49, -51,
-50, -51, -52, -51, -52, -53, -52, -51, -52, -50, -51, -50, -49, -48, -47, -46,
-46, -44, -44, -42, -41, -38, -35, -31, -28, -25, -21, -18, -15, -12, -9, -6,
-2, -1, 2, 6, 7, 10, 13, 16, 17, 19, 22, 24, 25, 27, 29, 30, 31, 33, 34, 34, 36,
36, 37, 38, 39, 39, 39, 39, 39, 39, 39, 39, 38, 38, 37, 37, 36, 34, 33, 32, 30,
28, 27, 25, 24, 21, 21, 18, 17, 15, 14, 12, 10, 9, 6, 5, 3, 2, 0, -2, -3, -5,
-6, -8, -9, -11, -12, -13, -15, -15, -17, -18, -19, -20, -20, -22, -23, -22,
-23, -23, -24, -23, -23, -23, -23, -22, -22, -23, -22, -20, -20, -20, -18, -17,
-17, -17, -15, -13, -12, -11, -10, -8, -7, -6, -5, -3, -1, 0, 2, 3, 5, 6, 7, 9,
11, 11, 13, 14, 16, 16, 18, 19, 20, 22, 22, 23, 24, 24, 25, 25, 25, 26, 27, 26,
26, 26, 25, 26, 25, 25, 24, 23, 22, 21, 20, 18, 17, 15, 15, 13, 12, 10, 7, 6, 4,
2, -1, -2, -4, -7, -10, -13, -15, -18, -20, -22, -24, -27, -30, -32, -35, -37,
-39, -42, -44, -46, -48, -50, -51, -54, -55, -58, -58, -61, -61, -63, -64, -65,
-66, -66, -66, -66, -66, -67, -67, -67, -66, -65, -64, -63, -62, -61, -58, -57,
-54, -52, -50, -48, -45, -43, -40, -36, -33, -29, -26, -22, -18, -14, -10, -6,
-2, };