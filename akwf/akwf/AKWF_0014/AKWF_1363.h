#define DATA_LENGTH 512
#define DATA AKWF_1363

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 9, 12, 15, 17, 21, 24, 27,
30, 33, 35, 38, 41, 43, 47, 50, 52, 56, 58, 61, 64, 67, 70, 72, 76, 77, 80, 82,
85, 87, 89, 91, 94, 96, 98, 100, 101, 103, 105, 106, 109, 110, 112, 112, 114,
114, 115, 116, 117, 118, 118, 118, 119, 119, 120, 119, 119, 118, 118, 118, 118,
116, 116, 115, 114, 113, 112, 110, 109, 107, 105, 103, 102, 101, 99, 97, 95, 92,
90, 88, 86, 83, 80, 78, 75, 73, 70, 68, 66, 62, 60, 56, 53, 50, 48, 45, 42, 39,
37, 33, 30, 28, 24, 21, 18, 16, 13, 10, 8, 5, 2, -1, -2, -6, -8, -11, -13, -15,
-17, -19, -22, -25, -27, -28, -30, -32, -34, -35, -38, -39, -41, -42, -45, -46,
-47, -48, -50, -51, -52, -53, -54, -54, -55, -57, -58, -59, -59, -59, -60, -61,
-62, -63, -63, -63, -63, -63, -65, -64, -65, -65, -66, -66, -67, -66, -67, -67,
-67, -67, -66, -66, -67, -67, -68, -67, -67, -68, -68, -68, -68, -68, -69, -68,
-68, -69, -69, -69, -69, -68, -68, -68, -68, -69, -68, -69, -69, -69, -69, -68,
-69, -69, -68, -69, -68, -69, -68, -68, -68, -68, -68, -68, -68, -67, -67, -67,
-66, -66, -66, -65, -65, -64, -64, -62, -62, -61, -60, -60, -58, -58, -56, -55,
-55, -54, -53, -51, -49, -48, -47, -45, -44, -42, -40, -39, -37, -36, -32, -31,
-29, -26, -25, -23, -20, -17, -16, -13, -10, -8, -6, -3, 0, 2, 5, 8, 11, 13, 17,
19, 23, 25, 28, 31, 34, 35, 39, 42, 45, 47, 51, 53, 56, 59, 62, 64, 67, 69, 71,
74, 76, 77, 80, 83, 84, 86, 88, 91, 92, 94, 95, 97, 98, 100, 101, 101, 103, 103,
104, 106, 105, 106, 107, 107, 107, 107, 107, 107, 107, 106, 107, 106, 105, 104,
103, 102, 101, 100, 99, 98, 96, 94, 94, 91, 89, 87, 86, 84, 80, 80, 77, 75, 73,
70, 68, 64, 63, 60, 56, 55, 52, 49, 45, 43, 41, 37, 34, 32, 29, 26, 23, 20, 18,
15, 12, 9, 6, 5, 1, -2, -4, -7, -9, -11, -14, -17, -19, -22, -24, -25, -27, -30,
-32, -34, -36, -38, -40, -42, -43, -45, -46, -48, -49, -51, -52, -54, -55, -56,
-56, -57, -59, -60, -60, -61, -63, -63, -63, -64, -65, -65, -65, -66, -66, -68,
-67, -67, -68, -68, -68, -68, -69, -68, -69, -69, -69, -68, -69, -68, -69, -69,
-70, -69, -70, -69, -69, -69, -69, -68, -68, -68, -68, -69, -68, -68, -68, -68,
-68, -68, -68, -67, -68, -67, -67, -68, -67, -67, -67, -67, -67, -66, -67, -66,
-66, -66, -65, -65, -65, -66, -65, -65, -64, -64, -63, -63, -62, -63, -61, -60,
-60, -60, -59, -59, -58, -57, -56, -56, -55, -53, -53, -50, -50, -48, -47, -45,
-44, -44, -41, -39, -39, -37, -35, -33, -31, -28, -26, -26, -23, -21, -18, -15,
-12, -8, -5, -1, };