#define DATA_LENGTH 512
#define DATA AKWF_1315

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 8, 11, 14, 17, 21, 24, 28, 30, 34,
36, 39, 43, 46, 48, 51, 54, 56, 59, 62, 64, 67, 69, 71, 74, 76, 78, 81, 83, 85,
85, 88, 90, 92, 93, 95, 97, 98, 100, 101, 102, 103, 105, 106, 107, 108, 108,
109, 111, 112, 113, 113, 114, 115, 115, 116, 116, 116, 117, 117, 116, 117, 117,
117, 117, 117, 118, 118, 117, 117, 116, 116, 115, 115, 114, 114, 113, 111, 111,
110, 110, 108, 108, 106, 104, 103, 102, 101, 100, 98, 96, 95, 93, 92, 90, 88,
85, 83, 81, 80, 77, 76, 74, 71, 70, 67, 65, 62, 59, 56, 54, 51, 48, 45, 43, 40,
37, 34, 31, 27, 24, 21, 17, 13, 11, 7, 3, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1,
1, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
-1, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, -1, 1,
-1, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, -1, 1, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0,
-1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0,
0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0,
1, 0, 0, 0, 0, 1, 1, 0, -1, 0, 0, 1, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 1, -1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0,
0, 0, -1, 0, 0, 0, -1, 0, 0, -1, 0, 0, -1, -3, -6, -10, -14, -17, -20, -23, -27,
-30, -34, -36, -39, -43, -45, -47, -51, -54, -56, -59, -61, -64, -66, -69, -72,
-73, -76, -79, -80, -83, -84, -87, -89, -90, -92, -94, -96, -97, -99, -100,
-102, -103, -104, -106, -107, -108, -109, -110, -111, -112, -113, -114, -115,
-115, -116, -116, -116, -118, -117, -118, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -118, -118, -117, -117, -117, -115, -116, -115, -114,
-113, -111, -111, -111, -109, -109, -108, -106, -104, -103, -101, -100, -99,
-97, -96, -95, -92, -90, -89, -87, -85, -83, -81, -80, -77, -74, -72, -70, -67,
-64, -62, -60, -56, -55, -52, -48, -46, -43, -40, -37, -34, -31, -27, -25, -21,
-17, -14, -11, -8, -4, 0, };