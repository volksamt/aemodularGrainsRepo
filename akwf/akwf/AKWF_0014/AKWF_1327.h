#define DATA_LENGTH 512
#define DATA AKWF_1327

const PROGMEM int8_t DATA[DATA_LENGTH] = {28, 33, 30, 32, 30, 32, 31, 32, 31,
31, 31, 31, 31, 31, 31, 31, 31, 32, 31, 31, 32, 32, 31, 31, 31, 31, 31, 32, 31,
31, 31, 31, 30, 31, 32, 31, 31, 31, 31, 32, 31, 32, 31, 31, 31, 31, 31, 32, 31,
32, 32, 31, 31, 31, 31, 30, 31, 31, 31, 31, 31, 31, 31, 30, 31, 31, 32, 32, 32,
31, 31, 31, 31, 32, 31, 31, 31, 32, 31, 31, 31, 32, 32, 31, 32, 32, 31, 31, 32,
32, 32, 31, 32, 32, 32, 32, 31, 31, 31, 31, 32, 31, 33, 31, 32, 31, 32, 31, 32,
31, 32, 31, 32, 31, 32, 31, 31, 32, 31, 33, 29, 34, 27, 37, 20, 80, 126, 107,
118, 110, 116, 112, 115, 112, 114, 113, 113, 113, 114, 114, 114, 114, 114, 114,
113, 114, 112, 114, 113, 114, 113, 113, 113, 113, 113, 114, 114, 113, 114, 113,
114, 113, 114, 114, 113, 114, 114, 113, 113, 113, 113, 113, 114, 113, 113, 114,
113, 113, 114, 113, 113, 113, 113, 113, 114, 114, 113, 114, 113, 113, 114, 114,
114, 114, 113, 114, 113, 113, 113, 113, 114, 113, 113, 113, 114, 113, 114, 114,
113, 113, 113, 113, 113, 114, 114, 114, 113, 114, 114, 113, 113, 114, 114, 114,
113, 114, 113, 114, 113, 114, 113, 114, 113, 114, 114, 112, 114, 112, 114, 112,
114, 112, 115, 111, 115, 111, 115, 112, 116, 110, 116, 110, 118, 109, 118, 104,
-50, -55, -49, -56, -50, -55, -51, -55, -50, -55, -50, -55, -50, -54, -51, -54,
-51, -54, -52, -54, -52, -52, -52, -53, -53, -52, -53, -52, -53, -53, -53, -53,
-53, -52, -53, -52, -53, -52, -52, -53, -53, -52, -53, -52, -52, -53, -52, -53,
-53, -52, -53, -53, -52, -53, -52, -53, -53, -53, -53, -53, -53, -53, -53, -53,
-53, -52, -53, -53, -53, -52, -53, -53, -52, -53, -53, -53, -53, -53, -52, -53,
-53, -52, -53, -53, -53, -53, -53, -53, -52, -53, -53, -53, -52, -52, -53, -53,
-53, -52, -53, -52, -53, -52, -53, -52, -53, -52, -53, -52, -53, -51, -53, -52,
-53, -53, -53, -52, -53, -53, -53, -53, -52, -54, -51, -56, -47, -89, -111,
-100, -106, -101, -105, -102, -104, -103, -104, -103, -104, -103, -104, -104,
-104, -104, -103, -103, -103, -104, -104, -103, -104, -103, -103, -104, -103,
-104, -103, -104, -104, -103, -103, -103, -103, -103, -103, -104, -104, -104,
-104, -104, -103, -103, -104, -104, -104, -103, -103, -104, -104, -104, -104,
-104, -104, -103, -103, -104, -104, -104, -104, -103, -103, -104, -104, -103,
-103, -103, -103, -103, -103, -103, -103, -104, -104, -104, -104, -103, -103,
-103, -104, -103, -103, -103, -103, -104, -103, -103, -103, -104, -103, -103,
-103, -104, -104, -104, -104, -104, -104, -103, -104, -104, -103, -104, -103,
-104, -103, -104, -103, -103, -103, -104, -103, -104, -103, -103, -104, -103,
-105, -102, -105, -101, -105, -102, -106, -101, -107, -99, -110, -89, };