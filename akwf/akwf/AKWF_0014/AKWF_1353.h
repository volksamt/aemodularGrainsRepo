#define DATA_LENGTH 512
#define DATA AKWF_1353

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 0, 0, 0, 0, 0, -1, -1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, -1, 1, -1, 1,
-1, 1, -1, 1, -1, 1, -1, 0, 0, 0, 1, -2, 4, -9, 79, 114, 100, 108, 100, 107,
102, 106, 103, 106, 104, 105, 103, 105, 104, 105, 104, 104, 104, 105, 105, 104,
105, 104, 104, 104, 105, 104, 105, 103, 105, 104, 104, 104, 105, 105, 104, 104,
105, 105, 105, 104, 105, 104, 104, 104, 105, 105, 104, 105, 104, 105, 105, 105,
104, 104, 104, 105, 104, 104, 104, 104, 104, 105, 105, 105, 104, 105, 104, 104,
105, 105, 104, 104, 105, 105, 104, 104, 105, 105, 105, 105, 105, 104, 104, 105,
105, 104, 104, 105, 105, 104, 105, 104, 104, 104, 104, 104, 105, 104, 105, 104,
107, 115, 113, 113, 113, 113, 113, 113, 113, 113, 113, 113, 113, 113, 113, 113,
114, 113, 112, 112, 113, 113, 113, 112, 113, 113, 113, 112, 113, 113, 113, 113,
112, 113, 113, 113, 114, 113, 113, 113, 112, 113, 113, 113, 112, 113, 113, 113,
112, 113, 113, 113, 112, 113, 113, 112, 112, 113, 113, 113, 113, 114, 114, 112,
113, 113, 113, 113, 113, 114, 113, 113, 113, 113, 112, 113, 113, 113, 114, 113,
113, 113, 113, 112, 114, 112, 114, 112, 113, 112, 114, 111, 115, 111, 114, 112,
114, 112, 113, 112, 112, 116, 29, 12, 22, 14, 20, 15, 19, 16, 18, 17, 19, 17,
19, 17, 17, 17, 18, 17, 18, 17, 18, 17, 17, 18, 18, 18, 17, 18, 17, 18, 17, 18,
17, 18, 18, 18, 17, 18, 17, 17, 18, 18, 18, 17, 18, 17, 18, 17, 18, 18, 18, 17,
18, 18, 18, 18, 18, 17, 18, 17, 18, 17, 18, 17, 18, 17, 18, 17, 17, 17, 17, 18,
18, 18, 18, 18, 17, 18, 16, 17, 17, 18, 18, 19, 17, 17, 17, 17, 17, 17, 18, 17,
19, 16, 19, 15, 20, 14, 23, 11, 30, -25, -107, -88, -98, -92, -96, -93, -95,
-94, -94, -94, -93, -94, -93, -94, -93, -94, -93, -94, -93, -94, -93, -94, -93,
-95, -93, -94, -93, -94, -94, -94, -94, -94, -94, -94, -94, -94, -94, -94, -94,
-94, -95, -94, -93, -93, -94, -94, -94, -94, -94, -93, -94, -94, -95, -94, -94,
-93, -94, -94, -94, -95, -94, -94, -94, -94, -95, -94, -95, -93, -93, -95, -94,
-94, -94, -94, -94, -94, -94, -94, -94, -93, -94, -94, -94, -95, -94, -94, -93,
-94, -94, -94, -94, -94, -94, -94, -93, -95, -93, -95, -94, -94, -93, -96, -118,
-119, -119, -120, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -120, -118, -119, -119, -120, -119, -119,
-118, -120, -119, -119, -119, -119, -120, -119, -119, -118, -119, -119, -120,
-119, -120, -118, -120, -118, -122, -116, -122, -115, -122, -114, -127, -101, };