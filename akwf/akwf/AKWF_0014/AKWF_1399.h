#define DATA_LENGTH 512
#define DATA AKWF_1399

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 9, 12, 14, 18, 20, 23, 27,
29, 32, 36, 38, 41, 44, 46, 50, 53, 56, 59, 60, 62, 75, 77, 75, 76, 75, 75, 74,
74, 74, 74, 73, 73, 73, 73, 72, 73, 72, 71, 71, 71, 71, 70, 71, 70, 70, 69, 69,
69, 68, 68, 68, 68, 67, 67, 67, 66, 65, 66, 64, 65, 63, 64, 64, 63, 62, 63, 62,
61, 61, 61, 60, 60, 60, 60, 59, 58, 58, 57, 58, 56, 55, 55, 55, 54, 55, 54, 53,
53, 53, 51, 52, 50, 50, 49, 49, 48, 48, 48, 46, 47, 46, 45, 44, 44, 43, 43, 42,
42, 42, 41, 40, 39, 39, 38, 37, 38, 36, 36, 35, 34, 34, 32, 32, 32, 32, 30, 30,
29, 28, 27, 26, 26, 25, 24, 23, 23, 22, 20, 20, 20, 18, 17, 16, 16, 16, 14, 14,
12, 11, 10, 9, 8, 8, 7, 6, 5, 3, 3, 2, 0, -1, -1, -2, -4, -5, -5, -7, -8, -9,
-10, -11, -12, -13, -14, -17, -17, -19, -19, -21, -22, -23, -24, -26, -28, -29,
-30, -32, -33, -34, -35, -37, -38, -40, -42, -43, -44, -45, -48, -48, -51, -51,
-55, -54, -58, -56, -63, -56, -75, -123, -118, -119, -118, -118, -117, -115,
-114, -112, -111, -109, -108, -105, -105, -103, -102, -101, -100, -96, -96, -94,
-93, -91, -89, -87, -85, -84, -82, -80, -79, -77, -75, -73, -71, -70, -68, -66,
-64, -62, -60, -57, -56, -54, -52, -49, -48, -46, -44, -41, -39, -37, -34, -32,
-30, -28, -25, -23, -20, -18, -16, -13, -11, -8, -6, -4, -1, 2, 5, 7, 10, 13,
15, 19, 21, 25, 27, 30, 33, 35, 39, 42, 45, 48, 51, 54, 58, 61, 65, 67, 71, 72,
76, 72, 60, 62, 62, 60, 61, 60, 59, 59, 59, 59, 58, 57, 57, 57, 56, 55, 55, 55,
54, 53, 53, 53, 52, 51, 51, 51, 51, 50, 50, 48, 48, 48, 47, 47, 46, 45, 46, 44,
45, 43, 43, 42, 42, 40, 40, 40, 40, 38, 37, 36, 36, 36, 35, 34, 34, 33, 32, 31,
31, 30, 29, 29, 28, 28, 26, 26, 25, 25, 23, 22, 22, 22, 20, 19, 18, 17, 17, 16,
15, 14, 13, 12, 12, 11, 10, 9, 8, 7, 5, 5, 5, 3, 2, 1, 0, -1, -2, -3, -4, -5,
-7, -8, -9, -10, -11, -13, -13, -14, -16, -17, -18, -20, -21, -22, -24, -24,
-25, -28, -29, -30, -31, -33, -33, -35, -36, -38, -40, -41, -43, -43, -45, -47,
-48, -50, -51, -53, -55, -56, -58, -59, -61, -62, -63, -65, -68, -69, -71, -72,
-74, -76, -77, -80, -81, -83, -83, -87, -88, -89, -91, -93, -94, -97, -98, -100,
-101, -104, -105, -105, -108, -108, -111, -111, -114, -113, -117, -115, -120,
-114, -124, -102, -56, -62, -56, -57, -53, -52, -50, -48, -46, -43, -42, -39,
-38, -34, -33, -30, -28, -25, -24, -20, -19, -15, -13, -11, -9, -6, -4, -1, };