#define DATA_LENGTH 512
#define DATA AKWF_1366

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 0, 0, 1, 1, 1, 2, 2, 3, 5, 5,
6, 8, 9, 10, 12, 13, 15, 17, 18, 20, 22, 24, 26, 28, 31, 33, 35, 37, 40, 43, 46,
49, 51, 54, 58, 60, 61, 62, 65, 65, 67, 69, 70, 72, 73, 74, 76, 77, 79, 80, 81,
83, 83, 84, 86, 87, 89, 90, 91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 101, 102,
102, 104, 105, 105, 106, 106, 108, 109, 108, 110, 110, 111, 112, 112, 113, 114,
113, 114, 115, 115, 116, 116, 116, 116, 116, 117, 118, 118, 118, 118, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 118, 118, 117,
117, 118, 116, 116, 116, 114, 115, 115, 114, 114, 113, 112, 112, 112, 111, 110,
109, 108, 108, 107, 106, 105, 104, 104, 103, 102, 101, 100, 99, 99, 97, 96, 94,
94, 93, 92, 91, 89, 88, 88, 87, 85, 83, 81, 81, 79, 78, 77, 76, 74, 73, 71, 70,
68, 67, 66, 64, 63, 61, 60, 58, 56, 56, 53, 52, 50, 49, 47, 45, 44, 42, 40, 38,
38, 36, 34, 33, 31, 28, 28, 25, 24, 22, 20, 18, 17, 16, 13, 11, 10, 9, 6, 4, 3,
1, -1, -3, -4, -6, -8, -9, -11, -13, -16, -17, -18, -21, -21, -23, -25, -26,
-29, -31, -32, -33, -35, -36, -38, -40, -42, -44, -45, -47, -49, -50, -51, -53,
-55, -56, -57, -60, -61, -62, -64, -65, -67, -68, -69, -71, -72, -74, -75, -76,
-78, -80, -81, -82, -82, -84, -85, -86, -88, -89, -91, -91, -92, -93, -95, -96,
-96, -98, -99, -100, -101, -102, -103, -103, -104, -106, -106, -107, -107, -108,
-109, -110, -110, -111, -111, -112, -113, -113, -113, -111, -109, -103, -97,
-90, -82, -75, -67, -57, -41, -26, -12, -2, 6, 10, 8, 6, 1, -5, -10, -15, -18,
-20, -22, -23, -22, -21, -20, -19, -17, -17, -16, -15, -14, -13, -12, -10, -9,
-7, -7, -12, -23, -36, -48, -60, -69, -75, -77, -79, -79, -79, -78, -77, -77,
-77, -78, -80, -79, -80, -83, -83, -84, -85, -86, -87, -87, -88, -89, -89, -89,
-88, -87, -86, -85, -83, -82, -80, -79, -78, -75, -74, -73, -71, -69, -68, -68,
-66, -64, -63, -61, -59, -59, -57, -55, -53, -52, -51, -49, -47, -44, -43, -41,
-39, -36, -35, -33, -31, -30, -28, -26, -23, -23, -21, -19, -17, -16, -14, -13,
-12, -9, -8, -6, -5, -4, -2, -1, 0, 2, 2, 4, 5, 6, 7, 8, 9, 10, 11, 12, 11, 12,
12, 13, 15, 14, 15, 14, 15, 15, 16, 16, 17, 17, 16, 16, 16, 16, 16, 16, 16, 16,
15, 15, 15, 14, 14, 13, 13, 14, 13, 13, 12, 12, 11, 11, 11, 10, 10, 9, 9, 9, 8,
8, 7, 6, 6, 5, 6, 5, 5, 5, 4, 3, 4, 3, 3, 2, 3, 2, 3, 1, 2, 1, 1, 1, 1, 0, 0, 1,
0, };