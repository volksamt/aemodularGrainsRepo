#define DATA_LENGTH 512
#define DATA AKWF_1400

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 9, 13, 17, 22, 27, 30, 34, 38, 42,
45, 49, 53, 57, 60, 62, 67, 69, 72, 74, 78, 80, 83, 85, 89, 90, 93, 95, 97, 98,
101, 102, 103, 105, 108, 108, 110, 110, 112, 113, 114, 115, 116, 116, 117, 118,
119, 119, 119, 119, 119, 117, 115, 113, 112, 110, 109, 107, 106, 105, 105, 103,
102, 101, 99, 100, 97, 97, 96, 94, 94, 93, 91, 91, 90, 89, 89, 87, 86, 86, 84,
84, 84, 82, 81, 80, 79, 79, 78, 77, 76, 76, 74, 74, 74, 73, 71, 72, 71, 70, 69,
68, 67, 66, 66, 66, 64, 64, 63, 62, 61, 60, 60, 58, 59, 58, 58, 57, 56, 55, 54,
54, 53, 53, 52, 51, 50, 49, 49, 49, 47, 47, 46, 46, 45, 45, 44, 43, 43, 43, 41,
41, 40, 40, 39, 38, 38, 38, 37, 37, 35, 36, 34, 33, 33, 32, 32, 31, 30, 30, 30,
29, 28, 28, 27, 27, 27, 26, 25, 25, 24, 23, 23, 22, 22, 22, 20, 20, 19, 20, 19,
18, 18, 17, 16, 16, 15, 15, 15, 14, 13, 13, 13, 11, 12, 11, 11, 11, 9, 9, 9, 8,
7, 7, 6, 6, 6, 5, 4, 4, 4, 3, 2, 2, 1, 1, 1, 0, 0, 0, -1, -1, -2, -2, -3, -3,
-4, -5, -4, -6, -6, -6, -7, -6, -7, -7, -8, -9, -8, -9, -10, -9, -11, -11, -11,
-13, -13, -13, -14, -14, -14, -15, -15, -15, -16, -16, -16, -17, -17, -17, -18,
-18, -20, -19, -19, -20, -20, -21, -22, -21, -21, -22, -23, -23, -23, -24, -24,
-25, -25, -25, -26, -26, -26, -27, -27, -27, -28, -28, -29, -28, -29, -30, -29,
-30, -31, -31, -31, -32, -32, -32, -32, -33, -34, -34, -34, -33, -35, -35, -35,
-35, -36, -36, -35, -37, -37, -38, -37, -38, -38, -39, -38, -39, -39, -40, -40,
-40, -40, -40, -41, -41, -41, -42, -43, -42, -42, -43, -43, -43, -43, -45, -45,
-45, -45, -45, -45, -46, -45, -45, -46, -46, -47, -47, -48, -47, -48, -47, -48,
-48, -48, -49, -49, -49, -49, -50, -49, -50, -50, -51, -51, -51, -51, -52, -51,
-52, -51, -52, -52, -53, -54, -52, -53, -54, -54, -53, -54, -54, -54, -54, -55,
-54, -55, -56, -55, -55, -55, -55, -56, -57, -57, -56, -56, -57, -57, -57, -58,
-57, -57, -58, -58, -58, -58, -58, -58, -58, -58, -59, -59, -60, -59, -59, -59,
-60, -59, -60, -60, -60, -60, -60, -60, -60, -61, -62, -61, -61, -61, -61, -61,
-61, -61, -62, -61, -62, -62, -61, -62, -62, -62, -62, -62, -63, -63, -62, -63,
-63, -63, -63, -63, -63, -63, -63, -63, -63, -63, -63, -63, -63, -63, -64, -63,
-63, -64, -64, -64, -64, -64, -64, -64, -64, -65, -63, -64, -64, -63, -64, -64,
-64, -65, -64, -64, -65, -65, -64, -65, -64, -64, -64, -64, -64, -64, -65, -63,
-66, -59, -47, -40, -34, -27, -21, -16, -10, -5, -1, };