#define DATA_LENGTH 512
#define DATA AKWF_1383

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 6, 9, 11, 14, 17, 20, 22, 24,
27, 29, 32, 34, 36, 38, 40, 42, 44, 46, 48, 49, 51, 53, 54, 56, 58, 59, 61, 63,
63, 65, 66, 68, 68, 68, 70, 71, 71, 71, 72, 73, 73, 73, 74, 75, 75, 76, 75, 75,
75, 75, 74, 75, 75, 74, 73, 73, 72, 73, 72, 72, 70, 69, 68, 68, 67, 66, 65, 65,
63, 62, 61, 60, 58, 57, 56, 54, 53, 51, 50, 49, 48, 46, 44, 43, 42, 40, 38, 37,
35, 33, 31, 30, 28, 27, 25, 24, 21, 21, 19, 16, 16, 14, 12, 10, 9, 7, 5, 4, 2,
0, -1, -3, -4, -7, -8, -8, -10, -12, -13, -14, -16, -17, -18, -20, -21, -22,
-23, -24, -25, -26, -28, -29, -29, -31, -32, -33, -34, -35, -36, -37, -37, -37,
-38, -39, -39, -40, -40, -40, -42, -41, -42, -41, -43, -42, -43, -43, -42, -43,
-43, -43, -43, -43, -43, -42, -43, -42, -43, -42, -41, -42, -42, -41, -40, -40,
-39, -38, -38, -38, -36, -37, -36, -35, -35, -34, -34, -33, -32, -31, -31, -29,
-29, -28, -27, -25, -25, -25, -24, -22, -22, -21, -20, -19, -18, -17, -16, -15,
-14, -12, -12, -10, -10, -9, -8, -7, -7, -5, -5, -3, -3, -1, 0, 0, 2, 2, 3, 4,
5, 6, 5, 7, 8, 8, 10, 10, 11, 12, 12, 13, 14, 14, 15, 16, 16, 17, 17, 17, 18,
19, 19, 20, 20, 20, 21, 22, 22, 21, 22, 23, 24, 23, 24, 24, 24, 24, 25, 24, 24,
25, 25, 24, 25, 25, 24, 25, 24, 25, 24, 24, 24, 23, 24, 24, 23, 23, 23, 22, 22,
22, 22, 22, 21, 21, 21, 21, 19, 19, 19, 18, 18, 18, 17, 17, 17, 16, 15, 15, 13,
14, 13, 13, 11, 11, 11, 11, 11, 10, 9, 8, 8, 7, 7, 6, 6, 5, 5, 4, 3, 3, 3, 1, 1,
1, 0, 0, -1, -2, -2, -3, -3, -3, -3, -4, -5, -5, -5, -6, -6, -6, -7, -7, -8, -9,
-8, -10, -9, -10, -9, -11, -11, -11, -11, -12, -12, -11, -12, -12, -12, -13,
-13, -13, -14, -13, -13, -14, -14, -14, -14, -14, -14, -14, -14, -14, -14, -14,
-14, -14, -14, -14, -14, -13, -14, -14, -14, -14, -13, -13, -13, -13, -12, -13,
-13, -12, -12, -12, -11, -11, -11, -10, -11, -11, -10, -10, -10, -10, -9, -9,
-8, -8, -9, -8, -7, -8, -7, -7, -6, -6, -5, -5, -5, -5, -4, -4, -4, -5, -3, -3,
-3, -2, -2, -2, -2, -1, -1, 0, -1, 1, 0, 2, 0, 3, 1, 3, 1, 4, 1, 6, 1, 7, 1, 7,
1, 9, -5, -119, -117, -114, -115, -111, -112, -107, -108, -103, -104, -98, -99,
-94, -95, -89, -89, -85, -84, -81, -78, -75, -73, -70, -67, -64, -61, -59, -55,
-54, -51, -47, -43, -41, -39, -36, -32, -30, -27, -23, -21, -18, -15, -12, -9,
-7, -4, -1, };