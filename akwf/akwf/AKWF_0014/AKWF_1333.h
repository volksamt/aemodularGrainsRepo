#define DATA_LENGTH 512
#define DATA AKWF_1333

const PROGMEM int8_t DATA[DATA_LENGTH] = {-31, -35, -33, -35, -34, -35, -33,
-35, -34, -34, -34, -35, -33, -34, -34, -34, -34, -33, -35, -34, -33, -33, -34,
-34, -34, -34, -34, -33, -34, -34, -34, -34, -33, -34, -33, -34, -34, -33, -33,
-34, -34, -35, -34, -33, -34, -35, -34, -34, -34, -34, -33, -34, -33, -34, -34,
-34, -34, -34, -34, -33, -34, -34, -35, -34, -34, -35, -33, -34, -35, -34, -34,
-33, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -33,
-33, -34, -34, -33, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34, -34,
-34, -34, -34, -34, -34, -34, -34, -34, -33, -34, -33, -34, -33, -34, -34, -35,
-34, -34, -33, -34, -34, -33, -34, -33, -34, -34, -34, -34, -33, -34, -35, -34,
-34, -33, -34, -34, -34, -34, -35, -33, -35, -33, -34, -33, -34, -33, -34, -33,
-34, -34, -34, -34, -33, -34, -33, -34, -33, -34, -33, -35, -32, -36, -29, -64,
-108, -106, -109, -107, -109, -106, -108, -107, -108, -107, -108, -108, -108,
-107, -107, -108, -107, -108, -107, -107, -107, -108, -107, -107, -107, -108,
-108, -108, -107, -108, -108, -108, -108, -107, -107, -108, -108, -107, -108,
-108, -107, -108, -108, -107, -108, -108, -107, -107, -107, -108, -108, -107,
-107, -108, -107, -108, -107, -108, -108, -107, -108, -108, -108, -107, -108,
-108, -108, -107, -108, -108, -107, -108, -107, -107, -108, -108, -107, -107,
-108, -108, -107, -108, -107, -108, -107, -108, -108, -108, -107, -108, -107,
-107, -108, -108, -107, -108, -107, -107, -108, -107, -108, -108, -107, -107,
-107, -108, -107, -108, -107, -107, -108, -108, -108, -108, -107, -108, -108,
-108, -108, -108, -107, -108, -107, -107, -108, -107, -107, -107, -108, -107,
-107, -107, -107, -108, -108, -107, -107, -107, -108, -108, -108, -107, -108,
-108, -107, -107, -109, -107, -108, -107, -109, -107, -109, -108, -108, -107,
-109, -107, -109, -108, -107, -109, -106, -108, -106, -109, -105, -112, -102,
-115, -96, -127, -54, 50, 22, 38, 28, 34, 29, 33, 31, 32, 31, 31, 32, 31, 32,
31, 32, 30, 32, 30, 32, 30, 32, 31, 33, 31, 32, 32, 32, 32, 32, 32, 32, 31, 31,
32, 32, 32, 32, 32, 31, 31, 31, 32, 31, 31, 31, 32, 31, 32, 31, 32, 31, 31, 31,
31, 32, 32, 32, 31, 31, 32, 31, 31, 31, 31, 32, 32, 31, 31, 32, 32, 31, 31, 32,
31, 32, 32, 32, 31, 32, 31, 31, 32, 31, 32, 32, 32, 32, 32, 31, 31, 32, 32, 32,
31, 32, 32, 31, 32, 31, 31, 32, 32, 32, 31, 32, 31, 31, 31, 32, 31, 32, 32, 31,
31, 32, 32, 32, 31, 31, 32, 32, 31, 32, 32, 31, 31, 32, 31, 31, 31, 32, 31, 32,
32, 32, 32, 32, 31, 31, 32, 32, 31, 32, 31, 31, 32, 32, 31, 32, 32, 31, 32, 32,
32, 32, 31, 32, 31, 32, 31, 31, 32, 31, 32, 31, 32, 30, 32, 30, 33, 26, };