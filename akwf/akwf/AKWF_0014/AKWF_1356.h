#define DATA_LENGTH 512
#define DATA AKWF_1356

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 37, 53, 63, 72, 77, 84, 87, 93, 96,
99, 101, 104, 106, 108, 108, 111, 112, 114, 114, 115, 116, 116, 116, 117, 117,
118, 118, 118, 119, 119, 120, 120, 119, 119, 119, 118, 119, 118, 118, 118, 117,
117, 117, 116, 116, 115, 114, 114, 113, 113, 112, 111, 110, 110, 108, 109, 107,
107, 105, 104, 103, 103, 102, 100, 99, 99, 98, 97, 95, 94, 92, 91, 90, 89, 87,
87, 85, 83, 82, 81, 80, 78, 77, 75, 73, 71, 71, 68, 67, 65, 64, 63, 61, 59, 57,
55, 54, 52, 50, 49, 46, 45, 43, 42, 40, 38, 37, 35, 33, 31, 29, 27, 25, 24, 21,
20, 18, 17, 14, 13, 12, 9, 8, 7, 4, 3, 1, -1, -3, -5, -7, -8, -10, -12, -13,
-15, -16, -18, -20, -22, -23, -25, -27, -27, -29, -30, -33, -34, -35, -38, -39,
-39, -42, -44, -45, -46, -47, -48, -49, -52, -52, -53, -55, -56, -58, -59, -61,
-62, -63, -63, -65, -66, -68, -69, -70, -71, -72, -74, -74, -75, -76, -77, -77,
-79, -80, -81, -82, -82, -84, -85, -86, -86, -87, -88, -89, -90, -91, -91, -92,
-93, -94, -94, -95, -96, -97, -97, -98, -97, -98, -100, -100, -101, -102, -102,
-103, -103, -103, -104, -105, -105, -105, -106, -106, -107, -108, -108, -108,
-109, -108, -109, -109, -110, -110, -111, -111, -111, -111, -111, -113, -112,
-113, -113, -114, -113, -114, -114, -115, -115, -115, -115, -115, -116, -115,
-116, -117, -116, -117, -117, -117, -117, -117, -117, -118, -118, -117, -118,
-119, -118, -118, -119, -118, -118, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-118, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -118, -118,
-118, -118, -119, -118, -118, -117, -118, -118, -117, -117, -116, -117, -116,
-117, -116, -116, -116, -116, -115, -116, -115, -115, -114, -115, -114, -114,
-114, -113, -114, -113, -113, -113, -113, -113, -113, -112, -111, -111, -111,
-111, -110, -110, -109, -109, -109, -109, -108, -108, -108, -107, -107, -106,
-106, -106, -106, -105, -105, -105, -104, -103, -102, -103, -102, -101, -102,
-101, -101, -100, -100, -99, -99, -98, -98, -97, -97, -96, -96, -96, -96, -94,
-94, -94, -93, -92, -91, -91, -91, -90, -90, -89, -88, -88, -88, -87, -86, -85,
-85, -85, -84, -84, -83, -82, -82, -81, -80, -79, -79, -78, -78, -77, -76, -75,
-74, -74, -73, -72, -73, -71, -70, -70, -69, -69, -68, -67, -66, -65, -65, -63,
-63, -63, -62, -62, -60, -59, -59, -58, -57, -56, -56, -55, -54, -53, -53, -52,
-51, -49, -49, -48, -48, -46, -46, -45, -44, -43, -43, -41, -42, -41, -39, -38,
-38, -37, -36, -36, -33, -33, -33, -31, -31, -30, -29, -28, -28, -27, -26, -25,
-24, -23, -21, -21, -20, -19, -19, -17, -16, -16, -15, -13, -13, -12, -12, -11,
-10, -9, -8, -7, -6, -5, -4, -4, -3, -2, -1, 0, 1, 2, };