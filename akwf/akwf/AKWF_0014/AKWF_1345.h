#define DATA_LENGTH 512
#define DATA AKWF_1345

const PROGMEM int8_t DATA[DATA_LENGTH] = {42, -93, -70, -47, -40, -21, -19, -4,
-4, 8, 7, 19, 17, 27, 26, 34, 33, 39, 39, 44, 44, 49, 49, 52, 54, 55, 57, 58,
62, 62, 65, 65, 67, 67, 70, 70, 72, 73, 74, 75, 77, 76, 79, 78, 80, 81, 82, 82,
82, 84, 84, 85, 86, 87, 87, 88, 89, 89, 89, 90, 91, 92, 93, 93, 93, 93, 94, 94,
94, 95, 95, 96, 97, 97, 98, 99, 99, 98, 100, 100, 99, 100, 100, 101, 101, 101,
102, 102, 102, 102, 104, 104, 104, 104, 103, 105, 105, 105, 105, 105, 106, 106,
106, 107, 107, 107, 107, 107, 107, 108, 107, 108, 108, 109, 108, 109, 109, 109,
109, 110, 109, 110, 111, 110, 111, 110, 110, 110, 111, 111, 111, 111, 111, 112,
111, 112, 112, 112, 112, 113, 112, 113, 112, 113, 113, 113, 114, 112, 114, 113,
114, 114, 113, 114, 114, 115, 114, 114, 114, 115, 115, 114, 115, 114, 116, 115,
115, 115, 115, 115, 115, 115, 115, 115, 116, 115, 116, 116, 116, 116, 116, 116,
116, 116, 116, 117, 116, 117, 117, 117, 117, 117, 116, 117, 117, 117, 117, 116,
117, 117, 118, 118, 118, 117, 118, 117, 118, 117, 117, 118, 117, 118, 118, 118,
118, 117, 117, 118, 117, 118, 118, 118, 117, 118, 118, 118, 118, 118, 118, 117,
118, 118, 119, 119, 119, 118, 118, 119, 118, 118, 118, 118, 118, 119, 119, 119,
118, 119, 119, 119, 119, 118, 118, 118, 119, 119, 120, 119, 118, 119, 118, 119,
118, 119, 119, 118, 118, 118, 118, 118, 118, 119, 119, 119, 119, 119, 120, 118,
119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 118, 119, 120, 119, 119,
119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 120,
119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 118, 119, 120, 119,
118, 119, 118, 119, 119, 119, 118, 118, 119, 119, 118, 118, 119, 118, 119, 119,
119, 119, 119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 118, 119, 119, 119,
118, 118, 118, 118, 118, 118, 118, 118, 118, 119, 119, 119, 119, 118, 119, 119,
118, 118, 118, 118, 118, 119, 119, 118, 118, 118, 118, 118, 118, 118, 117, 118,
118, 118, 118, 117, 118, 118, 118, 118, 118, 118, 117, 117, 118, 118, 118, 118,
118, 118, 118, 117, 118, 117, 117, 118, 117, 118, 118, 117, 118, 117, 117, 118,
118, 118, 117, 117, 117, 117, 117, 117, 118, 117, 118, 117, 117, 117, 117, 117,
117, 118, 118, 117, 118, 117, 117, 117, 116, 117, 116, 117, 117, 117, 116, 117,
117, 117, 117, 117, 118, 116, 116, 117, 117, 117, 117, 117, 117, 116, 117, 117,
116, 117, 116, 117, 116, 117, 117, 117, 117, 116, 117, 116, 116, 115, 117, 116,
117, 113, 117, 113, 119, 113, 120, 111, 123, 99, };