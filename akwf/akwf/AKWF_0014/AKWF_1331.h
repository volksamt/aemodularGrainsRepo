#define DATA_LENGTH 512
#define DATA AKWF_1331

const PROGMEM int8_t DATA[DATA_LENGTH] = {18, 22, 21, 22, 20, 21, 20, 22, 20,
21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 20, 21, 21, 21,
22, 21, 21, 21, 21, 21, 21, 21, 21, 22, 22, 21, 21, 22, 21, 21, 20, 21, 21, 22,
20, 21, 20, 23, 21, 22, 20, 22, 20, 23, 19, 23, 20, 24, 17, 28, 101, 99, 99,
100, 98, 100, 98, 100, 98, 100, 97, 100, 99, 99, 98, 99, 99, 99, 98, 99, 99, 99,
99, 100, 99, 98, 99, 99, 99, 99, 98, 99, 99, 98, 99, 99, 100, 99, 99, 100, 99,
100, 99, 99, 99, 99, 99, 99, 99, 99, 99, 99, 99, 99, 99, 99, 99, 99, 98, 98, 99,
98, 115, 120, 117, 119, 117, 119, 117, 119, 118, 118, 117, 118, 118, 119, 118,
118, 118, 118, 119, 119, 117, 118, 117, 118, 119, 118, 119, 118, 118, 117, 118,
118, 119, 118, 119, 119, 118, 118, 118, 118, 119, 118, 118, 118, 118, 118, 118,
118, 117, 119, 118, 118, 117, 119, 117, 119, 118, 119, 117, 118, 117, 119, 117,
119, 116, 70, 66, 68, 67, 68, 67, 68, 67, 67, 66, 68, 66, 68, 66, 67, 67, 67,
67, 67, 67, 67, 67, 68, 67, 67, 66, 68, 67, 67, 67, 67, 67, 67, 67, 67, 66, 67,
67, 67, 68, 67, 67, 66, 67, 66, 67, 66, 68, 66, 67, 67, 68, 66, 68, 66, 67, 66,
68, 66, 68, 67, 66, 72, -13, -30, -20, -27, -21, -26, -22, -26, -22, -25, -22,
-25, -23, -25, -24, -25, -23, -25, -24, -24, -24, -24, -24, -23, -24, -23, -25,
-23, -24, -23, -24, -24, -24, -23, -24, -24, -25, -24, -24, -25, -23, -24, -23,
-23, -24, -24, -25, -23, -24, -24, -25, -23, -25, -23, -24, -23, -25, -23, -25,
-22, -26, -22, -27, -21, -29, -101, -101, -100, -101, -99, -102, -99, -101,
-100, -102, -100, -102, -99, -101, -101, -101, -100, -100, -100, -101, -100,
-101, -100, -101, -101, -101, -101, -101, -101, -99, -101, -101, -101, -100,
-101, -101, -101, -100, -101, -100, -100, -101, -100, -100, -100, -101, -100,
-101, -100, -100, -100, -100, -100, -101, -101, -100, -101, -100, -100, -100,
-102, -99, -101, -99, -105, -119, -117, -118, -117, -117, -118, -117, -118,
-118, -117, -117, -117, -117, -118, -117, -118, -117, -117, -118, -118, -118,
-117, -117, -117, -118, -117, -118, -118, -117, -118, -117, -117, -117, -117,
-117, -118, -118, -118, -117, -118, -117, -117, -118, -117, -117, -117, -118,
-117, -118, -117, -117, -116, -119, -117, -118, -116, -118, -117, -118, -117,
-118, -116, -68, -63, -67, -63, -66, -64, -65, -63, -65, -64, -65, -64, -64,
-65, -65, -64, -65, -65, -64, -65, -65, -65, -65, -65, -65, -65, -65, -65, -65,
-64, -65, -65, -65, -64, -65, -64, -65, -64, -65, -65, -65, -65, -64, -65, -65,
-65, -65, -65, -65, -65, -65, -65, -64, -66, -63, -66, -63, -66, -63, -66, -63,
-67, -62, -69, -54, };