#define DATA_LENGTH 512
#define DATA AKWF_1372

const PROGMEM int8_t DATA[DATA_LENGTH] = {78, 117, 104, 110, 103, 107, 103, 104,
101, 101, 99, 100, 97, 98, 96, 95, 95, 95, 93, 92, 92, 90, 90, 88, 88, 86, 86,
85, 85, 83, 83, 81, 80, 80, 78, 77, 77, 76, 75, 74, 73, 72, 71, 70, 69, 68, 68,
67, 66, 66, 64, 63, 62, 62, 61, 59, 59, 58, 56, 56, 55, 54, 54, 53, 52, 52, 50,
49, 49, 47, 47, 45, 45, 45, 43, 43, 42, 41, 40, 38, 38, 37, 35, 35, 35, 34, 34,
32, 31, 31, 29, 29, 28, 27, 26, 25, 24, 24, 23, 22, 21, 20, 20, 19, 18, 16, 16,
15, 14, 14, 12, 12, 11, 10, 9, 8, 8, 7, 5, 6, 4, 3, 3, 1, 2, 0, -1, -2, -2, -3,
-4, -5, -6, -6, -8, -8, -9, -9, -11, -11, -12, -13, -14, -15, -16, -16, -17,
-18, -19, -20, -21, -21, -22, -23, -23, -24, -25, -26, -26, -27, -28, -28, -30,
-31, -31, -32, -33, -33, -34, -35, -36, -37, -39, -39, -39, -40, -42, -42, -43,
-43, -44, -45, -45, -46, -48, -48, -49, -49, -50, -52, -52, -53, -53, -54, -56,
-55, -56, -57, -58, -59, -60, -61, -62, -62, -62, -63, -64, -64, -66, -66, -67,
-68, -68, -70, -70, -71, -72, -73, -73, -75, -75, -76, -76, -76, -78, -79, -79,
-80, -81, -82, -82, -83, -83, -84, -85, -86, -87, -87, -88, -89, -90, -89, -92,
-91, -93, -93, -95, -93, -97, -94, -99, -96, -100, -95, -107, -71, 83, 113, 105,
108, 103, 107, 102, 104, 100, 102, 100, 101, 97, 98, 96, 96, 94, 95, 92, 92, 92,
91, 90, 89, 88, 87, 87, 84, 84, 82, 82, 80, 81, 80, 79, 78, 77, 76, 75, 74, 73,
73, 71, 70, 69, 69, 68, 66, 66, 66, 64, 64, 63, 62, 61, 60, 59, 57, 57, 56, 55,
55, 54, 52, 52, 51, 51, 49, 48, 48, 46, 46, 46, 44, 44, 42, 41, 40, 39, 39, 38,
37, 36, 35, 34, 34, 32, 32, 31, 30, 29, 29, 27, 27, 25, 25, 24, 23, 23, 22, 21,
20, 20, 18, 17, 17, 16, 14, 14, 14, 12, 12, 11, 10, 9, 8, 8, 7, 6, 5, 4, 3, 2,
2, 0, 1, -1, -2, -2, -2, -5, -4, -5, -6, -7, -8, -9, -10, -10, -12, -12, -12,
-15, -14, -15, -17, -17, -18, -19, -19, -20, -21, -22, -23, -24, -25, -25, -26,
-27, -28, -28, -30, -30, -31, -31, -32, -34, -34, -35, -36, -36, -37, -39, -38,
-40, -41, -40, -42, -43, -43, -45, -45, -46, -46, -48, -48, -49, -50, -50, -51,
-52, -53, -54, -54, -54, -56, -57, -57, -58, -59, -60, -60, -61, -61, -64, -63,
-64, -64, -66, -66, -66, -69, -69, -70, -71, -71, -72, -73, -73, -73, -75, -75,
-76, -78, -77, -79, -79, -81, -81, -82, -82, -83, -83, -85, -85, -86, -87, -88,
-88, -89, -90, -90, -91, -91, -94, -93, -95, -93, -98, -94, -100, -94, -102,
-94, -108, -78, };