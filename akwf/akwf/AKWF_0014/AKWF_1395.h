#define DATA_LENGTH 512
#define DATA AKWF_1395

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 5, 8, 7, 9, 8, 8, 9, 10,
11, 10, 11, 13, 14, 14, 16, 18, 19, 21, 23, 26, 26, 30, 32, 33, 35, 38, 38, 40,
42, 42, 43, 44, 44, 44, 45, 45, 45, 44, 44, 44, 44, 44, 42, 43, 41, 41, 41, 40,
40, 40, 39, 40, 39, 40, 40, 40, 41, 43, 44, 45, 45, 47, 49, 50, 50, 51, 52, 55,
56, 58, 61, 63, 65, 68, 71, 73, 75, 77, 80, 82, 83, 86, 88, 89, 90, 91, 92, 93,
94, 96, 97, 97, 97, 97, 97, 98, 98, 98, 97, 97, 97, 97, 96, 97, 97, 96, 96, 95,
96, 95, 94, 94, 93, 92, 93, 93, 91, 91, 91, 90, 90, 91, 92, 91, 91, 92, 92, 94,
95, 96, 96, 98, 99, 100, 101, 101, 102, 103, 104, 104, 104, 105, 105, 104, 106,
106, 106, 105, 105, 106, 105, 105, 105, 105, 105, 104, 104, 104, 104, 102, 101,
101, 100, 100, 99, 98, 97, 96, 94, 93, 91, 89, 87, 86, 83, 80, 78, 76, 72, 69,
65, 60, 55, 49, 45, 40, 34, 28, 21, 15, 9, 3, -2, -7, -13, -17, -21, -25, -30,
-33, -36, -39, -43, -46, -50, -52, -55, -59, -61, -63, -66, -69, -72, -73, -76,
-77, -79, -81, -82, -85, -86, -87, -88, -90, -91, -92, -94, -95, -96, -98, -100,
-101, -104, -105, -107, -109, -111, -112, -114, -113, -114, -116, -117, -117,
-118, -118, -118, -119, -119, -118, -118, -118, -117, -117, -115, -114, -113,
-110, -111, -110, -109, -109, -109, -109, -109, -108, -108, -108, -107, -106,
-105, -104, -104, -102, -100, -99, -98, -96, -94, -92, -92, -90, -88, -87, -86,
-86, -85, -84, -83, -83, -84, -83, -83, -83, -83, -84, -83, -83, -84, -84, -85,
-85, -85, -86, -85, -85, -86, -85, -84, -85, -83, -83, -81, -79, -77, -75, -74,
-73, -71, -70, -68, -66, -65, -64, -61, -60, -58, -56, -53, -51, -48, -47, -44,
-42, -41, -39, -36, -35, -33, -31, -30, -28, -26, -25, -23, -22, -20, -18, -17,
-15, -14, -12, -11, -9, -7, -6, -6, -4, -1, 0, 1, 3, 4, 5, 7, 9, 9, 10, 11, 13,
14, 14, 16, 16, 17, 18, 19, 21, 22, 23, 25, 26, 27, 29, 30, 32, 34, 36, 36, 37,
39, 40, 41, 42, 43, 44, 45, 45, 46, 46, 46, 47, 46, 46, 45, 46, 46, 46, 45, 46,
45, 45, 46, 46, 45, 45, 44, 44, 44, 44, 44, 43, 44, 44, 42, 42, 43, 43, 41, 41,
40, 40, 39, 40, 40, 39, 38, 37, 35, 33, 31, 28, 26, 22, 19, 16, 13, 8, 7, 3, 2,
0, -2, -4, -5, -5, -6, -7, -8, -9, -9, -10, -10, -9, -10, -10, -10, -9, -9, -8,
-8, -7, -7, -5, -5, -4, -3, -2, -2, -1, 1, 2, 1, 2, 2, 2, 1, 1, 1, 0, -1, 0, -1,
-2, -1, -2, -2, -2, -2, -2, -2, -3, -3, -2, -1, -1, 0, 0, };