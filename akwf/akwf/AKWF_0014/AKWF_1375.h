#define DATA_LENGTH 512
#define DATA AKWF_1375

const PROGMEM int8_t DATA[DATA_LENGTH] = {15, 28, 30, 35, 38, 42, 45, 50, 51,
54, 57, 59, 61, 62, 64, 65, 67, 67, 69, 69, 70, 70, 72, 72, 72, 73, 73, 73, 73,
74, 73, 73, 73, 73, 72, 72, 73, 73, 73, 73, 72, 73, 72, 72, 72, 71, 71, 71, 71,
71, 70, 70, 70, 71, 71, 70, 70, 71, 71, 72, 72, 73, 73, 73, 74, 74, 74, 75, 75,
76, 76, 76, 76, 76, 76, 76, 76, 75, 75, 75, 74, 73, 72, 73, 71, 70, 69, 69, 68,
67, 66, 65, 64, 62, 62, 61, 60, 57, 57, 55, 54, 51, 50, 49, 47, 44, 43, 41, 39,
36, 34, 32, 28, 26, 24, 21, 19, 17, 15, 14, 11, 9, 7, 6, 5, 3, 3, 0, 0, -2, -3,
-4, -4, -6, -6, -6, -6, -6, -7, -7, -9, -8, -9, -8, -9, -10, -9, -10, -9, -10,
-10, -11, -11, -10, -12, -11, -11, -11, -12, -11, -11, -11, -11, -12, -12, -12,
-11, -12, -13, -14, -13, -13, -15, -15, -16, -16, -18, -18, -17, -18, -19, -20,
-19, -21, -21, -21, -20, -21, -21, -21, -20, -20, -20, -19, -18, -19, -17, -18,
-17, -16, -16, -15, -15, -14, -15, -14, -14, -13, -13, -11, -11, -10, -10, -9,
-8, -6, -6, -5, -4, -3, -1, 0, 0, 3, 4, 6, 7, 7, 9, 11, 12, 13, 14, 15, 15, 16,
16, 17, 18, 18, 19, 19, 20, 21, 22, 22, 22, 24, 24, 25, 26, 26, 28, 29, 29, 31,
33, 32, 33, 35, 36, 36, 37, 36, 38, 38, 38, 38, 38, 37, 38, 37, 37, 37, 37, 35,
35, 35, 34, 33, 44, 52, 52, 51, 50, 51, 50, 50, 50, 51, 50, 49, 49, 49, 49, 49,
47, 47, 46, 46, 44, 44, 43, 42, 41, 41, 39, 38, 36, 36, 35, 34, 33, 32, 31, 31,
30, 29, 29, 27, 27, 26, 26, 25, 24, 24, 22, 21, 21, 19, 18, 27, 32, 29, 29, 27,
26, 24, 23, 22, 21, 20, 19, 18, 17, 15, 15, 14, 14, 13, 12, 10, 10, 8, 8, 6, 6,
4, 4, 3, 1, 1, -1, -2, -4, -5, -7, -9, -9, -11, -12, -14, -16, -16, -18, -19,
-20, -22, -22, -24, -25, -26, -27, -28, -29, -29, -30, -32, -32, -34, -35, -36,
-37, -39, -41, -42, -44, -45, -47, -49, -51, -53, -54, -55, -56, -58, -60, -61,
-63, -64, -64, -65, -66, -67, -68, -69, -69, -70, -71, -71, -73, -73, -74, -74,
-74, -75, -77, -78, -78, -79, -80, -80, -81, -83, -83, -83, -84, -85, -85, -86,
-85, -86, -87, -87, -87, -87, -87, -87, -88, -87, -87, -87, -87, -88, -87, -88,
-89, -90, -93, -94, -96, -99, -101, -104, -108, -109, -111, -112, -114, -115,
-117, -117, -119, -118, -119, -119, -119, -118, -118, -117, -116, -115, -114,
-113, -111, -108, -106, -103, -102, -99, -96, -94, -92, -89, -86, -83, -80, -76,
-72, -68, -64, -59, -54, -50, -46, -41, -37, -32, -28, -22, -20, -9, };