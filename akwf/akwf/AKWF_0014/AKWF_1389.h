#define DATA_LENGTH 512
#define DATA AKWF_1389

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 14, 21, 28, 35, 41, 46, 51, 57,
62, 67, 73, 77, 81, 86, 92, 96, 100, 104, 106, 108, 110, 112, 113, 114, 115,
116, 117, 118, 117, 117, 118, 119, 118, 118, 118, 119, 118, 119, 119, 119, 118,
119, 118, 119, 118, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 119, 118,
119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 120, 119, 119, 120, 119, 118, 119, 119, 120, 119, 119, 118, 119, 119,
119, 119, 119, 119, 119, 119, 120, 118, 119, 120, 119, 119, 119, 118, 119, 120,
119, 119, 119, 119, 118, 119, 120, 119, 119, 119, 118, 118, 119, 118, 119, 119,
119, 119, 119, 119, 118, 119, 118, 119, 119, 118, 118, 119, 119, 117, 118, 117,
119, 118, 118, 118, 118, 116, 117, 118, 117, 117, 117, 116, 117, 116, 115, 115,
115, 115, 114, 114, 113, 113, 113, 112, 112, 111, 110, 110, 109, 109, 108, 107,
106, 105, 104, 103, 102, 99, 98, 97, 96, 94, 94, 94, 91, 90, 90, 88, 86, 86, 84,
83, 81, 80, 80, 78, 77, 77, 77, 75, 74, 74, 74, 75, 75, 75, 75, 75, 74, 75, 74,
73, 73, 71, 69, 69, 67, 63, 64, 61, 59, 58, 56, 57, 54, 54, 52, 52, 51, 49, 49,
48, 46, 46, 44, 43, 42, 41, 39, 38, 37, 36, 35, 32, 31, 30, 29, 26, 24, 22, 20,
19, 16, 14, 12, 10, 8, 6, 4, 2, 0, -3, -5, -8, -10, -13, -15, -17, -20, -22,
-24, -27, -30, -33, -35, -38, -40, -42, -44, -47, -50, -52, -55, -57, -59, -62,
-64, -66, -68, -71, -73, -75, -77, -80, -81, -84, -86, -89, -90, -94, -96, -97,
-100, -101, -103, -105, -106, -106, -107, -109, -109, -109, -111, -111, -111,
-112, -112, -113, -113, -114, -114, -115, -116, -116, -117, -116, -116, -117,
-117, -118, -117, -117, -117, -118, -117, -118, -118, -118, -118, -118, -118,
-119, -119, -118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -118, -119, -120,
-119, -119, -119, -119, -119, -120, -119, -120, -119, -118, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -118, -118,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-120, -119, -120, -119, -120, -119, -119, -119, -119, -118, -120, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-118, -120, -119, -119, -120, -119, -120, -120, -119, -119, -119, -118, -119,
-119, -120, -119, -120, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -118, -119, -118, -119, -118, -118, -118, -118, -118, -116, -115,
-114, -112, -111, -109, -104, -102, -99, -94, -90, -85, -81, -77, -72, -69, -64,
-61, -56, -52, -47, -42, -36, -30, -25, -18, -11, -5, };