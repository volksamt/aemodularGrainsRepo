#define DATA_LENGTH 512
#define DATA AKWF_1310

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 11, 16, 19, 23, 27, 31, 34, 37,
39, 43, 46, 49, 52, 54, 56, 59, 61, 63, 64, 67, 69, 71, 73, 74, 76, 78, 79, 82,
82, 84, 85, 86, 87, 88, 90, 92, 92, 93, 95, 95, 96, 96, 98, 98, 99, 100, 100,
102, 102, 103, 103, 103, 104, 105, 106, 107, 107, 107, 107, 109, 108, 108, 109,
110, 110, 111, 110, 111, 111, 111, 112, 112, 113, 112, 113, 113, 114, 113, 114,
114, 114, 114, 115, 114, 116, 115, 114, 115, 115, 116, 115, 115, 116, 116, 117,
115, 116, 116, 117, 117, 116, 117, 116, 117, 117, 117, 118, 118, 118, 117, 118,
117, 118, 118, 118, 118, 117, 117, 118, 118, 117, 118, 118, 118, 118, 118, 119,
118, 118, 119, 119, 118, 119, 119, 119, 118, 118, 119, 119, 118, 118, 119, 118,
119, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 118,
120, 119, 119, 119, 119, 118, 119, 119, 119, 120, 119, 120, 120, 119, 119, 119,
119, 119, 119, 118, 120, 119, 119, 119, 119, 120, 118, 119, 119, 118, 119, 119,
118, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 120, 120, 119, 119, 119, 120, 119, 120, 119, 119, 119, 119, 120, 119, 119,
119, 119, 120, 118, 119, 119, 119, 119, 119, 119, 118, 119, 118, 111, 102, 95,
85, 78, 71, 64, 58, 50, 45, 38, 31, 26, 20, 16, 10, 5, 1, -4, -8, -11, -16, -20,
-25, -27, -31, -34, -37, -40, -43, -46, -49, -52, -54, -57, -59, -61, -63, -65,
-68, -69, -72, -73, -75, -76, -78, -80, -81, -82, -83, -86, -87, -88, -90, -90,
-90, -92, -93, -94, -95, -96, -98, -97, -98, -99, -101, -100, -102, -102, -103,
-104, -103, -105, -105, -106, -106, -107, -106, -107, -108, -108, -108, -109,
-110, -110, -111, -111, -111, -111, -112, -111, -112, -113, -113, -113, -113,
-113, -113, -114, -114, -114, -114, -114, -115, -114, -115, -115, -115, -116,
-116, -116, -116, -116, -116, -116, -117, -117, -117, -116, -116, -118, -117,
-116, -118, -117, -117, -117, -118, -118, -118, -117, -118, -118, -117, -118,
-117, -117, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118,
-118, -119, -118, -119, -119, -119, -118, -119, -119, -118, -118, -119, -119,
-119, -119, -118, -119, -119, -118, -119, -119, -118, -119, -120, -118, -119,
-119, -118, -119, -118, -119, -118, -119, -120, -120, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -118, -119, -119,
-120, -119, -118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -120, -119, -119, -119, -119, -119, -119, -120, -120, -119, -120, -119,
-119, -118, -120, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-118, -120, -119, -118, -111, -101, -93, -85, -78, -71, -63, -56, -50, -43, -37,
-31, -26, -20, -15, -11, -4, 0, };