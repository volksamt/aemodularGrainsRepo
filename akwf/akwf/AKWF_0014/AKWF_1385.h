#define DATA_LENGTH 512
#define DATA AKWF_1385

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 0, 1, 4, 3, 4, 5, 6, 7, 6, 8, 8, 8,
10, 9, 11, 11, 9, 8, 9, 10, 7, 9, 7, 8, 8, 7, 8, 9, 7, 6, 6, 3, 4, 3, 0, -1, -3,
-3, -2, -1, 2, 2, 6, 7, 10, 16, 19, 21, 25, 28, 31, 29, 32, 34, 35, 39, 35, 36,
32, 35, 33, 33, 31, 28, 31, 26, 24, 23, 22, 17, 14, 14, 10, 5, 5, 3, 0, -4, -4,
-1, 1, -2, 1, 5, 2, 5, 4, 10, 13, 13, 19, 21, 29, 30, 37, 35, 39, 44, 42, 43,
48, 48, 46, 50, 47, 51, 47, 41, 39, 38, 36, 31, 28, 27, 29, 26, 24, 21, 24, 25,
19, 20, 23, 24, 19, 18, 24, 20, 18, 18, 16, 20, 21, 27, 25, 31, 28, 41, 45, 46,
50, 49, 60, 62, 64, 62, 66, 69, 72, 73, 76, 73, 72, 65, 67, 70, 65, 68, 64, 65,
60, 63, 58, 57, 62, 52, 52, 47, 43, 41, 35, 34, 30, 33, 30, 31, 31, 30, 33, 22,
29, 27, 28, 31, 33, 31, 28, 35, 28, 31, 36, 36, 34, 39, 40, 42, 41, 38, 48, 42,
46, 42, 53, 31, -38, -35, -40, -45, -39, -42, -37, -33, -34, -26, -24, -26, -16,
-15, -7, -9, -7, 4, 9, 15, 23, 30, 34, 42, 48, 50, 63, 63, 65, 72, 72, 77, 83,
87, 85, 90, 99, 97, 102, 104, 103, 106, 104, 105, 103, 101, 96, 94, 90, 85, 83,
69, 71, 63, 52, 50, 43, 38, 29, 24, 20, 12, 9, 3, -6, -6, -16, -18, -18, -21,
-25, -29, -28, -35, -32, -38, -40, -42, -46, -50, -47, -48, -49, -46, -50, -48,
-47, -46, -46, -46, -51, -55, -61, -62, -70, -74, -81, -89, -94, -98, -102,
-106, -109, -108, -112, -113, -116, -120, -115, -117, -112, -115, -112, -112,
-110, -106, -107, -102, -100, -97, -95, -89, -84, -82, -76, -71, -69, -63, -60,
-53, -53, -53, -53, -50, -51, -51, -47, -49, -45, -49, -49, -48, -49, -50, -53,
-53, -56, -53, -55, -56, -54, -54, -56, -56, -54, -55, -53, -54, -51, -47, -45,
-43, -41, -37, -35, -34, -33, -31, -29, -26, -27, -27, -23, -23, -23, -22, -19,
-18, -20, -17, -17, -15, -14, -16, -16, -18, -16, -17, -17, -21, -21, -22, -23,
-22, -26, -26, -26, -26, -27, -27, -29, -27, -27, -26, -25, -24, -25, -24, -24,
-24, -22, -22, -20, -21, -19, -19, -19, -17, -17, -15, -14, -14, -11, -11, -10,
-10, -9, -9, -8, -8, -8, -6, -6, -6, -7, -6, -6, -6, -5, -6, -5, -6, -6, -5, -6,
-6, -6, -6, -6, -6, -7, -6, -7, -7, -7, -7, -8, -7, -8, -8, -8, -8, -8, -9, -8,
-8, -8, -9, -8, -8, -7, -6, -6, -6, -6, -7, -7, -7, -5, -6, -6, -6, -7, -6, -6,
-5, -4, -4, -5, -4, -3, -3, -5, -4, -5, -4, -5, -6, -3, -6, -5, -4, -3, -3, -2,
-2, -2, };