#define DATA_LENGTH 512
#define DATA AKWF_1382

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 11, 14, 19, 22, 27, 30, 34, 37,
40, 44, 46, 48, 51, 54, 56, 58, 61, 63, 64, 67, 68, 69, 70, 71, 71, 72, 72, 72,
72, 73, 73, 72, 72, 71, 70, 69, 68, 67, 66, 65, 64, 61, 60, 58, 55, 55, 53, 50,
48, 45, 43, 40, 38, 36, 34, 31, 28, 26, 23, 21, 17, 15, 12, 9, 7, 5, 2, 1, -3,
-4, -7, -9, -12, -14, -16, -18, -20, -22, -24, -26, -26, -28, -30, -31, -33,
-33, -35, -36, -37, -37, -38, -40, -40, -40, -41, -42, -42, -42, -42, -41, -41,
-41, -40, -41, -40, -39, -40, -39, -37, -37, -36, -35, -34, -33, -32, -30, -30,
-28, -27, -26, -24, -23, -22, -20, -19, -17, -16, -15, -13, -11, -10, -9, -7,
-5, -4, -3, -1, 0, 1, 3, 4, 5, 7, 8, 10, 10, 11, 13, 14, 14, 16, 16, 17, 18, 19,
19, 20, 21, 21, 22, 22, 23, 23, 23, 23, 23, 24, 23, 24, 23, 25, 24, 24, 24, 23,
23, 22, 22, 21, 21, 20, 20, 20, 19, 18, 17, 16, 16, 15, 14, 14, 12, 12, 11, 11,
9, 8, 8, 7, 6, 6, 4, 4, 4, 2, 2, 0, -1, -1, -2, -2, -3, -3, -5, -6, -6, -7, -7,
-8, -9, -9, -10, -10, -11, -11, -11, -12, -12, -13, -13, -13, -13, -13, -13,
-14, -13, -13, -14, -14, -14, -13, -13, -14, -13, -13, -13, -12, -13, -13, -12,
-11, -12, -11, -10, -10, -10, -9, -10, -8, -9, -8, -8, -7, -7, -6, -6, -6, -5,
-4, -4, -3, -3, -2, -2, -1, 0, 0, 1, 1, 1, 1, 2, 3, 3, 3, 3, 3, 4, 4, 5, 5, 5,
5, 6, 7, 6, 6, 7, 7, 7, 7, 7, 7, 8, 7, 8, 8, 8, 7, 7, 7, 8, 8, 7, 7, 7, 7, 7, 7,
6, 7, 6, 7, 7, 7, 6, 6, 5, 5, 5, 5, 5, 4, 4, 3, 2, 2, 3, 2, 2, 2, 1, 1, 1, 0, 0,
0, 0, -1, -1, 0, -2, -2, -2, -2, -2, -2, -2, -3, -4, -3, -3, -3, -3, -4, -3, -4,
-4, -4, -5, -4, -4, -4, -4, -4, -5, -5, -4, -5, -4, -5, -5, -4, -4, -5, -4, -4,
-4, -4, -4, -4, -4, -3, -3, -3, -4, -4, -2, -4, -2, -3, -3, -2, -3, -1, -2, -2,
-2, -1, -1, -1, -1, 0, -1, -1, -1, 1, 1, 0, 0, 0, 0, 1, 1, 2, 0, 2, 1, 2, 1, 2,
2, 3, 2, 2, 2, 2, 3, 2, 2, 3, 3, 2, 3, 2, 3, 3, 3, 3, 2, 2, 2, 3, 2, 3, 3, 3, 2,
3, 1, 3, 1, 3, 2, 3, 2, 3, 1, 3, 0, 1, 2, 0, 2, -1, 3, -5, 12, -84, -128, -109,
-118, -106, -110, -102, -104, -97, -96, -90, -88, -83, -80, -75, -71, -67, -62,
-59, -53, -50, -45, -42, -35, -32, -26, -23, -17, -14, -9, -4, 0, };