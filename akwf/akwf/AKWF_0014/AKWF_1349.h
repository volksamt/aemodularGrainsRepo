#define DATA_LENGTH 512
#define DATA AKWF_1349

const PROGMEM int8_t DATA[DATA_LENGTH] = {-79, -94, -86, -89, -84, -87, -82,
-85, -80, -82, -79, -81, -77, -79, -75, -76, -73, -74, -73, -71, -70, -69, -68,
-68, -68, -66, -66, -65, -64, -63, -62, -61, -62, -60, -59, -59, -58, -57, -57,
-55, -56, -54, -54, -54, -52, -51, -51, -51, -50, -49, -49, -48, -47, -47, -46,
-46, -46, -45, -44, -44, -43, -43, -42, -42, -41, -41, -40, -40, -39, -38, -38,
-38, -37, -36, -36, -36, -35, -35, -34, -34, -33, -34, -32, -32, -32, -31, -31,
-30, -30, -29, -30, -29, -29, -28, -27, -28, -28, -27, -27, -27, -25, -25, -25,
-24, -25, -24, -23, -23, -23, -22, -23, -23, -22, -22, -22, -21, -20, -20, -20,
-21, -20, -20, -19, -19, -19, -19, -19, -18, -18, -18, -17, -17, -17, -16, -17,
-16, -15, -16, -16, -15, -15, -15, -15, -14, -14, -13, -14, -14, -13, -13, -12,
-12, -12, -13, -11, -12, -12, -12, -12, -12, -11, -11, -11, -10, -10, -10, -10,
-10, -9, -10, -10, -10, -9, -10, -9, -9, -8, -8, -9, -7, -8, -8, -8, -7, -8, -7,
-6, -7, -7, -7, -7, -6, -6, -6, -6, -6, -6, -6, -5, -6, -5, -5, -5, -5, -4, -4,
-5, -5, -5, -4, -5, -3, -4, -4, -3, -3, -3, -2, -3, -3, -3, -3, -3, -3, -2, -3,
-2, -2, -2, -2, -1, -1, -1, -2, -1, -1, -1, -1, -1, 0, -1, 0, 0, 0, -1, 0, 0, 0,
0, 1, 0, 1, 0, 1, 1, 2, 1, 1, 1, 2, 2, 2, 2, 3, 2, 2, 2, 2, 2, 3, 3, 3, 3, 3, 3,
4, 3, 3, 3, 4, 4, 4, 5, 5, 5, 4, 5, 5, 5, 6, 5, 5, 5, 6, 6, 6, 6, 6, 6, 7, 7, 7,
7, 7, 8, 8, 7, 7, 8, 8, 8, 8, 8, 8, 8, 9, 9, 9, 9, 10, 10, 10, 10, 9, 11, 10,
10, 11, 11, 11, 11, 12, 12, 12, 11, 13, 12, 13, 13, 13, 14, 14, 14, 14, 14, 14,
15, 15, 15, 15, 15, 16, 17, 16, 17, 16, 17, 17, 17, 17, 17, 17, 18, 19, 19, 19,
19, 18, 19, 21, 20, 20, 20, 22, 22, 22, 22, 22, 23, 22, 23, 23, 23, 24, 24, 25,
25, 25, 26, 26, 26, 26, 26, 27, 28, 27, 28, 29, 29, 29, 30, 30, 30, 31, 32, 31,
33, 33, 33, 34, 34, 35, 35, 35, 35, 36, 37, 37, 37, 38, 39, 39, 40, 40, 41, 41,
42, 43, 43, 43, 44, 45, 45, 45, 46, 46, 46, 48, 49, 49, 49, 50, 50, 51, 52, 53,
53, 53, 54, 55, 56, 57, 58, 59, 60, 59, 60, 61, 62, 62, 64, 64, 65, 67, 67, 67,
68, 69, 70, 71, 72, 73, 74, 74, 75, 76, 77, 78, 79, 81, 81, 83, 82, 84, 85, 87,
88, 89, 90, 91, 91, 94, 94, 95, 97, 97, 100, 100, 102, 102, 106, 104, 108, 106,
111, 107, 115, 111, 119, 110, 125, 101, };