#define DATA_LENGTH 512
#define DATA AKWF_1396

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 3, 4, 5, 7, 9, 10, 11, 13,
15, 17, 18, 21, 24, 25, 28, 30, 33, 35, 37, 40, 42, 45, 47, 50, 52, 56, 59, 61,
64, 67, 70, 73, 75, 78, 80, 83, 85, 87, 90, 91, 94, 96, 98, 100, 101, 103, 105,
106, 108, 109, 110, 112, 113, 114, 115, 116, 117, 118, 118, 118, 119, 119, 120,
119, 119, 119, 119, 118, 118, 118, 117, 117, 116, 115, 115, 114, 114, 113, 113,
111, 111, 109, 108, 107, 105, 104, 103, 101, 101, 99, 97, 96, 95, 94, 92, 90,
89, 87, 86, 85, 83, 82, 79, 78, 77, 75, 73, 71, 70, 68, 66, 65, 63, 62, 60, 58,
57, 56, 54, 53, 52, 51, 50, 49, 48, 47, 46, 45, 44, 44, 42, 40, 40, 39, 36, 36,
34, 33, 32, 31, 29, 27, 26, 24, 23, 21, 20, 18, 18, 16, 15, 14, 12, 11, 10, 9,
7, 6, 5, 4, 4, 2, 2, 1, 0, 0, -1, -1, -2, -2, -3, -2, -3, -2, -3, -2, -2, -2,
-2, -2, -1, -1, -1, 1, 2, 2, 4, 4, 5, 6, 6, 9, 9, 10, 11, 13, 14, 15, 16, 17,
19, 20, 21, 23, 23, 25, 25, 27, 28, 29, 31, 31, 32, 32, 34, 34, 35, 37, 37, 38,
38, 39, 39, 39, 40, 41, 40, 40, 40, 40, 41, 40, 40, 40, 39, 38, 38, 38, 36, 35,
34, 33, 32, 31, 29, 27, 25, 23, 22, 19, 16, 15, 12, 9, 8, 6, 5, 2, 2, 0, -2, -3,
-3, -5, -6, -7, -7, -8, -8, -8, -8, -10, -10, -11, -11, -11, -11, -11, -11, -11,
-11, -11, -12, -11, -12, -10, -10, -10, -10, -9, -9, -9, -8, -8, -8, -7, -6, -7,
-7, -6, -5, -5, -5, -5, -4, -4, -3, -2, -2, -2, -2, -2, -1, -2, -1, 0, -1, -1,
-1, -1, -1, -2, -1, -2, -2, -2, -4, -4, -5, -4, -6, -6, -7, -9, -10, -13, -13,
-15, -17, -19, -21, -22, -24, -26, -28, -30, -32, -33, -35, -36, -38, -40, -41,
-43, -44, -46, -47, -48, -51, -53, -54, -55, -58, -59, -60, -61, -63, -64, -66,
-67, -69, -69, -71, -72, -73, -74, -75, -75, -75, -77, -77, -77, -77, -78, -78,
-79, -80, -80, -82, -83, -83, -86, -87, -88, -90, -92, -94, -94, -97, -98, -100,
-101, -103, -104, -106, -107, -108, -109, -111, -111, -112, -112, -113, -112,
-113, -113, -113, -112, -111, -110, -110, -108, -108, -106, -105, -104, -103,
-100, -99, -98, -95, -94, -91, -90, -87, -86, -84, -81, -79, -77, -75, -74, -72,
-70, -67, -66, -63, -61, -59, -58, -56, -54, -53, -50, -48, -47, -44, -44, -41,
-40, -39, -37, -36, -35, -33, -32, -31, -30, -29, -28, -27, -27, -25, -24, -24,
-23, -21, -22, -21, -20, -20, -19, -19, -18, -17, -18, -17, -16, -16, -15, -15,
-14, -14, -13, -13, -12, -12, -12, -10, -10, -8, -7, -6, -5, -4, -3, -2, -2, 0,
};