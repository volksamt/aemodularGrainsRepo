#define DATA_LENGTH 512
#define DATA AKWF_1390

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 6, 10, 13, 18, 22, 25, 31, 35, 39,
44, 48, 52, 55, 60, 64, 68, 72, 76, 81, 85, 89, 94, 98, 101, 103, 106, 109, 109,
111, 112, 114, 114, 115, 115, 115, 116, 117, 117, 117, 117, 117, 118, 118, 118,
118, 118, 118, 118, 118, 119, 118, 119, 119, 119, 118, 119, 119, 118, 119, 119,
119, 119, 119, 118, 119, 119, 120, 119, 119, 119, 119, 120, 119, 119, 120, 118,
119, 118, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 118, 120,
119, 118, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119,
119, 119, 120, 119, 119, 119, 119, 119, 119, 120, 118, 118, 119, 119, 119, 119,
119, 119, 120, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 118, 119, 119, 120, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 118, 118, 118,
118, 119, 119, 119, 119, 119, 119, 120, 118, 119, 119, 119, 120, 119, 120, 119,
118, 119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 118, 118, 118, 119, 118, 118, 118, 118, 118, 117, 118, 117, 116,
116, 116, 116, 115, 115, 114, 112, 112, 111, 110, 108, 106, 105, 102, 100, 97,
95, 91, 87, 84, 80, 77, 73, 69, 64, 60, 55, 50, 45, 40, 35, 29, 23, 17, 12, 5,
1, -5, -10, -15, -20, -25, -28, -33, -37, -42, -45, -50, -53, -58, -61, -66,
-70, -74, -79, -83, -86, -91, -94, -99, -101, -104, -106, -109, -109, -111,
-112, -113, -114, -114, -116, -116, -116, -117, -117, -118, -117, -118, -119,
-118, -119, -118, -118, -118, -119, -118, -119, -118, -119, -119, -119, -118,
-118, -118, -118, -118, -119, -120, -119, -120, -119, -118, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -118, -119, -119, -118, -119, -119,
-120, -119, -119, -119, -119, -120, -120, -120, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -120, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -120, -119, -119, -119,
-118, -119, -118, -118, -120, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -120, -119,
-119, -120, -119, -119, -119, -119, -118, -119, -120, -120, -120, -119, -119,
-119, -120, -119, -118, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -120, -120, -119, -118, -119, -120,
-119, -118, -119, -119, -119, -118, -118, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -118, -119, -118, -118, -118, -118, -118, -118, -118, -117,
-118, -118, -117, -117, -116, -116, -116, -116, -114, -115, -113, -113, -112,
-111, -109, -106, -105, -103, -100, -97, -95, -90, -86, -81, -78, -74, -69, -65,
-61, -57, -53, -49, -44, -41, -36, -32, -28, -24, -19, -15, -11, -7, -3, };