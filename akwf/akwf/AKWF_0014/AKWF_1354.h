#define DATA_LENGTH 512
#define DATA AKWF_1354

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 25, 37, 44, 50, 57, 62, 66, 70, 73,
77, 79, 83, 85, 88, 90, 93, 94, 96, 98, 100, 101, 103, 104, 105, 106, 108, 109,
109, 111, 111, 112, 113, 114, 115, 115, 116, 116, 116, 117, 117, 117, 119, 118,
118, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 118, 118,
118, 118, 116, 117, 117, 116, 115, 116, 115, 115, 114, 114, 113, 112, 113, 112,
112, 110, 110, 110, 109, 108, 107, 107, 107, 106, 105, 105, 104, 104, 102, 101,
102, 100, 100, 99, 98, 98, 96, 96, 95, 94, 93, 93, 92, 91, 91, 90, 89, 88, 87,
85, 85, 85, 84, 82, 82, 81, 81, 78, 77, 78, 76, 75, 74, 73, 72, 71, 71, 70, 69,
68, 67, 65, 65, 64, 63, 62, 60, 60, 59, 58, 57, 55, 56, 54, 53, 53, 51, 50, 49,
48, 47, 46, 46, 44, 44, 42, 41, 41, 40, 38, 38, 37, 36, 34, 34, 33, 32, 31, 30,
28, 27, 26, 25, 25, 24, 23, 22, 21, 20, 18, 17, 18, 16, 14, 14, 13, 12, 11, 10,
9, 8, 7, 7, 6, 5, 4, 3, 1, 1, -1, -1, -1, -3, -3, -5, -5, -6, -7, -8, -8, -10,
-11, -11, -13, -14, -15, -16, -16, -17, -18, -20, -20, -21, -22, -22, -23, -23,
-24, -26, -26, -27, -28, -30, -30, -31, -31, -32, -34, -34, -36, -36, -37, -38,
-38, -39, -40, -41, -42, -43, -42, -44, -44, -45, -46, -46, -47, -48, -49, -50,
-51, -51, -52, -53, -53, -54, -56, -56, -56, -57, -58, -59, -59, -61, -60, -62,
-62, -62, -64, -64, -65, -65, -66, -66, -68, -68, -69, -69, -70, -71, -71, -72,
-73, -72, -73, -74, -74, -76, -76, -76, -77, -78, -78, -78, -80, -79, -80, -81,
-82, -82, -82, -84, -84, -83, -85, -84, -85, -87, -87, -87, -87, -88, -89, -89,
-89, -90, -90, -91, -91, -92, -93, -93, -94, -94, -94, -95, -95, -96, -96, -97,
-97, -97, -98, -99, -98, -99, -100, -99, -100, -101, -101, -101, -101, -102,
-103, -103, -103, -104, -103, -105, -104, -105, -105, -105, -105, -106, -107,
-107, -108, -107, -107, -107, -109, -108, -109, -109, -109, -110, -109, -110,
-110, -111, -110, -111, -111, -112, -111, -113, -112, -112, -112, -112, -113,
-113, -114, -113, -113, -114, -114, -115, -115, -115, -115, -115, -115, -115,
-116, -116, -115, -115, -117, -116, -116, -117, -117, -117, -116, -117, -117,
-118, -116, -117, -117, -118, -118, -118, -117, -118, -118, -118, -118, -118,
-118, -119, -118, -118, -119, -119, -119, -119, -118, -119, -119, -118, -119,
-119, -119, -119, -118, -119, -118, -120, -120, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -118, -119, -118, -118, -117, -118, -117, -118, -117, -117, -117,
-118, -116, -118, -117, -117, -117, -117, -117, -117, -116, -115, -116, -115,
-117, -115, -117, -115, -117, -113, -117, -112, -117, -112, -119, -110, -120,
-97, };