#define DATA_LENGTH 512
#define DATA AKWF_1365

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 2, 3, 4, 4, 6, 7, 9, 10, 12,
13, 13, 15, 18, 19, 20, 22, 23, 24, 27, 29, 30, 32, 33, 36, 37, 38, 41, 42, 44,
46, 47, 50, 51, 53, 54, 56, 57, 59, 61, 62, 64, 66, 67, 69, 71, 72, 73, 76, 77,
78, 79, 81, 83, 84, 85, 87, 88, 89, 91, 92, 92, 94, 95, 97, 98, 99, 100, 100,
102, 103, 104, 104, 105, 107, 107, 108, 110, 109, 111, 112, 112, 114, 113, 114,
115, 115, 116, 116, 117, 117, 118, 119, 119, 119, 118, 118, 117, 116, 115, 114,
112, 112, 110, 110, 108, 107, 107, 106, 105, 103, 102, 101, 100, 99, 99, 96, 96,
95, 94, 92, 91, 90, 88, 88, 88, 86, 84, 83, 83, 81, 80, 79, 77, 77, 76, 74, 73,
72, 70, 70, 68, 66, 66, 65, 64, 62, 61, 60, 58, 57, 56, 56, 54, 53, 51, 50, 49,
48, 47, 46, 45, 43, 41, 41, 40, 39, 38, 35, 35, 34, 33, 32, 30, 29, 28, 26, 25,
24, 23, 21, 20, 20, 18, 17, 16, 15, 14, 12, 12, 10, 9, 8, 7, 6, 5, 3, 3, 1, 0,
-1, -3, -4, -5, -6, -7, -8, -9, -9, -11, -12, -13, -14, -15, -16, -17, -18, -19,
-21, -21, -22, -22, -23, -24, -25, -26, -27, -27, -28, -30, -29, -31, -32, -32,
-34, -33, -35, -35, -36, -37, -37, -39, -39, -40, -41, -42, -42, -42, -43, -44,
-45, -45, -46, -47, -47, -47, -48, -49, -50, -49, -50, -51, -52, -52, -52, -53,
-53, -53, -54, -54, -55, -56, -55, -56, -56, -57, -57, -58, -58, -58, -59, -59,
-60, -59, -60, -60, -61, -61, -61, -61, -61, -62, -62, -62, -63, -63, -63, -64,
-63, -64, -64, -64, -64, -64, -65, -64, -64, -64, -65, -66, -64, -64, -65, -65,
-66, -65, -66, -66, -65, -66, -66, -66, -66, -66, -66, -66, -66, -65, -66, -65,
-66, -65, -66, -65, -65, -65, -66, -65, -64, -65, -65, -65, -64, -64, -65, -64,
-64, -64, -63, -64, -63, -63, -63, -63, -63, -62, -62, -61, -62, -62, -61, -61,
-62, -61, -60, -60, -60, -60, -60, -59, -59, -59, -58, -58, -57, -57, -57, -57,
-57, -56, -56, -55, -56, -55, -55, -54, -55, -55, -53, -53, -53, -53, -52, -52,
-51, -51, -51, -50, -50, -50, -49, -49, -49, -48, -48, -48, -47, -46, -47, -46,
-46, -45, -45, -44, -43, -44, -43, -43, -43, -42, -41, -42, -40, -40, -39, -40,
-39, -38, -38, -37, -37, -36, -37, -36, -36, -34, -34, -34, -34, -33, -32, -32,
-31, -32, -30, -30, -30, -29, -29, -29, -28, -28, -27, -27, -26, -25, -25, -24,
-24, -24, -23, -22, -22, -22, -22, -21, -21, -19, -19, -19, -18, -18, -17, -16,
-17, -16, -16, -15, -16, -14, -14, -13, -13, -13, -11, -12, -11, -11, -10, -9,
-8, -9, -8, -8, -7, -6, -6, -6, -5, -5, -4, -4, -4, -3, -3, -2, -2, -1, -1, -1,
};