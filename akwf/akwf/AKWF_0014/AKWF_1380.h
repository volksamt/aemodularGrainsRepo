#define DATA_LENGTH 512
#define DATA AKWF_1380

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 13, 22, 29, 36, 43, 48, 53, 59, 63,
66, 69, 71, 72, 74, 73, 73, 72, 70, 68, 65, 62, 59, 55, 50, 46, 41, 37, 31, 26,
20, 16, 10, 4, 0, -6, -9, -15, -18, -23, -25, -29, -32, -34, -37, -39, -40, -41,
-42, -43, -41, -41, -40, -40, -38, -37, -34, -33, -30, -28, -24, -22, -18, -16,
-13, -10, -7, -4, -2, 1, 5, 7, 10, 13, 14, 16, 18, 19, 21, 22, 23, 23, 24, 24,
24, 24, 24, 22, 22, 21, 20, 19, 18, 16, 15, 14, 11, 10, 8, 6, 5, 3, 2, 0, -3,
-3, -5, -6, -7, -9, -9, -12, -12, -12, -12, -13, -14, -14, -14, -14, -13, -13,
-13, -12, -13, -11, -11, -10, -9, -8, -7, -6, -5, -4, -2, -2, -1, 0, 1, 2, 3, 3,
4, 5, 6, 5, 7, 6, 7, 7, 8, 8, 8, 7, 8, 8, 7, 7, 7, 7, 6, 6, 5, 5, 4, 4, 4, 3, 3,
1, 1, 0, -1, -1, -1, -2, -2, -2, -4, -4, -4, -3, -3, -3, -4, -4, -5, -5, -4, -5,
-4, -4, -4, -4, -4, -3, -2, -3, -3, -2, -2, -2, -1, -1, -1, -1, 0, 0, 0, 1, 1,
1, 2, 2, 2, 3, 3, 2, 3, 2, 2, 3, 2, 2, 2, 3, 2, 2, 3, 2, 1, 1, 2, 1, 1, 0, 1, 1,
1, 0, 1, 0, 0, -1, -1, -1, -1, -1, -1, -1, -1, -1, -2, -1, -2, -2, -2, -1, -1,
-1, -1, -1, -2, -2, -1, -1, -1, -1, -1, -1, -1, 0, -1, -1, 0, 0, 0, 0, 0, 1, 0,
1, 0, 1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 1, 1, 1, 1, 1, 1, 0, 0, 1, 0, 1, 0, 1, 0, 1,
0, 0, 0, 0, 0, 0, 0, 0, -1, -1, -1, 0, -1, -1, -1, -1, -1, 0, 0, -1, -1, 0, 0,
0, 0, -1, 0, 0, 0, 0, -1, 0, -1, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0,
1, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0,
0, -1, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 0, 0, -1,
1, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0,
0, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, -1,
0, 0, -1, 0, -1, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, -1, 0, -1, 1, -1, 1, 0, 0,
0, 1, 0, -1, 1, -1, 1, -2, 3, -4, 5, -8, 14, -59, -128, -103, -110, -95, -94,
-81, -76, -66, -58, -48, -39, -29, -21, -11, -2, };