#define DATA_LENGTH 512
#define DATA AKWF_1392

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 11, 18, 25, 31, 39, 45, 51, 57, 63,
69, 75, 79, 84, 89, 93, 97, 101, 103, 106, 107, 108, 110, 111, 112, 115, 117,
118, 118, 119, 119, 119, 118, 119, 119, 119, 118, 117, 117, 115, 115, 113, 111,
107, 103, 96, 90, 83, 76, 70, 63, 59, 53, 48, 44, 39, 36, 32, 29, 25, 22, 20,
18, 15, 13, 11, 9, 7, 5, 4, 3, 2, 1, 0, -1, -3, -3, -4, -4, -5, -5, -6, -6, -6,
-7, -6, -6, -5, -4, -4, -2, -1, -1, 1, 1, 2, 3, 4, 5, 5, 6, 7, 7, 8, 10, 13, 15,
16, 13, 10, 4, 0, -5, -9, -14, -18, -20, -22, -25, -26, -26, -27, -27, -28, -26,
-25, -25, -24, -23, -21, -20, -18, -17, -17, -15, -13, -11, -11, -9, -7, -7, -6,
-5, -5, -3, -3, -3, -2, -3, -2, -2, -3, -3, -4, -6, -6, -7, -9, -9, -12, -12,
-15, -17, -19, -21, -24, -26, -29, -31, -34, -41, -45, -39, -33, -32, -27, -24,
-22, -20, -18, -16, -15, -14, -15, -14, -14, -14, -14, -15, -16, -17, -19, -19,
-22, -23, -25, -27, -29, -30, -32, -34, -37, -38, -40, -42, -44, -46, -48, -50,
-51, -53, -54, -57, -59, -60, -62, -64, -67, -69, -71, -73, -75, -77, -80, -82,
-82, -85, -85, -86, -88, -89, -89, -89, -88, -90, -99, -103, -103, -102, -100,
-96, -92, -86, -80, -74, -67, -59, -52, -45, -37, -30, -23, -16, -9, -2, 5, 10,
18, 23, 29, 36, 42, 47, 53, 59, 64, 68, 74, 79, 84, 87, 91, 95, 99, 102, 104,
105, 106, 107, 108, 109, 110, 110, 110, 109, 109, 109, 107, 107, 106, 104, 102,
100, 98, 96, 93, 89, 85, 81, 71, 59, 51, 44, 39, 35, 32, 30, 29, 28, 27, 28, 29,
29, 31, 32, 33, 34, 36, 36, 37, 39, 40, 41, 43, 43, 44, 46, 47, 47, 49, 49, 50,
51, 52, 52, 53, 53, 53, 53, 52, 53, 53, 52, 52, 51, 50, 49, 48, 48, 46, 46, 44,
42, 40, 39, 37, 36, 34, 31, 30, 31, 30, 29, 27, 23, 16, 9, 2, -5, -12, -16, -22,
-26, -30, -33, -35, -37, -39, -40, -41, -40, -41, -41, -41, -41, -40, -39, -39,
-37, -37, -36, -35, -34, -33, -32, -31, -30, -29, -28, -28, -27, -26, -26, -25,
-26, -25, -26, -25, -26, -25, -27, -29, -29, -30, -31, -33, -34, -36, -37, -40,
-41, -44, -45, -47, -51, -53, -59, -67, -58, -47, -43, -37, -33, -28, -24, -22,
-20, -19, -18, -17, -17, -18, -18, -19, -20, -21, -23, -25, -28, -29, -32, -34,
-37, -40, -41, -43, -46, -48, -51, -52, -54, -56, -58, -61, -63, -64, -66, -68,
-70, -71, -73, -75, -77, -79, -80, -82, -84, -85, -86, -88, -89, -90, -91, -91,
-92, -91, -94, -100, -104, -104, -106, -107, -109, -107, -107, -104, -101, -96,
-91, -86, -79, -73, -66, -59, -52, -44, -39, -31, -24, -16, -9, -2, };