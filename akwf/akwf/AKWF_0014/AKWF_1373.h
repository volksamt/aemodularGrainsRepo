#define DATA_LENGTH 512
#define DATA AKWF_1373

const PROGMEM int8_t DATA[DATA_LENGTH] = {90, 120, 107, 114, 109, 113, 107, 110,
106, 108, 105, 105, 103, 103, 102, 102, 100, 100, 98, 97, 97, 96, 94, 94, 94,
92, 92, 90, 90, 88, 89, 88, 86, 85, 84, 83, 83, 82, 81, 80, 79, 79, 78, 77, 75,
75, 75, 73, 72, 72, 71, 70, 68, 68, 68, 66, 66, 65, 64, 63, 62, 61, 61, 60, 59,
59, 57, 56, 55, 54, 54, 52, 52, 51, 50, 49, 49, 48, 47, 46, 45, 44, 44, 42, 42,
41, 41, 39, 38, 38, 37, 36, 36, 34, 34, 33, 33, 32, 31, 29, 28, 28, 28, 26, 25,
25, 24, 23, 22, 22, 20, 20, 19, 18, 18, 17, 16, 15, 15, 14, 13, 12, 11, 10, 9,
9, 8, 8, 6, 5, 5, 4, 3, 2, 2, 1, 0, -1, -2, -2, -4, -4, -6, -6, -6, -7, -8, -9,
-10, -10, -11, -11, -12, -13, -15, -15, -15, -17, -17, -18, -19, -20, -21, -21,
-22, -23, -23, -24, -25, -26, -27, -28, -28, -29, -29, -30, -31, -32, -33, -33,
-34, -34, -35, -36, -37, -38, -39, -39, -39, -41, -41, -42, -43, -44, -45, -45,
-45, -47, -47, -48, -49, -49, -51, -52, -53, -52, -53, -53, -55, -55, -56, -57,
-58, -58, -59, -60, -60, -62, -63, -62, -63, -64, -65, -66, -66, -68, -68, -68,
-69, -70, -71, -72, -72, -73, -73, -74, -75, -76, -77, -77, -78, -79, -79, -79,
-81, -81, -82, -83, -83, -85, -85, -85, -87, -87, -89, -88, -89, -90, -91, -91,
-92, -92, -93, -93, -94, -96, -96, -97, -98, -100, -99, -101, -100, -103, -100,
-105, -100, -106, -99, -116, -41, 92, 92, 94, 92, 91, 90, 89, 88, 88, 87, 86,
85, 84, 84, 83, 83, 81, 80, 79, 79, 78, 77, 75, 75, 75, 73, 73, 72, 70, 70, 69,
68, 68, 66, 65, 64, 64, 63, 63, 61, 60, 60, 58, 58, 56, 56, 56, 54, 54, 52, 52,
51, 51, 49, 49, 48, 47, 46, 45, 44, 43, 42, 42, 41, 41, 39, 38, 38, 37, 36, 35,
34, 33, 33, 32, 31, 31, 30, 28, 28, 28, 26, 26, 24, 23, 23, 22, 22, 21, 19, 19,
18, 17, 16, 16, 16, 14, 13, 12, 12, 11, 10, 10, 8, 9, 7, 7, 5, 5, 4, 3, 3, 2, 1,
0, 0, -2, -2, -4, -4, -5, -6, -6, -7, -7, -9, -9, -10, -11, -12, -13, -14, -15,
-15, -15, -16, -17, -18, -18, -20, -21, -21, -22, -23, -23, -25, -26, -25, -27,
-27, -28, -28, -29, -31, -31, -31, -33, -33, -34, -35, -35, -37, -37, -38, -38,
-39, -39, -41, -42, -42, -43, -44, -44, -46, -46, -46, -47, -48, -49, -50, -50,
-51, -52, -53, -53, -55, -55, -55, -56, -57, -58, -59, -59, -60, -61, -62, -62,
-63, -64, -63, -65, -66, -67, -67, -68, -69, -70, -69, -71, -72, -73, -73, -74,
-74, -76, -75, -76, -77, -78, -80, -79, -80, -80, -83, -80, -84, -81, -87, -80,
-93, -57, };