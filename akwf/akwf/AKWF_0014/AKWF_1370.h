#define DATA_LENGTH 512
#define DATA AKWF_1370

const PROGMEM int8_t DATA[DATA_LENGTH] = {75, 119, 105, 113, 107, 110, 105, 107,
105, 106, 103, 104, 101, 102, 101, 101, 100, 99, 98, 97, 97, 96, 95, 94, 94, 92,
93, 91, 91, 90, 90, 89, 88, 87, 86, 85, 85, 84, 84, 83, 82, 82, 81, 80, 78, 78,
78, 77, 76, 76, 75, 74, 74, 73, 72, 71, 70, 69, 68, 68, 68, 67, 66, 65, 64, 63,
64, 63, 61, 62, 60, 60, 59, 59, 58, 57, 57, 55, 54, 54, 54, 52, 52, 51, 51, 50,
48, 48, 48, 47, 46, 46, 44, 45, 44, 42, 43, 41, 41, 41, 40, 38, 38, 37, 36, 35,
35, 34, 34, 33, 32, 32, 32, 30, 29, 29, 29, 28, 27, 26, 26, 25, 24, 23, 23, 22,
21, 21, 20, 20, 19, 18, 18, 17, 16, 15, 14, 15, 13, 13, 12, 12, 11, 10, 10, 9,
9, 8, 7, 6, 6, 5, 5, 3, 3, 3, 1, 2, 0, 0, 0, -2, -2, -2, -4, -4, -5, -5, -6, -7,
-7, -7, -8, -9, -10, -10, -11, -12, -12, -13, -13, -14, -14, -16, -16, -17, -17,
-19, -20, -20, -20, -21, -22, -23, -23, -24, -24, -25, -25, -26, -27, -27, -28,
-28, -29, -30, -30, -31, -31, -32, -32, -33, -34, -34, -35, -36, -36, -37, -38,
-37, -38, -40, -40, -41, -40, -41, -43, -43, -44, -44, -45, -46, -46, -46, -48,
-49, -49, -49, -50, -50, -51, -51, -52, -52, -53, -53, -54, -55, -56, -56, -56,
-57, -58, -59, -59, -60, -60, -62, -61, -63, -63, -63, -65, -65, -65, -66, -66,
-67, -67, -68, -69, -70, -69, -71, -71, -72, -72, -73, -74, -74, -74, -75, -76,
-76, -77, -77, -78, -78, -79, -79, -80, -80, -82, -81, -82, -83, -84, -84, -85,
-85, -85, -86, -87, -87, -88, -88, -89, -90, -90, -91, -91, -93, -93, -94, -94,
-95, -94, -96, -95, -98, -96, -98, -97, -99, -99, -100, -100, -101, -102, -101,
-102, 9, 71, 58, 63, 58, 61, 58, 59, 56, 57, 55, 56, 54, 55, 53, 54, 52, 51, 50,
50, 50, 48, 48, 47, 47, 45, 45, 44, 43, 43, 43, 42, 41, 40, 40, 39, 38, 38, 37,
36, 35, 35, 34, 34, 33, 33, 32, 30, 30, 29, 29, 27, 27, 26, 26, 26, 25, 24, 23,
22, 22, 22, 20, 20, 19, 19, 17, 18, 16, 16, 15, 15, 14, 12, 13, 13, 11, 11, 10,
10, 8, 8, 8, 7, 6, 5, 4, 4, 4, 3, 3, 2, 0, -1, -1, -1, -2, -2, -2, -4, -4, -6,
-6, -6, -8, -8, -8, -9, -9, -11, -11, -12, -12, -13, -13, -14, -15, -15, -16,
-17, -17, -18, -20, -19, -20, -20, -21, -22, -22, -22, -24, -24, -24, -25, -26,
-27, -27, -28, -28, -29, -31, -31, -30, -33, -33, -32, -33, -34, -35, -35, -36,
-37, -38, -37, -39, -39, -40, -41, -42, -41, -42, -43, -43, -43, -46, -45, -47,
-46, -48, -47, -49, -49, -49, -50, -50, -51, -51, -54, -50, -58, -26, };