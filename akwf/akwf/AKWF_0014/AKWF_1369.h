#define DATA_LENGTH 512
#define DATA AKWF_1369

const PROGMEM int8_t DATA[DATA_LENGTH] = {84, 119, 107, 114, 108, 111, 107, 109,
105, 108, 105, 105, 103, 104, 103, 103, 102, 101, 99, 99, 99, 98, 97, 97, 96,
94, 94, 94, 93, 91, 92, 91, 90, 90, 90, 88, 87, 86, 85, 85, 84, 84, 84, 82, 81,
81, 81, 80, 78, 78, 77, 77, 76, 76, 75, 74, 73, 73, 71, 71, 71, 70, 70, 69, 68,
66, 66, 66, 65, 64, 63, 64, 62, 62, 61, 60, 59, 59, 59, 58, 57, 56, 56, 55, 55,
54, 53, 52, 52, 51, 50, 50, 49, 48, 48, 47, 46, 46, 45, 44, 44, 44, 43, 41, 41,
41, 40, 39, 38, 38, 37, 36, 36, 35, 34, 34, 33, 33, 32, 31, 31, 30, 30, 28, 28,
28, 26, 26, 25, 24, 24, 24, 23, 22, 22, 21, 20, 19, 19, 18, 18, 17, 16, 15, 15,
14, 15, 13, 12, 12, 11, 11, 10, 9, 9, 8, 7, 8, 6, 5, 5, 4, 4, 3, 2, 2, 0, 0, 0,
0, -1, -1, -3, -4, -4, -4, -5, -6, -7, -7, -8, -7, -9, -9, -9, -10, -11, -12,
-13, -13, -13, -14, -15, -15, -16, -17, -17, -17, -19, -18, -19, -21, -21, -22,
-22, -22, -23, -24, -24, -24, -25, -26, -26, -27, -28, -29, -30, -30, -30, -31,
-31, -32, -33, -33, -34, -35, -35, -36, -36, -36, -37, -38, -38, -40, -40, -40,
-40, -41, -42, -43, -43, -44, -44, -45, -46, -46, -46, -47, -48, -49, -49, -49,
-50, -51, -50, -51, -53, -53, -54, -54, -54, -54, -55, -57, -58, -57, -58, -59,
-58, -60, -60, -61, -60, -62, -63, -64, -63, -65, -65, -66, -65, -67, -67, -68,
-68, -69, -70, -70, -70, -70, -71, -72, -73, -73, -74, -74, -74, -74, -76, -76,
-77, -77, -77, -78, -79, -79, -80, -80, -82, -82, -83, -84, -83, -84, -84, -84,
-85, -85, -86, -87, -88, -88, -88, -90, -90, -91, -90, -92, -92, -93, -93, -93,
-94, -95, -95, -95, -96, -97, -97, -98, -98, -99, -100, -99, -101, -100, -103,
-100, -105, -99, -111, -27, 60, 50, 55, 51, 52, 50, 50, 49, 48, 48, 47, 47, 45,
45, 45, 44, 43, 44, 42, 42, 41, 41, 39, 39, 39, 38, 37, 36, 35, 35, 35, 33, 33,
32, 32, 31, 30, 30, 29, 28, 27, 27, 26, 25, 26, 25, 24, 24, 22, 21, 22, 21, 21,
20, 19, 18, 17, 17, 16, 16, 16, 14, 14, 13, 12, 12, 11, 11, 10, 9, 9, 8, 7, 7,
6, 6, 6, 4, 3, 4, 2, 2, 1, 1, 0, 0, -1, -2, -3, -3, -4, -5, -5, -6, -6, -7, -8,
-8, -9, -9, -10, -10, -11, -12, -12, -13, -13, -14, -15, -16, -16, -17, -17,
-18, -18, -19, -19, -20, -21, -21, -22, -23, -23, -24, -24, -25, -25, -26, -27,
-28, -28, -29, -29, -30, -30, -31, -32, -32, -32, -34, -33, -35, -35, -36, -36,
-38, -37, -38, -39, -39, -40, -40, -42, -41, -44, -41, -45, -42, -48, -33, };