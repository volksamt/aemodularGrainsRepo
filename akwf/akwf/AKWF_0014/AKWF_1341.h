#define DATA_LENGTH 512
#define DATA AKWF_1341

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 5, 7, 8, 10, 12, 12, 15, 16,
18, 20, 21, 22, 24, 25, 27, 29, 30, 32, 33, 35, 36, 38, 39, 41, 42, 44, 46, 47,
49, 50, 51, 52, 54, 56, 57, 59, 60, 61, 62, 64, 65, 67, 67, 69, 71, 71, 73, 74,
76, 77, 79, 79, 81, 82, 83, 85, 85, 86, 87, 89, 90, 91, 92, 93, 94, 94, 95, 97,
98, 98, 99, 100, 101, 102, 102, 103, 104, 105, 105, 106, 107, 108, 108, 110,
110, 110, 112, 112, 112, 113, 114, 113, 114, 115, 115, 116, 115, 116, 116, 117,
116, 117, 118, 118, 117, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119,
120, 119, 119, 119, 119, 119, 118, 117, 118, 117, 117, 117, 116, 116, 117, 116,
115, 115, 115, 114, 114, 112, 112, 112, 112, 111, 111, 110, 108, 108, 108, 107,
107, 105, 104, 104, 103, 102, 101, 100, 100, 99, 99, 97, 96, 96, 94, 93, 93, 91,
90, 89, 89, 87, 86, 85, 84, 82, 81, 80, 79, 78, 76, 75, 73, 72, 71, 70, 69, 67,
66, 65, 63, 62, 60, 59, 57, 56, 55, 54, 52, 50, 50, 48, 46, 45, 44, 42, 41, 39,
37, 36, 34, 32, 31, 30, 27, 27, 24, 23, 21, 21, 18, 17, 15, 14, 12, 11, 9, 7, 6,
4, 3, 1, -1, -1, -4, -5, -7, -9, -10, -12, -14, -15, -17, -19, -19, -22, -22,
-24, -26, -28, -29, -31, -33, -34, -35, -37, -38, -40, -41, -43, -44, -46, -47,
-49, -50, -51, -54, -55, -56, -57, -59, -60, -61, -64, -65, -66, -68, -69, -70,
-71, -72, -74, -75, -76, -77, -78, -80, -81, -82, -84, -84, -85, -87, -88, -89,
-90, -91, -93, -93, -94, -95, -95, -98, -98, -98, -99, -100, -102, -102, -103,
-104, -105, -105, -105, -108, -108, -109, -108, -110, -110, -111, -111, -112,
-112, -114, -114, -114, -114, -114, -115, -116, -116, -116, -116, -117, -118,
-118, -118, -118, -117, -118, -119, -118, -119, -119, -119, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -118, -119, -119, -117, -118, -118,
-117, -117, -117, -115, -115, -116, -115, -114, -113, -113, -113, -112, -112,
-110, -110, -110, -109, -108, -107, -107, -107, -105, -105, -105, -104, -102,
-103, -102, -100, -100, -99, -98, -97, -96, -95, -93, -93, -91, -90, -90, -89,
-88, -87, -85, -84, -83, -82, -80, -79, -78, -77, -76, -75, -73, -72, -72, -70,
-69, -67, -66, -65, -63, -63, -60, -59, -57, -56, -54, -53, -51, -50, -49, -47,
-46, -44, -43, -42, -40, -38, -37, -35, -34, -32, -31, -29, -28, -26, -24, -23,
-21, -19, -18, -16, -15, -13, -12, -10, -8, -7, -5, -4, -1, -1, 1, 3, 4, 6, 8,
9, 10, 12, 14, 16, 16, 18, 20, 23, 24, 26, 26, 29, 30, 32, 32, 35, 36, 37, 39,
41, 42, 43, 45, 46, 48, 49, 51, 52, 55, 54, 58, 57, 60, 60, 64, 61, 67, 63, 72,
59, };