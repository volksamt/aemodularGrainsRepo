#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {105, 124, 113, 120, 113, 119, 113,
117, 112, 114, 111, 113, 109, 111, 108, 110, 107, 108, 107, 107, 105, 106, 104,
104, 104, 102, 102, 101, 100, 99, 100, 98, 98, 97, 97, 96, 96, 95, 94, 93, 92,
91, 91, 91, 89, 89, 89, 87, 87, 86, 86, 85, 85, 83, 83, 82, 82, 80, 80, 80, 79,
78, 77, 77, 76, 75, 75, 74, 74, 73, 73, 71, 72, 70, 70, 69, 68, 67, 66, 66, 65,
65, 65, 64, 63, 63, 61, 61, 60, 59, 59, 58, 58, 57, 56, 56, 54, 54, 53, 53, 52,
52, 50, 50, 50, 49, 48, 47, 47, 46, 46, 44, 44, 43, 42, 42, 42, 41, 40, 40, 39,
39, 38, 37, 36, 35, 35, 35, 34, 33, 32, 32, 31, 30, 30, 30, 29, 27, 27, 27, 25,
25, 24, 23, 23, 21, 22, 21, 20, 20, 18, 18, 17, 17, 16, 16, 14, 15, 14, 13, 13,
12, 10, 10, 9, 8, 8, 8, 7, 6, 6, 6, 4, 4, 2, 2, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 1,
0, 1, -1, 1, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, -1, -1, 0, 0, -1, 1,
0, -1, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0,
1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0,
1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0,
1, 0, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 0, -1, 1, 0, 0, 0, 0, 0,
0, -1, 0, 0, 1, 0, -1, -1, 0, -1, 1, 0, -1, 1, -1, 0, 0, -1, -2, -3, -3, -4, -5,
-5, -6, -7, -7, -9, -8, -10, -10, -10, -11, -13, -13, -13, -14, -15, -15, -16,
-17, -17, -18, -19, -20, -19, -21, -22, -22, -23, -23, -25, -25, -25, -27, -28,
-27, -28, -29, -30, -30, -30, -32, -32, -32, -34, -34, -35, -35, -37, -36, -37,
-38, -39, -39, -40, -40, -41, -42, -43, -43, -43, -45, -46, -45, -47, -48, -48,
-48, -49, -50, -50, -52, -53, -53, -53, -54, -55, -56, -56, -57, -58, -58, -59,
-60, -59, -61, -61, -63, -63, -63, -64, -65, -66, -66, -67, -68, -68, -69, -69,
-70, -72, -72, -72, -73, -74, -74, -74, -75, -77, -77, -78, -79, -78, -80, -81,
-81, -81, -83, -82, -84, -84, -85, -86, -87, -88, -88, -88, -90, -89, -90, -91,
-91, -92, -93, -94, -94, -95, -96, -96, -97, -97, -98, -99, -100, -100, -101,
-102, -102, -103, -104, -104, -105, -106, -107, -106, -108, -108, -110, -109,
-111, -110, -113, -111, -114, -112, -115, -115, -116, -116, -116, -117, -116,
-125, -19, 8, };