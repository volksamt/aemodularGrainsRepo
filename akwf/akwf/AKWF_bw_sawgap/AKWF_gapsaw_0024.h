#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 123, 111, 116, 108, 111, 104,
108, 101, 103, 97, 97, 93, 94, 89, 89, 86, 85, 83, 81, 78, 76, 75, 72, 71, 69,
67, 64, 63, 60, 59, 56, 54, 52, 51, 49, 46, 44, 43, 41, 38, 36, 34, 32, 30, 28,
26, 24, 22, 20, 17, 16, 14, 12, 10, 8, 5, 4, 2, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
1, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0,
-1, 0, 0, 0, 0, 0, 0, 0, 1, 1, -1, 1, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0,
0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, -1, 1, 0, -1, 0, 0, 0, 1, 0,
-1, 0, 1, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, -1, 0, 0, -1, 1, -1, 0, -1, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0,
-1, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, -1, -1,
0, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0,
1, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 1, 0, 0, 1,
0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1,
0, 0, 0, -1, 0, 0, 0, 1, -1, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0,
0, 0, 1, 0, 0, 0, 0, 1, 0, 1, -1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, -1,
0, 1, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, -1, 0, 1, 0, 1, -1, 1, 0, 0, 1, 0, 0, 0, 0,
0, 1, -1, 0, 1, 0, 0, 0, 1, -1, 1, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1,
-3, -5, -7, -10, -12, -14, -16, -17, -19, -22, -24, -26, -28, -30, -32, -34,
-36, -38, -40, -42, -44, -46, -48, -51, -51, -54, -56, -58, -60, -62, -64, -66,
-69, -70, -71, -74, -77, -78, -80, -81, -84, -86, -90, -90, -93, -93, -98, -97,
-102, -101, -106, -106, -109, -110, -112, -115, -115, -124, -18, 7, };