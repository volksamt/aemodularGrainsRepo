#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0033

const PROGMEM int8_t DATA[DATA_LENGTH] = {103, 120, 108, 112, 103, 106, 98, 100,
93, 93, 88, 87, 82, 81, 77, 76, 72, 71, 66, 64, 60, 59, 56, 53, 51, 47, 45, 41,
40, 36, 34, 30, 28, 25, 22, 19, 16, 12, 11, 8, 6, 2, 0, 0, -1, 0, 0, 0, 0, 0, 0,
1, 0, 0, 0, 0, 1, -1, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 1, -1, 0, 0, 0, 0, 0,
0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0,
0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 1,
-1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, -1, 0, -1, -1, -1, -1, -1, 1, 0, 0, 1,
0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0,
-1, 1, -1, -1, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 1, 0, 0, 0,
-1, -1, 0, 1, -1, 0, 0, 1, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 1,
1, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 1, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 1, 0,
0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 1, 0, 1, 0,
-1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, -2, -3, -5, -4, -5, -6, -7, -8, -8,
-9, -10, -10, -12, -12, -13, -13, -14, -14, -14, -15, -16, -16, -18, -18, -19,
-20, -21, -22, -22, -23, -24, -24, -25, -26, -26, -27, -28, -28, -29, -30, -31,
-31, -31, -33, -33, -34, -34, -36, -35, -37, -37, -38, -39, -39, -40, -40, -41,
-42, -43, -44, -45, -45, -46, -46, -48, -49, -49, -49, -51, -51, -51, -52, -53,
-54, -53, -55, -55, -56, -57, -58, -58, -59, -60, -60, -61, -62, -63, -63, -64,
-65, -66, -66, -67, -68, -68, -70, -70, -71, -71, -72, -72, -73, -73, -75, -75,
-76, -77, -77, -78, -80, -79, -81, -81, -83, -82, -83, -84, -85, -85, -86, -86,
-87, -88, -89, -89, -90, -91, -91, -92, -93, -93, -94, -95, -96, -96, -97, -98,
-99, -100, -100, -101, -101, -102, -103, -103, -105, -105, -107, -106, -108,
-106, -109, -108, -112, -110, -112, -111, -113, -112, -115, -113, -117, -116,
-118, -118, -116, -124, -18, 8, };