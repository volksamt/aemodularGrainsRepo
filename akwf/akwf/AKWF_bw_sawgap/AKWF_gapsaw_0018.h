#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 123, 112, 120, 112, 116, 111,
113, 109, 111, 106, 108, 105, 106, 104, 104, 101, 101, 99, 99, 97, 96, 95, 94,
93, 93, 91, 89, 88, 88, 87, 85, 85, 84, 83, 81, 81, 78, 78, 77, 76, 75, 74, 72,
71, 70, 69, 68, 67, 67, 65, 64, 63, 61, 60, 60, 59, 58, 56, 56, 55, 53, 52, 51,
49, 49, 48, 47, 46, 45, 43, 43, 42, 40, 40, 37, 37, 35, 34, 33, 33, 31, 30, 28,
29, 28, 26, 25, 23, 23, 22, 20, 20, 19, 17, 16, 15, 14, 13, 12, 10, 10, 8, 8, 6,
6, 4, 3, 3, 1, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0,
0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0, -1,
-1, 0, 0, 0, 0, 0, 1, 1, -1, 0, 0, 1, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 0,
1, 0, -1, 0, 0, 0, 1, 0, -1, 0, 0, 1, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0,
1, 0, 1, 1, 1, -1, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0,
0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0, -1, 0, -1, 0, 1, 0, 0, 1, 0,
1, 0, 0, 1, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 1, 0, 1, 1,
0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1,
0, 0, 0, 0, 0, 0, -1, 0, -1, -1, 0, 1, 0, 0, 0, 0, 0, -1, 1, 0, 0, 1, 0, 0, 1,
0, -1, 0, 1, 0, 1, 0, 0, 0, 0, 1, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0,
0, 0, 1, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0,
-1, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, -1, -3, -5, -5, -7, -7, -9, -9,
-10, -12, -12, -14, -15, -16, -17, -19, -19, -21, -22, -22, -24, -25, -26, -27,
-28, -29, -30, -31, -32, -34, -34, -36, -36, -38, -38, -40, -41, -42, -43, -44,
-45, -46, -47, -48, -50, -51, -51, -53, -54, -55, -57, -58, -58, -60, -60, -62,
-63, -63, -65, -66, -67, -68, -69, -70, -72, -72, -73, -75, -76, -76, -78, -79,
-80, -81, -81, -83, -85, -86, -86, -87, -88, -90, -91, -92, -92, -94, -94, -97,
-97, -99, -99, -101, -101, -104, -103, -105, -105, -108, -108, -111, -109, -112,
-111, -114, -114, -116, -118, -115, -125, -18, 8, };