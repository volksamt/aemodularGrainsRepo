#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 114, 120, 115, 119, 114,
117, 113, 116, 112, 114, 112, 114, 111, 112, 110, 111, 109, 109, 108, 108, 107,
106, 107, 106, 106, 104, 105, 104, 104, 103, 102, 102, 102, 101, 100, 100, 99,
99, 98, 98, 97, 97, 96, 95, 95, 95, 94, 94, 93, 93, 92, 92, 90, 90, 89, 90, 89,
88, 88, 87, 87, 86, 86, 85, 85, 85, 84, 84, 83, 83, 82, 81, 80, 81, 80, 79, 79,
78, 77, 77, 76, 76, 75, 75, 75, 74, 74, 72, 72, 72, 72, 71, 70, 70, 69, 69, 68,
68, 67, 66, 66, 65, 65, 65, 64, 64, 63, 62, 63, 62, 61, 60, 59, 60, 58, 58, 58,
57, 57, 56, 56, 55, 54, 54, 54, 53, 52, 53, 51, 51, 50, 50, 49, 49, 49, 48, 48,
47, 46, 46, 45, 45, 44, 43, 43, 43, 43, 42, 42, 40, 41, 39, 39, 39, 38, 37, 37,
36, 36, 35, 35, 35, 34, 34, 33, 32, 32, 31, 30, 30, 30, 29, 29, 28, 28, 27, 27,
27, 26, 25, 25, 24, 24, 23, 23, 22, 22, 21, 20, 20, 20, 19, 19, 18, 17, 17, 17,
16, 16, 16, 14, 14, 14, 13, 13, 11, 11, 11, 10, 10, 9, 8, 7, 8, 6, 6, 6, 5, 5,
4, 4, 3, 2, 2, 3, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 1,
-1, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, -1, 0, 0, -1, 0, -1, -1, -1, -3, -2, -3, -3, -4, -4, -5, -6, -6, -7,
-7, -9, -9, -9, -10, -9, -11, -10, -12, -12, -13, -13, -14, -15, -15, -15, -15,
-16, -17, -17, -17, -18, -19, -19, -20, -21, -21, -21, -22, -22, -22, -24, -24,
-24, -25, -25, -26, -26, -27, -28, -29, -28, -30, -29, -30, -31, -31, -32, -32,
-33, -34, -33, -35, -35, -36, -36, -37, -37, -37, -38, -38, -39, -40, -40, -40,
-41, -42, -42, -42, -43, -43, -44, -44, -45, -45, -46, -46, -47, -48, -48, -48,
-49, -49, -51, -51, -52, -52, -52, -53, -54, -54, -55, -54, -56, -56, -57, -58,
-57, -59, -58, -59, -60, -60, -61, -62, -62, -62, -62, -63, -64, -64, -65, -65,
-66, -67, -67, -67, -67, -69, -69, -70, -69, -70, -71, -72, -72, -73, -74, -75,
-74, -76, -76, -76, -76, -77, -78, -78, -79, -79, -80, -79, -81, -81, -83, -83,
-82, -82, -84, -84, -85, -84, -85, -86, -87, -88, -87, -89, -89, -90, -90, -90,
-90, -91, -92, -92, -94, -94, -94, -95, -94, -95, -96, -96, -97, -97, -98, -99,
-100, -100, -100, -102, -101, -102, -102, -102, -103, -103, -104, -105, -105,
-106, -107, -107, -107, -108, -109, -110, -109, -111, -111, -112, -111, -114,
-111, -115, -113, -115, -114, -116, -115, -117, -117, -118, -118, -117, -124,
-19, 7, };