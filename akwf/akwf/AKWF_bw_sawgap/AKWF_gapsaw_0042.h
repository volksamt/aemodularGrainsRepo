#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0042

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 114, 121, 114, 120, 114,
117, 113, 116, 113, 115, 112, 114, 111, 112, 111, 112, 109, 110, 109, 109, 108,
107, 107, 107, 106, 105, 106, 104, 104, 103, 104, 102, 103, 102, 101, 100, 100,
100, 99, 98, 98, 97, 97, 97, 95, 95, 95, 94, 94, 93, 93, 93, 92, 92, 92, 91, 90,
89, 89, 88, 88, 88, 87, 87, 86, 85, 85, 84, 84, 84, 83, 82, 82, 82, 81, 81, 80,
80, 79, 79, 78, 77, 76, 76, 75, 76, 75, 75, 74, 74, 72, 73, 72, 71, 71, 70, 70,
70, 68, 69, 68, 67, 67, 66, 66, 66, 65, 64, 64, 64, 63, 62, 62, 62, 61, 61, 60,
59, 59, 58, 58, 58, 57, 56, 56, 56, 55, 54, 54, 54, 53, 53, 51, 52, 51, 50, 50,
49, 49, 49, 48, 48, 48, 47, 46, 45, 45, 45, 44, 44, 43, 42, 42, 42, 41, 41, 39,
39, 39, 39, 38, 38, 37, 36, 36, 36, 34, 34, 34, 33, 34, 32, 32, 32, 31, 31, 30,
29, 29, 28, 28, 28, 27, 26, 26, 25, 25, 25, 23, 24, 23, 22, 22, 21, 20, 20, 20,
19, 19, 19, 18, 18, 17, 16, 15, 15, 15, 15, 13, 14, 13, 13, 12, 12, 11, 10, 10,
10, 9, 9, 8, 7, 6, 6, 6, 6, 5, 4, 4, 3, 3, 3, 2, 2, 1, 0, 0, 1, 0, 0, 0, 0, 0,
0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 1, 1, 1, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0,
1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, -1, 1, 0, 0, 1, 0, 0, 1,
-1, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 1, -1, 0, 0, 0, 0, 1, -1, 1, 0,
0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1,
0, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0,
0, -1, 0, 1, 0, 0, 0, 0, 0, 1, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 1,
0, 0, -1, 0, 0, 0, 0, -1, -3, -4, -6, -7, -9, -10, -12, -13, -15, -17, -19, -19,
-21, -23, -24, -26, -27, -29, -31, -33, -34, -35, -38, -38, -40, -41, -42, -44,
-46, -48, -50, -50, -53, -54, -56, -58, -58, -59, -62, -63, -65, -65, -68, -69,
-72, -73, -74, -76, -77, -79, -80, -82, -83, -86, -86, -89, -89, -92, -93, -95,
-95, -98, -99, -102, -101, -106, -104, -109, -107, -111, -111, -113, -115, -114,
-123, -18, 7, };