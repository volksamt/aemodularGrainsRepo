#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 122, 111, 114, 106, 109, 103,
105, 98, 100, 94, 94, 90, 89, 85, 84, 81, 79, 76, 74, 71, 70, 67, 64, 62, 59,
57, 55, 53, 50, 49, 46, 43, 41, 40, 37, 34, 32, 30, 27, 24, 22, 20, 18, 15, 12,
9, 7, 6, 3, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, -1, 0, 0, -1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 1, -1, 0, 0, 0, -1, 0, 0, 1, 0, 0,
0, 0, 0, 0, -1, -1, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0,
0, -1, 0, -1, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0,
0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 1, 0,
0, 1, 1, 0, 1, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, -1, 0, 1, -1, 0, 0, -1, 0,
0, 0, 0, 0, -1, 0, 0, 1, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0,
0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 1, 0, 0, 0, 0,
0, -1, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 0, 1, 0,
0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 1, -1, 0, 0,
0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0,
0, 1, 0, 1, 1, 0, -1, 1, -1, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1,
0, 0, -1, 0, 0, 1, -1, 0, 0, 1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, -1, -3, -6, -7, -10, -12, -14, -16, -20, -21, -24, -26, -29, -31, -33, -36,
-38, -40, -43, -45, -48, -50, -53, -54, -57, -60, -61, -64, -67, -68, -71, -74,
-75, -78, -80, -84, -84, -88, -90, -94, -93, -98, -98, -104, -103, -107, -108,
-111, -114, -114, -124, -19, 8, };