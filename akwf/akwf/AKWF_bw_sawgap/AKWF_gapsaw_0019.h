#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 123, 112, 119, 111, 116, 109,
112, 107, 111, 105, 107, 103, 105, 101, 102, 99, 100, 97, 97, 95, 95, 93, 91,
91, 90, 88, 87, 86, 85, 84, 83, 81, 80, 79, 77, 76, 76, 74, 74, 73, 72, 70, 69,
68, 67, 65, 64, 63, 61, 60, 60, 58, 57, 56, 55, 54, 52, 51, 50, 48, 47, 46, 45,
44, 42, 42, 41, 40, 39, 37, 36, 35, 33, 32, 31, 30, 29, 28, 27, 25, 23, 22, 22,
21, 20, 19, 17, 16, 14, 14, 12, 11, 9, 9, 7, 6, 6, 4, 3, 1, 0, 0, 0, -1, -1, 0,
0, 0, -1, 1, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, -1, 1, 0, 0, -1,
-1, 1, 0, -1, 0, 0, 0, 1, 0, -1, -1, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0,
0, 1, 1, 0, 0, -1, -1, 0, -1, 0, 0, 0, 0, -1, 0, -1, 0, 0, -1, 0, 0, -1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, -1, 0, -1, 0,
1, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
-1, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, -1, 1, 0, 0, 0, 0, 1,
0, 0, 0, -1, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0,
0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 0, 1, 0, 0, 1, 0, -1, 0, 0, 0, -1,
0, 0, 0, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, -1, -1, 0, 0, 0, 0, 0,
1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0,
0, 0, -1, 0, 0, 0, -1, -1, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, -2,
-3, -4, -5, -6, -8, -9, -10, -11, -12, -13, -14, -15, -17, -18, -19, -21, -22,
-22, -24, -25, -26, -27, -29, -30, -30, -32, -33, -35, -36, -36, -38, -39, -40,
-41, -43, -43, -45, -47, -48, -49, -50, -50, -52, -53, -54, -56, -57, -58, -59,
-60, -61, -62, -64, -64, -66, -67, -68, -69, -71, -72, -74, -74, -75, -77, -78,
-79, -80, -81, -81, -83, -85, -86, -87, -88, -89, -91, -92, -93, -95, -94, -97,
-98, -99, -100, -103, -101, -104, -103, -106, -106, -109, -108, -112, -111,
-113, -114, -116, -117, -116, -124, -19, 8, };