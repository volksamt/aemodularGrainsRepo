#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {-9, 26, 127, 114, 119, 115, 115, 115,
113, 114, 111, 112, 109, 111, 107, 109, 106, 108, 105, 106, 104, 104, 102, 102,
100, 100, 99, 98, 97, 97, 95, 95, 94, 93, 93, 91, 91, 90, 90, 89, 88, 87, 86,
85, 84, 83, 83, 81, 81, 80, 79, 78, 78, 77, 76, 75, 74, 73, 72, 72, 71, 70, 70,
69, 68, 68, 66, 65, 65, 63, 63, 62, 60, 60, 59, 59, 57, 57, 56, 56, 55, 54, 53,
52, 51, 50, 50, 49, 48, 47, 46, 45, 44, 43, 42, 42, 41, 40, 40, 39, 38, 37, 36,
36, 34, 34, 33, 32, 31, 31, 30, 29, 28, 26, 27, 26, 25, 23, 23, 22, 21, 21, 20,
19, 18, 17, 16, 15, 15, 14, 14, 12, 11, 11, 9, 10, 7, 7, 6, 5, 5, 4, 3, 3, 1, 1,
0, 0, -1, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, -1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0,
0, 0, 0, -1, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1,
0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0, -1, 0, 0, 0, 0, 1, 0, 0, -1, 0,
0, 1, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0,
0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0,
1, 1, 0, -1, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, -1, -2, -3, -5, -6, -6,
-7, -8, -8, -10, -9, -11, -12, -13, -13, -14, -14, -16, -16, -17, -18, -19, -20,
-20, -21, -23, -24, -24, -25, -26, -27, -27, -28, -29, -30, -30, -32, -33, -33,
-34, -35, -35, -36, -37, -38, -38, -40, -40, -41, -42, -44, -44, -44, -46, -46,
-48, -48, -48, -50, -50, -51, -53, -53, -54, -55, -56, -57, -58, -58, -59, -59,
-60, -61, -62, -64, -64, -65, -65, -67, -67, -67, -69, -70, -70, -72, -71, -73,
-73, -75, -75, -76, -78, -77, -79, -79, -79, -81, -82, -82, -84, -84, -85, -86,
-87, -87, -88, -90, -89, -91, -92, -92, -93, -95, -95, -96, -96, -98, -98, -99,
-100, -101, -102, -103, -103, -105, -106, -106, -107, -107, -110, -108, -112,
-109, -113, -111, -116, -112, -119, -112, -121, -113, -126, -101, };