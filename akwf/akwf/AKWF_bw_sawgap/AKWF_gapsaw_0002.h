#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {105, 124, 114, 120, 115, 119, 114,
117, 114, 116, 113, 115, 113, 114, 111, 112, 111, 112, 110, 110, 109, 108, 109,
108, 108, 107, 107, 106, 106, 105, 104, 103, 104, 102, 103, 102, 101, 101, 100,
100, 99, 100, 99, 98, 99, 97, 97, 96, 96, 96, 95, 95, 94, 94, 93, 93, 92, 92,
91, 91, 91, 90, 89, 89, 88, 88, 88, 87, 87, 86, 85, 84, 85, 84, 83, 83, 82, 81,
81, 81, 80, 80, 79, 79, 78, 78, 78, 77, 77, 76, 76, 75, 75, 75, 74, 73, 73, 72,
72, 72, 70, 70, 70, 69, 68, 69, 67, 67, 67, 67, 66, 65, 65, 65, 64, 63, 62, 63,
61, 61, 61, 60, 59, 59, 59, 59, 58, 57, 58, 57, 56, 56, 55, 55, 54, 54, 54, 53,
53, 52, 51, 51, 51, 50, 49, 49, 49, 48, 47, 47, 47, 46, 45, 45, 44, 43, 44, 43,
43, 43, 42, 41, 40, 40, 39, 40, 40, 38, 38, 38, 36, 36, 36, 35, 34, 35, 34, 33,
33, 33, 32, 31, 31, 31, 30, 29, 30, 29, 28, 28, 28, 27, 26, 26, 25, 25, 24, 24,
23, 24, 23, 22, 21, 21, 21, 20, 20, 19, 18, 18, 17, 18, 17, 17, 16, 15, 15, 14,
14, 13, 13, 12, 12, 12, 11, 10, 10, 9, 9, 8, 8, 7, 6, 6, 6, 6, 5, 4, 4, 4, 3, 3,
3, 2, 1, 0, 0, 1, 0, 0, 1, 0, 0, -1, 0, 0, -1, 0, 0, -1, 1, 0, 0, -1, -1, -1,
-2, -2, -2, -3, -4, -4, -5, -5, -5, -6, -6, -7, -7, -8, -9, -9, -10, -10, -11,
-10, -12, -12, -13, -13, -13, -13, -15, -15, -15, -16, -15, -17, -17, -18, -19,
-18, -20, -19, -20, -21, -21, -22, -22, -22, -23, -23, -24, -24, -24, -26, -27,
-26, -26, -28, -28, -28, -28, -30, -30, -30, -30, -31, -32, -32, -33, -33, -33,
-34, -34, -35, -35, -36, -36, -37, -37, -38, -39, -39, -39, -40, -40, -40, -41,
-41, -42, -43, -44, -43, -44, -44, -46, -46, -45, -46, -46, -48, -48, -49, -49,
-50, -50, -51, -52, -51, -52, -52, -53, -53, -54, -55, -55, -55, -56, -56, -57,
-57, -58, -57, -58, -59, -59, -60, -61, -61, -62, -62, -63, -64, -63, -65, -65,
-65, -66, -66, -66, -67, -67, -68, -68, -69, -70, -70, -71, -70, -72, -72, -72,
-73, -73, -73, -73, -75, -75, -75, -75, -76, -78, -77, -79, -78, -79, -79, -81,
-81, -81, -81, -82, -82, -82, -83, -84, -85, -84, -85, -86, -86, -86, -86, -87,
-88, -88, -89, -89, -90, -90, -91, -91, -91, -93, -93, -93, -94, -94, -95, -96,
-97, -96, -97, -97, -98, -98, -100, -99, -99, -99, -101, -101, -101, -103, -103,
-103, -104, -105, -105, -105, -105, -106, -106, -107, -107, -108, -108, -109,
-109, -110, -110, -111, -110, -113, -111, -114, -112, -115, -113, -115, -114,
-117, -115, -118, -116, -118, -118, -117, -124, -18, 7, };