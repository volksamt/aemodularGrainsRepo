#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 114, 121, 114, 118, 113,
116, 111, 115, 110, 112, 109, 110, 109, 110, 107, 108, 106, 106, 105, 105, 104,
103, 102, 102, 102, 100, 100, 98, 98, 97, 96, 96, 95, 95, 95, 93, 92, 92, 91,
90, 89, 89, 88, 87, 87, 87, 86, 84, 84, 83, 83, 82, 81, 80, 80, 80, 79, 78, 77,
77, 76, 74, 73, 73, 73, 72, 72, 71, 70, 70, 68, 68, 67, 66, 66, 64, 64, 64, 63,
62, 62, 62, 61, 59, 59, 58, 57, 56, 56, 55, 55, 54, 54, 52, 52, 51, 51, 50, 49,
48, 47, 46, 46, 45, 44, 44, 44, 43, 42, 41, 40, 39, 39, 39, 38, 37, 36, 35, 35,
34, 33, 33, 32, 32, 31, 30, 29, 28, 28, 28, 27, 26, 25, 25, 24, 24, 23, 21, 20,
20, 20, 18, 18, 18, 17, 16, 15, 14, 13, 13, 12, 11, 11, 11, 10, 8, 9, 8, 7, 6,
5, 5, 4, 3, 3, 3, 1, 0, 0, 1, 1, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 1, 0, 0, -1, 1, 1, 1, 0, 0,
0, 0, 0, 0, 1, 0, 1, -1, 1, 0, 1, 0, 0, 0, 1, 0, 0, 1, 0, 1, -1, 1, 0, 0, 0, 0,
0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, -1, 0, -1, -1, 0, 0, 0, 0, 1, 0, 1, 0, -1, 1,
0, -1, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0,
0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -2,
-3, -3, -4, -5, -6, -6, -7, -8, -8, -8, -10, -10, -11, -11, -12, -13, -14, -14,
-15, -16, -17, -17, -17, -18, -19, -20, -21, -21, -22, -23, -23, -24, -25, -26,
-26, -28, -28, -29, -29, -30, -30, -31, -32, -32, -33, -34, -35, -36, -36, -37,
-38, -38, -40, -40, -40, -41, -42, -42, -44, -44, -44, -45, -46, -46, -47, -49,
-49, -49, -50, -51, -51, -52, -53, -53, -54, -55, -56, -56, -57, -58, -58, -58,
-60, -61, -62, -62, -63, -64, -64, -65, -65, -67, -67, -67, -69, -69, -70, -70,
-71, -71, -72, -74, -73, -75, -75, -77, -77, -78, -78, -78, -79, -80, -81, -82,
-82, -83, -84, -84, -85, -86, -86, -88, -88, -90, -89, -91, -91, -92, -93, -92,
-93, -94, -95, -95, -97, -96, -97, -99, -99, -100, -101, -101, -101, -103, -102,
-105, -105, -106, -105, -109, -107, -109, -108, -111, -110, -113, -110, -114,
-113, -115, -113, -117, -115, -117, -118, -116, -124, -19, 8, };