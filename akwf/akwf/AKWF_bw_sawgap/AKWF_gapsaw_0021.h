#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 112, 118, 110, 114, 109,
111, 105, 108, 103, 105, 101, 102, 99, 98, 96, 95, 93, 92, 91, 89, 88, 86, 85,
83, 83, 80, 80, 77, 76, 75, 74, 72, 72, 69, 69, 67, 65, 64, 63, 61, 60, 59, 57,
55, 54, 53, 51, 50, 48, 47, 46, 45, 43, 42, 40, 40, 37, 36, 34, 33, 31, 31, 28,
27, 25, 24, 23, 22, 21, 19, 18, 15, 14, 13, 11, 11, 9, 8, 6, 5, 3, 3, 1, 1, 0,
0, 1, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0,
0, 1, 0, 1, 1, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0,
0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0,
1, 1, 0, 0, 0, -1, 0, -1, 0, 0, 0, -1, 1, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1,
-1, 0, -1, 1, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 1, 0, -1, 0, 0, 0, 0, -1, 0,
0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0, -1, 0, 0,
-1, 0, 0, 0, 1, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, -1,
0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, -1, 1, 1, 0, 1, 1, 1,
0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, -1, -1, 0,
-1, 0, -1, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, -1, 1, 0, 0, -1, 1, 0, 0, 0, 0, 0,
0, 0, 1, 0, 0, 0, -1, -3, -4, -7, -7, -10, -11, -11, -13, -15, -16, -17, -18,
-20, -21, -23, -24, -26, -28, -28, -30, -30, -33, -34, -35, -37, -38, -39, -41,
-43, -44, -46, -47, -49, -49, -52, -53, -54, -56, -56, -58, -60, -61, -62, -64,
-65, -66, -69, -69, -71, -72, -74, -74, -77, -78, -79, -81, -82, -83, -85, -86,
-87, -89, -90, -92, -93, -95, -95, -99, -98, -102, -101, -105, -103, -107, -106,
-110, -109, -112, -113, -115, -116, -116, -124, -19, 7, };