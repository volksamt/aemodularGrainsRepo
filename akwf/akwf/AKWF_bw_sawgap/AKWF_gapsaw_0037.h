#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0037

const PROGMEM int8_t DATA[DATA_LENGTH] = {105, 123, 113, 118, 111, 116, 110,
113, 107, 110, 105, 107, 104, 105, 101, 102, 100, 99, 98, 97, 96, 94, 93, 92,
90, 89, 89, 87, 87, 85, 84, 81, 82, 81, 79, 77, 77, 75, 74, 73, 72, 71, 69, 68,
68, 66, 65, 64, 63, 61, 60, 59, 58, 56, 56, 54, 53, 52, 51, 50, 49, 48, 46, 45,
44, 43, 41, 40, 39, 38, 37, 36, 35, 33, 32, 30, 30, 29, 27, 27, 25, 24, 23, 22,
20, 19, 18, 17, 15, 14, 13, 12, 11, 10, 9, 7, 7, 5, 3, 3, 2, 0, 0, 0, 0, 1, 0,
0, 0, 0, 0, 0, 0, 0, -1, -1, 1, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0,
0, 0, 0, 0, -1, 0, 0, -1, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0,
-1, -1, 0, -1, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0,
-1, -1, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0,
0, -1, 0, 0, 0, 0, -1, -1, 0, 0, -1, 0, 0, 0, 0, -1, 0, 1, 0, 0, 1, 0, 0, 1, 1,
0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
0, 1, 0, 0, 0, 0, -1, 0, -1, 0, -1, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0,
0, 0, -1, 0, 0, 0, -1, 0, 0, 1, 0, 0, 1, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1,
0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0,
0, 0, 1, 1, 1, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, -1, -2,
-2, -4, -4, -5, -6, -7, -7, -9, -9, -10, -11, -11, -12, -13, -13, -14, -15, -15,
-17, -18, -18, -19, -20, -21, -22, -22, -23, -23, -25, -25, -26, -26, -27, -28,
-29, -30, -31, -32, -32, -33, -34, -34, -36, -37, -37, -37, -39, -39, -40, -40,
-41, -42, -43, -44, -45, -45, -46, -47, -48, -48, -50, -50, -51, -51, -52, -53,
-54, -55, -55, -56, -57, -59, -59, -60, -61, -61, -62, -63, -63, -64, -65, -65,
-67, -68, -68, -69, -70, -71, -71, -73, -73, -74, -74, -75, -76, -77, -78, -78,
-79, -80, -81, -81, -82, -83, -84, -84, -85, -86, -88, -88, -88, -89, -89, -91,
-92, -93, -93, -94, -94, -96, -96, -97, -98, -98, -99, -100, -101, -102, -102,
-103, -105, -105, -106, -105, -108, -107, -110, -108, -111, -110, -113, -111,
-115, -113, -116, -115, -117, -118, -116, -124, -18, 8, };