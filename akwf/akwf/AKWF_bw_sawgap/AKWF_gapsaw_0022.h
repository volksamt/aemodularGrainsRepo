#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {103, 123, 112, 117, 110, 113, 107,
111, 104, 107, 101, 103, 99, 100, 95, 97, 93, 93, 90, 90, 88, 87, 85, 83, 82,
80, 79, 76, 75, 74, 72, 70, 69, 67, 66, 63, 63, 60, 59, 58, 56, 54, 54, 52, 50,
48, 47, 46, 44, 42, 41, 39, 37, 36, 35, 33, 31, 30, 28, 27, 26, 23, 21, 19, 19,
17, 16, 14, 13, 11, 9, 8, 7, 5, 3, 2, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0,
0, 0, 0, 1, 0, 0, 0, 0, -1, 1, 0, 0, 0, 1, 0, 1, -1, -1, 0, 0, 0, -1, 0, 0, 0,
-1, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0,
0, 0, 0, -1, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0,
0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 1, 0,
0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 1, -1,
-1, 0, 1, 0, -1, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 1, 0,
1, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0,
-1, 0, 0, 0, 0, 1, 1, 0, 1, -1, 0, -1, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
1, 0, 1, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 1, -1, 0, 0, -1, 0, 0,
1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, 1, 1, 0, 0, -1, 0, 1, 0, 1, -1, 1, 0,
0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, -1, 0,
0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 1, 0, 1,
0, 0, -1, 0, 0, -1, -1, 0, 0, 1, 0, -1, -3, -3, -6, -7, -9, -10, -12, -13, -15,
-17, -18, -20, -21, -22, -24, -26, -28, -29, -30, -32, -34, -35, -37, -39, -41,
-42, -44, -45, -46, -49, -50, -51, -53, -54, -56, -58, -59, -60, -62, -64, -65,
-67, -69, -69, -72, -73, -75, -76, -78, -79, -81, -83, -84, -86, -87, -90, -90,
-93, -93, -96, -96, -100, -100, -102, -102, -106, -105, -108, -108, -112, -112,
-114, -115, -116, -124, -18, 8, };