#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0031

const PROGMEM int8_t DATA[DATA_LENGTH] = {103, 89, 46, 15, -5, 4, -4, 3, -3, 2,
-2, 2, -2, 1, 0, 1, -1, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, -1, 1, 0, 0,
0, 1, 1, -1, -1, 0, 0, 1, 0, -1, 0, -1, 0, -1, 0, 0, 0, 0, 1, -1, -1, 1, 0, 1,
0, -1, 0, 1, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 0, 0, -1, -1, 0, -1, 1, -1, 0, 0, 0,
0, 0, -1, 0, -1, 0, 0, 0, 0, 1, 0, 0, 1, -1, -1, -1, 0, 0, -1, 0, 0, 1, 0, 0, 0,
-1, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 1, 0, -1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0,
0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 0, -1, 0, -1, 0, 1, 0, 0, 0, 0, 0, -1, 0, 1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 1, 0, 1, 1, 1, 0, 0, 1, -1, -1, 1,
-1, 0, 0, 0, 0, 0, 0, -1, 0, -1, 1, 0, -1, -1, 0, 0, 0, -1, -1, 0, 0, 0, 1, -1,
0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 1, 0, -1, 1, 0, 0, 0, 0, 0, 1,
0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 1, 0, -1, 0, 0, 1, 0, 1, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0,
0, 0, 0, 0, 1, 0, -1, 0, 1, 0, 1, -1, 0, 1, 0, 0, 0, 0, 0, -1, -1, 0, 1, 0, 0,
-1, 0, 0, 0, 1, 1, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, -1, 0, -1, -1, 0, 0, 0, 0, 0,
-1, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0,
1, -1, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 1,
-1, 0, 0, 0, 0, 1, 1, 0, 1, 0, 0, 1, 0, 0, -1, 0, -1, 1, 0, 0, 0, -1, -1, 0, -1,
0, 0, 0, -1, -1, -1, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0,
1, -1, 0, 0, -1, 0, -1, 1, -1, 0, -1, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, -1, 0, 0, 0,
0, 1, -2, 1, -1, 1, -1, 1, -2, 2, -1, 2, -2, 1, -2, 2, -6, -43, -74, -119, -20,
9, };