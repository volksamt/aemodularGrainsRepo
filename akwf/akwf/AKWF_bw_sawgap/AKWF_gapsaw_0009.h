#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 114, 120, 114, 119, 113,
117, 111, 115, 111, 113, 110, 112, 109, 110, 108, 109, 108, 108, 107, 106, 106,
104, 104, 103, 103, 101, 101, 100, 100, 99, 99, 98, 97, 96, 96, 95, 95, 94, 94,
93, 93, 91, 91, 91, 89, 89, 88, 88, 86, 86, 86, 86, 85, 84, 83, 83, 82, 82, 81,
81, 80, 79, 78, 78, 78, 76, 76, 76, 74, 73, 73, 73, 72, 71, 70, 70, 69, 69, 68,
68, 67, 66, 66, 65, 64, 64, 62, 61, 62, 61, 60, 61, 59, 58, 58, 57, 56, 56, 56,
55, 53, 53, 53, 52, 52, 50, 51, 50, 49, 49, 47, 47, 46, 45, 44, 45, 44, 44, 42,
42, 41, 41, 40, 39, 38, 38, 37, 37, 36, 35, 36, 34, 34, 33, 33, 32, 32, 30, 29,
30, 28, 27, 27, 27, 26, 25, 25, 25, 24, 23, 22, 22, 21, 21, 20, 19, 18, 18, 17,
17, 16, 15, 14, 14, 13, 13, 12, 11, 11, 10, 10, 10, 8, 7, 8, 6, 6, 5, 4, 4, 3,
3, 2, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, -1, 1, 0, 0, 0, 0, 1, 0, -1, -1, 0, 0, 0,
0, 0, 0, 1, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1,
-1, 0, 0, 0, 0, 0, 1, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0,
0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0,
0, 0, -1, -1, 0, 0, -1, -1, -1, 0, 0, -1, -1, -1, -3, -3, -4, -5, -5, -7, -6,
-7, -8, -8, -9, -10, -11, -12, -12, -12, -13, -13, -15, -15, -15, -16, -17, -18,
-18, -19, -19, -20, -21, -22, -22, -23, -23, -24, -24, -26, -26, -26, -27, -28,
-28, -29, -29, -30, -31, -32, -32, -33, -34, -34, -35, -36, -37, -37, -38, -38,
-39, -40, -40, -41, -41, -42, -42, -42, -44, -44, -46, -45, -46, -47, -48, -49,
-49, -49, -50, -51, -52, -52, -53, -53, -54, -54, -55, -56, -56, -57, -58, -58,
-59, -60, -61, -61, -62, -62, -63, -63, -64, -64, -65, -66, -67, -67, -68, -68,
-69, -70, -70, -71, -72, -72, -73, -73, -75, -75, -75, -76, -77, -77, -78, -78,
-80, -80, -81, -80, -82, -83, -83, -84, -84, -85, -86, -87, -87, -88, -88, -89,
-89, -90, -92, -92, -93, -93, -94, -94, -95, -95, -96, -96, -97, -98, -99, -100,
-99, -100, -101, -102, -102, -103, -103, -105, -105, -106, -106, -107, -106,
-109, -107, -111, -109, -111, -111, -113, -112, -114, -112, -115, -114, -117,
-116, -117, -118, -116, -125, -19, 8, };