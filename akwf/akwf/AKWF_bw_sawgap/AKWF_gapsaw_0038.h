#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0038

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 114, 121, 114, 119, 113,
118, 113, 116, 112, 115, 112, 113, 111, 111, 110, 109, 109, 109, 108, 108, 107,
106, 106, 106, 105, 104, 104, 102, 103, 102, 103, 102, 100, 99, 100, 99, 98, 98,
97, 97, 97, 96, 95, 96, 95, 94, 93, 93, 93, 92, 91, 91, 90, 89, 89, 88, 88, 87,
87, 87, 86, 85, 85, 84, 83, 83, 83, 81, 82, 80, 80, 80, 79, 78, 77, 77, 77, 76,
76, 76, 75, 75, 73, 73, 72, 71, 72, 72, 70, 70, 69, 70, 68, 67, 67, 67, 66, 65,
65, 65, 64, 64, 63, 63, 62, 61, 61, 60, 60, 60, 59, 58, 57, 57, 57, 56, 56, 55,
55, 53, 53, 53, 51, 52, 51, 50, 50, 49, 50, 48, 48, 47, 46, 46, 46, 46, 45, 44,
44, 42, 42, 43, 42, 40, 40, 40, 39, 39, 38, 38, 37, 37, 36, 35, 35, 34, 35, 33,
33, 33, 32, 31, 30, 30, 29, 28, 29, 28, 28, 27, 26, 27, 25, 25, 24, 24, 23, 23,
22, 21, 22, 21, 20, 19, 19, 19, 18, 17, 16, 16, 16, 15, 14, 14, 14, 13, 12, 11,
11, 11, 10, 10, 9, 8, 8, 7, 7, 7, 6, 5, 5, 5, 3, 3, 3, 2, 1, 1, 1, 0, 0, 0, 0,
0, -1, 1, 0, 1, 0, 0, -1, 0, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
1, 0, -1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, -1, -1, -1, -1, -3, -3, -3, -3, -4, -4,
-5, -5, -6, -6, -6, -7, -7, -8, -9, -9, -10, -10, -12, -11, -12, -12, -12, -14,
-14, -15, -15, -15, -15, -16, -17, -18, -18, -19, -19, -19, -19, -20, -20, -21,
-21, -21, -23, -22, -23, -23, -24, -26, -25, -26, -26, -26, -27, -27, -28, -29,
-30, -30, -30, -31, -31, -31, -32, -33, -33, -33, -34, -35, -34, -35, -36, -37,
-37, -38, -38, -38, -39, -40, -39, -40, -40, -42, -42, -42, -43, -43, -44, -44,
-45, -45, -45, -46, -46, -47, -48, -48, -48, -49, -50, -50, -51, -50, -51, -52,
-52, -53, -53, -54, -55, -54, -55, -55, -56, -57, -57, -57, -58, -58, -59, -59,
-61, -61, -61, -61, -62, -62, -63, -63, -64, -65, -65, -66, -66, -67, -67, -67,
-67, -68, -69, -68, -70, -70, -71, -71, -72, -72, -73, -73, -73, -74, -74, -74,
-75, -76, -76, -77, -77, -77, -78, -78, -79, -80, -80, -81, -81, -82, -82, -83,
-83, -83, -84, -85, -85, -85, -86, -87, -86, -88, -88, -89, -88, -89, -90, -91,
-91, -91, -93, -93, -92, -93, -94, -94, -95, -96, -95, -96, -97, -97, -98, -98,
-98, -100, -100, -100, -100, -101, -102, -102, -103, -103, -104, -103, -105,
-104, -105, -106, -106, -107, -107, -108, -108, -109, -108, -111, -110, -111,
-111, -112, -111, -113, -112, -115, -113, -115, -114, -117, -114, -118, -116,
-118, -118, -117, -124, -19, 8, };