#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0040

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 125, 114, 120, 114, 119, 114,
118, 113, 116, 113, 116, 112, 114, 112, 113, 111, 111, 110, 110, 109, 109, 109,
108, 108, 107, 107, 106, 106, 105, 105, 104, 104, 103, 104, 102, 103, 101, 101,
100, 101, 100, 100, 99, 98, 98, 98, 98, 96, 96, 96, 95, 94, 94, 94, 94, 93, 92,
92, 92, 91, 91, 90, 89, 90, 88, 88, 88, 87, 87, 87, 86, 86, 86, 85, 84, 83, 83,
83, 82, 82, 81, 80, 80, 80, 80, 79, 78, 78, 77, 76, 77, 76, 76, 75, 75, 75, 74,
74, 72, 72, 71, 72, 71, 71, 71, 69, 69, 68, 68, 68, 67, 67, 65, 65, 66, 65, 64,
64, 64, 63, 62, 61, 62, 62, 60, 60, 60, 60, 59, 59, 58, 58, 57, 57, 56, 55, 55,
54, 54, 54, 53, 52, 53, 52, 52, 50, 51, 50, 49, 49, 49, 48, 48, 46, 47, 46, 45,
46, 45, 45, 44, 43, 43, 42, 42, 42, 41, 41, 41, 39, 39, 39, 38, 38, 37, 36, 37,
35, 35, 35, 34, 33, 33, 33, 33, 32, 32, 31, 31, 31, 30, 30, 29, 29, 28, 27, 27,
27, 26, 27, 25, 25, 25, 24, 24, 23, 23, 22, 21, 21, 21, 20, 20, 19, 19, 18, 18,
18, 17, 16, 16, 15, 15, 14, 14, 14, 13, 12, 12, 11, 11, 11, 9, 10, 9, 9, 9, 9,
8, 7, 7, 6, 6, 5, 5, 4, 4, 3, 3, 3, 1, 1, 1, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, -1,
-1, 0, 1, 1, 0, 1, -1, 0, 0, 0, 0, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 1, -1, -1, 1, 0, 0, 0, 0, 0, -1, 0,
0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0,
0, 0, -1, 0, -1, -1, 1, 0, 0, -1, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 1, 0,
0, 0, -1, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0,
0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, -1, 0,
0, 0, -1, -1, 1, 0, 0, 1, 0, 0, 0, -1, 0, 1, -1, 0, 0, 0, 0, -1, 0, -1, 0, 0, 1,
0, 1, -1, 1, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0,
-1, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 2,
-1, 0, 0, 1, -1, 1, -1, 1, -1, 1, -2, 2, -2, 1, -4, -34, -60, -94, -16, 6, };