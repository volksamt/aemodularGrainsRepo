#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 113, 120, 114, 119, 113,
118, 113, 116, 111, 115, 111, 113, 110, 112, 109, 109, 109, 109, 108, 107, 107,
106, 106, 105, 105, 104, 104, 103, 103, 102, 102, 100, 100, 99, 99, 98, 98, 97,
96, 96, 95, 94, 95, 94, 93, 92, 92, 92, 90, 90, 90, 90, 88, 89, 87, 87, 86, 86,
86, 85, 85, 84, 83, 82, 82, 82, 81, 80, 80, 80, 79, 78, 78, 76, 76, 76, 75, 74,
74, 74, 73, 72, 72, 71, 71, 70, 70, 69, 69, 68, 68, 67, 67, 66, 65, 65, 64, 64,
63, 63, 61, 62, 61, 60, 59, 59, 58, 57, 58, 57, 57, 55, 55, 55, 53, 53, 53, 52,
52, 51, 50, 50, 49, 50, 49, 48, 47, 47, 46, 46, 46, 45, 44, 43, 43, 42, 41, 41,
41, 40, 40, 39, 39, 39, 37, 36, 36, 35, 35, 35, 35, 33, 32, 32, 31, 30, 31, 29,
30, 29, 28, 27, 27, 27, 27, 26, 25, 24, 24, 24, 22, 22, 22, 21, 21, 20, 19, 19,
18, 18, 17, 17, 15, 15, 15, 14, 14, 14, 13, 12, 11, 10, 11, 9, 9, 9, 9, 7, 8, 6,
6, 5, 5, 3, 3, 3, 3, 2, 1, 1, 0, 0, 0, -1, 0, 0, 1, 0, 0, -1, 0, 0, -1, 0, 0, 0,
0, -1, 0, 1, -1, 0, 0, -1, -1, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 1, -1, 0, -1, 1,
0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
-1, 0, -1, 0, 0, 0, 0, 1, -1, 0, 0, 0, -1, 0, 0, 0, 0, -1, -1, 0, 0, -1, -2, -2,
-3, -3, -3, -4, -5, -5, -6, -7, -7, -8, -9, -9, -10, -11, -10, -11, -13, -12,
-13, -14, -14, -14, -16, -16, -17, -18, -18, -19, -18, -19, -20, -21, -20, -21,
-22, -23, -23, -24, -25, -25, -26, -26, -27, -27, -27, -28, -29, -29, -29, -31,
-30, -31, -32, -33, -33, -33, -35, -35, -36, -36, -37, -37, -39, -39, -38, -40,
-39, -40, -40, -42, -42, -43, -44, -43, -45, -45, -46, -46, -46, -47, -47, -48,
-48, -50, -49, -50, -51, -52, -53, -53, -53, -54, -55, -55, -56, -57, -57, -58,
-58, -59, -59, -60, -60, -60, -61, -62, -62, -62, -63, -64, -65, -65, -65, -66,
-67, -67, -68, -68, -68, -70, -70, -71, -72, -72, -73, -73, -74, -74, -74, -75,
-76, -76, -76, -77, -78, -79, -80, -80, -79, -80, -81, -82, -82, -84, -83, -85,
-85, -85, -86, -86, -87, -88, -88, -89, -90, -89, -91, -91, -92, -92, -93, -93,
-94, -94, -94, -96, -96, -96, -97, -98, -98, -99, -99, -100, -101, -102, -101,
-102, -103, -102, -104, -105, -105, -105, -106, -106, -108, -107, -109, -109,
-110, -109, -111, -110, -112, -111, -114, -112, -116, -113, -116, -114, -117,
-116, -117, -118, -116, -125, -18, 8, };