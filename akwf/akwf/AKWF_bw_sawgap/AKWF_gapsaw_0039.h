#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0039

const PROGMEM int8_t DATA[DATA_LENGTH] = {105, 124, 114, 120, 114, 118, 112,
116, 112, 114, 111, 113, 110, 112, 108, 109, 108, 108, 107, 106, 105, 105, 104,
104, 103, 101, 102, 102, 101, 99, 100, 98, 98, 97, 97, 95, 94, 94, 94, 92, 92,
91, 90, 90, 90, 89, 88, 88, 87, 86, 85, 86, 84, 85, 83, 83, 82, 81, 80, 80, 79,
78, 77, 77, 76, 76, 75, 74, 74, 73, 73, 72, 71, 70, 69, 69, 69, 67, 66, 66, 65,
65, 65, 64, 63, 62, 61, 61, 60, 60, 59, 58, 57, 57, 56, 56, 55, 54, 54, 53, 52,
51, 50, 50, 50, 49, 48, 47, 47, 47, 45, 44, 45, 43, 43, 42, 41, 40, 39, 39, 39,
37, 38, 37, 36, 36, 35, 34, 33, 33, 32, 32, 31, 31, 30, 29, 28, 28, 27, 26, 26,
25, 24, 24, 23, 23, 21, 21, 20, 20, 19, 19, 17, 17, 16, 16, 15, 14, 13, 12, 12,
11, 11, 11, 10, 9, 8, 7, 7, 7, 5, 5, 5, 4, 3, 3, 1, 0, 0, -1, 1, 0, 0, 0, 0, -1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 1, 0, 1, 1, 1, 0, 0, 0, 0, 0, 0,
-1, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, -1, -1,
0, 0, 0, -1, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1,
0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0,
-1, 1, 0, -1, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 1,
0, 1, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, -1, 0, 0, 1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0,
-1, 0, 0, -1, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, -1,
-1, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, -3, -4, -5, -7, -7, -8, -11, -11, -13, -15,
-16, -16, -18, -20, -22, -24, -24, -25, -27, -29, -30, -31, -33, -34, -35, -37,
-39, -40, -41, -42, -44, -46, -46, -48, -50, -51, -53, -53, -56, -56, -57, -60,
-61, -63, -63, -65, -67, -67, -69, -71, -72, -73, -74, -76, -77, -78, -80, -82,
-83, -85, -86, -87, -90, -89, -93, -92, -95, -95, -97, -97, -101, -100, -104,
-103, -107, -106, -109, -109, -111, -112, -115, -116, -114, -124, -19, 8, };