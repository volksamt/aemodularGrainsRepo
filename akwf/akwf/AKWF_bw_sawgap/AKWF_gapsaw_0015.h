#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 123, 114, 120, 112, 118, 111,
115, 110, 113, 109, 111, 108, 108, 106, 107, 105, 104, 103, 102, 102, 101, 101,
98, 98, 96, 96, 95, 94, 93, 93, 91, 92, 90, 89, 88, 87, 86, 86, 84, 84, 83, 82,
82, 80, 79, 79, 78, 77, 75, 75, 74, 73, 73, 71, 71, 70, 69, 67, 67, 66, 66, 65,
64, 63, 62, 61, 60, 59, 58, 57, 57, 56, 55, 55, 53, 53, 51, 50, 50, 49, 48, 47,
46, 45, 45, 44, 42, 41, 41, 40, 39, 39, 37, 36, 36, 35, 34, 33, 32, 31, 30, 30,
29, 27, 27, 26, 25, 24, 24, 23, 22, 21, 20, 19, 18, 16, 17, 16, 15, 15, 13, 12,
11, 10, 9, 8, 7, 6, 6, 5, 4, 3, 2, 1, 1, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, -1,
1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, -1, 0, 0, -1, 0, 0, 1, 0,
0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0,
0, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0,
0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0,
0, 0, 0, 1, 0, 0, 1, 0, -1, 0, 0, 1, 0, -1, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0,
0, -1, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, -1, 0, 1,
0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, -1, 0, 0,
0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 1, -1, 0, 0, 0, 1, 0, 0, -1,
-2, -3, -4, -4, -6, -7, -7, -8, -9, -10, -12, -12, -13, -13, -14, -15, -17, -17,
-18, -19, -20, -21, -21, -22, -23, -24, -25, -26, -27, -28, -29, -29, -30, -31,
-32, -33, -34, -34, -36, -37, -37, -38, -40, -39, -40, -42, -42, -43, -44, -46,
-47, -47, -48, -49, -49, -51, -52, -52, -53, -54, -55, -56, -57, -58, -58, -59,
-60, -61, -62, -62, -64, -65, -65, -67, -67, -68, -69, -70, -70, -72, -73, -73,
-74, -74, -76, -77, -77, -78, -79, -80, -81, -83, -83, -85, -84, -86, -87, -88,
-88, -89, -90, -90, -92, -93, -94, -95, -96, -96, -98, -98, -99, -99, -101,
-100, -103, -102, -104, -104, -107, -106, -108, -108, -111, -108, -112, -110,
-114, -113, -115, -115, -117, -118, -116, -125, -18, 7, };