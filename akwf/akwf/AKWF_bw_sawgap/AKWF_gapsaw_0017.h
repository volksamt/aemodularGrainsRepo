#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {-9, 25, 127, 114, 118, 115, 115, 114,
113, 113, 109, 111, 108, 108, 106, 106, 104, 104, 102, 102, 100, 100, 98, 98,
96, 95, 95, 94, 92, 92, 91, 90, 88, 87, 87, 86, 85, 84, 83, 81, 81, 80, 78, 77,
76, 76, 74, 74, 73, 71, 71, 69, 69, 68, 66, 66, 64, 63, 62, 62, 60, 60, 59, 57,
57, 56, 55, 54, 53, 51, 50, 50, 49, 47, 47, 46, 44, 44, 43, 41, 41, 39, 38, 37,
37, 36, 34, 34, 33, 32, 30, 30, 28, 28, 26, 26, 25, 24, 22, 22, 20, 19, 18, 18,
17, 16, 14, 14, 12, 11, 10, 10, 8, 7, 7, 5, 4, 4, 3, 1, 0, -1, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, -1, 0, 1, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0,
0, 0, -1, 0, 0, 1, 1, 0, 1, 0, -1, 0, -1, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0,
0, 1, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 1, -1,
-1, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 1,
0, -1, 0, -1, 1, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1,
0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 1, 0, -1, 0, 0, 0, 1, 0,
0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0,
0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 1, 0,
0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0,
-1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, -1, 0, 0, 0, 0,
0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -3, -4, -5, -6, -6, -8, -8, -10, -10,
-12, -13, -13, -14, -16, -16, -17, -19, -21, -21, -21, -23, -24, -24, -25, -27,
-28, -29, -29, -31, -31, -33, -33, -35, -35, -37, -39, -38, -39, -41, -42, -42,
-44, -45, -46, -47, -47, -49, -49, -51, -52, -53, -55, -55, -56, -57, -58, -59,
-59, -60, -62, -63, -64, -65, -66, -67, -68, -68, -70, -71, -72, -73, -74, -75,
-75, -77, -77, -79, -80, -82, -82, -83, -84, -85, -86, -88, -88, -89, -89, -92,
-91, -94, -94, -96, -96, -97, -98, -99, -100, -102, -102, -103, -105, -104,
-108, -106, -109, -108, -112, -109, -114, -111, -117, -112, -121, -112, -126,
-101, };