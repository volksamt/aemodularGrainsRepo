#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0032

const PROGMEM int8_t DATA[DATA_LENGTH] = {-9, 22, 96, 56, 34, 3, -1, 1, -1, 1,
-1, 1, -1, 2, -1, 1, -1, 1, -1, 2, -1, 0, -1, 1, -1, 1, -1, -1, 0, 0, -1, -1, 0,
0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, -1,
0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 1, -1, 0, -1, -1, 0, -1, 0, 0, 0,
1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 1, 0, -1, 0, -1, 0,
0, 1, -1, 0, 0, 1, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0,
0, 0, 0, -1, 1, 0, 0, 1, 0, 1, -1, -1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 1, 0,
0, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, -1, -1, -1, 0, 0, 0, 0, -1, 0,
0, -1, -1, -1, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0,
0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, -1, 0, -1, -1, 1, 0, -1, 0,
0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0,
1, 1, 1, 0, 0, 0, 1, 0, -1, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0,
-1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, -1, 1, 0, 0, 0, 0, 1, 0, 0, 1,
1, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0,
0, 0, 0, 0, 1, 1, 1, 1, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, -1, 1, 0, 0, 1, 1, 0, 0,
1, 1, 0, 1, -1, 0, 0, 0, 0, 1, 0, 1, 0, 1, -1, 0, 0, 0, -1, 0, 0, -1, 1, 0, -1,
0, 0, -1, -2, -2, -3, -4, -6, -6, -8, -8, -10, -11, -12, -13, -13, -16, -16,
-16, -17, -19, -20, -21, -22, -23, -24, -26, -25, -27, -28, -29, -30, -30, -31,
-33, -35, -34, -36, -37, -38, -39, -40, -40, -41, -42, -44, -44, -46, -47, -48,
-49, -50, -51, -52, -53, -54, -55, -56, -56, -58, -59, -60, -61, -62, -63, -64,
-64, -66, -66, -68, -69, -70, -70, -71, -73, -74, -75, -76, -77, -78, -79, -80,
-82, -82, -83, -84, -86, -85, -87, -87, -89, -90, -91, -91, -93, -94, -95, -96,
-98, -98, -99, -100, -101, -103, -102, -105, -104, -108, -106, -109, -107, -111,
-109, -115, -111, -117, -112, -121, -112, -126, -102, };