#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0034

const PROGMEM int8_t DATA[DATA_LENGTH] = {-10, 26, 127, 110, 113, 108, 106, 103,
100, 98, 94, 92, 88, 87, 82, 81, 77, 76, 71, 70, 66, 65, 60, 58, 55, 52, 49, 47,
44, 41, 38, 34, 32, 29, 27, 24, 21, 18, 15, 13, 10, 6, 5, 1, 0, 0, -1, -1, 0, 0,
0, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0,
0, 0, 0, 0, -1, 0, -1, 1, 1, -1, -1, -1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 0, 0, 0, -1,
-1, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0,
0, 1, 0, 0, 0, 0, 0, 1, 0, -1, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
0, 1, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 1, 0, -1, -1, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0,
0, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, -1, 0, -1, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0,
0, 0, -1, 0, -1, -1, -1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0,
0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0,
-1, 0, 1, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0,
-1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 1, 0, 0, 0, -1, 0, -1, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, -2, -4, -5, -7, -8, -10,
-10, -12, -14, -14, -17, -18, -18, -20, -22, -23, -25, -26, -28, -29, -30, -32,
-33, -35, -36, -37, -39, -40, -41, -43, -44, -45, -47, -48, -50, -51, -53, -55,
-56, -58, -59, -60, -61, -63, -65, -66, -67, -68, -70, -71, -73, -75, -76, -77,
-78, -79, -80, -83, -84, -85, -86, -88, -90, -91, -93, -93, -96, -96, -98, -99,
-102, -101, -105, -103, -108, -106, -111, -109, -115, -110, -118, -112, -125,
-101, };