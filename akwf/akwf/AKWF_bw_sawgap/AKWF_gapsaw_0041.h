#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0041

const PROGMEM int8_t DATA[DATA_LENGTH] = {-10, 26, 127, 112, 115, 110, 109, 107,
103, 102, 99, 98, 94, 94, 89, 89, 84, 83, 79, 79, 74, 74, 70, 69, 66, 64, 61,
59, 57, 55, 52, 49, 48, 45, 42, 40, 38, 35, 33, 31, 28, 27, 24, 22, 19, 17, 14,
12, 9, 7, 5, 2, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1,
0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0,
-1, 1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 1, 0, 0,
0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
-1, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0,
0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, -1, 0,
1, -1, -1, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, -1, 0, 1, 0, -1, 1, 0, 0,
0, 1, 0, 0, 0, -1, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0,
0, 0, 0, 0, 1, 0, 0, 0, -1, 1, 0, 0, 0, 1, 0, 1, 1, 0, 0, -1, 1, 0, 0, 0, 0, 0,
0, 1, -1, 0, 1, 1, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, -1,
0, 0, 0, 0, 1, 1, 0, -1, -1, 0, 0, 0, -1, 0, 0, 0, 1, 0, 1, 0, 1, -1, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0,
-1, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
0, 0, 1, 0, 0, -1, 0, 0, 1, 0, 0, 0, 1, 1, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0,
-1, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 1, 0, 1, 0, 0, 1, 0, -1, 1, 0, -2, -4, -6, -8,
-10, -12, -14, -16, -18, -20, -22, -24, -25, -28, -30, -33, -34, -36, -39, -41,
-42, -44, -46, -49, -51, -52, -54, -56, -58, -61, -63, -64, -67, -68, -71, -72,
-76, -76, -79, -80, -83, -86, -87, -90, -90, -93, -93, -98, -97, -103, -101,
-108, -105, -112, -108, -117, -110, -125, -101, };