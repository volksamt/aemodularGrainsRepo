#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {105, 123, 113, 120, 113, 117, 111,
115, 109, 113, 108, 110, 106, 108, 106, 106, 104, 103, 101, 102, 100, 99, 99,
97, 98, 95, 95, 93, 93, 91, 91, 90, 90, 88, 87, 86, 86, 84, 84, 83, 81, 80, 80,
79, 77, 77, 76, 75, 74, 73, 72, 71, 71, 70, 68, 68, 66, 66, 64, 63, 63, 61, 61,
60, 59, 58, 58, 56, 56, 55, 53, 53, 52, 51, 50, 49, 48, 47, 46, 45, 44, 43, 42,
42, 40, 39, 38, 38, 36, 35, 35, 34, 33, 33, 31, 30, 30, 28, 27, 26, 26, 24, 23,
22, 21, 21, 19, 19, 18, 17, 16, 15, 14, 14, 13, 11, 11, 9, 9, 8, 6, 6, 5, 4, 3,
2, 1, 0, 0, 1, 0, 1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, -1, 0,
0, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, -1, 0, 0, -1, -1, 0, 0, -1, 0, 0, 0, 1, 0, 0,
0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, -1, -1, 0, 0, 0, 1, 0,
-1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0,
0, 1, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0,
0, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0,
0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0,
0, 0, -1, 0, -1, 0, 1, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, -1,
0, 0, -1, -1, -3, -4, -5, -5, -7, -7, -8, -9, -11, -11, -11, -14, -14, -15, -16,
-17, -18, -19, -20, -21, -21, -23, -24, -23, -25, -25, -27, -28, -29, -29, -31,
-32, -32, -33, -35, -36, -36, -37, -38, -39, -40, -41, -42, -43, -44, -45, -46,
-47, -47, -49, -49, -51, -51, -52, -53, -54, -55, -57, -57, -58, -59, -59, -62,
-62, -62, -63, -65, -66, -66, -67, -69, -70, -70, -70, -71, -72, -74, -74, -75,
-76, -78, -78, -80, -80, -81, -83, -83, -84, -86, -85, -87, -87, -89, -90, -92,
-92, -93, -94, -94, -95, -96, -98, -98, -100, -99, -102, -101, -104, -103, -106,
-104, -108, -107, -110, -108, -112, -110, -114, -113, -114, -114, -115, -118,
-116, -125, -19, 8, };