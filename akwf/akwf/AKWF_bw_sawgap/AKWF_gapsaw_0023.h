#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {103, 123, 111, 117, 109, 113, 105,
108, 103, 105, 99, 100, 98, 97, 94, 94, 90, 90, 88, 86, 83, 82, 81, 78, 77, 74,
73, 71, 70, 67, 67, 64, 62, 61, 59, 58, 56, 53, 52, 50, 49, 46, 45, 43, 41, 39,
38, 37, 34, 33, 31, 29, 27, 26, 23, 22, 20, 19, 17, 14, 13, 11, 9, 8, 6, 4, 2,
0, 0, 0, -1, -1, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, -1, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0,
0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 1, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, -1, 0, 0, 0, 1,
-1, 0, 0, -1, 0, 0, 1, -1, 0, -1, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0,
0, 1, 1, 0, 0, 0, 0, 0, -1, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0,
0, 0, -1, -1, 0, 0, 0, 0, -1, 1, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
1, 1, 1, 0, 0, 0, 0, 0, -1, -1, 0, 0, 1, 0, 0, -1, 1, 0, -1, 0, 0, 0, 0, 0, 0,
0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0,
0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 1, 0, 0, 0, 0,
1, 0, 0, 0, 0, 0, 0, 0, 0, 1, -1, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1,
0, 0, 1, 0, 1, -1, 0, 1, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0,
1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, -1, 0, 0, -1,
1, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -3, -4, -5, -8, -10, -10,
-13, -14, -16, -18, -19, -21, -23, -26, -27, -28, -30, -32, -34, -36, -38, -38,
-41, -42, -45, -46, -48, -49, -51, -53, -55, -56, -59, -60, -62, -64, -66, -67,
-69, -70, -73, -74, -76, -78, -80, -81, -83, -85, -86, -89, -90, -93, -93, -97,
-96, -100, -100, -104, -103, -107, -106, -110, -111, -113, -115, -115, -124,
-19, 9, };