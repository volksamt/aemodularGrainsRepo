#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 114, 121, 114, 118, 113,
117, 113, 116, 111, 115, 111, 113, 111, 111, 110, 110, 109, 109, 108, 108, 108,
106, 106, 105, 106, 104, 104, 103, 104, 103, 103, 101, 100, 100, 100, 99, 99,
98, 97, 97, 96, 96, 95, 95, 94, 93, 93, 93, 92, 92, 90, 90, 90, 89, 89, 88, 87,
88, 87, 86, 86, 85, 84, 83, 83, 83, 82, 82, 81, 80, 81, 79, 79, 78, 78, 78, 77,
77, 76, 76, 75, 75, 74, 73, 73, 72, 72, 70, 71, 70, 69, 69, 69, 67, 67, 66, 67,
65, 65, 65, 64, 64, 64, 62, 63, 60, 62, 61, 60, 58, 59, 58, 58, 57, 57, 56, 55,
55, 54, 54, 53, 53, 52, 52, 51, 51, 50, 50, 49, 48, 48, 47, 47, 46, 46, 45, 44,
44, 44, 43, 43, 42, 41, 40, 40, 39, 39, 38, 38, 38, 37, 37, 35, 35, 35, 35, 33,
33, 32, 32, 32, 31, 30, 30, 29, 30, 28, 28, 27, 27, 26, 25, 26, 24, 24, 24, 24,
22, 22, 22, 20, 21, 19, 20, 20, 18, 18, 16, 17, 17, 16, 15, 14, 14, 13, 13, 12,
12, 11, 10, 11, 10, 9, 9, 8, 8, 7, 7, 6, 5, 4, 5, 3, 3, 2, 2, 2, 1, 1, 0, -1,
-1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1,
0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1, -1, -2, -3, -2, -3, -4, -4, -5,
-6, -6, -7, -7, -7, -7, -8, -8, -9, -10, -10, -11, -12, -12, -12, -13, -14, -15,
-15, -16, -16, -17, -17, -18, -18, -18, -20, -20, -20, -21, -21, -23, -23, -23,
-24, -24, -24, -26, -26, -26, -27, -27, -28, -28, -28, -30, -30, -30, -31, -32,
-33, -33, -34, -33, -34, -35, -36, -36, -36, -37, -38, -39, -39, -39, -39, -41,
-40, -41, -42, -42, -43, -43, -44, -44, -46, -45, -46, -47, -47, -48, -48, -48,
-50, -50, -50, -51, -52, -52, -53, -53, -54, -54, -55, -56, -56, -56, -57, -58,
-58, -59, -59, -59, -60, -61, -62, -62, -62, -63, -64, -63, -65, -65, -66, -66,
-67, -67, -68, -68, -69, -69, -69, -70, -71, -71, -72, -73, -73, -73, -74, -75,
-75, -76, -76, -77, -78, -79, -78, -79, -79, -80, -80, -81, -82, -81, -83, -84,
-84, -84, -86, -86, -85, -87, -87, -88, -88, -89, -89, -90, -91, -91, -92, -93,
-92, -92, -93, -94, -94, -95, -96, -96, -96, -97, -98, -98, -98, -101, -100,
-100, -101, -102, -102, -104, -103, -104, -105, -105, -105, -106, -107, -107,
-108, -108, -110, -109, -110, -110, -112, -111, -113, -111, -115, -112, -116,
-113, -116, -114, -118, -116, -118, -119, -117, -125, -18, 7, };