#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 115, 121, 114, 118, 113,
117, 112, 116, 111, 113, 111, 113, 109, 112, 109, 109, 108, 108, 107, 107, 106,
105, 105, 104, 104, 102, 103, 102, 102, 101, 101, 100, 99, 98, 99, 97, 97, 96,
96, 95, 95, 94, 93, 93, 92, 91, 91, 90, 89, 89, 89, 88, 88, 87, 87, 86, 86, 85,
83, 83, 82, 82, 81, 81, 81, 80, 79, 79, 78, 77, 77, 76, 77, 75, 75, 75, 73, 73,
72, 72, 71, 71, 70, 69, 69, 69, 68, 67, 67, 66, 65, 64, 64, 63, 63, 63, 62, 61,
61, 60, 59, 58, 58, 57, 57, 57, 56, 56, 55, 55, 53, 53, 53, 52, 51, 51, 50, 49,
49, 49, 48, 47, 47, 47, 45, 46, 44, 44, 43, 43, 43, 42, 41, 41, 40, 38, 39, 38,
37, 36, 36, 35, 35, 35, 34, 33, 33, 32, 31, 30, 30, 29, 29, 29, 27, 28, 27, 26,
26, 25, 24, 24, 23, 23, 23, 22, 21, 20, 20, 19, 18, 18, 17, 16, 16, 15, 15, 14,
14, 13, 12, 12, 12, 11, 10, 10, 9, 8, 8, 7, 7, 6, 6, 5, 4, 3, 4, 3, 3, 2, 1, 1,
1, 0, 1, 0, 0, 0, 0, 1, 1, 0, 1, 0, 0, 1, -1, 0, 0, 0, 0, 0, -1, 0, 0, 1, -1,
-1, 0, -1, 1, 0, -1, 0, 0, 0, 0, 0, -1, -1, 0, 1, -1, 0, 0, 1, -1, 0, 0, 1, 1,
0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, -1, 0,
0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 1, 0, 0, -1, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0,
0, -1, -2, -2, -2, -2, -3, -4, -4, -5, -5, -7, -8, -8, -9, -9, -9, -10, -11,
-11, -11, -12, -12, -14, -13, -14, -15, -16, -16, -17, -18, -18, -19, -19, -20,
-19, -21, -21, -23, -23, -23, -24, -24, -25, -25, -27, -27, -27, -28, -29, -29,
-30, -30, -31, -32, -32, -32, -33, -34, -34, -35, -35, -36, -36, -37, -38, -38,
-39, -40, -40, -41, -41, -41, -42, -43, -44, -44, -45, -46, -46, -46, -47, -47,
-48, -49, -49, -50, -50, -51, -52, -52, -54, -54, -54, -55, -55, -56, -56, -57,
-57, -59, -59, -59, -60, -60, -61, -62, -63, -63, -63, -64, -65, -65, -65, -67,
-66, -68, -68, -69, -69, -70, -70, -71, -72, -71, -74, -73, -74, -75, -75, -75,
-76, -76, -78, -79, -79, -80, -80, -81, -81, -81, -82, -83, -84, -84, -85, -85,
-86, -86, -86, -87, -88, -88, -89, -90, -91, -91, -91, -92, -92, -94, -94, -94,
-94, -96, -96, -96, -96, -99, -98, -99, -100, -101, -101, -102, -102, -103,
-103, -103, -104, -104, -105, -105, -107, -107, -108, -109, -110, -109, -112,
-110, -113, -111, -114, -111, -115, -113, -116, -114, -117, -116, -117, -119,
-116, -124, -18, 8, };