#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {105, 124, 114, 120, 113, 117, 112,
116, 112, 113, 109, 112, 109, 110, 108, 107, 105, 106, 105, 105, 104, 103, 102,
100, 100, 100, 99, 97, 98, 96, 95, 95, 95, 93, 93, 91, 91, 90, 89, 88, 88, 87,
86, 85, 85, 84, 84, 83, 82, 81, 80, 79, 78, 78, 77, 76, 75, 75, 73, 73, 72, 72,
71, 70, 69, 69, 68, 66, 67, 66, 64, 64, 62, 62, 61, 61, 60, 59, 58, 58, 57, 56,
55, 54, 54, 52, 52, 51, 51, 50, 48, 48, 47, 47, 45, 45, 44, 43, 42, 42, 41, 41,
39, 39, 38, 37, 37, 35, 35, 33, 34, 33, 32, 30, 30, 30, 29, 28, 27, 26, 25, 24,
23, 23, 23, 21, 21, 20, 19, 18, 18, 17, 16, 15, 14, 14, 14, 12, 12, 11, 10, 9,
8, 7, 6, 6, 5, 4, 4, 2, 2, 1, 1, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0,
0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, -1, -1, 0,
0, 1, 0, 0, 1, 0, -1, 0, 1, -1, 1, 0, 0, 0, 0, 0, 1, 0, 1, 0, -1, 0, -1, 0, 0,
0, 0, 1, 0, 1, -1, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, 1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
-1, 0, 0, 0, -1, 0, 0, 1, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0,
-1, 0, 0, 0, -1, 1, -1, 0, 0, 0, 0, 1, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, 0, -1, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, -1, 0, -1, 1, 0, -1, 0, 0, 0, 0,
0, -1, 0, 0, 0, 0, 0, -1, 0, 1, -1, 0, 0, -1, -2, -2, -3, -4, -4, -6, -7, -7,
-9, -9, -10, -11, -11, -12, -13, -13, -14, -16, -16, -16, -18, -18, -19, -20,
-20, -22, -23, -23, -24, -25, -25, -26, -27, -27, -28, -29, -30, -31, -31, -32,
-34, -34, -35, -35, -36, -37, -37, -38, -39, -41, -41, -42, -42, -43, -43, -45,
-46, -46, -47, -48, -48, -49, -51, -51, -51, -52, -53, -55, -55, -56, -57, -57,
-58, -60, -59, -60, -61, -62, -63, -64, -64, -64, -67, -67, -67, -69, -69, -70,
-71, -71, -72, -74, -73, -75, -75, -76, -77, -78, -78, -79, -80, -81, -82, -82,
-82, -84, -85, -85, -86, -87, -88, -88, -90, -89, -90, -92, -93, -92, -94, -95,
-96, -96, -97, -98, -99, -100, -100, -101, -101, -102, -102, -105, -104, -106,
-105, -108, -107, -110, -108, -112, -110, -113, -111, -115, -113, -116, -115,
-117, -118, -116, -124, -19, 8, };