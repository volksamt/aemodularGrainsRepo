#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0035

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 123, 113, 118, 112, 116, 110,
114, 109, 111, 107, 110, 106, 107, 104, 105, 102, 102, 100, 100, 99, 98, 97, 95,
95, 94, 94, 92, 90, 89, 90, 87, 87, 85, 85, 84, 83, 81, 81, 80, 79, 78, 77, 77,
74, 73, 72, 72, 71, 70, 69, 68, 66, 65, 65, 64, 63, 61, 61, 60, 59, 58, 57, 55,
55, 53, 52, 52, 51, 49, 49, 47, 47, 45, 45, 43, 43, 41, 41, 39, 39, 37, 37, 35,
35, 33, 32, 31, 31, 29, 28, 27, 27, 25, 24, 24, 22, 22, 21, 20, 18, 17, 16, 15,
15, 14, 13, 12, 11, 9, 9, 7, 6, 6, 5, 4, 3, 2, 1, 0, 1, -1, 0, 0, -1, 0, 1, 0,
0, 0, -1, 0, 0, 0, -1, 0, 0, -1, 0, -1, 0, 0, 1, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0,
0, 1, 0, 0, 0, -1, -1, -1, -1, 0, 0, 0, 0, -1, 0, -1, -1, 0, 1, 0, 0, -1, 0, 0,
0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0,
0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0,
0, 0, 0, -1, 0, 0, 0, 1, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1,
0, -1, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 1, 0, 0, 0, 1, 0,
0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0,
0, 1, 0, -1, 1, 0, 0, -1, -1, -1, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0,
-1, -1, -2, -3, -4, -4, -5, -5, -7, -6, -7, -8, -9, -9, -10, -10, -12, -12, -12,
-14, -14, -14, -16, -16, -17, -18, -19, -18, -20, -20, -21, -21, -21, -22, -24,
-24, -25, -25, -26, -27, -28, -28, -29, -30, -30, -31, -31, -32, -32, -32, -34,
-34, -35, -37, -36, -37, -38, -39, -39, -40, -40, -42, -42, -43, -43, -45, -45,
-45, -47, -47, -47, -48, -49, -50, -50, -51, -51, -53, -53, -54, -55, -54, -55,
-56, -57, -57, -58, -59, -59, -60, -61, -61, -63, -62, -64, -64, -65, -65, -65,
-67, -68, -68, -68, -69, -70, -70, -71, -72, -73, -73, -74, -75, -76, -76, -77,
-78, -78, -79, -79, -80, -81, -81, -83, -82, -84, -84, -85, -86, -86, -87, -87,
-88, -89, -90, -90, -91, -92, -92, -93, -94, -94, -94, -96, -96, -97, -98, -98,
-100, -100, -100, -100, -101, -102, -102, -103, -104, -105, -105, -107, -106,
-109, -108, -110, -109, -111, -110, -112, -111, -114, -113, -115, -115, -117,
-115, -117, -119, -116, -125, -19, 8, };