#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0036

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 123, 113, 119, 111, 115, 108,
111, 106, 108, 103, 105, 101, 102, 98, 99, 96, 96, 94, 93, 91, 89, 88, 87, 85,
84, 83, 81, 80, 78, 77, 74, 75, 73, 72, 70, 69, 67, 66, 64, 63, 61, 60, 59, 58,
56, 54, 52, 51, 49, 48, 47, 46, 45, 42, 42, 40, 39, 38, 36, 34, 33, 32, 30, 29,
28, 26, 24, 23, 21, 20, 19, 18, 17, 15, 14, 12, 10, 9, 8, 7, 4, 4, 2, 0, 0, 0,
0, -1, -1, 0, 0, 1, 1, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 1, 1,
0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, -1, 0, 1, -1, 0, 0, 0, 1, -1, 0, 0, -1,
0, 1, 0, -1, -1, 1, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 1, 0, -1, -1, -1, 0, 0, 1, 0, 0, -1, 0, 0, 0, -1, 1, 0, 0, -1, 0, 0, 0,
0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 1,
0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 1, -1, 0, 0, 1, 1, 0, 0, 0,
1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, -1,
0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, -1, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0,
0, 1, 0, -1, 0, -1, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, -1, -1,
0, 0, 0, 1, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, -1, -1, -1, 0, -1, 0, 0, 1, -1, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, 1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 1, 0,
0, 1, 0, -1, 0, 0, 0, 1, 0, 1, 1, -1, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, -1, 0, 0,
0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, 1, 1, 0, 1, 0, 1, -1, 0, 0, 0, 0, -1, 0,
0, 0, 0, 0, 1, 0, 0, 0, -1, 0, -1, -1, 0, 1, 1, 0, 1, 0, 0, 0, 0, 0, 0, 1, -1,
2, 0, 2, -2, 1, -1, 1, -1, 2, -2, 2, -2, 1, -5, -35, -59, -96, -16, 8, };