#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {105, 123, 113, 119, 111, 115, 109,
112, 107, 109, 105, 106, 102, 104, 100, 101, 98, 97, 95, 95, 93, 92, 91, 89, 88,
87, 86, 84, 84, 81, 81, 80, 77, 76, 76, 74, 73, 71, 71, 69, 68, 67, 64, 64, 63,
62, 60, 59, 57, 57, 55, 53, 52, 51, 50, 50, 47, 45, 45, 44, 43, 40, 40, 39, 37,
35, 34, 34, 32, 31, 29, 29, 27, 26, 24, 22, 22, 20, 19, 18, 16, 15, 14, 13, 12,
11, 9, 8, 7, 5, 4, 2, 2, 0, 0, 0, 0, 0, 1, 0, 0, -1, -1, 0, 0, 0, 0, -1, 0, 0,
-1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0,
0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
-1, 0, -1, -1, 0, 0, 0, 0, 1, -1, 0, 1, -1, 0, 0, 0, -1, -1, 0, 0, -1, 0, 0, -1,
0, 0, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, -1, 0, -1, 0, 0, 0,
0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 1, 0, 1, 0, 0, 1, 0, 0, -1, 0, 1, 0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0,
0, -1, 1, -1, 0, -1, 0, -1, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, -1, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0,
0, -1, 0, 1, 0, 0, -1, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 1, 1, 0, 0, 0,
-1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, -1,
0, 0, -1, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0,
-1, 0, 0, 0, -2, -3, -4, -6, -7, -9, -10, -12, -13, -14, -15, -16, -18, -19,
-20, -22, -23, -24, -25, -27, -28, -29, -30, -32, -33, -34, -36, -37, -38, -39,
-40, -42, -42, -44, -46, -47, -48, -50, -51, -52, -54, -55, -56, -58, -58, -60,
-61, -62, -64, -66, -67, -68, -69, -70, -71, -73, -74, -75, -75, -78, -78, -81,
-81, -83, -84, -85, -87, -87, -90, -90, -93, -93, -96, -96, -98, -97, -101, -99,
-104, -102, -106, -104, -109, -107, -110, -109, -113, -113, -115, -117, -115,
-124, -18, 8, };