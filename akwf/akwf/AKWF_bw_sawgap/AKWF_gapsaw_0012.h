#define DATA_LENGTH 512
#define DATA AKWF_gapsaw_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 123, 114, 120, 113, 117, 113,
116, 112, 114, 110, 112, 109, 110, 108, 109, 107, 107, 105, 105, 105, 104, 102,
101, 101, 100, 99, 99, 99, 97, 97, 95, 95, 94, 93, 92, 93, 91, 91, 90, 90, 89,
89, 87, 87, 86, 85, 84, 83, 84, 82, 81, 80, 80, 80, 78, 77, 77, 76, 76, 74, 74,
73, 72, 71, 71, 71, 70, 69, 67, 68, 67, 67, 65, 65, 64, 63, 62, 62, 61, 61, 59,
58, 58, 57, 56, 55, 54, 54, 54, 53, 52, 51, 51, 49, 49, 49, 48, 47, 46, 46, 45,
44, 43, 42, 42, 41, 40, 39, 38, 38, 36, 36, 36, 36, 33, 34, 33, 32, 31, 31, 29,
29, 28, 27, 27, 26, 25, 25, 24, 23, 23, 21, 21, 21, 20, 19, 18, 18, 17, 16, 15,
14, 13, 12, 11, 11, 11, 9, 9, 8, 8, 7, 6, 5, 4, 4, 3, 2, 1, 0, 0, 0, -1, 0, 0,
-1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1,
0, 0, 0, 0, 0, -1, 0, 0, 1, 1, 0, 1, 0, 1, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1,
0, 0, 0, 0, 1, 0, 1, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, -1, 1, 1, 0,
0, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0,
0, 1, 0, 0, -1, 0, -1, -1, 0, 0, 0, 0, 0, 1, 0, 0, -1, 1, 0, 0, 0, 1, 0, 0, 0,
0, -1, 0, -2, -2, -3, -4, -4, -5, -6, -7, -7, -9, -9, -9, -10, -11, -11, -12,
-13, -14, -14, -15, -16, -16, -17, -18, -19, -20, -20, -21, -22, -23, -24, -24,
-25, -26, -26, -28, -28, -30, -29, -30, -31, -32, -33, -33, -34, -34, -35, -36,
-37, -38, -39, -40, -40, -41, -41, -43, -43, -43, -45, -44, -46, -46, -47, -48,
-50, -50, -51, -51, -52, -52, -53, -54, -55, -56, -55, -57, -57, -58, -59, -60,
-60, -61, -62, -63, -63, -64, -65, -65, -67, -67, -67, -68, -70, -70, -71, -72,
-72, -74, -74, -74, -75, -76, -76, -77, -78, -79, -80, -80, -81, -81, -83, -83,
-83, -84, -85, -87, -87, -88, -89, -90, -90, -91, -92, -93, -93, -93, -94, -95,
-97, -97, -97, -98, -99, -101, -100, -101, -103, -103, -104, -104, -105, -105,
-108, -107, -109, -108, -110, -109, -112, -111, -114, -112, -115, -113, -116,
-116, -117, -118, -117, -125, -18, 8, };