#define DATA_LENGTH 512
#define DATA AKWF_pluckalgo_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 8, 11, 15, 19, 22, 25, 29, 32,
35, 39, 44, 47, 52, 56, 61, 65, 69, 74, 78, 82, 87, 89, 94, 97, 100, 102, 102,
104, 104, 105, 104, 104, 102, 101, 101, 98, 97, 95, 92, 90, 87, 84, 82, 79, 75,
73, 70, 67, 63, 60, 56, 52, 50, 47, 44, 41, 38, 37, 36, 35, 34, 35, 36, 38, 41,
44, 46, 51, 55, 60, 65, 69, 73, 77, 81, 86, 89, 93, 96, 98, 101, 103, 105, 107,
108, 110, 111, 113, 114, 115, 116, 117, 117, 119, 119, 119, 119, 119, 119, 118,
118, 118, 116, 115, 114, 113, 111, 110, 109, 108, 107, 107, 106, 105, 104, 103,
102, 102, 101, 101, 101, 100, 99, 98, 96, 96, 93, 91, 90, 88, 85, 83, 80, 78,
76, 75, 73, 72, 70, 69, 68, 67, 67, 67, 66, 67, 67, 67, 68, 68, 68, 69, 70, 70,
71, 71, 71, 71, 70, 70, 69, 69, 69, 67, 67, 67, 66, 66, 67, 67, 68, 68, 70, 71,
73, 75, 77, 79, 81, 83, 85, 86, 87, 88, 88, 87, 86, 86, 84, 82, 81, 80, 78, 76,
75, 74, 73, 71, 70, 69, 70, 69, 69, 70, 70, 71, 71, 72, 72, 71, 73, 73, 73, 73,
73, 73, 74, 73, 73, 72, 70, 70, 68, 67, 66, 64, 63, 61, 59, 58, 57, 55, 52, 52,
49, 48, 45, 44, 43, 41, 39, 37, 35, 33, 32, 30, 29, 27, 25, 23, 22, 21, 19, 16,
15, 13, 10, 8, 6, 5, 2, -1, -3, -7, -9, -12, -15, -17, -20, -23, -24, -27, -29,
-32, -35, -36, -38, -39, -42, -43, -44, -45, -45, -46, -46, -46, -45, -44, -41,
-40, -37, -34, -31, -28, -25, -20, -16, -12, -8, -4, -1, 3, 5, 8, 9, 10, 11, 11,
11, 9, 8, 5, 3, 1, -2, -6, -11, -13, -18, -21, -25, -28, -32, -35, -38, -40,
-43, -45, -46, -49, -50, -51, -52, -53, -52, -52, -51, -51, -49, -48, -47, -45,
-43, -42, -39, -39, -38, -36, -36, -35, -34, -34, -34, -34, -36, -36, -37, -39,
-40, -41, -42, -43, -45, -46, -47, -47, -47, -48, -48, -49, -48, -48, -49, -48,
-47, -47, -46, -46, -46, -46, -46, -46, -46, -47, -48, -49, -49, -51, -53, -54,
-55, -58, -59, -59, -60, -60, -61, -60, -61, -58, -58, -56, -54, -52, -49, -47,
-44, -41, -40, -37, -34, -32, -29, -27, -26, -23, -21, -19, -18, -17, -14, -13,
-12, -11, -11, -11, -10, -10, -9, -10, -8, -8, -8, -8, -7, -6, -5, -5, -3, -1,
1, 2, 5, 6, 9, 11, 13, 14, 17, 19, 19, 20, 20, 19, 20, 18, 15, 14, 11, 7, 5, 1,
-4, -8, -13, -17, -23, -27, -33, -38, -42, -47, -50, -56, -60, -63, -67, -70,
-74, -76, -78, -81, -82, -84, -85, -85, -86, -85, -84, -83, -82, -80, -76, -74,
-71, -67, -63, -58, -53, -49, -44, -39, -35, -29, -25, -20, -15, -11, -6, -2, };