#define DATA_LENGTH 512
#define DATA AKWF_pluckalgo_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 5, 7, 9, 11, 14, 16, 18, 21,
22, 25, 26, 29, 30, 33, 35, 37, 40, 41, 42, 45, 47, 49, 51, 52, 55, 57, 58, 60,
62, 63, 65, 67, 69, 71, 72, 73, 74, 76, 77, 79, 80, 82, 82, 84, 86, 88, 88, 89,
90, 92, 92, 93, 94, 96, 96, 97, 98, 100, 100, 100, 102, 103, 104, 104, 106, 106,
106, 107, 107, 108, 108, 109, 109, 110, 111, 110, 112, 112, 112, 113, 112, 113,
113, 114, 114, 114, 115, 115, 116, 116, 117, 116, 116, 117, 116, 118, 117, 118,
117, 117, 117, 117, 117, 118, 118, 118, 117, 119, 118, 118, 119, 119, 118, 119,
118, 118, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 120, 119, 118,
119, 119, 119, 119, 118, 119, 118, 118, 118, 119, 119, 119, 118, 118, 118, 117,
117, 118, 117, 117, 117, 117, 117, 116, 117, 116, 116, 116, 116, 115, 115, 115,
115, 115, 113, 113, 113, 113, 112, 112, 112, 111, 110, 111, 109, 109, 109, 108,
108, 107, 106, 107, 105, 105, 103, 103, 102, 101, 102, 99, 99, 98, 98, 96, 96,
94, 94, 92, 91, 91, 89, 87, 86, 85, 84, 83, 81, 81, 78, 77, 76, 75, 73, 70, 70,
68, 67, 65, 63, 60, 59, 58, 56, 54, 53, 50, 48, 46, 44, 43, 41, 38, 36, 34, 32,
31, 28, 26, 23, 21, 20, 18, 15, 12, 11, 8, 6, 4, 2, -1, -2, -5, -7, -10, -12,
-14, -16, -17, -20, -23, -24, -27, -29, -31, -33, -36, -37, -39, -41, -44, -45,
-47, -49, -50, -52, -55, -56, -59, -60, -62, -64, -65, -67, -68, -70, -71, -73,
-75, -76, -78, -79, -80, -82, -84, -85, -86, -87, -88, -90, -90, -92, -92, -94,
-95, -95, -96, -97, -98, -100, -101, -101, -102, -103, -103, -104, -104, -106,
-107, -106, -107, -108, -109, -109, -109, -110, -111, -112, -111, -112, -111,
-113, -113, -113, -114, -114, -114, -115, -115, -116, -116, -116, -116, -116,
-116, -117, -116, -116, -117, -118, -117, -117, -118, -117, -118, -118, -118,
-118, -118, -118, -118, -118, -119, -118, -119, -119, -119, -118, -119, -119,
-119, -118, -119, -119, -118, -120, -119, -118, -119, -119, -120, -119, -118,
-118, -120, -118, -119, -118, -119, -119, -119, -118, -119, -119, -118, -118,
-119, -118, -118, -118, -118, -118, -118, -118, -118, -117, -118, -117, -117,
-117, -117, -117, -117, -117, -116, -115, -115, -116, -115, -115, -114, -114,
-114, -114, -113, -114, -112, -112, -112, -110, -112, -110, -110, -110, -108,
-109, -107, -108, -106, -106, -105, -105, -105, -103, -103, -103, -101, -101,
-100, -98, -98, -97, -96, -95, -94, -93, -92, -91, -90, -88, -88, -86, -84, -83,
-82, -81, -79, -78, -77, -75, -73, -72, -69, -69, -67, -65, -63, -62, -60, -59,
-56, -55, -53, -51, -48, -47, -45, -43, -42, -39, -37, -36, -33, -31, -29, -27,
-25, -22, -20, -18, -16, -14, -12, -9, -7, -5, -3, -2, -1, -1, };