#define DATA_LENGTH 512
#define DATA AKWF_pluckalgo_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 12, 16, 19, 23, 26, 30, 32,
35, 38, 41, 44, 46, 49, 51, 53, 56, 57, 59, 61, 62, 64, 65, 66, 66, 67, 68, 68,
68, 68, 68, 67, 66, 65, 65, 63, 62, 61, 59, 58, 56, 55, 54, 52, 50, 49, 48, 46,
46, 44, 43, 43, 43, 41, 42, 41, 42, 42, 41, 42, 42, 43, 43, 44, 45, 45, 46, 47,
48, 49, 50, 50, 50, 52, 53, 53, 53, 54, 54, 55, 55, 55, 55, 55, 56, 55, 55, 54,
55, 55, 55, 55, 54, 55, 54, 54, 53, 54, 53, 54, 53, 54, 53, 54, 54, 54, 54, 54,
54, 54, 54, 54, 53, 54, 54, 54, 54, 54, 54, 53, 53, 53, 53, 53, 53, 52, 52, 53,
53, 53, 53, 53, 54, 54, 54, 55, 55, 56, 57, 57, 58, 59, 59, 60, 60, 61, 61, 63,
64, 64, 65, 66, 67, 69, 68, 69, 70, 72, 73, 73, 74, 76, 77, 77, 78, 79, 80, 80,
80, 82, 82, 82, 83, 83, 84, 83, 82, 83, 82, 81, 81, 80, 79, 77, 76, 75, 74, 73,
70, 69, 68, 67, 65, 63, 63, 61, 60, 59, 59, 58, 57, 56, 56, 56, 56, 56, 56, 56,
56, 57, 58, 58, 59, 61, 61, 62, 63, 64, 66, 66, 68, 69, 70, 72, 72, 74, 75, 75,
78, 79, 80, 81, 82, 82, 83, 84, 83, 84, 85, 85, 84, 84, 83, 82, 81, 80, 77, 75,
73, 70, 67, 64, 60, 56, 53, 48, 43, 38, 33, 28, 24, 18, 13, 7, 2, -4, -8, -14,
-19, -24, -27, -31, -34, -38, -41, -43, -45, -47, -49, -50, -51, -50, -50, -50,
-49, -49, -46, -45, -44, -42, -40, -38, -36, -34, -32, -30, -28, -26, -24, -23,
-21, -19, -19, -17, -18, -17, -17, -17, -17, -17, -19, -20, -22, -22, -25, -26,
-28, -30, -32, -34, -37, -39, -42, -45, -47, -49, -52, -54, -57, -59, -61, -63,
-65, -67, -69, -69, -71, -72, -73, -74, -76, -76, -77, -77, -78, -78, -79, -79,
-80, -81, -81, -81, -81, -82, -82, -83, -83, -84, -84, -85, -86, -86, -88, -88,
-89, -90, -91, -91, -92, -93, -94, -94, -95, -96, -96, -98, -97, -97, -98, -98,
-98, -97, -97, -97, -98, -97, -97, -98, -97, -98, -97, -97, -97, -98, -97, -99,
-99, -100, -100, -101, -101, -103, -104, -106, -106, -108, -109, -110, -111,
-113, -114, -115, -117, -117, -118, -118, -118, -119, -119, -119, -118, -117,
-116, -115, -114, -113, -111, -108, -106, -103, -100, -97, -95, -90, -88, -84,
-79, -77, -72, -68, -64, -61, -58, -54, -50, -47, -44, -40, -39, -36, -34, -32,
-30, -29, -29, -28, -27, -28, -27, -28, -28, -29, -30, -32, -34, -35, -39, -41,
-42, -45, -47, -49, -51, -54, -56, -57, -60, -61, -63, -64, -65, -65, -65, -67,
-65, -66, -64, -64, -63, -61, -59, -57, -55, -52, -50, -47, -44, -41, -38, -35,
-31, -27, -24, -20, -17, -13, -9, -5, -2, 0, };