#define DATA_LENGTH 512
#define DATA AKWF_pluckalgo_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 6, 8, 10, 12, 14, 16, 17, 19,
20, 22, 24, 25, 26, 27, 29, 30, 31, 33, 34, 35, 35, 36, 37, 38, 38, 39, 40, 40,
41, 42, 42, 42, 43, 42, 43, 44, 44, 43, 43, 44, 43, 44, 45, 44, 45, 44, 44, 43,
44, 43, 44, 43, 43, 43, 43, 43, 42, 42, 41, 41, 42, 41, 40, 41, 41, 40, 41, 40,
41, 41, 40, 40, 40, 40, 40, 40, 40, 40, 40, 41, 40, 41, 40, 40, 42, 41, 41, 42,
42, 41, 42, 43, 42, 43, 42, 44, 43, 43, 44, 45, 45, 45, 45, 47, 47, 46, 47, 47,
47, 48, 48, 49, 48, 50, 50, 51, 51, 51, 52, 52, 52, 53, 54, 54, 55, 56, 56, 56,
57, 56, 57, 58, 58, 59, 60, 60, 61, 61, 61, 63, 63, 63, 63, 63, 66, 65, 66, 67,
67, 67, 68, 68, 70, 70, 70, 71, 71, 71, 72, 73, 73, 74, 74, 75, 76, 76, 76, 76,
77, 77, 77, 78, 78, 78, 78, 78, 79, 78, 80, 78, 79, 79, 79, 79, 78, 79, 78, 78,
78, 78, 77, 77, 77, 76, 76, 75, 74, 74, 74, 73, 72, 72, 70, 70, 69, 68, 67, 66,
64, 64, 63, 62, 60, 59, 58, 56, 55, 54, 52, 51, 50, 47, 47, 45, 43, 41, 40, 38,
38, 35, 33, 32, 30, 29, 27, 24, 23, 21, 18, 18, 15, 14, 12, 9, 7, 5, 4, 2, 0,
-2, -4, -6, -8, -10, -12, -13, -16, -17, -19, -21, -22, -25, -26, -28, -30, -31,
-33, -36, -38, -40, -41, -43, -44, -46, -48, -50, -52, -53, -55, -57, -58, -60,
-60, -63, -64, -67, -67, -69, -72, -72, -74, -75, -77, -78, -80, -80, -82, -83,
-85, -87, -87, -89, -89, -92, -93, -94, -95, -96, -97, -98, -100, -100, -102,
-102, -103, -104, -105, -105, -107, -107, -108, -109, -110, -111, -111, -112,
-113, -113, -113, -114, -114, -115, -115, -116, -116, -117, -117, -117, -117,
-117, -118, -117, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -118, -118, -119, -119, -118, -118, -118, -118, -119, -118, -118,
-117, -117, -116, -117, -116, -116, -116, -117, -116, -116, -115, -115, -115,
-115, -113, -114, -113, -114, -113, -112, -113, -113, -111, -111, -112, -112,
-111, -111, -110, -111, -110, -110, -110, -110, -110, -110, -109, -109, -109,
-109, -109, -108, -108, -108, -108, -108, -108, -107, -108, -108, -108, -107,
-106, -106, -106, -107, -106, -106, -106, -106, -106, -105, -106, -105, -104,
-105, -104, -104, -104, -104, -103, -102, -102, -101, -102, -101, -101, -100,
-99, -99, -98, -98, -97, -97, -96, -95, -95, -94, -93, -91, -90, -89, -89, -89,
-86, -86, -84, -83, -82, -80, -79, -77, -76, -75, -74, -72, -70, -68, -67, -64,
-63, -61, -60, -57, -56, -54, -51, -49, -47, -46, -43, -41, -39, -37, -35, -33,
-31, -29, -27, -24, -23, -20, -17, -14, -13, -10, -8, -6, -5, -4, -4, -2, -2,
-1, };