#define DATA_LENGTH 512
#define DATA AKWF_pluckalgo_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 15, 24, 30, 36, 40, 42, 43, 43, 44,
44, 44, 45, 46, 47, 49, 50, 51, 53, 54, 54, 55, 55, 57, 58, 59, 61, 65, 66, 68,
69, 69, 68, 65, 63, 63, 60, 58, 57, 56, 56, 55, 53, 52, 50, 49, 47, 44, 43, 43,
44, 45, 50, 55, 62, 70, 80, 89, 98, 105, 111, 115, 117, 116, 116, 113, 110, 108,
106, 105, 103, 102, 101, 100, 98, 96, 95, 92, 91, 89, 89, 89, 91, 93, 95, 98,
100, 103, 103, 103, 101, 99, 96, 95, 92, 91, 90, 89, 89, 90, 88, 89, 86, 84, 80,
75, 69, 64, 59, 53, 50, 47, 46, 46, 49, 51, 55, 60, 65, 68, 72, 76, 80, 82, 84,
86, 88, 89, 90, 89, 88, 86, 84, 81, 78, 74, 70, 64, 60, 56, 52, 49, 48, 48, 50,
53, 57, 59, 64, 66, 69, 72, 74, 75, 77, 79, 80, 81, 82, 81, 80, 79, 76, 74, 73,
72, 71, 72, 72, 72, 71, 72, 71, 72, 71, 72, 74, 74, 77, 78, 80, 82, 84, 84, 85,
85, 83, 81, 78, 77, 74, 72, 72, 70, 70, 70, 69, 70, 69, 68, 67, 67, 66, 65, 65,
66, 67, 69, 70, 72, 74, 77, 79, 81, 84, 87, 89, 93, 94, 95, 97, 97, 98, 99, 98,
98, 97, 97, 97, 98, 98, 99, 98, 97, 96, 92, 89, 85, 80, 76, 73, 70, 67, 63, 59,
53, 45, 36, 25, 11, -3, -17, -31, -45, -56, -65, -74, -78, -82, -83, -84, -84,
-84, -83, -81, -79, -78, -75, -73, -71, -69, -67, -66, -65, -64, -65, -66, -67,
-68, -69, -69, -71, -69, -69, -67, -64, -61, -59, -55, -54, -53, -54, -55, -59,
-62, -64, -67, -70, -72, -74, -75, -75, -75, -74, -72, -72, -73, -72, -73, -73,
-73, -73, -74, -72, -72, -71, -69, -68, -67, -66, -66, -68, -68, -71, -74, -77,
-79, -80, -82, -83, -83, -83, -83, -82, -82, -82, -83, -86, -87, -90, -91, -93,
-95, -95, -94, -94, -92, -92, -89, -88, -87, -84, -82, -78, -75, -71, -67, -62,
-57, -52, -49, -45, -43, -43, -43, -44, -45, -48, -50, -53, -55, -58, -60, -61,
-62, -64, -66, -68, -71, -75, -78, -82, -86, -90, -95, -100, -104, -107, -111,
-114, -117, -119, -119, -119, -117, -116, -114, -111, -107, -102, -97, -92, -87,
-82, -77, -74, -71, -70, -70, -71, -73, -76, -78, -81, -85, -87, -89, -91, -91,
-92, -91, -89, -87, -83, -79, -74, -70, -67, -65, -64, -65, -67, -70, -74, -77,
-80, -82, -83, -84, -84, -83, -81, -82, -81, -80, -81, -83, -84, -86, -89, -93,
-96, -100, -103, -108, -110, -111, -113, -112, -112, -109, -107, -103, -100,
-98, -96, -95, -93, -93, -93, -92, -91, -89, -86, -84, -81, -78, -75, -71, -67,
-64, -61, -59, -59, -58, -59, -61, -63, -64, -68, -71, -73, -75, -79, -82, -85,
-89, -92, -93, -94, -95, -93, -91, -87, -80, -72, -61, -49, -36, -23, -10, -1,
};