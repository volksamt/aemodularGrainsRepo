#define DATA_LENGTH 512
#define DATA AKWF_pluckalgo_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 24, 43, 58, 71, 82, 93, 100, 106,
111, 113, 115, 117, 118, 118, 119, 119, 119, 120, 119, 119, 120, 119, 119, 120,
118, 120, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119,
119, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 120, 118, 120, 119, 120, 119, 119, 119, 119, 120, 119, 119, 118, 119, 119,
119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 120, 120,
119, 119, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 120, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 118, 119, 119,
119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 120, 119, 119, 119, 119,
120, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 119, 119, 119, 119, 118, 119, 118, 120, 120, 120, 119, 119, 120, 119,
119, 120, 120, 118, 118, 119, 119, 119, 120, 119, 119, 119, 119, 120, 119, 118,
119, 120, 119, 119, 118, 119, 120, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 118,
119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 117, 117, 115, 112, 108, 102,
97, 87, 77, 64, 49, 33, 16, -2, -20, -37, -52, -67, -80, -90, -99, -104, -109,
-112, -115, -117, -117, -118, -119, -119, -118, -119, -118, -120, -119, -119,
-119, -120, -119, -119, -120, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -120, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -120, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -120, -119, -118, -120,
-119, -118, -119, -119, -120, -118, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -118, -118, -118, -119, -119, -118, -119, -118, -119, -119,
-119, -119, -120, -120, -119, -119, -119, -119, -118, -119, -119, -120, -119,
-118, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -118, -120,
-119, -118, -119, -119, -120, -118, -119, -120, -118, -119, -119, -118, -119,
-119, -119, -120, -119, -120, -119, -120, -120, -119, -119, -119, -119, -120,
-119, -118, -118, -119, -119, -119, -119, -118, -119, -120, -119, -119, -119,
-119, -119, -119, -118, -120, -119, -119, -119, -120, -118, -118, -119, -119,
-119, -119, -119, -119, -118, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-120, -120, -119, -120, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -118, -119, -120, -119, -119, -119, -119, -118, -117,
-117, -115, -112, -109, -105, -97, -90, -80, -69, -52, -39, -19, };