#define DATA_LENGTH 512
#define DATA AKWF_pluckalgo_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 3, 5, 8, 8, 10, 11, 13, 14,
15, 17, 17, 19, 20, 22, 23, 25, 26, 27, 29, 31, 32, 33, 34, 35, 36, 37, 38, 40,
42, 43, 44, 45, 47, 47, 48, 51, 51, 52, 53, 55, 55, 58, 58, 59, 60, 61, 62, 63,
65, 66, 66, 67, 69, 70, 70, 72, 72, 74, 74, 75, 76, 77, 79, 79, 80, 81, 81, 83,
83, 83, 85, 86, 86, 87, 88, 88, 89, 90, 90, 92, 92, 93, 92, 93, 94, 95, 96, 96,
96, 97, 96, 97, 98, 99, 99, 98, 99, 100, 100, 100, 100, 101, 100, 101, 101, 101,
102, 103, 102, 102, 103, 103, 103, 103, 103, 104, 104, 103, 103, 103, 103, 103,
103, 103, 103, 102, 102, 102, 102, 102, 102, 101, 101, 100, 100, 101, 100, 100,
99, 99, 98, 98, 98, 97, 97, 97, 96, 94, 95, 94, 94, 93, 93, 92, 91, 91, 90, 89,
88, 87, 88, 86, 85, 85, 84, 83, 82, 81, 81, 80, 78, 78, 77, 76, 76, 74, 73, 71,
70, 69, 68, 67, 66, 65, 65, 63, 62, 60, 59, 58, 58, 56, 54, 54, 52, 51, 50, 49,
48, 45, 44, 43, 42, 40, 40, 37, 36, 35, 34, 32, 30, 29, 28, 27, 25, 23, 21, 21,
19, 17, 16, 14, 13, 12, 10, 8, 7, 5, 3, 2, 0, -1, -2, -4, -5, -7, -9, -10, -12,
-13, -14, -16, -18, -20, -22, -22, -24, -26, -27, -28, -30, -31, -34, -35, -36,
-37, -39, -41, -42, -44, -45, -47, -48, -49, -51, -52, -54, -54, -56, -57, -59,
-60, -62, -62, -64, -65, -67, -68, -69, -70, -71, -73, -73, -75, -77, -77, -78,
-79, -81, -82, -83, -84, -85, -85, -86, -88, -89, -90, -91, -93, -93, -94, -94,
-96, -96, -97, -98, -98, -100, -101, -101, -102, -103, -104, -104, -105, -106,
-106, -106, -107, -107, -108, -108, -110, -110, -110, -112, -112, -113, -112,
-113, -113, -114, -114, -114, -115, -114, -115, -116, -117, -116, -117, -117,
-117, -118, -118, -118, -118, -118, -118, -118, -118, -118, -119, -119, -119,
-119, -120, -119, -118, -119, -120, -119, -119, -118, -118, -118, -118, -118,
-119, -117, -119, -118, -118, -118, -117, -117, -117, -117, -116, -117, -115,
-115, -115, -114, -114, -114, -115, -114, -113, -112, -113, -111, -113, -111,
-112, -110, -110, -109, -110, -109, -108, -107, -107, -107, -106, -105, -105,
-104, -104, -103, -103, -102, -101, -101, -100, -100, -99, -98, -97, -96, -95,
-95, -94, -93, -92, -92, -91, -91, -89, -89, -88, -87, -85, -85, -84, -83, -83,
-81, -81, -80, -78, -77, -77, -75, -75, -74, -73, -71, -70, -70, -69, -68, -66,
-65, -65, -64, -62, -61, -60, -59, -57, -57, -55, -54, -53, -51, -51, -49, -49,
-47, -46, -44, -43, -42, -41, -39, -38, -37, -36, -35, -34, -32, -31, -30, -28,
-26, -25, -24, -23, -21, -19, -19, -17, -16, -15, -13, -11, -9, -9, -7, -5, -5,
-3, -3, -2, -2, -1, 0, };