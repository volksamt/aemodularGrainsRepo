#define DATA_LENGTH 512
#define DATA AKWF_pluckalgo_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 5, 6, 8, 11, 13, 14, 17, 18, 21,
22, 24, 27, 30, 31, 33, 35, 37, 39, 42, 43, 45, 47, 49, 51, 52, 55, 57, 58, 59,
61, 63, 64, 66, 68, 69, 71, 73, 74, 75, 77, 79, 79, 81, 83, 83, 85, 86, 87, 88,
89, 91, 92, 92, 93, 95, 96, 97, 97, 99, 99, 101, 101, 102, 102, 104, 104, 105,
106, 105, 106, 107, 108, 108, 109, 110, 109, 110, 111, 111, 111, 113, 112, 113,
113, 114, 114, 115, 114, 114, 115, 115, 116, 115, 116, 116, 117, 117, 117, 117,
117, 118, 117, 118, 117, 118, 118, 118, 118, 118, 118, 119, 118, 118, 118, 118,
119, 119, 119, 119, 118, 118, 119, 119, 119, 119, 119, 120, 119, 119, 120, 119,
119, 120, 119, 119, 119, 119, 118, 119, 118, 118, 119, 118, 119, 119, 117, 118,
118, 117, 117, 117, 118, 117, 116, 117, 117, 117, 116, 116, 116, 115, 115, 115,
115, 115, 114, 114, 114, 113, 113, 113, 112, 112, 112, 111, 110, 110, 110, 109,
109, 108, 107, 107, 106, 105, 104, 104, 103, 103, 102, 101, 100, 99, 99, 97, 97,
95, 95, 94, 93, 93, 91, 90, 89, 88, 87, 85, 83, 83, 81, 80, 79, 77, 76, 74, 73,
71, 70, 69, 67, 65, 63, 62, 60, 58, 57, 55, 53, 51, 49, 47, 45, 44, 42, 40, 37,
36, 34, 32, 30, 28, 25, 23, 21, 19, 17, 16, 13, 11, 8, 6, 4, 2, 1, -2, -4, -6,
-8, -11, -12, -15, -17, -19, -21, -23, -25, -27, -29, -31, -33, -35, -38, -39,
-41, -44, -45, -47, -49, -51, -52, -54, -56, -57, -60, -62, -63, -64, -67, -68,
-70, -71, -73, -75, -76, -77, -79, -79, -82, -82, -84, -85, -86, -87, -88, -90,
-91, -92, -93, -94, -95, -96, -97, -98, -99, -100, -100, -101, -101, -102, -103,
-105, -105, -105, -106, -106, -107, -107, -109, -109, -109, -110, -110, -110,
-111, -111, -113, -112, -114, -113, -114, -114, -114, -114, -115, -115, -115,
-116, -116, -116, -117, -116, -117, -117, -117, -117, -117, -118, -117, -118,
-118, -118, -118, -118, -118, -118, -119, -119, -119, -119, -118, -118, -119,
-119, -119, -120, -119, -120, -119, -119, -119, -119, -120, -119, -119, -118,
-118, -119, -119, -120, -119, -118, -118, -119, -119, -119, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -118, -118, -117, -117, -117, -117, -117,
-117, -116, -116, -116, -116, -115, -116, -115, -115, -114, -115, -114, -113,
-113, -113, -112, -112, -111, -111, -110, -110, -110, -109, -109, -107, -108,
-107, -105, -106, -105, -104, -104, -103, -102, -102, -100, -99, -98, -98, -96,
-97, -96, -94, -93, -91, -90, -90, -89, -87, -87, -86, -84, -82, -82, -80, -79,
-78, -75, -74, -72, -71, -70, -69, -66, -65, -64, -62, -60, -58, -57, -56, -54,
-51, -49, -47, -45, -44, -41, -40, -38, -36, -34, -32, -30, -27, -26, -23, -22,
-19, -17, -15, -12, -10, -9, -6, -5, -3, -1, 0, };