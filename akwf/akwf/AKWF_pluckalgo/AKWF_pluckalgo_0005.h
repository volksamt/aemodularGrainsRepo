#define DATA_LENGTH 512
#define DATA AKWF_pluckalgo_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 5, 7, 11, 14, 17, 19, 23, 25, 28,
30, 33, 35, 38, 41, 43, 45, 48, 51, 53, 54, 57, 59, 61, 63, 64, 66, 68, 69, 71,
72, 74, 75, 76, 77, 78, 78, 80, 80, 81, 82, 82, 83, 83, 84, 84, 84, 84, 84, 86,
85, 85, 85, 86, 86, 85, 85, 85, 85, 85, 85, 86, 85, 85, 85, 84, 85, 85, 84, 85,
84, 85, 85, 85, 85, 84, 85, 85, 86, 86, 85, 86, 87, 86, 87, 87, 87, 87, 89, 88,
89, 89, 90, 90, 91, 91, 91, 92, 92, 92, 93, 94, 94, 94, 95, 96, 95, 95, 96, 96,
97, 98, 98, 98, 99, 98, 99, 100, 99, 99, 99, 99, 100, 99, 100, 100, 99, 99, 100,
99, 100, 99, 99, 98, 98, 98, 99, 98, 98, 98, 97, 97, 96, 96, 96, 96, 95, 94, 94,
94, 93, 93, 92, 92, 92, 92, 91, 90, 89, 89, 88, 89, 88, 88, 87, 86, 86, 87, 86,
85, 85, 85, 84, 85, 84, 84, 83, 84, 84, 83, 84, 83, 84, 83, 83, 83, 83, 84, 84,
84, 83, 83, 84, 84, 85, 84, 85, 84, 85, 85, 85, 85, 84, 85, 85, 85, 85, 85, 85,
85, 85, 85, 84, 84, 84, 83, 83, 81, 81, 80, 79, 78, 78, 77, 76, 75, 74, 72, 71,
69, 68, 66, 64, 63, 61, 58, 56, 55, 52, 50, 47, 45, 42, 39, 36, 34, 30, 27, 24,
21, 18, 15, 12, 9, 6, 2, -1, -5, -7, -11, -15, -18, -21, -25, -28, -31, -34,
-37, -41, -44, -47, -50, -53, -56, -59, -61, -64, -66, -69, -72, -74, -76, -78,
-81, -82, -85, -87, -88, -90, -92, -93, -95, -96, -97, -99, -101, -101, -103,
-103, -104, -105, -106, -107, -108, -108, -109, -110, -110, -111, -112, -112,
-112, -113, -113, -114, -114, -114, -114, -115, -115, -116, -116, -115, -116,
-116, -116, -117, -117, -117, -117, -117, -118, -118, -118, -118, -119, -118,
-118, -119, -118, -118, -118, -119, -118, -119, -119, -119, -119, -118, -119,
-120, -119, -119, -120, -119, -118, -118, -119, -119, -118, -118, -118, -118,
-119, -117, -118, -117, -118, -116, -118, -117, -116, -116, -116, -116, -115,
-114, -115, -114, -115, -113, -113, -112, -112, -112, -111, -110, -111, -111,
-110, -108, -109, -108, -108, -108, -107, -106, -106, -105, -106, -105, -105,
-103, -103, -103, -102, -102, -102, -102, -100, -100, -100, -99, -99, -98, -98,
-98, -98, -97, -96, -97, -96, -96, -95, -96, -95, -94, -94, -94, -93, -93, -93,
-93, -93, -92, -93, -92, -92, -91, -92, -91, -90, -90, -90, -89, -89, -90, -89,
-89, -88, -88, -88, -88, -87, -87, -87, -86, -86, -86, -85, -84, -84, -83, -83,
-83, -82, -81, -81, -80, -79, -79, -78, -77, -76, -75, -75, -73, -72, -70, -70,
-68, -66, -66, -64, -64, -62, -60, -58, -57, -56, -54, -52, -49, -47, -46, -43,
-40, -39, -36, -34, -31, -30, -26, -24, -21, -19, -17, -13, -11, -8, -5, -1, };