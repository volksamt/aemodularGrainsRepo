#define DATA_LENGTH 512
#define DATA AKWF_1607

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 10, 14, 17, 21, 24, 28, 31, 33,
35, 37, 39, 39, 40, 40, 39, 39, 37, 36, 34, 32, 31, 28, 27, 25, 23, 22, 21, 20,
19, 19, 18, 19, 20, 21, 23, 25, 27, 31, 34, 38, 42, 47, 51, 57, 62, 68, 73, 79,
84, 88, 93, 97, 101, 103, 106, 107, 108, 108, 108, 109, 108, 108, 106, 105, 104,
102, 101, 99, 98, 95, 94, 92, 91, 89, 87, 88, 87, 87, 89, 90, 91, 94, 97, 100,
103, 107, 111, 114, 116, 119, 119, 119, 117, 114, 109, 102, 95, 85, 76, 65, 54,
44, 36, 29, 24, 21, 21, 21, 25, 28, 33, 39, 44, 52, 58, 65, 72, 78, 82, 87, 89,
91, 94, 95, 95, 94, 91, 88, 83, 75, 66, 53, 38, 16, -7, -31, -52, -69, -84, -96,
-104, -110, -114, -117, -119, -118, -119, -118, -117, -117, -116, -115, -115,
-115, -114, -115, -114, -114, -113, -113, -113, -113, -113, -110, -110, -110,
-109, -108, -108, -110, -111, -112, -113, -114, -116, -117, -118, -119, -118,
-118, -115, -112, -107, -104, -99, -93, -88, -83, -78, -73, -69, -64, -61, -57,
-55, -54, -52, -51, -50, -50, -50, -52, -53, -54, -57, -59, -61, -63, -65, -67,
-70, -71, -73, -74, -75, -75, -75, -75, -75, -72, -70, -68, -65, -61, -58, -53,
-48, -44, -38, -34, -30, -26, -21, -17, -13, -10, -6, -2, -1, 2, 5, 6, 7, 8, 10,
9, 10, 9, 7, 6, 6, 4, 3, 0, 0, -2, -4, -5, -8, -9, -8, -9, -10, -9, -9, -8, -6,
-4, -2, 0, 2, 6, 10, 12, 17, 21, 25, 30, 34, 39, 44, 49, 53, 58, 61, 65, 68, 70,
73, 74, 75, 75, 75, 75, 74, 73, 72, 70, 67, 64, 63, 61, 59, 57, 55, 54, 53, 51,
50, 51, 51, 52, 54, 55, 57, 61, 65, 69, 73, 78, 83, 89, 94, 99, 103, 108, 113,
115, 117, 119, 118, 118, 118, 117, 115, 113, 112, 110, 109, 109, 109, 109, 110,
111, 111, 112, 112, 113, 113, 113, 114, 115, 114, 114, 115, 115, 115, 116, 117,
117, 118, 118, 118, 118, 116, 114, 109, 103, 95, 82, 69, 50, 29, 5, -18, -39,
-54, -66, -76, -83, -88, -92, -93, -95, -95, -93, -92, -89, -86, -82, -77, -71,
-64, -59, -51, -44, -38, -32, -28, -24, -22, -21, -22, -24, -29, -36, -45, -55,
-65, -76, -87, -95, -103, -109, -114, -118, -118, -120, -118, -116, -114, -111,
-107, -103, -100, -97, -94, -92, -90, -88, -87, -88, -88, -89, -89, -91, -92,
-94, -95, -97, -99, -101, -103, -104, -105, -106, -107, -108, -109, -109, -108,
-108, -107, -105, -103, -99, -96, -93, -88, -83, -79, -73, -68, -62, -56, -52,
-46, -42, -38, -33, -31, -27, -25, -23, -21, -20, -19, -19, -19, -19, -19, -20,
-22, -23, -25, -27, -30, -31, -32, -35, -36, -38, -39, -39, -40, -40, -39, -39,
-37, -35, -33, -31, -27, -24, -20, -17, -13, -9, -5, -1, };