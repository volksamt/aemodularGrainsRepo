#define DATA_LENGTH 512
#define DATA AKWF_1619

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 14, 23, 24, 31, 35, 39, 48, 49, 51,
64, 76, 84, 102, 116, 118, 113, 96, 69, 54, 50, 53, 57, 64, 67, 64, 63, 57, 47,
45, 45, 44, 45, 42, 39, 31, 25, 19, 9, 4, 3, 6, 13, 23, 27, 36, 40, 45, 44, 44,
45, 44, 52, 62, 64, 65, 67, 60, 55, 51, 50, 59, 83, 106, 117, 119, 110, 93, 79,
71, 56, 49, 49, 44, 36, 34, 27, 23, 19, 8, -1, -1, -6, -21, -37, -47, -55, -53,
-45, -33, -14, -2, -2, -4, -1, 0, -3, -4, -3, 2, 9, 12, 13, 17, 18, 15, 15, 19,
15, 5, -10, -27, -41, -49, -56, -57, -55, -53, -53, -51, -52, -57, -60, -64,
-65, -62, -56, -54, -48, -45, -41, -32, -18, -7, 1, 7, 7, 3, -2, -8, -14, -17,
-19, -19, -16, -13, -15, -18, -24, -29, -33, -36, -38, -42, -47, -51, -51, -49,
-42, -34, -24, -16, -9, -3, 0, 1, 0, 2, 2, 7, 13, 18, 21, 23, 21, 21, 21, 19,
16, 10, 2, -6, -14, -20, -26, -29, -29, -26, -23, -20, -19, -18, -18, -16, -11,
-5, -1, 1, 2, 5, 10, 16, 19, 21, 23, 24, 25, 26, 23, 18, 12, 8, 8, 9, 11, 9, 6,
4, 3, 2, 5, 4, 2, 1, 1, 0, 1, 2, 1, 2, 5, 7, 12, 14, 13, 12, 9, 7, 6, 2, 2, -2,
-7, -11, -11, -14, -13, -12, -15, -10, -10, -12, -15, -20, -26, -31, -34, -39,
-39, -38, -36, -30, -22, -20, -17, -14, -11, -8, -7, -7, -4, 0, 7, 8, 8, 10, 9,
7, 6, 2, 2, 3, 4, 5, 4, 2, 2, 1, -5, -7, -10, -18, -20, -17, -18, -10, -7, -17,
-18, -20, -20, -12, -8, -5, -1, 2, 2, 3, 5, 4, 3, 2, 2, 6, 7, 9, 11, 9, 9, 7, 2,
-2, -7, -8, -7, -11, -13, -16, -18, -22, -26, -33, -37, -38, -39, -37, -31, -28,
-23, -15, -14, -10, -9, -14, -13, -12, -14, -12, -9, -9, -3, 1, 3, 6, 7, 8, 11,
12, 14, 13, 8, 5, 2, 1, 1, 2, 1, 0, 1, 2, 3, 5, 2, 3, 4, 5, 8, 10, 10, 9, 8, 9,
17, 22, 26, 26, 25, 22, 22, 20, 18, 13, 7, 2, 0, 0, -2, -9, -15, -18, -19, -19,
-19, -21, -26, -28, -29, -27, -22, -16, -9, -1, 7, 14, 19, 21, 21, 21, 22, 21,
19, 15, 10, 4, 2, 1, 0, 1, -2, -7, -13, -22, -31, -39, -47, -52, -51, -48, -44,
-40, -36, -34, -30, -25, -20, -16, -13, -14, -18, -19, -17, -15, -10, -4, 1, 5,
7, 4, -4, -15, -28, -39, -43, -48, -51, -55, -60, -65, -65, -61, -57, -54, -51,
-53, -53, -53, -56, -56, -51, -43, -32, -15, 0, 12, 18, 17, 14, 17, 17, 13, 13,
11, 4, -1, -3, -3, -1, 1, -2, -3, -1, -9, -27, -41, -52, -57, -51, -41, -27,
-11, -2, -2, };