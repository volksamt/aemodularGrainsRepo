#define DATA_LENGTH 512
#define DATA AKWF_1657

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 13, 16, 20, 24, 28, 32, 37,
42, 48, 53, 57, 63, 69, 74, 78, 83, 87, 90, 94, 95, 96, 97, 97, 95, 95, 94, 91,
89, 85, 83, 78, 74, 69, 65, 60, 56, 50, 46, 43, 37, 34, 30, 26, 23, 20, 16, 11,
8, 4, -1, -6, -10, -15, -20, -24, -28, -32, -36, -39, -44, -48, -51, -55, -56,
-56, -57, -54, -50, -44, -36, -24, -12, 1, 14, 26, 36, 46, 52, 55, 54, 53, 49,
42, 35, 27, 19, 11, 5, 0, -4, -8, -10, -12, -13, -15, -18, -20, -24, -28, -34,
-40, -48, -56, -61, -66, -70, -71, -70, -65, -57, -47, -35, -19, -6, 10, 25, 37,
49, 59, 66, 72, 77, 79, 80, 80, 79, 76, 74, 71, 67, 62, 56, 50, 42, 34, 28, 21,
14, 8, 2, -4, -9, -13, -18, -22, -27, -32, -39, -45, -52, -59, -67, -75, -82,
-90, -96, -102, -107, -110, -113, -114, -115, -114, -112, -110, -108, -104,
-100, -96, -91, -87, -80, -75, -69, -63, -57, -50, -45, -39, -32, -28, -22, -18,
-12, -7, -2, 3, 8, 14, 20, 25, 31, 37, 43, 48, 53, 59, 64, 70, 75, 80, 85, 89,
92, 94, 96, 96, 95, 92, 87, 80, 73, 63, 54, 44, 33, 21, 10, -2, -13, -24, -36,
-48, -59, -69, -78, -85, -91, -95, -98, -98, -97, -94, -91, -86, -81, -76, -70,
-65, -60, -54, -49, -44, -39, -34, -29, -25, -20, -16, -12, -8, -4, -1, 2, 5, 8,
12, 16, 20, 24, 28, 31, 37, 41, 45, 49, 54, 58, 64, 67, 73, 77, 82, 87, 91, 95,
98, 99, 101, 99, 99, 97, 94, 91, 86, 82, 78, 73, 69, 65, 60, 57, 53, 49, 45, 41,
37, 32, 29, 25, 22, 18, 14, 10, 7, 3, -1, -5, -10, -14, -21, -27, -33, -40, -45,
-50, -54, -56, -58, -56, -54, -50, -45, -39, -32, -25, -17, -11, -3, 4, 10, 17,
24, 30, 34, 39, 42, 44, 45, 44, 41, 37, 33, 26, 19, 13, 5, -3, -9, -15, -21,
-28, -32, -36, -42, -45, -49, -51, -54, -54, -56, -56, -56, -55, -53, -49, -45,
-39, -31, -22, -11, 2, 15, 30, 45, 58, 69, 78, 87, 90, 92, 90, 88, 82, 76, 68,
60, 53, 45, 39, 32, 28, 22, 17, 12, 6, 2, -4, -9, -14, -21, -26, -32, -39, -44,
-50, -56, -63, -69, -75, -81, -88, -94, -101, -105, -111, -114, -118, -118,
-119, -118, -114, -110, -106, -100, -94, -88, -81, -75, -69, -63, -57, -51, -46,
-41, -35, -31, -26, -21, -15, -10, -5, 0, 5, 10, 14, 20, 25, 31, 37, 43, 50, 57,
64, 71, 76, 82, 86, 90, 92, 94, 95, 93, 92, 88, 85, 80, 73, 67, 59, 50, 39, 28,
15, 4, -7, -20, -32, -42, -51, -60, -69, -76, -82, -88, -92, -95, -97, -97, -97,
-95, -91, -85, -80, -73, -65, -58, -52, -45, -38, -33, -28, -23, -20, -15, -12,
-9, -6, -1, };