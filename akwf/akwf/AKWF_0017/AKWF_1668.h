#define DATA_LENGTH 512
#define DATA AKWF_1668

const PROGMEM int8_t DATA[DATA_LENGTH] = {57, 68, 62, 67, 66, 69, 66, 69, 68,
70, 69, 70, 69, 71, 70, 72, 72, 72, 73, 74, 74, 75, 75, 76, 76, 76, 77, 78, 78,
78, 78, 79, 80, 80, 81, 81, 81, 82, 82, 83, 84, 84, 85, 85, 86, 86, 87, 87, 87,
87, 88, 88, 89, 89, 90, 90, 91, 91, 92, 93, 94, 94, 95, 95, 96, 95, 96, 97, 97,
98, 98, 98, 99, 100, 101, 101, 101, 101, 102, 102, 103, 104, 103, 104, 105, 105,
106, 107, 106, 108, 108, 108, 108, 109, 109, 110, 110, 111, 111, 112, 112, 113,
113, 114, 114, 115, 115, 115, 116, 117, 118, 118, 118, 118, 119, 119, 118, 119,
118, 116, 116, 116, 116, 115, 114, 114, 114, 113, 112, 113, 113, 112, 111, 110,
111, 111, 110, 109, 109, 108, 108, 107, 107, 107, 107, 106, 105, 105, 105, 103,
103, 104, 102, 103, 102, 102, 101, 100, 100, 100, 99, 99, 99, 98, 98, 98, 97,
96, 95, 95, 95, 94, 95, 93, 93, 93, 93, 92, 92, 91, 90, 90, 90, 90, 88, 88, 89,
87, 88, 86, 87, 86, 85, 85, 84, 85, 83, 83, 82, 83, 81, 81, 81, 81, 80, 80, 79,
78, 79, 78, 78, 77, 78, 76, 76, 76, 75, 74, 74, 73, 74, 72, 73, 72, 72, 71, 71,
71, 70, 70, 68, 69, 67, 70, 65, 70, 62, 72, 58, 80, 16, -74, -54, -65, -58, -63,
-61, -63, -62, -63, -63, -63, -65, -64, -66, -65, -66, -66, -67, -66, -68, -66,
-69, -68, -69, -69, -70, -70, -70, -70, -71, -71, -72, -72, -73, -73, -73, -74,
-75, -74, -74, -76, -76, -77, -77, -77, -77, -78, -79, -79, -79, -80, -80, -80,
-81, -80, -81, -82, -82, -82, -82, -84, -84, -84, -84, -85, -85, -86, -86, -87,
-87, -87, -87, -88, -88, -88, -89, -90, -89, -91, -91, -91, -92, -91, -92, -93,
-93, -93, -94, -94, -95, -95, -95, -96, -96, -97, -98, -98, -98, -98, -99, -99,
-100, -99, -100, -100, -101, -101, -102, -102, -102, -103, -103, -104, -104,
-104, -105, -105, -106, -106, -106, -106, -107, -107, -107, -108, -109, -109,
-109, -110, -110, -110, -110, -110, -109, -108, -109, -108, -107, -107, -106,
-106, -105, -105, -105, -104, -104, -103, -103, -103, -103, -101, -102, -100,
-101, -100, -100, -100, -100, -99, -98, -98, -98, -97, -98, -96, -95, -95, -95,
-95, -94, -94, -94, -93, -93, -93, -92, -92, -91, -91, -90, -89, -90, -89, -89,
-88, -88, -88, -87, -87, -87, -86, -86, -85, -84, -84, -84, -84, -83, -83, -82,
-82, -81, -81, -80, -81, -80, -79, -79, -79, -79, -78, -78, -77, -77, -76, -76,
-75, -75, -75, -75, -75, -74, -74, -73, -72, -72, -72, -72, -72, -70, -70, -70,
-69, -68, -69, -68, -68, -67, -67, -66, -67, -66, -66, -65, -66, -64, -63, -63,
-64, -62, -62, -63, -60, -63, -57, -66, -21, 6, -4, 2, -2, 2, -1, 1, -1, 1, -1,
1, 0, 0, 1, };