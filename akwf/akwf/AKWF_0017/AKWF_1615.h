#define DATA_LENGTH 512
#define DATA AKWF_1615

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 13, 23, 33, 44, 53, 60, 67, 71, 73,
78, 82, 86, 90, 93, 97, 99, 100, 100, 102, 102, 103, 104, 104, 105, 106, 108,
108, 109, 109, 110, 110, 111, 112, 111, 111, 112, 112, 112, 113, 112, 113, 113,
113, 112, 113, 113, 113, 113, 112, 113, 112, 112, 113, 113, 113, 112, 112, 113,
113, 113, 112, 112, 113, 112, 111, 111, 111, 110, 110, 111, 110, 110, 110, 110,
109, 108, 108, 108, 108, 106, 105, 106, 103, 103, 101, 101, 100, 99, 97, 97, 96,
95, 93, 92, 91, 88, 87, 86, 86, 85, 83, 82, 82, 78, 77, 75, 75, 73, 72, 71, 68,
66, 63, 62, 61, 59, 58, 55, 51, 47, 41, 30, 18, 7, 0, 5, 17, 28, 39, 47, 50, 54,
57, 59, 60, 63, 63, 65, 70, 70, 72, 73, 74, 75, 77, 78, 81, 83, 83, 84, 85, 87,
88, 89, 90, 92, 93, 95, 96, 96, 97, 99, 100, 100, 101, 102, 104, 104, 105, 106,
107, 108, 107, 109, 109, 110, 109, 110, 110, 111, 111, 111, 110, 112, 111, 112,
113, 113, 113, 112, 112, 112, 112, 113, 113, 113, 112, 113, 113, 112, 112, 113,
113, 113, 112, 112, 112, 112, 112, 111, 112, 112, 111, 112, 112, 110, 112, 110,
111, 109, 109, 109, 109, 107, 107, 106, 105, 104, 104, 103, 102, 100, 100, 99,
96, 94, 90, 87, 82, 78, 74, 71, 67, 60, 55, 45, 34, 23, 14, 4, -6, -14, -27,
-34, -39, -44, -48, -53, -58, -64, -69, -72, -74, -77, -77, -78, -81, -83, -84,
-86, -88, -91, -93, -94, -96, -98, -99, -100, -102, -105, -108, -108, -111,
-112, -112, -113, -114, -115, -116, -115, -116, -117, -117, -118, -118, -119,
-119, -119, -119, -118, -119, -119, -118, -119, -119, -119, -120, -119, -119,
-119, -118, -118, -118, -118, -118, -118, -118, -117, -118, -118, -117, -117,
-117, -117, -117, -117, -116, -116, -115, -115, -114, -114, -113, -112, -110,
-111, -109, -108, -108, -108, -107, -106, -105, -104, -103, -103, -100, -99,
-98, -98, -97, -96, -95, -93, -90, -86, -84, -77, -73, -65, -56, -51, -45, -40,
-35, -32, -26, -21, -19, -14, -11, -10, -8, -7, -7, -5, -5, -4, -3, -2, -1, -2,
-3, -3, -6, -5, -7, -7, -9, -11, -12, -16, -18, -21, -26, -32, -35, -41, -45,
-50, -57, -65, -73, -78, -83, -87, -90, -93, -94, -96, -97, -97, -99, -99, -101,
-102, -103, -104, -105, -106, -107, -107, -108, -109, -110, -109, -112, -112,
-113, -114, -115, -114, -115, -116, -116, -116, -116, -116, -117, -116, -117,
-117, -117, -117, -118, -118, -118, -119, -118, -119, -119, -119, -119, -120,
-118, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-117, -117, -117, -116, -116, -115, -114, -114, -114, -113, -112, -111, -109,
-107, -105, -102, -100, -99, -98, -96, -95, -94, -91, -88, -86, -85, -83, -80,
-79, -78, -76, -74, -73, -69, -63, -58, -52, -47, -43, -38, -34, -26, -14, -5,
};