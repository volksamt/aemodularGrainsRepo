#define DATA_LENGTH 512
#define DATA AKWF_1664

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 9, 12, 15, 18, 22, 24, 28, 31,
33, 36, 38, 41, 43, 46, 48, 51, 53, 56, 58, 60, 61, 63, 66, 67, 69, 70, 74, 75,
77, 79, 81, 82, 83, 85, 86, 88, 90, 91, 92, 94, 95, 96, 97, 99, 100, 101, 102,
104, 104, 106, 107, 108, 108, 109, 111, 111, 112, 113, 115, 115, 116, 116, 117,
117, 119, 118, 119, 118, 118, 118, 117, 116, 116, 114, 114, 113, 112, 111, 110,
108, 107, 106, 106, 105, 104, 103, 101, 100, 98, 98, 96, 95, 95, 93, 92, 91, 90,
89, 88, 87, 86, 85, 84, 83, 82, 82, 80, 80, 79, 78, 77, 78, 76, 76, 75, 73, 73,
74, 72, 72, 72, 72, 71, 71, 71, 71, 71, 70, 69, 70, 70, 69, 69, 70, 69, 69, 70,
70, 70, 70, 71, 71, 70, 71, 71, 71, 72, 73, 73, 73, 74, 74, 75, 76, 76, 77, 76,
78, 78, 79, 79, 80, 81, 81, 81, 83, 83, 84, 85, 85, 86, 87, 88, 88, 89, 89, 90,
91, 92, 92, 94, 94, 95, 95, 96, 97, 98, 99, 99, 100, 101, 101, 102, 102, 101,
101, 99, 98, 96, 96, 93, 90, 89, 86, 84, 81, 79, 76, 73, 70, 68, 65, 63, 59, 56,
53, 50, 47, 44, 41, 38, 36, 32, 28, 26, 23, 19, 17, 14, 10, 7, 5, 2, -2, -5, -7,
-9, -11, -13, -15, -17, -20, -21, -24, -25, -26, -28, -29, -30, -31, -32, -33,
-34, -35, -35, -36, -37, -38, -39, -38, -39, -40, -40, -40, -41, -42, -41, -42,
-42, -42, -41, -41, -42, -41, -41, -41, -42, -41, -40, -40, -40, -39, -38, -39,
-38, -37, -36, -36, -35, -35, -34, -33, -32, -32, -30, -29, -28, -26, -25, -25,
-23, -22, -20, -19, -18, -16, -16, -14, -13, -11, -9, -7, -5, -4, -2, 0, 2, 4,
6, 8, 9, 9, 8, 4, 1, -4, -9, -14, -19, -24, -29, -33, -38, -43, -46, -50, -54,
-57, -61, -64, -68, -70, -72, -76, -78, -79, -82, -83, -85, -87, -89, -90, -92,
-93, -94, -96, -97, -98, -99, -100, -101, -102, -104, -104, -105, -106, -106,
-106, -106, -108, -109, -109, -109, -110, -111, -110, -111, -112, -112, -113,
-113, -112, -113, -113, -114, -115, -113, -114, -113, -115, -114, -115, -115,
-115, -115, -115, -115, -115, -115, -116, -114, -115, -114, -115, -115, -115,
-115, -115, -115, -115, -114, -114, -114, -114, -114, -113, -114, -113, -113,
-113, -113, -112, -112, -112, -111, -111, -111, -111, -110, -110, -109, -109,
-109, -108, -108, -108, -108, -107, -106, -105, -106, -104, -104, -104, -103,
-103, -102, -102, -101, -100, -100, -99, -97, -98, -97, -96, -95, -94, -93, -92,
-92, -90, -89, -89, -89, -87, -86, -85, -84, -82, -81, -80, -79, -77, -76, -76,
-73, -73, -71, -70, -68, -66, -64, -63, -61, -60, -58, -55, -54, -52, -50, -48,
-46, -44, -41, -40, -37, -35, -32, -30, -27, -24, -22, -19, -16, -13, -9, -7,
-3, 0, };