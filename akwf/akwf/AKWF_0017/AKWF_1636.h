#define DATA_LENGTH 512
#define DATA AKWF_1636

const PROGMEM int8_t DATA[DATA_LENGTH] = {9, 67, 73, 78, 82, 85, 90, 93, 97, 99,
102, 103, 107, 108, 110, 110, 112, 113, 114, 114, 116, 116, 117, 117, 118, 118,
118, 118, 118, 119, 119, 119, 120, 120, 119, 119, 119, 118, 118, 119, 119, 118,
118, 118, 118, 117, 117, 117, 117, 116, 116, 116, 116, 115, 116, 115, 115, 114,
115, 114, 113, 114, 113, 113, 112, 112, 112, 112, 112, 111, 111, 111, 110, 110,
110, 110, 110, 109, 110, 108, 109, 107, 108, 108, 108, 107, 106, 106, 106, 106,
105, 105, 104, 104, 104, 104, 104, 103, 103, 102, 102, 103, 102, 101, 101, 101,
101, 101, 100, 100, 100, 98, 94, 88, 80, 75, 70, 65, 60, 57, 52, 50, 46, 44, 41,
38, 37, 35, 33, 31, 30, 29, 27, 26, 25, 24, 23, 22, 22, 21, 19, 19, 18, 18, 17,
17, 16, 16, 15, 15, 14, 14, 13, 14, 13, 12, 12, 12, 11, 11, 10, 10, 10, 9, 9, 9,
9, 8, 10, 15, 19, 23, 26, 29, 31, 33, 33, 29, 27, 25, 23, 22, 18, 18, 18, 21,
24, 25, 28, 28, 30, 32, 33, 35, 35, 35, 37, 37, 37, 37, 37, 38, 38, 38, 39, 38,
38, 38, 38, 38, 38, 38, 38, 37, 37, 36, 36, 34, 34, 33, 31, 31, 30, 30, 29, 29,
28, 27, 26, 27, 26, 22, 14, 3, -7, -16, -24, -31, -38, -44, -49, -55, -60, -64,
-68, -70, -73, -76, -73, -69, -64, -62, -58, -55, -52, -50, -47, -47, -44, -42,
-41, -40, -38, -37, -36, -35, -34, -34, -33, -32, -32, -32, -31, -31, -31, -31,
-29, -30, -29, -29, -28, -29, -29, -29, -28, -28, -28, -28, -28, -27, -28, -27,
-27, -27, -27, -28, -27, -27, -27, -27, -27, -27, -27, -27, -27, -27, -27, -27,
-27, -27, -27, -27, -27, -27, -27, -26, -27, -27, -27, -27, -27, -26, -27, -27,
-27, -27, -27, -27, -27, -26, -27, -27, -27, -27, -26, -27, -26, -26, -27, -27,
-27, -26, -27, -27, -22, -16, -11, -6, -2, 3, 7, 10, 13, 16, 18, 20, 23, 24, 25,
27, 25, 21, 16, 11, 8, 5, 1, -1, -9, -18, -26, -33, -40, -46, -51, -55, -56,
-55, -53, -53, -52, -50, -50, -49, -49, -48, -48, -46, -46, -46, -45, -44, -44,
-45, -45, -45, -45, -45, -45, -44, -44, -44, -44, -44, -45, -44, -45, -43, -44,
-43, -44, -44, -44, -44, -44, -45, -45, -44, -45, -45, -45, -45, -46, -45, -43,
-38, -36, -32, -28, -27, -24, -22, -23, -26, -28, -31, -33, -34, -36, -37, -37,
-35, -35, -34, -32, -32, -30, -30, -30, -29, -29, -28, -27, -27, -26, -27, -26,
-26, -27, -26, -26, -27, -27, -26, -27, -28, -28, -29, -29, -29, -29, -30, -33,
-38, -41, -44, -48, -51, -52, -55, -57, -59, -61, -62, -63, -66, -66, -67, -70,
-73, -75, -78, -81, -82, -84, -86, -87, -89, -90, -92, -93, -93, -93, -90, -78,
-64, -50, -39, -28, -18, -9, -2, };