#define DATA_LENGTH 512
#define DATA AKWF_1613

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 5, 7, 9, 10, 12, 14, 15, 17,
19, 22, 23, 25, 27, 29, 31, 33, 35, 39, 41, 43, 46, 48, 52, 54, 56, 60, 63, 66,
70, 73, 78, 83, 89, 95, 98, 100, 100, 99, 96, 92, 87, 83, 76, 69, 60, 50, 41,
29, 16, -2, -21, -35, -41, -46, -48, -50, -51, -51, -51, -52, -51, -52, -52,
-51, -51, -51, -50, -51, -50, -50, -49, -49, -49, -48, -48, -48, -47, -47, -46,
-46, -45, -44, -43, -43, -42, -42, -41, -40, -40, -39, -39, -37, -37, -36, -35,
-35, -34, -33, -32, -32, -31, -31, -30, -29, -28, -28, -27, -26, -26, -24, -23,
-21, -20, -18, -18, -16, -15, -13, -12, -10, -8, -6, -5, -3, -2, 1, 3, 4, 6, 8,
10, 12, 14, 15, 17, 21, 23, 25, 27, 29, 32, 34, 37, 40, 42, 45, 46, 51, 53, 56,
59, 63, 66, 70, 73, 78, 81, 85, 90, 95, 102, 110, 115, 118, 118, 116, 112, 108,
101, 95, 87, 79, 68, 58, 47, 36, 26, 25, 30, 37, 46, 55, 64, 74, 83, 91, 98,
106, 111, 115, 118, 118, 114, 109, 103, 99, 93, 87, 83, 79, 76, 72, 69, 65, 61,
58, 55, 52, 49, 46, 44, 41, 38, 35, 33, 30, 28, 26, 24, 21, 20, 17, 15, 13, 11,
8, 6, 6, 4, 1, 0, -3, -4, -6, -7, -9, -10, -12, -13, -16, -16, -18, -20, -21,
-23, -23, -25, -25, -27, -28, -28, -29, -29, -30, -31, -31, -33, -33, -33, -35,
-35, -36, -37, -38, -38, -39, -40, -40, -41, -41, -43, -43, -43, -43, -44, -46,
-46, -46, -47, -47, -48, -49, -48, -49, -50, -50, -50, -50, -51, -50, -51, -51,
-51, -51, -51, -52, -52, -52, -53, -53, -52, -53, -48, -37, -21, -6, 9, 23, 35,
46, 55, 63, 71, 79, 84, 90, 94, 97, 100, 101, 98, 94, 89, 85, 80, 76, 72, 68,
65, 62, 59, 55, 52, 50, 47, 45, 42, 40, 38, 34, 32, 31, 29, 26, 25, 22, 21, 19,
16, 14, 13, 11, 9, 8, 6, 5, 2, 1, 0, -2, -3, -5, -6, -8, -9, -10, -11, -12, -15,
-15, -17, -19, -19, -20, -21, -23, -23, -25, -26, -27, -28, -29, -30, -30, -31,
-32, -33, -34, -34, -36, -37, -38, -38, -39, -40, -40, -41, -42, -42, -43, -43,
-44, -45, -46, -46, -47, -47, -46, -47, -48, -48, -49, -49, -50, -50, -50, -51,
-51, -50, -51, -51, -51, -51, -51, -51, -52, -52, -53, -52, -53, -49, -35, -23,
-27, -36, -43, -47, -49, -50, -52, -51, -51, -52, -51, -52, -52, -52, -52, -51,
-50, -51, -50, -49, -50, -49, -49, -49, -48, -48, -47, -47, -47, -47, -45, -44,
-44, -44, -42, -43, -42, -41, -40, -40, -39, -39, -38, -37, -37, -36, -35, -34,
-32, -33, -31, -30, -30, -28, -27, -27, -24, -24, -23, -22, -20, -19, -18, -17,
-16, -15, -13, -13, -11, -9, -8, -7, -5, -3, -2, -1, };