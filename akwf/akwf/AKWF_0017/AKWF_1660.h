#define DATA_LENGTH 512
#define DATA AKWF_1660

const PROGMEM int8_t DATA[DATA_LENGTH] = {62, 81, 71, 77, 73, 76, 73, 75, 74,
75, 74, 76, 75, 75, 75, 75, 75, 75, 75, 75, 76, 75, 75, 75, 75, 75, 75, 75, 76,
75, 75, 75, 75, 75, 75, 75, 75, 75, 75, 75, 75, 75, 75, 75, 74, 75, 75, 74, 66,
61, 60, 60, 61, 61, 61, 60, 60, 61, 61, 61, 60, 60, 61, 60, 61, 61, 61, 61, 61,
60, 61, 61, 60, 60, 61, 61, 60, 61, 60, 61, 64, 64, 64, 64, 64, 65, 65, 65, 65,
65, 65, 64, 65, 64, 64, 65, 68, 69, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68, 68,
68, 67, 65, 64, 64, 64, 64, 64, 65, 64, 63, 64, 64, 64, 64, 64, 63, 65, 71, 77,
78, 77, 77, 77, 78, 78, 77, 77, 77, 77, 78, 77, 77, 77, 73, 65, 63, 63, 64, 64,
64, 63, 64, 64, 63, 63, 63, 63, 64, 64, 63, 63, 63, 64, 64, 63, 63, 63, 64, 64,
63, 64, 63, 63, 64, 63, 61, 59, 59, 59, 60, 59, 59, 59, 59, 59, 59, 58, 59, 58,
59, 59, 59, 59, 59, 58, 60, 59, 60, 59, 59, 58, 58, 58, 59, 59, 59, 59, 58, 59,
59, 58, 59, 59, 60, 59, 59, 58, 59, 59, 58, 59, 59, 59, 58, 59, 59, 58, 58, 59,
59, 58, 59, 58, 59, 59, 58, 58, 59, 59, 59, 59, 58, 59, 59, 59, 59, 59, 59, 59,
58, 59, 58, 59, 58, 58, 58, 59, 59, 58, 58, 58, 59, 58, 58, 59, 59, 58, 59, 59,
59, 57, 59, 58, 59, 58, 59, 58, 59, 59, 59, 58, 58, 58, 58, 58, 57, 73, 96, 102,
100, 101, 101, 100, 100, 101, 101, 101, 101, 101, 101, 101, 101, 100, 100, 99,
99, 98, 99, 99, 99, 100, 99, 99, 99, 100, 99, 99, 98, 98, 95, 89, 88, 88, 89,
88, 88, 88, 88, 89, 88, 89, 88, 88, 88, 88, 87, 84, 83, 84, 83, 83, 84, 84, 83,
84, 84, 84, 83, 83, 83, 81, 75, 72, 72, 72, 72, 72, 72, 72, 72, 72, 72, 72, 72,
72, 73, 70, 61, 55, 57, 57, 56, 57, 56, 56, 56, 57, 56, 56, 57, 56, 57, 54, 39,
23, 23, 24, 23, 24, 23, 23, 24, 23, 23, 23, 24, 23, 23, -1, -31, -36, -34, -35,
-34, -35, -34, -35, -35, -35, -34, -34, -35, -34, -34, -47, -69, -75, -74, -73,
-74, -74, -75, -74, -74, -74, -74, -74, -75, -75, -70, -96, -120, -118, -120,
-119, -119, -118, -119, -118, -119, -120, -120, -118, -119, -120, -118, -118,
-119, -118, -118, -118, -119, -119, -119, -119, -118, -119, -118, -119, -118,
-118, -118, -118, -116, -117, -116, -116, -117, -116, -117, -117, -118, -117,
-118, -116, -117, -116, -117, -116, -116, -115, -116, -116, -115, -116, -116,
-116, -115, -115, -116, -116, -116, -115, -115, -114, -113, -112, -113, -113,
-112, -113, -113, -113, -112, -113, -112, -113, -111, -114, -111, -111, -55, };