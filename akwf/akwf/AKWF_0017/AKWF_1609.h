#define DATA_LENGTH 512
#define DATA AKWF_1609

const PROGMEM int8_t DATA[DATA_LENGTH] = {67, 120, 107, 113, 109, 111, 109, 110,
108, 109, 108, 109, 108, 108, 108, 108, 107, 107, 106, 107, 106, 105, 105, 105,
106, 105, 105, 103, 104, 104, 103, 103, 103, 103, 103, 102, 102, 102, 101, 101,
100, 100, 99, 99, 98, 98, 97, 97, 95, 95, 96, 95, 94, 94, 93, 93, 92, 92, 90,
90, 89, 90, 89, 88, 88, 87, 86, 86, 86, 84, 84, 82, 85, 82, 85, 79, 88, 44, 1,
15, 8, 12, 10, 11, 10, 12, 10, 11, 11, 10, 11, 11, 11, 10, 11, 10, 10, 11, 12,
11, 11, 11, 11, 11, 11, 11, 11, 12, 11, 11, 10, 11, 11, 11, 11, 11, 11, 11, 11,
11, 11, 11, 10, 10, 11, 10, 17, -27, -59, -51, -54, -51, -52, -51, -52, -49,
-49, -49, -48, -48, -47, -47, -47, -46, -45, -46, -44, -44, -42, -43, -42, -42,
-40, -41, -40, -15, -9, -11, -9, -11, -10, -11, -10, -11, -9, -11, -10, -11,
-10, -11, -11, -11, -10, -11, -11, -11, -10, -11, -10, -11, -11, -10, -11, -11,
-11, -11, -11, -11, -10, -11, -11, -11, -11, -11, -10, -11, -12, -11, -11, -11,
-10, -11, -11, -11, -10, -11, -11, -11, -11, -10, -11, -11, -10, -10, -10, -10,
-10, -9, -9, -8, -8, -8, -8, -7, -7, -7, -6, -7, -5, -6, -5, -5, -6, -4, -4, -4,
-4, -4, -3, -3, -3, -2, -2, -2, -2, -1, -1, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 1,
0, 0, -1, 0, 0, 0, 2, 1, 2, 2, 3, 2, 2, 3, 3, 3, 4, 3, 4, 5, 5, 4, 5, 5, 6, 6,
6, 6, 7, 8, 7, 8, 7, 8, 8, 9, 9, 10, 10, 10, 10, 10, 10, 11, 10, 11, 11, 11, 11,
11, 11, 10, 11, 10, 11, 11, 10, 10, 10, 11, 10, 10, 11, 11, 11, 11, 11, 10, 11,
11, 11, 11, 11, 11, 11, 10, 11, 11, 11, 10, 11, 11, 10, 10, 11, 10, 11, 11, 11,
10, 11, 10, 11, 10, 11, 10, 12, 10, 17, 41, 40, 41, 43, 42, 44, 43, 44, 43, 44,
44, 45, 46, 47, 47, 48, 48, 49, 50, 49, 50, 51, 52, 51, 54, 51, 59, 23, -18, -9,
-11, -11, -12, -10, -11, -11, -10, -11, -10, -11, -11, -12, -11, -11, -10, -10,
-11, -11, -11, -10, -10, -11, -11, -11, -11, -11, -12, -11, -11, -11, -11, -10,
-11, -10, -12, -11, -11, -10, -12, -10, -11, -11, -10, -12, -9, -14, -2, -49,
-86, -79, -85, -80, -84, -83, -86, -85, -86, -85, -86, -86, -87, -88, -88, -90,
-90, -90, -91, -91, -92, -93, -92, -94, -94, -94, -95, -95, -96, -96, -97, -98,
-98, -99, -100, -100, -101, -101, -102, -102, -101, -102, -102, -103, -103,
-103, -104, -104, -105, -105, -104, -105, -106, -105, -106, -106, -106, -106,
-106, -107, -108, -107, -107, -108, -108, -108, -109, -109, -110, -110, -109,
-111, -109, -113, -108, -121, -63, };