#define DATA_LENGTH 512
#define DATA AKWF_1616

const PROGMEM int8_t DATA[DATA_LENGTH] = {88, 111, 106, 104, 62, 66, 62, 64, 62,
65, 62, 63, 48, 46, 47, 46, 47, 46, 46, 46, 47, 45, 48, 45, 47, 46, 47, 46, 47,
46, 46, 46, 46, 46, 45, 45, 46, 47, 46, 45, 45, 45, 46, 45, 45, 46, 45, 46, 45,
45, 45, 45, 44, 45, 45, 45, 44, 45, 44, 45, 45, 44, 45, 44, 44, 45, 45, 45, 45,
44, 44, 44, 44, 45, 44, 44, 45, 44, 43, 44, 44, 43, 44, 43, 43, 44, 44, 43, 43,
43, 43, 43, 43, 44, 43, 43, 44, 43, 43, 44, 42, 42, 43, 44, 43, 43, 44, 44, 43,
43, 43, 43, 43, 43, 43, 43, 44, 43, 44, 43, 44, 43, 44, 44, 43, 44, 44, 44, 44,
44, 44, 44, 44, 43, 45, 46, 44, 46, 43, 48, 30, 37, 48, 42, 46, 42, 45, 44, 45,
44, 45, 44, 44, 43, 44, 44, 44, 44, 44, 44, 43, 44, 44, 44, 43, 43, 43, 43, 43,
43, 43, 44, 43, 43, 43, 44, 43, 43, 44, 43, 43, 43, 44, 43, 43, 43, 43, 43, 44,
44, 43, 43, 43, 43, 43, 43, 43, 44, 44, 44, 43, 44, 43, 44, 43, 44, 44, 44, 44,
43, 44, 44, 44, 44, 45, 44, 44, 44, 44, 44, 44, 44, 45, 44, 45, 45, 45, 45, 45,
45, 44, 45, 45, 45, 45, 46, 46, 45, 45, 45, 46, 45, 46, 45, 45, 45, 46, 45, 46,
46, 46, 47, 45, 47, 46, 47, 45, 47, 46, 47, 46, 47, 46, 48, 45, 48, 45, 48, 45,
52, 65, 62, 64, 62, 64, 62, 65, 70, 117, 95, 127, 21, -128, -103, -118, -108,
-116, -110, -114, -112, -112, -112, -112, -113, -111, -113, -112, -113, -110,
-112, -111, -112, -111, -113, -112, -112, -112, -113, -112, -112, -112, -109,
-104, -105, -104, -104, -105, -105, -104, -103, -105, -104, -108, -113, -111,
-111, -111, -110, -109, -108, -108, -106, -107, -104, -102, -96, -75, -64, -63,
-60, -62, -60, -62, -64, -69, -72, -77, -84, -87, -93, -97, -103, -106, -111,
-110, -113, -110, -114, -109, -115, -108, -120, -86, 6, -2, 2, 0, 0, 1, 0, 1, 0,
1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0, 1, 1, 0, 1, 1, 1, 1, 1, 1, 0, 2, 1,
1, 1, 1, 1, 1, 1, 1, 1, 0, 1, 1, 1, 0, 1, 1, 1, 1, 0, 1, 0, 1, 0, 2, -1, 3, -1,
4, -3, 4, -6, 10, -34, -119, -108, -113, -112, -112, -112, -112, -111, -110,
-109, -105, -101, -95, -92, -84, -81, -73, -71, -66, -63, -61, -62, -61, -61,
-63, -67, -86, -101, -103, -106, -107, -108, -108, -108, -109, -110, -111, -110,
-112, -111, -105, -104, -105, -104, -106, -105, -105, -104, -105, -104, -106,
-111, -113, -112, -112, -111, -112, -112, -113, -112, -112, -112, -112, -112,
-112, -113, -111, -112, -111, -113, -111, -114, -111, -114, -110, -115, -109,
-116, -107, -120, -90, };