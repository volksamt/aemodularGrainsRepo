#define DATA_LENGTH 512
#define DATA AKWF_1659

const PROGMEM int8_t DATA[DATA_LENGTH] = {28, 43, 40, 42, 40, 41, 40, 41, 41,
40, 41, 41, 41, 42, 40, 45, 62, 70, 70, 70, 70, 70, 70, 70, 70, 69, 69, 69, 70,
70, 69, 72, 88, 98, 99, 99, 100, 100, 98, 100, 100, 100, 100, 100, 100, 100, 99,
100, 103, 107, 108, 109, 108, 109, 108, 108, 108, 108, 109, 108, 108, 108, 108,
110, 112, 114, 114, 113, 113, 113, 114, 113, 114, 114, 113, 114, 113, 113, 113,
113, 116, 117, 116, 116, 116, 116, 117, 116, 115, 116, 116, 116, 116, 116, 116,
117, 117, 117, 117, 118, 117, 117, 117, 117, 117, 117, 118, 117, 118, 117, 118,
118, 117, 118, 117, 117, 117, 117, 117, 117, 118, 118, 117, 117, 116, 117, 118,
117, 117, 117, 117, 117, 117, 117, 117, 118, 118, 117, 118, 117, 118, 117, 116,
117, 117, 118, 117, 117, 117, 117, 117, 117, 117, 118, 117, 117, 117, 117, 118,
118, 118, 117, 117, 118, 117, 117, 117, 117, 118, 118, 118, 118, 117, 117, 118,
116, 118, 117, 118, 116, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117,
116, 118, 118, 116, 117, 117, 117, 117, 117, 117, 117, 118, 117, 116, 117, 117,
117, 117, 118, 117, 117, 117, 117, 117, 117, 116, 117, 117, 117, 116, 117, 117,
117, 117, 117, 117, 116, 117, 115, 119, 114, 119, 113, 121, 111, 123, 108, 127,
30, -128, -112, -122, -117, -120, -119, -118, -120, -119, -119, -118, -120,
-118, -119, -118, -120, -117, -120, -117, -120, -118, -118, -117, -120, -119,
-119, -118, -119, -119, -119, -119, -119, -118, -118, -118, -118, -118, -118,
-118, -117, -118, -118, -118, -117, -118, -118, -119, -117, -118, -118, -117,
-118, -118, -117, -118, -118, -118, -118, -118, -117, -117, -118, -118, -118,
-118, -117, -117, -117, -117, -116, -117, -117, -117, -117, -117, -117, -117,
-118, -117, -118, -116, -115, -116, -116, -116, -117, -117, -116, -116, -116,
-117, -116, -116, -116, -116, -116, -117, -116, -116, -116, -117, -116, -116,
-116, -116, -116, -117, -117, -116, -116, -117, -115, -114, -114, -114, -114,
-114, -114, -114, -113, -114, -114, -113, -114, -113, -114, -114, -111, -110,
-109, -109, -109, -109, -109, -108, -109, -109, -109, -109, -110, -109, -110,
-109, -109, -109, -108, -109, -108, -108, -108, -108, -108, -107, -109, -108,
-108, -108, -108, -107, -107, -107, -106, -107, -106, -106, -106, -107, -106,
-106, -106, -106, -106, -107, -107, -106, -105, -103, -102, -103, -102, -103,
-102, -103, -102, -103, -103, -102, -102, -102, -102, -103, -98, -93, -93, -93,
-93, -93, -93, -93, -92, -92, -93, -93, -93, -93, -92, -92, -90, -86, -85, -86,
-87, -87, -85, -86, -86, -85, -86, -86, -86, -85, -86, -84, -80, -76, -76, -78,
-77, -77, -77, -77, -77, -76, -76, -77, -77, -77, -78, -77, -74, -73, -74, -73,
-74, -74, -73, -73, -74, -73, -73, -73, -73, -73, -73, -73, -53, -23, -19, -21,
-20, -20, -20, -20, -21, -20, -21, -20, -20, -20, -22, -19, -1, };