#define DATA_LENGTH 512
#define DATA AKWF_1672

const PROGMEM int8_t DATA[DATA_LENGTH] = {42, 60, 65, 74, 77, 83, 84, 89, 92,
94, 97, 99, 101, 103, 105, 107, 109, 110, 112, 112, 114, 114, 115, 116, 116,
118, 117, 119, 118, 120, 117, 124, 98, 65, 64, 55, 51, 46, 44, 40, 37, 34, 32,
30, 28, 25, 24, 23, 21, 19, 17, 16, 15, 14, 13, 11, 10, 9, 8, 8, 7, 6, 6, 5, 4,
3, 3, 3, 2, 1, 2, 1, 1, 0, 0, 0, 0, 1, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, -1, -1, 0, -1, 0, -1, 0, -1, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, -1, 1,
0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 1, 0, -1, 1,
1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0,
0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, -1, 1, 0, 0, 0, 0, -1, -1, 0, 0,
0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1,
0, -1, 0, 0, 0, -1, -1, -1, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0,
0, 0, 0, 0, -1, -1, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, -1, -1,
0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0,
-1, 0, -1, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, -1, -1, 0, 0, 0, 1, 0, -1, 0,
-1, 0, 0, 0, 0, -1, 0, 1, -1, 0, 0, -1, 0, -1, 1, 0, -1, 0, 0, -1, 0, 0, 1, -1,
1, -1, 1, -1, 1, -2, 2, -2, 2, -3, 5, -14, -108, -90, -66, -65, -55, -55, -50,
-49, -44, -44, -40, -40, -36, -36, -34, -33, -31, -30, -28, -27, -26, -25, -24,
-22, -23, -21, -20, -19, -18, -18, -18, -16, -15, -15, -14, -12, -13, -11, -11,
-11, -10, -9, -9, -9, -9, -8, -6, -7, -6, -6, -6, -6, -5, -5, -5, -5, -3, -3,
-2, -3, -2, -2, -2, -2, -2, -1, -1, -1, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, };