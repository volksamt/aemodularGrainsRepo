#define DATA_LENGTH 512
#define DATA AKWF_1637

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 6, 7, 7, 9, 12, 13, 15, 16,
18, 17, 20, 20, 22, 23, 25, 26, 27, 29, 31, 32, 33, 34, 36, 37, 38, 40, 41, 43,
45, 46, 46, 48, 50, 52, 54, 55, 56, 57, 58, 59, 59, 59, 60, 61, 62, 62, 63, 63,
66, 68, 69, 70, 70, 71, 71, 72, 73, 73, 74, 75, 76, 77, 78, 79, 79, 79, 80, 82,
81, 82, 83, 84, 84, 86, 86, 87, 88, 88, 89, 90, 90, 91, 93, 93, 95, 95, 97, 98,
100, 102, 102, 103, 104, 105, 106, 105, 106, 107, 108, 109, 109, 111, 112, 113,
113, 114, 116, 105, 6, -84, -104, -113, -112, -113, -112, -111, -110, -109,
-106, -105, -105, -103, -102, -99, -99, -97, -97, -96, -95, -94, -94, -92, -92,
-92, -90, -89, -89, -88, -87, -86, -87, -86, -84, -84, -84, -82, -82, -81, -80,
-80, -79, -78, -77, -77, -76, -75, -74, -74, -73, -71, -70, -68, -67, -66, -65,
-64, -63, -62, -61, -59, -59, -59, -58, -56, -55, -53, -52, -51, -50, -48, -48,
-47, -46, -44, -43, -42, -40, -40, -38, -37, -37, -35, -34, -32, -32, -31, -30,
-29, -28, -26, -26, -25, -24, -23, -21, -20, -17, -16, -15, -14, -11, -9, -7,
-7, -6, -5, -4, -4, -4, -2, -3, -2, -1, -1, 1, 0, 1, 0, -1, 0, -1, -2, -2, -3,
-3, -4, -5, -6, -6, -6, -8, -10, -11, -14, -15, -16, -18, -19, -21, -22, -24,
-24, -26, -27, -28, -29, -30, -31, -32, -33, -35, -36, -36, -38, -39, -39, -41,
-42, -43, -45, -46, -47, -47, -48, -50, -50, -52, -54, -54, -56, -57, -58, -59,
-60, -62, -62, -63, -65, -65, -67, -67, -69, -71, -72, -74, -73, -75, -75, -77,
-76, -78, -79, -78, -80, -81, -81, -82, -83, -84, -84, -85, -85, -86, -87, -87,
-88, -88, -89, -91, -91, -92, -94, -93, -95, -95, -97, -96, -98, -97, -101,
-101, -104, -104, -106, -106, -109, -110, -111, -113, -112, -116, -112, -125,
-46, -46, -47, -15, -24, -13, -21, -14, -19, -16, -20, -17, -20, -18, -19, -19,
-19, -19, -18, -19, -18, -20, -21, -23, -23, -22, -22, -24, -24, -25, -24, -25,
-24, -25, -24, -25, -24, -25, -25, -26, -24, -26, -25, -25, -25, -25, -26, -26,
-26, -26, -27, -25, -26, -26, -26, -27, -26, -26, -27, -27, -28, -28, -29, -28,
-29, -30, -29, -30, -29, -29, -30, -30, -30, -30, -30, -30, -31, -31, -31, -31,
-32, -32, -32, -32, -32, -32, -32, -31, -31, -32, -33, -32, -32, -33, -32, -32,
-32, -33, -33, -33, -32, -32, -32, -33, -33, -33, -35, -35, -34, -34, -34, -34,
-35, -34, -35, -35, -34, -34, -34, -33, -33, -33, -32, -33, -33, -33, -35, -34,
-34, -35, -33, -34, -34, -34, -36, -38, -40, -41, -42, -42, -41, -38, -35, -32,
-28, -25, -23, -24, -21, -21, -19, -18, -17, -14, -13, -13, -10, -9, -8, -7, -6,
-5, -4, -3, -1, 0, };