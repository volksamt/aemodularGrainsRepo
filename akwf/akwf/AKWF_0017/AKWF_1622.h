#define DATA_LENGTH 512
#define DATA AKWF_1622

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 4, 5, 5, 6, 7, 7, 8, 9, 10,
11, 12, 12, 12, 14, 13, 14, 14, 14, 13, 14, 13, 13, 14, 13, 13, 14, 14, 14, 14,
14, 13, 13, 12, 13, 12, 12, 11, 11, 11, 11, 10, 11, 10, 10, 10, 9, 9, 8, 8, 8,
7, 7, 6, 7, 6, 6, 5, 6, 5, 5, 4, 4, 4, 3, 4, 3, 3, 3, 2, 2, 2, 2, 2, 1, 1, 1, 0,
1, 2, 1, 0, 1, 1, 1, 0, 0, 1, 1, 1, 1, 2, 1, 1, 1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2,
3, 2, 3, 3, 3, 3, 2, 4, 3, 4, 3, 3, 3, 3, 4, 3, 4, 5, 6, 5, 6, 6, 5, 6, 6, 5, 6,
6, 7, 7, 7, 7, 7, 8, 8, 8, 8, 9, 9, 9, 9, 8, 8, 9, 9, 10, 13, 17, 23, 27, 30,
34, 36, 40, 43, 45, 47, 49, 51, 52, 54, 56, 57, 58, 58, 59, 59, 61, 61, 61, 61,
61, 62, 62, 61, 61, 61, 61, 61, 60, 61, 61, 61, 60, 60, 59, 59, 59, 59, 59, 58,
57, 57, 56, 56, 56, 55, 55, 54, 54, 53, 54, 54, 52, 53, 53, 52, 52, 51, 49, 42,
26, 10, -3, -15, -27, -36, -46, -54, -62, -68, -76, -80, -87, -91, -95, -99,
-102, -105, -108, -110, -112, -113, -115, -117, -117, -118, -118, -119, -119,
-119, -115, -105, -89, -75, -64, -51, -42, -31, -22, -15, -6, 1, 7, 13, 18, 24,
28, 32, 36, 39, 41, 44, 47, 48, 51, 52, 54, 56, 56, 59, 59, 59, 60, 60, 61, 60,
60, 59, 59, 59, 58, 58, 57, 57, 57, 57, 56, 55, 54, 54, 53, 51, 51, 49, 49, 48,
47, 46, 45, 44, 44, 43, 42, 42, 41, 39, 38, 36, 35, 33, 33, 32, 31, 29, 28, 28,
27, 27, 25, 25, 25, 24, 21, 20, 19, 18, 17, 16, 15, 14, 14, 12, 13, 11, 11, 10,
10, 10, 10, 8, 8, 7, 7, 7, 6, 5, 6, 5, 6, 5, 5, 5, 6, 6, 6, 8, 8, 9, 9, 10, 10,
10, 10, 11, 11, 12, 12, 13, 12, 12, 11, 12, 10, 10, 10, 9, 8, 8, 8, 8, 8, 8, 7,
7, 7, 5, 5, 4, 3, 3, 2, 1, 0, 0, -1, -1, -2, -2, -2, -3, -3, -4, -6, -8, -9,
-11, -13, -13, -13, -15, -15, -16, -17, -17, -17, -18, -20, -21, -23, -25, -27,
-28, -30, -31, -34, -35, -35, -36, -37, -38, -39, -39, -40, -41, -43, -46, -48,
-50, -53, -54, -55, -56, -57, -58, -59, -60, -59, -60, -61, -63, -67, -70, -74,
-76, -79, -81, -82, -85, -86, -87, -89, -90, -91, -92, -92, -93, -92, -93, -94,
-93, -94, -94, -93, -93, -92, -93, -92, -92, -91, -90, -89, -83, -75, -68, -61,
-55, -50, -45, -41, -36, -32, -28, -25, -22, -19, -17, -14, -12, -9, -7, -5, -4,
-1, 0, };