#define DATA_LENGTH 512
#define DATA AKWF_1685

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 8, 9, 12, 15, 18, 21, 24, 28, 31,
34, 37, 39, 43, 45, 48, 51, 53, 56, 58, 62, 63, 66, 68, 70, 72, 74, 76, 78, 80,
82, 83, 85, 86, 88, 90, 91, 92, 94, 95, 96, 98, 99, 100, 101, 101, 102, 103,
104, 105, 105, 106, 107, 107, 108, 108, 109, 110, 109, 110, 111, 110, 111, 110,
110, 111, 112, 111, 112, 111, 111, 112, 111, 111, 111, 110, 111, 111, 111, 110,
110, 109, 109, 109, 109, 108, 108, 107, 107, 107, 105, 106, 105, 104, 104, 103,
103, 102, 102, 100, 100, 99, 99, 98, 97, 97, 95, 94, 94, 93, 93, 92, 91, 90, 90,
89, 88, 88, 86, 84, 85, 84, 82, 82, 80, 80, 78, 79, 77, 75, 75, 74, 74, 72, 71,
70, 69, 68, 67, 66, 66, 64, 63, 62, 60, 60, 59, 58, 58, 57, 55, 55, 53, 52, 51,
50, 49, 49, 47, 46, 45, 44, 43, 42, 41, 39, 39, 38, 37, 36, 35, 33, 33, 32, 30,
30, 29, 28, 26, 26, 25, 23, 23, 22, 21, 20, 20, 19, 17, 16, 15, 15, 14, 13, 11,
12, 10, 9, 8, 8, 6, 5, 5, 4, 3, 2, 2, 1, 0, -1, -2, -3, -3, -3, -5, -6, -7, -7,
-8, -8, -9, -10, -10, -12, -11, -13, -14, -15, -16, -15, -16, -18, -18, -19,
-20, -21, -21, -22, -22, -23, -23, -25, -24, -26, -26, -27, -28, -28, -29, -29,
-29, -30, -31, -31, -33, -32, -34, -34, -35, -36, -36, -37, -37, -39, -38, -39,
-40, -41, -42, -41, -43, -43, -44, -44, -45, -46, -47, -46, -48, -48, -49, -49,
-50, -51, -52, -53, -54, -53, -54, -56, -57, -57, -58, -58, -59, -60, -61, -62,
-64, -65, -66, -67, -71, -79, -81, -83, -85, -85, -87, -87, -89, -90, -91, -91,
-92, -93, -94, -95, -96, -96, -96, -97, -98, -98, -99, -100, -100, -102, -102,
-102, -103, -104, -104, -105, -105, -106, -106, -107, -107, -108, -109, -109,
-109, -109, -111, -111, -111, -110, -112, -112, -113, -113, -113, -114, -114,
-113, -115, -115, -115, -115, -115, -115, -116, -117, -116, -116, -117, -117,
-117, -117, -118, -118, -117, -118, -118, -118, -118, -118, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -118, -119,
-119, -119, -118, -119, -118, -118, -118, -117, -117, -118, -117, -117, -116,
-116, -116, -116, -115, -115, -114, -114, -114, -112, -112, -112, -112, -111,
-111, -111, -110, -109, -109, -108, -107, -107, -106, -106, -105, -105, -104,
-104, -102, -101, -101, -101, -99, -99, -98, -97, -97, -95, -95, -94, -93, -92,
-92, -90, -90, -89, -88, -87, -86, -85, -84, -83, -82, -82, -80, -79, -78, -78,
-77, -75, -74, -74, -73, -71, -71, -70, -69, -67, -66, -66, -64, -64, -63, -62,
-60, -59, -59, -57, -56, -54, -53, -53, -50, -49, -49, -47, -46, -46, -43, -42,
-41, -39, -38, -36, -36, -34, -33, -32, -31, -28, -27, -25, -24, -21, -20, -14,
};