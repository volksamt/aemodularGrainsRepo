#define DATA_LENGTH 512
#define DATA AKWF_1612

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 16, 25, 29, 34, 37, 40, 41, 44, 46,
48, 49, 52, 55, 56, 58, 60, 61, 64, 65, 67, 69, 71, 72, 75, 76, 78, 80, 81, 83,
85, 86, 87, 89, 90, 91, 93, 93, 95, 95, 97, 96, 97, 97, 98, 97, 98, 97, 96, 96,
94, 94, 90, 88, 85, 81, 77, 73, 69, 65, 60, 55, 50, 43, 38, 31, 26, 19, 14, 10,
12, 16, 20, 25, 31, 36, 42, 48, 54, 58, 63, 67, 72, 77, 79, 84, 87, 90, 91, 94,
95, 96, 96, 97, 97, 98, 97, 97, 97, 97, 95, 94, 94, 92, 91, 91, 89, 87, 87, 84,
83, 81, 80, 78, 78, 75, 73, 71, 70, 68, 67, 65, 62, 60, 59, 56, 55, 53, 51, 48,
47, 44, 44, 41, 39, 38, 36, 27, 9, -5, -12, -16, -19, -20, -21, -20, -20, -18,
-14, -13, -12, -10, -10, -8, -7, -6, -4, -3, -1, -1, -1, 0, 0, 0, 0, 0, 1, 0,
-1, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, 1, 0, 1,
2, 3, 2, 4, 5, 6, 8, 9, 11, 12, 15, 16, 18, 21, 22, 24, 26, 28, 31, 32, 35, 38,
39, 42, 44, 45, 47, 49, 52, 54, 56, 58, 60, 62, 64, 66, 67, 69, 71, 73, 74, 77,
77, 79, 81, 82, 84, 86, 87, 89, 90, 92, 92, 94, 95, 97, 97, 98, 99, 100, 102,
103, 102, 104, 95, 42, -15, -43, -64, -79, -93, -102, -108, -108, -105, -99,
-95, -93, -94, -99, -104, -106, -106, -105, -101, -100, -99, -102, -104, -108,
-111, -113, -112, -111, -111, -111, -112, -114, -116, -118, -118, -119, -118,
-116, -116, -115, -115, -115, -115, -114, -112, -109, -106, -103, -100, -98,
-95, -92, -88, -84, -78, -74, -67, -62, -56, -50, -44, -38, -32, -26, -19, -12,
-10, -11, -15, -20, -26, -32, -38, -44, -50, -55, -61, -68, -73, -78, -84, -87,
-90, -94, -96, -100, -103, -107, -109, -113, -113, -114, -114, -114, -115, -116,
-117, -118, -119, -119, -117, -114, -112, -111, -111, -112, -114, -113, -112,
-109, -105, -103, -100, -101, -103, -106, -107, -106, -103, -98, -94, -92, -95,
-100, -106, -109, -113, -108, -103, -96, -96, -82, -23, 30, 60, 78, 87, 93, 96,
98, 98, 98, 98, 97, 96, 95, 94, 93, 92, 91, 89, 88, 85, 84, 82, 82, 80, 78, 76,
75, 73, 71, 70, 67, 67, 64, 63, 59, 58, 56, 54, 52, 49, 48, 45, 43, 41, 39, 38,
35, 33, 32, 29, 27, 24, 22, 21, 19, 17, 14, 12, 11, 10, 8, 7, 5, 5, 3, 2, 1, 1,
0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 1, 0, -1, -1, 0, 0, -1, 0, 0, -1, 0, 0, 0,
-1, 0, -1, -1, 0, 1, 1, 0, -2, -3, -4, -6, -8, -8, -9, -11, -12, -14, -16, -18,
-20, -21, -21, -22, -22, -23, -10, };