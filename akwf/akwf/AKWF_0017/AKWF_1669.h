#define DATA_LENGTH 512
#define DATA AKWF_1669

const PROGMEM int8_t DATA[DATA_LENGTH] = {22, 91, 89, 88, 88, 86, 87, 85, 85,
82, 84, 81, 82, 79, 79, 77, 77, 76, 75, 74, 73, 72, 72, 70, 69, 69, 67, 66, 66,
65, 64, 62, 62, 61, 60, 59, 58, 58, 56, 55, 55, 54, 53, 53, 50, 50, 49, 49, 48,
47, 45, 45, 44, 42, 41, 41, 40, 39, 39, 38, 37, 36, 35, 34, 33, 32, 30, 29, 29,
27, 27, 26, 25, 24, 24, 22, 22, 20, 19, 21, 4, -2, 1, -1, 0, 0, 0, 0, 0, 0, 0,
0, 0, -1, 0, 1, 1, -1, 0, 0, -1, 0, 1, 1, 0, -1, 0, 0, 0, 0, -1, 1, 0, 0, 0, 1,
0, 0, 0, -1, 0, -1, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 0,
-1, 0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0, 1, 1, 0, 0,
0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, -1, -1, -1, 0, 0, 0, -1, -1, -1, 1, 0, 1, 0, 1, 0, 0, 0,
-1, 0, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0,
-1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, -1, -1, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0,
0, 1, 0, 0, 0, 0, -1, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0,
0, 0, 0, 1, -1, 0, 0, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 1, 0,
0, -1, -1, -1, 0, 0, 1, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0,
0, 1, 0, 0, 0, 0, -1, 0, 0, 1, 0, -1, 0, 0, 0, 0, -1, 1, 1, 0, 0, -1, 0, 0, 0,
0, 1, 1, 1, 1, 0, -1, 0, 0, -1, -1, 0, 0, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, 0,
1, 0, -1, 1, 0, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0,
1, 0, -22, -26, -25, -29, -29, -31, -33, -35, -35, -37, -38, -40, -41, -43, -45,
-46, -48, -49, -51, -52, -54, -55, -57, -58, -59, -61, -63, -65, -65, -67, -69,
-71, -72, -74, -75, -77, -77, -79, -82, -82, -85, -86, -88, -87, -90, -91, -92,
-94, -96, -97, -99, -101, -102, -105, -105, -107, -108, -110, -111, -113, -114,
-117, -115, -122, -62, };