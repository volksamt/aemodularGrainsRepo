#define DATA_LENGTH 512
#define DATA AKWF_1654

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 1, 1, 3, 3, 3, 5, 4, 5, 5, 6,
8, 11, 13, 14, 16, 20, 23, 26, 30, 34, 37, 41, 46, 50, 55, 60, 66, 71, 75, 80,
84, 89, 93, 98, 102, 105, 108, 112, 115, 116, 118, 119, 120, 119, 119, 119, 119,
119, 119, 117, 115, 113, 111, 110, 106, 103, 101, 98, 95, 92, 89, 87, 83, 81,
78, 76, 74, 71, 69, 67, 65, 63, 61, 60, 58, 55, 53, 52, 49, 49, 46, 45, 43, 41,
40, 39, 36, 35, 34, 31, 30, 28, 26, 24, 23, 21, 19, 18, 15, 13, 11, 10, 9, 6, 5,
3, 1, -1, -3, -4, -5, -8, -9, -12, -14, -16, -16, -19, -21, -22, -25, -26, -28,
-30, -32, -33, -36, -38, -40, -41, -43, -45, -46, -49, -49, -52, -53, -55, -58,
-59, -62, -63, -65, -68, -68, -71, -74, -76, -78, -81, -82, -85, -87, -89, -91,
-94, -96, -96, -98, -100, -100, -100, -100, -101, -101, -100, -99, -96, -95,
-92, -90, -86, -81, -78, -72, -68, -62, -56, -50, -44, -38, -32, -25, -19, -14,
-8, -1, 4, 8, 13, 18, 22, 24, 28, 30, 31, 34, 33, 34, 35, 33, 32, 32, 31, 29,
26, 24, 22, 20, 16, 14, 10, 7, 4, 1, -3, -5, -8, -12, -13, -16, -19, -21, -24,
-26, -28, -30, -34, -35, -37, -39, -41, -43, -45, -46, -48, -48, -49, -51, -51,
-51, -52, -50, -51, -50, -49, -48, -47, -45, -43, -40, -38, -36, -33, -29, -25,
-22, -18, -16, -12, -9, -5, -1, 3, 6, 8, 11, 15, 16, 17, 20, 20, 22, 23, 24, 25,
25, 25, 24, 24, 23, 22, 21, 20, 19, 18, 17, 15, 13, 11, 11, 8, 8, 6, 4, 3, 1, 0,
-1, -3, -5, -5, -6, -8, -9, -11, -11, -13, -13, -15, -15, -16, -18, -18, -19,
-19, -19, -19, -18, -18, -17, -15, -15, -12, -11, -10, -7, -5, -2, 1, 4, 6, 9,
13, 16, 20, 23, 27, 29, 32, 36, 37, 41, 43, 46, 47, 49, 50, 51, 52, 52, 53, 53,
53, 53, 52, 52, 51, 49, 48, 47, 46, 43, 40, 39, 38, 34, 32, 28, 26, 24, 19, 16,
13, 10, 7, 2, -2, -6, -11, -16, -20, -25, -30, -35, -39, -44, -48, -53, -57,
-60, -65, -68, -72, -75, -77, -80, -82, -83, -85, -85, -86, -86, -85, -86, -85,
-84, -83, -81, -80, -77, -75, -72, -69, -66, -62, -59, -55, -51, -47, -43, -39,
-35, -29, -26, -21, -16, -11, -5, 1, 7, 13, 20, 25, 31, 37, 43, 49, 54, 60, 65,
70, 73, 77, 79, 83, 84, 85, 85, 86, 85, 84, 81, 78, 73, 69, 64, 58, 52, 45, 37,
30, 22, 15, 6, -1, -8, -16, -24, -30, -37, -43, -48, -52, -57, -60, -63, -65,
-67, -68, -67, -67, -67, -65, -64, -61, -58, -55, -52, -49, -45, -42, -38, -34,
-31, -26, -23, -21, -16, -14, -12, -9, -8, -5, -4, -4, -1, -1, 1, };