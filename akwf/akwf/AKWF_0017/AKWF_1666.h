#define DATA_LENGTH 512
#define DATA AKWF_1666

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 8, 12, 15, 19, 21, 24, 27, 31,
33, 36, 38, 40, 43, 46, 48, 50, 53, 54, 55, 58, 61, 61, 64, 66, 68, 68, 71, 71,
73, 74, 76, 77, 79, 80, 82, 83, 84, 85, 86, 87, 88, 89, 90, 91, 92, 92, 93, 94,
95, 96, 97, 97, 98, 99, 100, 100, 101, 102, 102, 103, 103, 104, 105, 104, 105,
105, 106, 107, 107, 108, 108, 108, 109, 108, 110, 109, 110, 110, 110, 111, 111,
112, 112, 112, 112, 113, 112, 114, 114, 114, 114, 114, 114, 115, 114, 115, 114,
115, 115, 115, 116, 116, 116, 116, 115, 114, 114, 112, 111, 110, 109, 108, 105,
104, 102, 99, 97, 94, 91, 87, 83, 78, 73, 66, 60, 53, 44, 35, 25, 14, 0, -12,
-23, -34, -44, -52, -59, -66, -72, -77, -82, -86, -90, -93, -97, -98, -101,
-103, -105, -107, -108, -109, -111, -112, -113, -113, -115, -115, -116, -116,
-116, -117, -118, -118, -118, -119, -118, -119, -119, -117, -116, -116, -115,
-113, -110, -108, -104, -99, -92, -84, -73, -60, -43, -22, 7, 28, 27, 27, 26,
27, 27, 26, 27, 27, 27, 27, 26, 28, 27, 26, 27, 27, 27, 26, 26, 27, 27, 27, 27,
26, 26, 27, 27, 27, 26, 27, 28, 27, 27, 27, 27, 26, 27, 28, 27, 28, 27, 26, 26,
27, 27, 27, 27, 27, 27, 27, 27, 26, 27, 27, 27, 27, 27, 26, 27, 27, 27, 27, 26,
27, 26, 27, 27, 27, 26, 26, 26, 27, 26, 27, 27, 27, 27, 26, 27, 27, 27, 26, 27,
26, 27, 26, 26, 27, 27, 27, 27, 26, 26, 27, 26, 26, 26, 26, 27, 26, 26, 26, 26,
27, 27, 26, 26, 26, 26, 27, 26, 26, 27, 26, 27, 26, 26, 26, 26, 26, 26, 27, 27,
27, 26, 27, 26, 27, 27, 27, 26, 27, 27, 27, 26, 26, 26, 26, 27, 26, 27, 27, 27,
27, 27, 26, 27, 26, 27, 26, 27, 27, 27, 26, 27, 27, 27, 27, 27, 27, 27, 27, 27,
26, 27, 27, 26, 27, 27, 26, 27, 26, 26, 26, 26, 26, 26, 27, 27, 26, 26, 26, 27,
27, 27, 26, 26, 27, 27, 27, 27, 27, 27, 26, 27, 27, 27, 27, 26, 26, 27, 26, 27,
26, 27, 26, 26, 26, 26, 27, 27, 27, 27, 26, 9, -8, -24, -38, -49, -60, -68, -76,
-82, -88, -92, -97, -100, -103, -106, -108, -110, -111, -112, -114, -115, -116,
-116, -117, -117, -119, -119, -119, -118, -119, -118, -118, -117, -117, -116,
-115, -114, -112, -112, -110, -109, -106, -104, -101, -98, -92, -90, -82, -78,
-68, -61, -49, -39, -24, -8, 12, 24, -64, -101, -93, -97, -92, -94, -91, -93,
-90, -90, -88, -89, -86, -87, -84, -83, -81, -81, -79, -78, -77, -75, -75, -73,
-71, -69, -69, -65, -65, -62, -61, -59, -57, -55, -52, -51, -49, -46, -43, -41,
-39, -36, -34, -31, -28, -25, -21, -19, -15, -12, -8, -6, -2, };