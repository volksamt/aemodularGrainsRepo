#define DATA_LENGTH 512
#define DATA AKWF_1617

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 12, 18, 23, 27, 31, 36, 38, 42, 42,
43, 42, 43, 47, 51, 57, 62, 67, 72, 77, 84, 91, 97, 99, 98, 99, 99, 99, 99, 96,
92, 88, 87, 87, 90, 92, 96, 97, 99, 101, 106, 109, 112, 109, 104, 98, 92, 88,
84, 78, 72, 64, 59, 57, 60, 62, 65, 65, 64, 63, 62, 60, 58, 54, 48, 39, 31, 25,
21, 20, 17, 14, 13, 12, 11, 11, 12, 11, 10, 8, 6, 2, 1, 1, 1, 1, 2, 2, 1, 1, 0,
-1, -2, -4, -4, -3, 1, 3, 5, 7, 6, 7, 6, 7, 7, 6, 5, 2, 1, 1, 2, 4, 4, 6, 7, 10,
15, 18, 21, 22, 22, 23, 23, 23, 23, 25, 24, 24, 23, 24, 24, 27, 28, 28, 29, 30,
33, 33, 35, 36, 35, 35, 34, 34, 33, 33, 32, 32, 31, 32, 31, 29, 28, 27, 25, 24,
21, 20, 19, 17, 17, 17, 17, 16, 16, 11, 7, 2, 3, 7, 12, 15, 16, 18, 17, 17, 17,
19, 20, 21, 23, 25, 27, 28, 29, 30, 31, 32, 33, 33, 32, 33, 34, 33, 35, 34, 36,
35, 33, 32, 31, 30, 30, 28, 27, 24, 25, 24, 22, 23, 24, 24, 24, 23, 23, 24, 23,
22, 18, 14, 10, 6, 5, 4, 3, 2, 1, 1, 2, 4, 5, 7, 7, 7, 7, 7, 6, 6, 4, 2, -2, -3,
-3, -2, 0, 1, 1, 2, 2, 1, 1, 1, 0, 1, 3, 5, 8, 10, 11, 12, 11, 12, 11, 13, 14,
16, 19, 22, 26, 31, 39, 47, 54, 58, 60, 62, 63, 65, 66, 65, 63, 60, 59, 60, 64,
70, 77, 83, 87, 92, 98, 103, 108, 111, 110, 106, 101, 99, 97, 96, 94, 90, 89,
88, 89, 93, 96, 99, 100, 99, 99, 99, 99, 96, 91, 84, 78, 72, 67, 63, 58, 53, 48,
44, 43, 42, 42, 42, 40, 35, 31, 28, 24, 19, 12, 6, -3, -10, -15, -20, -25, -30,
-35, -38, -41, -43, -46, -47, -51, -55, -58, -61, -64, -68, -73, -78, -83, -88,
-92, -95, -97, -102, -104, -107, -107, -108, -107, -107, -109, -108, -110, -110,
-111, -112, -113, -115, -117, -118, -119, -118, -118, -119, -119, -118, -115,
-111, -106, -102, -101, -98, -97, -94, -92, -91, -89, -87, -87, -85, -83, -80,
-75, -72, -69, -66, -62, -58, -52, -49, -46, -42, -38, -35, -31, -27, -26, -24,
-23, -22, -20, -17, -13, -9, -5, -2, -1, -6, -9, -13, -17, -20, -22, -24, -24,
-26, -28, -31, -35, -39, -43, -46, -49, -53, -58, -62, -66, -69, -72, -76, -81,
-83, -86, -86, -88, -90, -91, -93, -95, -98, -99, -101, -103, -106, -111, -115,
-118, -119, -119, -118, -119, -119, -118, -117, -114, -112, -112, -111, -111,
-110, -109, -108, -107, -108, -109, -108, -107, -104, -102, -98, -95, -91, -88,
-83, -77, -71, -68, -64, -61, -58, -54, -51, -47, -45, -43, -41, -37, -33, -28,
-24, -20, -15, -9, -2, };