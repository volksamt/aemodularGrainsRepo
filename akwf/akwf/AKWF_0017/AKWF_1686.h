#define DATA_LENGTH 512
#define DATA AKWF_1686

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 3, 4, 8, 9, 13, 17, 21, 25, 28, 31,
35, 38, 42, 45, 48, 51, 54, 58, 60, 61, 63, 66, 68, 70, 71, 73, 74, 76, 78, 78,
79, 80, 81, 82, 82, 82, 83, 84, 84, 84, 85, 86, 85, 86, 85, 85, 85, 86, 85, 85,
85, 85, 84, 84, 84, 85, 84, 83, 83, 84, 83, 84, 83, 83, 83, 83, 82, 83, 81, 82,
82, 82, 81, 81, 81, 80, 80, 80, 80, 80, 79, 79, 79, 79, 78, 78, 78, 77, 77, 77,
75, 76, 76, 75, 75, 73, 73, 73, 72, 71, 71, 71, 70, 69, 69, 68, 67, 66, 65, 65,
64, 63, 62, 61, 60, 60, 59, 58, 57, 57, 55, 54, 54, 53, 51, 51, 50, 49, 49, 48,
47, 45, 45, 44, 43, 43, 41, 41, 39, 39, 37, 37, 37, 35, 35, 33, 32, 31, 30, 31,
29, 29, 27, 27, 25, 25, 24, 23, 22, 22, 20, 19, 19, 18, 17, 16, 15, 14, 13, 12,
12, 11, 10, 9, 8, 8, 7, 6, 5, 3, 3, 1, 1, 0, -2, -3, -3, -4, -5, -6, -7, -8,
-10, -10, -11, -12, -14, -14, -16, -16, -18, -18, -19, -20, -22, -22, -24, -24,
-26, -27, -28, -29, -30, -31, -31, -32, -34, -35, -36, -37, -38, -39, -40, -41,
-42, -43, -43, -45, -46, -46, -47, -47, -48, -50, -50, -51, -52, -52, -53, -54,
-55, -56, -56, -58, -58, -59, -59, -60, -60, -61, -62, -62, -62, -63, -64, -65,
-65, -66, -66, -66, -67, -68, -67, -68, -69, -70, -69, -69, -70, -70, -71, -72,
-71, -71, -72, -73, -73, -73, -73, -73, -74, -74, -74, -74, -75, -74, -74, -76,
-76, -75, -75, -76, -76, -76, -77, -77, -76, -76, -77, -77, -77, -78, -77, -77,
-77, -77, -78, -78, -78, -78, -78, -79, -79, -78, -78, -79, -79, -79, -79, -79,
-79, -79, -79, -80, -79, -79, -80, -79, -79, -79, -80, -79, -80, -79, -79, -80,
-79, -79, -79, -79, -80, -80, -80, -80, -78, -80, -80, -78, -79, -79, -79, -78,
-79, -78, -78, -77, -77, -78, -77, -77, -77, -77, -76, -76, -76, -77, -75, -76,
-75, -75, -74, -74, -74, -73, -73, -72, -72, -73, -72, -72, -71, -71, -70, -69,
-69, -68, -68, -68, -67, -67, -66, -66, -65, -64, -65, -64, -63, -62, -62, -61,
-60, -61, -60, -60, -61, -61, -62, -62, -63, -65, -65, -66, -67, -68, -69, -71,
-72, -73, -76, -78, -80, -82, -84, -86, -87, -89, -90, -92, -94, -96, -98, -98,
-101, -102, -104, -105, -106, -108, -108, -110, -111, -112, -113, -114, -114,
-115, -116, -116, -118, -117, -118, -118, -119, -118, -118, -119, -119, -119,
-119, -118, -118, -117, -117, -117, -116, -115, -114, -112, -111, -111, -109,
-108, -105, -105, -102, -101, -99, -97, -96, -93, -91, -89, -86, -84, -82, -80,
-77, -74, -71, -69, -66, -63, -61, -58, -56, -52, -49, -47, -43, -41, -38, -37,
-33, -30, -28, -25, -23, -21, -17, -16, -12, };