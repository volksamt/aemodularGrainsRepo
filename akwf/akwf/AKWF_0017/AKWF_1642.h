#define DATA_LENGTH 512
#define DATA AKWF_1642

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 1, 1, 2, 1, 2, 2, 2, 4, 4, 5, 5,
5, 5, 6, 5, 7, 6, 7, 8, 7, 8, 8, 8, 9, 9, 10, 10, 10, 10, 11, 11, 11, 11, 12,
11, 12, 12, 13, 14, 17, 18, 19, 20, 21, 21, 22, 24, 24, 26, 26, 27, 28, 29, 30,
31, 33, 33, 34, 35, 36, 38, 38, 39, 39, 41, 41, 43, 42, 44, 44, 45, 46, 47, 47,
48, 50, 50, 50, 51, 52, 53, 54, 54, 54, 55, 56, 58, 59, 59, 61, 62, 63, 64, 64,
66, 66, 68, 68, 69, 69, 71, 72, 74, 74, 75, 76, 78, 78, 78, 79, 80, 81, 83, 82,
83, 84, 84, 85, 87, 87, 89, 89, 91, 91, 92, 93, 93, 94, 94, 95, 96, 96, 98, 98,
100, 100, 101, 102, 103, 103, 104, 105, 106, 106, 108, 108, 109, 109, 109, 110,
112, 112, 112, 114, 114, 115, 116, 117, 117, 118, 118, 119, 119, 119, 114, 107,
100, 92, 84, 77, 70, 65, 58, 53, 48, 43, 38, 33, 28, 24, 19, 16, 13, 9, 5, 3, 0,
-4, -6, -8, -11, -14, -16, -18, -19, -22, -23, -26, -27, -28, -29, -31, -32,
-33, -32, -34, -36, -35, -37, -37, -38, -39, -40, -40, -41, -41, -42, -42, -43,
-44, -44, -44, -44, -44, -45, -45, -45, -46, -46, -46, -47, -46, -47, -46, -47,
-47, -48, -48, -47, -48, -48, -47, -48, -47, -48, -49, -47, -48, -48, -48, -48,
-48, -48, -47, -48, -48, -47, -48, -48, -47, -48, -48, -47, -48, -48, -48, -48,
-48, -47, -47, -47, -46, -47, -47, -47, -47, -46, -46, -47, -45, -46, -46, -45,
-45, -46, -45, -45, -45, -45, -44, -44, -44, -44, -44, -44, -43, -44, -42, -43,
-43, -43, -42, -43, -42, -42, -42, -42, -41, -41, -41, -41, -40, -40, -41, -40,
-40, -40, -40, -40, -40, -40, -39, -39, -40, -39, -39, -38, -38, -39, -39, -38,
-37, -37, -38, -37, -38, -37, -37, -37, -38, -37, -36, -37, -36, -36, -36, -35,
-36, -35, -36, -35, -35, -35, -36, -35, -35, -35, -34, -34, -34, -33, -33, -34,
-34, -34, -34, -33, -33, -33, -33, -32, -32, -33, -33, -32, -33, -32, -33, -33,
-33, -34, -33, -33, -32, -33, -33, -33, -34, -33, -33, -33, -33, -33, -32, -33,
-33, -32, -32, -33, -32, -33, -32, -32, -32, -32, -31, -31, -31, -30, -30, -29,
-28, -27, -28, -27, -27, -26, -26, -25, -26, -26, -25, -25, -25, -25, -24, -25,
-24, -24, -24, -24, -24, -25, -24, -25, -23, -24, -23, -23, -23, -23, -23, -23,
-23, -23, -22, -22, -21, -22, -22, -22, -22, -21, -21, -21, -21, -21, -21, -21,
-21, -20, -20, -19, -20, -18, -19, -19, -18, -18, -18, -17, -15, -15, -15, -14,
-13, -12, -12, -12, -12, -10, -9, -9, -9, -8, -9, -7, -7, -7, -7, -7, -6, -6,
-5, -6, -5, -5, -4, -4, -4, -3, -3, -3, -3, -2, -1, -2, -1, 0, 0, };