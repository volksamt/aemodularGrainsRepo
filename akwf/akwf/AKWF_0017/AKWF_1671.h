#define DATA_LENGTH 512
#define DATA AKWF_1671

const PROGMEM int8_t DATA[DATA_LENGTH] = {31, 44, 47, 53, 55, 59, 60, 64, 65,
68, 67, 69, 70, 71, 71, 71, 72, 52, 42, 39, 34, 34, 31, 30, 27, 27, 24, 24, 22,
20, 19, 18, 17, 16, 15, 15, 15, 12, 13, 12, 11, 10, 10, 9, 8, 8, 7, 7, 7, 6, 6,
6, 5, 5, 5, 3, 4, 3, 4, 3, 2, 3, 2, 2, 2, 1, 1, 2, 1, 1, 0, 1, 0, 0, 1, -1, -1,
0, 0, 0, -1, 0, -1, -1, -1, -1, 0, 0, 1, -1, 0, 0, 0, 0, -1, 0, 0, -1, 1, 0, 0,
0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, -1, 0, 0, -1, 1, 0, 1, 1, -1, 1, 0, 0, 0, 0,
-1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1,
0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, -1, 1,
0, 0, -1, -1, 1, -1, -1, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0,
1, 0, 1, -2, 4, -23, -46, -48, -56, -57, -62, -64, -68, -69, -73, -74, -77, -79,
-81, -81, -84, -84, -86, -88, -88, -90, -91, -92, -94, -95, -95, -96, -97, -99,
-99, -100, -101, -101, -103, -103, -104, -106, -105, -106, -106, -107, -108,
-108, -110, -110, -111, -111, -112, -112, -112, -113, -113, -114, -113, -115,
-115, -115, -115, -116, -115, -116, -116, -117, -117, -118, -118, -118, -118,
-119, -118, -119, -118, -118, -118, -119, -118, -119, -119, -119, -120, -118,
-122, -86, -65, -62, -53, -51, -45, -44, -39, -37, -33, -31, -29, -27, -25, -23,
-22, -20, -19, -17, -15, -14, -13, -11, -12, -10, -10, -8, -8, -7, -5, -6, -4,
-4, -3, -2, -3, -2, -2, -1, -1, -1, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, -1, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 0,
0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, -1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, -1, -1, 0, 1, 0, 0, 0, 1, 0, 1,
-1, 1, -2, 1, -1, 1, -2, 3, -5, 20, 87, 52, 30, 26, 20, 17, 11, 10, 7, 6, 2, 3,
1, 1, 0, 1, 1, 2, 1, 2, 2, 2, 3, 3, 2, 3, 2, 3, 3, 2, 3, 2, 3, 2, 2, 2, 2, 2, 2,
2, 2, 2, 3, 2, 3, 2, 2, 2, 1, 3, 2, 1, 1, 2, 1, 1, 1, 1, 2, 1, 1, 0, 1, 1, 1, 1,
1, 0, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, };