#define DATA_LENGTH 512
#define DATA AKWF_1689

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 8, 10, 13, 15, 18, 20, 23,
26, 28, 30, 32, 35, 38, 40, 42, 44, 46, 49, 50, 53, 55, 56, 59, 60, 62, 64, 66,
68, 70, 71, 72, 74, 76, 78, 79, 81, 82, 84, 84, 85, 88, 88, 90, 90, 92, 93, 94,
95, 96, 96, 97, 98, 98, 99, 100, 99, 100, 101, 101, 102, 102, 102, 101, 102,
102, 103, 103, 103, 103, 103, 102, 101, 102, 101, 100, 100, 100, 99, 98, 97, 97,
96, 95, 95, 94, 93, 92, 91, 90, 89, 89, 87, 86, 85, 83, 83, 81, 80, 79, 77, 77,
75, 74, 72, 70, 69, 67, 66, 65, 63, 62, 61, 59, 57, 56, 55, 53, 52, 51, 50, 48,
47, 45, 43, 43, 41, 40, 39, 37, 36, 34, 34, 32, 31, 31, 29, 29, 28, 26, 26, 24,
24, 22, 22, 22, 21, 20, 20, 19, 18, 18, 17, 16, 15, 15, 15, 15, 14, 15, 14, 14,
14, 14, 13, 14, 13, 13, 13, 12, 13, 14, 14, 14, 14, 14, 14, 15, 15, 15, 16, 16,
17, 17, 18, 17, 19, 19, 20, 20, 22, 22, 22, 23, 24, 24, 25, 25, 26, 27, 28, 29,
30, 30, 31, 31, 32, 32, 33, 34, 36, 36, 37, 38, 38, 39, 39, 39, 41, 42, 41, 43,
43, 43, 44, 44, 45, 47, 46, 47, 47, 48, 49, 49, 49, 50, 50, 50, 51, 51, 51, 51,
51, 51, 52, 52, 51, 52, 51, 52, 52, 52, 50, 51, 51, 51, 51, 50, 49, 49, 49, 49,
49, 48, 48, 47, 47, 47, 45, 45, 46, 44, 44, 43, 43, 42, 42, 41, 40, 40, 39, 38,
38, 37, 36, 35, 34, 34, 34, 32, 31, 30, 31, 30, 29, 28, 28, 27, 26, 26, 24, 23,
22, 22, 22, 20, 20, 20, 18, 18, 17, 17, 15, 15, 15, 13, 13, 13, 11, 11, 10, 10,
9, 9, 8, 7, 6, 6, 5, 4, 4, 3, 3, 1, 1, 1, 0, -1, -2, -2, -3, -3, -4, -5, -6, -7,
-7, -8, -9, -9, -10, -11, -13, -13, -14, -15, -15, -17, -18, -18, -19, -20, -21,
-23, -23, -24, -25, -27, -28, -30, -32, -32, -33, -35, -36, -38, -39, -40, -41,
-42, -44, -45, -47, -48, -50, -51, -53, -54, -56, -58, -59, -61, -62, -64, -65,
-68, -68, -71, -72, -74, -76, -78, -79, -81, -81, -84, -86, -87, -89, -91, -91,
-93, -94, -95, -97, -98, -99, -101, -102, -104, -105, -106, -108, -109, -109,
-110, -111, -112, -113, -113, -115, -115, -115, -117, -118, -117, -117, -118,
-118, -119, -119, -119, -119, -120, -119, -119, -118, -119, -118, -118, -117,
-116, -116, -116, -115, -114, -112, -112, -110, -109, -108, -107, -106, -105,
-103, -101, -101, -99, -98, -96, -94, -92, -91, -88, -88, -84, -83, -81, -79,
-76, -75, -72, -70, -68, -65, -63, -61, -58, -55, -53, -51, -49, -46, -44, -41,
-39, -37, -34, -30, -29, -25, -23, -20, -18, -15, -12, -9, -7, -4, -2, };