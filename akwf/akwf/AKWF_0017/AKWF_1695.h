#define DATA_LENGTH 512
#define DATA AKWF_1695

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 9, 12, 15, 18, 21, 24, 26, 29,
31, 35, 36, 39, 40, 42, 44, 45, 47, 49, 51, 52, 53, 54, 54, 55, 55, 56, 56, 57,
57, 57, 57, 56, 57, 57, 56, 56, 57, 55, 56, 56, 55, 54, 54, 54, 53, 52, 53, 52,
52, 51, 51, 50, 50, 49, 49, 49, 48, 48, 47, 46, 46, 46, 46, 45, 44, 43, 43, 43,
42, 42, 41, 41, 41, 40, 39, 39, 39, 39, 37, 38, 37, 37, 37, 38, 37, 37, 37, 37,
38, 37, 38, 38, 38, 38, 39, 40, 40, 41, 41, 42, 42, 44, 44, 46, 47, 48, 48, 49,
51, 51, 53, 55, 56, 57, 58, 59, 61, 62, 62, 64, 67, 67, 69, 70, 73, 75, 75, 78,
79, 80, 82, 83, 84, 86, 87, 88, 89, 89, 89, 89, 89, 87, 85, 84, 82, 80, 78, 75,
73, 69, 66, 64, 60, 57, 53, 50, 47, 43, 39, 36, 32, 30, 26, 23, 20, 17, 14, 11,
9, 8, 6, 4, 2, 1, 0, -2, -2, -3, -3, -3, -3, -3, -3, -2, -1, -1, 1, 2, 3, 4, 6,
8, 9, 12, 14, 17, 19, 21, 23, 26, 28, 31, 33, 36, 38, 39, 40, 43, 44, 45, 45,
46, 45, 44, 43, 41, 39, 38, 37, 35, 31, 30, 28, 24, 21, 19, 16, 14, 10, 7, 5, 2,
-1, -2, -4, -7, -8, -11, -12, -12, -14, -16, -16, -16, -17, -17, -18, -17, -17,
-16, -15, -15, -15, -13, -12, -11, -10, -8, -7, -6, -4, -2, 0, 2, 4, 6, 8, 10,
13, 16, 17, 20, 21, 24, 27, 28, 31, 32, 34, 36, 37, 38, 39, 41, 41, 41, 41, 41,
40, 39, 38, 36, 36, 34, 32, 31, 29, 26, 23, 22, 19, 16, 13, 10, 7, 4, 0, -3, -5,
-9, -11, -14, -18, -21, -24, -27, -29, -32, -35, -37, -40, -43, -45, -47, -49,
-52, -54, -56, -58, -59, -60, -63, -65, -66, -67, -69, -71, -72, -73, -75, -76,
-77, -78, -80, -81, -82, -83, -85, -85, -86, -88, -89, -90, -91, -92, -93, -95,
-95, -96, -97, -98, -99, -100, -101, -101, -103, -104, -105, -105, -106, -107,
-109, -110, -110, -110, -111, -112, -113, -114, -116, -116, -116, -117, -117,
-117, -119, -119, -119, -119, -119, -119, -119, -118, -116, -117, -115, -113,
-111, -110, -107, -105, -102, -99, -97, -94, -91, -87, -84, -80, -76, -73, -69,
-66, -61, -57, -53, -50, -45, -42, -38, -35, -31, -28, -24, -20, -19, -15, -13,
-10, -7, -5, -2, 0, 2, 4, 5, 5, 7, 8, 9, 10, 11, 11, 12, 12, 12, 12, 11, 11, 11,
11, 10, 9, 8, 6, 6, 4, 3, 1, 1, -1, -2, -5, -5, -7, -10, -11, -13, -14, -17,
-20, -21, -23, -25, -28, -29, -32, -34, -35, -38, -39, -42, -43, -44, -46, -47,
-48, -49, -49, -48, -48, -47, -45, -44, -42, -42, -39, -37, -34, -33, -29, -27,
-24, -20, -16, -14, -11, -7, -4, -1, };