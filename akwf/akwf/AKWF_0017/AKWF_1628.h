#define DATA_LENGTH 512
#define DATA AKWF_1628

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 6, 8, 9, 10, 12, 14, 15, 17,
19, 21, 22, 23, 25, 27, 29, 29, 31, 34, 35, 37, 37, 39, 42, 43, 44, 46, 47, 49,
51, 52, 54, 56, 57, 58, 60, 62, 63, 65, 67, 68, 69, 71, 72, 75, 76, 78, 79, 80,
82, 84, 85, 87, 88, 90, 92, 93, 94, 96, 98, 100, 101, 103, 104, 106, 107, 110,
111, 113, 114, 117, 117, 118, 119, 117, 116, 113, 113, 111, 109, 106, 106, 103,
103, 100, 101, 96, 98, 92, 94, 88, 94, 75, -13, -21, -16, -20, -18, -19, -19,
-19, -19, -18, -18, -19, -18, -18, -18, -19, -19, -19, -18, -18, -18, -18, -18,
-19, -19, -19, -18, -19, -19, -19, -19, -19, -19, -19, -19, -19, -19, -19, -19,
-19, -19, -19, -19, -19, -19, -19, -19, -19, -19, -19, -18, -18, -18, -18, -19,
-18, -19, -18, -20, -18, -20, -18, -21, -17, -22, -15, -24, -13, -29, -53, -11,
-22, -17, -19, -19, -19, -18, -17, -19, -17, -19, -17, -19, -17, -19, -17, -19,
-17, -18, -18, -18, -18, -19, -18, -18, -17, -17, -17, -18, -17, -17, -18, -17,
-18, -18, -17, -17, -18, -18, -18, -17, -17, -18, -18, -17, -18, -18, -18, -17,
-17, -18, -17, -19, -17, -18, -17, -18, -18, -17, -17, -18, -17, -17, -18, -18,
-18, -18, -18, -18, -18, -18, -17, -17, -18, -18, -18, -18, -17, -17, -18, -17,
-17, -17, -17, -18, -17, -17, -18, -18, -18, -17, -17, -17, -18, -18, -17, -18,
-18, -17, -17, -17, -17, -17, -17, -18, -18, -18, -18, -18, -18, -17, -17, -18,
-17, -17, -17, -17, -17, -17, -18, -18, -17, -18, -17, -18, -18, -17, -17, -18,
-17, -18, -18, -18, -17, -17, -17, -17, -17, -18, -17, -18, -17, -18, -17, -17,
-18, -17, -18, -18, -18, -18, -18, -17, -14, -13, -12, -11, -9, -7, -6, -4, -2,
0, 0, 3, 4, 6, 7, 10, 11, 12, 14, 15, 17, 18, 20, 22, 23, 24, 28, 27, 35, 11,
-23, -17, -17, -17, -18, -17, -17, -17, -17, -18, -17, -18, -18, -18, -16, -18,
-17, -17, -18, -17, -17, -18, -17, -18, -17, -18, -17, -18, -17, -17, -17, -17,
-17, -17, -17, -18, -18, -17, -17, -17, -17, -17, -17, -18, -18, -17, -17, -18,
-17, -17, -18, -18, -17, -17, -18, -18, -18, -17, -18, -17, -17, -17, -17, -17,
-18, -17, -17, -17, -18, -17, -17, -17, -18, -18, -17, -17, -17, -17, -17, -17,
-17, -17, -17, -17, -17, -18, -17, -17, -17, -18, -17, -17, -17, -17, -17, -17,
-17, -17, -17, -18, -17, -17, -16, -17, -17, -17, -17, -17, -17, -17, -17, -17,
-17, -18, -17, -17, -18, -17, -17, -18, -17, -16, -17, -17, -16, -17, -18, -17,
-17, -17, -16, -17, -18, -17, -17, -16, -17, -17, -17, -17, -17, -18, -17, -17,
-17, -17, -17, -17, -17, -17, -17, -18, -16, -15, -15, -13, -11, -10, -8, -7,
-5, -3, -2, 0, };