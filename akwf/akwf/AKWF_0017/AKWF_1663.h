#define DATA_LENGTH 512
#define DATA AKWF_1663

const PROGMEM int8_t DATA[DATA_LENGTH] = {15, 24, 4, 19, 25, 36, 43, 50, 57, 62,
68, 73, 78, 81, 85, 88, 91, 93, 96, 98, 100, 101, 104, 105, 106, 107, 109, 110,
111, 111, 111, 114, 113, 114, 115, 115, 115, 116, 116, 116, 117, 117, 117, 117,
118, 118, 118, 118, 119, 118, 119, 118, 118, 119, 118, 119, 119, 119, 118, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 117,
118, 118, 117, 117, 117, 117, 116, 116, 116, 116, 116, 115, 114, 113, 114, 113,
112, 112, 111, 109, 109, 107, 107, 105, 103, 102, 101, 100, 97, 94, 92, 89, 86,
83, 79, 75, 71, 66, 60, 53, 47, 39, 31, 22, 12, 0, -10, -10, -10, -10, -10, -10,
-10, -10, -11, -10, -10, -11, -10, -11, -10, -10, -10, -10, -11, -11, -11, -11,
-11, -11, -10, -11, -11, -11, -11, -11, -11, -11, -11, -11, -11, -11, -11, -11,
-11, -10, -11, -11, -11, -10, -11, -10, -11, -11, -11, -10, -11, -11, -11, -10,
-11, -11, -10, -11, -10, -10, -11, -11, -11, -11, -10, -11, -11, -11, -11, -11,
-11, -11, -11, -11, -11, -11, -10, -11, -10, -10, -11, -11, -10, -11, -10, -11,
-11, -10, -10, -11, -11, -10, -11, -10, -11, -10, -10, -11, -11, -11, -11, -11,
-11, -11, -11, -11, -11, -10, -10, -11, -11, -11, -11, -10, -11, -11, -11, -11,
-11, -10, -10, -10, -11, -10, -10, -10, -11, -10, -11, -10, -10, -10, -10, -10,
-11, -11, -10, -11, -10, -10, -10, -11, -10, -11, -10, -11, -11, -11, -11, -10,
-10, -11, -10, -11, -11, -11, -10, -11, -10, -10, -10, -11, -10, -10, -10, -10,
-10, -10, -11, -11, -10, -11, -11, -11, -11, -11, -10, -11, -10, -10, -10, -10,
-11, -11, -10, -11, -11, -10, -11, -11, -10, -11, -10, -10, -10, -11, -11, -11,
-10, -11, -11, -10, -10, -10, -11, -10, -10, -10, -11, -11, -11, -11, -11, -10,
-10, -10, -10, -10, -11, -10, -10, -11, -10, -10, -11, -11, -11, -10, -11, -10,
-10, -11, -10, -11, -11, -10, -11, -10, -10, -10, -10, -11, -11, -10, -10, -11,
-10, -11, -11, -10, -10, -10, -11, -10, -10, -10, -11, -11, -11, -10, -10, -11,
-10, -11, -10, -11, -10, -11, -10, -10, -14, -27, -33, -43, -49, -57, -62, -68,
-72, -76, -82, -83, -95, -35, -20, -39, -39, -52, -54, -63, -64, -72, -75, -80,
-83, -87, -88, -92, -94, -97, -99, -100, -102, -104, -105, -106, -107, -108,
-110, -110, -112, -112, -114, -113, -114, -113, -115, -114, -115, -116, -116,
-117, -117, -117, -118, -118, -118, -117, -118, -118, -118, -118, -118, -119,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -118, -119, -118, -119, -117, -118,
-116, -118, -116, -118, -116, -118, -114, -117, -114, -116, -113, -115, -113,
-113, -113, -110, -112, -2, 17, 26, 34, 47, 46, 70, 30, -83, -49, -47, -24, -8,
};