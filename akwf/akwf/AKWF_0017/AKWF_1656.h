#define DATA_LENGTH 512
#define DATA AKWF_1656

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 32, 53, 71, 86, 98, 107, 111, 115,
115, 114, 110, 105, 97, 90, 82, 76, 69, 65, 61, 57, 53, 49, 44, 40, 35, 30, 25,
20, 16, 11, 6, 3, -2, -8, -12, -17, -21, -26, -31, -35, -40, -44, -47, -52, -57,
-64, -71, -77, -85, -90, -94, -96, -96, -94, -89, -81, -69, -53, -34, -10, 12,
32, 48, 58, 62, 60, 53, 44, 31, 16, -2, -20, -40, -56, -68, -74, -73, -69, -61,
-52, -42, -31, -23, -14, -5, 4, 11, 18, 22, 26, 30, 30, 30, 26, 22, 17, 9, 4,
-4, -10, -16, -22, -26, -28, -29, -26, -21, -14, -7, 3, 13, 21, 31, 41, 49, 55,
58, 57, 52, 46, 38, 31, 23, 17, 12, 9, 3, -5, -15, -30, -47, -63, -79, -92, -98,
-101, -96, -89, -77, -65, -52, -38, -23, -6, 10, 26, 42, 59, 76, 90, 99, 102,
97, 84, 62, 37, 11, -16, -39, -57, -74, -86, -93, -97, -92, -82, -66, -46, -24,
-1, 20, 40, 60, 77, 94, 106, 114, 116, 117, 113, 109, 103, 98, 93, 88, 81, 75,
69, 64, 60, 54, 50, 46, 42, 38, 34, 27, 24, 19, 14, 9, 5, -1, -5, -10, -14, -18,
-23, -28, -33, -37, -42, -47, -51, -55, -60, -65, -71, -77, -85, -92, -98, -100,
-98, -93, -84, -73, -57, -41, -23, -6, 14, 34, 49, 61, 65, 63, 54, 40, 23, 4,
-13, -28, -45, -57, -67, -75, -76, -72, -63, -52, -38, -24, -13, -4, 4, 9, 14,
18, 20, 24, 26, 27, 27, 26, 22, 16, 9, 1, -7, -14, -20, -24, -27, -28, -28, -25,
-20, -12, -2, 9, 20, 30, 38, 44, 49, 52, 53, 52, 50, 46, 41, 34, 26, 18, 9, 0,
-8, -16, -26, -37, -48, -62, -75, -87, -96, -100, -99, -93, -82, -67, -49, -33,
-14, 4, 24, 42, 57, 70, 80, 89, 92, 93, 88, 76, 58, 34, 5, -23, -50, -71, -86,
-93, -95, -92, -83, -72, -57, -37, -18, 5, 28, 47, 66, 83, 95, 107, 115, 118,
119, 116, 110, 103, 95, 87, 82, 76, 72, 67, 63, 58, 55, 49, 45, 41, 36, 31, 27,
22, 17, 12, 8, 3, -2, -7, -11, -16, -20, -25, -30, -34, -39, -43, -48, -53, -59,
-64, -69, -75, -81, -85, -91, -96, -97, -98, -94, -84, -71, -52, -31, -11, 9,
26, 39, 51, 58, 61, 59, 51, 37, 19, -1, -21, -40, -53, -63, -68, -70, -69, -66,
-59, -50, -38, -27, -13, -2, 8, 15, 19, 23, 25, 26, 27, 26, 25, 22, 18, 13, 6,
0, -8, -15, -23, -27, -29, -29, -27, -23, -17, -9, -1, 11, 22, 34, 44, 51, 54,
54, 52, 48, 43, 39, 34, 29, 26, 20, 13, 5, -7, -21, -35, -51, -64, -74, -83,
-88, -91, -92, -88, -83, -73, -62, -47, -31, -13, 5, 25, 46, 65, 82, 93, 99, 98,
91, 78, 61, 41, 21, -2, -29, -52, -75, -90, -99, -100, -93, -80, -64, -45, -26,
-6, };