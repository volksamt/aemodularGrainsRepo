#define DATA_LENGTH 512
#define DATA AKWF_1630

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 10, 14, 18, 22, 26, 31, 34, 39,
42, 47, 50, 55, 57, 63, 66, 71, 74, 80, 82, 88, 90, 97, 97, 108, 83, -72, -127,
-112, -114, -106, -106, -99, -97, -90, -90, -83, -80, -76, -72, -68, -64, -60,
-56, -52, -48, -44, -39, -36, -32, -29, -24, -21, -16, -9, -6, -8, -7, -7, -7,
-8, -6, -7, -6, -7, -7, -7, -7, -7, -7, -7, -8, -7, -6, -8, -7, -7, -7, -7, -7,
-6, -7, -7, -6, -7, -7, -7, -7, -7, -8, -6, -8, -7, -7, -7, -8, -7, -8, -6, -8,
-6, -8, -5, -8, -5, -9, -4, -10, -3, -11, -2, 97, 106, 100, 99, 93, 91, 85, 83,
77, 76, 70, 68, 63, 60, 55, 53, 49, 45, 41, 38, 33, 30, 25, 23, 18, 15, 11, 7,
4, -1, -7, -8, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -6, -6, -7, -7,
-7, -7, -7, -8, -7, -7, -6, -7, -7, -7, -8, -8, -7, -7, -7, -7, -7, -7, -8, -6,
-7, -7, -7, -7, -7, -6, -7, -7, -7, -7, -7, -7, -7, -8, -7, -7, -7, -7, -7, -7,
-8, -8, -8, -8, -8, -7, -8, -8, -8, -7, -7, -7, -7, -7, -7, -6, -7, -7, -6, -7,
-8, -7, -7, -6, -7, -7, -8, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -8, -7,
-7, -7, -7, -7, -7, -7, -8, -6, -7, -8, -8, -7, -8, -7, -7, -7, -7, -8, -7, -7,
-7, -6, -6, -7, -7, -7, -7, -7, -6, -7, -7, -7, -7, -7, -8, -6, -8, -6, -8, -6,
-8, -6, -7, -6, -8, -6, -8, -6, -8, -6, -8, -6, -7, -7, -5, -14, 84, 111, 98,
101, 92, 93, 85, 84, 78, 76, 71, 69, 63, 61, 57, 53, 49, 47, 42, 39, 35, 31, 27,
23, 20, 16, 12, 8, 5, 1, -6, -8, -7, -7, -6, -7, -6, -7, -7, -7, -7, -7, -6, -8,
-8, -7, -7, -7, -7, -7, -6, -7, -7, -7, -7, -7, -7, -7, -7, -7, -8, -7, -7, -7,
-7, -7, -8, -7, -8, -8, -7, -7, -7, -8, -7, -7, -7, -7, -7, -8, -7, -6, -7, -8,
-6, -7, -7, -7, -7, -8, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -6, -8, -7,
-7, -8, -7, -7, -7, -7, -7, -8, -7, -7, -7, -7, -7, -8, -7, -7, -7, -7, -8, -7,
-7, -7, -7, -7, -6, -7, -7, -7, -7, -7, -7, -7, -7, -8, -8, -7, -6, -7, -7, -7,
-7, -7, -7, -6, -7, -7, -7, -7, -7, -8, -8, -8, -7, -7, -7, -7, -7, -7, -7, -8,
-7, -7, -7, -7, -7, -7, -7, -6, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7, -7,
-8, -6, -7, -7, -7, -8, -6, -8, -7, -7, -7, -7, -7, -8, -7, -8, -7, -7, -7, -7,
-7, -6, -7, -7, -7, -7, -7, -7, -8, -7, -6, -1, };