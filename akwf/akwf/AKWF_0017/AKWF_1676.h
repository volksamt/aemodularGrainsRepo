#define DATA_LENGTH 512
#define DATA AKWF_1676

const PROGMEM int8_t DATA[DATA_LENGTH] = {52, 119, 115, 116, 116, 117, 116, 117,
116, 117, 117, 116, 117, 116, 117, 116, 116, 116, 116, 115, 117, 116, 117, 117,
117, 116, 116, 116, 116, 117, 116, 116, 116, 116, 116, 116, 116, 116, 117, 116,
115, 116, 117, 117, 116, 117, 117, 117, 117, 117, 117, 118, 117, 117, 116, 118,
116, 117, 116, 117, 116, 115, 120, 94, 19, -77, -103, -95, -100, -97, -98, -97,
-99, -98, -98, -97, -98, -98, -98, -99, -98, -99, -98, -98, -98, -99, -98, -98,
-98, -98, -98, -98, -98, -98, -99, -98, -98, -99, -98, -99, -98, -98, -98, -99,
-98, -98, -99, -98, -99, -98, -99, -99, -99, -98, -99, -99, -100, -99, -99, -99,
-98, -99, -98, -99, -98, -99, -99, -98, -99, -99, -99, -99, -99, -99, -99, -99,
-98, -98, -98, -99, -99, -99, -99, -99, -99, -98, -100, -99, -99, -99, -99, -98,
-98, -99, -99, -99, -99, -99, -99, -99, -99, -100, -98, -100, -99, -99, -99,
-99, -99, -99, -99, -99, -99, -99, -99, -99, -99, -99, -99, -100, -99, -100,
-100, -99, -99, -99, -100, -98, -100, -97, -100, -105, -98, -99, -98, -97, -98,
-97, -98, -98, -98, -98, -98, -98, -98, -98, -98, -98, -98, -98, -98, -98, -97,
-98, -98, -99, -97, -99, -98, -100, -97, -74, -51, -49, -49, -49, -49, -50, -49,
-49, -49, -49, -50, -49, -49, -50, -50, -38, -19, -16, -16, -15, -16, -16, -16,
-15, -15, -15, -15, -16, -16, -17, -11, 7, 15, 15, 15, 15, 15, 15, 14, 15, 15,
15, 14, 14, 15, 14, 16, 29, 38, 38, 38, 38, 39, 39, 39, 38, 39, 39, 39, 38, 38,
38, 38, 45, 51, 52, 52, 52, 52, 53, 52, 52, 52, 52, 53, 52, 53, 53, 52, 56, 63,
66, 65, 65, 66, 66, 66, 66, 66, 66, 65, 65, 66, 65, 69, 80, 85, 86, 86, 87, 86,
86, 85, 86, 85, 87, 85, 88, 83, 94, 101, 58, 45, 47, 46, 46, 47, 47, 46, 46, 47,
47, 46, 47, 46, 47, 45, 44, 43, 44, 43, 43, 44, 44, 43, 44, 43, 44, 44, 43, 43,
43, 41, 38, 38, 38, 39, 38, 39, 39, 39, 39, 38, 39, 38, 39, 38, 39, 38, 37, 37,
37, 36, 37, 37, 37, 37, 37, 36, 37, 37, 36, 37, 37, 36, 33, 32, 31, 32, 31, 32,
32, 32, 32, 32, 32, 32, 32, 32, 31, 30, 31, 30, 30, 29, 31, 30, 30, 30, 31, 30,
30, 31, 30, 30, 31, 30, 30, 30, 30, 30, 30, 31, 30, 30, 30, 30, 30, 30, 31, 30,
31, 30, 29, 29, 29, 29, 29, 29, 28, 28, 28, 28, 28, 28, 29, 29, 29, 27, 25, 23,
24, 23, 24, 24, 24, 24, 24, 23, 24, 24, 24, 25, 23, 17, 13, 12, 11, 13, 12, 12,
12, 12, 13, 12, 12, 12, 11, 12, 12, 9, 5, 5, 4, 4, 6, 5, 5, 5, 5, 4, 5, 5, 5, 4,
11, -22, -77, -102, -50, };