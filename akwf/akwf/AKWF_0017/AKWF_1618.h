#define DATA_LENGTH 512
#define DATA AKWF_1618

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 11, 17, 25, 34, 43, 51, 59, 68, 77,
85, 93, 101, 107, 112, 115, 119, 119, 119, 117, 114, 110, 107, 101, 96, 88, 82,
74, 68, 62, 59, 57, 55, 54, 53, 51, 52, 50, 48, 48, 46, 44, 46, 43, 38, 35, 30,
26, 20, 15, 11, 8, 3, 2, 7, 10, 15, 19, 25, 30, 34, 37, 41, 44, 45, 46, 48, 48,
49, 51, 51, 53, 54, 55, 57, 58, 61, 66, 72, 79, 87, 94, 101, 105, 109, 112, 116,
119, 120, 119, 118, 113, 109, 102, 96, 87, 79, 70, 61, 53, 46, 37, 28, 19, 13,
6, -2, -9, -16, -24, -32, -39, -46, -50, -56, -62, -67, -74, -79, -82, -86, -87,
-88, -87, -84, -81, -78, -74, -70, -66, -62, -56, -50, -46, -43, -40, -38, -38,
-39, -38, -41, -43, -45, -48, -51, -54, -58, -61, -63, -66, -68, -70, -72, -73,
-74, -75, -76, -75, -75, -74, -75, -74, -74, -74, -73, -72, -70, -65, -63, -58,
-54, -49, -44, -38, -32, -25, -18, -11, -4, 3, 9, 14, 19, 24, 26, 27, 29, 28,
28, 26, 25, 23, 20, 18, 15, 12, 9, 6, 3, 1, 0, -2, -2, -3, -3, -4, -6, -7, -8,
-8, -8, -8, -8, -7, -6, -5, -4, -1, 0, 4, 8, 12, 16, 21, 25, 31, 35, 40, 43, 47,
49, 52, 53, 54, 53, 54, 53, 51, 50, 47, 44, 41, 37, 34, 30, 27, 24, 20, 18, 14,
10, 6, 3, 0, -2, -4, -5, -7, -8, -10, -11, -11, -12, -12, -12, -11, -10, -8, -7,
-6, -3, -2, 0, 2, 3, 5, 5, 5, 6, 5, 5, 4, 2, -1, -2, -6, -9, -12, -15, -16, -19,
-21, -23, -24, -26, -27, -27, -27, -28, -26, -25, -24, -22, -19, -17, -15, -12,
-7, -3, -3, -7, -10, -15, -18, -20, -21, -23, -25, -27, -28, -28, -28, -28, -26,
-25, -23, -21, -20, -18, -15, -13, -10, -7, -3, -2, 1, 3, 4, 5, 5, 5, 5, 3, 3,
2, 0, -1, -4, -6, -8, -9, -9, -11, -11, -12, -12, -12, -11, -9, -9, -7, -5, -3,
-2, 1, 3, 7, 9, 13, 17, 20, 23, 27, 29, 33, 36, 40, 43, 47, 50, 52, 54, 54, 54,
54, 52, 53, 50, 47, 44, 40, 35, 31, 26, 21, 16, 12, 7, 4, 1, -1, -3, -5, -6, -7,
-7, -8, -8, -8, -8, -7, -5, -4, -4, -2, -2, -1, -1, 1, 3, 6, 8, 12, 15, 17, 20,
23, 25, 27, 28, 29, 28, 28, 27, 24, 19, 15, 10, 4, -4, -11, -18, -25, -31, -38,
-43, -48, -54, -58, -62, -66, -68, -71, -74, -73, -73, -73, -74, -74, -75, -75,
-76, -75, -75, -74, -72, -70, -69, -65, -64, -61, -58, -55, -51, -49, -46, -43,
-40, -39, -38, -37, -38, -39, -42, -47, -51, -55, -61, -66, -70, -74, -77, -81,
-85, -86, -88, -88, -87, -83, -78, -75, -69, -63, -57, -51, -46, -40, -33, -25,
-17, -10, -2, };