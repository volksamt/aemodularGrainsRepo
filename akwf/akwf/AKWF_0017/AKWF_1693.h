#define DATA_LENGTH 512
#define DATA AKWF_1693

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 12, 17, 21, 26, 29, 33, 38, 42,
46, 50, 55, 59, 62, 66, 69, 74, 77, 80, 82, 86, 89, 92, 95, 98, 99, 101, 104,
106, 107, 109, 111, 112, 113, 115, 115, 116, 117, 118, 118, 118, 118, 118, 119,
119, 119, 119, 118, 117, 117, 116, 116, 115, 115, 114, 113, 112, 111, 109, 108,
107, 107, 107, 105, 103, 103, 101, 99, 97, 96, 94, 93, 90, 89, 87, 85, 83, 81,
80, 77, 76, 75, 73, 72, 70, 68, 67, 63, 61, 59, 57, 55, 52, 51, 48, 46, 45, 44,
41, 40, 39, 37, 36, 34, 33, 32, 31, 30, 28, 27, 25, 23, 23, 22, 21, 20, 21, 19,
19, 19, 18, 18, 18, 17, 17, 17, 17, 17, 17, 16, 16, 15, 16, 16, 16, 16, 17, 16,
16, 18, 17, 17, 17, 17, 18, 17, 17, 17, 18, 18, 19, 18, 18, 18, 18, 19, 18, 18,
18, 18, 17, 16, 16, 15, 14, 14, 14, 13, 14, 13, 14, 14, 13, 12, 12, 11, 11, 11,
9, 8, 8, 6, 5, 4, 3, 2, 1, -2, -3, -4, -6, -7, -9, -11, -13, -14, -15, -17, -17,
-18, -20, -20, -21, -22, -22, -22, -23, -23, -24, -24, -24, -24, -24, -25, -25,
-26, -25, -26, -25, -25, -25, -25, -24, -24, -23, -21, -20, -18, -17, -15, -13,
-11, -9, -7, -4, -2, 2, 3, 6, 9, 12, 14, 17, 20, 22, 24, 27, 28, 32, 34, 36, 38,
40, 43, 45, 47, 48, 50, 52, 54, 55, 57, 59, 60, 62, 63, 65, 66, 67, 68, 68, 70,
70, 69, 69, 69, 69, 68, 68, 67, 67, 66, 65, 64, 63, 62, 61, 59, 58, 57, 55, 53,
51, 49, 48, 47, 45, 44, 41, 40, 38, 37, 35, 32, 31, 29, 26, 25, 24, 22, 20, 18,
16, 15, 13, 11, 10, 8, 6, 5, 3, 1, -2, -5, -6, -8, -9, -11, -13, -13, -15, -17,
-18, -20, -21, -22, -25, -26, -28, -29, -31, -33, -34, -36, -37, -39, -41, -41,
-42, -44, -45, -45, -46, -46, -47, -47, -47, -47, -48, -48, -49, -48, -49, -48,
-48, -47, -46, -47, -45, -45, -44, -43, -42, -42, -40, -40, -39, -38, -38, -36,
-36, -35, -34, -33, -32, -31, -30, -30, -29, -28, -28, -27, -26, -26, -26, -26,
-25, -26, -25, -25, -25, -25, -25, -25, -26, -27, -27, -27, -29, -30, -32, -32,
-33, -36, -38, -39, -41, -43, -46, -48, -51, -53, -54, -57, -59, -61, -63, -65,
-67, -70, -72, -72, -74, -76, -78, -79, -81, -83, -85, -86, -88, -90, -91, -92,
-93, -95, -96, -98, -98, -100, -102, -104, -103, -104, -105, -106, -106, -106,
-107, -106, -107, -106, -105, -106, -105, -104, -105, -104, -103, -102, -103,
-101, -100, -100, -100, -98, -96, -96, -94, -93, -91, -89, -88, -86, -83, -81,
-78, -76, -74, -71, -69, -66, -63, -60, -57, -54, -50, -48, -45, -41, -38, -35,
-31, -27, -24, -20, -17, -13, -8, -5, 0, };