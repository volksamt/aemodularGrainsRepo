#define DATA_LENGTH 512
#define DATA AKWF_1651

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 9, 13, 18, 21, 24, 27, 29, 32, 33,
36, 38, 40, 43, 45, 48, 52, 54, 57, 61, 63, 66, 68, 72, 74, 77, 80, 82, 85, 89,
93, 96, 102, 107, 110, 114, 116, 116, 114, 110, 103, 95, 84, 71, 56, 41, 26, 11,
-5, -20, -35, -50, -64, -78, -91, -101, -109, -115, -119, -120, -118, -115,
-111, -106, -100, -93, -88, -84, -80, -77, -74, -70, -66, -63, -58, -54, -47,
-43, -36, -29, -23, -15, -7, 2, 11, 22, 33, 44, 57, 68, 81, 90, 100, 106, 110,
111, 110, 107, 103, 98, 91, 86, 79, 74, 70, 66, 62, 59, 55, 51, 49, 45, 41, 38,
33, 31, 27, 23, 20, 15, 12, 8, 4, 1, -4, -7, -10, -14, -18, -21, -25, -29, -33,
-36, -39, -44, -47, -50, -55, -59, -62, -65, -69, -73, -76, -80, -84, -87, -92,
-95, -101, -106, -109, -115, -118, -119, -119, -117, -113, -106, -96, -85, -73,
-59, -47, -36, -24, -15, -8, -1, 4, 7, 11, 13, 15, 18, 20, 22, 26, 29, 31, 34,
38, 39, 42, 46, 48, 51, 54, 55, 59, 62, 65, 67, 71, 73, 76, 79, 83, 86, 88, 92,
95, 98, 101, 104, 107, 110, 112, 112, 111, 107, 101, 92, 81, 67, 51, 34, 16, -2,
-19, -35, -50, -62, -75, -85, -94, -102, -109, -113, -116, -118, -116, -115,
-112, -106, -100, -94, -88, -83, -77, -73, -71, -67, -65, -63, -58, -55, -50,
-43, -36, -27, -17, -6, 5, 17, 28, 39, 49, 58, 67, 75, 82, 90, 95, 99, 102, 104,
104, 103, 100, 95, 91, 85, 80, 74, 69, 64, 60, 56, 52, 49, 46, 43, 39, 36, 31,
28, 24, 20, 17, 14, 10, 6, 2, -1, -5, -9, -12, -17, -20, -24, -28, -32, -34,
-39, -41, -45, -48, -52, -56, -59, -64, -68, -72, -77, -80, -85, -89, -93, -97,
-100, -103, -106, -109, -110, -112, -113, -111, -110, -105, -99, -93, -83, -71,
-57, -43, -29, -16, -4, 6, 13, 20, 24, 27, 28, 29, 30, 30, 31, 33, 36, 39, 41,
44, 48, 50, 54, 56, 59, 62, 65, 66, 69, 72, 74, 78, 81, 85, 90, 94, 99, 103,
108, 112, 113, 114, 112, 110, 107, 101, 93, 85, 75, 64, 52, 38, 23, 7, -11, -28,
-46, -62, -78, -91, -101, -109, -114, -116, -116, -115, -111, -107, -104, -100,
-96, -92, -88, -84, -79, -75, -70, -67, -62, -58, -54, -50, -47, -43, -38, -34,
-27, -19, -9, 3, 17, 32, 46, 61, 74, 86, 96, 103, 107, 109, 109, 107, 102, 98,
94, 89, 84, 81, 76, 73, 68, 65, 61, 57, 54, 50, 46, 42, 40, 35, 31, 27, 24, 21,
17, 13, 9, 6, 2, -1, -6, -9, -12, -16, -19, -24, -27, -31, -35, -38, -42, -45,
-50, -52, -57, -60, -63, -67, -70, -73, -77, -82, -87, -92, -98, -103, -109,
-114, -118, -120, -119, -118, -114, -109, -101, -91, -80, -70, -61, -50, -40,
-33, -25, -18, -12, -5, -1, };