#define DATA_LENGTH 512
#define DATA AKWF_1680

const PROGMEM int8_t DATA[DATA_LENGTH] = {21, 29, 31, 35, 37, 41, 43, 46, 48,
52, 54, 56, 58, 60, 62, 63, 66, 68, 70, 72, 73, 75, 76, 78, 79, 80, 81, 83, 84,
86, 86, 88, 89, 90, 91, 92, 92, 94, 94, 94, 96, 96, 97, 98, 98, 98, 100, 100,
101, 101, 101, 102, 102, 103, 104, 104, 105, 105, 105, 106, 106, 106, 106, 108,
107, 107, 108, 108, 108, 109, 109, 108, 106, 107, 107, 107, 107, 107, 108, 107,
107, 108, 108, 108, 109, 109, 108, 108, 109, 109, 109, 109, 109, 109, 110, 109,
110, 110, 110, 110, 110, 111, 110, 110, 111, 110, 110, 110, 110, 110, 111, 110,
110, 111, 111, 110, 111, 111, 111, 111, 111, 110, 111, 111, 111, 111, 112, 111,
111, 111, 110, 111, 111, 112, 111, 112, 110, 112, 110, 113, 109, 116, 89, 61,
69, 65, 67, 66, 67, 66, 67, 67, 67, 67, 67, 67, 67, 67, 66, 67, 67, 67, 66, 67,
66, 67, 66, 67, 66, 67, 67, 67, 67, 66, 66, 67, 66, 67, 67, 67, 67, 67, 66, 66,
66, 68, 67, 67, 67, 66, 68, 66, 67, 67, 66, 67, 67, 67, 67, 76, 79, 79, 79, 79,
80, 78, 79, 78, 79, 79, 79, 78, 78, 78, 79, 79, 79, 79, 79, 78, 78, 79, 79, 79,
79, 79, 79, 79, 79, 78, 79, 79, 79, 80, 78, 79, 79, 78, 72, 66, 59, 53, 47, 42,
35, 31, 25, 20, 16, 11, 6, 3, -2, -6, -11, -12, 18, 16, 12, 10, 6, 4, 0, -1, -5,
-7, -10, -11, -14, -16, -18, -20, -22, -23, -26, -28, -29, -31, -33, -33, -35,
-36, -37, -39, -40, -41, -42, -43, -44, -46, -47, -47, -48, -50, -50, -51, -52,
-53, -53, -53, -54, -55, -56, -57, -57, -58, -58, -59, -60, -59, -60, -61, -60,
-62, -62, -62, -62, -62, -63, -64, -64, -64, -63, -65, -64, -65, -65, -66, -69,
-69, -70, -69, -69, -69, -70, -71, -70, -70, -71, -70, -71, -71, -71, -71, -71,
-71, -71, -72, -71, -72, -72, -72, -71, -72, -72, -72, -72, -73, -73, -72, -73,
-72, -73, -73, -72, -72, -73, -74, -73, -72, -73, -73, -73, -73, -73, -73, -74,
-73, -74, -73, -73, -73, -74, -74, -74, -74, -73, -74, -73, -73, -73, -74, -75,
-74, -76, -72, -77, -69, -101, -124, -115, -120, -117, -120, -118, -119, -118,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -120, -118,
-119, -118, -119, -118, -120, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -119, -120, -118, -110, -107, -107, -107,
-107, -107, -107, -107, -107, -108, -106, -107, -107, -108, -107, -107, -107,
-107, -108, -107, -107, -107, -108, -107, -107, -107, -107, -107, -107, -108,
-108, -108, -107, -108, -107, -107, -107, -108, -105, -100, -94, -87, -81, -75,
-69, -64, -58, -54, -48, -43, -38, -35, -31, -27, -21, -18, -12, };