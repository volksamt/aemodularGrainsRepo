#define DATA_LENGTH 512
#define DATA AKWF_1696

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 6, 7, 11, 13, 15, 17, 21, 22,
25, 27, 30, 32, 35, 38, 40, 43, 45, 49, 52, 54, 56, 59, 61, 64, 66, 69, 72, 74,
76, 80, 81, 84, 86, 88, 90, 92, 94, 98, 99, 102, 103, 105, 107, 108, 110, 112,
113, 114, 116, 117, 116, 117, 117, 118, 118, 118, 119, 119, 119, 119, 118, 118,
118, 118, 117, 115, 115, 115, 114, 114, 113, 113, 112, 111, 111, 109, 109, 108,
107, 107, 106, 105, 104, 103, 102, 101, 99, 98, 96, 95, 93, 93, 90, 89, 87, 85,
83, 81, 78, 76, 74, 72, 69, 66, 64, 62, 60, 58, 55, 53, 50, 47, 45, 43, 41, 38,
35, 33, 30, 28, 26, 23, 20, 18, 17, 14, 12, 10, 8, 6, 4, 1, 0, -2, -4, -8, -9,
-12, -13, -16, -18, -20, -23, -25, -27, -29, -31, -34, -35, -37, -40, -42, -43,
-44, -47, -48, -49, -51, -53, -54, -56, -56, -58, -59, -60, -60, -61, -61, -62,
-62, -63, -64, -64, -64, -65, -65, -66, -67, -67, -67, -69, -69, -69, -70, -70,
-71, -72, -72, -73, -74, -74, -74, -75, -75, -76, -76, -77, -78, -78, -78, -79,
-78, -78, -79, -78, -78, -78, -79, -78, -78, -77, -77, -77, -76, -75, -75, -74,
-73, -73, -72, -71, -71, -69, -69, -67, -66, -66, -64, -64, -63, -62, -60, -58,
-58, -58, -56, -54, -53, -52, -51, -49, -48, -47, -46, -44, -42, -42, -40, -38,
-36, -35, -33, -32, -31, -29, -27, -26, -25, -23, -22, -20, -18, -17, -14, -14,
-12, -10, -9, -7, -6, -4, -4, -2, 0, 1, 3, 5, 6, 7, 9, 12, 13, 14, 16, 18, 20,
22, 23, 25, 27, 28, 30, 32, 33, 34, 36, 37, 39, 39, 41, 43, 45, 46, 47, 48, 49,
50, 52, 53, 54, 53, 55, 56, 57, 58, 58, 59, 60, 61, 62, 62, 63, 64, 64, 65, 64,
65, 65, 66, 65, 66, 66, 66, 66, 67, 66, 66, 67, 65, 65, 64, 64, 64, 63, 63, 63,
62, 61, 61, 58, 58, 58, 56, 55, 55, 52, 50, 50, 48, 47, 45, 43, 42, 41, 39, 37,
35, 34, 33, 31, 28, 26, 25, 22, 21, 19, 17, 14, 13, 10, 9, 6, 4, 2, 0, -3, -5,
-7, -9, -12, -14, -17, -19, -21, -23, -25, -28, -30, -32, -34, -36, -40, -41,
-43, -46, -47, -50, -53, -54, -57, -59, -61, -63, -65, -67, -70, -71, -73, -75,
-76, -78, -80, -81, -84, -85, -86, -87, -88, -89, -90, -92, -92, -93, -93, -94,
-94, -95, -95, -95, -96, -97, -96, -97, -96, -96, -96, -95, -95, -95, -94, -95,
-94, -93, -92, -92, -92, -90, -90, -89, -89, -87, -86, -85, -84, -83, -83, -81,
-80, -78, -77, -75, -74, -73, -72, -69, -68, -67, -65, -63, -61, -60, -58, -56,
-54, -53, -49, -48, -46, -44, -42, -40, -38, -35, -34, -33, -31, -29, -26, -25,
-22, -20, -18, -16, -13, -12, -9, -7, -5, -3, -1, };