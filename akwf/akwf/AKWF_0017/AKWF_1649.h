#define DATA_LENGTH 512
#define DATA AKWF_1649

const PROGMEM int8_t DATA[DATA_LENGTH] = {103, 120, 113, 121, 115, 119, 115,
120, 115, 119, 116, 118, 117, 119, 116, 118, 117, 118, 117, 117, 117, 117, 118,
117, 117, 118, 118, 118, 118, 116, 118, 118, 117, 117, 117, 118, 118, 117, 117,
118, 117, 118, 118, 118, 117, 117, 117, 118, 118, 118, 117, 117, 118, 118, 117,
118, 117, 118, 118, 118, 117, 118, 118, 118, 117, 118, 118, 118, 118, 117, 117,
117, 118, 118, 118, 117, 117, 117, 117, 117, 118, 118, 117, 117, 118, 118, 117,
118, 118, 117, 117, 118, 117, 117, 117, 118, 118, 118, 118, 118, 118, 117, 117,
117, 117, 117, 117, 117, 117, 117, 117, 117, 118, 118, 118, 118, 117, 117, 117,
118, 118, 118, 118, 118, 117, 118, 117, 117, 117, 117, 117, 118, 118, 118, 118,
118, 117, 117, 117, 117, 117, 117, 118, 117, 117, 117, 117, 117, 117, 117, 117,
118, 118, 117, 117, 118, 118, 117, 118, 117, 118, 118, 118, 118, 118, 117, 117,
117, 117, 118, 117, 118, 117, 117, 117, 117, 117, 119, 116, 118, 117, 119, 117,
118, 116, 119, 117, 118, 117, 118, 118, 117, 118, 116, 118, 117, 119, 115, 121,
113, 123, 111, 125, 106, 127, 52, -125, -113, -123, -116, -121, -118, -119,
-119, -119, -121, -118, -120, -117, -121, -117, -121, -118, -120, -117, -121,
-117, -120, -119, -120, -119, -119, -119, -119, -119, -118, -120, -118, -120,
-118, -121, -117, -121, -117, -122, -116, -122, -116, -122, -115, -121, -115,
-122, -118, -93, -68, 102, 124, 112, 121, 113, 121, 115, 120, 114, 120, 115,
119, 116, 118, 116, 118, 116, 118, 118, 117, 119, 116, 119, 116, 119, 116, 119,
118, 118, 117, 118, 118, 117, 120, 115, 121, 113, 123, 110, 127, 103, 127, 31,
-128, -106, -127, -113, -122, -117, -121, -119, -118, -120, -118, -120, -118,
-120, -117, -120, -118, -121, -118, -120, -118, -120, -118, -120, -118, -120,
-118, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -120,
-120, -119, -119, -119, -119, -118, -119, -118, -119, -119, -120, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-120, -119, -119, -120, -120, -119, -119, -119, -118, -119, -118, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -120, -119, -118, -119,
-119, -119, -118, -120, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -118, -119, -119, -119, -119, -118, -119, -120, -119, -119, -119, -120,
-120, -120, -119, -119, -119, -119, -119, -118, -119, -119, -119, -120, -119,
-119, -120, -119, -119, -120, -119, -119, -119, -119, -120, -119, -120, -120,
-120, -119, -118, -119, -119, -119, -119, -119, -120, -119, -119, -118, -120,
-120, -119, -119, -119, -119, -119, -120, -119, -119, -118, -120, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -118, -119,
-118, -119, -119, -119, -118, -120, -118, -120, -118, -119, -118, -120, -118,
-120, -118, -118, -116, -26, };