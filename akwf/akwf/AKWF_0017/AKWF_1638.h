#define DATA_LENGTH 512
#define DATA AKWF_1638

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 11, 15, 19, 23, 27, 29, 33, 36,
39, 42, 44, 47, 50, 52, 54, 57, 59, 61, 62, 65, 67, 68, 70, 71, 73, 74, 76, 78,
80, 81, 83, 84, 86, 88, 89, 90, 91, 92, 93, 95, 95, 95, 97, 98, 98, 99, 101,
101, 101, 102, 103, 103, 104, 104, 105, 105, 105, 107, 107, 108, 108, 108, 109,
109, 109, 110, 111, 111, 111, 112, 112, 112, 113, 113, 113, 113, 114, 114, 114,
114, 115, 116, 115, 115, 115, 116, 116, 116, 116, 116, 117, 116, 116, 117, 117,
117, 117, 118, 119, 117, 119, 118, 119, 118, 119, 117, 113, 107, 102, 96, 91,
86, 82, 78, 74, 70, 66, 63, 60, 57, 53, 51, 50, 49, 49, 48, 47, 47, 47, 45, 45,
45, 44, 44, 43, 43, 42, 43, 43, 43, 43, 44, 44, 45, 45, 46, 46, 47, 47, 47, 48,
47, 48, 48, 48, 49, 49, 50, 49, 50, 50, 51, 51, 52, 52, 52, 51, 52, 52, 53, 53,
53, 54, 55, 55, 56, 57, 57, 57, 57, 58, 59, 59, 59, 59, 60, 62, 63, 63, 64, 66,
66, 67, 67, 69, 69, 70, 70, 71, 72, 73, 73, 74, 76, 77, 78, 79, 79, 81, 82, 83,
83, 84, 85, 86, 86, 87, 88, 88, 89, 90, 92, 92, 93, 93, 94, 95, 95, 96, 97, 98,
98, 99, 100, 99, 101, 101, 102, 102, 104, 103, 105, 105, 105, 106, 105, 107,
107, 106, 103, 94, 84, 75, 67, 58, 52, 44, 37, 31, 24, 18, 13, 8, 3, -3, -7,
-11, -15, -21, -24, -27, -31, -34, -38, -41, -44, -46, -49, -51, -54, -56, -59,
-61, -63, -65, -66, -69, -70, -72, -74, -75, -76, -78, -78, -80, -81, -82, -84,
-85, -85, -87, -87, -88, -89, -89, -91, -91, -92, -92, -93, -93, -93, -95, -94,
-95, -95, -96, -96, -96, -96, -96, -96, -97, -97, -97, -97, -96, -96, -97, -97,
-97, -98, -97, -98, -98, -98, -98, -98, -97, -98, -98, -98, -98, -99, -98, -99,
-98, -98, -99, -98, -99, -98, -98, -99, -98, -99, -99, -99, -99, -99, -98, -98,
-98, -99, -98, -99, -99, -99, -99, -99, -99, -98, -98, -98, -99, -99, -99, -99,
-97, -98, -98, -98, -98, -97, -98, -98, -97, -97, -97, -98, -97, -97, -97, -97,
-97, -97, -97, -96, -96, -96, -96, -96, -96, -95, -96, -95, -95, -95, -95, -95,
-94, -95, -94, -93, -94, -94, -93, -93, -93, -93, -93, -92, -93, -92, -93, -93,
-92, -92, -91, -92, -91, -91, -90, -91, -90, -91, -90, -90, -91, -89, -90, -90,
-89, -89, -89, -89, -88, -88, -88, -87, -89, -87, -88, -87, -87, -88, -88, -87,
-87, -86, -86, -86, -86, -85, -85, -85, -84, -85, -85, -84, -85, -85, -85, -84,
-84, -84, -84, -83, -82, -84, -83, -82, -83, -83, -82, -82, -82, -82, -82, -79,
-74, -69, -64, -61, -57, -54, -49, -47, -42, -39, -37, -34, -31, -28, -26, -21,
-15, -11, -5, -1, };