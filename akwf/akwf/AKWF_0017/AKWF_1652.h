#define DATA_LENGTH 512
#define DATA AKWF_1652

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 11, 13, 17, 20, 22, 25, 28,
30, 32, 34, 36, 37, 40, 42, 44, 44, 46, 47, 49, 50, 51, 52, 53, 54, 54, 55, 55,
56, 57, 58, 57, 58, 59, 58, 59, 59, 60, 60, 59, 60, 60, 61, 60, 61, 61, 60, 61,
60, 60, 61, 61, 60, 60, 60, 60, 60, 60, 59, 59, 59, 59, 58, 59, 57, 58, 58, 58,
58, 58, 57, 57, 58, 57, 58, 57, 58, 57, 58, 58, 57, 57, 57, 58, 58, 58, 58, 58,
58, 58, 57, 58, 57, 57, 58, 58, 58, 57, 58, 58, 57, 58, 59, 58, 58, 58, 59, 58,
58, 58, 58, 57, 58, 58, 58, 58, 58, 58, 57, 57, 58, 57, 57, 58, 57, 58, 58, 58,
58, 57, 57, 58, 57, 58, 57, 57, 56, 55, 55, 54, 53, 51, 51, 49, 48, 47, 44, 42,
40, 37, 35, 32, 30, 25, 23, 20, 16, 13, 9, 6, 2, -2, -4, -8, -12, -14, -18, -20,
-24, -26, -28, -31, -32, -34, -35, -37, -39, -39, -39, -40, -41, -41, -41, -41,
-40, -40, -39, -39, -38, -37, -37, -35, -34, -33, -33, -33, -31, -31, -30, -30,
-29, -28, -28, -27, -28, -27, -28, -28, -27, -27, -27, -27, -27, -27, -27, -27,
-28, -27, -26, -26, -25, -25, -24, -23, -21, -20, -19, -16, -16, -14, -11, -8,
-7, -4, -2, 1, 5, 7, 10, 13, 16, 19, 21, 25, 28, 31, 34, 36, 39, 42, 44, 46, 49,
51, 53, 55, 57, 58, 60, 63, 63, 63, 64, 64, 64, 63, 63, 64, 63, 63, 63, 64, 62,
63, 64, 62, 62, 63, 64, 63, 63, 63, 62, 60, 57, 56, 54, 52, 50, 48, 46, 43, 40,
36, 33, 30, 28, 25, 20, 18, 14, 10, 7, 3, -2, -5, -10, -13, -17, -21, -26, -30,
-35, -39, -43, -48, -54, -58, -63, -68, -73, -76, -81, -86, -89, -94, -97, -100,
-105, -107, -110, -112, -114, -116, -116, -118, -119, -119, -119, -119, -118,
-117, -116, -114, -113, -110, -107, -106, -103, -100, -96, -93, -91, -88, -84,
-83, -79, -76, -73, -70, -68, -66, -63, -60, -59, -56, -54, -52, -51, -49, -48,
-45, -44, -42, -42, -41, -39, -38, -36, -36, -35, -34, -32, -32, -32, -30, -30,
-29, -29, -29, -27, -27, -27, -27, -26, -25, -25, -25, -25, -25, -26, -25, -25,
-26, -25, -26, -26, -26, -27, -27, -28, -28, -28, -28, -28, -29, -28, -29, -29,
-30, -30, -31, -32, -31, -31, -32, -33, -33, -33, -33, -34, -34, -35, -35, -35,
-35, -35, -36, -36, -35, -36, -36, -35, -36, -35, -36, -35, -34, -35, -34, -35,
-33, -34, -33, -33, -32, -32, -31, -31, -30, -29, -29, -29, -29, -28, -28, -28,
-28, -27, -26, -28, -28, -28, -28, -28, -28, -29, -29, -29, -30, -31, -30, -31,
-32, -33, -32, -33, -32, -33, -33, -33, -33, -31, -31, -30, -29, -28, -27, -26,
-25, -23, -20, -17, -15, -14, -11, -8, -6, -3, 0, };