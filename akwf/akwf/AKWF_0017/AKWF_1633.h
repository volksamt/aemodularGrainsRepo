#define DATA_LENGTH 512
#define DATA AKWF_1633

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 4, 5, 6, 6, 6, 7, 8, 8, 7, 8, 7,
7, 8, 9, 10, 12, 13, 13, 16, 17, 18, 20, 21, 22, 23, 24, 24, 25, 25, 25, 27, 28,
30, 31, 33, 34, 36, 37, 39, 40, 41, 42, 43, 43, 44, 45, 46, 46, 48, 50, 50, 53,
55, 56, 58, 59, 60, 61, 61, 62, 62, 62, 63, 63, 63, 63, 63, 64, 64, 65, 65, 66,
66, 66, 68, 69, 70, 71, 72, 75, 76, 77, 78, 79, 80, 80, 80, 81, 80, 81, 82, 82,
83, 85, 88, 90, 92, 95, 97, 98, 99, 99, 99, 98, 99, 99, 99, 98, 98, 98, 99, 99,
100, 100, 100, 101, 99, 99, 99, 97, 97, 97, 96, 97, 98, 98, 98, 99, 98, 98, 99,
99, 100, 100, 101, 101, 102, 103, 105, 105, 107, 108, 110, 110, 111, 112, 113,
112, 113, 114, 115, 115, 115, 114, 113, 110, 108, 105, 102, 100, 98, 96, 94, 92,
92, 89, 88, 87, 85, 85, 85, 83, 82, 80, 79, 79, 77, 77, 75, 76, 75, 74, 74, 73,
71, 68, 67, 66, 64, 62, 60, 58, 56, 54, 52, 50, 48, 45, 43, 40, 36, 32, 27, 22,
18, 14, 10, 8, 5, 2, 0, -1, -4, -5, -7, -7, -10, -11, -14, -16, -20, -22, -25,
-27, -29, -30, -32, -32, -32, -34, -35, -35, -37, -40, -42, -44, -48, -50, -55,
-58, -62, -66, -68, -70, -73, -76, -78, -81, -83, -87, -89, -93, -95, -98, -101,
-104, -107, -109, -112, -113, -115, -116, -117, -118, -119, -119, -119, -119,
-118, -117, -118, -117, -117, -117, -117, -117, -117, -117, -118, -117, -117,
-116, -116, -116, -116, -116, -117, -117, -117, -118, -117, -118, -117, -117,
-117, -116, -113, -113, -112, -112, -111, -111, -111, -111, -110, -110, -109,
-107, -105, -103, -102, -100, -98, -97, -97, -95, -95, -95, -95, -95, -95, -94,
-94, -92, -91, -89, -86, -82, -80, -77, -74, -73, -71, -69, -67, -65, -63, -62,
-60, -57, -54, -51, -49, -45, -41, -38, -37, -35, -33, -32, -30, -29, -27, -26,
-24, -23, -20, -19, -17, -16, -13, -14, -12, -11, -10, -10, -7, -8, -2, 21, 23,
20, 22, 21, 21, 20, 20, 20, 20, 18, 18, 16, 15, 13, 10, 8, 6, 3, 3, 1, 0, -1,
-2, -3, -4, -5, -7, -9, -10, -13, -13, -15, -17, -17, -19, -20, -21, -21, -21,
-21, -20, -19, -19, -18, -18, -17, -17, -17, -18, -18, -18, -20, -21, -23, -24,
-26, -27, -27, -27, -26, -26, -27, -28, -29, -30, -31, -34, -36, -38, -40, -42,
-44, -43, -42, -41, -39, -36, -35, -32, -32, -31, -30, -32, -32, -33, -33, -34,
-35, -35, -35, -34, -34, -33, -33, -32, -32, -30, -30, -30, -30, -31, -30, -31,
-31, -30, -31, -31, -31, -31, -32, -32, -32, -31, -31, -30, -29, -27, -26, -24,
-22, -20, -18, -15, -14, -12, -10, -8, -7, -7, -5, -6, -7, -6, -6, -6, -6, -4,
-2, -2, 0, };