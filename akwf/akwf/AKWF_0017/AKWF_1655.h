#define DATA_LENGTH 512
#define DATA AKWF_1655

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 12, 19, 24, 32, 37, 44, 48, 55,
62, 67, 74, 79, 84, 90, 95, 99, 104, 108, 111, 115, 118, 119, 119, 119, 120,
119, 120, 118, 119, 119, 120, 117, 115, 114, 110, 108, 106, 103, 99, 96, 94, 91,
88, 85, 82, 80, 77, 75, 72, 71, 69, 67, 64, 62, 60, 58, 56, 55, 53, 51, 49, 47,
46, 43, 41, 40, 38, 36, 35, 32, 30, 28, 26, 24, 22, 20, 18, 16, 14, 12, 10, 9,
6, 5, 2, 0, -1, -3, -5, -7, -9, -11, -13, -15, -17, -19, -22, -23, -26, -27,
-30, -31, -34, -36, -37, -39, -40, -43, -45, -47, -49, -51, -54, -55, -58, -60,
-61, -63, -66, -67, -70, -73, -74, -77, -79, -82, -85, -87, -89, -92, -94, -95,
-98, -99, -99, -101, -101, -102, -101, -100, -99, -97, -95, -93, -90, -86, -83,
-78, -72, -67, -61, -54, -48, -42, -36, -29, -22, -16, -9, -4, 2, 8, 12, 17, 22,
25, 28, 30, 33, 34, 35, 34, 33, 33, 32, 30, 28, 26, 23, 20, 17, 13, 10, 7, 4, 0,
-3, -6, -10, -14, -17, -20, -21, -24, -26, -28, -32, -33, -35, -37, -39, -40,
-42, -43, -45, -45, -46, -47, -47, -49, -48, -48, -47, -47, -46, -45, -45, -43,
-40, -39, -35, -34, -31, -28, -24, -20, -17, -14, -11, -7, -2, 0, 4, 7, 10, 13,
15, 17, 20, 22, 23, 24, 24, 24, 25, 24, 24, 23, 22, 21, 20, 18, 16, 15, 14, 11,
10, 8, 6, 4, 2, 0, -1, -2, -5, -4, -7, -7, -9, -9, -11, -11, -13, -13, -14, -14,
-14, -14, -15, -15, -14, -15, -15, -13, -13, -12, -11, -10, -9, -7, -5, -3, 0,
2, 4, 8, 9, 13, 16, 19, 22, 25, 29, 31, 34, 37, 40, 43, 45, 47, 48, 50, 51, 51,
52, 52, 52, 52, 51, 50, 50, 48, 47, 45, 42, 40, 38, 35, 33, 30, 26, 24, 20, 17,
13, 9, 5, 2, -3, -7, -11, -15, -20, -26, -30, -35, -40, -45, -50, -55, -60, -65,
-69, -73, -76, -80, -83, -86, -88, -90, -91, -91, -92, -91, -91, -89, -87, -84,
-82, -77, -74, -71, -66, -61, -56, -52, -47, -41, -36, -30, -24, -19, -14, -7,
-2, 2, 7, 12, 16, 22, 26, 31, 35, 40, 45, 48, 54, 58, 61, 64, 67, 70, 72, 74,
75, 75, 76, 76, 74, 72, 70, 68, 64, 60, 54, 48, 41, 34, 25, 17, 9, -1, -9, -18,
-27, -35, -43, -51, -58, -64, -69, -74, -79, -80, -82, -82, -81, -78, -76, -71,
-65, -59, -50, -42, -34, -23, -14, -4, 6, 16, 27, 36, 45, 53, 61, 68, 73, 78,
82, 84, 84, 84, 84, 81, 78, 72, 67, 62, 55, 47, 40, 31, 23, 14, 5, -2, -11, -20,
-28, -35, -41, -47, -53, -57, -61, -64, -66, -67, -69, -69, -69, -69, -68, -66,
-65, -62, -59, -56, -53, -49, -45, -40, -37, -31, -27, -21, -17, -12, -8, -2, };