#define DATA_LENGTH 512
#define DATA AKWF_1684

const PROGMEM int8_t DATA[DATA_LENGTH] = {17, 21, 21, 22, 22, 23, 23, 24, 23,
25, 25, 25, 26, 26, 28, 28, 28, 28, 31, 37, 38, 38, 39, 40, 39, 39, 41, 42, 41,
42, 43, 43, 48, 52, 51, 52, 52, 54, 54, 55, 54, 57, 63, 63, 64, 64, 64, 65, 65,
67, 67, 68, 68, 68, 69, 70, 70, 72, 71, 74, 79, 79, 80, 80, 81, 81, 82, 82, 82,
84, 83, 85, 84, 89, 93, 92, 93, 91, 81, 71, 61, 35, 31, 33, 32, 34, 32, 38, 38,
38, 37, 38, 37, 38, 37, 38, 37, 37, 38, 37, 39, 43, 42, 42, 42, 43, 42, 42, 43,
41, 42, 42, 43, 42, 44, 46, 45, 46, 46, 46, 46, 45, 46, 46, 47, 46, 46, 46, 50,
50, 50, 50, 49, 49, 49, 49, 49, 49, 50, 50, 49, 49, 50, 49, 49, 50, 49, 52, 52,
53, 51, 53, 52, 52, 52, 52, 52, 52, 53, 51, 52, 53, 52, 53, 52, 52, 52, 52, 55,
55, 53, 55, 54, 55, 54, 54, 54, 54, 54, 55, 54, 55, 55, 56, 55, 56, 56, 55, 57,
57, 57, 58, 57, 57, 57, 57, 57, 57, 57, 57, 57, 57, 57, 57, 57, 57, 56, 57, 57,
57, 57, 57, 57, 58, 58, 58, 57, 57, 57, 57, 57, 57, 56, 57, 58, 59, 58, 57, 58,
58, 58, 58, 58, 58, 58, 57, 58, 58, 58, 57, 58, 57, 59, 57, 59, 57, 58, 57, 58,
57, 59, 57, 58, 57, 58, 57, 39, 39, 36, 39, 34, 41, 29, 50, -25, -98, -77, -90,
-81, -89, -85, -88, -87, -89, -88, -89, -90, -90, -91, -91, -93, -92, -94, -93,
-95, -95, -96, -95, -97, -96, -98, -97, -98, -99, -100, -100, -102, -101, -102,
-103, -103, -104, -104, -105, -105, -106, -106, -106, -107, -108, -108, -108,
-109, -110, -110, -110, -112, -112, -112, -112, -113, -113, -114, -115, -115,
-115, -115, -116, -116, -118, -118, -119, -119, -116, -104, -96, -83, -58, -57,
-58, -57, -58, -57, -58, -57, -57, -57, -55, -56, -56, -55, -56, -55, -56, -56,
-56, -56, -55, -56, -55, -53, -53, -53, -53, -53, -53, -53, -53, -53, -53, -53,
-53, -53, -53, -54, -53, -53, -53, -50, -50, -50, -50, -50, -50, -50, -50, -50,
-50, -50, -50, -50, -50, -49, -50, -50, -50, -49, -51, -47, -46, -46, -47, -46,
-47, -47, -47, -46, -45, -47, -47, -47, -46, -47, -46, -44, -42, -43, -41, -42,
-41, -37, -37, -37, -37, -38, -38, -38, -37, -37, -38, -38, -37, -36, -37, -37,
-37, -36, -37, -37, -37, -37, -33, -32, -33, -32, -32, -31, -32, -32, -32, -32,
-32, -32, -31, -33, -29, -25, -26, -26, -25, -26, -24, -20, -21, -19, -20, -21,
-20, -20, -20, -19, -20, -21, -20, -21, -20, -20, -20, -20, -20, -20, -20, -20,
-13, -14, -14, -14, -14, -14, -14, -14, -14, -14, -14, -13, -14, -10, -6, -7,
-7, -8, -7, -8, -7, -7, -7, -7, -7, -7, -7, -1, 0, };