#define DATA_LENGTH 512
#define DATA AKWF_1645

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 8, 11, 14, 18, 21, 24, 27, 31,
34, 37, 40, 44, 47, 50, 53, 56, 59, 62, 64, 68, 70, 73, 76, 78, 80, 83, 85, 88,
90, 92, 95, 96, 99, 100, 102, 104, 106, 106, 109, 110, 111, 113, 113, 115, 115,
116, 118, 118, 118, 118, 118, 118, 119, 120, 119, 118, 119, 118, 117, 118, 116,
115, 115, 113, 113, 112, 110, 109, 108, 107, 105, 104, 101, 99, 98, 95, 93, 92,
88, 87, 84, 83, 79, 78, 75, 71, 69, 66, 64, 61, 58, 56, 52, 49, 46, 43, 41, 38,
34, 32, 28, 25, 22, 19, 16, 13, 9, 6, 3, 0, -3, -7, -9, -13, -15, -18, -21, -24,
-26, -30, -32, -35, -37, -41, -43, -45, -48, -50, -53, -56, -58, -60, -62, -65,
-67, -69, -70, -72, -73, -75, -78, -79, -81, -82, -83, -85, -87, -87, -87, -89,
-90, -91, -92, -93, -94, -94, -95, -95, -95, -97, -96, -97, -96, -96, -97, -96,
-97, -96, -96, -96, -95, -95, -94, -94, -93, -93, -93, -91, -90, -89, -89, -89,
-87, -87, -85, -84, -83, -81, -80, -79, -79, -77, -76, -75, -73, -72, -70, -69,
-67, -66, -64, -63, -61, -60, -58, -57, -56, -54, -53, -50, -49, -47, -46, -44,
-43, -41, -40, -38, -36, -35, -33, -31, -30, -29, -27, -25, -24, -23, -21, -20,
-18, -17, -15, -14, -13, -10, -10, -8, -7, -6, -4, -2, -1, -1, 1, 3, 4, 5, 7, 8,
8, 10, 11, 12, 14, 15, 16, 17, 19, 19, 21, 22, 24, 24, 25, 26, 27, 29, 30, 30,
33, 32, 34, 35, 36, 36, 38, 39, 41, 41, 42, 44, 44, 45, 46, 46, 48, 49, 50, 52,
53, 53, 54, 55, 56, 56, 57, 59, 59, 60, 61, 63, 62, 64, 65, 66, 66, 67, 69, 69,
70, 71, 71, 72, 72, 73, 74, 75, 75, 76, 76, 77, 77, 78, 78, 79, 79, 80, 80, 80,
81, 81, 82, 81, 81, 81, 82, 82, 82, 82, 82, 81, 81, 80, 80, 80, 80, 79, 79, 78,
77, 76, 76, 74, 74, 73, 72, 71, 71, 69, 68, 67, 66, 64, 63, 61, 60, 58, 56, 55,
53, 52, 50, 48, 46, 44, 42, 40, 37, 35, 34, 31, 29, 26, 25, 22, 20, 17, 14, 12,
11, 7, 4, 2, -1, -2, -6, -8, -11, -14, -16, -20, -21, -24, -27, -29, -32, -35,
-37, -40, -42, -45, -48, -50, -53, -56, -58, -60, -62, -65, -67, -69, -72, -73,
-76, -78, -80, -81, -84, -86, -88, -90, -92, -93, -95, -96, -97, -99, -100,
-102, -103, -103, -105, -106, -107, -108, -108, -109, -110, -110, -111, -111,
-111, -111, -112, -112, -111, -110, -111, -110, -110, -109, -110, -109, -107,
-106, -106, -104, -103, -102, -101, -100, -99, -96, -95, -93, -92, -90, -88,
-87, -84, -82, -79, -77, -75, -73, -70, -68, -65, -63, -61, -57, -54, -51, -49,
-46, -43, -41, -37, -34, -30, -28, -24, -21, -18, -15, -11, -8, -4, -2, };