#define DATA_LENGTH 512
#define DATA AKWF_1605

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 8, 10, 12, 16, 17, 20, 22,
25, 28, 29, 32, 34, 36, 38, 40, 43, 46, 47, 50, 51, 54, 55, 57, 58, 61, 63, 64,
66, 68, 69, 71, 73, 75, 77, 77, 79, 81, 83, 85, 87, 89, 90, 92, 93, 95, 96, 98,
99, 100, 101, 101, 103, 104, 106, 106, 107, 109, 109, 111, 111, 113, 113, 114,
115, 116, 115, 116, 116, 117, 118, 118, 118, 118, 119, 119, 118, 119, 119, 119,
119, 119, 119, 119, 118, 118, 118, 118, 117, 117, 117, 117, 115, 115, 114, 114,
113, 112, 112, 112, 111, 109, 109, 108, 107, 106, 104, 104, 103, 102, 101, 99,
99, 97, 97, 97, 94, 93, 93, 91, 90, 88, 87, 86, 85, 83, 82, 80, 79, 78, 76, 75,
73, 72, 70, 69, 68, 66, 63, 63, 62, 59, 58, 57, 56, 54, 53, 52, 51, 49, 48, 46,
45, 44, 43, 41, 40, 39, 38, 37, 36, 35, 33, 32, 31, 30, 29, 28, 26, 26, 24, 24,
22, 21, 21, 19, 18, 18, 16, 16, 14, 15, 14, 13, 12, 11, 11, 9, 9, 8, 7, 7, 7, 6,
6, 6, 4, 4, 3, 3, 3, 3, 1, 1, 1, 0, 1, 0, -1, 0, 0, -1, -1, -2, -2, -3, -3, -2,
-2, -3, -3, -3, -3, -3, -3, -2, -3, -3, -3, -3, -2, -3, -2, -3, -2, -3, -2, -2,
-1, -2, -2, -2, -2, -1, -1, -1, -1, -1, 0, 0, -1, -1, 0, 0, 0, 0, 0, 0, 1, 1, 0,
1, 1, 1, 2, 2, 2, 2, 2, 2, 1, 2, 2, 3, 2, 3, 3, 3, 4, 3, 2, 3, 2, 3, 3, 3, 3, 3,
3, 3, 2, 3, 2, 2, 2, 2, 2, 1, 1, 0, 0, 0, -1, -1, -1, -1, -1, -3, -2, -3, -4,
-5, -5, -6, -7, -7, -7, -8, -9, -9, -11, -11, -11, -13, -13, -14, -14, -15, -16,
-16, -18, -19, -20, -21, -22, -22, -24, -26, -25, -27, -28, -29, -30, -32, -33,
-33, -35, -36, -38, -38, -39, -40, -42, -43, -44, -46, -47, -48, -50, -51, -52,
-52, -55, -56, -57, -58, -60, -62, -62, -65, -67, -68, -69, -71, -71, -73, -75,
-75, -77, -79, -81, -82, -83, -84, -86, -87, -89, -90, -91, -93, -94, -94, -95,
-97, -98, -100, -100, -101, -103, -103, -105, -106, -107, -106, -108, -109,
-110, -110, -110, -111, -112, -114, -114, -115, -115, -116, -117, -117, -117,
-117, -117, -117, -118, -119, -119, -119, -118, -118, -119, -120, -119, -119,
-119, -118, -118, -118, -118, -117, -117, -116, -116, -115, -115, -115, -113,
-113, -112, -110, -110, -109, -108, -107, -107, -106, -104, -103, -102, -100,
-100, -98, -97, -95, -95, -93, -92, -90, -88, -87, -84, -84, -81, -80, -79, -77,
-74, -73, -72, -69, -67, -66, -64, -62, -60, -59, -58, -55, -53, -51, -49, -47,
-45, -43, -41, -38, -35, -35, -31, -30, -27, -25, -22, -20, -17, -15, -12, -11,
-9, -6, -4, -2, };