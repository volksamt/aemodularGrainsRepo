#define DATA_LENGTH 512
#define DATA AKWF_1700

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 5, 8, 11, 13, 17, 21, 23, 27, 30,
32, 35, 38, 40, 41, 44, 47, 48, 50, 52, 54, 56, 58, 60, 62, 63, 65, 68, 70, 73,
76, 79, 81, 85, 88, 91, 95, 98, 101, 105, 107, 110, 112, 114, 116, 118, 119,
119, 119, 118, 118, 116, 115, 113, 110, 108, 105, 103, 99, 96, 92, 89, 85, 83,
80, 77, 73, 71, 69, 66, 64, 60, 58, 55, 53, 50, 47, 45, 42, 39, 36, 35, 32, 30,
27, 26, 24, 21, 20, 18, 16, 15, 13, 11, 11, 11, 11, 9, 9, 10, 9, 9, 10, 9, 9,
10, 10, 9, 9, 9, 9, 8, 7, 7, 7, 7, 6, 6, 5, 5, 4, 5, 5, 4, 4, 4, 4, 3, 4, 4, 3,
3, 3, 2, 1, 1, 0, -1, -2, -3, -5, -6, -8, -9, -12, -12, -15, -15, -17, -17, -20,
-20, -21, -22, -21, -22, -22, -22, -23, -22, -23, -22, -23, -23, -22, -22, -22,
-22, -23, -22, -22, -22, -21, -21, -20, -20, -20, -18, -18, -17, -16, -15, -15,
-14, -12, -12, -11, -10, -9, -7, -7, -6, -6, -4, -3, -3, -1, -1, 0, 1, 1, 2, 3,
3, 4, 4, 5, 6, 6, 7, 7, 8, 8, 10, 11, 12, 14, 15, 16, 18, 18, 19, 21, 21, 23,
24, 25, 26, 26, 29, 30, 31, 33, 35, 37, 39, 41, 43, 45, 47, 50, 51, 54, 55, 56,
57, 57, 57, 57, 57, 56, 56, 54, 53, 51, 49, 47, 45, 43, 40, 37, 35, 32, 30, 27,
25, 22, 21, 19, 17, 15, 15, 14, 13, 12, 11, 11, 11, 10, 11, 12, 13, 14, 13, 16,
16, 18, 19, 20, 21, 22, 23, 23, 24, 24, 26, 25, 26, 25, 26, 26, 27, 25, 26, 26,
24, 24, 23, 22, 22, 20, 18, 17, 15, 14, 12, 11, 8, 6, 5, 4, 1, 0, 0, -2, -2, -2,
-4, -4, -4, -5, -6, -8, -8, -8, -9, -10, -11, -11, -12, -13, -13, -14, -15, -15,
-15, -15, -15, -15, -15, -15, -15, -15, -16, -15, -15, -17, -17, -17, -18, -18,
-19, -19, -20, -19, -20, -20, -19, -19, -19, -18, -18, -18, -17, -18, -18, -19,
-19, -20, -20, -21, -23, -24, -26, -28, -30, -32, -35, -37, -39, -41, -44, -46,
-48, -51, -53, -55, -57, -59, -60, -61, -62, -62, -63, -63, -64, -63, -64, -63,
-62, -61, -60, -58, -57, -55, -54, -53, -51, -49, -47, -45, -44, -41, -40, -37,
-35, -34, -32, -31, -29, -28, -26, -25, -24, -22, -21, -20, -19, -19, -19, -18,
-18, -17, -17, -18, -20, -21, -22, -23, -24, -26, -27, -28, -30, -32, -33, -34,
-36, -38, -39, -40, -41, -43, -46, -47, -51, -52, -54, -57, -59, -61, -63, -66,
-67, -68, -70, -72, -73, -74, -74, -74, -73, -73, -72, -72, -71, -70, -68, -66,
-64, -62, -60, -58, -54, -52, -49, -46, -43, -40, -36, -33, -29, -26, -24, -20,
-17, -14, -12, -9, -6, -2, -1, };