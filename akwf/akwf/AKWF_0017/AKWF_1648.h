#define DATA_LENGTH 512
#define DATA AKWF_1648

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 13, 25, 35, 46, 54, 64, 70, 77, 81,
87, 90, 94, 98, 101, 104, 107, 109, 111, 113, 113, 114, 114, 112, 110, 107, 105,
102, 98, 94, 91, 86, 81, 76, 72, 67, 62, 59, 56, 54, 52, 51, 51, 52, 54, 57, 59,
61, 62, 64, 63, 64, 62, 60, 58, 55, 52, 48, 43, 39, 32, 27, 20, 12, 4, -4, -12,
-20, -27, -34, -39, -43, -44, -44, -44, -41, -38, -36, -34, -34, -36, -39, -42,
-47, -51, -55, -58, -62, -64, -68, -70, -73, -76, -80, -83, -88, -91, -96, -99,
-103, -107, -109, -110, -111, -113, -114, -114, -114, -114, -113, -113, -112,
-112, -111, -110, -110, -107, -104, -99, -94, -86, -79, -68, -58, -47, -35, -22,
-9, 2, 15, 25, 36, 44, 53, 61, 69, 75, 81, 85, 90, 96, 99, 104, 108, 110, 112,
114, 116, 116, 114, 114, 112, 110, 107, 105, 102, 98, 95, 92, 87, 82, 78, 73,
68, 63, 59, 55, 54, 52, 53, 53, 55, 57, 59, 60, 62, 64, 64, 64, 64, 62, 60, 57,
54, 51, 47, 42, 38, 32, 26, 20, 12, 4, -4, -13, -21, -29, -35, -40, -42, -44,
-42, -40, -36, -35, -33, -32, -33, -36, -38, -44, -49, -53, -57, -59, -62, -65,
-68, -70, -74, -76, -81, -85, -90, -94, -98, -103, -106, -109, -110, -111, -113,
-114, -114, -113, -113, -114, -114, -115, -115, -114, -113, -112, -111, -108,
-104, -99, -93, -85, -77, -68, -57, -45, -34, -21, -9, 2, 14, 25, 36, 45, 53,
61, 67, 73, 78, 83, 87, 92, 97, 102, 106, 110, 113, 116, 119, 119, 119, 117,
116, 113, 110, 106, 102, 98, 94, 89, 85, 80, 76, 71, 65, 61, 57, 54, 53, 52, 52,
52, 55, 57, 58, 61, 64, 66, 66, 66, 66, 64, 61, 58, 55, 51, 47, 42, 37, 32, 26,
18, 12, 3, -5, -13, -22, -29, -35, -39, -43, -42, -41, -39, -36, -34, -32, -31,
-31, -34, -38, -41, -46, -51, -56, -59, -62, -66, -68, -71, -74, -76, -79, -84,
-88, -93, -98, -101, -105, -107, -110, -111, -112, -113, -113, -113, -113, -114,
-114, -114, -114, -114, -113, -112, -110, -108, -105, -100, -95, -87, -79, -69,
-58, -46, -35, -23, -10, 3, 15, 26, 36, 45, 54, 61, 68, 75, 80, 84, 89, 94, 97,
102, 104, 109, 111, 114, 115, 117, 117, 117, 114, 112, 110, 106, 102, 99, 94,
90, 86, 81, 76, 71, 66, 62, 57, 54, 53, 50, 50, 51, 52, 55, 57, 59, 62, 63, 65,
65, 64, 63, 62, 58, 55, 52, 48, 43, 39, 33, 27, 19, 12, 4, -4, -13, -23, -30,
-36, -41, -43, -45, -42, -41, -38, -35, -33, -32, -33, -35, -38, -43, -47, -52,
-56, -59, -62, -65, -67, -71, -73, -77, -81, -85, -89, -93, -98, -101, -104,
-106, -109, -110, -112, -112, -112, -112, -113, -113, -113, -113, -113, -112,
-112, -111, -110, -107, -104, -100, -94, -87, -79, -69, -58, -46, -34, -22, -9,
};