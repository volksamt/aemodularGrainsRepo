#define DATA_LENGTH 512
#define DATA AKWF_1683

const PROGMEM int8_t DATA[DATA_LENGTH] = {36, 85, 114, 119, 117, 117, 116, 116,
114, 114, 112, 112, 110, 110, 110, 109, 107, 106, 106, 104, 104, 103, 103, 102,
100, 99, 98, 98, 97, 96, 95, 94, 94, 92, 92, 91, 90, 89, 88, 88, 87, 87, 85, 84,
83, 82, 82, 82, 81, 80, 79, 77, 77, 76, 76, 74, 73, 73, 72, 72, 70, 70, 69, 68,
67, 67, 66, 65, 65, 63, 63, 62, 61, 61, 60, 59, 58, 58, 56, 56, 55, 54, 54, 53,
52, 52, 50, 50, 50, 49, 48, 46, 47, 46, 45, 44, 43, 42, 42, 42, 41, 40, 39, 38,
29, -4, -43, -55, -53, -53, -54, -53, -54, -53, -55, -51, -19, 29, 46, 47, 43,
45, 41, 44, 41, 41, 37, 37, 95, 111, 106, 109, 107, 108, 105, 105, 104, 103,
102, 100, 102, 98, 101, 94, 106, 58, 10, 22, 15, 18, 15, 16, 14, 14, 12, 12, 10,
10, 9, 8, 8, 7, 7, 5, 5, 3, 3, 1, 1, 0, -1, -1, -2, -3, -4, -5, -5, -6, -7, -8,
-9, -9, -11, -11, -12, -12, -14, -14, -15, -15, -17, -17, -18, -18, -20, -19,
-21, -22, -23, -23, -25, -24, -26, -27, -27, -27, -28, -29, -29, -30, -31, -32,
-32, -33, -33, -34, -36, -36, -37, -37, -39, -38, -39, -40, -42, -42, -42, -43,
-43, -44, -45, -46, -46, -47, -48, -48, -49, -50, -51, -51, -52, -52, -53, -53,
-56, -54, -57, -55, -58, -57, -60, -58, -61, -60, -64, -60, 2, 9, 6, 9, 7, 8, 6,
6, 4, 4, 3, 2, 1, 2, 0, 0, -2, -2, -3, -4, -5, -5, -6, -7, -8, -8, -9, -10, -11,
-12, -12, -12, -13, -14, -14, -16, -17, -17, -17, -19, -19, -19, -20, -21, -22,
-22, -23, -24, -25, -25, -26, -26, -28, -28, -30, -29, -30, -31, -31, -32, -33,
-34, -35, -34, -36, -36, -38, -37, -38, -38, -40, -41, -40, -42, -42, -43, -42,
-44, -44, -46, -46, -47, -46, -50, -47, -51, -47, -56, -38, 24, 24, 24, 22, 22,
22, 20, 21, 20, 20, 17, 18, 17, 17, 13, -14, -59, -86, -87, -87, -87, -87, -87,
-87, -87, -88, -86, -88, -87, -88, -86, -88, -86, -89, -86, -89, -87, -92, -86,
-26, -15, -17, -15, -16, -14, -17, -14, -17, -16, -17, -16, -17, -17, -17, -17,
-18, -17, -19, -19, -17, -18, -18, -18, -19, -19, -19, -19, -20, -21, -21, -21,
-20, -21, -21, -21, -21, -22, -22, -22, -22, -22, -23, -23, -22, -23, -24, -24,
-24, -24, -24, -24, -25, -25, -25, -25, -26, -25, -26, -26, -26, -27, -27, -27,
-27, -28, -27, -28, -27, -28, -28, -29, -29, -29, -29, -30, -30, -30, -30, -30,
-32, -31, -31, -31, -31, -31, -32, -32, -33, -33, -33, -34, -34, -34, -34, -34,
-34, -35, -35, -36, -35, -35, -36, -36, -36, -36, -37, -37, -36, -37, -38, -38,
-38, -38, -38, -39, -39, -39, -40, -39, -41, -39, -41, -40, -42, -40, -46, -36,
};