#define DATA_LENGTH 512
#define DATA AKWF_1621

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 10, 9, 8, 9, 10, 10, 10, 10, 10,
10, 10, 10, 10, 10, 10, 12, 16, 17, 15, 15, 15, 15, 16, 16, 15, 15, 15, 14, 16,
15, 14, 16, 20, 22, 20, 21, 21, 22, 21, 21, 21, 21, 20, 20, 21, 20, 20, 20, 24,
26, 25, 24, 25, 24, 25, 25, 25, 25, 25, 24, 24, 24, 24, 23, 26, 27, 26, 26, 26,
26, 26, 26, 25, 26, 25, 25, 24, 24, 25, 25, 28, 29, 28, 28, 29, 28, 28, 28, 28,
27, 28, 28, 28, 28, 27, 28, 29, 28, 28, 28, 28, 29, 28, 28, 28, 28, 28, 27, 27,
27, 26, 26, 29, 31, 31, 29, 30, 29, 30, 29, 29, 29, 29, 29, 29, 29, 30, 30, 32,
34, 33, 33, 33, 33, 34, 34, 33, 34, 33, 34, 34, 33, 33, 35, 39, 40, 39, 40, 40,
40, 39, 39, 39, 39, 40, 40, 40, 40, 39, 41, 44, 44, 43, 44, 45, 44, 43, 45, 45,
44, 45, 44, 43, 44, 44, 44, 45, 45, 45, 44, 45, 44, 44, 45, 44, 44, 44, 44, 44,
44, 44, 45, 45, 45, 45, 45, 44, 45, 45, 45, 45, 45, 44, 43, 44, 44, 44, 43, 44,
44, 44, 43, 44, 43, 44, 43, 43, 43, 43, 42, 42, 42, 42, 43, 43, 42, 42, 42, 43,
42, 42, 42, 41, 42, 41, 41, 41, 42, 41, 42, 46, 48, 47, 47, 47, 48, 48, 47, 48,
48, 48, 48, 49, 48, 48, 49, 50, 50, 50, 50, 50, 49, 50, 49, 50, 50, 50, 49, 49,
49, 50, 47, 42, 42, 42, 42, 41, 41, 41, 41, 40, 40, 40, 40, 40, 40, 39, 40, 39,
39, 38, 38, 39, 39, 38, 39, 38, 39, 39, 39, 39, 39, 31, -51, -107, -85, -87,
-95, -98, -101, -105, -107, -110, -113, -114, -115, -118, -118, -119, -116,
-114, -115, -115, -114, -114, -115, -113, -112, -112, -111, -111, -109, -109,
-107, -107, -104, -101, -100, -99, -98, -97, -96, -94, -94, -92, -91, -90, -88,
-87, -86, -86, -82, -77, -75, -75, -73, -73, -72, -71, -69, -69, -68, -67, -66,
-65, -64, -63, -62, -61, -60, -60, -59, -58, -58, -58, -56, -56, -55, -55, -54,
-55, -54, -53, -52, -49, -50, -50, -49, -49, -48, -48, -49, -48, -48, -48, -48,
-48, -47, -48, -46, -42, -41, -42, -43, -43, -42, -41, -42, -41, -41, -42, -42,
-41, -41, -42, -40, -33, -32, -34, -32, -32, -32, -32, -32, -32, -31, -32, -32,
-32, -32, -32, -30, -29, -29, -29, -29, -29, -30, -29, -30, -29, -29, -30, -29,
-30, -31, -30, -24, -19, -21, -20, -20, -20, -20, -20, -19, -20, -20, -19, -19,
-20, -20, -20, -20, -19, -19, -19, -20, -19, -20, -20, -20, -20, -20, -21, -20,
-21, -20, -20, -13, -12, -13, -13, -13, -12, -12, -13, -13, -12, -12, -13, -12,
-12, -13, -12, -6, -3, -5, -5, -4, -4, -3, -4, -3, -4, -4, -4, -4, -4, -4, -3,
};