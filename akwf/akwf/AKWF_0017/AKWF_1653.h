#define DATA_LENGTH 512
#define DATA AKWF_1653

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 1, 3, 4, 5, 6, 5, 7, 8, 8,
10, 10, 11, 13, 14, 16, 16, 18, 19, 21, 22, 23, 24, 27, 28, 29, 31, 32, 34, 35,
36, 38, 39, 41, 43, 44, 45, 46, 47, 49, 50, 51, 53, 53, 55, 56, 57, 58, 59, 60,
60, 61, 62, 62, 63, 65, 65, 66, 66, 67, 67, 68, 68, 69, 69, 69, 69, 69, 69, 68,
69, 68, 68, 68, 68, 68, 68, 67, 67, 65, 66, 65, 65, 65, 65, 64, 63, 63, 63, 62,
62, 61, 60, 60, 60, 58, 58, 58, 57, 57, 56, 56, 55, 54, 54, 53, 53, 52, 52, 52,
51, 51, 51, 51, 51, 51, 51, 51, 51, 51, 51, 51, 52, 52, 52, 53, 53, 54, 55, 55,
54, 55, 56, 56, 58, 57, 59, 59, 60, 61, 61, 62, 62, 63, 65, 65, 66, 66, 66, 68,
69, 68, 70, 71, 70, 72, 72, 74, 74, 75, 76, 77, 78, 78, 78, 79, 80, 79, 80, 80,
81, 81, 82, 83, 82, 83, 83, 83, 83, 84, 84, 84, 84, 84, 84, 84, 84, 84, 85, 84,
84, 84, 84, 85, 84, 84, 85, 85, 85, 85, 84, 84, 85, 85, 85, 85, 86, 85, 86, 86,
85, 85, 84, 85, 84, 84, 84, 85, 84, 83, 82, 82, 82, 80, 80, 79, 78, 78, 77, 76,
76, 73, 73, 72, 70, 69, 68, 66, 65, 63, 61, 60, 58, 56, 55, 53, 51, 49, 46, 44,
42, 39, 37, 34, 32, 28, 26, 22, 20, 17, 13, 10, 7, 4, 2, -2, -5, -9, -11, -14,
-17, -20, -23, -25, -28, -31, -33, -36, -38, -41, -43, -46, -47, -49, -51, -54,
-55, -58, -60, -60, -62, -64, -65, -68, -69, -70, -71, -73, -75, -76, -76, -78,
-78, -79, -80, -81, -82, -84, -84, -84, -86, -87, -87, -87, -89, -89, -88, -90,
-90, -91, -91, -92, -93, -93, -93, -93, -95, -95, -96, -96, -97, -97, -98, -99,
-100, -100, -102, -103, -103, -105, -105, -106, -107, -107, -108, -109, -111,
-111, -113, -113, -113, -114, -115, -115, -116, -117, -117, -118, -118, -119,
-118, -119, -119, -119, -118, -119, -119, -118, -119, -119, -119, -118, -118,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -117,
-118, -118, -116, -115, -115, -115, -113, -113, -111, -111, -109, -108, -108,
-106, -105, -104, -103, -102, -101, -99, -98, -97, -95, -94, -93, -91, -90, -88,
-86, -84, -83, -81, -80, -77, -75, -73, -72, -70, -68, -66, -65, -62, -61, -58,
-57, -54, -52, -50, -48, -46, -45, -43, -41, -38, -37, -35, -34, -31, -30, -27,
-26, -23, -22, -20, -19, -17, -15, -13, -13, -11, -10, -8, -6, -5, -5, -4, -2,
-1, -1, 1, 0, 2, 1, 2, 2, 3, 3, 2, 2, 3, 2, 2, 2, 2, 1, 1, 1, 1, -1, -1, -1, -1,
-1, -2, -2, -2, -2, -2, -2, -3, -2, -3, -2, -2, -2, -2, -2, -2, -1, -1, -1, 0,
-1, };