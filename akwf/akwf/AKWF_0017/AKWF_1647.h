#define DATA_LENGTH 512
#define DATA AKWF_1647

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 14, 18, 20, 24, 27, 30,
33, 36, 38, 41, 43, 46, 48, 49, 51, 53, 55, 56, 58, 61, 62, 64, 66, 69, 73, 76,
78, 81, 84, 88, 91, 94, 97, 100, 103, 105, 108, 111, 112, 113, 115, 115, 116,
117, 116, 117, 118, 118, 117, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118,
117, 117, 116, 115, 114, 113, 112, 111, 108, 107, 104, 103, 100, 98, 96, 93, 90,
89, 87, 83, 81, 79, 76, 73, 71, 70, 66, 64, 62, 59, 57, 55, 52, 49, 47, 45, 42,
40, 38, 36, 34, 33, 31, 29, 28, 26, 25, 22, 21, 19, 17, 16, 15, 14, 13, 13, 11,
10, 10, 7, 6, 6, 5, 4, 2, 2, 0, 0, -2, -4, -5, -7, -9, -10, -13, -14, -17, -18,
-20, -22, -25, -27, -28, -30, -32, -35, -37, -39, -42, -43, -45, -48, -50, -52,
-55, -58, -61, -63, -66, -69, -72, -74, -77, -79, -81, -83, -87, -89, -91, -92,
-94, -96, -97, -98, -100, -102, -103, -105, -106, -107, -108, -110, -111, -112,
-113, -114, -114, -115, -116, -116, -116, -117, -116, -117, -116, -116, -115,
-115, -114, -112, -111, -110, -108, -106, -105, -104, -103, -101, -99, -97, -95,
-93, -90, -87, -84, -83, -80, -76, -74, -70, -67, -64, -61, -58, -55, -51, -47,
-44, -41, -37, -34, -31, -28, -24, -22, -18, -15, -12, -9, -5, -1, 1, 5, 8, 10,
14, 18, 21, 23, 26, 28, 32, 34, 37, 39, 41, 43, 45, 48, 49, 52, 52, 55, 56, 57,
59, 60, 61, 61, 62, 62, 63, 64, 63, 64, 63, 64, 63, 64, 64, 62, 64, 62, 61, 62,
62, 60, 61, 60, 58, 58, 57, 56, 56, 54, 54, 52, 51, 49, 48, 47, 44, 43, 42, 40,
38, 37, 34, 33, 31, 29, 27, 26, 23, 23, 21, 19, 19, 17, 15, 14, 13, 11, 10, 8,
7, 7, 5, 4, 4, 3, 2, 1, 0, 0, 0, 0, -1, -1, -2, -2, -2, -3, -3, -4, -4, -3, -3,
-3, -3, -3, -3, -3, -3, -3, -3, -3, -4, -3, -3, -4, -4, -4, -3, -4, -5, -4, -4,
-5, -5, -5, -6, -6, -7, -7, -7, -9, -8, -10, -9, -12, -11, -12, -13, -14, -15,
-16, -17, -18, -19, -20, -21, -21, -22, -23, -23, -25, -26, -26, -27, -28, -29,
-31, -31, -31, -33, -34, -35, -35, -37, -37, -37, -38, -39, -40, -41, -41, -41,
-42, -42, -43, -44, -44, -45, -45, -45, -45, -46, -47, -47, -47, -46, -47, -47,
-47, -47, -47, -47, -48, -47, -47, -47, -47, -46, -47, -46, -45, -44, -45, -43,
-43, -42, -42, -41, -41, -40, -40, -39, -38, -38, -37, -37, -36, -36, -36, -36,
-35, -33, -33, -33, -32, -32, -32, -31, -31, -30, -30, -29, -29, -29, -28, -28,
-28, -28, -27, -27, -27, -26, -26, -25, -25, -24, -24, -23, -23, -22, -21, -21,
-20, -19, -17, -16, -15, -13, -12, -10, -8, -5, -1, };