#define DATA_LENGTH 512
#define DATA AKWF_1690

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 6, 9, 11, 13, 17, 18, 22, 25,
28, 29, 32, 35, 37, 40, 42, 45, 49, 51, 53, 57, 59, 61, 63, 66, 69, 71, 74, 76,
79, 81, 84, 86, 88, 89, 92, 93, 95, 97, 99, 99, 102, 103, 105, 106, 107, 109,
109, 111, 111, 113, 114, 114, 116, 116, 117, 117, 118, 117, 118, 118, 118, 119,
119, 119, 119, 119, 119, 118, 119, 118, 116, 117, 115, 114, 114, 112, 113, 111,
110, 109, 108, 107, 106, 105, 104, 102, 101, 99, 97, 96, 93, 92, 91, 88, 87, 84,
82, 80, 79, 77, 74, 71, 70, 67, 64, 62, 60, 57, 54, 53, 50, 48, 45, 42, 40, 39,
36, 34, 32, 29, 26, 23, 22, 20, 18, 15, 13, 11, 8, 7, 4, 2, -1, -3, -5, -7, -8,
-12, -13, -15, -17, -18, -20, -21, -23, -24, -26, -28, -28, -29, -30, -31, -32,
-33, -34, -34, -35, -36, -37, -38, -39, -39, -40, -42, -43, -43, -44, -44, -46,
-47, -47, -48, -50, -51, -51, -53, -54, -55, -56, -58, -59, -60, -62, -64, -65,
-66, -67, -69, -69, -71, -72, -73, -74, -74, -75, -76, -77, -78, -77, -78, -77,
-78, -76, -77, -76, -76, -75, -74, -73, -71, -71, -69, -68, -67, -66, -64, -63,
-62, -61, -59, -57, -56, -55, -54, -52, -51, -50, -48, -47, -45, -44, -42, -41,
-39, -38, -36, -34, -33, -32, -29, -28, -26, -25, -23, -21, -19, -17, -15, -13,
-11, -10, -8, -7, -5, -2, -1, 2, 3, 6, 6, 9, 11, 12, 14, 16, 17, 19, 20, 21, 24,
26, 27, 28, 30, 32, 33, 34, 36, 38, 40, 41, 42, 43, 45, 47, 48, 49, 50, 52, 53,
54, 56, 57, 57, 59, 59, 61, 61, 62, 63, 64, 65, 66, 66, 68, 68, 69, 69, 70, 70,
71, 71, 72, 72, 72, 72, 73, 73, 73, 73, 73, 73, 73, 73, 73, 73, 72, 71, 72, 71,
70, 70, 69, 69, 68, 68, 66, 65, 65, 64, 64, 62, 61, 59, 59, 58, 56, 54, 55, 53,
51, 50, 48, 47, 45, 44, 42, 41, 39, 38, 37, 35, 33, 31, 29, 28, 26, 26, 23, 23,
20, 19, 17, 15, 14, 12, 11, 9, 7, 7, 4, 2, 1, 0, -2, -4, -5, -7, -8, -11, -12,
-14, -16, -17, -19, -21, -22, -23, -24, -27, -28, -29, -31, -32, -33, -33, -35,
-36, -37, -38, -39, -39, -41, -41, -44, -44, -46, -47, -48, -50, -51, -52, -54,
-55, -57, -58, -59, -60, -62, -63, -65, -66, -68, -69, -71, -71, -73, -75, -76,
-76, -78, -79, -80, -81, -83, -84, -86, -87, -87, -88, -88, -89, -89, -89, -89,
-88, -89, -88, -88, -87, -86, -85, -84, -83, -82, -81, -78, -78, -76, -74, -72,
-71, -69, -67, -65, -65, -62, -61, -60, -58, -57, -55, -54, -52, -51, -49, -48,
-47, -44, -43, -41, -39, -38, -36, -35, -33, -31, -30, -27, -25, -23, -20, -18,
-16, -14, -11, -9, -6, -4, -1, };