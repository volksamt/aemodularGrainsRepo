#define DATA_LENGTH 512
#define DATA AKWF_1661

const PROGMEM int8_t DATA[DATA_LENGTH] = {39, 35, 27, 35, 30, 35, 30, 33, 31,
33, 32, 33, 32, 33, 32, 32, 33, 33, 33, 34, 33, 33, 33, 33, 32, 33, 33, 32, 33,
32, 33, 34, 34, 33, 33, 33, 33, 34, 34, 33, 34, 34, 34, 33, 33, 34, 33, 34, 34,
33, 34, 34, 34, 33, 34, 34, 34, 34, 33, 34, 34, 34, 35, 39, 42, 41, 40, 41, 41,
41, 41, 40, 41, 40, 41, 42, 40, 41, 41, 44, 48, 48, 47, 48, 48, 48, 47, 48, 47,
47, 48, 48, 47, 48, 48, 48, 47, 48, 47, 47, 48, 47, 47, 48, 47, 47, 47, 48, 47,
48, 49, 52, 54, 53, 54, 54, 54, 54, 54, 54, 53, 54, 54, 54, 54, 54, 53, 50, 47,
48, 47, 47, 48, 47, 47, 47, 48, 47, 46, 48, 47, 47, 47, 49, 53, 54, 54, 54, 54,
54, 54, 54, 54, 53, 53, 53, 54, 53, 52, 47, 46, 47, 47, 47, 47, 47, 47, 47, 47,
48, 47, 47, 46, 48, 46, 42, 39, 40, 40, 41, 40, 40, 40, 40, 40, 40, 40, 41, 40,
41, 40, 40, 40, 40, 40, 39, 40, 40, 40, 39, 41, 39, 41, 38, 43, 35, 47, 108,
119, 120, 120, 119, 120, 118, 120, 119, 119, 119, 119, 118, 119, 119, 120, 119,
118, 118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 120, 120, 119, 119, 119,
118, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 118,
119, 119, 118, 118, 119, 119, 119, 119, 118, 118, 119, 119, 119, 118, 119, 119,
119, 118, 119, 119, 120, 119, 119, 119, 119, 118, 119, 118, 119, 118, 119, 119,
119, 119, 118, 119, 119, 118, 119, 119, 119, 118, 118, 118, 119, 119, 119, 119,
119, 118, 119, 119, 119, 119, 119, 118, 119, 118, 119, 118, 120, 119, 119, 119,
119, 120, 119, 119, 118, 119, 118, 119, 119, 119, 119, 120, 118, 120, 118, 119,
118, 120, 119, 119, 118, 120, 119, 119, 120, 117, 120, 115, 123, 114, 120, -36,
-128, -109, -125, -115, -123, -116, -120, -117, -121, -118, -119, -118, -118,
-119, -119, -119, -118, -120, -118, -119, -118, -119, -118, -120, -118, -120,
-118, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-118, -119, -118, -119, -119, -119, -119, -120, -119, -119, -118, -119, -119,
-118, -118, -118, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -118, -120, -118, -118, -118, -119,
-119, -119, -119, -119, -118, -118, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -118, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -118, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -118, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -118,
-118, -119, -119, -119, -118, -119, -118, -119, -119, -119, -119, -120, -117,
-120, -117, -119, -60, };