#define DATA_LENGTH 512
#define DATA AKWF_1610

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 12, 17, 22, 28, 32, 35, 41, 46,
50, 54, 59, 63, 67, 71, 75, 79, 81, 85, 87, 90, 93, 95, 98, 101, 102, 104, 107,
109, 109, 111, 112, 113, 115, 115, 117, 117, 118, 118, 119, 115, 103, 90, 80,
72, 66, 59, 55, 50, 45, 42, 38, 33, 28, 12, -3, -17, -27, -36, -44, -52, -58,
-64, -70, -74, -79, -82, -87, -90, -92, -94, -96, -97, -98, -100, -100, -101,
-100, -101, -100, -100, -98, -97, -95, -93, -92, -89, -87, -85, -82, -80, -77,
-73, -71, -66, -63, -60, -56, -52, -48, -43, -40, -35, -30, -26, -22, -16, -11,
-6, -2, 2, 8, 13, 17, 21, 26, 31, 34, 38, 41, 44, 47, 50, 52, 55, 58, 59, 61,
63, 64, 66, 66, 68, 69, 70, 71, 72, 72, 73, 73, 74, 74, 75, 75, 76, 76, 77, 76,
77, 76, 77, 75, 67, 50, 33, 20, 8, -1, -10, -17, -23, -30, -37, -42, -47, -52,
-56, -60, -63, -66, -69, -71, -73, -74, -76, -78, -78, -79, -80, -80, -80, -80,
-80, -80, -79, -78, -79, -77, -76, -74, -74, -72, -70, -68, -67, -65, -62, -59,
-56, -52, -49, -46, -42, -37, -33, -28, -24, -19, -15, -9, -4, 1, 5, 10, 15, 19,
24, 28, 32, 35, 39, 42, 46, 49, 52, 55, 58, 60, 62, 64, 65, 67, 69, 69, 72, 72,
73, 74, 74, 74, 74, 76, 75, 75, 75, 75, 74, 74, 73, 72, 72, 61, 44, 31, 20, 10,
3, -5, -11, -17, -23, -28, -33, -37, -41, -45, -48, -50, -52, -55, -58, -58,
-60, -61, -62, -62, -64, -63, -64, -63, -64, -64, -64, -63, -62, -62, -61, -60,
-59, -58, -57, -56, -54, -52, -51, -48, -46, -44, -41, -38, -36, -32, -29, -25,
-21, -17, -14, -10, -6, -2, 2, 5, 10, 12, 17, 20, 24, 27, 30, 34, 35, 39, 41,
43, 46, 48, 49, 51, 53, 54, 56, 57, 59, 59, 59, 60, 62, 61, 62, 63, 64, 64, 63,
64, 65, 65, 65, 65, 65, 65, 65, 65, 65, 66, 63, 53, 36, 24, 13, 4, -5, -12, -19,
-25, -30, -35, -41, -45, -49, -53, -58, -60, -63, -66, -68, -70, -72, -73, -74,
-75, -75, -76, -76, -75, -75, -75, -73, -73, -72, -70, -69, -67, -65, -63, -61,
-58, -55, -51, -47, -45, -40, -36, -32, -27, -22, -17, -12, -7, -3, 3, 7, 12,
17, 21, 26, 30, 34, 38, 41, 45, 48, 51, 55, 58, 60, 62, 64, 66, 67, 69, 71, 72,
73, 75, 75, 77, 77, 78, 79, 79, 80, 81, 81, 80, 80, 81, 81, 81, 81, 81, 81, 82,
80, 75, 60, 43, 28, 17, 6, -3, -11, -18, -24, -32, -37, -42, -46, -51, -56, -59,
-62, -65, -67, -69, -71, -72, -73, -74, -75, -75, -76, -76, -77, -76, -77, -75,
-76, -74, -74, -73, -72, -70, -68, -66, -64, -62, -59, -56, -53, -50, -47, -43,
-38, -34, -30, -25, -21, -15, -11, -5, -2, };