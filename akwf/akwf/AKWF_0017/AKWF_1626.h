#define DATA_LENGTH 512
#define DATA AKWF_1626

const PROGMEM int8_t DATA[DATA_LENGTH] = {32, 48, 52, 59, 68, 79, 91, 102, 111,
118, 119, 117, 111, 103, 92, 83, 75, 68, 63, 63, 63, 65, 68, 69, 72, 71, 69, 65,
61, 56, 51, 45, 42, 39, 37, 37, 38, 38, 39, 39, 40, 39, 37, 34, 32, 29, 27, 25,
23, 23, 21, 22, 22, 23, 23, 23, 22, 22, 21, 20, 18, 17, 16, 15, 14, 14, 14, 14,
15, 14, 15, 14, 14, 13, 12, 12, 10, 10, 10, 10, 9, 9, 9, 9, 8, 8, 8, 8, 8, 8, 7,
6, 5, 5, 5, 5, 4, 5, 4, 4, 4, 3, 3, 3, 2, 1, 2, 2, 1, 1, 0, 1, 0, 0, 0, -1, -1,
-2, -2, -2, -2, -3, -3, -3, -3, -4, -4, -4, -4, -4, -5, -5, -5, -5, -6, -7, -7,
-7, -8, -8, -8, -8, -8, -8, -9, -9, -10, -9, -10, -10, -11, -10, -11, -11, -12,
-12, -13, -13, -13, -13, -13, -14, -13, -15, -14, -16, -14, -17, -14, -18, -14,
-19, -13, -21, -9, -37, -4, 61, 43, 62, 64, 80, 90, 102, 111, 117, 119, 117,
111, 102, 93, 83, 75, 67, 64, 61, 63, 64, 68, 68, 71, 71, 68, 65, 62, 55, 50,
44, 42, 39, 37, 37, 37, 38, 39, 39, 40, 38, 36, 34, 32, 30, 26, 24, 23, 22, 22,
22, 22, 23, 23, 22, 22, 21, 21, 19, 18, 17, 15, 14, 14, 14, 14, 13, 15, 15, 14,
13, 13, 12, 11, 11, 10, 9, 10, 8, 8, 9, 8, 8, 8, 8, 8, 8, 7, 7, 6, 5, 5, 4, 4,
4, 4, 4, 4, 4, 3, 3, 3, 3, 2, 2, 2, 1, 0, 0, 0, 0, 0, 0, -1, -2, -2, -1, -1, -2,
-3, -3, -3, -3, -4, -4, -4, -4, -5, -6, -5, -6, -5, -6, -7, -7, -7, -7, -8, -9,
-9, -8, -10, -9, -9, -9, -10, -10, -10, -11, -11, -11, -12, -12, -11, -12, -12,
-12, -13, -13, -14, -14, -14, -15, -15, -15, -16, -16, -16, -16, -16, -17, -17,
-18, -18, -17, -18, -18, -19, -19, -19, -20, -21, -20, -20, -20, -21, -20, -21,
-22, -22, -22, -22, -22, -23, -22, -24, -23, -23, -24, -24, -25, -25, -24, -25,
-25, -26, -26, -27, -27, -26, -27, -28, -28, -28, -28, -29, -29, -29, -29, -29,
-30, -30, -30, -30, -31, -31, -31, -31, -32, -33, -32, -32, -33, -33, -33, -34,
-33, -34, -34, -34, -34, -35, -35, -35, -36, -36, -36, -36, -37, -37, -38, -37,
-38, -39, -38, -39, -39, -38, -38, -39, -40, -40, -41, -41, -41, -41, -41, -42,
-41, -42, -42, -42, -43, -42, -43, -43, -43, -44, -44, -44, -45, -44, -45, -46,
-46, -45, -46, -47, -47, -47, -47, -47, -47, -47, -48, -48, -49, -49, -49, -49,
-49, -49, -50, -50, -51, -51, -51, -51, -52, -51, -52, -51, -53, -52, -52, -53,
-53, -53, -53, -54, -53, -54, -52, -55, -54, -56, -53, -57, -53, -59, -53, -60,
-53, -60, -69, };