#define DATA_LENGTH 512
#define DATA AKWF_1614

const PROGMEM int8_t DATA[DATA_LENGTH] = {100, 101, 98, 102, 96, 100, 95, 98,
93, 97, 93, 95, 90, 92, 91, 92, 89, 91, 89, 89, 87, 85, 83, 82, 83, 81, 81, 79,
78, 78, 78, 76, 76, 75, 75, 74, 73, 72, 72, 71, 72, 69, 70, 70, 69, 68, 68, 66,
65, 65, 64, 64, 63, 62, 62, 61, 62, 61, 59, 58, 56, 56, 55, 54, 54, 52, 52, 52,
51, 51, 49, 49, 48, 48, 47, 46, 46, 44, 44, 44, 43, 41, 42, 42, 40, 40, 39, 39,
38, 37, 37, 36, 35, 35, 33, 33, 33, 32, 31, 31, 31, 30, 30, 29, 27, 25, 26, 26,
25, 24, 24, 22, 22, 21, 21, 20, 20, 20, 20, 20, 19, 18, 17, 17, 16, 15, 15, 14,
13, 13, 13, 12, 10, 9, 7, 2, 1, 1, 1, 2, 2, 7, 10, 11, 12, 13, 12, 14, 14, 15,
15, 15, 16, 17, 18, 18, 19, 19, 20, 20, 20, 21, 21, 22, 22, 23, 24, 25, 25, 26,
26, 27, 28, 30, 30, 31, 31, 32, 32, 33, 33, 34, 34, 35, 36, 37, 38, 38, 39, 39,
40, 41, 41, 41, 43, 42, 43, 44, 44, 45, 46, 48, 49, 49, 49, 50, 51, 52, 52, 53,
53, 54, 54, 55, 56, 56, 59, 60, 60, 62, 61, 63, 63, 63, 63, 65, 65, 66, 66, 67,
67, 68, 70, 70, 70, 71, 72, 73, 72, 74, 74, 75, 76, 77, 77, 77, 77, 78, 79, 80,
81, 83, 82, 83, 86, 86, 90, 89, 92, 90, 92, 90, 93, 91, 94, 93, 96, 95, 97, 97,
98, 99, 99, 102, 96, 109, -56, -119, -93, -108, -95, -103, -94, -99, -93, -96,
-91, -93, -89, -91, -87, -88, -86, -85, -85, -84, -83, -81, -81, -80, -81, -79,
-79, -78, -77, -76, -77, -75, -75, -74, -74, -72, -72, -72, -72, -71, -69, -69,
-69, -68, -67, -67, -66, -65, -65, -63, -63, -62, -60, -60, -58, -57, -57, -56,
-55, -53, -53, -52, -50, -50, -49, -49, -47, -45, -45, -43, -43, -42, -42, -41,
-40, -38, -37, -37, -36, -34, -33, -33, -31, -30, -30, -29, -28, -27, -25, -25,
-24, -22, -22, -21, -19, -19, -18, -17, -14, -13, -13, -11, -8, -7, -5, -5, -5,
-5, -4, -3, -3, -2, -2, -1, -1, 1, 0, 1, 0, 1, 0, -1, -1, -1, -3, -3, -4, -4,
-5, -5, -5, -6, -7, -10, -10, -13, -14, -15, -17, -19, -19, -21, -21, -22, -22,
-24, -25, -26, -26, -27, -28, -30, -30, -31, -32, -33, -34, -35, -36, -37, -38,
-40, -40, -41, -42, -44, -44, -45, -46, -47, -48, -49, -50, -51, -51, -53, -55,
-55, -55, -56, -58, -59, -59, -60, -62, -63, -64, -65, -65, -67, -67, -67, -68,
-69, -69, -70, -71, -71, -73, -72, -73, -73, -75, -75, -75, -76, -76, -77, -78,
-78, -79, -81, -81, -82, -82, -82, -83, -84, -85, -86, -86, -88, -89, -92, -92,
-93, -93, -96, -97, -97, -99, -98, -103, -98, -114, -47, };