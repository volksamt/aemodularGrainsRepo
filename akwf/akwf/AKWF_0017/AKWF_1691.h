#define DATA_LENGTH 512
#define DATA AKWF_1691

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 9, 12, 15, 18, 20, 23, 26,
29, 31, 34, 36, 39, 41, 43, 46, 48, 51, 53, 55, 58, 61, 63, 65, 68, 70, 72, 73,
76, 78, 81, 83, 85, 86, 88, 90, 92, 94, 96, 97, 99, 101, 103, 104, 105, 107,
107, 108, 109, 111, 112, 113, 113, 114, 115, 115, 116, 116, 117, 118, 118, 118,
119, 119, 118, 119, 120, 118, 118, 119, 118, 117, 117, 117, 116, 116, 115, 114,
115, 114, 113, 112, 112, 111, 110, 109, 108, 107, 105, 104, 103, 102, 101, 100,
99, 97, 96, 94, 93, 92, 92, 90, 88, 86, 85, 83, 81, 79, 77, 75, 73, 71, 70, 68,
66, 64, 62, 61, 59, 57, 55, 53, 51, 48, 45, 43, 41, 38, 35, 33, 29, 27, 24, 22,
19, 16, 14, 11, 7, 5, 2, -1, -3, -6, -9, -12, -14, -15, -17, -20, -23, -24, -26,
-28, -30, -32, -34, -35, -37, -37, -40, -41, -43, -44, -45, -45, -47, -47, -49,
-49, -51, -52, -52, -54, -54, -55, -57, -58, -59, -60, -61, -62, -62, -63, -65,
-67, -67, -69, -70, -71, -73, -75, -76, -78, -79, -80, -82, -82, -83, -84, -85,
-86, -87, -87, -88, -89, -89, -89, -90, -90, -90, -89, -89, -89, -89, -88, -86,
-86, -85, -83, -83, -81, -80, -78, -76, -74, -72, -70, -68, -66, -63, -61, -58,
-55, -52, -50, -48, -45, -42, -40, -38, -33, -32, -29, -26, -24, -21, -19, -17,
-13, -11, -9, -8, -5, -4, -1, 1, 3, 4, 6, 7, 9, 11, 13, 14, 16, 17, 19, 21, 21,
23, 24, 25, 27, 29, 29, 30, 32, 34, 35, 36, 37, 38, 40, 41, 41, 43, 44, 44, 46,
47, 48, 50, 51, 52, 53, 54, 55, 56, 57, 58, 58, 59, 60, 61, 61, 63, 62, 63, 65,
65, 65, 65, 66, 67, 67, 68, 68, 68, 69, 68, 68, 69, 69, 69, 69, 69, 68, 69, 69,
68, 68, 68, 68, 67, 68, 67, 67, 67, 66, 66, 65, 65, 63, 64, 63, 62, 62, 62, 61,
61, 60, 60, 58, 58, 58, 57, 56, 55, 55, 54, 53, 52, 52, 50, 50, 49, 48, 46, 46,
45, 44, 44, 42, 41, 40, 39, 37, 36, 33, 32, 30, 28, 26, 24, 22, 20, 17, 15, 13,
11, 8, 6, 4, 2, -1, -4, -6, -9, -10, -13, -17, -18, -20, -23, -25, -27, -30,
-32, -34, -36, -38, -40, -42, -44, -46, -49, -49, -52, -53, -54, -56, -58, -59,
-60, -62, -64, -64, -66, -68, -69, -70, -71, -73, -74, -74, -76, -77, -78, -79,
-80, -81, -84, -84, -85, -86, -87, -89, -90, -92, -91, -93, -94, -95, -96, -96,
-97, -96, -97, -98, -98, -98, -99, -99, -99, -99, -99, -99, -98, -97, -95, -95,
-93, -92, -91, -90, -89, -86, -84, -84, -82, -80, -77, -75, -72, -71, -68, -65,
-61, -58, -56, -53, -51, -48, -45, -42, -39, -36, -33, -31, -29, -26, -23, -19,
-16, -14, -11, -7, -4, -1, };