#define DATA_LENGTH 512
#define DATA AKWF_1632

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 6, 7, 9, 11, 13, 14, 16, 17,
18, 20, 21, 22, 23, 25, 26, 27, 29, 29, 32, 32, 33, 35, 35, 36, 37, 37, 38, 38,
40, 41, 41, 40, 41, 41, 42, 41, 41, 41, 40, 41, 42, 42, 42, 42, 42, 43, 44, 44,
43, 44, 44, 44, 43, 44, 43, 42, 41, 41, 40, 40, 40, 39, 39, 38, 38, 37, 37, 37,
38, 37, 38, 38, 39, 40, 40, 41, 41, 42, 42, 42, 43, 44, 43, 44, 45, 45, 46, 49,
49, 49, 51, 52, 52, 54, 55, 55, 57, 58, 60, 59, 61, 62, 62, 64, 65, 65, 65, 66,
67, 67, 69, 70, 71, 72, 72, 73, 74, 75, 76, 77, 77, 78, 78, 79, 78, 79, 79, 78,
77, 76, 74, 73, 70, 69, 66, 65, 62, 60, 56, 54, 52, 49, 46, 43, 41, 38, 35, 32,
30, 27, 24, 20, 18, 13, 11, 6, 1, -3, -9, -14, -19, -24, -30, -35, -40, -45,
-49, -54, -58, -61, -65, -68, -72, -75, -78, -81, -83, -86, -89, -91, -94, -96,
-99, -101, -105, -108, -109, -112, -114, -116, -118, -117, -119, -119, -120,
-119, -118, -118, -117, -117, -115, -115, -113, -112, -111, -109, -108, -106,
-104, -101, -99, -97, -94, -92, -88, -85, -82, -79, -74, -71, -69, -63, -60,
-57, -52, -48, -44, -40, -36, -32, -28, -24, -20, -16, -12, -8, -5, -2, 3, 6, 8,
11, 15, 18, 20, 23, 27, 29, 32, 36, 38, 42, 44, 47, 49, 51, 53, 55, 56, 57, 58,
59, 60, 61, 61, 61, 62, 61, 61, 61, 60, 60, 61, 60, 61, 61, 60, 59, 59, 57, 54,
52, 49, 47, 44, 43, 41, 39, 36, 35, 34, 32, 29, 29, 26, 25, 22, 20, 19, 15, 14,
11, 8, 5, 3, -1, -4, -7, -10, -13, -16, -18, -21, -24, -25, -27, -29, -31, -33,
-35, -37, -38, -40, -40, -42, -43, -44, -45, -45, -46, -46, -46, -47, -48, -49,
-49, -49, -51, -51, -52, -53, -53, -55, -55, -55, -55, -57, -57, -56, -57, -56,
-56, -55, -54, -53, -52, -51, -50, -48, -47, -46, -44, -43, -42, -40, -39, -38,
-37, -36, -35, -33, -32, -30, -29, -28, -27, -26, -25, -24, -21, -21, -19, -17,
-15, -13, -12, -10, -8, -7, -5, -4, -2, -1, 2, 3, 5, 7, 9, 10, 12, 12, 14, 16,
16, 18, 18, 21, 22, 24, 25, 26, 27, 30, 30, 31, 33, 34, 35, 35, 35, 36, 37, 37,
37, 38, 38, 39, 38, 38, 40, 40, 41, 41, 40, 41, 41, 42, 43, 44, 45, 46, 43, 46,
43, 46, 40, 51, 16, -49, -48, -51, -50, -52, -51, -52, -52, -54, -54, -53, -54,
-54, -54, -55, -55, -55, -56, -56, -57, -56, -57, -56, -55, -54, -52, -50, -50,
-49, -47, -45, -44, -42, -41, -39, -37, -36, -35, -33, -32, -30, -29, -28, -27,
-26, -24, -23, -22, -21, -19, -18, -15, -14, -13, -11, -10, -7, -6, -5, -2, 0,
};