#define DATA_LENGTH 512
#define DATA AKWF_1665

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 2, 3, 5, 6, 6, 7, 8, 10, 10, 12,
13, 14, 15, 16, 16, 17, 18, 20, 20, 21, 22, 23, 24, 24, 25, 26, 27, 29, 29, 30,
30, 31, 32, 33, 34, 35, 36, 36, 36, 37, 38, 39, 40, 41, 42, 42, 43, 44, 44, 45,
45, 47, 48, 48, 49, 49, 50, 51, 51, 52, 53, 53, 54, 55, 56, 55, 57, 58, 57, 59,
58, 60, 60, 61, 62, 62, 62, 63, 64, 64, 64, 66, 66, 67, 67, 68, 69, 68, 70, 71,
71, 72, 72, 73, 74, 74, 74, 74, 74, 75, 76, 77, 76, 77, 78, 78, 79, 79, 79, 80,
80, 81, 81, 82, 82, 83, 83, 84, 84, 84, 85, 86, 85, 86, 87, 87, 87, 87, 88, 89,
89, 90, 90, 91, 92, 91, 92, 92, 93, 93, 93, 94, 94, 94, 94, 95, 96, 96, 96, 96,
97, 97, 98, 98, 98, 99, 100, 99, 99, 99, 99, 101, 100, 101, 101, 102, 102, 103,
102, 104, 102, 103, 104, 105, 105, 104, 105, 105, 106, 106, 106, 106, 107, 107,
107, 107, 107, 108, 109, 109, 109, 109, 108, 110, 110, 110, 111, 111, 111, 111,
111, 111, 112, 112, 112, 113, 113, 112, 114, 113, 114, 114, 114, 115, 114, 115,
115, 115, 115, 115, 116, 116, 116, 116, 117, 117, 117, 117, 118, 118, 118, 118,
118, 119, 118, 119, 119, 119, 115, 110, 103, 93, 84, 73, 60, 45, 30, 14, -1,
-17, -30, -41, -50, -58, -64, -70, -75, -79, -84, -86, -90, -91, -94, -95, -98,
-100, -100, -102, -103, -104, -105, -106, -107, -107, -108, -108, -109, -109,
-110, -110, -110, -111, -111, -110, -111, -111, -112, -112, -111, -112, -112,
-112, -111, -111, -112, -112, -111, -112, -111, -111, -112, -111, -110, -110,
-111, -111, -110, -110, -110, -109, -110, -109, -109, -108, -109, -108, -108,
-108, -107, -108, -107, -107, -107, -107, -106, -106, -106, -105, -105, -105,
-105, -104, -103, -104, -104, -103, -103, -103, -102, -102, -102, -102, -102,
-101, -101, -101, -100, -100, -100, -99, -99, -98, -99, -97, -98, -98, -96, -97,
-96, -95, -96, -95, -95, -95, -94, -93, -93, -93, -92, -92, -91, -92, -91, -91,
-90, -89, -90, -89, -88, -89, -88, -87, -87, -86, -87, -86, -85, -85, -84, -85,
-84, -83, -83, -81, -81, -80, -81, -80, -80, -79, -79, -78, -79, -78, -77, -76,
-75, -76, -75, -75, -75, -73, -73, -72, -71, -72, -71, -70, -70, -69, -68, -67,
-68, -67, -66, -66, -65, -65, -64, -64, -63, -62, -62, -61, -60, -60, -59, -59,
-59, -57, -56, -56, -56, -55, -54, -54, -53, -53, -52, -51, -49, -49, -49, -49,
-47, -46, -46, -46, -45, -45, -43, -43, -42, -41, -40, -40, -39, -38, -36, -37,
-35, -35, -34, -33, -32, -31, -30, -30, -29, -28, -27, -26, -25, -25, -24, -23,
-23, -21, -20, -19, -18, -17, -17, -15, -15, -14, -12, -12, -11, -10, -9, -8,
-7, -6, -6, -5, -3, -2, -1, 0, };