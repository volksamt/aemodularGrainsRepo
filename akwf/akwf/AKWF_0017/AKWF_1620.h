#define DATA_LENGTH 512
#define DATA AKWF_1620

const PROGMEM int8_t DATA[DATA_LENGTH] = {18, 82, 74, 77, 76, 75, 76, 75, 75,
71, 73, 72, 73, 72, 73, 72, 73, 72, 72, 72, 74, 72, 74, 73, 73, 73, 73, 73, 74,
74, 73, 73, 74, 75, 74, 76, 74, 75, 74, 76, 72, 71, 72, 70, 70, 70, 70, 70, 76,
77, 78, 77, 77, 77, 78, 77, 78, 76, 78, 77, 78, 76, 78, 77, 78, 77, 78, 78, 77,
78, 76, 83, 42, 62, 83, 73, 80, 75, 80, 75, 79, 77, 79, 77, 78, 77, 78, 78, 77,
77, 77, 78, 77, 77, 76, 77, 77, 74, 70, 72, 70, 71, 70, 71, 71, 75, 75, 75, 75,
75, 75, 75, 75, 73, 74, 73, 73, 73, 73, 73, 74, 73, 73, 73, 73, 73, 73, 73, 73,
73, 73, 74, 71, 74, 71, 74, 72, 75, 74, 76, 75, 76, 75, 75, 72, -69, -122, -106,
-116, -109, -114, -110, -114, -111, -112, -111, -112, -111, -113, -112, -112,
-112, -112, -111, -110, -112, -111, -113, -111, -112, -111, -112, -110, -112,
-111, -110, -110, -43, -13, -22, -17, -21, -18, -20, -16, -12, -10, -11, -11,
-11, -11, -11, -11, -12, -13, -12, -12, -12, -11, -12, -12, -13, -14, -14, -14,
-14, -14, -14, -14, -14, -15, -14, -15, -16, -16, -15, -15, -15, -15, -15, -15,
-14, -15, -16, -15, -13, -14, -14, -13, -14, -13, -13, -12, -13, -14, -13, -14,
-13, -14, -12, -13, -13, -13, -14, -13, -13, -14, -13, -14, -13, -13, -13, -13,
-13, -13, -13, -13, -12, -12, -12, -12, -11, -12, -12, -12, -10, -10, -10, -10,
-11, -10, -10, -10, -10, -10, -9, -10, -10, -9, -10, -10, -8, -9, -8, -8, -9,
-9, -8, -8, -10, -10, -10, -10, -10, -10, -10, -10, -8, -8, -8, -9, -8, -9, -9,
-9, -10, -10, -10, -10, -10, -9, -9, -11, -11, -12, -11, -11, -11, -10, -12,
-12, -11, -12, -11, -11, -11, -11, -11, -11, -12, -11, -11, -11, -11, -11, -11,
-11, -12, -11, -11, -12, -11, -11, -12, -10, -10, -11, -10, -9, -10, -10, -10,
-8, -8, -8, -9, -9, -8, -8, -9, -10, -10, -10, -10, -9, -10, -10, -10, -9, -8,
-9, -8, -8, -8, -8, -9, -9, -10, -10, -9, -11, -10, -10, -10, -10, -10, -10,
-10, -9, -10, -10, -10, -11, -11, -11, -11, -12, -11, -12, -11, -12, -13, -13,
-13, -14, -13, -13, -14, -13, -14, -13, -13, -12, -13, -14, -13, -13, -13, -14,
-13, -14, -13, -13, -14, -13, -14, -13, -14, -13, -13, -14, -13, -14, -16, -15,
-15, -15, -16, -15, -15, -15, -15, -15, -15, -16, -15, -15, -15, -14, -14, -14,
-13, -13, -14, -14, -14, -12, -12, -13, -12, -12, -12, -12, -13, -11, -11, -10,
-10, -10, -11, -11, -11, -14, -20, -18, -20, -18, -20, -18, -23, -93, -116,
-108, -113, -109, -112, -110, -112, -110, -111, -111, -112, -111, -112, -112,
-111, -112, -111, -112, -110, -113, -110, -113, -109, -114, -109, -114, -108,
-116, -107, -117, -100, };