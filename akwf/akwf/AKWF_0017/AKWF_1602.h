#define DATA_LENGTH 512
#define DATA AKWF_1602

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 13, 19, 25, 30, 35, 41, 46, 50,
55, 59, 63, 66, 70, 73, 78, 80, 83, 85, 87, 89, 92, 94, 95, 98, 100, 102, 104,
106, 108, 109, 111, 113, 115, 114, 115, 116, 116, 117, 117, 118, 118, 118, 118,
119, 119, 118, 118, 119, 119, 119, 119, 119, 119, 119, 117, 115, 113, 111, 109,
107, 105, 103, 102, 99, 97, 95, 93, 90, 88, 86, 84, 84, 84, 84, 83, 83, 83, 83,
82, 82, 82, 82, 82, 81, 81, 80, 81, 81, 81, 81, 80, 80, 80, 79, 80, 79, 80, 80,
79, 79, 80, 79, 78, 79, 79, 79, 78, 77, 78, 77, 75, 74, 73, 71, 70, 69, 67, 65,
66, 66, 66, 67, 67, 68, 68, 69, 69, 70, 69, 71, 71, 71, 71, 72, 72, 71, 69, 67,
66, 64, 63, 62, 60, 59, 58, 59, 59, 58, 58, 57, 57, 57, 56, 56, 56, 56, 56, 56,
55, 54, 55, 54, 54, 53, 53, 53, 52, 52, 52, 52, 52, 50, 51, 50, 49, 49, 49, 47,
48, 46, 47, 45, 43, 42, 39, 36, 34, 31, 28, 26, 25, 22, 19, 17, 14, 13, 10, 7,
5, 5, 4, 3, 2, 2, 1, 2, 1, 0, 0, -1, -1, -1, -2, -1, -2, -3, -2, -3, -4, -4, -5,
-6, -7, -9, -9, -11, -12, -14, -16, -17, -18, -20, -21, -21, -23, -24, -25, -25,
-25, -25, -24, -24, -22, -21, -21, -21, -18, -16, -14, -11, -8, -6, -3, -2, 1,
4, 6, 8, 10, 13, 16, 19, 20, 21, 22, 23, 23, 24, 25, 26, 25, 25, 23, 22, 21, 20,
19, 18, 16, 15, 13, 12, 11, 9, 9, 7, 6, 5, 4, 3, 3, 2, 2, 2, 1, 1, 2, 1, 1, 0,
0, -1, -1, -2, -2, -2, -3, -4, -5, -5, -7, -9, -12, -15, -17, -19, -21, -24,
-26, -29, -31, -34, -37, -38, -42, -43, -45, -46, -47, -47, -48, -48, -49, -50,
-50, -51, -50, -51, -51, -52, -52, -52, -53, -54, -54, -54, -54, -55, -55, -55,
-55, -55, -56, -56, -57, -57, -57, -57, -58, -57, -59, -59, -58, -58, -59, -60,
-62, -64, -64, -67, -68, -69, -71, -72, -72, -71, -70, -71, -71, -70, -70, -69,
-68, -68, -67, -67, -67, -66, -66, -65, -65, -67, -68, -70, -71, -72, -74, -76,
-76, -77, -78, -78, -78, -79, -79, -80, -79, -79, -79, -79, -80, -80, -80, -80,
-79, -80, -81, -80, -80, -81, -81, -81, -82, -81, -82, -81, -82, -81, -82, -82,
-83, -83, -83, -84, -83, -84, -84, -85, -87, -89, -91, -93, -95, -96, -99, -102,
-103, -105, -107, -109, -111, -113, -115, -117, -119, -118, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -118, -117, -117, -116, -117,
-116, -115, -115, -114, -112, -111, -110, -109, -106, -104, -102, -100, -98,
-95, -93, -91, -89, -86, -85, -82, -79, -77, -73, -69, -65, -62, -58, -54, -50,
-47, -41, -35, -29, -24, -19, -13, -7, -2, };