#define DATA_LENGTH 512
#define DATA AKWF_1623

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 13, 22, 28, 34, 40, 46, 50, 54, 58,
62, 66, 67, 70, 72, 75, 77, 79, 81, 81, 83, 84, 85, 86, 87, 87, 88, 89, 89, 90,
90, 91, 91, 91, 92, 93, 92, 92, 93, 93, 93, 94, 94, 94, 94, 94, 94, 94, 95, 95,
95, 94, 95, 95, 94, 94, 95, 94, 95, 94, 94, 94, 95, 95, 94, 95, 95, 94, 95, 94,
95, 95, 95, 95, 95, 94, 94, 95, 95, 94, 94, 94, 94, 95, 94, 94, 94, 94, 95, 94,
95, 94, 94, 93, 94, 94, 94, 94, 94, 94, 95, 94, 95, 94, 94, 94, 94, 94, 94, 94,
93, 93, 87, 79, 70, 64, 57, 52, 47, 43, 38, 35, 30, 27, 25, 21, 20, 17, 16, 13,
11, 10, 10, 9, 7, 7, 5, 4, 3, 3, 2, 2, 1, 0, 1, 0, 0, -1, 0, 0, -1, -1, -1, -2,
-2, -2, -1, -2, -2, -2, -2, -3, -3, -2, -2, -3, -3, -3, 1, 7, 12, 17, 21, 25,
28, 32, 32, 28, 25, 22, 21, 19, 16, 14, 16, 20, 22, 27, 28, 31, 34, 35, 38, 39,
40, 41, 42, 44, 45, 46, 46, 47, 47, 47, 49, 48, 49, 50, 48, 48, 48, 48, 48, 48,
47, 47, 45, 44, 43, 42, 40, 40, 39, 38, 37, 36, 36, 34, 34, 34, 33, 29, 18, 4,
-9, -20, -31, -40, -49, -56, -63, -69, -76, -81, -85, -89, -93, -96, -92, -87,
-83, -78, -74, -70, -67, -64, -60, -58, -56, -54, -52, -51, -49, -48, -46, -45,
-44, -43, -42, -41, -40, -40, -39, -40, -39, -38, -37, -38, -38, -37, -37, -36,
-36, -36, -36, -36, -36, -35, -36, -35, -35, -35, -35, -35, -34, -34, -35, -34,
-35, -35, -35, -34, -34, -35, -34, -34, -34, -35, -34, -34, -35, -34, -34, -34,
-34, -35, -34, -34, -34, -35, -34, -35, -34, -34, -35, -33, -34, -35, -34, -34,
-33, -34, -34, -34, -35, -34, -34, -34, -34, -34, -34, -34, -34, -33, -29, -21,
-14, -8, -2, 3, 9, 12, 16, 20, 23, 25, 29, 31, 33, 34, 31, 25, 20, 14, 10, 6, 3,
-3, -12, -23, -32, -42, -50, -58, -65, -70, -71, -70, -69, -67, -66, -64, -64,
-63, -61, -62, -60, -60, -59, -59, -57, -58, -58, -57, -57, -58, -57, -56, -57,
-57, -56, -57, -56, -56, -57, -56, -56, -56, -56, -56, -56, -57, -57, -57, -57,
-57, -57, -57, -57, -57, -58, -57, -57, -57, -54, -49, -45, -41, -37, -34, -30,
-27, -28, -33, -36, -39, -41, -44, -46, -48, -47, -46, -44, -42, -42, -40, -40,
-38, -37, -37, -36, -35, -34, -34, -33, -34, -33, -34, -34, -34, -34, -34, -34,
-35, -35, -35, -35, -37, -38, -37, -38, -39, -43, -48, -54, -57, -61, -64, -68,
-70, -73, -75, -77, -80, -82, -82, -84, -87, -88, -94, -97, -100, -103, -105,
-107, -110, -111, -113, -115, -115, -117, -118, -119, -115, -99, -81, -64, -49,
-35, -23, -12, -2, };