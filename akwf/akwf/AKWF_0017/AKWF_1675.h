#define DATA_LENGTH 512
#define DATA AKWF_1675

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 2, 2, 2, 3, 2, 2, 3, 2, 2, 2, 3,
2, 6, 13, 17, 16, 16, 16, 16, 16, 16, 16, 15, 17, 16, 16, 16, 15, 18, 24, 27,
27, 27, 27, 27, 27, 27, 27, 26, 26, 27, 26, 27, 26, 27, 28, 28, 29, 28, 29, 29,
29, 28, 28, 29, 29, 29, 29, 29, 29, 29, 30, 32, 32, 32, 32, 32, 32, 32, 33, 32,
32, 32, 32, 33, 32, 35, 42, 45, 45, 45, 45, 45, 45, 44, 44, 45, 45, 45, 45, 45,
44, 46, 51, 56, 56, 55, 55, 55, 55, 55, 55, 56, 56, 56, 55, 55, 56, 55, 57, 57,
57, 58, 58, 57, 57, 58, 58, 58, 57, 58, 58, 57, 57, 59, 60, 61, 61, 61, 61, 61,
61, 61, 61, 61, 61, 61, 61, 61, 61, 62, 61, 61, 62, 61, 61, 61, 61, 61, 61, 61,
61, 61, 61, 61, 61, 61, 61, 61, 61, 61, 62, 61, 61, 62, 62, 60, 62, 61, 62, 61,
62, 61, 65, 69, 71, 70, 70, 71, 70, 71, 69, 71, 68, 74, 65, 80, 32, -19, -10,
-19, -14, -17, -15, -16, -14, -16, -15, -16, -15, -15, -16, -16, -30, -49, -53,
-52, -53, -52, -53, -52, -53, -53, -52, -52, -53, -52, -53, -52, -62, -88, -98,
-96, -97, -96, -97, -97, -96, -97, -96, -96, -97, -96, -97, -96, -99, -108,
-114, -114, -115, -115, -115, -115, -115, -114, -114, -115, -114, -115, -114,
-115, -114, -117, -118, -118, -118, -118, -118, -118, -118, -119, -119, -119,
-117, -118, -118, -118, -119, -117, -120, -118, -119, -116, -121, -116, -121,
-115, -122, -115, -123, -114, -126, -107, -9, 24, 76, 70, 70, 71, 70, 72, 69,
73, 69, 72, 70, 72, 69, 72, 70, 72, 70, 71, 70, 71, 71, 72, 71, 71, 71, 71, 72,
71, 71, 71, 71, 71, 70, 70, 72, 71, 72, 71, 72, 70, 71, 71, 71, 71, 72, 71, 70,
70, 69, 70, 70, 69, 69, 70, 69, 69, 70, 69, 70, 69, 71, 65, 55, 51, 52, 52, 53,
52, 52, 52, 52, 52, 52, 53, 52, 52, 53, 51, 45, 41, 43, 42, 42, 42, 42, 42, 42,
42, 42, 42, 43, 42, 41, 32, 21, 20, 22, 21, 20, 22, 21, 22, 21, 21, 21, 22, 20,
22, 22, 14, 2, 1, 1, 0, 0, 0, 1, -1, 2, -1, 2, -5, 9, -46, -38, 50, 73, 59, -19,
-64, -67, -65, -66, -65, -66, -65, -66, -64, -66, -65, -67, -63, -70, -118,
-113, -111, -113, -112, -113, -111, -113, -111, -113, -112, -112, -111, -113,
-112, -113, -111, -103, -97, -97, -96, -97, -96, -97, -96, -96, -97, -96, -97,
-97, -97, -97, -88, -75, -74, -74, -74, -74, -74, -74, -74, -74, -75, -75, -74,
-75, -75, -76, -65, -45, -39, -39, -39, -39, -40, -40, -39, -40, -40, -40, -39,
-40, -39, -41, -36, -17, -8, -9, -8, -8, -9, -8, -8, -9, -9, -9, -8, -8, -8, -8,
-9, -3, };