#define DATA_LENGTH 512
#define DATA AKWF_1678

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 8, 12, 17, 21, 24, 29, 32, 37,
39, 42, 45, 48, 50, 51, 54, 55, 57, 58, 61, 61, 63, 63, 66, 64, 76, 87, 84, 87,
88, 88, 89, 90, 90, 90, 92, 91, 93, 92, 94, 93, 95, 94, 95, 95, 95, 97, 95, 97,
95, 98, 96, 98, 96, 101, 95, 103, 91, 110, 62, -14, 2, -6, -1, -4, -2, -3, -2,
-2, -2, -1, -2, 0, -1, -1, -3, -1, -2, 0, -1, -1, -1, -1, -1, 0, -1, 0, 0, 0, 0,
0, 0, 1, 0, 0, -1, 1, 0, 1, -2, 7, 19, 15, 18, 17, 17, 16, 18, 16, 17, 17, 16,
16, 17, 17, 16, 18, 16, 17, 16, 17, 17, 17, 17, 17, 17, 17, 16, 17, 15, 17, 16,
17, 14, 21, 35, 32, 33, 32, 33, 32, 33, 33, 31, 32, 32, 32, 31, 32, 32, 32, 31,
30, 30, 30, 31, 31, 30, 30, 30, 29, 28, 29, 27, 29, 27, 29, 26, 30, 44, 43, 43,
42, 42, 41, 41, 41, 40, 40, 38, 39, 38, 37, 36, 36, 35, 34, 32, 32, 31, 29, 28,
27, 26, 24, 22, 20, 19, 17, 14, 12, 9, 6, 2, 0, -7, 1, 4, -4, -6, -12, -14, -18,
-21, -25, -28, -31, -33, -36, -37, -39, -41, -42, -44, -44, -45, -45, -46, -43,
-29, -1, 20, 32, 38, 43, 46, 48, 47, 49, 48, 49, 50, 50, 51, 51, 52, 50, 64, 69,
65, 65, 61, 60, 56, 55, 50, 47, 42, 38, 35, 30, 26, 22, 19, 15, 12, 9, 6, 4, 2,
-1, -3, -4, -6, -8, -8, -11, -11, -14, -13, -18, -5, 2, -2, -1, -3, -3, -3, -4,
-5, -6, -6, -7, -7, -9, -7, -10, -8, -10, -10, -11, -10, -11, -10, -11, -12,
-11, -13, -11, -15, -10, -16, -10, -21, -1, -62, -128, -109, -120, -114, -119,
-115, -118, -116, -117, -117, -117, -118, -117, -117, -117, -118, -117, -119,
-118, -119, -118, -119, -118, -119, -118, -119, -119, -119, -119, -119, -118,
-119, -118, -120, -119, -119, -118, -119, -118, -121, -110, -99, -103, -101,
-102, -102, -103, -101, -103, -102, -101, -101, -102, -102, -102, -102, -102,
-102, -102, -102, -102, -102, -101, -102, -102, -101, -101, -102, -101, -102,
-101, -102, -100, -103, -94, -82, -85, -83, -84, -83, -84, -84, -83, -83, -83,
-83, -83, -83, -83, -82, -82, -82, -81, -82, -81, -82, -81, -81, -81, -80, -79,
-80, -79, -80, -79, -80, -78, -80, -73, -59, -61, -59, -60, -58, -58, -58, -57,
-57, -56, -56, -55, -55, -54, -54, -53, -52, -51, -50, -49, -48, -47, -44, -44,
-43, -41, -39, -37, -36, -33, -31, -28, -26, -23, -19, -15, -12, 7, 17, 19, 24,
28, 32, 35, 39, 41, 44, 47, 50, 52, 54, 56, 58, 60, 61, 62, 63, 63, 62, 60, 43,
17, -5, -16, -23, -26, -29, -30, -30, -30, -32, -32, -33, -33, -34, -35, -35,
-35, -20, -15, -15, -11, -11, -7, -5, -2, };