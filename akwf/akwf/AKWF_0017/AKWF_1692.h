#define DATA_LENGTH 512
#define DATA AKWF_1692

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 9, 18, 26, 34, 41, 49, 54, 62, 68,
74, 80, 85, 90, 95, 99, 103, 107, 111, 114, 116, 117, 119, 118, 118, 117, 116,
116, 113, 113, 111, 110, 109, 107, 106, 105, 105, 105, 105, 105, 107, 108, 107,
107, 107, 106, 105, 104, 102, 101, 99, 97, 95, 93, 90, 88, 86, 85, 82, 81, 78,
76, 74, 73, 71, 70, 69, 68, 67, 66, 66, 64, 62, 60, 57, 57, 55, 55, 55, 55, 55,
53, 53, 52, 52, 52, 50, 51, 49, 47, 45, 42, 40, 36, 33, 29, 26, 23, 20, 18, 15,
12, 9, 6, 5, 3, 2, 1, -1, -2, -4, -6, -6, -8, -9, -9, -10, -10, -10, -9, -7, -6,
-3, 0, 2, 6, 9, 13, 17, 23, 26, 31, 36, 39, 44, 48, 51, 54, 57, 58, 61, 63, 64,
66, 68, 69, 69, 69, 70, 69, 67, 65, 62, 60, 57, 54, 51, 47, 44, 41, 38, 34, 32,
30, 29, 28, 28, 27, 26, 26, 26, 25, 25, 23, 23, 21, 20, 18, 16, 14, 12, 10, 7,
5, 2, 0, -2, -4, -7, -9, -11, -13, -15, -18, -18, -20, -21, -22, -24, -24, -26,
-28, -28, -29, -29, -28, -28, -27, -26, -26, -25, -25, -23, -23, -23, -22, -23,
-24, -25, -25, -27, -28, -30, -30, -32, -33, -34, -34, -35, -35, -36, -36, -35,
-34, -32, -31, -30, -28, -27, -25, -24, -22, -20, -18, -16, -13, -9, -6, -2, 2,
5, 11, 16, 20, 26, 33, 39, 44, 51, 57, 63, 68, 73, 79, 83, 87, 91, 94, 97, 100,
102, 105, 107, 108, 109, 110, 109, 108, 106, 104, 102, 98, 95, 91, 88, 83, 80,
76, 72, 68, 65, 62, 60, 59, 57, 56, 54, 52, 51, 49, 47, 45, 44, 40, 38, 35, 32,
29, 26, 23, 20, 17, 14, 11, 9, 6, 4, 0, -2, -4, -5, -8, -9, -10, -13, -15, -16,
-18, -19, -21, -23, -24, -25, -24, -24, -24, -25, -25, -26, -26, -26, -26, -26,
-28, -29, -31, -33, -35, -37, -40, -42, -44, -48, -49, -51, -53, -55, -56, -59,
-60, -61, -62, -62, -63, -63, -64, -64, -64, -63, -63, -63, -62, -61, -60, -58,
-56, -54, -51, -48, -45, -40, -37, -31, -26, -21, -16, -11, -5, 0, 5, 9, 14, 17,
20, 22, 25, 28, 30, 31, 34, 35, 36, 36, 36, 36, 34, 33, 30, 27, 24, 20, 16, 12,
8, 4, 1, -4, -9, -12, -16, -18, -20, -23, -24, -26, -28, -29, -32, -34, -36,
-38, -42, -44, -48, -50, -53, -56, -59, -62, -66, -68, -70, -73, -75, -77, -80,
-82, -85, -86, -88, -88, -90, -90, -91, -92, -94, -94, -95, -96, -96, -95, -95,
-94, -92, -92, -90, -90, -88, -88, -86, -84, -83, -83, -83, -83, -83, -84, -85,
-86, -86, -87, -88, -88, -88, -88, -88, -88, -88, -86, -85, -83, -82, -80, -79,
-76, -74, -72, -71, -68, -66, -63, -60, -57, -53, -48, -43, -38, -31, -26, -19,
-12, -5, };