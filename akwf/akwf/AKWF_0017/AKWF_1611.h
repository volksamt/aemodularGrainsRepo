#define DATA_LENGTH 512
#define DATA AKWF_1611

const PROGMEM int8_t DATA[DATA_LENGTH] = {14, 41, 56, 66, 73, 76, 79, 81, 83,
85, 86, 88, 88, 90, 91, 92, 93, 94, 95, 97, 99, 99, 100, 102, 103, 104, 105,
106, 107, 108, 110, 110, 111, 113, 114, 115, 116, 118, 119, 119, 118, 117, 115,
114, 114, 113, 111, 110, 108, 108, 106, 105, 105, 104, 102, 100, 100, 99, 97,
96, 95, 93, 92, 91, 90, 90, 89, 87, 86, 85, 84, 83, 82, 80, 79, 75, 38, -8, -32,
-49, -57, -62, -64, -65, -65, -64, -63, -63, -61, -60, -60, -59, -57, -57, -55,
-55, -53, -52, -51, -49, -49, -47, -46, -45, -43, -43, -42, -41, -40, -38, -37,
-36, -35, -34, -32, -14, 4, 13, 20, 23, 24, 24, 23, 23, 22, 21, 21, 19, 18, 17,
16, 15, 13, 13, 12, 10, 9, 8, 6, 5, 5, 4, 2, 1, 1, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0,
1, -1, 1, -1, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 2, 3, 4, 5, 7, 8, 9, 10, 11,
12, 14, 15, 16, 17, 17, 19, 21, 21, 22, 23, 25, 26, 27, 27, 30, 30, 32, 32, 34,
34, 35, 37, 37, 39, 41, 40, 43, 43, 44, 46, 47, 48, 49, 50, 51, 52, 53, 55, 56,
56, 59, 59, 61, 62, 62, 63, 64, 66, 60, 22, -17, -39, -53, -61, -68, -70, -74,
-76, -77, -79, -80, -81, -81, -84, -84, -86, -87, -89, -89, -90, -92, -93, -93,
-95, -96, -96, -97, -98, -100, -100, -102, -103, -105, -106, -106, -108, -108,
-110, -110, -111, -112, -113, -115, -116, -117, -117, -117, -117, -118, -118,
-118, -117, -117, -118, -117, -117, -117, -118, -117, -117, -117, -117, -109,
-109, -113, -114, -116, -116, -117, -117, -116, -117, -117, -117, -118, -118,
-117, -117, -118, -118, -118, -118, -118, -117, -115, -115, -113, -113, -112,
-110, -110, -109, -108, -107, -106, -105, -104, -102, -101, -100, -99, -98, -96,
-95, -95, -94, -93, -91, -90, -89, -88, -86, -85, -85, -84, -83, -82, -80, -80,
-78, -76, -77, -74, -74, -73, -69, -32, 10, 32, 47, 53, 57, 59, 60, 61, 60, 59,
59, 57, 55, 54, 54, 53, 52, 51, 49, 48, 47, 46, 45, 45, 43, 42, 41, 40, 38, 37,
36, 36, 33, 32, 32, 31, 29, 29, 28, 27, 25, 23, 22, 21, 20, 19, 18, 17, 16, 15,
14, 12, 12, 10, 10, 7, 7, 6, 5, 3, 2, 1, 0, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, 0, 0,
0, 0, 1, 0, -1, -1, 0, 0, 0, 0, 0, 1, 0, 1, 3, 3, 4, 6, 6, 8, 9, 11, 11, 12, 13,
14, 16, 17, 18, 19, 20, 21, 22, 24, 25, 26, 27, 29, 26, 10, -8, -18, -24, -29,
-33, -34, -36, -37, -39, -40, -41, -42, -44, -45, -46, -47, -48, -50, -51, -52,
-53, -53, -55, -56, -57, -59, -59, -61, -61, -63, -64, -65, -65, -67, -68, -69,
-71, -64, -21, };