#define DATA_LENGTH 512
#define DATA AKWF_1698

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 2, 3, 4, 4, 5, 5, 6, 5, 6, 6, 7,
7, 8, 8, 8, 8, 8, 10, 18, 29, 37, 42, 44, 47, 47, 46, 45, 43, 41, 39, 37, 35,
32, 31, 29, 26, 25, 23, 24, 26, 31, 35, 38, 40, 43, 42, 43, 42, 40, 39, 36, 34,
33, 31, 29, 28, 25, 24, 22, 20, 19, 17, 25, 43, 57, 65, 71, 75, 77, 77, 77, 74,
70, 68, 63, 58, 56, 61, 69, 78, 83, 86, 87, 86, 84, 80, 77, 73, 70, 65, 61, 58,
55, 68, 86, 97, 103, 107, 108, 106, 104, 100, 95, 91, 84, 79, 73, 71, 72, 73,
76, 81, 85, 88, 88, 86, 84, 81, 78, 74, 71, 67, 63, 58, 54, 49, 45, 40, 33, 27,
23, 21, 23, 24, 24, 24, 23, 22, 20, 20, 18, 16, 15, 13, 12, 11, 11, 11, 12, 12,
12, 14, 20, 32, 52, 68, 79, 86, 90, 89, 88, 85, 82, 77, 73, 68, 63, 59, 71, 89,
99, 105, 107, 106, 104, 99, 94, 89, 82, 76, 70, 65, 59, 54, 49, 45, 41, 36, 33,
29, 27, 24, 26, 33, 43, 49, 55, 57, 56, 56, 53, 50, 47, 44, 40, 37, 33, 30, 27,
24, 21, 18, 15, 14, 12, 9, 7, 5, 5, 3, 1, 1, 0, 0, 1, 2, 12, 25, 38, 45, 49, 52,
52, 51, 50, 47, 43, 41, 37, 34, 31, 27, 25, 21, 18, 16, 14, 12, 17, 26, 31, 33,
36, 36, 35, 34, 33, 30, 27, 25, 22, 21, 18, 15, 13, 12, 12, 15, 18, 20, 23, 24,
22, 22, 21, 19, 17, 16, 14, 11, 6, -1, -13, -22, -29, -34, -36, -38, -38, -38,
-37, -36, -35, -33, -32, -31, -29, -27, -25, -24, -22, -22, -19, -19, -18, -17,
-25, -43, -55, -64, -70, -73, -74, -73, -71, -68, -64, -61, -66, -80, -95, -103,
-107, -107, -105, -103, -99, -94, -88, -83, -78, -72, -67, -62, -57, -52, -49,
-45, -43, -46, -54, -65, -79, -94, -107, -114, -117, -117, -113, -109, -104,
-99, -93, -96, -105, -106, -107, -106, -103, -98, -93, -87, -81, -74, -69, -63,
-59, -66, -73, -76, -76, -77, -74, -71, -68, -63, -59, -55, -52, -51, -50, -50,
-51, -52, -54, -55, -58, -60, -62, -64, -74, -91, -107, -115, -119, -119, -117,
-112, -108, -101, -95, -88, -81, -75, -68, -63, -59, -66, -75, -80, -81, -80,
-78, -75, -71, -67, -61, -57, -52, -48, -43, -39, -37, -39, -46, -55, -60, -63,
-64, -63, -61, -58, -54, -51, -48, -43, -39, -36, -32, -30, -29, -26, -25, -27,
-30, -32, -33, -32, -29, -26, -24, -21, -18, -15, -14, -14, -16, -23, -34, -43,
-50, -53, -53, -53, -53, -49, -47, -44, -41, -38, -35, -31, -29, -26, -23, -21,
-18, -16, -14, -13, -11, -9, -9, -8, -8, -6, -5, -8, -12, -16, -20, -22, -22,
-22, -22, -21, -19, -18, -16, -13, -13, -10, -9, -7, -7, -5, -4, -2, -1, 0, };