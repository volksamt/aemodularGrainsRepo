#define DATA_LENGTH 512
#define DATA AKWF_1650

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 10, 14, 17, 20, 23, 26, 30,
31, 35, 37, 40, 41, 43, 46, 48, 49, 52, 53, 54, 55, 57, 58, 59, 60, 60, 62, 63,
64, 64, 65, 66, 66, 66, 67, 67, 67, 68, 69, 69, 70, 69, 69, 69, 69, 69, 69, 69,
69, 69, 68, 69, 68, 69, 69, 68, 69, 69, 68, 68, 68, 68, 68, 67, 66, 66, 67, 67,
67, 66, 66, 67, 67, 66, 66, 66, 65, 66, 66, 66, 66, 65, 66, 66, 65, 66, 66, 66,
66, 66, 66, 66, 66, 66, 67, 66, 67, 67, 67, 67, 67, 67, 68, 68, 68, 68, 68, 68,
69, 69, 68, 69, 69, 68, 69, 68, 68, 68, 67, 67, 67, 66, 67, 65, 65, 65, 65, 63,
63, 63, 61, 61, 60, 60, 59, 58, 56, 55, 54, 53, 52, 49, 47, 46, 43, 42, 39, 37,
34, 32, 29, 25, 24, 20, 17, 13, 10, 7, 3, -1, -4, -8, -10, -13, -17, -20, -22,
-26, -29, -31, -33, -35, -36, -38, -40, -41, -43, -44, -44, -44, -45, -45, -45,
-46, -46, -46, -45, -43, -43, -42, -41, -40, -41, -39, -38, -37, -36, -35, -35,
-33, -32, -32, -30, -31, -29, -28, -27, -27, -26, -25, -25, -23, -23, -23, -21,
-19, -19, -18, -16, -16, -14, -12, -11, -9, -8, -5, -3, -2, 1, 2, 5, 8, 10, 14,
16, 19, 21, 23, 27, 30, 33, 36, 38, 41, 43, 46, 48, 51, 54, 56, 59, 61, 62, 65,
68, 69, 68, 68, 67, 69, 68, 68, 68, 68, 69, 68, 68, 69, 68, 68, 68, 69, 69, 67,
69, 68, 68, 68, 68, 67, 68, 68, 65, 61, 58, 54, 49, 44, 38, 33, 27, 22, 17, 10,
5, -2, -7, -15, -20, -26, -32, -38, -43, -48, -54, -59, -64, -68, -73, -77, -81,
-85, -88, -92, -95, -98, -101, -103, -106, -107, -110, -111, -113, -115, -116,
-116, -118, -118, -118, -119, -119, -119, -119, -118, -118, -116, -115, -115,
-113, -111, -110, -107, -104, -102, -100, -98, -95, -92, -89, -85, -82, -79,
-77, -74, -71, -68, -65, -62, -60, -56, -54, -52, -49, -47, -46, -44, -42, -42,
-39, -38, -36, -36, -36, -34, -32, -33, -32, -31, -31, -31, -31, -29, -28, -29,
-28, -29, -28, -29, -28, -28, -28, -28, -28, -28, -28, -29, -29, -29, -30, -29,
-31, -31, -31, -32, -32, -33, -33, -33, -34, -34, -34, -35, -35, -36, -36, -36,
-36, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -37, -36, -37, -37, -36,
-36, -36, -36, -35, -35, -36, -34, -35, -34, -35, -33, -33, -34, -33, -33, -32,
-32, -32, -32, -31, -31, -31, -31, -31, -30, -31, -30, -29, -30, -30, -29, -30,
-29, -29, -29, -29, -29, -30, -29, -30, -30, -31, -32, -32, -33, -33, -33, -34,
-35, -35, -36, -36, -37, -37, -37, -37, -38, -38, -38, -37, -37, -35, -35, -34,
-33, -32, -30, -27, -27, -23, -22, -20, -16, -13, -10, -8, -5, -1, };