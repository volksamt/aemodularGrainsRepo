#define DATA_LENGTH 512
#define DATA AKWF_1644

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 3, 4, 6, 7, 9, 10, 12, 13, 16,
18, 20, 21, 23, 26, 28, 29, 31, 34, 36, 37, 40, 42, 44, 46, 47, 49, 51, 53, 55,
56, 58, 59, 61, 61, 62, 63, 65, 66, 65, 66, 67, 67, 66, 67, 67, 67, 66, 66, 66,
66, 65, 65, 65, 65, 65, 64, 64, 64, 64, 63, 64, 63, 63, 64, 64, 64, 64, 64, 64,
64, 66, 66, 67, 67, 68, 69, 69, 69, 71, 71, 72, 73, 73, 74, 75, 76, 77, 78, 79,
80, 80, 81, 81, 82, 83, 84, 84, 85, 85, 85, 85, 85, 85, 84, 84, 83, 82, 80, 80,
78, 77, 74, 73, 71, 70, 68, 67, 64, 62, 59, 57, 55, 52, 51, 48, 45, 43, 40, 39,
36, 34, 32, 30, 27, 24, 23, 21, 19, 17, 15, 14, 11, 10, 7, 5, 4, 2, 0, -1, -3,
-5, -6, -7, -8, -11, -13, -14, -16, -17, -18, -20, -21, -23, -24, -26, -26, -28,
-29, -31, -32, -35, -36, -37, -39, -40, -42, -43, -44, -47, -48, -50, -51, -53,
-54, -55, -57, -58, -60, -61, -64, -64, -65, -67, -68, -69, -71, -72, -73, -74,
-75, -77, -78, -78, -80, -79, -80, -81, -81, -82, -82, -82, -82, -83, -82, -83,
-82, -82, -81, -81, -79, -80, -79, -78, -76, -77, -75, -74, -72, -71, -69, -68,
-66, -64, -62, -60, -58, -56, -53, -51, -49, -47, -45, -42, -39, -37, -35, -32,
-29, -26, -24, -22, -20, -17, -13, -11, -8, -6, -3, 0, 2, 5, 7, 10, 13, 14, 18,
20, 23, 25, 27, 29, 32, 34, 37, 39, 41, 43, 45, 47, 49, 51, 53, 56, 56, 58, 60,
62, 64, 65, 66, 68, 70, 71, 73, 74, 75, 77, 79, 80, 81, 83, 84, 85, 88, 89, 90,
91, 93, 93, 95, 96, 98, 99, 101, 101, 103, 103, 105, 105, 105, 105, 106, 105,
105, 105, 105, 104, 103, 102, 101, 100, 97, 97, 95, 93, 91, 89, 87, 84, 83, 80,
78, 74, 72, 71, 67, 64, 62, 58, 57, 53, 50, 48, 46, 42, 38, 36, 33, 30, 27, 24,
21, 18, 15, 12, 9, 6, 2, 1, -3, -6, -9, -12, -14, -18, -21, -22, -26, -29, -31,
-34, -37, -39, -42, -45, -47, -49, -52, -54, -58, -59, -61, -64, -67, -68, -71,
-72, -75, -77, -79, -82, -83, -86, -88, -90, -91, -93, -96, -97, -98, -100,
-102, -104, -105, -107, -109, -109, -111, -112, -113, -114, -115, -116, -117,
-118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -118, -117, -117,
-116, -115, -115, -114, -112, -112, -110, -109, -107, -106, -104, -103, -101,
-100, -99, -96, -94, -92, -91, -89, -86, -85, -83, -81, -78, -76, -74, -72, -71,
-68, -66, -64, -62, -60, -58, -56, -54, -52, -51, -48, -47, -44, -43, -41, -39,
-37, -36, -34, -33, -31, -29, -28, -26, -25, -25, -23, -21, -20, -18, -17, -16,
-15, -14, -12, -11, -10, -8, -7, -6, -6, -3, -3, -1, };