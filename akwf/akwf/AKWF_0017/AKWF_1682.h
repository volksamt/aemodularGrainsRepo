#define DATA_LENGTH 512
#define DATA AKWF_1682

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 10, 19, 29, 37, 45, 53, 58, 61, 63,
67, 69, 72, 74, 73, 72, 72, 70, 69, 68, 68, 66, 67, 65, 65, 64, 63, 63, 61, 61,
60, 59, 58, 57, 57, 56, 56, 56, 54, 54, 53, 52, 51, 51, 51, 50, 50, 49, 48, 47,
46, 46, 45, 45, 44, 45, 43, 42, 43, 41, 41, 41, 41, 40, 40, 38, 39, 38, 37, 36,
37, 35, 36, 34, 36, 34, 34, 35, 32, 34, 31, 28, 13, 8, -25, 8, 40, 26, 34, 28,
32, 28, 30, 28, 29, 28, 28, 28, 27, 27, 27, 26, 26, 25, 24, 25, 24, 25, 24, 25,
24, 24, 23, 23, 22, 22, 22, 22, 22, 22, 22, 21, 21, 21, 21, 19, 20, 19, 20, 19,
19, 18, 19, 18, 18, 17, 18, 18, 17, 17, 16, 17, 16, 17, 16, 16, 15, 17, 15, 16,
14, 16, 13, 16, 13, 16, 13, 16, 13, 14, 10, 10, 6, 4, 0, -5, -9, -19, -17, -51,
12, 19, 9, 17, 10, 17, 10, 16, 10, 15, 10, 14, 10, 14, 10, 13, 11, 12, 11, 11,
12, 11, 12, 11, 11, 11, 10, 10, 11, 10, 10, 10, 10, 10, 11, 10, 10, 9, 9, 7, 11,
7, 15, -31, -55, -45, -49, -44, -47, -43, -44, -41, -42, -41, -40, -39, -39,
-37, -37, -36, -35, -35, -34, -32, -32, -32, -31, -30, -29, -29, -27, -28, -27,
-26, -26, -26, -24, -25, -24, -24, -23, -23, -19, -11, -6, 0, 6, 12, 17, 21, 26,
30, 34, 35, 35, 34, 33, 33, 32, 32, 31, 31, 30, 29, 29, 29, 28, 27, 26, 26, 26,
25, 25, 25, 24, 24, 24, 23, 22, 22, 21, 21, 21, 20, 21, 20, 19, 19, 18, 19, 18,
18, 17, 18, 17, 17, 16, 16, 16, 15, 16, 15, 14, 15, 15, 14, 14, 14, 14, 13, 13,
12, 13, 12, 12, 11, 13, 11, 12, 11, 11, 11, 11, 10, 10, 10, 7, 3, -9, -19, -47,
-6, 17, 6, 13, 7, 11, 8, 10, 7, 10, 8, 9, 7, 9, 8, 8, 7, 8, 8, 7, 7, 7, 8, 6, 7,
7, 7, 6, 6, 6, 7, 6, 6, 7, 6, 5, 5, 5, 6, 5, 6, 5, 5, 4, 4, 5, 5, 5, 4, 4, 5, 4,
5, 4, 3, 4, 4, 5, 3, 4, 3, 4, 4, 4, 3, 4, 3, 4, 3, 4, 2, 4, 3, 3, 4, 2, 3, 3, 4,
2, 5, 1, 7, -3, 14, -38, -100, -83, -92, -85, -88, -85, -86, -84, -84, -82, -82,
-82, -80, -81, -78, -79, -77, -77, -76, -76, -74, -74, -73, -73, -72, -72, -70,
-70, -69, -69, -68, -68, -66, -66, -64, -65, -65, -63, -63, -61, -63, -57, -107,
-122, -113, -117, -111, -112, -108, -109, -105, -106, -103, -103, -100, -99,
-97, -96, -94, -94, -92, -91, -90, -89, -88, -86, -86, -84, -83, -82, -80, -80,
-79, -77, -77, -75, -75, -69, -63, -56, -51, -41, -29, -19, -7, };