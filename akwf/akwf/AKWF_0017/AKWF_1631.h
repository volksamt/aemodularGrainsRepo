#define DATA_LENGTH 512
#define DATA AKWF_1631

const PROGMEM int8_t DATA[DATA_LENGTH] = {41, 63, 58, 61, 58, 59, 57, 59, 57,
58, 56, 57, 57, 56, 56, 56, 55, 55, 55, 55, 54, 53, 53, 53, 53, 52, 52, 51, 51,
51, 51, 49, 50, 50, 49, 48, 49, 48, 48, 47, 47, 47, 46, 46, 46, 46, 45, 45, 44,
45, 44, 43, 43, 43, 42, 41, 42, 41, 41, 40, 40, 40, 39, 39, 39, 38, 38, 37, 36,
38, 36, 36, 36, 36, 36, 35, 35, 34, 34, 34, 34, 33, 33, 32, 32, 31, 30, 30, 31,
30, 30, 29, 29, 29, 29, 28, 27, 27, 27, 27, 27, 26, 26, 25, 24, 25, 25, 24, 24,
23, 23, 22, 22, 22, 21, 21, 21, 21, 20, 20, 20, 19, 19, 19, 18, 18, 17, 17, 17,
16, 16, 16, 16, 15, 15, 15, 14, 14, 13, 14, 13, 13, 13, 11, 11, 11, 11, 11, 10,
10, 10, 9, 8, 9, 8, 8, 7, 7, 7, 7, 6, 6, 4, 5, 4, 5, 3, 5, 3, 4, 2, 3, 1, 2, 1,
2, 1, 1, 0, -1, 1, -3, 1, -28, 43, 71, 52, 64, 55, 61, 55, 60, 56, 58, 56, 57,
55, 56, 55, 55, 55, 54, 54, 53, 53, 53, 53, 51, 52, 51, 52, 50, 50, 51, 50, 49,
49, 49, 48, 48, 48, 48, 47, 46, 46, 46, 45, 45, 45, 45, 44, 44, 43, 43, 43, 43,
42, 42, 42, 42, 41, 40, 41, 39, 40, 40, 39, 38, 37, 38, 38, 37, 37, 36, 36, 36,
35, 35, 34, 34, 34, 34, 34, 33, 33, 33, 32, 32, 31, 31, 30, 31, 30, 29, 29, 29,
28, 28, 28, 27, 28, 26, 27, 26, 25, 25, 25, 25, 25, 24, 24, 23, 23, 23, 23, 22,
22, 21, 20, 21, 21, 20, 20, 20, 19, 18, 18, 18, 17, 17, 17, 16, 16, 16, 15, 15,
15, 14, 14, 14, 12, 13, 13, 12, 12, 12, 11, 11, 11, 10, 9, 10, 10, 9, 9, 8, 8,
8, 7, 7, 7, 6, 5, 6, 5, 5, 5, 5, 3, 4, 4, 3, 2, 2, 2, 2, 1, 1, 1, 0, 0, -1, -1,
-1, -1, -1, -2, -3, -4, -3, -3, -4, -4, -4, -5, -6, -5, -5, -6, -7, -6, -7, -7,
-8, -7, -9, -9, -9, -9, -10, -9, -11, -69, -96, -88, -92, -89, -92, -91, -92,
-92, -94, -92, -93, -93, -93, -94, -95, -94, -95, -95, -95, -96, -96, -96, -97,
-97, -98, -98, -98, -99, -99, -99, -100, -100, -100, -100, -101, -100, -101,
-101, -102, -102, -103, -102, -102, -103, -104, -104, -104, -104, -105, -105,
-105, -106, -106, -107, -107, -106, -108, -108, -108, -108, -108, -108, -109,
-110, -110, -110, -111, -110, -111, -111, -111, -113, -112, -113, -113, -113,
-114, -114, -114, -114, -115, -115, -116, -114, -119, -80, -52, -59, -55, -56,
-54, -54, -53, -53, -52, -51, -51, -50, -49, -49, -48, -47, -47, -46, -46, -46,
-44, -44, -42, -43, -41, -42, -40, -41, -38, -40, -36, -40, -33, };