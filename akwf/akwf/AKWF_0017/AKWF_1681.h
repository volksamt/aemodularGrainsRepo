#define DATA_LENGTH 512
#define DATA AKWF_1681

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 8, 10, 12, 16, 18, 20, 22, 25,
27, 29, 30, 33, 34, 36, 38, 41, 43, 43, 46, 47, 49, 52, 53, 54, 55, 58, 59, 61,
63, 63, 65, 66, 67, 68, 68, 68, 68, 69, 69, 69, 69, 70, 71, 72, 73, 74, 75, 76,
76, 78, 79, 80, 81, 83, 84, 84, 85, 86, 87, 87, 88, 88, 90, 89, 90, 89, 89, 89,
90, 87, 86, 86, 86, 83, 83, 82, 81, 80, 80, 80, 80, 80, 80, 80, 79, 81, 80, 79,
80, 80, 80, 79, 80, 79, 79, 80, 79, 79, 80, 80, 79, 79, 79, 79, 79, 80, 79, 79,
79, 78, 78, 78, 78, 78, 78, 76, 75, 75, 74, 72, 71, 70, 68, 66, 64, 62, 62, 60,
60, 58, 57, 57, 57, 56, 55, 56, 54, 54, 53, 54, 53, 52, 52, 52, 51, 51, 51, 51,
51, 51, 52, 51, 52, 53, 53, 56, 57, 59, 60, 62, 64, 67, 70, 73, 75, 79, 81, 83,
85, 86, 87, 88, 88, 89, 88, 88, 88, 87, 87, 86, 86, 85, 85, 85, 84, 83, 83, 82,
81, 81, 80, 80, 78, 78, 78, 77, 76, 74, 74, 73, 72, 71, 70, 68, 66, 65, 63, 61,
59, 57, 55, 54, 52, 50, 51, 50, 48, 48, 46, 46, 45, 45, 44, 43, 42, 42, 40, 39,
38, 38, 38, 36, 35, 34, 33, 31, 30, 29, 26, 25, 23, 21, 18, 16, 14, 11, 8, 7, 6,
4, 3, 3, 2, 0, 0, -1, -3, -3, -4, -5, -6, -7, -8, -8, -9, -10, -10, -11, -11,
-12, -12, -13, -14, -14, -15, -15, -15, -17, -17, -18, -19, -19, -19, -21, -20,
-22, -23, -24, -25, -27, -27, -30, -32, -34, -36, -37, -39, -40, -41, -42, -44,
-45, -45, -46, -47, -47, -47, -48, -49, -49, -50, -50, -51, -51, -51, -52, -52,
-52, -53, -52, -52, -52, -52, -52, -50, -50, -48, -46, -45, -43, -41, -38, -36,
-33, -31, -28, -25, -23, -21, -21, -19, -18, -18, -19, -18, -19, -19, -18, -19,
-20, -21, -21, -21, -23, -23, -25, -25, -27, -28, -28, -29, -30, -30, -32, -33,
-34, -35, -35, -37, -38, -40, -40, -42, -44, -45, -47, -49, -51, -53, -56, -58,
-60, -62, -64, -65, -66, -67, -68, -69, -70, -71, -72, -72, -73, -74, -75, -76,
-77, -78, -79, -81, -81, -82, -83, -84, -85, -87, -89, -90, -93, -95, -96, -98,
-101, -103, -105, -108, -109, -111, -112, -113, -114, -114, -114, -115, -115,
-116, -116, -118, -117, -119, -118, -119, -118, -119, -118, -119, -120, -119,
-119, -118, -119, -117, -117, -117, -117, -117, -116, -116, -116, -115, -115,
-114, -113, -113, -112, -112, -112, -111, -111, -112, -112, -111, -112, -114,
-114, -114, -114, -114, -113, -112, -111, -110, -109, -107, -106, -105, -103,
-103, -101, -99, -98, -96, -96, -93, -92, -89, -87, -85, -83, -82, -79, -76,
-74, -70, -67, -63, -60, -55, -52, -47, -41, -37, -32, -27, -21, -17, -11, -7,
-2, };