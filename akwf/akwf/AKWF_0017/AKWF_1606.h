#define DATA_LENGTH 512
#define DATA AKWF_1606

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 11, 16, 21, 25, 30, 33, 38, 42,
45, 49, 52, 55, 58, 60, 63, 65, 68, 70, 72, 74, 76, 78, 79, 80, 83, 84, 86, 89,
89, 91, 93, 94, 96, 97, 99, 99, 101, 101, 103, 103, 104, 105, 106, 108, 107,
108, 109, 109, 109, 110, 110, 109, 109, 110, 110, 109, 109, 109, 109, 109, 108,
109, 110, 110, 111, 112, 112, 113, 113, 114, 114, 116, 117, 118, 118, 119, 118,
120, 119, 119, 119, 119, 118, 117, 116, 115, 113, 111, 110, 108, 105, 103, 100,
98, 94, 91, 89, 85, 81, 77, 74, 71, 67, 63, 60, 55, 51, 47, 44, 40, 36, 32, 27,
24, 18, 14, 9, 6, 0, -4, -10, -14, -18, -23, -27, -31, -36, -40, -44, -46, -49,
-52, -55, -56, -59, -61, -62, -63, -64, -66, -65, -66, -67, -67, -67, -67, -68,
-69, -69, -71, -70, -71, -72, -74, -75, -76, -77, -80, -80, -82, -84, -85, -87,
-88, -90, -91, -93, -95, -96, -98, -100, -101, -103, -104, -106, -106, -108,
-108, -109, -110, -111, -112, -112, -113, -113, -113, -114, -115, -115, -114,
-115, -115, -115, -115, -116, -115, -115, -115, -116, -115, -113, -113, -112,
-109, -107, -106, -103, -101, -99, -96, -93, -90, -86, -83, -80, -76, -73, -70,
-67, -64, -61, -57, -53, -51, -48, -46, -43, -41, -38, -36, -34, -32, -30, -29,
-28, -26, -25, -23, -21, -21, -20, -18, -17, -17, -14, -13, -11, -10, -9, -7,
-6, -4, -3, -1, 1, 2, 5, 6, 7, 9, 10, 11, 13, 14, 15, 18, 19, 19, 21, 22, 24,
25, 26, 27, 29, 31, 33, 34, 36, 38, 41, 43, 46, 48, 52, 54, 57, 61, 63, 67, 70,
74, 77, 81, 84, 87, 90, 93, 97, 98, 101, 103, 106, 108, 110, 112, 113, 114, 114,
115, 115, 116, 116, 115, 115, 116, 115, 114, 115, 115, 115, 114, 113, 113, 112,
112, 112, 112, 111, 109, 109, 108, 107, 106, 103, 103, 102, 100, 98, 95, 95, 92,
92, 89, 88, 87, 85, 83, 82, 81, 78, 78, 77, 75, 74, 73, 72, 71, 70, 69, 69, 68,
67, 67, 67, 66, 67, 65, 65, 64, 63, 62, 61, 59, 57, 54, 51, 49, 47, 43, 39, 36,
31, 27, 23, 19, 14, 9, 4, 0, -6, -10, -15, -19, -24, -28, -32, -36, -40, -44,
-48, -52, -55, -60, -63, -67, -70, -74, -79, -82, -85, -88, -92, -95, -98, -101,
-103, -105, -109, -110, -112, -113, -115, -116, -117, -118, -119, -118, -119,
-119, -119, -119, -119, -117, -117, -117, -117, -115, -115, -114, -112, -112,
-111, -111, -110, -109, -109, -109, -108, -109, -109, -109, -110, -109, -109,
-110, -109, -110, -109, -109, -109, -109, -109, -108, -107, -106, -105, -105,
-104, -103, -101, -100, -100, -98, -97, -96, -94, -92, -90, -90, -88, -86, -85,
-82, -81, -79, -77, -75, -74, -71, -70, -69, -65, -63, -61, -58, -55, -52, -49,
-45, -42, -37, -34, -30, -24, -20, -17, -11, -6, -2, };