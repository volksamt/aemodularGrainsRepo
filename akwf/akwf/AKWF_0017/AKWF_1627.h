#define DATA_LENGTH 512
#define DATA AKWF_1627

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 11, 18, 23, 28, 33, 39, 43, 48, 52,
59, 63, 67, 72, 75, 78, 82, 87, 87, 92, 92, 99, 94, 106, 95, 118, 57, -13, 13,
6, 20, 21, 31, 32, 40, 44, 49, 53, 58, 63, 65, 71, 74, 79, 81, 86, 88, 92, 93,
97, 98, 101, 103, 105, 105, 107, 108, 109, 110, 110, 109, 109, 109, 109, 109,
108, 106, 104, 104, 102, 101, 99, 98, 96, 93, 92, 90, 87, 85, 83, 81, 79, 77,
74, 71, 69, 66, 63, 61, 59, 57, 55, 52, 49, 47, 45, 43, 40, 38, 36, 34, 32, 31,
28, 26, 24, 22, 20, 20, 18, 17, 15, 13, 13, 11, 9, 8, 7, 7, 5, 4, 4, 3, 2, 1,
-1, -1, -1, -2, -2, -3, -3, -3, -4, -4, -5, -6, -5, -6, -5, -6, -6, -7, -7, -7,
-6, -7, -7, -7, -7, -7, -7, -8, -7, -7, -7, -7, -6, -7, -7, -6, -7, -8, -7, -8,
-8, -8, -8, -9, -9, -8, -9, -9, -10, -11, -11, -11, -11, -12, -12, -13, -14,
-14, -15, -16, -16, -17, -18, -19, -20, -21, -23, -24, -25, -26, -26, -28, -30,
-31, -32, -34, -36, -37, -39, -41, -42, -44, -46, -48, -50, -52, -54, -56, -58,
-60, -62, -65, -67, -69, -70, -73, -75, -77, -80, -82, -83, -86, -89, -91, -92,
-94, -97, -98, -99, -102, -103, -104, -106, -106, -108, -110, -110, -112, -111,
-112, -112, -113, -113, -113, -112, -111, -110, -109, -109, -107, -105, -104,
-102, -101, -98, -95, -93, -90, -87, -83, -80, -76, -73, -68, -65, -61, -55,
-52, -48, -43, -38, -34, -28, -23, -18, -13, -9, -3, 1, 7, 11, 16, 21, 26, 30,
35, 40, 43, 48, 52, 56, 59, 63, 66, 69, 73, 75, 78, 79, 82, 85, 87, 88, 89, 91,
91, 91, 92, 93, 94, 94, 94, 93, 93, 92, 92, 91, 91, 90, 88, 87, 85, 84, 83, 81,
78, 78, 75, 73, 72, 69, 68, 66, 63, 61, 60, 57, 55, 54, 50, 49, 47, 44, 42, 40,
40, 36, 34, 33, 32, 29, 28, 27, 25, 23, 22, 19, 17, 18, 16, 14, 13, 11, 10, 10,
8, 7, 5, 6, 4, 3, 3, 2, 1, 1, 0, -2, 0, -2, -2, -3, -3, -3, -4, -4, -4, -5, -5,
-6, -6, -6, -6, -7, -6, -6, -7, -7, -6, -6, -6, -7, -7, -8, -7, -6, -6, -7, -6,
-7, -7, -7, -7, -7, -7, -7, -7, -8, -7, -8, -8, -8, -9, -8, -9, -9, -10, -10,
-11, -11, -10, -12, -12, -13, -14, -14, -15, -16, -17, -18, -18, -19, -20, -22,
-23, -24, -26, -26, -27, -28, -30, -32, -33, -35, -37, -38, -39, -42, -44, -45,
-47, -49, -51, -54, -56, -58, -59, -62, -64, -67, -69, -72, -73, -77, -79, -81,
-83, -86, -88, -89, -93, -95, -96, -99, -101, -104, -105, -106, -108, -110,
-111, -113, -114, -115, -116, -118, -116, -120, -118, -119, -117, -119, -117,
-120, -113, -121, -84, -3, };