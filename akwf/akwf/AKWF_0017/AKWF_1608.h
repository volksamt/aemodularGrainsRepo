#define DATA_LENGTH 512
#define DATA AKWF_1608

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 25, 44, 59, 75, 85, 94, 102, 108,
111, 114, 117, 118, 118, 119, 118, 118, 118, 116, 116, 115, 115, 114, 113, 113,
112, 111, 111, 110, 110, 109, 109, 110, 108, 109, 109, 109, 109, 109, 109, 108,
109, 109, 109, 109, 109, 109, 109, 108, 108, 106, 106, 104, 102, 101, 98, 95,
94, 91, 88, 84, 81, 78, 74, 71, 68, 65, 62, 58, 56, 53, 50, 48, 47, 45, 44, 42,
42, 40, 40, 39, 39, 39, 40, 41, 41, 42, 43, 45, 46, 48, 50, 52, 53, 55, 56, 58,
58, 60, 62, 63, 63, 64, 64, 65, 65, 65, 66, 65, 65, 64, 64, 63, 63, 63, 63, 63,
63, 63, 63, 61, 61, 61, 61, 61, 60, 58, 58, 58, 57, 56, 54, 52, 52, 51, 49, 45,
43, 40, 37, 32, 26, 20, 13, 2, -8, -18, -26, -34, -41, -46, -50, -52, -52, -53,
-52, -50, -48, -44, -40, -35, -30, -25, -21, -14, -10, -4, 2, 7, 12, 16, 20, 25,
30, 34, 37, 39, 43, 46, 48, 50, 52, 54, 56, 57, 58, 59, 61, 62, 63, 63, 64, 64,
65, 67, 67, 69, 69, 71, 71, 72, 73, 73, 74, 75, 74, 74, 74, 72, 69, 66, 60, 53,
44, 36, 29, 22, 16, 8, 2, -6, -15, -25, -39, -54, -70, -83, -90, -95, -97, -96,
-95, -92, -89, -84, -79, -75, -70, -64, -59, -54, -50, -45, -41, -37, -34, -30,
-27, -23, -19, -16, -14, -9, -7, -4, -1, 1, 4, 7, 10, 13, 16, 20, 23, 26, 30,
33, 37, 41, 46, 50, 55, 60, 64, 69, 75, 79, 84, 89, 92, 95, 97, 97, 95, 91, 82,
69, 52, 38, 25, 14, 5, -2, -9, -16, -23, -29, -36, -44, -54, -60, -65, -69, -72,
-73, -75, -74, -74, -74, -74, -73, -72, -70, -70, -69, -68, -68, -67, -66, -65,
-64, -63, -62, -62, -60, -59, -59, -56, -56, -54, -52, -50, -49, -45, -43, -40,
-37, -32, -30, -26, -21, -16, -11, -6, -1, 5, 10, 15, 20, 27, 31, 36, 40, 44,
48, 51, 52, 54, 54, 51, 49, 46, 41, 33, 26, 17, 8, -3, -12, -21, -27, -32, -37,
-41, -44, -46, -48, -50, -53, -53, -55, -55, -57, -58, -58, -59, -60, -60, -60,
-60, -62, -62, -62, -62, -62, -63, -63, -63, -63, -64, -64, -65, -64, -65, -66,
-64, -65, -65, -65, -64, -63, -62, -62, -60, -59, -58, -56, -54, -52, -51, -49,
-48, -46, -45, -43, -42, -41, -40, -40, -40, -40, -39, -40, -40, -42, -43, -43,
-44, -47, -49, -51, -54, -56, -59, -62, -65, -68, -71, -74, -79, -81, -85, -88,
-92, -94, -96, -99, -101, -103, -104, -106, -106, -107, -108, -109, -109, -110,
-109, -109, -109, -109, -109, -108, -108, -109, -109, -109, -109, -109, -110,
-109, -109, -110, -111, -111, -111, -111, -112, -114, -114, -114, -115, -117,
-118, -117, -119, -119, -118, -119, -118, -117, -115, -111, -108, -101, -95,
-84, -73, -59, -43, -22, -6, };