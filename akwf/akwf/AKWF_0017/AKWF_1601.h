#define DATA_LENGTH 512
#define DATA AKWF_1601

const PROGMEM int8_t DATA[DATA_LENGTH] = {66, 114, 100, 109, 105, 109, 106, 109,
106, 109, 108, 109, 108, 108, 109, 110, 110, 110, 111, 111, 111, 111, 112, 111,
112, 112, 113, 113, 113, 112, 113, 113, 114, 113, 114, 114, 114, 115, 115, 115,
115, 115, 116, 116, 115, 116, 116, 116, 116, 116, 116, 117, 117, 118, 118, 117,
118, 118, 117, 118, 118, 119, 118, 118, 118, 118, 119, 119, 119, 119, 119, 118,
119, 119, 118, 119, 118, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119,
119, 118, 118, 119, 118, 118, 118, 118, 118, 117, 117, 117, 118, 117, 117, 118,
116, 117, 114, 118, 104, 87, 87, 82, 81, 78, 77, 74, 73, 70, 68, 67, 65, 64, 61,
61, 58, 56, 54, 53, 51, 49, 48, 47, 45, 42, 41, 40, 37, 36, 34, 31, 30, 28, 26,
23, 22, 17, 18, 1, -14, -10, -13, -12, -13, -12, -13, -12, -13, -13, -14, -14,
-14, -14, -14, -15, -14, -14, -15, -14, -14, -15, -14, -15, -15, -15, -15, -15,
-15, -15, -14, -15, -14, -15, -16, -14, -15, -14, -14, -14, -15, -14, -14, -14,
-14, -14, -13, -13, -13, -13, -13, -13, -13, -12, -13, -12, -13, -12, -12, -12,
-12, -11, -11, -12, -11, -11, -10, -11, -10, -10, -10, -10, -10, -10, -10, -9,
-9, -9, -8, -8, -8, -8, -7, -7, -8, -6, -7, -7, -6, -5, -5, -5, -5, -5, -4, -4,
-4, -3, -3, -2, -2, -1, -2, -2, 0, -1, -1, 0, 0, 1, 1, 2, 2, 2, 2, 2, 2, 3, 4,
4, 4, 4, 5, 5, 5, 6, 7, 6, 6, 7, 7, 7, 7, 8, 8, 8, 8, 8, 9, 8, 9, 10, 9, 11, 10,
10, 10, 10, 11, 11, 11, 11, 12, 11, 12, 12, 12, 12, 13, 12, 13, 13, 13, 13, 13,
13, 13, 14, 14, 13, 14, 15, 14, 14, 14, 15, 14, 14, 14, 14, 15, 14, 15, 15, 14,
15, 14, 14, 15, 14, 15, 14, 15, 15, 15, 14, 15, 14, 14, 13, 14, 14, 14, 14, 13,
13, 14, 13, 13, 14, 12, 13, 12, 12, 11, 14, -3, -17, -17, -23, -23, -26, -28,
-30, -31, -34, -35, -37, -40, -41, -42, -44, -46, -47, -50, -51, -53, -54, -57,
-58, -59, -62, -64, -65, -67, -68, -71, -73, -74, -77, -79, -81, -83, -87, -88,
-105, -119, -114, -117, -116, -117, -117, -117, -117, -118, -118, -118, -118,
-118, -118, -118, -119, -119, -119, -118, -119, -119, -119, -118, -119, -119,
-120, -119, -119, -119, -119, -118, -119, -119, -119, -120, -119, -119, -119,
-118, -118, -118, -119, -118, -118, -118, -119, -119, -118, -118, -118, -117,
-117, -117, -117, -117, -117, -117, -117, -116, -116, -116, -116, -116, -115,
-115, -116, -115, -115, -115, -114, -115, -115, -114, -114, -114, -113, -113,
-113, -113, -113, -112, -113, -112, -113, -112, -112, -111, -112, -111, -111,
-110, -111, -110, -109, -109, -108, -109, -108, -107, -107, -107, -106, -108,
-104, -110, -101, -113, -62, };