#define DATA_LENGTH 512
#define DATA AKWF_1604

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 7, 9, 11, 13, 16, 18, 20, 23,
25, 28, 31, 32, 35, 37, 40, 43, 44, 47, 49, 52, 53, 56, 58, 60, 62, 64, 67, 68,
71, 72, 74, 76, 78, 80, 82, 83, 86, 87, 89, 91, 92, 92, 95, 96, 98, 99, 100,
101, 103, 103, 106, 107, 108, 108, 109, 110, 111, 113, 113, 113, 114, 115, 115,
116, 117, 117, 118, 117, 117, 118, 118, 119, 118, 120, 119, 118, 119, 118, 119,
119, 118, 119, 118, 117, 117, 117, 116, 116, 116, 115, 114, 114, 113, 112, 112,
111, 109, 109, 109, 108, 106, 105, 104, 104, 103, 101, 100, 100, 98, 97, 96, 95,
94, 92, 91, 90, 89, 88, 86, 85, 83, 82, 82, 80, 79, 77, 76, 73, 70, 68, 66, 63,
61, 58, 55, 53, 51, 49, 46, 44, 41, 39, 36, 34, 32, 30, 27, 26, 22, 21, 19, 17,
15, 12, 10, 8, 6, 5, 3, 0, -1, -2, -5, -7, -9, -11, -12, -14, -15, -17, -18,
-19, -21, -22, -24, -25, -26, -27, -29, -30, -31, -32, -32, -33, -35, -35, -36,
-36, -37, -38, -39, -39, -40, -40, -41, -41, -42, -41, -42, -42, -42, -43, -42,
-42, -42, -41, -42, -42, -41, -41, -41, -41, -40, -40, -40, -40, -38, -38, -37,
-36, -36, -35, -35, -34, -34, -32, -32, -30, -29, -28, -28, -26, -27, -25, -23,
-22, -22, -20, -19, -18, -17, -16, -14, -13, -12, -10, -10, -8, -7, -5, -5, -4,
-2, 0, 1, 1, 4, 4, 6, 7, 9, 10, 11, 12, 14, 15, 15, 16, 19, 19, 21, 22, 23, 24,
25, 26, 27, 28, 29, 30, 30, 31, 33, 34, 35, 34, 35, 36, 37, 37, 39, 38, 38, 39,
40, 40, 41, 41, 42, 42, 42, 43, 43, 42, 42, 42, 42, 43, 42, 41, 41, 42, 40, 41,
40, 40, 39, 38, 38, 37, 37, 36, 35, 34, 34, 33, 31, 30, 29, 28, 27, 26, 25, 23,
23, 21, 19, 18, 17, 15, 13, 12, 9, 8, 6, 5, 3, 2, 0, -3, -4, -6, -8, -10, -12,
-15, -17, -18, -21, -23, -25, -28, -30, -32, -35, -37, -40, -41, -44, -46, -48,
-51, -53, -57, -59, -61, -63, -66, -69, -70, -74, -76, -78, -79, -80, -82, -83,
-83, -85, -86, -88, -89, -91, -91, -92, -93, -95, -96, -97, -98, -99, -100,
-101, -102, -104, -105, -106, -107, -107, -108, -109, -110, -111, -111, -112,
-113, -114, -114, -115, -115, -116, -117, -117, -117, -118, -118, -118, -118,
-118, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -118, -118,
-118, -117, -117, -116, -115, -114, -114, -114, -112, -112, -111, -110, -109,
-108, -107, -106, -105, -103, -103, -101, -100, -98, -97, -96, -94, -93, -91,
-90, -89, -86, -86, -84, -81, -80, -78, -75, -74, -72, -70, -69, -66, -64, -62,
-60, -58, -56, -54, -51, -49, -47, -44, -42, -39, -38, -35, -33, -31, -27, -25,
-23, -20, -18, -15, -13, -11, -9, -5, -3, -1, };