#define DATA_LENGTH 512
#define DATA AKWF_1640

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 7, 12, 17, 23, 27, 31, 35, 40, 44,
48, 51, 54, 57, 60, 63, 66, 69, 72, 74, 76, 78, 81, 81, 84, 86, 87, 89, 91, 92,
94, 95, 96, 98, 98, 100, 100, 101, 102, 104, 104, 105, 106, 106, 107, 107, 108,
109, 109, 111, 111, 111, 112, 112, 112, 113, 113, 114, 114, 114, 115, 115, 115,
115, 115, 116, 116, 117, 117, 116, 117, 117, 117, 117, 117, 118, 118, 118, 117,
118, 118, 118, 118, 118, 119, 118, 118, 119, 119, 119, 118, 118, 119, 119, 119,
119, 118, 119, 119, 118, 119, 120, 119, 118, 120, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 118, 118, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 118, 118, 118,
119, 119, 119, 119, 119, 118, 118, 118, 118, 118, 118, 118, 117, 118, 118, 117,
118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 117, 117, 118, 118, 117,
118, 118, 118, 117, 118, 117, 117, 117, 117, 117, 118, 117, 117, 118, 117, 117,
118, 117, 116, 116, 117, 116, 117, 117, 117, 117, 116, 116, 116, 117, 117, 117,
117, 117, 116, 117, 116, 116, 116, 116, 116, 116, 117, 117, 116, 116, 116, 116,
115, 117, 116, 114, 107, 94, 80, 68, 55, 45, 34, 24, 14, 5, -4, -14, -22, -29,
-36, -42, -50, -56, -62, -67, -73, -78, -83, -88, -92, -97, -101, -104, -108,
-112, -115, -118, -119, -115, -113, -112, -111, -110, -107, -106, -105, -103,
-102, -100, -99, -99, -98, -96, -96, -95, -94, -93, -92, -92, -91, -91, -90,
-91, -89, -89, -89, -88, -87, -87, -86, -87, -87, -86, -86, -86, -86, -86, -85,
-86, -86, -86, -86, -86, -86, -85, -86, -86, -85, -86, -86, -86, -86, -85, -86,
-85, -86, -85, -85, -85, -86, -85, -86, -86, -86, -85, -86, -86, -86, -86, -86,
-87, -87, -87, -86, -86, -87, -87, -87, -88, -87, -87, -87, -88, -87, -87, -88,
-88, -88, -89, -89, -88, -88, -89, -89, -88, -90, -89, -89, -89, -90, -90, -91,
-90, -91, -91, -91, -91, -92, -91, -92, -92, -92, -92, -92, -92, -91, -93, -92,
-92, -92, -92, -92, -93, -93, -93, -92, -93, -93, -93, -94, -94, -94, -93, -94,
-94, -94, -94, -93, -94, -94, -94, -95, -95, -95, -95, -95, -96, -96, -96, -95,
-96, -96, -97, -97, -97, -97, -97, -98, -98, -97, -98, -99, -98, -99, -99, -99,
-99, -99, -99, -99, -100, -99, -99, -100, -100, -100, -100, -100, -100, -101,
-101, -101, -102, -102, -102, -101, -102, -102, -101, -102, -102, -102, -102,
-102, -102, -103, -102, -102, -102, -102, -103, -102, -102, -103, -103, -102,
-104, -104, -104, -105, -104, -106, -105, -106, -106, -107, -107, -107, -107,
-107, -108, -108, -108, -108, -108, -109, -109, -109, -109, -109, -108, -110,
-109, -109, -110, -110, -108, -101, -90, -80, -70, -62, -53, -45, -38, -30, -22,
-16, -10, -3, };