#define DATA_LENGTH 512
#define DATA AKWF_1641

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 3, 4, 5, 6, 8, 8, 10, 10, 11, 13,
16, 17, 18, 20, 22, 24, 26, 27, 28, 30, 31, 32, 34, 34, 36, 38, 41, 42, 45, 46,
48, 49, 52, 53, 54, 55, 57, 58, 60, 60, 62, 63, 65, 67, 68, 70, 71, 72, 74, 75,
75, 77, 78, 79, 79, 81, 81, 82, 84, 85, 86, 87, 88, 90, 90, 91, 92, 94, 94, 94,
96, 97, 98, 98, 98, 100, 100, 100, 101, 103, 103, 104, 104, 104, 105, 106, 107,
106, 108, 108, 109, 109, 110, 110, 110, 111, 112, 112, 112, 112, 113, 113, 113,
114, 113, 114, 115, 114, 115, 116, 117, 117, 117, 117, 118, 118, 118, 118, 119,
119, 119, 119, 119, 118, 117, 116, 116, 115, 115, 115, 113, 113, 112, 112, 112,
111, 108, 102, 92, 83, 74, 65, 55, 48, 40, 33, 27, 20, 13, 8, 1, -3, -8, -14,
-18, -22, -26, -30, -34, -37, -40, -44, -47, -49, -52, -55, -57, -60, -62, -63,
-63, -63, -62, -61, -61, -61, -60, -59, -59, -59, -58, -58, -58, -57, -57, -58,
-59, -59, -60, -62, -63, -64, -65, -66, -67, -67, -68, -68, -69, -70, -69, -69,
-68, -67, -68, -65, -65, -64, -63, -63, -63, -62, -61, -61, -60, -59, -58, -59,
-59, -59, -60, -60, -59, -60, -59, -60, -60, -59, -60, -60, -59, -61, -60, -60,
-60, -58, -58, -58, -57, -57, -55, -55, -55, -54, -54, -53, -53, -52, -52, -51,
-50, -48, -47, -47, -45, -44, -43, -42, -41, -40, -38, -38, -36, -36, -35, -34,
-35, -34, -33, -32, -31, -31, -30, -30, -29, -30, -28, -29, -28, -28, -27, -28,
-27, -26, -26, -26, -25, -24, -25, -24, -24, -23, -24, -23, -23, -23, -22, -22,
-21, -20, -21, -20, -20, -20, -20, -19, -19, -19, -18, -17, -17, -17, -17, -16,
-16, -15, -14, -14, -13, -13, -13, -12, -12, -11, -12, -11, -10, -10, -10, -6,
-1, 4, 9, 12, 18, 22, 26, 30, 33, 36, 40, 43, 45, 49, 51, 53, 53, 55, 55, 55,
55, 56, 55, 56, 56, 56, 57, 57, 56, 57, 57, 57, 54, 50, 48, 46, 43, 39, 38, 35,
33, 31, 29, 27, 26, 23, 21, 19, 14, 10, 7, 4, 0, -3, -6, -9, -12, -15, -18, -20,
-22, -23, -26, -29, -32, -35, -38, -40, -42, -44, -47, -49, -52, -53, -55, -56,
-60, -60, -62, -63, -64, -65, -66, -67, -67, -68, -69, -70, -71, -71, -71, -72,
-73, -73, -74, -74, -74, -73, -73, -73, -73, -73, -73, -72, -72, -72, -72, -72,
-72, -72, -71, -71, -70, -71, -69, -69, -68, -67, -66, -67, -65, -65, -65, -65,
-64, -64, -63, -62, -61, -60, -59, -57, -56, -56, -54, -53, -52, -52, -51, -50,
-49, -48, -48, -47, -45, -44, -43, -41, -41, -40, -39, -38, -38, -36, -35, -34,
-34, -33, -32, -31, -29, -27, -26, -24, -22, -20, -20, -18, -17, -16, -15, -13,
-11, -10, -10, -9, -6, -4, -3, -1, 0, };