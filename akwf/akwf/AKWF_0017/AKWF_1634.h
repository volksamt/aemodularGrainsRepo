#define DATA_LENGTH 512
#define DATA AKWF_1634

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 71, 71, 70, 71, 69, 70, 68, 69, 67,
68, 66, 67, 65, 66, 64, 65, 62, 64, 62, 61, 61, 61, 61, 60, 59, 59, 59, 58, 58,
57, 57, 57, 57, 55, 56, 55, 55, 54, 54, 54, 53, 53, 52, 52, 53, 51, 52, 51, 51,
49, 50, 50, 50, 50, 49, 48, 47, 47, 47, 46, 47, 46, 47, 46, 46, 45, 45, 44, 44,
44, 44, 43, 43, 43, 42, 43, 42, 42, 42, 40, 40, 40, 40, 39, 40, 39, 40, 40, 41,
41, 42, 43, 43, 43, 43, 44, 44, 45, 47, 47, 48, 48, 49, 50, 50, 50, 50, 52, 52,
52, 52, 53, 54, 54, 55, 55, 55, 57, 57, 57, 58, 58, 58, 58, 60, 60, 61, 61, 61,
63, 62, 63, 63, 63, 65, 65, 65, 66, 66, 67, 67, 68, 68, 69, 69, 70, 69, 70, 71,
71, 72, 73, 72, 73, 73, 74, 74, 74, 75, 75, 75, 76, 76, 77, 76, 78, 78, 78, 78,
79, 79, 80, 80, 81, 80, 81, 81, 81, 82, 82, 82, 83, 83, 83, 84, 84, 85, 85, 85,
85, 85, 86, 87, 87, 87, 87, 88, 88, 88, 88, 89, 89, 89, 90, 90, 90, 90, 90, 91,
91, 91, 91, 91, 91, 91, 92, 93, 92, 93, 92, 93, 93, 92, 94, 94, 93, 95, 95, 94,
94, 95, 94, 94, 94, 95, 95, 95, 95, 95, 96, 96, 96, 95, 95, 96, 95, 95, 97, 96,
96, 95, 96, 96, 96, 96, 96, 96, 96, 96, 97, 96, 96, 96, 96, 96, 94, 88, 67, 41,
21, 3, -12, -26, -37, -46, -54, -62, -68, -75, -80, -86, -91, -95, -98, -102,
-105, -107, -110, -111, -112, -115, -116, -116, -117, -117, -118, -118, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -118, -118, -119, -118, -118,
-118, -118, -118, -118, -117, -116, -117, -117, -116, -116, -115, -115, -114,
-114, -113, -113, -113, -111, -111, -111, -110, -109, -109, -108, -107, -107,
-107, -105, -105, -105, -104, -103, -102, -102, -101, -100, -99, -98, -98, -97,
-96, -96, -96, -94, -93, -93, -92, -92, -91, -89, -89, -88, -88, -88, -85, -85,
-84, -83, -84, -83, -82, -81, -79, -79, -79, -78, -78, -77, -76, -75, -76, -74,
-74, -73, -73, -72, -71, -71, -70, -70, -69, -68, -66, -66, -65, -66, -65, -64,
-63, -63, -63, -62, -61, -60, -60, -60, -58, -58, -58, -57, -56, -56, -55, -55,
-53, -53, -53, -52, -52, -51, -51, -50, -50, -49, -48, -47, -47, -46, -45, -44,
-44, -44, -43, -42, -42, -42, -41, -40, -40, -39, -38, -38, -37, -36, -36, -35,
-35, -34, -34, -33, -32, -32, -31, -31, -30, -29, -29, -28, -28, -27, -27, -26,
-25, -25, -24, -24, -23, -22, -21, -21, -21, -21, -20, -20, -18, -17, -17, -17,
-16, -15, -15, -14, -14, -12, -12, -13, -11, -11, -11, -9, -9, -9, -8, -7, -7,
-7, -7, -5, -6, -5, -4, -4, -4, -2, -2, -2, -1, -1, 0, -1, };