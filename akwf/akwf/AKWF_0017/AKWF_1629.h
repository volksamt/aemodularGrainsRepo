#define DATA_LENGTH 512
#define DATA AKWF_1629

const PROGMEM int8_t DATA[DATA_LENGTH] = {11, 21, 22, 22, 22, 23, 22, 23, 23,
23, 23, 24, 25, 24, 24, 25, 25, 26, 26, 26, 25, 25, 27, 27, 26, 27, 27, 28, 28,
28, 29, 28, 28, 29, 29, 29, 30, 29, 30, 31, 30, 30, 31, 31, 31, 31, 32, 32, 31,
33, 33, 34, 33, 34, 33, 33, 33, 34, 34, 35, 35, 35, 36, 35, 35, 36, 36, 36, 37,
38, 38, 37, 38, 38, 37, 38, 39, 40, 39, 39, 39, 39, 40, 40, 40, 40, 40, 41, 41,
41, 41, 41, 41, 42, 43, 42, 43, 42, 42, 41, 41, 41, 40, 41, 40, 41, 40, 40, 39,
39, 38, 38, 39, 38, 38, 38, 38, 38, 38, 37, 37, 36, 36, 36, 36, 36, 35, 34, 35,
34, 34, 33, 35, 33, 33, 33, 33, 33, 33, 32, 32, 32, 31, 31, 30, 30, 31, 30, 30,
29, 30, 29, 28, 29, 29, 28, 27, 28, 27, 28, 27, 27, 26, 26, 25, 27, 25, 27, 24,
25, 24, 26, 24, 24, 23, 24, 23, 24, 23, 21, 23, 20, 24, -47, 1, 34, 12, 27, 18,
25, 20, 24, 21, 25, 22, 24, 23, 24, 23, 24, 24, 24, 24, 25, 25, 25, 26, 25, 27,
26, 28, 27, 27, 27, 28, 28, 28, 28, 29, 28, 29, 29, 30, 29, 30, 30, 30, 30, 30,
30, 31, 31, 32, 32, 32, 33, 33, 32, 32, 34, 34, 34, 34, 34, 34, 35, 35, 34, 35,
35, 36, 36, 36, 36, 36, 36, 36, 37, 38, 37, 38, 38, 38, 39, 38, 39, 39, 39, 39,
39, 39, 40, 41, 41, 41, 42, 40, 41, 42, 41, 42, 42, 41, 41, 41, 40, 40, 40, 40,
39, 39, 39, 39, 39, 38, 37, 38, 37, 38, 37, 37, 36, 36, 36, 36, 35, 36, 35, 34,
35, 34, 34, 34, 34, 34, 33, 33, 33, 32, 33, 32, 32, 32, 32, 31, 31, 31, 30, 30,
30, 30, 30, 29, 29, 28, 28, 28, 27, 28, 28, 27, 28, 27, 27, 27, 26, 26, 26, 25,
25, 24, 24, 25, 24, 24, 24, 24, 23, 23, 22, 23, 22, 23, 22, 22, 20, 21, 20, 21,
20, 21, 20, 20, 19, 19, 20, 18, 20, 16, 23, -25, -56, -47, -53, -50, -52, -50,
-50, -50, -51, -50, -50, -51, -51, -50, -51, -51, -51, -51, -51, -51, -50, -50,
-50, -50, -51, -50, -51, -51, -51, -50, -50, -51, -51, -50, -50, -51, -51, -51,
-50, -51, -51, -51, -50, -51, -50, -51, -49, -52, -46, -68, -111, -108, -109,
-109, -109, -109, -108, -109, -109, -110, -109, -110, -110, -110, -111, -111,
-110, -111, -111, -112, -111, -111, -111, -112, -112, -111, -112, -112, -112,
-112, -112, -113, -113, -113, -113, -113, -113, -112, -114, -114, -114, -114,
-114, -113, -115, -114, -115, -114, -115, -115, -115, -116, -116, -116, -116,
-116, -116, -115, -116, -116, -117, -117, -117, -116, -116, -118, -116, -118,
-117, -119, -116, -119, -116, -120, -116, -122, -116, -123, -114, -126, -98, };