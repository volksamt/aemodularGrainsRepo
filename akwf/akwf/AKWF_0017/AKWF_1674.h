#define DATA_LENGTH 512
#define DATA AKWF_1674

const PROGMEM int8_t DATA[DATA_LENGTH] = {62, 30, 64, 65, 61, 66, 61, 66, 61,
66, 62, 65, 62, 65, 62, 65, 63, 67, 66, 69, 68, 68, 68, 67, 67, 68, 68, 68, 68,
68, 68, 67, 70, 77, 79, 78, 79, 79, 80, 78, 80, 79, 80, 79, 79, 79, 80, 78, 81,
89, 90, 90, 90, 91, 91, 90, 91, 90, 91, 91, 91, 91, 91, 91, 92, 94, 95, 95, 95,
95, 95, 95, 95, 95, 94, 95, 94, 94, 95, 95, 97, 102, 102, 103, 102, 102, 102,
102, 102, 102, 102, 103, 103, 102, 104, 103, 103, 104, 105, 104, 105, 103, 105,
104, 106, 103, 107, 102, 108, 101, 109, 93, 20, 24, 22, 23, 23, 22, 24, 22, 24,
22, 25, 22, 23, 22, 25, 27, 27, 25, 27, 26, 26, 27, 27, 27, 26, 27, 27, 27, 26,
27, 27, 29, 31, 30, 30, 30, 31, 31, 30, 31, 30, 30, 31, 31, 30, 30, 31, 33, 35,
34, 35, 35, 34, 35, 34, 34, 35, 34, 34, 34, 35, 35, 36, 38, 40, 40, 40, 40, 40,
41, 40, 40, 40, 40, 41, 40, 40, 40, 41, 44, 46, 45, 46, 45, 47, 45, 46, 46, 46,
46, 46, 46, 46, 47, 47, 47, 46, 46, 46, 47, 45, 47, 46, 47, 46, 47, 45, 47, 46,
47, 47, 51, 51, 52, 52, 52, 54, 50, 54, 49, 55, 47, 58, 46, 62, 40, 72, 19, -35,
-16, -84, -65, -78, -71, -75, -73, -73, -74, -72, -74, -72, -75, -72, -75, -72,
-76, -79, -84, -81, -84, -81, -84, -82, -83, -82, -84, -83, -83, -82, -84, -82,
-84, -91, -92, -92, -93, -93, -92, -92, -93, -93, -92, -94, -92, -92, -93, -93,
-93, -95, -95, -94, -94, -95, -95, -95, -95, -95, -95, -95, -95, -95, -95, -95,
-95, -95, -95, -95, -96, -95, -95, -95, -95, -95, -95, -95, -95, -95, -95, -96,
-96, -100, -101, -101, -100, -101, -102, -101, -102, -101, -102, -100, -101,
-100, -102, -100, -106, -114, -117, -116, -117, -115, -118, -115, -117, -115,
-117, -117, -115, -118, -113, -125, -32, 2, -13, -2, -10, -4, -9, -5, -8, -5,
-9, -5, -7, -6, -7, -9, -11, -10, -11, -10, -11, -11, -10, -10, -10, -11, -10,
-11, -11, -11, -11, -13, -12, -12, -13, -12, -12, -13, -12, -12, -13, -12, -12,
-13, -12, -12, -13, -15, -17, -16, -16, -17, -16, -16, -16, -16, -17, -16, -15,
-16, -16, -16, -17, -18, -20, -19, -20, -20, -20, -20, -20, -20, -20, -20, -21,
-19, -20, -20, -21, -21, -22, -21, -22, -23, -21, -22, -22, -22, -22, -22, -22,
-22, -22, -22, -22, -22, -22, -22, -22, -22, -22, -22, -22, -22, -22, -22, -22,
-22, -22, -22, -22, -25, -31, -31, -32, -32, -31, -32, -32, -31, -31, -32, -31,
-31, -32, -31, -31, -36, -45, -44, -45, -45, -44, -45, -45, -44, -45, -46, -45,
-44, -44, -46, -45, -52, -59, -61, -60, -60, -60, -60, -59, -61, -59, -61, -58,
-62, -58, -63, -51, };