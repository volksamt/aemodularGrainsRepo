#define DATA_LENGTH 512
#define DATA AKWF_1694

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 5, 9, 13, 17, 20, 24, 27, 31, 35,
39, 42, 46, 50, 53, 57, 60, 63, 67, 70, 72, 75, 79, 81, 83, 85, 88, 90, 91, 93,
95, 96, 98, 99, 100, 102, 102, 104, 104, 104, 105, 106, 106, 106, 107, 107, 107,
107, 108, 107, 107, 107, 108, 107, 107, 107, 106, 106, 106, 106, 105, 105, 105,
104, 103, 102, 102, 101, 99, 99, 97, 96, 94, 92, 91, 88, 86, 83, 81, 76, 73, 69,
66, 61, 56, 51, 47, 41, 37, 31, 26, 20, 14, 8, 4, -3, -8, -13, -18, -22, -28,
-33, -37, -41, -45, -49, -53, -56, -57, -61, -62, -65, -67, -67, -69, -70, -70,
-70, -70, -70, -70, -69, -67, -66, -66, -64, -63, -62, -60, -58, -56, -53, -52,
-49, -47, -44, -42, -39, -37, -34, -32, -29, -27, -25, -22, -18, -16, -15, -11,
-9, -6, -4, -1, 1, 3, 6, 9, 10, 13, 14, 17, 19, 21, 23, 25, 26, 28, 30, 31, 34,
35, 36, 38, 39, 40, 42, 43, 43, 45, 46, 47, 48, 50, 51, 52, 52, 53, 54, 55, 55,
56, 57, 58, 59, 60, 60, 62, 62, 63, 65, 65, 67, 67, 69, 69, 70, 72, 73, 75, 76,
77, 78, 80, 81, 84, 85, 87, 88, 89, 92, 93, 95, 96, 97, 98, 99, 99, 100, 99, 99,
98, 97, 95, 93, 88, 84, 81, 76, 71, 66, 60, 55, 50, 44, 38, 31, 26, 19, 14, 8,
0, -4, -10, -15, -20, -25, -30, -33, -37, -41, -44, -47, -50, -52, -54, -56,
-58, -59, -60, -61, -62, -63, -63, -63, -63, -63, -62, -62, -61, -60, -60, -59,
-59, -57, -57, -55, -55, -54, -52, -52, -51, -50, -48, -48, -46, -46, -44, -44,
-43, -41, -41, -40, -38, -38, -37, -37, -36, -35, -34, -34, -33, -33, -32, -31,
-30, -29, -29, -28, -27, -27, -27, -26, -25, -25, -24, -23, -23, -22, -22, -21,
-20, -19, -18, -17, -16, -16, -14, -14, -13, -13, -11, -10, -9, -7, -6, -4, -3,
-1, 1, 2, 4, 5, 8, 9, 11, 15, 16, 18, 21, 25, 27, 29, 33, 35, 38, 41, 44, 48,
50, 54, 57, 59, 63, 65, 68, 70, 71, 74, 76, 77, 78, 78, 77, 76, 75, 73, 70, 67,
64, 60, 57, 53, 48, 44, 39, 34, 28, 23, 17, 13, 6, 0, -5, -11, -17, -21, -26,
-31, -37, -41, -46, -50, -55, -58, -62, -67, -69, -72, -76, -79, -82, -85, -88,
-90, -91, -94, -96, -98, -99, -101, -103, -104, -105, -107, -108, -109, -110,
-111, -112, -113, -114, -114, -115, -115, -116, -117, -117, -117, -118, -118,
-119, -119, -119, -120, -119, -119, -119, -119, -118, -119, -118, -118, -117,
-117, -116, -115, -115, -113, -113, -112, -111, -109, -107, -107, -106, -104,
-102, -99, -99, -97, -95, -92, -90, -87, -85, -83, -80, -78, -75, -72, -70, -66,
-65, -61, -58, -55, -52, -50, -47, -43, -39, -36, -33, -31, -27, -23, -20, -17,
-13, -9, -6, -1, };