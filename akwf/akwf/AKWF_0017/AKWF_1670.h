#define DATA_LENGTH 512
#define DATA AKWF_1670

const PROGMEM int8_t DATA[DATA_LENGTH] = {38, 55, 59, 66, 69, 75, 77, 80, 83,
86, 87, 90, 91, 94, 94, 96, 97, 100, 100, 101, 102, 103, 103, 105, 105, 106,
106, 106, 107, 107, 109, 106, 112, 85, 64, 61, 53, 52, 47, 45, 42, 40, 37, 35,
33, 32, 29, 29, 27, 26, 24, 23, 21, 21, 20, 18, 18, 16, 16, 14, 14, 13, 12, 12,
10, 9, 9, 8, 8, 7, 7, 7, 6, 5, 5, 5, 5, 4, 3, 3, 3, 2, 3, 2, 2, 1, 1, 1, 0, 1,
1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 1,
0, 1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 1, 0,
1, 0, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 1, 0, 1, 1, 0,
0, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 1, 1, 0, 1, -1, 1, 0, 1, 1,
-1, 0, -1, 0, 0, 1, -1, 1, -1, 1, -1, 2, -1, 0, -1, 1, -1, 1, -1, 0, 1, -1, 1,
-1, 3, -5, 11, -47, -25, 9, -7, 4, -3, 2, -1, 2, -1, 0, 0, -1, 2, -5, -48, -59,
-67, -74, -76, -82, -84, -90, -90, -95, -95, -99, -100, -103, -104, -107, -108,
-109, -110, -111, -113, -114, -115, -116, -116, -116, -118, -117, -119, -118,
-119, -118, -119, -119, -80, -65, -61, -54, -50, -44, -43, -39, -37, -33, -32,
-29, -28, -25, -23, -22, -21, -19, -17, -16, -15, -14, -12, -11, -11, -9, -8,
-8, -7, -6, -5, -5, -4, -4, -4, -4, -2, -1, -2, -2, -1, 0, -1, 1, 0, 0, 0, 0,
-1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, -1, -1, -1, 0, 0, 0, 0, -1, 0, 0, 0, -1, 1, 0,
0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
-1, 0, 0, 0, -1, 0, 1, 1, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1,
1, 0, 1, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 1, 0, 0, -1, 1, 0, 0, 1, 0, -1, 0, 1, 0, 0, 0, -1, 0, 1, 0, 0,
-1, 0, 1, -1, 0, 0, 0, 1, 0, 1, -1, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, -1, 0, 0, 0,
0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, -1, 0, 0, 0, 0, -1, 1,
0, 0, 0, -1, -1, -1, 0, 0, 0, 0, 1, 0, 0, };