#define DATA_LENGTH 512
#define DATA AKWF_1667

const PROGMEM int8_t DATA[DATA_LENGTH] = {24, 34, 36, 41, 43, 46, 47, 50, 52,
53, 54, 56, 56, 58, 60, 60, 61, 63, 64, 65, 66, 67, 68, 69, 69, 70, 70, 72, 73,
73, 73, 75, 75, 76, 77, 77, 77, 79, 79, 79, 80, 80, 81, 81, 82, 82, 83, 84, 85,
84, 85, 85, 85, 87, 86, 87, 87, 88, 88, 89, 89, 89, 90, 90, 91, 91, 90, 91, 91,
92, 92, 93, 93, 93, 94, 94, 94, 94, 95, 96, 95, 96, 96, 97, 97, 96, 96, 97, 97,
97, 98, 98, 99, 98, 99, 99, 98, 99, 100, 100, 100, 100, 99, 100, 100, 100, 101,
101, 101, 101, 101, 101, 103, 102, 102, 102, 103, 103, 103, 102, 103, 103, 103,
104, 103, 103, 103, 103, 104, 104, 104, 104, 104, 105, 104, 105, 105, 105, 105,
105, 105, 104, 106, 105, 106, 105, 105, 105, 105, 105, 106, 105, 105, 104, 105,
104, 106, 105, 106, 105, 105, 107, 73, 57, 54, 46, 45, 40, 38, 34, 32, 29, 28,
25, 24, 22, 21, 19, 17, 17, 15, 13, 13, 11, 11, 10, 8, 8, 7, 6, 6, 5, 4, 5, 2,
5, 1, 4, 0, 3, -1, 3, -1, 2, -2, 2, -3, 2, -1, -107, -95, -80, -83, -74, -76,
-69, -70, -64, -67, -61, -63, -58, -60, -56, -57, -54, -55, -52, -53, -50, -50,
-49, -47, -46, -46, -46, -44, -44, -43, -42, -41, -41, -39, -40, -38, -38, -37,
-36, -36, -36, -34, -34, -33, -33, -33, -31, -32, -31, -31, -30, -29, -29, -29,
-28, -27, -27, -26, -27, -27, -25, -25, -24, -25, -23, -24, -23, -22, -22, -22,
-21, -20, -21, -20, -20, -20, -19, -19, -19, -18, -18, -17, -18, -16, -17, -16,
-16, -15, -15, -15, -15, -14, -14, -15, -13, -14, -13, -14, -13, -13, -12, -12,
-12, -12, -12, -10, -11, -11, -10, -10, -10, -10, -9, -10, -10, -9, -9, -8, -8,
-9, -8, -8, -7, -7, -7, -7, -7, -7, -6, -6, -5, -6, -5, -6, -5, -6, -5, -4, -5,
-5, -5, -4, -5, -4, -3, -4, -4, -3, -4, -4, -3, -3, -3, -3, -3, -3, -3, -2, -2,
-2, -3, -2, -2, -2, -2, -2, -2, -2, -2, -2, -1, -1, -1, -1, -1, -1, -1, 0, -1,
-1, -1, -1, -1, -1, -1, 0, -1, -1, 0, 0, -1, 0, -1, -1, 1, -1, 0, 0, 0, 0, 0, 0,
0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, -1, 0, 0, 1, 1, 0,
0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, -1, -1, 0, 0, 1, 0,
1, -1, 1, 0, -1, 0, 0, 0, 0, 0, 0, 1, 0, 1, -1, 0, -1, 0, -1, 1, -1, 1, -1, 0,
0, 0, 0, 1, 0, -1, 0, -1, 2, -3, 4, -9, 47, 48, 19, 25, 12, 15, 7, 9, 3, 4, 2,
2, 1, 1, 0, };