#define DATA_LENGTH 512
#define DATA AKWF_1688

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 29, 44, 53, 58, 61, 65, 71, 76,
81, 85, 89, 92, 95, 100, 103, 106, 110, 110, 111, 115, 116, 118, 120, 118, 118,
115, 113, 111, 110, 108, 107, 105, 102, 98, 94, 90, 87, 84, 81, 76, 73, 68, 64,
62, 59, 56, 54, 50, 45, 41, 39, 38, 36, 33, 30, 27, 24, 24, 23, 23, 26, 29, 33,
35, 39, 42, 44, 45, 45, 44, 42, 39, 35, 31, 24, 19, 12, 6, 0, -5, -8, -12, -14,
-17, -20, -23, -25, -27, -30, -31, -31, -33, -33, -35, -36, -37, -38, -41, -45,
-48, -52, -57, -62, -66, -70, -73, -76, -78, -79, -79, -78, -77, -75, -73, -71,
-69, -68, -66, -65, -65, -64, -64, -63, -63, -62, -62, -63, -64, -66, -68, -68,
-70, -72, -74, -76, -78, -78, -79, -79, -80, -81, -83, -86, -88, -91, -93, -94,
-94, -94, -92, -90, -87, -84, -79, -73, -67, -61, -55, -49, -42, -38, -32, -28,
-24, -21, -17, -12, -9, -5, -2, 0, 1, 3, 3, 5, 5, 6, 5, 4, 2, 0, -3, -6, -10,
-11, -16, -18, -20, -23, -27, -29, -33, -34, -36, -37, -38, -37, -36, -34, -31,
-27, -22, -18, -13, -8, -4, -1, 3, 7, 9, 11, 14, 16, 18, 21, 23, 26, 30, 32, 36,
38, 40, 42, 42, 44, 46, 46, 46, 45, 45, 44, 43, 42, 41, 41, 40, 40, 38, 37, 36,
36, 37, 39, 41, 46, 48, 53, 55, 59, 63, 67, 69, 72, 74, 77, 79, 80, 83, 84, 86,
85, 86, 86, 85, 84, 83, 83, 80, 80, 79, 77, 75, 76, 75, 75, 75, 75, 76, 75, 77,
77, 76, 76, 75, 75, 75, 75, 76, 75, 74, 73, 71, 69, 69, 67, 66, 63, 61, 59, 57,
55, 54, 52, 50, 49, 47, 47, 47, 47, 45, 45, 44, 43, 42, 41, 39, 38, 35, 34, 31,
29, 25, 21, 18, 14, 9, 3, 0, -5, -10, -14, -18, -21, -25, -29, -31, -35, -38,
-40, -43, -43, -45, -47, -49, -51, -54, -55, -57, -59, -60, -62, -62, -63, -63,
-63, -64, -65, -66, -67, -67, -67, -67, -67, -69, -70, -72, -73, -76, -78, -78,
-79, -80, -82, -83, -83, -82, -80, -79, -78, -77, -73, -70, -68, -65, -63, -61,
-58, -55, -54, -52, -51, -50, -50, -48, -48, -49, -49, -50, -50, -49, -48, -48,
-49, -48, -48, -49, -47, -48, -48, -46, -45, -42, -41, -40, -39, -38, -36, -34,
-33, -32, -30, -26, -24, -22, -20, -19, -17, -17, -20, -22, -24, -25, -25, -24,
-23, -23, -23, -21, -20, -16, -12, -9, -7, -5, -5, -3, 1, 3, 3, 2, -1, -7, -13,
-17, -19, -22, -27, -31, -35, -39, -43, -45, -47, -47, -45, -40, -34, -29, -22,
-17, -10, -3, 5, 10, 13, 16, 19, 23, 24, 23, 23, 23, 22, 24, 24, 22, 17, 12, 7,
3, 0, -4, -7, -10, -12, -13, -11, -9, -9, -9, -13, -15, -17, -19, -20, -20, -20,
-17, -15, -10, -2, };