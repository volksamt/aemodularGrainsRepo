#define DATA_LENGTH 512
#define DATA AKWF_1677

const PROGMEM int8_t DATA[DATA_LENGTH] = {36, 63, 56, 59, 58, 59, 58, 59, 58,
58, 58, 59, 59, 58, 59, 58, 55, 54, 54, 54, 54, 54, 55, 54, 54, 54, 54, 54, 55,
54, 54, 54, 52, 50, 50, 50, 51, 51, 50, 50, 50, 50, 50, 50, 51, 51, 50, 50, 48,
48, 49, 48, 48, 48, 48, 48, 48, 49, 49, 48, 49, 48, 48, 46, 45, 44, 44, 44, 44,
44, 44, 44, 45, 44, 44, 45, 44, 45, 44, 44, 43, 42, 42, 42, 42, 43, 42, 42, 43,
42, 42, 43, 43, 42, 43, 42, 41, 39, 39, 39, 39, 39, 38, 38, 38, 39, 39, 38, 39,
38, 39, 38, 37, 36, 36, 36, 36, 37, 36, 37, 36, 36, 36, 36, 36, 36, 37, 36, 34,
33, 33, 33, 32, 33, 32, 32, 33, 33, 33, 33, 33, 33, 32, 33, 32, 30, 30, 31, 30,
30, 30, 30, 31, 31, 30, 31, 30, 31, 30, 28, 26, 26, 26, 27, 27, 26, 26, 27, 26,
26, 26, 27, 27, 27, 27, 25, 23, 22, 22, 22, 23, 22, 23, 23, 22, 23, 22, 22, 22,
22, 22, 23, 21, 21, 20, 21, 20, 20, 20, 20, 20, 20, 20, 20, 21, 20, 21, 20, 18,
16, 17, 16, 16, 16, 16, 16, 16, 16, 17, 16, 16, 16, 16, 15, 14, 14, 14, 14, 14,
14, 14, 14, 14, 14, 14, 14, 14, 14, 14, 13, 10, 9, 10, 10, 10, 10, 10, 10, 10,
9, 10, 10, 10, 11, 11, 9, 7, 6, 5, 5, 6, 6, 5, 5, 6, 6, 5, 6, 6, 6, 6, 5, 5, 4,
4, 3, 4, 4, 3, 3, 4, 3, 3, 4, 4, 4, 4, 3, 2, 1, 2, 2, 2, 1, 2, 2, 2, 2, 1, 1, 2,
2, 2, 0, -4, -5, -5, -5, -5, -5, -4, -4, -4, -4, -5, -4, -5, -5, -5, -5, -8, -9,
-9, -9, -10, -8, -9, -9, -9, -9, -9, -8, -9, -8, -9, -11, -13, -13, -13, -13,
-13, -14, -13, -13, -13, -13, -14, -13, -13, -14, -13, -14, -16, -16, -16, -15,
-15, -15, -16, -15, -15, -16, -16, -15, -15, -15, -15, -16, -18, -20, -19, -19,
-19, -19, -20, -20, -20, -20, -19, -19, -20, -20, -20, -22, -21, -22, -22, -21,
-22, -22, -22, -22, -22, -22, -22, -22, -21, -22, -22, -25, -28, -29, -28, -28,
-28, -28, -28, -28, -29, -28, -28, -28, -27, -28, -28, -31, -37, -38, -39, -39,
-39, -39, -39, -39, -38, -39, -39, -38, -38, -39, -39, -40, -43, -46, -45, -45,
-45, -46, -46, -45, -46, -46, -45, -44, -46, -45, -46, -57, -66, -67, -67, -67,
-65, -66, -67, -66, -66, -67, -67, -66, -67, -66, -67, -73, -82, -83, -84, -83,
-84, -83, -83, -84, -84, -84, -83, -83, -83, -83, -83, -87, -96, -100, -100,
-100, -101, -101, -101, -101, -100, -100, -100, -100, -101, -101, -100, -101,
-109, -113, -112, -114, -113, -113, -112, -114, -112, -114, -111, -114, -111,
-117, -110, -31, };