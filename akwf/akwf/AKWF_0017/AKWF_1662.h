#define DATA_LENGTH 512
#define DATA AKWF_1662

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 8, 9, 10, 9, 10, 9, 9, 9, 9, 9,
9, 9, 9, 11, 18, 19, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 19, 20, 25, 30,
29, 31, 30, 30, 30, 30, 29, 30, 30, 30, 29, 29, 30, 30, 36, 45, 46, 46, 46, 46,
46, 46, 46, 47, 46, 47, 46, 46, 46, 46, 50, 57, 60, 60, 60, 60, 60, 60, 60, 60,
59, 61, 60, 60, 60, 59, 60, 64, 66, 66, 65, 65, 66, 66, 65, 66, 65, 65, 65, 65,
66, 66, 71, 76, 75, 75, 75, 75, 75, 75, 75, 75, 76, 76, 75, 75, 76, 76, 76, 79,
80, 79, 79, 80, 79, 79, 80, 80, 79, 80, 79, 79, 80, 79, 81, 86, 87, 87, 87, 87,
86, 87, 87, 87, 87, 87, 86, 87, 87, 87, 87, 90, 93, 92, 93, 93, 92, 92, 93, 92,
93, 93, 93, 93, 92, 92, 94, 96, 94, 95, 95, 95, 96, 96, 96, 95, 95, 95, 96, 95,
95, 96, 96, 99, 100, 100, 99, 99, 99, 99, 100, 99, 99, 99, 100, 99, 99, 99, 99,
101, 101, 101, 101, 101, 102, 102, 102, 100, 101, 101, 101, 101, 101, 102, 103,
104, 105, 104, 105, 105, 104, 105, 104, 105, 104, 104, 105, 104, 104, 104, 105,
105, 106, 107, 106, 106, 106, 106, 106, 105, 106, 107, 106, 106, 105, 106, 106,
108, 108, 109, 108, 109, 109, 109, 108, 108, 108, 109, 108, 109, 107, 108, 109,
109, 109, 110, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 110, 108, 110,
111, 112, 111, 112, 111, 112, 110, 112, 111, 112, 111, 111, 112, 111, 111, 112,
112, 113, 114, 111, 114, 111, 114, 109, 116, 109, 117, 107, 119, 103, 127, 51,
-124, -113, -122, -117, -120, -119, -118, -119, -118, -120, -118, -120, -117,
-120, -117, -121, -117, -120, -117, -120, -117, -119, -118, -118, -117, -119,
-119, -119, -118, -118, -118, -118, -118, -118, -117, -117, -117, -117, -118,
-118, -118, -117, -118, -117, -118, -117, -117, -117, -115, -115, -115, -116,
-115, -115, -115, -114, -115, -115, -114, -115, -115, -115, -114, -115, -111,
-107, -106, -107, -107, -106, -106, -106, -106, -107, -106, -106, -107, -107,
-106, -104, -102, -102, -102, -102, -103, -102, -101, -102, -101, -102, -101,
-101, -102, -102, -102, -98, -90, -89, -90, -90, -90, -90, -90, -89, -90, -90,
-90, -90, -90, -90, -90, -88, -81, -78, -79, -78, -79, -79, -78, -78, -79, -78,
-79, -79, -78, -78, -78, -78, -75, -74, -73, -74, -74, -74, -74, -73, -73, -74,
-74, -74, -73, -74, -74, -69, -64, -63, -63, -63, -63, -63, -63, -63, -63, -64,
-64, -63, -64, -64, -64, -61, -57, -56, -57, -57, -57, -57, -57, -58, -57, -57,
-58, -57, -57, -56, -57, -54, -46, -42, -42, -43, -42, -42, -42, -42, -42, -42,
-41, -42, -43, -43, -42, -33, -24, -24, -24, -25, -25, -24, -24, -25, -25, -24,
-24, -25, -25, -25, -25, -12, };