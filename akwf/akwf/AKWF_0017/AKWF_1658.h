#define DATA_LENGTH 512
#define DATA AKWF_1658

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 8, 9, 11, 10, 10, 10, 11, 12,
12, 14, 16, 18, 20, 22, 24, 25, 28, 29, 30, 32, 35, 37, 38, 39, 42, 43, 46, 47,
48, 50, 52, 53, 55, 56, 59, 60, 62, 65, 66, 67, 69, 70, 72, 74, 76, 77, 80, 81,
84, 85, 86, 88, 90, 93, 94, 98, 100, 102, 105, 108, 111, 110, 112, 110, 107,
103, 97, 89, 79, 70, 59, 47, 35, 23, 10, -1, -13, -25, -38, -49, -60, -70, -79,
-87, -94, -100, -105, -107, -110, -112, -111, -112, -110, -109, -107, -105,
-103, -100, -96, -92, -90, -85, -82, -78, -75, -72, -70, -66, -64, -61, -59,
-56, -55, -53, -52, -50, -48, -48, -46, -45, -43, -40, -37, -32, -29, -24, -19,
-12, -7, -1, 7, 16, 24, 33, 43, 54, 65, 76, 86, 94, 101, 108, 111, 113, 112,
111, 108, 104, 98, 93, 88, 85, 81, 78, 75, 72, 71, 69, 67, 66, 64, 60, 59, 57,
55, 52, 50, 48, 46, 43, 40, 39, 36, 34, 32, 30, 27, 26, 23, 21, 19, 16, 14, 12,
9, 7, 5, 2, 0, -2, -4, -6, -9, -11, -13, -16, -18, -20, -22, -25, -27, -29, -31,
-34, -35, -38, -40, -43, -44, -46, -49, -51, -54, -55, -58, -60, -63, -64, -67,
-70, -72, -74, -75, -77, -79, -81, -84, -86, -89, -91, -97, -100, -106, -110,
-114, -118, -118, -119, -119, -117, -113, -107, -100, -92, -83, -74, -65, -56,
-48, -40, -33, -26, -20, -14, -9, -3, 2, 4, 9, 10, 14, 14, 15, 17, 16, 17, 17,
18, 20, 21, 22, 24, 26, 27, 30, 31, 34, 35, 37, 40, 41, 42, 45, 46, 48, 50, 52,
53, 55, 57, 59, 60, 62, 63, 66, 67, 68, 70, 72, 73, 74, 76, 77, 79, 81, 83, 86,
89, 92, 95, 99, 102, 106, 108, 110, 110, 110, 109, 107, 104, 100, 97, 90, 84,
77, 69, 60, 50, 40, 28, 16, 5, -8, -20, -31, -42, -54, -64, -75, -83, -93, -99,
-107, -112, -115, -119, -119, -118, -116, -112, -109, -105, -101, -96, -92, -89,
-86, -83, -80, -78, -76, -74, -71, -69, -67, -63, -61, -59, -55, -53, -50, -48,
-46, -43, -42, -41, -40, -39, -38, -38, -36, -32, -28, -20, -13, -2, 9, 22, 34,
47, 60, 71, 81, 88, 94, 99, 101, 103, 104, 104, 103, 101, 99, 98, 96, 92, 90,
87, 84, 81, 78, 75, 71, 69, 66, 64, 62, 59, 57, 55, 54, 51, 49, 47, 45, 43, 40,
38, 36, 33, 32, 28, 26, 24, 22, 20, 17, 15, 13, 11, 9, 6, 4, 2, -1, -2, -6, -7,
-9, -12, -14, -16, -18, -21, -23, -25, -27, -29, -32, -35, -37, -39, -41, -43,
-46, -48, -51, -53, -55, -57, -59, -61, -63, -66, -67, -69, -71, -73, -76, -79,
-81, -84, -88, -91, -94, -98, -100, -103, -106, -107, -108, -111, -112, -112,
-113, -112, -110, -107, -103, -98, -91, -82, -71, -61, -50, -38, -28, -18, -9,
-2, };