#define DATA_LENGTH 512
#define DATA AKWF_1699

const PROGMEM int8_t DATA[DATA_LENGTH] = {26, 56, 76, 91, 101, 106, 107, 107,
103, 99, 92, 87, 77, 71, 63, 55, 48, 40, 35, 30, 25, 22, 18, 15, 13, 9, 8, 7, 5,
4, 3, 2, 2, 1, 1, 0, 0, 1, 0, 1, 1, 0, 1, 1, 3, 2, 3, 4, 5, 7, 6, 8, 8, 10, 10,
11, 11, 12, 11, 12, 10, 11, 9, 10, 10, 10, 10, 9, 9, 9, 10, 8, 8, 8, 7, 7, 7, 6,
6, 6, 6, 6, 5, 4, 4, 4, 4, 4, 4, 3, 4, 2, 3, 2, 2, 2, 2, 2, 2, 1, 2, 1, 2, 1, 2,
2, 2, 1, 1, 2, 2, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 1, 1, 2,
1, 1, 1, 1, 2, 2, 1, 1, 1, 1, 2, 1, 1, 1, 1, 1, 1, 2, 0, 1, 1, 1, 0, 1, 1, 0, 0,
0, 0, 1, 1, 0, 1, 0, 0, 1, 0, 1, 0, 0, 1, 0, 1, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 1,
0, 0, 1, 0, 1, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0,
1, 0, 1, 1, 1, 1, 1, 0, 1, 1, 1, 1, 2, 2, 1, 1, 2, 1, 1, 2, 1, 2, 4, 4, 6, 7, 7,
8, 8, 9, 10, 12, 13, 14, 16, 18, 25, 34, 39, 44, 47, 51, 53, 53, 53, 52, 50, 49,
47, 46, 44, 43, 41, 38, 36, 34, 32, 30, 29, 27, 26, 25, 25, 26, 24, 25, 22, 22,
21, 21, 20, 18, 18, 17, 17, 17, 17, 16, 16, 16, 16, 15, 14, 14, 14, 13, 13, 13,
13, 11, 11, 11, 13, 13, 12, 12, 11, 11, 11, 10, 10, 10, 9, 9, 9, 7, 8, 7, 6, 7,
6, 7, 6, 6, 6, 6, 6, 6, 5, 5, 4, 5, 4, 4, 4, 3, 3, 2, 2, 2, 2, 2, 1, 1, 0, 1, 1,
0, 1, 0, 0, 1, 0, 0, -1, 0, -1, -1, -1, -1, -1, -1, 0, 0, 0, -1, 0, 0, 0, -1, 0,
-1, -1, -1, -1, -1, -1, -2, -1, -1, -1, -1, -2, -1, -2, -2, -2, -2, -2, -2, -2,
-1, -2, -2, -3, -2, -1, -3, -2, -3, -2, -3, -3, -3, -3, -3, -2, -3, -3, -3, -2,
-3, -4, -3, -4, -3, -3, -3, -4, -4, -3, -4, -4, -3, -4, -4, -3, -4, -4, -5, -5,
-5, -5, -6, -5, -6, -6, -6, -6, -7, -7, -8, -8, -8, -8, -8, -10, -10, -10, -10,
-11, -11, -13, -13, -14, -15, -16, -18, -18, -19, -20, -29, -50, -65, -76, -83,
-86, -89, -90, -89, -88, -86, -84, -80, -76, -72, -69, -66, -63, -61, -60, -70,
-84, -95, -104, -111, -115, -118, -119, -119, -116, -112, -108, -101, -95, -88,
-81, -74, -69, -61, -55, -51, -44, -40, -35, -29, -25, -19, -3, };