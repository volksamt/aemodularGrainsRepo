#define DATA_LENGTH 512
#define DATA AKWF_1643

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 7, 9, 12, 14, 16, 19, 21, 23,
24, 27, 28, 30, 32, 35, 37, 39, 42, 44, 47, 51, 54, 56, 59, 62, 64, 67, 70, 71,
72, 74, 74, 75, 74, 74, 74, 75, 73, 73, 72, 73, 72, 71, 71, 71, 69, 69, 69, 68,
68, 68, 69, 69, 69, 70, 71, 72, 72, 73, 75, 76, 77, 79, 81, 82, 84, 86, 89, 90,
93, 95, 99, 100, 102, 105, 107, 109, 112, 115, 115, 117, 118, 118, 119, 119,
118, 117, 116, 115, 114, 112, 110, 108, 106, 104, 103, 102, 100, 98, 97, 96, 94,
94, 92, 91, 91, 90, 90, 89, 89, 89, 89, 90, 90, 90, 90, 91, 92, 92, 92, 92, 92,
92, 92, 93, 92, 91, 90, 88, 88, 86, 84, 83, 80, 77, 76, 73, 70, 68, 65, 62, 58,
55, 51, 48, 44, 40, 37, 34, 31, 27, 24, 21, 18, 15, 13, 11, 9, 7, 5, 4, 4, 4, 2,
2, 3, 3, 3, 3, 4, 5, 6, 8, 9, 10, 13, 14, 15, 17, 19, 22, 24, 25, 28, 31, 34,
35, 39, 40, 43, 46, 49, 51, 54, 57, 60, 62, 66, 68, 71, 74, 77, 78, 81, 83, 85,
87, 90, 89, 91, 90, 90, 90, 89, 87, 86, 85, 83, 81, 79, 78, 77, 77, 77, 75, 75,
75, 75, 75, 75, 75, 74, 75, 73, 72, 72, 71, 70, 69, 68, 66, 65, 64, 62, 60, 58,
57, 54, 51, 48, 45, 42, 39, 37, 34, 30, 26, 24, 19, 16, 12, 8, 4, 0, -4, -8,
-13, -16, -22, -25, -30, -35, -39, -43, -48, -53, -56, -60, -64, -68, -73, -75,
-78, -81, -83, -86, -88, -89, -91, -92, -92, -93, -91, -92, -92, -91, -90, -89,
-87, -87, -85, -82, -80, -79, -76, -74, -71, -69, -66, -63, -60, -58, -57, -54,
-53, -51, -49, -47, -46, -45, -44, -44, -43, -43, -43, -43, -44, -44, -45, -45,
-47, -47, -49, -50, -51, -53, -54, -56, -57, -58, -59, -60, -60, -60, -60, -60,
-59, -59, -58, -57, -55, -53, -52, -50, -48, -46, -44, -42, -41, -39, -37, -36,
-35, -35, -33, -31, -31, -30, -31, -29, -30, -29, -30, -30, -32, -32, -33, -34,
-35, -36, -38, -39, -42, -43, -45, -47, -50, -51, -55, -57, -60, -62, -64, -67,
-70, -73, -75, -76, -78, -81, -81, -82, -82, -83, -83, -81, -81, -80, -78, -78,
-76, -76, -74, -74, -75, -74, -75, -75, -75, -76, -77, -76, -76, -77, -78, -78,
-79, -79, -79, -80, -81, -82, -82, -83, -83, -83, -84, -84, -85, -85, -86, -87,
-87, -87, -88, -89, -90, -91, -92, -92, -93, -94, -96, -97, -98, -99, -101,
-102, -103, -105, -106, -109, -109, -110, -111, -113, -114, -116, -117, -117,
-117, -118, -119, -119, -118, -118, -118, -115, -115, -113, -112, -109, -108,
-105, -104, -100, -98, -94, -90, -87, -83, -79, -76, -70, -68, -63, -58, -53,
-49, -45, -41, -36, -32, -27, -23, -19, -16, -12, -9, -5, -1, };