#define DATA_LENGTH 512
#define DATA AKWF_1687

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 7, 10, 13, 15, 18, 22, 25, 27,
30, 34, 35, 36, 39, 40, 41, 42, 44, 43, 42, 43, 43, 43, 43, 43, 43, 42, 41, 40,
39, 41, 42, 45, 47, 49, 52, 55, 57, 60, 64, 66, 69, 71, 74, 77, 79, 81, 83, 84,
85, 87, 87, 87, 87, 87, 86, 87, 86, 85, 84, 83, 83, 83, 83, 83, 84, 82, 83, 83,
83, 83, 83, 82, 83, 83, 84, 82, 83, 81, 80, 79, 78, 76, 76, 75, 73, 71, 69, 67,
66, 64, 63, 61, 59, 58, 56, 56, 56, 55, 53, 52, 51, 51, 49, 47, 45, 44, 42, 39,
37, 35, 31, 28, 24, 19, 16, 12, 7, 3, -1, -5, -9, -12, -16, -20, -24, -27, -30,
-33, -35, -38, -40, -43, -45, -47, -50, -53, -55, -57, -59, -60, -61, -61, -63,
-64, -66, -67, -68, -68, -69, -69, -69, -71, -73, -75, -76, -78, -79, -81, -82,
-83, -84, -85, -86, -85, -85, -84, -83, -82, -81, -78, -76, -75, -73, -72, -70,
-66, -64, -63, -62, -61, -61, -58, -58, -57, -58, -57, -57, -56, -56, -55, -56,
-54, -55, -54, -54, -54, -54, -53, -51, -48, -47, -45, -46, -45, -44, -42, -41,
-39, -37, -35, -31, -29, -29, -27, -26, -25, -25, -28, -29, -29, -28, -26, -26,
-25, -26, -26, -24, -20, -17, -15, -14, -13, -12, -10, -7, -4, -2, -3, -6, -9,
-14, -16, -17, -18, -22, -27, -30, -34, -37, -39, -41, -42, -41, -37, -33, -29,
-27, -24, -19, -13, -7, -3, 1, 2, 6, 10, 12, 14, 14, 15, 17, 18, 21, 19, 17, 12,
9, 6, 5, 3, -1, -3, -5, -7, -6, -5, -5, -7, -10, -13, -16, -16, -16, -16, -16,
-14, -13, -11, -6, 6, 22, 34, 39, 40, 43, 47, 54, 62, 69, 75, 77, 81, 86, 91,
96, 100, 103, 105, 107, 110, 114, 116, 119, 119, 118, 117, 116, 117, 117, 117,
115, 114, 112, 108, 106, 103, 100, 98, 95, 91, 88, 83, 80, 78, 75, 73, 70, 65,
60, 56, 54, 52, 50, 46, 42, 40, 37, 35, 34, 35, 36, 37, 40, 41, 42, 43, 45, 47,
46, 46, 44, 41, 39, 35, 30, 27, 21, 16, 12, 8, 4, 1, -2, -5, -9, -12, -15, -18,
-20, -22, -24, -25, -26, -29, -31, -33, -36, -38, -41, -44, -48, -53, -57, -61,
-65, -69, -70, -73, -75, -75, -77, -76, -76, -75, -73, -73, -73, -72, -72, -71,
-70, -70, -69, -69, -69, -69, -70, -70, -72, -73, -73, -75, -76, -78, -80, -81,
-83, -82, -83, -83, -85, -88, -90, -92, -95, -96, -97, -97, -96, -96, -95, -94,
-91, -87, -83, -79, -73, -69, -64, -59, -55, -50, -46, -42, -37, -33, -28, -23,
-20, -17, -14, -12, -10, -8, -6, -4, -2, -2, -3, -4, -6, -7, -8, -9, -11, -14,
-16, -18, -21, -23, -26, -28, -29, -31, -33, -34, -34, -35, -32, -31, -28, -25,
-22, -18, -15, -12, -8, -6, -2, 0, };