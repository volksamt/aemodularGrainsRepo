#define DATA_LENGTH 512
#define DATA AKWF_1679

const PROGMEM int8_t DATA[DATA_LENGTH] = {35, 79, 72, 73, 72, 72, 71, 72, 69,
76, 39, 61, 78, 67, 73, 66, 70, 66, 68, 64, 66, 63, 66, 64, 65, 66, 66, 66, 66,
66, 66, 65, 65, 65, 65, 64, 63, 63, 63, 64, 62, 63, 63, 62, 62, 61, 60, 60, 60,
61, 60, 60, 59, 60, 59, 59, 59, 58, 58, 58, 57, 57, 57, 56, 57, 56, 55, 56, 56,
56, 55, 55, 55, 55, 54, 54, 54, 53, 53, 53, 53, 53, 52, 53, 51, 50, 50, 48, 48,
46, 47, 44, 43, 36, 32, 17, 1, 4, 2, 3, 1, 2, 1, 0, -1, -1, 0, -2, -2, -3, -2,
-3, -3, -4, -4, -5, -4, -2, 6, 15, 34, 44, 43, 44, 43, 44, 44, 43, 43, 44, 43,
43, 43, 44, 42, 43, 44, 43, 43, 44, 44, 43, 43, 44, 43, 44, 44, 43, 43, 43, 43,
43, 42, 42, 42, 42, 41, 41, 41, 41, 42, 41, 41, 42, 42, 41, 41, 41, 40, 39, 40,
40, 40, 39, 39, 40, 39, 40, 39, 39, 39, 39, 39, 39, 38, 38, 38, 37, 38, 37, 37,
36, 37, 37, 30, 34, 33, 33, 32, 32, 29, 28, 26, 26, 22, 20, 17, 14, 10, -20,
-29, -32, -42, -48, -54, -55, -54, -52, -51, -50, -50, -46, -47, -44, -41, -41,
-42, -43, -43, -43, -44, -43, -44, -44, -45, -45, -46, -45, -46, -47, -46, -47,
-48, -49, -48, -50, -49, -50, -49, -52, -49, -52, -47, -48, -36, -24, 13, 49,
43, 43, 43, 43, 43, 43, 43, 46, 9, 39, 49, 41, 46, 40, 43, 39, 42, 38, 41, 38,
41, 40, 42, 40, 43, 43, 43, 43, 42, 42, 42, 43, 42, 43, 41, 43, 42, 42, 42, 42,
42, 42, 42, 42, 42, 42, 42, 41, 40, 41, 41, 41, 41, 41, 40, 41, 41, 41, 40, 40,
40, 40, 40, 40, 40, 40, 40, 40, 40, 39, 39, 39, 39, 40, 39, 40, 39, 39, 39, 38,
38, 38, 37, 37, 36, 34, 34, 33, 33, 31, 31, 23, 18, 2, -12, -8, -11, -9, -11,
-10, -11, -11, -11, -12, -12, -12, -13, -13, -14, -14, -14, -14, -14, -15, -13,
-11, -4, 7, 27, 35, 34, 35, 34, 34, 34, 34, 35, 35, 35, 35, 34, 35, 34, 36, 36,
35, 35, 35, 34, 35, 36, 35, 36, 36, 35, 35, 36, 37, 36, 35, 35, 35, 35, 35, 35,
35, 34, 35, 34, 35, 34, 35, 35, 34, 34, 34, 35, 35, 33, 35, 34, 34, 34, 33, 33,
34, 33, 33, 34, 33, 34, 33, 34, 32, 34, 31, 35, 29, 36, 26, 41, 1, -56, -40,
-47, -40, -44, -43, -45, -44, -46, -46, -50, -50, -53, -54, -60, -91, -95, -101,
-107, -115, -117, -118, -117, -115, -113, -111, -109, -107, -106, -101, -99,
-99, -98, -99, -98, -99, -98, -98, -98, -99, -97, -98, -97, -98, -98, -97, -97,
-97, -97, -96, -98, -96, -97, -95, -98, -95, -97, -94, -96, -87, -84, -54, };