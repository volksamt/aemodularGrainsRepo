#define DATA_LENGTH 512
#define DATA AKWF_flute_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 3, 6, 7, 8, 9, 11, 11, 12, 13,
14, 13, 14, 13, 14, 13, 13, 13, 13, 13, 13, 12, 13, 13, 13, 14, 14, 15, 15, 15,
17, 18, 20, 21, 23, 24, 25, 26, 27, 28, 29, 30, 30, 30, 31, 32, 32, 33, 33, 34,
34, 35, 35, 36, 36, 37, 37, 38, 37, 37, 37, 37, 37, 36, 36, 37, 37, 37, 37, 37,
38, 38, 38, 39, 38, 39, 39, 41, 42, 42, 42, 44, 45, 46, 46, 46, 49, 48, 50, 50,
51, 52, 53, 53, 54, 54, 55, 55, 57, 57, 57, 59, 59, 59, 60, 61, 62, 63, 64, 64,
64, 65, 67, 67, 68, 69, 70, 71, 72, 72, 73, 74, 75, 76, 76, 78, 79, 80, 81, 82,
83, 84, 86, 88, 89, 91, 93, 94, 96, 97, 99, 101, 103, 104, 106, 108, 109, 110,
112, 113, 114, 115, 116, 117, 117, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 117, 117, 116, 115, 116, 115, 114, 114, 113, 113, 112, 112, 112, 111, 112,
112, 112, 112, 113, 112, 112, 112, 113, 113, 113, 112, 112, 112, 111, 111, 112,
112, 111, 110, 109, 109, 109, 109, 108, 106, 105, 104, 103, 101, 101, 100, 97,
96, 94, 92, 92, 89, 88, 86, 84, 83, 80, 80, 78, 75, 74, 72, 69, 67, 66, 63, 61,
59, 58, 54, 53, 50, 47, 45, 43, 40, 37, 34, 31, 28, 25, 22, 19, 15, 13, 11, 9,
6, 4, 2, 0, -2, -4, -5, -6, -8, -8, -9, -10, -12, -12, -12, -14, -15, -14, -16,
-17, -16, -18, -17, -18, -19, -19, -19, -20, -20, -20, -22, -22, -23, -25, -26,
-27, -28, -30, -30, -31, -32, -33, -34, -35, -36, -36, -36, -37, -38, -39, -40,
-40, -40, -41, -41, -42, -44, -43, -44, -44, -45, -44, -46, -46, -45, -46, -46,
-46, -47, -48, -49, -49, -50, -50, -51, -51, -52, -53, -53, -53, -53, -53, -54,
-54, -55, -55, -56, -57, -58, -59, -59, -60, -60, -60, -61, -61, -63, -63, -63,
-63, -65, -65, -65, -65, -66, -65, -67, -67, -68, -68, -69, -70, -70, -71, -72,
-74, -74, -75, -77, -78, -79, -80, -81, -82, -83, -83, -85, -86, -87, -89, -90,
-91, -93, -93, -94, -96, -97, -99, -101, -100, -102, -104, -103, -104, -105,
-107, -108, -108, -108, -108, -108, -108, -109, -109, -109, -110, -110, -111,
-111, -112, -111, -112, -112, -114, -113, -114, -115, -114, -114, -114, -115,
-115, -116, -114, -115, -115, -113, -113, -113, -112, -112, -112, -111, -110,
-108, -108, -107, -106, -106, -105, -104, -103, -103, -102, -102, -102, -102,
-101, -100, -100, -101, -100, -100, -99, -99, -98, -98, -97, -97, -98, -98, -98,
-99, -100, -99, -100, -100, -99, -99, -99, -99, -97, -96, -95, -91, -91, -88,
-86, -84, -81, -79, -76, -73, -70, -67, -65, -61, -58, -55, -52, -48, -45, -41,
-39, -34, -32, -29, -27, -24, -21, -19, -16, -14, -12, -9, -7, -5, -3, -1, };