#define DATA_LENGTH 512
#define DATA AKWF_flute_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 5, 6, 7, 9, 11, 12, 13, 14,
16, 18, 19, 20, 21, 22, 24, 25, 25, 27, 28, 29, 29, 31, 33, 33, 35, 36, 37, 38,
39, 41, 42, 42, 45, 45, 46, 47, 48, 49, 51, 52, 53, 54, 55, 56, 57, 58, 59, 60,
62, 63, 64, 65, 66, 66, 68, 69, 70, 71, 71, 73, 74, 74, 76, 77, 76, 77, 78, 80,
80, 80, 81, 82, 83, 84, 85, 84, 85, 86, 87, 89, 89, 90, 92, 92, 93, 94, 94, 95,
95, 97, 97, 98, 98, 100, 101, 101, 101, 102, 103, 103, 104, 105, 105, 106, 106,
108, 108, 109, 110, 110, 111, 112, 112, 113, 113, 113, 114, 114, 115, 115, 116,
116, 116, 117, 118, 117, 117, 117, 118, 118, 118, 118, 119, 120, 119, 120, 119,
119, 119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 118, 118, 119, 117, 118,
117, 117, 117, 116, 116, 115, 115, 114, 113, 113, 112, 112, 111, 111, 110, 108,
108, 107, 106, 106, 105, 103, 103, 102, 101, 99, 98, 96, 95, 94, 94, 93, 92, 90,
90, 88, 87, 84, 83, 81, 80, 78, 77, 75, 75, 72, 71, 70, 68, 67, 64, 63, 62, 60,
57, 55, 54, 52, 51, 48, 46, 44, 43, 41, 39, 37, 35, 33, 32, 30, 27, 25, 23, 22,
20, 18, 16, 14, 12, 10, 10, 8, 6, 4, 2, 0, 0, -2, -4, -5, -7, -9, -10, -11, -13,
-15, -17, -17, -19, -19, -22, -22, -24, -26, -26, -28, -29, -31, -31, -31, -32,
-34, -35, -36, -36, -37, -38, -39, -40, -42, -42, -43, -44, -44, -45, -45, -46,
-47, -48, -48, -49, -49, -50, -50, -52, -51, -52, -52, -53, -53, -54, -54, -55,
-55, -55, -56, -56, -56, -57, -58, -58, -59, -59, -59, -59, -60, -61, -62, -62,
-62, -63, -62, -63, -65, -65, -66, -66, -66, -68, -68, -69, -70, -70, -70, -71,
-71, -72, -73, -73, -74, -73, -75, -76, -76, -77, -79, -78, -80, -80, -81, -81,
-82, -83, -83, -84, -85, -85, -86, -88, -88, -89, -89, -90, -91, -91, -93, -92,
-93, -94, -94, -95, -95, -96, -96, -97, -98, -98, -98, -99, -99, -100, -100,
-99, -100, -100, -100, -100, -101, -101, -101, -101, -102, -101, -102, -102,
-101, -102, -101, -102, -102, -101, -101, -101, -100, -100, -101, -100, -100,
-100, -98, -98, -98, -98, -98, -98, -97, -97, -96, -95, -95, -95, -94, -93, -94,
-93, -92, -90, -90, -90, -89, -88, -87, -87, -87, -86, -85, -85, -83, -83, -82,
-81, -81, -80, -80, -80, -79, -79, -77, -76, -76, -75, -74, -73, -73, -72, -71,
-71, -69, -68, -67, -66, -66, -64, -63, -62, -61, -61, -60, -59, -59, -58, -57,
-56, -55, -54, -52, -52, -51, -49, -47, -46, -45, -44, -43, -42, -41, -40, -38,
-38, -36, -35, -34, -32, -31, -29, -28, -26, -25, -24, -23, -21, -20, -19, -18,
-16, -15, -14, -12, -11, -9, -7, -6, -5, -4, -2, -1, };