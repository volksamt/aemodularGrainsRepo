#define DATA_LENGTH 512
#define DATA AKWF_flute_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 6, 8, 10, 12, 12, 15, 16, 19,
21, 22, 23, 25, 27, 27, 29, 31, 33, 33, 35, 37, 37, 39, 39, 40, 42, 43, 45, 46,
47, 48, 49, 50, 51, 52, 52, 54, 54, 55, 57, 58, 58, 59, 59, 61, 62, 62, 63, 63,
65, 65, 66, 67, 67, 67, 68, 69, 70, 71, 70, 72, 72, 72, 72, 73, 73, 74, 75, 75,
76, 76, 77, 76, 77, 77, 79, 78, 80, 80, 80, 80, 81, 82, 82, 81, 83, 83, 84, 85,
85, 86, 87, 87, 89, 89, 90, 91, 91, 92, 93, 94, 94, 94, 96, 96, 97, 97, 99, 98,
99, 100, 100, 101, 101, 101, 103, 102, 102, 104, 103, 103, 103, 104, 105, 105,
105, 105, 105, 106, 105, 105, 106, 106, 106, 105, 106, 106, 106, 106, 106, 105,
106, 106, 105, 105, 105, 105, 105, 106, 105, 105, 104, 104, 104, 104, 104, 103,
103, 103, 103, 103, 102, 102, 101, 102, 102, 101, 101, 100, 100, 100, 100, 100,
100, 99, 99, 99, 99, 98, 98, 97, 97, 97, 96, 95, 95, 95, 95, 94, 93, 93, 92, 91,
91, 91, 89, 89, 89, 88, 87, 86, 85, 84, 84, 83, 81, 81, 80, 79, 78, 78, 77, 75,
73, 72, 72, 71, 69, 68, 67, 65, 64, 63, 61, 60, 59, 58, 56, 54, 53, 52, 50, 48,
47, 45, 44, 42, 42, 40, 37, 36, 35, 33, 32, 30, 28, 27, 25, 23, 21, 20, 18, 16,
15, 14, 11, 10, 8, 7, 4, 3, 2, 1, -2, -2, -4, -6, -8, -9, -11, -12, -14, -15,
-16, -19, -20, -21, -22, -25, -26, -27, -28, -30, -32, -33, -34, -35, -37, -38,
-39, -42, -42, -44, -45, -46, -47, -50, -51, -52, -53, -53, -55, -56, -58, -59,
-59, -61, -62, -64, -65, -66, -68, -67, -69, -71, -71, -73, -73, -74, -75, -76,
-77, -78, -78, -80, -81, -81, -83, -83, -85, -85, -86, -86, -87, -88, -89, -89,
-91, -91, -92, -93, -94, -94, -96, -97, -98, -99, -98, -99, -100, -100, -102,
-102, -103, -103, -105, -105, -106, -106, -107, -108, -108, -109, -109, -110,
-110, -111, -112, -112, -113, -114, -114, -114, -115, -116, -116, -116, -116,
-117, -117, -117, -118, -119, -119, -118, -118, -119, -119, -119, -120, -119,
-119, -119, -118, -119, -119, -119, -119, -118, -118, -118, -117, -117, -116,
-116, -115, -115, -114, -113, -113, -112, -112, -112, -112, -111, -111, -110,
-110, -109, -108, -107, -106, -106, -105, -105, -105, -104, -104, -103, -102,
-101, -101, -100, -100, -99, -98, -97, -97, -96, -95, -95, -93, -93, -92, -90,
-90, -88, -87, -86, -86, -84, -84, -83, -82, -81, -80, -78, -77, -77, -75, -73,
-73, -72, -71, -70, -68, -67, -66, -64, -63, -62, -61, -60, -60, -58, -57, -56,
-55, -53, -53, -51, -50, -49, -48, -46, -45, -43, -43, -41, -39, -37, -36, -34,
-32, -31, -30, -28, -25, -24, -23, -20, -19, -17, -14, -12, -10, -8, -5, -4, -2,
0, };