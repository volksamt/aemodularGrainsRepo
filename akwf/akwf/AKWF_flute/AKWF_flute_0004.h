#define DATA_LENGTH 512
#define DATA AKWF_flute_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 3, 5, 6, 8, 10, 13, 13, 16, 18,
20, 22, 23, 25, 26, 28, 30, 32, 33, 35, 36, 38, 39, 41, 42, 43, 45, 47, 49, 50,
51, 53, 54, 55, 55, 56, 58, 59, 61, 62, 63, 65, 67, 68, 68, 70, 70, 71, 72, 72,
74, 75, 75, 77, 77, 78, 78, 79, 79, 79, 80, 79, 79, 81, 80, 81, 81, 81, 82, 82,
83, 83, 83, 83, 84, 83, 84, 84, 84, 85, 85, 86, 86, 87, 88, 88, 90, 91, 92, 93,
94, 95, 95, 96, 98, 98, 99, 100, 101, 101, 102, 102, 103, 104, 105, 107, 108,
109, 111, 111, 112, 112, 112, 113, 113, 113, 113, 114, 116, 116, 117, 117, 117,
118, 118, 117, 117, 117, 117, 118, 117, 117, 118, 118, 117, 116, 115, 115, 113,
114, 113, 112, 111, 110, 109, 109, 107, 107, 105, 104, 103, 101, 99, 98, 96, 94,
94, 91, 89, 88, 85, 83, 81, 78, 77, 74, 73, 71, 68, 66, 63, 60, 58, 56, 53, 50,
47, 44, 41, 39, 36, 34, 33, 30, 28, 24, 22, 20, 17, 14, 11, 8, 5, 3, 0, -2, -5,
-7, -9, -12, -14, -17, -20, -22, -23, -25, -28, -31, -32, -34, -36, -38, -39,
-41, -42, -44, -45, -47, -49, -49, -51, -51, -51, -53, -53, -54, -55, -55, -55,
-55, -56, -56, -55, -55, -54, -54, -54, -53, -53, -51, -52, -51, -49, -49, -48,
-46, -45, -45, -43, -42, -40, -39, -38, -37, -35, -35, -34, -33, -31, -30, -28,
-27, -26, -24, -23, -22, -20, -21, -20, -19, -17, -16, -14, -13, -13, -11, -11,
-9, -10, -9, -9, -8, -8, -8, -8, -8, -7, -7, -7, -7, -7, -6, -6, -6, -6, -5, -5,
-4, -5, -4, -4, -4, -5, -6, -6, -7, -8, -7, -8, -8, -9, -10, -11, -10, -11, -11,
-11, -12, -13, -13, -14, -14, -15, -17, -17, -18, -18, -18, -20, -21, -21, -22,
-24, -25, -25, -26, -28, -28, -30, -31, -32, -33, -34, -35, -36, -38, -39, -39,
-40, -41, -42, -43, -44, -44, -45, -45, -46, -47, -48, -49, -49, -50, -49, -50,
-51, -51, -51, -52, -51, -52, -53, -52, -52, -53, -54, -54, -54, -55, -55, -55,
-56, -57, -59, -59, -60, -61, -62, -63, -63, -65, -66, -67, -69, -70, -71, -73,
-74, -74, -76, -79, -81, -81, -83, -84, -85, -86, -88, -89, -91, -93, -95, -96,
-98, -99, -100, -101, -103, -104, -107, -107, -109, -110, -111, -113, -113,
-113, -115, -115, -115, -116, -116, -116, -117, -118, -117, -118, -118, -119,
-120, -119, -119, -119, -118, -118, -118, -117, -116, -116, -114, -115, -113,
-113, -112, -112, -111, -109, -109, -107, -105, -105, -104, -102, -101, -99,
-97, -95, -94, -92, -91, -89, -87, -85, -83, -80, -78, -75, -73, -72, -69, -67,
-64, -62, -60, -58, -55, -52, -49, -46, -45, -41, -40, -37, -36, -32, -31, -28,
-26, -24, -22, -20, -17, -15, -13, -11, -9, -7, -5, -4, -1, -1, -1, };