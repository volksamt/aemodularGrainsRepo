#define DATA_LENGTH 512
#define DATA AKWF_flute_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 5, 7, 9, 11, 13, 14, 14, 16, 17,
19, 20, 23, 23, 23, 23, 23, 25, 24, 24, 25, 24, 25, 26, 26, 27, 26, 26, 25, 26,
27, 28, 28, 28, 28, 30, 30, 31, 31, 31, 32, 32, 32, 34, 36, 38, 39, 39, 39, 40,
42, 43, 44, 46, 46, 48, 49, 50, 51, 52, 53, 54, 54, 55, 55, 57, 58, 58, 58, 57,
57, 57, 58, 59, 59, 60, 61, 60, 60, 58, 59, 58, 59, 58, 59, 59, 58, 59, 59, 59,
59, 59, 59, 58, 59, 59, 59, 60, 61, 61, 62, 63, 63, 63, 63, 65, 66, 66, 66, 66,
66, 68, 68, 69, 70, 70, 72, 72, 73, 74, 74, 75, 76, 77, 79, 80, 81, 81, 81, 82,
84, 85, 86, 86, 88, 90, 90, 90, 92, 92, 92, 93, 94, 97, 97, 97, 98, 99, 99, 100,
101, 102, 103, 104, 104, 106, 106, 106, 106, 106, 106, 107, 107, 108, 109, 109,
110, 109, 110, 111, 111, 110, 110, 110, 109, 110, 108, 109, 109, 108, 108, 106,
106, 105, 106, 105, 104, 103, 103, 103, 101, 102, 101, 101, 100, 99, 99, 98, 97,
96, 94, 94, 93, 91, 92, 91, 91, 89, 88, 87, 86, 85, 84, 82, 82, 81, 80, 78, 77,
76, 74, 73, 69, 69, 66, 65, 64, 61, 59, 58, 56, 55, 52, 48, 45, 43, 40, 37, 35,
32, 31, 28, 25, 23, 20, 17, 14, 13, 10, 8, 5, 3, 0, -3, -5, -6, -9, -11, -13,
-14, -14, -17, -18, -20, -21, -21, -22, -24, -24, -25, -25, -25, -25, -25, -25,
-25, -24, -25, -25, -24, -23, -21, -20, -19, -18, -18, -17, -16, -16, -16, -15,
-16, -16, -14, -14, -15, -14, -16, -15, -16, -16, -18, -19, -20, -21, -22, -24,
-25, -26, -27, -27, -29, -31, -33, -36, -38, -40, -40, -42, -44, -46, -46, -48,
-48, -50, -51, -51, -52, -52, -52, -52, -52, -53, -53, -53, -53, -53, -53, -52,
-51, -52, -51, -50, -51, -50, -50, -50, -48, -48, -49, -50, -51, -52, -52, -53,
-53, -54, -56, -57, -58, -59, -60, -62, -63, -66, -65, -68, -69, -71, -72, -73,
-76, -77, -79, -81, -83, -84, -86, -86, -88, -89, -90, -91, -93, -93, -94, -96,
-97, -98, -97, -98, -99, -100, -103, -104, -104, -104, -104, -104, -105, -107,
-106, -107, -107, -109, -108, -110, -110, -110, -110, -112, -112, -112, -114,
-114, -115, -115, -115, -115, -115, -116, -116, -118, -118, -118, -118, -119,
-119, -119, -119, -120, -120, -119, -119, -118, -119, -118, -117, -116, -116,
-115, -114, -114, -113, -113, -112, -111, -110, -110, -109, -108, -107, -107,
-105, -106, -105, -104, -104, -103, -101, -102, -101, -102, -101, -101, -100,
-100, -99, -98, -96, -95, -94, -93, -93, -91, -90, -89, -87, -86, -85, -82, -82,
-79, -77, -75, -72, -69, -67, -64, -61, -58, -55, -53, -50, -46, -44, -41, -37,
-34, -31, -28, -24, -22, -19, -16, -14, -13, -9, -7, -5, -1, };