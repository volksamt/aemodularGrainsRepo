#define DATA_LENGTH 512
#define DATA AKWF_flute_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 7, 8, 10, 11, 13, 14, 17, 17,
18, 19, 21, 21, 22, 23, 23, 24, 25, 25, 25, 25, 25, 25, 25, 25, 24, 25, 25, 25,
24, 24, 25, 24, 25, 25, 25, 25, 25, 25, 25, 25, 26, 26, 26, 27, 28, 29, 30, 31,
31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 40, 42, 42, 43, 44, 44, 45, 45, 45, 46,
47, 47, 47, 48, 48, 48, 49, 49, 50, 50, 50, 51, 50, 52, 53, 53, 53, 54, 54, 55,
57, 57, 57, 58, 59, 60, 61, 62, 63, 64, 66, 66, 67, 68, 69, 70, 71, 73, 74, 74,
76, 76, 78, 77, 79, 80, 81, 82, 83, 83, 84, 85, 85, 86, 87, 88, 88, 88, 90, 90,
90, 91, 91, 91, 92, 93, 94, 95, 95, 96, 97, 98, 99, 99, 100, 100, 101, 102, 102,
103, 103, 104, 104, 105, 107, 108, 108, 110, 111, 111, 112, 113, 114, 114, 116,
117, 117, 118, 118, 118, 119, 119, 119, 120, 118, 118, 119, 119, 120, 119, 118,
118, 118, 116, 116, 115, 115, 114, 114, 113, 111, 111, 109, 109, 107, 106, 104,
103, 101, 100, 99, 97, 95, 94, 93, 90, 89, 87, 86, 84, 82, 80, 79, 77, 76, 74,
72, 71, 69, 68, 67, 65, 64, 63, 60, 59, 58, 57, 55, 53, 52, 52, 50, 48, 47, 46,
45, 44, 43, 42, 42, 41, 41, 40, 38, 37, 36, 35, 33, 31, 30, 29, 26, 25, 22, 22,
18, 16, 15, 13, 10, 9, 7, 5, 3, 2, 0, -3, -4, -7, -8, -9, -11, -11, -13, -13,
-15, -16, -17, -18, -19, -20, -21, -21, -22, -23, -24, -25, -25, -26, -27, -27,
-27, -28, -29, -30, -30, -30, -31, -32, -33, -33, -32, -33, -34, -35, -34, -35,
-35, -37, -36, -36, -38, -38, -38, -38, -39, -41, -41, -41, -42, -43, -43, -43,
-44, -45, -44, -45, -46, -45, -46, -46, -48, -48, -49, -49, -50, -50, -51, -52,
-53, -53, -54, -55, -55, -56, -57, -57, -58, -58, -60, -60, -61, -61, -62, -62,
-63, -64, -63, -64, -64, -64, -65, -66, -67, -67, -68, -68, -69, -69, -69, -70,
-69, -70, -71, -72, -72, -74, -75, -76, -77, -78, -80, -80, -81, -81, -82, -83,
-83, -84, -85, -86, -87, -87, -88, -89, -89, -91, -92, -92, -92, -93, -93, -95,
-94, -96, -96, -96, -95, -95, -95, -96, -95, -94, -94, -93, -92, -93, -91, -92,
-91, -90, -90, -91, -91, -91, -90, -89, -89, -90, -89, -88, -87, -87, -87, -87,
-87, -87, -86, -86, -87, -87, -85, -86, -85, -85, -84, -83, -83, -83, -83, -83,
-83, -82, -81, -81, -81, -80, -79, -78, -77, -75, -74, -73, -71, -69, -69, -67,
-65, -64, -63, -62, -61, -60, -58, -57, -55, -54, -53, -51, -49, -49, -47, -45,
-44, -43, -41, -41, -39, -37, -36, -34, -33, -32, -30, -27, -25, -24, -22, -20,
-18, -17, -14, -13, -11, -9, -7, -6, -4, -2, 0, };