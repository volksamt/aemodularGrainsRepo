#define DATA_LENGTH 512
#define DATA AKWF_flute_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 4, 6, 7, 7, 8, 10, 10, 11,
12, 13, 15, 15, 16, 16, 18, 18, 18, 19, 19, 20, 19, 21, 21, 21, 21, 22, 23, 22,
22, 23, 23, 23, 23, 24, 24, 24, 25, 26, 25, 26, 26, 26, 27, 28, 27, 28, 29, 30,
30, 31, 31, 32, 32, 33, 34, 36, 37, 38, 39, 40, 41, 42, 43, 43, 44, 45, 45, 46,
47, 47, 48, 49, 49, 50, 50, 51, 51, 51, 51, 50, 50, 51, 51, 51, 51, 52, 51, 52,
52, 52, 53, 53, 53, 54, 54, 55, 55, 57, 57, 58, 59, 60, 61, 62, 62, 64, 63, 63,
64, 65, 67, 66, 68, 69, 70, 70, 73, 74, 75, 76, 77, 78, 80, 81, 82, 83, 84, 86,
87, 88, 88, 89, 91, 91, 92, 92, 92, 94, 93, 94, 94, 95, 95, 96, 96, 96, 97, 96,
98, 97, 98, 98, 99, 100, 101, 102, 103, 105, 106, 107, 108, 109, 110, 111, 111,
112, 113, 114, 115, 115, 117, 117, 118, 118, 119, 119, 119, 118, 119, 119, 118,
118, 118, 116, 116, 115, 114, 113, 112, 112, 110, 109, 108, 108, 106, 105, 103,
102, 99, 98, 96, 94, 92, 91, 90, 88, 87, 87, 86, 86, 85, 84, 82, 81, 80, 78, 77,
77, 75, 73, 73, 72, 70, 69, 67, 66, 63, 62, 61, 59, 57, 56, 54, 52, 51, 49, 47,
44, 43, 41, 40, 37, 36, 34, 31, 28, 27, 25, 22, 21, 19, 18, 15, 13, 11, 10, 8,
5, 2, 1, -1, -3, -6, -7, -9, -10, -11, -13, -13, -14, -15, -15, -15, -17, -17,
-17, -17, -18, -19, -19, -18, -19, -19, -20, -20, -20, -21, -21, -23, -22, -23,
-23, -23, -23, -25, -25, -26, -28, -29, -30, -31, -31, -32, -33, -33, -35, -36,
-36, -36, -37, -38, -38, -39, -39, -41, -41, -40, -42, -41, -42, -43, -43, -43,
-44, -43, -44, -44, -44, -45, -45, -45, -45, -45, -45, -46, -47, -47, -48, -48,
-49, -50, -51, -53, -53, -54, -54, -55, -56, -56, -56, -59, -59, -60, -60, -61,
-62, -62, -63, -64, -63, -64, -65, -65, -66, -66, -66, -67, -68, -69, -69, -69,
-70, -70, -71, -71, -72, -72, -73, -74, -74, -75, -77, -78, -79, -81, -82, -83,
-84, -86, -88, -88, -90, -91, -91, -93, -94, -94, -94, -95, -96, -96, -96, -95,
-96, -96, -95, -95, -96, -96, -95, -96, -95, -94, -95, -95, -95, -95, -94, -94,
-94, -95, -95, -95, -95, -95, -95, -94, -94, -94, -95, -95, -95, -96, -96, -97,
-98, -99, -100, -100, -101, -102, -101, -101, -101, -101, -101, -100, -100, -99,
-99, -98, -97, -96, -94, -94, -93, -91, -89, -88, -86, -85, -83, -81, -78, -76,
-74, -72, -70, -68, -65, -62, -61, -58, -54, -53, -50, -48, -45, -43, -41, -40,
-39, -36, -35, -34, -32, -30, -29, -28, -27, -25, -24, -23, -22, -20, -19, -18,
-17, -16, -15, -13, -12, -10, -8, -7, -4, -3, -1, 0, };