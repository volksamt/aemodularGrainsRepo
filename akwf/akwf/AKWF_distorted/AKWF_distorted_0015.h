#define DATA_LENGTH 512
#define DATA AKWF_distorted_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 10, 14, 19, 22, 27, 31, 35, 39, 42,
45, 49, 51, 55, 58, 60, 63, 66, 68, 70, 72, 74, 76, 78, 80, 81, 83, 84, 86, 87,
89, 90, 92, 94, 94, 95, 96, 96, 97, 99, 100, 101, 102, 103, 103, 104, 104, 106,
106, 107, 107, 106, 108, 108, 109, 109, 110, 110, 111, 110, 112, 111, 112, 112,
113, 112, 114, 113, 114, 113, 114, 114, 114, 115, 115, 116, 115, 117, 113, 120,
110, 122, 106, 127, 36, -68, -33, -48, -32, -36, -27, -27, -20, -18, -12, -8,
-3, 3, 7, 14, 17, 22, 25, 31, 34, 38, 40, 46, 47, 51, 54, 57, 58, 63, 64, 67,
69, 72, 73, 76, 77, 79, 80, 83, 84, 86, 87, 89, 90, 90, 93, 93, 95, 95, 96, 98,
99, 99, 100, 102, 102, 103, 104, 104, 105, 105, 107, 106, 107, 108, 108, 109,
108, 110, 110, 110, 111, 111, 112, 112, 112, 113, 113, 114, 113, 114, 114, 114,
114, 114, 115, 115, 115, 116, 115, 116, 116, 115, 116, 117, 116, 115, 116, 116,
116, 117, 117, 117, 117, 118, 117, 117, 118, 118, 117, 118, 118, 118, 118, 118,
118, 118, 119, 118, 119, 118, 118, 118, 118, 119, 118, 119, 118, 118, 119, 119,
119, 118, 119, 119, 119, 118, 119, 119, 119, 118, 120, 118, 119, 118, 119, 118,
118, 120, 118, 120, 118, 120, 118, 120, 117, 121, 117, 121, 117, 122, 117, 122,
117, 122, 117, 121, 118, 118, 126, -91, -128, -110, -127, -113, -124, -114,
-123, -115, -122, -116, -121, -117, -120, -118, -120, -118, -119, -119, -118,
-119, -119, -119, -117, -119, -119, -119, -118, -120, -118, -120, -119, -118,
-118, -118, -119, -119, -118, -119, -119, -118, -118, -119, -119, -119, -118,
-118, -119, -118, -118, -119, -119, -118, -118, -118, -117, -119, -118, -117,
-118, -118, -118, -117, -118, -118, -117, -118, -118, -117, -117, -117, -117,
-116, -116, -117, -116, -117, -116, -116, -115, -116, -116, -114, -115, -116,
-114, -114, -114, -114, -115, -114, -113, -114, -113, -113, -112, -111, -111,
-111, -111, -111, -110, -109, -110, -109, -107, -107, -107, -106, -106, -105,
-104, -104, -104, -103, -102, -101, -100, -100, -98, -98, -97, -96, -95, -93,
-92, -91, -90, -89, -87, -86, -84, -82, -82, -79, -77, -75, -74, -71, -69, -67,
-65, -62, -60, -56, -55, -51, -48, -45, -42, -38, -35, -30, -27, -22, -18, -14,
-8, -4, 3, 6, 15, 14, 24, 21, 34, 28, 44, 31, 60, 0, -128, -109, -120, -114,
-118, -115, -115, -115, -114, -116, -113, -116, -113, -115, -113, -115, -112,
-114, -113, -113, -111, -113, -111, -113, -111, -111, -110, -110, -110, -110,
-109, -108, -108, -107, -107, -107, -106, -105, -105, -103, -103, -102, -101,
-101, -100, -98, -99, -97, -97, -95, -94, -93, -92, -90, -89, -88, -87, -85,
-83, -81, -81, -78, -76, -74, -72, -69, -68, -65, -63, -60, -58, -56, -53, -49,
-45, -42, -39, -36, -31, -28, -23, -19, -14, -11, -4, 0, };