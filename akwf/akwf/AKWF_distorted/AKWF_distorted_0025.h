#define DATA_LENGTH 512
#define DATA AKWF_distorted_0025

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 26, 39, 44, 44, 35, 25, 13, 8, 24,
43, 56, 64, 60, 52, 41, 29, 25, 32, 43, 56, 64, 69, 69, 63, 57, 47, 42, 46, 54,
65, 74, 76, 75, 70, 58, 51, 51, 56, 67, 74, 78, 77, 72, 63, 56, 53, 60, 71, 76,
81, 79, 75, 70, 66, 63, 65, 66, 67, 70, 73, 77, 79, 79, 78, 74, 71, 70, 73, 76,
79, 79, 81, 83, 84, 86, 88, 88, 88, 87, 86, 87, 88, 90, 92, 94, 95, 96, 97, 98,
100, 101, 100, 99, 98, 96, 98, 103, 106, 109, 110, 110, 106, 102, 99, 101, 104,
109, 112, 113, 112, 112, 108, 105, 104, 106, 109, 112, 114, 114, 112, 110, 108,
107, 109, 110, 112, 113, 112, 109, 107, 106, 107, 110, 111, 112, 111, 108, 106,
103, 101, 98, 96, 97, 99, 104, 106, 107, 104, 96, 79, 73, 78, 94, 101, 101, 71,
-38, -105, -103, -102, -32, 74, 107, 63, -61, -114, -114, -121, -112, -106, -77,
-77, -101, -114, -117, -118, -118, -117, -115, -115, -116, -117, -117, -118,
-119, -119, -118, -118, -117, -117, -119, -117, -119, -120, -119, -118, -117,
-115, -114, -115, -116, -118, -119, -118, -117, -114, -108, -103, -105, -108,
-112, -113, -113, -111, -107, -98, -87, -76, -74, -79, -86, -91, -92, -85, -71,
-33, 19, 38, 35, -2, -35, -38, -27, 22, 60, 72, 75, 65, 44, 24, 20, 38, 65, 77,
81, 77, 62, 36, 13, 6, 26, 50, 60, 66, 55, 31, -9, -41, -51, -48, -36, -17, -8,
-23, -43, -64, -76, -78, -75, -69, -64, -68, -77, -86, -90, -90, -87, -82, -80,
-82, -87, -92, -94, -94, -91, -88, -86, -84, -84, -86, -85, -85, -84, -83, -81,
-77, -74, -73, -71, -72, -71, -66, -59, -45, -23, -4, 3, -8, -29, -39, -40, -24,
15, 45, 59, 66, 64, 58, 54, 49, 51, 57, 63, 69, 74, 78, 80, 81, 80, 78, 78, 79,
80, 82, 81, 77, 74, 71, 70, 73, 80, 85, 86, 82, 74, 62, 46, 41, 51, 62, 74, 78,
74, 63, 43, 15, 3, 8, 22, 36, 38, 33, 20, 0, -15, -21, -25, -29, -30, -26, -20,
-12, -8, -23, -41, -54, -60, -55, -40, -25, -15, -24, -43, -56, -60, -58, -50,
-41, -36, -36, -38, -42, -44, -44, -41, -37, -30, -23, -19, -19, -22, -28, -31,
-27, -20, -14, -5, -1, 4, 10, 18, 20, 19, 15, 11, 11, 17, 24, 27, 30, 32, 32,
37, 40, 38, 30, 15, -3, -7, 5, 24, 44, 52, 52, 42, 16, -14, -30, -34, -22, 1,
26, 41, 39, 26, -8, -42, -55, -57, -48, -22, 5, 13, 2, -29, -49, -56, -55, -47,
-34, -33, -44, -53, -62, -61, -52, -42, -31, -30, -41, -54, -64, -68, -68, -62,
-52, -40, -33, -32, -36, -42, -49, -54, -58, -59, -56, -46, -32, -16, -4, -12,
-26, -39, -48, -44, -29, -11, 6, 4, -14, -26, -29, -21, 3, 23, 27, 24, 8, -9,
-14, -8, };