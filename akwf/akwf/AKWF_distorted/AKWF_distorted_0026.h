#define DATA_LENGTH 512
#define DATA AKWF_distorted_0026

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 16, 23, 30, 41, 55, 69, 76, 80, 84,
89, 90, 94, 98, 100, 100, 101, 102, 104, 101, 102, 102, 103, 103, 103, 102, 103,
106, 109, 109, 111, 112, 112, 111, 111, 112, 112, 111, 110, 110, 109, 108, 107,
107, 106, 106, 107, 108, 111, 115, 117, 117, 118, 118, 119, 119, 119, 120, 119,
118, 117, 117, 115, 114, 114, 113, 112, 109, 106, 105, 105, 106, 105, 104, 102,
98, 94, 94, 94, 92, 88, 82, 81, 80, 77, 69, 60, 43, 18, -5, -11, -5, -8, -22,
-40, -59, -77, -89, -95, -100, -103, -106, -107, -108, -108, -107, -105, -102,
-98, -93, -85, -69, -47, -22, -6, -7, -14, -21, -22, -17, -7, 3, 3, -6, -14,
-17, -20, -24, -23, -17, -7, 5, 21, 39, 49, 54, 54, 55, 58, 61, 66, 69, 69, 68,
64, 61, 63, 65, 69, 71, 70, 63, 52, 36, 8, -29, -57, -76, -88, -95, -100, -103,
-104, -106, -108, -109, -108, -109, -108, -107, -108, -107, -107, -107, -107,
-106, -106, -106, -107, -108, -110, -109, -110, -111, -111, -112, -112, -112,
-111, -110, -109, -108, -108, -106, -106, -105, -105, -103, -102, -100, -99,
-95, -91, -84, -72, -59, -43, -26, -3, 18, 31, 37, 39, 34, 26, 16, 3, -10, -23,
-36, -46, -55, -61, -65, -67, -70, -71, -71, -71, -69, -67, -62, -59, -58, -59,
-63, -67, -70, -74, -77, -82, -86, -89, -92, -93, -93, -95, -96, -97, -99, -100,
-102, -103, -104, -104, -106, -107, -107, -105, -104, -103, -102, -100, -96,
-93, -88, -82, -76, -67, -58, -49, -37, -26, -15, -4, 2, 6, 4, 4, 3, 4, 6, 9,
14, 20, 28, 39, 50, 58, 64, 69, 72, 75, 77, 77, 77, 77, 76, 76, 75, 76, 76, 75,
73, 71, 67, 63, 56, 47, 34, 14, -8, -28, -43, -55, -63, -70, -75, -80, -83, -86,
-87, -88, -88, -87, -84, -83, -81, -78, -75, -72, -70, -70, -70, -71, -71, -71,
-69, -66, -63, -59, -52, -41, -28, -15, -5, -1, 0, 2, 8, 15, 21, 28, 37, 46, 55,
64, 68, 71, 72, 74, 75, 76, 77, 78, 79, 81, 83, 85, 85, 84, 82, 79, 76, 71, 65,
56, 48, 42, 40, 41, 42, 44, 45, 47, 49, 50, 48, 43, 35, 27, 22, 21, 21, 20, 17,
17, 20, 24, 27, 26, 22, 15, 11, 9, 9, 8, 6, 2, 2, 5, 9, 13, 14, 12, 8, 4, 5, 7,
13, 19, 25, 30, 37, 45, 53, 58, 61, 60, 58, 55, 54, 53, 51, 44, 41, 40, 37, 34,
30, 23, 16, 13, 8, 1, -12, -25, -37, -45, -46, -48, -51, -54, -58, -61, -60,
-56, -54, -55, -59, -61, -60, -54, -47, -42, -46, -52, -56, -58, -60, -64, -70,
-78, -83, -85, -87, -89, -92, -95, -96, -98, -98, -99, -97, -97, -96, -97, -95,
-93, -88, -83, -79, -76, -75, -72, -70, -66, -62, -61, -59, -53, -47, -43, -38,
-36, -41, -41, -36, -31, -25, -13, -4, };