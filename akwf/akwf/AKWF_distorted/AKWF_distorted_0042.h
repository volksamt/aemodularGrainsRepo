#define DATA_LENGTH 512
#define DATA AKWF_distorted_0042

const PROGMEM int8_t DATA[DATA_LENGTH] = {96, 122, 114, 121, 116, 120, 116, 120,
116, 120, 117, 120, 117, 119, 117, 119, 118, 120, 119, 118, 119, 120, 119, 118,
119, 119, 118, 118, 119, 119, 119, 120, 116, 112, 114, 113, 114, 114, 115, 115,
115, 114, 115, 116, 116, 116, 115, 116, 116, 115, 116, 116, 116, 116, 117, 117,
116, 116, 117, 117, 117, 117, 117, 117, 117, 116, 116, 117, 117, 116, 117, 116,
118, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 117, 116, 116,
117, 117, 117, 117, 117, 116, 117, 116, 116, 117, 116, 116, 116, 115, 115, 115,
115, 116, 116, 116, 114, 114, 115, 115, 115, 115, 114, 114, 114, 114, 113, 113,
113, 114, 113, 112, 112, 112, 112, 112, 110, 111, 110, 110, 109, 109, 109, 109,
107, 107, 107, 106, 106, 105, 104, 104, 103, 103, 103, 100, 100, 100, 99, 97,
97, 95, 95, 93, 93, 91, 90, 89, 88, 87, 85, 84, 83, 82, 79, 79, 77, 75, 75, 73,
72, 70, 69, 68, 66, 66, 65, 64, 64, 63, 63, 64, 63, 65, 65, 66, 67, 69, 70, 71,
73, 74, 76, 77, 79, 80, 82, 84, 85, 86, 87, 89, 90, 92, 94, 95, 95, 96, 98, 98,
99, 100, 101, 103, 103, 104, 104, 105, 106, 107, 108, 107, 109, 109, 110, 110,
111, 110, 112, 112, 113, 112, 114, 113, 114, 113, 114, 115, 114, 116, 114, 117,
114, 118, 113, 119, 112, 121, 112, 121, 110, 124, 108, 127, 71, -108, -88, -93,
-87, -84, -80, -73, -67, -46, 10, 59, 67, 77, 81, 86, 88, 91, 94, 96, 98, 100,
100, 102, 103, 105, 103, 109, 102, 115, 96, 127, -32, -128, -100, -124, -106,
-120, -109, -117, -110, -114, -110, -113, -110, -111, -110, -110, -111, -110,
-111, -108, -110, -108, -109, -108, -109, -107, -107, -106, -107, -106, -107,
-106, -106, -106, -106, -105, -106, -104, -106, -106, -105, -105, -105, -104,
-105, -105, -105, -105, -105, -105, -106, -106, -105, -107, -107, -106, -106,
-106, -108, -107, -107, -108, -108, -108, -109, -109, -109, -110, -110, -110,
-110, -111, -111, -111, -111, -111, -111, -112, -112, -113, -114, -113, -113,
-114, -114, -113, -114, -115, -115, -115, -114, -115, -115, -115, -115, -115,
-116, -116, -116, -117, -116, -116, -116, -116, -117, -116, -116, -117, -117,
-117, -117, -117, -117, -118, -118, -118, -118, -117, -117, -118, -118, -117,
-117, -117, -118, -117, -117, -118, -118, -118, -118, -117, -118, -118, -119,
-119, -117, -118, -118, -118, -118, -119, -118, -119, -118, -118, -119, -118,
-118, -118, -118, -118, -118, -118, -118, -119, -118, -117, -119, -118, -119,
-117, -118, -118, -118, -118, -118, -118, -118, -118, -118, -117, -117, -118,
-118, -118, -118, -117, -117, -118, -118, -118, -117, -117, -117, -117, -117,
-117, -117, -116, -116, -116, -116, -116, -116, -116, -116, -116, -115, -115,
-115, -115, -114, -115, -114, -113, -113, -112, -113, -112, -112, -110, -111,
-108, -110, -107, -109, -105, -108, -102, -108, -99, -107, -86, };