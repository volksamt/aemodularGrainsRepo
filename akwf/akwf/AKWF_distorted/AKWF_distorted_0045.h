#define DATA_LENGTH 512
#define DATA AKWF_distorted_0045

const PROGMEM int8_t DATA[DATA_LENGTH] = {96, 124, 116, 121, 116, 121, 117, 121,
117, 120, 118, 120, 119, 121, 118, 119, 119, 120, 119, 120, 119, 119, 119, 118,
119, 119, 119, 119, 119, 118, 119, 118, 120, 119, 119, 119, 120, 120, 120, 119,
120, 119, 119, 118, 118, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119,
118, 119, 120, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119,
119, 119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 118, 120, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 118, 119, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 118, 119, 118,
119, 118, 119, 120, 119, 120, 119, 118, 119, 119, 119, 119, 120, 120, 119, 120,
119, 119, 119, 118, 120, 119, 120, 119, 120, 119, 120, 120, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 118, 119, 120, 120, 119, 119, 120, 120, 119, 119, 120, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120, 120, 120, 120, 120,
118, 120, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 120, 118, 119, 118, 119, 118, 119, 119, 120, 119, 119, 119, 119, 120, 119,
119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 120, 119, 118, 119, 119,
119, 119, 119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 120, 119, 119, 119,
120, 119, 119, 119, 119, 119, 120, 118, 120, 119, 119, 118, 119, 119, 119, 120,
119, 119, 119, 119, 119, 120, 118, 120, 119, 119, 119, 119, 119, 119, 118, 120,
119, 119, 119, 119, 119, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 119,
118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 120, 118, 118, 119,
119, 120, 119, 119, 120, 118, 119, 120, 119, 119, 119, 119, 118, 119, 119, 119,
118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
120, 119, 118, 119, 120, 119, 118, 119, 120, 119, 119, 118, 119, 118, 120, 119,
120, 119, 119, 119, 118, 119, 120, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 119, 118, 119, 120, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 120, 120, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119,
119, 119, 118, 118, 119, 118, 120, 119, 120, 119, 119, 119, 120, 118, 120, 118,
119, 119, 119, 118, 120, 119, 119, 119, 118, 120, 119, 119, 118, 120, 116, 122,
116, 121, 115, 123, 114, 125, 112, 126, 108, 127, 82, -128, -115, -120, -119,
-118, -121, -118, -121, -117, -122, -116, -122, -116, -121, -117, -122, -117,
-122, -117, -122, -116, -122, -116, -123, -115, -123, -114, -126, -102, };