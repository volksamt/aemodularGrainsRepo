#define DATA_LENGTH 512
#define DATA AKWF_distorted_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {32, 50, 52, 57, 60, 63, 64, 68, 68,
71, 72, 73, 74, 76, 77, 78, 80, 81, 81, 82, 83, 84, 85, 86, 87, 86, 87, 89, 90,
90, 91, 91, 92, 92, 92, 93, 93, 94, 94, 94, 96, 95, 97, 96, 96, 98, 98, 99, 99,
99, 100, 100, 100, 101, 102, 101, 102, 102, 102, 102, 103, 103, 104, 104, 104,
104, 105, 105, 106, 106, 106, 106, 106, 107, 107, 107, 108, 108, 108, 108, 108,
108, 108, 109, 108, 109, 109, 110, 110, 110, 110, 111, 110, 110, 110, 111, 112,
111, 112, 111, 113, 113, 112, 113, 113, 112, 113, 113, 113, 113, 113, 113, 113,
114, 114, 115, 114, 114, 115, 115, 115, 115, 115, 115, 115, 116, 115, 115, 115,
116, 115, 116, 116, 115, 116, 116, 116, 117, 116, 117, 116, 117, 117, 116, 117,
117, 117, 117, 117, 117, 117, 118, 117, 118, 117, 117, 118, 118, 117, 118, 117,
117, 118, 119, 118, 118, 118, 118, 118, 119, 118, 118, 119, 118, 119, 119, 118,
119, 118, 119, 118, 118, 118, 119, 118, 119, 118, 120, 120, 119, 119, 119, 118,
118, 117, 117, 117, 116, 117, 117, 117, 117, 116, 115, 116, 115, 114, 114, 113,
114, 113, 113, 112, 112, 111, 110, 110, 109, 109, 108, 108, 108, 107, 107, 106,
106, 105, 105, 103, 104, 102, 102, 101, 100, 100, 99, 98, 99, 97, 96, 95, 95,
94, 93, 91, 90, 89, 87, 87, 85, 81, 80, 79, 76, 75, 71, 72, 66, 67, 60, 61, 49,
54, 11, -52, -48, -59, -60, -64, -65, -68, -70, -72, -74, -74, -76, -77, -79,
-80, -81, -82, -83, -84, -86, -85, -87, -88, -88, -88, -90, -90, -92, -93, -93,
-93, -94, -95, -95, -95, -96, -97, -98, -98, -97, -98, -99, -99, -99, -101,
-100, -102, -101, -101, -101, -103, -103, -103, -103, -103, -104, -104, -105,
-106, -106, -106, -106, -106, -107, -107, -107, -107, -107, -108, -108, -109,
-108, -108, -109, -109, -109, -109, -110, -110, -110, -110, -111, -110, -111,
-111, -111, -111, -112, -111, -112, -113, -112, -112, -112, -113, -112, -113,
-113, -113, -113, -113, -113, -114, -113, -114, -114, -113, -114, -114, -113,
-114, -114, -114, -114, -114, -114, -115, -114, -115, -114, -115, -115, -115,
-115, -115, -114, -115, -115, -115, -114, -115, -115, -115, -115, -116, -115,
-115, -115, -115, -115, -116, -115, -114, -115, -116, -115, -114, -115, -114,
-115, -115, -114, -115, -115, -115, -114, -114, -114, -114, -115, -114, -114,
-114, -113, -114, -113, -113, -114, -113, -114, -113, -113, -113, -112, -112,
-112, -111, -112, -111, -111, -111, -111, -111, -110, -110, -109, -109, -109,
-108, -108, -108, -108, -108, -106, -107, -106, -106, -106, -105, -105, -104,
-104, -103, -103, -102, -102, -102, -101, -101, -100, -100, -99, -99, -98, -98,
-97, -96, -96, -96, -95, -94, -94, -93, -93, -91, -91, -89, -89, -89, -88, -87,
-85, -84, -82, -80, -76, -76, -74, -73, -71, -69, -66, -64, -60, -59, -52, -49,
-32, };