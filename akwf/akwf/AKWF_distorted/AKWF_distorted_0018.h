#define DATA_LENGTH 512
#define DATA AKWF_distorted_0018

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 17, 26, 35, 44, 53, 60, 69, 76, 82,
90, 96, 97, 98, 98, 99, 100, 99, 100, 100, 100, 101, 101, 101, 101, 102, 101,
101, 102, 102, 102, 101, 102, 102, 102, 102, 101, 106, 114, 112, 111, 111, 112,
111, 112, 111, 110, 111, 111, 112, 110, 111, 111, 111, 111, 111, 110, 110, 111,
111, 110, 111, 110, 110, 110, 110, 110, 111, 110, 111, 110, 110, 111, 109, 110,
110, 109, 110, 109, 110, 109, 110, 110, 109, 109, 110, 110, 109, 110, 110, 110,
109, 109, 110, 110, 109, 110, 109, 110, 109, 109, 110, 109, 110, 109, 109, 110,
110, 110, 109, 109, 109, 110, 110, 109, 109, 109, 109, 109, 109, 109, 109, 109,
108, 109, 109, 108, 109, 109, 109, 109, 108, 109, 109, 110, 109, 110, 108, 110,
109, 110, 108, 110, 108, 109, 108, 110, 108, 109, 109, 109, 110, 108, 111, 106,
111, 106, 113, 104, 115, 101, 118, 96, 127, 43, -128, -103, -119, -110, -116,
-113, -114, -116, -115, -117, -115, -118, -116, -118, -115, -119, -115, -120,
-117, -119, -117, -120, -117, -118, -119, -119, -118, -119, -118, -119, -119,
-119, -119, -118, -119, -118, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -118, -118, -117, -119, -118, -117, -117, -117, -117, -117, -116, -116,
-115, -116, -115, -115, -114, -114, -114, -113, -112, -112, -112, -111, -111,
-110, -109, -109, -108, -107, -108, -107, -106, -106, -104, -103, -103, -102,
-102, -100, -100, -99, -98, -92, -81, -70, -59, -49, -39, -30, -21, -12, -3, 4,
12, 19, 26, 33, 39, 45, 50, 56, 62, 66, 70, 74, 79, 82, 86, 88, 90, 94, 95, 96,
97, 97, 97, 98, 97, 98, 97, 98, 95, 105, 115, 112, 113, 112, 112, 112, 112, 111,
111, 111, 111, 111, 112, 111, 112, 111, 112, 111, 111, 110, 110, 111, 111, 110,
110, 111, 110, 111, 110, 111, 110, 110, 110, 111, 111, 111, 110, 110, 110, 110,
110, 109, 110, 110, 110, 110, 111, 109, 110, 111, 110, 109, 111, 109, 110, 110,
110, 110, 110, 110, 109, 110, 110, 110, 110, 110, 109, 110, 109, 110, 110, 109,
109, 110, 110, 109, 110, 109, 109, 110, 110, 110, 109, 109, 110, 109, 110, 109,
109, 110, 109, 109, 110, 110, 109, 110, 110, 109, 109, 109, 109, 109, 109, 109,
110, 109, 111, 108, 110, 108, 111, 108, 111, 107, 110, 108, 110, 107, 110, 109,
109, 109, 108, 110, 106, 115, 100, 127, -51, -128, -100, -123, -107, -121, -110,
-119, -112, -118, -114, -118, -115, -118, -116, -117, -117, -117, -119, -116,
-119, -118, -120, -117, -120, -118, -119, -118, -119, -118, -120, -119, -120,
-118, -119, -119, -119, -118, -120, -119, -119, -118, -119, -118, -118, -118,
-118, -117, -118, -118, -116, -116, -116, -116, -116, -116, -116, -115, -114,
-114, -113, -112, -112, -112, -112, -110, -110, -110, -110, -108, -107, -107,
-106, -105, -104, -103, -102, -101, -100, -100, -98, -98, -88, -75, -61, -49,
-36, -25, -13, -3, };