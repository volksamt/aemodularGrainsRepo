#define DATA_LENGTH 512
#define DATA AKWF_distorted_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {25, 29, 27, 28, 28, 28, 28, 26, 36,
54, 49, 52, 48, 55, 69, 66, 68, 67, 68, 67, 68, 66, 68, 66, 71, 81, 81, 81, 81,
80, 82, 80, 81, 81, 81, 90, 92, 91, 92, 91, 91, 91, 91, 92, 91, 91, 91, 91, 90,
95, 101, 98, 100, 99, 99, 99, 99, 99, 99, 99, 99, 99, 99, 99, 100, 105, 105,
106, 105, 106, 105, 106, 106, 105, 105, 106, 105, 106, 105, 105, 106, 105, 106,
105, 106, 105, 105, 106, 106, 105, 107, 110, 110, 110, 110, 110, 110, 111, 110,
109, 110, 110, 111, 110, 110, 110, 111, 110, 110, 111, 110, 111, 110, 111, 110,
110, 110, 110, 111, 110, 109, 111, 110, 111, 110, 112, 114, 114, 114, 114, 114,
114, 114, 114, 113, 114, 114, 114, 114, 114, 114, 114, 114, 114, 114, 114, 114,
114, 114, 113, 114, 113, 113, 114, 114, 114, 114, 114, 114, 114, 113, 114, 114,
114, 113, 114, 114, 114, 114, 114, 115, 114, 114, 113, 114, 114, 114, 114, 114,
113, 114, 114, 115, 117, 117, 117, 117, 117, 117, 116, 117, 118, 117, 117, 117,
117, 117, 117, 116, 117, 116, 117, 116, 117, 117, 116, 116, 117, 116, 117, 117,
117, 116, 117, 117, 117, 116, 118, 117, 117, 116, 117, 117, 116, 117, 117, 118,
117, 117, 115, 118, 115, 118, 115, 118, 115, 119, 115, 118, 115, 119, 116, 119,
115, 118, 112, 83, 104, -10, -66, -90, -106, -96, -111, -104, -115, -110, -117,
-111, -118, -115, -118, -116, -116, -116, -120, -118, -120, -119, -119, -119,
-119, -119, -119, -120, -118, -120, -119, -120, -118, -119, -119, -119, -119,
-119, -119, -118, -119, -120, -119, -118, -120, -119, -119, -120, -119, -119,
-118, -119, -119, -119, -119, -119, -120, -119, -120, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -120, -119, -119, -118, -117, -116, -117,
-117, -117, -117, -117, -116, -117, -117, -117, -117, -117, -116, -117, -117,
-116, -116, -117, -116, -117, -118, -117, -116, -117, -117, -116, -117, -117,
-117, -117, -117, -117, -117, -117, -116, -117, -117, -118, -116, -117, -118,
-117, -117, -117, -116, -116, -117, -117, -117, -117, -117, -117, -117, -116,
-117, -116, -117, -117, -113, -114, -113, -114, -114, -115, -114, -114, -115,
-114, -114, -114, -114, -113, -114, -114, -114, -113, -114, -114, -114, -114,
-114, -114, -113, -114, -114, -114, -115, -114, -114, -114, -114, -114, -113,
-110, -111, -110, -110, -111, -110, -110, -110, -110, -110, -111, -110, -111,
-110, -110, -110, -111, -109, -110, -111, -110, -110, -105, -106, -105, -105,
-105, -106, -105, -104, -106, -105, -106, -105, -105, -106, -106, -105, -104,
-106, -103, -99, -98, -98, -99, -99, -100, -100, -98, -100, -99, -100, -96, -90,
-91, -91, -92, -91, -92, -92, -92, -91, -91, -90, -79, -81, -80, -81, -81, -81,
-81, -81, -81, -68, -66, -68, -68, -67, -68, -66, -69, -62, -49, -50, -51, -49,
-53, -42, -26, -29, -29, -26, -31, -17, 3, -2, 1, 0, };