#define DATA_LENGTH 512
#define DATA AKWF_distorted_0029

const PROGMEM int8_t DATA[DATA_LENGTH] = {91, 113, 104, 111, 105, 110, 105, 110,
106, 110, 106, 109, 107, 109, 106, 110, 115, 116, 116, 116, 115, 116, 116, 115,
116, 116, 117, 116, 116, 116, 116, 116, 116, 116, 117, 116, 118, 117, 116, 116,
116, 117, 117, 116, 116, 117, 115, 117, 118, 118, 118, 118, 118, 118, 118, 117,
118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 119, 118, 119, 118, 119, 119,
118, 118, 119, 118, 118, 118, 119, 118, 118, 118, 118, 119, 118, 118, 118, 118,
119, 119, 118, 118, 118, 119, 118, 118, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
119, 119, 120, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 119, 119, 119,
119, 119, 118, 119, 120, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119, 118,
119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 120, 119, 118, 119, 120, 119,
118, 118, 119, 120, 119, 119, 119, 118, 119, 118, 119, 119, 119, 119, 120, 119,
119, 119, 119, 119, 120, 118, 120, 119, 120, 119, 120, 119, 120, 119, 119, 119,
119, 119, 118, 119, 119, 119, 118, 119, 118, 120, 119, 120, 118, 119, 118, 120,
118, 119, 118, 119, 119, 119, 119, 119, 120, 118, 121, 117, 121, 117, 122, 115,
123, 114, 124, 112, 127, 108, 127, 64, -128, -112, -122, -118, -120, -119, -118,
-120, -118, -121, -117, -121, -117, -120, -117, -120, -117, -120, -118, -120,
-118, -119, -118, -119, -118, -119, -119, -118, -119, -119, -119, -118, -119,
-118, -119, -118, -119, -118, -119, -118, -119, -119, -118, -118, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -118, -118, -119, -118, -119, -119,
-118, -118, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -118, -119, -119, -120, -118, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -118, -118, -118, -118, -118, -119, -119, -118, -119, -118,
-119, -118, -119, -119, -119, -118, -119, -118, -118, -118, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -118, -119, -119, -119, -118, -118,
-118, -119, -118, -119, -119, -118, -119, -119, -118, -118, -119, -118, -119,
-119, -118, -119, -118, -118, -118, -119, -119, -118, -118, -118, -119, -119,
-119, -118, -119, -118, -118, -118, -119, -119, -119, -118, -119, -119, -118,
-118, -118, -119, -118, -119, -118, -118, -118, -119, -119, -118, -119, -118,
-118, -118, -118, -119, -119, -119, -119, -118, -118, -118, -119, -118, -119,
-118, -118, -118, -118, -119, -118, -118, -118, -118, -119, -117, -118, -118,
-119, -119, -118, -118, -118, -118, -118, -117, -117, -118, -117, -117, -118,
-118, -118, -117, -118, -117, -117, -118, -118, -117, -114, -113, -114, -113,
-114, -114, -114, -114, -114, -113, -114, -114, -114, -113, -114, -113, -110,
-110, -110, -110, -110, -111, -110, -110, -110, -110, -109, -111, -110, -111,
-109, -108, -91, -86, -88, -88, -88, -88, -87, -89, -87, -89, -87, -89, -87,
-88, -87, -14, };