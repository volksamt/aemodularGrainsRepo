#define DATA_LENGTH 512
#define DATA AKWF_distorted_0038

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 125, 115, 122, 116, 122, 117,
121, 117, 120, 118, 120, 117, 120, 118, 119, 118, 119, 119, 119, 119, 119, 120,
118, 119, 119, 120, 118, 119, 118, 118, 118, 119, 118, 118, 119, 119, 118, 119,
118, 118, 119, 119, 119, 117, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118,
118, 118, 118, 117, 118, 118, 117, 118, 118, 117, 117, 118, 117, 117, 117, 117,
117, 117, 117, 117, 117, 117, 116, 116, 116, 116, 117, 116, 116, 115, 116, 115,
115, 115, 115, 116, 115, 115, 114, 115, 114, 114, 115, 115, 114, 113, 114, 114,
113, 113, 113, 113, 113, 112, 112, 112, 112, 112, 112, 111, 110, 111, 111, 109,
109, 109, 109, 108, 108, 108, 108, 107, 107, 106, 106, 106, 104, 104, 104, 102,
103, 102, 101, 100, 100, 98, 98, 97, 96, 95, 95, 93, 91, 90, 89, 87, 85, 83, 81,
79, 76, 72, 69, 63, 58, 39, 5, -2, 0, -1, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, 0, 0,
0, 1, 0, 0, -1, 0, -1, -1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1,
0, 0, 0, 0, -1, -1, 0, 0, -1, -1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, -1,
-1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0,
1, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0,
-1, 0, 0, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0, 1, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, 1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1, -31, -56, -62, -67,
-71, -75, -78, -80, -83, -85, -86, -88, -90, -91, -92, -94, -95, -96, -96, -98,
-99, -99, -101, -101, -102, -102, -103, -104, -104, -105, -104, -106, -106,
-107, -107, -107, -108, -108, -109, -109, -109, -111, -110, -110, -110, -110,
-111, -111, -111, -111, -112, -112, -112, -112, -113, -113, -113, -113, -113,
-114, -114, -114, -114, -114, -115, -114, -115, -115, -115, -116, -115, -115,
-115, -116, -116, -117, -116, -116, -116, -115, -116, -116, -116, -116, -117,
-117, -116, -117, -116, -117, -117, -117, -117, -117, -117, -117, -118, -117,
-118, -118, -117, -117, -118, -117, -118, -118, -118, -118, -118, -117, -117,
-118, -118, -118, -118, -118, -118, -118, -119, -119, -119, -118, -119, -119,
-118, -119, -119, -119, -119, -118, -119, -118, -118, -118, -119, -118, -119,
-119, -118, -119, -119, -119, -118, -120, -118, -119, -118, -120, -118, -120,
-117, -120, -117, -120, -118, -120, -119, -119, -119, -117, -125, -18, 8, };