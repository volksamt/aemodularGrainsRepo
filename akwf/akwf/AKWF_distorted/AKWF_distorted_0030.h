#define DATA_LENGTH 512
#define DATA AKWF_distorted_0030

const PROGMEM int8_t DATA[DATA_LENGTH] = {57, 77, 71, 75, 72, 75, 73, 75, 73,
75, 73, 74, 73, 74, 73, 77, 88, 94, 94, 93, 93, 92, 93, 94, 93, 94, 93, 93, 94,
93, 93, 101, 107, 108, 107, 107, 107, 107, 107, 108, 107, 107, 108, 107, 107,
107, 107, 109, 112, 112, 112, 112, 112, 112, 112, 111, 112, 112, 112, 112, 112,
112, 111, 113, 115, 116, 116, 116, 115, 115, 115, 116, 116, 116, 116, 116, 115,
116, 115, 116, 116, 116, 116, 116, 116, 116, 117, 116, 116, 116, 116, 116, 117,
116, 116, 117, 118, 118, 117, 118, 118, 118, 117, 117, 117, 118, 117, 118, 118,
117, 118, 118, 117, 118, 118, 118, 118, 118, 118, 117, 119, 118, 118, 118, 118,
119, 119, 118, 118, 118, 118, 119, 119, 117, 119, 118, 118, 119, 118, 119, 119,
119, 119, 118, 119, 119, 119, 119, 119, 119, 118, 119, 119, 118, 119, 119, 118,
118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 118, 119, 119,
118, 119, 119, 118, 118, 119, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118,
119, 118, 118, 116, 116, 116, 115, 116, 115, 116, 116, 116, 116, 116, 116, 116,
115, 115, 116, 112, 111, 112, 112, 112, 112, 112, 113, 111, 112, 112, 112, 111,
113, 111, 112, 107, 102, 102, 102, 103, 103, 102, 102, 103, 101, 104, 100, 105,
99, 106, 97, 95, 32, 6, 34, 16, 27, 19, 25, 20, 25, 18, 25, 14, 32, 0, -85, -96,
-104, -99, -104, -100, -102, -100, -102, -102, -102, -101, -100, -102, -101,
-101, -108, -118, -117, -118, -116, -117, -116, -118, -117, -118, -117, -118,
-117, -116, -117, -117, -118, -118, -118, -119, -119, -118, -118, -118, -118,
-119, -118, -118, -119, -118, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -118, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -120, -119, -119, -119, -120,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -118, -119, -119, -118, -118, -119, -118, -119, -118, -119,
-118, -118, -119, -119, -119, -119, -119, -118, -118, -119, -118, -118, -118,
-119, -119, -118, -118, -118, -119, -118, -118, -118, -117, -117, -116, -117,
-116, -117, -116, -117, -116, -117, -117, -117, -116, -117, -117, -116, -117,
-116, -116, -115, -116, -116, -115, -115, -115, -116, -115, -116, -115, -116,
-116, -115, -114, -115, -114, -115, -114, -114, -114, -115, -114, -114, -114,
-114, -114, -115, -114, -114, -114, -113, -113, -113, -113, -113, -113, -113,
-113, -112, -113, -113, -114, -113, -113, -113, -112, -110, -108, -109, -109,
-109, -108, -109, -110, -108, -109, -108, -108, -109, -108, -109, -108, -103,
-99, -99, -100, -99, -100, -99, -100, -99, -99, -100, -100, -100, -100, -99,
-91, -72, -67, -70, -68, -70, -69, -69, -68, -69, -69, -70, -67, -69, -67, -72,
-45, };