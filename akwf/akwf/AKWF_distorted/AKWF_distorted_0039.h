#define DATA_LENGTH 512
#define DATA AKWF_distorted_0039

const PROGMEM int8_t DATA[DATA_LENGTH] = {102, 121, 112, 120, 115, 119, 115,
119, 116, 120, 116, 119, 116, 119, 117, 119, 117, 119, 119, 118, 118, 119, 118,
119, 118, 118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119,
119, 118, 119, 119, 118, 119, 119, 118, 119, 119, 120, 119, 119, 119, 120, 119,
119, 120, 120, 118, 119, 120, 119, 119, 119, 119, 120, 118, 120, 119, 120, 119,
119, 119, 119, 119, 120, 119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119,
120, 119, 118, 119, 119, 119, 119, 119, 118, 119, 119, 119, 118, 118, 118, 119,
118, 118, 118, 119, 118, 118, 118, 118, 119, 118, 117, 118, 118, 117, 117, 118,
118, 116, 117, 117, 116, 116, 116, 117, 116, 115, 116, 116, 115, 116, 115, 114,
114, 114, 114, 113, 113, 113, 113, 112, 111, 112, 110, 110, 110, 109, 108, 108,
107, 107, 106, 105, 105, 104, 103, 102, 101, 99, 99, 98, 97, 95, 93, 92, 91, 89,
88, 86, 84, 82, 80, 78, 75, 73, 71, 68, 65, 63, 59, 55, 48, 36, 28, 19, 13, 7,
3, 1, 0, 0, 3, 7, 11, 19, 27, 36, 47, 55, 58, 62, 64, 67, 71, 73, 74, 77, 80,
82, 83, 86, 87, 88, 91, 92, 94, 95, 97, 98, 99, 100, 100, 101, 102, 103, 105,
105, 106, 106, 108, 107, 109, 109, 110, 109, 112, 112, 112, 111, 112, 112, 113,
113, 113, 115, 114, 115, 114, 117, 114, 118, 112, 123, 7, -120, -113, -117,
-114, -116, -115, -115, -114, -114, -113, -113, -114, -113, -113, -112, -113,
-110, -111, -109, -110, -109, -108, -108, -107, -107, -106, -105, -105, -103,
-103, -101, -102, -100, -98, -97, -96, -95, -93, -91, -91, -90, -88, -85, -83,
-82, -80, -77, -75, -73, -70, -68, -65, -62, -59, -56, -48, -36, -28, -19, -12,
-7, -3, -1, -1, 0, -3, -7, -12, -19, -27, -36, -48, -55, -58, -62, -65, -67,
-70, -73, -75, -77, -79, -81, -83, -85, -87, -89, -90, -92, -94, -95, -97, -98,
-99, -100, -101, -102, -103, -104, -104, -105, -106, -107, -107, -108, -108,
-108, -110, -110, -111, -111, -112, -113, -113, -113, -113, -114, -114, -114,
-115, -115, -115, -115, -115, -116, -115, -115, -116, -116, -117, -116, -117,
-117, -117, -117, -118, -118, -117, -118, -118, -117, -118, -118, -118, -119,
-118, -118, -118, -118, -118, -118, -118, -118, -119, -119, -119, -119, -118,
-118, -118, -119, -119, -119, -118, -118, -119, -119, -118, -118, -119, -119,
-119, -118, -119, -118, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-118, -119, -120, -119, -119, -119, -119, -120, -119, -120, -119, -119, -120,
-119, -119, -120, -119, -119, -119, -119, -119, -120, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -118, -118, -119,
-119, -120, -119, -119, -119, -119, -118, -119, -118, -119, -118, -118, -118,
-117, -119, -118, -118, -117, -118, -116, -120, -116, -119, -116, -119, -115,
-120, -115, -119, -114, -119, -112, -5, };