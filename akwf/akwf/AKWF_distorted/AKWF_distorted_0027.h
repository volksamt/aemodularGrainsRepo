#define DATA_LENGTH 512
#define DATA AKWF_distorted_0027

const PROGMEM int8_t DATA[DATA_LENGTH] = {58, 87, 94, 105, 107, 111, 110, 112,
112, 113, 113, 115, 114, 114, 114, 114, 114, 114, 114, 113, 113, 113, 111, 110,
110, 109, 107, 107, 104, 101, 100, 98, 96, 91, 88, 85, 82, 78, 76, 76, 77, 75,
76, 82, 85, 90, 93, 96, 98, 98, 101, 105, 106, 108, 109, 111, 110, 109, 108,
108, 107, 106, 105, 106, 104, 102, 100, 98, 96, 95, 92, 94, 97, 96, 99, 98, 98,
94, 94, 86, 86, 78, 83, 43, -50, -81, -91, -97, -99, -104, -105, -107, -107,
-109, -108, -108, -107, -108, -109, -105, -103, -100, -98, -83, -85, -75, -83,
-6, 78, 72, 92, 92, 98, 95, 97, 100, 101, 102, 104, 107, 106, 108, 108, 108,
109, 110, 109, 110, 110, 111, 112, 114, 112, 113, 111, 110, 111, 113, 115, 117,
117, 118, 116, 117, 114, 115, 115, 116, 117, 118, 117, 116, 113, 109, 107, 108,
111, 112, 114, 114, 114, 111, 109, 104, 102, 103, 107, 108, 112, 107, 109, 68,
-66, -108, -105, -110, -106, -108, -108, -114, -114, -118, -117, -119, -117,
-118, -117, -116, -116, -117, -117, -118, -118, -117, -117, -117, -117, -116,
-116, -117, -117, -116, -117, -116, -116, -116, -116, -116, -115, -114, -114,
-114, -113, -113, -112, -112, -112, -111, -110, -108, -107, -108, -109, -111,
-111, -114, -114, -113, -113, -112, -112, -112, -113, -115, -115, -114, -113,
-110, -109, -108, -109, -109, -110, -110, -109, -106, -104, -98, -98, -94, -98,
-95, -96, -88, -87, -27, 83, 95, 101, 105, 105, 105, 104, 107, 109, 112, 112,
114, 113, 113, 110, 110, 110, 109, 108, 109, 108, 107, 107, 106, 106, 105, 104,
106, 107, 106, 108, 109, 110, 109, 109, 109, 110, 110, 110, 111, 110, 112, 109,
108, 105, 105, 104, 104, 103, 103, 101, 100, 100, 103, 105, 107, 108, 109, 111,
111, 114, 112, 114, 111, 113, 107, 110, 101, 107, 92, 103, 29, -85, -89, -104,
-103, -107, -107, -107, -107, -109, -109, -109, -111, -110, -110, -109, -109,
-106, -106, -104, -104, -105, -106, -107, -105, -105, -99, -97, -90, -93, -90,
-98, -89, -93, -43, 71, 93, 102, 102, 105, 104, 104, 108, 107, 111, 112, 115,
112, 114, 112, 109, 106, 105, 106, 110, 110, 111, 109, 107, 106, 97, 98, 104,
107, 110, 112, 111, 112, 109, 107, 107, 109, 112, 112, 112, 113, 113, 112, 114,
116, 117, 117, 119, 118, 119, 117, 119, 117, 120, 117, 120, 118, 120, 115, 117,
113, 114, 111, 114, 110, 102, 85, -71, -114, -107, -119, -112, -117, -111, -117,
-114, -120, -116, -120, -117, -119, -118, -119, -117, -119, -118, -120, -119,
-119, -119, -118, -119, -118, -119, -118, -119, -118, -118, -117, -118, -116,
-115, -113, -113, -112, -112, -112, -112, -109, -107, -106, -105, -108, -110,
-111, -112, -113, -114, -112, -112, -112, -112, -114, -114, -114, -115, -113,
-112, -113, -113, -113, -112, -112, -112, -111, -112, -111, -111, -111, -110,
-111, -109, -108, -105, -99, -91, -85, -78, -69, -27, };