#define DATA_LENGTH 512
#define DATA AKWF_distorted_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {27, 64, 80, 94, 102, 107, 109, 112,
114, 116, 115, 117, 117, 117, 118, 118, 118, 117, 118, 117, 119, 119, 119, 118,
119, 118, 118, 118, 119, 119, 119, 118, 118, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 119, 119, 120, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119,
118, 120, 119, 118, 119, 119, 118, 119, 119, 119, 119, 120, 119, 118, 119, 119,
119, 119, 119, 120, 119, 119, 119, 118, 118, 118, 120, 120, 119, 119, 119, 119,
120, 120, 118, 119, 119, 119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 118, 118, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119,
119, 118, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 119, 120, 119,
118, 119, 118, 119, 119, 120, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119,
120, 119, 119, 119, 119, 119, 120, 118, 119, 119, 119, 118, 119, 119, 118, 117,
118, 117, 118, 117, 116, 116, 115, 115, 113, 111, 108, 105, 99, 89, 71, 41, -12,
-59, -82, -99, -106, -111, -113, -117, -116, -118, -117, -118, -118, -119, -118,
-120, -118, -120, -118, -120, -119, -120, -119, -118, -97, 55, 118, 110, 121,
115, 120, 116, 120, 117, 119, 117, 119, 118, 119, 119, 119, 118, 118, 118, 118,
118, 117, 116, 115, 113, 110, 105, 96, 82, 57, 17, -33, -64, -83, -94, -101,
-107, -109, -112, -114, -115, -115, -116, -117, -117, -117, -118, -118, -119,
-118, -119, -119, -118, -118, -119, -118, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -118, -119, -119, -118, -119, -119, -119,
-119, -118, -119, -119, -120, -119, -118, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-120, -119, -118, -119, -118, -119, -119, -120, -119, -119, -119, -119, -118,
-119, -118, -120, -119, -120, -119, -118, -119, -119, -119, -119, -120, -120,
-120, -119, -119, -119, -118, -119, -119, -120, -119, -119, -119, -119, -119,
-120, -119, -118, -119, -120, -118, -119, -120, -119, -120, -119, -118, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -118, -119, -119, -120, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -118, -119, -118, -119, -119, -118, -119, -118,
-119, -119, -119, -119, -120, -119, -118, -119, -118, -118, -119, -119, -118,
-118, -118, -118, -118, -119, -119, -119, -118, -118, -118, -117, -118, -117,
-117, -117, -116, -115, -115, -114, -111, -108, -104, -98, -87, -69, -35, 19,
63, 85, 100, 106, 112, 113, 116, 116, 118, 117, 119, 118, 120, 117, 120, 118,
119, 118, 121, 118, 120, 117, 120, 85, -70, -118, -112, -121, -115, -120, -116,
-120, -117, -119, -117, -119, -118, -119, -118, -120, -118, -119, -118, -118,
-118, -117, -116, -115, -113, -109, -105, -94, -79, -53, -14, };