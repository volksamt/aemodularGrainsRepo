#define DATA_LENGTH 512
#define DATA AKWF_distorted_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {99, 118, 109, 116, 110, 114, 110, 114,
110, 115, 111, 113, 111, 114, 112, 113, 112, 113, 112, 112, 112, 113, 113, 113,
113, 113, 113, 112, 112, 112, 113, 112, 113, 112, 112, 113, 113, 112, 113, 113,
113, 113, 113, 112, 112, 112, 113, 113, 112, 112, 113, 113, 113, 112, 113, 113,
112, 112, 112, 113, 113, 112, 113, 112, 112, 112, 112, 113, 112, 112, 113, 112,
112, 113, 112, 112, 113, 113, 113, 112, 112, 113, 113, 112, 112, 112, 112, 112,
113, 112, 113, 112, 112, 112, 112, 113, 112, 112, 112, 113, 112, 112, 112, 112,
112, 112, 112, 112, 113, 113, 112, 112, 113, 113, 112, 113, 113, 112, 113, 113,
112, 112, 113, 113, 113, 112, 112, 112, 113, 112, 112, 113, 112, 112, 112, 113,
113, 112, 112, 113, 112, 112, 112, 112, 112, 112, 112, 113, 112, 112, 112, 112,
112, 112, 111, 113, 112, 112, 112, 112, 111, 112, 112, 112, 112, 113, 112, 112,
112, 112, 113, 112, 112, 113, 112, 112, 112, 112, 111, 112, 112, 112, 112, 112,
113, 111, 112, 113, 112, 112, 112, 112, 113, 113, 111, 112, 112, 112, 112, 112,
112, 111, 112, 112, 113, 112, 111, 112, 112, 112, 113, 112, 112, 112, 113, 112,
111, 112, 112, 112, 112, 112, 112, 111, 112, 112, 112, 111, 111, 112, 112, 112,
112, 112, 112, 112, 112, 112, 113, 112, 112, 112, 112, 112, 111, 112, 112, 111,
112, 112, 112, 113, 111, 112, 111, 112, 112, 112, 112, 111, 113, 111, 112, 111,
112, 111, 113, 111, 113, 110, 113, 111, 113, 110, 114, 111, 113, 111, 113, 112,
111, 113, 109, 115, 108, 119, 100, 127, -25, -128, -91, -115, -98, -111, -101,
-109, -103, -107, -105, -106, -105, -105, -104, -106, -105, -105, -105, -104,
-106, -105, -106, -105, -106, -104, -106, -104, -107, -105, -105, -105, -105,
-105, -105, -105, -106, -106, -105, -106, -106, -105, -105, -106, -105, -105,
-105, -106, -105, -105, -106, -105, -105, -105, -104, -106, -104, -105, -105,
-105, -105, -105, -106, -105, -105, -104, -106, -103, -110, -121, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -120, -119, -118, -120, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-118, -119, -119, -119, -119, -119, -118, -119, -119, -118, -118, -120, -118,
-118, -120, -119, -119, -118, -119, -119, -120, -118, -119, -118, -120, -118,
-120, -112, -103, -105, -105, -105, -104, -105, -103, -105, -104, -104, -104,
-104, -105, -105, -104, -105, -105, -104, -104, -105, -104, -104, -104, -104,
-104, -104, -104, -104, -105, -104, -104, -104, -105, -105, -104, -104, -104,
-103, -104, -104, -103, -103, -105, -104, -104, -104, -105, -104, -104, -104,
-105, -104, -104, -104, -104, -104, -104, -104, -104, -103, -104, -104, -104,
-104, -104, -104, -103, -103, -104, -104, -104, -104, -104, -105, -103, -105,
-102, -106, -101, -107, -101, -107, -99, -110, -89, };