#define DATA_LENGTH 512
#define DATA AKWF_distorted_0019

const PROGMEM int8_t DATA[DATA_LENGTH] = {58, 103, 103, 107, 106, 109, 109, 111,
111, 111, 111, 111, 110, 111, 110, 110, 110, 110, 110, 109, 110, 109, 109, 109,
110, 108, 108, 109, 108, 107, 108, 107, 108, 108, 108, 107, 107, 107, 107, 108,
107, 107, 107, 108, 107, 108, 108, 107, 107, 108, 108, 108, 108, 108, 108, 108,
108, 109, 109, 108, 109, 109, 109, 110, 109, 109, 110, 110, 110, 110, 110, 109,
110, 111, 110, 111, 111, 111, 111, 110, 110, 111, 111, 110, 111, 111, 111, 110,
110, 110, 110, 110, 109, 110, 110, 110, 111, 111, 109, 110, 110, 110, 110, 110,
110, 110, 110, 110, 111, 110, 111, 111, 111, 110, 110, 110, 111, 111, 111, 111,
111, 111, 110, 110, 110, 110, 109, 110, 110, 110, 109, 110, 109, 110, 109, 109,
109, 109, 109, 109, 109, 108, 108, 109, 108, 108, 108, 107, 108, 108, 107, 107,
108, 108, 107, 108, 108, 108, 107, 107, 108, 107, 107, 107, 108, 107, 107, 107,
108, 108, 108, 108, 107, 108, 108, 108, 108, 109, 108, 108, 109, 109, 109, 109,
109, 110, 109, 110, 110, 110, 110, 110, 110, 110, 110, 110, 111, 110, 110, 110,
109, 109, 109, 108, 109, 106, 107, 105, 103, 99, 97, 66, 13, -38, -92, -102,
-103, -106, -109, -111, -111, -113, -114, -115, -115, -117, -117, -117, -119,
-119, -119, -120, -119, -118, -119, -119, -119, -119, -119, -119, -118, -119,
-119, -118, -118, -118, -119, -119, -118, -118, -117, -118, -118, -118, -118,
-118, -117, -117, -117, -117, -117, -117, -116, -116, -116, -116, -115, -116,
-115, -115, -115, -114, -115, -114, -115, -113, -115, -113, -115, -112, -114,
-113, -114, -113, -113, -116, -119, -120, -116, -113, 28, 112, 106, 113, 107,
112, 108, 111, 107, 109, 106, 108, 106, 108, 107, 107, 107, 107, 107, 107, 108,
107, 109, 108, 109, 109, 110, 110, 110, 110, 110, 110, 110, 110, 110, 110, 110,
111, 110, 111, 110, 110, 110, 109, 109, 110, 110, 110, 111, 110, 110, 111, 110,
110, 110, 111, 110, 110, 111, 110, 110, 109, 110, 110, 110, 109, 109, 108, 109,
109, 108, 108, 108, 107, 108, 106, 107, 107, 108, 107, 107, 107, 107, 107, 107,
107, 108, 107, 108, 108, 108, 108, 108, 109, 108, 109, 109, 109, 109, 109, 109,
110, 110, 110, 110, 111, 110, 111, 111, 111, 111, 110, 109, 108, 108, 106, 106,
101, 102, 73, 1, -68, -101, -103, -107, -109, -111, -113, -115, -116, -117,
-117, -118, -118, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -118, -118, -118, -117, -117, -117, -117, -117, -117, -117,
-117, -116, -115, -116, -116, -116, -116, -115, -116, -115, -114, -114, -115,
-114, -113, -114, -114, -114, -113, -114, -113, -113, -113, -113, -114, -113,
-114, -114, -114, -115, -114, -115, -115, -115, -116, -116, -116, -116, -116,
-117, -118, -117, -117, -117, -118, -118, -118, -118, -119, -118, -119, -118,
-120, -118, -120, -117, -119, -116, -116, -112, -112, -106, -105, -92, -14, };