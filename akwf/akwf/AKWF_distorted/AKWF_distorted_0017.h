#define DATA_LENGTH 512
#define DATA AKWF_distorted_0017

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 7, 13, 18, 23, 28, 33, 37, 41, 45,
50, 52, 56, 59, 61, 64, 68, 70, 72, 74, 76, 79, 81, 82, 84, 86, 88, 89, 91, 92,
93, 94, 97, 97, 98, 99, 100, 101, 103, 104, 104, 105, 106, 107, 108, 109, 109,
110, 111, 110, 112, 112, 113, 114, 114, 114, 115, 115, 115, 115, 116, 117, 117,
118, 118, 118, 118, 118, 118, 119, 119, 118, 119, 119, 119, 120, 119, 118, 119,
117, 112, 112, 109, 107, 106, 104, 103, 101, 101, 99, 97, 96, 95, 94, 93, 92,
91, 88, 88, 87, 86, 83, 83, 82, 81, 79, 78, 77, 76, 75, 73, 72, 71, 70, 68, 68,
66, 65, 64, 63, 62, 60, 59, 57, 57, 55, 55, 53, 51, 50, 48, 47, 46, 45, 44, 43,
42, 40, 39, 37, 36, 34, 33, 33, 31, 30, 28, 26, 26, 25, 23, 21, 20, 18, 17, 16,
15, 14, 11, 11, 9, 8, 6, 6, 4, 2, 1, -1, -2, -3, -4, -6, -7, -9, -10, -12, -13,
-14, -16, -17, -18, -20, -21, -23, -24, -26, -27, -28, -29, -31, -32, -34, -34,
-37, -37, -39, -40, -42, -43, -44, -45, -46, -48, -49, -50, -51, -53, -55, -55,
-57, -57, -56, -55, -55, -55, -54, -54, -53, -54, -53, -52, -52, -51, -51, -51,
-50, -50, -50, -49, -49, -48, -47, -48, -47, -47, -47, -46, -46, -46, -45, -45,
-45, -45, -45, -43, -44, -43, -43, -42, -42, -42, -42, -42, -41, -41, -40, -40,
-40, -40, -40, -39, -39, -39, -38, -38, -38, -38, -38, -38, -37, -38, -36, -36,
-37, -36, -36, -37, -37, -36, -36, -36, -36, -35, -35, -35, -35, -35, -34, -35,
-34, -35, -34, -34, -35, -34, -34, -34, -34, -33, -33, -34, -33, -33, -33, -33,
-33, -33, -33, -34, -33, -33, -33, -33, -33, -32, -33, -32, -32, -33, -32, -32,
-32, -32, -32, -32, -33, -32, -32, -32, -32, -32, -33, -32, -32, -32, -32, -32,
-32, -32, -31, -32, -32, -32, -32, -33, -32, -32, -32, -32, -32, -33, -32, -32,
-32, -32, -32, -32, -33, -32, -33, -32, -33, -32, -33, -33, -32, -33, -33, -33,
-33, -33, -33, -33, -33, -34, -33, -32, -33, -32, -33, -33, -32, -33, -33, -33,
-33, -33, -33, -33, -34, -33, -33, -33, -33, -33, -33, -34, -34, -34, -34, -33,
-34, -34, -34, -35, -34, -34, -34, -34, -33, -35, -34, -34, -35, -34, -34, -35,
-35, -34, -35, -35, -35, -34, -35, -34, -35, -35, -35, -36, -34, -35, -35, -35,
-35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -35, -36, -35, -36, -35, -35,
-35, -35, -35, -35, -35, -35, -36, -35, -35, -36, -36, -36, -35, -35, -35, -35,
-36, -36, -35, -35, -36, -36, -36, -35, -35, -36, -36, -35, -35, -36, -36, -36,
-36, -36, -36, -36, -36, -35, -35, -36, -35, -36, -36, -36, -35, -31, -30, -32,
-34, -36, -38, -41, -44, -47, -51, -53, -48, -40, -31, -25, -17, -10, -3, };