#define DATA_LENGTH 512
#define DATA AKWF_distorted_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {16, 44, 62, 77, 86, 95, 101, 105, 108,
112, 113, 114, 115, 116, 118, 118, 118, 118, 119, 119, 119, 118, 119, 119, 118,
119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 119, 118, 119, 119, 120, 119,
119, 119, 119, 119, 120, 119, 120, 119, 118, 120, 119, 119, 119, 119, 119, 119,
119, 119, 119, 120, 119, 119, 119, 119, 118, 120, 119, 119, 118, 119, 119, 119,
119, 119, 120, 118, 119, 119, 118, 119, 119, 118, 118, 118, 118, 117, 116, 116,
115, 113, 111, 109, 107, 103, 99, 93, 85, 75, 61, 44, 22, -6, -34, -53, -67,
-80, -89, -95, -100, -102, -104, -106, -109, -111, -113, -114, -115, -115, -116,
-117, -116, -117, -118, -118, -118, -118, -118, -118, -119, -118, -118, -119,
-118, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -118, -115, -112, -110, -110, -109, -109, -108,
-107, -104, -101, -95, -87, -78, -69, -58, -48, -38, -30, -25, -21, -17, -15,
-12, -11, -10, -9, -8, -7, -6, -5, -4, -3, -2, -2, -1, -1, 0, -1, 0, 0, 0, 0,
-1, -1, 0, 0, 0, 0, 0, 1, 0, 0, 1, 10, 24, 40, 53, 64, 73, 82, 88, 94, 98, 102,
105, 108, 109, 112, 113, 115, 115, 116, 116, 116, 117, 118, 118, 118, 118, 118,
119, 119, 118, 119, 118, 119, 119, 119, 120, 119, 119, 118, 118, 119, 119, 119,
120, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 118, 119, 119, 118,
119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 118, 118, 119, 119, 120, 119,
119, 118, 119, 118, 118, 118, 118, 118, 118, 117, 117, 117, 117, 114, 114, 113,
111, 109, 106, 101, 98, 91, 83, 71, 57, 38, 14, -14, -39, -57, -72, -83, -91,
-97, -102, -107, -109, -112, -113, -114, -115, -117, -117, -117, -118, -118,
-118, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -120, -120, -119, -119, -120, -119, -119, -119,
-118, -118, -119, -119, -119, -119, -119, -119, -119, -120, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -120, -119, -120, -118, -120, -119, -119, -119, -119, -119, -118, -119,
-118, -117, -117, -117, -115, -115, -113, -112, -109, -108, -103, -99, -94, -86,
-76, -63, -46, -24, 4, 31, 52, 66, 78, 74, 32, -31, -69, -86, -96, -103, -108,
-111, -113, -114, -117, -118, -117, -118, -118, -118, -119, -119, -119, -118,
-118, -119, -119, -119, -119, -119, -118, -119, -119, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -120, -119, -119, -119, -120, -119, -119, -118,
-120, -119, -119, -119, -119, -120, -119, -119, -119, -119, -120, -119, -120,
-119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -118, -117, -118, -118, -117, -115, -116,
-114, -113, -110, -108, -103, -99, -92, -84, -71, -56, -34, -8, };