#define DATA_LENGTH 512
#define DATA AKWF_distorted_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {21, 34, 40, 46, 51, 56, 59, 63, 66,
70, 73, 76, 79, 83, 86, 87, 90, 94, 97, 100, 102, 105, 109, 111, 116, 119, 119,
118, 118, 119, 120, 118, 119, 119, 119, 119, 119, 118, 120, 119, 120, 119, 119,
118, 118, 119, 119, 119, 120, 119, 119, 119, 119, 120, 119, 119, 119, 119, 120,
119, 119, 119, 119, 118, 119, 120, 119, 120, 119, 119, 119, 119, 119, 120, 118,
119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 118, 118, 120, 119, 120, 119,
119, 119, 119, 118, 119, 119, 119, 119, 119, 118, 120, 119, 119, 119, 119, 119,
118, 118, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 118, 119, 119, 119, 119, 119,
119, 119, 119, 119, 120, 119, 119, 119, 118, 119, 119, 119, 118, 119, 119, 118,
119, 119, 119, 119, 118, 119, 115, 112, 108, 105, 102, 99, 97, 93, 91, 88, 84,
82, 79, 76, 73, 70, 67, 63, 59, 56, 51, 46, 40, 34, 14, -25, -38, -44, -53, -58,
-66, -71, -78, -84, -91, -99, -108, -117, -120, -118, -120, -118, -121, -118,
-121, -117, -120, -118, -121, -116, -125, -92, 75, 126, 115, 121, 118, 120, 118,
121, 119, 120, 118, 121, 117, 119, 115, 107, 96, 91, 83, 78, 69, 64, 57, 52, 43,
37, 23, -23, -35, -41, -47, -52, -57, -59, -64, -66, -71, -73, -76, -79, -82,
-84, -89, -91, -95, -96, -99, -103, -106, -109, -112, -116, -120, -118, -119,
-120, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -120, -120, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -120, -119, -118, -118, -119,
-119, -118, -119, -119, -120, -119, -120, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -118, -120, -119, -120, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -120, -119, -118,
-119, -119, -119, -118, -119, -119, -118, -119, -118, -119, -118, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -120, -120, -118, -120, -120,
-119, -120, -120, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -118, -120, -120, -119, -118, -118, -119, -119, -119, -118,
-119, -119, -119, -119, -120, -119, -115, -112, -108, -106, -103, -99, -97, -93,
-91, -88, -85, -82, -79, -77, -73, -70, -66, -63, -59, -55, -50, -47, -39, -34,
-11, 27, 38, 45, 53, 58, 66, 72, 79, 85, 92, 99, 109, 118, 120, 118, 120, 118,
120, 117, 120, 117, 121, 116, 123, 113, 127, 74, -92, -123, -117, -119, -118,
-120, -118, -120, -117, -120, -118, -120, -118, -120, -114, -106, -97, -91, -82,
-76, -69, -64, -57, -51, -43, -37, -21, };