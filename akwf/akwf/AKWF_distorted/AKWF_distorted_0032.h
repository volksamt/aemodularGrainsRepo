#define DATA_LENGTH 512
#define DATA AKWF_distorted_0032

const PROGMEM int8_t DATA[DATA_LENGTH] = {54, 80, 84, 93, 96, 102, 102, 106,
107, 109, 109, 111, 111, 113, 113, 114, 114, 114, 114, 115, 116, 115, 116, 116,
117, 117, 117, 117, 118, 116, 118, 117, 117, 118, 118, 117, 118, 118, 118, 118,
119, 119, 118, 119, 118, 118, 118, 118, 118, 118, 118, 119, 118, 119, 119, 119,
118, 118, 118, 118, 118, 118, 118, 118, 119, 118, 118, 119, 119, 119, 119, 117,
118, 118, 119, 118, 118, 117, 118, 118, 119, 118, 118, 118, 118, 118, 118, 117,
118, 117, 117, 117, 117, 116, 117, 116, 116, 116, 116, 115, 116, 115, 115, 115,
115, 115, 114, 114, 114, 114, 114, 113, 113, 113, 112, 111, 111, 111, 110, 110,
110, 110, 109, 109, 108, 108, 108, 107, 107, 106, 105, 106, 105, 105, 104, 104,
103, 103, 103, 103, 102, 103, 102, 102, 102, 101, 101, 100, 100, 100, 101, 99,
100, 100, 99, 99, 100, 99, 99, 99, 98, 97, 98, 97, 98, 98, 97, 96, 96, 95, 96,
96, 96, 96, 96, 96, 96, 96, 95, 96, 96, 96, 97, 97, 97, 97, 97, 97, 97, 97, 98,
98, 97, 97, 97, 97, 97, 96, 97, 96, 96, 96, 96, 96, 94, 95, 95, 94, 94, 93, 93,
93, 92, 91, 92, 91, 90, 90, 89, 90, 89, 88, 88, 88, 87, 87, 86, 85, 84, 85, 84,
84, 84, 83, 83, 82, 82, 82, 81, 81, 80, 80, 78, 78, 78, 77, 76, 75, 74, 73, 71,
70, 69, 66, 65, 63, 62, 60, 59, 58, 57, 57, 57, 57, 58, 58, 59, 61, 62, 64, 66,
68, 69, 72, 73, 74, 76, 78, 78, 80, 81, 82, 84, 85, 87, 87, 89, 89, 90, 90, 91,
93, 94, 94, 95, 96, 96, 97, 98, 98, 99, 100, 100, 100, 101, 101, 102, 102, 103,
103, 104, 104, 104, 105, 105, 106, 105, 105, 107, 108, 108, 107, 108, 108, 108,
109, 109, 110, 110, 110, 110, 111, 110, 110, 110, 110, 111, 110, 109, 110, 110,
110, 110, 110, 109, 110, 110, 108, 109, 108, 108, 106, 106, 105, 105, 105, 103,
103, 101, 100, 99, 97, 95, 92, 89, 86, 83, 79, 71, 63, 33, -28, -61, -71, -77,
-82, -87, -90, -93, -95, -98, -100, -101, -103, -104, -105, -107, -108, -109,
-110, -110, -111, -112, -113, -114, -114, -114, -114, -115, -116, -116, -116,
-116, -117, -116, -116, -117, -117, -117, -117, -118, -118, -118, -118, -118,
-118, -119, -119, -119, -118, -118, -118, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -120, -119, -119,
-119, -119, -119, -118, -119, -119, -120, -119, -119, -119, -118, -120, -119,
-119, -119, -120, -119, -119, -119, -120, -119, -118, -119, -119, -119, -118,
-119, -119, -118, -120, -119, -118, -119, -118, -118, -118, -118, -118, -119,
-118, -117, -118, -117, -117, -117, -117, -118, -117, -117, -116, -116, -115,
-116, -115, -114, -114, -114, -112, -111, -109, -109, -107, -107, -104, -102,
-99, -94, -90, -82, -69, -22, };