#define DATA_LENGTH 512
#define DATA AKWF_distorted_0035

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 115, 122, 117, 121, 116,
121, 117, 120, 117, 119, 117, 119, 117, 118, 117, 118, 117, 117, 116, 116, 115,
116, 115, 113, 114, 113, 113, 111, 111, 109, 109, 105, 106, 100, 101, 95, 94,
84, 80, 55, -2, 1, -1, -1, 0, -1, 0, 0, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 1, 0, 1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0,
0, 0, 0, 0, -1, 0, 0, 0, -1, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, -1, 0,
-1, 0, -1, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0,
0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 0, -1, -1, 0, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, 1,
0, -1, 0, -1, 0, 0, 1, 0, 1, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0,
0, 1, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, -1, 0, 1, 0, 1, 0, 0, 0, 0, 0, -1, 0, 1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, -1, 1, 0, 0, 0, 0, 0, -1, 0,
0, -1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, -1, 0, 0,
-1, 0, 0, 1, 1, 0, 1, 0, 0, -1, 1, 1, 0, 0, 0, 0, -1, 1, 0, 0, 0, 0, 0, 0, 0, 0,
0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0,
0, 0, 0, -1, 0, 0, 0, 0, 0, 1, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1,
0, 0, 0, -1, -1, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, -1, 0, 0, -1, 0, 0, 0, 0, -1,
0, -1, 0, 0, 0, -1, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 1, -1, 1, -2,
2, -2, 4, -13, -60, -67, -75, -80, -85, -88, -91, -93, -96, -97, -99, -101,
-102, -103, -104, -106, -105, -107, -107, -109, -110, -109, -110, -110, -111,
-112, -111, -113, -113, -113, -114, -114, -114, -114, -114, -115, -115, -115,
-116, -116, -116, -117, -117, -117, -116, -116, -116, -117, -117, -117, -117,
-118, -118, -117, -118, -117, -118, -117, -119, -118, -118, -118, -119, -118,
-120, -117, -119, -118, -119, -118, -120, -117, -120, -118, -120, -118, -120,
-118, -120, -118, -120, -120, -117, -124, -18, 8, };