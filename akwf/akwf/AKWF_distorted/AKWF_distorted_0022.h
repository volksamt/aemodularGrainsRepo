#define DATA_LENGTH 512
#define DATA AKWF_distorted_0022

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 18, 33, 45, 56, 65, 73, 80, 86, 90,
95, 98, 102, 104, 106, 108, 110, 111, 113, 113, 114, 114, 116, 115, 116, 118,
117, 118, 118, 119, 118, 118, 118, 118, 119, 119, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 119, 119, 118, 119, 118, 119, 118, 118, 118, 118, 119, 118,
118, 118, 117, 117, 118, 117, 117, 116, 116, 116, 116, 115, 114, 114, 113, 112,
112, 112, 110, 110, 108, 108, 107, 106, 104, 104, 101, 101, 99, 97, 95, 93, 91,
89, 87, 83, 81, 78, 76, 72, 70, 66, 62, 58, 54, 51, 46, 41, 37, 31, 27, 22, 16,
10, 5, -2, -7, -13, -17, -22, -27, -31, -34, -37, -42, -44, -47, -49, -52, -55,
-57, -58, -60, -62, -64, -64, -65, -67, -67, -68, -69, -70, -69, -70, -70, -70,
-70, -70, -69, -69, -67, -66, -65, -65, -62, -63, -60, -58, -56, -54, -50, -48,
-44, -40, -36, -31, -27, -21, -15, -8, 0, 8, 15, 22, 29, 35, 41, 47, 51, 57, 61,
66, 69, 73, 75, 77, 80, 82, 84, 87, 88, 90, 92, 93, 94, 95, 96, 96, 98, 99, 99,
99, 100, 101, 102, 101, 102, 102, 102, 103, 103, 104, 104, 104, 105, 105, 106,
105, 106, 106, 106, 106, 106, 106, 107, 107, 107, 107, 107, 108, 108, 108, 108,
108, 109, 109, 109, 109, 109, 109, 109, 109, 110, 109, 110, 110, 110, 110, 110,
110, 110, 110, 110, 110, 110, 109, 110, 109, 109, 108, 109, 110, 109, 108, 109,
108, 107, 107, 108, 107, 107, 106, 105, 105, 104, 104, 104, 103, 101, 101, 101,
99, 98, 96, 96, 94, 93, 92, 89, 87, 86, 83, 82, 79, 76, 72, 69, 66, 62, 57, 52,
48, 41, 35, 28, 20, 11, 1, -9, -18, -27, -35, -42, -50, -56, -63, -68, -73, -77,
-81, -85, -88, -91, -95, -96, -99, -101, -103, -104, -106, -107, -107, -109,
-109, -110, -112, -111, -112, -112, -113, -113, -113, -113, -113, -113, -113,
-112, -113, -113, -113, -113, -112, -113, -112, -111, -112, -112, -111, -110,
-111, -111, -110, -110, -110, -110, -109, -109, -110, -109, -109, -108, -108,
-108, -108, -108, -107, -107, -108, -107, -107, -108, -107, -106, -107, -107,
-107, -107, -107, -107, -107, -107, -107, -107, -107, -108, -107, -108, -107,
-107, -109, -108, -108, -109, -109, -110, -109, -110, -109, -110, -110, -110,
-110, -111, -111, -111, -112, -111, -111, -112, -112, -113, -112, -112, -113,
-113, -113, -113, -114, -113, -114, -114, -114, -114, -115, -115, -115, -114,
-115, -115, -114, -114, -115, -114, -115, -115, -115, -114, -115, -115, -114,
-114, -114, -115, -114, -114, -115, -114, -114, -114, -113, -114, -115, -114,
-115, -114, -113, -113, -113, -114, -114, -113, -112, -113, -112, -113, -112,
-112, -112, -113, -113, -112, -112, -111, -111, -111, -110, -110, -110, -110,
-109, -109, -109, -107, -106, -106, -105, -103, -102, -102, -99, -98, -94, -92,
-89, -86, -83, -77, -71, -64, -57, -49, -38, -26, -10, };