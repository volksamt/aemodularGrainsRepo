#define DATA_LENGTH 512
#define DATA AKWF_distorted_0037

const PROGMEM int8_t DATA[DATA_LENGTH] = {105, 124, 115, 122, 117, 122, 117,
121, 117, 120, 117, 119, 117, 119, 117, 119, 118, 118, 117, 118, 117, 117, 116,
116, 116, 115, 116, 116, 115, 115, 115, 113, 114, 111, 113, 110, 111, 109, 109,
108, 106, 105, 102, 101, 97, 95, 90, 88, 75, 74, 23, -7, 3, -3, 1, -1, 2, 0, 0,
0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, -1, 0,
0, -1, 0, -1, 0, -1, -1, 0, 0, 0, 0, 0, 0, 0, 1, 0, -1, 0, 0, 0, 0, 0, -1, 1, 0,
0, 0, -1, 0, -1, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 0, 1,
-1, 0, 0, 0, 0, 0, -1, 1, -1, 0, 0, 0, 1, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, -1, -1,
-1, 0, 0, 0, 1, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, -1, 1, -1, 0, 0, 0, -1, 0, 0, 1,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 0, 0, -1, -1, 0, 0, 0, 1,
1, 0, 0, 0, 1, -1, 0, 0, 0, 0, 1, 0, 0, 1, 0, 0, 0, 0, 1, 0, 0, 0, -1, 0, 0, 0,
0, 0, 1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0,
0, 0, -1, 0, 0, -1, 0, 0, 0, -1, 0, 0, 0, 0, 0, 1, -1, 0, 0, 0, 0, 1, 0, 0, 0,
-1, 1, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0, 0, 0, -1,
0, 0, 0, 1, 0, 0, -1, 0, 1, 0, 0, 0, 1, -1, 0, 0, 0, 1, -1, 0, -1, 0, 0, 0, 0,
0, 0, 0, 0, 0, 1, 0, -1, 1, 0, 0, 0, 0, 0, -1, 0, 0, 0, 1, 0, 0, 0, -1, 0, 1, 0,
0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, -1, 0, 0, 0, -1, -1, 0, 0, 0, 0, 0, -1,
1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1,
-1, 0, 0, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, -1, 0, -1, 0, -1, 0, -1, 1, -1,
1, 1, 0, 0, 0, 0, 0, 0, 0, 1, -3, 5, -41, -74, -75, -86, -88, -94, -95, -100,
-100, -104, -104, -106, -106, -108, -108, -110, -110, -111, -112, -113, -114,
-113, -114, -114, -115, -115, -116, -115, -117, -116, -117, -117, -117, -117,
-117, -118, -117, -118, -117, -119, -118, -119, -117, -119, -118, -119, -118,
-120, -118, -119, -118, -120, -118, -120, -118, -119, -119, -117, -125, -19, 7,
};