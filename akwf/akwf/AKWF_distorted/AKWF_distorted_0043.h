#define DATA_LENGTH 512
#define DATA AKWF_distorted_0043

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 116, 122, 116, 121, 118,
120, 117, 121, 117, 120, 117, 120, 117, 119, 118, 119, 118, 119, 118, 118, 119,
119, 119, 117, 119, 119, 118, 118, 119, 118, 118, 117, 118, 118, 118, 117, 118,
118, 117, 118, 117, 117, 117, 117, 116, 116, 116, 116, 116, 115, 115, 116, 116,
115, 116, 116, 115, 115, 115, 115, 114, 114, 114, 114, 114, 115, 114, 113, 114,
114, 113, 112, 112, 112, 112, 111, 111, 110, 110, 110, 108, 108, 108, 107, 107,
105, 105, 104, 103, 102, 102, 102, 101, 101, 100, 99, 99, 98, 97, 96, 96, 95,
94, 93, 91, 91, 88, 87, 86, 85, 82, 82, 78, 77, 72, 71, 65, 63, 55, 43, 11, -10,
-44, -51, -67, -49, 104, 118, 110, 116, 110, 116, 111, 115, 110, 114, 111, 114,
111, 112, 110, 111, 110, 111, 110, 111, 110, 110, 109, 108, 109, 108, 108, 107,
108, 107, 107, 106, 106, 105, 105, 105, 104, 103, 103, 102, 101, 100, 99, 96,
96, 94, 92, 90, 87, 85, 81, 78, 71, 66, 53, 16, -20, -49, -60, -64, -70, -73,
-77, -78, -82, -83, -86, -88, -89, -90, -92, -93, -94, -96, -98, -99, -100,
-101, -102, -103, -104, -105, -105, -107, -107, -108, -109, -109, -109, -110,
-110, -111, -111, -112, -111, -112, -112, -113, -112, -114, -113, -114, -115,
-115, -115, -115, -115, -114, -116, -114, -117, -115, -117, -114, -117, -114,
-119, -114, -119, -112, -120, -113, -121, -113, -122, -111, -125, -99, 112, 121,
114, 120, 113, 121, 113, 120, 113, 119, 114, 119, 114, 117, 114, 117, 114, 116,
114, 116, 114, 115, 114, 115, 115, 114, 114, 113, 114, 113, 113, 111, 113, 111,
112, 111, 110, 110, 110, 109, 108, 108, 108, 106, 106, 105, 104, 104, 102, 102,
101, 100, 98, 96, 95, 93, 93, 90, 88, 87, 86, 84, 81, 79, 77, 73, 71, 66, 60,
53, 23, -6, -40, -63, -67, -75, -78, -84, -85, -89, -91, -93, -94, -96, -98,
-99, -101, -101, -103, -104, -103, -104, -105, -105, -106, -106, -106, -107,
-107, -107, -108, -107, -110, -108, -110, -109, -110, -109, -111, -110, -112,
-110, -112, -111, -112, -112, -112, -113, -111, -113, -112, -115, -110, -117,
-109, -120, -105, -126, -37, 64, 39, 29, -4, -25, -51, -56, -67, -67, -73, -74,
-78, -79, -82, -84, -85, -88, -87, -90, -90, -93, -92, -95, -94, -97, -96, -98,
-98, -99, -99, -100, -101, -102, -102, -103, -104, -103, -105, -105, -106, -107,
-107, -107, -108, -109, -110, -110, -111, -110, -111, -112, -112, -113, -112,
-113, -114, -114, -114, -114, -113, -114, -114, -114, -115, -115, -114, -115,
-115, -116, -116, -115, -115, -116, -115, -116, -117, -116, -116, -117, -117,
-117, -117, -117, -117, -117, -117, -117, -118, -117, -118, -118, -118, -118,
-118, -118, -118, -118, -117, -118, -118, -119, -118, -118, -119, -119, -118,
-119, -119, -119, -118, -118, -119, -118, -119, -117, -120, -118, -120, -117,
-121, -116, -121, -116, -123, -114, -125, -95, };