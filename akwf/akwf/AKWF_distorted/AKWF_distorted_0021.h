#define DATA_LENGTH 512
#define DATA AKWF_distorted_0021

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 22, 36, 48, 58, 66, 73, 80, 84, 90,
93, 96, 100, 101, 104, 106, 108, 109, 111, 112, 113, 113, 114, 114, 116, 116,
116, 116, 117, 117, 117, 118, 118, 119, 118, 119, 119, 119, 119, 119, 119, 118,
120, 119, 119, 119, 119, 119, 118, 118, 118, 119, 117, 118, 118, 116, 118, 117,
117, 116, 116, 116, 114, 115, 114, 113, 113, 112, 111, 110, 109, 108, 107, 107,
105, 104, 102, 102, 100, 99, 96, 95, 92, 91, 88, 86, 83, 81, 79, 74, 72, 69, 65,
61, 59, 54, 51, 47, 43, 40, 36, 33, 29, 25, 23, 20, 16, 15, 13, 10, 9, 7, 6, 5,
5, 5, 5, 6, 6, 7, 8, 10, 12, 12, 15, 16, 18, 21, 23, 25, 26, 28, 31, 34, 35, 37,
39, 41, 43, 46, 48, 50, 51, 53, 54, 56, 57, 58, 59, 60, 61, 62, 62, 63, 63, 64,
64, 64, 65, 64, 64, 63, 63, 63, 63, 62, 61, 60, 60, 59, 58, 56, 56, 54, 53, 52,
50, 48, 46, 45, 42, 40, 37, 35, 32, 28, 24, 20, 16, 10, 6, -1, -7, -14, -20,
-26, -31, -37, -42, -47, -51, -56, -61, -65, -68, -71, -74, -77, -80, -83, -85,
-87, -89, -90, -92, -93, -95, -96, -97, -98, -99, -99, -100, -100, -101, -101,
-102, -104, -104, -104, -105, -105, -106, -106, -106, -107, -108, -108, -108,
-109, -108, -109, -109, -110, -110, -111, -110, -111, -110, -111, -110, -110,
-111, -111, -110, -110, -110, -110, -110, -110, -109, -109, -109, -108, -107,
-107, -106, -106, -106, -105, -104, -104, -102, -102, -102, -101, -100, -99,
-98, -98, -97, -97, -97, -95, -95, -94, -94, -93, -92, -92, -91, -91, -90, -88,
-88, -86, -85, -85, -82, -82, -80, -79, -77, -76, -74, -71, -69, -68, -65, -62,
-60, -58, -55, -53, -50, -47, -44, -42, -38, -37, -34, -31, -28, -25, -22, -21,
-18, -15, -13, -10, -7, -4, -2, 2, 5, 8, 12, 15, 17, 21, 24, 28, 31, 34, 39, 42,
44, 49, 52, 55, 58, 61, 64, 66, 69, 72, 74, 77, 80, 81, 83, 85, 87, 88, 90, 91,
92, 93, 95, 96, 98, 98, 99, 101, 102, 102, 103, 103, 104, 105, 105, 106, 107,
106, 107, 107, 108, 107, 108, 109, 108, 108, 109, 109, 109, 109, 109, 109, 109,
108, 108, 108, 107, 108, 107, 106, 106, 105, 103, 103, 101, 100, 99, 98, 96, 94,
93, 89, 88, 84, 79, 76, 71, 65, 58, 51, 43, 33, 22, 8, -6, -20, -33, -43, -52,
-62, -70, -76, -81, -86, -91, -95, -98, -101, -104, -105, -107, -108, -111,
-112, -113, -113, -115, -114, -115, -116, -117, -117, -117, -117, -117, -117,
-118, -118, -118, -119, -119, -118, -118, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -118, -118, -118, -118, -117,
-117, -117, -116, -116, -114, -114, -113, -112, -110, -109, -107, -105, -101,
-98, -95, -90, -84, -78, -71, -61, -51, -39, -24, -8, };