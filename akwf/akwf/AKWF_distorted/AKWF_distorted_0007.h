#define DATA_LENGTH 512
#define DATA AKWF_distorted_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {39, 93, 98, 102, 104, 106, 107, 108,
110, 111, 111, 112, 113, 114, 115, 115, 116, 116, 116, 117, 117, 118, 118, 118,
119, 118, 119, 119, 119, 119, 118, 118, 119, 119, 119, 119, 119, 120, 120, 119,
119, 119, 120, 119, 119, 120, 120, 119, 119, 120, 119, 120, 119, 119, 119, 119,
119, 119, 118, 119, 119, 119, 120, 119, 120, 119, 118, 119, 119, 119, 118, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 118, 118,
119, 118, 119, 119, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 118, 119, 119, 119, 119, 119, 119, 119, 118, 118, 119, 119, 119, 119, 118,
118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119,
119, 119, 120, 119, 119, 120, 119, 119, 119, 119, 120, 119, 119, 119, 118, 120,
119, 120, 119, 119, 119, 118, 119, 119, 118, 119, 119, 119, 119, 119, 120, 119,
118, 119, 119, 119, 118, 118, 119, 119, 119, 119, 118, 119, 118, 118, 117, 117,
115, 116, 115, 114, 114, 113, 111, 111, 110, 109, 109, 107, 105, 103, 101, 100,
89, 29, -62, -98, -101, -104, -106, -110, -111, -113, -113, -115, -116, -119,
-119, -119, -119, -120, -118, -120, -118, -120, -118, -120, -118, -121, -117,
-125, -92, 74, 126, 115, 121, 117, 122, 118, 119, 118, 120, 117, 120, 119, 120,
117, 118, 116, 116, 114, 113, 110, 110, 106, 105, 100, 99, 54, -49, -94, -99,
-102, -104, -106, -107, -109, -110, -110, -111, -112, -113, -114, -114, -115,
-116, -116, -117, -117, -118, -118, -119, -118, -119, -120, -120, -119, -120,
-119, -120, -119, -119, -119, -119, -119, -118, -119, -119, -120, -119, -120,
-119, -119, -118, -119, -118, -119, -119, -119, -118, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -118, -119, -119, -118, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -118, -119, -118, -119,
-120, -119, -119, -119, -120, -118, -119, -120, -119, -119, -119, -119, -119,
-119, -120, -119, -120, -119, -119, -119, -119, -120, -119, -120, -119, -119,
-119, -119, -119, -118, -119, -118, -119, -119, -120, -118, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -118, -119, -120, -119, -119, -118, -118, -118, -118, -117, -116, -116,
-115, -115, -114, -113, -112, -112, -110, -111, -109, -108, -107, -106, -104,
-101, -99, -86, -19, 69, 98, 102, 105, 107, 109, 111, 112, 115, 116, 117, 118,
119, 120, 119, 120, 119, 120, 118, 121, 117, 121, 117, 122, 114, 127, 70, -94,
-122, -118, -119, -119, -119, -117, -119, -118, -119, -118, -120, -119, -120,
-118, -118, -115, -116, -113, -113, -110, -109, -106, -104, -99, -97, -45, };