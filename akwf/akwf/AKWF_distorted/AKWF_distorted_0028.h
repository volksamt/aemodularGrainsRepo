#define DATA_LENGTH 512
#define DATA AKWF_distorted_0028

const PROGMEM int8_t DATA[DATA_LENGTH] = {26, 57, 68, 78, 83, 85, 85, 87, 86,
88, 86, 86, 84, 84, 84, 86, 88, 92, 95, 98, 100, 100, 99, 99, 98, 100, 100, 101,
101, 103, 103, 105, 103, 104, 104, 106, 106, 106, 106, 106, 106, 107, 108, 108,
107, 108, 110, 110, 111, 111, 111, 112, 112, 113, 113, 112, 113, 115, 114, 114,
114, 115, 115, 116, 116, 115, 115, 115, 116, 115, 117, 116, 117, 117, 117, 116,
117, 117, 117, 117, 117, 117, 117, 118, 117, 117, 117, 118, 118, 118, 118, 119,
118, 118, 118, 118, 118, 118, 119, 118, 118, 119, 118, 119, 118, 119, 119, 119,
118, 119, 118, 119, 119, 119, 118, 118, 118, 119, 119, 119, 118, 119, 118, 118,
117, 118, 118, 118, 118, 118, 119, 119, 119, 118, 120, 118, 121, 117, 122, 110,
118, 49, -87, -85, -95, -68, 45, 88, 87, 84, 69, 52, 55, 61, 62, 68, 81, 92, 98,
101, 99, 98, 98, 97, 93, 84, 69, 52, -27, -78, -88, -98, -99, -102, -104, -108,
-109, -110, -109, -111, -110, -112, -112, -112, -111, -113, -112, -113, -112,
-112, -113, -113, -114, -113, -112, -113, -114, -115, -115, -113, -115, -115,
-116, -114, -115, -115, -115, -115, -115, -116, -115, -115, -115, -116, -116,
-115, -116, -116, -116, -115, -116, -116, -116, -116, -115, -115, -116, -115,
-116, -116, -116, -116, -116, -116, -115, -114, -115, -115, -116, -115, -115,
-115, -116, -115, -115, -115, -116, -116, -116, -115, -116, -115, -115, -116,
-115, -116, -115, -116, -116, -115, -115, -115, -115, -115, -115, -114, -114,
-114, -114, -113, -113, -114, -114, -114, -114, -114, -114, -114, -114, -114,
-113, -113, -113, -112, -112, -112, -112, -112, -112, -111, -111, -111, -111,
-112, -111, -111, -110, -111, -111, -110, -109, -108, -109, -109, -109, -109,
-109, -109, -110, -108, -108, -107, -106, -105, -104, -104, -105, -104, -104,
-105, -105, -105, -103, -102, -100, -100, -101, -101, -101, -102, -100, -102,
-102, -101, -100, -98, -97, -97, -98, -98, -96, -94, -95, -95, -95, -94, -92,
-92, -93, -95, -92, -90, -88, -87, -88, -89, -88, -88, -86, -86, -84, -79, -74,
-73, -78, -81, -84, -87, -88, -87, -84, -79, -76, -76, -75, -74, -75, -78, -80,
-77, -74, -66, -64, -66, -68, -70, -70, -74, -77, -78, -77, -75, -71, -71, -74,
-78, -79, -81, -80, -79, -78, -77, -78, -77, -75, -77, -82, -86, -85, -81, -76,
-76, -79, -82, -81, -79, -79, -80, -83, -85, -86, -86, -84, -81, -75, -71, -73,
-76, -80, -83, -84, -85, -85, -87, -90, -89, -88, -85, -83, -82, -82, -84, -86,
-90, -92, -92, -90, -87, -85, -84, -83, -84, -85, -87, -88, -89, -89, -90, -90,
-90, -89, -89, -90, -89, -91, -92, -91, -90, -88, -89, -90, -89, -86, -86, -88,
-89, -90, -86, -83, -82, -85, -86, -85, -83, -85, -88, -87, -83, -80, -82, -83,
-83, -80, -78, -79, -80, -80, -80, -82, -85, -86, -83, -77, -67, -65, -62, -60,
-34, -6, -27, -51, -28, };