#define DATA_LENGTH 512
#define DATA AKWF_distorted_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {7, 32, 41, 48, 53, 58, 63, 66, 71, 74,
78, 81, 85, 88, 91, 94, 98, 101, 104, 108, 111, 115, 118, 119, 120, 119, 119,
119, 118, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119,
119, 118, 119, 119, 119, 120, 119, 118, 119, 119, 119, 119, 119, 120, 118, 118,
118, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 120, 120, 118, 119, 115, 111, 107, 104, 100, 97, 93, 90, 85, 83, 78, 75,
71, 66, 62, 56, 51, 42, 37, -6, -35, -41, -52, -55, -63, -66, -72, -76, -81,
-84, -89, -92, -96, -101, -106, -109, -115, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -118, -119, -119, -120, -119, -119, -119, -118,
-119, -119, -118, -119, -119, -119, -119, -119, -120, -119, -119, -120, -119,
-119, -119, -119, -119, -118, -119, -119, -119, -118, -119, -119, -119, -119,
-120, -119, -119, -119, -120, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -118, -119, -119, -119, -120, -119, -119, -119, -119, -119,
-118, -120, -119, -119, -119, -119, -119, -118, -120, -119, -119, -119, -120,
-119, -120, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -120, -119, -119, -119, -119, -119, -120, -119, -120, -116, -110,
-105, -100, -95, -91, -85, -81, -76, -71, -66, -59, -53, -45, -34, 9, 39, 47,
55, 61, 67, 72, 77, 82, 88, 92, 97, 101, 106, 110, 117, 119, 119, 119, 119, 119,
119, 120, 119, 119, 119, 120, 119, 119, 119, 120, 120, 119, 119, 119, 119, 119,
119, 120, 120, 118, 120, 119, 119, 119, 120, 119, 120, 120, 119, 118, 120, 119,
119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 118,
119, 118, 119, 119, 120, 119, 119, 118, 119, 119, 119, 120, 119, 119, 119, 119,
119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 119, 120, 119, 119, 119, 119, 119, 118, 119, 120, 119, 120, 119, 119, 119,
119, 118, 118, 119, 119, 119, 119, 114, 108, 104, 101, 97, 93, 87, 83, 79, 75,
71, 65, 61, 54, 49, 40, 33, -6, -41, -43, -53, -57, -63, -67, -72, -75, -80,
-83, -87, -90, -94, -98, -100, -105, -108, -112, -117, -119, -119, -120, -118,
-120, -119, -119, -119, -119, -119, -119, -120, -119, -120, -119, -119, -119,
-119, -119, -118, -119, -118, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -120, -120, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118,
-118, -119, -119, -119, -119, -119, -119, -119, -119, -118, -118, -119, -119,
-118, -119, -118, -119, -118, -114, -110, -107, -103, -100, -98, -94, -90, -87,
-84, -80, -78, -74, -70, -66, -62, -56, -52, -45, -42, -25, };