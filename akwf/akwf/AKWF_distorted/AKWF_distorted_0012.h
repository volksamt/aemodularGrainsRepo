#define DATA_LENGTH 512
#define DATA AKWF_distorted_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {50, 58, 55, 58, 56, 56, 58, 54, 67,
90, 83, 88, 83, 92, 103, 102, 102, 101, 102, 102, 102, 102, 102, 100, 103, 110,
110, 110, 110, 109, 110, 110, 110, 110, 111, 114, 114, 115, 114, 114, 115, 114,
114, 114, 115, 114, 113, 115, 114, 115, 117, 117, 116, 117, 117, 117, 117, 117,
117, 116, 116, 116, 117, 116, 117, 117, 118, 117, 118, 118, 118, 118, 118, 118,
118, 119, 119, 118, 118, 117, 118, 117, 117, 118, 118, 118, 117, 118, 118, 117,
118, 119, 119, 118, 118, 119, 118, 118, 118, 119, 119, 119, 118, 118, 118, 119,
118, 118, 118, 119, 119, 118, 119, 118, 119, 119, 118, 119, 119, 119, 118, 118,
118, 119, 118, 118, 119, 120, 119, 120, 118, 119, 119, 119, 119, 119, 119, 119,
119, 118, 118, 119, 118, 119, 119, 118, 119, 118, 118, 118, 119, 119, 119, 120,
119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 118, 119, 119, 119,
119, 119, 119, 118, 119, 119, 118, 119, 119, 118, 119, 119, 119, 119, 119, 119,
119, 120, 118, 119, 119, 119, 119, 119, 119, 118, 119, 120, 119, 119, 119, 119,
119, 120, 120, 119, 119, 120, 119, 119, 119, 120, 118, 119, 119, 119, 118, 119,
119, 119, 119, 119, 119, 119, 120, 119, 121, 118, 119, 118, 120, 118, 120, 118,
120, 118, 121, 117, 120, 117, 120, 119, 119, 120, 117, 122, 107, 127, -29, -107,
-105, -126, -110, -124, -114, -124, -115, -122, -116, -121, -117, -120, -118,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -120, -118,
-119, -119, -120, -118, -120, -119, -119, -119, -119, -119, -118, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -118, -119,
-120, -120, -119, -119, -119, -120, -120, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -118, -119,
-119, -120, -119, -119, -120, -118, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -118, -118, -119, -119, -119, -120, -119, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -118, -119, -119, -120,
-119, -118, -119, -118, -118, -119, -118, -119, -119, -119, -119, -119, -118,
-119, -119, -119, -119, -119, -119, -119, -118, -118, -119, -119, -119, -119,
-119, -119, -118, -119, -120, -119, -118, -120, -118, -119, -118, -119, -119,
-119, -118, -118, -119, -119, -118, -118, -119, -118, -118, -119, -118, -118,
-118, -118, -118, -118, -118, -118, -118, -118, -118, -117, -118, -117, -118,
-118, -118, -118, -118, -119, -118, -117, -118, -118, -118, -117, -117, -116,
-117, -117, -116, -117, -117, -117, -116, -117, -116, -115, -114, -115, -114,
-115, -114, -115, -114, -115, -114, -114, -108, -110, -110, -110, -109, -111,
-110, -110, -110, -103, -101, -102, -101, -101, -103, -101, -104, -97, -86, -86,
-87, -84, -90, -74, -54, -56, -59, -54, -63, -34, 7, -3, 2, -2, };