#define DATA_LENGTH 512
#define DATA AKWF_distorted_0023

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 17, 31, 42, 52, 60, 68, 75, 81, 87,
91, 95, 98, 102, 104, 106, 109, 110, 111, 113, 113, 115, 115, 115, 117, 117,
117, 117, 118, 118, 118, 118, 118, 119, 118, 119, 119, 119, 120, 119, 119, 119,
119, 120, 118, 119, 118, 119, 118, 118, 119, 119, 118, 118, 117, 118, 118, 118,
117, 117, 117, 116, 116, 116, 115, 115, 115, 114, 115, 114, 113, 112, 112, 112,
112, 111, 111, 110, 109, 109, 108, 107, 107, 106, 105, 104, 104, 103, 103, 102,
101, 100, 99, 99, 97, 96, 96, 95, 94, 92, 92, 91, 90, 89, 88, 88, 86, 84, 84,
83, 81, 81, 80, 79, 77, 76, 75, 73, 72, 71, 69, 67, 66, 65, 64, 62, 61, 59, 57,
56, 54, 52, 50, 48, 46, 43, 42, 41, 38, 36, 33, 32, 28, 27, 24, 21, 18, 15, 12,
9, 7, 3, 0, -5, -7, -10, -13, -16, -18, -22, -25, -27, -30, -32, -35, -37, -39,
-41, -44, -46, -49, -50, -52, -54, -55, -58, -59, -61, -62, -64, -66, -67, -68,
-70, -71, -72, -74, -75, -76, -77, -79, -80, -82, -81, -83, -84, -85, -86, -88,
-88, -89, -90, -90, -91, -93, -93, -94, -95, -95, -95, -97, -97, -98, -99, -100,
-100, -100, -101, -102, -102, -103, -103, -104, -104, -105, -105, -106, -106,
-106, -107, -107, -107, -108, -109, -109, -109, -109, -111, -111, -110, -112,
-112, -111, -111, -112, -112, -111, -113, -112, -113, -113, -113, -113, -114,
-113, -114, -114, -114, -114, -115, -115, -114, -115, -115, -115, -115, -116,
-115, -115, -115, -115, -115, -115, -114, -115, -115, -116, -115, -116, -115,
-115, -115, -114, -115, -114, -114, -114, -114, -114, -113, -113, -113, -112,
-111, -111, -110, -109, -109, -108, -107, -106, -103, -102, -100, -99, -95, -92,
-89, -84, -79, -74, -68, -60, -51, -41, -30, -16, 1, 16, 28, 41, 51, 60, 68, 74,
80, 85, 89, 92, 95, 97, 101, 102, 103, 106, 106, 107, 109, 109, 109, 111, 111,
110, 111, 112, 112, 111, 111, 112, 111, 111, 111, 110, 110, 111, 110, 110, 109,
108, 108, 107, 107, 105, 104, 104, 102, 101, 100, 99, 97, 96, 94, 92, 90, 89,
86, 84, 83, 80, 77, 75, 72, 69, 65, 63, 60, 55, 53, 50, 46, 41, 37, 34, 29, 24,
20, 16, 11, 6, 1, -4, -9, -13, -17, -20, -23, -27, -31, -35, -36, -40, -42, -46,
-48, -49, -51, -54, -56, -57, -59, -61, -62, -64, -66, -67, -68, -71, -71, -73,
-74, -75, -76, -77, -78, -80, -81, -82, -83, -83, -85, -85, -86, -87, -88, -88,
-89, -90, -91, -92, -91, -93, -94, -93, -95, -95, -96, -96, -97, -97, -98, -98,
-98, -99, -99, -100, -101, -101, -101, -102, -101, -102, -102, -103, -102, -102,
-103, -103, -103, -103, -102, -102, -102, -102, -102, -102, -101, -101, -101,
-100, -100, -98, -98, -96, -95, -95, -93, -91, -90, -88, -86, -82, -80, -77,
-72, -68, -63, -56, -49, -42, -32, -21, -8, };