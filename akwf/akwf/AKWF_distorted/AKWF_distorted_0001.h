#define DATA_LENGTH 512
#define DATA AKWF_distorted_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {14, 56, 64, 70, 75, 80, 84, 87, 90,
92, 97, 98, 102, 104, 106, 109, 112, 115, 118, 119, 119, 120, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 118, 119,
119, 120, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118,
119, 119, 118, 119, 119, 118, 118, 118, 120, 120, 118, 119, 119, 119, 120, 119,
119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119, 118, 119,
118, 120, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 118, 119,
119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 120, 119, 119, 119, 119,
119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119,
118, 119, 119, 118, 119, 119, 120, 119, 120, 118, 118, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 120,
118, 119, 119, 120, 120, 119, 119, 119, 119, 119, 119, 120, 120, 119, 120, 119,
118, 119, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 120,
119, 118, 118, 119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 119,
120, 119, 118, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 120, 120, 119, 118, 119, 119, 119, 119, 117, 115, 111, 111, 108,
107, 104, 103, 100, 99, 95, 93, 91, 89, 85, 82, 79, 72, 71, 58, 59, -20, -67,
-62, -76, -75, -84, -84, -90, -91, -96, -97, -100, -104, -106, -108, -111, -114,
-118, -119, -119, -119, -118, -119, -118, -120, -119, -119, -118, -120, -119,
-119, -119, -118, -119, -120, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -120, -120, -119,
-120, -120, -119, -119, -120, -119, -118, -120, -120, -120, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -120, -119, -118, -119, -119,
-118, -119, -119, -120, -119, -119, -119, -119, -118, -119, -119, -118, -119,
-119, -119, -119, -119, -120, -120, -119, -119, -119, -119, -119, -120, -118,
-118, -119, -119, -119, -118, -120, -119, -119, -119, -118, -119, -119, -119,
-120, -119, -119, -119, -119, -119, -119, -118, -120, -119, -119, -119, -119,
-118, -119, -118, -119, -119, -120, -118, -119, -119, -119, -119, -119, -120,
-119, -119, -118, -120, -119, -119, -120, -119, -119, -119, -119, -119, -118,
-119, -120, -120, -119, -119, -120, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -118, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119,
-116, -115, -112, -110, -109, -108, -106, -104, -102, -99, -98, -95, -94, -89,
-89, -83, -83, -77, -75, -67, -65, -45, };