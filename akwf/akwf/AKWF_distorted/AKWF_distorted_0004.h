#define DATA_LENGTH 512
#define DATA AKWF_distorted_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {21, 33, 37, 44, 47, 52, 54, 58, 59,
63, 64, 67, 70, 73, 75, 77, 80, 82, 84, 86, 88, 90, 92, 94, 96, 98, 100, 102,
104, 107, 108, 111, 114, 116, 119, 119, 119, 119, 119, 119, 118, 118, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 120, 119, 119,
119, 120, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 118, 120, 119, 119, 119, 119, 119, 120, 119, 120, 119, 118, 119, 119, 120,
119, 119, 118, 119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 118, 119, 120, 119, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119,
118, 119, 119, 119, 119, 118, 119, 119, 119, 118, 119, 118, 119, 119, 119, 119,
118, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 118,
119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119,
119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120,
119, 119, 119, 120, 118, 120, 119, 117, 115, 113, 110, 109, 107, 106, 104, 101,
99, 97, 96, 94, 93, 93, 93, 92, 90, 88, 86, 83, 81, 78, 77, 76, 75, 74, 72, 70,
68, 67, 63, 61, 58, 56, 53, 52, 49, 47, 44, 41, 35, 29, 16, -21, -32, -35, -41,
-42, -47, -49, -53, -55, -58, -61, -63, -65, -68, -69, -72, -73, -76, -77, -79,
-80, -83, -85, -87, -89, -90, -93, -94, -96, -98, -99, -101, -103, -105, -107,
-108, -110, -113, -114, -115, -117, -119, -119, -120, -119, -118, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -118, -119, -120, -119, -120, -119, -119, -119, -119, -119, -118, -119,
-119, -119, -119, -120, -119, -119, -119, -119, -119, -120, -120, -119, -119,
-119, -120, -119, -119, -119, -120, -119, -120, -119, -119, -119, -119, -120,
-119, -119, -119, -119, -119, -119, -118, -119, -119, -118, -119, -119, -119,
-119, -119, -118, -119, -119, -119, -119, -119, -119, -118, -119, -120, -120,
-118, -118, -119, -120, -118, -119, -119, -119, -119, -120, -120, -119, -118,
-119, -119, -119, -120, -118, -120, -118, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -119, -119, -120, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -120, -119, -119, -118, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -120, -118,
-116, -114, -113, -112, -113, -113, -112, -108, -105, -101, -99, -96, -95, -94,
-93, -92, -90, -89, -86, -84, -81, -80, -76, -74, -72, -70, -68, -67, -66, -62,
-61, -57, -54, -50, -46, -42, -39, -34, -28, -16, };