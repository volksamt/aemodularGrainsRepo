#define DATA_LENGTH 512
#define DATA AKWF_distorted_0041

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 35, 58, 63, 68, 72, 76, 79, 82, 84,
85, 88, 90, 91, 93, 93, 95, 96, 97, 98, 99, 99, 101, 102, 102, 103, 103, 105,
105, 105, 106, 105, 106, 107, 107, 108, 109, 109, 110, 109, 109, 110, 110, 111,
112, 111, 112, 111, 112, 113, 112, 113, 112, 113, 113, 113, 113, 114, 114, 114,
114, 114, 115, 115, 115, 114, 115, 115, 115, 116, 115, 116, 116, 115, 116, 116,
116, 116, 117, 117, 117, 116, 117, 117, 116, 117, 117, 117, 117, 117, 117, 118,
117, 117, 118, 118, 117, 117, 118, 117, 118, 118, 117, 119, 118, 118, 119, 117,
118, 118, 119, 118, 118, 117, 120, 119, 119, 118, 119, 118, 119, 118, 118, 119,
117, 120, 117, 120, 117, 121, 117, 121, 116, 122, 114, 124, 113, 124, 112, 127,
87, -102, -112, -112, -114, -111, -114, -111, -113, -110, -113, -109, -112,
-109, -111, -109, -110, -109, -110, -108, -108, -107, -107, -106, -107, -106,
-105, -105, -104, -103, -104, -102, -102, -101, -100, -100, -98, -97, -96, -96,
-94, -92, -91, -91, -88, -87, -84, -83, -81, -79, -74, -72, -66, -61, -49, -21,
15, 43, 62, 63, 73, 72, 79, 77, 85, 83, 89, 86, 92, 90, 94, 96, 91, 107, -81,
-128, -108, -125, -111, -123, -113, -122, -114, -120, -115, -119, -116, -118,
-116, -118, -116, -117, -116, -117, -117, -116, -116, -117, -117, -115, -116,
-115, -116, -116, -116, -114, -116, -115, -116, -115, -115, -114, -115, -115,
-114, -114, -115, -114, -114, -114, -114, -113, -113, -112, -112, -113, -112,
-112, -111, -111, -112, -111, -112, -110, -110, -110, -110, -109, -110, -109,
-108, -108, -107, -107, -106, -106, -106, -106, -104, -103, -103, -102, -102,
-102, -100, -100, -99, -99, -97, -96, -95, -94, -92, -91, -89, -87, -86, -84,
-82, -78, -75, -72, -69, -62, -56, -35, -2, 31, 55, 63, 68, 72, 75, 78, 81, 83,
85, 87, 89, 90, 91, 94, 94, 97, 97, 98, 99, 100, 101, 101, 102, 103, 103, 104,
105, 105, 105, 107, 106, 107, 107, 108, 107, 109, 109, 110, 110, 110, 111, 110,
111, 111, 112, 110, 111, 112, 113, 112, 112, 112, 115, 113, 114, 113, 114, 113,
115, 114, 114, 114, 115, 116, 115, 116, 114, 118, 113, 119, 112, 120, 111, 122,
109, 126, 103, 127, 51, -127, -109, -123, -115, -119, -118, -117, -119, -117,
-120, -116, -119, -116, -119, -116, -119, -116, -119, -115, -118, -116, -118,
-116, -118, -116, -117, -118, -117, -117, -117, -118, -116, -116, -116, -116,
-116, -116, -116, -117, -115, -116, -115, -115, -116, -115, -115, -115, -115,
-115, -115, -115, -115, -114, -115, -115, -115, -114, -115, -114, -113, -114,
-113, -113, -112, -112, -112, -112, -112, -111, -112, -111, -110, -110, -110,
-110, -109, -109, -108, -108, -107, -107, -107, -106, -107, -106, -105, -105,
-104, -103, -102, -103, -101, -102, -100, -100, -98, -98, -96, -95, -94, -94,
-91, -91, -89, -86, -85, -83, -81, -78, -75, -70, -67, -61, -54, -23, };