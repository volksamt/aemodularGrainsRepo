#define DATA_LENGTH 512
#define DATA AKWF_distorted_0024

const PROGMEM int8_t DATA[DATA_LENGTH] = {8, 25, 38, 49, 58, 66, 73, 78, 83, 86,
89, 92, 95, 97, 100, 101, 103, 104, 105, 107, 107, 108, 109, 110, 111, 111, 111,
112, 113, 114, 114, 114, 115, 115, 116, 115, 116, 116, 116, 116, 116, 117, 117,
117, 118, 118, 118, 117, 118, 118, 117, 118, 119, 118, 119, 117, 118, 118, 118,
119, 119, 118, 119, 118, 119, 118, 118, 119, 117, 118, 118, 118, 118, 118, 118,
118, 117, 118, 118, 117, 118, 117, 118, 117, 117, 118, 117, 118, 117, 117, 117,
117, 117, 117, 117, 116, 116, 116, 116, 115, 115, 116, 116, 115, 114, 114, 115,
115, 114, 114, 114, 113, 113, 113, 112, 112, 112, 112, 111, 111, 110, 111, 110,
110, 110, 109, 108, 108, 107, 107, 107, 107, 106, 105, 105, 105, 104, 104, 103,
101, 100, 100, 98, 98, 97, 96, 95, 93, 92, 90, 89, 87, 85, 83, 81, 79, 76, 73,
70, 67, 63, 60, 56, 52, 47, 43, 37, 33, 28, 23, 17, 11, 4, -1, -7, -11, -16,
-20, -23, -26, -28, -31, -33, -36, -38, -39, -41, -41, -43, -44, -45, -47, -48,
-50, -50, -52, -53, -54, -54, -55, -57, -59, -59, -61, -62, -64, -65, -67, -68,
-70, -71, -72, -73, -75, -77, -78, -79, -80, -81, -83, -84, -84, -86, -86, -86,
-88, -88, -89, -89, -90, -90, -91, -91, -92, -93, -92, -94, -94, -93, -94, -93,
-94, -94, -94, -93, -94, -94, -93, -93, -93, -94, -93, -93, -92, -93, -92, -91,
-91, -91, -91, -90, -90, -89, -88, -88, -86, -87, -86, -85, -85, -84, -83, -83,
-81, -81, -81, -80, -80, -79, -79, -79, -77, -78, -78, -77, -78, -76, -77, -77,
-76, -76, -75, -76, -74, -74, -73, -73, -72, -71, -70, -70, -68, -67, -65, -64,
-62, -60, -58, -55, -52, -48, -45, -41, -37, -34, -28, -22, -15, -8, 1, 9, 16,
24, 30, 35, 41, 46, 50, 53, 57, 60, 63, 65, 68, 70, 73, 73, 75, 77, 78, 79, 80,
80, 82, 82, 82, 83, 83, 83, 83, 83, 82, 81, 81, 81, 81, 80, 79, 78, 76, 75, 75,
73, 71, 69, 69, 67, 65, 63, 62, 58, 58, 53, 53, 49, 46, 43, 39, 35, 30, 25, 20,
14, 7, -2, -9, -16, -24, -31, -36, -43, -49, -54, -58, -63, -67, -71, -74, -78,
-81, -85, -87, -90, -92, -95, -97, -98, -101, -102, -104, -104, -106, -107,
-109, -109, -110, -112, -112, -113, -114, -114, -115, -115, -115, -116, -116,
-116, -117, -117, -118, -118, -118, -119, -118, -117, -118, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -118, -119, -119, -120, -119, -119,
-119, -119, -118, -119, -119, -118, -119, -118, -118, -117, -118, -117, -118,
-117, -117, -117, -117, -117, -115, -116, -115, -114, -114, -114, -113, -112,
-112, -111, -110, -108, -107, -105, -104, -101, -99, -96, -93, -90, -86, -81,
-75, -69, -60, -52, -40, -28, -10, };