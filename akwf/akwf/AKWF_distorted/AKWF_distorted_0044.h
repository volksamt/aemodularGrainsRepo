#define DATA_LENGTH 512
#define DATA AKWF_distorted_0044

const PROGMEM int8_t DATA[DATA_LENGTH] = {101, 122, 114, 121, 114, 119, 115,
118, 115, 119, 115, 118, 116, 119, 117, 118, 117, 117, 118, 117, 117, 117, 117,
118, 118, 118, 117, 118, 118, 117, 119, 117, 118, 118, 118, 117, 118, 117, 118,
117, 118, 118, 118, 118, 117, 117, 118, 118, 118, 118, 117, 117, 118, 118, 117,
118, 119, 118, 119, 118, 118, 118, 119, 118, 119, 118, 118, 118, 118, 118, 118,
118, 119, 118, 118, 118, 118, 119, 119, 118, 118, 118, 118, 118, 118, 117, 117,
118, 118, 118, 118, 117, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118, 118,
118, 118, 117, 118, 118, 118, 118, 119, 118, 118, 118, 118, 117, 118, 117, 118,
118, 118, 118, 118, 117, 118, 117, 118, 117, 119, 119, 119, 119, 119, 118, 120,
119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 118, 118, 119, 119, 119,
118, 119, 119, 119, 118, 118, 118, 118, 119, 119, 118, 119, 118, 118, 119, 119,
118, 118, 119, 118, 119, 118, 118, 118, 118, 118, 118, 117, 117, 118, 117, 117,
117, 117, 117, 116, 117, 116, 117, 116, 116, 115, 115, 115, 115, 115, 114, 115,
114, 114, 113, 113, 112, 112, 111, 111, 110, 110, 109, 107, 107, 106, 104, 103,
101, 99, 96, 94, 91, 86, 82, 71, 62, 1, -62, -71, -82, -85, -92, -94, -97, -100,
-102, -104, -105, -106, -107, -110, -108, -112, -109, -114, -111, -115, -110,
-117, -111, -119, -112, -120, -111, -120, -111, -124, -97, 111, 120, 114, 119,
113, 119, 112, 118, 112, 117, 110, 116, 110, 114, 109, 112, 107, 110, 107, 108,
104, 104, 101, 100, 96, 93, 90, 85, 80, 71, 54, -22, -67, -74, -83, -86, -92,
-94, -98, -100, -102, -103, -104, -106, -108, -109, -108, -110, -111, -111,
-112, -113, -113, -113, -113, -114, -115, -114, -115, -116, -115, -115, -116,
-116, -116, -117, -117, -116, -116, -118, -117, -117, -117, -117, -118, -117,
-118, -117, -117, -118, -118, -118, -118, -118, -118, -118, -118, -118, -119,
-118, -118, -119, -119, -119, -118, -119, -119, -119, -118, -119, -118, -119,
-119, -119, -119, -120, -119, -120, -119, -119, -119, -118, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -120, -119, -119, -120, -119, -120, -119,
-118, -118, -117, -118, -118, -117, -118, -117, -118, -117, -118, -118, -117,
-118, -117, -118, -118, -118, -117, -118, -119, -117, -118, -117, -117, -118,
-117, -118, -117, -118, -118, -118, -118, -118, -118, -118, -119, -117, -118,
-118, -118, -118, -117, -118, -118, -118, -118, -118, -118, -118, -119, -119,
-117, -118, -118, -118, -118, -119, -118, -118, -119, -118, -117, -118, -118,
-119, -119, -119, -117, -118, -118, -117, -117, -118, -117, -118, -118, -118,
-118, -118, -118, -117, -119, -117, -118, -117, -117, -118, -118, -118, -117,
-117, -117, -118, -117, -118, -118, -118, -117, -118, -117, -117, -118, -118,
-117, -118, -117, -117, -118, -117, -117, -117, -117, -117, -118, -116, -118,
-116, -119, -115, -119, -114, -120, -114, -121, -113, -123, -94, };