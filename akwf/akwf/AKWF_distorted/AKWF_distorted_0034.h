#define DATA_LENGTH 512
#define DATA AKWF_distorted_0034

const PROGMEM int8_t DATA[DATA_LENGTH] = {104, 124, 115, 122, 116, 121, 117,
120, 118, 120, 118, 120, 118, 120, 117, 120, 118, 119, 119, 119, 118, 119, 119,
119, 119, 119, 120, 118, 119, 118, 119, 118, 119, 118, 119, 118, 119, 118, 119,
118, 118, 119, 119, 119, 118, 118, 119, 119, 119, 118, 118, 118, 118, 119, 118,
118, 119, 118, 118, 117, 119, 119, 118, 118, 118, 119, 118, 117, 118, 118, 118,
118, 117, 117, 117, 117, 118, 117, 118, 119, 118, 117, 118, 118, 117, 117, 118,
118, 116, 118, 118, 117, 118, 117, 118, 117, 117, 117, 118, 118, 117, 117, 117,
116, 117, 117, 118, 116, 117, 116, 116, 116, 117, 116, 116, 116, 116, 116, 116,
116, 116, 115, 115, 115, 116, 116, 116, 115, 115, 115, 115, 115, 115, 115, 115,
115, 114, 114, 114, 115, 114, 114, 114, 114, 114, 114, 113, 114, 113, 113, 113,
113, 114, 113, 113, 113, 112, 113, 112, 111, 111, 112, 111, 110, 110, 110, 110,
110, 110, 109, 109, 109, 109, 109, 108, 109, 107, 107, 108, 108, 107, 106, 107,
106, 106, 105, 105, 105, 104, 105, 104, 103, 102, 102, 102, 101, 100, 100, 100,
99, 98, 98, 97, 97, 96, 95, 94, 93, 93, 92, 90, 89, 89, 87, 87, 84, 84, 82, 81,
78, 78, 74, 72, 69, 67, 62, 59, 51, 33, 8, -1, 0, 0, 0, -1, 1, 0, 1, 0, -1, 0,
0, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, -1,
0, 0, 0, -1, 1, -1, 1, -1, 0, 0, 1, -1, 2, -5, -26, -47, -58, -61, -66, -69,
-72, -75, -76, -79, -80, -81, -84, -85, -85, -87, -88, -90, -91, -92, -93, -94,
-94, -95, -96, -97, -98, -97, -98, -99, -99, -100, -100, -102, -101, -102, -103,
-103, -104, -103, -104, -104, -105, -105, -105, -106, -107, -107, -106, -107,
-107, -107, -107, -108, -108, -109, -109, -109, -110, -109, -109, -110, -110,
-110, -111, -111, -111, -112, -112, -111, -111, -112, -113, -112, -112, -112,
-112, -114, -112, -114, -113, -113, -113, -114, -113, -114, -115, -114, -114,
-113, -114, -114, -114, -115, -115, -115, -115, -115, -115, -116, -115, -116,
-116, -116, -115, -115, -115, -116, -116, -116, -116, -116, -116, -116, -116,
-116, -116, -117, -116, -117, -117, -117, -116, -116, -117, -117, -117, -118,
-117, -117, -117, -117, -118, -117, -117, -118, -117, -117, -117, -117, -118,
-117, -118, -118, -118, -117, -118, -118, -118, -118, -117, -118, -117, -118,
-118, -117, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118, -118,
-118, -118, -119, -118, -119, -119, -119, -119, -119, -119, -118, -118, -119,
-119, -118, -119, -118, -119, -118, -119, -119, -119, -118, -119, -118, -119,
-119, -119, -118, -119, -118, -120, -118, -119, -119, -119, -118, -119, -119,
-118, -120, -118, -119, -118, -119, -118, -120, -118, -120, -118, -120, -118,
-120, -117, -120, -117, -120, -118, -119, -119, -118, -125, -18, 8, };