#define DATA_LENGTH 512
#define DATA AKWF_distorted_0040

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 14, 19, 24, 30, 35, 40, 45, 51,
54, 55, 57, 58, 59, 60, 61, 63, 63, 64, 65, 66, 67, 67, 68, 69, 70, 71, 71, 72,
72, 73, 73, 74, 75, 75, 80, 86, 90, 92, 95, 97, 99, 102, 102, 104, 106, 107,
106, 109, 109, 110, 111, 111, 112, 112, 112, 114, 113, 114, 114, 114, 115, 115,
116, 115, 116, 116, 117, 117, 117, 116, 117, 117, 117, 117, 117, 117, 118, 118,
118, 119, 118, 118, 118, 118, 118, 118, 118, 118, 119, 119, 119, 119, 119, 120,
118, 119, 118, 119, 119, 119, 120, 119, 118, 118, 120, 119, 119, 119, 120, 119,
120, 118, 119, 119, 119, 119, 120, 119, 119, 120, 119, 119, 120, 119, 119, 119,
119, 119, 119, 118, 118, 118, 118, 118, 118, 118, 117, 118, 118, 116, 117, 117,
118, 116, 117, 116, 116, 116, 116, 115, 115, 116, 115, 115, 115, 114, 115, 114,
113, 113, 113, 112, 113, 113, 112, 113, 113, 112, 112, 112, 113, 112, 113, 113,
113, 113, 112, 113, 113, 113, 113, 112, 112, 113, 112, 112, 113, 113, 113, 112,
112, 113, 113, 113, 114, 114, 114, 113, 113, 113, 113, 113, 114, 114, 113, 114,
113, 113, 114, 114, 114, 114, 114, 113, 113, 115, 114, 113, 114, 114, 114, 115,
114, 114, 115, 114, 114, 114, 113, 112, 113, 112, 111, 111, 110, 109, 110, 109,
107, 107, 106, 105, 103, 102, 102, 101, 99, 98, 95, 93, 89, 87, 82, 78, 72, 66,
42, -19, -58, -68, -77, -82, -86, -88, -91, -93, -97, -98, -99, -102, -102,
-103, -105, -105, -107, -108, -109, -109, -109, -110, -111, -111, -112, -112,
-112, -113, -113, -113, -114, -114, -115, -114, -114, -114, -114, -114, -114,
-114, -114, -114, -114, -113, -114, -114, -114, -114, -114, -113, -113, -113,
-113, -113, -113, -113, -114, -114, -114, -114, -113, -114, -113, -113, -114,
-113, -114, -114, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113,
-113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -112, -113, -113,
-113, -113, -113, -113, -112, -113, -113, -114, -114, -114, -115, -114, -115,
-115, -115, -115, -116, -116, -116, -117, -116, -116, -117, -117, -118, -117,
-118, -118, -118, -118, -118, -117, -118, -118, -119, -118, -119, -118, -119,
-119, -119, -118, -120, -119, -119, -119, -118, -120, -119, -120, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -119, -118, -118, -119, -118, -120,
-119, -119, -118, -119, -119, -119, -118, -118, -120, -118, -118, -119, -119,
-119, -119, -119, -118, -119, -119, -118, -118, -118, -118, -117, -118, -117,
-118, -117, -117, -116, -117, -117, -117, -116, -116, -115, -116, -116, -115,
-115, -116, -115, -114, -114, -114, -113, -113, -112, -111, -111, -110, -110,
-109, -108, -107, -105, -105, -103, -102, -101, -98, -96, -94, -92, -88, -83,
-78, -71, -71, -70, -69, -68, -67, -66, -66, -65, -64, -63, -62, -62, -60, -60,
-57, -57, -54, -54, -48, -44, -39, -33, -28, -23, -18, -13, -7, -1, };