#define DATA_LENGTH 512
#define DATA AKWF_distorted_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 12, 18, 20, 20, 21, 24, 28, 30, 30,
24, 20, 22, 31, 42, 51, 59, 65, 70, 73, 77, 80, 84, 86, 90, 91, 94, 96, 97, 99,
101, 103, 103, 105, 106, 106, 106, 108, 109, 109, 109, 111, 111, 111, 112, 112,
113, 112, 113, 113, 114, 115, 115, 114, 116, 115, 115, 115, 115, 116, 116, 116,
116, 116, 117, 117, 116, 117, 116, 117, 117, 117, 117, 117, 118, 117, 118, 118,
118, 118, 118, 118, 118, 118, 118, 117, 118, 119, 119, 118, 118, 118, 118, 118,
119, 119, 119, 118, 119, 119, 119, 118, 120, 119, 119, 118, 119, 119, 118, 119,
119, 119, 119, 118, 119, 119, 118, 119, 119, 120, 118, 120, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 120, 119, 118, 119, 119, 118, 118, 119, 119, 118,
119, 120, 119, 119, 118, 119, 118, 118, 119, 119, 118, 119, 119, 119, 119, 119,
119, 119, 119, 118, 118, 119, 119, 119, 118, 118, 119, 118, 118, 119, 119, 118,
118, 118, 118, 118, 117, 119, 118, 118, 118, 118, 117, 118, 117, 117, 118, 117,
118, 117, 117, 116, 117, 116, 117, 116, 116, 116, 115, 116, 116, 116, 115, 115,
115, 115, 114, 114, 114, 114, 113, 113, 112, 112, 111, 111, 111, 110, 110, 109,
108, 108, 106, 105, 105, 103, 102, 100, 100, 98, 96, 94, 90, 87, 84, 79, 73, 66,
61, 58, 60, 62, 63, 60, 56, 53, 52, 52, 47, 43, 37, 28, 17, 6, -4, -12, -19,
-21, -20, -21, -24, -28, -31, -29, -24, -19, -22, -32, -43, -52, -60, -65, -69,
-73, -78, -81, -84, -87, -90, -92, -94, -97, -98, -99, -100, -102, -104, -104,
-105, -107, -108, -109, -109, -109, -109, -110, -112, -111, -111, -112, -113,
-113, -114, -113, -114, -114, -115, -115, -115, -115, -115, -115, -116, -116,
-116, -116, -116, -116, -116, -117, -117, -116, -117, -118, -117, -117, -117,
-117, -118, -117, -117, -117, -117, -117, -118, -118, -119, -118, -118, -118,
-117, -119, -119, -119, -119, -118, -118, -118, -118, -119, -119, -119, -118,
-118, -118, -118, -119, -119, -118, -119, -119, -119, -119, -118, -119, -118,
-119, -119, -119, -119, -118, -119, -118, -118, -119, -119, -119, -119, -118,
-119, -119, -120, -120, -120, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -120, -119, -120, -119, -119, -119, -120, -119, -119, -118,
-119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-118, -119, -119, -118, -119, -119, -118, -117, -118, -118, -118, -118, -118,
-118, -118, -118, -118, -118, -118, -117, -118, -117, -117, -117, -117, -117,
-118, -118, -117, -117, -116, -116, -116, -116, -116, -116, -116, -116, -115,
-115, -115, -115, -115, -115, -115, -114, -113, -113, -113, -113, -112, -112,
-112, -110, -111, -110, -110, -109, -107, -107, -107, -106, -105, -104, -102,
-101, -99, -98, -96, -93, -91, -88, -84, -79, -72, -65, -60, -59, -60, -62, -61,
-60, -56, -53, -52, -51, -46, -42, -35, -27, -16, -5, };