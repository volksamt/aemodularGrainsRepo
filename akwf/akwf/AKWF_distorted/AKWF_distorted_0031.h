#define DATA_LENGTH 512
#define DATA AKWF_distorted_0031

const PROGMEM int8_t DATA[DATA_LENGTH] = {65, 104, 96, 100, 97, 99, 98, 100, 98,
98, 98, 99, 98, 98, 98, 99, 99, 99, 98, 99, 98, 98, 98, 98, 98, 98, 98, 98, 99,
99, 99, 99, 98, 98, 99, 98, 99, 98, 99, 97, 99, 98, 99, 98, 98, 97, 99, 111,
117, 117, 116, 117, 117, 117, 117, 117, 116, 117, 117, 117, 117, 117, 117, 115,
106, 96, 99, 97, 98, 98, 98, 98, 98, 97, 98, 97, 98, 98, 98, 97, 97, 98, 97, 98,
98, 97, 98, 97, 98, 98, 98, 98, 98, 97, 98, 98, 97, 97, 98, 97, 98, 98, 98, 98,
98, 97, 98, 98, 98, 97, 98, 99, 97, 98, 98, 97, 97, 98, 98, 98, 97, 98, 98, 98,
97, 98, 98, 98, 98, 98, 98, 98, 98, 97, 98, 98, 97, 98, 98, 97, 98, 98, 97, 94,
91, 91, 92, 92, 91, 91, 91, 92, 91, 91, 90, 91, 91, 91, 90, 90, 91, 91, 91, 91,
91, 89, 92, 90, 92, 89, 91, 89, 91, 89, 92, 90, 93, 88, 92, 89, 91, 91, 91, 91,
90, 93, 87, 96, 80, 111, -47, -127, -110, -126, -114, -122, -116, -121, -118,
-120, -118, -119, -119, -120, -118, -122, -114, -126, 48, 100, 66, 89, 73, 86,
76, 85, 77, 83, 79, 82, 79, 82, 79, 75, 59, 56, 58, 56, 57, 57, 58, 57, 58, 57,
58, 58, 57, 60, -3, -80, -83, -84, -82, -84, -83, -85, -83, -84, -84, -83, -84,
-84, -83, -83, -83, -83, -84, -83, -84, -83, -84, -83, -84, -83, -83, -83, -83,
-83, -84, -84, -83, -84, -83, -84, -84, -84, -84, -84, -84, -83, -83, -84, -83,
-83, -83, -83, -84, -79, -69, -64, -65, -64, -65, -65, -65, -64, -65, -65, -64,
-65, -65, -66, -66, -65, -65, -65, -66, -64, -65, -64, -65, -63, -65, -65, -65,
-63, -65, -64, -64, -64, -64, -65, -64, -65, -64, -65, -64, -67, -62, -67, -61,
-71, -54, -83, 6, 119, 108, 123, 112, 121, 115, 120, 115, 120, 114, 118, 116,
118, 116, 118, 116, 116, 76, -59, -66, -62, -67, -64, -67, -64, -67, -64, -66,
-65, -67, -64, -66, -66, -67, -66, -66, -66, -66, -65, -66, -66, -65, -66, -65,
-66, -66, -66, -66, -65, -66, -66, -65, -66, -66, -65, -66, -67, -65, -67, -65,
-66, -66, -66, -66, -67, -67, -66, -66, -66, -66, -67, -65, -66, -66, -66, -67,
-66, -66, -66, -58, 20, 65, 53, 58, 54, 58, 57, 57, 56, 58, 56, 57, 57, 57, 57,
57, 58, 56, 58, 55, 58, 56, 57, 56, 58, 55, 59, 55, 59, 53, 61, 34, -78, -100,
-98, -100, -98, -100, -97, -101, -98, -100, -99, -100, -99, -99, -99, -99, -98,
-100, -99, -100, -98, -100, -98, -99, -99, -99, -99, -98, -100, -99, -99, -102,
-110, -111, -113, -112, -112, -112, -113, -111, -112, -111, -112, -112, -112,
-112, -111, -112, -115, -118, -117, -118, -116, -119, -115, -119, -115, -120,
-114, -119, -114, -120, -113, -124, -96, };