#define DATA_LENGTH 512
#define DATA AKWF_distorted_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {40, 61, 66, 74, 76, 83, 85, 89, 91,
95, 97, 100, 102, 105, 107, 110, 113, 115, 119, 119, 118, 119, 119, 119, 119,
119, 119, 119, 118, 118, 119, 119, 119, 118, 119, 119, 119, 120, 119, 120, 118,
119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
118, 119, 119, 119, 118, 120, 119, 119, 119, 119, 120, 120, 119, 119, 119, 119,
118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119,
119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 120, 118, 119, 120, 119,
119, 119, 119, 120, 120, 119, 119, 119, 119, 120, 119, 119, 119, 120, 119, 120,
119, 120, 119, 120, 119, 120, 118, 119, 119, 118, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 120, 119, 119, 120,
118, 119, 119, 119, 120, 119, 119, 118, 119, 119, 119, 120, 118, 119, 118, 119,
119, 119, 119, 118, 119, 120, 118, 119, 119, 119, 119, 118, 118, 119, 119, 120,
118, 118, 119, 119, 119, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 120,
120, 119, 119, 119, 119, 119, 120, 119, 119, 119, 119, 118, 120, 119, 119, 119,
120, 119, 119, 119, 117, 114, 111, 110, 107, 106, 103, 102, 97, 97, 91, 91, 85,
84, 77, 75, 67, 64, 46, -44, -62, -66, -74, -77, -84, -85, -91, -91, -97, -97,
-102, -102, -106, -107, -110, -112, -116, -118, -119, -119, -119, -118, -119,
-119, -119, -120, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-118, -119, -119, -120, -118, -119, -119, -120, -119, -119, -119, -119, -118,
-119, -119, -120, -119, -120, -119, -120, -120, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -118, -119, -119, -120, -119, -120, -119, -119,
-120, -118, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-120, -119, -118, -118, -119, -119, -120, -120, -119, -119, -119, -119, -119,
-119, -119, -120, -119, -119, -119, -120, -119, -119, -120, -118, -119, -118,
-119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -118, -119, -119, -118, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -120, -119, -120, -119, -119, -119,
-119, -119, -119, -118, -118, -118, -119, -119, -120, -119, -119, -119, -120,
-119, -118, -119, -119, -119, -119, -118, -119, -119, -119, -119, -119, -119,
-119, -118, -119, -119, -119, -119, -119, -120, -119, -119, -118, -119, -120,
-119, -119, -119, -119, -119, -119, -120, -119, -120, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -117, -114, -112, -109, -108, -105, -102, -101,
-98, -96, -91, -90, -85, -83, -77, -75, -67, -63, -43, };