#define DATA_LENGTH 512
#define DATA AKWF_distorted_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {80, 107, 106, 115, 113, 120, 117, 121,
118, 120, 118, 119, 119, 119, 119, 120, 118, 120, 119, 119, 119, 119, 119, 119,
119, 120, 119, 119, 119, 120, 119, 119, 119, 119, 119, 119, 119, 119, 119, 119,
119, 119, 119, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 119, 119, 120,
119, 119, 120, 119, 119, 119, 119, 118, 119, 119, 120, 119, 119, 119, 119, 120,
119, 119, 118, 121, 119, 120, 118, 121, 117, 121, 118, 120, 118, 120, 118, 121,
118, 120, 120, 119, 121, 117, 124, 109, 127, -35, -128, -105, -128, -113, -124,
-115, -122, -116, -121, -117, -121, -118, -120, -119, -119, -119, -119, -120,
-118, -119, -119, -120, -119, -120, -118, -120, -119, -119, -118, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119, -118, -119,
-120, -119, -120, -119, -120, -119, -120, -118, -120, -118, -120, -118, -120,
-118, -120, -115, -115, -111, -111, -109, -109, -109, -109, -110, -107, -109,
-98, -109, 26, 110, 100, 116, 109, 118, 114, 120, 117, 120, 118, 119, 120, 118,
119, 118, 120, 119, 120, 118, 120, 118, 119, 119, 120, 119, 116, 89, -60, -124,
-111, -122, -117, -121, -118, -121, -119, -120, -119, -120, -118, -119, -118,
-119, -119, -120, -118, -120, -118, -121, -117, -120, -118, -120, -117, -121,
-118, -121, -117, -119, -114, -115, -109, -105, -95, 79, 114, 105, 118, 112,
122, 115, 121, 116, 122, 117, 121, 117, 121, 118, 120, 118, 119, 119, 120, 120,
119, 119, 119, 120, 118, 119, 118, 119, 118, 119, 118, 120, 118, 119, 118, 120,
119, 120, 119, 118, 119, 119, 119, 119, 120, 119, 120, 119, 119, 120, 119, 119,
119, 119, 119, 119, 120, 118, 119, 119, 120, 118, 120, 119, 119, 120, 118, 120,
118, 120, 118, 120, 119, 120, 118, 120, 118, 121, 118, 120, 117, 121, 117, 121,
118, 120, 119, 118, 122, 112, 120, -63, -128, -109, -126, -114, -124, -115,
-123, -116, -122, -117, -120, -117, -121, -118, -120, -119, -118, -120, -119,
-120, -118, -120, -119, -119, -119, -119, -118, -120, -118, -120, -118, -119,
-118, -119, -119, -119, -118, -120, -119, -119, -119, -119, -119, -119, -119,
-118, -119, -119, -119, -118, -120, -118, -119, -120, -119, -119, -119, -118,
-119, -119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -120,
-119, -119, -119, -120, -119, -120, -119, -119, -118, -120, -119, -118, -119,
-118, -120, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -120, -119, -120, -120, -119, -120, -119, -120, -119, -117, -116, -114,
-112, -109, -106, -99, -101, 10, 106, 97, 116, 103, 121, 99, 124, 41, -123,
-109, -121, -118, -119, -119, -118, -119, -117, -120, -118, -119, -118, -120,
-118, -120, -119, -119, -119, -120, -119, -119, -120, -119, -120, -118, -121,
-117, -120, -113, -116, -105, -109, -80, };