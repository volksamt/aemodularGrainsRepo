#define DATA_LENGTH 512
#define DATA AKWF_distorted_0033

const PROGMEM int8_t DATA[DATA_LENGTH] = {52, 80, 86, 96, 98, 105, 106, 109,
110, 113, 113, 115, 115, 117, 116, 118, 117, 118, 118, 119, 118, 119, 119, 118,
120, 119, 119, 119, 119, 119, 119, 119, 118, 119, 118, 120, 119, 119, 119, 119,
119, 119, 119, 119, 118, 119, 118, 118, 119, 119, 119, 118, 118, 117, 118, 117,
118, 116, 117, 114, 115, 113, 113, 110, 109, 104, 102, 94, 87, 67, -35, -80,
-86, -96, -99, -103, -103, -107, -107, -109, -109, -110, -110, -111, -110, -111,
-111, -112, -112, -112, -112, -111, -111, -112, -111, -111, -110, -111, -111,
-109, -111, -110, -108, -108, -108, -106, -105, -105, -103, -102, -99, -98, -94,
-92, -86, -83, -73, -66, -24, 46, 68, 75, 81, 84, 88, 89, 91, 93, 94, 94, 95,
95, 94, 94, 93, 93, 91, 89, 88, 85, 81, 78, 71, 65, 35, -31, -65, -73, -80, -85,
-90, -94, -96, -98, -100, -101, -104, -105, -106, -107, -109, -109, -109, -110,
-111, -112, -112, -112, -112, -113, -113, -114, -113, -113, -114, -114, -113,
-114, -113, -115, -114, -114, -114, -115, -114, -113, -114, -113, -114, -113,
-113, -113, -113, -112, -111, -112, -111, -112, -111, -111, -110, -109, -109,
-108, -107, -106, -105, -104, -103, -101, -100, -97, -96, -92, -90, -85, -81,
-73, -67, -32, 38, 65, 73, 80, 84, 89, 91, 93, 95, 97, 99, 100, 101, 103, 103,
105, 104, 105, 106, 107, 107, 107, 107, 108, 108, 109, 109, 110, 109, 110, 110,
110, 110, 110, 110, 110, 109, 110, 110, 109, 108, 107, 107, 106, 106, 104, 103,
101, 102, 99, 97, 95, 93, 91, 88, 85, 80, 78, 70, 65, 46, 0, -40, -60, -65, -71,
-75, -77, -80, -83, -84, -86, -87, -89, -90, -91, -91, -92, -93, -93, -94, -94,
-93, -93, -93, -94, -94, -94, -94, -92, -92, -92, -91, -91, -89, -89, -88, -86,
-84, -82, -80, -77, -74, -71, -66, -61, -47, -16, 10, 32, 53, 60, 62, 66, 69,
72, 73, 74, 74, 73, 75, 75, 75, 75, 75, 75, 74, 74, 73, 72, 71, 69, 69, 66, 63,
60, 57, 55, 41, 21, 2, -17, -37, -54, -60, -64, -67, -69, -71, -73, -76, -76,
-79, -80, -81, -82, -85, -85, -86, -88, -89, -91, -92, -93, -94, -95, -95, -97,
-97, -98, -99, -100, -99, -101, -101, -101, -102, -102, -103, -103, -104, -104,
-103, -104, -103, -105, -104, -104, -105, -105, -105, -104, -104, -105, -105,
-104, -104, -104, -104, -103, -103, -103, -103, -103, -102, -101, -101, -100,
-99, -99, -99, -99, -98, -97, -97, -97, -96, -96, -95, -95, -95, -95, -93, -93,
-92, -91, -91, -90, -91, -90, -89, -89, -88, -87, -86, -86, -86, -83, -83, -82,
-83, -83, -83, -83, -83, -83, -83, -85, -85, -85, -86, -86, -86, -88, -89, -90,
-91, -93, -93, -94, -94, -96, -96, -96, -97, -97, -98, -100, -100, -102, -102,
-103, -103, -104, -104, -104, -104, -104, -104, -104, -104, -103, -103, -101,
-101, -99, -97, -92, -90, -81, -74, -38, };