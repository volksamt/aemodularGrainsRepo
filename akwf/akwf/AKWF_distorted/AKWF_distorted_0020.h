#define DATA_LENGTH 512
#define DATA AKWF_distorted_0020

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 14, 25, 34, 42, 49, 56, 63, 68, 73,
78, 82, 86, 90, 94, 96, 98, 99, 102, 104, 105, 107, 109, 109, 111, 111, 112,
113, 113, 114, 115, 116, 115, 116, 116, 117, 117, 118, 118, 118, 118, 118, 117,
119, 118, 119, 119, 119, 119, 118, 119, 119, 119, 119, 119, 120, 119, 119, 118,
119, 118, 118, 119, 119, 119, 119, 118, 118, 119, 118, 119, 118, 118, 118, 118,
119, 118, 118, 117, 117, 117, 118, 118, 118, 117, 118, 118, 117, 117, 117, 116,
116, 115, 116, 115, 115, 115, 114, 114, 114, 114, 114, 113, 113, 112, 112, 112,
112, 111, 110, 110, 110, 109, 108, 108, 107, 107, 106, 106, 106, 105, 103, 103,
102, 102, 101, 99, 99, 98, 96, 96, 95, 93, 92, 91, 89, 88, 87, 86, 84, 83, 81,
80, 78, 77, 77, 74, 73, 70, 70, 68, 65, 65, 63, 61, 60, 59, 57, 55, 54, 52, 50,
50, 48, 47, 46, 44, 44, 42, 42, 42, 40, 39, 38, 37, 38, 36, 35, 34, 34, 33, 32,
32, 31, 29, 29, 28, 28, 27, 27, 24, 24, 23, 22, 22, 20, 19, 17, 17, 16, 14, 13,
12, 10, 9, 7, 5, 4, 3, 1, -1, -2, -4, -5, -6, -9, -9, -10, -12, -13, -14, -16,
-17, -17, -19, -20, -22, -23, -24, -24, -26, -27, -27, -28, -30, -30, -31, -32,
-33, -33, -35, -35, -36, -37, -38, -39, -40, -41, -42, -42, -43, -44, -44, -45,
-46, -47, -47, -48, -49, -49, -51, -51, -53, -53, -53, -54, -56, -56, -57, -58,
-60, -60, -61, -62, -63, -63, -64, -65, -66, -66, -68, -68, -69, -70, -71, -72,
-73, -73, -74, -76, -76, -77, -78, -79, -80, -81, -82, -82, -83, -84, -85, -86,
-86, -87, -88, -88, -89, -90, -91, -90, -91, -93, -93, -95, -95, -96, -96, -97,
-96, -98, -98, -99, -99, -100, -100, -101, -101, -102, -102, -102, -102, -102,
-103, -103, -102, -103, -103, -103, -104, -103, -103, -103, -104, -104, -103,
-103, -103, -103, -103, -103, -103, -102, -101, -101, -100, -100, -99, -99, -98,
-97, -96, -97, -95, -95, -94, -93, -92, -92, -91, -90, -90, -89, -88, -88, -88,
-86, -86, -86, -84, -85, -83, -84, -83, -83, -82, -82, -82, -81, -82, -82, -83,
-81, -82, -83, -82, -83, -83, -83, -83, -84, -84, -85, -86, -86, -86, -87, -88,
-88, -88, -89, -90, -91, -91, -92, -93, -93, -94, -95, -96, -95, -97, -96, -97,
-98, -98, -99, -99, -101, -101, -101, -102, -102, -103, -103, -104, -103, -105,
-104, -105, -105, -105, -105, -106, -107, -107, -108, -107, -107, -108, -107,
-108, -108, -109, -108, -108, -109, -109, -108, -109, -109, -109, -109, -110,
-109, -109, -108, -108, -109, -109, -109, -109, -109, -109, -108, -107, -108,
-108, -107, -107, -106, -106, -105, -105, -104, -103, -103, -101, -100, -99,
-99, -97, -95, -95, -94, -92, -90, -87, -85, -83, -80, -76, -73, -69, -64, -60,
-54, -48, -41, -34, -25, -16, -5, };