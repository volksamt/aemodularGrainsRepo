#define DATA_LENGTH 512
#define DATA AKWF_vgsin_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 11, 9, 17, 25, 25, 23, 24, 24, 24,
24, 24, 24, 24, 24, 22, 25, 32, 37, 36, 36, 36, 36, 36, 35, 39, 46, 49, 47, 47,
50, 56, 60, 59, 59, 58, 59, 59, 59, 59, 59, 58, 59, 58, 63, 71, 72, 72, 72, 71,
72, 70, 71, 76, 80, 80, 80, 79, 84, 89, 89, 89, 89, 88, 89, 89, 90, 90, 89, 89,
88, 90, 94, 99, 98, 99, 98, 99, 98, 98, 99, 102, 104, 103, 102, 103, 108, 111,
110, 110, 110, 109, 109, 110, 109, 109, 110, 110, 109, 111, 114, 115, 114, 114,
114, 115, 115, 115, 115, 116, 115, 116, 116, 117, 117, 118, 117, 118, 117, 118,
118, 117, 118, 118, 117, 117, 118, 118, 117, 118, 117, 117, 117, 117, 118, 118,
116, 115, 116, 116, 116, 114, 112, 112, 112, 112, 112, 113, 113, 113, 113, 112,
113, 114, 112, 109, 107, 108, 108, 107, 108, 109, 108, 105, 103, 100, 102, 102,
100, 96, 94, 96, 95, 95, 95, 95, 95, 95, 95, 95, 95, 96, 91, 87, 86, 87, 87, 87,
87, 87, 87, 80, 74, 75, 77, 76, 71, 66, 66, 67, 67, 66, 67, 67, 66, 66, 67, 66,
68, 66, 59, 54, 55, 55, 56, 55, 55, 57, 52, 44, 41, 43, 44, 41, 33, 30, 32, 32,
32, 31, 32, 32, 32, 32, 31, 32, 33, 28, 20, 18, 19, 19, 19, 19, 20, 20, 12, 3,
4, 6, 5, -1, -8, -8, -7, -8, -8, -8, -8, -7, -8, -7, -8, -13, -20, -22, -21,
-21, -21, -20, -22, -20, -19, -23, -31, -36, -33, -32, -34, -43, -47, -46, -46,
-46, -46, -46, -46, -46, -46, -46, -47, -54, -58, -57, -57, -57, -56, -57, -57,
-56, -57, -62, -69, -69, -68, -67, -73, -78, -81, -79, -80, -80, -80, -79, -80,
-79, -79, -79, -82, -88, -90, -89, -89, -89, -90, -89, -89, -88, -89, -94, -98,
-97, -95, -97, -101, -105, -105, -105, -104, -105, -105, -105, -105, -105, -104,
-105, -107, -110, -110, -110, -110, -110, -109, -110, -109, -109, -111, -114,
-114, -114, -114, -114, -118, -117, -118, -118, -118, -118, -117, -117, -118,
-117, -117, -118, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119,
-119, -119, -119, -119, -119, -119, -118, -117, -118, -117, -117, -117, -117,
-117, -118, -117, -117, -116, -114, -112, -110, -112, -111, -111, -110, -111,
-111, -111, -111, -111, -112, -112, -110, -106, -105, -105, -105, -105, -105,
-105, -105, -104, -105, -105, -104, -99, -98, -98, -99, -99, -98, -98, -99, -96,
-91, -90, -90, -90, -91, -91, -86, -81, -80, -81, -81, -81, -80, -81, -80, -80,
-82, -82, -76, -70, -69, -70, -70, -69, -69, -70, -70, -64, -60, -60, -61, -61,
-61, -60, -52, -48, -49, -50, -49, -49, -49, -49, -49, -49, -50, -48, -39, -34,
-35, -35, -35, -34, -36, -36, -32, -24, -21, -22, -22, -22, -23, -19, -12, -10,
-11, -12, -11, -11, -12, -11, -10, -11, -12, -5, };