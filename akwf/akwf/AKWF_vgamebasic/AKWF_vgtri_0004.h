#define DATA_LENGTH 512
#define DATA AKWF_vgtri_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 9, 9, 8, 7, 8, 8, 8, 8, 8, 8, 8, 8,
8, 8, 9, 7, 8, 9, 8, 8, 8, 8, 7, 8, 14, 23, 31, 35, 34, 34, 34, 34, 34, 34, 34,
33, 34, 34, 33, 33, 33, 34, 34, 34, 34, 33, 33, 34, 33, 38, 47, 47, 48, 56, 60,
58, 58, 59, 58, 58, 58, 58, 57, 58, 59, 58, 58, 57, 58, 58, 58, 58, 58, 58, 57,
57, 63, 71, 71, 72, 81, 86, 84, 83, 84, 83, 83, 84, 84, 84, 83, 84, 84, 84, 83,
84, 84, 84, 84, 84, 83, 83, 83, 89, 97, 96, 98, 108, 110, 109, 109, 109, 110,
109, 109, 109, 109, 109, 110, 110, 109, 109, 109, 109, 109, 109, 110, 109, 109,
109, 113, 116, 118, 112, 104, 102, 103, 103, 104, 103, 102, 103, 103, 103, 103,
103, 103, 103, 103, 103, 103, 104, 103, 103, 104, 99, 93, 91, 92, 93, 88, 79,
78, 79, 79, 79, 79, 79, 80, 78, 79, 78, 79, 80, 79, 79, 78, 79, 79, 78, 79, 80,
74, 66, 66, 66, 67, 62, 53, 52, 53, 52, 53, 54, 53, 53, 53, 53, 52, 54, 53, 54,
53, 53, 53, 52, 53, 53, 55, 48, 39, 39, 40, 42, 35, 27, 26, 28, 28, 27, 28, 27,
28, 28, 28, 27, 28, 28, 27, 28, 28, 28, 27, 28, 27, 27, 22, 14, 14, 13, 3, 1, 2,
2, 2, 1, 1, 2, 1, 2, 2, 2, 2, 1, 2, 2, 2, 1, 2, 2, 2, -1, -8, -8, -8, -8, -7,
-8, -13, -22, -21, -20, -21, -21, -21, -20, -20, -20, -21, -21, -21, -20, -21,
-20, -21, -21, -21, -20, -25, -33, -34, -34, -34, -33, -33, -40, -47, -48, -47,
-47, -47, -46, -46, -47, -46, -46, -46, -46, -47, -47, -46, -46, -47, -46, -46,
-52, -59, -60, -60, -60, -59, -59, -67, -73, -73, -72, -72, -73, -72, -72, -72,
-73, -72, -73, -72, -72, -73, -73, -72, -71, -75, -84, -86, -86, -86, -86, -85,
-85, -86, -93, -98, -97, -97, -97, -96, -96, -97, -96, -97, -97, -97, -97, -97,
-97, -97, -96, -96, -100, -108, -111, -109, -109, -109, -110, -108, -109, -116,
-119, -119, -119, -118, -120, -119, -119, -119, -120, -119, -119, -119, -119,
-119, -118, -118, -119, -115, -107, -105, -107, -106, -106, -106, -107, -105,
-97, -93, -93, -93, -93, -94, -93, -94, -93, -93, -93, -93, -93, -93, -94, -93,
-94, -94, -89, -81, -80, -80, -80, -80, -81, -82, -79, -70, -66, -66, -68, -68,
-67, -67, -67, -67, -68, -67, -68, -67, -68, -68, -70, -66, -57, -54, -54, -54,
-55, -55, -55, -55, -56, -54, -45, -43, -43, -43, -43, -44, -44, -43, -43, -43,
-43, -43, -44, -43, -44, -45, -41, -32, -29, -31, -30, -30, -30, -30, -31, -32,
-28, -20, -17, -18, -18, -17, -18, -18, -17, -18, -18, -17, -18, -18, -18, -17,
-20, -15, -6, -3, -6, -5, -5, -5, -4, -5, -6, -3, };