#define DATA_LENGTH 512
#define DATA AKWF_vgsqu_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {54, 122, 104, 100, 102, 103, 103, 103,
102, 102, 103, 102, 102, 102, 103, 107, 111, 110, 110, 110, 110, 109, 110, 110,
110, 109, 109, 111, 112, 112, 111, 112, 112, 112, 112, 111, 111, 111, 111, 112,
111, 111, 111, 112, 111, 111, 111, 112, 111, 112, 112, 112, 111, 111, 111, 111,
112, 111, 111, 112, 111, 112, 112, 112, 112, 111, 111, 111, 111, 111, 111, 112,
111, 112, 111, 112, 112, 112, 112, 112, 112, 111, 112, 111, 112, 112, 112, 111,
112, 111, 112, 111, 111, 111, 111, 111, 112, 112, 112, 112, 111, 111, 111, 111,
111, 112, 112, 112, 111, 111, 112, 111, 112, 112, 112, 112, 112, 112, 112, 111,
112, 112, 111, 111, 111, 111, 112, 112, 111, 111, 112, 111, 112, 111, 111, 112,
111, 111, 112, 112, 112, 112, 112, 112, 112, 111, 112, 111, 111, 112, 111, 111,
111, 112, 112, 112, 111, 112, 112, 111, 111, 111, 112, 112, 111, 112, 111, 112,
111, 112, 112, 112, 111, 112, 111, 112, 112, 111, 112, 111, 111, 112, 112, 111,
112, 111, 112, 112, 111, 112, 111, 112, 111, 111, 111, 111, 111, 112, 111, 111,
112, 112, 112, 112, 111, 112, 112, 111, 111, 111, 111, 112, 112, 112, 112, 112,
111, 112, 111, 111, 112, 112, 112, 112, 111, 111, 112, 111, 112, 111, 112, 111,
111, 111, 113, 111, 112, 111, 112, 108, 106, 108, 121, 80, -63, -123, -115,
-118, -118, -120, -118, -120, -119, -120, -119, -119, -118, -120, -119, -120,
-119, -119, -118, -119, -119, -119, -119, -119, -119, -119, -119, -115, -115,
-114, -114, -115, -115, -114, -114, -114, -115, -114, -115, -115, -115, -115,
-114, -114, -113, -112, -113, -113, -113, -113, -113, -113, -113, -113, -113,
-112, -113, -113, -113, -113, -112, -114, -113, -113, -113, -112, -113, -113,
-113, -113, -114, -113, -114, -113, -114, -113, -114, -113, -112, -114, -114,
-113, -113, -112, -113, -113, -113, -113, -113, -113, -113, -112, -113, -113,
-113, -113, -113, -113, -114, -113, -113, -112, -113, -113, -113, -113, -113,
-113, -113, -112, -112, -113, -113, -113, -113, -113, -113, -114, -113, -113,
-113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -114,
-113, -113, -113, -113, -113, -112, -113, -113, -113, -113, -113, -114, -113,
-113, -113, -112, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113,
-113, -113, -113, -112, -113, -113, -113, -112, -113, -113, -113, -112, -114,
-113, -113, -113, -113, -113, -113, -114, -114, -113, -113, -113, -113, -113,
-114, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113,
-113, -114, -113, -114, -113, -114, -112, -113, -113, -113, -113, -113, -113,
-113, -113, -113, -113, -113, -114, -113, -113, -113, -113, -113, -114, -113,
-113, -113, -114, -113, -112, -112, -113, -113, -113, -113, -113, -112, -113,
-112, -113, -113, -113, -113, -112, -114, -116, -117, -115, -117, -116, -116,
-116, -116, -116, -115, -116, -116, -115, -116, -116, -116, -117, -115, -116,
-115, -114, -115, -123, -63, };