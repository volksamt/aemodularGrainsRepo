#define DATA_LENGTH 512
#define DATA AKWF_vgsaw_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {4, 7, 5, 5, 6, 6, 6, 9, 10, 9, 9, 9,
10, 10, 9, 10, 10, 9, 10, 10, 10, 10, 9, 9, 12, 16, 17, 16, 16, 16, 15, 16, 15,
16, 15, 18, 20, 20, 19, 19, 20, 20, 19, 20, 19, 20, 20, 20, 20, 19, 21, 25, 26,
26, 25, 25, 25, 25, 24, 25, 26, 24, 26, 29, 32, 31, 31, 30, 31, 31, 31, 30, 31,
31, 31, 33, 35, 35, 35, 36, 34, 36, 35, 35, 35, 35, 34, 37, 41, 41, 40, 44, 45,
45, 44, 44, 45, 45, 44, 45, 44, 45, 44, 45, 45, 45, 45, 44, 44, 45, 45, 45, 48,
50, 50, 51, 51, 51, 50, 53, 55, 55, 54, 54, 55, 54, 55, 54, 54, 54, 54, 55, 55,
55, 55, 54, 56, 59, 61, 60, 61, 59, 60, 61, 60, 60, 61, 63, 65, 64, 64, 64, 67,
69, 70, 70, 69, 70, 70, 70, 69, 71, 69, 70, 70, 70, 70, 70, 70, 70, 71, 70, 70,
71, 74, 78, 80, 80, 79, 80, 80, 80, 80, 79, 81, 80, 80, 80, 80, 80, 80, 80, 81,
80, 79, 80, 79, 80, 79, 82, 85, 86, 86, 87, 90, 90, 89, 89, 89, 89, 89, 89, 90,
89, 90, 90, 90, 90, 90, 90, 89, 90, 89, 90, 93, 95, 96, 94, 95, 95, 95, 96, 97,
97, 97, 97, 97, 97, 96, 98, 96, 97, 96, 97, 96, 95, 99, 118, 56, -82, -122,
-118, -118, -119, -120, -119, -119, -118, -120, -109, -98, -97, -99, -98, -98,
-98, -97, -97, -98, -98, -98, -98, -98, -97, -95, -96, -95, -96, -95, -95, -95,
-96, -95, -95, -96, -94, -90, -87, -86, -85, -86, -85, -86, -85, -85, -85, -85,
-85, -85, -85, -85, -86, -86, -86, -85, -86, -85, -85, -86, -85, -83, -79, -80,
-80, -80, -77, -76, -75, -76, -76, -76, -76, -76, -75, -75, -75, -76, -76, -76,
-76, -75, -76, -75, -76, -75, -70, -69, -69, -71, -71, -70, -70, -70, -69, -66,
-66, -65, -65, -65, -66, -65, -65, -65, -65, -66, -66, -66, -65, -65, -66, -66,
-61, -59, -60, -60, -60, -60, -60, -60, -60, -62, -58, -54, -55, -55, -54, -55,
-55, -54, -55, -54, -55, -55, -55, -55, -53, -50, -50, -50, -51, -51, -51, -50,
-50, -51, -51, -51, -50, -45, -43, -41, -41, -40, -41, -41, -41, -40, -40, -40,
-41, -40, -41, -41, -41, -41, -41, -41, -40, -41, -40, -41, -40, -38, -34, -34,
-36, -36, -34, -31, -30, -31, -30, -31, -31, -30, -31, -31, -31, -31, -31, -31,
-31, -31, -31, -31, -31, -30, -26, -24, -25, -25, -25, -25, -25, -25, -24, -21,
-20, -21, -21, -20, -21, -21, -21, -21, -21, -21, -21, -21, -21, -21, -19, -16,
-15, -16, -15, -16, -15, -16, -15, -15, -15, -16, -14, -11, -11, -12, -10, -11,
-11, -12, -11, -11, -12, -12, -11, -7, -4, -2, -1, -1, -2, -1, -1, -1, -2, -2,
-2, -1, -2, -2, 0, };