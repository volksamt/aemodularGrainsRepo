#define DATA_LENGTH 512
#define DATA AKWF_vgsqu_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {60, 123, 109, 104, 107, 107, 107, 107,
108, 107, 107, 107, 107, 108, 109, 110, 110, 110, 110, 109, 109, 110, 110, 110,
110, 110, 111, 109, 110, 111, 112, 112, 112, 111, 112, 111, 111, 112, 112, 111,
111, 111, 112, 112, 111, 112, 111, 112, 111, 111, 112, 112, 111, 111, 112, 112,
111, 111, 111, 111, 112, 112, 111, 112, 112, 111, 111, 112, 112, 112, 112, 111,
111, 112, 111, 111, 112, 111, 112, 112, 112, 112, 112, 112, 111, 112, 111, 111,
111, 111, 112, 111, 111, 112, 111, 111, 112, 111, 111, 112, 111, 112, 112, 112,
112, 111, 111, 112, 112, 111, 112, 112, 111, 111, 112, 112, 112, 111, 112, 111,
111, 112, 111, 111, 112, 111, 112, 112, 112, 111, 112, 111, 111, 112, 111, 111,
111, 111, 112, 112, 112, 112, 112, 112, 112, 112, 112, 112, 111, 111, 112, 111,
112, 111, 111, 111, 111, 111, 112, 112, 111, 112, 112, 112, 111, 112, 111, 111,
111, 111, 112, 111, 111, 111, 112, 112, 111, 111, 111, 112, 111, 112, 111, 112,
112, 111, 112, 112, 112, 111, 112, 111, 111, 111, 111, 112, 111, 112, 111, 111,
112, 111, 112, 111, 111, 112, 112, 111, 111, 111, 111, 112, 112, 112, 112, 111,
111, 111, 111, 111, 112, 111, 112, 112, 112, 111, 111, 111, 111, 112, 113, 113,
113, 113, 113, 115, 114, 115, 115, 115, 114, 115, 115, 114, 114, 114, 115, 115,
115, 115, 114, 114, 115, 114, 115, 112, 114, 119, 107, -18, -119, -117, -116,
-110, -112, -111, -112, -111, -111, -111, -111, -112, -112, -112, -111, -111,
-111, -112, -111, -112, -112, -112, -111, -112, -112, -112, -112, -113, -113,
-113, -113, -113, -113, -113, -113, -113, -113, -113, -114, -114, -113, -113,
-113, -113, -114, -113, -113, -113, -114, -113, -113, -113, -113, -113, -113,
-113, -113, -113, -113, -113, -112, -113, -112, -113, -113, -114, -114, -113,
-112, -113, -113, -112, -113, -113, -113, -113, -113, -113, -113, -113, -113,
-112, -113, -113, -113, -113, -113, -113, -113, -113, -114, -114, -113, -113,
-113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -114, -114,
-113, -113, -113, -113, -112, -113, -113, -113, -113, -114, -113, -113, -113,
-113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -112,
-113, -113, -113, -114, -113, -113, -112, -113, -113, -113, -113, -113, -113,
-114, -113, -113, -113, -113, -113, -113, -112, -112, -112, -113, -113, -114,
-113, -112, -113, -113, -113, -113, -113, -113, -113, -113, -112, -113, -113,
-113, -113, -113, -113, -113, -112, -113, -113, -113, -112, -113, -113, -113,
-113, -114, -113, -113, -114, -113, -113, -113, -114, -112, -113, -113, -113,
-113, -112, -113, -113, -113, -113, -112, -112, -114, -113, -113, -113, -113,
-113, -113, -112, -113, -114, -113, -113, -113, -113, -113, -113, -112, -113,
-115, -115, -115, -115, -115, -115, -114, -115, -114, -115, -115, -114, -115,
-115, -114, -115, -115, -115, -115, -116, -116, -116, -117, -115, -114, -116,
-122, -55, };