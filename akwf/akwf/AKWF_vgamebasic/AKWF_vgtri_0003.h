#define DATA_LENGTH 512
#define DATA AKWF_vgtri_0003

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 10, 13, 13, 12, 13, 12, 13, 13, 13,
13, 12, 14, 13, 13, 12, 12, 13, 12, 13, 13, 12, 13, 12, 18, 25, 25, 27, 37, 40,
38, 38, 38, 39, 38, 38, 38, 38, 38, 38, 39, 38, 37, 38, 38, 38, 39, 39, 38, 38,
38, 38, 38, 46, 56, 64, 67, 66, 64, 65, 65, 65, 66, 65, 65, 65, 65, 66, 65, 66,
66, 65, 65, 65, 66, 65, 64, 66, 65, 66, 64, 67, 77, 79, 78, 78, 78, 79, 78, 78,
78, 77, 77, 83, 93, 93, 92, 92, 93, 92, 92, 93, 92, 92, 92, 92, 92, 91, 95, 104,
106, 105, 105, 105, 105, 105, 105, 105, 105, 105, 105, 105, 104, 108, 116, 119,
117, 118, 118, 117, 117, 118, 117, 118, 118, 113, 104, 102, 103, 104, 104, 104,
103, 103, 104, 104, 104, 103, 104, 104, 101, 92, 90, 90, 91, 91, 90, 91, 91, 90,
91, 92, 86, 78, 77, 77, 78, 78, 78, 78, 79, 78, 78, 79, 78, 78, 77, 79, 80, 71,
63, 63, 64, 64, 63, 64, 63, 64, 65, 59, 51, 50, 51, 51, 51, 50, 51, 51, 51, 50,
51, 51, 51, 51, 51, 51, 51, 50, 41, 37, 38, 38, 38, 38, 39, 39, 31, 23, 23, 24,
24, 24, 24, 24, 24, 23, 24, 24, 23, 24, 23, 24, 24, 25, 23, 14, 10, 11, 11, 11,
11, 11, 12, 5, -3, -3, -1, -2, -1, -2, -1, -2, -2, -2, -2, -1, -1, -2, -2, -1,
-1, -1, 0, -6, -14, -15, -14, -14, -13, -14, -21, -28, -27, -27, -28, -27, -27,
-27, -27, -27, -27, -27, -27, -27, -27, -27, -27, -27, -27, -27, -26, -27, -35,
-41, -40, -39, -39, -48, -55, -55, -53, -54, -54, -54, -53, -54, -54, -54, -53,
-55, -54, -54, -54, -54, -54, -54, -54, -53, -54, -62, -68, -67, -66, -67, -74,
-80, -80, -79, -80, -79, -80, -79, -80, -79, -80, -80, -80, -80, -79, -79, -80,
-80, -79, -80, -80, -80, -78, -83, -92, -94, -94, -102, -108, -107, -107, -106,
-106, -106, -107, -107, -106, -107, -106, -107, -107, -107, -107, -107, -107,
-106, -107, -107, -107, -106, -106, -106, -114, -118, -110, -104, -105, -105,
-106, -104, -105, -105, -105, -105, -105, -105, -105, -105, -104, -105, -104,
-105, -104, -105, -106, -104, -105, -106, -105, -99, -90, -82, -78, -79, -79,
-80, -79, -80, -79, -79, -80, -79, -80, -79, -80, -80, -79, -80, -80, -80, -80,
-71, -64, -65, -66, -65, -65, -65, -65, -65, -65, -65, -65, -64, -65, -66, -66,
-65, -66, -66, -67, -59, -52, -52, -52, -52, -52, -52, -52, -53, -53, -52, -53,
-54, -50, -42, -39, -40, -39, -40, -40, -39, -39, -40, -40, -40, -39, -40, -41,
-38, -29, -25, -25, -25, -25, -26, -26, -25, -26, -26, -26, -23, -13, -12, -13,
-13, -13, -12, -12, -12, -13, -12, -12, -13, -13, -12, -13, -14, -9, 0, 1, 0, 0,
0, 0, 0, 0, -2, };