#define DATA_LENGTH 512
#define DATA AKWF_vgsin_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 18, 23, 21, 20, 21, 20, 20, 20, 21,
21, 21, 21, 21, 21, 21, 21, 19, 20, 31, 39, 39, 37, 38, 39, 38, 36, 42, 53, 56,
54, 54, 54, 54, 54, 54, 54, 54, 54, 55, 55, 53, 57, 65, 70, 69, 68, 68, 68, 67,
69, 69, 68, 67, 72, 82, 84, 82, 83, 83, 83, 82, 82, 83, 83, 82, 88, 94, 94, 93,
93, 93, 94, 93, 94, 94, 93, 94, 99, 104, 103, 106, 110, 110, 109, 110, 109, 109,
110, 109, 109, 110, 109, 109, 109, 109, 109, 109, 110, 110, 109, 111, 114, 115,
114, 114, 115, 114, 116, 116, 117, 117, 117, 117, 117, 118, 118, 117, 117, 117,
118, 117, 117, 117, 117, 117, 117, 118, 118, 117, 118, 117, 118, 118, 118, 116,
115, 115, 115, 114, 115, 114, 114, 114, 114, 114, 114, 115, 115, 115, 112, 108,
107, 108, 108, 108, 108, 108, 107, 107, 108, 108, 104, 100, 99, 100, 100, 99,
100, 100, 100, 101, 101, 100, 94, 89, 91, 91, 90, 90, 90, 91, 90, 89, 91, 90,
80, 78, 79, 71, 64, 65, 65, 65, 65, 65, 65, 65, 65, 65, 65, 65, 65, 64, 65, 65,
65, 66, 66, 59, 50, 48, 49, 49, 50, 49, 41, 31, 32, 34, 33, 33, 33, 34, 33, 33,
33, 33, 33, 33, 33, 35, 33, 21, 15, 15, 16, 16, 16, 16, 16, 17, 16, 5, -3, -2,
-1, -1, -2, -1, -1, -1, -1, -2, -1, 0, -7, -17, -19, -17, -17, -18, -17, -17,
-18, -18, -16, -17, -24, -37, -46, -52, -52, -51, -51, -51, -50, -51, -51, -51,
-50, -51, -50, -51, -50, -50, -51, -51, -50, -51, -51, -50, -49, -55, -65, -67,
-67, -76, -82, -82, -80, -81, -81, -81, -82, -81, -81, -81, -81, -81, -82, -81,
-81, -81, -81, -81, -81, -88, -94, -94, -94, -94, -92, -95, -100, -104, -104,
-102, -103, -103, -103, -103, -104, -103, -102, -103, -104, -103, -103, -102,
-105, -110, -111, -110, -111, -111, -111, -111, -111, -110, -112, -115, -116,
-116, -116, -116, -116, -115, -116, -117, -119, -119, -119, -119, -119, -119,
-119, -119, -118, -120, -118, -118, -119, -120, -118, -119, -118, -118, -116,
-115, -115, -116, -115, -116, -116, -116, -116, -116, -116, -116, -116, -116,
-116, -116, -116, -116, -116, -116, -116, -115, -112, -111, -112, -112, -110,
-106, -104, -105, -105, -105, -105, -105, -105, -105, -104, -104, -105, -105,
-105, -105, -104, -105, -105, -100, -95, -95, -95, -95, -96, -95, -97, -92, -85,
-82, -84, -84, -84, -84, -85, -84, -83, -83, -84, -84, -84, -84, -84, -85, -78,
-70, -69, -70, -70, -70, -69, -69, -70, -71, -65, -56, -53, -54, -53, -53, -54,
-54, -53, -54, -54, -54, -55, -54, -43, -37, -37, -38, -38, -38, -38, -38, -38,
-38, -40, -37, -26, -13, -3, -2, -3, -4, -3, -3, -3, -4, -3, -4, -3, -3, -3, -4,
-3, -3, -3, -4, -4, -4, -4, -1, 2, 3, 1, -1, };