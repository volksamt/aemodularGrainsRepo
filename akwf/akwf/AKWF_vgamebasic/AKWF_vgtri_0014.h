#define DATA_LENGTH 512
#define DATA AKWF_vgtri_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 3, 3, 4, 6, 6, 6, 9, 9, 10, 12,
12, 12, 14, 17, 16, 16, 18, 20, 18, 19, 19, 22, 26, 27, 28, 27, 27, 27, 29, 30,
30, 32, 33, 33, 34, 37, 36, 36, 39, 40, 40, 41, 43, 45, 47, 45, 46, 46, 48, 49,
49, 50, 52, 52, 53, 55, 56, 55, 57, 58, 59, 59, 61, 62, 62, 61, 62, 65, 64, 64,
68, 70, 70, 70, 73, 73, 73, 74, 76, 76, 77, 79, 80, 79, 82, 82, 82, 83, 85, 86,
86, 89, 90, 89, 90, 92, 92, 92, 94, 96, 95, 98, 99, 99, 99, 102, 101, 101, 105,
105, 105, 105, 108, 108, 108, 108, 110, 111, 112, 111, 115, 116, 116, 116, 115,
113, 113, 113, 113, 113, 110, 110, 109, 109, 106, 107, 106, 103, 104, 103, 102,
100, 100, 100, 97, 97, 97, 95, 94, 93, 93, 91, 88, 87, 87, 88, 87, 87, 84, 85,
84, 81, 81, 82, 79, 77, 77, 78, 78, 76, 75, 75, 74, 70, 69, 69, 68, 67, 67, 65,
64, 63, 64, 61, 61, 60, 60, 57, 58, 56, 54, 53, 54, 52, 51, 51, 50, 48, 48, 47,
46, 44, 44, 43, 41, 42, 42, 38, 38, 38, 36, 35, 35, 35, 32, 32, 32, 33, 32, 29,
28, 29, 26, 24, 24, 24, 21, 20, 21, 19, 18, 18, 17, 13, 12, 10, 11, 11, 11, 10,
8, 8, 7, 5, 4, 5, 3, 1, 2, 1, -2, -1, -2, -3, -3, -3, -4, -7, -7, -7, -9, -11,
-12, -13, -13, -13, -12, -13, -15, -16, -15, -17, -20, -20, -20, -23, -25, -24,
-25, -26, -26, -27, -30, -30, -29, -32, -33, -33, -34, -36, -37, -36, -39, -39,
-39, -41, -42, -43, -43, -45, -46, -46, -47, -50, -49, -50, -52, -53, -52, -54,
-55, -55, -56, -58, -59, -59, -61, -62, -62, -62, -61, -65, -67, -67, -68, -69,
-69, -70, -72, -73, -74, -74, -76, -76, -77, -78, -80, -80, -81, -83, -82, -83,
-85, -87, -88, -89, -88, -89, -90, -93, -92, -92, -94, -96, -95, -97, -99, -99,
-99, -101, -102, -102, -104, -105, -104, -105, -105, -107, -108, -107, -109,
-113, -113, -113, -114, -116, -116, -117, -119, -119, -118, -117, -116, -116,
-114, -112, -113, -112, -110, -109, -109, -107, -106, -106, -105, -103, -103,
-103, -102, -100, -100, -99, -96, -97, -97, -94, -94, -94, -92, -91, -90, -90,
-87, -87, -87, -88, -87, -84, -84, -84, -81, -79, -80, -79, -77, -74, -73, -72,
-73, -74, -71, -70, -70, -69, -67, -67, -67, -64, -63, -63, -63, -61, -60, -60,
-58, -57, -58, -56, -55, -54, -54, -51, -50, -48, -47, -48, -48, -47, -44, -44,
-45, -43, -41, -41, -41, -41, -40, -37, -38, -36, -34, -33, -34, -31, -30, -30,
-29, -27, -27, -27, -24, -23, -24, -22, -20, -20, -20, -18, -18, -17, -16, -14,
-14, -12, -12, -11, -11, -9, -7, -9, -7, -5, -4, -4, -1, -2, -2, -1, -1, 0, };