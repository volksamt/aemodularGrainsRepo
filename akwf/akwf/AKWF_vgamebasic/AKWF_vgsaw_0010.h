#define DATA_LENGTH 512
#define DATA AKWF_vgsaw_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 2, 4, 3, 3, 3, 2, 4, 6, 6, 7, 6, 6,
5, 8, 10, 9, 10, 12, 13, 14, 13, 14, 14, 13, 13, 13, 12, 15, 17, 16, 16, 16, 16,
16, 18, 20, 19, 19, 20, 19, 21, 23, 23, 23, 24, 27, 27, 26, 27, 27, 27, 26, 26,
28, 30, 30, 30, 30, 29, 30, 32, 33, 33, 33, 34, 32, 33, 36, 36, 37, 35, 36, 39,
40, 40, 40, 40, 40, 39, 40, 41, 43, 43, 44, 43, 43, 43, 44, 47, 47, 46, 47, 45,
46, 48, 50, 50, 49, 50, 51, 53, 53, 52, 53, 53, 53, 52, 53, 55, 57, 56, 56, 56,
56, 57, 59, 60, 60, 59, 59, 60, 60, 62, 62, 62, 62, 64, 66, 66, 66, 67, 66, 67,
65, 66, 67, 69, 70, 69, 70, 69, 69, 72, 72, 72, 72, 73, 72, 73, 75, 76, 77, 75,
76, 78, 79, 79, 79, 79, 79, 80, 80, 81, 81, 82, 81, 81, 81, 83, 84, 85, 84, 84,
83, 84, 87, 88, 87, 88, 87, 87, 88, 91, 91, 91, 91, 91, 91, 91, 93, 94, 94, 96,
97, 98, 98, 98, 98, 97, 97, 98, 97, 99, 101, 101, 101, 101, 100, 101, 103, 104,
104, 104, 104, 104, 104, 106, 108, 107, 106, 107, 107, 108, 109, 112, 110, 111,
110, 111, 111, 112, 112, 112, 112, 113, 113, 112, 114, 114, 114, 114, 115, 114,
113, 110, 111, 109, 109, 115, 121, 35, -97, -122, -111, -111, -113, -116, -116,
-116, -116, -116, -115, -117, -119, -118, -114, -114, -114, -114, -114, -114,
-114, -113, -113, -115, -114, -112, -111, -110, -110, -110, -111, -111, -110,
-107, -107, -108, -108, -107, -108, -105, -103, -102, -101, -100, -100, -101,
-100, -100, -101, -101, -101, -101, -100, -97, -98, -97, -98, -98, -97, -96,
-95, -94, -94, -93, -95, -94, -93, -90, -89, -88, -87, -88, -88, -88, -87, -88,
-88, -88, -88, -87, -86, -84, -84, -85, -84, -84, -84, -82, -82, -82, -82, -81,
-81, -81, -78, -77, -74, -74, -74, -75, -74, -75, -75, -74, -75, -74, -72, -71,
-71, -71, -71, -71, -70, -69, -67, -68, -68, -68, -68, -67, -65, -64, -65, -63,
-61, -61, -60, -62, -61, -61, -61, -62, -62, -60, -58, -58, -58, -58, -57, -58,
-56, -55, -54, -55, -54, -55, -55, -53, -51, -52, -50, -48, -48, -48, -48, -48,
-48, -49, -49, -48, -48, -45, -45, -45, -45, -45, -44, -44, -42, -42, -41, -41,
-41, -41, -41, -38, -38, -39, -36, -34, -35, -34, -35, -35, -35, -35, -35, -35,
-33, -31, -32, -31, -32, -33, -31, -29, -28, -28, -28, -28, -27, -25, -24, -25,
-25, -24, -24, -23, -23, -23, -23, -23, -24, -24, -21, -20, -19, -19, -20, -20,
-20, -17, -16, -16, -17, -16, -17, -16, -14, -12, -13, -13, -13, -11, -10, -11,
-10, -10, -9, -10, -10, -9, -7, -6, -6, -7, -6, -7, -6, -4, -3, -3, -4, -4, -4,
-2, -1, 0, -1, 0, };