#define DATA_LENGTH 512
#define DATA AKWF_vgtri_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {6, 11, 10, 10, 10, 10, 9, 9, 13, 20,
23, 21, 21, 20, 22, 21, 21, 21, 21, 21, 21, 21, 21, 22, 21, 22, 29, 36, 34, 34,
34, 34, 34, 34, 33, 33, 38, 45, 47, 45, 45, 45, 46, 46, 46, 46, 46, 46, 46, 45,
49, 57, 58, 57, 57, 57, 57, 57, 57, 57, 57, 56, 59, 67, 74, 79, 81, 80, 79, 79,
80, 80, 80, 80, 79, 81, 80, 80, 80, 80, 80, 80, 80, 80, 80, 79, 80, 86, 92, 92,
90, 91, 96, 102, 104, 103, 103, 103, 103, 102, 103, 103, 102, 102, 103, 102,
103, 103, 103, 102, 102, 106, 113, 115, 114, 114, 114, 114, 114, 114, 115, 116,
116, 116, 115, 116, 116, 115, 116, 116, 116, 116, 116, 116, 116, 115, 108, 104,
105, 100, 94, 92, 93, 94, 93, 92, 93, 92, 93, 93, 93, 93, 93, 92, 93, 93, 93,
93, 93, 94, 89, 82, 81, 82, 82, 82, 82, 81, 81, 82, 81, 81, 82, 82, 78, 71, 63,
56, 56, 57, 58, 58, 56, 57, 57, 58, 57, 56, 57, 58, 56, 57, 57, 57, 57, 58, 57,
58, 56, 49, 44, 46, 47, 46, 40, 34, 34, 34, 35, 34, 34, 34, 34, 35, 34, 34, 35,
35, 35, 35, 34, 34, 35, 29, 23, 22, 22, 23, 23, 23, 24, 23, 16, 11, 11, 12, 11,
12, 12, 12, 11, 12, 12, 11, 11, 12, 12, 10, 2, -1, 0, 0, 0, 0, -1, 0, 0, 0, 1,
0, -6, -10, -11, -10, -10, -10, -10, -10, -10, -10, -9, -10, -15, -21, -22, -20,
-22, -21, -21, -22, -20, -21, -21, -20, -25, -32, -33, -32, -40, -45, -44, -44,
-44, -44, -44, -44, -44, -44, -44, -45, -44, -44, -44, -44, -44, -44, -44, -43,
-45, -51, -56, -56, -56, -56, -54, -56, -63, -68, -67, -67, -67, -67, -67, -66,
-66, -67, -66, -67, -67, -68, -67, -68, -66, -67, -67, -74, -81, -80, -79, -80,
-80, -80, -79, -82, -88, -93, -92, -92, -91, -91, -91, -91, -91, -91, -92, -92,
-91, -91, -90, -95, -102, -104, -103, -102, -104, -103, -102, -102, -103, -103,
-101, -104, -112, -115, -115, -114, -114, -114, -114, -114, -114, -114, -114,
-114, -117, -119, -119, -119, -119, -119, -119, -119, -119, -119, -118, -119,
-114, -108, -108, -106, -98, -95, -96, -97, -96, -96, -96, -95, -96, -96, -96,
-96, -95, -97, -96, -97, -97, -96, -97, -96, -94, -87, -84, -84, -85, -85, -85,
-84, -75, -73, -74, -73, -74, -74, -74, -73, -74, -73, -73, -73, -73, -73, -73,
-73, -74, -68, -61, -62, -62, -62, -62, -62, -61, -62, -63, -60, -52, -50, -50,
-51, -51, -51, -51, -50, -50, -51, -51, -51, -52, -48, -41, -38, -39, -39, -39,
-39, -39, -39, -39, -40, -39, -40, -40, -37, -29, -27, -28, -28, -28, -28, -27,
-27, -28, -28, -29, -26, -17, -13, -14, -15, -14, -15, -15, -14, -14, -15, -16,
-15, -8, -3, -4, 0, };