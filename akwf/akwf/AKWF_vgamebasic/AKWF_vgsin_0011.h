#define DATA_LENGTH 512
#define DATA AKWF_vgsin_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 2, 1, 1, 1, 4, 11, 11, 11, 10,
11, 10, 15, 20, 19, 18, 19, 23, 28, 30, 29, 29, 28, 28, 32, 37, 42, 45, 44, 44,
45, 44, 45, 45, 44, 44, 49, 52, 53, 52, 52, 57, 61, 61, 60, 60, 60, 61, 65, 68,
66, 66, 67, 72, 75, 75, 75, 75, 73, 76, 79, 79, 79, 78, 80, 85, 88, 88, 88, 87,
87, 88, 92, 93, 92, 92, 93, 97, 98, 98, 100, 102, 102, 101, 102, 101, 101, 101,
103, 106, 106, 106, 106, 106, 106, 108, 110, 110, 109, 109, 111, 112, 113, 113,
113, 112, 113, 113, 114, 114, 114, 115, 115, 115, 116, 116, 116, 116, 116, 116,
117, 117, 118, 118, 117, 118, 117, 117, 118, 117, 117, 117, 118, 117, 117, 116,
115, 115, 116, 117, 116, 117, 116, 115, 115, 114, 114, 114, 113, 112, 113, 113,
113, 114, 112, 110, 109, 109, 110, 110, 107, 104, 103, 102, 103, 104, 104, 103,
103, 103, 104, 102, 100, 97, 98, 98, 99, 99, 97, 94, 93, 94, 95, 92, 88, 87, 88,
87, 86, 82, 82, 83, 83, 83, 83, 79, 74, 75, 74, 70, 68, 68, 68, 69, 68, 68, 69,
69, 68, 63, 60, 61, 61, 61, 56, 51, 46, 44, 44, 45, 44, 45, 44, 43, 46, 44, 38,
36, 36, 37, 36, 37, 35, 30, 28, 29, 29, 27, 20, 18, 18, 19, 18, 12, 11, 11, 12,
12, 12, 9, 2, 1, 2, 2, 1, 3, -2, -7, -7, -7, -5, -9, -16, -16, -17, -16, -16,
-16, -19, -23, -30, -34, -33, -34, -33, -34, -33, -34, -34, -33, -38, -40, -40,
-39, -39, -44, -50, -50, -49, -49, -49, -49, -53, -56, -56, -55, -55, -61, -65,
-64, -63, -64, -62, -64, -69, -71, -70, -69, -71, -76, -78, -78, -78, -77, -77,
-79, -83, -84, -84, -84, -86, -89, -90, -91, -94, -95, -95, -95, -96, -96, -96,
-94, -96, -100, -100, -100, -99, -100, -99, -102, -104, -106, -105, -104, -106,
-109, -110, -109, -109, -110, -109, -111, -111, -111, -111, -111, -112, -114,
-114, -115, -114, -114, -114, -115, -116, -116, -115, -116, -116, -117, -118,
-118, -117, -117, -118, -118, -119, -119, -119, -119, -119, -119, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -118, -118, -118, -118, -118, -117,
-118, -118, -116, -115, -116, -116, -116, -113, -111, -111, -111, -111, -111,
-111, -111, -112, -111, -112, -109, -107, -106, -106, -106, -107, -107, -105,
-103, -104, -104, -104, -102, -98, -98, -98, -98, -97, -94, -93, -93, -93, -94,
-94, -91, -86, -87, -87, -87, -88, -88, -84, -80, -81, -81, -81, -77, -74, -74,
-75, -75, -74, -75, -71, -67, -61, -60, -60, -61, -60, -61, -61, -59, -61, -60,
-56, -53, -54, -55, -53, -48, -43, -44, -45, -45, -46, -44, -39, -37, -38, -39,
-38, -31, -28, -28, -29, -28, -29, -26, -21, -20, -21, -22, -19, -13, -11, -11,
-11, -11, -11, -9, -3, -3, -3, -4, -1, };