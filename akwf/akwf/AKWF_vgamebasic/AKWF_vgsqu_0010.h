#define DATA_LENGTH 512
#define DATA AKWF_vgsqu_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {44, 114, 99, 93, 95, 95, 96, 99, 101,
101, 102, 102, 102, 102, 102, 102, 102, 102, 102, 102, 102, 102, 103, 102, 102,
102, 102, 103, 104, 104, 103, 104, 103, 104, 104, 103, 103, 103, 103, 104, 104,
104, 104, 104, 103, 104, 104, 105, 103, 103, 104, 103, 103, 103, 104, 103, 103,
104, 103, 103, 104, 104, 104, 103, 103, 104, 104, 103, 103, 103, 104, 104, 104,
104, 104, 104, 103, 104, 103, 104, 104, 104, 104, 103, 104, 104, 103, 103, 104,
104, 103, 103, 104, 104, 104, 104, 103, 103, 103, 104, 104, 104, 104, 104, 104,
104, 104, 104, 103, 104, 103, 104, 104, 104, 103, 104, 103, 103, 104, 103, 103,
103, 104, 104, 103, 104, 103, 104, 104, 104, 104, 104, 103, 104, 103, 104, 103,
104, 104, 104, 104, 104, 104, 103, 104, 104, 103, 104, 103, 104, 103, 104, 104,
104, 104, 103, 103, 103, 103, 104, 104, 104, 104, 104, 104, 104, 104, 103, 104,
104, 103, 104, 103, 104, 104, 103, 104, 104, 103, 104, 103, 104, 104, 104, 104,
104, 103, 103, 104, 104, 104, 103, 103, 104, 104, 104, 104, 103, 104, 103, 104,
104, 103, 104, 104, 103, 104, 103, 104, 104, 105, 103, 104, 103, 104, 103, 104,
104, 103, 104, 104, 103, 103, 103, 104, 103, 104, 104, 103, 103, 103, 102, 102,
102, 103, 102, 103, 103, 102, 102, 102, 104, 105, 105, 105, 106, 104, 106, 107,
110, 109, 108, 109, 122, 84, -55, -124, -112, -105, -107, -109, -107, -109,
-107, -108, -107, -109, -107, -107, -106, -107, -106, -107, -106, -106, -106,
-106, -106, -106, -107, -106, -106, -105, -105, -105, -105, -104, -105, -105,
-104, -105, -105, -105, -105, -105, -105, -105, -105, -105, -105, -105, -105,
-105, -105, -105, -105, -105, -105, -105, -106, -105, -105, -104, -105, -104,
-105, -105, -105, -105, -105, -104, -105, -106, -105, -106, -106, -105, -106,
-105, -105, -104, -104, -105, -105, -105, -106, -105, -105, -106, -105, -105,
-105, -104, -105, -105, -105, -105, -106, -105, -105, -105, -105, -105, -105,
-105, -106, -105, -105, -105, -105, -106, -105, -105, -105, -105, -105, -105,
-105, -105, -105, -106, -105, -106, -106, -105, -105, -105, -105, -105, -105,
-104, -105, -106, -105, -106, -105, -104, -106, -105, -105, -105, -105, -106,
-105, -105, -104, -105, -105, -105, -105, -105, -105, -104, -105, -105, -105,
-105, -105, -104, -105, -106, -105, -106, -105, -105, -104, -105, -105, -105,
-105, -104, -104, -105, -105, -105, -105, -105, -105, -106, -104, -105, -105,
-105, -105, -105, -104, -105, -105, -105, -104, -105, -105, -105, -105, -106,
-106, -106, -105, -105, -106, -104, -105, -105, -105, -106, -105, -105, -106,
-105, -105, -105, -105, -105, -105, -105, -105, -105, -105, -106, -105, -105,
-105, -105, -106, -105, -105, -105, -105, -105, -106, -105, -105, -105, -105,
-105, -105, -105, -105, -105, -105, -105, -106, -107, -106, -107, -107, -106,
-106, -106, -106, -106, -105, -108, -109, -112, -109, -111, -110, -109, -111,
-123, -65, };