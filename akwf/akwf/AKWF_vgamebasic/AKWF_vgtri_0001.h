#define DATA_LENGTH 512
#define DATA AKWF_vgtri_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 10, 9, 8, 9, 8, 8, 9, 9, 8, 8, 8,
9, 9, 8, 8, 9, 8, 8, 8, 9, 8, 9, 9, 8, 7, 9, 20, 26, 26, 25, 25, 25, 26, 25, 25,
25, 26, 25, 25, 25, 25, 25, 25, 23, 30, 43, 45, 44, 44, 44, 44, 42, 45, 57, 63,
63, 62, 62, 61, 62, 62, 62, 62, 62, 62, 62, 63, 62, 62, 62, 63, 62, 62, 61, 62,
62, 62, 62, 60, 63, 73, 80, 79, 79, 78, 79, 79, 79, 78, 79, 80, 79, 78, 78, 79,
79, 79, 77, 83, 96, 99, 97, 97, 97, 97, 96, 98, 110, 117, 115, 115, 116, 116,
116, 116, 116, 115, 116, 116, 116, 115, 116, 116, 116, 116, 116, 116, 115, 116,
116, 115, 116, 116, 116, 116, 116, 116, 116, 116, 116, 115, 116, 116, 116, 116,
116, 115, 116, 115, 118, 114, 103, 96, 96, 98, 97, 97, 97, 98, 98, 97, 87, 79,
79, 81, 81, 80, 81, 81, 81, 80, 80, 81, 81, 81, 80, 80, 80, 80, 80, 81, 81, 81,
81, 80, 80, 82, 81, 69, 61, 61, 62, 63, 62, 62, 62, 63, 62, 62, 62, 62, 62, 62,
64, 61, 50, 42, 44, 44, 43, 44, 43, 43, 44, 45, 34, 26, 26, 28, 27, 27, 27, 27,
27, 28, 27, 27, 27, 26, 27, 26, 27, 27, 26, 27, 28, 27, 26, 28, 28, 21, 9, -2,
-7, -7, -7, -7, -6, -7, -7, -7, -6, -7, -7, -6, -7, -7, -7, -7, -7, -7, -7, -7,
-7, -7, -7, -8, -5, -7, -16, -26, -27, -26, -25, -26, -25, -25, -25, -25, -24,
-25, -38, -45, -44, -43, -44, -43, -43, -44, -44, -43, -43, -44, -43, -43, -43,
-53, -62, -61, -60, -61, -60, -60, -60, -60, -60, -61, -59, -60, -61, -61, -60,
-60, -60, -60, -61, -60, -60, -60, -61, -61, -60, -60, -69, -79, -80, -78, -78,
-79, -79, -80, -79, -79, -79, -79, -80, -78, -79, -79, -79, -79, -79, -79, -79,
-79, -80, -78, -77, -83, -94, -107, -114, -116, -114, -114, -114, -114, -114,
-114, -114, -114, -114, -115, -114, -114, -114, -114, -114, -114, -114, -114,
-114, -114, -113, -114, -114, -114, -117, -119, -118, -119, -119, -118, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -120, -119, -119, -119,
-119, -119, -120, -118, -120, -115, -104, -92, -83, -83, -84, -84, -85, -84,
-84, -84, -84, -84, -83, -84, -83, -84, -84, -84, -84, -84, -84, -84, -84, -83,
-83, -84, -85, -85, -76, -64, -64, -66, -65, -66, -65, -65, -65, -66, -65, -66,
-65, -65, -65, -65, -65, -66, -65, -66, -65, -66, -65, -65, -67, -63, -52, -39,
-29, -29, -30, -30, -31, -30, -30, -29, -30, -30, -30, -30, -31, -30, -30, -30,
-30, -30, -30, -30, -31, -30, -30, -29, -31, -32, -22, -11, -11, -12, -12, -12,
-11, -12, -12, -11, -12, -11, -12, -12, -12, -12, -12, -12, -12, -12, -12, -11,
-12, -12, -13, -9, };