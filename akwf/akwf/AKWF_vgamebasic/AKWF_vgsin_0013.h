#define DATA_LENGTH 512
#define DATA AKWF_vgsin_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 8, 6, 6, 7, 10, 12, 11, 10, 11, 16,
19, 19, 22, 26, 28, 27, 26, 28, 31, 32, 32, 36, 38, 39, 38, 38, 40, 43, 43, 42,
43, 46, 50, 50, 50, 54, 56, 56, 55, 56, 58, 60, 60, 63, 67, 71, 72, 72, 72, 72,
71, 72, 71, 73, 76, 76, 77, 80, 82, 83, 82, 82, 85, 86, 86, 85, 85, 88, 91, 90,
91, 95, 96, 98, 99, 99, 99, 99, 99, 99, 101, 103, 102, 102, 103, 103, 103, 102,
103, 104, 107, 109, 108, 109, 110, 109, 109, 109, 110, 111, 113, 114, 114, 114,
114, 114, 114, 116, 116, 116, 116, 116, 115, 116, 116, 116, 117, 117, 117, 117,
117, 117, 117, 118, 117, 117, 118, 117, 118, 117, 118, 117, 117, 117, 117, 116,
115, 116, 115, 116, 115, 116, 115, 114, 114, 115, 114, 114, 113, 113, 113, 111,
109, 110, 109, 108, 108, 108, 108, 108, 109, 106, 105, 105, 104, 102, 102, 102,
101, 101, 100, 98, 99, 97, 95, 95, 94, 95, 95, 93, 92, 93, 89, 86, 87, 88, 87,
85, 82, 82, 83, 83, 79, 78, 78, 78, 78, 76, 73, 73, 72, 67, 67, 66, 68, 66, 64,
62, 63, 59, 56, 55, 56, 56, 55, 53, 52, 52, 53, 50, 46, 44, 44, 40, 37, 38, 39,
38, 35, 33, 34, 34, 34, 30, 27, 27, 26, 20, 18, 19, 20, 18, 15, 14, 15, 11, 6,
5, 6, 6, 5, 2, 1, 2, 3, -1, -5, -7, -7, -11, -13, -12, -14, -17, -18, -17, -17,
-18, -17, -22, -25, -25, -27, -32, -34, -33, -32, -33, -38, -38, -39, -41, -44,
-44, -44, -44, -46, -49, -49, -50, -49, -51, -55, -56, -56, -61, -63, -63, -61,
-62, -66, -67, -66, -69, -73, -73, -73, -73, -74, -75, -77, -76, -75, -77, -80,
-82, -81, -83, -87, -89, -91, -90, -90, -90, -91, -90, -91, -92, -95, -95, -96,
-99, -100, -100, -100, -100, -101, -102, -102, -104, -105, -104, -104, -104,
-105, -108, -110, -111, -111, -111, -111, -110, -111, -111, -113, -113, -113,
-112, -114, -115, -115, -114, -114, -115, -116, -116, -116, -118, -117, -117,
-117, -118, -118, -120, -119, -119, -119, -119, -118, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -118, -117, -118, -117, -118, -117, -118,
-118, -117, -118, -117, -116, -115, -115, -115, -114, -114, -115, -114, -112,
-113, -113, -112, -109, -109, -109, -109, -109, -107, -107, -108, -108, -107,
-105, -105, -105, -101, -100, -101, -100, -98, -98, -99, -99, -97, -94, -93,
-94, -93, -93, -91, -90, -91, -91, -90, -86, -86, -86, -83, -80, -78, -79, -80,
-78, -77, -77, -75, -71, -69, -69, -71, -69, -66, -63, -63, -63, -63, -62, -61,
-61, -58, -55, -54, -54, -55, -53, -50, -48, -49, -50, -48, -42, -41, -41, -38,
-35, -35, -35, -35, -33, -30, -30, -30, -31, -27, -22, -22, -22, -17, -15, -15,
-16, -15, -13, -11, -12, -8, -3, -3, -3, -3, -1, };