#define DATA_LENGTH 512
#define DATA AKWF_vgtri_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 6, 5, 5, 4, 5, 7, 9, 10, 10, 9, 9,
14, 17, 16, 16, 15, 15, 17, 20, 22, 20, 20, 21, 26, 27, 27, 27, 27, 26, 28, 31,
31, 32, 36, 38, 38, 38, 38, 38, 38, 37, 40, 42, 44, 43, 41, 44, 48, 50, 50, 49,
49, 49, 51, 53, 54, 54, 53, 55, 59, 62, 65, 65, 65, 65, 66, 65, 66, 65, 65, 67,
70, 72, 71, 72, 71, 71, 72, 76, 76, 76, 76, 78, 82, 83, 83, 82, 84, 87, 88, 88,
87, 87, 87, 88, 93, 94, 94, 93, 94, 94, 95, 98, 99, 98, 98, 100, 104, 105, 106,
105, 104, 105, 106, 110, 114, 116, 117, 117, 116, 116, 116, 116, 116, 116, 115,
114, 114, 114, 114, 115, 115, 112, 107, 107, 109, 109, 105, 102, 101, 102, 102,
100, 97, 96, 97, 97, 98, 97, 95, 91, 90, 90, 90, 91, 90, 88, 86, 86, 86, 86, 83,
80, 78, 80, 80, 80, 80, 77, 74, 70, 68, 68, 68, 69, 68, 68, 68, 68, 69, 66, 64,
63, 64, 64, 61, 57, 56, 58, 57, 58, 58, 55, 52, 51, 53, 52, 49, 46, 45, 46, 46,
47, 46, 44, 40, 41, 41, 42, 39, 35, 34, 35, 35, 36, 35, 32, 30, 29, 30, 31, 28,
24, 24, 23, 19, 19, 19, 19, 18, 19, 20, 19, 16, 13, 12, 13, 13, 14, 13, 9, 8, 9,
8, 8, 5, 1, 1, 1, 2, 2, 1, 0, -2, -2, -1, -2, -5, -8, -7, -8, -8, -8, -8, -11,
-13, -13, -13, -13, -16, -20, -19, -19, -19, -19, -19, -21, -24, -23, -26, -30,
-31, -30, -30, -30, -30, -30, -29, -33, -35, -36, -35, -34, -39, -41, -41, -41,
-41, -41, -41, -44, -46, -47, -45, -46, -48, -53, -56, -58, -57, -57, -56, -57,
-58, -58, -57, -57, -61, -64, -65, -63, -63, -63, -64, -66, -69, -68, -68, -68,
-72, -75, -74, -74, -74, -77, -80, -80, -80, -79, -78, -79, -83, -86, -87, -85,
-86, -85, -85, -88, -91, -91, -90, -90, -94, -97, -97, -97, -97, -97, -98, -99,
-103, -107, -108, -108, -108, -108, -108, -109, -107, -107, -108, -111, -113,
-113, -113, -113, -117, -119, -119, -119, -119, -119, -119, -115, -114, -114,
-115, -115, -110, -108, -108, -108, -107, -109, -107, -104, -102, -104, -104,
-103, -99, -96, -97, -96, -97, -97, -96, -94, -91, -92, -93, -91, -88, -85, -86,
-84, -81, -80, -80, -81, -81, -80, -81, -81, -77, -74, -75, -75, -74, -75, -74,
-71, -69, -70, -71, -69, -65, -63, -64, -64, -64, -64, -62, -60, -58, -59, -60,
-59, -55, -52, -53, -51, -47, -47, -48, -47, -48, -48, -48, -47, -48, -47, -43,
-40, -41, -42, -40, -37, -35, -36, -33, -30, -29, -30, -30, -31, -31, -31, -29,
-25, -23, -23, -24, -23, -24, -23, -20, -18, -20, -20, -18, -14, -13, -13, -13,
-13, -13, -12, -9, -8, -8, -8, -7, -3, -1, -2, -1, -2, -2, 0, };