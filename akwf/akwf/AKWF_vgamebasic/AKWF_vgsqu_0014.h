#define DATA_LENGTH 512
#define DATA AKWF_vgsqu_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {23, 97, 122, 116, 108, 97, 99, 99,
101, 101, 101, 102, 103, 102, 102, 102, 103, 103, 102, 103, 102, 102, 103, 103,
102, 104, 104, 104, 103, 103, 104, 104, 104, 103, 103, 104, 104, 104, 104, 103,
104, 103, 104, 103, 104, 104, 103, 104, 104, 104, 104, 104, 104, 104, 103, 104,
103, 104, 103, 104, 104, 104, 104, 104, 103, 104, 103, 104, 103, 104, 103, 104,
103, 103, 103, 104, 104, 104, 103, 104, 104, 104, 104, 103, 104, 104, 103, 104,
103, 103, 104, 103, 104, 104, 104, 104, 104, 104, 104, 103, 104, 103, 104, 103,
103, 104, 103, 104, 104, 104, 103, 103, 104, 103, 104, 104, 104, 104, 104, 103,
103, 103, 104, 104, 103, 104, 104, 104, 103, 104, 103, 103, 104, 104, 103, 104,
103, 104, 103, 103, 104, 103, 104, 104, 104, 103, 103, 104, 104, 104, 104, 104,
104, 103, 104, 104, 103, 103, 104, 104, 104, 103, 104, 103, 104, 103, 104, 104,
104, 104, 103, 103, 103, 104, 103, 104, 103, 103, 104, 103, 103, 103, 104, 104,
104, 104, 103, 104, 103, 104, 104, 104, 104, 104, 103, 104, 104, 104, 105, 104,
104, 104, 103, 104, 104, 104, 103, 103, 103, 104, 103, 104, 103, 104, 103, 104,
104, 104, 104, 103, 103, 104, 104, 104, 104, 103, 104, 103, 103, 103, 102, 102,
102, 102, 103, 102, 102, 102, 101, 102, 102, 102, 103, 102, 100, 102, 100, 100,
99, 100, 99, 97, 95, 114, 77, -64, -122, -116, -114, -109, -111, -110, -108,
-108, -108, -107, -106, -106, -107, -106, -107, -106, -107, -106, -107, -107,
-107, -106, -106, -106, -104, -105, -105, -105, -105, -105, -105, -104, -104,
-105, -105, -105, -104, -105, -105, -104, -105, -104, -104, -105, -105, -105,
-105, -105, -105, -105, -106, -105, -105, -105, -106, -105, -106, -104, -106,
-105, -105, -105, -105, -104, -105, -106, -106, -105, -105, -104, -105, -105,
-105, -105, -105, -105, -106, -104, -104, -105, -105, -105, -106, -105, -105,
-105, -105, -105, -105, -106, -105, -104, -105, -105, -106, -104, -105, -105,
-105, -105, -104, -105, -106, -106, -105, -105, -105, -105, -106, -104, -105,
-105, -105, -104, -106, -106, -105, -105, -105, -105, -104, -106, -106, -105,
-105, -104, -105, -104, -105, -105, -105, -105, -105, -105, -106, -104, -105,
-106, -105, -105, -105, -106, -105, -105, -105, -105, -105, -105, -104, -105,
-105, -106, -105, -105, -105, -105, -104, -105, -105, -105, -105, -105, -106,
-105, -105, -105, -105, -105, -105, -105, -105, -105, -105, -105, -106, -105,
-104, -105, -105, -105, -105, -105, -105, -105, -106, -105, -105, -105, -105,
-105, -105, -105, -105, -105, -105, -105, -105, -106, -105, -106, -105, -105,
-105, -104, -105, -105, -105, -105, -105, -106, -105, -105, -104, -104, -104,
-105, -105, -105, -105, -105, -106, -106, -104, -105, -105, -106, -105, -105,
-105, -106, -106, -107, -107, -106, -107, -106, -106, -106, -106, -106, -106,
-106, -107, -106, -107, -107, -104, -101, -101, -99, -96, -103, -97, -34, 2, -6,
};