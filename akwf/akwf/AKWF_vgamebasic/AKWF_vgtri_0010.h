#define DATA_LENGTH 512
#define DATA AKWF_vgtri_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 6, 8, 7, 6, 6, 5, 8, 12, 13, 12,
13, 13, 13, 17, 19, 19, 21, 25, 26, 26, 25, 25, 25, 25, 26, 29, 30, 30, 31, 30,
30, 31, 35, 37, 36, 36, 37, 36, 38, 42, 44, 42, 42, 45, 49, 49, 49, 49, 49, 49,
49, 50, 54, 56, 55, 56, 56, 54, 57, 61, 62, 62, 62, 62, 62, 65, 69, 69, 68, 68,
70, 75, 75, 74, 75, 74, 75, 74, 75, 80, 81, 81, 81, 81, 80, 82, 87, 88, 88, 87,
86, 87, 91, 94, 95, 93, 93, 96, 100, 100, 100, 99, 100, 100, 100, 101, 105, 107,
106, 106, 107, 111, 114, 112, 112, 113, 112, 114, 117, 118, 117, 117, 118, 117,
115, 111, 111, 111, 111, 112, 111, 106, 104, 104, 104, 105, 105, 104, 99, 99,
99, 98, 98, 99, 96, 92, 91, 92, 92, 93, 92, 89, 85, 85, 86, 86, 86, 85, 82, 79,
79, 80, 80, 80, 78, 73, 72, 73, 74, 73, 74, 71, 67, 66, 67, 67, 68, 67, 62, 60,
60, 60, 60, 60, 60, 56, 54, 53, 53, 54, 55, 52, 48, 47, 48, 48, 47, 48, 45, 41,
42, 41, 41, 42, 41, 38, 35, 34, 36, 35, 31, 28, 28, 28, 28, 29, 29, 25, 24, 24,
23, 23, 24, 22, 18, 17, 17, 17, 18, 18, 15, 11, 7, 5, 5, 5, 5, 5, 6, 5, 4, 5, 5,
4, 0, -1, -2, -2, -1, -1, -3, -6, -7, -6, -6, -7, -6, -8, -13, -18, -19, -19,
-19, -19, -20, -19, -19, -19, -19, -18, -20, -24, -27, -25, -25, -26, -25, -28,
-32, -32, -31, -32, -31, -32, -35, -39, -43, -45, -44, -44, -44, -44, -44, -45,
-44, -44, -44, -46, -50, -51, -51, -50, -50, -50, -53, -57, -58, -57, -56, -60,
-64, -63, -64, -67, -69, -69, -69, -69, -68, -68, -68, -67, -69, -73, -75, -75,
-75, -74, -73, -77, -80, -82, -81, -81, -80, -80, -83, -87, -88, -88, -93, -95,
-93, -94, -94, -94, -94, -95, -93, -94, -99, -100, -100, -100, -100, -99, -102,
-106, -107, -106, -107, -106, -107, -109, -113, -112, -114, -118, -120, -119,
-118, -119, -119, -119, -118, -119, -118, -115, -112, -113, -113, -112, -114,
-111, -107, -106, -107, -106, -107, -107, -103, -100, -100, -99, -94, -93, -94,
-94, -94, -93, -94, -94, -89, -87, -87, -88, -87, -88, -87, -83, -83, -82, -83,
-83, -83, -81, -77, -76, -76, -77, -74, -70, -70, -70, -70, -69, -69, -70, -70,
-66, -63, -64, -64, -64, -64, -62, -58, -57, -56, -57, -57, -58, -55, -51, -50,
-50, -51, -49, -45, -44, -44, -45, -45, -44, -45, -44, -40, -38, -39, -38, -39,
-38, -37, -32, -31, -32, -32, -32, -32, -29, -26, -25, -25, -26, -23, -20, -19,
-19, -19, -19, -19, -20, -19, -14, -12, -12, -12, -13, -13, -12, -6, -6, -6, -5,
-7, -7, -3, 1, 1, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, -1, -1, };