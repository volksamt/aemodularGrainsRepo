#define DATA_LENGTH 512
#define DATA AKWF_vgtri_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 3, 4, 5, 4, 5, 8, 7, 7, 11,
11, 11, 13, 15, 17, 18, 17, 18, 19, 19, 19, 22, 22, 22, 24, 26, 27, 28, 28, 30,
30, 30, 30, 33, 34, 33, 36, 37, 37, 38, 39, 42, 43, 43, 44, 45, 45, 44, 47, 48,
47, 48, 51, 54, 54, 54, 55, 55, 55, 57, 59, 59, 59, 61, 62, 62, 63, 64, 67, 68,
68, 69, 69, 70, 70, 72, 73, 73, 75, 76, 78, 79, 79, 80, 81, 81, 81, 83, 84, 85,
85, 87, 87, 89, 90, 92, 94, 94, 94, 95, 95, 95, 97, 99, 98, 99, 101, 103, 105,
105, 104, 106, 106, 107, 108, 109, 109, 111, 114, 112, 114, 115, 116, 116, 116,
116, 114, 114, 114, 113, 112, 111, 110, 108, 106, 105, 104, 105, 104, 103, 103,
102, 101, 101, 99, 96, 95, 94, 94, 94, 93, 93, 92, 90, 89, 89, 88, 85, 86, 85,
84, 81, 80, 80, 79, 78, 77, 77, 76, 74, 75, 74, 72, 70, 69, 68, 67, 67, 67, 67,
65, 63, 63, 62, 61, 61, 60, 58, 56, 55, 53, 53, 53, 52, 53, 51, 49, 49, 49, 47,
44, 42, 43, 43, 41, 42, 41, 40, 38, 39, 37, 34, 34, 35, 33, 30, 28, 28, 28, 28,
27, 28, 26, 24, 24, 24, 22, 19, 17, 17, 17, 16, 16, 16, 14, 12, 13, 12, 10, 9,
9, 8, 6, 3, 2, 3, 1, 2, 2, 1, -1, -2, -2, -2, -4, -6, -7, -6, -7, -8, -8, -10,
-11, -11, -11, -14, -15, -14, -16, -18, -20, -21, -20, -22, -23, -23, -23, -25,
-25, -25, -27, -30, -31, -32, -32, -32, -33, -33, -34, -36, -37, -37, -39, -39,
-39, -41, -43, -45, -47, -46, -47, -47, -47, -47, -50, -51, -50, -52, -55, -56,
-58, -57, -57, -59, -58, -59, -61, -62, -61, -64, -65, -65, -66, -69, -71, -71,
-71, -72, -73, -73, -73, -75, -76, -76, -77, -80, -82, -83, -82, -84, -84, -84,
-85, -86, -88, -88, -89, -92, -93, -94, -95, -95, -96, -95, -97, -98, -98, -99,
-102, -102, -102, -103, -105, -108, -109, -107, -108, -110, -109, -109, -111,
-114, -113, -114, -116, -119, -119, -117, -117, -118, -118, -117, -115, -114,
-114, -113, -111, -112, -110, -108, -106, -105, -105, -104, -103, -103, -102,
-102, -100, -100, -99, -96, -95, -93, -93, -92, -92, -92, -91, -89, -89, -89,
-87, -86, -86, -85, -83, -81, -79, -79, -80, -78, -78, -78, -76, -75, -75, -74,
-72, -70, -67, -67, -66, -67, -67, -67, -65, -64, -64, -62, -60, -60, -59, -58,
-56, -54, -54, -53, -53, -53, -52, -51, -49, -49, -49, -46, -45, -42, -42, -41,
-42, -41, -41, -40, -38, -38, -37, -35, -34, -34, -33, -31, -29, -29, -29, -28,
-27, -27, -26, -24, -24, -23, -22, -19, -17, -16, -16, -16, -16, -16, -14, -13,
-13, -11, -9, -10, -9, -8, -5, -3, -3, -3, -2, -2, -2, -1, 0, 0, 0, 0, };