#define DATA_LENGTH 512
#define DATA AKWF_vgsaw_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 3, 5, 7, 7, 7, 7, 7, 7, 7, 8, 7, 7,
7, 7, 7, 9, 11, 10, 10, 10, 10, 10, 9, 11, 13, 13, 13, 12, 15, 17, 17, 16, 17,
17, 17, 17, 17, 17, 17, 20, 20, 20, 20, 19, 20, 19, 21, 22, 22, 23, 22, 22, 22,
22, 22, 24, 27, 26, 27, 27, 27, 26, 29, 29, 29, 29, 30, 30, 29, 29, 30, 32, 33,
33, 32, 32, 32, 32, 33, 36, 36, 37, 38, 40, 39, 39, 40, 38, 39, 39, 39, 39, 39,
39, 42, 42, 42, 41, 43, 41, 41, 42, 44, 46, 47, 47, 46, 47, 46, 48, 49, 49, 49,
49, 49, 49, 48, 50, 52, 52, 52, 52, 52, 51, 51, 53, 55, 57, 56, 56, 56, 56, 57,
59, 59, 58, 61, 62, 62, 61, 62, 61, 62, 61, 62, 61, 62, 61, 62, 63, 66, 66, 65,
66, 66, 65, 67, 70, 69, 69, 69, 69, 68, 71, 71, 71, 71, 71, 71, 71, 71, 71, 71,
74, 76, 76, 76, 76, 76, 76, 78, 78, 78, 78, 78, 79, 79, 78, 80, 82, 85, 86, 86,
85, 85, 86, 85, 85, 85, 86, 85, 86, 88, 88, 88, 89, 88, 88, 88, 88, 88, 88, 91,
92, 91, 91, 92, 95, 95, 96, 95, 95, 95, 96, 95, 95, 95, 97, 97, 97, 97, 97, 96,
96, 97, 96, 97, 96, 97, 96, 96, 97, 118, 60, -80, -123, -117, -118, -119, -120,
-112, -99, -96, -99, -98, -98, -97, -98, -98, -98, -96, -97, -96, -97, -97, -96,
-97, -95, -95, -95, -94, -91, -91, -90, -91, -91, -90, -91, -91, -91, -92, -91,
-90, -89, -88, -89, -89, -88, -88, -89, -88, -86, -86, -85, -85, -85, -87, -85,
-82, -81, -81, -81, -81, -81, -81, -82, -79, -78, -78, -78, -78, -78, -79, -79,
-77, -76, -75, -76, -75, -75, -76, -73, -71, -72, -71, -69, -68, -69, -68, -69,
-69, -68, -69, -69, -68, -68, -69, -69, -67, -65, -66, -67, -66, -67, -64, -62,
-62, -62, -61, -62, -61, -60, -59, -59, -58, -59, -59, -58, -59, -59, -59, -58,
-57, -56, -56, -55, -56, -56, -54, -51, -52, -52, -51, -52, -51, -52, -51, -50,
-48, -46, -46, -46, -47, -45, -46, -47, -47, -46, -47, -46, -47, -46, -43, -42,
-42, -41, -42, -43, -42, -42, -40, -39, -40, -39, -40, -39, -37, -36, -36, -36,
-36, -36, -36, -37, -37, -35, -32, -32, -32, -33, -32, -32, -32, -32, -30, -29,
-30, -30, -29, -29, -29, -30, -28, -27, -27, -27, -27, -27, -27, -24, -22, -23,
-23, -23, -23, -22, -23, -21, -19, -20, -20, -19, -20, -19, -20, -19, -18, -16,
-18, -15, -13, -12, -13, -12, -13, -12, -13, -13, -12, -12, -13, -10, -9, -10,
-10, -10, -9, -10, -10, -8, -7, -7, -7, -7, -8, -7, -5, -2, -3, -3, -3, -2, -4,
-3, -2, -1, 1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, };