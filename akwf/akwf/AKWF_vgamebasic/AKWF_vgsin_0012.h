#define DATA_LENGTH 512
#define DATA AKWF_vgsin_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 6, 6, 4, 5, 9, 14, 18, 20, 19, 18,
20, 26, 28, 27, 27, 27, 27, 28, 26, 29, 34, 34, 33, 33, 36, 40, 40, 40, 39, 39,
38, 43, 48, 49, 48, 47, 49, 54, 59, 61, 62, 62, 62, 62, 62, 61, 62, 67, 69, 69,
68, 69, 72, 75, 75, 74, 74, 77, 79, 80, 80, 79, 82, 86, 86, 86, 89, 92, 90, 91,
91, 91, 90, 90, 93, 97, 98, 97, 97, 97, 99, 100, 99, 100, 101, 103, 103, 103,
102, 104, 107, 108, 108, 109, 109, 109, 109, 109, 110, 110, 111, 113, 114, 112,
113, 113, 113, 114, 114, 114, 115, 115, 116, 117, 115, 116, 115, 116, 118, 117,
117, 117, 118, 118, 117, 118, 118, 117, 118, 117, 118, 117, 118, 117, 118, 117,
117, 117, 116, 116, 116, 116, 115, 116, 116, 115, 114, 114, 112, 111, 111, 111,
111, 111, 110, 110, 110, 109, 110, 109, 108, 106, 106, 107, 106, 105, 103, 103,
103, 104, 101, 98, 98, 98, 98, 98, 96, 95, 95, 95, 95, 96, 94, 90, 90, 90, 91,
89, 85, 84, 84, 85, 83, 79, 77, 77, 78, 78, 75, 72, 73, 74, 73, 70, 66, 66, 67,
67, 64, 61, 59, 61, 61, 59, 54, 53, 54, 54, 55, 54, 51, 48, 48, 48, 49, 44, 38,
37, 39, 38, 37, 32, 31, 32, 32, 31, 25, 23, 24, 25, 23, 19, 16, 15, 17, 16, 12,
9, 10, 10, 11, 5, 2, 1, 2, 1, 2, 2, -4, -7, -7, -6, -6, -11, -16, -16, -16, -16,
-18, -22, -22, -22, -22, -24, -29, -31, -30, -30, -32, -37, -38, -39, -38, -38,
-41, -47, -50, -51, -50, -50, -51, -51, -50, -51, -49, -52, -55, -58, -57, -56,
-57, -63, -67, -67, -66, -66, -70, -73, -74, -73, -73, -74, -78, -82, -84, -85,
-84, -85, -84, -84, -84, -85, -87, -89, -89, -89, -89, -88, -91, -93, -95, -94,
-94, -95, -99, -101, -100, -100, -100, -103, -104, -106, -107, -106, -106, -106,
-106, -106, -105, -108, -109, -110, -109, -109, -111, -113, -113, -112, -112,
-113, -114, -114, -114, -115, -114, -114, -115, -116, -116, -117, -118, -117,
-118, -117, -118, -117, -117, -119, -119, -119, -119, -120, -118, -119, -119,
-119, -120, -119, -119, -119, -119, -119, -118, -117, -118, -117, -117, -118,
-118, -117, -118, -118, -118, -117, -116, -116, -116, -116, -116, -115, -113,
-112, -113, -113, -112, -109, -109, -109, -111, -108, -107, -107, -106, -104,
-103, -103, -103, -103, -103, -103, -100, -100, -100, -100, -100, -97, -95, -95,
-95, -95, -96, -95, -92, -90, -90, -91, -90, -87, -84, -85, -83, -78, -77, -78,
-77, -78, -78, -75, -73, -72, -73, -73, -71, -67, -66, -66, -68, -65, -62, -60,
-60, -62, -59, -56, -53, -53, -55, -53, -48, -45, -47, -46, -46, -46, -45, -40,
-38, -38, -39, -38, -33, -29, -30, -32, -30, -25, -21, -22, -23, -23, -19, -16,
-15, -16, -16, -13, -8, -7, -8, -9, -5, };