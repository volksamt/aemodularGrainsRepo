#define DATA_LENGTH 512
#define DATA AKWF_vgsqu_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {54, 121, 105, 100, 103, 107, 109, 108,
108, 108, 111, 113, 113, 112, 113, 111, 110, 110, 111, 110, 110, 111, 112, 111,
112, 111, 112, 111, 112, 111, 112, 111, 111, 112, 111, 112, 112, 111, 111, 112,
111, 112, 112, 111, 112, 111, 111, 112, 111, 112, 112, 111, 112, 112, 112, 112,
111, 112, 111, 112, 111, 112, 112, 112, 112, 111, 112, 111, 112, 112, 112, 112,
111, 112, 111, 112, 112, 111, 112, 112, 111, 112, 111, 111, 111, 111, 111, 112,
112, 112, 112, 111, 111, 111, 111, 112, 112, 111, 112, 111, 112, 112, 112, 112,
112, 111, 112, 112, 111, 112, 112, 111, 111, 111, 111, 111, 112, 111, 112, 111,
111, 112, 112, 112, 111, 111, 112, 111, 112, 111, 112, 111, 111, 111, 112, 111,
111, 112, 112, 111, 111, 111, 111, 111, 111, 112, 112, 111, 111, 111, 111, 111,
112, 111, 111, 112, 112, 111, 111, 112, 112, 111, 112, 112, 112, 111, 111, 111,
111, 112, 111, 112, 112, 111, 112, 112, 111, 111, 111, 112, 112, 111, 112, 111,
111, 112, 112, 112, 112, 112, 112, 111, 111, 112, 111, 112, 112, 111, 112, 111,
111, 111, 111, 111, 111, 112, 112, 111, 111, 111, 112, 112, 112, 111, 112, 111,
112, 111, 111, 112, 112, 111, 112, 111, 111, 111, 112, 112, 111, 111, 111, 110,
110, 110, 110, 110, 109, 113, 113, 113, 114, 113, 110, 109, 109, 108, 108, 114,
117, 117, 119, 117, 64, -5, -9, 3, 10, -44, -111, -119, -118, -118, -119, -119,
-116, -110, -109, -110, -110, -110, -112, -112, -112, -112, -112, -114, -115,
-114, -115, -115, -113, -113, -112, -113, -113, -113, -113, -113, -114, -113,
-114, -113, -113, -113, -113, -113, -113, -114, -112, -114, -113, -113, -113,
-113, -114, -113, -114, -113, -113, -114, -114, -113, -113, -113, -113, -112,
-113, -113, -113, -113, -113, -113, -113, -114, -113, -112, -112, -113, -113,
-114, -113, -113, -113, -113, -114, -113, -113, -113, -112, -114, -113, -114,
-114, -113, -113, -113, -113, -114, -113, -114, -112, -113, -113, -113, -112,
-113, -113, -113, -113, -113, -113, -113, -113, -113, -114, -113, -113, -113,
-113, -112, -113, -113, -113, -113, -113, -113, -113, -113, -113, -112, -114,
-113, -113, -113, -112, -113, -113, -112, -113, -114, -113, -113, -113, -112,
-113, -113, -114, -113, -113, -113, -114, -113, -113, -113, -113, -113, -114,
-113, -112, -113, -113, -113, -113, -113, -112, -113, -113, -113, -113, -113,
-113, -113, -112, -114, -113, -113, -113, -113, -113, -113, -113, -113, -113,
-113, -113, -113, -114, -114, -113, -114, -113, -113, -114, -113, -113, -113,
-113, -113, -114, -113, -113, -113, -113, -113, -113, -112, -114, -113, -114,
-113, -113, -113, -113, -114, -113, -113, -112, -113, -113, -113, -113, -113,
-113, -113, -113, -113, -113, -112, -113, -113, -113, -113, -113, -113, -113,
-113, -113, -114, -113, -113, -113, -114, -115, -114, -114, -115, -113, -111,
-111, -111, -111, -113, -117, -117, -114, -106, -103, -103, -102, -107, -120,
-57, };