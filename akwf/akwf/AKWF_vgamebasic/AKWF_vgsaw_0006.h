#define DATA_LENGTH 512
#define DATA AKWF_vgsaw_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {-1, 2, 6, 8, 8, 9, 8, 9, 8, 8, 9, 9,
8, 8, 8, 9, 9, 8, 9, 8, 8, 7, 9, 12, 14, 13, 13, 13, 12, 15, 18, 18, 18, 18, 18,
17, 18, 18, 17, 19, 17, 18, 19, 22, 23, 23, 23, 24, 22, 22, 23, 23, 23, 23, 24,
27, 32, 34, 35, 34, 34, 35, 34, 34, 34, 35, 34, 34, 35, 34, 34, 35, 35, 34, 35,
39, 39, 40, 39, 39, 39, 39, 39, 42, 44, 44, 44, 45, 44, 44, 44, 45, 45, 45, 44,
43, 45, 48, 50, 49, 49, 49, 49, 49, 49, 49, 49, 52, 56, 58, 60, 59, 59, 58, 59,
59, 59, 58, 59, 59, 58, 59, 59, 59, 59, 59, 59, 59, 60, 64, 65, 66, 66, 65, 66,
65, 65, 68, 71, 70, 70, 70, 71, 70, 70, 71, 70, 71, 70, 70, 71, 75, 75, 74, 75,
76, 75, 75, 75, 75, 75, 80, 80, 80, 83, 85, 85, 85, 85, 84, 85, 84, 85, 84, 85,
84, 85, 85, 85, 84, 84, 84, 86, 90, 90, 90, 90, 90, 90, 89, 91, 94, 97, 96, 96,
96, 97, 97, 95, 96, 96, 95, 96, 101, 102, 100, 101, 101, 101, 101, 101, 101,
102, 100, 102, 106, 106, 107, 109, 110, 110, 109, 109, 108, 109, 110, 110, 110,
109, 110, 109, 109, 109, 110, 110, 112, 113, 113, 113, 112, 112, 111, 112, 120,
93, -21, -80, -63, -61, -61, -63, -61, -62, -62, -61, -56, -76, -111, -120,
-117, -118, -120, -119, -119, -118, -119, -118, -114, -111, -112, -114, -112,
-108, -107, -107, -108, -108, -107, -107, -108, -107, -108, -108, -108, -107,
-107, -108, -109, -106, -101, -100, -101, -102, -101, -101, -101, -100, -102,
-101, -97, -96, -96, -96, -97, -96, -96, -97, -96, -95, -97, -94, -91, -91, -92,
-92, -91, -91, -91, -92, -92, -90, -86, -86, -86, -88, -85, -81, -81, -82, -81,
-82, -82, -81, -81, -82, -82, -81, -82, -82, -82, -82, -82, -80, -76, -77, -77,
-77, -76, -77, -77, -77, -77, -76, -71, -69, -70, -70, -70, -70, -70, -70, -70,
-70, -67, -64, -66, -65, -66, -65, -66, -65, -64, -66, -66, -63, -61, -60, -60,
-61, -59, -56, -55, -56, -56, -56, -56, -55, -56, -55, -56, -55, -55, -56, -57,
-54, -51, -50, -51, -51, -51, -51, -51, -50, -50, -51, -51, -49, -46, -45, -46,
-46, -46, -46, -46, -46, -46, -44, -40, -39, -39, -39, -40, -39, -39, -40, -40,
-38, -34, -34, -34, -34, -34, -35, -32, -29, -30, -29, -29, -29, -29, -27, -24,
-25, -24, -24, -25, -25, -24, -24, -24, -25, -25, -25, -24, -25, -24, -24, -25,
-23, -20, -18, -15, -14, -15, -15, -15, -15, -15, -14, -15, -14, -15, -15, -15,
-15, -15, -14, -14, -15, -16, -13, -9, -7, -9, -7, -8, -8, -6, -3, -3, -3, -3,
-4, -4, -3, -3, -3, -3, -2, -4, -4, -3, -2, 0, 0, 0, 0, 0, 1, 0, 0, 0, };