#define DATA_LENGTH 512
#define DATA AKWF_vgsin_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 18, 16, 15, 16, 16, 15, 13, 21,
35, 38, 37, 36, 37, 37, 37, 36, 36, 37, 36, 36, 36, 36, 36, 37, 36, 35, 40, 51,
56, 54, 54, 54, 54, 53, 53, 60, 71, 73, 71, 71, 72, 72, 72, 72, 71, 72, 71, 72,
72, 72, 72, 72, 71, 70, 75, 84, 88, 85, 86, 86, 86, 86, 85, 90, 99, 100, 98, 98,
99, 98, 99, 98, 99, 99, 98, 99, 98, 98, 98, 97, 99, 106, 109, 108, 108, 108,
108, 108, 108, 107, 108, 111, 113, 113, 113, 113, 113, 114, 113, 112, 112, 112,
112, 112, 113, 112, 113, 113, 113, 117, 118, 117, 118, 117, 117, 118, 118, 117,
118, 118, 118, 117, 117, 117, 118, 118, 118, 117, 117, 118, 118, 117, 117, 117,
118, 118, 118, 115, 114, 115, 115, 114, 115, 114, 114, 115, 115, 111, 108, 107,
109, 109, 108, 108, 108, 108, 108, 109, 108, 108, 108, 108, 108, 109, 107, 100,
98, 99, 99, 99, 99, 98, 98, 99, 99, 93, 88, 87, 88, 87, 86, 87, 87, 87, 88, 87,
87, 88, 87, 89, 86, 79, 73, 74, 75, 74, 75, 74, 74, 76, 77, 68, 59, 57, 59, 58,
59, 59, 59, 58, 59, 58, 59, 59, 58, 59, 59, 61, 56, 45, 37, 40, 40, 40, 40, 40,
40, 40, 39, 41, 40, 28, 19, 20, 21, 21, 21, 20, 21, 21, 20, 20, 20, 20, 21, 22,
18, 6, 0, 0, 2, 1, 2, 1, 2, 1, 2, 2, 1, -10, -19, -17, -17, -17, -17, -17, -18,
-17, -18, -17, -17, -18, -18, -16, -21, -34, -40, -38, -37, -38, -38, -38, -38,
-38, -38, -37, -39, -49, -57, -56, -55, -56, -56, -55, -55, -55, -55, -55, -55,
-54, -57, -66, -71, -70, -70, -70, -70, -71, -70, -70, -70, -70, -70, -68, -71,
-81, -87, -86, -86, -86, -85, -86, -86, -86, -86, -86, -86, -85, -87, -95, -99,
-99, -97, -98, -98, -99, -99, -99, -98, -99, -99, -98, -99, -106, -109, -108,
-107, -108, -108, -108, -108, -108, -108, -108, -108, -107, -109, -113, -115,
-114, -114, -113, -114, -115, -114, -114, -114, -114, -114, -113, -115, -119,
-119, -118, -119, -119, -119, -119, -120, -119, -119, -119, -119, -119, -119,
-118, -118, -120, -119, -119, -119, -119, -120, -120, -118, -119, -120, -117,
-115, -111, -111, -111, -112, -111, -112, -111, -111, -111, -111, -111, -111,
-111, -111, -111, -111, -111, -110, -111, -111, -110, -111, -111, -111, -111,
-111, -107, -99, -93, -89, -90, -91, -91, -91, -90, -90, -91, -90, -91, -90,
-91, -91, -91, -90, -90, -91, -90, -90, -91, -90, -90, -90, -92, -89, -82, -71,
-62, -59, -60, -60, -60, -61, -60, -60, -61, -60, -60, -61, -60, -60, -60, -61,
-60, -60, -60, -60, -60, -60, -60, -61, -62, -59, -48, -35, -24, -21, -22, -23,
-22, -22, -22, -22, -23, -23, -22, -22, -22, -22, -22, -23, -22, -22, -22, -22,
-21, -23, -23, -22, -12, -6, -8, -2, };