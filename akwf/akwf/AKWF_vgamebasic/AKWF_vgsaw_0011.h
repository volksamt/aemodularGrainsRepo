#define DATA_LENGTH 512
#define DATA AKWF_vgsaw_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 3, 3, 3, 3, 4, 2, 3, 4, 6, 6, 6,
6, 7, 9, 9, 9, 9, 8, 9, 10, 11, 11, 11, 11, 11, 14, 16, 17, 16, 17, 17, 17, 17,
17, 17, 17, 18, 20, 21, 20, 21, 19, 20, 20, 21, 22, 21, 21, 22, 24, 25, 25, 24,
26, 27, 28, 28, 28, 28, 28, 29, 31, 31, 31, 31, 31, 31, 31, 32, 32, 32, 32, 33,
35, 36, 35, 35, 35, 36, 37, 38, 41, 42, 42, 42, 42, 41, 42, 42, 41, 41, 42, 43,
44, 43, 43, 44, 46, 47, 46, 47, 46, 46, 47, 49, 50, 50, 49, 50, 52, 53, 52, 53,
53, 52, 53, 54, 54, 54, 54, 54, 56, 57, 57, 58, 57, 57, 58, 59, 62, 64, 64, 64,
64, 63, 63, 64, 65, 65, 65, 65, 66, 65, 65, 64, 65, 66, 68, 68, 68, 68, 68, 71,
71, 71, 71, 71, 71, 73, 74, 74, 74, 74, 75, 76, 78, 77, 77, 77, 77, 78, 79, 79,
79, 79, 79, 82, 82, 82, 82, 82, 82, 83, 84, 85, 85, 84, 85, 87, 88, 88, 89, 90,
90, 90, 89, 90, 90, 89, 90, 93, 93, 93, 92, 93, 92, 93, 95, 96, 95, 95, 97, 99,
99, 99, 99, 99, 98, 100, 100, 101, 100, 100, 100, 104, 104, 104, 104, 103, 104,
103, 106, 107, 107, 106, 108, 111, 112, 112, 111, 112, 112, 109, 106, 116, 105,
12, -71, -66, -56, -59, -59, -59, -52, -70, -109, -120, -118, -119, -119, -115,
-112, -112, -113, -113, -113, -112, -107, -106, -107, -107, -106, -106, -104,
-104, -104, -104, -104, -104, -103, -103, -104, -104, -103, -101, -100, -100,
-100, -100, -100, -100, -97, -97, -98, -98, -97, -95, -94, -94, -94, -94, -94,
-92, -93, -92, -93, -93, -93, -90, -89, -89, -90, -90, -90, -89, -88, -87, -87,
-87, -86, -85, -83, -83, -83, -84, -84, -84, -82, -81, -79, -79, -79, -79, -79,
-79, -79, -78, -80, -78, -77, -76, -76, -76, -75, -73, -73, -73, -73, -73, -72,
-73, -72, -71, -71, -71, -72, -69, -68, -68, -68, -68, -68, -67, -66, -65, -65,
-65, -65, -63, -61, -62, -62, -63, -62, -61, -61, -60, -60, -61, -61, -58, -58,
-57, -56, -54, -54, -54, -54, -54, -55, -54, -54, -53, -51, -51, -51, -51, -51,
-51, -50, -50, -50, -50, -49, -47, -46, -46, -47, -46, -46, -46, -44, -43, -43,
-44, -44, -41, -40, -40, -40, -40, -41, -40, -39, -38, -39, -38, -38, -37, -34,
-35, -36, -35, -35, -36, -33, -32, -32, -32, -29, -29, -30, -29, -30, -29, -29,
-30, -28, -27, -27, -28, -28, -27, -24, -25, -24, -25, -25, -24, -23, -21, -22,
-21, -22, -21, -18, -17, -16, -17, -17, -17, -17, -17, -17, -17, -16, -17, -17,
-16, -14, -13, -14, -14, -13, -10, -11, -11, -10, -11, -11, -8, -8, -8, -7, -5,
-5, -5, -4, -4, -5, -4, -5, -4, -3, -3, -3, -3, 0, 0, -1, };