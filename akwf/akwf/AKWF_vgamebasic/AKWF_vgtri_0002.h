#define DATA_LENGTH 512
#define DATA AKWF_vgtri_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {5, 9, 8, 8, 8, 8, 8, 9, 8, 8, 8, 8, 8,
8, 9, 8, 8, 8, 8, 8, 9, 7, 6, 14, 23, 22, 25, 36, 41, 39, 39, 39, 40, 39, 39,
40, 39, 39, 39, 39, 39, 39, 39, 39, 40, 39, 39, 39, 39, 39, 39, 39, 38, 42, 52,
55, 54, 53, 54, 54, 54, 53, 53, 54, 54, 54, 54, 54, 53, 53, 57, 67, 70, 69, 68,
68, 69, 68, 68, 67, 71, 83, 87, 85, 85, 84, 85, 85, 84, 85, 85, 84, 85, 85, 85,
85, 85, 85, 85, 85, 85, 84, 88, 98, 101, 100, 97, 103, 114, 118, 116, 116, 116,
117, 116, 115, 116, 116, 116, 116, 116, 115, 116, 117, 116, 116, 116, 116, 116,
116, 115, 116, 116, 116, 114, 112, 110, 111, 111, 111, 110, 111, 111, 111, 111,
111, 110, 111, 113, 108, 97, 93, 95, 95, 95, 94, 94, 95, 95, 95, 95, 90, 81, 78,
80, 80, 80, 80, 80, 80, 80, 80, 79, 80, 80, 79, 80, 80, 80, 80, 82, 77, 66, 62,
64, 64, 64, 65, 58, 50, 48, 49, 48, 49, 49, 49, 48, 49, 48, 49, 49, 49, 49, 49,
50, 50, 49, 49, 49, 49, 49, 48, 50, 47, 37, 26, 18, 18, 19, 18, 18, 18, 18, 18,
18, 18, 18, 18, 19, 19, 18, 18, 18, 18, 18, 18, 18, 17, 19, 18, 18, 19, 11, 3,
2, 3, 3, 4, 3, 3, 3, 3, 3, 4, 3, 3, 3, 3, 3, 4, 1, -9, -14, -12, -12, -11, -12,
-11, -11, -18, -27, -27, -26, -26, -26, -26, -26, -26, -26, -26, -26, -26, -26,
-25, -26, -26, -26, -26, -26, -26, -27, -24, -28, -39, -43, -42, -50, -58, -57,
-57, -57, -58, -57, -56, -57, -57, -58, -58, -57, -57, -57, -57, -57, -57, -56,
-58, -57, -57, -57, -57, -57, -56, -56, -67, -74, -73, -73, -74, -73, -73, -73,
-74, -73, -73, -74, -74, -73, -74, -72, -75, -84, -89, -88, -89, -88, -88, -88,
-89, -86, -88, -97, -104, -103, -102, -103, -102, -103, -103, -103, -103, -103,
-103, -102, -103, -103, -103, -103, -103, -103, -103, -101, -103, -113, -120,
-120, -120, -118, -114, -111, -111, -112, -111, -111, -111, -111, -111, -112,
-111, -111, -112, -111, -111, -110, -111, -110, -111, -110, -111, -111, -112,
-111, -111, -113, -109, -99, -93, -94, -95, -94, -94, -94, -95, -95, -95, -94,
-95, -95, -94, -94, -96, -92, -83, -79, -79, -81, -79, -80, -80, -79, -82, -78,
-68, -61, -64, -65, -64, -64, -64, -64, -64, -64, -64, -64, -63, -63, -64, -64,
-64, -63, -63, -64, -65, -61, -52, -47, -48, -50, -47, -36, -32, -33, -33, -32,
-33, -32, -32, -33, -33, -33, -32, -33, -32, -32, -33, -33, -33, -33, -33, -32,
-33, -33, -34, -32, -25, -15, -5, -2, -3, -3, -4, -3, -3, -3, -4, -3, -4, -4,
-3, -3, -3, -4, -3, -3, -3, -3, -3, -3, -3, -3, -3, -4, -1, };