#define DATA_LENGTH 512
#define DATA AKWF_vgtri_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 5, 4, 4, 5, 5, 5, 4, 4, 6, 11,
14, 13, 13, 13, 14, 13, 12, 16, 22, 23, 22, 22, 22, 23, 22, 22, 21, 23, 30, 32,
31, 30, 30, 31, 30, 30, 35, 40, 40, 41, 40, 41, 39, 40, 40, 40, 42, 48, 49, 48,
48, 48, 49, 47, 48, 55, 59, 58, 58, 58, 59, 58, 58, 61, 65, 67, 65, 66, 66, 66,
66, 65, 66, 67, 74, 77, 76, 75, 76, 76, 76, 76, 75, 76, 81, 84, 84, 83, 84, 83,
84, 91, 94, 94, 93, 93, 93, 93, 94, 93, 93, 93, 94, 100, 102, 101, 102, 101,
101, 100, 101, 106, 111, 111, 111, 111, 111, 111, 116, 120, 119, 120, 119, 119,
119, 119, 119, 120, 120, 118, 114, 109, 109, 109, 110, 109, 109, 109, 109, 110,
105, 101, 100, 102, 102, 98, 91, 91, 91, 92, 92, 91, 92, 91, 92, 92, 92, 93, 91,
87, 82, 83, 84, 84, 83, 84, 85, 82, 75, 73, 75, 76, 73, 67, 65, 66, 66, 66, 66,
66, 66, 66, 65, 67, 66, 67, 63, 56, 56, 56, 56, 57, 57, 57, 56, 56, 55, 49, 48,
48, 42, 37, 39, 39, 38, 39, 39, 38, 39, 38, 39, 39, 39, 38, 39, 34, 29, 28, 29,
28, 30, 29, 29, 29, 30, 27, 22, 16, 11, 10, 11, 11, 12, 12, 11, 11, 11, 11, 11,
12, 12, 12, 12, 12, 8, 4, 3, 2, 3, 3, 4, 3, 3, -2, -8, -13, -14, -13, -13, -13,
-13, -13, -12, -13, -13, -13, -13, -12, -14, -13, -11, -14, -21, -24, -22, -22,
-22, -23, -23, -23, -22, -23, -28, -31, -31, -31, -30, -31, -31, -30, -34, -39,
-41, -40, -40, -40, -40, -40, -41, -39, -42, -46, -49, -48, -49, -49, -48, -48,
-48, -54, -59, -59, -57, -59, -58, -58, -58, -58, -58, -61, -65, -67, -66, -65,
-65, -66, -65, -66, -72, -76, -76, -76, -76, -76, -76, -75, -78, -83, -84, -84,
-84, -84, -84, -84, -84, -82, -86, -92, -94, -93, -94, -94, -93, -93, -93, -93,
-94, -99, -102, -101, -102, -101, -101, -103, -109, -112, -111, -111, -110,
-111, -111, -111, -111, -111, -110, -112, -118, -119, -120, -120, -119, -120,
-120, -119, -116, -112, -112, -113, -113, -113, -113, -108, -104, -104, -104,
-104, -105, -104, -105, -105, -105, -104, -105, -98, -94, -94, -96, -95, -96,
-95, -96, -95, -96, -91, -86, -86, -87, -87, -83, -77, -76, -77, -77, -77, -77,
-77, -77, -77, -77, -77, -78, -78, -72, -69, -69, -69, -69, -69, -69, -70, -66,
-60, -58, -60, -60, -58, -53, -51, -51, -51, -51, -52, -51, -51, -51, -51, -52,
-52, -52, -48, -42, -42, -42, -42, -43, -43, -41, -42, -42, -39, -35, -34, -33,
-28, -23, -24, -25, -24, -25, -24, -24, -24, -24, -24, -24, -24, -24, -25, -20,
-16, -15, -16, -17, -17, -16, -16, -16, -9, -6, -7, -3, 0, 1, 0, 0, 0, 0, 0, 0,
0, };