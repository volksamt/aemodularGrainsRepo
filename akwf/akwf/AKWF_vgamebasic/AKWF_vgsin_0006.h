#define DATA_LENGTH 512
#define DATA AKWF_vgsin_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 8, 6, 6, 6, 6, 6, 5, 7, 7, 6, 7, 6,
6, 6, 6, 7, 6, 5, 6, 16, 25, 25, 24, 24, 31, 38, 39, 37, 39, 38, 38, 37, 38, 38,
38, 38, 39, 39, 38, 37, 37, 45, 53, 54, 53, 53, 52, 52, 52, 52, 52, 57, 67, 75,
78, 78, 78, 78, 78, 78, 78, 78, 78, 77, 78, 77, 78, 78, 79, 78, 78, 77, 77, 83,
89, 89, 89, 89, 89, 90, 95, 100, 98, 98, 98, 98, 98, 98, 99, 99, 98, 98, 98,
101, 106, 108, 106, 106, 106, 107, 107, 107, 107, 106, 106, 107, 112, 114, 116,
116, 116, 116, 117, 116, 116, 117, 116, 116, 116, 116, 117, 116, 116, 115, 116,
116, 117, 117, 118, 117, 117, 118, 117, 118, 117, 117, 118, 118, 117, 117, 117,
118, 117, 117, 118, 117, 118, 117, 114, 115, 114, 115, 114, 114, 114, 114, 114,
113, 111, 109, 109, 106, 103, 103, 103, 104, 103, 104, 104, 103, 103, 103, 103,
103, 103, 103, 104, 104, 104, 102, 96, 94, 96, 96, 95, 96, 96, 95, 89, 85, 85,
86, 85, 86, 86, 87, 86, 86, 86, 86, 87, 83, 76, 74, 74, 75, 74, 75, 75, 75, 76,
73, 63, 60, 61, 53, 47, 47, 48, 47, 48, 48, 48, 48, 48, 47, 47, 47, 48, 48, 48,
47, 49, 45, 36, 32, 33, 34, 33, 33, 34, 34, 24, 15, 14, 16, 16, 16, 15, 16, 16,
15, 17, 16, 7, -1, 1, 1, 2, 2, 2, 2, 2, 1, 3, 0, -10, -13, -12, -22, -31, -30,
-29, -30, -30, -30, -31, -30, -30, -30, -29, -30, -30, -30, -29, -30, -39, -45,
-46, -44, -45, -45, -45, -45, -43, -44, -51, -58, -58, -57, -57, -56, -57, -57,
-57, -58, -56, -56, -68, -74, -73, -73, -73, -73, -73, -73, -72, -73, -79, -85,
-85, -83, -83, -89, -94, -94, -93, -93, -93, -94, -93, -93, -94, -93, -93, -94,
-94, -93, -93, -94, -99, -104, -104, -104, -102, -103, -102, -104, -103, -103,
-106, -110, -110, -109, -110, -109, -109, -113, -115, -114, -114, -115, -114,
-114, -115, -114, -114, -115, -114, -115, -114, -114, -116, -118, -118, -117,
-118, -118, -119, -119, -120, -119, -119, -118, -120, -119, -119, -119, -120,
-120, -120, -118, -119, -120, -118, -118, -117, -117, -117, -117, -117, -118,
-118, -118, -116, -114, -114, -114, -114, -115, -114, -114, -114, -114, -112,
-110, -110, -110, -110, -110, -110, -110, -110, -109, -110, -110, -106, -103,
-103, -104, -105, -99, -94, -93, -93, -94, -94, -94, -94, -94, -94, -94, -94,
-94, -94, -95, -91, -85, -83, -85, -84, -84, -84, -84, -84, -84, -85, -84, -80,
-73, -72, -73, -74, -73, -73, -73, -73, -75, -68, -58, -56, -57, -58, -57, -57,
-56, -57, -58, -54, -46, -42, -45, -44, -46, -46, -39, -30, -30, -30, -30, -30,
-31, -30, -30, -31, -31, -30, -30, -30, -31, -26, -14, -11, -13, -12, -13, -13,
-13, -12, -15, -9, };