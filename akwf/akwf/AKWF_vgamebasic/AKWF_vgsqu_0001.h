#define DATA_LENGTH 512
#define DATA AKWF_vgsqu_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {67, 123, 108, 105, 106, 108, 107, 107,
108, 111, 111, 112, 111, 111, 112, 111, 112, 112, 111, 111, 112, 112, 112, 112,
112, 112, 111, 112, 111, 111, 111, 111, 111, 112, 112, 112, 111, 111, 111, 112,
111, 111, 111, 112, 111, 112, 112, 112, 111, 112, 111, 111, 112, 112, 112, 112,
111, 112, 112, 111, 112, 112, 111, 111, 111, 111, 112, 112, 111, 112, 112, 111,
111, 111, 111, 112, 111, 112, 111, 111, 112, 112, 112, 112, 111, 112, 112, 111,
112, 112, 111, 112, 111, 111, 112, 112, 111, 112, 112, 111, 112, 112, 111, 111,
112, 112, 112, 111, 111, 112, 111, 111, 111, 112, 111, 111, 111, 112, 111, 111,
112, 112, 111, 111, 111, 112, 111, 112, 111, 112, 111, 112, 112, 112, 112, 111,
111, 111, 111, 112, 111, 111, 111, 111, 111, 112, 111, 111, 111, 111, 112, 112,
111, 111, 111, 111, 112, 112, 111, 111, 112, 111, 112, 112, 111, 112, 112, 111,
112, 111, 112, 112, 112, 112, 112, 111, 111, 112, 112, 112, 112, 111, 111, 112,
111, 111, 112, 112, 112, 112, 112, 111, 111, 111, 111, 111, 112, 112, 112, 111,
112, 112, 111, 112, 112, 112, 112, 112, 112, 111, 111, 111, 112, 111, 112, 112,
112, 112, 111, 112, 112, 112, 112, 111, 111, 112, 111, 112, 111, 112, 112, 112,
111, 110, 109, 110, 110, 109, 110, 110, 111, 110, 110, 109, 111, 110, 111, 109,
110, 110, 110, 110, 110, 110, 110, 110, 108, 110, 123, 90, -49, -123, -117,
-118, -117, -121, -119, -120, -118, -119, -119, -120, -119, -119, -119, -118,
-119, -117, -111, -111, -112, -111, -112, -112, -111, -111, -112, -112, -112,
-113, -112, -113, -114, -113, -113, -112, -113, -113, -113, -113, -113, -112,
-112, -113, -112, -113, -113, -114, -112, -113, -113, -113, -113, -113, -112,
-113, -113, -113, -113, -113, -113, -113, -112, -113, -113, -113, -114, -113,
-113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113,
-113, -113, -113, -114, -113, -114, -114, -113, -113, -113, -114, -113, -113,
-113, -113, -113, -113, -112, -113, -113, -112, -113, -113, -113, -113, -113,
-113, -113, -113, -113, -113, -113, -113, -113, -114, -113, -114, -113, -113,
-113, -113, -112, -114, -113, -113, -113, -113, -114, -113, -113, -113, -113,
-113, -113, -113, -113, -113, -114, -113, -113, -112, -113, -113, -113, -112,
-112, -114, -113, -113, -114, -113, -114, -113, -113, -112, -114, -113, -113,
-112, -113, -114, -113, -113, -113, -113, -113, -114, -114, -113, -113, -113,
-113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -114,
-114, -113, -113, -112, -113, -113, -113, -113, -113, -113, -112, -113, -114,
-114, -113, -113, -113, -114, -113, -113, -113, -113, -113, -113, -113, -112,
-113, -114, -113, -112, -113, -113, -113, -114, -112, -113, -113, -113, -113,
-114, -115, -114, -114, -114, -114, -115, -115, -115, -115, -115, -114, -114,
-114, -114, -115, -114, -115, -114, -115, -115, -114, -115, -114, -111, -116,
-120, -46, };