#define DATA_LENGTH 512
#define DATA AKWF_vgsaw_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 3, 6, 11, 10, 10, 11, 10, 10,
10, 10, 11, 10, 11, 10, 10, 10, 10, 10, 10, 10, 11, 10, 10, 10, 10, 14, 16, 17,
18, 22, 24, 24, 23, 24, 24, 24, 24, 24, 24, 23, 24, 24, 24, 24, 24, 24, 23, 23,
23, 23, 24, 22, 26, 30, 31, 31, 36, 38, 38, 38, 38, 37, 37, 38, 37, 38, 37, 37,
38, 37, 38, 38, 37, 38, 37, 37, 37, 37, 40, 45, 44, 43, 43, 47, 51, 51, 51, 51,
50, 50, 51, 51, 51, 51, 51, 51, 50, 50, 51, 51, 50, 51, 51, 51, 50, 53, 56, 58,
58, 57, 59, 63, 66, 65, 65, 65, 65, 65, 65, 65, 64, 65, 65, 65, 65, 65, 65, 65,
65, 65, 65, 64, 64, 69, 72, 73, 71, 71, 75, 79, 78, 78, 79, 78, 78, 78, 79, 79,
78, 78, 78, 79, 78, 79, 79, 78, 79, 78, 79, 84, 86, 85, 84, 85, 85, 86, 89, 91,
91, 89, 90, 90, 90, 90, 90, 91, 90, 90, 90, 90, 91, 91, 91, 89, 89, 91, 94, 98,
97, 96, 96, 97, 97, 102, 104, 104, 103, 104, 104, 104, 104, 103, 104, 105, 104,
104, 103, 103, 103, 104, 103, 104, 103, 106, 111, 111, 110, 111, 111, 109, 112,
116, 117, 116, 116, 115, 117, 116, 115, 115, 116, 115, 116, 115, 117, 115, 116,
115, 115, 115, 116, 115, 112, 112, 121, 101, -33, -121, -116, -118, -117, -121,
-118, -119, -119, -119, -119, -118, -119, -119, -119, -119, -118, -119, -119,
-118, -118, -115, -116, -116, -115, -115, -116, -116, -116, -113, -110, -110,
-110, -111, -111, -111, -111, -110, -111, -111, -110, -111, -111, -111, -110,
-111, -111, -110, -105, -103, -104, -103, -105, -104, -103, -104, -102, -98,
-96, -97, -98, -97, -97, -97, -97, -97, -97, -97, -96, -97, -97, -97, -97, -98,
-97, -94, -90, -90, -91, -90, -90, -90, -91, -89, -85, -83, -84, -83, -84, -83,
-84, -83, -83, -84, -83, -83, -83, -83, -84, -83, -83, -84, -82, -77, -75, -77,
-76, -76, -77, -77, -77, -73, -70, -70, -70, -70, -69, -69, -70, -69, -70, -70,
-70, -69, -70, -70, -70, -70, -66, -63, -62, -63, -63, -63, -63, -63, -63, -63,
-61, -57, -55, -55, -56, -56, -55, -56, -55, -56, -56, -56, -57, -55, -56, -56,
-57, -55, -51, -49, -49, -49, -49, -49, -49, -49, -50, -50, -45, -42, -42, -43,
-42, -42, -42, -42, -43, -42, -42, -42, -43, -42, -42, -42, -43, -39, -35, -35,
-36, -36, -36, -35, -36, -37, -37, -33, -29, -29, -29, -29, -29, -29, -29, -29,
-29, -29, -29, -28, -28, -29, -29, -30, -27, -23, -21, -23, -23, -22, -23, -21,
-23, -23, -21, -17, -14, -15, -16, -15, -15, -15, -16, -15, -15, -16, -15, -16,
-15, -15, -12, -11, -10, -10, -10, -10, -10, -10, -10, -9, -10, -10, -7, -4, -3,
-4, -4, -3, -3, -3, -3, -4, -4, -4, -3, -4, -4, -3, };