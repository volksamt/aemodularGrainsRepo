#define DATA_LENGTH 512
#define DATA AKWF_vgsin_0014

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 3, 5, 5, 7, 10, 9, 11, 14, 14, 14,
17, 19, 19, 21, 23, 24, 24, 27, 28, 28, 28, 29, 31, 33, 33, 36, 40, 40, 40, 44,
44, 44, 47, 49, 49, 51, 53, 53, 54, 57, 60, 62, 62, 62, 62, 62, 65, 67, 67, 69,
72, 71, 71, 74, 75, 75, 77, 79, 78, 80, 83, 82, 83, 85, 86, 85, 87, 89, 91, 93,
92, 92, 92, 92, 92, 95, 97, 97, 97, 98, 98, 99, 101, 101, 102, 103, 103, 103,
104, 106, 106, 106, 108, 109, 109, 108, 110, 110, 109, 110, 111, 111, 112, 112,
112, 114, 114, 115, 115, 115, 116, 116, 115, 116, 116, 116, 118, 118, 118, 117,
118, 117, 118, 118, 118, 117, 117, 118, 118, 117, 118, 117, 118, 118, 117, 115,
115, 116, 116, 116, 116, 115, 114, 114, 114, 115, 114, 114, 114, 113, 112, 111,
111, 111, 111, 110, 109, 110, 109, 107, 108, 108, 105, 105, 104, 104, 103, 103,
103, 104, 102, 100, 99, 100, 97, 97, 96, 95, 93, 94, 93, 91, 90, 90, 89, 87, 88,
87, 84, 84, 84, 81, 79, 80, 78, 76, 77, 75, 73, 73, 72, 71, 68, 68, 68, 65, 65,
65, 61, 60, 61, 59, 55, 55, 55, 52, 52, 53, 53, 52, 49, 47, 48, 43, 39, 39, 40,
37, 36, 36, 34, 31, 27, 27, 27, 27, 26, 23, 20, 21, 19, 15, 16, 15, 12, 11, 12,
8, 6, 6, 5, 1, 1, 1, -2, -3, -3, -6, -9, -11, -12, -13, -12, -12, -15, -18, -17,
-19, -22, -23, -22, -21, -24, -28, -29, -28, -31, -35, -35, -36, -39, -40, -40,
-43, -45, -44, -46, -50, -49, -50, -53, -54, -54, -55, -56, -57, -58, -62, -63,
-63, -65, -67, -67, -68, -69, -69, -70, -73, -75, -75, -77, -79, -78, -78, -81,
-80, -81, -84, -86, -86, -85, -86, -87, -89, -89, -90, -93, -94, -94, -96, -97,
-97, -98, -100, -101, -100, -102, -102, -101, -104, -105, -105, -106, -106,
-106, -107, -108, -109, -109, -111, -111, -111, -112, -112, -113, -113, -113,
-114, -114, -114, -116, -115, -116, -115, -115, -116, -116, -118, -117, -118,
-118, -117, -118, -118, -118, -119, -119, -119, -119, -119, -119, -120, -119,
-118, -119, -119, -119, -119, -119, -119, -119, -118, -118, -118, -117, -118,
-117, -117, -118, -116, -115, -116, -116, -114, -115, -113, -113, -113, -113,
-111, -111, -111, -110, -109, -109, -110, -109, -107, -108, -109, -108, -107,
-104, -102, -101, -101, -101, -101, -100, -100, -100, -99, -97, -97, -97, -95,
-94, -94, -92, -90, -91, -89, -88, -87, -87, -86, -84, -85, -83, -79, -77, -76,
-76, -77, -76, -74, -72, -74, -72, -69, -68, -68, -66, -63, -64, -63, -61, -60,
-61, -61, -58, -56, -56, -55, -52, -49, -49, -47, -45, -44, -44, -41, -39, -39,
-37, -35, -35, -34, -31, -30, -31, -27, -26, -25, -24, -21, -21, -21, -17, -16,
-17, -14, -10, -11, -11, -7, -6, -6, -3, 0, 0, };