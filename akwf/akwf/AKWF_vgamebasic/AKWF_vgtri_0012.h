#define DATA_LENGTH 512
#define DATA AKWF_vgtri_0012

const PROGMEM int8_t DATA[DATA_LENGTH] = {2, 4, 3, 2, 3, 7, 11, 14, 15, 15, 14,
15, 15, 15, 14, 17, 19, 20, 19, 19, 21, 24, 25, 24, 24, 25, 28, 30, 29, 29, 30,
32, 34, 33, 36, 39, 39, 38, 38, 39, 38, 38, 39, 45, 45, 45, 45, 45, 48, 50, 50,
50, 50, 53, 56, 55, 54, 55, 58, 59, 59, 61, 64, 65, 64, 65, 64, 64, 66, 69, 70,
69, 69, 69, 69, 71, 74, 74, 74, 73, 76, 80, 81, 81, 80, 81, 85, 86, 85, 88, 91,
91, 89, 90, 91, 90, 94, 95, 95, 94, 95, 97, 100, 100, 100, 99, 102, 105, 105,
105, 105, 105, 105, 108, 109, 109, 110, 115, 116, 116, 116, 117, 116, 117, 117,
118, 117, 118, 117, 114, 112, 113, 113, 113, 109, 107, 107, 108, 107, 105, 102,
102, 103, 103, 100, 98, 97, 97, 98, 99, 98, 94, 91, 92, 93, 92, 88, 86, 86, 87,
87, 85, 82, 82, 83, 82, 81, 77, 77, 77, 78, 76, 73, 71, 72, 73, 72, 69, 67, 67,
67, 67, 68, 67, 63, 62, 63, 64, 62, 57, 55, 56, 56, 56, 53, 51, 52, 52, 51, 49,
46, 47, 47, 46, 44, 41, 42, 42, 42, 40, 37, 37, 37, 38, 36, 32, 32, 32, 32, 32,
32, 30, 27, 26, 28, 27, 25, 21, 20, 21, 21, 20, 17, 15, 16, 16, 15, 13, 12, 11,
12, 11, 8, 6, 6, 7, 6, 3, 1, 1, 2, 2, 1, -3, -5, -7, -6, -6, -7, -6, -6, -7, -6,
-6, -10, -13, -13, -12, -12, -14, -17, -18, -18, -18, -18, -22, -22, -23, -22,
-24, -26, -29, -32, -32, -32, -33, -32, -32, -32, -32, -35, -37, -37, -37, -38,
-36, -37, -41, -42, -41, -41, -42, -45, -49, -49, -47, -48, -50, -54, -56, -59,
-59, -58, -57, -59, -58, -58, -60, -63, -63, -63, -63, -63, -67, -68, -68, -68,
-68, -71, -72, -72, -72, -73, -72, -72, -75, -80, -83, -85, -84, -83, -84, -84,
-83, -83, -86, -89, -88, -89, -88, -91, -93, -94, -94, -92, -96, -98, -99, -99,
-102, -103, -103, -102, -104, -106, -108, -108, -108, -108, -108, -108, -107,
-109, -112, -112, -113, -112, -114, -118, -120, -119, -119, -118, -118, -118,
-117, -119, -117, -114, -113, -113, -110, -108, -107, -108, -107, -108, -108,
-105, -103, -103, -104, -104, -101, -99, -98, -97, -98, -98, -98, -96, -93, -93,
-94, -94, -91, -87, -87, -87, -84, -82, -82, -82, -82, -82, -81, -78, -77, -77,
-78, -77, -74, -72, -72, -73, -73, -69, -67, -68, -68, -67, -65, -62, -62, -63,
-63, -61, -58, -58, -57, -58, -58, -59, -55, -51, -52, -51, -52, -49, -46, -46,
-47, -46, -45, -42, -41, -43, -42, -40, -38, -36, -37, -38, -36, -33, -31, -32,
-32, -33, -29, -28, -27, -28, -27, -27, -27, -24, -22, -23, -23, -22, -18, -16,
-15, -17, -17, -13, -11, -11, -12, -12, -9, -7, -6, -6, -7, -5, -3, -1, -2, -2,
0, };