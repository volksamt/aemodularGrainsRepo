#define DATA_LENGTH 512
#define DATA AKWF_vgsin_0010

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 1, 1, 2, 2, 2, 5, 11, 12, 11,
11, 11, 11, 16, 21, 22, 19, 20, 26, 32, 32, 32, 31, 31, 32, 37, 41, 40, 39, 39,
39, 41, 46, 49, 48, 47, 48, 47, 48, 54, 57, 56, 56, 54, 54, 59, 64, 66, 65, 65,
64, 65, 70, 73, 73, 73, 74, 72, 73, 77, 80, 79, 80, 80, 78, 81, 86, 87, 87, 88,
87, 86, 89, 94, 94, 94, 94, 93, 93, 95, 99, 99, 99, 98, 98, 99, 101, 103, 103,
103, 104, 103, 104, 106, 108, 108, 108, 108, 107, 109, 110, 112, 111, 111, 111,
111, 113, 114, 114, 114, 114, 114, 114, 115, 116, 116, 115, 115, 116, 116, 117,
118, 117, 118, 117, 117, 117, 117, 118, 117, 118, 117, 118, 118, 118, 117, 117,
118, 117, 116, 115, 116, 116, 117, 115, 116, 115, 115, 114, 114, 115, 115, 113,
110, 109, 108, 108, 108, 108, 108, 108, 108, 107, 108, 108, 107, 104, 103, 104,
103, 103, 103, 102, 98, 97, 98, 98, 99, 98, 96, 91, 87, 86, 85, 86, 86, 86, 86,
86, 85, 87, 86, 84, 79, 76, 78, 77, 78, 78, 76, 72, 71, 72, 71, 72, 72, 68, 63,
57, 54, 54, 53, 54, 54, 54, 54, 55, 55, 50, 44, 44, 45, 44, 45, 44, 40, 38, 38,
38, 39, 33, 28, 28, 29, 29, 24, 19, 19, 18, 19, 19, 19, 19, 20, 20, 15, 10, 9,
9, 9, 9, 10, 3, -2, -2, -2, -1, -1, -2, -8, -12, -11, -15, -20, -22, -20, -20,
-20, -21, -21, -20, -20, -24, -30, -30, -30, -30, -30, -29, -35, -40, -39, -39,
-40, -39, -40, -46, -49, -49, -53, -56, -58, -57, -58, -57, -57, -57, -57, -56,
-60, -65, -67, -66, -66, -67, -66, -69, -75, -76, -74, -75, -74, -74, -78, -81,
-81, -83, -88, -89, -89, -88, -89, -89, -88, -89, -92, -94, -93, -93, -93, -93,
-94, -99, -100, -100, -99, -101, -100, -100, -105, -105, -105, -105, -106, -109,
-109, -109, -109, -110, -109, -110, -110, -111, -113, -112, -113, -113, -112,
-114, -114, -116, -116, -116, -116, -116, -116, -117, -118, -118, -118, -117,
-119, -119, -119, -120, -120, -119, -119, -119, -119, -118, -119, -119, -119,
-119, -119, -119, -120, -120, -119, -119, -119, -119, -118, -117, -117, -117,
-117, -117, -116, -116, -116, -116, -116, -116, -116, -115, -113, -112, -112,
-113, -112, -109, -109, -110, -110, -110, -109, -107, -105, -105, -104, -105,
-105, -105, -101, -100, -100, -99, -100, -100, -100, -97, -95, -95, -96, -96,
-96, -93, -89, -88, -89, -88, -89, -90, -86, -81, -80, -81, -80, -82, -80, -77,
-74, -75, -74, -75, -75, -74, -69, -66, -67, -66, -67, -68, -66, -59, -57, -57,
-57, -57, -58, -54, -49, -49, -49, -48, -50, -50, -45, -39, -39, -40, -40, -41,
-39, -34, -30, -30, -30, -30, -30, -29, -22, -19, -20, -20, -20, -22, -18, -11,
-10, -12, -10, -11, -12, -7, -1, 1, 1, 0, };