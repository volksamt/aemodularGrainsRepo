#define DATA_LENGTH 512
#define DATA AKWF_vgtri_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 5, 5, 7, 10, 10, 9, 10, 11, 13,
13, 13, 13, 15, 17, 17, 18, 21, 22, 23, 23, 23, 24, 26, 26, 28, 31, 30, 30, 30,
32, 34, 34, 33, 33, 35, 38, 38, 39, 41, 44, 46, 46, 46, 47, 46, 47, 47, 52, 51,
51, 51, 51, 55, 56, 55, 55, 55, 58, 59, 59, 62, 64, 65, 65, 64, 65, 67, 71, 73,
72, 72, 71, 73, 73, 76, 77, 78, 76, 77, 79, 80, 80, 82, 85, 86, 85, 85, 86, 88,
89, 89, 88, 89, 92, 95, 98, 98, 97, 98, 98, 98, 100, 101, 102, 101, 101, 103,
106, 106, 107, 109, 111, 112, 111, 112, 113, 114, 114, 115, 118, 119, 119, 117,
115, 115, 115, 115, 117, 115, 112, 111, 111, 108, 105, 106, 106, 106, 105, 103,
103, 104, 104, 101, 98, 97, 99, 95, 93, 94, 92, 90, 90, 91, 91, 88, 85, 85, 86,
86, 85, 82, 82, 82, 83, 81, 77, 76, 77, 74, 72, 72, 73, 73, 71, 69, 69, 69, 65,
64, 64, 65, 64, 61, 61, 61, 61, 61, 58, 56, 56, 55, 52, 51, 51, 52, 51, 49, 48,
48, 49, 47, 45, 43, 43, 41, 39, 39, 39, 39, 37, 35, 36, 35, 31, 31, 31, 31, 31,
28, 27, 27, 27, 27, 24, 23, 23, 21, 18, 17, 17, 18, 17, 14, 14, 15, 15, 13, 10,
9, 10, 6, 4, 4, 5, 5, 4, 1, 1, 1, -1, -1, -1, -2, -2, -5, -5, -5, -4, -5, -8,
-10, -10, -11, -15, -15, -14, -15, -16, -17, -17, -17, -17, -19, -21, -22, -23,
-25, -28, -28, -27, -28, -29, -31, -30, -31, -35, -37, -39, -39, -39, -39, -39,
-39, -38, -39, -43, -44, -42, -46, -48, -48, -48, -48, -50, -51, -51, -51, -55,
-56, -57, -57, -56, -58, -61, -64, -65, -64, -64, -63, -64, -66, -69, -70, -70,
-69, -70, -71, -72, -73, -71, -74, -76, -78, -77, -80, -82, -82, -81, -82, -83,
-85, -89, -91, -90, -90, -90, -90, -90, -92, -94, -93, -93, -93, -97, -99, -98,
-99, -103, -104, -103, -103, -103, -106, -106, -105, -106, -107, -110, -113,
-116, -116, -115, -116, -115, -116, -117, -119, -119, -119, -118, -118, -117,
-118, -117, -115, -114, -114, -115, -113, -110, -109, -110, -108, -104, -104,
-105, -101, -100, -101, -102, -101, -102, -101, -98, -96, -96, -93, -91, -91,
-92, -92, -90, -88, -89, -87, -84, -83, -84, -83, -82, -81, -80, -81, -78, -75,
-75, -76, -75, -73, -71, -71, -71, -71, -69, -68, -68, -66, -64, -62, -63, -63,
-63, -60, -59, -59, -60, -59, -57, -55, -56, -54, -51, -50, -50, -49, -50, -47,
-47, -46, -47, -46, -43, -42, -42, -40, -37, -36, -38, -37, -35, -34, -34, -34,
-30, -28, -29, -30, -28, -27, -25, -26, -27, -26, -23, -20, -21, -20, -17, -15,
-16, -16, -15, -14, -12, -12, -14, -13, -9, -8, -8, -6, -3, -3, -4, -3, -2, 0,
0, 0, -1, };