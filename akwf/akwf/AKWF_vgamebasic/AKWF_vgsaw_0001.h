#define DATA_LENGTH 512
#define DATA AKWF_vgsaw_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 7, 7, 6, 5, 8, 16, 17, 16, 16, 16,
16, 16, 17, 16, 17, 16, 17, 16, 16, 16, 17, 16, 16, 17, 17, 16, 16, 17, 17, 16,
15, 19, 24, 26, 24, 25, 26, 24, 25, 24, 24, 25, 25, 25, 25, 25, 25, 25, 25, 25,
25, 25, 25, 28, 33, 35, 32, 32, 37, 43, 44, 43, 42, 43, 43, 43, 44, 43, 43, 43,
43, 42, 42, 43, 43, 43, 43, 43, 43, 43, 43, 43, 43, 43, 42, 45, 51, 52, 51, 51,
52, 51, 51, 51, 52, 52, 51, 52, 52, 51, 52, 52, 51, 51, 51, 53, 59, 59, 59, 60,
60, 59, 63, 68, 68, 67, 68, 68, 67, 67, 67, 68, 68, 68, 68, 67, 67, 68, 67, 68,
68, 68, 68, 67, 68, 67, 68, 67, 66, 73, 78, 78, 78, 78, 78, 78, 78, 77, 77, 78,
78, 78, 78, 78, 78, 78, 78, 77, 77, 80, 86, 87, 85, 86, 86, 86, 91, 95, 94, 95,
94, 95, 94, 94, 94, 94, 94, 94, 95, 94, 94, 94, 94, 94, 96, 103, 105, 104, 104,
104, 103, 104, 103, 104, 104, 104, 104, 103, 105, 104, 104, 104, 104, 103, 105,
104, 103, 104, 104, 104, 104, 104, 104, 107, 111, 111, 111, 111, 110, 110, 110,
111, 111, 110, 111, 111, 111, 111, 111, 111, 110, 111, 110, 112, 110, 112, 110,
111, 110, 110, 110, 111, 110, 108, 110, 122, 96, -44, -122, -116, -119, -118,
-120, -118, -120, -119, -120, -119, -120, -119, -120, -119, -120, -119, -118,
-120, -119, -113, -109, -109, -109, -109, -110, -108, -102, -98, -99, -100, -99,
-99, -99, -100, -100, -99, -98, -99, -99, -99, -99, -99, -100, -99, -99, -99,
-100, -99, -99, -99, -100, -100, -98, -93, -90, -90, -91, -91, -91, -91, -91,
-91, -90, -91, -90, -90, -91, -91, -91, -91, -91, -92, -91, -86, -82, -83, -82,
-83, -84, -81, -75, -71, -73, -74, -73, -73, -73, -73, -72, -72, -73, -73, -73,
-73, -73, -73, -73, -73, -73, -73, -73, -73, -72, -72, -72, -73, -71, -66, -63,
-64, -65, -65, -65, -65, -64, -64, -64, -64, -64, -65, -64, -65, -65, -64, -65,
-65, -64, -58, -56, -56, -57, -56, -57, -55, -47, -45, -47, -47, -47, -47, -46,
-46, -46, -46, -46, -46, -46, -46, -46, -46, -47, -47, -46, -46, -47, -47, -47,
-46, -46, -47, -45, -39, -38, -38, -38, -38, -38, -37, -38, -38, -38, -38, -38,
-38, -38, -38, -38, -38, -38, -39, -37, -31, -29, -30, -29, -30, -31, -27, -21,
-19, -21, -20, -19, -19, -20, -20, -19, -20, -21, -19, -20, -19, -20, -19, -20,
-20, -21, -20, -20, -20, -20, -20, -20, -21, -17, -12, -11, -12, -11, -12, -11,
-11, -11, -12, -11, -11, -11, -12, -12, -12, -11, -11, -12, -12, -10, -4, -2,
-4, -3, -3, -3, -3, 0, 1, 0, 0, 1, -1, 0, 0, 0, 0, 0, -1, 0, 1, 0, 0, 0, 0, 0,
-1, 0, };