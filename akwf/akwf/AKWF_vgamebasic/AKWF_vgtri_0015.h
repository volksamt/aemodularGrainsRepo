#define DATA_LENGTH 512
#define DATA AKWF_vgtri_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 2, 4, 3, 4, 5, 4, 6, 7, 8, 8, 9,
12, 14, 15, 14, 15, 17, 16, 16, 18, 19, 19, 21, 22, 22, 24, 26, 28, 29, 28, 29,
30, 31, 30, 33, 33, 34, 35, 38, 39, 39, 39, 41, 41, 41, 43, 45, 45, 44, 46, 49,
48, 48, 51, 53, 54, 54, 55, 56, 56, 56, 58, 59, 58, 60, 62, 65, 65, 65, 65, 66,
66, 67, 69, 70, 70, 71, 72, 72, 73, 76, 79, 80, 79, 80, 81, 81, 80, 83, 84, 84,
85, 86, 89, 91, 90, 91, 92, 93, 93, 93, 95, 95, 96, 98, 98, 99, 100, 102, 104,
105, 105, 106, 107, 106, 107, 109, 109, 110, 112, 113, 116, 116, 116, 117, 117,
118, 116, 114, 115, 113, 111, 111, 111, 109, 108, 105, 105, 105, 104, 102, 104,
102, 100, 99, 100, 98, 96, 94, 93, 93, 92, 92, 92, 91, 90, 89, 88, 86, 85, 86,
84, 82, 81, 80, 80, 79, 77, 78, 78, 75, 75, 75, 73, 71, 68, 68, 68, 67, 67, 67,
66, 64, 63, 63, 62, 60, 57, 57, 57, 56, 56, 56, 55, 53, 53, 52, 50, 49, 49, 47,
46, 44, 43, 43, 42, 41, 41, 41, 39, 38, 38, 36, 35, 33, 32, 31, 31, 30, 30, 30,
27, 27, 28, 25, 24, 24, 23, 20, 20, 17, 18, 16, 16, 17, 15, 14, 13, 13, 11, 10,
8, 7, 7, 6, 4, 5, 4, 3, 1, 1, 0, -1, -2, -2, -3, -4, -7, -6, -6, -7, -8, -8, -9,
-11, -11, -12, -14, -16, -17, -18, -18, -19, -19, -19, -21, -22, -22, -22, -25,
-26, -25, -27, -30, -32, -32, -32, -33, -33, -32, -35, -37, -37, -36, -39, -41,
-43, -43, -43, -43, -44, -44, -46, -48, -47, -48, -50, -50, -51, -52, -54, -56,
-57, -57, -58, -58, -59, -59, -62, -63, -62, -64, -65, -68, -68, -69, -69, -70,
-72, -74, -73, -73, -73, -75, -76, -77, -77, -79, -81, -83, -82, -83, -84, -84,
-85, -87, -88, -88, -88, -91, -93, -94, -94, -94, -95, -95, -95, -97, -99, -98,
-100, -101, -101, -102, -104, -107, -108, -108, -108, -109, -109, -110, -112,
-114, -112, -114, -116, -118, -119, -120, -119, -117, -117, -116, -116, -114,
-114, -114, -112, -108, -107, -109, -108, -106, -107, -106, -104, -103, -103,
-101, -100, -100, -99, -98, -95, -93, -94, -94, -93, -92, -92, -90, -89, -89,
-89, -85, -84, -83, -82, -82, -81, -81, -81, -79, -77, -77, -77, -75, -75, -75,
-73, -70, -68, -68, -68, -67, -67, -67, -65, -64, -63, -63, -61, -59, -58, -57,
-57, -56, -55, -55, -54, -52, -53, -52, -50, -49, -49, -48, -45, -43, -43, -43,
-42, -41, -41, -40, -39, -38, -38, -36, -34, -32, -32, -31, -31, -31, -30, -29,
-28, -27, -27, -24, -23, -24, -23, -21, -19, -17, -18, -17, -16, -15, -15, -13,
-13, -13, -11, -9, -7, -7, -7, -6, -5, -5, -5, -2, -1, -2, -1, 0, 0, };