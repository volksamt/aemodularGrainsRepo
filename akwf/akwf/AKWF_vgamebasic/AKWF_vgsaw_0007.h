#define DATA_LENGTH 512
#define DATA AKWF_vgsaw_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 0, 0, 1, 2, 2, 2, 1, 2, 2, 2, 1, 1,
2, 2, 2, 2, 1, 1, 4, 4, 5, 4, 4, 5, 5, 4, 6, 9, 12, 15, 15, 14, 14, 15, 15, 14,
15, 16, 16, 15, 14, 15, 15, 14, 14, 17, 20, 20, 19, 20, 19, 20, 19, 19, 20, 20,
23, 22, 23, 23, 23, 22, 23, 24, 27, 28, 28, 28, 28, 28, 28, 27, 28, 28, 32, 33,
33, 33, 32, 32, 33, 32, 34, 37, 37, 38, 38, 37, 37, 38, 38, 37, 39, 41, 42, 41,
40, 40, 40, 40, 41, 45, 46, 46, 45, 46, 45, 46, 46, 49, 51, 51, 51, 51, 51, 50,
50, 50, 50, 53, 55, 55, 55, 55, 55, 56, 55, 56, 55, 56, 59, 59, 59, 60, 58, 58,
61, 64, 64, 64, 63, 63, 63, 64, 63, 63, 64, 64, 67, 69, 68, 69, 69, 68, 68, 68,
70, 74, 74, 73, 74, 73, 73, 75, 77, 76, 76, 77, 77, 77, 77, 76, 77, 76, 77, 81,
82, 81, 82, 82, 82, 81, 82, 81, 81, 85, 87, 86, 86, 87, 89, 92, 92, 91, 92, 91,
91, 91, 90, 91, 92, 91, 90, 92, 97, 96, 96, 96, 96, 97, 96, 97, 96, 98, 100, 99,
100, 103, 105, 104, 104, 104, 104, 105, 105, 105, 105, 104, 105, 105, 105, 104,
108, 110, 110, 109, 110, 110, 109, 109, 111, 116, 116, 115, 114, 113, 112, 113,
113, 113, 112, 112, 113, 112, 114, 111, 112, 120, 104, -26, -122, -114, -110,
-109, -111, -110, -111, -110, -112, -116, -119, -114, -112, -112, -113, -113,
-113, -112, -112, -113, -112, -112, -113, -113, -113, -113, -112, -112, -109,
-108, -107, -108, -107, -108, -109, -108, -104, -103, -99, -99, -99, -99, -100,
-99, -100, -99, -99, -100, -99, -100, -100, -99, -99, -99, -98, -94, -94, -94,
-95, -95, -94, -94, -94, -95, -94, -91, -89, -89, -90, -90, -90, -90, -90, -87,
-84, -84, -84, -84, -85, -84, -84, -85, -84, -84, -82, -81, -81, -81, -82, -81,
-81, -80, -77, -76, -77, -77, -77, -76, -74, -71, -71, -72, -71, -71, -71, -71,
-72, -72, -72, -72, -70, -67, -67, -67, -66, -67, -67, -67, -66, -64, -63, -64,
-63, -63, -64, -63, -63, -64, -63, -59, -59, -58, -58, -59, -59, -58, -58, -59,
-57, -55, -54, -54, -54, -53, -54, -52, -50, -49, -49, -49, -49, -49, -49, -49,
-49, -49, -49, -47, -46, -46, -46, -46, -45, -46, -46, -45, -42, -40, -41, -41,
-41, -41, -39, -37, -36, -35, -36, -35, -36, -35, -35, -36, -36, -36, -34, -31,
-31, -32, -31, -31, -31, -32, -31, -31, -30, -27, -28, -29, -28, -26, -23, -23,
-23, -23, -22, -23, -23, -23, -23, -23, -23, -24, -23, -19, -17, -18, -18, -17,
-18, -18, -18, -16, -12, -13, -13, -13, -12, -10, -10, -10, -10, -10, -10, -10,
-9, -10, -10, -10, -11, -9, -10, -8, -5, -4, -5, -5, -6, -4, -5, -5, -2, };