#define DATA_LENGTH 512
#define DATA AKWF_vgsin_0001

const PROGMEM int8_t DATA[DATA_LENGTH] = {10, 18, 15, 14, 14, 15, 14, 15, 15,
14, 14, 15, 14, 14, 14, 14, 15, 12, 13, 27, 39, 39, 37, 38, 38, 39, 37, 38, 53,
63, 63, 62, 62, 62, 62, 62, 62, 62, 62, 61, 62, 62, 62, 62, 62, 62, 62, 61, 62,
62, 61, 62, 62, 62, 61, 60, 68, 81, 84, 82, 83, 83, 83, 82, 82, 82, 83, 82, 83,
82, 83, 83, 83, 83, 81, 83, 92, 100, 99, 98, 99, 99, 99, 97, 100, 107, 112, 111,
110, 111, 112, 111, 112, 111, 111, 111, 111, 111, 111, 111, 111, 111, 111, 112,
111, 111, 111, 112, 112, 111, 111, 111, 110, 113, 116, 116, 116, 116, 116, 116,
116, 115, 115, 115, 116, 116, 116, 116, 116, 115, 116, 116, 117, 117, 117, 117,
117, 118, 117, 118, 118, 116, 113, 111, 111, 111, 111, 112, 112, 112, 111, 111,
111, 111, 112, 110, 112, 110, 111, 110, 111, 111, 111, 111, 111, 112, 111, 111,
111, 111, 105, 99, 99, 100, 100, 100, 100, 100, 100, 100, 101, 100, 100, 100,
99, 100, 101, 99, 90, 83, 84, 85, 84, 85, 85, 84, 85, 86, 80, 67, 63, 65, 66,
66, 66, 65, 66, 66, 65, 65, 65, 66, 65, 66, 65, 65, 65, 65, 65, 65, 65, 65, 66,
65, 65, 67, 65, 50, 38, 39, 40, 40, 40, 39, 40, 40, 41, 40, 40, 39, 39, 39, 40,
42, 36, 21, 12, 13, 14, 15, 15, 14, 14, 15, 17, 7, -10, -13, -11, -11, -10, -12,
-11, -11, -11, -11, -11, -11, -11, -12, -11, -11, -10, -11, -12, -11, -11, -10,
-11, -11, -12, -12, -9, -13, -29, -40, -40, -39, -38, -38, -38, -38, -38, -38,
-38, -38, -38, -38, -38, -39, -36, -42, -57, -64, -63, -62, -62, -62, -61, -63,
-61, -60, -69, -81, -83, -81, -81, -81, -81, -81, -81, -81, -81, -81, -81, -81,
-81, -81, -81, -82, -81, -81, -81, -81, -81, -81, -81, -80, -81, -91, -102,
-109, -112, -111, -111, -112, -110, -111, -111, -111, -111, -111, -112, -111,
-111, -111, -112, -111, -111, -111, -111, -111, -111, -111, -112, -111, -111,
-111, -110, -114, -117, -118, -118, -118, -117, -118, -118, -118, -118, -118,
-117, -117, -118, -118, -117, -117, -117, -118, -117, -118, -118, -117, -117,
-117, -117, -118, -119, -119, -115, -114, -114, -114, -114, -114, -114, -114,
-114, -114, -114, -115, -114, -114, -115, -114, -114, -114, -114, -114, -114,
-114, -114, -114, -114, -114, -115, -113, -108, -103, -103, -104, -104, -104,
-103, -103, -103, -104, -101, -92, -88, -88, -89, -88, -89, -89, -89, -89, -89,
-89, -89, -89, -89, -89, -90, -91, -84, -70, -67, -68, -69, -68, -69, -69, -68,
-68, -69, -68, -69, -69, -68, -68, -69, -68, -68, -68, -68, -69, -68, -69, -68,
-67, -68, -70, -67, -52, -42, -44, -44, -44, -45, -44, -44, -45, -44, -45, -45,
-45, -44, -44, -44, -44, -44, -45, -44, -44, -44, -45, -44, -45, -47, -41, -26,
-6, };