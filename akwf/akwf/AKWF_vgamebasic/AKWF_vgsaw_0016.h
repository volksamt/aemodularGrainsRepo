#define DATA_LENGTH 512
#define DATA AKWF_vgsaw_0016

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 1, 2, 2, 4, 3, 3, 5, 6, 6, 6, 6,
7, 7, 7, 8, 9, 10, 10, 10, 11, 12, 13, 12, 13, 12, 12, 14, 14, 13, 14, 15, 15,
15, 17, 18, 18, 18, 19, 19, 20, 20, 19, 21, 22, 23, 23, 23, 24, 25, 25, 24, 25,
25, 25, 26, 26, 26, 27, 28, 28, 27, 29, 30, 31, 31, 31, 32, 33, 32, 33, 34, 35,
36, 36, 36, 37, 38, 37, 37, 36, 38, 37, 39, 39, 39, 40, 39, 40, 42, 42, 44, 44,
44, 45, 45, 45, 45, 46, 47, 48, 48, 48, 49, 50, 49, 49, 49, 49, 50, 51, 51, 51,
53, 52, 54, 54, 54, 55, 55, 55, 56, 57, 57, 57, 58, 59, 60, 60, 60, 61, 62, 62,
62, 61, 62, 61, 63, 63, 64, 64, 65, 66, 67, 67, 67, 68, 68, 69, 69, 70, 70, 70,
70, 72, 73, 73, 72, 74, 74, 74, 74, 74, 74, 75, 76, 76, 76, 77, 78, 79, 79, 78,
80, 81, 81, 80, 81, 83, 82, 82, 84, 85, 85, 85, 86, 86, 86, 86, 86, 86, 87, 87,
89, 87, 89, 89, 90, 91, 91, 91, 92, 93, 93, 94, 94, 94, 94, 95, 97, 98, 97, 97,
99, 99, 99, 99, 98, 98, 99, 100, 101, 101, 102, 102, 104, 104, 104, 105, 106,
105, 106, 107, 107, 107, 108, 111, 111, 111, 111, 114, 114, 114, 113, 107, 106,
106, 103, 107, 118, 54, -51, -96, -106, -105, -108, -117, -119, -118, -117,
-116, -116, -115, -113, -112, -111, -112, -110, -109, -109, -108, -107, -104,
-105, -105, -106, -105, -105, -104, -103, -101, -102, -102, -102, -102, -101,
-101, -101, -100, -100, -100, -99, -97, -97, -97, -97, -96, -95, -96, -94, -95,
-94, -93, -92, -93, -92, -91, -90, -90, -89, -90, -90, -90, -90, -89, -88, -88,
-87, -87, -86, -85, -85, -85, -84, -83, -83, -82, -82, -81, -81, -80, -81, -81,
-79, -78, -77, -77, -77, -77, -78, -77, -76, -76, -75, -76, -75, -74, -73, -73,
-73, -72, -70, -71, -70, -69, -69, -70, -68, -68, -68, -68, -66, -65, -64, -65,
-65, -65, -65, -66, -63, -64, -63, -63, -62, -61, -60, -60, -60, -58, -59, -59,
-58, -57, -57, -56, -56, -55, -56, -54, -54, -53, -52, -53, -53, -53, -53, -52,
-50, -51, -51, -50, -49, -48, -47, -48, -47, -46, -47, -46, -45, -45, -44, -44,
-43, -43, -43, -42, -40, -40, -41, -41, -41, -40, -41, -39, -39, -39, -39, -36,
-36, -35, -36, -35, -35, -35, -34, -34, -32, -33, -32, -31, -31, -31, -30, -29,
-28, -28, -28, -28, -28, -27, -26, -26, -26, -26, -25, -24, -23, -24, -23, -22,
-22, -22, -21, -20, -19, -20, -19, -18, -19, -17, -18, -16, -15, -15, -15, -16,
-15, -15, -14, -13, -14, -14, -12, -11, -11, -11, -11, -9, -9, -9, -9, -8, -8,
-7, -6, -6, -6, -5, -4, -4, -4, -3, -3, -4, -3, -3, -2, -2, -2, -1, };