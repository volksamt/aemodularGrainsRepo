#define DATA_LENGTH 512
#define DATA AKWF_vgsaw_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 4, 5, 5, 10, 14, 14, 13, 13, 14,
14, 14, 14, 13, 14, 13, 13, 14, 13, 14, 13, 13, 13, 12, 13, 13, 13, 13, 13, 12,
13, 18, 22, 21, 21, 22, 21, 22, 22, 22, 22, 22, 21, 21, 22, 22, 21, 21, 27, 30,
30, 30, 31, 30, 30, 30, 29, 29, 32, 37, 37, 37, 36, 37, 36, 37, 36, 37, 37, 36,
37, 36, 36, 37, 36, 37, 36, 37, 35, 36, 41, 45, 45, 44, 44, 48, 53, 54, 53, 53,
53, 52, 52, 53, 53, 53, 53, 53, 52, 53, 52, 53, 52, 53, 52, 53, 53, 52, 54, 52,
53, 52, 55, 58, 60, 60, 59, 60, 59, 59, 60, 59, 59, 60, 59, 60, 59, 61, 67, 69,
68, 68, 68, 68, 68, 68, 68, 68, 67, 70, 75, 77, 75, 76, 76, 77, 76, 77, 77, 76,
76, 76, 77, 75, 75, 76, 76, 76, 75, 77, 82, 85, 84, 84, 85, 84, 86, 90, 92, 90,
91, 92, 90, 91, 91, 91, 90, 91, 91, 91, 91, 91, 91, 91, 91, 92, 90, 91, 90, 90,
90, 91, 95, 100, 106, 108, 107, 108, 107, 107, 107, 108, 107, 108, 108, 108,
107, 108, 107, 108, 107, 107, 108, 108, 108, 108, 108, 107, 107, 106, 109, 115,
118, 118, 118, 117, 118, 118, 118, 117, 118, 117, 117, 116, 118, 117, 117, 117,
121, 74, -44, -81, -62, -63, -62, -64, -59, -63, -97, -120, -119, -119, -118,
-119, -119, -120, -119, -120, -119, -119, -118, -119, -119, -119, -118, -119,
-119, -119, -120, -119, -119, -118, -111, -109, -109, -105, -100, -101, -101,
-101, -100, -100, -101, -101, -101, -102, -101, -101, -102, -101, -101, -101,
-101, -101, -101, -101, -101, -101, -101, -101, -101, -101, -97, -92, -92, -93,
-93, -93, -92, -93, -93, -92, -92, -93, -92, -92, -94, -93, -93, -94, -93, -89,
-86, -86, -86, -86, -85, -86, -87, -83, -78, -78, -78, -78, -78, -78, -78, -78,
-78, -78, -78, -78, -77, -78, -78, -77, -78, -77, -78, -77, -78, -78, -78, -73,
-69, -71, -67, -61, -60, -60, -61, -61, -61, -61, -61, -61, -60, -61, -61, -62,
-61, -61, -62, -61, -61, -60, -61, -62, -61, -62, -61, -61, -61, -60, -55, -54,
-55, -55, -55, -54, -54, -55, -55, -55, -55, -55, -55, -54, -55, -56, -53, -47,
-46, -46, -46, -47, -46, -46, -47, -47, -45, -40, -37, -38, -39, -38, -38, -38,
-38, -38, -38, -38, -38, -39, -38, -38, -38, -38, -38, -38, -39, -39, -37, -32,
-31, -31, -32, -31, -25, -23, -23, -23, -24, -24, -22, -23, -23, -23, -23, -23,
-23, -23, -24, -23, -23, -23, -23, -24, -23, -23, -23, -23, -23, -24, -23, -18,
-14, -15, -15, -15, -14, -15, -14, -15, -14, -15, -15, -14, -15, -16, -11, -6,
-6, -7, -7, -6, -7, -7, -7, -6, -8, -6, -3, 0, 0, 1, 0, 0, 0, 0, 0, 1, 0, 1, 0,
0, 0, 0, 0, 0, 0, -1, };