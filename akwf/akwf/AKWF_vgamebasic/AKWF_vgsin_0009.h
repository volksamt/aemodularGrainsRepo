#define DATA_LENGTH 512
#define DATA AKWF_vgsin_0009

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 4, 5, 5, 4, 5, 5, 4, 4, 10, 16, 24,
28, 27, 27, 27, 27, 27, 27, 26, 27, 28, 27, 27, 32, 38, 38, 38, 38, 38, 38, 37,
40, 46, 49, 48, 46, 50, 57, 60, 58, 58, 59, 59, 59, 59, 58, 60, 66, 69, 68, 68,
69, 69, 68, 67, 72, 77, 77, 76, 76, 76, 76, 75, 77, 84, 87, 86, 84, 86, 93, 95,
93, 94, 94, 94, 93, 94, 93, 95, 97, 99, 98, 98, 99, 99, 98, 99, 102, 105, 104,
105, 109, 110, 110, 109, 109, 109, 109, 109, 109, 109, 109, 111, 112, 113, 113,
113, 114, 112, 112, 112, 116, 116, 115, 116, 117, 116, 117, 117, 118, 118, 118,
117, 118, 117, 118, 117, 117, 118, 118, 117, 117, 117, 118, 117, 116, 115, 116,
117, 116, 116, 116, 114, 114, 113, 111, 111, 111, 111, 111, 110, 111, 111, 111,
111, 111, 111, 112, 108, 108, 109, 108, 108, 108, 107, 103, 101, 101, 102, 102,
102, 99, 97, 96, 97, 96, 97, 96, 97, 97, 98, 95, 89, 88, 89, 88, 89, 90, 84, 79,
79, 79, 80, 79, 79, 80, 79, 75, 67, 62, 61, 62, 62, 61, 62, 62, 62, 62, 61, 62,
62, 61, 54, 52, 52, 52, 53, 52, 53, 53, 48, 42, 42, 43, 44, 37, 32, 31, 33, 31,
32, 32, 31, 32, 33, 27, 19, 18, 19, 19, 19, 19, 20, 19, 11, 9, 10, 10, 9, 9, 10,
10, 3, -3, -4, -3, -4, -2, -4, -12, -17, -17, -16, -16, -15, -16, -15, -20, -26,
-26, -25, -25, -26, -25, -25, -27, -36, -38, -38, -44, -50, -49, -49, -50, -49,
-49, -48, -50, -50, -49, -49, -55, -58, -57, -57, -56, -57, -56, -56, -61, -68,
-69, -68, -67, -68, -68, -75, -79, -78, -78, -78, -79, -78, -77, -80, -86, -87,
-85, -86, -86, -85, -85, -87, -91, -94, -93, -94, -94, -93, -95, -99, -100,
-101, -102, -105, -104, -105, -104, -105, -105, -104, -105, -105, -105, -105,
-104, -106, -111, -112, -111, -111, -111, -110, -113, -114, -115, -114, -114,
-115, -114, -117, -118, -117, -117, -118, -117, -118, -117, -117, -118, -117,
-119, -119, -120, -118, -119, -119, -119, -119, -120, -119, -119, -119, -118,
-119, -120, -118, -117, -115, -116, -116, -117, -116, -116, -116, -116, -116,
-115, -116, -115, -115, -112, -113, -112, -112, -112, -113, -113, -112, -109,
-109, -109, -110, -109, -106, -104, -105, -105, -104, -105, -104, -105, -106,
-105, -101, -98, -99, -98, -99, -98, -99, -99, -96, -91, -92, -92, -92, -92,
-92, -92, -91, -85, -84, -83, -85, -84, -85, -81, -75, -73, -74, -74, -75, -74,
-75, -74, -69, -66, -67, -66, -66, -67, -67, -67, -62, -56, -56, -54, -46, -44,
-44, -45, -45, -44, -45, -44, -44, -45, -46, -41, -35, -34, -35, -36, -36, -35,
-36, -34, -26, -21, -21, -22, -23, -23, -20, -12, -9, -12, -11, -11, -11, -12,
-12, -3, 1, 0, 0, 1, 0, 1, -1, };