#define DATA_LENGTH 512
#define DATA AKWF_vgsaw_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {0, 1, 2, 1, 1, 2, 1, 2, 1, 2, 2, 2, 2,
6, 7, 6, 6, 6, 6, 7, 10, 11, 11, 11, 10, 11, 11, 12, 13, 15, 14, 14, 14, 13, 13,
14, 13, 14, 14, 16, 19, 20, 18, 18, 18, 19, 18, 19, 21, 24, 23, 23, 23, 23, 24,
25, 27, 27, 26, 26, 26, 26, 27, 27, 26, 26, 28, 31, 32, 31, 31, 31, 31, 30, 32,
34, 36, 35, 36, 36, 36, 35, 39, 39, 38, 38, 39, 38, 38, 38, 38, 38, 38, 40, 43,
44, 44, 44, 44, 44, 43, 44, 47, 48, 48, 48, 48, 47, 48, 51, 51, 51, 51, 52, 50,
51, 51, 52, 51, 51, 53, 56, 56, 55, 56, 56, 55, 56, 56, 59, 60, 60, 60, 60, 60,
61, 63, 64, 63, 63, 63, 63, 64, 64, 64, 63, 63, 65, 69, 68, 68, 68, 67, 68, 67,
68, 72, 74, 73, 73, 72, 72, 73, 76, 76, 75, 76, 75, 77, 76, 75, 76, 75, 76, 79,
81, 81, 80, 81, 81, 81, 80, 82, 85, 86, 85, 85, 85, 85, 87, 88, 89, 88, 88, 88,
88, 88, 88, 88, 88, 87, 91, 93, 93, 93, 93, 94, 93, 93, 94, 96, 97, 97, 97, 97,
97, 99, 101, 100, 101, 100, 101, 100, 100, 101, 101, 103, 105, 105, 105, 104,
106, 105, 106, 105, 105, 105, 107, 107, 106, 106, 107, 107, 104, 103, 103, 104,
103, 105, 102, 102, 109, 117, 8, -113, -119, -117, -118, -120, -118, -119, -118,
-118, -115, -108, -107, -108, -109, -108, -109, -106, -105, -105, -105, -106,
-106, -105, -105, -105, -105, -103, -102, -102, -102, -102, -102, -101, -102,
-102, -102, -100, -98, -96, -97, -97, -98, -98, -95, -92, -93, -93, -93, -94,
-93, -93, -93, -93, -91, -89, -90, -90, -90, -90, -90, -90, -90, -91, -87, -85,
-85, -85, -84, -85, -86, -81, -80, -81, -80, -80, -80, -80, -80, -81, -80, -79,
-77, -77, -77, -77, -78, -77, -78, -75, -73, -73, -73, -72, -72, -73, -73, -72,
-71, -69, -70, -69, -69, -70, -70, -70, -70, -69, -66, -65, -65, -65, -65, -65,
-65, -65, -63, -61, -61, -61, -60, -60, -60, -61, -59, -58, -57, -58, -57, -57,
-57, -57, -57, -57, -57, -54, -53, -52, -52, -52, -52, -52, -52, -52, -48, -48,
-48, -47, -48, -48, -49, -47, -46, -44, -44, -45, -45, -44, -46, -45, -45, -45,
-42, -40, -40, -40, -40, -40, -41, -40, -38, -35, -36, -36, -35, -36, -36, -36,
-35, -33, -32, -32, -33, -32, -32, -32, -32, -33, -32, -29, -28, -28, -29, -28,
-28, -28, -28, -26, -23, -23, -23, -23, -23, -24, -24, -23, -21, -21, -20, -19,
-20, -21, -20, -19, -21, -19, -16, -15, -15, -16, -15, -15, -15, -16, -13, -11,
-10, -11, -10, -11, -11, -12, -11, -8, -8, -7, -7, -8, -8, -7, -8, -8, -7, -4,
-2, -3, -4, -4, -3, -3, -3, -1, 0, 0, 1, 0, 0, 0, 0, };