#define DATA_LENGTH 512
#define DATA AKWF_vgsqu_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {65, 124, 114, 113, 114, 115, 114, 116,
112, 110, 110, 112, 112, 112, 111, 111, 112, 111, 111, 112, 111, 112, 112, 111,
112, 111, 112, 112, 112, 111, 112, 111, 111, 112, 111, 111, 111, 112, 112, 111,
111, 111, 112, 112, 112, 111, 111, 112, 111, 112, 111, 111, 112, 111, 112, 111,
112, 111, 112, 111, 111, 111, 111, 112, 111, 111, 112, 112, 111, 112, 111, 112,
111, 112, 111, 111, 111, 111, 111, 112, 112, 111, 111, 112, 112, 112, 111, 112,
111, 112, 112, 111, 111, 112, 112, 111, 111, 111, 111, 111, 112, 111, 112, 112,
111, 111, 112, 112, 111, 112, 112, 111, 111, 112, 111, 111, 112, 111, 111, 111,
112, 111, 112, 112, 111, 111, 112, 111, 112, 112, 111, 112, 111, 111, 111, 111,
112, 112, 112, 112, 111, 111, 111, 112, 111, 111, 111, 111, 112, 112, 111, 112,
111, 111, 112, 112, 111, 111, 111, 111, 112, 111, 111, 112, 111, 111, 111, 111,
111, 112, 111, 112, 111, 112, 111, 111, 112, 111, 112, 111, 111, 112, 111, 112,
111, 111, 112, 111, 111, 111, 111, 111, 111, 112, 112, 112, 111, 111, 111, 112,
111, 112, 112, 111, 112, 111, 111, 112, 112, 111, 111, 111, 112, 112, 112, 111,
112, 111, 111, 112, 112, 111, 112, 111, 112, 111, 111, 112, 111, 112, 112, 112,
113, 114, 112, 113, 113, 114, 113, 113, 113, 113, 113, 113, 113, 113, 113, 114,
110, 105, 101, 103, 104, 102, 103, 101, 101, 117, 104, -26, -119, -117, -113,
-112, -116, -114, -115, -114, -114, -114, -115, -114, -115, -114, -115, -115,
-114, -112, -111, -111, -111, -111, -111, -111, -112, -113, -113, -113, -113,
-113, -114, -113, -113, -113, -114, -113, -113, -113, -114, -113, -113, -113,
-113, -113, -113, -113, -112, -113, -113, -112, -113, -113, -113, -113, -113,
-113, -113, -112, -113, -113, -113, -112, -113, -113, -113, -112, -113, -113,
-113, -113, -113, -113, -113, -112, -113, -113, -113, -113, -113, -113, -112,
-113, -113, -113, -112, -113, -113, -113, -113, -114, -112, -113, -114, -113,
-112, -112, -113, -113, -114, -113, -113, -113, -113, -113, -113, -113, -112,
-114, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113, -113,
-113, -113, -113, -114, -113, -113, -114, -113, -113, -113, -113, -113, -113,
-113, -112, -113, -114, -113, -114, -112, -113, -113, -113, -113, -112, -113,
-113, -113, -113, -113, -112, -113, -113, -114, -114, -112, -113, -113, -114,
-113, -114, -113, -113, -113, -113, -112, -112, -113, -113, -114, -113, -113,
-114, -114, -112, -113, -113, -114, -113, -113, -113, -113, -112, -113, -113,
-113, -113, -113, -112, -114, -113, -113, -113, -112, -113, -114, -114, -114,
-113, -114, -113, -113, -113, -113, -113, -113, -113, -113, -112, -114, -114,
-114, -113, -114, -113, -113, -113, -113, -113, -113, -113, -113, -114, -112,
-111, -112, -111, -111, -111, -112, -112, -112, -111, -112, -111, -112, -111,
-111, -111, -113, -115, -115, -114, -114, -115, -115, -115, -113, -116, -117,
-120, -55, };