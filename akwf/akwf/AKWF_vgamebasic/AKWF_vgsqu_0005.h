#define DATA_LENGTH 512
#define DATA AKWF_vgsqu_0005

const PROGMEM int8_t DATA[DATA_LENGTH] = {52, 122, 116, 116, 117, 118, 118, 117,
117, 117, 117, 117, 118, 117, 118, 118, 118, 115, 112, 113, 113, 112, 113, 113,
113, 113, 113, 112, 113, 114, 115, 114, 114, 114, 115, 115, 115, 115, 114, 114,
114, 115, 114, 115, 115, 115, 114, 115, 114, 114, 115, 114, 114, 114, 114, 114,
115, 115, 115, 115, 115, 115, 114, 115, 114, 115, 114, 114, 115, 114, 114, 114,
113, 115, 114, 114, 115, 115, 114, 114, 114, 114, 114, 114, 114, 114, 114, 114,
114, 115, 114, 115, 114, 115, 115, 115, 115, 115, 115, 115, 114, 114, 114, 115,
114, 114, 114, 114, 115, 115, 115, 115, 115, 115, 115, 114, 114, 115, 114, 114,
115, 114, 115, 114, 115, 114, 114, 114, 115, 114, 114, 115, 114, 114, 114, 115,
114, 114, 114, 114, 114, 114, 114, 115, 114, 114, 114, 115, 114, 115, 115, 115,
114, 114, 114, 114, 115, 115, 115, 115, 114, 114, 114, 114, 114, 115, 114, 114,
115, 114, 114, 114, 115, 115, 114, 114, 114, 115, 114, 115, 114, 114, 114, 115,
114, 114, 114, 114, 114, 114, 115, 114, 115, 114, 114, 114, 115, 114, 115, 115,
114, 114, 114, 114, 114, 114, 115, 114, 114, 114, 115, 114, 114, 114, 115, 114,
114, 115, 115, 114, 115, 114, 114, 115, 116, 116, 116, 117, 116, 116, 116, 115,
116, 116, 115, 117, 117, 116, 115, 116, 116, 116, 115, 117, 116, 117, 116, 112,
111, 121, 65, -76, -124, -111, -110, -111, -111, -111, -111, -111, -112, -110,
-112, -111, -111, -111, -111, -111, -112, -111, -112, -115, -118, -117, -117,
-117, -118, -118, -116, -115, -116, -116, -116, -116, -116, -116, -117, -117,
-116, -115, -116, -116, -117, -116, -116, -117, -116, -116, -116, -115, -116,
-116, -115, -116, -116, -116, -116, -116, -116, -116, -117, -115, -116, -116,
-117, -116, -115, -116, -116, -116, -116, -116, -116, -115, -116, -117, -116,
-115, -116, -116, -116, -116, -116, -115, -116, -116, -116, -115, -116, -116,
-116, -116, -116, -115, -116, -116, -116, -116, -116, -116, -116, -116, -116,
-115, -116, -116, -116, -116, -116, -116, -116, -115, -116, -116, -116, -116,
-115, -116, -116, -117, -116, -116, -116, -116, -116, -116, -116, -116, -117,
-116, -115, -116, -116, -116, -116, -116, -116, -117, -116, -116, -116, -116,
-116, -116, -115, -116, -116, -116, -116, -116, -116, -116, -115, -115, -116,
-115, -116, -116, -116, -116, -116, -116, -115, -116, -116, -117, -116, -116,
-116, -116, -116, -116, -116, -116, -116, -116, -116, -116, -116, -116, -116,
-115, -116, -115, -116, -115, -116, -116, -116, -116, -117, -116, -116, -115,
-116, -117, -115, -116, -116, -116, -116, -116, -116, -115, -116, -115, -116,
-117, -115, -116, -116, -116, -115, -116, -116, -116, -116, -116, -115, -116,
-115, -116, -116, -116, -116, -116, -115, -116, -116, -116, -116, -116, -116,
-116, -116, -116, -116, -116, -114, -114, -114, -115, -114, -114, -114, -113,
-117, -119, -119, -118, -120, -119, -120, -119, -120, -118, -121, -117, -119,
-115, -123, -71, };