#define DATA_LENGTH 512
#define DATA AKWF_vgsin_0002

const PROGMEM int8_t DATA[DATA_LENGTH] = {3, 8, 7, 7, 6, 6, 7, 6, 6, 6, 6, 6, 7,
6, 6, 6, 6, 6, 6, 6, 7, 6, 5, 15, 28, 28, 31, 47, 55, 52, 52, 53, 52, 52, 52,
53, 52, 52, 52, 52, 52, 52, 53, 53, 52, 53, 52, 52, 52, 52, 52, 52, 50, 55, 68,
73, 72, 71, 71, 72, 72, 71, 71, 71, 71, 71, 72, 72, 72, 69, 76, 87, 90, 89, 89,
88, 90, 89, 88, 88, 91, 100, 103, 101, 102, 102, 102, 101, 101, 101, 101, 102,
101, 102, 102, 101, 102, 102, 101, 101, 102, 101, 104, 110, 112, 110, 111, 112,
115, 116, 116, 116, 117, 116, 116, 116, 116, 117, 116, 116, 116, 116, 116, 115,
116, 117, 117, 116, 116, 116, 115, 116, 116, 116, 117, 118, 118, 117, 117, 118,
118, 117, 118, 118, 116, 113, 112, 112, 113, 113, 113, 113, 113, 113, 113, 112,
112, 112, 112, 113, 113, 110, 105, 105, 105, 105, 105, 105, 104, 104, 105, 105,
104, 105, 105, 105, 105, 105, 105, 105, 105, 102, 94, 91, 92, 92, 92, 93, 87,
76, 76, 76, 77, 77, 76, 76, 76, 76, 77, 76, 76, 76, 77, 77, 76, 76, 76, 76, 76,
76, 76, 76, 78, 72, 60, 46, 36, 35, 37, 36, 37, 37, 36, 36, 36, 36, 36, 37, 37,
36, 36, 37, 36, 36, 36, 37, 37, 36, 36, 35, 38, 38, 25, 10, 9, 12, 11, 11, 11,
11, 11, 11, 11, 11, 12, 11, 11, 11, 11, 14, 8, -7, -13, -11, -11, -11, -12, -10,
-10, -22, -34, -34, -33, -34, -34, -34, -34, -34, -33, -34, -34, -33, -33, -33,
-33, -34, -34, -33, -33, -33, -33, -31, -36, -52, -56, -56, -66, -75, -76, -74,
-74, -74, -75, -74, -75, -75, -75, -75, -74, -74, -75, -74, -75, -75, -74, -75,
-75, -75, -75, -74, -75, -73, -75, -85, -93, -92, -92, -92, -93, -92, -92, -92,
-92, -92, -92, -92, -92, -92, -93, -92, -91, -95, -103, -107, -105, -105, -105,
-105, -104, -104, -110, -116, -115, -115, -115, -115, -115, -114, -114, -115,
-114, -115, -115, -115, -114, -115, -114, -114, -114, -115, -114, -114, -113,
-116, -118, -119, -119, -120, -119, -119, -119, -119, -119, -118, -119, -119,
-119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119, -119,
-118, -118, -119, -119, -118, -115, -114, -115, -113, -115, -114, -114, -114,
-114, -114, -114, -114, -115, -114, -114, -115, -112, -106, -104, -105, -105,
-105, -105, -105, -105, -106, -104, -95, -91, -92, -93, -92, -92, -92, -92, -91,
-92, -93, -92, -92, -92, -93, -92, -92, -92, -91, -91, -94, -90, -79, -74, -76,
-79, -73, -60, -53, -55, -56, -56, -56, -55, -56, -56, -56, -55, -55, -56, -56,
-56, -55, -57, -57, -46, -34, -34, -35, -35, -34, -35, -35, -36, -35, -36, -34,
-35, -34, -35, -35, -35, -35, -34, -35, -34, -34, -37, -32, -17, -9, -11, -11,
-11, -12, -11, -11, -12, -12, -12, -7, };