#define DATA_LENGTH 512
#define DATA AKWF_vgsqu_0006

const PROGMEM int8_t DATA[DATA_LENGTH] = {19, 89, 115, 103, 104, 103, 105, 104,
104, 102, 105, 109, 113, 112, 112, 112, 112, 111, 112, 111, 112, 111, 111, 111,
111, 111, 111, 111, 113, 113, 114, 113, 113, 114, 112, 113, 113, 113, 112, 113,
113, 114, 113, 113, 112, 113, 113, 113, 113, 113, 114, 113, 113, 114, 113, 114,
113, 114, 114, 113, 113, 113, 114, 113, 113, 112, 113, 113, 113, 114, 113, 113,
113, 112, 113, 113, 113, 113, 113, 113, 112, 113, 113, 114, 113, 113, 113, 113,
113, 113, 114, 112, 113, 113, 112, 113, 113, 112, 113, 112, 113, 113, 113, 113,
112, 113, 113, 113, 113, 112, 113, 114, 113, 113, 113, 113, 113, 113, 113, 112,
113, 113, 113, 114, 112, 113, 113, 113, 112, 113, 114, 113, 113, 113, 113, 113,
114, 113, 113, 113, 113, 113, 113, 112, 113, 114, 113, 113, 113, 113, 114, 113,
114, 113, 113, 113, 113, 113, 113, 113, 113, 113, 112, 113, 113, 113, 113, 113,
113, 112, 113, 113, 113, 113, 113, 113, 113, 113, 112, 112, 113, 113, 113, 113,
113, 113, 113, 113, 112, 113, 113, 113, 112, 112, 113, 113, 114, 112, 112, 113,
113, 113, 113, 114, 113, 113, 112, 113, 113, 113, 113, 113, 113, 113, 113, 114,
113, 113, 113, 113, 113, 113, 112, 114, 113, 114, 113, 113, 113, 113, 113, 113,
114, 113, 114, 114, 115, 115, 115, 114, 114, 115, 114, 118, 118, 120, 119, 119,
119, 120, 118, 120, 118, 119, 116, 123, 56, -87, -123, -111, -108, -110, -111,
-110, -111, -110, -111, -112, -113, -113, -114, -114, -114, -113, -115, -115,
-115, -115, -115, -115, -114, -115, -114, -114, -114, -115, -114, -115, -114,
-114, -114, -114, -115, -115, -114, -115, -115, -115, -115, -114, -114, -115,
-114, -114, -114, -115, -115, -114, -115, -114, -115, -114, -115, -114, -114,
-115, -114, -115, -114, -115, -115, -114, -114, -115, -115, -115, -114, -114,
-115, -115, -114, -115, -115, -115, -114, -115, -115, -114, -114, -114, -115,
-114, -114, -114, -114, -114, -114, -114, -114, -115, -115, -115, -114, -114,
-114, -115, -115, -115, -114, -115, -114, -114, -115, -114, -114, -115, -114,
-114, -115, -114, -114, -114, -115, -115, -115, -114, -114, -115, -115, -114,
-114, -115, -115, -114, -114, -114, -114, -115, -114, -115, -115, -114, -114,
-115, -115, -115, -114, -115, -114, -115, -114, -115, -115, -114, -114, -114,
-115, -114, -114, -114, -115, -115, -114, -115, -114, -115, -115, -114, -114,
-114, -114, -114, -114, -114, -115, -115, -114, -115, -114, -114, -115, -114,
-115, -115, -114, -114, -114, -115, -115, -114, -115, -115, -114, -114, -115,
-114, -114, -115, -115, -114, -114, -115, -115, -115, -114, -115, -114, -114,
-115, -115, -115, -114, -115, -114, -114, -114, -115, -115, -114, -115, -115,
-114, -114, -114, -114, -114, -114, -114, -114, -114, -115, -116, -116, -116,
-116, -116, -116, -116, -115, -117, -117, -117, -116, -116, -116, -116, -116,
-117, -116, -116, -117, -118, -71, 2, 7, -1, -1, 1, -1, 1, -3, -8, };