#define DATA_LENGTH 512
#define DATA AKWF_vgsqu_0007

const PROGMEM int8_t DATA[DATA_LENGTH] = {68, 123, 115, 119, 118, 120, 118, 119,
119, 120, 119, 120, 119, 119, 119, 119, 118, 115, 114, 115, 114, 115, 115, 115,
114, 115, 114, 112, 111, 111, 112, 112, 112, 111, 111, 112, 113, 114, 112, 113,
113, 113, 113, 113, 112, 113, 113, 112, 113, 113, 113, 114, 112, 112, 113, 113,
113, 113, 114, 112, 113, 112, 113, 113, 113, 113, 113, 113, 114, 112, 113, 113,
113, 113, 113, 113, 113, 113, 113, 113, 112, 113, 113, 112, 112, 113, 112, 113,
113, 113, 113, 113, 114, 114, 113, 114, 112, 113, 114, 113, 113, 112, 113, 113,
113, 113, 113, 112, 112, 112, 112, 113, 113, 112, 114, 113, 112, 113, 112, 113,
113, 113, 113, 113, 113, 113, 113, 113, 113, 113, 113, 112, 113, 113, 113, 113,
113, 113, 113, 113, 113, 113, 113, 112, 113, 113, 113, 112, 113, 113, 113, 113,
112, 114, 113, 113, 113, 113, 113, 113, 113, 113, 113, 113, 112, 113, 113, 114,
112, 113, 113, 113, 113, 114, 113, 113, 114, 112, 113, 113, 113, 113, 113, 113,
113, 113, 113, 113, 112, 113, 113, 113, 113, 113, 113, 113, 112, 113, 113, 113,
113, 113, 112, 113, 113, 112, 113, 113, 113, 113, 112, 112, 113, 112, 113, 113,
113, 113, 113, 113, 114, 114, 113, 113, 113, 113, 112, 113, 113, 113, 113, 113,
111, 111, 112, 111, 112, 112, 111, 112, 112, 112, 115, 118, 120, 119, 119, 119,
120, 119, 119, 119, 119, 119, 119, 119, 118, 116, 122, 93, -44, -122, -108,
-104, -104, -106, -104, -105, -107, -113, -115, -116, -116, -116, -116, -116,
-116, -116, -116, -116, -116, -116, -116, -116, -116, -116, -116, -114, -115,
-114, -115, -114, -114, -115, -115, -115, -115, -114, -114, -114, -114, -114,
-115, -115, -114, -115, -114, -114, -114, -114, -114, -115, -114, -114, -115,
-114, -114, -115, -114, -115, -115, -115, -115, -114, -114, -115, -115, -114,
-115, -115, -115, -114, -114, -115, -114, -115, -114, -114, -115, -115, -114,
-114, -115, -114, -114, -115, -115, -114, -115, -114, -115, -115, -114, -115,
-115, -115, -115, -114, -115, -114, -114, -114, -115, -115, -115, -114, -115,
-115, -114, -115, -115, -114, -114, -115, -115, -114, -115, -114, -114, -114,
-114, -114, -114, -114, -114, -114, -114, -114, -114, -114, -115, -115, -115,
-115, -114, -114, -115, -114, -114, -114, -114, -115, -115, -114, -115, -115,
-114, -114, -115, -115, -114, -114, -114, -114, -114, -115, -114, -114, -114,
-115, -114, -114, -115, -114, -115, -115, -114, -115, -115, -114, -114, -114,
-114, -115, -115, -114, -114, -114, -115, -115, -114, -114, -115, -115, -114,
-114, -115, -114, -115, -114, -114, -114, -115, -115, -115, -115, -115, -114,
-115, -114, -114, -115, -115, -115, -114, -114, -114, -115, -115, -114, -114,
-114, -115, -115, -115, -114, -114, -115, -115, -114, -114, -114, -114, -114,
-115, -114, -113, -113, -112, -112, -112, -113, -112, -113, -112, -113, -113,
-113, -113, -113, -113, -111, -110, -110, -110, -110, -110, -110, -108, -114,
-121, -52, };