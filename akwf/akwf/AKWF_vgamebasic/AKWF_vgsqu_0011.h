#define DATA_LENGTH 512
#define DATA AKWF_vgsqu_0011

const PROGMEM int8_t DATA[DATA_LENGTH] = {31, 105, 121, 118, 118, 119, 115, 114,
115, 114, 115, 115, 113, 111, 111, 111, 112, 111, 112, 112, 112, 111, 111, 111,
112, 113, 113, 113, 113, 113, 113, 113, 112, 112, 113, 113, 113, 113, 113, 113,
113, 113, 114, 112, 113, 112, 113, 112, 113, 113, 113, 113, 113, 113, 113, 113,
113, 113, 113, 113, 112, 113, 113, 113, 112, 113, 113, 112, 113, 113, 113, 113,
113, 113, 112, 113, 113, 112, 113, 113, 113, 112, 113, 113, 113, 113, 113, 113,
113, 114, 113, 112, 113, 113, 113, 113, 113, 113, 113, 113, 112, 113, 113, 113,
113, 113, 112, 113, 113, 113, 113, 112, 113, 113, 113, 113, 114, 112, 113, 113,
113, 113, 113, 113, 113, 113, 112, 112, 113, 114, 113, 113, 113, 113, 113, 113,
113, 113, 113, 113, 113, 112, 113, 113, 113, 113, 113, 113, 112, 113, 113, 113,
112, 112, 113, 112, 113, 113, 113, 113, 113, 113, 113, 112, 113, 112, 114, 113,
113, 114, 113, 112, 113, 112, 114, 113, 113, 113, 114, 112, 113, 112, 114, 113,
114, 113, 113, 113, 113, 113, 113, 113, 112, 113, 112, 113, 113, 113, 113, 113,
113, 113, 113, 113, 114, 113, 112, 113, 113, 113, 113, 112, 113, 113, 113, 113,
113, 113, 113, 112, 113, 112, 113, 112, 113, 113, 113, 111, 112, 111, 112, 111,
111, 112, 114, 115, 114, 114, 114, 114, 113, 115, 113, 115, 117, 119, 118, 119,
117, 120, 85, 6, -13, 1, 9, -25, -98, -119, -109, -109, -110, -115, -117, -116,
-116, -116, -116, -115, -116, -116, -116, -116, -116, -116, -114, -114, -113,
-113, -112, -113, -114, -115, -114, -115, -115, -115, -114, -114, -115, -114,
-115, -115, -115, -114, -114, -115, -114, -115, -115, -115, -115, -115, -115,
-114, -114, -114, -115, -114, -115, -114, -115, -114, -114, -114, -115, -115,
-114, -114, -115, -115, -114, -114, -114, -115, -114, -115, -114, -114, -114,
-115, -115, -114, -114, -115, -114, -115, -115, -114, -115, -115, -115, -114,
-115, -114, -114, -114, -114, -114, -114, -114, -114, -114, -114, -115, -114,
-115, -115, -114, -114, -115, -114, -114, -115, -114, -115, -115, -115, -114,
-114, -114, -115, -115, -115, -114, -114, -114, -115, -114, -114, -114, -114,
-114, -115, -115, -114, -114, -114, -115, -115, -114, -114, -115, -115, -114,
-114, -114, -115, -115, -114, -114, -115, -115, -115, -115, -114, -114, -114,
-114, -114, -114, -114, -115, -115, -115, -115, -114, -114, -114, -114, -114,
-114, -115, -114, -115, -114, -114, -114, -114, -114, -114, -114, -115, -114,
-115, -114, -115, -115, -115, -114, -114, -115, -114, -115, -114, -115, -114,
-115, -115, -115, -115, -114, -115, -114, -114, -114, -115, -115, -114, -114,
-115, -115, -114, -115, -114, -115, -115, -115, -115, -114, -115, -115, -114,
-115, -115, -114, -115, -114, -114, -114, -116, -115, -116, -115, -116, -116,
-115, -115, -117, -116, -117, -116, -116, -116, -116, -117, -114, -112, -110,
-111, -112, -111, -105, -105, -108, -115, -78, -8, 10, -1, 2, -5, -8, };