#define DATA_LENGTH 512
#define DATA AKWF_vgsqu_0013

const PROGMEM int8_t DATA[DATA_LENGTH] = {20, 95, 122, 116, 108, 97, 99, 100,
100, 99, 102, 101, 101, 101, 103, 105, 106, 104, 103, 101, 103, 103, 103, 102,
102, 102, 102, 102, 103, 103, 103, 104, 104, 104, 104, 103, 104, 104, 104, 104,
104, 103, 103, 103, 103, 104, 104, 104, 104, 104, 103, 104, 104, 104, 104, 104,
104, 103, 104, 103, 104, 103, 103, 103, 104, 103, 103, 104, 103, 104, 103, 104,
104, 104, 103, 104, 104, 103, 103, 103, 104, 104, 104, 103, 103, 103, 104, 104,
104, 103, 103, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 103, 104, 103,
103, 104, 104, 103, 104, 103, 103, 103, 104, 104, 104, 104, 104, 104, 104, 103,
103, 103, 103, 104, 103, 104, 103, 104, 104, 104, 103, 103, 103, 103, 104, 103,
103, 104, 104, 104, 103, 104, 103, 104, 105, 104, 104, 104, 104, 104, 103, 103,
103, 104, 104, 103, 103, 103, 103, 104, 103, 104, 103, 103, 103, 104, 104, 104,
103, 104, 104, 103, 104, 104, 103, 104, 103, 103, 103, 104, 103, 104, 103, 104,
103, 104, 104, 103, 103, 104, 104, 103, 104, 104, 104, 104, 103, 103, 104, 103,
103, 104, 103, 103, 104, 104, 103, 104, 104, 103, 104, 104, 104, 104, 103, 104,
103, 104, 103, 104, 104, 103, 103, 104, 104, 104, 103, 104, 104, 104, 104, 103,
105, 105, 105, 106, 106, 104, 102, 101, 103, 105, 106, 104, 105, 105, 106, 106,
107, 107, 104, 94, 109, 93, -36, -120, -118, -118, -118, -115, -110, -111, -108,
-103, -102, -102, -102, -103, -104, -104, -103, -104, -104, -106, -107, -106,
-106, -103, -103, -104, -104, -104, -105, -105, -105, -106, -105, -105, -105,
-105, -105, -104, -105, -105, -105, -105, -105, -105, -105, -105, -104, -106,
-104, -105, -105, -105, -104, -105, -105, -105, -105, -104, -105, -105, -105,
-104, -105, -105, -105, -105, -105, -105, -106, -105, -105, -106, -105, -105,
-105, -105, -105, -105, -104, -106, -105, -105, -105, -105, -105, -105, -105,
-105, -106, -104, -104, -105, -105, -105, -105, -104, -106, -106, -105, -104,
-106, -104, -105, -105, -105, -105, -106, -106, -104, -105, -105, -105, -105,
-105, -105, -105, -105, -105, -105, -105, -104, -105, -105, -105, -105, -104,
-105, -105, -105, -105, -105, -105, -106, -105, -105, -105, -105, -105, -105,
-105, -105, -105, -105, -105, -104, -105, -105, -105, -105, -105, -106, -106,
-105, -105, -105, -105, -105, -105, -105, -105, -105, -105, -105, -105, -105,
-105, -105, -105, -105, -106, -105, -105, -105, -104, -104, -105, -104, -105,
-105, -106, -104, -105, -105, -105, -105, -105, -105, -106, -106, -105, -106,
-105, -105, -105, -105, -105, -105, -105, -105, -105, -104, -105, -105, -104,
-106, -105, -105, -105, -105, -105, -105, -105, -105, -105, -105, -105, -105,
-105, -105, -105, -105, -106, -105, -105, -105, -106, -105, -106, -105, -105,
-105, -106, -106, -107, -107, -107, -106, -107, -106, -107, -106, -106, -104,
-103, -104, -106, -109, -108, -108, -108, -110, -110, -110, -117, -110, -44, 4,
-5, };