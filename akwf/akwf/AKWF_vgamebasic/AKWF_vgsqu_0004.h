#define DATA_LENGTH 512
#define DATA AKWF_vgsqu_0004

const PROGMEM int8_t DATA[DATA_LENGTH] = {54, 122, 117, 117, 118, 119, 118, 119,
119, 119, 120, 120, 119, 119, 119, 118, 120, 119, 118, 115, 114, 114, 115, 115,
114, 114, 114, 114, 113, 113, 112, 113, 113, 112, 113, 113, 113, 113, 112, 112,
112, 113, 113, 113, 113, 112, 113, 113, 113, 113, 112, 114, 113, 113, 113, 113,
114, 113, 113, 113, 114, 113, 113, 113, 114, 113, 113, 112, 113, 113, 113, 113,
113, 113, 114, 112, 113, 113, 113, 113, 113, 113, 113, 113, 113, 113, 113, 113,
113, 113, 113, 113, 113, 113, 113, 113, 113, 114, 114, 113, 113, 113, 113, 113,
113, 113, 113, 113, 113, 113, 113, 114, 113, 113, 113, 114, 113, 113, 113, 113,
112, 114, 113, 112, 112, 112, 113, 114, 114, 113, 113, 114, 113, 113, 113, 113,
112, 113, 113, 113, 113, 113, 113, 113, 114, 113, 112, 113, 113, 113, 112, 112,
113, 112, 113, 113, 113, 113, 113, 113, 113, 114, 113, 113, 113, 113, 113, 113,
113, 112, 113, 113, 113, 113, 113, 113, 113, 112, 112, 113, 113, 113, 113, 114,
114, 113, 112, 113, 112, 113, 113, 113, 112, 113, 113, 113, 113, 113, 113, 113,
113, 112, 113, 113, 113, 113, 112, 113, 112, 113, 113, 113, 114, 113, 113, 113,
113, 112, 114, 113, 114, 113, 113, 113, 113, 113, 113, 112, 114, 112, 113, 114,
115, 114, 114, 114, 115, 115, 114, 114, 114, 115, 114, 115, 113, 111, 109, 110,
110, 110, 110, 110, 109, 110, 108, 109, 115, 116, 21, -106, -118, -103, -104,
-105, -106, -106, -105, -105, -105, -106, -105, -105, -111, -113, -113, -112,
-114, -113, -113, -113, -113, -112, -113, -113, -113, -113, -114, -114, -114,
-115, -114, -114, -115, -114, -114, -114, -115, -114, -114, -114, -114, -115,
-115, -115, -114, -115, -115, -115, -115, -115, -114, -114, -115, -114, -114,
-114, -114, -114, -115, -114, -115, -114, -115, -115, -115, -114, -115, -114,
-114, -115, -114, -115, -115, -115, -114, -114, -114, -115, -115, -115, -115,
-115, -115, -115, -114, -114, -115, -114, -115, -114, -115, -115, -114, -115,
-114, -115, -115, -114, -114, -114, -114, -115, -115, -114, -114, -115, -115,
-115, -114, -114, -115, -115, -115, -115, -115, -115, -115, -115, -115, -115,
-115, -115, -114, -114, -115, -115, -115, -115, -115, -114, -114, -115, -115,
-115, -114, -115, -115, -114, -114, -114, -114, -115, -115, -114, -114, -114,
-115, -115, -114, -114, -115, -114, -114, -115, -115, -115, -115, -114, -115,
-114, -114, -115, -114, -115, -115, -115, -114, -114, -114, -114, -114, -115,
-115, -115, -114, -115, -115, -114, -115, -115, -115, -115, -115, -114, -114,
-114, -114, -115, -114, -115, -114, -115, -115, -115, -115, -114, -115, -115,
-114, -114, -114, -115, -114, -115, -114, -115, -114, -114, -114, -114, -114,
-114, -114, -114, -115, -114, -115, -114, -115, -115, -115, -115, -114, -115,
-114, -116, -114, -113, -113, -112, -112, -111, -111, -111, -112, -111, -111,
-111, -112, -111, -112, -111, -111, -111, -113, -111, -113, -111, -110, -112,
-123, -67, };