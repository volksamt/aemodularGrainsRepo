#define DATA_LENGTH 512
#define DATA AKWF_vgtri_0008

const PROGMEM int8_t DATA[DATA_LENGTH] = {1, 1, 1, 2, 2, 2, 2, 1, 1, 2, 6, 10,
10, 9, 10, 10, 10, 8, 12, 19, 19, 19, 18, 19, 18, 18, 20, 24, 28, 27, 27, 27,
27, 27, 27, 26, 27, 32, 35, 36, 34, 35, 35, 35, 34, 39, 44, 46, 43, 44, 45, 44,
43, 44, 50, 53, 52, 53, 52, 53, 53, 52, 56, 60, 61, 60, 60, 60, 60, 60, 61, 59,
63, 68, 69, 68, 68, 68, 69, 68, 69, 75, 79, 78, 78, 78, 78, 78, 77, 81, 86, 86,
86, 85, 85, 86, 86, 86, 85, 88, 94, 95, 93, 94, 94, 93, 93, 94, 99, 104, 104,
103, 103, 104, 103, 103, 106, 110, 111, 111, 111, 111, 111, 111, 111, 110, 112,
116, 117, 116, 117, 115, 115, 117, 115, 110, 105, 106, 107, 106, 106, 107, 108,
103, 99, 98, 99, 98, 99, 98, 99, 99, 100, 97, 92, 90, 91, 91, 90, 91, 91, 90,
84, 80, 81, 80, 82, 81, 81, 82, 79, 73, 73, 73, 73, 73, 73, 73, 73, 67, 64, 65,
65, 65, 65, 65, 66, 66, 66, 60, 56, 57, 57, 57, 57, 58, 58, 54, 48, 47, 48, 48,
48, 47, 49, 48, 42, 40, 40, 40, 40, 40, 39, 39, 41, 40, 35, 31, 32, 32, 32, 32,
32, 33, 29, 23, 21, 22, 22, 23, 23, 23, 22, 17, 14, 14, 14, 14, 14, 14, 14, 14,
14, 10, 6, 6, 6, 7, 7, 7, 7, 4, -1, -2, -1, -2, -1, -1, 0, -2, -6, -10, -10, -9,
-9, -9, -9, -9, -9, -10, -15, -18, -17, -21, -26, -28, -27, -27, -27, -27, -28,
-27, -27, -27, -28, -26, -28, -32, -35, -35, -35, -35, -34, -34, -34, -38, -42,
-48, -52, -52, -51, -51, -51, -51, -51, -51, -51, -51, -51, -51, -50, -51, -50,
-51, -57, -61, -61, -61, -60, -61, -60, -59, -62, -68, -73, -77, -77, -77, -76,
-76, -76, -76, -76, -76, -75, -75, -77, -77, -77, -75, -76, -81, -87, -86, -86,
-86, -86, -86, -85, -87, -93, -99, -102, -102, -101, -102, -101, -101, -102,
-102, -102, -102, -102, -102, -101, -101, -101, -102, -108, -112, -112, -111,
-111, -111, -111, -110, -114, -119, -115, -110, -111, -112, -112, -111, -111,
-111, -111, -111, -112, -111, -112, -112, -112, -111, -111, -106, -101, -101,
-101, -101, -101, -101, -102, -100, -95, -90, -86, -85, -86, -85, -86, -86, -86,
-85, -85, -86, -86, -86, -86, -85, -86, -86, -81, -78, -77, -77, -78, -78, -78,
-79, -75, -70, -63, -61, -60, -60, -61, -61, -60, -60, -61, -60, -60, -61, -61,
-61, -60, -61, -61, -57, -52, -52, -53, -53, -53, -53, -53, -51, -44, -39, -34,
-35, -34, -34, -35, -35, -35, -35, -35, -36, -35, -35, -35, -34, -35, -35, -31,
-26, -27, -28, -27, -27, -27, -28, -25, -19, -14, -9, -10, -10, -9, -10, -9,
-10, -9, -10, -10, -10, -9, -10, -9, -10, -10, -6, -1, -2, -1, -1, -2, -2, -2,
-1, };