#define DATA_LENGTH 512
#define DATA AKWF_vgsqu_0015

const PROGMEM int8_t DATA[DATA_LENGTH] = {23, 86, 103, 96, 104, 110, 110, 107,
106, 106, 107, 105, 105, 105, 105, 105, 103, 102, 102, 102, 103, 103, 102, 103,
102, 102, 103, 104, 104, 104, 103, 103, 104, 104, 104, 104, 104, 104, 103, 104,
103, 104, 103, 104, 104, 104, 104, 104, 104, 104, 103, 104, 104, 104, 103, 103,
104, 103, 104, 104, 103, 104, 103, 103, 104, 104, 104, 104, 103, 103, 104, 104,
103, 104, 104, 104, 103, 104, 103, 104, 103, 104, 103, 104, 104, 103, 104, 104,
103, 104, 104, 104, 104, 104, 105, 103, 103, 104, 103, 103, 104, 103, 103, 104,
104, 103, 103, 104, 104, 103, 104, 104, 103, 103, 104, 103, 103, 104, 104, 104,
103, 104, 104, 104, 103, 104, 104, 104, 104, 103, 103, 104, 104, 103, 104, 104,
104, 103, 103, 104, 104, 103, 103, 103, 103, 104, 104, 104, 104, 104, 103, 104,
104, 103, 104, 104, 103, 103, 104, 103, 104, 104, 104, 104, 104, 103, 104, 103,
104, 104, 104, 103, 104, 104, 103, 104, 103, 104, 103, 103, 103, 103, 104, 103,
104, 104, 103, 103, 104, 104, 103, 104, 104, 104, 103, 103, 103, 104, 104, 104,
103, 104, 104, 103, 104, 104, 103, 104, 103, 105, 103, 104, 104, 103, 103, 104,
104, 103, 104, 104, 104, 103, 104, 104, 104, 103, 104, 103, 103, 104, 105, 105,
106, 104, 103, 102, 103, 102, 103, 102, 103, 102, 102, 100, 101, 102, 106, 107,
106, 109, 107, 109, 122, 94, -48, -123, -115, -109, -94, -96, -96, -101, -101,
-101, -101, -102, -101, -103, -104, -103, -103, -103, -105, -106, -107, -106,
-107, -106, -107, -106, -105, -105, -104, -106, -105, -105, -105, -105, -105,
-105, -104, -105, -105, -104, -105, -105, -105, -106, -105, -104, -105, -105,
-104, -105, -105, -105, -105, -106, -104, -105, -104, -104, -105, -105, -105,
-105, -105, -104, -105, -104, -105, -105, -105, -104, -105, -105, -105, -106,
-105, -105, -106, -104, -106, -105, -104, -105, -105, -104, -106, -105, -106,
-106, -105, -105, -105, -105, -105, -105, -105, -106, -105, -105, -105, -106,
-105, -105, -105, -105, -105, -105, -105, -105, -105, -105, -105, -105, -105,
-105, -105, -105, -105, -105, -105, -105, -105, -105, -105, -105, -104, -105,
-105, -106, -105, -104, -105, -105, -105, -105, -105, -105, -105, -104, -105,
-105, -105, -105, -105, -104, -105, -106, -105, -106, -105, -105, -105, -104,
-105, -105, -106, -105, -105, -105, -105, -104, -105, -105, -105, -105, -105,
-106, -105, -105, -105, -104, -105, -105, -104, -105, -105, -105, -105, -105,
-105, -105, -105, -104, -104, -105, -105, -105, -105, -105, -105, -104, -105,
-105, -104, -105, -105, -105, -105, -106, -104, -106, -106, -105, -105, -105,
-106, -105, -104, -105, -105, -105, -105, -106, -104, -105, -105, -105, -105,
-105, -105, -105, -106, -105, -105, -105, -105, -105, -105, -105, -105, -104,
-103, -105, -107, -107, -106, -106, -107, -106, -106, -107, -107, -107, -107,
-107, -106, -108, -108, -109, -104, -101, -102, -99, -96, -104, -92, -27, 4, -5,
};